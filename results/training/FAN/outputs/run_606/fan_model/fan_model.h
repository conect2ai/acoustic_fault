/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.15303892e-01f, 3.64164978e-01f, -2.91997015e-01f, 5.05074561e-02f, 1.77975073e-01f, 2.75529772e-01f, 7.22041428e-01f, 1.66502401e-01f, -5.23821302e-02f, 2.28986070e-02f,
  -6.62700459e-02f, -3.47015500e-01f, -3.61802965e-01f, -2.20049232e-01f, 1.05227254e-01f, 1.95694491e-01f, 7.66929314e-02f, -2.73725331e-01f, -1.02469355e-01f, 2.65805036e-01f,
  2.39641711e-01f, 1.36361212e-01f, -1.73662484e-01f, -3.76657335e-05f, -2.93785725e-02f, -2.63115108e-01f, -8.15351829e-02f, 1.49752833e-02f, -5.66128083e-02f, -4.95079398e-01f,
  -2.84990758e-01f, 3.60260135e-03f, 3.24573852e-02f, -4.39953767e-02f, -3.01939808e-02f, -3.18772458e-02f, 1.08177913e-02f, -7.46507049e-02f, -5.73015250e-02f, -3.53462063e-02f,
  -8.90276954e-02f, 8.16118321e-04f, -4.75750454e-02f, -7.79222548e-02f, -1.22334687e-02f, -1.19852936e-02f, -1.55976508e-02f, -3.35869342e-02f, 3.29208151e-02f, 4.18441519e-02f,
  3.65008265e-02f, -3.53503749e-02f, 4.09856178e-02f, 1.69437036e-01f, 7.28231762e-03f, -7.01297000e-02f, 1.69821344e-02f, -1.93528645e-02f, -4.30862680e-02f, -5.51675372e-02f,
  -4.65168469e-02f, 1.21815791e-02f, 6.57666475e-02f, 4.74213585e-02f, -5.70434099e-03f, -7.42752627e-02f, -2.20618527e-02f, 4.18433221e-03f, -4.88744937e-02f, 4.18592766e-02f,
  1.48011744e-02f, -6.00907672e-03f, -9.13411845e-03f, -1.31224410e-03f, -7.17408136e-02f, 5.72408475e-02f, -2.51659416e-02f, 4.79045371e-03f, -1.99688226e-02f, 2.27129404e-02f,
  -3.02279685e-02f, 6.02379106e-02f, -5.45011312e-02f, 6.50754496e-02f, 3.11846659e-02f, -6.12614192e-02f, -2.59326901e-02f, 1.68609973e-02f, 7.40510353e-04f, -2.89107691e-02f,
  -9.74446442e-03f, 4.46116403e-02f, -1.87334254e-01f, 2.84239906e-03f, 2.93459762e-02f, -2.28116084e-02f, -9.88596454e-02f, -1.49984844e-03f, -5.10511473e-02f, -1.74288061e-02f,
  4.47817594e-02f, -5.92163131e-02f, -4.82390672e-02f, 8.97694454e-02f, 6.33318350e-02f, -1.30368825e-02f, 3.22862417e-02f, -7.72821903e-02f, 8.25816020e-02f, 4.17196266e-02f,
  4.13166992e-02f, 4.04540896e-02f, 5.26048895e-03f, -7.65758893e-03f, 1.08104208e-02f, -4.14415300e-02f, -1.38846308e-03f, -3.72692011e-04f, 1.86277293e-02f, 2.05175072e-01f,
  -3.65750730e-01f, 6.00473762e-01f, -3.45831245e-01f, 8.85651931e-02f, 5.14392078e-01f, 6.43582046e-02f, 3.61749798e-01f, 3.96598801e-02f, -7.36879557e-02f, 2.07139209e-01f,
  3.12322021e-01f, -4.87468019e-02f, -1.24968208e-01f, -2.33943656e-01f, -3.28379393e-01f, -1.99548863e-02f, -1.32076755e-01f, -5.34488142e-01f, -4.80552077e-01f, 1.45487022e-03f,
  2.84116387e-01f, 6.40963987e-02f, -1.99325532e-01f, -1.10453673e-01f, 2.51442134e-01f, -8.97982195e-02f, -5.51661476e-02f, 1.43902212e-01f, 7.43653029e-02f, -1.31198391e-02f,
  -1.65476486e-01f, 9.06531215e-02f, -1.28396243e-01f, -1.33251101e-02f, 4.35909927e-02f, -4.08412851e-02f, -1.84319653e-02f, 2.56666504e-02f, 6.17197454e-02f, -3.18744108e-02f,
  -1.11716492e-02f, -1.06236674e-02f, -4.70354967e-02f, 2.43549272e-02f, 1.30063221e-02f, 2.31795460e-02f, -3.72112030e-03f, -1.80109069e-01f, -1.55922532e-01f, 4.92136478e-02f,
  1.79451704e-01f, 1.33424819e-01f, -2.76136789e-02f, 6.59999847e-02f, -1.77162930e-01f, -4.01930604e-03f, 8.60599652e-02f, -1.29889697e-01f, -1.70911059e-01f, 4.12718989e-02f,
  -2.38123699e-03f, -8.89653936e-02f, -1.35125360e-03f, 5.46469800e-02f, 1.37409586e-02f, 6.16851449e-02f, -3.49717326e-02f, 5.18867634e-02f, -1.11337036e-01f, -4.01929114e-03f,
  8.59297514e-02f, 7.77131552e-03f, -5.93765825e-03f, 3.84387262e-02f, -3.41134742e-02f, -2.55419053e-02f, -7.31594744e-04f, 2.75482517e-02f, 3.44403498e-02f, -3.28012072e-02f,
  4.86425241e-04f, -2.11241506e-02f, 8.46834779e-02f, -2.36592852e-02f, 1.11995973e-01f, -6.47425205e-02f, -5.01086041e-02f, 5.58799282e-02f, -4.53333706e-02f, 6.58818483e-02f,
  1.32089764e-01f, -4.06434610e-02f, 4.19958718e-02f, -6.94146454e-02f, 2.60342099e-02f, 1.27637647e-02f, 7.74746761e-02f, 2.21950617e-02f, 4.97747064e-02f, 4.53714607e-03f,
  1.17420517e-02f, -3.37640569e-02f, -3.50078358e-03f, -3.56368721e-02f, -4.57966402e-02f, 1.50859598e-02f, 6.28452078e-02f, 5.41505665e-02f, -3.98405716e-02f, 1.00987971e-01f,
  5.93604594e-02f, 9.53261333e-04f, -9.18599591e-03f, -3.13763060e-02f, 8.50666463e-02f, -5.59827387e-02f, 7.33706430e-02f, -3.13875079e-02f, -8.58038440e-02f, 1.23073235e-01f,
  -3.02691776e-02f, 3.51519585e-01f, 2.98032872e-02f, -3.00778925e-01f, 1.94921106e-01f, -4.01022565e-03f, 3.89182866e-01f, -3.03531811e-02f, -2.72685617e-01f, 1.62931934e-01f,
  -5.86266443e-02f, -2.34638318e-01f, -1.23652875e-01f, -9.81665850e-02f, -9.16833133e-02f, 7.18753338e-02f, 1.19513057e-01f, -2.19850659e-01f, -3.42880219e-01f, -1.39138624e-01f,
  -6.84769824e-02f, -1.39019608e-01f, -3.45724493e-01f, -3.33854496e-01f, 2.39377603e-01f, -3.95065136e-02f, 1.22228138e-01f, 7.31771216e-02f, 1.48137391e-01f, 4.78793532e-01f,
  1.37758121e-01f, 1.49416357e-01f, -1.23717532e-01f, -2.40932666e-02f, 4.38814536e-02f, -3.38229979e-03f, 1.22582637e-01f, 1.08672500e-01f, 4.45600180e-03f, 3.50085180e-03f,
  -1.87229933e-04f, -5.90873733e-02f, 1.79225262e-02f, -2.77792886e-02f, 2.31940076e-02f, -2.22095847e-02f, -5.40431440e-02f, -7.16790855e-02f, -5.53461574e-02f, 7.89227039e-02f,
  -3.53717953e-02f, 2.74290480e-02f, 1.05019242e-01f, -1.06836140e-01f, 2.85718832e-02f, -1.28088787e-01f, 5.09293191e-02f, 1.10838443e-01f, -4.64705825e-02f, 1.78179130e-01f,
  4.73089404e-02f, -3.07373386e-02f, -1.75127927e-02f, -1.12122037e-02f, 2.13017594e-02f, -4.79143448e-02f, 1.47564514e-02f, -3.94540560e-03f, -1.53385606e-02f, -4.86877039e-02f,
  -2.12995280e-02f, 4.15570624e-02f, -5.03237434e-02f, 6.50280863e-02f, -1.24834683e-02f, -3.58445831e-02f, 3.51704955e-02f, -3.73826316e-03f, -4.82498482e-02f, 1.70204584e-02f,
  9.65920929e-03f, -2.51553059e-02f, -3.70012671e-02f, 8.39010775e-02f, -7.24701071e-03f, 5.22205345e-02f, 2.82918010e-02f, -7.81532284e-03f, -3.81642468e-02f, -2.28028540e-02f,
  -4.66724560e-02f, -9.69325751e-02f, 5.04116975e-02f, 4.54713069e-02f, -6.57940796e-03f, -2.45187487e-02f, 2.94468403e-02f, -2.40728613e-02f, 2.43738908e-02f, -4.68491465e-02f,
  -1.39151756e-02f, 4.80951555e-03f, 4.12793085e-02f, -6.31052442e-03f, -3.19087841e-02f, 2.38743909e-02f, 4.05888073e-03f, 4.90370914e-02f, -4.26407196e-02f, 8.68912339e-02f,
  -2.96697486e-02f, -3.36806402e-02f, 4.36236449e-02f, -9.81177390e-03f, -7.88604375e-03f, -8.95605423e-03f, 1.33204013e-01f, 1.68589074e-02f, 1.20662991e-02f, 1.63723290e-01f,
  3.26769233e-01f, -2.28073254e-01f, -3.59647840e-01f, 4.44022655e-01f, -1.66206762e-01f, -7.38989376e-03f, -2.10670754e-01f, 3.18337023e-01f, 3.94426227e-01f, -1.53626606e-01f,
  -1.28658012e-01f, 5.61521612e-02f, -4.40717712e-02f, 7.04043508e-02f, 9.48842168e-02f, -1.75916895e-01f, -1.82979837e-01f, -2.41099834e-01f, 1.18569195e-01f, 1.25266925e-01f,
  9.00987834e-02f, 7.76549801e-02f, 7.04132691e-02f, 2.30147049e-01f, 8.73576254e-02f, 2.29694143e-01f, -1.14520356e-01f, -8.08284432e-02f, -1.46362215e-01f, -4.59467351e-01f,
  -5.22665381e-01f, 2.00378839e-02f, 3.98963988e-02f, -4.05685380e-02f, -6.10411391e-02f, 8.20308179e-03f, 1.13369795e-02f, -3.12014632e-02f, 9.04359072e-02f, 7.57811964e-02f,
  -1.23810917e-02f, -1.60951260e-02f, 2.52254754e-02f, 2.62348875e-02f, -5.88334426e-02f, -1.15512172e-02f, 2.49315724e-02f, 7.54861981e-02f, -7.60674290e-03f, -8.61499533e-02f,
  -5.45807406e-02f, -1.96222082e-01f, -2.81829000e-01f, 8.60449970e-02f, 1.08371213e-01f, -4.69231606e-03f, 4.27652374e-02f, 1.06122278e-01f, -9.07969382e-03f, 4.41625081e-02f,
  7.11982995e-02f, -1.27112210e-01f, -3.90414111e-02f, 1.89775936e-02f, 3.62620354e-02f, 6.18480220e-02f, -6.05548769e-02f, -2.55212523e-02f, 6.81274906e-02f, -1.39772715e-02f,
  -7.72142261e-02f, 8.11003483e-05f, 2.50605028e-03f, 3.57485376e-03f, 1.19075812e-02f, -1.16869509e-01f, -2.89022792e-02f, -5.01320288e-02f, -6.36222884e-02f, -7.29144886e-02f,
  -5.07267267e-02f, 1.94954183e-02f, -9.82983708e-02f, 8.81237984e-02f, -9.10108238e-02f, -8.45782273e-03f, 4.26220037e-02f, -6.34712577e-02f, 5.49982712e-02f, 6.68130219e-02f,
  2.52099484e-01f, -7.71410465e-02f, -2.45304275e-02f, 7.07202926e-02f, -2.50290483e-02f, -3.64930145e-02f, -5.40565476e-02f, 2.86518261e-02f, 4.31076512e-02f, 7.12091178e-02f,
  3.50998975e-02f, 6.39178231e-02f, -1.32929357e-02f, 1.80542339e-02f, 8.10590908e-02f, 1.18313365e-01f, 1.61135197e-02f, 7.51122609e-02f, -1.33757880e-02f, 4.33209166e-03f,
  8.63601714e-02f, 5.81984371e-02f, -6.05794862e-02f, 7.44061992e-02f, 1.48513317e-02f, 1.41286403e-02f, -1.04206717e-02f, 5.80001697e-02f, 1.47324977e-02f, 1.79913402e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.85910839e-02f, 2.10227102e-01f, -5.02165318e-01f, -1.27057210e-02f, -5.33580303e-01f, -4.01650041e-01f, -1.76281538e-02f, 1.80659503e-01f, 1.59038186e-01f, -1.08041085e-01f,
  1.24844931e-01f, 3.99072617e-01f, 4.53705579e-01f, -1.40944896e-02f, -9.89375189e-02f, -2.55370528e-01f, -5.16727149e-01f, -3.24928135e-01f, 6.23104945e-02f, -1.68934688e-01f,
  9.94470716e-03f, 2.04765812e-01f, 1.36847213e-01f, 1.09569371e-01f, 2.44243592e-01f, 1.74963728e-01f, -1.38895214e-01f, -1.40751183e-01f, -2.64194548e-01f, -6.12093925e-01f,
  4.68147099e-01f, -3.52088541e-01f, -4.38449055e-01f, -1.75987631e-01f, 2.49427371e-02f, 3.19616683e-02f, 1.14848554e-01f, -2.46780619e-01f, -6.61263168e-02f, -9.19847712e-02f,
  1.23604596e-01f, -8.69150236e-02f, -4.37683724e-02f, 2.14915927e-02f, 9.30649489e-02f, 2.28802692e-02f, -2.07380056e-02f, -2.57202834e-01f, -1.57334387e-01f, 2.76337937e-02f,
  6.75922707e-02f, -2.99106896e-01f, -2.44616643e-02f, -1.88481346e-01f, -2.12881908e-01f, -2.28841767e-01f, -8.63671452e-02f, -1.43470600e-01f, -4.47930187e-01f, 3.90722305e-02f,
  2.98956875e-02f, 6.53136671e-02f, -8.50106031e-02f, 1.21917412e-01f, 7.80280977e-02f, 9.25434008e-02f, 2.57632006e-02f, 5.15745347e-03f, 1.04188278e-01f, 1.68958694e-01f,
  8.27532336e-02f, 8.75419658e-03f, -1.84768736e-02f, 1.01857156e-01f, 5.77288866e-03f, -8.65509436e-02f, -5.88370524e-02f, 7.51455501e-02f, -8.40478167e-02f, 6.38756063e-03f,
  8.68283387e-04f, -1.62278801e-01f, -1.10016853e-01f, 1.82904815e-03f, -2.20541373e-01f, -1.21844590e-01f, -5.30913845e-02f, 1.38818612e-02f, 6.97563440e-02f, -1.88943610e-01f,
  8.24765980e-01f, -7.49730408e-01f, 3.86287421e-01f, 3.97339575e-02f, -1.37602046e-01f, -9.85462964e-02f, 2.71431021e-02f, -2.39698678e-01f, 2.50259396e-02f, 5.96349873e-02f,
  -2.42444098e-01f, 6.30591810e-02f, 1.59104645e-01f, -1.03101194e-01f, 3.20180207e-02f, -8.79018679e-02f, -1.45961000e-02f, -1.70556139e-02f, -2.99641974e-02f, -8.47921520e-03f,
  -7.19789937e-02f, -1.22681811e-01f, 3.69504362e-01f, -7.16693550e-02f, 2.04573885e-01f, 1.75531536e-01f, 3.71549040e-01f, 2.58765340e-01f, 1.15155401e-02f, 5.49910009e-01f,
  -6.32902741e-01f, 1.27509832e-01f, -8.29317570e-01f, -3.32682610e-01f, 3.60652626e-01f, 1.77764401e-01f, 1.06143624e-01f, -1.55922458e-01f, 3.06359828e-02f, 7.73587152e-02f,
  4.02473778e-01f, 3.03556174e-01f, -2.27115806e-02f, 3.06066185e-01f, 4.35570516e-02f, 1.41499475e-01f, 1.90926090e-01f, -3.61260504e-01f, -2.69509137e-01f, 5.46188772e-01f,
  6.61127806e-01f, -1.19846165e-01f, -5.02000988e-01f, 3.38316150e-02f, -8.15926213e-03f, -3.31135001e-03f, -3.11017454e-01f, -6.54972857e-04f, 1.64642587e-01f, 1.05028003e-02f,
  3.75221409e-02f, -2.91675180e-01f, 5.63021302e-02f, 8.21021572e-02f, -1.02091782e-01f, -1.07223399e-01f, -4.68400493e-02f, -1.81263193e-01f, -4.85470854e-02f, 5.46271773e-03f,
  5.61194401e-03f, 6.72614127e-02f, 5.42910397e-02f, 9.25212651e-02f, -2.44645532e-02f, -1.37266815e-01f, -4.26901907e-01f, -3.05621028e-01f, -4.28575605e-01f, -2.21924037e-01f,
  3.59689176e-01f, 1.54909343e-01f, -3.71737391e-01f, 6.37231991e-02f, -2.49643609e-01f, -4.71804403e-02f, -1.36141941e-01f, -1.36743963e-01f, -2.69686073e-01f, -3.89671236e-01f,
  5.18276170e-02f, -4.16126056e-03f, 9.05136541e-02f, -1.50516005e-02f, 4.92279939e-02f, -1.41524430e-02f, 7.79142231e-02f, 3.62407267e-02f, 2.06180438e-01f, -1.98662996e-01f,
  5.30550815e-02f, 4.49288674e-02f, -1.20879635e-02f, -9.87441987e-02f, 1.56463012e-02f, 9.12502501e-03f, -4.71171545e-04f, 4.84222546e-03f, 1.10884443e-01f, -6.84352368e-02f,
  -3.36676054e-02f, -4.99040373e-02f, -1.60973221e-01f, -6.10668100e-02f, 3.34735215e-02f, -5.61880358e-02f, 5.91877699e-02f, 5.45481183e-02f, -1.18298501e-01f, -1.20589249e-01f,
  -1.48321748e-01f, 1.24797203e-01f, -1.95023090e-01f, 3.14637423e-02f, 4.23299801e-03f, -4.52219956e-02f, 6.91680834e-02f, -2.95442510e-02f, -8.23131502e-02f, -1.43359527e-01f,
  2.11003069e-02f, -1.92183480e-02f, -9.49156005e-03f, 7.13404790e-02f, 4.79210354e-03f, 2.18533184e-02f, 6.35578036e-02f, -7.04352260e-02f, 8.59818906e-02f, 5.98584581e-03f,
  -5.10989539e-02f, -1.19966790e-01f, -1.17019378e-01f, -1.68833479e-01f, 1.95650663e-02f, -2.14912761e-02f, -6.86217248e-02f, -2.40160480e-01f, -2.80695468e-01f, -4.45553541e-01f,
  -4.38747033e-02f, 8.02412406e-02f, 3.54961693e-01f, 5.49870253e-01f, 1.71247870e-01f, 2.03484654e-01f, -3.79287265e-02f, 1.68519855e-01f, 1.45461813e-01f, 2.01173816e-02f,
  1.18557245e-01f, 3.55641186e-01f, 3.14164311e-01f, 2.52105892e-01f, 1.61624625e-01f, 1.63497150e-01f, 3.84168446e-01f, 2.69347668e-01f, 8.57215971e-02f, 1.68923572e-01f,
  3.72802168e-01f, -6.12709187e-02f, -4.57748882e-02f, 1.24982469e-01f, 6.29939437e-02f, 3.55210572e-01f, 1.98188767e-01f, -1.30418418e-02f, 2.23997631e-03f, 3.11937600e-01f,
  -2.69863278e-01f, -1.23221859e-01f, 1.36265367e-01f, -2.64644157e-02f, -1.27575189e-01f, -7.11535588e-02f, 7.56730810e-02f, -1.77770808e-01f, -1.80947125e-01f, -1.51176855e-01f,
  -1.36956414e-02f, -4.98420149e-02f, -6.67699203e-02f, -5.55876940e-02f, -1.25669390e-01f, -1.79462507e-01f, -3.76206450e-02f, 5.98381162e-02f, 1.44573867e-01f, -6.30617961e-02f,
  1.49520040e-01f, -3.35700512e-02f, -1.14957117e-01f, 1.55953512e-01f, 5.86036406e-02f, 3.17070112e-02f, -9.14093014e-03f, -6.19858578e-02f, 1.41088581e-02f, 3.77334952e-02f,
  6.83460245e-03f, 4.32168087e-03f, 1.21114422e-02f, -5.70088513e-02f, -2.03159638e-03f, 4.32962738e-02f, -5.18444972e-03f, 7.29415715e-02f, 1.54023722e-01f, -6.10309802e-02f,
  2.38365848e-02f, 6.13606349e-02f, 6.11196980e-02f, 8.51198211e-02f, 1.10999949e-01f, -3.64883542e-02f, -9.83817056e-02f, -3.63109596e-02f, 1.47061450e-02f, -4.89640795e-02f,
  -4.34756912e-02f, -2.18301695e-02f, 9.41002741e-02f, 6.10811543e-03f, -5.06151542e-02f, 8.44553709e-02f, 9.74399075e-02f, -9.07500759e-02f, -7.11036921e-02f, -6.03827424e-02f,
  1.14104569e-01f, 3.15880656e-01f, 6.17874451e-02f, -1.11523177e-02f, -3.34871635e-02f, -1.60532847e-01f, 1.83981553e-01f, -1.12293594e-01f, -2.02827483e-01f, 1.03757896e-01f,
  -1.06340796e-01f, -3.92616279e-02f, 4.69907336e-02f, -5.31236120e-02f, 5.16905542e-03f, -8.39092061e-02f, -1.89136155e-03f, 1.27424240e-01f, 3.47307883e-02f, -6.35097772e-02f,
  1.02557279e-01f, 3.83334756e-02f, -1.66971087e-01f, 1.36909382e-02f, 5.10572344e-02f, -5.31113930e-02f, -1.56964689e-01f, -1.75105393e-01f, -3.76583040e-02f, -1.67930245e-01f,
  -2.15938449e-01f, -1.29748240e-01f, -3.91514182e-01f, 1.31297573e-01f, -1.21943094e-01f, -2.70057380e-01f, -6.90280974e-01f, 1.21287622e-01f, 5.08686960e-01f, -4.94450033e-01f,
  -3.22913438e-01f, -2.22704969e-02f, -3.12740684e-01f, -4.98840630e-01f, -9.75419998e-01f, -8.84331465e-01f, -6.15923345e-01f, -7.03659654e-01f, -6.91138744e-01f, -6.41667396e-02f,
  -3.86260509e-01f, -3.05924565e-01f, -2.92721480e-01f, -1.31443679e-01f, 1.44548461e-01f, -8.55307430e-02f, -2.38769408e-02f, 2.34621949e-02f, -1.60020411e-01f, -2.33900100e-01f,
  -5.27531683e-01f, 4.04256493e-01f, 3.79953086e-02f, 6.16238341e-02f, 1.90102663e-02f, 6.83809072e-02f, -6.53034896e-02f, 1.03131957e-01f, 1.37282044e-01f, -1.21312946e-01f,
  1.13735303e-01f, -5.77747710e-02f, -8.39927979e-03f, 1.01400809e-02f, -5.90176228e-03f, -1.25570998e-01f, 1.68735012e-01f, -1.01634130e-01f, 1.33976862e-02f, 2.42462561e-01f,
  -4.86900657e-03f, -1.54190451e-01f, 1.00626200e-02f, 3.06318738e-02f, 2.18897671e-01f, -3.92032266e-02f, 1.37402505e-01f, 2.12117836e-01f, -1.53357517e-02f, 1.53341806e-02f,
  -1.08927459e-01f, 1.65957548e-02f, -2.29596179e-02f, -7.05265105e-02f, -1.96050238e-02f, 6.15922213e-02f, -5.61292879e-02f, -5.53826317e-02f, 8.25516600e-03f, -7.73403272e-02f,
  9.77478996e-02f, -6.57137111e-02f, 1.15155339e-01f, 8.57588183e-03f, -1.59063175e-01f, -1.43560139e-03f, -1.17730372e-01f, -9.51535031e-02f, 3.67920175e-02f, 7.11793751e-02f,
  -9.48260725e-02f, 1.54028326e-01f, 1.02645658e-01f, 5.31349815e-02f, -5.47270998e-02f, 1.44842386e-01f, 8.71292576e-02f, -3.21986564e-02f, 1.15961738e-01f, -3.31022479e-02f,
  1.49147362e-02f, -1.94229424e-01f, -1.36969872e-02f, 1.49783725e-02f, 2.42551919e-02f, 1.24062546e-01f, -1.31621305e-02f, -7.21808299e-02f, 1.06677987e-01f, 4.94523235e-02f,
  1.21858396e-01f, 2.17339508e-02f, -2.36507822e-02f, 2.94296984e-02f, 6.57091066e-02f, -4.22289707e-02f, -8.64125788e-02f, -2.18898565e-01f, 1.27734626e-02f, 2.41524741e-01f,
  -4.76592742e-02f, -2.02997163e-01f, -1.25012010e-01f, -5.53401560e-02f, 1.72678500e-01f, -2.76263803e-01f, -2.62695581e-01f, 1.31595895e-01f, -3.06194425e-01f, -2.46550795e-02f,
  1.40427184e+00f, -3.91986609e-01f, -9.34803486e-01f, 2.36337066e-01f, -4.01875287e-01f, -2.42437143e-02f, 4.08562347e-02f, 9.89692137e-02f, 1.11896157e-01f, -1.77818075e-01f,
  2.68701501e-02f, 3.19901109e-01f, 3.23146507e-02f, 1.60360560e-02f, 3.07715029e-01f, -3.52015913e-01f, -3.25631678e-01f, 7.82998502e-02f, 3.29794139e-01f, 1.37622759e-01f,
  3.05969473e-02f, 8.80207345e-02f, 2.97218055e-01f, 2.52489328e-01f, -3.44194531e-01f, 6.95561916e-02f, -5.49257815e-01f, -2.03422979e-01f, -1.08618937e-01f, -6.91265106e-01f,
  -3.04108828e-01f, -2.49030918e-01f, 1.83433928e-02f, 1.31187469e-01f, -1.89588830e-01f, 1.51348695e-01f, 4.05583233e-02f, 1.87034020e-03f, 4.45589982e-02f, -7.95584172e-02f,
  -8.54385942e-02f, -1.98388454e-02f, -3.54869515e-02f, 2.92436220e-02f, -4.67989556e-02f, 3.02075390e-02f, -8.79772156e-02f, 2.25860793e-02f, -9.51894522e-02f, -1.83101326e-01f,
  -1.43147454e-01f, 3.80720739e-04f, -9.54691842e-02f, -1.06586963e-01f, -9.89879221e-02f, -6.21159822e-02f, -2.42794812e-01f, -1.25889689e-01f, -1.77413300e-01f, -1.31884173e-01f,
  -5.31768799e-02f, -7.78243914e-02f, 2.54488494e-02f, 6.62222952e-02f, 3.47980447e-02f, -1.63664669e-02f, -1.61840022e-02f, 9.40251574e-02f, 8.99462253e-02f, -9.48212370e-02f,
  -2.47109011e-02f, 5.80510497e-02f, -1.77326314e-02f, -1.67923383e-02f, -5.20302132e-02f, 2.27758754e-02f, -6.22077659e-02f, 4.59618047e-02f, 7.36188740e-02f, 9.81022790e-02f,
  1.75420016e-01f, -2.11455077e-02f, -9.30210203e-02f, -2.40517445e-02f, -3.90747190e-02f, -1.18977092e-02f, -1.83371827e-02f, 4.97441515e-02f, 1.01282977e-01f, 2.06649881e-02f,
  1.61245525e-01f, 1.04954548e-01f, 2.00939737e-02f, 4.78970036e-02f, 4.42036875e-02f, -7.12391629e-04f, -4.48390357e-02f, -3.24045084e-02f, 4.85879667e-02f, -1.75433457e-02f,
  -2.87255775e-02f, 6.69140741e-02f, -1.10889420e-01f, -1.04665998e-02f, 5.78016117e-02f, 6.73193112e-02f, 1.57567546e-01f, 1.38214380e-01f, 2.89888922e-02f, -1.24219231e-01f,
  -1.10312300e-02f, 2.34800637e-01f, 3.24247926e-01f, 1.43494204e-01f, -8.26852303e-03f, 1.19641505e-01f, 8.16975832e-02f, -8.32174718e-02f, 2.00894445e-01f, 3.08781713e-01f,
  4.58233207e-01f, 6.99146450e-01f, -2.50961721e-01f, 2.91919351e-01f, 4.52229351e-01f, 8.67656432e-03f, 1.84861645e-01f, -1.77193135e-01f, -7.28679746e-02f, 1.19914882e-01f,
  1.32423595e-01f, 6.43816069e-02f, -2.00336710e-01f, -1.43957570e-01f, -1.29688844e-01f, 1.33322668e-03f, 2.70111293e-01f, 1.16303302e-01f, -2.76931494e-01f, -1.34271209e-03f,
  2.24129274e-01f, 3.06734204e-01f, 9.78905931e-02f, -1.25936761e-01f, 3.77941072e-01f, -2.85177559e-01f, -1.71015337e-01f, 4.15553004e-01f, 1.09452799e-01f, 6.29693449e-01f,
  8.29377621e-02f, 4.81776983e-01f, -6.01049185e-01f, 7.22655505e-02f, 2.36459076e-01f, -5.55089973e-02f, -1.34376496e-01f, 3.22014689e-02f, -1.38791688e-02f, -1.57956839e-01f,
  1.71484381e-01f, 1.00200132e-01f, 4.07589942e-01f, 7.70511702e-02f, 1.48688301e-01f, 1.93660837e-02f, 4.24521826e-02f, -5.05085848e-02f, -1.96338937e-01f, -1.29599705e-01f,
  2.26821035e-01f, 2.26462096e-01f, 1.15758507e-02f, -3.40748280e-01f, -5.69869801e-02f, 1.70978475e-02f, -1.56912729e-01f, 6.21580053e-03f, -4.07095820e-01f, 5.90885431e-02f,
  -3.23595732e-01f, -8.62069149e-03f, 1.47206977e-01f, 1.26664594e-01f, 5.47413751e-02f, 4.11313139e-02f, 6.14075214e-02f, 1.35499284e-01f, 1.23694234e-01f, 1.19401075e-01f,
  -2.08148941e-01f, -7.31011853e-02f, -5.85225523e-02f, -1.52586907e-01f, -2.32900321e-01f, 2.01141030e-01f, -1.47359714e-01f, 8.65087956e-02f, -1.13416500e-01f, 2.94606164e-02f,
  1.83969393e-01f, 2.84272805e-02f, -1.42211422e-01f, -1.24774285e-01f, -2.20883545e-02f, 5.75372502e-02f, -8.84665176e-02f, -1.24204509e-01f, -3.45717520e-02f, 4.44536023e-02f,
  -4.48616445e-01f, -5.89405894e-01f, -1.66061953e-01f, 1.24030076e-01f, -1.96827203e-02f, 7.06815347e-02f, 4.47018221e-02f, -7.04523399e-02f, 9.35902819e-02f, 3.35701555e-02f,
  3.19466926e-02f, -1.69622511e-01f, 6.70000352e-03f, -1.23517312e-01f, -7.44087063e-03f, -1.11460581e-01f, 2.22227216e-01f, 1.07192481e-02f, -1.63989782e-01f, 5.51215038e-02f,
  -1.15175709e-01f, -1.33702099e-01f, -2.77858168e-01f, -1.45330250e-01f, -7.05250800e-02f, -5.54460764e-01f, -2.29625702e-01f, -2.00841755e-01f, -5.10908663e-01f, -3.69978726e-01f,
  3.83061469e-01f, -1.87976912e-01f, 8.67376924e-02f, 3.66897702e-01f, 4.74904031e-01f, 4.15243447e-01f, 4.73654091e-01f, 1.72128379e-01f, 2.13995337e-01f, 1.49321616e-01f,
  -6.01043217e-02f, 2.54357122e-02f, -1.99733512e-03f, 1.23824263e-02f, -5.26255257e-02f, 8.93720388e-02f, 1.87466815e-01f, -1.39593631e-01f, 1.83218811e-02f, 1.38988823e-01f,
  -7.25799501e-02f, 1.49000669e-02f, -8.59698653e-02f, -2.36703027e-02f, -2.51984298e-02f, 1.51994944e-01f, 1.06890097e-01f, -1.29292756e-01f, -1.69224426e-01f, -1.96349367e-01f,
  -4.30569530e-01f, -2.61448950e-01f, 1.93802211e-02f, 7.22266287e-02f, -1.75712004e-01f, -5.47086075e-02f, -3.50446906e-03f, -3.46009769e-02f, 5.10397404e-02f, 9.08182375e-03f,
  -3.77108976e-02f, -5.10773398e-02f, 6.26539141e-02f, 8.28235000e-02f, 1.22019909e-01f, 5.03587872e-02f, -4.06681709e-02f, 7.25275427e-02f, 1.57847688e-01f, -7.14817122e-02f,
  1.46259638e-02f, 3.29859480e-02f, 1.62541449e-01f, 2.31087193e-01f, 5.82932606e-02f, 5.35669327e-02f, -8.82715732e-02f, 3.48515995e-02f, -4.46857773e-02f, 6.32922724e-02f,
  -4.70897295e-02f, 2.55499840e-01f, 4.65397984e-02f, -1.00766636e-01f, -4.11342531e-02f, 9.94164497e-02f, -2.17790827e-02f, 2.82312874e-02f, 1.71842441e-01f, 3.42104584e-02f,
  1.29736364e-01f, 2.17428245e-02f, 8.03643763e-02f, -3.08089275e-02f, -5.51836267e-02f, 2.99914684e-02f, 6.44919500e-02f, -2.01061308e-01f, -1.52785301e-01f, -6.13149144e-02f,
  -4.25901078e-03f, -9.85352471e-02f, -1.75815225e-01f, -2.64522165e-01f, -8.67168903e-02f, -1.36041865e-01f, -1.05391145e-01f, -3.05328984e-02f, 1.02773108e-01f, -6.59762789e-03f,
  3.03339303e-01f, 2.33989786e-02f, -7.29039237e-02f, 1.01471268e-01f, 3.72525714e-02f, -1.03647240e-01f, 3.96942943e-02f, -1.85833439e-01f, -7.36369714e-02f, -2.13402975e-02f,
  -2.78108902e-02f, -6.06278442e-02f, 2.74990033e-02f, 1.55323441e-03f, 1.19536258e-01f, 4.68755960e-02f, 7.92877749e-02f, 1.22057013e-01f, 1.75684728e-02f, -4.90990467e-02f,
  -4.86683846e-02f, 3.49591196e-01f, 2.42658332e-01f, 1.10099211e-01f, 4.45295870e-03f, 1.24348745e-01f, -6.79624304e-02f, -9.27809626e-02f, -8.57680757e-03f, 1.83304027e-01f,
  1.00671327e+00f, -3.80176216e-01f, 6.26820505e-01f, 2.25680828e-01f, 3.73377800e-01f, 6.33573532e-01f, 6.34906352e-01f, 3.31454605e-01f, 1.28672421e-01f, 2.44830519e-01f,
  -2.91898549e-01f, -5.10237038e-01f, -4.36732918e-01f, -3.09219897e-01f, -1.12547260e-02f, 2.61231482e-01f, 2.89974511e-01f, 1.98217854e-01f, 3.76374125e-01f, 3.64341319e-01f,
  -1.64250538e-01f, 1.50802195e-01f, 1.06911138e-01f, -1.93371251e-02f, 1.26640379e-01f, -7.50397667e-02f, 1.31312117e-01f, -3.08351219e-02f, -1.82016373e-01f, -1.37760490e-01f,
  6.06493279e-02f, 2.62113184e-01f, -9.73307043e-02f, -2.72596478e-01f, -1.99808419e-01f, 1.65084768e-02f, 2.20181458e-02f, -1.98743030e-01f, -1.63523734e-01f, 4.72259484e-02f,
  -1.31401196e-01f, -4.20000516e-02f, -1.49810929e-02f, 4.87855524e-02f, 2.07552448e-01f, 9.40783694e-02f, 1.83386747e-02f, 2.06681546e-02f, 4.08012383e-02f, -1.39941387e-02f,
  -2.45027915e-01f, -8.49016104e-03f, 7.57567063e-02f, 9.08489078e-02f, 6.68606162e-02f, -1.41458467e-01f, -6.25225231e-02f, -5.73217906e-02f, -2.62344219e-02f, 7.59380031e-03f,
  -1.55162625e-02f, 2.99038511e-04f, 9.58862947e-05f, 7.71484673e-02f, -2.48810686e-02f, 7.08378106e-02f, 3.70202959e-02f, -4.19924967e-02f, 4.50072289e-02f, 3.54810543e-02f,
  -1.34610832e-01f, 7.22368136e-02f, -1.28883095e-02f, 4.51512337e-02f, -3.46115381e-02f, 1.47401348e-01f, 1.10563293e-01f, -1.33841127e-01f, -1.13248229e-02f, -1.36766462e-02f,
  3.41108581e-03f, 5.78876399e-02f, 2.28389278e-02f, -1.23650627e-03f, -3.64316218e-02f, -8.81449655e-02f, 8.84553492e-02f, 1.29293287e-02f, -7.14984536e-02f, -7.68944919e-02f,
  -3.70920569e-01f, -1.18544281e-01f, 9.31962430e-02f, -1.73313931e-01f, 5.62318750e-02f, -1.96486875e-01f, 8.52260888e-02f, -1.15229681e-01f, -1.85151115e-01f, -1.72976982e-02f,
  -5.61867803e-02f, -8.71455297e-02f, 4.26382273e-02f, -2.92563755e-02f, 6.20899908e-03f, -1.59786996e-02f, -1.35496274e-01f, -1.44123599e-01f, -1.38636306e-01f, -9.96484384e-02f,
  -3.74506414e-02f, 9.31557193e-02f, 6.06892109e-02f, 3.13841854e-03f, -1.52535543e-01f, -8.47391561e-02f, 8.61097649e-02f, -4.60748980e-03f, 1.18251532e-01f, 6.91868141e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.94972122e-01f, 2.93058455e-01f, 8.26638713e-02f, 5.19456267e-01f, 2.28025764e-01f, 5.23919642e-01f, 1.81749195e-01f, 5.06616592e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.81981295e-01f, 1.38579592e-01f, 3.05504967e-02f, 1.44566894e-01f, 7.33715236e-01f, 5.74408233e-01f, 6.95064710e-03f, 2.51536310e-01f, 5.16422912e-02f, 3.94664913e-01f,
  -5.92761822e-02f, 8.75213146e-02f, -1.36001900e-01f, 3.05531651e-01f, 8.90977308e-02f, -2.18368918e-01f, 1.35179624e-01f, 3.40054221e-02f, 2.24601254e-01f, 2.07915261e-01f,
  1.90118000e-01f, -5.18870533e-01f, 7.09830150e-02f, -3.18382204e-01f, -1.15026750e-01f, 3.45629342e-02f, 1.97891861e-01f, -3.55742484e-01f, 5.17318904e-01f, 1.04736187e-01f,
  6.91170320e-02f, 1.48007479e-02f, 3.47478427e-02f, 5.55203743e-02f, 8.38246755e-03f, -1.79366425e-01f, 1.93288222e-01f, 3.94003600e-01f, -8.29819590e-02f, 1.59343570e-01f,
  -1.42305955e-01f, 2.58007884e-01f, 3.09948802e-01f, 2.27391005e-01f, 4.22242373e-01f, -1.62018999e-01f, -9.20681059e-02f, -3.88058811e-01f, -1.33880645e-01f, -1.37367696e-02f,
  1.64682612e-01f, 1.42768756e-01f, 1.99324504e-01f, -2.20082551e-02f, 3.67219150e-01f, -5.01348749e-02f, -2.41446808e-01f, 3.16597931e-02f, -8.49370509e-02f, -2.43922710e-01f,
  -1.31199464e-01f, 2.23758668e-01f, -1.35909364e-01f, 1.37665361e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.05937123e-01f, -9.38485935e-02f, 4.40511823e-01f, 5.74990869e-01f, -1.24098134e+00f, -5.23570359e-01f, -2.84400761e-01f, 2.98022538e-01f, 6.91731632e-01f, -5.48467278e-01f,
  3.34570944e-01f, 2.30227157e-01f, 1.80044636e-01f, 3.34225267e-01f, -6.33091569e-01f, 3.09366044e-02f, 4.70779061e-01f, 5.02197266e-01f, 5.16246617e-01f, -2.30081901e-01f,
  7.65275896e-01f, 8.17131698e-01f, 7.98280723e-03f, 3.50211114e-01f, 6.98386192e-01f, 6.37229085e-01f, 1.87195703e-01f, 3.91692758e-01f, 8.22784066e-01f, -2.62376785e-01f,
  -2.31351316e-01f, 7.54655302e-01f, 5.87966703e-02f, -4.49524745e-02f, 2.49590218e-01f, 4.24251527e-01f, 2.81082362e-01f, -5.83795071e-01f, 2.50837535e-01f, 4.99799699e-01f,
  -9.62217972e-02f, -1.68870687e-01f, 4.39607203e-01f, 1.56200483e-01f, 7.84138262e-01f, 4.19798523e-01f, 2.84020692e-01f, 8.86188924e-01f, 3.35926145e-01f, 7.16138422e-01f,
  4.76154178e-01f, 4.17503208e-01f, 2.69069642e-01f, 2.24655084e-02f, 4.15125161e-01f, -2.53139585e-01f, 6.93827510e-01f, -6.52726889e-01f, -3.23895514e-01f, -3.78750145e-01f,
  6.81584105e-02f, 3.91698182e-01f, -1.24041982e-01f, 9.79053438e-01f, 2.23828375e-01f, -1.20271794e-01f, -2.81814873e-01f, 1.21935815e-01f, -3.24394643e-01f, -5.17465472e-01f,
  -2.70518750e-01f, 1.42173350e-01f, -1.10696703e-01f, 4.51743394e-01f, -2.38674402e-01f, 6.28487051e-01f, -7.51431465e-01f, -1.98627964e-01f, 1.19758599e-01f, 4.90598567e-02f,
  8.20744336e-02f, 4.96896714e-01f, 1.49242386e-01f, 9.23835933e-02f, 6.05342269e-01f, 1.14718676e+00f, 2.79822469e-01f, -7.14133754e-02f, 6.50878727e-01f, 8.50790203e-01f,
  1.06910758e-01f, 5.36658943e-01f, -4.70663428e-01f, 7.68009305e-01f, -1.69054389e-01f, -1.66868508e-01f, 5.08712411e-01f, 6.98675215e-01f, 2.59354025e-01f, 7.37263933e-02f,
  4.44850653e-01f, 9.41312239e-02f, -2.13614047e-01f, 4.15788502e-01f, 1.81721196e-01f, 6.57716572e-01f, -3.53804320e-01f, 4.45086807e-01f, 4.72971827e-01f, -7.89554298e-01f,
  6.23029992e-02f, 6.14150941e-01f, 2.36473575e-01f, 2.47427732e-01f, 6.99315369e-01f, 1.08865929e+00f, -5.38235784e-01f, 5.22397697e-01f, 2.56873637e-01f, -1.11939514e+00f,
  -3.01354766e-01f, 3.99883717e-01f, 6.54976964e-02f, 2.54305601e-01f, -1.11670423e+00f, 6.70446515e-01f, -4.20782983e-01f, -3.34212147e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.51203912e-01f, -1.29833311e-01f, 2.64926702e-01f, 2.29650080e-01f, 3.10011715e-01f, 5.92004538e-01f, 1.15339831e-01f, 6.67270184e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -8.98288116e-02f, -1.49139181e-01f, 2.91515410e-01f, 2.65457869e-01f, 7.03400448e-02f, 1.52687848e-01f, 2.28524014e-01f, -5.43320656e-01f, -1.25861794e-01f, -1.70036763e-01f,
  -2.32943147e-01f, -3.78947496e-01f, 3.79215539e-01f, 1.40129477e-01f, 8.76631290e-02f, 3.10945928e-01f, 2.09294885e-01f, 4.64136451e-01f, -1.06394768e-01f, 2.91747808e-01f,
  6.15772568e-02f, -8.31165314e-02f, -1.52321056e-01f, 7.58968946e-03f, -3.18869144e-01f, 1.07682183e-01f, -2.40109444e-01f, 5.65018177e-01f, -3.38678718e-01f, 1.00929283e-01f,
  3.48450169e-02f, -3.12716335e-01f, 6.45713508e-02f, -6.71152174e-01f, 3.17339510e-01f, -2.08367243e-01f, -3.58956337e-01f, -6.47649914e-02f, 4.30223018e-01f, -5.65382719e-01f,
  5.50538599e-01f, 5.87261468e-02f, 4.60966192e-02f, -3.13801080e-01f, 7.92803243e-02f, -3.16374332e-01f, -1.25069782e-01f, 1.80082966e-03f, 1.11700803e-01f, 8.71033892e-02f,
  -1.97412014e-01f, -1.14571080e-01f, 3.68183076e-01f, -4.03736800e-01f, -7.62602866e-01f, 4.19748604e-01f, -2.60032475e-01f, -1.17151730e-01f, -1.24439508e-01f, 4.56618577e-01f,
  3.25572848e-01f, 1.31287485e-01f, 1.41245976e-01f, -2.38311961e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.47861409e-01f, -1.76474880e-02f, 4.58835453e-01f, 5.21662235e-01f, 8.96532357e-01f, -4.34659690e-01f, 1.55559734e-01f, -5.65079413e-02f, -7.66165257e-01f, 5.68929732e-01f,
  -6.33401930e-01f, 2.92863101e-01f, 5.47617316e-01f, 9.34249401e-01f, 6.36206746e-01f, 5.89294732e-01f, -1.38649315e-01f, 3.99125457e-01f, -8.51964355e-02f, -3.65042426e-02f,
  -2.52095759e-01f, 5.96680462e-01f, -7.55434573e-01f, -4.73452181e-01f, 4.35265787e-02f, 9.13667560e-01f, 2.82116592e-01f, 1.15940499e+00f, -1.89085826e-01f, -3.39741677e-01f,
  5.64828277e-01f, -6.99351013e-01f, 4.42438066e-01f, -4.39271808e-01f, -1.40637279e-01f, 6.84146881e-02f, -6.17276967e-01f, 2.74638623e-01f, -9.65675294e-01f, 7.12952614e-01f,
  1.53943896e-01f, -3.06622446e-01f, 3.92712057e-01f, 9.19293106e-01f, -6.34185612e-01f, -7.01008022e-01f, 3.75303477e-01f, 4.36684608e-01f, -4.32750762e-01f, -6.49739325e-01f,
  -5.30536711e-01f, -8.70370805e-01f, -3.29562962e-01f, -5.00431061e-01f, 6.72213137e-01f, -3.65338892e-01f, 4.96179372e-01f, 8.64011765e-01f, 4.73237127e-01f, -9.38784957e-01f,
  3.98175776e-01f, 3.69075030e-01f, 5.95206201e-01f, -4.37416852e-01f, -4.95216101e-01f, 4.44244117e-01f, 2.60556132e-01f, 8.23187232e-01f, 7.99978137e-01f, 1.95088983e-01f,
  3.57382208e-01f, 2.44633362e-01f, -9.94298637e-01f, 9.28849801e-02f, -8.14063326e-02f, -3.50343548e-02f, -3.04913461e-01f, 7.24598050e-01f, -2.91653961e-01f, 7.43644655e-01f,
  1.67921573e-01f, -3.83218229e-01f, -7.46554613e-01f, 1.06347375e-01f, 5.07051110e-01f, 5.88389635e-01f, -1.81337342e-01f, 4.40107822e-01f, -1.03103623e-01f, -3.06118399e-01f,
  4.79573846e-01f, -9.42444243e-03f, -5.69809794e-01f, 7.07653046e-01f, -8.92951190e-01f, 5.35341978e-01f, -6.59303367e-02f, -2.78376669e-01f, -7.25066423e-01f, 1.57414019e-01f,
  -9.78121758e-01f, 5.48125565e-01f, 2.44246557e-01f, 5.89328349e-01f, -3.96308869e-01f, 6.25445545e-01f, 6.25045240e-01f, 6.11701548e-01f, -1.36995780e+00f, -7.38657638e-02f,
  -1.29405975e-01f, -9.72614810e-02f, 4.74938005e-01f, 1.44730628e-01f, 6.78496242e-01f, 6.50042817e-02f, -2.27521196e-01f, 4.44431216e-01f, -3.82474840e-01f, -6.74343050e-01f,
  1.38579035e+00f, -1.86134741e-01f, -3.96310613e-02f, 6.01018012e-01f, -2.15580449e-01f, 5.14128029e-01f, -7.68906176e-01f, 8.18245471e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.63626605e-01f, -2.06966683e-01f, 1.44679546e-01f, 1.06893275e-02f, 3.03587735e-01f, -8.25566277e-02f, 1.62680790e-01f, 3.34279805e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  7.50519156e-01f, 2.42195815e-01f, -2.28369579e-01f, -9.77329612e-01f, -1.97602287e-01f, -5.80239356e-01f, -1.56719491e-01f, 3.09974581e-01f, 2.86867529e-01f, 3.23840827e-01f,
  7.97374621e-02f, 3.98992538e-01f, -1.21570134e+00f, 6.78828135e-02f, -8.83651912e-01f, -1.13735914e+00f, -4.42425549e-01f, 1.95627660e-02f, -9.53197837e-01f, -5.55338681e-01f,
  -4.75520134e-01f, -7.78640687e-01f, 1.18777111e-01f, -8.11097920e-02f, -1.46714139e+00f, 3.79550278e-01f, -5.76095320e-02f, 5.19421816e-01f, -1.19063549e-01f, -2.19887972e-01f,
  2.01578021e-01f, -9.24115777e-02f, 9.01608050e-01f, -1.17624640e+00f, -2.93899655e-01f, -3.02913547e-01f, 1.24163640e+00f, -9.34702516e-01f, 1.15730023e+00f, -1.38686264e+00f,
  -1.01038480e+00f, -1.60911486e-01f, 1.21187277e-01f, -9.12498757e-02f, -9.93277669e-01f, -6.19851291e-01f, -6.14558160e-01f, 7.31704175e-01f, -6.58617258e-01f, 3.57826024e-01f,
  -1.09946024e+00f, 4.01727051e-01f, 1.30911559e-01f, -1.70038879e-01f, -5.56232452e-01f, 4.43910062e-01f, 4.87021983e-01f, -3.17101538e-01f, -3.85212302e-01f, -3.08484375e-01f,
  9.24908280e-01f, -1.02360773e+00f, -9.45191264e-01f, -9.41517293e-01f, -8.16804051e-01f, -6.46955431e-01f, 7.67881393e-01f, 5.12274027e-01f, 1.42803311e+00f, 3.42334151e-01f,
  4.76831973e-01f, 8.03405270e-02f, 3.37815821e-01f, -7.41480291e-01f, 2.88260907e-01f, 3.12219739e-01f, -4.31137502e-01f, -3.46648037e-01f, 1.80184960e-01f, 6.84239492e-02f,
  -6.42223597e-01f, 2.06958875e-01f, 9.79750574e-01f, 8.30566287e-01f, -1.05494678e+00f, 1.33882236e+00f, 3.91144276e-01f, -5.74580312e-01f, -1.70624211e-01f, 4.92122978e-01f,
  -7.40628302e-01f, 2.47943103e-01f, -3.64680409e-01f, -2.40512356e-01f, 2.07173392e-01f, -3.94256234e-01f, -1.05156578e-01f, 4.30177093e-01f, 6.43561184e-01f, 2.59209514e-01f,
  -6.34113789e-01f, -3.28120828e-01f, -4.93302077e-01f, -7.08627403e-02f, -1.20766056e+00f, -5.59060633e-01f, 7.54613101e-01f, -5.56325734e-01f, -3.83046210e-01f, 2.17601851e-01f,
  2.54131872e-02f, 3.42156351e-01f, 3.57165158e-01f, -6.14162743e-01f, -2.95259029e-01f, -9.73892689e-01f, 7.17364848e-01f, -7.43625164e-01f, -3.43400598e-01f, -1.00194347e+00f,
  -3.41026764e-03f, -2.15293169e-01f, -5.86134136e-01f, -7.21481442e-02f, 4.88739192e-01f, 4.25032407e-01f, 5.05920768e-01f, -5.61485827e-01f, -4.45242643e-01f, 3.75238389e-01f,
  2.06739921e-02f, 1.47069618e-01f, 3.76931876e-01f, 4.20158803e-01f, -7.71153033e-01f, 7.62627065e-01f, -3.40234488e-01f, 3.82144302e-01f, 8.13061118e-01f, -3.67776811e-01f,
  -7.58178711e-01f, -5.31425416e-01f, 3.11224252e-01f, -5.83248913e-01f, 3.22495878e-01f, 7.40317404e-02f, 5.03306925e-01f, -2.11143032e-01f, 2.93975770e-01f, 1.16468780e-01f,
  -3.32502127e-01f, -4.30685610e-01f, -1.47587925e-01f, -6.30979836e-01f, -4.13883835e-01f, -5.98911166e-01f, 3.47302228e-01f, 5.67149818e-01f, -9.96412098e-01f, 4.38758731e-01f,
  -6.18586779e-01f, -7.65335441e-01f, -2.27306426e-01f, -3.07533532e-01f, -1.02335918e+00f, 1.02641428e+00f, 1.24269962e-01f, 1.56186795e+00f, -7.00238300e-03f, 3.50927740e-01f,
  -4.34481919e-01f, -5.96256077e-01f, -4.08393443e-01f, -1.38029778e+00f, -6.48455024e-01f, 7.26318419e-01f, -1.89348489e-01f, 4.41409588e-01f, -3.45503688e-01f, -4.16391432e-01f,
  -4.80089843e-01f, 7.79984295e-01f, 8.19885731e-02f, 5.49410224e-01f, -1.50234878e-01f, 6.95068613e-02f, 1.23985730e-01f, -1.26110637e+00f, 5.20718932e-01f, 3.39447588e-01f,
  4.95510072e-01f, -3.37033570e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.98858792e-01f, -2.18448862e-01f, 5.47592342e-01f, -2.61816293e-01f, -3.05903647e-02f, -1.89341351e-01f, -1.49961680e-01f, 2.99765007e-03f, -1.74701422e-01f, -3.59494030e-01f,
  -3.58181030e-01f, 2.09128842e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    