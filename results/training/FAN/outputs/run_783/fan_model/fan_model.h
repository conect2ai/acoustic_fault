/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.33882809e-01f, 2.17451882e-02f, 4.42739457e-01f, 2.50026137e-01f, 8.33585933e-02f, 1.83469847e-01f, 1.32317871e-01f, 6.56535476e-02f, 1.23500461e-02f, 9.60690752e-02f,
  -1.52656004e-01f, -2.86692172e-01f, -5.44597730e-02f, -1.07818685e-01f, 1.16995163e-01f, 2.40174219e-01f, 1.94127753e-01f, 3.35370988e-01f, 1.16475470e-01f, 3.80508602e-02f,
  -6.29194826e-02f, 1.24566285e-02f, 1.82231665e-01f, 7.13433251e-02f, -6.05333932e-02f, -3.61858457e-02f, 7.36686885e-02f, 7.43766427e-02f, -1.25227332e-01f, 1.69060659e-02f,
  1.17951132e-01f, 6.05548546e-02f, -9.13462713e-02f, -1.54576033e-01f, -2.94973291e-02f, 6.62268838e-03f, -6.57661259e-02f, -3.00440025e-02f, -1.02185450e-01f, -8.55554044e-02f,
  -2.44944040e-02f, -2.56921072e-02f, 3.25459841e-04f, -1.03704691e-01f, 5.86247854e-02f, -1.74612049e-02f, -4.03173752e-02f, 1.66302100e-01f, 1.29062817e-01f, -6.70972615e-02f,
  -9.97912735e-02f, -1.45232618e-01f, -2.07220521e-02f, -2.35574096e-02f, 2.79576071e-02f, -2.21131425e-02f, -3.70337479e-02f, -2.12502461e-02f, 1.55528903e-01f, 7.54291713e-02f,
  6.01337627e-02f, 1.17336564e-01f, 3.95369083e-02f, 8.74750223e-03f, -5.43652959e-02f, -3.60083170e-02f, -3.36008482e-02f, 2.67989673e-02f, 3.77124250e-02f, -1.06855771e-02f,
  1.62892230e-02f, 4.19053994e-02f, -1.23877702e-02f, 3.49713787e-02f, 1.15809981e-02f, 5.64322248e-03f, -4.01145481e-02f, 3.61355431e-02f, -1.96310636e-02f, 1.17698293e-02f,
  2.86568538e-03f, -5.70077486e-02f, 5.10473251e-02f, -4.74885255e-02f, 8.75064358e-02f, 2.53707580e-02f, -6.31266385e-02f, -6.01131506e-02f, -2.01321580e-02f, -1.68038774e-02f,
  -2.15443149e-01f, -3.38246003e-02f, -1.44494083e-02f, 2.04642885e-03f, 1.10934325e-03f, 9.00294818e-03f, 3.38470042e-02f, -1.82260685e-02f, 3.92910875e-02f, 2.37118788e-02f,
  -8.79650339e-02f, 6.03330992e-02f, 5.67407906e-02f, -4.60457094e-02f, 1.16319535e-02f, -6.09831959e-02f, -4.98404801e-02f, -2.79356856e-02f, -9.12448093e-02f, 3.43795009e-02f,
  2.83221677e-02f, -3.76941785e-02f, -6.29647076e-02f, -4.89689633e-02f, -6.53757378e-02f, -7.48558342e-02f, -3.92470732e-02f, -5.56694530e-02f, -7.81119242e-02f, -3.64353471e-02f,
  1.27856433e-01f, 2.69260198e-01f, 2.95817971e-01f, -2.29011685e-01f, -2.31029943e-01f, 1.20474678e-03f, 2.50848800e-01f, 2.74174750e-01f, -1.78454399e-01f, 4.02194373e-02f,
  9.96182188e-02f, -1.35822251e-01f, 1.01519249e-01f, -4.41102572e-02f, 2.44782925e-01f, 1.76021844e-01f, -2.67815553e-02f, -3.13484371e-02f, -5.14772981e-02f, -1.46670908e-01f,
  -3.68818194e-01f, -1.32933244e-01f, -4.72258031e-02f, -4.76017110e-02f, -1.09240495e-01f, -1.69268042e-01f, 8.67733210e-02f, -1.20331591e-03f, -1.36976978e-02f, -2.86883593e-01f,
  4.46987078e-02f, 3.14995021e-01f, -1.65806301e-02f, -1.51384249e-01f, -7.45861456e-02f, 1.19621515e-01f, 5.54731786e-02f, 2.87774727e-02f, -3.31884883e-02f, 7.85475597e-02f,
  -1.68614849e-01f, -1.21315168e-02f, -1.36664867e-01f, -9.59231555e-02f, -6.80240914e-02f, -9.24436841e-03f, 9.23032910e-02f, 1.11545503e-01f, 1.28874078e-01f, 1.29632428e-01f,
  -2.26414531e-01f, -1.61883786e-01f, 5.50913997e-02f, 1.58630431e-01f, 1.44532785e-01f, -2.37671331e-01f, 1.30574763e-01f, 7.38694295e-02f, 8.79388377e-02f, 1.17498033e-01f,
  9.61075351e-03f, -1.23277614e-02f, -3.45540792e-02f, 3.91676649e-02f, -7.19574839e-02f, -6.23954547e-05f, 2.35064868e-02f, -4.53969352e-02f, -4.58841026e-02f, 2.79045254e-02f,
  1.99286472e-02f, 5.93587756e-02f, -3.75012569e-02f, 5.79897389e-02f, -1.09761924e-01f, -1.96917765e-02f, -2.68999934e-02f, -2.50605419e-02f, 3.78063768e-02f, -2.06158217e-02f,
  1.78594887e-02f, -1.01305721e-02f, -3.90811041e-02f, -5.66813722e-02f, 2.24594213e-02f, 3.12112290e-02f, -8.49446803e-02f, -3.46559323e-02f, 2.47347895e-02f, -7.73793980e-02f,
  8.29169229e-02f, 4.73430380e-02f, -5.41741354e-03f, 1.28234684e-01f, -2.11586654e-02f, -1.84416864e-02f, -5.74950725e-02f, 3.39257643e-02f, -4.03270535e-02f, 6.79615736e-02f,
  1.81021616e-02f, 3.96107584e-02f, 7.66454116e-02f, 3.32799517e-02f, -4.66489568e-02f, -2.62061674e-02f, -2.48238966e-02f, -7.24094808e-02f, -2.41884794e-02f, -1.98597796e-02f,
  -1.05552096e-02f, -1.34480391e-02f, -1.64073184e-02f, 5.14909141e-02f, -8.79620090e-02f, -6.26379773e-02f, 8.22553188e-02f, -6.69492558e-02f, 1.18477002e-01f, 1.76214114e-01f,
  -5.27956843e-01f, 3.81085366e-01f, 2.36998096e-01f, -5.30287288e-02f, 1.55852631e-01f, -9.24902484e-02f, 2.61003166e-01f, -1.06962435e-01f, -1.96444586e-01f, 2.01697111e-01f,
  1.41223043e-01f, -3.60487491e-01f, -1.84985131e-01f, -2.28904530e-01f, -3.01389396e-01f, 3.58555555e-01f, 2.83337355e-01f, -8.70545730e-02f, -3.62684935e-01f, -1.39901817e-01f,
  -2.20984649e-02f, 7.57878050e-02f, -2.39333451e-01f, -1.09643564e-01f, 2.52069861e-01f, -1.86937824e-01f, 3.26508433e-01f, 9.13905874e-02f, 1.90144092e-01f, 3.44452620e-01f,
  -4.55163009e-02f, 3.72399166e-02f, -7.39359558e-02f, -1.29947187e-02f, 1.44867599e-01f, -7.03148544e-02f, -5.65382689e-02f, 4.82806750e-02f, 2.16620937e-02f, -5.23010194e-02f,
  6.29572272e-02f, -5.55000864e-02f, -7.27614909e-02f, 4.57267463e-02f, -3.97837684e-02f, 3.39007415e-02f, 3.29813398e-02f, -6.31897226e-02f, 5.93603775e-03f, 1.21538788e-01f,
  -1.25477863e-02f, 1.29126921e-01f, 1.08878955e-01f, 3.83229111e-03f, -1.27213523e-01f, -6.94429204e-02f, 9.88346264e-02f, -4.06487547e-02f, -3.51717025e-02f, 1.84477895e-01f,
  -4.45083193e-02f, 1.71774328e-02f, -3.78383212e-02f, 7.49331713e-02f, -8.42588171e-02f, 2.59248409e-02f, 5.86833991e-02f, 1.90991983e-02f, -8.17723572e-02f, 1.02586418e-01f,
  -4.81298976e-02f, 2.51817852e-02f, -8.73680692e-03f, -4.11602147e-02f, 2.20070425e-02f, 3.58667485e-02f, -4.77267466e-02f, 9.19105634e-02f, -1.11933281e-04f, -2.50025885e-03f,
  -8.79461784e-03f, 1.83268357e-03f, 6.71945093e-03f, 5.96942753e-03f, -1.28158228e-02f, -5.43538807e-03f, -2.28670537e-02f, 4.61782813e-02f, -4.51417081e-02f, -2.17667758e-03f,
  -6.17565066e-02f, -7.83937145e-03f, -1.81513373e-02f, -5.87741844e-02f, -2.94698477e-02f, 2.69666221e-02f, -4.76554669e-02f, 5.73687218e-02f, -1.38619812e-02f, -2.29149144e-02f,
  -1.16834193e-01f, -7.73174912e-02f, 5.49434014e-02f, -2.00091191e-02f, -2.82226969e-02f, -8.03269893e-02f, 1.32173762e-01f, -2.49308329e-02f, 1.62479170e-02f, -1.53632658e-02f,
  7.27903843e-02f, -2.24801358e-02f, -2.02029087e-02f, 2.26528570e-02f, -6.55551478e-02f, -8.11833888e-02f, 5.02479775e-03f, 3.63461822e-02f, -1.41639516e-01f, 1.43942311e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.52306479e-01f, 3.89007926e-01f, -1.37559883e-02f, 2.27465540e-01f, 1.11306474e-01f, -1.76509038e-01f, -1.11743964e-01f, -8.49389285e-02f, -3.47010493e-02f, 1.03770658e-01f,
  5.54248691e-02f, -4.56569642e-02f, -2.13825956e-01f, -2.41109774e-01f, -1.86979368e-01f, 5.88704683e-02f, -1.62069425e-02f, -5.67171127e-02f, -3.61848980e-01f, -1.07853502e-01f,
  1.46813858e-02f, 1.37240589e-01f, -5.27668633e-02f, 2.75664497e-02f, 2.42708072e-01f, -1.89966466e-02f, -4.30681817e-02f, 1.43564582e-01f, 1.13734834e-01f, 5.04623234e-01f,
  3.38726699e-01f, 5.53825915e-01f, -3.08900356e-01f, -9.27866623e-02f, 7.87088200e-02f, 9.66756605e-03f, 8.18988308e-02f, 1.25824124e-01f, -1.73626170e-02f, 5.14819510e-02f,
  2.97904257e-02f, 7.78193772e-02f, 1.20522119e-01f, -3.91466729e-02f, -2.06889808e-02f, -6.04250804e-02f, -3.69328745e-02f, -6.81504421e-03f, -1.47564501e-01f, 7.15113208e-02f,
  2.24079993e-02f, 1.37728408e-01f, 8.53192061e-03f, -7.53045306e-02f, 4.78655212e-02f, -1.41917109e-01f, -7.45815635e-02f, 3.78511250e-02f, -1.62298664e-01f, 1.47957757e-01f,
  -9.72476900e-02f, 8.24569315e-02f, 5.09377345e-02f, 8.93277749e-02f, 1.42999934e-02f, 4.15007547e-02f, 2.55005565e-02f, -9.88986250e-03f, -7.00593367e-02f, 4.98732068e-02f,
  -1.22962490e-01f, -6.71553835e-02f, -3.14544253e-02f, -1.55971549e-03f, -3.39072421e-02f, 6.52887821e-02f, 1.57537609e-02f, 1.03465235e-02f, -1.00496620e-01f, 2.30130507e-04f,
  1.33457929e-02f, -2.40667164e-02f, 5.13809510e-02f, -6.94871927e-03f, -1.26753170e-02f, -7.59668052e-02f, 1.14661746e-01f, -3.78337912e-02f, 5.34232035e-02f, 1.28143921e-01f,
  -2.63261944e-01f, -4.68790889e-01f, 9.41407830e-02f, 5.61312474e-02f, 1.25998706e-01f, 2.68606399e-03f, 2.96329819e-02f, -1.09784119e-02f, 1.03132851e-01f, -1.86911179e-03f,
  -7.62677332e-03f, -2.85870656e-02f, 5.84388413e-02f, -1.89951584e-02f, -7.90017694e-02f, -3.01395338e-02f, 1.41400434e-02f, 7.27270870e-03f, -1.08389109e-01f, -5.00006936e-02f,
  -1.20158546e-01f, -1.95285067e-01f, -3.04336816e-01f, -2.32850611e-01f, -9.80200171e-02f, -2.15330765e-01f, -2.44277373e-01f, -1.28168106e-01f, -2.94212162e-01f, -3.79882842e-01f,
  2.94792265e-01f, -4.90183294e-01f, 1.18504584e-01f, 2.81440943e-01f, 3.58686298e-01f, 4.84317780e-01f, 1.83738768e-01f, 8.31190720e-02f, 2.20901370e-01f, -4.88384366e-02f,
  -6.77440092e-02f, 8.37271512e-02f, 9.81495455e-02f, 2.42324956e-02f, 8.08647089e-03f, 9.58406329e-02f, 1.50634259e-01f, 1.44493535e-01f, 3.05994034e-01f, 2.37507284e-01f,
  1.22661017e-01f, -1.58546060e-01f, -1.83978617e-01f, -8.72757286e-02f, 2.43199337e-02f, 2.90546805e-01f, -6.93525746e-03f, -1.19524293e-01f, -5.26107363e-02f, -1.01234384e-01f,
  -1.74635679e-01f, -1.28332257e-01f, 2.19014972e-01f, -1.48060083e-01f, -7.56682605e-02f, -1.18194155e-01f, 2.71866582e-02f, -9.97134671e-02f, -1.29823864e-01f, -6.05339408e-02f,
  -9.62330177e-02f, -1.06870674e-01f, -4.28768322e-02f, -1.09806418e-01f, -2.47978009e-02f, -3.97115685e-02f, -5.89331985e-02f, 7.95011129e-03f, -4.73026223e-02f, -7.82614052e-02f,
  -1.88893765e-01f, 2.48626253e-04f, 1.25590369e-01f, 5.14594577e-02f, 9.27782580e-02f, 1.41747043e-01f, -1.80297390e-01f, 1.10533405e-02f, 2.55817454e-02f, -8.95510614e-02f,
  -7.18937665e-02f, 3.97513099e-02f, 7.72428662e-02f, 2.06793882e-02f, 6.44584820e-02f, 5.63866682e-02f, -6.66617183e-03f, -2.12696604e-02f, -4.34105564e-03f, 7.12979883e-02f,
  -3.55618186e-02f, 1.00106001e-01f, -3.57727185e-02f, 6.77242130e-02f, 2.96089258e-02f, -6.65027723e-02f, 1.00913728e-02f, -6.62324876e-02f, 6.57922635e-03f, 5.83919361e-02f,
  -6.57782750e-03f, -3.51989940e-02f, -9.69967097e-02f, -5.64255640e-02f, 3.47930240e-04f, 8.23094547e-02f, 1.01568304e-01f, -5.53641506e-02f, 8.71110037e-02f, -6.25335723e-02f,
  -1.81091726e-01f, 1.29785702e-01f, 1.50707141e-01f, -4.00336608e-02f, 6.46450892e-02f, -1.09193020e-01f, -1.39768701e-02f, -1.50725216e-01f, -1.53353930e-01f, -3.74625213e-02f,
  -5.57600446e-02f, 6.77745566e-02f, -8.58225599e-02f, -5.28443567e-02f, 1.29294902e-01f, 5.36690541e-02f, -1.34000093e-01f, 1.08207554e-01f, -4.10420485e-02f, -5.90872988e-02f,
  -1.79257557e-01f, 1.58427551e-01f, 2.18718156e-01f, 2.27369577e-01f, 5.43386303e-02f, 2.78540552e-01f, 1.89439833e-01f, 7.21839964e-02f, 2.25342721e-01f, 1.07805587e-01f,
  6.80107713e-01f, -7.38463104e-02f, 3.58077943e-01f, 8.32845867e-02f, -3.73577982e-01f, -2.78109282e-01f, -5.15239418e-01f, -2.04585314e-01f, -1.29460201e-01f, -1.30180657e-01f,
  2.79029049e-02f, 2.88747489e-01f, 3.41737539e-01f, 2.57038653e-01f, 2.77087331e-01f, -9.33067873e-02f, -1.24537766e-01f, 4.72970784e-01f, 3.09733003e-01f, -1.52566686e-01f,
  -2.83940017e-01f, -5.65049006e-03f, 3.70220333e-01f, 1.31371066e-01f, -3.16097111e-01f, -1.78183429e-02f, 7.59330392e-02f, 3.57053764e-02f, -4.45155241e-02f, -6.81942105e-02f,
  1.26750678e-01f, 1.45026281e-01f, 2.25985274e-02f, 2.02752538e-02f, 6.12947531e-02f, -2.56904550e-02f, -1.57579463e-02f, 1.01695120e-01f, -8.26997831e-02f, -1.18318968e-01f,
  -9.95315611e-02f, 2.24267803e-02f, 8.81910250e-02f, -5.03275655e-02f, -1.25436366e-01f, 1.61175281e-02f, -3.76884006e-02f, 1.21133566e-01f, 7.73386285e-02f, -3.55225280e-02f,
  -5.29791899e-02f, -2.76549049e-02f, -6.29408658e-02f, -1.25725763e-02f, 1.41210899e-01f, 1.38921052e-01f, -7.49085993e-02f, 3.44657041e-02f, 6.58120438e-02f, -7.17054382e-02f,
  5.08792093e-03f, 8.96225348e-02f, 3.37026315e-03f, -3.44178937e-02f, 7.24610733e-03f, -8.19094758e-03f, -4.72981632e-02f, 6.64771860e-03f, 1.90687878e-03f, 2.03957800e-02f,
  -8.01658556e-02f, 6.82730004e-02f, 4.58062515e-02f, -1.39691262e-02f, 1.42037451e-01f, -3.54733057e-02f, -7.97691122e-02f, 4.67232205e-02f, 9.45537612e-02f, 3.12535092e-03f,
  6.02439456e-02f, -5.87045625e-02f, 2.42535025e-02f, -4.30075973e-02f, 3.47929746e-02f, 2.76811235e-02f, -5.68963354e-03f, 8.54600966e-02f, 8.30705557e-03f, -1.01957008e-01f,
  -2.14572921e-01f, 4.25470263e-01f, 9.22636315e-03f, -5.28791621e-02f, 4.77996208e-02f, 7.04847500e-02f, 3.48283052e-02f, -3.44369560e-02f, -5.81948459e-02f, -2.58733630e-02f,
  -4.03249338e-02f, 5.91169335e-02f, -1.73992626e-02f, -4.34510112e-02f, -8.24368671e-02f, -7.04180673e-02f, 1.25395916e-02f, 3.98893096e-02f, 5.55016100e-02f, -1.31025702e-01f,
  -3.81227285e-02f, -1.88232675e-01f, -5.96236736e-02f, 4.63399803e-03f, -1.93204498e-03f, 5.23192286e-02f, -1.26224250e-01f, -1.83903947e-01f, 6.55585006e-02f, -2.74179995e-01f,
  -7.52098486e-03f, -2.10336223e-01f, -2.34717891e-01f, -1.45803988e-01f, -1.75890863e-01f, -1.41458035e-01f, -1.55421317e-01f, 4.76577990e-02f, -6.06692880e-02f, -1.78261712e-01f,
  -9.18355305e-03f, -1.48790434e-01f, -2.57410109e-01f, -9.89107862e-02f, -1.44778505e-01f, -2.76428968e-01f, -3.10772181e-01f, -2.75048524e-01f, -2.21573547e-01f, -9.30712093e-03f,
  -2.21287563e-01f, -2.77831733e-01f, -1.78410053e-01f, -1.22111239e-01f, -3.16627264e-01f, -2.81931311e-01f, -2.72244155e-01f, -2.39871725e-01f, -2.70088822e-01f, -4.67500985e-01f,
  -4.96635050e-01f, 1.89347863e-01f, 7.72295054e-03f, -1.24841882e-02f, -6.14513606e-02f, 2.12445129e-02f, -5.77349775e-02f, 4.01531979e-02f, 8.49622488e-02f, -4.79085520e-02f,
  -8.19113255e-02f, -1.23212691e-02f, -1.54038100e-02f, 1.26436548e-02f, -1.26229987e-01f, -5.93315288e-02f, -4.31692647e-03f, -2.21773367e-02f, -7.79399788e-03f, 1.37300743e-02f,
  2.06606532e-03f, -5.36621846e-02f, -4.66927327e-02f, 9.63691473e-02f, 1.09023675e-01f, -1.62811473e-01f, 5.94214015e-02f, -8.82936269e-02f, -9.63810161e-02f, -1.15146548e-01f,
  -3.16094793e-02f, 6.92464039e-02f, 3.73858260e-03f, 1.31777255e-02f, 3.95468548e-02f, 4.69529442e-02f, 3.82380337e-02f, -2.55011879e-02f, 9.22539085e-02f, -8.67433548e-02f,
  -3.04653659e-03f, -1.25333769e-02f, 5.62567860e-02f, -5.76272383e-02f, 2.90400727e-04f, -5.79018816e-02f, -3.79014276e-02f, -1.36942416e-02f, 9.79795586e-03f, -6.52420372e-02f,
  -5.93624562e-02f, -1.71617363e-02f, 2.67293165e-03f, -2.88122650e-02f, -1.93260740e-02f, -1.23435311e-01f, 1.43136740e-01f, 1.48295090e-02f, 2.83618812e-02f, 1.45607963e-01f,
  -3.11283022e-01f, 1.19322859e-01f, -1.73263878e-01f, -3.99967935e-03f, -1.12243861e-01f, -4.50977823e-03f, -2.37191934e-02f, 3.75160538e-02f, -2.62823533e-02f, 1.82381179e-02f,
  -2.93473396e-02f, -6.99023381e-02f, 2.45609023e-02f, 1.23420684e-02f, -2.53327005e-02f, 1.39991576e-02f, 6.17573597e-03f, -1.38204381e-01f, 1.73091087e-02f, 3.12008522e-02f,
  6.10384233e-02f, -1.69053614e-01f, -8.00957307e-02f, -8.14780500e-03f, -1.35261968e-01f, -7.19780624e-02f, -1.77427560e-01f, -1.77912951e-01f, -1.50515676e-01f, -2.07605302e-01f,
  6.11348808e-01f, -3.69433373e-01f, -3.65390658e-01f, 1.44322338e-02f, -2.98877191e-02f, 2.21446510e-02f, -1.01101905e-01f, 9.37166288e-02f, 1.59504607e-01f, -2.01544285e-01f,
  -2.95337796e-01f, -1.26449205e-02f, -1.24073096e-01f, -1.20486483e-01f, -8.52629915e-02f, -3.26162577e-01f, -2.17601940e-01f, 3.58857326e-02f, 3.28440458e-01f, -2.27939282e-02f,
  -1.08586200e-01f, -1.24668218e-02f, 1.85071841e-01f, 4.51178923e-02f, -2.21575618e-01f, 2.39718314e-02f, -1.79238662e-01f, -1.87848687e-01f, -2.12742329e-01f, -3.56851667e-01f,
  -2.99804717e-01f, -6.67758361e-02f, 8.20540190e-02f, 4.58636507e-02f, -5.94059080e-02f, 1.17216349e-01f, 5.76338731e-03f, 2.67072115e-02f, 1.09915748e-01f, 3.82913165e-02f,
  -1.19486474e-01f, -1.04063507e-02f, -1.93755999e-02f, -8.60745162e-02f, 7.24438876e-02f, 6.27160296e-02f, 5.44647835e-02f, 6.26397803e-02f, -8.83566588e-03f, -1.04277462e-01f,
  -1.94105968e-01f, -6.32700622e-02f, 1.60135791e-01f, 6.23097494e-02f, 1.14181475e-03f, 5.86678460e-02f, -1.35013682e-03f, 2.38651931e-02f, 8.38054419e-02f, 6.36312738e-02f,
  -4.13557999e-02f, -8.13835859e-03f, 1.45510612e-02f, 2.71995328e-02f, 6.35526180e-02f, -2.27044616e-02f, 6.62158206e-02f, 1.83901731e-02f, -3.47451977e-02f, 2.95352191e-02f,
  9.05157719e-03f, -9.27359536e-02f, -3.70041803e-02f, -3.14523652e-02f, -9.68732834e-02f, 2.94708554e-03f, -1.23936841e-02f, 6.89111054e-02f, 5.00274412e-02f, 3.41482945e-02f,
  5.05448505e-02f, 7.32633248e-02f, -9.85345989e-02f, -5.14733663e-04f, -1.62319168e-01f, -7.62249753e-02f, -5.19711412e-02f, 4.69938479e-02f, 4.88113984e-02f, 5.13836034e-02f,
  1.31330252e-01f, 1.03515014e-02f, -1.25248045e-01f, 6.85190186e-02f, -3.84006910e-02f, -5.79826832e-02f, -1.06894843e-01f, 5.05524985e-02f, -4.31326218e-02f, -5.92263341e-02f,
  -8.51806626e-02f, 2.13031862e-02f, -7.05667511e-02f, -9.07886699e-02f, 4.08093184e-02f, 4.90015112e-02f, 1.35219516e-02f, 3.04003041e-02f, -4.50177640e-02f, -5.16426414e-02f,
  3.28591913e-02f, 1.75063595e-01f, 2.77940303e-01f, 1.44795030e-01f, -1.39435213e-02f, 3.78305912e-02f, 2.71757785e-03f, 5.72938509e-02f, 1.52346760e-01f, 1.53285459e-01f,
  -1.32740557e-01f, 3.23498100e-01f, -1.38293177e-01f, -2.99041837e-01f, -4.00364101e-01f, -1.11737728e-01f, 2.54163276e-02f, -1.05180800e-01f, -1.63127542e-01f, 1.14331916e-01f,
  2.18894724e-02f, 9.01207998e-02f, 2.87841201e-01f, 1.80662706e-01f, 6.08437508e-02f, 1.33465305e-01f, -6.81172982e-02f, -6.16858229e-02f, -5.97654060e-02f, -8.54448900e-02f,
  -1.69728473e-02f, -1.01996064e-01f, -2.18600869e-01f, -2.39626572e-01f, -8.08534697e-02f, 6.91698715e-02f, -1.47443399e-01f, -1.96175694e-01f, -1.12625122e-01f, -2.18324438e-01f,
  2.03182057e-01f, -2.19609976e-01f, -1.66471988e-01f, -6.07929416e-02f, -1.76381655e-02f, -4.27631475e-02f, 7.07797185e-02f, -3.68747627e-03f, -2.48250999e-02f, 1.81812141e-02f,
  -7.69476891e-02f, -8.41026902e-02f, -1.01526976e-01f, -9.09584537e-02f, 1.99720562e-02f, -1.15068607e-01f, 1.02210045e-02f, -1.00770377e-01f, -1.15897484e-01f, -5.05716652e-02f,
  3.91478352e-02f, -1.88874185e-01f, -9.74893495e-02f, -4.58977669e-02f, -1.75151929e-01f, -8.74731392e-02f, -7.77138621e-02f, -2.14434236e-01f, -1.09588854e-01f, -3.50978300e-02f,
  6.56850189e-02f, 4.49585840e-02f, 1.10308011e-03f, 2.40680445e-02f, 6.77674711e-02f, 1.14719383e-01f, -2.07857713e-02f, 8.49279612e-02f, -6.01537433e-03f, 9.61332843e-02f,
  -2.53256899e-03f, -1.74685866e-02f, 6.22806214e-02f, -4.17904416e-03f, -5.19824028e-03f, -6.75608963e-02f, 6.56651333e-02f, 5.11473343e-02f, -3.46621946e-02f, -7.33817220e-02f,
  -6.40048683e-02f, -1.23994917e-01f, -1.45358462e-02f, 7.97984004e-02f, -1.29480615e-01f, -3.66235673e-02f, 2.56567784e-02f, 5.19096591e-02f, 1.08600389e-02f, -9.42889154e-02f,
  3.99106234e-01f, -7.54692703e-02f, 1.41077235e-01f, 3.40486541e-02f, -3.83974984e-02f, 6.35693148e-02f, 4.39660996e-02f, -5.55408671e-02f, 3.24395746e-02f, 3.99959534e-02f,
  -1.01367414e-01f, -2.47091171e-04f, 7.40003288e-02f, 1.25123104e-02f, -2.03944687e-02f, -3.21425050e-02f, 8.26643631e-02f, 3.91640291e-02f, -3.82864699e-02f, -1.00271814e-01f,
  -1.58192255e-02f, 9.02334526e-02f, 3.00191522e-01f, 1.47074342e-01f, -1.17321673e-03f, 1.39245436e-01f, 2.05421388e-01f, 2.54575312e-02f, 7.11856857e-02f, 5.05148530e-01f,
  5.55458926e-02f, 1.91359520e-01f, 1.62296101e-01f, -1.06668286e-01f, 2.59498507e-01f, 3.61179262e-01f, 3.53178859e-01f, 1.96945921e-01f, -5.10065928e-02f, 7.13693202e-02f,
  3.54975522e-01f, -3.10940500e-02f, -1.88100129e-01f, -5.24679124e-02f, 1.95322614e-02f, -9.49371606e-02f, -3.15647036e-01f, -2.17105240e-01f, -7.35062510e-02f, -7.36795040e-03f,
  -3.04928757e-02f, -2.40795344e-01f, -2.06946686e-01f, -1.38370946e-01f, -2.07069948e-01f, -2.30666488e-01f, -5.27605079e-02f, 2.49273721e-02f, -1.99385900e-02f, -3.26501846e-01f,
  1.40412211e-01f, 5.23974836e-01f, -2.83775982e-02f, -7.70883039e-02f, 1.59612834e-01f, -8.55542123e-02f, 7.57213384e-02f, -1.24331489e-01f, -2.44197566e-02f, -7.94673264e-02f,
  1.18693635e-01f, 1.13485202e-01f, 2.55978256e-02f, -1.11584207e-02f, 9.21972096e-02f, -4.69646230e-03f, -2.00328161e-03f, -1.84032336e-01f, 1.74110234e-02f, 9.18910876e-02f,
  8.01401213e-03f, 4.95877899e-02f, 1.63450286e-01f, -4.23019305e-02f, 1.46339431e-01f, 3.63563211e-03f, 1.68617919e-01f, -4.19986844e-02f, 7.64612630e-02f, -2.30536774e-01f,
  -4.54007462e-02f, 2.89029796e-02f, 6.15041330e-02f, 3.52080502e-02f, -5.21154031e-02f, 1.17369834e-03f, -5.07152937e-02f, 2.58941408e-02f, 5.17698191e-03f, -1.51999563e-01f,
  2.96542812e-02f, 1.14168502e-01f, -1.34807387e-02f, -4.67558950e-02f, -5.25693968e-02f, -1.64256955e-03f, 3.89269218e-02f, -6.67673051e-02f, 3.76783088e-02f, 1.69480219e-02f,
  3.26828733e-02f, -1.21965194e-02f, -2.67861541e-02f, -5.95556833e-02f, -2.07478423e-02f, 5.23977987e-02f, -2.90904436e-02f, 7.02335909e-02f, -2.29259077e-02f, 2.76127420e-02f,
  -2.46894434e-01f, 1.96742073e-01f, -1.06650166e-01f, -1.56750903e-02f, 2.49977876e-02f, 3.11721843e-02f, 7.56430849e-02f, 8.42016016e-04f, 1.65556967e-01f, -3.05142328e-02f,
  1.11426763e-01f, 3.00231334e-02f, 1.10590987e-01f, -6.35679513e-02f, -2.16965843e-02f, 7.81321004e-02f, -1.30269285e-02f, -6.55676499e-02f, -5.16899824e-02f, -2.28461176e-02f,
  -1.74582675e-01f, -1.60808876e-01f, -3.03974122e-01f, -1.45565197e-01f, -9.51103270e-02f, -2.21291110e-01f, -1.75566465e-01f, -1.44842014e-01f, -3.85508202e-02f, -4.29202944e-01f,
  6.75966740e-02f, -1.24646902e-01f, -2.45325416e-02f, 2.12312043e-01f, 5.12168631e-02f, -2.14913979e-01f, -3.77563298e-01f, -1.49153307e-01f, 1.72120824e-01f, -1.60527267e-02f,
  1.55536041e-01f, 1.46985278e-01f, 7.88106304e-03f, -2.21661076e-01f, -3.11110407e-01f, -3.53940636e-01f, -3.26644182e-01f, -3.50849569e-01f, -3.75503689e-01f, -2.17498839e-01f,
  -4.48255092e-02f, -7.95697570e-02f, -1.93777569e-02f, -6.06760420e-02f, 2.07157299e-01f, 1.52257696e-01f, 2.05954224e-01f, 1.01218678e-01f, 3.75247411e-02f, 8.59625563e-02f,
  2.92144958e-02f, 9.62298810e-02f, -1.18208766e-01f, 7.15230480e-02f, 7.43540823e-02f, 1.74318403e-02f, -5.60145862e-02f, -3.60114593e-03f, 1.31661526e-03f, -5.75107299e-02f,
  8.14979672e-02f, -6.16110936e-02f, 2.69517265e-02f, 5.26484451e-04f, -3.48675288e-02f, -9.78091508e-02f, -1.23190187e-01f, -2.54339546e-01f, -5.41998111e-02f, -8.59465152e-02f,
  -1.29423544e-01f, -3.07668056e-02f, -1.81872338e-01f, -2.00828873e-02f, -2.76638027e-02f, -9.12327543e-02f, 3.76917012e-02f, 1.32808983e-01f, -1.23684861e-01f, 1.82843968e-01f,
  3.86846182e-03f, -1.74429622e-02f, -6.32477105e-02f, 2.79586911e-02f, -4.16936204e-02f, 4.21219058e-02f, 2.47885995e-02f, -8.57057124e-02f, -3.48951742e-02f, 2.52160095e-02f,
  1.16381003e-02f, 2.22492423e-02f, -2.81928107e-02f, 7.12923855e-02f, 2.16242187e-02f, 1.05982171e-02f, -5.83941936e-02f, -1.17808692e-01f, 1.25078624e-03f, -4.98706428e-03f,
  3.00947987e-02f, 1.04846070e-02f, 1.12505049e-01f, -3.60878371e-02f, 3.10138147e-02f, -2.37267502e-02f, -3.85440402e-02f, 5.12030572e-02f, -1.97302047e-02f, -4.04553600e-02f,
  4.53631014e-01f, -2.90755421e-01f, 1.01141669e-02f, -4.30137105e-02f, 1.11573800e-01f, 6.41277283e-02f, 1.48722723e-01f, -5.53746559e-02f, 6.30745664e-02f, -4.00811695e-02f,
  -7.18405321e-02f, 8.13839305e-03f, 5.18835615e-03f, -4.63548601e-02f, -1.32945552e-01f, -3.50322239e-02f, -3.29953805e-02f, -5.32559007e-02f, -1.77777916e-01f, 6.97719529e-02f,
  -1.18341148e-02f, -2.30702758e-01f, -1.83640227e-01f, -3.96284424e-02f, -4.15770449e-02f, -1.03668913e-01f, -1.53717510e-02f, -7.75804669e-02f, -2.40625247e-01f, 1.49209769e-02f,
  -8.34321082e-01f, 1.78466350e-01f, -3.56524408e-01f, -1.22839808e-01f, 1.53961211e-01f, 2.74758846e-01f, 2.13920683e-01f, 5.61273582e-02f, -4.29131929e-03f, 5.88101558e-02f,
  4.37768698e-02f, 1.07882924e-01f, 2.05794591e-02f, 1.73364088e-01f, 8.72065946e-02f, 1.47647768e-01f, 1.48676500e-01f, -4.66910042e-02f, -1.23964168e-01f, 3.32290754e-02f,
  2.63222635e-01f, -1.90355986e-01f, -2.82279700e-01f, -1.99020505e-02f, 9.56564695e-02f, 1.23696029e-02f, -1.74561441e-01f, -1.71285402e-02f, 1.91465139e-01f, 2.05053821e-01f,
  -1.65868580e-01f, -2.57559776e-01f, 2.76079625e-02f, 1.12653067e-02f, -2.35372037e-02f, -1.78628653e-01f, -1.19897403e-01f, -1.66075379e-01f, -8.96185040e-02f, -3.17639834e-03f,
  -7.30646700e-02f, 4.51731198e-02f, -4.42538187e-02f, -1.67542417e-02f, -1.31751120e-01f, -1.37505397e-01f, -9.45861414e-02f, -2.17166856e-01f, -1.62826255e-01f, 3.92555306e-03f,
  2.48495549e-01f, -5.39024472e-02f, -2.87451535e-01f, 2.04055142e-02f, -5.34130931e-02f, -1.40769154e-01f, -4.72099893e-02f, -1.01635672e-01f, -1.12450421e-01f, -1.30253896e-01f,
  3.43961120e-02f, 3.45188007e-02f, 6.42112270e-02f, -1.43545652e-02f, 6.29786449e-03f, -2.26005614e-02f, 9.88988727e-02f, 7.34505728e-02f, 1.45893907e-02f, -5.16200475e-02f,
  -6.85292855e-02f, 3.14186774e-02f, 3.68522741e-02f, -8.59477147e-02f, -2.13285945e-02f, -2.59518269e-02f, 1.29038107e-03f, 3.19490284e-02f, -8.50169435e-02f, -3.51745151e-02f,
  5.71652912e-02f, -1.17366351e-01f, -5.78645580e-02f, -2.11743005e-02f, 9.44750756e-02f, -6.25674948e-02f, -2.43921597e-02f, 6.99522570e-02f, -9.85004455e-02f, -1.79921016e-02f,
  -1.81143045e-01f, 1.18021779e-01f, -8.71789828e-02f, 5.49540855e-02f, -6.89990399e-03f, -2.28205323e-02f, 3.52871194e-02f, -5.62457219e-02f, -4.51585883e-03f, -1.28935516e-01f,
  -2.73563396e-02f, -6.51104674e-02f, -6.49006739e-02f, 6.03384636e-02f, -7.68629760e-02f, -5.05726077e-02f, 6.93147480e-02f, -5.41014187e-02f, 2.55867783e-02f, 2.13705860e-02f,
  -5.82544394e-02f, -3.29768993e-02f, -1.66293010e-01f, -1.27770722e-01f, -1.00006767e-01f, -5.47610335e-02f, -4.62356359e-02f, -2.12755755e-01f, -2.10702017e-01f, -9.71572921e-02f,
  -6.33125782e-01f, 3.30718756e-02f, -1.64058041e-02f, -4.35444593e-01f, -1.57094449e-01f, 8.78401548e-02f, 1.99470654e-01f, 3.61424834e-02f, -2.54835576e-01f, 1.38411447e-01f,
  -8.47513962e-04f, -1.81685120e-01f, 6.71331436e-05f, 1.87757071e-02f, -3.01981159e-03f, 4.20832746e-02f, -1.76053122e-01f, -1.95953116e-01f, -2.02797011e-01f, -2.59970836e-02f,
  -1.40959382e-01f, -2.88143307e-01f, -3.96686137e-01f, -1.32520840e-01f, -8.01485106e-02f, -5.00609837e-02f, 5.68684489e-02f, -1.28790066e-01f, 5.39741106e-02f, 7.78279826e-02f,
  2.63618737e-01f, -1.88035369e-01f, 1.11189283e-01f, -8.47814456e-02f, 3.55227515e-02f, 1.68029927e-02f, 1.70077644e-02f, -4.62874658e-02f, -6.45672902e-02f, 3.17142978e-02f,
  -3.11434455e-02f, -3.43734771e-02f, -3.56915779e-02f, -1.00691849e-02f, -1.16874404e-01f, -9.93958674e-03f, -4.46455330e-02f, 5.88392315e-04f, 5.50181456e-02f, 1.04629502e-01f,
  1.02732718e-01f, 5.52977212e-02f, -1.94408856e-02f, 1.53579995e-01f, 1.36436075e-01f, -5.38183935e-02f, 1.86794877e-01f, 7.54209831e-02f, 1.05644666e-01f, 1.50600418e-01f,
  -1.53045962e-02f, 4.43377085e-02f, 1.25440776e-01f, -7.50951171e-02f, 6.43097609e-02f, 3.61198597e-02f, -5.61431758e-02f, 2.46149600e-02f, 4.20752466e-02f, -1.09744042e-01f,
  -4.24464844e-04f, 4.53279950e-02f, -4.93587144e-02f, 2.79963445e-02f, 4.89214845e-02f, 8.44792351e-02f, -8.77726078e-02f, 1.00430898e-01f, -1.67212300e-02f, 5.78059675e-03f,
  -2.68941615e-02f, 7.39645511e-02f, -4.67421673e-02f, 7.81189054e-02f, 2.42134351e-02f, -5.80205880e-02f, -3.90807949e-02f, -5.67170512e-03f, 3.13990340e-02f, 8.97845812e-03f,
  1.76640246e-02f, -1.32129148e-01f, -6.74697906e-02f, -8.34684893e-02f, -4.91649695e-02f, -4.02102582e-02f, -2.04073265e-02f, -6.37997463e-02f, -3.82452793e-02f, -6.42298982e-02f,
  2.34380774e-02f, 4.28247340e-02f, -4.92241159e-02f, 1.64080467e-02f, -8.32716897e-02f, 2.85189226e-02f, -4.13136370e-02f, 6.21563196e-02f, 4.03092653e-02f, 7.78453127e-02f,
  1.42209128e-01f, 2.35886108e-02f, -3.87623087e-02f, 8.71803388e-02f, 3.51820253e-02f, -3.38244028e-02f, 7.27545768e-02f, 1.74563408e-01f, -6.41370192e-02f, 5.85759766e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.85231405e-01f, 2.91262329e-01f, 8.53530943e-01f, 5.71359456e-01f, 2.82144576e-01f, 4.87294376e-01f, 4.29584652e-01f, 1.64895028e-01f, 7.78656155e-02f, 2.38471210e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.23137513e-01f, -1.37039021e-01f, -2.61486351e-01f, -5.74538074e-02f, -3.99287611e-01f, -6.95575893e-01f, -2.95015052e-02f, -5.08486092e-01f, 6.38626814e-01f, -3.41235176e-02f,
  1.88863903e-01f, 5.87111451e-02f, -4.70647097e-01f, -4.48748171e-02f, 1.54421777e-01f, -5.79382539e-01f, -1.30316690e-01f, -2.38618866e-01f, -4.88473594e-01f, -2.77050495e-01f,
  -3.12403381e-01f, -8.93662572e-01f, -2.10122272e-01f, 4.46701586e-01f, 1.05896503e-01f, 6.71464726e-02f, 4.23280209e-01f, 8.90114531e-02f, -1.38949245e-01f, 3.54646772e-01f,
  -1.54013336e-01f, -2.12894008e-01f, -9.13319737e-02f, 1.34540573e-01f, -4.51825447e-02f, -3.52710903e-01f, -3.23339030e-02f, -2.09539041e-01f, 1.11215420e-01f, -6.46818340e-01f,
  6.71994209e-01f, 2.53693581e-01f, 5.90371937e-02f, -2.89305389e-01f, 8.19974840e-02f, 3.08733910e-01f, -1.15176506e-01f, -1.98263124e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.25997439e-03f, 1.06905013e-01f, -3.57301146e-01f, -1.65413275e-01f, -2.68380344e-02f, -1.64972395e-01f, -5.58632255e-01f, 1.20864129e-02f, -8.77523422e-02f, 3.17887902e-01f,
  1.27049312e-01f, 2.14215294e-01f, 4.71496761e-01f, -7.54253149e-01f, 5.22804320e-01f, 4.60213304e-01f, 4.80834335e-01f, 2.75480717e-01f, 8.41093957e-01f, -4.18142617e-01f,
  5.83264470e-01f, 2.60603637e-01f, -1.99373901e-01f, -2.46800631e-01f, -1.42291307e-01f, -1.36531204e-01f, -3.47963423e-01f, 1.31573617e+00f, -2.92700857e-01f, 3.59415025e-01f,
  -6.86591938e-02f, 4.47411180e-01f, -3.44388932e-01f, 5.75822949e-01f, 3.33002865e-01f, 6.23830140e-01f, 4.56467152e-01f, 2.06067368e-01f, 7.63434827e-01f, 3.40905249e-01f,
  -1.44049242e-01f, -3.11306059e-01f, 1.55723229e-01f, -2.09106386e-01f, -2.47394294e-01f, -2.73078769e-01f, -3.51763576e-01f, 2.63234749e-02f, 2.01649278e-01f, -3.91268462e-01f,
  2.52958328e-01f, -1.13746002e-01f, -6.27481103e-01f, 1.14913642e-01f, 9.42665279e-01f, -2.98007935e-01f, -1.10667974e-01f, -2.69322187e-01f, -3.98806557e-02f, -1.51735619e-01f,
  -2.59759516e-01f, 2.22465619e-01f, 2.45083347e-01f, -1.54809490e-01f, 7.93451011e-01f, -3.57242286e-01f, 3.58486354e-01f, -1.32166955e-03f, -1.00739121e+00f, 6.68429211e-02f,
  1.01312205e-01f, 5.23272514e-01f, -6.96466863e-02f, 1.14427805e-01f, 8.20466802e-02f, -1.51926041e-01f, -2.66938061e-01f, 2.57460833e-01f, 8.16635907e-01f, -2.45490596e-01f,
  2.11703390e-01f, -1.20868079e-01f, 2.91450560e-01f, -4.67172205e-01f, 3.54482867e-02f, 4.59708244e-01f, 1.53632551e-01f, -2.31793806e-01f, -2.97951818e-01f, 1.21629024e+00f,
  1.71765313e-01f, -3.15094382e-01f, 9.00252402e-01f, 7.83443749e-01f, 1.47587478e-01f, 5.58791876e-01f, 7.98245296e-02f, 2.76709825e-01f, 2.03789681e-01f, -8.63982886e-02f,
  1.65366396e-01f, -3.82915772e-02f, -1.45952404e-01f, 1.12616457e-01f, 3.07762146e-01f, 1.61905602e-01f, -1.97044447e-01f, 1.62840843e-01f, 5.08659407e-02f, -4.55120921e-01f,
  6.43487751e-01f, 2.23746151e-01f, 5.58067977e-01f, 3.77034396e-01f, 6.66012645e-01f, 5.68473041e-01f, -9.45505425e-02f, 1.64559126e-01f, 8.33103657e-01f, -6.70529664e-01f,
  1.15715289e+00f, 3.02260220e-01f, -3.41927528e-01f, -4.36362177e-01f, 2.42835864e-01f, 3.66105624e-02f, -6.60487533e-01f, -2.13307500e-01f, -5.31747460e-01f, -1.17942438e-01f,
  -4.94866401e-01f, -3.44897777e-01f, 4.98545617e-01f, -3.05249333e-01f, 3.01922381e-01f, 3.78768742e-01f, 7.97688603e-01f, 5.64488351e-01f, -2.35510804e-02f, 1.32393196e-01f,
  7.23825097e-01f, 6.32304847e-02f, -2.20047653e-01f, 2.37332523e-01f, 4.98171389e-01f, 6.92355573e-01f, 2.41142794e-01f, 5.43120801e-01f, -3.48231345e-01f, -1.06938720e+00f,
  -6.11132324e-01f, 2.68632054e-01f, 3.97376120e-01f, 5.55356324e-01f, 1.19044387e+00f, 9.33817104e-02f, -3.94722760e-01f, -8.25437084e-02f, -4.38322335e-01f, -4.62257057e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -2.19996139e-01f, 4.32629436e-01f, 1.08434096e-01f, 1.52780697e-01f, 5.25476158e-01f, 5.47764361e-01f, -4.69072647e-02f, 3.10887724e-01f, 2.47483969e-01f, 5.49271286e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  4.91309538e-02f, -7.22939014e-01f, -3.41548264e-01f, -1.47697553e-01f, 4.28891003e-01f, 1.64834589e-01f, 2.89167196e-01f, -7.69085824e-01f, -2.35673279e-01f, 1.18809834e-01f,
  -2.09031165e-01f, 7.98596799e-01f, -2.35920534e-01f, -6.86142564e-01f, 4.23947990e-01f, 2.13699654e-01f, 1.14499323e-01f, -6.12667978e-01f, 3.25908601e-01f, 8.00547183e-01f,
  4.46683139e-01f, -7.23132715e-02f, 2.08862334e-01f, -3.23549062e-01f, -2.68065751e-01f, -1.29964307e-01f, -4.79512393e-01f, -4.17227387e-01f, 2.31803417e-01f, -2.83537269e-01f,
  1.06154048e+00f, 8.00163805e-01f, -2.22526208e-01f, 5.49815118e-01f, 9.54543948e-02f, 5.98350286e-01f, -1.25840232e-01f, 5.70504963e-01f, -2.63802260e-01f, -2.40783185e-01f,
  -6.47250354e-01f, -4.86139953e-01f, 1.54803097e-01f, -3.01969558e-01f, 1.56749040e-01f, 9.69636440e-01f, -4.72474486e-01f, 7.68937528e-01f, -7.21307158e-01f, 2.91025996e-01f,
  6.91480935e-02f, 2.87117362e-01f, -6.96626246e-01f, 1.03904612e-01f, 9.63601172e-01f, -8.94686580e-02f, -2.98144221e-01f, -9.73531902e-02f, -1.71067744e-01f, 7.05264449e-01f,
  4.62964237e-01f, -6.75578237e-01f, 1.36622727e-01f, -8.69773090e-01f, -4.98889238e-01f, 6.31579876e-01f, -3.45883101e-01f, -2.40425631e-01f, 2.53928035e-01f, 1.44274652e-01f,
  -7.61393368e-01f, 3.16089362e-01f, 6.37858063e-02f, -3.09887946e-01f, -1.73433334e-01f, 9.54446077e-01f, -4.15344834e-01f, -8.86935964e-02f, 3.49185944e-01f, -6.49765015e-01f,
  8.37514877e-01f, 5.88192046e-01f, 7.78219581e-01f, 4.22182009e-02f, 1.00325489e+00f, 2.17976615e-01f, -2.16867656e-01f, 6.47913158e-01f, -2.10649058e-01f, -1.89064592e-01f,
  2.77202837e-02f, 2.34387860e-01f, 1.52185142e-01f, -4.01460558e-01f, -2.46019632e-01f, 6.46117687e-01f, 2.62245238e-01f, -2.20050827e-01f, -5.16564697e-02f, 4.14451301e-01f,
  -4.59080994e-01f, 3.57069254e-01f, -1.67596161e-01f, -3.02211285e-01f, 1.01315534e+00f, 2.85025537e-01f, -6.91176832e-01f, -1.03276777e+00f, 1.10376403e-02f, 9.85084355e-01f,
  -2.34705865e-01f, -3.60561550e-01f, 2.66695440e-01f, -4.07462120e-02f, -4.29802269e-01f, -8.18431228e-02f, -2.70351917e-01f, -6.57903314e-01f, 2.31265917e-01f, -4.35588986e-01f,
  2.85016838e-02f, 6.72039330e-01f, 1.07726038e+00f, -1.93010688e-01f, 4.00532961e-01f, -4.29684341e-01f, -3.66245449e-01f, -4.16464299e-01f, -1.91896096e-01f, 1.95485741e-01f,
  -5.56092680e-01f, -5.64870834e-01f, 3.80132467e-01f, -5.34909606e-01f, -2.56850123e-01f, -1.22930564e-01f, 4.68353242e-01f, -3.61122966e-01f, 1.87043503e-01f, -7.26054251e-01f,
  -2.05992863e-01f, -5.58679104e-01f, -7.12818086e-01f, 1.04869771e+00f, -1.38662353e-01f, 2.22590894e-01f, 1.38735518e-01f, 1.36678249e-01f, -1.30052567e-01f, 5.45714140e-01f,
  -6.03208989e-02f, -2.65953183e-01f, -4.56161827e-01f, 8.65550280e-01f, 7.11693764e-01f, -4.38839896e-03f, -3.12055618e-01f, 7.47067809e-01f, -2.98269004e-01f, -5.87075591e-01f,
  -1.65126428e-01f, -1.39230177e-01f, -4.28263918e-02f, -2.37110183e-01f, 3.22550595e-01f, -2.10228577e-01f, -7.94143230e-02f, 1.53686941e+00f, -2.66564220e-01f, -2.97661096e-01f,
  -4.92388487e-01f, -3.79481941e-01f, 1.51678115e-01f, -3.22724760e-01f, -1.94073673e-02f, -7.42615581e-01f, -6.18498981e-01f, -3.37543905e-01f, 5.14798641e-01f, -8.39443862e-01f,
  -7.72653222e-01f, 3.68241183e-02f, -3.60346287e-01f, -2.29000881e-01f, 3.65119010e-01f, -3.02104533e-01f, -7.13599980e-01f, 3.22023064e-01f, -8.85876566e-02f, 6.16113126e-01f,
  6.63310766e-01f, -6.30878747e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.07905823e-01f, -8.09674859e-02f, -2.76941359e-01f, -1.04203440e-01f, -2.36406311e-01f, 7.44504854e-02f, 1.78178594e-01f, -1.86160542e-02f, 2.39504039e-01f, 1.03473872e-01f,
  2.03024536e-01f, 3.39846343e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    