/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.50860000e-01f, -5.43435574e-01f, -3.18765119e-02f, 2.56258696e-01f, -9.66289043e-02f, -2.02017725e-01f, -4.37239021e-01f, -2.82611072e-01f, 1.06301300e-01f, -6.52920231e-02f,
  -6.22426607e-02f, 1.96233958e-01f, 1.54748678e-01f, 1.41238660e-01f, 1.15824826e-01f, -1.80954024e-01f, 1.45935014e-01f, 2.78938800e-01f, 2.47231156e-01f, 1.30098406e-02f,
  1.51730761e-01f, 1.70410171e-01f, 3.50291401e-01f, 1.32415043e-02f, -2.86836307e-02f, 8.36839974e-02f, -2.33828202e-02f, 2.33107522e-01f, 3.90811302e-02f, 3.72911245e-01f,
  1.99398566e-02f, -2.45405972e-01f, 1.18434727e-01f, 1.06941566e-01f, 8.30528140e-02f, 4.51293476e-02f, -2.87997425e-02f, 6.29098862e-02f, 2.03851461e-02f, 5.40915579e-02f,
  8.14329162e-02f, 1.35645792e-01f, 1.05348311e-01f, 3.95645127e-02f, -1.35198422e-02f, 1.98378172e-02f, 9.20626968e-02f, 6.41498202e-03f, 4.25641499e-02f, -1.47459954e-01f,
  1.38626873e-01f, 2.98004337e-02f, 8.84088054e-02f, -1.28478467e-01f, 3.08474898e-03f, 1.64861292e-01f, -1.06679924e-01f, 1.15375146e-01f, 8.09901655e-02f, -2.37538479e-02f,
  -3.86442542e-02f, -1.15046026e-02f, 2.34911237e-02f, 1.64251705e-03f, -4.65856791e-02f, 4.73348163e-02f, -2.27391510e-03f, 3.94816361e-02f, 5.26733026e-02f, -3.01042777e-02f,
  4.28619748e-03f, -2.20782589e-02f, 4.93320227e-02f, -8.10813606e-02f, 1.01627111e-01f, -2.46585384e-02f, 7.28780106e-02f, 2.53270138e-02f, -4.37154099e-02f, 1.27637669e-01f,
  3.05345450e-02f, 2.60504745e-02f, 2.56222356e-02f, 4.43437919e-02f, -6.77159987e-05f, 3.01361699e-02f, -5.42438775e-02f, -6.68289512e-03f, 9.70601216e-02f, 3.52962762e-02f,
  3.91343655e-03f, 1.12989500e-01f, 2.03830767e-02f, 6.12563640e-02f, -7.72097260e-02f, -3.20569426e-03f, 9.60998684e-02f, 8.47231317e-03f, 4.97354902e-02f, 2.31055748e-02f,
  1.84486415e-02f, -2.37105079e-02f, 6.47673905e-02f, 6.17126301e-02f, 6.55161142e-02f, 1.07923530e-01f, 2.26087011e-02f, -5.82055235e-03f, 4.67716604e-02f, -1.56150330e-02f,
  1.04092613e-01f, -4.13004570e-02f, -1.05860613e-01f, -7.56123587e-02f, 2.50819158e-02f, 8.07037950e-02f, -1.60947770e-01f, -3.79990973e-02f, 3.55041474e-02f, -2.90784538e-01f,
  -1.51010007e-01f, 8.23922269e-03f, -3.84188890e-01f, 1.27907604e-01f, -8.00352320e-02f, 5.43555208e-02f, 7.31064007e-02f, 6.14799410e-02f, 8.45613405e-02f, 1.38529599e-01f,
  -1.53147161e-01f, -2.68788457e-01f, -1.53254107e-01f, -5.00741713e-02f, -7.33543467e-03f, 1.12501264e-01f, 1.55070499e-01f, -2.57982224e-01f, -2.43796483e-01f, 1.84264868e-01f,
  1.86034635e-01f, 1.17494995e-02f, -9.10343230e-02f, 2.79403836e-01f, 2.58112848e-01f, 1.58888102e-01f, 2.88200766e-01f, 1.82314590e-01f, 8.68698731e-02f, -9.56132729e-03f,
  -8.34275857e-02f, -8.15244690e-02f, -1.01519659e-01f, 3.43862213e-02f, -2.68326793e-02f, -3.31226811e-02f, 4.04929891e-02f, -1.30331993e-01f, -3.73547003e-02f, -2.30028443e-02f,
  -3.66281681e-02f, -5.97194619e-02f, -2.37645116e-02f, -5.82051557e-03f, -3.29322293e-02f, 2.42122449e-02f, 1.47785142e-01f, -1.24452308e-01f, -4.50493954e-02f, 5.79766333e-02f,
  4.80969138e-02f, -1.35273010e-01f, -5.66837192e-02f, 9.09467041e-02f, 7.51255229e-02f, -8.96116644e-02f, 1.53901074e-02f, 8.49340260e-02f, -4.31143539e-03f, 1.85944408e-01f,
  9.39873755e-02f, -1.23148598e-01f, 4.34222668e-02f, 1.34751454e-01f, 3.28123420e-02f, -8.94354805e-02f, -3.43654938e-02f, 3.64915021e-02f, -1.63466129e-02f, 2.97239199e-02f,
  -6.39112443e-02f, 6.79948702e-02f, -2.00270023e-02f, 4.06039841e-02f, 8.26362893e-02f, -1.67630601e-03f, 1.04960836e-02f, 1.36899412e-01f, 5.52063398e-02f, -2.35414249e-03f,
  1.47235626e-02f, 1.91186517e-02f, -1.40602645e-02f, -4.75055389e-02f, 1.15223289e-01f, 3.29733104e-03f, 1.51524860e-02f, 5.55892661e-02f, 6.54913783e-02f, 2.95883194e-02f,
  1.48564294e-01f, -1.15041018e-01f, -9.12703052e-02f, 1.00939751e-01f, 1.39342826e-02f, 9.87612084e-03f, 2.65746173e-02f, 2.71478929e-02f, -1.03265718e-01f, 6.10540472e-02f,
  3.91159430e-02f, 9.34739336e-02f, 3.54214897e-03f, 8.97109434e-02f, -4.16388623e-02f, 5.63069284e-02f, 8.40301365e-02f, 1.64265167e-02f, 5.71202338e-02f, 7.55258799e-02f,
  1.15296513e-01f, 8.69301409e-02f, 9.45461243e-02f, -3.38377990e-02f, 9.74476989e-03f, -4.19982197e-03f, 3.21918353e-02f, 6.76051900e-02f, -7.59436190e-02f, 3.07385325e-01f,
  -9.22888815e-02f, -3.71537358e-02f, -3.99514854e-01f, 1.06336124e-01f, 1.61917612e-01f, 2.09077239e-01f, 4.03221577e-01f, 9.31077823e-02f, 7.25497454e-02f, -4.66214679e-02f,
  2.23388955e-01f, 1.53642306e-02f, -1.09869756e-01f, -1.08454302e-01f, 7.92402402e-02f, -1.33984938e-01f, -5.27166128e-02f, -2.67630428e-01f, 7.78172463e-02f, 4.43619698e-01f,
  4.00840968e-01f, 1.41003624e-01f, -3.90358828e-02f, 8.02096128e-02f, -2.42410451e-02f, 8.01126286e-02f, -2.03382120e-01f, -1.70455068e-01f, 6.91082254e-02f, -5.99682033e-01f,
  -2.82177776e-01f, -2.28625629e-02f, 1.64739519e-01f, 6.65652230e-02f, 1.19522568e-02f, 6.31371513e-02f, 4.12406549e-02f, -1.16288714e-01f, 7.46564791e-02f, 3.12880315e-02f,
  7.40392357e-02f, 6.40677065e-02f, 4.49858382e-02f, -3.22845019e-02f, 1.03938095e-02f, 9.10638422e-02f, -5.77325933e-02f, -4.24128063e-02f, -1.13357216e-01f, 3.75094973e-02f,
  1.18422352e-01f, 8.84442404e-02f, 6.71621934e-02f, 6.43351823e-02f, 7.90880024e-02f, 3.45138200e-02f, 1.33696839e-01f, -2.29956377e-02f, -1.39065767e-02f, -2.02360719e-01f,
  8.55176374e-02f, -7.00934082e-02f, -2.07942184e-02f, -1.81260481e-02f, 5.53009771e-02f, -3.37618701e-02f, -9.12280679e-02f, 6.09318055e-02f, 1.91283952e-02f, -4.40354347e-02f,
  -6.23549744e-02f, -8.41777772e-03f, -1.22716902e-02f, -1.26007631e-01f, -3.73461731e-02f, -7.03006908e-02f, -7.47082978e-02f, -6.88538421e-03f, 3.65738611e-04f, 3.54102999e-02f,
  4.63588722e-03f, 2.40127780e-02f, -1.03187382e-01f, -7.26779848e-02f, -5.25523052e-02f, -8.13947991e-02f, 2.86798161e-02f, 2.56114285e-02f, 4.65682782e-02f, 2.54290961e-02f,
  6.19870648e-02f, 1.06337771e-01f, -1.43340454e-01f, -6.15695445e-03f, -1.74188782e-02f, 7.10785314e-02f, -2.16627214e-02f, -1.39763793e-02f, 3.14272940e-02f, 1.65088437e-02f,
  5.17626479e-02f, -8.33205506e-03f, -1.00291774e-01f, 3.24191041e-02f, 9.48269814e-02f, 6.19442537e-02f, 5.76988719e-02f, -4.65225019e-02f, 6.12390488e-02f, 1.93255842e-02f,
  -3.94053273e-02f, 1.98686868e-01f, 7.79999420e-02f, -2.65130773e-02f, -1.05171092e-02f, 1.67756468e-01f, -1.65048894e-02f, -1.39655769e-02f, 1.33864865e-01f, 4.76234742e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.89290833e-01f, 1.52407125e-01f, -4.73672777e-01f, -5.88599406e-02f, 3.48502010e-01f, 1.88605294e-01f, 4.83102232e-01f, 7.49783069e-02f, 1.03773162e-01f, 1.87357247e-01f,
  1.05618015e-01f, 3.14540826e-02f, 5.35928793e-02f, 1.77006304e-01f, 1.30681381e-01f, 3.33719879e-01f, 2.25683808e-01f, -2.12747023e-01f, -4.94539179e-02f, 1.53975561e-01f,
  4.09574389e-01f, -1.58089757e-01f, -4.08291459e-01f, 4.06845249e-02f, -4.81862538e-02f, -5.34329340e-02f, 2.53918469e-02f, -1.97870540e-03f, 1.65594786e-01f, -1.00277871e-01f,
  -3.59891921e-01f, -1.65835351e-01f, 3.79059762e-02f, -3.90423462e-02f, -1.03537142e-01f, -2.02368826e-01f, 7.97532722e-02f, -1.81012586e-01f, -6.14238158e-02f, -9.49572474e-02f,
  -5.78829013e-02f, 5.42355999e-02f, 4.66629416e-02f, 7.56119797e-03f, -6.81936368e-02f, -7.25964233e-02f, -2.17658846e-04f, -2.19760895e-01f, -9.97370407e-02f, -2.41276860e-01f,
  3.20204645e-01f, 2.86581330e-02f, -2.67855942e-01f, 1.07167833e-01f, -4.51992676e-02f, -6.67705238e-02f, -1.79983914e-01f, -2.88562268e-01f, -3.17737758e-01f, -2.68097311e-01f,
  7.59225041e-02f, -3.82370353e-02f, 2.38275696e-02f, 2.58341394e-02f, -4.04510833e-02f, 3.89810205e-02f, -8.07739720e-02f, 1.18875124e-01f, 1.27569571e-01f, -2.59993989e-02f,
  -5.72357439e-02f, 9.21398923e-02f, -1.76264439e-02f, 3.57193835e-02f, -1.23968208e-02f, 6.94844425e-02f, 6.13380037e-02f, -1.14175066e-01f, -1.88928675e-02f, -6.88393638e-02f,
  -2.06791889e-02f, -1.13931887e-01f, -5.09143546e-02f, 1.12626068e-02f, -8.85084048e-02f, -2.54382826e-02f, 2.52848193e-02f, 3.77016366e-02f, 5.24289310e-02f, 6.90225437e-02f,
  -2.53158987e-01f, 2.62984723e-01f, -1.71248557e-03f, 8.56859609e-02f, 4.42827456e-02f, -8.71519372e-02f, 5.71056567e-02f, -1.41242780e-02f, -6.89664558e-02f, -3.31449211e-02f,
  5.34626096e-03f, -1.74122099e-02f, -7.79791549e-03f, -5.15159145e-02f, 3.69475000e-02f, -6.54629478e-03f, -2.29142532e-02f, -6.14801869e-02f, 5.45268022e-02f, -6.79313615e-02f,
  -4.35949489e-02f, 1.54507989e-02f, -4.00438644e-02f, -1.98534250e-01f, -7.24833459e-03f, -7.09932065e-03f, -5.65865003e-02f, -1.11290731e-01f, -1.90546051e-01f, 5.58192655e-03f,
  7.30177224e-01f, -6.97784424e-01f, 7.77418256e-01f, 4.39240485e-02f, -3.59935492e-01f, -3.54867578e-02f, -2.84706473e-01f, 4.52511050e-02f, 7.59402588e-02f, -9.20375362e-02f,
  -5.94306409e-01f, -4.12574470e-01f, -1.49375871e-01f, -7.89527074e-02f, 1.73326835e-01f, 2.26271719e-01f, 3.42634946e-01f, 5.86835623e-01f, 6.30703092e-01f, 1.85739130e-01f,
  -1.97448611e-01f, 8.78806263e-02f, 3.45870495e-01f, 1.82505310e-01f, 1.05041884e-01f, 6.05613478e-02f, 8.53754655e-02f, -1.55181840e-01f, -2.27151856e-01f, 2.69173831e-01f,
  2.03634262e-01f, -9.18467417e-02f, 1.72256261e-01f, -1.22646719e-01f, -9.96830165e-02f, 1.42993182e-01f, -4.22605500e-02f, 1.32064950e-02f, -1.20491900e-01f, 5.78186028e-02f,
  -8.34322944e-02f, -6.53860951e-03f, -3.43754441e-02f, -5.31900823e-02f, 3.69823202e-02f, 7.90238380e-02f, 7.14438930e-02f, 1.89781055e-01f, 1.26825750e-01f, -6.50859177e-02f,
  -3.22255850e-01f, -2.75935501e-01f, -7.15671182e-02f, -1.37672469e-01f, 9.60042328e-02f, -8.53633359e-02f, -1.61757052e-01f, 6.09935448e-02f, 3.37356217e-02f, 1.28252923e-01f,
  1.28794804e-01f, 4.64706533e-02f, -2.27411725e-02f, 8.32973607e-03f, -4.72270176e-02f, -6.84657022e-02f, -3.52564757e-03f, 2.67111436e-02f, -1.16069587e-02f, -2.50327308e-02f,
  -3.63737978e-02f, 8.76763277e-03f, -4.28949669e-02f, -1.42506547e-02f, -1.04781151e-01f, 2.01424938e-02f, 4.95827310e-02f, -4.37314156e-03f, -1.43106461e-01f, -6.45359457e-02f,
  1.45774540e-02f, 7.55343959e-02f, -1.27284331e-02f, -2.79584285e-02f, -8.21832046e-02f, -6.27400875e-02f, 1.55922338e-01f, -2.04990238e-01f, 7.33710751e-02f, -2.65412871e-02f,
  -3.63654971e-01f, -9.15368423e-02f, 1.46417677e-01f, 1.36222944e-01f, 4.79365923e-02f, -7.90973306e-02f, -5.12586869e-02f, -3.29477899e-02f, -1.17473438e-01f, 2.19961535e-02f,
  -8.04395750e-02f, 9.86747518e-02f, -5.92034124e-02f, 3.17206047e-02f, 3.23269106e-02f, -5.91063425e-02f, -1.65715471e-01f, 9.07642953e-03f, -6.85564578e-02f, -3.42366174e-02f,
  -2.18526106e-02f, 8.16438571e-02f, -1.15869708e-01f, -3.05024553e-02f, -1.94929484e-02f, 2.47206744e-02f, -1.76453814e-02f, 2.86975335e-02f, 3.46027724e-02f, 2.69659571e-02f,
  -1.28452349e+00f, 1.78488597e-01f, 2.90098816e-01f, -5.97346246e-01f, -8.93997401e-02f, 2.86379009e-01f, 4.87224817e-01f, -2.20489010e-01f, -4.21701461e-01f, -4.36769798e-02f,
  2.32833430e-01f, 9.46318805e-02f, 5.53552024e-02f, 1.55099183e-01f, 1.27878174e-01f, 2.81667113e-01f, 1.09843351e-02f, -9.51293781e-02f, 4.87124696e-02f, 2.07698345e-01f,
  -4.98349741e-02f, -3.65326077e-01f, -5.42360842e-01f, -2.90852726e-01f, -9.05938148e-02f, 9.53710228e-02f, 7.48749599e-02f, -5.60050085e-02f, 2.89310366e-01f, 9.41287652e-02f,
  4.68495488e-01f, -1.16239600e-01f, 6.84162676e-02f, -1.42412648e-01f, 4.21475768e-02f, -1.08688690e-01f, -7.35119358e-02f, -1.04587469e-02f, -8.67319107e-02f, 3.02092936e-02f,
  -2.80668084e-02f, -1.34045221e-02f, -9.17323902e-02f, 9.56450924e-02f, -4.76793088e-02f, 3.64097916e-02f, -1.39024317e-01f, 3.54669802e-02f, 1.72547698e-01f, 2.01290041e-01f,
  3.43962349e-02f, 2.69417316e-02f, 1.22709163e-01f, 1.03582926e-01f, 1.73112620e-02f, -1.41381204e-01f, 2.32414126e-01f, 3.82519551e-02f, 1.47664964e-01f, 4.32914943e-02f,
  -5.61947152e-02f, 3.32841687e-02f, -5.95419668e-03f, -1.45619633e-02f, -1.42826624e-02f, 5.50940819e-02f, 5.42955939e-03f, 1.19209841e-01f, 1.70708373e-02f, -1.55968294e-01f,
  -2.89436392e-02f, 2.69489121e-02f, 8.90795514e-02f, -9.44839492e-02f, -1.47257354e-02f, -2.38743331e-03f, -1.03477556e-02f, 2.48949863e-02f, 2.50631999e-02f, -5.81792071e-02f,
  -2.94261239e-02f, -4.61413413e-02f, -9.99835283e-02f, 8.06734785e-02f, 3.93132158e-02f, -4.46622670e-02f, -2.98247188e-02f, -1.81891222e-03f, -1.86768025e-02f, -1.19021200e-01f,
  1.06185324e-01f, 4.37251925e-02f, 7.04014748e-02f, -1.52276903e-02f, -1.17466394e-02f, -1.81966320e-01f, -4.96647693e-02f, -1.04100414e-01f, -2.14387234e-02f, -2.31818240e-02f,
  1.19355693e-01f, -4.16098461e-02f, 7.22325081e-03f, 2.56625861e-02f, -1.31863840e-02f, -2.82293255e-03f, -7.63338804e-02f, 1.98679008e-02f, 9.12844017e-02f, 1.03557043e-01f,
  -6.55252039e-02f, 2.64972374e-02f, 1.48178652e-01f, 4.54729311e-02f, -7.37927407e-02f, -2.08123326e-02f, 2.24331602e-01f, 1.01204343e-01f, 1.80697665e-01f, 1.03982210e-01f,
  9.27942812e-01f, 7.13347197e-02f, 1.75924003e-01f, 7.29341060e-02f, -2.46677309e-01f, -1.66580211e-02f, -8.38095397e-02f, 1.68353662e-01f, 1.86863959e-01f, 1.25695616e-01f,
  1.78179473e-01f, 2.50530601e-01f, 2.12191686e-01f, 7.18636587e-02f, 2.02380806e-01f, -4.06390242e-02f, -1.71601132e-01f, 7.39342719e-02f, 7.35417530e-02f, -8.19036588e-02f,
  -2.49618918e-01f, -5.91018833e-02f, 2.24652216e-01f, -3.51954512e-02f, -1.75515711e-01f, 3.55434306e-02f, -1.51244536e-01f, -2.30682135e-01f, -8.91204104e-02f, -1.75771028e-01f,
  7.05503970e-02f, 4.10205901e-01f, 6.45071715e-02f, 1.20948829e-01f, -4.03943732e-02f, 1.42799512e-01f, 1.29901096e-01f, 8.74362290e-02f, -4.86063622e-02f, 5.89763857e-02f,
  2.60182209e-02f, 2.25500837e-02f, -5.42560518e-02f, -9.86463279e-02f, -6.40880018e-02f, 1.20453991e-01f, 2.33358555e-02f, 5.86265028e-02f, 5.35791814e-02f, 4.30719033e-02f,
  -1.14440382e-01f, 1.19676664e-01f, 8.00851956e-02f, 2.66641146e-03f, 1.34645239e-01f, 5.07001095e-02f, 4.25099432e-02f, 1.76757365e-01f, 1.39147684e-01f, 2.60433316e-01f,
  -1.70632377e-02f, -4.67014499e-02f, 1.20961983e-02f, -4.05262923e-03f, -1.06896617e-01f, -2.06555217e-03f, -6.45810440e-02f, -9.18207765e-02f, -5.48652112e-02f, 1.52847059e-02f,
  9.00933519e-02f, 8.17131177e-02f, -4.95889299e-02f, 6.04123436e-02f, -8.02303702e-02f, -1.43836766e-01f, -2.91278847e-02f, 1.14468765e-03f, -7.80813545e-02f, 9.13368538e-02f,
  -8.27934872e-03f, -3.45775448e-02f, -4.41085696e-02f, -7.82115608e-02f, 1.57072052e-01f, 1.61462486e-01f, 4.09427918e-02f, -4.37391698e-02f, 4.29863259e-02f, 3.07202060e-02f,
  -2.94304490e-01f, 1.18794106e-01f, 3.26918699e-02f, 2.71902159e-02f, 2.69422289e-02f, 4.34304141e-02f, 1.44309429e-02f, -5.89606278e-02f, -5.24807237e-02f, 5.71019985e-02f,
  9.02413800e-02f, 5.30516915e-03f, 5.85923232e-02f, -6.85806051e-02f, -1.00620702e-01f, 2.39661150e-02f, -1.89365968e-02f, -1.93234459e-02f, -1.07930703e-02f, 8.20060540e-03f,
  -1.27938651e-02f, 1.48483794e-02f, 5.02075441e-02f, 4.95875366e-02f, -1.30475350e-02f, 6.50629699e-02f, -6.59832284e-02f, 5.13515435e-02f, 1.39229804e-01f, 3.74852344e-02f,
  -8.67474496e-01f, -2.60235846e-01f, 3.87414917e-02f, -2.61479855e-01f, 8.76222327e-02f, 3.80976945e-02f, -3.09087455e-01f, 1.44690782e-01f, 7.39761218e-02f, -3.04153293e-01f,
  -1.72333330e-01f, -3.63373637e-01f, -4.88996118e-01f, -1.67252675e-01f, -4.48831201e-01f, -5.89324176e-01f, -4.39831018e-01f, -3.28474224e-01f, 5.87660521e-02f, 4.49038625e-01f,
  2.71251410e-01f, -4.27495502e-02f, 4.31404747e-02f, 3.62966478e-01f, -4.70230076e-03f, -3.12335700e-01f, -1.25543058e-01f, -2.18166038e-01f, -1.60986140e-01f, -7.04086900e-01f,
  -3.40132803e-01f, 2.18305588e-01f, 1.00881927e-01f, -6.98267668e-02f, 2.62224097e-02f, 1.53897390e-01f, -1.16213776e-01f, -1.00401141e-01f, 3.59831303e-02f, -3.91312875e-02f,
  -1.19657747e-01f, 1.79150671e-01f, -4.01546657e-02f, 9.56730843e-02f, -6.29720986e-02f, 7.68013252e-03f, 9.20830108e-03f, 1.42299846e-01f, 3.81992906e-02f, 1.70083642e-01f,
  2.95551363e-02f, 1.55494493e-02f, -1.95758596e-01f, 1.01172633e-01f, 3.44974190e-01f, 1.47842392e-01f, 2.77806997e-01f, 2.85905153e-01f, 2.61986524e-01f, -1.64106727e-01f,
  8.40532854e-02f, -1.40220700e-02f, 2.50857584e-02f, 4.41334732e-02f, -1.47617632e-03f, 4.56987359e-02f, 7.56165162e-02f, -8.63816589e-02f, 3.51207443e-02f, -9.59785879e-02f,
  2.06910700e-01f, -3.45660485e-02f, 7.16534108e-02f, -9.63250846e-02f, 5.08182049e-02f, -7.96720684e-02f, -7.18714017e-03f, 1.82605386e-02f, 2.10784078e-02f, -1.06675491e-01f,
  -1.17915161e-01f, 1.25501037e-01f, -2.39734612e-02f, 1.04410321e-01f, -5.10598086e-02f, -2.70465352e-02f, -2.35803761e-02f, 7.36815706e-02f, 8.15600380e-02f, -1.77781042e-02f,
  -4.18432832e-01f, -1.73203852e-02f, -3.96707594e-01f, 3.06910593e-02f, -8.00972804e-04f, 1.09324478e-01f, -7.00869858e-02f, 1.58969790e-01f, -2.13552624e-01f, -4.44173329e-02f,
  9.33690444e-02f, -1.07562609e-01f, -1.47813082e-01f, 7.23338798e-02f, -9.61330086e-02f, 7.33188391e-02f, 6.59884587e-02f, -1.55368358e-01f, 3.68674286e-02f, -2.76592071e-03f,
  6.64156023e-03f, -1.41146913e-01f, -4.84251559e-01f, -2.94008851e-01f, -3.97181958e-02f, -3.98429722e-01f, -2.96049207e-01f, 2.52867490e-02f, -3.18824738e-01f, -4.55736816e-01f,
  6.87733114e-01f, 3.65267247e-01f, 2.81987160e-01f, 5.53972907e-02f, 1.06790334e-01f, 2.87111700e-01f, 5.39088547e-01f, 2.59858340e-01f, -1.02691494e-01f, 3.37024294e-02f,
  5.45323975e-02f, -2.28212401e-01f, -1.65902704e-01f, -3.25948954e-01f, 1.50151685e-01f, 1.54955626e-01f, 6.83504641e-02f, 8.89606252e-02f, 6.35314882e-02f, -5.43560274e-02f,
  -1.33815527e-01f, 1.13449641e-01f, 1.08763844e-01f, 4.62558679e-02f, -1.00371957e-01f, -2.29484633e-01f, -3.53858396e-02f, 2.05761701e-01f, -2.42818873e-02f, -1.81214325e-02f,
  1.69194639e-01f, 5.22313654e-01f, -1.16418205e-01f, -6.70870021e-02f, 1.60037912e-02f, -4.96928068e-03f, 2.88092587e-02f, 2.03179233e-02f, -2.71984041e-02f, 4.41163406e-02f,
  -3.80406268e-02f, -7.77566060e-02f, 1.65535510e-02f, -1.29884154e-01f, 1.12063466e-02f, 2.64981482e-02f, -5.44606820e-02f, 1.63775504e-01f, -1.02703065e-01f, -1.96025819e-02f,
  -4.19408642e-02f, 7.78543130e-02f, 2.47416377e-01f, -6.45973906e-02f, -1.11091537e-02f, -1.35062829e-01f, 1.87324762e-01f, -3.61314835e-03f, 8.49588662e-02f, -1.10531393e-02f,
  -4.68130037e-02f, 1.49969785e-02f, -1.71672761e-01f, 6.06886446e-02f, -1.95878781e-02f, -9.06496942e-02f, -2.09127981e-02f, -2.78237928e-02f, -9.68096331e-02f, 3.14869992e-02f,
  -5.82199730e-03f, 3.17472480e-02f, -5.61354868e-02f, 1.41007438e-01f, -8.18547830e-02f, -5.75097883e-03f, 3.33687179e-02f, -5.75138852e-02f, -2.40326039e-02f, -8.49477053e-02f,
  -5.44912480e-02f, -4.68022227e-02f, -4.14359272e-02f, 2.56265998e-02f, 9.45520103e-02f, 2.44654026e-02f, -7.88497254e-02f, 1.24393962e-01f, 6.25045002e-02f, 1.62879098e-02f,
  -4.97976452e-01f, -7.63008222e-02f, -4.84948680e-02f, -7.81079009e-02f, -4.20268662e-02f, -1.11824051e-01f, -1.76311970e-01f, -8.56046751e-02f, -8.64481553e-02f, 3.55786607e-02f,
  1.31277904e-01f, 2.12716521e-03f, -6.93693608e-02f, -5.79975508e-02f, -8.32004696e-02f, -1.11481503e-01f, -1.33989543e-01f, -5.52851595e-02f, -1.57044828e-01f, 3.07985097e-02f,
  -5.57935424e-02f, -1.01077326e-01f, -1.62993759e-01f, -6.02669194e-02f, -7.78237954e-02f, -3.05343091e-01f, -8.93345177e-02f, -2.48173773e-02f, -7.40902871e-02f, -2.08871260e-01f,
  1.95234567e-01f, 1.51623618e-02f, -2.05131799e-01f, 4.30053741e-01f, 2.84431547e-01f, -2.08072495e-02f, 3.09468746e-01f, 2.53859967e-01f, 1.74711287e-01f, 1.17772847e-01f,
  -3.98000032e-01f, -4.56448197e-01f, -5.38979292e-01f, -3.28868359e-01f, -1.89251110e-01f, 3.29441875e-01f, 3.99087220e-01f, -1.32840276e-01f, -8.35856870e-02f, 9.18014944e-02f,
  1.94801986e-01f, 2.57847875e-01f, -9.85180736e-02f, -9.77655500e-02f, -1.93156134e-02f, -2.31824610e-02f, -3.38787697e-02f, -1.61893174e-01f, -1.29373401e-01f, -5.16524240e-02f,
  -2.72954106e-01f, -3.20299983e-01f, 8.62549543e-02f, -4.90279347e-02f, -9.89111699e-03f, 1.48452416e-01f, 4.86215241e-02f, -3.77668403e-02f, 6.58634258e-03f, 1.36793643e-01f,
  7.26758852e-04f, -1.23885512e-01f, -4.00799736e-02f, -9.28593352e-02f, 8.48093554e-02f, -1.04118302e-01f, -2.87673734e-02f, -1.06653892e-01f, -6.38221651e-02f, -7.16232583e-02f,
  -3.99048738e-02f, -8.51935521e-02f, -5.69248348e-02f, 2.62451340e-02f, -6.44217059e-02f, -1.62486911e-01f, -1.07764892e-01f, -9.22269151e-02f, -1.82339326e-01f, -9.06326808e-04f,
  -1.58448759e-02f, 1.93710644e-02f, -1.72403064e-02f, 3.85935716e-02f, 5.58393495e-03f, 5.10460213e-02f, 3.66473794e-02f, 4.39337753e-02f, 3.31197940e-02f, 1.72984984e-03f,
  1.67794712e-02f, -2.73698606e-02f, 4.79947105e-02f, 2.01705191e-02f, -3.76673862e-02f, -6.33705556e-02f, 1.52354566e-02f, -2.74065213e-04f, -7.97908530e-02f, -9.65109840e-03f,
  -1.49525674e-02f, 6.01856522e-02f, 5.41565083e-02f, -3.12695242e-02f, -4.04108204e-02f, -1.18701532e-01f, -1.04357734e-01f, -1.57134622e-01f, 1.50005836e-02f, 7.40569010e-02f,
  1.52426613e-02f, -3.78913224e-01f, 1.46101698e-01f, -6.57594875e-02f, 8.29506258e-04f, -5.75611666e-02f, -6.17396347e-02f, -1.47884553e-02f, 6.53675348e-02f, -5.31873405e-02f,
  -1.02757558e-01f, -7.71127781e-03f, -1.99274905e-02f, 5.73710501e-02f, 9.15408954e-02f, -2.54873820e-02f, 1.26343504e-01f, 9.10318550e-03f, -9.22077987e-03f, 1.23407044e-01f,
  2.56088942e-01f, 1.93552956e-01f, 1.41896114e-01f, 6.40583560e-02f, 2.11026162e-01f, 1.64269999e-01f, 1.31900266e-01f, 8.57370645e-02f, 1.31837679e-02f, 4.93025273e-01f,
  1.19113684e+00f, -5.59318483e-01f, -6.57160401e-01f, 1.20544799e-01f, -3.05930197e-01f, 1.25861928e-01f, -1.06159732e-01f, 1.00198470e-01f, 4.37603593e-02f, -4.46339369e-01f,
  -3.48496139e-02f, 3.74608636e-01f, 4.20190580e-02f, 1.11408919e-01f, 5.08135080e-01f, -4.01437759e-01f, -5.26535153e-01f, 7.45328236e-03f, 5.35579205e-01f, 3.07022542e-01f,
  -1.74173880e-02f, 9.91961509e-02f, 3.13706428e-01f, 1.36261759e-02f, -3.14362615e-01f, -1.27161384e-01f, -6.10238552e-01f, -2.72797495e-01f, -2.19247952e-01f, -5.29473066e-01f,
  -5.39737605e-02f, -1.79057613e-01f, 9.29862410e-02f, 1.14611633e-01f, -2.41060078e-01f, 7.57282600e-02f, 7.03349337e-02f, -1.49831414e-01f, -9.20668468e-02f, -7.88743049e-02f,
  -8.75998661e-02f, 4.57110442e-02f, 4.07213010e-02f, -6.89646453e-02f, 4.54266369e-02f, 1.26270920e-01f, -5.65198772e-02f, 2.37652827e-02f, 6.17849380e-02f, -8.43054205e-02f,
  -1.13173030e-01f, -7.21502081e-02f, 3.20865028e-02f, -5.32472953e-02f, -4.40861546e-02f, -1.17027782e-01f, -2.25832798e-02f, 4.32473188e-03f, -9.93213132e-02f, -3.04610103e-01f,
  6.84883771e-03f, -2.59022564e-02f, 1.90270822e-02f, -4.59981337e-02f, 1.33176580e-01f, -3.16095874e-02f, 2.38159625e-03f, 7.30391443e-02f, 1.27702743e-01f, -3.24010924e-02f,
  -3.05172019e-02f, -3.39022465e-02f, 7.85602406e-02f, -8.96039326e-03f, 3.30796055e-02f, 8.46741199e-02f, 8.31947327e-02f, -4.63490793e-03f, -3.20526920e-02f, 9.37976092e-02f,
  1.81953847e-01f, -4.11149450e-02f, -7.58474022e-02f, -3.52489240e-02f, -6.32600039e-02f, -5.70469275e-02f, -1.88277774e-02f, -3.88657296e-04f, -4.80974419e-03f, -4.44708765e-02f,
  1.60322219e-01f, -2.49918899e-03f, -4.14792262e-03f, 1.34936824e-01f, -1.22066364e-01f, -1.23649254e-01f, -1.62090302e-01f, -6.25849813e-02f, -6.71373233e-02f, 3.91166378e-03f,
  6.06330745e-02f, 1.06097728e-01f, -1.19555891e-01f, -7.22644255e-02f, 7.81241506e-02f, 2.73911785e-02f, -6.21341728e-02f, 1.05880842e-01f, 1.64761782e-01f, -1.17124626e-02f,
  -1.41372189e-01f, 1.26727596e-01f, 3.25315952e-01f, 1.11663111e-01f, -2.90531083e-03f, 2.37834945e-01f, 4.39842045e-02f, 1.01233102e-01f, 2.11683095e-01f, 1.54853277e-02f,
  8.52303922e-01f, 6.23350084e-01f, 1.05419151e-01f, 2.43008524e-01f, 2.41368160e-01f, 6.42257035e-02f, 1.16974905e-01f, -2.35708252e-01f, -8.42560008e-02f, 8.27540457e-02f,
  2.26052165e-01f, -8.25515762e-02f, -1.84253871e-01f, -2.26153001e-01f, -1.51142061e-01f, -1.07324548e-01f, -7.19119981e-02f, 8.20818171e-02f, -1.45047277e-01f, 1.64895013e-01f,
  1.54411793e-01f, 2.49432147e-01f, 8.42726752e-02f, -4.45789890e-03f, 2.30115369e-01f, -1.82907164e-01f, -8.52108002e-02f, 3.07498038e-01f, 1.85534582e-01f, 3.81508410e-01f,
  2.69599825e-01f, 4.03509170e-01f, -4.16802853e-01f, 7.04677776e-02f, 9.98910144e-02f, -6.69509470e-02f, -6.14122562e-02f, -1.05634496e-01f, -7.94904828e-02f, -1.35400817e-01f,
  1.01402618e-01f, 1.32816091e-01f, 1.25506371e-01f, 1.64216571e-02f, 5.60284741e-02f, -1.40398741e-02f, 1.10485494e-01f, 2.04058085e-02f, 1.34114847e-02f, 1.00652628e-01f,
  2.35776380e-01f, 2.73565054e-01f, -7.32893869e-02f, -1.32959619e-01f, 4.72266823e-02f, 4.96437028e-02f, 1.41267598e-01f, 7.59337991e-02f, -1.19068176e-01f, 1.43962577e-01f,
  -2.97197588e-02f, 1.30762696e-01f, 8.58374387e-02f, 5.09658717e-02f, 3.32501531e-02f, -4.68984693e-02f, 4.36830185e-02f, -2.91651450e-02f, -2.92648077e-02f, 7.45314360e-02f,
  -7.16008320e-02f, 1.28890991e-01f, -1.38931582e-02f, -1.13702185e-01f, -1.96876694e-02f, 2.18679309e-01f, -1.11809885e-02f, 6.49740873e-03f, 6.20015971e-02f, -3.90668102e-02f,
  4.81693596e-02f, -2.57043689e-02f, 4.92925122e-02f, -6.66757077e-02f, 1.83871947e-02f, 1.18710427e-02f, 8.49636942e-02f, 1.74742453e-02f, 6.88066110e-02f, 1.89342216e-01f,
  -6.61480546e-01f, -2.80695587e-01f, 7.23451301e-02f, -6.97653070e-02f, 6.83740824e-02f, 9.57330167e-02f, 1.66837662e-01f, -6.31474108e-02f, -5.08600213e-02f, -1.24149613e-01f,
  1.15272694e-03f, -4.42067683e-02f, 3.23404297e-02f, 4.90663573e-02f, -3.20760608e-02f, -5.41622415e-02f, 7.30132237e-02f, -9.04044658e-02f, -1.15531720e-01f, -1.84066594e-02f,
  6.68308064e-02f, -1.06591083e-01f, -4.34281230e-01f, -3.54819179e-01f, -3.18819694e-02f, -2.90166944e-01f, -1.70387492e-01f, -1.19694017e-01f, -3.56340468e-01f, -2.78872460e-01f,
  3.61488819e-01f, -4.02529567e-01f, 4.43325609e-01f, 3.28103065e-01f, 4.73570824e-01f, 6.30627215e-01f, 6.35108709e-01f, 3.22802514e-01f, 8.39413553e-02f, -1.68311242e-02f,
  -1.14072762e-01f, -2.34037682e-01f, -1.70409918e-01f, -2.69063234e-01f, 7.82148447e-03f, 2.30846018e-01f, 2.46025309e-01f, -7.93868955e-03f, 2.66212165e-01f, 1.75990045e-01f,
  -1.62010342e-02f, -2.63170376e-02f, -4.90420498e-02f, -1.05834775e-01f, -7.17972070e-02f, -1.90968085e-02f, 1.01184987e-01f, 1.13257974e-01f, -8.38149413e-02f, -1.25901833e-01f,
  5.18456893e-03f, 1.10822722e-01f, 2.38912161e-02f, -2.70994842e-01f, -5.61281145e-02f, -8.24068189e-02f, 1.11325430e-02f, -8.32682103e-02f, 9.80161782e-03f, -5.29785156e-02f,
  -1.59629900e-02f, 3.61133926e-02f, 1.34798214e-01f, 6.38855919e-02f, 1.00426972e-01f, -3.52813415e-02f, -5.03669158e-02f, -5.34451306e-02f, 1.26050916e-02f, -1.23132631e-01f,
  -1.20017797e-01f, 5.61186522e-02f, 8.14333633e-02f, 8.50059018e-02f, 1.16587974e-01f, 3.90378051e-02f, -1.50311559e-01f, -5.57091385e-02f, 1.50092617e-02f, -2.00692266e-01f,
  -3.11741466e-03f, -6.31504059e-02f, 1.99625045e-02f, 1.07344659e-02f, -6.51740953e-02f, 3.68824489e-02f, 1.41769871e-01f, 2.35363506e-02f, 4.47315536e-02f, 1.26987267e-02f,
  7.54825538e-03f, 6.37461692e-02f, 8.40658322e-02f, 8.26976970e-02f, -9.77814794e-02f, 7.00712204e-02f, 1.32993519e-01f, -9.88412574e-02f, -7.30506107e-02f, 5.47168851e-02f,
  -7.15503395e-02f, 7.89941177e-02f, 5.42180752e-03f, -6.86701164e-02f, -5.71120083e-02f, -4.86848988e-02f, 3.63498665e-02f, -1.14748433e-01f, -1.06074892e-01f, -3.65494308e-03f,
  -1.18402489e-01f, 2.74475545e-01f, 1.58098698e-01f, -8.67590830e-02f, 1.34703398e-01f, -5.63585432e-03f, 1.15052737e-01f, -1.99276179e-01f, -3.00698336e-02f, 4.46903929e-02f,
  -6.05940027e-03f, 2.68947463e-02f, 6.54008687e-02f, 1.38950080e-03f, 1.74381956e-01f, 5.73715679e-02f, -1.60533339e-01f, 2.92771142e-02f, 2.78919358e-02f, -6.86962530e-02f,
  -9.43487659e-02f, 3.56153771e-02f, 5.26312143e-02f, 1.04440697e-01f, 5.74425757e-02f, 8.75249952e-02f, 3.90874073e-02f, -3.43088270e-03f, 1.52430817e-01f, -1.10879414e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.16775979e-02f, 3.85963112e-01f, 2.71731336e-02f, 2.69183636e-01f, 2.12383822e-01f, -1.92431778e-01f, 2.62231052e-01f, 5.82465827e-01f, 2.90467709e-01f, 5.92673272e-02f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -8.32662061e-02f, 1.43532932e-01f, 4.31142539e-01f, -1.65053144e-01f, 2.93110430e-01f, -3.15574706e-02f, 3.64838302e-01f, 7.41430894e-02f, 5.57735205e-01f, -2.53010273e-01f,
  -1.26054706e-02f, -5.31175077e-01f, 4.91798043e-01f, -1.06993251e-01f, -4.82136086e-02f, 5.43514416e-02f, -2.15602264e-01f, 4.67886254e-02f, 1.10645145e-01f, 9.35691744e-02f,
  2.24824816e-01f, -1.23397827e-01f, 7.31225073e-01f, 3.35008139e-03f, 2.58468866e-01f, -1.94831401e-01f, -1.55040756e-01f, -5.55686116e-01f, 2.13541657e-01f, -2.33732745e-01f,
  2.27156524e-02f, -2.66192079e-01f, 3.84008549e-02f, 2.23715290e-01f, 2.12491632e-01f, -4.18192856e-02f, -1.97481713e-03f, -1.45770609e-01f, -5.93713462e-01f, -2.35029966e-01f,
  3.46120507e-01f, 4.20926977e-03f, -3.48042309e-01f, 9.98704955e-02f, -1.77981749e-01f, 1.58360869e-01f, 4.33065265e-01f, 1.07277855e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.48922068e-01f, 1.73702851e-01f, 1.48002401e-01f, 1.23933010e-01f, 3.40234727e-01f, 4.15996581e-01f, 5.26390690e-03f, 4.24930274e-01f, -4.32308555e-01f, -7.06548095e-02f,
  -1.08057879e-01f, 2.63102427e-02f, 2.81337559e-01f, 6.71310902e-01f, 3.36400419e-01f, 3.13608021e-01f, 4.02477324e-01f, -1.99729964e-01f, 2.29733228e-03f, 2.48034209e-01f,
  -1.75390646e-01f, 4.23041254e-01f, 6.35008335e-01f, -1.37978554e-01f, -9.72354785e-02f, 2.97795087e-01f, 7.98813939e-01f, 2.84110546e-01f, -4.87537324e-01f, 3.68449658e-01f,
  1.11589581e-01f, 1.28936069e-02f, 7.09293112e-02f, 4.46548283e-01f, 3.36037844e-01f, -2.68940091e-01f, -4.57556665e-01f, 1.00291230e-01f, 6.96782321e-02f, -3.88604663e-02f,
  3.22153956e-01f, -1.25859126e-01f, 6.73686922e-01f, -3.57781887e-01f, 1.79152310e-01f, 1.96270734e-01f, 4.32626605e-02f, -9.05319691e-01f, -1.25311121e-01f, 4.61761385e-01f,
  2.97951430e-01f, 3.50241542e-01f, -5.85257649e-01f, -8.54898214e-01f, -4.04815488e-02f, 5.14642119e-01f, -6.15724802e-01f, -2.62822390e-01f, 2.76404649e-01f, -3.19125563e-01f,
  -1.20077960e-01f, -4.25139904e-01f, 4.49795097e-01f, -5.65325499e-01f, 9.69598591e-01f, 1.05616480e-01f, 4.35589731e-01f, -1.55431017e-01f, 1.74349397e-01f, 3.67198847e-02f,
  3.37165654e-01f, 5.11261746e-02f, -2.11652488e-01f, -2.47967124e-01f, -2.97574073e-01f, 3.62308919e-01f, 5.89570820e-01f, -3.29231955e-02f, -1.64054722e-01f, 3.37037623e-01f,
  -5.30145049e-01f, -1.22797014e-02f, -1.77236497e-01f, -1.43249659e-02f, -1.48151591e-01f, 2.67152667e-01f, 4.15876150e-01f, 7.55187497e-02f, 4.41210181e-01f, -2.25945085e-01f,
  3.65121253e-02f, -2.43539289e-01f, 3.08884978e-01f, -1.80456653e-01f, -3.47060680e-01f, 1.72728702e-01f, 4.51822579e-01f, 1.69640720e-01f, 5.36385417e-01f, -5.21512866e-01f,
  2.59445161e-01f, 7.45511532e-01f, 7.94425666e-01f, -6.64126694e-01f, -1.19477600e-01f, -1.36516482e-01f, 5.39262414e-01f, 3.23935628e-01f, 3.30046356e-01f, 6.59404516e-01f,
  2.88321912e-01f, 4.23880108e-02f, 1.69613197e-01f, 4.74948764e-01f, 1.82936221e-01f, 4.25497681e-01f, 1.65683348e-02f, 6.47145361e-02f, -4.21928644e-01f, 9.84450996e-01f,
  -4.46202040e-01f, 2.45075479e-01f, 5.82170784e-02f, 1.37909614e-02f, 5.49806893e-01f, 6.82938278e-01f, -8.03135708e-02f, 2.42527246e-01f, -5.26916832e-02f, 3.77577126e-01f,
  7.42327511e-01f, 1.29645050e-01f, -3.25369477e-01f, -1.40888363e-01f, -1.49382085e-01f, -2.96439175e-02f, 4.33371961e-01f, -3.71293128e-01f, -2.81047016e-01f, 3.97851765e-01f,
  -5.77503681e-01f, 2.73170948e-01f, 8.02585483e-01f, -1.05383201e-02f, 2.56296962e-01f, 4.78808343e-01f, 2.07024008e-01f, -6.71009347e-03f, -2.79684186e-01f, -2.47645006e-01f,
  -3.29741836e-01f, 8.00348759e-01f, -5.32478988e-01f, -7.36271143e-02f, -3.53330858e-02f, 8.22948664e-02f, 5.53175472e-02f, 7.84050941e-01f, 5.76409042e-01f, 2.26936296e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.32723677e-01f, 1.38061643e-01f, 6.69418097e-01f, 2.79735774e-01f, 2.22533762e-01f, 1.69731021e-01f, 2.77179688e-01f, 4.08702791e-01f, 4.42030430e-01f, 6.61782861e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.37253513e-02f, 4.59855109e-01f, 4.81624484e-01f, 1.41307473e-01f, 3.83866400e-01f, -3.82335931e-01f, 1.33574372e-02f, -1.71347961e-01f, 3.11644912e-01f, 2.81409808e-02f,
  6.09587021e-02f, -9.88312364e-02f, 1.34298652e-01f, -2.38250583e-01f, -9.04117245e-03f, -6.41923249e-02f, 1.73383802e-01f, 3.12264115e-01f, 5.83589554e-01f, 4.58133012e-01f,
  -1.81070358e-01f, -2.29293332e-01f, 1.08237766e-01f, -9.46883559e-02f, -1.91895142e-01f, -3.84205103e-01f, 2.14391440e-01f, 3.76514226e-01f, -1.60160393e-01f, 2.55563319e-01f,
  -3.51594329e-01f, -1.54066935e-01f, 2.02384681e-01f, -1.31816998e-01f, -3.03439766e-01f, 1.04808705e-02f, -5.35563469e-01f, 2.07636610e-01f, 2.28051603e-01f, -9.77181364e-03f,
  -2.72584856e-01f, 9.96363815e-03f, 2.52128597e-02f, -1.75737098e-01f, -1.89921528e-01f, -9.15024877e-02f, 3.50779563e-01f, 1.96564451e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  6.20237887e-01f, 5.11638165e-01f, 2.98028618e-01f, -9.19939801e-02f, 4.62050319e-01f, -2.86695421e-01f, -6.32643476e-02f, 7.97222912e-01f, 9.48331714e-01f, -5.96243590e-02f,
  -4.09522682e-01f, -4.93189059e-02f, 3.68919075e-01f, -1.19680399e-02f, 1.27347205e-02f, 3.72578539e-02f, 5.35116941e-02f, 7.48937547e-01f, 6.17228150e-01f, 3.02423328e-01f,
  -1.35777280e-01f, -3.88098598e-01f, 1.93400532e-01f, -1.30889907e-01f, 4.46294509e-02f, 1.07064021e+00f, -1.09950162e-01f, 8.17100331e-02f, -4.62588817e-01f, 5.34084439e-01f,
  1.48742214e-01f, 4.78826344e-01f, 8.23466063e-01f, 4.85148489e-01f, 7.52052426e-01f, 2.14681223e-01f, -3.30277592e-01f, -3.81830662e-01f, 3.40702146e-01f, 4.25945483e-02f,
  3.50014150e-01f, 2.45017022e-01f, -4.79199225e-03f, -8.73804748e-01f, 4.16107476e-01f, 5.28574049e-01f, -5.71817458e-01f, 6.81425095e-01f, 8.79216716e-02f, 8.29265416e-01f,
  8.35381627e-01f, 8.25576663e-01f, 1.02682376e+00f, 4.36706364e-01f, -3.15820992e-01f, -1.67660415e-01f, 7.71827340e-01f, 5.08248448e-01f, 2.28035048e-01f, 1.56499997e-01f,
  3.95294845e-01f, -5.79997540e-01f, 4.88669276e-01f, 3.78794186e-02f, -5.56875765e-01f, 2.38449633e-01f, 2.58473188e-01f, 1.37596413e-01f, 2.03495726e-01f, -1.05406344e-01f,
  2.33126447e-01f, -3.65942456e-02f, -9.33844745e-02f, -5.68129793e-02f, 6.00822866e-01f, 6.82643294e-01f, 3.83393288e-01f, 2.85002321e-01f, -2.82037944e-01f, 1.76450744e-01f,
  -3.47341388e-01f, -1.20472834e-01f, -5.01493335e-01f, -3.67700644e-02f, -7.08858147e-02f, 6.81221426e-01f, 1.91264078e-01f, -1.18627108e-03f, -3.64663340e-02f, 4.73384142e-01f,
  4.61089581e-01f, 1.77386388e-01f, 4.99507636e-01f, -3.04328301e-03f, 1.04324865e+00f, 5.30992329e-01f, 2.44837731e-01f, -3.07311323e-02f, 9.66000408e-02f, -4.85972464e-01f,
  -1.38595283e-01f, 5.65451682e-01f, 4.35942411e-01f, 9.09053162e-02f, -1.61840349e-01f, 5.08224905e-01f, 1.11098878e-01f, -2.24867612e-01f, 1.87734857e-01f, 4.19155031e-01f,
  6.62513018e-01f, 6.45709813e-01f, -2.43190333e-01f, -4.86389756e-01f, -2.01478768e-02f, -3.48457336e-01f, 4.85619530e-02f, -9.66556743e-03f, 6.07204139e-01f, 3.42443883e-01f,
  -2.07612321e-01f, -1.55593050e+00f, 3.05183172e-01f, 1.36994168e-01f, 5.03596902e-01f, 2.22134233e-01f, -1.18148774e-01f, 5.62351406e-01f, 1.98761132e-02f, 1.61872819e-01f,
  4.83697146e-01f, 6.60091639e-01f, -3.36405933e-01f, -4.75943118e-01f, 5.19650221e-01f, -2.05105901e-01f, 2.43967116e-01f, -6.56455755e-01f, 6.93506300e-01f, 6.51849359e-02f,
  4.99171734e-01f, 1.04800008e-01f, -6.84707165e-01f, 1.39399782e-01f, -4.91959639e-02f, -2.92052686e-01f, -3.19475859e-01f, 1.22376293e-01f, 5.03244460e-01f, -3.83140057e-01f,
  3.47713679e-01f, 1.72557265e-01f, 4.25786406e-01f, -3.01366001e-01f, 6.86331868e-01f, 9.67690825e-01f, 6.66901767e-01f, -2.43985280e-01f, 5.79544485e-01f, -3.53450291e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  2.47863799e-01f, 3.12848121e-01f, 2.35246673e-01f, 3.47657919e-01f, 2.13542461e-01f, 2.84018844e-01f, 2.44189814e-01f, -1.01353422e-01f, -5.88740334e-02f, 2.59491742e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  5.73176086e-01f, 2.05186754e-01f, 3.66435826e-01f, -5.06081581e-02f, 6.74096644e-01f, -1.90214574e-01f, 2.56585628e-01f, -3.35509241e-01f, 3.02946866e-01f, -4.68727760e-02f,
  -1.69662699e-01f, -8.17680135e-02f, -1.81903049e-01f, 1.52555674e-01f, -1.42662004e-01f, -8.46260637e-02f, 3.59989673e-01f, -3.74039263e-01f, -1.77790940e-01f, 1.57839313e-01f,
  1.07909761e-01f, 8.38610083e-02f, -2.11293012e-01f, -2.67935574e-01f, -1.46508947e-01f, 2.49597818e-01f, 3.67923260e-01f, 2.30847985e-01f, -9.70289409e-02f, -3.92878428e-02f,
  2.52242208e-01f, -1.25720397e-01f, -6.58564746e-01f, 1.31102949e-01f, -3.92614782e-01f, 1.91629738e-01f, -5.82132459e-01f, 1.64948940e-01f, -3.21062505e-01f, -2.92146895e-02f,
  -1.25280544e-01f, 3.30727212e-02f, 2.77985744e-02f, 2.14786544e-01f, 1.74319908e-01f, -8.48793145e-03f, -3.79207492e-01f, 7.95700997e-02f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  6.66847706e-01f, 4.86801267e-01f, 9.44267027e-03f, 2.79873818e-01f, -3.90905201e-01f, 6.54784739e-01f, 8.37884903e-01f, -3.82699251e-01f, -4.62805256e-02f, 1.39116824e+00f,
  -1.80811107e-01f, 3.90575349e-01f, -1.96393114e-02f, 4.56977710e-02f, 4.17538546e-02f, 7.52260268e-01f, 8.81243497e-02f, -1.89259909e-02f, -1.23857796e-01f, 6.76415324e-01f,
  3.58779013e-01f, -9.40129995e-01f, 2.28555165e-02f, 2.83279251e-02f, 6.42670512e-01f, -2.83916877e-03f, 4.58715081e-01f, 1.92265434e-03f, -1.01079971e-01f, 1.17955752e-01f,
  8.38003278e-01f, 3.67100149e-01f, -1.69388875e-01f, 3.16882581e-01f, -5.80358744e-01f, -5.97811937e-01f, -4.69611168e-01f, 5.14239848e-01f, 2.20362529e-01f, 3.24847311e-01f,
  3.15892071e-01f, -8.83946657e-01f, -1.84371918e-01f, 4.74016130e-01f, 5.18369377e-01f, 3.27514917e-01f, -3.47532958e-01f, -2.31828496e-01f, -5.24659395e-01f, -2.23694846e-01f,
  -4.64271009e-01f, -6.19589329e-01f, -6.25674844e-01f, -1.27731254e-02f, 2.82075822e-01f, -1.78453907e-01f, 1.28273979e-01f, -6.76615298e-01f, -3.44022959e-02f, 1.51060835e-01f,
  1.90850925e-02f, 1.43570125e-01f, -1.38296127e-01f, 2.98027396e-01f, 2.53014505e-01f, 3.60337734e-01f, 7.86148429e-01f, -3.45395893e-01f, -3.34919691e-01f, -4.57486153e-01f,
  4.66605797e-02f, 8.02169323e-01f, -1.16390109e-01f, 7.71403909e-01f, 8.73594210e-02f, 3.20346594e-01f, 3.32939118e-01f, -6.50881827e-01f, -7.25056708e-01f, -1.47668332e-01f,
  -6.23945057e-01f, -9.29948613e-02f, -9.87787247e-01f, 9.83699709e-02f, 4.73701149e-01f, 1.69950083e-01f, 3.39151293e-01f, -1.76872030e-01f, -1.94405660e-01f, 2.51189083e-01f,
  3.02070856e-01f, -2.05146432e-01f, -8.69758785e-01f, 3.71100120e-02f, -9.15666595e-02f, 3.14608932e-01f, 2.75433622e-02f, -1.29205668e+00f, -5.70923746e-01f, -1.47958291e+00f,
  -8.52088511e-01f, 8.07818770e-01f, -1.02442801e+00f, 9.46515054e-02f, -4.01239060e-02f, 2.23238975e-01f, -4.11617383e-02f, 5.67997813e-01f, 1.40474271e-02f, -2.27469832e-01f,
  3.20040554e-01f, 2.45794699e-01f, 5.51613212e-01f, 5.58556207e-02f, 4.95002359e-01f, -7.56218672e-01f, 5.60696542e-01f, 5.24507761e-01f, -5.03498256e-01f, 9.69757140e-03f,
  2.48516887e-01f, -7.16694593e-01f, 6.66407287e-01f, 8.15387011e-01f, 6.90983355e-01f, 6.91155136e-01f, 3.30490500e-01f, 6.66907907e-01f, 5.71964681e-01f, 7.26920739e-02f,
  9.10715997e-01f, 6.50663197e-01f, -2.74706036e-01f, -4.58974540e-01f, 1.70573205e-01f, 7.87422419e-01f, 7.97706008e-01f, 2.48677239e-01f, -1.12605385e-01f, -9.70625505e-02f,
  1.10614002e-01f, -2.46931553e-01f, 3.88160527e-01f, -3.12411249e-01f, 5.83454967e-01f, 4.33238029e-01f, -2.96955019e-01f, -1.00527573e+00f, -4.15178835e-01f, 9.84362125e-01f,
  -2.09973678e-01f, 2.29416758e-01f, 1.17378771e-01f, -2.89239645e-01f, -6.45966589e-01f, 4.26845819e-01f, 5.52422523e-01f, -1.67337999e-01f, -2.30958462e-01f, -8.55827183e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  4.74335134e-01f, 2.03787118e-01f, -1.91086262e-01f, -3.00532486e-02f, 7.28706717e-01f, -5.12390509e-02f, 2.75342643e-01f, -9.04397219e-02f, 2.31544048e-01f, 2.78344125e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -6.43911541e-01f, 9.14570391e-02f, 3.43968064e-01f, -3.79145116e-01f, -2.37795532e-01f, 3.48056853e-01f, 3.48417878e-01f, 1.50927022e-01f, -4.47397865e-02f, 2.94642419e-01f,
  -1.11711979e+00f, -8.58537138e-01f, -1.55849969e+00f, -3.18118274e-01f, 1.08838618e-01f, -6.56754494e-01f, 1.89961731e-01f, 2.23952889e-01f, 2.67250180e-01f, -2.14671969e-01f,
  -7.20455885e-01f, -4.59686778e-02f, -3.29289317e-01f, -2.55540758e-01f, 4.64582860e-01f, 9.49592590e-02f, -5.08980036e-01f, -1.70802101e-01f, -1.03307104e+00f, 3.63930851e-01f,
  -2.55146790e-02f, 5.45725636e-02f, 5.26566982e-01f, -7.97574997e-01f, 5.51627934e-01f, -8.16848814e-01f, -3.55131269e-01f, -1.18267000e-01f, -2.07846969e-01f, -4.15300041e-01f,
  -3.98974791e-02f, 2.28687048e-01f, 4.37929988e-01f, -1.06974053e+00f, -1.31896651e+00f, -2.89648443e-01f, 5.10609865e-01f, 1.77273139e-01f, 2.60032475e-01f, 8.64150599e-02f,
  5.78412175e-01f, 3.14926416e-01f, 7.99062908e-01f, -3.38618964e-01f, 4.75757211e-01f, 1.57174066e-01f, -7.92951763e-01f, -7.09962428e-01f, -5.13038218e-01f, 8.01525891e-01f,
  -6.27186716e-01f, -9.46510494e-01f, -9.81576264e-01f, -2.64459193e-01f, -1.58886284e-01f, 8.69498774e-02f, -4.82268512e-01f, 9.83972311e-01f, -5.98536670e-01f, -8.62943232e-01f,
  3.10901910e-01f, 6.22880273e-03f, -4.47915375e-01f, -3.39738101e-01f, 8.50787982e-02f, -6.58872664e-01f, -5.66501915e-01f, -5.99013448e-01f, 4.66690361e-01f, -8.38212192e-01f,
  2.02088028e-01f, 8.30678225e-01f, -4.16872054e-01f, 8.29291701e-01f, 7.44413733e-01f, -2.69309014e-01f, -2.66375929e-01f, 5.11183798e-01f, -4.02075976e-01f, -8.79289091e-01f,
  -2.90128797e-01f, -1.19422030e+00f, -1.12366605e+00f, 1.95785224e-01f, 2.49508753e-01f, -5.68570733e-01f, 1.13058604e-01f, -6.82928920e-01f, -8.09739053e-01f, 6.63352668e-01f,
  -4.98104841e-01f, -2.23289207e-01f, -1.29314566e+00f, -2.20645949e-01f, 2.98346609e-01f, 1.03996538e-01f, 2.89964348e-01f, -1.61282361e-01f, 3.23367149e-01f, 9.76521000e-02f,
  7.55984485e-02f, 6.79159537e-02f, 2.55538583e-01f, -7.09886909e-01f, 2.10931107e-01f, 2.28324905e-01f, 1.91619933e-01f, -5.21539867e-01f, -2.60159597e-02f, 6.55112118e-02f,
  -4.68363732e-01f, -1.76469266e-01f, -1.57314494e-01f, -4.95551139e-01f, -3.06445837e-01f, 4.17314470e-01f, -6.82178080e-01f, -5.38227618e-01f, -3.32064927e-01f, -1.92839101e-01f,
  -3.23779851e-01f, -5.35630882e-01f, 3.30921590e-01f, -5.76088428e-01f, -8.02493811e-01f, 1.03685178e-01f, -9.83512923e-02f, -7.25089610e-02f, -5.67431092e-01f, 1.78235486e-01f,
  6.37348771e-01f, 2.81623602e-01f, 2.08979085e-01f, -3.27152789e-01f, -1.04878604e+00f, 5.55390298e-01f, -7.30722100e-02f, -6.78029135e-02f, -3.60249490e-01f, 7.59136438e-01f,
  2.85248697e-01f, -9.54496980e-01f, -5.44927083e-02f, -3.94009978e-01f, 1.94993958e-01f, -2.84181213e+00f, 2.46244311e-01f, -9.29176584e-02f, 1.63029134e-01f, 2.77502388e-01f,
  -1.14443162e-02f, -3.10420215e-01f, 2.19966665e-01f, -7.09743202e-01f, 1.14020026e+00f, 1.50687885e+00f, 4.98744428e-01f, -6.52629256e-01f, -1.01288903e+00f, -1.19369900e+00f,
  5.68402350e-01f, -9.17503655e-01f, -3.58038276e-01f, -6.08011447e-02f, -4.48223740e-01f, -9.63821769e-01f, -2.17389651e-02f, 2.84701675e-01f, -6.32406175e-01f, -6.22660100e-01f,
  7.26678908e-01f, 3.78640234e-01f, 3.85731086e-02f, -4.78094667e-01f, 2.41998747e-01f, 6.88733757e-02f, -4.87408727e-01f, -1.72573173e+00f, 4.01256412e-01f, 2.41845608e-01f,
  -9.71694469e-01f, 3.71640563e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.97725502e-02f, -4.70901370e-01f, 2.25061014e-01f, -6.81869239e-02f, 3.60579863e-02f, 1.33823305e-01f, 4.29504439e-02f, 1.16625957e-01f, -4.05383250e-03f, 1.65840298e-01f,
  5.29651754e-02f, -2.92471439e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    