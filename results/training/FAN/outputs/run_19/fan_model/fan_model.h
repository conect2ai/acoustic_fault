/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.26422301e-01f, -1.87989652e-01f, 2.00255468e-01f, -2.56077852e-02f, 2.95199186e-01f, -1.96087375e-01f, -1.66794717e-01f, -1.10607373e-03f, 1.60198584e-01f, -2.80765831e-01f,
  -8.12703818e-02f, 9.55297798e-02f, -1.40135765e-01f, 2.56031081e-02f, -1.46194249e-01f, -8.16253349e-02f, -3.53262313e-02f, 4.08456512e-02f, 1.61147982e-01f, -3.94723229e-02f,
  -1.53694218e-02f, -2.32314244e-01f, 8.04538664e-04f, 1.14786573e-01f, 5.27511276e-02f, 1.46087080e-01f, -3.02029550e-01f, 1.32041380e-01f, -4.43128757e-02f, 9.80358943e-02f,
  2.92315688e-02f, 2.18279451e-01f, -4.90190201e-02f, 1.17709478e-02f, -1.08516537e-01f, -3.55625637e-02f, -2.09725145e-02f, 4.16755043e-02f, 4.54928912e-02f, 3.51836085e-02f,
  8.00596643e-03f, 1.35612236e-02f, 8.69221613e-02f, 6.62216619e-02f, 5.65579608e-02f, 1.06030583e-01f, 1.31126508e-01f, 8.16680789e-02f, 9.53740068e-03f, 1.03403581e-02f,
  8.65175724e-02f, 1.08791716e-01f, -6.09964132e-02f, 6.09624479e-03f, 4.79951315e-03f, -2.95638782e-03f, -7.78362295e-03f, -1.30890151e-02f, -6.38149232e-02f, 5.42989634e-02f,
  1.16573259e-01f, -9.80510488e-02f, 1.35537490e-01f, -4.75435555e-02f, 8.44258144e-02f, 2.46678628e-02f, 5.24326377e-02f, -3.44429500e-02f, -1.92266125e-02f, -7.38101527e-02f,
  7.12583540e-03f, -7.62582645e-02f, 8.36333446e-03f, -4.48844619e-02f, 5.64501286e-02f, -7.16003999e-02f, 3.98920774e-02f, 2.14441046e-02f, -8.61336067e-02f, 4.68470082e-02f,
  -1.02575511e-01f, 2.25571659e-03f, -9.39124003e-02f, -5.03009707e-02f, 3.40774357e-02f, -6.69167340e-02f, -9.48884413e-02f, 6.88184192e-03f, 4.84617800e-03f, 3.35888416e-02f,
  -4.86445010e-01f, -4.27825987e-01f, -1.18636332e-01f, 8.81243423e-02f, 6.64381087e-02f, 1.60418265e-02f, 1.52032152e-01f, 3.58475149e-02f, -8.89272764e-02f, -6.16427464e-03f,
  -1.95705052e-02f, 6.15380928e-02f, -9.99633148e-02f, 4.55635227e-02f, -9.59919542e-02f, -9.38931108e-02f, -1.25176877e-01f, -9.13227201e-02f, -1.38750240e-01f, 3.35173402e-03f,
  -1.00585051e-01f, -3.19345780e-02f, 1.24833129e-01f, 5.34328558e-02f, -6.88288435e-02f, 5.55567741e-02f, 4.33120392e-02f, 1.00142248e-02f, 4.92256097e-02f, -7.69328475e-02f,
  1.07695125e-01f, -5.82645595e-01f, -1.11363091e-01f, -6.35696799e-02f, 1.13460355e-01f, 1.37580320e-01f, 9.34301466e-02f, -1.99399486e-01f, 3.33381854e-02f, -8.20212960e-02f,
  1.57387719e-01f, -1.04393400e-01f, -6.25519454e-02f, 1.17058456e-01f, 3.15871984e-01f, 7.35328645e-02f, 2.24333286e-01f, 1.12606570e-01f, 4.71336357e-02f, -1.00857370e-01f,
  1.04945516e-02f, 2.05725864e-01f, 2.49069259e-01f, -1.03271663e-01f, 1.69385746e-02f, -7.56933019e-02f, 1.50666609e-01f, -1.72235176e-01f, 7.89496973e-02f, 8.12949836e-02f,
  -1.08416103e-01f, -1.76447496e-01f, 2.72994768e-02f, -1.08075909e-01f, 3.26012000e-02f, -3.05173378e-02f, -6.28815684e-03f, -8.63527432e-02f, 4.85839024e-02f, -3.18044871e-02f,
  -5.30136712e-02f, -5.02718352e-02f, 2.69254670e-02f, -8.34262669e-02f, -7.99663663e-02f, -1.92392975e-01f, -6.59441650e-02f, 1.59675613e-01f, -7.09967315e-02f, 1.61087587e-02f,
  -7.09725097e-02f, -1.39434694e-03f, 7.43983313e-02f, 5.15572205e-02f, -2.80922726e-02f, -3.46175060e-02f, 1.39047474e-01f, 6.34504110e-02f, 5.01829609e-02f, 4.75489944e-02f,
  4.07866426e-02f, -1.08635770e-02f, 1.03264283e-02f, 3.26729119e-02f, -1.33597162e-02f, 1.00190565e-01f, 2.53004357e-02f, 1.04776561e-01f, 8.11579917e-03f, 1.54022751e-02f,
  9.53618884e-02f, -5.00245355e-02f, 8.19835588e-02f, -6.75725937e-02f, 8.39758888e-02f, 9.33218841e-03f, 1.69187877e-02f, 8.77187178e-02f, 1.76367834e-01f, 6.47282377e-02f,
  4.91928533e-02f, 6.18269965e-02f, 6.81757703e-02f, 6.27748063e-03f, -2.97411066e-03f, -2.35393587e-02f, -6.56903386e-02f, -2.26201545e-02f, 3.53554301e-02f, 1.28086554e-02f,
  -7.24986419e-02f, -7.61602446e-02f, 4.41079885e-02f, 4.57225107e-02f, 4.65081027e-03f, 4.41768393e-02f, 1.91558804e-02f, 4.82955538e-02f, -7.60287642e-02f, 4.26490456e-02f,
  6.11394458e-03f, 2.37834360e-02f, -4.33935784e-03f, 5.66946417e-02f, -1.94994844e-02f, 9.57636535e-02f, 5.53533956e-02f, -1.24072060e-02f, 1.53793886e-01f, 1.11262813e-01f,
  -1.77406650e-02f, 1.05194040e-01f, 2.62927040e-02f, 2.71459273e-03f, 9.52868834e-02f, 4.36073206e-02f, -1.82103738e-02f, -4.42367159e-02f, 2.95080021e-02f, 1.68271810e-02f,
  -1.82485238e-01f, -1.83210030e-01f, 2.39579216e-01f, -2.29053169e-01f, 7.45371729e-02f, 1.77895471e-01f, -1.03043981e-01f, -9.40664262e-02f, -1.18437253e-01f, -2.74575740e-01f,
  -3.32277596e-01f, 3.17794740e-01f, -1.32294580e-01f, -1.57366380e-01f, 1.95923105e-01f, -1.85327902e-01f, -2.38090530e-01f, -1.07686564e-01f, 8.96403417e-02f, -1.00198142e-01f,
  1.69474125e-01f, -1.43538997e-01f, 1.03603445e-01f, -6.53403699e-02f, 8.02626386e-02f, 9.26185474e-02f, -1.40918732e-01f, 1.29246652e-01f, -9.51973572e-02f, 1.73501387e-01f,
  4.79157679e-02f, -2.57736355e-01f, 3.41448486e-02f, 7.83932060e-02f, -1.25188544e-01f, -3.39200208e-03f, 5.95122799e-02f, 1.05671592e-01f, 5.73014729e-02f, 4.03527636e-03f,
  9.20641348e-02f, 8.64688903e-02f, -1.07216209e-01f, 1.19746447e-01f, 5.14825545e-02f, -1.24009009e-02f, 1.44586563e-01f, 3.13125998e-02f, -4.18099761e-02f, 1.20144919e-01f,
  2.84054894e-02f, 7.85267279e-02f, 2.80468129e-02f, 8.69138613e-02f, 6.89563975e-02f, -3.98659892e-02f, 7.58124292e-02f, 1.30306363e-01f, 2.94664130e-02f, -1.26328431e-02f,
  1.26032811e-02f, 2.82006040e-02f, -8.03921819e-02f, -8.11724551e-03f, -1.67489424e-02f, -4.96935621e-02f, -2.14304589e-02f, -9.31467563e-02f, 6.65218234e-02f, -1.11389488e-01f,
  -1.29291369e-02f, -5.48592675e-03f, -7.02065080e-02f, -3.66953462e-02f, -1.66242030e-02f, -1.02501094e-01f, 2.46905293e-02f, -6.20746017e-02f, 3.44116352e-02f, -2.84920307e-03f,
  5.90064414e-02f, 1.81568526e-02f, -8.65560472e-02f, -6.06800653e-02f, -4.31043888e-03f, 5.22570200e-02f, 2.23866384e-02f, 2.98849065e-02f, 8.94302595e-03f, 3.64217535e-02f,
  -1.93965863e-02f, -1.69175878e-01f, -1.62735935e-02f, 3.81946601e-02f, 6.56763837e-02f, 7.18034655e-02f, -9.75769237e-02f, 3.48260254e-02f, 1.00137658e-01f, -4.37493846e-02f,
  -2.17023045e-02f, -1.34465516e-01f, 1.10536143e-01f, -9.92987603e-02f, 5.95296472e-02f, 8.85105971e-03f, -1.60680667e-01f, 8.84375721e-02f, 7.14370981e-02f, -2.20297673e-03f,
  -1.46939224e-02f, -8.93044416e-05f, 9.05361846e-02f, -1.71028420e-01f, -5.88357486e-02f, -2.57544871e-02f, -6.88078627e-02f, -5.20360991e-02f, 7.61943385e-02f, 3.40820923e-02f,
  5.75545549e-01f, -3.48161221e-01f, 2.77573705e-01f, -2.10439056e-01f, -4.03856151e-02f, 1.56140432e-01f, 8.87942314e-02f, -1.72773361e-01f, 2.09825009e-01f, -3.52837116e-01f,
  -1.27679005e-01f, -6.84132129e-02f, -1.47708476e-01f, -2.22895309e-01f, 2.65540928e-01f, 1.01501837e-01f, -2.73233769e-03f, -3.84452790e-02f, -1.18425349e-02f, -2.22522244e-01f,
  8.75989199e-02f, -2.95864344e-01f, 4.18165810e-02f, -9.21072960e-02f, -4.26809639e-02f, 1.46926969e-01f, -4.88801077e-02f, -8.96219835e-02f, -7.07612559e-02f, -1.71329767e-01f,
  5.51111847e-02f, -1.29718423e-01f, 5.14086857e-02f, 1.03466138e-01f, 4.42565093e-03f, -6.05207272e-02f, 7.40004554e-02f, 1.01347022e-01f, 2.18429007e-02f, 4.72569466e-02f,
  3.82658131e-02f, 4.70853820e-02f, -1.11333299e-02f, 2.03885045e-02f, -5.17929159e-02f, 5.32930307e-02f, -4.95569818e-02f, -5.77994110e-03f, -3.50404135e-03f, 9.17754322e-02f,
  6.00796491e-02f, 4.22031991e-02f, 5.05762137e-02f, 4.50028405e-02f, 2.73154620e-02f, -8.32465291e-02f, 2.17548348e-02f, 3.23365591e-02f, 1.52297458e-02f, 5.02733365e-02f,
  3.82322073e-02f, 3.83804329e-02f, -1.35559030e-02f, -5.81578072e-03f, -1.04729421e-01f, -2.18456462e-02f, -7.45553821e-02f, -8.58815834e-02f, -4.06888267e-03f, 1.61349366e-03f,
  2.41526291e-02f, -2.24460978e-02f, 4.02840711e-02f, 1.39483865e-02f, -1.61151635e-03f, -1.90784596e-02f, 8.12954903e-02f, -6.09852746e-02f, 1.24692902e-01f, -3.49724889e-02f,
  7.87896011e-03f, -3.01858541e-02f, -2.89418250e-02f, 4.83036824e-02f, 3.28887478e-02f, 7.05008060e-02f, -9.60922688e-02f, 1.06180971e-02f, -4.99152206e-02f, 2.03684270e-02f,
  -6.13581389e-02f, -1.77297682e-01f, -6.29065335e-02f, -2.30278615e-02f, -4.77170572e-02f, 4.17899042e-02f, 1.96985453e-02f, 4.39512655e-02f, -3.98611873e-02f, -7.86359757e-02f,
  7.07473233e-02f, -6.52783662e-02f, 8.34872127e-02f, 1.87452883e-02f, 8.80272016e-02f, 4.66884598e-02f, 2.57154536e-02f, -1.49129536e-02f, 8.73673633e-02f, -1.21515065e-01f,
  -2.02569980e-02f, 2.68582487e-03f, -1.51452003e-02f, 1.91116184e-02f, -5.08462731e-03f, 4.70089614e-02f, 3.23393615e-03f, 8.57063755e-02f, 5.35488911e-02f, -1.87101811e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.11041343e-01f, 3.27199042e-01f, 9.07224193e-02f, -3.03732127e-01f, 1.45641983e-01f, 1.82095498e-01f, -3.13330531e-01f, 8.97369087e-02f, -3.87052655e-01f, 3.34674478e-01f,
  -1.26848578e-01f, 3.34801853e-01f, -3.07821214e-01f, -2.23752871e-01f, -1.19124556e+00f, -7.52252340e-01f, -5.31997800e-01f, -1.46023929e-01f, -5.04168689e-01f, 4.89955619e-02f,
  -3.29709619e-01f, -4.72754031e-01f, -3.47239077e-01f, 2.21105948e-01f, 3.99095356e-01f, 2.44271711e-01f, -8.81024450e-02f, 2.73525298e-01f, 2.98985511e-01f, -1.54425323e-01f,
  -6.02879524e-02f, -1.24281622e-01f, 2.56219923e-01f, 2.37644855e-02f, -3.42115834e-02f, 1.09519936e-01f, 1.61278069e-01f, -1.49696723e-01f, 8.73412490e-02f, 7.12080449e-02f,
  8.86546820e-02f, -2.91586295e-02f, -3.03763524e-03f, -3.36679891e-02f, 2.16324925e-01f, 6.68770298e-02f, 6.93763718e-02f, 5.27854972e-02f, 1.55703602e-02f, 1.63518667e-01f,
  -8.73460472e-02f, 5.59686348e-02f, 6.77093416e-02f, 4.35401574e-02f, 2.93700024e-02f, -3.12043298e-02f, 6.67254580e-03f, 3.58153284e-02f, 7.68361613e-03f, 9.12889019e-02f,
  -4.13417406e-02f, 7.79215072e-04f, -1.22537967e-02f, 5.46812192e-02f, 9.58839897e-03f, 2.97932029e-02f, -8.73477235e-02f, 9.10496786e-02f, 5.67912199e-02f, 4.48708376e-03f,
  6.85839280e-02f, 8.61158147e-02f, -7.04881176e-02f, 6.54808432e-02f, 2.77595464e-02f, 3.68400328e-02f, -2.97841635e-02f, -1.47196855e-02f, 2.16740780e-02f, -4.21080068e-02f,
  -4.52920347e-02f, -6.42859712e-02f, 8.62355158e-02f, 6.58164769e-02f, -1.59314319e-01f, 1.34938993e-02f, 1.45048425e-01f, 7.71550089e-02f, 3.03025078e-03f, -6.34294301e-02f,
  -4.94875312e-02f, -1.19154237e-01f, -4.64028642e-02f, 3.53971012e-02f, -6.37892783e-02f, -4.11989577e-02f, -1.82058617e-01f, 4.62696403e-02f, -3.66959050e-02f, -1.22428343e-01f,
  7.97007978e-02f, 1.22386411e-01f, 1.48560420e-01f, 1.20523944e-02f, -1.52962014e-01f, -1.58287019e-01f, -4.50530089e-02f, 3.25836204e-02f, -8.66747722e-02f, 5.78117743e-02f,
  1.82978615e-01f, 4.14483696e-02f, -1.05355121e-01f, -1.16091922e-01f, 4.92878705e-02f, 7.12517351e-02f, -2.67188512e-02f, 8.55908915e-02f, 3.97580042e-02f, 8.98082256e-02f,
  -5.74534118e-01f, 1.23047456e-01f, -2.28442892e-01f, -8.10337961e-02f, 3.61276478e-01f, 8.77208471e-01f, 8.65810290e-02f, 2.99467385e-01f, 1.95706442e-01f, 7.04890043e-02f,
  -2.45224670e-01f, -2.59815127e-01f, -2.13589102e-01f, -3.32043171e-01f, -9.46274698e-02f, -6.60640523e-02f, 2.87025452e-01f, 3.86096761e-02f, 1.73234679e-02f, 2.06847683e-01f,
  1.69749931e-01f, 2.73788646e-02f, -3.79614234e-01f, 6.24983124e-02f, -8.26350227e-02f, 5.49090207e-02f, -8.00313130e-02f, 1.04641353e-04f, -1.21804886e-01f, 7.82892704e-02f,
  -1.90950349e-01f, -1.63038909e-01f, -2.83390880e-01f, -1.92134958e-02f, 1.24775041e-02f, 1.28621191e-01f, 7.23064095e-02f, -6.05897009e-02f, 2.55495925e-02f, -1.14325602e-02f,
  -7.04536913e-03f, -4.74443547e-02f, -1.02817342e-01f, 1.86501015e-02f, 8.54178518e-02f, -1.18069142e-01f, -2.10330337e-01f, -6.32388666e-02f, -1.43402427e-01f, -9.68694463e-02f,
  -1.49053395e-01f, -4.38357219e-02f, 1.39171761e-02f, 1.18139155e-01f, -1.70428127e-01f, -4.55363058e-02f, 1.02510974e-01f, -1.56127736e-02f, -1.63993950e-03f, 8.18067566e-02f,
  1.36094674e-01f, 3.11465293e-01f, -5.11579774e-02f, -7.52970874e-02f, -8.46870467e-02f, -5.98252416e-02f, 1.72890164e-02f, -1.63827054e-02f, 6.81694085e-03f, -6.84769079e-02f,
  6.85362443e-02f, -5.70256785e-02f, -7.02728704e-02f, 3.76905128e-02f, 1.00204006e-01f, -6.32772073e-02f, -7.55131524e-03f, 4.38063256e-02f, 5.33212125e-02f, -6.61230758e-02f,
  -5.84529266e-02f, 2.10480452e-01f, -9.08364207e-02f, 3.50882336e-02f, 3.24492566e-02f, -7.69527182e-02f, 6.88766241e-02f, 3.07768695e-02f, 4.05515963e-03f, -4.56984825e-02f,
  4.08250451e-01f, 9.04598176e-01f, -3.65114957e-02f, -5.80522828e-02f, 1.14523922e-03f, -3.01697180e-02f, -2.54679117e-02f, -8.19800496e-02f, 1.38517499e-01f, 6.89862072e-02f,
  1.54951304e-01f, 4.74603847e-02f, 9.34482366e-02f, -7.76015073e-02f, -7.31298253e-02f, 1.96338683e-01f, 1.27314985e-01f, 7.69497007e-02f, 1.53956562e-01f, 1.88955795e-02f,
  -9.27895531e-02f, 1.68244854e-01f, 4.10837382e-02f, -1.42358840e-01f, -3.21830139e-02f, 5.60600609e-02f, 1.41022176e-01f, 5.70115354e-03f, 1.45991072e-01f, 6.89467788e-02f,
  4.83754873e-01f, 5.43928258e-02f, -1.11013845e-01f, -1.69420929e-03f, -2.48211280e-01f, 5.82175612e-01f, 8.19419026e-01f, -5.60458243e-01f, -2.05485493e-01f, 3.26313645e-01f,
  2.92445660e-01f, 2.72391200e-01f, 4.70657945e-01f, 3.79264325e-01f, 4.68253672e-01f, 4.42296535e-01f, 2.33894631e-01f, 3.02159429e-01f, -2.78401405e-01f, 2.44076829e-03f,
  -2.75722533e-01f, 2.55511373e-01f, 5.04569933e-02f, -4.15317833e-01f, 1.38677806e-01f, -4.61379111e-01f, -2.04319313e-01f, 2.55586077e-02f, -1.45935908e-01f, 2.77273469e-02f,
  1.24554753e-01f, -2.47242544e-02f, -1.53993294e-01f, -2.12210175e-02f, -7.32602626e-02f, 5.04730754e-02f, 2.16645896e-01f, 2.44340703e-01f, -1.93693772e-01f, 9.56395864e-02f,
  1.92111805e-01f, 1.40242977e-02f, -1.52016245e-03f, 4.80194055e-02f, 4.72387224e-02f, -2.99349204e-02f, -2.25451276e-01f, 1.39732426e-02f, -1.08965099e-01f, 9.47649851e-02f,
  5.54357246e-02f, 1.89614538e-02f, 1.20097855e-02f, -3.12625244e-02f, -9.20844376e-02f, 4.88650016e-02f, 2.18108043e-01f, 6.30781800e-02f, 4.50914241e-02f, 2.25805007e-02f,
  3.12960334e-02f, 7.77761489e-02f, 1.49091840e-01f, 4.17854302e-02f, 4.41564918e-02f, -1.10938340e-01f, 5.21258153e-02f, -1.05522946e-02f, -1.08714834e-01f, 2.48148516e-02f,
  8.34303908e-03f, -4.79728915e-02f, 8.02759826e-02f, 1.22271199e-03f, 2.01903403e-01f, 2.90804449e-02f, 1.41381532e-01f, -2.83017438e-02f, -2.08508093e-02f, -1.85113177e-02f,
  -5.39223552e-02f, 4.33502579e-03f, -1.80250034e-02f, 6.39093295e-02f, 1.11609012e-01f, -4.74637970e-02f, -8.10698792e-02f, -3.74806747e-02f, -4.61727679e-02f, 7.28472248e-02f,
  2.48366836e-02f, 1.31772369e-01f, 2.33002994e-02f, 1.28375739e-01f, -5.73945530e-02f, -5.81388688e-03f, 6.34533688e-02f, -6.70237616e-02f, 2.59551145e-02f, -5.37820607e-02f,
  1.00395093e-02f, 2.39977445e-02f, 1.37438491e-01f, -1.33977681e-01f, -1.30661830e-01f, -3.52395466e-03f, 2.39846170e-01f, -3.88372429e-02f, -4.92880233e-02f, -4.49113511e-02f,
  3.84649038e-02f, 7.33676925e-02f, 9.91698354e-02f, 3.47469859e-02f, -5.99553175e-02f, 1.30362526e-01f, -1.84883326e-01f, -2.42362320e-02f, -4.84846234e-02f, 1.49970874e-02f,
  7.30788529e-01f, 1.81281403e-01f, 7.59846926e-01f, 7.85521746e-01f, -6.68819621e-02f, -7.82122731e-01f, -2.98197925e-01f, 3.04669976e-01f, 4.55715150e-01f, -3.62731636e-01f,
  -1.19052216e-01f, 2.75967240e-01f, -6.22712195e-01f, 3.59897941e-01f, 2.85855561e-01f, -3.88527155e-01f, 5.49864888e-01f, -8.78870413e-02f, 2.17470661e-01f, 4.14328367e-01f,
  5.25089324e-01f, -1.18761711e-01f, 5.02415240e-01f, -1.00149680e-02f, 4.00205374e-01f, 3.45074803e-01f, 1.32587627e-01f, -1.75654426e-01f, 3.30879301e-01f, -2.32251421e-01f,
  -4.65104058e-02f, 2.17374861e-01f, 4.61614616e-02f, 5.96724711e-02f, 5.44027872e-02f, 1.78847709e-04f, -2.03351125e-01f, -2.25590155e-01f, -2.05022499e-01f, -1.44582659e-01f,
  -1.20269833e-02f, -8.00860673e-03f, 1.53679729e-01f, -3.78325172e-02f, 7.40719214e-02f, 2.21271157e-01f, 9.72937346e-02f, 4.29600477e-02f, 1.19184792e-01f, 1.55945644e-01f,
  2.15272501e-01f, 3.28269824e-02f, 9.74001810e-02f, 5.07112667e-02f, 4.79191281e-02f, 8.50576982e-02f, 8.86522159e-02f, 8.19715187e-02f, 1.85447305e-01f, 1.35370925e-01f,
  7.04287216e-02f, -1.27003387e-01f, -4.27184403e-02f, -4.76153791e-02f, 1.97698362e-02f, 3.98537293e-02f, -2.46300042e-04f, -6.34833798e-02f, -8.83075222e-02f, -9.72026065e-02f,
  5.61113283e-02f, 7.89377540e-02f, -1.27279535e-02f, 8.53356440e-03f, 8.65819305e-02f, 9.20039490e-02f, 7.43143400e-03f, -4.56791297e-02f, 2.23582432e-01f, 1.33234188e-01f,
  -5.36461286e-02f, -7.78202415e-02f, -3.09996419e-02f, -1.21208273e-01f, -1.42908674e-02f, -9.89337116e-02f, 1.51771039e-01f, 1.50920913e-01f, -3.68382409e-02f, 1.17787616e-02f,
  -4.36672568e-02f, 3.57219249e-01f, -1.64305549e-02f, -1.28860041e-01f, -6.22607097e-02f, -4.77754436e-02f, 1.58324018e-01f, 2.27717817e-01f, 1.50683120e-01f, -3.47247161e-03f,
  7.95195403e-04f, 1.65061317e-02f, -3.48360278e-02f, 5.89348711e-02f, 1.06973425e-02f, 7.40914419e-02f, -5.86963594e-02f, 5.70788309e-02f, 1.80560052e-01f, 8.94049089e-03f,
  -8.87715891e-02f, -2.27362141e-01f, 9.67750624e-02f, 4.27382328e-02f, -3.76433246e-02f, 3.83789055e-02f, 4.57128398e-02f, 1.12357913e-02f, 2.58602314e-02f, 6.65504634e-02f,
  -1.60416043e+00f, 1.10330991e-01f, 5.92311144e-01f, -5.90575278e-01f, -1.47975072e-01f, 5.06781101e-01f, 3.18241149e-01f, 9.05257463e-03f, -3.83869618e-01f, 1.21312551e-02f,
  -1.43143290e-03f, -2.48221919e-01f, 4.33618128e-01f, 1.84456781e-02f, 4.74361777e-01f, 5.78438580e-01f, 3.03930730e-01f, -1.69178657e-02f, -3.53933461e-02f, -2.63012409e-01f,
  -2.15842277e-02f, -1.30006269e-01f, 3.76768917e-01f, -1.11092851e-01f, -1.72988236e-01f, -3.27646226e-01f, -7.96275809e-02f, 1.66526899e-01f, 1.12196863e-01f, 1.58199489e-01f,
  -3.40302885e-01f, -4.18745637e-01f, -3.45213823e-02f, 1.10204376e-01f, -7.19040930e-02f, 7.32171461e-02f, 9.20732170e-02f, 5.19607328e-02f, -1.19076148e-01f, -1.02921084e-01f,
  -6.56331480e-02f, -3.32104489e-02f, -2.28461161e-01f, -1.19783692e-02f, -2.02612832e-01f, 1.04749193e-02f, -3.61501076e-03f, -6.78746030e-03f, -3.55189815e-02f, 2.11075887e-01f,
  2.42950365e-01f, 9.23726782e-02f, 1.60676520e-02f, 7.29324594e-02f, 5.99405952e-02f, -5.09991646e-02f, 8.01885128e-02f, 7.54221380e-02f, 3.11161112e-02f, -9.93494913e-02f,
  5.08631803e-02f, 4.39338908e-02f, 1.00864656e-01f, -7.01048896e-02f, 8.12794492e-02f, -4.62665148e-02f, -5.81438839e-02f, 9.90421325e-02f, -3.65738012e-03f, -3.84740718e-03f,
  -1.69809639e-01f, -2.76326519e-02f, -1.44101426e-01f, 7.15943724e-02f, 5.87050878e-02f, 8.94315913e-02f, 7.51347765e-02f, 1.51480781e-02f, -1.14121303e-01f, 8.07153881e-02f,
  -8.22642967e-02f, -7.37775192e-02f, 5.59099242e-02f, 4.45992276e-02f, 7.45499432e-02f, 1.03230812e-02f, -1.78565815e-01f, 9.38306749e-02f, -8.96057300e-03f, 5.07853031e-02f,
  -5.51527143e-01f, -5.02824962e-01f, -9.27528515e-02f, -1.65516511e-01f, -2.14949548e-02f, -1.04045078e-01f, -6.72074556e-02f, -7.44130015e-02f, 2.26410795e-02f, -8.31112340e-02f,
  -1.12686545e-01f, -7.23039806e-02f, -9.63109583e-02f, -4.49664481e-02f, 1.07234314e-01f, -3.34628858e-02f, -8.43233094e-02f, -1.57040119e-01f, -7.86026642e-02f, -4.94299158e-02f,
  -1.51384324e-01f, -1.84582859e-01f, 1.81227982e-01f, -4.26250622e-02f, -7.61023164e-02f, -6.97593391e-02f, -1.93383664e-01f, -8.62222686e-02f, 2.87701041e-02f, 1.78916920e-02f,
  1.18221331e+00f, -3.47187102e-01f, 5.84625483e-01f, 5.81949115e-01f, 4.81628984e-01f, 4.26023781e-01f, 7.46445060e-01f, 1.50232092e-01f, 6.27285838e-01f, -4.65627700e-01f,
  -1.77474692e-01f, 1.05741359e-01f, 1.55181050e-01f, -2.56466031e-01f, 2.96918035e-01f, -2.09703356e-01f, 7.73939788e-02f, -8.79628435e-02f, -5.71529157e-02f, 1.57572981e-02f,
  1.66209310e-01f, -3.01054776e-01f, 1.15828188e-02f, -6.59680188e-01f, 1.79430172e-01f, -9.27869603e-02f, -4.76923019e-01f, 3.53811421e-02f, -3.86097223e-01f, 4.01019212e-03f,
  7.28996024e-02f, -5.04044667e-02f, -1.43757612e-01f, -2.04004675e-01f, 4.13345881e-02f, 1.28925024e-02f, -2.63469797e-02f, 4.36686166e-02f, 2.54971921e-01f, 2.24232394e-02f,
  -2.32349448e-02f, -5.47683910e-02f, -1.02400362e-01f, 8.96212077e-06f, 4.73105870e-02f, 2.92162001e-02f, 2.01335922e-02f, -4.11669202e-02f, -9.56730917e-02f, 1.09053470e-01f,
  -2.34061517e-02f, -2.07762104e-02f, 1.53654397e-01f, -9.42132697e-02f, 5.11642806e-02f, 5.73838316e-03f, -5.47629595e-02f, 1.42424881e-01f, -4.02353778e-02f, -2.92950906e-02f,
  -2.62080580e-01f, 1.46399930e-01f, 4.40895185e-02f, 1.13932595e-01f, 4.90358286e-02f, -3.89444344e-02f, -2.32593436e-02f, 5.19626476e-02f, 4.61671166e-02f, 3.36863869e-03f,
  -1.74851585e-02f, 7.99548775e-02f, -3.37585062e-02f, 2.07925126e-01f, 2.96669081e-02f, 1.75859146e-02f, -1.07962124e-01f, -4.55600061e-02f, -1.15862347e-01f, 2.40798909e-02f,
  1.02841675e-01f, -3.03080808e-02f, -5.47112711e-02f, 1.12530425e-01f, -6.34130612e-02f, 3.62723544e-02f, -9.11789909e-02f, 8.91094580e-02f, 8.30359310e-02f, -9.22816098e-02f,
  -3.66649270e-01f, -4.26303267e-01f, -3.07348464e-02f, -1.78529527e-02f, -2.54338570e-02f, -1.81017041e-01f, -2.10548937e-02f, -1.58772990e-01f, -3.85377891e-02f, -4.00659852e-02f,
  -2.00987294e-01f, 1.42018303e-01f, -6.97892308e-02f, 1.78841259e-02f, -2.64564566e-02f, -9.61195454e-02f, -7.69691467e-02f, -1.53761759e-01f, -1.69440508e-01f, -1.22664928e-01f,
  -1.07051514e-01f, 8.64230022e-02f, 2.46200673e-02f, -1.92089360e-02f, -2.43899319e-02f, -4.22092006e-02f, 1.48324758e-01f, 2.08322927e-02f, -8.72305855e-02f, 6.07472807e-02f,
  5.41113555e-01f, -6.00951672e-01f, -5.23826778e-01f, 2.69977510e-01f, 6.91974282e-01f, 4.41484183e-01f, -4.54087555e-02f, 2.17043921e-01f, -4.08110410e-01f, -4.03139859e-01f,
  8.81078839e-02f, -2.49815106e-01f, -7.16137707e-01f, 4.50236201e-01f, 8.96506190e-01f, -4.38195705e-01f, 6.33388937e-01f, 1.15881048e-01f, -5.90770766e-02f, 1.91753775e-01f,
  4.50426757e-01f, 7.32599795e-01f, -2.27196440e-02f, 3.54758054e-01f, 5.65661073e-01f, 3.74740660e-02f, 2.29543820e-01f, -2.78965145e-01f, 4.92573351e-01f, 2.88526416e-01f,
  1.48420438e-01f, -1.37029039e-02f, -7.67886266e-02f, -9.59846601e-02f, 2.60794200e-02f, 2.96957865e-02f, -8.47901851e-02f, 6.61367923e-02f, -2.62623380e-05f, -1.47665799e-01f,
  -5.56125902e-02f, 1.77487701e-01f, 7.64258355e-02f, 1.25334784e-01f, 6.32183626e-02f, 1.30363867e-01f, -1.62264258e-02f, -8.38309377e-02f, -1.68273851e-01f, 8.57165977e-02f,
  -1.91162333e-01f, 1.71372667e-02f, 1.21473342e-01f, -1.93450928e-01f, -1.21569879e-01f, -1.16608767e-02f, 2.63361800e-02f, -4.37834673e-02f, 1.42714540e-02f, 5.20668179e-02f,
  1.10075817e-01f, 9.20444578e-02f, -1.05851609e-02f, -1.64870955e-02f, 1.70291550e-02f, -5.26070334e-02f, 1.09425202e-01f, -1.76411439e-02f, -6.18535839e-02f, -5.28117418e-02f,
  -1.73446070e-02f, 1.80034488e-02f, -6.01249598e-02f, -1.55350138e-02f, 1.12801008e-01f, -7.63079897e-02f, 1.81270149e-02f, -2.17567328e-02f, -1.81559026e-01f, -6.30846471e-02f,
  -5.03007509e-02f, 5.91326654e-02f, -1.19210884e-01f, 2.12326013e-02f, 5.90209700e-02f, -1.79383889e-01f, 9.11019295e-02f, -9.60734561e-02f, -8.08664858e-02f, -1.20020965e-02f,
  -3.97458561e-02f, -8.89777169e-02f, -2.17902303e-01f, -4.01614867e-02f, -1.27458721e-01f, 4.05588597e-02f, -1.31640220e-02f, 1.91854443e-02f, -1.08688734e-02f, 5.87266218e-03f,
  1.13017291e-01f, -1.76079832e-02f, 8.98251310e-02f, -2.02075578e-02f, 7.71478415e-02f, 4.06812988e-02f, -5.07113747e-02f, -1.44282758e-01f, 1.33489564e-01f, 2.35540550e-02f,
  7.87783191e-02f, -5.17438278e-02f, 6.53934851e-03f, 8.22305828e-02f, 3.23741883e-02f, -1.03240632e-01f, 5.42765148e-02f, -1.06803728e-02f, 1.47441372e-01f, -8.42268020e-02f,
  -2.98767418e-01f, -1.17149018e-01f, -5.64434469e-01f, -7.64822483e-01f, 3.70607972e-02f, -6.44513309e-01f, -5.40157437e-01f, -2.68840134e-01f, 3.50158781e-01f, -1.84481051e-02f,
  -1.40738875e-01f, 6.92821816e-02f, 6.62016034e-01f, -5.80922842e-01f, -2.21310839e-01f, 2.55981147e-01f, -7.17221916e-01f, -3.42330903e-01f, 2.09803075e-01f, -5.94056904e-01f,
  -1.59331918e-01f, -4.33034778e-01f, -3.90677720e-01f, -9.31154341e-02f, -5.91710746e-01f, -6.48717433e-02f, 5.99264987e-02f, 2.17558846e-01f, -5.60153544e-01f, 1.08057216e-01f,
  -5.20750955e-02f, 1.28642395e-01f, -2.86845952e-01f, -8.41905251e-02f, -4.23851997e-01f, -6.30262569e-02f, -2.09725365e-01f, 1.07385151e-01f, 3.58591899e-02f, 3.33533771e-02f,
  -1.42730726e-02f, -1.87985110e-03f, -1.01512030e-01f, 1.45172834e-01f, 1.94367226e-02f, 4.03756201e-02f, -1.52345300e-02f, -7.84568563e-02f, 1.18292868e-01f, 2.50014663e-02f,
  2.33166050e-02f, -9.58381519e-02f, -2.22133413e-01f, -3.65425041e-03f, -1.09573819e-01f, 1.17023767e-03f, -8.42847973e-02f, -7.92484879e-02f, -6.34200945e-02f, -1.31495565e-01f,
  -9.82249752e-02f, 8.64733905e-02f, -1.23749301e-01f, 8.21888596e-02f, -8.69914964e-02f, 3.89392972e-02f, -5.44150732e-03f, 9.97178033e-02f, 1.08419985e-01f, -1.14623988e-02f,
  6.96811527e-02f, -4.28599492e-02f, 2.43974067e-02f, -9.55673680e-02f, -9.83875096e-02f, 2.07027066e-02f, -6.99716136e-02f, -5.21502681e-02f, -4.24759164e-02f, -7.08478019e-02f,
  2.07516670e-01f, -5.95911406e-02f, 1.22073181e-01f, 8.87813345e-02f, -9.59674641e-02f, 4.08415496e-02f, 6.88852668e-02f, -4.18690629e-02f, -6.97967559e-02f, -1.12921372e-01f,
  -1.64085150e-01f, -5.71412444e-02f, 1.32432550e-01f, 4.27627601e-02f, -3.82322744e-02f, -1.23825006e-01f, 3.50891910e-02f, -1.50930434e-01f, 3.18506397e-02f, -7.34633878e-02f,
  -1.81951180e-01f, -1.72457516e-01f, -1.88503683e-01f, 6.17133677e-02f, 5.41950436e-03f, -2.46476233e-02f, -2.33911397e-03f, -7.90043771e-02f, -1.55694902e-01f, -1.56456843e-01f,
  -4.91610356e-03f, 9.03476588e-03f, 9.35434699e-02f, -1.62111484e-02f, -1.08896486e-01f, -4.74497192e-02f, 2.61537507e-02f, 1.64754346e-01f, -8.33411887e-02f, 5.54198176e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.38993764e-01f, 7.24660456e-01f, 5.23118794e-01f, 5.52432656e-01f, 5.15049100e-01f, 1.05026555e+00f, 5.90394080e-01f, 1.88447922e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.94141465e-01f, 2.58440431e-02f, 8.25933814e-02f, 5.46193361e-01f, 1.32944152e-01f, -6.48785293e-01f, 4.32749003e-01f, 1.04631715e-01f, 2.87624806e-01f, 3.71329814e-01f,
  -2.35610932e-01f, -7.87265897e-02f, 6.25358745e-02f, -1.78469449e-01f, -4.04677361e-01f, -1.32203504e-01f, -1.48634851e-01f, 1.84933946e-01f, 4.46492344e-01f, 1.27046436e-01f,
  2.39658475e-01f, -4.12938803e-01f, -3.09295237e-01f, 3.47854793e-01f, -7.00321719e-02f, 2.69566834e-01f, -1.10695370e-01f, 4.74942446e-01f, -2.69644648e-01f, 9.21525285e-02f,
  -4.63174522e-01f, 2.13290840e-01f, 1.52634710e-01f, -1.76164508e-01f, -3.67404640e-01f, 2.38318220e-01f, -9.97952074e-02f, -7.37506568e-01f, -1.20239004e-01f, -3.76136392e-01f,
  3.86228085e-01f, -1.75291687e-01f, -1.48094520e-01f, 1.91849723e-01f, 3.48196417e-01f, -3.90770614e-01f, -7.47265341e-03f, -2.25068271e-01f, -2.25335076e-01f, -4.43813801e-01f,
  -1.83187783e-01f, -4.67222154e-01f, 5.67109466e-01f, 3.38398814e-01f, -4.22552198e-01f, -2.13951126e-01f, -9.59574208e-02f, -2.94231623e-01f, -2.12592974e-01f, -1.50531769e-01f,
  -1.70255899e-01f, 3.91177349e-02f, 4.98273760e-01f, 4.67468292e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.25502390e-01f, 3.36726040e-01f, 5.58011413e-01f, 9.81759250e-01f, 9.17251885e-01f, -8.13517570e-01f, 9.31807995e-01f, 8.74665499e-01f, 1.36720634e+00f, 5.61625361e-01f,
  -5.81572711e-01f, -3.07091791e-03f, 4.28602695e-01f, 5.93288600e-01f, 5.06364107e-01f, 8.16298090e-03f, -2.59192795e-01f, -2.52310256e-03f, 6.66261077e-01f, 4.37328309e-01f,
  1.00100052e+00f, 1.69981882e-01f, -3.46633017e-01f, 5.23400366e-01f, 3.56899679e-01f, -7.44339943e-01f, 3.69186461e-01f, 1.23891413e+00f, -3.45669061e-01f, 1.14978778e+00f,
  7.91375995e-01f, -5.98616838e-01f, 1.47336692e-01f, 6.82589471e-01f, 2.85909951e-01f, 2.93145478e-02f, -1.26977694e+00f, 5.31672649e-02f, -8.84778857e-01f, -1.41443157e+00f,
  5.10486305e-01f, 1.09514785e+00f, 3.62604111e-01f, 2.51195073e-01f, -5.47383308e-01f, -6.41501248e-01f, 1.01507485e+00f, 8.23136449e-01f, 3.54896337e-01f, 4.37419936e-02f,
  -4.25341815e-01f, 6.37837410e-01f, -8.50181282e-01f, 5.26966989e-01f, -4.40704465e-01f, -6.47244573e-01f, -1.02098152e-01f, 9.19239998e-01f, 8.78027797e-01f, -2.52065063e-01f,
  1.11595964e+00f, -3.23556483e-01f, 6.82997227e-01f, -1.09684262e-02f, 4.45647210e-01f, -7.68758833e-01f, 8.64776745e-02f, -5.35892367e-01f, 9.03869510e-01f, -4.47238028e-01f,
  -2.48778313e-01f, -8.52523327e-01f, -2.57716458e-02f, -3.36970150e-01f, -5.68514228e-01f, 9.51553166e-01f, 1.20262396e+00f, -5.77888966e-01f, 2.50154316e-01f, 1.05466127e+00f,
  5.61230958e-01f, 8.58172655e-01f, -9.39876512e-02f, 3.03613663e-01f, -7.48218477e-01f, 6.00517452e-01f, 5.99718511e-01f, 8.47381651e-01f, -1.04791462e+00f, 5.69795310e-01f,
  1.03157103e+00f, -1.55538335e-01f, 1.20107365e+00f, 6.51753306e-01f, -3.40117067e-01f, 6.48333609e-01f, 9.44814179e-03f, 9.75479364e-01f, 8.84882510e-01f, 7.44979754e-02f,
  -1.76465765e-01f, 2.74733007e-01f, -9.39370453e-01f, 7.70991683e-01f, -1.30997717e+00f, 8.97423685e-01f, 2.73309469e-01f, 8.43407214e-01f, -5.90278685e-01f, 9.31594312e-01f,
  3.80150750e-02f, 2.08641201e-01f, 3.31837177e-01f, -1.57826081e-01f, 1.94651574e-01f, -3.58522356e-01f, 6.88768685e-01f, 3.69466990e-01f, 1.24142373e+00f, 6.95797324e-01f,
  -8.91295969e-02f, -3.56315225e-01f, 1.06450476e-01f, -5.52421927e-01f, 4.25709754e-01f, 2.13832200e-01f, 1.31098926e+00f, 1.14585555e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.67822242e-01f, 3.54024470e-01f, 4.26854789e-01f, 4.58778143e-01f, 1.77740693e-01f, 6.91519856e-01f, 1.71429247e-01f, 1.96541682e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  2.57605940e-01f, 5.05694710e-02f, 4.58589159e-02f, 3.30697626e-01f, -6.56562567e-01f, -7.76346922e-01f, 8.92160892e-01f, -5.87650955e-01f, -1.35863209e+00f, -6.84540808e-01f,
  -8.20783898e-02f, 7.46629596e-01f, 1.59593135e-01f, 7.21404016e-01f, -1.35061944e+00f, -1.20148540e+00f, -7.55855918e-01f, -4.70154621e-02f, -9.90481153e-02f, 5.85331500e-01f,
  -4.28135961e-01f, -7.74683177e-01f, -4.61513251e-01f, 3.59545529e-01f, -1.23593545e+00f, -1.45721987e-01f, 7.55381644e-01f, 5.44219673e-01f, -1.14624500e+00f, -2.96529740e-01f,
  -6.86754137e-02f, 1.07009180e-01f, -3.08218986e-01f, -3.00493479e-01f, 1.93447724e-01f, -7.86147296e-01f, -2.61486888e-01f, -5.71826756e-01f, 7.78879747e-02f, 3.42899203e-01f,
  -2.24121362e-02f, 4.12498087e-01f, -2.15620160e-01f, -3.00975870e-02f, 1.30893484e-01f, -1.11438906e+00f, -5.73147655e-01f, 5.80085397e-01f, -1.86056331e-01f, 3.37865859e-01f,
  1.62174046e-01f, 6.56446517e-02f, 6.38217568e-01f, 5.59272110e-01f, 7.79230833e-01f, 1.20292449e+00f, 1.65048875e-02f, -1.11603773e+00f, 2.44703636e-01f, -4.95943904e-01f,
  1.27960992e+00f, -1.13875449e+00f, -7.75237441e-01f, 1.16198905e-01f, 2.50986755e-01f, 4.71484244e-01f, 4.11947936e-01f, 3.50080878e-01f, 1.22433853e+00f, -3.78006607e-01f,
  3.49520445e-01f, -7.85151780e-01f, 7.07541049e-01f, -9.58687425e-01f, -1.07689917e+00f, 1.15090340e-01f, 1.33164048e-01f, 3.34861100e-01f, -1.04278302e+00f, 3.39446187e-01f,
  6.38811886e-01f, 7.54088759e-02f, 7.51140788e-02f, -8.44440222e-01f, 7.47294843e-01f, 1.34961677e+00f, -7.58101344e-01f, -6.14805758e-01f, -3.10755372e-01f, -3.56874228e-01f,
  -8.83698612e-02f, 4.29039896e-02f, -7.38271654e-01f, 5.49132586e-01f, 1.04176915e+00f, -1.43441951e+00f, 2.52046087e-03f, 2.52158344e-01f, -1.82093367e-01f, 4.46981102e-01f,
  -6.28527462e-01f, 7.26067305e-01f, -2.53076643e-01f, 8.79700661e-01f, -1.53570762e-02f, 6.85926259e-01f, -9.87284720e-01f, -1.17198610e+00f, -7.07231522e-01f, -3.65306884e-01f,
  9.44252074e-01f, -3.19826096e-01f, -1.41497771e-03f, -3.32343996e-01f, -5.95529318e-01f, -4.56008941e-01f, -8.12489092e-01f, 1.93050057e-01f, -7.77956963e-01f, 3.16864848e-01f,
  -2.94448107e-01f, -7.87385523e-01f, -2.17551678e-01f, -9.36333895e-01f, 5.12174249e-01f, 2.27328181e-01f, -1.97659954e-01f, 8.02405357e-01f, 1.83581844e-01f, 6.32063523e-02f,
  -2.29362383e-01f, 2.01561704e-01f, -4.15548712e-01f, 1.94533020e-01f, 5.34767509e-01f, -4.84556034e-02f, -9.44575489e-01f, 4.84820932e-01f, 3.52843583e-01f, -6.10031843e-01f,
  8.59752536e-01f, -7.99006581e-01f, 4.62086529e-01f, -1.16213274e+00f, 1.64121017e-02f, -1.33419603e-01f, -7.07920313e-01f, -1.27877012e-01f, -9.35391366e-01f, -1.09109128e+00f,
  -6.84372008e-01f, -4.13137585e-01f, -2.11710930e-01f, -7.37808645e-02f, -1.27770770e+00f, -2.43579179e-01f, -1.18799400e+00f, 7.06401289e-01f, -2.43810847e-01f, 7.34125018e-01f,
  -4.15400445e-01f, 2.48693451e-01f, -5.49466088e-02f, 6.12260401e-02f, 4.03106064e-01f, 1.26552060e-01f, 4.34975386e-01f, -9.20467734e-01f, 5.58002114e-01f, -7.98933387e-01f,
  9.54611003e-01f, -3.73605080e-02f, -1.07732737e+00f, -7.89469779e-01f, -6.57190323e-01f, -1.37656534e+00f, 6.38152137e-02f, -5.11433110e-02f, 1.54178098e-01f, 2.94054300e-02f,
  8.95968258e-01f, 7.23520398e-01f, 7.92564392e-01f, -6.30322158e-01f, 6.71414256e-01f, 9.20235217e-01f, -7.76006579e-01f, -9.57024872e-01f, -1.10502288e-01f, -8.38021576e-01f,
  -7.82645702e-01f, -9.63426948e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.22918800e-01f, -1.17590435e-01f, -3.96713436e-01f, 8.50932598e-02f, 1.34817138e-01f, 2.94743478e-02f, -3.00241828e-01f, -1.51321635e-01f, -2.36777335e-01f, 9.85177606e-02f,
  2.01187894e-01f, 1.70904428e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    