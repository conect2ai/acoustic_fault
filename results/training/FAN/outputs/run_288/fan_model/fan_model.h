/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.48852170e-01f, -3.80141497e-01f, -1.02240458e-01f, 7.94266239e-02f, 8.36901367e-02f, -1.54623203e-03f, 1.12406313e-01f, -1.18389010e-01f, 2.71391254e-02f, -1.30474120e-01f,
  1.60396188e-01f, -2.15377927e-01f, 1.06874831e-01f, 7.57640004e-02f, 2.64984488e-01f, 1.23758860e-01f, 1.01832725e-01f, 1.25819854e-02f, -3.56730074e-02f, -1.44951478e-01f,
  1.24662921e-01f, 1.35227919e-01f, 1.69590816e-01f, -6.78505078e-02f, -7.15740994e-02f, -1.10523283e-01f, 9.19300616e-02f, -9.04278085e-02f, -1.25545915e-02f, 1.93033181e-02f,
  -1.20456994e-01f, -1.89930517e-02f, -7.18790889e-02f, -1.51307341e-02f, -4.42314520e-03f, 1.01720151e-02f, -4.01603058e-02f, 7.23011345e-02f, -2.91804429e-02f, 3.57061019e-03f,
  -4.36937902e-03f, 4.24298085e-03f, 1.01062786e-02f, -2.71714292e-03f, -6.45622462e-02f, 2.08805799e-02f, -3.56605370e-03f, 5.54236099e-02f, -6.93064034e-02f, 9.79799032e-03f,
  3.90491150e-02f, 4.83475327e-02f, 1.19333537e-02f, -4.63224426e-02f, 1.08693041e-01f, 7.71017447e-02f, -1.59536693e-02f, 2.43516490e-02f, -6.11388870e-02f, -1.80140622e-02f,
  -1.66945290e-02f, -9.73155629e-03f, 6.90642074e-02f, -8.05972219e-02f, -1.78737845e-02f, 6.12925217e-02f, -5.17081516e-03f, 5.98655753e-02f, -1.45700211e-02f, -8.72486446e-04f,
  -6.86422661e-02f, -7.64104798e-02f, 4.62275371e-02f, 3.16505581e-02f, -5.71279263e-04f, 2.64045969e-02f, 3.12496647e-02f, -4.55819517e-02f, 2.10243296e-02f, 4.53996286e-02f,
  2.44356561e-02f, 1.39049767e-02f, -5.57897501e-02f, 1.84091553e-02f, -2.96247620e-02f, -4.29062918e-02f, -4.42594849e-02f, -5.30012585e-02f, 1.56840906e-02f, 3.00179217e-02f,
  -1.61239415e-01f, -1.25267684e-01f, 3.65475565e-02f, -7.26431087e-02f, -6.33210987e-02f, 2.36310363e-02f, -1.72162671e-02f, 4.65418175e-02f, -4.89389822e-02f, -5.62464595e-02f,
  5.03885299e-02f, 5.67837246e-02f, -7.12156445e-02f, 3.47685330e-02f, 2.40137713e-04f, 5.08139189e-03f, 2.35013403e-02f, 8.68860260e-03f, 2.73549464e-02f, -1.60244592e-02f,
  -6.69604316e-02f, -8.48841965e-02f, 7.80854076e-02f, 6.52299821e-02f, 4.46779169e-02f, 7.82451853e-02f, 2.71003917e-02f, -7.15768114e-02f, 2.01978218e-02f, 1.06408708e-02f,
  -3.11003834e-01f, 2.02745557e-01f, 6.88238740e-02f, -2.92645305e-01f, -1.98167145e-01f, -2.15521634e-01f, -1.66489407e-01f, -7.08030462e-02f, 5.55854617e-03f, 1.45254061e-01f,
  -8.63556191e-02f, 1.71368718e-01f, 2.48051047e-01f, -9.70837250e-02f, -3.22474837e-01f, 1.67999908e-01f, -2.20435515e-01f, 5.82941156e-03f, 3.66311781e-02f, -1.27501190e-01f,
  -1.42333478e-01f, -1.20733872e-01f, -8.22072010e-03f, 5.70639558e-02f, -2.14372128e-01f, -2.76992805e-02f, -9.96227339e-02f, 9.15841535e-02f, -8.71237367e-02f, -3.83677264e-03f,
  -1.10073298e-01f, -8.52539912e-02f, -3.88485268e-02f, 7.25662857e-02f, -1.23553231e-01f, -1.97229274e-02f, -5.86564206e-02f, 4.14836407e-02f, 1.92690156e-02f, 1.48697039e-02f,
  1.01681858e-01f, -1.52627183e-02f, 2.28820387e-02f, 6.39610365e-02f, 1.53501006e-03f, 4.03727442e-02f, 1.77911751e-03f, -1.00845937e-02f, -7.22202845e-03f, -4.27506641e-02f,
  -2.67396085e-02f, -1.55299855e-02f, 3.09512694e-03f, 1.79000869e-02f, -7.82381743e-02f, -3.63096409e-02f, -7.76230590e-03f, -1.43988933e-02f, -4.15945798e-02f, -9.67836902e-02f,
  -1.03102978e-02f, 1.59207378e-02f, 4.05014530e-02f, -2.84645264e-03f, -1.09173935e-02f, -1.45506514e-02f, 2.03031600e-02f, -2.78610848e-02f, 5.22079058e-02f, -6.60231933e-02f,
  -9.69893765e-03f, -1.96706373e-02f, 2.81146560e-02f, 1.00589395e-02f, -1.11069940e-02f, -5.64220920e-03f, 5.89196607e-02f, 1.51323909e-02f, -3.75034474e-02f, -5.27028181e-02f,
  5.59993647e-02f, -2.78504267e-02f, -3.96379270e-03f, -3.53379026e-02f, 1.77823268e-02f, 9.98621900e-03f, 7.02664778e-02f, -8.25846754e-03f, -2.14025900e-02f, -6.78208992e-02f,
  -2.23952472e-01f, -4.46064807e-02f, 6.40275627e-02f, -9.06925648e-03f, 1.56900473e-03f, 1.51910977e-02f, -3.70554603e-03f, 1.14729686e-03f, 8.02834227e-04f, 7.23434938e-03f,
  -6.18887469e-02f, -2.28424147e-02f, -8.37551504e-02f, 5.85268028e-02f, 1.98074076e-02f, -3.96216027e-02f, -5.04816510e-02f, 1.95336342e-02f, -7.88417608e-02f, 1.41065242e-02f,
  2.93866862e-02f, -2.28432082e-02f, -1.76278278e-02f, -4.57527451e-02f, 4.55764048e-02f, -2.57806145e-02f, -8.00418928e-02f, 2.11855117e-02f, -1.19568938e-02f, 4.32012528e-02f,
  -9.27477404e-02f, -2.26421148e-01f, 1.58680230e-01f, -7.26603866e-02f, -1.75132945e-01f, 1.75876781e-01f, 4.13252503e-01f, -1.26352459e-01f, -8.40476975e-02f, 8.02067965e-02f,
  6.94491761e-03f, -7.10911006e-02f, 2.72491723e-01f, -5.68583682e-02f, 1.59377977e-01f, 1.80142373e-01f, -6.83455095e-02f, -2.68126894e-02f, -1.27615988e-01f, -1.16249800e-01f,
  -6.54174685e-02f, -2.22591311e-01f, 3.65855768e-02f, -1.76562563e-01f, -1.77754033e-02f, -1.07294284e-01f, -8.73768702e-02f, 4.26192209e-02f, -1.36841595e-01f, -1.24208732e-02f,
  -1.26915604e-01f, -1.77464977e-01f, 1.11288257e-01f, 7.31676444e-02f, 1.50913782e-02f, 6.41232058e-02f, 8.11570734e-02f, 9.45909023e-02f, 2.54283063e-02f, -3.04114800e-02f,
  3.77967581e-02f, -2.61507649e-02f, 3.11817694e-03f, 7.71157444e-02f, 5.14080338e-02f, -2.62062252e-02f, -5.02787270e-02f, 4.29423042e-02f, -4.27233353e-02f, 8.97295401e-03f,
  6.65632933e-02f, -4.84500825e-03f, 2.45910995e-02f, 1.32215330e-02f, -3.43032591e-02f, -7.18657859e-03f, 2.86772326e-02f, 8.68541822e-02f, -3.40686142e-02f, -3.79372425e-02f,
  6.05123043e-02f, 5.58339208e-02f, -3.12834233e-02f, -6.58482462e-02f, 2.34456565e-02f, -3.10925245e-02f, 4.24161777e-02f, 3.59448348e-03f, 3.21432613e-02f, -3.23171020e-02f,
  -3.03789899e-02f, -5.70682324e-02f, -6.36498583e-03f, 6.30053952e-02f, 3.55368219e-02f, 1.34489313e-02f, 2.21045297e-02f, 2.43003364e-03f, -4.22249399e-02f, 2.72242557e-02f,
  4.27838974e-02f, -7.33112637e-03f, 3.61154340e-02f, -3.05584706e-02f, 5.23179471e-02f, 4.31922637e-02f, -3.75258364e-02f, 4.90696682e-03f, -5.01177534e-02f, 5.73792420e-02f,
  -1.18777111e-01f, -8.58620629e-02f, -4.83795162e-03f, -9.98054817e-02f, -3.79316956e-02f, 1.39451306e-02f, 2.21862942e-02f, -3.41320261e-02f, 9.81469406e-04f, -8.08911026e-03f,
  3.34486216e-02f, 8.11501668e-05f, -2.38311104e-03f, -3.94559391e-02f, -3.33378837e-02f, 1.36632239e-02f, 4.14417917e-03f, -4.27630031e-04f, 2.99805962e-03f, -7.05805123e-02f,
  -4.87954393e-02f, 3.20136845e-02f, 2.51940880e-02f, 2.88242027e-02f, 3.82904895e-02f, 3.94313969e-02f, 2.12955065e-02f, 1.87164024e-02f, -2.89816577e-02f, -8.76773242e-03f,
  8.02655444e-02f, 3.44042063e-01f, 1.50615692e-01f, -2.90165152e-02f, -1.23015508e-01f, -1.08977549e-01f, 9.59010199e-02f, -3.21912095e-02f, 2.90182561e-01f, 2.33290736e-02f,
  -2.02864215e-01f, 2.06469938e-01f, 1.92968696e-01f, -1.59442052e-01f, -8.64782780e-02f, 1.86037421e-01f, -2.11101294e-01f, -8.89193863e-02f, 1.06666304e-01f, -4.70355935e-02f,
  -1.14389345e-01f, -2.37455159e-01f, -7.47952312e-02f, -9.02917981e-02f, -1.62728846e-01f, 2.82449778e-02f, -2.65075386e-01f, 1.16973236e-01f, -2.51066118e-01f, -2.89984904e-02f,
  -2.24735755e-02f, 1.38318449e-01f, -4.26789038e-02f, 6.91591129e-02f, -1.06634222e-01f, -3.74969430e-02f, -8.35419819e-02f, -6.93465443e-03f, -2.09811400e-03f, 7.84704909e-02f,
  3.16920802e-02f, 1.05176829e-02f, -3.73585559e-02f, 7.32875392e-02f, 2.26328131e-02f, 1.24371015e-02f, 1.88634600e-02f, -1.14914477e-02f, 2.34506447e-02f, 5.77915646e-02f,
  5.19818887e-02f, -4.67684157e-02f, -9.75826308e-02f, -3.39846825e-03f, -2.22412888e-02f, 2.88630687e-02f, 2.27786023e-02f, 1.52364168e-02f, -4.13531475e-02f, 4.57803458e-02f,
  -7.17488229e-02f, -4.31803316e-02f, 3.21445316e-02f, 1.07754748e-02f, 2.17206813e-02f, -1.57938208e-02f, -7.03025982e-02f, 6.29387842e-03f, 1.01564953e-03f, 1.95609871e-02f,
  -2.40169931e-02f, -2.16043647e-03f, 5.66301693e-04f, -1.57938991e-02f, -6.46331683e-02f, 1.21323010e-02f, -5.22323474e-02f, 3.14573012e-02f, 2.95685921e-02f, -1.95383709e-02f,
  1.84227508e-02f, 1.31175260e-03f, 6.27554022e-04f, -6.10966757e-02f, -6.87478343e-03f, 2.17253342e-02f, -2.65000816e-02f, 4.68446538e-02f, -1.79999974e-02f, -5.25153130e-02f,
  -1.07136920e-01f, 1.48407882e-02f, 9.40247476e-02f, -4.32293341e-02f, 5.16005307e-02f, -3.65189314e-02f, 1.64480824e-02f, 4.38453108e-02f, 5.03729917e-02f, -2.16464177e-02f,
  -8.85681808e-02f, -5.41965757e-03f, -1.62931196e-02f, -4.66073975e-02f, -3.67902443e-02f, 3.02957054e-02f, -6.46311194e-02f, -6.67812303e-02f, -7.22764283e-02f, -6.84750155e-02f,
  -6.89262748e-02f, -4.25629020e-02f, -1.52258656e-03f, -5.84288947e-02f, -2.60561407e-02f, -6.94774091e-02f, 1.16324127e-02f, 2.67447368e-03f, -5.02440557e-02f, 3.92844342e-02f,
  -1.51160583e-02f, 1.53602153e-01f, 3.64622325e-02f, 1.25910252e-01f, 1.46200627e-01f, -2.91291356e-01f, -3.08807969e-01f, 1.69880465e-01f, 1.37782454e-01f, 2.82664597e-02f,
  -1.04523599e-01f, -1.14748981e-02f, -8.20065960e-02f, -2.10877374e-01f, -5.25050044e-01f, -2.38925844e-01f, -1.97077945e-01f, -7.24766776e-02f, 1.48200970e-02f, 1.46610945e-01f,
  7.78763667e-02f, -1.67843461e-01f, -1.74519315e-01f, 1.68580458e-01f, 7.34496489e-02f, 2.73317367e-01f, 6.43035620e-02f, 8.92140865e-02f, -1.11996159e-02f, -1.67151153e-01f,
  -1.65636033e-01f, 1.46179065e-01f, 1.01942264e-01f, -2.79495995e-02f, 1.28446091e-02f, -1.32134371e-02f, -4.92966846e-02f, -8.83357003e-02f, 2.39559412e-02f, 3.56130674e-03f,
  1.46744656e-03f, -4.03586440e-02f, -8.73106159e-03f, 2.32935604e-02f, 4.88444827e-02f, 4.41477522e-02f, 1.43270334e-02f, 6.41201437e-03f, 2.02331319e-02f, -5.87729327e-02f,
  3.92236970e-02f, -1.95842776e-02f, 2.38576997e-02f, -5.54190017e-02f, -1.38422390e-02f, 2.93095019e-02f, -7.14310780e-02f, -2.15695072e-02f, 5.09596206e-02f, 1.77906808e-02f,
  4.08244543e-02f, 6.25972217e-03f, -3.15166712e-02f, -1.89802647e-02f, -2.14863662e-02f, 2.13567652e-02f, -2.32022218e-02f, -4.08346429e-02f, 2.27989815e-02f, 3.75614571e-03f,
  1.71714332e-02f, 8.42376146e-03f, 7.19078397e-03f, -8.21939763e-03f, 2.50544846e-02f, 2.61154622e-02f, -2.88483091e-02f, -7.34883826e-03f, -3.62441846e-04f, 2.87486259e-02f,
  9.99963563e-03f, -6.76628277e-02f, -6.60951855e-03f, -4.54223044e-02f, -6.39891401e-02f, 2.38254387e-02f, -3.17813605e-02f, -2.56376876e-03f, 1.16422493e-02f, -4.14795727e-02f,
  1.44388657e-02f, 1.01626806e-01f, -3.37598240e-03f, -1.37845417e-02f, -1.99123714e-02f, -1.96608752e-02f, -4.53909524e-02f, 4.16371636e-02f, 1.87302157e-02f, -2.56301798e-02f,
  2.88558844e-02f, 4.03682254e-02f, -5.07525541e-03f, -2.57697683e-02f, -3.10570598e-02f, -1.65582299e-02f, -3.54682505e-02f, -1.43496608e-02f, 2.11866572e-02f, 4.37041819e-02f,
  2.45068651e-02f, 7.85755645e-03f, 6.29806006e-03f, 5.51529638e-02f, 4.00240906e-02f, -2.63361093e-02f, 7.29915947e-02f, 7.72040058e-03f, -3.36187221e-02f, -1.09589482e-02f,
  5.05991101e-01f, -2.07805961e-01f, 2.11605638e-01f, 3.34330082e-01f, 1.62258118e-01f, -8.59910697e-02f, -6.11311160e-02f, 9.51892436e-02f, 1.09202735e-01f, -3.88906538e-01f,
  -2.42131520e-02f, 1.24464497e-01f, -2.72528172e-01f, 2.73828544e-02f, 4.16789502e-01f, -1.90308496e-01f, -1.93111459e-03f, -1.18345775e-01f, 5.57847582e-02f, 9.61537659e-02f,
  2.10439920e-01f, -4.07851972e-02f, 9.71419439e-02f, -3.87054943e-02f, 1.47383481e-01f, 6.77876398e-02f, -1.67414360e-03f, -9.87627506e-02f, -4.16244343e-02f, 4.44501378e-02f,
  5.97676709e-02f, -4.83873896e-02f, 2.74323169e-02f, -2.36482937e-02f, -2.40512714e-02f, -4.20228168e-02f, -8.56468733e-03f, 9.52938851e-03f, 9.73911062e-02f, 1.32074850e-02f,
  -3.78154740e-02f, 6.97040260e-02f, 8.87317955e-03f, 2.06519533e-02f, 6.13984242e-02f, 4.35627177e-02f, 5.78577965e-02f, 8.38030055e-02f, 1.23263663e-02f, 4.96091060e-02f,
  2.33625825e-02f, -6.86210208e-03f, 3.16878520e-02f, -5.66529706e-02f, 3.50000188e-02f, 4.23298180e-02f, 1.83464233e-02f, -7.05175325e-02f, -4.26054746e-02f, -4.00187075e-03f,
  -6.21193275e-02f, -6.38245493e-02f, 2.57025398e-02f, 2.24903543e-02f, 2.87838597e-02f, -1.52929043e-02f, 2.54436638e-02f, -5.28196767e-02f, 2.52768490e-02f, 1.41871290e-03f,
  5.92903979e-02f, 7.45481104e-02f, 1.40844369e-02f, 2.90929135e-02f, 2.90122558e-03f, -9.18781105e-03f, -2.15941034e-02f, -4.89336960e-02f, -3.18027884e-02f, 5.45196980e-02f,
  -4.70326692e-02f, 2.52376795e-02f, -2.05014870e-02f, -1.93519574e-02f, -1.98302045e-02f, 3.42253596e-02f, -1.63642447e-02f, 1.16421711e-02f, 4.95918700e-03f, 1.16306385e-02f,
  -1.16882674e-01f, -1.53308049e-01f, -3.03532816e-02f, -2.98547000e-02f, -6.69690520e-02f, 2.54101530e-02f, -2.65734121e-02f, -2.07439461e-03f, -4.40175682e-02f, -2.44571846e-02f,
  -2.51689572e-02f, -1.07727293e-02f, -5.00139147e-02f, 8.17116443e-03f, 3.23555544e-02f, 4.28984920e-03f, -9.35208574e-02f, -1.83595866e-02f, 2.11886875e-02f, -1.33852521e-02f,
  3.24138366e-02f, -3.83142345e-02f, 1.29540814e-02f, 1.49652245e-03f, -3.33788395e-02f, -3.95829752e-02f, 2.65935138e-02f, 1.94695927e-02f, -1.72650404e-02f, -5.72288781e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.97472419e-02f, -1.58749312e-01f, 2.17871577e-01f, -5.89050464e-02f, 2.09736094e-01f, 1.99236393e-01f, 1.69645369e-01f, 9.81845781e-02f, 1.43390790e-01f, -2.64877081e-01f,
  -1.22496925e-01f, -1.81576386e-01f, -2.06026044e-02f, -6.89206272e-02f, 1.95631668e-01f, 8.44251439e-02f, 7.29465857e-02f, -1.00019246e-01f, 5.86020425e-02f, -6.75125644e-02f,
  -3.27283926e-02f, -1.70350999e-01f, 1.73057453e-03f, -3.43807675e-02f, -5.03650531e-02f, -2.56255474e-02f, -1.50824681e-01f, 1.08465955e-01f, -1.82063952e-01f, 5.89082092e-02f,
  6.46776184e-02f, 4.72013205e-02f, 6.49740100e-02f, 8.34986717e-02f, 1.08527571e-01f, -1.11589193e-01f, -8.40067640e-02f, -6.72624558e-02f, 6.55921176e-02f, -7.59543777e-02f,
  -8.91309008e-02f, -5.43158092e-02f, 2.88235862e-02f, 1.01032713e-02f, -4.43493500e-02f, -4.21022400e-02f, 6.69276789e-02f, 6.60951585e-02f, -5.44118918e-02f, -7.17344806e-02f,
  -4.67703640e-02f, 3.22946645e-02f, 1.17724322e-01f, -1.10691950e-01f, -3.47968005e-02f, -5.19326739e-02f, -3.02218050e-02f, -5.89228459e-02f, -3.58915962e-02f, 6.31703762e-03f,
  -8.65847617e-02f, 7.27378502e-02f, -3.86353210e-03f, -1.68226962e-03f, 4.13014786e-03f, 9.59686190e-02f, 4.08952013e-02f, 7.42844790e-02f, -3.88746313e-03f, -2.62628328e-02f,
  -6.81519182e-03f, -4.46089245e-02f, 1.04107291e-01f, 1.19038997e-02f, -8.16865936e-02f, 2.55057067e-02f, -9.31339264e-02f, 4.60982285e-02f, 1.69327110e-02f, 1.16335906e-01f,
  -7.13093579e-02f, -6.54884707e-03f, -9.26271081e-02f, -5.23199998e-02f, 4.88154180e-02f, -1.77783575e-02f, 1.49184570e-03f, 1.50169656e-02f, -2.76371334e-02f, -9.65569019e-02f,
  1.22949682e-01f, -1.17688045e-01f, 2.55826991e-02f, 7.99901336e-02f, 4.20448296e-02f, -3.08796205e-02f, -4.76844842e-03f, -1.81322489e-02f, -6.45145308e-03f, 6.77591339e-02f,
  8.89929291e-03f, -9.17677358e-02f, 3.15039717e-02f, 3.74211706e-02f, -3.20595317e-02f, 7.06196502e-02f, -1.21606499e-01f, 3.79341803e-02f, -2.12631803e-02f, 2.43811682e-02f,
  -1.01484634e-01f, 3.99096496e-02f, -9.24284607e-02f, -1.18945248e-01f, -4.97732460e-02f, -2.45277993e-02f, -8.99468642e-03f, -9.26382840e-02f, -1.16322473e-01f, 2.98129264e-02f,
  -7.61641026e-01f, 4.28547531e-01f, 2.59521276e-01f, -2.10595295e-01f, -5.12379184e-02f, 1.83912784e-01f, 5.12973890e-02f, -9.22583342e-02f, -2.46682018e-01f, 8.50263759e-02f,
  7.33487234e-02f, -5.13412207e-02f, 1.95332825e-01f, 1.66781425e-01f, -2.12892860e-01f, 2.46413171e-01f, -9.74324048e-02f, -1.35021582e-01f, 6.56773672e-02f, -2.05867603e-01f,
  -1.28204674e-01f, 4.99291793e-02f, 1.47726357e-01f, 1.70256853e-01f, -1.48449698e-02f, -4.83705699e-02f, -2.14659169e-01f, 2.15261519e-01f, 9.64078009e-02f, 2.27643922e-01f,
  -2.27620602e-01f, -3.27432007e-01f, -1.94637373e-01f, -8.01126063e-02f, -2.06069544e-01f, -1.41288146e-01f, -8.95833075e-02f, 9.43033695e-02f, -5.21709723e-03f, -2.27893498e-02f,
  -1.08764462e-01f, -2.05755159e-02f, 3.08384430e-02f, -3.01644264e-04f, -1.42358959e-01f, 4.15241010e-02f, 7.82102495e-02f, 1.00874312e-01f, 3.10050920e-02f, 4.66981642e-02f,
  8.24887305e-02f, 6.41628578e-02f, -6.27608597e-02f, 2.89292447e-02f, 3.29438262e-02f, 6.87679499e-02f, 1.59119591e-02f, 1.03521571e-02f, -6.18659966e-02f, -1.97819564e-02f,
  -7.27866637e-03f, -5.42149656e-02f, 1.60130188e-02f, 5.49669890e-03f, 8.32566060e-03f, 1.95099581e-02f, -5.06820716e-03f, 3.22653283e-03f, -3.09605021e-02f, 6.88337302e-03f,
  -8.62892494e-02f, -3.94509770e-02f, -9.39167738e-02f, -4.63471897e-02f, -4.11704816e-02f, -4.88508716e-02f, 1.03820860e-02f, -9.70203280e-02f, 3.96346599e-02f, 1.42369489e-03f,
  -2.01237411e-03f, -1.31098507e-02f, 3.25032622e-02f, -3.15660462e-02f, 2.41375947e-03f, 4.73765098e-02f, -3.27119492e-02f, 2.44570300e-02f, -2.25837417e-02f, 1.47205582e-02f,
  -4.09116387e-01f, -4.62277323e-01f, -8.01318884e-02f, -1.01002090e-01f, -7.08440468e-02f, -1.27390146e-01f, -2.54264753e-03f, -5.31309657e-02f, -9.88675207e-02f, -7.56771937e-02f,
  -2.99402792e-02f, -4.62985113e-02f, -1.07717931e-01f, -1.19305179e-02f, 8.93004835e-02f, -2.06095111e-02f, -4.28850576e-02f, -1.07768282e-01f, -1.27958566e-01f, -1.14913005e-02f,
  -4.37359661e-02f, -5.76645508e-02f, 4.23308350e-02f, -5.17142862e-02f, -9.19707566e-02f, -8.96426886e-02f, -5.29237352e-02f, 1.63348708e-02f, 1.50198368e-02f, 2.77141365e-03f,
  1.43028319e-01f, -1.78769231e-02f, 2.21743703e-01f, 1.99719548e-01f, -6.26972467e-02f, -5.47399037e-02f, 9.06833410e-02f, -9.79458466e-02f, 1.07392699e-01f, -4.39670347e-02f,
  -1.43667310e-01f, 1.61522523e-01f, -9.05497968e-02f, -2.22561862e-02f, -8.91392007e-02f, -1.28190324e-01f, 7.73389116e-02f, 6.96263239e-02f, 4.64765765e-02f, 1.32667437e-01f,
  -2.45542987e-03f, -1.45548463e-01f, -2.53778752e-02f, -8.66432413e-02f, -2.79383715e-02f, 5.21710925e-02f, -1.05027249e-02f, 5.31462505e-02f, 5.97997867e-02f, -8.26854445e-03f,
  -4.72667441e-02f, 8.45894441e-02f, -3.29994746e-02f, -4.11760397e-02f, 3.46761420e-02f, 9.24259832e-04f, -7.75176159e-04f, 1.27840182e-02f, 4.46426235e-02f, 9.13513452e-03f,
  9.15244520e-02f, -5.85988164e-02f, 3.49537879e-02f, -8.86963010e-02f, 3.57800652e-03f, -6.54917210e-02f, -9.49753798e-04f, 1.04949728e-01f, 7.86402747e-02f, 9.46084931e-02f,
  -1.82174277e-02f, -1.24938944e-02f, -8.04809295e-03f, 4.03859690e-02f, -2.14510243e-02f, 5.49646430e-02f, 1.00745261e-03f, 3.75307351e-02f, 9.97378379e-02f, 1.10724255e-01f,
  6.75330684e-02f, -4.23810519e-02f, 4.05905768e-02f, -2.40735821e-02f, -6.54411614e-02f, -4.24686186e-02f, 1.65308937e-02f, 4.88361456e-02f, -4.39087190e-02f, -3.08735594e-02f,
  1.30266941e-03f, 5.97625896e-02f, 7.92846158e-02f, -1.83337815e-02f, 5.03916033e-02f, 2.41120327e-02f, 5.93554340e-02f, 3.27104218e-02f, -3.32828029e-04f, -1.98687576e-02f,
  -1.26494421e-02f, 2.70336121e-02f, -1.93923700e-03f, -5.28241321e-02f, 4.44624461e-02f, -1.27778044e-02f, -3.99441011e-02f, 1.31747443e-02f, -4.99065779e-03f, 6.76013604e-02f,
  -1.23879828e-01f, -7.28499815e-02f, 1.96415000e-02f, 4.85312678e-02f, -5.43098152e-02f, 4.51475307e-02f, -5.26720881e-02f, 3.14613357e-02f, -6.45947307e-02f, 1.96147263e-02f,
  2.49266848e-02f, 9.53398719e-02f, 2.48203743e-02f, -3.52991596e-02f, 3.23700421e-02f, -6.87664971e-02f, -4.95829200e-03f, 4.89792228e-02f, -2.87636630e-02f, -2.04044264e-02f,
  2.31904574e-02f, -9.78089869e-03f, 5.63431233e-02f, -2.40592547e-02f, 5.15411049e-02f, -5.49933016e-02f, 7.65335187e-03f, 3.57280113e-02f, 7.27797076e-02f, -4.48571369e-02f,
  2.47046538e-02f, 1.37741774e-01f, 4.51466814e-02f, -9.09135044e-02f, 4.58170883e-02f, -3.48065615e-01f, -2.14365676e-01f, -8.35781842e-02f, 1.60283491e-01f, 1.69840068e-01f,
  -4.64672968e-02f, 8.85226950e-02f, -3.66805345e-02f, -1.78776085e-01f, -3.14208120e-01f, -4.22204332e-03f, -2.68723667e-01f, -1.31069407e-01f, -6.46351725e-02f, -7.92605728e-02f,
  -8.61490443e-02f, -3.77984680e-02f, -5.40146604e-02f, 2.75292434e-02f, 4.53888401e-02f, 4.82727215e-02f, -2.63208505e-02f, 7.66412020e-02f, -1.10824332e-02f, -7.97635540e-02f,
  -3.76402177e-02f, -3.78844291e-02f, -6.55387044e-02f, -1.75498519e-02f, -1.07384503e-01f, -4.79560271e-02f, -1.07273059e-02f, 8.82219803e-03f, 6.89107180e-02f, 5.08403592e-02f,
  1.92563310e-02f, -2.26771254e-02f, 3.86578590e-02f, -2.93006860e-02f, 9.18429941e-02f, 3.63446139e-02f, -4.29346375e-02f, -2.12744828e-02f, 9.10879001e-02f, 2.35757679e-02f,
  7.01124445e-02f, -9.10772290e-03f, 4.91933525e-03f, 3.54649052e-02f, 4.79272529e-02f, 4.06990480e-03f, 1.83609836e-02f, -5.53701371e-02f, -7.68187568e-02f, -1.93443727e-02f,
  3.73435840e-02f, 3.46444398e-02f, 3.45265530e-02f, 3.05297244e-02f, -6.39539286e-02f, 2.41421387e-02f, 2.88408790e-02f, 7.06477314e-02f, -6.07736185e-02f, -8.04707333e-02f,
  7.39208143e-03f, 3.14105360e-04f, 1.19361505e-02f, 4.19294834e-02f, 5.55099212e-02f, 5.05110202e-03f, 6.55998141e-02f, -1.33973062e-02f, -8.42238069e-02f, -8.23794678e-02f,
  -2.64606439e-02f, 4.39899508e-03f, -6.01015380e-03f, 7.28735700e-02f, 2.41957419e-02f, -7.16546848e-02f, -4.40498963e-02f, -5.16812317e-02f, 2.38936190e-02f, -8.95148069e-02f,
  -1.17514722e-01f, -9.88752991e-02f, 6.39271513e-02f, 5.21891415e-02f, -9.48997140e-02f, -7.12470151e-03f, 6.35675937e-02f, -1.50251482e-03f, -2.33176351e-02f, -9.69617069e-02f,
  -3.79064381e-02f, -3.15134488e-02f, -1.17368121e-02f, -4.17909175e-02f, 1.03179114e-02f, 3.11259814e-02f, -3.35147716e-02f, 8.64793584e-02f, -1.01412393e-01f, -7.57434592e-02f,
  7.45750591e-02f, -4.66090776e-02f, 5.52158430e-02f, 2.28232164e-02f, -1.21730147e-02f, 4.55059335e-02f, -1.20929005e-02f, 3.95440646e-02f, -1.32537838e-02f, -3.78577970e-02f,
  -1.00343175e-01f, -6.02828013e-03f, -2.34502435e-01f, -1.98362708e-01f, -1.78037643e-01f, -2.57302999e-01f, -2.66166896e-01f, -6.20645136e-02f, 2.24109188e-01f, 4.35543992e-03f,
  -1.67250767e-01f, 1.48642823e-01f, 1.77842349e-01f, -3.35736722e-01f, 7.61022717e-02f, 1.40494004e-01f, -2.95059085e-01f, -1.58035710e-01f, -1.27154216e-02f, -1.74777865e-01f,
  -7.70808086e-02f, -1.73851714e-01f, -2.01799735e-01f, -3.63601707e-02f, -2.78085530e-01f, -1.60051256e-01f, -2.00721230e-02f, -7.84096718e-02f, -1.65968701e-01f, -7.83220008e-02f,
  -1.96804628e-01f, 7.50727504e-02f, -1.87496208e-02f, 3.23649682e-02f, 2.87550185e-02f, -6.38010129e-02f, -1.03336303e-02f, -1.10897109e-01f, -6.18024953e-02f, -3.56978388e-04f,
  1.03408560e-01f, -1.55792804e-03f, 5.43140173e-02f, 2.72111818e-02f, -6.49323761e-02f, -4.56703966e-03f, 2.60089468e-02f, -3.40028619e-03f, -8.51912498e-02f, -4.12753262e-02f,
  1.25922514e-02f, 5.31177521e-02f, -2.13103388e-02f, 6.56485856e-02f, 1.85828947e-04f, 1.42568806e-02f, 5.76453917e-02f, 4.09984775e-02f, -4.69149053e-02f, 2.98044346e-02f,
  -3.47873904e-02f, -4.43091989e-02f, -5.75439706e-02f, -4.17658128e-02f, 4.40905876e-02f, 4.79215086e-02f, 6.60843030e-02f, -2.42055627e-03f, 5.10594286e-02f, -2.23081615e-02f,
  -3.29322703e-02f, 1.87660065e-02f, 7.31662363e-02f, 1.69370901e-02f, -1.98889747e-02f, -2.03362368e-02f, -6.89534917e-02f, 3.99115421e-02f, -2.04061456e-02f, 8.43770131e-02f,
  -1.20564224e-03f, -4.77799363e-02f, 3.47292311e-02f, -5.29614612e-02f, -6.54236749e-02f, -1.78559367e-02f, -3.35462652e-02f, -8.26842990e-03f, -3.27004753e-02f, 2.57341228e-02f,
  6.48823008e-02f, 6.98323175e-02f, -2.25055851e-02f, 9.10199806e-02f, -5.68865985e-03f, 7.83719402e-03f, -9.04920474e-02f, 7.21714571e-02f, -2.10417435e-02f, 2.23043505e-02f,
  5.11187688e-02f, 9.55417845e-03f, 3.13812401e-03f, 1.84335653e-02f, 2.10423185e-03f, -3.17553654e-02f, 2.54571950e-03f, -7.26522738e-03f, 1.52377766e-02f, -5.26642874e-02f,
  -4.15652618e-03f, 1.01529211e-01f, 5.73494062e-02f, 5.05491309e-02f, -9.77817737e-03f, 3.97665650e-02f, 2.83519905e-02f, 2.65662931e-02f, 6.75861165e-02f, 3.35935205e-02f,
  8.29342008e-02f, 1.70531496e-01f, -1.62649274e-01f, -3.87921073e-02f, 1.09366238e-01f, 2.02845037e-01f, 2.07154602e-01f, 6.42614216e-02f, 1.14324622e-01f, 2.70262390e-01f,
  2.41517738e-01f, 1.28060207e-01f, -2.45450176e-02f, 3.16059738e-01f, 1.00552380e-01f, 9.03936550e-02f, 3.32628250e-01f, 1.91271141e-01f, -5.96373975e-02f, 8.58323723e-02f,
  3.69237959e-02f, 1.84373930e-01f, -9.98037457e-02f, 3.66696203e-03f, 1.09518111e-01f, -1.61602393e-01f, -7.01583549e-03f, -2.42715910e-01f, 4.59232032e-02f, 9.57830846e-02f,
  8.81946236e-02f, 6.93574622e-02f, -4.95072715e-02f, -1.54761290e-02f, 1.61941932e-03f, -9.04314443e-02f, -1.66669309e-01f, -9.79787707e-02f, -2.77734622e-02f, 1.37673328e-02f,
  2.85221133e-02f, 2.23904150e-03f, 2.25451756e-02f, -1.75980832e-02f, 3.07664536e-02f, -8.68817568e-02f, -5.81146926e-02f, 7.36141279e-02f, -6.59431294e-02f, -1.17639238e-02f,
  -9.41939428e-02f, 4.63344045e-02f, 3.73966433e-02f, 3.42093520e-02f, -5.77639081e-02f, -3.65788154e-02f, -8.27127770e-02f, -9.97218397e-03f, 1.97326131e-02f, 7.53609762e-02f,
  3.38371261e-03f, -3.72437611e-02f, 1.94053594e-02f, -4.10359763e-02f, -6.50381818e-02f, -5.57449646e-02f, 6.32467046e-02f, 3.97718735e-02f, 4.42631135e-04f, 6.63309544e-02f,
  2.54486632e-02f, -3.79507951e-02f, 1.08494274e-02f, -1.07350107e-02f, 6.83828443e-02f, -4.77801748e-02f, 3.69572453e-02f, 2.74848994e-02f, -6.15244508e-02f, -3.54488418e-02f,
  1.36192758e-02f, 7.80583695e-02f, 2.18983404e-02f, -1.25166578e-02f, 3.74242216e-02f, -6.07107133e-02f, 3.15655470e-02f, 2.18564514e-02f, -7.74678513e-02f, -1.72568895e-02f,
  1.17665738e-01f, 3.08569428e-02f, 3.66356294e-03f, -1.12353079e-01f, -4.37971428e-02f, 9.82808769e-02f, -7.92779867e-03f, -1.93043482e-02f, 1.06925182e-02f, 4.03407775e-02f,
  -4.47454676e-02f, -1.19233109e-01f, 3.71597074e-02f, 2.08407384e-03f, -7.14341477e-02f, 1.70381293e-01f, 3.73324119e-02f, 1.20878862e-02f, 3.10561433e-02f, 7.58201778e-02f,
  -7.23577337e-03f, 4.48801089e-03f, -4.27240171e-02f, -6.75668716e-02f, 3.25296335e-02f, 3.58815789e-02f, -7.14269951e-02f, -1.41141759e-02f, 4.08327095e-02f, 1.57149434e-02f,
  -5.31974509e-02f, -1.21156693e-01f, 1.02231346e-01f, -2.54325173e-03f, 6.56703860e-02f, 6.56843334e-02f, 1.01524303e-02f, 1.39341116e-01f, 1.42114341e-01f, 1.43094063e-02f,
  -9.36646163e-02f, -1.85000643e-01f, -2.86258906e-02f, -1.34637073e-01f, -4.08046246e-02f, -7.64899701e-02f, -2.14418415e-02f, 1.65434647e-02f, 8.76883492e-02f, -4.81560715e-02f,
  -1.21766329e-02f, 1.08426232e-02f, 4.58425172e-02f, -5.34972548e-02f, -3.40624042e-02f, -3.18841301e-02f, 7.04534873e-02f, 1.65645078e-01f, 4.65523591e-03f, 6.28191680e-02f,
  3.00697573e-02f, -4.38399389e-02f, 4.88989577e-02f, 1.99712925e-02f, 3.24061848e-02f, -6.56721219e-02f, 4.07912470e-02f, 9.19735525e-03f, 9.31656659e-02f, -1.80497300e-02f,
  -7.04369247e-02f, 5.69536686e-02f, -1.02147304e-01f, 5.77255115e-02f, 7.33549818e-02f, -3.93759236e-02f, 1.18305860e-02f, -5.69581203e-02f, 4.61323708e-02f, -4.42913547e-02f,
  2.43931748e-02f, 7.88752288e-02f, -2.33882852e-02f, 5.95181063e-02f, 7.18820021e-02f, 7.58341402e-02f, -4.06345986e-02f, 7.47369975e-02f, -7.93160945e-02f, 8.75731558e-02f,
  9.84555557e-02f, 7.46812150e-02f, 1.62886959e-02f, -2.84443311e-02f, 3.70295048e-02f, -4.37143855e-02f, 8.03227201e-02f, -2.11303383e-02f, 8.33055377e-03f, 8.10138360e-02f,
  -3.42492722e-02f, 2.18130760e-02f, -3.11094597e-02f, 3.01052742e-02f, 8.48429054e-02f, -9.13959295e-02f, 3.60055789e-02f, -3.00940778e-02f, -6.04498088e-02f, -3.02368570e-02f,
  -2.41269879e-02f, -2.49176603e-02f, 7.47177079e-02f, -1.15592266e-02f, 7.19831064e-02f, 8.04267302e-02f, 3.55368331e-02f, 8.91956091e-02f, -5.40321618e-02f, 7.97644556e-02f,
  1.04895137e-01f, 2.43997341e-03f, 7.80691504e-02f, 1.87903084e-02f, -1.22772390e-02f, -6.08720258e-02f, 7.28580877e-02f, -6.76814914e-02f, 4.05122730e-04f, -3.95187140e-02f,
  -5.94630884e-03f, -1.78521220e-02f, 3.85093247e-03f, -5.94578125e-02f, -3.56281884e-02f, 2.49303915e-02f, -1.61289312e-02f, -5.97520433e-02f, 1.76936910e-02f, 8.53787363e-02f,
  -5.57350740e-02f, 6.33768039e-03f, 3.45659666e-02f, 7.09057674e-02f, -7.12426379e-02f, 6.19070195e-02f, -5.63241467e-02f, -1.72642134e-02f, 1.02427088e-01f, -4.53659594e-02f,
  3.19087148e-01f, -1.13556229e-01f, -3.85878831e-01f, -6.16491772e-02f, 2.76828289e-01f, 2.57318199e-01f, 1.48988096e-02f, -3.68753867e-03f, -1.36790588e-01f, -1.53939221e-02f,
  4.03366089e-02f, -6.99559972e-02f, -3.74477565e-01f, 3.30244809e-01f, 2.01916128e-01f, -1.76768899e-01f, 3.18803370e-01f, 1.48981407e-01f, -3.59973945e-02f, 7.36466795e-02f,
  -2.30147745e-02f, 4.62095112e-01f, -1.84396297e-01f, 2.50878751e-01f, 1.92276686e-01f, -8.48472491e-02f, 1.11018963e-01f, -2.06745341e-01f, 2.75294185e-01f, 2.66625971e-01f,
  3.86675522e-02f, 2.79132240e-02f, -8.49446505e-02f, -2.80363727e-02f, -5.45973331e-02f, 1.02953970e-01f, 3.46696675e-02f, 7.20570087e-02f, 1.12596983e-02f, -4.01068069e-02f,
  -5.73927537e-02f, 7.86384642e-02f, 5.92957623e-02f, 3.57914194e-02f, 7.49371201e-02f, 2.91897412e-02f, -7.66680092e-02f, -1.13839135e-01f, -9.68815386e-02f, -6.80667013e-02f,
  -1.25067398e-01f, 5.70050534e-03f, -7.56893083e-02f, -3.91159393e-02f, -1.33948237e-01f, 4.42113131e-02f, -1.86300080e-03f, -6.22327328e-02f, 9.11238715e-02f, 8.40712562e-02f,
  1.41688541e-01f, 4.97601070e-02f, -1.72934458e-02f, 1.47300847e-02f, 6.94947243e-02f, 4.27078679e-02f, -8.38982966e-03f, 2.80262269e-02f, -7.20187053e-02f, -5.26836468e-03f,
  -4.19920571e-02f, -3.91864330e-02f, 3.26420404e-02f, 2.72370875e-02f, 5.35356626e-02f, 4.20646854e-02f, -4.65711392e-02f, 8.03479925e-02f, -5.76156154e-02f, -6.38563000e-03f,
  1.60276145e-02f, 4.96417917e-02f, -3.17112282e-02f, -5.81701137e-02f, 3.05727720e-02f, -3.18695530e-02f, 6.83690533e-02f, -2.66752355e-02f, -1.27972826e-01f, 1.29289571e-02f,
  7.01650977e-02f, 7.65392259e-02f, -2.03766227e-02f, 8.43328312e-02f, -2.08574422e-02f, 1.25753477e-01f, -7.72239873e-03f, 7.99428150e-02f, 2.37533320e-02f, -6.17139880e-03f,
  4.11316380e-02f, 7.61730131e-03f, 8.50686952e-02f, 3.34600024e-02f, -1.85059179e-02f, -3.48280370e-02f, 6.12100586e-02f, 5.34632765e-02f, 2.08374001e-02f, 7.38215223e-02f,
  -6.04466982e-02f, -1.84439868e-02f, -1.73608874e-04f, -4.69239429e-02f, 7.17645586e-02f, -3.44056706e-03f, 3.15270685e-02f, -1.65809859e-02f, 2.10688971e-02f, -7.04781786e-02f,
  1.41801462e-01f, 9.73265711e-03f, -1.14961229e-01f, -3.84536386e-02f, 4.36490774e-02f, -2.55669594e-01f, -1.80635840e-01f, 3.76653001e-02f, 4.60605435e-02f, 1.10802939e-02f,
  -1.96287874e-02f, 4.27547842e-02f, -3.46504524e-02f, 1.36107132e-01f, 1.11379676e-01f, -1.84688699e-02f, 2.41762586e-02f, -7.73541257e-02f, 1.38570353e-01f, 6.17401004e-02f,
  1.66297182e-01f, 2.25156814e-01f, 1.46266341e-01f, 8.97573307e-03f, 1.34009406e-01f, 5.74272200e-02f, 1.18425697e-01f, -8.08101147e-02f, 2.62106936e-02f, 1.84340950e-03f,
  3.67935896e-02f, 1.97167233e-01f, 8.60392228e-02f, 2.82594636e-02f, -2.88633397e-03f, 2.40159146e-02f, -2.50989795e-02f, -2.50265859e-02f, 5.66411093e-02f, -2.92781573e-02f,
  1.01702334e-02f, 9.96964201e-02f, 2.77415030e-02f, 5.53658195e-02f, -7.82684702e-03f, -7.76684331e-03f, -3.87385711e-02f, -2.39188746e-02f, -1.25262514e-02f, -3.46056484e-02f,
  -4.99240942e-02f, 6.82793409e-02f, -6.22347780e-02f, 2.91783977e-02f, 4.32114722e-03f, -1.42648695e-02f, -8.68967474e-02f, -3.88870426e-02f, -7.63380975e-02f, -2.61935499e-02f,
  -7.12551735e-03f, -4.43146229e-02f, -8.30523595e-02f, 6.21219426e-02f, -9.94060114e-02f, -1.38329426e-02f, -5.09677492e-02f, 3.60206626e-02f, -3.97572294e-03f, 5.56401126e-02f,
  -1.71358045e-02f, -6.24474362e-02f, 7.40370154e-02f, -5.05831987e-02f, -2.13352460e-02f, 4.98272628e-02f, -7.22925365e-02f, 4.16515954e-03f, 6.62685558e-02f, -3.78966592e-02f,
  2.64952537e-02f, -4.43194434e-02f, -4.87489849e-02f, -1.51409497e-02f, -5.16357571e-02f, -8.08440074e-02f, 6.81147561e-04f, 7.19236806e-02f, -6.07120432e-02f, 4.65442836e-02f,
  -6.45068139e-02f, 3.63802798e-02f, -9.18556824e-02f, 2.20870450e-02f, -5.95449284e-02f, 3.24742980e-02f, -2.61062826e-03f, 2.88986862e-02f, -3.69443111e-02f, -2.88833142e-03f,
  -5.34448735e-02f, -4.40697819e-02f, -4.69225161e-02f, 6.65752739e-02f, -3.95869128e-02f, -5.32480143e-03f, 4.99865599e-02f, -7.30678588e-02f, -2.50855815e-02f, 9.42758694e-02f,
  -3.35835330e-02f, -5.49965836e-02f, -4.31208685e-02f, -4.86938395e-02f, 4.93414029e-02f, -1.67224910e-02f, 4.60813977e-02f, 7.56214000e-03f, 6.49365038e-02f, 2.88002118e-02f,
  4.20207798e-01f, 8.33178237e-02f, 3.21399420e-02f, 5.77825308e-02f, -8.24127421e-02f, 1.18673570e-01f, 6.62345216e-02f, -5.91985025e-02f, 4.21798453e-02f, -4.60039675e-02f,
  -2.65311655e-02f, 6.85783476e-02f, -1.12339959e-01f, 3.16139236e-02f, -9.54406932e-02f, -1.38584405e-01f, -1.96257811e-02f, 3.17660756e-02f, -2.00363083e-05f, 8.62513483e-02f,
  7.80393854e-02f, -6.17299415e-03f, -1.07615061e-01f, -1.31387979e-01f, 9.03962329e-02f, 1.09250441e-01f, -1.69233114e-01f, -1.38857782e-01f, -8.78446847e-02f, -2.41378192e-02f,
  -2.40982231e-02f, 3.59618552e-02f, 4.08644080e-02f, 4.51189242e-02f, 6.08574040e-02f, 1.32146388e-01f, -5.75165171e-03f, -1.36917889e-01f, 4.60020415e-02f, 6.11221753e-02f,
  7.05543235e-02f, -1.08325519e-02f, 6.25849813e-02f, -8.69816318e-02f, 2.89414600e-02f, 9.10683796e-02f, -9.30325408e-03f, 4.55026999e-02f, -1.61261000e-02f, -2.72033270e-03f,
  7.11275786e-02f, 1.23457544e-01f, 2.47982866e-03f, -3.57467472e-03f, 5.45455851e-02f, 3.42052802e-02f, -8.50450422e-04f, 3.76990326e-02f, 8.79802182e-02f, -2.93976776e-02f,
  2.09404770e-02f, 2.11648289e-02f, -1.31540382e-02f, 7.16825724e-02f, 8.41786060e-03f, 2.60757785e-02f, -6.16172031e-02f, 1.36346454e-02f, 3.97215635e-02f, -2.73630116e-02f,
  3.27974483e-02f, -2.25481205e-03f, -3.93896224e-03f, -3.75596434e-02f, 7.29663938e-04f, 7.68104941e-02f, -7.74876997e-02f, 2.04859544e-02f, -2.33096294e-02f, -4.05693278e-02f,
  -1.79940704e-02f, 2.63592750e-02f, -2.90778112e-02f, 8.03275481e-02f, 1.92095302e-02f, -2.05562189e-02f, -9.34270248e-02f, 5.09581575e-03f, 2.65960321e-02f, 6.25276715e-02f,
  -9.09676552e-02f, -9.65891555e-02f, -5.45875495e-03f, -7.24489167e-02f, -9.71087068e-03f, 2.06541009e-02f, -9.84347314e-02f, 5.63125871e-02f, -1.74707882e-02f, -7.69350678e-02f,
  1.19233117e-01f, 1.45049682e-02f, -4.98494171e-02f, 5.24536036e-02f, 3.55834462e-04f, -2.69363318e-02f, -5.41729517e-02f, 3.31526101e-02f, 4.47936133e-02f, -8.94129393e-04f,
  4.10049371e-02f, 3.84466499e-02f, 9.31441486e-02f, -3.47321182e-02f, -2.97728665e-02f, -2.67005730e-02f, 7.00606480e-02f, -1.91456247e-02f, 7.95879811e-02f, 7.90009368e-03f,
  1.60195410e-01f, 1.79012105e-01f, 2.06520095e-01f, 1.11810729e-01f, -7.97572583e-02f, -2.01919973e-01f, 7.93883484e-03f, -1.09727040e-01f, 1.07365074e-02f, 9.97300744e-02f,
  -1.17339730e-01f, 3.37342203e-01f, -6.58688992e-02f, 9.19848531e-02f, -2.73420393e-01f, -9.33154896e-02f, -8.86903033e-02f, 1.53920865e-02f, 6.99542835e-02f, -8.84160027e-02f,
  1.11429477e-02f, -1.16971768e-01f, 8.73239711e-02f, -8.11037272e-02f, 1.37956768e-01f, 1.95162803e-01f, -8.59154537e-02f, 1.87094919e-02f, 9.28746238e-02f, -7.38669112e-02f,
  -2.71156488e-04f, 7.05092996e-02f, 5.29101584e-03f, 8.17944258e-02f, 3.60909733e-03f, -2.25449763e-02f, 6.11554235e-02f, 4.44976613e-02f, -6.00648820e-02f, 3.01457103e-02f,
  5.13265887e-03f, -8.99229571e-02f, 3.56611572e-02f, -2.82645579e-02f, -4.13492396e-02f, 6.05888329e-02f, 5.45114502e-02f, 1.22902572e-01f, 3.52817588e-02f, 8.05646777e-02f,
  4.50929850e-02f, 1.01225683e-02f, 5.79173826e-02f, -4.25163805e-02f, -2.28011478e-02f, -4.71923081e-03f, -7.49955550e-02f, 2.46425066e-02f, 4.47453633e-02f, -2.24769469e-02f,
  2.91174464e-02f, -3.38104367e-02f, 2.65974998e-02f, -3.07055656e-02f, 5.72474077e-02f, -3.57082821e-02f, -8.39845277e-03f, -3.96042392e-02f, 8.25484768e-02f, -9.06964205e-03f,
  -7.07804188e-02f, 7.01720864e-02f, 5.47040738e-02f, 4.15634997e-02f, 5.33083156e-02f, -5.83949946e-02f, 4.18292778e-03f, -4.30245921e-02f, 7.66536407e-03f, 4.66427673e-03f,
  2.36504097e-02f, -8.03507417e-02f, 2.77771931e-02f, 1.51455943e-02f, 5.51112443e-02f, -6.55848011e-02f, -5.66441156e-02f, 3.82134691e-02f, -9.19538811e-02f, -1.05206311e-01f,
  -1.18217140e-01f, -2.55084615e-02f, -1.77861843e-02f, 1.26989102e-02f, -3.45929526e-02f, 3.49348001e-02f, -8.57883915e-02f, 3.54831815e-02f, -7.27973580e-02f, -8.97277370e-02f,
  -2.05232110e-02f, 1.57879724e-04f, 5.08171879e-03f, -1.60348341e-02f, 3.00081782e-02f, 5.47046028e-02f, 7.76840886e-03f, -4.34358045e-02f, -2.47158837e-02f, -2.81558447e-02f,
  4.94597442e-02f, -5.42660616e-02f, -7.55208125e-03f, -5.54150492e-02f, -3.86983678e-02f, 2.54239533e-02f, 5.51886857e-02f, 3.48934978e-02f, 3.42649445e-02f, -6.15966134e-03f,
  4.72131977e-03f, 1.68857425e-02f, -1.39697894e-01f, -1.41044065e-01f, 4.73788492e-02f, -1.06740281e-01f, -6.44027069e-03f, -4.08600736e-03f, -2.49177501e-01f, 1.38867393e-01f,
  1.45761132e-01f, 1.85607094e-02f, -4.90789674e-02f, -1.82960749e-01f, -2.76330829e-01f, -3.59792948e-01f, -6.30992353e-02f, -6.08517230e-02f, -1.90392613e-01f, 2.02105835e-01f,
  -1.11667002e-02f, 2.27310862e-02f, -5.84968477e-02f, 1.88120916e-01f, 9.09287110e-02f, 2.50616312e-01f, 3.06663036e-01f, 8.68883505e-02f, 1.98421791e-01f, -9.05241892e-02f,
  -7.76707903e-02f, -1.28328890e-01f, -1.66610684e-02f, -1.32357687e-01f, 6.34693950e-02f, 1.31285802e-01f, 2.18145382e-02f, -3.52039374e-02f, 1.11027267e-02f, -2.32610740e-02f,
  1.63005199e-02f, -6.43722191e-02f, -7.30955824e-02f, -6.43331334e-02f, -2.43161302e-02f, 5.55165820e-02f, 5.56039251e-03f, 3.42269801e-02f, -1.96950994e-02f, 2.60355286e-02f,
  -2.73585897e-02f, 6.75314516e-02f, 3.92701942e-03f, 9.40432120e-03f, 1.04954140e-02f, 3.01310029e-02f, 8.79688859e-02f, 1.34820208e-01f, -2.76726577e-02f, -6.05641678e-02f,
  1.45733789e-01f, 5.84055223e-02f, -2.15846533e-03f, -4.35246937e-02f, 5.07898442e-02f, 3.84753868e-02f, 3.40641439e-02f, 1.20198249e-03f, 4.16988544e-02f, 1.14470543e-02f,
  -2.16412228e-02f, 5.29654138e-02f, -6.85101449e-02f, 3.66392806e-02f, 1.04461666e-02f, -9.17537361e-02f, 6.42345920e-02f, 8.18862095e-02f, 6.98666871e-02f, 3.78324986e-02f,
  -4.81254645e-02f, -5.84567226e-02f, 2.54750978e-02f, 3.98887359e-02f, -9.23387036e-02f, 1.11673802e-01f, 9.25361738e-02f, 2.80047972e-02f, 3.43804881e-02f, 6.54913262e-02f,
  6.11239299e-02f, 3.17279071e-01f, 2.07576044e-02f, -7.08828121e-02f, -5.40439039e-03f, 1.15521260e-01f, -9.69955549e-02f, 9.43995826e-03f, 4.78996709e-02f, -3.50704975e-02f,
  1.02202170e-01f, 9.18925554e-02f, 1.01766616e-01f, -2.23760158e-02f, -3.71163385e-03f, 1.30987242e-01f, 1.06523417e-01f, 8.22999701e-02f, 8.70547071e-02f, 5.94016016e-02f,
  1.49777934e-01f, 2.36795526e-02f, 3.69246900e-02f, -4.85645868e-02f, 1.64284259e-02f, 8.64360034e-02f, 3.93943824e-02f, -1.18074659e-03f, 6.37248755e-02f, -3.36518399e-02f,
  2.83168070e-02f, 2.45255202e-01f, 1.95452198e-01f, 1.75446600e-01f, -2.27098450e-01f, -1.12280920e-02f, -8.73238593e-03f, -8.95269066e-02f, 1.44827694e-01f, 1.42811552e-01f,
  -1.61404967e-01f, 2.82027781e-01f, -1.03167266e-01f, 2.27482896e-02f, -1.72891766e-01f, -2.41273522e-01f, 5.82498610e-02f, 2.23305523e-02f, 2.29826793e-02f, 7.05035403e-02f,
  -5.77901006e-02f, -1.85427323e-01f, -1.07306585e-01f, -1.19459160e-01f, 5.66820987e-02f, 2.22053587e-01f, -1.19862854e-01f, -1.03478104e-01f, 1.70088783e-01f, -7.18695596e-02f,
  7.48749673e-02f, 2.03993432e-02f, 1.01884857e-01f, 8.60187598e-03f, 1.01823449e-01f, -3.83231528e-02f, 9.76370722e-02f, -3.85620110e-02f, 3.61875929e-02f, 5.17960563e-02f,
  5.87210506e-02f, -2.44099405e-02f, 4.48672622e-02f, -6.40133396e-02f, 6.32488802e-02f, 9.23957974e-02f, 1.27257198e-01f, 2.09411290e-02f, 1.93597879e-02f, -5.88279478e-02f,
  1.19211944e-02f, 9.01084542e-02f, 2.55633425e-02f, 4.27213684e-02f, -2.83063925e-03f, 6.72897324e-02f, 1.04682110e-01f, 5.67793883e-02f, 1.36822104e-01f, 9.44496021e-02f,
  -5.68705052e-02f, -8.12546015e-02f, -5.53791672e-02f, -4.99216616e-02f, -1.00409783e-01f, -1.02929115e-01f, 5.39901815e-02f, -1.09053455e-01f, -3.30478959e-02f, -8.27307533e-03f,
  2.04676390e-02f, 1.74838919e-02f, -4.54365835e-02f, -1.47095611e-02f, -7.77260065e-02f, -2.81382706e-02f, 2.21714936e-02f, 1.33298626e-02f, 1.65437516e-02f, -1.06151560e-02f,
  -3.60118486e-02f, -5.53874783e-02f, -6.79546148e-02f, -5.78535795e-02f, 4.83584255e-02f, -2.97962525e-03f, 3.65810022e-02f, 3.26430425e-02f, 4.95572910e-02f, -6.28182590e-02f,
  6.25438988e-02f, 1.80980369e-01f, 8.12624097e-02f, 4.73256633e-02f, -2.77011525e-02f, -1.55548728e-03f, -3.51309143e-02f, -1.83536333e-03f, -4.72336300e-02f, -7.54387006e-02f,
  2.92427652e-02f, -5.87118119e-02f, 2.78762057e-02f, 3.97891067e-02f, -8.33877623e-02f, -6.56809136e-02f, 7.57429972e-02f, 1.14533633e-01f, -3.07169091e-02f, -2.12320071e-02f,
  -1.68229570e-03f, 4.28911708e-02f, -3.94969061e-02f, -2.21117400e-02f, 7.20213354e-02f, 1.82263106e-02f, -4.67917211e-02f, 6.77641705e-02f, -1.67828817e-02f, 1.24003924e-01f,
  -8.84643495e-02f, 3.40695441e-01f, 2.33186349e-01f, -8.57287571e-02f, 5.19198924e-03f, 1.87910154e-01f, -8.63763690e-02f, 1.54696837e-01f, 1.06938943e-01f, 7.20603839e-02f,
  -1.53567031e-01f, 1.07942984e-01f, -1.06439456e-01f, 3.64276208e-02f, 5.93611412e-02f, -1.53843062e-02f, 3.01542245e-02f, 1.44510518e-03f, 1.63173452e-02f, 6.89193830e-02f,
  2.05117334e-02f, -7.23768175e-02f, -8.89394507e-02f, -4.53957450e-03f, 6.61956966e-02f, 4.42299806e-02f, -1.69606581e-01f, -8.57025161e-02f, 1.20178685e-01f, -5.96172921e-02f,
  -8.17660913e-02f, -4.13809307e-02f, 4.68818545e-02f, 1.00482836e-01f, 1.85670964e-02f, -4.49986681e-02f, 2.70219967e-02f, -4.13297080e-02f, 1.09017799e-02f, -4.06190380e-02f,
  -3.82632911e-02f, -3.44316252e-02f, 3.84950414e-02f, -7.58461356e-02f, -6.78333687e-03f, -9.12137050e-03f, 3.25829126e-02f, 1.10196523e-01f, 5.36888577e-02f, 1.26382902e-01f,
  9.31690708e-02f, 1.56269893e-01f, 1.90848000e-02f, -3.03896796e-03f, 2.98861898e-02f, 4.63780314e-02f, 7.16643259e-02f, 7.57998154e-02f, -1.31822247e-02f, 1.60350967e-02f,
  3.07729207e-02f, 8.66464525e-02f, 1.71903905e-03f, -9.34364926e-03f, 3.29309776e-02f, -2.67309304e-02f, 1.45194596e-02f, -1.07795380e-01f, 5.12335002e-02f, 2.20119394e-02f,
  4.53772917e-02f, -6.82991892e-02f, -4.38804477e-02f, 3.27360220e-02f, 2.55056676e-02f, -1.44277532e-02f, -1.81130823e-02f, -6.93911836e-02f, -2.25408804e-02f, -1.47513952e-02f,
  -1.29543051e-01f, -6.50939625e-03f, 6.50158077e-02f, 2.75569987e-02f, -9.54923744e-04f, -2.88377274e-02f, 4.21536937e-02f, 3.07360366e-02f, -3.68158636e-03f, -9.17301103e-02f,
  1.69223070e-01f, 2.27247268e-01f, -5.55870496e-02f, -2.06597690e-02f, -5.59422001e-03f, 9.50082615e-02f, 4.66019921e-02f, 3.91551480e-02f, 1.22080490e-01f, -1.05718104e-02f,
  -5.67408353e-02f, -2.44215727e-02f, 8.62739012e-02f, -5.24072126e-02f, 5.50162680e-02f, 9.25822333e-02f, -2.14894284e-02f, 4.88913544e-02f, 2.67910939e-02f, 8.14852957e-03f,
  6.52280301e-02f, -4.54834364e-02f, 3.49671990e-02f, 2.65724175e-02f, -2.50357445e-02f, 2.52405107e-02f, -4.60165627e-02f, 3.44220176e-02f, 8.75030980e-02f, 9.69795212e-02f,
  -1.42085832e-02f, 6.21280447e-02f, 1.52863771e-01f, -4.26935926e-02f, 1.34003967e-01f, 6.71790317e-02f, -1.30072132e-01f, 1.39481248e-02f, 1.49285555e-01f, -3.96995656e-02f,
  -4.80209924e-02f, 1.26661167e-01f, 5.17346784e-02f, -8.39650109e-02f, -1.37721658e-01f, -7.01507414e-03f, -3.88360322e-02f, -8.65720436e-02f, 2.32487731e-02f, 3.97907235e-02f,
  1.93235907e-03f, -2.16809958e-01f, -1.07676655e-01f, -6.57014996e-02f, 8.03194568e-03f, -2.22172146e-03f, -1.35661349e-01f, -1.53971638e-03f, -7.08212610e-03f, 2.21999176e-02f,
  -2.73912903e-02f, -7.04716220e-02f, 3.23605500e-02f, 1.07903227e-01f, 9.38079357e-02f, 9.02648717e-02f, -6.37573674e-02f, 4.67339717e-02f, -8.35071057e-02f, -3.91314551e-02f,
  -9.27391462e-03f, 4.05800976e-02f, -4.36396897e-02f, -8.68948847e-02f, 1.02832958e-01f, -5.54658361e-02f, -6.44775778e-02f, -7.11133424e-03f, 1.28072202e-01f, 9.98667628e-03f,
  -4.03754264e-02f, 1.15032062e-01f, 1.63602587e-02f, 2.55738404e-02f, 1.72647145e-02f, -7.07866549e-02f, -5.18047996e-02f, 8.66103917e-03f, -5.08583337e-02f, 6.78637475e-02f,
  -2.40485873e-02f, -3.00466921e-03f, 9.13022161e-02f, -5.28883422e-03f, -1.42269963e-02f, -7.06692114e-02f, -8.17026477e-03f, 6.14988357e-02f, 2.50555724e-02f, -6.91627637e-02f,
  -1.62114948e-02f, 1.33484155e-02f, 7.50247687e-02f, -3.31097469e-02f, -6.14311025e-02f, -4.46470417e-02f, -8.77873078e-02f, 1.99105013e-02f, -3.82802710e-02f, -2.17064302e-02f,
  5.09022921e-02f, -2.10938137e-02f, -7.29981735e-02f, 5.08442745e-02f, 2.45525949e-02f, 2.12465748e-02f, -3.58881764e-02f, 1.24176994e-01f, -9.18427706e-02f, -1.07514620e-01f,
  -2.88447086e-02f, -2.67292447e-02f, -1.27031216e-02f, -3.01407855e-02f, 6.63547516e-02f, 3.24137323e-02f, -8.11301991e-02f, 2.60479301e-02f, 1.71617921e-02f, -7.89703727e-02f,
  8.33192319e-02f, -1.63748004e-02f, 8.90000537e-02f, 2.60671526e-02f, -7.32246935e-02f, -9.15521458e-02f, -8.84315744e-02f, -3.21171917e-02f, 2.91876961e-02f, -1.43903727e-03f,
  -8.71647801e-03f, 5.69775030e-02f, -8.46614838e-02f, 6.14965335e-02f, -5.72605208e-02f, 5.33177257e-02f, 6.15442498e-03f, 8.95630941e-02f, 6.75688162e-02f, -8.33824277e-02f,
  -4.22494859e-02f, -2.61922121e-01f, -1.92044571e-01f, 6.26630709e-02f, 1.86312973e-01f, 1.22703001e-01f, -1.05602883e-01f, 3.81800681e-02f, -6.97901770e-02f, -1.32708505e-01f,
  -2.17173584e-02f, -4.62405337e-03f, -2.55451173e-01f, 5.05811013e-02f, 1.39006600e-02f, -3.13140810e-01f, 6.38802126e-02f, 5.74660860e-02f, -1.05326138e-01f, 4.76164110e-02f,
  2.04421300e-02f, 1.05772883e-01f, -4.92900647e-02f, 1.92236781e-01f, 7.86590427e-02f, 2.05377787e-01f, 5.16651981e-02f, -2.79377792e-02f, 1.59109131e-01f, 1.54243350e-01f,
  -5.19770905e-02f, -4.84478027e-02f, -5.40745035e-02f, -3.42972055e-02f, 4.23746258e-02f, 6.86666137e-03f, -4.45859693e-02f, 2.88288225e-03f, -4.38012145e-02f, 6.62369579e-02f,
  1.48140481e-02f, 2.27375664e-02f, 1.10634878e-01f, -5.76519184e-02f, 2.16631498e-02f, 7.73556307e-02f, -5.50249824e-03f, -3.45171280e-02f, 8.21910203e-02f, -1.27671510e-01f,
  -1.20303907e-01f, -2.50333976e-02f, -8.34338833e-03f, -1.51881725e-02f, -9.09388363e-02f, 1.69698000e-02f, -8.71942565e-03f, 5.15686199e-02f, 8.49497691e-02f, 5.37310950e-02f,
  -8.53339024e-03f, -1.10839196e-02f, -1.06929466e-01f, -7.73905963e-02f, -5.46293557e-02f, 7.94323012e-02f, -4.66297306e-02f, 7.39388987e-02f, 7.42160017e-03f, -6.19213432e-02f,
  -1.25278197e-02f, -5.42196929e-02f, -2.67840596e-03f, 4.12964895e-02f, 5.19273318e-02f, 6.53886572e-02f, 7.78386667e-02f, 7.51305297e-02f, -5.57153448e-02f, -7.41402805e-02f,
  -8.82144123e-02f, -7.48723187e-03f, 4.14346084e-02f, 9.36831236e-02f, -3.12045608e-02f, -6.14073500e-02f, 1.81277916e-02f, 4.79869470e-02f, 4.75627370e-02f, 6.04414120e-02f,
  -8.78762081e-02f, -2.13518608e-02f, -3.06993630e-03f, 3.80012020e-02f, 3.88712846e-02f, -2.26695854e-02f, -5.87023832e-02f, -2.00631190e-02f, 1.27319628e-02f, 6.71933126e-03f,
  1.07660107e-01f, -3.75252441e-02f, -5.66191822e-02f, -5.20692021e-03f, 2.89756153e-02f, -2.92106029e-02f, -6.96690753e-02f, -6.22984581e-02f, 6.60932884e-02f, 8.44287276e-02f,
  1.32564350e-03f, -2.37573776e-02f, 1.71827730e-02f, -5.47676086e-02f, 9.22871679e-02f, -3.63429822e-02f, 1.01460673e-01f, 6.68632761e-02f, -2.52750516e-02f, 4.54505607e-02f,
  1.63829565e-01f, -1.84748173e-01f, 2.78745368e-02f, 1.45721629e-01f, 1.15928054e-01f, 1.53879285e-01f, 9.18414071e-02f, 6.78404644e-02f, 1.93663701e-01f, -1.02552980e-01f,
  8.89299810e-02f, 4.00683247e-02f, 3.05745169e-03f, 9.09105241e-02f, 1.21372052e-01f, 2.43345574e-02f, 4.73263934e-02f, -6.94782957e-02f, -2.19128095e-02f, 1.13840453e-01f,
  9.80434287e-03f, 4.54476401e-02f, -1.00469217e-02f, -2.26138219e-01f, -2.20788866e-02f, -1.69523209e-01f, -1.16599388e-01f, -5.63696362e-02f, -1.46968901e-01f, -6.59534633e-02f,
  2.25355872e-03f, 7.29552358e-02f, 5.71354479e-02f, -7.53951073e-02f, -5.80646247e-02f, -3.51924896e-02f, 9.43012163e-03f, -1.42430831e-02f, 2.14273371e-02f, -7.76358843e-02f,
  -1.78776067e-02f, 3.15775797e-02f, -4.73362841e-02f, -5.88533422e-03f, -3.72057259e-02f, -2.18805838e-02f, 7.27710128e-02f, -3.08566689e-02f, -5.91959842e-02f, 2.71724258e-02f,
  1.66384447e-02f, -5.28932363e-02f, 7.83868954e-02f, -1.22552682e-02f, -5.38824638e-03f, -3.32396887e-02f, -7.07281604e-02f, -1.93212554e-02f, 5.09388670e-02f, 4.70296806e-03f,
  5.82272634e-02f, -2.65244469e-02f, 4.30564731e-02f, 2.15352774e-02f, -6.84258863e-02f, -3.29621807e-02f, -4.24832925e-02f, -6.77034035e-02f, -4.60430272e-02f, -4.69172522e-02f,
  3.79314385e-02f, -4.30856571e-02f, 8.29882696e-02f, 4.16776165e-02f, 6.92317933e-02f, -1.91275664e-02f, 3.73766385e-02f, -9.26823020e-02f, 6.46643415e-02f, 7.86340609e-02f,
  3.41808647e-02f, -2.04040911e-02f, 1.07217528e-01f, -9.50756371e-02f, -1.15309313e-01f, 3.77863348e-02f, 9.65902861e-03f, -4.94677797e-02f, -5.83083518e-02f, -1.80865789e-03f,
  5.04930243e-02f, -8.19281712e-02f, 8.98007378e-02f, 1.03552490e-02f, 2.32457519e-02f, 5.53321205e-02f, -1.79808233e-02f, -2.16677636e-02f, -7.28534982e-02f, -1.98227782e-02f,
  -7.11965263e-02f, -9.05451924e-02f, 2.94186305e-02f, 9.06768604e-04f, -1.29006058e-01f, 6.40445799e-02f, -7.79113770e-02f, -9.93042253e-03f, -7.49159455e-02f, 3.02534015e-03f,
  -1.89881306e-02f, 3.18046026e-02f, -4.32415353e-03f, 1.69201288e-02f, -1.09374344e-01f, -8.39955062e-02f, 4.70942003e-04f, -1.22165028e-02f, -5.94430864e-02f, 3.16244736e-02f,
  -3.29425365e-01f, 2.47177511e-01f, -1.29081279e-01f, 1.96535543e-01f, -2.01661825e-01f, -3.59535217e-02f, 1.85415149e-01f, -5.86067736e-02f, -1.16809763e-01f, 3.72227490e-01f,
  1.53235137e-01f, 2.29113409e-03f, 9.48173553e-02f, 3.26627642e-01f, -9.06933844e-02f, 1.96512386e-01f, 3.37194890e-01f, 2.25434527e-01f, -9.18695554e-02f, 5.59273697e-02f,
  6.10921085e-02f, 2.63542175e-01f, 1.97356343e-01f, 2.88046915e-02f, 8.80966932e-02f, -9.97422114e-02f, 4.30107899e-02f, -1.73746705e-01f, 1.60526142e-01f, -8.98006558e-03f,
  8.07636827e-02f, -2.50233170e-02f, -6.02823347e-02f, -6.35371134e-02f, 1.00040622e-01f, 1.80608891e-02f, -5.33673353e-02f, -8.07021186e-02f, -4.87225205e-02f, -8.45057070e-02f,
  -5.66397347e-02f, -1.09212317e-01f, -1.92735028e-02f, -4.50440794e-02f, -2.00415272e-02f, -4.13138308e-02f, 2.91378088e-02f, 3.05661187e-02f, 2.06617042e-02f, 3.22783692e-03f,
  1.35976234e-02f, 2.42953990e-02f, 1.94031429e-02f, 8.53789076e-02f, -3.24284658e-02f, 6.29798248e-02f, 6.16124943e-02f, -2.60956269e-02f, -4.39881580e-03f, 1.55289685e-02f,
  -7.07115754e-02f, -3.61927450e-02f, 1.46109564e-02f, 6.33361414e-02f, 3.61526236e-02f, 4.57702689e-02f, 5.20765632e-02f, 2.03951281e-02f, -5.50474860e-02f, 1.06525786e-01f,
  -3.35545130e-02f, 5.23277670e-02f, 3.11919153e-02f, 4.92219217e-02f, 7.58116022e-02f, 1.46515144e-03f, -3.47131230e-02f, 7.06667732e-03f, 1.36992782e-02f, 3.43444198e-02f,
  6.26645470e-03f, -2.14058012e-02f, 5.49630634e-02f, 8.16910490e-02f, -4.33491692e-02f, 3.24473232e-02f, 8.30261335e-02f, -1.71883907e-02f, 2.26089284e-02f, -4.87990528e-02f,
  1.98871613e-01f, 4.65923660e-02f, 1.69061981e-02f, -4.99825515e-02f, -2.41339169e-02f, -3.85720171e-02f, 5.18579676e-04f, -7.69069940e-02f, 3.07154469e-03f, -4.22137119e-02f,
  -4.09991434e-03f, 1.37006268e-02f, -1.85275152e-02f, -3.77253070e-02f, -2.44377833e-02f, -2.52978560e-02f, -1.33084049e-02f, -7.02499785e-03f, 2.16946546e-02f, 3.02938919e-04f,
  -8.48449469e-02f, -3.70972194e-02f, -6.03137389e-02f, -8.28265958e-03f, 5.78420199e-02f, -6.20831437e-02f, -1.86328068e-02f, 2.33508442e-02f, 1.24497190e-02f, 9.16963350e-03f,
  -1.50930688e-01f, 3.31869215e-01f, -5.40010780e-02f, 1.24719732e-01f, -2.02595949e-01f, 9.57479924e-02f, 2.56303281e-01f, -1.89418830e-02f, 2.34236509e-01f, 3.24380040e-01f,
  1.60456933e-02f, 7.33678713e-02f, -8.12109280e-03f, 3.16394836e-01f, 4.20411378e-02f, 1.80348814e-01f, 3.84496570e-01f, 2.67399281e-01f, 4.04099375e-02f, 1.27886787e-01f,
  1.08701978e-02f, 1.75003722e-01f, -4.22662236e-02f, -1.03205338e-01f, 6.51630387e-03f, -1.34449869e-01f, -7.67275319e-02f, -2.62181938e-01f, -6.03962056e-02f, -6.13557361e-02f,
  -3.08313817e-02f, 9.28067118e-02f, -7.08249733e-02f, -2.32227929e-02f, 2.22329777e-02f, -4.67578657e-02f, 8.52165744e-03f, -1.56047553e-01f, 1.66851357e-02f, -1.95442662e-02f,
  -5.52820507e-03f, 1.92855615e-02f, -2.72796005e-02f, 5.17124031e-03f, -7.68268034e-02f, -6.05289117e-02f, -1.12062199e-02f, 4.54094168e-03f, 5.60890920e-02f, -1.01975746e-01f,
  -1.37771918e-02f, -3.95544544e-02f, 2.32299659e-02f, 6.53487742e-02f, 1.98365981e-03f, 7.33893737e-02f, 7.45366588e-02f, -3.36965881e-02f, 1.66541841e-02f, 8.61962736e-02f,
  -7.74721941e-03f, 9.43622962e-02f, 1.85177550e-02f, -4.48548980e-03f, -5.11555523e-02f, -5.00680879e-02f, -1.82151049e-02f, -6.18670695e-02f, -1.59988310e-02f, 3.78312506e-02f,
  3.86924781e-02f, 2.81387456e-02f, -6.44827187e-02f, 6.10168129e-02f, 1.58095639e-02f, 5.13509922e-02f, -6.29262179e-02f, -4.69246134e-02f, -4.37125936e-02f, 4.67178458e-03f,
  -3.10020912e-02f, -8.04370455e-03f, -1.51218781e-02f, -9.12969038e-02f, 2.37212759e-02f, 3.60009708e-02f, 2.50957347e-02f, -1.65190659e-02f, -5.36700375e-02f, -1.22139631e-02f,
  1.51495963e-01f, 2.74575472e-01f, 8.28818753e-02f, 4.29024883e-02f, -1.08764018e-03f, 5.69600016e-02f, -2.90863439e-02f, 7.53981248e-02f, 9.34652612e-02f, 9.09321830e-02f,
  3.38306476e-04f, 5.44213578e-02f, 6.45155832e-02f, -5.96555658e-02f, 8.41282234e-02f, 6.79279938e-02f, 5.42712659e-02f, 7.56502710e-03f, -3.11830789e-02f, -9.73918382e-03f,
  1.90550368e-02f, 4.57545407e-02f, 2.37390399e-02f, 1.39970956e-02f, -6.91170245e-02f, -4.13479805e-02f, -6.72371534e-04f, -6.44738972e-02f, -7.26716220e-02f, 9.78398845e-02f,
  -1.96998894e-01f, 2.26391837e-01f, -2.00978369e-02f, -1.36393607e-02f, 2.46399250e-02f, -2.24927202e-01f, -1.52142823e-01f, 7.84928501e-02f, -3.44545841e-02f, 9.70491990e-02f,
  1.53198808e-01f, -4.58850414e-02f, 1.14369810e-01f, -4.16088589e-02f, -3.60021293e-01f, -1.90479100e-01f, -1.04937620e-01f, -1.44045025e-01f, -3.75563949e-02f, 6.28367439e-02f,
  -1.17852204e-01f, 3.51546928e-02f, -1.01073369e-01f, 2.11271971e-01f, 9.82780755e-02f, -2.68516205e-02f, 1.10622965e-01f, 1.59579486e-01f, 1.92836523e-02f, 2.99826730e-02f,
  -1.89464781e-02f, 1.57718346e-01f, 3.57954353e-02f, -9.44512412e-02f, -1.06131416e-02f, -3.37978341e-02f, -3.24785598e-02f, -5.08335717e-02f, -1.07169099e-01f, -8.07626173e-02f,
  -3.34132798e-02f, -5.49466647e-02f, 1.45102683e-02f, 1.12930052e-01f, 1.01300469e-02f, -2.43277252e-02f, 4.70338427e-02f, 3.72286066e-02f, 4.70664315e-02f, -9.62384567e-02f,
  1.49573414e-02f, -5.15255369e-02f, -9.48535800e-02f, -2.88877133e-02f, 1.99867389e-03f, 1.10433884e-02f, -5.98128475e-02f, 2.08880622e-02f, 6.92531765e-02f, 3.06769125e-02f,
  3.85865569e-02f, 1.46740982e-02f, -1.63942371e-02f, 7.12943748e-02f, 3.47466804e-02f, 5.91880493e-02f, 2.81365030e-02f, 3.33285183e-02f, 1.66689362e-02f, -2.46060994e-02f,
  -2.60851849e-02f, -6.06595129e-02f, 1.48534952e-02f, -4.37033661e-02f, 5.34575544e-02f, 2.19087433e-02f, -8.07979554e-02f, -2.79694125e-02f, 2.25250572e-02f, -1.86421804e-03f,
  -2.83052847e-02f, 6.28868267e-02f, -5.39390184e-02f, 7.47360429e-03f, -8.56238604e-02f, -4.95075174e-02f, 7.19676688e-02f, 1.02118086e-02f, -2.99401209e-02f, -3.04445364e-02f,
  2.77495664e-02f, 7.44479150e-02f, 1.56875066e-02f, 2.14481540e-02f, -5.47780395e-02f, -3.12436670e-02f, 5.69988564e-02f, 4.43803817e-02f, -3.33004631e-02f, 3.30335274e-02f,
  1.24436403e-02f, -2.95285769e-02f, -5.67930080e-02f, 5.95591739e-02f, -5.16990647e-02f, -7.58045241e-02f, 5.41813113e-02f, -4.97451983e-02f, 5.86109459e-02f, 4.11734693e-02f,
  1.60449855e-02f, 1.10704087e-01f, -2.51749270e-02f, -4.68240827e-02f, -1.65849626e-02f, 4.27720100e-02f, -6.49246648e-02f, 4.85206246e-02f, -5.72667867e-02f, 6.37390241e-02f,
  1.39444679e-01f, -2.73093849e-01f, 1.74634382e-01f, 1.37326375e-01f, 1.42114699e-01f, 1.09687164e-01f, 4.02427524e-01f, -2.00986311e-01f, 6.62782192e-02f, -3.04083586e-01f,
  -2.50359997e-02f, 2.23997280e-01f, 6.94635287e-02f, -1.44811394e-02f, 1.66619867e-01f, -7.28027225e-02f, 7.84364343e-02f, 2.03596354e-01f, 7.30481297e-02f, -2.79337075e-02f,
  3.99858924e-03f, 4.38216515e-02f, -5.16818985e-02f, -3.13711584e-01f, -1.90817006e-02f, -5.42594567e-02f, -1.24338657e-01f, 1.48619786e-01f, -6.22017309e-04f, 5.47227226e-02f,
  -2.96330433e-02f, 4.70156670e-02f, 4.32311781e-02f, -1.92948449e-02f, -1.16971776e-01f, -9.40945446e-02f, 3.00801396e-02f, 1.26247659e-01f, 1.72124635e-02f, -5.10401428e-02f,
  5.55600636e-02f, 6.14389703e-02f, -7.50662461e-02f, 4.79756109e-02f, -5.32921515e-02f, -4.32736725e-02f, -5.21022864e-02f, -1.78538114e-02f, -7.97825903e-02f, -8.27881843e-02f,
  5.85436039e-02f, -3.18884365e-02f, -4.73256558e-02f, -2.58189756e-02f, -9.65376869e-02f, 1.00312745e-02f, -2.53828615e-03f, 7.98215866e-02f, 5.80677167e-02f, 2.26643682e-02f,
  -2.60147247e-02f, 5.32503761e-02f, -1.92645360e-02f, 1.05273791e-01f, 4.89110164e-02f, 1.01127736e-01f, -3.81354578e-02f, 2.22334247e-02f, 2.84175221e-02f, -1.47266663e-04f,
  2.13387944e-02f, 8.43183622e-02f, 4.25061099e-02f, 7.81447962e-02f, -5.24696186e-02f, 2.23875027e-02f, 6.31264672e-02f, 7.09145293e-02f, -7.70776346e-02f, 4.35728719e-03f,
  -2.32531428e-02f, -6.17168061e-02f, -6.66378811e-02f, -4.96259257e-02f, -4.43270467e-02f, 6.35415539e-02f, -1.24576977e-02f, 1.78339984e-02f, 2.56715026e-02f, -5.03973570e-03f,
  -4.48428504e-02f, 4.96192500e-02f, 6.93276711e-03f, 1.00933611e-02f, -8.10168013e-02f, -8.05471018e-02f, 1.46159092e-02f, 4.12397366e-03f, 8.07132348e-02f, -7.96662942e-02f,
  -1.37215406e-01f, 1.69335771e-02f, -1.93453692e-02f, -3.97524349e-02f, -4.32275794e-02f, -6.91834241e-02f, 3.76900099e-02f, -4.72075194e-02f, 7.35417008e-02f, -7.67567083e-02f,
  2.22877879e-02f, -3.48740369e-02f, 3.86427008e-02f, -9.37910303e-02f, -7.12109804e-02f, 2.23318208e-02f, -2.65999362e-02f, -7.66345561e-02f, -6.46274025e-03f, 2.45555434e-02f,
  1.55739218e-01f, 9.59782824e-02f, 1.45687759e-01f, 1.67378470e-01f, -4.58442830e-02f, -1.23005711e-01f, -3.17226723e-02f, -9.73541662e-02f, 1.27471902e-03f, -2.14162171e-02f,
  -4.23653563e-03f, 2.34598592e-01f, 5.19104227e-02f, 6.92795888e-02f, -5.90436831e-02f, -1.95801437e-01f, 4.13654000e-02f, -4.05353010e-02f, -2.28813067e-02f, 1.78831611e-02f,
  1.26907736e-01f, -5.75468317e-02f, 8.11449066e-02f, -6.14511147e-02f, 1.12124525e-01f, 9.17851701e-02f, 1.27530783e-01f, 3.04223523e-02f, 1.26589864e-01f, -4.06208858e-02f,
  9.96509008e-03f, 1.04865223e-01f, 8.60318542e-02f, -6.09066300e-02f, -5.56687266e-03f, -4.46426012e-02f, -6.93363771e-02f, -6.20753616e-02f, -5.78733906e-02f, 6.31590262e-02f,
  -3.31894099e-03f, 2.76398659e-02f, -3.75013761e-02f, -5.72717935e-02f, 1.02004912e-02f, -4.04093321e-03f, 1.39580313e-02f, 3.63824852e-02f, 5.60068041e-02f, 7.11792633e-02f,
  -1.34262927e-02f, 3.22603136e-02f, -3.77221182e-02f, -2.90325675e-02f, 1.44833587e-02f, -6.28553927e-02f, -4.66395095e-02f, -1.73889492e-02f, 7.20059499e-02f, 1.27200382e-02f,
  9.91768390e-02f, 2.92023662e-02f, -9.71819833e-02f, 6.72277855e-03f, 7.36283092e-03f, 2.24612448e-02f, 2.02198252e-02f, 7.77420104e-02f, -7.84090683e-02f, 5.43975011e-02f,
  3.60596552e-02f, -4.98539470e-02f, 2.01654080e-02f, -5.09227253e-02f, 6.44045770e-02f, -3.93892415e-02f, 4.47034612e-02f, -4.90721203e-02f, -5.53725585e-02f, 5.33064120e-02f,
  -8.49068388e-02f, 5.41928299e-02f, -6.31296560e-02f, 6.70605153e-02f, 2.56269798e-02f, -1.06018968e-02f, 4.85054217e-02f, 6.56583346e-03f, -7.71134943e-02f, -4.85640094e-02f,
  2.40430180e-02f, 1.27592966e-01f, -5.74380718e-02f, -7.61157200e-02f, 6.09825999e-02f, -7.18723089e-02f, -3.96010131e-02f, 7.02330321e-02f, -5.76908775e-02f, 7.07970262e-02f,
  1.67636629e-02f, 8.29151459e-03f, 6.30734190e-02f, 7.45275244e-02f, -7.73937032e-02f, 6.40667379e-02f, 1.14374749e-01f, -5.61753027e-02f, -3.52528319e-02f, 1.28952190e-01f,
  7.59515017e-02f, 2.32751220e-02f, 5.63394055e-02f, 9.74096917e-03f, 8.49648640e-02f, 8.17641914e-02f, 8.25892985e-02f, -5.62359691e-02f, -5.03545254e-02f, -1.47848576e-02f,
  -3.75789046e-01f, 1.78024679e-01f, -5.81520163e-02f, -4.07496840e-02f, -3.94873694e-02f, 1.16460048e-01f, -3.38724926e-02f, 1.70420744e-02f, -1.36021495e-01f, 9.55386162e-02f,
  8.48867185e-03f, -1.94566593e-01f, -4.79041934e-02f, 1.48747355e-01f, -1.23048134e-01f, 1.43398359e-01f, 2.12949440e-01f, 5.12306951e-02f, 7.31607601e-02f, -8.24559778e-02f,
  -6.41530305e-02f, -1.02714889e-01f, 1.28392860e-01f, 4.10447828e-03f, -1.03038020e-01f, -6.55126721e-02f, -1.03256114e-01f, -7.59984925e-03f, 5.38093597e-02f, -3.74568589e-02f,
  -1.07967123e-01f, -1.03571735e-01f, -2.30930839e-02f, -1.21146418e-01f, -6.56426847e-02f, -3.58865187e-02f, -1.02278292e-01f, -5.19456044e-02f, -2.09766813e-02f, -8.80029891e-03f,
  -6.73307404e-02f, 6.60490766e-02f, 8.05089027e-02f, 6.08658604e-02f, 7.44051337e-02f, -6.15350865e-02f, 1.12346463e-01f, 7.27339387e-02f, 7.79273808e-02f, 2.72943601e-02f,
  4.23570871e-02f, 7.60468766e-02f, 4.05423492e-02f, 6.99341744e-02f, 5.61756566e-02f, 2.11796965e-02f, -6.07618093e-02f, -7.62594640e-02f, 9.50886980e-02f, -3.08257304e-02f,
  4.82165515e-02f, 4.83715534e-03f, -3.08047254e-02f, 6.11848645e-02f, -3.81430029e-03f, -2.31905840e-02f, 5.68265729e-02f, -1.90250576e-02f, 2.00284319e-03f, 6.20951690e-02f,
  2.37433892e-02f, 4.00175015e-03f, 4.28496450e-02f, 7.15768486e-02f, 6.21856898e-02f, -2.57689264e-02f, -3.11983228e-02f, 8.89273906e-06f, 2.24957820e-02f, 7.19631240e-02f,
  -8.10956433e-02f, -3.39471325e-02f, -6.59513175e-02f, 5.89095801e-02f, -1.07983814e-03f, -4.64663655e-02f, -2.26378907e-02f, 2.69738287e-02f, 2.48402562e-02f, -5.25944941e-02f,
  -7.74016902e-02f, -1.30155250e-01f, 2.55344119e-02f, -9.81834531e-02f, -9.74106193e-02f, 1.03253260e-01f, 1.00709347e-03f, 5.32985665e-02f, -1.42307403e-02f, -2.45540757e-02f,
  -5.79258651e-02f, 5.53545468e-02f, -5.72422147e-02f, 3.90524901e-02f, -6.27696514e-02f, 1.73188336e-02f, -1.12295926e-01f, -5.81395701e-02f, -6.01433441e-02f, -4.99822199e-05f,
  2.25931145e-02f, 3.67247686e-02f, -1.29852612e-02f, 2.99167056e-02f, -1.02624334e-02f, -2.31174659e-02f, -6.34054020e-02f, -3.04345656e-02f, 3.40336487e-02f, -1.67328063e-02f,
  -1.21373169e-01f, -3.89196514e-03f, -1.24348454e-01f, 9.06190127e-02f, 1.33377492e-01f, -1.96505547e-01f, -7.39812329e-02f, 1.77780434e-01f, 1.23793244e-01f, 7.37176612e-02f,
  -5.59921749e-02f, -1.49719179e-01f, -4.01546545e-02f, -8.82026404e-02f, -1.08657286e-01f, -2.56258667e-01f, -1.30850583e-01f, -2.47301847e-01f, 1.39282634e-02f, 1.08725755e-02f,
  -1.67584587e-02f, 7.96261579e-02f, 7.87265971e-03f, 2.35467702e-01f, 6.28242344e-02f, 1.82841137e-01f, 8.45875069e-02f, 1.18169717e-01f, 5.61364144e-02f, -2.63047144e-02f,
  1.47703075e-04f, 1.06414996e-01f, -1.50737166e-02f, -4.71187085e-02f, -7.76712922e-03f, 6.68149665e-02f, -2.68701976e-03f, -3.30800824e-02f, 1.03653833e-01f, 2.51707211e-02f,
  -5.47626428e-02f, -6.49479330e-02f, 5.21098152e-02f, -3.26774269e-02f, 7.06571266e-02f, -1.83008369e-02f, -4.99973670e-02f, 5.16826399e-02f, 8.63663852e-03f, -9.22566950e-02f,
  -5.90066426e-02f, -3.02017620e-03f, 2.45906767e-02f, 4.18051109e-02f, -4.63881083e-02f, 1.08986303e-01f, -9.84039381e-02f, -1.15920216e-01f, -6.55594915e-02f, 3.10794469e-02f,
  3.58700640e-02f, 9.67473164e-02f, 2.82864366e-02f, 8.85009915e-02f, 8.66446123e-02f, 2.38745976e-02f, 4.14517149e-02f, -1.43683311e-02f, 7.67542720e-02f, 2.80098841e-02f,
  8.92304927e-02f, 1.08434528e-01f, 5.40939234e-02f, -5.64320199e-02f, 1.56553034e-02f, 4.29165773e-02f, -9.79278609e-02f, -1.03605993e-01f, 1.94649789e-02f, 3.31355110e-02f,
  1.02830552e-01f, 3.37000899e-02f, 3.24861966e-02f, 2.83253323e-02f, 2.79193427e-02f, 5.36745787e-02f, -8.18187520e-02f, -1.08123757e-01f, 4.96616773e-02f, 2.60763355e-02f,
  -1.02155015e-01f, 1.10389274e-02f, 4.04598191e-02f, 4.50677648e-02f, 5.03464453e-02f, -9.54105407e-02f, 1.29562253e-02f, -6.41286075e-02f, -5.12448847e-02f, -1.79280676e-02f,
  2.31136791e-02f, -1.16770286e-02f, 4.86893719e-03f, 5.90108000e-02f, -5.01635624e-03f, -5.26796170e-02f, 7.24109039e-02f, -4.80094850e-02f, -2.08124635e-03f, -8.98534246e-03f,
  4.61401790e-02f, 6.22469448e-02f, 8.42116103e-02f, -1.56607479e-02f, -4.36960161e-02f, 2.17962414e-02f, -7.34330267e-02f, -8.98905750e-03f, -2.55859382e-02f, -1.16715701e-02f,
  1.74352705e-01f, 2.57149022e-02f, 2.69548595e-01f, 2.09769696e-01f, -1.04067177e-02f, -9.13145393e-03f, 3.64616923e-02f, -1.01762392e-01f, -3.25572938e-02f, -1.22079909e-01f,
  -1.56726748e-01f, 2.62825817e-01f, -1.43072829e-02f, -8.95137340e-02f, 2.13349108e-02f, -1.89039394e-01f, -4.43698615e-02f, 1.63562074e-02f, -2.77552269e-02f, 7.32014626e-02f,
  -5.03654480e-02f, -1.86614871e-01f, 1.68066964e-01f, -1.53807744e-01f, 8.02415833e-02f, 8.86483584e-03f, -1.24644399e-01f, 2.03479826e-02f, 2.03554630e-02f, 5.30301742e-02f,
  2.00594198e-02f, -3.12869288e-02f, 1.47901788e-01f, 5.11165299e-02f, 2.39749476e-02f, -9.37349256e-03f, 1.51485085e-01f, 2.64040083e-02f, -7.53818899e-02f, 1.66075453e-02f,
  1.05604261e-01f, 3.60139040e-03f, 1.62797794e-02f, -3.50591540e-02f, -4.63238768e-02f, -1.04573220e-02f, 7.65214562e-02f, 9.58663374e-02f, 1.67388543e-02f, 1.82759300e-01f,
  1.08146608e-01f, 4.53054607e-02f, -4.27108491e-03f, 8.93674940e-02f, 1.07173420e-01f, -2.35299189e-02f, 1.12597279e-01f, 1.78418048e-02f, 2.58567873e-02f, -1.72140803e-02f,
  9.06832982e-03f, -4.11609933e-02f, -7.00992942e-02f, -6.32317439e-02f, -2.28764154e-02f, 4.51731496e-02f, 3.42025310e-02f, -2.77616307e-02f, -6.53110668e-02f, 3.56568210e-02f,
  -2.03992929e-02f, -3.27002071e-02f, -4.57297675e-02f, -8.72834250e-02f, -7.74225220e-03f, 1.73736624e-02f, -2.97814570e-02f, 1.17595785e-03f, 8.95794760e-03f, 6.71326220e-02f,
  -4.68465649e-02f, 4.13010977e-02f, -7.16521218e-02f, -4.58180420e-02f, -3.82517576e-02f, 1.71251856e-02f, 4.45877686e-02f, -5.34832180e-02f, -3.90916914e-02f, 8.47722441e-02f,
  -2.19755590e-01f, -1.51770324e-01f, -5.18137105e-02f, -4.40107659e-02f, -8.42276365e-02f, -9.65098068e-02f, -1.44427903e-02f, -6.73696026e-02f, -2.12623775e-02f, -2.20589284e-02f,
  3.87299098e-02f, -1.21710859e-02f, -1.25659471e-02f, 2.67636124e-02f, -2.42729988e-02f, -1.03415117e-01f, -6.50274530e-02f, 2.35127956e-02f, 7.15733925e-03f, -3.72755155e-02f,
  2.67581716e-02f, 1.38859386e-02f, -9.42018814e-03f, -3.06668542e-02f, 8.16974416e-03f, -3.73153836e-02f, 1.21237589e-02f, 9.37424526e-02f, -7.98325464e-02f, 5.87209538e-02f,
  -1.28569901e-01f, 2.57281005e-01f, 6.67149201e-02f, 5.10450602e-02f, -4.96398099e-02f, 1.70964614e-01f, 1.45024480e-02f, 1.41473845e-01f, 2.70182312e-01f, 1.66236848e-01f,
  -5.86962253e-02f, 2.27258921e-01f, -5.46189919e-02f, 1.99409258e-02f, -2.47102808e-02f, 1.23509616e-02f, 9.23778713e-02f, 1.09554648e-01f, -2.82334164e-02f, 1.82414632e-02f,
  -2.93938965e-02f, -1.11070618e-01f, -4.00046222e-02f, -1.50162131e-01f, 1.00929476e-02f, -4.21125405e-02f, -1.48590088e-01f, -1.91933826e-01f, 8.42464995e-03f, -6.15157858e-02f,
  6.74845204e-02f, -8.16257745e-02f, -2.17282008e-02f, 7.41946846e-02f, 1.64480247e-02f, -7.42207319e-02f, -4.30298336e-02f, 5.99200651e-02f, -3.89794894e-02f, 4.40257080e-02f,
  5.67985810e-02f, 7.45095611e-02f, 1.21770084e-01f, 4.49363030e-02f, -1.21148415e-02f, -5.60112447e-02f, 3.50787700e-03f, -4.26312350e-02f, 7.27110431e-02f, -2.96131074e-02f,
  3.65825221e-02f, 3.63894999e-02f, -8.25328529e-02f, 1.10123880e-01f, 7.01801926e-02f, 5.44465818e-02f, 2.60122269e-02f, -7.23019764e-02f, 5.10908328e-02f, 1.01285279e-02f,
  -2.17451807e-02f, 7.21232668e-02f, -3.31744142e-02f, -7.86705241e-02f, 1.09433658e-01f, -2.43036170e-02f, 7.80108571e-02f, -5.57146482e-02f, -2.25006249e-02f, 4.48177531e-02f,
  -1.86490342e-02f, -3.25390883e-02f, -1.21169081e-02f, 5.53855486e-02f, 1.56616198e-03f, -7.00625926e-02f, -4.11997549e-02f, -8.24136585e-02f, -2.52006925e-03f, -1.78367086e-02f,
  -1.00739777e-01f, -2.35800184e-02f, -4.22034636e-02f, -7.94883519e-02f, -2.44018342e-02f, -3.35038975e-02f, -8.80700350e-02f, 4.91756685e-02f, -5.56519590e-02f, 2.16381848e-02f,
  7.50349611e-02f, 1.71534270e-01f, 1.00833394e-01f, 1.69174150e-02f, 1.62887666e-02f, -6.15370311e-02f, 1.35940185e-03f, 3.55102271e-02f, 1.83261558e-02f, 6.24894118e-03f,
  5.06640784e-02f, 8.96877795e-02f, 3.95299010e-02f, 4.12459671e-03f, 2.91413255e-03f, 2.72967629e-02f, 3.99942920e-02f, 6.78547025e-02f, 4.26386967e-02f, -4.43316698e-02f,
  -2.61485353e-02f, 1.48509266e-02f, 8.27624723e-02f, -5.63165322e-02f, 1.04558328e-02f, 3.51134203e-02f, 3.70422751e-02f, 3.80914845e-02f, -2.64824852e-02f, 7.70433918e-02f,
  9.26151872e-02f, -7.04259053e-02f, 1.17916450e-01f, 3.84298146e-01f, 1.67391941e-01f, -3.31877358e-02f, -3.29906978e-02f, 3.20184708e-01f, 5.28148949e-01f, -2.92898685e-01f,
  -6.89319447e-02f, -1.73234612e-01f, -1.78254947e-01f, 4.93719950e-02f, 8.07434693e-02f, 1.63559932e-02f, 1.76900402e-01f, -1.87957641e-02f, 3.26832145e-01f, 1.12134792e-01f,
  2.38928869e-01f, 7.49561144e-03f, 2.53013987e-02f, -3.35523412e-02f, -5.07513285e-02f, 6.27786294e-02f, -2.23652676e-01f, -6.15329221e-02f, -1.76731959e-01f, -6.99373260e-02f,
  -3.05513944e-02f, 1.85442895e-01f, -1.68856412e-01f, -6.11022413e-02f, 5.30267432e-02f, -9.91499200e-02f, -1.10937141e-01f, -1.46133676e-01f, -8.29824619e-03f, -1.32259233e-02f,
  -8.35344121e-02f, -7.80577306e-03f, 3.81151102e-02f, 2.76133437e-02f, 7.56718516e-02f, -6.25013979e-03f, 7.36153722e-02f, 1.02912389e-01f, -6.32460266e-02f, 5.91282211e-02f,
  -1.56898573e-02f, -1.31760519e-02f, 2.22820248e-02f, -7.58712366e-02f, 5.51547408e-02f, -2.49805823e-02f, 4.81577255e-02f, -3.40670422e-02f, 8.22745077e-03f, -1.05988747e-02f,
  1.16918087e-01f, -4.17662971e-02f, -7.91268796e-02f, -2.29779612e-02f, -3.36717069e-02f, 1.70798842e-02f, -7.02982694e-02f, 3.20659764e-02f, 4.31043431e-02f, -4.22561057e-02f,
  -3.31980288e-02f, 1.36217512e-02f, 5.97057156e-02f, -8.79095308e-03f, -1.08041503e-02f, 5.43269366e-02f, -1.06014553e-02f, 8.25278610e-02f, 1.08806953e-01f, -4.58628573e-02f,
  1.46738188e-02f, 6.33700639e-02f, -1.07827649e-01f, 3.48493792e-02f, -2.97728162e-02f, 7.61747500e-03f, 7.12773502e-02f, -1.91812012e-02f, 8.56868923e-03f, -7.05466419e-03f,
  1.56104058e-01f, 1.93731606e-01f, 4.33577225e-02f, 1.53639112e-02f, -6.79522334e-03f, -3.65293510e-02f, 5.04553020e-02f, -4.44081426e-03f, 1.02889955e-01f, 3.23695280e-02f,
  1.63347237e-02f, -5.27978651e-02f, -1.54891517e-02f, -8.24545175e-02f, -6.40310571e-02f, 1.69349965e-02f, 1.32446326e-02f, -3.35208252e-02f, -7.45834112e-02f, -6.19877055e-02f,
  -9.98068824e-02f, -1.35238767e-02f, 1.70355011e-02f, 6.91979975e-02f, -5.80453407e-03f, -5.87952398e-02f, -2.23002527e-02f, 1.61150731e-02f, -8.09946433e-02f, 6.96893260e-02f,
  -1.36682004e-01f, 3.49181265e-01f, 3.56977671e-01f, -1.28087074e-01f, 2.97158025e-03f, 3.24234068e-02f, -1.64288506e-01f, 2.78142154e-01f, -1.54034216e-02f, -1.74074009e-01f,
  -1.48974046e-01f, -4.15471010e-02f, 1.23913206e-01f, -8.92890245e-02f, -7.02737495e-02f, 6.73086047e-02f, 5.99736013e-02f, -1.53530955e-01f, 9.71476138e-02f, 1.07985407e-01f,
  9.04676691e-02f, -8.17996934e-02f, 1.91905290e-01f, 2.43421033e-01f, 1.06241412e-01f, 6.75804615e-02f, -2.76858062e-02f, 1.94990218e-01f, 6.18891716e-02f, -4.13424633e-02f,
  -1.27269313e-01f, 4.48944978e-02f, 2.88973805e-02f, 1.22593351e-01f, 4.95961607e-02f, -1.62895191e-02f, -2.25272961e-02f, -7.97642916e-02f, 4.16694097e-02f, -3.09379045e-02f,
  -4.91624139e-03f, 1.12888873e-01f, 2.25752462e-02f, -6.40826076e-02f, 5.73647842e-02f, 1.17900498e-01f, 1.69357210e-01f, 1.65637657e-02f, -1.51267294e-02f, 1.26057625e-01f,
  1.53773621e-01f, 4.16780822e-02f, -2.96870917e-02f, 5.06896041e-02f, 5.07638883e-03f, 5.41890785e-02f, -1.11590624e-01f, 4.91821840e-02f, 5.78761548e-02f, 9.13961455e-02f,
  2.55994815e-02f, -6.81456402e-02f, -2.43754359e-03f, 1.94545370e-02f, -2.32998710e-02f, 4.33213562e-02f, 5.06109074e-02f, -8.75315815e-02f, 4.96623740e-02f, 4.55346182e-02f,
  1.65304281e-02f, 3.57770137e-02f, 2.92449202e-02f, -3.62649895e-02f, 5.12839109e-03f, -8.25459212e-02f, 5.04766442e-02f, 2.17942912e-02f, -6.25486001e-02f, 4.46333997e-02f,
  3.25577296e-02f, -3.51375826e-02f, 2.68607419e-02f, -6.87614456e-02f, -4.65894006e-02f, 3.80766317e-02f, 4.48502712e-02f, 4.75346930e-02f, 8.92343894e-02f, 4.93624806e-03f,
  4.21244127e-04f, -7.55492449e-02f, 6.43931925e-02f, -6.68149143e-02f, -1.71444267e-02f, 9.14312783e-04f, 2.26829164e-02f, 3.13594751e-03f, -6.73646778e-02f, 6.59964532e-02f,
  6.27109930e-02f, 1.92571450e-02f, -9.62980688e-02f, -4.63062786e-02f, -4.96460572e-02f, 1.01084439e-02f, -6.83779716e-02f, -1.03694245e-01f, 1.19260810e-02f, 5.64222075e-02f,
  2.17729341e-02f, -4.36967276e-02f, 1.17057608e-02f, 2.53748745e-02f, -4.36037630e-02f, -2.61045471e-02f, -1.00505762e-02f, -4.59431894e-02f, 4.77418341e-02f, -1.07018119e-02f,
  -8.63097666e-04f, -6.22475147e-02f, 1.18946843e-01f, 1.39154315e-01f, -8.91933683e-03f, 1.04706455e-02f, -4.48442809e-02f, -3.98642682e-02f, -2.85376161e-01f, -1.01380840e-01f,
  3.73680405e-02f, 3.20671760e-02f, 1.19447121e-02f, 2.51512248e-02f, 2.52411991e-01f, -3.92119475e-02f, -7.72156753e-03f, 3.93551178e-02f, -7.90842623e-02f, 1.26401484e-01f,
  8.49954635e-02f, 9.22827423e-02f, 2.26957858e-01f, 1.16383336e-01f, -1.42873486e-03f, 7.95259923e-02f, 1.56290099e-01f, 2.39953533e-01f, 8.48073438e-02f, 1.02531910e-01f,
  2.31479784e-03f, -1.86636783e-02f, -5.70813641e-02f, 4.02688868e-02f, 2.82426085e-02f, -1.01328390e-02f, 1.27320349e-01f, 1.18973970e-01f, 9.02944878e-02f, 1.55028896e-02f,
  7.86968991e-02f, 3.36404257e-02f, -2.03461573e-02f, 3.41148153e-02f, 3.45888846e-02f, -4.54974882e-02f, -1.30617628e-02f, -5.43384030e-02f, -5.16996942e-02f, 4.77638934e-03f,
  5.94028756e-02f, 6.57367334e-02f, 3.85411717e-02f, -2.38115955e-02f, -1.64801907e-02f, 1.96814276e-02f, -4.65772487e-02f, -2.81024426e-02f, 3.72140296e-02f, -6.33366629e-02f,
  3.80353304e-03f, -9.53571200e-02f, 3.79776284e-02f, -8.64885896e-02f, -8.89484864e-03f, -3.75365205e-02f, 7.93351233e-02f, -3.93614583e-02f, -7.91831240e-02f, -6.64011315e-02f,
  5.34955263e-02f, 5.31856902e-03f, -5.44772036e-02f, -1.24437613e-02f, 7.29579404e-02f, 3.34317982e-02f, 5.24898544e-02f, 3.83059718e-02f, -3.05305831e-02f, 2.10019331e-02f,
  -9.92824212e-02f, 8.56616497e-02f, 3.01191285e-02f, 1.48730827e-02f, 2.69316584e-02f, -6.80627823e-02f, 7.67461210e-02f, -6.65591732e-02f, 5.14206588e-02f, 9.40409824e-02f,
  -6.14287471e-03f, 6.17869645e-02f, 2.08208915e-02f, -5.11094257e-02f, -8.25843494e-03f, 7.59138614e-02f, 7.21261427e-02f, -2.50891801e-02f, 9.42835808e-02f, -2.22358871e-02f,
  1.11559048e-01f, 7.17421845e-02f, -3.28436866e-02f, 6.20913357e-02f, 7.44005516e-02f, -9.12643224e-02f, 1.17709786e-02f, -6.45470396e-02f, -6.64796755e-02f, 1.66650619e-02f,
  -1.92523422e-03f, 4.30492684e-02f, 3.14568244e-02f, 4.13122736e-02f, 4.89312224e-02f, 6.18529133e-02f, -7.99239129e-02f, -2.87010637e-03f, 6.25791028e-02f, 4.70481925e-02f,
  1.25761762e-01f, 2.01871634e-01f, 2.43626505e-01f, 2.46199563e-01f, -6.49819747e-02f, -1.58983935e-02f, -2.73751654e-02f, 9.31269005e-02f, 2.16538772e-01f, 5.04179858e-02f,
  -9.30704102e-02f, 2.13184446e-01f, -7.65935332e-02f, 2.34618366e-01f, -2.51637787e-01f, -9.22742486e-02f, 8.74466151e-02f, 9.76899862e-02f, 5.48173040e-02f, -1.89967069e-03f,
  -1.56024722e-02f, -1.73413634e-01f, -9.99320485e-03f, -1.26044303e-01f, 1.19482130e-01f, 7.56482556e-02f, -1.73239127e-01f, -1.85688406e-01f, 9.72685888e-02f, -1.34253219e-01f,
  9.23028067e-02f, -5.14935562e-03f, 1.00602157e-01f, 2.90433615e-02f, 5.36869727e-02f, 4.10932414e-02f, 8.22471529e-02f, -3.69914919e-02f, -3.35614718e-02f, 6.85544312e-02f,
  8.53678137e-02f, 3.75890657e-02f, 5.90832531e-02f, 1.84746366e-02f, -3.43179554e-02f, 1.49954502e-02f, 9.11828578e-02f, 3.64629626e-02f, 2.33636387e-02f, 9.05420817e-03f,
  7.18002468e-02f, 5.08318692e-02f, 3.63866873e-02f, 5.52082360e-02f, 3.02439611e-02f, 4.99987463e-03f, 6.82452917e-02f, -2.32912581e-02f, 9.38300565e-02f, -1.66519340e-02f,
  -7.72814378e-02f, -8.53363499e-02f, 1.34917838e-03f, 6.45356476e-02f, -2.75295079e-02f, 4.62100049e-03f, -2.24052612e-02f, 3.28266099e-02f, -4.81981039e-02f, -4.93259169e-02f,
  -8.33117217e-02f, 2.29244214e-02f, -6.51564747e-02f, 1.11259576e-02f, -3.83118019e-02f, 1.00638598e-01f, -6.57343641e-02f, 9.48192552e-02f, 2.45324410e-02f, 6.76092058e-02f,
  -8.54461417e-02f, 1.92056689e-02f, 4.51862291e-02f, -3.74500602e-02f, -5.85844405e-02f, -3.21154520e-02f, -4.96286787e-02f, 4.44755368e-02f, -4.65532281e-02f, 4.86573437e-03f,
  5.40013276e-02f, -3.52120250e-02f, 4.63629924e-02f, 6.72622919e-02f, 6.25026599e-02f, -8.58098269e-02f, 1.04392609e-02f, 3.87372188e-02f, -1.72400661e-02f, -2.21106987e-02f,
  9.16471798e-03f, -1.26196928e-02f, -7.28076696e-02f, 3.49221900e-02f, -6.99597523e-02f, 8.27942882e-03f, -5.68870492e-02f, -5.22927307e-02f, -5.85522205e-02f, 6.60307556e-02f,
  -9.13963467e-03f, -6.72123879e-02f, -8.33087862e-02f, 5.58910780e-02f, -1.07523622e-02f, 5.72981015e-02f, -6.96293684e-03f, 3.01465834e-03f, 1.26216875e-03f, 1.02293200e-03f,
  -1.42096639e-01f, -1.70862097e-02f, 3.03992331e-01f, 1.16374552e-01f, 9.57332402e-02f, 3.53155285e-01f, 3.21277440e-01f, 1.10875227e-01f, 2.17766747e-01f, -1.79595500e-01f,
  -1.30601242e-01f, -4.74602431e-02f, 1.25444591e-01f, -6.70697615e-02f, 1.81816041e-01f, 2.78319687e-01f, 1.53613165e-01f, 6.43034354e-02f, 1.81404844e-01f, -1.04361497e-01f,
  1.61267314e-02f, -2.57704258e-01f, 4.82898951e-02f, -3.06989402e-01f, -2.22690493e-01f, -1.52941301e-01f, -2.73217708e-01f, -2.44676713e-02f, -2.48231634e-01f, 6.19815812e-02f,
  -5.30177504e-02f, -8.10211524e-02f, -1.57390311e-01f, -1.37945153e-02f, 1.78993251e-02f, 4.28527854e-02f, 2.80871429e-02f, 9.69325453e-02f, 4.74253744e-02f, -2.39243582e-02f,
  -8.45573172e-02f, -7.54159689e-02f, -8.02800059e-02f, 1.98722184e-02f, 3.21120620e-02f, -3.15681510e-02f, -1.25589697e-02f, 4.37886361e-03f, 1.52482241e-02f, 1.11519463e-01f,
  5.55240810e-02f, -2.45600920e-02f, 3.96558009e-02f, 2.42991243e-02f, 2.95931902e-02f, -4.73088175e-02f, 3.08398623e-02f, 2.72395406e-02f, -5.27707301e-02f, -3.75429094e-02f,
  8.03058669e-02f, 9.24609974e-02f, -7.44848624e-02f, 8.89430381e-03f, -6.23304620e-02f, -2.90027186e-02f, 1.77852192e-03f, -6.89802170e-02f, 4.84255962e-02f, -5.74274324e-02f,
  -2.68914318e-03f, -1.12782739e-01f, -7.35936686e-02f, 4.35097367e-02f, 4.97897947e-03f, 6.49510399e-02f, -5.13115935e-02f, -1.66926645e-02f, -2.44687311e-02f, -6.19893670e-02f,
  -2.09120754e-02f, 9.12916809e-02f, -1.04961999e-01f, 5.02555668e-02f, -1.32100098e-02f, 9.88338888e-03f, -9.05073732e-02f, 5.32582700e-02f, 1.40386671e-02f, -2.00436614e-03f,
  -8.95198733e-02f, -8.67057964e-02f, -1.41184613e-01f, -8.99356902e-02f, -8.97541493e-02f, -8.77363533e-02f, 5.08939438e-02f, -2.15321463e-02f, 5.01092412e-02f, 4.59988602e-02f,
  1.17716575e-02f, -5.09682931e-02f, -8.82363617e-02f, -9.24751570e-04f, 8.60918593e-03f, -9.87869576e-02f, 4.37518023e-03f, 1.08348171e-03f, 3.66371199e-02f, -7.43595660e-02f,
  -4.62076403e-02f, -9.34102461e-02f, -1.05804787e-03f, -1.14415385e-01f, -2.90228259e-02f, -1.28501551e-02f, -1.40121253e-02f, 7.78887570e-02f, 4.67750914e-02f, 7.32332170e-02f,
  2.01682467e-02f, 5.09760901e-02f, 1.02753885e-01f, 1.48771718e-01f, -1.51915804e-01f, 1.05334044e-01f, 1.94518223e-01f, -1.14499047e-01f, 1.58733949e-01f, -4.74380562e-03f,
  -2.66994566e-01f, 2.31678963e-01f, -6.63560405e-02f, 3.14128138e-02f, 1.89378902e-01f, -2.18091756e-02f, 5.75106665e-02f, 7.33109042e-02f, -7.75674591e-03f, 6.90836534e-02f,
  5.73832355e-02f, -1.40975907e-01f, -1.45968303e-01f, -2.57298172e-01f, -7.91635737e-02f, 2.99387109e-02f, -2.43045628e-01f, 5.25601618e-02f, -8.67271423e-02f, -3.53743955e-02f,
  -3.15395445e-02f, -7.87852407e-02f, -7.25309327e-02f, 6.91130236e-02f, -9.47721228e-02f, 4.16379943e-02f, 1.02978554e-02f, 3.14064398e-02f, 6.01496175e-02f, 1.39643857e-02f,
  -1.79076334e-03f, -5.24345711e-02f, -1.83511414e-02f, 4.77063693e-02f, 4.32471633e-02f, -4.68581496e-03f, -1.75223872e-02f, -9.37462598e-02f, -2.59542149e-02f, 9.18771233e-03f,
  -4.45083678e-02f, -2.16575284e-02f, -8.02727416e-02f, 6.61139339e-02f, 8.70801229e-03f, 2.04275958e-02f, -8.61110259e-03f, 9.21682492e-02f, 2.00855825e-02f, -2.18172595e-02f,
  9.23570246e-02f, 4.59319055e-02f, -2.13636234e-02f, 9.97581985e-03f, -1.61103904e-02f, -4.50062379e-02f, -5.44976145e-02f, 1.32994233e-02f, 4.57830764e-02f, -1.01029696e-02f,
  -1.57519281e-02f, -4.36746143e-03f, -3.01311873e-02f, 1.04212627e-01f, 6.53264672e-02f, -9.28071886e-03f, 3.22357155e-02f, -6.92607164e-02f, 5.06961904e-02f, -4.93663251e-02f,
  1.07518565e-02f, 5.95790893e-02f, -5.04606636e-03f, 3.54358442e-02f, 6.09290339e-02f, -3.47200148e-02f, 3.28914747e-02f, -2.79420353e-02f, 1.68959852e-02f, 9.51267406e-03f,
  1.24422424e-01f, 2.20447481e-01f, -3.91793847e-02f, 1.12707531e-02f, 9.70741659e-02f, -1.01232596e-01f, 5.57884499e-02f, -5.86230308e-02f, 6.25175759e-02f, 9.40757431e-03f,
  6.47482881e-03f, 9.42389891e-02f, -7.36860372e-03f, -3.77773754e-02f, 6.25114590e-02f, 1.67469773e-02f, -4.36610635e-03f, 1.59507822e-02f, 7.83000588e-02f, 3.03811450e-02f,
  -1.39746247e-02f, 9.59850475e-02f, 8.77675638e-02f, 6.51319101e-02f, -8.21194723e-02f, 1.20726982e-02f, 8.18671882e-02f, -7.30849430e-02f, -5.47051243e-02f, -4.83922996e-02f,
  8.56794044e-02f, -1.63855210e-01f, -1.14139661e-01f, -8.71345773e-02f, -1.24283500e-01f, -1.08893424e-01f, -9.37578231e-02f, -1.84170008e-01f, -2.25569159e-01f, -1.56943887e-01f,
  -9.51315090e-02f, 2.55511701e-02f, 1.06484070e-01f, -2.18782961e-01f, 2.38809913e-01f, 8.54298100e-02f, -1.14270173e-01f, 6.39329925e-02f, -6.36486635e-02f, -1.32945880e-01f,
  -6.00270554e-02f, -1.86998248e-01f, 7.71320164e-02f, -1.39170691e-01f, -1.45462183e-02f, -9.46961641e-02f, -1.27989249e-02f, -7.54389679e-03f, -9.91679132e-02f, 2.52754427e-02f,
  -1.02021746e-01f, -2.07704008e-02f, -9.49231312e-02f, 3.18287313e-02f, 7.91956261e-02f, 8.71438459e-02f, 4.59737852e-02f, 3.05254795e-02f, 1.23524126e-02f, -3.02180368e-02f,
  5.64711727e-02f, -3.63832638e-02f, -2.55769417e-02f, -1.24335513e-02f, -1.04558267e-01f, -2.73396261e-02f, 6.14836719e-03f, 1.18246311e-02f, -4.91019152e-02f, 7.01996908e-02f,
  -9.08569992e-02f, -5.23117147e-02f, 4.77295704e-02f, -2.40525529e-02f, 2.93838605e-02f, -5.07590808e-02f, -6.48471862e-02f, 8.53598639e-02f, 4.63400446e-02f, -1.07605539e-01f,
  -1.43060889e-02f, 2.16270909e-02f, -2.75204219e-02f, 5.84346056e-02f, 5.41121848e-02f, -1.65420007e-02f, 1.81400422e-02f, 9.63778645e-02f, -1.63376480e-02f, 1.00554988e-01f,
  -6.87848032e-02f, -3.53791974e-02f, -6.85148826e-03f, -5.77435270e-02f, 5.31867286e-03f, -6.40077218e-02f, 9.03549567e-02f, 1.07282698e-02f, 2.01428104e-02f, 2.32997630e-02f,
  -3.13337869e-03f, 4.24638763e-02f, -5.46630546e-02f, 2.08001714e-02f, -4.58494984e-02f, 9.32116657e-02f, -1.93767883e-02f, -5.67006245e-02f, -1.21960901e-02f, -3.23302634e-02f,
  -4.03229184e-02f, -1.48223236e-01f, -4.15313281e-02f, -4.98776510e-02f, -2.71901526e-02f, 5.83240800e-02f, -1.90455709e-02f, -1.14058837e-01f, -2.35472601e-02f, 8.65057576e-03f,
  -6.73658475e-02f, -2.87183989e-02f, -2.03799270e-02f, 7.71232843e-02f, -6.24087732e-03f, -1.16060883e-01f, 2.63851769e-02f, -1.17502706e-02f, 4.19710763e-02f, -5.62203266e-02f,
  5.80478832e-02f, -5.50655201e-02f, 9.30712372e-02f, -5.62433228e-02f, -1.71358336e-03f, 1.01624418e-03f, 4.04358022e-02f, 7.24327341e-02f, -7.00908080e-02f, -1.51250698e-02f,
  -3.81090306e-02f, -1.67130589e-01f, 1.27271220e-01f, -3.11539114e-01f, 1.93072796e-01f, 3.00980330e-01f, 1.21169493e-01f, 4.46971357e-02f, -1.60851121e-01f, -1.12462759e-01f,
  -5.87087646e-02f, -1.78642511e-01f, 7.58479931e-04f, -1.00113392e-01f, 1.36308715e-01f, 1.87728498e-02f, -4.60009091e-02f, -9.19840038e-02f, -1.57541055e-02f, 8.09952766e-02f,
  1.89688243e-02f, -8.51885602e-03f, 6.22059032e-02f, -8.28053355e-02f, 6.48674071e-02f, -9.86231193e-02f, -4.09360640e-02f, 1.10732429e-01f, -9.58138704e-02f, -1.78987067e-02f,
  7.19551742e-02f, 2.84914188e-02f, 1.72469988e-01f, -2.35366076e-02f, 1.47592470e-01f, 1.11135393e-01f, 5.56424111e-02f, 1.20343275e-01f, -6.65542930e-02f, -3.82837318e-02f,
  3.13210441e-03f, 4.71032150e-02f, -1.37588784e-01f, 3.28867659e-02f, -9.77944732e-02f, -3.94220576e-02f, 5.48918061e-02f, 6.41342998e-02f, -3.08533236e-02f, 2.72019841e-02f,
  7.82719180e-02f, -3.76234837e-02f, 3.18026822e-03f, -1.37623489e-01f, 7.35547999e-03f, 7.10689742e-03f, 2.49269083e-02f, 1.07029360e-02f, 3.45931351e-02f, -6.22639060e-03f,
  4.09735441e-02f, 2.21466105e-02f, 6.20662384e-02f, -1.24210129e-02f, 4.09340858e-02f, -1.38081424e-02f, -8.32841024e-02f, 3.92143540e-02f, -6.54673427e-02f, -8.43165219e-02f,
  -1.63112115e-02f, -5.13232313e-02f, 6.48148581e-02f, 5.95078617e-02f, 8.69918987e-03f, -5.39609157e-02f, -8.49434361e-03f, 3.63628156e-02f, -3.73375043e-02f, -9.21377465e-02f,
  -4.63806354e-02f, 5.23851439e-02f, 6.05502054e-02f, -9.13407058e-02f, 9.09498334e-02f, -6.22965395e-02f, -9.01336744e-02f, -6.25719223e-03f, -1.30651295e-02f, -2.42577028e-02f,
  -6.49575368e-02f, -1.39117256e-01f, -2.97075119e-02f, 3.49806473e-02f, 4.35875654e-02f, 1.15441598e-01f, 5.10146767e-02f, -6.61098510e-02f, -7.53720999e-02f, 3.88051793e-02f,
  -4.13573384e-02f, -8.52075741e-02f, 3.13693425e-03f, 3.57667506e-02f, -6.19783439e-03f, 2.12247279e-02f, -9.64070931e-02f, -8.74123052e-02f, 3.73146944e-02f, 2.98715662e-02f,
  -6.39757812e-02f, -4.86367606e-02f, -3.26963924e-02f, 2.95504965e-02f, -1.14355758e-01f, 1.86657850e-02f, -6.82884157e-02f, -1.02153860e-01f, 2.48920564e-02f, -1.17495414e-02f,
  -5.58018647e-02f, 2.04731151e-01f, -2.41022214e-01f, -2.91358326e-02f, -7.59407133e-02f, 1.72518998e-01f, 3.09000850e-01f, 8.67832899e-02f, 2.64678895e-01f, 3.04217368e-01f,
  1.75846413e-01f, 1.23966627e-01f, 1.28355846e-01f, 1.93793461e-01f, 5.29551692e-02f, 2.08272099e-01f, 3.29953700e-01f, 1.81866452e-01f, 6.79997206e-02f, 1.13740399e-01f,
  -1.06580243e-01f, 2.70646393e-01f, -2.31767088e-01f, 7.07607865e-02f, -7.85114616e-02f, -1.55910581e-01f, -8.42606425e-02f, -1.55195072e-01f, 5.87553233e-02f, 7.94239864e-02f,
  1.21775381e-02f, 1.67748891e-02f, -7.24675283e-02f, -4.62846942e-02f, -9.88945961e-02f, -4.58381232e-03f, -3.70047353e-02f, 8.12404044e-03f, -5.87515719e-02f, 4.18990627e-02f,
  -7.51360785e-03f, -6.74829111e-02f, 4.12162691e-02f, -8.02624971e-02f, -1.32718077e-02f, -4.89831679e-02f, -9.42179561e-03f, -3.64600532e-02f, -6.32902905e-02f, -2.76822485e-02f,
  -3.68905030e-02f, -4.86185290e-02f, -7.85582419e-03f, 1.02142856e-01f, -1.09266907e-01f, 6.38320372e-02f, 4.93717380e-02f, -6.90785795e-02f, 1.69751560e-03f, 5.72566837e-02f,
  -5.87274786e-03f, -1.84482057e-02f, 5.66722080e-02f, 1.02506792e-02f, -6.75722025e-03f, -6.75706267e-02f, 6.91485703e-02f, 1.21542579e-02f, 1.17235826e-02f, -3.70565727e-02f,
  4.60543334e-02f, 1.33185405e-02f, 4.39533256e-02f, -2.41596196e-02f, 4.60761264e-02f, 3.04396488e-02f, -6.73048198e-02f, 5.56977801e-02f, 1.08727096e-02f, -1.84671627e-03f,
  -2.34341081e-02f, 9.07839760e-02f, 7.76983574e-02f, -3.38350832e-02f, -2.13539433e-02f, -3.30177173e-02f, 5.05403504e-02f, 1.22284833e-02f, 2.71353088e-02f, -5.00100330e-02f,
  1.53838471e-01f, 2.65501052e-01f, 3.65532823e-02f, 3.81407812e-02f, -3.19351293e-02f, -5.37302569e-02f, 3.50863226e-02f, -3.86414528e-02f, 1.40374769e-02f, 6.37373775e-02f,
  -9.04274359e-03f, 1.27593335e-02f, -6.67279437e-02f, -4.69144098e-02f, 5.50683551e-02f, 1.45298451e-01f, 1.94136817e-02f, -1.96579732e-02f, 1.01838827e-01f, -8.96431506e-02f,
  7.08506035e-04f, 9.15546119e-02f, -4.07678932e-02f, -5.87689131e-02f, 8.58983248e-02f, -2.71343328e-02f, -2.95411255e-02f, -5.89039661e-02f, 4.42333110e-02f, -5.03847785e-02f,
  1.01106744e-02f, -4.10375558e-02f, -1.88215926e-01f, -1.73609927e-01f, -1.33232608e-01f, -4.39333767e-02f, -1.85643300e-01f, -7.55958855e-02f, 9.56033692e-02f, 2.80998722e-02f,
  1.23791866e-01f, -1.22681722e-01f, 1.57661006e-01f, -1.05843991e-02f, -2.74559110e-02f, 1.56011075e-01f, -9.21316445e-02f, 6.59263805e-02f, 7.97227100e-02f, -9.81618091e-02f,
  3.83518636e-02f, -4.60522696e-02f, -5.22434525e-02f, -5.43668820e-03f, -1.15461655e-01f, -1.68257189e-04f, 8.63019153e-02f, -8.91744345e-02f, -5.41974194e-02f, 7.67587498e-03f,
  1.19562827e-01f, 1.07972287e-01f, 7.87357986e-02f, -3.35017852e-02f, -3.37612592e-02f, -8.72386396e-02f, 1.98027920e-02f, 4.05326635e-02f, 3.22422273e-02f, 6.49971291e-02f,
  -9.45522338e-02f, -9.19309258e-02f, -3.78826074e-02f, -5.30807720e-03f, -1.18928753e-01f, -9.50565487e-02f, 2.64665205e-03f, 6.98544383e-02f, -8.05629715e-02f, -7.82320872e-02f,
  -3.73601504e-02f, 6.54075295e-02f, -5.06377704e-02f, -3.03850193e-02f, 4.84727658e-02f, -3.08873244e-02f, 2.58655157e-02f, 1.94468759e-02f, -5.88929765e-02f, -7.91338980e-02f,
  1.37235131e-02f, -2.97717080e-02f, 7.80536830e-02f, 3.54153551e-02f, -1.92199778e-02f, 9.34766233e-03f, -1.31960902e-02f, -1.02188997e-02f, 3.30542140e-02f, -6.90086484e-02f,
  3.07716932e-02f, 6.65622652e-02f, 1.09730577e-02f, -3.43016461e-02f, 3.09338490e-03f, -1.09469024e-02f, -1.97439529e-02f, -2.26469915e-02f, -7.52371997e-02f, 7.28866458e-02f,
  -5.34082763e-02f, -5.19674309e-02f, -4.64001074e-02f, 2.35170238e-02f, 2.18133889e-02f, -5.10286763e-02f, 6.83104843e-02f, 4.85241637e-02f, -3.56689841e-03f, -6.28053024e-02f,
  9.19999089e-03f, -7.41819385e-03f, -5.87766729e-02f, 2.22804360e-02f, 4.59102169e-02f, -6.08456172e-02f, -7.29513466e-02f, 5.57585992e-02f, -8.15915465e-02f, 4.29427512e-02f,
  -7.64118880e-02f, -1.54303238e-02f, 6.58341050e-02f, -6.55040443e-02f, -1.92328095e-02f, 7.96275884e-02f, 4.80832048e-02f, -6.08685762e-02f, -4.98260856e-02f, 3.18402648e-02f,
  3.27545851e-02f, 5.20600891e-03f, 3.28009538e-02f, 1.42321759e-03f, -2.45797150e-02f, -3.44090164e-02f, -2.32677143e-02f, -5.08774705e-02f, -5.92692159e-02f, 8.38779062e-02f,
  -7.73321278e-03f, 2.72935349e-02f, -1.64870441e-01f, -3.22965607e-02f, -1.13527529e-01f, 7.91225508e-02f, 2.55018380e-02f, -6.25373004e-03f, -2.28400398e-02f, 2.55343854e-01f,
  6.79678172e-02f, -2.39906181e-02f, 3.68529558e-02f, 7.45047033e-02f, 3.73728983e-02f, 1.41646832e-01f, 2.23726436e-01f, 1.22275196e-01f, -7.97881782e-02f, 6.62582815e-02f,
  -2.50273887e-02f, 3.01992167e-02f, -1.44311577e-01f, -6.81901202e-02f, -3.72929722e-02f, -8.33704844e-02f, -1.54882781e-02f, -1.64648429e-01f, -1.85605120e-02f, -7.50371516e-02f,
  4.15632501e-02f, -6.68168664e-02f, -4.58995551e-02f, -1.03724346e-01f, 8.40848684e-02f, -3.04908846e-02f, 8.14372674e-02f, -1.07312635e-01f, 3.16704973e-03f, 5.79817630e-02f,
  6.07015043e-02f, -2.96610612e-02f, 1.16534065e-02f, -4.02484089e-02f, 3.76192406e-02f, -3.39335166e-02f, -8.95927921e-02f, 2.58945711e-02f, -3.32584158e-02f, -7.64245838e-02f,
  -5.38127162e-02f, -9.51853208e-03f, 4.22228947e-02f, 5.64842001e-02f, -8.85494500e-02f, -6.23778626e-02f, 2.88044922e-02f, -5.44158556e-02f, 3.53291444e-02f, 1.73450094e-02f,
  9.33842734e-02f, 4.87953201e-02f, 1.04963504e-01f, -6.22377060e-02f, 3.18548195e-02f, 1.12769352e-02f, 2.03285683e-02f, -3.85554358e-02f, -3.21451500e-02f, -7.79297762e-03f,
  -7.40287453e-02f, -8.81034657e-02f, 4.90948968e-02f, 4.52887043e-02f, 9.41463411e-02f, -7.50928931e-03f, -4.71960194e-02f, -7.44905099e-02f, -2.09528152e-02f, 5.49571216e-02f,
  1.60559490e-02f, -5.04889674e-02f, -4.43471000e-02f, 4.43284251e-02f, 6.83063343e-02f, -8.09811875e-02f, -4.75001335e-02f, 2.10881028e-02f, 1.56091070e-02f, 7.11500272e-02f,
  1.00045323e-01f, 1.84866309e-01f, -4.27267887e-02f, -9.34643671e-03f, -1.29322661e-02f, 4.72629741e-02f, -4.69391942e-02f, 6.99259574e-03f, -4.79486510e-02f, -7.46724475e-03f,
  6.10837974e-02f, -5.21324277e-02f, 7.19687119e-02f, -2.54840311e-02f, -4.96433340e-02f, 7.26165250e-02f, 7.18980059e-02f, -5.31277359e-02f, 6.24823347e-02f, -8.36718380e-02f,
  5.65497056e-02f, 4.67169434e-02f, -3.15123573e-02f, -5.45926439e-03f, 7.33438358e-02f, 5.70935830e-02f, 9.03163292e-03f, -6.45493940e-02f, -2.77516874e-03f, 3.12612727e-02f,
  -3.01036071e-02f, -2.02589706e-01f, -4.05768231e-02f, 9.48601663e-02f, 1.37050569e-01f, 7.30116293e-02f, 1.06234483e-01f, -1.36686534e-01f, 1.65913522e-01f, -2.34400019e-01f,
  -7.82041550e-02f, -7.90135413e-02f, 8.70759338e-02f, -8.42774063e-02f, 1.63603365e-01f, 8.79039317e-02f, -7.70578757e-02f, -2.09618267e-02f, 9.98485461e-02f, -5.69692487e-03f,
  -9.26556364e-02f, -1.57287583e-01f, -4.75322604e-02f, -2.73484826e-01f, -4.75666150e-02f, -2.45435964e-02f, -8.70918185e-02f, 6.01599999e-02f, -1.93204015e-01f, 5.93295135e-02f,
  5.48185594e-02f, 4.08421233e-02f, 2.71268748e-02f, 5.47729731e-02f, -3.72443423e-02f, -1.12998605e-01f, -8.81302170e-03f, 1.12581201e-01f, 2.31487304e-02f, -7.99761619e-03f,
  -6.50620088e-02f, 5.89666478e-02f, -1.05316781e-01f, -6.13296218e-02f, 1.97013747e-03f, -5.20042740e-02f, 3.34961824e-02f, 2.27192771e-02f, -5.42668775e-02f, 4.02162187e-02f,
  -8.32994357e-02f, 5.81628159e-02f, -1.81959737e-02f, -6.98833838e-02f, 8.14421177e-02f, 8.07695612e-02f, -4.97813113e-02f, 9.07535106e-03f, 2.13545505e-02f, -1.34037556e-02f,
  -4.73791435e-02f, 1.03819519e-02f, 5.88534065e-02f, -2.94796675e-02f, 3.23730521e-02f, -6.75853491e-02f, -7.12635592e-02f, -8.24039876e-02f, 4.29587588e-02f, -4.26291265e-02f,
  3.92814055e-02f, -3.34793283e-03f, 2.10825168e-02f, 4.88104150e-02f, 7.48074502e-02f, -4.23141681e-02f, 4.91112024e-02f, -5.18607609e-02f, 5.02524003e-02f, -1.63442437e-02f,
  8.62468854e-02f, 3.06768320e-03f, -2.05948036e-02f, -8.05663839e-02f, -4.83352095e-02f, 5.68912784e-03f, -9.51458663e-02f, -2.07280796e-02f, 7.01466575e-02f, 9.74483490e-02f,
  6.50428012e-02f, -7.21934140e-02f, -1.51680978e-02f, -8.44556689e-02f, 1.96177289e-02f, -1.32103071e-01f, -6.95301145e-02f, 7.06250891e-02f, 8.06971639e-02f, 6.64086416e-02f,
  1.77224458e-04f, 3.69075313e-03f, -2.35729162e-02f, 6.24830760e-02f, -5.83453812e-02f, -6.01179861e-02f, -3.63885015e-02f, -3.66770383e-03f, 7.33162761e-02f, -1.19460121e-01f,
  -3.01936250e-02f, -2.89433300e-02f, -3.80520187e-02f, 2.56007966e-02f, -3.87673900e-02f, -3.74313369e-02f, 5.88139240e-03f, 1.08663633e-03f, -7.71257374e-03f, -8.50784034e-02f,
  -2.55949736e-01f, -1.10644810e-01f, -9.75094140e-02f, -4.41091247e-02f, 1.82418227e-01f, -3.65841500e-02f, -7.43422061e-02f, 7.70644620e-02f, 8.36895332e-02f, 1.84680060e-01f,
  1.28648221e-01f, -2.75519401e-01f, -1.57183432e-03f, -8.45702961e-02f, -3.65311325e-01f, -1.77633435e-01f, -1.01438910e-01f, -9.67393890e-02f, -7.87402615e-02f, 9.87287611e-03f,
  -4.66062501e-02f, 6.01346307e-02f, -1.48928389e-01f, 2.13253975e-01f, 5.55835553e-02f, 9.64491516e-02f, 1.27165571e-01f, 1.10324912e-01f, 1.04572177e-02f, -1.40718192e-01f,
  -1.10274792e-01f, 7.08556324e-02f, -2.19374876e-02f, 4.64642197e-02f, 8.81533399e-02f, 2.00780090e-02f, -3.88414003e-02f, -9.09455419e-02f, -9.48116183e-02f, 6.15804363e-03f,
  -5.92999607e-02f, -1.61701243e-03f, -4.46693115e-02f, 2.70762071e-02f, 4.22989652e-02f, 2.79213581e-02f, -8.60138908e-02f, -7.64740482e-02f, -1.29433786e-02f, -8.24671984e-03f,
  -3.91272083e-03f, -7.24351555e-02f, -7.84875825e-02f, 2.72008553e-02f, -3.30782123e-02f, -1.95061415e-02f, -3.51624712e-02f, -3.44466232e-02f, 3.01893372e-02f, -4.09490168e-02f,
  2.69947071e-02f, -2.08921060e-02f, -1.47768268e-02f, -4.20561470e-02f, 4.67410721e-02f, -1.93878710e-02f, -6.40729815e-02f, -4.73443717e-02f, -5.56391440e-02f, 3.05140242e-02f,
  2.60674767e-02f, 2.04683468e-02f, 4.55123261e-02f, 8.05111006e-02f, -2.76897685e-03f, -3.23595013e-03f, 1.88862818e-04f, 3.10502704e-02f, -4.40762006e-02f, 3.99023183e-02f,
  2.81587094e-02f, -2.41685752e-02f, 1.87481418e-02f, -6.94582760e-02f, -9.41078216e-02f, -4.15244177e-02f, 8.78833532e-02f, 2.92567583e-03f, 5.13439253e-02f, 1.84488110e-02f,
  -2.33876444e-02f, 1.95605401e-03f, 4.84565012e-02f, -2.31339540e-02f, -3.11814733e-02f, -1.26417242e-02f, -2.00174674e-02f, -4.34807837e-02f, -6.75203353e-02f, 4.37701903e-02f,
  6.68809041e-02f, 1.27520517e-01f, 4.35389541e-02f, 3.32037872e-03f, 2.77393907e-02f, 1.54259019e-02f, -1.80333331e-02f, 1.20116901e-02f, 6.26854450e-02f, 3.21428478e-02f,
  8.24373066e-02f, 3.15158553e-02f, 8.09941664e-02f, -4.44185399e-02f, -4.42605466e-03f, 5.36943302e-02f, 2.14434024e-02f, -1.87937506e-02f, -1.34851802e-02f, -6.84817741e-03f,
  8.25577304e-02f, -7.02551231e-02f, -1.50949359e-01f, -1.44808680e-01f, 2.80536469e-02f, 2.02327043e-01f, 6.69714212e-02f, 1.88823380e-02f, -1.67967051e-01f, 6.50992244e-02f,
  1.47438077e-02f, -2.18051299e-01f, -1.09043285e-01f, -1.69885829e-01f, -1.65198848e-01f, -2.12060690e-01f, 8.27980489e-02f, 8.03470016e-02f, -1.17984228e-01f, -3.44777964e-02f,
  -5.54522276e-02f, 6.38979375e-02f, -1.42083362e-01f, 5.49926013e-02f, -1.84652358e-02f, 1.35339186e-01f, 9.35721546e-02f, 8.68002176e-02f, 8.45662653e-02f, -6.35492206e-02f,
  -1.49112167e-02f, -3.75669524e-02f, -7.10637346e-02f, 2.10704152e-02f, 1.45629138e-01f, 6.55128136e-02f, 2.58367695e-02f, -6.28648698e-02f, 2.17463356e-03f, 4.15352620e-02f,
  -3.35787125e-02f, -1.02869347e-01f, -8.15195814e-02f, -3.05265039e-02f, -3.91674004e-02f, 6.92383968e-04f, -2.93927304e-02f, 2.41340101e-02f, -3.02772131e-02f, -9.58833992e-02f,
  -7.43511468e-02f, -1.00798085e-02f, -2.34604329e-02f, -2.51732767e-02f, 3.21780629e-02f, 6.11048937e-02f, -5.56772947e-02f, -7.43276104e-02f, 8.74803513e-02f, -7.25807622e-02f,
  -6.98260441e-02f, 1.24638572e-01f, -8.93818738e-04f, 4.27725054e-02f, -2.95704342e-02f, 6.74193799e-02f, -3.90743092e-02f, 9.25906375e-02f, 1.55371372e-02f, 5.04061505e-02f,
  8.92946422e-02f, -1.42076761e-02f, 7.68286064e-02f, -1.33170234e-03f, -2.86492947e-02f, -6.69127181e-02f, -8.16794112e-02f, -6.96183741e-02f, -2.25027259e-02f, 1.05819125e-02f,
  7.89891481e-02f, 9.40127000e-02f, -3.75017971e-02f, -6.14010468e-02f, 6.03304431e-02f, 1.17219202e-02f, -5.73478118e-02f, -1.03083327e-01f, 4.81698848e-02f, 1.54932952e-02f,
  1.78023905e-01f, 5.25371209e-02f, -3.64114791e-02f, 1.22852984e-03f, 7.46179968e-02f, 3.35354991e-02f, 6.98175505e-02f, -4.62464355e-02f, 3.53111736e-02f, 3.77573841e-03f,
  5.34389690e-02f, 9.76985097e-02f, 6.44018427e-02f, -2.66092606e-02f, 1.05496019e-01f, -3.20137851e-02f, 4.25502062e-02f, -2.03837864e-02f, 1.06829911e-01f, 2.41062418e-02f,
  7.29726814e-03f, 1.06573805e-01f, -5.15782088e-02f, -7.14502158e-03f, -4.12893258e-02f, 4.03295942e-02f, 9.97657105e-02f, -3.89110334e-02f, -2.29019336e-02f, -4.33107540e-02f,
  -1.74277753e-01f, 5.82954846e-02f, -1.72732696e-01f, -1.00607261e-01f, -4.00171578e-02f, 1.59040138e-01f, -1.50271216e-02f, 5.87299243e-02f, 2.99935825e-02f, 1.64742514e-01f,
  1.46699637e-01f, -1.10306703e-01f, -2.47555785e-02f, 9.83974412e-02f, 2.90188268e-02f, 8.97241309e-02f, 8.12861547e-02f, 7.85602480e-02f, -5.48938662e-02f, -4.52458262e-02f,
  3.48089896e-02f, 1.77080646e-01f, -8.56193434e-03f, 4.11787480e-02f, 2.06801649e-02f, -4.26635407e-02f, 6.89898655e-02f, -1.38268799e-01f, 1.12219833e-01f, -2.55731568e-02f,
  7.42799640e-02f, -7.97327757e-02f, -1.33875370e-01f, 2.12957356e-02f, -1.97573584e-02f, -3.37762237e-02f, -5.04407622e-02f, -1.94854047e-02f, -1.00860395e-01f, 2.09289361e-02f,
  -3.08991806e-03f, -1.36583094e-02f, 5.05329929e-02f, -8.15002527e-03f, -1.33460518e-02f, -6.39572665e-02f, -2.32170187e-02f, -3.76790874e-02f, -5.71856797e-02f, 4.37437706e-02f,
  -7.98200890e-02f, 7.18974918e-02f, -3.48502882e-02f, 6.64683208e-02f, -5.09568602e-02f, 6.88526183e-02f, -1.74150150e-02f, 6.13004640e-02f, -2.75674406e-02f, 3.06437761e-02f,
  -1.63482707e-02f, -2.87024211e-02f, -6.45187795e-02f, 8.16850364e-02f, 7.88242277e-03f, -5.71634015e-03f, -8.37510917e-03f, 2.58892383e-02f, -1.45742437e-02f, -5.32821827e-02f,
  2.10745111e-02f, -3.27120838e-03f, -4.85875346e-02f, -4.06638049e-02f, -7.91565478e-02f, -7.31696188e-02f, 3.68487053e-02f, 2.73773950e-02f, -7.42363855e-02f, -7.98111111e-02f,
  -7.04497546e-02f, -7.04455078e-02f, -6.52326941e-02f, 8.84814933e-02f, 4.57583554e-02f, 7.15174004e-02f, 2.92303972e-02f, -8.99254754e-02f, -4.66325060e-02f, 6.40792772e-02f,
  7.37769976e-02f, -3.16158459e-02f, -2.34147012e-02f, 3.04322485e-02f, 8.99100229e-02f, 1.93650015e-02f, 5.93567342e-02f, -7.41641503e-03f, 2.39374135e-02f, 2.47875080e-02f,
  -3.25560048e-02f, 3.55390944e-02f, -4.60563451e-02f, -7.75314867e-02f, 5.32175936e-02f, 6.68909773e-02f, -1.03940070e-02f, -3.72436158e-02f, -3.40742916e-02f, -9.40456390e-02f,
  7.80749917e-02f, 3.43295932e-03f, -5.75107299e-02f, 5.91433533e-02f, 8.06290507e-02f, 9.53302160e-03f, 2.50406545e-02f, -9.76777226e-02f, 8.39193165e-02f, 2.51017809e-02f,
  1.88692853e-01f, 3.70275937e-02f, 1.21134244e-01f, 9.16886553e-02f, -1.06341779e-01f, -2.00336173e-01f, -1.72622874e-01f, 7.40045682e-02f, -1.86936796e-01f, -1.39527321e-01f,
  1.40369833e-01f, -1.69140920e-02f, 7.29229152e-02f, 7.03162029e-02f, 1.69193789e-01f, 2.39095949e-02f, 8.22249576e-02f, -1.53821530e-02f, -7.72443414e-02f, 1.63422868e-01f,
  5.47819398e-02f, 2.53450513e-01f, 1.37554154e-01f, 4.86355387e-02f, 6.56796545e-02f, 1.44952998e-01f, 8.41983259e-02f, 1.08984612e-01f, 1.47475913e-01f, 1.30515620e-01f,
  2.60841344e-02f, 1.64674833e-01f, -4.75424305e-02f, 1.27003305e-02f, 6.33630529e-02f, -7.01574683e-02f, -6.70224279e-02f, 2.32675895e-02f, -2.75670663e-02f, 3.79167423e-02f,
  2.84125526e-02f, -3.92815359e-02f, 3.64636048e-03f, 2.92085670e-02f, -1.07224040e-01f, 3.15832570e-02f, -8.40173196e-03f, -3.04290969e-02f, -1.21348396e-01f, 1.05816841e-01f,
  6.94451630e-02f, -2.24192012e-02f, -2.68440377e-02f, -2.54071653e-02f, -6.26474321e-02f, -8.49009007e-02f, 1.30831618e-02f, -3.52608897e-02f, 2.57452019e-02f, 1.74615234e-02f,
  9.57433209e-02f, -2.67370492e-02f, -4.73499810e-03f, -4.76562977e-02f, 1.25251701e-02f, -8.50322843e-02f, 1.35254469e-02f, -6.06034957e-02f, 2.09900420e-02f, -2.98891906e-02f,
  -4.30959510e-04f, -1.41834235e-02f, 5.55755533e-02f, -9.68789775e-03f, 2.26210486e-02f, -7.51122460e-02f, -1.07547194e-02f, 6.78514019e-02f, -2.22609956e-02f, -3.87787558e-02f,
  4.03533019e-02f, 4.40281183e-02f, -8.48690346e-02f, -3.14230174e-02f, -4.71401326e-02f, -1.56262086e-03f, 3.97624075e-02f, -1.49850117e-03f, -3.93847935e-02f, 8.80215466e-02f,
  1.05704237e-02f, 1.79055139e-01f, 4.30755764e-02f, -4.87747341e-02f, -8.59782100e-03f, 7.28892460e-02f, 7.51196640e-03f, 9.07378867e-02f, 2.72274818e-02f, 2.17245296e-02f,
  -2.51195189e-02f, -9.34386998e-02f, -3.31350416e-03f, -2.62008123e-02f, 5.25739715e-02f, 7.27053881e-02f, 1.56198163e-02f, -8.83091986e-02f, -1.49698453e-02f, 6.24501631e-02f,
  7.28655383e-02f, 2.54530255e-02f, 1.00545987e-01f, -7.65844062e-02f, -6.55198768e-02f, 4.25804406e-02f, 1.76990041e-04f, 3.16879079e-02f, 6.28423318e-02f, 6.56085312e-02f,
  -7.94853084e-03f, -5.01148462e-01f, -7.38957748e-02f, 1.82300285e-01f, 8.98085386e-02f, 9.99040455e-02f, 2.81973500e-02f, -1.75600335e-01f, -1.89528227e-01f, -2.74974763e-01f,
  -1.16347075e-02f, 5.30174784e-02f, -3.83239955e-01f, 6.72520921e-02f, 2.96892822e-01f, -1.40058070e-01f, 1.24880522e-01f, 1.49566472e-01f, -3.03713046e-02f, -1.13565408e-01f,
  1.66171491e-02f, 1.84967622e-01f, -4.72935364e-02f, 1.19495533e-01f, 5.71620613e-02f, 4.96659875e-02f, 9.96189564e-02f, 6.24441095e-02f, 2.96207398e-01f, 2.62146980e-01f,
  -3.90912890e-02f, -1.37072891e-01f, -2.39453800e-02f, -6.80681467e-02f, 1.34991808e-02f, -5.84525689e-02f, 3.55237201e-02f, 9.00587291e-02f, 1.19695505e-02f, -8.31581801e-02f,
  -1.01555079e-01f, 8.15112516e-02f, 6.50412664e-02f, -3.65585787e-03f, 8.28583986e-02f, 6.68151006e-02f, 3.70508283e-02f, -1.19135275e-01f, 1.21781686e-02f, 4.49766498e-03f,
  -3.08093056e-02f, -1.05339997e-01f, -4.41919230e-02f, 4.77749631e-02f, -2.83269631e-03f, 6.38617724e-02f, 4.53805588e-02f, -2.54007429e-02f, -4.03856160e-03f, 5.69894314e-02f,
  1.41262086e-02f, 2.98716258e-02f, 2.90219598e-02f, 4.68976088e-02f, 1.91966109e-02f, -2.92362142e-02f, -6.94151409e-03f, 2.51085851e-02f, 4.18848842e-02f, 2.93488782e-02f,
  2.27569584e-02f, 3.12243532e-02f, -6.75416067e-02f, -3.92409004e-02f, -4.86540198e-02f, 2.64878534e-02f, 9.45972204e-02f, 4.57422547e-02f, 4.64750268e-02f, 1.56289320e-02f,
  1.20765530e-02f, 3.54544669e-02f, -5.81558719e-02f, 7.85853192e-02f, -4.78034467e-02f, 2.41414597e-03f, -7.17125759e-02f, -1.77993951e-03f, -9.14701000e-02f, -2.46022828e-03f,
  -1.95061103e-01f, -2.60347933e-01f, 1.37808174e-02f, 4.28537317e-02f, -6.06076643e-02f, -1.39392177e-02f, -2.19955556e-02f, 3.01589109e-02f, -5.68837225e-02f, -1.89442616e-02f,
  2.60408111e-02f, 7.35780001e-02f, -3.58494967e-02f, -3.71286622e-03f, -1.34905428e-02f, -1.00617982e-01f, 1.41078802e-02f, 2.90255137e-02f, -5.35538010e-02f, -9.46988072e-03f,
  -3.45387757e-02f, -1.58724617e-02f, 6.91533536e-02f, 2.25423817e-02f, 1.12281606e-01f, 2.76421569e-02f, 2.26798542e-02f, -3.42631675e-02f, -9.71320085e-03f, 2.84115062e-03f,
  3.34539637e-02f, -1.58591703e-01f, -1.30904555e-01f, -1.99818462e-01f, -8.89688730e-02f, -2.44927600e-01f, -3.28132033e-01f, -1.69504926e-01f, -1.27322152e-01f, -1.32378429e-01f,
  -1.01661108e-01f, -1.06780611e-01f, 4.48155589e-02f, -2.95378655e-01f, 1.73022732e-01f, 1.49750292e-01f, -1.95554227e-01f, -1.65918335e-01f, 2.88567580e-02f, -1.02615714e-01f,
  5.15990332e-02f, -7.94029236e-02f, -9.98374447e-02f, -1.01252005e-01f, -2.15627447e-01f, -3.20732743e-02f, 4.85048592e-02f, -4.17796103e-03f, -1.06409155e-01f, -8.23941380e-02f,
  -1.43858299e-01f, -4.47421558e-02f, -8.55048373e-02f, 3.20477970e-02f, -6.03387989e-02f, 1.54107641e-02f, -4.31896448e-02f, -6.81834370e-02f, 4.52630706e-02f, 1.85136721e-02f,
  5.38665541e-02f, -2.26204768e-02f, -4.07719091e-02f, 2.85810269e-02f, -2.10568756e-02f, -4.26706783e-02f, -7.72032142e-02f, 2.54275603e-03f, -6.34939969e-02f, 7.16095045e-02f,
  7.39595387e-04f, 2.25248262e-02f, -8.18124563e-02f, 1.91348977e-02f, 3.09028346e-02f, 5.14012873e-02f, 7.34350160e-02f, 6.24501407e-02f, 6.42851293e-02f, -2.88724080e-02f,
  1.69395190e-03f, 8.84318575e-02f, 8.79437998e-02f, 2.54530143e-02f, 7.40085077e-03f, -2.36561429e-02f, 5.56976348e-02f, -7.13136941e-02f, -6.00177944e-02f, 6.53683841e-02f,
  -5.18187210e-02f, -4.70192209e-02f, -9.91020817e-03f, 7.05048293e-02f, 5.71836112e-03f, 7.43676201e-02f, -8.02690070e-03f, -2.73969956e-02f, -9.34725255e-02f, 2.31068786e-02f,
  -7.90577084e-02f, 1.27570536e-02f, -2.74837366e-03f, 6.56993985e-02f, 2.61239038e-04f, 3.36845890e-02f, 1.99679844e-02f, 2.61634886e-02f, 5.14552817e-02f, 2.06121262e-02f,
  5.58660477e-02f, -8.67841616e-02f, 2.25892360e-03f, -8.65402967e-02f, -3.67578492e-02f, 1.16411634e-02f, 3.16428742e-03f, -9.08308029e-02f, 3.74210738e-02f, 4.00070176e-02f,
  6.94099739e-02f, -7.33924704e-03f, 4.16748635e-02f, 4.44388986e-02f, 2.64491159e-02f, -8.32440406e-02f, -2.91632190e-02f, 9.49378219e-03f, -6.64594993e-02f, -4.13368009e-02f,
  4.42297151e-03f, 2.21017972e-02f, -5.86708523e-02f, 5.47044873e-02f, -1.60005242e-02f, 2.11055540e-02f, 5.23806140e-02f, 1.25472192e-02f, 6.26919568e-02f, 6.20457008e-02f,
  -4.47138138e-02f, 7.78064355e-02f, 4.92100008e-02f, 8.60616863e-02f, -9.68158320e-02f, -2.69733429e-01f, -1.45562679e-01f, -1.88332498e-02f, 9.59265686e-04f, 1.17813691e-01f,
  4.23801504e-02f, 4.32006717e-02f, 2.52688006e-02f, 6.42767251e-02f, -4.88847420e-02f, -7.16625899e-02f, -1.37708336e-01f, -2.85310857e-03f, 5.67570925e-02f, -5.77549487e-02f,
  6.59888163e-02f, 2.28549317e-02f, 1.70945823e-01f, 8.22520107e-02f, 1.09908218e-02f, 1.92409933e-01f, 1.36723936e-01f, -1.57305170e-02f, 1.11488566e-01f, -1.06491730e-01f,
  -1.60412595e-01f, 9.33715627e-02f, 1.39046926e-02f, -9.25037414e-02f, 3.55905108e-02f, -9.95822921e-02f, -3.88741270e-02f, 5.20882271e-02f, 2.66785920e-03f, 4.86652516e-02f,
  -6.92534894e-02f, -1.59221049e-02f, -4.19547036e-02f, 1.07706428e-01f, 5.44517227e-02f, 4.89193685e-02f, 1.11905811e-02f, 1.86221786e-02f, 8.80074408e-03f, 6.25041798e-02f,
  4.10516039e-02f, -3.68170068e-02f, 1.99927296e-02f, 6.50321245e-02f, 9.02323052e-02f, -6.15989603e-02f, -2.96318717e-03f, 1.18880244e-02f, -4.98749502e-02f, -3.54914367e-02f,
  -4.94877882e-02f, 1.61205530e-02f, 1.76140498e-02f, 4.01543118e-02f, -4.45972607e-02f, 4.84802422e-06f, -5.97140715e-02f, 3.52105796e-02f, 8.00284818e-02f, -8.53979290e-02f,
  -1.29674161e-02f, -3.14446539e-03f, -3.19524333e-02f, -7.41108209e-02f, 3.05249896e-02f, 6.58731759e-02f, -6.68881983e-02f, 1.99095858e-03f, 3.63017991e-03f, 8.10506418e-02f,
  9.09501500e-03f, -9.71618667e-02f, 8.31390396e-02f, -1.04245029e-01f, 5.98311946e-02f, 1.06798202e-01f, 3.12334299e-03f, -4.95609269e-02f, 9.70764384e-02f, -2.64800917e-02f,
  -9.83273014e-02f, 1.25822961e-01f, 1.42621165e-02f, 3.95458890e-03f, -6.27960358e-03f, -3.37233359e-05f, 9.49785113e-02f, -1.65853146e-02f, 8.75235200e-02f, -9.08513442e-02f,
  4.35478836e-02f, 4.84202914e-02f, 5.63799255e-02f, -3.28991190e-02f, -6.81530833e-02f, -3.33196744e-02f, 1.16713375e-01f, -4.04361524e-02f, -1.85173508e-02f, 1.04441769e-01f,
  5.09596206e-02f, -2.40836367e-02f, -1.20070418e-02f, 4.98739630e-02f, -2.24966221e-02f, -3.43447998e-02f, 7.18511790e-02f, 2.00500898e-02f, 9.66215134e-03f, -2.73212940e-02f,
  3.54601532e-01f, -1.77463666e-01f, 1.83602810e-01f, 1.57800123e-01f, 2.63770252e-01f, 5.75778671e-02f, 1.70380212e-02f, 1.30063564e-01f, 2.36055419e-01f, -1.84550598e-01f,
  -3.34404334e-02f, 5.19023910e-02f, -2.74619579e-01f, 1.50190443e-01f, 2.81778481e-02f, -2.17131555e-01f, 9.02597010e-02f, -5.57822213e-02f, 3.83684784e-02f, -2.93001980e-02f,
  7.26986304e-02f, -4.86539826e-02f, 5.13274856e-02f, -5.20881712e-02f, 1.70919463e-01f, 9.35843736e-02f, -2.28484392e-01f, -6.04374148e-02f, 5.40450253e-02f, -3.67537774e-02f,
  4.61348519e-02f, 1.13017470e-01f, 8.66615847e-02f, 4.60978784e-02f, -7.32500553e-02f, 8.05850103e-02f, -5.17866425e-02f, 3.59967612e-02f, 1.02099352e-01f, -3.39763314e-02f,
  6.07329095e-03f, 2.10260204e-03f, -7.21358182e-03f, -1.91828550e-03f, 9.29312110e-02f, -2.53051315e-02f, 9.10573602e-02f, 4.01241854e-02f, 2.56391037e-02f, -2.27569118e-02f,
  8.33569318e-02f, 9.92871448e-02f, 1.12568825e-01f, -9.98108555e-03f, 5.66813909e-02f, 5.02854101e-02f, -3.61145623e-02f, 3.46527658e-02f, 4.46431786e-02f, 6.08175844e-02f,
  -1.24097675e-01f, 8.86185654e-03f, -4.39765640e-02f, 1.14641741e-01f, -4.46651829e-03f, -2.89825350e-02f, 8.35204218e-03f, -3.39305736e-02f, -1.76552888e-02f, -3.52975354e-02f,
  5.99586219e-02f, 3.24543491e-02f, 6.94474392e-03f, 3.05568483e-02f, 2.05109045e-02f, 1.70524046e-03f, -6.54141009e-02f, -4.48359735e-02f, 1.14656584e-02f, 9.65428576e-02f,
  -7.63609167e-03f, -3.06294952e-02f, -9.74116661e-03f, -2.62893606e-02f, 4.10910212e-02f, -3.32602151e-02f, 2.17312705e-02f, 4.90087681e-02f, 7.65787512e-02f, -5.98218665e-02f,
  -1.24138467e-01f, -3.75970662e-01f, 3.00052930e-02f, 2.69431993e-02f, -7.33336136e-02f, 6.52547404e-02f, -1.75148435e-02f, 9.69352871e-02f, -6.98580919e-03f, 7.26403669e-02f,
  -5.69899231e-02f, 6.06754124e-02f, -3.74941975e-02f, -3.22929136e-02f, -6.73286617e-03f, 5.09022400e-02f, -1.37375697e-01f, -1.91894975e-02f, -2.81023700e-02f, -8.27709138e-02f,
  -1.86531730e-02f, 4.70074303e-02f, -1.76490825e-02f, 4.05016877e-02f, -1.74903870e-02f, -6.44739568e-02f, -5.30777983e-02f, -1.13183945e-01f, -8.65327641e-02f, -4.76824790e-02f,
  7.02146366e-02f, -1.30364999e-01f, 4.71927300e-02f, 5.14337383e-02f, -1.20873511e-01f, -8.86939839e-02f, -8.11779350e-02f, -9.31887180e-02f, -1.50610790e-01f, -1.32525176e-01f,
  3.90589051e-02f, 7.70369396e-02f, 2.16364801e-01f, 1.48501277e-01f, 3.43617260e-01f, 1.59159884e-01f, -2.31378805e-02f, 1.11207344e-01f, -9.08904448e-02f, -3.35498787e-02f,
  1.22602165e-01f, 2.25659162e-02f, 2.83949763e-01f, -3.61772701e-02f, -7.02300519e-02f, -7.69393072e-02f, 2.62374282e-01f, 7.43284449e-02f, -2.48252973e-02f, 1.03496790e-01f,
  -1.33378729e-01f, 5.66717004e-03f, 4.07573730e-02f, -2.02215519e-02f, 4.06139083e-02f, -6.95120320e-02f, 8.44555814e-03f, 9.67187807e-02f, 2.84369420e-02f, -7.56677464e-02f,
  9.90681164e-03f, -4.53172885e-02f, -1.00149170e-01f, 1.25211673e-02f, -1.47449747e-01f, -1.10303052e-01f, -3.07420269e-02f, -4.92183752e-02f, 2.62862090e-02f, -6.81455657e-02f,
  -5.42911189e-03f, -1.11106806e-01f, 5.54489456e-02f, -5.99362468e-03f, 8.60503837e-02f, -8.58362615e-02f, 3.50569636e-02f, 9.39106420e-02f, -9.46572646e-02f, -9.52081308e-02f,
  9.14936587e-02f, -1.43925929e-02f, -6.51326030e-02f, -3.49775068e-02f, -4.60754856e-02f, -5.83653487e-02f, -5.13754180e-03f, 3.76845598e-02f, 9.98264924e-02f, 4.41760309e-02f,
  4.57176417e-02f, 4.47203703e-02f, -1.98113509e-02f, 3.80839333e-02f, 5.99793121e-02f, 4.80041914e-02f, -5.62328324e-02f, -2.68420298e-02f, -2.76443046e-02f, -4.11574766e-02f,
  2.60431245e-02f, 1.45025859e-02f, -4.10265028e-02f, 1.40099591e-02f, 1.17028495e-02f, 1.06375404e-01f, -2.17485875e-02f, 4.55484428e-02f, -7.75650963e-02f, 5.97297661e-02f,
  -6.93419995e-03f, 1.08481735e-01f, -4.75754142e-02f, 2.21418357e-03f, -5.14194183e-02f, 1.23635819e-02f, -5.59500903e-02f, 1.91473518e-03f, 8.37105587e-02f, 5.74909635e-02f,
  4.34645042e-02f, -2.85897031e-02f, -3.34402137e-02f, 4.78007086e-02f, -2.78111510e-02f, 2.50477605e-02f, 6.38873875e-02f, 4.00801823e-02f, -4.13384475e-02f, 5.92218824e-02f,
  -3.39488499e-03f, 6.70066848e-02f, 2.90617887e-02f, -8.88964459e-02f, -2.13085003e-02f, -5.15374765e-02f, -7.00374097e-02f, 2.58267019e-02f, -2.03387141e-02f, -2.45330576e-02f,
  -4.42646295e-02f, 1.23610586e-01f, 1.93170190e-01f, 2.24182397e-01f, -2.82150432e-02f, -3.23052227e-01f, -2.22911403e-01f, -2.60380860e-02f, 3.82497236e-02f, -1.69435740e-01f,
  -3.25728878e-02f, -1.86766479e-02f, -2.16746777e-01f, 2.37383679e-01f, 1.96238235e-01f, -2.71146782e-02f, 1.35754243e-01f, -3.43677774e-02f, 6.74970746e-02f, 4.00080532e-02f,
  2.14434594e-01f, 2.52267569e-01f, 2.35785276e-01f, 1.38512552e-01f, 5.92040867e-02f, 2.12683454e-01f, 2.62830079e-01f, 5.69217764e-02f, 2.90610462e-01f, 8.54260325e-02f,
  -1.50893599e-01f, 3.40607092e-02f, 3.96428630e-02f, -1.93588436e-02f, -5.07706963e-02f, -1.02370620e-01f, -5.77021344e-03f, -3.40187661e-02f, -2.80828960e-02f, -3.22260484e-02f,
  1.82319738e-04f, 1.92054212e-02f, 3.96871641e-02f, 2.50823535e-02f, -1.55024109e-02f, 1.18377127e-01f, 2.99607385e-02f, -4.46817279e-02f, 1.08976783e-02f, -5.42589873e-02f,
  -1.23572294e-02f, 6.81476947e-03f, -8.76845140e-03f, 4.77990061e-02f, 4.07527499e-02f, 1.79695096e-02f, 3.52055393e-02f, 5.37776053e-02f, 2.95125078e-02f, 8.88255704e-03f,
  -9.48660523e-02f, 4.84648757e-02f, -4.05593682e-03f, -4.46180906e-03f, 4.93835285e-02f, 3.11914235e-02f, -2.60351487e-02f, 1.20079909e-02f, -4.04273905e-02f, -2.26672366e-02f,
  7.35188276e-02f, -9.78245027e-03f, 5.05900644e-02f, 2.60866452e-02f, -4.67325002e-02f, -3.13375182e-02f, -2.48844903e-02f, 4.87801880e-02f, -2.33147480e-02f, 4.88276221e-02f,
  5.96161895e-02f, 1.04586910e-02f, 5.78620099e-02f, -2.39793845e-02f, -6.42691478e-02f, 3.27396952e-02f, -2.65175980e-02f, -6.41027465e-02f, 1.90557018e-02f, 2.41267048e-02f,
  4.18165177e-02f, 3.05350065e-01f, 7.94522613e-02f, -5.69169186e-02f, 1.03782117e-01f, -4.00458500e-02f, 2.79547926e-02f, -2.34473590e-02f, 1.35618269e-01f, 3.24920900e-02f,
  -7.88471475e-02f, -5.77247217e-02f, 6.85655279e-04f, -3.38931158e-02f, -5.73190302e-03f, 1.24185216e-02f, -1.50038768e-02f, 1.01804487e-01f, 6.23918623e-02f, 2.11315006e-02f,
  8.78368616e-02f, -1.10587245e-02f, 3.78752057e-03f, -6.83947727e-02f, -3.66183929e-02f, -2.56729703e-02f, -7.23601803e-02f, -3.89190428e-02f, 8.20469186e-02f, 7.94558004e-02f,
  3.51648778e-01f, -1.49515614e-01f, -1.37810498e-01f, 1.88618172e-02f, 1.50471359e-01f, 1.48202240e-01f, 1.76326826e-01f, 1.40122995e-01f, 2.06365779e-01f, -4.03264724e-02f,
  2.42251351e-01f, -1.23738691e-01f, -9.58920196e-02f, 1.37159526e-01f, 1.20880894e-01f, -4.72532958e-03f, 1.17964543e-01f, 1.19960934e-01f, -2.64087729e-02f, 4.27100770e-02f,
  8.97067487e-02f, 1.54142514e-01f, -9.24983062e-03f, -7.24100545e-02f, 1.64554238e-01f, -1.44084379e-01f, -2.18212791e-02f, -5.42844273e-02f, -1.44947495e-03f, -3.29578742e-02f,
  9.64699313e-03f, 1.11491963e-01f, 8.14656541e-02f, -9.97448638e-02f, 2.15477105e-02f, -5.70773222e-02f, -1.20931335e-01f, -6.43986985e-02f, -2.66621429e-02f, 7.76601210e-02f,
  -1.24228343e-01f, -4.67563011e-02f, 3.10073271e-02f, 1.85483869e-03f, 6.22477271e-02f, 6.35299310e-02f, 9.49250460e-02f, -1.80310197e-02f, -9.58944336e-02f, -1.46264713e-02f,
  6.95825294e-02f, -3.93981077e-02f, 1.12509966e-01f, -8.53549242e-02f, -3.82047556e-02f, -5.68894623e-03f, -1.23031043e-01f, -8.67442340e-02f, -7.17767328e-02f, -5.58484569e-02f,
  -5.72237000e-02f, -2.76555903e-02f, 4.14289854e-04f, -6.79550543e-02f, 1.34305460e-02f, 4.92632948e-02f, 4.46321210e-03f, -2.26708092e-02f, 3.35389115e-02f, -5.17291985e-02f,
  6.10482432e-02f, -2.33780942e-03f, -7.04373941e-02f, 3.44075263e-02f, 6.81342334e-02f, 6.94898665e-02f, -1.13082994e-02f, -5.67827411e-02f, 4.99321446e-02f, 2.55037956e-02f,
  -1.11517660e-01f, -1.98686030e-02f, 1.00187391e-01f, -5.06300256e-02f, 6.24257885e-02f, 7.77638555e-02f, 4.50710114e-03f, 7.47700781e-02f, 6.05302118e-02f, -6.98190108e-02f,
  1.22455377e-02f, -8.58249813e-02f, -2.98752952e-02f, -3.42060439e-02f, -1.44518718e-01f, -4.00311165e-02f, 2.53701713e-02f, 2.36791410e-02f, -6.66566864e-02f, -2.23088590e-03f,
  3.27581502e-02f, -6.19053058e-02f, 7.69738257e-02f, -3.79404165e-02f, -1.45943360e-02f, 1.85155068e-02f, -5.35762273e-02f, -7.51562566e-02f, 2.58105826e-02f, -1.83969717e-02f,
  3.11980918e-02f, -4.13482115e-02f, -9.71354991e-02f, 5.31052127e-02f, -8.08165148e-02f, 2.72361841e-02f, -1.85256843e-02f, -3.80253643e-02f, 4.34922404e-05f, -8.90749320e-02f,
  -3.25691223e-01f, 2.85911083e-01f, -3.73727456e-02f, -6.11517541e-02f, -4.06393632e-02f, -2.00635791e-01f, 6.25338629e-02f, -1.63631923e-02f, -3.60765941e-02f, 3.56547445e-01f,
  1.71565697e-01f, -5.18620834e-02f, 1.42403707e-01f, 1.10111400e-01f, -4.72055078e-01f, -7.93965010e-04f, -1.79912448e-01f, 1.23552780e-03f, -4.10213787e-03f, -2.71075107e-02f,
  -1.73271447e-01f, 9.11997780e-02f, -5.09973019e-02f, -7.41981808e-03f, 4.76872995e-02f, -2.59625446e-02f, 1.37364492e-02f, 8.18142742e-02f, 4.62286407e-03f, -2.20496431e-02f,
  2.04806179e-02f, 1.31573111e-01f, -3.13374517e-03f, 9.03661102e-02f, -6.39266446e-02f, -5.45075396e-03f, 5.32816350e-02f, -6.13345392e-03f, 2.28764564e-02f, -1.00005850e-01f,
  -2.38424782e-02f, 6.43515587e-02f, 1.10438466e-02f, -1.78166814e-02f, -3.59315127e-02f, 2.89386939e-02f, 3.55253997e-03f, 2.38400269e-02f, 7.57701695e-02f, 2.39256732e-02f,
  5.75458631e-02f, -4.18804623e-02f, 3.61063448e-03f, -1.01505853e-02f, -9.75546688e-02f, 2.45212186e-02f, -7.97159299e-02f, 3.94465216e-02f, -8.81944075e-02f, -1.14930324e-01f,
  -7.00795725e-02f, -7.39692301e-02f, 9.16402116e-02f, 1.27636474e-02f, -5.51845366e-03f, 3.64458784e-02f, 9.31480527e-02f, -5.79986535e-02f, 3.61206941e-02f, 5.09506129e-02f,
  2.35455260e-02f, -2.75541283e-02f, -3.85620110e-02f, 5.19910343e-02f, -7.27501512e-02f, 1.36059616e-02f, -2.64114682e-02f, -5.69427498e-02f, -7.44008198e-02f, -1.77051462e-02f,
  7.77667835e-02f, -2.32369211e-02f, 9.15456042e-02f, 8.21470618e-02f, -6.23551793e-02f, 3.47314030e-02f, -4.33123931e-02f, 4.05886136e-02f, 3.69984396e-02f, -2.95474306e-02f,
  1.82124390e-03f, -1.76380202e-01f, 2.56819166e-02f, 6.54552355e-02f, 1.00457892e-01f, -1.59443244e-02f, -1.95757486e-02f, -1.14496380e-01f, -4.75326926e-02f, -7.36971125e-02f,
  -9.67639014e-02f, 3.73387896e-02f, -9.78140607e-02f, -4.12996337e-02f, -7.34979510e-02f, -4.74702269e-02f, 3.62017145e-03f, -1.36391064e-02f, -7.84129277e-02f, -1.24890745e-01f,
  2.73720715e-02f, 3.68722081e-02f, 1.21118780e-02f, 2.02791467e-02f, 6.21859953e-02f, 6.80038780e-02f, 3.75927077e-03f, -6.62209317e-02f, 1.91347264e-02f, -7.36682117e-02f,
  -1.90934792e-01f, 9.60181132e-02f, -6.67680353e-02f, -2.76493341e-01f, 2.44318862e-02f, -1.94321409e-01f, -3.39660704e-01f, 9.88971964e-02f, 1.16276301e-01f, 9.69125479e-02f,
  -6.16701804e-02f, 1.47560090e-01f, 1.06308796e-01f, -2.39418060e-01f, -1.18442126e-01f, 7.37217814e-02f, -3.80995899e-01f, -1.61856845e-01f, -1.86831281e-02f, -2.12727979e-01f,
  -8.68109986e-02f, -1.64553255e-01f, -1.42422602e-01f, -3.58822532e-02f, -2.33926222e-01f, -3.76194320e-03f, 2.61906739e-02f, -3.87872607e-02f, -2.86707282e-01f, 1.44169014e-02f,
  -2.38282327e-02f, 9.82786119e-02f, -1.32039597e-03f, -6.37622327e-02f, -9.75794941e-02f, -3.21652889e-02f, -7.07416013e-02f, 5.63400723e-02f, 5.54328039e-02f, 4.33451608e-02f,
  1.75798107e-02f, 3.42626199e-02f, 2.22186204e-02f, 1.17668740e-01f, 2.94833593e-02f, 6.15032837e-02f, 2.91175917e-02f, -7.49325678e-02f, 4.65996377e-02f, 4.65046316e-02f,
  -1.09106317e-01f, 1.12610655e-02f, 1.27066931e-04f, -7.40456134e-02f, -3.29343341e-02f, 3.39026786e-02f, -4.25206460e-02f, -1.01550281e-01f, -7.59265348e-02f, -4.36666831e-02f,
  -1.39040221e-02f, -7.12942258e-02f, -4.73185107e-02f, -1.30751207e-02f, 5.68916276e-02f, -1.58636738e-02f, 3.34775671e-02f, -4.51691309e-03f, -2.16011051e-02f, -2.81963348e-02f,
  -6.30723163e-02f, 6.30932078e-02f, 1.00970455e-02f, 1.98256597e-02f, -1.25855161e-02f, -5.97290546e-02f, -1.62500143e-02f, 1.17241191e-02f, -1.13249473e-01f, 3.35769281e-02f,
  8.27700347e-02f, -4.96047698e-02f, 3.60431825e-03f, 7.49312900e-03f, -8.43029527e-04f, 8.38305429e-02f, 1.63200963e-02f, 2.14419477e-02f, -3.46522145e-02f, -1.65406726e-02f,
  3.63774672e-02f, -3.43298167e-02f, 4.50499244e-02f, 8.68724883e-02f, 5.46043776e-02f, 5.88607416e-02f, -3.80928814e-02f, 1.99628086e-03f, -6.81654736e-02f, 2.09004395e-02f,
  -1.03221834e-01f, -4.37856205e-02f, -1.00427240e-01f, -4.40215729e-02f, 3.30097042e-02f, -7.12856427e-02f, -6.66171720e-04f, 5.75682409e-02f, -4.08719741e-02f, -9.25579853e-03f,
  -5.49899489e-02f, -5.97150326e-02f, -5.13363518e-02f, -1.65378093e-03f, -8.84370692e-03f, -5.43644726e-02f, 1.75063293e-02f, 7.46536031e-02f, -1.88092235e-02f, -2.28875875e-02f,
  -2.72752047e-01f, -9.48965782e-04f, 3.54299136e-02f, -2.09997535e-01f, 2.08087698e-01f, 1.05433874e-01f, -1.25148684e-01f, -8.59782624e-04f, -2.61805415e-01f, 4.49703857e-02f,
  1.24464966e-01f, -1.55839399e-01f, 1.00670792e-01f, -3.09370190e-01f, -1.89487830e-01f, -1.75485268e-01f, -1.97385877e-01f, -1.60008550e-01f, -1.80596575e-01f, -1.19679701e-02f,
  -1.16433270e-01f, 5.37223509e-03f, -1.24818407e-01f, 1.90599889e-01f, 1.38336103e-02f, -4.68089990e-02f, 1.11060418e-01f, 2.08153456e-01f, -2.65031885e-02f, 2.77411863e-02f,
  -4.32718918e-02f, -9.77575108e-02f, -3.42066437e-02f, 6.88415319e-02f, -5.19833760e-03f, 9.74089131e-02f, 2.46317405e-02f, -8.33386555e-03f, 4.93102260e-02f, -8.16771463e-02f,
  8.72720703e-02f, 1.32733230e-02f, -5.15688993e-02f, -6.17295271e-03f, -3.66205424e-02f, -9.33622643e-02f, 4.56137136e-02f, 7.51741379e-02f, -2.99323425e-02f, -5.46975695e-02f,
  1.75364111e-02f, -5.98728433e-02f, -6.12464771e-02f, -3.81948836e-02f, -4.88352887e-02f, -9.44058523e-02f, -6.26631826e-02f, 4.32011448e-02f, -1.31890662e-02f, 4.47643250e-02f,
  1.83973927e-02f, -4.26345430e-02f, -3.10029406e-02f, 2.64396854e-02f, -9.32335481e-02f, 3.51816006e-02f, -4.83193099e-02f, -8.75390321e-03f, -6.51227981e-02f, 1.65709928e-02f,
  7.72749409e-02f, -5.74005060e-02f, -2.42216308e-02f, -4.56407405e-02f, -2.78095789e-02f, 3.79605889e-02f, 8.48249570e-02f, 6.16761409e-02f, -6.60908744e-02f, -2.14220192e-02f,
  -9.00607631e-02f, 2.78858934e-02f, -5.61707132e-02f, 4.57266979e-02f, -1.79380109e-03f, -4.32482101e-02f, 8.77905563e-02f, -2.40416862e-02f, 4.38148808e-03f, -2.26109512e-02f,
  1.16856769e-01f, -4.11502570e-02f, -1.68758689e-03f, 7.19058737e-02f, 6.86217323e-02f, 7.81422183e-02f, 2.69009806e-02f, -5.88717870e-03f, 3.35989296e-02f, -8.04394782e-02f,
  5.17040007e-02f, -6.23569824e-02f, 6.97060451e-02f, 3.37874517e-02f, 6.22828007e-02f, 6.05058521e-02f, 3.89856956e-04f, 9.67771634e-02f, -6.19318860e-04f, 7.78508633e-02f,
  1.61172282e-02f, 5.44440150e-02f, -8.57114643e-02f, -3.13496366e-02f, 1.82465650e-02f, 9.75898118e-04f, -6.88478425e-02f, 1.35488156e-02f, -1.98572222e-02f, 5.27054854e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.35608190e-01f, 4.14325804e-01f, 1.56988621e-01f, 1.13212906e-01f, 1.16211317e-01f, 1.56520516e-01f, 1.38685226e-01f, 1.20604433e-01f, 3.26138851e-03f, 1.96597368e-01f,
  5.95212840e-02f, 1.47319064e-01f, 1.42005295e-01f, 2.19314188e-01f, 4.69887443e-02f, 1.48337826e-01f, 2.26937365e-02f, 1.34950608e-01f, 1.67383224e-01f, 5.33926450e-02f,
  2.16982290e-01f, 1.66433707e-01f, 1.39736921e-01f, 1.31493509e-01f, 2.68873066e-01f, 1.33487925e-01f, 2.32288092e-01f, 2.95090407e-01f, 5.79682849e-02f, 2.11932763e-01f,
  3.88908386e-01f, 2.66577065e-01f, 5.92610426e-02f, 1.82773292e-01f, 2.74499387e-01f, -1.16403529e-03f, 1.78407848e-01f, 1.54748127e-01f, 2.63101667e-01f, 9.95890051e-02f,
  5.54108098e-02f, 1.49077132e-01f, 4.70566787e-02f, 8.77418444e-02f, 1.23813100e-01f, 2.53092378e-01f, 2.04176635e-01f, 2.68139429e-02f, 3.18020061e-02f, 1.56064898e-01f,
  1.90084413e-01f, 2.89789885e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -9.95488539e-02f, 2.43059453e-02f, -1.93119328e-02f, 1.38716221e-01f, -2.02776924e-01f, -5.02350092e-01f, 3.86443824e-01f, 2.37063825e-01f, 3.60666215e-01f, -1.66322768e-01f,
  -4.53871727e-01f, -5.58727264e-01f, -1.72523588e-01f, 4.51834828e-01f, -4.75817695e-02f, -2.89917737e-03f, -3.20739269e-01f, 2.15344235e-01f, -1.46718293e-01f, -3.08716327e-01f,
  -9.16510299e-02f, -1.31215662e-01f, -1.85980592e-02f, -1.56962484e-01f, -6.73141032e-02f, -2.50652254e-01f, -2.37055227e-01f, -2.11808398e-01f, -8.28953162e-02f, 7.60812402e-01f,
  4.81694072e-01f, 8.32635537e-02f, -1.67406693e-01f, -1.90372899e-01f, 3.96519452e-01f, -6.83983192e-02f, -1.96380168e-01f, -2.34820531e-03f, -3.00527811e-01f, -2.71263182e-01f,
  -1.45283490e-01f, 1.07342035e-01f, 4.52015661e-02f, -2.20180392e-01f, 2.17574835e-02f, -1.68478340e-01f, 3.27608883e-01f, 2.74292648e-01f, 2.91443110e-01f, -1.88431755e-01f,
  1.07703730e-01f, 8.24344829e-02f, 3.28382164e-01f, -2.33133107e-01f, -1.01261310e-01f, -1.17094278e-01f, -3.58490832e-02f, -2.62531489e-01f, 1.37534350e-01f, -1.45329326e-01f,
  9.07175168e-02f, 3.92291963e-01f, -2.40817755e-01f, -1.51241720e-01f, 4.06670086e-02f, -1.32797211e-01f, 2.11351380e-01f, -4.20928448e-02f, -7.24053904e-02f, 4.05993551e-01f,
  -5.87959774e-02f, -5.14411867e-01f, -3.02029788e-01f, -3.63556713e-01f, -3.88694912e-01f, -1.29919887e-01f, -1.94181114e-01f, -3.32760751e-01f, -2.29143396e-01f, -1.83424279e-01f,
  -2.45799348e-01f, 7.07131267e-01f, -2.06911877e-01f, 7.72940218e-01f, 1.42667457e-01f, 2.73802221e-01f, -4.65157032e-02f, 7.49942139e-02f, -3.09648067e-01f, 7.88042620e-02f,
  -5.92408627e-02f, -1.39884986e-02f, 1.75485522e-01f, 2.82394081e-01f, 2.92901039e-01f, -1.14095449e-01f, -3.20136026e-02f, 1.36007620e-02f, -1.24059217e-02f, -2.12872028e-01f,
  -2.22968578e-01f, 7.50993416e-02f, -2.05154240e-01f, -1.59731939e-01f, -2.98299938e-02f, -8.10404494e-02f, -3.56332213e-01f, -2.10980162e-01f, 1.77035198e-01f, 1.63332626e-01f,
  5.09491324e-01f, 1.08788446e-01f, 2.55686969e-01f, -2.46469155e-01f, -1.16717368e-01f, 1.09936714e-01f, 2.71173418e-01f, 2.34820992e-01f, -1.55063331e-01f, 1.68674186e-01f,
  -2.29360566e-01f, -3.58444937e-02f, 7.47682452e-02f, -2.66318232e-01f, 4.47452694e-01f, -1.69948369e-01f, -1.72691494e-01f, -9.87953991e-02f, -1.80723965e-01f, -2.48178437e-01f,
  3.77284065e-02f, -6.46116138e-01f, -1.37465030e-01f, -3.41771007e-01f, 2.34854177e-01f, -2.33460486e-01f, -2.48230323e-01f, -3.83103251e-01f, -2.70648539e-01f, 3.87100965e-01f,
  -2.37705372e-02f, 7.91829675e-02f, -5.43746129e-02f, -6.38396144e-02f, -1.65700257e-01f, -4.91407029e-02f, -8.80340859e-02f, 6.81883574e-01f, 1.14902325e-01f, -1.63266540e-01f,
  2.52162199e-03f, -1.70196578e-01f, -1.25631019e-01f, -8.52362216e-02f, -1.41115800e-01f, 5.15313804e-01f, -2.10772678e-01f, -6.76819161e-02f, -2.13537455e-01f, -3.51032577e-02f,
  2.41380781e-02f, -6.99549392e-02f, 3.30057479e-02f, 1.47683874e-01f, -9.10697039e-03f, -6.32862076e-02f, -1.11843668e-01f, -1.56159312e-01f, 1.59394920e-01f, -7.62080029e-02f,
  -2.46370882e-01f, -2.46994309e-02f, -5.38862087e-02f, -1.47422209e-01f, -8.65145624e-02f, -1.43806249e-01f, -1.28918409e-01f, -9.11453366e-02f, 2.86040530e-02f, 5.27479909e-02f,
  1.36294201e-01f, 4.18257602e-02f, 8.76651704e-01f, -3.57214957e-02f, -5.28192967e-02f, 2.25080222e-01f, 5.24510369e-02f, 3.13524067e-01f, -5.82761802e-02f, -1.77986294e-01f,
  -1.40521064e-01f, 6.38821125e-02f, -1.11530103e-01f, -5.41150868e-01f, 5.22701889e-02f, -3.91208716e-02f, -2.77671844e-01f, -2.67129958e-01f, -1.54538944e-01f, 3.16652358e-01f,
  -2.15928122e-01f, 5.09646654e-01f, 4.97943521e-01f, -3.66237313e-01f, -9.78280455e-02f, 5.42876005e-01f, -1.06193535e-01f, 4.21826690e-01f, 1.98319629e-01f, -2.24027514e-01f,
  -3.08410777e-03f, -2.13155150e-01f, 3.60900499e-02f, -2.10051537e-01f, 1.06222099e-02f, -7.05013275e-02f, -6.99901134e-02f, -2.41750598e-01f, 5.12734689e-02f, -1.41883358e-01f,
  -1.78302318e-01f, -2.26516813e-01f, -7.26283342e-02f, 4.81140286e-01f, 1.02426633e-02f, -9.91831794e-02f, 9.30759776e-03f, 3.84626478e-01f, -2.40668416e-01f, -1.02639332e-01f,
  -1.08358428e-01f, 1.20731130e-01f, -1.96335167e-01f, -1.73690543e-01f, -4.34092134e-01f, -1.23554997e-01f, -2.24763021e-01f, -1.18606292e-01f, 7.39547685e-02f, 5.43133840e-02f,
  -2.20629334e-01f, 4.58629280e-02f, 4.07695144e-01f, -1.71632320e-01f, 3.55358385e-02f, -4.50749733e-02f, -1.57752082e-01f, -1.15101829e-01f, 1.14347808e-01f, -2.04603150e-01f,
  -8.03262591e-02f, 3.93307954e-02f, -2.38055084e-03f, 5.70752442e-01f, 5.34843028e-01f, 2.70844519e-01f, 1.84566438e-01f, 2.26583302e-01f, 3.93061787e-02f, 1.23130612e-01f,
  4.03671056e-01f, 4.88383710e-01f, 3.77890095e-02f, 3.65357310e-01f, 6.91139773e-02f, 2.88688928e-01f, -1.71520472e-01f, -2.55413204e-01f, 4.63989437e-01f, 9.85608876e-01f,
  -2.41326496e-01f, -1.98887989e-01f, -8.59925225e-02f, -2.70992994e-01f, 1.23575263e-01f, -2.23293468e-01f, 1.01171499e-02f, -1.06059074e-01f, -1.85706854e-01f, -2.74910182e-01f,
  -8.36441293e-02f, 2.74936438e-01f, 2.00227976e-01f, -1.50898665e-01f, -7.49235749e-02f, -4.24273275e-02f, -2.82307595e-01f, -1.57346740e-01f, -4.05786723e-01f, -3.07997555e-01f,
  4.20061976e-01f, -1.50046766e-01f, -7.41392549e-04f, 1.28642112e-01f, 2.36246660e-02f, 5.56643665e-01f, 6.55263737e-02f, -5.47526926e-02f, 3.83818060e-01f, -2.18190044e-01f,
  -7.05249831e-02f, 4.60755318e-01f, -3.32294583e-01f, 1.25669703e-01f, -1.95396394e-01f, -3.50973755e-02f, -5.00890166e-02f, 9.22324955e-02f, 7.11114258e-02f, 8.60641059e-03f,
  -8.45462307e-02f, -7.12827817e-02f, -1.63573951e-01f, 6.83493167e-02f, -1.04266033e-01f, -6.28587902e-02f, -9.07740816e-02f, -7.00772554e-02f, 1.38086662e-01f, 1.87918127e-01f,
  2.66374379e-01f, 2.51721382e-01f, 2.04129711e-01f, 1.79861113e-01f, 2.35183150e-01f, 4.57619101e-01f, -2.04266876e-01f, 1.13030478e-01f, 2.12421790e-01f, 5.91800869e-01f,
  -1.64835393e-01f, -1.85674906e-01f, 1.01952106e-01f, -4.70504761e-01f, 4.26155403e-02f, -2.48156428e-01f, 1.44683212e-01f, 1.05160579e-01f, 1.02952711e-01f, -1.09619245e-01f,
  -2.03755304e-01f, 1.11285597e-01f, -7.10990056e-02f, -1.56634435e-01f, 2.80605286e-01f, 3.28166097e-01f, -1.43334679e-02f, -1.87932223e-01f, -1.23144069e-03f, -9.87551734e-02f,
  6.07847154e-01f, -1.23106308e-01f, 1.83744326e-01f, -7.57066831e-02f, -6.07388243e-02f, -1.30627573e-01f, -2.13022426e-01f, 4.21784163e-01f, 4.26198035e-01f, -2.22136244e-01f,
  -1.47446021e-01f, 1.31225795e-01f, 4.85753596e-01f, 5.68116784e-01f, -1.52648404e-01f, -1.80357203e-01f, 5.00570059e-01f, -3.71763855e-02f, 2.43736148e-01f, 8.17625374e-02f,
  -8.51866603e-02f, 5.55542447e-02f, -3.36759980e-03f, -1.73222184e-01f, -1.11571439e-01f, -1.56856328e-01f, -2.22036526e-01f, -2.45794997e-01f, -9.58940461e-02f, 1.22630075e-01f,
  -1.58199057e-01f, -2.97682852e-01f, -1.98569484e-02f, -3.26196074e-01f, -4.74137254e-03f, -1.46212593e-01f, 2.69223332e-01f, 3.51325363e-01f, 2.35159069e-01f, -6.00874305e-01f,
  2.98476905e-01f, -4.29042906e-01f, 2.97910888e-02f, 1.02180868e-01f, 2.24419549e-01f, 6.42674983e-01f, 3.73173863e-01f, -4.49078470e-01f, 1.16274118e-01f, 1.76773965e-02f,
  -2.08824202e-01f, 3.81734013e-03f, 1.20081104e-01f, -2.05616549e-01f, 4.92153056e-02f, 3.05896550e-01f, -8.05533677e-02f, -1.81236461e-01f, -1.42806664e-01f, -2.49708325e-01f,
  2.79992837e-02f, 6.33806735e-02f, 3.89259905e-01f, -2.58637786e-01f, -3.97411138e-02f, -2.10683748e-01f, 1.74472049e-01f, -1.18162651e-02f, -1.23430630e-02f, 3.07112306e-01f,
  4.09769006e-02f, -1.24386914e-01f, 7.05324888e-01f, 1.22782029e-02f, -2.89313644e-01f, 8.46154392e-02f, 3.27543169e-01f, -1.59312692e-02f, -2.70905793e-01f, 1.22349430e-02f,
  -2.05449194e-01f, 7.36111104e-02f, -8.57510790e-02f, 2.29223594e-01f, 2.02296540e-01f, 5.98561801e-02f, -8.59664306e-02f, -1.85602725e-01f, 5.60490787e-02f, -2.16963783e-01f,
  -9.17438567e-02f, 6.77653551e-01f, -2.99035668e-01f, -2.48768747e-01f, 4.88299847e-01f, -1.93656296e-01f, -2.19854802e-01f, -2.78045148e-01f, 1.30202360e-02f, -2.96538383e-01f,
  -1.81095198e-01f, -3.50668073e-01f, -6.20651431e-02f, 2.16546860e-02f, 1.22997813e-01f, 3.30032527e-01f, -7.08652809e-02f, 8.42943862e-02f, 5.53764626e-02f, -9.50159281e-02f,
  -7.50843361e-02f, -2.16023132e-01f, -8.34504813e-02f, 2.64660984e-01f, 7.74001122e-01f, -4.14254554e-02f, -1.01426773e-01f, -1.67629257e-01f, 1.84514746e-01f, -6.66363463e-02f,
  7.62935802e-02f, -2.08293587e-01f, -1.55375078e-01f, -1.39348745e-01f, 7.51434341e-02f, -1.89510316e-01f, 8.63243490e-02f, -1.56764120e-01f, -6.15633354e-02f, -2.44650558e-01f,
  -7.66163021e-02f, 3.87602323e-03f, 2.47912183e-02f, -3.97606529e-02f, -7.34141991e-02f, -1.32740453e-01f, -1.54803721e-02f, -1.85216576e-01f, -1.71276107e-01f, -1.72727555e-01f,
  -3.73703130e-02f, -3.68790776e-02f, 3.57319295e-01f, -8.45526233e-02f, -1.77223697e-01f, 3.21147829e-01f, 8.91980156e-02f, 1.74232960e-01f, -1.72623292e-01f, -1.85808957e-01f,
  5.10396846e-02f, -1.19270146e-01f, -9.17795002e-02f, 6.33254588e-01f, 1.54042244e-01f, -5.66987097e-02f, 2.31953606e-01f, -1.76125113e-02f, -2.48892270e-02f, -1.73286855e-01f,
  5.67501485e-01f, 2.14657299e-02f, -1.51269659e-01f, -1.45216584e-01f, -2.10310847e-01f, -1.68958470e-01f, -3.87415253e-02f, -7.31121525e-02f, 9.77634490e-02f, -2.42823452e-01f,
  -1.58683583e-01f, -2.81178385e-01f, 2.30720773e-01f, 3.45612139e-01f, -1.24498345e-01f, -1.07952341e-01f, -1.29925497e-02f, -1.03375509e-01f, -5.57776727e-02f, 1.49453795e-02f,
  -2.43669190e-03f, -1.25415176e-01f, 2.86755621e-01f, -4.11072485e-02f, 4.27544601e-02f, 3.19096267e-01f, 1.26450568e-01f, 1.94148809e-01f, -1.70854643e-01f, -1.25340223e-01f,
  1.53700728e-02f, 2.84538329e-01f, 2.04281226e-01f, 1.36842862e-01f, -1.10772669e-01f, 3.01685721e-01f, -1.94646269e-01f, 1.94530010e-01f, 2.16720086e-02f, -9.63784605e-02f,
  2.88660347e-01f, 3.00977737e-01f, 3.33968788e-01f, -1.79304313e-02f, -2.36512557e-01f, -8.60304311e-02f, -7.50912279e-02f, -2.17057511e-01f, -6.02388605e-02f, -5.25303818e-02f,
  2.24624090e-02f, -1.90461025e-01f, -5.49560599e-02f, -2.60218233e-01f, 4.27208462e-04f, 5.52680254e-01f, -2.79803097e-01f, 4.19810601e-03f, 3.63795131e-01f, -1.73051804e-01f,
  3.70132029e-01f, 7.40750134e-01f, -6.03390597e-02f, -2.33910337e-01f, -8.23917091e-02f, -1.16851039e-01f, 9.94527861e-02f, 3.58292580e-01f, -2.45487735e-01f, 3.41705203e-01f,
  -2.60744214e-01f, 2.11471111e-01f, 4.21680152e-01f, -3.44775349e-01f, 5.65390289e-01f, 6.23121765e-03f, -6.37700856e-01f, 5.26496410e-01f, 2.37425297e-01f, 1.12782270e-01f,
  1.03716090e-01f, -2.14974150e-01f, -1.17792033e-01f, -2.59818017e-01f, 7.62790293e-02f, -3.11792374e-01f, -2.64480501e-01f, 2.06905715e-02f, -5.38352877e-02f, -1.55499563e-01f,
  -2.75951862e-01f, -2.75346279e-01f, -4.97106239e-02f, -1.08710207e-01f, 1.52863383e-01f, -2.93866396e-01f, -3.71214926e-01f, -1.78306043e-01f, 6.01729035e-01f, 4.01334874e-02f,
  -3.11031908e-01f, -1.78842247e-01f, 3.19748670e-01f, -3.57986778e-01f, -4.65212345e-01f, -2.87587762e-01f, 2.38301396e-01f, -3.43901962e-01f, 4.44562197e-01f, 1.77850336e-01f,
  3.36823910e-01f, 3.30652624e-01f, -2.40033299e-01f, -1.43605784e-01f, -9.07015800e-02f, 3.41170281e-01f, -2.75246680e-01f, -8.81743282e-02f, -1.29115134e-01f, 7.22700357e-02f,
  3.10717851e-01f, 7.25922436e-02f, -1.21254191e-01f, -1.90689007e-03f, 3.98090124e-01f, -2.76900500e-01f, 1.82168931e-02f, -5.46711870e-02f, -1.82796225e-01f, 2.68308613e-02f,
  4.69214842e-02f, 4.53622371e-01f, 2.26604879e-01f, 1.64718151e-01f, -1.98377118e-01f, 4.39217240e-02f, -8.19300860e-02f, -4.23078053e-02f, -1.06231481e-01f, -5.29221356e-01f,
  6.33598566e-01f, -5.06521463e-01f, -8.18306953e-02f, -4.23171788e-01f, -8.00522789e-02f, 4.77231964e-02f, 2.81183980e-02f, -2.21578881e-01f, 1.20085232e-01f, -4.92536835e-02f,
  -2.48380780e-01f, 1.49460789e-02f, -2.16875210e-01f, 7.76160836e-01f, 7.05794245e-02f, 1.02714874e-01f, 6.50974885e-02f, 2.21020818e-01f, -2.55543411e-01f, -1.10872820e-01f,
  -1.05525650e-01f, 2.20563263e-01f, -1.84102952e-01f, 1.06725981e-03f, 2.40716003e-02f, 2.37342119e-01f, -1.48818120e-01f, -6.77603856e-02f, -1.85986444e-01f, -1.19990870e-01f,
  8.28514025e-02f, -2.09399164e-01f, -1.99485108e-01f, -5.28562069e-02f, -6.82565123e-02f, 5.48189133e-02f, -1.55527741e-01f, -3.18031758e-02f, 1.32676527e-01f, -1.58274755e-01f,
  4.74624127e-01f, 4.70144331e-01f, 1.32138118e-01f, -1.76135868e-01f, -5.11857793e-02f, 2.06055138e-02f, 2.83900108e-02f, -2.44511172e-01f, -2.35573679e-01f, -1.73482925e-01f,
  -1.06146216e-01f, 6.54682145e-02f, -2.64525060e-02f, 5.81737578e-01f, -2.96858191e-01f, 1.76411152e-01f, 5.96357137e-02f, 9.75781754e-02f, -1.33137822e-01f, 1.23878941e-01f,
  -3.97220492e-01f, 2.98393548e-01f, -9.36704427e-02f, 3.43937308e-01f, 4.44701642e-01f, 5.96843623e-02f, -2.18964651e-01f, -2.61746291e-02f, 3.47429723e-01f, 2.45370060e-01f,
  -1.19416647e-01f, -4.51215468e-02f, -2.06935242e-01f, -2.19117537e-01f, -5.64573705e-02f, 3.77661794e-01f, 5.55672705e-01f, 8.66328701e-02f, 5.87336183e-01f, 2.60820657e-01f,
  2.28139833e-01f, 5.45229316e-02f, -2.58185510e-02f, 6.42427504e-02f, 4.81787659e-02f, 1.57470033e-02f, 9.58892405e-02f, 2.61206269e-01f, 3.61495726e-02f, -7.83025473e-02f,
  5.06107748e-01f, 1.65418699e-01f, -1.69414729e-01f, 2.26287559e-01f, -1.37628585e-01f, 5.79235494e-01f, -1.46544546e-01f, 1.73475668e-01f, -9.57548916e-02f, -1.66739717e-01f,
  -2.93088228e-01f, -1.57514095e-01f, -1.45531341e-01f, -1.96636721e-01f, -1.79489315e-01f, -1.40577510e-01f, -2.13527441e-01f, -5.77887967e-02f, -1.47558600e-01f, -2.81100899e-01f,
  5.21388426e-02f, 3.28181595e-01f, -2.71302521e-01f, -1.31497368e-01f, -3.26852314e-02f, 1.10932082e-01f, -2.07127966e-02f, -1.64299592e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.18741838e-02f, -8.03739354e-02f, -1.58145234e-01f, -7.51531571e-02f, 2.24185005e-01f, -2.59319576e-03f, 1.15785383e-01f, -1.60384446e-01f, -1.79071680e-01f, 1.90191403e-01f,
  1.63286433e-01f, -4.52199765e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    