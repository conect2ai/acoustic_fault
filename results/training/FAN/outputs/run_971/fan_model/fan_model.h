/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.03391433e+00f, -1.54104456e-01f, -2.84827381e-01f, 6.05193317e-01f, -3.22220415e-01f, -3.27269256e-01f, -5.78830957e-01f, -7.50231966e-02f, 2.35345945e-01f, -5.82736954e-02f,
  -9.69975535e-03f, 2.68246889e-01f, 2.52720058e-01f, 1.02178909e-01f, -3.89479473e-02f, -2.70574629e-01f, -8.64261687e-02f, 3.70301068e-01f, -1.92543976e-02f, -4.26786959e-01f,
  -1.15224488e-01f, 2.27378428e-01f, 5.67371190e-01f, 5.57263233e-02f, -7.73416087e-02f, -6.30180165e-02f, -1.16701335e-01f, 8.80644470e-02f, -1.50126576e-01f, 3.98961127e-01f,
  -3.25771272e-02f, 6.19554259e-02f, -1.41927302e-01f, 6.31950274e-02f, -3.35404016e-02f, 1.16381682e-01f, -1.05515435e-01f, 9.03055370e-02f, -4.30739820e-02f, -3.48276831e-02f,
  3.76657434e-02f, -3.97182396e-03f, 7.59746730e-02f, -7.42845237e-02f, 4.31314064e-03f, -1.55118285e-02f, 8.53766277e-02f, 5.38065359e-02f, 3.08163259e-02f, -9.96976197e-02f,
  7.80590205e-03f, 4.26801108e-02f, 4.70708832e-02f, -1.98500633e-01f, -2.92949425e-03f, 7.57348090e-02f, -1.27721742e-01f, 4.00756225e-02f, -1.52961493e-01f, 4.65242863e-02f,
  -4.16511446e-02f, -6.81660417e-03f, -5.10817878e-02f, -4.51737382e-02f, -6.54829713e-03f, 1.78707633e-02f, 1.73352398e-02f, 1.63567495e-02f, -6.47986606e-02f, -2.20260192e-02f,
  -3.26994658e-02f, 2.88173323e-03f, -2.64245234e-02f, 2.77931131e-02f, 3.42712887e-02f, 6.02186024e-02f, 4.20216471e-02f, 5.15657011e-03f, -1.84312910e-02f, 2.65462301e-03f,
  6.65361285e-02f, -4.95893210e-02f, 6.70659095e-02f, -6.53644502e-02f, -5.72989322e-02f, 3.97235714e-02f, 4.47964109e-02f, -3.36132124e-02f, 5.43058552e-02f, -9.13538737e-04f,
  4.92049158e-02f, -4.97250743e-02f, 1.40916720e-01f, -3.63556971e-03f, -4.36363131e-04f, -3.31064872e-02f, 7.62831122e-02f, -4.95424606e-02f, 6.97381645e-02f, 3.85463089e-02f,
  -1.27218813e-02f, 5.75469621e-02f, -1.25443107e-02f, 1.79917552e-02f, -7.79960677e-02f, -1.51197892e-02f, -4.61105928e-02f, 2.51900963e-02f, -2.53412351e-02f, -3.42477560e-02f,
  3.78002226e-02f, -4.30747904e-02f, 7.85214379e-02f, -2.25239955e-02f, 4.08736616e-02f, 1.86686981e-02f, -2.44714189e-02f, -3.98051254e-02f, 1.33464206e-02f, -8.48519579e-02f,
  -6.91595852e-01f, -1.62846670e-01f, 2.11070672e-01f, -1.22544885e-01f, 2.65510917e-01f, 2.46413767e-01f, 9.04767737e-02f, 1.39309406e-01f, -2.98823044e-02f, -2.21929893e-01f,
  5.69584556e-02f, -9.46848989e-02f, -8.37964490e-02f, 3.43630053e-02f, 1.71597376e-02f, -1.18233390e-01f, 3.75465653e-03f, -6.55523036e-03f, 2.15108380e-01f, 2.99177349e-01f,
  1.40232518e-01f, -7.47355819e-02f, -1.81037873e-01f, 9.63795334e-02f, -1.61993444e-01f, -2.43474692e-01f, -1.78081065e-01f, -2.37631872e-01f, -7.04028681e-02f, -5.40015757e-01f,
  -3.66194725e-01f, 4.25864086e-02f, 1.01792224e-01f, -9.35522839e-02f, 3.05160135e-02f, -9.55250338e-02f, -7.18226358e-02f, -5.71348518e-02f, -4.66099530e-02f, -2.25256924e-02f,
  5.78025449e-03f, 5.88216744e-02f, -4.01337296e-02f, 5.91487959e-02f, 2.52940897e-02f, 7.08604231e-02f, 2.29199473e-02f, 4.44766097e-02f, -4.52511199e-03f, -2.97417422e-03f,
  1.74469389e-02f, 7.05777258e-02f, 1.32754281e-01f, 1.54286176e-01f, 1.78172231e-01f, 1.67698432e-02f, 1.24349780e-01f, 1.27118751e-01f, 7.01918602e-02f, -3.26925039e-01f,
  -5.31347804e-02f, -5.94834797e-02f, 4.62736152e-02f, -1.86368544e-02f, 1.28119187e-02f, -3.31084020e-02f, -1.20632052e-02f, -6.38897792e-02f, 3.26408222e-02f, -1.09921515e-01f,
  5.49833700e-02f, -2.72875931e-03f, -1.71610445e-03f, -3.16268392e-02f, -8.93643871e-03f, 1.75665971e-02f, 1.79752465e-02f, -7.99911544e-02f, 1.95567068e-02f, -4.99053113e-03f,
  7.80798942e-02f, 2.38662288e-02f, -8.90395138e-03f, -6.13932982e-02f, -1.12508610e-03f, 1.14424890e-02f, 4.01702477e-03f, 1.54095143e-02f, -2.94958819e-02f, 9.00504962e-02f,
  -1.85488701e-01f, 1.59530714e-01f, -2.10003316e-01f, 1.17898345e-01f, -2.53198389e-02f, 4.04275656e-02f, 1.97385289e-02f, 5.09003662e-02f, -1.44264065e-02f, -4.50877398e-02f,
  1.12879612e-01f, -8.01066682e-03f, -2.40894537e-02f, 3.47142592e-02f, -3.01093068e-02f, 6.10058382e-02f, -1.71415899e-02f, -1.01267949e-01f, 6.56584576e-02f, 2.48706248e-02f,
  2.18217149e-02f, -3.42136957e-02f, -1.75043687e-01f, -1.18989445e-01f, 2.26420606e-03f, -2.24913862e-02f, -1.16751797e-01f, -6.76846206e-02f, -1.77302025e-02f, -3.82277042e-01f,
  7.14553297e-01f, -4.72969353e-01f, -7.38787726e-02f, 1.75007164e-01f, -3.12133968e-01f, 9.51056629e-02f, 1.29013071e-02f, 1.44301936e-01f, -3.70550491e-02f, -1.37724206e-01f,
  -2.94832915e-01f, -7.42532834e-02f, -2.16857232e-02f, -4.99975458e-02f, 2.43678659e-01f, 2.25121863e-02f, 2.90049296e-02f, 4.86028075e-01f, 5.90369523e-01f, 2.08298460e-01f,
  -1.00547686e-01f, 2.43541747e-01f, 2.94216543e-01f, 1.78671956e-01f, -1.71911731e-01f, 2.43081041e-02f, -3.46418798e-01f, -6.99908137e-02f, -1.56696886e-01f, -1.91072479e-01f,
  -9.98238027e-02f, -1.27112359e-01f, 1.00683488e-01f, 4.60474230e-02f, -1.59760907e-01f, 1.82107221e-02f, -2.64407694e-02f, -7.68852010e-02f, -3.00567504e-02f, 1.12247951e-02f,
  -4.22952063e-02f, -1.33947637e-02f, 8.39128625e-03f, -1.73962917e-02f, 1.82229150e-02f, 1.82434879e-02f, 6.72656968e-02f, 1.06374092e-01f, 7.49237612e-02f, -1.21380158e-01f,
  -1.06401116e-01f, -5.82716800e-02f, 1.00137657e-02f, -8.09810590e-03f, 7.08597377e-02f, 5.87508343e-02f, -1.06697701e-01f, -5.31753562e-02f, 5.08641787e-02f, -6.42622262e-03f,
  1.92444548e-02f, -4.98176366e-02f, -7.23692030e-02f, 2.50003841e-02f, 3.38617042e-02f, -4.15627565e-03f, -2.11845487e-02f, 2.10865792e-02f, -2.12010625e-03f, 3.35460491e-02f,
  1.34410569e-03f, -1.11526595e-02f, 1.42968092e-02f, -3.34485155e-03f, -6.74577728e-02f, -2.67374516e-02f, 2.45528296e-02f, 3.05802952e-02f, -5.57843670e-02f, 5.23324823e-04f,
  7.13202953e-02f, 8.65892693e-02f, -1.84681620e-02f, 6.72160164e-02f, -1.45664131e-02f, 5.06484918e-02f, 2.32860353e-02f, -6.64488822e-02f, 4.66987118e-02f, -8.05469044e-03f,
  1.08567424e-01f, -7.16456538e-03f, 4.43908833e-02f, 9.01741832e-02f, 4.47741635e-02f, 1.87375210e-02f, -1.69390868e-02f, 4.21920456e-02f, -2.47788522e-02f, 1.05785333e-01f,
  5.03364531e-03f, 1.08046278e-01f, -2.65182573e-02f, -5.30416518e-03f, 9.66641232e-02f, 1.63588747e-02f, -2.52248514e-02f, 9.17788669e-02f, 2.40775887e-02f, -1.84470955e-02f,
  2.83174738e-02f, 2.32554704e-01f, 2.50530303e-01f, 9.48062837e-02f, 1.00528179e-02f, 1.79482192e-01f, 3.08614634e-02f, 5.54941855e-02f, 2.03007370e-01f, 1.86857551e-01f,
  -1.46440983e-01f, 2.11024195e-01f, 2.98570007e-01f, -1.76779568e-01f, 1.37165129e-01f, 3.05502921e-01f, 6.54099822e-01f, 5.73535673e-02f, -2.63380438e-01f, 2.29588538e-01f,
  -2.41599798e-01f, -4.25000221e-01f, -3.79984975e-01f, -2.46853441e-01f, 2.63893843e-01f, 4.92926687e-01f, 4.33074921e-01f, -6.82374686e-02f, -4.12487313e-02f, 1.07761689e-01f,
  5.62188588e-02f, -5.43610705e-03f, 5.41779445e-03f, -1.91382028e-03f, -8.88844579e-02f, -1.52023211e-01f, 1.20460108e-01f, -2.75495410e-01f, 1.03710823e-01f, -7.46789128e-02f,
  -4.96304296e-02f, -1.02020450e-01f, 6.88181818e-02f, -1.06186591e-01f, -2.68406216e-02f, 1.52139226e-02f, 3.14960815e-02f, -1.82382613e-02f, -1.55289043e-02f, 2.40677260e-02f,
  -1.21545710e-01f, -5.04267290e-02f, -3.31017300e-02f, 2.28183065e-02f, 4.06676903e-02f, 1.63708173e-03f, -3.92037742e-02f, -3.62614393e-02f, 7.61997029e-02f, -1.00065321e-02f,
  -3.35952565e-02f, -3.00384592e-02f, -4.47385386e-02f, 5.52754961e-02f, 5.17642573e-02f, -1.33250922e-01f, -6.76344931e-02f, -3.40233929e-02f, -8.50741565e-02f, 6.92986101e-02f,
  -4.84441814e-04f, -3.59940752e-02f, 3.80667783e-02f, -1.78385768e-02f, 2.57451739e-02f, -3.21583115e-02f, 4.25896719e-02f, 1.62089034e-03f, 3.48227769e-02f, 1.76692044e-03f,
  8.09742953e-04f, 3.84522304e-02f, 2.31926609e-02f, 3.30823548e-02f, -5.10783643e-02f, 5.08932956e-02f, -1.15264459e-02f, 3.48173827e-02f, -3.07396986e-02f, 7.18791261e-02f,
  -1.97765022e-03f, 2.91454177e-02f, -5.49559966e-02f, 2.03929506e-02f, -4.66039963e-02f, -1.09651573e-02f, -3.45240235e-02f, 6.86602993e-03f, 3.58356303e-03f, -1.60586629e-02f,
  -1.75182998e-01f, 4.11066525e-02f, -3.66637185e-02f, -1.89163082e-03f, 4.07845713e-02f, -7.75383264e-02f, -1.14925556e-01f, -8.62020999e-03f, -7.00903013e-02f, 1.36677232e-02f,
  -4.75585163e-02f, 1.60365310e-02f, 4.80683558e-02f, -4.31486294e-02f, 6.08643517e-02f, -2.89593954e-02f, 2.82974797e-03f, 4.97433543e-03f, 2.44178995e-02f, -2.48814542e-02f,
  1.30677698e-02f, 1.30367711e-01f, 6.99940696e-02f, -2.01000292e-02f, -4.79891263e-02f, -6.18476346e-02f, 7.03987479e-02f, -3.17123868e-02f, 8.16748589e-02f, 3.05510849e-01f,
  9.42139566e-01f, -4.54548061e-01f, 8.04347813e-01f, -9.45840180e-02f, -1.65173169e-02f, 1.40128225e-01f, -5.05457446e-02f, -1.13400981e-01f, -7.54757524e-02f, 9.03618261e-02f,
  -1.13896154e-01f, -3.78422797e-01f, -2.54511654e-01f, -1.65734649e-01f, -6.15463257e-02f, 1.02571793e-01f, 4.05222386e-01f, 4.68199998e-01f, 1.42969593e-01f, -2.91104674e-01f,
  -3.59959215e-01f, -7.00513832e-03f, 8.67277160e-02f, -7.20136799e-03f, -1.36328027e-01f, -2.36301973e-01f, 2.51199216e-01f, 2.00361341e-01f, 4.65088859e-02f, 2.52214938e-01f,
  3.02630335e-01f, 1.73954546e-01f, 2.45581917e-03f, -9.67123285e-02f, -4.66831811e-02f, 5.78308962e-02f, -3.74813825e-02f, 9.19179060e-03f, -1.42138496e-01f, 8.36017951e-02f,
  3.68775912e-02f, 1.84174757e-02f, 8.51212814e-03f, 5.20292390e-03f, 3.24732885e-02f, 9.44594443e-02f, 6.82974085e-02f, 1.97230667e-01f, 5.08067757e-02f, 5.29662333e-03f,
  -1.63040280e-01f, 1.12911060e-01f, 1.80151388e-01f, -3.29359609e-04f, 3.54973860e-02f, 4.13517207e-02f, 6.12842292e-03f, 6.41049966e-02f, 1.31484419e-01f, -5.29212095e-02f,
  4.75346670e-03f, -4.18850500e-03f, -2.92375986e-03f, 4.52350974e-02f, -3.13842446e-02f, 6.00656644e-02f, 2.00177524e-02f, -2.02667769e-02f, -4.37756144e-02f, 1.57687105e-02f,
  -5.49820513e-02f, 1.02507556e-02f, -1.98710412e-02f, 4.47145775e-02f, -4.36069928e-02f, 5.28421067e-02f, 4.45203148e-02f, -6.08974211e-02f, -2.05771457e-02f, 3.55465598e-02f,
  -6.33002445e-02f, 1.46571323e-02f, -8.79179500e-03f, -6.48781881e-02f, -3.33487540e-02f, 1.36962719e-02f, 4.87962700e-02f, -5.20286337e-02f, -4.73629087e-02f, 1.02394834e-01f,
  -2.75178492e-01f, 1.58347283e-02f, -5.09129930e-03f, -2.95151398e-02f, 1.06934451e-01f, -1.00221559e-01f, 3.13990191e-02f, -5.05269468e-02f, -1.68436319e-02f, -2.13615131e-02f,
  -6.14822544e-02f, -6.03878349e-02f, 5.98013625e-02f, -5.74612692e-02f, -6.21838868e-02f, -1.02663524e-01f, -5.88470176e-02f, -9.34461355e-02f, -6.05257377e-02f, 5.74157899e-03f,
  -3.04533541e-02f, -2.98030842e-02f, -4.23938222e-02f, -7.64224678e-02f, -6.98507950e-02f, -1.43801160e-02f, -6.91577718e-02f, -1.09069712e-01f, -9.21882165e-04f, -2.85067856e-01f,
  3.89749527e-01f, -5.10899901e-01f, -3.63781810e-01f, -1.18923925e-01f, -5.03620356e-02f, 1.03594959e-01f, -1.96255445e-01f, 5.78380339e-02f, 9.06531513e-02f, -2.65909672e-01f,
  -4.47484516e-02f, 1.31046429e-01f, -9.51199606e-02f, 1.19177252e-01f, 1.55298635e-01f, -3.12446833e-01f, -3.73969555e-01f, 1.17669053e-01f, 4.42280620e-01f, 2.79587179e-01f,
  -1.87552869e-02f, -1.84090510e-01f, 1.70487940e-01f, 1.20533682e-01f, -1.91625789e-01f, 1.19933300e-01f, -3.30237776e-01f, -6.11311793e-02f, 1.50431097e-01f, -4.86576438e-01f,
  -2.13304520e-01f, -1.90767378e-01f, 1.56124830e-01f, 1.07057407e-01f, -9.74051654e-02f, 3.89905982e-02f, 5.63679188e-02f, -6.72866479e-02f, 6.20517582e-02f, 2.95914407e-03f,
  -7.51518831e-02f, 6.69957250e-02f, 6.34022579e-02f, -4.52449769e-02f, -6.30913302e-02f, -8.30692705e-03f, -8.24177712e-02f, -2.28466447e-02f, -6.14080690e-02f, -2.54435651e-02f,
  -1.18227601e-01f, -7.86071494e-02f, -1.20760448e-01f, -5.68216443e-02f, 3.84472497e-02f, 1.12615399e-01f, -9.50857997e-02f, 4.58469987e-02f, 3.56340557e-02f, -1.87928185e-01f,
  1.28969261e-02f, -4.44417484e-02f, 4.15181480e-02f, 7.88200926e-03f, 6.40780851e-02f, -3.47151048e-02f, 2.10763682e-02f, -2.45996052e-03f, 1.16247386e-02f, -2.01269127e-02f,
  7.35227764e-02f, 1.24055361e-02f, -2.84474082e-02f, -5.87893575e-02f, -5.64937368e-02f, -4.47005779e-02f, -5.21027204e-03f, -2.24804264e-02f, -7.62675004e-03f, 2.42567714e-02f,
  7.21203163e-02f, 3.17937769e-02f, -5.27637228e-02f, -4.01092358e-02f, -7.54848309e-03f, -5.44871390e-03f, 8.50973278e-03f, 4.74040322e-02f, 4.55345511e-02f, 4.08496745e-02f,
  -1.07313938e-01f, 2.70368338e-01f, -1.31609634e-01f, 1.46535560e-02f, -5.24598472e-02f, 1.41319931e-02f, -1.12893924e-01f, 6.84837103e-02f, -2.13420913e-02f, -3.25421505e-02f,
  5.20297997e-02f, 9.01768915e-03f, -1.14064097e-01f, 4.25145440e-02f, 5.43972291e-02f, 7.25220144e-02f, 3.73574197e-02f, -1.18941087e-02f, 8.97857547e-02f, -6.49028867e-02f,
  3.37061547e-02f, 8.84919018e-02f, 1.12789422e-01f, 5.35955699e-03f, 1.17636304e-02f, 1.48380280e-01f, -5.88660426e-02f, 4.82125357e-02f, 1.88089296e-01f, -1.14469059e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.17916906e-01f, -9.51165259e-01f, 7.04122365e-01f, -1.76725566e-01f, 1.97426111e-01f, 2.11925477e-01f, 1.24771804e-01f, -3.11449826e-01f, -3.46013844e-01f, -2.91620672e-01f,
  -6.30568862e-02f, 4.21705931e-01f, 5.69774508e-01f, 3.48653048e-01f, 1.71720371e-01f, 4.07851666e-01f, 4.51553255e-01f, 6.50420070e-01f, 6.61602497e-01f, 2.20284060e-01f,
  3.20845991e-02f, -2.68936813e-01f, -4.81470615e-01f, 6.34703487e-02f, -1.08811960e-01f, 4.44097847e-01f, -1.17694819e-03f, -2.62588710e-01f, -1.79208145e-01f, 9.74263623e-03f,
  4.17771339e-01f, -6.29638016e-01f, 4.24951702e-01f, -1.31709859e-01f, -9.26238671e-02f, -2.11029053e-01f, 8.48706588e-02f, -1.47356331e-01f, -3.10657620e-01f, 7.91299716e-02f,
  -3.30363587e-02f, -1.58933371e-01f, 1.47892371e-01f, 8.57868642e-02f, -6.76888507e-03f, -1.62092581e-01f, -7.56535009e-02f, 5.15621305e-02f, 1.45028740e-01f, -8.57205689e-02f,
  -5.13858385e-02f, -1.15072861e-01f, 7.40740076e-02f, 1.35147035e-01f, -7.84845129e-02f, 1.63806394e-01f, -8.53083059e-02f, -1.01454392e-01f, 2.84872595e-02f, 1.49332453e-03f,
  -1.98697131e-02f, 2.90635884e-01f, 2.03538630e-02f, 2.25817580e-02f, 6.12527393e-02f, -2.54314346e-03f, 1.67707518e-01f, 8.13934579e-02f, 2.85890222e-01f, -8.17473307e-02f,
  -7.96540976e-02f, 8.38712677e-02f, -8.20691064e-02f, -4.43462841e-02f, 1.86895400e-01f, -8.72405916e-02f, -1.38979882e-01f, 5.58507144e-02f, -4.72059809e-02f, -5.93702421e-02f,
  -5.24703041e-02f, 3.11351959e-02f, -2.30696380e-01f, -3.01669352e-02f, -6.70615658e-02f, 5.34955002e-02f, 5.98461032e-02f, 4.03328910e-02f, 4.65029739e-02f, -2.29144432e-02f,
  -8.48719254e-02f, 1.46105990e-01f, 3.47819149e-01f, 1.65093556e-01f, -1.31485835e-01f, -4.66239810e-01f, 2.93151319e-01f, -2.37357449e-02f, -1.70911416e-01f, -7.45995902e-03f,
  -3.37517858e-01f, -4.03141864e-02f, -2.81699141e-03f, -1.72005430e-01f, -2.26186980e-02f, -7.94489384e-02f, -2.75148243e-01f, 9.11571085e-02f, -1.07398033e-01f, -3.54499757e-01f,
  -2.91934878e-01f, 6.87703639e-02f, 3.83383095e-01f, 2.93313026e-01f, -3.35651636e-02f, 5.01174748e-01f, 2.23680958e-01f, -4.17465456e-02f, 2.56884128e-01f, 8.21100399e-02f,
  -5.44745147e-01f, -3.29122454e-01f, 6.72989368e-01f, -1.73188224e-01f, -6.57685459e-01f, -7.53665149e-01f, -1.02725089e+00f, -3.93965036e-01f, -2.87371594e-02f, -2.97796011e-01f,
  -7.66548574e-01f, -2.06036404e-01f, 3.08294952e-01f, 4.68200684e-01f, 3.92591864e-01f, 3.60867530e-01f, 7.73067117e-01f, 9.97473598e-01f, 4.54681277e-01f, -2.46890008e-01f,
  -3.34672034e-02f, 2.34499589e-01f, 5.44249952e-01f, 5.79474986e-01f, 1.34357095e-01f, 1.49092153e-01f, 3.84348705e-02f, -1.16365470e-01f, 1.54194981e-01f, 1.27932882e+00f,
  5.63975535e-02f, -3.21609527e-01f, -8.72556195e-02f, 5.84376827e-02f, 5.04166521e-02f, -5.39701059e-02f, -1.26445398e-01f, 1.15142196e-01f, 4.10404895e-03f, 2.06381127e-01f,
  -9.45778713e-02f, 3.90805043e-02f, 5.70628121e-02f, 1.80747420e-01f, -3.31635773e-01f, -1.29852712e-01f, 2.18205214e-01f, 3.62350523e-01f, 2.08219811e-01f, -3.15805674e-01f,
  1.76811263e-01f, -2.51147002e-01f, -4.68851119e-01f, -2.71596581e-01f, -9.90475714e-02f, 4.20692027e-01f, -4.26988691e-01f, 1.93681438e-02f, -1.83756381e-01f, 2.47138023e-01f,
  3.46710160e-02f, 3.46190184e-02f, 4.84385230e-02f, 2.17271447e-02f, -2.28298511e-02f, 1.02487598e-02f, -4.78006341e-02f, -5.67853190e-02f, 2.11229682e-01f, -2.62844395e-02f,
  1.57558337e-01f, -2.41427556e-01f, 2.62086034e-01f, -1.41175225e-01f, 8.15628916e-02f, 4.70860824e-02f, -8.43730569e-02f, 2.18003660e-01f, -8.63356330e-03f, -6.04516193e-02f,
  9.03283730e-02f, 3.07188388e-02f, -7.04319179e-02f, 2.34102681e-01f, -8.60092416e-02f, 2.70948201e-01f, -1.06364548e-01f, -2.49881178e-01f, 2.28146575e-02f, -5.39862067e-02f,
  -7.19923317e-01f, 1.61917537e-01f, -1.28396392e-01f, 6.52215853e-02f, 9.76541359e-03f, -2.19308063e-01f, 1.32456675e-01f, 1.75779626e-01f, -3.21778566e-01f, -8.41366276e-02f,
  -3.90778512e-01f, -4.47579212e-02f, -2.01699272e-01f, 3.93436372e-01f, -1.15039293e-02f, -2.70990729e-01f, -2.05629766e-02f, -1.79092959e-01f, -8.47164989e-02f, -2.64791608e-01f,
  7.64109045e-02f, -4.32460606e-01f, -6.77479863e-01f, -3.40874672e-01f, -4.55546290e-01f, -4.39995348e-01f, -6.27790987e-02f, -4.30919230e-01f, -8.63299906e-01f, -6.64012134e-01f,
  -9.12478939e-02f, 3.17255527e-01f, -1.38363373e+00f, 8.66121233e-01f, 8.12634826e-01f, -1.90912634e-01f, -1.56705961e-01f, -2.11064264e-01f, 2.86128104e-01f, 2.16405779e-01f,
  -1.37601525e-01f, 4.25481237e-02f, -1.37848169e-01f, -2.90419042e-01f, -5.80825150e-01f, -2.74334010e-02f, 4.05326158e-01f, -4.33197200e-01f, -5.02567530e-01f, -1.86173886e-03f,
  8.11276674e-01f, 8.06618333e-01f, 2.81445384e-02f, -8.32416788e-02f, 5.61791420e-01f, 2.91603029e-01f, -1.90504357e-01f, 2.71707296e-01f, -2.55329221e-01f, 5.25412202e-01f,
  -8.10032189e-01f, -5.48306048e-01f, -1.46742314e-01f, 3.40956658e-01f, 5.21094017e-02f, -3.04742754e-01f, -4.98057976e-02f, -3.37302357e-01f, -4.23507318e-02f, -4.12957789e-03f,
  8.27817321e-02f, -5.98703846e-02f, 1.24082200e-01f, 6.71724454e-02f, -1.19176157e-01f, -1.20324120e-01f, -1.03158362e-01f, -6.45110309e-01f, -5.37322402e-01f, -4.71864969e-01f,
  7.85974920e-01f, 1.26347795e-01f, -4.60406780e-01f, -2.68911153e-01f, -6.11828148e-01f, -1.00853950e-01f, -3.13292414e-01f, -6.19803667e-01f, -1.01212585e+00f, -1.02870554e-01f,
  3.73709574e-02f, -2.69746147e-02f, -2.23412775e-02f, 3.31029110e-03f, 2.03241900e-01f, -2.73663662e-02f, -3.13020051e-02f, 9.83451605e-02f, 6.66870922e-02f, 8.87069926e-02f,
  -2.82594170e-02f, -8.69486704e-02f, 1.40071467e-01f, -1.84375525e-01f, 1.58124000e-01f, -5.76407984e-02f, 4.24713381e-02f, -8.92279446e-02f, -3.24385464e-02f, 1.93401296e-02f,
  6.51250482e-02f, -2.15066746e-02f, 5.66117056e-02f, -8.29530507e-02f, -8.28243122e-02f, -1.92395180e-01f, 6.65511787e-02f, -1.67266354e-01f, -1.13820722e-02f, 1.85734794e-01f,
  3.40366840e-01f, -2.95604110e-01f, 1.11995805e-02f, -1.59998462e-01f, 4.24496755e-02f, 5.37609048e-02f, 9.76766646e-02f, 1.55229315e-01f, -6.43994138e-02f, -6.63786978e-02f,
  -1.79505676e-01f, -9.68002230e-02f, 1.42409336e-02f, 2.10251674e-01f, -8.80983695e-02f, 6.57712743e-02f, 2.43569896e-01f, 1.84817091e-01f, 1.43428147e-01f, 3.18890139e-02f,
  1.94984242e-01f, 1.96335301e-01f, -3.47827226e-02f, 7.35714212e-02f, 2.19328389e-01f, -2.67502433e-03f, -1.52508169e-01f, 8.05881321e-02f, -3.86052638e-01f, 7.38677800e-01f,
  1.81507564e+00f, 1.05236769e+00f, 4.17042106e-01f, 3.40625167e-01f, 9.07359049e-02f, 2.56318718e-01f, 6.29607499e-01f, 3.49988043e-01f, -2.81358249e-02f, 2.94923723e-01f,
  3.85607302e-01f, 3.70585360e-02f, 1.50847614e-01f, -3.88713591e-02f, 2.74852663e-01f, 7.48354718e-02f, -1.15482770e-01f, 1.46037251e-01f, 5.90731315e-02f, 2.24412888e-01f,
  7.87152722e-02f, 9.08096582e-02f, 2.99472511e-01f, 1.00798242e-01f, 1.91630393e-01f, -1.23643830e-01f, 2.03510001e-02f, 2.57965595e-01f, 2.98823893e-01f, 1.51596338e-01f,
  2.77190745e-01f, 9.02956247e-01f, -4.51602697e-01f, -2.06608400e-01f, -1.91630915e-01f, -2.71380186e-01f, -1.04988843e-01f, -2.06063747e-01f, -1.32919922e-01f, -2.17748329e-01f,
  -1.52357638e-01f, 7.68249389e-03f, 2.21800730e-02f, -7.57087916e-02f, -1.37767941e-01f, -8.02934244e-02f, -1.12239473e-01f, 7.75632858e-02f, -8.22941866e-03f, 7.06991479e-02f,
  -3.79882902e-02f, 9.53241158e-03f, 4.93120551e-02f, -5.09718768e-02f, 7.91476443e-02f, -1.76519021e-01f, 4.80755828e-02f, 1.55846938e-01f, -9.09748152e-02f, 1.65812224e-01f,
  9.19162631e-02f, 2.48678908e-01f, 2.53580689e-01f, 3.74860652e-02f, 1.09671287e-01f, -6.71403483e-02f, -1.26095310e-01f, 6.50182515e-02f, 2.50564218e-01f, 9.06069651e-02f,
  -1.53849736e-01f, 1.10150643e-01f, -5.02411649e-02f, -4.05280758e-03f, -1.22087173e-01f, 1.29144281e-01f, -1.68008924e-01f, -1.26160279e-01f, 7.83103034e-02f, -1.06277056e-01f,
  1.55729979e-01f, -1.05476014e-01f, -4.98245880e-02f, -6.66542426e-02f, -7.52456114e-02f, 1.65589020e-01f, -2.50882320e-02f, -7.19099306e-03f, -5.29526286e-02f, 1.70286850e-03f,
  -9.55062807e-01f, 9.09065530e-02f, 1.02107279e-01f, 6.18133210e-02f, 7.37718493e-02f, -7.84834027e-02f, 1.93590984e-01f, -6.94110841e-02f, -2.21082598e-01f, -1.05431832e-01f,
  -5.08724265e-02f, 8.24392810e-02f, 1.33021280e-01f, 6.35440275e-02f, -1.26545653e-01f, -1.78873077e-01f, 8.32576826e-02f, -1.14090927e-02f, -5.69880120e-02f, -1.14195287e-01f,
  -1.40378416e-01f, -6.54772818e-02f, -2.75207043e-01f, -2.09589794e-01f, -8.52782130e-02f, -3.88269335e-01f, -1.58148423e-01f, -2.25287303e-01f, -2.53317982e-01f, -2.25510240e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.49804866e+00f, 6.74002349e-01f, 4.92480516e-01f, 5.90145230e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  1.09605193e+00f, -1.21733844e+00f, 1.35968935e+00f, -7.66802907e-01f, -1.13481438e+00f, -2.12497354e+00f, -1.01167977e+00f, 1.11449206e+00f, -6.34804487e-01f, -1.04644859e+00f,
  -9.95635152e-01f, 1.53891015e+00f, -9.21107292e-01f, -2.21805975e-01f, 4.08880264e-01f, -6.27914727e-01f, -3.08275610e-01f, 3.90697956e-01f, -5.99899948e-01f, -1.90738350e-01f,
  8.82511616e-01f, -1.37091315e+00f, 1.46905267e+00f, -4.41012502e-01f, 1.11860156e+00f, -1.23170233e+00f, -4.45242882e-01f, 1.08967674e+00f, 2.08114192e-01f, -8.67832422e-01f,
  -8.07767153e-01f, 6.58666968e-01f, -8.18075985e-02f, 1.85597315e-01f, 2.43584320e-01f, -5.61501123e-02f, -1.35390386e-01f, -1.76348127e-02f, 7.26748288e-01f, 6.24325097e-01f,
  3.97018582e-01f, -1.22196816e-01f, 1.15842688e+00f, 7.96750367e-01f, -4.65278596e-01f, 1.39981616e+00f, -1.29586017e+00f, -1.48978567e+00f, -2.54361749e+00f, -1.24511182e+00f,
  -1.29690433e+00f, 7.57518828e-01f, 4.78496760e-01f, 1.29999495e+00f, -5.76545596e-01f, 1.07292509e+00f, -8.69545817e-01f, 1.83824193e+00f, -1.31971133e+00f, 9.26375747e-01f,
  -3.72845232e-01f, 4.99547511e-01f, -1.30888772e+00f, -8.33798468e-01f, 1.87618506e+00f, 5.51495492e-01f, -1.61859298e+00f, -4.58041042e-01f, 8.39144230e-01f, 1.55365539e+00f,
  -5.89083433e-01f, 1.49731708e+00f, -1.12175632e+00f, -1.51939321e+00f, -8.12974274e-01f, -9.34703231e-01f, -3.28584343e-01f, 7.17910305e-02f, -2.66935498e-01f, -1.42022580e-01f,
  1.12353957e+00f, -1.70417577e-01f, 1.15424299e+00f, 9.03380215e-01f, -1.00430213e-01f, 1.60030532e+00f, 9.82291460e-01f, -1.33675563e+00f, 8.64074409e-01f, 9.92304504e-01f,
  -7.70555556e-01f, 7.36754000e-01f, -1.00371611e+00f, -1.90332937e+00f, 1.13448489e+00f, -2.68111020e-01f, -1.27766633e+00f, -7.69110858e-01f, 3.63294840e-01f, 1.00109196e+00f,
  -1.00560892e+00f, -5.97736597e-01f, 2.47464031e-01f, -9.42827880e-01f, 7.89897561e-01f, -1.29100740e-01f, 8.03303957e-01f, -8.64832401e-01f, -1.61051869e+00f, 8.40640783e-01f,
  -1.31647813e+00f, 3.11615378e-01f, -8.42600986e-02f, -5.36851168e-01f, -1.83210909e-01f, -9.79132593e-01f, -2.27019459e-01f, -9.29676175e-01f, -4.10395592e-01f, 3.55834305e-01f,
  -4.34463143e-01f, 8.37300301e-01f, -3.16492796e-01f, -4.40926760e-01f, 6.90736949e-01f, -1.06562786e-01f, 1.20440519e+00f, -2.75846392e-01f, 1.26853895e+00f, 9.44821954e-01f,
  -1.35510659e+00f, -1.04216564e+00f, -3.13900083e-01f, 7.65679777e-01f, -7.37174988e-01f, -5.59655905e-01f, 7.28580892e-01f, 1.36474657e+00f, 1.84886277e+00f, 7.01951385e-01f,
  3.97896022e-01f, -5.70595026e-01f, 6.12734675e-01f, -3.88324201e-01f, -6.45617425e-01f, -4.20134142e-02f, 1.98594570e-01f, -9.89824235e-01f, 1.06474495e+00f, 7.68885091e-02f,
  1.25239766e+00f, -1.27307451e+00f, -1.34762025e+00f, -1.42370903e+00f, 1.37715876e+00f, -1.05310440e+00f, -4.70424354e-01f, 3.22376907e-01f, 5.44267416e-01f, -1.37606263e-01f,
  -7.96092868e-01f, 6.99073613e-01f, 1.25102520e+00f, 5.86544216e-01f, -1.21597022e-01f, 7.62707889e-01f, -1.39069617e+00f, -1.20975780e+00f, 6.46717250e-02f, -1.23824246e-01f,
  -1.17846322e+00f, -1.25369251e+00f, 4.96750861e-01f, -7.29518473e-01f, -1.67109537e+00f, -1.35890198e+00f, 1.03465855e+00f, 7.12142169e-01f, 6.65101290e-01f, 2.29650274e-01f,
  -1.81232303e-01f, -2.98162699e-01f, -8.48356485e-02f, 2.61554211e-01f, 6.25434220e-02f, 1.27252460e+00f, 1.05854738e+00f, -1.18839431e+00f, -1.72787178e+00f, -1.12264097e+00f,
  -7.30587721e-01f, 8.28144550e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  8.53046715e-01f, 6.87085509e-01f, 5.46532460e-02f, -4.62789536e-02f, 3.48438680e-01f, 5.12364268e-01f, -6.94991648e-02f, -1.06801271e+00f, -2.33467221e-01f, -5.74305892e-01f,
  -9.26188707e-01f, 3.24872792e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    