/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.15715945e-01f, -3.33265543e-01f, 1.08402058e-01f, -3.72750252e-01f, 9.84768495e-02f, -9.00936127e-03f, 1.25645474e-01f, -2.29593426e-01f, -1.13161586e-01f, -2.94938385e-01f,
  -1.13939106e-01f, 2.40856819e-02f, -1.73015222e-02f, -4.48778003e-01f, 2.21855208e-01f, -8.24328288e-02f, -2.09750906e-01f, -1.55117676e-01f, -5.68305515e-02f, -5.38740978e-02f,
  -4.03293855e-02f, -2.86898941e-01f, -9.83550921e-02f, -6.70496300e-02f, -1.21604554e-01f, -1.15088299e-02f, -1.21329036e-02f, 1.64737284e-01f, -1.09506547e-01f, -1.24140400e-02f,
  3.00969556e-02f, -7.19918013e-02f, -1.99953467e-02f, 6.94510043e-02f, 7.47558773e-02f, -3.31336781e-02f, -2.87084673e-02f, 7.13876784e-02f, 3.80023569e-02f, -9.64419544e-03f,
  5.88994995e-02f, 1.02449656e-02f, -8.51943493e-02f, 3.30620185e-02f, 1.78762879e-02f, 3.82943312e-03f, 2.29754858e-02f, -1.74071975e-02f, -8.12587738e-02f, 3.98015343e-02f,
  2.29030587e-02f, -1.90639887e-02f, -1.73241943e-02f, 4.24029231e-02f, 5.69169484e-02f, -7.02983290e-02f, 2.19472162e-02f, 8.77479091e-02f, -3.52378003e-02f, -6.50179088e-02f,
  1.94717627e-02f, 5.27123222e-03f, -2.73105111e-02f, 1.23521527e-02f, -3.71835567e-02f, 3.73352249e-03f, -2.64570722e-03f, -5.19484244e-02f, 2.90386984e-03f, -2.46676654e-02f,
  -1.88670903e-02f, 3.96899559e-04f, -8.56055841e-02f, -1.78497620e-02f, -5.21556959e-02f, -6.32753819e-02f, 6.27830774e-02f, -5.20399399e-02f, 1.66347735e-02f, -1.74697451e-02f,
  -5.28537966e-02f, 9.40940590e-05f, -5.52099533e-02f, 1.17956400e-02f, -2.23973282e-02f, 2.99377069e-02f, -6.63115531e-02f, 7.85354525e-03f, -5.60147464e-02f, 3.96435075e-02f,
  -1.53769225e-01f, -5.54913729e-02f, -1.43327722e-02f, -2.84239892e-02f, -1.02906357e-02f, -1.78562030e-02f, -5.93371503e-02f, 3.45348679e-02f, 2.51532923e-02f, -6.61713956e-03f,
  3.17356661e-02f, -4.79656272e-03f, 6.02874793e-02f, -3.26438993e-02f, -1.25374808e-03f, -4.49340902e-02f, 4.94340956e-02f, 3.86253856e-02f, 6.54214702e-04f, -4.68534790e-03f,
  1.55144241e-02f, 7.59365037e-02f, -9.41758603e-03f, -2.57892795e-02f, -5.80765791e-02f, 8.82272050e-02f, -6.07326552e-02f, 6.47820458e-02f, 2.74643935e-02f, 1.22597329e-02f,
  5.56302130e-01f, -4.64354724e-01f, -1.54537305e-01f, 1.34820351e-02f, -6.62414581e-02f, -2.19034627e-01f, -5.04188128e-02f, -2.45254353e-01f, -1.88199967e-01f, -1.72096863e-01f,
  -2.51827165e-02f, 2.01833591e-01f, 1.22870621e-03f, -2.13638693e-01f, 3.23176831e-01f, -1.49076805e-02f, -2.46702299e-01f, -2.27959864e-02f, -1.09302752e-01f, -5.41714802e-02f,
  9.39903408e-02f, 3.42533402e-02f, 4.01609950e-02f, -2.02657834e-01f, -5.61441183e-02f, 3.40235122e-02f, 8.30831304e-02f, 2.96377018e-02f, -1.01853535e-01f, 5.61404489e-02f,
  8.48391727e-02f, 7.36727342e-02f, -8.16251785e-02f, -7.04060718e-02f, -2.40314007e-02f, -5.92382334e-04f, -1.25223575e-02f, 1.20502792e-01f, 9.26835909e-02f, -9.40259248e-02f,
  -2.80708857e-02f, 6.68125898e-02f, -8.58435705e-02f, 3.86655331e-02f, -7.42032379e-02f, -3.36658768e-02f, 4.60375324e-02f, -4.20563556e-02f, -4.38796766e-02f, 9.53106210e-03f,
  -6.54500797e-02f, -4.27863263e-02f, -7.59780183e-02f, -2.19326913e-02f, 4.21653613e-02f, -6.75478205e-02f, 3.86713408e-02f, 7.80121982e-02f, 3.98605625e-04f, -3.02572958e-02f,
  -1.08633069e-02f, 5.29157184e-02f, 3.41457017e-02f, 4.24022367e-03f, 1.00888098e-02f, 8.90855789e-02f, -1.16632488e-02f, 6.52429909e-02f, 2.01005787e-02f, 1.92511212e-02f,
  -7.04730228e-02f, 4.05475264e-03f, -3.83277312e-02f, 1.02390023e-02f, -1.76406298e-02f, -1.97551176e-02f, 5.97798191e-02f, 1.35585777e-02f, -7.03457184e-03f, 3.73200886e-02f,
  2.58828476e-02f, -5.54100163e-02f, -2.03218553e-02f, -1.72775006e-03f, 1.59951504e-02f, 2.08358690e-02f, -4.37222198e-02f, -9.05591249e-02f, 4.48830649e-02f, 8.56807679e-02f,
  -8.52102935e-02f, 1.26601949e-01f, -3.93131860e-02f, 1.70353297e-02f, 2.76570618e-02f, -4.79238890e-02f, 2.87678540e-02f, -5.93758672e-02f, -7.15772063e-02f, 7.82774761e-02f,
  -6.31404817e-02f, -2.54805461e-02f, 6.72658682e-02f, -1.68728791e-02f, 8.51057768e-02f, -4.48870733e-02f, -5.22355502e-03f, -2.37678699e-02f, 6.48998469e-03f, -1.86414886e-02f,
  5.32220304e-02f, 3.48080359e-02f, 6.38665110e-02f, 2.34452840e-02f, -5.03158793e-02f, 5.56061566e-02f, -2.57354137e-02f, -6.08447231e-02f, 3.99533547e-02f, -3.27154137e-02f,
  1.53247878e-01f, 2.37536617e-02f, 3.70353729e-01f, 7.00991526e-02f, -1.40120462e-01f, 1.07062653e-01f, 3.44907135e-01f, -1.94754288e-01f, 2.53313422e-01f, -1.89284861e-01f,
  -1.85667381e-01f, 1.13137253e-01f, 2.39956498e-01f, -1.54229954e-01f, 1.75531119e-01f, 1.86905116e-01f, -8.54761451e-02f, 6.08322956e-02f, 1.44936934e-01f, -1.46497175e-01f,
  7.53830001e-02f, -2.75289863e-01f, 1.66176423e-01f, -2.96379000e-01f, -4.26100343e-02f, -1.48293432e-02f, -3.72999698e-01f, 9.28866118e-02f, -3.21200401e-01f, -3.38869588e-03f,
  -7.99258333e-03f, 3.59168462e-02f, -2.90593300e-02f, 1.85300987e-02f, -3.18857208e-02f, -8.01475719e-02f, 1.90358460e-02f, 5.22451885e-02f, 2.73558833e-02f, 7.21435174e-02f,
  2.02061683e-02f, -5.88416904e-02f, -2.13902462e-02f, 1.79652274e-02f, 1.26380557e-02f, -2.73037851e-02f, 1.72614418e-02f, -3.03090196e-02f, 1.07753603e-02f, 4.69158590e-02f,
  1.30817354e-01f, -1.75760090e-02f, 4.24435697e-02f, 3.98456817e-03f, 3.44596170e-02f, 6.87876418e-02f, -7.83936121e-03f, -3.05716973e-02f, 1.69936959e-02f, 2.09995136e-02f,
  -2.51750890e-02f, -1.42523721e-02f, 1.49945514e-02f, -6.95847422e-02f, 3.01819295e-02f, -8.53722095e-02f, -1.22303478e-02f, -7.22537786e-02f, 2.68005412e-02f, -2.13185810e-02f,
  -7.61508569e-02f, -1.89116667e-03f, -3.60716321e-02f, -1.63160004e-02f, 8.52916576e-03f, 1.95845077e-03f, -1.55361937e-02f, -2.19868608e-02f, -6.17803447e-03f, -2.14336882e-03f,
  7.67990276e-02f, 2.22765375e-02f, 3.03202402e-02f, -3.35551687e-02f, 3.97003219e-02f, 2.01403499e-02f, -6.96750283e-02f, 2.90235821e-02f, 2.42098402e-02f, 3.67779750e-03f,
  3.70228551e-02f, -1.48449838e-01f, 6.73615048e-03f, 2.00394467e-02f, -2.48472253e-03f, -5.07223867e-02f, 6.47792071e-02f, -1.13083780e-01f, -3.66223231e-02f, 2.07850942e-03f,
  -4.05011699e-02f, -3.19809504e-02f, -2.75078285e-02f, -1.85908582e-02f, -5.15222456e-03f, 9.42397863e-03f, 1.60479918e-02f, -4.35241796e-02f, -1.90803595e-02f, -9.01447311e-02f,
  -5.31384833e-02f, 1.45835029e-02f, 3.57907154e-02f, -2.76652332e-02f, -1.13830611e-01f, -2.68383604e-02f, -2.78481729e-02f, 8.57454315e-02f, -2.91108396e-02f, 1.90054215e-02f,
  -2.84390509e-01f, 4.39047366e-01f, -6.05295300e-02f, 1.21785000e-01f, -3.14550638e-01f, -2.51996249e-01f, -1.91403538e-01f, -3.16975378e-02f, 1.11383416e-01f, 1.25705346e-01f,
  -8.22219327e-02f, -4.29707579e-04f, -1.54195791e-02f, 5.39922081e-02f, -6.79477602e-02f, 2.81237900e-01f, 3.91151104e-03f, -1.57481223e-01f, 1.98605403e-01f, -1.50784403e-01f,
  -5.17130010e-02f, 6.16858304e-02f, -1.54672777e-02f, -5.44157717e-03f, -1.20870862e-02f, -1.08798981e-01f, -3.62898670e-02f, -6.49903715e-02f, -1.76152378e-01f, -1.04550935e-01f,
  1.17950246e-01f, 1.56175131e-02f, -9.36811492e-02f, 1.01063866e-02f, -7.28297010e-02f, -1.19134337e-01f, -1.14062034e-01f, -1.29898131e-01f, -1.07910931e-01f, 2.13916637e-02f,
  -3.69353518e-02f, -7.65503496e-02f, -8.93356204e-02f, -9.42486338e-03f, -6.67672753e-02f, -4.90574539e-02f, 2.08944380e-02f, 1.33226827e-01f, 3.08947638e-02f, -1.56828593e-02f,
  -1.24304462e-02f, -1.54195288e-02f, -3.29641718e-03f, 9.35236886e-02f, -2.88779587e-02f, 4.83237207e-02f, -7.10498095e-02f, -7.55058452e-02f, 4.98248190e-02f, -4.80508357e-02f,
  -3.23291905e-02f, 2.30094492e-02f, -1.27980709e-02f, 1.72717217e-02f, 4.14690860e-02f, 2.80503836e-02f, 7.72685781e-02f, -1.82969403e-02f, 2.22418960e-02f, -1.61283202e-02f,
  -1.18678799e-02f, -8.64108093e-03f, 3.64672765e-02f, -4.84970063e-02f, -4.64276485e-02f, -6.55594608e-03f, -4.58907187e-02f, -7.20365793e-02f, 6.58754213e-03f, -2.02108975e-02f,
  4.93904352e-02f, 4.87835594e-02f, -7.54630938e-02f, 5.02467006e-02f, 6.06468357e-02f, -5.24735749e-02f, 1.37270689e-02f, -1.66676138e-02f, -4.40506265e-03f, -7.49937147e-02f,
  -4.33028452e-02f, 4.16731164e-02f, 7.16470405e-02f, -2.66800467e-02f, 8.29947218e-02f, -6.34475574e-02f, 1.42820165e-01f, 1.21022277e-02f, 3.96087281e-02f, 5.13910875e-02f,
  -1.59171835e-01f, -4.23594698e-04f, 4.87945005e-02f, 6.39347872e-03f, -3.95539366e-02f, -5.47992587e-02f, 6.83145970e-02f, -3.93771902e-02f, -6.78235386e-03f, -5.52934743e-02f,
  -1.94379743e-02f, -3.74524249e-03f, -1.18858097e-02f, 2.47501116e-03f, -1.18954644e-01f, 1.34607870e-02f, -5.86715862e-02f, -7.82340672e-03f, -5.17906472e-02f, 4.47831443e-03f,
  4.91642565e-01f, 3.51769358e-01f, 6.38870820e-02f, 1.48898184e-01f, 8.47201273e-02f, 1.59161329e-01f, -9.81475711e-02f, 2.36377493e-01f, 1.44473284e-01f, 9.94602591e-02f,
  -1.35202259e-02f, 1.25485629e-01f, 3.02332938e-02f, -1.72828510e-03f, -5.21599911e-02f, -2.84845196e-02f, 8.47595930e-02f, 2.07244735e-02f, 8.49329587e-03f, 6.53550923e-02f,
  8.04053098e-02f, -1.96238440e-02f, -1.03269592e-01f, -1.49858429e-03f, -2.58131362e-02f, 8.47845972e-02f, -8.73643085e-02f, -5.11235073e-02f, 4.99679632e-02f, -1.07218497e-01f,
  4.71354760e-02f, 5.89656308e-02f, 1.89660173e-02f, 2.70377146e-03f, 8.22494105e-02f, -3.52970921e-02f, -7.86526222e-03f, -9.89459753e-02f, -6.26696870e-02f, 5.21858893e-02f,
  -1.39993876e-02f, 1.80837978e-02f, -4.19949070e-02f, -3.96827683e-02f, -2.61800662e-02f, 8.59041810e-02f, 2.96087265e-02f, 3.57126258e-02f, 2.83499230e-02f, -6.41789734e-02f,
  8.78165513e-02f, 3.24634537e-02f, 7.12917559e-03f, 1.27188666e-02f, 1.37340594e-02f, 3.27320024e-02f, 9.71974991e-03f, -1.87015291e-02f, 7.64580965e-02f, 8.15659016e-02f,
  -2.50679278e-03f, -1.49921449e-02f, -3.38851591e-03f, -2.75186785e-02f, -1.09933494e-02f, -7.32165501e-02f, -2.13970859e-02f, -3.94857749e-02f, -5.61118461e-02f, 6.55081123e-02f,
  6.80689663e-02f, 1.38823222e-03f, 2.62776129e-02f, 7.24494224e-03f, -4.74258438e-02f, 1.57866906e-02f, 1.49840657e-02f, 4.14727479e-02f, 2.27937084e-02f, -3.77780907e-02f,
  -7.70495785e-03f, 2.90163197e-02f, 2.54880860e-02f, -1.02087809e-02f, -2.35448033e-02f, 1.35778794e-02f, 3.31797227e-02f, 3.48502472e-02f, -1.79977212e-02f, -3.51140052e-02f,
  2.99040109e-01f, 2.89479733e-01f, -3.95047255e-02f, -9.98531841e-03f, -1.88252535e-02f, 4.25811708e-02f, -5.17683178e-02f, 5.63608892e-02f, 2.83197523e-03f, 1.55362198e-02f,
  4.16275375e-02f, -4.51365300e-02f, 4.05755080e-02f, 1.75579209e-02f, -2.20624134e-02f, -6.90549787e-04f, -1.37069905e-02f, -2.97309142e-02f, 2.35912632e-02f, 3.99632268e-02f,
  6.29698439e-03f, 2.80358153e-03f, -5.66561557e-02f, 4.34326977e-02f, -6.53835610e-02f, 2.38050707e-02f, 6.79305242e-03f, -2.82686818e-02f, -2.46125534e-02f, -2.91399863e-02f,
  2.71405876e-01f, -4.60933298e-02f, -3.59991603e-02f, -3.36727686e-02f, 2.09495723e-01f, 2.21527088e-03f, -1.40487999e-01f, 1.62248015e-01f, 3.92569341e-02f, -2.40451664e-01f,
  -8.76177624e-02f, -1.88452929e-01f, -2.30308011e-01f, -5.68943955e-02f, -8.37777406e-02f, -8.71451348e-02f, 8.41279030e-02f, -3.21868025e-02f, 1.43313900e-01f, 1.44744426e-01f,
  8.96322727e-02f, 1.63452461e-01f, -5.11140516e-03f, 1.55359149e-01f, 1.35206074e-01f, 1.07462138e-01f, -1.28777906e-01f, -3.26142721e-02f, -6.10940978e-02f, -7.84097835e-02f,
  1.40375659e-01f, 8.54645893e-02f, 3.91264446e-02f, -3.56503539e-02f, 1.05859809e-01f, 8.15085694e-03f, -7.65194371e-02f, -3.89417000e-02f, 9.21241269e-02f, 1.37123130e-02f,
  -8.54644626e-02f, -1.31498221e-02f, 4.44169119e-02f, -4.07879893e-03f, 1.36086969e-02f, 2.71498170e-02f, -5.44889309e-02f, 9.02638808e-02f, -4.46135215e-02f, -4.33292650e-02f,
  -5.57593293e-02f, -3.36191505e-02f, 8.00090656e-03f, 2.17875075e-02f, -6.52432963e-02f, 9.87978303e-04f, -1.52484281e-02f, -4.09210213e-02f, 2.45206654e-02f, 2.14247196e-03f,
  -3.78529392e-02f, -4.68593240e-02f, 1.77592486e-02f, 5.07127047e-02f, 2.95918137e-02f, 1.97321735e-02f, 5.16001433e-02f, -9.08568576e-02f, 2.15415899e-02f, -8.69261250e-02f,
  6.19886182e-02f, -9.35586691e-02f, 5.35165966e-02f, -4.06840108e-02f, 1.59410294e-02f, -5.91115914e-02f, 8.15001782e-03f, -7.00125545e-02f, 1.25886109e-02f, -9.37342830e-03f,
  -5.61179183e-02f, 2.94968486e-03f, -7.57156163e-02f, -4.33648117e-02f, 5.89546375e-03f, -1.14533290e-01f, -7.63212666e-02f, 2.11128462e-02f, 9.34462622e-03f, -2.67829131e-02f,
  -4.50363802e-03f, -4.67757583e-02f, 7.71644488e-02f, 1.43263647e-02f, -6.01135232e-02f, 3.83667983e-02f, 3.83297578e-02f, 3.44295464e-02f, -1.27674505e-01f, 7.88609758e-02f,
  1.30656397e-03f, -1.08859539e-02f, 1.60032324e-02f, -1.17609669e-02f, -8.62081498e-02f, -3.51835303e-02f, -3.81066538e-02f, 6.26202498e-04f, 1.04458174e-02f, -3.38994293e-03f,
  4.91554849e-03f, 1.53077208e-02f, 3.75406370e-02f, 1.01880133e-01f, -6.53707469e-03f, -6.17538057e-02f, 3.31802890e-02f, -2.41734385e-02f, -2.11840011e-02f, -7.61435106e-02f,
  2.32380882e-01f, 2.13541627e-01f, -1.37730435e-01f, 8.91387612e-02f, -1.49151921e-01f, 1.70081988e-01f, 5.52151129e-02f, -1.21636242e-01f, -1.81683525e-01f, 2.97925234e-01f,
  1.50707111e-01f, -1.38993170e-02f, 3.62176970e-02f, 1.32280216e-01f, 8.58575851e-02f, 1.25534907e-02f, 1.93979338e-01f, 6.55031856e-03f, -9.84045640e-02f, 1.44263273e-02f,
  4.70347237e-03f, 1.16514228e-01f, -1.13014681e-02f, 1.26884393e-02f, 3.80986184e-02f, -6.51298016e-02f, 2.29751304e-01f, -2.57702991e-02f, 1.39142856e-01f, -1.95625238e-02f,
  -2.65786424e-02f, -1.05316699e-01f, 1.06678672e-01f, -3.53112444e-02f, 1.04570940e-01f, 1.77273992e-02f, -3.19029316e-02f, -1.08707748e-01f, 2.98519339e-02f, -1.10126920e-01f,
  2.86543574e-02f, -4.56522144e-02f, -4.89879511e-02f, -5.11453375e-02f, -7.40026012e-02f, -8.13038147e-04f, -6.24042042e-02f, 4.84631248e-02f, 1.32866884e-02f, -8.63213241e-02f,
  -7.30043054e-02f, -3.91894206e-02f, 8.41227174e-02f, -2.17098966e-02f, 3.26340948e-03f, -3.71049754e-02f, 1.94916036e-02f, -3.96642685e-02f, 8.36153105e-02f, 9.24294665e-02f,
  -1.45674169e-01f, -1.54801356e-02f, 8.70368909e-03f, -5.03394082e-02f, 4.83661033e-02f, 5.14865108e-02f, 4.24921550e-02f, -2.75231693e-02f, 2.15625837e-02f, 5.82702318e-03f,
  7.75286853e-02f, -3.30780856e-02f, -7.07943439e-02f, 3.10634989e-02f, 3.88331115e-02f, -1.22767454e-02f, 5.52813821e-02f, -4.47029509e-02f, 9.06138346e-02f, -9.54530481e-03f,
  -3.34815384e-04f, 5.04944436e-02f, -3.34519264e-03f, -4.15968103e-03f, -3.92655097e-02f, -2.24188715e-02f, -3.93385254e-02f, -3.36111244e-03f, -4.39545773e-02f, 5.99217564e-02f,
  2.89743096e-01f, 4.39830832e-02f, 7.01192617e-02f, 1.40507994e-02f, 4.56210300e-02f, -3.33407037e-02f, -9.74938422e-02f, 1.07153989e-02f, 4.05936651e-02f, -2.27359552e-02f,
  3.09512187e-02f, 7.23260343e-02f, 4.77418117e-02f, -3.92613299e-02f, 1.08583290e-02f, 4.97589856e-02f, 7.71714002e-02f, 7.59885982e-02f, 7.09572434e-02f, -8.31044093e-03f,
  1.97734348e-02f, 4.20407243e-02f, -5.11059202e-02f, 4.55245562e-02f, -7.23167276e-03f, 1.36066169e-01f, -2.58938167e-02f, 4.65606675e-02f, -6.96299151e-02f, 2.28720353e-04f,
  5.84667623e-01f, -2.30656892e-01f, 2.72906311e-02f, 3.22896332e-01f, 2.76721954e-01f, 1.02495693e-01f, 1.73906744e-01f, 1.07660733e-01f, 1.63371980e-01f, -1.40337870e-01f,
  -3.85044441e-02f, 4.92335809e-03f, -2.35161990e-01f, 2.18619891e-02f, 2.35952735e-01f, -2.60264367e-01f, 9.39510912e-02f, 2.81090531e-02f, -5.38686775e-02f, 1.49897486e-01f,
  1.19524129e-01f, 6.99399561e-02f, -1.58571839e-01f, -1.56839252e-01f, 1.11322656e-01f, -1.83120108e-04f, 8.66600573e-02f, -8.40305239e-02f, 3.50123364e-03f, 7.33570307e-02f,
  -3.73968519e-02f, -8.52021128e-02f, 1.43538509e-02f, -1.12523369e-01f, 5.52269667e-02f, -2.29872577e-03f, 2.31053550e-02f, -3.12857553e-02f, -9.37537663e-03f, 1.97033901e-02f,
  6.40164837e-02f, 1.19988229e-02f, 2.20086835e-02f, -1.15645770e-02f, 9.09216627e-02f, 5.54004684e-04f, 2.69387886e-02f, -6.21584477e-04f, 2.76630204e-02f, -3.22782695e-02f,
  -5.15461974e-02f, -7.87054934e-03f, 9.36088860e-02f, 1.99671574e-02f, 6.42484352e-02f, 2.86804643e-02f, -2.05955338e-02f, -1.49204880e-02f, 7.89645128e-04f, 3.76893952e-02f,
  3.08944192e-02f, 2.92484113e-03f, -2.51500905e-02f, -5.96637130e-02f, 3.10904682e-02f, 1.46516776e-02f, 5.81756085e-02f, -2.37289835e-02f, 7.02400953e-02f, 7.03345519e-03f,
  1.50741618e-02f, 3.21286954e-02f, -1.83118507e-02f, 8.02865718e-03f, 3.84754911e-02f, 6.01180270e-02f, -3.38659957e-02f, 4.27218853e-03f, -1.92988738e-02f, 3.02343015e-02f,
  -5.20065166e-02f, 7.44320899e-02f, 5.60962595e-03f, 6.02556691e-02f, -3.15851010e-02f, 2.61723138e-02f, -4.57093958e-03f, -2.32993215e-02f, 4.76098396e-02f, 8.19750577e-02f,
  3.84511650e-02f, 1.47047728e-01f, -3.63403484e-02f, 1.07555585e-02f, -5.85153773e-02f, -5.71152642e-02f, 7.24580511e-02f, -1.03854444e-02f, 2.37797573e-02f, 3.47373448e-02f,
  -7.17826933e-02f, 3.72499526e-02f, 2.84306593e-02f, 3.27669606e-02f, -3.43900621e-02f, 1.23585286e-02f, 2.09519453e-02f, -1.24738486e-02f, 4.59180810e-02f, 2.88575012e-02f,
  2.16351580e-02f, 2.57200059e-02f, -2.27645002e-02f, -1.78506654e-02f, -8.09368677e-03f, 2.30466556e-02f, 8.01118016e-02f, -4.94248234e-02f, 3.45421657e-02f, -5.69441877e-02f,
  -4.22333419e-01f, 3.79015356e-01f, 2.34790996e-01f, -1.42456079e-03f, -9.66643021e-02f, 2.95121461e-01f, 2.60471970e-01f, 2.55350899e-02f, -4.98700738e-02f, 1.44372165e-01f,
  8.59550908e-02f, -5.67762367e-03f, 1.83789998e-01f, 9.27921981e-02f, 4.85993214e-02f, 1.45597875e-01f, -5.88954538e-02f, 6.50221929e-02f, 1.30857120e-03f, 5.49536608e-02f,
  -6.04052506e-02f, 6.84247762e-02f, 1.60651281e-01f, 6.31127581e-02f, 2.98325550e-02f, 6.60191923e-02f, -1.33510664e-01f, 1.32989228e-01f, 7.08537474e-02f, 6.21188730e-02f,
  7.99256042e-02f, 1.39437661e-01f, -6.93833604e-02f, 1.00775510e-02f, 4.88702953e-02f, 3.45384516e-02f, -4.81008515e-02f, 4.38606814e-02f, 5.08488948e-03f, 4.71574813e-03f,
  4.63935882e-02f, 5.25950938e-02f, -1.62831638e-02f, 2.31513456e-02f, 5.08298958e-03f, 3.83546837e-02f, -1.57297049e-02f, 1.70778576e-02f, 4.00758870e-02f, 4.63950709e-02f,
  1.09754041e-01f, 7.45527297e-02f, -1.31562045e-02f, 6.61676377e-02f, 2.12659612e-02f, -8.29913467e-03f, 6.56325370e-02f, 6.94074780e-02f, -4.43072505e-02f, -2.14587599e-02f,
  3.03635071e-03f, 4.33784276e-02f, 2.14865059e-02f, -3.06049176e-02f, 4.93635125e-02f, -4.32003513e-02f, 7.14954734e-02f, -1.39660183e-02f, -6.19311351e-03f, 3.36582661e-02f,
  -6.30224645e-02f, -1.10757528e-02f, -7.45927617e-02f, -1.74127426e-02f, -1.83968712e-02f, -3.42167020e-02f, -5.21772308e-04f, -4.64023985e-02f, -3.95169742e-02f, 4.81883949e-03f,
  -6.08039238e-02f, -1.48248216e-02f, 4.42635901e-02f, -4.47111875e-02f, -5.00547048e-03f, -6.45451527e-03f, -7.71054905e-03f, 6.64124936e-02f, 5.01888804e-02f, 7.43171796e-02f,
  1.13351926e-01f, 2.59881765e-02f, 3.62288244e-02f, -8.62689409e-03f, -3.20689082e-02f, -1.35343909e-01f, 3.00973207e-02f, 7.86516536e-03f, 3.30438837e-02f, 6.60411939e-02f,
  -5.70146851e-02f, -6.96045682e-02f, 1.87716614e-02f, -4.37411778e-02f, 2.69557331e-02f, -3.98776941e-02f, 2.33133193e-02f, -2.31388723e-03f, -7.74923190e-02f, -3.69696831e-03f,
  -3.15396860e-02f, -2.37141587e-02f, 2.03664135e-02f, 9.22742579e-03f, -3.29976678e-02f, -3.02970372e-02f, -6.17060997e-02f, -9.47461184e-03f, 3.71686220e-02f, -4.32731882e-02f,
  -1.08797975e-01f, -1.17082752e-01f, -1.23773567e-01f, 3.89493965e-02f, -3.64555717e-02f, 1.35399073e-01f, 4.10503328e-01f, -1.25345588e-01f, -3.16396177e-01f, 1.14894129e-01f,
  2.30669335e-01f, -2.83217081e-03f, 1.73215374e-01f, 2.37094060e-01f, 1.54999226e-01f, 1.17710941e-01f, 1.59128010e-01f, 7.38869905e-02f, -7.68492073e-02f, -7.53166527e-02f,
  -6.96910322e-02f, 2.32504457e-01f, 2.28418753e-01f, -4.88926545e-02f, 6.33435184e-03f, -1.29187897e-01f, 2.01139927e-01f, -2.19441783e-02f, 1.41848773e-01f, 1.63533092e-01f,
  1.76812321e-01f, -1.41009495e-01f, 1.30407698e-02f, -1.30433682e-02f, -6.01161681e-02f, 6.96113631e-02f, 1.43960312e-01f, 1.90683991e-01f, -9.41818506e-02f, 3.36664021e-02f,
  -1.59621127e-02f, -7.78549165e-02f, -4.18625511e-02f, -1.82104092e-02f, -4.29500006e-02f, -7.70511851e-02f, 1.32669946e-02f, 9.16625038e-02f, -7.38393441e-02f, -4.41575190e-03f,
  -8.95261914e-02f, 2.62440611e-02f, -4.54432778e-02f, 1.16008848e-01f, -2.72020057e-04f, 2.50636432e-02f, -2.69382354e-03f, 1.41159398e-02f, 1.49105424e-02f, -1.27861604e-01f,
  1.03423474e-02f, 3.21200956e-03f, 4.52606604e-02f, 7.61862546e-02f, 2.55362168e-02f, 2.35859733e-02f, 5.36731258e-02f, 5.01773786e-03f, -1.21957492e-02f, -8.11440311e-03f,
  3.36155742e-02f, -6.25615269e-02f, 1.24727469e-02f, 4.10890859e-03f, -3.24520804e-02f, -5.89062506e-03f, 2.36101151e-02f, 7.24781975e-02f, -1.89364087e-02f, -7.15634152e-02f,
  2.25747470e-02f, -1.13420365e-02f, -8.18221793e-02f, 6.06624857e-02f, 3.68684833e-03f, 2.36506034e-02f, 2.08536927e-02f, 5.70277125e-02f, -6.27908332e-04f, -5.28381997e-06f,
  -2.19903421e-02f, -1.88436761e-01f, 1.00755654e-02f, 3.06021255e-02f, -2.61560790e-02f, -6.69530407e-02f, -1.88310165e-02f, -8.68752524e-02f, -7.08518922e-02f, 2.35947669e-02f,
  9.83781833e-03f, -1.25106722e-02f, 1.71977710e-02f, 7.23191798e-02f, -3.88502330e-02f, -4.25519086e-02f, -1.13549246e-03f, 3.63963842e-03f, 6.80825561e-02f, -3.90310064e-02f,
  1.27153754e-01f, 2.78674029e-02f, -3.01392842e-02f, -3.79146859e-02f, -5.17068338e-03f, 4.16840287e-03f, -1.18441738e-01f, -5.73595501e-02f, 1.49253281e-02f, -3.35827172e-02f,
  2.47303113e-01f, 1.32626250e-01f, 1.41147479e-01f, -1.05626751e-02f, -8.88129547e-02f, -3.58369499e-01f, -2.94883788e-01f, -9.67488512e-02f, -2.35833555e-01f, 4.83260676e-03f,
  -1.87907323e-01f, 9.01665241e-02f, 9.73639414e-02f, -2.66666234e-01f, -2.64923722e-01f, -1.27393708e-01f, -1.72224239e-01f, 2.18095370e-02f, 6.06262088e-02f, 9.44972485e-02f,
  -1.17469341e-01f, -1.38531119e-01f, -1.03574075e-01f, -1.24418467e-01f, -5.38808405e-02f, 1.08793788e-01f, 1.66863397e-01f, 2.94234920e-02f, 1.05105422e-01f, -1.40859024e-03f,
  1.29482727e-02f, 1.95727721e-02f, 3.54063474e-02f, -5.56994267e-02f, -3.97509336e-02f, 7.52749890e-02f, 1.42790422e-01f, 1.28014584e-03f, -6.30124146e-03f, 1.82282627e-02f,
  3.64757441e-02f, -1.39548972e-01f, -4.87650707e-02f, 1.09993396e-02f, 2.70288624e-02f, -5.26159257e-02f, -1.16063088e-01f, -1.63437352e-02f, -1.00738756e-01f, -4.28481475e-02f,
  -8.56191516e-02f, -6.55790269e-02f, -2.90310103e-02f, -3.27744000e-02f, -2.14546709e-03f, -9.39456001e-02f, -1.53581088e-03f, -7.55238486e-03f, -2.98496243e-02f, 4.24322449e-02f,
  -1.19470574e-01f, 3.28841917e-02f, 1.11963768e-02f, -1.68175958e-02f, 1.53598571e-02f, -4.17429022e-02f, 1.20003847e-02f, 7.95812067e-03f, 1.23562276e-01f, -4.87985350e-02f,
  1.18759386e-02f, -1.09829772e-02f, 3.39698158e-02f, 5.71072400e-02f, 7.12538958e-02f, 2.55367886e-02f, 5.97956851e-02f, -2.93270890e-02f, -5.45627438e-03f, -1.02480240e-01f,
  5.87373003e-02f, 5.99158555e-02f, -3.02818716e-02f, -2.94373687e-02f, -9.53909978e-02f, -3.58132422e-02f, -9.08741727e-02f, -2.62226677e-03f, 3.48067731e-02f, 3.25553752e-02f,
  2.25375503e-01f, 2.29947627e-01f, -6.85745291e-03f, 1.13468096e-02f, 1.84203982e-02f, -6.85511976e-02f, -4.09988407e-03f, -6.22746535e-02f, 1.38514534e-01f, -7.74717564e-03f,
  -3.18616591e-02f, 4.81936447e-02f, 8.76083449e-02f, 4.88616573e-03f, -1.12506665e-01f, 3.48430648e-02f, 1.69289354e-02f, 7.98749030e-02f, 4.53637019e-02f, -1.34286042e-02f,
  6.56393096e-02f, 4.88834344e-02f, 3.76377515e-02f, 4.55909828e-03f, 1.16384597e-02f, 4.14013378e-02f, 6.01025894e-02f, -5.24546877e-02f, -2.94024008e-03f, -9.06760767e-02f,
  2.96564102e-01f, 2.08151117e-01f, 1.76133499e-01f, 2.99073428e-01f, -1.75104856e-01f, 2.48070091e-01f, 2.75867760e-01f, -7.48031437e-02f, 8.51263851e-02f, 8.19270685e-02f,
  -5.14792390e-02f, 1.14602730e-01f, 1.05195725e-03f, 1.97780013e-01f, 4.80209738e-02f, -4.42626625e-02f, 1.82616800e-01f, 1.38029516e-01f, -1.01939380e-01f, 1.63606912e-01f,
  -6.57802355e-03f, 2.46085916e-02f, 3.62020172e-02f, -1.21306375e-01f, 3.51344272e-02f, 5.31333173e-03f, -3.31034958e-02f, -6.93570962e-03f, 4.86735962e-02f, -3.64663545e-03f,
  -2.76058931e-02f, -7.07370862e-02f, -8.03761184e-02f, 5.37220277e-02f, 2.57181767e-02f, 1.38361128e-02f, 5.89438640e-02f, 3.06861778e-03f, -1.46637615e-02f, 1.04667631e-03f,
  2.87097171e-02f, -1.75908282e-02f, 6.73137903e-02f, -6.94738999e-02f, 4.59008757e-03f, -8.38933885e-02f, -4.21767868e-03f, -4.35972251e-02f, 8.46770965e-03f, -8.95381868e-02f,
  -5.48218191e-02f, -2.96227224e-02f, 2.87045240e-02f, -2.17134692e-02f, -5.95006980e-02f, 1.11221801e-02f, 1.75673775e-02f, 4.23447229e-02f, -3.69190276e-02f, -1.67645160e-02f,
  -6.52219495e-03f, -1.32877514e-01f, -6.60843328e-02f, 2.61339862e-02f, 1.09738354e-02f, -3.64783034e-02f, -1.16392942e-02f, 6.19053002e-03f, -1.94300655e-02f, 2.92902924e-02f,
  1.87132973e-02f, 4.63345908e-02f, 4.38682996e-02f, -1.13321640e-01f, 9.20650810e-02f, 3.11222244e-02f, 1.75403114e-02f, -2.74597555e-02f, 2.17287093e-02f, -2.12156661e-02f,
  7.46589676e-02f, -6.04135655e-02f, -1.55507307e-02f, -7.10799126e-03f, 7.87016153e-02f, 5.60709350e-02f, -4.84766997e-02f, 1.59144886e-02f, 3.58813852e-02f, 4.65876311e-02f,
  1.39970168e-01f, 1.57649130e-01f, -3.51649430e-03f, -4.08572704e-02f, 5.57916192e-03f, -1.20237591e-02f, 3.05143762e-02f, 4.79499772e-02f, 9.24450085e-02f, -7.41782552e-03f,
  4.65100594e-02f, 1.86163802e-02f, 5.90666570e-03f, -3.67346704e-02f, 7.26269856e-02f, 1.47804739e-02f, 9.92671251e-02f, 1.12832792e-01f, 6.71618730e-02f, -3.92473638e-02f,
  -8.48343875e-03f, 9.51899961e-02f, 6.63165143e-03f, -2.40065530e-02f, 6.59995154e-02f, 3.96371223e-02f, 1.52412933e-04f, 1.47545701e-02f, 2.32657362e-02f, 1.76083855e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.07216159e-01f, 4.52068985e-01f, -4.07825828e-01f, 1.32977720e-02f, -1.99252561e-01f, 5.13836324e-01f, 2.59701818e-01f, -8.12009051e-02f, 1.19723961e-01f, 3.36885273e-01f,
  1.04564629e-01f, 2.66813729e-02f, 1.18383966e-01f, 2.22885698e-01f, 5.35976104e-02f, 2.21686259e-01f, 3.41305077e-01f, 2.20539764e-01f, 8.94382522e-02f, 1.68119624e-01f,
  -2.32052710e-02f, 3.19872051e-01f, -2.46622950e-01f, 1.49744153e-02f, -8.02721828e-02f, -8.98694843e-02f, -2.29370281e-01f, -1.74323902e-01f, -1.45977005e-01f, 4.91259247e-02f,
  1.05163574e-01f, 3.28244604e-02f, -1.32825151e-01f, 5.01155555e-02f, -4.19649146e-02f, -4.56219427e-02f, -1.01259559e-01f, 1.77376904e-02f, -3.09707616e-02f, 3.51561457e-02f,
  4.88301814e-02f, -8.54395628e-02f, 8.01296011e-02f, 3.32384114e-03f, 2.60650087e-02f, -4.99479063e-02f, -1.06505223e-01f, -3.99768390e-02f, -1.17109500e-01f, -5.98034682e-03f,
  -5.62920123e-02f, -4.41659838e-02f, -6.41068816e-02f, 3.78243700e-02f, -1.36031240e-01f, -1.63063407e-02f, -1.06802369e-02f, -1.39698591e-02f, 1.33926226e-02f, 6.75712228e-02f,
  6.02719076e-02f, 2.55870167e-03f, 5.76986037e-02f, 2.45991219e-02f, 5.70143573e-02f, -9.16911736e-02f, 8.07251707e-02f, -3.77857015e-02f, -1.19780228e-02f, 1.84020493e-02f,
  -1.00178599e-01f, -1.41647747e-02f, -3.35044116e-02f, 8.98680091e-02f, 4.17527892e-02f, 1.91641077e-02f, 3.01084649e-02f, -6.34773374e-02f, -6.99740974e-03f, -1.90775320e-02f,
  1.31751522e-02f, -7.23191677e-03f, -3.89842764e-02f, 1.99734122e-02f, 5.09932358e-03f, -6.23417608e-02f, -4.12464291e-02f, -7.07066506e-02f, -3.68377604e-02f, -2.18587685e-02f,
  2.12916389e-01f, 3.07493687e-01f, 1.46507556e-02f, 4.91049048e-03f, 4.10509929e-02f, 6.15243949e-02f, 1.11087449e-01f, 2.89896764e-02f, 1.23604625e-01f, 6.19190484e-02f,
  -6.96823969e-02f, 4.93400097e-02f, 9.37644020e-02f, -1.79404505e-02f, 2.03330088e-02f, 5.58250695e-02f, -9.88137722e-03f, -9.46687087e-02f, 3.21064517e-02f, 1.51403726e-03f,
  -1.97745189e-02f, 4.84450348e-02f, 4.00505736e-02f, -6.18820377e-02f, 3.93732227e-02f, -6.08758815e-02f, 3.58020514e-02f, -3.47725931e-04f, -3.42963785e-02f, 2.61063501e-02f,
  2.21162856e-01f, 3.67032737e-01f, 1.34055719e-01f, -7.03786463e-02f, -1.27399668e-01f, -1.29318923e-01f, -3.85555997e-02f, -1.44881830e-02f, -2.34365121e-01f, 2.52256036e-01f,
  -2.88380831e-01f, 1.14922248e-01f, -2.00179353e-01f, -1.94207802e-01f, -6.34137988e-01f, -2.49826208e-01f, -1.28079727e-01f, 2.22438574e-02f, -1.05749667e-01f, 6.11035824e-02f,
  -1.68582022e-01f, -2.75672197e-01f, -2.26472374e-02f, -6.65980056e-02f, 1.86254993e-01f, 3.12679350e-01f, -9.53430459e-02f, 5.59000373e-02f, 1.79822326e-01f, -1.12728007e-01f,
  -1.49506643e-01f, -1.17557831e-01f, 7.15308338e-02f, 4.82655652e-02f, 8.21881071e-02f, 1.00809947e-01f, 1.50286898e-01f, -9.33966115e-02f, -6.81693554e-02f, -1.96837652e-02f,
  4.62928191e-02f, -2.89327130e-02f, -7.61814490e-02f, -7.80894235e-02f, 1.27287343e-01f, 1.72987431e-02f, 7.03790113e-02f, 2.53516324e-02f, -2.68470347e-02f, 1.30518273e-01f,
  2.09457297e-02f, 8.16555694e-02f, 1.31935567e-01f, 8.95193219e-02f, 4.13064891e-03f, -5.00512272e-02f, 4.86446582e-02f, 7.73200095e-02f, 2.25801729e-02f, 4.49727774e-02f,
  1.43902854e-03f, 7.50195161e-02f, -6.53927848e-02f, 2.11822409e-02f, -4.99690659e-02f, -9.22956616e-02f, -3.96914929e-02f, 2.34936699e-02f, 6.15500845e-02f, 4.79816552e-03f,
  -2.02917363e-02f, -2.52941009e-02f, -6.32851794e-02f, 1.16996534e-01f, 1.27918301e-02f, 1.59132537e-02f, 1.41963521e-02f, -3.34287472e-02f, 7.47993588e-02f, -7.64598548e-02f,
  1.28120724e-02f, 3.24533731e-02f, 7.35724568e-02f, 7.40387961e-02f, -9.63103548e-02f, 6.08529635e-02f, -3.31025422e-02f, 2.41000522e-02f, 2.15166137e-02f, 2.67591532e-02f,
  1.30153403e-01f, 1.28233165e-01f, -6.66916370e-02f, -1.09850466e-02f, 2.65381150e-02f, 2.45599169e-02f, -4.13875766e-02f, 3.30175646e-03f, -2.30313744e-02f, -4.47823368e-02f,
  1.20320313e-01f, 4.66604866e-02f, 9.52685624e-02f, 7.22433487e-03f, -3.01402137e-02f, -8.99335090e-03f, 1.18967872e-02f, 2.03896370e-02f, 9.92938504e-03f, -1.91461071e-02f,
  1.27320662e-01f, -3.63792316e-03f, 2.17986722e-02f, -8.50620270e-02f, 2.16754782e-03f, 1.01019114e-01f, 3.49985659e-02f, 6.49394840e-02f, 1.17189121e-02f, 4.27556932e-02f,
  4.13857847e-01f, 2.06398591e-01f, 2.34322734e-02f, 1.22601420e-01f, -2.81972170e-01f, -4.20985699e-01f, -3.51773292e-01f, 7.16200322e-02f, -1.86453715e-01f, -9.71586481e-02f,
  -3.86500545e-02f, -1.57845259e-01f, 8.71989578e-02f, 3.05006951e-02f, 2.05620304e-01f, 2.99742430e-01f, -4.29224782e-02f, -1.19684927e-01f, 1.53230071e-01f, 1.29885480e-01f,
  1.72530383e-01f, 6.36876523e-02f, 2.36610711e-01f, 4.10229750e-02f, 8.63891989e-02f, 2.64014989e-01f, 3.61705214e-01f, 9.60365981e-02f, -5.58603890e-02f, -8.29886571e-02f,
  -5.18904859e-03f, -2.85347998e-02f, 3.29821706e-02f, -5.72176836e-02f, 4.11568768e-02f, -3.91173512e-02f, -6.61568195e-02f, -5.69231026e-02f, -1.40738338e-01f, -4.26258817e-02f,
  3.56860878e-03f, -3.32853794e-02f, -6.51426017e-02f, -5.94858043e-02f, -2.98813712e-02f, 1.07224826e-02f, -5.77021316e-02f, -6.94679245e-02f, -7.33102066e-03f, 5.88719733e-02f,
  5.04426695e-02f, -2.42783744e-02f, 1.45469122e-02f, 9.07242671e-03f, -3.76641080e-02f, -3.35734785e-02f, -4.32023481e-02f, -8.43865890e-03f, -1.59638433e-03f, -7.80629590e-02f,
  2.99728438e-02f, 4.76877429e-02f, 2.49218848e-02f, -1.04582896e-02f, 3.29098366e-02f, 4.63811755e-02f, 1.98999271e-02f, -2.26377118e-02f, 1.06483437e-01f, 8.23503956e-02f,
  1.72844864e-02f, 7.10074324e-03f, -1.18263923e-01f, -3.09030134e-02f, 1.35628581e-02f, 9.71883535e-03f, -6.51071966e-02f, 2.51747388e-02f, -7.72160962e-02f, -1.63206570e-02f,
  -1.33891599e-02f, 7.25526959e-02f, 2.44791284e-02f, 3.38054895e-02f, 6.51114807e-02f, -5.22348471e-03f, -2.86156330e-02f, 1.18197329e-01f, 2.44514756e-02f, -4.45895642e-02f,
  -3.22184013e-03f, 4.08162713e-01f, -5.74848838e-02f, -1.86361313e-01f, -4.66744788e-02f, 1.03340581e-01f, -1.19592994e-02f, 6.55978099e-02f, 5.55791743e-02f, 2.92602498e-02f,
  -8.78849626e-02f, -3.13179046e-02f, 1.12345833e-02f, 8.23891610e-02f, 3.36820520e-02f, 3.48910205e-02f, 7.05163777e-02f, -7.00683743e-02f, 9.30742174e-03f, 8.88370425e-02f,
  -5.86659797e-02f, 1.49998024e-01f, 5.04473746e-02f, -8.54687616e-02f, 3.22197676e-02f, 8.64618272e-03f, 1.46975378e-02f, -3.75512838e-02f, 3.84021960e-02f, -3.63079496e-02f,
  2.13065684e-01f, 2.74275825e-03f, -9.88549814e-02f, 1.83359951e-01f, -9.69961062e-02f, -2.00948641e-01f, -3.02686006e-01f, 1.42655969e-01f, -1.60666540e-01f, 2.63072960e-02f,
  1.37856334e-01f, -1.79747447e-01f, -1.41152233e-01f, 1.49704948e-01f, 1.81173161e-01f, -2.50083655e-01f, 1.62821427e-01f, 4.74622212e-02f, -1.21441975e-01f, 1.19137876e-01f,
  1.19190663e-01f, 1.85760051e-01f, 2.24344328e-01f, 2.75187761e-01f, 1.08918011e-01f, 2.11294979e-01f, 4.10009503e-01f, 1.71562526e-02f, 2.86192209e-01f, 1.12097844e-01f,
  -2.13260297e-02f, 1.97662450e-02f, 5.52156903e-02f, -2.87532937e-02f, 4.03072312e-02f, 6.88876063e-02f, 3.40469964e-02f, 2.66915243e-02f, -9.37034935e-02f, -1.26891294e-02f,
  -5.53227179e-02f, 3.20852123e-04f, -1.89493336e-02f, -3.86284053e-04f, -1.32071218e-02f, 4.52079512e-02f, -1.26861885e-01f, -6.06296137e-02f, -6.42002299e-02f, 7.70182610e-02f,
  -1.22506879e-01f, -1.06686607e-01f, -4.68283109e-02f, 4.37013991e-03f, -4.65724692e-02f, 1.08017279e-02f, -5.02438620e-02f, -2.23700721e-02f, -9.47203115e-03f, -5.43814264e-02f,
  6.59879968e-02f, -1.07249618e-02f, -5.19433466e-04f, -2.22153869e-02f, -7.57613732e-03f, -7.27284998e-02f, 5.91014465e-03f, -6.31730631e-02f, 2.39854530e-02f, 3.05049643e-02f,
  2.49504205e-02f, 3.38284001e-02f, 9.38349515e-02f, -3.52568403e-02f, -1.73900314e-02f, -6.98649064e-02f, -5.29088005e-02f, -2.72572748e-02f, -3.07045951e-02f, -4.63361293e-02f,
  2.19414569e-02f, 1.01073524e-02f, 9.00515243e-02f, -2.01482344e-02f, 9.93844774e-03f, 4.50381674e-02f, 1.16259798e-01f, -5.77673391e-02f, -6.78540170e-02f, -6.99275732e-02f,
  7.33917281e-02f, 5.96561022e-02f, -2.79452335e-02f, 1.83077026e-02f, -6.02481253e-02f, -5.14628850e-02f, -2.28023902e-03f, 6.11890405e-02f, 1.20721392e-01f, 2.36243531e-02f,
  3.06631643e-02f, -3.79019097e-04f, -3.01370602e-02f, -1.46196336e-02f, 9.66578647e-02f, -5.83789945e-02f, 3.78977433e-02f, 1.09838009e-01f, -2.11978015e-02f, 1.17334081e-02f,
  3.39584909e-02f, -1.35185823e-01f, 3.81146297e-02f, -1.15534574e-01f, -3.43602411e-02f, -2.74220109e-02f, 3.61798331e-02f, 4.98406030e-02f, 7.56015163e-03f, 7.54208863e-02f,
  2.40775809e-01f, 5.71421742e-01f, 2.70121306e-01f, 1.09334484e-01f, -3.33280005e-02f, -3.83027643e-01f, -2.35796779e-01f, 1.22350454e-01f, -4.12712507e-02f, -3.57496105e-02f,
  -1.97534859e-01f, 2.64341921e-01f, 1.34424701e-01f, -1.06961075e-02f, -2.67798334e-01f, -2.25685537e-01f, 4.36769314e-02f, 8.84017199e-02f, -3.03868111e-03f, 7.28864148e-02f,
  -2.29896978e-02f, -1.18600719e-01f, 2.31923983e-01f, -4.14410569e-02f, 1.57123223e-01f, 1.99997321e-01f, 6.11792691e-02f, 9.79466289e-02f, 1.76511288e-01f, -3.34742200e-03f,
  -2.37275422e-01f, -1.36233177e-02f, 1.19052887e-01f, 1.14481881e-01f, -4.38802950e-02f, 1.68276466e-02f, -1.09779257e-02f, -3.63187492e-02f, -4.44824509e-02f, 3.17335338e-03f,
  2.99182888e-02f, -2.48031486e-02f, 6.76162839e-02f, -3.71519919e-03f, -5.95735833e-02f, 7.53335506e-02f, 1.13413408e-01f, 4.07727323e-02f, 1.00707412e-01f, 8.19807202e-02f,
  1.55870123e-02f, 8.60647559e-02f, 3.62390317e-02f, 1.20110691e-01f, -4.56372835e-02f, -7.68318847e-02f, -6.52135164e-02f, 7.23466650e-02f, 5.58420159e-02f, -7.07290322e-02f,
  4.04378446e-03f, -9.76167470e-02f, 3.14762481e-02f, -1.28481640e-02f, -3.37621644e-02f, -4.01661173e-02f, -2.71777320e-03f, 6.28724992e-02f, 1.70268603e-02f, -7.26545230e-02f,
  -1.76960919e-02f, 8.18132050e-03f, -6.20088689e-02f, -7.89549947e-02f, 5.16219065e-04f, 5.46336286e-02f, -1.57110337e-02f, 4.47892807e-02f, 3.70356813e-02f, 8.45702142e-02f,
  -7.04535171e-02f, 2.87602022e-02f, -5.78370020e-02f, 3.75665948e-02f, -5.82677387e-02f, -8.98681656e-02f, -8.75944737e-03f, 2.60963738e-02f, 1.97502188e-02f, 3.38421785e-03f,
  7.42899552e-02f, 2.72854328e-01f, -3.92221399e-02f, -4.17717546e-02f, -9.35062021e-02f, -1.07883267e-01f, -1.00386076e-01f, 7.03299195e-02f, -5.14880382e-03f, 1.57135725e-02f,
  9.05177277e-03f, -2.37363018e-03f, -3.42461579e-02f, -5.59618995e-02f, 4.10402343e-02f, -1.05153203e-01f, -4.12433222e-02f, -7.49963671e-02f, 9.53412428e-02f, -2.90221511e-03f,
  8.19410831e-02f, -1.51520491e-01f, -3.49614844e-02f, -1.70515571e-03f, 1.98016968e-02f, -2.83378386e-03f, -6.01364300e-02f, -2.12770980e-02f, 2.72534526e-04f, -6.25012517e-02f,
  -5.20660162e-01f, -5.93807064e-02f, -5.86438775e-01f, -4.36345249e-01f, 9.70493406e-02f, -2.41512522e-01f, -3.66691470e-01f, -3.57313966e-03f, 2.40852591e-02f, 2.15007171e-01f,
  1.52858227e-01f, -4.83457446e-02f, 5.95715828e-02f, -3.53811830e-01f, -4.86505538e-01f, -2.64345199e-01f, -4.76866603e-01f, -2.13954166e-01f, -1.04132168e-01f, -1.02431044e-01f,
  -1.76164135e-01f, -3.04687414e-02f, -3.78098875e-01f, 2.41284385e-01f, -1.99064508e-01f, 2.25229621e-01f, 2.57375091e-01f, 1.39724553e-01f, -7.63012841e-02f, -3.40004079e-02f,
  7.99591914e-02f, -2.58504953e-02f, 6.51412457e-03f, -2.02150792e-02f, -8.52785110e-02f, 6.37406781e-02f, -3.52070928e-02f, 2.94312350e-02f, 6.20850967e-03f, -3.11594992e-03f,
  1.74661085e-03f, 1.22712336e-01f, -5.93729056e-02f, 7.95161575e-02f, 1.62881874e-02f, 3.38618085e-02f, -7.89230168e-02f, -6.80468604e-02f, 2.15352327e-03f, -2.01908469e-01f,
  -1.76974788e-01f, 6.58650533e-05f, -5.17139994e-02f, -1.73562206e-02f, -1.72976479e-01f, 6.50906339e-02f, -8.63552988e-02f, 5.33201955e-02f, 2.94737238e-02f, -4.20337617e-02f,
  -1.99550912e-02f, -6.73426017e-02f, -2.29970403e-02f, 3.30530442e-02f, -6.41747890e-03f, 7.30127990e-02f, -7.82173201e-02f, -9.38888453e-03f, -2.10626633e-04f, 6.93411082e-02f,
  -1.11178420e-02f, 1.08808409e-02f, 1.94709208e-02f, -6.93064183e-02f, -1.35555426e-02f, 3.55628282e-02f, 2.08445638e-02f, 2.07148138e-02f, -1.11996658e-01f, 1.30860908e-02f,
  -2.14967914e-02f, -1.36846364e-01f, 6.54252246e-02f, -7.89675191e-02f, -1.93830039e-02f, 5.26874624e-02f, -3.71696951e-04f, 6.06208965e-02f, -3.04828137e-02f, 1.99836865e-02f,
  6.27011014e-03f, 1.23748310e-01f, 6.15116619e-02f, 6.93889782e-02f, 4.24986482e-02f, -4.66196835e-02f, -8.56372565e-02f, -3.13619860e-02f, 5.07777147e-02f, 9.32857208e-03f,
  5.46595827e-02f, 4.70573455e-03f, 1.43542523e-02f, -8.10331106e-02f, 9.61864218e-02f, -4.58204783e-02f, -3.63896973e-03f, 8.08837935e-02f, 5.54355420e-03f, 1.52854234e-01f,
  6.92784488e-02f, 7.08297938e-02f, 2.66598370e-02f, 4.08637077e-02f, -7.76856542e-02f, 5.59103414e-02f, 2.77806520e-02f, 7.06179719e-03f, -1.17306281e-02f, -9.00813378e-03f,
  2.47694090e-01f, -1.29912630e-01f, -2.43615478e-01f, -2.17085049e-01f, -2.50792354e-01f, -6.77184984e-02f, -2.49124438e-01f, -2.10837066e-01f, -1.85167104e-01f, -2.36726068e-02f,
  -2.46619478e-01f, 1.12240508e-01f, 4.23749201e-02f, -4.76898670e-01f, 2.70460874e-01f, 1.80730388e-01f, -1.90499663e-01f, 4.73788157e-02f, -1.27193540e-01f, -9.82252895e-05f,
  4.45537679e-02f, -3.11539084e-01f, -5.56213260e-02f, 4.34495546e-02f, -2.85274357e-01f, 1.25666149e-02f, 5.06170914e-02f, -1.86209962e-01f, -2.76106834e-01f, -2.33412102e-01f,
  5.67704104e-02f, -1.66515633e-02f, -1.22487091e-01f, 1.41757829e-02f, -5.73925627e-03f, -1.01368548e-02f, -9.30731967e-02f, -9.11248624e-02f, 6.37509897e-02f, 3.60719077e-02f,
  3.18754092e-02f, -7.43357018e-02f, -3.15389922e-03f, -4.11750674e-02f, -3.98600958e-02f, 2.77652293e-02f, 1.25414804e-02f, 4.07600068e-02f, -1.06947072e-01f, -1.17845803e-01f,
  -1.11178808e-01f, -9.54042673e-02f, -7.40795135e-02f, -5.85959069e-02f, -1.17810726e-01f, -7.43637010e-02f, 2.38011349e-02f, -4.04573716e-02f, 4.75467853e-02f, 2.07619108e-02f,
  -1.95809826e-02f, -1.29285470e-01f, 4.84737121e-02f, -1.87228806e-02f, 2.22395863e-02f, -4.74681146e-04f, 7.00345039e-02f, -8.71021822e-02f, 3.45721990e-02f, -3.54384631e-03f,
  2.60795411e-02f, -8.30291398e-03f, 3.46854627e-02f, -5.80499088e-03f, 2.57796538e-03f, -7.82837495e-02f, 3.02562211e-02f, -2.59895790e-02f, -1.05550652e-02f, 1.62184700e-01f,
  -2.31981762e-02f, -1.24482349e-01f, 4.06641141e-02f, -4.40814756e-02f, -3.69705893e-02f, 3.75657380e-02f, -8.79388675e-02f, -1.96098187e-03f, 3.88032943e-02f, 5.61388917e-02f,
  -4.65882905e-02f, -1.25778377e-01f, 2.20955219e-02f, -1.44199925e-02f, 1.36269853e-01f, 1.58226088e-01f, -5.95626533e-02f, -2.23356038e-02f, -1.19400591e-01f, -6.89971074e-02f,
  -3.56678292e-02f, 1.06277712e-01f, -1.69772469e-03f, -6.79205135e-02f, 4.69269529e-02f, -1.74324848e-02f, -9.00568068e-02f, 3.12342476e-02f, -8.58202130e-02f, -5.68062104e-02f,
  -3.12085282e-02f, 9.43341777e-02f, 2.35124752e-02f, 8.95280689e-02f, 5.56532592e-02f, -5.67372777e-02f, 1.15726382e-01f, 4.95776758e-02f, 1.99920801e-03f, -1.06574960e-01f,
  4.00535643e-01f, 4.27589953e-01f, 3.91571552e-01f, 4.69421178e-01f, -1.70219213e-01f, -3.61632258e-01f, -1.66206285e-01f, 1.51121199e-01f, 1.43815473e-01f, -1.87421106e-02f,
  -1.08566359e-01f, 1.79159567e-01f, 1.23977126e-03f, 1.50119856e-01f, -1.80550963e-01f, -1.08217016e-01f, -6.16221987e-02f, -1.79198179e-02f, 9.13263112e-02f, 1.39922798e-01f,
  8.31567347e-02f, -2.76264608e-01f, -3.74986627e-03f, -1.28098205e-01f, 1.16751306e-01f, 2.24258766e-01f, -1.12402849e-01f, -3.82874571e-02f, 5.13430014e-02f, -2.06386805e-01f,
  -2.15153545e-01f, 1.95166707e-01f, 3.33328918e-02f, 1.37979332e-02f, 3.40192555e-03f, -1.37834430e-01f, -5.66062406e-02f, -1.27944827e-01f, -5.07243127e-02f, 3.54381762e-02f,
  -7.03283260e-03f, 4.09639888e-02f, -2.31532007e-02f, -1.95391309e-02f, 4.74328585e-02f, 7.16205314e-02f, 4.06310372e-02f, 1.11901276e-01f, 6.19123541e-02f, 5.94099239e-02f,
  1.09191686e-01f, 5.89659773e-02f, -3.72850969e-02f, -8.42270702e-02f, 1.49478525e-01f, 3.45982909e-02f, 8.95622361e-04f, -5.22966348e-02f, -4.78526391e-03f, -1.63050294e-02f,
  5.26469089e-02f, -1.92812011e-02f, 3.61650973e-03f, 3.77105959e-02f, 4.03599814e-02f, 6.67499786e-04f, 4.70128767e-02f, -1.48909882e-01f, 3.45747955e-02f, -6.22461140e-02f,
  -7.19632879e-02f, 1.21335372e-01f, -3.64930108e-02f, -6.51551336e-02f, 6.43086387e-03f, -8.39115307e-03f, -4.75505888e-02f, -5.34849167e-02f, -1.02888301e-01f, 1.80295445e-02f,
  -4.64546756e-04f, -1.08696245e-01f, 1.92664750e-02f, -1.15088992e-01f, -1.29285768e-01f, 9.24906041e-03f, 6.41740188e-02f, 1.40767485e-01f, -2.41758153e-02f, -1.60390530e-02f,
  -1.99839875e-01f, 1.12351067e-02f, 6.65041357e-02f, -8.35122317e-02f, -3.23466561e-03f, 5.17669469e-02f, -1.11965770e-02f, -5.23149688e-03f, 3.16043273e-02f, -7.90023431e-02f,
  -5.15392236e-02f, -1.51207848e-02f, 9.55838524e-03f, 7.48581141e-02f, -8.58876482e-02f, 4.55314890e-02f, -6.34759723e-04f, -1.20850336e-02f, -1.42257601e-01f, 3.63226198e-02f,
  2.03718897e-02f, -1.69286635e-02f, -5.70523366e-02f, 4.95060813e-03f, 8.54128506e-03f, 2.80686282e-02f, -5.99071756e-02f, 1.98055264e-02f, -6.35827184e-02f, 1.29882433e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.26215190e-02f, -3.89950722e-02f, -2.37530366e-01f, 2.12024804e-02f, -1.19099990e-01f, 9.39189568e-02f, 1.49915023e-02f, 9.92362350e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.86087338e-02f, 8.13634992e-02f, 1.41492829e-01f, 3.66213992e-02f, -9.64690149e-02f, -1.30170599e-01f, -2.69918978e-01f, -1.94573089e-01f, 2.86107771e-02f, -1.24063566e-02f,
  1.56142071e-01f, -6.67350963e-02f, -2.40456581e-01f, -3.52924764e-01f, 3.12809139e-01f, 1.00606821e-01f, 3.66239578e-01f, 5.64590544e-02f, 2.06109378e-02f, 1.25579804e-01f,
  1.86017439e-01f, 1.12943463e-02f, -3.66644055e-01f, -2.60954313e-02f, 3.45356047e-01f, 1.95018932e-01f, 1.49356440e-01f, -3.26279216e-02f, 1.95095509e-01f, -4.18436676e-01f,
  -4.02623452e-02f, 3.05247217e-01f, 4.94637452e-02f, 7.18779862e-02f, -2.51023322e-01f, -2.74432283e-02f, 1.70918331e-01f, -5.18631153e-02f, 1.73766509e-01f, 5.84173240e-02f,
  2.63466209e-01f, 5.40006608e-02f, 6.72128201e-02f, 3.10164839e-01f, 2.80009985e-01f, -5.29095605e-02f, 6.75506815e-02f, -2.44274870e-01f, 1.46848650e-03f, 1.19728193e-01f,
  1.96683854e-01f, 4.19712216e-01f, 1.35800526e-01f, 1.17689706e-01f, -2.28104547e-01f, 2.84525454e-01f, 2.14077786e-01f, 6.35485500e-02f, -1.39354452e-01f, -6.81535760e-03f,
  -3.07946235e-01f, -8.63776170e-03f, -1.49581552e-01f, -2.26890877e-01f, 1.56296164e-01f, 4.15995985e-01f, -2.73672730e-01f, -4.29152139e-02f, 7.30787069e-02f, -3.93690728e-02f,
  2.37342447e-01f, 5.60809001e-02f, -6.12391084e-02f, 1.52644977e-01f, -1.76433802e-01f, 6.32128343e-02f, -1.61658078e-01f, 1.03487838e-02f, 2.78222952e-02f, -4.61990058e-01f,
  3.84806812e-01f, 3.78264517e-01f, 4.30924475e-01f, 3.45586628e-01f, -1.11964621e-01f, 4.55242656e-02f, 6.80833906e-02f, 2.80154556e-01f, -1.33310985e-02f, 1.83417201e-01f,
  8.50226264e-03f, 3.40992630e-01f, 1.96735740e-01f, -2.91498657e-03f, -8.20952579e-02f, 1.45349219e-01f, -2.37349257e-01f, 1.50539339e-01f, 1.23621859e-01f, 8.11689869e-02f,
  2.21933238e-03f, 1.71467990e-01f, 3.74905840e-02f, 3.38527620e-01f, -1.85401738e-02f, -6.23845570e-02f, 1.30598843e-01f, -1.06483698e-02f, -1.61968902e-01f, -3.70240599e-01f,
  -1.24490060e-01f, 1.84143916e-01f, 2.14432016e-01f, -2.07674295e-01f, 2.10102841e-01f, -1.65972576e-01f, 2.96371192e-01f, 4.17942135e-03f, 2.79633582e-01f, 4.21819836e-02f,
  3.50094378e-01f, 1.81471575e-02f, 3.06130558e-01f, 1.33166105e-01f, 6.75772503e-02f, -2.24838674e-01f, 1.90761894e-01f, -1.12941235e-01f, 1.67588994e-01f, 2.56804615e-01f,
  -2.76535824e-02f, 1.33271486e-01f, -3.21917385e-02f, 3.14840943e-01f, 1.09552175e-01f, 1.29694596e-01f, 3.92761501e-03f, 1.92618132e-01f, -2.16019630e-01f, -1.36923030e-01f,
  -6.95246458e-02f, 3.16536352e-02f, -8.33934098e-02f, 1.83929071e-01f, 2.67946512e-01f, 1.35987684e-01f, -2.56998271e-01f, -1.19550042e-01f, -3.99776816e-01f, -3.37132752e-01f,
  3.65777135e-01f, -9.92428064e-02f, 5.35758659e-02f, 9.56276730e-02f, 2.05658987e-01f, 1.01426847e-01f, 3.42603654e-01f, 4.48847175e-01f, 1.35085192e-02f, 2.89118052e-01f,
  2.03385979e-01f, -1.19232237e-02f, 3.22911404e-02f, 1.24176398e-01f, -5.19518480e-02f, -7.17542097e-02f, -2.62519211e-01f, -3.16246301e-01f, -1.60556778e-01f, 1.62972331e-01f,
  1.83322892e-01f, -3.45189601e-01f, 2.47798488e-01f, -2.65864223e-01f, 4.01452512e-01f, 8.60134587e-02f, 4.29115556e-02f, 1.35061741e-01f, -1.84188366e-01f, -1.85321525e-01f,
  1.23114005e-01f, -2.30535701e-01f, 5.09457774e-02f, -1.30602270e-01f, 3.51525284e-02f, -5.06643057e-01f, 2.24078834e-01f, -1.26823545e-01f, -3.45931828e-01f, -1.66979045e-01f,
  6.40475303e-02f, -1.00527540e-01f, -9.78031531e-02f, -1.82088524e-01f, -2.45582625e-01f, -2.60561798e-02f, -2.72128314e-01f, 2.73342639e-01f, 2.98830479e-01f, 8.43853205e-02f,
  -1.13150179e-01f, -2.12669387e-01f, -1.84058502e-01f, 1.49598315e-01f, 1.62368312e-01f, 4.38425899e-01f, -7.62225762e-02f, -1.09696791e-01f, -4.85707611e-01f, -1.27375543e-01f,
  -2.52904296e-01f, 4.62723104e-03f, -3.48271281e-01f, 2.41584599e-01f, 3.71053964e-01f, -4.31536287e-02f, -3.02989483e-01f, 1.25675038e-01f, -3.29365253e-01f, -1.27320781e-01f,
  -1.73536427e-02f, 4.56969887e-01f, 8.09712932e-02f, -2.54159123e-01f, 1.94239303e-01f, -2.03285187e-01f, -1.46418251e-02f, -5.40610589e-02f, -1.83465466e-01f, -2.65544802e-01f,
  2.21379876e-01f, -2.96455204e-01f, -6.38465360e-02f, 4.35951054e-02f, -7.45627098e-03f, -1.38543710e-01f, -1.37436420e-01f, 5.12001455e-01f, 9.90831554e-02f, 2.92771339e-01f,
  -1.70464590e-01f, 2.00350229e-02f, -8.59321356e-02f, -1.01747148e-01f, -2.19238877e-01f, -1.01407193e-01f, -1.57897145e-01f, 3.08881998e-02f, -3.12881410e-01f, -1.33788258e-01f,
  -1.26471296e-02f, 1.65075436e-01f, 2.16243133e-01f, -1.83266535e-01f, -3.12978774e-01f, 3.05710912e-01f, -2.03681141e-01f, 1.92044541e-01f, -1.61461666e-01f, -1.51527848e-03f,
  -2.79484004e-01f, 1.72462404e-01f, 1.82713255e-01f, 3.23578149e-01f, -1.04566298e-01f, 1.30614564e-01f, -3.90603170e-02f, -3.52522880e-02f, 2.36614048e-01f, 3.30207348e-01f,
  -1.10466450e-01f, -3.28864604e-01f, -4.78834771e-02f, 1.75290883e-01f, 1.50517330e-01f, 2.46574551e-01f, -1.90327704e-01f, -9.28550586e-02f, 2.98578203e-01f, 8.02131649e-03f,
  -2.77383626e-01f, 3.61910135e-01f, -1.32608175e-01f, 2.50136346e-01f, 3.07264239e-01f, -4.75990772e-02f, -5.87020777e-02f, 1.94243178e-01f, 3.18267912e-01f, 8.55320692e-02f,
  3.03347915e-01f, 2.86049366e-01f, -5.04950993e-03f, 1.06060296e-01f, -2.10037768e-01f, -7.91832358e-02f, 1.56025335e-01f, 3.06344718e-01f, 3.84479240e-02f, 3.00141107e-02f,
  -1.15691386e-01f, -3.90598029e-01f, -9.11901742e-02f, -1.97321877e-01f, 3.10095072e-01f, 3.81441832e-01f, -1.43893853e-01f, -1.22248620e-01f, -1.91370487e-01f, -1.95409507e-01f,
  -2.60698617e-01f, 1.88356355e-01f, 4.06145640e-02f, 2.21984699e-01f, -2.66064078e-01f, -6.56420141e-02f, -1.31478578e-01f, -2.85388902e-02f, -1.77492544e-01f, 1.56366378e-01f,
  -2.05406561e-01f, 1.83318704e-01f, -4.32013422e-02f, 1.32983223e-01f, -1.81833468e-02f, -1.42190248e-01f, -3.69353816e-02f, 3.61212878e-04f, 1.21943787e-01f, -1.64620861e-01f,
  -1.31537318e-01f, 2.26481348e-01f, 1.72327682e-02f, 5.74506857e-02f, -3.17141056e-01f, -4.19650733e-01f, 9.18490738e-02f, 4.90854621e-01f, 2.02729061e-01f, 3.36292267e-01f,
  -2.74065346e-01f, 1.79540858e-01f, -9.65147987e-02f, 2.29973048e-01f, -1.78514626e-02f, 2.32265592e-01f, 1.51467741e-01f, 1.12057567e-01f, 1.10749900e-01f, -1.49697036e-01f,
  -1.32901385e-01f, 2.96599478e-01f, 1.91408619e-02f, 1.35446995e-01f, 1.09793432e-01f, 1.74260195e-02f, 1.15099519e-01f, 3.00723314e-02f, 4.52723168e-02f, -5.85383810e-02f,
  -1.66024715e-01f, 7.36166537e-02f, -1.98276803e-01f, -9.93527770e-02f, 2.73112565e-01f, 2.72794962e-01f, -6.37479946e-02f, -1.84706226e-01f, 1.24978989e-01f, 2.24300414e-01f,
  -1.05557002e-01f, 1.45712048e-02f, -4.12581444e-01f, -3.13020051e-01f, 1.46197543e-01f, -2.22767189e-01f, -3.32842410e-01f, 5.68464808e-02f, 1.09316267e-01f, 4.98494506e-02f,
  2.17860326e-01f, 2.11280406e-01f, 7.79834017e-02f, 3.72148186e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.34424388e-01f, 3.12372208e-01f, -1.59746230e-01f, 1.41904205e-01f, 1.40825570e-01f, 1.19415931e-01f, 7.97665417e-02f, 1.47180349e-01f, 3.44317466e-01f, 9.40624475e-02f,
  2.99179442e-02f, 4.68614429e-01f, -3.83460611e-01f, 1.96635038e-01f, -4.71740246e-01f, -1.38238102e-01f, 1.54822037e-01f, 2.64520466e-01f, 2.20643401e-01f, 7.11603284e-01f,
  -3.04785728e-01f, 3.87409665e-02f, -4.57179219e-01f, 3.46461385e-01f, 3.04625213e-01f, 6.52273595e-02f, 3.67444456e-01f, 6.60439909e-01f, 3.16086084e-01f, -1.95255190e-01f,
  -2.92162508e-01f, 1.60939589e-01f, -4.70644496e-02f, 1.65339142e-01f, 2.94236273e-01f, 1.99611813e-01f, -5.64165674e-02f, 3.42627078e-01f, -1.45443892e-02f, 2.77841389e-01f,
  1.34108454e-01f, -3.97975603e-03f, -4.30263914e-02f, 3.40213180e-02f, -5.50782800e-01f, -1.58127367e-01f, -2.51168668e-01f, 7.25383610e-02f, 2.55919069e-01f, -2.55436242e-01f,
  4.06104088e-01f, 2.31227770e-01f, 4.79647607e-01f, 1.87511191e-01f, 2.28919405e-02f, 2.71267116e-01f, 3.53524059e-01f, 1.63864449e-01f, 5.78627050e-01f, 3.56131732e-01f,
  3.19274753e-01f, -6.05712235e-01f, -2.63979733e-01f, 5.26655853e-01f, 5.08101165e-01f, 3.00391108e-01f, 1.72611773e-01f, 2.59081841e-01f, 4.24560845e-01f, 4.77345765e-01f,
  3.36773872e-01f, 1.15275703e-01f, 3.66803944e-01f, 6.30643189e-01f, 3.65245879e-01f, -1.90291442e-02f, 5.52283704e-01f, -2.36613244e-01f, 6.45245910e-01f, 1.49685562e-01f,
  1.10549472e-01f, -1.73352405e-01f, -7.13743687e-01f, -4.70784754e-02f, -1.05087407e-01f, -6.73792362e-01f, 5.05032301e-01f, -1.52385272e-02f, 2.23679081e-01f, 7.49064684e-02f,
  1.20159872e-01f, -5.72801769e-01f, 1.48468614e-01f, 6.34606302e-01f, 2.56632298e-01f, 3.60593230e-01f, 6.96524799e-01f, 3.89046639e-01f, 1.12163693e-01f, -1.73448920e-02f,
  1.51186526e-01f, 4.44386721e-01f, 1.83806017e-01f, -6.08358625e-03f, 2.29822502e-01f, 1.75367862e-01f, 1.22563988e-01f, 9.69776288e-02f, -1.04889415e-01f, -2.83967882e-01f,
  -4.34676796e-01f, -2.97761708e-01f, -1.70112118e-01f, 4.04758483e-01f, 1.58487797e-01f, -1.34614199e-01f, -4.09653813e-01f, -3.26541424e-01f, 2.70270348e-01f, -1.64465383e-01f,
  -2.00345486e-01f, 6.94554627e-01f, -5.00817657e-01f, 1.19538337e-01f, 1.47336587e-01f, 6.71271861e-01f, -4.74816084e-01f, 1.04775593e-01f, 1.64478213e-01f, 1.28370896e-01f,
  2.11749718e-01f, 3.16924512e-01f, -1.14278179e-02f, 2.31485650e-01f, 9.54944566e-02f, 4.15275216e-01f, 2.64219344e-01f, 4.35470521e-01f, 2.88411170e-01f, 9.74234268e-02f,
  -3.80411774e-01f, -6.19684875e-01f, 4.18589354e-01f, 2.25173801e-01f, 7.98451841e-01f, -1.49320900e-01f, 1.88078076e-01f, 3.04740191e-01f, 3.58156145e-01f, -4.42234546e-01f,
  -2.72734344e-01f, 5.87171555e-01f, 6.55116022e-01f, 2.00498179e-01f, 2.37006977e-01f, 4.69050631e-02f, 1.01905420e-01f, -4.68240529e-01f, 2.25978673e-01f, 4.48613465e-01f,
  6.74624264e-01f, 3.40912789e-01f, 3.17993790e-01f, 3.47876936e-01f, 4.12797242e-01f, 1.91366673e-01f, -3.09811234e-02f, -3.94202024e-01f, 1.75271064e-01f, 4.89562750e-01f,
  2.11635515e-01f, 1.21003583e-01f, -1.08717300e-01f, -3.44426513e-01f, 2.19302610e-01f, 1.80334821e-01f, 1.66974604e-01f, 5.33055007e-01f, -4.71611649e-01f, -5.12099229e-02f,
  -1.41941756e-01f, -6.16720021e-01f, -3.23879898e-01f, -2.51035541e-01f, -6.77948669e-02f, -3.59108478e-01f, -3.77434313e-01f, -1.12378649e-01f, -1.68996498e-01f, 4.48025137e-01f,
  -4.61839557e-01f, 1.60158172e-01f, 6.64933547e-02f, -2.44817525e-01f, 5.69894433e-01f, 1.56746522e-01f, 2.92411655e-01f, -3.47338920e-03f, -3.44443247e-02f, -1.00922637e-01f,
  8.07091594e-02f, -2.46970817e-01f, 2.90884614e-01f, 2.38172263e-01f, -4.10511076e-01f, -3.57012153e-01f, 1.19876511e-01f, 7.13002264e-01f, -4.31016266e-01f, -4.72447425e-01f,
  -4.46333349e-01f, -9.96311903e-01f, 6.71586275e-01f, 1.24795303e-01f, -1.47218317e-01f, -4.40121025e-01f, -1.18032247e-01f, -1.28884465e-01f, 1.45776272e-01f, -2.90922195e-01f,
  2.22016424e-01f, 3.01384091e-01f, 2.17787270e-02f, 2.15657532e-01f, 2.38591190e-02f, -5.87283969e-02f, 1.88581049e-01f, 7.75902942e-02f, 1.08240582e-01f, 2.27428809e-01f,
  1.55482039e-01f, 3.64195913e-01f, 3.91220033e-01f, 3.54453593e-01f, 4.55019146e-01f, 3.27014267e-01f, 1.85081750e-01f, -1.51969060e-01f, 6.03341699e-01f, 1.72072887e-01f,
  2.45927319e-01f, -2.76438624e-01f, -5.98110929e-02f, 3.03085912e-02f, 5.13205469e-01f, 1.12520330e-01f, -2.36409321e-01f, 2.84466803e-01f, 4.89970624e-01f, -4.24989969e-01f,
  3.41743939e-02f, -4.78424616e-02f, -7.60046124e-01f, -3.65443885e-01f, 4.80298996e-01f, -4.75931644e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.43969673e-01f, -2.13134363e-02f, 3.51290405e-01f, 1.09490588e-01f, 7.98668861e-02f, 1.68318912e-01f, 2.22920612e-01f, 3.44487816e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -8.67476035e-03f, -4.57963115e-03f, 8.14557076e-02f, -8.24892819e-02f, 2.30150804e-01f, -2.17278628e-03f, -1.43416360e-01f, -2.22666468e-02f, -8.92895535e-02f, 7.02539980e-02f,
  -2.56156027e-02f, 2.71404851e-02f, 3.86105090e-01f, 3.98629874e-01f, 2.24671051e-01f, 1.86528713e-02f, -1.46308914e-01f, -3.37673463e-02f, 8.77359882e-02f, 5.23208827e-03f,
  2.09266424e-01f, 2.00577587e-01f, 4.43482518e-01f, -2.58084059e-01f, 2.85403937e-01f, 3.19766730e-01f, -1.26110241e-01f, -3.22271466e-01f, 8.41476172e-02f, -1.16879895e-01f,
  -6.88849166e-02f, 1.71206534e-01f, -7.11348504e-02f, -1.71099547e-02f, -4.48943898e-02f, 1.50049478e-01f, 7.83418640e-02f, 2.46421054e-01f, 2.18720391e-01f, 7.10906759e-02f,
  2.14566842e-01f, 2.22850256e-02f, 2.87854373e-02f, 2.90901721e-01f, -2.34382197e-01f, 3.50954123e-02f, 5.82946604e-03f, -3.82686496e-01f, 1.73161104e-02f, 2.84064621e-01f,
  1.46304993e-02f, 1.85732752e-01f, -1.02867343e-01f, 2.11210683e-01f, -8.38199481e-02f, 1.95040733e-01f, -4.47653383e-02f, -2.38469005e-01f, 7.54407570e-02f, 3.29870075e-01f,
  -5.05486391e-02f, 3.27345580e-01f, -4.61839326e-03f, -8.72004703e-02f, 1.95151672e-01f, 2.90161759e-01f, 6.59869909e-02f, -3.12944949e-01f, 2.29023397e-01f, 1.55328661e-01f,
  -8.35180879e-02f, -1.44838527e-01f, -2.12374702e-02f, -4.23968099e-02f, 1.15503557e-01f, -1.02527954e-01f, 4.26583618e-01f, 8.08286667e-02f, -1.38742343e-01f, 1.61487475e-01f,
  4.29681018e-02f, 4.62099135e-01f, -5.94694257e-01f, -2.34098256e-01f, -4.30694222e-01f, -1.28010526e-01f, 3.40128317e-02f, -3.25359285e-01f, -3.47602256e-02f, -1.93265360e-02f,
  -1.09736487e-01f, -2.32088700e-01f, 2.50140071e-01f, 1.25525400e-01f, 5.20475488e-03f, 2.84958303e-01f, -6.59708455e-02f, -5.96136600e-02f, -1.30493090e-01f, 1.23905152e-01f,
  -1.63628519e-01f, -2.13867143e-01f, -1.40584141e-01f, 1.60668612e-01f, -3.11863035e-01f, -1.90755486e-01f, -4.22471501e-02f, -2.48843282e-01f, 8.93273577e-02f, -1.16513006e-01f,
  6.91883340e-02f, 1.40551031e-01f, -1.79848433e-01f, -3.33237648e-01f, 3.78095567e-01f, 2.12142304e-01f, 3.90975237e-01f, -3.92675139e-02f, 4.60466862e-01f, 2.51922846e-01f,
  -3.20166200e-02f, 3.44155908e-01f, -1.76782429e-01f, -1.84650257e-01f, -6.79504201e-02f, -3.91245633e-01f, 3.87629084e-02f, -2.10194528e-01f, 1.92883000e-01f, -3.94422174e-01f,
  9.93952230e-02f, 7.89356008e-02f, 4.77074981e-01f, 1.57610521e-01f, 2.98411469e-03f, 1.26890540e-01f, 5.14291108e-01f, -3.74465026e-02f, -1.67400450e-01f, 2.58054018e-01f,
  -2.22712740e-01f, -1.07875131e-01f, -4.28488076e-01f, -2.38517791e-01f, 1.33344561e-01f, 2.72351682e-01f, 8.30952078e-02f, 2.15921417e-01f, 6.77064583e-02f, -2.24730402e-01f,
  -1.32000804e-01f, -2.34976485e-01f, 2.20203757e-01f, -1.88400924e-01f, 3.71959597e-01f, -3.63674313e-01f, -9.66064408e-02f, 8.21679831e-02f, -1.93428203e-01f, 2.95565933e-01f,
  -1.97819144e-01f, 1.06610082e-01f, 1.39873102e-01f, 2.30469927e-01f, 7.14321658e-02f, -3.62422206e-02f, -4.48358320e-02f, 1.34178428e-02f, 1.72749504e-01f, -2.21526884e-02f,
  1.77972376e-01f, -5.79912290e-02f, -3.39401424e-01f, 1.13213733e-01f, -1.29846543e-01f, 3.75703782e-01f, -6.12487681e-02f, 2.23960191e-01f, 9.18901265e-02f, -4.93687481e-01f,
  -1.51851729e-01f, -3.41386050e-01f, -1.25212237e-01f, -2.12672055e-01f, -2.81956881e-01f, -1.72587410e-01f, 3.04420680e-01f, -2.19200868e-02f, 8.40324908e-02f, -1.53643176e-01f,
  -1.28308624e-01f, 3.19962502e-01f, -9.62973293e-03f, 2.06858248e-01f, -5.00468388e-02f, -7.60451555e-02f, 1.53469518e-01f, 2.14167133e-01f, -2.67534852e-01f, -1.25144899e-01f,
  1.04553014e-01f, 5.51823154e-02f, 1.56765744e-01f, -1.35421097e-01f, 5.07326890e-03f, 3.85764211e-01f, -1.50511801e-01f, 1.79405198e-01f, -3.54690030e-02f, 1.16569631e-01f,
  -2.27832943e-01f, -3.93837303e-01f, 2.63353027e-02f, -4.19903219e-01f, -1.09239742e-01f, -3.00096035e-01f, -2.08884105e-01f, -8.57033655e-02f, 1.50263116e-01f, -1.88943312e-01f,
  1.03892729e-01f, -1.59712270e-01f, -2.26637527e-01f, 2.71367699e-01f, 1.17045492e-01f, 1.78822190e-01f, -3.61938551e-02f, 4.21021655e-02f, 3.08306336e-01f, 1.51486143e-01f,
  8.47650971e-03f, 3.75155866e-01f, 3.82088274e-02f, 2.81237245e-01f, -1.40659183e-01f, 1.09699192e-02f, -5.88621721e-02f, 2.13708267e-01f, 1.23794667e-01f, -1.93892479e-01f,
  2.48408377e-01f, -7.10366592e-02f, -5.09378575e-02f, 1.19308598e-01f, -9.44357365e-02f, 4.59642470e-01f, 9.66646969e-02f, 8.60482305e-02f, -9.14299786e-02f, -2.93349534e-01f,
  -1.63564205e-01f, 2.00564444e-01f, -2.76154876e-01f, 3.46939176e-01f, 2.70913213e-01f, -1.07346535e-01f, 2.73029029e-01f, -5.17886914e-02f, -1.24958560e-01f, -1.80356607e-01f,
  9.47959051e-02f, 1.64487556e-01f, -5.23105673e-02f, 3.48130673e-01f, 2.40863681e-01f, -8.00647121e-03f, 3.69625427e-02f, 1.82481825e-01f, 1.34917367e-02f, -1.81310341e-01f,
  -3.58145505e-01f, 7.85029680e-02f, 2.71301493e-02f, 4.10849512e-01f, -4.49036986e-01f, 4.90857124e-01f, -2.00833365e-01f, 6.76987469e-02f, -2.78227657e-01f, -5.52394949e-02f,
  -3.51345120e-03f, 1.93496779e-01f, 2.44697154e-01f, -2.50898808e-01f, 8.61829668e-02f, 3.48783225e-01f, 2.82833099e-01f, -1.39394045e-01f, 5.48056932e-03f, 1.50886744e-01f,
  3.53573523e-02f, -2.61010319e-01f, 1.63504314e-02f, -5.39650843e-02f, 1.23443520e-02f, -6.08427189e-02f, 7.99079239e-02f, 1.34881631e-01f, -1.32382154e-01f, -2.50313818e-01f,
  2.07834512e-01f, 8.84626657e-02f, 2.37822235e-01f, -2.94056147e-01f, 8.93350914e-02f, 2.16891970e-02f, -2.15387523e-01f, 3.60242218e-01f, 1.03390925e-01f, 3.19849104e-01f,
  4.26593274e-01f, 2.51308084e-01f, 2.80765027e-01f, 1.74124524e-01f, -3.47455323e-01f, -2.28332356e-01f, -1.34657249e-01f, 1.60957500e-01f, -4.66651022e-02f, -1.95190668e-01f,
  -1.29358649e-01f, 2.59294659e-01f, 2.00014308e-01f, 1.67808935e-01f, 3.39856088e-01f, -3.56116742e-01f, 9.28704739e-02f, -6.36963397e-02f, -1.91837698e-01f, 1.82444349e-01f,
  7.28916228e-02f, 2.08860606e-01f, 2.48519152e-01f, 2.77328104e-01f, -1.48685008e-01f, 2.78470486e-01f, -1.27920955e-01f, 9.19265375e-02f, 4.72157113e-02f, -3.74373794e-01f,
  -2.55866498e-01f, 4.98915792e-01f, -2.21486166e-01f, -4.95070338e-01f, 4.82155234e-02f, 1.53329708e-02f, -2.60653347e-01f, 1.84034854e-01f, -1.03974693e-01f, -7.94056654e-02f,
  2.69063681e-01f, -9.70297903e-02f, -2.85166711e-01f, 5.41615263e-02f, -1.15716271e-01f, -2.20170885e-01f, -4.96907562e-01f, -9.70810503e-02f, -7.18945963e-03f, -1.04857236e-01f,
  -2.57059157e-01f, -7.97776505e-02f, -5.66975400e-02f, -2.80228823e-01f, 2.33426895e-02f, -7.14420825e-02f, 2.46622115e-02f, 3.84812236e-01f, -1.59957502e-02f, -2.68431067e-01f,
  2.06471026e-01f, -3.07223231e-01f, 1.66824952e-01f, -2.12268367e-01f, 2.53386319e-01f, 2.10041001e-01f, 7.47833326e-02f, 2.17491791e-01f, 1.56228513e-01f, -4.33512926e-02f,
  7.92681128e-02f, -3.19835722e-01f, -2.57734030e-01f, -8.60036239e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.05144548e-01f, 8.29294249e-02f, 1.55194968e-01f, 3.72882485e-01f, 3.69796962e-01f, 2.13097855e-01f, 2.68583238e-01f, 3.42549801e-01f, 4.36257184e-01f, 6.51938915e-01f,
  5.29636264e-01f, 6.81733429e-01f, -9.40723836e-01f, 8.21307063e-01f, 6.90830767e-01f, -7.48352408e-01f, -1.56352203e-02f, -8.49395394e-01f, 9.31099832e-01f, 2.24462692e-02f,
  1.00856054e+00f, 9.65957195e-02f, 7.29903102e-01f, 4.36067164e-01f, 7.58555412e-01f, -3.97225589e-01f, 1.27231881e-01f, 8.13750148e-01f, -5.93928635e-01f, 4.67394650e-01f,
  -2.76613861e-01f, -1.54872254e-01f, 4.52674747e-01f, 5.36498785e-01f, 4.38559264e-01f, 2.74286419e-01f, 6.84832454e-01f, 6.89306855e-01f, 6.02540560e-02f, 4.03735340e-01f,
  2.53865808e-01f, 7.33873427e-01f, 5.40035367e-01f, 2.16808617e-01f, 6.31309211e-01f, 8.61337483e-01f, 2.71528929e-01f, 1.98731467e-01f, -4.67983931e-01f, -1.33917093e-01f,
  -6.36071324e-01f, -6.21732771e-01f, -1.72807872e-01f, 3.06043923e-01f, 1.73486561e-01f, -7.39868879e-01f, 6.33186162e-01f, 6.97090030e-01f, 4.11985964e-02f, -5.01207769e-01f,
  6.36319637e-01f, 3.53662550e-01f, 3.32623452e-01f, 8.04815769e-01f, 1.77142352e-01f, -2.79955417e-02f, -1.74598783e-01f, -1.48015663e-01f, -4.22150016e-01f, 8.06504041e-02f,
  -2.28955969e-01f, 9.56894010e-02f, 2.22647768e-02f, -1.97841917e-04f, -1.54944986e-01f, -1.74427807e-01f, 4.64204401e-01f, -5.79965889e-01f, 1.60719886e-01f, 6.06686652e-01f,
  5.88211305e-02f, -6.42511666e-01f, -3.37128043e-01f, -7.37229139e-02f, 2.79235780e-01f, -2.38767248e-02f, 6.16499007e-01f, 3.24073166e-01f, 6.44176900e-01f, 9.45696592e-01f,
  -6.11746870e-02f, -1.83513001e-01f, 4.89431143e-01f, -5.89082062e-01f, 7.72939622e-02f, -1.71470910e-01f, 1.64386585e-01f, 4.30464119e-01f, -1.02680810e-01f, 2.99554974e-01f,
  -1.82575002e-01f, 1.07232228e-01f, 3.22606951e-01f, 2.18184322e-01f, 2.19284490e-01f, -4.99509662e-01f, 9.34813693e-02f, 1.69421375e-01f, 5.66702843e-01f, -2.74921894e-01f,
  3.64715725e-01f, -1.57138437e-01f, 7.70864427e-01f, 7.70980299e-01f, -6.46240294e-01f, -2.80674279e-01f, -4.35380489e-01f, 7.63499260e-01f, 1.01908475e-01f, 5.05886614e-01f,
  -3.75513524e-01f, -3.54542285e-01f, 1.09408379e+00f, 6.79990232e-01f, 5.77632368e-01f, 8.41772437e-01f, -4.59797159e-02f, 8.01423192e-02f, 3.60962152e-01f, 2.10148647e-01f,
  5.41910946e-01f, 3.45866233e-01f, 8.98332894e-02f, 6.92240477e-01f, 2.71810323e-01f, 6.99186862e-01f, 4.52446610e-01f, 3.65193456e-01f, 5.33213496e-01f, -2.26369664e-01f,
  -2.25151420e-01f, -2.05395192e-01f, -8.42813253e-01f, 1.95448250e-01f, -3.91681284e-01f, 9.83297974e-02f, 2.21927777e-01f, -3.49906236e-01f, -4.09077615e-01f, -2.97205120e-01f,
  -8.28225911e-01f, 4.76448610e-02f, -2.57911354e-01f, -1.37586847e-01f, 6.15658343e-01f, 2.60568053e-01f, 1.48280129e-01f, 3.44336450e-01f, 1.27602053e+00f, 2.65984654e-01f,
  -1.42931372e-01f, 5.86833417e-01f, -3.92327279e-01f, 3.78273278e-01f, -8.90337706e-01f, -7.52845228e-01f, 1.64628372e-01f, 2.47424021e-01f, -6.94841683e-01f, 4.11698431e-01f,
  8.88919979e-02f, 2.22279891e-01f, -3.34239751e-01f, -2.43979633e-01f, 2.52558768e-01f, 3.10321301e-01f, -1.08295597e-01f, -6.44362390e-01f, 5.02615750e-01f, 2.49658436e-01f,
  7.91995943e-01f, 2.31152311e-01f, 7.04886243e-02f, 4.59845632e-01f, 3.07963818e-01f, 4.65721548e-01f, 1.82557315e-01f, 7.55906403e-01f, 1.58329427e-01f, -5.32707013e-02f,
  2.79576987e-01f, -9.00094330e-01f, -6.00160519e-03f, -1.55284390e-01f, -2.42215499e-01f, 6.81780875e-02f, -4.12785709e-02f, -1.14760980e-01f, -3.38654369e-01f, -4.38175678e-01f,
  3.24764512e-02f, -8.64760652e-02f, -1.98373660e-01f, -4.92277928e-03f, 4.35689479e-01f, 3.96379143e-01f, 9.20018971e-01f, 4.65088189e-01f, 8.04395199e-01f, -4.45885748e-01f,
  -4.05710995e-01f, -2.03566507e-01f, 1.68452248e-01f, 7.94485390e-01f, 3.94915193e-01f, -7.10318089e-02f, 7.58993626e-01f, 3.58528435e-01f, 1.91298470e-01f, 3.74761522e-01f,
  5.96501648e-01f, 3.31690669e-01f, -9.71203983e-01f, 3.09903137e-02f, 9.93274003e-02f, -2.70708561e-01f, 4.03154194e-01f, 4.01700139e-01f, -1.91908389e-01f, 2.35588148e-01f,
  5.47245070e-02f, 1.67978033e-01f, 7.22560585e-01f, 4.15671915e-02f, 1.94868296e-01f, 4.81934547e-01f, -8.47095609e-01f, -5.23839056e-01f, -4.17506695e-01f, 1.79916501e-01f,
  2.94054300e-01f, -9.81565267e-02f, 6.18438900e-01f, -3.77125293e-01f, -4.63147499e-02f, -5.57775021e-01f, -5.85789561e-01f, 3.94701332e-01f, -3.94628584e-01f, -3.88031602e-01f,
  5.96194565e-01f, 3.11135292e-01f, -3.05852294e-01f, 1.59581482e-01f, 7.05356121e-01f, 2.54066885e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  6.24642968e-01f, 3.41408074e-01f, 2.09559992e-01f, -3.93689871e-02f, 5.29617667e-01f, 1.03619792e-01f, 2.28242218e-01f, 3.14769298e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.12693578e-02f, -1.62179917e-01f, -5.37950337e-01f, 1.61982134e-01f, 3.99305940e-01f, 2.18157887e-01f, -1.11431219e-01f, 3.36805671e-01f, 1.95337869e-02f, 3.35777789e-01f,
  -3.50889832e-01f, 1.07070096e-01f, 4.02286619e-01f, -5.72467208e-01f, -2.31043592e-01f, -3.88532549e-01f, -7.36358464e-01f, 5.60493171e-01f, 3.93496871e-01f, -2.56255329e-01f,
  4.18215752e-01f, -3.17312300e-01f, 5.17608345e-01f, -1.57988101e-01f, -7.71952033e-01f, 4.22712475e-01f, -1.41612440e-01f, -1.06721044e+00f, 5.12129545e-01f, -1.67158097e-01f,
  -5.35144150e-01f, -6.54334307e-01f, -1.03123061e-01f, -3.64732966e-02f, -4.56905127e-01f, 6.58722401e-01f, 2.76326329e-01f, 2.84817427e-01f, 4.27867085e-01f, -1.89339742e-01f,
  6.11728966e-01f, 1.46030456e-01f, -1.32323936e-01f, 3.77689153e-02f, -1.06275283e-01f, -5.26756644e-01f, 1.10543333e-01f, -4.51340914e-01f, 5.23596220e-02f, -4.00621563e-01f,
  4.73556817e-01f, -2.71509141e-01f, 2.83978526e-02f, 6.70026183e-01f, 1.80407450e-01f, 6.54273391e-01f, -4.18077886e-01f, 2.33433336e-01f, 3.53541881e-01f, -3.34053993e-01f,
  -1.01566339e+00f, -8.58115673e-01f, 4.29369092e-01f, -3.37992936e-01f, -7.36145675e-02f, -8.57648731e-04f, -1.95185229e-01f, 3.59493196e-01f, 2.51954556e-01f, -4.79916155e-01f,
  -3.01632762e-01f, -1.39665961e-01f, 3.82829785e-01f, 6.45631999e-02f, 3.89805064e-02f, 2.38283455e-01f, 2.48814359e-01f, 3.99381608e-01f, -4.21499610e-01f, -2.03117326e-01f,
  4.85581011e-01f, -4.67371047e-01f, -3.43768358e-01f, 4.55828488e-01f, -4.17944908e-01f, 6.88307762e-01f, 1.57639623e-01f, -4.04118329e-01f, 4.82842565e-01f, -1.53064281e-01f,
  -2.48758182e-01f, -5.64559221e-01f, -8.70697021e-01f, 3.52659553e-01f, 2.55044937e-01f, -6.82736874e-01f, -1.53693715e-02f, -1.66685522e-01f, -1.30790239e-02f, -2.12471858e-01f,
  5.07566392e-01f, 3.21373016e-01f, -5.66452861e-01f, -5.21649420e-01f, -3.49036902e-01f, 1.01156913e-01f, 1.45531937e-01f, -2.67707914e-01f, 3.52803797e-01f, -3.15965116e-01f,
  -3.32295984e-01f, 4.26121622e-01f, -5.83220087e-02f, 3.02945733e-01f, -4.48825121e-01f, 1.25192702e-01f, 3.32353085e-01f, 6.42248541e-02f, -3.80588905e-03f, -4.56360519e-01f,
  -5.71418554e-02f, -7.25316584e-01f, 7.16715679e-02f, 1.17538303e-01f, 2.92068332e-01f, 1.09149709e-01f, -8.63992035e-01f, 3.69568765e-01f, 5.35943866e-01f, -2.45507672e-01f,
  -3.64188790e-01f, -3.04817289e-01f, -1.01283126e-01f, 2.66254116e-02f, 2.36516327e-01f, -1.40959159e-01f, -4.33496386e-01f, 7.73551613e-02f, -1.26567790e-02f, -7.54866123e-01f,
  -6.47615612e-01f, 5.93025804e-01f, 7.95018137e-01f, 4.25742656e-01f, 3.06389838e-01f, 4.26099002e-01f, 1.13119863e-01f, 8.03781569e-01f, -3.99212688e-02f, -3.78864259e-01f,
  7.03673065e-01f, -2.13348508e-01f, -5.97505927e-01f, 9.04738829e-02f, -4.46643889e-01f, 2.73770422e-01f, 2.94719189e-01f, -7.86643386e-01f, -6.83779478e-01f, 2.44320929e-01f,
  -4.91506398e-01f, 3.75695199e-01f, -1.14518352e-01f, -6.31244719e-01f, -1.59224331e-01f, -3.87338251e-01f, -4.53597784e-01f, -3.75942923e-02f, -4.05677497e-01f, -3.91919583e-01f,
  2.80263722e-01f, 2.91357249e-01f, 3.34867507e-01f, -2.12289214e-01f, -1.26091585e-01f, 4.25851822e-01f, 6.60692036e-01f, 1.19095080e-01f, 2.94177324e-01f, -7.01872170e-01f,
  1.76527992e-01f, -4.45371300e-01f, 1.34380236e-01f, -3.73223454e-01f, -7.61412501e-01f, 2.35470414e-01f, -3.29241365e-01f, 1.59354597e-01f, -1.40208215e-01f, -5.30464470e-01f,
  3.68911773e-01f, -4.32778805e-01f, 2.17433482e-01f, -4.16428298e-01f, 3.97502452e-01f, -3.23392749e-01f, -1.27574354e-01f, 5.51029742e-01f, 3.48958254e-01f, -2.18999177e-01f,
  -1.26624778e-01f, 4.88494784e-01f, -1.41767234e-01f, 5.69207259e-02f, 1.67209640e-01f, 9.90696624e-02f, 2.12757915e-01f, 8.82714987e-02f, 1.93580002e-01f, -5.94828904e-01f,
  -4.41915154e-01f, 5.69162369e-01f, 4.60945308e-01f, 7.57267296e-01f, -6.78685963e-01f, -1.54888108e-01f, 1.44694716e-01f, -1.09286636e-01f, -7.16884196e-01f, 5.95866382e-01f,
  -1.70518160e-01f, -6.39396429e-01f, 1.44616127e-01f, -5.43386936e-01f, -3.91402781e-01f, 4.79966074e-01f, 3.06358874e-01f, 1.70917481e-01f, -3.00003558e-01f, -3.64390314e-01f,
  2.89083093e-01f, 3.43403697e-01f, -2.64233321e-01f, -2.30345100e-01f, -3.95985365e-01f, 3.93332154e-01f, -4.39078897e-01f, 4.40342426e-01f, -4.19739962e-01f, -5.73617518e-01f,
  3.12512189e-01f, 2.97589779e-01f, 3.61819476e-01f, -7.34641910e-01f, 4.29221064e-01f, -6.57132640e-03f, -6.82937980e-01f, 4.30990309e-01f, -9.09938157e-01f, -8.52530658e-01f,
  5.39948158e-02f, -5.68506606e-02f, 4.74776536e-01f, -5.89439869e-01f, -4.57513362e-01f, 6.54151559e-01f, -2.61258364e-01f, -2.07398653e-01f, 5.06997645e-01f, -1.60932794e-01f,
  2.02603534e-01f, -4.57436502e-01f, 6.85423091e-02f, -1.39557794e-01f, -3.19696099e-01f, -3.51086795e-01f, -3.31335068e-01f, -4.53292370e-01f, -2.28185523e-02f, -4.94334936e-01f,
  1.94159195e-01f, 5.27316988e-01f, -4.35037494e-01f, 9.23145190e-02f, -5.18304706e-01f, -2.70914454e-02f, 2.33236030e-01f, 3.62590939e-01f, -4.75995481e-01f, 1.96400806e-01f,
  -2.70275563e-01f, -1.02357753e-01f, 4.97469723e-01f, -8.32155824e-01f, -6.19985521e-01f, 4.65634078e-01f, 1.31960586e-01f, -4.13322300e-01f, 1.00717068e-01f, 3.75229269e-01f,
  5.53972483e-01f, 1.67414665e-01f, -5.12830138e-01f, -8.39093328e-02f, 2.30757132e-01f, 4.81752902e-01f, 6.02408051e-01f, 9.92518663e-02f, 4.28680509e-01f, 3.29141259e-01f,
  2.67379642e-01f, 3.40864539e-01f, -2.11618930e-01f, -3.19986433e-01f, 2.23638684e-01f, 4.56366569e-01f, 6.34864926e-01f, 1.58771992e-01f, -4.05175835e-02f, -4.69645232e-01f,
  -3.61759186e-01f, -3.27117354e-01f, 4.87022907e-01f, 1.84259072e-01f, -8.80273998e-01f, -6.59340620e-01f, 1.55530542e-01f, -4.69195336e-01f, -6.74137354e-01f, 1.42009944e-01f,
  -4.97955561e-01f, -1.87132820e-01f, -1.41668618e-01f, -1.80056617e-01f, -3.14591527e-01f, 2.05847085e-01f, 1.02420211e-01f, 2.18292326e-01f, 2.24797707e-02f, -1.16420925e-01f,
  1.42401576e-01f, 1.58804417e-01f, -5.97936571e-01f, 1.04023263e-01f, -1.14690930e-01f, -3.55246127e-01f, -6.21420145e-01f, 2.16209054e-01f, -2.49331400e-01f, 3.91433239e-01f,
  -7.56804287e-01f, -5.32476187e-01f, -7.45213479e-02f, 7.39366770e-01f, 2.97598809e-01f, -8.91498387e-01f, -7.65664041e-01f, 7.96667188e-02f, -2.20620066e-01f, 4.97894526e-01f,
  1.47895843e-01f, -3.98220345e-02f, 4.97417480e-01f, 4.17621493e-01f, 1.38941616e-01f, 3.25751811e-01f, -3.11341107e-01f, 2.88781852e-01f, -2.66891450e-01f, 2.92569637e-01f,
  2.63793141e-01f, 2.28660822e-01f, -5.35072163e-02f, -2.16822773e-01f, 3.46192211e-01f, 2.15870425e-01f, -2.98149467e-01f, 4.35827613e-01f, -4.27051604e-01f, -4.33721960e-01f,
  -9.67242122e-02f, -5.77518225e-01f, -1.81867763e-01f, -3.00493002e-01f, -1.11088924e-01f, 5.01155794e-01f, -3.27936113e-01f, -3.77321869e-01f, 1.11257173e-01f, 3.68158609e-01f,
  -2.85062701e-01f, 4.48898017e-01f, 1.28298700e-01f, -5.61089933e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  9.79719087e-02f, -1.02247037e-01f, 2.16205865e-01f, -2.08652675e-01f, -1.32950572e-02f, -5.62349558e-02f, -4.05038260e-02f, 1.86596781e-01f, -2.63880879e-01f, 2.78062344e-01f,
  -4.91846874e-02f, -3.02036200e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    