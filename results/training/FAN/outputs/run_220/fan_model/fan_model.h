/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.79942250e-01f, -8.22311044e-02f, 5.24922162e-02f, 8.85087624e-02f, 4.01311703e-02f, 2.51146346e-01f, 1.04599759e-01f, 4.42450568e-02f, -1.14255935e-01f, 8.95375758e-02f,
  -1.06158972e-01f, -2.04447340e-02f, -1.96592197e-01f, 1.53517336e-01f, -2.73213446e-01f, -4.48973663e-02f, 3.62396836e-02f, 4.38639112e-02f, -1.47778422e-01f, 9.11097303e-02f,
  -5.52326031e-02f, -8.72863515e-04f, 4.35248157e-03f, 8.10958073e-03f, 1.06970489e-01f, 3.62950824e-02f, -1.21303931e-01f, -1.23326639e-02f, -2.40041353e-02f, -9.67414118e-03f,
  -1.25429645e-01f, 6.81866780e-02f, 8.61781538e-02f, 4.34224233e-02f, 1.01995487e-02f, 2.79853418e-02f, 3.66161577e-02f, -1.53977852e-02f, -3.13511267e-02f, -1.29834684e-02f,
  2.64987648e-02f, -5.91554865e-02f, 2.50648540e-02f, -5.67863062e-02f, 1.99436862e-02f, -4.33771685e-02f, 2.73730028e-02f, 3.86761576e-02f, 1.89482681e-02f, -6.29806072e-02f,
  6.62906514e-03f, -9.11669398e-04f, 9.20222774e-02f, -2.36895438e-02f, 7.54036531e-02f, 2.03886237e-02f, -9.04569216e-03f, 5.79738654e-02f, 3.67137492e-02f, -5.53751215e-02f,
  4.58694212e-02f, -4.34061363e-02f, 7.90794194e-03f, -2.27935314e-02f, -3.79046760e-02f, -5.17550437e-03f, 4.40494157e-02f, -5.51925004e-02f, -7.32000768e-02f, -3.35586704e-02f,
  3.50611564e-03f, -5.30396169e-03f, 2.62608193e-02f, -1.50964828e-03f, -4.81908210e-02f, 4.79675308e-02f, -4.67256568e-02f, 4.55093458e-02f, -3.38851474e-02f, -4.43272898e-03f,
  1.16254576e-02f, -3.16800214e-02f, 2.28136797e-02f, 4.77971323e-02f, -2.59096436e-02f, 3.41905653e-02f, 1.05632767e-02f, -2.13738773e-02f, 5.41540682e-02f, 1.11703062e-02f,
  -4.49530175e-03f, -6.46868795e-02f, -2.89341584e-02f, -1.99454371e-02f, -8.28379914e-02f, 7.68983550e-03f, -2.89645977e-02f, 6.97197691e-02f, -4.39100862e-02f, 3.60069126e-02f,
  6.53050020e-02f, 6.00651093e-02f, -4.79920506e-02f, -1.72176380e-02f, 2.70080026e-02f, 1.70369986e-02f, -4.06890502e-03f, 1.07171349e-02f, 3.94589230e-02f, -8.86478368e-03f,
  -1.47415828e-02f, 1.53810838e-02f, -3.74768712e-02f, 4.87293825e-02f, -3.28809768e-02f, 8.44270084e-03f, -6.95380270e-02f, -1.37616042e-02f, -3.06531377e-02f, -3.94571433e-03f,
  -4.30699170e-01f, 5.16381525e-02f, -2.22665817e-01f, 2.28384167e-01f, -3.95363495e-02f, 2.17160240e-01f, 1.73769727e-01f, -7.69123957e-02f, -5.52563854e-02f, -8.53489116e-02f,
  -1.27877370e-02f, 1.00937756e-02f, -1.62554368e-01f, 2.84026176e-01f, 2.47031465e-01f, 1.15331180e-01f, 2.99923748e-01f, 2.25004498e-02f, 7.76837021e-02f, -3.39143723e-02f,
  9.95955318e-02f, 2.19674379e-01f, 5.49656749e-02f, 1.91656440e-01f, -3.57152410e-02f, -3.46741006e-02f, -1.84388146e-01f, -6.55249879e-02f, 1.14922591e-01f, 2.98731811e-02f,
  2.20551819e-01f, -1.93563662e-02f, -1.12564474e-01f, 2.57779728e-03f, -3.95683162e-02f, -1.24528266e-01f, -7.12113157e-02f, 3.55133079e-02f, 6.53809756e-02f, 5.19762896e-02f,
  -2.83052176e-02f, 5.03731556e-02f, 5.37992567e-02f, -2.64655389e-02f, -5.18338233e-02f, 8.91005397e-02f, 5.09430701e-03f, -3.17028128e-02f, 1.16841979e-02f, 2.07645055e-02f,
  3.67237926e-02f, -5.12446500e-02f, -3.79000157e-02f, 2.71223336e-02f, -2.34737974e-02f, 7.22175762e-02f, 3.00924927e-02f, -5.21358065e-02f, -5.06600253e-02f, -2.57204361e-02f,
  -6.87394962e-02f, -2.47607082e-02f, -6.39759228e-02f, -2.76628435e-02f, -2.77241953e-02f, -4.77363132e-02f, -3.89925390e-02f, 4.30595176e-03f, -5.11035174e-02f, 2.94334833e-02f,
  -2.77423207e-02f, -5.39840125e-02f, -1.44270379e-02f, -2.67701373e-02f, 6.24588132e-02f, -6.20856099e-02f, -2.18400750e-02f, -1.13880895e-02f, 2.51014829e-02f, 2.58644279e-02f,
  7.63193741e-02f, -4.36742045e-02f, 8.11797939e-03f, -3.47532444e-02f, 4.75820601e-02f, -4.40263860e-02f, 2.06657276e-02f, -8.06002691e-02f, -7.04288110e-02f, -2.33020838e-02f,
  3.25859301e-02f, -1.78892180e-01f, 5.92353474e-03f, 6.83258101e-02f, 3.92037891e-02f, 9.85921081e-03f, 2.70556696e-02f, 1.05851348e-02f, -3.36571783e-02f, -4.10557166e-02f,
  -1.24130193e-02f, 3.93706141e-03f, -3.31677385e-02f, 6.06339760e-02f, 2.02410333e-02f, -5.71603850e-02f, 1.61222629e-02f, -3.36782113e-02f, -7.06862286e-02f, 5.93775930e-03f,
  -5.02208769e-02f, -2.54924931e-02f, -1.71169173e-02f, -3.51373293e-02f, 4.45011817e-02f, -6.14362098e-02f, -4.26875660e-03f, 5.82012236e-02f, -5.26988413e-03f, -2.72606108e-02f,
  4.92269069e-01f, 2.68584162e-01f, -1.49814598e-02f, 1.52187884e-01f, -2.88827717e-02f, -2.45238803e-02f, -1.81145296e-02f, 1.06196232e-01f, -2.33520746e-01f, 6.56123906e-02f,
  -5.62038384e-02f, 4.81786057e-02f, -6.27287850e-02f, -2.21408140e-02f, -2.64302701e-01f, -1.31101936e-01f, 7.24486634e-03f, 5.94729967e-02f, -1.08454794e-01f, 1.21826671e-01f,
  -4.90245149e-02f, 2.74025351e-02f, 3.66978571e-02f, -2.96709687e-02f, 1.87690005e-01f, 1.57920316e-01f, 2.84108557e-02f, -3.63738202e-02f, 1.17300674e-01f, -7.26660267e-02f,
  -3.90087627e-02f, 1.25758424e-01f, 2.33285129e-02f, 1.93560570e-02f, 1.09531291e-01f, 4.44227345e-02f, 8.83136317e-02f, -1.23356069e-02f, -5.03471009e-02f, -5.81811480e-02f,
  2.21999176e-03f, 5.93812875e-02f, -3.54805845e-03f, -8.93365294e-02f, -1.81139242e-02f, 3.71015556e-02f, -2.61591300e-02f, 4.17169556e-02f, 1.16224590e-04f, 6.54254528e-03f,
  2.64113974e-02f, 7.48178959e-02f, 4.52968329e-02f, -2.00978182e-02f, 1.08138388e-02f, -1.64665849e-04f, 5.80988713e-02f, 2.89623700e-02f, 6.16574064e-02f, 5.00693098e-02f,
  2.99993232e-02f, -2.85881236e-02f, -6.53447816e-03f, 4.59640734e-02f, -1.19601442e-02f, -2.81059812e-03f, -1.78858992e-02f, 2.58366112e-03f, 9.61385015e-03f, 6.94664661e-03f,
  -1.05857849e-02f, 2.26382148e-02f, 1.48961255e-02f, 2.12676376e-02f, 3.62038650e-02f, 2.73167770e-02f, 1.70043930e-02f, 3.10324077e-02f, -2.07294710e-02f, 2.88941078e-02f,
  5.74118830e-02f, -1.06415795e-02f, 4.67190407e-02f, 1.01768523e-02f, -5.38787246e-02f, -4.54141498e-02f, 1.68770850e-02f, -1.71619151e-02f, -7.03352168e-02f, -5.24870493e-03f,
  1.68103546e-01f, 1.86844096e-01f, -4.97535244e-02f, 6.36717305e-02f, -9.83315483e-02f, -1.01723827e-01f, -1.08791038e-01f, -1.33721335e-02f, 3.18708867e-02f, -1.14125414e-02f,
  1.07056923e-01f, 4.62575903e-04f, 3.41545083e-02f, 3.68464068e-02f, -7.72605538e-02f, -2.71625407e-02f, 4.44828756e-02f, 2.49530226e-02f, 1.85059998e-02f, 9.06269774e-02f,
  7.97371864e-02f, 6.13440573e-03f, -3.70480530e-02f, 3.87943424e-02f, 3.71668786e-02f, 4.75588739e-02f, -1.01599470e-02f, 2.81774141e-02f, -1.41625237e-02f, -4.19665165e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.19238591e-01f, -3.72214578e-02f, 2.44237289e-01f, 4.22047228e-01f, 9.01420936e-02f, -4.43080664e-02f, 4.71740551e-02f, 9.00188759e-02f, 3.95852894e-01f, -1.10046081e-01f,
  7.24870488e-02f, 1.29559651e-01f, -1.66985065e-01f, 2.87477851e-01f, -8.86380896e-02f, -2.21513510e-02f, 2.11197644e-01f, 1.71748638e-01f, 2.42861919e-02f, 1.27615914e-01f,
  1.29924491e-01f, -2.17606127e-02f, -9.51670110e-02f, -1.49883628e-01f, 7.02044517e-02f, 4.72072838e-03f, -3.00027251e-01f, -1.91343546e-01f, -1.13196939e-01f, -1.52933240e-01f,
  -5.54270446e-02f, 3.40233445e-02f, -5.20769767e-02f, -4.02558595e-02f, 1.82171594e-02f, -4.47949506e-02f, -3.42446938e-02f, -1.52145132e-01f, 2.90350784e-02f, 5.70960045e-02f,
  4.56066467e-02f, -4.07623015e-02f, 1.00036211e-01f, 4.71363496e-03f, -1.21892132e-02f, 5.71746342e-02f, 5.77829219e-02f, 3.41053568e-02f, 3.72642837e-02f, 4.49088514e-02f,
  2.69340561e-03f, -1.14022745e-02f, 7.68091679e-02f, -5.95066026e-02f, 4.51311981e-03f, 6.22136220e-02f, 7.36738443e-02f, -3.24182548e-02f, 2.86344942e-02f, -6.12774082e-02f,
  -7.32800663e-02f, -1.14813857e-01f, -3.50399092e-02f, -2.99710743e-02f, 2.25565676e-03f, -6.56344695e-03f, 1.90717280e-02f, 4.00269777e-02f, 6.72325268e-02f, 8.12289771e-03f,
  3.30483243e-02f, 3.31511386e-02f, 7.70022795e-02f, -4.41190414e-02f, 8.67219046e-02f, 4.26745377e-02f, -4.12832648e-02f, 7.45206773e-02f, 1.17633596e-01f, -3.46143171e-02f,
  2.71810573e-02f, -2.11657165e-03f, 1.20876934e-02f, -2.11535972e-02f, 3.91645990e-02f, 4.37624333e-03f, 5.65117076e-02f, 4.13110591e-02f, 1.70961227e-02f, -2.98393946e-02f,
  5.13496399e-02f, -1.00140870e-01f, 2.98318919e-03f, -1.30947651e-02f, 2.77679451e-02f, 7.13999942e-02f, 1.75883214e-03f, 1.06075510e-01f, -1.19144604e-01f, -6.10425249e-02f,
  -9.38056111e-02f, 4.96198721e-02f, -8.47419649e-02f, -2.50394233e-02f, 2.25449614e-02f, 1.72506347e-02f, -1.12265144e-02f, -6.92253485e-02f, 1.42121175e-02f, -5.70348762e-02f,
  4.45137434e-02f, -4.30119270e-03f, -5.27189262e-02f, -1.66129787e-02f, 5.26358709e-02f, -4.76129241e-02f, 3.21729928e-02f, -4.82700579e-02f, -6.64493442e-02f, 7.61830881e-02f,
  3.21453929e-01f, 1.63355380e-01f, -4.89707328e-02f, 1.55696981e-02f, 2.89344620e-02f, 2.01483175e-01f, 8.71009976e-02f, 1.06506318e-01f, 1.41694471e-01f, 1.67069241e-01f,
  -3.84996384e-02f, 4.41619903e-02f, -1.60195470e-01f, 1.30236432e-01f, 4.12079766e-02f, -6.92436844e-02f, 1.00437865e-01f, 4.87242080e-02f, -6.00063838e-02f, 4.48915064e-02f,
  -2.29354128e-02f, -5.38385026e-02f, -1.05265133e-01f, -1.66921586e-01f, -6.19231127e-02f, -6.70768470e-02f, -1.95794597e-01f, -1.75886124e-01f, -3.54593759e-03f, -6.24385625e-02f,
  5.06945001e-03f, 5.47313355e-02f, 8.66777599e-02f, 1.19857788e-01f, -3.74042839e-02f, 8.94531533e-02f, -1.96324904e-02f, 2.13557966e-02f, -3.12599936e-03f, 5.20504452e-02f,
  2.97160894e-02f, 8.71767569e-03f, 9.10797566e-02f, -9.74554718e-02f, 1.20141990e-01f, -7.25990385e-02f, -4.75305691e-02f, -4.09380160e-02f, -1.30053870e-02f, 4.86001791e-03f,
  -4.33566310e-02f, -5.11045158e-02f, 3.04029323e-02f, -5.59991710e-02f, -3.62438671e-02f, 3.03920005e-02f, -2.07961258e-02f, -5.71544468e-02f, 3.36670652e-02f, 1.32425979e-01f,
  -3.37691978e-02f, 1.39284685e-01f, 4.68991324e-02f, -3.38930413e-02f, 1.70332436e-02f, -2.20823800e-03f, -2.01756191e-02f, -9.34162810e-02f, -9.64670032e-02f, -3.47609334e-02f,
  -4.53089178e-02f, -3.23513076e-02f, -3.41564938e-02f, 1.19091617e-03f, 8.69312510e-02f, -1.31034944e-02f, 3.82984020e-02f, -3.51540111e-02f, 8.02841689e-03f, -2.11787913e-02f,
  -3.87202203e-02f, 5.57165854e-02f, -2.43752301e-02f, 9.96450707e-03f, 1.11636315e-02f, 5.38882986e-02f, -8.29551443e-02f, -5.36200637e-03f, 5.38286529e-02f, -7.44655402e-03f,
  1.31935000e-01f, -5.68451881e-02f, 8.41090977e-02f, 1.29971281e-01f, 5.98090515e-02f, 4.87863719e-02f, -3.49277146e-02f, 6.32988736e-02f, -6.43346682e-02f, 1.51375504e-02f,
  1.19600616e-01f, -5.29775908e-03f, -5.17834835e-02f, 5.52570522e-02f, -2.45674569e-02f, 3.26115675e-02f, 1.29339406e-02f, 5.85400760e-02f, 6.40299916e-02f, -3.99202593e-02f,
  2.91070435e-02f, 3.65918018e-02f, -1.20933331e-03f, -2.18246747e-02f, -4.14895490e-02f, -9.82404351e-02f, -2.70079691e-02f, -2.93828808e-02f, -1.01314280e-02f, -7.83814304e-03f,
  8.94802734e-02f, 2.52211571e-01f, 1.96820483e-01f, 7.13888630e-02f, -9.58339050e-02f, -1.95381343e-01f, -4.39312421e-02f, 2.55713873e-02f, 6.68125451e-02f, 1.42423183e-01f,
  -3.26603912e-02f, 1.22313119e-01f, 9.06468406e-02f, -9.73049402e-02f, 1.04712553e-01f, -1.30765587e-01f, 6.22630976e-02f, -1.37697518e-01f, 8.37597847e-02f, 8.22950378e-02f,
  -6.27007410e-02f, 5.05245179e-02f, 1.50978073e-01f, 8.54483321e-02f, 3.72400843e-02f, 1.28929660e-01f, 1.44685999e-01f, 3.59365828e-02f, 2.60933340e-02f, -4.61150473e-03f,
  -1.05102964e-01f, -4.69784699e-02f, 3.31393071e-02f, -1.39304511e-02f, 1.18869869e-02f, -3.66176628e-02f, -7.44944289e-02f, -5.45505658e-02f, 7.76463747e-02f, 2.15933286e-02f,
  -2.63530910e-02f, -8.37034266e-03f, 2.01519821e-02f, -6.62332401e-02f, -5.39722061e-03f, 8.09573382e-02f, 1.49397394e-02f, -9.64980479e-03f, 3.37844156e-02f, -4.30541597e-02f,
  -1.82956774e-02f, -1.37278745e-02f, 7.86371622e-03f, 2.24201977e-02f, 9.44702607e-03f, -6.50981516e-02f, -4.77666557e-02f, 3.87875848e-02f, -4.57042502e-03f, -5.37230149e-02f,
  9.89764649e-03f, 5.62600791e-02f, -3.33849378e-02f, 4.93120626e-02f, 2.00994383e-03f, -8.01130664e-03f, -3.92004382e-03f, 1.40858078e-02f, -4.65617031e-02f, 4.66208979e-02f,
  2.85087293e-03f, 3.06923185e-02f, -1.06492281e-01f, -1.04634010e-03f, 1.76648013e-02f, -5.23761511e-02f, -2.19936818e-02f, -6.18479177e-02f, -4.01956402e-02f, -2.11205464e-02f,
  2.26562638e-02f, 2.53928751e-02f, -2.16933955e-02f, -7.90876076e-02f, 3.17953862e-02f, -4.83937711e-02f, 1.99520309e-02f, 2.37984359e-02f, 2.51418315e-02f, 2.50849482e-02f,
  -3.25520933e-02f, 2.41158560e-01f, -1.39708514e-03f, -3.94078307e-02f, -6.36201575e-02f, 6.59349049e-03f, 1.97313465e-02f, -3.34171578e-02f, 8.61534923e-02f, 9.62416902e-02f,
  -7.95839354e-03f, -2.50244737e-02f, -5.39908707e-02f, -3.98786440e-02f, 2.70825010e-02f, 3.67880575e-02f, 7.01526552e-02f, 8.21693987e-02f, 2.99924035e-02f, 8.85282606e-02f,
  3.19985338e-02f, 4.77042235e-02f, 4.95035062e-03f, -8.31322931e-03f, 7.28052109e-02f, -4.74315844e-02f, -4.65408564e-02f, 9.60581601e-02f, 8.20633397e-03f, 8.39466378e-02f,
  6.20612979e-01f, -9.08071846e-02f, 2.06385285e-01f, 4.04739976e-01f, 3.63803804e-01f, 3.57058316e-01f, 7.49629080e-01f, 6.81355447e-02f, 4.66891527e-01f, -8.05311054e-02f,
  8.74251686e-03f, -7.28264675e-02f, 7.73514807e-02f, -8.08482468e-02f, 1.87405691e-01f, 1.00452766e-01f, 1.73315823e-01f, 1.92962348e-01f, 6.45086989e-02f, 1.00922287e-01f,
  8.79460126e-02f, 1.36479333e-01f, -1.08513713e-03f, -1.47185013e-01f, 1.09170459e-01f, -5.90311363e-02f, -6.81373328e-02f, 6.87751845e-02f, -2.20332414e-01f, 3.40721942e-02f,
  -8.37765932e-02f, 9.72529873e-02f, -6.88934401e-02f, -2.98654307e-02f, -3.82831991e-02f, -5.04654832e-02f, 3.68683296e-03f, 2.31039431e-03f, 2.83208899e-02f, -2.13506706e-02f,
  -2.40289178e-02f, -7.05913752e-02f, -2.60077249e-02f, 3.75303999e-02f, 6.94304556e-02f, -6.65849894e-02f, -5.55766709e-02f, -3.08316182e-02f, 1.67924184e-02f, -6.75571486e-02f,
  -6.07985817e-03f, -7.07358494e-02f, 7.15238824e-02f, -4.64316681e-02f, 9.44010392e-02f, 6.67077973e-02f, 3.93313468e-02f, -6.47516772e-02f, 4.43496974e-03f, 9.61260032e-03f,
  -4.36727777e-02f, 3.80545445e-02f, -3.30994911e-02f, -3.87455858e-02f, 1.40146923e-03f, -4.82365675e-02f, -4.86100614e-02f, -2.80893687e-02f, -4.00078744e-02f, 1.02676094e-01f,
  2.73276549e-02f, 6.12989860e-03f, -1.12851644e-02f, 3.37301642e-02f, -5.89184985e-02f, -3.97428498e-02f, 1.39974561e-02f, -7.25889727e-02f, 5.74099645e-03f, 1.25168813e-02f,
  3.50522026e-02f, 3.37082297e-02f, -8.62754807e-02f, -6.36122329e-03f, -4.71101841e-03f, 3.86104570e-03f, -4.39424217e-02f, -2.21893992e-02f, 3.76135053e-04f, -3.46385385e-03f,
  1.26773089e-01f, 1.71306789e-01f, -6.07422665e-02f, -4.48245481e-02f, -5.60876913e-02f, -1.03445798e-01f, 1.45974588e-02f, 6.91826716e-02f, 4.28346321e-02f, -2.55196802e-02f,
  6.27926439e-02f, 9.89818424e-02f, 3.68295237e-02f, 1.11528272e-02f, -2.70476025e-02f, 2.75354069e-02f, 4.42726053e-02f, 7.22483546e-02f, 4.75298651e-02f, -9.24170017e-02f,
  -7.00876936e-02f, 8.72448981e-02f, -1.54650817e-02f, 9.41243842e-02f, -2.57235505e-02f, 2.54911035e-02f, 2.20055273e-03f, 1.57273039e-02f, -5.59127741e-02f, -3.00218873e-02f,
  2.72719972e-02f, -9.97909978e-02f, -1.09552905e-01f, -1.70610324e-01f, -3.05580169e-01f, -9.42735374e-02f, -1.68629155e-01f, -1.49494037e-01f, -9.59877148e-02f, -5.78755736e-02f,
  1.26023889e-02f, 3.19774561e-02f, 2.25334302e-01f, -2.35310763e-01f, 1.67972937e-01f, 2.16600657e-01f, -1.14374824e-01f, 4.93587665e-02f, -3.60399336e-02f, -4.10810262e-02f,
  4.38486785e-02f, -9.95434523e-02f, -4.26953621e-02f, -6.10842630e-02f, -2.50375360e-01f, -8.69406015e-02f, -5.49750850e-02f, -1.74150407e-01f, -1.40449449e-01f, -8.84441510e-02f,
  1.08697638e-01f, 1.02835871e-01f, -5.68728745e-02f, 1.04787864e-01f, -3.70178558e-02f, -9.74898115e-02f, 1.06946956e-02f, 2.17036605e-02f, -6.28286824e-02f, -1.39598772e-02f,
  5.73922582e-02f, 1.07117511e-01f, -3.83573212e-02f, -3.09615452e-02f, -2.16277279e-02f, 6.66264966e-02f, 4.96294117e-03f, 4.13922686e-03f, 1.16000988e-03f, 7.46202618e-02f,
  -2.34199520e-02f, -2.35253237e-02f, -1.02152705e-01f, -1.56158684e-02f, -2.47520464e-03f, -4.49196901e-03f, -2.67004594e-02f, 8.40609744e-02f, 5.10966871e-04f, -3.62838395e-02f,
  -5.06558232e-02f, -6.88888552e-03f, 2.95505859e-02f, -2.87817866e-02f, 1.45403948e-02f, 6.04349449e-02f, 1.17379334e-02f, 5.29461130e-02f, -4.58458103e-02f, 5.23811439e-03f,
  5.80446795e-02f, -4.40528318e-02f, 6.42210022e-02f, -3.78216170e-02f, -1.98561847e-02f, 4.67405841e-02f, 1.92533880e-02f, -5.44964112e-02f, 6.17449684e-03f, 3.72935385e-02f,
  8.29573646e-02f, 2.60883588e-02f, -3.97951193e-02f, 4.68695946e-02f, -3.21872607e-02f, 3.57146608e-03f, -2.84671299e-02f, -3.04368753e-02f, -2.37150900e-02f, 6.27141595e-02f,
  4.26958948e-02f, -2.36711781e-02f, 1.18605494e-02f, 2.17742473e-02f, -2.73048449e-02f, -1.02021396e-02f, -2.73724571e-02f, -4.10673805e-02f, 2.04987358e-03f, -3.03203762e-02f,
  -1.99202728e-02f, 9.73825343e-03f, -2.46648793e-03f, 9.76648647e-04f, 1.93600766e-02f, -4.16251011e-02f, 2.64895856e-02f, 1.66877490e-02f, 2.82512959e-02f, -1.45949854e-03f,
  7.30891451e-02f, -1.56590890e-04f, 7.13778660e-02f, -1.29827755e-02f, -2.60768700e-02f, 2.14964394e-02f, -7.03118369e-02f, 1.81641448e-02f, -2.27935240e-02f, 1.89550966e-02f,
  6.75565720e-01f, 5.82827590e-02f, 3.31213214e-02f, 3.40875357e-01f, 1.58052087e-01f, -1.22503258e-01f, -1.93569645e-01f, 3.24839354e-01f, 1.81546416e-02f, -7.76675669e-03f,
  2.13487148e-01f, -1.92262739e-01f, -1.27189428e-01f, 1.65722460e-01f, 1.90423250e-01f, -2.13970751e-01f, 3.17899466e-01f, 2.99994256e-02f, 2.82247295e-03f, 2.63530910e-01f,
  2.23001972e-01f, 3.73644739e-01f, 5.87989800e-02f, 2.18092084e-01f, 1.78387150e-01f, 1.20120384e-01f, 3.37270796e-01f, -2.66171619e-02f, 1.78894237e-01f, -5.74463978e-02f,
  -1.67676970e-01f, -8.23179353e-03f, 7.79329836e-02f, -5.74301891e-02f, 8.76470432e-02f, 3.65796573e-02f, -5.16167060e-02f, -1.21438846e-01f, -5.10314964e-02f, -5.41069135e-02f,
  -6.40543103e-02f, 5.88625744e-02f, 4.36137542e-02f, 9.96834189e-02f, -4.38396297e-02f, 2.87391935e-02f, 4.43235552e-03f, -2.36437917e-02f, -1.21635040e-02f, -2.89255567e-02f,
  -5.89011759e-02f, 6.54423237e-02f, 1.57682728e-02f, -7.87721649e-02f, 1.18924767e-01f, 7.95521811e-02f, -1.53138876e-01f, -4.92593609e-02f, -4.92128842e-02f, -3.13243270e-02f,
  8.19470435e-02f, 4.16631286e-04f, -1.24244131e-02f, -8.37673247e-03f, -2.81856656e-02f, -1.71442758e-02f, 2.10599117e-02f, -5.74503317e-02f, -8.68036970e-02f, 3.00288368e-02f,
  4.33454588e-02f, 6.84760325e-03f, 5.89409508e-02f, 1.65667683e-02f, -4.92089316e-02f, 1.07470842e-03f, -1.41163111e-01f, -7.92898610e-02f, 5.17033972e-02f, 4.82028760e-02f,
  -7.74964541e-02f, 9.42702219e-02f, 7.25065023e-02f, 8.95660818e-02f, 4.44140807e-02f, 1.58251484e-03f, 1.45784065e-01f, 1.97517350e-02f, -2.52804141e-02f, -9.35479347e-03f,
  8.82399306e-02f, 3.40966851e-01f, -6.79355636e-02f, -8.96576047e-02f, -7.16385692e-02f, 9.66668874e-03f, 1.59696229e-02f, 1.19606756e-01f, 1.21696278e-01f, 3.05679962e-02f,
  1.05005100e-01f, -7.01999515e-02f, 3.58903557e-02f, -5.36505282e-02f, -2.45312769e-02f, 9.66862887e-02f, -1.61443109e-04f, -2.86829583e-02f, 2.46921815e-02f, 7.23980218e-02f,
  1.08090878e-01f, -1.19758204e-01f, -7.49329105e-02f, -6.07950389e-02f, 2.32433937e-02f, -4.28262502e-02f, -7.38671795e-02f, -2.51891706e-02f, -3.30562294e-02f, -5.68722114e-02f,
  -1.24948345e-01f, 2.37234030e-02f, -2.83099771e-01f, 3.44490647e-01f, 2.09979013e-01f, 1.20084271e-01f, -1.93966199e-02f, 8.66233408e-02f, 1.36640415e-01f, 1.62010074e-01f,
  1.04060896e-01f, -4.76024672e-02f, -3.06593418e-01f, 3.83235127e-01f, 1.77049518e-01f, -1.27784118e-01f, 3.74944329e-01f, 2.10275188e-01f, -5.92161790e-02f, 1.57711461e-01f,
  1.81915630e-02f, 3.85341108e-01f, -2.59080589e-01f, 8.06814507e-02f, -4.00064653e-03f, -1.36449292e-01f, 1.43325269e-01f, -2.67277539e-01f, 7.13812634e-02f, 1.53288260e-01f,
  6.06265403e-02f, -3.43274437e-02f, -5.03540002e-02f, -8.86587501e-02f, 2.09303144e-02f, 1.33409621e-02f, -5.24956957e-02f, -1.33877739e-01f, -4.40475494e-02f, -6.77133575e-02f,
  -3.25478353e-02f, -2.46636029e-02f, 1.36142494e-02f, 2.47979965e-02f, 6.94042072e-02f, -4.56871688e-02f, 8.33872333e-03f, -2.69587096e-02f, -6.00383952e-02f, -9.33098421e-02f,
  -5.14964387e-02f, 6.42562285e-02f, 6.98077753e-02f, -2.72974633e-02f, -1.89095773e-02f, 8.20054393e-03f, 1.30404979e-02f, -6.92709610e-02f, 7.91596919e-02f, 6.20208308e-02f,
  6.69386983e-02f, -9.23303142e-02f, -7.16154277e-02f, -6.05633259e-02f, 9.40674245e-02f, -2.20224820e-02f, 1.25243170e-02f, -3.05521954e-02f, 5.63910753e-02f, 3.64680253e-02f,
  -6.19084295e-03f, -3.10185160e-02f, -6.72208797e-03f, -9.86262187e-02f, 2.38118377e-02f, -3.08928192e-02f, 4.76818755e-02f, -5.11626387e-03f, -7.98585415e-02f, -8.18442479e-02f,
  -2.06682943e-02f, -2.31927354e-02f, -6.31010979e-02f, -9.83321294e-03f, 1.21710706e-03f, -8.49059895e-02f, -2.89529040e-02f, -4.23163995e-02f, -7.97435939e-02f, 3.44929211e-02f,
  2.87032664e-01f, 9.58683342e-02f, -6.50876909e-02f, -1.71849318e-02f, -2.90112440e-02f, 1.05265312e-01f, 6.85623288e-02f, 6.31748885e-02f, -4.62554246e-02f, -9.23396572e-02f,
  -3.94969508e-02f, 2.68793069e-02f, 5.59487231e-02f, 2.63768472e-02f, 2.40679011e-02f, 1.44868270e-02f, -1.42546613e-02f, 7.74733797e-02f, 1.31661549e-01f, -2.64504589e-02f,
  -6.96734190e-02f, 3.79168056e-02f, 1.35711879e-02f, 6.81850836e-02f, -1.45570440e-02f, -6.59555569e-02f, 7.20468014e-02f, 4.39437367e-02f, -1.44593799e-02f, 2.26918440e-02f,
  -5.20911396e-01f, -1.75389573e-02f, -3.00900191e-01f, -1.84110269e-01f, 1.60418496e-01f, 1.73450008e-01f, -9.63191837e-02f, 6.86225519e-02f, -1.73463792e-01f, 2.95192212e-01f,
  1.05274484e-01f, -2.78563380e-01f, -9.19379294e-02f, -1.06629387e-01f, -4.17905360e-01f, -1.67366311e-01f, -5.69619276e-02f, -9.60893854e-02f, -1.67081699e-01f, -5.77929057e-02f,
  -1.16884433e-01f, 1.30715460e-01f, -2.42724046e-01f, 1.27097324e-01f, 6.53367043e-02f, 1.16892226e-01f, 1.94402844e-01f, 1.14973962e-01f, 2.54281759e-02f, 7.12694973e-02f,
  1.54618531e-01f, -1.19467042e-01f, -1.28609985e-01f, -1.03718773e-01f, -3.38279502e-03f, -1.20658986e-02f, -3.75856869e-02f, -4.92365584e-02f, -2.07292605e-02f, -1.16822019e-01f,
  -4.48246077e-02f, -1.25668040e-02f, 6.93078898e-03f, 2.42856313e-02f, -1.63263991e-03f, -9.71974339e-03f, -2.78372690e-02f, -7.75257275e-02f, -1.48677537e-02f, -4.46967818e-02f,
  -9.48391035e-02f, 5.66205662e-03f, 6.75550476e-03f, -6.16652295e-02f, -1.58249848e-02f, 5.53597510e-02f, 1.48999365e-02f, -3.66608053e-02f, 2.38284189e-02f, 3.83258052e-02f,
  -8.11681002e-02f, -6.63335761e-03f, -2.25655697e-02f, 1.69216748e-02f, 2.48247553e-02f, 1.05745271e-02f, -6.62961602e-02f, 4.61253673e-02f, -8.76447484e-02f, 6.43918291e-02f,
  -1.99050996e-02f, -4.99460436e-02f, -1.76740717e-02f, -6.76767807e-03f, -3.94599838e-03f, 2.45543253e-02f, -3.55553329e-02f, 9.60799959e-03f, 6.54101521e-02f, 2.71492675e-02f,
  4.95705307e-02f, -1.06070628e-02f, -2.09570378e-02f, -4.36565652e-02f, 4.69795465e-02f, -3.73006649e-02f, 5.27400291e-03f, -3.74612436e-02f, -4.63457294e-02f, 9.55147948e-03f,
  1.56065688e-01f, 1.05731986e-01f, -1.10826921e-02f, 5.52159548e-02f, -1.83097981e-02f, 5.17195314e-02f, -5.13643399e-02f, 2.84430534e-02f, 1.47657935e-02f, 5.43184206e-02f,
  8.56881067e-02f, 2.72933301e-03f, 4.87008318e-02f, -5.25440238e-02f, -5.59286661e-02f, 3.07964962e-02f, 6.20784834e-02f, 8.74101296e-02f, 3.72459926e-02f, 2.27848198e-02f,
  8.16515535e-02f, 5.61541989e-02f, -3.97813693e-02f, 6.62930757e-02f, 2.56738234e-02f, 8.17977190e-02f, 6.34988770e-02f, -4.08306345e-02f, -2.15265937e-02f, 1.82102434e-02f,
  -1.53154165e-01f, -1.88590810e-01f, 8.05899724e-02f, 2.84901083e-01f, -6.83950493e-03f, -6.82308972e-02f, -1.97162554e-01f, 1.17859192e-01f, -3.82068008e-01f, -2.41916597e-01f,
  8.41766689e-03f, -1.37596935e-01f, -3.74114335e-01f, -4.08928171e-02f, -3.78710032e-02f, -4.89210308e-01f, 4.51718867e-02f, -2.03422084e-02f, -8.35349634e-02f, 1.66193560e-01f,
  1.44117594e-01f, 7.23887756e-02f, 2.05994681e-01f, 3.43256444e-01f, 1.15722548e-02f, 4.51455861e-01f, 4.64379728e-01f, 3.87461632e-02f, 4.58889544e-01f, 1.16967022e-01f,
  -2.58163422e-01f, -1.63550839e-01f, 2.46503763e-02f, 3.49663459e-02f, 8.20664316e-02f, 6.96007162e-02f, 5.08813784e-02f, -1.93823110e-02f, 5.33774048e-02f, 3.53796408e-02f,
  -7.64122158e-02f, -3.30154113e-02f, 1.33544495e-02f, -3.41289155e-02f, 1.91607792e-02f, 1.34251229e-02f, 3.42021137e-02f, -4.25745323e-02f, -7.73203745e-02f, -1.13543406e-01f,
  -7.55205527e-02f, -4.04460132e-02f, 9.14801136e-02f, 5.16661890e-02f, -4.38717902e-02f, 7.90420696e-02f, 2.89576724e-02f, -3.28002311e-02f, 6.51894063e-02f, 9.59521458e-02f,
  -7.32509866e-02f, 2.74224840e-02f, -1.80665478e-02f, 2.66727302e-02f, 4.39092629e-02f, 7.13146944e-03f, -3.58165465e-02f, 8.00388679e-03f, 2.72003599e-02f, -1.66200716e-02f,
  1.00637697e-01f, -1.20637780e-02f, 3.66627499e-02f, -1.57915298e-02f, 9.60994978e-03f, -7.45679960e-02f, 5.32538742e-02f, 5.47177941e-02f, 2.51837224e-02f, -3.18857916e-02f,
  -6.71183243e-02f, -1.17871314e-02f, -1.08096212e-01f, 2.42481660e-03f, -9.75895971e-02f, 5.64518869e-02f, -2.57812859e-03f, -4.41146418e-02f, 4.88829799e-02f, 3.91821899e-02f,
  4.15989608e-02f, 1.48373291e-01f, 3.52643477e-03f, 7.91515484e-02f, -5.49781136e-02f, -1.01255797e-01f, -4.54963818e-02f, -7.50743132e-03f, -1.60730164e-02f, -8.06786120e-03f,
  1.34163469e-01f, 5.96700422e-02f, -5.87695651e-02f, 5.03847674e-02f, 1.13313571e-01f, -7.59924948e-02f, 2.61186082e-02f, 6.09420501e-02f, 1.36103764e-01f, 1.09511912e-01f,
  3.04404460e-02f, 2.26196507e-03f, 8.02605972e-02f, 3.12879421e-02f, 5.32345548e-02f, -7.77270412e-03f, 1.15008600e-01f, 4.49285991e-02f, 5.97482845e-02f, -1.18190199e-01f,
  -5.58568776e-01f, 4.09757882e-01f, -2.13448361e-01f, 2.43324056e-01f, -8.80611017e-02f, 4.93988991e-01f, 3.28938216e-01f, 1.84503928e-01f, 1.50534451e-01f, 4.72499162e-01f,
  1.36744738e-01f, 6.11297749e-02f, 1.43649638e-01f, 3.22301865e-01f, 8.04967135e-02f, 3.30240637e-01f, 2.90538669e-01f, 2.07224578e-01f, -6.05242141e-02f, 5.79452701e-02f,
  -4.52069566e-02f, 1.98541448e-01f, -3.00236121e-02f, -1.22908786e-01f, -9.31139514e-02f, -1.65670708e-01f, -6.04325496e-02f, -1.33901790e-01f, 7.48459715e-03f, -1.80553626e-02f,
  -4.87133712e-02f, -9.56104472e-02f, -1.34498119e-01f, -1.54647216e-01f, 4.51597534e-02f, -7.70825073e-02f, 2.83586457e-02f, -7.55327791e-02f, -1.14093326e-01f, 1.22091947e-02f,
  -1.37208041e-03f, -9.88363251e-02f, 4.93749343e-02f, -3.25742289e-02f, -2.32596006e-02f, -6.48217499e-02f, -2.12335829e-02f, -2.69513633e-02f, 5.69557138e-02f, 2.07515061e-02f,
  -2.69961897e-02f, 7.16345981e-02f, 3.56944688e-02f, 3.43461223e-02f, -4.13777679e-02f, 5.29679656e-02f, 2.02465788e-01f, -9.75931361e-02f, 7.01723099e-02f, 9.68823507e-02f,
  -2.21144967e-02f, -1.17788312e-03f, 5.59041975e-03f, -1.11160912e-02f, 6.78492412e-02f, -1.06226832e-01f, 6.28061891e-02f, 1.29763344e-02f, 1.46958884e-02f, 2.43091360e-02f,
  4.85669412e-02f, 1.00620084e-01f, -5.28176129e-02f, 8.89771879e-02f, 1.71802044e-02f, 3.94640379e-02f, -1.69978980e-02f, 3.67705859e-02f, 6.87983558e-02f, 1.86646655e-02f,
  1.56850889e-02f, 2.07907073e-02f, -3.66435200e-02f, -6.79172799e-02f, 5.70530221e-02f, 1.00446204e-02f, -1.12358369e-02f, 3.24633382e-02f, -2.27041002e-02f, -1.83372349e-02f,
  1.86416820e-01f, 2.20652372e-01f, -6.41560880e-03f, -4.93666269e-02f, 2.36232523e-02f, 1.13272425e-02f, 2.10771747e-02f, -2.63437405e-02f, 1.14535131e-01f, -1.19278906e-02f,
  1.07285343e-02f, 8.01961310e-03f, -3.63741107e-02f, 7.99898338e-03f, -9.43613425e-03f, 1.07466981e-01f, 6.63858466e-03f, 4.93900776e-02f, 2.88263112e-02f, 1.38907237e-02f,
  4.64279242e-02f, -1.13062887e-02f, -5.79773635e-02f, 7.56050413e-03f, 1.24071548e-02f, 6.75316826e-02f, -4.16289829e-02f, -9.66085866e-03f, 5.94457844e-03f, 1.00904576e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  6.65895268e-02f, 1.75156683e-01f, -2.84212045e-02f, 8.62681493e-02f, 1.52685177e-02f, 2.28787035e-01f, 3.70897770e-01f, 2.14851305e-01f, 6.46929815e-02f, 2.28473216e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  8.51113617e-01f, 1.68901056e-01f, -3.74088436e-01f, 3.93284768e-01f, -3.43219161e-01f, 3.45629752e-01f, 6.85987324e-02f, -3.27132158e-02f, 3.75957005e-02f, -2.34619588e-01f,
  -2.75135070e-01f, -2.99785078e-01f, -2.85659403e-01f, 5.28299928e-01f, -2.89962083e-01f, -3.03094119e-01f, -4.60379452e-01f, -5.52119426e-02f, 1.10270426e-01f, 9.28891376e-02f,
  2.09277511e-01f, -2.47502401e-01f, -4.45490569e-01f, 1.21750226e-02f, 1.84365034e-01f, -3.59993398e-01f, 3.27623636e-01f, 4.76034194e-01f, 2.51933813e-01f, -3.12089235e-01f,
  2.01606542e-01f, 4.77745086e-01f, -2.47414470e-01f, 4.05724883e-01f, -2.05192327e-01f, -4.21073735e-01f, -7.81659558e-02f, 6.48855805e-01f, 6.35676086e-02f, 2.04636633e-01f,
  -4.50699171e-03f, 5.41377127e-01f, 7.84035251e-02f, 2.18359500e-01f, 4.60698158e-02f, -5.17687678e-01f, -2.15232238e-01f, 2.03394741e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.96457762e-01f, -1.73141181e-01f, 4.66600388e-01f, 6.85140133e-01f, 3.71826947e-01f, -4.04639482e-01f, -4.41453159e-01f, -1.27400756e-01f, -2.93372214e-01f, -3.53481412e-01f,
  -1.08065948e-01f, -1.71234965e-01f, 3.54398042e-01f, 6.18836284e-01f, 4.56379831e-01f, 6.18990600e-01f, 2.40252256e-01f, 2.94379711e-01f, -1.21988408e-01f, 7.14313984e-02f,
  -1.20642394e-01f, -9.78349522e-02f, 2.07504556e-01f, 3.27582955e-01f, -4.21217903e-02f, 6.16631005e-03f, -1.53295556e-03f, -3.05361114e-02f, -1.62478551e-01f, -2.52484441e-01f,
  2.27060929e-01f, 3.54629517e-01f, -1.48941770e-01f, 1.15629444e-02f, -2.10035756e-01f, -4.86157201e-02f, 1.76792935e-01f, -9.66986455e-03f, -1.07298896e-01f, 1.23052031e-01f,
  3.43070254e-02f, -9.88712460e-02f, -2.23767921e-01f, -1.92999631e-01f, -4.06217575e-02f, -5.57757281e-02f, -2.21942693e-01f, 3.19981128e-02f, 7.77329266e-01f, 2.15721473e-01f,
  3.22746396e-01f, 1.73414990e-01f, 1.49806030e-02f, 2.57236630e-01f, 5.83458304e-01f, 2.95092195e-01f, 3.52233928e-03f, 4.37325180e-01f, -2.67923236e-01f, 7.82007337e-01f,
  7.50718355e-01f, 3.60659450e-01f, 5.85085034e-01f, 2.83240318e-01f, 5.73736966e-01f, -2.56755445e-02f, -1.13948062e-01f, 5.70497215e-02f, -3.76670539e-01f, 7.84989417e-01f,
  5.59821606e-01f, 4.37761486e-01f, 4.06371921e-01f, 5.86175844e-02f, -5.22228062e-01f, 7.36899436e-01f, 5.86282253e-01f, -4.59427834e-02f, 1.00472832e+00f, -2.13930830e-01f,
  -2.23594829e-01f, 7.06275478e-02f, -1.48661911e-01f, -5.06491587e-02f, -2.29678720e-01f, -1.48096666e-01f, -8.90406743e-02f, 1.52351201e-01f, -2.12827533e-01f, 2.70381421e-02f,
  -1.10443711e-01f, -3.49222794e-02f, -7.89701119e-02f, -6.53190315e-02f, -1.99304312e-01f, -2.34291539e-01f, 9.21195865e-01f, 6.33760393e-01f, 6.83121443e-01f, 2.35052153e-01f,
  3.45860511e-01f, -3.28024536e-01f, 1.52361572e-01f, 2.24564567e-01f, 2.08057970e-01f, 1.07944393e+00f, -1.05137089e-02f, -1.82845294e-01f, -2.76273966e-01f, -6.75692484e-02f,
  -5.19970238e-01f, 4.88992631e-01f, -2.05064029e-01f, -1.50852472e-01f, -2.19325587e-01f, 2.05349058e-01f, -1.05243959e-01f, -1.52367009e-02f, -7.80372927e-03f, -4.30428796e-02f,
  -2.25232616e-02f, -1.98986009e-01f, -3.23900394e-02f, -5.74539825e-02f, -6.34284392e-02f, -2.17715308e-01f, -2.29360953e-01f, -2.88147368e-02f, -8.93145129e-02f, -1.37816612e-02f,
  3.76918283e-03f, 4.37851071e-01f, 3.90526682e-01f, -1.41001984e-01f, -3.54973406e-01f, 3.16936493e-01f, -3.73846173e-01f, -2.49615073e-01f, -5.13425097e-02f, 5.22331119e-01f,
  6.06246829e-01f, 1.08093090e-01f, -5.60978763e-02f, 9.21580732e-01f, 1.52412087e-01f, -1.79048583e-01f, -5.38323112e-02f, 1.30208313e-01f, 1.79567978e-01f, -3.80142517e-02f,
  -1.49073511e-01f, 8.13182667e-02f, -1.53694540e-01f, -2.51300663e-01f, -1.95183218e-01f, -2.25519687e-01f, 1.63001627e-01f, 7.42518753e-02f, 1.00128446e-03f, -1.30838037e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  5.57639539e-01f, -1.33494794e-01f, 1.05605848e-01f, 5.34224272e-01f, 3.15172821e-01f, 4.29279208e-02f, 2.87645429e-01f, -3.27810049e-02f, 2.61375844e-01f, -1.74753577e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.78017241e-01f, 5.80163181e-01f, 6.81627914e-02f, 9.34287012e-01f, -6.54355049e-01f, -2.14219362e-01f, -1.76584393e-01f, 1.18645869e-01f, 1.98730767e-01f, 1.30275011e-01f,
  1.64029181e-01f, -2.09505677e-01f, 3.05428207e-01f, -1.19578950e-01f, -5.02869308e-01f, 1.18385978e-01f, 1.07168965e-01f, -5.54861486e-01f, -2.29732513e-01f, 3.16955522e-02f,
  -5.06200194e-01f, 2.38032207e-01f, -2.94332772e-01f, 4.56487536e-02f, -1.65085152e-01f, 1.14237234e-01f, 4.06570792e-01f, 4.44511957e-02f, -1.67486295e-01f, -2.27331370e-01f,
  -2.21549228e-01f, 1.20559774e-01f, -2.29270339e-01f, 1.42616788e-02f, -1.06228113e-01f, 1.05449378e+00f, -5.50864160e-01f, -4.54500556e-01f, 1.91842869e-01f, -4.52608168e-02f,
  -1.53721884e-01f, -1.41222537e-01f, 4.27379273e-02f, -1.63399532e-01f, -6.80789575e-02f, 1.91578925e-01f, -1.38319075e-01f, -1.58259958e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.97794437e-01f, -3.53522688e-01f, 2.67645866e-01f, -1.35628259e+00f, 9.83221233e-01f, 1.02943189e-01f, 8.00419807e-01f, 1.20267846e-01f, -1.73351243e-01f, 4.81109679e-01f,
  -3.47810715e-01f, -1.32584974e-01f, 6.02344394e-01f, -8.78743082e-02f, 8.55007231e-01f, 8.17328468e-02f, -4.69471335e-01f, -1.50433287e-01f, 1.16437338e-01f, 6.63460135e-01f,
  3.03435445e-01f, -8.40595782e-01f, 6.09369397e-01f, -2.17694730e-01f, -1.76572174e-01f, 7.79905021e-01f, 5.73998213e-01f, 1.98686719e-01f, -3.27297866e-01f, 1.96108803e-01f,
  1.93836123e-01f, 2.07888201e-01f, -2.54151911e-01f, -2.53466815e-01f, -4.68920469e-01f, -7.53148019e-01f, -3.85176003e-01f, 1.18120372e+00f, -6.93690836e-01f, 1.42653450e-01f,
  -2.28694856e-01f, 8.54820669e-01f, 7.06782639e-01f, 1.56050295e-01f, 6.35717809e-01f, -1.42566442e-01f, -9.64902937e-02f, 1.53183341e-01f, -1.88444689e-01f, -3.04165453e-01f,
  2.29261205e-01f, 6.33942366e-01f, -2.73286581e-01f, -7.42601573e-01f, 4.41904128e-01f, -1.49129659e-01f, -1.70136452e-01f, 6.25117898e-01f, 9.93140280e-01f, -4.49498035e-02f,
  -8.30381691e-01f, -2.70538088e-02f, -1.32433861e-01f, -1.46414995e-01f, 7.45517462e-02f, -2.26695359e-01f, 6.24862791e-04f, 9.32279825e-02f, 7.86006004e-02f, -2.32784644e-01f,
  -2.29596078e-01f, -1.75085530e-01f, 9.95915532e-02f, -5.45214824e-02f, -1.38093963e-01f, 5.00382632e-02f, -1.21426093e-03f, -2.33316451e-01f, -2.29097769e-01f, -1.60949662e-01f,
  7.73684740e-01f, 8.50008130e-01f, 5.41632175e-01f, 1.30953479e+00f, -8.26352656e-01f, -2.53333561e-02f, 1.85525879e-01f, 1.77815884e-01f, -8.31212625e-02f, 6.62835956e-01f,
  -1.71494111e-02f, -2.45813608e-01f, 1.38848889e+00f, -3.96400541e-02f, -4.76746976e-01f, 2.36871704e-01f, 1.90036550e-01f, -2.06663340e-01f, 8.26970190e-02f, -1.87289659e-02f,
  -8.89287218e-02f, -2.42769122e-01f, -2.46383846e-01f, -1.72556147e-01f, -8.54120702e-02f, -8.69764686e-02f, -1.01352073e-02f, 2.40766108e-01f, -1.84367329e-01f, 2.63115335e-02f,
  -1.78654566e-01f, -7.64621943e-02f, -1.10016540e-01f, -3.29585671e-02f, -2.31833771e-01f, -2.21391141e-01f, -3.94963980e-01f, -7.17334449e-02f, -1.20255560e-01f, -2.98631489e-01f,
  2.42187962e-01f, 3.59870315e-01f, -2.25337580e-01f, 9.94500741e-02f, 3.55368972e-01f, -5.64376414e-02f, -3.61230105e-01f, -6.19806647e-02f, 1.04211085e-01f, -6.04259193e-01f,
  -1.36520386e-01f, -2.64950156e-01f, -4.11521904e-02f, 4.99128819e-01f, -4.82227594e-01f, 1.37615755e-01f, 2.22642615e-01f, 8.49139929e-01f, 1.26652646e+00f, 6.68893382e-02f,
  -3.48060012e-01f, 3.31808105e-02f, -1.42981648e-01f, -1.71505183e-01f, -1.46266282e-01f, -5.48433006e-01f, 8.48215073e-03f, 2.74046183e-01f, 4.68659371e-01f, -4.33242738e-01f,
  9.05925751e-01f, 9.31316167e-02f, -1.47894725e-01f, 3.91891569e-01f, 4.38432442e-03f, 1.17082529e-01f, -7.04313591e-02f, 1.42412573e-01f, 7.81769216e-01f, -2.19250277e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.47021550e-01f, -2.59897839e-02f, -8.11226889e-02f, 1.34133399e-01f, -1.63359210e-01f, 5.75902700e-01f, -1.63108587e-01f, 1.20680057e-01f, -2.25857437e-01f, -4.24891487e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -6.88963115e-01f, 1.56385168e-01f, 5.33414558e-02f, -4.01440799e-01f, -9.77924839e-02f, 1.62436012e-02f, 9.45644200e-01f, -5.61880395e-02f, -6.87222302e-01f, -5.25165975e-01f,
  1.69566050e-01f, -3.54758471e-01f, 2.75001246e-02f, -2.57635802e-01f, -5.77704549e-01f, 6.24494076e-01f, -4.64250088e-01f, -6.30139781e-04f, -3.77600521e-01f, -7.27131784e-01f,
  4.47633892e-01f, 6.05401099e-02f, 4.62983310e-01f, -1.00304149e-02f, 4.57098216e-01f, -2.86542505e-01f, 6.21157885e-02f, -7.51837492e-01f, 6.57759532e-02f, 3.73289199e-03f,
  3.61904740e-01f, 6.23615861e-01f, 2.29483619e-01f, -4.99738783e-01f, 1.62902996e-01f, -7.12632000e-01f, 2.53041297e-01f, 2.44045053e-02f, 5.80661520e-02f, 5.21037936e-01f,
  -4.80111897e-01f, 8.61878157e-01f, 2.29936913e-02f, -9.10607934e-01f, 7.96329230e-02f, 1.20614329e-02f, 1.96366593e-01f, 4.07763124e-01f, -5.25193632e-01f, 1.36519790e-01f,
  3.59208360e-02f, 8.56088638e-01f, -1.84895203e-01f, 9.54471707e-01f, -6.22954965e-01f, 5.74663162e-01f, -8.27339709e-01f, 1.90155193e-01f, -1.50552034e-01f, 1.01951671e+00f,
  5.52112870e-02f, 2.92477876e-01f, -1.04168987e+00f, 1.63129658e-01f, 7.74895728e-01f, -1.17813021e-01f, 8.12906444e-01f, 1.50230993e-02f, -3.53075355e-01f, -1.49718657e-01f,
  2.61609316e-01f, -1.18591540e-01f, -9.44227219e-01f, -3.49264055e-01f, 2.08679706e-01f, 1.01762235e+00f, 2.25849077e-01f, -3.34853530e-01f, -2.77284175e-01f, 3.42672974e-01f,
  6.74367726e-01f, 1.26431391e-01f, -3.48644137e-01f, 7.33775795e-02f, -2.30295047e-01f, -2.22530261e-01f, 5.76881886e-01f, -4.25886899e-01f, 8.82959843e-01f, -7.49965549e-01f,
  2.10309744e-01f, 2.03738324e-02f, 6.50619715e-02f, -2.54956316e-02f, -9.51625258e-02f, -6.92986697e-03f, 5.79875074e-02f, -4.55499381e-01f, -3.33719373e-01f, 6.42066121e-01f,
  5.09309113e-01f, -3.60184252e-01f, -2.78820395e-01f, -3.59193772e-01f, 9.65380907e-01f, -5.21850348e-01f, -1.91607326e-01f, 1.80151030e-01f, 9.30728689e-02f, 4.86271262e-01f,
  5.55886745e-01f, -4.33888316e-01f, 7.15934038e-01f, 7.88300812e-01f, 8.97231773e-02f, -1.20263469e+00f, -9.86449242e-01f, -1.11693585e+00f, 1.08734763e+00f, -4.32479590e-01f,
  -5.30691259e-02f, -3.19773525e-01f, -2.09901929e-01f, -9.27060485e-01f, -1.69234067e-01f, 5.63112795e-02f, -3.70887220e-01f, -3.97831410e-01f, 1.14676468e-01f, -8.38308156e-01f,
  -4.86130863e-01f, 2.46691614e-01f, -9.19526219e-02f, 2.15950847e-01f, -3.77128899e-01f, 2.70077676e-01f, 3.97060990e-01f, 2.92970568e-01f, -2.05977798e-01f, -6.26504898e-01f,
  -3.01445611e-02f, -2.41127491e-01f, 8.63658547e-01f, -3.78218353e-01f, 4.73570824e-01f, 4.04583484e-01f, 3.60408485e-01f, 6.31789505e-01f, -1.47544101e-01f, -3.01304221e-01f,
  -5.83527461e-02f, -9.80885565e-01f, 5.61308339e-02f, -4.95056063e-01f, -4.60230261e-02f, 1.26123130e+00f, -1.61537454e-01f, 3.51480842e-01f, -5.48442185e-01f, -6.57652497e-01f,
  -5.38716793e-01f, -1.14117779e-01f, 1.61525294e-01f, 6.30100906e-01f, 1.04647852e-01f, 3.80019456e-01f, -6.78257585e-01f, 8.82175922e-01f, -5.67101657e-01f, 8.98389697e-01f,
  -5.04377931e-02f, -1.16650276e-01f, -1.39575256e-02f, -1.91189334e-01f, -5.91815859e-02f, 2.23006621e-01f, -4.08005357e-01f, -3.01201493e-01f, 4.36539441e-01f, 6.46539867e-01f,
  5.82168758e-01f, 4.94009256e-01f, -1.22062492e+00f, -2.95706928e-01f, 2.83049345e-01f, 4.00644183e-01f, -2.18663905e-02f, 7.40867913e-01f, -6.51167259e-02f, -2.17827052e-01f,
  5.87009609e-01f, -4.23597455e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.02483827e-01f, -1.35637196e-02f, -3.22993994e-01f, 1.47679210e-01f, 3.06916624e-01f, -7.85461515e-02f, -2.95999765e-01f, 1.07939792e+00f, -6.51864946e-01f, 1.39811054e-01f,
  3.21520306e-02f, 2.23236933e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    