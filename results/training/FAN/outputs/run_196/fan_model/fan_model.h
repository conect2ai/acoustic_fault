/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.73999989e-01f, 3.63397658e-01f, 4.58001830e-02f, 1.30817518e-01f, -3.33645761e-01f, -1.45220190e-01f, 1.65568143e-01f, -1.50509730e-01f, 3.30394298e-01f, 1.90554053e-01f,
  -8.88126250e-03f, 3.19636941e-01f, 2.15209961e-01f, 1.20814390e-01f, -8.13736692e-02f, 3.55010301e-01f, -4.49115895e-02f, 5.49859665e-02f, 2.89710555e-02f, -1.73856422e-01f,
  -7.35342652e-02f, -8.93999785e-02f, -2.86037028e-02f, -2.44542256e-01f, -1.32962406e-01f, -1.55339956e-01f, -2.05943555e-01f, -7.26929121e-03f, -1.99995995e-01f, 9.31513757e-02f,
  -2.07004860e-01f, 9.29917693e-02f, -5.57138678e-03f, 5.11482470e-02f, -1.79052785e-01f, -5.14108576e-02f, -4.98287641e-02f, 2.26202626e-02f, 3.65217775e-02f, 2.81430073e-02f,
  3.84247713e-02f, -4.09299433e-02f, -2.27174945e-02f, 4.86633368e-02f, 3.53437550e-02f, -7.32504856e-03f, -1.53656933e-03f, 4.21370799e-03f, 2.63927877e-02f, -1.56888701e-02f,
  2.46522296e-02f, 2.64640991e-02f, 5.65357246e-02f, 6.63968846e-02f, 8.69330205e-03f, 3.05222310e-02f, -1.09097874e-02f, -3.46943960e-02f, 9.84704718e-02f, -7.84956887e-02f,
  -7.48849958e-02f, -3.02943513e-02f, 2.43840236e-02f, -1.33777857e-02f, -6.97954465e-03f, -4.75923419e-02f, 6.50219545e-02f, -2.31558401e-02f, 2.36154292e-02f, -3.16780061e-02f,
  -1.94923263e-02f, 3.68380696e-02f, 4.96459119e-02f, 2.06582695e-02f, -3.40065919e-02f, 1.57427900e-02f, -2.33015157e-02f, -9.01939068e-03f, -5.93305342e-02f, 1.41435796e-02f,
  9.71888900e-02f, -1.70182984e-03f, -4.10105027e-02f, -2.59348899e-02f, 6.39167055e-02f, -2.42349375e-02f, -2.64092032e-02f, 7.53856525e-02f, -1.77017152e-02f, -6.67771325e-02f,
  -9.35112983e-02f, -8.42646509e-02f, 1.58586223e-02f, 3.01641431e-02f, 3.26572806e-02f, -2.88315751e-02f, 9.65747237e-03f, -7.24804169e-03f, 9.97537933e-03f, -3.95563543e-02f,
  -1.15213983e-01f, -3.47824730e-02f, 1.18754581e-02f, -3.61877158e-02f, -2.25355499e-03f, -5.34878634e-02f, -1.88046834e-04f, -6.17294386e-03f, -1.24709485e-02f, -8.15566927e-02f,
  -4.58274409e-02f, -8.13744143e-02f, -1.03438820e-03f, -8.73131305e-02f, -1.99619606e-02f, -2.74697542e-02f, -3.14494669e-02f, 1.47305140e-02f, -1.29158208e-02f, 6.51387349e-02f,
  4.10051495e-01f, -3.11042249e-01f, -2.02690393e-01f, 1.74908862e-02f, 1.81006715e-01f, -2.98786551e-01f, -1.77244097e-01f, 4.33413610e-02f, 3.05855095e-01f, -1.09685048e-01f,
  -5.39766699e-02f, -2.47629136e-02f, -1.03017218e-01f, -3.03578734e-01f, -1.17104836e-01f, -2.15030476e-01f, -2.42946029e-01f, -1.75015911e-01f, 1.11072987e-01f, 9.29324850e-02f,
  7.79384673e-02f, -4.86184321e-02f, -2.46643171e-01f, 4.35234495e-02f, -3.52487639e-02f, 9.19615105e-02f, 8.60545263e-02f, 4.64552417e-02f, -1.33674622e-01f, -8.66263881e-02f,
  5.63742965e-02f, 1.55616865e-01f, -1.33583009e-01f, -6.82744905e-02f, 3.91802099e-03f, 1.78012569e-02f, -3.43893282e-02f, -4.98166010e-02f, 3.48924585e-02f, -8.39333516e-03f,
  1.26178134e-02f, 2.92926114e-02f, -1.10128764e-02f, 2.40490083e-02f, -1.92147382e-02f, -6.83555827e-02f, -8.75177905e-02f, -7.94098824e-02f, -7.69338151e-03f, -6.35626912e-02f,
  -8.09780583e-02f, -1.29083097e-01f, -4.90933284e-02f, -7.93500915e-02f, 3.76674049e-02f, 3.48728225e-02f, -4.54636589e-02f, 1.17927035e-02f, -3.19327749e-02f, 5.50982617e-02f,
  3.68293934e-02f, 8.93337354e-02f, 1.24503691e-02f, -4.66178637e-03f, -3.51180546e-02f, -8.19335692e-03f, -3.64271328e-02f, -5.18875383e-02f, 5.21443188e-02f, -2.38527581e-02f,
  7.34019512e-03f, -4.59571881e-03f, 4.79909852e-02f, -2.09826045e-03f, 4.09300327e-02f, 4.63212207e-02f, -5.27894944e-02f, 1.23588899e-02f, 1.34754032e-02f, 3.04224920e-02f,
  4.00628261e-02f, -1.94476481e-04f, 4.15593348e-02f, -3.27662914e-03f, -5.18901907e-02f, -1.32462438e-02f, -6.36551762e-03f, -5.28822131e-02f, 4.13629562e-02f, -1.67228039e-02f,
  1.00036487e-01f, 2.36325040e-02f, 8.10427889e-02f, 3.67632024e-02f, -5.89222386e-02f, -8.12363103e-02f, -3.11253592e-02f, -8.57762992e-03f, -1.30185848e-02f, 5.58927357e-02f,
  1.60455313e-02f, 9.82297584e-03f, 1.30933234e-02f, -6.36380017e-02f, -4.84145172e-02f, 5.61764911e-02f, 3.35960947e-02f, 2.57220566e-02f, 5.24818106e-03f, -2.44516507e-02f,
  1.81023274e-02f, 9.51019954e-03f, 1.71639603e-02f, 6.72521219e-02f, -1.80184022e-02f, -8.25975370e-03f, 7.71778971e-02f, -1.45134646e-02f, -2.61311680e-02f, -3.88947949e-02f,
  1.41240269e-01f, -3.00155818e-01f, -4.33598340e-01f, -1.37563050e-01f, 4.59006846e-01f, 2.56595612e-01f, 1.53913587e-01f, -3.14010046e-02f, 1.11457631e-01f, -3.98146175e-02f,
  1.46488547e-01f, -1.19453922e-01f, -1.13657355e-01f, -1.45857140e-01f, 1.27518848e-01f, -2.36226469e-01f, 5.35829887e-02f, 2.40721125e-02f, -4.12624553e-02f, 6.51569739e-02f,
  -1.05215557e-01f, 3.18647891e-01f, -3.34679544e-01f, 4.00608219e-02f, 7.93207139e-02f, -1.31080940e-01f, 1.30011171e-01f, -8.55133235e-02f, -4.48602811e-02f, 1.86534859e-02f,
  9.60026607e-02f, -7.76236877e-02f, -3.51358168e-02f, -4.75234464e-02f, 5.55653460e-02f, 5.24880290e-02f, -5.70530482e-02f, -3.40562984e-02f, -1.15267504e-02f, -1.10041071e-02f,
  2.50932667e-02f, 7.36594796e-02f, -3.11272293e-02f, 4.91114892e-02f, 1.01165958e-01f, -4.88362797e-02f, -4.12336923e-02f, 1.04629276e-02f, -7.33798184e-03f, -2.16523949e-02f,
  -7.82395899e-02f, -3.82365771e-02f, -1.24092270e-02f, -4.49141897e-02f, -5.94888479e-02f, -4.58929921e-03f, -4.32098843e-03f, -1.12428386e-02f, 3.67290489e-02f, 7.63667747e-02f,
  -5.34479544e-02f, -1.29028363e-02f, -1.05365347e-02f, 2.78558098e-02f, 4.87874411e-02f, -6.82792487e-03f, 1.76207181e-02f, 2.14451384e-02f, -5.91387749e-02f, 9.73760039e-02f,
  5.65803275e-02f, 3.10352780e-02f, 2.35479753e-02f, -1.72131113e-03f, 2.78566405e-02f, 2.61278561e-04f, 2.62841047e-03f, 4.02405448e-02f, -3.21886912e-02f, 6.94158208e-03f,
  -5.20083494e-02f, 7.55310804e-02f, -3.39604239e-03f, -4.62689018e-03f, 1.34211481e-02f, -3.38887386e-02f, -7.10539743e-02f, 1.31234722e-02f, -4.45656851e-02f, 6.70925900e-02f,
  3.50867182e-01f, 4.79361750e-02f, -5.46497181e-02f, 1.16224393e-01f, 3.19996825e-03f, 2.81069819e-02f, -7.24906102e-03f, -1.97013468e-02f, -1.52818486e-03f, 1.09881058e-01f,
  3.83798257e-02f, -1.53565053e-02f, 6.92568123e-02f, -5.41893952e-03f, -4.35060784e-02f, 3.10963988e-02f, -1.91050805e-02f, 4.00833674e-02f, 1.02807716e-01f, 1.70955760e-03f,
  2.52636317e-02f, 3.19973305e-02f, -2.45027933e-02f, 8.28902200e-02f, 6.08658046e-02f, 2.69075967e-02f, 6.19910844e-02f, -1.01819150e-01f, 7.69563339e-05f, -5.19250259e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.28779131e-01f, 2.49396905e-01f, -2.18352526e-01f, 1.53866708e-01f, -2.26392657e-01f, 1.70005828e-01f, 3.06113333e-01f, -1.22739717e-01f, 1.36960015e-01f, 5.47427177e-01f,
  -6.24495782e-02f, 2.71185488e-01f, -1.48375332e-02f, -8.05237070e-02f, -7.11393356e-01f, -2.27592811e-01f, 1.54520556e-01f, 3.00687969e-01f, -6.12512380e-02f, 1.91622645e-01f,
  -1.64534673e-01f, -6.75788596e-02f, -3.11410010e-01f, 4.67293970e-02f, 8.46959185e-03f, 1.96240112e-01f, 2.36835256e-02f, -5.52645363e-02f, 1.05853185e-01f, -2.16776326e-01f,
  -1.23340718e-01f, -9.21886414e-04f, -2.64378302e-02f, -1.78339854e-02f, 1.89267825e-02f, 1.27733350e-01f, 1.08751602e-01f, -1.57087356e-01f, -7.56432191e-02f, 1.01325966e-01f,
  1.03796408e-01f, -2.34198719e-02f, 1.33938678e-02f, -5.58600686e-02f, 4.90790606e-02f, 7.28993714e-02f, -6.11653067e-02f, -7.31853843e-02f, 4.20507938e-02f, -1.22612201e-01f,
  -1.25957821e-02f, -6.57055825e-02f, 3.53747308e-02f, 8.38655382e-02f, -6.43987134e-02f, 4.20303605e-02f, 8.84616449e-02f, 1.08122723e-02f, 8.29364061e-02f, -1.67474244e-02f,
  4.48468663e-02f, 1.24020167e-01f, -6.26098812e-02f, -4.75356020e-02f, -2.10985504e-02f, 4.04133201e-02f, 2.43770108e-02f, -7.44445249e-03f, 8.34549021e-04f, 5.51045574e-02f,
  -2.41703037e-02f, -4.34397608e-02f, 1.01877016e-03f, 8.50405172e-02f, -2.92287786e-02f, -1.75695904e-02f, 1.08584724e-02f, 4.98130843e-02f, 1.03508271e-01f, -5.49665429e-02f,
  -8.20589066e-03f, 5.22591695e-02f, 3.89936380e-02f, 3.54097672e-02f, -3.58354189e-02f, -9.41104889e-02f, 6.02424238e-03f, -1.44963404e-02f, 5.01081906e-02f, -1.13362530e-02f,
  1.98236242e-01f, 3.07650000e-01f, 7.65472502e-02f, 7.44669884e-02f, 6.88733384e-02f, -4.38906401e-02f, -1.31416116e-02f, 1.05972784e-02f, 4.55627590e-02f, -5.56124374e-03f,
  1.14033334e-01f, 4.23052907e-02f, 2.45681889e-02f, -4.88190167e-02f, 2.03378126e-02f, 3.05943750e-02f, 1.18930601e-01f, 9.93446335e-02f, 1.01085417e-01f, 1.03583643e-02f,
  9.58505124e-02f, 1.40558243e-01f, 1.91427711e-02f, -2.09897310e-02f, 6.21634424e-02f, 6.71532974e-02f, 8.66460279e-02f, 2.50717774e-02f, -4.24484760e-02f, 9.35558602e-02f,
  4.33470160e-01f, -6.37433589e-01f, -3.90404820e-01f, 3.41359109e-01f, 3.77600551e-01f, 2.40872964e-01f, 1.28741622e-01f, 1.27519697e-01f, 7.44535848e-02f, -2.46990100e-01f,
  1.72313437e-01f, -2.42265493e-01f, -5.67060649e-01f, 2.46839315e-01f, 3.33140284e-01f, -2.84973085e-01f, 3.65502924e-01f, 1.03270262e-01f, -6.52656257e-02f, 2.91062687e-02f,
  2.66211390e-01f, 4.24827963e-01f, -1.71591476e-01f, 5.44623546e-02f, 1.28281981e-01f, -9.37150940e-02f, -3.79114039e-02f, -2.68932849e-01f, 2.52541661e-01f, 1.71794981e-01f,
  1.14663824e-01f, 1.88411493e-02f, -1.46498065e-02f, -2.73643229e-02f, -4.97120917e-02f, 5.90325408e-02f, -7.12110996e-02f, 2.12616492e-02f, 9.37854648e-02f, 2.06191335e-02f,
  -8.56929645e-02f, 1.26513594e-03f, 1.69255376e-01f, -1.88352223e-02f, 1.40704930e-01f, 5.26528731e-02f, 2.77213734e-02f, -3.18153873e-02f, -5.26721776e-02f, -5.87362535e-02f,
  -1.65804967e-01f, 1.18632568e-02f, 6.32747263e-02f, -3.97256576e-02f, -1.64158903e-02f, 5.59297539e-02f, -1.08526841e-01f, -1.04209982e-01f, 5.92156649e-02f, 4.40416895e-02f,
  3.76672158e-03f, -1.75428111e-02f, -2.05181614e-02f, 9.29370802e-03f, -3.50241289e-02f, 5.13413101e-02f, -4.19018492e-02f, -1.44948587e-02f, -6.97786780e-03f, -8.26697499e-02f,
  8.43128636e-02f, 2.95235291e-02f, 6.70204237e-02f, 6.19692430e-02f, 1.87000558e-02f, 1.08540216e-02f, -5.51340282e-02f, 5.42243477e-03f, 3.70413139e-02f, 3.62627432e-02f,
  -1.47545794e-02f, 4.37326878e-02f, -6.42443597e-02f, -3.45285460e-02f, 1.02415532e-02f, -5.61194718e-02f, 3.21461260e-02f, -4.30902503e-02f, -5.82274720e-02f, -2.86031961e-02f,
  -5.28589822e-02f, -3.23973179e-01f, -3.38098854e-02f, 2.77390387e-02f, -4.02570404e-02f, 8.88741016e-02f, 1.65215041e-02f, 2.06888020e-02f, -2.76558176e-02f, -6.29928987e-03f,
  1.63496025e-02f, 1.74835026e-02f, 9.93940141e-03f, 2.84275133e-03f, 3.28883007e-02f, 6.42641336e-02f, -2.66241226e-02f, 2.95285136e-02f, 2.97237514e-03f, -2.15076748e-02f,
  -4.95301895e-02f, -2.81249918e-02f, -1.43218844e-03f, 2.44394839e-02f, -3.11985277e-02f, 2.79506290e-04f, -2.75957808e-02f, -1.32576495e-01f, -1.00083895e-01f, -4.25473116e-02f,
  4.05263186e-01f, 4.18091029e-01f, 6.58710182e-01f, 4.41051185e-01f, 3.20415199e-01f, 1.37917131e-01f, -7.70490058e-03f, 3.23286951e-01f, 6.89777017e-01f, -1.20771796e-01f,
  -3.27214718e-01f, 1.94496930e-01f, -3.68279159e-01f, 1.29613444e-01f, -4.53960180e-01f, -3.29481721e-01f, 1.39921620e-01f, 5.49277943e-03f, 2.84188181e-01f, 2.09687501e-01f,
  1.15112677e-01f, -5.28129458e-01f, -8.14169049e-02f, -1.92409903e-01f, 3.50572437e-01f, 2.44443059e-01f, -6.23539269e-01f, -9.79785174e-02f, -5.81932664e-02f, -1.87403321e-01f,
  6.67490810e-02f, 1.21545538e-01f, 1.41325608e-01f, 1.42687514e-01f, 6.71493858e-02f, 7.31911212e-02f, 1.66644901e-02f, -1.54207394e-01f, 7.05048582e-03f, 9.45258141e-02f,
  -3.85372676e-02f, 7.63683300e-03f, 9.12065059e-02f, 6.78906590e-03f, 1.78663597e-01f, 1.83954462e-01f, 1.66229010e-01f, 2.63599724e-01f, 1.56484827e-01f, 2.42910683e-01f,
  2.45209172e-01f, 2.08920643e-01f, 1.85326681e-01f, -2.76712719e-02f, 4.53028381e-02f, 1.27005637e-01f, 1.02379611e-02f, 1.89144984e-02f, 1.19455509e-01f, 1.14677295e-01f,
  -8.17032009e-02f, -5.37596308e-02f, -3.00685167e-02f, 4.46894057e-02f, -4.44159247e-02f, 4.18386934e-03f, -5.39831966e-02f, -9.05294642e-02f, -1.93175662e-03f, -5.92615940e-02f,
  -1.95979681e-02f, 3.85849252e-02f, -2.61254031e-02f, 1.26760341e-02f, -4.88721393e-02f, 6.32177666e-02f, -4.86273766e-02f, -1.89876035e-02f, 4.32834253e-02f, 2.82349754e-02f,
  -8.52235034e-02f, -3.13552208e-02f, -2.55903918e-02f, -2.94639580e-02f, -2.48773880e-02f, -5.04118092e-02f, -1.56934485e-02f, 1.30184650e-01f, -5.92909520e-03f, -1.57965466e-01f,
  -1.81135565e-01f, -3.39248896e-01f, -8.17805901e-02f, -8.53784569e-03f, -6.26081824e-02f, -6.21237420e-03f, -5.12149744e-02f, 1.21793225e-01f, -4.17759046e-02f, -1.89959668e-02f,
  6.18673563e-02f, -6.99806679e-03f, -2.48095840e-02f, -5.17876633e-02f, -1.16047889e-01f, -2.14952193e-02f, -9.49670374e-02f, -1.45758688e-01f, -7.24509582e-02f, -6.52966946e-02f,
  -1.04643842e-02f, -1.23825625e-01f, -1.12731727e-02f, 6.68842569e-02f, -1.56910233e-02f, -1.50170252e-01f, 8.52134898e-02f, -3.67214647e-03f, -7.85102919e-02f, -4.76087891e-02f,
  2.28447542e-01f, -8.62968620e-03f, -6.49086416e-01f, -2.37104788e-01f, -5.27167544e-02f, 3.42777014e-01f, 2.85061002e-01f, -3.48013453e-02f, -3.33707511e-01f, 6.81628883e-01f,
  6.09061062e-01f, -3.04199666e-01f, 9.87335518e-02f, 5.95791280e-01f, -2.51443952e-01f, 2.33239830e-01f, 5.07183671e-01f, 4.63186830e-01f, -2.12918267e-01f, 8.84435512e-03f,
  -6.87894896e-02f, 5.40342927e-01f, -9.57742706e-02f, 5.35515957e-02f, 2.62123853e-01f, -2.81243563e-01f, 1.04169354e-01f, -3.24831486e-01f, 2.13883996e-01f, -1.06710652e-02f,
  1.05034888e-01f, -7.56367594e-02f, -1.57667890e-01f, -1.59155160e-01f, 2.92481054e-02f, 9.38714817e-02f, -1.05656786e-02f, -7.80336335e-02f, -1.38046682e-01f, -2.08860636e-02f,
  1.30165063e-04f, -1.28991500e-01f, -8.20226073e-02f, -1.17386237e-01f, 2.83603445e-02f, -9.01464820e-02f, -6.37145713e-02f, -5.27444156e-03f, -8.56330022e-02f, 3.29998396e-02f,
  -5.13224378e-02f, 3.00948098e-02f, 3.87782753e-02f, 7.98282679e-03f, -1.00315392e-01f, -3.61998342e-02f, -8.37191492e-02f, 2.03265417e-02f, 7.36870430e-03f, -3.65373641e-02f,
  9.27857012e-02f, 7.19611868e-02f, 1.21716984e-01f, 4.67381552e-02f, -2.51838621e-02f, 3.52133922e-02f, 9.93223581e-03f, 6.06138669e-02f, -1.13293193e-01f, 1.02775745e-01f,
  -2.69857291e-02f, -3.05752493e-02f, 3.57564278e-02f, 5.06874770e-02f, 1.37914971e-01f, 4.07674834e-02f, -2.93672625e-02f, 4.08282690e-02f, 3.74304201e-03f, -5.12803718e-02f,
  3.61287370e-02f, -3.96262445e-02f, 5.32407500e-02f, 8.14382508e-02f, 3.87653895e-02f, -3.01122144e-02f, 1.34525836e-01f, -1.03249550e-02f, 1.40698710e-02f, 1.91977173e-02f,
  4.34386544e-02f, -1.92370769e-02f, -2.69426443e-02f, -8.68648291e-02f, -6.74602538e-02f, 1.43058881e-01f, 3.53948325e-02f, -5.28944544e-02f, -2.48404276e-02f, 1.34521192e-02f,
  3.52290422e-02f, -1.05060507e-02f, 3.99691202e-02f, -2.98145376e-02f, -1.33872628e-01f, 1.56178042e-01f, 7.35551640e-02f, -7.69269541e-02f, 1.90151669e-02f, -4.96157259e-02f,
  -2.14013886e-02f, 2.64525954e-02f, -4.56703603e-02f, -3.68453935e-02f, -2.80638393e-02f, 5.48064932e-02f, -6.22849539e-02f, -1.04068771e-01f, 4.66944203e-02f, -2.44573448e-02f,
  -6.49485052e-01f, 4.94169481e-02f, 5.03652871e-01f, -9.75204557e-02f, 7.51477480e-02f, 6.86105371e-01f, 6.42386973e-01f, 2.32997999e-01f, 3.37521076e-01f, 1.68497283e-02f,
  -1.19152777e-01f, -4.65930820e-01f, 2.74570733e-01f, 1.18146941e-01f, 3.46714020e-01f, 5.01348674e-01f, 4.88200247e-01f, 1.73354983e-01f, 2.72957027e-01f, -4.51492816e-02f,
  1.15121171e-01f, -3.01647112e-02f, 2.24387258e-01f, -2.19096854e-01f, -1.24655858e-01f, -3.46285731e-01f, -4.12084609e-01f, 3.68752591e-02f, -2.83151120e-01f, 6.14759922e-02f,
  -1.52869731e-01f, -2.15628952e-01f, -2.00034827e-01f, -7.30974600e-02f, -2.61592083e-02f, -4.31615300e-02f, -5.22038266e-02f, 1.93055887e-02f, -5.88176958e-03f, 8.92655924e-03f,
  -1.57661170e-01f, -3.83247994e-02f, -3.94879840e-02f, 2.99170637e-03f, 7.21051916e-02f, -1.47879412e-02f, 2.08280887e-02f, 4.84163910e-02f, 3.21958549e-02f, 1.40881449e-01f,
  8.51045325e-02f, 3.36131081e-04f, 5.35704195e-02f, 8.31591934e-02f, -1.53457765e-02f, -3.11199147e-02f, 8.22025090e-02f, -3.81044894e-02f, -7.47862533e-02f, 3.44014652e-02f,
  9.29780304e-03f, 8.11192840e-02f, -2.81784106e-02f, 9.51326103e-04f, -4.19568494e-02f, -4.46537808e-02f, -2.54318379e-02f, -6.45821244e-02f, -2.20893323e-03f, -1.36083094e-02f,
  -3.20696831e-02f, -6.69083521e-02f, -1.22394618e-02f, 7.37000927e-02f, -1.29061909e-02f, -2.04546470e-02f, -3.28505412e-02f, -6.61097020e-02f, 7.05225617e-02f, -8.87826551e-03f,
  4.73937541e-02f, 3.51245739e-02f, -9.82229412e-03f, -3.02655157e-02f, 3.85693461e-02f, 1.67477224e-03f, -7.50767738e-02f, 7.10373446e-02f, 5.09609506e-02f, 5.05366916e-05f,
  -2.08852351e-01f, -1.65798575e-01f, -9.31244716e-02f, -8.93547907e-02f, 1.59812649e-03f, 5.18207904e-03f, 9.52301919e-02f, -2.46674567e-02f, 5.35040013e-02f, 8.22223425e-02f,
  -3.96498479e-02f, -2.00630296e-02f, -1.13207363e-01f, -6.88236430e-02f, -2.96300445e-02f, -2.50037028e-05f, -9.11540687e-02f, -7.79908895e-02f, -7.44150877e-02f, -8.81225094e-02f,
  -1.74292088e-01f, -3.31533998e-02f, -1.39563112e-02f, -5.23177199e-02f, -1.13267433e-02f, -4.81966063e-02f, -1.46523610e-01f, -1.74819957e-02f, -5.69624603e-02f, 9.24412683e-02f,
  -2.97981143e-01f, -4.46679294e-01f, -1.66279659e-01f, -6.63816988e-01f, 2.07301214e-01f, 1.15985190e-02f, -4.26643014e-01f, -2.28058174e-01f, -5.20218790e-01f, -2.07293585e-01f,
  -1.88128591e-01f, -1.94416896e-01f, -2.46924683e-02f, -7.89115191e-01f, 1.90675616e-01f, 2.78312284e-02f, -3.91555786e-01f, -1.71870977e-01f, -1.08228900e-01f, -3.27442735e-01f,
  -1.09330557e-01f, -4.23616856e-01f, -4.63003702e-02f, -1.15629010e-01f, -3.65566939e-01f, -1.28916711e-01f, 3.20870221e-01f, 7.48593826e-03f, -3.36331241e-02f, -7.04189111e-03f,
  -2.18192399e-01f, -3.08826476e-01f, -5.79239018e-02f, 4.30157259e-02f, 4.79670316e-02f, 1.04307182e-01f, 1.44157812e-01f, 6.00937270e-02f, -2.10278779e-02f, -3.06939567e-03f,
  2.97288336e-02f, 3.20541635e-02f, -1.01785801e-01f, 8.78587924e-03f, -6.19493946e-02f, -6.99057430e-02f, -8.34557787e-03f, 5.60294800e-02f, -7.39804283e-02f, 8.27353001e-02f,
  -1.03684060e-01f, 3.68227884e-02f, 2.01620497e-02f, 5.59592210e-02f, -4.04060297e-02f, -3.70944999e-02f, 2.90395562e-02f, 1.11422107e-01f, -1.32349171e-02f, 1.12264249e-02f,
  -1.43666202e-02f, 9.22865719e-02f, -1.62436720e-02f, -5.75218685e-02f, -6.62617087e-02f, 1.04997167e-02f, 3.81587818e-02f, 4.19140644e-02f, -3.26432101e-02f, 8.50544274e-02f,
  -8.26474577e-02f, -7.18149915e-02f, -4.60851081e-02f, -3.45596336e-02f, 3.31645319e-03f, -1.55001376e-02f, 2.00964860e-04f, -2.51667947e-02f, -4.12078947e-02f, 1.01683103e-02f,
  -7.98678175e-02f, -2.62305755e-02f, -5.71792908e-02f, 3.95443738e-02f, -3.40850055e-02f, 7.51735941e-02f, -1.07676303e-02f, 2.84319650e-02f, -3.35685723e-02f, 4.56861518e-02f,
  1.14743829e-01f, -1.25804782e-01f, -1.48123233e-02f, -1.66022275e-02f, 3.20339785e-03f, 6.47591203e-02f, -8.98076594e-02f, -8.66417959e-02f, -6.74562678e-02f, -3.64670828e-02f,
  1.11525171e-01f, -2.75027249e-02f, 1.44930974e-01f, -3.49923261e-02f, -1.79667789e-02f, -3.83182988e-03f, 2.23743599e-02f, 3.15943989e-03f, 3.03012617e-02f, 1.02071270e-01f,
  5.76120242e-02f, 3.44583020e-03f, -1.10802632e-02f, -7.84821734e-02f, 1.09197833e-02f, 2.91867107e-02f, 6.45620003e-02f, 3.42001691e-02f, 4.73060608e-02f, -8.12394603e-04f,
  3.33607107e-01f, -9.41778898e-01f, 3.07368338e-01f, 3.92454922e-01f, 3.15589309e-01f, 2.56071597e-01f, 5.75603366e-01f, -3.26828271e-01f, -2.73883849e-01f, -6.77757680e-01f,
  -4.47944645e-03f, 9.48653594e-02f, -8.97846520e-02f, -2.58094128e-02f, 5.20701110e-01f, -2.51251131e-01f, 3.65696591e-03f, 1.51619211e-01f, -6.67170286e-02f, -8.53689611e-02f,
  9.89658833e-02f, -4.49371934e-02f, 2.10465699e-01f, -3.50795895e-01f, 1.87085345e-01f, -1.71813648e-03f, -3.41614075e-02f, 1.50884628e-01f, -2.46228557e-02f, 2.26010039e-01f,
  -8.28569159e-02f, -1.96881637e-01f, 4.81169708e-02f, -1.69716761e-01f, -5.43814860e-02f, 1.05534755e-01f, 9.12888199e-02f, 2.59436548e-01f, 1.30708873e-01f, -3.52796577e-02f,
  -1.57479092e-03f, -4.51387800e-02f, -3.19404118e-02f, 4.30329591e-02f, 2.81599499e-02f, -7.90748820e-02f, 5.00990450e-02f, -1.30566014e-02f, 3.49327293e-03f, 6.17720373e-02f,
  7.75794163e-02f, 4.45118902e-04f, 5.44044562e-02f, -1.51741952e-02f, 6.49241954e-02f, 4.18338999e-02f, 1.24881364e-01f, 1.10372655e-01f, -6.46725595e-02f, 9.36544791e-04f,
  -6.21539950e-02f, -1.60080697e-02f, -6.60064220e-02f, -9.59949661e-03f, 4.21294197e-02f, 3.09864897e-02f, 1.66735426e-02f, 2.97041908e-02f, 3.95862758e-02f, -2.30856314e-02f,
  4.69596172e-03f, 1.77300740e-02f, 1.97779872e-02f, -5.30400835e-02f, -1.73302628e-02f, 4.14095446e-02f, 1.73963681e-01f, -3.24359462e-02f, 1.05007943e-02f, -7.73936603e-03f,
  5.45757934e-02f, 7.84832425e-03f, -1.90923009e-02f, 4.51380908e-02f, -1.24217775e-02f, 8.03015474e-03f, -9.80474800e-02f, 4.92308512e-02f, 5.66509506e-03f, 9.70056504e-02f,
  -4.37523484e-01f, -6.25635922e-01f, -1.70311972e-01f, -8.08835309e-03f, -9.54114944e-02f, -1.15060233e-01f, 2.37593260e-02f, -7.02251717e-02f, -1.38193503e-01f, -3.92553918e-02f,
  -4.50145714e-02f, 9.15876701e-02f, -1.08657479e-01f, 3.89605910e-02f, -3.00563648e-02f, -8.90755504e-02f, -7.13306814e-02f, -2.64806133e-02f, 4.46832217e-02f, -6.78507239e-02f,
  9.09167435e-03f, -2.13788077e-02f, 4.61100601e-02f, -9.77701508e-03f, -5.65169305e-02f, 1.36925681e-02f, -2.44111363e-02f, -3.91597562e-02f, 5.35017578e-03f, -1.12080328e-01f,
  1.42644092e-01f, 2.95572102e-01f, 1.98438838e-01f, 5.15317261e-01f, 3.49314027e-02f, -1.12864738e-02f, -2.71271974e-01f, 1.35700181e-01f, -9.17066559e-02f, -2.85752535e-01f,
  2.29127910e-02f, -6.69513037e-03f, -4.03788060e-01f, 4.54346299e-01f, 5.58651209e-01f, -9.62823688e-04f, 5.31020284e-01f, 1.45411238e-01f, 1.58408791e-01f, 3.76422673e-01f,
  4.72711444e-01f, 5.09964108e-01f, 3.46742839e-01f, 4.02479619e-01f, 2.24150926e-01f, 3.00214440e-01f, 2.29685634e-01f, -9.15902182e-02f, 4.37415391e-01f, 2.18979806e-01f,
  -1.35917872e-01f, 1.18478335e-01f, -9.33998264e-03f, -9.76339206e-02f, 4.68143784e-02f, -1.06589586e-01f, -7.94182345e-02f, -5.85337402e-03f, -1.09009534e-01f, -2.32615061e-02f,
  -8.14890563e-02f, 6.27401769e-02f, 1.97982877e-01f, -2.50480548e-02f, 2.08053645e-02f, 3.93211357e-02f, 3.22505683e-02f, -5.21599911e-02f, -7.41921589e-02f, -4.46940726e-03f,
  -1.49768004e-02f, -5.35772666e-02f, 1.03198495e-02f, 3.05889547e-02f, 6.62696734e-02f, 6.54176772e-02f, 4.37207632e-02f, 3.42945084e-02f, 5.69870174e-02f, 1.38076901e-01f,
  9.17835832e-02f, -8.25293660e-02f, -4.25907709e-02f, -1.06888704e-01f, 6.38931617e-02f, 2.33560242e-02f, 4.72308658e-02f, -1.01530626e-01f, 6.55575283e-03f, 1.03483209e-02f,
  -1.64193641e-02f, 2.27555297e-02f, -3.41705233e-02f, -6.47144020e-02f, 5.14034443e-02f, -3.74763347e-02f, 3.28215510e-02f, -2.22413894e-02f, -6.76226914e-02f, -8.54045302e-02f,
  -1.99173260e-02f, 6.37208149e-02f, 1.83843914e-02f, -8.65170732e-02f, 7.70921931e-02f, -6.70472905e-02f, -2.15710234e-02f, 1.84029322e-02f, -6.26780912e-02f, -2.79208855e-03f,
  2.70928055e-01f, 6.14548922e-01f, -7.14875683e-02f, -1.53187541e-02f, 3.46093290e-02f, 1.39236435e-01f, 4.56060283e-02f, 1.40416116e-01f, 2.64971137e-01f, 1.37786150e-01f,
  -2.57647596e-03f, -3.48056927e-02f, 6.51146611e-03f, 1.85297765e-02f, 1.18859401e-02f, 1.12938702e-01f, 1.32205551e-02f, 5.48344031e-02f, 1.09656274e-01f, 1.10090822e-01f,
  -1.54446848e-02f, -2.01973729e-02f, 7.94552639e-03f, -4.23722565e-02f, 4.40564491e-02f, -3.59263830e-02f, 6.80184960e-02f, -1.39911734e-02f, 1.13276578e-01f, 4.38742042e-02f,
  -1.02664530e+00f, 5.74070156e-01f, 7.79815763e-02f, -5.77979088e-01f, 4.18058664e-01f, 3.01659456e-03f, -1.69686243e-01f, 1.73061743e-01f, -2.49550924e-01f, 1.01388879e-01f,
  5.13172336e-02f, -2.00040713e-01f, 2.47525632e-01f, -4.25466374e-02f, -8.34486723e-01f, -5.00438884e-02f, -4.59054440e-01f, -3.42128336e-01f, 9.94619504e-02f, -1.72420248e-01f,
  -3.58219862e-01f, 2.10996509e-01f, -3.48439328e-02f, 5.53019583e-01f, 1.06987238e-01f, -3.64628024e-02f, -1.53482601e-01f, 5.02419651e-01f, -8.47624466e-02f, 2.36419588e-01f,
  -2.07664371e-01f, -1.17879398e-01f, 2.92605050e-02f, 3.15121450e-02f, -1.28419712e-01f, -7.20646977e-02f, -2.48914789e-02f, 2.93691643e-02f, 4.23551816e-03f, -1.02676754e-03f,
  -2.84415856e-02f, 9.99273285e-02f, 7.03624040e-02f, 8.16026777e-02f, 3.87118594e-03f, 4.70045209e-02f, 7.65120462e-02f, 3.61379981e-02f, 1.13815717e-01f, 4.20685560e-02f,
  1.12633128e-02f, 2.41209455e-02f, -1.01374969e-01f, -6.48539364e-02f, -2.43186243e-02f, 2.66489703e-02f, -1.34133756e-01f, -8.77671465e-02f, -4.47576046e-02f, -3.89692560e-02f,
  -1.70781799e-02f, -7.24925846e-02f, 7.69765377e-02f, 1.98746985e-03f, -3.83597314e-02f, 3.68731824e-04f, 3.51136783e-03f, 3.47520076e-02f, -3.62616330e-02f, -2.35626157e-02f,
  -5.78002445e-02f, 3.15040210e-03f, 4.11340557e-02f, -6.75753206e-02f, -1.18461244e-01f, -3.02673667e-03f, -6.74094958e-03f, 1.80632025e-02f, -9.46533680e-02f, 2.20184531e-02f,
  5.01638353e-02f, 2.44604447e-03f, 7.61192068e-02f, -1.19226556e-02f, 6.96741566e-02f, 4.66889217e-02f, 1.65189374e-02f, 6.11909777e-02f, -4.16410640e-02f, -4.48778644e-02f,
  -3.09026450e-01f, -3.15007269e-01f, 4.07780372e-02f, 1.00038044e-01f, -1.74243213e-03f, 3.47808958e-03f, -2.16552671e-02f, 1.93666294e-02f, -1.10493913e-01f, -3.87927182e-02f,
  -8.00981298e-02f, -9.09668878e-02f, -1.31014854e-01f, 5.51598286e-03f, -4.25846986e-02f, 5.73993707e-03f, -1.05296746e-01f, -4.64089662e-02f, -5.28982840e-02f, -8.66106004e-02f,
  7.83578530e-02f, -4.52686334e-03f, -4.13788743e-02f, 1.91552099e-02f, -7.54809529e-02f, -3.00860368e-02f, -5.23509867e-02f, 5.25636338e-02f, 1.55421412e-02f, 1.43865421e-02f,
  1.42522991e-01f, 6.18984662e-02f, 9.65660438e-02f, 1.33779705e-01f, 1.06450329e-02f, 3.65657479e-01f, 4.90994245e-01f, -1.67863499e-02f, 1.71293497e-01f, -1.14728622e-02f,
  -2.55846292e-01f, 3.81541401e-01f, -6.13024347e-02f, -3.91617008e-02f, 3.64919424e-01f, 6.96054697e-02f, 1.66725397e-01f, 1.46090314e-01f, -5.58780506e-02f, 1.51170596e-01f,
  -1.92100294e-02f, -1.05262704e-01f, -2.94771433e-01f, -3.50348711e-01f, -1.42795548e-01f, -1.57145247e-01f, -4.49803561e-01f, -9.76125449e-02f, -2.24371448e-01f, -1.11592710e-02f,
  -8.90670493e-02f, -5.78082763e-02f, -7.06910342e-02f, 2.51132296e-03f, 5.20553254e-02f, -2.60019880e-02f, 7.13105202e-02f, 1.40906215e-01f, -2.11115349e-02f, 2.27922481e-02f,
  6.01882897e-02f, -3.39438692e-02f, 5.30095920e-02f, 2.16273349e-02f, 1.07351337e-02f, -9.49453339e-02f, -6.77325279e-02f, -1.01631038e-01f, 5.96459489e-03f, 2.57164560e-04f,
  -1.07640075e-02f, 2.48557962e-02f, -4.49449942e-02f, 3.71139124e-02f, -7.28788674e-02f, -1.24455020e-01f, 2.44075358e-02f, 3.30951102e-02f, -6.51021255e-03f, 1.00704551e-01f,
  6.16279570e-03f, 7.85610825e-02f, 6.33544251e-02f, -2.91697066e-02f, -5.42785339e-02f, -1.24487951e-01f, 1.64314285e-02f, -1.42341042e-02f, 3.38006653e-02f, -3.09791043e-02f,
  4.57511321e-02f, 2.40054186e-02f, 2.40710024e-02f, 1.98278110e-02f, 6.50297180e-02f, 1.08881406e-01f, 1.55319963e-02f, 2.03363132e-02f, 2.55884342e-02f, -3.94899063e-02f,
  -3.86284925e-02f, 4.29299511e-02f, 4.25837561e-02f, -6.91769347e-02f, 3.84376273e-02f, -1.73746496e-02f, 3.07936091e-02f, -2.02154107e-02f, -1.52794138e-01f, 1.07345451e-02f,
  1.59856215e-01f, 3.05845171e-01f, -5.95959239e-02f, 2.37069707e-02f, 2.02102121e-02f, 6.71494901e-02f, 3.15051898e-02f, 4.91319597e-03f, 1.36348903e-01f, 3.66593599e-02f,
  8.94431397e-03f, -1.69143118e-02f, 1.50889695e-01f, -6.44460320e-02f, 4.08267155e-02f, 9.36474092e-03f, 8.04905817e-02f, 5.87114133e-02f, 8.38283971e-02f, -7.15670586e-02f,
  -5.32359071e-02f, 3.88611071e-02f, 5.82250431e-02f, 4.17576693e-02f, -1.49851497e-02f, 1.87472533e-02f, 1.10556699e-01f, -7.50505477e-02f, 8.22126716e-02f, 1.94093548e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  8.09286594e-01f, 2.82415092e-01f, 7.20264077e-01f, 2.21075788e-01f, 7.06828594e-01f, 8.40345085e-01f, 3.95548880e-01f, 3.17215383e-01f, 5.69428802e-01f, 4.24385071e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.53935170e-01f, -8.65106881e-01f, 2.14591518e-01f, 5.61670959e-01f, -3.46887887e-01f, -4.38235193e-01f, 3.88053238e-01f, -1.71127081e-01f, -3.63948584e-01f, 1.12727296e+00f,
  6.91097915e-01f, -4.42183256e-01f, -1.82391867e-01f, -3.23825479e-01f, -1.49131520e-02f, -3.72506440e-01f, 1.46340132e-01f, -2.27500737e-01f, -7.70147264e-01f, -7.50374049e-02f,
  -3.74809980e-01f, 8.33186448e-01f, -1.79417402e-01f, 5.67762077e-01f, -2.75106966e-01f, 1.18944597e+00f, -2.20881701e-01f, 7.26588294e-02f, -4.51698720e-01f, 5.29028177e-01f,
  -4.38738734e-01f, 3.35455596e-01f, -6.66067600e-01f, 2.83834375e-02f, 4.97799739e-02f, -4.05946940e-01f, -1.79235175e-01f, 4.61655766e-01f, -4.00090218e-01f, 1.07552290e+00f,
  -5.91729999e-01f, -2.71003306e-01f, -5.71532071e-01f, -1.67744309e-01f, 7.75930107e-01f, 6.74839795e-01f, 1.31941363e-01f, -2.70327419e-01f, 4.08333480e-01f, 3.89356725e-02f,
  1.33758858e-01f, 6.73535228e-01f, 5.79776824e-01f, 1.01460144e-01f, 2.40935221e-01f, -2.89937049e-01f, -1.78955525e-01f, -2.92726398e-01f, -5.32942474e-01f, -2.93814182e-01f,
  -4.37921077e-01f, -2.86038727e-01f, 1.57116842e+00f, -3.79409283e-01f, 1.57096684e-01f, 2.81739468e-03f, -1.61791638e-01f, -2.13521108e-01f, -7.16080725e-01f, -3.10495406e-01f,
  -5.88878453e-01f, -4.34326440e-01f, 4.32319790e-01f, -3.30866098e-01f, 9.80059206e-01f, 4.27105755e-01f, -1.88272536e-01f, 9.23912153e-02f, 7.99443305e-01f, -2.44072556e-01f,
  -1.20245233e-01f, 4.38648760e-01f, 3.75991642e-01f, 6.52603984e-01f, -1.92042723e-01f, 2.25532889e-01f, 6.19766116e-01f, -3.49823505e-01f, 1.91354275e-01f, -3.48076731e-01f,
  7.90287077e-01f, -4.73445624e-01f, -5.47455549e-01f, 3.05952966e-01f, -7.98703909e-01f, 1.03926766e+00f, 6.38741180e-02f, -2.57004112e-01f, 9.05027837e-02f, -5.79863310e-01f,
  6.55083776e-01f, 4.61368769e-01f, -5.72656751e-01f, 7.01302290e-01f, 1.00268781e+00f, -2.50312507e-01f, 3.83731872e-01f, -7.68404782e-01f, 5.96175790e-01f, -3.05721074e-01f,
  -3.71052563e-01f, -6.93801465e-03f, 3.85149568e-02f, -4.23825443e-01f, 4.70513165e-01f, 5.80046356e-01f, 8.08896065e-01f, -3.66681039e-01f, -3.49801779e-01f, -3.70476663e-01f,
  -5.15367031e-01f, -4.90970463e-01f, 1.32975522e-02f, 1.30287349e+00f, -2.24276781e-01f, -2.48336956e-01f, -3.43761981e-01f, 7.61091411e-02f, 2.28626773e-01f, 1.32181272e-01f,
  -2.98682779e-01f, -5.38352191e-01f, -2.52699673e-01f, -7.22731233e-01f, -3.33383977e-01f, -1.92586765e-01f, -2.16467544e-01f, -3.02836418e-01f, -3.89574260e-01f, -3.57940316e-01f,
  -3.78255367e-01f, 1.49243665e+00f, -3.07186186e-01f, -3.61682802e-01f, 4.89428073e-01f, 2.14975402e-01f, 1.05879098e-01f, -9.60726589e-02f, -3.62459421e-01f, 1.84492335e-01f,
  -4.30014789e-01f, -1.39657408e-01f, -7.35151708e-01f, -4.56225574e-01f, 2.36094683e-01f, 2.56831318e-01f, 1.50003612e+00f, -4.95629370e-01f, -4.28284317e-01f, 4.37343270e-01f,
  -4.20031399e-01f, 2.29854346e-03f, -8.71496089e-03f, -1.33648944e+00f, 7.59566784e-01f, 9.09754336e-01f, 8.49730611e-01f, -1.70545615e-02f, -2.90654540e-01f, 1.07488208e-01f,
  -5.77181876e-01f, 6.61649108e-01f, -1.45033970e-01f, -3.29433233e-01f, 4.47048783e-01f, 4.42060269e-02f, 2.22865969e-01f, 2.92336762e-01f, -3.08791846e-01f, 3.54020685e-01f,
  -2.11464763e-01f, -6.59586847e-01f, 4.78619277e-01f, -4.34261590e-01f, 1.43544698e+00f, -2.27923378e-01f, -8.71221185e-01f, -4.93264347e-01f, 3.81266810e-02f, -3.03603888e-01f,
  -1.13516018e-01f, 1.83738232e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.13634598e-01f, 9.36744735e-02f, -3.54035646e-01f, -1.71839759e-01f, -9.21370536e-02f, -7.72816688e-02f, -1.31393239e-01f, 1.08528025e-01f, 8.28221664e-02f, -4.22756560e-02f,
  2.14575097e-01f, -1.09350480e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    