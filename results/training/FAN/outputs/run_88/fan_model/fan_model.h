/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.87221551e-01f, 2.34585211e-01f, 1.34873509e-01f, 3.53105575e-01f, -1.50798976e-01f, 1.87619373e-01f, 2.17786238e-01f, 8.79992098e-02f, -3.21980231e-02f, 1.79758310e-01f,
  2.29965523e-01f, -1.08751863e-01f, 1.60271481e-01f, 2.09295198e-01f, -7.71578252e-02f, 2.09180355e-01f, 2.54518330e-01f, 2.19436660e-01f, -9.10860673e-02f, 4.38612364e-02f,
  -2.14448497e-02f, 3.11536759e-01f, 1.41182303e-01f, 9.94521100e-03f, 1.35693446e-01f, -5.29751368e-03f, 1.12398013e-01f, 1.00358725e-01f, 4.50347625e-02f, -5.07871509e-02f,
  -7.62500847e-03f, -3.50276455e-02f, -2.20071133e-02f, -6.65494353e-02f, 5.98056018e-02f, -2.31758021e-02f, 1.88986138e-02f, -6.47079647e-02f, -2.51758508e-02f, 1.40407737e-02f,
  -5.64172864e-02f, -1.03283443e-01f, 4.81990874e-02f, -5.00009730e-02f, -6.34784847e-02f, -6.75930306e-02f, 2.52844747e-02f, -5.03426753e-02f, -1.45411715e-02f, -6.17971867e-02f,
  -1.59427933e-02f, -3.84668517e-03f, 5.35133667e-02f, 2.91078389e-02f, -2.61335857e-02f, 9.79138725e-03f, 3.19499522e-02f, -3.64607386e-02f, -6.33677244e-02f, 4.03868370e-02f,
  -1.30128060e-02f, -4.01461199e-02f, 3.29098180e-02f, -1.75976213e-02f, 2.73328391e-03f, 2.93661468e-02f, -2.32717562e-02f, 3.01874038e-02f, -5.21680995e-05f, 5.97359985e-02f,
  6.48387894e-02f, 6.83373883e-02f, -4.07591499e-02f, 2.62475871e-02f, 6.98761418e-02f, -5.62858395e-03f, 2.78284866e-02f, -4.28855494e-02f, -4.81326599e-03f, -4.37246002e-02f,
  -5.36462404e-02f, 3.44359130e-02f, 6.21598139e-02f, 4.21794057e-02f, -2.02764068e-02f, 2.22166516e-02f, 5.42012341e-02f, -3.12883127e-03f, 4.53400575e-02f, 1.76394992e-02f,
  1.31897181e-01f, 2.57476032e-01f, 4.85647619e-02f, 7.98529387e-02f, -6.46069506e-03f, 1.77847818e-02f, 1.68613587e-02f, -6.28581783e-03f, 7.08921701e-02f, 6.43151104e-02f,
  -3.46475095e-02f, 9.57439318e-02f, 3.21160182e-02f, -3.57310823e-03f, -1.07433544e-02f, 1.57014895e-02f, -1.52059249e-04f, 1.01489453e-02f, 1.02513760e-01f, 3.36896479e-02f,
  1.19904727e-02f, 1.00448709e-02f, -9.44135059e-03f, 7.04492703e-02f, 2.41292659e-02f, 1.01916209e-01f, -5.20763807e-02f, -5.22434190e-02f, -7.14350268e-02f, 1.16617614e-02f,
  -5.18346764e-02f, 1.91062510e-01f, -1.53354645e-01f, 9.61234570e-02f, -2.68914461e-01f, -1.39310434e-01f, -1.21522747e-01f, 3.53282019e-02f, -1.59870580e-01f, 3.21088910e-01f,
  1.22491203e-01f, 3.05881109e-02f, 1.89414605e-01f, 1.06724508e-01f, -1.32649228e-01f, 6.66044503e-02f, -6.07039928e-02f, -6.26788288e-02f, -8.09854791e-02f, 7.92554952e-03f,
  -7.59073123e-02f, 2.68403366e-02f, -4.54982370e-02f, 1.45986289e-01f, -5.17260991e-02f, 5.55297174e-02f, 7.85757080e-02f, -1.58270568e-01f, 1.84225403e-02f, -4.22949567e-02f,
  -5.30785210e-02f, 1.61685362e-01f, 4.01219539e-02f, 6.00750074e-02f, -5.23075387e-02f, 9.01822280e-03f, -1.90923624e-02f, -2.62292605e-02f, -3.75804007e-02f, 9.35759768e-02f,
  2.56082825e-02f, -9.95609257e-03f, -2.83112004e-02f, 1.47122024e-02f, -2.32400652e-02f, 6.89004734e-02f, -6.67623430e-02f, -7.96857625e-02f, 2.76746303e-02f, -6.16688058e-02f,
  7.27576297e-03f, -6.59316331e-02f, -1.01830721e-01f, 2.85339244e-02f, -3.74880657e-02f, 5.28281322e-03f, -3.49252950e-03f, -6.43841699e-02f, -7.07468987e-02f, 2.39150021e-02f,
  -2.35997718e-02f, -1.21540673e-01f, 2.88024992e-02f, -2.10697465e-02f, -5.23544140e-02f, 2.37834267e-02f, -3.68506983e-02f, 6.02420010e-02f, -2.33275965e-02f, -5.48125431e-02f,
  1.10999057e-02f, -3.74397002e-02f, -8.29090625e-02f, -2.56995279e-02f, 1.72175448e-02f, 4.27482128e-02f, -2.62860078e-02f, 5.29561006e-02f, -7.21916780e-02f, 3.25632421e-03f,
  -6.28267154e-02f, -1.05424687e-01f, -3.46336663e-02f, -2.89901644e-02f, -3.78292687e-02f, 8.68128520e-03f, -5.34705594e-02f, 8.29055812e-03f, -2.56481692e-02f, -3.21058892e-02f,
  -4.53748778e-02f, 1.12824939e-01f, 5.06114587e-02f, 6.55038506e-02f, -2.31300201e-02f, 5.96295148e-02f, -1.10952355e-01f, 5.71520589e-02f, -8.17926079e-02f, 9.30780396e-02f,
  -1.93467252e-02f, 2.03814469e-02f, 9.80532449e-03f, -1.04946978e-01f, -5.81588671e-02f, 8.34789574e-02f, 2.62998883e-03f, 2.69984137e-02f, 5.36618289e-03f, -3.43409590e-02f,
  -4.94466871e-02f, -3.72980814e-03f, -4.56946483e-03f, 5.58684357e-02f, 2.77915671e-02f, 1.83892492e-02f, 8.41203108e-02f, 1.79025326e-02f, 1.92385931e-02f, -9.07740742e-02f,
  3.17427099e-01f, -2.84335941e-01f, -1.66245326e-01f, 2.33848952e-02f, 5.32103963e-02f, 1.01719312e-02f, 2.65317619e-01f, -1.34041101e-01f, 9.94723365e-02f, -5.39573953e-02f,
  1.94497541e-01f, -7.93970525e-02f, 7.94709995e-02f, -3.07967752e-01f, 1.41318291e-01f, -1.16222107e-03f, -1.39037952e-01f, -4.16792743e-02f, -1.02773055e-01f, 7.80972913e-02f,
  7.10198209e-02f, -2.86069475e-02f, -7.58618638e-02f, -1.16236225e-01f, -1.78647581e-02f, -9.81545374e-02f, 1.39372215e-01f, 1.55262165e-02f, -9.87837911e-02f, -1.25602623e-02f,
  2.05180962e-02f, 9.92497578e-02f, -6.24152273e-02f, -1.09815314e-01f, -2.62369085e-02f, -8.30331165e-03f, 8.51682201e-02f, 1.02306008e-01f, 1.01851644e-02f, -1.11215357e-02f,
  6.72971606e-02f, 8.08756948e-02f, -7.02124536e-02f, -3.60112861e-02f, 7.09593892e-02f, -2.46210117e-02f, -2.01974660e-02f, -1.47234062e-02f, 1.30232866e-03f, -1.19306454e-02f,
  -4.51395400e-02f, -1.51639700e-01f, -5.42740943e-03f, -1.02589801e-01f, -7.44131254e-03f, 1.33925630e-02f, -7.46010691e-02f, 4.65927720e-02f, -4.71647568e-02f, -1.04537725e-01f,
  6.38685673e-02f, 7.12414756e-02f, -1.32756270e-02f, -1.01029798e-01f, -4.31968533e-02f, 9.14363749e-03f, -5.34138121e-02f, 1.42801320e-02f, -5.82486531e-03f, 8.95492435e-02f,
  3.69213112e-02f, -1.25277950e-03f, 5.60331680e-02f, 1.66655201e-02f, -3.37747447e-02f, -6.82346374e-02f, 5.64874597e-02f, 4.85793762e-02f, -7.01272339e-02f, -1.92050599e-02f,
  3.63838789e-03f, 9.32217017e-02f, 7.97214173e-03f, -2.42675692e-02f, 1.24615002e-02f, -3.51268314e-02f, 2.13847850e-02f, -3.66529115e-02f, 9.08029526e-02f, 5.76216467e-02f,
  7.36391395e-02f, 8.31837133e-02f, -5.21352179e-02f, -1.85745545e-02f, -3.68238688e-02f, -4.22468670e-02f, -6.07894585e-02f, -1.22438977e-02f, 3.60586941e-02f, 5.35166524e-02f,
  1.30869195e-01f, 4.44474295e-02f, 1.05984714e-02f, -4.62221764e-02f, -1.24943899e-02f, 9.24788881e-03f, 7.09855407e-02f, 8.39201063e-02f, 9.26431865e-02f, -6.09798869e-03f,
  2.50435621e-02f, 4.95685451e-03f, 9.42240283e-02f, 3.64609137e-02f, 1.18239075e-02f, 8.42048004e-02f, -1.03983870e-02f, -3.54376212e-02f, 3.32156904e-02f, -2.91320514e-02f,
  2.69856125e-01f, 1.27423361e-01f, 1.05542682e-01f, 2.26525411e-01f, 7.70615821e-04f, 9.01165605e-02f, -1.29941419e-01f, 1.97975710e-01f, 2.33650044e-01f, -7.31296837e-03f,
  -1.54413208e-01f, -1.11476347e-01f, -2.04353958e-01f, 8.97951499e-02f, -2.30228305e-02f, -1.63842544e-01f, 2.47670338e-01f, 6.31229952e-02f, 1.46447659e-01f, 8.75807777e-02f,
  5.33840954e-02f, 3.52622643e-02f, -4.56876755e-02f, -6.50859922e-02f, 9.33123678e-02f, 4.68500331e-02f, -1.72500461e-01f, -1.68560132e-01f, 7.72505924e-02f, -8.24105553e-03f,
  1.29013270e-01f, -1.55427670e-02f, 1.01941548e-01f, -3.67884105e-03f, 1.09606236e-01f, -1.29602700e-01f, -1.43579781e-01f, -1.86430454e-01f, 7.41082430e-02f, -2.95273736e-02f,
  -6.56158030e-02f, 3.35780275e-03f, 1.15928806e-01f, -1.13352731e-01f, -7.12167695e-02f, 7.23220932e-04f, 1.23423658e-01f, 8.21073949e-02f, -6.70027435e-02f, 2.14013364e-02f,
  1.37678206e-01f, 6.66815788e-02f, 8.47576559e-02f, 8.60239491e-02f, 9.11378209e-03f, 2.77299043e-02f, 5.94309829e-02f, -8.21140409e-02f, 1.01328641e-02f, 6.36613518e-02f,
  -8.58507380e-02f, -6.24874781e-04f, 1.20879686e-03f, 1.06577031e-01f, 1.93917397e-02f, 9.60265622e-02f, 1.11142330e-01f, -7.07010999e-02f, 9.42948237e-02f, 1.10542059e-01f,
  5.21950983e-02f, -5.20604365e-02f, -3.16592529e-02f, -1.59566030e-02f, 6.40069991e-02f, -6.60514310e-02f, -4.02286611e-02f, 6.84687942e-02f, 6.08855300e-02f, -2.45541241e-02f,
  -3.75912189e-02f, -3.70809287e-02f, -1.05157522e-02f, -1.00348093e-01f, 3.02727353e-02f, -9.62318573e-03f, -7.05742016e-02f, 4.79284935e-02f, -6.11859076e-02f, 1.39677869e-02f,
  2.35082582e-01f, 1.21984452e-01f, 7.89449885e-02f, -2.04863008e-02f, 1.66756213e-01f, -1.32619277e-01f, 4.08780500e-02f, -9.04738605e-02f, -3.08803394e-02f, -1.18398242e-01f,
  -6.02370426e-02f, 1.07055649e-01f, -2.32451111e-02f, -4.33970988e-02f, -4.66874726e-02f, 6.39731437e-03f, -1.15094043e-03f, -1.01161584e-01f, 5.64045534e-02f, -3.35259922e-02f,
  5.53454719e-02f, -2.24239454e-02f, 4.15121391e-03f, 8.21034308e-04f, -1.74735654e-02f, -1.02045294e-02f, 1.08217292e-01f, 7.62829408e-02f, -3.43101956e-02f, 1.44631229e-03f,
  -2.64493167e-01f, 2.84526855e-01f, -2.10617051e-01f, 8.52220654e-02f, -1.98313579e-01f, -2.16958210e-01f, -1.64865449e-01f, 3.95717891e-03f, 6.88400865e-02f, 2.66556919e-01f,
  -6.57804385e-02f, -9.57056880e-03f, -1.62918363e-02f, -1.83295291e-02f, -3.24954242e-01f, -5.71268909e-02f, 3.02697942e-02f, -5.39257340e-02f, 3.87766981e-03f, -3.32801305e-02f,
  -5.00559956e-02f, -9.46475193e-02f, -2.50193506e-01f, 7.67304376e-02f, -2.04316467e-01f, 1.15337474e-02f, -3.30392979e-02f, -1.36748301e-02f, -6.65031075e-02f, -1.24629892e-01f,
  -1.14558995e-01f, 4.01303880e-02f, 2.23780274e-02f, 2.89573334e-02f, -1.53790414e-01f, -1.48966182e-02f, -3.01840086e-03f, -8.72387663e-02f, 2.20727883e-02f, -5.96959591e-02f,
  2.32191924e-02f, -8.62661153e-02f, 7.72747099e-02f, -1.76062658e-02f, 1.97490733e-02f, -2.00878438e-02f, -4.11452726e-02f, -1.41863534e-02f, 7.39550730e-03f, -1.26877204e-01f,
  -4.03262824e-02f, 8.08077678e-02f, 6.01710826e-02f, 4.02735136e-02f, -1.17423385e-01f, 4.61984314e-02f, -3.31977047e-02f, -1.49705991e-01f, -3.17437053e-02f, -4.27698940e-02f,
  -8.82442892e-02f, -2.13440340e-02f, -3.57449502e-02f, -1.06649089e-03f, -8.26455876e-02f, -3.79873514e-02f, 5.24316430e-02f, 2.22788658e-03f, -5.44180200e-02f, 1.14852819e-03f,
  1.81723926e-02f, 2.51497366e-02f, 5.25622591e-02f, -1.07315689e-01f, 7.73874447e-02f, 1.24847386e-02f, -2.76601985e-02f, -2.09982581e-02f, 2.85481084e-02f, -4.25431225e-03f,
  1.67230982e-02f, 3.77643518e-02f, -5.37729785e-02f, -1.28302677e-02f, 5.13391644e-02f, 1.08229015e-02f, 6.93747327e-02f, -6.89278394e-02f, 4.24608551e-02f, -3.42358798e-02f,
  1.37352690e-01f, 1.61904603e-01f, -5.68189891e-03f, 6.56017885e-02f, 5.84839955e-02f, -1.69249866e-02f, 1.57902092e-02f, -6.22193366e-02f, 1.52875066e-01f, -8.41514170e-02f,
  -3.91452760e-02f, -4.46740910e-02f, 1.50711179e-01f, -2.91382186e-02f, 3.41898873e-02f, 7.62612522e-02f, 2.74635125e-02f, 1.95233122e-01f, 1.80231370e-02f, 1.23783562e-03f,
  -5.99759370e-02f, 1.78003311e-02f, -6.51038960e-02f, -1.33652046e-01f, -3.92211154e-02f, -5.52534238e-02f, -2.28648540e-02f, 1.10072635e-01f, -8.88533071e-02f, 2.85928063e-02f,
  8.08272511e-02f, -3.71037811e-01f, -1.54843852e-01f, -1.38148636e-01f, 2.22040743e-01f, 3.96334410e-01f, 2.52054542e-01f, -1.22862667e-01f, -1.16237074e-01f, -8.78575072e-02f,
  1.81227669e-01f, -1.43956378e-01f, -1.15509078e-01f, -5.01789525e-03f, 1.98229477e-01f, -7.81911239e-02f, 3.67264356e-03f, -8.53207931e-02f, -9.07438919e-02f, -6.07559830e-02f,
  4.02737148e-02f, 1.13278806e-01f, -9.70296413e-02f, 3.92060261e-03f, 2.31180321e-02f, -1.57950282e-01f, -1.74765680e-02f, -1.78416863e-01f, 1.10147513e-01f, 4.68776338e-02f,
  1.86783910e-01f, -1.66511059e-01f, 5.36556132e-02f, 1.04331011e-02f, 1.36188790e-01f, 4.68116924e-02f, 2.67675915e-03f, 3.28719951e-02f, -6.20057853e-03f, 2.62428951e-02f,
  -1.66800302e-02f, -8.74348506e-02f, 3.69035378e-02f, -7.26551563e-02f, 3.03656105e-02f, -1.08667873e-01f, -6.86872751e-02f, -2.75409725e-02f, -7.77590275e-02f, 5.92279993e-02f,
  -7.45792761e-02f, -2.48271897e-02f, -7.80126080e-02f, -8.63687843e-02f, 9.43860877e-03f, -1.03305265e-01f, 6.31651282e-02f, 6.93730190e-02f, 2.50036791e-02f, 1.05236195e-01f,
  3.74013856e-02f, -7.94672668e-02f, -2.19899733e-02f, -4.05685343e-02f, -8.67732242e-03f, 3.16132791e-02f, -3.33398692e-02f, 4.74004261e-02f, -1.25429332e-01f, -1.37957931e-03f,
  8.78100172e-02f, -6.97163641e-02f, 9.40915721e-04f, 2.00353432e-02f, 8.62494707e-02f, 6.32905439e-02f, 3.47916149e-02f, 2.31042691e-02f, -9.95654427e-03f, 5.26255257e-02f,
  -6.02994151e-02f, -5.84849268e-02f, 8.75717588e-03f, 7.78023824e-02f, 2.84940898e-02f, -9.22059342e-02f, -8.92493650e-02f, -5.88895977e-02f, -5.95200844e-02f, 7.86037147e-02f,
  1.16495304e-01f, -5.98686971e-02f, 4.51992685e-03f, 1.89562961e-02f, 5.32645397e-02f, 5.91599457e-02f, -9.10612494e-02f, -3.31931636e-02f, -1.18125260e-01f, 1.47467762e-01f,
  -4.61757146e-02f, -4.36670333e-03f, 1.06057525e-01f, 2.94527621e-04f, 1.68194994e-02f, 6.42605796e-02f, 2.98509859e-02f, 1.12891952e-02f, 1.10586025e-01f, 4.76388261e-02f,
  -5.32364734e-02f, 1.46765029e-02f, -7.66516849e-02f, 5.13669029e-02f, 3.98165546e-02f, 9.66587439e-02f, 1.26122624e-01f, 5.76335266e-02f, 5.15880696e-02f, -2.68660113e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.11731425e-01f, 2.96317250e-01f, -2.39149794e-01f, 1.45118581e-02f, 5.14967553e-03f, 4.04641688e-01f, 3.66874367e-01f, 1.09370753e-01f, 2.74409562e-01f, 3.98373902e-01f,
  2.33033165e-01f, 2.18894869e-01f, 1.94018379e-01f, 2.85712421e-01f, 8.37256983e-02f, 2.38135427e-01f, 2.17320830e-01f, 1.86901271e-01f, -7.15946481e-02f, 4.68036123e-02f,
  -5.87822273e-02f, 3.79539817e-03f, -1.92251518e-01f, -1.24571085e-01f, -2.01547563e-01f, -3.02207768e-01f, -8.69277194e-02f, -2.28220731e-01f, -1.19109325e-01f, 2.29457133e-02f,
  -6.08356297e-02f, -5.42977676e-02f, -8.08158144e-02f, -4.54787239e-02f, -7.85515383e-02f, -8.62546116e-02f, -2.95646191e-02f, -2.49842182e-02f, -7.57344514e-02f, -1.22679099e-02f,
  6.56371936e-02f, -4.32375483e-02f, 4.10236567e-02f, 2.37089936e-02f, 6.18473068e-02f, -3.01371571e-02f, -1.22458898e-02f, -3.61839607e-02f, -7.13477060e-02f, 1.90813020e-02f,
  -4.35946807e-02f, 2.49555670e-02f, -5.82294948e-02f, -4.91653860e-04f, -7.61328861e-02f, 2.74141803e-02f, 1.13650113e-01f, -6.18044380e-03f, 5.55317998e-02f, 8.49985033e-02f,
  6.20550010e-03f, 4.27235849e-02f, -2.97279377e-02f, -6.87558278e-02f, 3.10283732e-02f, -9.93177667e-02f, 1.22020155e-01f, -2.03346331e-02f, -7.53715215e-03f, 1.60926525e-02f,
  2.97069419e-02f, -1.09895067e-02f, 9.59679205e-03f, 8.16840585e-03f, 4.62946407e-02f, -4.43407595e-02f, 6.88530691e-03f, -2.60175653e-02f, -1.47848474e-02f, 1.34256799e-02f,
  -8.85895640e-03f, 2.46679205e-02f, -6.79626390e-02f, -4.09210660e-02f, -2.12224443e-02f, 1.90564841e-02f, -6.85468223e-03f, -1.06371120e-02f, -2.95455605e-02f, -3.89381405e-03f,
  3.03909928e-01f, 1.50731459e-01f, -2.15603206e-02f, 5.01219975e-03f, 2.60201693e-02f, 2.12944858e-02f, -8.38080142e-03f, -7.20047392e-04f, 6.31217435e-02f, -5.55253476e-02f,
  3.92992496e-02f, -1.52076660e-02f, 1.57155562e-02f, 8.63337610e-03f, 9.27486494e-02f, 1.20503396e-01f, -1.30915409e-02f, 2.32690051e-02f, 1.41589060e-01f, -4.48533036e-02f,
  -1.81475282e-02f, 3.03480588e-02f, -1.25028379e-02f, -1.02600388e-01f, 2.70864721e-02f, 1.59766320e-02f, 3.32418755e-02f, -5.84794814e-03f, 1.55697959e-02f, 3.69253829e-02f,
  1.06180474e-01f, 2.96849370e-01f, 2.46489838e-01f, 1.78024769e-01f, 3.02719623e-02f, -3.53034645e-01f, -1.20239422e-01f, 8.66589919e-02f, -1.78062066e-01f, 1.49618834e-01f,
  -3.03546432e-02f, 2.67658561e-01f, -1.65824845e-01f, 4.34696972e-02f, -3.00685197e-01f, -2.65738040e-01f, -1.57820776e-01f, 3.28933746e-02f, -9.76139158e-02f, 1.80996612e-01f,
  -8.00509751e-02f, -1.97409227e-01f, 1.60795450e-02f, -2.12616175e-02f, 8.47050697e-02f, 2.45288402e-01f, 6.00236431e-02f, 8.29737931e-02f, 1.42976359e-01f, -1.21262304e-01f,
  1.16047608e-02f, 8.13832507e-03f, 8.03397521e-02f, -8.62877369e-02f, -1.46718482e-02f, -2.03198865e-02f, 9.18746665e-02f, -1.95664223e-02f, -7.61912093e-02f, 6.27771839e-02f,
  7.53897950e-02f, -1.11726619e-01f, -4.19095047e-02f, -4.62426245e-02f, -7.27361068e-02f, -8.56984928e-02f, 7.22028594e-03f, 2.99675781e-02f, -1.05493525e-02f, -1.40737575e-02f,
  -4.65089902e-02f, 3.45107764e-02f, 8.77192989e-02f, -7.83693716e-02f, 3.22568305e-02f, -2.47228257e-02f, 3.04173003e-03f, 1.58559531e-03f, -1.20001018e-01f, -1.82946231e-02f,
  -2.12674905e-02f, -2.96193250e-02f, -5.34228086e-02f, 6.49667755e-02f, -3.45895924e-02f, -1.29137486e-01f, -5.05584925e-02f, -8.05300102e-02f, 4.84481715e-02f, -8.66295695e-02f,
  5.53735383e-02f, 3.49676013e-02f, -9.57665145e-02f, 5.48939481e-02f, 6.12753443e-02f, 8.27071592e-02f, 2.20163935e-03f, -9.13394317e-02f, 9.61962491e-02f, 6.00387901e-02f,
  -5.67820296e-03f, -1.55264689e-02f, 8.60846117e-02f, 2.10800730e-02f, 7.25326538e-02f, 2.47690231e-02f, -4.69585098e-02f, 1.43643999e-02f, 1.01828359e-01f, -6.71519786e-02f,
  7.77328014e-02f, 6.16666302e-02f, 4.83825244e-02f, -4.60367016e-02f, -2.39121169e-02f, 9.98042896e-03f, -9.65028480e-02f, 9.80789363e-02f, 1.95021667e-02f, -6.40291050e-02f,
  4.53082733e-02f, 8.12129397e-03f, 3.19183571e-03f, 4.01506238e-02f, -4.17330526e-02f, 3.51888388e-02f, -3.00217234e-02f, 4.61131893e-02f, 1.81028096e-03f, 1.58808136e-03f,
  5.52763827e-02f, -5.18972538e-02f, -4.53532599e-02f, -7.07611442e-02f, -1.98584273e-02f, -1.53751988e-02f, -6.20376468e-02f, -1.95903946e-02f, -8.58015846e-03f, 9.04910630e-05f,
  4.98919934e-02f, 3.64837885e-01f, 3.50498736e-01f, -7.70217087e-03f, 1.27814025e-01f, -4.28224578e-02f, -7.16807768e-02f, 1.51276484e-01f, -3.18454690e-02f, 1.56691492e-01f,
  -5.64116985e-02f, 3.58813018e-01f, -1.64269879e-01f, 1.16940171e-01f, -5.46084940e-01f, -2.29504764e-01f, -2.33777702e-01f, -1.17713891e-01f, -1.73307821e-01f, -2.09300984e-02f,
  -1.10696606e-01f, -3.66353095e-01f, -2.71477886e-02f, -1.15925476e-01f, 6.61757886e-02f, 1.36800036e-01f, -2.41854966e-01f, 1.17960218e-02f, -4.97429445e-02f, -2.17166077e-03f,
  -2.19432972e-02f, 2.12662652e-01f, 6.57019466e-02f, 1.88241675e-01f, -4.46315110e-02f, 2.66395006e-02f, 7.53684342e-02f, 6.02146462e-02f, -1.49378851e-02f, 1.02216452e-01f,
  1.17625512e-01f, -1.15051940e-01f, -1.86853837e-02f, -5.17601930e-02f, 1.07215084e-01f, 1.07625335e-01f, 1.19176202e-01f, 2.69996822e-02f, 1.15084223e-01f, 3.14335115e-02f,
  -1.26885502e-02f, 3.57716233e-02f, 1.48740098e-01f, -1.30609248e-03f, -1.52424974e-02f, 6.96235597e-02f, 3.18361484e-02f, -4.30551581e-02f, 6.10261895e-02f, -1.35607319e-02f,
  -9.75403469e-03f, 9.41937231e-03f, 3.79596576e-02f, 6.55168891e-02f, -7.66253322e-02f, -3.95502523e-02f, 6.44752905e-02f, -9.24232230e-02f, 6.47922456e-02f, -6.69688433e-02f,
  -7.01277331e-02f, 1.26653388e-01f, 2.71668471e-02f, -3.71823758e-02f, 3.72101516e-02f, 9.48461145e-02f, -7.93275386e-02f, 1.74749531e-02f, -1.75187755e-02f, -5.09681664e-02f,
  -3.95055674e-02f, -7.01317489e-02f, -4.96500963e-03f, 1.08734109e-02f, -2.79360320e-02f, 9.47016943e-03f, 2.21822094e-02f, 1.09805711e-01f, 2.98094247e-02f, -1.80454031e-01f,
  -2.06093177e-01f, -3.11610222e-01f, -7.08715022e-02f, 8.64585396e-03f, 1.00610377e-02f, -1.33058116e-01f, -4.05309312e-02f, 1.35967061e-01f, 1.50049077e-02f, -6.87311217e-02f,
  -5.12755811e-02f, -6.68281456e-03f, -2.72469390e-02f, 4.67186943e-02f, -2.35232309e-01f, -5.00878096e-02f, -1.66538823e-02f, 2.77111977e-02f, -4.45137881e-02f, -6.51940256e-02f,
  -8.90223403e-03f, -4.05640341e-02f, -6.51324168e-02f, -8.28917697e-02f, -1.24418791e-02f, -6.38615340e-02f, 5.47597669e-02f, -4.21574153e-02f, -1.16967387e-01f, -1.58146210e-02f,
  -5.21109879e-01f, -8.17486420e-02f, -1.15587816e-01f, 3.59700099e-02f, -1.55343756e-01f, -1.70953050e-01f, 1.90280341e-02f, -2.23933518e-01f, -1.55389771e-01f, 8.76713321e-02f,
  -7.77183026e-02f, -8.47119614e-02f, 1.25706345e-01f, 1.80775672e-01f, 7.22700804e-02f, 1.13410324e-01f, 1.00227803e-01f, -1.17885759e-02f, 1.33560881e-01f, -1.07588597e-01f,
  -5.84583022e-02f, 6.24416396e-02f, 2.07092881e-01f, 7.75455013e-02f, -3.34813483e-02f, -9.04102868e-04f, 9.39630717e-02f, 2.60014478e-02f, -7.45805949e-02f, 3.01253106e-02f,
  -2.72831053e-01f, -1.72512665e-01f, -9.85426903e-02f, -5.71810082e-02f, -7.35971034e-02f, -1.57449441e-03f, -2.23454051e-02f, -1.44645059e-02f, -1.01713575e-01f, -6.40040189e-02f,
  -1.04494043e-01f, -1.28115579e-01f, -1.20121591e-01f, 4.49777208e-02f, 2.29138024e-02f, -5.62735181e-03f, -7.70040378e-02f, 1.04623348e-01f, -1.62452385e-01f, -1.83351617e-02f,
  6.86213200e-04f, 4.63643037e-02f, -7.22677261e-02f, 1.24125458e-01f, 7.33022392e-02f, -1.12917364e-01f, 9.60489288e-02f, -1.06786927e-02f, -2.03053672e-02f, 7.98250362e-02f,
  -3.78965251e-02f, -7.06042023e-03f, -8.89968425e-02f, -8.89601931e-02f, -2.96145082e-02f, -3.10683455e-02f, -9.98902880e-03f, -4.06088866e-02f, -3.18092457e-03f, -3.18290778e-02f,
  -6.05439655e-02f, -6.41442975e-03f, 5.17261773e-02f, 7.01668188e-02f, -6.30152673e-02f, -8.45216289e-02f, 3.26011591e-02f, -6.41762540e-02f, -2.72635669e-02f, -3.60232852e-02f,
  -8.90465640e-03f, 2.35705357e-02f, 1.47376955e-01f, 2.75548492e-02f, -1.40221655e-01f, 2.23488756e-03f, -1.76624563e-02f, 1.15433231e-01f, 4.50989902e-02f, 1.11985907e-01f,
  -3.24581563e-01f, -2.33083636e-01f, -6.47392720e-02f, -7.91559145e-02f, -2.80387551e-02f, -3.61141488e-02f, 7.91569054e-02f, -7.26992488e-02f, 1.35420915e-02f, 7.43692071e-05f,
  2.99070291e-02f, 7.57780746e-02f, -5.56669310e-02f, 1.21873245e-01f, 3.47029269e-02f, -1.34011442e-02f, -5.04974015e-02f, 1.09223239e-01f, -1.86207630e-02f, -6.81254491e-02f,
  -6.85475767e-02f, -1.97009817e-02f, 9.67389047e-02f, 5.45388311e-02f, 4.87091653e-02f, 7.49316961e-02f, -6.35427013e-02f, -6.98990673e-02f, 1.85902342e-01f, -4.79818285e-02f,
  -4.84026343e-01f, -2.69983169e-02f, -8.07665437e-02f, -5.93758747e-02f, -4.79041077e-02f, 3.38405669e-01f, 2.58397490e-01f, 3.08943854e-04f, -2.22017109e-01f, 7.55136013e-02f,
  1.12004429e-01f, -8.78578201e-02f, 1.25546440e-01f, 2.47809678e-01f, 1.92959741e-01f, 8.27063397e-02f, 1.58227593e-01f, 6.90564215e-02f, -1.59465745e-02f, -1.85789853e-01f,
  -1.09734990e-01f, 1.90823693e-02f, 1.82501674e-01f, -1.40422527e-02f, -5.73697202e-02f, -1.23414516e-01f, 3.32032591e-02f, 8.84646326e-02f, 1.43962055e-01f, 2.30058372e-01f,
  -8.81797522e-02f, -2.32097343e-01f, -7.94981718e-02f, -1.36501361e-02f, 1.78163908e-02f, -8.13468248e-02f, 1.58294942e-02f, 1.00494891e-01f, -5.52733475e-03f, 1.71777401e-02f,
  -4.51800488e-02f, -9.39088594e-03f, -9.70365014e-03f, -4.01196703e-02f, -7.03132004e-02f, -1.49590420e-02f, 9.84246284e-02f, 5.74526116e-02f, -9.78758931e-03f, 2.67002899e-02f,
  2.89377309e-02f, 6.47595674e-02f, -8.82973671e-02f, 5.27263358e-02f, 3.14986929e-02f, 3.39035178e-03f, -3.94066200e-02f, 3.59378159e-02f, -6.83806464e-03f, 8.32598656e-02f,
  -1.20507136e-01f, -6.70923591e-02f, -1.42696396e-01f, 4.27001007e-02f, -1.09642912e-02f, -2.91470382e-02f, 1.52396485e-02f, 1.51895068e-03f, -3.61031666e-02f, 2.08200198e-02f,
  5.08718565e-02f, 3.80407907e-02f, 3.32672261e-02f, -8.39515869e-03f, -5.74991778e-02f, -5.38806468e-02f, -1.05169583e-02f, 1.01879640e-02f, 7.61547089e-02f, 4.65185242e-03f,
  -1.14430655e-02f, 3.06587797e-02f, -1.22759245e-01f, -4.89966087e-02f, -5.29465489e-02f, -2.62320265e-02f, -1.68526527e-02f, -2.39447616e-02f, 4.44609299e-02f, 1.84421819e-02f,
  -4.12846208e-02f, -2.39279002e-01f, -5.42175137e-02f, 3.57231386e-02f, 2.71797497e-02f, -2.53260843e-02f, -5.64137250e-02f, 5.50500788e-02f, 1.33347493e-02f, 2.55970284e-02f,
  -7.28733465e-03f, -4.62990999e-03f, -4.03437987e-02f, -4.03592661e-02f, -4.90579866e-02f, 7.81565085e-02f, -7.54814744e-02f, 6.13167919e-02f, 9.13204402e-02f, 9.97819565e-03f,
  -1.53424833e-02f, -6.24850988e-02f, 9.96754095e-02f, -8.45308676e-02f, -4.49239314e-02f, 8.47452320e-03f, -5.17388992e-02f, 7.95757771e-02f, 3.16243124e-04f, 8.51102397e-02f,
  -3.89079064e-01f, -2.56227523e-01f, -2.70779610e-01f, -9.53154415e-02f, 1.72737554e-01f, 3.08911562e-01f, -2.01999471e-01f, -2.29632948e-02f, -3.73322964e-01f, -1.94284678e-01f,
  1.68925226e-02f, -5.72964102e-02f, -3.78593743e-01f, 1.32571161e-01f, 2.61152416e-01f, -1.59087047e-01f, 2.02224836e-01f, 8.11159834e-02f, -1.09571151e-01f, -4.66514677e-02f,
  5.41706979e-02f, 2.56092757e-01f, 1.39592335e-01f, 2.59656578e-01f, -1.02940671e-01f, 3.25320177e-02f, 8.19295347e-02f, -8.72959346e-02f, 3.15280229e-01f, 2.04240695e-01f,
  9.01506543e-02f, -1.91284284e-01f, -1.28438368e-01f, -3.61861773e-02f, -1.89432241e-02f, -2.19318271e-02f, 3.70057411e-02f, 2.73725744e-02f, 7.09453523e-02f, -1.68221444e-02f,
  -1.01064807e-02f, 1.04358263e-01f, 1.92532673e-01f, -4.56685945e-03f, -3.57113704e-02f, 2.42440570e-02f, -1.08103476e-01f, 3.97261903e-02f, -9.81519595e-02f, -1.46047756e-01f,
  -1.14806101e-01f, 5.63437939e-02f, -4.79662791e-02f, 6.30578920e-02f, -6.49450347e-02f, 9.82554164e-03f, 5.57913966e-02f, -5.61528914e-02f, 1.07178926e-01f, -3.81160155e-02f,
  -2.87213940e-02f, 7.95503259e-02f, -6.66494817e-02f, 4.88782264e-02f, 2.29324810e-02f, -7.26905391e-02f, 1.08415768e-01f, 9.10452008e-03f, -5.26049994e-02f, -1.32188872e-01f,
  -1.04727119e-01f, 2.05557514e-02f, -1.57409459e-01f, -9.61868744e-03f, 4.20428105e-02f, -7.38825053e-02f, 1.52447289e-02f, -5.23692966e-02f, -7.27691054e-02f, -1.04504207e-03f,
  -2.36950684e-02f, 2.62614936e-02f, -5.39014824e-02f, 5.90642318e-02f, 8.62143710e-02f, 3.10493335e-02f, -1.23171359e-02f, -6.75117075e-02f, 4.52225003e-03f, 6.90929219e-02f,
  3.74381542e-02f, -1.77168727e-01f, -4.04181890e-02f, 1.46267256e-02f, 2.80756354e-02f, -1.29178315e-02f, 6.83122054e-02f, 9.74595323e-02f, 7.64351487e-02f, -1.00491449e-01f,
  1.04918584e-01f, 4.93859872e-02f, 1.61256269e-02f, -3.85405496e-02f, 8.97436291e-02f, -3.85639071e-02f, -6.08424097e-02f, 7.92612955e-02f, -2.35927813e-02f, -1.70965102e-02f,
  -6.41671717e-02f, -1.35670155e-01f, 1.57392204e-01f, 7.90084079e-02f, -6.63862447e-04f, -5.76436631e-02f, 4.44348902e-02f, 5.59778837e-03f, -2.96417577e-03f, -3.07483710e-02f,
  -2.31766403e-01f, -1.46775860e-02f, -2.65365213e-01f, -2.36140102e-01f, 7.09635613e-04f, -3.76061350e-01f, -4.13544834e-01f, -2.61541363e-02f, 8.86875987e-02f, -1.70567140e-01f,
  -1.81826144e-01f, 1.13361649e-01f, 1.24503136e-01f, -5.07056154e-02f, 4.28149141e-02f, 2.42544502e-01f, -2.51804948e-01f, -2.23906919e-01f, 1.48754671e-01f, -1.00143507e-01f,
  -6.04799911e-02f, -7.55728558e-02f, 1.94243133e-01f, 4.67211269e-02f, -1.32484078e-01f, -1.63318440e-02f, 1.34575531e-01f, -1.18707523e-01f, -1.47213429e-01f, 8.54718871e-03f,
  -1.40969917e-01f, 3.45574915e-02f, -1.57003850e-02f, -1.52141182e-02f, -1.51769876e-01f, -9.72881690e-02f, -7.36038461e-02f, -8.17734078e-02f, -9.10870824e-03f, -3.16379704e-02f,
  -1.22213122e-02f, -5.40886819e-03f, 4.81300056e-02f, 1.08388379e-01f, -9.55180898e-02f, -7.89838806e-02f, 4.51100525e-04f, -7.34192431e-02f, 5.55971377e-02f, -2.38141380e-02f,
  3.96459065e-02f, -1.63708124e-02f, 1.53005030e-02f, -2.73463931e-02f, 5.00972494e-02f, -1.40085697e-01f, 6.77347034e-02f, 1.39069948e-02f, -3.73382941e-02f, 2.87168995e-02f,
  9.28616524e-02f, 1.45253856e-02f, -3.81802022e-02f, 1.80534786e-03f, -1.81807054e-03f, -3.37558575e-02f, -1.29524350e-01f, -6.89057680e-03f, 2.05459911e-02f, 1.61868054e-02f,
  5.60909808e-02f, 5.30322343e-02f, -1.65922493e-02f, -6.87542409e-02f, -1.41293973e-01f, 1.10499328e-02f, 8.92672464e-02f, -3.71329114e-02f, 6.40877038e-02f, 1.95062906e-02f,
  1.10028177e-01f, -4.97452356e-02f, 4.63375375e-02f, -3.64956483e-02f, -5.40510053e-03f, 1.78971604e-01f, 1.18948929e-01f, -3.72177362e-02f, -1.96614042e-01f, -1.48810446e-01f,
  -8.14000815e-02f, -1.53137576e-02f, 2.45090630e-02f, -1.04225717e-01f, 1.94895882e-02f, -2.72171907e-02f, 1.36617303e-01f, 1.08323961e-01f, -6.91941679e-02f, -9.71944034e-02f,
  -1.84222057e-01f, 4.44379682e-03f, 3.73511994e-03f, -7.24593550e-02f, 3.82928550e-02f, -1.14329988e-02f, 2.79876846e-03f, -9.77957398e-02f, -5.05449772e-02f, 9.22936387e-03f,
  -5.86897358e-02f, -2.22654939e-02f, 1.07011430e-01f, 1.85293760e-02f, 1.36686847e-01f, -1.51274994e-01f, 7.54276738e-02f, 1.20937891e-01f, 2.78263800e-02f, 9.51609686e-02f,
  3.58696491e-01f, -2.23312080e-01f, -1.22524612e-03f, 2.14644298e-01f, 2.93602496e-01f, 1.91585854e-01f, 1.43953040e-03f, 2.10478589e-01f, 3.19179416e-01f, -1.65407583e-01f,
  -2.67703254e-02f, -1.89984635e-01f, -2.69268930e-01f, 4.46400829e-02f, 1.24648020e-01f, -1.82754800e-01f, 1.05461113e-01f, 6.92697838e-02f, 9.21318755e-02f, 3.93033028e-02f,
  1.79472417e-01f, 2.03274533e-01f, -1.97828591e-01f, 7.36473128e-02f, 1.42342463e-01f, -3.47596668e-02f, -2.12856606e-01f, -1.84921220e-01f, -1.81715891e-01f, 1.35116326e-02f,
  1.12297073e-01f, -3.99774290e-04f, -1.67627588e-01f, -4.29867916e-02f, 3.75411920e-02f, -4.14755680e-02f, -1.57766551e-01f, -3.16511430e-02f, -5.07779382e-02f, 4.63132076e-02f,
  -7.35521466e-02f, -4.18761708e-02f, 3.00468076e-02f, -7.66488537e-03f, 7.42609650e-02f, 1.23184890e-01f, 4.17745449e-02f, 2.25808769e-02f, -1.16683627e-02f, 3.91485617e-02f,
  9.43649858e-02f, -1.32977637e-02f, 1.01476200e-01f, 8.72873329e-03f, -8.05708170e-02f, 9.64743420e-02f, 9.49403867e-02f, -2.17980035e-02f, -1.74902268e-02f, -6.21530674e-02f,
  -5.61955348e-02f, -4.02332395e-02f, 6.72060549e-02f, 2.10011080e-02f, 9.22571793e-02f, 6.19220287e-02f, 1.41949384e-02f, -1.60645247e-02f, 5.83773032e-02f, -5.00895567e-02f,
  -1.27209453e-02f, 4.77839187e-02f, 6.41486375e-03f, -4.31132056e-02f, 2.42503602e-02f, 3.00532617e-02f, -1.43646551e-02f, 3.31461951e-02f, 3.63870189e-02f, 8.86332840e-02f,
  -5.18475212e-02f, 3.11864000e-02f, 2.02789810e-02f, -7.31763989e-02f, 4.14467230e-02f, 5.78117296e-02f, -3.16510126e-02f, 1.04757905e-01f, 4.70064208e-02f, -7.67543763e-02f,
  3.47321406e-02f, -6.73486590e-02f, -4.96157892e-02f, -2.80010682e-02f, -9.83919129e-02f, -2.08388641e-02f, 6.85573230e-03f, 1.00922480e-01f, 1.67703796e-02f, 8.54078531e-02f,
  4.44459803e-02f, -9.64691639e-02f, 1.05888043e-02f, -1.00189745e-02f, -1.07224531e-01f, 1.43484622e-01f, -8.22082311e-02f, -1.32790336e-03f, -2.25335341e-02f, -1.34177029e-01f,
  -3.24698165e-02f, 1.59047078e-02f, 5.99670038e-02f, 1.21342421e-01f, -1.05479686e-02f, -8.19271505e-02f, 2.50101667e-02f, -1.03692167e-01f, -3.61335278e-02f, 2.43757088e-02f,
  -3.06147516e-01f, -5.98087423e-02f, -3.31622094e-01f, -3.12564701e-01f, 1.90116838e-01f, -5.07675745e-02f, -1.05972111e-01f, 1.05091088e-01f, -7.60770515e-02f, 1.81361943e-01f,
  2.52696604e-01f, -2.89299101e-01f, 1.75554454e-01f, -3.86965573e-01f, -5.10586917e-01f, -2.41691858e-01f, -4.43439245e-01f, -1.09117270e-01f, -1.06858514e-01f, -6.66792095e-02f,
  -2.67967135e-01f, -8.21528733e-02f, -3.08577061e-01f, 2.84515172e-01f, -3.89919616e-02f, -2.42610881e-03f, 9.39683691e-02f, 2.50459045e-01f, 5.95320314e-02f, -4.82693017e-02f,
  7.60337478e-03f, 1.80478813e-03f, -2.10969672e-02f, -1.25067890e-01f, -3.95640098e-02f, -3.01796142e-02f, -1.10529475e-02f, -1.58751886e-02f, 1.34934271e-02f, -5.01260124e-02f,
  -6.38330355e-02f, -3.64828296e-02f, -2.10856050e-02f, 1.20912544e-01f, 3.69597450e-02f, 7.58100897e-02f, -7.64380470e-02f, 5.91383725e-02f, -2.96197161e-02f, -1.49728497e-02f,
  -9.61172953e-02f, -8.93282611e-03f, -1.10201634e-01f, -6.97151721e-02f, -8.30319375e-02f, 1.12756968e-01f, -3.33315227e-03f, -2.70590950e-02f, -6.53638914e-02f, 2.56811213e-02f,
  -6.22076355e-02f, -5.31066507e-02f, -9.25979242e-02f, 6.51450502e-03f, 1.00407876e-01f, 4.90490347e-03f, 1.96809787e-02f, 7.75806457e-02f, 4.55561318e-02f, -2.61049271e-02f,
  1.14524603e-01f, -8.71710479e-03f, -1.12707205e-02f, 1.16309477e-02f, -2.45972313e-02f, 2.55923532e-02f, -5.93630411e-02f, 9.98059586e-02f, -1.31198809e-01f, 6.71047643e-02f,
  7.90362770e-04f, -5.40881865e-02f, -6.56248257e-03f, -1.72813702e-02f, -2.83911098e-02f, 1.80950912e-03f, 2.98260227e-02f, -5.07165864e-02f, -4.02722694e-02f, -6.04244471e-02f,
  1.19978234e-01f, 1.37424886e-01f, 7.93044493e-02f, 1.09285280e-01f, 8.35876986e-02f, -7.20025152e-02f, -6.40278533e-02f, -2.83277407e-02f, -3.34685929e-02f, -9.52983871e-02f,
  6.41784891e-02f, 2.80155223e-02f, -3.23000737e-02f, 7.05392435e-02f, -4.88365553e-02f, 5.53072356e-02f, -9.10595357e-02f, 1.62426278e-03f, -1.05122523e-02f, 1.53523549e-01f,
  8.16678628e-02f, 2.80157989e-03f, 3.85929155e-03f, 4.50287014e-02f, 2.09976994e-02f, 1.58471793e-01f, -4.11477834e-02f, -1.08368117e-02f, 3.68388891e-02f, -2.40215268e-02f,
  1.34486049e-01f, -4.26539183e-01f, 1.38645425e-01f, -2.34341007e-02f, 1.86887130e-01f, -1.11584760e-01f, 2.10067481e-01f, -2.85601646e-01f, 2.71263067e-03f, -2.75121212e-01f,
  -3.48226428e-02f, 2.78983414e-01f, -2.80194413e-02f, -5.65072522e-03f, 5.18941522e-01f, 1.06303237e-01f, -4.25214432e-02f, 2.27323428e-01f, -5.61592355e-02f, -5.72142936e-02f,
  1.65831342e-01f, 9.01842937e-02f, 1.63497061e-01f, -2.63052791e-01f, 5.33796512e-02f, -7.66617432e-02f, 8.98138806e-02f, -2.50670500e-02f, 7.59196281e-03f, 1.25664771e-01f,
  -4.25366424e-02f, -1.15275756e-01f, -1.53547853e-01f, 7.85079785e-03f, -7.50729740e-02f, -2.40747407e-02f, 8.02244172e-02f, 8.51345882e-02f, -6.98792096e-03f, -2.14592610e-02f,
  2.94332653e-02f, -8.68537463e-03f, -2.24112216e-02f, 8.79095122e-02f, -6.66360110e-02f, -5.82694262e-02f, 6.69207051e-02f, -6.57510757e-02f, -3.13825272e-02f, 1.24026667e-02f,
  1.51449651e-01f, -6.81422949e-02f, -7.08404779e-02f, -5.42054325e-03f, 7.01054558e-02f, -7.66218230e-02f, 6.57073334e-02f, 3.09856646e-02f, -2.23486517e-02f, -6.35538308e-04f,
  3.21896300e-02f, 1.24417543e-02f, 7.84887224e-02f, 4.62238193e-02f, 1.77381951e-02f, -3.15308198e-02f, 6.38710856e-02f, 2.76216469e-03f, 4.29191254e-02f, -3.69814709e-02f,
  -5.40886149e-02f, 9.32929758e-03f, -2.77200527e-02f, -5.53242378e-02f, -6.56584417e-03f, -1.39930109e-02f, -3.80812138e-02f, -1.20920399e-02f, 6.66662082e-02f, -4.48231213e-02f,
  -1.39569473e-02f, -2.95345094e-02f, -6.48007914e-02f, 5.09753190e-02f, -8.75420286e-04f, -1.43866753e-02f, -1.13767721e-01f, -7.92273208e-02f, 3.94592956e-02f, 5.12333997e-02f,
  -3.33288819e-01f, -2.67057210e-01f, -7.66930953e-02f, -8.98630917e-02f, 1.16684353e-02f, -2.98255812e-02f, -4.97076511e-02f, -6.96816593e-02f, -1.27939939e-01f, 3.31991501e-02f,
  -8.77123922e-02f, -3.76533833e-03f, -6.48947731e-02f, 7.96199590e-02f, -3.29134017e-02f, -2.17409059e-02f, 2.84749898e-03f, -9.86044258e-02f, -1.40790522e-01f, -6.01863414e-02f,
  -3.98457758e-02f, 4.28918144e-03f, 1.35117888e-01f, -8.84813517e-02f, -7.07597807e-02f, 8.15293267e-02f, 7.09036514e-02f, -2.25943420e-02f, 5.50204329e-02f, 1.74984746e-02f,
  2.07594633e-01f, -1.75603405e-01f, 2.50857890e-01f, 9.21943262e-02f, 1.35737702e-01f, 2.68179089e-01f, 3.91538054e-01f, -1.33361697e-01f, 1.49833634e-01f, -1.41319171e-01f,
  -2.28744224e-01f, 4.99229506e-02f, 1.53003916e-01f, -1.55485854e-01f, 4.78014946e-01f, 1.00205772e-01f, 1.70260638e-01f, -6.44421726e-02f, 4.79346141e-02f, -1.70355245e-01f,
  -1.60350516e-01f, -2.12395936e-01f, -1.71756875e-02f, -1.46402493e-01f, 1.82287749e-02f, -6.94340244e-02f, -1.40888438e-01f, 1.80203989e-01f, -2.43688390e-01f, 1.94467887e-01f,
  6.97461069e-02f, 8.59823748e-02f, -6.95611387e-02f, 8.67328420e-02f, 1.56585611e-02f, 1.52825257e-02f, 2.04612147e-02f, 1.53027505e-01f, 3.80011648e-02f, -3.77260782e-02f,
  -5.70987314e-02f, 4.09245081e-02f, 3.77225392e-02f, 1.42177092e-02f, 6.91925436e-02f, -5.91492429e-02f, -9.22809616e-02f, -1.26238197e-01f, -1.74475834e-02f, -4.99329008e-02f,
  -8.48443657e-02f, 3.32035758e-02f, -4.03493382e-02f, 1.59838498e-02f, 2.08338648e-02f, 5.11855027e-03f, 2.55324580e-02f, -3.66945267e-02f, 2.04534363e-02f, 3.65227610e-02f,
  -9.32108760e-02f, 8.84981230e-02f, -1.11195952e-01f, -1.01304196e-01f, 2.39747912e-02f, -1.52939677e-01f, -9.89128575e-02f, 5.05373403e-02f, -2.56788880e-02f, -5.23992702e-02f,
  6.49921075e-02f, 1.17463745e-01f, 5.83349504e-02f, -6.79684505e-02f, -1.08684059e-02f, -1.41946062e-01f, 6.28874227e-02f, -6.00081496e-02f, -3.58714582e-03f, -1.22712351e-01f,
  -5.02665155e-02f, 6.74477890e-02f, 1.13578416e-01f, 3.78910676e-02f, 7.40734488e-02f, 1.08890072e-01f, 2.24702712e-02f, -8.81367773e-02f, -1.01958558e-01f, 4.48894920e-03f,
  -1.95028645e-03f, 1.52702525e-01f, 1.46268285e-03f, -1.22960314e-01f, -1.38661098e-02f, -1.58045217e-02f, 1.14286989e-01f, 1.89519562e-02f, 1.65330186e-01f, 6.65004998e-02f,
  1.18242819e-02f, 7.32296258e-02f, 3.53452861e-02f, -2.90782303e-02f, -9.80261900e-03f, -1.48366450e-03f, 7.38620907e-02f, 1.32399499e-01f, -2.44964119e-02f, -6.19783327e-02f,
  -1.51181415e-01f, 5.51531836e-02f, 6.04191758e-02f, -6.12646751e-02f, -3.55426259e-02f, -4.32478525e-02f, -7.45106563e-02f, -3.32153104e-02f, 1.21205583e-01f, 1.08903572e-01f,
  -5.57757139e-01f, 2.13632315e-01f, 4.34445649e-01f, -1.67767093e-01f, 2.49004550e-02f, 1.00215815e-01f, 6.25987574e-02f, 1.58726603e-01f, -1.39424026e-01f, -4.59197201e-02f,
  2.19532270e-02f, -9.40442979e-02f, 1.69337213e-01f, 2.63437834e-02f, 2.13638887e-01f, 2.80148312e-02f, -1.60806999e-03f, -6.40752465e-02f, -1.34480000e-02f, -1.43325925e-01f,
  -1.50072267e-02f, -1.08532168e-01f, 1.95447892e-01f, 5.09344973e-02f, -3.16388048e-02f, -1.26129597e-01f, 4.79582250e-02f, 2.27489427e-01f, 3.86052504e-02f, 2.32488975e-01f,
  -9.66477692e-02f, -1.54721364e-01f, -1.18525922e-01f, -4.66498397e-02f, -6.44830018e-02f, -5.41343503e-02f, 9.10559967e-02f, -7.90619850e-02f, 4.91226465e-02f, -4.14692499e-02f,
  -2.04024781e-02f, 4.40519825e-02f, -1.00141697e-01f, -2.91535091e-02f, -4.45403680e-02f, 1.11103384e-02f, 6.58446178e-02f, -9.98429675e-03f, -2.05035657e-02f, 9.76558775e-02f,
  2.23671511e-01f, 4.93837744e-02f, -1.18898936e-02f, -1.93607677e-02f, 8.52724165e-02f, 7.83123598e-02f, 5.26938997e-02f, -7.20361844e-02f, 2.56824661e-02f, -5.40576577e-02f,
  5.54899909e-02f, -5.08922227e-02f, 2.32536811e-02f, 5.12338094e-02f, 8.74996111e-02f, 7.15923831e-02f, -6.39959797e-02f, -6.68451563e-02f, -1.04141101e-01f, -3.51617951e-03f,
  -8.50066990e-02f, -5.95969707e-02f, 1.39620146e-02f, -1.73699111e-02f, 1.72267389e-02f, 7.60514438e-02f, 7.58514181e-02f, 2.83549577e-02f, 1.60508435e-02f, -2.74166949e-02f,
  3.18364352e-02f, -1.44486492e-02f, 3.88775244e-02f, -9.67493951e-02f, 5.10257855e-02f, 5.78514598e-02f, 2.63388753e-02f, 1.66450962e-02f, -9.18688402e-02f, 1.78914014e-02f,
  -6.67865276e-02f, -6.99211732e-02f, -9.28997025e-02f, -1.34927720e-01f, 4.12509888e-02f, -7.76913315e-02f, 2.77137663e-02f, -9.84995365e-02f, 5.32941371e-02f, -1.69463947e-01f,
  -1.85804311e-02f, -2.29376871e-02f, -5.82579002e-02f, 5.84890172e-02f, 1.17815770e-01f, -8.51257890e-03f, 3.38486843e-02f, -7.10292459e-02f, -1.04758002e-01f, 4.68597561e-02f,
  -2.11257786e-02f, -1.16667263e-01f, 9.84253064e-02f, -6.74120858e-02f, -1.32285625e-01f, 8.37542489e-02f, -8.93712118e-02f, -1.12484351e-01f, 4.95893834e-03f, 7.81963989e-02f,
  -4.42355573e-01f, 4.91119884e-02f, 1.96995765e-01f, -3.71423542e-01f, 1.36960879e-01f, 2.20911130e-01f, -9.75070894e-02f, 1.00822290e-02f, -1.03062943e-01f, -1.10309742e-01f,
  -1.94536269e-01f, 1.03129953e-01f, 5.19459695e-02f, -1.85710862e-01f, -1.78632155e-01f, -1.26204044e-02f, -4.07058150e-02f, 4.22157645e-02f, 8.30933601e-02f, 1.05747901e-01f,
  -2.36551315e-02f, -2.09825307e-01f, 1.15538407e-02f, 2.05402911e-01f, 1.42889405e-02f, -6.43558353e-02f, -1.81258783e-01f, 6.83602989e-02f, 1.10504583e-01f, 3.36864069e-02f,
  2.07888763e-02f, -8.84969905e-03f, -3.61798238e-03f, 1.73970927e-02f, 2.57346965e-03f, 4.11199220e-02f, -3.14649716e-02f, -3.02503314e-02f, 4.32616659e-02f, 2.55713370e-02f,
  -1.73314940e-03f, -4.82943887e-03f, -3.29362489e-02f, 7.92403370e-02f, 3.73708680e-02f, 2.82351468e-02f, 1.95278022e-02f, 4.78142612e-02f, 4.98708943e-03f, 1.29711911e-01f,
  1.07391261e-01f, 5.56966616e-03f, -3.81196216e-02f, -1.64530426e-02f, -3.68012749e-02f, -3.93466167e-02f, 2.86548901e-02f, 1.06878512e-01f, 1.11198321e-03f, 1.61403622e-02f,
  9.24072266e-02f, 7.67807662e-02f, 1.71681195e-02f, -1.55011537e-02f, 4.52422015e-02f, 4.50799391e-02f, -9.15022846e-03f, 3.84024978e-02f, 2.08120421e-02f, -1.61781698e-01f,
  -1.66792244e-01f, -3.04171699e-03f, 7.46486560e-02f, 1.33032665e-01f, 4.67843330e-03f, 3.70916501e-02f, -1.61967706e-02f, 6.94819838e-02f, -1.36836708e-01f, 2.37972587e-02f,
  -1.50898129e-01f, 7.38444030e-02f, 9.03019402e-03f, -2.96396222e-02f, 4.17053737e-02f, 2.58293822e-02f, -3.53801437e-02f, 9.53364894e-02f, -1.57711767e-02f, -4.85007837e-02f,
  -7.70298913e-02f, -1.45819977e-01f, -7.75514990e-02f, -7.22516030e-02f, -6.28550649e-02f, 6.48535714e-02f, 8.21671188e-02f, 4.40918878e-02f, -1.47663981e-01f, 5.67552540e-03f,
  -9.21930373e-03f, -7.75561184e-02f, 4.91167903e-02f, 5.88232502e-02f, 5.52836666e-03f, 6.43177377e-03f, -1.88132152e-01f, -1.26750290e-01f, -6.54171631e-02f, 1.07291073e-01f,
  -6.69679865e-02f, -1.28727838e-01f, -8.70924443e-02f, 3.50671411e-02f, -4.84667756e-02f, -6.87505901e-02f, 6.80636391e-02f, 5.52399345e-02f, 1.17950395e-01f, 4.80738431e-02f,
  1.69232488e-01f, -1.99427962e-01f, -2.38393396e-01f, 1.34282745e-02f, 1.30321383e-01f, 2.16120049e-01f, -1.34392465e-02f, 1.88827425e-01f, -1.57940909e-01f, -8.01233426e-02f,
  1.22995280e-01f, -3.30465615e-01f, -3.15346658e-01f, -6.89786002e-02f, 7.09683672e-02f, -4.44068581e-01f, -1.54516017e-02f, -4.93665822e-02f, -2.09251747e-01f, -9.60431120e-04f,
  -1.89907365e-02f, 2.81534165e-01f, 3.26094497e-03f, 3.06471735e-01f, 2.45821804e-01f, 2.38326117e-01f, 4.27144647e-01f, 2.57478356e-02f, 3.78787190e-01f, -3.28366160e-02f,
  3.07268128e-02f, -1.23272106e-01f, 3.95086855e-02f, -8.30780901e-03f, -3.77569417e-03f, 6.92153350e-02f, 1.57934457e-01f, -7.99488425e-02f, -3.49161844e-03f, -1.07699111e-01f,
  -3.73261352e-03f, -4.61186953e-02f, -6.33910950e-03f, 1.10313982e-01f, -1.65893435e-02f, 4.89311330e-02f, -5.01274243e-02f, -4.49000066e-03f, -9.70460847e-02f, -1.37795985e-01f,
  -1.22967385e-01f, -1.20331138e-01f, -8.78743641e-03f, -2.92248707e-02f, -3.57374400e-02f, -9.63798538e-02f, -1.59627236e-02f, -1.60526223e-02f, -2.61118580e-02f, 3.47885638e-02f,
  3.33656594e-02f, -9.02059898e-02f, -4.19084057e-02f, 2.15278044e-02f, -3.41738015e-02f, -1.07891075e-01f, 5.40792802e-03f, -7.33380318e-02f, 6.50283182e-03f, 3.87714361e-04f,
  1.18142543e-02f, 1.01504460e-01f, 3.94700207e-02f, 2.91580763e-02f, 2.97804810e-02f, -5.74906282e-02f, 3.45136635e-02f, 8.86167772e-03f, 2.63670646e-02f, 4.58248183e-02f,
  8.86421464e-03f, 6.09842315e-02f, -3.93805243e-02f, -2.86520980e-02f, -4.77157719e-02f, 3.40069570e-02f, 8.27398524e-02f, 1.28989853e-02f, 3.87642570e-02f, 8.44045207e-02f,
  -5.11192381e-02f, -2.27981508e-02f, -9.07199681e-02f, -3.79551314e-02f, -1.65103432e-02f, 1.02661170e-01f, -4.30698693e-02f, 6.98037744e-02f, 1.32377511e-02f, -5.85063361e-02f,
  2.19609693e-01f, -9.82213393e-02f, -6.20046034e-02f, 8.19147155e-02f, 8.68209079e-02f, 7.06285983e-02f, -5.07140309e-02f, 4.14857119e-02f, 2.17986882e-01f, 7.63036162e-02f,
  6.10111617e-02f, 1.06444143e-01f, -4.97388206e-02f, -1.20717911e-02f, 1.05557099e-01f, 2.00957898e-02f, 5.42978197e-02f, 2.92639136e-02f, -8.34515318e-02f, -2.48831362e-02f,
  -4.93080437e-01f, 2.33654007e-02f, 1.57331288e-01f, -2.45009273e-01f, -1.46648869e-01f, 1.76291570e-01f, 2.36732379e-01f, -2.08034869e-02f, -5.48417456e-02f, 1.98738396e-01f,
  1.21113874e-01f, -1.49384618e-01f, 1.44941404e-01f, -1.31683707e-01f, 8.31283778e-02f, 1.13916241e-01f, -2.90403962e-02f, -5.25546893e-02f, -1.55150190e-01f, -2.45841473e-01f,
  -1.18939862e-01f, -2.33100355e-01f, 5.98325999e-03f, -1.17413044e-01f, -2.16722414e-01f, -8.16275850e-02f, -1.05040625e-01f, -1.15900919e-01f, -6.36605099e-02f, -5.40203750e-02f,
  -1.39339283e-01f, -2.68884391e-01f, 4.29761335e-02f, -2.92941947e-02f, -8.40116572e-03f, -2.19072867e-02f, -5.12516834e-02f, 9.08444822e-02f, -4.12730239e-02f, -4.15263660e-02f,
  2.86197979e-02f, -1.62457500e-03f, -4.84899357e-02f, -6.18811278e-03f, -7.99745917e-02f, -9.92021896e-03f, -4.40453552e-03f, -5.61464354e-02f, 5.75175583e-02f, -6.31955937e-02f,
  1.74284913e-02f, 8.10439736e-02f, -6.20538332e-02f, 1.97105110e-02f, -1.91354323e-02f, 1.48597255e-01f, -1.51190516e-02f, -2.32744738e-02f, -1.35158435e-01f, -3.50185335e-02f,
  3.21814884e-03f, 5.40923662e-02f, 4.19874825e-02f, -4.65863980e-02f, -1.57535002e-02f, 3.09438035e-02f, -4.11223881e-02f, -1.81802828e-02f, 4.72565144e-02f, 5.87669611e-02f,
  4.09446843e-02f, -7.27954134e-02f, -5.50955534e-02f, -1.94902271e-02f, -3.08262128e-02f, 4.93150838e-02f, 3.12669426e-02f, 2.80039129e-03f, -4.82936613e-02f, 7.51014985e-03f,
  2.44821142e-02f, 1.33941934e-01f, -1.03993252e-01f, -8.30752775e-02f, 9.69394073e-02f, 1.22265406e-02f, -1.08834170e-01f, -6.02406971e-02f, 2.69199386e-02f, 2.13563461e-02f,
  -2.24899828e-01f, -2.92255908e-01f, 1.40063018e-01f, 6.59250375e-03f, -3.25955600e-02f, -4.96174246e-02f, -9.15279761e-02f, 5.52571863e-02f, -1.32732121e-02f, -9.03826114e-03f,
  -2.49404535e-02f, 2.07091030e-02f, 1.84257682e-02f, 4.60076071e-02f, -6.75121555e-03f, -2.84158848e-02f, -5.63969612e-02f, 6.21758960e-02f, -5.15322872e-02f, -8.02805051e-02f,
  -8.05946533e-03f, 5.09481728e-02f, 5.01474962e-02f, -1.41541976e-02f, -2.19780020e-02f, -3.54733840e-02f, -7.29958713e-02f, 1.15439780e-01f, -1.65891070e-02f, -7.71570131e-02f,
  -2.31271580e-01f, 1.15976483e-01f, -1.32523566e-01f, -2.92000175e-01f, 2.10801676e-01f, 1.68282278e-02f, -1.29538611e-01f, -1.65417492e-02f, -1.35030523e-01f, 2.80672550e-01f,
  7.21623050e-03f, 3.78393903e-02f, -2.17170753e-02f, -1.84235573e-01f, -5.41102648e-01f, -3.04717749e-01f, -2.28067890e-01f, -5.03362566e-02f, -1.96975097e-01f, -3.99824642e-02f,
  -9.92188901e-02f, -7.38350153e-02f, -1.83673114e-01f, 1.19547255e-01f, 8.83276835e-02f, 9.95077565e-02f, -2.00358462e-02f, 1.28856480e-01f, 7.78585598e-02f, -2.12347079e-02f,
  -7.15986490e-02f, -1.06570616e-01f, 2.13815691e-03f, -1.29305311e-02f, 4.19809396e-04f, 1.61051333e-01f, 8.71568844e-02f, 6.01831004e-02f, 3.84043604e-02f, 9.12603661e-02f,
  4.86591160e-02f, 7.60138184e-02f, -7.26058111e-02f, 6.51736511e-03f, 1.20094806e-01f, -3.44597269e-04f, 5.74060827e-02f, 2.02256944e-02f, 1.75135329e-01f, 4.10300754e-02f,
  4.07212414e-03f, 9.16748121e-02f, 3.32552120e-02f, -2.55309939e-02f, 6.25527874e-02f, -2.59279236e-02f, -5.97247679e-04f, 4.34056595e-02f, -2.43097693e-02f, 4.40106653e-02f,
  3.18051055e-02f, 5.72320595e-02f, -8.86828825e-02f, 4.86113392e-02f, 6.46025017e-02f, 3.87449539e-03f, -1.26856063e-02f, -2.48754118e-02f, 7.75241181e-02f, 6.81556910e-02f,
  1.96938533e-02f, -4.00198512e-02f, -5.99327385e-02f, 1.60554089e-02f, 2.25862321e-02f, 2.56847218e-02f, -1.71607884e-04f, -5.47455698e-02f, -6.19994327e-02f, -5.49395382e-02f,
  -8.69731009e-02f, -2.64169127e-02f, 7.22757801e-02f, 2.02518553e-02f, 1.74330454e-02f, 9.32992548e-02f, 7.69677535e-02f, 8.80578309e-02f, 2.64760237e-02f, -1.98102873e-02f,
  -2.23476458e-02f, 4.13497277e-02f, 2.63211988e-02f, 1.69641506e-02f, 1.47691427e-03f, -6.51636571e-02f, -1.00135833e-01f, 6.38630008e-03f, -5.37708774e-02f, -8.08901042e-02f,
  1.18124746e-01f, 2.64822170e-02f, 4.70095351e-02f, -8.40682536e-02f, 1.81248393e-02f, -2.15425305e-02f, -8.09412077e-03f, -6.70016138e-03f, -4.77769040e-03f, 5.52138779e-03f,
  1.19063474e-01f, 3.66426297e-02f, 1.96514316e-02f, 1.19407669e-01f, -3.17382533e-03f, 4.27605398e-02f, -3.20394002e-02f, -4.03446145e-02f, -2.05980856e-02f, 6.58422634e-02f,
  6.35089874e-02f, 3.54301691e-01f, 1.93194747e-01f, 4.05131161e-01f, -8.59518200e-02f, -9.34468657e-02f, -2.78723329e-01f, 2.19909281e-01f, 8.70835632e-02f, -9.17785019e-02f,
  1.34574890e-01f, 2.59238601e-01f, -1.61768675e-01f, 3.37301582e-01f, 1.14812165e-01f, -1.22773737e-01f, 1.79588839e-01f, 1.26650468e-01f, -8.13363958e-03f, 1.86357930e-01f,
  1.31529301e-01f, 2.14486152e-01f, 1.15469150e-01f, 6.05792105e-02f, 1.66079462e-01f, 2.46847823e-01f, 1.43357322e-01f, -9.04167593e-02f, 2.48829454e-01f, 8.88831913e-03f,
  -9.93384281e-04f, 1.90656170e-01f, -2.67693046e-02f, -2.36326922e-02f, -2.78458203e-04f, 1.07930578e-01f, -2.54803021e-02f, 8.28472059e-03f, -3.90295684e-02f, 4.79250923e-02f,
  8.14075992e-02f, 6.87777996e-02f, 7.14959055e-02f, -3.19051847e-04f, 5.81614615e-04f, -4.04317118e-02f, 1.06275762e-02f, 1.05977707e-01f, 7.61777461e-02f, 1.59782201e-01f,
  1.17224112e-01f, 5.02339043e-02f, 3.10485233e-02f, 3.83021683e-02f, 4.20540534e-02f, 5.25691845e-02f, 9.07069296e-02f, 1.24268614e-01f, 1.69618249e-01f, 8.20346177e-02f,
  1.01234727e-01f, -5.49904481e-02f, -1.55391882e-03f, 4.02550139e-02f, 9.87570509e-02f, -2.75185588e-03f, -4.09641005e-02f, -1.21569805e-01f, -6.18397146e-02f, 1.47350819e-03f,
  -4.62699197e-02f, 7.47724343e-03f, 2.86723711e-02f, -3.61416601e-02f, -2.32732911e-02f, 2.97201369e-02f, -1.51277468e-01f, -3.58091518e-02f, 5.89303449e-02f, 5.61528057e-02f,
  -2.33919695e-02f, -6.86099231e-02f, 3.27316374e-02f, -2.64805928e-02f, -4.19147424e-02f, 1.09414160e-01f, -4.81146649e-02f, -4.64530848e-03f, -2.27158200e-02f, 1.86505225e-02f,
  1.09199159e-01f, 3.03329706e-01f, -7.18983561e-02f, -3.14685963e-02f, 5.70040382e-03f, -4.55707349e-02f, 1.55314980e-02f, -2.17217635e-02f, 7.34117329e-02f, -5.27842045e-02f,
  1.54510802e-02f, -9.42687839e-02f, 9.72466841e-02f, 3.50118615e-02f, 4.75182757e-02f, 4.56374064e-02f, -6.07767440e-02f, -3.87667865e-02f, 1.03468085e-02f, 1.36898071e-01f,
  8.77183825e-02f, -7.31215859e-03f, 4.77688499e-02f, 7.94463679e-02f, 1.04208633e-01f, 2.05900893e-02f, 1.14737097e-02f, -6.52939454e-03f, 6.70891479e-02f, -3.63863707e-02f,
  1.90028131e-01f, 2.84817722e-02f, -1.74132496e-01f, 7.29000345e-02f, -2.69863624e-02f, -1.33506760e-01f, -1.83804199e-01f, 1.27376780e-01f, -1.90811232e-01f, -2.66025178e-02f,
  4.58850004e-02f, 3.72506753e-02f, -1.31478399e-01f, 3.74946535e-01f, 3.11043441e-01f, -4.69972147e-03f, 1.96090460e-01f, -7.05218036e-03f, -2.60827541e-02f, 2.54122257e-01f,
  1.79656669e-01f, 6.25894845e-01f, 2.08676964e-01f, 2.66266048e-01f, 2.04902962e-01f, 7.89166056e-03f, 3.39152157e-01f, 3.05048823e-02f, 2.15731993e-01f, 1.76493391e-01f,
  1.40841857e-01f, 1.18721090e-01f, -3.44073363e-02f, 1.18975108e-02f, 2.42921337e-02f, 1.29676247e-02f, 1.34589691e-02f, -2.21187738e-03f, -8.93526226e-02f, -4.53898832e-02f,
  -6.42619208e-02f, -1.96163612e-03f, -3.15950736e-02f, -2.14685798e-02f, -3.99159007e-02f, 2.10072603e-02f, -8.58637597e-03f, -5.12644947e-02f, -1.00148991e-01f, -8.51136446e-02f,
  -7.67653137e-02f, -2.89829932e-02f, -1.34854233e-02f, 4.32990640e-02f, -7.59063661e-02f, 6.32674843e-02f, -5.39974272e-02f, -2.35244315e-02f, -1.59295984e-02f, -5.11429086e-02f,
  2.52534691e-02f, -4.02333848e-02f, 3.26845944e-02f, -2.62767039e-02f, 1.02009706e-01f, 2.97309663e-02f, -7.26885498e-02f, 5.27842641e-02f, 4.02737893e-02f, 1.12747394e-01f,
  3.19693945e-02f, -3.57216187e-02f, 5.45365363e-02f, -7.41973007e-03f, -3.81514989e-02f, -5.50168268e-02f, -4.63356599e-02f, 4.51414883e-02f, -1.25158876e-01f, 6.07063062e-02f,
  1.26573639e-02f, 1.22444175e-01f, 1.81435011e-02f, 9.41012055e-03f, 2.21067909e-02f, -1.20012520e-03f, 3.53233516e-02f, -1.98766068e-02f, -5.81262633e-02f, -2.93295421e-02f,
  9.13933069e-02f, 6.79395795e-02f, 8.33888911e-03f, -4.80239540e-02f, -5.80078326e-02f, 4.81509529e-02f, 3.41429971e-02f, 2.54620761e-02f, -5.06210979e-03f, 7.69454986e-02f,
  -3.68729830e-02f, -2.83567421e-02f, -5.13136163e-02f, 1.50131121e-01f, 1.99071243e-02f, 6.61247447e-02f, 5.35749458e-02f, -4.90594618e-02f, 5.03703281e-02f, 1.36680812e-01f,
  7.05273449e-02f, -1.23808405e-03f, 8.38812366e-02f, -6.23100512e-02f, -1.56886049e-03f, 1.59830693e-02f, 2.54484657e-02f, -9.02838558e-02f, 8.14189762e-02f, -1.18859923e-02f,
  4.44982275e-02f, 3.39263976e-02f, -3.70779872e-01f, -3.59954238e-02f, -1.75528914e-01f, 2.66771555e-01f, 1.97333321e-01f, -2.28573933e-01f, -2.46110305e-01f, 1.43350273e-01f,
  1.84020221e-01f, -1.51023895e-01f, 1.32845148e-01f, 4.65060353e-01f, -1.87641904e-02f, 1.22336328e-01f, 2.45063245e-01f, 2.28217736e-01f, -1.59128755e-01f, 2.61985976e-03f,
  -1.24531880e-01f, 3.69552404e-01f, -2.40666736e-02f, 2.03962196e-02f, 9.43224803e-02f, -1.70435846e-01f, 2.42386833e-02f, -2.07041800e-01f, 1.76447425e-02f, 9.46717486e-02f,
  1.98424593e-01f, -5.17846569e-02f, -1.98941957e-02f, -4.43700068e-02f, 3.83192599e-02f, 1.11712739e-01f, -5.22199310e-02f, -3.25869620e-02f, -1.06913649e-01f, -8.59112591e-02f,
  -6.78652972e-02f, 3.99364121e-02f, -4.49007526e-02f, 8.13516614e-04f, -6.08551688e-02f, -7.08880052e-02f, -4.24759202e-02f, -1.50424968e-02f, -6.08367138e-02f, 4.63277474e-02f,
  -2.82443911e-02f, -1.08609438e-01f, -5.04017361e-02f, 1.85300782e-02f, -1.18958294e-01f, -2.05745231e-02f, -5.15564121e-02f, -7.10627735e-02f, 9.90855135e-03f, -6.28873184e-02f,
  1.67609956e-02f, 3.39490287e-02f, 1.12634271e-01f, 1.24583684e-01f, -3.69745400e-03f, 2.16022171e-02f, 9.04411450e-03f, 1.58741754e-02f, -9.99270827e-02f, 5.54289632e-02f,
  1.57174524e-02f, -4.15312592e-03f, 7.93335028e-04f, 5.02348989e-02f, 1.69373844e-02f, 4.42716330e-02f, 5.25118262e-02f, 2.10597385e-02f, -6.61771521e-02f, -3.23384963e-02f,
  -4.42913845e-02f, -1.95897147e-02f, 8.03933386e-03f, 1.50606707e-01f, 1.89104993e-02f, -1.18981265e-02f, -6.21760897e-02f, -1.75466873e-02f, -9.72837768e-03f, -5.64564615e-02f,
  3.74803133e-03f, -6.37722239e-02f, -4.82211038e-02f, 2.34648343e-02f, -2.58469358e-02f, 3.52835245e-02f, 4.41173501e-02f, -3.51894181e-04f, -5.34676462e-02f, 6.24863766e-02f,
  2.41899639e-02f, 4.74933907e-02f, -5.60717955e-02f, -6.04675412e-02f, -7.81654939e-02f, 1.81275757e-03f, 2.02041958e-02f, -2.98062284e-02f, -6.22591935e-02f, -2.77860612e-02f,
  7.20498431e-03f, 6.46682009e-02f, -5.03307581e-03f, -3.07533108e-02f, 2.55274214e-02f, -3.73076499e-02f, 5.31284362e-02f, 2.97424793e-02f, -1.01278447e-01f, -3.52661423e-02f,
  -3.74493182e-01f, -8.04667547e-02f, 5.46696931e-02f, -4.00023550e-01f, 1.16772488e-01f, 4.01275307e-02f, -1.78629383e-01f, 8.82180501e-03f, -2.25556836e-01f, -2.03383669e-01f,
  -4.33548354e-02f, -9.01231244e-02f, 1.32683247e-01f, -1.97771192e-01f, 3.77865314e-01f, 1.54323563e-01f, 2.06643320e-03f, -4.16348763e-02f, 2.00262349e-02f, -1.78950965e-01f,
  -8.05973113e-02f, -2.52337694e-01f, 1.66464508e-01f, -1.98865179e-02f, -1.29781663e-01f, -1.65935323e-01f, -4.44763266e-02f, 3.94397117e-02f, -6.61192834e-02f, -3.14088725e-02f,
  1.40223414e-01f, -2.43944019e-01f, 7.70646110e-02f, 1.43065810e-01f, 7.78588727e-02f, -5.05316518e-02f, -2.23278645e-02f, 1.22970147e-02f, -3.32857966e-02f, -4.73812781e-02f,
  -2.27723573e-03f, 6.06039166e-03f, -7.82944709e-02f, 1.90986053e-03f, -1.67376503e-01f, -2.40531657e-02f, 5.44938259e-02f, 1.92823522e-02f, 1.14398845e-01f, 9.27430540e-02f,
  2.85880696e-02f, -4.45458330e-02f, -8.63687471e-02f, -1.78600475e-01f, -3.19518521e-02f, -1.03590451e-01f, 5.99617139e-03f, 1.19485229e-01f, 2.37257518e-02f, -1.81596369e-01f,
  -9.10166129e-02f, -4.01372686e-02f, 1.58341788e-02f, 6.43752664e-02f, -6.88759238e-03f, 2.06398545e-03f, 2.41466127e-02f, -6.26213998e-02f, -4.10871431e-02f, -6.30173981e-02f,
  -3.15474197e-02f, 2.05887258e-02f, -3.55838798e-02f, -8.51842985e-02f, -7.09270090e-02f, -5.98363429e-02f, -3.25757228e-02f, -2.53884774e-02f, -6.30795211e-02f, -3.58220935e-02f,
  1.13685308e-02f, -4.10557203e-02f, 1.06245726e-01f, 1.57462340e-02f, -1.92230362e-02f, 5.41735208e-03f, -2.17753015e-02f, 4.97086756e-02f, 5.16715087e-02f, 7.44267087e-03f,
  -1.59114506e-02f, -2.38591820e-01f, 4.92344145e-03f, 7.99447671e-02f, 1.08030528e-01f, 4.22386220e-03f, -3.48665379e-02f, 6.44969270e-02f, 8.95337388e-03f, 3.02699227e-02f,
  -5.57648353e-02f, 1.82368176e-03f, 5.27189448e-02f, -2.99039185e-02f, -4.15369794e-02f, 6.06700517e-02f, -9.74306092e-03f, 1.31475162e-02f, 6.25891089e-02f, -1.33503349e-02f,
  8.61893073e-02f, -9.70920399e-02f, -1.83200520e-02f, -3.87416743e-02f, -2.46871263e-02f, -2.29198169e-02f, 1.12276487e-01f, -1.87442440e-03f, 6.60462230e-02f, -1.06409285e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.51129842e-01f, 8.80173668e-02f, 2.11479398e-03f, 8.76092017e-02f, 1.75667122e-01f, 2.06762671e-01f, 1.73300043e-01f, 1.20994285e-01f, -4.55288514e-02f, 6.13355972e-02f,
  2.02612340e-01f, 1.19776897e-01f, 1.87734753e-01f, 3.14715952e-01f, 8.62072781e-02f, 9.55421776e-02f, 6.89595863e-02f, 1.08305641e-01f, -4.29260023e-02f, 1.27698034e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -9.43472832e-02f, 4.17155139e-02f, -7.46217668e-02f, -7.76286274e-02f, 9.22596455e-02f, -2.12488964e-01f, 6.52104318e-02f, 8.25516060e-02f, 1.77558996e-02f, -1.36179954e-01f,
  -1.76295593e-01f, 5.97727969e-02f, -1.08928710e-01f, -1.74616158e-01f, -9.57383215e-02f, 2.85861194e-01f, 2.83595830e-01f, 1.96936563e-01f, 7.28105083e-02f, -1.53732479e-01f,
  -1.18250921e-01f, 6.15750663e-02f, -1.57564431e-01f, 3.47694814e-01f, -6.26326874e-02f, 6.56762347e-02f, 3.34723815e-02f, -3.14496249e-01f, 4.76122461e-03f, 4.67376232e-01f,
  2.35483482e-01f, 2.31825039e-01f, -7.59472027e-02f, -2.36778885e-01f, -9.64330435e-02f, -2.72537172e-02f, -7.73713142e-02f, 3.25513333e-02f, -4.62174416e-02f, -2.79142894e-03f,
  -3.34811062e-01f, -4.06706855e-02f, 1.31039336e-01f, -3.49618137e-01f, -2.22935621e-02f, -4.53757457e-02f, 2.86528349e-01f, 1.94711685e-01f, 1.15226712e-02f, -1.52539954e-01f,
  1.13763444e-01f, -3.02554756e-01f, -7.51183406e-02f, -1.98336229e-01f, -1.21092826e-01f, 2.19524339e-01f, 2.49267742e-01f, -4.79198962e-01f, 2.70979494e-01f, -1.34964883e-02f,
  1.39925689e-01f, -2.36532703e-01f, -5.28336950e-02f, 3.62240738e-04f, 1.66105211e-01f, 1.86347008e-01f, 8.08583498e-02f, 9.17109251e-02f, 8.65005329e-02f, 1.43326253e-01f,
  -1.64997801e-01f, -2.27184501e-02f, -1.06266342e-01f, 2.14484721e-01f, -1.68689102e-01f, -6.39607236e-02f, 1.83648884e-01f, 1.55568510e-01f, -6.77628517e-02f, -2.86861688e-01f,
  -1.29962862e-01f, 6.70381188e-02f, -4.35406379e-02f, 1.31755695e-01f, -1.91851526e-01f, 3.33742760e-02f, 4.58511636e-02f, -2.59667754e-01f, 2.13655159e-02f, 2.96026707e-01f,
  -2.46925771e-01f, 7.01820618e-03f, 3.83209258e-01f, 2.64762521e-01f, -2.96926379e-01f, -1.35316461e-01f, -2.84125119e-01f, 1.01905696e-01f, 2.65694857e-02f, 1.33635625e-01f,
  1.16295516e-01f, -3.38078618e-01f, 1.38584048e-01f, 2.49225691e-01f, -8.09581205e-02f, 1.78309634e-01f, -9.49694142e-02f, 5.25903702e-02f, 9.16198418e-02f, 1.38315156e-01f,
  1.71016186e-01f, 1.73318163e-01f, 2.04527527e-01f, 2.82572269e-01f, -1.70897990e-01f, -5.80715872e-02f, -3.22707236e-01f, 5.51858097e-02f, -2.24372357e-01f, -7.52867833e-02f,
  -2.82068998e-01f, 2.41957411e-01f, -1.71871051e-01f, -1.09893464e-01f, 7.54751712e-02f, 3.01889449e-01f, 3.59405547e-01f, -2.79604524e-01f, 2.18097731e-01f, -6.99279755e-02f,
  -5.53143881e-02f, 1.45069838e-01f, -3.54349911e-02f, 1.95757166e-01f, -1.78085476e-01f, -9.57464799e-02f, 9.54157412e-02f, 2.18035370e-01f, -1.53555974e-01f, 3.49343717e-01f,
  -9.15848985e-02f, -1.69721901e-01f, -3.60907167e-01f, -2.44573101e-01f, -9.22486186e-02f, 1.00582704e-01f, -1.41737357e-01f, 3.13267827e-01f, 1.74448296e-01f, 4.37283963e-02f,
  -9.81886536e-02f, -3.62896532e-01f, -1.64292574e-01f, 3.95265728e-01f, -2.49675080e-01f, 1.56804666e-01f, -2.57939368e-01f, -7.74827413e-03f, 9.91942361e-02f, -1.71565756e-01f,
  4.85908054e-03f, -4.14467826e-02f, -9.41448733e-02f, -1.91826314e-01f, -4.68395799e-02f, 1.19079771e-02f, -9.91921350e-02f, -7.25365877e-02f, 6.62198365e-02f, -1.13755308e-01f,
  1.40691236e-01f, -6.96993098e-02f, -2.53608465e-01f, -1.28443912e-01f, 2.32772771e-02f, -7.61845633e-02f, -7.55840614e-02f, 8.20059106e-02f, 1.78264931e-01f, -1.42765775e-01f,
  2.66769320e-01f, 3.97573382e-01f, 6.35378584e-02f, 8.98547750e-03f, 1.46684393e-01f, -2.42660474e-03f, 7.47902766e-02f, 4.26762141e-02f, 1.58496961e-01f, 6.52770475e-02f,
  -3.79561722e-01f, 3.52834344e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -2.86721051e-01f, 1.86677471e-01f, 1.16640858e-01f, -5.80939688e-02f, 1.10268235e-01f, 1.06984720e-01f, 2.67972262e-03f, -5.70704862e-02f, -5.06893359e-02f, -3.84644330e-01f,
  1.46612167e-01f, -8.82180873e-03f, 7.95680061e-02f, -1.66915044e-01f, -1.27537921e-01f, 4.07458335e-01f, 1.49077863e-01f, 1.74871698e-01f, 3.49732220e-01f, -2.79300630e-01f,
  -6.90811276e-02f, 1.89637467e-01f, 2.18216315e-01f, 1.87618658e-01f, 2.27341458e-01f, -3.67875159e-01f, 4.04872566e-01f, -1.66049585e-01f, -3.09054434e-01f, 3.75824049e-02f,
  4.43611629e-02f, 3.44032347e-01f, -2.98129648e-01f, 1.10605136e-01f, 1.22615516e-01f, 2.37014398e-01f, 2.39553422e-01f, 7.81204402e-02f, 3.38075638e-01f, 3.38428855e-01f,
  3.64748202e-02f, 8.50336701e-02f, 2.85721213e-01f, -8.15661773e-02f, 5.11679471e-01f, -5.00066355e-02f, -2.34574199e-01f, 1.71772577e-03f, 1.58153445e-01f, -8.03699121e-02f,
  2.96623975e-01f, -4.47337190e-03f, -1.43401220e-01f, -4.26289469e-01f, 2.61701614e-01f, -3.73769365e-02f, -2.56294399e-01f, -1.10473879e-01f, 1.29184693e-01f, -2.78178692e-01f,
  3.07528973e-01f, 1.68160215e-01f, 2.73329705e-01f, -6.50339648e-02f, -4.33470219e-01f, 6.78820387e-02f, 3.11508607e-02f, 5.38907610e-02f, 3.39914829e-01f, 7.88523853e-02f,
  2.08333120e-01f, 1.06607474e-01f, 3.95811237e-02f, -1.26457391e-02f, 1.77566096e-01f, -1.39892668e-01f, 4.41833556e-01f, -1.40414432e-01f, -1.07384242e-01f, 1.07098222e-01f,
  2.06443039e-03f, -1.40015617e-01f, 3.23401511e-01f, 2.28700992e-02f, 2.28995588e-02f, -2.04198629e-01f, 8.39405656e-02f, 3.09227128e-02f, -3.17425281e-02f, -1.04807205e-01f,
  2.36225128e-01f, -1.79352507e-01f, 9.27235484e-02f, 1.20059937e-01f, 1.59721062e-01f, 2.31935665e-01f, 3.08963120e-01f, 2.20485330e-01f, 1.48313582e-01f, 2.07967341e-01f,
  5.15336245e-02f, 1.05221443e-01f, 6.71954006e-02f, -1.55349389e-01f, -2.42773324e-01f, -4.18019062e-03f, 2.85247892e-01f, -7.89756998e-02f, 1.75441653e-01f, 9.07823741e-02f,
  2.75907815e-01f, 2.21296459e-01f, 2.68780947e-01f, 3.26587707e-01f, 6.14794856e-03f, -8.54545608e-02f, 2.22263619e-01f, -1.74316436e-01f, -6.16487861e-02f, 2.02051044e-01f,
  3.44689280e-01f, 3.69412452e-02f, 2.79729724e-01f, 1.78604335e-01f, 4.12099846e-02f, 2.24888977e-02f, -7.78007805e-02f, 3.26848835e-01f, 1.97688296e-01f, 2.00485364e-02f,
  -3.98076177e-02f, 5.18024527e-03f, 1.06351860e-01f, 6.68484122e-02f, -8.38844627e-02f, 9.79069546e-02f, -2.09507570e-01f, 8.80553797e-02f, 2.17170134e-01f, -9.53280851e-02f,
  -2.01723516e-01f, 1.95294484e-01f, 2.01619446e-01f, 1.78452075e-01f, 1.02118561e-02f, 1.18833348e-01f, 9.89684761e-02f, -7.75125474e-02f, 3.26175064e-01f, -2.61561871e-02f,
  -2.36491770e-01f, 1.53396964e-01f, 2.66074181e-01f, -7.31513724e-02f, 5.86644597e-02f, 3.60011816e-01f, 2.66983598e-01f, 8.33685137e-03f, -1.54548749e-01f, 1.25321612e-01f,
  2.24453345e-01f, 2.39590272e-01f, 3.07583392e-01f, 1.61633417e-01f, 2.18238279e-01f, 2.31547639e-01f, -1.70808777e-01f, -1.90243870e-01f, -1.53820775e-02f, 3.12560678e-01f,
  -1.56862572e-01f, 1.57850295e-01f, 2.91445553e-01f, 4.84181046e-02f, 2.11470276e-01f, -2.28822619e-01f, 1.34046838e-01f, 2.42037520e-01f, -2.08760515e-01f, 4.32681143e-01f,
  -1.71960056e-01f, 9.68815535e-02f, 1.25660539e-01f, -1.33861229e-01f, 3.00837010e-02f, 3.94050986e-01f, -9.81554985e-02f, 6.75888674e-04f, 2.56014377e-01f, 1.73867270e-01f,
  5.04659954e-03f, 9.60580111e-02f, -1.35743871e-01f, -4.68256809e-02f, 2.14737386e-01f, 1.33189395e-01f, 1.12536848e-01f, -1.32142797e-01f, 9.22391787e-02f, 1.17382936e-01f,
  -1.30748942e-01f, 1.29035652e-01f, -1.62084669e-01f, -3.17878693e-01f, -2.95415610e-01f, 2.53744543e-01f, 2.12154910e-01f, -1.08197145e-01f, -3.17378759e-01f, -2.55859226e-01f,
  1.68726481e-02f, -2.86145657e-01f, -3.81270438e-01f, 1.29293855e-02f, -2.49894455e-01f, 1.03212528e-01f, -7.34732905e-03f, 7.37686753e-02f, -6.27656132e-02f, 4.11395356e-03f,
  4.13193673e-01f, 3.20917040e-01f, -2.68808454e-01f, -1.08505398e-01f, -2.73313094e-02f, 1.40372142e-01f, 5.43204136e-02f, 5.39759547e-02f, 7.99030587e-02f, -8.82501453e-02f,
  2.36849878e-02f, 2.50920206e-02f, -2.92092860e-01f, -2.56276205e-02f, 5.33923320e-02f, -3.39406073e-01f, -1.89649507e-01f, 2.26213887e-01f, 3.23797405e-01f, 1.87274188e-01f,
  1.44084498e-01f, 1.99685022e-01f, 2.86542803e-01f, -2.47686237e-01f, 3.03683113e-02f, -1.86236262e-01f, -3.91432524e-01f, 1.88398793e-01f, 1.69328615e-01f, 1.09314434e-01f,
  5.63199744e-02f, 1.29160523e-01f, 9.85798985e-02f, 1.18068151e-01f, -1.13038607e-01f, 1.41234577e-01f, -1.09895691e-02f, 1.25012964e-01f, 2.73867999e-03f, 5.33685498e-02f,
  1.43647149e-01f, -2.71341026e-01f, -1.81513071e-01f, 1.22048587e-01f, -3.19944471e-01f, 1.46066695e-01f, -3.35728005e-02f, -2.05721110e-01f, 7.75720272e-03f, 5.04651070e-02f,
  5.06339133e-01f, 2.19866112e-01f, 2.18952224e-02f, 2.72990912e-01f, 7.20152259e-02f, -1.38175935e-01f, -6.92266300e-02f, -3.57831985e-01f, -2.78545350e-01f, 2.00637057e-01f,
  2.72771090e-01f, -6.08084127e-02f, 2.09129497e-01f, 9.00982320e-02f, 2.27618098e-01f, 2.89281607e-01f, 1.44067749e-01f, 1.95319504e-01f, -1.20149672e-01f, 1.24191269e-01f,
  4.64740172e-02f, 1.93361744e-01f, 3.09663117e-01f, -9.46089551e-02f, 1.20493688e-01f, 8.97600278e-02f, -2.26531044e-01f, 1.93360984e-01f, 7.87527338e-02f, -8.16628560e-02f,
  2.87036598e-01f, 2.24959597e-01f, 1.67068407e-01f, 1.50190577e-01f, 1.77987829e-01f, 2.29047626e-01f, 7.72178397e-02f, -1.24655701e-01f, -1.13977112e-01f, -3.55683833e-01f,
  -1.65908366e-01f, 2.09190667e-01f, 1.71720251e-01f, 4.80291201e-03f, 9.95668545e-02f, -4.76770699e-02f, 3.08038741e-01f, 3.39517802e-01f, 2.53116697e-01f, 4.72163185e-02f,
  2.87326127e-01f, 1.76471472e-01f, 1.49297744e-01f, 1.64639447e-02f, 1.78112090e-01f, 2.52939999e-01f, -1.07349281e-03f, -5.18076234e-02f, -7.34779760e-02f, 3.02876323e-01f,
  2.53201604e-01f, -5.27215004e-02f, 1.90164149e-01f, 2.54776567e-01f, 1.23575471e-01f, -5.52355051e-02f, -2.55507808e-02f, -1.57022867e-02f, 6.01312146e-02f, 1.55739412e-01f,
  3.35869104e-01f, -6.65037483e-02f, 2.85659190e-02f, 1.24432724e-02f, 2.70962000e-01f, 1.29440591e-01f, -7.42364749e-02f, 3.48732054e-01f, 2.41500169e-01f, -5.52425440e-03f,
  -3.50123614e-01f, 1.33568093e-01f, 2.28057504e-01f, 4.14940454e-02f, 1.38932526e-01f, -1.31494820e-01f, 7.38790408e-02f, 3.80484521e-01f, 4.60582376e-02f, -4.20095079e-04f,
  3.16602021e-01f, -6.83453977e-02f, 2.25647822e-01f, -8.02375972e-02f, 1.82590678e-01f, -9.07296911e-02f, -3.55009764e-01f, -2.01435499e-02f, -2.43028641e-01f, -2.59955287e-01f,
  3.67665976e-01f, 2.20538244e-01f, 5.64177096e-01f, 2.65334189e-01f, 1.98709697e-01f, -1.36679307e-01f, 1.29664717e-02f, 8.62830654e-02f, -4.51603346e-02f, 2.33659297e-01f,
  -1.01922669e-01f, -1.90634102e-01f, -3.57893705e-01f, -4.72364528e-03f, -1.67240888e-01f, 2.20958009e-01f, 1.99834719e-01f, 1.54057741e-01f, 3.03239256e-01f, -1.47339389e-01f,
  2.00350568e-01f, 3.96441966e-02f, -5.22642732e-02f, 1.06082313e-01f, -6.14311472e-02f, 1.10029161e-01f, 3.77747625e-01f, 9.45348572e-03f, -1.19860522e-01f, 2.47137502e-01f,
  2.47709692e-01f, 2.44836763e-01f, 1.19030319e-01f, 1.52851775e-01f, -2.92770326e-01f, -1.67262360e-01f, 1.21967949e-01f, 1.94066629e-01f, -6.95863888e-02f, 1.40538767e-01f,
  1.34562090e-01f, -2.33872145e-01f, 5.57461828e-02f, 3.69714975e-01f, 4.03312474e-01f, 1.48995101e-01f, 4.19342637e-01f, 1.32196620e-01f, 1.87148109e-01f, 1.21802881e-01f,
  2.04247698e-01f, 4.24973182e-02f, -1.11158593e-02f, 4.59498242e-02f, 6.21557720e-02f, 1.49362134e-02f, 1.53757229e-01f, -1.21341117e-01f, -3.81586492e-01f, 3.79797488e-01f,
  2.56571501e-01f, -4.61911671e-02f, -1.87225804e-01f, 2.96018243e-01f, -1.64470505e-02f, 6.95733204e-02f, 3.21690917e-01f, -8.35573599e-02f, -3.07198375e-01f, 1.06276676e-01f,
  1.16007864e-01f, 3.03120315e-01f, -7.58934841e-02f, 3.71260643e-01f, 1.99759021e-01f, -6.85249195e-02f, -2.11045444e-01f, 1.94915999e-02f, 2.33271837e-01f, 1.34068653e-01f,
  1.69391617e-01f, 9.91218239e-02f, 1.91480994e-01f, 8.67103040e-02f, -2.06804678e-01f, -1.04641400e-01f, 6.30510449e-02f, 1.37079254e-01f, -2.50824779e-01f, 8.37633982e-02f,
  1.14521734e-01f, 7.77822509e-02f, 1.01900995e-01f, -1.01143904e-01f, 1.16733886e-01f, 1.67579919e-01f, -1.38783440e-01f, 1.31299168e-01f, -1.59603789e-01f, 1.07793123e-01f,
  1.72656164e-01f, 8.49789828e-02f, 7.21679330e-02f, 3.67678195e-01f, -1.05237186e-01f, 2.54420191e-02f, 1.51336566e-01f, 2.54585266e-01f, 2.14486167e-01f, 2.67141461e-02f,
  4.46124107e-01f, 2.52787352e-01f, 5.48643097e-02f, 1.18823364e-01f, -7.94228613e-02f, 2.49551073e-01f, 4.92414981e-02f, -3.19149315e-01f, 3.09758093e-02f, -1.84189111e-01f,
  -1.63232476e-01f, 3.01079690e-01f, 9.13809389e-02f, -9.55059007e-02f, -4.81479093e-02f, 1.38079002e-01f, 1.42805353e-01f, 2.87502468e-01f, 1.77980736e-02f, 2.59213597e-01f,
  1.09625570e-01f, 2.91337401e-01f, 2.47726247e-01f, 1.71049237e-01f, 2.21776396e-01f, 1.83204353e-01f, 1.31777480e-01f, 2.12339133e-01f, -9.51916799e-02f, 5.71561903e-02f,
  7.37921055e-03f, 1.78350389e-01f, -2.18866184e-01f, -1.90012187e-01f, -1.63234502e-01f, -2.35084221e-01f, -2.56170541e-01f, -1.74008220e-01f, -3.61356378e-01f, 1.39599159e-01f,
  2.67223138e-02f, -2.17267066e-01f, 1.19908333e-01f, -3.59220982e-01f, -1.40070748e-02f, -9.41663012e-02f, 3.10754597e-01f, -4.08621952e-02f, -1.85748488e-01f, -3.30206037e-01f,
  2.47809172e-01f, -1.16975628e-01f, 4.16470081e-01f, 3.24285775e-02f, -7.76276737e-02f, -4.18938510e-02f, -4.55105752e-02f, -2.62641370e-01f, 1.78481996e-01f, -1.48078483e-02f,
  -2.38384437e-02f, -3.02948467e-02f, -7.73187540e-03f, 1.63015395e-01f, 4.11263764e-01f, 2.78703600e-01f, 2.68854737e-01f, 1.70596913e-01f, 5.69543839e-02f, 1.20774545e-01f,
  -2.01975688e-01f, -2.62428343e-01f, -1.17738657e-01f, 2.14969546e-01f, -2.33227193e-01f, 2.30868995e-01f, 2.39988774e-01f, 4.73470753e-03f, 2.80490845e-01f, -1.34564668e-01f,
  8.92003402e-02f, 1.96660921e-01f, -2.40570724e-01f, 1.88651383e-01f, -2.01458573e-01f, 9.92350802e-02f, 2.45356888e-01f, 7.26688877e-02f, 1.97349578e-01f, 2.46020511e-01f,
  9.66901556e-02f, -1.27701685e-01f, 1.05243266e-01f, 5.11105265e-03f, 9.76596400e-02f, 1.68985203e-01f, 1.69680238e-01f, 5.70932887e-02f, 3.36514488e-02f, -1.39222071e-01f,
  -3.64497602e-02f, 8.12935457e-02f, -2.93484796e-02f, -1.77547991e-01f, 8.51144716e-02f, 6.83735758e-02f, -1.76604047e-01f, 5.46877645e-02f, -6.43840060e-02f, -1.85524330e-01f,
  -8.84647369e-02f, 1.29992180e-02f, 7.98209235e-02f, -1.78706944e-01f, 3.40471342e-02f, 2.91218936e-01f, -1.50366321e-01f, 2.40709901e-01f, 2.55326778e-01f, 1.79566473e-01f,
  -6.96572512e-02f, 4.92489599e-02f, 5.68683334e-02f, -1.34792969e-01f, -5.97434081e-02f, -1.07181855e-01f, -6.47551864e-02f, 5.90274781e-02f, 3.32617044e-01f, -4.71815057e-02f,
  1.09077103e-01f, -8.27050880e-02f, -1.74429238e-01f, 8.56889114e-02f, -1.02068625e-01f, -2.69589573e-01f, 4.71795239e-02f, -3.18359137e-01f, -1.62374258e-01f, 3.05560648e-01f,
  -3.78765732e-01f, -9.14878622e-02f, -2.20824435e-01f, 2.54919440e-01f, 3.20072800e-01f, 2.71538019e-01f, 3.03114802e-01f, -6.54244572e-02f, 3.45583439e-01f, 4.77274448e-01f,
  2.90011972e-01f, 3.63398403e-01f, 2.91088969e-01f, 2.92964816e-01f, 2.55338311e-01f, 7.47565255e-02f, -2.24861979e-01f, -2.00248566e-02f, -1.29518911e-01f, 4.31861013e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.75029889e-01f, 1.12524740e-02f, 1.79961234e-01f, 2.24688396e-01f, 2.23582517e-02f, 4.45031710e-02f, -8.42729434e-02f, 1.81380302e-01f, 1.08213864e-01f, 1.45344451e-01f,
  2.87276506e-01f, 3.11281502e-01f, 6.14418238e-02f, 1.65801108e-01f, 5.58784381e-02f, 2.22036019e-01f, -3.85434330e-02f, 1.13882229e-01f, 5.37588894e-02f, 1.30672649e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.84711958e-02f, -7.16028586e-02f, -1.27941501e-04f, -6.42895326e-02f, -6.17447197e-02f, -8.65329057e-03f, -2.89415896e-01f, -1.58489853e-01f, 3.80391508e-01f, -3.54666077e-02f,
  2.80834317e-01f, -1.57905564e-01f, -3.54118466e-01f, 2.75918376e-02f, 8.23905841e-02f, -1.31682783e-01f, -3.84664200e-02f, 1.27401248e-01f, 1.71241164e-01f, 4.71163504e-02f,
  -4.28426936e-02f, 1.83557961e-02f, 1.24019533e-01f, 1.33558987e-02f, -1.14137901e-03f, 2.76900351e-01f, -2.46532410e-02f, -3.53018753e-02f, -1.49624661e-01f, 2.49983761e-02f,
  -3.74914915e-03f, -2.16652125e-01f, 1.91718042e-01f, 1.56002101e-02f, 5.36045954e-02f, 2.58731656e-03f, 1.08945603e-02f, 5.54596037e-02f, -1.77067116e-01f, 1.41367316e-01f,
  2.54082650e-01f, -2.79527139e-02f, 2.02697486e-01f, -2.19448820e-01f, -2.88474888e-01f, 1.42643571e-01f, 2.49494854e-02f, -1.00441903e-01f, -4.80547287e-02f, 1.16335966e-01f,
  -1.64759248e-01f, -1.82134241e-01f, -9.80823785e-02f, 7.51385419e-03f, -5.07563949e-02f, -5.93975447e-02f, -2.26771962e-02f, -1.47514194e-01f, 1.26169607e-01f, -7.16655864e-04f,
  1.89477690e-02f, 2.09494248e-01f, 8.20231065e-03f, -2.67928004e-01f, 7.68510299e-03f, -3.02245528e-01f, 4.97786626e-02f, -3.42035621e-01f, -1.64627567e-01f, -9.90705863e-02f,
  -2.60797590e-02f, -2.63979793e-01f, 2.98141479e-01f, 1.09916098e-01f, 3.40031266e-01f, 2.35885605e-02f, -2.47804314e-01f, -5.37957326e-02f, -4.85198572e-02f, -2.09398970e-01f,
  -4.35747132e-02f, 5.46938665e-02f, 1.75789550e-01f, 7.85193443e-02f, 7.65906274e-02f, 2.58002449e-02f, 1.14572339e-01f, -7.12762680e-03f, -2.24248338e-02f, 2.09900066e-01f,
  2.58859307e-01f, -1.45817548e-01f, -7.78205916e-02f, -3.59140411e-02f, -5.08060008e-02f, -1.06551439e-01f, 1.44937620e-01f, 9.56256092e-02f, -3.45636941e-02f, -4.08697315e-03f,
  9.27123129e-02f, -1.49000883e-01f, 2.11120039e-01f, -1.68018937e-01f, 5.99182732e-02f, 1.92702129e-01f, -6.24732412e-02f, -2.54074663e-01f, 1.24666482e-01f, 2.83768445e-01f,
  7.51837268e-02f, 4.39310037e-02f, -1.03375718e-01f, -7.31133148e-02f, -8.29707310e-02f, -1.00874521e-01f, -1.70858651e-01f, -8.88444204e-03f, 1.18291436e-03f, 1.07843600e-01f,
  2.29735956e-01f, -1.93334550e-01f, -1.61526389e-02f, -1.01101123e-01f, 1.23420201e-01f, -8.45162570e-02f, 2.57628709e-02f, -1.16359912e-01f, 5.13050556e-02f, 2.93397903e-01f,
  1.70294583e-01f, 2.92587847e-01f, 5.67989424e-02f, 1.21453449e-01f, 2.27326587e-01f, 1.71785489e-01f, -1.79163933e-01f, -1.63875848e-01f, -2.04383492e-01f, 1.24710374e-01f,
  2.78921068e-01f, 1.74105480e-01f, 5.91607429e-02f, -6.13931455e-02f, -1.57746911e-01f, -1.13500655e-01f, -2.72558540e-01f, -7.97194615e-02f, 1.54770808e-02f, 1.06600426e-01f,
  4.41969782e-02f, 1.59047991e-01f, -1.03850797e-01f, -2.71979868e-01f, 5.15860207e-02f, 1.69221669e-01f, 6.86670020e-02f, 1.62386913e-02f, 1.68355137e-01f, 6.17498234e-02f,
  -1.22870944e-01f, 3.66090760e-02f, -1.47822544e-01f, 1.61202997e-01f, 8.93603116e-02f, 1.37827499e-02f, -4.03731130e-02f, 2.39525940e-02f, -2.05473811e-03f, 1.03255637e-01f,
  -7.44846985e-02f, 2.80244090e-02f, 3.91305387e-02f, -5.87911978e-02f, 8.22830498e-02f, 1.85779423e-01f, 1.69875368e-01f, -2.09981665e-01f, 2.68084228e-01f, 1.99568108e-01f,
  -1.16249532e-01f, 1.26595467e-01f, 4.32413146e-02f, -1.92701016e-02f, -2.08144605e-01f, 2.41482779e-01f, -1.04500897e-01f, -5.83347715e-02f, -1.94587976e-01f, -2.72769928e-01f,
  -6.18548468e-02f, -1.22005083e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  4.07764576e-02f, 1.94963321e-01f, -8.56027231e-02f, -1.95194259e-01f, 1.74944010e-02f, -7.12706968e-02f, 1.02051675e-01f, 5.79093285e-02f, 2.47013755e-02f, 1.51849583e-01f,
  -2.65061289e-01f, -7.74650052e-02f, 1.43924683e-01f, 3.64468753e-01f, 4.06791568e-01f, 9.15106758e-02f, 4.31910828e-02f, 6.22584969e-02f, 2.68646717e-01f, 1.87325582e-01f,
  3.30389708e-01f, 3.32081199e-01f, 5.39795309e-02f, 4.48324084e-02f, 2.30063170e-01f, -1.00696281e-01f, 7.67301172e-02f, -7.89041668e-02f, 2.48793036e-01f, -2.24761423e-02f,
  -1.17303289e-01f, -1.36794761e-01f, 9.75054950e-02f, 6.03846461e-02f, 2.27925047e-01f, 4.05441225e-01f, 8.70612487e-02f, 1.29756182e-01f, -1.83011144e-01f, 4.93307747e-02f,
  -1.64523810e-01f, -3.20153236e-01f, -2.72773206e-01f, 2.99492300e-01f, 3.06157649e-01f, -7.94918761e-02f, 1.01111650e-01f, 4.82266366e-01f, 2.04438090e-01f, -2.30448037e-01f,
  -2.34018847e-01f, 1.98013529e-01f, 2.99417228e-01f, 1.42996654e-01f, 2.84402937e-01f, 2.31924683e-01f, -1.98504105e-01f, 2.96162188e-01f, -9.51336473e-02f, 2.71852851e-01f,
  3.91942054e-01f, -1.02274172e-01f, -2.45419499e-02f, 2.10560501e-01f, 2.99685467e-02f, -5.30269183e-02f, 8.70096236e-02f, 5.55894673e-02f, -1.78986028e-01f, 1.56178132e-01f,
  -2.82132089e-01f, 2.74324939e-02f, 1.83395982e-01f, -1.65012568e-01f, 3.29178840e-01f, 1.85075868e-02f, -1.88608453e-01f, -2.92000890e-01f, -2.19487146e-01f, 2.41673842e-01f,
  3.20694178e-01f, 3.15030932e-01f, -8.72268155e-02f, 1.28401428e-01f, 1.12520076e-01f, 1.44758061e-01f, 3.60839933e-01f, -1.33401215e-01f, -1.30480826e-01f, 3.45315367e-01f,
  1.62880868e-01f, 2.29939386e-01f, -1.16035931e-01f, 2.73265004e-01f, -3.23471278e-02f, -1.01586968e-01f, 1.73499271e-01f, -1.29724443e-01f, 2.17356786e-01f, 2.17419073e-01f,
  9.67233721e-03f, 2.87830234e-01f, -2.81465679e-01f, -2.33042687e-01f, 3.54807317e-01f, -9.31436941e-02f, 3.60987574e-01f, -1.76067412e-01f, -2.82819152e-01f, -1.06309555e-01f,
  -8.75423178e-02f, 1.30189657e-01f, 5.78005910e-02f, 3.00603926e-01f, -2.58161098e-01f, -1.27497733e-01f, 5.36550097e-02f, -1.58089623e-01f, 2.28932574e-01f, 2.74848729e-01f,
  -5.07443622e-02f, 3.47983181e-01f, 3.53546768e-01f, 3.38595390e-01f, -2.45099753e-01f, 1.79488584e-01f, 2.50628531e-01f, 1.01344936e-01f, 2.16882005e-01f, 1.07871428e-01f,
  1.51383821e-02f, 3.20541352e-01f, 7.48646632e-02f, 2.41468519e-01f, -3.40734810e-01f, -3.77149433e-01f, 5.08883834e-01f, -8.08425024e-02f, 3.24795902e-01f, -1.26692042e-01f,
  -2.93530911e-01f, 1.86689779e-01f, 9.38144103e-02f, -9.05340016e-02f, -5.35478033e-02f, 4.40827549e-01f, -4.21754196e-02f, -2.07455173e-01f, -1.82215154e-01f, 1.77829433e-02f,
  3.83011073e-01f, 4.37327504e-01f, 9.12515074e-02f, 2.70391971e-01f, 1.36044711e-01f, 1.04367904e-01f, -4.17795092e-01f, 2.27525771e-01f, 1.98534355e-01f, -1.15398459e-01f,
  -1.42933801e-01f, 1.05128869e-01f, -3.03965807e-02f, -2.01236829e-01f, 3.68416193e-03f, 5.41400313e-02f, 3.93628657e-01f, -7.10183308e-02f, -1.31445751e-02f, 1.21573858e-01f,
  -1.01334915e-01f, -4.85392325e-02f, 1.92796767e-01f, 2.72374362e-01f, 1.52884394e-01f, 5.74150793e-02f, -1.62069395e-01f, 3.62613291e-01f, 9.26828757e-02f, 7.67822862e-02f,
  1.70491144e-01f, 2.14003682e-01f, -1.66576669e-01f, -3.28582227e-01f, 4.26169664e-01f, -3.26416671e-01f, 2.99627304e-01f, 1.81891501e-01f, -5.39959706e-02f, 3.37503880e-01f,
  1.44957498e-01f, 1.92283183e-01f, -2.42993802e-01f, -1.88331008e-01f, -1.29507586e-01f, -4.49689806e-01f, -9.68432724e-02f, -8.08328465e-02f, 2.57680058e-01f, 6.31945953e-02f,
  -8.48168284e-02f, 1.76739171e-01f, 1.65716074e-02f, -6.08754158e-02f, 4.79053929e-02f, 6.09196723e-02f, 1.79281719e-02f, 1.19160369e-01f, 3.30631575e-03f, 1.09553635e-01f,
  1.49663717e-01f, 2.05374047e-01f, 3.04963142e-01f, 3.27809781e-01f, -1.72233030e-01f, -5.00435770e-01f, 3.52139562e-01f, 1.58930495e-02f, 2.11211175e-01f, 3.28401811e-02f,
  -5.94915114e-02f, 8.51644501e-02f, -1.40983716e-01f, 6.41395971e-02f, -3.83468308e-02f, 1.06663264e-01f, -5.73390312e-02f, -8.75381008e-02f, -1.35572534e-02f, 4.54611480e-02f,
  -1.47614062e-01f, 2.79768407e-01f, 3.58237512e-02f, 1.01173051e-01f, -2.22456828e-01f, -1.02807812e-01f, -2.38479637e-02f, 1.78180680e-01f, 5.18917255e-02f, 1.54073194e-01f,
  6.80246949e-02f, 1.64415151e-01f, 2.28915885e-01f, 9.96093228e-02f, 3.20347190e-01f, 2.60669827e-01f, 5.48696481e-02f, -3.50123644e-01f, 1.18778683e-01f, 6.44519478e-02f,
  5.92462383e-02f, -2.32035499e-02f, -5.92475310e-02f, 2.26348460e-01f, -7.77172819e-02f, -1.83853567e-01f, -5.05338609e-02f, 7.53564984e-02f, -1.25999868e-01f, -3.24935824e-01f,
  5.84345832e-02f, -5.19102402e-02f, 3.03166419e-01f, -1.14912309e-01f, -1.78325437e-02f, 2.70745486e-01f, -2.97572941e-01f, -4.79406454e-02f, 2.00437576e-01f, 1.80344492e-01f,
  3.13582361e-01f, -3.50095183e-02f, 1.57426521e-01f, 1.59285605e-01f, 4.14409488e-01f, 2.50324637e-01f, 2.76584268e-01f, 1.80943355e-01f, 1.52315006e-01f, -3.48194987e-02f,
  3.40160966e-01f, 1.19770765e-01f, 9.84706506e-02f, -1.91491067e-01f, 2.27608517e-01f, -1.56082392e-01f, -1.29789054e-01f, -6.64519593e-02f, -1.23715259e-01f, -1.82440579e-01f,
  9.80730057e-02f, 7.50583829e-03f, 1.10374339e-01f, -6.75397217e-02f, 2.80006945e-01f, -2.52254546e-01f, 6.13272190e-02f, 1.00960575e-01f, 1.13603860e-01f, -5.69919311e-03f,
  8.61596391e-02f, 4.68930528e-02f, -4.14451100e-02f, 1.61457121e-01f, -2.12444723e-01f, 1.95710942e-01f, 9.37409792e-03f, -7.60897696e-02f, -1.46914661e-01f, 1.89385921e-01f,
  -5.68620954e-03f, -1.02743410e-01f, 2.87498713e-01f, -1.49343014e-01f, 3.91517073e-01f, 3.87914956e-01f, -3.48286539e-01f, 1.62653208e-01f, 9.12467018e-02f, 3.63903344e-01f,
  1.77899361e-01f, -1.08096236e-02f, 2.43633568e-01f, 4.55532968e-01f, 9.07277167e-02f, 1.27957210e-01f, 1.02729499e-01f, -2.46699974e-01f, 1.56497329e-01f, -1.32164046e-01f,
  2.65483469e-01f, 1.58910453e-01f, 2.81210274e-01f, -1.02280438e-01f, -3.97545137e-02f, 2.50373539e-02f, -1.38178363e-01f, 3.14832836e-01f, -2.18180463e-01f, -2.27702290e-01f,
  -3.01090628e-01f, -2.73301005e-01f, 8.92699808e-02f, 1.75710171e-01f, -1.04334233e-02f, -4.01170850e-02f, 1.52809158e-01f, 3.04045677e-01f, -2.86373049e-01f, 3.67761016e-01f,
  3.82679164e-01f, 4.16293919e-01f, 1.42824307e-01f, 2.66803443e-01f, 1.93223402e-01f, 1.94797993e-01f, 1.56593788e-02f, 5.25209457e-02f, 1.86507404e-01f, -4.63904850e-02f,
  1.55718094e-02f, -1.32317454e-01f, 5.23466170e-02f, -8.34924132e-02f, 5.39809346e-01f, 2.48490885e-01f, 3.67239445e-01f, 1.79732025e-01f, -1.55050576e-01f, 1.21394157e-01f,
  -5.23575485e-01f, -1.17171265e-01f, -1.43897608e-02f, -1.08141661e-01f, -7.28134215e-02f, 2.10373759e-01f, 3.59762102e-01f, -3.89930099e-01f, 4.27476950e-02f, 3.21332753e-01f,
  2.49682795e-02f, 4.03412789e-01f, 2.56327868e-01f, 4.65203941e-01f, 3.20366353e-01f, 4.26378727e-01f, 1.10002480e-01f, 2.66745329e-01f, 1.81688875e-01f, 2.05959886e-01f,
  -3.64733845e-01f, 4.30950075e-02f, 3.94370347e-01f, -1.35540487e-02f, -2.92475075e-01f, -1.43001357e-03f, -1.08270280e-01f, 3.84648532e-01f, 1.92540422e-01f, 2.84219086e-01f,
  2.00519323e-01f, 1.48354784e-01f, 4.15272087e-01f, 2.39061043e-01f, 1.75470710e-01f, 2.89317608e-01f, 3.12205553e-01f, 1.20947488e-01f, 3.17715891e-02f, 1.76691890e-01f,
  9.88631696e-02f, -1.77923575e-01f, -1.50600085e-02f, 1.07788183e-01f, -9.78771523e-02f, -3.69967997e-01f, 8.83626286e-03f, 2.36512661e-01f, 4.46440615e-02f, 1.20810412e-01f,
  5.53001575e-02f, -9.61480141e-02f, 1.62346140e-01f, 1.08892031e-01f, -3.16336691e-01f, -7.19396546e-02f, -2.49331906e-01f, 1.33242637e-01f, 4.97621477e-01f, 1.48342848e-01f,
  3.00029010e-01f, 1.52640566e-01f, 1.74088906e-02f, -2.21279830e-01f, -1.17783457e-01f, 6.15966506e-02f, 5.80638126e-02f, 3.84858698e-02f, -4.51959334e-02f, 2.35042632e-01f,
  9.24417451e-02f, -1.86571226e-01f, -1.67772681e-01f, 7.56095126e-02f, 3.08058351e-01f, -1.01283588e-01f, 4.86731082e-02f, 2.69655108e-01f, -1.48692746e-02f, -2.60863960e-01f,
  1.00827101e-03f, 6.82947636e-02f, -1.66386902e-01f, 3.01919878e-01f, 1.44380694e-02f, 2.18263730e-01f, -7.38604292e-02f, -2.67355412e-01f, 3.40553969e-01f, 2.72440612e-01f,
  -2.71917433e-01f, -5.72837055e-01f, -4.43243325e-01f, 2.88015693e-01f, 3.41931611e-01f, 1.48655474e-01f, -8.89614373e-02f, 3.69409293e-01f, 2.72848159e-01f, 1.96107328e-02f,
  9.42777321e-02f, -2.22094312e-01f, -6.86920583e-02f, 4.45370495e-01f, 9.62292999e-02f, 1.00453936e-01f, 4.28065360e-02f, 2.16027245e-01f, 5.39087132e-02f, 3.77117991e-01f,
  -1.99265815e-02f, -5.78895919e-02f, -1.09847166e-01f, -2.50936002e-01f, 4.50594071e-03f, 2.77545583e-02f, 1.49112046e-01f, 1.82796329e-01f, -4.36849520e-02f, 2.17214465e-01f,
  -2.11840704e-01f, -1.95065111e-01f, 1.06005944e-01f, 3.47365588e-01f, 2.50665069e-01f, 1.86642975e-01f, -4.95772623e-02f, 1.53974742e-01f, 1.11493640e-01f, 1.65250912e-01f,
  3.40554118e-01f, 3.28264713e-01f, 3.74381021e-02f, -3.68554056e-01f, 2.95216978e-01f, -2.12581202e-01f, 6.76807985e-02f, -5.69488741e-02f, 8.83453488e-02f, 1.48941025e-01f,
  -1.29203096e-01f, -1.52496129e-01f, -8.72992799e-02f, 1.91943109e-01f, 1.10197857e-01f, 1.03366293e-01f, 8.93877596e-02f, 9.24025327e-02f, 3.45124900e-02f, 1.30419850e-01f,
  -1.00300983e-01f, -1.04821511e-01f, -3.16973299e-01f, 3.74194711e-01f, 1.48669213e-01f, -2.45405689e-01f, 1.52915537e-01f, 1.46220833e-01f, 3.95831555e-01f, -2.20554158e-01f,
  5.52575253e-02f, 3.14407438e-01f, 2.94339150e-01f, 1.61438778e-01f, 2.65475154e-01f, 1.69576645e-01f, -8.71056840e-02f, 2.28562310e-01f, -2.38799509e-02f, 2.73043454e-01f,
  4.61352944e-01f, -1.11378916e-01f, -6.05698079e-02f, 4.39200729e-01f, 2.12448657e-01f, 1.91580489e-01f, 1.79206744e-01f, 4.23711509e-01f, 1.00618862e-01f, 9.82989371e-02f,
  -2.83458352e-01f, 8.71570632e-02f, -1.32949427e-02f, -1.91795424e-01f, -6.82531223e-02f, 3.02014351e-01f, 6.49169534e-02f, -1.36750475e-01f, -5.62025383e-02f, 2.73565799e-01f,
  3.01395535e-01f, -1.25086933e-01f, 2.68956780e-01f, 3.10785919e-01f, 1.16395719e-01f, -3.56664695e-02f, 4.67329085e-01f, 5.94767213e-01f, -5.37060983e-02f, 3.75224590e-01f,
  -2.40291655e-02f, 7.09472373e-02f, 4.09047246e-01f, -4.55019809e-02f, 3.00901346e-02f, 3.13718289e-01f, -1.32395074e-01f, 1.18791446e-01f, -4.03882451e-02f, -3.78307492e-01f,
  -9.26124826e-02f, -5.61177656e-02f, 2.53151894e-01f, 2.66124725e-01f, -1.41614825e-01f, 2.48036087e-01f, -2.62184739e-01f, -5.43411672e-02f, 4.73017246e-02f, 3.33241522e-01f,
  1.56628445e-01f, 2.33657375e-01f, 1.02893868e-03f, 7.92998895e-02f, 3.59842896e-01f, 3.07431310e-01f, 4.25695896e-01f, 1.67636946e-01f, 2.11353935e-02f, -4.84907150e-01f,
  3.56100976e-01f, 1.58595949e-01f, 9.69413295e-02f, -1.31984264e-01f, 1.79654732e-01f, 1.56453237e-01f, -1.30513534e-01f, -1.14222839e-01f, -6.85722977e-02f, -4.72583845e-02f,
  -5.89965768e-02f, -1.29362375e-01f, -2.75990665e-02f, 4.47926968e-02f, -1.84750453e-01f, 2.68511206e-01f, 9.80927348e-02f, 7.05524310e-02f, -2.78660320e-02f, -5.76919317e-02f,
  -8.18942636e-02f, 2.97736041e-02f, 5.37128970e-02f, 2.00842336e-01f, 3.61356214e-02f, 3.47542375e-01f, -3.96854468e-02f, -1.17299991e-04f, 2.12297827e-01f, 2.28848413e-01f,
  1.19950823e-01f, -4.25423086e-01f, 2.16508761e-01f, -2.30840668e-02f, 2.43571430e-01f, 1.50247976e-01f, -2.15943083e-01f, 4.44959581e-01f, -8.35956857e-02f, -1.83535829e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  6.37407899e-02f, 1.76807880e-01f, 1.43978164e-01f, 1.82870761e-01f, 2.41178557e-01f, 9.22277421e-02f, -4.54762988e-02f, 2.19428819e-02f, 2.77598035e-02f, 4.06234078e-02f,
  1.79922655e-01f, 1.35226324e-02f, 1.11665465e-01f, 4.34303544e-02f, 1.14549510e-01f, 4.89320047e-03f, 1.09893858e-01f, 2.69599527e-01f, 6.54875636e-02f, -4.27566655e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -7.99911469e-02f, -1.41324997e-01f, -1.23775482e-01f, -1.00407861e-01f, -1.16456635e-01f, 2.99945828e-02f, -9.29000825e-02f, -2.12381050e-01f, 1.53447121e-01f, -4.12133560e-02f,
  -8.34892392e-02f, 9.36830491e-02f, -1.90959200e-02f, -4.51874807e-02f, 4.90380339e-02f, -1.01479761e-01f, -2.58602470e-01f, 1.68937340e-01f, 9.39843357e-02f, -1.55384522e-02f,
  -2.62088794e-02f, 2.00803846e-01f, -1.47793535e-02f, -1.56883329e-01f, -1.17228411e-01f, -2.38217209e-02f, 8.10779780e-02f, 1.14974707e-01f, 2.52632294e-02f, -9.20889080e-02f,
  2.19298065e-01f, 1.23941720e-01f, -2.18359530e-02f, -1.26221562e-02f, -5.55084310e-02f, -7.01053208e-03f, -9.07969922e-02f, 1.02094576e-01f, -2.09372282e-01f, -1.64531559e-01f,
  -3.49297255e-01f, 1.24306895e-01f, 2.86951870e-01f, -5.46426512e-02f, 1.67536002e-03f, 3.14108789e-01f, -6.75979331e-02f, -1.05312191e-01f, -6.24578148e-02f, -1.21006936e-01f,
  -8.76912251e-02f, 1.10696390e-01f, -1.91558272e-01f, -1.36959985e-01f, 9.25388858e-02f, 1.69526353e-01f, -2.80605797e-02f, 1.35518268e-01f, -1.43409014e-01f, -2.77678687e-02f,
  9.47589800e-02f, 1.65740922e-02f, -5.44941388e-02f, 9.93226245e-02f, 3.12308297e-02f, -1.15780301e-01f, 5.86889386e-02f, 3.82528864e-02f, 1.02475040e-01f, -1.19133353e-01f,
  1.57902688e-01f, 1.71396360e-01f, 1.09987877e-01f, -2.76907962e-02f, -2.40653586e-02f, -7.73082599e-02f, 1.05587140e-01f, -5.74365072e-02f, -1.80150405e-01f, -8.98271278e-02f,
  2.17258081e-01f, -5.71729690e-02f, -6.09549470e-02f, -2.32286863e-02f, 7.48671293e-02f, -9.01634544e-02f, -4.85436665e-03f, -1.35032862e-01f, -2.48352904e-02f, -3.34083848e-02f,
  -1.37147218e-01f, 4.21197712e-03f, 7.54436478e-02f, -7.54182562e-02f, -2.60788109e-02f, -1.03342980e-01f, 8.60677361e-02f, 5.81675395e-02f, 4.81718220e-02f, -4.35496941e-02f,
  6.16690554e-02f, 4.29621115e-02f, 5.10083651e-03f, -1.39074877e-01f, -7.11981356e-02f, -9.08599570e-02f, -5.72003387e-02f, 1.02925487e-01f, -4.18695435e-02f, -5.22893555e-02f,
  -7.05736354e-02f, -6.77627325e-02f, -1.62777394e-01f, 3.97646651e-02f, 3.26709496e-03f, 3.05946413e-02f, 5.57553805e-02f, 9.57929194e-02f, 1.97322425e-02f, -2.90523414e-02f,
  -1.51188716e-01f, 1.99473985e-02f, 2.28401914e-01f, -7.08287433e-02f, 1.74317598e-01f, 1.79120749e-01f, 1.52401492e-01f, -9.32584479e-02f, -8.20499286e-02f, 8.37035254e-02f,
  -2.51814090e-02f, -4.58565205e-02f, -9.63962674e-02f, 1.22907743e-01f, -1.55784935e-01f, -2.48710155e-01f, -1.14199132e-01f, 5.55923432e-02f, -3.91759276e-02f, 1.55754417e-01f,
  -1.20860837e-01f, 2.23770320e-01f, -5.73794432e-02f, 5.29283397e-02f, -6.32336289e-02f, -1.04521990e-01f, -1.20461740e-01f, -9.33787376e-02f, 3.26270647e-02f, 1.48673430e-01f,
  4.95511629e-02f, -2.64211334e-02f, -4.69854735e-02f, 4.75105830e-02f, -1.89323708e-01f, -1.12710267e-01f, 1.58966869e-01f, 1.28138755e-02f, -3.08855206e-01f, -2.26576522e-01f,
  -7.99934343e-02f, 1.86906829e-01f, 6.05120882e-03f, 1.53774887e-01f, -1.25469968e-01f, 8.74488801e-02f, 1.24174789e-01f, -2.69151628e-02f, 2.86274217e-03f, 1.16485581e-01f,
  6.34573922e-02f, -1.39587924e-01f, -1.03035113e-02f, -1.98135212e-01f, -6.74854517e-02f, -2.25895271e-02f, 2.89772488e-02f, 6.37428537e-02f, -1.20563053e-01f, 5.25508635e-02f,
  1.55082509e-01f, 5.67477979e-02f, 1.94568664e-01f, -7.35197440e-02f, 2.16988370e-01f, 1.36095481e-02f, -3.50941718e-01f, 6.16288930e-02f, 7.08255470e-02f, 8.12027976e-02f,
  -7.30404556e-02f, -3.90215926e-02f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  8.60081539e-02f, -1.61995776e-02f, -6.18829355e-02f, 1.68396741e-01f, -1.58468515e-01f, 1.51267886e-01f, -1.11063771e-01f, 8.77564494e-03f, -3.69058192e-01f, 2.57138222e-01f,
  2.95182943e-01f, 3.32704894e-02f, 1.47739723e-01f, 3.74785572e-01f, -1.41644821e-01f, 3.67851034e-02f, 3.10904700e-02f, -1.01986356e-01f, -3.39413941e-01f, -9.08525810e-02f,
  8.00104961e-02f, 4.40608934e-02f, 1.62120804e-01f, 2.78561056e-01f, 1.46755084e-01f, 3.83957863e-01f, -2.04060674e-01f, -9.94950384e-02f, 2.51933783e-01f, 3.46547276e-01f,
  -1.18968479e-01f, -1.80111468e-01f, -1.30871475e-01f, 2.18273457e-02f, -1.12432785e-01f, -2.99881063e-02f, 3.93246822e-02f, 7.95830414e-02f, -1.87237307e-01f, -3.40943873e-01f,
  1.54535487e-01f, -2.69186080e-01f, -4.90033664e-02f, 7.31177852e-02f, -1.60487428e-01f, 2.91140616e-01f, 1.12011619e-01f, -3.89006995e-02f, -1.29481062e-01f, -5.88015467e-03f,
  2.42914334e-01f, -1.35778174e-01f, -4.04151715e-02f, 3.37311029e-01f, 1.78593501e-01f, 3.54339220e-02f, -2.59011149e-01f, 6.15667589e-02f, 5.00053227e-01f, -5.64333797e-02f,
  3.20428848e-01f, 7.17239678e-02f, -1.02638066e-01f, -4.70792241e-02f, 9.14878100e-02f, 9.66819674e-02f, 9.05416161e-02f, -7.14671984e-02f, 1.08836502e-01f, 1.05606951e-01f,
  8.39094520e-02f, 7.86719397e-02f, -1.84123944e-02f, 1.55884221e-01f, -1.44551069e-01f, 5.42088188e-02f, 3.79698664e-01f, -6.88035488e-02f, 1.13323584e-01f, -2.44341463e-01f,
  -5.44810370e-02f, 4.12508875e-01f, 4.87620264e-01f, 5.32308042e-01f, 4.25416082e-01f, 1.77203164e-01f, -2.98041016e-01f, 1.38744846e-01f, 3.50637525e-01f, 3.39267068e-02f,
  -1.97886154e-02f, 5.06144881e-01f, -1.46403894e-01f, -2.98013687e-01f, 3.94936830e-01f, 5.54191291e-01f, -5.04311903e-40f, -4.87321159e-40f, -5.06998192e-40f, -4.92985208e-40f,
  4.92217296e-40f, -4.96041439e-40f, -4.30441053e-40f, -4.96129721e-40f, -4.98988370e-40f, 4.92044936e-40f, 2.89389152e-40f, -5.01890459e-40f, -4.92613863e-40f, -6.16400366e-40f,
  -4.95961565e-40f, -4.92657304e-40f, -4.91512443e-40f, -4.98845438e-40f, 6.29198425e-40f, -5.04211010e-40f, -5.04345534e-40f, -4.94009557e-40f, -4.96440810e-40f, -6.01071562e-40f,
  -4.94428545e-40f, 5.68047161e-40f, -4.95244101e-40f, -4.96398771e-40f, -5.96161412e-40f, 4.91163520e-40f, -5.02467794e-40f, -4.94006754e-40f, 2.10102156e-01f, -9.19353869e-03f,
  1.41014457e-01f, -8.50499496e-02f, 6.02901801e-02f, 4.09772992e-02f, 2.41257086e-01f, 2.16626242e-01f, -2.01568544e-01f, -1.13737874e-01f, 1.45385653e-01f, -7.20585436e-02f,
  -5.89690469e-02f, 2.74840772e-01f, 3.07113886e-01f, 2.19662458e-01f, 3.30556393e-01f, -1.60365149e-01f, -2.10176006e-01f, 1.48423210e-01f, -2.50457913e-01f, -1.05885677e-01f,
  -1.62251234e-01f, -1.00672334e-01f, 3.78385723e-01f, -1.04005791e-01f, 5.48051149e-02f, 9.58744064e-02f, -1.70599949e-02f, 2.60041416e-01f, -7.30785653e-02f, 1.04457349e-01f,
  -8.02843075e-04f, 1.12029128e-01f, -2.12810904e-01f, 1.99496105e-01f, -1.18250951e-01f, 2.58601606e-01f, -2.51975149e-01f, -1.71191230e-01f, -3.71117741e-01f, 2.72327274e-01f,
  2.94419765e-01f, -1.70240358e-01f, 1.07464261e-01f, 8.40199962e-02f, -4.62865561e-01f, -2.59985566e-01f, -1.91043690e-02f, 3.25638950e-01f, 1.81488663e-01f, 2.36611944e-02f,
  1.18187875e-01f, 3.47796559e-01f, 2.67610282e-01f, 3.37245584e-01f, 1.07720062e-01f, 3.35631847e-01f, -3.07161450e-01f, 1.87279359e-01f, 8.30991492e-02f, -9.05456766e-02f,
  2.82422781e-01f, -7.10307509e-02f, 7.62380660e-02f, -1.06904335e-01f, 1.35396123e-01f, 7.57672042e-02f, 1.68097064e-01f, 6.53151721e-02f, 1.68852791e-01f, 2.09336773e-01f,
  1.67627349e-01f, 3.68590176e-01f, -3.28326747e-02f, -7.80954957e-02f, 3.58462632e-01f, -3.13351244e-01f, -2.51985759e-01f, -1.99877307e-01f, 1.51695386e-01f, 3.30145359e-01f,
  3.57323945e-01f, 1.14232898e-01f, 4.61180627e-01f, 2.54720122e-01f, -2.02237234e-01f, 2.37794854e-02f, 1.33558035e-01f, 7.46154040e-02f, -5.22304595e-01f, 2.73979336e-01f,
  -3.19278687e-01f, -2.31143489e-01f, 2.92869031e-01f, 1.10211521e-01f, 1.57267451e-02f, 2.63203502e-01f, 9.97604057e-02f, -1.01264894e-01f, 5.17773516e-02f, -9.27092433e-02f,
  2.02641785e-01f, 4.40521948e-02f, -6.84182066e-03f, -2.69194037e-01f, -6.92020580e-02f, -1.73588786e-02f, -2.94501781e-01f, 2.11878419e-01f, 4.17400271e-01f, 4.66035903e-01f,
  4.00979310e-01f, -6.31561950e-02f, -2.18590692e-01f, 1.61707066e-02f, -3.30840081e-01f, 8.10354128e-02f, 3.92689943e-01f, 1.31156454e-02f, 2.83831619e-02f, -1.99875429e-01f,
  5.02565384e-01f, -2.94914156e-01f, 5.00888973e-02f, 2.00997099e-01f, -1.77608982e-01f, 1.93691477e-01f, -3.97624038e-02f, 1.38008920e-02f, 1.79292727e-02f, -2.47097686e-02f,
  -2.43502669e-02f, -2.60990933e-02f, 1.89661801e-01f, -2.40348563e-01f, 3.31785709e-01f, -3.48482996e-01f, -3.61440510e-01f, 2.24653989e-01f, 2.63735130e-02f, 1.09631136e-01f,
  3.44597787e-01f, 1.92741737e-01f, -5.02419658e-03f, -4.86094085e-03f, 3.05499166e-01f, 1.30410507e-01f, 1.99811205e-01f, 7.27416435e-03f, -2.52070993e-01f, -3.26669604e-01f,
  1.35007843e-01f, -1.60729706e-01f, 5.50059021e-01f, 8.11042562e-02f, 2.65355617e-01f, 2.14776739e-01f, 2.13556901e-01f, 3.39024253e-02f, 7.33705387e-02f, 6.09165616e-02f,
  2.13077012e-03f, -9.24425125e-02f, -2.50780672e-01f, 9.70711708e-02f, -1.63911387e-01f, -2.94227362e-01f, -2.44829699e-01f, 6.53707087e-02f, 8.50798190e-02f, 2.94939876e-01f,
  9.38140601e-02f, 4.30099249e-01f, -8.80088508e-02f, -2.52086759e-01f, -2.83497572e-01f, -1.92688346e-01f, -8.91867951e-02f, -6.42727762e-02f, 3.68328877e-02f, 8.61863941e-02f,
  -2.70851329e-03f, 1.66627765e-01f, -5.95773831e-02f, 3.38089764e-01f, -5.80832474e-02f, 3.29844956e-03f, 3.74689639e-01f, 3.20672393e-01f, -4.03007353e-03f, -1.01667717e-01f,
  1.09858416e-01f, 8.55347589e-02f, 1.86631799e-01f, 6.67102933e-02f, 4.81904708e-02f, 1.09093547e-01f, -1.17585719e-01f, -1.83189496e-01f, -1.11477956e-01f, 6.14024065e-02f,
  1.66304976e-01f, 2.74330258e-01f, 3.44791621e-01f, 3.14869225e-01f, -6.21524686e-03f, -2.74895817e-01f, -2.92204112e-01f, -5.32611609e-02f, 1.90738171e-01f, 2.82399625e-01f,
  3.43288720e-01f, -2.16474846e-01f, -3.74902666e-01f, 2.79502049e-02f, 4.08445448e-01f, 2.72522658e-01f, 1.35686129e-01f, 3.34735930e-01f, 4.38624173e-01f, 3.73504072e-01f,
  5.26337862e-01f, 5.42166941e-02f, 3.41865048e-02f, 3.38087194e-02f, -1.78935695e-02f, 5.92068071e-03f, -1.65747017e-01f, -8.15774947e-02f, -1.03890367e-01f, -2.42743179e-01f,
  4.23714668e-02f, -2.21811965e-01f, 1.10589704e-02f, 2.24147290e-01f, 1.08228192e-01f, 2.55862385e-01f, 6.53499318e-03f, -1.22808650e-01f, -1.91409700e-02f, 3.76846083e-02f,
  -4.98658745e-04f, -7.57272989e-02f, 1.57883376e-01f, -7.10292310e-02f, 1.56698152e-01f, -1.09112777e-01f, 1.15439013e-01f, 1.06481001e-01f, 4.01095986e-01f, -2.03598768e-01f,
  3.91360611e-01f, 3.53096366e-01f, -9.81079191e-02f, -9.39810090e-03f, 6.82514012e-02f, 1.78384677e-01f, -9.01961923e-02f, 4.31930870e-02f, -3.67918499e-02f, 8.44989624e-03f,
  -3.95568907e-02f, 8.86083394e-02f, -9.67614055e-02f, -1.60596326e-01f, 1.01945966e-01f, -9.09243450e-02f, -7.92785734e-02f, -1.79358691e-01f, 1.09598190e-01f, 6.48502111e-02f,
  -4.58412953e-02f, 2.63791680e-01f, 1.22575216e-01f, 1.29369915e-01f, -1.16003335e-01f, 2.09141634e-02f, 5.15520498e-02f, -1.28383413e-01f, -9.28275734e-02f, -1.27454177e-01f,
  2.03525588e-01f, 6.64955303e-02f, 4.48201634e-02f, 3.21103483e-02f, 1.96086824e-01f, 9.81131420e-02f, 1.90614343e-01f, 5.83026893e-02f, 8.27199146e-02f, 4.56395894e-02f,
  1.66511133e-01f, 8.45864341e-02f, 2.64746815e-01f, -1.60465967e-02f, 4.79594618e-02f, -2.43897438e-01f, -2.59238761e-02f, 8.89540166e-02f, 4.64497171e-02f, 2.35407487e-01f,
  3.19816530e-01f, 1.36386812e-01f, 1.24902874e-01f, -2.24961653e-01f, -1.07889719e-01f, 9.95582864e-02f, 9.66103896e-02f, -1.00733280e-01f, -1.53825089e-01f, -1.15520537e-01f,
  3.43892723e-01f, -1.08749092e-01f, 3.43471915e-01f, -2.11323932e-01f, 1.31278753e-01f, 2.97786146e-01f, 3.61025035e-02f, -9.30246934e-02f, -2.26901006e-02f, -1.67187169e-01f,
  6.99252561e-02f, 1.99588630e-02f, -2.96852756e-02f, 8.12984407e-02f, 2.19350338e-01f, 2.37604812e-01f, 5.97517416e-02f, -1.41419545e-01f, -1.43423244e-01f, -2.98325926e-01f,
  -7.59015083e-02f, -8.43933225e-02f, 4.35549438e-01f, 4.95414764e-01f, 4.83578414e-01f, -1.03212502e-02f, -5.38086984e-03f, -1.83696505e-02f, -1.93144470e-01f, 2.20293567e-01f,
  4.80651617e-01f, 3.89948189e-01f, 1.56466030e-02f, -2.09160715e-01f, 2.68581897e-01f, -8.48012939e-02f, -1.50510773e-01f, -7.76008964e-02f, -5.89716136e-02f, 3.28880906e-01f,
  -1.78480014e-01f, -2.52699330e-02f, 3.84983122e-02f, -7.66899958e-02f, -8.88428986e-02f, -1.17724035e-02f, 3.51014912e-01f, 7.89160207e-02f, 3.69070709e-01f, 5.15520908e-02f,
  -3.23594540e-01f, -3.97095084e-02f, 2.10421383e-01f, -3.43060881e-01f, 2.68167078e-01f, 3.16827297e-01f, 3.57938886e-01f, 1.91022933e-01f, 2.96723604e-01f, 2.37126738e-01f,
  1.65050402e-01f, 3.65738094e-01f, 1.49902850e-01f, 7.84585550e-02f, 2.92127222e-01f, -2.40713030e-01f, 3.29297259e-02f, 3.47804248e-01f, -2.34224498e-01f, -1.02073193e-01f,
  2.97202229e-01f, 3.91494364e-01f, 2.84785759e-02f, -6.82457685e-02f, -6.73113158e-03f, 1.78271875e-01f, 1.40083572e-02f, 1.12549387e-01f, -2.11434260e-01f, 1.02238618e-01f,
  -2.81253397e-01f, 1.58535361e-01f, 4.28337514e-01f, -4.31993335e-01f, 4.39113285e-03f, -1.99771915e-02f, 4.05187532e-02f, 5.53433783e-02f, 1.24777652e-01f, 3.40995103e-01f,
  -5.67455888e-02f, -1.18656717e-02f, -2.72697300e-01f, 2.99906313e-01f, 4.99937862e-01f, 5.71248055e-01f, 5.39132915e-02f, 1.68309420e-01f, -8.14993009e-02f, -1.87305771e-02f,
  -2.00035989e-01f, 6.16776124e-02f, -1.80347905e-01f, 2.69870490e-01f, -3.69007117e-03f, -2.60344762e-02f, 2.45861962e-01f, 2.05708146e-01f, 1.89810380e-01f, 5.28436117e-02f,
  4.96517360e-01f, 6.19530864e-02f, 2.04598293e-01f, -7.36909583e-02f, -1.45705968e-01f, 3.08639314e-02f, 4.30022851e-02f, -2.06562057e-02f, 8.86846036e-02f, 3.39720637e-01f,
  6.65230155e-01f, -1.19120918e-01f, -2.21481249e-01f, -2.17142403e-02f, 3.39156613e-02f, 9.92726982e-02f, 2.13728771e-01f, -1.94646761e-01f, 4.51004475e-01f, -2.17182636e-01f,
  -1.84875235e-01f, -1.45654887e-01f, -8.61912370e-02f, 2.21386865e-01f, -1.35410696e-01f, -2.84074415e-02f, -8.59781578e-02f, -8.93337950e-02f, 3.44672948e-02f, 1.69432372e-01f,
  -8.28895569e-02f, -5.49837798e-02f, -1.19533360e-01f, 9.10739526e-02f, -1.15769558e-01f, -4.07728031e-02f, 2.81951576e-01f, -2.71110147e-01f, -9.69484299e-02f, 1.07326880e-02f,
  2.39045024e-02f, 3.35150182e-01f, 1.29452929e-01f, 3.31395894e-01f, 8.50638375e-02f, -2.14293659e-01f, -2.29317714e-02f, 2.80314296e-01f, 3.84363115e-01f, 4.13674414e-01f,
  -3.28173786e-01f, 8.56565163e-02f, 2.85507441e-01f, 2.31245961e-02f, 8.89440179e-02f, 7.97734782e-02f, -1.35584995e-01f, -1.18416362e-01f, 1.11173153e-01f, 1.81694869e-02f,
  -9.95201841e-02f, 1.63505360e-01f, -7.76897222e-02f, 5.69836125e-02f, -1.88356623e-01f, 6.38366565e-02f, -2.83249825e-01f, 1.74506918e-01f, 2.28407934e-01f, 1.29126362e-03f,
  1.41210258e-01f, 2.08950803e-01f, -1.91937461e-01f, -3.16016003e-02f, 5.97639605e-02f, 2.89467908e-02f, -2.86969662e-01f, -1.58240438e-01f, 1.30243346e-01f, -3.15535552e-04f,
  1.47775739e-01f, 2.71828890e-01f, 1.27552345e-01f, 4.39178288e-01f, -1.84769213e-01f, -7.87148252e-02f, 2.47784346e-01f, 2.23432720e-01f, -1.31485090e-01f, -2.04839140e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  1.84282079e-01f, -4.50412147e-02f, -4.66204584e-02f, -4.60250875e-40f, -7.10039772e-03f, 2.00156793e-01f, 2.43403334e-02f, -3.47697884e-02f, 1.31857162e-02f, 4.68565039e-02f,
  2.68782191e-02f, 1.19859114e-01f, 2.60115247e-02f, 4.00267206e-02f, -7.39443079e-02f, -2.10497323e-02f, 2.25818798e-01f, 1.15410518e-03f, 3.00835390e-02f, 4.03285511e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.97193027e-01f, 1.22656874e-01f, -1.91131011e-01f, 1.71196237e-01f, -1.00603767e-01f, 1.83339611e-01f, 1.26345605e-01f, -4.36780788e-02f, 1.64153442e-01f, 6.67760596e-02f,
  -7.22410306e-02f, -1.93114094e-02f, -1.57215148e-01f, -1.62951082e-01f, 2.60166645e-01f, -5.24518627e-40f, -3.45953852e-01f, 2.79093444e-01f, 2.47791782e-01f, -4.49216783e-01f,
  -3.17227006e-01f, 1.47027999e-01f, 1.42647535e-01f, -3.28758806e-01f, 2.93066725e-02f, -3.61500293e-01f, -3.85286778e-01f, -3.70095447e-02f, 9.49824788e-03f, -6.02033079e-01f,
  -2.08132535e-01f, 6.38782606e-02f, -1.93568259e-01f, -3.46323192e-01f, 2.44895853e-02f, -1.45915106e-01f, -3.37259062e-02f, 1.02965020e-01f, 2.56649047e-01f, -2.02855632e-01f,
  1.07981682e-01f, -1.53056368e-01f, 7.98575655e-02f, 5.42105176e-02f, -6.86469674e-01f, -3.07350725e-01f, 2.97821730e-01f, -4.98423647e-40f, -1.26967996e-01f, -6.56934977e-02f,
  4.08330590e-01f, -4.52070087e-01f, -1.40967324e-01f, -5.36293685e-01f, -2.01527789e-01f, -5.87343097e-01f, -8.80878940e-02f, -4.10067260e-01f, 2.08045006e-01f, 2.67354429e-01f,
  7.63873756e-02f, -1.16254622e-02f, 2.97728851e-02f, -5.89820087e-01f, -3.42088908e-01f, -3.03417593e-01f, -6.43505007e-02f, 1.37831852e-01f, -2.08940014e-01f, -1.76454425e-01f,
  8.98471475e-02f, 5.21190204e-02f, 3.00199062e-01f, 1.41285628e-01f, 5.78138418e-02f, -3.04543555e-01f, -4.60039586e-01f, 1.96690321e-01f, 1.55911699e-01f, 4.96114307e-40f,
  -1.17509365e-01f, -2.17258409e-01f, -3.76363933e-01f, 1.37176335e-01f, 3.52739356e-02f, -1.33807823e-01f, -2.94518679e-01f, 4.12394255e-02f, 9.06074122e-02f, -1.38084218e-01f,
  2.11677715e-01f, 2.22243980e-01f, 2.08328087e-02f, -3.29574436e-01f, 1.67614192e-01f, -3.56870651e-01f, -2.17016220e-01f, -1.99765593e-01f, -2.49642227e-03f, 1.61771983e-01f,
  6.17052279e-02f, -1.38525754e-01f, -2.82024503e-01f, 4.60097417e-02f, -3.08658835e-03f, -7.54329711e-02f, 6.55116364e-02f, -1.87298432e-01f, 1.44772545e-01f, 1.41192764e-01f,
  -4.07063276e-01f, 4.91251801e-40f, 1.37304559e-01f, -4.18327749e-01f, -2.60507017e-01f, -4.40979116e-02f, 3.88977267e-02f, 2.86585093e-02f, 3.37824762e-01f, 2.43851036e-01f,
  -1.42788440e-01f, 2.70473510e-01f, -5.21358311e-01f, -7.92539477e-01f, -5.06081879e-01f, 5.80092520e-02f, -1.93036959e-01f, 2.10824117e-01f, -5.07348478e-02f, -5.98069988e-02f,
  -1.33166566e-01f, 2.39656456e-02f, 1.36586294e-01f, 9.38920453e-02f, 1.99126914e-01f, 8.94118547e-02f, 1.63850799e-01f, 1.85861632e-01f, -2.58962989e-01f, -1.64635822e-01f,
  -3.57924961e-02f, 2.55598903e-01f, 9.28527638e-02f, -4.93704074e-40f, 4.38700542e-02f, 1.31636858e-01f, -3.50084931e-01f, -1.49760827e-01f, 9.62574556e-02f, 4.50571626e-02f,
  1.45511404e-01f, 1.59980476e-01f, 3.37071493e-02f, 3.93813895e-03f, -8.15724805e-02f, -2.33220592e-01f, 1.54454917e-01f, -3.88417125e-01f, 1.47951737e-01f, -5.26762269e-02f,
  3.31765443e-01f, 2.14783162e-01f, -1.02659091e-01f, -1.00724369e-01f, -3.22575837e-01f, -1.02984220e-01f, -4.93893288e-02f, 5.29807806e-02f, -2.14999899e-01f, -4.44862187e-01f,
  -2.02107102e-01f, 1.33120582e-01f, 1.75194964e-01f, -5.08537591e-01f, 1.16795793e-01f, -5.90821064e-40f, 3.79685938e-01f, 1.90939531e-01f, 2.16059573e-02f, -4.27967012e-02f,
  -4.82650697e-01f, -1.00971282e-01f, -1.55945823e-01f, -2.40649462e-01f, -4.29627113e-02f, -1.09263577e-01f, 1.59957722e-01f, 4.83253188e-02f, 2.71279484e-01f, 2.20099539e-01f,
  -9.48629007e-02f, 2.04328567e-01f, 1.08262211e-01f, -4.77903411e-02f, -3.30886468e-02f, 2.20439926e-01f, 2.38260418e-01f, 1.13093168e-01f, -3.73933733e-01f, -2.32586056e-01f,
  -1.69383645e-01f, -3.98149878e-01f, -3.32256705e-01f, 8.36764351e-02f, -2.52437413e-01f, -9.33687985e-02f, -3.74187291e-01f, -4.99229393e-40f, 6.12521581e-02f, -2.79964983e-01f,
  -3.77665043e-01f, 2.78386563e-01f, -2.13972211e-01f, -5.65836430e-01f, -7.55302429e-01f, -1.04688533e-01f, 7.38806427e-02f, 1.31482661e-01f, 2.16039419e-01f, -5.02230711e-02f,
  2.40224987e-01f, 2.31761366e-01f, 2.78181881e-01f, -2.06791461e-01f, 1.74596217e-02f, 1.13991551e-01f, 1.37717322e-01f, 4.52356935e-02f, -2.36458275e-02f, -4.09537703e-02f,
  -3.80268484e-01f, 7.78589696e-02f, -2.13221297e-01f, -8.82657841e-02f, 2.79302478e-01f, 1.93390682e-01f, 3.43823284e-01f, -1.91984609e-01f, -2.82333732e-01f, 4.91676395e-40f,
  -3.12001646e-01f, 1.50223672e-01f, -6.54925853e-02f, -6.57684505e-01f, -3.44698995e-01f, 2.98131615e-01f, 2.21678734e-01f, 1.73581243e-01f, -4.02229697e-01f, -1.62876621e-01f,
  -5.33183396e-01f, -4.32786763e-01f, 7.67389387e-02f, -1.54363424e-01f, 1.71016119e-02f, 3.80289584e-01f, -2.21595187e-02f, -1.74759895e-01f, 1.96633160e-01f, 4.34134416e-02f,
  -8.73764604e-02f, -2.98104454e-02f, 6.00444674e-02f, -3.77995402e-01f, -2.73004603e-02f, 1.90704510e-01f, -8.66076797e-02f, 2.45329052e-01f, -4.07512546e-01f, -9.71911326e-02f,
  1.28256172e-01f, 4.91037403e-40f, -1.89297795e-01f, 1.28597897e-02f, 2.68183738e-01f, -3.00748169e-01f, 1.97098285e-01f, -2.22982451e-01f, 1.43266201e-01f, 1.50013611e-01f,
  1.14278458e-01f, 8.77968594e-02f, -3.52796197e-01f, 1.79102421e-01f, -5.03274918e-01f, 2.71727622e-01f, -4.19344097e-01f, -2.45358706e-01f, 1.67171936e-04f, 2.34577745e-01f,
  -2.17802629e-01f, 2.13255212e-01f, -7.85328727e-03f, 1.58182517e-01f, 2.04858929e-01f, 8.82980824e-02f, 5.85786290e-02f, 2.79368401e-01f, 1.99814335e-01f, 1.70557812e-01f,
  1.03124775e-01f, 2.80486882e-01f, -4.85183239e-01f, 4.96772917e-40f, -4.12904590e-01f, 2.85824776e-01f, -3.28699976e-01f, 1.43203646e-01f, -4.34815794e-01f, -2.95636547e-03f,
  -6.63472891e-01f, 9.14186835e-02f, -8.57121253e-04f, -4.56415683e-01f, 9.48115885e-02f, -1.71324462e-01f, 2.34282345e-01f, -1.86130986e-01f, 2.48389229e-01f, 1.36127055e-01f,
  -3.98142226e-02f, 2.35920176e-01f, -1.05946749e-01f, 3.39127369e-02f, -9.62699484e-03f, 9.77074634e-03f, -1.92068666e-01f, 4.79969457e-02f, -4.72917706e-02f, 3.11373919e-01f,
  3.41219276e-01f, -1.44297853e-01f, -4.97946925e-02f, 1.93627357e-01f, -5.05606115e-01f, -4.91550278e-40f, 1.57538220e-01f, -4.04115945e-01f, -2.24044070e-01f, 2.67741501e-01f,
  1.74389735e-01f, 1.70055926e-02f, -2.57097632e-01f, 1.11955047e-01f, -2.45213315e-01f, 1.83939248e-01f, 1.74156755e-01f, -1.33150861e-01f, -3.34228516e-01f, 3.79155606e-01f,
  -1.88049212e-01f, -1.32416427e-01f, 1.51839316e-01f, 2.38581002e-01f, -2.57173665e-02f, -3.55633013e-02f, -1.64438576e-01f, 2.51950473e-01f, -1.10641390e-01f, 1.77849337e-01f,
  1.62846223e-01f, 1.99783400e-01f, -2.75757462e-01f, -9.07723978e-02f, -2.38527387e-01f, -1.37346610e-01f, 1.68134645e-01f, -5.45330712e-40f, 1.11295961e-01f, -5.59909761e-01f,
  -5.81437826e-01f, 1.80179581e-01f, 2.42623389e-01f, 3.15764248e-02f, 2.82631218e-01f, 6.87809587e-02f, -2.71438025e-02f, 1.83610573e-01f, -1.66266903e-01f, -4.26709577e-02f,
  -4.02074665e-01f, 4.39883024e-02f, -5.96336901e-01f, -4.54716653e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.76732394e-02f, 3.07134129e-02f, -4.78833355e-02f, 9.89796519e-02f, -1.14982940e-01f, -4.39156853e-02f, -1.75239481e-02f, 1.60002664e-01f, -1.22552209e-01f, 4.37581167e-03f,
  2.56561693e-02f, 1.14174187e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    