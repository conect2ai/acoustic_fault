/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.51312697e-01f, 3.41952518e-02f, 1.16862044e-01f, 1.26140505e-01f, 1.32634431e-01f, -1.82609826e-01f, -2.69863188e-01f, 1.55765623e-01f, 1.24981180e-01f, -1.57945320e-01f,
  -5.47111332e-02f, -5.86963668e-02f, -2.58962840e-01f, 1.51038200e-01f, -2.20615983e-01f, -1.50452912e-01f, 3.90766263e-02f, -5.53872176e-02f, 1.50150135e-01f, 7.24779293e-02f,
  8.65603685e-02f, -5.49893007e-02f, 8.92856941e-02f, 1.80963412e-01f, 1.01034537e-01f, 1.36402875e-01f, -1.66423842e-01f, -1.66877732e-02f, 1.35907121e-02f, -1.05013058e-01f,
  6.06897548e-02f, 7.72434622e-02f, 6.08978458e-02f, 5.11940289e-03f, 4.58822697e-02f, -3.58268321e-02f, -1.35211036e-01f, -1.06203832e-01f, 1.98999494e-02f, -9.36438665e-02f,
  -1.22611932e-01f, -6.14834391e-03f, 7.86664337e-02f, -6.32163230e-03f, -2.13848567e-03f, 1.26881391e-01f, 3.07634845e-02f, 1.03138447e-01f, 5.65937757e-02f, 2.56743934e-02f,
  -2.26760674e-02f, 8.30689818e-02f, 4.09881733e-02f, -5.27940392e-02f, -1.19732721e-02f, 2.87683364e-02f, -5.66984378e-02f, -5.67073189e-02f, -2.73061004e-02f, 1.08537443e-01f,
  2.19403896e-02f, -3.98445167e-02f, -2.77244928e-03f, 6.88905653e-04f, -4.15301695e-02f, 3.51925418e-02f, -3.00299469e-02f, -5.21905348e-02f, -1.17410044e-03f, -4.57915291e-02f,
  5.69889918e-02f, 3.41090523e-02f, 1.90543421e-02f, 4.73187603e-02f, -9.91677213e-03f, 4.43599299e-02f, 6.75520161e-03f, -2.61428524e-02f, 3.99481021e-02f, 3.57556418e-02f,
  -5.13908900e-02f, 1.84563380e-02f, -4.05227952e-03f, -5.00383526e-02f, 4.44503035e-03f, 6.29846612e-03f, 2.11598184e-02f, 4.47425842e-02f, -6.68130291e-04f, -6.77013695e-02f,
  -1.35800898e-01f, -1.10626616e-01f, 1.73415169e-02f, 4.70785089e-02f, -7.07442537e-02f, -3.07900477e-02f, 2.49980371e-02f, 6.59271106e-02f, -6.68840930e-02f, 3.16119418e-02f,
  -2.19297092e-02f, 2.20336784e-02f, -7.94981942e-02f, 4.77604978e-02f, 4.27578054e-02f, -6.59756735e-02f, -6.61596730e-02f, -4.09460142e-02f, -3.99949178e-02f, -2.91995928e-02f,
  -3.83957326e-02f, -1.48719139e-02f, -1.04827406e-02f, -4.03645076e-03f, -3.63664180e-02f, -3.90813127e-02f, -3.37218493e-02f, 3.02590746e-02f, -5.56390136e-02f, -8.65930766e-02f,
  3.57671440e-01f, -6.19398728e-02f, 1.90459475e-01f, 1.24836676e-01f, -2.21410930e-01f, -1.01820059e-01f, 1.71618760e-01f, -1.39074713e-01f, 2.26767421e-01f, -1.61960155e-01f,
  -1.27969384e-01f, 2.42730901e-01f, 1.72077075e-01f, -9.77067128e-02f, 2.54967719e-01f, 2.37921029e-01f, -2.14132741e-02f, 5.14527373e-02f, 8.54893774e-02f, -6.94779232e-02f,
  1.17398702e-01f, -2.55829632e-01f, 7.06278235e-02f, -2.42018685e-01f, -6.40179887e-02f, 4.24384698e-02f, -1.55600309e-01f, 2.81182304e-02f, -2.33598843e-01f, 1.10334745e-02f,
  -3.07527483e-02f, -3.25048529e-02f, -4.84949797e-02f, 1.10477291e-01f, -3.71136777e-02f, -5.38533106e-02f, 6.81988448e-02f, 1.24019338e-03f, 4.26602699e-02f, -1.73047651e-02f,
  6.85808957e-02f, 4.48557325e-02f, -1.03263706e-01f, -3.59202619e-03f, -1.31317992e-02f, -4.56440961e-03f, 4.22354642e-05f, -9.15111974e-02f, -9.93463304e-03f, 6.71857893e-02f,
  6.77526444e-02f, -1.29684135e-02f, 1.99783221e-02f, -5.78143224e-02f, 1.74056906e-02f, 4.93199341e-02f, -4.67525087e-02f, 2.35639699e-02f, -4.95458730e-02f, 4.91793007e-02f,
  -3.86871919e-02f, -5.75782992e-02f, 3.90425734e-02f, -3.42371464e-02f, 1.10012693e-02f, -1.24282375e-01f, 5.93271293e-02f, -9.68517885e-02f, 7.93050826e-02f, -1.47202220e-02f,
  -1.41152143e-02f, 2.95453947e-02f, 2.25007217e-02f, -2.07864512e-02f, -6.17945418e-02f, -3.85922496e-03f, 3.56172882e-02f, -3.83426622e-02f, 2.57187523e-02f, -6.18820675e-02f,
  6.46492317e-02f, 5.24562609e-04f, 2.86252685e-02f, -4.87830937e-02f, -4.17754240e-02f, 5.07201953e-03f, -4.22278680e-02f, 1.48255751e-02f, -1.03840893e-02f, 2.71580182e-02f,
  3.49258110e-02f, 6.22355938e-02f, -2.21036263e-02f, -5.02383709e-02f, 1.24736875e-03f, -2.80055646e-02f, 2.84656715e-02f, -6.18385291e-03f, 4.18188348e-02f, 5.57586811e-02f,
  -7.13831112e-02f, -3.71954106e-02f, -4.38703829e-03f, -6.04369445e-03f, -2.84548081e-03f, -5.13783023e-02f, 7.44033903e-02f, 9.24915969e-02f, 2.08027498e-03f, -3.26128639e-02f,
  -8.14088434e-02f, -2.87681483e-02f, 1.76157951e-02f, -1.84248723e-02f, -5.14394194e-02f, 5.03426827e-02f, -6.36056112e-03f, 5.95218353e-02f, -8.65450688e-03f, 1.37214642e-03f,
  -5.68636656e-02f, 4.69903685e-02f, -3.54624331e-01f, -1.55056408e-02f, 1.49761140e-01f, -7.18794093e-02f, -1.90662459e-01f, 8.92714262e-02f, -1.21440142e-01f, 1.48830310e-01f,
  7.75059238e-02f, -1.01269215e-01f, -1.93413198e-01f, 1.11768924e-01f, -2.35546201e-01f, 5.89634292e-03f, -6.66690171e-02f, -5.88380881e-02f, 5.36916777e-02f, -6.34121299e-02f,
  -1.29317388e-01f, 3.03698361e-01f, -2.03681275e-01f, 2.55053848e-01f, -1.49633102e-02f, -3.03984229e-02f, 1.04383677e-01f, -1.71495825e-01f, 1.64938465e-01f, 1.08705021e-01f,
  1.26238167e-01f, -4.37127091e-02f, -5.18945679e-02f, -2.07289811e-02f, -3.99151146e-02f, -5.91250993e-02f, -2.86947452e-02f, -8.25436935e-02f, -9.93706379e-03f, -4.09907289e-02f,
  -5.47154732e-02f, 4.00884636e-02f, 3.41193974e-02f, -2.04174370e-02f, -1.49164973e-02f, 2.91615408e-02f, -1.63543504e-03f, -3.90003994e-02f, -2.66852765e-03f, -7.75461197e-02f,
  -7.71962181e-02f, -1.15472917e-02f, -1.32671013e-01f, -4.37211915e-04f, -7.42121860e-02f, 2.87409667e-02f, -9.46919620e-02f, -7.86966160e-02f, 2.11639665e-02f, 3.61042470e-02f,
  -3.97216715e-02f, -4.46819104e-02f, -4.63734083e-02f, 4.83355746e-02f, 1.90344006e-02f, 6.08617663e-02f, -1.06354326e-03f, -2.72324216e-02f, 9.55048203e-03f, 3.65253463e-02f,
  7.96283111e-02f, -2.63866857e-02f, 3.32738832e-02f, -3.93952392e-02f, 4.00268734e-02f, 1.24849500e-02f, -1.98850036e-02f, 3.99636850e-02f, -1.06454395e-01f, 2.76450627e-02f,
  -7.06937984e-02f, -3.73922661e-02f, 2.55284570e-02f, 7.21154874e-03f, 4.55747498e-03f, -2.14133784e-02f, -4.00157645e-02f, -5.94958058e-03f, -3.99714671e-02f, -3.18656862e-02f,
  2.03536659e-01f, -2.72457693e-02f, 3.23974714e-02f, 1.26654640e-01f, 1.19040497e-01f, -1.13317370e-03f, -6.97672069e-02f, 1.83910653e-02f, 1.33172618e-02f, -2.11087484e-02f,
  -1.39122509e-04f, 2.39087176e-02f, -3.36514153e-02f, 2.07556244e-02f, -2.31045689e-02f, -3.24486010e-02f, -3.48550528e-02f, -2.34887972e-02f, 3.13958600e-02f, 8.81432295e-02f,
  1.20156799e-02f, 2.49345019e-03f, -5.77279851e-02f, 3.23205218e-02f, 2.47637834e-02f, 3.11803706e-02f, -1.72346402e-02f, 1.24818496e-02f, 2.43996605e-02f, 1.58393261e-04f,
  2.02980071e-01f, 2.54281580e-01f, 2.22761810e-01f, 2.51357704e-01f, -9.65795442e-02f, -2.77744323e-01f, -1.15549654e-01f, 3.30383591e-02f, 2.90633380e-01f, -6.07416406e-02f,
  -1.86159506e-01f, 1.87452421e-01f, -6.50988370e-02f, -1.66063562e-01f, -1.01604067e-01f, -7.31298476e-02f, -6.71178922e-02f, -1.78501438e-02f, 5.38998060e-02f, 8.34253281e-02f,
  3.91611904e-02f, -1.85921624e-01f, 9.54541638e-02f, -1.08262859e-01f, 9.54923406e-03f, 1.66128650e-01f, 4.08312455e-02f, -2.21537314e-02f, -7.12848678e-02f, -8.01202729e-02f,
  -6.15273826e-02f, 1.54045150e-01f, 4.33591194e-02f, -4.53400426e-04f, 2.64603994e-03f, -2.81355288e-02f, -9.05585662e-03f, -7.53054768e-02f, -3.62658165e-02f, -1.74393263e-02f,
  1.15595600e-02f, -6.00499623e-02f, -5.89234866e-02f, -4.53566608e-04f, 7.78112784e-02f, 2.33218651e-02f, 3.82423848e-02f, -2.09058126e-04f, 4.49510030e-02f, -7.80754089e-02f,
  -1.90027859e-02f, 2.92104166e-02f, 6.73259571e-02f, 1.17932232e-02f, -2.16881838e-02f, 3.61622386e-02f, 1.05904732e-02f, 3.19940416e-04f, -8.79401341e-02f, 1.08439684e-01f,
  -1.23172048e-02f, 4.92564514e-02f, -7.02723265e-02f, 4.71007042e-02f, -3.81880812e-02f, -1.12457145e-02f, 4.59891325e-03f, -1.14660095e-02f, 3.60824578e-02f, 2.61353403e-02f,
  -6.03152290e-02f, 7.59752914e-02f, -2.68897973e-02f, -1.33034075e-02f, 3.16698872e-03f, 5.36256172e-02f, 2.68779490e-02f, -6.92901388e-02f, 3.50344740e-02f, -9.62691940e-03f,
  -5.63138574e-02f, -2.55024843e-02f, 2.44307071e-02f, -8.26165974e-02f, -7.89662227e-02f, 3.45952921e-02f, 3.04333796e-03f, -1.38185425e-02f, 1.08442558e-02f, -6.77479431e-03f,
  4.24343459e-02f, 1.17809370e-01f, 1.07587148e-02f, 1.41172223e-02f, -1.58708803e-02f, -4.74299490e-02f, -5.10250293e-02f, -3.40686068e-02f, 5.32844365e-02f, -4.12959373e-03f,
  -5.06563894e-02f, -7.32369954e-03f, 5.78511655e-02f, -5.84771931e-02f, -4.86100167e-02f, -3.27474140e-02f, 9.94370878e-03f, -6.19855011e-03f, -9.81735997e-03f, 3.83463167e-02f,
  -4.19130959e-02f, -3.48677635e-02f, -3.50012034e-02f, 2.12881584e-02f, -3.01528238e-02f, 6.57572076e-02f, 4.02669283e-03f, 7.24041462e-03f, 6.47510821e-03f, -6.17327951e-02f,
  -2.41274312e-01f, 3.41452450e-01f, 2.47271299e-01f, -7.53946826e-02f, -5.48514761e-02f, -8.07027668e-02f, -3.86954322e-02f, 2.13119779e-02f, 5.63414954e-02f, -2.15885229e-02f,
  8.67897179e-03f, 1.48066908e-01f, 1.71750516e-01f, 8.85574743e-02f, -2.38863721e-01f, 1.61612615e-01f, -1.29235104e-01f, -4.75186408e-02f, 8.83933678e-02f, -2.60895137e-02f,
  -4.83204462e-02f, -5.77308983e-02f, 1.42053127e-01f, 1.40321121e-01f, -3.77857802e-03f, -1.66758392e-02f, -1.32114023e-01f, 2.09119081e-01f, -1.24966264e-01f, -7.62275532e-02f,
  -1.15588069e-01f, -1.76231004e-02f, 1.30385458e-01f, 9.60327834e-02f, -1.85464937e-02f, -9.98348445e-02f, -5.09989099e-04f, 1.14328206e-01f, 5.85465394e-02f, 3.79743427e-02f,
  -3.04831024e-02f, 9.66235250e-03f, 3.00604180e-02f, 1.23044379e-01f, -4.63503525e-02f, 1.09652184e-01f, 9.98383909e-02f, 3.27377394e-02f, 8.72307122e-02f, 9.21416096e-03f,
  6.83914647e-02f, -2.29201689e-02f, 2.89640818e-02f, -1.21623576e-02f, 2.88799219e-02f, 2.35503633e-02f, -7.05865351e-03f, -7.07051251e-03f, -5.26991859e-02f, 4.25100476e-02f,
  6.86557218e-02f, -7.42783770e-02f, 2.48004720e-02f, 2.29902677e-02f, -3.41371517e-03f, -1.12568373e-02f, 9.71141458e-02f, -2.69174799e-02f, -3.19066606e-02f, 1.50940111e-02f,
  -1.15762040e-01f, -6.12192936e-02f, -2.70558335e-02f, -1.59427486e-02f, -1.13981389e-01f, -3.18069477e-04f, 1.63291786e-02f, -4.54344861e-02f, -9.24655795e-02f, -1.56383775e-02f,
  8.00103396e-02f, 3.19473236e-03f, 3.41817737e-02f, -2.93549132e-02f, 3.96968983e-02f, 9.95093957e-03f, 7.67386798e-03f, 1.46714628e-01f, 6.01228187e-03f, -1.02392219e-01f,
  -1.17336191e-01f, -6.23176768e-02f, -6.19792156e-02f, -7.71174282e-02f, -3.88882160e-02f, 2.36510616e-02f, -3.46439593e-02f, 4.48113233e-02f, 4.15066481e-02f, -1.51574500e-02f,
  8.99945013e-03f, -3.50617431e-02f, -9.37350914e-02f, -5.13642915e-02f, -3.77442874e-02f, -1.73364971e-02f, -8.45696405e-02f, 1.96330994e-02f, -1.65080801e-01f, -8.94691497e-02f,
  3.33233178e-02f, 1.45431822e-02f, -9.05894209e-03f, -5.32696396e-03f, -1.30792663e-01f, -4.39594463e-02f, -8.51031914e-02f, 8.00428726e-03f, -1.51473214e-03f, 4.66794055e-03f,
  -1.67666063e-01f, 2.74593651e-01f, 9.07037556e-02f, -1.33441985e-01f, 1.47921806e-02f, -1.41147986e-01f, -2.12149873e-01f, 2.16645703e-01f, -8.76718462e-02f, -8.27826373e-03f,
  -1.57431334e-01f, 1.59515992e-01f, -4.42982279e-02f, -1.70545846e-01f, -2.56515175e-01f, -1.08758278e-01f, -2.02185452e-01f, -3.43088210e-02f, 2.01802813e-02f, 1.15288697e-01f,
  -3.71919349e-02f, -4.54594865e-02f, 1.78740732e-02f, 2.07171351e-01f, 8.84555578e-02f, 2.41366979e-02f, -9.87506285e-02f, 1.20462611e-01f, 7.27694333e-02f, 5.00512570e-02f,
  1.10623389e-01f, -1.04722800e-02f, -3.12783271e-02f, 1.14989646e-01f, -7.23106638e-02f, -1.78785308e-03f, 2.72217542e-02f, -9.34727956e-03f, 1.30757899e-03f, 1.99466813e-02f,
  -2.17122585e-02f, 2.39555687e-02f, -2.05498375e-02f, 2.71218307e-02f, -2.53337901e-02f, 6.81852102e-02f, 6.64112195e-02f, -3.81979831e-02f, 9.77565870e-02f, -2.82059778e-02f,
  2.01969370e-02f, 2.00440176e-02f, -4.93841916e-02f, 8.66358541e-03f, 1.07450336e-02f, -5.61898388e-02f, -1.88067381e-03f, -9.40025039e-03f, 1.87598448e-02f, -4.11107130e-02f,
  -9.61693227e-02f, -5.48631549e-02f, 1.43197821e-02f, 9.14685354e-02f, -4.34652753e-02f, 3.37460339e-02f, -4.19520913e-03f, 8.65479407e-04f, 7.63950795e-02f, -8.97661131e-03f,
  -4.28956598e-02f, 3.40722501e-02f, 1.88959967e-02f, -2.67082080e-02f, -7.23148044e-03f, -5.24922870e-02f, 9.67451185e-03f, 8.98551196e-02f, -4.12173979e-02f, 1.64484922e-02f,
  -2.48336755e-02f, -1.37471072e-02f, 4.43202928e-02f, -1.94289424e-02f, 2.44229101e-02f, 4.10801508e-02f, 3.68737360e-03f, 2.73793247e-02f, -1.24891791e-02f, -2.20175683e-02f,
  1.13140240e-01f, 8.15316737e-02f, -1.49294762e-02f, 1.43446233e-02f, 6.79901103e-03f, 2.27511022e-03f, 5.25234677e-02f, 9.04064812e-03f, 1.09387092e-01f, -5.26664108e-02f,
  1.00135848e-01f, -2.46222429e-02f, 6.90679550e-02f, 5.95177384e-03f, 2.94040777e-02f, -2.56247725e-02f, -4.34323475e-02f, -9.86625161e-03f, -4.50713821e-02f, -1.29895974e-02f,
  -2.62779351e-02f, 7.53762852e-03f, -3.69136371e-02f, 4.08950150e-02f, 4.64941971e-02f, -3.08398213e-02f, 4.11879475e-04f, 3.65209691e-02f, 4.29774337e-02f, 6.21394143e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.81173061e-02f, 1.11827636e-02f, 1.21288665e-01f, 1.80949479e-01f, -3.61118391e-02f, -1.03437871e-01f, -1.16218820e-01f, -3.39552052e-02f, -1.28383741e-01f, 1.26286340e-03f,
  -1.61678255e-01f, 2.00152114e-01f, -1.55505523e-01f, -5.64730838e-02f, 1.00061558e-01f, -2.65682489e-01f, 1.02619454e-01f, 1.86434239e-02f, -1.64733410e-01f, 2.44106010e-01f,
  -3.74680161e-02f, -9.38384533e-02f, 4.55456600e-02f, 9.26693082e-02f, 1.96485981e-01f, 2.25753769e-01f, 3.69481832e-01f, 2.00129271e-01f, 3.04950535e-01f, -1.32760584e-01f,
  -1.31533146e-01f, -3.58164124e-02f, -5.89733683e-02f, -8.07835311e-02f, 1.67400971e-01f, 1.05662301e-01f, 1.49296492e-01f, -4.22200598e-02f, 1.58964619e-01f, -1.17265172e-01f,
  7.82462135e-02f, 3.69483698e-03f, 1.05943123e-03f, 2.79523078e-02f, -1.32835001e-01f, 1.70210078e-01f, 6.88379779e-02f, 2.11780705e-02f, -2.80503407e-02f, -1.03742853e-01f,
  3.35068852e-02f, -1.43532930e-02f, 4.75481451e-02f, 6.95289746e-02f, -2.67383605e-02f, -4.05728742e-02f, 7.39858374e-02f, 8.27198848e-02f, -1.06853750e-02f, -2.93089263e-02f,
  -6.37986362e-02f, 6.92648739e-02f, -5.29509708e-02f, -1.51752725e-01f, -2.78826803e-02f, -2.06982680e-02f, -1.77105572e-02f, -5.66371791e-02f, -1.12803474e-01f, 1.37690723e-01f,
  6.26467019e-02f, 5.19186184e-02f, -9.30140913e-02f, -6.88440651e-02f, -9.57260281e-02f, -3.63449194e-02f, 1.38949201e-01f, 9.02942270e-02f, -3.94769595e-04f, -6.48350790e-02f,
  -3.32252607e-02f, 5.64225763e-02f, 1.25587014e-02f, 2.67416355e-03f, -1.13032423e-01f, -2.33912151e-02f, -2.91434769e-02f, -2.06553526e-02f, -3.21476138e-03f, -1.07933199e-02f,
  4.11667824e-02f, 1.77292138e-01f, -7.40333945e-02f, -1.42051920e-03f, -5.19046262e-02f, 1.27684399e-01f, -1.77984133e-01f, -1.57682709e-02f, 1.65231898e-01f, -9.44710970e-02f,
  1.58651069e-01f, 5.34029379e-02f, 1.02074459e-01f, 6.43750057e-02f, 1.23480871e-01f, -1.92050617e-02f, 1.10916369e-01f, 1.15134351e-01f, 1.75488666e-01f, 1.01807922e-01f,
  1.42531889e-02f, 5.23007475e-02f, -9.86176059e-02f, 6.07322808e-03f, 9.47120413e-03f, -8.23334325e-04f, 1.87611394e-02f, 1.07256405e-01f, -4.53141443e-02f, 4.68244590e-02f,
  1.65433079e-01f, -3.43526006e-01f, -5.47069348e-02f, 1.38409019e-01f, 1.01577170e-01f, -2.05271587e-01f, -3.38905081e-02f, 5.82001135e-02f, 3.34000379e-01f, -7.05129802e-02f,
  -1.16912030e-01f, -2.53628921e-02f, 4.79750186e-02f, -1.67149231e-01f, 3.07690918e-01f, 5.85305318e-02f, -1.77669063e-01f, -1.65329315e-02f, 1.77286431e-01f, -9.89436880e-02f,
  -9.95169207e-03f, -1.40095115e-01f, -1.18735872e-01f, -1.70118332e-01f, -2.00301990e-01f, 2.11007390e-02f, -2.43893806e-02f, -1.39581040e-01f, -2.25469977e-01f, -3.10202558e-02f,
  -2.08988860e-01f, -1.01105161e-01f, -1.42304927e-01f, -9.64274481e-02f, -1.23851418e-01f, 3.29610296e-02f, -4.46015298e-02f, 7.56129846e-02f, 2.27876734e-02f, -2.51532588e-02f,
  -1.99941546e-02f, 3.59962545e-02f, 3.34462970e-02f, 1.54659450e-01f, -6.54602051e-02f, -1.98353101e-02f, 7.26610273e-02f, -8.39214921e-02f, 3.11969612e-02f, -4.25293706e-02f,
  -3.95529792e-02f, -9.19928998e-02f, -7.02331811e-02f, -1.05359813e-03f, 1.27682537e-02f, -7.38745630e-02f, 3.24434713e-02f, -3.48693691e-02f, -5.52848689e-02f, -4.38080579e-02f,
  8.40786025e-02f, -1.49026494e-02f, 1.15363218e-03f, 1.63510293e-02f, -4.75489125e-02f, -1.68918036e-02f, 1.91902053e-02f, 2.55529545e-02f, -2.92990506e-02f, 8.57347921e-02f,
  -6.46503791e-02f, -4.36487421e-03f, 1.61030442e-01f, -3.30302976e-02f, 6.57003000e-02f, -2.53747646e-02f, 5.38406847e-03f, 7.59719163e-02f, 6.94732368e-02f, -7.22701102e-02f,
  -1.58337522e-02f, 6.21943325e-02f, 1.60659663e-02f, -7.39285797e-02f, 8.46853629e-02f, -2.29858551e-02f, 5.26006818e-02f, 8.81709829e-02f, -2.39290129e-02f, -4.90448587e-02f,
  -1.89650461e-01f, -1.84694454e-01f, 2.23621936e-03f, -7.67409652e-02f, -1.32155372e-02f, -5.23145571e-02f, 1.03050925e-01f, 4.69986722e-02f, -1.17197566e-01f, -4.74107359e-03f,
  1.91509898e-03f, -6.40842840e-02f, -8.87526646e-02f, 3.22020911e-02f, 1.71908096e-03f, 3.17168236e-02f, -7.74970800e-02f, -5.77135570e-02f, -5.99632002e-02f, -1.15069836e-01f,
  -5.72812278e-03f, 3.72038372e-02f, 1.34411566e-02f, -6.46969012e-04f, -2.29372606e-02f, 1.35515304e-03f, 7.48668090e-02f, 4.83341143e-03f, -3.97874117e-02f, -5.43500781e-02f,
  -8.65043178e-02f, 3.57365042e-01f, 1.71953976e-01f, 1.42925307e-01f, 1.92013264e-01f, 2.44976729e-01f, 5.59671856e-02f, 1.09217376e-01f, 2.86286503e-01f, -2.47499734e-01f,
  -3.50177914e-01f, -1.53983887e-02f, -2.83998430e-01f, 1.06137805e-01f, -4.41090502e-02f, 1.16973311e-01f, 1.73236385e-01f, 2.83468254e-02f, 3.22320819e-01f, -9.78250131e-02f,
  1.56690642e-01f, -1.98877841e-01f, -1.39504924e-01f, -1.96294524e-02f, -1.42618418e-01f, 1.82677522e-01f, -2.84492522e-01f, 1.53690418e-02f, -1.11035639e-04f, 6.24010805e-03f,
  1.65274769e-01f, 1.03141151e-01f, 1.20534888e-02f, 1.25519186e-01f, -3.32618169e-02f, -1.14138238e-01f, -3.04885358e-02f, -3.21644507e-02f, 5.60877137e-02f, 1.93338487e-02f,
  -8.26658234e-02f, -7.59860128e-02f, 8.65711272e-02f, 3.65340291e-03f, 1.41621828e-01f, -2.99935602e-02f, 5.02325296e-02f, 4.89586629e-02f, 1.24862678e-01f, -4.14203107e-03f,
  1.92057025e-02f, 1.34174889e-02f, 1.09084986e-01f, 6.45890608e-02f, 1.77657798e-01f, 2.07984373e-01f, 3.15612741e-02f, 2.37648319e-02f, -2.64791753e-02f, 6.78838864e-02f,
  6.00495003e-02f, -1.94701962e-02f, -4.85829078e-03f, -1.96286619e-01f, -1.50114689e-02f, -2.01884210e-02f, 3.45207974e-02f, -9.48789641e-02f, 1.71943411e-01f, -5.39513156e-02f,
  -3.99656929e-02f, 1.08983621e-01f, 1.04271062e-01f, 1.09010991e-02f, 1.66050605e-02f, -2.36099609e-03f, 2.12257579e-02f, 3.13029103e-02f, 9.59712043e-02f, -3.03084180e-02f,
  -9.47112143e-02f, 1.07362173e-01f, -9.71846431e-02f, -1.64942052e-02f, 1.20471559e-01f, -6.39172420e-02f, -2.12546870e-01f, -2.20400393e-02f, 4.40581739e-02f, -9.05681476e-02f,
  1.53292626e-01f, 1.01667985e-01f, 1.31523728e-01f, 1.11454964e-01f, 5.63563369e-02f, -1.24135405e-01f, 1.00157417e-01f, 3.58768962e-02f, 1.64601013e-01f, -3.90956774e-02f,
  1.26543855e-02f, -4.30726558e-02f, -7.46950954e-02f, -5.62481768e-02f, 1.07452169e-01f, -1.80757325e-02f, 1.77669395e-02f, 4.56741340e-02f, -3.11414730e-02f, -1.08222209e-01f,
  -1.16325147e-01f, 2.63303239e-02f, -6.24421127e-02f, 9.81690288e-02f, -2.70797051e-02f, 5.01135306e-04f, -5.57042658e-02f, 4.91841063e-02f, -1.17750756e-01f, 1.38531700e-01f,
  -6.34412050e-01f, 2.88546562e-01f, 1.31488100e-01f, -1.57114729e-01f, 1.63089380e-01f, -6.55131089e-03f, -1.03572737e-02f, 5.89040034e-02f, 1.57511085e-01f, 2.27756813e-01f,
  9.02346671e-02f, 1.02293126e-01f, 2.11188197e-01f, 1.40720792e-02f, -2.14736387e-01f, 1.89700484e-01f, -2.44429529e-01f, -1.85640767e-01f, 1.04465544e-01f, -6.01598211e-02f,
  -8.94123167e-02f, -1.00338392e-01f, -1.37749389e-01f, 1.03575336e-02f, -2.06052005e-01f, -8.81287083e-02f, -2.51057595e-01f, 2.11997345e-01f, -1.30292535e-01f, 4.30572219e-02f,
  -2.69350678e-01f, -2.62137726e-02f, 1.09493397e-02f, -6.01260997e-02f, -2.10361108e-01f, -7.14239553e-02f, -1.12229288e-01f, 5.78105226e-02f, 6.51075393e-02f, 6.41154498e-02f,
  1.70934692e-01f, -9.62959789e-03f, -8.25839117e-02f, 1.29492044e-01f, -4.05760631e-02f, 2.51424313e-02f, 7.09254816e-02f, -1.14208087e-01f, 9.77756903e-02f, -2.15893076e-03f,
  2.01890290e-01f, -2.95290649e-02f, -1.86791942e-01f, -9.81655344e-02f, -1.15203410e-01f, 1.12848449e-02f, 3.32864188e-02f, -9.36557874e-02f, -4.60806452e-02f, -7.10946470e-02f,
  -5.01470380e-02f, 5.48339747e-02f, 1.09565608e-01f, -1.01012569e-02f, 2.31612045e-02f, -8.20978060e-02f, -2.14535948e-02f, -2.77207587e-02f, -1.30892262e-01f, -4.22481522e-02f,
  -7.90896565e-02f, -5.23050800e-02f, -4.55708131e-02f, -2.90437434e-02f, 4.29084450e-02f, 1.56330820e-02f, -3.63861658e-02f, 2.52383072e-02f, -1.45221248e-01f, -1.28910571e-01f,
  7.78242797e-02f, 5.32899499e-02f, -7.69764557e-02f, -4.88611385e-02f, -3.18569504e-02f, -8.26519951e-02f, -5.70067354e-02f, 7.93363154e-03f, -1.39079299e-02f, -4.96187955e-02f,
  -3.85398537e-01f, -1.85031995e-01f, 3.80847231e-02f, -1.04378117e-02f, 5.38047664e-02f, -1.53479911e-02f, -1.22894421e-02f, -5.24215773e-02f, 6.17645159e-02f, -1.73486453e-02f,
  -5.29637076e-02f, -2.17396170e-02f, -8.58358368e-02f, 7.43799210e-02f, 7.38412738e-02f, -3.77718061e-02f, 4.79494557e-02f, 8.02144632e-02f, -2.63175406e-02f, -3.68392863e-03f,
  -1.17227681e-01f, -2.88578235e-02f, -6.15521669e-02f, -5.95806129e-02f, -1.26819462e-01f, -1.00332461e-01f, -1.41738430e-01f, -4.94806953e-02f, 6.69812188e-02f, -1.05424456e-01f,
  -6.08207807e-02f, 3.72996598e-01f, -1.64721578e-01f, 1.43087000e-01f, -2.12579101e-01f, 3.63512009e-01f, 3.47265691e-01f, 1.24020979e-01f, 2.47444391e-01f, 3.57792705e-01f,
  2.73839980e-02f, 1.40894786e-01f, 1.19467907e-01f, 2.72879928e-01f, 7.85250366e-02f, 1.79424271e-01f, 3.46422404e-01f, 3.23760003e-01f, 5.28797172e-02f, 1.36198532e-02f,
  -3.30643877e-02f, 2.19887719e-01f, -1.95884407e-01f, -1.48852959e-01f, -3.66159715e-02f, -1.81172669e-01f, -1.93463027e-01f, -2.30969414e-01f, -6.76524118e-02f, 7.97064509e-03f,
  6.76997751e-02f, 5.40300682e-02f, -1.29630938e-01f, 2.68300287e-02f, 2.78344210e-02f, -9.43140686e-02f, -4.85848524e-02f, -6.05015196e-02f, -1.57103270e-01f, 7.15564489e-02f,
  2.61330996e-02f, -1.59278624e-02f, 1.57410055e-01f, -8.19511935e-02f, -8.93652290e-02f, -1.10674866e-01f, -7.34870955e-02f, 5.51646762e-03f, 1.28488634e-02f, -4.37584110e-02f,
  -6.52513877e-02f, -2.27746507e-03f, -4.19806354e-02f, 1.24233648e-01f, -1.03772199e-02f, 3.48515697e-02f, 8.63510296e-02f, -1.09038102e-02f, 9.60121751e-02f, 3.88860740e-02f,
  -1.13348607e-02f, 1.86885186e-02f, -6.25453368e-02f, -6.98187724e-02f, -2.96249855e-02f, -6.23460859e-02f, -1.54789733e-02f, -2.93601975e-02f, -6.93253651e-02f, -1.59812942e-02f,
  -1.77990943e-02f, -1.32310353e-02f, 3.51250754e-03f, 4.94172946e-02f, -3.10461782e-03f, 5.18511571e-02f, -7.34421462e-02f, 3.41509469e-02f, 6.11725375e-02f, -5.27284965e-02f,
  2.66699493e-02f, 6.01109453e-02f, 2.86508035e-02f, 3.42313722e-02f, 2.13617198e-02f, -2.04848051e-02f, 8.73835012e-02f, 3.10349707e-02f, -2.53040791e-02f, -1.42436603e-03f,
  1.64306402e-01f, 2.94139355e-01f, 1.19478002e-01f, -4.41472344e-02f, -3.84804197e-02f, 1.69599783e-02f, -3.93531397e-02f, 7.80588314e-02f, 1.41702026e-01f, 2.61183791e-02f,
  1.92200709e-02f, 1.26643172e-02f, -6.06589504e-02f, -9.72283259e-02f, -5.68916425e-02f, 6.22514598e-02f, 2.96123810e-02f, 5.30237854e-02f, 3.76010202e-02f, -4.49230559e-02f,
  -1.32501423e-01f, 1.75775774e-02f, -3.98248173e-02f, 7.13277049e-03f, 8.78753662e-02f, 1.31758964e-02f, 1.66051537e-02f, -1.23499312e-01f, 1.23745343e-02f, 1.55409291e-01f,
  4.37768906e-01f, 3.93536268e-03f, 2.03517765e-01f, 3.33949983e-01f, 5.86369969e-02f, 1.00941524e-01f, 3.36636364e-01f, 1.30883092e-02f, 4.26018000e-01f, -1.15604013e-01f,
  -9.55805779e-02f, 2.47788221e-01f, -9.09506455e-02f, -2.07512453e-02f, -1.36289135e-01f, -1.82705447e-01f, -7.30286092e-02f, 1.12063617e-01f, 5.65068014e-02f, 2.04810098e-01f,
  1.31569982e-01f, -1.27567112e-01f, -2.18015332e-02f, -2.70720273e-01f, 6.82262853e-02f, 9.97376442e-02f, -3.07034850e-01f, -1.09771118e-02f, -1.60222039e-01f, -2.53355708e-02f,
  -5.18366545e-02f, 2.82196831e-02f, 4.55845520e-03f, -4.48569022e-02f, 4.31391262e-02f, -2.74192425e-03f, 5.64193502e-02f, -8.11142623e-02f, 1.19831458e-01f, 5.91786280e-02f,
  9.18371677e-02f, 4.78923544e-02f, -9.58085731e-02f, 2.68261898e-02f, 5.29738935e-03f, 2.84682098e-03f, 1.26006957e-02f, -4.44185510e-02f, 3.78070623e-02f, 1.76063050e-02f,
  1.81800827e-01f, 4.62223217e-02f, -9.27799940e-03f, -7.03561902e-02f, -9.92945731e-02f, -5.64026833e-02f, 4.57133427e-02f, -1.08417729e-02f, 8.69762972e-02f, -1.78836528e-02f,
  -9.70465243e-02f, -5.26142307e-02f, 6.74472600e-02f, 8.66687819e-02f, 1.26355859e-02f, 4.60855812e-02f, 6.19279593e-02f, -5.79506829e-02f, 6.96708634e-02f, -1.35606751e-02f,
  -2.69751586e-02f, -9.36430842e-02f, 4.32424732e-02f, 6.48036972e-03f, 5.69398142e-02f, 7.46060312e-02f, -1.14497848e-01f, -6.56626299e-02f, 3.07202116e-02f, -6.59101680e-02f,
  5.31139895e-02f, 3.64478007e-02f, -7.05733225e-02f, 1.68171078e-01f, -2.80923024e-02f, 4.21743467e-02f, 6.43485710e-02f, 4.95350957e-02f, -2.59152311e-03f, -5.38280886e-03f,
  -1.88007224e-02f, -2.23081112e-01f, -7.21463263e-02f, -3.84549089e-02f, 2.10926123e-02f, -4.39647064e-02f, 3.37202325e-02f, -2.33068317e-02f, -2.36885678e-02f, 1.12510324e-02f,
  4.59284931e-02f, 4.38526981e-02f, 2.54582940e-03f, -2.36404072e-02f, -3.17448527e-02f, -1.11120865e-02f, -5.34635708e-02f, -9.46268961e-02f, -1.20953530e-01f, -1.47492103e-02f,
  -5.81750348e-02f, 1.03978105e-01f, 8.68940279e-02f, 6.07619137e-02f, -7.59976804e-02f, -8.19276422e-02f, -5.20089418e-02f, -1.06519081e-01f, -5.88342771e-02f, -2.24386621e-02f,
  4.67720509e-01f, 1.23564899e-02f, 2.79492319e-01f, 3.20449561e-01f, 7.54293278e-02f, -1.93416640e-01f, -2.41333619e-02f, 5.07878289e-02f, 2.02905566e-01f, -1.20185189e-01f,
  -1.35441408e-01f, 1.64836094e-01f, -2.30422854e-01f, 1.90911919e-01f, -3.40391517e-01f, -2.11383462e-01f, 3.30402479e-02f, 3.09411306e-02f, -2.03788150e-02f, 6.35450780e-02f,
  6.13605902e-02f, -1.39948756e-01f, -1.34498343e-01f, 4.95122150e-02f, 1.76202953e-01f, 2.12385535e-01f, -9.28913578e-02f, -8.04167986e-02f, 8.27964321e-02f, 4.95476089e-02f,
  -5.35442717e-02f, 5.77915534e-02f, 7.72892982e-02f, -2.52747294e-02f, -1.89819206e-02f, 1.15422234e-02f, -5.21398894e-02f, -1.06738895e-01f, -5.03515154e-02f, 2.20694114e-02f,
  1.55366948e-02f, -4.57372926e-02f, 1.49679124e-01f, -3.30616310e-02f, 1.44296527e-01f, 1.25384688e-01f, 9.97419357e-02f, -4.03544540e-03f, 9.36926976e-02f, 2.32627150e-02f,
  8.74954686e-02f, 1.05553130e-02f, 7.65956342e-02f, -1.35205849e-03f, -3.20486259e-03f, -6.90158643e-03f, -1.74725559e-02f, 5.74057885e-02f, -3.06501575e-02f, 4.29161191e-02f,
  3.10168648e-03f, -1.79843865e-02f, 5.50629273e-02f, 1.19703770e-01f, 7.44651705e-02f, 2.43737604e-02f, -7.25530535e-02f, -2.24360302e-02f, -7.11462945e-02f, -6.02733791e-02f,
  2.14990284e-02f, 1.68030307e-01f, 9.09296945e-02f, 1.13452047e-01f, -8.95857140e-02f, 1.35608107e-01f, -3.49095985e-02f, 4.16934751e-02f, 3.06777600e-02f, -4.41135243e-02f,
  1.95945557e-02f, -8.61218274e-02f, 4.85974550e-02f, 4.40183170e-02f, -1.10908292e-01f, -1.93140939e-01f, -1.58358719e-02f, 1.54496044e-01f, -1.04107834e-01f, -7.35977441e-02f,
  -4.01137441e-01f, -4.33999747e-01f, -1.17074475e-01f, -5.31706437e-02f, -1.22140935e-02f, -1.08488493e-01f, -7.47675896e-02f, 1.00285769e-01f, -1.34476185e-01f, 3.60311419e-02f,
  -7.28755668e-02f, 1.64316371e-02f, 4.68628593e-02f, 9.32637006e-02f, -2.67910808e-02f, -6.79436177e-02f, -9.26654637e-02f, -2.92152688e-02f, -1.06777668e-01f, -1.27568498e-01f,
  1.06060058e-01f, -3.31430696e-02f, -9.68852565e-02f, 4.53399047e-02f, 4.90990244e-02f, -1.44677162e-02f, 1.30215123e-01f, 7.26723373e-02f, -7.24403337e-02f, -3.91943045e-02f,
  -3.13453496e-01f, 1.19000450e-02f, -9.33955535e-02f, -3.43617380e-01f, 2.99385309e-01f, 1.54311374e-01f, -9.84937325e-02f, 8.55990201e-02f, -1.05383515e-01f, 1.46427184e-01f,
  -6.50496855e-02f, -1.96768641e-01f, 2.46146675e-02f, -3.37899774e-01f, -4.00821000e-01f, -3.33897769e-01f, -2.44099706e-01f, -1.37870640e-01f, -1.80090293e-01f, 3.86685170e-02f,
  -2.15188786e-01f, 2.91158706e-02f, -2.03333065e-01f, 2.17607915e-01f, 3.22286263e-02f, 1.59886032e-01f, 2.13118494e-01f, 2.14934260e-01f, 1.88911986e-02f, -5.41800493e-03f,
  -1.09094679e-01f, -2.49840289e-01f, -5.18448837e-03f, 7.91664496e-02f, 1.26557890e-02f, 3.39341313e-02f, 1.68079808e-01f, -2.66672913e-02f, -4.33566496e-02f, -1.25544325e-01f,
  6.87906817e-02f, -8.87398049e-02f, -1.76430102e-02f, -2.55877059e-02f, 3.12237162e-02f, -9.07097310e-02f, -2.13951264e-02f, -8.17369390e-03f, -2.28625089e-02f, -2.09338427e-01f,
  -1.00521013e-01f, 2.54465826e-02f, 3.53964120e-02f, -1.18291058e-01f, 2.06259713e-02f, 5.14909700e-02f, -7.75527284e-02f, -1.01950197e-02f, -9.11908224e-04f, -1.04788512e-01f,
  -6.13991395e-02f, 5.96530586e-02f, 4.37584147e-03f, -6.24016263e-02f, -5.53931296e-02f, 4.25031260e-02f, 2.77515482e-02f, 7.33565725e-03f, 2.90618762e-02f, 1.23005211e-02f,
  -7.74588287e-02f, 1.88717656e-02f, 1.53574012e-02f, 4.32884432e-02f, -3.12712528e-02f, -4.61640134e-02f, 1.26398399e-01f, -6.27055988e-02f, -9.66665149e-02f, 4.81862994e-03f,
  7.61173293e-02f, 4.98016626e-02f, 4.79316153e-02f, 4.21808250e-02f, 5.45284636e-02f, -1.56007484e-02f, 6.97258338e-02f, -3.21247987e-02f, 9.24969092e-02f, 2.05030404e-02f,
  1.39370084e-01f, 4.63624112e-02f, 2.27661505e-02f, 3.16043012e-02f, -5.75531945e-02f, 6.84899539e-02f, 1.83753595e-02f, -2.16577705e-02f, 7.38621876e-02f, 8.44211280e-02f,
  6.88784570e-02f, -2.42857430e-02f, 1.14609949e-01f, 1.01779923e-02f, 5.13001252e-03f, -5.88371651e-03f, 8.92224088e-02f, 1.03839651e-01f, 8.25292096e-02f, 9.05243158e-02f,
  1.21834338e-01f, 1.75750125e-02f, -4.82205525e-02f, 4.96528670e-02f, -6.61847414e-03f, 1.81934088e-02f, 7.67484605e-02f, -3.48188393e-02f, -3.45438123e-02f, -1.32983811e-02f,
  1.69876263e-01f, 8.30004364e-02f, 3.81530486e-02f, 2.33790770e-01f, -1.29155248e-01f, 3.19236070e-01f, 3.10956508e-01f, 3.07979882e-02f, 3.30350369e-01f, 1.51003808e-01f,
  1.09023200e-02f, 1.75623387e-01f, 6.88202828e-02f, 1.53464809e-01f, 7.23499879e-02f, 1.39665559e-01f, 2.93037564e-01f, 1.38653323e-01f, 8.70814770e-02f, 1.30197003e-01f,
  3.94049510e-02f, 9.56815854e-02f, -2.40170434e-01f, -5.75622218e-03f, -9.00902301e-02f, -1.54661253e-01f, -2.78380901e-01f, -1.91284582e-01f, -7.17766583e-02f, -1.69009745e-01f,
  2.69426778e-02f, 9.13956687e-02f, 3.39159071e-02f, -2.66662296e-02f, -5.79930330e-03f, 2.48468071e-02f, -6.70731664e-02f, -1.70284808e-01f, -8.33803564e-02f, 1.30590215e-01f,
  1.57256853e-02f, -4.98322435e-02f, 7.69881532e-02f, -9.53330547e-02f, -3.55154800e-04f, -6.11108765e-02f, 1.95004772e-02f, -8.89062807e-02f, -7.47200325e-02f, -8.96248668e-02f,
  2.00006627e-02f, 2.39883792e-02f, 1.44189179e-01f, 6.33599833e-02f, -8.31246525e-02f, 1.31223291e-01f, 4.97944914e-02f, -2.62903273e-02f, -1.67627595e-02f, 1.05478219e-03f,
  -6.04424998e-02f, 3.89989018e-02f, -1.91667527e-02f, 1.14734340e-02f, 1.67751387e-02f, 2.32827812e-02f, -8.24322179e-02f, -1.40204495e-02f, 1.36979908e-01f, 9.53842029e-02f,
  3.44288759e-02f, -2.24989317e-02f, -7.99938850e-03f, 8.00369680e-02f, 8.71634670e-03f, 5.73277357e-04f, -6.59648702e-02f, -6.14373051e-02f, 9.85057577e-02f, -7.63262585e-02f,
  -1.09967932e-01f, 1.51391476e-02f, 4.64551449e-02f, -1.76741764e-01f, -3.70034836e-02f, -9.63324308e-02f, -4.93627042e-02f, 1.75613184e-02f, -5.82936220e-02f, -1.69263966e-02f,
  6.31165802e-02f, 9.85841826e-02f, -1.27230622e-02f, 4.81232852e-02f, -2.32463758e-02f, 7.73308277e-02f, 7.10710734e-02f, 9.91800129e-02f, 3.59530281e-03f, 7.17569813e-02f,
  -4.22837660e-02f, 1.34418309e-01f, 1.64787229e-02f, -4.55686450e-02f, 3.06550954e-02f, 3.93984094e-02f, 9.85558778e-02f, -5.64991944e-02f, 6.44714907e-02f, -1.55835524e-01f,
  -9.41319577e-03f, 4.93094474e-02f, -2.97696628e-02f, 2.96536237e-02f, 4.66011092e-03f, -4.71534692e-02f, 3.65386978e-02f, 2.50184140e-03f, -1.30615532e-01f, 8.55877325e-02f,
  -2.51455277e-01f, 3.40000205e-02f, -2.99410373e-01f, 1.11264745e-02f, -1.19436741e-01f, 3.06840599e-01f, 4.01894003e-01f, -6.34910762e-02f, 1.32226348e-01f, 3.35511774e-01f,
  2.99344420e-01f, -7.82293081e-02f, 1.37631387e-01f, 4.04178977e-01f, 9.54333320e-02f, 3.20067286e-01f, 2.53923893e-01f, 2.86687285e-01f, -1.51444167e-01f, -6.89947754e-02f,
  -1.78129852e-01f, 2.61846453e-01f, -1.41667458e-03f, -1.25253573e-01f, 6.36323169e-02f, -2.21562698e-01f, -5.23064807e-02f, -2.28615746e-01f, 6.92220703e-02f, 3.90726551e-02f,
  5.44806803e-03f, -2.00507998e-01f, -9.12741423e-02f, -1.23797968e-01f, -6.08646721e-02f, -8.73231068e-02f, 8.41313228e-03f, -1.15416542e-01f, -5.52545339e-02f, -8.55312124e-02f,
  1.09776640e-02f, -1.22435868e-01f, -1.42201222e-02f, 4.60781269e-02f, -2.65273713e-02f, 2.45437468e-03f, -1.77378245e-02f, 5.83186485e-02f, -2.21802182e-02f, -6.91231266e-02f,
  -5.41906990e-02f, 4.32307050e-02f, 5.77536933e-02f, 1.13194078e-01f, -5.48192970e-02f, 4.90497239e-02f, -4.44308259e-02f, 1.18137477e-02f, -1.70500595e-02f, -7.15847164e-02f,
  2.26900075e-02f, -1.61945336e-02f, 5.14714606e-02f, 7.07230764e-03f, -2.45541707e-02f, 8.47688541e-02f, 9.47975516e-02f, 4.39474136e-02f, -1.29852429e-01f, 1.48147464e-01f,
  -3.73165645e-02f, 8.23098868e-02f, -2.22079759e-03f, -1.33840144e-02f, 1.28316842e-02f, 3.26043442e-02f, 3.61295678e-02f, 4.03819196e-02f, 4.08168286e-02f, 3.94557454e-02f,
  -4.24000015e-03f, 5.45060961e-03f, 3.68732810e-02f, 1.34906853e-02f, 3.71559449e-02f, -9.23869163e-02f, -4.06760238e-02f, -2.39692591e-02f, 1.06275575e-02f, 2.44465983e-03f,
  1.41384974e-01f, -1.02500610e-01f, 1.42932199e-02f, -5.80833852e-03f, 6.24357238e-02f, 7.30496049e-02f, -4.42102272e-03f, -3.75845619e-02f, 1.14839979e-01f, -5.97530343e-02f,
  6.26965836e-02f, 5.62796742e-02f, 5.50373644e-02f, -6.83425069e-02f, 2.57024001e-02f, 6.14173152e-02f, 4.27795313e-02f, 4.60768351e-03f, 7.18088672e-02f, 4.81017400e-03f,
  7.50445575e-02f, -8.52606595e-02f, 1.65277533e-02f, -3.10703609e-02f, 5.43632284e-02f, -1.27327233e-03f, -2.70849895e-02f, -7.05434531e-02f, 4.46253605e-02f, -4.55660746e-02f,
  -3.98504168e-01f, 2.71879524e-01f, 1.62730098e-01f, 3.09640408e-01f, -2.07569405e-01f, -2.64630467e-01f, -1.66703433e-01f, -5.59881292e-02f, -1.00978866e-01f, 9.50113311e-02f,
  2.89823394e-02f, -8.35282058e-02f, 1.67496338e-01f, 2.88085043e-01f, -2.77846288e-02f, 1.47670805e-01f, 1.48311406e-01f, 6.93194121e-02f, 6.27608895e-02f, 4.42309342e-02f,
  2.02368125e-01f, 9.12447646e-02f, 2.10659996e-01f, 5.51542006e-02f, 3.16044576e-02f, 1.29247710e-01f, 1.02340929e-01f, 8.99195373e-02f, 1.27198845e-01f, -1.11325070e-01f,
  -6.50985762e-02f, -1.22789675e-02f, 6.61927834e-02f, -6.52139187e-02f, 8.80326554e-02f, -8.26436952e-02f, 4.52626031e-03f, -1.07848018e-01f, -4.23001535e-02f, -2.78698951e-02f,
  -1.68283612e-01f, -2.52129603e-02f, 5.20835817e-03f, -7.65603408e-02f, -1.50706604e-01f, -3.09165078e-03f, -6.30956665e-02f, -8.92738998e-02f, -6.71176016e-02f, 2.25562621e-02f,
  3.01520918e-02f, 7.42207021e-02f, 3.60298646e-03f, 1.47740215e-01f, 3.05182114e-02f, -2.02669371e-02f, -6.49665808e-03f, 2.31106747e-02f, 5.36109358e-02f, -3.82926402e-04f,
  -1.03368521e-01f, 2.90275477e-02f, 3.45795155e-02f, 5.46993092e-02f, 2.08490808e-02f, 3.93650867e-02f, 7.65789896e-02f, -9.66240242e-02f, -1.09410947e-02f, 1.05852127e-01f,
  -4.77544032e-02f, 9.42056254e-03f, -1.23729765e-01f, 6.67936429e-02f, 2.08495441e-03f, 5.12735210e-02f, -5.21986000e-02f, -5.44661693e-02f, 6.01483621e-02f, -1.66357830e-02f,
  1.65057648e-02f, -5.80032542e-02f, -2.12169345e-02f, -2.52002887e-02f, -6.23077936e-02f, 6.42710701e-02f, 5.57323918e-02f, -1.98441613e-02f, -4.43718806e-02f, -2.54811812e-02f,
  1.01562990e-02f, 1.03296988e-01f, -2.62582637e-02f, -1.59004599e-01f, -3.77083234e-02f, -9.23584700e-02f, 2.43428070e-02f, -2.95348279e-02f, 7.66451564e-03f, 1.84300523e-02f,
  -8.01756456e-02f, -5.72746620e-02f, 2.50334702e-02f, -8.83525014e-02f, -1.86385177e-02f, 6.70790374e-02f, -6.01832531e-02f, -4.14815582e-02f, 8.80322978e-02f, 6.04750291e-02f,
  5.34602962e-02f, -3.27831842e-02f, 8.86539221e-02f, -8.60831365e-02f, -5.12420572e-02f, -2.53926311e-02f, 6.67744726e-02f, -7.00103864e-02f, 6.18349910e-02f, 8.05087611e-02f,
  1.47958443e-01f, -7.08907982e-03f, -2.13403478e-01f, -2.15793163e-01f, -2.12404504e-02f, -1.66141391e-01f, -2.35779196e-01f, -6.24789335e-02f, -4.15701568e-01f, -1.02755271e-01f,
  -4.88248691e-02f, -1.88118681e-01f, 1.17214166e-01f, 1.51242595e-02f, 7.12049305e-02f, 1.28725380e-01f, 3.11364383e-02f, -4.61978652e-02f, 1.45179629e-01f, 2.82616198e-01f,
  8.01730454e-02f, 1.92618310e-01f, 2.52360970e-01f, 2.74978369e-01f, 8.58560354e-02f, 1.77558586e-01f, 1.45116106e-01f, 8.56055245e-02f, -4.95369062e-02f, -6.49110973e-02f,
  7.56569058e-02f, 4.88012917e-02f, -4.31120321e-02f, -3.25504839e-02f, 1.16507612e-01f, 2.26208735e-02f, 6.74665123e-02f, -3.56289409e-02f, -1.30992219e-01f, 9.33938250e-02f,
  6.88960478e-02f, -5.65124117e-02f, -5.81196137e-02f, -7.18721747e-02f, -1.22764418e-02f, -1.98823124e-01f, 1.33282114e-02f, -5.51534109e-02f, -5.23897372e-02f, 2.27125898e-01f,
  -1.73898507e-02f, 3.94512573e-03f, -4.94460762e-02f, 2.02087853e-02f, 4.91561443e-02f, -8.65607113e-02f, -7.07494467e-02f, 7.45396912e-02f, -3.21698301e-02f, -2.06090864e-02f,
  1.46759346e-01f, 4.99088727e-02f, 6.39198199e-02f, -1.31558543e-02f, -1.05037568e-02f, 7.66346231e-02f, 4.52138372e-02f, 5.21639735e-02f, -9.89947021e-02f, 3.15196402e-02f,
  -1.44101664e-01f, 4.25516302e-03f, -2.19731256e-02f, 3.34027931e-02f, 1.63051262e-01f, 3.82913416e-03f, 4.43448462e-02f, 5.39439283e-02f, -9.85506773e-02f, -6.27773330e-02f,
  -2.84625217e-02f, 9.60726589e-02f, -5.51718809e-02f, -1.33272232e-02f, -8.60537775e-03f, -5.94579540e-02f, -7.06321513e-03f, 9.85906646e-02f, -6.45697191e-02f, 2.37268154e-02f,
  1.57584101e-02f, 2.78096646e-01f, -9.79804993e-02f, -1.64144859e-01f, 8.04411341e-03f, 9.15963128e-02f, -1.63499936e-02f, -3.63132767e-02f, 6.59243912e-02f, 7.81731531e-02f,
  3.67154367e-02f, 2.57428251e-02f, 9.42925811e-02f, -7.37753361e-02f, -3.62376422e-02f, -1.14654720e-01f, 1.40097022e-01f, -2.26499215e-01f, -9.55821797e-02f, 6.69799447e-02f,
  5.82760125e-02f, 8.06016773e-02f, -3.04083545e-02f, -2.44521592e-02f, -6.53536171e-02f, 2.48645041e-02f, 2.96515296e-03f, -7.88532197e-02f, 9.45206210e-02f, -1.10208929e-01f,
  3.93731475e-01f, -1.68251619e-01f, -3.80223729e-02f, 2.21061766e-01f, 3.01964998e-01f, 9.79759321e-02f, 1.42857686e-01f, 1.47910893e-01f, 4.26699609e-01f, -9.86320600e-02f,
  4.41789515e-02f, -2.59718508e-01f, -1.40127614e-01f, -1.28523350e-01f, 1.45696223e-01f, -1.51640609e-01f, 3.03990036e-01f, -6.62012622e-02f, 1.16450310e-01f, -2.81175263e-02f,
  4.06101681e-02f, -9.58643705e-02f, -2.33072385e-01f, -4.44594249e-02f, 6.17386810e-02f, -3.58855650e-02f, -1.50003925e-01f, 1.06818015e-02f, -1.51456684e-01f, -1.41986892e-01f,
  -7.05709383e-02f, 3.85122262e-02f, -1.40114889e-01f, -8.45542178e-02f, 4.19187993e-02f, 8.80611017e-02f, 1.56759620e-02f, -1.55128002e-01f, 8.23529884e-02f, -8.03490430e-02f,
  -6.87634498e-02f, -4.16248888e-02f, -3.73711027e-02f, 3.36713679e-02f, -7.38909061e-04f, 2.77841538e-02f, 4.22029644e-02f, 6.24232478e-02f, 4.26827595e-02f, -3.68665084e-02f,
  -3.93261053e-02f, 7.16416240e-02f, 7.48322392e-03f, -5.15562221e-02f, -8.21711868e-02f, 2.29713265e-02f, -9.90783200e-02f, 2.88286270e-03f, 1.56941973e-02f, 7.89098348e-03f,
  -1.10910416e-01f, -3.02897282e-02f, -5.95196225e-02f, -5.03424704e-02f, -8.09509307e-02f, 8.19590539e-02f, 4.25414890e-02f, -2.55260970e-02f, -1.66369900e-02f, 2.64354306e-03f,
  4.26304974e-02f, -7.80544728e-02f, 2.98897047e-02f, -7.32635781e-02f, -4.43731509e-02f, 9.88221094e-02f, 9.39127281e-02f, 4.81105484e-02f, -7.48133808e-02f, 3.21875140e-02f,
  9.20070708e-03f, -3.61464545e-03f, -6.76338822e-02f, 1.19434193e-01f, -8.25079530e-02f, -1.47578448e-01f, 8.12418610e-02f, -3.76935042e-02f, -3.74962464e-02f, 1.44201800e-01f,
  5.89086786e-02f, 5.94328679e-02f, -1.44830316e-01f, -1.13659017e-01f, -1.12651512e-02f, 1.23473018e-01f, 1.03410386e-01f, 5.15165515e-02f, 3.79015170e-02f, 1.00772223e-02f,
  -1.40080657e-02f, 2.11681426e-02f, 3.26504596e-02f, -3.59821394e-02f, -8.96691903e-02f, 9.67275947e-02f, -3.44573930e-02f, 2.26918329e-02f, 6.53854711e-03f, -5.37651144e-02f,
  -2.61258464e-02f, 6.91723600e-02f, -9.52490373e-04f, 1.04697384e-01f, -1.63638219e-02f, 6.29670098e-02f, 2.87607238e-02f, 7.34127453e-03f, 7.36861378e-02f, 8.07378292e-02f,
  1.86447874e-01f, -1.82769015e-01f, -2.69542128e-01f, -1.30391896e-01f, 3.37701142e-01f, 3.83560061e-01f, 7.28762150e-02f, 2.12633133e-01f, -2.61623979e-01f, -8.50056577e-03f,
  1.13301665e-01f, -3.46482962e-01f, -1.34147480e-01f, -2.27813013e-02f, 3.35069038e-02f, -2.71094978e-01f, 1.23796731e-01f, -1.71889458e-02f, -1.22188590e-01f, 1.45331338e-01f,
  1.05623379e-01f, 2.91418880e-01f, -1.15844093e-01f, 1.90546349e-01f, 2.78565258e-01f, -1.63554534e-01f, 1.39447004e-01f, 4.05188242e-04f, 1.39380693e-01f, 8.73201638e-02f,
  1.12595618e-01f, -4.09678742e-02f, -2.45089512e-02f, -7.79928407e-04f, 1.46686122e-01f, 1.80906132e-01f, 5.65939583e-02f, -1.36638820e-01f, -8.16246346e-02f, -2.70569008e-02f,
  -2.61302125e-02f, -2.06602030e-02f, -7.63011202e-02f, 3.41505222e-02f, 7.93793797e-02f, 1.24935389e-01f, -2.67940331e-02f, -8.65515172e-02f, -1.14765838e-01f, -2.30235960e-02f,
  3.24245580e-02f, -8.02292377e-02f, -5.22928983e-02f, -6.99859187e-02f, -4.88528833e-02f, -4.22526821e-02f, -8.14440846e-02f, 2.78102756e-02f, -6.44049793e-02f, -2.56764982e-02f,
  -3.41593698e-02f, -4.59092818e-02f, -2.85217352e-02f, -5.74334599e-02f, 2.82795867e-03f, -8.11477005e-02f, -3.93905304e-02f, -7.19709024e-02f, -3.86795364e-02f, 1.15824074e-01f,
  -7.81975836e-02f, 3.52636613e-02f, 8.98434501e-03f, -5.94254397e-03f, 6.01196326e-02f, -1.15401022e-01f, -2.94343219e-03f, -2.31601074e-02f, 6.00606855e-03f, -1.67132560e-02f,
  -1.64603025e-01f, 2.21433342e-02f, 4.60199304e-02f, -1.41300604e-01f, -1.25347212e-01f, 2.04971824e-02f, 4.59257849e-02f, 5.78268878e-02f, -9.49545801e-02f, 5.22031337e-02f,
  2.70072427e-02f, -1.22227378e-01f, -1.09370053e-01f, 3.24364938e-02f, -8.00909400e-02f, 6.42519593e-02f, -1.23209469e-01f, -1.07864320e-01f, -3.68547551e-02f, 9.52394903e-02f,
  -7.92670902e-03f, -4.06406038e-02f, -7.36217946e-02f, 5.12701944e-02f, -1.83989201e-02f, 1.51986137e-01f, -7.31831640e-02f, -7.58426934e-02f, 3.47963683e-02f, -7.64512923e-03f,
  -2.10579932e-02f, 1.41296471e-02f, -4.01064940e-02f, 8.30953419e-02f, 9.58610419e-03f, 9.42057893e-02f, 2.09482741e-02f, 3.16387787e-02f, 9.52205434e-02f, -7.47029856e-02f,
  2.16427445e-01f, -1.73840210e-01f, 2.00390369e-01f, 8.52415562e-02f, 2.82028913e-01f, 3.83066386e-01f, 2.98854113e-01f, 2.61827320e-01f, 2.97443837e-01f, -2.60154665e-01f,
  -6.98916242e-02f, -2.76038647e-01f, 4.92415205e-02f, -1.68381572e-01f, 1.80409655e-01f, 1.31224215e-01f, 7.95334056e-02f, -1.88914657e-01f, 5.12612425e-02f, -9.73107964e-02f,
  1.03663519e-01f, -2.00847849e-01f, -1.89074073e-02f, -7.61642382e-02f, -1.54311299e-01f, -1.99307546e-01f, -1.20818511e-01f, 1.20313697e-01f, -3.10070932e-01f, -3.71415429e-02f,
  2.99782846e-02f, -2.54451539e-02f, 7.03545213e-02f, -3.69460993e-02f, 6.06786236e-02f, -1.62099227e-02f, -6.67728903e-03f, -3.55345756e-02f, 8.47147629e-02f, -4.71685454e-02f,
  -7.97385946e-02f, 4.65051793e-02f, -3.49410921e-02f, -7.60231465e-02f, 7.94293284e-02f, -4.10838537e-02f, 9.21091586e-02f, 7.50345439e-02f, 1.27267882e-01f, 4.27151620e-02f,
  1.68409925e-02f, 3.49513479e-02f, -4.94526885e-02f, -1.17150858e-01f, 4.05638590e-02f, 5.68161085e-02f, 1.42756347e-02f, -1.05335839e-01f, -4.34742309e-02f, -1.90824792e-02f,
  3.77411209e-02f, 1.60047069e-01f, -5.13097830e-02f, -1.16966225e-01f, -1.04331776e-01f, -7.46405721e-02f, -1.23196118e-01f, -1.54308394e-01f, -3.78543921e-02f, 1.01246573e-01f,
  -2.26818137e-02f, -1.89106558e-02f, 2.20963825e-02f, 9.92470980e-02f, -3.76355718e-03f, -6.68236869e-04f, -1.88442335e-01f, -6.16047680e-02f, 1.44404337e-01f, 1.82300419e-01f,
  6.55558854e-02f, -2.07053847e-03f, 1.49269181e-04f, 2.33536158e-02f, 6.53543770e-02f, -6.93820277e-03f, -1.03798307e-01f, 2.88124699e-02f, 4.12525497e-02f, -2.89486144e-02f,
  -1.50797352e-01f, -1.13419302e-01f, 9.06682685e-02f, -1.08387157e-01f, -1.20046444e-01f, -6.74337940e-03f, -8.42512026e-03f, -4.45666499e-02f, 9.58622769e-02f, -5.29918745e-02f,
  3.44965458e-02f, -1.20757371e-01f, -9.38303024e-02f, -8.41929242e-02f, 3.89600848e-03f, 6.36000112e-02f, -4.80969884e-02f, 4.82405089e-02f, 1.38428286e-02f, -1.47802401e-02f,
  -7.68061578e-02f, -4.77870479e-02f, 1.15155624e-02f, 4.50858846e-03f, -1.01795934e-01f, -2.44751461e-02f, -9.48439240e-02f, -5.70911616e-02f, 5.06667905e-02f, 5.40349521e-02f,
  -3.31489205e-01f, 1.90657303e-01f, 6.14735633e-02f, -9.81592610e-02f, 1.74230635e-01f, -3.30172330e-01f, -1.21572629e-01f, 1.58382997e-01f, 2.22520217e-01f, 2.31516600e-01f,
  1.30148217e-01f, 1.16294272e-01f, 2.11638525e-01f, -1.16970157e-02f, -3.48052114e-01f, -1.22401305e-01f, -3.19962680e-01f, -2.23662242e-01f, 6.62162900e-02f, 2.66488213e-02f,
  -1.79715142e-01f, 4.36192229e-02f, -2.59198934e-01f, 1.87495366e-01f, 9.49212611e-02f, 7.51362443e-02f, -1.77472815e-01f, 1.00009508e-01f, -2.74201661e-01f, 3.81941572e-02f,
  -1.94697037e-01f, 1.17923029e-01f, -3.64950560e-02f, -7.87677169e-02f, -1.62891194e-01f, -6.10989295e-02f, -7.03244284e-02f, 6.64202683e-03f, -2.42650211e-02f, -4.42833304e-02f,
  2.88034473e-02f, 8.32463242e-03f, -7.71555528e-02f, 1.16093839e-02f, 1.09709036e-02f, 6.60065711e-02f, 2.22597755e-02f, -3.19396295e-02f, 2.79094446e-02f, 1.68644506e-02f,
  -1.20257162e-01f, 8.68206844e-02f, -1.16331287e-01f, -8.99358094e-02f, -1.54468706e-02f, 1.20689571e-01f, -9.85061228e-02f, -1.12143472e-01f, -2.13366281e-02f, -6.40026629e-02f,
  1.30494991e-02f, -6.27178922e-02f, -2.91772746e-02f, -6.67592660e-02f, -2.36436464e-02f, -1.26483431e-02f, 3.03954668e-02f, -4.71525677e-02f, 3.78703326e-03f, 5.57199456e-02f,
  1.19547648e-02f, 2.14338023e-02f, 7.23217949e-02f, -1.32357210e-01f, 6.85071647e-02f, -5.57123721e-02f, -5.77617474e-02f, 5.88550083e-02f, 1.16477543e-02f, 2.43474524e-02f,
  5.29836416e-02f, -1.10928886e-01f, 6.52472004e-02f, -5.98663092e-02f, -1.85019039e-02f, -5.90556078e-02f, 4.01118174e-02f, -9.98181850e-02f, -7.78870806e-02f, -5.33210821e-02f,
  -1.09871268e-01f, 1.50652379e-01f, 2.84465365e-02f, 8.25412422e-02f, -4.99165095e-02f, 2.53511257e-02f, 2.96627264e-02f, -1.02226228e-01f, 3.73791531e-02f, 7.30255544e-02f,
  -3.20052244e-02f, 1.03767045e-01f, -1.29744053e-01f, -1.43017005e-02f, -4.96633165e-02f, -2.26861481e-02f, -5.26224561e-02f, 3.33745964e-02f, -1.12051971e-01f, -5.57994246e-02f,
  4.45605963e-02f, 7.81299397e-02f, 2.91960165e-02f, 8.27071220e-02f, 4.36164849e-02f, 5.42860338e-03f, -1.48277534e-02f, 6.21838868e-02f, -6.75113723e-02f, -7.50015676e-02f,
  1.99340925e-01f, 2.62449324e-01f, 1.53127700e-01f, 1.77115560e-01f, -1.19285509e-01f, -7.20143914e-02f, -2.91714221e-02f, -1.21003017e-01f, -1.27080396e-01f, 1.84080616e-01f,
  -6.50948510e-02f, 2.24413097e-01f, -2.18906641e-01f, -1.48335218e-01f, -2.95887470e-01f, -2.19375134e-01f, -1.16725169e-01f, 3.62527333e-02f, -1.32912412e-01f, 2.51802295e-01f,
  -8.06453377e-02f, -2.74123698e-01f, 1.09740533e-02f, -4.19462360e-02f, 1.19716346e-01f, 3.09003860e-01f, 1.33201286e-01f, -4.65447530e-02f, 2.77526349e-01f, -1.72623292e-01f,
  -1.39406726e-01f, 3.51948738e-02f, 1.09018981e-01f, 3.47845890e-02f, -1.70062575e-02f, 5.91437034e-02f, 7.35988989e-02f, -7.49429315e-02f, -8.59975070e-02f, 2.28540786e-02f,
  1.69638231e-01f, -2.59340811e-03f, -6.85610175e-02f, 1.75623130e-02f, 8.35041925e-02f, 6.64362758e-02f, 9.37468410e-02f, 1.18638694e-01f, -1.57431711e-03f, 3.97667587e-02f,
  1.65718928e-01f, 5.10310382e-02f, -3.27824652e-02f, 6.20172843e-02f, 5.69414487e-03f, -2.28830241e-02f, 1.72608886e-02f, 1.87986597e-01f, 1.05227515e-01f, 7.07272813e-02f,
  1.21342756e-01f, -6.48068041e-02f, -8.26481506e-02f, -9.79644582e-02f, -4.49800789e-02f, 2.12612469e-02f, -2.53020525e-02f, -2.39913631e-02f, 3.34853828e-02f, 3.15398090e-02f,
  -4.81975591e-03f, 6.64459541e-02f, -8.06050152e-02f, 1.30093545e-01f, 1.62364468e-01f, 4.35748510e-02f, -4.80490066e-02f, -5.00315391e-02f, 4.09778841e-02f, 1.11650839e-01f,
  -9.46201161e-02f, -8.09986219e-02f, 9.03505534e-02f, -8.34635720e-02f, -2.19708905e-01f, -1.31879188e-02f, -5.99345863e-02f, 3.30112986e-02f, -3.42599675e-02f, 2.92827506e-02f,
  8.36164206e-02f, 4.98462766e-02f, 1.06507935e-01f, -8.21333975e-02f, 2.77592633e-02f, 7.91197177e-03f, -2.87173921e-03f, -1.27218468e-02f, -6.25891164e-02f, -6.38696030e-02f,
  1.27327517e-01f, 4.76530492e-02f, -1.16873737e-02f, -9.34861600e-02f, -1.37174632e-02f, -5.72388014e-03f, -7.74821192e-02f, 9.33739692e-02f, 4.17159162e-02f, 2.46325266e-02f,
  1.51660010e-01f, 8.09270889e-02f, 4.70228717e-02f, 9.72033963e-02f, 2.71917060e-02f, 1.17070720e-01f, 2.11010949e-04f, 4.59746160e-02f, 4.71959896e-02f, -1.75088998e-02f,
  -6.19953156e-01f, 2.21143171e-01f, 1.13190107e-01f, -1.40801713e-01f, -1.71991616e-01f, 2.56742477e-01f, 2.28090465e-01f, -6.17662296e-02f, -1.82923943e-01f, 1.81547552e-01f,
  2.84463726e-02f, -2.95427591e-01f, 9.96530056e-02f, 2.06037074e-01f, -5.07708602e-02f, 2.56641626e-01f, 2.47303620e-01f, 4.41432074e-02f, 7.75562599e-02f, -1.05553776e-01f,
  -1.56970334e-03f, 6.41623139e-02f, 1.76998943e-01f, 4.34006788e-02f, -8.76545683e-02f, -1.04199082e-01f, -1.18352503e-01f, -7.11775199e-02f, 5.50615676e-02f, -7.74219707e-02f,
  -3.26169848e-01f, -2.58039922e-01f, -1.85989037e-01f, -1.69166297e-01f, -1.57172933e-01f, 1.71890073e-02f, -3.74870673e-02f, 1.57714039e-02f, -1.15073219e-01f, -4.17464636e-02f,
  -1.74102783e-01f, 1.50965352e-03f, -7.60108829e-02f, -1.35171339e-02f, -1.06911272e-01f, -2.34762602e-03f, 4.61563766e-02f, 8.53450671e-02f, 8.61934945e-02f, 5.03645726e-02f,
  3.55661586e-02f, 6.42741919e-02f, 1.20531060e-01f, 1.37884483e-01f, -2.21133512e-02f, -2.99431216e-02f, 1.43319055e-01f, -3.06024067e-02f, -5.36017194e-02f, -4.81542125e-02f,
  -3.85561287e-02f, -1.69235654e-02f, 2.83151157e-02f, -3.18884067e-02f, -9.90550150e-04f, 3.75207444e-03f, -3.64671759e-02f, 1.73333939e-03f, 5.05887605e-02f, 8.48417878e-02f,
  -6.86460212e-02f, -5.19133732e-02f, -2.04760265e-02f, 5.56806773e-02f, 4.96645831e-02f, -4.44723219e-02f, -1.86481662e-02f, -9.64595750e-02f, 6.77159727e-02f, 7.73862079e-02f,
  -8.30748826e-02f, -5.85002899e-02f, -8.94184690e-03f, 6.48147613e-02f, -4.02998365e-03f, -3.15973125e-02f, -2.33889986e-02f, 6.88717291e-02f, 2.94279531e-02f, -5.51513694e-02f,
  -3.83003592e-01f, -3.38848889e-01f, -3.56998891e-02f, -6.39902204e-02f, 2.50980500e-02f, -9.88300145e-02f, 1.45524954e-02f, 2.63258759e-02f, -3.63980569e-02f, -1.21211626e-01f,
  -6.04792945e-02f, -1.38878273e-02f, -3.63341458e-02f, 4.26369533e-02f, 1.70314834e-02f, -1.48810623e-02f, -3.11141703e-02f, -7.05837682e-02f, -1.11379303e-01f, -2.97533162e-02f,
  -7.36507624e-02f, -8.55786074e-03f, 9.29540917e-02f, -2.42316164e-02f, 3.39842364e-02f, 5.12579791e-02f, -1.66576728e-01f, 8.22682828e-02f, -3.57807018e-02f, 1.12368070e-01f,
  -1.10000275e-01f, 2.88208276e-02f, -1.39953181e-01f, -2.50897855e-01f, -1.77350461e-01f, -1.91887200e-01f, -1.43335730e-01f, -1.38510481e-01f, 1.15195245e-01f, -8.55212063e-02f,
  -1.09582745e-01f, 6.34682551e-02f, 2.71291018e-01f, -2.14600980e-01f, 6.21667802e-02f, 3.06757867e-01f, -3.10448766e-01f, -1.55988991e-01f, 7.13285953e-02f, -8.47947598e-02f,
  -1.06961794e-01f, -7.67241195e-02f, -1.26117364e-01f, 1.55190034e-02f, -2.62038767e-01f, -2.03833923e-01f, -6.54717628e-03f, -9.37739015e-02f, -2.72373915e-01f, -1.48741499e-01f,
  -3.25493127e-01f, -2.12924078e-01f, -5.49035072e-02f, -1.40691191e-01f, -2.12276354e-01f, -2.58616116e-02f, -1.01710647e-01f, -1.29260020e-02f, -4.23909947e-02f, -6.81440905e-02f,
  4.38766032e-02f, 1.10672578e-01f, -4.40458618e-02f, 7.47893006e-02f, -1.92488506e-02f, -4.19436917e-02f, 2.50367671e-02f, -8.68476182e-02f, -9.43922028e-02f, 4.08581458e-02f,
  -4.71976474e-02f, -1.00676090e-01f, -2.04822198e-01f, -1.14290945e-01f, -6.24707714e-02f, -7.27623999e-02f, -1.82119906e-02f, 6.06379993e-02f, -1.07853875e-01f, -1.12122983e-01f,
  6.74919039e-02f, 3.02484799e-02f, 4.53893188e-03f, -9.62878764e-02f, -2.70316470e-03f, -2.40823608e-02f, 9.31511074e-03f, -9.27154794e-02f, 1.81720704e-02f, 2.12163925e-02f,
  -1.05821162e-01f, -1.83291007e-02f, -7.80424243e-03f, 1.19483258e-04f, -2.27154437e-02f, 8.40085074e-02f, -9.75099206e-02f, -1.37302190e-01f, 4.09239484e-03f, -3.60757753e-04f,
  -2.24465001e-02f, -1.66242607e-02f, 1.70559417e-02f, 3.46443355e-02f, -8.19224939e-02f, 1.15984127e-01f, -1.29985929e-01f, -2.44064592e-02f, 7.30787218e-02f, 4.16196464e-03f,
  -2.67901808e-01f, -1.26049295e-01f, -8.47254544e-02f, -7.46241137e-02f, 1.83982085e-02f, 4.12549563e-02f, -4.30224016e-02f, 6.04502037e-02f, -6.35599941e-02f, 1.31648824e-01f,
  3.79557163e-02f, 1.77912321e-02f, -5.57045154e-02f, 5.72298653e-02f, 4.42509241e-02f, -5.11843227e-02f, -1.13969091e-02f, -3.75373336e-03f, -6.63805678e-02f, -8.37814286e-02f,
  -1.12530477e-01f, 3.52310576e-02f, 1.11975253e-01f, 2.66672950e-02f, -5.12848757e-02f, -7.19134733e-02f, 1.19133573e-02f, -2.57606581e-02f, 7.20985904e-02f, 7.14520514e-02f,
  -4.74595040e-01f, 3.53239685e-01f, 3.10911804e-01f, -1.09939650e-01f, -5.32097742e-02f, 3.62237453e-01f, 1.09320752e-01f, 2.07567573e-01f, 1.23783179e-01f, 1.68512344e-01f,
  -2.26894066e-01f, 1.07230231e-01f, 7.17451423e-02f, 1.77605048e-01f, -2.42902115e-01f, 9.24408585e-02f, 8.51223320e-02f, 1.22627886e-02f, 1.72814623e-01f, 4.83085252e-02f,
  -1.61742166e-01f, -1.34153709e-01f, -3.14416140e-02f, 1.80862173e-01f, -1.41056672e-01f, 1.57680847e-02f, -2.99294561e-01f, -2.38541625e-02f, 1.02541171e-01f, -2.16443352e-02f,
  -3.62610072e-01f, -5.51901311e-02f, -2.43967354e-01f, -1.01801582e-01f, -1.35638684e-01f, 1.04600519e-01f, -4.01415676e-02f, -9.58908349e-02f, -2.41352729e-02f, 7.14059621e-02f,
  1.88116264e-02f, -3.88488248e-02f, -5.12957526e-03f, -4.55986485e-02f, 5.35512976e-02f, 8.52925051e-03f, 9.72216725e-02f, 7.86938518e-02f, -1.17276609e-02f, 7.36394674e-02f,
  9.24370363e-02f, 6.85570529e-03f, -3.65268737e-02f, 3.69328223e-02f, -5.06534949e-02f, -4.62953374e-03f, 1.03616454e-01f, 1.32997474e-02f, -2.90196035e-02f, 1.56869162e-02f,
  1.18589569e-02f, 1.44557399e-03f, -4.53474857e-02f, 4.59230877e-02f, -6.46310253e-03f, -7.45159015e-02f, -5.19920811e-02f, -1.02956347e-01f, 1.17335208e-01f, 9.18907821e-02f,
  1.56010734e-02f, 7.51746371e-02f, -5.28498143e-02f, 9.61687788e-03f, -5.44124059e-02f, -5.85915744e-02f, -4.43511643e-02f, 4.25098985e-02f, -5.48171327e-02f, -5.16397431e-02f,
  -8.24122597e-03f, -1.43079041e-02f, 1.55587611e-03f, -2.57798545e-02f, 4.46603075e-02f, 6.18771203e-02f, 1.18865065e-01f, 3.33624110e-02f, -7.28366971e-02f, -4.11519259e-02f,
  -1.57472476e-01f, -1.21203527e-01f, -1.60546809e-01f, -1.40093222e-01f, -6.85534328e-02f, -7.33581930e-02f, -7.76384119e-03f, -3.74550782e-02f, -1.03410035e-02f, -5.28420284e-02f,
  -4.62159626e-02f, 4.49535623e-02f, -7.40492484e-03f, -2.52898037e-02f, 1.74169472e-04f, 2.63299849e-02f, 1.40396347e-02f, -4.57997248e-02f, -7.52847344e-02f, -3.56996655e-02f,
  2.74994387e-03f, -1.21158566e-02f, 5.01870289e-02f, -5.13898693e-02f, -1.14387274e-01f, -7.78097212e-02f, 4.44181915e-03f, 1.77609324e-02f, -5.69319585e-03f, -3.48436087e-02f,
  2.22197890e-01f, -3.21770996e-01f, -3.61373991e-01f, -6.14716113e-02f, 3.12746733e-01f, 3.22481006e-01f, -1.05209406e-02f, 2.18372233e-03f, -2.41655484e-01f, -6.72094449e-02f,
  2.68444657e-01f, -1.15905076e-01f, -1.43465608e-01f, 2.14255467e-01f, 2.33332515e-01f, -3.08222502e-01f, 2.05580398e-01f, 1.37644127e-01f, -1.64343223e-01f, -1.75050925e-02f,
  1.20616041e-01f, 1.84617653e-01f, -1.28173217e-01f, 2.54556000e-01f, 1.96881533e-01f, 9.77499876e-03f, 1.74873173e-01f, -8.59697610e-02f, 2.24057958e-01f, 1.08114980e-01f,
  1.24777019e-01f, -3.03458516e-02f, -2.11917479e-02f, -6.48467466e-02f, 4.04257700e-02f, 6.65585101e-02f, 6.30065054e-02f, 1.46569327e-01f, 3.47195491e-02f, -1.08596841e-02f,
  3.33590545e-02f, 2.94259060e-02f, 2.46257875e-02f, -5.59318364e-02f, 1.07227057e-01f, 4.82496433e-02f, 3.25320326e-02f, -1.66602153e-02f, -8.61067399e-02f, 3.14116515e-02f,
  -7.79011846e-02f, 3.39191258e-02f, 6.40238076e-02f, -2.54417472e-02f, -1.58288628e-01f, -2.41361670e-02f, 1.43394778e-02f, -4.15503532e-02f, 4.42984141e-02f, -1.21035082e-02f,
  1.12318881e-01f, -5.01359962e-02f, 3.82190347e-02f, -2.34838519e-02f, -3.03823296e-02f, -6.37265518e-02f, 6.25806749e-02f, -9.00994707e-03f, -9.17092338e-02f, -1.05736749e-02f,
  3.69033813e-02f, 2.25019753e-02f, -2.11376939e-02f, 3.50843486e-03f, -2.60156728e-02f, 3.35428142e-03f, 6.57821598e-04f, -3.88610712e-03f, -4.11319882e-02f, -7.73913264e-02f,
  9.56210215e-03f, -3.60599495e-02f, -3.26595828e-02f, 6.40319735e-02f, 3.46312113e-02f, -3.78666334e-02f, 5.90106770e-02f, -1.24987826e-01f, -1.67739429e-02f, 1.17644016e-02f,
  -4.12857048e-02f, -1.57269731e-01f, -6.65512905e-02f, -2.85724457e-02f, -1.46991476e-01f, 1.20142788e-01f, -7.08120968e-03f, 4.09565195e-02f, 3.01531497e-02f, -4.64224964e-02f,
  1.61696419e-01f, 1.07356429e-01f, -3.61437127e-02f, -3.09177339e-02f, 6.11060001e-02f, -9.29780975e-02f, 4.52746563e-02f, 4.29123119e-02f, -5.73668955e-03f, 2.46987562e-03f,
  1.11647148e-03f, 3.68643813e-02f, -6.36494681e-02f, 3.95296287e-04f, -1.29880114e-02f, -4.42028120e-02f, 7.08143273e-03f, 8.29906028e-04f, 8.81540775e-02f, 2.19130535e-02f,
  -2.15045512e-01f, -3.02349124e-02f, 5.60865402e-02f, -2.10645478e-02f, 6.24937043e-02f, 2.48673558e-02f, 1.37393981e-01f, -4.75901961e-02f, -2.66389877e-01f, 1.76771432e-01f,
  1.81473643e-01f, -5.60900755e-02f, 1.86657652e-01f, -1.65010139e-01f, -3.95875156e-01f, -1.72775403e-01f, -1.22063629e-01f, 1.34002432e-01f, -9.87568125e-02f, 1.04825258e-01f,
  -2.29547068e-01f, -9.18812156e-02f, -2.19537895e-02f, -6.75346702e-02f, 4.53009829e-02f, 1.03681266e-01f, 1.43599361e-01f, 1.25420079e-01f, 1.33653626e-01f, -1.12289153e-01f,
  6.62801191e-02f, -3.39818224e-02f, 3.50793917e-03f, 5.97368367e-02f, 1.08540617e-01f, 8.22746828e-02f, 7.16820508e-02f, 3.79325561e-02f, 4.83608320e-02f, 3.24750468e-02f,
  9.44276676e-02f, 3.97377014e-02f, -1.48328736e-01f, -1.32883728e-01f, -1.79448854e-02f, -9.54655465e-03f, -1.26945481e-01f, 7.46338302e-03f, 8.06931406e-02f, -2.51546055e-02f,
  1.47078009e-02f, 7.85921440e-02f, 7.75628770e-03f, -5.86063648e-03f, -1.66742399e-01f, 7.40134567e-02f, -3.91660212e-03f, 1.94570780e-01f, -1.54916614e-01f, -3.90004963e-02f,
  -1.29871011e-01f, 7.24186525e-02f, -4.94709313e-02f, -3.18212546e-02f, -7.70195946e-02f, 6.35700375e-02f, -8.57738033e-03f, 6.93595558e-02f, 6.22237660e-02f, -2.50618197e-02f,
  5.93609139e-02f, -6.81860298e-02f, -3.72305885e-02f, 7.76794041e-03f, -1.13171592e-01f, -7.03896508e-02f, 8.81050974e-02f, -4.19562794e-02f, 1.62379146e-01f, 1.30355945e-02f,
  4.45331633e-02f, 4.41482440e-02f, 7.09903389e-02f, 8.02234709e-02f, -6.74575195e-02f, 5.11141643e-02f, -2.21278844e-03f, 3.08125410e-02f, 1.13461189e-01f, 6.96594641e-02f,
  3.19327898e-02f, -1.29902482e-01f, 4.10032552e-03f, 6.32657558e-02f, -9.05668736e-03f, -2.59449426e-02f, -5.52819856e-02f, -3.33618186e-02f, 2.39800066e-02f, -1.30948648e-01f,
  7.14681596e-02f, 9.64941829e-02f, 4.53091972e-02f, 9.76403505e-02f, 9.61370915e-02f, 7.44676962e-02f, 9.49376300e-02f, 1.42224744e-01f, -5.45547307e-02f, 9.14421231e-02f,
  6.09702505e-02f, 8.35924149e-02f, -1.92636728e-01f, -5.27966842e-02f, 1.29811512e-02f, 9.87610221e-02f, 3.70431580e-02f, -1.07381465e-02f, -3.08663938e-02f, -1.74316186e-02f,
  2.00011194e-01f, -4.53529656e-02f, -2.18209684e-01f, -1.71613991e-01f, 1.10244118e-02f, -5.01364842e-03f, -1.05287194e-01f, -5.86499386e-02f, -2.39271984e-01f, 1.54357493e-01f,
  -1.85266044e-02f, -2.57211067e-02f, -9.06562358e-02f, -2.06507817e-01f, -3.20423663e-01f, -2.73794711e-01f, -7.13869110e-02f, -3.35441716e-02f, -1.22475125e-01f, 1.31487280e-01f,
  -1.37432724e-01f, -9.21315625e-02f, -2.65750557e-01f, 6.96533397e-02f, 1.38326079e-01f, 1.62863910e-01f, 1.01448305e-01f, 2.80585289e-02f, 4.55865785e-02f, 2.40975786e-02f,
  -5.22807464e-02f, -1.27358824e-01f, -7.23950863e-02f, 3.23685445e-02f, 1.54920310e-01f, 1.26124710e-01f, 4.94115315e-02f, -1.80815570e-02f, -1.09396696e-01f, 3.29945274e-02f,
  5.85889444e-02f, -1.16387241e-01f, 4.88698557e-02f, -1.18318582e-02f, 3.29154991e-02f, 6.42597005e-02f, -7.96863064e-02f, 7.07066432e-02f, -2.86778416e-02f, 3.50955613e-02f,
  -1.16389751e-01f, 7.36101493e-02f, 4.57084924e-02f, -1.01077594e-01f, -7.06386054e-03f, 2.15198696e-02f, 4.40212674e-02f, -1.26117552e-02f, 8.23330879e-02f, -6.42324463e-02f,
  8.63429159e-02f, 1.93651021e-01f, -1.75383780e-02f, 1.85138453e-02f, -4.49106358e-02f, -6.75236732e-02f, -2.10628677e-02f, -1.07963212e-01f, 1.80167016e-02f, -5.89401871e-02f,
  9.76099670e-02f, -7.74325877e-02f, -4.97254319e-02f, -6.82562450e-03f, 6.76445290e-02f, -1.22135449e-02f, 1.77903593e-01f, 5.98123260e-02f, 7.15606287e-02f, -1.67460069e-01f,
  -2.82758940e-02f, -7.22861513e-02f, -1.17266886e-01f, 7.07717612e-02f, -3.01166456e-02f, 6.18160628e-02f, 1.51455849e-01f, -6.09855074e-03f, -1.02580693e-02f, -1.52780013e-02f,
  -9.41222236e-02f, 4.84948829e-02f, -9.14405957e-02f, 6.55506551e-02f, 9.71204694e-03f, 1.30967766e-01f, 1.87727332e-03f, -1.15656899e-02f, -1.75389554e-02f, 6.08890057e-02f,
  1.70082167e-01f, 5.97020090e-02f, 1.94845691e-01f, -8.65787491e-02f, -4.54561934e-02f, 1.13817811e-01f, -1.07306186e-02f, 2.91899443e-02f, 1.03964778e-02f, 3.31511572e-02f,
  8.32791254e-02f, 1.49707958e-01f, 7.31980056e-02f, 7.81600475e-02f, 4.02700081e-02f, 2.93148961e-02f, -2.73739658e-02f, -9.94600635e-03f, 1.15599111e-01f, -3.92864309e-02f,
  -2.00956792e-01f, 1.14161283e-01f, -4.31847498e-02f, -3.44942421e-01f, 8.32651034e-02f, -1.52103454e-01f, -2.93619335e-01f, 1.84170734e-02f, -4.51854169e-02f, 4.41649221e-02f,
  -1.25872597e-01f, -1.06947772e-01f, 1.82424396e-01f, -2.73509175e-01f, -1.68424472e-01f, 1.37351766e-01f, -2.19799131e-01f, -2.00679138e-01f, 1.49471939e-01f, -2.09535718e-01f,
  2.89134844e-03f, -1.48299217e-01f, -3.23829092e-02f, 2.53657788e-01f, -8.68400410e-02f, 4.54825684e-02f, 1.52122090e-02f, 1.73283905e-01f, -1.56196877e-01f, 1.19550042e-01f,
  -3.05933625e-01f, -2.52832919e-01f, -9.34711993e-02f, 2.59772316e-02f, -1.31707773e-01f, -1.32269710e-01f, -7.04483017e-02f, 1.76770650e-02f, -7.47741461e-02f, -1.65200897e-03f,
  -3.45862806e-02f, 2.11152062e-02f, -1.70434602e-02f, 7.65577704e-02f, 3.13374139e-02f, 3.97122838e-02f, -2.12023668e-02f, -8.88346061e-02f, -5.07149659e-02f, 9.26916003e-02f,
  -2.54792981e-02f, 1.87198296e-02f, -8.31007287e-02f, 4.61583845e-02f, 4.23034988e-02f, 3.31226438e-02f, -3.54196914e-02f, 7.21673220e-02f, -3.60867307e-02f, 1.73121169e-02f,
  4.49780636e-02f, 1.01978689e-01f, -4.48300503e-02f, 3.32381763e-02f, -4.12687585e-02f, 6.90153837e-02f, -8.42733774e-03f, 4.49250359e-03f, 7.06124753e-02f, -8.47363174e-02f,
  -1.83676500e-02f, -4.08057459e-02f, -2.98536904e-02f, -5.78353852e-02f, -5.51608354e-02f, -5.07910475e-02f, 3.40516195e-02f, 1.94376968e-02f, 1.09466352e-01f, -7.68215880e-02f,
  4.61889580e-02f, 8.51557404e-03f, 8.16107392e-02f, -6.98095933e-03f, -2.02644058e-02f, 1.77025795e-02f, 3.86142470e-02f, 1.86780300e-02f, 2.55898777e-02f, -1.21990517e-02f,
  -2.74640173e-01f, -3.22723567e-01f, -3.00729356e-04f, -9.47558731e-02f, -1.47102594e-01f, -4.21965756e-02f, 4.87868525e-02f, 6.23588227e-02f, -6.89470842e-02f, 1.02014644e-02f,
  -5.60786985e-02f, 3.77860316e-03f, -4.20599096e-02f, -2.15075314e-02f, 2.36967765e-02f, -1.24909272e-02f, -1.36745319e-01f, -2.41830815e-02f, -6.54617921e-02f, 5.39112389e-02f,
  -6.58784732e-02f, 3.56777711e-03f, 1.13188745e-02f, 2.61221752e-02f, -5.11650182e-02f, -8.63748938e-02f, -4.89402227e-02f, 2.30078120e-02f, -3.27834189e-02f, -1.16840973e-02f,
  -3.59010667e-01f, -5.87776341e-02f, 2.01300487e-01f, -4.00832325e-01f, -7.04615563e-02f, 2.16805309e-01f, 1.51186794e-01f, -1.54118553e-01f, -1.27329588e-01f, -7.43081048e-02f,
  -2.22147778e-01f, -4.82935421e-02f, 2.26460665e-01f, -1.52772695e-01f, 3.40714484e-01f, 3.21649879e-01f, -1.59528136e-01f, -1.15378812e-01f, 9.37484503e-02f, -2.54205614e-01f,
  -4.96911518e-02f, -1.37683749e-01f, 2.27515563e-01f, -2.23067179e-01f, -2.20297933e-01f, -2.22914517e-01f, -9.24401507e-02f, 1.95079502e-02f, -2.06472740e-01f, 5.71523830e-02f,
  4.55991253e-02f, -2.93030262e-01f, 1.67684313e-02f, 2.25435290e-02f, 3.89592089e-02f, -4.52923663e-02f, 7.97023922e-02f, 5.92176095e-02f, -2.66252793e-02f, -2.81838663e-02f,
  2.39258800e-02f, 6.32475168e-02f, -9.11807083e-03f, 5.00251912e-02f, -1.49919897e-01f, 2.57583633e-02f, -3.20793316e-02f, -6.99632838e-02f, 3.14042270e-02f, 1.05455190e-01f,
  1.21746056e-01f, 4.93863598e-02f, 3.14164273e-02f, -5.64299244e-03f, 1.20192856e-01f, -6.73384890e-02f, 5.35585545e-02f, -3.91422585e-02f, 2.64406856e-02f, -1.20583802e-01f,
  -8.16011801e-02f, 1.25204411e-03f, -3.93447019e-02f, -6.94662929e-02f, -5.32785207e-02f, -1.51632443e-01f, 4.41068485e-02f, 3.53533365e-02f, -1.04444079e-01f, 3.95526253e-02f,
  -3.84257524e-03f, -1.34432286e-01f, -6.49366006e-02f, 1.26761720e-02f, -1.29400104e-01f, -9.80848894e-02f, 7.75164589e-02f, 7.16440827e-02f, -5.71225537e-03f, 3.48986173e-03f,
  -6.99205399e-02f, -1.89642422e-02f, -4.30668518e-03f, 1.10447714e-02f, 1.05504997e-01f, 8.66866484e-02f, 3.65727544e-02f, -2.82480884e-02f, -5.38741872e-02f, 8.93389806e-02f,
  5.55133671e-02f, -2.38558471e-01f, -1.93677489e-02f, 2.22579092e-02f, 8.72714445e-02f, -2.84150504e-02f, 7.26902336e-02f, -8.63422230e-02f, -6.58921227e-02f, -3.03543974e-02f,
  -1.05717570e-01f, 8.13028291e-02f, 3.95331420e-02f, -4.38197292e-02f, -2.87126321e-02f, 4.15393412e-02f, 8.79887957e-03f, -1.25247940e-01f, -7.63449669e-02f, -9.86763388e-02f,
  -5.96425608e-02f, 1.25733195e-02f, 3.38393659e-03f, -4.95790737e-03f, -6.78963959e-03f, -1.16172731e-01f, -7.94708878e-02f, 1.07093446e-01f, -1.13039538e-02f, 1.84297841e-02f,
  2.48434678e-01f, -1.96707860e-01f, 5.95776513e-02f, 2.95251667e-01f, 4.22722064e-02f, -8.98221582e-02f, 2.08667144e-02f, 1.94138587e-01f, -1.06974067e-02f, -2.55670309e-01f,
  9.81371775e-02f, -1.95932630e-02f, -1.93589732e-01f, 1.53216392e-01f, 3.73130888e-01f, -1.52152658e-01f, 3.91854569e-02f, 3.15206982e-02f, 8.64117369e-02f, 1.03843644e-01f,
  1.25885323e-01f, 2.12919101e-01f, 2.65694827e-01f, 4.39661033e-02f, 8.02121311e-02f, 1.29840270e-01f, 9.71340910e-02f, 5.36118373e-02f, 1.88083842e-01f, 1.21973135e-01f,
  -1.30097061e-01f, 2.54572891e-02f, 1.70017295e-02f, -1.59372658e-01f, 1.19989827e-01f, -9.71537381e-02f, -2.50549950e-02f, 1.25524044e-01f, 7.09375888e-02f, 3.36645506e-02f,
  -1.61746085e-01f, 1.41435964e-02f, 5.54942340e-02f, -2.51396094e-02f, 3.18041109e-02f, -7.69220740e-02f, -2.63762902e-02f, -6.26368895e-02f, -4.45170738e-02f, 3.86045426e-02f,
  -9.18980781e-03f, -3.68190333e-02f, 3.68693769e-02f, -1.45073861e-01f, 1.99965127e-02f, 2.29461193e-02f, -1.68903574e-01f, -4.02086489e-02f, -6.58254232e-03f, 2.77039409e-02f,
  -2.26736870e-02f, 7.04782009e-02f, -5.58473542e-02f, -6.36366382e-02f, 1.80898216e-02f, 4.37655076e-02f, -1.84127856e-02f, 2.57537477e-02f, -8.55116323e-02f, 2.58887671e-02f,
  1.00212127e-01f, 1.14690058e-01f, -8.37793425e-02f, -9.46843550e-02f, -2.02576891e-02f, -3.50846983e-02f, 1.53642725e-02f, 8.27723369e-02f, -1.17725499e-01f, 4.82074469e-02f,
  1.82223059e-02f, 6.33825958e-02f, 2.72917114e-02f, 3.54548618e-02f, 2.11222991e-02f, 9.87003073e-02f, -1.19344215e-03f, -2.15862077e-02f, -5.75344041e-02f, -2.35311110e-02f,
  -5.08842804e-02f, 1.29256114e-01f, 6.04496337e-02f, -1.47316411e-01f, 1.14321454e-04f, -6.59298524e-02f, -6.68782219e-02f, -2.12934427e-02f, 1.04320474e-01f, 8.07915404e-02f,
  -1.52550295e-01f, 8.19144621e-02f, -8.49234536e-02f, 7.61134848e-02f, -3.76050919e-02f, 6.36824593e-02f, 1.41939027e-02f, 4.22314443e-02f, 3.42872017e-03f, 4.01772968e-02f,
  -6.23678714e-02f, -7.25191226e-03f, -2.88093998e-03f, 4.08138223e-02f, -9.53180864e-02f, 7.58808628e-02f, -6.99827224e-02f, -3.01455949e-02f, -5.72271971e-03f, -1.75818487e-03f,
  1.04260080e-01f, 3.37866277e-01f, 1.49143934e-01f, 1.76468231e-02f, -1.54212147e-01f, -4.96192090e-02f, -7.17502907e-02f, 2.11422089e-02f, 9.42696482e-02f, 2.13622287e-01f,
  -1.33071512e-01f, 4.38048512e-01f, -1.38529316e-02f, 5.92462607e-02f, -3.03705871e-01f, -2.82670230e-01f, -9.63716432e-02f, 6.47588894e-02f, -3.07318680e-02f, -4.42025550e-02f,
  -2.22854942e-01f, -3.78520638e-01f, -1.48924053e-01f, -1.22680090e-01f, 1.90370411e-01f, 2.37513423e-01f, -3.54280025e-01f, -5.13122268e-02f, 1.26078457e-01f, -4.36275490e-02f,
  -1.82582792e-02f, 1.03354238e-01f, 1.30037233e-01f, 1.39797062e-01f, 2.37998478e-02f, 8.38708729e-02f, 1.76285319e-02f, -7.81361945e-03f, -8.19878802e-02f, 1.30952112e-02f,
  9.94408876e-03f, 1.81378853e-02f, 8.62073973e-02f, -2.30652746e-02f, 5.65512888e-02f, 8.34503546e-02f, -5.77010156e-04f, 7.56670162e-02f, 7.33326524e-02f, 1.97637215e-01f,
  1.45283967e-01f, 2.32004821e-01f, -4.89487266e-03f, 4.12393063e-02f, -4.87249419e-02f, -2.69250683e-02f, -2.12522522e-02f, 7.24056214e-02f, 9.24556330e-02f, -1.77451354e-02f,
  7.55547211e-02f, -1.79056704e-01f, -5.26272366e-03f, 4.46406659e-03f, 1.41919581e-02f, -1.75620988e-02f, 4.08369303e-02f, -9.77300629e-02f, -1.72790363e-02f, -7.01584667e-02f,
  -4.28434834e-02f, 4.49875854e-02f, -6.07364401e-02f, -1.99586544e-02f, -8.31908360e-02f, -4.57769772e-03f, -2.09779516e-02f, 6.88012317e-02f, 4.99534532e-02f, 3.35229449e-02f,
  -6.93014935e-02f, -1.00131810e-01f, 6.61677569e-02f, -1.81781091e-02f, 3.84667143e-02f, 4.91420813e-02f, 1.50196344e-01f, 1.11173607e-01f, -8.14796239e-02f, -1.42848104e-01f,
  -2.20413171e-02f, -1.83680102e-01f, -6.19408190e-02f, 1.07940987e-01f, -1.78345609e-02f, -2.49812528e-02f, -9.77115240e-04f, 1.76119789e-01f, -2.16564704e-02f, 3.35975252e-02f,
  -2.76405271e-02f, -2.87805200e-02f, -5.41447662e-02f, 7.17744753e-02f, -7.42754489e-02f, -1.19808398e-01f, -5.88311777e-02f, -9.54920799e-02f, -1.49937840e-02f, 1.15795128e-01f,
  3.32259759e-02f, -1.11030377e-01f, 3.42739373e-02f, -1.08465932e-01f, 4.92336825e-02f, 9.30237304e-03f, 2.19881162e-02f, 1.04777373e-01f, -1.86725147e-02f, 3.79444216e-03f,
  -6.78822324e-02f, 2.03182280e-01f, 2.89751977e-01f, 9.13316011e-02f, -1.40393093e-01f, -2.47078866e-01f, -2.64693648e-01f, 1.22775905e-01f, 9.12249833e-03f, -9.53123625e-03f,
  5.83140887e-02f, 1.24633260e-01f, -1.68854184e-02f, 6.83276877e-02f, 2.03389376e-01f, -2.82582864e-02f, 1.96913123e-01f, -2.91676186e-02f, 1.60742655e-01f, 1.17615916e-01f,
  1.53475806e-01f, -6.23080879e-02f, 2.88125128e-01f, 1.95291281e-01f, 1.06110722e-01f, 2.71233737e-01f, 2.40237117e-01f, 4.30627950e-02f, 3.07299942e-01f, 2.89162453e-02f,
  -9.87708122e-02f, 4.65116352e-02f, 6.06949143e-02f, -1.09678566e-01f, 3.58739235e-02f, 4.65372168e-02f, 1.21953189e-02f, -3.10753547e-02f, 4.13631760e-02f, 1.33122792e-02f,
  5.10624871e-02f, -3.26849706e-02f, -5.14950454e-02f, 7.66620133e-03f, -1.10374782e-02f, -9.49993078e-03f, -9.29094926e-02f, -1.85132790e-02f, -1.88511536e-02f, 8.99177883e-03f,
  -1.60327572e-02f, 2.25166529e-02f, 3.66662145e-02f, -3.62429582e-03f, -2.90501863e-02f, -9.02320519e-02f, 2.75492519e-02f, -6.89311549e-02f, -3.04856058e-02f, 7.85778388e-02f,
  -8.14898461e-02f, 2.62172669e-02f, -3.69315930e-02f, 7.52511472e-02f, 5.37706986e-02f, 5.84221892e-02f, -1.89171284e-02f, 7.09427744e-02f, -1.52681733e-03f, 3.94121371e-02f,
  -2.06742045e-02f, 4.53526936e-02f, -9.08483788e-02f, -6.40738085e-02f, 1.62001997e-02f, -5.32608964e-02f, 1.12206317e-01f, -9.41848103e-03f, -6.90985247e-02f, 6.69148751e-03f,
  -8.53475109e-02f, 4.24958318e-02f, 1.13582931e-01f, -8.49660784e-02f, -1.24496967e-01f, -6.77146539e-02f, -7.03172907e-02f, 2.45124456e-02f, 8.42787772e-02f, 4.03741561e-02f,
  1.89801939e-02f, 8.33558515e-02f, 8.01294968e-02f, -4.97281589e-02f, 1.07257456e-01f, 1.14821270e-01f, 9.55996588e-02f, -1.04728177e-01f, -2.66550928e-02f, 7.93734752e-03f,
  -4.16996256e-02f, 1.30357713e-01f, -9.26270410e-02f, -3.93585116e-02f, -3.62392217e-02f, -5.41408174e-03f, -8.15104246e-02f, 3.60132121e-02f, -4.50606979e-02f, 4.50710543e-02f,
  3.31043266e-02f, -1.97423864e-02f, 9.15147830e-03f, -5.47824912e-02f, -6.33081272e-02f, -7.04877973e-02f, 5.62147424e-02f, -7.98257068e-02f, 3.42643596e-02f, 3.86813879e-02f,
  -3.64215970e-02f, -1.73765700e-02f, 2.78424233e-01f, 2.44106382e-01f, -1.72817901e-01f, -3.32350045e-01f, -2.22612545e-01f, 1.44233242e-01f, -7.85874128e-02f, -3.97557840e-02f,
  4.40129563e-02f, -4.54393141e-02f, 6.93420842e-02f, 5.18615171e-02f, 8.11041072e-02f, -1.51946872e-01f, 3.41447406e-02f, -9.43076611e-02f, 6.36229813e-02f, 8.89927521e-02f,
  1.15423270e-01f, 1.87242888e-02f, 1.93936929e-01f, 1.11351117e-01f, -1.91388577e-02f, 1.67021215e-01f, 2.33844265e-01f, 7.41296168e-03f, 9.58077610e-02f, -1.90916821e-01f,
  -1.50603577e-01f, 1.47479534e-01f, 1.54042363e-01f, -6.57480359e-02f, 1.29801542e-01f, -1.25412524e-01f, 6.68655261e-02f, -1.51174972e-02f, 9.46159009e-03f, 2.84745060e-02f,
  -3.05021629e-02f, -4.72439788e-02f, -4.34130728e-02f, -5.44545427e-02f, -1.63114861e-01f, -2.58691330e-02f, 4.02663313e-02f, 7.52788559e-02f, -8.39204118e-02f, 6.97005466e-02f,
  1.40899688e-01f, 5.18666804e-02f, -3.59267369e-02f, -4.46411707e-02f, 2.53299084e-02f, -6.58906391e-03f, 2.22782977e-02f, 7.18247816e-02f, -6.42256513e-02f, -1.94894373e-02f,
  8.21785405e-02f, 5.05072670e-03f, -3.56401913e-02f, -2.30055675e-02f, 1.39276311e-02f, 8.80714133e-02f, -9.30310600e-03f, 3.08677554e-03f, -6.15582801e-03f, -9.46869776e-02f,
  4.06807959e-02f, -4.16551754e-02f, -6.57208636e-02f, -8.12088847e-02f, 1.30841494e-01f, -8.61059651e-02f, -4.19410765e-02f, 2.51728203e-02f, 1.33586720e-01f, 3.27789485e-02f,
  2.66772788e-02f, -1.69901431e-01f, -3.54362167e-02f, -1.01831229e-02f, -8.90561938e-02f, 4.57930714e-02f, 7.06827715e-02f, -8.82197767e-02f, 4.72532772e-02f, 7.11195767e-02f,
  5.94432540e-02f, 2.59605974e-01f, 1.57242402e-01f, -2.10069437e-02f, -4.57989722e-02f, -3.62771899e-02f, -6.80981651e-02f, 4.48567532e-02f, 1.97544247e-02f, 3.37794982e-02f,
  -3.40179796e-03f, 1.09199192e-02f, 2.23222841e-02f, -4.95859310e-02f, 9.06412899e-02f, 1.80082731e-02f, 9.48467776e-02f, 2.82226969e-02f, 5.00436127e-02f, 5.72998635e-02f,
  6.31094649e-02f, -6.31764531e-02f, -5.34360707e-02f, 3.66122313e-02f, 8.69039446e-02f, -3.74315493e-02f, -9.01046395e-02f, -4.85598408e-02f, 9.50339139e-02f, 4.53034900e-02f,
  1.93754822e-01f, 1.28271699e-01f, 1.03210233e-01f, 6.12549894e-02f, -3.74764092e-02f, -2.03206748e-01f, -1.94114104e-01f, -4.96969074e-02f, 2.32545510e-01f, -4.38989960e-02f,
  -1.03359140e-01f, 2.24629864e-01f, -1.55327618e-01f, -2.04288047e-02f, -2.59449363e-01f, -1.39588946e-02f, -1.42498910e-01f, -1.02775984e-01f, 1.45708278e-01f, 6.65212702e-03f,
  1.26308605e-01f, -2.34942600e-01f, -3.05495206e-02f, -2.94343978e-01f, -3.44745554e-02f, 8.29003900e-02f, -2.74950117e-01f, -2.04120591e-01f, -7.30861202e-02f, -7.60202184e-02f,
  -3.02951299e-02f, 2.22996734e-02f, 5.00147231e-02f, -8.46124589e-02f, 2.41622627e-02f, -2.80170590e-02f, 4.33298722e-02f, 2.88548805e-02f, -9.86770168e-03f, 5.05275540e-02f,
  3.06891073e-02f, -1.06313147e-01f, 7.36833513e-02f, 8.58388171e-02f, -1.76141802e-02f, -4.38240059e-02f, 9.07534584e-02f, 1.48960859e-01f, -9.17624757e-02f, 1.22472800e-01f,
  4.76919189e-02f, 8.71992391e-03f, -5.81250601e-02f, -4.98038270e-02f, 1.86623842e-01f, -2.96394192e-02f, -1.61295570e-02f, -3.86092835e-03f, 8.16169530e-02f, 1.23205051e-01f,
  5.02734352e-03f, -6.88244530e-04f, -9.24622566e-02f, -3.27555463e-02f, -1.50684819e-01f, 8.03018287e-02f, -2.92168092e-02f, 3.80464233e-02f, -5.17442450e-02f, -7.96675310e-02f,
  -1.18249804e-01f, -2.04610918e-02f, -5.64868152e-02f, 2.90710852e-02f, 5.27267642e-02f, 7.46832192e-02f, 3.55811715e-02f, 2.15090509e-03f, 1.88843422e-02f, 1.44118935e-01f,
  5.08426055e-02f, -1.68413837e-02f, -1.83292739e-02f, 1.73640177e-02f, -9.14598852e-02f, -3.34708393e-02f, 1.10488541e-01f, 4.40272316e-02f, 1.70631900e-01f, -1.42902553e-01f,
  -1.41823068e-01f, -1.15756638e-01f, -8.68171677e-02f, 8.26036483e-02f, 9.10573825e-03f, -1.05979316e-01f, 1.16922192e-01f, -2.36885101e-02f, -1.67462692e-01f, -8.35150108e-02f,
  1.08145541e-02f, 5.56269661e-03f, -9.02089253e-02f, 4.07990701e-02f, -1.20166481e-01f, -9.96261463e-02f, 4.22644895e-03f, -6.51934668e-02f, -2.99304780e-02f, 6.39403760e-02f,
  -9.23952088e-03f, 2.06867885e-02f, -9.01162848e-02f, 7.83499982e-03f, 6.57509407e-03f, 4.53897156e-02f, 8.82574916e-02f, 1.25176907e-01f, -6.93734437e-02f, -5.49405478e-02f,
  -1.51421363e-02f, -1.34269655e-01f, -2.28004649e-01f, -1.26226485e-01f, 1.85965095e-02f, -1.63946405e-01f, -2.91973114e-01f, -7.30101988e-02f, 1.16442218e-01f, -5.57285361e-03f,
  -1.67869478e-01f, -1.89996585e-02f, -4.26857173e-02f, -3.02734882e-01f, 1.72560066e-02f, 9.15460736e-02f, -1.03480197e-01f, -2.19211392e-02f, 1.28611460e-01f, -1.89044982e-01f,
  -8.76101255e-02f, -2.72238106e-01f, -3.17252129e-01f, -2.00692877e-01f, -2.74717003e-01f, 9.83282626e-02f, 9.75696445e-02f, -4.00029048e-02f, -4.19612490e-02f, 1.49741499e-02f,
  -4.11354005e-02f, 6.37713447e-02f, -9.80166253e-04f, -6.99785724e-02f, 8.70104805e-02f, 4.35495041e-02f, 9.27940011e-02f, -1.46543622e-01f, -6.31734058e-02f, 3.94772701e-02f,
  1.17616933e-02f, 8.77543390e-02f, 4.88255098e-02f, -5.29242679e-02f, -1.10435985e-01f, -5.92616983e-02f, -1.47900833e-02f, 3.60801183e-02f, -3.37797925e-02f, -5.38374707e-02f,
  -1.24735110e-01f, 5.20762503e-02f, 3.90688106e-02f, 1.07905515e-01f, -1.73354503e-02f, 4.15673144e-02f, 3.76707278e-02f, -9.25898645e-03f, 7.43486434e-02f, 1.19567022e-01f,
  -3.26254331e-02f, 9.41855833e-02f, 1.09172082e-02f, -1.65070463e-02f, -5.24394885e-02f, 1.14446096e-02f, 1.07239969e-02f, -2.80479081e-02f, 1.43223032e-01f, -6.25597164e-02f,
  7.60438794e-04f, -1.21384196e-01f, 3.00245658e-02f, -5.80977723e-02f, -1.47816107e-01f, -2.50973087e-02f, -4.92134020e-02f, 1.24474443e-01f, 1.11254871e-01f, -4.92993034e-02f,
  -1.03757173e-01f, 3.98508683e-02f, -1.56135798e-01f, -4.00761552e-02f, -2.47980375e-02f, 5.98686896e-02f, -1.60492975e-02f, -1.27179354e-01f, -1.03921182e-02f, -1.89044122e-02f,
  3.55498632e-03f, 1.18214674e-01f, -1.18695421e-03f, -3.02041564e-02f, 2.79949699e-02f, -1.02988057e-01f, -7.62849450e-02f, -6.18368909e-02f, 1.22633606e-01f, -8.07795525e-02f,
  5.58608137e-02f, 1.32064357e-01f, 7.80266300e-02f, 5.05719222e-02f, 5.67233525e-02f, -7.36820400e-02f, 5.54710962e-02f, 1.86725199e-01f, 8.39214325e-02f, 1.02211095e-01f,
  1.60592906e-02f, 8.07497352e-02f, 6.74156621e-02f, 6.11172207e-02f, 5.17398380e-02f, 5.83098410e-03f, 1.21453695e-01f, 1.65369473e-02f, 1.55601591e-01f, -1.95836592e-02f,
  -2.51729131e-01f, 2.73646079e-02f, -5.93160987e-02f, -2.06681728e-01f, 2.95561999e-02f, -3.59547824e-01f, -2.55006939e-01f, 1.95002425e-02f, 2.39434130e-02f, 1.37725830e-01f,
  -6.42001256e-02f, 4.05965559e-02f, 2.33466879e-01f, -3.43505919e-01f, -2.80917197e-01f, -1.33116156e-01f, -3.57926697e-01f, -2.49632865e-01f, 3.19615304e-02f, -3.13163362e-02f,
  -4.24891300e-02f, -3.20733376e-02f, -1.10584132e-01f, 1.28395826e-01f, -4.33740690e-02f, 1.74451962e-01f, 2.54517198e-01f, 1.46048859e-01f, -2.22891895e-03f, -4.21659686e-02f,
  -5.77621646e-02f, 1.19368635e-01f, -5.28433248e-02f, -4.08359058e-02f, 7.20199794e-02f, 6.17139228e-02f, -2.33168285e-02f, -6.02751086e-03f, -5.12454920e-02f, 5.52456714e-02f,
  6.65739924e-02f, -2.18624827e-02f, -5.98728955e-02f, 3.02290265e-02f, 8.43914808e-04f, -5.99437989e-02f, -1.19894976e-02f, -3.63641977e-02f, 6.97715655e-02f, -8.62721428e-02f,
  -5.75556681e-02f, -9.18211713e-02f, -1.11135598e-02f, 1.87300034e-02f, 8.55016634e-02f, -4.26971316e-02f, -9.68540907e-02f, -5.45351580e-02f, -6.46799356e-02f, -1.83524620e-02f,
  -1.05713513e-02f, -8.67036805e-02f, -1.08236805e-01f, 4.24752906e-02f, -7.22895190e-02f, -2.72185588e-03f, -9.32780802e-02f, 1.29321553e-02f, -9.32911336e-02f, 5.05423211e-02f,
  4.39113341e-02f, 5.83601743e-02f, 3.32621224e-02f, 3.58732976e-02f, 7.07902480e-04f, -1.48448516e-02f, -1.05978161e-01f, -5.63647002e-02f, -2.43192613e-02f, -5.81666306e-02f,
  1.41810589e-02f, -1.44454474e-02f, -4.39559408e-02f, 4.98312339e-02f, -7.65608922e-02f, 8.02296698e-02f, -2.01374814e-02f, -1.20634004e-01f, -6.68907389e-02f, 1.90184284e-02f,
  6.94882497e-02f, 1.55074358e-01f, 6.38382658e-02f, -1.99477281e-02f, 9.91961639e-03f, -2.13902257e-03f, -7.33915344e-02f, 1.31726172e-02f, 3.71883474e-02f, -7.62324333e-02f,
  1.08114719e-01f, -9.75037459e-03f, 1.57579314e-02f, -9.15312022e-02f, 1.96399949e-02f, -2.64197532e-02f, 1.07260257e-01f, 9.92366523e-02f, 5.30748479e-02f, 1.09966109e-02f,
  1.56520173e-01f, 1.29870132e-01f, 5.60656451e-02f, 6.11137971e-02f, 3.72215919e-02f, 8.53637606e-02f, -1.25736464e-02f, 8.91103372e-02f, -7.70298298e-03f, 7.86388367e-02f,
  -1.70482516e-01f, 1.36320353e-01f, 2.82095551e-01f, -3.06329638e-01f, 2.77548194e-01f, 1.71001881e-01f, -1.37312949e-01f, 2.75354981e-01f, 2.59131920e-02f, -1.79151013e-01f,
  -5.36744073e-02f, -1.68758377e-01f, 2.01304242e-01f, -3.10596496e-01f, 1.26226321e-01f, 7.38840923e-02f, -9.11849588e-02f, -2.34417498e-01f, 4.02900763e-02f, -1.86309785e-01f,
  2.02399269e-02f, -2.36724153e-01f, -2.83535644e-02f, 7.49066547e-02f, 6.78104013e-02f, -9.04722139e-02f, -2.11030632e-01f, 1.49959058e-01f, -1.32669657e-01f, 8.71058777e-02f,
  -8.82984549e-02f, -1.32697731e-01f, -2.29279976e-04f, 1.31317712e-02f, 1.42807066e-01f, 3.21628037e-03f, -1.35977820e-01f, -1.03234656e-01f, 3.41679007e-02f, 5.44984639e-02f,
  -1.68540236e-02f, 2.07192656e-02f, -8.55471864e-02f, 8.43606666e-02f, 4.87664901e-02f, 1.44254386e-01f, -3.99317332e-02f, 3.08033871e-03f, -8.42522830e-02f, 6.32952079e-02f,
  6.81986585e-02f, 7.83790350e-02f, 8.85252133e-02f, -2.43414007e-02f, 1.08247821e-03f, 9.35052037e-02f, -1.47651490e-02f, 4.15684730e-02f, -1.06729791e-02f, 5.83804809e-02f,
  -4.83534224e-02f, -2.47733463e-02f, -4.94079590e-02f, 5.06070815e-02f, -8.08264967e-03f, 7.45351464e-02f, -5.34132794e-02f, -5.13738431e-02f, -1.11071423e-01f, -5.50195458e-04f,
  -1.34929139e-02f, -1.28623350e-02f, 5.70293777e-02f, -2.42315549e-02f, -5.82825802e-02f, -5.00630885e-02f, -1.71049058e-01f, -6.86132759e-02f, 3.44988108e-02f, 2.07850840e-02f,
  -9.23984498e-02f, -5.27779907e-02f, 1.01063378e-01f, -9.24671963e-02f, -3.59372422e-02f, 3.81524563e-02f, -9.48959440e-02f, -2.56038010e-02f, -2.40423623e-02f, 4.69521582e-02f,
  -2.06007466e-01f, -2.42534429e-01f, -7.02247024e-02f, -1.49260044e-01f, 1.46566285e-02f, 4.08969261e-02f, -1.37674987e-01f, 5.63417897e-02f, 1.53901940e-03f, -6.59079924e-02f,
  7.52825588e-02f, -5.12952730e-02f, 3.69723700e-02f, 2.14347094e-02f, 2.52084862e-02f, -9.25163105e-02f, -2.34763399e-01f, -4.74259630e-02f, -1.25219673e-01f, 7.97825679e-02f,
  -9.40075368e-02f, -1.09838784e-01f, 2.06970070e-02f, -9.61354598e-02f, -7.66700134e-02f, -2.03412063e-02f, 1.07779428e-02f, 7.31936609e-03f, -6.21723291e-03f, 1.60364658e-01f,
  -2.21933350e-01f, -1.66850775e-01f, 1.83084950e-01f, 3.18321437e-01f, -1.49205133e-01f, -2.58600205e-01f, -3.39205623e-01f, 8.63211229e-02f, -1.15315005e-01f, -2.23839596e-01f,
  -7.44109228e-02f, -8.50755945e-02f, -2.47975528e-01f, 2.35785738e-01f, 1.95553571e-01f, -4.75138873e-02f, 1.94089890e-01f, 6.29494041e-02f, 2.16318414e-01f, 8.60245898e-02f,
  2.35840112e-01f, 3.22542340e-01f, 1.89297453e-01f, 3.15937430e-01f, 3.36154699e-02f, 1.18556961e-01f, 2.75646299e-01f, 8.38455856e-02f, 3.36684316e-01f, 3.05237304e-02f,
  -7.60080367e-02f, -4.30527404e-02f, -8.06907285e-03f, -3.15648429e-02f, 2.15069205e-02f, 6.51871087e-03f, 5.56941517e-02f, -2.61075161e-02f, 7.76134133e-02f, 2.41686832e-02f,
  -1.47160813e-01f, 1.48727566e-01f, 9.70919654e-02f, 3.69793065e-02f, -8.73462632e-02f, 1.44001365e-01f, -1.14860423e-02f, -5.50357997e-02f, 3.32425758e-02f, 4.89435974e-04f,
  -6.31976947e-02f, -1.16573805e-02f, -4.86980528e-02f, -1.94259491e-02f, 4.23878729e-02f, 5.54279946e-02f, 6.58580586e-02f, 1.71424507e-03f, 8.41287076e-02f, 5.35479076e-02f,
  -2.57381238e-02f, -4.17787395e-02f, 1.30644171e-02f, 9.94762778e-02f, 1.53787946e-02f, 1.85872186e-02f, 1.48967700e-02f, -9.83299911e-02f, 8.48931260e-03f, -4.02580537e-02f,
  7.66120031e-02f, -1.06436592e-02f, -2.92222705e-02f, 5.20176999e-02f, 7.14964746e-03f, 2.61708386e-02f, -3.95234190e-02f, 8.27934220e-02f, 4.10210975e-02f, 1.03290252e-01f,
  -3.83180939e-02f, -1.80731136e-02f, 1.01476517e-02f, -3.68906669e-02f, -5.76336570e-02f, 2.16917265e-02f, 5.25912531e-02f, -4.86225709e-02f, 2.00202391e-02f, 1.16038598e-01f,
  -1.00488819e-01f, 1.29084677e-01f, 3.10586896e-02f, -4.16661752e-03f, 5.57712987e-02f, 4.58578467e-02f, 5.79305552e-02f, 1.04392702e-02f, 2.10489016e-02f, 1.40009280e-02f,
  5.43706901e-02f, 8.34006630e-03f, -1.89557113e-02f, 2.28001270e-02f, 6.53436175e-03f, 9.39358491e-03f, 3.39269452e-02f, -4.90069687e-02f, -6.47412837e-02f, 5.64565696e-02f,
  4.56470884e-02f, -4.27632108e-02f, 8.11539590e-02f, 1.03493899e-01f, -2.25027073e-02f, 6.30110800e-02f, -1.38280792e-02f, 2.66861171e-02f, 1.11829244e-01f, 1.04760258e-02f,
  1.85933560e-01f, 1.94934353e-01f, -2.78886128e-03f, 2.10809246e-01f, 1.77948490e-01f, -1.27451420e-01f, -1.45190403e-01f, 4.53828163e-02f, 1.24074304e-02f, -3.89566720e-02f,
  9.87297520e-02f, 1.14190705e-01f, -1.34240314e-01f, 3.22243929e-01f, 2.16807336e-01f, -2.20084950e-01f, 3.52437198e-01f, 3.70870568e-02f, 1.32554948e-01f, 2.00946420e-01f,
  2.06020921e-01f, 3.47453177e-01f, -5.36075532e-02f, 1.69099912e-01f, 1.48762211e-01f, -8.16699769e-03f, 8.84433985e-02f, -1.74679071e-01f, 1.96980536e-01f, 1.27337798e-01f,
  7.10058138e-02f, 1.12854645e-01f, 1.28356423e-02f, 2.55956631e-02f, -8.35223719e-02f, -1.05063971e-02f, -6.31180033e-02f, -7.44140446e-02f, -9.61860791e-02f, -4.94762361e-02f,
  9.18728858e-03f, 9.66711193e-02f, 3.30109298e-02f, -3.24064260e-03f, 4.14580144e-02f, -2.35473868e-02f, 2.54293084e-02f, 1.90845355e-02f, -5.85462973e-02f, 4.29664142e-02f,
  -1.61182415e-02f, -8.24937820e-02f, 9.31016058e-02f, 6.88750744e-02f, 2.16155145e-02f, 5.29890060e-02f, 9.21046212e-02f, -2.90881060e-02f, -6.60604909e-02f, 1.30266637e-01f,
  6.74548745e-02f, 2.59745922e-02f, 3.74544673e-02f, -4.23302315e-02f, 4.22292612e-02f, -1.01197675e-01f, -8.79617000e-04f, 2.09960360e-02f, -2.04412024e-02f, 2.90183276e-02f,
  -1.28212377e-01f, 4.24124338e-02f, -5.46773896e-02f, 1.18070282e-02f, 1.04397960e-01f, 8.83153453e-02f, -7.03987256e-02f, -2.76280884e-02f, -2.06977054e-02f, 5.03781177e-02f,
  -6.84659258e-02f, 3.71488184e-02f, -6.55572414e-02f, -9.94010642e-02f, -3.29509042e-02f, -6.95344210e-02f, 3.31459530e-02f, 1.87232383e-02f, -1.24851257e-01f, 7.18016401e-02f,
  9.89054888e-03f, 2.63159573e-01f, -4.17151749e-02f, 2.14135889e-02f, -7.49702081e-02f, 8.23056884e-03f, 8.37863162e-02f, 1.01075746e-01f, 8.39936510e-02f, -5.24504706e-02f,
  6.06686436e-02f, -2.22155303e-02f, 2.31707152e-02f, 8.83256197e-02f, -8.09266567e-02f, 9.22476053e-02f, -4.84840348e-02f, 1.32264178e-02f, 9.34351757e-02f, 1.00893520e-01f,
  2.64352690e-02f, -1.15244240e-01f, -2.26728618e-04f, -6.47874475e-02f, 5.90411387e-02f, -6.40600547e-02f, 6.65112305e-03f, 3.22969966e-02f, -2.68442021e-03f, 7.78816035e-03f,
  4.62131836e-02f, -1.74081504e-01f, 1.26685455e-01f, -1.63000807e-01f, 4.58268784e-02f, -2.44340450e-02f, 3.95855308e-02f, -2.53533244e-01f, -1.04626849e-01f, -2.50877947e-01f,
  -7.35851824e-02f, 1.08970262e-01f, 2.09497780e-01f, -3.17264915e-01f, 5.55231452e-01f, 1.78728685e-01f, -2.87367642e-01f, -1.34916857e-01f, -8.39783177e-02f, -2.28453621e-01f,
  -8.07455406e-02f, -2.98603684e-01f, -2.09329724e-02f, -2.85708636e-01f, -1.77190036e-01f, -1.75863594e-01f, 1.74194332e-02f, 7.98783824e-02f, -2.40799323e-01f, 4.13946062e-02f,
  -1.14248112e-01f, -1.38491973e-01f, -7.21947849e-02f, -1.34089775e-02f, -1.05950378e-01f, 4.88463342e-02f, -2.95242760e-03f, 1.16654485e-01f, 3.43142281e-04f, 5.56671545e-02f,
  9.99169797e-02f, -1.19137112e-02f, -8.36490691e-02f, 3.51556279e-02f, -1.35075644e-01f, -1.36496164e-02f, 3.68727073e-02f, 4.56791855e-02f, -4.75735329e-02f, 1.18328862e-01f,
  1.08416779e-02f, 7.36883208e-02f, 2.27738433e-02f, 8.73356033e-03f, 4.50723320e-02f, 5.24093490e-03f, 3.96545418e-02f, 1.51021704e-01f, -2.66552381e-02f, 2.17334405e-02f,
  -3.91631797e-02f, -3.70375700e-02f, -2.82512028e-02f, -6.80986941e-02f, -5.94225265e-02f, -6.50720298e-02f, 9.69912391e-03f, 6.24186872e-03f, 6.82245046e-02f, 1.45607255e-02f,
  3.23059224e-02f, 7.78252212e-03f, -7.47064799e-02f, -6.44761100e-02f, -3.88815627e-02f, -9.59516168e-02f, 5.59795983e-02f, 9.76911280e-03f, -6.32230863e-02f, 1.06118143e-01f,
  5.84995970e-02f, -2.31744610e-02f, 8.41369331e-02f, 9.23308581e-02f, -1.02721937e-01f, 5.09331413e-02f, -6.28329962e-02f, 9.26963910e-02f, 3.80921252e-02f, 1.46787152e-01f,
  -1.27157774e-02f, -2.76740491e-01f, 4.06622365e-02f, -3.05730551e-02f, -5.79301156e-02f, -5.01724482e-02f, -8.87847170e-02f, 4.59611788e-02f, -2.56258510e-02f, -5.17483167e-02f,
  -6.90392852e-02f, 3.22017185e-02f, -6.55996874e-02f, 1.53233381e-02f, 2.71091983e-02f, 4.65810075e-02f, 5.41126728e-03f, 6.50582835e-02f, 1.10793732e-01f, -3.81435640e-02f,
  2.78934017e-02f, 4.66310270e-02f, 6.10153228e-02f, -8.19208473e-02f, 5.72426133e-02f, 1.47509918e-01f, -3.10303867e-02f, 6.78974763e-02f, 1.17070675e-01f, -8.05401185e-04f,
  -1.29687950e-01f, -7.04964763e-03f, -2.37412572e-01f, -8.97046402e-02f, 9.75680947e-02f, -3.52654219e-01f, -1.91225365e-01f, 1.88396021e-03f, -4.08925489e-02f, 1.79265335e-01f,
  3.66410404e-03f, -6.29056469e-02f, 7.06116036e-02f, -3.89764160e-01f, -3.70086938e-01f, -1.92333549e-01f, -2.62132108e-01f, -1.45144910e-01f, 6.50751125e-03f, 3.86191756e-02f,
  -7.18429610e-02f, -1.54977053e-01f, -2.98770964e-01f, 2.26564154e-01f, -1.25507087e-01f, 2.09548116e-01f, 2.11350933e-01f, 2.02497974e-01f, -6.91232234e-02f, -1.50953025e-01f,
  -4.51045707e-02f, 5.51977940e-02f, -1.21613722e-02f, -6.49132729e-02f, -1.98996416e-03f, 7.18688816e-02f, -4.30590212e-02f, -4.31789048e-02f, 3.89010198e-02f, -5.35651669e-02f,
  6.05356209e-02f, 1.87503938e-02f, -1.29597485e-01f, -9.91007313e-02f, 5.27085885e-02f, -3.48323323e-02f, -1.66263863e-01f, 1.79902576e-02f, -3.26224193e-02f, -6.29439801e-02f,
  -4.74596359e-02f, -3.39541323e-02f, 1.07412852e-01f, -3.50978002e-02f, 9.74434521e-03f, -1.04836129e-01f, 1.35273067e-02f, -6.96848109e-02f, -2.76100021e-02f, 3.07499357e-02f,
  5.30137159e-02f, 6.09548911e-02f, 7.63271898e-02f, -1.57952569e-02f, -3.94129194e-03f, 3.24640796e-02f, -1.46647980e-02f, -2.44940147e-02f, 9.61126313e-02f, -2.07718499e-02f,
  -2.80944351e-02f, 1.28322328e-02f, -2.10077334e-02f, 5.22587541e-03f, -3.09882481e-02f, -4.80841435e-02f, -5.12015969e-02f, 2.38917731e-02f, -5.62595502e-02f, -4.41843681e-02f,
  5.54811992e-02f, 7.46403262e-03f, 4.05432321e-02f, -7.33630778e-03f, -6.41044080e-02f, 8.55423603e-03f, 1.28146112e-01f, -7.15676602e-03f, 1.73263568e-02f, 4.64942716e-02f,
  -5.30214533e-02f, 8.54831412e-02f, 2.58630011e-02f, -2.16368102e-02f, -3.44460979e-02f, -4.05287072e-02f, 1.33005921e-02f, -7.52975270e-02f, 4.59275432e-02f, 8.01860318e-02f,
  8.74697194e-02f, 3.33520956e-02f, 4.38486934e-02f, -3.05059105e-02f, 1.05209285e-02f, -8.77442490e-03f, 3.49007286e-02f, -2.43903585e-02f, 6.63245320e-02f, 7.50653222e-02f,
  1.04641668e-01f, -6.85140043e-02f, 1.37406262e-02f, -8.73488374e-03f, -2.63980236e-02f, -4.08944488e-03f, 9.56285298e-02f, -2.48574596e-02f, -3.87549810e-02f, 3.82456407e-02f,
  2.41227075e-01f, -2.62408733e-01f, 1.68087073e-02f, 8.12572241e-02f, 1.54907763e-01f, 1.69711754e-01f, 3.64891499e-01f, -2.42614895e-01f, -2.80581787e-02f, -3.06222618e-01f,
  -3.54652405e-02f, 1.63356420e-02f, -3.04528698e-02f, -5.99498414e-02f, 2.72987723e-01f, -5.52357472e-02f, 4.25376892e-02f, -7.54385442e-03f, -1.12211056e-01f, -5.66559955e-02f,
  -2.27825791e-02f, 4.83151786e-02f, 6.29843865e-03f, -2.45486706e-01f, 1.16273098e-01f, -1.38879597e-01f, -8.56583938e-02f, 4.26714383e-02f, -1.47577479e-01f, 1.59042701e-01f,
  9.42100361e-02f, -2.10911874e-02f, 3.96706983e-02f, 1.98095813e-02f, -8.80067274e-02f, 4.61326428e-02f, -3.99347767e-02f, 9.32594389e-02f, 1.14658952e-01f, -3.40021700e-02f,
  -4.03839685e-02f, -4.55320925e-02f, 5.51773980e-03f, 1.00464106e-01f, 1.03255592e-01f, 4.05519642e-02f, -8.42266753e-02f, -1.05262920e-01f, -1.44499704e-01f, -7.30474070e-02f,
  5.33066317e-03f, -7.89975375e-02f, 6.82982206e-02f, -1.16032295e-01f, 5.22698574e-02f, -1.52092978e-01f, -1.16963696e-03f, 6.29630014e-02f, 6.15972355e-02f, 3.70366015e-02f,
  -4.61255759e-02f, -9.69889853e-03f, 8.37127268e-02f, 7.05548525e-02f, 7.91918263e-02f, -1.81285944e-02f, 1.32152215e-02f, -1.19575532e-02f, -2.34676972e-02f, -2.86282552e-03f,
  1.49748191e-01f, -5.88577390e-02f, 2.85611153e-02f, 1.13882825e-01f, 5.08913770e-02f, -5.06570898e-02f, 1.34814471e-01f, -9.42987129e-02f, -6.65739104e-02f, -4.83433977e-02f,
  -4.15862426e-02f, -3.68414931e-02f, 8.01430270e-02f, -1.19999386e-01f, 1.63219422e-02f, 1.65232658e-01f, -7.04013407e-02f, -3.83176692e-02f, -9.99585092e-02f, 1.42280683e-02f,
  4.55228016e-02f, -9.53848362e-02f, 5.76937199e-02f, -3.37513424e-02f, -8.62554386e-02f, -1.41553104e-01f, 2.13915091e-02f, -5.92184216e-02f, 2.28042696e-02f, -5.02109006e-02f,
  -1.17983542e-01f, -6.56511784e-02f, -1.07568707e-02f, -5.08371554e-02f, -1.03697270e-01f, -9.29448232e-02f, -4.93086725e-02f, -3.66185084e-02f, -8.62341747e-02f, -4.83566150e-02f,
  4.19457443e-02f, -1.43548138e-02f, 5.66290617e-02f, -2.90175667e-03f, 3.58994082e-02f, -8.72424394e-02f, 8.06069653e-03f, 7.67799094e-02f, -1.12251714e-01f, -9.84940119e-03f,
  -2.46815026e-01f, -1.34882435e-01f, 3.42508167e-01f, 1.01937363e-02f, 1.60558894e-01f, 2.61194378e-01f, 2.62277365e-01f, 7.80436629e-03f, -5.46914041e-02f, -1.79557115e-01f,
  -1.24614440e-01f, -5.25329867e-03f, 1.73255220e-01f, -1.60964906e-01f, 4.38856632e-01f, 2.22471729e-01f, -1.08900843e-02f, -9.87667590e-03f, 6.12602681e-02f, -4.37211953e-02f,
  -5.34514748e-02f, -1.57808989e-01f, 1.20725557e-01f, -3.03705961e-01f, -8.32018480e-02f, -1.97512090e-01f, -1.72178999e-01f, 2.17692509e-01f, -4.72911783e-02f, 2.00638786e-01f,
  -9.96825993e-02f, -1.92372426e-01f, -1.11302234e-01f, -8.83411467e-02f, 1.98321715e-02f, 2.36062706e-02f, 1.47728637e-01f, 1.18407004e-01f, -4.85204048e-02f, 6.43932670e-02f,
  6.12528361e-02f, -6.79986030e-02f, -1.22574806e-01f, -8.20539966e-02f, -9.04878378e-02f, -1.80946216e-02f, 1.33593753e-02f, 4.06153034e-03f, -1.45893507e-02f, 2.91261990e-02f,
  3.16648781e-02f, 8.57183561e-02f, -5.50312474e-02f, -6.37102723e-02f, 2.44736131e-02f, 7.31183290e-02f, 1.67492870e-02f, 1.61073923e-01f, -6.11861981e-02f, 5.18552028e-02f,
  -3.22009400e-02f, -3.91048267e-02f, -2.19643656e-02f, -8.41319039e-02f, -3.26233506e-02f, -1.35766994e-02f, -3.32733281e-02f, -5.28075323e-02f, 8.70830417e-02f, -4.57757711e-02f,
  -1.39248464e-02f, 1.98954325e-02f, -1.67414229e-02f, -1.05952673e-01f, -8.77130777e-03f, -1.30283060e-02f, 1.64179219e-04f, -8.73916373e-02f, -6.30563125e-02f, 6.59227073e-02f,
  -3.13849635e-02f, 1.18951052e-01f, -6.71128035e-02f, 5.09220622e-02f, -5.64740449e-02f, 8.41082931e-02f, -3.07211243e-02f, -4.05861437e-02f, 3.08952406e-02f, 1.36288881e-01f,
  -2.04897463e-01f, -2.39020407e-01f, -1.07461080e-01f, -9.54182148e-02f, -3.89932021e-02f, 1.24656865e-02f, 8.73620901e-03f, -1.26139671e-01f, 7.81132057e-02f, -2.48737130e-02f,
  -2.49098875e-02f, -9.06423479e-02f, -4.07939889e-02f, 2.97878701e-02f, -1.34747587e-02f, -2.18691826e-02f, 9.71612409e-02f, -2.26225448e-03f, 2.66565010e-02f, -1.14035405e-01f,
  8.45012441e-02f, 2.13577691e-02f, -1.07451982e-03f, -1.29091479e-02f, -4.71225753e-02f, 5.30948443e-03f, -1.05297431e-01f, 7.92367980e-02f, 4.53235246e-02f, -2.35990845e-02f,
  2.04183698e-01f, -1.64457746e-02f, 1.23740077e-01f, 6.88482970e-02f, 2.22864106e-01f, 2.50425458e-01f, 4.06482697e-01f, 1.40311360e-01f, 4.12841141e-01f, -1.49685796e-03f,
  -4.08492275e-02f, 1.87701769e-02f, -5.80847170e-03f, -2.51495112e-02f, 1.81645438e-01f, -3.94419171e-02f, 1.76061317e-01f, 1.54557571e-01f, 1.83515385e-01f, 1.70799643e-01f,
  1.64841861e-01f, -5.09847924e-02f, -1.57671481e-01f, -1.81494072e-01f, 5.10591920e-03f, -1.67789340e-01f, -2.77777612e-01f, 9.98096541e-02f, -2.09663153e-01f, 1.94124386e-01f,
  -4.01206538e-02f, -6.05852045e-02f, -1.12083599e-01f, -1.99411474e-02f, -1.39047831e-01f, -9.58436355e-02f, 6.20330721e-02f, 4.19727787e-02f, -5.85995317e-02f, 5.16731218e-02f,
  2.11819634e-02f, 2.15596855e-02f, 4.67835963e-02f, 9.51262638e-02f, 4.26592119e-03f, 1.41097503e-02f, -2.00557727e-02f, -5.61331734e-02f, -3.94896939e-02f, -9.00666714e-02f,
  -6.96899369e-03f, 1.99737195e-02f, -8.20817053e-02f, 4.74727638e-02f, 7.68915936e-02f, 1.88920889e-02f, 1.05223998e-01f, -1.47498623e-02f, 3.40777114e-02f, 2.91434433e-02f,
  4.77325683e-03f, 1.58486754e-01f, 4.00362257e-03f, -1.35712530e-02f, 3.83041147e-03f, -5.72258011e-02f, -3.10711917e-02f, -2.37003695e-02f, -7.59634981e-03f, -5.34345470e-02f,
  2.04942133e-02f, 4.33000512e-02f, 2.19193865e-02f, -7.49112666e-02f, -5.90563715e-02f, -8.35346282e-02f, -1.17328212e-01f, 8.93114656e-02f, -5.14654182e-02f, -4.43831980e-02f,
  7.44224563e-02f, 5.45572527e-02f, -1.58547554e-02f, -3.43001597e-02f, -9.04383659e-02f, 5.66349924e-02f, -3.96836139e-02f, 5.02484990e-03f, -7.10128769e-02f, -6.92607239e-02f,
  1.49482712e-01f, 2.20076382e-01f, 3.64583102e-03f, -3.25923264e-02f, -1.16519816e-01f, -2.76010134e-03f, 6.39945939e-02f, 9.83910188e-02f, 9.82914418e-02f, -1.40870837e-02f,
  -2.83443797e-02f, -2.58241668e-02f, 6.49339110e-02f, 6.22426867e-02f, -5.73475249e-02f, -3.35550830e-02f, -3.76672633e-02f, 9.29623493e-04f, 3.40953544e-02f, -3.02291457e-02f,
  -5.99677712e-02f, 8.34158659e-02f, -1.58457384e-02f, -2.17926968e-02f, -8.65782723e-02f, -1.26415372e-01f, 5.52683696e-02f, -5.29302545e-02f, 2.35852078e-02f, -4.45238613e-02f,
  1.92671627e-01f, 1.07810855e-01f, -3.60243432e-02f, 1.78374171e-01f, 1.79598946e-02f, 7.02469349e-02f, -1.28152773e-01f, 2.46978283e-01f, 8.28947574e-02f, 4.74202633e-02f,
  1.01391874e-01f, 2.38701217e-02f, 3.44117694e-02f, 1.56223014e-01f, 2.92693913e-01f, -4.44081575e-02f, 3.24895620e-01f, 4.83636409e-02f, 4.71477695e-02f, 2.49682426e-01f,
  2.06096098e-01f, 2.69777566e-01f, 3.94025519e-02f, 1.85558543e-01f, 1.18392371e-02f, 4.64367159e-02f, 9.12418440e-02f, -5.23160771e-02f, 1.96298465e-01f, 1.15941748e-01f,
  -2.91127246e-02f, 7.54427910e-02f, -2.95006614e-02f, -1.31450638e-01f, 1.27928048e-01f, 1.22283008e-02f, -8.41335878e-02f, -8.87792110e-02f, -6.33706301e-02f, 6.93540201e-02f,
  -4.42185998e-02f, 5.20752557e-02f, 2.71214396e-02f, -3.28757963e-03f, -6.13012053e-02f, -3.66871767e-02f, 3.81525271e-02f, -1.28747210e-01f, -2.01923493e-02f, 8.39995407e-03f,
  -7.62948766e-02f, 9.19130445e-02f, -1.05835013e-02f, -2.74640284e-02f, -2.74396278e-02f, 5.95273450e-02f, -1.06854022e-01f, 5.36219124e-03f, 4.22382839e-02f, 2.07652487e-02f,
  8.54754522e-02f, -8.83768722e-02f, -9.41967964e-03f, -3.74699347e-02f, -2.79770680e-02f, 3.13510559e-02f, -3.71870585e-02f, -8.83523151e-02f, 6.05498382e-04f, -4.02016845e-03f,
  -2.25021373e-02f, 2.00807359e-02f, 1.75554324e-02f, -3.48459184e-02f, 4.60544936e-02f, 1.44411931e-02f, -1.11360468e-01f, 3.27387042e-02f, -1.61221009e-02f, 8.62843636e-03f,
  -2.85959616e-03f, 6.63420036e-02f, 7.83640295e-02f, -1.24773584e-01f, -3.11346166e-02f, 3.79852764e-02f, 1.14298806e-01f, 9.21126232e-02f, -1.95885580e-02f, 3.11931111e-02f,
  5.84542006e-02f, 2.15219215e-01f, -6.32689446e-02f, -4.94000316e-02f, -1.25574603e-04f, 4.07078583e-03f, 3.47690620e-02f, 5.51763885e-02f, 1.05775133e-01f, 7.50403777e-02f,
  1.48667591e-02f, -9.01022106e-02f, 4.40177806e-02f, -1.45370113e-02f, 6.56384528e-02f, 1.08118348e-01f, -7.14883730e-02f, 1.46942101e-02f, 4.34601009e-02f, 1.56398982e-01f,
  4.51681018e-02f, 8.30317810e-02f, 1.09518936e-03f, -9.19074938e-02f, 6.40023127e-02f, -4.96747866e-02f, 1.04277231e-01f, -9.33055431e-02f, 5.06276190e-02f, -3.99082229e-02f,
  -8.08313861e-02f, 1.61163658e-01f, 1.60302803e-01f, -3.04552853e-01f, -5.82473651e-02f, 5.72092384e-02f, -1.27252504e-01f, 2.55917877e-01f, 6.49750307e-02f, 1.01740837e-01f,
  1.46294255e-02f, 5.53339086e-02f, -2.58138962e-03f, 4.80531231e-02f, -7.68552050e-02f, -3.67897600e-02f, -1.39657512e-01f, -7.24251121e-02f, -9.52339396e-02f, -5.48815392e-02f,
  -2.18614340e-01f, -2.40871996e-01f, -1.84641153e-01f, 5.48373815e-03f, -4.19637412e-02f, 1.15501061e-01f, -3.25431347e-01f, 1.04078539e-01f, 2.76566297e-02f, 1.34744704e-01f,
  5.83564304e-02f, 2.50149220e-01f, 2.32695475e-01f, 1.95038512e-01f, 1.02085121e-01f, 5.78088649e-02f, -5.35367131e-02f, -3.18184798e-03f, -3.35523486e-02f, 1.20104831e-02f,
  -1.34445533e-01f, -6.70319423e-02f, 2.86695790e-02f, -2.69067213e-02f, 4.92228381e-02f, 3.71967107e-02f, 4.42156792e-02f, -1.26901150e-01f, 1.73015520e-02f, 2.34785341e-02f,
  -1.24107555e-01f, 2.28736382e-02f, -2.48548295e-02f, -2.49875132e-02f, -7.54241571e-02f, 6.89234808e-02f, 7.80419186e-02f, 1.07877981e-03f, 4.86929156e-02f, -8.04767981e-02f,
  -3.79229039e-02f, 1.08431540e-02f, 5.70220463e-02f, 3.59498002e-02f, 2.97235958e-02f, 7.37307370e-02f, 6.68095483e-04f, 1.44808665e-02f, -2.49008872e-02f, 1.92958489e-02f,
  -7.22693279e-02f, -2.20671799e-02f, -7.50919208e-02f, -1.63645908e-01f, -1.78223580e-01f, 1.24600768e-01f, 2.48252228e-02f, -4.28913236e-02f, -1.42046854e-01f, -1.88366190e-01f,
  1.67596117e-02f, -1.16571210e-01f, -6.29568174e-02f, -1.29067943e-01f, 2.88667604e-02f, -7.13341683e-02f, 9.68145877e-02f, 1.14449643e-01f, -1.04253637e-02f, -7.74915516e-02f,
  -2.22386792e-02f, 2.04275399e-01f, 1.02868542e-01f, 1.78134993e-01f, 9.46992487e-02f, 1.11967102e-01f, 7.56319985e-02f, 4.78713922e-02f, 4.74243285e-03f, 9.06915367e-02f,
  -7.72247389e-02f, -9.06354710e-02f, -1.01423077e-01f, 3.10959127e-02f, -1.77455604e-01f, 2.53499672e-02f, -1.44621879e-01f, -1.19746163e-01f, -1.21506453e-01f, 2.28591003e-02f,
  -1.25658764e-02f, 1.80051886e-02f, -9.60995182e-02f, -3.28050740e-02f, 5.81435002e-02f, 2.39436366e-02f, 1.77340619e-02f, 1.23798884e-01f, -1.98989082e-02f, 2.00929716e-02f,
  -1.60403714e-01f, -3.93359363e-01f, 7.29751121e-03f, 1.15910619e-01f, 7.63239115e-02f, 1.80610240e-01f, 9.32792351e-02f, -2.57618666e-01f, -3.79293263e-01f, -3.48537594e-01f,
  -8.81734863e-03f, 1.08583905e-02f, -1.86394364e-01f, 1.73931390e-01f, 3.63492608e-01f, -9.31845531e-02f, 1.87735516e-03f, 8.60934258e-02f, -6.77168556e-03f, -1.40296444e-01f,
  2.69185565e-02f, 9.76831019e-02f, 1.66456804e-01f, -1.98291093e-02f, -4.54343446e-02f, 2.26763953e-02f, 1.18782915e-01f, 1.25834063e-01f, 1.96608186e-01f, 2.78195560e-01f,
  -5.60904965e-02f, -3.00478131e-01f, 2.19080038e-02f, 3.17670256e-02f, -8.32630247e-02f, -4.43774983e-02f, 1.49974316e-01f, 9.99306813e-02f, 8.33105743e-02f, -7.87597895e-02f,
  -4.57348675e-03f, -4.96197008e-02f, 2.09832774e-03f, 1.44376457e-01f, -1.13198077e-02f, -3.60773839e-02f, -3.71318907e-02f, 1.60426591e-02f, -1.90498270e-02f, -1.13473855e-01f,
  -4.13789228e-02f, -9.84296501e-02f, 1.85925420e-02f, 6.50818720e-02f, 7.56144077e-02f, 4.41228040e-03f, 9.73497182e-02f, 7.58518726e-02f, -8.30189064e-02f, 2.73761004e-02f,
  5.13033830e-02f, -1.54833004e-04f, -1.37205929e-01f, 5.95819065e-03f, -1.07450724e-01f, 5.31024449e-02f, 2.46818736e-02f, 7.63981864e-02f, 4.98358048e-02f, -3.50546874e-02f,
  -7.75266215e-02f, -7.62852132e-02f, -6.36760890e-02f, 6.91157067e-03f, 5.60321333e-03f, -1.52061572e-02f, 4.18048315e-02f, 3.81875543e-05f, 2.78893323e-03f, 1.36781782e-02f,
  -8.26721732e-03f, 1.22722806e-02f, -3.09262499e-02f, -3.36418510e-03f, 3.32813561e-02f, -4.34181951e-02f, -6.51568621e-02f, -7.68039096e-03f, -8.58820900e-02f, 5.35998791e-02f,
  -3.03909242e-01f, -3.38558257e-01f, -7.08345026e-02f, -1.40938591e-02f, 3.32195051e-02f, -1.93892047e-02f, 6.52389005e-02f, -5.35683222e-02f, -1.11151516e-01f, -5.24477847e-02f,
  9.87464748e-03f, 8.59785900e-02f, -2.56163608e-02f, -2.44728271e-02f, 7.17233568e-02f, -6.37376159e-02f, -9.19479504e-02f, -5.37411496e-02f, 5.08867428e-02f, -5.76357283e-02f,
  -1.33238316e-01f, -3.11721060e-02f, 5.04255146e-02f, -2.26669405e-02f, 6.85383901e-02f, -2.00945903e-02f, -4.15083021e-03f, -7.30333924e-02f, 8.57854113e-02f, -2.87461579e-02f,
  2.04537466e-01f, -3.21348071e-01f, 2.23783478e-02f, 3.06682020e-01f, 6.12739138e-02f, -2.03422353e-01f, -1.39914602e-01f, 5.44400178e-02f, 2.81478584e-01f, -1.76058307e-01f,
  -6.55096769e-02f, -7.26168454e-02f, -2.46867105e-01f, -4.94455406e-03f, 2.22005099e-01f, -7.78459460e-02f, -1.42660001e-02f, -4.62947972e-02f, 9.45056453e-02f, 3.25128138e-02f,
  1.35030136e-01f, -9.82284248e-02f, -2.06641138e-01f, -9.95204002e-02f, 3.10926121e-02f, -1.59337893e-02f, -1.49981007e-01f, -1.46178529e-01f, -2.11892679e-01f, -1.50594383e-01f,
  1.02444857e-01f, 3.79462838e-02f, -3.88216996e-03f, 2.09351853e-02f, -3.70013788e-02f, -9.75969657e-02f, -2.26568021e-02f, -6.54799491e-02f, 1.13597944e-01f, 3.40559743e-02f,
  4.53409515e-02f, 1.31104933e-02f, 2.70707905e-02f, 6.51425263e-03f, 2.88073346e-03f, 4.17892709e-02f, 4.38463911e-02f, 1.10894643e-01f, -1.20708428e-01f, -9.69401225e-02f,
  8.18810426e-03f, 5.33311553e-02f, 1.03037558e-01f, -2.88348347e-02f, 1.04327448e-01f, 8.57659951e-02f, -3.23702395e-02f, -5.92612848e-02f, -1.14285700e-01f, 9.43005383e-02f,
  -1.27221420e-01f, -7.71700591e-02f, 1.82549958e-03f, 3.02014197e-03f, -6.37000601e-04f, 5.34997471e-02f, 1.11976020e-01f, -4.40340117e-02f, 9.26911533e-02f, 3.18870917e-02f,
  3.78920473e-02f, 5.33403940e-02f, -5.50034419e-02f, 2.76572537e-02f, -6.34750798e-02f, 9.50199552e-03f, 3.62565331e-02f, 3.17354910e-02f, 1.03992201e-01f, 8.99193361e-02f,
  5.57419620e-02f, 1.80543903e-02f, -1.23518020e-01f, 3.72384153e-02f, 4.71749716e-02f, -1.36657255e-02f, 4.12242375e-02f, -2.58682575e-02f, 1.39290959e-01f, -8.86099339e-02f,
  -7.98431635e-02f, -3.07670981e-01f, -4.01457772e-02f, 8.86561200e-02f, 1.81281809e-02f, 8.56315866e-02f, -9.63569246e-03f, 4.56478037e-02f, -4.75919917e-02f, -1.01319477e-02f,
  1.28214797e-02f, 8.60905424e-02f, 7.48290196e-02f, 8.79713967e-02f, -7.01275840e-02f, 1.94959044e-02f, 5.43451719e-02f, 2.63725482e-02f, 1.28625042e-03f, -2.67061051e-02f,
  -1.76381432e-02f, 1.13019189e-02f, 1.52916946e-02f, 9.48188677e-02f, 1.40455619e-01f, -6.19885474e-02f, 1.11467890e-01f, -1.25661120e-01f, 2.80069578e-02f, 4.27267281e-03f,
  2.83479035e-01f, -9.24510807e-02f, 2.15650396e-03f, -1.94319189e-01f, 1.33796141e-01f, 1.12907410e-01f, 6.34947866e-02f, -2.80936688e-01f, -2.41814703e-01f, -2.81499147e-01f,
  -3.69430967e-02f, 4.97137532e-02f, 1.54144615e-01f, 2.41914974e-03f, 3.60476017e-01f, 1.33465692e-01f, -3.06951534e-02f, 1.23145267e-01f, 7.94582218e-02f, -5.79994246e-02f,
  -3.67796570e-02f, -4.99412082e-02f, 4.18969356e-02f, -3.07911187e-02f, 1.30738571e-01f, -6.12858236e-02f, -5.06155603e-02f, 4.72238548e-02f, -5.41637950e-02f, 4.10167463e-02f,
  2.19390094e-02f, 1.75636839e-02f, 2.29474697e-02f, 7.53188087e-03f, -6.21005036e-02f, 1.55531438e-02f, 3.37833352e-02f, 1.75848454e-01f, -6.61914796e-02f, -8.21070969e-02f,
  5.45357950e-02f, -8.88236612e-03f, -8.65246877e-02f, 7.11729825e-02f, 2.10666321e-02f, -1.55267239e-01f, -6.33964315e-02f, -1.04275374e-02f, -1.12253707e-02f, 3.20999138e-02f,
  1.03213172e-02f, 5.83722554e-02f, -3.32405120e-02f, -4.10852581e-02f, -1.39861837e-01f, -4.61717844e-02f, 2.58903559e-02f, 1.04080550e-01f, -7.84546658e-02f, 2.42570583e-02f,
  9.51632485e-03f, 5.93400002e-02f, 1.01468295e-01f, 1.00381933e-01f, 1.19823948e-01f, 2.54581869e-03f, 8.96593183e-02f, -1.08966723e-01f, 6.66012987e-02f, 1.57736856e-02f,
  -3.02175768e-02f, 6.19319305e-02f, -9.91280284e-03f, -1.43418163e-02f, 9.15649608e-02f, 2.73824558e-02f, 1.14316374e-01f, -7.43233487e-02f, -5.49941808e-02f, -2.59805731e-02f,
  -7.55561190e-03f, 4.52054627e-02f, 1.18593462e-02f, -1.19241402e-01f, -7.12578744e-02f, 1.64805800e-02f, -1.26562312e-01f, 4.69407514e-02f, -4.29621562e-02f, 9.72257480e-02f,
  1.98713522e-02f, -9.14128199e-02f, 2.28914842e-02f, -6.19036779e-02f, 1.19202077e-01f, 9.36089754e-02f, 9.84095186e-02f, -8.21295604e-02f, -8.00480098e-02f, 1.66830828e-03f,
  -8.37137103e-02f, 3.54373492e-02f, 1.09257568e-02f, -9.68294144e-02f, -2.86310737e-04f, -8.21891949e-02f, -5.73809259e-02f, 1.28893079e-02f, -2.46961620e-02f, 8.36080387e-02f,
  -5.67108355e-02f, -2.49836054e-02f, 3.96913029e-02f, -1.95792578e-02f, -1.44217595e-01f, 6.70916066e-02f, 1.77614056e-02f, -5.75227626e-02f, 4.51982990e-02f, -4.43902649e-02f,
  3.50354433e-01f, -2.60121197e-01f, -1.44780993e-01f, 2.14451909e-01f, 3.16972911e-01f, 2.43593380e-01f, 1.29382715e-01f, 1.62214085e-01f, 6.33827001e-02f, -2.44482428e-01f,
  -6.66082662e-04f, -2.51164258e-01f, -2.44640231e-01f, 1.50496006e-01f, 1.82639718e-01f, -1.29008219e-01f, 2.46858820e-01f, 9.70881805e-02f, 1.56148255e-01f, 9.50164124e-02f,
  2.11382166e-01f, 2.90863633e-01f, 1.39826998e-01f, 7.49480128e-02f, 2.23674372e-01f, 7.43452236e-02f, 5.87434396e-02f, -5.93029819e-02f, 1.67980850e-01f, 4.53658216e-02f,
  -5.15528880e-02f, 1.89961772e-02f, -4.18410264e-02f, 2.43578218e-02f, 1.64307952e-02f, -5.95239140e-02f, -1.23093501e-01f, -5.90325042e-04f, 8.78024027e-02f, 2.31893230e-02f,
  -5.90185169e-03f, 1.11841336e-01f, 3.89870293e-02f, -3.25605646e-02f, -3.20614167e-02f, 3.33825871e-02f, 1.78966001e-02f, -2.15236843e-02f, 3.73483375e-02f, 1.54993618e-02f,
  1.30487280e-02f, 3.35266953e-03f, 6.28656670e-02f, -4.89233583e-02f, 2.83440351e-02f, 7.24672452e-02f, 1.54177081e-02f, -1.08492099e-01f, 2.23211013e-02f, 3.57074030e-02f,
  -2.57338788e-02f, -5.83756268e-02f, 2.59227604e-02f, 3.37520167e-02f, 7.68249184e-02f, 1.11555800e-01f, 4.18088539e-03f, 3.61190625e-02f, -1.18877310e-02f, -6.12167045e-02f,
  5.55174910e-02f, 2.91224439e-02f, -1.53635656e-02f, -8.35651755e-02f, 2.85773557e-02f, 2.92366687e-02f, -6.81774840e-02f, 1.26171494e-02f, 9.94596817e-03f, -3.17322165e-02f,
  -1.26681319e-02f, 3.73478942e-02f, -4.98509817e-02f, 4.55353372e-02f, 4.56473008e-02f, -6.81343004e-02f, -4.89156134e-02f, -2.85431184e-02f, -8.57039448e-03f, -3.96124646e-02f,
  -3.23919177e-01f, -2.88394928e-01f, -5.34623191e-02f, 7.83307885e-04f, -1.76688999e-01f, -7.27844238e-02f, -1.26977608e-01f, 8.82466808e-02f, -1.15009002e-01f, 6.60772845e-02f,
  -1.53392088e-02f, -5.78828566e-02f, -7.39899576e-02f, 9.11314040e-03f, 1.07330503e-02f, -4.15890850e-02f, 2.06942041e-03f, -8.42854157e-02f, -9.02510136e-02f, 8.18566903e-02f,
  -1.05250988e-03f, -1.84994992e-02f, 9.70513672e-02f, 1.14720248e-01f, 6.80745766e-02f, -2.07042266e-02f, -9.38881040e-02f, -1.10801170e-02f, 8.80363062e-02f, -1.39959473e-02f,
  2.35614330e-01f, -1.43972278e-01f, -2.27402359e-01f, -1.80929735e-01f, -3.48374486e-01f, -1.84425041e-01f, -9.61706638e-02f, -2.75890827e-01f, -1.54318325e-02f, 8.64585415e-02f,
  -6.48620129e-02f, -6.38900325e-02f, 2.91000396e-01f, -3.48922536e-02f, 9.90046561e-02f, 2.31306165e-01f, 9.24229622e-02f, 3.45031098e-02f, 3.21213305e-02f, -4.56409529e-02f,
  -4.79399301e-02f, 7.64616281e-02f, -1.14625789e-01f, -1.04539946e-01f, -2.77845114e-01f, -1.03411153e-01f, 6.40201494e-02f, -2.49317244e-01f, -1.77950948e-01f, -1.47860080e-01f,
  -4.99049053e-02f, 2.32211053e-02f, -1.12361722e-01f, 1.33595377e-01f, 2.02965215e-02f, -2.56035384e-02f, -9.49118361e-02f, -2.36684419e-02f, -5.86581342e-02f, 5.52894138e-02f,
  5.40961465e-03f, 5.83827794e-02f, 1.27548009e-01f, 3.49566974e-02f, 3.07504553e-02f, -5.66896535e-02f, -1.05352879e-01f, 7.45887682e-02f, -8.71987790e-02f, 9.70631186e-03f,
  -3.41408551e-02f, 9.81733575e-02f, 4.36117669e-04f, -2.35669967e-02f, -1.38803318e-01f, 6.21223077e-02f, -3.76085704e-03f, -7.96997547e-02f, -6.04252331e-02f, -4.35418859e-02f,
  -1.01359691e-02f, 1.05294049e-01f, 5.28772026e-02f, -3.86693813e-02f, 9.05563682e-02f, -9.97176617e-02f, 7.89005980e-02f, 1.55070135e-02f, -2.03667954e-02f, -8.37985426e-02f,
  4.46357615e-02f, -1.27579883e-01f, -6.23965338e-02f, 2.09367257e-02f, 2.17297569e-01f, 8.10793042e-03f, 8.03715084e-03f, 5.85887767e-03f, -6.33056741e-03f, 4.46640253e-02f,
  -6.39138818e-02f, 1.14933878e-01f, -9.26708654e-02f, 7.52443373e-02f, -4.54304554e-02f, -7.01314434e-02f, 7.22730085e-02f, 1.16199935e-02f, -3.44621725e-02f, -1.01141483e-01f,
  -5.20693585e-02f, -3.80700417e-02f, -9.32212472e-02f, 8.46440271e-02f, -3.71794775e-02f, -1.32831469e-01f, 2.80263065e-03f, -9.11941379e-02f, 1.78310741e-02f, 2.59751454e-02f,
  -3.72682363e-02f, 7.80386804e-03f, -2.57206019e-02f, 8.68392736e-03f, -2.08434518e-02f, -1.12606712e-01f, 1.19649414e-02f, 7.94050619e-02f, -1.25461584e-02f, -3.69507410e-02f,
  8.17747116e-02f, 9.14182588e-02f, 1.28492683e-01f, 9.20086652e-02f, 1.12996913e-01f, 8.26445892e-02f, 4.80094105e-02f, -8.62542093e-02f, -1.08751534e-02f, 6.35079890e-02f,
  1.79680169e-01f, -4.69219929e-04f, -2.06109434e-01f, 1.04988769e-01f, 1.91634268e-01f, 1.71596885e-01f, 1.68038040e-01f, 8.31704736e-02f, 2.96564251e-01f, 6.05885014e-02f,
  1.48576155e-01f, -7.58315325e-02f, -1.39171496e-01f, 2.77372569e-01f, 1.78129405e-01f, 6.75770864e-02f, 2.60546684e-01f, 1.33175790e-01f, 8.60831365e-02f, 2.26827502e-01f,
  1.45542458e-01f, 3.15997094e-01f, -2.23376632e-01f, -4.98943217e-02f, 7.35853761e-02f, -8.33794698e-02f, -3.40240747e-02f, -2.47805238e-01f, 7.01608285e-02f, 4.79284115e-02f,
  6.95678219e-02f, 1.20917186e-01f, -4.29516770e-02f, -1.14623576e-01f, -7.24687278e-02f, -1.22972265e-01f, 1.05369156e-02f, -1.55954018e-01f, -8.18837658e-02f, -4.97256871e-03f,
  -6.10689633e-02f, 1.07031371e-02f, 4.75604981e-02f, 7.98772722e-02f, -2.31154938e-03f, 9.56965461e-02f, -1.61548648e-02f, 2.53629219e-02f, -2.44572293e-02f, -8.08270648e-03f,
  4.42788228e-02f, -1.16394414e-02f, 4.14520781e-03f, 3.68068670e-03f, -6.13382868e-02f, 1.30684659e-01f, 3.21165100e-02f, -4.13521118e-02f, 4.96467203e-02f, 9.35825482e-02f,
  -1.16362292e-02f, -4.53686416e-02f, -7.53888860e-02f, 7.70942345e-02f, -1.34595651e-02f, -4.21086922e-02f, 5.68569340e-02f, -5.52726872e-02f, -1.24735059e-02f, 1.13469116e-01f,
  8.89078677e-02f, -3.69677283e-02f, 6.40158951e-02f, -8.26755539e-03f, 1.53387427e-01f, 3.33116413e-03f, -1.67108387e-01f, -2.29125400e-03f, 7.37090409e-02f, 1.60773426e-01f,
  5.34535665e-03f, -1.58069714e-03f, -2.88279299e-02f, -2.24718228e-02f, 1.28202602e-01f, -9.51230433e-03f, 1.28879517e-01f, -7.38420896e-03f, 1.00777157e-01f, -4.72511388e-02f,
  2.33550165e-02f, 1.79347470e-01f, 5.19051366e-02f, -6.91365004e-02f, -2.81881988e-02f, 8.36315379e-02f, 4.17673141e-02f, 7.84565732e-02f, -7.68612772e-02f, 8.89016017e-02f,
  -5.88704124e-02f, -3.01376209e-02f, 1.25216663e-01f, -3.04686837e-02f, 8.79394636e-02f, 2.38236617e-02f, 8.92347917e-02f, -6.86152205e-02f, 1.61583554e-02f, -7.69510716e-02f,
  5.74290901e-02f, 1.18518732e-02f, 6.35687634e-02f, -7.91900158e-02f, -2.05896180e-02f, -8.01320150e-02f, 7.90013000e-02f, -8.11299235e-02f, 2.25028209e-02f, -5.30880019e-02f,
  -4.76006925e-01f, 9.09485966e-02f, -2.18171075e-01f, 1.84831806e-02f, -1.64888024e-01f, -1.81200758e-01f, 1.12436846e-01f, 1.50714979e-01f, -5.22354692e-02f, 3.60779583e-01f,
  3.33900303e-01f, -1.74043283e-01f, 2.95324802e-01f, 1.51010782e-01f, -4.41112608e-01f, 4.75024013e-03f, -8.35208222e-02f, 6.73826784e-02f, -8.89958292e-02f, -1.98831763e-02f,
  -5.42328395e-02f, 1.02488384e-01f, -5.67697175e-02f, 7.40751922e-02f, -3.10077667e-02f, -5.57721741e-02f, 2.72001982e-01f, 6.30597100e-02f, 4.22403738e-02f, -6.49941042e-02f,
  6.48408532e-02f, 3.08188554e-02f, 6.64553642e-02f, -5.28305769e-02f, -6.48921728e-03f, -2.30795797e-03f, 3.69545142e-03f, -9.15093124e-02f, -8.65351781e-02f, -6.81813434e-02f,
  -1.95208061e-02f, -5.48298061e-02f, -4.73615564e-02f, -5.95106510e-03f, -1.01497635e-01f, -4.64947969e-02f, -8.42268765e-02f, -7.34736249e-02f, 4.51411679e-03f, -3.52393202e-02f,
  -1.03840597e-01f, -2.13231612e-02f, 4.33985777e-02f, -5.87223172e-02f, -3.37703228e-02f, 9.10056755e-02f, -7.40042946e-04f, 7.99068715e-03f, -1.11593977e-01f, -8.89100134e-02f,
  -6.71061724e-02f, -7.44767562e-02f, 1.52422776e-02f, -7.34826681e-05f, -2.23206524e-02f, 1.38366237e-01f, 4.58161114e-03f, 2.47835163e-02f, -3.54652256e-02f, 2.48692874e-02f,
  -1.57158375e-02f, 5.54127945e-03f, 8.59462917e-02f, -9.77755059e-03f, -1.36599159e-02f, 1.60888694e-02f, -7.41962641e-02f, 7.68260360e-02f, -6.63279593e-02f, 1.00339064e-03f,
  1.60716176e-01f, -7.70500600e-02f, 6.98409230e-02f, 7.02560395e-02f, -8.78126733e-03f, 2.64452603e-02f, 4.33975644e-02f, -3.54341753e-02f, 4.53546457e-02f, -4.73369621e-02f,
  1.00860782e-01f, 1.59658454e-02f, 5.36648743e-02f, -2.33559851e-02f, 5.36076091e-02f, -4.12930660e-02f, 6.52135983e-02f, -7.86127895e-02f, 3.73534709e-02f, -6.78890711e-03f,
  -3.16477828e-02f, 7.00174496e-02f, 1.04934759e-02f, 1.12979524e-02f, -8.35616216e-02f, -1.96675602e-02f, 9.49542448e-02f, -6.81256354e-02f, -7.43394578e-03f, -5.68772331e-02f,
  -3.00110523e-02f, -4.82214913e-02f, -4.84804027e-02f, 1.12134986e-01f, 8.50906223e-02f, -8.07176344e-03f, -1.13900341e-01f, 4.27868441e-02f, -1.89194027e-02f, 6.39939085e-02f,
  1.56278238e-01f, -8.62030499e-03f, 4.04080078e-02f, 1.86843853e-02f, -1.59062505e-01f, -5.40130772e-03f, 2.95048326e-01f, -1.41020983e-01f, -2.45005056e-01f, 8.13546553e-02f,
  2.81702608e-01f, -4.03754413e-02f, 2.55145937e-01f, 2.53198266e-01f, 2.20049277e-01f, 2.81949818e-01f, 2.90206105e-01f, 1.64680168e-01f, -1.60713494e-01f, 1.58787638e-01f,
  1.06719341e-02f, 1.78409949e-01f, 2.88815737e-01f, -6.55663200e-03f, 1.77901432e-01f, -1.36901021e-01f, 2.13367045e-02f, -7.62037188e-02f, -4.44434620e-02f, 6.58495054e-02f,
  1.16165660e-01f, 5.59975840e-02f, 4.16251682e-02f, 5.67733049e-02f, 5.36619872e-02f, 1.00027837e-01f, 1.43781692e-01f, 2.18729395e-02f, -9.57537144e-02f, 8.00845847e-02f,
  3.18897590e-02f, -1.41061366e-01f, -6.40598163e-02f, 3.38907633e-03f, -9.63442177e-02f, -6.21432327e-02f, -1.20395273e-01f, 4.51709181e-02f, -7.98626337e-03f, -9.49435867e-03f,
  -4.99997400e-02f, 3.91019993e-02f, -6.92098066e-02f, 1.11106381e-01f, -1.52816728e-01f, -2.61969655e-03f, 2.20099278e-02f, -8.34365413e-02f, -5.86426118e-03f, -1.02639578e-01f,
  -7.90489987e-02f, -1.56958234e-02f, -1.35858613e-03f, 7.21112788e-02f, -5.46555519e-02f, 2.90447231e-02f, 5.69780320e-02f, -1.87837072e-02f, -5.37008513e-03f, -1.08831242e-01f,
  -3.02297994e-02f, 3.98524292e-02f, 1.98901817e-02f, -1.16296476e-02f, -5.61733022e-02f, -5.96558154e-02f, -2.83519588e-02f, 5.00139855e-02f, -8.29255059e-02f, -7.64544532e-02f,
  -4.58743945e-02f, 2.79619973e-02f, -4.64127362e-02f, 5.59763126e-02f, 9.81850401e-02f, -6.77927490e-03f, 7.09919026e-03f, -7.80401379e-02f, 2.79377610e-03f, -5.98001182e-02f,
  3.26030701e-02f, 8.24594405e-03f, 4.11953330e-02f, -2.56321616e-02f, 3.85754406e-02f, 6.75109923e-02f, -1.46374069e-02f, 4.37741540e-02f, -4.20586355e-02f, 1.00712962e-01f,
  6.44348040e-02f, 2.81654149e-02f, 4.72932234e-02f, 1.97603852e-02f, -1.26794958e-02f, 3.65145179e-03f, 1.08690776e-01f, 5.34235984e-02f, -3.22001278e-02f, 1.09672658e-01f,
  5.46385311e-02f, 5.08529171e-02f, 4.22092043e-02f, -4.91176674e-04f, 8.99864454e-03f, 5.50571606e-02f, 1.57129560e-02f, -1.89944599e-02f, -5.16544618e-02f, -1.23035915e-01f,
  2.00779483e-01f, -3.52673829e-01f, 2.83084154e-01f, 2.32003719e-01f, 1.91086844e-01f, -1.56882964e-02f, 4.28538211e-02f, -6.80141374e-02f, -9.08048172e-03f, -2.39503220e-01f,
  -9.57217887e-02f, 1.02369420e-01f, -2.18419895e-01f, -4.43606488e-02f, 1.57028422e-01f, -2.13781357e-01f, 6.36567026e-02f, 1.33578598e-01f, 4.54881825e-02f, 1.45641983e-01f,
  1.27533987e-01f, -1.12494446e-01f, 1.43316939e-01f, -9.45982262e-02f, 1.07293077e-01f, 1.02799080e-01f, -1.34034023e-01f, -4.36383523e-02f, 3.39588337e-02f, 3.76261808e-02f,
  -3.71780731e-02f, -5.09562977e-02f, 4.48571853e-02f, -5.48171923e-02f, 6.34318292e-02f, -8.47339854e-02f, 1.00320086e-01f, 2.06245910e-02f, -2.03875992e-02f, 1.21540949e-01f,
  -9.01945755e-02f, 8.04028735e-02f, 4.17934097e-02f, -1.83189623e-02f, -2.54010521e-02f, 1.52254831e-02f, 4.18060422e-02f, 2.92265937e-02f, 1.32843137e-01f, 1.14620566e-01f,
  1.06188357e-01f, 1.03953868e-01f, 6.29097745e-02f, -7.42912069e-02f, 9.18147042e-02f, -6.93856226e-03f, 1.03512757e-01f, 1.72287342e-03f, 5.07192835e-02f, -7.23566711e-02f,
  -2.74347831e-02f, -4.88366038e-02f, -1.03828736e-01f, -1.12160690e-01f, -2.66037434e-02f, 1.17680952e-02f, -3.53928804e-02f, 2.12510582e-02f, 8.23225975e-02f, 6.34728000e-02f,
  -2.14772355e-02f, -1.58541044e-03f, 8.06304589e-02f, -4.89419384e-04f, 1.18202297e-02f, -4.20332402e-02f, 1.12683319e-01f, 6.88405856e-02f, -8.92092008e-03f, 7.49078300e-03f,
  -5.76075800e-02f, 4.85182926e-02f, -1.12541825e-01f, 2.99399104e-02f, -6.24981262e-02f, 5.06505789e-03f, -6.20721206e-02f, 1.04511967e-02f, -3.30339000e-02f, 7.94828385e-02f,
  -4.00695413e-01f, -3.64708215e-01f, -7.01919273e-02f, 4.15898524e-02f, -8.59829634e-02f, -1.01018347e-01f, 4.38206270e-02f, 8.65495019e-03f, -5.34289554e-02f, -8.71261060e-02f,
  1.63843948e-02f, 8.91061574e-02f, -7.32897744e-02f, -4.34405468e-02f, -1.31398141e-01f, -7.42887259e-02f, -3.01325675e-02f, 2.70383395e-02f, -1.91504974e-02f, -6.75197020e-02f,
  -5.92503250e-02f, -3.51778045e-02f, 9.80135426e-03f, 9.37296227e-02f, -1.09704509e-01f, 6.29392685e-03f, -3.29796486e-02f, 2.34719943e-02f, 1.09014101e-02f, -1.35592371e-01f,
  8.19301382e-02f, 2.93531984e-01f, 4.52733375e-02f, 1.21429361e-01f, -1.03263035e-01f, 1.10014221e-02f, -4.98019643e-02f, 1.00009345e-01f, -1.36176065e-01f, 2.30868496e-02f,
  -3.40549052e-02f, 2.45761089e-02f, -2.74871409e-01f, 2.82896817e-01f, 2.43025124e-01f, -1.65589958e-01f, 2.54572332e-01f, 1.30655199e-01f, -1.36436790e-01f, 1.81897134e-01f,
  -8.78077522e-02f, 2.24636778e-01f, 4.28253057e-04f, 1.51203886e-01f, 1.70398533e-01f, 1.63301062e-02f, 2.29656458e-01f, -9.18792412e-02f, 2.04819679e-01f, 1.72045335e-01f,
  -5.64124174e-02f, 1.61923151e-02f, 6.35463884e-03f, -1.91927031e-02f, -9.21003707e-03f, -1.53560370e-01f, -2.82973871e-02f, 6.85657412e-02f, 3.20872548e-03f, 8.71851817e-02f,
  3.80596444e-02f, 6.07038215e-02f, 3.10839321e-02f, -1.05779275e-01f, 1.08811960e-01f, 7.78160233e-04f, -2.55545769e-02f, -8.58560670e-03f, 5.87177239e-02f, -1.56644378e-02f,
  -1.09952316e-01f, 1.53698832e-01f, 1.12282485e-01f, 7.56092817e-02f, 8.43484253e-02f, 7.79997110e-02f, 1.30680650e-01f, 3.88374887e-02f, 3.12681906e-02f, 1.86744377e-01f,
  9.61457863e-02f, 5.17092384e-02f, 3.52145918e-02f, 1.90330409e-02f, 5.93579412e-02f, 5.97027726e-02f, 9.63643044e-02f, 4.15545888e-02f, 6.58995435e-02f, -8.87483135e-02f,
  -6.14078902e-03f, -4.25422080e-02f, -3.69265079e-02f, 5.72690032e-02f, 1.09426547e-02f, -1.30109712e-01f, -1.64447725e-03f, -7.58042419e-03f, 2.19259989e-02f, -2.06558537e-02f,
  -7.71166757e-02f, 2.17445605e-02f, 1.01490496e-02f, -2.29541212e-03f, 1.55549608e-02f, 1.88920591e-02f, -1.46413734e-03f, -1.31777590e-02f, -7.94365257e-02f, 2.00037565e-02f,
  1.07931860e-01f, 1.79627478e-01f, 3.07834055e-02f, 8.62390455e-03f, -3.56165171e-02f, 1.82980727e-02f, 3.89926555e-03f, 4.92650531e-02f, 1.15608662e-01f, 1.28685394e-02f,
  7.57622048e-02f, -2.00416166e-02f, 7.99381956e-02f, 1.91855766e-02f, 4.33291979e-02f, 2.60687601e-02f, 7.87287429e-02f, -1.01101957e-01f, 1.06107637e-01f, 1.13483936e-01f,
  3.86432037e-02f, -2.17430554e-02f, 1.06957108e-01f, 2.61867400e-02f, 6.82363883e-02f, 4.59017837e-03f, 6.57284632e-02f, 2.57163271e-02f, -4.62853834e-02f, 6.95538819e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.54010969e-01f, 1.61458090e-01f, 2.55757779e-01f, 2.08384916e-01f, 2.68850535e-01f, 3.37157488e-01f, 1.97861612e-01f, 1.92027956e-01f, 2.77282536e-01f, 2.32847705e-01f,
  2.00421214e-01f, 2.04230040e-01f, 2.13214174e-01f, 3.66150230e-01f, 1.93694487e-01f, 1.76630661e-01f, 1.86248347e-01f, 1.34474650e-01f, 2.20398188e-01f, 3.02640200e-01f,
  2.77503133e-01f, 2.83169240e-01f, 2.32603014e-01f, 1.57792270e-01f, 3.84495169e-01f, 2.46870786e-01f, 1.09756567e-01f, 2.01154411e-01f, 1.17442481e-01f, 2.33318806e-01f,
  1.00358285e-01f, 2.50161976e-01f, 1.54106721e-01f, 8.18121061e-02f, 3.23563129e-01f, 2.57627219e-01f, 1.84298560e-01f, 2.20522955e-01f, 3.04237366e-01f, 1.57651246e-01f,
  3.08458090e-01f, 1.67922437e-01f, 1.48078859e-01f, 2.56517231e-01f, 1.32692635e-01f, 1.76761165e-01f, 1.20624006e-01f, 1.82196051e-01f, 2.60103196e-01f, 1.87096089e-01f,
  2.79931128e-01f, 2.79903531e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.42059661e-02f, -1.30014777e-01f, 1.20705575e-01f, -1.55059472e-01f, 4.25537638e-02f, 3.24492380e-02f, -1.47414595e-01f, -4.09856103e-02f, 1.72744513e-01f, 8.78876448e-02f,
  -5.77821545e-02f, -6.32563978e-02f, 1.27351433e-01f, -2.37723425e-01f, -1.10847577e-01f, -2.28862837e-02f, 2.30145946e-01f, -1.05242543e-01f, 1.52456239e-01f, 1.06996886e-01f,
  8.31723884e-02f, 1.25392780e-01f, 2.15043500e-01f, -3.79927382e-02f, -2.18212038e-01f, -4.85066362e-02f, -2.30192184e-01f, 7.28411153e-02f, 1.70824394e-01f, 5.23665436e-02f,
  -1.45950690e-01f, -2.74032056e-02f, -7.51489997e-02f, 2.20508978e-01f, 2.26655290e-01f, -7.45570511e-02f, -4.36547957e-02f, -1.19915277e-01f, 1.43094793e-01f, 7.64166489e-02f,
  8.20625201e-02f, 6.89892694e-02f, -9.62407142e-02f, 2.58168191e-01f, -1.57472342e-01f, -6.38848096e-02f, 1.12553246e-01f, -2.67259330e-01f, 2.27589339e-01f, -2.46025756e-01f,
  -4.92126234e-02f, -2.45788544e-01f, -1.20561846e-01f, -5.82545176e-02f, -1.16111137e-01f, -4.96401042e-02f, -1.13201186e-01f, -1.26540378e-01f, 8.08216333e-02f, 9.89069268e-02f,
  2.41365761e-01f, -1.19706029e-02f, -7.94374496e-02f, 1.88739821e-02f, 2.00646021e-03f, -9.79559124e-02f, -1.35223895e-01f, 1.75800901e-02f, -6.78656921e-02f, -1.29080281e-01f,
  1.47788554e-01f, -2.04975441e-01f, -1.80020835e-02f, 1.22491658e-01f, -5.39569817e-02f, 1.58998519e-01f, 9.59685668e-02f, -1.87652677e-01f, -1.25777096e-01f, 1.43134534e-01f,
  -2.36379594e-01f, -1.23297431e-01f, 2.62899101e-01f, 1.56969935e-01f, -9.79360864e-02f, -8.45624954e-02f, -2.01818272e-02f, -8.06706399e-02f, 3.40616591e-02f, 3.80573384e-02f,
  -1.43252283e-01f, 1.96556151e-01f, 1.62019178e-01f, -6.97775781e-02f, -1.10160254e-01f, -3.22082788e-02f, 4.31495532e-02f, 1.39851153e-01f, 8.81885514e-02f, 5.81444167e-02f,
  -2.65787959e-01f, 8.51945952e-02f, 3.74237075e-02f, 1.14723258e-01f, 1.24805622e-01f, 1.22609571e-01f, 3.25513892e-02f, 1.70378685e-01f, -3.37571418e-03f, 1.29010722e-01f,
  7.27891997e-02f, -8.55002701e-02f, 2.24977627e-01f, -1.08549178e-01f, -2.62259960e-01f, -1.45752639e-01f, 9.36169084e-03f, -6.24016933e-02f, 5.46843521e-02f, -5.54809496e-02f,
  -1.41209945e-01f, 8.36278349e-02f, -1.75532371e-01f, -6.07709326e-02f, 1.00719474e-01f, -1.94847241e-01f, -2.10151095e-02f, 7.27707893e-02f, -9.71515104e-03f, -4.13077399e-02f,
  1.02466114e-01f, -8.62453356e-02f, -1.07677385e-01f, -6.56755716e-02f, 1.17285907e-01f, -2.69872516e-01f, 1.47982255e-01f, -9.90565866e-02f, -1.45381326e-02f, 1.66791022e-01f,
  -1.12915769e-01f, -7.61999935e-02f, 4.97274399e-02f, -2.71087158e-02f, -1.49586394e-01f, 6.55435538e-03f, 2.78915584e-01f, 2.84589618e-01f, -2.03982651e-01f, -3.10536593e-01f,
  9.79825333e-02f, 1.91334262e-02f, 4.06923406e-02f, 9.88457575e-02f, 1.06481895e-01f, 1.60298005e-01f, 2.07875464e-02f, -8.60407725e-02f, -6.08065017e-02f, 5.17219640e-02f,
  3.16680521e-02f, -8.15403536e-02f, -6.90485016e-02f, 2.17071608e-01f, -2.01738626e-01f, -4.43443358e-02f, 1.32696137e-01f, -2.85324492e-02f, 2.41877779e-01f, 2.05832243e-01f,
  -9.32064354e-02f, 1.50304720e-01f, 2.12776780e-01f, 2.72151828e-01f, 1.72563661e-02f, -5.75439371e-02f, 1.03787355e-01f, -1.64968327e-01f, 2.11498234e-02f, -1.46253943e-01f,
  -3.73076722e-02f, 8.33171979e-02f, 6.05114177e-02f, 5.72739951e-02f, -8.96545723e-02f, 2.15380475e-01f, -1.87466636e-01f, -1.03434652e-01f, 7.52772838e-02f, -3.72113362e-02f,
  9.52382907e-02f, -1.28842682e-01f, -7.65201673e-02f, 1.05023168e-01f, 4.59452756e-02f, 1.37524635e-01f, 1.06549360e-01f, -6.95907176e-02f, -2.08786547e-01f, 1.07881151e-01f,
  -7.16592669e-02f, -9.17690620e-02f, -7.72135705e-02f, -1.65435955e-01f, 5.85360825e-02f, 6.32015057e-03f, 2.74029071e-03f, -1.09555081e-01f, 5.47861196e-02f, 1.39548443e-02f,
  -1.71311766e-01f, 1.10742547e-01f, 2.65706121e-03f, 2.01796517e-01f, -1.31521076e-01f, -1.06731154e-01f, 2.02277482e-01f, 1.82672828e-01f, 5.33865467e-02f, -2.93237600e-03f,
  -3.75272557e-02f, 1.31632432e-01f, -2.13174626e-01f, -9.46637169e-02f, 9.09339190e-02f, 1.40406579e-01f, 7.93129299e-03f, -5.63556403e-02f, 4.90038507e-02f, 9.47168693e-02f,
  -2.18211815e-01f, 7.31720077e-03f, 3.08486875e-02f, -1.74638167e-01f, -3.01989000e-02f, -1.30108997e-01f, -8.86434689e-04f, -1.84077114e-01f, -2.58702546e-01f, -9.36483517e-02f,
  -1.28339469e-01f, 7.60096237e-02f, 2.18852147e-01f, 1.39085799e-01f, -1.82822898e-01f, -9.44755450e-02f, 2.00123876e-01f, -3.36263562e-03f, -8.30509290e-02f, -9.99256503e-03f,
  8.88722762e-02f, -1.12047724e-01f, 1.48006812e-01f, 9.41925198e-02f, 7.91289359e-02f, 6.73350766e-02f, -1.63271707e-02f, -6.12391494e-02f, 1.01364426e-01f, -5.46725504e-02f,
  -1.77583024e-01f, -1.72209010e-01f, 3.15512925e-01f, -1.16675235e-01f, -9.07560736e-02f, 1.56189455e-02f, 4.60833572e-02f, 9.69129428e-02f, 9.01673585e-02f, 1.15319319e-01f,
  -1.05798304e-01f, 7.92467594e-02f, -1.99686378e-01f, 1.07958518e-01f, 2.33180299e-01f, 4.41914424e-02f, 8.89342129e-02f, -2.07770690e-01f, 8.68024081e-02f, -1.22645050e-01f,
  1.83419988e-01f, -1.06533401e-01f, 3.18304040e-02f, 1.27813503e-01f, 3.72087769e-02f, -2.38255680e-01f, 3.01344134e-02f, -8.89098346e-02f, -1.05435446e-01f, -1.66556109e-02f,
  2.87424643e-02f, 1.24286741e-01f, -2.73537993e-01f, 2.12491062e-02f, -7.73858204e-02f, 1.19731054e-01f, 8.59875455e-02f, 2.47840136e-01f, -6.86652735e-02f, 1.42372757e-01f,
  -6.73263818e-02f, 2.15874672e-01f, 1.60230428e-01f, -2.41402745e-01f, 2.12679639e-01f, -9.17943940e-02f, -1.40235007e-01f, -4.75077927e-02f, 2.97517590e-02f, -1.65430531e-01f,
  -1.25509733e-02f, 2.56507456e-01f, -1.03096113e-01f, 9.69330519e-02f, -1.40796587e-01f, -8.75858497e-03f, 5.83580285e-02f, -3.53264203e-03f, 1.83282539e-01f, 2.44230758e-02f,
  4.22173291e-02f, 3.99173386e-02f, -3.88700739e-02f, -6.33840486e-02f, -3.67518663e-02f, -7.76919574e-02f, 4.87012416e-02f, 2.52881110e-01f, -3.15123141e-01f, 1.98140249e-01f,
  -2.03360012e-03f, -5.56516685e-02f, 2.01664746e-01f, 1.55538186e-01f, 7.44611323e-02f, -6.22434318e-02f, 4.17477153e-02f, 2.99754620e-01f, 1.66600600e-01f, -2.43475407e-01f,
  1.70859963e-01f, -2.74798810e-01f, 5.08296825e-02f, -2.08862036e-01f, 1.19577102e-01f, -2.53132105e-01f, 4.83871289e-02f, -3.58287767e-02f, 9.61926654e-02f, -1.34792045e-01f,
  -7.99995959e-02f, -3.55559960e-02f, -2.25894064e-01f, 3.04643754e-02f, -9.66892317e-02f, -3.08738291e-01f, 2.16905819e-03f, 2.05532953e-01f, 1.47429541e-01f, 2.31046110e-01f,
  1.36730909e-01f, -2.72606891e-02f, -1.25505716e-01f, -1.49877906e-01f, -9.47728381e-02f, 8.87112841e-02f, -6.04663379e-02f, 1.07722893e-01f, -6.45047724e-02f, 9.00443420e-02f,
  -2.55484059e-02f, 1.72677249e-01f, -9.35415924e-02f, -7.25451931e-02f, 4.84556109e-02f, 1.35475799e-01f, 3.54696475e-02f, -8.46319646e-02f, 1.73637792e-02f, -8.15450624e-02f,
  -8.46085101e-02f, 9.35186446e-03f, 2.13050067e-01f, 5.50742075e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.30922833e-01f, 1.88565418e-01f, 1.46420170e-02f, 3.16376723e-02f, 2.33305097e-01f, 1.37338027e-01f, -2.28670016e-01f, 8.26290473e-02f, -3.23832124e-01f, -1.97260410e-01f,
  1.42296553e-01f, -6.54281909e-03f, -6.30863197e-03f, 1.20459512e-01f, 1.72501370e-01f, 2.72655338e-01f, -2.00237352e-02f, 4.15188484e-02f, -9.41227898e-02f, -6.03218451e-02f,
  -7.16180652e-02f, 2.22861804e-02f, 1.29180685e-01f, -2.74598990e-02f, -5.53708151e-02f, -1.08372986e-01f, 1.94230154e-01f, -1.29100442e-01f, -9.58204716e-02f, 3.59099597e-01f,
  1.83533564e-01f, 2.04922959e-01f, -1.58719629e-01f, 2.64884848e-02f, -2.87250746e-02f, 3.74493115e-02f, 3.93465906e-01f, -1.20686121e-01f, 8.85993764e-02f, 4.92025400e-03f,
  2.57269051e-02f, 1.19966276e-01f, 1.57309115e-01f, -4.95489277e-02f, 3.09123576e-01f, -1.09208953e-02f, -1.31730318e-01f, 3.10220569e-01f, -1.41594097e-01f, 2.41835453e-02f,
  3.93542975e-01f, -1.01059407e-01f, -1.16071925e-01f, 2.22185940e-01f, 3.57568711e-01f, 2.01334730e-01f, 2.38060519e-01f, 9.43998024e-02f, -3.36066037e-02f, -1.95088908e-01f,
  -3.94472703e-02f, 8.23943764e-02f, 2.16334313e-01f, -1.10202529e-01f, 7.95222223e-02f, 2.28562444e-01f, 5.24104536e-02f, 7.61836246e-02f, 7.16758594e-02f, -2.08504442e-02f,
  2.51733005e-01f, -4.08390947e-02f, -2.13734820e-01f, 1.46967441e-01f, 2.42262214e-01f, 2.73653716e-01f, -2.17378493e-02f, -1.41982004e-01f, 2.05278248e-01f, 3.49037617e-01f,
  -4.62612733e-02f, 3.16879362e-01f, 2.71413147e-01f, 1.46963045e-01f, -9.55435913e-03f, -2.29421675e-01f, 2.56096005e-01f, 1.00592878e-02f, 9.23868716e-02f, -1.46576956e-01f,
  1.09740198e-01f, 3.94820184e-01f, 2.91168749e-01f, 4.65803519e-02f, 4.27822620e-02f, 2.68274248e-01f, -1.18888512e-01f, 2.22861618e-01f, 5.13351941e-03f, 1.91424102e-01f,
  -7.09499419e-02f, 1.42765641e-01f, 4.18911636e-01f, 1.17965527e-02f, 2.79035568e-01f, 1.36798039e-01f, -1.64252341e-01f, 1.33535609e-01f, 8.16949606e-02f, 1.55091345e-01f,
  1.72547609e-01f, -1.24054968e-01f, 1.88866213e-01f, 4.38200682e-02f, 1.33273691e-01f, 1.04076013e-01f, 4.72520031e-02f, 2.96742350e-01f, -6.91759288e-02f, -1.66303795e-02f,
  -1.00032896e-01f, -1.19256437e-01f, -2.49213964e-01f, -1.29254431e-01f, 2.71748602e-01f, 1.58760864e-02f, 2.61049151e-01f, -5.76756988e-03f, 5.12201190e-02f, 2.37590030e-01f,
  2.89022505e-01f, 1.80005282e-02f, 1.97579086e-01f, 9.01016816e-02f, 3.74153972e-01f, 1.81820869e-01f, -7.64508322e-02f, 7.83831999e-02f, -1.18979685e-01f, 6.19866587e-02f,
  9.58106294e-02f, -4.19233069e-02f, 4.02448118e-01f, -1.77138254e-01f, 3.20378959e-01f, 3.64712358e-01f, 4.13998723e-01f, -1.65343329e-01f, 2.80279011e-01f, -1.28632085e-02f,
  -2.96994328e-01f, -2.02045396e-01f, 3.43237221e-01f, 8.64220634e-02f, 1.57283992e-01f, 6.74340650e-02f, 2.63896793e-01f, -3.14730793e-01f, -2.13598907e-01f, 1.26098320e-01f,
  2.41947144e-01f, -2.37031177e-01f, 2.75497586e-01f, -7.59074390e-02f, -1.07923903e-01f, 3.90202627e-02f, 1.76161721e-01f, 1.80730484e-02f, -2.60260731e-01f, 2.62000293e-01f,
  -6.71005994e-02f, -2.71801144e-01f, 3.50757539e-02f, -3.18742730e-02f, 1.68099195e-01f, -1.23507626e-01f, -6.25253245e-02f, 1.72744989e-01f, 3.30534987e-02f, 2.67833441e-01f,
  6.05236366e-02f, -2.97086053e-02f, -2.20257938e-01f, 3.13272148e-01f, 3.62893343e-02f, 1.99948356e-01f, 2.07700357e-02f, 2.41741553e-01f, -1.61141977e-01f, 8.54069293e-02f,
  8.74651596e-02f, 7.70756006e-02f, 1.23116888e-01f, 1.45746902e-01f, 2.40601227e-01f, 1.25634700e-01f, 2.76298136e-01f, 1.88867539e-01f, -2.77355880e-01f, 6.65175989e-02f,
  -2.28701293e-01f, 9.59648192e-02f, 1.07608758e-01f, 2.24931370e-02f, 3.21432918e-01f, -1.34718940e-01f, -3.29253674e-02f, 2.71903798e-02f, 3.17959517e-01f, 1.06309734e-01f,
  -7.32948408e-02f, 6.53735886e-04f, 1.58075184e-01f, 2.56525636e-01f, 3.17177981e-01f, 7.06429183e-02f, -1.19614333e-01f, -1.50253996e-02f, -1.01313114e-01f, -1.02176979e-01f,
  3.45771760e-01f, 2.44312689e-01f, -1.90886796e-01f, 2.75816411e-01f, -1.01810299e-01f, 2.30400488e-01f, 2.33918384e-01f, -2.78565824e-01f, 6.85396492e-02f, 1.04477080e-02f,
  1.78957731e-01f, 2.67252296e-01f, 2.25875050e-01f, 6.88542128e-02f, 1.00901730e-01f, -1.33854914e-02f, -1.27911851e-01f, 6.35091439e-02f, -3.38976607e-02f, 4.78830263e-02f,
  9.61712971e-02f, -1.27178758e-01f, 2.08377227e-01f, -5.14948741e-02f, 2.97210291e-02f, 6.55012652e-02f, 4.01288159e-02f, -5.89426234e-02f, -1.33631408e-01f, -2.27310821e-01f,
  -5.51016666e-02f, -1.04513973e-01f, 2.32219949e-01f, 1.52545184e-01f, 6.85440078e-02f, 1.78971186e-01f, -2.08984390e-02f, 3.79753076e-02f, 1.66655168e-01f, 5.13675660e-02f,
  -1.43631222e-02f, 1.42328888e-02f, 1.83305323e-01f, 2.09181443e-01f, 6.12602048e-02f, 7.73678571e-02f, -8.60885084e-02f, -1.18407615e-01f, 6.67287409e-02f, 6.03179000e-02f,
  -5.17100049e-03f, -2.32921224e-02f, 1.07816093e-01f, 3.80881846e-01f, 1.67832062e-01f, -2.43965477e-01f, 2.03388453e-01f, -6.41267048e-03f, -1.27916083e-01f, -7.73410499e-02f,
  7.43745267e-02f, 1.00886099e-01f, 8.14087614e-02f, 3.17157395e-02f, 2.03360245e-01f, -2.51318246e-01f, -1.44902334e-01f, -1.11951619e-01f, 2.67652512e-01f, -1.17833100e-01f,
  1.56484663e-01f, -2.58142322e-01f, -1.45775765e-01f, 1.06377959e-01f, 2.03670174e-01f, 4.09106351e-02f, 7.50867426e-02f, 2.34181017e-01f, -1.02943711e-01f, -1.42754868e-01f,
  -1.58551335e-01f, 5.81522547e-02f, 3.18895429e-01f, -3.72309089e-02f, -7.13519752e-02f, 1.81000546e-01f, 1.69561729e-01f, 1.78981423e-01f, 4.56507541e-02f, 5.09732552e-02f,
  1.07035615e-01f, 1.70909733e-01f, 2.45625168e-01f, 3.04126173e-01f, -3.97638194e-02f, 1.39384851e-01f, -2.62983561e-01f, 1.58743218e-01f, 2.91033179e-01f, 2.43974566e-01f,
  1.73650503e-01f, 5.87844029e-02f, 8.59789997e-02f, 6.02145977e-02f, 2.72910837e-02f, 2.16699213e-01f, -4.63637263e-02f, -2.43884102e-01f, 3.28337997e-01f, -2.28245333e-01f,
  -2.47799352e-01f, 2.25125149e-01f, 1.48643285e-01f, -2.33301476e-01f, 1.04363926e-01f, 1.96704522e-01f, 7.97037482e-02f, -1.75950527e-01f, 1.09486086e-02f, 3.42527837e-01f,
  -3.81532721e-02f, 3.01231295e-02f, -1.15892634e-01f, 1.58920541e-01f, 8.17111209e-02f, 1.56619310e-01f, -2.85081446e-01f, 2.19297275e-01f, 1.42166791e-02f, -2.54662991e-01f,
  1.26503006e-01f, -6.82989061e-02f, 3.05800676e-01f, 2.30018288e-01f, 2.48397365e-01f, 6.91908598e-02f, -1.31817549e-01f, 1.33572385e-01f, 8.78238529e-02f, -4.56508435e-02f,
  -3.85083444e-02f, -1.23866051e-01f, 3.63264009e-02f, 2.08873406e-01f, -7.39350915e-02f, 1.81747019e-01f, 2.24826336e-01f, -2.18710482e-01f, 1.64011344e-01f, -9.60169435e-02f,
  -1.76000416e-01f, 2.09390596e-01f, 2.76864529e-01f, 1.30043790e-01f, 2.42183968e-01f, -1.59064740e-01f, 2.55944692e-02f, 2.84852870e-02f, 4.02478501e-02f, 2.53566772e-01f,
  5.28174415e-02f, 4.38096859e-02f, 2.26986147e-02f, 2.39245176e-01f, 2.14811444e-01f, 1.08941250e-01f, -5.66168725e-02f, 2.72318542e-01f, 1.99415207e-01f, 5.97769320e-02f,
  -1.93460062e-01f, 2.37426192e-01f, -6.71741292e-02f, -2.10970357e-01f, 3.86811676e-03f, -8.04877877e-02f, 5.68763316e-02f, -8.90605524e-02f, 2.25451756e-02f, 6.57925755e-02f,
  1.75948754e-01f, 1.13328353e-01f, -1.93735480e-01f, 9.56761017e-02f, 7.99581483e-02f, 2.02062592e-01f, 1.10430829e-02f, 1.35934696e-01f, 2.10337654e-01f, 1.37491971e-01f,
  1.91789597e-01f, 3.57693397e-02f, -1.37909263e-01f, 6.80194795e-02f, 4.33183983e-02f, 2.44138017e-02f, 1.37027398e-01f, 2.03108251e-01f, 1.79258026e-02f, -2.09084839e-01f,
  1.14169486e-01f, 2.35622570e-01f, -1.85197592e-01f, 1.26725033e-01f, 4.78607509e-03f, -1.77882925e-01f, -2.38075495e-01f, -7.16125453e-03f, 3.28497514e-02f, 1.88771173e-01f,
  1.58678323e-01f, 1.70049563e-01f, -2.11600021e-01f, 2.18714356e-01f, 3.44607800e-01f, 1.76597238e-01f, 1.58260077e-01f, 3.84827778e-02f, 2.81568587e-01f, -1.56209916e-02f,
  2.07645580e-01f, 1.69165567e-01f, 6.93284255e-03f, 8.20176452e-02f, -7.56099895e-02f, 2.80075938e-01f, 5.80077805e-02f, 1.52644381e-01f, -3.66492756e-02f, 1.07786231e-01f,
  1.72939613e-01f, 1.04489541e-02f, 1.59438759e-01f, 8.35492834e-02f, 1.55198619e-01f, 2.02652618e-01f, -1.37598500e-01f, 2.06913069e-01f, -8.57981518e-02f, -2.60656811e-02f,
  7.95555338e-02f, 2.74761021e-01f, 2.22823456e-01f, -1.84801698e-01f, 2.19211131e-01f, 2.94960529e-01f, 3.68638098e-01f, -2.75276065e-01f, 2.00197563e-01f, -8.18776116e-02f,
  -4.22122553e-02f, -1.23124696e-01f, 3.23902994e-01f, -1.35296717e-01f, 1.96054444e-01f, 3.98136415e-02f, 3.42905343e-01f, -2.41305739e-01f, 9.75422654e-03f, 2.00291928e-02f,
  -2.27515891e-01f, -1.14730693e-01f, 2.56236255e-01f, 1.43733826e-02f, -1.52264550e-01f, 4.04474325e-02f, 1.00217342e-01f, 1.00129835e-01f, 1.72614276e-01f, 3.23419362e-01f,
  2.74665803e-01f, 5.13978265e-02f, -8.74655768e-02f, -2.51363013e-02f, 2.44640350e-01f, -1.51387434e-02f, 5.50107211e-02f, -9.57389176e-02f, -1.60095647e-01f, 9.96737257e-02f,
  2.42793813e-01f, -6.13449663e-02f, -2.94220388e-01f, 2.51988888e-01f, 1.88509636e-02f, -6.30125552e-02f, 2.63630509e-01f, 1.76877499e-01f, -2.64963835e-01f, 1.70260575e-03f,
  5.53575978e-02f, 5.65128475e-02f, 1.46110460e-01f, 9.39181354e-03f, 3.02156582e-02f, 6.38546571e-02f, 1.38723210e-01f, -4.89032641e-02f, -3.48201901e-01f, -2.31791332e-01f,
  1.24154717e-01f, -3.88398796e-01f, -2.47044295e-01f, -3.20975125e-01f, 1.80237256e-02f, -4.88488637e-02f, -2.17814997e-01f, -6.53901920e-02f, 9.73629132e-02f, -2.04696625e-01f,
  -7.82069862e-02f, 3.46475810e-01f, -2.49334574e-02f, 2.61425585e-01f, 9.67214182e-02f, -1.46245612e-02f, 1.35053426e-01f, 9.72385481e-02f, -1.30940363e-01f, -2.13569496e-02f,
  1.16950244e-01f, 1.96758762e-01f, -9.05246735e-02f, -1.23895638e-01f, 2.35962957e-01f, 3.26013356e-01f, 2.85163224e-01f, -1.27795890e-01f, -1.22286208e-01f, -3.67791466e-02f,
  -1.23074606e-01f, -3.99224907e-02f, -2.40688846e-01f, -1.47183448e-01f, 1.91446796e-01f, 1.90810740e-01f, -2.79099524e-01f, -1.39063448e-01f, -4.50507700e-02f, -4.16210368e-02f,
  8.70729312e-02f, 2.43021533e-01f, 6.37422949e-02f, -2.00973883e-01f, 3.17657739e-02f, -2.16891557e-01f, 3.53836387e-01f, 1.24659523e-01f, -8.02340582e-02f, 1.34683058e-01f,
  7.84663111e-02f, 1.28093243e-01f, 3.55886817e-01f, 2.38485426e-01f, 1.14408182e-02f, 4.57236543e-02f, 2.91816350e-02f, -9.04032737e-02f, -1.67566407e-02f, 8.64961818e-02f,
  2.12208763e-01f, -7.09301308e-02f, -1.41732395e-01f, 1.36465281e-01f, -1.05828263e-01f, -1.79748889e-02f, -3.86314005e-01f, -5.56837302e-03f, 2.82471448e-01f, 1.17579855e-01f,
  -3.28432858e-01f, -3.11354786e-01f, -3.58512014e-01f, 3.01198736e-02f, 1.94963049e-02f, 3.00796360e-01f, -1.18461400e-01f, 2.44294554e-02f, 1.18278541e-01f, 4.14619818e-02f,
  2.52091527e-01f, 2.11426511e-01f, 7.65326992e-02f, -1.57421708e-01f, 2.13530064e-01f, -4.65270542e-02f, -9.41846613e-03f, -3.68035853e-01f, 3.69248241e-01f, 1.64694086e-01f,
  1.33316830e-01f, 3.80149186e-02f, 4.59687151e-02f, 1.89311266e-01f, 2.79598907e-02f, 3.23037148e-01f, 2.54603028e-01f, 2.14517027e-01f, 3.16314310e-01f, 1.69071540e-01f,
  5.88319562e-02f, 1.19737089e-01f, 1.02128178e-01f, 3.14126700e-01f, 1.20784551e-01f, 1.42101794e-01f, 2.34607980e-01f, -7.16967881e-02f, 2.54339445e-02f, -2.19445065e-01f,
  2.01034144e-01f, 2.47811735e-01f, 2.29764506e-01f, 2.17712134e-01f, 3.27120349e-02f, -6.24097697e-02f, -1.36044368e-01f, 7.64933228e-02f, 3.37740749e-01f, -1.33830318e-02f,
  3.26235294e-02f, -1.47503883e-01f, -3.26146781e-02f, 1.47192776e-01f, 2.20464796e-01f, 1.71711996e-01f, -4.98853922e-02f, -1.25830814e-01f, 2.86135878e-02f, -2.72255838e-01f,
  -3.02336752e-01f, -1.35952100e-01f, 1.61406785e-01f, 1.76973894e-01f, -1.24385573e-01f, -3.38400006e-01f, -2.76568472e-01f, 8.86769593e-02f, -1.58382952e-01f, 3.78414273e-01f,
  -1.82007793e-02f, 9.47671682e-02f, -4.07444400e-04f, -1.05280995e-01f, 3.26224744e-01f, 2.50956148e-01f, 1.32781073e-01f, -3.29225953e-03f, 1.29923612e-01f, -2.34831855e-01f,
  -1.99367777e-01f, -3.64344865e-01f, 3.04531127e-01f, 2.37236902e-01f, 1.75634593e-01f, -1.21364966e-01f, -1.16987251e-01f, 2.10310206e-01f, -2.77843028e-01f, -9.10847820e-03f,
  1.54554263e-01f, -1.75760370e-02f, 4.78696637e-02f, 1.15212336e-01f, -7.09355772e-02f, 1.54412538e-01f, 1.48923174e-01f, 1.50440976e-01f, 1.20888934e-01f, 2.23126546e-01f,
  2.09752724e-01f, 2.65158024e-02f, 2.79287286e-02f, -1.53724402e-01f, 2.95867652e-01f, 2.29551822e-01f, 7.55174980e-02f, 3.44047099e-01f, -1.27680719e-01f, 1.70393090e-03f,
  1.02677867e-01f, -3.07099354e-02f, 2.51212686e-01f, 9.83173996e-02f, 1.23170972e-01f, 2.13465929e-01f, 2.53971238e-02f, 8.57951939e-02f, 2.76113510e-01f, 4.56233434e-02f,
  -2.13697836e-01f, 3.58140171e-01f, -3.33136886e-01f, 1.73817873e-01f, 6.70287684e-02f, -9.27397162e-02f, 1.02577180e-01f, 1.53879255e-01f, 1.94087803e-01f, 1.92152649e-01f,
  2.43956726e-02f, 1.98845208e-01f, 1.55606464e-01f, -2.30598643e-01f, 2.61776924e-01f, 1.95821896e-02f, -5.82237728e-02f, -3.42202769e-03f, 1.38100907e-01f, -3.78214419e-02f,
  3.57187897e-01f, -1.31659538e-01f, 2.59100683e-02f, 1.16740733e-01f, 3.17525715e-01f, 5.98390102e-02f, -2.59446532e-01f, 6.51855171e-02f, 2.19369195e-02f, 1.99707419e-01f,
  3.40843737e-01f, -9.83176380e-02f, 2.24109031e-02f, -2.37843376e-02f, -5.45143448e-02f, 1.90591559e-01f, 9.66621265e-02f, 1.17546983e-01f, 2.53567040e-01f, -9.46872383e-02f,
  -2.40940824e-01f, 3.13313305e-01f, -1.42271101e-01f, 1.93581834e-01f, 3.59383762e-01f, 2.47869521e-01f, -1.78067416e-01f, 2.75143012e-02f, 4.10611033e-02f, 1.30821764e-01f,
  2.44486816e-02f, 7.62653276e-02f, 9.14916769e-02f, -3.69778834e-02f, -9.37025920e-02f, 7.55012175e-03f, 2.27130517e-01f, -1.08787492e-01f, -1.44180991e-02f, -3.71991992e-02f,
  -1.84450775e-01f, -4.09337245e-02f, 2.02865116e-02f, -1.67820260e-01f, 1.85133427e-01f, 3.18096697e-01f, -1.14398137e-01f, 2.05535978e-01f, -6.02125004e-02f, -1.79083720e-01f,
  1.92203075e-01f, 4.30875778e-01f, -1.14501230e-01f, -1.65006265e-01f, -2.25341842e-01f, 1.29441470e-01f, 1.32249132e-01f, -4.86842319e-02f, -2.18115479e-01f, -2.56810814e-01f,
  5.29898629e-02f, 8.98665711e-02f, 1.06630981e-01f, 2.85573229e-02f, 8.67246166e-02f, -1.18659742e-01f, -1.74754858e-02f, -8.26880038e-02f, 2.37738162e-01f, -3.50761265e-01f,
  1.40104428e-01f, -5.32414578e-02f, -1.74835324e-01f, 9.95354131e-02f, 1.43515900e-01f, 2.42309630e-01f, -1.87295094e-01f, 3.11133087e-01f, 3.56617421e-01f, 8.32742676e-02f,
  1.92999363e-01f, 1.49525940e-01f, 8.88617989e-03f, 2.40701005e-01f, 1.57744005e-01f, 3.36271852e-01f, -7.69291967e-02f, 1.78943872e-01f, 1.55292675e-01f, -8.66539925e-02f,
  1.36230201e-01f, -2.05076888e-01f, 4.10129666e-01f, 3.71393621e-01f, 3.33987027e-02f, 2.97688216e-01f, 1.74161360e-01f, 9.26426649e-02f, -2.03872725e-01f, 1.31076336e-01f,
  3.51056576e-01f, 1.99880600e-02f, 8.03258643e-03f, 5.45486435e-02f, 1.79169267e-01f, -2.67253313e-02f, -2.15039309e-03f, 3.10327020e-02f, -1.74692914e-01f, -3.45252484e-01f,
  2.83980310e-01f, -2.91939944e-01f, -1.72979292e-02f, -2.62814403e-01f, 1.10851988e-01f, -3.11018914e-01f, -6.54265692e-04f, 1.09892726e-01f, 4.41330820e-01f, -2.76063561e-01f,
  -2.44656384e-01f, 1.91705972e-01f, 1.91366106e-01f, 4.39875752e-01f, 4.13165450e-01f, 2.45973557e-01f, -2.41812970e-02f, 1.98224351e-01f, -2.66635358e-01f, 5.77945262e-02f,
  1.33405522e-01f, 2.13921383e-01f, 4.62821573e-02f, 1.17807455e-01f, 1.86206356e-01f, 2.09789753e-01f, 1.04366332e-01f, -1.05114147e-01f, -3.05952271e-04f, 1.48977950e-01f,
  -3.12513262e-01f, 3.38525698e-02f, 9.12922695e-02f, -1.70472637e-01f, -1.99333191e-01f, -6.37203157e-02f, -2.33046383e-01f, 1.59129843e-01f, 2.25677729e-01f, -2.43368700e-01f,
  1.18867688e-01f, -3.78919505e-02f, -5.79027608e-02f, -3.97589318e-02f, 3.52203548e-01f, -6.21974170e-02f, 2.91620623e-02f, -5.46270274e-02f, -5.33793494e-02f, 1.14012118e-02f,
  1.80411130e-01f, 3.28745365e-01f, 3.85362387e-01f, 2.62454838e-01f, -3.32106084e-01f, 2.09589005e-01f, 7.29073584e-02f, 1.56535596e-01f, 1.00198083e-01f, 2.53442913e-01f,
  1.87254623e-01f, 1.01022283e-02f, -1.31677836e-01f, 1.74355939e-01f, 9.46021676e-02f, -2.15733826e-01f, -1.73603281e-01f, -2.22329184e-01f, -3.05083562e-02f, 1.63703978e-01f,
  1.02796577e-01f, -3.33786495e-02f, 3.30515444e-01f, 2.13618502e-01f, -6.00595884e-02f, -2.66892165e-01f, 2.35386312e-01f, 3.57275069e-01f, -2.65202910e-01f, 6.44507483e-02f,
  8.42930451e-02f, 1.71033606e-01f, 2.28480428e-01f, -1.90118270e-03f, -8.02485645e-02f, -1.12790607e-01f, -1.29337922e-01f, 1.43271223e-01f, 1.91230103e-01f, -1.30733475e-01f,
  1.10673286e-01f, -3.30758452e-01f, -2.63073053e-02f, 6.83710650e-02f, -1.95720464e-01f, -1.68132022e-01f, -9.01695937e-02f, -1.51037732e-02f, -8.56754854e-02f, -2.32854947e-01f,
  -2.20872849e-01f, -1.55122057e-01f, 2.09168438e-02f, 4.22122404e-02f, -9.83132944e-02f, 7.68579021e-02f, 2.17747048e-01f, 2.40427241e-01f, 1.63183376e-01f, -5.42084724e-02f,
  3.21322940e-02f, -6.43889755e-02f, 1.14478581e-01f, 6.33732155e-02f, 1.37907183e-02f, 2.17105061e-01f, -1.54234901e-01f, 1.60300255e-01f, -1.60896674e-01f, 1.64141521e-01f,
  1.92675039e-01f, 2.29938090e-01f, 1.93973958e-01f, 1.87263817e-01f, -1.99224688e-02f, 1.01736739e-01f, 5.94836362e-02f, -2.32692480e-01f, 4.48621102e-02f, -8.61881375e-02f,
  3.57430667e-01f, 1.57497317e-01f, -1.37442008e-01f, -2.05670193e-01f, 2.38248445e-02f, 3.41042519e-01f, -2.08051875e-01f, 1.34520754e-01f, 2.72248000e-01f, 3.87067646e-01f,
  -1.53748095e-01f, -2.59057600e-02f, -3.09265107e-02f, -7.41476938e-02f, -1.85835660e-01f, 1.41410381e-01f, -1.64590985e-01f, 3.52608472e-01f, 5.70473820e-02f, 1.78988129e-01f,
  1.10118184e-02f, 3.97512287e-01f, 3.29812095e-02f, 3.53704929e-01f, 1.03443928e-01f, 3.34599257e-01f, 2.50539660e-01f, -2.01717630e-01f, 4.22254771e-01f, 7.50075653e-02f,
  -1.24737829e-01f, 1.14157230e-01f, -1.60544947e-01f, 1.40776247e-01f, 2.50226885e-01f, -1.37794465e-02f, -1.51278973e-01f, -3.27092484e-02f, 8.12849551e-02f, -2.99757365e-02f,
  2.01738983e-01f, -2.78187662e-01f, -1.92883536e-01f, 2.70436496e-01f, 2.74596065e-01f, -1.02522857e-01f, 1.05929643e-01f, 1.26286224e-01f, -2.28087246e-01f, -2.46215224e-01f,
  2.29338035e-01f, 3.54811847e-02f, 1.51402503e-01f, 4.05885242e-02f, 1.39537156e-01f, 1.92660302e-01f, 1.18491769e-01f, -5.03667966e-02f, 1.44394459e-02f, 7.05161095e-02f,
  1.76543370e-02f, 2.34132603e-01f, -2.16431692e-01f, 1.59411207e-01f, 3.60983133e-01f, 9.34578404e-02f, 1.74964800e-01f, -1.13051213e-01f, 3.28996152e-01f, 3.56725156e-01f,
  1.41820282e-01f, 2.48183265e-01f, 2.52892524e-01f, -1.52701996e-02f, 2.58189052e-01f, 2.19264571e-02f, 3.88565004e-01f, -1.09279670e-01f, -8.22500736e-02f, -3.34112048e-01f,
  -8.31938908e-02f, 3.45250249e-01f, 1.19183101e-01f, 3.59549552e-01f, 2.06805170e-01f, 3.64882290e-01f, -2.64038533e-01f, 2.46309310e-01f, -1.11180574e-01f, -7.18023926e-02f,
  3.98349240e-02f, 3.96003239e-02f, 3.22816998e-01f, 2.06694052e-01f, 3.37746233e-01f, 7.29244351e-02f, -6.93673864e-02f, 2.26283476e-01f, 5.68577787e-03f, 2.57658213e-01f,
  -1.98730733e-04f, -1.80209711e-01f, -3.26941758e-02f, -1.87051803e-01f, -5.00441715e-02f, -2.19231285e-02f, -7.90032558e-03f, 1.69762269e-01f, -7.02367052e-02f, -1.88461110e-01f,
  -2.09537178e-01f, -3.03486258e-01f, 4.78681140e-02f, -8.12337324e-02f, 2.65405267e-01f, 6.36555552e-02f, -9.75427553e-02f, 1.35597542e-01f, -5.93612716e-02f, 6.15564995e-02f,
  1.65930912e-01f, 1.90984219e-01f, 6.47397190e-02f, 2.04982698e-01f, -3.81101295e-02f, 2.12150201e-01f, 2.40985602e-02f, -6.23519607e-02f, -1.02484664e-02f, -1.70400828e-01f,
  -1.90785572e-01f, 2.85502672e-01f, 1.42589390e-01f, 1.08144119e-01f, 2.65210599e-01f, 4.10209596e-02f, -8.90249666e-03f, -2.03958318e-01f, 3.53245854e-01f, 3.49410176e-01f,
  -1.86168477e-01f, 1.66298270e-01f, 1.96860403e-01f, 8.23247433e-02f, 2.58425534e-01f, -1.40586168e-01f, -1.95497975e-01f, 1.06987186e-01f, 2.71513790e-01f, 8.49098638e-02f,
  -2.04776824e-02f, -2.21493185e-01f, 7.81862065e-02f, 6.31950572e-02f, 2.62739331e-01f, -1.25402734e-01f, -2.70016074e-01f, 1.81710254e-03f, -3.40851881e-02f, 2.51075514e-02f,
  2.37778977e-01f, -7.73076341e-02f, 1.43913254e-01f, -1.01734690e-01f, 5.13784401e-02f, 8.36211741e-02f, 2.18993220e-02f, 3.14696990e-02f, 1.05514102e-01f, 3.14503044e-01f,
  -2.27398309e-03f, 1.12796471e-01f, -2.60022759e-01f, 1.10167108e-01f, 2.15561032e-01f, 7.33647346e-02f, 2.18097761e-01f, 2.02058211e-01f, 8.91968980e-02f, 1.32770464e-01f,
  -7.58737177e-02f, -5.33086620e-02f, 2.20770612e-01f, 1.83195531e-01f, 1.26999289e-01f, 2.31158406e-01f, 2.80060172e-01f, 9.35791507e-02f, -1.66874960e-01f, 1.81398764e-01f,
  3.24078426e-02f, -1.43062398e-01f, -9.77972001e-02f, -9.24455673e-02f, 1.88449204e-01f, -1.52341381e-01f, 1.67685747e-01f, 1.02134831e-01f, 3.06204051e-01f, -1.11117512e-01f,
  -2.91225553e-01f, 7.76060969e-02f, 2.70812601e-01f, 2.01287851e-01f, 1.17032707e-01f, 1.59385622e-01f, 2.23603845e-01f, 1.52676433e-01f, 8.43240544e-02f, -6.40012743e-03f,
  -3.24954130e-02f, 1.50596827e-01f, 9.67775658e-03f, 1.11729085e-01f, -1.44424438e-01f, -1.17282055e-01f, 1.51770428e-01f, -2.40138367e-01f, 4.98323925e-02f, 9.97198969e-02f,
  -1.44618645e-01f, 1.68218374e-01f, 9.03319791e-02f, -2.10235566e-01f, -1.10520408e-01f, -6.55810237e-02f, 8.68450478e-02f, -4.35057580e-02f, 1.23471931e-01f, -1.07515998e-01f,
  -6.35123327e-02f, -9.79828462e-02f, 2.52895877e-02f, 2.05684453e-01f, 2.94102758e-01f, 5.77496588e-02f, -2.12333396e-01f, -2.13311940e-01f, -8.05017799e-02f, -1.41271755e-01f,
  1.06692612e-01f, 2.53958523e-01f, 1.83639511e-01f, 2.11564988e-01f, -2.82965541e-01f, 2.63487816e-01f, -1.79311670e-02f, -1.90689247e-02f, 2.14161292e-01f, 3.38800550e-02f,
  1.46185324e-01f, 1.69062033e-01f, 2.94544220e-01f, 2.96920929e-02f, 2.71039605e-01f, 1.61413997e-02f, -1.47494078e-01f, 7.21731186e-02f, 2.74578959e-01f, 1.59791395e-01f,
  1.95237800e-01f, -2.32200056e-01f, 2.10406840e-01f, 4.52210493e-02f, 1.15983002e-01f, 1.33651316e-01f, 2.70910501e-01f, 9.92375612e-02f, -4.61667180e-02f, 1.02948658e-01f,
  3.74579787e-01f, 2.89067835e-01f, 2.30624437e-01f, -1.06238157e-01f, 1.17327021e-02f, -1.91452816e-01f, -4.89436127e-02f, 1.14350110e-01f, 8.49378854e-02f, -4.46760729e-02f,
  1.55597463e-01f, -9.58033279e-03f, -1.72269270e-01f, 1.46270171e-01f, -8.60785395e-02f, 1.72811702e-01f, 2.55149379e-02f, 2.81567544e-01f, 2.70619303e-01f, -1.00985095e-02f,
  2.61460040e-02f, 1.77189872e-01f, 3.15785140e-01f, 3.52511071e-02f, 9.56983864e-02f, 8.80272537e-02f, -8.85624215e-02f, 2.48320431e-01f, 1.16223767e-01f, 5.60513213e-02f,
  -2.99272150e-01f, 2.35267803e-01f, 4.85102413e-03f, 1.80540740e-01f, 2.20339805e-01f, 2.90959477e-01f, -2.86175847e-01f, -1.61254093e-01f, -1.24467209e-01f, 2.24166319e-01f,
  1.28277674e-01f, 2.24818751e-01f, 3.05270813e-02f, 2.22106293e-01f, 1.35552436e-01f, 2.23495856e-01f, -1.87627837e-01f, 2.78689772e-01f, -2.20158622e-01f, -1.31187961e-01f,
  4.89141122e-02f, -1.23035155e-01f, 2.04217166e-01f, -9.47244912e-02f, 8.37868154e-02f, 1.80630609e-01f, 3.55981857e-01f, -4.16033380e-02f, -1.45449892e-01f, -7.21670538e-02f,
  1.04753084e-01f, 1.98148578e-01f, 2.98545033e-01f, 2.75184333e-01f, -1.89748392e-01f, -2.90434267e-02f, -2.66905222e-02f, -4.88035232e-02f, 1.74417943e-02f, 3.76410127e-01f,
  -3.12770233e-02f, 4.03552026e-01f, -6.25471119e-03f, -2.04538684e-02f, 2.56429892e-02f, -2.36523896e-01f, 3.39853436e-01f, -1.07314222e-01f, 9.38673615e-02f, 2.01434121e-01f,
  -6.98693395e-02f, -1.40122369e-01f, -1.61877036e-01f, -3.49546552e-01f, -1.16965696e-02f, -2.05916334e-02f, 1.92333281e-01f, 2.00170875e-01f, -3.28033566e-01f, 5.90241291e-02f,
  1.76874503e-01f, 1.78445563e-01f, 2.36425772e-01f, 1.91495106e-01f, 7.43364468e-02f, -1.84809342e-01f, 1.10904627e-01f, -4.43501621e-02f, 9.29219276e-02f, -3.32759544e-02f,
  1.37896780e-02f, 3.78928185e-01f, -1.61883473e-01f, 1.26176521e-01f, -4.85788472e-02f, -1.41976804e-01f, 4.15401533e-02f, -1.20873526e-01f, -7.94242844e-02f, 1.07250579e-01f,
  1.76485404e-02f, 6.05320036e-02f, 3.52927633e-02f, -2.34640911e-02f, 1.00717656e-01f, 2.30094679e-02f, -1.22290567e-01f, -7.82208294e-02f, -1.11191504e-01f, -4.31482717e-02f,
  -8.81122798e-02f, -3.75080332e-02f, -4.73958589e-02f, 7.79839531e-02f, -1.11131286e-02f, -1.27814934e-01f, 4.16922122e-02f, -4.22471613e-02f, -1.18275538e-01f, -1.25244543e-01f,
  -5.96007258e-02f, -6.52712956e-02f, -6.25029206e-02f, -7.70386681e-02f, -2.68421024e-02f, 5.80752157e-02f, -4.96470332e-02f, -6.49880525e-03f, 1.26364706e-02f, -9.55461487e-02f,
  2.40592360e-02f, 2.58980840e-02f, -8.89478996e-02f, -9.38994661e-02f, -4.66134679e-03f, -7.16009215e-02f, -1.23037584e-01f, 7.10146651e-02f, -7.49808252e-02f, 6.37011677e-02f,
  -1.19817734e-01f, -8.96073431e-02f, -2.08603730e-03f, 3.49726528e-02f, -7.31499642e-02f, -9.22321901e-02f, 5.47664054e-03f, -7.21680559e-03f, -2.14834362e-02f, 1.78650289e-03f,
  5.20232841e-02f, -2.17733681e-02f, -1.82041824e-02f, 1.22277439e-03f, 9.63250250e-02f, 2.51625609e-02f, 1.92049593e-02f, -2.13919021e-02f, -1.53078223e-02f, -1.62550583e-01f,
  -1.76258788e-01f, 7.06057772e-02f, -2.47285832e-02f, 1.41200647e-01f, -1.44276530e-01f, 1.43599823e-01f, 1.90611541e-01f, -1.99312538e-01f, -2.40734577e-01f, -3.23452763e-02f,
  1.35138884e-01f, 3.57168615e-01f, -2.81059563e-01f, 4.87520918e-02f, -2.31412992e-01f, -4.83661033e-02f, 5.70822619e-02f, 1.28462031e-01f, -5.66039123e-02f, -4.96567748e-02f,
  -2.20361263e-01f, 6.23392388e-02f, -1.42426314e-02f, 1.20581940e-01f, 4.16958556e-02f, 1.29935533e-01f, -1.83901265e-01f, -1.97024316e-01f, 2.72730440e-01f, -2.64002234e-01f,
  2.02860355e-01f, 1.12143785e-01f, 9.90572795e-02f, 2.98752457e-01f, 1.96342885e-01f, 1.93174347e-01f, -9.72020105e-02f, 2.43625995e-02f, -4.83595952e-02f, 2.04361483e-01f,
  1.04645804e-01f, 2.12405652e-01f, -1.74165014e-02f, -1.60810538e-02f, 6.22716583e-02f, 4.02623415e-01f, 3.03839892e-01f, 2.22147360e-01f, 1.27335310e-01f, 4.11093049e-02f,
  2.79972348e-02f, -1.01007767e-01f, 3.91176462e-01f, 2.21737221e-01f, 2.61416674e-01f, 3.06819528e-01f, 2.32126102e-01f, -1.92310493e-02f, 1.18613977e-03f, -1.27513129e-02f,
  9.06827226e-02f, -1.38887493e-02f, 2.77287155e-01f, -6.58390373e-02f, 3.81834880e-02f, 5.74639142e-02f, 1.68463579e-04f, 2.24959552e-01f, -1.20716594e-01f, -2.63295054e-01f,
  3.90113950e-01f, -3.76713485e-01f, -4.50556308e-01f, 1.21860400e-01f, 3.52446556e-01f, -2.48843685e-01f, -2.42572725e-01f, -3.53145123e-01f, -2.07171999e-02f, -4.45184976e-01f,
  -3.06047261e-01f, 2.10705251e-01f, -1.33509338e-01f, 1.71425268e-01f, -1.28047451e-01f, 2.38707647e-01f, 1.00667924e-01f, 4.33743298e-01f, -1.71857387e-01f, -5.09193242e-02f,
  9.10686031e-02f, -1.26522526e-01f, -1.09415315e-01f, -1.49787918e-01f, 5.03826439e-01f, 4.80622165e-02f, 3.31227779e-01f, 1.04273288e-02f, -2.17714712e-01f, 1.74234703e-01f,
  -1.80187806e-01f, 1.90008923e-01f, -9.53492224e-02f, -8.73840880e-03f, 1.07445948e-01f, -5.33779226e-02f, -2.61530519e-01f, 2.08343536e-01f, 1.71620518e-01f, 1.10755600e-01f,
  9.21317041e-02f, 1.03138298e-01f, -4.39538546e-02f, 7.05000982e-02f, 2.85600752e-01f, -3.04271057e-02f, 2.15274408e-01f, 6.82139024e-02f, 9.58690867e-02f, 2.47826710e-01f,
  1.07534185e-01f, 1.08916320e-01f, -6.18467741e-02f, 1.20721320e-02f, -3.89353484e-02f, 1.49950802e-01f, 1.97651625e-01f, 4.98268828e-02f, 1.24875888e-01f, -5.22443652e-02f,
  -3.46215791e-03f, 2.23894492e-01f, 2.28511542e-01f, -1.03772610e-01f, 1.48663968e-01f, 2.28171468e-01f, 7.24527091e-02f, 3.48760664e-01f, 1.35918692e-01f, 1.54743552e-01f,
  -6.17000349e-02f, 1.57288596e-01f, -2.26051733e-01f, -4.03270870e-02f, 2.32803106e-01f, 3.08259875e-01f, -1.45893425e-01f, -2.15858504e-01f, 1.22186303e-01f, 3.11864942e-01f,
  -1.39963359e-01f, 5.69031388e-02f, -1.03182733e-01f, 2.14037806e-01f, 2.44312763e-01f, 3.36361639e-02f, 2.11808354e-01f, 1.38178200e-01f, 2.36668810e-03f, 2.55235016e-01f,
  3.44285846e-01f, 2.70780504e-01f, 1.40722051e-01f, -2.32572392e-01f, 2.12275356e-01f, 2.04321548e-01f, 9.44921225e-02f, 3.66537571e-01f, 2.29870990e-01f, 2.98441321e-01f,
  1.98834464e-01f, -1.05093807e-01f, 8.51603821e-02f, 2.34568715e-01f, 1.65110335e-01f, -8.93635079e-02f, -9.24529433e-02f, -9.35782120e-02f, -1.14994109e-01f, 3.33917558e-01f,
  -1.75812006e-01f, -8.47798958e-02f, -1.23327468e-02f, -2.50029892e-01f, 2.92438399e-02f, -2.10270166e-01f, 3.04251105e-01f, -7.22196102e-02f, 1.11153595e-01f, 1.04834154e-01f,
  1.49328142e-01f, 7.10869655e-02f, 1.76665068e-01f, 8.15881267e-02f, 1.30963735e-02f, 1.90297171e-01f, 1.34005144e-01f, -9.52291936e-02f, 3.98594178e-02f, -5.00231283e-03f,
  4.63881008e-02f, -7.95696452e-02f, 1.88585557e-02f, -1.33863077e-01f, 4.58850473e-01f, 1.66387439e-01f, 2.33146548e-01f, -1.03929766e-01f, 4.81127687e-02f, -1.20467961e-01f,
  1.25849098e-01f, 5.88753372e-02f, -2.35500373e-02f, -3.69642414e-02f, 1.47941530e-01f, -9.63478610e-02f, 1.45839497e-01f, 1.77109602e-03f, -8.02402105e-03f, 2.54504681e-01f,
  -5.92321493e-02f, 1.88167438e-01f, -6.49546608e-02f, -1.36807755e-01f, -1.14306279e-01f, -8.26668441e-02f, 4.78098653e-02f, 9.24519673e-02f, 1.89968497e-01f, 1.60577625e-01f,
  8.30502361e-02f, 1.86629537e-02f, 8.87350217e-02f, -2.64230162e-01f, 1.82191789e-01f, 3.90937477e-01f, 3.10233414e-01f, -2.84339130e-01f, -1.46301299e-01f, -1.16019525e-01f,
  5.41538000e-02f, 1.86031491e-01f, 1.61919072e-01f, 1.17043205e-01f, 1.84817284e-01f, 9.80791450e-03f, -3.60292085e-02f, 1.92434072e-01f, 3.62658352e-02f, 9.32744667e-02f,
  -2.87858158e-01f, -1.63656145e-01f, -1.06020942e-01f, 2.97172308e-01f, 1.32964849e-01f, 5.89783862e-02f, 1.40513200e-03f, 1.20004781e-01f, 1.19382448e-01f, 7.51968324e-02f,
  1.02149449e-01f, -8.66010413e-02f, 6.26809672e-02f, -6.88150572e-03f, -2.46650085e-01f, -2.01165620e-02f, 3.57429266e-01f, -8.52558091e-02f, 1.44208476e-01f, -3.17207009e-01f,
  -2.62723833e-01f, -5.33560999e-02f, 9.26770493e-02f, 3.02544713e-01f, 5.70600256e-02f, -1.09447680e-01f, 2.89224572e-02f, 1.67137876e-01f, 2.12287202e-01f, 2.00474337e-01f,
  1.90168396e-01f, -5.11858463e-02f, 4.88303006e-02f, -4.92820777e-02f, -3.04343790e-01f, -7.66840205e-02f, 1.80695504e-01f, 9.02807713e-02f, 7.05478936e-02f, 1.37709444e-02f,
  -4.35516834e-02f, 2.68497050e-01f, -9.18383449e-02f, 3.32436085e-01f, 2.00201333e-01f, 5.80645353e-02f, 9.59916040e-02f, 5.53323552e-02f, 7.82389492e-02f, 3.39650810e-01f,
  1.80366591e-01f, -8.62502828e-02f, 9.01708659e-03f, -9.91288498e-02f, 5.99177144e-02f, 2.86666621e-02f, 2.24838257e-01f, -2.05824301e-01f, 1.65773362e-01f, 7.04628378e-02f,
  -1.36435643e-01f, 3.02892894e-01f, -5.85103296e-02f, 1.96626261e-01f, -1.61789656e-02f, -6.86885193e-02f, 5.10563888e-02f, 2.40265518e-01f, 9.24290195e-02f, 2.09234759e-01f,
  1.50360852e-01f, -2.04016604e-02f, 2.09568471e-01f, 1.27442300e-01f, -2.95675714e-02f, 1.33666128e-01f, -5.48980720e-02f, 2.16993809e-01f, 1.98042244e-01f, 1.43905766e-02f,
  1.29709721e-01f, -2.08822042e-02f, 2.72558928e-01f, 2.36624122e-01f, 4.01649028e-01f, -4.94387485e-02f, -1.95133537e-02f, -1.13779679e-01f, 1.27577394e-01f, 2.19874740e-01f,
  3.67303044e-01f, 2.64855802e-01f, -7.94377550e-02f, -1.59090221e-01f, -8.92553926e-02f, -1.91284604e-02f, 9.98144597e-02f, 2.92261809e-01f, 2.02353463e-01f, 2.03142017e-01f,
  -1.87752321e-01f, -4.62189913e-02f, -9.25763398e-02f, 1.31312996e-01f, 1.92194879e-01f, -1.35047168e-01f, 2.89391041e-01f, 2.87743658e-01f, 1.09211519e-01f, 1.70677692e-01f,
  2.17035919e-01f, -4.11347449e-02f, -6.29854202e-02f, 1.53308928e-01f, 2.08924010e-01f, -6.07048273e-02f, -1.91382654e-02f, -1.92607731e-01f, -1.47472858e-01f, -1.05272584e-01f,
  1.49192318e-01f, 1.64175004e-01f, -2.84215122e-01f, -1.95189029e-01f, -9.06232670e-02f, -9.48714837e-02f, 1.81239605e-01f, 1.18048429e-01f, 2.20191315e-01f, 2.70141900e-01f,
  -2.21726790e-01f, 2.40569577e-01f, 5.72481900e-02f, 1.62635297e-01f, 5.43835759e-02f, 9.27176476e-02f, 9.31743160e-02f, 1.77248985e-01f, -3.49486917e-01f, 3.42193246e-02f,
  -1.69865519e-01f, -2.28131428e-01f, 3.25198650e-01f, -5.27246296e-02f, -2.41236135e-01f, 2.29279324e-01f, -1.72099665e-01f, 4.38753307e-01f, -6.21723793e-02f, -3.75772528e-02f,
  -1.22717626e-01f, -2.26607285e-02f, -9.22682434e-02f, 1.54220328e-01f, 1.15725003e-01f, 1.20558932e-01f, -2.53570825e-01f, 3.03244907e-02f, 2.13005319e-02f, 3.00034583e-01f,
  -1.84664786e-01f, 3.31295967e-01f, 3.75005066e-01f, 2.63117820e-01f, -1.67232439e-01f, 2.57615954e-01f, -1.43485442e-01f, 2.67175585e-01f, 4.00458544e-01f, -1.45516485e-01f,
  9.23362672e-02f, 6.48142025e-02f, 1.54873645e-02f, -4.86483984e-02f, -6.10396415e-02f, 2.53458560e-01f, 1.56441361e-01f, -7.06757680e-02f, -2.63787895e-01f, 3.00364882e-01f,
  1.17028370e-01f, 1.95972815e-01f, 3.20578605e-01f, -9.87089351e-02f, -2.50037968e-01f, 1.03045739e-01f, 1.78343132e-01f, -1.91849202e-01f, 2.90811568e-01f, -1.00226037e-01f,
  1.51446790e-01f, -2.65510499e-01f, 3.85371089e-01f, 1.73225090e-01f, 8.83449800e-03f, -2.52370477e-01f, 1.67495869e-02f, 1.99777171e-01f, -1.04622971e-02f, -1.14520207e-01f,
  -9.90866572e-02f, -4.05564606e-02f, 3.67081285e-01f, 5.44775352e-02f, -5.85728809e-02f, 1.72149450e-01f, 2.91494340e-01f, 9.27170739e-02f, 5.70355356e-02f, 9.40663666e-02f,
  2.56179303e-01f, 2.13475466e-01f, -9.84685123e-02f, 1.61005378e-01f, 3.09459597e-01f, -2.79391687e-02f, -1.86053663e-01f, -3.26003015e-01f, 2.74160415e-01f, 8.43214542e-02f,
  2.65768506e-02f, 5.76586053e-02f, 1.48536399e-01f, 1.93914264e-01f, 3.03890500e-02f, 1.54275209e-01f, 1.13404915e-02f, 1.45492762e-01f, -2.59402264e-02f, -2.41523147e-01f,
  -8.90286416e-02f, 1.64061800e-01f, -8.62631723e-02f, 1.78472281e-01f, 2.40926892e-01f, 2.37616614e-01f, 2.91306496e-01f, 2.86532760e-01f, -2.06322566e-01f, 1.43004075e-01f,
  4.02078748e-01f, 3.42514813e-01f, 2.27088735e-01f, -1.25595510e-01f, -9.38102081e-02f, -1.65594682e-01f, -3.83459479e-02f, -1.52510092e-01f, 2.05033585e-01f, 2.07191825e-01f,
  -8.10931996e-02f, 3.08469534e-01f, -9.72853675e-02f, 3.15140218e-01f, -3.07196945e-01f, 7.19243512e-02f, -1.08101435e-01f, 8.89665708e-02f, 2.65070349e-01f, 1.09349236e-01f,
  -3.59294266e-02f, 3.49655710e-02f, 1.19585916e-01f, 9.60344672e-02f, -6.02584369e-02f, 1.05823420e-01f, -1.64261743e-01f, 5.65405041e-02f, 2.17736915e-01f, -4.57494929e-02f,
  -3.15492928e-01f, -1.62639588e-01f, 2.59476632e-01f, 2.21127704e-01f, 7.14283660e-02f, 1.75831258e-01f, 3.70721072e-01f, -2.24611163e-01f, -3.73291560e-02f, 1.53305605e-01f,
  1.80425242e-01f, 2.82414287e-01f, 2.98494905e-01f, -4.06250805e-02f, 2.17225552e-02f, -1.10897422e-01f, -1.21141843e-01f, 1.47144258e-01f, 2.03253046e-01f, -1.09870592e-02f,
  2.39206165e-01f, -7.46537000e-02f, 4.33292985e-02f, 1.11250840e-01f, 1.64189249e-01f, 1.60607230e-02f, -1.25414059e-02f, 1.78501770e-01f, -1.50370747e-01f, 5.25762923e-02f,
  1.96933553e-01f, -2.72549503e-02f, 2.35706076e-01f, 3.90330017e-01f, -2.28432715e-01f, 2.84371346e-01f, 2.08790243e-01f, -6.92530796e-02f, 2.09708109e-01f, -1.40932724e-01f,
  -2.33286619e-01f, -9.99766514e-02f, 6.57420382e-02f, -2.44449936e-02f, 1.65185988e-01f, -4.84402850e-03f, -2.67645121e-01f, -9.12209973e-02f, 2.68109858e-01f, 3.44677389e-01f,
  2.94628829e-01f, 1.49909168e-01f, -1.75658420e-01f, 2.57419378e-01f, 2.48219833e-01f, 2.34979808e-01f, 1.35989890e-01f, 7.93655515e-02f, 1.00951687e-01f, 2.54293680e-01f,
  -1.67574346e-01f, 3.64090711e-01f, -1.98577613e-01f, 1.83509842e-01f, 3.24069440e-01f, 2.89204448e-01f, 1.08324230e-01f, 1.17344692e-01f, 1.00861907e-01f, 4.37492847e-01f,
  -3.44090164e-02f, 9.74037051e-02f, 1.09070323e-01f, -8.96754265e-02f, -3.82793918e-02f, -2.14764327e-01f, 1.23016134e-01f, 1.41968876e-01f, -3.83115858e-02f, -1.59611851e-01f,
  2.13503778e-01f, 2.69259334e-01f, 2.15363994e-01f, -7.34891817e-02f, 2.01264516e-01f, 1.56554803e-01f, -1.22087635e-01f, -1.73535168e-01f, -1.21805668e-01f, 1.17446795e-01f,
  3.63190174e-01f, 6.16941005e-02f, 3.83830339e-01f, 2.15059176e-01f, 1.76567033e-01f, 1.62283897e-01f, 1.24841318e-01f, 1.22814164e-01f, 3.31013471e-01f, 3.72971855e-02f,
  -5.90038544e-04f, 2.48171821e-01f, -4.16818038e-02f, -1.03573250e-02f, 2.39813805e-01f, 1.43755421e-01f, 4.77312319e-02f, 2.74615943e-01f, -4.70005721e-02f, -2.22253357e-03f,
  4.48915511e-02f, -1.56322643e-01f, -4.11519818e-02f, -1.38753444e-01f, -1.18868627e-01f, -4.31177318e-02f, 1.04423672e-01f, 1.71527579e-01f, 4.54205424e-02f, 1.64766058e-01f,
  2.09968407e-02f, 8.80170017e-02f, 5.27547710e-02f, 1.60247356e-01f, 1.07723914e-01f, -3.86191338e-01f, 2.77231663e-01f, -2.07908183e-01f, -2.49067843e-01f, -1.03654020e-01f,
  8.46325830e-02f, 1.29551530e-01f, -6.26290888e-02f, -4.04789567e-01f, 5.49713373e-02f, -1.67650804e-02f, 2.48686150e-02f, 2.07635269e-01f, 8.15395042e-02f, 1.06743455e-01f,
  -1.11271217e-01f, 1.59375310e-01f, 2.60356665e-01f, 4.17200267e-01f, 1.77667215e-01f, -8.50973502e-02f, 1.00308089e-02f, -1.99085981e-01f, -3.91909003e-01f, -2.65916675e-01f,
  3.68304342e-01f, 4.53858264e-02f, 2.25867763e-01f, 7.32256994e-02f, -9.69930589e-02f, 2.68622935e-01f, -3.18110526e-01f, 1.65917501e-01f, 5.14681116e-02f, -2.85080094e-02f,
  -6.02739723e-03f, 1.06616311e-01f, -6.35813400e-02f, 2.03384101e-01f, 1.43371671e-01f, 6.75509870e-02f, 3.01630404e-02f, 2.69077033e-01f, 1.36613175e-02f, 1.47897348e-01f,
  2.29115069e-01f, -1.32054880e-01f, 6.72285035e-02f, 2.66950965e-01f, 2.32429788e-01f, 2.28426352e-01f, 1.71040118e-01f, 3.61472964e-01f, -2.03701202e-02f, 1.66701853e-01f,
  1.37132868e-01f, 1.57667935e-01f, 8.93172026e-02f, 3.07591856e-02f, 6.23895228e-02f, 4.69769314e-02f, -6.78622946e-02f, -3.89623046e-02f, 1.04115702e-01f, -1.83736488e-01f,
  -9.75854248e-02f, -2.40143791e-01f, -8.36650282e-02f, 4.83312123e-02f, 2.23700792e-01f, -7.24339439e-03f, -2.92883404e-02f, -7.99131468e-02f, -3.24405730e-01f, 9.83354375e-02f,
  2.24808261e-01f, 1.60358027e-01f, -9.86255854e-02f, 5.86121455e-02f, -1.40177339e-01f, -1.23989023e-01f, -2.18699574e-02f, 1.39395133e-01f, 5.41748181e-02f, -8.07853788e-02f,
  3.03548813e-01f, 2.36177877e-01f, -1.73435241e-01f, 1.46181613e-01f, 3.17253053e-01f, 4.19697195e-01f, 7.95653313e-02f, -5.52782118e-02f, 1.33528292e-01f, 7.08957110e-03f,
  2.99956888e-01f, 7.83520564e-02f, -1.15451664e-01f, 6.94455206e-02f, -3.75949172e-03f, -1.40454441e-01f, 7.93149769e-02f, 7.08576813e-02f, 2.32300870e-02f, 2.38888800e-01f,
  -9.16892216e-02f, 1.14930131e-01f, 3.57576758e-01f, 2.53048278e-02f, -1.96350694e-01f, 1.19765513e-01f, 4.27469283e-01f, 1.82165131e-01f, 2.32717395e-01f, 8.55720639e-02f,
  -7.84150586e-02f, -1.22514613e-01f, -1.97068959e-01f, 1.32121846e-01f, 3.89054388e-01f, 2.23519616e-02f, 8.17825124e-02f, 2.12563146e-02f, 2.00509086e-01f, 2.27540076e-01f,
  4.42770608e-02f, 1.35663256e-01f, -1.66503593e-01f, 2.18852147e-01f, -2.11882129e-01f, -1.28392681e-01f, 1.26368657e-01f, -9.04310197e-02f, 2.71813512e-01f, -7.68511817e-02f,
  2.21254937e-02f, 2.29854956e-01f, 2.41857648e-01f, -8.40476751e-02f, -1.00884505e-01f, -8.70952681e-02f, 2.22909618e-02f, 1.05477072e-01f, 2.28024900e-01f, 1.87515512e-01f,
  7.58115202e-03f, -4.32590023e-02f, -1.37334666e-03f, -5.27929030e-02f, -1.14222758e-01f, 5.40146083e-02f, 7.96036571e-02f, 1.98463410e-01f, 7.83207417e-02f, -9.98288468e-02f,
  -2.41861143e-03f, -1.94372937e-01f, 3.34483147e-01f, 2.13087842e-01f, -2.89542060e-02f, 1.70768514e-01f, 3.01022734e-02f, -1.19207524e-01f, -7.13331327e-02f, -1.39958620e-01f,
  3.08776721e-02f, 1.72690347e-01f, 2.68517315e-01f, 8.02958459e-02f, -3.33159953e-01f, 1.82388902e-01f, 2.83479065e-01f, 2.16884166e-01f, 2.69275755e-01f, 8.30419734e-02f,
  2.45406479e-01f, -1.80300444e-01f, 1.63121000e-01f, -9.45084468e-02f, -7.43137300e-02f, 1.24091007e-01f, -1.10124186e-01f, 3.00515443e-01f, -1.03806980e-01f, 2.61089861e-01f,
  1.21310987e-01f, 1.53753191e-01f, -2.59914249e-02f, 3.91975977e-02f, 3.24118929e-03f, 3.11321821e-02f, -1.53110161e-01f, -4.29617554e-01f, 3.41929436e-01f, -3.78649503e-01f,
  2.80322731e-01f, 2.58773953e-01f, -6.94710296e-03f, -1.19970493e-01f, 7.77356550e-02f, 3.53646934e-01f, -2.03868207e-02f, -3.12899232e-01f, -1.65098876e-01f, 4.27480906e-01f,
  -2.43907690e-01f, 2.93126673e-01f, 2.31584221e-01f, 3.18100810e-01f, -1.18132636e-01f, 3.31826389e-01f, 8.31874609e-02f, 3.31300646e-01f, -1.33392826e-01f, 3.45084876e-01f,
  7.14093596e-02f, 9.12067220e-02f, 3.18031907e-01f, 1.80792063e-01f, -3.07564139e-02f, 1.73649982e-01f, 2.60573834e-01f, -4.94520087e-03f, 7.37500656e-03f, 4.58509661e-02f,
  -3.82667966e-02f, -1.93456680e-01f, -4.00439948e-02f, 1.11156054e-01f, 2.17069611e-01f, 1.11485593e-01f, 1.36768267e-01f, 1.12466924e-01f, 2.51133472e-01f, -8.61596018e-02f,
  1.93745300e-01f, -5.22052385e-02f, 8.86372104e-02f, 1.24789774e-01f, 1.54806256e-01f, -7.80214146e-02f, 4.85316291e-02f, 6.92514926e-02f, -3.56593020e-02f, 1.21697538e-01f,
  2.17225894e-01f, -1.01403771e-02f, -1.20328970e-01f, 1.14309564e-01f, 3.51206921e-02f, 2.43194044e-01f, 4.69369814e-02f, 1.08399130e-01f, 6.44165501e-02f, 3.12559366e-01f,
  1.86387688e-01f, 3.37589651e-01f, -4.29191589e-01f, 1.29927501e-01f, -7.10292608e-02f, -8.77764896e-02f, 2.25755200e-01f, 3.60129416e-01f, 3.14275295e-01f, -2.26691198e-02f,
  -9.47680045e-03f, 4.13950980e-01f, 3.22067946e-01f, -7.31351376e-02f, 8.34211111e-02f, -1.94786608e-01f, -1.58696324e-01f, -6.21089488e-02f, 3.09455395e-01f, -3.56404632e-02f,
  2.91120142e-01f, -9.58675519e-02f, 1.37631565e-01f, -1.10646218e-01f, 5.51333129e-02f, 1.11113280e-01f, -8.39355681e-03f, -4.33428213e-03f, -3.48116569e-02f, -9.04131215e-03f,
  2.42914990e-01f, 7.76130408e-02f, 2.16133758e-01f, 2.35048696e-01f, -3.18727791e-02f, 1.70333236e-01f, 2.36122146e-01f, -5.09482995e-02f, 3.71809214e-01f, 2.79193938e-01f,
  -9.31054354e-02f, 2.70292997e-01f, -1.55989021e-01f, 1.10968314e-01f, 3.68812412e-01f, 2.17930213e-01f, -2.38923877e-02f, 8.59424695e-02f, 3.20029944e-01f, 3.79322916e-01f,
  9.14111808e-02f, 7.95624405e-02f, 1.26787741e-02f, 7.81673044e-02f, -3.72673690e-01f, -5.85640334e-02f, 3.83665979e-01f, -7.58356554e-03f, 1.44413054e-01f, 9.71831679e-02f,
  -6.42212406e-02f, -6.51579276e-02f, 8.84105160e-04f, -2.08798721e-02f, 2.16336027e-01f, -1.16807915e-01f, -2.84842789e-01f, -3.70403416e-02f, 2.83820122e-01f, 5.64167164e-02f,
  7.91648179e-02f, 6.22758046e-02f, -6.40482232e-02f, -3.21894437e-02f, -1.72130868e-01f, -1.67138696e-01f, 7.65572190e-02f, -8.70863348e-02f, -1.10652022e-01f, 6.81992471e-02f,
  2.67787337e-01f, 2.51844078e-01f, -6.39299899e-02f, 2.47557133e-01f, 2.60456085e-01f, -1.47711515e-01f, -9.00764018e-02f, 3.64822656e-01f, -1.62842676e-01f, 2.25942791e-01f,
  2.25560337e-01f, -5.13683148e-02f, -2.76749194e-01f, 1.24240473e-01f, 2.34339595e-01f, 2.45848924e-01f, -2.03543529e-01f, 3.05593759e-01f, 3.50333005e-01f, -1.11585386e-01f,
  -1.63339764e-01f, 4.43423204e-02f, 1.82699844e-01f, 4.17792439e-01f, 7.95937926e-02f, -7.85886589e-03f, -1.76090285e-01f, -9.27987322e-02f, 9.68551263e-02f, -1.33036569e-01f,
  6.82418048e-02f, 9.04458910e-02f, 1.70244634e-01f, 2.30463654e-01f, -1.70904975e-02f, 3.40416402e-01f, -3.10830195e-02f, 5.82097508e-02f, 1.06436163e-01f, 2.50871003e-01f,
  3.45294416e-01f, 5.73548600e-02f, 9.28174052e-03f, 2.25853492e-02f, 1.22659698e-01f, 1.19520426e-01f, 1.43023342e-01f, 1.28162891e-01f, 1.53354436e-01f, -1.86869726e-01f,
  -2.13493221e-02f, 1.29150882e-01f, -1.50702924e-01f, 1.94045752e-01f, 3.55954260e-01f, -2.39441618e-01f, 1.16055839e-01f, -2.79012084e-01f, 1.57678768e-01f, 2.52366960e-01f,
  1.47216201e-01f, -1.88513938e-02f, 3.74224521e-02f, 5.20485342e-02f, 2.14206770e-01f, 1.21602230e-01f, 1.70038685e-01f, 1.53295636e-01f, -1.08333848e-01f, -1.11769680e-02f,
  3.60511661e-01f, -2.73226231e-01f, -9.28640291e-02f, -6.81599006e-02f, 2.02597320e-01f, 1.42926663e-01f, 9.98493806e-02f, -2.48333707e-01f, -1.81080684e-01f, 9.16337818e-02f,
  3.18140924e-01f, 2.15041980e-01f, 1.25372574e-01f, 1.71048194e-01f, -1.51746318e-01f, 1.59878656e-01f, -1.07957795e-01f, 2.95784306e-02f, 2.11757526e-01f, -1.26679558e-02f,
  1.28288984e-01f, -1.24628149e-01f, 2.23622628e-04f, -4.22492437e-02f, 2.40727395e-01f, -1.13126837e-01f, -1.69393957e-01f, 1.19400643e-01f, 1.89117789e-02f, 1.24693714e-01f,
  2.36612875e-02f, 2.53550977e-01f, -1.39997937e-02f, 4.77223657e-02f, -1.58379488e-02f, 2.92430818e-01f, -2.72737574e-02f, 1.07408114e-01f, 1.33323759e-01f, -9.82427504e-03f,
  -1.28738850e-01f, 7.51608312e-02f, 4.77893323e-01f, -1.77739292e-01f, 4.27921623e-01f, -1.52201369e-01f, -1.29521385e-01f, -1.23975731e-01f, -4.33381170e-01f, 1.02134764e-01f,
  -2.72906840e-01f, -8.51537228e-01f, -4.17424142e-02f, 2.19223440e-01f, 2.22367287e-01f, -3.66614401e-01f, 4.15017921e-03f, 3.34371179e-01f, -3.06909438e-02f, 3.11079562e-01f,
  1.87572628e-01f, 4.37968910e-01f, 4.96004373e-01f, -2.64237732e-01f, -1.01352103e-01f, -5.11993878e-02f, -4.51509237e-01f, -3.90964299e-01f, 1.99281096e-01f, -3.40731055e-01f,
  1.34265363e-01f, 3.04749578e-01f, -2.44121745e-01f, 4.36284468e-02f, -3.62156808e-01f, -1.16046116e-01f, 5.64767122e-02f, 3.71150404e-01f, -1.08257495e-03f, -4.34148051e-02f,
  1.07705764e-01f, -5.84820211e-01f, 1.91574708e-01f, -1.54304206e-01f, 3.99970971e-02f, 1.53741598e-01f, 9.21947137e-02f, 8.67942646e-02f, 1.66416600e-01f, 1.28206730e-01f,
  -6.47233546e-01f, 1.46617696e-01f, 3.53152245e-01f, 4.61974472e-01f, -1.53722670e-02f, 2.78751791e-01f, -4.91353823e-03f, 1.04812026e-01f, 1.60744879e-02f, -1.30677104e-01f,
  1.52882218e-01f, 7.85560235e-02f, -1.79990903e-02f, 1.50660574e-01f, -1.32853016e-01f, -1.70995399e-01f, -2.38558263e-01f, -2.58766860e-01f, 3.43054906e-02f, -9.35713351e-02f,
  2.51201510e-01f, 7.35446904e-03f, -4.22623068e-01f, 3.01885098e-01f, 7.58066867e-03f, 3.93509865e-01f, 9.20231640e-02f, -3.53600860e-01f, -6.62134634e-03f, 1.28285423e-01f,
  5.13206758e-02f, 3.03916186e-01f, 2.30833814e-01f, 1.64032262e-02f, -4.20285225e-01f, 9.60848201e-03f, -1.21840909e-01f, 4.70109105e-01f, -1.71919182e-01f, 4.25482243e-01f,
  4.47927177e-01f, 4.55350339e-01f, -2.29806393e-01f, 2.22262830e-01f, 9.47352499e-03f, 3.74475300e-01f, 4.21121538e-01f, -2.27519304e-01f, 1.01926833e-01f, -1.86415464e-01f,
  1.58271417e-01f, 2.28294916e-02f, 1.83580205e-01f, 3.12091827e-01f, 9.17369947e-02f, 2.70862341e-01f, -1.96294233e-01f, -8.32742155e-02f, 2.58523494e-01f, -1.65274531e-01f,
  -1.14984736e-01f, -2.47682407e-01f, -2.20014304e-01f, 2.02649310e-01f, -7.45503604e-02f, -4.70442101e-02f, -1.10974543e-01f, -4.29384708e-02f, 2.66050667e-01f, -8.05138424e-02f,
  5.94341516e-01f, 2.38495156e-01f, -2.29225650e-01f, -2.22359106e-01f, 3.62435840e-02f, 6.17221463e-03f, 3.05321217e-01f, 1.66724950e-01f, 2.23852292e-01f, 4.63991389e-02f,
  2.28039250e-01f, -9.51815099e-02f, -1.03399821e-01f, 3.61832321e-01f, -6.91167712e-02f, -1.37843266e-02f, 1.15404613e-01f, 1.93784565e-01f, 2.73244858e-01f, 9.62489918e-02f,
  1.57716498e-01f, 3.76116782e-01f, 1.77904576e-01f, 2.25247249e-01f, 1.51890025e-01f, -9.87137929e-02f, 3.16414647e-02f, -2.04070956e-01f, 1.61706820e-01f, -1.34911060e-01f,
  1.36747047e-01f, 2.55884945e-01f, 2.71192431e-01f, -2.86100864e-01f, 1.49050474e-01f, 8.83756131e-02f, -2.41066933e-01f, 1.14824556e-01f, 1.26925305e-01f, 1.24951594e-01f,
  -1.51223570e-01f, -4.41226512e-02f, 2.63325423e-01f, -1.32908151e-01f, 1.92776993e-01f, 2.43262991e-01f, 3.37622195e-01f, 3.75133365e-01f, 6.79079592e-02f, -6.85179010e-02f,
  -2.16033985e-03f, -1.03640854e-01f, 4.08866137e-01f, 2.24249699e-04f, -1.34694055e-01f, 2.74464548e-01f, -5.02195172e-02f, 1.79125935e-01f, -2.89523184e-01f, 1.86897874e-01f,
  -1.93601057e-01f, 8.15466493e-02f, 2.26822831e-02f, 9.36655924e-02f, 1.87485352e-01f, -1.20785624e-01f, 9.53517929e-02f, -1.42964721e-01f, 2.25229472e-01f, -4.79615889e-02f,
  8.65561364e-04f, 9.22595635e-02f, 1.70197472e-01f, 8.13808218e-02f, -3.59963506e-01f, 4.26859319e-01f, -2.28389338e-01f, -1.30584687e-01f, -1.15731940e-01f, -8.33402425e-02f,
  7.54199252e-02f, 2.76756972e-01f, -2.41556644e-01f, 1.81012258e-01f, -1.04733549e-01f, 1.00779720e-01f, -4.21875454e-02f, -2.77751386e-01f, -1.55131087e-01f, -3.70119065e-02f,
  6.50547519e-02f, 1.67384908e-01f, 6.94848672e-02f, 7.22848549e-02f, 1.81494907e-01f, -2.17198223e-01f, -1.15459189e-01f, -2.72620451e-02f, 2.35664576e-01f, -9.70927924e-02f,
  5.12163248e-03f, -4.90395399e-03f, -1.52820991e-02f, 2.35767812e-01f, 2.97248214e-01f, 5.26826493e-02f, -8.20327401e-02f, -4.54760268e-02f, 1.01151079e-01f, 1.08721472e-01f,
  1.69402331e-01f, 1.31913632e-01f, 1.35880843e-01f, -6.99118450e-02f, -2.24471778e-01f, 4.80347902e-01f, -5.57801984e-02f, 2.11776406e-01f, 3.90838623e-01f, 1.03114091e-01f,
  -9.95666981e-02f, 1.75497662e-02f, 1.34929299e-01f, -8.43962934e-03f, 1.63099483e-01f, -1.43533200e-01f, 3.61687578e-02f, -2.47155115e-01f, -3.28561991e-01f, 4.04388011e-02f,
  5.43448366e-02f, -1.62409216e-01f, 2.40137279e-01f, 5.00640832e-03f, 2.06672221e-01f, 1.92190900e-01f, 1.78200990e-01f, 1.99416861e-01f, -1.89183533e-01f, 4.53853279e-01f,
  -3.10958415e-01f, 2.05453962e-01f, 2.71977335e-02f, -1.78709239e-01f, 2.69561827e-01f, 8.00482929e-02f, 5.19963801e-02f, -3.60351056e-02f, 7.90130571e-02f, 4.34605718e-01f,
  1.59483269e-01f, -1.92287549e-01f, 2.26649210e-01f, -1.86327919e-01f, 2.04104017e-02f, -9.10024047e-02f, 2.58878112e-01f, -2.54101962e-01f, 2.33089387e-01f, -1.03560477e-01f,
  1.72705367e-01f, -2.13380188e-01f, 1.79663077e-01f, 1.81326821e-01f, -2.22148299e-01f, 1.21214502e-01f, 2.59094555e-02f, -4.64557707e-02f, 1.52130097e-01f, 2.06900552e-01f,
  2.10698381e-01f, 2.25771874e-01f, 2.67110914e-01f, 2.00516433e-01f, 1.60744727e-01f, -7.77962506e-02f, 1.75703138e-01f, -2.37184241e-02f, 7.60893011e-03f, 2.21811622e-01f,
  -1.82483643e-01f, 1.41062617e-01f, 3.40649933e-01f, 3.52924794e-01f, 2.47590221e-03f, 5.04002497e-02f, 4.44223359e-02f, 1.62721187e-01f, 2.31259197e-01f, -1.55246388e-02f,
  2.58898269e-02f, -8.61961097e-02f, -3.10285151e-01f, -2.45291237e-02f, 1.13037348e-01f, -4.30269662e-04f, 1.34599596e-01f, 1.84051484e-01f, 4.38946262e-02f, 7.97333866e-02f,
  -1.73763677e-01f, -5.42368069e-02f, 2.86129028e-01f, -3.03337932e-01f, 2.25709118e-02f, 2.20259726e-02f, 3.04249525e-01f, 2.69838750e-01f, 1.37501501e-03f, 5.47332317e-02f,
  2.62672871e-01f, 1.76095501e-01f, -2.63929695e-01f, 1.34896904e-01f, 2.16794550e-01f, 1.65094286e-01f, -7.12139159e-02f, -6.62977099e-02f, 1.20672457e-01f, -1.86650768e-01f,
  7.32456148e-02f, 7.67876357e-02f, -6.40425086e-02f, 3.09867561e-01f, 8.47580880e-02f, 2.78764844e-01f, -1.90843008e-02f, 3.60621065e-01f, 2.22044900e-01f, 2.04609543e-01f,
  -1.12323329e-01f, 2.07285717e-01f, -1.20979853e-01f, -1.25037596e-01f, 3.18932235e-01f, -1.53436318e-01f, -2.04425141e-01f, 2.36981720e-01f, 6.67198747e-03f, 1.08939148e-01f,
  6.72550797e-02f, 8.02541822e-02f, 9.64494422e-03f, -2.36091048e-01f, 7.00545833e-02f, -2.34448798e-02f, -9.23668314e-03f, -2.08463892e-01f, 2.14560516e-02f, 3.60075951e-01f,
  1.72583565e-01f, 2.79834330e-01f, -7.47755840e-02f, 2.18337402e-01f, -6.53182492e-02f, 1.25687748e-01f, 1.89507455e-01f, -6.97893500e-02f, 2.53497064e-01f, -7.57449940e-02f,
  2.37636253e-01f, 1.20106339e-01f, 1.34707004e-01f, 1.30170703e-01f, -1.28181964e-01f, 5.35830632e-02f, 2.08509892e-01f, -2.42146805e-01f, 3.80645394e-02f, 4.23049517e-02f,
  3.04733992e-01f, 1.80968538e-01f, 9.68655422e-02f, 3.57892201e-03f, 2.36418590e-01f, 2.02273011e-01f, -1.57617539e-01f, -3.15183908e-01f, 4.19158489e-03f, 3.13921839e-01f,
  -3.26543540e-01f, -2.96591669e-01f, 7.04367608e-02f, 7.18951076e-02f, -1.04446346e-02f, 1.23354681e-02f, 6.69239014e-02f, 3.61511737e-01f, -1.13402698e-02f, 5.80204353e-02f,
  1.53164208e-01f, 5.36743999e-02f, 1.25640675e-01f, -1.12252198e-01f, 4.30427343e-02f, 2.90399283e-01f, 4.23579775e-02f, 1.46333322e-01f, -7.38962740e-02f, 1.17311671e-01f,
  2.95138389e-01f, 1.44269571e-01f, 8.14851299e-02f, 1.26456082e-01f, 4.16614413e-01f, 3.49334538e-01f, 2.53281921e-01f, 9.14111286e-02f, 1.99682593e-01f, -2.01378196e-01f,
  1.39479667e-01f, -2.22135127e-01f, 1.39453843e-01f, 2.76402950e-01f, 1.08992562e-01f, 2.01003477e-02f, -5.07973023e-02f, 2.41648272e-01f, -1.45288810e-01f, 5.40215634e-02f,
  3.20848189e-02f, -1.89017892e-01f, -3.88503238e-03f, 1.53798401e-01f, 7.28806779e-02f, 3.67649272e-02f, 1.64512694e-01f, 7.81062543e-02f, 1.62884966e-01f, 1.67524442e-01f,
  -1.57767326e-01f, 1.81628019e-01f, 2.89269760e-02f, -3.17917503e-02f, -2.53843278e-01f, -3.23820919e-01f, 1.48576364e-01f, 2.64082998e-01f, 6.50560856e-02f, -1.26424685e-01f,
  3.34642380e-01f, 1.39036164e-01f, -1.40637994e-01f, -1.58194512e-01f, 2.07116827e-01f, 1.15137808e-01f, -1.40287817e-01f, 5.25724255e-02f, 2.92479575e-01f, -4.17141132e-02f,
  6.90353885e-02f, -1.02980062e-02f, -2.13474147e-02f, -2.42488846e-01f, 2.23974407e-01f, -6.92904592e-02f, 8.33680183e-02f, -1.40547439e-01f, 9.69514251e-02f, 2.49039964e-03f,
  2.02444512e-02f, 2.18545228e-01f, -3.01704556e-01f, -1.25599757e-01f, -1.37079850e-01f, 8.22297037e-02f, 2.24514917e-01f, 1.25969216e-01f, -1.05350755e-01f, -1.13151491e-01f,
  1.32150397e-01f, 1.22311696e-01f, 1.22379728e-01f, 1.11447319e-01f, 1.05734713e-01f, 2.38865212e-01f, 1.77862138e-01f, -2.93168798e-02f, -1.25989467e-01f, 1.93527684e-01f,
  4.05346863e-02f, 1.47758499e-01f, 3.82461965e-01f, 2.09845439e-01f, -1.10097364e-01f, -4.63083386e-02f, -8.30275789e-02f, 1.14328735e-01f, 1.13654450e-01f, 4.35593091e-02f,
  4.42632996e-02f, 8.58505145e-02f, -1.70551129e-02f, -2.55754050e-02f, 1.05382107e-01f, 2.44685542e-02f, -2.13445023e-01f, -3.13516892e-02f, 7.83407986e-02f, -2.19651088e-01f,
  -1.66477878e-02f, 1.40701616e-02f, 1.73869088e-01f, 8.03474560e-02f, 7.23192319e-02f, 1.27336174e-01f, 2.05090165e-01f, 9.66988057e-02f, 2.15087682e-01f, 2.14374259e-01f,
  -6.14229180e-02f, -1.77418366e-01f, 1.36622936e-01f, 1.94094092e-01f, 2.70840377e-01f, -1.48524746e-01f, -9.68063027e-02f, 2.71021843e-01f, -9.95182246e-02f, 2.12699152e-03f,
  2.72937715e-01f, 2.60147184e-01f, -1.17711313e-01f, -9.52461287e-02f, 1.81689367e-01f, 1.65199280e-01f, 1.07393540e-01f, -2.39248853e-02f, -6.85742348e-02f, -3.39820683e-02f,
  -2.15619415e-01f, -1.91289291e-01f, -7.41721643e-03f, 1.39669180e-02f, -1.22386396e-01f, 4.70909886e-02f, -3.13820362e-01f, 3.18950713e-01f, 2.89660543e-01f, -6.42843544e-03f,
  -2.06452146e-01f, -3.96002717e-02f, 2.00188011e-01f, 1.70706049e-01f, 9.81553495e-02f, 2.91390508e-01f, 1.17722124e-01f, 1.22736268e-01f, 1.25369549e-01f, 2.16914952e-01f,
  3.05301875e-01f, -5.56397066e-02f, 6.60560131e-02f, 9.60299522e-02f, 2.62976527e-01f, -2.43170876e-02f, 3.54031436e-02f, 1.77026361e-01f, 2.03205526e-01f, -8.34751278e-02f,
  -9.38231125e-02f, 3.36637050e-01f, 2.90138200e-02f, 1.72318801e-01f, 1.52894795e-01f, 9.19362456e-02f, 1.07652336e-01f, -7.91214779e-02f, -4.58358228e-02f, 2.29907081e-01f,
  1.39527202e-01f, 1.93654507e-01f, 1.06885992e-01f, -2.24091113e-01f, 7.54094198e-02f, -6.42725974e-02f, 3.03475291e-01f, 1.41636938e-01f, 5.81684597e-02f, 5.91072515e-02f,
  3.41363132e-01f, -9.68247652e-02f, 6.71990514e-02f, 1.07102044e-01f, -1.17885999e-01f, 1.84001580e-01f, 1.99699461e-01f, 2.99830049e-01f, -9.74013209e-02f, -1.63686201e-02f,
  1.92577779e-01f, 6.65304884e-02f, 2.78685898e-01f, 1.54469460e-01f, 3.11416179e-01f, 3.24803203e-01f, 2.87222773e-01f, 8.53796527e-02f, 1.34805599e-02f, -1.86193306e-02f,
  3.49455535e-01f, -1.20589342e-02f, 1.20415008e-02f, -6.94816038e-02f, 1.54211730e-01f, 7.08672702e-02f, -2.07045659e-01f, 2.66498953e-01f, -2.04400748e-01f, 5.97031303e-02f,
  -2.83923112e-02f, 5.71032614e-02f, 8.16897675e-03f, -2.40651950e-01f, 1.78779662e-01f, -5.34557812e-02f, 1.81161731e-01f, 1.25226885e-01f, -2.65143923e-02f, 2.27471292e-01f,
  9.19484813e-03f, -4.69013676e-02f, 3.50413769e-01f, 1.13433696e-01f, -3.73365125e-03f, 9.89886001e-02f, 2.89445043e-01f, 1.16534550e-02f, -1.86003163e-01f, 2.81091839e-01f,
  2.90910006e-01f, 2.00327680e-01f, -1.18407831e-01f, 1.96479544e-01f, 3.45778316e-01f, -5.09671010e-02f, 7.62004703e-02f, -2.28075802e-01f, -1.91998661e-01f, -2.48667434e-01f,
  1.77443713e-01f, 7.89572969e-02f, 1.08672850e-01f, 2.44813770e-01f, -2.93462258e-02f, -1.10168889e-01f, 6.93675950e-02f, 1.71063408e-01f, 1.14123516e-01f, -5.55501916e-02f,
  -1.34022638e-01f, 1.55271187e-01f, 7.79659674e-02f, 1.00967288e-01f, 1.73991546e-01f, 2.08445378e-02f, -1.48725241e-01f, 2.76589721e-01f, 6.16573691e-02f, 8.42538923e-02f,
  1.97364464e-01f, -3.52645628e-02f, 1.30158011e-02f, 1.41238943e-01f, -2.30761673e-02f, 2.95359462e-01f, 2.63248056e-01f, 2.14220211e-01f, 1.24040414e-02f, 6.35952055e-02f,
  8.26692730e-02f, 2.64787555e-01f, 1.54177159e-01f, 2.68406332e-01f, -3.39505747e-02f, -5.08858217e-03f, -6.55430555e-02f, -1.30092874e-02f, 2.87005454e-01f, 8.68758745e-03f,
  -2.27708146e-02f, 2.34394118e-01f, 3.76900248e-02f, -3.41898948e-02f, 6.22923337e-02f, 4.34699319e-02f, -1.16405375e-01f, -2.40173042e-01f, 3.10277760e-01f, -2.20120251e-01f,
  4.48937155e-03f, -3.26868035e-02f, -1.13485031e-01f, -1.21149801e-01f, -1.80013420e-03f, 9.67389196e-02f, 2.88727224e-01f, -6.02699891e-02f, -1.82903126e-01f, -1.63194895e-01f,
  2.62038648e-01f, 2.50273556e-01f, 1.58512220e-01f, 1.55905470e-01f, 5.37188612e-02f, 2.31277838e-01f, -2.84707006e-02f, -1.46516353e-01f, 1.67603083e-02f, 4.06595796e-01f,
  -1.33036286e-01f, 2.12454677e-01f, 1.67203680e-01f, -1.51559800e-01f, 1.76776931e-01f, 1.95685923e-02f, 1.27670005e-01f, -6.53317273e-02f, -2.16799062e-02f, -2.90033501e-02f,
  -1.59195200e-01f, 2.19242107e-02f, -1.73286185e-01f, -1.32013693e-01f, -7.16127530e-02f, -3.22279513e-01f, 6.46804050e-02f, -1.44515380e-01f, -9.86303017e-02f, 1.42185032e-01f,
  5.80004137e-03f, 1.00138217e-01f, 3.85775752e-02f, -1.74903888e-02f, -3.27093333e-01f, -2.99960315e-01f, 2.10729539e-01f, 6.36276379e-02f, 1.14733920e-01f, 2.72208840e-01f,
  2.57543564e-01f, 3.30369383e-01f, -3.97039235e-01f, 6.27039745e-02f, 7.11811259e-02f, 5.34353107e-02f, 1.15521505e-01f, 2.13618740e-01f, 2.32849866e-01f, 3.03734094e-01f,
  -2.86828667e-01f, -1.61270961e-01f, 2.65191853e-01f, -7.53684267e-02f, -1.07622057e-01f, 1.82283610e-01f, 6.54613152e-02f, 4.00248617e-02f, -9.76375118e-03f, 1.16079770e-01f,
  2.33457033e-02f, 2.35937573e-02f, -2.35576510e-01f, 2.49190733e-01f, 4.91261296e-02f, -1.24615736e-01f, 1.01277098e-01f, 3.58936995e-01f, 2.29283303e-01f, 1.50617123e-01f,
  2.19089389e-01f, 2.63160080e-01f, -5.08068018e-02f, -2.51395702e-02f, 1.64927989e-01f, 1.47786200e-01f, 4.06499691e-02f, 2.63694394e-02f, 1.00986928e-01f, 3.07480395e-01f,
  3.24259996e-01f, -2.49257218e-02f, -1.44547299e-01f, 4.03926801e-03f, 1.07390180e-01f, -1.67495683e-01f, 2.83081979e-01f, 2.99176663e-01f, 3.66986871e-01f, -4.83519323e-02f,
  1.28992781e-01f, 2.16392457e-01f, 2.64181435e-01f, -2.15238839e-01f, -3.35892439e-02f, 1.59122109e-01f, 1.63032487e-01f, 3.21442842e-01f, -2.76107818e-01f, -1.06270596e-01f,
  -6.86242059e-02f, -1.19751126e-01f, 8.26853141e-02f, 1.04256265e-01f, 2.06854433e-01f, -1.37061357e-01f, -3.14776778e-01f, -9.43518709e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.86825797e-01f, 2.25463048e-01f, 1.21185251e-01f, 1.21700495e-01f, 1.56980351e-01f, 2.36896016e-02f, 4.07151468e-02f, 1.63553402e-01f, 1.43130004e-01f, 9.86124724e-02f,
  7.94152766e-02f, 1.13965429e-01f, -3.33038718e-02f, 2.51653939e-01f, 1.16934083e-01f, 2.01692313e-01f, 2.15150401e-01f, 1.39050528e-01f, 9.61011201e-02f, -3.89921404e-02f,
  2.15545148e-01f, -1.16149865e-01f, 1.52138308e-01f, 3.12551074e-02f, 2.38498431e-02f, 1.27001971e-01f, 3.62665989e-02f, 1.97767422e-01f, 2.64582306e-01f, 1.44593999e-01f,
  9.07186791e-02f, 2.26447329e-01f, 4.97612320e-02f, 1.02613859e-01f, 5.91279306e-02f, 2.12651953e-01f, 1.81040987e-01f, -6.45125192e-03f, 1.57779932e-01f, 1.21105433e-01f,
  1.02294393e-01f, 2.37274960e-01f, 4.15074639e-02f, 9.44796875e-02f, 1.13448530e-01f, 5.71991429e-02f, -1.40179535e-02f, 2.08732679e-01f, 2.23229498e-01f, 1.65895015e-01f,
  -3.95798218e-03f, 1.32675216e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.06400453e-01f, -3.59677263e-02f, -8.43205154e-02f, -1.62362799e-01f, -4.97429445e-03f, -4.92820740e-02f, 3.73658359e-01f, -4.81413044e-02f, -2.01699108e-01f, 2.73864657e-01f,
  -1.39954880e-01f, -2.40570650e-01f, 9.30569991e-02f, -1.02299988e-01f, -2.96070844e-01f, 2.43712619e-01f, -3.52803022e-01f, -1.61965311e-01f, -4.13770229e-03f, -3.26012671e-01f,
  3.41776222e-01f, -2.49977529e-01f, -2.04265147e-01f, 7.44138705e-03f, -1.81302413e-01f, 3.13107550e-01f, 2.49314196e-02f, -8.36300198e-03f, 3.02152574e-01f, 6.71481490e-02f,
  1.09773129e-01f, -2.95226127e-01f, 2.73691446e-01f, -1.27137154e-01f, -3.79037976e-01f, -3.03929240e-01f, -1.75495520e-01f, 1.69086792e-02f, -1.27853319e-01f, 2.78573692e-01f,
  2.38575280e-01f, -3.53422701e-01f, 3.10734749e-01f, -3.60600352e-01f, -1.42571658e-01f, -9.63629112e-02f, 3.79793928e-03f, 6.86130598e-02f, -4.90227789e-01f, 1.23283856e-01f,
  -1.86618611e-01f, -7.71488130e-01f, 3.55567247e-01f, -2.22149879e-01f, -3.55003715e-01f, -4.31152403e-01f, 3.28139006e-03f, -4.42035466e-01f, -8.93632621e-02f, 2.41401866e-01f,
  -3.53200942e-01f, -4.89341021e-01f, 2.19560072e-01f, -1.86468050e-01f, 1.44547403e-01f, 7.59572443e-03f, 5.55926636e-02f, -1.84318293e-02f, 9.21064243e-02f, -1.44164503e-01f,
  7.66485929e-02f, -1.95535675e-01f, -2.33411118e-01f, -1.12130567e-02f, -2.83477813e-01f, -3.33391339e-01f, -4.01017189e-01f, -4.02703464e-01f, 1.34119883e-01f, -5.30990846e-02f,
  1.93794161e-01f, 1.78165793e-01f, 1.29274487e-01f, -9.89584923e-02f, 7.39189535e-02f, -1.10075474e-01f, -3.68350409e-02f, -3.66191864e-01f, -2.47102946e-01f, 2.05522090e-01f,
  2.72014856e-01f, -2.74610996e-01f, -4.19569910e-01f, 9.92869586e-02f, 1.67022929e-01f, 2.18537062e-01f, 1.74545974e-01f, -7.07687065e-02f, -5.40390648e-02f, 3.21326643e-01f,
  1.57267544e-02f, -3.51702273e-02f, 8.56881775e-03f, 2.38050763e-02f, -2.12995648e-01f, -2.45626062e-01f, 2.82487981e-02f, -3.16439807e-01f, 2.46735483e-01f, -1.69423148e-01f,
  1.42546579e-01f, 5.73641025e-02f, -4.15875196e-01f, -1.58294201e-01f, 1.59851640e-01f, 6.47046149e-01f, -4.63014781e-01f, -3.85723114e-01f, -1.29074529e-01f, -3.26150686e-01f,
  -3.08989406e-01f, -2.16522843e-01f, 1.45934343e-01f, -1.06577195e-01f, -3.66219848e-01f, -2.29415923e-01f, 3.27958018e-01f, 2.19785701e-02f, 4.84475084e-02f, -8.74680951e-02f,
  1.46817463e-02f, 9.31017622e-02f, 5.82170710e-02f, -2.50207586e-03f, -2.92225212e-01f, 1.29222319e-01f, 4.95348237e-02f, 1.51453018e-01f, 2.37007275e-01f, -2.10604165e-02f,
  -1.52558431e-01f, -2.75546521e-01f, 9.03100967e-02f, -2.08719403e-01f, 1.92715317e-01f, 2.14862540e-01f, 3.99981849e-02f, -1.91371068e-01f, 1.66094884e-01f, 2.23254666e-01f,
  1.83063179e-01f, -3.41604978e-01f, 2.56645769e-01f, -1.12485051e-01f, -5.29727489e-02f, -4.19952124e-02f, -2.75812328e-01f, -2.76777387e-01f, -2.25602716e-01f, 9.57293287e-02f,
  -1.20330378e-01f, -3.92495655e-02f, 2.20372990e-01f, 2.70572841e-01f, -3.70070845e-01f, 2.05368891e-01f, 2.00091377e-01f, -4.02651101e-01f, -3.61864328e-01f, 6.74599931e-02f,
  1.24290422e-01f, -3.86563331e-01f, 1.82575494e-01f, 2.47345760e-01f, 5.59936836e-02f, -3.49295549e-02f, 1.55886531e-01f, 1.57880500e-01f, -9.37044341e-03f, -6.56693578e-01f,
  -6.04749024e-01f, -4.05915678e-01f, -4.83358681e-01f, -2.78138041e-01f, 2.30685622e-01f, 2.12303415e-01f, -7.77691230e-03f, 1.47867262e-01f, -2.68594444e-01f, 7.94872791e-02f,
  -3.44253123e-01f, -5.09367168e-01f, 1.33822188e-01f, -8.31744745e-02f, -2.63736527e-02f, -6.31533042e-02f, -6.38805106e-02f, -1.79426298e-02f, 1.75354615e-01f, 2.56415308e-01f,
  1.35841757e-01f, -3.28373909e-01f, 2.42582217e-01f, -1.49534106e-01f, -1.76369935e-01f, 3.10656935e-01f, -2.33558998e-01f, -1.47600517e-01f, -1.26886293e-01f, 1.97618008e-01f,
  -3.55523974e-01f, -2.39089385e-01f, -1.13327868e-01f, -4.66976970e-01f, -2.28428051e-01f, -1.63472727e-01f, -6.68938383e-02f, -1.41372740e-01f, -1.23152509e-01f, 1.98785499e-01f,
  2.39225700e-01f, -2.21364170e-01f, -2.20443100e-01f, -4.62243199e-01f, -3.09446067e-01f, -8.74902010e-02f, -2.16975641e-02f, -6.63721502e-01f, 2.01004997e-01f, -3.07615966e-01f,
  -3.62612367e-01f, -2.42109206e-02f, 3.03228498e-01f, 8.95428658e-02f, 1.10510021e-01f, 1.75317720e-01f, -5.72566450e-01f, -3.31984997e-01f, -3.62554848e-01f, 1.78985551e-01f,
  -5.19129753e-01f, -2.92231590e-01f, -2.62553275e-01f, -5.87781481e-02f, 3.86955470e-01f, 2.53221124e-01f, -3.59019727e-01f, -5.72147906e-01f, 3.05389136e-01f, 2.91480780e-01f,
  -2.44901836e-01f, -3.43481272e-01f, 6.69308826e-02f, 1.34222969e-01f, -3.69057715e-01f, 1.82399765e-01f, 1.91082492e-01f, 1.43241391e-01f, 2.31936216e-01f, 1.00930199e-01f,
  -7.47244582e-02f, 2.14635342e-01f, -4.75574732e-01f, -4.03613865e-01f, 2.60392100e-01f, -1.92452129e-02f, -1.94375709e-01f, -2.98083872e-01f, 2.66162217e-01f, 1.20614618e-01f,
  -1.28585815e-01f, -1.51785566e-02f, -2.85558343e-01f, -1.22610375e-01f, 1.81629099e-02f, -3.90752405e-01f, -3.45653176e-01f, -1.93568543e-01f, -2.51548201e-01f, 1.07955821e-01f,
  -1.29483461e-01f, -2.60945499e-01f, -2.74795443e-01f, 1.88626990e-01f, 6.10850938e-02f, -1.61844473e-02f, -1.16821518e-02f, -1.11492150e-01f, 2.09020793e-01f, 2.30354704e-02f,
  -2.73839235e-01f, -8.71582702e-02f, 1.33203408e-02f, 1.64643273e-01f, 4.71511334e-02f, 3.60301584e-02f, 2.15290546e-01f, 2.55383849e-01f, -4.97057706e-01f, 2.18580112e-01f,
  -1.29858911e-01f, 1.33071572e-01f, 1.28686950e-01f, 2.02293456e-01f, 8.56902972e-02f, 3.30047667e-01f, -2.88022041e-01f, -6.97468892e-02f, -2.54313350e-02f, -2.04232946e-01f,
  4.89457548e-02f, -7.94994682e-02f, 1.68791950e-01f, 2.63628632e-01f, -4.32112873e-01f, 2.06125714e-02f, -4.54261750e-02f, 4.19368148e-02f, -4.26346585e-02f, 1.03844374e-01f,
  1.28465831e-01f, -1.42585799e-01f, -1.34862334e-01f, -1.46458670e-02f, 4.90365550e-02f, 1.30788144e-02f, -2.07898870e-01f, -2.01262623e-01f, -2.59786397e-01f, 6.45059422e-02f,
  -1.36979535e-01f, 4.17190671e-01f, -8.42244551e-02f, -2.48680990e-02f, 2.74516970e-01f, 1.72841370e-01f, 5.22412844e-02f, 7.72949401e-03f, 5.95706403e-02f, 3.04268032e-01f,
  -2.55268127e-01f, -3.88228953e-01f, -2.25318089e-01f, 1.88008174e-01f, -2.72218674e-01f, -1.65623859e-01f, 2.43196100e-01f, -2.92625427e-01f, 2.33629674e-01f, 1.54519901e-01f,
  2.40658179e-01f, 1.85727611e-01f, 2.61353821e-01f, -5.75867705e-02f, -3.46580654e-01f, -3.23023975e-01f, -3.68280232e-01f, 2.29471520e-01f, -7.36275362e-03f, 1.24532126e-01f,
  -7.76484236e-02f, -2.39567369e-01f, 1.05311930e-01f, 1.67952776e-01f, -1.45384490e-01f, -3.55482757e-01f, 2.41182283e-01f, -3.64123583e-01f, 1.65101632e-01f, -4.33532804e-01f,
  -3.00275944e-02f, -1.06729758e+00f, -1.82935223e-01f, 2.53075778e-01f, -4.81134467e-02f, 2.72511333e-01f, -2.57735044e-01f, -2.16737613e-01f, 3.10992509e-01f, -6.97851703e-02f,
  -1.01187952e-01f, -5.44684939e-03f, -7.07793236e-02f, 3.32192555e-02f, -1.57530203e-01f, 7.91049153e-02f, -4.55980226e-02f, 9.05914158e-02f, -6.01629391e-02f, 1.57910865e-02f,
  -1.87658221e-01f, -1.14378870e-01f, 1.59648150e-01f, 1.49490491e-01f, 3.91671091e-01f, 2.30216250e-01f, -1.38378426e-01f, 2.76741199e-02f, 3.06530356e-01f, -3.74583185e-01f,
  1.94231570e-01f, -3.87524158e-01f, -6.53233528e-02f, 2.77165890e-01f, -1.61687180e-01f, 2.84599811e-02f, 1.00549228e-01f, 1.33306190e-01f, 2.05467194e-01f, -5.88044465e-01f,
  4.48694639e-02f, -1.93907022e-01f, -3.34006071e-01f, 1.17485709e-01f, -2.32916757e-01f, 2.40122125e-01f, -3.78629565e-01f, -1.40876882e-02f, -7.55569488e-02f, -3.62607688e-01f,
  -3.43697608e-01f, -4.90464680e-02f, 1.57326877e-01f, -3.77198130e-01f, -3.87454540e-01f, 2.15144947e-01f, -2.72004068e-01f, -2.57554978e-01f, 1.60848096e-01f, -6.01899549e-02f,
  -2.90180624e-01f, -4.52583611e-01f, 2.43385658e-01f, 9.59430262e-02f, -7.32246712e-02f, 5.81467748e-01f, -3.90941501e-01f, 2.33040079e-01f, -1.99612290e-01f, 6.78906441e-02f,
  1.02138802e-01f, -1.27853736e-01f, 8.21825862e-02f, 2.24195510e-01f, 2.27645382e-01f, 2.88123399e-01f, -1.45584285e-01f, -2.34341949e-01f, -4.94838431e-02f, 6.85686385e-03f,
  5.44344112e-02f, -8.20111856e-02f, 3.53820138e-02f, 5.12712859e-02f, -9.60630178e-02f, -1.30705640e-01f, -1.16321586e-01f, -2.60469019e-01f, 5.33142244e-04f, -9.18081477e-02f,
  1.13592885e-01f, -3.10317725e-01f, -2.09293038e-01f, -1.97941020e-01f, -2.01252446e-01f, -1.44338310e-01f, -3.39565158e-01f, 2.32508019e-01f, -1.44686073e-01f, 1.86127096e-01f,
  -2.38916665e-01f, 2.33475789e-01f, 2.77662814e-01f, -3.83256346e-01f, -3.18651736e-01f, -2.20196933e-01f, -2.10044101e-01f, 1.94103554e-01f, -2.60470659e-01f, 1.74415946e-01f,
  -2.10271955e-01f, -1.15788363e-01f, 2.19337106e-01f, -4.76218052e-02f, 1.94599122e-01f, -2.37355411e-01f, -5.63236438e-02f, 1.43367305e-01f, 1.14111960e-01f, -1.43037558e-01f,
  1.75308347e-01f, 1.45961151e-01f, -1.01185314e-01f, -2.71417201e-01f, -2.59152353e-01f, -1.74872279e-01f, 9.79305431e-02f, -2.23488778e-01f, -2.01002941e-01f, -1.39245272e-01f,
  1.61374673e-01f, 4.58020009e-02f, 3.74453694e-01f, 3.52015048e-02f, -2.08161950e-01f, 5.02487309e-02f, 2.61989146e-01f, -3.75537306e-01f, 1.47341609e-01f, -4.33843769e-02f,
  -1.93366006e-01f, 1.34408653e-01f, -1.49122700e-02f, -8.19805339e-02f, 5.43261357e-02f, -1.23537533e-01f, -2.16066360e-01f, -9.75831449e-02f, 1.05412349e-01f, 2.06158623e-01f,
  4.42774873e-03f, -1.62283048e-01f, 2.16620252e-01f, 3.20254654e-01f, -3.58329654e-01f, 1.75593376e-01f, -1.49543360e-01f, 1.74981683e-01f, 7.81932846e-03f, 2.84852218e-02f,
  5.47871664e-02f, 1.05741680e-01f, -2.97945231e-01f, 1.33930340e-01f, -5.76785486e-03f, -3.21324825e-01f, 2.88271695e-01f, 7.49420822e-02f, -2.80060709e-01f, -3.63393813e-01f,
  2.50540376e-01f, -2.95648694e-01f, 1.31231561e-01f, 5.19212596e-02f, 3.83467861e-02f, -5.53155802e-02f, -2.70855814e-01f, -3.33302543e-02f, -1.01427086e-01f, 3.19920592e-02f,
  2.26723373e-01f, 2.09822923e-01f, -2.25292325e-01f, 2.79782355e-01f, 2.01960266e-01f, 8.79188254e-02f, -5.34521602e-02f, -4.01725769e-01f, 1.79389462e-01f, -1.49988681e-01f,
  -1.32958099e-01f, 2.73323089e-01f, 2.44544193e-01f, -4.74548876e-01f, -5.39359212e-01f, -1.07658260e-01f, -2.49245435e-01f, 6.94964156e-02f, -3.56355458e-01f, 2.01819032e-01f,
  -1.55579448e-01f, -3.55368435e-01f, 1.13708377e-01f, -3.78398389e-01f, -2.12746650e-01f, -5.03776930e-02f, -1.09448068e-01f, -1.15696482e-01f, -3.29523347e-02f, -1.92375407e-01f,
  -1.93260722e-02f, -3.51059400e-02f, -1.73753306e-01f, -4.47283834e-02f, -2.43611321e-01f, 2.28146642e-01f, -2.10365772e-01f, 2.67614663e-01f, 1.83761507e-01f, -7.45072663e-02f,
  -1.06121212e-01f, 2.12491341e-02f, 7.82545954e-02f, -1.74806818e-01f, 2.49106765e-01f, -3.35232437e-01f, 9.72855166e-02f, 2.94190019e-01f, 1.69409975e-01f, 2.52110958e-01f,
  2.56326228e-01f, -4.71149772e-01f, 9.83643606e-02f, -3.94036509e-02f, -1.95294738e-01f, -8.03844631e-02f, -1.90354139e-01f, -3.44571382e-01f, 1.64673820e-01f, 5.34527004e-03f,
  2.37597987e-01f, -5.18439822e-02f, -3.03869456e-01f, -3.41146886e-01f, -6.16913661e-02f, -3.92902762e-01f, 2.81593859e-01f, -3.05437714e-01f, -2.79562414e-01f, 1.17138900e-01f,
  -4.13419493e-02f, 2.11714044e-01f, 2.08499879e-01f, -2.35218227e-01f, 1.51720315e-01f, -3.09105255e-02f, -2.67419398e-01f, -3.25698018e-01f, -7.23007143e-01f, -2.80490637e-01f,
  3.97823542e-01f, 2.80114174e-01f, -3.28806370e-01f, -3.66562724e-01f, -2.59530041e-02f, 1.81947768e-01f, -3.35236698e-01f, 8.09582993e-02f, -3.44027400e-01f, -2.22577095e-01f,
  -1.56150103e-01f, -1.02417924e-01f, -2.40095872e-02f, 1.29764497e-01f, 1.22761019e-01f, -5.38908355e-02f, 1.78859532e-01f, 2.53025413e-01f, 1.03111953e-01f, 9.98913944e-02f,
  1.07173845e-01f, -1.95604816e-01f, -2.88501054e-01f, 3.01769320e-02f, -1.34335622e-01f, 1.79624289e-01f, -3.82774293e-01f, 2.70741284e-01f, -1.30018115e-01f, -8.08077678e-02f,
  3.26260597e-01f, 2.72863299e-01f, 2.49298736e-01f, -2.40059093e-01f, -3.18287224e-01f, 3.28253396e-02f, -2.64552861e-01f, 3.64271514e-02f, -1.36039034e-01f, -3.09407741e-01f,
  4.74131890e-02f, 9.83883888e-02f, -3.84265602e-01f, -5.56872375e-02f, 6.40777312e-03f, 2.90402621e-01f, 1.39509380e-01f, -3.17511916e-01f, 2.35380024e-01f, -2.05278665e-01f,
  -1.27806798e-01f, -3.94289374e-01f, 1.99913010e-01f, -1.55859843e-01f, 1.14078417e-01f, 6.14440702e-02f, -4.02729481e-01f, 1.25201821e-01f, -2.16544002e-01f, -3.13649774e-01f,
  1.60044238e-01f, -5.33008993e-01f, -1.32483914e-01f, 2.07766190e-01f, -2.50120610e-01f, -1.69816345e-01f, -3.21909525e-02f, 1.16400793e-01f, -2.90323403e-02f, -2.87391901e-01f,
  2.63694942e-01f, -3.86562705e-01f, -2.22955734e-01f, 2.68873274e-01f, 8.28521326e-02f, 1.20306529e-01f, -3.14697511e-02f, -4.83121872e-02f, 3.96186449e-02f, -9.97867733e-02f,
  2.02789873e-01f, 2.45067596e-01f, 4.07618843e-02f, -3.10542643e-01f, 2.34969407e-01f, 3.18171501e-01f, -4.77349423e-02f, 2.82174826e-01f, 2.73313254e-01f, 2.06126779e-01f,
  2.47306451e-01f, -8.54128376e-02f, -3.53653520e-01f, 3.20220500e-01f, -2.03820437e-01f, -2.00875644e-02f, -3.02439302e-01f, -1.98578718e-03f, -1.81851789e-01f, -3.84746581e-01f,
  -2.47155800e-01f, 1.46929353e-01f, 2.46353313e-01f, -3.49442810e-01f, -3.08532685e-01f, 2.97936262e-04f, 1.29290356e-03f, 2.00821441e-02f, -3.35573882e-01f, -2.69085020e-01f,
  2.38156185e-01f, -3.75148393e-02f, -5.76786585e-02f, 1.14575282e-01f, -1.82909220e-01f, 1.76098108e-01f, -1.64080307e-01f, 1.63985223e-01f, -4.44559783e-01f, 2.92505115e-01f,
  -1.90263674e-01f, -3.36272299e-01f, 1.52722284e-01f, -2.38722324e-01f, 2.43398353e-01f, -8.33658934e-01f, -4.42235768e-01f, 1.89691395e-01f, -2.26215228e-01f, 1.54181153e-01f,
  2.27703616e-01f, -1.45950347e-01f, -3.79591882e-01f, -6.92865476e-02f, 2.18102872e-01f, 9.00399759e-02f, -1.59425810e-01f, -3.26283008e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.65124521e-01f, 1.05888374e-01f, -1.17458411e-01f, -7.17388168e-02f, 2.21567415e-03f, -3.21760811e-02f, -6.72301501e-02f, 8.29510987e-02f, -1.56034663e-01f, 3.21132168e-02f,
  3.42599675e-02f, 3.49393934e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    