/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.90964836e-01f, -2.91132092e-01f, -4.96916398e-02f, -1.24106467e-01f, -4.43361029e-02f, -1.28559336e-01f, -1.74434900e-01f, -1.23101853e-01f, 6.07409813e-02f, -1.44288152e-01f,
  1.10987447e-01f, 1.81915298e-01f, 1.25180990e-01f, 1.02419838e-01f, 1.21863708e-01f, -2.02706218e-01f, -1.29430339e-01f, -2.56547183e-02f, 1.50621161e-01f, 1.21524729e-01f,
  3.63859870e-02f, -1.16569757e-01f, -4.47141528e-02f, 4.27966453e-02f, -2.23228842e-01f, -8.34233537e-02f, -1.71269119e-01f, -4.40348610e-02f, -1.45619795e-01f, -1.89196363e-01f,
  -1.47129074e-01f, -7.69019872e-02f, 8.68485346e-02f, 1.16027854e-02f, 8.58762786e-02f, -1.07967608e-01f, 1.80377197e-02f, 9.79365502e-03f, 1.29699767e-01f, -9.02227685e-02f,
  3.49281020e-02f, 8.75504315e-02f, 2.04557981e-02f, -3.42375413e-02f, 2.08460726e-02f, -8.32277164e-02f, -4.22743242e-03f, 6.96645603e-02f, 7.05546588e-02f, 2.81652324e-02f,
  1.87593233e-02f, -4.69315276e-02f, -5.95075637e-02f, 5.03657237e-02f, 6.75205886e-02f, 1.25153989e-01f, -1.05262719e-01f, -7.98592791e-02f, -1.36490330e-01f, -3.29600841e-01f,
  -4.00593542e-02f, 1.01402357e-01f, 2.63553741e-03f, 5.34915887e-02f, -3.68640572e-02f, 4.48100781e-03f, 1.47012481e-02f, -2.54940782e-02f, 1.44422976e-02f, -4.95153219e-02f,
  5.26465252e-02f, 2.96434350e-02f, 2.49316655e-02f, -4.90082949e-02f, -5.14926687e-02f, 2.69522369e-02f, -8.97952840e-02f, -3.79061550e-02f, -1.78103000e-02f, 4.47786823e-02f,
  -2.14550328e-02f, 5.24366181e-03f, -1.19345076e-02f, 4.37649153e-02f, -2.13847980e-02f, -3.29763256e-03f, -3.21932696e-02f, 6.71963543e-02f, 2.08479376e-03f, -1.90035142e-02f,
  -9.63131040e-02f, 2.17042536e-01f, -2.28567153e-01f, -6.70782402e-02f, -5.62698171e-02f, 3.02422978e-02f, -1.09596886e-01f, -2.10562884e-03f, 5.48737645e-02f, -1.00369252e-01f,
  4.96229790e-02f, -4.41510193e-02f, -1.03506073e-01f, 1.02286808e-01f, 2.76830196e-02f, 1.83741860e-02f, -8.77464414e-02f, 2.99201701e-02f, -6.14700392e-02f, -5.60189709e-02f,
  -1.31333657e-02f, -1.17357269e-01f, -7.93856680e-02f, -7.28751868e-02f, -1.23676792e-01f, -6.63191965e-03f, -1.28301561e-01f, -1.94964603e-01f, -1.50949582e-01f, -3.94805610e-01f,
  -3.32540393e-01f, 7.12360516e-02f, 7.46276528e-02f, -2.53028691e-01f, -5.67027442e-02f, 1.76566973e-01f, 4.21253264e-01f, 1.91392496e-01f, -2.06723139e-02f, 9.51169990e-03f,
  -1.71961546e-01f, -1.85158998e-01f, -1.31717667e-01f, -6.38053119e-02f, 2.39357263e-01f, 1.00358292e-01f, 7.49233738e-02f, 9.21437442e-02f, 1.34144098e-01f, 9.74645391e-02f,
  -1.47699434e-02f, -1.05003245e-01f, -3.03594600e-02f, 9.17311758e-03f, -5.13580777e-02f, -1.13918036e-01f, 3.24164182e-02f, -4.58208956e-02f, -4.80731055e-02f, -2.25981817e-01f,
  -2.20191151e-01f, -7.34394416e-02f, 9.24912691e-02f, -5.83187528e-02f, -1.30404979e-01f, 6.21325597e-02f, 1.44788092e-02f, -6.97136894e-02f, -6.31006956e-02f, -4.60285135e-02f,
  -7.97336027e-02f, -7.96630830e-02f, -1.18657507e-01f, -5.06862141e-02f, 7.53218085e-02f, -6.28027180e-03f, 1.00940704e-01f, 4.97961715e-02f, -3.33961956e-02f, 6.54676333e-02f,
  -2.10299212e-02f, -2.89383661e-02f, 1.89223029e-02f, 1.00421645e-01f, 4.65329699e-02f, -1.25329047e-01f, 4.99369465e-02f, -6.08070659e-05f, 2.77866516e-02f, 3.75253730e-05f,
  -5.84208732e-03f, -9.54439864e-02f, -2.12379470e-02f, 5.46267778e-02f, 4.70588170e-02f, -5.77881373e-02f, -4.42561470e-02f, 2.87381951e-02f, 4.36158888e-02f, -5.18474579e-02f,
  4.07942943e-02f, -7.30009656e-03f, 1.35090398e-02f, -4.16747071e-02f, -9.73537657e-03f, -6.24342181e-04f, -3.37849036e-02f, 8.85268897e-02f, -2.31018886e-02f, 5.00677601e-02f,
  -6.06255345e-02f, 3.32289897e-02f, -7.31380731e-02f, -7.04272045e-03f, 5.99940568e-02f, 2.98387296e-02f, -4.23358791e-02f, 3.48495087e-03f, -5.86732244e-03f, -1.86769553e-02f,
  -1.05981953e-01f, 1.72447234e-01f, -1.49863064e-01f, -1.40806409e-02f, -9.54179838e-02f, -6.18267581e-02f, -8.44975263e-02f, -3.67508344e-02f, -8.06929395e-02f, -1.43115614e-02f,
  -3.02825887e-02f, 4.07619886e-02f, 3.70121282e-03f, 6.46867529e-02f, 6.21447712e-02f, 3.14610153e-02f, -3.57306339e-02f, -1.10921562e-01f, 1.12798125e-01f, -5.93839809e-02f,
  -3.10265310e-02f, -2.73639951e-02f, 5.30172661e-02f, 4.84453849e-02f, 3.52736786e-02f, -3.75321358e-02f, 8.24358314e-02f, -1.08887460e-02f, 9.25915539e-02f, 1.04683794e-01f,
  -1.10366233e-01f, -2.97791839e-01f, -3.00843567e-01f, -2.11441088e-02f, -8.50248560e-02f, 1.00812828e-02f, -2.45524645e-01f, -1.11954048e-01f, 1.04663625e-01f, -1.20978758e-01f,
  -5.93993664e-02f, 5.74195832e-02f, -6.94440901e-02f, 5.19311838e-02f, -2.10114405e-01f, -3.08177292e-01f, -3.15639764e-01f, -1.30662993e-01f, -6.51527792e-02f, 2.30065156e-02f,
  1.62074625e-01f, -5.41299805e-02f, -2.72783134e-02f, -9.32393521e-02f, 9.72492993e-02f, 7.73330107e-02f, -7.52478689e-02f, -6.53157234e-02f, -5.32373376e-02f, 4.98335771e-02f,
  4.68650125e-02f, -1.29986748e-01f, 1.23255625e-01f, 1.28030777e-01f, 3.00321802e-02f, 7.12609962e-02f, 8.35096613e-02f, -3.38914879e-02f, -3.59027870e-02f, -8.37445557e-02f,
  1.97896883e-02f, 4.46464168e-03f, -7.22010434e-02f, -2.48857830e-02f, -4.62703034e-02f, 7.50437826e-02f, 2.35267095e-02f, -1.34192064e-01f, -9.03133526e-02f, -4.28308882e-02f,
  -2.07269713e-02f, -6.09523896e-03f, -5.40057644e-02f, -4.13518846e-02f, -1.04036741e-01f, 5.50813712e-02f, -4.13155109e-02f, -1.51401404e-02f, 1.96828209e-02f, 2.00445056e-02f,
  6.45547220e-03f, 7.35217929e-02f, 2.61548832e-02f, 4.79582362e-02f, -6.18202006e-03f, 1.87106673e-02f, -5.06161945e-03f, -8.69233832e-02f, -2.39193905e-02f, 7.66960206e-03f,
  2.07621623e-02f, -1.80667522e-03f, -1.05598532e-02f, -2.94311401e-02f, -4.69102114e-02f, -6.74499944e-02f, 2.99663804e-02f, -6.31957799e-02f, -4.50776592e-02f, 9.39883739e-02f,
  4.94179875e-02f, 5.17614335e-02f, -4.60418276e-02f, -3.43943574e-02f, -1.13822417e-02f, -4.43704054e-02f, -2.12288070e-02f, 1.22514898e-02f, -5.82722947e-02f, 3.65839750e-02f,
  1.43064916e-01f, -1.10711783e-01f, 1.09803841e-01f, -6.00298271e-02f, -4.54249196e-02f, 3.84216569e-02f, 6.51791915e-02f, -2.03149468e-02f, 7.86573514e-02f, 3.91666777e-02f,
  -5.67518435e-02f, -1.44307949e-02f, -6.22111894e-02f, 1.32956076e-02f, 1.07150659e-01f, 4.16807421e-02f, -4.78558689e-02f, 1.38359657e-02f, -2.34395564e-02f, 8.70241299e-02f,
  -2.45176181e-02f, -6.22435100e-02f, 4.09663580e-02f, 7.02618575e-03f, -1.24964546e-02f, 4.98823151e-02f, -1.18837124e-02f, 6.00908138e-02f, 9.84224305e-02f, 7.61328489e-02f,
  3.50255281e-01f, -9.15532708e-02f, 7.79483616e-02f, 7.98038021e-02f, -3.07232410e-01f, -2.97789514e-01f, -3.06395471e-01f, -5.08166961e-02f, -6.61739558e-02f, -1.56620562e-01f,
  -1.49049535e-01f, -1.87977552e-02f, -2.93461643e-02f, 1.37288064e-01f, 1.84373990e-01f, -8.88018906e-02f, -7.30230063e-02f, 2.59908676e-01f, 1.46829143e-01f, 9.08742659e-03f,
  -1.89167410e-01f, -4.17617703e-05f, 2.86568433e-01f, 1.64507225e-01f, -6.54627904e-02f, -1.43815083e-02f, 4.06953916e-02f, -1.38415173e-02f, -2.83726119e-02f, -1.55581295e-01f,
  -7.18778819e-02f, 1.09058067e-01f, 3.10594887e-02f, 5.52339964e-02f, -9.58229527e-02f, 1.55464232e-01f, -2.32127886e-02f, 7.13946819e-02f, -3.47594582e-02f, 8.24877322e-02f,
  -1.24439672e-01f, 9.92311910e-02f, 3.51930968e-02f, -4.82682697e-02f, 6.79746196e-02f, -5.45039698e-02f, 1.45342365e-01f, 1.61307707e-01f, 1.21410556e-01f, -4.43103127e-02f,
  -7.21423775e-02f, -1.15173310e-01f, -4.11720835e-02f, -8.69439691e-02f, 6.64147642e-03f, 6.64561689e-02f, 5.20514101e-02f, 2.86414195e-02f, 1.54465333e-01f, 7.55129382e-02f,
  2.23967042e-02f, -5.15461154e-02f, -4.91977409e-02f, 1.91907585e-02f, -5.15396195e-03f, 1.20013049e-02f, -9.42373369e-03f, -6.72487617e-02f, -8.67831055e-04f, -9.84452944e-03f,
  8.69991481e-02f, -6.75079972e-02f, 3.30705158e-02f, -2.91490275e-02f, 1.88864544e-02f, 1.62615143e-02f, -6.75208792e-02f, 3.37888338e-02f, -3.10011394e-02f, 6.96379915e-02f,
  8.37017745e-02f, -6.85859099e-02f, 1.97959132e-02f, 1.60848070e-02f, -2.37015374e-02f, 2.21095867e-02f, 3.12124304e-02f, -8.37747082e-02f, -4.27881442e-02f, 5.06017879e-02f,
  4.80148010e-02f, 6.58648685e-02f, 3.56556411e-04f, 3.52155976e-02f, 2.69639418e-02f, -1.42493211e-02f, -6.83189407e-02f, 3.67721058e-02f, 5.45497350e-02f, 5.94150983e-02f,
  1.45683074e-02f, 5.88626564e-02f, 3.33134346e-02f, 5.25033846e-02f, 5.51392091e-03f, -2.24784594e-02f, -2.40785943e-04f, 4.35067303e-02f, 8.79771337e-02f, 6.21710494e-02f,
  -4.64720540e-02f, -6.90998323e-03f, 4.18660790e-02f, -9.11523961e-03f, -3.20547558e-02f, 1.26000084e-02f, -1.43688067e-03f, -9.00978595e-02f, -4.14409190e-02f, -2.91790557e-03f,
  2.60569394e-01f, -1.98477268e-01f, -1.07915908e-01f, -1.72723420e-02f, -1.45894274e-01f, -3.68959159e-02f, -5.42191789e-02f, 7.38770440e-02f, -8.18102509e-02f, -1.22458637e-01f,
  2.68602371e-03f, -2.24877968e-02f, 7.40076676e-02f, -2.12335549e-02f, -8.10018182e-03f, -1.53195441e-01f, -1.45698786e-01f, 1.28713772e-01f, 2.02154323e-01f, 7.14563653e-02f,
  -6.87142387e-02f, -6.06328025e-02f, 1.48644388e-01f, 1.07700892e-01f, -1.13796666e-01f, -1.00659885e-01f, -1.47141680e-01f, -1.89251185e-03f, -5.58152124e-02f, -1.15359634e-01f,
  -1.26710013e-01f, 4.00093757e-02f, 2.25622952e-02f, -5.54397563e-03f, 2.73170862e-02f, -8.57843906e-02f, -3.47755663e-02f, 2.16986779e-02f, -5.67801856e-03f, -1.93905067e-02f,
  -6.76952749e-02f, 6.21827729e-02f, -4.48636226e-02f, 3.05615831e-02f, 1.05331820e-02f, 7.80430585e-02f, 2.31555067e-02f, 9.22949165e-02f, 5.55553921e-02f, -9.58827883e-03f,
  -7.57849216e-02f, -2.36235047e-03f, -3.19396704e-02f, -1.62808243e-02f, 6.72517577e-03f, 8.48279744e-02f, 6.51043504e-02f, -2.13531256e-02f, 5.13967238e-02f, -5.64523712e-02f,
  -3.11947558e-02f, -8.15048963e-02f, 2.08503753e-02f, 2.94079464e-02f, 1.23041542e-02f, -6.58391640e-02f, 3.51270027e-02f, 3.67432907e-02f, 1.61732584e-02f, -7.84898400e-02f,
  -4.43277657e-02f, -4.62468006e-02f, 1.28746359e-02f, 7.66589120e-02f, -5.50747439e-02f, 4.40742709e-02f, -8.83576721e-02f, -8.77665430e-02f, 5.47047816e-02f, 3.24475132e-02f,
  1.05178952e-01f, 6.02736436e-02f, 1.04619963e-02f, -1.85746215e-02f, 3.28012295e-02f, 6.80926442e-02f, -6.36215834e-03f, 2.62287185e-02f, 3.60431299e-02f, -3.37567963e-02f,
  -1.18608311e-01f, 1.78397462e-01f, -7.98499435e-02f, -1.31588522e-03f, 2.16374937e-02f, 4.18765247e-02f, -4.00122516e-02f, -4.85263690e-02f, -5.10133095e-02f, -6.80041164e-02f,
  3.04167904e-02f, -5.07554114e-02f, -2.76305154e-02f, 5.86662628e-02f, -5.33423806e-03f, 1.77216958e-02f, -4.79404069e-02f, 2.12116800e-02f, 7.08142966e-02f, -7.68460184e-02f,
  -1.11134380e-01f, 1.72240529e-02f, 4.76462543e-02f, -3.43626142e-02f, -6.98088855e-02f, 5.29880114e-02f, -9.43528414e-02f, 3.72734815e-02f, -4.71897200e-02f, -1.55299067e-01f,
  3.96083176e-01f, 5.80914840e-02f, -1.91615194e-01f, 1.37436852e-01f, -4.92637418e-02f, -5.07669002e-02f, -2.24706307e-01f, 4.65386100e-02f, 2.29862630e-02f, 8.21757503e-03f,
  1.93171546e-01f, 1.91908047e-01f, 3.59667949e-02f, -1.82785928e-01f, -2.62689501e-01f, -2.06607148e-01f, -3.68619055e-01f, -2.53706366e-01f, -9.80853736e-02f, -6.12223260e-02f,
  -9.47123989e-02f, -1.07504725e-01f, 6.00389787e-04f, -4.77832630e-02f, 1.47919372e-01f, 3.48862410e-02f, 1.34005891e-02f, 4.52586859e-02f, -1.04742281e-01f, 1.49721764e-02f,
  1.46682754e-01f, 2.87657708e-01f, -8.66441727e-02f, -2.58430522e-02f, 3.87578867e-02f, 5.99901564e-02f, 5.75393364e-02f, -1.00449985e-02f, 7.86143020e-02f, 3.29312473e-03f,
  8.91270861e-02f, -3.86441648e-02f, -2.76808329e-02f, -5.00337742e-02f, 3.88998277e-02f, 9.71010402e-02f, -2.12578140e-02f, -1.18227236e-01f, -9.81005728e-02f, -3.52559127e-02f,
  -4.71884497e-02f, -2.69661527e-02f, 7.98763186e-02f, -1.29366055e-01f, 4.63817129e-03f, -7.59272426e-02f, 6.57245889e-02f, 1.98351033e-02f, -7.77269080e-02f, 1.21789835e-02f,
  -7.75369629e-02f, -5.77644147e-02f, -3.88451107e-02f, 6.51623458e-02f, 5.55849560e-02f, -1.85184032e-02f, 5.38795441e-03f, -7.03476146e-02f, -3.02762575e-02f, -4.34962623e-02f,
  -1.93567108e-02f, -2.91612484e-02f, 3.59717607e-02f, -6.88559860e-02f, 9.44323465e-03f, -2.89658853e-03f, -4.97690737e-02f, -8.70182961e-02f, -6.29414618e-02f, -1.57033820e-02f,
  -3.65276784e-02f, 7.59503469e-02f, 5.51439822e-02f, -7.28930766e-03f, 6.00185432e-02f, -4.94439676e-02f, 1.11133680e-01f, -1.37105370e-02f, 9.48420167e-02f, 4.70786691e-02f,
  -4.94116917e-03f, -1.07759789e-01f, -9.85755678e-03f, 2.86337454e-02f, 2.67883744e-02f, 4.84459326e-02f, 9.32202116e-02f, -2.84492876e-02f, 7.55561665e-02f, 6.19653314e-02f,
  -1.48308910e-02f, -4.56287293e-03f, -6.82087615e-04f, -1.27289677e-02f, -1.98410172e-02f, -1.83821972e-02f, -6.43982813e-02f, -4.30230424e-02f, -2.28907224e-02f, 1.29963711e-01f,
  -9.01912451e-02f, -2.53592450e-02f, 5.30044399e-02f, -1.32612903e-02f, 7.44785517e-02f, 2.12719738e-02f, -6.46263361e-02f, 7.07171410e-02f, 1.80796944e-02f, -1.82937980e-01f,
  1.01926938e-01f, 1.24219500e-01f, 3.63214999e-01f, 2.26820990e-01f, 2.30775625e-01f, 1.94697604e-01f, 1.05466336e-01f, 4.16199043e-02f, 5.30945770e-02f, 1.46350950e-01f,
  -2.65563503e-02f, -1.39388487e-01f, -1.33875892e-01f, 1.34622147e-02f, 4.26574424e-02f, 2.20057160e-01f, 2.82691866e-01f, 6.45009875e-02f, 1.18940532e-01f, 1.75148603e-02f,
  1.24905325e-01f, 2.17018113e-01f, 1.98530793e-01f, 1.27014622e-01f, 1.81688573e-02f, 2.46636290e-02f, 1.85764492e-01f, 3.60177122e-02f, 7.73587301e-02f, 1.14736959e-01f,
  -1.28152105e-03f, 6.24679253e-02f, -1.15031237e-02f, -1.76461935e-02f, 6.25274181e-02f, -2.93358881e-02f, 1.55820670e-02f, -4.83856797e-02f, -1.34914771e-01f, 4.35886569e-02f,
  -2.56796144e-02f, -8.50607827e-02f, -1.16065696e-01f, -2.51276009e-02f, -4.44466807e-02f, -9.41803679e-02f, 1.92851145e-02f, 8.86648893e-02f, -2.50778086e-02f, -9.42727849e-02f,
  2.72742240e-03f, 5.07303253e-02f, -9.38910618e-03f, -1.05604809e-02f, -1.02758050e-01f, 7.90266842e-02f, -6.68240711e-02f, -7.87080973e-02f, -5.84052242e-02f, 8.17313492e-02f,
  2.77366154e-02f, 8.49733129e-03f, -2.18336396e-02f, -3.56717445e-02f, -3.47065181e-02f, -6.10685050e-02f, 1.06042819e-02f, -1.93264224e-02f, 3.26211154e-02f, -1.01117184e-02f,
  -5.72321750e-02f, 9.01236944e-03f, -4.30324338e-02f, 6.07139152e-03f, -1.14116324e-02f, 2.33265106e-03f, -1.49638131e-02f, -5.30265197e-02f, -1.06956959e-02f, -5.39854690e-02f,
  -4.68239039e-02f, 1.75411496e-02f, -3.75047959e-02f, -2.35000420e-02f, -4.22218665e-02f, 3.79613042e-02f, 3.07352245e-02f, -1.40552565e-01f, -2.24338789e-02f, 3.72306667e-02f,
  -2.00512215e-01f, -1.12629617e-02f, 1.51163442e-02f, -5.09700887e-02f, 1.53815486e-02f, -7.30578825e-02f, -8.98291357e-03f, -5.60328364e-02f, 3.10324132e-02f, 2.51880586e-02f,
  -9.32178721e-02f, -6.20641448e-02f, 5.88737838e-02f, 1.25363450e-02f, -6.96481380e-04f, -5.62688373e-02f, -3.70203182e-02f, 7.03873187e-02f, -8.17149729e-02f, -6.81773126e-02f,
  3.51549685e-02f, 6.13282882e-02f, -1.10023744e-01f, 7.75567302e-03f, 1.24620320e-02f, -6.16207570e-02f, -2.09205002e-02f, -6.63617998e-02f, -2.07997467e-02f, -3.89763080e-02f,
  -2.39280492e-01f, -5.72152324e-02f, 4.06953335e-01f, -1.82476267e-01f, 1.22925676e-01f, 1.95098117e-01f, 1.94623202e-01f, 1.37774879e-02f, -1.39669165e-01f, 5.40104546e-02f,
  8.36582854e-02f, -1.09280646e-01f, -9.49114114e-02f, -4.27496135e-02f, -8.56935605e-02f, 5.68395667e-02f, 1.32807754e-02f, -9.06925276e-02f, 4.08695713e-02f, 2.11046524e-02f,
  -2.30087474e-01f, -1.20071255e-01f, -1.68264851e-01f, -1.83822393e-01f, -1.85040534e-01f, -1.24172151e-01f, 1.11801319e-01f, 6.65397802e-03f, 1.05503671e-01f, -2.24964052e-01f,
  1.92890525e-01f, 8.07691645e-03f, -2.39391979e-02f, -4.14560735e-02f, 5.99572062e-02f, -2.08663642e-02f, 1.07043553e-02f, 1.10234441e-02f, 7.53888069e-03f, -6.94671199e-02f,
  7.01426342e-02f, -3.50123346e-02f, -3.71964462e-02f, -1.02875948e-01f, 4.17377278e-02f, 5.20275049e-02f, -1.00692019e-01f, -1.94049310e-02f, -4.79002036e-02f, 2.75445748e-02f,
  -2.10077967e-02f, 9.90257189e-02f, 9.88880470e-02f, 2.39519328e-02f, 2.09056144e-03f, 3.35616320e-02f, 1.58461243e-01f, 4.68401723e-02f, 1.49302557e-01f, -1.39486060e-01f,
  -4.42583859e-02f, -9.18877218e-03f, 4.83314022e-02f, -6.61376491e-02f, -4.81918231e-02f, 1.44928526e-02f, 3.00304178e-04f, 1.42919756e-02f, 3.80670987e-02f, -3.88026722e-02f,
  -1.13180149e-02f, 7.74612501e-02f, -7.55068660e-02f, -5.02699837e-02f, 2.98096798e-02f, 5.79729502e-04f, -1.37877567e-02f, -1.52491620e-02f, 4.59793583e-02f, -9.35521536e-03f,
  4.28640246e-02f, -3.47008370e-02f, -1.43395364e-02f, 3.43269110e-02f, -2.09877025e-02f, 4.30908287e-03f, -1.20683908e-01f, -7.93949515e-02f, -4.93870527e-02f, 1.94375105e-02f,
  -2.32944544e-02f, 1.80909052e-01f, -2.23912355e-02f, -9.87950191e-02f, 6.84557632e-02f, -4.92355488e-02f, 4.60860506e-02f, -4.42080535e-02f, 7.99408704e-02f, -4.97285575e-02f,
  5.11128083e-02f, -6.21507615e-02f, 5.33641651e-02f, 5.24243563e-02f, 1.02583049e-02f, 4.02260832e-02f, -8.22846079e-04f, 4.15880568e-02f, 4.36330549e-02f, 6.61104992e-02f,
  -7.93906152e-02f, 8.16859379e-02f, 2.48672292e-02f, 2.91967113e-02f, 5.45630138e-03f, -4.17656591e-03f, 8.00103247e-02f, 7.29553699e-02f, 1.23463176e-01f, -1.49682984e-01f,
  1.65631294e-01f, 2.60502428e-01f, -4.10654619e-02f, -9.12174881e-02f, 6.47736564e-02f, 4.03660312e-02f, 1.01125650e-01f, 6.42637461e-02f, -1.05918713e-01f, 1.66427903e-02f,
  8.08734074e-02f, -1.47897273e-01f, -1.58237785e-01f, -1.79730624e-01f, -8.07708874e-02f, 5.25274016e-02f, -1.75134093e-01f, -2.10900590e-01f, -5.37607260e-02f, -8.05115385e-04f,
  -9.30207595e-02f, -4.57232408e-02f, 2.49704509e-03f, -1.28649082e-02f, 1.06258966e-01f, -1.45077422e-01f, -1.63054317e-02f, 8.22599158e-02f, 3.51772681e-02f, 1.22722365e-01f,
  2.60123849e-01f, 3.34538013e-01f, -1.55429721e-01f, -3.16798687e-02f, -6.62494972e-02f, -3.73669341e-02f, -1.72344688e-02f, 6.47458667e-03f, 1.82727166e-02f, 1.02842182e-01f,
  3.48060089e-03f, 5.19912094e-02f, -2.49560419e-02f, 9.22790393e-02f, 6.81491941e-02f, 8.29085559e-02f, 5.80312721e-02f, 3.73258814e-02f, 4.06744331e-02f, 9.46014449e-02f,
  2.01931931e-02f, 9.77682099e-02f, -9.30864364e-03f, -3.31500545e-02f, -3.11794709e-02f, -2.99745183e-02f, 7.22786933e-02f, 6.27943724e-02f, -5.55423135e-03f, 2.79357843e-02f,
  5.33794388e-02f, -3.75036849e-03f, 1.26990918e-02f, 4.79129925e-02f, -9.33320820e-02f, -6.52306601e-02f, 1.29477410e-02f, -1.22341327e-02f, 1.97405871e-02f, -1.46299480e-02f,
  -2.51518525e-02f, -5.29926009e-02f, -6.94648698e-02f, 1.28114978e-02f, -5.84258847e-02f, 9.28252637e-02f, 2.34332327e-02f, 5.02808206e-02f, -2.71573961e-02f, 3.67561765e-02f,
  -4.27591391e-02f, -7.47588947e-02f, 4.53213751e-02f, -9.31221992e-02f, 6.12882972e-02f, -1.83563642e-02f, 2.63578277e-02f, 9.66331363e-02f, -2.53898948e-02f, 8.12394777e-04f,
  -1.28423154e-01f, -2.17342734e-01f, -6.04242459e-02f, 4.79953550e-02f, 6.74020350e-02f, 5.12026995e-02f, -2.67653838e-02f, 3.10635641e-02f, -3.99805605e-02f, 6.15807623e-02f,
  7.13845119e-02f, 3.25842686e-02f, -1.13573316e-02f, 6.18265867e-02f, -9.54152569e-02f, 4.92618652e-03f, 1.00346608e-02f, -1.11275159e-01f, -3.05864997e-02f, 2.84129865e-02f,
  -3.17557231e-02f, 1.69734396e-02f, -4.33373339e-02f, -1.20864496e-01f, -8.57136995e-02f, -9.16438326e-02f, -9.39263180e-02f, 6.01204783e-02f, -8.32754970e-02f, 3.36837433e-02f,
  4.30866629e-01f, -1.26726460e-02f, 1.57104135e-01f, -1.06283743e-02f, 2.76025627e-02f, 3.73842344e-02f, 1.17942147e-01f, 7.02410713e-02f, -5.71747459e-02f, 1.19364904e-02f,
  -1.87326655e-01f, -6.47076741e-02f, -1.33668825e-01f, 2.06873789e-02f, 8.12109187e-02f, 3.20789940e-03f, 7.75281154e-03f, 2.47799382e-01f, 9.87885967e-02f, -3.97844911e-02f,
  -1.85788646e-02f, -1.19743934e-02f, 2.11416811e-01f, 2.04738248e-02f, -6.45570457e-02f, -1.54181585e-01f, 3.89441475e-02f, 2.89021432e-02f, 4.67834249e-02f, -3.70625518e-02f,
  -3.15091088e-02f, 1.10114887e-01f, 6.05715290e-02f, -5.98770566e-02f, -3.62001806e-02f, 4.83118966e-02f, 1.20155169e-02f, 6.14597611e-02f, 6.10612817e-02f, -6.18843362e-02f,
  -3.86492200e-02f, -9.27311182e-02f, -1.01430818e-01f, -9.46538001e-02f, 3.22881266e-02f, 3.44102047e-02f, 6.15908653e-02f, 1.15320563e-01f, 1.10076100e-01f, 2.89828726e-03f,
  -5.80644533e-02f, 1.87577046e-02f, 1.77506834e-01f, -5.71990525e-03f, 9.15386993e-03f, 7.16475323e-02f, 3.18231098e-02f, -2.83601438e-03f, 3.62421945e-02f, 2.56098006e-02f,
  -5.24699539e-02f, 3.46101709e-02f, 8.37417096e-02f, 1.98415425e-02f, -2.54167542e-02f, -6.65163249e-02f, -6.44037779e-03f, 8.22013803e-03f, 1.05748316e-02f, -1.00611132e-02f,
  4.80353273e-02f, 5.23578301e-02f, 1.47596849e-02f, 1.76986605e-02f, -4.34853360e-02f, 1.55532397e-02f, 6.98319972e-02f, 6.66684955e-02f, -2.64161434e-02f, 9.04493034e-02f,
  4.16611657e-02f, 3.15135792e-02f, 6.57832548e-02f, -8.85117501e-02f, 7.75233582e-02f, 5.13186939e-02f, 2.32593492e-02f, -2.18715742e-02f, -5.18632084e-02f, 7.83308148e-02f,
  -4.86072190e-02f, 4.61126082e-02f, 1.14078866e-02f, -4.90205698e-02f, 2.71125305e-02f, 5.28723113e-02f, -9.49915573e-02f, 4.02472839e-02f, -1.16794314e-02f, 4.81132977e-02f,
  6.08624704e-02f, 5.26255332e-02f, 3.94978523e-02f, -7.20921382e-02f, 9.33690369e-02f, -2.38373876e-02f, 4.62444685e-02f, 1.06836371e-01f, 7.43411258e-02f, 1.47986431e-02f,
  -1.36544229e-02f, 1.28105223e-01f, 1.49923384e-01f, 2.41562687e-02f, 2.38156063e-03f, 1.44366354e-01f, -5.89452265e-03f, 8.33951011e-02f, 1.72728643e-01f, 1.17777392e-01f,
  2.08806247e-01f, 2.37226650e-01f, 3.48430686e-02f, 9.93488431e-02f, 9.35618579e-03f, -9.79254767e-03f, 3.44432853e-02f, 2.91943271e-02f, -1.09821688e-02f, 8.20292905e-03f,
  -7.09697902e-02f, -8.95438790e-02f, -2.10953727e-01f, -2.07366452e-01f, -3.23848426e-02f, 7.92034045e-02f, 3.85642536e-02f, -9.27220508e-02f, -8.94757956e-02f, 2.38060001e-02f,
  2.18744837e-02f, 5.22807352e-02f, 1.25356754e-02f, -2.87584420e-02f, 4.58321273e-02f, -1.25250015e-02f, -1.59255881e-02f, 1.33318692e-01f, -3.31445448e-02f, -2.94247437e-02f,
  -2.79626429e-01f, 2.30496407e-01f, -2.09156588e-01f, -8.76155719e-02f, 2.14403681e-02f, -2.78042872e-02f, 2.62060091e-02f, 5.04516251e-02f, 1.11871131e-01f, -7.44039007e-03f,
  -1.79109089e-02f, 1.26422539e-01f, 4.10042629e-02f, -1.49960993e-02f, -2.79251356e-02f, -6.90135211e-02f, 1.39909074e-01f, 4.01322804e-02f, -2.28338856e-02f, 1.92891192e-02f,
  3.35714854e-02f, -8.36328231e-03f, -3.14761810e-02f, -7.54600838e-02f, 2.79825423e-02f, -1.62666932e-01f, 8.88804346e-02f, -7.14499429e-02f, -3.32236029e-02f, -4.99094240e-02f,
  -5.33140339e-02f, 7.66443163e-02f, 7.01900572e-03f, 4.38107215e-02f, 6.41432032e-02f, -6.54079765e-02f, 4.51141894e-02f, -8.73007700e-02f, -2.57283896e-02f, 3.82679440e-02f,
  -3.72766443e-02f, -4.43532830e-03f, -1.75132006e-02f, -6.20956086e-02f, -3.02838050e-02f, -2.59031691e-02f, 4.89772148e-02f, -4.48299758e-02f, 4.25720699e-02f, -3.92569937e-02f,
  -9.18189157e-03f, -7.71898627e-02f, 3.61923426e-02f, 5.96228503e-02f, 1.25081148e-02f, 9.71590914e-03f, -4.91711758e-02f, -1.43629184e-03f, 8.02044524e-04f, -5.90551868e-02f,
  -2.08841518e-01f, -1.23751417e-01f, -1.51650548e-01f, -1.68980155e-02f, -6.35124967e-02f, -1.02854213e-02f, -6.48563132e-02f, 4.20805961e-02f, 7.89136514e-02f, -4.44921106e-02f,
  -1.93113368e-02f, 8.76536127e-03f, -5.27932011e-02f, 8.09871703e-02f, 6.74216775e-03f, 2.09136605e-02f, 1.05148656e-02f, -5.39353341e-02f, -1.01412190e-02f, 5.56937940e-02f,
  -1.89957209e-02f, -1.54984981e-01f, -1.64639935e-01f, -1.00753948e-01f, -2.95344163e-02f, -2.43963987e-01f, -2.20690504e-01f, -6.40101135e-02f, -2.31002063e-01f, -7.03113377e-02f,
  -6.46572262e-02f, 1.53041631e-01f, 4.98695999e-01f, 1.48887858e-01f, -8.74306336e-02f, -7.10401088e-02f, -2.76575625e-01f, -2.25759298e-01f, -3.23447511e-02f, -2.13736319e-03f,
  5.48104420e-02f, -5.47675155e-02f, 2.17075031e-02f, -2.74837632e-02f, -2.68628262e-02f, 4.04042117e-02f, 1.59159496e-01f, 1.78579643e-01f, 5.85736381e-03f, -1.96649611e-01f,
  -2.34991729e-01f, 1.35958074e-02f, 6.27311394e-02f, -6.64926693e-02f, 1.33410200e-01f, 7.85450190e-02f, 1.70392051e-01f, 7.95394257e-02f, 4.62148227e-02f, 2.93252528e-01f,
  2.68407285e-01f, 1.36049211e-01f, -4.33629341e-02f, -1.18264526e-01f, 1.31969988e-01f, -1.01166246e-02f, 4.40511145e-02f, 5.69070764e-02f, 2.84241233e-02f, -2.88546626e-02f,
  9.76502746e-02f, -1.56890452e-02f, 6.71596900e-02f, 3.76596279e-03f, -3.71603742e-02f, -1.41865304e-02f, -1.48688918e-02f, 1.64070681e-01f, 7.89700374e-02f, 9.83990878e-02f,
  5.74276149e-02f, 7.90608115e-03f, 1.53928712e-01f, 6.22612648e-02f, -3.18762921e-02f, 7.55439047e-04f, 2.93521062e-02f, 5.55112958e-02f, -4.05628458e-02f, 1.34658232e-01f,
  -5.03533110e-02f, 4.02317457e-02f, 2.58370601e-02f, 1.72186308e-02f, -5.67495590e-03f, -9.37162526e-03f, 1.88324973e-02f, -6.18807562e-02f, -8.74570757e-03f, -3.08804102e-02f,
  -1.16716120e-02f, -1.14571713e-02f, 4.51795533e-02f, -4.65172492e-02f, 6.35842159e-02f, 6.91492036e-02f, -3.06234346e-03f, -9.23114549e-03f, 1.88065264e-02f, -9.64522585e-02f,
  6.96397293e-03f, 4.87281345e-02f, 8.24480727e-02f, -5.38820587e-02f, 7.13881745e-04f, 3.45519148e-02f, 2.16424465e-02f, -4.84221205e-02f, 1.84966419e-02f, -2.09002160e-02f,
  -6.12076409e-02f, -1.62456021e-01f, 3.13368924e-02f, -5.85455745e-02f, 1.92289297e-02f, 6.95530698e-02f, 1.33537864e-02f, 3.39239053e-02f, 5.58556318e-02f, 4.71730866e-02f,
  -1.66555848e-02f, 7.19294101e-02f, 4.03297916e-02f, -4.47122008e-02f, -1.73089523e-02f, -4.76603247e-02f, -5.16850799e-02f, -1.92984696e-02f, -8.74006525e-02f, 3.28440592e-02f,
  -1.03329480e-01f, -9.98577550e-02f, -1.36219710e-01f, -2.91138911e-03f, -1.02482371e-01f, -1.37479268e-02f, 4.39188480e-02f, -1.00917570e-01f, -4.76326868e-02f, -2.22905993e-01f,
  2.01917030e-02f, -8.12515244e-03f, -2.59102076e-01f, -1.45064250e-01f, -2.63583779e-01f, -1.49581283e-01f, -1.39450610e-01f, -1.53551117e-01f, -4.61037867e-02f, -1.54127896e-01f,
  -1.14282705e-01f, -2.21327245e-02f, -1.24789663e-01f, -1.01132646e-01f, -1.33966610e-01f, -9.23266113e-02f, -1.29675359e-01f, -2.32380435e-01f, -2.62096375e-01f, -2.77133614e-01f,
  -1.46354467e-01f, -2.22812086e-01f, -1.86233446e-01f, -1.19174331e-01f, -3.87494983e-05f, -4.20811847e-02f, -1.43076837e-01f, -4.61636260e-02f, -5.57454564e-02f, -9.74339396e-02f,
  -2.52824873e-02f, 7.88538978e-02f, -4.22355048e-02f, -2.64037084e-02f, 3.68389897e-02f, 7.83009105e-04f, 3.34395654e-02f, 4.39491645e-02f, 4.89582829e-02f, 6.70396909e-02f,
  -1.06218029e-02f, 3.84688191e-02f, -5.68670109e-02f, 3.20124738e-02f, -5.36637492e-02f, -5.54030426e-02f, -6.11097142e-02f, -3.37091498e-02f, 1.84179947e-03f, 3.48616429e-02f,
  -1.41204055e-02f, -9.44944546e-02f, 5.06763384e-02f, -4.38747788e-03f, 4.00414988e-02f, -4.87791747e-02f, 9.07489434e-02f, -2.23136004e-02f, 4.87112552e-02f, 1.26435518e-01f,
  -9.04041249e-03f, 2.99036521e-02f, -7.52191320e-02f, -1.53622692e-02f, 2.11610906e-02f, 5.55697782e-03f, -8.76315217e-03f, 4.20683920e-02f, 8.47925339e-03f, 2.42032241e-02f,
  -4.87722680e-02f, 4.34510186e-02f, -4.44523431e-02f, -4.95507233e-02f, -4.50329185e-02f, -2.72437036e-02f, -2.40757614e-02f, -1.65197096e-04f, 6.55018091e-02f, 2.38381531e-02f,
  -1.73388831e-02f, 1.23997759e-02f, 5.97274443e-03f, 9.48364437e-02f, -9.33390260e-02f, -3.10995597e-02f, -8.44153836e-02f, 5.17491661e-02f, -3.58959697e-02f, 4.10768390e-02f,
  1.31566161e-02f, -5.97460344e-02f, 7.43884295e-02f, 7.82669857e-02f, 1.10102156e-02f, 4.00917903e-02f, 7.60952681e-02f, 1.00156806e-01f, 4.59618196e-02f, 2.35152338e-02f,
  -3.60751897e-02f, 2.42864899e-02f, 1.47578120e-02f, -3.70503739e-02f, 2.57245218e-03f, 1.00556621e-02f, 7.00529292e-02f, -3.72388810e-02f, 8.41719843e-03f, -5.47147077e-03f,
  6.79595843e-02f, 5.03736362e-02f, 2.36563329e-02f, 2.11748108e-02f, 1.17961638e-01f, 1.11462697e-02f, 1.15657166e-01f, 6.37139902e-02f, 8.83032195e-03f, 5.92728034e-02f,
  1.61823437e-01f, -6.71187192e-02f, -1.22584328e-02f, 1.86093122e-01f, -1.43657833e-01f, -2.42087424e-01f, -3.14724833e-01f, -7.22863600e-02f, 7.70120025e-02f, 6.69477209e-02f,
  -1.32815138e-01f, 2.02487689e-02f, -5.62463515e-02f, -6.09344430e-02f, -1.02336913e-01f, -1.63814407e-02f, -6.24749102e-02f, 3.50302905e-02f, 7.53133930e-03f, 3.76763344e-02f,
  1.69809368e-02f, 1.03997983e-01f, 1.37958646e-01f, 8.83624181e-02f, 2.14134693e-01f, 9.78117511e-02f, 1.31552471e-02f, 1.85559541e-02f, -6.86823502e-02f, 2.55041838e-01f,
  2.26318866e-01f, -7.42127225e-02f, 4.66813855e-02f, 4.85820603e-03f, -8.29412937e-02f, 3.08103729e-02f, -7.86821619e-02f, 2.81538945e-02f, -6.01551086e-02f, 4.82356101e-02f,
  -2.02466715e-02f, -7.33963447e-03f, 2.70389877e-02f, -3.78037095e-02f, 1.73403956e-02f, -1.42917130e-02f, 7.06809983e-02f, -3.97682898e-02f, -8.52343068e-03f, 3.76450941e-02f,
  -8.66208225e-02f, -1.97827797e-02f, -8.26015547e-02f, -8.84281322e-02f, -5.15548997e-02f, -1.04971200e-01f, -1.44993201e-01f, 2.52583828e-02f, -6.56324029e-02f, 1.16283990e-01f,
  -8.21157992e-02f, 2.46174517e-03f, 2.05940809e-02f, 4.50145788e-02f, 1.00722173e-02f, 4.19514403e-02f, 4.08026762e-02f, 6.47768974e-02f, -4.98214774e-02f, -1.27332387e-02f,
  -2.35318784e-02f, -1.58470795e-02f, -1.08038606e-02f, -1.69676244e-02f, 7.60771483e-02f, -2.81487089e-02f, -1.26640694e-02f, 9.88990217e-02f, -5.80479689e-02f, -1.24991257e-02f,
  -7.27590397e-02f, -6.79141060e-02f, 1.08830810e-01f, 5.34910187e-02f, -6.99489191e-02f, -1.48164702e-03f, 4.75006066e-02f, -3.17016914e-02f, 5.77316061e-03f, -1.44676380e-02f,
  2.05273777e-01f, -3.74597669e-01f, 1.67483196e-01f, 2.06137709e-02f, 1.39973164e-01f, -1.52181191e-02f, 8.02583098e-02f, 8.62711594e-02f, 2.99473107e-02f, -1.13789681e-02f,
  -5.57647981e-02f, 8.95062387e-02f, 3.38443778e-02f, 3.06655187e-02f, 4.58522737e-02f, -3.20872478e-02f, 3.14870439e-02f, -2.37703994e-02f, -1.15379374e-02f, 4.72962335e-02f,
  6.52953004e-03f, -4.41284366e-02f, 1.76689178e-02f, -5.77113703e-02f, -5.39111830e-02f, 4.78033908e-02f, 8.57521817e-02f, 1.02443052e-02f, -7.97820762e-02f, 1.68518141e-01f,
  -7.06548244e-02f, 3.85317296e-01f, 2.35366821e-02f, 4.56189997e-02f, 4.62185144e-02f, 5.02022393e-02f, 2.18445927e-01f, 8.22133645e-02f, -3.16298604e-02f, 1.49983943e-01f,
  1.49637777e-02f, -2.21614555e-01f, -1.62651464e-01f, -3.97008024e-02f, -7.85707533e-02f, 2.47567207e-01f, 2.24512070e-01f, -8.16738829e-02f, -1.35407820e-01f, -1.57408416e-01f,
  4.26107533e-02f, 1.15534946e-01f, -1.54748648e-01f, -5.71601130e-02f, 6.47971332e-02f, -5.45663014e-02f, 1.22801684e-01f, 9.28039551e-02f, 5.73966764e-02f, 1.98429227e-01f,
  3.29958573e-02f, -9.67280790e-02f, -8.62549618e-02f, -1.32958621e-01f, -2.50617471e-02f, -5.95759228e-02f, 1.15597658e-01f, -6.42563179e-02f, 6.76982850e-02f, 1.76308248e-02f,
  2.36707702e-02f, -1.10733798e-02f, -7.08535835e-02f, -2.10856102e-04f, -3.53409797e-02f, -6.09182380e-02f, -4.13220227e-02f, -6.09990470e-02f, -1.23521149e-01f, -4.57348973e-02f,
  4.62561026e-02f, 5.25672436e-02f, -3.95242609e-02f, -2.10619923e-02f, -2.84128673e-02f, -1.67672127e-01f, 3.95843163e-02f, -7.06454068e-02f, -1.47900388e-01f, 1.80268601e-01f,
  5.96144535e-02f, 2.38701403e-02f, -6.81038275e-02f, -2.34456789e-02f, 6.23310730e-02f, 4.12167236e-02f, -3.20325419e-02f, -2.57536937e-02f, -7.82468021e-02f, -1.67168602e-02f,
  -6.73859119e-02f, -1.06279263e-02f, -6.52010879e-03f, -1.26018655e-02f, -3.77438441e-02f, 3.94848473e-02f, 3.60887311e-02f, 1.24136217e-01f, -1.08155943e-02f, 1.94191225e-02f,
  2.56696101e-02f, -8.99543464e-02f, 6.59606829e-02f, 1.88822690e-02f, -2.66333725e-02f, 5.08400202e-02f, 7.72037497e-03f, 4.53477353e-02f, 1.34353451e-02f, -3.49600799e-02f,
  2.36402452e-01f, -2.76900530e-01f, 1.27960876e-01f, -7.42023215e-02f, 6.64241463e-02f, 6.67722076e-02f, -6.95696026e-02f, 2.30692420e-03f, -7.42640197e-02f, 3.07907835e-02f,
  -8.85173902e-02f, -3.62673067e-02f, 1.03981420e-01f, 6.58651367e-02f, 3.07062492e-02f, -2.52263863e-02f, 1.40533611e-01f, -5.16172349e-02f, -6.60055727e-02f, 5.45846857e-02f,
  3.45160812e-02f, 1.17339671e-01f, 1.27300784e-01f, 2.59352140e-02f, -8.88429210e-02f, -1.44870868e-02f, 1.26943156e-01f, 8.82268772e-02f, 1.98598187e-02f, 4.09718841e-01f,
  5.57145298e-01f, 1.88404098e-01f, -5.67794070e-02f, 1.94906101e-01f, -2.08630517e-01f, -1.33872956e-01f, 8.82820189e-02f, 1.56887949e-01f, 1.33449912e-01f, 9.68998000e-02f,
  -5.04999235e-02f, -1.23748928e-01f, 5.73836863e-02f, -3.31616066e-02f, 1.41905695e-01f, -7.94229377e-03f, 6.70761913e-02f, 1.68870259e-02f, -1.61211520e-01f, -1.41457364e-01f,
  -1.31136835e-01f, 3.19913961e-03f, 1.59260333e-01f, 8.10819678e-03f, 5.82936108e-02f, -5.05663194e-02f, -2.46200636e-02f, -5.20850718e-02f, -5.72611056e-02f, -2.53985506e-02f,
  -2.55288750e-01f, 2.70243526e-01f, -1.40900835e-01f, -7.62186199e-03f, -5.76794595e-02f, 5.64039834e-02f, 6.64457008e-02f, -2.51895189e-02f, 9.57841650e-02f, 2.84511838e-02f,
  -2.62337290e-02f, -2.41281129e-02f, 3.38754766e-02f, 5.63464593e-03f, -2.23222561e-02f, 1.04667312e-02f, 4.22121063e-02f, 1.13400504e-01f, 4.44133990e-02f, -1.26294822e-01f,
  -6.88636974e-02f, -3.06778569e-02f, -2.34853663e-02f, 1.80648938e-02f, 7.33000413e-02f, -1.00504488e-01f, -4.65058163e-02f, 4.45661061e-02f, -4.35239263e-02f, 1.52505800e-01f,
  -8.21034331e-03f, -1.13602526e-01f, 2.43546329e-02f, 4.51119617e-03f, 7.60957077e-02f, 2.82605607e-02f, 6.45555630e-02f, -9.17646810e-02f, -4.01482880e-02f, 1.03724468e-02f,
  -5.05739823e-02f, 9.04221926e-03f, -4.63530123e-02f, 1.50129542e-01f, -4.29917015e-02f, -1.92990210e-02f, -1.12537267e-02f, -1.03998892e-02f, -3.72335985e-02f, 6.67059124e-02f,
  2.26738472e-02f, -2.80475970e-02f, -1.89398360e-02f, 8.63143615e-03f, -4.15056273e-02f, 4.33975551e-03f, 1.36794532e-02f, -1.03635319e-01f, 1.21210692e-02f, -4.58273068e-02f,
  5.12122512e-02f, -2.95634090e-04f, 4.17381385e-03f, 1.17010936e-01f, -9.09181312e-02f, 2.04600617e-02f, -5.75358421e-02f, 5.69095984e-02f, -4.11697058e-03f, 3.63393407e-03f,
  1.79555975e-02f, -2.41198242e-02f, -2.96420529e-02f, 7.66705582e-03f, 4.99489205e-03f, 5.04538864e-02f, -1.49363875e-02f, 1.50871696e-02f, 1.33258281e-02f, 3.27712931e-02f,
  2.30760947e-02f, 7.31001562e-03f, 1.36768326e-01f, 5.06326556e-02f, -2.93442011e-02f, -3.52113787e-03f, -5.23636565e-02f, -1.26608750e-02f, 3.89430001e-02f, 1.98233858e-01f,
  -9.61693376e-02f, 6.83163181e-02f, 4.28504124e-02f, 2.80063469e-02f, 8.89951643e-03f, -5.65730333e-02f, -8.84457231e-02f, 1.87862348e-02f, -4.44086529e-02f, 3.32764871e-02f,
  1.15657561e-01f, 8.82102028e-02f, 7.12969229e-02f, 5.77758327e-02f, -3.19447406e-02f, -1.33394539e-01f, -2.82373093e-02f, 2.23007090e-02f, 7.46692866e-02f, 2.22507697e-02f,
  1.03762925e-01f, 1.15454398e-01f, 1.11014217e-01f, 8.99192169e-02f, 6.49234205e-02f, 9.82680023e-02f, 1.07732132e-01f, 1.02829888e-01f, 7.25348070e-02f, 3.96785475e-02f,
  1.03799678e-01f, 6.93107918e-02f, -5.93972206e-03f, 2.49868035e-02f, -3.26870941e-02f, 1.73493556e-03f, -5.77745549e-02f, -2.51236781e-02f, -7.75677059e-03f, 1.63385719e-02f,
  -4.54440266e-02f, 5.36551960e-02f, 1.37395799e-01f, 5.27556650e-02f, -7.66759068e-02f, 3.85341421e-02f, -1.05429359e-01f, -1.86161231e-02f, -1.59044564e-03f, -5.35677075e-02f,
  4.13205251e-02f, 9.41090286e-02f, -1.00028655e-02f, -6.22037090e-02f, 4.59576212e-02f, 7.55763873e-02f, 3.56972441e-02f, 4.28727865e-02f, -5.43884858e-02f, -1.23021863e-01f,
  -1.92953840e-01f, 1.58038605e-02f, -4.59751934e-02f, 6.03690967e-02f, -1.03235058e-01f, -8.00021142e-02f, 3.03997286e-02f, 7.68087665e-03f, 6.39451966e-02f, 6.35156631e-02f,
  -2.72316374e-02f, -4.92730103e-02f, -7.16236830e-02f, 2.21188436e-03f, 6.87366398e-03f, -1.04975989e-02f, 6.64551109e-02f, 3.12077664e-02f, 5.59251755e-02f, 4.78930399e-03f,
  6.27280623e-02f, -2.14531589e-02f, 4.85727703e-03f, 3.36971357e-02f, -4.98125330e-02f, -8.94061700e-02f, 5.41675091e-02f, 4.38920297e-02f, 6.04847856e-02f, 5.19159585e-02f,
  1.73888262e-02f, 2.50398908e-02f, -1.59136672e-02f, 3.34842540e-02f, -4.45447862e-03f, 2.69733332e-02f, 8.81521180e-02f, 3.12481783e-02f, 7.76131637e-03f, 4.22847010e-02f,
  9.29468498e-02f, 6.46316782e-02f, 1.27536982e-01f, -3.68248783e-02f, 9.62864328e-03f, -3.13995895e-03f, 6.33828901e-03f, -3.07050385e-02f, -1.39561063e-03f, -4.74290587e-02f,
  -1.10619240e-01f, -1.57876477e-01f, -6.58459067e-02f, -1.39834717e-01f, -8.30156133e-02f, 4.03917059e-02f, -2.60672048e-02f, -1.03644490e-01f, -6.05272278e-02f, -2.29601189e-01f,
  -1.19879097e-01f, 2.56344140e-01f, -3.48002091e-02f, 7.82690793e-02f, 1.62349969e-01f, 1.99889801e-02f, 1.61060572e-01f, -2.19979677e-02f, -5.00880219e-02f, 1.34264007e-01f,
  1.90392599e-01f, -3.08844969e-02f, -4.39203009e-02f, -6.80290461e-02f, -6.05429672e-02f, 5.37291802e-02f, -1.35062024e-01f, -2.75637180e-01f, -3.11800629e-01f, -8.97716582e-02f,
  -1.72537640e-02f, -3.62740830e-02f, -1.29413590e-01f, -1.34467930e-02f, 2.78373491e-02f, -1.18431402e-04f, -3.87295932e-02f, -5.55535480e-02f, 9.55530256e-03f, 3.59039642e-02f,
  -1.45596087e-01f, 1.96773604e-01f, -9.41957682e-02f, 3.77675705e-02f, 7.52786323e-02f, -2.14827079e-02f, -6.23554960e-02f, -3.20608914e-02f, 2.35780198e-02f, 5.47497049e-02f,
  9.00671408e-02f, -1.27953803e-02f, 4.57726866e-02f, -1.43254837e-02f, 4.88121249e-02f, -6.78407354e-03f, 7.69680589e-02f, -1.60640657e-01f, -1.48480862e-01f, -4.63383347e-02f,
  5.11086844e-02f, 1.28171653e-01f, -1.66867282e-02f, 7.23153055e-02f, -4.87802699e-02f, -1.34310037e-01f, -4.18511741e-02f, -5.22430018e-02f, -7.64985159e-02f, -7.69302174e-02f,
  -2.18757503e-02f, -1.38894776e-02f, 1.74496099e-02f, 7.26195564e-03f, 2.14684214e-02f, -6.28263578e-02f, 6.87370002e-02f, 1.09556066e-02f, -7.47610629e-02f, -9.42731742e-03f,
  -4.75971289e-02f, -3.30236144e-02f, 3.01037095e-02f, 1.29722236e-02f, 2.33232044e-02f, 3.78469899e-02f, -1.24927033e-02f, -4.04655235e-03f, 5.38780764e-02f, 4.84324060e-02f,
  6.12822622e-02f, 4.57662567e-02f, 8.35504904e-02f, -3.55166532e-02f, -3.18379998e-02f, 1.80981699e-02f, 1.93681405e-03f, 2.58996896e-02f, -4.46257740e-02f, -1.55788455e-02f,
  -2.96001453e-02f, 5.57971932e-02f, -9.47359875e-02f, -1.43560171e-02f, 6.62075058e-02f, -5.87699227e-02f, 9.31748673e-02f, 3.78131047e-02f, 3.95309031e-02f, -6.11689948e-02f,
  -5.92279341e-03f, 1.45326601e-02f, 6.71792254e-02f, -7.86131695e-02f, -4.43758070e-02f, -4.42970321e-02f, 8.99943188e-02f, -7.12674111e-02f, -4.07531895e-02f, 7.46941417e-02f,
  8.59323665e-02f, -1.18022589e-02f, -2.18647912e-01f, -1.29820287e-01f, -3.72235067e-02f, -4.86492664e-02f, -1.32227957e-01f, -1.04914702e-01f, -1.89924508e-01f, -1.02839947e-01f,
  3.20563614e-01f, -8.20200890e-02f, -3.60200524e-01f, 1.45425141e-01f, 2.98426673e-02f, -3.19700199e-03f, -1.79467693e-01f, 3.36239636e-02f, 6.26804456e-02f, -7.75259435e-02f,
  1.41241280e-02f, 1.10323608e-01f, 7.76906759e-02f, 8.77622068e-02f, 6.87629208e-02f, -1.53572515e-01f, -8.34137723e-02f, 3.62194218e-02f, 2.55662948e-02f, 1.65162653e-01f,
  9.18986574e-02f, 1.46238193e-01f, 5.54858744e-02f, 1.08807698e-01f, -1.17808342e-01f, 2.28072274e-02f, -2.21039146e-01f, -1.34982407e-01f, -1.35545447e-01f, -1.02219932e-01f,
  -9.00679529e-02f, -7.52669722e-02f, 1.20364748e-01f, 9.02600214e-02f, -6.26517907e-02f, 1.84229165e-02f, -4.93199117e-02f, -1.24346271e-01f, 6.59926310e-02f, -1.46586513e-02f,
  6.61513135e-02f, 9.17379931e-03f, -6.10133260e-03f, -2.49458905e-02f, 2.38885060e-02f, -3.73210981e-02f, -8.20877180e-02f, -1.84707288e-02f, 4.16994579e-02f, -1.07596301e-01f,
  -2.49990746e-02f, 9.84208286e-03f, 1.23956297e-02f, -1.29249487e-02f, -2.03405600e-02f, 5.19512445e-02f, -1.32057309e-01f, 4.14909758e-02f, -8.62352625e-02f, 4.54308838e-02f,
  5.49779870e-02f, -6.86158836e-02f, -2.47477572e-02f, 3.51762515e-03f, 5.42337708e-02f, -5.90844564e-02f, -7.73407817e-02f, -2.83412188e-02f, -2.83049345e-02f, -5.02419323e-02f,
  4.04854193e-02f, 2.91034356e-02f, -3.14847715e-02f, -1.61789507e-02f, -1.04596969e-02f, -7.47129321e-02f, 4.08743061e-02f, -5.78125156e-02f, 5.72357737e-02f, 2.03956254e-02f,
  2.41042003e-02f, -4.38516773e-02f, -3.12616453e-02f, -1.13687091e-01f, 1.04279704e-02f, -4.90746312e-02f, 6.48730546e-02f, 1.06043937e-02f, -1.57559253e-02f, -5.77174351e-02f,
  1.72923580e-02f, -4.38722782e-02f, 1.17654920e-01f, 1.50247410e-01f, 3.70963514e-02f, -4.17959057e-02f, 3.90481874e-02f, 4.30066660e-02f, 2.54263990e-02f, 2.04790831e-02f,
  -3.83620113e-02f, 8.06988478e-02f, 1.89830307e-02f, 3.28428783e-02f, 1.37598529e-01f, 1.35132112e-03f, 1.61982123e-02f, 5.41044287e-02f, -7.12770177e-03f, -2.93321554e-02f,
  -8.65654051e-02f, 1.00202538e-01f, 1.63159788e-01f, 5.26800230e-02f, -3.45410337e-03f, 1.07445791e-01f, 2.60136034e-02f, -1.82716493e-02f, 8.43196288e-02f, 1.43672258e-01f,
  4.03983802e-01f, 3.32715631e-01f, 1.34934396e-01f, 2.34472558e-01f, -8.86119530e-03f, -4.26100753e-02f, 1.04928665e-01f, 3.50977108e-02f, 2.50848215e-02f, 1.10252582e-01f,
  2.98504531e-02f, -1.59911901e-01f, -7.69660696e-02f, -4.46517244e-02f, -5.07840980e-03f, 1.30628303e-01f, 1.47031143e-01f, 5.64400740e-02f, -1.33504748e-01f, -9.16797370e-02f,
  2.23795604e-02f, 4.69314195e-02f, 1.26825469e-02f, -3.49278115e-02f, 2.23728597e-01f, 2.26115715e-02f, 5.20825572e-02f, 1.40213042e-01f, 4.17741276e-02f, 3.49656403e-01f,
  6.57481104e-02f, 2.20820829e-01f, -7.67298043e-02f, 2.46859547e-02f, 1.69236902e-02f, 1.17573803e-02f, -2.36509573e-02f, -1.30027803e-02f, -1.97209939e-02f, -6.82537118e-03f,
  -3.53048481e-02f, 3.91699886e-03f, -6.55916557e-02f, 3.38778123e-02f, 9.88118872e-02f, -8.81864205e-02f, -2.47077327e-02f, -1.23247951e-02f, -5.98886870e-02f, 2.70740911e-02f,
  2.99443118e-02f, 1.60476267e-01f, 8.08687881e-02f, 3.51563864e-03f, 7.64991865e-02f, -9.94943082e-02f, -2.83266641e-02f, -7.05827102e-02f, -7.20991641e-02f, 5.71377426e-02f,
  -2.84518376e-02f, -2.66487841e-02f, 2.47884169e-02f, -5.17969429e-02f, 1.83095653e-02f, -1.85376480e-02f, 5.96220531e-02f, 5.83412498e-03f, -6.16666451e-02f, 3.44623551e-02f,
  2.52846684e-02f, -3.98125909e-02f, 2.26796065e-02f, -2.84105912e-02f, 6.79592788e-02f, -3.36271338e-02f, 2.29737647e-02f, -4.43100370e-02f, 3.67518030e-02f, 3.67796570e-02f,
  -1.21741723e-02f, -3.09871286e-02f, 3.53655890e-02f, 2.49230433e-02f, 2.83907354e-02f, 2.05024574e-02f, 5.66591397e-02f, -1.01081900e-01f, 3.74593623e-02f, -3.74685340e-02f,
  -1.47459149e-01f, -2.20195845e-01f, 1.72061875e-01f, -2.90173292e-02f, 1.96066760e-02f, -4.33499599e-03f, 7.42521212e-02f, -3.18875350e-02f, 5.82370311e-02f, 8.09096470e-02f,
  6.03863820e-02f, -3.13361175e-02f, 8.01236555e-02f, -3.84065416e-03f, 1.66311730e-02f, 7.72827771e-03f, 2.51219440e-02f, -5.10501862e-03f, -4.90979217e-02f, 5.54993153e-02f,
  -6.37959018e-02f, -2.47626510e-02f, -4.46268469e-02f, -9.49205384e-02f, -2.50159055e-02f, -7.71592632e-02f, -4.27415222e-02f, 2.60555390e-02f, -1.42248541e-01f, -1.90426118e-03f,
  3.70038986e-01f, 1.64235651e-01f, 2.37554118e-01f, 6.36817068e-02f, -2.38244496e-02f, 2.79318281e-02f, 2.32004598e-01f, 1.71935692e-01f, 3.57865058e-02f, -5.84633043e-03f,
  -9.48919281e-02f, -1.60023212e-01f, -1.58739477e-01f, -8.95256102e-02f, -1.63626652e-02f, 2.16346845e-01f, 1.41738415e-01f, 8.48082155e-02f, 5.94940446e-02f, -3.07878517e-02f,
  -1.24358833e-01f, 7.08450153e-02f, 1.66158546e-02f, -5.59882298e-02f, -8.71916488e-02f, -1.51399523e-01f, -9.11179278e-03f, 5.59202880e-02f, -7.57412165e-02f, 4.07447480e-02f,
  9.91464313e-03f, 1.85752824e-01f, -3.73815559e-02f, -2.07591839e-02f, -2.38658637e-02f, 3.81208956e-02f, -4.36489545e-02f, 7.73952752e-02f, -8.58473182e-02f, 9.53377783e-02f,
  -8.77834111e-02f, -5.08694127e-02f, -7.07517117e-02f, -1.16841486e-02f, 1.74602885e-02f, 6.34372011e-02f, 1.20053023e-01f, 7.51070976e-02f, 1.03803672e-01f, 8.06919709e-02f,
  -1.33139100e-02f, -2.31209714e-02f, 1.75420791e-01f, 4.96628322e-02f, -1.14557827e-02f, -2.38154717e-02f, -7.38840252e-02f, -4.27071527e-02f, -3.92080918e-02f, 1.40449509e-01f,
  7.22476887e-03f, 1.02835987e-02f, -5.65054417e-02f, 5.00954539e-02f, -7.05768354e-03f, -6.98940977e-02f, -4.96885590e-02f, 4.35426198e-02f, -4.64798212e-02f, 3.40787619e-02f,
  6.47936314e-02f, 1.61816422e-02f, 6.31306693e-02f, 1.51745658e-02f, 9.08088498e-03f, 7.11703598e-02f, 1.35619137e-02f, 6.42379299e-02f, -5.86176291e-02f, -4.54072841e-03f,
  3.39282826e-02f, 4.42732424e-02f, -6.42380118e-02f, -7.79154301e-02f, -9.64342803e-02f, 4.26143706e-02f, -2.89018396e-02f, 1.41956555e-02f, 1.71696115e-02f, 6.32085055e-02f,
  -5.17664738e-02f, -6.69418126e-02f, -4.26921993e-03f, -1.49595058e-02f, 7.27022812e-02f, -9.11863744e-02f, -4.65227962e-02f, -1.83976255e-02f, -7.00167269e-02f, -8.55407584e-03f,
  4.32646088e-03f, -5.19440174e-02f, 5.87233342e-02f, 1.76460743e-02f, -3.85143012e-02f, -4.68064705e-03f, 4.94161397e-02f, 2.06741802e-02f, -2.10862868e-02f, 5.30970618e-02f,
  8.00757110e-02f, 1.87042013e-01f, 7.27321953e-02f, 1.36251077e-01f, -7.69253001e-02f, -3.58079821e-02f, 1.13944717e-01f, -5.89848831e-02f, 7.88877308e-02f, 1.69367060e-01f,
  1.00888655e-01f, -3.12437173e-02f, 1.95544600e-01f, -6.86685219e-02f, 2.16272727e-01f, 2.17749655e-01f, 3.28356326e-01f, 3.97411222e-03f, -6.10664673e-02f, -2.12126579e-02f,
  6.95275441e-02f, -2.50720587e-02f, -1.62679814e-02f, -7.04453886e-02f, -4.47588693e-03f, 4.32792269e-02f, 6.36505242e-03f, 1.83862895e-02f, 1.55143782e-01f, 1.39520615e-01f,
  -8.46787915e-02f, -1.19454384e-01f, -4.88499366e-02f, -9.56977066e-03f, -4.76405770e-02f, -1.50640747e-02f, -2.01359158e-03f, -4.16391753e-02f, 6.19332679e-02f, -7.70543590e-02f,
  -2.16060467e-02f, 2.47291792e-02f, 7.50790089e-02f, -1.37678739e-02f, 5.12032844e-02f, 6.92727640e-02f, 2.46150363e-02f, 1.25387125e-03f, 9.86817572e-03f, -6.74831271e-02f,
  2.92316619e-02f, 5.32598495e-02f, -3.80988792e-02f, -9.60779414e-02f, -1.19581576e-02f, -4.38340865e-02f, -1.15779616e-01f, 5.80089539e-03f, 3.16987815e-03f, -7.64634982e-02f,
  4.85823154e-02f, 2.25740626e-01f, 1.97445393e-01f, 6.99894056e-02f, 5.36357127e-02f, 1.52975485e-01f, 3.53347287e-02f, -3.95740904e-02f, 7.23238513e-02f, -7.14425743e-02f,
  -1.78895220e-02f, -3.95902060e-02f, -4.06439938e-02f, -6.34272918e-02f, 8.59578047e-03f, -2.67857802e-03f, -2.72254720e-02f, -5.58788925e-02f, -4.60552797e-02f, 6.01693429e-02f,
  2.74790768e-02f, 3.33944336e-02f, -4.72943820e-02f, 5.81198023e-04f, -7.10938200e-02f, 5.89053445e-02f, 3.43917087e-02f, -9.05933604e-02f, 1.88543797e-02f, -7.18769133e-02f,
  5.55228768e-03f, 5.22373691e-02f, 4.16334765e-03f, -3.95483263e-02f, 6.15136772e-02f, -5.19856811e-02f, 3.06025147e-02f, -8.32974017e-02f, 9.21359099e-03f, 9.85485688e-02f,
  -2.10774168e-01f, 2.43813768e-01f, 3.80136855e-02f, -8.27921554e-02f, 6.64110556e-02f, -8.74375105e-02f, 6.01047464e-02f, -8.88493881e-02f, 1.00021638e-01f, 4.84805480e-02f,
  1.70363877e-02f, -1.61674805e-02f, 3.00134439e-02f, -5.31587154e-02f, 4.74367850e-02f, 6.95931837e-02f, -8.76294374e-02f, -1.40064629e-02f, -1.15503557e-02f, -2.71515157e-02f,
  -7.52821043e-02f, 1.96714312e-01f, 1.11021273e-01f, 9.23020542e-02f, 1.02731399e-01f, 1.56610876e-01f, 1.36963263e-01f, 1.25210196e-01f, 1.30306572e-01f, 1.14138119e-01f,
  9.13954154e-02f, -2.90488094e-01f, -3.29078138e-01f, 1.74279168e-01f, -1.00390553e-01f, -2.39242986e-01f, -3.44523907e-01f, -8.87444988e-02f, 1.28408819e-01f, -5.22432439e-02f,
  -1.65046439e-01f, 2.14839564e-03f, -1.72850990e-03f, -2.42157243e-02f, 2.64011864e-02f, -8.02989453e-02f, -8.91726464e-03f, -4.16977815e-02f, 5.60710542e-02f, 1.31372824e-01f,
  1.14445917e-01f, 2.57827610e-01f, 8.01732540e-02f, 1.70895115e-01f, 1.85654044e-01f, 1.62191853e-01f, 7.02611580e-02f, -4.24608886e-02f, -4.09088507e-02f, 5.10056242e-02f,
  -3.76588851e-01f, -9.75452885e-02f, 1.16505727e-01f, 1.85439065e-01f, 5.54259196e-02f, 5.68916239e-02f, 1.51921688e-02f, 2.02229177e-03f, -4.21168730e-02f, 7.59097189e-02f,
  5.93838505e-02f, -2.50977706e-02f, -8.13865382e-03f, 1.57913787e-03f, 8.93966407e-02f, -8.60540420e-02f, 1.47598863e-01f, 5.32035790e-02f, 4.51264903e-03f, -3.08935717e-02f,
  1.18269278e-02f, 3.25798355e-02f, -1.29843026e-01f, -7.24810585e-02f, -6.21793456e-02f, -2.60642692e-02f, -1.42467856e-01f, 5.11836968e-02f, -1.33766234e-01f, 1.05456263e-01f,
  6.38050288e-02f, -4.89323363e-02f, -3.10794450e-02f, -2.04539895e-02f, 2.86258440e-02f, -3.79801504e-02f, -7.52890483e-03f, 8.09338782e-03f, -1.66927334e-02f, 4.12643887e-02f,
  -5.33864014e-02f, 7.53122335e-03f, -2.60845609e-02f, 1.58698820e-02f, 3.08485851e-02f, -2.04761829e-02f, -2.71924529e-02f, -6.52221171e-03f, -9.33898985e-03f, -2.05798689e-02f,
  5.13882656e-03f, 6.76757051e-03f, 4.07881811e-02f, 1.52869765e-02f, 1.15519129e-02f, -1.45711554e-02f, -3.00911572e-02f, 3.56144756e-02f, 6.60630316e-02f, 6.99932352e-02f,
  4.31200340e-02f, -2.44950876e-02f, -7.65496716e-02f, 4.05865163e-02f, -6.36551380e-02f, -2.68917941e-02f, -1.14803417e-02f, 6.77136406e-02f, 4.15694602e-02f, -1.34635149e-02f,
  -8.60347077e-02f, 1.92458127e-02f, -5.56685813e-02f, 4.34202589e-02f, -5.78252645e-03f, 3.41936783e-03f, 4.94786948e-02f, 6.61201850e-02f, -2.72744298e-02f, 4.31638472e-02f,
  4.60321456e-02f, 1.88936759e-02f, -1.68795094e-01f, -6.40646964e-02f, -4.31368575e-02f, -6.90814853e-02f, -1.07338838e-01f, -1.02379903e-01f, -1.78993598e-01f, -6.30451366e-02f,
  -3.98698658e-01f, -1.28581420e-01f, 2.56734461e-01f, -2.45068431e-01f, -1.26432301e-03f, 7.09110349e-02f, 1.62181333e-01f, 5.70323877e-02f, -1.55126214e-01f, -6.73335567e-02f,
  -1.23987664e-02f, -6.88675717e-02f, 1.12039577e-02f, 4.92334366e-02f, -2.51895506e-02f, 1.22999705e-01f, 1.68330908e-01f, 6.01480305e-02f, 2.02013373e-01f, -3.96468565e-02f,
  -1.27013717e-02f, -9.46257785e-02f, -1.89026237e-01f, -4.87299860e-02f, -1.13073304e-01f, 8.41576904e-02f, 3.66564356e-02f, -1.15729086e-01f, 1.41951395e-03f, -9.17105526e-02f,
  2.20358923e-01f, -1.08165525e-01f, 6.10849671e-02f, -7.40940571e-02f, 2.13133246e-02f, -5.30583821e-02f, 1.57973021e-02f, -5.64260930e-02f, -5.61338663e-02f, 1.11258272e-02f,
  -1.13487720e-01f, -7.79195577e-02f, 4.51771766e-02f, 5.68690524e-02f, -7.18532875e-02f, 5.36155589e-02f, 2.14492735e-02f, -5.57277799e-02f, 5.53156361e-02f, -7.11403936e-02f,
  -6.20740689e-02f, -1.63021177e-01f, -4.66586016e-02f, 1.41207784e-01f, 1.94961764e-02f, -5.79125620e-02f, 4.87267226e-02f, -2.31126640e-02f, 3.64720076e-02f, -7.13673383e-02f,
  5.00222631e-02f, 7.54234642e-02f, 1.05100907e-02f, -7.01277480e-02f, -9.57707595e-03f, -3.96638550e-02f, 1.33492695e-02f, 4.73727807e-02f, -5.16735464e-02f, 8.47377554e-02f,
  -3.22871916e-02f, 1.79750230e-02f, -1.01260263e-02f, 1.54766981e-02f, 3.89189124e-02f, -8.68368614e-03f, -6.28531650e-02f, -1.39750587e-02f, 7.29170218e-02f, -3.95225286e-02f,
  -9.76308286e-02f, -1.95878763e-02f, 4.25569825e-02f, -5.32224253e-02f, 4.75581102e-02f, -6.34705126e-02f, 1.83922313e-02f, 2.17889100e-02f, 9.28357895e-03f, -9.99255106e-02f,
  -6.97461814e-02f, -1.07204141e-02f, -9.25938785e-02f, 2.15088632e-02f, -4.13230769e-02f, 3.03976075e-03f, -5.48608154e-02f, -2.27731885e-03f, -9.50929057e-03f, 8.90978649e-02f,
  -1.46349082e-02f, -6.51985101e-05f, -5.43624908e-02f, -3.41795124e-02f, -6.20749034e-03f, -1.18302926e-02f, -1.17717959e-01f, 4.95446660e-02f, 4.31163050e-02f, 1.46798091e-02f,
  -2.76640896e-02f, 1.82344653e-02f, 7.01014400e-02f, 1.12915963e-01f, -5.43835163e-02f, -2.09444202e-02f, 1.32016465e-01f, 7.88958520e-02f, 1.38545439e-01f, 9.30153355e-02f,
  1.95418194e-01f, 1.74589753e-02f, 1.52297065e-01f, 6.41754121e-02f, -1.11626498e-01f, -2.28834763e-01f, -2.51744211e-01f, -1.71782672e-01f, -9.50240940e-02f, -4.62888665e-02f,
  3.62480953e-02f, -4.35837582e-02f, -6.01537675e-02f, -1.03683108e-02f, -1.47125423e-01f, -1.69556260e-01f, -1.11879017e-02f, -1.33281257e-02f, 5.97972274e-02f, -5.14242575e-02f,
  1.22269737e-02f, -2.00807117e-02f, 1.22575112e-01f, -2.38554683e-02f, 4.18262966e-02f, 1.15375102e-01f, 1.63840085e-01f, 1.45495176e-01f, 9.91675481e-02f, 2.23069251e-01f,
  1.71716437e-01f, 1.46676838e-01f, -1.18138604e-02f, 4.74107303e-02f, 1.21114172e-01f, -6.06473237e-02f, 8.63847136e-02f, 1.37116924e-01f, -1.74007230e-02f, 8.12140293e-03f,
  1.08486265e-01f, -3.53940576e-02f, 9.12250280e-02f, 5.20765446e-02f, 1.05433236e-03f, 4.97395508e-02f, -5.53531311e-02f, 7.19093680e-02f, 1.57577433e-02f, -3.74100991e-02f,
  -3.66305970e-02f, 6.45660758e-02f, 1.40692726e-01f, -2.25358009e-02f, 6.74477741e-02f, 2.59373039e-02f, 5.79886474e-02f, 1.67772442e-01f, 6.32240325e-02f, -3.93460728e-02f,
  1.93522032e-02f, 2.86866426e-02f, -1.52420234e-02f, 1.80922411e-02f, -4.49022129e-02f, -2.67362986e-02f, 7.88902864e-02f, -5.65111712e-02f, -1.11079197e-02f, 1.68352146e-02f,
  -4.08108830e-02f, -2.64187325e-02f, 3.39259692e-02f, 2.90132444e-02f, 7.75621906e-02f, 5.25738159e-03f, 4.52314317e-02f, -3.66287865e-02f, -2.00775694e-02f, -1.77351572e-02f,
  -1.55106867e-02f, 6.30147830e-02f, 1.74965020e-02f, 2.58807801e-02f, -5.21961972e-02f, -3.02133579e-02f, -1.31649745e-03f, -4.55852076e-02f, 8.60174820e-02f, 3.58652249e-02f,
  -1.36222303e-01f, -1.41084446e-02f, -7.48821869e-02f, -4.02005725e-02f, 4.91144918e-02f, 7.71438405e-02f, -2.61591095e-02f, -3.08847073e-02f, 1.08623408e-01f, -7.00896755e-02f,
  -3.16437520e-02f, -2.38991603e-02f, -5.11611849e-02f, -3.44489180e-02f, -8.36676136e-02f, -6.99416846e-02f, -2.26563234e-02f, -8.46204013e-02f, -8.02420974e-02f, -9.61712282e-03f,
  -1.08038627e-01f, -9.76069197e-02f, -1.92547187e-01f, -1.94348663e-01f, 5.52175529e-02f, -1.12223528e-01f, -9.34900492e-02f, -1.44093156e-01f, -1.84640348e-01f, -2.59912431e-01f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.83623105e-01f, -1.25695020e-01f, -4.28038478e-01f, -1.41731963e-01f, -1.90391451e-01f, -2.00958952e-01f, -1.89678594e-01f, -4.01485562e-02f, -4.24866714e-02f, -2.40736663e-01f,
  -1.75878555e-02f, -2.91651245e-02f, 8.31505749e-03f, 1.05002411e-01f, 4.86696921e-02f, -2.89225668e-01f, -2.74376094e-01f, -1.75040103e-02f, 1.37276966e-02f, 1.11362688e-01f,
  7.43370131e-02f, -7.84307420e-02f, 1.37891602e-02f, 5.14887758e-02f, -1.17592320e-01f, -6.95502162e-02f, -3.01005572e-01f, -1.44479468e-01f, -1.70926169e-01f, -2.83417046e-01f,
  -2.17413247e-01f, -4.57170866e-02f, 8.13331641e-03f, -1.76947434e-02f, -1.08595647e-01f, 5.91518097e-02f, 3.99219692e-02f, 2.82767639e-02f, 4.49392432e-03f, 5.42872166e-03f,
  -1.07685596e-01f, 7.95407817e-02f, -6.06333464e-02f, 5.08673023e-03f, 4.59894165e-02f, 7.55224526e-02f, 4.70149927e-02f, 6.97808340e-02f, 3.94810475e-02f, -7.45256990e-02f,
  -1.75991543e-02f, -6.33725896e-03f, 6.75397888e-02f, 5.35500459e-02f, -5.50292991e-02f, 1.23704849e-02f, -1.58277452e-02f, -3.79781723e-02f, 1.40910726e-02f, -4.55921292e-02f,
  -1.02600865e-02f, -6.07525781e-02f, 6.90747648e-02f, -7.10536167e-02f, 1.56684418e-03f, -5.09119183e-02f, -4.76084203e-02f, 3.26421075e-02f, -3.00999712e-02f, 1.61494333e-02f,
  -1.73466094e-02f, -1.43064810e-02f, -4.52585667e-02f, -6.15207441e-02f, 1.88772548e-02f, -6.77174404e-02f, 7.50940666e-02f, 4.31788936e-02f, 5.57504781e-02f, 2.71717906e-02f,
  1.18222078e-02f, 5.32738604e-02f, -6.29912615e-02f, 4.45139594e-02f, -9.83660594e-02f, 4.49172147e-02f, 1.40177011e-02f, -1.45749394e-02f, 7.23603889e-02f, -7.26189390e-02f,
  4.22297120e-02f, -5.08835614e-02f, -2.02658214e-02f, 1.45633742e-01f, -1.12132780e-01f, -1.02341443e-01f, -9.59181562e-02f, 5.17457202e-02f, -4.98084947e-02f, 2.08498240e-02f,
  -2.14176439e-02f, 1.19357780e-01f, 2.59166174e-02f, -1.93402674e-02f, -3.63109931e-02f, 3.75591554e-02f, -7.14706853e-02f, -8.03739056e-02f, 4.55603981e-03f, -9.98205915e-02f,
  -1.32761613e-01f, 9.16154832e-02f, 1.88236132e-01f, -2.46082526e-03f, 1.11132078e-01f, 1.43393531e-01f, 5.15722744e-02f, -8.54683202e-03f, 2.33476423e-02f, -1.53016811e-02f,
  -1.50952309e-01f, -3.61958742e-02f, 7.40074515e-02f, -1.25581235e-01f, 1.32322982e-01f, 1.70916468e-01f, 1.92337051e-01f, 7.42261410e-02f, -1.12710200e-01f, -6.98647872e-02f,
  5.57200499e-02f, -1.09142490e-01f, -1.28793582e-01f, -3.81401926e-02f, 6.53981417e-02f, 7.97964409e-02f, 1.59475654e-02f, -8.69803727e-02f, -8.48753229e-02f, 8.00789222e-02f,
  -6.68750703e-02f, -9.37033072e-02f, -6.14266470e-02f, -5.83086312e-02f, -2.18933038e-02f, -7.19946399e-02f, -7.88548291e-02f, -7.18240514e-02f, -4.08914313e-02f, -1.23562016e-01f,
  -2.88529061e-02f, 3.97920385e-02f, -8.42614565e-03f, 5.28112687e-02f, -7.24679381e-02f, 1.27220554e-02f, 3.99230868e-02f, 2.87972484e-02f, 4.66936640e-02f, 7.31167644e-02f,
  2.24495623e-02f, -1.15006063e-02f, -2.87233256e-02f, 4.17482071e-02f, 7.17772320e-02f, -7.70661468e-03f, -5.10563366e-02f, 4.56711762e-02f, 4.44738902e-02f, -1.30203934e-02f,
  8.17815512e-02f, -2.14586128e-02f, -7.32632540e-03f, 4.97999601e-02f, -6.17438869e-04f, -1.71813797e-02f, 3.50995958e-02f, -7.05783367e-02f, -1.29130865e-02f, 4.97860312e-02f,
  2.52817422e-02f, -6.25827489e-03f, -5.96673936e-02f, -2.81292573e-02f, 5.15229888e-02f, -1.83805563e-02f, -4.40748967e-02f, -2.37448718e-02f, -3.36850770e-02f, -1.06233535e-02f,
  -2.39629969e-02f, 6.92601055e-02f, -1.81845929e-02f, 3.42429243e-02f, 5.89422658e-02f, 5.97880706e-02f, -2.33135391e-02f, -1.91158578e-02f, 7.90118799e-02f, -2.03249138e-02f,
  2.18946068e-03f, 4.79945820e-03f, -8.33625793e-02f, 5.13617247e-02f, -6.99622259e-02f, 4.19201106e-02f, -3.19674052e-02f, -5.21634743e-02f, 2.22640969e-02f, -1.11461468e-02f,
  -8.99840966e-02f, 6.42039552e-02f, 2.60000844e-02f, -3.24030071e-02f, -5.97307868e-02f, -9.77027714e-02f, -5.17166071e-02f, -7.22412542e-02f, -4.97508273e-02f, -7.50326132e-03f,
  -1.43129462e-02f, -3.19315344e-02f, -2.43358109e-02f, -4.03342545e-02f, 2.08049733e-02f, -3.14154066e-02f, 8.94121081e-02f, 6.59557898e-03f, 9.17207599e-02f, 8.69423449e-02f,
  -1.16093578e-02f, 8.51737708e-03f, 2.34296266e-02f, 3.12595479e-02f, 8.59349295e-02f, -4.95943204e-02f, -8.22465047e-02f, 8.95755738e-02f, 4.14217524e-02f, -1.28943264e-01f,
  1.33873103e-02f, 7.46963173e-02f, 4.02416252e-02f, 4.76752855e-02f, -9.83135402e-02f, -6.29567169e-03f, -9.76927504e-02f, -5.70164584e-02f, -5.63391745e-02f, -1.23849846e-02f,
  -1.41633883e-01f, -8.47938284e-02f, 5.09819202e-02f, 6.38948306e-02f, 3.45884599e-02f, 7.61500001e-02f, 1.23613119e-01f, 1.97317764e-01f, 1.07669875e-01f, 3.52790020e-02f,
  -6.59710988e-02f, 1.27545863e-01f, 8.40781406e-02f, 1.47404224e-01f, 1.21633768e-01f, -2.68447995e-02f, 1.06910385e-01f, -6.81388844e-03f, 5.62850833e-02f, 1.70056239e-01f,
  -5.73416278e-02f, 9.33048353e-02f, -1.28665209e-01f, -2.82371640e-02f, -9.22325850e-02f, -3.72001901e-02f, 2.21855622e-02f, -1.14368964e-02f, -1.03308680e-02f, -1.77425966e-02f,
  3.89344171e-02f, -8.16952512e-02f, 9.07745734e-02f, 4.92021330e-02f, -5.03393859e-02f, -3.48924845e-02f, 5.51450513e-02f, -1.85670960e-03f, 2.95503829e-02f, 2.16758493e-02f,
  2.77072042e-02f, -1.92768164e-02f, -1.18369915e-01f, 4.26356122e-02f, 8.45475197e-02f, 4.15055789e-02f, 3.88233922e-02f, -4.77305204e-02f, -5.31020276e-02f, -4.31007221e-02f,
  2.15126630e-02f, 8.63356814e-02f, 7.84482807e-02f, -1.12357810e-02f, -2.25144476e-02f, -5.23731411e-02f, -5.84171936e-02f, 7.40803257e-02f, 3.25470716e-02f, -7.48444870e-02f,
  7.63349831e-02f, -1.79875214e-02f, -3.76737723e-03f, -7.84520358e-02f, -2.79833600e-02f, -6.17067749e-03f, 1.74995288e-02f, 4.48462106e-02f, 2.99594644e-02f, 4.40989509e-02f,
  -6.67547062e-02f, 1.00893732e-02f, -2.46422309e-02f, 8.38177726e-02f, -3.72335054e-02f, 8.25345740e-02f, 6.45464892e-03f, -2.77597234e-02f, 1.89934913e-02f, -1.15547571e-02f,
  -1.11873329e-01f, -1.77633256e-01f, 4.06807698e-02f, 1.36360740e-02f, -1.75762139e-02f, -9.02904123e-02f, 7.41362618e-03f, -6.19784258e-02f, 1.46720214e-02f, -7.96928778e-02f,
  -4.13145758e-02f, -8.76505673e-02f, -1.17201500e-01f, 2.28595827e-02f, 1.68852210e-02f, -1.28346514e-02f, -4.72107939e-02f, -1.46997739e-02f, -8.91407877e-02f, -8.85623395e-02f,
  -8.03941041e-02f, -7.02491999e-02f, -7.59808570e-02f, -5.78222871e-02f, -1.01898808e-03f, -1.52197098e-02f, -1.31248608e-01f, -1.01780109e-01f, -1.30988732e-01f, -7.57653117e-02f,
  -5.67600923e-03f, -8.73357356e-02f, 6.68084025e-02f, 6.01642393e-02f, 7.72122527e-03f, 7.36828074e-02f, -2.58793905e-02f, 6.30780533e-02f, 2.58478820e-02f, 4.75663245e-02f,
  -9.79510695e-03f, -1.13559693e-01f, -1.21916525e-01f, -9.42484941e-03f, 1.71478931e-02f, 1.79696397e-03f, 1.31910324e-01f, 9.04320702e-02f, 6.03200011e-02f, -3.19903977e-02f,
  -4.28592823e-02f, -7.23047480e-02f, 5.88033162e-02f, 8.70225877e-02f, -1.94375161e-02f, 5.39025180e-02f, 5.98380342e-02f, -2.06839647e-02f, -5.62549755e-02f, 5.78637607e-02f,
  -2.56550834e-02f, -9.51101631e-02f, 7.36829964e-03f, 1.91685166e-02f, -3.80106643e-02f, -2.77906172e-02f, -2.23979652e-02f, 2.56010070e-02f, -1.08932905e-01f, -6.21909499e-02f,
  -3.61279957e-02f, 2.51337960e-02f, 6.11209087e-02f, 1.61918402e-02f, 3.78367119e-02f, 3.46522070e-02f, 5.11135813e-03f, 6.26398101e-02f, 5.62491342e-02f, -9.91051458e-03f,
  6.20937860e-03f, 5.42710871e-02f, 3.13474685e-02f, -6.74203411e-03f, 6.11018203e-02f, 7.43651316e-02f, -1.57255158e-02f, 6.98623359e-02f, 4.91475165e-02f, 7.60070309e-02f,
  1.00617558e-01f, -4.26920205e-02f, -4.07889411e-02f, -3.98834273e-02f, 5.45442924e-02f, 2.91820476e-03f, 4.54846062e-02f, -6.10282645e-02f, -6.42504245e-02f, 1.25607010e-02f,
  -1.94478277e-02f, 3.89119573e-02f, -6.49062097e-02f, 5.10765053e-02f, 4.36144844e-02f, 5.18845692e-02f, -2.16411687e-02f, 6.84821978e-02f, -6.98743835e-02f, 1.03259366e-02f,
  -1.29947450e-03f, -1.08738653e-02f, 8.83929878e-02f, -4.38662283e-02f, 4.15095054e-02f, 6.23277985e-02f, 5.70514193e-03f, -8.71156454e-02f, 4.86688428e-02f, 8.93427804e-02f,
  1.15425885e-03f, 7.74456188e-02f, 2.16026623e-02f, -3.08508873e-02f, -4.35333662e-02f, 7.64454007e-02f, -7.55824298e-02f, 1.50461518e-03f, -5.86611181e-02f, -4.94289696e-02f,
  2.55037416e-02f, 6.77810609e-02f, -4.67249714e-02f, 7.05641136e-02f, 6.01828396e-02f, -6.75297678e-02f, -7.33155236e-02f, -3.34581695e-02f, 5.91658540e-02f, 7.80912116e-02f,
  -3.29010934e-02f, -7.53921550e-03f, -3.88995744e-02f, 1.04744136e-01f, 8.31565112e-02f, 1.30922645e-01f, -2.63923150e-03f, -5.39513677e-02f, 1.33343693e-03f, 6.71020476e-03f,
  -6.06767833e-04f, 2.14327592e-02f, -1.04663692e-01f, -1.14643775e-01f, -4.64278180e-03f, 1.17472308e-02f, -3.29110841e-03f, -5.76962903e-02f, 6.49801269e-02f, 8.92880112e-02f,
  2.38481555e-02f, -5.35430498e-02f, -1.02535255e-01f, -6.37640432e-02f, -6.85507059e-02f, 6.04569167e-02f, 8.79945755e-02f, -4.05086689e-02f, 1.09169841e-01f, 4.51457538e-02f,
  6.67100251e-02f, -6.74235374e-02f, 1.43246977e-02f, -9.46994871e-03f, -8.01153705e-02f, 5.10667115e-02f, -1.03846751e-02f, -7.47956485e-02f, -4.92733084e-02f, -1.04557015e-01f,
  8.87269154e-02f, -1.62036821e-01f, 5.00793979e-02f, -2.43255384e-02f, 1.18228318e-02f, 2.93482076e-02f, -6.35456517e-02f, -1.29418507e-01f, 1.71797145e-02f, 3.86801064e-02f,
  -4.85190712e-02f, -1.48555804e-02f, -1.10308401e-01f, 4.38610613e-02f, 5.66574112e-02f, 2.19355877e-02f, -7.94617683e-02f, -1.07067682e-01f, -9.27133709e-02f, -6.79531395e-02f,
  1.70212593e-02f, 4.16585617e-03f, 7.75968190e-04f, 4.72546890e-02f, -4.14728187e-02f, 5.27462140e-02f, 6.38936907e-02f, -1.68087874e-02f, -9.30227861e-02f, -7.34971836e-02f,
  9.09962729e-02f, 4.58338894e-02f, -3.60839777e-02f, -7.16512799e-02f, 8.72117877e-02f, -7.47616068e-02f, 8.16719532e-02f, -7.84266591e-02f, 7.90108666e-02f, 8.30230955e-03f,
  -7.62311816e-02f, -1.39492126e-02f, -4.25486127e-03f, 4.85585108e-02f, -7.90252015e-02f, 2.71661486e-02f, 2.87415441e-02f, -7.59900436e-02f, -4.03808579e-02f, 7.39823207e-02f,
  -4.47156746e-03f, -8.27548802e-02f, -2.33973358e-02f, -1.25704799e-02f, -1.04056008e-01f, 6.26803786e-02f, 5.92887029e-02f, -5.45249041e-03f, 6.50222003e-02f, -8.21884423e-02f,
  1.03369989e-01f, -9.37714949e-02f, -4.18961085e-02f, -4.26143110e-02f, -1.01064608e-01f, 5.90613522e-02f, 1.08087645e-03f, 2.90174782e-02f, 1.89385433e-02f, -3.01798787e-02f,
  -9.52446163e-02f, 4.34508957e-02f, 3.86140719e-02f, 1.31394491e-02f, 6.28701150e-02f, -5.71946800e-02f, -5.52632241e-03f, 8.43115617e-03f, 5.92158586e-02f, 5.40280752e-02f,
  2.23031379e-02f, 9.05831456e-02f, 8.17053989e-02f, 2.76968572e-02f, 6.28920496e-02f, 9.48969200e-02f, 7.81590641e-02f, 7.08286837e-02f, 7.75289834e-02f, 1.26283124e-01f,
  1.18142277e-01f, -1.76840052e-01f, -9.51154381e-02f, -5.95148355e-02f, -3.60536501e-02f, -1.09603219e-01f, -5.39173596e-02f, 5.50629720e-02f, 5.42192049e-02f, 3.90404873e-02f,
  1.39280185e-02f, -5.81723172e-03f, 4.00958806e-02f, 4.25959453e-02f, 1.05996437e-01f, 1.00435913e-02f, -2.76458021e-02f, 8.74304175e-02f, 1.07925065e-01f, -5.92503399e-02f,
  -9.11707357e-02f, -2.81891990e-02f, 1.03350796e-01f, 1.04057245e-01f, 2.67234109e-02f, 5.90599030e-02f, 3.95410173e-02f, -6.41080609e-04f, -4.82491404e-02f, -3.44626568e-02f,
  4.11745198e-02f, -4.71062809e-02f, 4.61517759e-02f, 3.33330072e-02f, -6.84219748e-02f, 1.22321686e-02f, -2.25969795e-02f, -4.36255746e-02f, -6.90270439e-02f, 2.22176518e-02f,
  -1.85756683e-02f, 4.55216132e-02f, -8.18663165e-02f, 7.03583509e-02f, -6.70737550e-02f, -2.56444104e-02f, -4.74991230e-03f, 2.61050630e-02f, 6.04156451e-03f, 3.82324937e-03f,
  -1.05441354e-01f, -1.26686290e-01f, -6.86427020e-03f, -6.31169677e-02f, 7.17466399e-02f, -1.56668648e-02f, 5.43047003e-02f, -7.88597614e-02f, 4.03092355e-02f, -6.81755245e-02f,
  -1.19789317e-02f, 6.64429367e-02f, 5.21710068e-02f, -6.40613958e-02f, 1.10624088e-02f, -4.38474119e-02f, -1.86190987e-03f, 2.56854738e-03f, -8.19328427e-02f, -1.56381563e-03f,
  9.89357084e-02f, -5.26710525e-02f, 3.86372097e-02f, 8.49571005e-02f, -3.65760773e-02f, -1.07466872e-03f, 2.99287904e-02f, 6.13841936e-02f, -1.67011078e-02f, 6.64747134e-02f,
  8.62680655e-03f, 5.09758070e-02f, 6.19937852e-02f, 4.43500886e-03f, -5.01439087e-02f, -8.18370357e-02f, 5.67486510e-02f, -2.86661834e-02f, 7.71501940e-03f, -9.16630328e-02f,
  2.46266834e-03f, 5.27189337e-02f, 7.08633140e-02f, -1.33210206e-02f, 2.38785311e-03f, 1.48113295e-02f, -8.32113102e-02f, 7.71170631e-02f, -3.44077833e-02f, -3.22847441e-02f,
  5.34890853e-02f, -4.82701696e-02f, 3.38225327e-02f, -1.03399217e-01f, -5.37555628e-02f, -1.63137279e-02f, -5.90326451e-02f, 9.14619537e-04f, -2.44232994e-02f, 1.19380066e-02f,
  1.42750405e-02f, -1.02483258e-01f, -1.40715344e-02f, 8.32407773e-02f, -1.13529712e-02f, 7.42738321e-02f, -2.57975366e-02f, -8.85844827e-02f, -9.85861570e-03f, -5.00779375e-02f,
  2.42224276e-01f, -1.96971744e-01f, 9.47886705e-02f, 3.23531241e-03f, 1.64348140e-01f, 9.88423005e-02f, 1.69487167e-02f, 5.18180095e-02f, 1.01583518e-01f, 1.71426143e-02f,
  -8.85770395e-02f, 6.23178184e-02f, 1.42513022e-01f, 6.87084161e-03f, -4.08798344e-02f, -4.70257141e-02f, 5.13628591e-03f, 7.60034919e-02f, 8.67594704e-02f, 2.60764994e-02f,
  2.43063495e-02f, -7.78601021e-02f, 5.34164459e-02f, 4.25691571e-04f, -1.56723604e-01f, -9.73440055e-03f, -9.44315940e-02f, -3.33963558e-02f, -6.28214106e-02f, -1.30347282e-01f,
  4.86130193e-02f, -1.16199516e-01f, 9.11630467e-02f, -1.13893464e-01f, -8.20960179e-02f, -3.57207209e-02f, 5.58693223e-02f, 1.15984660e-02f, 5.22056362e-04f, -6.90736845e-02f,
  -6.82655200e-02f, 5.12141995e-02f, -7.41753057e-02f, -1.29263461e-01f, 4.77358513e-02f, -1.17501402e-02f, -6.92881364e-03f, -8.40388387e-02f, -7.10421354e-02f, -1.32372513e-01f,
  -1.47498965e-01f, -6.43558577e-02f, 3.11125182e-02f, 4.31452319e-02f, -1.61882918e-02f, -3.40990610e-02f, -9.29563120e-02f, -1.04971882e-03f, -4.03432436e-02f, -8.70642290e-02f,
  6.26431853e-02f, 1.34679511e-01f, -4.58317101e-02f, -2.80342251e-02f, 1.10600166e-01f, 6.60527591e-03f, -6.01447299e-02f, -4.93329354e-02f, -1.75767355e-02f, -6.34241700e-02f,
  -6.94951275e-03f, 5.50820455e-02f, -4.82298806e-02f, 1.18122540e-01f, -5.66483997e-02f, 3.01932804e-02f, 2.47169696e-02f, -8.84570275e-03f, 2.64174696e-02f, 3.60788368e-02f,
  -4.43813540e-02f, 1.72355045e-02f, 2.80938558e-02f, 2.82643903e-02f, -1.55008622e-02f, -8.44543129e-02f, 3.66450846e-02f, 1.78299304e-02f, 4.61335033e-02f, -1.72406174e-02f,
  1.02070197e-01f, 8.48606303e-02f, 4.44774590e-02f, 8.18223730e-02f, 3.96932624e-02f, -7.14919865e-02f, 9.21512097e-02f, -9.70026851e-02f, -7.42571577e-02f, 2.17347033e-02f,
  -7.35735148e-03f, 7.37963058e-03f, -6.50400072e-02f, -6.25156388e-02f, 6.41099960e-02f, 8.48328471e-02f, -8.45092814e-03f, -2.32030135e-02f, 2.05939617e-02f, -8.50408599e-02f,
  -6.66824728e-02f, 1.40164942e-01f, 2.42544338e-01f, 1.45794019e-01f, 9.87074152e-03f, 2.37234935e-01f, 1.69116855e-01f, 4.90661040e-02f, 5.22308946e-02f, 1.61126554e-01f,
  -2.09581643e-01f, 1.64676994e-01f, -1.39079452e-01f, -2.59654611e-01f, -2.09365875e-01f, 3.34820971e-02f, 5.06702997e-02f, -1.28887668e-01f, -1.58946410e-01f, 9.46522281e-02f,
  1.20543860e-01f, -7.70554617e-02f, 3.78812253e-02f, -7.07819536e-02f, 7.39519596e-02f, 5.88040706e-03f, -6.82778358e-02f, -1.06897831e-01f, -1.65684178e-01f, -1.66907340e-01f,
  -1.16221517e-01f, -1.95436269e-01f, -1.45227760e-01f, -6.67945966e-02f, -1.11626573e-01f, -8.65126476e-02f, 3.17182057e-02f, -1.18772052e-01f, -5.44125959e-02f, 3.25646326e-02f,
  1.75218090e-01f, -3.69719975e-02f, -8.13121051e-02f, -5.13180122e-02f, 6.19325675e-02f, -5.50350435e-02f, -8.04588869e-02f, -3.89950089e-02f, -7.67544359e-02f, -6.65778806e-03f,
  -4.59316149e-02f, 6.19770437e-02f, -8.73606652e-02f, -2.35928260e-02f, -3.33970785e-02f, 2.72861980e-02f, 5.08910790e-02f, 1.33365160e-02f, 4.86717932e-02f, 2.10884260e-03f,
  1.37470469e-01f, -4.80371527e-02f, 1.15010984e-01f, 6.63789921e-04f, 5.39476909e-02f, 5.05946577e-03f, 9.52683091e-02f, -5.18183820e-02f, 1.00104306e-02f, 2.08814815e-02f,
  8.39181170e-02f, 5.59824035e-02f, 6.62451014e-02f, -7.35648498e-02f, -2.46208068e-02f, 5.01643233e-02f, 7.43847266e-02f, -1.01848901e-03f, -6.20321780e-02f, 5.98109402e-02f,
  3.62309851e-02f, 8.32391307e-02f, -2.29524039e-02f, 4.75689061e-02f, 8.20369571e-02f, -1.67857483e-02f, 1.30013004e-02f, 8.82769898e-02f, -5.34856282e-02f, -3.08839921e-02f,
  -4.03206125e-02f, 5.36223464e-02f, -9.79063660e-02f, -2.14515124e-02f, -5.06454296e-02f, 2.30291635e-02f, -5.30255623e-02f, -2.80912686e-02f, 2.74199098e-02f, 5.01738265e-02f,
  1.22218058e-01f, -3.06645762e-02f, -3.25584738e-03f, 3.05757727e-02f, -8.48618001e-02f, 9.35675800e-02f, -1.81198306e-03f, 4.52131499e-03f, 2.14467738e-02f, -1.68222860e-02f,
  -8.37348700e-02f, -4.10848148e-02f, 6.17342480e-02f, -4.98082228e-02f, -2.32342072e-02f, -9.76293441e-03f, 7.25981407e-03f, 5.46921492e-02f, 2.70845182e-02f, 6.83427006e-02f,
  6.40339702e-02f, 1.89042315e-02f, 1.90077662e-01f, 3.23321559e-02f, 5.63307945e-03f, -1.38486922e-03f, -1.24698074e-03f, 4.36263420e-02f, 9.62349698e-02f, 1.52040869e-01f,
  2.08056286e-01f, 8.89832973e-02f, 1.23002194e-01f, 3.30333300e-02f, -8.93237218e-02f, 3.21107521e-03f, 9.05573368e-03f, -6.86007813e-02f, 2.51118187e-02f, 4.18183878e-02f,
  -9.12584141e-02f, -3.26513387e-02f, 7.20824301e-02f, -5.98694608e-02f, 1.26798555e-01f, 3.02543771e-02f, 2.11968794e-02f, 8.66289139e-02f, 9.86647531e-02f, 8.68868008e-02f,
  -8.26672018e-02f, -5.89812435e-02f, 7.08058178e-02f, 3.45567539e-02f, 2.39515118e-02f, -1.15154423e-02f, -2.26084385e-02f, 8.27417821e-02f, 4.99880537e-02f, -1.73055287e-02f,
  -3.08956001e-02f, 1.55155867e-01f, 5.80564290e-02f, -4.32310589e-02f, -4.63095354e-03f, 1.24349639e-01f, -6.07787482e-02f, 7.06547052e-02f, 9.12456140e-02f, 4.12485600e-02f,
  6.05002940e-02f, 1.18704312e-01f, 7.26339072e-02f, 8.94802213e-02f, 5.00014238e-02f, 9.79212020e-03f, 9.55557376e-02f, 8.97994451e-03f, 2.09003109e-02f, 1.69958845e-02f,
  -8.72751921e-02f, 5.42644635e-02f, -7.60981021e-03f, -1.03990436e-02f, 6.65269569e-02f, -5.12495376e-02f, 2.07693260e-02f, 4.59566936e-02f, -4.75951433e-02f, 1.83329936e-02f,
  -5.05055040e-02f, 1.45499380e-02f, -2.21293811e-02f, -9.97038092e-03f, -4.34823930e-02f, -1.49445282e-03f, 3.06008663e-02f, 1.42403813e-02f, 9.12654698e-02f, -2.37350911e-02f,
  1.03241848e-02f, -3.00664306e-02f, -7.51497969e-02f, 8.22992772e-02f, -4.83272523e-02f, -3.34032662e-02f, 1.97622385e-02f, 1.17218094e-02f, 3.60604078e-02f, 9.88946706e-02f,
  -3.23502743e-03f, -1.66433528e-02f, -3.18325087e-02f, 7.70759284e-02f, -4.39097099e-02f, -9.40726884e-03f, -7.21374527e-02f, 2.69159842e-02f, -6.91949427e-02f, 1.80045255e-02f,
  -2.28172652e-02f, 1.23061694e-01f, -4.67577912e-02f, 1.29162548e-02f, -3.21645685e-03f, 9.65273231e-02f, 1.77296437e-03f, -5.48877753e-02f, -5.35119288e-02f, 4.26561832e-02f,
  -5.00830598e-02f, 3.93586606e-02f, -4.81075281e-03f, -2.49200221e-02f, 5.57598993e-02f, 7.73389405e-03f, -6.15767054e-02f, 6.17883094e-02f, -5.32369949e-02f, -6.96508512e-02f,
  -5.64473448e-04f, 3.25757414e-02f, -6.35470673e-02f, 3.28947790e-02f, 9.43166949e-03f, 4.33064327e-02f, -7.84478337e-02f, -9.78673100e-02f, 1.03614936e-02f, 2.39494201e-02f,
  4.28902805e-01f, 1.14170812e-01f, -6.19255751e-02f, 9.06574801e-02f, -6.74075261e-02f, -8.33294243e-02f, 1.34159796e-04f, -2.87175737e-02f, -4.94782533e-03f, 6.71783164e-02f,
  1.81891248e-01f, 1.32923350e-01f, 1.43823594e-01f, 1.16637059e-01f, 1.91724181e-01f, -6.70556203e-02f, -4.86268029e-02f, 2.71759387e-02f, 6.76823035e-02f, 8.85496661e-02f,
  1.36248767e-02f, -8.85623991e-02f, 2.80327443e-02f, 1.39028411e-02f, -1.29440725e-01f, 9.53886583e-02f, 3.01336218e-02f, -9.30235684e-02f, 3.40881385e-02f, -1.72070041e-02f,
  9.61404517e-02f, 1.46640792e-01f, -1.53251197e-02f, -3.91411223e-02f, -1.15116403e-01f, 8.05257633e-02f, 6.41609207e-02f, 4.48955931e-02f, -7.12650120e-02f, -4.81488928e-02f,
  2.84894444e-02f, -2.55732499e-02f, -1.50801027e-02f, 1.23891719e-02f, -1.04683064e-01f, -7.84121454e-02f, -5.63612916e-02f, 6.99942559e-02f, -1.79796806e-03f, 7.12169483e-02f,
  3.05555072e-02f, -4.00749408e-02f, -5.83862402e-02f, -3.49226035e-02f, 8.67504254e-03f, 1.78534910e-02f, -4.69825827e-02f, 2.69647855e-02f, 4.47035246e-02f, 5.49532175e-02f,
  3.19675989e-02f, 8.81583542e-02f, 1.23238266e-01f, -5.19617088e-02f, 1.06195182e-01f, -5.77845424e-02f, 3.79962251e-02f, 5.09291664e-02f, 3.64181725e-03f, 3.98715846e-02f,
  5.02924845e-02f, 2.14411318e-02f, 5.28936647e-02f, -2.00623386e-02f, 1.48370713e-02f, -4.67831548e-03f, 4.42582779e-02f, 1.57698803e-02f, 6.59196898e-02f, -5.27547598e-02f,
  2.33881697e-02f, 1.95914842e-02f, -5.94957732e-03f, -3.62917259e-02f, 1.86190698e-02f, -6.96287490e-03f, -5.85802794e-02f, -4.99358214e-02f, 3.99729535e-02f, -8.09056759e-02f,
  -1.19305305e-01f, 4.15631197e-02f, 9.19250548e-02f, 1.13574706e-01f, -1.17859747e-02f, 2.45362101e-03f, -1.84035450e-02f, -1.00577399e-01f, -4.22592908e-02f, -1.06367439e-01f,
  -6.28160313e-03f, 7.23118708e-02f, -2.01780945e-02f, -9.45212469e-02f, 7.22856214e-03f, -8.32439959e-02f, 4.89914082e-02f, -1.75103676e-02f, -6.37277067e-02f, -4.60104123e-02f,
  4.03624848e-02f, 1.12172365e-02f, 7.05103502e-02f, 1.88849568e-02f, -4.35396507e-02f, 1.19270369e-01f, -9.84340720e-03f, -3.40745933e-02f, 4.10249420e-02f, 3.11499797e-02f,
  1.40511826e-01f, -2.72622388e-02f, -1.67457517e-02f, 1.03061616e-01f, -4.64032963e-02f, -1.45986557e-01f, -1.75263152e-01f, -1.24734588e-01f, -6.13936521e-02f, 7.89720379e-03f,
  2.63801310e-02f, -1.34233078e-02f, -2.44294875e-03f, -4.54587154e-02f, -3.23376544e-02f, -8.88123959e-02f, 8.75807628e-02f, -4.25228253e-02f, -3.48063856e-02f, -8.73107165e-02f,
  -1.99594721e-02f, 9.01736468e-02f, 2.12796661e-03f, 1.10418662e-01f, 7.78217092e-02f, 4.22197953e-02f, 1.09060645e-01f, 1.14472456e-01f, 9.89714563e-02f, 2.15292513e-01f,
  1.50945231e-01f, 8.99234861e-02f, -1.31177157e-01f, -3.92991826e-02f, 4.57868353e-02f, 2.14236360e-02f, 1.21407844e-02f, -3.92049365e-02f, 1.09968558e-02f, -8.45980570e-02f,
  -6.10261597e-02f, -6.34186119e-02f, 5.46537922e-05f, -8.91117901e-02f, -1.10415012e-01f, -9.22738016e-02f, -1.11218415e-01f, -7.48994946e-02f, 1.95645373e-02f, 4.14044149e-02f,
  9.96700600e-02f, -6.08717948e-02f, -4.75327782e-02f, -1.14108128e-02f, -1.09116144e-01f, -3.50275896e-02f, 2.80628558e-02f, 1.88272330e-03f, -1.14386432e-01f, 7.23194405e-02f,
  4.25960161e-02f, 9.30497050e-02f, -4.31931876e-02f, -5.05974889e-02f, 4.88668904e-02f, 6.69401931e-03f, 9.01807938e-03f, 7.97503144e-02f, 2.89980788e-02f, -9.32916403e-02f,
  -3.24563235e-02f, 4.98591736e-02f, -8.34389683e-03f, -2.34016366e-02f, 2.38782424e-03f, 7.73043334e-02f, 8.25900435e-02f, 4.13016090e-03f, 3.23898606e-02f, 5.26996888e-02f,
  -5.13581978e-03f, -6.81574494e-02f, -2.28236392e-02f, 1.45856896e-02f, 8.48548580e-03f, 2.15754844e-02f, -1.48117775e-02f, -2.75652707e-02f, -6.24864213e-02f, 2.34665293e-02f,
  -2.84218583e-02f, -1.00122117e-01f, -4.24107444e-03f, -5.71525767e-02f, -6.98364526e-02f, -5.62859178e-02f, 3.89313586e-02f, 1.15430159e-02f, 1.99349504e-02f, 4.08927873e-02f,
  -1.03085823e-01f, 1.94154587e-02f, -1.03385106e-01f, 3.36283483e-02f, -5.10627851e-02f, -1.09134458e-01f, 2.05645692e-02f, 4.49481048e-02f, -7.11281300e-02f, 4.54729497e-02f,
  -6.46819919e-02f, -8.96299779e-02f, -1.00524902e-01f, -1.70660287e-01f, 5.41430563e-02f, -9.30021480e-02f, -1.59252658e-01f, -1.21067993e-01f, -2.20610559e-01f, -1.76660255e-01f,
  -2.01182023e-01f, 9.71785933e-03f, 7.72753730e-03f, -1.72214396e-02f, -3.86439003e-02f, -1.49793213e-03f, -4.67170589e-02f, -2.78829169e-02f, 5.23270927e-02f, -4.08923179e-02f,
  6.75459057e-02f, -8.08227900e-03f, -4.01555486e-02f, -2.91796681e-02f, 6.02058321e-02f, 2.63740681e-02f, 4.47968915e-02f, 4.46972623e-02f, -6.17332608e-02f, -4.20293249e-02f,
  7.88342133e-02f, -3.16314176e-02f, -6.40380085e-02f, -1.77472904e-02f, 1.13608316e-01f, 4.31335112e-03f, -7.42877722e-02f, -7.88706075e-03f, 1.06065959e-01f, -1.49147278e-02f,
  -1.26302168e-01f, -1.37178078e-01f, 9.73062217e-02f, 9.54832062e-02f, 5.12793213e-02f, 2.76070703e-02f, -9.05497968e-02f, 4.36060131e-02f, 5.32846190e-02f, -1.77131817e-02f,
  1.35943238e-02f, -1.82904582e-02f, 2.09339280e-02f, -6.18301332e-02f, -1.08917832e-01f, -5.55772707e-02f, -8.11594725e-02f, 3.04898638e-02f, -4.62429263e-02f, 3.95444557e-02f,
  -4.81905080e-02f, -2.84861047e-02f, -3.99910286e-02f, -1.08445793e-01f, -4.62427810e-02f, -4.06891964e-02f, 3.50078493e-02f, -7.09957480e-02f, -1.17393903e-01f, -1.39450118e-01f,
  -2.11987682e-02f, -8.35035294e-02f, -3.01053561e-02f, -2.07003318e-02f, 8.83335993e-02f, -2.11390313e-02f, 1.81560814e-02f, 9.39456299e-02f, -7.05467165e-02f, -5.05844951e-02f,
  -4.18498367e-02f, 2.82048807e-02f, -6.68688789e-02f, -2.66066082e-02f, 4.34675254e-02f, 2.41813809e-02f, 5.48791438e-02f, 8.66211057e-02f, 4.21704054e-02f, -1.56446286e-02f,
  -6.05144016e-02f, 5.18838130e-02f, 9.60827619e-02f, 4.65008058e-02f, 9.10573751e-02f, -6.43225387e-03f, -6.36716560e-02f, -7.70775974e-02f, 1.83692556e-02f, -5.15091345e-02f,
  -1.14720806e-01f, 8.55926573e-02f, 3.60818915e-02f, 3.64773981e-02f, -4.93738167e-02f, 8.11766461e-02f, -5.99825615e-03f, -3.88571955e-02f, -6.97534308e-02f, 4.96970788e-02f,
  -3.23444884e-03f, -2.30368394e-02f, -1.02290675e-01f, -5.57973348e-02f, 2.47957930e-02f, 3.07869688e-02f, -6.23690896e-02f, -4.77149449e-02f, -7.75585920e-02f, 5.74047416e-02f,
  -7.09270984e-02f, -2.07131822e-02f, -1.42081767e-01f, -1.34529501e-01f, 1.11864265e-02f, -1.13465607e-01f, -8.60670358e-02f, -3.63933034e-02f, -1.26834944e-01f, -9.55168977e-02f,
  -3.29795390e-01f, 1.12417117e-01f, 5.10542728e-02f, -1.84244573e-01f, -5.99527471e-02f, 2.05861181e-01f, 1.69993803e-01f, -6.96666539e-02f, -1.71753630e-01f, 3.78236435e-02f,
  -1.93195380e-02f, -1.35830358e-01f, -1.47048920e-01f, 6.47856519e-02f, 6.66751191e-02f, 1.51058882e-01f, 3.21643166e-02f, -7.56078139e-02f, -7.88561068e-03f, 1.08874561e-02f,
  -1.05537707e-02f, -1.21757723e-01f, -8.67295489e-02f, -2.97375862e-02f, -1.38919234e-01f, -1.00713685e-01f, -7.13938326e-02f, -7.98923075e-02f, 2.43777093e-02f, -1.10411115e-01f,
  -4.10291329e-02f, -9.28968471e-03f, 7.12780934e-03f, -6.09389730e-02f, 4.74602096e-02f, -6.83216751e-02f, 1.52810263e-02f, -2.58272253e-02f, -9.21778455e-02f, 8.53766594e-03f,
  -5.78899868e-02f, -3.68645713e-02f, -1.71631481e-02f, 4.24029194e-02f, -6.11671582e-02f, -7.14567229e-02f, -2.58043129e-02f, -4.84524183e-02f, 9.69728306e-02f, 1.26782730e-01f,
  9.84369591e-02f, 1.07108429e-01f, -1.82934385e-02f, 1.18028872e-01f, 2.15102509e-02f, -4.08949098e-03f, -4.02781852e-02f, -5.54391742e-02f, 9.16994736e-02f, -1.43271461e-01f,
  8.57908353e-02f, -4.22358140e-02f, -4.69843000e-02f, -8.78556296e-02f, -9.63306893e-03f, 4.06834483e-02f, -7.48356506e-02f, 2.50942390e-02f, -4.39395793e-02f, 2.91269943e-02f,
  3.14951353e-02f, 1.04374103e-01f, -9.90449730e-03f, 1.29486537e-02f, -1.98047888e-02f, -6.09110445e-02f, 7.48940706e-02f, 5.62676266e-02f, -6.89676777e-02f, 1.16459075e-02f,
  7.13132173e-02f, -5.77686690e-02f, -5.81466556e-02f, 7.29368329e-02f, 8.59747678e-02f, 3.67778316e-02f, 5.59308790e-02f, 6.18256852e-02f, -4.17470485e-02f, -3.22953761e-02f,
  -2.89930671e-01f, 2.19027802e-01f, -1.07644625e-01f, -5.27427122e-02f, -1.07478775e-01f, -2.18149442e-02f, 4.32221256e-02f, 4.81420495e-02f, 7.03619514e-03f, -3.05314772e-02f,
  1.89727289e-04f, -2.31178645e-02f, -4.28484231e-02f, 7.06779957e-02f, 5.49363941e-02f, 2.75656115e-02f, 5.53425103e-02f, -7.98570290e-02f, 6.06205501e-02f, 5.05403690e-02f,
  5.11220507e-02f, 2.69918386e-02f, -4.28980254e-02f, -4.51181419e-02f, -5.58968782e-02f, 4.83221412e-02f, -8.89270753e-02f, -3.63939931e-03f, 1.01996884e-01f, -1.18993156e-01f,
  -2.65355498e-01f, -9.99876857e-02f, -3.14421654e-01f, -1.13997124e-02f, 4.94829081e-02f, 5.40030375e-02f, 1.20882206e-01f, 1.04389377e-01f, 3.99933383e-02f, -9.28296149e-02f,
  1.54782403e-02f, -1.61990197e-03f, -2.67127845e-02f, 5.34148850e-02f, 1.20725013e-01f, -4.14045379e-02f, 2.10027434e-02f, -8.56443075e-04f, 3.35696638e-02f, 1.34270519e-01f,
  2.19223365e-01f, 5.08361943e-02f, -8.12907144e-02f, -6.03415817e-03f, 6.79513887e-02f, 4.93794680e-02f, -1.57469988e-01f, -6.50518686e-02f, 2.50378121e-02f, -5.91515042e-02f,
  -2.42388204e-01f, -1.88188016e-01f, -2.92424485e-02f, 1.01111606e-01f, -5.08738309e-02f, 1.30404457e-02f, -2.30383053e-02f, -1.01802409e-01f, -1.20027736e-02f, -5.09703718e-02f,
  2.55440008e-02f, -7.53198564e-02f, 7.08407164e-02f, 9.45795104e-02f, -7.78382346e-02f, 4.83785607e-02f, -5.33569790e-02f, -4.37027663e-02f, -1.20565780e-01f, -7.22178891e-02f,
  1.09760568e-01f, -8.36543813e-02f, -1.65919736e-01f, -8.97909552e-02f, -3.50936688e-02f, -8.81982893e-02f, -8.58033895e-02f, -6.89987317e-02f, -1.04160160e-01f, -1.93536207e-01f,
  1.44316712e-02f, -1.93122216e-02f, -3.23316120e-02f, 3.78992334e-02f, -5.03009781e-02f, -9.84890014e-02f, 8.59375522e-02f, 1.03507526e-01f, 9.00537521e-02f, 1.87722165e-02f,
  -1.47679029e-02f, -3.58036384e-02f, 5.03038876e-02f, -1.09050892e-01f, 3.90418135e-02f, -4.69710343e-02f, -3.10881510e-02f, 7.87202045e-02f, -3.06515880e-02f, 5.62948845e-02f,
  -3.64501663e-02f, -5.23897335e-02f, -4.81099114e-02f, -3.31866667e-02f, 1.21369790e-02f, -4.54899631e-02f, 6.58440068e-02f, 5.17673939e-02f, -5.28163798e-02f, 7.69120548e-03f,
  -9.22977626e-02f, -5.55105358e-02f, 1.01602804e-02f, -3.92121822e-02f, 6.95532113e-02f, -1.55901341e-02f, 1.41551727e-02f, -1.06379636e-01f, 9.64386389e-03f, 1.03922340e-03f,
  9.70001221e-02f, -2.04516649e-02f, -9.99722108e-02f, 8.01392943e-02f, -1.50424857e-02f, 9.29835252e-03f, 2.91027520e-02f, -7.04164803e-02f, -5.86411208e-02f, -5.84727386e-03f,
  -9.31701735e-02f, 6.52347039e-03f, -9.28971916e-02f, 6.41155802e-03f, 5.27677126e-03f, 2.28632353e-02f, -1.08102299e-01f, -1.12688728e-01f, -1.26778260e-01f, -1.44976318e-01f,
  3.15880068e-02f, -1.17676042e-01f, -2.10582223e-02f, -1.65850475e-01f, 5.27943596e-02f, 6.27927333e-02f, 9.16398540e-02f, 8.39626715e-02f, 4.18926626e-02f, -5.84298708e-02f,
  -3.24919187e-02f, -1.79412495e-02f, 1.62288118e-02f, -1.20962754e-01f, -3.84782143e-02f, -1.85566004e-02f, -1.06183346e-02f, -7.04206899e-02f, 1.08815499e-01f, 1.16710982e-03f,
  3.50688584e-02f, 3.80527265e-02f, -9.64575559e-02f, -1.08898774e-01f, -1.21821992e-01f, -9.17693228e-02f, -1.37034759e-01f, -1.34416863e-01f, 3.01384237e-02f, -1.11576580e-01f,
  2.46331166e-03f, -1.38615668e-02f, 3.80163677e-02f, -1.51902705e-03f, -3.68184894e-02f, -6.47901818e-02f, 7.93741271e-02f, 1.89471953e-02f, 6.94449022e-02f, 9.43305716e-02f,
  -2.89968979e-02f, 5.64942993e-02f, 3.54887508e-02f, 2.36879266e-03f, -2.38641221e-02f, -6.66299239e-02f, 2.31990833e-02f, -1.76633708e-02f, -1.08241566e-01f, -2.90601682e-02f,
  7.06248358e-02f, -1.34155694e-02f, 3.36433761e-02f, 7.96956047e-02f, 4.03288901e-02f, -8.56254026e-02f, 4.61101569e-02f, 1.66445095e-02f, -2.05917992e-02f, 4.61877659e-02f,
  -5.38751557e-02f, -6.52509257e-02f, 6.87071681e-02f, 8.81459936e-02f, 9.43519697e-02f, 8.02052990e-02f, 7.68860653e-02f, 4.03615274e-02f, 1.12932116e-01f, -5.60557209e-02f,
  -4.69531827e-02f, 4.93673496e-02f, -8.75107870e-02f, 5.24467267e-02f, 2.92751603e-02f, -3.53179947e-02f, -7.57390633e-02f, 4.73675393e-02f, 9.46998131e-03f, -1.03176765e-01f,
  -7.22225159e-02f, -4.79511917e-03f, -7.58941844e-03f, 8.83395299e-02f, -9.61443484e-02f, -4.44367938e-02f, -7.11816996e-02f, -1.16112968e-02f, -1.59878898e-02f, -2.49056760e-02f,
  1.02638334e-01f, 2.51234695e-02f, 3.47537547e-02f, -1.18648879e-01f, -1.25202730e-01f, 7.43160769e-02f, -8.27307031e-02f, 1.82302520e-02f, 8.31187889e-03f, -3.62640955e-02f,
  4.57198247e-02f, 6.84302226e-02f, 4.64695394e-02f, 3.55798006e-02f, 8.38867724e-02f, 3.14600021e-02f, 6.44949973e-02f, 1.99889205e-02f, -1.03672490e-01f, 2.48341579e-02f,
  -5.07958904e-02f, 3.79244387e-02f, -5.21281660e-02f, 8.38508457e-02f, 1.40597085e-02f, -1.80573727e-03f, 5.00523811e-03f, -1.15838470e-02f, 6.71893498e-03f, 1.59427986e-01f,
  -5.67187294e-02f, 6.59116209e-02f, 1.37348920e-01f, -9.91237164e-03f, -1.28643721e-01f, -3.04808151e-02f, 4.62319888e-02f, -5.13347164e-02f, 5.89055009e-02f, -4.64801416e-02f,
  -1.19558983e-01f, -1.38791159e-01f, 2.60392693e-03f, 7.72285908e-02f, -3.58507894e-02f, 3.79838906e-02f, -1.05477208e-02f, 2.30602641e-02f, -3.47393788e-02f, -6.09783642e-02f,
  -5.92224412e-02f, -8.10695589e-02f, 3.50714438e-02f, 4.29673046e-02f, -5.52619845e-02f, -2.74208616e-02f, 7.50391856e-02f, -4.55546714e-02f, 5.83248027e-03f, 9.84353200e-02f,
  9.61633623e-02f, -7.40284026e-02f, 2.68694274e-02f, -7.35843033e-02f, 1.37672238e-02f, -3.24711343e-03f, -4.65618484e-02f, -4.18708324e-02f, -6.30734414e-02f, 3.71272601e-02f,
  -2.13108701e-03f, -6.32093800e-03f, -3.21455672e-02f, -1.29733812e-02f, -5.58013022e-02f, 7.55297318e-02f, 1.01326689e-01f, -4.91305105e-02f, 1.05147354e-01f, 1.00292213e-01f,
  -9.17216018e-02f, -7.33212158e-02f, -6.90247715e-02f, -2.31904909e-02f, 9.46402252e-02f, 3.97485644e-02f, 1.10104583e-01f, 1.12650648e-01f, 4.68233414e-02f, 8.09252262e-02f,
  1.43259959e-02f, 4.94762287e-02f, 2.10198946e-02f, 1.77911781e-02f, -1.23683875e-02f, 6.97176233e-02f, 3.19902673e-02f, -6.09901510e-02f, -5.57435825e-02f, -9.23445597e-02f,
  -3.61848366e-03f, -2.72351466e-02f, 4.49664630e-02f, 2.98467651e-02f, 2.90573537e-02f, 3.39906365e-02f, -6.32630438e-02f, -6.87756911e-02f, 3.91433761e-02f, 5.10725714e-02f,
  -7.97377676e-02f, 5.39065599e-02f, 1.02376882e-02f, -4.22442034e-02f, 5.41425236e-02f, -3.41158807e-02f, -1.00344811e-02f, -5.54567650e-02f, 9.65617523e-02f, -6.05904646e-02f,
  -5.91196939e-02f, -5.79974093e-02f, 5.67811504e-02f, 5.42500950e-02f, -3.26614305e-02f, 2.56160405e-02f, 2.45081726e-02f, 3.80908884e-02f, -7.66663700e-02f, -8.31218287e-02f,
  -8.68342370e-02f, -2.87708342e-02f, -9.15985480e-02f, 4.49292101e-02f, 3.68114188e-03f, 1.73678882e-02f, -2.59114094e-02f, 3.59594338e-02f, -5.78339659e-02f, 5.87014556e-02f,
  1.62379686e-02f, -9.80555788e-02f, -5.24081290e-02f, 1.02920423e-03f, 4.63309102e-02f, -1.13614365e-01f, -3.33994925e-02f, -6.24945872e-02f, -6.07504807e-02f, -1.15379049e-02f,
  7.02732876e-02f, -2.83500999e-02f, 1.64481163e-01f, -4.13652218e-04f, -3.81605290e-02f, 3.43656875e-02f, -1.08848587e-01f, -9.34931561e-02f, 1.75065622e-02f, -9.98017713e-02f,
  3.03140432e-02f, -4.13443781e-02f, -1.32591929e-02f, -7.94001222e-02f, -1.17824869e-02f, 3.72343399e-02f, -1.44688413e-02f, 6.29800186e-02f, 2.50332244e-02f, -7.34211802e-02f,
  -1.07732125e-01f, -2.99665555e-02f, -2.87788454e-02f, -8.19009729e-03f, 6.07069731e-02f, 4.61724028e-02f, 4.85756770e-02f, 1.19445071e-01f, -3.63026932e-02f, 1.39069408e-01f,
  5.54709369e-03f, 7.92244151e-02f, -1.26236677e-02f, 7.93787092e-03f, -2.56679039e-02f, -2.06341501e-02f, -6.44542053e-02f, -2.02890579e-02f, -2.97814738e-02f, -3.64212245e-02f,
  -1.70535520e-02f, -1.07983146e-02f, -6.81280941e-02f, -9.36030503e-03f, -5.46258889e-05f, -8.64914954e-02f, 3.95263061e-02f, 2.35582665e-02f, 3.58620472e-02f, 7.65718669e-02f,
  -1.10289663e-01f, 4.78331633e-02f, -1.05204796e-02f, -9.04754698e-02f, 5.56558520e-02f, 1.68521553e-02f, -1.51993977e-02f, -1.24012502e-02f, -3.02416291e-02f, 7.75050670e-02f,
  -4.34054546e-02f, -7.39426240e-02f, -1.74941570e-02f, -9.91546661e-02f, 3.27326246e-02f, -6.37170672e-02f, 7.20008910e-02f, -5.74015640e-02f, -9.40124989e-02f, -7.37957582e-02f,
  7.02656433e-02f, 6.10561036e-02f, -1.13819353e-03f, -1.10914260e-02f, 3.22480947e-02f, -1.98379699e-02f, -6.89075217e-02f, -1.27978390e-02f, 1.78770926e-02f, -2.03333180e-02f,
  -7.86269382e-02f, 2.42905449e-02f, -6.31610770e-03f, -7.46362656e-02f, 6.86891526e-02f, 1.22484127e-02f, -3.25224437e-02f, 2.22981926e-02f, 6.11239299e-02f, -5.98497428e-02f,
  -1.05694383e-01f, -1.58509910e-01f, 3.59636396e-02f, -8.67819116e-02f, 6.05710037e-02f, 8.56059119e-02f, 1.61727872e-02f, -5.07697351e-02f, -5.42966910e-02f, 3.63577679e-02f,
  6.45214990e-02f, 1.18858814e-02f, 4.69232798e-02f, -5.39322384e-03f, -3.07435934e-02f, -4.52290010e-03f, -2.06194166e-02f, 2.63940375e-02f, 2.62961499e-02f, -3.90933221e-03f,
  -2.60037314e-02f, 2.16253884e-02f, -1.24578498e-01f, 2.54301503e-02f, 7.15622380e-02f, -1.09934688e-01f, -9.27396715e-02f, -1.87591240e-02f, 1.15212891e-02f, 2.60924567e-02f,
  -5.79060987e-02f, 8.88652131e-02f, -2.15651542e-02f, -5.13866171e-02f, 1.26270667e-01f, 1.08171314e-01f, 2.01588139e-01f, 8.57001394e-02f, -6.36611730e-02f, 1.24569805e-02f,
  -5.40808542e-03f, 3.14054801e-03f, -9.47616622e-03f, -1.76756550e-02f, -6.62420765e-02f, 7.63484910e-02f, -2.74315216e-02f, -8.51996243e-02f, -1.65061411e-02f, 3.33814546e-02f,
  5.67209683e-02f, 6.15593009e-02f, -1.21466450e-01f, -1.58653688e-02f, -3.96260666e-03f, 9.36395582e-03f, -7.77314603e-02f, -6.96814656e-02f, 1.16309933e-02f, -5.28819151e-02f,
  -1.04115736e-02f, 1.22960337e-01f, -6.09768778e-02f, 5.74811250e-02f, 8.38882774e-02f, 2.34680176e-02f, 6.67855889e-02f, -1.02252305e-01f, -1.53504321e-02f, -9.85570848e-02f,
  4.24446426e-02f, -8.70981440e-02f, -7.88838789e-02f, -1.34294815e-02f, -5.85627481e-02f, -3.28266397e-02f, -4.30120863e-02f, 3.68522890e-02f, 1.66784525e-02f, -8.10259953e-02f,
  1.00883879e-01f, -2.17795111e-02f, -7.02758059e-02f, -2.71892287e-02f, -5.07760607e-02f, -9.73534957e-02f, -3.92201319e-02f, 2.78970972e-02f, 5.56634851e-02f, -1.05593294e-01f,
  4.36567068e-02f, 9.59427003e-03f, 7.10547194e-02f, 4.42664558e-03f, 3.91540863e-02f, 2.95897443e-02f, 3.30128409e-02f, -4.51826751e-02f, -1.83273237e-02f, 4.31698225e-02f,
  -8.25338364e-02f, 1.63857694e-04f, 7.07418472e-02f, -8.06422532e-02f, -7.16041848e-02f, 2.07108557e-02f, 4.96606976e-02f, 2.76573543e-02f, -4.39997539e-02f, -5.23545742e-02f,
  -8.04603621e-02f, -5.10557964e-02f, -3.24702747e-02f, 1.20676104e-02f, -7.88078271e-03f, -5.88251352e-02f, 4.72399667e-02f, -6.56450121e-03f, -1.19085722e-02f, -3.29135023e-02f,
  -2.03823790e-01f, -3.70353251e-03f, -1.29559217e-02f, -6.96431175e-02f, -1.75068323e-02f, 3.54332924e-02f, 1.76761262e-02f, -1.99467167e-02f, 6.65411130e-02f, -2.81078890e-02f,
  -4.91850451e-02f, 1.23294210e-02f, 4.86530662e-02f, 8.36230665e-02f, 6.90739304e-02f, 1.61647741e-02f, 5.68213724e-02f, 5.35059534e-02f, -4.96283993e-02f, 7.52400756e-02f,
  -3.58074419e-02f, -2.39657126e-02f, -1.37069359e-01f, 4.94743735e-02f, 1.28674302e-02f, -7.87028447e-02f, -1.22087367e-01f, -5.84626608e-02f, -1.02242768e-01f, -1.48842216e-01f,
  2.71347433e-01f, 1.32486627e-01f, -2.72607148e-01f, 3.55529375e-02f, -1.88434035e-01f, -2.09598303e-01f, -1.01509176e-01f, -4.05173488e-02f, 3.88515182e-02f, 4.29147147e-02f,
  -6.06608912e-02f, 2.85943821e-02f, -8.69057551e-02f, -7.10666627e-02f, 5.90798259e-02f, -1.37503803e-01f, -1.36069238e-01f, -1.68133989e-01f, -1.63980201e-01f, -6.62819967e-02f,
  2.03599613e-02f, 7.43082687e-02f, -1.81127097e-02f, -2.08722893e-02f, -7.15944767e-02f, 2.75170058e-02f, -1.42763585e-01f, -7.97457695e-02f, -7.87731707e-02f, -7.39504024e-03f,
  -2.49093994e-01f, 1.20343640e-02f, 1.61998998e-02f, 5.51215112e-02f, -1.35094263e-02f, 1.07333437e-01f, -3.60211916e-02f, 6.63919002e-02f, 1.31866131e-02f, 7.53936172e-02f,
  4.86460002e-03f, 4.06941697e-02f, 4.73545827e-02f, -1.07511893e-01f, -2.22300831e-02f, -2.79073976e-02f, -9.21940431e-04f, 9.91095304e-02f, 1.04012657e-02f, -4.27685156e-02f,
  -7.01295286e-02f, -4.21045087e-02f, -6.12198524e-02f, -5.91192134e-02f, -2.19717044e-02f, 6.05213456e-02f, -2.85759056e-03f, -8.94257054e-02f, -8.27111453e-02f, 1.08537130e-01f,
  -9.35063511e-02f, -4.66473475e-02f, -2.86635454e-03f, 4.35294919e-02f, -2.25399379e-02f, 3.24102119e-02f, 1.92043725e-02f, 2.77193580e-02f, -7.31457071e-03f, -1.77606251e-02f,
  -3.27672400e-02f, 5.15351072e-02f, -7.11382851e-02f, 3.09235193e-02f, 3.19420733e-02f, 6.12233113e-03f, 3.46997455e-02f, 7.49178529e-02f, -7.02006146e-02f, -4.72211242e-02f,
  5.97529160e-03f, -2.74730064e-02f, 3.31822522e-02f, 6.76331669e-02f, -1.13500319e-01f, -5.14892451e-02f, -6.24195673e-02f, 6.99686185e-02f, -3.97800244e-02f, -9.44102928e-02f,
  8.23505670e-02f, -9.48759094e-02f, 5.80665097e-02f, 1.19508639e-01f, -9.69007388e-02f, -3.87391336e-02f, 3.21243405e-02f, -1.87909380e-02f, -2.02011201e-03f, -8.60181600e-02f,
  8.91787745e-03f, -3.28504629e-02f, -4.46523316e-02f, -4.46743742e-02f, 1.07631668e-01f, 2.23906357e-02f, 1.40377581e-01f, -4.60951850e-02f, 5.38372509e-02f, 6.39030896e-03f,
  1.44298926e-01f, 1.71842963e-01f, 1.31158680e-01f, 1.30917132e-01f, 4.91734110e-02f, -1.48671223e-02f, 2.21085940e-02f, -4.83771600e-02f, 4.93452772e-02f, 2.30113074e-01f,
  1.03362620e-01f, -1.18135564e-01f, -1.36506349e-01f, -1.68478385e-01f, -1.61357462e-01f, -1.59000102e-02f, -1.30846143e-01f, -1.47861421e-01f, -7.38686100e-02f, -1.07767433e-01f,
  -3.74997631e-02f, 1.15761213e-01f, 1.44907132e-01f, 1.65152773e-01f, 1.53811619e-01f, -1.73242986e-01f, -9.18477327e-02f, 1.10453308e-01f, 8.03568363e-02f, 9.02083516e-02f,
  -6.26669601e-02f, 8.02682713e-03f, 3.85219306e-02f, -4.52649295e-02f, -7.41123632e-02f, 7.19359443e-02f, -6.28844276e-02f, -8.43049660e-02f, -1.10989891e-01f, -6.23322912e-02f,
  1.32556900e-01f, 6.21497259e-02f, 7.59756342e-02f, 1.27173364e-01f, 4.94218022e-02f, -4.43489440e-02f, -1.61850564e-02f, 1.86076779e-02f, -2.92105554e-03f, -8.58837813e-02f,
  5.22485226e-02f, 7.73171410e-02f, 3.19673754e-02f, -1.29052401e-02f, -1.15886681e-01f, -3.96154784e-02f, -4.89325486e-02f, -3.16155255e-02f, 1.03784688e-02f, -9.45595000e-03f,
  3.81331891e-02f, -5.13859652e-02f, 3.76828015e-03f, 1.06878504e-02f, -7.48723745e-02f, 1.04746193e-01f, 1.16372937e-02f, -2.01192126e-02f, -6.75733835e-02f, -9.60715562e-02f,
  1.10551072e-02f, 7.38761649e-02f, -6.98821694e-02f, 5.17501310e-02f, -3.25812176e-02f, 4.12567891e-02f, 4.36257347e-02f, -1.27828484e-02f, -5.11387102e-02f, -4.79304157e-02f,
  4.25304174e-02f, -5.80392964e-02f, -1.32870916e-02f, 4.43837605e-02f, 8.24284852e-02f, 6.03498071e-02f, -5.31652719e-02f, -2.90278662e-02f, -2.28159409e-02f, 8.66958033e-03f,
  1.10451385e-01f, -1.65945590e-02f, 3.99082266e-02f, -3.30162272e-02f, -2.88051125e-02f, -1.73299052e-02f, -6.31923368e-03f, -2.97880899e-02f, 6.08741492e-02f, -9.10413787e-02f,
  8.76200795e-02f, 1.66140601e-01f, 4.22531813e-02f, 3.31731625e-02f, -7.75031373e-02f, -1.46916760e-02f, -2.40556542e-02f, 4.68137786e-02f, -3.56119801e-03f, -7.00052008e-02f,
  -1.69376209e-02f, -1.27578834e-02f, 9.45439190e-02f, -6.04601204e-02f, 4.63957526e-02f, -1.88554022e-02f, 2.88309604e-02f, 1.11063562e-01f, 7.51917884e-02f, -1.45481244e-01f,
  -1.35387361e-01f, 7.13172108e-02f, 1.76548004e-01f, -4.57313135e-02f, 8.02116171e-02f, 1.75123110e-01f, 2.02513132e-02f, -6.22606166e-02f, 1.49509683e-01f, -2.81195948e-03f,
  -2.44292393e-02f, -2.94891763e-02f, 2.87298020e-02f, -1.79439678e-03f, 4.80224043e-02f, 1.18723050e-01f, 8.43311325e-02f, -7.92706534e-02f, -9.88139957e-02f, 6.30566329e-02f,
  -7.88033828e-02f, -1.28400326e-02f, -1.13784149e-01f, 8.96144379e-03f, -1.42004520e-01f, 7.49024451e-02f, -1.08426651e-02f, -9.43710506e-02f, -4.45857011e-02f, -6.48005400e-04f,
  -1.06734820e-01f, -7.29454458e-02f, -1.36899859e-01f, -5.45618944e-02f, 7.54587650e-02f, 7.05287755e-02f, 1.06410772e-01f, 4.11177315e-02f, 8.43626112e-02f, 8.08170810e-02f,
  8.47900733e-02f, -8.64335299e-02f, 5.69872372e-02f, -8.90146941e-02f, -5.56025803e-02f, -4.08862345e-02f, 7.47905821e-02f, 2.40098704e-02f, -5.92524782e-02f, -4.68114652e-02f,
  -1.04942266e-02f, 6.93812594e-02f, -3.22984420e-02f, -3.48324589e-02f, 7.60255456e-02f, -5.49235232e-02f, -7.23316744e-02f, -1.18551552e-01f, 7.28264526e-02f, -2.18762066e-02f,
  6.64106309e-02f, -3.92217226e-02f, 2.82689296e-02f, -9.84430127e-03f, -8.04914832e-02f, 8.62228274e-02f, 8.78738835e-02f, -5.44253737e-02f, -2.51868665e-02f, 7.75799826e-02f,
  -3.50338705e-02f, -5.40721528e-02f, -7.75713027e-02f, 5.16961664e-02f, 3.11952252e-02f, 3.66609469e-02f, 9.94017646e-02f, 6.75113499e-02f, 3.85802165e-02f, 4.34752837e-05f,
  8.24435651e-02f, 1.87303443e-02f, -6.17345385e-02f, 5.84920309e-02f, -5.82382530e-02f, -8.87698457e-02f, 7.90164154e-03f, -7.89470822e-02f, -1.62845198e-02f, -1.26516353e-02f,
  -2.11226381e-02f, 7.54206702e-02f, 5.54800555e-02f, 4.91416864e-02f, 6.74078614e-02f, 8.73263702e-02f, 1.09069133e-02f, -2.36532800e-02f, -2.18179617e-02f, 2.65912339e-02f,
  6.54935092e-02f, -4.79751453e-02f, 1.89763047e-02f, -3.44250761e-02f, 7.75494352e-02f, 3.69064994e-02f, -1.82069503e-02f, 3.86315510e-02f, -6.71169683e-02f, -3.42326127e-02f,
  4.67162468e-02f, 6.74652383e-02f, -5.27858958e-02f, 9.80592817e-02f, -2.31454019e-02f, -2.75926422e-02f, 4.16012406e-02f, 5.61972037e-02f, 7.29616685e-03f, -5.27651757e-02f,
  5.70466183e-02f, 8.27019364e-02f, 4.80022021e-02f, -8.62501748e-03f, 1.01793893e-01f, 8.43747705e-03f, 1.26249967e-02f, 1.37906805e-01f, 9.91796702e-02f, 3.70907597e-02f,
  -7.74873793e-02f, -6.73630312e-02f, 5.74973226e-02f, -1.50630072e-01f, -7.56356344e-02f, -1.20849773e-01f, -1.34258613e-01f, -1.14070274e-01f, -5.18060103e-02f, -1.18997462e-01f,
  -5.40719666e-02f, 6.50810003e-02f, 9.52995867e-02f, 1.28051624e-01f, 3.50118205e-02f, -1.50454259e-02f, 4.99260388e-02f, 2.05542538e-02f, 9.67738479e-02f, -1.16017491e-01f,
  4.16448253e-04f, -5.78779057e-02f, 5.87269403e-02f, -6.18498512e-02f, -7.88742602e-02f, 4.99747247e-02f, -2.82371715e-02f, -5.67990495e-03f, 2.95726862e-02f, -1.41000181e-01f,
  -5.04756384e-02f, -9.60500166e-02f, 5.98900691e-02f, 7.77711645e-02f, -4.76333983e-02f, 3.46243684e-03f, 5.51997833e-02f, 7.21692219e-02f, 7.81014338e-02f, -2.48224828e-02f,
  -1.08027719e-01f, -1.54614691e-02f, 1.92632321e-02f, 4.27029654e-02f, -8.21935162e-02f, 1.00529660e-02f, -3.87999020e-03f, -7.14033656e-03f, -2.19038855e-02f, -2.09420472e-02f,
  -7.53806829e-02f, -3.40654366e-02f, -3.54608372e-02f, 2.23432109e-02f, -8.33040923e-02f, -1.10501572e-02f, -4.46596183e-02f, -1.09078929e-01f, -3.11112162e-02f, 1.18390843e-02f,
  -4.97535653e-02f, 8.00713059e-03f, 2.87933648e-02f, -2.47270335e-02f, -4.34500985e-02f, 8.09069665e-04f, 3.64954881e-02f, 1.50711527e-02f, -7.46329129e-03f, -7.33100176e-02f,
  2.21119057e-02f, -2.21321750e-02f, 7.57605433e-02f, -6.27461448e-02f, -4.40009795e-02f, -2.82971431e-02f, -6.87324032e-02f, 1.18131721e-02f, -6.92523718e-02f, 9.61093009e-02f,
  -8.58740043e-03f, 1.65619534e-02f, 3.51589918e-02f, -4.23516817e-02f, 8.39694664e-02f, 7.04068393e-02f, -6.29309937e-02f, 9.54570100e-02f, -4.08891067e-02f, 1.06056789e-02f,
  -1.50743201e-01f, 1.32143304e-01f, -6.37022853e-02f, 4.21805419e-02f, -1.41706943e-04f, -5.80108538e-03f, -6.27526492e-02f, 1.91841330e-02f, -6.84465617e-02f, -3.23309959e-03f,
  2.51532365e-02f, 2.52593569e-02f, 3.79669257e-02f, 6.36944026e-02f, -4.61149449e-03f, -4.40926701e-02f, 6.03715715e-04f, 1.70220714e-02f, -5.23180552e-02f, -2.51284633e-02f,
  -3.67529020e-02f, 2.11587790e-02f, 3.95389609e-02f, 6.57860786e-02f, 1.44716846e-02f, 9.54280794e-02f, -1.04984917e-01f, -1.16505519e-01f, -3.50737087e-02f, -6.54828176e-02f,
  2.18126252e-01f, 1.77513316e-01f, -1.05410479e-02f, 8.84874091e-02f, 6.02951981e-02f, -1.68040961e-01f, -1.03449874e-01f, -9.51986462e-02f, -7.47994930e-02f, -8.02209973e-03f,
  9.11871716e-02f, 2.77977474e-02f, 3.62414345e-02f, -2.12630965e-02f, -2.17934921e-02f, 3.59613827e-04f, -1.33600412e-02f, 8.17170441e-02f, 1.01077547e-02f, 4.63887081e-02f,
  1.55400217e-01f, 1.20340504e-01f, 4.87093031e-02f, 7.46900737e-02f, 4.87542935e-02f, 3.97277996e-02f, -1.33971367e-02f, 1.62058860e-01f, 1.24710128e-01f, 2.13243812e-01f,
  1.70061514e-01f, -1.99823305e-02f, -1.64036348e-01f, 1.20035991e-01f, -4.01188955e-02f, 5.52257933e-02f, 9.11987498e-02f, -6.12067468e-02f, -6.48756251e-02f, -4.08645608e-02f,
  7.70798475e-02f, 1.75895449e-02f, -6.72121346e-02f, -4.00914662e-02f, 6.82847872e-02f, -3.71042900e-02f, 2.09811218e-02f, -7.96555355e-02f, -1.25655066e-02f, 5.99063039e-02f,
  2.72564478e-02f, 7.64983222e-02f, -1.29470155e-02f, -1.11325167e-01f, -1.20813332e-01f, -1.00911304e-01f, -4.01977226e-02f, 5.80045730e-02f, -8.66670068e-03f, -3.76196057e-02f,
  2.65287906e-02f, -6.95102289e-02f, -5.11003472e-02f, 3.16987559e-02f, 4.39975690e-03f, 7.84063898e-03f, 2.53957529e-02f, -5.59777804e-02f, 3.51704061e-02f, 5.45185357e-02f,
  -5.74641377e-02f, 4.33795787e-02f, 4.32648063e-02f, 5.61503097e-02f, -2.02835668e-02f, -4.84076105e-02f, -3.02815735e-02f, -5.67815080e-03f, -5.42226201e-03f, -5.22439741e-02f,
  -2.92393342e-02f, -2.61374563e-02f, 1.27960881e-02f, 1.70448478e-02f, 4.90650609e-02f, -7.06712678e-02f, -4.64872308e-02f, -7.12570176e-02f, -2.09776387e-02f, 7.95640051e-02f,
  -6.32831529e-02f, -1.57184675e-01f, -4.68524471e-02f, 5.85802272e-03f, 2.67525855e-02f, 6.09148741e-02f, 4.81426865e-02f, 5.09743504e-02f, -3.88118438e-03f, -2.25464161e-02f,
  -4.06774916e-02f, -9.75004360e-02f, -4.70098071e-02f, 3.20443660e-02f, 5.34424447e-02f, 1.42635824e-02f, -6.22085780e-02f, 3.09524499e-02f, -4.04013246e-02f, 7.08762277e-03f,
  -1.35532301e-02f, -8.19684714e-02f, -1.70080110e-01f, -1.50140360e-01f, -8.15627947e-02f, -1.25601888e-01f, -2.36731805e-02f, -1.27964646e-01f, -1.87017128e-01f, -1.26872405e-01f,
  7.79886395e-02f, 3.44936326e-02f, -4.99842577e-02f, 6.36729002e-02f, 7.33616576e-02f, 1.28961310e-01f, 7.89513215e-02f, 1.30307660e-01f, 1.22878691e-02f, 1.11991234e-01f,
  1.35423958e-01f, -2.14876421e-02f, 1.17187254e-01f, -5.39091863e-02f, 3.81490998e-02f, -1.76070817e-02f, -6.24911487e-02f, 1.01995945e-01f, -1.99022945e-02f, 9.67376982e-04f,
  1.93201620e-02f, 8.77477974e-02f, 5.13484664e-02f, -7.73517564e-02f, 3.62510346e-02f, 2.53422037e-02f, -4.23626862e-02f, -3.30529287e-02f, 4.78508398e-02f, -4.73223403e-02f,
  5.78215271e-02f, -5.59444726e-03f, 4.57505994e-02f, 7.31933862e-02f, -1.76516064e-02f, 8.52918699e-02f, -4.60595936e-02f, -5.40069118e-02f, 6.61057457e-02f, 6.30720481e-02f,
  -6.63629323e-02f, -3.56823653e-02f, -7.81319067e-02f, -3.82992625e-02f, -7.01053664e-02f, -9.05742031e-03f, -7.71309361e-02f, -2.95988750e-03f, -5.76456450e-02f, 3.50994170e-02f,
  -6.84335679e-02f, -8.09264779e-02f, 9.79770198e-02f, 7.68110976e-02f, -6.34997189e-02f, -1.74808074e-02f, 1.48531180e-02f, 1.80866867e-02f, 3.43977176e-02f, -1.15025945e-01f,
  5.33142220e-03f, 1.63118672e-02f, 4.80968356e-02f, -7.66806304e-02f, -7.42166340e-02f, -4.74690162e-02f, -2.53623948e-02f, 2.02283747e-02f, -3.06211822e-02f, -8.41258839e-02f,
  -4.73720618e-02f, 7.85997957e-02f, -6.15546219e-02f, 3.49811949e-02f, 7.73440227e-02f, 4.57873307e-02f, -8.44717920e-02f, 1.16705475e-02f, 8.29222351e-02f, 4.60459776e-02f,
  9.96836722e-02f, -7.99931437e-02f, 8.22127238e-02f, 7.73113295e-02f, 6.92887828e-02f, -6.02490753e-02f, 6.13391399e-02f, 6.02857545e-02f, 5.14006838e-02f, 5.09330668e-02f,
  -8.80596340e-02f, -2.20027454e-02f, 3.53052765e-02f, 4.35045324e-02f, 7.25390315e-02f, 7.19540864e-02f, -8.57768804e-02f, 1.76250748e-02f, -1.90433748e-02f, -8.47967044e-02f,
  1.48606347e-03f, 5.89135736e-02f, -1.42216273e-02f, -2.80300211e-02f, -4.48994040e-02f, -2.64232010e-02f, -2.10109912e-02f, -5.50639145e-02f, -2.60069370e-02f, -4.29349504e-02f,
  -6.66405410e-02f, -6.29372448e-02f, 3.94875295e-02f, 9.46130604e-03f, 2.02013440e-02f, -2.75594611e-02f, 1.06912875e-03f, 3.12072933e-02f, -3.50690521e-02f, 5.02312519e-02f,
  1.60957009e-01f, 7.25372434e-02f, -2.26549581e-02f, 6.36683553e-02f, 2.63559297e-02f, -6.11481210e-03f, 1.39757976e-01f, 2.06476852e-01f, 2.39442006e-01f, 1.29800528e-01f,
  -6.21158481e-02f, 1.52412623e-01f, 4.25750166e-02f, 7.61466995e-02f, 5.25058508e-02f, 1.29359722e-01f, 1.29079163e-01f, 2.80670915e-02f, 1.56488836e-01f, 3.28762047e-02f,
  9.93958190e-02f, 4.10699248e-02f, 5.29832132e-02f, -1.29858106e-02f, 1.14572309e-01f, 6.71892241e-02f, 1.13528296e-01f, 4.41161059e-02f, -5.29846139e-02f, 1.61933005e-01f,
  -5.67213967e-02f, -5.89158237e-02f, 1.10827580e-01f, 2.43929904e-02f, -1.61557898e-01f, -9.37994104e-03f, -2.92187482e-02f, 2.14139465e-03f, -9.67570860e-03f, 2.10818667e-02f,
  -1.14486434e-01f, -8.12469497e-02f, -9.87987444e-02f, 2.26254575e-02f, 3.16052102e-02f, -7.21608326e-02f, -4.56011146e-02f, -4.25052494e-02f, 2.74223685e-02f, 1.07453465e-02f,
  6.06765933e-02f, -1.24115996e-01f, -9.95596051e-02f, 8.81440639e-02f, 7.09962398e-02f, -1.21446988e-02f, -2.44607963e-02f, 5.32837175e-02f, 1.30006149e-02f, 2.02611685e-02f,
  -6.24566004e-02f, 4.62324359e-02f, -1.30515564e-02f, 3.26037407e-02f, -6.54550642e-02f, -4.72660288e-02f, 2.67194957e-02f, -2.38280176e-04f, 4.79383320e-02f, -8.48173723e-02f,
  7.09112883e-02f, 5.43370396e-02f, 2.31397599e-02f, -7.31278211e-02f, 9.79665443e-02f, -1.01567924e-01f, -4.32983264e-02f, -8.07858855e-02f, -3.58438343e-02f, 5.17141819e-03f,
  2.01672018e-02f, -5.31886816e-02f, -1.55813317e-03f, -1.87598597e-02f, 6.00973144e-02f, 3.39852087e-02f, -2.69979425e-02f, 2.53613703e-02f, 6.49475679e-02f, -5.46238199e-02f,
  5.93558140e-02f, -1.90311298e-02f, 1.17345616e-01f, 8.68400782e-02f, -4.94945236e-02f, -5.57420440e-02f, -1.62537880e-02f, -6.22320920e-02f, 7.16263289e-03f, -3.58684026e-02f,
  -1.18694991e-01f, 3.91834751e-02f, -7.32204840e-02f, -3.06312591e-02f, -2.56233476e-02f, 2.39053126e-02f, 5.97100258e-02f, -3.73963900e-02f, 5.21886684e-02f, -7.35579357e-02f,
  -1.02364337e-02f, -4.43362519e-02f, 2.70340256e-02f, 2.64913496e-02f, 2.58973427e-02f, 1.25487745e-01f, 1.61678717e-02f, -9.21606869e-02f, 1.19320117e-02f, 9.96743143e-02f,
  -7.76705565e-03f, -2.62770742e-01f, 2.71738116e-02f, -3.08649912e-02f, -1.47143781e-01f, -1.40993728e-03f, -2.14625940e-01f, -1.34474620e-01f, -1.27957970e-01f, -1.93037152e-01f,
  -1.75598800e-01f, 1.86183956e-02f, 1.19972385e-01f, 4.07840051e-02f, 1.19320497e-01f, -9.22740698e-02f, 7.48221204e-02f, 1.51049361e-01f, 2.13698015e-01f, -8.44147354e-02f,
  -3.02920341e-02f, 7.85528049e-02f, 1.51473582e-01f, 4.89135757e-02f, -1.27631709e-01f, -7.53828809e-02f, 9.23470221e-03f, -9.37335193e-02f, 1.46366451e-02f, -7.16039389e-02f,
  -9.99070704e-02f, -6.16052421e-03f, 6.16603047e-02f, 8.21074769e-02f, 7.48527721e-02f, 1.11685740e-02f, 3.12728691e-03f, -2.38919426e-02f, -6.43939599e-02f, 2.36791484e-02f,
  6.31398410e-02f, -6.60179630e-02f, 5.09304330e-02f, -9.66744646e-02f, 5.16040018e-03f, -8.03440586e-02f, 8.49401951e-02f, 1.43322945e-01f, -1.28746284e-02f, -7.06964508e-02f,
  -1.18248627e-01f, -8.44304860e-02f, 1.20359436e-01f, -1.50496652e-03f, 1.38615975e-02f, 2.66700815e-02f, -2.49249823e-02f, 6.56189770e-02f, 5.66585828e-03f, -1.48427695e-01f,
  4.29199748e-02f, -1.34482458e-02f, 1.89500172e-02f, 3.31091806e-02f, -4.47422005e-02f, 4.48272899e-02f, -1.07053285e-02f, -1.66750004e-04f, -1.11766802e-02f, -2.44205333e-02f,
  -6.84683621e-02f, -7.47102052e-02f, -3.85746732e-02f, -3.74129228e-02f, -1.54267345e-02f, 1.34332497e-02f, 2.72663939e-03f, 4.93241660e-02f, 4.18105163e-02f, 2.84158112e-03f,
  -1.16409932e-03f, -3.97907384e-03f, -8.50407630e-02f, 2.38205330e-03f, 1.52710080e-02f, -3.24123167e-02f, 4.10262980e-02f, 5.18904775e-02f, -9.11311731e-02f, -3.68547253e-02f,
  -1.05683446e-01f, 2.20883310e-01f, 5.49700707e-02f, -3.69089469e-02f, -5.53166084e-02f, 1.35358737e-03f, -3.62053327e-02f, 1.09909281e-01f, 1.18876547e-01f, 4.09914814e-02f,
  -6.71046600e-02f, 3.57942209e-02f, -3.61334197e-02f, -1.05264999e-01f, 9.86444503e-02f, 8.92780349e-02f, -8.78168941e-02f, 6.10915050e-02f, 3.07590123e-02f, -7.60073885e-02f,
  -8.12729746e-02f, 2.69725807e-02f, 1.19291797e-01f, 8.79004438e-05f, -6.53778315e-02f, 6.55314326e-02f, -2.15380359e-02f, 6.60168752e-02f, 1.21677853e-01f, -6.42943457e-02f,
  9.08541828e-02f, 4.45849784e-02f, 1.15826331e-01f, -8.64203721e-02f, 5.87888435e-02f, -4.60798033e-02f, -2.64366455e-02f, 1.14761099e-01f, 7.21007660e-02f, -1.78183150e-02f,
  -1.16979880e-02f, 5.02289198e-02f, -2.77971872e-03f, -3.69882546e-02f, -6.95619360e-03f, -1.15940645e-02f, -3.65737714e-02f, -3.83716151e-02f, -4.90778834e-02f, 2.53960676e-02f,
  2.06342414e-02f, -3.36871743e-02f, 6.76263217e-03f, -2.55162753e-02f, -6.98675290e-02f, -2.23830305e-02f, -5.36399484e-02f, 9.20974240e-02f, 2.59225424e-02f, -3.45417559e-02f,
  -2.82254834e-02f, 1.31785616e-01f, -7.33686090e-02f, -6.12574331e-02f, -9.13048834e-02f, 4.66332734e-02f, 8.26950371e-02f, -8.24062154e-02f, 8.99825096e-02f, -8.44790339e-02f,
  -7.20515922e-02f, -4.93829772e-02f, -3.67238596e-02f, 4.57333177e-02f, 6.57636151e-02f, 2.61471774e-02f, -2.32285876e-02f, -5.31515330e-02f, -4.10725102e-02f, 5.22028888e-03f,
  -4.18980680e-02f, 3.28274295e-02f, -2.02433206e-03f, 4.74065579e-02f, 6.97267950e-02f, 7.57999048e-02f, -3.61605617e-03f, 1.05834492e-01f, 7.86919817e-02f, 6.75463900e-02f,
  -6.26688227e-02f, -3.99921685e-02f, 5.75600900e-02f, -9.09810606e-03f, -2.75160708e-02f, 2.93208566e-02f, 1.57545637e-02f, -1.17961958e-03f, -6.87098280e-02f, -7.26716965e-02f,
  1.69032048e-02f, -7.60014951e-02f, -4.04790696e-03f, -1.18772155e-02f, -8.03880170e-02f, 7.36982375e-02f, -4.15955819e-02f, -2.71120993e-03f, 2.17421912e-02f, -5.92665635e-02f,
  6.78216591e-02f, 2.28179824e-02f, 7.68447444e-02f, 5.42478301e-02f, -3.94146554e-02f, -1.96469147e-02f, 7.12569356e-02f, 9.65906754e-02f, 8.08590278e-02f, 4.39624935e-02f,
  -3.97101492e-02f, 1.28868399e-02f, -6.14559799e-02f, -8.74699503e-02f, 6.65908679e-03f, 3.32508087e-02f, -1.01575121e-01f, -7.26457909e-02f, 8.81916210e-02f, 6.53159693e-02f,
  -4.24139714e-03f, -4.29840945e-03f, 6.61288723e-02f, -7.23217428e-02f, -5.58453426e-02f, 1.86995845e-02f, 6.92266971e-02f, -4.03833669e-03f, -1.20777236e-02f, -1.84006933e-02f,
  6.48868307e-02f, 7.08683804e-02f, -3.69831398e-02f, -2.57465318e-02f, -5.39735518e-02f, -6.89934120e-02f, -3.53475548e-02f, -1.37646431e-02f, 4.56191078e-02f, 2.78073251e-02f,
  -2.32354134e-01f, 6.59177005e-02f, 1.15128718e-01f, -4.12735529e-02f, 9.68296640e-03f, 7.38146678e-02f, 1.55729622e-01f, -5.22008948e-02f, -1.17476083e-01f, -6.92257658e-02f,
  -2.31158989e-03f, -1.53422832e-01f, -1.09206274e-01f, 5.21246269e-02f, -2.98253577e-02f, 1.33871451e-01f, 5.30488230e-03f, -3.14437300e-02f, -1.48200825e-01f, -3.72614339e-02f,
  -4.47449982e-02f, -1.10382371e-01f, -8.39729309e-02f, -9.36894417e-02f, 6.34322390e-02f, -4.39288355e-02f, 7.73020461e-02f, -9.12018307e-03f, 1.11609437e-01f, 2.52940636e-02f,
  5.62810674e-02f, 1.04361914e-01f, -1.13273144e-03f, -1.16884135e-01f, 5.55682555e-02f, -3.13194643e-04f, -1.16157405e-01f, -1.28389942e-02f, 7.65944868e-02f, 8.21573064e-02f,
  2.31747162e-02f, 2.32054070e-02f, 5.25204912e-02f, 4.77609262e-02f, 4.56111133e-03f, 7.61986524e-02f, -2.21044887e-02f, 1.83617435e-02f, 8.12818762e-03f, 1.12845622e-01f,
  1.16295710e-01f, 5.00756428e-02f, -1.17911082e-02f, -2.11861562e-02f, 8.63340795e-02f, -8.65989327e-02f, 9.96910408e-02f, 7.70460069e-02f, 7.04482868e-02f, 1.28024202e-02f,
  1.61774028e-02f, 3.37487669e-04f, -2.07548938e-03f, 1.51441628e-02f, 9.75670386e-03f, 2.07820511e-03f, -5.11997677e-02f, -2.64722947e-02f, -8.82233605e-02f, 4.23194766e-02f,
  -2.89812218e-02f, 3.27129401e-02f, -5.75632937e-02f, -5.95664047e-02f, -2.00826470e-02f, 1.27614532e-02f, -7.00047845e-03f, 6.45029396e-02f, -5.01573319e-03f, 8.05591792e-03f,
  8.71161893e-02f, -3.79645415e-02f, 5.49757443e-02f, 1.08024172e-01f, -1.89612880e-02f, 7.91975409e-02f, -1.42844319e-02f, 4.27162275e-02f, -4.23041098e-02f, -2.23970525e-02f,
  -4.82721590e-02f, 1.28353938e-01f, -6.36835694e-02f, 7.31650591e-02f, 2.55191028e-02f, 9.25650820e-02f, 3.45315859e-02f, -6.99582836e-03f, 7.01569067e-03f, 2.27785129e-02f,
  9.88509059e-02f, 8.91902600e-04f, -1.20450966e-02f, 6.89545125e-02f, -1.12138510e-01f, 7.08709061e-02f, 3.18386368e-02f, -2.74240673e-02f, 8.37505162e-02f, 9.85417217e-02f,
  1.42037436e-01f, -7.76339322e-02f, 3.14326142e-03f, -6.57214150e-02f, -2.77552232e-02f, -9.66897234e-02f, -4.94219624e-02f, -8.16806555e-02f, 7.12481290e-02f, -1.45175084e-01f,
  6.96989000e-02f, 2.40113616e-01f, 8.53224471e-02f, -9.45737511e-02f, 3.06189656e-02f, 3.04682329e-02f, 2.27155790e-01f, 6.54806644e-02f, -1.70142099e-03f, 6.37539551e-02f,
  2.42670216e-02f, -1.60985306e-01f, 1.51664605e-02f, -6.12769388e-02f, 6.45360500e-02f, 3.21641751e-02f, -4.74195667e-02f, -1.12163037e-01f, -1.41736716e-01f, -5.97305000e-02f,
  -1.23381048e-01f, 3.51776779e-02f, -3.40024121e-02f, -7.92910010e-02f, -1.32480234e-01f, -1.26606435e-01f, -2.15057340e-02f, 1.70103759e-02f, 4.56568934e-02f, -3.40161100e-02f,
  4.30997135e-03f, 1.97164670e-01f, -8.91383737e-03f, 1.06769905e-03f, 1.18492581e-02f, 7.64025748e-02f, 1.92188043e-02f, -2.47202516e-02f, 3.64232878e-03f, -4.57887724e-03f,
  -4.54109833e-02f, -4.35391925e-02f, 2.41261553e-02f, -2.74823159e-02f, 5.49953096e-02f, -9.75556497e-04f, 7.39578679e-02f, -4.37228158e-02f, -7.81117678e-02f, 8.45305249e-02f,
  -4.32017744e-02f, 7.69665837e-02f, 4.17752042e-02f, 7.41868839e-02f, -5.79538792e-02f, 6.48125727e-03f, 6.31600395e-02f, 2.84659453e-02f, -2.11493298e-02f, -1.04446739e-01f,
  -2.34136507e-02f, 5.87174706e-02f, 7.18176290e-02f, 9.00102779e-03f, -2.71657705e-02f, 7.62757212e-02f, 1.74916964e-02f, -2.15958152e-02f, 8.65590721e-02f, -1.56129189e-02f,
  2.65536886e-02f, -5.13761193e-02f, 7.17407316e-02f, -9.92934555e-02f, -6.66904449e-02f, 2.09513828e-02f, -5.15275784e-02f, 9.01374370e-02f, 1.34563409e-02f, -4.97478731e-02f,
  -1.03086598e-01f, 4.50364389e-02f, -5.00131063e-02f, -4.42401059e-02f, 8.09289664e-02f, 1.88446383e-03f, -8.22435617e-02f, -6.83001950e-02f, -9.67045967e-03f, -4.40832376e-02f,
  -1.07355565e-01f, 1.12108134e-01f, 1.90212671e-03f, -9.20426920e-02f, -2.76105106e-02f, -4.42925766e-02f, -1.76171083e-02f, 3.22124995e-02f, 1.46196000e-02f, 6.25188798e-02f,
  4.68416736e-02f, 4.77572791e-02f, -3.01385648e-03f, -3.73647772e-02f, -3.39232273e-02f, -4.57612164e-02f, 6.12004474e-02f, -1.29315808e-01f, -6.47437274e-02f, 7.54003376e-02f,
  5.75563274e-02f, 4.67256084e-02f, -1.03697062e-01f, -1.13430535e-02f, -6.55193999e-02f, -1.42716318e-02f, 1.14308996e-02f, -1.43372580e-01f, -8.64139851e-03f, -4.09886204e-02f,
  -2.70054966e-01f, 4.05476429e-02f, 1.30577326e-01f, -2.33603660e-02f, 1.11609763e-02f, -1.10446066e-01f, -8.82593989e-02f, -1.71625037e-02f, -1.41768940e-02f, -1.50222634e-03f,
  -6.06819168e-02f, -1.69820458e-01f, 2.82547418e-02f, -1.27139300e-01f, -1.68140516e-01f, 6.47511035e-02f, 4.55249064e-02f, -1.34759456e-01f, -2.00554386e-01f, -2.44737893e-01f,
  -1.95069999e-01f, -1.85913399e-01f, -5.40207922e-02f, -1.29086569e-01f, 3.15350555e-02f, -6.65164590e-02f, 7.22123384e-02f, -8.96156281e-02f, 3.95345017e-02f, 1.08752578e-01f,
  -3.73772047e-02f, 2.07499340e-02f, 2.55055148e-02f, 3.85759063e-02f, 7.79789388e-02f, 7.03550577e-02f, -2.68840995e-02f, 1.12768739e-01f, 2.76241964e-03f, -5.81160001e-02f,
  -5.34215011e-02f, 4.01871018e-02f, 3.45980339e-02f, -8.13042745e-02f, -1.07954279e-01f, -1.05965110e-02f, 7.57168885e-03f, -6.28236756e-02f, 6.76999241e-02f, -1.13398889e-02f,
  5.91891259e-02f, -1.25733912e-01f, -8.82800668e-02f, 6.46732152e-02f, 6.62238002e-02f, -5.60203195e-02f, -3.87999006e-02f, 1.01493590e-01f, 1.48894489e-01f, 2.17638053e-02f,
  9.75234341e-03f, 5.38463257e-02f, 2.96438653e-02f, -7.04263523e-02f, -2.19634995e-02f, -2.33497862e-02f, -5.28672822e-02f, -7.67461360e-02f, -9.56129432e-02f, -8.54366720e-02f,
  -1.01409052e-02f, 3.81014682e-02f, -6.24866858e-02f, 2.45477892e-02f, 4.27810960e-02f, -2.80537941e-02f, -3.54909804e-03f, 1.02821169e-02f, 6.89946264e-02f, 2.28037611e-02f,
  -1.09545358e-01f, 6.39167354e-02f, 7.78291048e-03f, 1.33255683e-02f, 8.23768452e-02f, 3.04236019e-04f, 2.24806201e-02f, 6.86359406e-02f, 5.76046370e-02f, -7.84448013e-02f,
  -1.05475225e-01f, 7.57222846e-02f, -4.91658114e-02f, -6.78358227e-02f, 7.16781542e-02f, -5.27431667e-02f, -3.43907950e-03f, -5.23624793e-02f, 2.58191749e-02f, 2.29762960e-02f,
  -3.53233181e-02f, -1.53475419e-01f, 7.96504784e-03f, -1.93070211e-02f, -1.66271582e-01f, -7.50620067e-02f, -3.81475203e-02f, -1.32471308e-01f, 3.36467102e-02f, -7.18565360e-02f,
  -1.79956537e-02f, -8.16984549e-02f, -6.30945936e-02f, -2.55914200e-02f, 2.13571880e-02f, -1.02668040e-01f, -1.08723842e-01f, -1.91887114e-02f, -1.06213205e-02f, -8.09326023e-02f,
  -4.30671662e-01f, -6.88321218e-02f, -1.09689087e-01f, -2.38143668e-01f, 3.05377096e-02f, 2.05560356e-01f, 2.34947786e-01f, 1.36167318e-01f, -6.37525395e-02f, -1.17168754e-01f,
  3.06337159e-02f, -1.39235601e-01f, 7.56750582e-04f, 9.72105041e-02f, 6.13329895e-02f, 3.51543799e-02f, 4.06486616e-02f, -2.22817739e-03f, -2.60006636e-02f, 6.94547370e-02f,
  1.14551604e-01f, -1.96696833e-01f, -1.52028546e-01f, -1.28162131e-01f, -2.40739156e-02f, -1.21273296e-02f, -1.67004183e-01f, -7.64804855e-02f, 9.35026631e-02f, -1.24772072e-01f,
  -1.20796980e-02f, -1.15897067e-01f, -3.05045322e-02f, -7.81326070e-02f, -2.91187735e-03f, -1.18194136e-03f, 1.36538716e-02f, -1.38376504e-01f, -7.84638226e-02f, -7.34317973e-02f,
  -3.01459078e-02f, -7.44320452e-02f, -7.50274584e-02f, -2.59598289e-02f, -9.92825627e-02f, 7.68835247e-02f, 8.51505846e-02f, 3.19191590e-02f, -4.31455262e-02f, 3.89182903e-02f,
  8.27828497e-02f, -2.24249507e-03f, -1.22515835e-01f, -2.28876825e-02f, 7.94168711e-02f, -6.14220239e-02f, 4.46882322e-02f, -3.22944000e-02f, -4.92104106e-02f, -7.99424201e-02f,
  7.40864053e-02f, 4.17906605e-02f, 4.03224714e-02f, -3.66844311e-02f, 1.91684999e-02f, 2.42939740e-02f, -6.37360141e-02f, 3.97611558e-02f, -7.63389468e-02f, -8.37313831e-02f,
  -5.31448191e-03f, 4.83557396e-02f, -6.10407330e-02f, -9.01285708e-02f, 3.83255966e-02f, -2.47887671e-02f, 7.55985603e-02f, 1.74314212e-02f, 8.07297006e-02f, -3.74459550e-02f,
  -2.85393074e-02f, -1.61858406e-02f, -2.52674352e-02f, 1.99066345e-02f, 4.03641015e-02f, 7.69913048e-02f, -3.57283577e-02f, 5.69557548e-02f, 3.47889848e-02f, -5.24897426e-02f,
  -2.96156347e-01f, 8.36935788e-02f, -9.99214947e-02f, 2.26868242e-02f, -1.14590816e-01f, 3.20357014e-03f, -8.84482041e-02f, 6.20192811e-02f, -7.18052834e-02f, 3.62469209e-03f,
  7.64589980e-02f, -6.88042492e-02f, -1.38079286e-01f, 8.56921449e-03f, -4.27015275e-02f, -4.45955358e-02f, -5.53849600e-02f, 1.63725633e-02f, 6.38577417e-02f, -2.72191502e-02f,
  6.55931532e-02f, 9.73891839e-03f, 8.17649707e-04f, -7.57062808e-02f, -2.58376505e-02f, -5.24837561e-02f, -9.68600735e-02f, 6.39868826e-02f, 1.22853573e-02f, -7.95704946e-02f,
  1.31833255e-01f, 4.07885425e-02f, -2.12705672e-01f, 5.86588271e-02f, -4.68994491e-02f, -6.66467398e-02f, -5.77541627e-02f, -1.79481097e-02f, -2.30546128e-02f, 5.80973290e-02f,
  1.88918374e-02f, -9.52491984e-02f, 4.35598120e-02f, -4.60361354e-02f, -1.55808777e-01f, -9.42524970e-02f, -1.80672377e-01f, -1.38576999e-01f, -2.32286304e-01f, -8.89826939e-02f,
  -1.52086958e-01f, -1.50071710e-01f, -1.29664883e-01f, -1.28103346e-01f, 1.35279652e-02f, -2.90282350e-02f, -3.98951955e-02f, -3.23203616e-02f, -1.47273794e-01f, -5.29776216e-02f,
  -6.40647486e-02f, 1.33088902e-01f, -1.11160979e-01f, 7.07271844e-02f, 3.20089757e-02f, -3.41378599e-02f, -9.21899602e-02f, 2.19783019e-02f, -4.94854450e-02f, 7.34719932e-02f,
  1.59847718e-02f, -9.88292992e-02f, 1.38829937e-02f, -4.99551445e-02f, 1.09551195e-03f, -1.15764230e-01f, 2.57584620e-02f, -4.42537256e-02f, -1.20227091e-01f, -4.23282124e-02f,
  -9.23527330e-02f, -1.07153721e-01f, -2.33402122e-02f, 2.19835658e-02f, 5.31547405e-02f, -4.41181213e-02f, 2.05501262e-02f, -3.78993899e-02f, 2.04758570e-02f, 8.80303979e-02f,
  6.32336689e-03f, -3.87262292e-02f, -2.08595023e-03f, -6.98258821e-03f, 3.56552228e-02f, -5.83393797e-02f, 1.59065668e-02f, 7.82102272e-02f, 7.91350566e-03f, -6.42455220e-02f,
  -1.34285865e-02f, -4.60660234e-02f, -2.30578110e-02f, -2.60564368e-02f, 9.61915497e-03f, 6.60988018e-02f, 6.90507144e-02f, 5.03043421e-02f, 2.73138117e-02f, 4.54257466e-02f,
  1.81960184e-02f, -1.00918904e-01f, -3.86778009e-03f, -5.20375669e-02f, -5.21385744e-02f, -9.42958072e-02f, 9.36244335e-03f, 7.33152181e-02f, 9.38336328e-02f, 8.52357149e-02f,
  1.25459313e-01f, -1.61953066e-02f, 5.61008342e-02f, -8.11277255e-02f, 3.57502848e-02f, 2.39341473e-03f, 6.82110861e-02f, -6.62610754e-02f, 5.83547130e-02f, 1.54565712e-02f,
  -1.09159358e-01f, -2.66409460e-02f, -6.71416372e-02f, -1.00900255e-01f, -7.69472942e-02f, -1.05389930e-01f, 2.52112504e-02f, -7.38774091e-02f, -7.81196877e-02f, -2.67954124e-03f,
  -1.47714922e-02f, -4.93387431e-02f, -2.20420733e-02f, 4.50587422e-02f, 3.98406312e-02f, -4.18101484e-03f, 9.66447294e-02f, 1.05342992e-01f, 3.77854295e-02f, -1.07166665e-02f,
  1.45013556e-01f, -1.92966282e-01f, 1.21178314e-01f, 2.15549782e-01f, 1.64654404e-01f, 1.99940458e-01f, 2.14242294e-01f, 1.60951447e-02f, 2.67172679e-02f, -6.66620582e-02f,
  -1.52124032e-01f, -2.14800000e-01f, -8.16780552e-02f, -1.09405056e-01f, -6.32292032e-02f, 7.69044459e-02f, 8.39165375e-02f, 1.22514561e-01f, 1.86345354e-01f, 5.64959049e-02f,
  4.30314578e-02f, -3.58927995e-02f, -6.37859479e-02f, 6.99549988e-02f, -7.06032366e-02f, 2.26565301e-02f, 4.43364568e-02f, 6.20856602e-03f, -3.57216857e-02f, 3.92917031e-03f,
  -3.34541574e-02f, 7.83558339e-02f, 2.48354841e-02f, -3.11702546e-02f, 1.36714336e-03f, -9.96478871e-02f, 5.10716625e-02f, 3.81509475e-02f, 1.49666201e-02f, -2.48282794e-02f,
  -1.19646706e-01f, -7.01836124e-03f, -1.05650395e-01f, 1.28844380e-02f, 5.31984419e-02f, 5.56247532e-02f, 7.04386365e-03f, -1.12464748e-01f, -6.66595399e-02f, -1.61755472e-01f,
  -1.26695752e-01f, -1.97469033e-02f, 1.29886717e-01f, 4.02686000e-03f, -6.85485452e-02f, -8.44390318e-02f, 3.70853133e-02f, -1.77718030e-04f, 2.13611778e-03f, -1.06943222e-02f,
  -5.51623851e-02f, 5.14449961e-02f, -3.11943553e-02f, 4.21457104e-02f, 8.11056271e-02f, -3.85025479e-02f, 6.70620129e-02f, -3.32223281e-04f, 3.07117365e-02f, -2.77622025e-02f,
  4.92520221e-02f, -4.38992381e-02f, 3.59236412e-02f, -3.97864096e-02f, -4.60508242e-02f, 1.06723912e-01f, 2.88471393e-02f, -4.29842845e-02f, -6.86641186e-02f, 4.84181531e-02f,
  8.04696679e-02f, 1.03404336e-02f, -5.40932752e-02f, -3.12684514e-02f, -3.05012590e-03f, -3.23297866e-02f, -7.78226405e-02f, -5.53047657e-02f, 1.82155594e-02f, -7.12053385e-03f,
  -7.00726807e-02f, 2.09312560e-03f, 7.30938613e-02f, -1.01608679e-01f, 7.82495439e-02f, -7.01734871e-02f, -6.20314553e-02f, 3.05126421e-02f, -4.04924639e-02f, 5.23174666e-02f,
  -1.00433581e-01f, -6.29361421e-02f, -1.23218052e-01f, 1.08951712e-02f, 1.59604952e-01f, 4.27490333e-03f, -9.25433263e-02f, 8.64394978e-02f, -1.21622786e-01f, -1.01775438e-01f,
  -4.71043251e-02f, 1.91832781e-01f, 1.89932927e-01f, 1.07697032e-01f, 7.95317739e-02f, 1.79929137e-01f, 1.06010325e-02f, 1.22407719e-01f, 3.73446867e-02f, 8.21236819e-02f,
  -1.14532858e-01f, -8.08943436e-02f, 1.26704320e-01f, 2.14226898e-02f, 8.50753114e-02f, 4.91794832e-02f, -3.45562138e-02f, -3.44500542e-02f, -4.27337438e-02f, -8.51385146e-02f,
  -1.12300105e-01f, -3.27094011e-02f, -4.21292856e-02f, -2.06964416e-03f, 2.46311631e-02f, 5.19306697e-02f, 8.11770037e-02f, 1.60182178e-01f, 1.78538591e-01f, 3.40022556e-02f,
  8.76563415e-02f, 6.49911463e-02f, 9.49328840e-02f, -4.42342423e-02f, 2.30322946e-02f, 3.47226821e-02f, 1.02996014e-01f, -3.90199497e-02f, -3.89436781e-02f, 5.46958297e-02f,
  -1.22320533e-01f, -1.36129752e-01f, 3.23365033e-02f, -2.20960416e-02f, 4.12027538e-03f, -7.74441361e-02f, 1.29172681e-02f, 3.03692725e-02f, 5.40881790e-02f, 4.05317396e-02f,
  -3.57859358e-02f, -8.14040601e-02f, -3.59908901e-02f, -6.34718984e-02f, 1.66631378e-02f, 2.68206764e-02f, 3.52678858e-02f, -5.45353517e-02f, -7.90167227e-03f, -1.29081413e-01f,
  -5.18869162e-02f, 7.85106421e-03f, 5.30062988e-02f, -4.84599210e-02f, -1.65628698e-02f, 5.77759631e-02f, -8.27202275e-02f, -9.28362757e-02f, -7.20641091e-02f, -8.10615893e-04f,
  3.52041386e-02f, -6.28314167e-02f, -6.20430261e-02f, -6.37145862e-02f, 8.89268331e-03f, -5.43612093e-02f, 3.44481096e-02f, 4.75703031e-02f, 2.90730335e-02f, 4.33314033e-03f,
  -3.23977247e-02f, 4.17979769e-02f, 3.47060524e-02f, 7.28887692e-02f, -6.02113679e-02f, -4.46014665e-03f, -7.83179998e-02f, -1.55954761e-02f, -4.67648208e-02f, -5.28577790e-02f,
  3.48593644e-03f, -2.96251755e-02f, 2.37399824e-02f, 7.31683671e-02f, 2.54223365e-02f, -3.87115963e-02f, 3.60094644e-02f, -2.67593078e-02f, -1.15915956e-02f, 2.77959891e-02f,
  9.01908353e-02f, 5.00888415e-02f, -4.74712066e-02f, 3.73426639e-02f, 3.31344344e-02f, 4.72149029e-02f, -1.01870820e-01f, -2.12594271e-02f, 7.34871104e-02f, -5.84004112e-02f,
  -4.23854515e-02f, 2.68169455e-02f, -2.57672295e-02f, 6.79249242e-02f, 5.20795397e-03f, 4.67837742e-03f, -6.03368096e-02f, 1.95161346e-02f, -1.65513530e-02f, -1.18548134e-02f,
  -3.05894203e-02f, 1.08412549e-01f, -4.65839822e-03f, 1.14021599e-01f, 3.90827283e-02f, 1.25602350e-01f, 6.77867383e-02f, -1.07573587e-02f, 1.08731322e-01f, 9.98226628e-02f,
  3.28783132e-03f, -4.51684073e-02f, 1.62794501e-01f, 6.57663196e-02f, -2.44264286e-02f, 4.00686339e-02f, 1.32074626e-02f, -6.99863024e-03f, -5.90537600e-02f, 1.50486948e-02f,
  4.21446860e-02f, -1.44675419e-01f, -5.38592003e-02f, -3.47237512e-02f, -2.20212550e-03f, -6.32401183e-02f, 9.17156599e-03f, -1.33410156e-01f, -1.62682801e-01f, -1.14801213e-01f,
  -2.32240800e-02f, -6.85758293e-02f, -9.10355598e-02f, -1.48467673e-02f, 1.37561290e-02f, 4.26514708e-02f, 3.53415944e-02f, -6.60112873e-02f, -8.35743695e-02f, 2.04568096e-02f,
  -3.12248487e-02f, 1.02699347e-01f, -1.32686049e-02f, -1.34776115e-01f, 5.38619496e-02f, -1.91195402e-02f, -4.92211096e-02f, -5.53454123e-02f, 2.02389769e-02f, -6.84306547e-02f,
  -3.34221125e-02f, -6.26496673e-02f, -3.48607674e-02f, 5.21478355e-02f, -9.53729153e-02f, -7.46235996e-02f, 1.08757177e-02f, 3.80727649e-02f, -7.28871152e-02f, 7.58434609e-02f,
  2.84441710e-02f, -1.69530530e-02f, 9.48462635e-02f, -3.17546502e-02f, 7.08181411e-02f, -8.29830319e-02f, -3.08197495e-02f, -7.25197867e-02f, 3.99590023e-02f, 7.28864148e-02f,
  -1.90301742e-02f, -4.12988998e-02f, -2.24788841e-02f, -4.71163988e-02f, -8.79571885e-02f, -1.33650154e-02f, 9.76781100e-02f, -3.59916352e-02f, 2.81794127e-02f, 3.03967074e-02f,
  9.89516452e-02f, 1.14133902e-01f, -6.96271136e-02f, 6.80456758e-02f, -5.83658591e-02f, 4.36687991e-02f, 1.78511683e-02f, 1.75839290e-02f, -6.60533533e-02f, -3.75194699e-02f,
  -7.72266835e-02f, 5.14162146e-02f, -6.48873821e-02f, 2.54883263e-02f, -4.82167229e-02f, 2.59967726e-02f, 3.72853726e-02f, 7.69351609e-03f, 5.59261860e-03f, 5.94744124e-02f,
  -6.36240318e-02f, 2.23252457e-02f, -7.13877985e-03f, -3.41798067e-02f, 7.31992200e-02f, -3.62228639e-02f, 8.46068189e-03f, 2.12270152e-02f, -6.51798621e-02f, -1.10201225e-01f,
  1.07694464e-02f, 1.46629391e-02f, 8.23355094e-02f, 4.08359021e-02f, 2.29002554e-02f, -3.58389243e-02f, -5.31941578e-02f, -8.59775115e-03f, -3.48574296e-02f, 2.55777389e-02f,
  -3.82128060e-02f, -1.01516187e-01f, -7.30354264e-02f, 1.18887099e-02f, -7.40312189e-02f, -4.67654169e-02f, -1.16585223e-02f, -1.41102420e-02f, 2.04924941e-02f, -2.51719914e-02f,
  2.16884807e-01f, -2.38053530e-04f, 1.94874674e-01f, -4.15980704e-02f, -5.86164445e-02f, 2.81544644e-02f, 6.71098381e-03f, 4.89682257e-02f, -5.13388366e-02f, -1.28541395e-01f,
  1.88560109e-03f, -1.44193303e-02f, -8.12141597e-02f, 5.87418303e-02f, 4.74914499e-02f, 1.53835751e-02f, 7.04753324e-02f, 6.47282675e-02f, 6.10207431e-02f, 7.39332428e-03f,
  -4.89180814e-03f, 1.28783181e-01f, 2.01907218e-01f, 6.56965151e-02f, 1.91043522e-02f, -4.74664494e-02f, 1.27224311e-01f, 6.13962207e-03f, -3.01091392e-02f, 6.79815263e-02f,
  6.95741177e-02f, 1.60723150e-01f, -3.44340391e-02f, -5.13766184e-02f, 6.26317859e-02f, -8.63237381e-02f, -8.30375403e-02f, 3.82006466e-02f, 1.40519813e-02f, 2.69157961e-02f,
  -1.33926515e-02f, 8.41788203e-02f, -5.66117801e-02f, -3.95646468e-02f, 2.80208644e-02f, -7.84728825e-02f, 6.91512600e-02f, 1.21926636e-01f, -3.08573805e-02f, -1.01344220e-01f,
  -9.62003022e-02f, 9.06475708e-02f, -1.58038121e-02f, 1.26214409e-02f, 3.12575847e-02f, -9.32755694e-02f, -2.51215473e-02f, -7.84803629e-02f, 4.50132862e-02f, -1.09007649e-01f,
  3.99673432e-02f, -2.10284609e-02f, -3.58977206e-02f, 2.75972951e-02f, -4.81610000e-02f, 5.10745458e-02f, -3.59673202e-02f, -3.53420079e-02f, -6.06082119e-02f, 5.49215004e-02f,
  9.61723477e-02f, 9.41307545e-02f, 1.08274974e-01f, -2.32222788e-02f, -1.56501606e-02f, 6.86654449e-02f, 4.99011017e-02f, -7.65884444e-02f, 1.06085435e-01f, 5.44080324e-02f,
  -5.79494387e-02f, -5.71369007e-02f, 6.45175800e-02f, 7.01547033e-05f, -2.15767398e-02f, 9.86017436e-02f, 6.24341853e-02f, 4.02173065e-02f, 6.07641004e-02f, -4.23943019e-03f,
  -1.22054197e-01f, 1.15102611e-01f, -8.89523700e-02f, -3.45246270e-02f, 2.02533863e-02f, -7.98081160e-02f, -4.84785996e-03f, 3.74524333e-02f, 1.44523699e-02f, 3.60807367e-02f,
  -2.31715050e-02f, 2.21891757e-02f, 7.46709704e-02f, -2.27496028e-02f, -5.49738780e-02f, 2.90748607e-02f, 2.66436357e-02f, -4.23317291e-02f, -1.36199836e-02f, 4.23438288e-03f,
  -9.72801745e-02f, -4.31083776e-02f, 4.99007665e-02f, 2.89282706e-02f, -2.95432340e-02f, -2.25529578e-02f, 5.30076213e-02f, 4.89932150e-02f, -3.74382809e-02f, -6.65146932e-02f,
  -1.63611591e-01f, 7.03576878e-02f, 8.53851661e-02f, 7.20466068e-03f, -1.07651062e-01f, -1.07160695e-02f, 8.33424628e-02f, 5.14071025e-02f, 6.33959621e-02f, 7.70575702e-02f,
  -6.58422410e-02f, -1.17779255e-01f, -5.78251928e-02f, -8.54207575e-02f, -4.65135695e-03f, -2.85802092e-02f, -2.64238100e-02f, -1.93090752e-01f, -2.00443268e-01f, -1.25848442e-01f,
  -1.37603551e-01f, -6.34453297e-02f, -1.38985738e-01f, -6.81336895e-02f, -4.68369015e-02f, 1.96243953e-02f, 1.05825856e-01f, 3.56983505e-02f, -3.83934341e-02f, 9.21315923e-02f,
  1.47886679e-01f, -3.47903110e-02f, -1.40383258e-01f, -8.00071955e-02f, -7.83401057e-02f, 5.55902980e-02f, 2.90287007e-02f, -7.59937614e-02f, -2.50733248e-03f, 9.56484899e-02f,
  -1.02781303e-01f, -1.61364730e-02f, -6.95457458e-02f, -1.00463718e-01f, 1.84975676e-02f, -2.94433199e-02f, -9.48980823e-02f, -4.82638106e-02f, 5.07623889e-02f, -9.79537293e-02f,
  -3.38987447e-02f, 3.78678925e-02f, -9.92618874e-02f, 2.53795180e-03f, 7.94119015e-02f, -5.20912595e-02f, -3.60366218e-02f, -3.12622897e-02f, -4.69580628e-02f, 5.82183376e-02f,
  -6.79969639e-02f, 5.71463676e-03f, 1.98526029e-03f, 8.04297104e-02f, -7.29969665e-02f, -4.91061769e-02f, 9.92176086e-02f, 9.39242542e-02f, 6.97452649e-02f, 8.80650803e-02f,
  -3.92890945e-02f, 3.13446410e-02f, 3.40157822e-02f, -4.99968305e-02f, -3.86615917e-02f, -1.46036604e-02f, 5.23528736e-03f, -5.91338351e-02f, -7.19908858e-03f, 3.57290134e-02f,
  3.36017907e-02f, -3.75580490e-02f, -2.19365992e-02f, -5.10021001e-02f, -5.32644242e-02f, 3.75251919e-02f, 3.59680429e-02f, -3.50103267e-02f, 3.75463031e-02f, -7.42584914e-02f,
  3.33346538e-02f, -1.33236438e-01f, 1.56921968e-02f, -8.41697231e-02f, -7.58533552e-02f, 3.63615826e-02f, -3.00809164e-02f, -4.40753996e-02f, 1.49359861e-02f, -2.12262496e-02f,
  3.50124165e-02f, 1.56726316e-02f, 9.19769052e-03f, 4.71030138e-02f, -1.14318892e-01f, 5.61985150e-02f, 4.75718677e-02f, -1.11923411e-01f, 3.41625921e-02f, -6.83472455e-02f,
  -7.12265447e-02f, -9.56460536e-02f, -1.46016881e-01f, 6.52076155e-02f, -2.29972624e-03f, -4.85606641e-02f, 4.00111526e-02f, -4.77496535e-02f, -7.85748065e-02f, 5.52174151e-02f,
  1.85759142e-01f, -9.67060402e-03f, 1.44134864e-01f, 1.06050000e-02f, 1.35020483e-02f, -5.30637652e-02f, 3.47045437e-02f, 5.97065203e-02f, -2.77062822e-02f, 2.93278303e-02f,
  -1.75126970e-01f, -1.57038584e-01f, -9.11487117e-02f, -3.92097682e-02f, 1.21605769e-01f, 1.56127557e-01f, 6.49889261e-02f, 8.65777135e-02f, 1.17343307e-01f, 8.46252590e-02f,
  1.82624068e-02f, 3.41308489e-02f, 1.33060306e-01f, 1.64251134e-01f, 8.14924166e-02f, -7.37952515e-02f, -4.69410196e-02f, -5.49632572e-02f, 3.68608795e-02f, 1.89336970e-01f,
  1.20334327e-02f, 3.59842516e-02f, 5.68321534e-02f, -1.24309845e-01f, -1.33587703e-01f, 6.44343942e-02f, -3.49631011e-02f, -8.90246313e-03f, -4.06973250e-02f, 4.73468378e-02f,
  -1.02253437e-01f, 2.42058709e-02f, 3.86376828e-02f, -7.34377652e-02f, 5.98458154e-03f, 7.21925274e-02f, -2.10096221e-02f, 1.57583967e-01f, 2.38170512e-02f, -8.21069553e-02f,
  -2.76797172e-02f, 1.18438527e-02f, -1.02223136e-01f, 3.49241644e-02f, 1.08273178e-01f, -7.99608007e-02f, -6.95087016e-02f, -2.80685816e-02f, -5.46276011e-02f, 1.08153678e-01f,
  1.76651087e-02f, 3.72376014e-03f, -4.90291156e-02f, 6.10121489e-02f, -9.03645828e-02f, 7.69432858e-02f, 7.60610849e-02f, -4.13012784e-03f, 6.16218224e-02f, 2.65746973e-02f,
  -3.94435711e-02f, -3.70325223e-02f, 1.41622455e-04f, -7.29153864e-03f, 3.64298150e-02f, -5.45897596e-02f, -2.39752848e-02f, 5.57123572e-02f, -1.01860069e-01f, -2.20644362e-02f,
  -1.78263392e-02f, 7.98631012e-02f, -8.95362347e-02f, 8.56885612e-02f, -5.00887781e-02f, 3.17928419e-02f, 7.62804374e-02f, -5.77036664e-02f, -2.09929161e-02f, -2.65485477e-02f,
  6.82255672e-03f, -2.06478462e-01f, 1.31624863e-01f, 1.18190393e-01f, -2.21284479e-02f, 4.98395599e-02f, 3.96440877e-03f, 9.00643039e-03f, 3.88772413e-02f, -4.14445661e-02f,
  -2.84177326e-02f, 8.85664374e-02f, -5.27404472e-02f, -4.17779535e-02f, 3.18959244e-02f, 4.98826057e-02f, -1.23556167e-01f, 2.22093947e-02f, -5.09845763e-02f, 7.77065977e-02f,
  -3.13396044e-02f, 4.45596389e-02f, 1.09756719e-02f, -6.39112145e-02f, -6.97438642e-02f, -1.07844993e-01f, -3.11424378e-02f, 1.08467206e-01f, 7.07628205e-02f, 1.96966492e-02f,
  4.37127277e-02f, -1.52722850e-01f, 5.10441363e-02f, 2.08721742e-01f, 1.92650616e-01f, 1.31844223e-01f, 1.41626105e-01f, -1.82230528e-02f, 8.44157115e-02f, 1.29257571e-02f,
  -1.06544457e-01f, 2.43285671e-02f, 1.70419328e-02f, -7.48654082e-02f, -3.83065604e-02f, 5.90167455e-02f, 1.47951329e-02f, 7.78051540e-02f, 1.12184204e-01f, 1.17546983e-01f,
  -9.80228838e-03f, 6.10346831e-02f, 2.33558733e-02f, -7.28696510e-02f, 5.34825679e-03f, 1.15376543e-02f, -6.36456087e-02f, -2.59632133e-02f, 1.24521488e-02f, -3.83870378e-02f,
  -3.11246943e-02f, -2.20261943e-02f, 3.93154733e-02f, 2.25403421e-02f, -3.40413395e-03f, -1.04395226e-01f, 7.45227709e-02f, -1.17632724e-01f, -1.03822492e-01f, 7.04931691e-02f,
  -4.68709581e-02f, -3.69765423e-02f, -5.83271310e-02f, -4.15132903e-02f, 6.46068528e-02f, 7.93464482e-03f, -6.36264235e-02f, -1.33596897e-01f, -9.79485139e-02f, 1.95551501e-03f,
  -1.75082423e-02f, -2.03381516e-02f, 7.01422319e-02f, -7.00727403e-02f, -2.55739558e-02f, 1.90321784e-02f, -1.11443400e-01f, -8.00281167e-02f, -1.32822888e-02f, -8.11437890e-02f,
  -9.67470091e-03f, 4.75202836e-02f, 7.41617456e-02f, -6.70740530e-02f, -8.08136165e-03f, 4.52463292e-02f, 2.04855460e-03f, -1.90236289e-02f, -2.71962723e-04f, -1.68393124e-02f,
  -7.33491927e-02f, -2.52029337e-02f, -3.36076394e-02f, 7.39129111e-02f, -7.04010651e-02f, 6.32324768e-03f, -5.93744293e-02f, -1.02325469e-01f, -3.79492305e-02f, -5.65753952e-02f,
  4.52993251e-02f, -3.98259982e-02f, 7.35521317e-04f, -5.00796847e-02f, -8.64438340e-02f, 5.68838045e-02f, 6.90512136e-02f, -2.24627350e-02f, -6.46343678e-02f, 7.98518062e-02f,
  -1.23420037e-01f, -1.34770423e-02f, 5.56540629e-03f, -5.38583063e-02f, 7.47917742e-02f, 5.20681813e-02f, -9.10771042e-02f, -6.82670400e-02f, 2.68722139e-02f, 2.19608564e-02f,
  -1.15632534e-01f, -1.15345165e-01f, -1.83773339e-02f, -8.90320987e-02f, 8.23203251e-02f, 7.94490427e-02f, -9.13420413e-03f, -4.71441820e-02f, 2.73827575e-02f, -2.95606200e-02f,
  5.19862026e-03f, 1.74885184e-01f, 1.07061461e-01f, -7.35221105e-03f, 8.32698047e-02f, 1.45306736e-01f, 8.20592567e-02f, 1.07501656e-01f, -4.69856430e-03f, 3.15665863e-02f,
  1.32208347e-01f, 2.11003963e-02f, 1.25273399e-03f, 3.31461057e-02f, -6.09148741e-02f, -2.83604469e-02f, -7.06916973e-02f, -4.20094142e-03f, -2.37179007e-02f, 8.56694654e-02f,
  -7.60347247e-02f, 2.46278779e-03f, 2.21995674e-02f, 3.51559967e-02f, -3.72760445e-02f, -4.21776585e-02f, -4.59506512e-02f, 5.67993931e-02f, -5.16647175e-02f, 2.53502419e-03f,
  -8.04138854e-02f, -2.52644327e-02f, 4.36637700e-02f, 8.85257050e-02f, -8.69023800e-02f, -2.66709155e-03f, -7.03640431e-02f, -1.08364992e-01f, 2.79101189e-02f, 4.49281037e-02f,
  -6.37072176e-02f, -1.17555782e-01f, -2.09553409e-02f, 2.21652128e-02f, 1.76066812e-02f, 1.12858742e-01f, -5.16185351e-02f, 4.55202162e-02f, 3.34469862e-02f, 8.97946805e-02f,
  5.89066744e-02f, -4.95498590e-02f, -2.38780044e-02f, 2.43367944e-02f, -4.17652652e-02f, 6.99510053e-02f, 4.09550779e-02f, 3.32475011e-03f, -8.63956884e-02f, -6.89114109e-02f,
  4.52320687e-02f, -9.46938246e-02f, -1.24821318e-02f, 9.64890420e-02f, 4.96653095e-03f, -9.27841142e-02f, -5.01156859e-02f, -8.36828947e-02f, -9.61339176e-02f, 9.23130438e-02f,
  1.30088106e-01f, 1.10101163e-01f, -1.04751177e-01f, -1.11159254e-02f, -1.18603986e-02f, -8.15802291e-02f, 5.92492446e-02f, -6.86669946e-02f, 7.60516301e-02f, -3.86479981e-02f,
  -2.07454208e-02f, -4.36414108e-02f, 6.20961078e-02f, 9.08165872e-02f, -2.25720387e-02f, -3.15289907e-02f, -8.16705301e-02f, 4.56736200e-02f, -1.77351069e-02f, 4.33195904e-02f,
  -3.05755381e-02f, -3.33387591e-02f, -1.84480436e-02f, -1.25292130e-03f, 1.31305167e-02f, -1.55366072e-02f, -5.16812988e-02f, -9.20144469e-02f, -2.73538586e-02f, -2.51604822e-02f,
  1.10394806e-01f, -1.28187761e-02f, 6.49514720e-02f, -6.48236275e-02f, -4.66983393e-02f, 2.96499990e-02f, 6.55830726e-02f, -1.70934666e-02f, 7.88051561e-02f, -2.32747328e-02f,
  -3.13669927e-02f, 1.54366959e-02f, -3.39545794e-02f, 2.78338306e-02f, -7.01682121e-02f, 2.68312860e-02f, 2.18363386e-02f, 7.84233436e-02f, -5.43191694e-02f, -8.28091577e-02f,
  5.12980558e-02f, 1.45943090e-02f, 1.28622487e-01f, 8.86669978e-02f, 2.41145939e-02f, 4.42024879e-02f, 2.47624945e-02f, -7.26125464e-02f, 6.88563511e-02f, 1.15904160e-01f,
  -1.51162446e-01f, -7.59521946e-02f, 9.75853205e-02f, 1.55186847e-01f, 1.58707991e-01f, 1.98005483e-01f, 1.26185149e-01f, 1.45419359e-01f, 8.85107741e-02f, 7.24488720e-02f,
  1.12791762e-01f, -8.25179368e-03f, -6.94793044e-03f, 6.10246584e-02f, 7.18245804e-02f, 1.63272962e-01f, 1.36080638e-01f, 2.86056125e-03f, 2.18015183e-02f, 5.14859930e-02f,
  1.01729311e-01f, 8.71868953e-02f, -7.37553313e-02f, 4.55753393e-02f, 1.85221229e-02f, 1.23766884e-01f, -4.62179109e-02f, 1.22943766e-01f, -1.22099891e-02f, -4.68265042e-02f,
  -2.74277441e-02f, 3.44547145e-02f, -4.79606772e-03f, -7.19549134e-02f, -3.14283781e-02f, -1.23518873e-02f, -2.96949893e-02f, -8.05743113e-02f, -8.00188556e-02f, 7.43275881e-02f,
  -7.92082921e-02f, -9.32676643e-02f, -5.70868957e-04f, 7.78456032e-03f, -7.96953812e-02f, 2.35127304e-02f, -5.76375015e-02f, -3.15655656e-02f, 4.39428575e-02f, 2.66515706e-02f,
  3.50164883e-02f, -9.54180881e-02f, -3.03587355e-02f, 2.69588623e-02f, -5.68839125e-02f, -5.61251752e-02f, -9.36984271e-02f, 4.53147292e-02f, -1.09795801e-01f, -4.95572947e-03f,
  -8.85751992e-02f, -7.21867755e-03f, -5.87166287e-02f, 2.45686132e-03f, 3.56008336e-02f, 2.83410437e-02f, -2.36463491e-02f, 1.03645362e-01f, 6.29512966e-02f, -6.46231547e-02f,
  -5.21647558e-02f, 6.21690974e-02f, 6.59335554e-02f, -1.33306701e-02f, 4.53347154e-03f, -8.76720697e-02f, -9.09619108e-02f, 3.75296399e-02f, -8.88786614e-02f, -2.77792476e-02f,
  3.42005976e-02f, 5.67784011e-02f, -5.05072251e-02f, -4.90349717e-02f, -3.09427697e-02f, 1.63645558e-02f, -4.11789753e-02f, 2.56503597e-02f, -1.04538746e-01f, 9.59586527e-04f,
  6.05782494e-02f, -1.95816858e-03f, -1.65082980e-02f, 2.61195917e-02f, 5.21535017e-02f, -8.58337954e-02f, -2.47571263e-02f, 7.27092847e-02f, 7.04176500e-02f, 7.90953077e-03f,
  -6.08517379e-02f, 3.27100269e-02f, -4.11037281e-02f, -3.18330117e-02f, -7.15134572e-03f, 4.01407667e-02f, 2.75139511e-02f, 1.35349650e-02f, 1.94679759e-02f, -8.85097310e-02f,
  6.75579980e-02f, -3.82669941e-02f, -5.08372746e-02f, 7.40187839e-02f, -6.01811148e-03f, -2.73064207e-02f, 1.32666063e-03f, -1.11769982e-01f, 1.48438988e-02f, -1.09783411e-01f,
  -1.09971806e-01f, -6.66682376e-04f, 1.50124863e-01f, 5.86806051e-02f, 4.70572412e-02f, 1.22587331e-01f, 6.57600164e-02f, -3.84895131e-02f, 4.04879563e-02f, 5.32737784e-02f,
  -1.25536367e-01f, -1.05808146e-01f, 2.89476644e-02f, -4.82621640e-02f, 9.04405788e-02f, 5.57064749e-02f, 1.72137782e-01f, 2.95992550e-02f, 1.20174393e-01f, -5.93931340e-02f,
  -6.88384026e-02f, -8.07706714e-02f, -5.43657504e-02f, 2.19563767e-02f, 3.00961472e-02f, 8.55091736e-02f, -3.63979000e-03f, 3.38629149e-02f, 2.91218776e-02f, 3.52903642e-02f,
  -4.38455585e-03f, -1.21379271e-01f, -4.24951613e-02f, -1.33746848e-01f, -7.15912208e-02f, 8.93956516e-03f, -2.44223885e-02f, -5.69041306e-03f, -5.59943262e-04f, -7.02184662e-02f,
  -4.85479049e-02f, 5.41750900e-02f, -9.55945626e-02f, 4.86240396e-03f, 4.55344543e-02f, 8.87853354e-02f, -7.44036511e-02f, 2.38825846e-02f, -5.07283919e-02f, 4.57323622e-03f,
  -1.02828696e-01f, -7.50474110e-02f, 4.09123637e-02f, -3.91496755e-02f, 6.23641759e-02f, -7.96744823e-02f, 6.60267621e-02f, 7.35272169e-02f, 3.52293774e-02f, 4.85258400e-02f,
  8.83710533e-02f, -6.32432103e-02f, 7.71276355e-02f, 7.98566453e-03f, -6.28458112e-02f, 7.19749704e-02f, -2.31828894e-02f, -8.41748528e-03f, 1.28220404e-02f, 8.22329000e-02f,
  1.04459468e-02f, -8.36263821e-02f, -6.36800602e-02f, -1.26753068e-02f, -7.14114085e-02f, -6.94094375e-02f, 5.83857968e-02f, 1.52778905e-02f, -1.69075616e-02f, -4.90597486e-02f,
  3.24265435e-02f, 2.38035098e-02f, 3.32030701e-03f, 4.13696319e-02f, -7.20511302e-02f, -5.47446124e-02f, 1.62331220e-02f, -1.15111984e-01f, 1.24956146e-02f, -4.99875343e-04f,
  -1.28951157e-02f, -2.79356595e-02f, 7.78629109e-02f, -4.63227592e-02f, 7.18295574e-02f, 5.41701764e-02f, -6.03138059e-02f, -5.53738400e-02f, -8.67135748e-02f, 8.33799541e-02f,
  1.85155645e-02f, 7.12219849e-02f, -3.53389494e-02f, 2.99583469e-02f, -7.52616897e-02f, -1.49438707e-02f, -5.20969778e-02f, 5.59716485e-02f, -2.95459926e-02f, -2.77734026e-02f,
  3.92650962e-02f, -3.56910191e-02f, 6.54923841e-02f, -6.65387213e-02f, -6.70942515e-02f, -4.40070592e-02f, 7.20560476e-02f, 3.56760400e-04f, 7.05648065e-02f, -5.81900999e-02f,
  -2.32272178e-01f, -1.73814725e-02f, -1.11052297e-01f, 9.25188810e-02f, 1.63291059e-02f, -1.07909322e-01f, -4.44182707e-03f, 3.65462410e-03f, 1.34192154e-01f, -1.62425917e-02f,
  -6.78178594e-02f, 2.22568102e-02f, 5.93039021e-02f, 3.26759815e-02f, -7.03327032e-03f, -2.68229377e-02f, 6.64752126e-02f, -1.51921302e-01f, -7.74127245e-02f, -1.64328814e-01f,
  -6.20266907e-02f, -6.68491349e-02f, 2.78807562e-02f, -5.71363196e-02f, 8.15143511e-02f, 3.66678089e-02f, 6.82901517e-02f, -5.74112050e-02f, -1.02760255e-01f, -7.89452940e-02f,
  -1.57670945e-01f, -1.23000234e-01f, 2.28360202e-02f, -2.63708401e-02f, 5.54790236e-02f, 3.82327326e-02f, 4.49980907e-02f, -4.21744920e-02f, 6.31845668e-02f, -3.44508253e-02f,
  -9.61634293e-02f, 2.51823235e-02f, 1.54774478e-02f, -8.27733241e-03f, -1.73882656e-02f, -1.06904455e-01f, -1.12931804e-04f, -7.26994723e-02f, 2.98067853e-02f, -8.29788111e-03f,
  1.15976539e-02f, -1.15517102e-01f, -7.02096894e-02f, 3.99221368e-02f, -1.09212048e-01f, -1.06199928e-01f, -1.20999105e-01f, -1.59015805e-02f, -1.39578447e-01f, -4.27667797e-03f,
  1.16391834e-02f, -1.25369048e-02f, 5.47196828e-02f, 5.89134581e-02f, 8.32007006e-02f, -4.95102555e-02f, 2.60627121e-02f, -8.07513371e-02f, 1.98589377e-02f, 8.45736489e-02f,
  2.19239350e-02f, 3.84412296e-02f, -2.16826946e-02f, -1.38260135e-02f, -3.62999812e-02f, 6.85230866e-02f, 7.86669552e-02f, -6.62072077e-02f, 4.55690660e-02f, -1.90960113e-02f,
  -1.08579196e-01f, -1.78715009e-02f, -3.75088006e-02f, -6.32796958e-02f, -6.59100786e-02f, 2.63693966e-02f, -5.61322235e-02f, -9.04586166e-02f, 1.02887554e-02f, -2.52948310e-02f,
  1.61237746e-01f, -9.61632282e-02f, -4.99753505e-02f, -1.66016780e-02f, 2.12762803e-02f, -4.53653932e-02f, 4.43925373e-02f, 2.45193802e-02f, -1.22678094e-01f, -1.05067866e-03f,
  -9.74346101e-02f, 1.67700425e-02f, 1.07187862e-02f, -5.70554473e-02f, 9.44738276e-03f, -2.73306128e-02f, 7.83858374e-02f, 3.71770188e-02f, -3.27003039e-02f, 9.38909426e-02f,
  5.55472262e-02f, -1.15598015e-01f, -1.52574956e-01f, -3.72892022e-02f, -1.04160666e-01f, -4.62573916e-02f, -1.35968402e-01f, -1.41738743e-01f, -1.09047130e-01f, 5.07043414e-02f,
  -1.34990767e-01f, -1.70583069e-01f, -3.28441449e-02f, -2.86684986e-02f, 3.93871218e-02f, 1.01702921e-01f, -1.37696285e-02f, 6.78876340e-02f, 6.65398836e-02f, 4.40613888e-02f,
  -1.69214774e-02f, -2.25670561e-02f, -1.74044091e-02f, -6.57375306e-02f, -5.01725897e-02f, -2.43848115e-02f, -7.64923468e-02f, 7.53254537e-03f, 1.29137039e-01f, 1.16520494e-01f,
  -6.89418986e-02f, -5.15572503e-02f, -3.20013985e-02f, 2.48470902e-02f, 4.20172652e-03f, -4.87446524e-02f, -9.75905061e-02f, -5.81620522e-02f, -7.23121539e-02f, -9.36104879e-02f,
  -8.60939641e-03f, -1.02322750e-01f, 9.36505944e-02f, 2.31756307e-02f, -5.46945073e-02f, -1.04176207e-02f, -9.37185511e-02f, 6.21040119e-04f, 3.51547077e-02f, 1.57955196e-02f,
  -8.16085115e-02f, 1.72911100e-02f, -4.76148166e-03f, 4.35460247e-02f, 3.41867693e-02f, -1.50086442e-02f, -7.90092275e-02f, 7.11202770e-02f, 2.86030844e-02f, 3.36547419e-02f,
  3.37537676e-02f, 7.93950334e-02f, 6.38818145e-02f, 7.66455680e-02f, 8.01959783e-02f, 1.94134377e-02f, 3.15760598e-02f, 8.87328237e-02f, -4.75352667e-02f, -3.90665084e-02f,
  -9.86131281e-02f, 3.83637398e-02f, 9.30879936e-02f, 5.73446229e-02f, -1.38409594e-02f, -2.42026206e-02f, 8.48072618e-02f, 3.77765670e-02f, -3.94366346e-02f, 5.04341163e-02f,
  -6.28658980e-02f, -5.47313355e-02f, -7.36260563e-02f, 2.94636078e-02f, -1.53781672e-03f, 3.73189636e-02f, -2.91126762e-02f, -8.40190947e-02f, -6.17908780e-03f, 2.44711787e-02f,
  7.42379725e-02f, 9.26931053e-02f, -1.68373901e-02f, 4.84317765e-02f, -8.96010771e-02f, -5.86170666e-02f, 8.57350528e-02f, 5.69293909e-02f, -3.38757818e-04f, 5.25275543e-02f,
  -6.91229030e-02f, 2.78565623e-02f, 4.89497297e-02f, 2.53867097e-02f, 1.89493597e-02f, -4.09221463e-02f, -2.47629117e-02f, -7.78173879e-02f, -6.35847747e-02f, 5.52330874e-02f,
  -5.65305836e-02f, 1.30586904e-02f, -2.72676293e-02f, 8.86279866e-02f, 7.92000294e-02f, -2.84546036e-02f, -1.50072221e-02f, -6.57519847e-02f, 4.66222130e-02f, -6.66353256e-02f,
  -4.19445783e-02f, 5.87863242e-03f, -5.67613579e-02f, 8.67571235e-02f, 9.08504352e-02f, 9.36913416e-02f, 8.60965550e-02f, -6.24460839e-02f, 8.49412158e-02f, -4.64337543e-02f,
  1.28225073e-01f, 9.92054939e-02f, 7.61197740e-03f, 1.89065591e-01f, 3.13562490e-02f, -1.40703052e-01f, -1.90600261e-01f, -2.23459035e-01f, -1.07257880e-01f, -5.13631152e-03f,
  1.21644504e-01f, -2.97250208e-02f, 6.75778538e-02f, -5.05026020e-02f, -1.23215981e-01f, -1.44401878e-01f, -3.00670490e-02f, 4.66896817e-02f, -1.38657540e-01f, 4.16156985e-02f,
  1.63226053e-02f, 2.57374421e-02f, 9.97473300e-02f, 8.09398517e-02f, 8.89793858e-02f, 1.10400572e-01f, -2.90584303e-02f, 1.21660464e-01f, 1.53354639e-02f, 1.16697103e-01f,
  1.05839066e-01f, -4.99959514e-02f, -1.34425655e-01f, 1.12774603e-01f, -5.15120244e-03f, -7.98424855e-02f, 1.59583930e-02f, -7.99887478e-02f, 3.48051041e-02f, -3.80848497e-02f,
  1.13679938e-01f, -6.86132163e-02f, -5.61984372e-04f, -2.78575905e-02f, -1.11809030e-01f, 2.48066392e-02f, -1.17018536e-01f, 4.47180774e-03f, -1.03368573e-01f, 1.20866587e-02f,
  8.83906335e-02f, 1.10082403e-01f, -5.30148186e-02f, -1.40334010e-01f, -6.47277161e-02f, -4.66740206e-02f, 1.82128400e-02f, 1.56141715e-02f, -4.09506122e-03f, 4.54440005e-02f,
  1.29284998e-02f, -3.93674336e-02f, -4.64127026e-02f, -8.18880349e-02f, 2.22676508e-02f, 1.66595783e-02f, -9.86477286e-02f, 3.14738415e-02f, -8.17241892e-03f, -5.32729812e-02f,
  -8.63814950e-02f, 2.73578614e-02f, 3.39850187e-02f, 1.92644224e-02f, -6.80304598e-04f, -6.67855814e-02f, -1.41004948e-02f, -1.29927276e-02f, 3.91076580e-02f, 1.24573763e-02f,
  9.71770659e-02f, -6.21698871e-02f, -2.34789718e-02f, -7.20050484e-02f, -3.35194380e-03f, 2.74561681e-02f, -1.89386271e-02f, -2.52271350e-03f, 2.49910139e-04f, 8.54075402e-02f,
  -1.14881203e-01f, -2.42527314e-02f, -2.58349702e-02f, -7.06040710e-02f, 8.13466609e-02f, -5.70802651e-02f, -5.53004667e-02f, -2.40500774e-02f, 4.05248664e-02f, -1.38872862e-01f,
  -3.15730609e-02f, -1.05286692e-03f, -1.39537184e-02f, -9.70142055e-03f, -1.11535527e-01f, 3.32326367e-02f, -6.94031939e-02f, 2.63866559e-02f, 2.63623544e-03f, 3.56195122e-02f,
  -8.25486034e-02f, -1.02974102e-01f, -5.62952235e-02f, -7.28216544e-02f, -1.00929260e-01f, -1.19638234e-01f, -7.44988471e-02f, -1.27736226e-01f, -7.42917955e-02f, -7.13438541e-02f,
  2.09394589e-01f, 1.61149189e-01f, 1.31536096e-01f, 1.24837555e-01f, -5.24309538e-02f, 3.55415083e-02f, 8.23654979e-02f, 1.25790507e-01f, 7.89627954e-02f, 9.13498551e-02f,
  9.28492099e-02f, 1.99973453e-02f, 4.79344428e-02f, 5.00057414e-02f, 3.84068303e-02f, 5.88215701e-02f, 4.23661433e-02f, 5.31622320e-02f, 1.03450872e-01f, 1.14022724e-01f,
  -4.06071916e-03f, -4.08459194e-02f, 3.51596996e-02f, 1.22966155e-01f, 8.09294283e-02f, -7.86359459e-02f, 3.00280750e-02f, 5.22102043e-02f, 3.81577983e-02f, -1.59170032e-02f,
  -7.90222883e-02f, 1.32221565e-01f, -8.98438878e-03f, -9.21962708e-02f, 1.58599727e-02f, 5.15463613e-02f, 6.75951466e-02f, 3.28670889e-02f, 4.65939976e-02f, 1.17348917e-02f,
  -1.10432371e-01f, 6.67743906e-02f, -7.77004659e-02f, -6.94216117e-02f, 2.31750198e-02f, 2.27483083e-02f, 6.21817540e-03f, 4.54240069e-02f, -1.43538900e-02f, -7.13159842e-03f,
  -1.11026756e-01f, -1.15405999e-01f, 8.04812610e-02f, -7.51106963e-02f, 1.08374484e-01f, -1.01750359e-01f, -5.39442897e-02f, 1.11467734e-01f, 5.05490182e-03f, 1.08312536e-03f,
  -6.65039718e-02f, 6.67062178e-02f, -7.17141032e-02f, 3.76452133e-02f, 9.08185095e-02f, -2.06257422e-02f, 2.59909872e-02f, -6.77484795e-02f, 8.49031284e-02f, -8.95980746e-02f,
  4.80870120e-02f, 5.33490926e-02f, 1.13836909e-02f, 8.29992518e-02f, -3.87015566e-02f, 4.49161083e-02f, -7.15190619e-02f, 5.68470247e-02f, 7.12361261e-02f, -1.20448448e-01f,
  4.94850650e-02f, 9.28794220e-02f, 2.43119262e-02f, 1.00295372e-01f, -5.66534735e-02f, -2.82939002e-02f, 2.32140534e-02f, -8.66047144e-02f, 3.97274457e-02f, -6.13461202e-03f,
  -1.40324071e-01f, -1.71686023e-01f, -1.02094254e-02f, 6.38945177e-02f, -6.51870668e-02f, -7.00649247e-02f, -5.28425835e-02f, -3.42587903e-02f, 2.25989353e-02f, 2.01733615e-02f,
  -1.81144138e-03f, 5.79137588e-03f, 3.93076017e-02f, -4.64218436e-03f, -7.66571835e-02f, -8.71502012e-02f, -7.78903067e-02f, 5.02431244e-02f, -7.38679171e-02f, -1.09129854e-01f,
  -1.33658603e-01f, 5.68460161e-03f, -5.99241927e-02f, 3.05069517e-02f, -8.46951082e-02f, -2.85302717e-02f, -1.47437528e-02f, -3.06099486e-02f, -6.72989562e-02f, -1.00186937e-01f,
  -3.08357384e-02f, 1.00389048e-01f, 4.29953597e-02f, -1.16721177e-02f, 3.90656032e-02f, 6.78916350e-02f, 1.27965719e-01f, 1.12582654e-01f, 1.53033892e-02f, 6.30924776e-02f,
  -1.79652392e-03f, -2.45146658e-02f, 1.30160928e-01f, 1.50452461e-02f, 1.06447320e-02f, 1.13461636e-01f, 4.38894033e-02f, 6.51676208e-02f, 7.15938956e-02f, 1.23849317e-01f,
  1.17219009e-01f, -4.21823263e-02f, 4.94155623e-02f, -3.53071578e-02f, 1.11669868e-01f, 6.21457025e-02f, -3.49262077e-03f, -4.64595370e-02f, -4.50732820e-02f, 7.07391798e-02f,
  1.02949925e-01f, -7.45292231e-02f, 5.75614125e-02f, -7.91875944e-02f, -1.11206844e-02f, -5.18259630e-02f, 7.11810142e-02f, 2.23312732e-02f, 3.42607908e-02f, -3.96455377e-02f,
  1.40347695e-02f, 4.24200036e-02f, 7.66680529e-03f, -8.45899731e-02f, -9.30385217e-02f, 2.73388717e-03f, -8.97063538e-02f, 5.08184694e-02f, -3.58977402e-03f, 8.15283135e-02f,
  1.51548358e-02f, -3.45603228e-02f, -7.35222315e-03f, -7.45210424e-02f, -3.32172476e-02f, -1.42367501e-02f, -1.68762708e-05f, 4.68033738e-02f, -3.95585075e-02f, -9.36638340e-02f,
  5.64106517e-02f, 4.02426980e-02f, 1.62119363e-02f, 7.86129981e-02f, 1.07909903e-01f, 8.49178210e-02f, 7.59534240e-02f, 5.26902117e-02f, 9.05165598e-02f, 3.50319110e-02f,
  -6.72301650e-02f, -4.34952714e-02f, 8.57848227e-02f, -3.09131225e-03f, 1.03746451e-01f, -1.55211790e-02f, 2.55396869e-02f, -2.50881705e-02f, -6.09052517e-02f, 4.99370843e-02f,
  -6.90075979e-02f, -5.95232621e-02f, 5.47028109e-02f, -1.71647873e-02f, -5.34780063e-02f, -2.54216790e-02f, 8.93713534e-02f, 8.07682499e-02f, -1.01257458e-01f, -7.87125528e-02f,
  -5.95840253e-03f, -1.38486341e-01f, 6.00854382e-02f, -7.78596699e-02f, -4.78474572e-02f, -6.11273162e-02f, -5.96617348e-02f, 2.88577080e-02f, -3.73457707e-02f, -5.51764257e-02f,
  -5.93430102e-02f, -4.56695594e-02f, -4.79712225e-02f, -9.67478156e-02f, 6.46526972e-03f, 4.24293093e-02f, -8.61076452e-03f, 3.30120362e-02f, -8.14202335e-03f, -5.59777627e-03f,
  4.03992012e-02f, -9.98277888e-02f, -7.82223344e-02f, -1.61094666e-02f, -6.02404363e-02f, 1.47268027e-02f, 3.17435339e-02f, -2.06458475e-02f, 5.56200296e-02f, 2.06783327e-04f,
  7.80013204e-02f, -1.21377528e-01f, 2.60333382e-02f, -1.69226266e-02f, 1.31640404e-01f, 8.01825672e-02f, 6.06924780e-02f, 1.02733865e-01f, -2.61278655e-02f, 1.17631601e-02f,
  -2.57148165e-02f, -7.59196505e-02f, -7.92628303e-02f, -5.44402339e-02f, -4.53587659e-02f, -8.55217278e-02f, -7.14288875e-02f, -2.13735364e-02f, 4.37825732e-02f, -2.96338014e-02f,
  6.84298063e-03f, 9.85978097e-02f, -5.69426678e-02f, -1.46884779e-02f, 4.22941297e-02f, 4.34376933e-02f, 3.08788158e-02f, -7.87169486e-02f, -2.51910668e-02f, -2.50670239e-02f,
  1.75538175e-02f, 4.97935787e-02f, 4.84002754e-02f, -4.76784147e-02f, 2.52107941e-02f, -5.49651980e-02f, -6.39964119e-02f, 3.74385603e-02f, 4.24211919e-02f, -7.07431510e-02f,
  -5.53154759e-02f, -2.21673604e-02f, -7.91002288e-02f, -4.06001927e-03f, 4.24036086e-02f, 8.54967907e-02f, 3.10353446e-03f, 2.45911740e-02f, 5.61689399e-02f, -2.23964583e-02f,
  -1.50779545e-01f, -9.19486508e-02f, 1.04247347e-01f, -9.32066813e-02f, -1.10627659e-01f, -5.67495152e-02f, 3.05802729e-02f, -8.06538835e-02f, 6.35958239e-02f, -8.90462194e-03f,
  5.76045457e-03f, 9.10570752e-03f, -1.57703441e-02f, -3.31977918e-03f, 3.04577295e-02f, 4.97839451e-02f, 9.22772735e-02f, 7.80191720e-02f, 5.11849225e-02f, 1.30559364e-02f,
  -1.67096499e-02f, 5.11693321e-02f, -1.30084343e-03f, -7.85577074e-02f, -2.49198377e-02f, -4.75252084e-02f, 1.62593964e-02f, -3.68089601e-02f, -9.04976204e-02f, -1.66233833e-04f,
  -9.87885594e-02f, 5.69948666e-02f, 4.19309698e-02f, 1.27904704e-02f, 5.95189910e-03f, -8.47555622e-02f, -6.80661798e-02f, 3.02696899e-02f, 5.43667339e-02f, -4.48746756e-02f,
  2.43074093e-02f, 1.86410826e-02f, 1.88426785e-02f, -4.41616364e-02f, -2.33176295e-02f, -7.29161724e-02f, -1.21331792e-02f, -9.00936872e-02f, -2.59339660e-02f, -2.35942360e-02f,
  -8.49553570e-02f, 8.40375666e-03f, 3.62877809e-02f, 1.04261078e-02f, 2.52375156e-02f, 8.78720731e-02f, -6.97453767e-02f, -6.96445107e-02f, 4.66626734e-02f, -3.10771987e-02f,
  -3.34785692e-02f, 1.50185749e-01f, 1.28549471e-01f, 6.99602738e-02f, -5.59406064e-04f, 1.56517789e-01f, 3.58904712e-04f, -1.20926993e-02f, 1.27294585e-01f, 1.44915422e-02f,
  -2.50880837e-01f, -5.07409964e-03f, 7.14359209e-02f, -1.33430362e-01f, -7.95267671e-02f, -8.07664618e-02f, -8.24202001e-02f, -9.18401331e-02f, -3.46039273e-02f, -1.14613876e-01f,
  2.46118549e-02f, 3.02658533e-03f, 7.72510320e-02f, -5.18409386e-02f, 2.32396200e-02f, 1.23285905e-01f, 5.24490513e-02f, 1.11396298e-01f, -6.52860031e-02f, 5.81664816e-02f,
  4.35958616e-02f, -6.85886741e-02f, 7.45500103e-02f, 3.81983072e-02f, 2.04165298e-02f, -7.56996963e-03f, 9.91788432e-02f, -2.41671186e-02f, 1.06090896e-01f, 6.46736696e-02f,
  2.88871974e-01f, -1.18488409e-01f, 7.79756252e-03f, 1.09339654e-02f, -3.90506312e-02f, 8.10012668e-02f, -7.77982874e-04f, -7.11053237e-02f, 5.38334437e-02f, -4.25977074e-02f,
  8.85042772e-02f, -6.80157244e-02f, 7.47891292e-02f, 4.92027253e-02f, 4.60206568e-02f, -9.60812047e-02f, 2.62012500e-02f, 1.66488755e-02f, 9.82078612e-02f, 4.80253389e-03f,
  1.82524640e-02f, -6.71264622e-03f, -6.43427223e-02f, 6.61570430e-02f, -1.19451126e-02f, -8.39007795e-02f, 5.76089323e-02f, -1.35076819e-02f, 9.65091065e-02f, -9.56800859e-03f,
  1.01188375e-02f, -4.16734181e-02f, -6.27856404e-02f, -2.62104021e-03f, 2.88833007e-02f, -3.43339518e-02f, -2.88928044e-03f, 3.95153798e-02f, 2.44027805e-02f, -9.93189588e-03f,
  -4.46781423e-03f, -2.07765289e-02f, 3.34059671e-02f, 8.16499889e-02f, 6.02272265e-02f, 2.36928370e-02f, -2.20701434e-02f, 1.77621841e-02f, -9.86314099e-03f, -2.36065313e-02f,
  -3.00972555e-02f, -2.91646365e-02f, 6.36716187e-02f, 1.04261488e-02f, 1.68034770e-02f, -8.52117464e-02f, -5.47481515e-02f, -4.89983745e-02f, -2.15256233e-02f, -3.54306959e-02f,
  1.41860127e-01f, -1.41929397e-02f, 8.25683102e-02f, -6.80115893e-02f, 6.08256087e-02f, 5.69518656e-02f, 6.81908131e-02f, 3.91364619e-02f, -4.12016325e-02f, 5.30632213e-02f,
  2.87341569e-02f, 1.10145397e-01f, 8.86195712e-03f, 4.18061092e-02f, 8.57233927e-02f, -8.11730549e-02f, 7.65445381e-02f, -4.16442901e-02f, 5.85851222e-02f, -1.78349931e-02f,
  5.64582236e-02f, -8.90023261e-03f, 5.90563454e-02f, 8.69012997e-02f, 2.59498763e-03f, 8.76708105e-02f, -1.83470808e-02f, 5.86009547e-02f, -2.98042130e-02f, -6.42476305e-02f,
  -4.67050299e-02f, -1.82120398e-01f, -1.79642141e-01f, -2.54329033e-02f, -7.33208880e-02f, -3.88422720e-02f, -1.02347888e-01f, 1.53885230e-01f, 3.88770327e-02f, -1.11946158e-01f,
  -5.80727309e-02f, -2.19618641e-02f, -1.67310730e-01f, -1.45919129e-01f, -1.43821821e-01f, -9.66049284e-02f, -1.57541201e-01f, -2.10662588e-01f, -1.22247472e-01f, -4.01931964e-02f,
  -8.89645666e-02f, -1.13648154e-01f, -3.10691781e-02f, -8.16920027e-02f, -8.53375345e-02f, -1.87757954e-01f, -1.15633249e-01f, -1.32993937e-01f, -1.44571528e-01f, -1.57238603e-01f,
  -7.44315907e-02f, 8.57224986e-02f, 4.65061553e-02f, -6.26514256e-02f, 2.36864612e-02f, -2.53919605e-02f, -9.40227136e-03f, -2.51385998e-02f, 4.63844202e-02f, 1.79471243e-02f,
  -2.22381838e-02f, 1.06287874e-01f, 8.97703767e-02f, -1.90231036e-02f, 5.44936322e-02f, 1.97228659e-02f, 5.11160567e-02f, -7.89939761e-02f, 3.72803770e-02f, 5.30570559e-03f,
  1.14802402e-02f, -1.03888564e-01f, -1.24690637e-01f, -2.31875703e-02f, 3.83594967e-02f, -1.50778785e-01f, -4.02509384e-02f, -5.06865419e-02f, -9.04416367e-02f, -1.21826291e-01f,
  6.75766394e-02f, -6.26110658e-03f, 5.04986681e-02f, -5.40886112e-02f, 2.21777172e-03f, -9.09991376e-03f, -2.61382870e-02f, 1.03483265e-02f, 4.26688902e-02f, -6.26161769e-02f,
  9.40392390e-02f, 1.62360519e-02f, 7.42618293e-02f, -6.59950376e-02f, 1.74073894e-02f, -5.46478406e-02f, -1.29350787e-02f, -6.16622828e-02f, -1.20985568e-01f, -8.71417001e-02f,
  3.75391543e-02f, 6.97127432e-02f, -1.92906074e-02f, 4.53444235e-02f, 4.90790196e-02f, -7.89746866e-02f, 7.96407312e-02f, 1.83711052e-02f, 1.94112733e-02f, 8.03953633e-02f,
  3.58136073e-02f, -7.17782602e-02f, -7.98573066e-03f, 5.71074486e-02f, -9.14883688e-02f, 5.78052402e-02f, -9.02335048e-02f, 5.63631915e-02f, 8.80116299e-02f, -3.70628610e-02f,
  7.63145462e-02f, -4.98585813e-02f, 2.95730103e-02f, -6.00068225e-03f, -7.92823732e-03f, 8.34869295e-02f, -1.28292084e-01f, -1.44183189e-01f, -3.17536928e-02f, 4.19603698e-02f,
  -5.63627854e-02f, -8.44987705e-02f, -9.77707580e-02f, -8.52850601e-02f, 5.50047727e-03f, -1.58045024e-01f, -1.17869772e-01f, -7.66444132e-02f, -2.07417667e-01f, -1.91060156e-01f,
  -4.26773913e-02f, 8.82462785e-02f, 1.27579063e-01f, -7.59550557e-02f, 2.15667449e-02f, -2.81065330e-02f, 7.60722384e-02f, 1.55260535e-02f, -1.35907546e-01f, 7.94646814e-02f,
  -3.16374078e-02f, 4.51987609e-02f, -6.29490912e-02f, -3.18070054e-02f, -5.98226069e-03f, 1.16208047e-02f, 3.19135524e-02f, 3.80829312e-02f, -9.70792696e-02f, -1.54947042e-01f,
  -1.54579923e-01f, -1.65797785e-01f, -3.01687215e-02f, -9.97646675e-02f, -1.48986829e-02f, -5.16385138e-02f, -1.19916275e-02f, 2.28135698e-02f, -7.35578388e-02f, 2.10132301e-02f,
  7.36118993e-03f, 1.25548825e-01f, 2.75898017e-02f, -3.08718835e-03f, 7.81253204e-02f, -3.16138864e-02f, 5.18749543e-02f, 6.48024157e-02f, -8.09266716e-02f, -3.98616083e-02f,
  1.80146322e-02f, 6.39954656e-02f, 7.16151446e-02f, -1.00040309e-01f, 6.32609874e-02f, -1.03012607e-01f, 1.28591703e-02f, -1.04255542e-01f, 2.19215732e-02f, 4.82402556e-02f,
  -7.04619437e-02f, -1.01879127e-01f, -7.67815635e-02f, -5.42903766e-02f, 7.65167400e-02f, -2.69884206e-02f, 6.70890659e-02f, -9.50622186e-02f, -7.24966228e-02f, -1.60415605e-01f,
  1.48700411e-02f, 8.34171996e-02f, -7.68145248e-02f, 3.20859253e-02f, -5.81662953e-02f, 9.26999450e-02f, 3.63046229e-02f, -5.11574522e-02f, -7.94995762e-03f, -9.88415927e-02f,
  8.05374831e-02f, -6.67576045e-02f, 1.14370948e-02f, -5.71514331e-02f, 4.31732833e-02f, 3.08518205e-02f, -6.75764531e-02f, -7.05951750e-02f, -3.57651873e-03f, -1.07276961e-02f,
  2.61290483e-02f, -8.83863866e-02f, -3.47432159e-02f, 1.27895521e-02f, 7.77176097e-02f, 3.19788307e-02f, 8.57008845e-02f, -1.08453166e-02f, 5.72352558e-02f, -3.03975563e-03f,
  -9.52178910e-02f, 1.73660502e-01f, 3.54347192e-02f, -1.18959077e-01f, 1.51774287e-02f, 4.63183299e-02f, 1.38429403e-02f, 1.00039318e-01f, -3.82228605e-02f, -2.52067838e-02f,
  9.10454318e-02f, 6.17837422e-02f, 7.51800537e-02f, -9.49529931e-02f, -6.41362742e-02f, -1.05049899e-02f, -5.46854809e-02f, -2.66912058e-02f, -1.98338106e-02f, -4.78338897e-02f,
  5.34675606e-02f, 7.33372010e-03f, -2.92509627e-02f, 2.98918374e-02f, -8.64832699e-02f, -7.93550462e-02f, -1.00259043e-01f, 5.94158564e-03f, -7.57334800e-03f, -1.43929303e-01f,
  1.01375528e-01f, -9.62396190e-02f, -3.79295577e-03f, -8.29365999e-02f, -1.58105388e-01f, -6.37928322e-02f, -2.62864865e-02f, -1.99623518e-02f, -6.02519810e-02f, 3.06443889e-02f,
  8.76228809e-02f, 4.07135189e-02f, 1.74254820e-01f, 3.20564434e-02f, 4.67523262e-02f, -5.04148975e-02f, -9.70249325e-02f, -5.92350261e-03f, 8.86799768e-02f, -5.81495576e-02f,
  8.05890486e-02f, 3.02824974e-02f, 3.26984562e-02f, -2.23052893e-02f, -5.61468378e-02f, 1.01354793e-01f, 5.01615778e-02f, -1.01681717e-01f, -1.01602040e-01f, -3.35283950e-02f,
  2.97444999e-01f, -1.80293947e-01f, -7.28638843e-02f, 5.06349206e-02f, -1.23361908e-01f, -1.21765975e-02f, 9.08983126e-03f, -8.14905390e-02f, -7.25578563e-03f, -6.17009290e-02f,
  -5.36298752e-02f, 3.66111174e-02f, 9.38045885e-03f, -5.99869676e-02f, 4.83068414e-02f, 2.93497667e-02f, -9.57308188e-02f, -4.86783162e-02f, -1.44409731e-01f, 4.13160734e-02f,
  2.59590074e-02f, -4.47489396e-02f, -1.08717315e-01f, -2.94360481e-02f, -1.49310930e-02f, -3.74878012e-02f, -1.05543435e-01f, 1.54615548e-02f, -1.25091746e-02f, -5.55109009e-02f,
  2.35194433e-02f, -3.82591896e-02f, 2.68051755e-02f, -3.89921144e-02f, -2.75856964e-02f, -2.05504727e-02f, -9.31608751e-02f, 2.39343066e-02f, -4.77131084e-02f, 4.59159948e-02f,
  6.95782527e-02f, -7.60983452e-02f, -1.26844151e-02f, 3.44230374e-03f, -1.61573682e-02f, 4.59618457e-02f, -4.07499708e-02f, -3.31035890e-02f, 5.14784735e-03f, 3.79499868e-02f,
  1.26459999e-02f, -2.85000056e-02f, 3.42242345e-02f, 2.07364205e-02f, -4.05243970e-02f, 2.12164689e-02f, -5.97425960e-02f, -5.22206649e-02f, 8.32414627e-02f, -5.22748679e-02f,
  3.18375260e-01f, -9.69704837e-02f, 1.24467723e-01f, 3.42784636e-02f, -1.36129424e-01f, -1.13322534e-01f, 7.01690912e-02f, 8.43108445e-03f, -8.61010104e-02f, 7.95347318e-02f,
  3.99725474e-02f, -8.49650875e-02f, -4.83310893e-02f, -1.22653963e-02f, 5.14752083e-02f, 4.30182591e-02f, -6.15635626e-02f, -1.16403420e-02f, 1.75251509e-03f, -3.12675089e-02f,
  -1.01560235e-01f, 4.26545404e-02f, 9.86575633e-02f, 4.77256365e-02f, -7.87941962e-02f, 1.14144422e-01f, 5.58240972e-02f, 3.16548310e-02f, 9.56131145e-02f, 1.35584682e-01f,
  -1.79753914e-01f, 2.93991100e-02f, 1.78469606e-02f, -1.05443738e-01f, -1.33796439e-01f, -4.68785875e-02f, 7.48855025e-02f, 4.01646458e-02f, -6.93077594e-02f, 1.10875480e-02f,
  1.15983978e-01f, 1.87773973e-01f, 1.63567141e-01f, 5.55870347e-02f, 1.05777197e-01f, 5.90018928e-02f, -7.93048590e-02f, -4.39732410e-02f, -2.79084072e-02f, 3.11004817e-02f,
  9.03192908e-03f, -4.19243388e-02f, -7.69952685e-02f, -5.93035035e-02f, -9.42447558e-02f, 8.68586600e-02f, 4.88492437e-02f, 7.82130100e-03f, -2.68989690e-02f, -7.81659409e-02f,
  1.98247626e-01f, -1.34777069e-01f, -3.88971493e-02f, 2.78483611e-03f, 4.30267602e-02f, -5.39814159e-02f, -1.48723070e-02f, -6.44925088e-02f, -1.04930818e-01f, -2.07385831e-02f,
  -7.73563832e-02f, -7.90282413e-02f, -8.14699903e-02f, -5.44294761e-03f, -1.64175816e-02f, 4.64154454e-03f, -3.03536479e-04f, 5.93513576e-03f, -7.57906511e-02f, -4.89726551e-02f,
  1.83871202e-02f, -1.57255083e-02f, 6.55284375e-02f, -5.16963154e-02f, -3.74590494e-02f, -3.63231152e-02f, 3.97558324e-02f, -8.22649598e-02f, 1.57287382e-02f, 5.20995110e-02f,
  -7.81421065e-02f, 1.18654696e-02f, 5.95568959e-03f, -1.71822086e-02f, 6.66255206e-02f, 7.70258624e-03f, 1.76810827e-02f, 8.28086510e-02f, 7.70655647e-02f, -4.42717858e-02f,
  -6.45156652e-02f, 9.14250985e-02f, -1.17758336e-02f, -4.62367833e-02f, -4.70958725e-02f, -8.52363482e-02f, -2.93219294e-02f, -4.80263159e-02f, 7.57863652e-03f, -9.83826816e-02f,
  5.80568984e-02f, -3.60366777e-02f, 2.60253507e-03f, -3.84907275e-02f, -1.07144229e-01f, -8.35852027e-02f, 1.62872509e-03f, 7.31696263e-02f, 6.21536151e-02f, -1.92162413e-02f,
  2.94765085e-01f, -3.67240272e-02f, 8.51880163e-02f, 2.63274089e-02f, -5.36092222e-02f, 6.73164800e-03f, -9.41721871e-02f, 1.02239000e-02f, 2.82437764e-02f, -7.24647269e-02f,
  1.96845923e-02f, 6.12013675e-02f, 9.57451388e-02f, 2.71242354e-02f, 4.66947705e-02f, -3.16321105e-02f, 5.29704243e-03f, -7.67142475e-02f, 1.40658524e-02f, 5.58235263e-03f,
  -2.39034668e-02f, -4.83848713e-02f, 1.47680953e-01f, 6.97218627e-02f, 2.45306678e-02f, -1.72316693e-02f, 1.28333345e-01f, 6.59668744e-02f, -4.40097675e-02f, 1.75516352e-01f,
  2.66087260e-02f, -2.05879379e-03f, 4.62322682e-02f, 1.19492598e-01f, 5.53557165e-02f, 3.87321482e-03f, 5.75784966e-02f, -4.33172956e-02f, -3.23528312e-02f, 3.82413194e-02f,
  1.37831390e-01f, 1.19621642e-01f, -6.25271630e-03f, 1.34471981e-02f, -7.55904466e-02f, -6.66953772e-02f, 4.73488793e-02f, 7.81371966e-02f, -2.56655030e-02f, -1.21064568e-02f,
  5.87637462e-02f, -1.76731404e-02f, -2.32233461e-02f, 2.05997173e-02f, 1.18586980e-01f, 6.81644678e-02f, -4.09414172e-02f, 9.32150707e-02f, 1.60883891e-03f, -4.19256426e-02f,
  2.16857661e-02f, -4.85676527e-02f, 2.64353096e-03f, 6.61795288e-02f, 5.68354782e-03f, -1.11489937e-01f, -8.66268296e-03f, -4.42297421e-02f, -3.01831681e-02f, -6.24556653e-03f,
  4.26438376e-02f, -3.44230682e-02f, 6.75301813e-03f, -7.02118501e-02f, -9.01304707e-02f, -4.00833711e-02f, -6.48429692e-02f, 2.89633349e-02f, 2.45147455e-03f, -4.82011624e-02f,
  6.67007565e-02f, 9.27311853e-02f, -4.47682180e-02f, -3.80016747e-04f, -5.89936227e-03f, 6.13517221e-03f, -6.62050955e-03f, -5.12580648e-02f, -1.21190213e-02f, -1.05287299e-01f,
  1.83980949e-02f, 3.45967859e-02f, -6.13623336e-02f, -4.30731848e-02f, 2.60665510e-02f, 4.89666015e-02f, 5.27540743e-02f, -5.07510155e-02f, 5.83022684e-02f, 4.81834523e-02f,
  -2.72351336e-02f, -2.75319871e-02f, 3.73353884e-02f, 5.65252379e-02f, 2.77659670e-02f, 8.87572542e-02f, -7.32568949e-02f, -6.17251880e-02f, -4.60720398e-02f, -6.42186552e-02f,
  -6.43355539e-03f, -5.31143509e-03f, -3.38318758e-02f, -3.90303321e-02f, -4.52133827e-02f, -3.17010768e-02f, 4.30265367e-02f, -3.31537575e-02f, -3.54010649e-02f, 4.22713719e-02f,
  -4.21586744e-02f, 6.21467419e-02f, 5.91455102e-02f, 3.47579690e-03f, -5.57453372e-02f, -3.40726296e-03f, 6.71273544e-02f, 7.83663541e-02f, -5.57940044e-02f, -1.78944524e-02f,
  7.53060281e-02f, 8.90734885e-03f, -1.94781553e-02f, -5.46872057e-02f, -2.29877476e-02f, -2.95443051e-02f, -6.22459054e-02f, -2.19046837e-03f, 6.07320629e-02f, 3.78518924e-03f,
  6.72998431e-04f, -2.40413733e-02f, -1.39909023e-02f, -1.12597160e-01f, -2.09492602e-04f, -4.50763367e-02f, 3.87550145e-02f, 1.05154347e-02f, -2.72241645e-02f, -5.55690676e-02f,
  -1.74202509e-02f, -9.60269645e-02f, -5.80213964e-02f, -2.39088219e-02f, 6.99134916e-02f, 7.37618878e-02f, -6.10034429e-02f, -2.37375405e-03f, -7.77405873e-02f, -1.56164495e-03f,
  -4.14221138e-02f, 2.58661370e-04f, 4.43087630e-02f, -3.12882327e-02f, 6.63783848e-02f, 2.74456609e-02f, -9.05193985e-02f, -3.61467712e-02f, -6.69224337e-02f, -2.71581262e-02f,
  -5.54337725e-02f, 7.91448355e-02f, -8.99132714e-02f, -1.09640092e-01f, 2.46446370e-03f, -7.53611177e-02f, -1.14053532e-01f, -1.25322253e-01f, -1.33611709e-01f, -4.65583056e-03f,
  -1.50306448e-01f, -5.83577640e-02f, 5.63132726e-02f, 4.65088934e-02f, -9.09910947e-02f, -1.17959315e-02f, 4.78478940e-03f, -4.68816757e-02f, 8.04520324e-02f, -8.04376602e-02f,
  -6.48144335e-02f, -2.12825369e-02f, 5.12550734e-02f, -6.41334131e-02f, 1.07753901e-02f, -7.29043856e-02f, 3.66774723e-02f, -1.08656928e-01f, -5.26161976e-02f, -9.73069444e-02f,
  3.62901799e-02f, 5.03288358e-02f, -1.98027305e-02f, -9.15228724e-02f, 3.72364596e-02f, 6.93414956e-02f, -2.34729256e-02f, 4.14699353e-02f, -1.88714024e-02f, -9.56837367e-03f,
  -3.00500169e-03f, 5.17942905e-02f, -7.96199441e-02f, 8.48329440e-02f, 7.72316009e-02f, -8.67690817e-02f, -3.87960635e-02f, 1.64931677e-02f, -4.91219908e-02f, 2.44990308e-02f,
  -2.96772793e-02f, -9.04699340e-02f, 1.01508439e-01f, -8.36326331e-02f, -2.43529733e-02f, 2.75324062e-02f, -1.96688715e-02f, 7.75652230e-02f, -7.47511629e-03f, 7.24815354e-02f,
  -9.02441889e-03f, -5.99734224e-02f, 8.59675114e-04f, -7.64721781e-02f, 6.69554397e-02f, 6.35336265e-02f, 6.21860214e-02f, 9.28008333e-02f, 3.14996094e-02f, 9.59188789e-02f,
  -6.69118613e-02f, 7.92304650e-02f, -8.88146088e-02f, 2.42591519e-02f, -1.69919766e-02f, 1.88481077e-04f, 4.71346825e-02f, -7.48332543e-03f, -6.13007024e-02f, -3.27253081e-02f,
  -4.25406620e-02f, 5.81886107e-03f, 3.75031307e-02f, 3.92294899e-02f, -3.46292444e-02f, 1.08856961e-01f, 8.45747814e-02f, 1.04823448e-02f, -4.44758423e-02f, -3.92664224e-02f,
  8.17290395e-02f, 7.00640827e-02f, 9.66821834e-02f, -5.57644516e-02f, 3.78727317e-02f, 6.87685683e-02f, 8.15893710e-03f, 4.20147832e-03f, -4.03224006e-02f, 1.20124295e-02f,
  5.15609346e-02f, -1.36228979e-01f, 1.28827810e-01f, 9.62717608e-02f, 1.40297115e-01f, 7.83240423e-02f, -9.12569976e-06f, 1.00007378e-01f, 3.06746550e-03f, -2.46462896e-02f,
  -7.09600449e-02f, 7.16990530e-02f, -6.06103428e-02f, -2.83699092e-02f, -6.72397614e-02f, -4.38424125e-02f, -6.66556656e-02f, 6.68923035e-02f, 1.18457116e-01f, 1.38448793e-02f,
  4.62077931e-02f, 2.00581714e-03f, 8.35217610e-02f, -5.78938834e-02f, 5.67018650e-02f, 1.34714264e-02f, -1.61204282e-02f, 8.17544758e-02f, 4.65418920e-02f, -6.04198053e-02f,
  1.08137697e-01f, -8.09868351e-02f, -2.47157495e-02f, -7.03776851e-02f, -4.06072028e-02f, -9.34517980e-02f, 1.86845306e-02f, -7.73646981e-02f, -9.39389318e-02f, -7.19474852e-02f,
  1.62803587e-02f, 5.36901169e-02f, 7.47485682e-02f, -3.43015827e-02f, 8.62924010e-02f, -3.42450887e-02f, 2.01822519e-02f, -9.93755534e-02f, 2.45990679e-02f, -3.66184376e-02f,
  -5.77641167e-02f, -2.48383787e-02f, -1.53979370e-02f, 7.79723227e-02f, 1.03512369e-02f, 8.43163282e-02f, 2.61187069e-02f, 1.45255784e-02f, -6.81694746e-02f, 2.39307936e-02f,
  -2.72052288e-02f, 6.09158091e-02f, 9.38935354e-02f, -3.47220823e-02f, -3.23178172e-02f, 3.01233120e-02f, -4.51261662e-02f, 8.30011442e-02f, 7.26134405e-02f, 4.37362194e-02f,
  4.24347296e-02f, -5.88154756e-02f, -5.10016307e-02f, 7.93760344e-02f, -5.29613020e-03f, 9.44138169e-02f, 2.38043945e-02f, 6.71971170e-03f, 7.81397447e-02f, -1.79821569e-02f,
  6.29369691e-02f, -1.30796162e-02f, 8.87655467e-02f, 3.98636870e-02f, -1.01536334e-01f, 3.88791002e-02f, 5.84794320e-02f, 7.09545016e-02f, 9.76482639e-04f, -6.97675049e-02f,
  2.43522059e-02f, -5.34592802e-03f, -5.86053729e-02f, -1.04281165e-01f, -3.91399972e-02f, -6.91464404e-03f, -6.50865352e-03f, 6.91918805e-02f, -6.81186765e-02f, 1.50613859e-02f,
  6.15781881e-02f, 3.24872648e-03f, 1.20206119e-03f, -3.52017768e-02f, 7.44910166e-02f, 1.19309863e-02f, -2.74541900e-02f, 2.80722454e-02f, -9.58883613e-02f, -9.37095657e-02f,
  -7.02522555e-03f, 4.33881134e-02f, 1.76287442e-02f, 1.00452445e-01f, -8.24335497e-03f, -1.98131781e-02f, 1.22986324e-01f, 4.47311252e-02f, 1.11280911e-01f, 1.39403537e-01f,
  -1.72672972e-01f, -6.54342696e-02f, -9.51476097e-02f, 6.24666996e-02f, 1.03513993e-01f, -7.24424198e-02f, 6.27695695e-02f, -4.67705866e-03f, 1.53661162e-01f, 8.70622918e-02f,
  1.23561993e-01f, 2.22445786e-01f, 1.10429123e-01f, 1.14142314e-01f, -1.77095868e-02f, 1.50595993e-01f, 4.65901271e-02f, -4.27364409e-02f, 3.34779732e-03f, 1.52017236e-01f,
  1.57927364e-01f, 1.36676177e-01f, 8.89678150e-02f, 4.52477522e-02f, 8.87328833e-02f, 1.32826611e-01f, 3.67327668e-02f, 1.06541574e-01f, 1.03928097e-01f, 1.60468102e-01f,
  -9.56443604e-03f, -1.35240480e-01f, 3.82568687e-02f, -1.83729418e-02f, 4.61763851e-02f, -1.00562908e-01f, -5.55307418e-02f, -1.12979166e-01f, 6.02962896e-02f, 5.65447398e-02f,
  -6.36388035e-03f, -4.86245975e-02f, -1.26562361e-02f, 6.91757575e-02f, -9.03193280e-02f, 8.98753386e-03f, -1.11822255e-01f, 3.99535596e-02f, 3.33628580e-02f, -1.00357994e-01f,
  1.25016630e-01f, 9.99318138e-02f, -1.35137767e-01f, -2.17313990e-02f, -1.49144335e-02f, 1.94451995e-02f, -6.79149181e-02f, 1.70376468e-02f, -1.54143602e-01f, -2.88700983e-02f,
  9.20336619e-02f, 6.02088235e-02f, 8.18352215e-03f, 5.70079908e-02f, 6.08442836e-02f, 6.51457757e-02f, 2.76309270e-02f, 4.27068844e-02f, -3.75479273e-02f, 6.92754164e-02f,
  4.78348732e-02f, 6.68554902e-02f, -2.63846926e-02f, 7.50697926e-02f, 7.19261244e-02f, 2.53010672e-02f, -4.11773622e-02f, 4.64238934e-02f, -4.50861305e-02f, 3.78152262e-03f,
  4.65544593e-03f, 1.02549288e-02f, 2.86174994e-02f, -1.04273222e-01f, 3.40565816e-02f, -1.91644188e-02f, 6.23373985e-02f, -1.65811041e-03f, -2.00105296e-03f, 5.71932867e-02f,
  3.97809371e-02f, -5.69934323e-02f, 4.80435118e-02f, 3.62912044e-02f, -4.56649214e-02f, 4.96871397e-02f, 9.02760699e-02f, -6.20980747e-02f, 9.51796025e-03f, -4.28055972e-02f,
  4.29250970e-02f, -1.04629267e-02f, 3.35578732e-02f, 3.10940724e-02f, -3.07633076e-02f, 4.83259670e-02f, 1.03577182e-01f, -4.42521609e-02f, -2.06378312e-03f, 4.50812727e-02f,
  5.82151599e-02f, -7.32399970e-02f, 3.13128158e-02f, 3.21407765e-02f, 2.24527158e-02f, 5.47902891e-03f, 6.12569489e-02f, -7.42633268e-02f, 7.83567596e-03f, 1.79159213e-02f,
  2.86364645e-01f, -2.93042064e-01f, -3.43387686e-02f, 6.07910007e-02f, -8.28997716e-02f, 5.73882423e-02f, -1.58768922e-01f, -4.71460298e-02f, 2.18926854e-02f, -1.40032440e-01f,
  3.20411357e-03f, 7.04497397e-02f, 1.32392049e-01f, 1.00096628e-01f, 1.11271434e-01f, -1.39170796e-01f, -7.42903501e-02f, 1.63596407e-01f, 9.09378156e-02f, 4.97813299e-02f,
  -1.00721553e-01f, -5.49750067e-02f, 1.32730473e-02f, -9.46652442e-02f, -6.66198283e-02f, -3.84898521e-02f, -5.06914500e-03f, -2.02915389e-02f, -1.61163151e-01f, -1.47228852e-01f,
  -8.41420293e-02f, -3.93446162e-02f, 1.18201047e-01f, 9.78448540e-02f, -8.27228874e-02f, -3.24598104e-02f, -6.94446862e-02f, 5.96281420e-03f, 1.74307392e-03f, 4.30899560e-02f,
  -4.06402089e-02f, -5.03889993e-02f, 4.29866463e-02f, -3.20062712e-02f, -3.87622193e-02f, -2.65196618e-03f, -5.60307726e-02f, 6.53689280e-02f, -3.71325426e-02f, 3.31121683e-02f,
  -4.19501169e-03f, 3.43231559e-02f, 1.49357682e-02f, 2.01196931e-02f, 3.02746687e-02f, 1.49702013e-01f, -1.06233813e-01f, -1.79541688e-02f, 1.99443810e-02f, -6.21466599e-02f,
  1.71636697e-02f, 1.67006664e-02f, 8.73104483e-02f, -7.59848393e-03f, 5.85398003e-02f, 2.13813055e-02f, -2.16253046e-02f, -1.87395103e-02f, -2.86123976e-02f, -1.71034131e-02f,
  1.44943092e-02f, -3.55198383e-02f, -3.10054887e-02f, -2.48818155e-02f, 7.10454956e-02f, -2.48274803e-02f, 7.94030949e-02f, -4.73888367e-02f, -4.78922427e-02f, -4.32742052e-02f,
  6.99389800e-02f, -3.67544331e-02f, 1.72439904e-03f, -8.30723420e-02f, 3.05600613e-02f, 7.05294460e-02f, -5.31453267e-02f, -1.47056475e-03f, -4.01987359e-02f, -2.15576440e-02f,
  1.03609739e-02f, 1.42535374e-01f, -5.08135855e-02f, 1.08224854e-01f, 3.31443138e-02f, -1.68150943e-03f, 2.88678538e-02f, 3.46953329e-03f, 7.96170812e-03f, -8.65104422e-03f,
  -3.93632278e-02f, 1.98614411e-02f, -4.28267494e-02f, -7.47706592e-02f, -1.90093517e-02f, 9.01102647e-02f, 2.03926563e-02f, 7.99377188e-02f, -3.26100886e-02f, 1.29721034e-02f,
  -7.73138031e-02f, 8.27326775e-02f, 9.60675403e-02f, 5.65224588e-02f, -4.05673608e-02f, 7.78187811e-02f, 7.52117932e-02f, -3.95633653e-02f, 9.00626779e-02f, -1.44517913e-01f,
  3.92923467e-02f, 1.78908393e-01f, 4.60164510e-02f, 7.16942176e-02f, 1.93034187e-02f, 1.24108441e-01f, 2.13577941e-01f, 1.01083070e-01f, -4.17582579e-02f, 2.63501406e-02f,
  1.35480119e-02f, -8.02542865e-02f, -3.55306156e-02f, -4.71226871e-02f, -3.61420885e-02f, -4.74937111e-02f, 7.42586851e-02f, -9.24887210e-02f, -5.76339811e-02f, -7.99850523e-02f,
  -9.09269154e-02f, 2.80807242e-02f, -7.47329295e-02f, 6.15637265e-02f, 6.55695722e-02f, -2.38397177e-02f, -2.91609913e-02f, 2.79604737e-02f, 6.75973594e-02f, 2.20987499e-02f,
  -5.34587763e-02f, 1.55515909e-01f, -7.14102983e-02f, -3.25557403e-02f, 1.19229235e-01f, -3.03316042e-02f, -1.53860589e-03f, 3.87667902e-02f, -2.73227226e-02f, -2.56324913e-02f,
  3.62478383e-03f, -4.39253040e-02f, -6.59157634e-02f, -5.44889495e-02f, 5.34934644e-03f, -9.00693052e-03f, -2.66324300e-02f, 5.28472215e-02f, 2.80650295e-02f, 7.49653354e-02f,
  -1.23573029e-02f, 1.28967986e-01f, 1.48331612e-01f, 7.74485767e-02f, -5.04898503e-02f, -3.79160307e-02f, 6.29089624e-02f, -5.91285601e-02f, -5.71082793e-02f, 1.39460638e-02f,
  5.36748543e-02f, 1.14718662e-03f, 3.61060426e-02f, 2.25437526e-02f, 2.88936961e-02f, 7.11023286e-02f, -5.19265346e-02f, 8.81356597e-02f, 6.08500019e-02f, -4.40668724e-02f,
  6.70481399e-02f, -3.80320102e-02f, 6.24461062e-02f, 1.69429015e-02f, -4.81967442e-02f, 1.07001856e-01f, -6.11328371e-02f, -6.22744225e-02f, 6.97868764e-02f, -4.55883928e-02f,
  -6.16931058e-02f, -1.99945401e-02f, -1.38946623e-02f, -7.31419697e-02f, 7.16054738e-02f, 9.06194523e-02f, -6.83895424e-02f, -4.77838032e-02f, 5.32983169e-02f, 3.00238486e-02f,
  -4.52073030e-02f, 2.36340538e-02f, -1.33030146e-01f, -8.21848512e-02f, 2.54576541e-02f, -7.27759376e-02f, 3.66744101e-02f, 5.36451042e-02f, 8.59627053e-02f, -4.75741886e-02f,
  9.19055790e-02f, 6.40547462e-03f, 7.34697804e-02f, 9.39407200e-03f, 8.02433565e-02f, -1.98259261e-02f, -2.33611893e-02f, -5.54634184e-02f, -6.32941723e-02f, -2.27054153e-02f,
  -3.02636111e-03f, 7.80983120e-02f, -2.61204336e-02f, -2.68046353e-02f, 7.32312948e-02f, -6.49438873e-02f, -5.68288714e-02f, -3.06233447e-02f, -9.06059239e-03f, -8.89043510e-02f,
  -1.81286380e-01f, 1.23916872e-01f, 9.00272094e-03f, -3.20804939e-02f, 1.80712640e-02f, -1.17741220e-01f, -1.26007289e-01f, -1.34884879e-01f, -8.01840872e-02f, 3.19063514e-02f,
  9.32311490e-02f, -9.98225361e-02f, -5.76559566e-02f, -1.45183742e-01f, -4.68984172e-02f, 3.26679759e-02f, -1.80522446e-02f, -1.21919475e-01f, -2.05134273e-01f, -2.08567649e-01f,
  -7.93554913e-03f, -7.42693469e-02f, -1.26198515e-01f, -1.04739241e-01f, -3.67424078e-02f, 3.73077616e-02f, 5.77250719e-02f, -4.23943512e-02f, -1.06413864e-01f, 1.00566700e-01f,
  9.84167159e-02f, -1.04888193e-01f, -1.60094559e-01f, -1.39552401e-02f, 4.91576567e-02f, -7.31522292e-02f, -4.93729785e-02f, -4.71511036e-02f, -2.93143429e-02f, 7.18842000e-02f,
  1.29401637e-02f, -1.01900309e-01f, -2.26969458e-03f, -1.00260422e-01f, -7.97025952e-03f, -3.78378518e-02f, 1.88579969e-02f, -1.59542672e-02f, -1.27980247e-01f, -9.61002111e-02f,
  8.14493448e-02f, 3.49114090e-02f, -1.20246001e-01f, -6.27219602e-02f, -5.38681746e-02f, -1.33497223e-01f, 6.55809343e-02f, -1.19827524e-01f, -9.73176062e-02f, -1.38931368e-02f,
  7.04576224e-02f, -7.15363771e-02f, -6.40446395e-02f, -5.87744750e-02f, 9.43071321e-02f, -3.50734070e-02f, -3.00085284e-02f, 1.77733358e-02f, -8.05299878e-02f, -4.14687470e-02f,
  -4.98239845e-02f, 1.29505852e-02f, 6.08315542e-02f, 8.96917358e-02f, 3.69140618e-02f, 3.17259915e-02f, -7.73054212e-02f, 8.62225369e-02f, -1.17407469e-02f, 1.66605972e-02f,
  5.21392711e-02f, 4.78564724e-02f, 6.58391863e-02f, 3.10243713e-03f, 6.67968765e-02f, 6.40929639e-02f, -2.77569070e-02f, -5.88785186e-02f, -6.96943142e-03f, -1.57967466e-03f,
  2.14606598e-01f, -1.40958697e-01f, 1.41485527e-01f, -5.73461615e-02f, -1.07530914e-02f, -4.06602658e-02f, 6.36814209e-03f, 2.79188342e-02f, -1.89728476e-02f, -4.79291081e-02f,
  -5.88776655e-02f, 5.22126779e-02f, 4.53488491e-02f, -2.38104295e-02f, 2.37828121e-02f, 4.05436195e-02f, 1.00727715e-01f, -8.38368163e-02f, -7.00446032e-03f, 5.24162650e-02f,
  -1.13042761e-02f, -5.35854958e-02f, 7.79783204e-02f, 1.11979552e-01f, 2.85962643e-03f, -5.75646013e-02f, 1.06039017e-01f, -5.82834259e-02f, -1.22800142e-01f, 2.02058703e-01f,
  1.24708936e-01f, 1.78691864e-01f, -3.21171582e-02f, -1.78321209e-02f, 7.10026324e-02f, 1.54657541e-02f, 6.44976785e-03f, 7.94923455e-02f, 7.63521418e-02f, 7.59022404e-03f,
  1.28454074e-01f, 5.46997879e-03f, -3.51848565e-02f, -8.34919419e-03f, 3.90065089e-02f, 9.23013128e-03f, -9.98890027e-02f, 1.02121332e-04f, -9.72700715e-02f, 1.15657747e-02f,
  3.65663543e-02f, -4.53555547e-02f, -3.38056870e-02f, -1.46788759e-02f, -1.82996523e-02f, 1.10228635e-01f, -8.29546619e-03f, 9.91039276e-02f, 3.88315320e-02f, 8.37996006e-02f,
  5.40299481e-03f, 1.81599617e-01f, -1.36017591e-01f, 1.11818155e-02f, 2.14778744e-02f, 9.04815504e-04f, -5.57571575e-02f, -5.83976544e-02f, -7.33363330e-02f, -4.47823778e-02f,
  5.41462712e-02f, 3.77020501e-02f, 3.49378251e-02f, 7.28972331e-02f, -7.39836767e-02f, -3.16097103e-02f, 5.64028434e-02f, 1.19894393e-01f, 1.05562909e-02f, -6.27088593e-03f,
  -1.03223175e-01f, 8.51818398e-02f, 3.27773369e-03f, 9.01087075e-02f, 7.36409649e-02f, -4.34275046e-02f, 3.26266065e-02f, 1.10867985e-01f, 1.38170067e-02f, 3.57549749e-02f,
  -9.06773955e-02f, -2.87478138e-02f, -1.19446050e-02f, -2.83262064e-03f, -6.69613183e-02f, 6.36612475e-02f, -9.08973813e-02f, -2.33849362e-02f, -2.48010680e-02f, 5.92057928e-02f,
  -3.37726611e-04f, -6.71295747e-02f, -4.96755950e-02f, 5.99278733e-02f, -1.89919658e-02f, 6.01775572e-03f, -3.58283110e-02f, -7.00998008e-02f, 2.45549306e-02f, 3.79641689e-02f,
  1.38053559e-02f, -7.49082342e-02f, 1.84473023e-02f, 2.49916278e-02f, 3.14011313e-02f, 8.65890365e-03f, -9.09058750e-02f, -3.64548191e-02f, 4.85109799e-02f, -1.75170936e-02f,
  -7.54150003e-02f, -1.39147475e-01f, -6.65504336e-02f, 1.03372633e-01f, 8.21790844e-02f, 1.76446361e-03f, -4.04985622e-02f, 3.31995115e-02f, -5.90139143e-02f, 8.29393696e-03f,
  -5.46012446e-02f, 2.11238824e-02f, 5.64955696e-02f, -4.04467322e-02f, -1.02683522e-01f, 1.92352789e-04f, -2.61801966e-02f, 4.57475819e-02f, -5.79707772e-02f, 2.57242285e-02f,
  -1.05634563e-01f, -8.69154632e-02f, -1.20965786e-01f, -9.80742872e-02f, 8.94987117e-03f, -2.43759844e-02f, -4.05503809e-02f, -3.48305516e-02f, -1.26090935e-02f, -8.46589357e-03f,
  1.15387052e-01f, -1.28597685e-03f, -4.35910225e-02f, 1.07005440e-01f, 2.18174513e-02f, 2.77989097e-02f, -4.95050976e-04f, 3.60658392e-02f, 5.28447852e-02f, 4.11978252e-02f,
  1.31732702e-01f, 6.06661923e-02f, -5.27256019e-02f, 3.77544500e-02f, -7.96786994e-02f, -3.56824603e-03f, -5.41583188e-02f, -3.71986292e-02f, 1.40158646e-02f, 6.95110559e-02f,
  -7.46983141e-02f, 3.31671201e-02f, 4.85229865e-02f, -8.02904367e-02f, 9.03422534e-02f, -4.88267802e-02f, -6.97260946e-02f, -6.33105189e-02f, -1.12696014e-01f, -3.75889651e-02f,
  -8.83323550e-02f, 3.15945260e-02f, 5.32733016e-02f, 3.14475037e-02f, -2.29681749e-02f, 9.82993171e-02f, -6.21413719e-03f, 1.09768145e-01f, 9.96993631e-02f, -2.60469690e-02f,
  -3.41151208e-02f, 7.59107322e-02f, 6.78273141e-02f, 9.35316607e-02f, -3.49951833e-02f, 7.86761269e-02f, 8.75762403e-02f, 6.43756613e-02f, 2.73567587e-02f, 3.56975682e-02f,
  4.07052040e-02f, 6.61794171e-02f, 4.13048789e-02f, 8.42041671e-02f, -4.66249231e-03f, -3.45254764e-02f, -9.09922495e-02f, -9.52145532e-02f, -5.06584272e-02f, -4.05426184e-03f,
  2.06836779e-02f, 5.31086288e-02f, 6.10556453e-02f, 3.67949791e-02f, 4.56721894e-02f, 9.51940343e-02f, 9.37327966e-02f, 5.02474755e-02f, -2.66970973e-02f, 9.13671255e-02f,
  9.93577950e-03f, 2.30269991e-02f, -4.50006388e-02f, -4.22651432e-02f, 1.74097437e-02f, 7.59185478e-02f, 6.14337698e-02f, 5.96483089e-02f, 2.57412512e-02f, 6.73139021e-02f,
  -6.87374771e-02f, 2.22638100e-02f, -1.62711497e-02f, 2.66320668e-02f, 7.85596222e-02f, -4.72652875e-02f, -6.02262206e-02f, -3.61204259e-02f, -1.46233728e-02f, 8.04084316e-02f,
  8.61692727e-02f, -9.68395621e-02f, -4.03692499e-02f, 5.66960946e-02f, -3.96756046e-02f, 1.07399948e-01f, 9.31344926e-03f, 6.82541803e-02f, 3.89405005e-02f, -5.28837591e-02f,
  1.02318439e-03f, -1.42413015e-02f, 7.89911896e-02f, 3.83085571e-02f, 3.80348265e-02f, -7.01094642e-02f, 8.48001465e-02f, 2.43318751e-02f, 3.45317610e-02f, -7.37425685e-02f,
  4.95560421e-03f, 9.00099128e-02f, -5.24941422e-02f, 6.88036680e-02f, 7.60319531e-02f, 9.59523544e-02f, -4.66312021e-02f, 6.58029392e-02f, 2.47752629e-02f, 4.20560315e-02f,
  -1.00287855e-01f, -1.04674891e-01f, -1.05155341e-01f, -5.57208210e-02f, 1.46330027e-02f, 1.00095846e-01f, 2.22641245e-01f, 1.65582865e-01f, 2.02057185e-03f, -2.63332445e-02f,
  -1.14233620e-01f, 8.01526383e-03f, -4.14976589e-02f, 4.85753873e-04f, -3.75270173e-02f, -4.41325270e-02f, 6.38184473e-02f, 5.64504461e-03f, -2.28834385e-03f, 1.18938245e-01f,
  9.47471708e-02f, -2.67703366e-02f, -9.15757492e-02f, -7.30620027e-02f, -9.17067304e-02f, -8.88037980e-02f, -1.10377170e-01f, -2.20542792e-02f, 9.89086184e-05f, -1.12353228e-02f,
  -1.80385396e-01f, -7.19669461e-02f, 1.24843553e-01f, 1.55928191e-02f, -6.36925995e-02f, -5.97584248e-02f, -4.57572080e-02f, -7.00790808e-02f, -5.88070713e-02f, -4.97906581e-02f,
  -6.08551838e-02f, 6.02074079e-02f, -1.47868246e-02f, -8.36213753e-02f, 2.97917286e-03f, 7.90997446e-02f, -8.75705853e-02f, 4.09962907e-02f, -9.49649364e-02f, -9.96627212e-02f,
  -5.52138640e-03f, -2.68199621e-03f, -2.42371131e-02f, -1.90799907e-02f, 3.68264690e-02f, -6.11262508e-02f, -3.77918594e-03f, 3.89638968e-04f, -9.21318587e-03f, -1.02740109e-01f,
  1.04700243e-02f, -4.05422710e-02f, -6.83431327e-02f, 7.44087547e-02f, -3.26184779e-02f, 2.22288091e-02f, 9.99026559e-03f, 4.17724177e-02f, -5.78465946e-02f, -2.03468092e-02f,
  -6.74201325e-02f, 2.62629278e-02f, 1.47844879e-02f, 5.86234964e-02f, -3.30188796e-02f, 7.66536668e-02f, 1.04886733e-01f, 3.61909019e-03f, 4.80405018e-02f, -7.60222971e-02f,
  -6.69240952e-02f, -1.64937973e-02f, 5.09532280e-02f, -7.20421746e-02f, 2.25458406e-02f, -2.89350990e-02f, -7.14706769e-03f, -3.50295529e-02f, 2.20411327e-02f, -5.17938435e-02f,
  -1.81008711e-01f, 6.79449886e-02f, -8.02816376e-02f, -5.51613942e-02f, 1.13186780e-02f, 4.76779081e-02f, -8.58557969e-02f, 1.06859412e-02f, -4.92174886e-02f, 6.43608393e-03f,
  9.99995023e-02f, -2.81650946e-02f, -1.99492532e-03f, -4.00003865e-02f, 1.03454098e-01f, 6.53838217e-02f, 4.89245616e-02f, -5.46122529e-02f, -2.68678684e-02f, 7.79798254e-02f,
  5.40756583e-02f, 9.34839100e-02f, 9.67901051e-02f, -8.19000155e-02f, 4.05253209e-02f, 8.21097419e-02f, -5.52933849e-02f, -1.53449513e-02f, -4.03132709e-03f, -3.92887630e-02f,
  -3.38655055e-01f, 9.89572629e-02f, 4.56544161e-02f, 4.53166589e-02f, 2.54359394e-01f, 1.60778984e-01f, 2.57549375e-01f, 4.60182503e-02f, 2.13307273e-02f, 3.55325304e-02f,
  -2.65419763e-02f, -7.05321599e-03f, 3.46580707e-03f, -1.17552064e-01f, -3.20694372e-02f, 6.87424019e-02f, 1.79094255e-01f, -5.36611769e-04f, -1.20909519e-01f, 4.90724063e-03f,
  4.49803062e-02f, -6.44370308e-03f, -2.17973918e-01f, 5.08575328e-02f, 2.10383441e-03f, 8.18787217e-02f, 1.79867316e-02f, 9.60312337e-02f, 1.04306482e-01f, 1.34088308e-01f,
  -1.41874015e-01f, -1.36402950e-01f, -5.43325245e-02f, -1.21045504e-02f, -7.29977116e-02f, -1.46019965e-01f, -3.33304680e-03f, -3.84340025e-02f, -5.21924645e-02f, 2.06599906e-02f,
  5.21235280e-02f, -1.13249850e-02f, 7.45370165e-02f, -9.60577875e-02f, -1.34010136e-01f, -1.13413975e-01f, -3.36597450e-02f, -1.98841602e-01f, -1.34326637e-01f, -1.29555076e-01f,
  8.22762251e-02f, -1.05028534e-02f, -3.12365592e-02f, -1.19746504e-02f, -6.50567040e-02f, -7.36042159e-03f, -8.33595917e-02f, -1.09702796e-01f, -1.68258548e-01f, -2.94563062e-02f,
  3.21270376e-02f, -3.76751088e-02f, 3.43562998e-02f, -4.07112502e-02f, -5.55693218e-03f, 9.32809860e-02f, -3.11008040e-02f, 1.08430415e-01f, -5.97523339e-02f, -6.32889420e-02f,
  6.95108101e-02f, -9.94227156e-02f, 4.69901524e-02f, -4.78919968e-02f, 3.42760533e-02f, -1.75263025e-02f, 9.65701491e-02f, 5.71078025e-02f, 2.71088537e-02f, -7.96208754e-02f,
  -4.73889671e-02f, -9.47303474e-02f, -1.14855068e-02f, -9.79246385e-03f, -3.10746748e-02f, 6.48904219e-02f, -4.24759015e-02f, 3.92779009e-03f, -3.62251769e-03f, 1.37069179e-02f,
  -1.81217819e-01f, -7.19610229e-02f, -7.50281960e-02f, -9.54368562e-02f, -6.55072625e-04f, -6.13128096e-02f, -2.17817426e-02f, -7.04031512e-02f, -5.26460335e-02f, -1.09451730e-02f,
  5.52819297e-02f, -7.92681724e-02f, -4.68769222e-02f, -8.50539133e-02f, -7.54347071e-02f, 7.97630101e-03f, -3.32437195e-02f, -5.79533540e-02f, -1.21672750e-01f, -2.43181903e-02f,
  3.64055783e-02f, -3.67350061e-03f, 2.11455505e-02f, 1.09804980e-02f, -1.29823266e-02f, -9.26623121e-02f, 1.37652485e-02f, -8.61684605e-02f, -4.81414162e-02f, -9.67051610e-02f,
  2.79352218e-02f, 1.89341277e-01f, -2.41068348e-01f, -4.15292941e-02f, -4.54944819e-02f, -1.09746590e-01f, -7.40330219e-02f, -3.28914961e-04f, 1.08471856e-01f, 5.88560589e-02f,
  1.23707543e-03f, -3.28174978e-02f, -2.82851923e-02f, -4.96059889e-03f, -1.24931410e-01f, -3.54647748e-02f, -5.89042495e-04f, -1.98063523e-01f, -1.37399942e-01f, -1.63173079e-01f,
  4.78197820e-02f, 9.56780761e-02f, 3.75159159e-02f, 4.69799787e-02f, -3.30569632e-02f, -9.64384992e-03f, 2.36996748e-02f, -5.36580160e-02f, -1.41503483e-01f, 1.94402959e-03f,
  -1.63427815e-01f, -1.71719983e-01f, -1.28965810e-01f, -1.73017327e-02f, -3.60711105e-02f, -8.92922729e-02f, 9.21559706e-03f, -4.37653586e-02f, -9.21548065e-03f, -1.12317339e-01f,
  -6.51024580e-02f, 3.11253816e-02f, 1.10042933e-02f, -8.53315219e-02f, 2.90820245e-02f, -9.04020388e-03f, 7.07368075e-04f, -1.23175934e-01f, -5.35107516e-02f, -8.18516091e-02f,
  1.64151210e-02f, -5.50067285e-03f, -5.83654419e-02f, -4.47899885e-02f, -1.42657295e-01f, -1.20788373e-01f, -9.46899280e-02f, -4.41467613e-02f, -1.73616722e-01f, 8.76095071e-02f,
  6.91973791e-02f, 5.65120112e-03f, 6.02397993e-02f, -3.21532264e-02f, -3.16971689e-02f, -2.75685992e-02f, -4.77998331e-02f, 2.52461643e-03f, 6.53604195e-02f, 1.07685044e-01f,
  7.62149170e-02f, -5.03539033e-02f, -8.41313154e-02f, 9.35757607e-02f, 3.95558216e-03f, -3.42134461e-02f, -2.43020430e-02f, 1.43463416e-02f, -1.30418455e-02f, 1.18349155e-03f,
  1.95145495e-02f, -4.29552160e-02f, -2.96253357e-02f, 4.48176712e-02f, 8.18222687e-02f, 6.97194561e-02f, -6.55952245e-02f, -9.00506526e-02f, -8.05307478e-02f, 8.94448906e-03f,
  1.16824515e-01f, -7.19844177e-02f, 1.80367231e-02f, -6.89011216e-02f, -7.19827134e-03f, -3.69178392e-02f, 4.31383327e-02f, 9.75512248e-03f, 8.33765790e-03f, -8.01681131e-02f,
  -1.15368694e-01f, -6.26750803e-03f, 2.93499846e-02f, -9.66413319e-02f, -8.04894716e-02f, 2.76177353e-03f, 5.91740794e-02f, 6.69821352e-02f, -1.79462973e-02f, -4.48685586e-02f,
  1.01269610e-01f, 5.37142977e-02f, 3.35885882e-02f, 2.85240635e-02f, 6.87193051e-02f, 3.24884919e-03f, -2.33429689e-02f, -2.52119135e-02f, -6.37153862e-03f, 1.74696147e-01f,
  2.73111045e-01f, 9.96773690e-02f, 1.18241183e-01f, 1.78727031e-01f, 1.63657978e-01f, 1.76092848e-01f, 2.35777542e-01f, 1.05095655e-01f, 3.57289985e-02f, 8.63448381e-02f,
  1.50786862e-01f, 4.64028753e-02f, 2.47122981e-02f, 3.08320001e-02f, 9.18947980e-02f, 7.64675066e-02f, -7.57782161e-02f, 8.44955668e-02f, 8.97805393e-02f, -5.68888038e-02f,
  -4.68400260e-03f, -1.17870504e-02f, 8.20610151e-02f, -8.18879530e-02f, -1.62038524e-02f, -1.05246585e-02f, 7.79528618e-02f, -3.66366357e-02f, -9.86190047e-04f, -1.09721467e-01f,
  -2.78354939e-02f, 2.11282417e-01f, -7.13829994e-02f, -1.48872416e-02f, -4.16807160e-02f, -5.27297482e-02f, 5.42486049e-02f, -5.86627759e-02f, 2.06463411e-02f, -1.17781363e-01f,
  -1.64957009e-02f, -8.24043378e-02f, -7.56050972e-03f, -5.00497110e-02f, 3.63588370e-02f, 5.44693172e-02f, -4.26610336e-02f, 3.83020304e-02f, -7.07613155e-02f, -5.70945702e-02f,
  -5.64367212e-02f, 4.41642553e-02f, 1.25612259e-01f, -2.84664147e-02f, -1.54070593e-02f, 5.98994363e-03f, 8.68714750e-02f, 1.52386297e-02f, 9.60753635e-02f, -1.65366922e-02f,
  -1.85870845e-02f, 3.81058082e-02f, 3.16433096e-03f, -5.53472452e-02f, -3.97867151e-02f, -1.02738023e-01f, -3.66405696e-02f, 1.98033303e-02f, -2.03352533e-02f, -2.02698610e-03f,
  -2.63051130e-03f, 9.14589390e-02f, 5.34469374e-02f, 6.84758425e-02f, -7.70538449e-02f, -5.88812642e-02f, 2.33549457e-02f, 6.51724695e-04f, 4.24420722e-02f, 8.20189193e-02f,
  -2.47261040e-02f, 4.35542092e-02f, 3.38734426e-02f, -4.36413176e-02f, 4.86713313e-02f, -2.54787151e-02f, 1.96355246e-02f, 6.07216768e-02f, 5.08939624e-02f, 5.76060340e-02f,
  -3.30080800e-02f, 6.49594814e-02f, -2.46981569e-02f, -9.29850861e-02f, -5.66379353e-02f, 2.56395303e-02f, 3.24764326e-02f, 2.07599881e-03f, -7.38654137e-02f, 2.97713690e-02f,
  4.98959236e-02f, -2.18635481e-02f, 3.82548608e-02f, -4.53198887e-02f, 3.13302539e-02f, 3.81979272e-02f, -3.78709473e-02f, -4.44142893e-02f, -1.69732347e-02f, -3.01248245e-02f,
  -3.99662033e-02f, -4.89544235e-02f, -1.50402002e-02f, -7.33799189e-02f, 5.59321865e-02f, 2.12884489e-02f, -6.94820955e-02f, 3.88258100e-02f, 7.44584501e-02f, -1.13649540e-01f,
  1.67604685e-01f, 2.19628531e-02f, 5.41265905e-02f, 3.44045050e-02f, 1.36470199e-01f, 5.40837100e-05f, 8.33426490e-02f, 4.37253118e-02f, 2.90671121e-02f, -2.26746965e-02f,
  -9.39810649e-02f, -3.22422944e-02f, -1.44188121e-01f, -1.47388428e-01f, -2.45235972e-02f, 6.46931157e-02f, 1.33477107e-01f, -5.70151908e-03f, 5.63901290e-02f, 2.69463137e-02f,
  1.23431742e-01f, 2.02713622e-04f, 1.17227010e-01f, -8.27286392e-03f, 7.09067145e-03f, -1.39466021e-02f, 7.58724462e-04f, 5.38312979e-02f, -6.42705634e-02f, 8.17761421e-02f,
  -1.42177135e-01f, -7.27457106e-02f, -7.26388469e-02f, -5.82629181e-02f, -1.18219264e-01f, 5.98644838e-02f, -8.46831724e-02f, -9.69360024e-02f, 2.26074774e-02f, 3.28708887e-02f,
  -1.15095846e-01f, -1.45175029e-03f, 7.64732808e-03f, 5.37149459e-02f, 6.06149547e-02f, -2.72158254e-03f, 1.72589514e-02f, -9.14576650e-03f, 4.81382757e-02f, -1.07618093e-01f,
  -6.54027015e-02f, 5.61527424e-02f, 3.54692675e-02f, -4.80212718e-02f, -8.10173750e-02f, -8.21878612e-02f, 1.32422494e-02f, -7.57498667e-02f, 5.04357815e-02f, 6.58732429e-02f,
  -4.51675337e-03f, 7.71194100e-02f, -9.93957594e-02f, -5.50199524e-02f, -1.51210027e-02f, -6.12947196e-02f, -4.31249179e-02f, 7.73390606e-02f, 6.99043646e-02f, 5.28676175e-02f,
  -5.79362884e-02f, 3.92513396e-03f, -7.25333691e-02f, 4.05021273e-02f, 2.12126989e-02f, -4.77065425e-03f, -7.17843249e-02f, 5.12639545e-02f, -2.25174706e-02f, 6.49634674e-02f,
  9.00097564e-03f, -7.91153461e-02f, -4.05129381e-02f, -3.19806598e-02f, 6.79007247e-02f, 4.78581414e-02f, -5.65551408e-02f, -3.69694233e-02f, 2.32837610e-02f, 5.03573120e-02f,
  -1.93815213e-02f, -1.78198829e-01f, 2.63814093e-03f, 5.08428551e-02f, -6.97107911e-02f, -1.10927515e-01f, -6.42103776e-02f, -9.15967748e-02f, -1.05573982e-01f, -4.91901115e-02f,
  3.19588743e-02f, 3.00256629e-02f, -1.13960154e-01f, -7.23932013e-02f, -3.09788790e-02f, 8.05972368e-02f, 1.77665446e-02f, 1.00095384e-01f, -9.96172130e-02f, -5.14417887e-02f,
  6.25784695e-02f, 1.22748226e-01f, -1.49712767e-02f, -3.44076492e-02f, -1.77074075e-02f, 6.81155249e-02f, 4.08172123e-02f, 1.13516316e-01f, -6.16249219e-02f, 2.02576835e-02f,
  8.77960026e-02f, -2.31559132e-03f, -8.97433981e-02f, 7.20534921e-02f, 1.81279451e-01f, -1.05013356e-01f, -4.93262224e-02f, -4.14793827e-02f, -4.76054549e-02f, -1.33022934e-03f,
  1.87107742e-01f, 4.03104536e-02f, 9.78070647e-02f, 7.10948464e-03f, -1.57555282e-01f, -1.75834045e-01f, -4.74303146e-04f, -7.57481754e-02f, -1.19463004e-01f, 1.17131658e-01f,
  1.45959109e-01f, -1.16534717e-03f, 1.09708101e-01f, 1.89130325e-02f, 2.16237940e-02f, 1.36676639e-01f, -6.16309345e-02f, -5.05473511e-03f, 3.06928754e-02f, 6.90346435e-02f,
  -1.60438661e-02f, -9.59331694e-04f, -1.06490925e-01f, -1.45250624e-02f, 4.60789390e-02f, 3.57128344e-02f, -7.99510106e-02f, -9.84519422e-02f, 3.67460921e-02f, -8.61410052e-02f,
  8.21820926e-03f, -5.26676774e-02f, 3.19387466e-02f, 1.34871593e-02f, 1.53139327e-02f, -2.49281731e-02f, -1.47753000e-01f, -1.11062042e-01f, -1.26286089e-01f, -1.08750761e-02f,
  1.50258720e-01f, 8.42500478e-02f, -4.16916348e-02f, -1.55378997e-01f, -6.32776245e-02f, -6.76806048e-02f, 2.19059326e-02f, -9.09653099e-05f, -1.08890608e-01f, -4.49479073e-02f,
  8.64648148e-02f, -4.23888117e-02f, 6.80414885e-02f, 2.02389956e-02f, 2.28086077e-02f, -5.81268184e-02f, 3.36799175e-02f, 3.76436450e-02f, 1.69025268e-02f, 1.78244244e-02f,
  2.01096889e-02f, -2.27374341e-02f, -2.38701999e-02f, -8.82327035e-02f, 7.03114420e-02f, 3.90671603e-02f, -2.35745646e-02f, -2.07696203e-02f, -5.85648678e-02f, 4.62832265e-02f,
  -4.12704609e-02f, -3.45321037e-02f, 5.73336221e-02f, -5.26163019e-02f, 5.95634384e-03f, -8.14040527e-02f, -1.82874352e-02f, 1.01148142e-02f, -1.79732516e-02f, -4.86504324e-02f,
  7.88573846e-02f, -4.26004976e-02f, 6.66636368e-03f, -1.12808421e-01f, 1.88975297e-02f, -8.00342858e-02f, -8.18226114e-02f, -1.21037580e-01f, -2.32882705e-02f, 8.85348767e-03f,
  1.17667932e-02f, 3.82887460e-02f, 1.00986129e-02f, -8.54604170e-02f, 3.23217809e-02f, -8.07725713e-02f, 1.34978602e-02f, -8.15314204e-02f, -4.58803810e-02f, 2.06935611e-02f,
  -9.78355631e-02f, -3.27675976e-02f, -2.87847463e-02f, -1.83358222e-01f, -1.24818809e-01f, 4.34303619e-02f, -1.08121686e-01f, -5.47056124e-02f, -2.12999046e-01f, -1.03845119e-01f,
  2.96409853e-04f, -3.34756784e-02f, 3.24303173e-02f, 5.85439801e-02f, 4.18137014e-02f, -5.56108057e-02f, 7.48974308e-02f, 2.25117840e-02f, 2.08480787e-02f, 7.00137615e-02f,
  -3.70989298e-03f, 7.03216419e-02f, 7.01175481e-02f, 1.68249514e-02f, 9.80836004e-02f, 1.47330035e-02f, -7.61905834e-02f, 4.94805276e-02f, -3.29280458e-03f, 5.39627187e-02f,
  -7.61103630e-02f, 2.88019516e-03f, -5.65778427e-02f, -1.00721549e-02f, -4.83843461e-02f, -2.39105546e-03f, 2.60436404e-02f, 1.57191344e-02f, -3.65542769e-02f, 3.92066920e-03f,
  -2.23190919e-03f, -5.81013504e-03f, -1.22633651e-02f, -1.76732219e-03f, 3.77326868e-02f, -3.75966877e-02f, -7.05804396e-03f, 1.58049539e-02f, -5.30668162e-02f, 5.97802363e-02f,
  -3.30048986e-02f, -3.73188709e-03f, -5.23539297e-02f, 7.88380504e-02f, 1.61610916e-02f, -1.08565912e-02f, 9.13692564e-02f, 9.18372124e-02f, 8.06829333e-02f, -2.36873925e-02f,
  3.74820530e-02f, -5.98740131e-02f, 5.88022731e-02f, -3.59168611e-02f, 4.31601591e-02f, -6.18289551e-03f, -7.92510509e-02f, -7.30019286e-02f, -5.56483045e-02f, 1.00114644e-02f,
  4.04769033e-02f, 6.61548600e-02f, -5.69736063e-02f, 3.25387418e-02f, 8.19590613e-02f, -3.08923852e-02f, -2.82443855e-02f, -5.28019555e-02f, -1.49952760e-02f, -2.57820319e-02f,
  6.87534139e-02f, -6.62487894e-02f, 8.80346298e-02f, -2.04448681e-02f, 1.63885970e-02f, 6.77722320e-02f, -6.46406114e-02f, 2.55380552e-02f, -7.26507530e-02f, -7.61942714e-02f,
  -4.93813888e-04f, -1.77566949e-02f, -3.28631997e-02f, -3.38144936e-02f, -4.00535464e-02f, -2.25381963e-02f, -7.36065730e-02f, -5.59236854e-02f, 2.25470643e-02f, -6.05489649e-02f,
  -4.17983346e-02f, 5.55687994e-02f, 6.06120192e-02f, 2.05437280e-02f, 1.69970971e-02f, -6.19976781e-02f, 1.62798055e-02f, -6.86683953e-02f, 8.38445500e-02f, 1.03414819e-01f,
  -6.07054532e-02f, -6.86545148e-02f, -5.58872661e-03f, 6.24323077e-02f, 2.43055783e-02f, 8.56557488e-02f, -7.20267892e-02f, 5.47519252e-02f, 1.30780844e-03f, 5.48679195e-02f,
  5.86866355e-03f, 8.85472000e-02f, -1.07385963e-02f, 4.25608456e-02f, 2.84466892e-02f, 2.30961153e-03f, -7.51281902e-03f, 3.04845534e-02f, 4.96896841e-02f, -3.28241885e-02f,
  -2.31012225e-01f, -1.56198844e-01f, -8.97845253e-02f, -1.45014152e-01f, -4.36579101e-02f, 3.95575128e-02f, -2.03651637e-02f, 2.91080847e-02f, -2.88749617e-02f, -9.56214741e-02f,
  -6.65867552e-02f, -7.93728307e-02f, -3.48583423e-03f, -1.02062061e-01f, -1.11899272e-01f, -1.30760968e-01f, 7.85858277e-03f, -1.18844062e-01f, 1.76677492e-03f, -5.66673465e-02f,
  -4.67059053e-02f, -1.41471371e-01f, -5.57219647e-02f, 4.26126420e-02f, -1.09775521e-01f, -4.81085293e-02f, -4.93278094e-02f, -7.47664496e-02f, 3.42246448e-03f, -1.01775743e-01f,
  2.22228207e-02f, 5.31381406e-02f, -1.49345677e-02f, -4.60807271e-02f, -2.53882781e-02f, 3.39729674e-02f, -2.21024640e-02f, -7.61564001e-02f, -2.66328771e-02f, 2.50814874e-02f,
  -1.99311320e-02f, 3.11711468e-02f, 1.96542144e-02f, 5.13963327e-02f, 5.97465634e-02f, 7.46890455e-02f, 1.25750862e-02f, -5.75074218e-02f, 1.23388069e-02f, -8.87330621e-03f,
  -2.56963130e-02f, -6.09753132e-02f, -1.05514325e-01f, 7.78465718e-02f, 2.40040738e-02f, -9.10052434e-02f, 7.41704032e-02f, -2.92747598e-02f, -3.80723663e-02f, -3.77895944e-02f,
  -4.08519953e-02f, -2.94128712e-02f, -4.43847757e-03f, -9.83240735e-03f, -2.72733215e-02f, -1.91396195e-02f, -5.35541512e-02f, -7.58091658e-02f, 5.27453125e-02f, 4.76211484e-04f,
  -4.56919409e-02f, 4.16049763e-04f, 7.26311728e-02f, -1.02237356e-03f, 5.62083907e-02f, 6.70547411e-02f, 1.62071362e-02f, 3.97819839e-02f, -3.05164475e-02f, -1.01316273e-02f,
  -9.90643632e-03f, -5.61261624e-02f, 3.78725491e-02f, 2.87766643e-02f, 9.52010304e-02f, -8.89999792e-02f, 6.66884929e-02f, -6.28732592e-02f, -6.26433715e-02f, -6.30627573e-02f,
  -8.97119567e-02f, 6.26908541e-02f, 1.71473306e-02f, 2.23418828e-02f, 1.68298241e-02f, 1.47659536e-02f, 4.88932990e-02f, -6.57469928e-02f, 3.72302197e-02f, -6.13494702e-02f,
  3.41567621e-02f, -4.40707579e-02f, -1.32972047e-01f, 2.55236626e-02f, 4.21118028e-02f, 1.12088118e-02f, -5.15430309e-02f, -1.33649036e-01f, 4.17331383e-02f, -4.31666151e-02f,
  -6.86972663e-02f, -5.21233007e-02f, -7.68074840e-02f, 2.01752293e-03f, -4.93877009e-02f, -1.35791168e-01f, -1.21231817e-01f, -4.58993986e-02f, -1.00545868e-01f, -5.86325303e-02f,
  5.93334660e-02f, 1.27321303e-01f, 2.53024876e-01f, -5.53253368e-02f, -7.45843053e-02f, 7.45055676e-02f, 3.02564241e-02f, -5.15611768e-02f, 2.03487538e-02f, -1.19403964e-02f,
  -8.38758349e-02f, -1.08939163e-01f, -1.11194216e-01f, -1.65966507e-02f, 1.01843297e-01f, 2.44132802e-02f, 4.86083515e-02f, 1.08508244e-01f, 4.35614511e-02f, -5.32893464e-02f,
  -8.17734897e-02f, -3.16681229e-02f, 5.28047532e-02f, 7.63949603e-02f, 4.71211644e-03f, -5.53241335e-02f, 1.33280635e-01f, 8.79007205e-02f, 8.10610652e-02f, -6.22668229e-02f,
  -9.92627218e-02f, 9.26564261e-02f, -1.04760855e-01f, 1.44121675e-02f, -2.34258603e-02f, 4.47032265e-02f, -3.72767709e-02f, 1.07007496e-01f, 2.31504403e-02f, -6.19676933e-02f,
  -4.78033088e-02f, -4.07097256e-03f, -3.45977284e-02f, 1.06737586e-02f, 7.42518082e-02f, -1.23556089e-02f, 6.76396862e-03f, 3.68414782e-02f, 9.29602087e-02f, -7.58834630e-02f,
  -1.31243551e-02f, 1.86287854e-02f, 6.87601268e-02f, 9.45329368e-02f, 3.41462791e-02f, 2.27177050e-02f, 1.21439090e-02f, -5.18470742e-02f, -4.60110120e-02f, 3.28054279e-02f,
  -7.76663274e-02f, 8.59299526e-02f, 8.36153999e-02f, -6.80931807e-02f, 1.16304830e-02f, 4.00659554e-02f, -4.76974919e-02f, 1.97396893e-02f, 1.57505814e-02f, -5.55232242e-02f,
  8.58410895e-02f, -6.14201277e-02f, 9.75618586e-02f, -4.77886610e-02f, -4.82519343e-02f, 7.28878081e-02f, -7.75667047e-03f, -9.73388031e-02f, -5.80319809e-03f, 9.37027857e-04f,
  -4.85538840e-02f, 2.18731984e-02f, -5.98477898e-04f, 2.24558334e-03f, 4.65172641e-02f, -7.72371888e-02f, 4.11485359e-02f, -3.33441496e-02f, 6.20727353e-02f, -9.39809009e-02f,
  -5.02217039e-02f, 3.80079336e-02f, -1.16369456e-01f, -1.06000192e-01f, 8.85957666e-03f, -3.57554257e-02f, -6.86844215e-02f, 7.91680738e-02f, 5.65655343e-02f, 4.25547473e-02f,
  1.97048411e-02f, -4.84890752e-02f, -5.41244671e-02f, -5.17228469e-02f, -4.79195714e-02f, -3.18893194e-02f, -6.07997701e-02f, 2.99667399e-02f, -9.46132466e-02f, -5.51956557e-02f,
  3.97284105e-02f, 4.64933924e-02f, -6.72167689e-02f, -5.36920503e-02f, -7.84634985e-03f, -6.54757321e-02f, 2.78918864e-03f, 3.66171598e-02f, 1.24477027e-02f, -8.56437837e-04f,
  2.15521261e-01f, 7.40543231e-02f, 2.52747652e-03f, 4.14743051e-02f, 1.81225557e-02f, 7.94879943e-02f, 2.85270326e-02f, -1.85115375e-02f, 2.96028219e-02f, 6.52846992e-02f,
  1.81016073e-01f, 8.84357840e-02f, 1.06767423e-01f, 6.02580756e-02f, 1.32780001e-01f, 4.48042993e-04f, -1.39900029e-01f, 3.67899761e-02f, -6.09804615e-02f, 4.33598906e-02f,
  3.19018327e-02f, -7.56745646e-03f, 2.88790055e-02f, -4.44082841e-02f, -1.21797755e-01f, 2.18590628e-02f, -6.67892322e-02f, -1.00693248e-01f, -9.12879407e-02f, -1.45831496e-01f,
  -7.71123692e-02f, -3.63638904e-03f, 1.75024644e-02f, 3.80306062e-03f, -6.59564435e-02f, 3.74235958e-02f, -3.78987473e-03f, -1.01622625e-03f, -5.14040701e-04f, -4.02345993e-02f,
  3.72104230e-03f, 6.40169382e-02f, 1.01949587e-01f, 6.92032054e-02f, -6.17967620e-02f, -5.72133530e-03f, 6.66633770e-02f, 6.42518923e-02f, 6.25832081e-02f, 1.78893134e-02f,
  5.68045340e-02f, -6.88957721e-02f, 1.12829953e-01f, -5.78477159e-02f, -2.46884432e-02f, 1.20736100e-01f, 3.58263068e-02f, 8.58319774e-02f, -3.05507239e-02f, -6.55715121e-03f,
  6.87385499e-02f, 1.59168076e-02f, 3.42214964e-02f, 7.00834244e-02f, 2.37086844e-02f, 1.68546252e-02f, -4.64867614e-02f, 6.71394914e-02f, -1.12852184e-02f, -5.03791645e-02f,
  8.51910736e-04f, 8.77912939e-02f, 7.56510049e-02f, -2.32229661e-02f, 1.65457278e-02f, 2.61203963e-02f, -7.09894001e-02f, 9.32910200e-03f, -1.09458584e-02f, -5.48606515e-02f,
  5.14585152e-03f, -3.59288752e-02f, 1.87625997e-02f, -1.24932107e-04f, -5.03228083e-02f, -2.81681027e-03f, 1.43926786e-02f, 7.56569877e-02f, -6.35097772e-02f, -1.89806037e-02f,
  -1.07942954e-01f, 2.57588029e-01f, -1.30262645e-02f, -2.39062365e-02f, -5.97283728e-02f, 1.88656393e-02f, -2.82183243e-03f, -1.90202557e-02f, -8.51090923e-02f, -3.39505821e-02f,
  -4.80949692e-02f, 4.96785045e-02f, 1.51396124e-02f, -9.26957726e-02f, -4.72945124e-02f, -3.78757939e-02f, -5.48849590e-02f, -6.75265267e-02f, -7.91583434e-02f, -4.89025339e-02f,
  -9.66600180e-02f, 5.96076809e-02f, 1.25999704e-01f, 5.62666953e-02f, -2.15155520e-02f, 4.71061319e-02f, -7.51746967e-02f, -7.45961536e-03f, 1.25036210e-01f, -8.42324123e-02f,
  9.23173409e-03f, -5.92044517e-02f, 1.56204909e-01f, -1.37779564e-01f, -1.40357271e-01f, -1.66305318e-01f, -1.87453032e-01f, -8.41542780e-02f, 2.80919988e-02f, -1.01587571e-01f,
  -8.71198550e-02f, -6.13565035e-02f, 6.21672720e-02f, 2.54782867e-02f, 1.24447256e-01f, 8.37978348e-02f, 2.11928003e-02f, 6.55543804e-02f, 4.26534601e-02f, -1.16443569e-02f,
  -1.83282252e-02f, -1.85665339e-02f, 9.83346999e-02f, 3.83674987e-02f, 7.59173855e-02f, -7.39473179e-02f, 8.93218517e-02f, 2.08863243e-02f, 1.76518057e-02f, 1.38105422e-01f,
  -4.06800359e-02f, 6.04975112e-02f, -8.18937197e-02f, 2.07102764e-02f, -7.48856068e-02f, 1.81780253e-02f, -3.77750210e-02f, 2.11025178e-02f, -7.14289919e-02f, 8.66008252e-02f,
  -1.05589099e-01f, -1.01322636e-01f, 3.28108035e-02f, -6.00690506e-02f, -6.83080852e-02f, 5.60402609e-02f, -2.08059959e-02f, 4.68147593e-03f, 1.17002033e-01f, 6.38265014e-02f,
  -8.87247324e-02f, -5.15463203e-02f, 2.70986613e-02f, 1.62533149e-02f, 7.46975169e-02f, -2.14288980e-02f, -4.54461388e-02f, 1.32172145e-02f, -4.97898757e-02f, -5.95101863e-02f,
  -1.31528629e-02f, 6.84677809e-02f, 8.60986933e-02f, -4.27841507e-02f, -5.67295495e-03f, 6.62048988e-05f, -5.90408966e-02f, -4.30058874e-02f, 7.92368203e-02f, -2.50531044e-02f,
  6.81854710e-02f, 1.33513175e-02f, -4.22653696e-03f, -4.94111422e-03f, -2.26134732e-02f, -1.60091906e-03f, 6.21084645e-02f, -3.20572518e-02f, 3.66396122e-02f, 8.60708579e-02f,
  -1.39884064e-02f, -5.30570932e-02f, -6.20473735e-02f, -5.18694557e-02f, 1.72613300e-02f, 3.75014693e-02f, 8.30127895e-02f, 2.51496863e-02f, -6.01078682e-02f, -5.31289242e-02f,
  -1.33615792e-01f, 9.79532897e-02f, 1.32923163e-02f, -1.11869499e-01f, 1.33885676e-02f, 9.67305154e-02f, -6.80260733e-02f, 6.21408485e-02f, -9.26386937e-02f, -1.09413508e-02f,
  -2.42640059e-02f, -5.61096445e-02f, -4.07796726e-02f, -8.58102292e-02f, 1.84434163e-03f, -1.01651683e-01f, -6.83416128e-02f, -4.60027456e-02f, 6.54557860e-03f, -4.71805129e-03f,
  -1.12295851e-01f, -1.04419842e-01f, -6.80889711e-02f, -1.43259123e-01f, -5.39417714e-02f, -5.83633967e-02f, 1.15771042e-02f, -1.05213709e-01f, -8.41268152e-02f, -1.14424154e-01f,
  -7.70228729e-02f, 3.37306000e-02f, -7.44623542e-02f, -1.12097375e-02f, 1.13365158e-01f, 5.91448620e-02f, 5.33729382e-02f, -2.98596136e-02f, 3.57066318e-02f, 5.55019900e-02f,
  -2.06639394e-02f, -3.99413817e-02f, 4.71223667e-02f, 9.31116566e-02f, -6.78078085e-02f, 8.61045346e-02f, 7.46395215e-02f, -9.70273241e-02f, -6.62370166e-03f, 2.25714687e-02f,
  4.31007221e-02f, 6.88979998e-02f, -1.15492128e-01f, -2.98285093e-02f, -4.64564040e-02f, 3.56250331e-02f, 6.53636456e-02f, 3.14004496e-02f, -9.21331625e-03f, 5.92390215e-03f,
  -3.06486944e-03f, -8.04829672e-02f, 4.42351885e-02f, 7.74282068e-02f, -5.60266152e-02f, -2.66898554e-02f, -4.04210798e-02f, 5.99251986e-02f, -6.31884253e-03f, -1.06554963e-01f,
  -6.00992963e-02f, -2.21170262e-02f, 3.00189219e-02f, -2.00751536e-02f, 5.43177314e-02f, -3.98465283e-02f, -8.28053281e-02f, 5.73855883e-04f, -2.07647439e-02f, -9.31388661e-02f,
  2.52598021e-02f, -5.84576763e-02f, -1.83300897e-02f, -4.69603166e-02f, -2.00207974e-03f, -7.74804279e-02f, -1.00476839e-01f, -4.84986082e-02f, -9.63420272e-02f, -1.53642641e-02f,
  -7.38845095e-02f, 5.00766635e-02f, 1.42535232e-02f, 5.52900769e-02f, -2.32980605e-02f, -3.44479550e-03f, -6.39281571e-02f, 5.99187948e-02f, -7.38209039e-02f, -4.83173318e-02f,
  7.22483322e-02f, -8.82842466e-02f, 3.15703899e-02f, 2.42866762e-03f, 7.38563687e-02f, 2.36434862e-02f, -5.41455969e-02f, 1.47140399e-02f, 4.23721746e-02f, -3.96443568e-02f,
  1.68443061e-02f, 3.52148004e-02f, -9.50600654e-02f, 8.88303518e-02f, -2.10646316e-02f, 2.55996287e-02f, 4.78809960e-02f, -5.70978075e-02f, 1.50556993e-02f, 5.38102426e-02f,
  2.06363276e-02f, 1.56721752e-02f, -8.80056545e-02f, -4.55553122e-02f, -1.56718940e-02f, 3.11535131e-03f, 2.07984261e-02f, -2.28414591e-02f, 8.04808736e-02f, 3.84130664e-02f,
  -5.34728244e-02f, -9.91718620e-02f, 6.48361668e-02f, -2.99429391e-02f, 1.04176272e-02f, -6.45618141e-02f, -8.38648081e-02f, 3.24476622e-02f, 6.12177476e-02f, -1.10649187e-02f,
  -7.12685138e-02f, -6.88839555e-02f, -1.42772287e-01f, 3.84290628e-02f, -4.02310044e-02f, 3.19051854e-02f, -1.40038095e-02f, -1.18777879e-01f, -1.91962514e-02f, -8.25854242e-02f,
  -3.08812521e-02f, -7.94558413e-03f, -8.08164701e-02f, 7.23560946e-03f, 1.14213206e-01f, 4.97958995e-02f, 3.19449988e-04f, 8.91705453e-02f, -1.49031067e-02f, 1.04116894e-01f,
  5.23455888e-02f, 3.40725854e-02f, 1.31160975e-01f, 9.02922004e-02f, -5.52459806e-02f, 1.00961290e-01f, -3.63631770e-02f, -8.44873395e-03f, 8.00571069e-02f, 6.51707500e-02f,
  -2.46856138e-02f, -3.69616039e-03f, -4.49986644e-02f, -3.41254063e-02f, 3.85784730e-02f, 3.04833543e-03f, -5.38899601e-02f, 4.16698866e-02f, -2.96953414e-02f, -6.61183298e-02f,
  -1.01814372e-03f, 4.19210754e-02f, -4.47737388e-02f, 5.74173816e-02f, -4.07188274e-02f, 6.46472126e-02f, -6.57758787e-02f, 3.28009911e-02f, -7.02821836e-02f, 9.95937921e-03f,
  4.61210310e-03f, -6.91112950e-02f, -7.31891999e-03f, 3.01438719e-02f, -1.04152873e-01f, -8.49683136e-02f, -1.22369833e-01f, -1.23957008e-01f, -5.26579581e-02f, 4.55367081e-02f,
  1.10108301e-01f, -4.38941829e-02f, -7.94717518e-04f, 3.31893004e-02f, -9.75857750e-02f, 5.89928031e-02f, -2.29173861e-02f, 6.14215508e-02f, 3.08905896e-02f, -7.71007240e-02f,
  -5.60079701e-03f, 5.02814762e-02f, 8.36952589e-03f, -2.52261292e-02f, 4.55377763e-03f, 1.02281403e-02f, 6.19043261e-02f, 2.29055882e-02f, -5.56591228e-02f, -3.03111644e-03f,
  -7.48434663e-02f, -5.81513867e-02f, 9.45046693e-02f, -5.90671370e-05f, -2.56865881e-02f, 1.37728741e-02f, 7.57709071e-02f, -1.27355065e-02f, -3.07561960e-02f, 6.45275787e-02f,
  -2.12617777e-02f, 4.06146534e-02f, 2.50824038e-02f, 4.97349277e-02f, -3.64317670e-02f, -1.40472036e-02f, -3.17426175e-02f, 1.38611533e-02f, 7.63733387e-02f, -5.25248945e-02f,
  -3.68885435e-02f, -2.49951258e-02f, 2.37928424e-02f, 2.88668331e-02f, -3.14966701e-02f, -2.89954115e-02f, 8.98580626e-02f, 3.07072401e-02f, 3.05142868e-02f, -4.65940349e-02f,
  6.37304634e-02f, -1.00846060e-01f, 5.65449111e-02f, -4.22288366e-02f, 6.54628649e-02f, -2.35232543e-02f, 1.06127700e-02f, -3.06037664e-02f, 4.82351054e-03f, 5.57434708e-02f,
  4.64554690e-02f, 4.23187576e-02f, -6.03615269e-02f, 3.96866761e-02f, -7.87608922e-02f, 2.16222927e-02f, -5.68064675e-02f, -4.93698306e-02f, -3.56152393e-02f, 5.40623628e-02f,
  6.85635731e-02f, -1.56324267e-01f, -2.69626111e-01f, 9.20514986e-02f, -1.44296944e-01f, -1.34847641e-01f, -5.77706769e-02f, 3.99629027e-02f, 1.05157122e-01f, -1.34303868e-01f,
  -9.83802602e-02f, -1.29099498e-02f, -1.35818869e-01f, -1.11410275e-01f, -9.42238420e-02f, -5.30123375e-02f, -1.01743236e-01f, -1.99288577e-01f, -6.09782375e-02f, -5.10944538e-02f,
  -1.02181517e-01f, -4.43978198e-02f, 5.69807691e-03f, -7.53996447e-02f, -7.54194558e-02f, -5.39757945e-02f, -1.21160261e-01f, 2.50344314e-02f, -1.89003542e-01f, -4.39226218e-02f,
  -9.68747586e-02f, 2.59680469e-02f, 5.44586629e-02f, 1.53214810e-02f, 7.50987679e-02f, 8.39926302e-02f, -7.59686381e-02f, 7.11531341e-02f, -6.84924424e-02f, 4.69862437e-03f,
  -9.79709923e-02f, 5.15514798e-02f, -1.50303869e-02f, 8.96186531e-02f, 5.10138497e-02f, 6.33329824e-02f, -1.52574144e-02f, -4.08078767e-02f, -9.00440291e-02f, 6.34005964e-02f,
  2.41412818e-02f, -1.45417869e-01f, -5.68829365e-02f, 6.68167025e-02f, 2.70580146e-02f, 6.15839381e-04f, 8.89986306e-02f, -4.06246372e-02f, 6.93814158e-02f, 1.18763819e-01f,
  -1.53126149e-02f, 8.65848437e-02f, -3.26894820e-02f, 3.34959440e-02f, 6.63006380e-02f, 8.93586800e-02f, -4.76760231e-02f, -6.41586781e-02f, -5.45395017e-02f, 4.66506481e-02f,
  5.88982254e-02f, 1.53561132e-02f, -5.48461378e-02f, 5.86699396e-02f, -3.41847092e-02f, -6.87128156e-02f, -6.17902428e-02f, 2.56983954e-02f, -3.03313863e-02f, 2.09952984e-02f,
  5.90513162e-02f, 3.63741629e-02f, -8.41488317e-03f, -1.30370902e-02f, 2.13721003e-02f, 3.79443057e-02f, 1.26315549e-03f, 9.53243766e-03f, -1.17248241e-02f, -8.16800743e-02f,
  1.59472629e-01f, -1.53938681e-01f, 5.58407279e-03f, 3.40394154e-02f, 1.73048265e-02f, -1.47315972e-02f, 3.77397984e-02f, -4.70658392e-02f, -2.79289149e-02f, 6.87319562e-02f,
  4.40392569e-02f, -3.49452645e-02f, -2.36079171e-02f, -5.16792480e-03f, 9.39577892e-02f, -3.92761305e-02f, -3.66854556e-02f, 4.80043851e-02f, -5.21993311e-03f, 8.98321196e-02f,
  2.96051707e-02f, -1.34411249e-02f, 1.29571125e-01f, -3.54470797e-02f, 1.26949161e-01f, -7.85838738e-02f, -9.10332799e-03f, 7.11067347e-03f, 8.05447325e-02f, 5.92954755e-02f,
  -7.54461996e-03f, 1.55098978e-02f, 1.75970905e-02f, 6.82283416e-02f, 5.83827868e-02f, 1.78280901e-02f, 3.65329236e-02f, 2.11087447e-02f, 3.05575226e-02f, -5.42122461e-02f,
  -6.08872026e-02f, -6.68780506e-02f, -4.66781333e-02f, -1.86840761e-02f, 8.87099430e-02f, -8.64622369e-02f, -5.55307567e-02f, -3.59250829e-02f, 1.35919496e-01f, 6.21166006e-02f,
  -3.73650305e-02f, -2.36705337e-02f, 9.34027433e-02f, -6.90761954e-02f, -4.75948006e-02f, 3.04260682e-02f, 5.24320118e-02f, -9.55725163e-02f, 5.69839627e-02f, -4.81415391e-02f,
  -9.44347307e-02f, -6.58689663e-02f, 5.99060068e-03f, 7.65829980e-02f, -9.42813158e-02f, 1.51117668e-02f, 2.72462424e-02f, 5.19752055e-02f, 4.76699844e-02f, 4.88681011e-02f,
  4.89057712e-02f, 7.54724964e-02f, -4.11574496e-04f, -9.97266639e-03f, 8.94426927e-02f, -3.92641351e-02f, 2.03192867e-02f, 7.23048598e-02f, 5.27279526e-02f, -4.28312831e-02f,
  3.24593037e-02f, 6.89758062e-02f, 2.28148811e-02f, 2.20714193e-02f, 4.25530747e-02f, 1.20524699e-02f, 4.90153581e-02f, -2.99899690e-02f, 8.01205561e-02f, 4.37051654e-02f,
  -6.66012689e-02f, -3.79479416e-02f, -4.84929383e-02f, 7.37143531e-02f, 3.67337503e-02f, -1.56483166e-02f, 5.68103939e-02f, -8.19246247e-02f, 2.43190862e-02f, -6.71203956e-02f,
  -1.35238664e-02f, 1.58476783e-03f, 6.23230077e-02f, 9.32079852e-02f, -6.88849762e-02f, -1.50058810e-02f, 3.72844152e-02f, -3.34815122e-03f, -8.05166289e-02f, -8.60728174e-02f,
  2.59647630e-02f, -2.66574323e-02f, 1.34481629e-02f, 6.26854151e-02f, 5.24414666e-02f, -3.70007660e-03f, -8.43354911e-02f, 4.18664627e-02f, -3.66560742e-02f, 6.58453777e-02f,
  5.15388884e-02f, 1.93590336e-02f, 9.72647071e-02f, -2.64243055e-02f, -7.30235204e-02f, 1.33574167e-02f, -7.45982155e-02f, -9.38085243e-02f, -9.96835455e-02f, 1.94128510e-02f,
  6.76443279e-02f, -6.67231753e-02f, -3.48242633e-02f, -1.98362656e-02f, 4.96010743e-02f, -2.18626577e-02f, -2.59516742e-02f, 8.68882313e-02f, 2.48666462e-02f, -2.39999089e-02f,
  -9.77352113e-02f, -6.80249855e-02f, 7.41388276e-02f, -4.31911871e-02f, 9.98071744e-04f, -6.24764115e-02f, 1.88261513e-02f, -7.75572360e-02f, 6.07178062e-02f, -4.37068846e-03f,
  3.33672136e-01f, 2.43472978e-01f, 3.73875350e-02f, 8.09510052e-02f, -1.13897860e-01f, -5.36420383e-02f, -1.21700736e-02f, 2.25666296e-02f, 8.86292830e-02f, 1.22342132e-01f,
  2.11223662e-02f, -3.58075090e-02f, 7.14966431e-02f, 3.45419310e-02f, 9.39793363e-02f, 2.18057707e-02f, -4.38533202e-02f, -4.84623685e-02f, -3.02757993e-02f, -1.66219790e-02f,
  -4.58765216e-02f, 1.15055770e-01f, 1.58175930e-01f, 9.45509672e-02f, -7.72597492e-02f, 6.81327190e-03f, 7.14289472e-02f, 9.80852991e-02f, -6.04164265e-02f, -5.64486370e-04f,
  -2.95294356e-02f, 1.78561926e-01f, -8.22919980e-02f, -1.01515688e-01f, -1.16177306e-01f, -4.63525206e-03f, 9.73716453e-02f, 8.21370184e-02f, -4.84589338e-02f, 6.17103651e-02f,
  -7.36719891e-02f, 2.81877108e-02f, -7.33687207e-02f, -2.67987680e-02f, 1.52946799e-03f, 6.20779842e-02f, 3.89070548e-02f, 1.23947524e-01f, 1.95278302e-02f, -2.56073172e-03f,
  -1.34802118e-01f, -7.83860087e-02f, 8.72199833e-02f, 1.20056998e-02f, -6.92768320e-02f, -8.44009072e-02f, -6.85791373e-02f, -1.59917213e-02f, 3.47657502e-02f, -6.04712870e-04f,
  7.05870911e-02f, 1.76206008e-02f, -9.28868502e-02f, 2.27568634e-02f, -6.25368729e-02f, -5.44477217e-02f, -7.46045038e-02f, 1.66382138e-02f, -6.57706261e-02f, 2.49131825e-02f,
  -1.92792043e-02f, -4.42941412e-02f, 3.21186930e-02f, -4.52626646e-02f, -1.02355152e-01f, 6.01346567e-02f, -3.13232047e-03f, -3.91213074e-02f, -9.31690335e-02f, 6.95675984e-02f,
  -7.31239170e-02f, 2.10291636e-03f, -6.56723455e-02f, -9.54873115e-02f, 6.85801904e-04f, 2.00576670e-02f, -7.28840753e-03f, -2.19887793e-02f, 7.74847269e-02f, 6.37733117e-02f,
  -8.39896426e-02f, -1.36919962e-02f, -3.82216834e-02f, 5.24600560e-04f, -4.21496779e-02f, 6.67257532e-02f, -6.66676462e-02f, -7.49738663e-02f, -8.20438340e-02f, 3.15770954e-02f,
  -7.39637911e-02f, 2.33765692e-02f, 4.66835313e-02f, 1.26064774e-02f, -1.11556686e-01f, 1.63933542e-02f, 7.76516274e-02f, -7.15798885e-02f, -3.26803932e-03f, 6.65354878e-02f,
  -6.58190623e-02f, -7.35246390e-02f, 3.69266756e-02f, -3.89481485e-02f, 3.29879411e-02f, -2.81866323e-02f, 4.45025787e-02f, 2.97928769e-02f, 5.65700978e-02f, 5.22095487e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  7.34335855e-02f, 1.36270821e-01f, 1.38605600e-02f, -3.49393077e-02f, 1.38474554e-01f, 1.12918295e-01f, 2.13759109e-01f, 1.59891576e-01f, -2.23062355e-02f, 1.83313206e-01f,
  1.13414777e-02f, 7.13830739e-02f, 1.76732585e-01f, 1.69478551e-01f, -2.73320246e-02f, 4.48975600e-02f, 1.06390771e-02f, 7.57993758e-02f, 5.37722036e-02f, 1.01136155e-01f,
  3.35465856e-02f, 1.52761796e-02f, 1.69054475e-02f, 4.34412137e-02f, 1.49320960e-01f, 9.72741842e-02f, 6.02741390e-02f, 2.31165677e-01f, 1.76177412e-01f, 4.05071229e-02f,
  1.01844169e-01f, 1.89145625e-01f, 1.64673716e-01f, 4.05847840e-02f, 8.60048532e-02f, 1.72621369e-01f, 2.60026380e-02f, 1.12902679e-01f, 1.46524668e-01f, -3.10195535e-02f,
  -1.93828680e-02f, 1.64340556e-01f, 1.35705441e-01f, 1.53575419e-02f, 9.65329856e-02f, 5.49224801e-02f, -5.68454564e-02f, 1.13903582e-01f, 1.77927092e-02f, -7.37939402e-02f,
  5.72281666e-02f, 2.40106821e-01f, 9.45592523e-02f, -4.65371609e-02f, 3.34560983e-02f, -1.40025839e-02f, 1.37481496e-01f, 1.24247789e-01f, 1.14770532e-01f, 1.07953101e-01f,
  7.18446895e-02f, 2.68167034e-02f, 1.88150615e-01f, 9.64143649e-02f, 1.58384815e-01f, 1.32991418e-01f, 4.57633324e-02f, 3.36172134e-02f, -7.99449161e-02f, -1.71622504e-02f,
  1.64366528e-01f, 1.85823634e-01f, 6.46411702e-02f, -3.03745433e-03f, 1.59952026e-02f, 5.12518212e-02f, -1.07180676e-03f, 1.66800424e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -4.21116382e-01f, 7.99576268e-02f, -4.01476175e-01f, 3.16746086e-02f, -1.99433506e-01f, -1.93196684e-01f, -2.24831983e-01f, 4.26901579e-02f, -1.17297314e-01f, -2.62060128e-02f,
  -8.57371911e-02f, -4.09853518e-01f, 1.89201534e-02f, -6.03685565e-02f, -3.83243203e-01f, 7.47039691e-02f, -6.84324950e-02f, 2.48755552e-02f, 9.46725085e-02f, -3.12636167e-01f,
  -2.58543730e-01f, -1.45146534e-01f, -2.39735365e-01f, -2.52018068e-02f, -1.60683189e-02f, 2.27486026e-02f, 1.69165999e-01f, 1.47052184e-01f, 6.51908666e-02f, 3.33559841e-01f,
  1.54979065e-01f, 1.57927349e-02f, -1.77061692e-01f, 8.46465528e-02f, -1.24806389e-01f, 7.43645951e-02f, -3.24416488e-01f, 8.31876248e-02f, -3.83261926e-02f, -3.39081556e-01f,
  -1.07809305e-01f, 4.65649553e-02f, 5.61232939e-02f, 2.67015457e-01f, -5.58108911e-02f, -1.50309399e-01f, -1.47950068e-01f, 3.39953542e-01f, -1.10663436e-01f, -3.34367976e-02f,
  6.08170688e-01f, 6.82220384e-02f, -9.48995352e-02f, -4.88346443e-04f, -3.34782638e-02f, 8.30067396e-02f, -7.15415105e-02f, -1.35229677e-01f, 6.88407123e-02f, -6.37029037e-02f,
  -9.09881890e-02f, 7.06176236e-02f, -7.28494078e-02f, 3.95483494e-01f, 2.20242530e-01f, -6.34093732e-02f, -1.49335682e-01f, 5.53472303e-02f, 1.57944441e-01f, 6.82659894e-02f,
  -1.58478051e-01f, 3.45541053e-02f, -8.16379115e-02f, -6.41591698e-02f, -1.47306621e-01f, 3.00772227e-02f, 5.65596186e-02f, -4.68202084e-02f, -5.15575930e-02f, -1.30597308e-01f,
  1.75635725e-01f, 1.38643041e-01f, -1.01767592e-01f, -6.39947131e-02f, -7.10868835e-02f, -3.60629186e-02f, -9.50713679e-02f, 2.26123799e-02f, -1.88230723e-02f, -9.40538570e-02f,
  -1.11825339e-01f, -9.03933123e-02f, 6.72469139e-02f, 1.72907025e-01f, -8.11615810e-02f, -8.84951577e-02f, -1.01403661e-01f, 8.07196200e-02f, -6.44171610e-02f, 5.82119942e-01f,
  -1.55982703e-01f, 1.10449223e-02f, 1.51595660e-02f, 4.25601862e-02f, 1.57912001e-01f, -2.64447201e-02f, -2.67367940e-02f, 1.35680214e-01f, -1.08495370e-01f, -2.26781815e-01f,
  6.11962117e-02f, 7.22622648e-02f, 1.50712729e-01f, -1.88711733e-01f, -3.32434326e-02f, -1.21520452e-01f, -6.23584576e-02f, 1.31227732e-01f, 1.06487893e-01f, 2.48471886e-01f,
  -6.44776672e-02f, 2.26294324e-02f, -5.87951876e-02f, -9.91795305e-03f, 2.74766907e-02f, 3.71675521e-01f, 1.20870270e-01f, -5.59762456e-02f, 3.24464649e-01f, 1.23147517e-01f,
  -1.38194477e-02f, -1.70919746e-01f, -1.40205100e-01f, 3.00606061e-03f, -1.69827819e-01f, 1.90879598e-01f, -8.97946229e-05f, 7.66949281e-02f, 4.44101170e-02f, -1.35414645e-01f,
  -2.98545718e-01f, 8.06537941e-02f, 5.42861708e-02f, 9.72906314e-03f, 8.77433792e-02f, 1.90654118e-02f, -2.01305896e-01f, -1.37773395e-01f, 2.77511328e-01f, 7.72770792e-02f,
  1.61806434e-01f, 5.62397055e-02f, 1.37762055e-01f, 3.00516546e-01f, -2.08734006e-01f, 8.84271972e-03f, 1.55714005e-01f, 2.21969604e-01f, 2.02267364e-01f, -1.92292288e-01f,
  -3.33856158e-02f, -3.33112895e-01f, 2.35696763e-01f, -4.72324967e-01f, -1.37000918e-01f, 2.47849990e-03f, -1.97700635e-01f, -5.40404379e-01f, 3.13986301e-01f, -3.58553603e-02f,
  -2.69934744e-01f, 3.57222825e-01f, -1.30204633e-01f, -3.51681672e-02f, 2.39731178e-01f, -1.48680881e-01f, -8.17704499e-02f, -2.54439712e-01f, 4.91012335e-01f, -1.11609459e-01f,
  -1.18186280e-01f, -1.45757403e-02f, 9.75926220e-03f, 1.75610080e-01f, 3.75194848e-01f, 4.08595204e-02f, 4.98539768e-02f, 5.09069860e-01f, -1.16703235e-01f, -1.77601725e-01f,
  -1.07611567e-01f, -9.67645794e-02f, -4.69172187e-02f, -1.11539260e-01f, -1.06546283e-01f, -1.28912777e-01f, 2.36367375e-01f, 4.56564337e-01f, -1.47236943e-01f, 2.04009190e-01f,
  -6.41878024e-02f, 1.56830922e-01f, 2.76262432e-01f, 2.74973094e-01f, 4.14909571e-02f, -2.80651271e-01f, -1.05060689e-01f, -1.17283672e-01f, -1.24480769e-01f, 1.17772900e-01f,
  -1.55628948e-02f, -9.06947106e-02f, -1.11426666e-01f, -2.28952826e-03f, -2.41857320e-01f, -4.58399802e-02f, 5.51456846e-02f, 4.63851504e-02f, 1.54961437e-01f, -3.62754799e-02f,
  -1.97285846e-01f, 7.86697567e-02f, -1.22896366e-01f, 2.52908111e-01f, 1.78403080e-01f, 4.14993800e-02f, -2.13983864e-01f, -1.67895094e-01f, 4.22817795e-03f, 1.87687844e-01f,
  2.47110650e-02f, 7.84809515e-02f, 1.29934385e-01f, 3.69980708e-02f, 1.22719593e-01f, 4.53352630e-01f, -1.15827717e-01f, -2.53810138e-01f, 7.12656230e-02f, 2.77731083e-02f,
  -1.04527250e-02f, -2.40306213e-01f, -1.23347998e-01f, 3.29035431e-01f, -1.61111921e-01f, -3.76721248e-02f, 4.60274927e-02f, -9.19135287e-02f, -1.54290959e-01f, 4.15064454e-01f,
  -4.19949181e-02f, -2.51108706e-02f, 1.08233109e-01f, 3.75253744e-02f, 4.76291142e-02f, 5.43968342e-02f, -1.02581836e-01f, 7.69806057e-02f, 2.17099622e-01f, -4.99718590e-03f,
  3.84326950e-02f, 9.68471318e-02f, 3.79999787e-01f, 7.64855891e-02f, 3.95086519e-02f, 1.65222138e-01f, 1.50356188e-01f, 1.00179151e-01f, 2.71767139e-01f, 1.47163719e-01f,
  2.13390170e-03f, 9.13164616e-02f, 1.00401998e-01f, 1.33685708e-01f, 1.21767811e-01f, 3.32939863e-01f, 1.45839453e-01f, 7.00442046e-02f, -1.02447681e-01f, 8.73185322e-02f,
  -3.09913922e-02f, 6.49522722e-01f, 3.94531153e-02f, -7.48510808e-02f, 4.46329802e-01f, 3.10513049e-01f, -4.58535194e-01f, 1.64983794e-01f, -2.23034155e-02f, -4.35034066e-01f,
  9.43941548e-02f, 1.91220399e-02f, 3.20841968e-01f, -3.31162244e-01f, -5.95598333e-02f, -4.62158799e-01f, -2.27878377e-01f, 1.09687708e-01f, -2.29025468e-01f, -2.41273224e-01f,
  -3.63107622e-01f, -2.18691751e-01f, -1.72658131e-01f, 3.05805951e-01f, 1.19232371e-01f, 2.90960193e-01f, -1.60921201e-01f, -1.33986503e-01f, 1.30969107e-01f, 1.28722116e-01f,
  -6.63649067e-02f, 1.67746902e-01f, -1.25357509e-01f, -2.03592271e-01f, 1.55937448e-01f, -1.37253538e-01f, 1.00725442e-02f, 1.49746820e-01f, 6.93885311e-02f, -9.29980800e-02f,
  2.63963616e-03f, 1.18716225e-01f, 2.08996516e-02f, -1.14074074e-01f, -2.02085540e-01f, 1.24257773e-01f, -1.45882875e-01f, 2.48866186e-01f, -8.21301341e-02f, -9.91368145e-02f,
  -1.62444696e-01f, 4.16559935e-01f, -2.95171794e-02f, 7.09424689e-02f, -1.23720907e-01f, 1.04384325e-01f, -4.79508080e-02f, -2.48046115e-01f, -1.40028104e-01f, 2.17722386e-01f,
  2.15414781e-02f, 1.95182249e-01f, -1.37729153e-01f, -7.07496479e-02f, -1.26244456e-01f, 2.19864808e-02f, -5.96341081e-02f, 2.16664467e-02f, 9.24801528e-02f, -5.71882632e-03f,
  3.40879075e-02f, -1.48561195e-01f, -1.68778136e-01f, -7.34755173e-02f, 1.53958261e-01f, -1.70086652e-01f, 5.92092834e-02f, -1.05944261e-01f, -8.55359957e-02f, -2.54457202e-02f,
  -7.04820007e-02f, -8.46939860e-04f, -5.51896356e-02f, 1.08882755e-01f, -7.42033198e-02f, -1.20560497e-01f, -1.89247280e-01f, -8.40740502e-02f, -8.35962147e-02f, -2.07604513e-01f,
  -6.70993552e-02f, -1.54863253e-01f, -1.48722857e-01f, -9.16305706e-02f, -2.16382705e-02f, -3.50319664e-03f, 1.73303068e-01f, 6.59149066e-02f, 3.47347677e-01f, 5.33834435e-02f,
  -1.51354998e-01f, -2.04142854e-01f, 2.91153342e-02f, -1.24954075e-01f, -2.86203146e-01f, -2.00117990e-01f, 1.85361341e-01f, -6.62666857e-02f, 3.90647203e-02f, 2.94304103e-01f,
  1.96114689e-01f, -1.91430837e-01f, 2.87257563e-02f, -6.89717829e-02f, -4.72915964e-03f, -5.27279414e-02f, 1.79286599e-01f, -2.10528046e-01f, 2.81761717e-02f, -7.63491318e-02f,
  -1.05288640e-01f, -1.21834978e-01f, -1.02930948e-01f, -2.09029075e-02f, -1.67538226e-02f, 1.50341421e-01f, -1.06549598e-02f, -5.02238944e-02f, 4.53160629e-02f, 2.63981283e-01f,
  4.38675523e-01f, 9.54997092e-02f, -3.07448715e-01f, -9.06414911e-02f, -2.28417739e-01f, -2.22003654e-01f, 3.90883714e-01f, 1.90162405e-01f, -1.27942175e-01f, 1.82567704e-02f,
  -2.28059515e-01f, 1.34684309e-01f, -4.66828883e-01f, -6.10679714e-03f, -2.28867248e-01f, -1.80611938e-01f, 1.93739712e-01f, -2.57872611e-01f, -2.39000872e-01f, -1.16879880e-01f,
  -9.23810469e-04f, -3.83728772e-01f, 4.24694628e-01f, -2.04684168e-01f, -2.19658256e-01f, 2.75542527e-01f, -1.44178420e-01f, 7.26074800e-02f, 1.09892674e-01f, -1.14568584e-01f,
  -1.32879242e-01f, 3.54752749e-01f, -5.95022403e-02f, -7.24067613e-02f, -9.21420678e-02f, 2.03664616e-01f, 6.29903674e-01f, 1.61525756e-01f, 9.32514071e-02f, 1.61540568e-01f,
  -6.01262935e-02f, 1.66086212e-01f, -2.23363191e-01f, -1.01292267e-01f, 1.02768414e-01f, 1.32104844e-01f, -4.41658273e-02f, 1.03176720e-02f, -1.09748840e-01f, -1.13303319e-01f,
  7.33852535e-02f, 2.90176630e-01f, 2.33359396e-01f, 3.15757692e-01f, 6.69690311e-01f, -7.24316090e-02f, -8.10313523e-02f, -7.31910840e-02f, 7.06324130e-02f, -1.42966434e-01f,
  1.70514673e-01f, -1.19722046e-01f, -2.65401751e-02f, -1.61729038e-01f, -8.59249309e-02f, 8.44933242e-02f, -1.57937349e-03f, 9.31161195e-02f, -2.24477619e-01f, -3.68485935e-02f,
  2.89571807e-02f, -9.33263451e-02f, -1.58883892e-02f, 7.81753138e-02f, 2.21995845e-01f, -2.57161856e-01f, -6.90589100e-02f, -6.45022318e-02f, 8.33319798e-02f, 1.47105129e-02f,
  -9.01189893e-02f, -1.54890969e-01f, -6.21850556e-03f, 6.00038059e-02f, -1.06642507e-01f, -1.47385448e-01f, 1.21876858e-01f, 1.07826479e-01f, -9.38807130e-02f, -9.07469820e-03f,
  -1.34968743e-01f, -1.31435648e-01f, -5.48327435e-03f, 2.66783506e-01f, -6.03873581e-02f, 7.27190822e-02f, 1.32896543e-01f, 6.92860857e-02f, 7.54917264e-02f, -1.79868937e-01f,
  -6.22006655e-02f, -1.68389916e-01f, -1.92514256e-01f, -1.03196204e-02f, -2.59371754e-03f, 1.52022779e-01f, 1.17075339e-01f, -2.29385942e-01f, 2.24526972e-02f, 5.03816083e-02f,
  -1.41114071e-01f, -2.02965945e-01f, -1.00365490e-01f, 3.31316769e-01f, -2.61283457e-01f, 1.82152092e-01f, 1.15221806e-01f, 7.14297146e-02f, 1.73545778e-01f, -2.55282193e-01f,
  6.52179196e-02f, 2.60644704e-01f, -6.07120469e-02f, -2.81433731e-01f, 2.23542556e-01f, 6.08879328e-02f, -1.49240956e-01f, 4.02827233e-01f, -3.82189423e-01f, 2.20906496e-01f,
  -1.39511243e-01f, -1.17526203e-01f, 4.48385894e-01f, -4.95154977e-01f, 1.73256412e-01f, 1.28751844e-01f, -1.04719348e-01f, 3.64507847e-02f, 3.26442540e-01f, 2.38873050e-01f,
  1.55174345e-01f, -3.58605059e-03f, 1.41239688e-01f, -1.20052867e-01f, 1.93747625e-01f, -3.85244042e-01f, -1.12252623e-01f, -1.43670663e-01f, -1.93812385e-01f, 6.01286963e-02f,
  9.84062999e-03f, 3.40743065e-01f, -2.53063023e-01f, -8.59638751e-02f, -7.71894976e-02f, -2.03923732e-02f, -1.51376709e-01f, -2.91016768e-03f, -2.04866797e-01f, 1.22699551e-01f,
  1.60003174e-02f, 2.99111009e-02f, 1.67983130e-01f, 4.28560562e-02f, -1.98415115e-01f, -2.07655981e-01f, -1.42587408e-01f, 1.62977323e-01f, 1.46020904e-01f, -6.86144531e-02f,
  -3.26828361e-02f, -2.21937448e-01f, 1.33180946e-01f, -1.06455842e-02f, -3.27657387e-02f, -1.18045770e-01f, 5.13226911e-02f, -1.88890323e-01f, 8.38586017e-02f, 1.37385532e-01f,
  -1.48906680e-02f, 4.92582589e-01f, -2.16746733e-01f, 3.74127835e-01f, -2.49328129e-02f, -1.21058233e-01f, 2.42381155e-01f, -1.64820477e-01f, 3.16125512e-01f, -2.40680948e-02f,
  -1.42560363e-01f, -7.32267871e-02f, -1.07701622e-01f, -9.77294613e-03f, 2.75301903e-01f, -4.33966238e-03f, 7.52832890e-02f, -1.22608706e-01f, -9.92623195e-02f, -2.67670136e-02f,
  9.74396840e-02f, 3.77797663e-01f, 1.51480436e-01f, -7.65119046e-02f, -1.91936214e-02f, 3.23985592e-02f, -7.85543099e-02f, -2.39003822e-02f, -1.45610115e-02f, -6.05316721e-02f,
  9.37920958e-02f, 2.91663647e-01f, 2.09029242e-01f, 1.40713066e-01f, -2.85490990e-01f, -1.25611112e-01f, 8.59567598e-02f, 2.04268880e-02f, -6.78348616e-02f, -3.59141640e-03f,
  6.62926361e-02f, 1.20322682e-01f, 1.73598845e-02f, -3.92872356e-02f, 5.35109863e-02f, 9.39869732e-02f, -3.83729823e-02f, 1.80625945e-01f, -6.88702017e-02f, -4.16513048e-02f,
  2.83026069e-01f, 1.75845057e-01f, 1.29469007e-01f, 1.45237803e-01f, 1.19679555e-01f, 1.56795219e-01f, 2.44753301e-01f, 9.58393216e-02f, 8.71408954e-02f, 2.15949506e-01f,
  3.47508013e-01f, -1.13616668e-01f, -9.59986299e-02f, -5.58714494e-02f, 1.70849547e-01f, -1.29502341e-01f, -2.23716453e-01f, 2.51039952e-01f, 9.65898335e-02f, 3.36936235e-01f,
  3.48380469e-02f, 1.00302987e-01f, 1.74509257e-01f, 9.83555540e-02f, 6.61789477e-02f, -4.56262559e-01f, 3.26040154e-03f, 4.80187032e-03f, 3.34534980e-02f, -1.42134622e-01f,
  2.18559969e-02f, -1.78525075e-01f, -4.62170482e-01f, -1.87484045e-02f, 4.25793566e-02f, -8.43123905e-03f, -5.48081219e-01f, 2.57236630e-01f, 1.37995526e-01f, 5.29616237e-01f,
  4.71468866e-01f, -2.40843564e-01f, 1.56511754e-01f, 2.44729787e-01f, -1.57812820e-03f, 1.53565377e-01f, -2.18151167e-01f, 2.85714626e-01f, -2.90629238e-01f, -4.07028407e-01f,
  1.02808848e-01f, -1.02172174e-01f, -2.08318621e-01f, -7.06785172e-02f, 1.54247940e-01f, -1.63752213e-02f, 3.91861387e-02f, 2.06708461e-01f, -1.65251363e-02f, -1.95621550e-02f,
  -1.46900892e-01f, -5.45304567e-02f, -1.49332374e-01f, -1.47211188e-02f, 1.32674411e-01f, -7.16180801e-02f, -1.70547232e-01f, -1.21935345e-01f, 5.41762590e-01f, -2.30616480e-01f,
  -3.79203111e-02f, -9.48893204e-02f, -2.85585243e-02f, 5.43963462e-02f, 2.18153521e-01f, -2.97716677e-01f, 2.81698741e-02f, -2.46818110e-01f, 6.41391948e-02f, -1.03511773e-01f,
  -1.28698215e-01f, 2.77050525e-01f, -5.42200878e-02f, 3.56673747e-02f, -6.98095039e-02f, -7.35053942e-02f, 7.41334483e-02f, -5.87170385e-02f, -1.18402985e-03f, 2.49171570e-01f,
  -3.98110338e-02f, -1.36132210e-01f, 2.22444221e-01f, -1.57676220e-01f, -1.17198810e-01f, -6.27766177e-02f, -1.23877443e-01f, 1.97094474e-02f, -1.48851007e-01f, -3.07183564e-02f,
  -1.60803974e-01f, 1.58702165e-01f, 9.24262330e-02f, -5.98776937e-02f, 9.39504653e-02f, -1.57068763e-03f, 1.04490168e-01f, -2.34578639e-01f, -4.15825024e-02f, 3.01743448e-01f,
  -6.09115548e-02f, 1.47756726e-01f, -2.33794134e-02f, -1.38025999e-01f, 5.04340768e-01f, 3.30508351e-02f, 1.36002123e-01f, 2.16023214e-02f, 5.81589267e-02f, -1.39830962e-01f,
  -6.38931841e-02f, 7.18716085e-02f, -9.85397473e-02f, 5.35497442e-02f, 1.91564715e-04f, 2.49115974e-01f, 3.47497649e-02f, 2.34730825e-01f, 6.95475712e-02f, 1.17784165e-01f,
  -2.49688700e-02f, -5.95399998e-02f, -9.39302426e-03f, 6.82434067e-02f, -4.90610953e-03f, -2.00303838e-01f, 5.97286038e-02f, 4.17059399e-02f, -1.17628843e-01f, -3.02209258e-01f,
  1.16586998e-01f, -8.59294161e-02f, -1.05380528e-02f, -1.12946577e-01f, 6.08325228e-02f, 3.91511843e-02f, 2.79783104e-02f, -2.80356765e-01f, 8.47630426e-02f, 9.02152210e-02f,
  1.30298927e-01f, -8.70853588e-02f, -1.80630490e-01f, -4.17367905e-01f, -1.51139021e-01f, -3.80563825e-01f, 4.96400118e-01f, 4.30245697e-02f, -2.16375347e-02f, 4.60508049e-01f,
  -3.48363042e-01f, 2.96705902e-01f, 2.60148466e-01f, 3.61393094e-01f, 2.95499414e-01f, -3.07468116e-01f, 3.72571349e-01f, 8.08874890e-02f, 4.46294695e-01f, 8.10645521e-02f,
  -1.94914892e-01f, -1.00144222e-01f, 3.83008599e-01f, 4.68457133e-01f, -2.63637811e-01f, 1.66339174e-01f, -1.33544981e-01f, 2.09099397e-01f, -7.43595958e-02f, -1.67957440e-01f,
  3.62356424e-01f, 1.06146811e-02f, -1.26652196e-01f, 2.96147112e-02f, -2.21701726e-01f, -1.88282698e-01f, 1.65876612e-01f, 1.73420399e-01f, 2.47985497e-01f, -9.09593925e-02f,
  -1.84072092e-01f, -2.99320787e-01f, -1.03053197e-01f, 1.93862721e-01f, 2.06885278e-01f, -1.07584454e-01f, 2.14532465e-02f, -1.30572483e-01f, -1.70381382e-01f, -6.22863136e-02f,
  3.44956338e-01f, -6.82279170e-02f, 1.01961598e-01f, -2.07297169e-02f, 6.41109273e-02f, -1.72678847e-02f, -7.97607899e-02f, -8.21343809e-02f, -1.58016413e-01f, -9.80377868e-02f,
  -1.28548875e-01f, -9.37847346e-02f, -1.07111871e-01f, 1.81547955e-01f, 5.08125722e-02f, 4.13393885e-01f, -2.46134490e-01f, 3.21128182e-02f, -1.93953931e-01f, 1.33399874e-01f,
  -2.00720146e-01f, -4.41527404e-02f, 8.25670585e-02f, 3.06081802e-01f, 2.20650844e-02f, -1.22333243e-01f, 1.00753084e-01f, -9.03998464e-02f, -1.36205837e-01f, -3.29670087e-02f,
  -1.66875735e-01f, -1.22267731e-01f, -1.92749307e-01f, -1.33453429e-01f, -1.39351860e-01f, -3.42937186e-02f, -1.08271390e-01f, -9.46756452e-02f, 1.66285291e-01f, -1.01920784e-01f,
  -1.52140647e-01f, -2.62247413e-01f, -2.02806354e-01f, -8.99906531e-02f, 1.59766659e-01f, -1.96311861e-01f, 2.78100036e-02f, -1.51857316e-01f, 9.17064101e-02f, -1.11722156e-01f,
  2.72067696e-01f, -1.24066107e-01f, -1.70034230e-01f, -1.30447343e-01f, -2.13654451e-02f, 3.17262471e-01f, 1.09340241e-02f, -8.48976523e-02f, -1.43398419e-01f, -2.83031434e-01f,
  -1.55740693e-01f, -3.84982765e-01f, -1.95729584e-01f, -1.73250139e-01f, -1.15180813e-01f, -1.93262637e-01f, -5.12623154e-02f, 9.59417149e-02f, -2.72839934e-01f, 2.64996085e-02f,
  -4.81361933e-02f, -1.22571394e-01f, -5.68846725e-02f, -2.88991574e-02f, -1.32037729e-01f, 1.52647402e-02f, 4.54698764e-02f, -1.88800711e-02f, -1.87382568e-02f, 2.18205713e-02f,
  -1.55477241e-01f, 4.11259197e-02f, 2.37649888e-01f, -3.01081538e-01f, -3.11025769e-01f, -2.30682731e-01f, -3.48258972e-01f, 1.81622073e-01f, -1.27892181e-01f, -3.41009140e-01f,
  -2.97285050e-01f, 1.22858174e-01f, -6.56729862e-02f, -2.49838382e-01f, -1.77700624e-01f, 1.50127649e-01f, -2.43357308e-02f, 1.43672004e-01f, 1.87733233e-01f, -8.81701633e-02f,
  8.50823000e-02f, -1.01347812e-01f, 3.15323472e-02f, 1.42307833e-01f, -4.51423377e-02f, -2.17615113e-01f, -1.66752324e-01f, 5.18682413e-02f, 1.64653406e-01f, 1.00029103e-01f,
  -4.65555377e-02f, -6.81041926e-02f, -9.23487693e-02f, -7.28796497e-02f, -1.40304431e-01f, -1.88994065e-01f, 7.49858213e-04f, 1.82602808e-01f, 4.64547947e-02f, 4.17786509e-01f,
  -1.01579003e-01f, -4.31275973e-03f, -5.77826165e-02f, 1.84674129e-01f, -8.02760795e-02f, -3.66404764e-02f, -1.47975348e-02f, 6.08844981e-02f, 1.60964206e-02f, -4.21408452e-02f,
  2.70072877e-01f, -6.38988689e-02f, -1.19177185e-01f, 1.30597144e-01f, -1.72568545e-01f, -4.94345315e-02f, 1.66365996e-01f, -1.45566314e-01f, -5.41031808e-02f, 1.27629846e-01f,
  -8.19425806e-02f, -2.14293733e-01f, 9.34275612e-02f, 3.67803164e-02f, 5.55428937e-02f, -6.58451319e-02f, 3.24438035e-01f, 1.74082398e-01f, 2.35079914e-01f, 1.06723480e-01f,
  -3.18831317e-02f, 4.75474745e-02f, 1.47508532e-01f, -9.04864371e-02f, 1.09595723e-01f, -1.02317937e-01f, -1.00069828e-01f, -1.71117872e-01f, 6.89385906e-02f, 7.48385191e-02f,
  2.70432532e-02f, -1.24126211e-01f, 3.51253957e-01f, -1.08384043e-01f, 1.37203522e-02f, -8.79488662e-02f, -1.14995218e-03f, -3.22663262e-02f, 2.15968341e-01f, 6.00350976e-01f,
  2.59245690e-02f, -6.54186234e-02f, 1.26557365e-01f, 6.28359765e-02f, 1.07412204e-01f, -7.08917975e-02f, -7.86526501e-02f, -1.18428133e-01f, -1.29002422e-01f, 2.12895155e-01f,
  7.30204955e-02f, 2.85299756e-02f, -2.05497518e-02f, -1.89877912e-01f, -2.13161826e-01f, -2.88605206e-02f, 1.99707627e-01f, 4.93081436e-02f, -2.63673533e-02f, 5.74016497e-02f,
  8.62888619e-02f, -1.16393510e-02f, 1.04523987e-01f, -1.75243407e-01f, 5.50630204e-02f, 1.65705681e-01f, 1.04691960e-01f, 1.33673921e-01f, -1.80811360e-02f, 2.17559021e-02f,
  -1.22972457e-02f, -2.48243148e-03f, 1.21250257e-01f, 1.58435851e-01f, -6.98443055e-02f, -3.14333409e-01f, 1.15287662e-01f, 2.12255325e-02f, -1.24002397e-02f, -4.59744453e-01f,
  7.88583159e-02f, 3.30705487e-04f, -1.25878856e-01f, -3.38591412e-02f, -2.31010765e-01f, 3.33058000e-01f, 1.99879870e-01f, -8.82291943e-02f, 3.17275286e-01f, -1.43761873e-01f,
  -8.55196491e-02f, -1.95141822e-01f, 1.04950853e-01f, 1.61153600e-01f, 3.79396975e-02f, -2.82385886e-01f, -3.44784915e-01f, 9.20499861e-02f, 1.14628207e-03f, 3.87303263e-01f,
  4.03208435e-01f, -2.01008737e-01f, 2.51815349e-01f, -1.99031785e-01f, -1.96606874e-01f, 7.23016337e-02f, -6.48723096e-02f, 1.47066146e-01f, 1.56847119e-01f, -9.68827829e-02f,
  4.15831447e-01f, -2.76974767e-01f, -5.39379492e-02f, -1.71241254e-01f, -1.29279137e-01f, -4.81315181e-02f, -5.60470708e-02f, -1.61246449e-01f, 1.17057353e-01f, 1.82872918e-02f,
  6.22094423e-02f, -2.65239999e-02f, -1.39637083e-01f, -1.00032471e-01f, 1.53127030e-01f, -1.45544738e-01f, -1.17757149e-01f, 2.92772916e-03f, 5.77245802e-02f, 1.54129624e-01f,
  2.01645736e-02f, -1.96385726e-01f, -1.39244214e-01f, -1.30754322e-01f, -1.77670389e-01f, -1.35080069e-01f, 6.66060686e-01f, 2.94393659e-01f, 2.58335058e-04f, 1.06519006e-01f,
  -1.33384049e-01f, 2.34822273e-01f, 4.38052297e-01f, -3.63840014e-02f, 1.25539480e-02f, 2.23565832e-01f, -1.76973715e-01f, 1.46405458e-01f, -4.87310067e-02f, -2.68129772e-03f,
  3.84718440e-02f, 2.97641724e-01f, -1.23959437e-01f, -1.18716925e-01f, -1.21142827e-01f, -2.06805672e-02f, -2.25127637e-01f, 3.99440294e-03f, 3.47900055e-02f, 2.79540390e-01f,
  -1.41906105e-02f, 1.13685429e-01f, 2.57309861e-02f, -1.29132390e-01f, -1.35773614e-01f, -3.10602114e-02f, 1.67046428e-01f, 1.10167652e-01f, -2.13272899e-01f, 6.54779375e-02f,
  2.73359925e-01f, -1.61404669e-01f, -2.64613833e-02f, -4.61917035e-02f, 7.12210387e-02f, -1.52386457e-01f, -4.35781106e-02f, -6.98941723e-02f, -1.70891173e-02f, -1.96684692e-02f,
  6.61625043e-02f, -9.93802920e-02f, 2.11330861e-01f, -4.15404648e-01f, 2.57009000e-01f, 2.68966287e-01f, 8.94058030e-03f, -6.13725595e-02f, 2.17833981e-01f, -6.16655312e-02f,
  1.69631258e-01f, -4.84059714e-02f, 9.63514894e-02f, -6.02406897e-02f, 1.44553974e-01f, -3.14377025e-02f, 1.84332713e-01f, 8.04470703e-02f, -1.49162665e-01f, 4.44785841e-02f,
  8.22532922e-02f, 5.50565943e-02f, 7.51253543e-03f, 2.18252875e-02f, -9.73206908e-02f, -1.39547452e-01f, -2.01903686e-01f, 1.98529109e-01f, -6.24906719e-01f, 3.18675190e-01f,
  -2.24366114e-01f, -1.71889290e-01f, 3.64926457e-01f, 6.34121671e-02f, -2.97155827e-01f, 1.35165349e-01f, -3.04300338e-01f, 1.07405245e-01f, 3.32476318e-01f, -6.16229465e-03f,
  3.53998303e-01f, -6.99655861e-02f, -3.25584590e-01f, 2.15176985e-01f, 2.92110801e-01f, 4.87575457e-02f, 4.15886343e-01f, -2.57272601e-01f, -1.02469936e-01f, 2.57036358e-01f,
  -4.08068776e-01f, 4.52252209e-01f, -1.83474973e-01f, -6.11406192e-02f, 1.00642085e-01f, -4.81188446e-02f, -4.85552289e-02f, -1.06318444e-01f, -1.01972707e-01f, -7.00502470e-02f,
  -9.32635739e-02f, 5.78717031e-02f, 4.21202421e-01f, 1.14401206e-01f, -1.74246490e-01f, 3.88015695e-02f, -1.63874358e-01f, -8.52698758e-02f, 3.31981704e-02f, 4.59222756e-02f,
  2.74598319e-02f, 7.55353197e-02f, 1.01031788e-01f, -6.90514073e-02f, 5.03553808e-01f, -3.13226879e-02f, -7.42816254e-02f, -1.46473229e-01f, -3.82055603e-02f, -1.48327220e-02f,
  -1.56306237e-01f, -8.01216736e-02f, -2.08884388e-01f, -6.83470517e-02f, -1.88969910e-01f, 1.70540740e-03f, -1.11904316e-01f, -1.57274038e-03f, -4.36620340e-02f, -2.15627372e-01f,
  4.77166586e-02f, -8.93403515e-02f, -2.97857635e-02f, -9.68601927e-02f, -5.76674044e-02f, -1.52612105e-01f, 5.05628824e-01f, -1.52746707e-01f, 2.43694019e-02f, -1.12061165e-01f,
  6.37748912e-02f, -1.27069935e-01f, -6.57714754e-02f, 3.48868668e-02f, -5.10140620e-02f, 1.82647437e-01f, -1.59040540e-02f, 3.92889418e-02f, 3.55180919e-01f, -6.12030998e-02f,
  -4.88877222e-02f, 8.63895863e-02f, 2.48690750e-02f, 1.13827609e-01f, -1.36012986e-01f, 1.14539839e-01f, 8.65939558e-02f, -1.15422882e-01f, -2.84776241e-02f, 4.68419552e-01f,
  -8.69577471e-03f, -5.55794612e-02f, -2.64766216e-01f, -6.93403184e-02f, 1.81720294e-02f, 4.31941450e-02f, 3.85504924e-02f, -1.68019161e-01f, -6.40821308e-02f, -1.88292921e-01f,
  2.50936240e-01f, 1.14487670e-01f, 4.69066165e-02f, -3.29086208e-03f, 4.79138345e-02f, 1.23598017e-01f, -3.49114761e-02f, -1.35522261e-02f, 7.06471577e-02f, 2.04220444e-01f,
  -3.27808291e-01f, 1.58877328e-01f, 9.12498757e-02f, 6.28685281e-02f, -9.98987630e-02f, -8.48676562e-02f, 1.09048001e-01f, -3.25588882e-02f, 9.41468999e-02f, -1.22722901e-01f,
  1.00666836e-01f, 2.06845820e-01f, -1.61332324e-01f, -3.47311020e-01f, -3.88829559e-02f, -2.03359991e-01f, 7.77027160e-02f, 1.66190520e-01f, -2.00950846e-01f, -3.41712654e-01f,
  -1.21055111e-01f, -3.04380208e-01f, 3.08094859e-01f, -6.20572492e-02f, -1.73648030e-01f, -4.57478493e-01f, 8.06925595e-02f, 2.21997499e-01f, 2.52020299e-01f, 2.91400909e-01f,
  -4.92374539e-01f, -8.62023514e-03f, -2.86633700e-01f, -1.47208154e-01f, -2.58510470e-01f, -1.28616348e-01f, 1.46888737e-02f, -4.46294576e-01f, 5.09581268e-01f, -1.37395382e-01f,
  -3.50293294e-02f, -7.79275000e-02f, -1.05708197e-01f, -1.23833306e-01f, 1.81743935e-01f, -3.18961889e-02f, 1.54555827e-01f, 3.50484937e-01f, -2.18956858e-01f, -7.34775662e-02f,
  -1.10992625e-01f, -7.41306096e-02f, -1.23509489e-01f, -8.36086497e-02f, 1.06930546e-01f, 3.23148705e-02f, -5.19012511e-02f, -9.18967649e-02f, -1.64562494e-01f, 1.73650831e-01f,
  1.07795633e-01f, -8.90755206e-02f, -5.00032194e-02f, -3.89155038e-02f, -1.26721159e-01f, -2.97986213e-02f, -8.47944915e-02f, -8.14595670e-02f, -1.20082609e-01f, -1.80866241e-01f,
  -8.14382434e-02f, 2.40644049e-02f, -1.17885359e-01f, 2.52725501e-02f, -8.70530307e-02f, -1.25826478e-01f, 1.64154351e-01f, -3.22673167e-03f, -1.24424696e-01f, -3.38201895e-02f,
  -1.21487461e-01f, 8.72510076e-02f, -4.68495786e-02f, 5.28630204e-02f, -1.47066697e-01f, -1.43686816e-01f, 5.07508367e-02f, 4.34079617e-02f, 2.89479196e-01f, -2.11867496e-01f,
  -7.05432743e-02f, 4.57652092e-01f, 4.85225588e-01f, -4.79912870e-02f, -7.69760087e-02f, 1.19154848e-01f, 7.77212605e-02f, -1.47060990e-01f, -2.01045051e-02f, 2.88124830e-01f,
  -1.29003510e-01f, -1.34998336e-01f, -1.74719155e-01f, -1.98650956e-02f, -9.64325368e-02f, -1.96099624e-01f, -1.85276091e-01f, -7.88991824e-02f, 2.02910136e-02f, -6.21719062e-02f,
  -9.13777426e-02f, -1.25596374e-01f, -1.49273261e-01f, -4.50455733e-02f, 1.67333819e-02f, 3.04265618e-02f, -3.05652842e-02f, -8.00903291e-02f, 5.86179830e-02f, 1.75995469e-01f,
  -2.80590326e-01f, 3.79157551e-02f, 9.34532657e-02f, 4.06692587e-02f, -9.94613320e-02f, 5.18689714e-02f, 6.15157932e-02f, -2.81023905e-02f, -1.47896931e-01f, 3.31876650e-02f,
  9.96794328e-02f, 8.05908069e-03f, 1.23828929e-03f, 3.12345456e-02f, -3.14512663e-02f, -4.13760282e-02f, 5.86343147e-02f, -2.78025270e-02f, -7.49402419e-02f, 1.73698030e-02f,
  3.54494825e-02f, 1.34811386e-01f, 1.29997417e-01f, -1.50140911e-01f, 1.40685424e-01f, -3.16064775e-01f, -1.37587830e-01f, 4.21536202e-03f, 1.71651781e-01f, 2.26872548e-01f,
  5.00817418e-01f, 4.03807372e-01f, 2.49165684e-01f, 3.08176368e-01f, 1.33078471e-01f, -1.34528264e-01f, -4.60093349e-01f, 2.83180885e-02f, 2.11468384e-01f, 1.48429513e-01f,
  4.02902424e-01f, -2.61486709e-01f, 2.95037657e-01f, 3.19557846e-01f, 4.91185784e-01f, -5.48608243e-01f, -2.24740207e-01f, 1.68188244e-01f, -1.89101472e-01f, 8.90551955e-02f,
  -4.45164070e-02f, -1.20524123e-01f, -1.41554460e-01f, -1.67077243e-01f, -1.34249389e-01f, 7.19044264e-03f, 1.34571806e-01f, 2.91857328e-02f, -9.98300761e-02f, -1.23815969e-01f,
  1.51953772e-01f, -2.02330127e-01f, -5.39306365e-02f, -7.15678111e-02f, 8.97270627e-03f, 2.12804601e-01f, -8.58771577e-02f, -4.18522358e-02f, -2.55325846e-02f, -1.51670635e-01f,
  8.16554949e-02f, 9.55971256e-02f, -2.35183790e-01f, -6.01114742e-02f, 1.71226382e-01f, 2.15420738e-01f, 3.69764656e-01f, -4.24731150e-02f, -1.10946044e-01f, 7.50255510e-02f,
  6.61799088e-02f, -1.81577548e-01f, 1.57804340e-01f, 2.59981424e-01f, 9.12327692e-02f, -1.27963707e-01f, -5.24228737e-02f, -1.64351091e-01f, 4.69485186e-02f, 3.53230126e-02f,
  -1.73252329e-01f, -3.71925235e-02f, 6.67548776e-02f, 2.10199997e-01f, -3.42362151e-02f, 1.55510549e-02f, -1.62185654e-01f, -1.03755228e-01f, 1.32206261e-01f, -1.92354143e-01f,
  -5.41384667e-02f, 3.53447683e-02f, -3.87098566e-02f, 2.78980620e-02f, -2.22326159e-01f, -1.43377796e-01f, 3.71047020e-01f, -1.05498053e-01f, 2.17033461e-01f, 3.16415774e-03f,
  5.58076426e-02f, 9.87392440e-02f, -1.61417872e-01f, 4.25172448e-01f, 3.00019477e-02f, 1.20276645e-01f, -6.29760101e-02f, -9.13055539e-02f, 2.36055538e-01f, 1.75129935e-01f,
  -1.10476993e-01f, -4.63946573e-02f, -3.70046757e-02f, -1.79109663e-01f, -1.66071076e-02f, 2.08113313e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.55134383e-02f, -4.12162766e-02f, 1.14219785e-01f, -8.04490596e-02f, 8.47014487e-02f, 7.47663602e-02f, -1.17158659e-01f, -7.65742362e-02f, -1.52211217e-02f, 4.15306650e-02f,
  -5.84068820e-02f, 8.82549137e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    