/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.07013571e-01f, 3.14442247e-01f, -3.38160098e-01f, 2.42064521e-01f, 1.60898209e-01f, 4.44857441e-02f, 3.00130919e-02f, -3.70149612e-02f, 8.45129266e-02f, 1.03544138e-01f,
  1.09850138e-01f, -6.76079690e-02f, -1.38651460e-01f, -2.33246118e-01f, -1.66518182e-01f, -2.30799377e-01f, -2.20591947e-01f, -3.65902305e-01f, -3.54853183e-01f, -3.43099460e-02f,
  9.97348279e-02f, 1.16743155e-01f, -3.43935415e-02f, -1.13562465e-01f, 1.56580135e-01f, -6.36885315e-02f, -1.25000149e-01f, 1.34497911e-01f, 4.47978601e-02f, 8.12744200e-02f,
  4.65159304e-02f, 2.91054249e-01f, -7.21514374e-02f, 1.06217511e-01f, 1.05659992e-01f, 3.49867456e-02f, 5.09156585e-02f, 7.16649136e-03f, 7.24036843e-02f, 8.11189339e-02f,
  2.18706459e-01f, 7.82353058e-02f, 1.30759060e-01f, 4.17235792e-02f, 9.51421186e-02f, 7.35729709e-02f, 5.27912453e-02f, 4.76675853e-02f, 7.05040470e-02f, 6.25585765e-02f,
  2.17506275e-01f, 2.42486596e-01f, 1.28453001e-01f, 8.01811591e-02f, 6.44556284e-02f, 2.30922997e-02f, 1.59717396e-01f, 4.84470390e-02f, 6.60660397e-03f, 8.39651674e-02f,
  -8.02065209e-02f, -1.83570012e-01f, 7.33460709e-02f, -1.56147387e-02f, -6.53780401e-02f, 6.11909516e-02f, -4.70223315e-02f, -2.28457712e-02f, -8.38496312e-02f, -1.15120625e-02f,
  -1.44804213e-02f, -9.74261668e-03f, -3.36031616e-02f, 2.75356397e-02f, -2.13020854e-02f, 1.08647505e-02f, 5.60953841e-02f, -3.56308483e-02f, 1.08812973e-02f, 9.62297544e-02f,
  6.61974028e-02f, 1.90737117e-02f, -1.25773204e-02f, 3.34716998e-02f, 2.01400761e-02f, -3.51110548e-02f, 2.56065428e-02f, 4.11944743e-03f, -5.48118278e-02f, 3.19389775e-02f,
  1.17321402e-01f, 4.19207057e-03f, 2.54453393e-03f, -4.82803620e-02f, 1.08000837e-01f, 7.65564144e-02f, 5.21892831e-02f, 8.92520696e-02f, 1.13705486e-01f, 2.56766230e-02f,
  9.03457701e-02f, 1.12251593e-02f, 1.20287649e-02f, 2.64868494e-02f, -4.77895327e-03f, 6.74511865e-02f, 1.12474225e-01f, 2.48491317e-02f, 5.49532399e-02f, 1.71785727e-01f,
  -9.08305962e-03f, 3.86989675e-02f, 1.38217947e-02f, -2.17381641e-02f, 3.46431099e-02f, -5.28461784e-02f, 4.61122906e-03f, -1.70459468e-02f, -3.98980789e-02f, -2.29095891e-02f,
  -5.35889328e-01f, 4.01739739e-02f, 1.98815510e-01f, -2.68323570e-01f, -2.70365834e-01f, -8.86970907e-02f, -1.55024707e-01f, -5.81539720e-02f, -1.16061233e-01f, -5.42412773e-02f,
  -1.42735675e-01f, -1.49105430e-01f, 2.03847177e-02f, 8.62598047e-02f, 4.94182855e-02f, 2.15696946e-01f, 3.27201217e-01f, 8.62966776e-02f, -6.35313019e-02f, -1.90514207e-01f,
  -9.54231694e-02f, -6.28593639e-02f, -9.31541845e-02f, 7.37898275e-02f, 9.77184549e-02f, -1.21898286e-01f, 2.39390731e-01f, 9.45523232e-02f, -3.97291929e-02f, 2.85800815e-01f,
  1.67794794e-01f, 4.23718095e-02f, 3.62630412e-02f, 6.76858053e-02f, 1.40043437e-01f, 5.29069006e-02f, 4.54950370e-02f, 1.30805328e-01f, 3.90208177e-02f, 5.88377044e-02f,
  2.85649914e-02f, -1.06123434e-02f, 2.61458587e-02f, 1.59921467e-01f, -2.37632841e-02f, 6.35966519e-03f, 1.61589861e-01f, 1.67547643e-01f, 1.13543689e-01f, 1.68248285e-02f,
  -1.23726325e-02f, -3.27851530e-03f, 5.62594160e-02f, 1.13270186e-01f, 3.46032605e-02f, 6.82680085e-02f, 6.29094616e-02f, 1.22533426e-01f, 7.60703906e-02f, 1.82894349e-01f,
  5.86149395e-02f, -7.30140880e-02f, -1.11249425e-01f, -1.17994957e-01f, -9.60887894e-02f, -4.52747010e-02f, -1.03302643e-01f, -2.03977060e-02f, -1.40552400e-02f, -4.27354239e-02f,
  -2.92084869e-02f, -7.72885084e-02f, 4.17923601e-03f, -2.86070034e-02f, -6.05995767e-03f, 1.25031164e-02f, -7.42083639e-02f, -6.13109348e-03f, -2.99703013e-02f, -5.31606115e-02f,
  -8.03809892e-03f, -6.93320408e-02f, -1.35885330e-03f, 5.16233332e-02f, -2.39477810e-02f, 3.92788313e-02f, -5.44341207e-02f, -5.23661412e-02f, -3.50859091e-02f, -4.51691002e-02f,
  -1.62149355e-01f, 8.05577338e-02f, 1.04791455e-01f, 2.17003729e-02f, 1.70758143e-02f, 1.59902945e-01f, 2.46596094e-02f, 4.74176258e-02f, 3.22475955e-02f, 1.93682592e-02f,
  -1.48174940e-02f, 8.39133747e-03f, 7.41983354e-02f, 7.40772188e-02f, -9.62864514e-03f, 6.30566254e-02f, 8.96917749e-03f, -2.65228190e-02f, -5.70244016e-03f, 8.08147900e-03f,
  9.46471691e-02f, -9.19826999e-02f, -1.34526372e-01f, -2.57684477e-02f, 6.35076985e-02f, -1.02443658e-01f, 8.85010883e-02f, 7.90463388e-02f, 7.32703060e-02f, -7.35399798e-02f,
  5.91558814e-01f, -5.55960715e-01f, 2.41715625e-01f, 2.21024260e-01f, -4.99678068e-02f, -2.26954333e-02f, -4.14599955e-01f, -1.47117063e-01f, 4.41676416e-02f, -3.11438918e-01f,
  -3.48193914e-01f, -1.00937136e-01f, -3.98956090e-02f, -1.60083957e-02f, 7.04915076e-02f, -1.64225139e-02f, 2.32828394e-01f, 3.39008003e-01f, 3.33275318e-01f, -3.86960618e-02f,
  -1.91059008e-01f, 6.64699897e-02f, 3.32499206e-01f, 1.78734988e-01f, -1.82987779e-01f, -1.41822612e-02f, -5.64845279e-02f, 1.07917204e-01f, -4.25227731e-02f, -1.00115731e-01f,
  -1.25336066e-01f, 1.55910552e-02f, 9.35741290e-02f, -7.62001202e-02f, -3.97657752e-02f, 4.83316509e-03f, -4.64873947e-03f, 3.84103581e-02f, 5.51051088e-03f, 4.42959461e-03f,
  3.20531130e-02f, 1.04461554e-02f, -2.48785019e-02f, -4.93423007e-02f, 2.73973681e-02f, -4.62183654e-02f, 2.64954958e-02f, 9.18509737e-02f, 1.18261941e-01f, -7.28939325e-02f,
  -1.59215555e-01f, -1.19780324e-01f, 8.18399861e-02f, -6.01560101e-02f, -8.13524425e-02f, 3.55632715e-02f, -1.20502003e-01f, 5.43175973e-02f, 7.26142898e-02f, -1.39875397e-01f,
  -6.29613642e-03f, -2.98269931e-02f, 1.10984417e-02f, 2.21730918e-02f, -1.22875586e-01f, 1.56832151e-02f, 1.57220736e-02f, -3.09511125e-02f, 3.25403437e-02f, 7.40130767e-02f,
  -6.14768080e-02f, 2.53312606e-02f, -2.13039983e-02f, 3.45749222e-02f, -2.54194029e-02f, 4.29451503e-02f, 8.24068114e-02f, 4.06585587e-03f, 2.87737809e-02f, 1.44471880e-02f,
  -8.09006467e-02f, 6.53094947e-02f, -3.08265109e-02f, 1.28703918e-02f, -5.11266245e-03f, 1.92873478e-02f, 5.01156263e-02f, -7.31728896e-02f, 5.29147871e-02f, 2.65589617e-02f,
  -1.03038922e-01f, 1.01715364e-01f, -5.98043352e-02f, 3.93394083e-02f, -7.00945780e-02f, -3.65447812e-02f, -1.96704511e-02f, -9.84092057e-02f, -4.32961099e-02f, -2.41269041e-02f,
  -1.04468703e-01f, 8.54790304e-03f, -2.23318748e-02f, -1.21301174e-01f, 5.21831727e-03f, -7.78569505e-02f, -4.60273325e-02f, -2.12852787e-02f, 2.61318870e-02f, 2.08485566e-04f,
  -6.98136762e-02f, 2.29139887e-02f, -6.38512755e-03f, -5.47855087e-02f, -5.06848097e-02f, 9.25405771e-02f, -1.38506740e-01f, -7.30505139e-02f, 1.27927018e-02f, -2.12658748e-01f,
  -6.93012178e-01f, 4.29963827e-01f, -2.08590657e-01f, -1.92649812e-01f, 2.65688807e-01f, 2.36017350e-02f, 2.73402095e-01f, 2.44805086e-02f, -1.34924263e-01f, 1.61999345e-01f,
  2.42816314e-01f, 2.45573614e-02f, -9.53684449e-02f, 6.39029220e-02f, -1.57007009e-01f, -1.57496353e-04f, -9.49772149e-02f, -3.53503078e-01f, -3.91157418e-01f, -1.76271591e-02f,
  2.05649391e-01f, -1.01164885e-01f, -3.69360238e-01f, -2.20767930e-01f, 6.83738217e-02f, 6.06662519e-02f, 2.57853661e-02f, 5.13274819e-02f, 1.68019548e-01f, -7.14384718e-03f,
  -1.54579759e-01f, -1.32810846e-01f, -8.33045468e-02f, -4.80257869e-02f, -3.95512488e-03f, -1.12027347e-01f, -1.00361675e-01f, -6.26237839e-02f, -6.98798969e-02f, -5.07069714e-02f,
  -3.56926844e-02f, -1.32518979e-02f, -1.40390873e-01f, -7.41246715e-02f, -2.75032911e-02f, -6.54441342e-02f, -8.40031803e-02f, -2.54603595e-01f, -1.98928431e-01f, 2.20110472e-02f,
  2.60061547e-02f, 6.23351894e-03f, -9.18722823e-02f, -8.57074466e-03f, -1.23787753e-01f, -1.26384780e-01f, 2.61275433e-02f, -1.31220624e-01f, -1.67378649e-01f, -8.10314491e-02f,
  -6.96745887e-02f, 6.20853975e-02f, -1.80473775e-02f, 2.61996686e-02f, 6.13126159e-03f, -3.54209580e-02f, -5.62566966e-02f, 5.62959798e-02f, -5.63244009e-03f, 4.27242368e-02f,
  -3.21159489e-03f, 7.50384061e-03f, -3.34888101e-02f, -1.22688031e-02f, -6.81047700e-03f, -4.04176041e-02f, -2.82680131e-02f, 6.55877776e-03f, -3.90134640e-02f, 6.65888563e-03f,
  -3.54618914e-02f, 2.81878710e-02f, -1.56998411e-02f, -5.84635176e-02f, 6.19768761e-02f, -9.03980881e-02f, -8.36474150e-02f, 6.31087348e-02f, 6.57504350e-02f, 3.33743282e-02f,
  1.72087476e-01f, -7.10040852e-02f, -7.66405165e-02f, -2.74464674e-02f, -7.89510086e-02f, -4.71490249e-02f, -4.11073081e-02f, -1.96581613e-02f, -9.94660407e-02f, -5.58853336e-02f,
  -6.54820874e-02f, -1.22409888e-01f, -3.14901099e-02f, -5.07141277e-02f, -6.56448081e-02f, -3.19663472e-02f, 5.97057939e-02f, 9.42521170e-03f, -5.70844822e-02f, 5.38545707e-03f,
  3.57146375e-02f, 7.97003061e-02f, -6.84439540e-02f, -1.80479772e-02f, -7.73998946e-02f, -5.01316637e-02f, -8.24070442e-03f, 3.15365307e-02f, -6.69478476e-02f, 1.37449056e-01f,
  -1.37818664e-01f, 2.64168419e-02f, 4.88117617e-03f, -1.48812816e-01f, -6.16176575e-02f, -9.98846516e-02f, -8.05931762e-02f, -1.80882096e-01f, -1.19276419e-01f, -1.82290018e-01f,
  -1.60645902e-01f, -2.10137129e-01f, -1.19892947e-01f, -4.04383056e-02f, -3.54539230e-02f, -5.15316427e-02f, 1.85507774e-01f, 9.04493704e-02f, -1.77766308e-01f, -4.87723127e-02f,
  8.28303322e-02f, -4.48245704e-02f, -1.23726234e-01f, 5.60639761e-02f, 1.98145315e-01f, 1.92826446e-02f, 3.37831303e-02f, 2.11077645e-01f, 1.86581284e-01f, 3.91589552e-01f,
  -7.67783821e-02f, -6.40341341e-02f, -1.98081091e-01f, -1.31924115e-02f, -7.67318010e-02f, -3.22792828e-02f, -7.11327866e-02f, 7.28149414e-02f, 3.39354239e-02f, -8.35728087e-03f,
  5.11315502e-02f, 9.14791971e-02f, 3.36432979e-02f, 2.44600344e-02f, 8.14334117e-03f, -9.51342657e-02f, -3.26839611e-02f, -3.70806307e-02f, 7.35658687e-03f, -4.05735709e-02f,
  -3.20993029e-02f, 2.08243374e-02f, -4.66543175e-02f, -8.40078667e-02f, -4.85240147e-02f, -6.29223709e-04f, -6.91802502e-02f, 3.51044303e-03f, -6.24839887e-02f, -3.27414111e-03f,
  5.23980297e-02f, 1.22371800e-01f, 1.20927691e-01f, 5.56314364e-02f, 1.85759198e-02f, -2.20246986e-02f, 8.61142650e-02f, -2.06776196e-03f, 3.56225632e-02f, 1.03952410e-03f,
  2.89834547e-03f, -3.35750096e-02f, 3.32258940e-02f, 1.75024923e-02f, -2.50852015e-02f, 8.09532702e-02f, 6.23732135e-02f, 6.89328834e-03f, -3.70024634e-03f, 4.03120667e-02f,
  6.85749575e-02f, 1.04918525e-01f, 4.08792347e-02f, -2.52114628e-02f, 9.24339667e-02f, 6.21625297e-02f, 5.08656763e-02f, 4.42872606e-02f, 4.83719520e-02f, 4.66914736e-02f,
  -3.17730695e-01f, -1.60131350e-01f, -8.95349905e-02f, -1.42375901e-01f, -3.02848797e-02f, -4.39544283e-02f, -6.80283457e-02f, -5.01984395e-02f, -6.84072124e-03f, -2.13363040e-02f,
  -1.25926197e-01f, -6.81444332e-02f, -1.70691520e-01f, -1.10773295e-01f, -1.32563755e-01f, -1.27648309e-01f, -1.02105111e-01f, -1.16517693e-01f, -9.87370908e-02f, -8.27719048e-02f,
  -1.19266398e-01f, -2.11892545e-01f, -2.52259910e-01f, -1.70805737e-01f, -1.39058501e-01f, -1.36000365e-01f, -1.29068464e-01f, -1.25906497e-01f, -2.66163379e-01f, -4.25706357e-01f,
  2.26973787e-01f, -3.93979132e-01f, -2.69537717e-01f, -2.22898111e-01f, -2.46308506e-01f, -3.77769545e-02f, -2.02142105e-01f, 4.39028293e-02f, -1.26402542e-01f, -1.93299785e-01f,
  -7.78242424e-02f, 1.21167816e-01f, -3.84549424e-02f, 8.43948200e-02f, 1.15620710e-01f, -3.24572265e-01f, -2.20199525e-01f, -7.84895569e-02f, 3.25416833e-01f, 8.58302191e-02f,
  -5.00894487e-02f, -1.13253286e-02f, 3.25629525e-02f, 1.35084298e-02f, -2.56384671e-01f, -1.49002463e-01f, -2.92249858e-01f, -9.19838175e-02f, -1.78442463e-01f, -5.04708707e-01f,
  -1.77781433e-01f, -1.93940312e-01f, 6.86020171e-03f, -9.94824693e-02f, -1.75428614e-01f, -7.21115768e-02f, -1.02328144e-01f, -1.56396329e-01f, -1.51577309e-01f, -1.57908246e-01f,
  -1.34101659e-01f, -1.70745179e-01f, -1.03920914e-01f, -1.68483809e-01f, -1.44433886e-01f, -4.29407954e-02f, -7.32399672e-02f, -1.45781904e-01f, -1.45856798e-01f, -1.49891913e-01f,
  -2.74844855e-01f, -3.09354633e-01f, -2.62399405e-01f, -1.05436996e-01f, -2.15195030e-01f, -1.99929237e-01f, -2.55989164e-01f, -1.78239986e-01f, -1.07134506e-01f, -3.83723557e-01f,
  -5.93145303e-02f, 6.25087619e-02f, 1.69630915e-01f, 7.59730563e-02f, 5.56657501e-02f, 1.02851041e-01f, 9.20934230e-02f, 7.56577700e-02f, 7.80919120e-02f, -5.58800995e-04f,
  8.02668184e-02f, 6.80464134e-02f, 4.25771140e-02f, 6.50164112e-02f, 6.16032258e-02f, 1.69089902e-02f, 1.15987659e-01f, 4.42166440e-02f, 1.33088470e-01f, 1.03445150e-01f,
  1.27643868e-01f, 1.32969305e-01f, 3.55429612e-02f, 3.42626981e-02f, 6.84038401e-02f, 6.18141852e-02f, 7.71114603e-02f, 1.62166819e-01f, 7.58454055e-02f, 1.44681722e-01f,
  -1.29394054e-01f, 1.48235083e-01f, -1.53661981e-01f, -9.77265462e-02f, -4.98621725e-02f, -4.33938466e-02f, -1.79092526e-01f, -4.56066318e-02f, -1.18706621e-01f, -9.15386826e-02f,
  -3.88943255e-02f, 3.55200423e-03f, -9.82549414e-02f, -8.14890489e-02f, -1.19926780e-01f, -1.18272856e-01f, -1.00823291e-01f, -1.36009544e-01f, -1.03253804e-01f, -1.59609571e-01f,
  -1.38202056e-01f, -1.25854701e-01f, -7.53840134e-02f, -2.38893405e-01f, -1.29274592e-01f, -1.39440894e-01f, -7.97776729e-02f, -1.51219398e-01f, -1.29688889e-01f, -1.31065458e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.33933067e-01f, 1.36146814e-01f, -5.09983540e-01f, -2.03471735e-01f, 4.08154726e-01f, 3.13221693e-01f, 3.86787772e-01f, 4.08288762e-02f, -3.62284780e-02f, -9.98527743e-03f,
  1.49403036e-01f, 2.60705709e-01f, 6.51772097e-02f, 2.69750327e-01f, 1.52121618e-01f, 1.55492678e-01f, 9.93279591e-02f, -6.88527301e-02f, -8.06167647e-02f, 2.27112189e-01f,
  3.64935786e-01f, -2.31923521e-01f, -3.79439890e-01f, -1.71357155e-01f, -9.96231735e-02f, 6.59519434e-02f, -1.66075572e-01f, -2.01157138e-01f, 1.29300326e-01f, -1.42167285e-02f,
  -1.49898618e-01f, -2.77277291e-01f, 3.08576487e-02f, 7.84291625e-02f, -2.22213894e-01f, -2.46083453e-01f, -2.22982720e-01f, -2.02703744e-01f, 5.47934882e-02f, -1.67802915e-01f,
  -6.76956624e-02f, -1.61496565e-01f, 3.92111540e-02f, -5.10631390e-02f, -1.58800870e-01f, 1.71814337e-02f, -2.95934808e-02f, -2.59455532e-01f, -2.26929650e-01f, -8.01949352e-02f,
  3.45791280e-01f, 4.68759723e-02f, -3.02330226e-01f, -5.16155511e-02f, -8.54059979e-02f, -7.68616423e-02f, -2.22159475e-01f, -1.60788625e-01f, -2.95551687e-01f, -5.00936270e-01f,
  2.83693466e-02f, -2.04657614e-02f, 4.21203487e-02f, -6.61431327e-02f, 3.68501022e-02f, 1.31756082e-01f, 4.83755656e-02f, 7.98682347e-02f, 1.24282375e-01f, -1.41089752e-01f,
  1.46434277e-01f, 8.00467357e-02f, 8.44480768e-02f, -4.37564664e-02f, 7.35824043e-03f, -6.77475333e-02f, 2.56270636e-02f, -8.75906125e-02f, -1.17383815e-01f, -3.08525246e-02f,
  1.50451645e-01f, 2.57728938e-02f, -4.90979217e-02f, 3.95424478e-02f, 1.63797691e-01f, 6.76315650e-02f, -5.41897900e-02f, 1.38878256e-01f, 6.79059625e-02f, -7.52207786e-02f,
  -7.78739750e-02f, 2.19538361e-01f, -1.21707834e-01f, 5.78385368e-02f, -4.12858799e-02f, -7.82189518e-02f, -6.05503805e-02f, 8.33255053e-02f, -8.96519721e-02f, -7.08537549e-02f,
  1.70633011e-02f, -2.03413814e-01f, -1.52006205e-02f, -1.10268608e-01f, 5.58926240e-02f, 7.86171705e-02f, 1.59670249e-01f, 8.06939751e-02f, -8.98926519e-04f, -2.45096967e-01f,
  -7.58433715e-02f, 3.94996768e-03f, -9.03071091e-02f, -2.03294419e-02f, -1.26728669e-01f, 7.07476288e-02f, -1.16303414e-01f, -1.15136892e-01f, -1.23070620e-01f, -3.73300046e-01f,
  6.96699023e-01f, 2.62538105e-01f, 3.56151313e-01f, -6.38019070e-02f, 2.22759590e-01f, 2.74880558e-01f, 5.44553757e-01f, 1.03907891e-01f, -1.79712236e-01f, -4.54125032e-02f,
  -1.17503956e-01f, -3.64694506e-01f, -3.52772325e-01f, -3.28004122e-01f, -1.67479529e-03f, 2.30038241e-02f, 4.73023579e-02f, 7.67571479e-02f, 4.80225804e-04f, 5.51444218e-02f,
  -8.36539790e-02f, 1.57038033e-01f, 2.34325230e-01f, 6.56699091e-02f, 9.61145163e-02f, -2.15302899e-01f, -4.10244279e-02f, 2.73878574e-01f, 1.98175739e-02f, -3.85260917e-02f,
  4.96455329e-03f, 3.44058067e-01f, -2.85153121e-01f, -1.04928873e-01f, -4.90047485e-02f, -1.73265144e-01f, -5.16099967e-02f, -2.62752268e-02f, -7.43328482e-02f, -3.41633596e-02f,
  -7.05712512e-02f, -6.19558915e-02f, -8.79318938e-02f, -1.11302204e-01f, 6.44297749e-02f, 1.46613384e-04f, -1.74578410e-02f, 1.53001333e-02f, -9.07936022e-02f, -4.32957672e-02f,
  -2.58770436e-01f, -7.69222528e-03f, 2.58173704e-01f, -1.16885742e-02f, -1.21863976e-01f, -1.97579578e-01f, 1.16204210e-01f, 1.10445358e-01f, -6.11762032e-02f, -5.88874072e-02f,
  -2.48289689e-01f, 9.16201174e-02f, -8.90158676e-03f, -1.66156724e-01f, -4.76182066e-02f, -2.37054806e-02f, -8.20789114e-02f, 3.96005772e-02f, -6.78579733e-02f, 2.54259054e-02f,
  -1.24015838e-01f, -1.46335065e-01f, -1.42918482e-01f, -1.19230457e-01f, -1.66988671e-01f, -3.02248634e-02f, 2.87611317e-02f, -9.71110612e-02f, -3.89922224e-02f, -1.01517506e-01f,
  -8.90013874e-02f, 4.15463857e-02f, -2.83726193e-02f, -1.39816016e-01f, -5.45517392e-02f, -1.52414382e-01f, -1.27072409e-01f, -2.06874996e-01f, 4.15217802e-02f, 5.05808182e-03f,
  -5.54108500e-01f, -3.08967203e-01f, -1.34170145e-01f, -1.31107569e-01f, 1.92029715e-01f, -1.05663873e-01f, -2.42523521e-01f, -1.33518115e-01f, 9.86337736e-02f, 1.88803170e-02f,
  1.20633148e-01f, -1.02258362e-02f, -7.87382498e-02f, 1.54152634e-02f, -1.20492028e-02f, 7.63845444e-03f, 1.87402144e-02f, 3.41123454e-02f, -5.18522151e-02f, -8.43829513e-02f,
  -1.52016655e-01f, 1.16710678e-01f, -4.95104939e-02f, -2.52082967e-03f, -1.50664030e-02f, -1.17396079e-01f, 6.57564849e-02f, -4.89316555e-03f, -2.30326150e-02f, 1.51142571e-02f,
  3.17171633e-01f, -4.12890047e-01f, -5.88083744e-01f, -2.03087583e-01f, -3.19898874e-01f, -8.13723654e-02f, -2.82550424e-01f, 1.12227954e-01f, 5.42517118e-02f, -3.50538820e-01f,
  1.51554853e-01f, 3.24817717e-01f, -1.62546616e-02f, 8.06349069e-02f, 7.89328068e-02f, -5.38335085e-01f, -5.17313242e-01f, -4.78616729e-02f, 4.03738528e-01f, 2.82501489e-01f,
  1.70442253e-01f, -7.53549561e-02f, 1.59512118e-01f, -1.35201951e-02f, -2.77936041e-01f, -2.12694593e-02f, -5.54486334e-01f, -1.39615625e-01f, -8.97558630e-02f, -4.12644297e-01f,
  -2.48236045e-01f, 8.48899260e-02f, 2.09417507e-01f, 1.50787592e-01f, -1.01052225e-01f, 1.35330781e-01f, 5.88278174e-02f, -9.70596522e-02f, 4.52574268e-02f, -5.74605167e-02f,
  1.58417057e-02f, 1.17457425e-02f, 1.02006190e-01f, -4.35306616e-02f, -1.65115260e-02f, -1.36749921e-02f, -5.04636839e-02f, -1.03974028e-03f, 4.66930121e-02f, -1.18251562e-01f,
  -2.94931754e-02f, -1.40233457e-01f, -3.35195996e-02f, -1.42245695e-01f, -2.37394795e-02f, -8.00614655e-02f, -9.79300886e-02f, 5.17631508e-02f, -1.48193523e-01f, -3.22541445e-01f,
  1.52644869e-02f, 3.78032140e-02f, 1.34823322e-02f, 8.97597969e-02f, 1.33600563e-01f, -9.33693722e-02f, -3.87786217e-02f, 2.07274836e-02f, 7.53474655e-03f, 9.41173583e-02f,
  -8.77208039e-02f, -4.13372042e-03f, 6.76241666e-02f, -7.09791780e-02f, -8.66301805e-02f, -9.60581750e-03f, 8.71439558e-03f, 7.20412750e-03f, 3.59226875e-02f, 7.88761303e-02f,
  7.54741356e-02f, -1.81021378e-03f, -5.81574887e-02f, 6.12765886e-02f, -5.23717701e-02f, -1.91303696e-02f, -9.49176587e-03f, 4.47625145e-02f, 8.18671286e-02f, -2.99443165e-03f,
  4.69175428e-02f, -9.07386541e-02f, -4.11916263e-02f, 9.15735438e-02f, -6.98314756e-02f, -7.78362714e-03f, -4.23623361e-02f, -1.49626300e-01f, -5.88485077e-02f, 6.98711816e-03f,
  1.22507863e-01f, 6.18982017e-02f, -9.98996198e-02f, 4.40757227e-04f, -1.74673293e-02f, -5.67554012e-02f, 1.82610732e-02f, 9.06376019e-02f, 3.55445361e-03f, -5.76139279e-02f,
  -8.58090594e-02f, 1.23397648e-01f, 1.53452128e-01f, -5.70333935e-02f, -4.75340411e-02f, 1.17966436e-01f, -1.21610455e-01f, 1.37189124e-03f, 1.51241511e-01f, -1.79578438e-01f,
  5.84564090e-01f, -6.03887379e-01f, -5.26983619e-01f, 9.92983729e-02f, 1.11066841e-01f, 1.90413103e-01f, -4.42690253e-02f, 1.26742721e-01f, 2.22129017e-01f, -1.64722800e-01f,
  -2.32428789e-01f, 3.43684852e-02f, -1.74533010e-01f, -1.05388522e-01f, 2.14095339e-02f, -2.13601604e-01f, -1.68005824e-01f, -2.33300813e-02f, 3.02282065e-01f, 3.04904729e-01f,
  1.19762786e-01f, 1.39071345e-01f, 1.80635631e-01f, 5.16856648e-02f, -4.42888215e-02f, -4.06944863e-02f, -4.27100122e-01f, -2.77836621e-01f, -3.12371820e-01f, -5.01474321e-01f,
  -4.92130034e-02f, -3.99542302e-01f, 1.30593225e-01f, -4.38366272e-02f, -7.54886419e-02f, 3.22531909e-02f, 3.18979695e-02f, -1.42399177e-01f, -1.38940811e-01f, -4.97871190e-02f,
  -1.54495984e-01f, -2.07834393e-02f, -7.63064772e-02f, 2.30694562e-02f, 6.80892169e-02f, 2.22485121e-02f, -5.43837361e-02f, -3.06800585e-02f, -2.10486606e-01f, -1.50741234e-01f,
  -2.54749149e-01f, -4.29163920e-03f, -8.31789803e-03f, -7.63232261e-02f, -8.25700685e-02f, -9.29202065e-02f, -2.41090938e-01f, -2.84048859e-02f, -1.27432361e-01f, 4.55268547e-02f,
  7.38617852e-02f, 5.09055518e-02f, -3.37861404e-02f, -4.12685126e-02f, 9.54406038e-02f, 2.02497244e-02f, -6.60767779e-02f, 1.31681457e-01f, -2.69453581e-02f, -5.70080755e-03f,
  -6.66642794e-03f, -7.74359033e-02f, -8.78406465e-02f, -5.78056723e-02f, -8.63443762e-02f, -2.60025356e-02f, 7.53103290e-03f, -1.77114740e-01f, -1.02500081e-01f, 4.81142104e-02f,
  4.31131683e-02f, 2.50724126e-02f, -2.82635968e-02f, -1.75825227e-02f, -8.87961164e-02f, -3.39855216e-02f, -6.09695278e-02f, 1.63499992e-02f, -3.39051522e-02f, 2.03265175e-02f,
  3.17172825e-01f, -2.06820115e-01f, 1.96100339e-01f, -8.37124139e-02f, -2.39005405e-03f, -9.09452140e-02f, -1.19871765e-01f, -9.27336514e-03f, -6.25391584e-03f, 4.79793884e-02f,
  -1.48202404e-01f, 4.13149633e-02f, -2.05334499e-01f, -6.43395409e-02f, 1.70541584e-01f, 5.34596927e-02f, -2.50383150e-02f, 2.63450090e-02f, -6.20660521e-02f, -1.91243030e-02f,
  -1.99015010e-02f, 2.04245463e-01f, 2.63757914e-01f, 1.89333692e-01f, 2.17254870e-02f, 1.90780342e-01f, 1.66663021e-01f, 7.77751431e-02f, 2.45500132e-01f, 3.74509126e-01f,
  3.94715220e-01f, 9.51963365e-02f, 2.16963701e-03f, 4.16653216e-01f, -1.14564821e-01f, -9.03771967e-02f, -1.04547694e-01f, 4.42768484e-02f, 1.01688050e-01f, 1.33238390e-01f,
  2.67313644e-02f, 1.51479274e-01f, 2.28433609e-01f, 9.14409161e-02f, 1.84559301e-02f, -9.93144605e-03f, 1.75138444e-01f, 2.16710582e-01f, 3.49193513e-02f, 1.27523035e-01f,
  2.19826043e-01f, 4.39102463e-02f, -1.05681822e-01f, 1.66896023e-02f, 2.58813351e-01f, 1.67354301e-01f, -8.76720026e-02f, 3.19655202e-02f, 3.40927280e-02f, 5.24721682e-01f,
  2.67901868e-01f, -2.78318208e-02f, 4.86108027e-02f, -1.10730276e-01f, -2.85566561e-02f, 6.65235147e-03f, -1.81310177e-02f, -1.39128029e-01f, -8.10566992e-02f, -8.08194205e-02f,
  2.80050095e-02f, -3.80539745e-02f, 5.61474264e-03f, -6.93148002e-02f, -8.14917963e-03f, 1.03661686e-03f, -6.10137433e-02f, 5.33423461e-02f, 7.52862915e-03f, 6.32740185e-02f,
  1.57345623e-01f, -7.20806569e-02f, -2.20942482e-01f, -1.51691258e-01f, 5.09392470e-03f, 1.01276888e-02f, -9.23494622e-02f, 6.98139742e-02f, -1.13335818e-01f, 6.88959807e-02f,
  -7.09239244e-02f, -6.05901778e-02f, 7.44756386e-02f, 1.28492475e-01f, 1.19976543e-01f, 9.15138051e-02f, 1.25297248e-01f, -6.45923093e-02f, 7.40813389e-02f, 6.31462038e-02f,
  5.39519191e-02f, -1.56357326e-02f, -6.04275800e-02f, -2.93980315e-02f, 4.21308205e-02f, -4.00699750e-02f, -4.80277464e-02f, -2.76152734e-02f, -1.62850663e-01f, -1.55073240e-01f,
  7.35902740e-03f, 1.26721799e-01f, 3.05789262e-02f, 2.17213839e-01f, 3.35838273e-02f, 8.08166414e-02f, 3.54441591e-02f, 1.29220244e-02f, -6.84256852e-02f, -7.59344175e-02f,
  -3.14153582e-01f, -4.57412392e-01f, 3.04194242e-01f, 1.42270520e-01f, -1.79972395e-01f, -1.96863577e-01f, 5.91838807e-02f, -2.11952582e-01f, -1.50990501e-01f, -3.65572758e-02f,
  -1.81965381e-01f, 2.55753659e-02f, -1.97294474e-01f, 7.41219381e-03f, -4.10167687e-02f, -1.14241373e-02f, -4.50299196e-02f, 8.43816996e-02f, -1.31225675e-01f, -1.34167433e-01f,
  4.29869220e-02f, -2.24075258e-01f, -1.71153069e-01f, -1.07787848e-01f, -4.92529012e-02f, -1.75412565e-01f, -1.13092244e-01f, -1.35673240e-01f, -3.02439719e-01f, -1.79958090e-01f,
  -7.01940775e-01f, -2.46802956e-01f, -7.57731218e-03f, -3.85422736e-01f, -1.25920147e-01f, 1.08975716e-01f, 1.46916002e-01f, -1.00149013e-01f, -2.93093741e-01f, -1.42696917e-01f,
  -8.58411640e-02f, -6.77394494e-03f, 5.16814366e-02f, 6.18188232e-02f, 2.07064986e-01f, 3.18371773e-01f, 1.83325797e-01f, 5.84890768e-02f, 1.85325518e-01f, 1.79322287e-01f,
  4.02283408e-02f, -2.11717665e-01f, -2.18704611e-01f, -1.76504090e-01f, -1.81649834e-01f, 6.26650592e-03f, -7.92136788e-02f, -1.54312730e-01f, -4.67425538e-03f, -1.33214474e-01f,
  4.79245216e-01f, -3.49916935e-01f, -7.80650601e-02f, -1.18669622e-01f, -7.92496577e-02f, -1.89226300e-01f, -1.73610989e-02f, -1.75946534e-01f, -1.09666504e-01f, -1.71984714e-02f,
  -2.16376871e-01f, -4.57792357e-02f, -4.62765284e-02f, 3.18046510e-02f, -7.47760013e-02f, -1.82320803e-01f, -1.17483534e-01f, -1.05949948e-02f, 2.69011203e-02f, -1.69303305e-02f,
  5.21090056e-04f, -4.55180481e-02f, 9.51302350e-02f, 1.11103058e-01f, -1.40653640e-01f, 4.58610952e-02f, -1.77130446e-01f, -1.32566005e-01f, 3.64844874e-02f, 2.01817267e-02f,
  1.50084630e-01f, 7.98121467e-02f, 5.98333664e-02f, -2.29807664e-02f, -3.31916027e-02f, 1.85483769e-01f, 1.78073555e-01f, 8.97789150e-02f, 6.39281273e-02f, 6.55426234e-02f,
  -9.28001199e-03f, 6.98947236e-02f, 5.34123816e-02f, -9.60370153e-03f, -8.24405253e-02f, -1.58475749e-02f, -4.41545360e-02f, -4.42676544e-02f, -9.53503624e-02f, -1.45484671e-01f,
  -6.85809106e-02f, -3.31118852e-02f, -4.73276936e-02f, 8.23514163e-03f, -1.07437767e-01f, -8.05859417e-02f, -1.17399938e-01f, -1.65960006e-02f, -9.65979788e-03f, 5.99445701e-02f,
  5.66411257e-01f, -2.66558304e-03f, 1.15993641e-01f, 2.09330320e-02f, -1.32861165e-02f, -2.03678042e-01f, -4.43550125e-02f, -1.31530156e-02f, 1.01473788e-02f, 5.00979014e-02f,
  -9.32362825e-02f, -8.50177333e-02f, 2.89794207e-02f, -9.77687761e-02f, -5.95816225e-02f, -1.47273704e-01f, -5.01215272e-02f, 3.38071547e-02f, 2.19540000e-02f, 9.99906752e-03f,
  4.30504940e-02f, 2.22719625e-01f, 3.24023187e-01f, 1.25388756e-01f, 1.05416104e-01f, 3.20582509e-01f, 2.72043347e-01f, 8.43594670e-02f, 1.41081452e-01f, 3.48127991e-01f,
  2.00051472e-01f, 3.40251088e-01f, 3.32255810e-01f, 3.10634732e-01f, 3.26435000e-01f, 4.19109881e-01f, 4.86558557e-01f, 3.30726922e-01f, 1.11625262e-01f, 1.52668417e-01f,
  2.54166037e-01f, 1.82788357e-01f, 1.86574057e-01f, 1.05646616e-02f, 2.11175621e-01f, 1.70658648e-01f, 1.41537115e-01f, -4.37376387e-02f, 1.96410306e-02f, 6.53054342e-02f,
  1.46483287e-01f, 1.37633547e-01f, -2.65662875e-02f, -7.48589337e-02f, 2.14024186e-02f, 1.30737990e-01f, 1.39791787e-01f, 2.16594458e-01f, 1.83525249e-01f, 3.59706767e-02f,
  1.66610181e-01f, 1.91120788e-01f, -8.42011645e-02f, -2.23452538e-01f, -3.92287374e-02f, -1.87810063e-01f, 1.03265224e-02f, -1.99677095e-01f, -9.61328521e-02f, -9.24385488e-02f,
  -9.15333778e-02f, -9.42444652e-02f, 8.21354091e-02f, -6.43070638e-02f, -1.12353794e-01f, -3.25285867e-02f, -6.61294684e-02f, -2.73855112e-04f, 1.63094193e-01f, 8.57357681e-03f,
  1.31690176e-02f, 1.14663504e-01f, 2.04102725e-01f, 1.52221531e-01f, 2.11430296e-01f, 2.99760066e-02f, 1.16103061e-01f, 3.67369652e-02f, 1.45810068e-01f, -5.29357716e-02f,
  9.49588493e-02f, 2.28550985e-01f, 2.06677809e-01f, 1.11697046e-02f, 6.11291640e-02f, -1.38892874e-01f, -2.66303914e-03f, -1.40715064e-02f, 6.17939197e-02f, -1.25449240e-01f,
  -7.75672868e-02f, 9.13873091e-02f, -2.37659514e-02f, 7.27092996e-02f, -5.82329892e-02f, 1.16754375e-01f, -8.03619996e-02f, 6.51231781e-02f, -1.69049762e-02f, -1.74041484e-02f,
  8.99486095e-02f, 2.85579860e-02f, -1.12317123e-01f, -3.53641361e-02f, 5.63154705e-02f, 1.60723045e-01f, 2.66768560e-02f, -1.65897198e-02f, 5.43026428e-04f, 5.70530109e-02f,
  8.94559845e-02f, 4.18158114e-01f, -5.67789488e-02f, -1.29832044e-01f, -3.83021608e-02f, -1.92397445e-01f, 8.52738023e-02f, -1.71675533e-01f, -1.74672931e-01f, -4.77313362e-02f,
  -1.24467202e-01f, -1.40756831e-01f, -3.19817476e-02f, -7.25335479e-02f, -1.96225658e-01f, -1.44193202e-01f, -3.39781903e-02f, 1.01549275e-01f, 5.13437912e-02f, -7.08025098e-02f,
  -1.20766409e-01f, -7.09409192e-02f, -8.79680216e-02f, -6.66890517e-02f, -3.14295106e-02f, -1.70324624e-01f, -8.05961043e-02f, -4.90279905e-02f, -1.16784275e-01f, -2.24199429e-01f,
  3.22976053e-01f, 4.13678020e-01f, 4.20275152e-01f, 4.70200270e-01f, 2.00553969e-01f, 1.37514398e-01f, 2.45531783e-01f, 1.23654716e-01f, 3.09931301e-02f, 1.57133847e-01f,
  3.40773463e-02f, -1.55889709e-02f, 9.47165340e-02f, 1.51731908e-01f, 1.81094825e-01f, 2.43489549e-01f, 2.32311621e-01f, 1.63017854e-01f, -2.04077121e-02f, 2.08087149e-03f,
  -9.37173422e-03f, -1.49570405e-01f, -6.24962449e-02f, 6.58606272e-03f, 1.08117931e-01f, -8.84023756e-02f, -8.46768022e-02f, 2.40110382e-02f, -3.21224295e-02f, 2.29121551e-01f,
  2.50387758e-01f, 1.76359266e-01f, 7.98141882e-02f, -8.44964758e-02f, 5.63991703e-02f, 7.00984746e-02f, 1.98645722e-02f, -8.43131542e-02f, -6.44985959e-02f, 1.00352429e-01f,
  -6.20870665e-02f, -1.51166350e-01f, -4.15368332e-03f, -8.86390582e-02f, -5.84005713e-02f, 2.50991521e-04f, -4.68310229e-02f, 8.82152021e-02f, 7.57794604e-02f, 8.28959718e-02f,
  -1.70750711e-02f, 1.58636384e-02f, 1.94824338e-02f, -1.04104713e-01f, 1.30213397e-02f, 3.85433994e-02f, -1.01264408e-02f, -2.21080482e-02f, 6.08211122e-02f, 7.33407810e-02f,
  -3.91295813e-02f, -2.34949291e-02f, -8.66281018e-02f, -8.58380720e-02f, -1.86987430e-01f, -2.22219855e-01f, 7.45456442e-02f, -1.41094282e-01f, -1.48571149e-01f, -2.40264401e-01f,
  -1.63167015e-01f, 4.62427288e-02f, 1.13197453e-01f, 6.82072435e-03f, -2.26182062e-02f, -2.06946619e-02f, 1.17900550e-01f, -3.26446630e-02f, -1.06731653e-01f, 3.48478034e-02f,
  4.18331660e-02f, 5.60473911e-02f, -1.01433741e-02f, -1.12885989e-01f, 5.36253750e-02f, 5.07195070e-02f, 2.05176957e-02f, -1.00408927e-01f, -1.32368132e-01f, -1.09503247e-01f,
  2.16875404e-01f, -6.81159794e-02f, 2.52605863e-02f, 8.45733806e-02f, 8.98621902e-02f, -1.06871039e-01f, 5.07931337e-02f, -9.93486214e-03f, 1.63413048e-01f, 6.67837076e-03f,
  2.26975158e-02f, -6.03763536e-02f, -8.84689018e-02f, -2.32280552e-01f, -2.80528486e-01f, -5.61602861e-02f, 2.90107410e-02f, 1.73343554e-01f, 1.26242548e-01f, 5.53795584e-02f,
  7.62061030e-02f, -4.22929749e-02f, -9.68101714e-03f, -1.34587139e-01f, -4.69348729e-02f, -7.18837231e-02f, -8.66486803e-02f, -6.69850558e-02f, -1.07642122e-01f, -1.29867971e-01f,
  7.32949138e-01f, -4.35507923e-01f, 2.32289940e-01f, 2.23896965e-01f, 2.25123182e-01f, 2.59890378e-01f, 6.35493696e-02f, 1.76508069e-01f, 1.30112156e-01f, -4.88967709e-02f,
  7.40795434e-02f, 2.81241030e-01f, 1.78803772e-01f, 1.57839209e-01f, 1.76314875e-01f, 2.05467734e-02f, -6.22365400e-02f, 1.25694484e-01f, 1.30613789e-01f, 1.09379821e-01f,
  -8.21338743e-02f, -2.11698353e-01f, -3.14763077e-02f, -2.77914666e-02f, -3.32614094e-01f, 1.90769918e-02f, -7.81342760e-02f, -1.17994599e-01f, -1.12957157e-01f, -3.35309207e-01f,
  -4.95481044e-02f, 8.90943706e-02f, 1.41702354e-01f, -2.83416621e-02f, 1.42420293e-03f, 3.97042669e-02f, 1.29214853e-01f, -6.01914478e-03f, -6.13397062e-02f, 3.07105798e-02f,
  -1.03845008e-01f, -6.19659461e-02f, -1.40540540e-01f, -1.66867495e-01f, -6.95267841e-02f, -1.75499264e-02f, -4.45471630e-02f, 7.53661543e-02f, 6.95927441e-02f, -5.40807918e-02f,
  -2.78043970e-02f, 3.54895443e-02f, 1.00719228e-01f, 1.75158545e-01f, 2.13968173e-01f, 2.62204707e-01f, -4.94107567e-02f, -6.77257311e-04f, 2.02386543e-01f, 5.69718368e-02f,
  2.26263076e-01f, 8.39208066e-02f, 3.12379487e-02f, 3.40952687e-02f, 1.10012464e-01f, 3.91377248e-02f, -6.40029833e-02f, -1.72541402e-02f, 1.96798638e-01f, -2.40837466e-02f,
  -8.98273438e-02f, 1.29980013e-01f, 1.90970749e-01f, 9.20036528e-03f, -8.39348212e-02f, -1.89522207e-02f, -3.78429443e-02f, -1.31836772e-01f, -7.22085088e-02f, 2.89162993e-02f,
  4.82779592e-02f, -4.96585760e-03f, -1.81226447e-01f, -1.75944060e-01f, -5.09536117e-02f, 5.39986836e-03f, -8.86631906e-02f, -5.51356226e-02f, 5.34552336e-02f, -5.97736165e-02f,
  -2.54128039e-01f, 2.70809293e-01f, 3.09279747e-02f, -8.98648053e-02f, -1.78399861e-01f, -3.04042310e-01f, 4.43298519e-02f, -1.69319317e-01f, -7.68876970e-02f, 2.26779357e-02f,
  -3.40223312e-02f, -5.06796613e-02f, -2.19881713e-01f, -1.12737261e-01f, 5.02205901e-02f, 5.28821610e-02f, -5.86981475e-02f, -1.05172750e-02f, 3.93309891e-02f, -1.43436745e-01f,
  -7.50622824e-02f, 1.63000613e-01f, 2.42834553e-01f, 1.44094229e-01f, 1.63649082e-01f, 9.24917310e-02f, 5.71815260e-02f, -2.90037859e-02f, 9.14781541e-02f, 6.41333833e-02f,
  -2.33081594e-01f, 4.92266193e-03f, 2.69967049e-01f, -2.41949871e-01f, 1.91721842e-01f, 1.42502904e-01f, -2.52133578e-01f, -1.75229803e-01f, 9.85128358e-02f, 1.09953851e-01f,
  3.81054789e-01f, 1.00232728e-01f, -9.33763981e-02f, -1.66996434e-01f, -4.88206655e-01f, -2.25335881e-01f, -3.28280926e-01f, -2.50266403e-01f, -2.96037108e-01f, -1.57895714e-01f,
  -6.17818721e-02f, -1.81467742e-01f, -3.88193965e-01f, -2.82724679e-01f, -8.16603601e-02f, -1.41829923e-01f, -1.01955816e-01f, -3.28698917e-03f, -1.05172032e-02f, -1.05869621e-01f,
  2.01382026e-01f, 1.72147915e-01f, 2.23089486e-01f, -6.17902726e-02f, 2.25918427e-01f, -4.67583016e-02f, -1.11120753e-01f, 5.43776900e-03f, 2.72980452e-01f, 3.87959331e-02f,
  -2.72767935e-02f, 1.14586376e-01f, -4.39444706e-02f, 1.91673487e-01f, 6.96003363e-02f, -2.13907938e-02f, -1.85806602e-01f, -1.58156440e-01f, -2.39873976e-01f, -2.45253555e-02f,
  -3.91688645e-02f, 6.67288303e-02f, -2.17384592e-01f, -8.43282044e-02f, -2.53341198e-01f, -1.31544573e-02f, 4.63698767e-02f, -1.77245602e-01f, -1.77165553e-01f, -4.66407448e-01f,
  -6.58488423e-02f, 4.62572500e-02f, 9.59606096e-02f, -4.19325531e-02f, -1.54299647e-01f, 1.35042995e-01f, -5.50429076e-02f, -1.37918979e-01f, 5.56074269e-02f, -7.53485635e-02f,
  -2.83113364e-02f, 2.17400342e-01f, -5.90750538e-02f, -2.37607569e-01f, -1.08970307e-01f, -4.92753424e-02f, 6.80834353e-02f, -2.46963665e-01f, -2.79147804e-01f, 3.42700258e-02f,
  -5.11026010e-02f, -6.96755201e-02f, 9.46743339e-02f, 2.77734306e-02f, 1.25653967e-01f, 7.14667737e-02f, -6.75447211e-02f, 5.73758520e-02f, -1.30948365e-01f, 6.66389987e-02f,
  -2.26168633e-01f, 1.25510976e-01f, 2.01500375e-02f, -1.08963929e-01f, 1.81908328e-02f, 1.32949017e-02f, 1.04891799e-01f, 2.44260542e-02f, 1.49177939e-01f, -6.24502115e-02f,
  1.21967308e-01f, -1.58835445e-02f, -5.46493195e-02f, -1.16836317e-01f, 6.05279356e-02f, -4.76113223e-02f, -3.11464041e-01f, -8.08798224e-02f, -1.28044575e-01f, 1.38963595e-01f,
  -2.09693328e-01f, -2.66604632e-01f, -2.65279084e-01f, -3.19081008e-01f, -3.10329169e-01f, -2.78354555e-01f, -2.51158327e-01f, -1.11922257e-01f, -2.02451035e-01f, -6.65571749e-01f,
  -3.49146217e-01f, 1.80024579e-01f, -4.53435183e-01f, 2.11477384e-01f, 5.08608639e-01f, 3.67210917e-02f, 1.01483382e-01f, -1.80288166e-01f, -1.27986386e-01f, -1.21952273e-01f,
  2.01528847e-01f, 2.53415734e-01f, 1.43826216e-01f, 1.10670462e-01f, -5.23300432e-02f, 1.07293390e-02f, -3.94460605e-03f, -2.08928451e-01f, -2.11002171e-01f, 1.72060549e-01f,
  4.41267520e-01f, 1.92449465e-02f, -1.95789486e-01f, -9.69861150e-02f, 1.49316028e-01f, 1.71448588e-02f, -1.59203470e-01f, 1.97439387e-01f, 2.11009309e-01f, 4.53191586e-02f,
  -7.34475479e-02f, 6.26719519e-02f, -1.63247749e-01f, 3.15657884e-01f, -2.63405275e-02f, -1.90338328e-01f, 9.60810333e-02f, -9.08781663e-02f, 1.87817976e-01f, -9.50425118e-03f,
  1.71476245e-01f, 6.90492392e-02f, 4.81945902e-01f, 1.03396319e-01f, 1.80739500e-02f, -1.63492188e-01f, -3.94689254e-02f, -3.16727847e-01f, -2.46520162e-01f, -1.81514740e-01f,
  4.33785737e-01f, 4.60557401e-01f, -7.90559873e-02f, -1.63346097e-01f, -1.99857265e-01f, 2.00738758e-02f, -2.31966421e-01f, -2.14333445e-01f, -3.58181566e-01f, -2.85241008e-01f,
  2.89465301e-02f, -3.29937488e-02f, 4.95165922e-02f, -2.90653575e-02f, -8.34731758e-02f, 5.01440316e-02f, -5.54502308e-02f, -2.92658247e-02f, -2.80180909e-02f, 3.82506521e-03f,
  -7.26634264e-02f, -1.82806104e-01f, -1.04589753e-01f, -4.88313939e-03f, 5.96176796e-02f, -2.44974811e-02f, -7.37474393e-03f, -5.15215211e-02f, -4.69148196e-02f, -2.11160528e-04f,
  -1.10179815e-03f, -1.20245174e-01f, -1.09617589e-02f, -1.04035221e-01f, -1.28976122e-01f, -1.28435656e-01f, -1.34682521e-01f, -8.39392841e-02f, -1.07460238e-01f, 5.80576947e-03f,
  3.72803882e-02f, 8.70206729e-02f, -2.09043995e-01f, 5.68746477e-02f, 7.46288002e-02f, 3.61392200e-02f, 7.49964714e-02f, -3.19839045e-02f, -8.68978873e-02f, -1.12632915e-01f,
  -9.41612497e-02f, -1.44043386e-01f, 1.43695906e-01f, -1.72078028e-01f, -4.41415906e-02f, -9.94068831e-02f, 3.60409282e-02f, -1.66241691e-01f, -9.65578929e-02f, 5.90079091e-03f,
  -4.58740536e-03f, -7.88905993e-02f, -1.11714773e-01f, -2.01385394e-01f, -3.74481902e-02f, -6.43450916e-02f, -1.86514720e-01f, -2.22520724e-01f, -1.93746656e-01f, -2.84260333e-01f,
  -8.34907711e-01f, -2.21165158e-02f, 5.41726127e-02f, -4.02645886e-01f, -3.98431532e-02f, -2.70150732e-02f, -8.90018791e-02f, -2.13848371e-02f, -1.15677245e-01f, -8.04745108e-02f,
  6.79695159e-02f, -1.27037868e-01f, -1.03112020e-01f, -1.56161651e-01f, -2.95693904e-01f, -2.27636829e-01f, -3.31926912e-01f, -3.75038594e-01f, -2.81173110e-01f, 5.18062226e-02f,
  -1.52814969e-01f, -4.48386610e-01f, -3.63524586e-01f, -2.33620897e-01f, 4.37832326e-02f, -1.67714983e-01f, 1.69196818e-02f, -1.80053040e-01f, 1.11494496e-01f, -2.35429153e-01f,
  2.17712358e-01f, 2.32783929e-02f, 4.38901745e-02f, -1.63328022e-01f, 1.02895677e-01f, -9.73705128e-02f, -2.16456130e-01f, -7.86135197e-02f, -2.37954333e-02f, 1.00258656e-01f,
  -1.99931208e-02f, -7.84943998e-02f, -2.18431443e-01f, 5.64282127e-02f, -1.18917294e-01f, -4.97659482e-03f, 2.33361796e-01f, 2.13677242e-01f, 2.48365805e-01f, 2.22705752e-01f,
  4.33295816e-02f, -2.42769234e-02f, 2.72445589e-01f, 2.31311858e-01f, 2.78493851e-01f, 9.32623371e-02f, 3.69094878e-01f, 2.98879832e-01f, 1.90154538e-01f, 2.04238713e-01f,
  -1.04673445e-01f, 1.84315249e-01f, 9.64948982e-02f, 4.41516973e-02f, 2.63793785e-02f, 7.53980502e-03f, 3.17149535e-02f, 6.72305748e-02f, -1.66997507e-01f, -1.62848346e-02f,
  5.63096330e-02f, -2.23283004e-02f, -1.11594833e-01f, -9.23915207e-03f, 6.11235537e-02f, 1.65928714e-02f, -5.60050905e-02f, 3.77673432e-02f, 1.15058884e-01f, 6.45508096e-02f,
  7.82713592e-02f, 1.04763873e-01f, -9.99291018e-02f, 3.89907174e-02f, 8.28164071e-02f, -2.71287207e-02f, 1.63761340e-02f, 1.70183163e-02f, -1.82420924e-01f, -7.60875344e-02f,
  1.72225475e-01f, 4.30861712e-02f, -1.67695686e-01f, 1.58754177e-02f, -3.93118337e-02f, 3.32078040e-02f, -1.54119050e-02f, -5.64221889e-02f, -1.14349566e-01f, 7.81039819e-02f,
  -1.50645394e-02f, -5.67058548e-02f, -9.61895138e-02f, 1.37262613e-01f, -2.26753116e-01f, -6.76651150e-02f, 2.44692713e-02f, 2.51288037e-03f, 1.29462332e-01f, 1.34768486e-01f,
  1.31591916e-01f, 3.74061316e-02f, 6.69007599e-02f, 1.71226621e-01f, 6.47736266e-02f, -1.08201474e-01f, 2.03742813e-02f, 6.51014561e-04f, -1.60742737e-02f, -8.78536627e-02f,
  3.80741447e-01f, 9.37459916e-02f, -3.52234155e-01f, 4.82792944e-01f, 1.40662357e-01f, -1.99705854e-01f, -3.20729434e-01f, -1.49447337e-01f, 2.73254067e-01f, 1.81274742e-01f,
  8.74109268e-02f, 6.43888339e-02f, 2.15310045e-02f, -2.68295050e-01f, -6.10109925e-01f, -2.82293767e-01f, -1.68100223e-01f, -3.52763057e-01f, -7.14510024e-01f, -4.19961840e-01f,
  -7.18870461e-02f, 8.61572921e-02f, -1.26254082e-01f, -1.33567497e-01f, 2.76187569e-01f, 4.18640748e-02f, 1.47307590e-01f, 1.55655563e-01f, -1.25803500e-02f, 2.71871835e-01f,
  -2.25285918e-01f, 1.92288719e-02f, -1.50925130e-01f, 8.76489207e-02f, 1.68324515e-01f, 1.20044157e-01f, 5.57414591e-02f, 2.64501311e-02f, 6.03983179e-02f, -3.36939059e-02f,
  1.28009111e-01f, -7.44558647e-02f, -1.23473078e-01f, -9.53222439e-02f, 6.47138897e-03f, -8.54837820e-02f, -1.64798144e-02f, -2.45675027e-01f, -5.90582639e-02f, -1.95180327e-02f,
  1.27586037e-01f, -6.79265633e-02f, 3.78546081e-02f, -8.61870646e-02f, -9.66847539e-02f, -8.06789845e-03f, -9.71793085e-02f, -8.09410438e-02f, -2.10275680e-01f, 1.63749889e-01f,
  1.54880717e-01f, 1.16144188e-01f, 6.79228380e-02f, 9.86669436e-02f, 1.79140300e-01f, 8.46230984e-02f, 5.35652228e-02f, 1.30674735e-01f, -5.60626388e-02f, 7.08747804e-02f,
  5.93186170e-02f, 8.23628753e-02f, -3.98568027e-02f, 1.27202913e-01f, -9.56008062e-02f, 5.84188215e-02f, -4.03213361e-03f, 8.98047388e-02f, -3.05512175e-02f, 7.05536008e-02f,
  -2.02093385e-02f, -2.06255428e-02f, 2.30616182e-02f, -1.46476671e-01f, -7.17877522e-02f, 5.27969338e-02f, 8.40290263e-03f, -1.99202616e-02f, 1.09458238e-01f, -4.19723168e-02f,
  1.00482725e-01f, -4.06457365e-01f, 2.18450055e-01f, -1.69577166e-01f, -5.26474528e-02f, 2.75589600e-02f, 1.19403787e-01f, -2.86599831e-03f, 1.53948456e-01f, -5.74187934e-03f,
  -7.36681074e-02f, 5.99705949e-02f, 8.37353989e-02f, -1.23565294e-01f, -5.03065139e-02f, -1.22317839e-02f, 5.03420308e-02f, 1.55451745e-02f, -9.10351127e-02f, 3.34674381e-02f,
  9.86194611e-02f, -7.11270347e-02f, -1.10279687e-01f, 1.03010461e-02f, 4.18980233e-02f, 6.15372509e-02f, -2.97977477e-02f, -4.04477753e-02f, -1.68753162e-01f, 2.24181592e-01f,
  -7.84283519e-01f, -2.99201339e-01f, -4.50698107e-01f, -3.18716407e-01f, 1.60557613e-01f, 2.60446638e-01f, 3.18832755e-01f, 1.37754142e-01f, -1.37032971e-01f, -6.28120005e-02f,
  -2.83085089e-02f, -5.13044819e-02f, -9.56062451e-02f, 7.57551789e-02f, 9.71885026e-02f, 6.85748979e-02f, 2.68954873e-01f, 9.93038248e-03f, 1.25991970e-01f, 1.85483932e-01f,
  3.80977303e-01f, -1.71396613e-01f, -3.26071650e-01f, 1.04814321e-01f, 2.70109288e-02f, 1.42742187e-01f, -7.95303881e-02f, -5.87710515e-02f, 6.82564527e-02f, -2.47686282e-02f,
  -4.22144175e-01f, -4.15565848e-01f, 1.24962613e-01f, -7.29869911e-03f, 3.50312926e-02f, -1.67024344e-01f, -6.30709156e-02f, -2.75878161e-01f, 6.96235076e-02f, -4.65270467e-02f,
  -6.07921183e-02f, 1.22868521e-02f, 3.52120586e-02f, 2.78354771e-02f, -8.50686654e-02f, -6.94733113e-02f, -7.93802068e-02f, -1.94132641e-01f, -1.41392112e-01f, -9.10823941e-02f,
  3.69392604e-01f, 1.10508546e-01f, -3.68610203e-01f, 2.33196244e-01f, 8.47214554e-03f, -6.38279319e-02f, -4.14064638e-02f, 1.49102136e-01f, 4.13066968e-02f, -1.53745338e-01f,
  8.05200934e-02f, -5.27262921e-03f, -5.26921125e-03f, -9.47617553e-03f, 2.73323283e-02f, -1.19689172e-02f, 1.01621501e-01f, 1.33733615e-01f, 2.43503880e-02f, -4.78399582e-02f,
  -1.15652956e-01f, -1.86241809e-02f, 6.38755113e-02f, -5.66619560e-02f, -9.39583173e-04f, -1.65664017e-01f, 1.47232592e-01f, 1.80677380e-02f, -8.08704179e-03f, -9.27659497e-02f,
  -8.86502396e-03f, 6.00344501e-02f, -2.21739616e-02f, 9.00191665e-02f, 9.72327292e-02f, 2.05978919e-02f, -6.45381212e-02f, -1.15866624e-01f, -5.98940626e-02f, -8.63560736e-02f,
  -4.33984131e-01f, 1.55126289e-01f, -1.54029414e-01f, -8.36738665e-03f, -3.65620740e-02f, -1.79905280e-01f, -4.89070788e-02f, -1.89163699e-03f, -8.03433433e-02f, 9.22643915e-02f,
  9.01869237e-02f, -8.28083754e-02f, -9.23997909e-02f, 1.06548510e-01f, 2.76739970e-02f, -1.74264878e-01f, 2.04622131e-02f, -5.17330617e-02f, 4.71397378e-02f, -3.27195451e-02f,
  6.51041716e-02f, -8.73202365e-03f, -3.51914823e-01f, -2.84777358e-02f, 8.25166255e-02f, -7.45122833e-03f, 8.63357261e-03f, -5.77521175e-02f, -7.80419335e-02f, -3.13521057e-01f,
  8.39310586e-01f, 5.53105712e-01f, 1.89723730e-01f, 1.10187180e-01f, 1.69868127e-01f, 7.69486800e-02f, 3.46864700e-01f, 9.30306315e-02f, -1.06588706e-01f, 1.69801027e-01f,
  2.05436632e-01f, -2.25129910e-02f, -8.33640769e-02f, -8.35237876e-02f, 1.65383384e-01f, 1.21064693e-01f, -9.86014158e-02f, -9.57050547e-02f, -1.62473187e-01f, 3.05297710e-02f,
  3.42912152e-02f, 1.18578523e-01f, 2.41682887e-01f, -5.11799892e-03f, 6.77428469e-02f, -1.19946793e-01f, 7.07231611e-02f, 2.15873107e-01f, 1.72014758e-01f, 1.15368724e-01f,
  7.99269136e-03f, 6.01872504e-01f, -2.67359376e-01f, -1.02480657e-01f, 7.70412758e-02f, -1.09332450e-01f, -3.65860127e-02f, -1.47993022e-04f, -1.55020854e-03f, -1.19566254e-01f,
  2.65572425e-02f, 9.89716575e-02f, 2.22725138e-01f, 9.54918005e-03f, 1.79854333e-01f, -8.46414939e-02f, 9.89511237e-02f, 1.35751680e-01f, -5.84233068e-02f, 2.00470164e-02f,
  1.25750318e-01f, 2.05817699e-01f, 6.77802488e-02f, -3.57209258e-02f, 5.89704402e-02f, -8.70105848e-02f, 1.06993675e-01f, 4.89070155e-02f, -2.89231706e-02f, 8.26933011e-02f,
  2.03127362e-04f, 1.47317231e-01f, 2.36764267e-01f, 1.84203058e-01f, 1.30786538e-01f, 7.00461566e-02f, -1.18142486e-01f, 1.00090273e-01f, -2.33915448e-02f, 1.91145614e-01f,
  -1.38403103e-01f, 3.99469510e-02f, -6.35229796e-02f, 9.97301191e-02f, 1.49893248e-02f, 2.46548150e-02f, -5.27381450e-02f, -7.26229791e-03f, 5.00182845e-02f, -6.36948720e-02f,
  1.27373755e-01f, -1.45898715e-01f, -1.21105686e-01f, 5.81006147e-02f, -2.82021705e-02f, -4.29734401e-02f, 2.07233373e-02f, 8.55190679e-02f, 1.37415364e-01f, 9.27463770e-02f,
  -5.45904815e-01f, -3.02065685e-02f, -1.24081366e-01f, -4.45046229e-03f, 3.47106121e-02f, 5.03690392e-02f, 9.22703817e-02f, -2.02849805e-02f, -9.29958895e-02f, -9.70017537e-02f,
  9.27302390e-02f, 1.13282993e-01f, 6.97229654e-02f, -6.31099716e-02f, -1.66783869e-01f, -9.28785577e-02f, 9.73911304e-03f, -2.71390617e-01f, -1.45442143e-01f, -2.22270295e-01f,
  -3.29641923e-02f, -2.80331433e-01f, -2.13282689e-01f, -2.69896895e-01f, -4.26686928e-02f, -3.15285772e-01f, -2.65251607e-01f, -9.99363661e-02f, -8.14758614e-02f, -1.80855229e-01f,
  -4.88028735e-01f, -2.42672041e-01f, -3.26674730e-01f, -3.07019621e-01f, -1.35434210e-01f, -1.36763111e-01f, -2.11539343e-01f, 1.31592438e-01f, -1.18195631e-01f, -4.77470487e-01f,
  -3.19309592e-01f, -3.81313294e-01f, -4.42853123e-01f, -1.70493245e-01f, -2.70563483e-01f, -3.77524465e-01f, -5.11364341e-01f, -3.23285878e-01f, 1.97762605e-02f, 2.44390011e-01f,
  1.02799594e-01f, -2.41709009e-01f, -3.22673768e-02f, 5.26659898e-02f, -3.71041149e-03f, -2.25208148e-01f, -2.98616558e-01f, -1.25378400e-01f, 2.30173040e-02f, -3.80570620e-01f,
  -4.62040007e-01f, 5.96910063e-03f, 1.79525346e-01f, 1.21376172e-01f, -2.09095851e-01f, -5.98106487e-03f, -1.23320214e-01f, -1.59845635e-01f, 7.03971162e-02f, -1.06671423e-01f,
  -8.47378448e-02f, 7.76747018e-02f, -8.20023715e-02f, -7.61150643e-02f, -1.08754061e-01f, 1.18006751e-01f, 3.00826523e-02f, 5.51755950e-02f, -2.62345783e-02f, 1.02047883e-01f,
  3.38203087e-02f, -9.29216966e-02f, -5.26282862e-02f, 2.34294906e-01f, 1.59488916e-01f, -1.25511494e-02f, 2.71959394e-01f, 2.49775633e-01f, 2.25670367e-01f, -7.98802972e-02f,
  5.58228716e-02f, -5.71101205e-03f, 5.67113049e-02f, 3.73102911e-02f, -3.56376804e-02f, -4.87450436e-02f, -3.00508849e-02f, -1.49357870e-01f, 1.22036785e-01f, -1.69808194e-02f,
  3.15464325e-02f, -6.36825636e-02f, -6.54109418e-02f, -1.37631595e-02f, 3.19920890e-02f, -3.79062332e-02f, -1.00325972e-01f, -6.81374073e-02f, 7.77306184e-02f, 5.96823357e-02f,
  -9.10993945e-03f, 2.16213912e-01f, -9.88049656e-02f, -3.36939469e-02f, -9.49470624e-02f, -2.42163628e-01f, 5.66295274e-02f, 1.09562963e-01f, 6.23601489e-02f, 3.13935988e-02f,
  -4.28225756e-01f, 3.15231122e-02f, -3.80272955e-01f, -1.46987140e-01f, -3.61641422e-02f, -7.96619058e-03f, -1.67456180e-01f, 1.89089880e-03f, -1.61217898e-01f, -9.99141261e-02f,
  4.48257439e-02f, -1.12784594e-01f, -1.42766565e-01f, 1.33918926e-01f, -5.82494773e-02f, 8.40329528e-02f, 3.49561288e-03f, -1.40138283e-01f, 2.66934279e-02f, 5.86296730e-02f,
  1.58127863e-02f, -1.38579816e-01f, -2.03393340e-01f, -6.30528927e-02f, 3.14336047e-02f, -1.34824529e-01f, -2.39460524e-02f, 3.85466553e-02f, -4.17650528e-02f, -1.34033322e-01f,
  1.93804115e-01f, -2.70149503e-02f, 4.89391536e-01f, 2.01613575e-01f, 3.45568538e-01f, 5.65159202e-01f, 6.14171326e-01f, 1.85949266e-01f, -1.06072547e-02f, -3.03728189e-02f,
  -1.31083280e-01f, -2.27542564e-01f, -3.63451988e-01f, -3.10188472e-01f, -2.83602215e-02f, 4.38148007e-02f, 2.61870734e-02f, 9.27103907e-02f, 7.94766992e-02f, 1.79288805e-01f,
  -1.89357087e-01f, -1.75464731e-02f, 7.35873505e-02f, -1.09698139e-01f, -1.87656686e-01f, -1.57645404e-01f, -4.72071618e-02f, 7.90203512e-02f, -6.96703559e-03f, -2.56419837e-01f,
  -6.14774190e-02f, 1.64552987e-01f, -2.11689830e-01f, -2.64964432e-01f, -1.61670089e-01f, -1.43359229e-01f, -9.92236361e-02f, -7.27063715e-02f, -2.95488723e-02f, -1.10481381e-01f,
  -4.15671291e-03f, -1.36711210e-01f, -1.84016470e-02f, 5.57489693e-02f, 2.28013676e-02f, 4.23375107e-02f, -1.01957964e-02f, 2.58155745e-02f, -6.42141774e-02f, -3.36838886e-04f,
  -6.17024526e-02f, 1.29442707e-01f, 1.44122317e-01f, 1.86968446e-01f, 1.36157900e-01f, -1.54025769e-02f, -8.94806236e-02f, -5.29832691e-02f, -3.05821113e-02f, -6.74671158e-02f,
  -1.27768859e-01f, -3.71489041e-02f, -1.25519648e-01f, -3.50877941e-02f, 2.26398874e-02f, -2.92087179e-02f, 4.91402522e-02f, 6.61662370e-02f, 1.09292626e-01f, 3.96380797e-02f,
  9.68021229e-02f, 7.95084462e-02f, 1.07792035e-01f, 1.04920961e-01f, 5.13198189e-02f, 5.80069572e-02f, 2.01890826e-01f, -2.39273272e-02f, 4.34560068e-02f, 7.42922118e-03f,
  1.41485855e-01f, 1.06548436e-01f, 2.04407766e-01f, 9.68430191e-02f, 1.74350478e-02f, 9.88339111e-02f, 2.15782248e-03f, 4.96001728e-02f, 7.17902258e-02f, 1.36209458e-01f,
  -6.95263073e-02f, 1.88656226e-01f, -1.08448491e-01f, -3.03040534e-01f, -7.69231319e-02f, -8.44064355e-03f, 1.81602854e-02f, -1.58407614e-02f, -2.51404420e-02f, -5.16560934e-02f,
  5.74560603e-03f, -5.91150895e-02f, 1.49055883e-01f, 1.32685378e-01f, 1.23748615e-01f, 1.60489142e-01f, -1.99744493e-01f, 3.59937958e-02f, -1.52865306e-01f, -8.74288455e-02f,
  2.34384537e-02f, 1.20092221e-01f, 1.90949619e-01f, 1.03746794e-01f, 2.26373039e-02f, 3.46562453e-02f, -2.79461667e-02f, 1.17525451e-01f, 8.89420733e-02f, -1.20888688e-02f,
  8.06548178e-01f, -5.04179657e-01f, -4.00686324e-01f, 2.31771424e-01f, -3.28953147e-01f, -3.46133649e-01f, -6.65062845e-01f, -9.58628505e-02f, 2.90796846e-01f, -3.86471242e-01f,
  5.03149442e-02f, 5.29018819e-01f, 3.46029460e-01f, 1.52656317e-01f, 3.42790723e-01f, -5.54913759e-01f, -3.37839663e-01f, 2.11317852e-01f, 2.58159727e-01f, -1.95311412e-01f,
  -1.59324408e-02f, 4.58884239e-02f, 4.13555741e-01f, 2.53512800e-01f, -2.08898336e-01f, 1.92733318e-01f, -1.13051012e-01f, -1.46710694e-01f, -1.73732355e-01f, -5.77813625e-01f,
  -3.48905623e-01f, -1.74927935e-01f, 1.31672323e-01f, 2.16792762e-01f, -5.06304130e-02f, 1.93918739e-02f, -9.18536037e-02f, 8.79475921e-02f, 1.69487074e-01f, -5.35592809e-02f,
  7.01992363e-02f, 3.23990500e-03f, 1.44841403e-01f, -6.74903691e-02f, -9.10136178e-02f, -1.96996182e-01f, -3.59699242e-02f, 1.26069710e-02f, 6.68111593e-02f, -1.47952840e-01f,
  -1.95618108e-01f, -1.67847946e-01f, -1.30538389e-01f, -6.85145482e-02f, -5.16123138e-02f, 2.12008908e-01f, -2.57004797e-01f, -2.85734355e-01f, -2.51292855e-01f, -5.66151440e-01f,
  -1.55220702e-01f, -3.05616371e-02f, 9.29319561e-02f, -1.21251181e-01f, 5.56763867e-03f, 6.71717972e-02f, -1.35566695e-02f, 3.16809420e-03f, 4.91645783e-02f, -1.22130610e-01f,
  -7.22379377e-03f, -7.68262222e-02f, 2.69068107e-02f, -6.16173679e-03f, 6.42412230e-02f, -6.47044228e-03f, -1.38892382e-01f, -3.45588177e-02f, 7.45602176e-02f, 5.79234585e-02f,
  6.19386882e-03f, -5.08509278e-02f, 1.01218224e-01f, 8.81866813e-02f, 8.17887578e-03f, 2.65077986e-02f, -3.96618322e-02f, 4.50279228e-02f, 3.64720933e-02f, -8.96078795e-02f,
  2.05129862e-01f, 3.36926460e-01f, -6.50205314e-02f, -7.29645491e-02f, 5.71567342e-02f, 6.45817071e-02f, 6.67442456e-02f, 8.15241933e-02f, 1.75019011e-01f, 6.63326085e-02f,
  -3.68286148e-02f, 5.08553982e-02f, 1.83044486e-02f, -6.05715364e-02f, -5.42889647e-02f, 1.25166010e-02f, 1.00516215e-01f, 6.51685968e-02f, 1.34845808e-01f, -1.03016026e-01f,
  7.88290128e-02f, -7.35842586e-02f, 2.29873396e-02f, 8.90799984e-02f, -9.25674383e-03f, 1.66040078e-01f, -3.87439840e-02f, -4.99700606e-02f, 5.15875518e-02f, -5.32384589e-02f,
  1.19171530e-01f, 3.96048538e-02f, -5.90073109e-01f, 3.33518028e-01f, -1.38296977e-01f, -2.85897970e-01f, -8.35125819e-02f, 3.01083088e-01f, 4.60495919e-01f, 7.55824745e-02f,
  -1.54720619e-01f, 1.38569817e-01f, 1.63862616e-01f, -9.91786644e-02f, -2.39387557e-01f, -1.63960606e-01f, -1.22125499e-01f, -3.33926737e-01f, -4.95213211e-01f, -2.30354846e-01f,
  3.83102819e-02f, 1.09983318e-01f, 1.20594643e-01f, -5.73480017e-02f, 1.51970744e-01f, 2.18653023e-01f, 2.14691907e-01f, -1.22201759e-02f, -1.92655176e-01f, -8.89803935e-03f,
  -3.55776459e-01f, -1.00848839e-01f, -8.15416798e-02f, -1.45880416e-01f, -1.19470455e-01f, -1.33235291e-01f, -2.89740920e-01f, -2.05435917e-01f, -1.19591676e-01f, -1.11286022e-01f,
  -2.05220655e-01f, -2.46846706e-01f, -2.02022880e-01f, -8.13057795e-02f, -1.45938098e-01f, -2.58610517e-01f, 6.56366125e-02f, -1.90105483e-01f, -1.87828287e-01f, -3.29101920e-01f,
  -1.94011346e-01f, -3.91696036e-01f, -2.39772931e-01f, -1.68102473e-01f, -1.34935871e-01f, -2.07200974e-01f, -9.36609581e-02f, -1.61419123e-01f, -2.14738950e-01f, 2.42460281e-01f,
  2.90518869e-02f, -1.05753802e-01f, -1.14477433e-01f, -2.78703906e-02f, 6.83659315e-02f, 1.50628742e-02f, -1.77657027e-02f, 1.76643673e-02f, 9.30212215e-02f, -5.17828017e-03f,
  -4.72377874e-02f, -4.18636128e-02f, 1.25825748e-01f, -2.69887131e-02f, 6.51725614e-03f, -1.50310338e-01f, -7.63136074e-02f, -3.08917388e-02f, -1.41931614e-02f, -1.93638634e-02f,
  -5.31671681e-02f, 5.58413491e-02f, -5.18163517e-02f, 1.85131148e-01f, -1.79861754e-01f, -2.02597067e-01f, -1.67006515e-02f, -1.13724932e-01f, 7.37170354e-02f, -1.35832980e-01f,
  4.46945667e-01f, -2.79304326e-01f, 1.14739113e-01f, 6.72382414e-02f, -1.39712781e-01f, -2.56395191e-01f, -6.43141195e-02f, -2.39897496e-03f, 1.76741905e-03f, -1.31341927e-02f,
  -2.70492494e-01f, -2.69344598e-02f, 9.39255729e-02f, 9.27534252e-02f, 7.25961477e-02f, 3.32785916e-04f, -4.94817272e-02f, 2.70474572e-02f, -2.47039683e-02f, 4.18104492e-02f,
  1.60418183e-01f, 4.82578687e-02f, 3.15963253e-02f, 1.94691807e-01f, 1.84030384e-01f, -1.72489490e-02f, 5.33134490e-02f, 1.94470048e-01f, 7.20063224e-02f, 5.54117441e-01f,
  -1.44278646e-01f, -1.90133169e-01f, 1.07027002e-01f, 9.26616117e-02f, -9.61497128e-02f, -4.23836470e-01f, -8.14889312e-01f, -5.06741166e-01f, -1.14567086e-01f, -1.07415669e-01f,
  -1.42363474e-01f, 1.18933968e-01f, 2.94852316e-01f, 5.72658330e-02f, -1.17301464e-01f, 2.76838280e-02f, 1.78111151e-01f, 1.32516026e-01f, -1.11640312e-01f, -2.42310017e-01f,
  1.26022518e-01f, 1.05805844e-01f, 2.02271700e-01f, 1.27701938e-01f, 1.38566568e-01f, 1.04768276e-01f, 2.03645259e-01f, 2.50566065e-01f, 1.45231053e-01f, 6.20846272e-01f,
  2.94446975e-01f, -1.44240968e-02f, -1.29026264e-01f, 4.04759906e-02f, 5.11101186e-02f, -1.28134504e-01f, -1.03487410e-01f, 1.02768749e-01f, -9.40297469e-02f, 2.77182441e-02f,
  8.89301151e-02f, -1.74885243e-02f, 1.47503436e-01f, -1.44856319e-01f, -2.91608460e-02f, -2.50252485e-01f, 2.48282333e-03f, -1.48542058e-02f, -1.78015321e-01f, -3.85150492e-01f,
  -7.69089675e-03f, 4.82439958e-02f, -2.85666194e-02f, -8.69274735e-02f, -1.81048453e-01f, 6.35938868e-02f, -1.88593894e-01f, -7.49493986e-02f, -2.71816086e-02f, -1.31713942e-01f,
  -1.03317365e-01f, 4.74533141e-02f, 1.96277097e-01f, -4.37508076e-02f, -8.84312466e-02f, 9.62572619e-02f, 1.85949177e-01f, 1.06158936e-02f, 8.90344530e-02f, -7.52186924e-02f,
  -1.77016482e-02f, -5.84530942e-02f, -1.36887863e-01f, -1.04645044e-02f, 1.09060295e-02f, 4.94436920e-02f, -7.87004307e-02f, -7.10461959e-02f, 4.86142822e-02f, 1.54069200e-01f,
  1.05462134e-01f, 2.07611024e-02f, 2.16904849e-01f, 2.97303479e-02f, -5.12549020e-02f, -5.44326417e-02f, -1.27713218e-01f, -1.78592116e-01f, -8.68591815e-02f, 7.86433071e-02f,
  -7.18068406e-02f, 1.75029650e-01f, -1.11021074e-02f, 3.32683660e-02f, -4.78672273e-02f, -1.11079842e-01f, 1.45912021e-02f, -6.89706951e-02f, -8.51463452e-02f, -1.03970274e-01f,
  -2.68709868e-01f, -1.34072021e-01f, -6.49998989e-03f, -7.91361853e-02f, -1.54979393e-01f, -1.01987280e-01f, -1.74172536e-01f, -6.00401834e-02f, -1.40275493e-01f, -1.47660434e-01f,
  -2.37222873e-02f, -3.56749594e-01f, -2.32411653e-01f, -2.18909368e-01f, -9.76928920e-02f, -1.91501111e-01f, -2.23368093e-01f, -3.19109589e-01f, -3.06562424e-01f, -6.96495533e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.53699362e-01f, 3.83526534e-01f, -1.01629287e-01f, 3.85334700e-01f, 1.56115204e-01f, 3.93206060e-01f, 4.36129838e-01f, 7.55303949e-02f, 2.16514431e-02f, 1.85643911e-01f,
  1.59251437e-01f, 2.62361765e-01f, 3.77486616e-01f, 2.52606809e-01f, 1.87111542e-01f, 3.22764248e-01f, 3.44639212e-01f, 5.01800895e-01f, 1.70232087e-01f, 3.15449923e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.72073783e-02f, 1.17688835e-01f, 8.55660886e-02f, 4.42273840e-02f, -4.42868285e-02f, 1.19812787e-01f, -1.39854765e-02f, 1.68992542e-02f, -1.63991805e-02f, -1.07199453e-01f,
  4.52652238e-02f, 3.22688632e-02f, -3.36778820e-01f, 4.06851470e-01f, -4.14392918e-01f, -5.99582344e-02f, -4.55734581e-02f, -1.89007685e-01f, -2.65675306e-01f, -1.12512380e-01f,
  -3.26516740e-02f, 1.86378852e-01f, -3.51156550e-03f, 3.17247510e-02f, 4.91641700e-01f, -3.79983813e-01f, 3.48763913e-01f, -1.57021999e-01f, -1.15903534e-01f, -1.27825946e-01f,
  7.93807432e-02f, 4.20543015e-01f, -2.86312811e-02f, 2.56290082e-02f, -6.83513582e-02f, 4.89962138e-02f, 3.05139292e-02f, 8.94664973e-02f, -2.25012377e-01f, -4.04399782e-02f,
  -8.62302259e-02f, 5.38274871e-05f, -8.04151446e-02f, 5.86750135e-02f, 4.72398024e-05f, -3.81909609e-02f, -3.50686520e-01f, -2.06669226e-01f, -4.68066074e-02f, 1.15419365e-01f,
  4.96243918e-03f, -1.80344746e-01f, -1.15507595e-01f, 1.59891903e-01f, 3.44817042e-01f, 2.96969146e-01f, 2.67198861e-01f, -3.76740456e-01f, 2.38300309e-01f, -1.71559304e-01f,
  1.26136178e-02f, -1.98252842e-01f, 2.57510245e-01f, 2.38993131e-02f, -8.85021500e-03f, -9.67906117e-02f, 1.08848857e-02f, -2.18905330e-01f, -1.10394090e-01f, 8.14265385e-02f,
  -1.23615608e-01f, 7.54091367e-02f, 1.75005257e-01f, -4.10954207e-01f, -7.19126081e-03f, -5.58936386e-04f, -7.32823610e-02f, -1.27046123e-01f, 1.19674616e-01f, -2.67258994e-02f,
  3.69392484e-01f, 8.56644511e-02f, -1.85586601e-01f, 2.81473607e-01f, 2.99548898e-02f, -4.84139353e-01f, -1.01205185e-02f, -1.23304017e-01f, -2.35507175e-01f, 3.98289442e-01f,
  -1.72697574e-01f, 2.35300120e-02f, -7.18481690e-02f, 2.24013522e-01f, -3.37408841e-01f, 1.06303379e-01f, 2.45364606e-01f, 1.52982906e-01f, -5.98377250e-02f, 1.68209046e-01f,
  1.73159555e-01f, -9.49661061e-02f, -2.28118345e-01f, 8.55560377e-02f, 8.74399841e-02f, -4.72724549e-02f, -5.02660424e-02f, -5.61721735e-02f, 3.87829930e-01f, -1.66081816e-01f,
  2.23772484e-03f, 3.91161799e-01f, 4.65245306e-04f, 3.45721245e-01f, 9.17802975e-02f, -1.20410234e-01f, 2.81590909e-01f, -1.81749821e-01f, 1.87071264e-01f, 1.00965850e-01f,
  1.02609359e-01f, 4.14200723e-01f, -2.43035585e-01f, -1.05285801e-01f, 8.92738923e-02f, 3.83760214e-01f, -3.41011025e-02f, -2.12495893e-01f, -2.10352391e-01f, -6.44555986e-02f,
  8.86006430e-02f, 3.78576980e-04f, -1.17991179e-01f, -9.55249220e-02f, 2.19084918e-01f, 8.52698982e-02f, -8.86488408e-02f, 9.50911790e-02f, 7.20041469e-02f, 1.20169640e-01f,
  6.43670326e-03f, 1.54617682e-01f, 1.94931433e-01f, -1.31368607e-01f, -9.23561491e-03f, -3.48116428e-01f, 2.05343053e-01f, -1.01636663e-01f, -3.53002518e-01f, 1.75433934e-01f,
  1.99227005e-01f, 1.47976920e-01f, 1.53722271e-01f, 1.25958562e-01f, 1.16450347e-01f, 1.47709712e-01f, 2.55239829e-02f, -3.00559521e-01f, 1.81830287e-01f, -1.22646846e-01f,
  7.63269961e-02f, 1.25441149e-01f, 4.00083549e-02f, -1.66370273e-02f, 1.96267758e-02f, 1.38473408e-02f, -3.14788185e-02f, -5.99319860e-03f, -1.10036314e-01f, 1.20638296e-01f,
  -7.72375911e-02f, -1.41406476e-01f, 2.61928141e-01f, 1.35683909e-01f, -4.42476779e-01f, 4.14217897e-02f, 1.15853459e-01f, 8.79755542e-02f, -2.70202994e-01f, 9.90438089e-02f,
  -3.11425805e-01f, 7.15895593e-02f, 2.01341912e-01f, 4.74401861e-02f, 3.10539842e-01f, 1.71620861e-01f, 4.99358587e-02f, -1.32710531e-01f, -3.77697200e-02f, -5.17309725e-01f,
  1.35435820e-01f, -1.74839914e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -3.51584405e-02f, 3.86964142e-01f, -2.39051983e-01f, 5.69051653e-02f, 3.30297619e-01f, -1.02526292e-01f, -4.45980489e-01f, 4.05045688e-01f, 7.04038143e-02f, -6.94634169e-02f,
  2.66189396e-01f, 3.38333011e-01f, -7.63798580e-02f, -8.34491327e-02f, -3.78539503e-01f, -4.38358039e-01f, -4.57015991e-01f, -2.33827263e-01f, -1.45126507e-01f, -4.45131689e-01f,
  -1.23863496e-01f, 9.99281630e-02f, -2.06813484e-01f, 1.17767945e-01f, 4.59459983e-02f, 1.33172646e-01f, -2.09415719e-01f, 1.88799679e-01f, 1.05766751e-01f, 1.04293592e-01f,
  4.98731956e-02f, 5.58455288e-01f, 3.62668484e-02f, 2.15593144e-01f, -8.84523615e-02f, -6.77807555e-02f, 1.83512822e-01f, -2.11473927e-02f, 1.43443421e-01f, 1.73051432e-02f,
  -1.96682084e-02f, -1.95476077e-02f, 2.30443865e-01f, -8.59511495e-02f, 4.17393893e-01f, 2.61053443e-01f, 2.92288929e-01f, 1.37024865e-01f, -7.96363130e-02f, -1.98863372e-02f,
  1.55874968e-01f, -3.50800753e-02f, 1.74357906e-01f, 1.24176994e-01f, 6.16955422e-02f, 2.22764239e-01f, -4.41573799e-01f, 6.50336385e-01f, 2.08272949e-01f, 2.12845564e-01f,
  4.60458934e-01f, -1.46744559e-02f, -3.58223855e-01f, -4.65263426e-01f, 3.66455734e-01f, -1.82971638e-02f, -4.70377840e-02f, -1.70951992e-01f, -1.29099071e-01f, 2.43141148e-02f,
  -6.04149662e-02f, 4.16778743e-01f, 4.90659028e-02f, 3.12136095e-02f, 3.86368781e-02f, -2.89294749e-01f, 1.53289825e-01f, 7.54961520e-02f, -3.72466385e-01f, -5.86839616e-01f,
  5.45992792e-01f, 4.37211961e-01f, -2.42746755e-01f, 7.94513375e-02f, -4.10335511e-01f, -5.45760214e-01f, 4.40387838e-02f, -1.48058543e-02f, 4.78707343e-01f, 4.37997818e-01f,
  7.97170848e-02f, -4.79347229e-01f, -2.66388178e-01f, -5.26588321e-01f, 3.86774868e-01f, 2.36574963e-01f, 4.02289242e-01f, 2.55273044e-01f, -6.59158230e-02f, 2.56889939e-01f,
  2.20184252e-01f, 4.29367237e-02f, -4.25178260e-01f, 2.25279003e-01f, 4.00417671e-02f, -2.48033866e-01f, 1.20309107e-01f, -5.73060801e-03f, 6.12623096e-01f, -4.47592616e-01f,
  3.10743332e-01f, 1.20301262e-01f, 3.92276496e-01f, 2.94696540e-01f, 1.19484358e-01f, -1.30716890e-01f, 7.86672831e-02f, 1.63735032e-01f, 1.71587914e-01f, 7.93681219e-02f,
  -4.29756492e-01f, 5.28858423e-01f, 2.19470188e-01f, 4.21883911e-01f, -2.11003602e-01f, 6.20696902e-01f, -2.33817518e-01f, 1.93206057e-01f, 2.89143026e-01f, -8.72420445e-02f,
  2.59036303e-01f, 2.41261452e-01f, -1.13873752e-02f, -1.51966706e-01f, 7.93689676e-03f, -1.73689753e-01f, 2.27989540e-01f, -3.49908769e-01f, -4.66280095e-02f, -5.72401881e-02f,
  -2.23251149e-01f, 3.48328590e-01f, 5.39220095e-01f, 2.11842462e-01f, 4.10865843e-01f, -3.14778328e-01f, 8.02267119e-02f, 2.45323837e-01f, 2.84103155e-01f, -6.97869137e-02f,
  -2.08830088e-02f, 9.79060754e-02f, -4.88643721e-03f, -3.16212595e-01f, 4.28925723e-01f, 6.15567751e-02f, 1.50640175e-01f, 6.34223521e-01f, 2.51689732e-01f, -2.15626415e-02f,
  7.14579001e-02f, 5.32793067e-02f, 2.57891834e-01f, 5.57169095e-02f, -4.01513763e-02f, 3.00758749e-01f, 5.10217071e-01f, 3.24308187e-01f, -1.55811548e-01f, 3.37456971e-01f,
  1.23782054e-01f, 1.20947920e-01f, 3.12115163e-01f, 4.66476768e-01f, -8.64308998e-02f, -7.07791984e-01f, -7.51934424e-02f, -1.47872269e-01f, 2.94546485e-01f, -1.08254850e-01f,
  -2.95334935e-01f, 1.99454024e-01f, 2.81248927e-01f, -7.74336755e-02f, 2.99510509e-01f, 2.96403877e-02f, 6.35979831e-01f, -1.30898774e-01f, 4.09794087e-03f, -3.99314970e-01f,
  -1.88387349e-01f, 2.19133839e-01f, 1.94531679e-01f, -1.40305102e-01f, 3.26196045e-01f, 4.33307379e-01f, 7.77778476e-02f, 1.16932653e-01f, -4.46439441e-03f, -1.77718312e-01f,
  -2.59712130e-01f, -5.91278672e-02f, -2.69390792e-01f, 1.38518423e-01f, -3.14604551e-01f, -4.34369862e-01f, 4.29075211e-01f, 5.90038478e-01f, 2.39506707e-01f, -6.12699315e-02f,
  2.28028789e-01f, -1.70897901e-01f, -2.30972096e-02f, 1.30326629e-01f, -5.65218255e-02f, -5.34205996e-02f, 1.57617971e-01f, -3.42397779e-01f, 1.33496508e-01f, 1.64296955e-01f,
  -8.91739503e-02f, 5.95642805e-01f, 5.38523853e-01f, -1.84154436e-01f, 1.29733190e-01f, -1.00242244e-02f, 3.86992484e-01f, 1.98920518e-01f, 8.32573231e-03f, 1.83677971e-02f,
  2.48126939e-01f, -1.84832871e-01f, -4.77306694e-02f, -1.08670503e-01f, -1.52614981e-01f, -5.73735051e-02f, 6.12162232e-01f, -8.20131153e-02f, 3.77969921e-01f, -1.75010681e-01f,
  -7.00895265e-02f, -4.83294010e-01f, -1.21232271e-01f, -5.41341156e-02f, -4.92117405e-02f, 4.91111398e-01f, 3.04899186e-01f, 5.12475908e-01f, 1.29097149e-01f, 5.87685883e-01f,
  8.52295458e-02f, 5.23282766e-01f, -2.05987040e-02f, -1.43537382e-02f, -5.61416447e-02f, 1.08939469e-01f, 1.18628182e-02f, 1.09362796e-01f, 4.40176487e-01f, 3.47361177e-01f,
  1.64635673e-01f, 1.61523297e-01f, 5.52827358e-01f, -3.66248667e-01f, 6.46047443e-02f, -1.86664816e-02f, -2.64327526e-01f, 2.56106883e-01f, -1.74832359e-01f, 4.92637873e-01f,
  2.39682987e-01f, 5.39188683e-01f, -4.27772440e-02f, -2.02656016e-02f, 6.35802224e-02f, -1.18867286e-01f, 4.67110574e-02f, -6.69217929e-02f, 1.00512594e-01f, -3.21093351e-01f,
  6.64851665e-01f, -4.69993830e-01f, 2.19624966e-01f, 1.87167376e-01f, 4.42389846e-01f, 6.28208816e-01f, 2.06884369e-01f, -3.20233434e-01f, -1.12693705e-01f, -1.49023101e-01f,
  9.92670655e-03f, -1.59916222e-01f, -1.80260569e-01f, 1.16526447e-01f, 6.19832501e-02f, 1.18647672e-01f, -2.27055982e-01f, -9.06453282e-03f, -1.02606021e-01f, -2.88310517e-02f,
  3.11160564e-01f, -1.70194447e-01f, -2.52423733e-01f, -4.59675461e-01f, 5.56545593e-02f, 2.46068910e-01f, 3.67677987e-01f, 5.33572547e-02f, 2.46605620e-01f, -3.20907533e-01f,
  1.93680823e-02f, -6.15033880e-03f, -1.94128770e-02f, 4.20074821e-01f, -1.81385547e-01f, -3.54010373e-01f, -8.34789202e-02f, 4.25721444e-02f, 4.53184694e-01f, -2.46175230e-01f,
  -1.73035383e-01f, 2.44767386e-02f, 1.05236769e-01f, 9.75451469e-02f, 2.22998232e-01f, 1.20576106e-01f, -3.15772027e-01f, 1.34751946e-01f, 2.08808228e-01f, -3.67441654e-01f,
  1.54374123e-01f, 2.25947261e-01f, -4.09945458e-01f, -5.42603619e-02f, -8.36035088e-02f, -1.64198935e-01f, 1.73370689e-01f, -2.53658473e-01f, 1.11068062e-01f, 1.74021423e-01f,
  1.90549925e-01f, 3.36164415e-01f, -2.73351282e-01f, -9.47935954e-02f, 9.64144617e-02f, -2.91491717e-01f, 2.37920359e-01f, 1.03972346e-01f, -6.12225244e-03f, 4.60699677e-01f,
  3.76741476e-02f, 5.10982871e-01f, 5.00724763e-02f, 2.58198585e-02f, 2.70189911e-01f, 1.77953467e-02f, 7.64355958e-02f, 2.91046709e-01f, -1.90674271e-02f, -1.35946125e-01f,
  -1.28641278e-01f, 2.29580402e-01f, 5.57869098e-05f, 1.08710423e-01f, 6.00354791e-01f, -4.03221734e-02f, 2.40074277e-01f, 2.85238594e-01f, -2.17889175e-01f, 4.38699424e-01f,
  4.76378173e-01f, 1.06550649e-01f, 2.68647909e-01f, 3.47163789e-02f, 3.13929796e-01f, 5.99435627e-01f, -3.71230058e-02f, 4.38213795e-01f, 6.77501559e-02f, 4.48064297e-01f,
  -5.39456569e-02f, 2.34144881e-01f, 4.77136731e-01f, -8.83630589e-02f, 3.48708689e-01f, 1.19226195e-01f, 4.80376072e-02f, 1.61775202e-01f, 1.39733953e-02f, -4.25931253e-02f,
  -1.05404086e-01f, 4.69924100e-02f, 2.33536109e-01f, -2.95712531e-01f, 1.79293960e-01f, 8.38939995e-02f, -6.94859803e-01f, 3.53842318e-01f, 3.73791009e-01f, 2.14777410e-01f,
  6.74647540e-02f, 1.78335041e-01f, 2.33593345e-01f, 1.21155441e-01f, 9.83247384e-02f, -1.97499707e-01f, -2.77687728e-01f, -3.85842025e-02f, -4.44091499e-01f, -3.67012620e-01f,
  2.49468356e-01f, -2.40681976e-01f, 4.60294366e-01f, 4.83986586e-02f, -2.91525215e-01f, -4.19503674e-02f, 1.06122337e-01f, 1.97202146e-01f, 1.67606905e-01f, -5.27354665e-02f,
  2.52773259e-02f, 1.32126763e-01f, 6.43222407e-02f, 2.30538726e-01f, -3.57781619e-01f, 3.01619440e-01f, -1.63939267e-01f, 6.11437857e-02f, 3.03090274e-01f, 1.00012526e-01f,
  -7.34125450e-02f, -4.65495229e-01f, -1.68563664e-01f, 3.14265877e-01f, 1.60485774e-01f, -2.16207072e-01f, -3.93784344e-01f, 5.22246718e-01f, -4.85832006e-01f, 5.46680093e-01f,
  -1.15215704e-01f, -3.82028222e-02f, 7.97272772e-02f, 1.60348713e-01f, 1.45481527e-01f, -1.54130176e-01f, -5.44524007e-03f, -5.92375919e-02f, -9.24839973e-02f, -6.42230734e-02f,
  5.68499386e-01f, 3.84613901e-01f, 7.68193826e-02f, -1.26638010e-01f, 5.85889995e-01f, -3.20376486e-01f, -1.76903561e-01f, 3.39686394e-01f, 1.90322727e-01f, -2.17874095e-01f,
  7.08943531e-02f, -7.94297904e-02f, -7.87818581e-02f, 1.29063487e-01f, -4.86412384e-02f, -4.00121212e-01f, 3.51090357e-02f, 5.95106520e-02f, -4.82276529e-01f, 1.49211377e-01f,
  4.41692561e-01f, 7.79647008e-02f, 6.90627038e-01f, -3.17700021e-02f, 1.01573996e-01f, -5.56030218e-03f, -1.94696710e-02f, 9.53164175e-02f, 5.46093822e-01f, 3.82375717e-01f,
  2.44495589e-02f, 3.33265692e-01f, 1.84780583e-01f, 2.46922985e-01f, 1.23109311e-01f, 2.34089211e-01f, -6.09370181e-03f, -3.23003322e-01f, 1.05408639e-01f, 7.83765689e-03f,
  1.10749498e-01f, 8.69485587e-02f, 5.06340265e-02f, 4.10386503e-01f, -3.37942481e-01f, 4.05331790e-01f, -2.63169765e-01f, 5.11841178e-01f, -9.28634629e-02f, 4.31767814e-02f,
  -7.81218931e-02f, 1.52591899e-01f, 1.08146027e-01f, -8.16175714e-02f, -1.44013464e-01f, -1.93661358e-02f, -1.05060637e-02f, 1.16684832e-01f, 4.29006189e-01f, -9.21654820e-01f,
  -4.74845730e-02f, -1.50625035e-01f, 2.97612399e-01f, 1.42794132e-01f, 2.05439746e-01f, 1.01013206e-01f, 2.17825487e-01f, 2.57922173e-01f, 2.12572053e-01f, -1.10536988e-03f,
  1.78975284e-01f, -2.04756055e-02f, 1.65238589e-01f, 2.71836013e-01f, 4.56332192e-02f, 2.17159152e-01f, -1.30923718e-01f, -2.93454438e-01f, 3.09045553e-01f, -1.82022423e-01f,
  5.29585741e-02f, 1.70608163e-01f, -4.30590242e-01f, -1.81505710e-01f, 4.13687050e-01f, -2.53966093e-01f, 2.60217816e-01f, -3.97474598e-03f, 2.89389044e-01f, -2.45969415e-01f,
  9.14048031e-02f, -1.77264005e-01f, -3.84349942e-01f, 3.78871530e-01f, 2.88890362e-01f, 9.65832174e-02f, 1.73066571e-01f, 5.36491834e-02f, 1.02999672e-01f, 1.60929963e-01f,
  3.13224822e-01f, -7.49890655e-02f, 1.10594243e-01f, -2.89827883e-01f, 1.04691163e-01f, -2.08460271e-01f, -1.62347674e-01f, 2.35740557e-01f, -3.58697087e-01f, 3.27437490e-01f,
  3.40241224e-01f, 1.06479041e-01f, 3.08914125e-01f, -5.36861122e-02f, -1.43396243e-01f, -6.20110705e-02f, -1.64570898e-01f, -1.97315961e-01f, 1.26481831e-01f, 2.04582632e-01f,
  3.58598620e-01f, -4.18952852e-01f, 5.80352962e-01f, -5.87831557e-01f, -2.41004184e-01f, 3.07011276e-01f, -2.09394395e-02f, 1.20077834e-01f, 2.80793849e-02f, 9.29880440e-02f,
  8.86427090e-02f, 8.16226527e-02f, 1.24452129e-01f, -2.95843277e-02f, 1.61267206e-01f, -3.00380260e-01f, 1.00462444e-01f, -8.16451013e-02f, 8.08890238e-02f, -3.74915600e-01f,
  -4.97850962e-02f, -5.17956197e-01f, 1.06377222e-01f, -6.93543330e-02f, 2.82825142e-01f, 1.60550594e-01f, -1.98809311e-01f, 6.28261864e-01f, 1.65796846e-01f, 4.69165295e-02f,
  2.40173072e-01f, 6.61892354e-01f, -1.27199024e-01f, 4.16854858e-01f, -1.42944157e-01f, 2.54295953e-02f, -2.10384503e-01f, 7.19768465e-01f, 6.60347223e-01f, 3.62760633e-01f,
  2.56917596e-01f, 3.34839940e-01f, -6.57161623e-02f, 1.70358390e-01f, -1.52558491e-01f, -7.45394379e-02f, -6.75534084e-02f, 1.45966291e-01f, -1.22038178e-01f, 1.08996682e-01f,
  2.55795568e-01f, 2.26009637e-01f, 2.84737855e-01f, 4.72673595e-01f, 1.16026767e-01f, 5.76987326e-01f, 1.83683783e-02f, -2.46687710e-01f, 2.35263095e-03f, 2.07253307e-01f,
  1.73393682e-01f, -4.21455726e-02f, -4.01082098e-01f, 5.68597376e-01f, -1.45735741e-01f, 1.02155827e-01f, 7.72444829e-02f, -1.49943799e-01f, 1.15729049e-01f, -6.08978808e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.86060506e-01f, -4.00874764e-01f, 4.74541575e-01f, 1.85967013e-01f, 1.50747791e-01f, 1.29303038e-01f, 1.38221353e-01f, 2.98883114e-02f, -3.35528515e-02f, -2.97475278e-01f,
  1.49607256e-01f, -1.39155746e-01f, 9.88267455e-03f, 8.58676955e-02f, 1.67103410e-01f, 2.68339574e-01f, 3.68932784e-01f, 2.92392135e-01f, 4.20816839e-01f, 1.12963773e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -6.67928234e-02f, -1.98456943e-02f, -2.87656516e-01f, -1.11751363e-01f, -2.28586346e-01f, 9.28599387e-02f, 8.51884708e-02f, -2.18922362e-01f, -4.94976528e-02f, -1.73078477e-01f,
  1.94723442e-01f, -4.55657206e-02f, -6.82469830e-02f, -1.99112579e-01f, 1.55448467e-01f, -1.78447843e-01f, -1.11227855e-01f, -1.66549087e-01f, 1.48466751e-01f, 3.23400460e-02f,
  2.16186792e-01f, -2.33991325e-01f, -5.73613346e-02f, -1.93784267e-01f, -1.31689057e-01f, -9.64421779e-03f, 3.04877520e-01f, 2.75861807e-02f, -2.73341268e-01f, -1.89220458e-01f,
  7.40033388e-02f, 2.55520642e-01f, -3.80762190e-01f, -1.59409031e-01f, 1.50655434e-01f, -4.54282016e-02f, -1.83869019e-01f, -1.33739173e-01f, -7.82217160e-02f, 1.59395948e-01f,
  -1.77204400e-01f, -2.57369168e-02f, -1.54044554e-02f, -2.85992950e-01f, -1.38105586e-01f, 1.69797018e-01f, -4.01443809e-01f, 1.38742507e-01f, 3.17428529e-01f, -1.29407704e-01f,
  1.12355724e-01f, -1.93684772e-02f, -1.00186497e-01f, 1.59691170e-01f, 2.94895411e-01f, -5.27424440e-02f, 1.88520253e-01f, 1.19497180e-01f, -1.55310750e-01f, 2.50103083e-02f,
  -2.92444885e-01f, -6.06814725e-03f, 3.33873816e-02f, 4.50026132e-02f, 1.87333569e-01f, -1.02041401e-01f, -8.55383649e-02f, 3.55915278e-01f, 1.21309243e-01f, -9.45282206e-02f,
  -4.58431780e-01f, 1.06574379e-01f, -9.30514336e-02f, -1.28567934e-01f, 1.34729028e-01f, 1.65015876e-01f, -4.23725396e-02f, -4.67256643e-02f, 1.03627391e-01f, 1.65104319e-03f,
  -1.62938923e-01f, 1.34274036e-01f, -2.31008548e-02f, 2.54339457e-01f, -1.00781158e-01f, 2.21511964e-02f, -9.97243375e-02f, -2.32769791e-02f, -3.11965197e-01f, 4.49710377e-02f,
  1.60175815e-01f, -1.82423482e-05f, 3.01171262e-02f, -2.28736579e-01f, 5.98646663e-02f, 2.68020071e-02f, 2.79063344e-01f, 5.54262251e-02f, -8.01070035e-03f, 5.59461899e-02f,
  6.11997060e-02f, 3.04881841e-01f, 3.55960786e-01f, 1.63833216e-01f, 1.37849927e-01f, -7.60357082e-02f, -2.86155473e-02f, 2.73253500e-01f, 8.35734457e-02f, -3.29604059e-01f,
  1.67917520e-01f, -1.97866540e-02f, -1.40225753e-01f, -2.62390394e-02f, 7.65472557e-03f, -1.14633895e-01f, -1.98357448e-01f, 4.78998311e-02f, 1.45717770e-01f, -1.05545171e-01f,
  1.00756571e-01f, 2.04196021e-01f, -3.80982645e-02f, 1.68211713e-01f, 9.04684290e-02f, 1.66362152e-01f, 3.58821362e-01f, 3.63377258e-02f, -1.58872560e-01f, 2.64436752e-01f,
  -1.01088965e-02f, -2.68110603e-01f, -1.72889575e-01f, -5.31248689e-01f, -3.19126397e-01f, -1.35792186e-02f, -2.24963561e-01f, -6.76500648e-02f, -3.06374520e-01f, 3.25521111e-01f,
  7.00899959e-02f, 2.94909000e-01f, -8.92403349e-02f, 3.86305787e-02f, 7.82734454e-02f, 5.15720211e-02f, 4.66364548e-02f, 2.52354026e-01f, -2.38518134e-01f, -1.54317990e-01f,
  -2.17122417e-02f, 1.02325659e-02f, -1.49478972e-01f, 2.64342856e-02f, -2.87410080e-01f, -1.98761031e-01f, -8.18773359e-02f, -1.43603340e-01f, -1.75305232e-01f, 1.12163246e-01f,
  -4.19047810e-02f, 6.99089095e-02f, 1.93092883e-01f, 3.29539210e-01f, -6.65199533e-02f, 1.69034064e-01f, -1.99477077e-01f, -6.10977054e-01f, 5.85475385e-01f, -3.86823229e-02f,
  -1.83761939e-01f, -5.06955236e-02f, -1.11530282e-01f, -1.48945332e-01f, -2.50046682e-02f, 1.22101985e-01f, 2.76932895e-01f, -1.48452461e-01f, 1.37763515e-01f, 6.23152293e-02f,
  7.83999413e-02f, 1.44640589e-03f, -3.30922306e-02f, -2.37621009e-01f, 6.57223314e-02f, -6.98435083e-02f, -6.14772141e-02f, -3.16976249e-01f, -1.29940659e-01f, 2.26743937e-01f,
  8.21638852e-02f, 7.90613666e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -6.08648360e-01f, -1.24460578e-01f, 2.38177910e-01f, -1.94269165e-01f, 1.66627109e-01f, -2.27211684e-01f, -1.29786864e-01f, -1.56491041e-01f, 5.22150576e-01f, -2.69204527e-01f,
  3.52242887e-02f, -8.92117769e-02f, -2.52537936e-01f, -2.28631392e-01f, 3.19392979e-01f, 1.06427670e-01f, 2.97159493e-01f, 1.78061705e-02f, 4.06585753e-01f, -1.45779237e-01f,
  -2.07257181e-01f, 3.81290495e-01f, 1.05420768e-01f, 3.40347379e-01f, -5.84398136e-02f, -5.97987622e-02f, -1.13820620e-01f, -3.20541918e-01f, 5.87991402e-02f, 1.10248573e-01f,
  2.71903705e-02f, -1.99053809e-02f, 1.18864782e-01f, -4.07580845e-02f, 3.06721926e-01f, -2.07841381e-01f, 4.43831831e-01f, -3.89959738e-02f, 3.13504934e-01f, 7.89482653e-01f,
  -2.95742542e-01f, 3.33612204e-01f, -2.38047615e-01f, 6.02500699e-02f, 1.02658182e-01f, -5.57882071e-01f, 3.87653142e-01f, 5.31357378e-02f, 1.09971657e-01f, -1.95442691e-01f,
  3.03134441e-01f, 8.88517946e-02f, 2.57280767e-01f, 2.05404177e-01f, -5.23149930e-02f, 1.31987825e-01f, -1.48565024e-01f, 1.83392569e-01f, 2.37742707e-01f, -1.06796116e-01f,
  -3.34759861e-01f, -6.45568550e-01f, -3.40061337e-01f, 1.42212763e-01f, -2.49995455e-01f, 4.80774313e-01f, 9.59155038e-02f, 2.16602176e-01f, -7.45741799e-02f, -1.37292415e-01f,
  -3.21200669e-01f, -6.23677433e-01f, -3.09374124e-01f, -4.27202851e-01f, -3.50789987e-02f, 1.27823412e-01f, -2.42442027e-01f, 6.91128895e-02f, -2.22225294e-01f, 2.33149841e-01f,
  3.09229404e-01f, 3.29632699e-01f, 8.14738050e-02f, 4.04113322e-01f, 4.07155484e-01f, -1.88448250e-01f, -1.82131007e-01f, 5.21422364e-02f, 2.72707175e-02f, 2.32302118e-02f,
  6.86603934e-02f, 5.62225208e-02f, 4.07576770e-01f, 2.71726727e-01f, 1.81168646e-01f, -1.34220168e-01f, 3.24661195e-01f, 7.02282861e-02f, 5.85943282e-01f, -3.93716097e-01f,
  5.78977883e-01f, 1.72413588e-01f, -5.61679959e-01f, -1.52483389e-01f, -3.55465800e-01f, 5.97378194e-01f, -5.46661198e-01f, -1.15602702e-01f, -5.41097105e-01f, -6.80044480e-03f,
  1.78490341e-01f, 1.89060003e-01f, 3.79797459e-01f, -2.34968722e-01f, 4.85729575e-01f, -1.90524265e-01f, 4.50645447e-01f, 6.55676099e-03f, -1.08550191e-01f, 1.88164845e-01f,
  -6.22831620e-02f, -2.57166594e-01f, 6.11761175e-02f, 6.72514439e-02f, -7.72079527e-02f, -1.33907303e-01f, -5.02312720e-01f, 3.80963415e-01f, -4.79861572e-02f, 1.99174834e-03f,
  -7.40100220e-02f, 1.12738274e-01f, 2.21975744e-01f, -5.09868920e-01f, -2.56005730e-02f, -1.65100530e-01f, 3.56373303e-02f, 3.58936518e-01f, -3.35703731e-01f, 3.56200673e-02f,
  -3.06005716e-01f, 3.17648590e-01f, -3.07357637e-03f, -4.64374609e-02f, 1.11173749e-01f, -1.64755106e-01f, 3.56175154e-01f, 2.58122385e-01f, 5.62325060e-01f, 1.83727711e-01f,
  -3.20424139e-02f, 2.23999768e-01f, -9.74906534e-02f, -4.08538431e-02f, 1.51764601e-01f, -1.48692846e-01f, -2.72570066e-02f, 2.47997642e-01f, 4.54995148e-02f, -5.99584877e-02f,
  1.89915955e-01f, -4.36289422e-03f, 1.91890553e-01f, -1.69725657e-01f, -1.53097376e-01f, 3.06051761e-01f, 4.49165434e-01f, 3.07340413e-01f, -1.82787731e-01f, 5.02371073e-01f,
  -3.52740586e-01f, -2.41794586e-02f, -2.55982518e-01f, -8.98023099e-02f, 2.13028565e-01f, 3.40671348e-03f, 8.56924057e-02f, -6.56933069e-01f, -1.43306684e-02f, -9.78667915e-01f,
  -1.48421794e-01f, 2.54752878e-02f, -9.64452699e-02f, 3.10697615e-01f, 1.77736044e-01f, -1.60750952e-02f, -8.44355166e-01f, 4.88436610e-01f, -1.36674687e-01f, 2.00009942e-01f,
  9.96080115e-02f, 6.67159796e-01f, 4.65513803e-02f, 3.85951757e-01f, 4.56517011e-01f, 4.82660800e-01f, 3.00590664e-01f, 2.96739042e-01f, -2.59709179e-01f, -1.52897716e-01f,
  4.86885160e-01f, -5.01723111e-01f, 3.14071506e-01f, 7.57891953e-01f, -5.75787842e-01f, -2.04608902e-01f, 7.73187518e-01f, 2.53125846e-01f, -5.38741536e-02f, 3.31735939e-01f,
  -3.01152915e-01f, 1.78827763e-01f, -3.30829084e-01f, 5.20626903e-02f, -5.19851670e-02f, -1.98906213e-01f, -3.14494014e-01f, -3.12962860e-01f, 5.70725918e-01f, 5.87742291e-02f,
  4.02530581e-01f, 2.08651394e-01f, 2.60194093e-01f, 8.36321712e-02f, 2.20368445e-01f, 1.72540069e-01f, 8.75242129e-02f, 1.43553913e-01f, 3.91746163e-01f, 7.60849476e-01f,
  1.90781549e-01f, 9.20475870e-02f, -6.46502614e-01f, -4.14277673e-01f, 5.84267437e-01f, -3.55261117e-01f, -5.79196334e-01f, -1.79968625e-01f, 3.35789233e-01f, 1.93331521e-02f,
  3.41630042e-01f, 1.55274525e-01f, 1.45190611e-01f, -1.32958695e-01f, 6.26054466e-01f, -1.52998306e-02f, -2.20322356e-01f, -1.30303400e-02f, -6.99748397e-02f, -3.38975430e-01f,
  6.90192163e-01f, 2.55451858e-01f, 4.95574325e-01f, 1.08415738e-01f, 1.50201231e-01f, 1.34693757e-01f, 2.74321973e-01f, 2.36190602e-01f, -2.37377003e-01f, 2.87918478e-01f,
  4.90342081e-01f, 6.16062462e-01f, 6.51808739e-01f, 3.53189707e-01f, -1.72986180e-01f, 4.30440813e-01f, -1.53277338e-01f, -6.57754689e-02f, 9.67461467e-01f, -1.97373331e-01f,
  -3.41982245e-01f, 2.35358626e-01f, -1.41969845e-01f, -2.00151816e-01f, 1.56528279e-01f, 2.20859125e-01f, -7.78645799e-02f, -4.81089979e-01f, 3.83705705e-01f, 5.38872443e-02f,
  -5.35726488e-01f, 2.73912512e-02f, 5.52503109e-01f, -2.52862185e-01f, 3.63896936e-02f, -1.83186471e-01f, 4.88764882e-01f, -2.65919298e-01f, 2.36508653e-01f, -4.99632694e-02f,
  -2.67813087e-01f, 2.56690115e-01f, 6.40290827e-02f, 2.41114020e-01f, 5.60509503e-01f, 7.65514612e-01f, -1.24747030e-01f, -2.77082389e-03f, 4.98868674e-02f, 6.02468967e-01f,
  4.98557121e-01f, -2.67299831e-01f, 1.65484279e-01f, -4.22972813e-02f, -4.22144026e-01f, 5.22717498e-02f, -1.57206189e-02f, 1.21302314e-01f, -2.03159526e-01f, 5.71093000e-02f,
  -2.91506182e-02f, 7.87177160e-02f, 1.42029032e-01f, 5.42627931e-01f, 2.42560934e-02f, 3.49978507e-02f, -5.54039299e-01f, -7.53106400e-02f, 2.08737761e-01f, 1.38912365e-01f,
  2.82984853e-01f, 2.40895838e-01f, 2.41693825e-01f, 6.21545389e-02f, 1.91358343e-01f, -3.38004649e-01f, -3.18509132e-01f, -6.53582275e-01f, 6.47251070e-01f, 5.04821777e-01f,
  -5.28812468e-01f, -1.80343434e-01f, 3.97955567e-01f, 1.83475658e-01f, -1.76450275e-02f, 5.80786288e-01f, 2.19274476e-01f, -9.87781808e-02f, -9.38971415e-02f, 1.18852846e-01f,
  -2.05545664e-01f, 1.18953161e-01f, 2.23134935e-01f, 2.43698254e-01f, 1.47386476e-01f, 1.56172454e-01f, -4.75186288e-01f, -2.43624784e-02f, -2.84747444e-02f, -2.46754199e-01f,
  1.07938081e-01f, 1.15914159e-01f, -4.46027368e-01f, -2.93564945e-01f, 1.67603850e-01f, -2.49241859e-01f, -3.31344083e-02f, -7.04472780e-01f, 2.35128164e-01f, -4.79977727e-02f,
  3.58944386e-01f, 8.29811320e-02f, -2.58283466e-01f, -9.85416621e-02f, -9.51297432e-02f, -8.85214880e-02f, 4.42768395e-01f, 2.27027424e-02f, 3.51385176e-01f, 5.45366965e-02f,
  4.43458468e-01f, 4.76458594e-02f, 2.02123985e-01f, 4.05759871e-01f, 2.25780725e-01f, 2.88828492e-01f, -1.45346314e-01f, -2.35949576e-01f, 2.14622647e-01f, -3.29125851e-01f,
  -1.56980783e-01f, 7.34125613e-04f, 2.19532117e-01f, -2.95627743e-01f, 1.76925972e-01f, 2.70721704e-01f, -3.11840773e-01f, 4.32313383e-01f, 4.03627664e-01f, 7.00291336e-01f,
  6.38455987e-01f, 5.08580506e-01f, -1.41232103e-01f, -6.21825337e-01f, 6.36222422e-01f, 1.82592034e-01f, 3.31329197e-01f, -3.54542464e-01f, 3.11428607e-02f, -2.14719847e-01f,
  2.16732219e-01f, 2.22264379e-01f, 1.23284915e-02f, 3.31824012e-02f, 2.02251107e-01f, -2.45870575e-01f, 3.52981657e-01f, -1.65070891e-02f, 2.94371605e-01f, 1.97921664e-01f,
  3.39923590e-01f, 8.67926404e-02f, 1.59416418e-03f, -1.77927539e-02f, 1.05367109e-01f, -3.18336755e-01f, 3.95807140e-02f, 1.95976049e-01f, 3.03011477e-01f, -6.49429336e-02f,
  5.58949523e-02f, -2.29195163e-01f, -3.36043715e-01f, -5.78197718e-01f, 3.84300888e-01f, -2.55476952e-01f, -7.06808493e-02f, 2.08452642e-01f, -3.54538292e-01f, 2.39652231e-01f,
  2.26472408e-01f, 1.25621830e-03f, 1.73660770e-01f, 3.34225953e-01f, 1.78029701e-01f, 6.39117584e-02f, 1.24876484e-01f, -3.30686003e-01f, -7.65593797e-02f, -4.74214144e-02f,
  1.86259076e-01f, 1.56576261e-01f, -2.93599635e-01f, 6.78290054e-02f, 3.36322188e-01f, 5.16935289e-01f, 7.65893087e-02f, 2.96264708e-01f, 9.17607620e-02f, 2.21721917e-01f,
  3.18829983e-01f, -1.47291914e-01f, 2.92350113e-01f, 4.68492091e-01f, -4.42811340e-01f, 2.05462292e-01f, -3.71118128e-01f, 4.21162918e-02f, -5.44630289e-01f, 1.53665736e-01f,
  -5.16370177e-01f, -1.75386712e-01f, 1.03394300e-01f, 2.34536946e-01f, 3.72125208e-01f, 3.80108416e-01f, 2.82330364e-01f, -4.78002846e-01f, 5.06442070e-01f, -3.24322224e-01f,
  1.02783039e-01f, -5.26120663e-02f, 1.85059011e-01f, 2.33236179e-01f, -3.62116933e-01f, 1.97451934e-01f, 3.39269608e-01f, 2.21197665e-01f, -3.40349525e-01f, 5.50259203e-02f,
  4.31867152e-01f, 8.69378000e-02f, 1.08749419e-01f, -1.01231910e-01f, -7.94580504e-02f, 4.76615131e-01f, -5.52726150e-01f, 1.39501914e-01f, -5.42599499e-01f, 4.43151027e-01f,
  1.43293291e-01f, -4.65484560e-01f, -1.67029858e-01f, 5.64413071e-01f, -5.07324517e-01f, -9.86812860e-02f, -6.97853789e-02f, 2.91971534e-01f, -3.95641588e-02f, 1.32058814e-01f,
  1.78042129e-01f, -2.52381921e-01f, -4.10279155e-01f, 3.11486930e-01f, 1.13986209e-01f, 5.88236786e-02f, -2.54372895e-01f, 5.10654569e-01f, 1.72836274e-01f, 1.36465505e-01f,
  -2.01929644e-01f, 2.66540200e-01f, -1.05923459e-01f, -2.84834392e-02f, -2.18020350e-01f, 3.42922598e-01f, 1.63938403e-01f, 1.73804417e-01f, -4.98692915e-02f, 7.46580139e-02f,
  -3.59664172e-01f, 1.74446538e-01f, 2.76508421e-01f, 3.55535328e-01f, 8.72646365e-03f, 5.22940792e-02f, 7.06982538e-02f, 5.17680287e-01f, -2.04583168e-01f, 6.43076599e-02f,
  3.62083852e-01f, 4.24989343e-01f, -2.38188773e-01f, -3.14277500e-01f, -4.59289223e-01f, 6.43832311e-02f, -6.51165247e-01f, 3.01280379e-01f, 3.94498527e-01f, -2.01777160e-01f,
  1.21778011e-01f, -7.75411204e-02f, 4.33494776e-01f, 4.07907277e-01f, -3.22553456e-01f, -2.01736242e-01f, -2.09794819e-01f, -3.30890939e-02f, -2.88015932e-01f, -2.14253411e-01f,
  -2.86501586e-01f, 2.25945681e-01f, -3.06212693e-01f, 1.25284523e-01f, 3.05522442e-01f, 4.15012211e-01f, 7.65037781e-04f, 2.69761413e-01f, 2.78653115e-01f, 5.20814717e-01f,
  -2.52632409e-01f, 1.82961747e-01f, 2.59420071e-02f, 5.48669815e-01f, -4.37136441e-01f, 6.31927475e-02f, -3.81730527e-01f, 4.34753418e-01f, 1.23634167e-01f, 4.36659008e-01f,
  1.39261931e-01f, -9.63122919e-02f, -3.03125996e-02f, -1.01488732e-01f, 2.37013176e-01f, 5.67192078e-01f, 2.48219073e-01f, 2.63045400e-01f, -5.69656670e-01f, 1.83752924e-01f,
  -3.41561466e-01f, 1.58517674e-01f, 2.49546230e-01f, 6.81795657e-01f, -3.98994654e-01f, 4.15323712e-02f, 5.82655430e-01f, -2.78030217e-01f, 3.25374454e-02f, 2.51387179e-01f,
  -4.37754631e-01f, -1.84891015e-01f, 2.36966103e-01f, 3.69940460e-01f, 1.17308972e-03f, 5.79426050e-01f, 1.61808938e-01f, 5.57565987e-02f, -2.92131957e-02f, 3.42733860e-01f,
  -1.77786931e-01f, 1.23171948e-01f, 4.90501106e-01f, 1.16767837e-02f, -4.78302613e-02f, -1.82904169e-01f, 3.27876247e-02f, -2.86840975e-01f, 4.46375102e-01f, 6.53636605e-02f,
  -6.51353672e-02f, -1.10682793e-01f, 3.74516040e-01f, 6.32441223e-01f, -4.00070585e-02f, 6.80097878e-01f, -5.31299472e-01f, 4.86054868e-01f, 1.90678716e-01f, -1.41841292e-01f,
  1.67020828e-01f, -2.90698022e-01f, 1.65090650e-01f, 1.40714958e-01f, -1.73366487e-01f, -1.86483234e-01f, 4.26487476e-01f, 3.07976063e-02f, 7.95524791e-02f, 2.01709956e-01f,
  -2.93696016e-01f, 2.05417097e-01f, -5.17202139e-01f, 3.33307207e-01f, 4.39756900e-01f, -2.58451104e-01f, -1.76557273e-01f, -5.20430148e-01f, -3.10561240e-01f, 3.45016092e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.45472074e-01f, 2.13630602e-01f, 4.86937203e-02f, 1.83775797e-01f, -2.20077112e-01f, 7.72162229e-02f, 4.33740556e-01f, 1.67171419e-01f, 3.99217159e-01f, 9.91839468e-02f,
  2.23379359e-01f, -1.67865500e-01f, 4.15168792e-01f, -9.95049775e-02f, 5.77091575e-01f, 1.84676200e-01f, 3.95901278e-02f, -1.10769987e-01f, -1.36307225e-01f, 5.97316213e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -1.17260730e-02f, -5.85393846e-01f, -1.79602817e-01f, -3.92980605e-01f, -5.34897625e-01f, -1.83158338e-01f, 4.89863932e-01f, -2.71575570e-01f, 3.22759628e-01f, -2.60309596e-02f,
  4.94775474e-01f, -3.55496593e-02f, 1.35569096e-01f, -5.97244129e-02f, 1.24674402e-01f, -5.08803315e-02f, 1.16217017e-01f, -7.90019810e-01f, -1.00343108e+00f, -1.21292323e-01f,
  -9.23410654e-02f, -8.30278575e-01f, -4.69736420e-02f, 5.04992791e-02f, -3.16846877e-01f, 3.35379578e-02f, -7.42766678e-01f, 3.17082666e-02f, 2.09527045e-01f, 2.79070884e-01f,
  3.22953045e-01f, 8.45840797e-02f, -6.80881888e-02f, -4.87202227e-01f, -1.81379750e-01f, -3.24196368e-01f, 3.58625293e-01f, -6.61202133e-01f, 3.69861126e-01f, -2.45030716e-01f,
  -1.70108512e-01f, -2.92938322e-01f, 6.16806448e-01f, -1.44722044e-01f, 1.86051443e-01f, 2.54134506e-01f, 2.35478252e-01f, 2.75106907e-01f, 2.84366399e-01f, -3.55044335e-01f,
  -5.76138616e-01f, -6.32663295e-02f, -7.28447080e-01f, 1.92742690e-01f, 2.31394708e-01f, 3.27774137e-01f, -5.20100117e-01f, 2.37450123e-01f, 2.45922476e-01f, -1.46329686e-01f,
  -3.02910715e-01f, -2.21472979e-01f, -2.58966357e-01f, -2.38782570e-01f, 2.47645471e-02f, -3.75229754e-02f, 3.23107660e-01f, 1.04874894e-01f, 4.17625636e-01f, -2.55845916e-02f,
  -7.05269456e-01f, 3.89776528e-01f, 1.83601733e-02f, 1.03061438e-01f, -4.07188274e-02f, 4.97287005e-01f, 1.05378935e-02f, -5.55791199e-01f, 4.08545472e-02f, -6.76921457e-02f,
  -2.03562707e-01f, -3.24028969e-01f, -2.95375377e-01f, -4.78199989e-01f, 8.80517066e-01f, -2.85068899e-01f, 6.33727849e-01f, 1.52404336e-02f, 7.71362055e-03f, -2.33188421e-01f,
  -1.51145056e-01f, -1.19308427e-01f, 1.42762095e-01f, -4.98255312e-01f, -7.70194903e-02f, -5.23001909e-01f, 2.72647053e-01f, 1.19544223e-01f, -2.43504047e-01f, 1.34780586e-01f,
  -7.60087550e-01f, -3.53733480e-01f, 2.70423949e-01f, 1.15817100e-01f, -2.99476534e-01f, 8.58233124e-02f, 2.33892381e-01f, -3.20508212e-01f, -4.08922672e-01f, -3.27608377e-01f,
  5.55736497e-02f, -5.43857217e-01f, -1.66011140e-01f, -1.43195957e-01f, -3.63659620e-01f, -9.58374500e-01f, -7.60972947e-02f, 1.95735246e-01f, 2.91473985e-01f, -7.43503690e-01f,
  -2.52191484e-01f, 1.12005491e-02f, -4.42650408e-01f, 2.80611426e-01f, 1.96368992e-01f, 3.94266218e-01f, -2.38245782e-02f, 7.93275386e-02f, 1.87964797e-01f, 1.63626239e-01f,
  -4.89777058e-01f, 5.14155626e-02f, 4.51626718e-01f, 2.83401340e-01f, 5.10685086e-01f, 3.32586795e-01f, 5.70484877e-01f, 2.74924636e-01f, 7.02620521e-02f, -4.05670643e-01f,
  -4.65113372e-02f, 3.00873786e-01f, -1.08585387e-01f, -3.95713270e-01f, 1.17512666e-01f, 1.89209670e-01f, -2.95208007e-01f, -2.75812149e-01f, 2.12232292e-01f, 5.03316522e-01f,
  -1.34562388e-01f, 1.48098037e-01f, 4.40539300e-01f, -2.94840395e-01f, -3.31346989e-01f, -2.91055828e-01f, 4.73061278e-02f, 5.15915155e-02f, 1.34577021e-01f, 2.44612902e-01f,
  -6.99544132e-01f, 5.06936967e-01f, 4.40896839e-01f, 1.36512771e-01f, -1.55123606e-01f, 5.24400651e-01f, 4.00667220e-01f, 2.09412158e-01f, 2.26028841e-02f, -3.66860211e-01f,
  -2.38631830e-01f, 5.58883920e-02f, -6.45830259e-02f, 3.75558674e-01f, -8.72479454e-02f, 3.47494721e-01f, -6.48662150e-02f, -1.72577992e-01f, -2.45274276e-01f, 2.89888829e-01f,
  1.55357402e-02f, -3.24179113e-01f, -7.47709051e-02f, -5.42101674e-02f, 4.19010557e-02f, -4.11265701e-01f, 1.48824751e-01f, 2.62956500e-01f, -1.76601037e-01f, -4.14744884e-01f,
  2.60152429e-01f, 4.20625001e-01f, -1.81100905e-01f, 2.91696727e-01f, 4.38830927e-02f, -8.12103823e-02f, -8.77142921e-02f, -1.58125475e-01f, -3.49803597e-01f, -4.52799231e-01f,
  -6.92723215e-01f, 3.36205781e-01f, -4.68935184e-02f, 1.80210277e-01f, 3.68558288e-01f, -1.22859627e-01f, 1.69986576e-01f, -2.33162105e-01f, -5.19099295e-01f, -8.09945688e-02f,
  2.66069919e-01f, 2.28453964e-01f, -5.54127753e-01f, -1.78683192e-01f, -1.87543094e-01f, -3.37295420e-02f, 3.88551474e-01f, 3.10257882e-01f, 4.04014111e-01f, -7.22030640e-01f,
  -9.20755029e-01f, -7.14226186e-01f, -5.99770963e-01f, -1.62275046e-01f, -3.79579425e-01f, -2.79289454e-01f, -4.09344822e-01f, 4.26904261e-01f, 1.81497574e-01f, 5.31358384e-02f,
  4.26756479e-02f, 1.60696749e-02f, 1.85697332e-01f, 2.62686368e-02f, -3.89653265e-01f, -2.02792928e-01f, 2.94155389e-01f, -3.63431156e-01f, -3.94118112e-03f, -2.86943972e-01f,
  7.73112997e-02f, 3.74143898e-01f, 3.23237538e-01f, 2.08147895e-03f, -7.78436124e-01f, -1.77578405e-01f, -1.01276107e-01f, 2.85640955e-01f, -4.76447970e-01f, 1.84868630e-02f,
  -5.64411342e-01f, -2.41924718e-01f, 1.37326732e-01f, 2.01494113e-01f, -1.60407107e-02f, -4.55545634e-01f, 5.05905926e-01f, -1.27764136e-01f, -2.89109856e-01f, 3.54982555e-01f,
  -1.52519062e-01f, 5.42635471e-02f, -2.16537341e-01f, 5.49460113e-01f, -2.28575006e-01f, -1.51058942e-01f, -3.72121334e-01f, 6.01447284e-01f, -5.05648315e-01f, -6.85953856e-01f,
  4.18437012e-02f, 2.95863926e-01f, 1.45228744e-01f, 5.35780013e-01f, -1.78331226e-01f, 1.09681308e-01f, -5.50400436e-01f, -2.72632927e-01f, -7.17491135e-02f, -4.27242607e-01f,
  -2.56729215e-01f, 2.57400006e-01f, 3.07872504e-01f, 3.56997937e-01f, -5.25195718e-01f, -5.28982103e-01f, -6.22687221e-01f, -5.85547626e-01f, 7.40497231e-01f, -1.53181091e-01f,
  5.70153296e-01f, 1.38001263e-01f, -1.22154340e-01f, 1.08272225e-01f, -3.89319599e-01f, -3.91406119e-01f, 8.50470603e-01f, 4.34692532e-01f, 3.01739350e-02f, 3.42049122e-01f,
  -1.52765512e-01f, -6.01250648e-01f, 2.27081656e-01f, -2.59649873e-01f, -5.02236420e-03f, -4.24796402e-01f, 1.97333664e-01f, 2.62891024e-01f, 3.11882049e-01f, -6.24421895e-01f,
  -3.34849507e-01f, -1.70025171e-03f, 2.01178059e-01f, -1.97180472e-02f, -5.47308736e-02f, -1.00648630e+00f, 2.45574355e-01f, -3.36339474e-01f, -5.31012230e-02f, -4.33630705e-01f,
  1.59862921e-01f, 2.09550783e-01f, 3.12982388e-02f, 2.10878924e-02f, 1.14786893e-01f, -3.47765535e-02f, 2.01073419e-02f, 9.81733203e-02f, 2.06122145e-01f, 3.71714085e-01f,
  4.04897690e-01f, -2.83287078e-01f, -1.19461149e-01f, 4.79455024e-01f, -6.74423933e-01f, 3.17901433e-01f, -4.82065052e-01f, 5.99845111e-01f, -2.35049780e-02f, -4.43823040e-01f,
  -1.77711144e-01f, 4.44933295e-01f, -6.52331635e-02f, -5.82809627e-01f, -5.78055799e-01f, -3.45451057e-01f, 5.39621651e-01f, 6.93742409e-02f, 1.18935257e-01f, 2.16290027e-01f,
  -7.77503490e-01f, 4.21191692e-01f, -1.68662131e-01f, -2.29586456e-02f, -4.92885411e-02f, 1.45324126e-01f, -2.16218412e-01f, 2.57532597e-01f, -2.00514138e-01f, 2.07364649e-01f,
  -2.98882067e-01f, 7.44352788e-02f, -1.02491125e-01f, -4.70735192e-01f, -6.16807938e-01f, -4.20652896e-01f, 2.71457493e-01f, -5.24607539e-01f, -9.44345817e-02f, -5.52838743e-01f,
  -4.37469810e-01f, 2.42352441e-01f, -5.87394714e-01f, 6.65156022e-02f, -7.75087595e-01f, -2.43819177e-01f, 2.10457429e-01f, 1.82294905e-01f, 2.95685053e-01f, 3.73209387e-01f,
  -4.43493813e-01f, -8.43301937e-02f, 5.35238802e-01f, -2.12571621e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.46646100e-01f, 2.93300673e-03f, 3.05701435e-01f, -1.12783134e-01f, 7.00296462e-02f, 6.80789351e-02f, 2.71207303e-01f, -2.46255457e-01f, 1.98973909e-01f, 1.13601707e-01f,
  8.69932845e-02f, 3.70779298e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    