/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.35507065e-01f, -2.44066283e-01f, -1.01575684e-02f, -1.52320331e-02f, 1.31307021e-01f, -3.39519754e-02f, -2.69212842e-01f, -2.35823661e-01f, -5.26152290e-02f, -2.80429106e-02f,
  7.94387758e-02f, 6.35200441e-02f, 9.20955837e-02f, 6.90266415e-02f, -4.18105349e-02f, -8.08087885e-02f, 1.49480477e-01f, 4.71830890e-02f, -5.23052318e-03f, -9.63708758e-02f,
  9.57774557e-03f, -6.35203272e-02f, -5.30571938e-02f, 1.44519415e-02f, 1.18832052e-01f, 5.89295216e-02f, -2.57648528e-02f, 1.32180542e-01f, 6.56743571e-02f, 2.60039508e-01f,
  1.33835450e-01f, -8.31362158e-02f, 1.04490779e-01f, 8.52699280e-02f, 9.85209420e-02f, -1.29415840e-01f, -6.44583851e-02f, -1.80427395e-02f, 1.74464479e-01f, -2.27790400e-02f,
  8.37103054e-02f, 1.01611011e-01f, 1.48851678e-01f, 7.16792941e-02f, -2.50594672e-02f, -1.98265468e-03f, -9.25953090e-02f, -4.99104075e-02f, -6.60255551e-02f, 4.84796539e-02f,
  1.16733268e-01f, 1.57122225e-01f, -1.31086022e-01f, -5.53327352e-02f, -3.10752764e-02f, 1.89121738e-01f, 6.21421449e-02f, 1.51156075e-02f, -1.24859601e-01f, -2.49491438e-01f,
  -4.95303655e-03f, 1.38037987e-02f, -3.01168370e-03f, -5.74444719e-02f, -6.10641912e-02f, -1.71741622e-03f, 3.57545093e-02f, -6.04937784e-02f, 2.84154695e-02f, -7.25066885e-02f,
  2.97062527e-02f, -3.35876532e-02f, 5.37663847e-02f, -2.70137154e-02f, -2.02776734e-02f, 9.47968103e-03f, 6.76472038e-02f, -5.84527850e-02f, 7.33951926e-02f, 4.45151515e-03f,
  8.49019662e-02f, 9.38592758e-03f, 1.74967963e-02f, 8.94778222e-02f, 2.42492817e-02f, 9.95528474e-02f, -1.97384451e-02f, -6.45368919e-02f, -3.76941785e-02f, -1.43998330e-02f,
  -1.83812469e-01f, 2.00266570e-01f, -1.70242880e-02f, -8.54328573e-02f, 3.98811996e-02f, 3.64815295e-02f, 1.71126183e-02f, 7.66975526e-03f, 1.05631404e-01f, 5.66402860e-02f,
  -1.88423451e-02f, -3.01608685e-02f, -5.37325069e-02f, -4.06673178e-02f, -6.16441667e-02f, 5.46585955e-03f, -8.70697051e-02f, -8.72218888e-03f, 1.49552710e-02f, -8.05948600e-02f,
  -5.12727164e-02f, -1.18722804e-01f, -2.03385711e-01f, -1.08120754e-01f, -7.23140538e-02f, -5.13086766e-02f, -1.99007228e-01f, -1.61984757e-01f, -1.94106191e-01f, -4.65731472e-01f,
  -8.05184525e-03f, 1.51624516e-01f, 1.58914790e-01f, -1.93422139e-01f, -3.12051512e-02f, -1.44291054e-02f, 1.14406779e-01f, -1.32291317e-01f, -9.03508663e-02f, 1.63132459e-01f,
  3.19729656e-01f, 4.83163446e-02f, 3.81452776e-02f, -6.15615062e-02f, -1.28510714e-01f, 4.62008342e-02f, -1.97474569e-01f, -2.69386590e-01f, -1.65965721e-01f, -3.07758078e-02f,
  -1.00700893e-01f, -8.66310298e-02f, -1.53870836e-01f, -1.85254395e-01f, -6.28039101e-03f, -9.95459594e-03f, 9.98960808e-02f, 7.31797293e-02f, 1.51991636e-01f, 1.15422510e-01f,
  3.66146326e-01f, 2.70234197e-01f, -1.79385141e-01f, -8.48567933e-02f, 1.39068693e-01f, 4.89012785e-02f, -4.31008544e-03f, -7.16172606e-02f, -6.47606477e-02f, -1.27735600e-01f,
  5.13899587e-02f, 4.43553105e-02f, 1.26482425e-02f, -2.19420027e-02f, -2.91590709e-02f, -2.31533721e-02f, -5.78289758e-03f, -9.25162062e-02f, -1.29862621e-01f, 1.69904739e-01f,
  1.05675338e-02f, 1.15065407e-02f, -1.46182044e-03f, -7.14828670e-02f, 5.21211745e-03f, -7.34730363e-02f, 6.86219335e-02f, 1.91968419e-02f, 8.10134262e-02f, -6.57595834e-03f,
  -3.49998870e-03f, 3.55972573e-02f, 3.70560624e-02f, 7.78745562e-02f, -1.98026989e-02f, 4.83159348e-02f, 1.43221878e-02f, -8.25192872e-03f, -3.48068140e-02f, -1.08413147e-02f,
  -2.49672458e-02f, 3.22386548e-02f, -6.62492514e-02f, -2.53234114e-02f, -4.42385226e-02f, -7.67487660e-02f, -1.73905045e-02f, -6.58517927e-02f, 5.48410974e-03f, -6.08489364e-02f,
  -6.97393715e-03f, -1.51444394e-02f, -6.23881742e-02f, -2.72948220e-02f, 5.23354821e-02f, 1.01322785e-01f, -1.02955267e-01f, 2.43773330e-02f, 1.35943396e-02f, 1.50718139e-02f,
  -1.02270633e-01f, -2.84099746e-02f, 1.18077524e-01f, -2.62899119e-02f, -1.20543735e-02f, 3.41360345e-02f, 7.25500360e-02f, -1.11839853e-01f, -7.87156913e-03f, -1.69590116e-02f,
  7.79323503e-02f, -1.24610975e-01f, 3.15210856e-02f, 2.29006819e-02f, -8.05028006e-02f, -1.02849500e-02f, -5.53421006e-02f, 6.20383918e-02f, -8.72661173e-03f, 9.37325880e-02f,
  -1.37403458e-01f, -6.58504069e-02f, -4.07436490e-02f, -1.00040227e-01f, 5.00182733e-02f, -3.15036550e-02f, 1.43727005e-01f, 2.00786088e-02f, -9.39500555e-02f, -1.12891458e-01f,
  4.35812056e-01f, -2.23462135e-01f, -2.69583846e-03f, 9.74152833e-02f, -1.70015961e-01f, -1.01369843e-01f, -3.61701578e-01f, -7.00446963e-02f, 1.89329922e-01f, 2.98677236e-02f,
  -1.04513317e-01f, -7.58779943e-02f, -1.02897897e-01f, -6.01554438e-02f, -6.16532415e-02f, -1.75145969e-01f, 4.45048399e-02f, 1.02425776e-01f, 1.62536353e-01f, -2.27822717e-02f,
  -8.98100585e-02f, 1.13371693e-01f, 2.79369950e-01f, 1.70503750e-01f, 3.09031247e-03f, 4.19389270e-02f, -1.93982944e-02f, 2.11301781e-02f, -1.57074541e-01f, -1.18865661e-01f,
  -1.21346042e-01f, -6.04279190e-02f, 5.28664477e-02f, 8.89514294e-03f, 1.23099540e-03f, 1.16218776e-01f, -2.49173958e-02f, 1.27685145e-01f, -4.21868376e-02f, 2.08548959e-02f,
  -1.36472601e-02f, -1.70628559e-02f, -3.88984494e-02f, 2.68302020e-02f, 5.60100516e-03f, -2.34356988e-02f, 1.06421895e-01f, 7.40266591e-02f, 5.78622818e-02f, -7.77055770e-02f,
  -8.91762078e-02f, -1.01392098e-01f, -2.28012931e-02f, -6.47080243e-02f, -8.13983157e-02f, -3.89339663e-02f, 1.09547023e-02f, 7.38715008e-03f, 9.59791690e-02f, 8.23601335e-02f,
  2.95417812e-02f, 4.45887037e-02f, -7.94838706e-04f, -2.54555903e-02f, -6.05513677e-02f, 2.46175323e-02f, 8.63732584e-03f, -1.62053667e-02f, -4.08902317e-02f, 4.95846160e-02f,
  -3.22696865e-02f, 2.40340717e-02f, -2.36681532e-02f, 5.86491488e-02f, -4.70627695e-02f, 2.71064546e-02f, 2.59940922e-02f, -3.42781767e-02f, -5.47183417e-02f, 4.84280586e-02f,
  -2.84208022e-02f, -3.45312580e-02f, 1.01012476e-01f, -6.11616597e-02f, 3.55260968e-02f, 2.63770185e-02f, -5.45393005e-02f, -1.14825048e-01f, 1.82166528e-02f, 2.05348022e-02f,
  1.86244518e-01f, -7.59309232e-02f, -2.27169320e-03f, -4.90000136e-02f, 8.13471451e-02f, -1.67830866e-02f, -1.13178626e-01f, -6.25288254e-03f, -1.80456508e-02f, -5.58901541e-02f,
  -8.21519718e-02f, -5.06671481e-02f, -7.21487552e-02f, -4.33032587e-03f, 7.91079700e-02f, -4.56941128e-02f, -3.87641266e-02f, -3.63840424e-02f, 8.31109751e-03f, 6.09595999e-02f,
  5.79854101e-02f, 1.59138128e-01f, -1.05983915e-03f, 3.92410532e-02f, -2.07575541e-02f, 2.20663734e-02f, -6.84144273e-02f, 9.28397700e-02f, -3.18990052e-02f, 1.29537687e-01f,
  -1.08313374e-01f, -3.91382910e-02f, -2.61095800e-02f, -1.61602974e-01f, 1.14549240e-02f, 2.05094159e-01f, 3.49426806e-01f, 2.78576642e-01f, 9.77215543e-03f, -9.10014734e-02f,
  9.81433131e-03f, -1.29066780e-01f, -7.94873461e-02f, 3.58028784e-02f, 2.44829386e-01f, 8.35817829e-02f, -7.10574538e-02f, 5.87905431e-03f, 7.31446147e-02f, 1.71825096e-01f,
  -2.30805222e-02f, -1.28184091e-02f, -4.38368134e-02f, 9.99494642e-02f, -8.12472925e-02f, -1.62518099e-01f, -1.85554534e-01f, -4.74286787e-02f, 1.77770443e-02f, -2.76669145e-01f,
  -5.51662087e-01f, -2.29923818e-02f, 4.28890511e-02f, -6.43097684e-02f, -6.12202622e-02f, -1.94010381e-02f, -5.16071692e-02f, -1.47175789e-01f, -1.13684058e-01f, -7.70582780e-02f,
  -2.42447723e-02f, -5.99331514e-04f, -3.96376513e-02f, -3.05718407e-02f, 5.89591563e-02f, -3.42828520e-02f, -1.34385927e-02f, 6.35146275e-02f, 3.69176976e-02f, -2.80173719e-02f,
  -5.30550256e-02f, -5.16419299e-02f, -1.63209029e-02f, 1.82209834e-02f, 8.04971829e-02f, 5.94345443e-02f, 7.59111568e-02f, 5.10645173e-02f, 1.89885259e-01f, -1.79082349e-01f,
  7.07907379e-02f, -6.12735748e-02f, 2.10889690e-02f, -1.47445907e-03f, -9.72119917e-04f, 9.62645933e-03f, -1.68902297e-02f, -5.20917326e-02f, 6.11554049e-02f, -6.17267825e-02f,
  6.70713633e-02f, 3.26615050e-02f, -3.06098685e-02f, -4.56109941e-02f, -1.15349859e-01f, 7.53891142e-03f, 4.01603654e-02f, 3.38402092e-02f, -3.79654281e-02f, 2.28052866e-02f,
  2.10726541e-02f, 1.57713629e-02f, -5.71204871e-02f, 6.90211589e-03f, -4.35066829e-03f, 2.91746203e-02f, -5.26928483e-03f, 2.43607108e-02f, -3.94188985e-02f, 1.46123003e-02f,
  -2.06899703e-01f, 2.64754266e-01f, -2.46991813e-01f, 1.00558311e-01f, -6.10942766e-02f, 5.88010438e-02f, -2.05138382e-02f, 1.64585616e-02f, -1.30549446e-03f, 1.30523425e-02f,
  4.33653668e-02f, 1.51805766e-02f, 1.75897125e-02f, 4.54106182e-02f, 1.83313296e-06f, 3.46477292e-02f, -6.51918119e-03f, 3.01134493e-02f, 7.14123547e-02f, -4.28502262e-02f,
  -3.33771557e-02f, 5.06720468e-02f, -1.26546428e-01f, -5.31508811e-02f, -3.10428478e-02f, 1.17966644e-02f, -4.63574193e-02f, -3.48831378e-02f, 1.39173463e-01f, -9.68101621e-02f,
  -5.27640522e-01f, -3.11919779e-01f, -4.05662544e-02f, -8.07466954e-02f, 6.63791895e-02f, -1.46918446e-02f, -1.17310129e-01f, -7.29226694e-02f, 9.85422283e-02f, -1.97427183e-01f,
  5.01069836e-02f, 1.27293721e-01f, 2.70538609e-02f, 1.29982665e-01f, -4.70562465e-02f, -1.79349467e-01f, -7.99853653e-02f, -5.02880430e-03f, 1.41313687e-01f, 1.73559472e-01f,
  6.87709227e-02f, -1.58796355e-01f, -7.50109032e-02f, -5.71983419e-02f, 3.35370051e-03f, 2.02243164e-01f, -6.51160106e-02f, -1.59489792e-02f, 3.27368043e-02f, -6.58852831e-02f,
  7.56786615e-02f, -2.66433358e-01f, 7.53845498e-02f, 2.13577989e-02f, 4.55425419e-02f, -7.83572197e-02f, -8.92208368e-02f, -1.80833123e-03f, 3.02418359e-02f, -1.19856305e-01f,
  8.39303955e-02f, 4.93146072e-05f, 8.44626799e-02f, 4.71372679e-02f, -1.09967003e-02f, -1.30414158e-01f, -8.48168954e-02f, -1.78214401e-01f, -1.34803250e-01f, 4.98311296e-02f,
  -3.13105285e-02f, 2.48771459e-02f, -1.49722412e-01f, 2.13283044e-03f, -3.47105716e-03f, 5.24326339e-02f, 4.08443920e-02f, -6.02362156e-02f, -1.67500183e-01f, -2.01562941e-01f,
  2.07559355e-02f, 3.50644067e-02f, -2.19871756e-02f, -1.47618011e-01f, 2.62241662e-02f, -3.29921651e-03f, 2.09352076e-02f, 2.85085421e-02f, -2.58874986e-02f, -2.88262293e-02f,
  3.74708138e-02f, 4.80037108e-02f, 3.24721336e-02f, -1.42022386e-01f, 9.11441818e-02f, -4.56045009e-02f, 7.74709508e-02f, -1.54157719e-02f, 1.17817046e-02f, 1.93376057e-02f,
  -2.63515562e-02f, 7.96393678e-02f, 8.41973256e-03f, 5.95109537e-02f, 1.86033268e-02f, 1.76522080e-02f, 1.12355268e-02f, 1.73880439e-02f, -1.06896818e-01f, -1.21390827e-01f,
  -1.17447980e-01f, 5.52000739e-02f, -6.20771572e-02f, -1.93925668e-02f, 2.52974369e-02f, 1.20615259e-01f, 9.82926227e-03f, 5.93345165e-02f, -2.15385705e-02f, 2.02126764e-02f,
  -4.86783311e-02f, -8.98253843e-02f, -6.81582168e-02f, 3.82144749e-02f, 4.23947982e-02f, -4.56944928e-02f, -3.11752576e-02f, -2.36574169e-02f, 8.10141563e-02f, -1.59652736e-02f,
  -7.65480325e-02f, -6.02861643e-02f, -1.04976572e-01f, -2.26659421e-02f, -4.36242633e-02f, -3.89102474e-02f, -1.87639110e-02f, 4.17983234e-02f, -5.68794459e-02f, -2.50211358e-01f,
  -2.79273152e-01f, -7.41131604e-02f, 2.13572443e-01f, -2.80179888e-01f, 1.90342873e-01f, 4.41056997e-01f, 5.33332646e-01f, 1.86339989e-01f, -1.28023431e-01f, 2.87704617e-02f,
  4.70941067e-02f, -1.87810704e-01f, -8.25254321e-02f, -1.35922004e-02f, 4.82514091e-02f, 5.91057874e-02f, 3.50167044e-02f, 6.32924139e-02f, 5.27275205e-02f, 5.84779195e-02f,
  2.38356995e-03f, -1.22615144e-01f, -1.65882125e-01f, -1.20784752e-01f, -8.18749145e-02f, -1.23519540e-01f, -8.28133672e-02f, 2.09523179e-02f, 8.97482410e-02f, -2.23997131e-01f,
  4.05144133e-02f, 1.13771841e-01f, 8.97104070e-02f, -1.14356754e-02f, 1.32703353e-02f, -9.31631178e-02f, 3.54994126e-02f, -2.42710654e-02f, 4.90339883e-02f, -4.49650735e-02f,
  -3.66322249e-02f, 1.86572727e-02f, 5.98225258e-02f, 1.55558558e-02f, -3.65835764e-02f, 6.83614016e-02f, -7.86703825e-02f, -3.12371179e-02f, -1.03803702e-01f, -2.18887366e-02f,
  1.69540439e-02f, 8.39588493e-02f, 2.01037481e-01f, 1.67948857e-01f, 9.27707553e-02f, 3.88149470e-02f, 5.50350361e-02f, 9.17525738e-02f, 6.51401505e-02f, -2.37418428e-01f,
  3.24499607e-02f, -2.60918401e-02f, 3.62457223e-02f, -1.07177123e-02f, -3.97199467e-02f, -7.35576898e-02f, 1.48564568e-02f, -5.18090464e-02f, 3.57124619e-02f, -4.68925498e-02f,
  6.26344755e-02f, -9.59516764e-02f, -2.99872067e-02f, -2.79083978e-02f, -2.03743000e-02f, 4.60965559e-02f, 5.80609180e-02f, -7.13381320e-02f, 2.83188131e-02f, -7.70371780e-03f,
  -3.74104157e-02f, 7.73890167e-02f, -2.19355356e-02f, -2.65802406e-02f, 6.69947043e-02f, -1.94150638e-02f, -4.64083590e-02f, 8.91659502e-03f, 3.53820808e-03f, 6.90097883e-02f,
  -1.63473099e-01f, 1.84323296e-01f, -1.76952615e-01f, -8.33236787e-04f, -2.63517611e-02f, -4.83019464e-02f, -3.70880663e-02f, -2.75450237e-02f, -4.22289409e-02f, 3.67033668e-02f,
  7.57057294e-02f, -3.58834304e-02f, -4.35700938e-02f, -2.32424941e-02f, 4.38691787e-02f, -3.82431895e-02f, -1.68208964e-02f, -4.46657836e-02f, -1.51084848e-02f, -1.76248439e-02f,
  2.09801663e-02f, -5.84341027e-03f, 9.13393218e-03f, 1.13584679e-02f, -4.72647510e-03f, -1.12533905e-02f, 6.89196680e-03f, 2.13509593e-02f, 8.96589234e-02f, -1.39452934e-01f,
  -1.78924024e-01f, -2.20072493e-01f, 1.59217358e-01f, -6.46813735e-02f, 1.42240718e-01f, 2.56952792e-01f, 1.66534320e-01f, 1.19600603e-02f, -1.21064626e-01f, -1.20758288e-01f,
  8.71104449e-02f, 2.87265964e-02f, 3.86548676e-02f, 8.18291306e-02f, -2.65887682e-03f, -1.21457882e-01f, -7.07818866e-02f, 6.07636422e-02f, 2.93856680e-01f, 2.03231797e-01f,
  -1.13828458e-01f, -1.15194097e-01f, -8.88891052e-03f, 1.14886626e-03f, -1.72502145e-01f, 1.32698417e-01f, -1.38202846e-01f, -9.37984735e-02f, 3.79270455e-03f, -3.11480820e-01f,
  2.35992149e-01f, -1.88256606e-01f, 1.38140425e-01f, -1.15879364e-01f, 1.79567952e-02f, -4.19806950e-02f, 6.90536061e-03f, -8.82374346e-02f, 2.33767033e-02f, -8.66363794e-02f,
  2.55294293e-02f, -5.70609942e-02f, -4.94797900e-03f, -1.10067762e-01f, -6.05354235e-02f, -4.87509519e-02f, -6.71489537e-02f, -1.43427089e-01f, -8.93227085e-02f, 3.90974432e-03f,
  -5.98013476e-02f, -1.37232132e-02f, -7.02791885e-02f, -1.79761853e-02f, 4.26150709e-02f, -3.70244868e-03f, 1.05321035e-01f, -6.49604797e-02f, 5.81435375e-02f, -7.20646977e-02f,
  2.07812842e-02f, 4.33752313e-02f, 6.93267956e-02f, -2.52027102e-02f, 1.00663099e-02f, 7.58834258e-02f, -1.66910142e-02f, 6.40522912e-02f, -1.65625929e-03f, 2.77473629e-02f,
  9.52648092e-03f, 5.54909892e-02f, 2.20459681e-02f, 5.96161820e-02f, -3.33790369e-02f, 1.57036427e-02f, 1.58652700e-02f, -1.57504305e-02f, 5.14757819e-04f, -7.81670287e-02f,
  3.01014651e-02f, 1.82537522e-04f, -1.17869526e-02f, 4.50172834e-02f, -5.62201701e-02f, -5.55568486e-02f, 1.99457090e-02f, -3.93351279e-02f, 1.71746034e-02f, -3.99074703e-02f,
  1.54778197e-01f, -6.32118853e-03f, 3.76994759e-02f, -3.75204310e-02f, 4.47689071e-02f, -1.08772047e-01f, 1.04076741e-02f, -2.55688503e-02f, -4.42178175e-02f, 3.05595482e-03f,
  7.52231060e-03f, 3.46596614e-02f, -1.03823468e-01f, 2.80225724e-02f, 9.63965245e-03f, -2.09355932e-02f, -6.17672093e-02f, 2.86381487e-02f, -4.12808135e-02f, 5.88406529e-03f,
  -6.37398437e-02f, 3.93542834e-02f, 1.92770317e-01f, 1.96312204e-01f, -4.72711921e-02f, 1.36478558e-01f, 1.91204250e-01f, 1.32350177e-01f, 1.68923229e-01f, 1.69623017e-01f,
  -5.55076659e-01f, 1.11507274e-01f, -1.06063195e-01f, 8.82845372e-03f, 3.01267177e-01f, -2.38671899e-02f, -6.07966967e-02f, -1.04798771e-01f, 9.18324888e-02f, 1.62485875e-02f,
  1.67117760e-01f, 1.11937456e-01f, 2.43524704e-02f, -2.50457879e-02f, -1.33843467e-01f, -1.39152378e-01f, 2.35301349e-02f, -1.93037733e-01f, -1.93523079e-01f, -9.23434496e-02f,
  5.77524230e-02f, 1.34005984e-02f, -1.40071109e-01f, -4.59270291e-02f, 1.34333462e-01f, 8.85524079e-02f, 2.40475982e-02f, 1.29908696e-01f, 2.33662780e-02f, 1.83569491e-01f,
  -1.42557338e-01f, 1.12761874e-02f, -3.61542287e-03f, 4.76630256e-02f, 1.85077190e-01f, -3.13288942e-02f, -5.20203970e-02f, 3.68759334e-02f, -2.76234336e-02f, 5.14671318e-02f,
  1.07021026e-01f, 6.53558820e-02f, -9.45165753e-02f, 6.58297092e-02f, 1.74607243e-02f, 1.27270864e-02f, 4.84106541e-02f, -1.01652995e-01f, -4.97762673e-02f, 5.62525727e-02f,
  1.36767298e-01f, 1.63352057e-01f, -2.24228278e-02f, 2.23855767e-02f, 2.54961699e-02f, 1.18668757e-01f, 1.12506442e-01f, 1.12299994e-01f, 3.34406048e-02f, -5.93491085e-02f,
  -6.26016930e-02f, 4.25518304e-02f, 8.26138854e-02f, -2.69879792e-02f, -1.49907125e-02f, 3.38214152e-02f, 2.11330019e-02f, 4.37840149e-02f, 2.60200519e-02f, -2.84278113e-02f,
  2.76602581e-02f, 1.04695968e-02f, -2.47620512e-02f, 1.09422943e-02f, 3.40908170e-02f, 8.60843807e-02f, -3.16436477e-02f, 3.12686861e-02f, 1.34186577e-02f, -2.15517767e-02f,
  -7.95937777e-02f, -3.29949753e-03f, 3.50311361e-02f, -6.55648261e-02f, 9.67867523e-02f, -9.33254883e-03f, 1.89446881e-02f, 4.01468687e-02f, 4.46525887e-02f, 2.38338243e-02f,
  -1.73402011e-01f, 9.83071551e-02f, -8.26624781e-02f, -1.07221417e-01f, -2.02460047e-02f, 4.36449759e-02f, 4.23057303e-02f, -4.61795256e-02f, -1.89170223e-02f, -9.14903507e-02f,
  -2.23390646e-02f, -1.70417085e-01f, -8.42172746e-03f, -5.61600691e-03f, -4.53185886e-02f, -5.58936447e-02f, 3.83123234e-02f, -9.15112868e-02f, -7.10271820e-02f, -8.79680831e-03f,
  -2.92058568e-02f, -1.34289071e-01f, -1.50316998e-01f, -3.08132730e-02f, -2.59668753e-02f, -1.92647576e-01f, -8.38083401e-02f, -1.45503893e-01f, -1.37975246e-01f, -3.20066661e-01f,
  -2.47253343e-01f, -1.84514984e-01f, 1.23352520e-01f, 3.77009027e-02f, 1.52511910e-01f, -9.98535827e-02f, -1.77184895e-01f, -2.43153766e-01f, -1.36897951e-01f, -1.28061965e-01f,
  -5.36729023e-02f, 9.04924050e-02f, -4.25102971e-02f, 3.38439867e-02f, -1.59413695e-01f, -1.01237902e-02f, 4.57707904e-02f, 1.17125697e-01f, 1.29753664e-01f, 5.82470233e-03f,
  1.35792866e-01f, 2.84932911e-01f, 1.25307307e-01f, 7.17236251e-02f, 1.84352040e-01f, 3.58330995e-01f, 2.00164810e-01f, 2.09122136e-01f, 3.09909761e-01f, 5.48502266e-01f,
  1.54155418e-01f, -1.67874590e-01f, -1.39187705e-02f, -1.54674668e-02f, 9.71878096e-02f, -2.59454343e-02f, -2.05249004e-02f, -3.63412835e-02f, -1.13440104e-01f, -5.57513488e-03f,
  2.87676230e-02f, -2.91973632e-02f, 1.42362760e-02f, 9.71911103e-02f, 2.70498954e-02f, 1.07617117e-02f, -1.31833315e-01f, -1.28314868e-02f, -5.84916435e-02f, -3.31540853e-02f,
  1.53555628e-02f, 5.63643761e-02f, -2.48514637e-02f, -4.60020415e-02f, -1.50431588e-01f, 7.76280165e-02f, -1.07048236e-01f, 1.30236402e-01f, 1.22420862e-01f, 7.12829456e-02f,
  7.00315237e-02f, 2.07465477e-02f, 1.52128246e-02f, 4.05916804e-03f, 2.52137370e-02f, -1.26277450e-02f, 7.84214064e-02f, 4.07515317e-02f, 4.46906686e-02f, -2.32046936e-02f,
  -4.84492481e-02f, 1.22402050e-02f, 2.87167281e-02f, -7.45436922e-02f, -7.22225085e-02f, 2.34067980e-02f, 2.04253080e-03f, -2.19710357e-03f, 4.84427735e-02f, 1.09856147e-02f,
  2.37176362e-02f, -6.33760989e-02f, 1.25635660e-03f, -4.00374867e-02f, -6.39015511e-02f, -4.60208617e-02f, 1.80456154e-02f, -2.59122048e-02f, -6.65282831e-02f, -6.71226084e-02f,
  -7.82548264e-02f, -7.52182826e-02f, -9.88493487e-03f, -3.60131972e-02f, 3.74600403e-02f, -8.85491893e-02f, -2.93965638e-03f, -1.04200300e-02f, 1.39701767e-02f, -4.91098799e-02f,
  -4.20315899e-02f, -3.13842334e-02f, 3.03844456e-03f, 4.39274218e-03f, 3.13628875e-02f, -9.75404307e-02f, -2.84679141e-02f, 8.11765343e-02f, 3.66151929e-02f, -1.49099687e-02f,
  -1.45161748e-01f, -4.99751009e-02f, -1.80411041e-02f, -6.40064999e-02f, 8.69543999e-02f, 7.57771581e-02f, 2.54477505e-02f, 6.44939616e-02f, 6.74766675e-02f, -6.29471540e-02f,
  1.41508445e-01f, 5.76938726e-02f, -6.36714280e-01f, -4.06070352e-02f, -1.78913891e-01f, -1.53974995e-01f, -1.49080127e-01f, 3.66499685e-02f, 1.03147492e-01f, -5.11424504e-02f,
  1.41718805e-01f, 2.96961844e-01f, 5.19725122e-02f, 5.84032759e-02f, -5.04681394e-02f, -1.58645421e-01f, -3.11736792e-01f, -2.51184523e-01f, -1.30398601e-01f, 1.38223171e-01f,
  1.15865782e-01f, 8.09645131e-02f, 4.96997833e-02f, 3.95516306e-02f, -2.32588518e-02f, 1.47625934e-02f, -1.60023332e-01f, -3.52940597e-02f, 7.93986022e-03f, -1.99232623e-01f,
  -1.65013358e-01f, -9.05208364e-02f, -1.06942326e-01f, 1.26992807e-01f, -1.32192373e-01f, 2.33201757e-02f, -4.56464477e-02f, -2.39579398e-02f, 2.24195365e-02f, 2.09627338e-02f,
  -2.04429193e-03f, 6.49743825e-02f, -9.44788679e-02f, 1.00651365e-02f, 7.78899016e-03f, 2.03795377e-02f, 1.95232071e-02f, -1.26934096e-01f, -9.15717240e-03f, -7.74422437e-02f,
  3.81277688e-02f, 1.43793905e-02f, -5.21209911e-02f, 1.23171490e-02f, -8.63680337e-03f, 1.68932695e-02f, 2.36549526e-02f, -3.76993939e-02f, -2.27891859e-02f, 1.06544517e-01f,
  1.54711469e-03f, -4.64027636e-02f, -4.29779757e-03f, 2.90800277e-02f, 9.98138338e-02f, -2.24900525e-03f, -4.56235111e-02f, -1.23745725e-02f, -6.65297499e-03f, 7.73185268e-02f,
  -8.66339635e-03f, -5.92346899e-02f, -4.00361083e-02f, 7.36645889e-03f, -7.33942958e-03f, -3.98220047e-02f, 2.90655997e-02f, 2.62446478e-02f, 9.42650959e-02f, 3.70565951e-02f,
  8.41419771e-02f, -4.41897325e-02f, -9.12611466e-03f, 5.66437654e-03f, 4.46606224e-04f, -7.38411173e-02f, -1.38234962e-02f, 5.56961596e-02f, -5.34903677e-03f, 2.79434714e-02f,
  1.57124206e-01f, -1.75307263e-02f, 4.05955315e-02f, 4.74460982e-02f, 5.65079413e-03f, 3.21132243e-02f, 1.39384549e-02f, 2.44262572e-02f, -3.82519402e-02f, -5.49135096e-02f,
  -7.98911043e-03f, 5.20156249e-02f, 1.29693588e-02f, -3.50790657e-03f, 1.80883426e-02f, 2.09530983e-02f, 8.35158527e-02f, -8.43673870e-02f, 5.78307174e-02f, -1.45841744e-02f,
  8.95542093e-03f, 2.62208134e-02f, 8.91668722e-02f, -1.48450006e-02f, 7.71167800e-02f, -2.97770109e-02f, 9.34456661e-03f, 1.51573494e-02f, 3.05651501e-02f, 4.17394787e-02f,
  -3.91872883e-01f, 2.44455040e-02f, -3.36108476e-01f, -3.96544904e-01f, -3.71947110e-01f, -6.80465698e-02f, 2.91073862e-02f, 1.26285076e-01f, -6.85542226e-02f, -1.42130539e-01f,
  -1.47768870e-01f, -9.71799642e-02f, -5.94801567e-02f, 2.39041075e-02f, 1.37938157e-01f, -6.04286604e-02f, -1.22562155e-01f, -8.30738917e-02f, -6.53813928e-02f, -4.47909832e-02f,
  -8.44956860e-02f, -2.53996074e-01f, -1.05995186e-01f, -7.52687603e-02f, -7.15453774e-02f, -5.35341799e-02f, -1.34664565e-01f, -1.14119843e-01f, -2.41344310e-02f, -2.17626035e-01f,
  -9.71901044e-02f, -2.00496197e-01f, 2.63007358e-02f, -1.21047594e-01f, -6.55220002e-02f, 8.73912126e-02f, 6.40404373e-02f, 7.49649573e-03f, 2.44898461e-02f, 5.25648035e-02f,
  -1.32515997e-01f, -5.86805344e-02f, -1.08887609e-02f, -7.84355476e-02f, 2.60138195e-02f, 3.67175043e-03f, 8.39712769e-02f, -2.28949618e-02f, 4.99155484e-02f, -3.64885703e-02f,
  -1.58219665e-01f, -1.20124355e-01f, -6.97083622e-02f, 9.55185071e-02f, 3.77732292e-02f, -4.82875928e-02f, 6.59138560e-02f, 5.22224233e-02f, -4.28275168e-02f, 5.55619076e-02f,
  1.87483877e-02f, 7.18162805e-02f, 2.88774334e-02f, -6.13746990e-04f, -7.59639498e-03f, 9.97237489e-02f, -1.35343615e-02f, 4.02418226e-02f, 2.29650270e-02f, 5.57244159e-02f,
  1.31050032e-02f, -7.08834752e-02f, 5.57043590e-02f, -5.36123775e-02f, 9.01228283e-03f, -8.16185251e-02f, 1.83506645e-02f, 4.51077614e-03f, 3.37512195e-02f, -1.61888096e-02f,
  5.80098433e-03f, -2.24516839e-02f, -3.29768993e-02f, 5.29210046e-02f, -8.75028688e-03f, -1.30822966e-02f, -5.92576526e-03f, -1.28184445e-02f, 3.23197804e-04f, -1.11259021e-01f,
  1.28047466e-01f, -1.34615034e-01f, -7.32512819e-03f, 7.22024590e-02f, 2.45112628e-02f, 5.20355627e-02f, -9.04160142e-02f, 1.21820621e-01f, -4.58060391e-02f, -1.48331672e-02f,
  -1.17247412e-02f, 5.75714037e-02f, -6.31049350e-02f, 2.02241186e-02f, -3.27405632e-02f, 1.09323021e-02f, -2.18040887e-02f, -1.01193063e-01f, 5.01962788e-02f, 4.84785698e-02f,
  5.83983362e-02f, 1.13569193e-01f, 8.99574682e-02f, 1.58480614e-01f, 1.02691323e-01f, -4.76831645e-02f, 1.02494150e-01f, 8.09763595e-02f, 4.89989184e-02f, 2.25697815e-01f,
  1.49135485e-01f, -1.31582901e-01f, -3.15028548e-01f, 1.44080430e-01f, -7.17756525e-02f, -1.65938601e-01f, -4.17567790e-01f, 2.54601147e-02f, 1.30652294e-01f, -2.09794998e-01f,
  3.49688642e-02f, 3.56844157e-01f, 2.90231645e-01f, 2.24367902e-01f, 6.62289858e-02f, -3.44523698e-01f, -2.50730783e-01f, -2.34600194e-02f, 2.59688556e-01f, 5.58647551e-02f,
  1.52547404e-01f, 1.58064127e-01f, 1.86552092e-01f, 1.38213024e-01f, -1.14573836e-01f, 7.49835297e-02f, -1.94511294e-01f, -8.19757730e-02f, -3.13262381e-02f, -1.03455096e-01f,
  -1.28514662e-01f, -7.84132108e-02f, 1.51635468e-01f, 1.54947206e-01f, -4.47739325e-02f, -4.78968956e-02f, 2.92590447e-03f, -5.80207743e-02f, 8.22177455e-02f, 6.43833540e-03f,
  4.96995598e-02f, -4.26592305e-02f, 7.29765072e-02f, 1.76217873e-02f, -2.27357838e-02f, 3.99386361e-02f, -1.90100465e-02f, 1.52113391e-02f, -6.10018745e-02f, -1.40399233e-01f,
  7.50393718e-02f, -1.31522357e-01f, -1.67400211e-01f, -4.41495376e-03f, -4.14429791e-02f, 1.58007786e-01f, -1.20566897e-01f, 6.75670430e-02f, 6.59534559e-02f, -8.17131400e-02f,
  9.07595158e-02f, -4.75842133e-02f, 1.37940384e-02f, -1.58753768e-02f, 3.59413251e-02f, -3.40557694e-02f, 2.38082502e-02f, -6.47247583e-03f, 1.92086622e-02f, -6.24192432e-02f,
  9.82672255e-03f, -3.35244276e-02f, 2.28117350e-02f, -3.54253799e-02f, 5.07882088e-02f, -4.73471135e-02f, -5.31375259e-02f, 4.65758443e-02f, 2.46089268e-02f, -7.78255798e-03f,
  8.36068094e-02f, -3.26077454e-02f, -2.57239193e-02f, -7.44245527e-03f, -1.85182516e-03f, -1.80647876e-02f, -8.29094928e-03f, 4.17404473e-02f, 4.97802496e-02f, 2.74503287e-02f,
  1.54973075e-01f, 1.23060971e-01f, -2.41395906e-02f, 2.85315979e-02f, -7.08075985e-02f, 5.27840927e-02f, 3.38426270e-02f, 6.23515667e-03f, 9.72994789e-02f, -2.56254012e-03f,
  4.20434726e-03f, 7.60080516e-02f, 2.99759284e-02f, -2.42062341e-02f, 2.18378343e-02f, -4.56364043e-02f, -1.16080036e-02f, 5.68298511e-02f, 3.06767086e-03f, 1.79110244e-02f,
  4.08159159e-02f, -7.77921453e-02f, 1.41197303e-02f, 1.75798927e-02f, 6.95699081e-02f, 3.10407672e-02f, -2.18188111e-03f, -6.75462745e-03f, -5.34315780e-02f, -1.33351982e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.10679317e-01f, -1.64207384e-01f, 1.77310072e-02f, -3.65122586e-01f, -1.52166039e-01f, -1.20586403e-01f, -2.77220249e-01f, -1.86978832e-01f, -1.61106259e-01f, -3.49846870e-01f,
  -1.32902279e-01f, -2.15584673e-02f, 8.07843879e-02f, 1.09648928e-01f, 6.32681474e-02f, -1.21344738e-01f, -1.02298893e-01f, 1.37159795e-01f, 2.90200979e-01f, 1.19729824e-01f,
  -1.32605031e-01f, -6.37518987e-02f, 8.31343830e-02f, 8.10249224e-02f, -2.75113940e-01f, 2.59461645e-02f, -7.77465105e-02f, -5.31167649e-02f, 1.16021417e-01f, -2.94892281e-01f,
  -1.40624240e-01f, -1.02377683e-01f, 8.14535245e-02f, 7.36587867e-02f, -8.40862170e-02f, 3.14013660e-02f, -5.91433432e-04f, -1.80205349e-02f, 5.55050299e-02f, -7.63677657e-02f,
  -6.29487634e-02f, 4.33933698e-02f, -3.90626583e-03f, 2.54671108e-02f, -7.75409490e-02f, -2.76444722e-02f, -4.79970971e-04f, 1.18027188e-01f, 1.39735028e-01f, -1.50846019e-02f,
  3.83517966e-02f, 1.02347480e-02f, 1.09484464e-01f, 4.46327068e-02f, 2.58083828e-02f, 9.49313045e-02f, 4.25981032e-03f, -3.95621080e-03f, 1.65515959e-01f, -1.18742384e-01f,
  1.79755397e-03f, -9.89889819e-03f, 2.37642992e-02f, 2.14322321e-02f, -4.18883748e-02f, 6.78884685e-02f, 1.33172683e-02f, -4.32120711e-02f, -3.90869491e-02f, -8.79172608e-03f,
  -2.62645688e-02f, 2.86479816e-02f, 6.77584410e-02f, -3.54191102e-02f, -2.11153254e-02f, -2.26237401e-02f, 1.74713284e-02f, -6.32046759e-02f, -1.18356608e-02f, 4.51939143e-02f,
  7.84735661e-03f, 8.59613642e-02f, -5.55312186e-02f, 9.14271921e-03f, 5.22506610e-02f, -6.70104520e-03f, 2.74418779e-02f, 1.26810849e-03f, -6.41868934e-02f, 7.06919581e-02f,
  -2.22548664e-01f, 3.30768555e-01f, -1.34683877e-01f, -1.95662398e-02f, -2.93254312e-02f, -1.75016839e-02f, -1.19707592e-01f, -3.24855861e-03f, -2.73672771e-02f, -9.57080349e-02f,
  4.36863303e-02f, -9.03174281e-02f, -2.99527496e-02f, 4.66932394e-02f, -1.33176269e-02f, 3.71789895e-02f, -1.67537481e-02f, 4.77083363e-02f, 1.51073411e-01f, -7.84408301e-03f,
  3.93855423e-02f, -9.92119778e-03f, -1.23079211e-01f, 4.30784114e-02f, -3.89417596e-02f, 4.49070893e-02f, -6.24720082e-02f, -6.50945306e-02f, 1.49151713e-01f, -2.35324964e-01f,
  3.26599628e-01f, -7.83343688e-02f, 1.74399659e-01f, 1.37215927e-01f, 1.54584274e-01f, 1.70624688e-01f, 2.29327440e-01f, 1.32368103e-01f, 3.36792581e-02f, 1.41128421e-01f,
  -2.50978153e-02f, 8.09086263e-02f, 6.87196180e-02f, -5.48975319e-02f, 7.17320740e-02f, -6.82895035e-02f, -1.08738042e-01f, 5.56113087e-02f, 1.48905650e-01f, 1.42304718e-01f,
  -1.28811300e-02f, -2.22240612e-02f, -1.00507610e-01f, -7.52257258e-02f, -8.49158093e-02f, 8.40837285e-02f, -9.47792083e-02f, -9.57357064e-02f, 2.40393896e-02f, -1.85923308e-01f,
  -7.94207752e-02f, -1.14901895e-02f, -3.73701267e-02f, -3.14368457e-02f, 1.29655395e-02f, 4.58689183e-02f, -1.53793646e-02f, -7.15630278e-02f, -2.43334509e-02f, 4.80568921e-03f,
  -6.59134686e-02f, 6.10012980e-03f, 5.73646054e-02f, -1.83578804e-02f, 2.37868335e-02f, -3.12171923e-03f, -4.46149632e-02f, -6.45616949e-02f, 4.92460094e-02f, 5.88734858e-02f,
  -1.72616523e-02f, -7.07008094e-02f, 2.65642069e-02f, 1.21306088e-02f, 3.47266756e-02f, 7.19133392e-02f, 3.70927416e-02f, -3.23257446e-02f, 4.53067049e-02f, -6.68507293e-02f,
  -3.55388373e-02f, 2.68645845e-02f, -1.07249524e-02f, -6.37181848e-02f, 6.75498620e-02f, -5.00348732e-02f, 7.17888549e-02f, -4.98470431e-03f, -4.46125083e-02f, 1.83126107e-02f,
  2.52778549e-02f, 2.44285949e-02f, 1.10270195e-01f, 4.36250865e-03f, -2.78182402e-02f, -3.51985358e-02f, 6.79567307e-02f, -6.22841856e-03f, 7.47315027e-03f, 4.28804308e-02f,
  1.37783989e-01f, -4.02022861e-02f, -2.42983475e-02f, -2.26371996e-02f, -2.45031044e-02f, 3.75562161e-02f, 2.34843045e-02f, 9.43822488e-02f, 6.12349845e-02f, -6.51444271e-02f,
  -1.25550434e-01f, 6.62643537e-02f, 3.32157798e-02f, 3.32523957e-02f, -7.76159391e-02f, -1.05519824e-01f, -2.75627542e-02f, -1.03670247e-01f, 1.74063463e-02f, -1.38159655e-02f,
  -4.17050980e-02f, -4.45956066e-02f, -6.30566180e-02f, -3.59186605e-02f, 5.08246012e-02f, 6.07064143e-02f, -1.53387651e-01f, -4.51772846e-02f, 9.37109347e-03f, -1.38328537e-01f,
  -3.79878916e-02f, 6.83009326e-02f, 8.39268491e-02f, 6.35204241e-02f, -1.01645932e-01f, 1.96042042e-02f, -6.34072721e-02f, -4.86453101e-02f, 1.42204508e-01f, 4.30613719e-02f,
  1.39232188e-01f, -1.75944254e-01f, -1.95207745e-01f, 3.22264701e-01f, 1.10020988e-01f, -4.56933454e-02f, -2.38443047e-01f, 3.58614139e-02f, 2.09319517e-01f, -7.78733492e-02f,
  8.31402652e-03f, 1.46981895e-01f, -2.62414832e-02f, -6.45130575e-02f, -3.54810476e-01f, -4.50445145e-01f, -3.08634192e-01f, -2.06740856e-01f, 1.71130784e-02f, 6.11236924e-03f,
  1.68212384e-01f, 4.84593771e-02f, 2.22171377e-02f, -3.27261910e-02f, 1.63598925e-01f, -3.08751623e-04f, -1.79682970e-01f, -3.02703697e-02f, -2.00562716e-01f, -2.03257024e-01f,
  -2.08139122e-01f, 1.43658325e-01f, 7.03314692e-02f, 8.71009603e-02f, 7.02038407e-02f, 4.72417772e-02f, 7.07255006e-02f, 8.31101730e-04f, -2.80377399e-02f, -4.06171232e-02f,
  -1.94960069e-02f, 8.66437554e-02f, 4.51585315e-02f, 1.22208774e-01f, 1.24610988e-02f, 2.47693658e-02f, -9.70105678e-02f, -2.43805330e-02f, -6.69648498e-02f, -9.54821333e-02f,
  2.27224268e-02f, 4.09726566e-03f, -2.43590120e-02f, -1.06644414e-01f, -5.52480295e-02f, -3.03505659e-02f, 1.30204614e-02f, -7.00332448e-02f, -8.18865225e-02f, -7.83412755e-02f,
  -8.66525024e-02f, 2.09612306e-02f, -1.31555544e-02f, 9.99661088e-02f, -2.65600197e-02f, 9.90242930e-04f, -1.55228237e-03f, -5.60274385e-02f, 3.42434496e-02f, -5.08551719e-03f,
  2.83720414e-03f, -7.50159174e-02f, 1.87082514e-02f, -5.65999597e-02f, -7.22308755e-02f, 1.53187532e-02f, -5.88679723e-02f, -1.33463234e-01f, -1.22635700e-01f, -6.32765591e-02f,
  -3.22104245e-02f, 3.93707082e-02f, 4.57760179e-03f, 1.17335590e-02f, -9.30243507e-02f, -8.23913738e-02f, 1.08942948e-02f, 5.28115258e-02f, 3.86986434e-02f, 7.68492296e-02f,
  1.64278507e-01f, -1.89702094e-01f, -7.22620264e-02f, -1.25883343e-02f, -1.07106725e-02f, -1.06568776e-01f, -5.05763153e-03f, 2.73924898e-02f, 9.16639417e-02f, 3.46205123e-02f,
  7.84042180e-02f, -1.75076704e-02f, -7.39284977e-03f, -1.23403603e-02f, 2.88904514e-02f, -1.73646845e-02f, -4.65013124e-02f, 4.36645225e-02f, -1.33007720e-01f, 1.02672122e-01f,
  -5.90766743e-02f, -9.74655524e-02f, -1.25928679e-02f, -1.00617208e-01f, -5.06243370e-02f, -1.22707075e-04f, -1.58538640e-01f, -1.23686425e-01f, -9.10835192e-02f, -1.37063712e-01f,
  1.31563857e-01f, 6.52581900e-02f, 1.17674395e-01f, 5.22246026e-02f, -5.25333360e-02f, -8.93903598e-02f, -1.16832644e-01f, -4.18445515e-03f, -1.69613790e-02f, -4.06270362e-02f,
  -1.44824892e-01f, -5.71910143e-02f, -3.43745723e-02f, -3.54680941e-02f, 4.15183976e-02f, 3.31687331e-02f, 1.52122140e-01f, 2.34663233e-01f, 1.36753038e-01f, 6.19712099e-02f,
  1.67872548e-01f, 7.22814202e-02f, 2.27153063e-01f, 1.71061963e-01f, 1.58751994e-01f, 7.89350197e-02f, 3.92558649e-02f, 8.13697800e-02f, 9.14852018e-04f, 2.13406280e-01f,
  -1.27796724e-01f, 4.43073846e-02f, -2.90663075e-03f, -4.77200039e-02f, -1.45508721e-02f, 5.35468422e-02f, 4.35763970e-02f, 3.49293724e-02f, -3.47476117e-02f, -1.16409278e-02f,
  3.85179147e-02f, -4.70583439e-02f, 2.54717283e-02f, 7.81136602e-02f, 6.20733276e-02f, -1.75605225e-03f, 1.13408111e-01f, -4.49252926e-04f, 7.13590756e-02f, 2.09115986e-02f,
  5.58568425e-02f, 2.93145236e-02f, 2.81247124e-02f, -3.17045338e-02f, -4.33498919e-02f, -4.66596745e-02f, -9.14715603e-02f, 2.23903749e-02f, -4.44681989e-03f, 3.82826217e-02f,
  7.33217131e-03f, 5.52315898e-02f, 9.55147576e-03f, -2.25774795e-02f, 1.94292683e-02f, -4.88144681e-02f, -8.61402135e-03f, 5.35790101e-02f, -1.15999635e-02f, 1.16487943e-01f,
  1.90149564e-02f, -4.92457785e-02f, 4.72268648e-03f, -7.59308413e-02f, 5.64084295e-03f, -1.27082793e-02f, 1.98391415e-02f, 2.06917208e-02f, -9.48968083e-02f, -7.71769183e-03f,
  1.04075760e-01f, -3.80538031e-02f, 5.58614545e-03f, 8.02922994e-03f, -8.43874458e-03f, 1.77133419e-02f, 5.98255172e-02f, 2.49317996e-02f, -3.69783565e-02f, 7.73993805e-02f,
  -1.57372147e-01f, -1.22167282e-01f, 1.96999181e-02f, -4.42505628e-02f, -1.32126687e-02f, 2.45921686e-03f, -8.59398991e-02f, -4.40953299e-02f, -6.42551780e-02f, 4.17099781e-02f,
  -1.76075939e-02f, -1.84866320e-02f, -1.17099002e-01f, 1.27803972e-02f, 3.40925492e-02f, -4.34502289e-02f, -1.12063726e-02f, 3.37376492e-03f, -9.02320370e-02f, -9.59677175e-02f,
  -5.49067892e-02f, -8.10275823e-02f, 2.54512262e-02f, -2.46971026e-02f, 6.48192363e-03f, -9.92960706e-02f, -3.53935398e-02f, 2.51627751e-02f, -1.00509301e-01f, 7.68682659e-02f,
  -1.19904749e-01f, -1.53312370e-01f, 7.57738203e-02f, -1.09909847e-01f, -5.64269200e-02f, 1.74947381e-02f, 3.09728552e-02f, -6.34706393e-02f, -8.48305821e-02f, 2.97865421e-02f,
  -6.82198405e-02f, 2.21255999e-02f, 6.74537420e-02f, -8.56988803e-02f, -8.57937858e-02f, -6.28513992e-02f, 3.94596253e-03f, 1.09245174e-01f, 1.81593701e-01f, 1.09677546e-01f,
  -7.60669559e-02f, -5.10246083e-02f, -7.41324276e-02f, -6.60167187e-02f, -2.71172151e-02f, 5.12306653e-02f, 2.68776733e-02f, -8.24973956e-02f, 3.09608039e-02f, -9.89690796e-02f,
  2.55918324e-01f, -1.59348026e-01f, 5.43184094e-02f, -1.55720383e-01f, -6.88803673e-04f, -3.02878935e-02f, 4.71757613e-02f, 7.60975201e-03f, -5.02124242e-02f, 3.10616158e-02f,
  -2.95498241e-02f, 3.28540988e-02f, 9.93623286e-02f, 5.22036105e-03f, -3.96186523e-02f, 1.96997542e-02f, -1.41384915e-01f, -2.05854289e-02f, -7.04794824e-02f, -2.50675306e-02f,
  -7.02157021e-02f, -2.14261301e-02f, 1.21464029e-01f, 3.51316705e-02f, -1.04629055e-01f, 1.38691187e-01f, -8.85011349e-03f, -8.35613832e-02f, -6.17043376e-02f, -1.17600933e-01f,
  -8.32725316e-02f, 6.11404069e-02f, 5.71376048e-02f, 5.54788001e-02f, 4.03297432e-02f, -6.52916729e-02f, 8.37253630e-02f, 8.22225139e-02f, 1.52650476e-02f, -7.25528970e-02f,
  1.32776867e-03f, -7.21101984e-02f, -9.35413390e-02f, 1.70582868e-02f, 2.46808790e-02f, 2.02831742e-03f, -8.57441500e-02f, 1.97531376e-02f, 1.01593579e-03f, 4.08868007e-02f,
  3.13279480e-02f, -5.29926792e-02f, 3.91635746e-02f, 3.12894792e-03f, -8.46499652e-02f, 5.60590532e-04f, -4.37015109e-02f, -3.01658195e-02f, 5.58913499e-03f, 1.05145737e-03f,
  8.03550929e-02f, -2.34843735e-02f, 5.21198893e-03f, -1.72193944e-02f, 6.71247095e-02f, -4.42821048e-02f, -4.03426439e-02f, -8.79405588e-02f, -3.80869024e-02f, 7.34689310e-02f,
  -6.69337660e-02f, -5.75466976e-02f, 4.56946306e-02f, -1.65976621e-02f, 3.74348350e-02f, 2.52764560e-02f, -3.86550985e-02f, 4.67003435e-02f, 1.16260638e-02f, -1.15598373e-01f,
  -7.41960779e-02f, 3.36942729e-03f, 1.58104107e-01f, 1.32761747e-01f, -2.13240292e-02f, 1.48525298e-01f, 1.64088741e-01f, 7.35085532e-02f, 1.40448079e-01f, 1.47166029e-02f,
  5.55203438e-01f, -6.46910429e-01f, -1.61103576e-01f, 9.49500576e-02f, 3.77269238e-02f, 1.56105354e-01f, -1.57317564e-01f, -1.23288278e-02f, 1.35457933e-01f, -1.48516446e-01f,
  -2.08563820e-01f, 1.10295631e-01f, 7.98758045e-02f, 3.02557796e-02f, 1.73417151e-01f, -2.10130095e-01f, -5.96745126e-03f, 2.73435861e-01f, 3.91732365e-01f, 1.16630942e-01f,
  1.59907062e-02f, -5.58656864e-02f, 2.05437705e-01f, 6.38219565e-02f, -3.00470471e-01f, 9.26490873e-02f, -1.85271665e-01f, -2.03154966e-01f, -2.52715349e-01f, -3.39340448e-01f,
  -1.28747553e-01f, -8.04252848e-02f, 2.08809793e-01f, 2.10441053e-02f, -6.00005910e-02f, 1.53923213e-01f, 6.25853762e-02f, -6.81048632e-03f, -2.56789960e-02f, 2.82412618e-02f,
  -2.40131766e-02f, -1.56213623e-02f, -3.86335067e-02f, -5.30849863e-03f, -8.15406144e-02f, 4.25394960e-02f, -1.09177664e-01f, 8.62849802e-02f, -6.48853630e-02f, -3.28959040e-02f,
  -2.68401384e-01f, -4.32182550e-02f, 3.72273885e-02f, 4.73773666e-02f, -2.87538301e-03f, 1.04840323e-01f, -1.73098326e-01f, -4.36104313e-02f, -5.24963550e-02f, -1.68231696e-01f,
  -1.23177923e-01f, 3.05402149e-02f, 1.95650049e-02f, 2.17404030e-02f, 5.01519516e-02f, -2.98279934e-02f, -4.64881584e-02f, 3.31093334e-02f, 6.02162182e-02f, -1.41294245e-02f,
  2.96476670e-03f, -4.11114357e-02f, -4.07704003e-02f, 3.00405570e-03f, -6.24422543e-02f, 5.35906991e-03f, 3.97047773e-02f, -1.10598564e-01f, 5.39071597e-02f, -5.84532693e-02f,
  -2.17230003e-02f, 2.34456137e-02f, 1.74438879e-02f, -3.21705528e-02f, -5.47934435e-02f, 1.00399498e-02f, 3.84272598e-02f, 5.90710565e-02f, 2.27521677e-02f, -9.05869063e-03f,
  -2.14224011e-02f, 1.58923566e-01f, 1.83529519e-02f, 6.04763860e-04f, 2.91653033e-02f, -4.19268906e-02f, 2.46934909e-02f, -1.88265983e-02f, -5.81382699e-02f, 2.99068838e-02f,
  6.22173958e-02f, -1.45117128e-02f, -6.10611774e-02f, 2.31271586e-03f, 4.78060432e-02f, 5.94037138e-02f, -3.64483707e-02f, 4.41330336e-02f, 1.35124819e-02f, -9.12467316e-02f,
  -1.49291366e-01f, 1.75046071e-01f, 2.33089864e-01f, -3.38611417e-02f, 1.14092976e-01f, 2.73528844e-01f, 3.11745033e-02f, -7.68623799e-02f, 2.65129179e-01f, -5.26552349e-02f,
  5.64715974e-02f, -1.02955751e-01f, 3.65304090e-02f, 1.31905913e-01f, 3.89860338e-03f, 6.16057403e-02f, 9.79729220e-02f, 1.23072602e-01f, 1.14461474e-01f, 8.68246108e-02f,
  1.72178745e-01f, 2.15490058e-01f, 2.60628313e-01f, 9.98964384e-02f, 1.65921986e-01f, 1.13498107e-01f, -3.40947770e-02f, 1.12470709e-01f, 1.43086240e-01f, 1.46132454e-01f,
  6.66009113e-02f, -7.79486597e-02f, -9.80399456e-03f, 1.72462948e-02f, 6.19599186e-02f, 4.79962416e-02f, 7.71854892e-02f, -1.28142431e-01f, -2.23843530e-02f, 4.45229113e-02f,
  3.52495797e-02f, -1.27472118e-01f, 1.06667243e-01f, 5.23660630e-02f, -1.87350381e-02f, -1.06213242e-02f, -8.84115174e-02f, -5.85489497e-02f, -1.28784642e-01f, -5.13194799e-02f,
  8.35956912e-03f, -1.07798338e-01f, -9.23525691e-02f, -1.24457076e-01f, -1.73930258e-01f, 2.57760789e-02f, -1.80383101e-02f, 5.25329374e-02f, 7.58903027e-02f, 9.24987718e-02f,
  8.77319127e-02f, -1.29567785e-03f, 7.54977316e-02f, 4.68298532e-02f, 6.22796342e-02f, 6.85019232e-03f, -3.21159661e-02f, 2.08186246e-02f, 5.12443967e-02f, -2.96891797e-02f,
  1.07702129e-01f, 7.20590651e-02f, 7.95833990e-02f, -6.33959174e-02f, 4.66829306e-03f, 3.44630592e-02f, 6.97057620e-02f, -2.03805305e-02f, 4.96219285e-02f, -2.70214770e-02f,
  3.68488058e-02f, 3.62417176e-02f, 1.35364169e-02f, 5.10683917e-02f, 8.22928324e-02f, -8.54159817e-02f, -3.06712035e-02f, -3.79936956e-02f, -6.45184368e-02f, 8.23709648e-03f,
  -8.61878321e-02f, 6.71195015e-02f, -4.11732867e-02f, -1.01664681e-02f, 2.94689015e-02f, 5.90338297e-02f, -2.85284147e-02f, -4.86440770e-02f, -4.16266881e-02f, -4.64980453e-02f,
  2.46264338e-02f, 7.74119720e-02f, 4.86216582e-02f, 5.95583171e-02f, -6.09175712e-02f, -6.37002289e-02f, 1.02245569e-01f, 2.70236749e-02f, -1.08521752e-01f, -2.30259970e-02f,
  3.08533218e-02f, 1.18432250e-02f, -7.61102438e-02f, -4.45482023e-02f, -1.38338925e-02f, -8.87583569e-03f, 6.19140193e-02f, 5.44783510e-02f, 9.23345163e-02f, -1.83622371e-02f,
  3.08852326e-02f, -2.47012805e-02f, 1.63217708e-01f, 1.37006026e-02f, 1.18430004e-01f, 9.40252244e-02f, 1.47703886e-02f, 6.82029948e-02f, 1.19136386e-02f, 1.02007933e-01f,
  -3.05830866e-01f, 6.11968823e-02f, -3.28772701e-02f, 2.14372978e-01f, -1.46171488e-02f, 8.27468261e-02f, 1.54764906e-01f, 2.19613194e-01f, 2.03900054e-01f, 2.01669801e-03f,
  -1.82855576e-02f, 1.37075692e-01f, 1.84171021e-01f, 1.44040421e-01f, 1.24676868e-01f, 3.00093055e-01f, 3.60677510e-01f, 1.29640820e-02f, -2.19204854e-02f, 5.77189773e-02f,
  8.72572735e-02f, -2.64033992e-02f, -7.89728388e-02f, 7.92908743e-02f, 2.30403408e-01f, 1.72585666e-01f, 2.93157250e-02f, 6.86645508e-02f, -4.97285612e-02f, 2.94435501e-01f,
  -1.70170948e-01f, -1.59149036e-01f, 6.48349300e-02f, 3.05836997e-03f, -8.84393901e-02f, -1.30382255e-02f, 1.31906848e-02f, -1.19972780e-01f, 4.19177003e-02f, 4.90384847e-02f,
  4.17089136e-03f, -9.38825533e-02f, 4.16329131e-02f, -3.95413414e-02f, -8.79832506e-02f, -1.10832877e-01f, -5.27945533e-03f, 9.27023292e-02f, 8.29264894e-02f, -2.13295687e-02f,
  3.84851247e-02f, -9.39828083e-02f, -8.03052410e-02f, -9.03650746e-02f, 1.33230984e-01f, 2.50127167e-02f, -9.20064896e-02f, -3.75612602e-02f, -1.20974584e-02f, -8.88991728e-02f,
  -4.94601466e-02f, 2.87616421e-02f, 6.84824493e-03f, 7.49192573e-03f, 1.05062902e-01f, -1.63481161e-02f, 7.36594573e-02f, 4.75936532e-02f, 4.00299095e-02f, -1.71143212e-03f,
  -9.70530882e-03f, -3.07325809e-03f, -2.57748924e-02f, -1.09596492e-03f, -9.85026173e-03f, -8.40967074e-02f, -4.10248712e-02f, 9.17049998e-04f, -5.01402654e-02f, -3.09446305e-02f,
  2.61696219e-03f, -1.14075420e-02f, -2.26287115e-02f, 5.52832745e-02f, -4.51703072e-02f, 5.04986718e-02f, -3.38751860e-02f, -3.56443971e-02f, -8.17434266e-02f, -5.38467988e-03f,
  2.39900555e-02f, -7.41500705e-02f, 1.13442048e-01f, 8.27762857e-02f, 3.53205353e-02f, -1.04836062e-01f, -2.16413066e-02f, -4.58240174e-02f, -6.57769367e-02f, -3.58345620e-02f,
  -3.45431902e-02f, -5.09244874e-02f, 4.29077931e-02f, -2.94797104e-02f, -1.25908345e-01f, -7.03148991e-02f, -4.87867035e-02f, -2.14986615e-02f, 3.73785906e-02f, -2.03946885e-02f,
  2.77577676e-02f, -1.44155979e-01f, -1.41436815e-01f, 5.09538986e-02f, -4.66221273e-02f, -6.34472519e-02f, -1.92604009e-02f, -4.98049930e-02f, -5.88194504e-02f, -1.57610044e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.96627051e-01f, 2.79959470e-01f, 1.22747041e-01f, 1.40490547e-01f, 1.21031024e-01f, 3.97544771e-01f, -6.03480600e-02f, 8.94378275e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.03707992e-01f, -1.20920248e-01f, -1.79348346e-02f, 2.18543649e-01f, 7.68362135e-02f, -1.96451932e-01f, 8.20161253e-02f, 2.30238974e-01f, -9.56313908e-02f, 1.44413933e-01f,
  9.11233351e-02f, 1.08908504e-01f, -1.95847169e-01f, -1.68032393e-01f, 9.94543210e-02f, 4.91830222e-02f, -4.90009397e-01f, -2.07233921e-01f, -2.48046979e-01f, -2.37696573e-01f,
  1.07054509e-01f, 1.09278616e-02f, -2.18466058e-01f, -4.38259035e-01f, -3.43505472e-01f, -6.21699207e-02f, -3.18547994e-01f, 4.25674886e-01f, -1.83192685e-01f, -3.24267179e-01f,
  -4.27494645e-01f, 6.01539724e-02f, -2.14979142e-01f, -1.22539461e-01f, 1.25162736e-01f, -1.74451880e-02f, 1.06821649e-01f, 7.60637522e-02f, -3.84585969e-02f, 1.47994816e-01f,
  -5.87657616e-02f, 2.52152413e-01f, 2.31750250e-01f, -7.02751875e-02f, 4.02660906e-01f, -1.90605447e-01f, 7.85639063e-02f, -2.81998932e-01f, 6.17647134e-02f, -4.93141800e-01f,
  -4.12213683e-01f, 3.65404934e-01f, 3.76730144e-01f, 7.11621419e-02f, -1.20103806e-01f, 2.73501128e-01f, -9.48113054e-02f, -2.83557653e-01f, 1.43137336e-01f, 1.12469964e-01f,
  -1.49170697e-01f, -2.94252127e-01f, 4.61955480e-02f, 2.52933681e-01f, 1.28729874e-02f, 1.46264862e-03f, -5.65395392e-02f, 1.41210146e-02f, -1.22539029e-01f, -1.23995848e-01f,
  1.78355560e-01f, 9.43049937e-02f, -6.34301500e-03f, 3.79907787e-02f, -5.49179316e-02f, 1.50169823e-02f, -1.78980038e-01f, -1.47478923e-01f, 1.19529717e-01f, 3.20809901e-01f,
  -8.20451453e-02f, 5.86279705e-02f, -7.48745650e-02f, -1.31505325e-01f, -2.60665268e-01f, 1.65837482e-01f, 1.35043144e-01f, 3.40982527e-01f, 1.80941626e-01f, -1.69233121e-02f,
  -2.10732520e-01f, -2.88080126e-02f, -1.98349983e-01f, 1.76799923e-01f, -1.19457401e-01f, -1.55142710e-01f, 1.32038761e-02f, -3.24022882e-02f, 2.01098304e-02f, 9.36061218e-02f,
  -1.11880243e-01f, -2.60006815e-01f, 1.10860027e-01f, 6.27480298e-02f, 1.98789522e-01f, 5.86594641e-02f, -7.76513889e-02f, -2.14033127e-01f, 2.84389257e-01f, -1.51392817e-01f,
  -3.15512180e-01f, 5.32214224e-01f, 3.28942060e-01f, 5.18089950e-01f, 1.35944322e-01f, 2.60967970e-01f, 8.05154964e-02f, -1.78685054e-01f, -2.30242535e-01f, -8.78866166e-02f,
  3.97848964e-01f, -1.47645086e-01f, -2.82424569e-01f, -1.20893858e-01f, -1.89883411e-01f, -1.50322989e-01f, -1.35869056e-01f, 1.71295434e-01f, 1.78589150e-01f, -2.25022003e-01f,
  1.11675607e-02f, -1.40372261e-01f, -3.12930644e-01f, 1.29189864e-01f, 1.98981076e-01f, -9.23284069e-02f, -1.95119843e-01f, 1.29826248e-01f, -5.27317561e-02f, -1.61265075e-01f,
  2.14244008e-01f, 2.89215475e-01f, -1.67347074e-01f, 2.79746860e-01f, 2.74311006e-01f, 1.87893718e-01f, 1.07362919e-01f, 2.08928034e-01f, -3.57205391e-01f, 3.76213729e-01f,
  2.69306123e-01f, 2.46134877e-01f, 4.24149543e-01f, 8.05416852e-02f, 9.19840112e-02f, -2.01801732e-01f, -3.13461907e-02f, -3.33656371e-02f, 2.60967255e-01f, -9.15006921e-02f,
  -3.64219286e-02f, -1.49341285e-01f, 2.64719695e-01f, -1.20222978e-01f, 1.27225205e-01f, -5.83346449e-02f, -1.89770684e-01f, 7.33998194e-02f, 8.56660604e-02f, 2.45180666e-01f,
  -2.00912312e-01f, 8.09047297e-02f, -2.11331367e-01f, 5.54017067e-01f, -3.11546534e-01f, -5.81034243e-01f, -9.99576822e-02f, -1.89497173e-01f, 5.30395396e-02f, -3.38240042e-02f,
  1.08854786e-01f, 5.62186055e-02f, 7.82855526e-02f, -9.20754373e-02f, -3.65321577e-01f, -4.83051641e-03f, 6.39117211e-02f, 1.43581912e-01f, 2.43704423e-01f, -4.40549105e-01f,
  -1.08672623e-02f, -1.35932580e-01f, -2.64990926e-01f, -3.82522307e-02f, -1.77092612e-01f, -2.67621242e-02f, 1.41691491e-01f, -8.47914293e-02f, -2.64242738e-02f, -1.24479234e-01f,
  -1.54048160e-01f, -3.16748291e-01f, 1.48701772e-01f, 7.71320611e-03f, 1.61426470e-01f, -3.50789994e-01f, 1.70200586e-01f, 2.88978722e-02f, -2.95856535e-01f, -1.17300875e-01f,
  -2.35629715e-02f, 1.06460288e-01f, 5.63015938e-01f, -4.10550594e-01f, -6.46124244e-01f, 2.26248398e-01f, -1.35970220e-01f, -5.63529693e-02f, 1.91705003e-01f, 3.30893487e-01f,
  -8.69760364e-02f, 3.08308661e-01f, -6.27074167e-02f, 2.03712583e-01f, -4.22031358e-02f, 2.76048854e-02f, 1.40870363e-01f, 6.83026239e-02f, -6.99238181e-02f, 7.88234770e-02f,
  1.83244959e-01f, -1.43515905e-02f, -1.60723954e-01f, -2.19994530e-01f, 1.18309632e-02f, -2.58038282e-01f, -1.29357830e-01f, -2.08430812e-01f, 2.05714315e-01f, -3.58474664e-02f,
  3.04525852e-01f, -3.22792888e-01f, 3.04678202e-01f, -1.61331624e-01f, -4.16544646e-01f, 2.98169971e-01f, 6.20118201e-01f, 3.96539688e-01f, 1.46106660e-01f, 5.51774241e-02f,
  3.49333823e-01f, -2.29990199e-01f, 4.04040627e-02f, 2.47050330e-01f, 1.70038231e-02f, -1.67367890e-01f, -9.42913443e-02f, -8.26445669e-02f, 1.31332189e-01f, 9.57492087e-03f,
  -6.44173995e-02f, -7.73448721e-02f, -2.65473276e-01f, 1.65996835e-01f, -1.29859596e-01f, 8.02801326e-02f, -1.44894734e-01f, 3.82742733e-02f, -5.06942093e-01f, 2.15701967e-01f,
  1.58247992e-01f, -1.32436782e-01f, -4.14901495e-01f, 1.96327316e-03f, 1.04906544e-01f, -2.21189842e-01f, -3.41203839e-01f, 3.82922986e-03f, 3.24929595e-01f, -3.79587978e-01f,
  -4.85258132e-01f, 2.89933294e-01f, 3.73450331e-02f, -6.44284487e-02f, 1.28356367e-01f, -2.76910484e-01f, -4.68630865e-02f, -2.07401723e-01f, 3.58186573e-01f, 1.21181764e-01f,
  8.47819522e-02f, 4.92350049e-02f, -9.64084789e-02f, 1.52164683e-01f, 1.39705479e-01f, -6.37106076e-02f, 7.37615004e-02f, -3.83870840e-01f, -9.87643301e-02f, -1.26825377e-01f,
  -5.41212976e-01f, -2.57861335e-02f, 3.91843915e-01f, 1.75739288e-01f, -2.86225885e-01f, -3.44281867e-02f, 1.71476871e-01f, -5.56905210e-01f, -3.81185621e-01f, -4.28390615e-02f,
  2.41622537e-01f, 3.29474628e-01f, -2.66903006e-02f, 2.50862837e-01f, 1.32465810e-01f, -1.95757776e-01f, -5.89283779e-02f, 3.88747960e-01f, -1.27306976e-03f, -1.56536475e-01f,
  -1.08039625e-01f, -3.45267147e-01f, -1.96125418e-01f, -2.33615428e-01f, -4.84263189e-02f, -4.91776764e-02f, -1.73285410e-01f, -2.62132496e-01f, 3.53190362e-01f, -9.91479903e-02f,
  4.56683524e-02f, -2.32202336e-01f, -1.23101234e-01f, -7.83373266e-02f, -4.37280059e-01f, 1.02917049e-02f, -4.55296859e-02f, 3.53876740e-01f, 3.95643748e-02f, 1.15938522e-02f,
  3.89953852e-01f, -4.95270967e-01f, -3.38200539e-01f, -2.83994645e-01f, -1.79695219e-01f, 2.42877945e-01f, -1.25310257e-01f, 1.24258678e-02f, 1.60590529e-01f, -2.66553611e-01f,
  2.74741083e-01f, 3.82267497e-02f, -4.04819250e-02f, 4.01004702e-02f, -1.80430841e-02f, -2.04126045e-01f, 2.40721907e-02f, 2.18428969e-01f, -5.26638031e-02f, 7.04760849e-02f,
  6.04916271e-03f, 1.69041175e-02f, -2.75418192e-01f, 9.15770680e-02f, -1.47800408e-02f, 3.02074462e-01f, 3.92137207e-02f, -4.81940717e-01f, 3.49466562e-01f, -3.41636002e-01f,
  1.22398578e-01f, 8.53686070e-05f, -1.59631118e-01f, 4.91027892e-01f, 2.29532450e-01f, 5.00781834e-01f, 5.29294796e-02f, -1.19071379e-01f, 3.36306930e-01f, -8.43996778e-02f,
  6.67625815e-02f, -8.95431489e-02f, 2.38395318e-01f, 5.83675765e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.38915586e-01f, 8.85854885e-02f, 3.80884469e-01f, 4.13697749e-01f, -3.08595687e-01f, 2.45997295e-01f, 5.07545590e-01f, 4.00903523e-01f, 6.85393140e-02f, 1.81611180e-01f,
  -2.61114463e-02f, 8.39016065e-02f, 1.75169945e-01f, 4.70890909e-01f, -8.29033703e-02f, 7.45908618e-02f, 8.06251168e-02f, 2.14613378e-01f, -3.31943780e-01f, 4.98915881e-01f,
  -4.52685922e-01f, 2.61808813e-01f, 2.84090608e-01f, -1.72183737e-01f, 7.92069361e-03f, -1.26196831e-01f, 4.66307372e-01f, 7.09724873e-02f, -9.11155418e-02f, -2.97898561e-01f,
  1.65475756e-01f, -1.70312136e-01f, -2.51607932e-02f, 9.16449502e-02f, -4.33677472e-02f, 5.04802689e-02f, 2.11338237e-01f, 2.53812909e-01f, 1.68747857e-01f, 1.47111222e-01f,
  2.52555370e-01f, 2.13640496e-01f, -9.88411531e-02f, -9.43165123e-02f, -5.75407781e-02f, -1.53560042e-01f, -1.82086855e-01f, 2.37355560e-01f, 1.62899703e-01f, 2.36210629e-01f,
  2.34703068e-02f, -1.08454056e-01f, 8.83624256e-02f, -2.95648485e-01f, -1.56943828e-01f, 5.21193705e-02f, 3.52761179e-01f, 2.08897322e-01f, 1.11842223e-01f, -1.67115942e-01f,
  1.90961942e-01f, 2.24974290e-01f, 7.66770244e-02f, -5.06160334e-02f, 3.60754579e-01f, 1.59088373e-01f, 1.58168599e-01f, 3.66331041e-01f, 3.59855980e-01f, 4.00236577e-01f,
  -1.91288263e-01f, -4.83484901e-02f, 5.25676608e-01f, 1.07761085e-01f, 3.25986743e-01f, 2.37153217e-01f, -4.05985534e-01f, -2.56977320e-01f, 3.22798878e-01f, -3.00814331e-01f,
  -1.31107646e-03f, -1.84012055e-01f, 4.11864758e-01f, -7.22281039e-01f, 3.48041728e-02f, -3.71518314e-01f, 2.80060410e-01f, 2.71218598e-01f, 2.39738971e-01f, 1.64718613e-01f,
  -4.53969479e-01f, 2.47303203e-01f, 4.50642496e-01f, 6.96932375e-01f, 1.58080131e-01f, -8.78221914e-03f, 5.13534881e-02f, 9.96774882e-02f, 1.46518081e-01f, 2.22510427e-01f,
  -4.32288907e-02f, 2.99927026e-01f, 4.05716121e-01f, 1.74529344e-01f, -4.90978099e-02f, -3.82479995e-01f, -3.39659810e-01f, -5.65950386e-02f, -4.61609922e-02f, -3.09251934e-01f,
  8.25766549e-02f, 4.01418984e-01f, 1.15759753e-01f, 4.87354305e-03f, 1.54860228e-01f, -6.04038723e-02f, -2.55736530e-01f, 3.08200240e-01f, -1.16563238e-01f, 7.27328897e-01f,
  5.75061888e-02f, 2.92167991e-01f, 4.76938456e-01f, 3.50964479e-02f, -9.21579078e-02f, 5.30105889e-01f, 2.06077337e-01f, 4.99286711e-01f, 8.45171064e-02f, 2.13805422e-01f,
  3.23898554e-01f, -9.07837972e-02f, 3.29199225e-01f, 2.14908924e-02f, -2.76437681e-03f, 1.20107561e-01f, 3.40806454e-01f, 1.03436977e-01f, -2.24516198e-01f, 9.15580336e-03f,
  6.06861636e-02f, 1.44363180e-01f, 9.91861243e-03f, -4.03197676e-01f, 1.11894421e-01f, -2.34002247e-01f, 2.98469812e-02f, -3.24029833e-01f, 5.69123104e-02f, -4.02621785e-03f,
  -2.78666168e-01f, 2.57356793e-01f, 6.55728355e-02f, 1.36939526e-01f, -1.57727220e-03f, -3.69034335e-02f, 7.26292580e-02f, -8.65412056e-02f, -7.81140178e-02f, -9.75106135e-02f,
  -2.03417450e-01f, 1.15077645e-01f, 3.72180998e-01f, 2.56658643e-02f, 2.02657133e-01f, 1.51873708e-01f, 2.53093690e-01f, -5.05229048e-02f, -1.86411291e-01f, 2.60238349e-01f,
  1.62590981e-01f, 4.52282071e-01f, 3.28973085e-01f, 1.91377774e-01f, 3.27006191e-01f, -3.03891182e-01f, 1.74064353e-01f, -4.85216916e-01f, -3.09713691e-01f, 4.23307449e-01f,
  -9.76876020e-02f, 2.77266115e-01f, 4.75124605e-02f, -4.36765468e-03f, 3.76640335e-02f, -1.92915708e-01f, 5.70793040e-02f, 4.98885550e-02f, -2.40049660e-01f, -2.07136959e-01f,
  1.21481121e-01f, 1.39488935e-01f, 1.76285058e-01f, -1.81745505e-03f, 1.65880844e-01f, 3.59695971e-01f, 1.61043525e-01f, -7.22989962e-02f, 2.89919227e-01f, -8.00083950e-02f,
  1.34855762e-01f, 1.93757728e-01f, 8.43755454e-02f, 8.15953165e-02f, 1.47390604e-01f, 3.41344364e-02f, -1.82950087e-02f, 2.26355761e-01f, -1.91059038e-01f, 4.69059974e-01f,
  1.81902617e-01f, -2.90207386e-01f, -9.68246460e-02f, -3.64824951e-01f, 2.89023407e-02f, -2.67704338e-01f, 3.17921340e-01f, 3.79062235e-01f, -2.81209379e-01f, 2.35555410e-01f,
  8.78697336e-02f, 5.40167809e-01f, 7.96736851e-02f, -2.17941701e-01f, 3.50984037e-01f, 1.60153121e-01f, -2.18128487e-02f, 2.64869779e-01f, -6.10228032e-02f, 3.38025540e-02f,
  -1.45903766e-01f, 2.23387226e-01f, 3.47619951e-01f, -1.36466166e-02f, -2.30328873e-01f, 2.44557679e-01f, -5.12645394e-02f, 1.47012845e-01f, -3.34830880e-01f, 4.14394885e-02f,
  -4.37712342e-01f, 1.23188362e-01f, -1.72076106e-01f, -2.51976818e-01f, 1.39732763e-01f, -3.22375327e-01f, -5.39181292e-01f, -2.35689320e-02f, -2.18636438e-01f, 2.20328391e-01f,
  -2.60496706e-01f, 4.26438861e-02f, -2.27053300e-01f, -1.34491816e-01f, 1.98251113e-01f, 6.89491808e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.99134696e-01f, -2.27370765e-02f, 1.35821462e-01f, 1.96015090e-02f, 3.02082419e-01f, 3.61027151e-01f, 9.84665938e-03f, 2.00292930e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -7.62826920e-01f, 7.72004947e-02f, -5.27193695e-02f, 2.89119750e-01f, -2.83293813e-01f, -1.92242846e-01f, 3.92542899e-01f, -4.54579413e-01f, -2.31287837e-01f, -1.56137645e-01f,
  -4.46378857e-01f, -3.68812144e-01f, -1.46601975e-01f, -3.68589073e-01f, 1.04880072e-01f, 1.31112978e-01f, 3.94562840e-01f, -2.58792073e-01f, -1.11520842e-01f, 2.03469276e-01f,
  6.85256943e-02f, 5.69233060e-01f, 8.78280997e-02f, 2.98697710e-01f, 3.42901438e-01f, 5.80429882e-02f, -3.90784472e-01f, 9.20164943e-01f, -1.45295382e-01f, -1.34557456e-01f,
  -2.94424683e-01f, -3.56449127e-01f, -4.69296604e-01f, -8.17473570e-04f, -4.74607170e-01f, -4.52283584e-02f, -4.71447781e-02f, 1.74699109e-02f, 7.48875067e-02f, -1.91964820e-01f,
  1.54424340e-01f, -3.88778031e-01f, -5.66724360e-01f, -9.65240747e-02f, -6.10759437e-01f, -2.49064997e-01f, 1.32296339e-01f, -2.29743466e-01f, 4.34541732e-01f, -6.08150959e-02f,
  -2.11424410e-01f, 1.45585492e-01f, -3.93320113e-01f, -5.49265258e-02f, 2.13058844e-01f, 2.20555991e-01f, -5.80686033e-01f, 2.02676266e-01f, 6.97426081e-01f, 4.60714161e-01f,
  2.93249547e-01f, -4.58671868e-01f, 2.92398661e-01f, 3.91241938e-01f, 3.09655577e-01f, -9.71522629e-02f, 2.28765339e-01f, 8.55136141e-02f, 2.77495861e-01f, -2.80008972e-01f,
  2.81220734e-01f, 5.22690594e-01f, -7.76594043e-01f, 4.20752645e-01f, -1.75154179e-01f, 3.35831493e-01f, -1.31195383e-02f, 6.72632992e-01f, 1.87085375e-01f, 4.24481750e-01f,
  -2.15344373e-02f, -6.26422465e-01f, 4.26994532e-01f, 1.82145670e-01f, -1.45613536e-01f, -4.05541062e-01f, -5.26805699e-01f, -2.10427612e-01f, -1.31173477e-01f, 3.28508288e-01f,
  4.87893552e-01f, -1.16809666e-01f, 3.21346819e-02f, 2.62849897e-01f, 2.13245943e-01f, -5.60721278e-01f, -4.58101481e-02f, 3.24874848e-01f, 1.66238740e-01f, -3.95636022e-01f,
  -3.69791627e-01f, 1.01406872e-01f, -3.38460654e-01f, 6.91780627e-01f, 2.31058076e-01f, 2.20301881e-01f, 2.39394605e-04f, 4.85146463e-01f, -4.62428987e-01f, -6.85955822e-01f,
  1.17870666e-01f, 9.70122218e-01f, 4.88067627e-01f, -3.65038931e-01f, -5.50208688e-01f, 2.59836137e-01f, -3.08263481e-01f, -2.90887803e-01f, -5.38182020e-01f, -6.18279353e-02f,
  5.12290657e-01f, 9.91816148e-02f, -4.48230654e-01f, -2.83299267e-01f, -2.74744481e-01f, -1.55953392e-02f, 4.14485872e-01f, -3.36065680e-01f, -1.35115594e-01f, 1.10915475e-01f,
  -8.15412924e-02f, 9.11747664e-02f, 5.28153218e-02f, 1.68225706e-01f, -2.70146072e-01f, -3.66381481e-02f, 2.40373313e-01f, 4.99967873e-01f, -4.12044168e-01f, -4.06143904e-01f,
  -2.52098382e-01f, 3.27353656e-01f, -2.40382537e-01f, -4.60311353e-01f, 5.63686967e-01f, 3.34903985e-01f, -5.04633486e-01f, 5.09871960e-01f, 2.83459812e-01f, 1.95335522e-02f,
  -1.20575622e-01f, 1.30670831e-01f, 7.99037039e-01f, -1.77542329e-01f, -4.34053034e-01f, -3.65097761e-01f, -2.74560988e-01f, 7.91804552e-01f, -3.95697623e-01f, -3.23460072e-01f,
  5.89179099e-01f, 3.87693226e-01f, 1.35427952e-01f, -1.97629616e-01f, 5.39122939e-01f, 5.48581183e-01f, 9.35715809e-02f, -1.15306295e-01f, 4.18118566e-01f, -2.62653023e-01f,
  -5.65548599e-01f, 1.58355981e-01f, 3.10344517e-01f, -2.62907952e-01f, 4.47070777e-01f, -6.39675200e-01f, -3.04419667e-01f, -2.31598362e-01f, -3.29417288e-01f, 8.05183709e-01f,
  5.43461919e-01f, 8.55887294e-01f, -2.41286725e-01f, 1.79708153e-01f, -1.01401798e-01f, -2.97778845e-01f, 2.60145336e-01f, 3.66695791e-01f, 3.25829722e-02f, 1.64780825e-01f,
  -2.09773600e-01f, -1.82184070e-01f, -7.42998302e-01f, -9.74424556e-02f, 7.01863244e-02f, 1.01469293e-01f, -4.04616207e-01f, 2.89742351e-01f, -3.62016782e-02f, -5.94652176e-01f,
  2.56262124e-01f, 2.81526834e-01f, 3.15717250e-01f, 1.49527892e-01f, 5.79830587e-01f, 6.26509964e-01f, -1.11509077e-01f, -6.08880818e-01f, -4.75692123e-01f, 1.88157976e-01f,
  4.97581661e-01f, -6.61886632e-01f, -1.02453373e-01f, -2.91671336e-01f, -2.50886828e-01f, -1.90562665e-01f, -2.29810297e-01f, -3.64168137e-01f, 2.00306267e-01f, -5.65092146e-01f,
  2.57610708e-01f, 9.85510126e-02f, 4.50595208e-02f, 5.55718958e-01f, -7.70436004e-02f, -9.35508162e-02f, -7.43576214e-02f, -4.05119538e-01f, -1.12640798e-01f, -2.04929933e-02f,
  -2.43213534e-01f, -5.75512588e-01f, -4.08277959e-01f, -4.53318864e-01f, -1.39238894e-01f, 1.42092407e-01f, 2.90807903e-01f, 3.20526779e-01f, -2.13815749e-01f, 5.88246882e-01f,
  -2.01288387e-02f, -4.73841101e-01f, 3.55817646e-01f, -2.67298818e-01f, -2.73783892e-01f, -5.59965611e-01f, 8.62953722e-01f, -3.54392946e-01f, -3.39379042e-01f, 1.46743208e-01f,
  -3.95775288e-01f, 3.39403480e-01f, -1.21125154e-01f, -4.03223298e-02f, -3.19286466e-01f, 7.55856693e-01f, 4.38495493e-03f, -3.15624863e-01f, -3.21755907e-03f, -2.18462735e-01f,
  -3.15204859e-01f, 6.64059669e-02f, 4.84839119e-02f, 2.48505279e-01f, 1.91150121e-02f, -5.58304228e-02f, 4.95937049e-01f, -3.05345148e-01f, 5.99273406e-02f, -3.63133639e-01f,
  -2.32031062e-01f, -2.45243177e-01f, -5.07572532e-01f, -2.80323446e-01f, 4.14967984e-01f, 3.33441491e-03f, 3.10111552e-01f, 4.62752312e-01f, 5.93237579e-01f, -8.18975449e-01f,
  -7.99257636e-01f, 1.30181074e-01f, 8.18211317e-01f, -2.04074070e-01f, -3.01499486e-01f, -2.69081742e-01f, 7.79479682e-01f, -1.18024789e-01f, 4.17625964e-01f, -5.45131981e-01f,
  -2.44767945e-02f, 2.11530387e-01f, 3.18463773e-01f, 1.96821347e-01f, 7.07689226e-02f, 1.90403447e-01f, -1.65134490e-01f, -3.50706726e-01f, 2.12606803e-01f, -4.17334288e-02f,
  1.68423802e-01f, 2.64250100e-01f, -3.60823095e-01f, -2.94035226e-01f, -3.66301119e-01f, 5.52076995e-01f, 5.69355071e-01f, -3.52736175e-01f, -4.29477602e-01f, -5.95618904e-01f,
  -3.58215958e-01f, 6.57451987e-01f, 1.16972864e-01f, -2.92345524e-01f, -7.49329925e-01f, -9.24549401e-02f, 3.81885916e-01f, 6.34091258e-01f, -2.36147493e-01f, -2.97295004e-01f,
  2.89780587e-01f, 7.01777115e-02f, 9.51133445e-02f, -3.58473621e-02f, 1.96462512e-01f, -6.86542332e-01f, -3.92635942e-01f, 4.62798715e-01f, 1.69012576e-01f, 4.71984893e-01f,
  5.11333287e-01f, -1.24595277e-01f, -4.80226517e-01f, -3.79635394e-01f, -2.83191651e-01f, -1.93583503e-01f, -1.14779398e-01f, 8.40507030e-01f, -6.31252468e-01f, 2.20915839e-01f,
  4.83793706e-01f, 3.46614242e-01f, -3.49548198e-02f, 5.15264452e-01f, -3.02813828e-01f, 8.01818892e-02f, 7.03005016e-01f, -5.56020498e-01f, 4.34689313e-01f, -2.10991591e-01f,
  -7.65995905e-02f, -1.03012063e-01f, 1.74903929e-01f, 3.30893308e-01f, 2.18977854e-01f, 1.16643578e-01f, 2.01865494e-01f, 2.05278769e-01f, 4.67375338e-01f, -2.41355374e-01f,
  4.61441934e-01f, 4.95772213e-01f, 1.73333213e-01f, -1.77625343e-01f, 4.96972233e-01f, -5.22344291e-01f, 5.01736924e-02f, 5.13348579e-01f, -2.58178592e-01f, 1.51802644e-01f,
  -1.60576478e-01f, -6.13898218e-01f, 3.17741156e-01f, 2.47796521e-01f, 4.50785905e-01f, -7.01567829e-01f, 3.86954099e-01f, 1.80586457e-01f, -4.00511801e-01f, -2.67522871e-01f,
  6.49956316e-02f, -3.36999238e-01f, 3.15395117e-01f, 4.30723250e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.69992144e-02f, -9.41831097e-02f, -2.74343807e-02f, 2.45692372e-01f, 5.79112619e-02f, 2.58728951e-01f, -6.32398650e-02f, -9.69473198e-02f, -1.98177740e-01f, 2.31990144e-01f,
  1.78026840e-01f, -5.04583009e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    