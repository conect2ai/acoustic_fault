/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.11651042e-01f, -1.03313759e-01f, -1.08244523e-01f, -4.52156961e-02f, -5.51200137e-02f, 5.02043515e-02f, 1.08038515e-01f, -9.02722254e-02f, -9.87760574e-02f, 1.01012833e-01f,
  -5.28347045e-02f, -7.20039681e-02f, 8.59917849e-02f, -1.38318256e-01f, 7.26421997e-02f, 3.13331783e-02f, -2.98009161e-02f, -7.78982937e-02f, -8.40718895e-02f, -3.45356613e-02f,
  -4.01033647e-02f, 1.52503625e-01f, -4.17494625e-02f, 4.08291025e-03f, -2.65973452e-02f, -6.08509816e-02f, 1.29109129e-01f, 1.86885092e-02f, 2.42035668e-02f, 1.20746627e-01f,
  3.09705094e-04f, -1.74594894e-01f, 4.72701946e-03f, -6.76119048e-03f, 1.48066236e-02f, 1.33450804e-02f, 6.50217682e-02f, 6.25460520e-02f, -2.04019453e-02f, -1.30967284e-02f,
  3.95054333e-02f, 1.12553290e-03f, -8.50559697e-02f, 9.17834863e-02f, 4.02403437e-02f, -1.18549122e-03f, -4.11475413e-02f, 3.81247289e-02f, -4.80747931e-02f, -9.71198156e-02f,
  -4.44955938e-02f, -5.17709740e-02f, -4.34922650e-02f, 1.47530052e-03f, -6.57874122e-02f, -6.85093403e-02f, 2.53083315e-02f, -5.90196662e-02f, -7.07493052e-02f, -5.25735179e-03f,
  8.98001567e-02f, 5.09185828e-02f, -7.60721713e-02f, -6.47284016e-02f, -4.73330654e-02f, -2.37495247e-02f, -4.39112969e-02f, -4.38180752e-02f, 3.37105133e-02f, 4.00253199e-02f,
  5.55905327e-03f, 7.32840877e-03f, -1.63458437e-02f, 9.91525222e-03f, 8.74506459e-02f, -4.04178090e-02f, 4.59175706e-02f, 5.16644977e-02f, -1.78910103e-02f, -5.20908162e-02f,
  -8.19651876e-03f, -2.29794458e-02f, 6.31772652e-02f, -1.51494546e-02f, -1.40251722e-02f, 2.45792028e-02f, -1.35341017e-02f, 9.23241675e-02f, -3.83565798e-02f, 4.95453775e-02f,
  2.29804486e-01f, 1.19418576e-01f, 1.42075692e-03f, -1.15248729e-02f, 1.06163040e-01f, -3.63042690e-02f, -2.79468484e-02f, 3.50759998e-02f, 5.92994057e-02f, 1.12108337e-02f,
  6.86374446e-03f, 2.18534842e-02f, 2.69702729e-02f, 1.52913816e-02f, 1.06597086e-02f, 2.35151649e-02f, 1.11615323e-02f, 1.82082728e-02f, 8.87370110e-02f, 5.87326623e-02f,
  3.48752849e-02f, -1.62001662e-02f, -6.73463643e-02f, -7.51075074e-02f, -1.60584431e-02f, 6.04619198e-02f, -5.58879524e-02f, 3.45386472e-03f, -1.41659845e-02f, -3.73150073e-02f,
  -3.60078104e-02f, -1.69321656e-01f, 2.09621415e-01f, -1.85677689e-02f, 8.81919190e-02f, 1.42897844e-01f, 1.42398715e-01f, -6.84240982e-02f, 5.25859036e-02f, -2.37259939e-01f,
  -1.01380490e-01f, 6.55173957e-02f, 3.55788693e-02f, 1.29182087e-02f, 1.75047770e-01f, 3.08210519e-03f, 1.70631974e-03f, -1.47985846e-01f, -6.18410716e-03f, -1.38738409e-01f,
  -7.18980581e-02f, 3.70446406e-03f, 1.29437551e-01f, 5.96555434e-02f, 7.21685439e-02f, 9.94688272e-02f, -6.73743486e-02f, -2.61177104e-02f, -2.68117320e-02f, 2.42196862e-02f,
  1.13521233e-01f, 6.45082593e-02f, 7.42776841e-02f, -1.38081750e-02f, -4.23703007e-02f, 3.92626002e-02f, -2.38128081e-02f, 1.34942949e-01f, 8.57396945e-02f, 1.03061006e-03f,
  5.74511439e-02f, 3.31197418e-02f, 2.71855462e-02f, 8.50702748e-02f, 1.32211586e-02f, 5.70551753e-02f, 8.55975822e-02f, 6.10962957e-02f, 7.60845244e-02f, 4.21567634e-02f,
  1.14247769e-01f, 3.79834026e-02f, 2.82718930e-02f, -1.29081095e-02f, 5.77426255e-02f, 9.68476236e-02f, 3.95942596e-04f, 3.79795693e-02f, 3.11367251e-02f, 4.59473059e-02f,
  3.78460512e-02f, -2.72720717e-02f, 3.18359747e-03f, -2.37381719e-02f, 1.80825461e-02f, -1.43784015e-02f, -5.14556374e-03f, -7.43855024e-03f, 4.87395376e-02f, 2.35862937e-02f,
  -3.94235365e-02f, 7.92125147e-03f, -3.20262797e-02f, 4.50747162e-02f, -4.27793292e-03f, -1.88842230e-02f, -2.02256460e-02f, 1.36271100e-02f, 3.96590531e-02f, -3.98476869e-02f,
  2.93615721e-02f, -3.20285298e-02f, -1.94984078e-02f, 3.16039100e-02f, 7.33447215e-03f, 1.91622376e-02f, -5.53803332e-02f, 1.43757532e-03f, -2.14634882e-03f, 3.23618785e-03f,
  -2.27136821e-01f, -2.86993563e-01f, -2.01481208e-02f, -4.96835038e-02f, -2.22270228e-02f, -6.59319088e-02f, -7.68327294e-03f, -9.61766243e-02f, -4.47572730e-02f, 4.32198197e-02f,
  -5.34025393e-02f, 1.65869649e-02f, -5.33435233e-02f, 4.85221716e-03f, 4.33360110e-04f, -2.51893915e-04f, -8.08910280e-02f, -7.33853430e-02f, 4.10500262e-03f, -9.82495993e-02f,
  -9.66654569e-02f, -5.61945438e-02f, 1.15136644e-02f, 2.44971476e-02f, -7.62485936e-02f, 3.93326879e-02f, -8.85917246e-03f, -5.04495688e-02f, -7.55771436e-03f, 7.08530843e-03f,
  -3.04914806e-02f, 7.79531375e-02f, 1.64097875e-01f, 1.86717138e-02f, 1.40267164e-01f, -1.35940090e-01f, 1.75806154e-02f, 2.35630348e-01f, 9.05183852e-02f, 9.33815259e-03f,
  -2.51153558e-02f, -1.71203837e-01f, -1.03114108e-02f, -6.02784976e-02f, -3.50429833e-01f, -6.87059015e-02f, -1.40669541e-02f, 5.97951654e-03f, 6.09944053e-02f, 8.15272182e-02f,
  8.01310688e-02f, -9.35484841e-03f, -1.33656915e-02f, 8.73814076e-02f, 4.81624566e-02f, 2.56028503e-01f, -3.73452157e-02f, 5.42537980e-02f, -9.41898599e-02f, 4.18706648e-02f,
  -7.19371140e-02f, 3.32330950e-02f, 6.76658675e-02f, 7.85819720e-03f, 6.95535317e-02f, 4.76731062e-02f, 1.38710300e-02f, 6.80185715e-03f, -5.02916463e-02f, 2.68355035e-03f,
  -2.15126462e-02f, -2.18044631e-02f, -5.79964779e-02f, -1.50800794e-02f, 6.90659881e-02f, 6.77288994e-02f, 3.44543979e-02f, 4.66194972e-02f, 9.60464329e-02f, -2.73786522e-02f,
  8.83949548e-03f, 3.04180365e-02f, -2.33393395e-03f, -2.18675565e-02f, -8.07042513e-03f, -1.19908601e-02f, 2.96050613e-03f, 4.24148217e-02f, 3.07085905e-02f, 6.36439919e-02f,
  6.16117008e-02f, 8.51531699e-03f, -4.85376976e-02f, -8.79297033e-02f, -4.26910967e-02f, 2.52864752e-02f, -7.61629939e-02f, -6.59702346e-02f, 5.72549691e-03f, 5.90921789e-02f,
  9.45759530e-04f, -1.02586346e-02f, 8.03862810e-02f, -1.02389175e-02f, 1.65727269e-03f, 1.91485360e-02f, -1.16520505e-02f, 5.12154996e-02f, 1.87387299e-02f, 2.43014637e-02f,
  -5.18938489e-02f, 6.84954822e-02f, -1.30360350e-02f, 4.01710086e-02f, 7.29977246e-03f, 4.44320180e-02f, 2.03207135e-02f, 1.17078595e-01f, -1.31660979e-02f, 4.49508876e-02f,
  -1.05185218e-01f, 1.17331497e-01f, 2.02600583e-02f, -6.76751286e-02f, -3.69029604e-02f, -5.78039177e-02f, 2.01721191e-02f, -1.20301554e-02f, -7.51949986e-03f, -1.77438743e-02f,
  3.59607749e-02f, 1.12078488e-02f, 5.51587380e-02f, 9.98847187e-04f, -8.99515767e-03f, -4.51283455e-02f, -4.50865217e-02f, -6.19184412e-02f, 1.06196031e-02f, -2.67506391e-02f,
  -1.30576463e-02f, -5.18444255e-02f, 3.43805514e-02f, 4.04003784e-02f, -2.39094831e-02f, 1.48619786e-02f, -9.32403561e-03f, 2.84225587e-02f, -3.35504562e-02f, 3.84952966e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.47587669e-01f, 6.96869418e-02f, 3.61412168e-01f, -2.65292674e-01f, -9.59597602e-02f, 2.00481772e-01f, 3.36380392e-01f, -1.96519926e-01f, -2.79936582e-01f, 2.03055725e-03f,
  -8.79262388e-03f, 5.57146326e-04f, 3.55906665e-01f, 9.66400430e-02f, 1.86530530e-01f, 1.68234468e-01f, -4.27003838e-02f, 2.81654410e-02f, -4.78966199e-02f, -9.03761759e-02f,
  -4.82303947e-02f, -6.95156604e-02f, 3.11102390e-01f, -1.44213885e-01f, -1.75193399e-02f, -1.12155579e-01f, 5.13629802e-02f, 2.21377462e-01f, -5.21463603e-02f, 6.11195490e-02f,
  2.15965956e-02f, -1.78308412e-01f, 8.38493854e-02f, 1.49526317e-02f, -2.19232659e-03f, 3.97890732e-02f, 5.20875603e-02f, 7.73664415e-02f, -3.48087214e-02f, -8.40895548e-02f,
  -8.72771908e-03f, 3.44757829e-03f, -1.07230380e-01f, -1.25749810e-02f, -5.59736937e-02f, -1.22009926e-02f, -1.16350353e-02f, 4.39902246e-02f, 1.72862783e-02f, 1.17713198e-01f,
  4.27925736e-02f, 8.90731066e-02f, -3.02896202e-02f, -2.18466502e-02f, 8.18669796e-02f, 6.51444197e-02f, 8.27883719e-04f, 9.71205086e-02f, -1.23895667e-02f, -6.38920516e-02f,
  -1.07690707e-01f, -3.96538898e-02f, 2.93983109e-02f, -9.46791470e-02f, 4.56150919e-02f, -6.78105578e-02f, -2.02519558e-02f, 2.48329826e-02f, -3.08421440e-02f, 5.43349981e-02f,
  2.01058723e-02f, 1.56379025e-02f, 2.55585238e-02f, 1.31844338e-02f, -7.58944973e-02f, -8.11225083e-03f, -2.51189922e-03f, -2.42644977e-02f, -3.10368445e-02f, 4.36545499e-02f,
  -4.24033627e-02f, 3.89055572e-02f, 3.66489100e-03f, 2.10970081e-02f, 5.21405637e-02f, 9.12167430e-02f, -2.36364305e-02f, -2.72839926e-02f, -5.43290898e-02f, 1.21382006e-01f,
  -1.58323884e-01f, -1.91008076e-01f, -8.52809995e-02f, 7.24970698e-02f, -2.37562358e-02f, 1.57502759e-02f, -2.79945582e-02f, 2.36733370e-02f, -7.03214258e-02f, -1.95320100e-02f,
  1.73777584e-02f, -1.94813944e-02f, -6.46751095e-03f, -2.47832350e-02f, 6.38651699e-02f, -1.00422008e-02f, 5.88309020e-02f, -4.76916544e-02f, -7.16396198e-02f, -3.90045047e-02f,
  8.92878622e-02f, -6.78889230e-02f, 3.24907191e-02f, -9.13626403e-02f, -3.41752134e-02f, -4.37227041e-02f, -6.97043538e-02f, 3.00184488e-02f, 2.80095451e-02f, -4.05668728e-02f,
  4.97543206e-03f, -1.86205417e-01f, 1.66820437e-02f, -1.77257270e-01f, -9.97892395e-02f, -1.97672799e-01f, -3.99609618e-02f, 4.83954474e-02f, 2.11276580e-03f, -8.80950764e-02f,
  -9.42925066e-02f, 2.29086075e-02f, 9.86746922e-02f, -1.16726518e-01f, 3.24562453e-02f, 4.67084274e-02f, -9.30802152e-02f, -1.09324589e-01f, -2.86424365e-02f, -1.12746969e-01f,
  -1.23313449e-01f, -1.87369764e-01f, -1.24261361e-02f, -3.02120801e-02f, -7.35204667e-02f, -5.46374582e-02f, 2.26497836e-02f, -4.72288802e-02f, -1.00143611e-01f, 6.88100830e-02f,
  1.48466617e-01f, 2.11001530e-01f, 1.39774665e-01f, 5.87919448e-03f, 3.25605199e-02f, 1.00940190e-01f, -1.11127868e-02f, -2.47652065e-02f, 3.98942828e-02f, -6.36222735e-02f,
  -4.19413559e-02f, 3.13190371e-02f, -2.45189108e-02f, 8.79424736e-02f, -1.06409363e-01f, -3.33706327e-02f, -9.52455774e-02f, 3.98278162e-02f, 2.48619393e-02f, -1.70760807e-02f,
  4.76011448e-02f, 5.00628427e-02f, -1.40824793e-02f, -6.15469355e-04f, -2.37654578e-02f, -2.69523133e-02f, -4.10383046e-02f, 4.19065431e-02f, 9.07372013e-02f, -5.27617373e-02f,
  4.71933931e-02f, -9.45730358e-02f, 7.44733438e-02f, 7.23777488e-02f, -3.09000947e-02f, 5.80295958e-02f, 4.55904566e-02f, 3.31425443e-02f, -1.25823215e-01f, -1.10507598e-02f,
  -4.26808335e-02f, -3.24696749e-02f, 8.84490460e-02f, -1.80807896e-02f, -3.71774510e-02f, 2.39006765e-02f, -1.11218028e-01f, 6.82674199e-02f, -3.48265283e-04f, -5.16163036e-02f,
  -1.10596688e-02f, -7.48119177e-03f, -6.53660716e-03f, 1.25460960e-02f, 1.24891654e-01f, 6.87064901e-02f, 1.38767026e-02f, -7.53764510e-02f, 7.64477700e-02f, -2.71979030e-02f,
  -2.16590706e-02f, 3.51834483e-02f, 1.43045440e-01f, 9.18143317e-02f, 6.12429827e-02f, -3.06402761e-02f, 7.13977441e-02f, 8.39561000e-02f, 1.97712537e-02f, -3.58742699e-02f,
  -1.20936170e-01f, -7.61690512e-02f, -5.68646714e-02f, 1.97712984e-03f, -1.23706482e-01f, -9.83138382e-03f, 5.87394200e-02f, -1.52441964e-01f, -3.99943031e-02f, -6.68754429e-02f,
  8.42409953e-02f, 1.99905913e-02f, 2.81952303e-02f, 2.37018075e-02f, -4.67566885e-02f, -6.79633766e-02f, 6.61441237e-02f, 9.80471373e-02f, -7.61818187e-03f, 2.51040999e-02f,
  -3.81353241e-03f, -2.29857732e-02f, -1.01313749e-02f, -4.14066836e-02f, 6.78022057e-02f, -1.67320166e-02f, -7.71701485e-02f, 1.94995310e-02f, -8.18836875e-03f, -3.95257957e-02f,
  1.28974810e-01f, -5.90306818e-02f, 2.24329196e-02f, 1.31936269e-02f, -2.61289272e-02f, -6.07168414e-02f, -6.68212846e-02f, -6.43530190e-02f, -7.10901525e-03f, 1.22359745e-01f,
  -7.11062178e-03f, 1.86154410e-01f, 4.08410355e-02f, 1.11238778e-01f, 2.86383834e-03f, -6.45668507e-02f, 1.08115217e-02f, -2.19407585e-02f, -5.64314798e-02f, 5.25880978e-02f,
  -6.41203523e-02f, -2.04144642e-02f, -2.76351646e-02f, -5.37163839e-02f, 1.25714326e-02f, -8.74296203e-03f, -3.07737608e-02f, 7.18407482e-02f, 4.58705723e-02f, -6.87306523e-02f,
  1.87965129e-02f, 1.00410588e-01f, 8.73243157e-03f, 6.81551471e-02f, 6.71055019e-02f, 2.31928937e-02f, -4.01708707e-02f, -3.81312035e-02f, -8.03233534e-02f, -6.09529726e-02f,
  6.93983659e-02f, 7.39407837e-02f, -9.01660789e-03f, 7.03659207e-02f, -7.57825524e-02f, 6.13372773e-02f, -9.20288116e-02f, 7.84387738e-02f, 1.84616670e-02f, -6.09125420e-02f,
  7.33262450e-02f, -1.10811107e-02f, -7.24904537e-02f, -8.37058350e-02f, -5.71720898e-02f, 4.19627875e-02f, 7.36534595e-02f, -4.53468375e-02f, 4.90891896e-02f, -2.73370799e-02f,
  2.80481949e-02f, -7.51063824e-02f, -8.09922591e-02f, -1.82199513e-03f, 4.27808166e-02f, 2.17977371e-02f, 1.51026873e-02f, 1.78527422e-04f, 4.38486263e-02f, -1.40288724e-02f,
  -2.90173143e-02f, -1.48119722e-02f, 5.83680756e-02f, 4.93774526e-02f, -9.14854333e-02f, -8.24875906e-02f, 7.84183666e-02f, -7.73536712e-02f, -8.09273645e-02f, 1.23386290e-02f,
  4.97416332e-02f, 6.85415491e-02f, 7.22945854e-02f, 1.15753496e-02f, 7.33658746e-02f, 6.05934970e-02f, -1.01676524e-01f, -6.97573721e-02f, 8.95692930e-02f, 3.77216786e-02f,
  3.89852710e-02f, 2.12772768e-02f, -3.35115455e-02f, 8.11413676e-02f, -4.02241684e-02f, 6.98790140e-03f, -9.53174848e-03f, 6.03051223e-02f, -6.88859373e-02f, -6.98545128e-02f,
  -6.30237386e-02f, -7.40720704e-02f, -3.54422294e-02f, -1.44732455e-02f, 4.95904461e-02f, 1.06907357e-02f, -8.36255774e-02f, 3.22670788e-02f, -6.10794798e-02f, -7.80531839e-02f,
  6.11923523e-02f, 2.25516129e-02f, 1.04039773e-01f, 8.35517421e-02f, -4.81676534e-02f, 8.17811191e-02f, -1.07913598e-01f, 8.11235458e-02f, -6.32738918e-02f, -4.77805249e-02f,
  3.46246660e-02f, 1.32232457e-01f, 2.91762613e-02f, -1.53175099e-02f, 1.12497695e-01f, -7.08488002e-02f, 7.44595379e-02f, 1.10439740e-01f, 5.27828857e-02f, 8.72021616e-02f,
  5.46681695e-02f, -5.20269712e-03f, 9.27753672e-02f, 3.91756967e-02f, -5.12033850e-02f, 2.93782484e-02f, -3.88921089e-02f, 4.52772565e-02f, 1.88002661e-02f, 4.51852195e-02f,
  2.79004779e-03f, 7.14614987e-02f, 2.61359122e-02f, -8.61351006e-03f, 5.47631122e-02f, -2.27672551e-02f, 5.76997101e-02f, 5.32922223e-02f, -7.01848716e-02f, -8.50612745e-02f,
  5.95001206e-02f, 2.38972642e-02f, 3.62327578e-03f, -7.35708624e-02f, -1.74528360e-02f, 3.90567482e-02f, 3.91898975e-02f, 1.06541328e-01f, 7.97780813e-04f, 8.63161832e-02f,
  1.04163535e-01f, -8.67355391e-02f, 2.86085978e-02f, -8.11357722e-02f, 1.31331652e-03f, -2.13977825e-02f, 5.07431701e-02f, 7.65329897e-02f, 8.39373767e-02f, 9.70106944e-02f,
  -1.12875849e-01f, -2.04260293e-02f, -3.55097391e-02f, -1.06644779e-01f, 2.31337938e-02f, -8.22472647e-02f, 6.82644472e-02f, -4.20452468e-02f, 7.94610847e-03f, 2.16086656e-02f,
  1.05039338e-02f, -1.12118088e-01f, -1.31786382e-02f, -1.67095009e-02f, 3.39133963e-02f, 6.60668164e-02f, 4.60850634e-02f, -7.11609796e-02f, -2.01108940e-02f, -2.79436707e-02f,
  5.68534993e-02f, 2.52342131e-02f, 6.87676519e-02f, -7.30590075e-02f, -1.22790327e-02f, -4.56994884e-02f, 6.92187920e-02f, 5.16270101e-02f, -1.23822428e-01f, 9.66850892e-02f,
  -1.60075985e-02f, -1.06829241e-01f, 5.60270436e-02f, -2.46530436e-02f, 5.71085233e-03f, 2.77255736e-02f, -4.64406647e-02f, 6.62344918e-02f, 8.29790458e-02f, -8.95547643e-02f,
  -7.16302544e-02f, -9.31933075e-02f, -3.18202865e-03f, -1.03654295e-01f, 7.17296675e-02f, -2.69652866e-02f, 2.85682771e-02f, 9.11191478e-02f, 1.02405712e-01f, -1.32150296e-02f,
  5.78484870e-02f, 7.41765276e-02f, 7.20332041e-02f, -5.70168756e-02f, -5.03954254e-02f, 6.92564473e-02f, 2.23933291e-02f, 1.06450185e-01f, -2.53641466e-03f, -3.82832438e-02f,
  -6.72167465e-02f, 8.60328227e-02f, 1.61164120e-01f, -1.21073239e-01f, 4.35768552e-02f, 8.32114145e-02f, 3.25811468e-02f, 2.39890907e-02f, 6.41549425e-03f, -7.16733932e-02f,
  9.38333664e-03f, -3.82041745e-02f, -2.88843792e-02f, 7.92784616e-02f, 1.30486950e-01f, -1.76422447e-02f, -2.97493581e-02f, -5.75159639e-02f, -5.23155816e-02f, -8.61917734e-02f,
  8.83709732e-03f, -3.53192464e-02f, 1.15406260e-01f, 2.45549232e-02f, -2.40119603e-02f, -8.24868381e-02f, -4.41779047e-02f, 6.86797872e-02f, 4.31952663e-02f, -1.76007468e-02f,
  -1.99378133e-02f, 2.47665867e-02f, -6.55348524e-02f, -2.11848654e-02f, -8.32148418e-02f, 3.03170271e-02f, -3.67556885e-02f, 7.71548375e-02f, 3.48099805e-02f, -3.11117843e-02f,
  -2.84816213e-02f, -7.77229890e-02f, 5.07299788e-02f, -9.45304483e-02f, 3.12539167e-03f, -2.30435398e-03f, -4.91941795e-02f, -7.75751248e-02f, -4.14052941e-02f, 5.45223281e-02f,
  -6.02382608e-02f, -1.39538050e-02f, 2.93734968e-02f, 7.16486666e-03f, 4.50083800e-02f, -9.46039110e-02f, 6.66642189e-02f, 1.07444458e-01f, 5.92044070e-02f, -1.47406636e-02f,
  1.27959877e-01f, -7.15009421e-02f, -3.63341793e-02f, -6.77957088e-02f, -5.62859513e-02f, 5.79063259e-02f, 5.11082225e-02f, -5.70503548e-02f, -2.70154271e-02f, -5.72117791e-02f,
  -3.97280231e-02f, -5.82146309e-02f, -3.62195410e-02f, -1.17342591e-01f, 4.36858796e-02f, 9.91572291e-02f, -3.63174006e-02f, -6.94572255e-02f, 6.45582005e-02f, 6.54228777e-02f,
  1.06376424e-01f, -8.27486441e-02f, 5.44738770e-02f, -2.77601033e-02f, -7.69825205e-02f, 5.10209724e-02f, 2.41916496e-02f, 4.36517112e-02f, 1.85265951e-02f, 8.40006843e-02f,
  -6.58384562e-02f, -6.09248430e-02f, -5.36576807e-02f, -8.99282545e-02f, 2.14674119e-02f, 7.38264024e-02f, 5.32728098e-02f, 7.14492872e-02f, -3.85020003e-02f, -5.06595261e-02f,
  -3.55702713e-02f, -1.16727106e-01f, -2.42458042e-02f, -4.46687080e-02f, -1.12209162e-02f, -4.23505008e-02f, 8.29719827e-02f, 7.97024090e-03f, -6.26759380e-02f, -2.83390116e-02f,
  -1.09706827e-01f, 4.67860587e-02f, 3.09570376e-02f, -9.44764167e-02f, -1.86852310e-02f, -6.46755770e-02f, -1.51485614e-02f, -2.19065906e-03f, -6.30844533e-02f, -3.20885070e-02f,
  4.77686971e-01f, -7.22665489e-02f, -1.97090864e-01f, 1.89479336e-01f, -3.03115100e-02f, -1.14558019e-01f, -3.73385280e-01f, 1.34733349e-01f, -3.00763756e-01f, -1.27358008e-02f,
  2.90334225e-01f, -2.30258759e-02f, -1.46749482e-01f, 3.52363348e-01f, 3.65624875e-01f, -8.99093822e-02f, 1.65098891e-01f, 5.88476956e-02f, -1.55189574e-01f, 2.59607453e-02f,
  1.77798763e-01f, 3.55218917e-01f, 2.28811413e-01f, 3.77007306e-01f, 1.75254658e-01f, 1.19148873e-01f, 3.53542358e-01f, -6.25368804e-02f, 3.45238388e-01f, 2.51916081e-01f,
  -7.85510466e-02f, -7.00916126e-02f, -2.73402426e-02f, 3.40176485e-02f, 2.09630243e-02f, 2.75150910e-02f, -9.79447588e-02f, 7.69851059e-02f, -1.02561347e-01f, -3.52974422e-02f,
  -5.15052155e-02f, -2.36741337e-03f, 6.34921864e-02f, 3.21710259e-02f, -1.51340123e-02f, -3.70680206e-02f, -2.62019634e-02f, -5.66202141e-02f, -1.38722539e-01f, -1.74913220e-02f,
  -1.12145931e-01f, 2.18210667e-02f, -2.97224266e-03f, 4.60980274e-03f, -1.42321400e-02f, -2.30392441e-02f, -1.37944184e-02f, -8.04467574e-02f, 1.57158244e-02f, 1.10859098e-02f,
  5.61896078e-02f, -5.44304736e-02f, 8.89248475e-02f, -1.80959366e-02f, 4.56921495e-02f, -3.69348587e-03f, 1.48653518e-02f, -1.08589549e-02f, -6.96004331e-02f, 1.16305640e-02f,
  8.94535985e-03f, -3.76284085e-02f, -5.58096953e-02f, 1.41623421e-02f, 4.17572968e-02f, -9.63900518e-03f, 6.89283013e-02f, 9.74624604e-03f, -8.64800960e-02f, -9.52124074e-02f,
  3.23270522e-02f, 2.84003618e-04f, -4.37929481e-02f, -4.84546088e-03f, 3.23224738e-02f, 5.33776581e-02f, 5.40286079e-02f, 1.50332898e-02f, -8.61268118e-02f, 3.24714221e-02f,
  3.53138074e-02f, 1.00770153e-01f, -7.33946487e-02f, -1.18290856e-02f, -5.53948954e-02f, 9.14110336e-03f, 4.78189811e-02f, 4.47913557e-02f, 6.28214255e-02f, 8.89652595e-03f,
  6.42352039e-03f, 1.60610192e-02f, -4.93760081e-03f, -3.69638093e-02f, 8.17487985e-02f, -1.46965804e-02f, -9.35164932e-03f, -1.57586541e-02f, 8.11270922e-02f, 2.30922475e-02f,
  8.11694469e-03f, -1.05189309e-01f, 1.24324183e-03f, 2.43387930e-02f, -3.53117436e-02f, -1.05189802e-02f, -1.10409188e-03f, 5.25973849e-02f, 4.90052477e-02f, -7.77044753e-03f,
  2.84238756e-01f, -2.38373503e-01f, -8.21443573e-02f, -1.25382515e-02f, 7.68419951e-02f, 1.07923105e-01f, 1.16446912e-01f, -6.69909045e-02f, -1.16365999e-01f, -1.92179427e-01f,
  -1.54236136e-02f, -3.96397188e-02f, -4.18113284e-02f, 7.28341937e-02f, 1.50848940e-01f, -1.03002638e-02f, 6.69902489e-02f, 4.70054820e-02f, -9.54009518e-02f, -6.83791190e-02f,
  1.85980997e-03f, 7.56901652e-02f, -6.83610588e-02f, 2.07893439e-02f, 1.43592864e-01f, -7.73854405e-02f, -4.23431732e-02f, 9.04511958e-02f, -3.62106748e-02f, 8.63610432e-02f,
  7.91290477e-02f, -1.53089911e-01f, 1.11219406e-01f, 3.00632399e-02f, -1.31245786e-02f, 2.04737391e-02f, -3.67058069e-02f, 5.49299307e-02f, 1.02312304e-01f, -7.06845671e-02f,
  1.87716689e-02f, 5.18597588e-02f, -7.42762908e-02f, -3.73902805e-02f, 4.04633768e-02f, 1.90379340e-02f, -3.72551307e-02f, -2.92936079e-02f, -1.17329493e-01f, -5.60571216e-02f,
  -2.60776915e-02f, -7.12697580e-02f, 1.29993986e-02f, -9.22588184e-02f, 7.13307271e-03f, -9.52008963e-02f, -2.80114496e-03f, 6.61126524e-02f, -2.47484595e-02f, -2.12382302e-02f,
  -9.00729373e-02f, 1.34509757e-01f, -4.12146822e-02f, 3.79555821e-02f, 1.69958384e-03f, -6.52748197e-02f, 7.94038922e-02f, -4.55600806e-02f, 5.95031157e-02f, 1.29041576e-03f,
  1.63305905e-02f, -1.15435505e-02f, 7.73458481e-02f, 2.42825039e-03f, 3.65630072e-03f, -2.39348914e-02f, 9.65631753e-02f, 2.36668848e-02f, 5.52104004e-02f, 6.48731645e-03f,
  1.79031733e-02f, -3.96779627e-02f, 5.87124601e-02f, -2.48383097e-02f, -2.23149545e-02f, -4.31603082e-02f, 7.38564227e-03f, 4.52349819e-02f, 2.48020738e-02f, -3.75593975e-02f,
  -1.09805726e-01f, -1.59728542e-01f, -6.39039502e-02f, -1.46838063e-02f, -5.74774779e-02f, 1.24480724e-01f, -6.42980412e-02f, 8.42393283e-03f, -5.40216379e-02f, -8.73105749e-02f,
  -3.96959595e-02f, 3.73843275e-02f, -9.49070603e-03f, 5.57286777e-02f, 1.39810219e-02f, 8.14340427e-04f, 2.67044995e-02f, 7.76037201e-02f, 9.25273597e-02f, -1.04477122e-01f,
  -1.35000683e-02f, 4.11800481e-02f, 6.61588982e-02f, 3.39201428e-02f, -1.58520434e-02f, 2.61121746e-02f, -5.50745279e-02f, 1.14431689e-02f, 1.24313198e-02f, -6.70609251e-02f,
  -3.86670530e-02f, 1.84235424e-02f, -8.40296820e-02f, 1.58681776e-02f, -1.59889888e-02f, 8.97044614e-02f, -4.35573086e-02f, 7.43574277e-02f, 2.61332635e-02f, 1.67856947e-01f,
  -1.76086631e-02f, -2.07650568e-02f, -4.79172058e-02f, 1.62084326e-01f, 1.51199088e-01f, -1.86599679e-02f, 2.32092693e-01f, 4.41467203e-02f, 1.86393354e-02f, 7.29015619e-02f,
  4.10902128e-02f, 1.39811918e-01f, 5.78320287e-02f, 1.15111820e-01f, -2.71657575e-02f, -2.46043615e-02f, 1.86701834e-01f, -1.59094110e-01f, 3.52844782e-02f, -6.11134842e-02f,
  1.74361153e-03f, -6.06230460e-02f, 8.44227523e-03f, -1.08972892e-01f, -8.59984979e-02f, -1.22360379e-01f, -7.40724653e-02f, 5.53608015e-02f, 3.16331796e-02f, -4.88608936e-03f,
  2.35216431e-02f, 3.36234272e-02f, -6.78677708e-02f, 7.47288764e-02f, -7.41008073e-02f, 5.96950613e-02f, 4.10733782e-02f, -1.00417407e-02f, 1.18286654e-01f, -9.40599367e-02f,
  -5.33886291e-02f, -1.08369738e-02f, -8.89240056e-02f, 6.16393760e-02f, 5.40439524e-02f, -7.20359981e-02f, -7.88637847e-02f, 5.64451665e-02f, 1.27270594e-02f, 7.06173405e-02f,
  9.35930107e-03f, -8.84472281e-02f, -1.66773498e-02f, 8.07934254e-02f, 1.12948557e-02f, 1.65489819e-02f, -6.40228838e-02f, -6.89228484e-03f, 5.06605469e-02f, 8.93009156e-02f,
  2.83040274e-02f, 5.83269969e-02f, -1.80783384e-02f, -5.01508825e-02f, -7.91153088e-02f, 4.08485569e-02f, -1.27890483e-01f, 6.42228872e-02f, 6.82468787e-02f, -5.88849327e-03f,
  2.40361001e-02f, 3.14323865e-02f, -4.28932607e-02f, -6.70141056e-02f, 1.13961324e-01f, 6.14436343e-03f, 4.21311036e-02f, 3.99332754e-02f, 1.02580301e-02f, -6.18001111e-02f,
  -8.49346537e-03f, 1.27313003e-01f, 3.87275033e-02f, 4.18552905e-02f, 1.74664310e-03f, 4.79790866e-02f, 4.92552035e-02f, -1.49322385e-02f, 2.14241091e-02f, 4.09869812e-02f,
  2.61899978e-02f, -8.99653956e-02f, -6.03038371e-02f, 6.98908195e-02f, 2.95193959e-02f, 8.66471007e-02f, 3.89029086e-02f, -2.47790888e-02f, 4.34021242e-02f, 1.36444829e-02f,
  -6.73837736e-02f, -1.09277805e-02f, 9.68756080e-02f, -8.38720147e-03f, 6.77619176e-03f, -1.13861397e-01f, -2.37323041e-03f, -1.27891019e-01f, -3.77916545e-02f, 3.34436446e-02f,
  4.82191704e-03f, -3.57714631e-02f, -2.18866125e-01f, -4.42119054e-02f, 5.66505492e-02f, 9.98660922e-02f, -7.18287379e-02f, 1.77659038e-02f, -1.72151864e-01f, 1.54467255e-01f,
  5.94585016e-02f, 2.76212525e-02f, 3.54792215e-02f, -1.52208194e-01f, -7.13108405e-02f, -1.32726774e-01f, 1.35252504e-02f, -1.50524089e-02f, -6.46266788e-02f, 1.68913439e-01f,
  -3.45689431e-02f, 3.99218760e-02f, -1.48361266e-01f, -1.26627758e-02f, -6.45239726e-02f, 4.33754474e-02f, 1.86085463e-01f, -1.63544174e-02f, 1.01677649e-01f, -6.03140704e-02f,
  -3.29153948e-02f, -1.18730135e-01f, -9.46297571e-02f, -1.98347792e-02f, 7.87115768e-02f, 1.22459196e-01f, 6.25420287e-02f, -1.50224566e-02f, -6.31933585e-02f, -5.37937991e-02f,
  -1.04536917e-02f, -3.12055349e-02f, -1.07969128e-01f, 2.48802248e-02f, 7.91732892e-02f, -8.68990272e-02f, -9.87388715e-02f, -3.29765044e-02f, 2.95737628e-02f, -1.34332003e-02f,
  -5.04569709e-02f, 5.35801910e-02f, 7.04607293e-02f, -3.73592824e-02f, -1.22962566e-02f, 4.32335734e-02f, 5.45226689e-03f, 2.88596600e-02f, -2.24595014e-02f, -5.00054695e-02f,
  3.51719297e-02f, 3.30231935e-02f, 6.08738512e-02f, -1.93463489e-02f, -5.53505011e-02f, 5.28074875e-02f, 3.56715024e-02f, 8.80203322e-02f, 5.65754808e-02f, 4.29501198e-02f,
  -6.53363764e-03f, 4.63484824e-02f, -6.70136288e-02f, 1.53945358e-02f, 1.91764510e-03f, -4.30813991e-02f, 6.13769330e-02f, 2.17298139e-02f, 5.38311116e-02f, -4.50644419e-02f,
  -5.61632402e-03f, -5.67337461e-02f, -3.90288606e-02f, 2.49154419e-02f, -5.83013482e-02f, 4.42505591e-02f, -6.87761605e-03f, -6.17620908e-02f, 5.85581437e-02f, 6.69362396e-02f,
  4.53558564e-02f, 1.14464052e-01f, -2.29796786e-02f, -6.95481226e-02f, 6.66917935e-02f, -7.85727892e-03f, 3.57141308e-02f, -5.76208206e-03f, 1.74641721e-02f, 3.23356539e-02f,
  1.19099123e-02f, 7.86274821e-02f, 1.02465644e-01f, 6.87266048e-03f, 7.91817158e-02f, 5.15606739e-02f, 4.80489433e-02f, 5.96859604e-02f, 2.86138058e-02f, 5.65791549e-03f,
  5.63312620e-02f, 6.87662065e-02f, 1.01125792e-01f, 6.92698434e-02f, -4.94800247e-02f, 1.04077548e-01f, 3.24247815e-02f, -1.84479468e-02f, -1.63385943e-02f, 3.59353684e-02f,
  5.30229211e-02f, 4.93473671e-02f, 1.89549923e-01f, 1.30959954e-02f, 9.19504017e-02f, 1.36811703e-01f, 2.62247603e-02f, -2.87611745e-02f, 1.33912891e-01f, -4.03676443e-02f,
  -1.71023309e-02f, 2.48379186e-02f, -7.13672042e-02f, -3.84233408e-02f, -1.17492452e-01f, 9.00079980e-02f, -4.02646139e-02f, 9.92650837e-02f, 1.54821873e-01f, -6.42613275e-04f,
  2.68845772e-03f, 4.52896468e-02f, 6.27587959e-02f, -5.31260557e-02f, -2.13955566e-02f, -6.85434043e-02f, -7.51634687e-02f, -4.89774207e-03f, -3.87060754e-02f, -3.29068489e-02f,
  -8.76518711e-02f, 4.74174805e-02f, -1.21013530e-01f, -8.86261016e-02f, -6.93045184e-02f, 1.29267480e-02f, -1.15955673e-01f, -8.37539285e-02f, -2.83559281e-02f, -2.60950159e-02f,
  -5.87401912e-02f, -4.37739305e-02f, -4.60441709e-02f, -4.73677404e-02f, -8.34113806e-02f, -5.87414391e-02f, 1.14445992e-01f, 8.28250349e-02f, 7.67549947e-02f, 9.26255733e-02f,
  9.43412110e-02f, 4.51343171e-02f, -3.97306979e-02f, -5.58701605e-02f, -2.99827959e-02f, -5.99109046e-02f, 1.70625728e-02f, -7.92889595e-02f, -6.77815974e-02f, -8.73645023e-02f,
  -5.34337386e-02f, 5.94350807e-02f, -3.04018464e-02f, -4.15705256e-02f, 5.32772839e-02f, 4.38100146e-03f, -4.22988385e-02f, -8.73454362e-02f, 7.85474479e-02f, 1.00930464e-02f,
  -1.01237148e-01f, 4.86439764e-02f, 3.03106271e-02f, -3.75669040e-02f, -6.83862418e-02f, -6.11680001e-02f, 7.90211558e-02f, 2.09341142e-02f, -5.95279271e-03f, -5.70773371e-02f,
  2.39545703e-02f, 4.29273248e-02f, -5.44577464e-02f, 2.73146499e-02f, -4.26883921e-02f, 3.22820209e-02f, -6.39105141e-02f, 2.41664350e-02f, 3.68488766e-02f, -1.00675583e-01f,
  -8.48110765e-02f, 1.90211348e-02f, -1.12220101e-01f, -8.05913359e-02f, -2.98296753e-02f, 6.53889310e-03f, -9.03041437e-02f, 6.02430999e-02f, -1.20111322e-03f, 7.02420324e-02f,
  -2.82670744e-02f, 5.44269085e-02f, -1.01943698e-03f, -4.28596660e-02f, 4.06740904e-02f, 3.92668992e-02f, -3.24824899e-02f, 4.20557149e-02f, -8.90042186e-02f, -6.39669821e-02f,
  -1.15452088e-01f, -3.29812779e-03f, 2.52749510e-02f, -2.32383274e-02f, -2.74572279e-02f, 2.63737068e-02f, -7.53814401e-03f, 1.70270521e-02f, -1.51334386e-02f, -7.17948601e-02f,
  2.66162902e-02f, -3.24195921e-02f, -1.26485497e-01f, 5.71739376e-02f, 6.87435865e-02f, 1.02468170e-01f, 3.17829549e-02f, -4.03308906e-02f, -4.01012562e-02f, 1.39290523e-02f,
  -3.99294049e-02f, -1.27747399e-03f, -1.24751851e-01f, -1.56533763e-01f, -1.93771556e-01f, -1.94345966e-01f, -6.06944412e-02f, -3.14519107e-02f, -7.74095729e-02f, 2.62730327e-02f,
  4.88419831e-02f, -6.47386089e-02f, 6.74425140e-02f, 5.93823269e-02f, 2.34383997e-02f, 1.37892321e-01f, -1.16108423e-02f, -9.65447724e-03f, -7.80523056e-03f, 4.90013100e-02f,
  -9.37258229e-02f, -5.31224941e-05f, 4.74010631e-02f, 4.40874547e-02f, 5.80829643e-02f, 1.10567026e-01f, -2.57591251e-02f, -4.71732616e-02f, 1.31085981e-02f, 2.37363223e-02f,
  8.35056230e-03f, 1.32707609e-02f, -2.46994067e-02f, 4.27749492e-02f, 9.12679955e-02f, -9.11407769e-02f, -3.45104896e-02f, -5.80148622e-02f, 4.73080501e-02f, 6.24576630e-03f,
  4.79401611e-02f, 5.12171537e-02f, 3.45794372e-02f, -1.54094277e-02f, -6.34027198e-02f, 1.41088031e-02f, -9.55340713e-02f, -9.39439237e-02f, -1.49386358e-02f, 3.42345387e-02f,
  -3.39659862e-02f, -9.70214978e-03f, -6.03955276e-02f, 3.14176120e-02f, -5.60090840e-02f, -1.33298775e-02f, -8.32267255e-02f, 5.33184931e-02f, 9.14979056e-02f, 4.00030874e-02f,
  1.66765619e-02f, 3.89286899e-03f, -5.51379770e-02f, -4.67506498e-02f, -3.50978151e-02f, 6.09928407e-02f, 5.83701916e-02f, 6.53536767e-02f, 7.93253444e-03f, 5.00340760e-03f,
  6.82806596e-02f, -3.83023545e-02f, 3.85417528e-02f, -1.75664872e-02f, -1.56696085e-02f, 7.23830312e-02f, -4.79469709e-05f, -6.72295764e-02f, 7.08993748e-02f, 3.82468402e-02f,
  4.54931930e-02f, 4.27980954e-03f, -5.62553410e-04f, 3.53080928e-02f, -6.48509152e-03f, 1.78866349e-02f, 3.84235010e-02f, -4.21848521e-02f, 2.82923807e-04f, -2.68522394e-03f,
  1.28988460e-01f, 7.62191117e-02f, -1.00811847e-01f, -3.47933099e-02f, 6.83694705e-02f, 1.53542394e-02f, 1.26768099e-02f, 4.53688167e-02f, -2.70441566e-02f, 6.28224388e-02f,
  1.38803665e-02f, 9.45815444e-03f, -6.36009723e-02f, 7.99776688e-02f, -6.49718717e-02f, 8.43179673e-02f, 3.82709689e-02f, -3.07244994e-02f, 1.09142978e-02f, 2.17175931e-02f,
  2.58959323e-01f, 4.43367898e-01f, 4.31941599e-01f, 2.34952271e-01f, -2.24593818e-01f, -5.61429381e-01f, -3.33484799e-01f, -2.01598406e-02f, -8.03840309e-02f, 9.28736944e-03f,
  -1.55268013e-01f, 3.23878378e-01f, 2.14426182e-02f, 1.88843489e-01f, -3.12940925e-01f, -2.25691572e-02f, 4.78278175e-02f, -6.34130649e-03f, -8.64171609e-02f, 1.50993004e-01f,
  1.44751435e-02f, -1.94469884e-01f, 2.51404285e-01f, -3.66846807e-02f, 1.21187322e-01f, 2.22982720e-01f, -3.93197574e-02f, 3.77401784e-02f, 1.69708848e-01f, -9.58983228e-02f,
  -9.85283405e-02f, 1.54930614e-02f, 1.46104768e-01f, -3.03257238e-02f, -3.88956591e-02f, -3.17560025e-02f, 5.38462996e-02f, -5.63538820e-02f, -4.60439874e-03f, -3.70644704e-02f,
  5.78764826e-04f, -4.96011227e-02f, -3.93754728e-02f, -1.76267549e-02f, -1.21354787e-02f, 3.84206846e-02f, 8.27401504e-02f, 1.60382558e-02f, 8.12346116e-02f, 8.18564668e-02f,
  1.10415079e-01f, -9.89365764e-03f, 2.44334899e-02f, -1.87003985e-02f, 6.50289357e-02f, 5.53051708e-03f, -1.36239240e-02f, 8.50503147e-02f, 1.22470623e-02f, 2.26978064e-02f,
  2.66050710e-03f, -2.94096768e-02f, -5.76239564e-02f, 3.22865248e-02f, 3.05909757e-02f, -4.38131951e-02f, -4.89934385e-02f, -8.31590146e-02f, -3.30726169e-02f, -5.62805757e-02f,
  -5.29076904e-02f, 8.89903530e-02f, -6.54436946e-02f, 3.16344462e-02f, 3.64642367e-02f, -3.75559065e-03f, -2.28157714e-02f, -5.62692992e-02f, 1.15502859e-03f, 5.75661473e-02f,
  -8.32777321e-02f, -5.93513064e-02f, 3.32988203e-02f, 4.89102863e-02f, -4.57009859e-02f, 2.73094214e-02f, 5.84597327e-02f, 1.75062604e-02f, 4.30941507e-02f, -7.85825551e-02f,
  -2.11395603e-03f, 6.72243387e-02f, 2.28710826e-02f, 4.03149687e-02f, -1.99688338e-02f, -2.53474154e-02f, -1.42883107e-01f, 5.54412156e-02f, 2.03446820e-02f, -9.28584784e-02f,
  -4.30591516e-02f, -2.99315266e-02f, -5.73311700e-03f, 2.70875935e-02f, -1.47103602e-02f, -3.01187485e-02f, -1.28610879e-02f, 3.99656035e-03f, 3.10149342e-02f, 4.13081124e-02f,
  8.82136971e-02f, -1.44404158e-01f, -9.35633108e-02f, -4.44459245e-02f, -2.57526170e-02f, -5.00641428e-02f, -2.08010282e-02f, 5.30063473e-02f, -6.77203611e-02f, -8.95914435e-03f,
  -6.27856016e-01f, 1.99977249e-01f, -1.73854575e-01f, -3.43173504e-01f, -1.82314530e-01f, -2.85639554e-01f, -2.79473215e-01f, -1.16881803e-01f, -2.78469563e-01f, 1.20452717e-02f,
  -8.32541808e-02f, -3.91859375e-02f, 9.83626619e-02f, 1.75299216e-02f, -1.09873906e-01f, 3.01150650e-01f, -9.48812515e-02f, -2.04114869e-01f, 1.85387239e-01f, -1.88716039e-01f,
  -1.10758550e-01f, 1.79635957e-02f, 1.15157194e-01f, 1.34665787e-01f, -1.72488958e-01f, -1.39455408e-01f, 8.94699339e-03f, 5.88657558e-02f, -3.20408791e-02f, 5.26799895e-02f,
  -2.56047368e-01f, -1.09923996e-01f, -1.45397112e-01f, -7.61216432e-02f, -1.65841922e-01f, -8.82190093e-02f, -6.09756671e-02f, -2.13430990e-02f, -5.96936345e-02f, -3.75955142e-02f,
  1.11661376e-02f, -2.62230057e-02f, -5.94755933e-02f, 4.32763658e-02f, -4.64110309e-03f, 2.23661512e-02f, 7.54133761e-02f, -2.14202572e-02f, -5.38608879e-02f, 5.25223389e-02f,
  3.77576277e-02f, 2.80408934e-02f, -1.37828775e-02f, -3.58247384e-02f, 1.62275657e-02f, 5.79049736e-02f, 3.87237854e-02f, -4.44432646e-02f, -1.09188870e-01f, -3.68518941e-02f,
  8.52812305e-02f, -2.32466329e-02f, -4.91618477e-02f, 1.85045265e-02f, -1.81200225e-02f, -1.44445314e-03f, -4.10890430e-02f, -2.02234928e-02f, -2.32160301e-03f, 5.26042171e-02f,
  -1.71104111e-02f, 3.04860150e-04f, -2.46107411e-02f, -2.52309665e-02f, -4.00830247e-02f, -1.45899141e-02f, 1.31743131e-02f, 2.13910472e-02f, -5.08905165e-02f, 3.25132385e-02f,
  -2.39962358e-02f, -1.70278419e-02f, 6.70598447e-02f, -2.04612277e-02f, -4.01761979e-02f, 4.95403111e-02f, 3.54726128e-02f, 8.55917037e-02f, -3.28417355e-03f, -2.77966857e-02f,
  -4.62084800e-01f, -4.18432713e-01f, -4.06541377e-02f, -9.68835130e-02f, 4.53029051e-02f, 2.36894097e-02f, 3.60727422e-02f, -5.53846769e-02f, -7.11600184e-02f, -2.94067953e-02f,
  -8.03158730e-02f, 2.49665286e-02f, -9.61567312e-02f, 7.80488551e-03f, 6.26282021e-02f, -2.68224515e-02f, -1.08518355e-01f, -8.63187984e-02f, -7.05045015e-02f, 6.72484608e-03f,
  -7.83206895e-02f, -1.79280788e-02f, -1.94997847e-04f, 1.53921666e-02f, 1.39929364e-02f, -2.26579849e-02f, -1.80781797e-01f, -4.88218851e-02f, -4.94208187e-03f, 8.13304447e-03f,
  -1.17492825e-02f, 1.13688372e-01f, 1.11403055e-01f, -6.62140921e-02f, 5.00781089e-02f, 1.04928918e-01f, -8.57695341e-02f, 4.70260307e-02f, 7.16514662e-02f, 4.22876999e-02f,
  -9.11793187e-02f, 1.08051203e-01f, -3.51180062e-02f, -1.21506732e-02f, 4.06804979e-02f, -2.24159821e-03f, -4.00864519e-02f, -8.69932547e-02f, 4.13443595e-02f, 6.00531325e-03f,
  2.74040792e-02f, -3.77313271e-02f, 1.00735510e-02f, 5.17342053e-02f, 1.30705284e-02f, -4.25750092e-02f, -1.72900960e-01f, 6.30170554e-02f, 2.92147305e-02f, 4.65311930e-02f,
  -7.23077208e-02f, -1.29438445e-01f, 1.00108802e-01f, 4.99546938e-02f, -6.63499534e-02f, -6.37220368e-02f, -1.67431877e-04f, 7.74286613e-02f, 6.59935102e-02f, 7.47255906e-02f,
  5.24962097e-02f, 4.13680822e-02f, -8.10214579e-02f, -2.58801822e-02f, 4.13106456e-02f, -5.86479008e-02f, 9.63922963e-02f, 1.07739970e-01f, 1.12098321e-01f, -3.90388467e-03f,
  -2.61728466e-02f, 3.50381620e-02f, 3.09291035e-02f, -6.13184199e-02f, -9.92143713e-03f, 7.75646195e-02f, 5.76411234e-03f, 1.25865666e-02f, 6.71053752e-02f, -2.67681461e-02f,
  -2.83704735e-02f, -1.38476193e-02f, 5.96084073e-02f, 5.89534715e-02f, 5.73406108e-02f, -1.95661709e-02f, -4.33611795e-02f, 2.35722773e-02f, 5.96902594e-02f, 3.91362272e-02f,
  -1.74047276e-02f, 4.12530638e-02f, 2.47142240e-02f, -8.46475363e-02f, 6.32750988e-02f, -3.03030889e-02f, 4.99091819e-02f, -1.30784018e-02f, -7.46720955e-02f, -2.02282537e-02f,
  -2.39034183e-02f, -9.16245505e-02f, 3.61485444e-02f, 3.46564204e-02f, -1.15195382e-02f, 5.87709285e-02f, -3.90180945e-02f, 7.79008269e-02f, -1.00422136e-01f, -9.42110792e-02f,
  -8.43488425e-02f, -1.54603451e-01f, -2.70671807e-02f, 6.54265052e-03f, 7.22363219e-02f, -1.54329622e-02f, 4.72331457e-02f, -4.46123676e-03f, -2.07838546e-02f, 9.05699953e-02f,
  -3.80604826e-02f, -2.99762040e-02f, 1.85801983e-02f, -6.60943687e-02f, 2.28199456e-02f, 2.90745068e-02f, -4.25925246e-03f, -1.00574549e-02f, 8.21984485e-02f, 3.72487940e-02f,
  1.62874982e-02f, -7.62454420e-02f, 4.36301790e-02f, 2.79029347e-02f, -5.00533991e-02f, -3.15756239e-02f, -7.50408648e-03f, -2.41432781e-03f, -9.26067308e-02f, 5.63725717e-02f,
  6.06759600e-02f, -2.21539989e-01f, -2.15350315e-01f, -5.85170649e-02f, -1.10060006e-01f, -2.31992707e-01f, -3.33067417e-01f, -1.33689806e-01f, 1.59480739e-02f, 5.30157499e-02f,
  -1.66337922e-01f, 8.83562341e-02f, 6.97442889e-02f, -2.59908676e-01f, 7.50345364e-02f, 1.57451004e-01f, -3.48011255e-01f, 4.05297913e-02f, 1.21721514e-02f, -1.72457471e-01f,
  -4.09975238e-02f, -7.93336332e-02f, -5.45268655e-02f, -8.59832242e-02f, -2.80575007e-01f, -4.33808602e-02f, 2.17397258e-01f, -1.82648033e-01f, -5.90072647e-02f, -6.89997077e-02f,
  2.06764173e-02f, 8.83224756e-02f, -1.34796783e-01f, 4.41694334e-02f, -1.87143404e-02f, -5.92337325e-02f, -4.41197343e-02f, 2.93635372e-02f, -2.18705516e-02f, -3.74934450e-02f,
  5.02297431e-02f, 3.94239463e-02f, -7.62734339e-02f, -1.18945181e-01f, -8.19147378e-02f, -5.86147532e-02f, -4.51602526e-02f, -1.14542441e-02f, -4.83068712e-02f, 8.78289267e-02f,
  -3.89927439e-02f, -1.45450588e-02f, -8.17778409e-02f, 8.50296617e-02f, -4.56050448e-02f, -1.99332952e-01f, 4.21145074e-02f, 4.60093319e-02f, 3.51315476e-02f, -2.52476931e-02f,
  2.39451625e-03f, 8.38834643e-02f, 6.93910867e-02f, 2.56314892e-02f, 7.84768816e-03f, 3.91812390e-03f, 9.39568039e-03f, 4.06739041e-02f, -6.42294511e-02f, 6.11637607e-02f,
  -3.23635922e-03f, 1.35056540e-01f, -5.64419515e-02f, -6.51505142e-02f, -6.02671392e-02f, -3.62848304e-02f, -5.12359478e-02f, 9.39890295e-02f, -8.49752203e-02f, 4.80969884e-02f,
  1.24712281e-01f, 3.41858715e-02f, -1.46263056e-02f, 4.11731489e-02f, -4.23727334e-02f, -2.08117794e-02f, -1.46509828e-02f, 7.32795820e-02f, 3.92826796e-02f, 2.82347798e-02f,
  -9.03352126e-02f, -7.31161907e-02f, 5.78268766e-02f, -7.93702155e-02f, -4.93427403e-02f, 5.57137132e-02f, -9.97445956e-02f, -4.59901094e-02f, 6.94707111e-02f, -3.05758715e-02f,
  4.29953113e-02f, 9.51413661e-02f, 2.01196764e-02f, -1.17001519e-01f, 1.67157408e-02f, 2.36973520e-02f, 8.55064671e-03f, -1.63167343e-02f, 7.05522150e-02f, -3.03951316e-02f,
  4.99900654e-02f, 6.76538199e-02f, 1.19933728e-02f, 6.97625205e-02f, 5.37220202e-02f, 3.14686969e-02f, -1.25684394e-02f, -6.62528351e-02f, 3.23819034e-02f, -7.79969618e-03f,
  -3.57314385e-02f, 1.34822860e-01f, 9.64758694e-02f, -1.17955701e-02f, -8.31223130e-02f, 5.26340911e-04f, 3.46171553e-03f, 8.96613300e-02f, 5.37417305e-04f, 3.92356096e-03f,
  5.67403287e-02f, 7.04759881e-02f, 3.19065936e-02f, 3.50188538e-02f, -1.78641304e-01f, -4.08612788e-02f, -1.05213895e-01f, -3.71233486e-02f, 7.93547630e-02f, 2.64505371e-02f,
  -1.00112744e-01f, -9.15117860e-02f, 3.47613655e-02f, -2.56456677e-02f, 7.43262172e-02f, 3.81867141e-02f, -2.50468310e-02f, 4.56908680e-02f, -6.24623783e-02f, -8.61164778e-02f,
  2.48744395e-02f, 1.15967602e-01f, 6.88319951e-02f, -5.40929437e-02f, 6.93374202e-02f, -2.56390106e-02f, 2.62793545e-02f, 1.47465374e-02f, -7.76440948e-02f, 5.36367930e-02f,
  -1.00817569e-02f, -6.14680685e-02f, -1.80856208e-03f, -1.94578292e-03f, -3.97806354e-02f, -2.05793083e-02f, 2.40811016e-02f, 7.16784820e-02f, -8.17505494e-02f, 6.08085357e-02f,
  -2.84461696e-02f, -6.63319007e-02f, -8.76014605e-02f, -3.98750044e-02f, -5.18522225e-02f, 1.01935044e-02f, 3.16920877e-02f, -3.25511559e-03f, -2.39595454e-02f, -5.68235628e-02f,
  7.57721961e-02f, -4.46746126e-03f, -5.47091253e-02f, 3.77843417e-02f, 4.96704318e-02f, -7.26804603e-03f, -3.62370275e-02f, 3.58608998e-02f, -5.30935451e-03f, -2.11655796e-02f,
  -6.62199734e-03f, -5.75510971e-02f, 1.35189146e-02f, 7.62207853e-03f, 5.24328314e-02f, 7.18633085e-02f, 5.54746427e-02f, -6.84724674e-02f, -3.67630236e-02f, 1.57670956e-02f,
  6.27534166e-02f, 4.38705608e-02f, -1.00517504e-01f, 3.80290411e-02f, -4.12486792e-02f, 4.14511040e-02f, -3.19144726e-02f, 3.05970591e-02f, 2.03806758e-02f, 6.92822738e-03f,
  -8.80159065e-02f, 4.52841409e-02f, 3.83735932e-02f, 3.34578156e-02f, 8.60596374e-02f, -6.57166913e-02f, 4.30886149e-02f, 2.21021101e-02f, 3.91343944e-02f, -7.13640302e-02f,
  -2.84060440e-03f, 2.18094308e-02f, 1.01989796e-02f, 4.62994426e-02f, 9.86251682e-02f, 1.90786216e-02f, 4.64880094e-02f, -4.85757738e-02f, -3.43836397e-02f, -1.54606737e-02f,
  2.50258371e-02f, 3.99821065e-02f, 2.11971370e-03f, 6.34991601e-02f, 2.79894136e-02f, -6.55462965e-02f, 1.29061770e-02f, -8.56757462e-02f, 5.31585552e-02f, 5.69558106e-02f,
  -1.99395731e-01f, -2.02060733e-02f, -6.50643557e-02f, -9.30456296e-02f, -1.18136808e-01f, -1.76232383e-01f, 2.85365339e-02f, -1.49909168e-01f, -4.06698063e-02f, 9.56652984e-02f,
  4.59284820e-02f, -3.17251459e-02f, 2.26873457e-02f, 1.21836904e-02f, -7.19036385e-02f, 1.28261119e-01f, 1.01870345e-02f, -1.29766436e-02f, -7.49992728e-02f, -4.77806777e-02f,
  1.07493855e-01f, 3.29730138e-02f, -4.49168421e-02f, -5.79980714e-03f, 9.13553592e-03f, 2.25270893e-02f, -4.70267460e-02f, 6.17245771e-03f, 1.63714821e-03f, 5.70335600e-04f,
  -2.79489858e-03f, -6.19350784e-02f, 5.48725054e-02f, -2.24980097e-02f, -5.60222827e-02f, -7.88064301e-02f, -5.17189354e-02f, -4.10215296e-02f, -2.20039915e-02f, -5.85984485e-03f,
  1.34691056e-02f, -2.58079059e-02f, 6.78792745e-02f, 6.63757278e-03f, 3.00297309e-02f, 7.40955845e-02f, 2.16811895e-02f, -6.73617870e-02f, -1.95146166e-02f, -7.14217424e-02f,
  2.98940558e-02f, 3.93172503e-02f, -2.43250392e-02f, 5.79087958e-02f, 6.64700102e-03f, -1.88432820e-02f, -6.82453141e-02f, -9.90336314e-02f, 5.61381467e-02f, 6.51997626e-02f,
  9.38302651e-03f, -6.56960234e-02f, 6.17610030e-02f, -3.34506482e-02f, 4.64960970e-02f, 1.28241405e-01f, 2.75266990e-02f, -3.69430073e-02f, 5.80688789e-02f, 4.72715497e-02f,
  -3.77779342e-02f, -4.93167378e-02f, -6.45735636e-02f, -8.98090154e-02f, 1.39697984e-01f, -2.17168778e-02f, -4.16164659e-02f, -8.43893457e-03f, 3.83036621e-02f, -7.76201561e-02f,
  6.66132346e-02f, -6.15738221e-02f, -1.64048430e-02f, 4.19206992e-02f, -1.52604887e-02f, -4.68730815e-02f, -4.81637008e-02f, -2.03228481e-02f, 5.82200587e-02f, -1.12214535e-01f,
  3.00791282e-02f, -6.97648823e-02f, -5.38672917e-02f, 8.16728082e-03f, -6.03385903e-02f, -8.13759789e-02f, -9.21645164e-02f, -3.94210480e-02f, -5.80579266e-02f, -4.78559881e-02f,
  -2.45705005e-02f, -7.45188966e-02f, 3.06889862e-02f, 7.71062598e-02f, 8.54385830e-03f, 6.14090823e-02f, -7.63070583e-02f, 1.56785864e-02f, -9.63852555e-02f, 3.07745729e-02f,
  3.15950369e-03f, 8.22737515e-02f, 7.04562366e-02f, 6.73166588e-02f, -8.42287168e-02f, -2.73564924e-02f, 2.15574671e-02f, 2.26024687e-02f, -3.83215547e-02f, 2.96185035e-02f,
  6.00966029e-02f, -2.69481242e-02f, -1.89222351e-01f, -1.12402976e-01f, 7.51627907e-02f, 8.35656747e-02f, 1.11107253e-01f, 4.93364409e-02f, -1.37494467e-02f, 6.85892254e-02f,
  -6.18286207e-02f, -6.02453910e-02f, 4.58450662e-03f, 6.71242699e-02f, 6.82425424e-02f, -5.68068177e-02f, 2.19202787e-01f, -1.03047583e-02f, -6.16519079e-02f, -3.48948990e-03f,
  6.10998198e-02f, 1.78794280e-01f, -5.93822636e-02f, -5.69462888e-02f, -4.38556671e-02f, -1.70230269e-01f, -5.44608012e-03f, -1.67198271e-01f, 1.00981936e-01f, -5.53138331e-02f,
  -2.50200145e-02f, -2.75695585e-02f, 6.38819262e-02f, -1.11903958e-01f, 3.57198194e-02f, 3.09181642e-02f, -1.00457622e-02f, -1.02383919e-01f, -2.53655855e-03f, -2.55916398e-02f,
  -5.23962826e-02f, 4.11825217e-02f, 7.40109980e-02f, 8.61437584e-04f, -2.82240864e-02f, 4.76908907e-02f, -3.69640030e-02f, 5.41332625e-02f, 7.72212446e-02f, 5.87262213e-02f,
  9.24772175e-04f, 9.92542282e-02f, 1.55765787e-02f, -2.36409102e-02f, -2.96899378e-02f, 4.35206220e-02f, 4.03870940e-02f, 4.88078222e-02f, 3.69751896e-03f, 4.30155881e-02f,
  4.93389368e-02f, 2.41388772e-02f, 1.21389009e-01f, -2.45918985e-03f, -3.40026841e-02f, 7.95120746e-02f, 4.50042151e-02f, 2.08371249e-03f, -6.16001748e-02f, 5.63277863e-02f,
  -2.58808979e-03f, 2.22984683e-02f, 5.84829263e-02f, -3.88570651e-02f, 1.08775727e-01f, -8.37857425e-02f, -5.02582267e-02f, 1.02635324e-01f, -5.91797158e-02f, 7.44343847e-02f,
  -1.39612574e-02f, -2.84188520e-02f, 2.90540885e-02f, 2.79867277e-02f, -4.43220660e-02f, 4.92210053e-02f, -5.96807189e-02f, -4.60809544e-02f, -5.20774387e-02f, -4.80236113e-02f,
  1.27229929e-01f, -1.24184662e-04f, -2.77948044e-02f, 2.59702150e-02f, -6.19528741e-02f, 6.21496886e-02f, 3.85376886e-02f, 3.77473831e-02f, -9.79287922e-02f, 1.04217447e-01f,
  1.06026672e-01f, -1.15911923e-02f, 1.42871756e-02f, -3.11533380e-02f, -2.75346916e-02f, -1.41859427e-02f, 9.73222428e-04f, -6.96127489e-02f, -6.24144897e-02f, -2.56862789e-02f,
  -3.51710757e-03f, 4.20298874e-02f, -2.26054303e-02f, 6.33201972e-02f, 7.39653930e-02f, 7.33294785e-02f, 1.95627734e-02f, -5.13445996e-02f, -5.10157365e-03f, -7.76886418e-02f,
  -2.54854590e-01f, -9.54149365e-02f, -2.14425296e-01f, -5.46563715e-02f, -2.41951436e-01f, -2.54180104e-01f, -1.38398856e-01f, -1.22988522e-01f, 6.43173058e-04f, 1.90313876e-01f,
  4.72604819e-02f, -8.38835835e-02f, 1.50269002e-01f, -4.16717976e-02f, -1.51394263e-01f, 8.37415978e-02f, -1.74868882e-01f, -5.48627973e-03f, -9.76977125e-02f, -1.53576389e-01f,
  -1.20627731e-01f, -3.41916177e-03f, -1.21809550e-01f, -4.71600629e-02f, -1.95847288e-01f, -2.84913299e-03f, 6.12122715e-02f, -4.24835458e-03f, 7.30298981e-02f, -1.22032143e-01f,
  -1.33524284e-01f, -2.85042040e-02f, -6.80250376e-02f, 6.70835748e-02f, -8.71763080e-02f, -4.12500426e-02f, -1.16361834e-01f, 7.38109229e-03f, -1.32152429e-02f, -5.59291877e-02f,
  -5.61361015e-03f, -8.10540747e-03f, 3.72163183e-03f, 2.78171357e-02f, -6.29855394e-02f, 1.81836393e-02f, -3.37433629e-02f, 1.56386867e-02f, 1.80224981e-02f, -1.32613823e-01f,
  -1.34636775e-01f, -4.70240451e-02f, 3.03662382e-02f, 2.55951341e-02f, -3.43446998e-04f, 7.00071827e-02f, -1.63104590e-02f, 6.00686595e-02f, 8.37831292e-03f, 2.90635526e-02f,
  -1.75004639e-02f, -5.69295473e-02f, 8.32208991e-02f, -3.29769328e-02f, -7.79010057e-02f, 6.00338094e-02f, 4.18127254e-02f, -6.97976872e-02f, -1.24083422e-02f, -4.67588827e-02f,
  1.08395973e-02f, -9.33012143e-02f, 2.36416552e-02f, 3.09310183e-02f, -2.92135845e-03f, 4.09622602e-02f, 2.31791977e-02f, 8.08060542e-02f, -7.53179938e-02f, -3.42035815e-02f,
  9.32257157e-03f, -4.08497825e-02f, 2.40500849e-02f, -5.94207980e-02f, 7.42668612e-03f, 8.00649375e-02f, 8.43786970e-02f, 1.63178295e-02f, -4.82483283e-02f, 4.81790714e-02f,
  -4.38090181e-03f, 6.37172908e-02f, -4.11575139e-02f, 1.10483378e-01f, 5.77093475e-03f, 5.32136895e-02f, 4.12961934e-03f, -4.70091254e-02f, -2.79610455e-02f, 7.23656127e-03f,
  -5.02939001e-02f, 5.88264242e-02f, -1.01333916e-01f, -2.53666993e-02f, 6.30132183e-02f, -1.40356552e-02f, -1.73229631e-02f, 9.06373411e-02f, -8.91433805e-02f, 2.89197098e-02f,
  -1.11421205e-01f, -5.55651402e-03f, 7.54450187e-02f, -1.31782340e-02f, 7.31732249e-02f, 2.17900015e-02f, -1.89524945e-02f, 3.76142040e-02f, -8.69787857e-03f, 1.98507290e-02f,
  -8.09129179e-02f, 2.25223511e-01f, 2.10354887e-02f, -2.04841375e-01f, 1.30818253e-02f, -4.90420572e-02f, -5.56014813e-02f, -1.11703668e-02f, -3.76854092e-02f, 2.10344866e-01f,
  1.56288128e-02f, 1.08406991e-02f, 9.16111395e-02f, -2.23366931e-01f, -3.13010007e-01f, -2.00599983e-01f, -3.59626621e-01f, -1.84107691e-01f, -7.30835274e-02f, -8.69201049e-02f,
  -1.00749604e-01f, -1.41956955e-01f, -1.46665946e-01f, 1.53129712e-01f, -3.68663314e-04f, 4.27571014e-02f, 2.10504234e-03f, 8.81746784e-02f, -4.43774983e-02f, 4.81300801e-02f,
  -4.39878516e-02f, 4.88186674e-03f, 7.89221525e-02f, 1.21988811e-01f, -1.27418593e-01f, 2.35497970e-02f, -8.38934705e-02f, 9.08921938e-03f, 6.20008633e-02f, -2.22178474e-02f,
  4.92186099e-02f, 2.41343882e-02f, -4.00038855e-03f, 2.89883353e-02f, 1.11323394e-01f, 7.16091096e-02f, -1.18704647e-01f, -1.87388714e-02f, 6.36859238e-02f, -5.36674932e-02f,
  1.21697467e-02f, 1.83220226e-02f, -4.84641045e-02f, 6.60343096e-02f, -1.21791456e-02f, 6.01304434e-02f, -1.43544599e-02f, 1.09004818e-01f, 8.83982796e-03f, 1.06642544e-02f,
  -2.51056459e-02f, -3.29473503e-02f, 1.63866323e-03f, 7.61880502e-02f, -5.08200028e-04f, -3.69596444e-02f, 1.39622157e-02f, 9.36232582e-02f, 1.34988837e-02f, 1.00827664e-01f,
  8.80553573e-02f, 5.53574599e-02f, -9.08817500e-02f, 9.60897934e-03f, -9.28384662e-02f, -2.17824765e-02f, 1.68121010e-02f, 5.40427230e-02f, -8.00302029e-02f, 2.23529637e-02f,
  5.58056720e-02f, -3.48517671e-02f, 6.06811568e-02f, -1.71035773e-03f, 6.66274875e-02f, 4.33921330e-02f, -1.33737829e-02f, 3.27675864e-02f, 1.06827486e-02f, -4.82412800e-02f,
  -4.08150926e-02f, -6.83747828e-02f, 1.42278336e-02f, 8.77822638e-02f, 1.30536826e-02f, -6.96293861e-02f, -1.36372063e-03f, 4.13565300e-02f, -7.25107193e-02f, -7.93797672e-02f,
  -1.48492167e-03f, 4.05143686e-02f, -6.46441951e-02f, 2.07333956e-02f, -4.07900289e-02f, 1.00442786e-02f, -1.13464799e-02f, -5.92509285e-02f, -5.21294288e-02f, -6.55526221e-02f,
  -2.31344625e-02f, 6.19710274e-02f, -4.11319360e-03f, -5.45457862e-02f, -2.28171740e-02f, 5.54734692e-02f, 5.06453253e-02f, -5.87850995e-02f, 2.31851730e-02f, -8.39272887e-02f,
  -2.50737935e-01f, -4.64734696e-02f, -1.72948465e-01f, -1.04923218e-01f, -3.55812013e-01f, -1.38329253e-01f, -1.64708123e-01f, -1.03584424e-01f, -8.68913308e-02f, 1.59826249e-01f,
  8.27677771e-02f, -7.35756308e-02f, 2.30267286e-01f, 3.81525792e-02f, -2.53203604e-02f, 2.55052537e-01f, -3.29533679e-04f, 1.14060149e-01f, -3.96669516e-03f, -2.66519301e-02f,
  8.66719987e-03f, -7.48310015e-02f, 1.67001098e-01f, -4.89171408e-02f, -4.00559604e-02f, -4.49290574e-02f, 3.07982061e-02f, -2.02393115e-01f, -1.50138019e-02f, -8.69759247e-02f,
  -4.98103127e-02f, -2.26551257e-02f, 7.71977194e-03f, -2.62042489e-02f, -3.35194245e-02f, 2.44914405e-02f, 8.33181441e-02f, -6.89636096e-02f, -6.00714721e-02f, -5.07232659e-02f,
  -2.29673386e-02f, -6.36863038e-02f, 4.15391102e-02f, -1.45216910e-02f, -1.82799157e-02f, -2.50587463e-02f, 4.57843915e-02f, 7.04887584e-02f, 4.66258451e-02f, 7.58927409e-03f,
  1.21054821e-01f, -4.96412255e-02f, 4.69402559e-02f, -2.27217861e-02f, -9.08398107e-02f, -2.79977359e-02f, -4.20243293e-03f, 8.83464292e-02f, -5.67713641e-02f, -1.48928657e-01f,
  -3.49670015e-02f, -6.67096898e-02f, -5.26283681e-02f, -1.01700537e-02f, -1.96404140e-02f, -1.88419539e-02f, 5.48358308e-03f, 7.39336014e-02f, 3.78004387e-02f, -2.90337615e-02f,
  2.00507641e-02f, -5.14595397e-02f, 3.67963202e-02f, 4.39619645e-02f, -3.95484753e-02f, 6.45298883e-02f, 6.60398528e-02f, -6.03302233e-02f, 2.05469057e-02f, 4.87442873e-02f,
  -6.84033497e-04f, 2.44530272e-02f, 1.04372576e-02f, 1.91337466e-02f, -6.87846169e-02f, 7.76758045e-02f, -7.18682408e-02f, 6.78314567e-02f, 2.68033054e-02f, -1.06075943e-01f,
  -4.61342931e-02f, -1.45272404e-01f, 6.57478124e-02f, 3.44581716e-02f, -4.29813983e-04f, 7.26507790e-03f, 8.05666763e-03f, 4.08700947e-03f, -2.59297565e-02f, -6.71191961e-02f,
  7.22587705e-02f, 9.59206000e-03f, 5.54656796e-03f, 1.65539701e-02f, -7.50057213e-03f, 3.62622142e-02f, 9.67508331e-02f, -8.68578851e-02f, -9.46735442e-02f, -8.72618333e-02f,
  8.77878070e-03f, -2.74834735e-03f, 2.83751730e-02f, 4.21995595e-02f, -5.07198647e-02f, 5.89522310e-02f, -5.68242883e-03f, -8.11528042e-02f, -3.38088796e-02f, 2.07036994e-02f,
  -2.71245658e-01f, 2.01459080e-01f, 1.93465836e-02f, 7.61913955e-02f, -1.77994862e-01f, 1.58844367e-01f, 1.81088671e-01f, -3.18329073e-02f, -2.10823938e-02f, 2.07747743e-01f,
  2.08341092e-01f, -2.91490089e-02f, 1.32211477e-01f, 2.64371932e-01f, 7.36249099e-03f, 7.93600604e-02f, 2.63467938e-01f, 1.11976743e-01f, 4.27724347e-02f, 5.29025607e-02f,
  -6.24584258e-02f, 6.69400468e-02f, 5.38734673e-03f, 3.97435129e-02f, 4.77341749e-02f, -1.31872699e-01f, -3.39218378e-02f, -2.88094506e-02f, 2.35478822e-02f, -1.79119427e-02f,
  9.35029164e-02f, 3.63902971e-02f, -1.14367537e-01f, 4.32989262e-02f, 1.42108304e-02f, -9.15805623e-03f, -3.08096921e-03f, -2.80181989e-02f, 3.73795140e-03f, 5.77229448e-02f,
  -2.83920094e-02f, -5.56634143e-02f, 8.25602747e-03f, -1.03230998e-01f, -4.13627662e-02f, -1.00279137e-01f, -7.07466230e-02f, -2.16636453e-02f, 4.95184325e-02f, 2.67944857e-02f,
  -7.59984646e-03f, 5.43779321e-02f, -3.26910093e-02f, 6.32082075e-02f, -1.00798793e-01f, -2.62451433e-02f, 1.07381791e-01f, -8.30081850e-02f, 7.73529634e-02f, 2.36978428e-03f,
  -7.39748729e-03f, 1.00086361e-01f, -1.16851971e-01f, -3.62685733e-02f, -7.05762357e-02f, -1.31437359e-02f, -2.48369724e-02f, -3.34340520e-02f, -4.24460806e-02f, 4.98616137e-02f,
  -6.61815107e-02f, 3.48266475e-02f, 6.72403574e-02f, 4.42539044e-02f, 2.57036649e-02f, 4.45980392e-02f, 2.38525216e-02f, -5.33370264e-02f, -7.48613477e-03f, -7.49178883e-03f,
  -2.94191465e-02f, 6.37121499e-02f, -1.13829393e-02f, 3.75536308e-02f, 3.90491858e-02f, -9.09986198e-02f, 2.35035811e-02f, -2.21742429e-02f, 5.19471727e-02f, 5.93854487e-03f,
  8.56682360e-02f, 1.96444139e-01f, -2.47507822e-02f, -6.73712185e-03f, 3.14539187e-02f, -7.11311772e-02f, 2.27427930e-02f, -6.84704930e-02f, -2.14732550e-02f, 4.15967703e-02f,
  7.85748034e-06f, 1.14271939e-02f, -1.63525939e-02f, 3.69346850e-02f, -1.75524391e-02f, -4.34901826e-02f, 7.93427601e-03f, 8.40480849e-02f, 4.67458293e-02f, 8.72643664e-03f,
  -9.45702791e-02f, -3.88377011e-02f, 7.43033271e-03f, -5.36486395e-02f, -9.46632866e-03f, 4.44305912e-02f, -4.15097456e-03f, 1.04388529e-02f, -7.82487318e-02f, 7.02066869e-02f,
  -1.56508401e-01f, 7.70594850e-02f, 1.02115393e-01f, -1.46261483e-01f, 6.52042776e-02f, 2.56122462e-02f, 4.43119667e-02f, 3.38474102e-02f, -9.63948295e-02f, -6.31954744e-02f,
  9.92728099e-02f, -1.89125780e-02f, 1.28579557e-01f, -2.51305290e-03f, 1.02265760e-01f, -7.13150576e-02f, -7.42270947e-02f, -6.95413426e-02f, 6.15061112e-02f, -3.02100182e-02f,
  1.28479414e-02f, -6.30847663e-02f, -1.33654892e-01f, 2.98015419e-02f, -8.98226425e-02f, 5.24428720e-03f, -9.46175307e-02f, 9.36518386e-02f, -7.69859329e-02f, 3.04980371e-02f,
  2.08583493e-02f, -7.17878714e-02f, 1.30417347e-02f, -4.92386445e-02f, -5.92545141e-03f, -4.83963303e-02f, -3.63854468e-02f, 4.77778986e-02f, -2.07304917e-02f, 1.18610166e-01f,
  -4.91235685e-03f, 1.02726333e-01f, 4.20996845e-02f, 5.99270239e-02f, -9.10427514e-03f, 4.90796603e-02f, -7.55219311e-02f, 6.39154688e-02f, 2.78242789e-02f, 1.29452646e-01f,
  1.58100086e-03f, -2.96875499e-02f, -4.26865704e-02f, 4.85658050e-02f, 1.76193714e-02f, -1.08629219e-01f, -5.08789346e-02f, -9.26111545e-03f, -4.41455878e-02f, 3.20199244e-02f,
  -9.04636011e-02f, 5.76087162e-02f, 1.30679365e-02f, -2.82861348e-02f, -2.09668651e-02f, -4.82472181e-02f, 3.91394608e-02f, -1.14148539e-02f, 4.07198854e-02f, -6.51095435e-02f,
  4.66892086e-02f, 6.79480135e-02f, -4.80005071e-02f, 1.24755492e-02f, -3.45397368e-02f, 6.42119274e-02f, -6.30301833e-02f, 3.80643159e-02f, -5.57543412e-02f, 1.09019112e-02f,
  2.50665303e-02f, 2.35408358e-02f, -6.52489811e-02f, 9.71499458e-03f, 9.33474749e-02f, -1.01098038e-01f, -2.34949682e-02f, 2.60067102e-03f, -7.93613773e-03f, -1.56118125e-02f,
  -3.86263018e-05f, 2.81099267e-02f, 5.41987829e-02f, -5.34900539e-02f, 9.00203139e-02f, -8.76064599e-02f, -1.89582221e-02f, -2.77364049e-02f, 9.62352157e-02f, 1.24355161e-03f,
  9.26460177e-02f, -8.60717371e-02f, -8.46243650e-02f, -2.16564387e-02f, 7.73628205e-02f, -7.11702928e-02f, -6.50274158e-02f, 1.00374240e-02f, 1.96427554e-02f, 7.62647241e-02f,
  3.94451618e-02f, -5.27672879e-02f, -1.60510074e-02f, -2.32504439e-02f, -2.18288396e-02f, -5.47120906e-02f, -1.36312032e-02f, -4.10394780e-02f, 1.08374488e-02f, -4.45066020e-02f,
  -2.77973711e-01f, 9.27792937e-02f, -1.06037213e-02f, 1.57267407e-01f, -3.12847048e-02f, 1.38886262e-05f, 1.60716325e-01f, 1.06148809e-01f, 1.83080867e-01f, 1.17717810e-01f,
  -2.01042020e-03f, -1.83177963e-02f, 2.96464399e-03f, 2.66014133e-03f, 1.36407102e-02f, 1.68560311e-01f, 1.17990680e-01f, -7.64469150e-03f, -5.48576042e-02f, 2.58823764e-02f,
  -2.29778253e-02f, 1.50719867e-03f, 1.03244565e-04f, -9.25578251e-02f, -1.94246415e-02f, -3.02030612e-02f, -4.75766882e-02f, -4.99968678e-02f, 4.85460237e-02f, 8.79686549e-02f,
  -9.04892460e-02f, -1.21328004e-01f, 1.74263977e-02f, -4.28688116e-02f, 8.54600873e-03f, -1.15389928e-01f, -3.07407300e-03f, -1.97855923e-02f, -6.79791719e-02f, -1.73680820e-02f,
  2.28057411e-02f, -1.12761043e-01f, 4.09431476e-03f, -4.88247946e-02f, 3.14459652e-02f, -1.88676585e-02f, -2.10512914e-02f, -2.92155221e-02f, -4.51340750e-02f, -6.48243800e-02f,
  4.28160802e-02f, 6.53390363e-02f, 3.01299151e-02f, 1.16017526e-02f, -6.01171479e-02f, 9.49272215e-02f, 1.45060504e-02f, 9.78565216e-02f, 2.77093742e-02f, -1.36586437e-02f,
  8.32339898e-02f, -5.85629083e-02f, 4.39083949e-02f, 1.03731021e-01f, -4.78224410e-03f, 3.67792160e-03f, 1.61096621e-02f, 1.49227446e-02f, 1.25356438e-02f, 3.90851945e-02f,
  -5.70009090e-02f, -4.89618592e-02f, -1.30644277e-01f, 3.89823387e-03f, -1.28433723e-02f, 8.57209414e-02f, -6.11548778e-03f, 4.41799387e-02f, -2.10415404e-02f, 5.81927449e-02f,
  -8.24691076e-03f, 6.34816438e-02f, -8.13421458e-02f, 4.72449400e-02f, 7.41272569e-02f, 1.44869415e-02f, -1.37859872e-02f, -1.16645964e-02f, -2.98969653e-02f, 4.05226126e-02f,
  -3.98571277e-03f, 8.07970017e-02f, 6.97705150e-02f, -8.68773647e-03f, -2.08128840e-02f, 1.81460511e-02f, 3.59605029e-02f, -5.15469424e-02f, 1.82323202e-01f, 7.91961104e-02f,
  -5.02030216e-02f, 6.68881508e-03f, -6.72597289e-02f, 1.81844812e-02f, 6.36909995e-03f, 3.24971043e-02f, -2.49813050e-02f, 3.02808210e-02f, 1.13702536e-01f, -4.38467450e-02f,
  -1.14029869e-01f, -5.72125874e-02f, 1.55354328e-02f, -3.15975398e-02f, 1.77322738e-02f, 6.22518780e-03f, -2.30407491e-02f, 7.76521266e-02f, 3.48998234e-02f, -3.82501595e-02f,
  2.30452836e-01f, -4.57907021e-01f, 2.39471257e-01f, 3.32689881e-01f, 1.93183497e-01f, -2.14374494e-02f, 9.62605327e-02f, -4.95274067e-02f, -1.28442049e-01f, -4.68853593e-01f,
  7.88336918e-02f, -1.03519164e-01f, -1.71423793e-01f, -3.06502078e-03f, 2.37990469e-01f, -4.45074737e-02f, 5.50907291e-03f, -7.32458904e-02f, -1.21067073e-02f, 8.48512053e-02f,
  1.72871649e-01f, 8.16218853e-02f, 2.06793085e-01f, -3.42726074e-02f, 3.53265256e-02f, 4.01633047e-02f, 2.80636549e-02f, -3.94999273e-02f, 6.47347793e-02f, 5.04899174e-02f,
  -1.04018629e-01f, -7.14359879e-02f, -4.37423699e-02f, 3.97370569e-02f, -5.45862988e-02f, -8.80563259e-02f, 1.26678869e-01f, -1.83293689e-03f, 1.97266899e-02f, -1.81392021e-02f,
  -1.21664964e-02f, -7.83213675e-02f, -4.60984651e-03f, 6.28695562e-02f, 5.41792670e-03f, 6.04301915e-02f, -9.25139636e-02f, 2.81612072e-02f, 6.30568117e-02f, -2.89168824e-02f,
  -6.21224307e-02f, 2.60130074e-02f, -3.64895649e-02f, 3.66258696e-02f, -3.08402386e-02f, -5.53285405e-02f, -5.39680310e-02f, 7.72062168e-02f, -5.15014604e-02f, -2.89452518e-03f,
  7.94923380e-02f, -3.23419608e-02f, -3.71165127e-02f, -1.22462846e-02f, -1.24695888e-02f, 3.17367204e-02f, -4.47059311e-02f, -1.08965673e-02f, 3.12242210e-02f, 9.26314760e-03f,
  -1.15667591e-02f, 7.94389993e-02f, -1.62174720e-02f, -4.06071618e-02f, 3.69305797e-02f, 1.66750237e-04f, 1.00868037e-02f, 3.45503390e-02f, -9.50620994e-02f, 7.83686861e-02f,
  -9.06848535e-02f, 7.76389241e-02f, -1.83259919e-02f, 3.47441435e-02f, 3.03794257e-02f, 1.18185822e-02f, -1.32082002e-02f, -1.09782070e-02f, 4.15463559e-02f, 4.37530503e-02f,
  -3.13691080e-01f, -2.52582848e-01f, -1.15112420e-02f, -1.57509614e-02f, -3.88486963e-03f, -1.40527576e-01f, -2.40708385e-02f, -1.64379328e-02f, -1.64133847e-01f, -1.82864163e-02f,
  -1.95316132e-02f, 5.51160462e-02f, -1.00114301e-01f, 3.68732437e-02f, 6.34576306e-02f, -1.33049279e-01f, -1.70337409e-02f, -1.06969848e-01f, -4.92844284e-02f, 3.30720022e-02f,
  -4.49406821e-03f, -4.59847152e-02f, 1.01526409e-01f, 9.33695398e-03f, -3.17482725e-02f, 3.79238874e-02f, -4.52929270e-03f, -2.81898510e-02f, -3.13155949e-02f, 2.63226572e-02f,
  -2.07575873e-01f, 1.45085990e-01f, -5.78149147e-02f, -2.82020777e-01f, 4.68526110e-02f, -7.82216992e-03f, -1.37313470e-01f, 5.67638911e-02f, -1.29091799e-01f, 8.06571618e-02f,
  -8.23592395e-02f, 3.08833104e-02f, 1.48318753e-01f, -7.79227242e-02f, -2.83609450e-01f, -3.46923284e-02f, -1.96444616e-01f, -1.19595520e-01f, 2.78865583e-02f, -2.53343638e-02f,
  -8.20730180e-02f, -9.21031386e-02f, -1.26535729e-01f, 1.91166624e-01f, 2.15924624e-02f, 1.51032330e-02f, -5.80715667e-03f, 1.37970567e-01f, 3.38089764e-02f, 8.88444632e-02f,
  -1.43030941e-01f, -7.86634088e-02f, 3.42968218e-02f, 3.42996754e-02f, 2.50087827e-02f, 9.01039317e-02f, 4.70006466e-02f, 2.83246208e-02f, -7.44089624e-03f, 4.80217710e-02f,
  4.71385196e-02f, 4.66936976e-02f, 4.94422056e-02f, 3.72826904e-02f, 3.72487642e-02f, 2.90801097e-02f, 3.76533940e-02f, -5.77364070e-03f, -1.56709272e-03f, 4.79550734e-02f,
  4.57140394e-02f, -1.49791390e-02f, -9.19798762e-02f, 3.20167951e-02f, -4.89489362e-02f, 7.81327486e-02f, -8.51721689e-02f, -8.26084465e-02f, -6.33569993e-03f, -1.29059181e-01f,
  6.79718405e-02f, 4.33181264e-02f, -1.07868863e-02f, -3.31028029e-02f, 2.71205530e-02f, -1.69811361e-02f, 3.42429131e-02f, -2.91646458e-02f, 1.69723406e-02f, -4.16972898e-02f,
  -6.50138482e-02f, -2.12297775e-02f, 2.52914187e-02f, 3.54778841e-02f, 2.19182670e-02f, 2.42656358e-02f, -6.50814921e-03f, 2.39851344e-02f, -7.26063475e-02f, -1.95170455e-02f,
  2.15086080e-02f, -6.08186983e-02f, -3.11678089e-02f, -2.80198306e-02f, -3.62169929e-02f, -1.99700054e-03f, -3.20653096e-02f, -1.66725665e-02f, -5.04123755e-02f, 7.44251907e-02f,
  -3.17245955e-03f, -1.41707465e-01f, 2.29997298e-04f, -1.16506889e-02f, 9.24457014e-02f, -3.62432972e-02f, -5.87671883e-02f, -1.21322489e-06f, -5.07034287e-02f, 9.57483277e-02f,
  2.15700250e-02f, -9.40948203e-02f, -8.12293738e-02f, -4.38533537e-02f, -2.03786772e-02f, -9.18978453e-02f, -1.92438513e-02f, -6.65728003e-03f, -2.87662204e-02f, -8.78978346e-04f,
  7.46896565e-02f, -4.86941971e-02f, 6.13224283e-02f, -5.26890717e-03f, -4.21979018e-02f, -4.89065982e-02f, -4.30291668e-02f, 2.16379520e-02f, -2.68362798e-02f, 2.75048241e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  9.22509581e-02f, 7.19428435e-02f, 8.20642710e-02f, -5.36897266e-03f, 6.32007420e-02f, 3.90705764e-02f, 6.96578017e-03f, 1.08682729e-01f, 1.31263494e-01f, 1.33277643e-02f,
  1.78846315e-01f, 1.48866838e-02f, 9.82656479e-02f, 2.49508079e-02f, -3.41592208e-02f, 4.99255322e-02f, -3.49921361e-02f, 4.05263714e-02f, 1.51979029e-01f, 9.55917984e-02f,
  4.43481188e-03f, 4.04598489e-02f, 9.57530923e-03f, 1.59672394e-01f, 1.09096132e-01f, 1.23023607e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.90828413e-01f, -2.78394949e-02f, -4.99872006e-02f, 1.80729568e-01f, 1.61070794e-01f, -2.04873487e-01f, 2.79096574e-01f, 3.24566036e-01f, 9.10558924e-02f, -1.96200743e-01f,
  1.24987721e-01f, 7.62086222e-03f, 5.62264249e-02f, -1.29361644e-01f, -2.22609818e-01f, -1.99654073e-01f, -3.50096449e-02f, -3.03144544e-01f, 1.16992481e-01f, 2.34762896e-02f,
  2.35308304e-01f, -1.33489911e-02f, 6.83520138e-02f, -2.63651349e-02f, 1.40457034e-01f, 6.96542710e-02f, 1.89536989e-01f, 1.67059049e-01f, -3.06631569e-02f, 3.14237438e-02f,
  -1.20275550e-01f, -4.72125150e-02f, -1.30970791e-01f, 6.14032149e-02f, 1.34755075e-01f, 4.70490344e-02f, -3.04589540e-01f, -2.18060493e-01f, 1.34502888e-01f, -2.39351466e-01f,
  1.20065473e-01f, -1.49123343e-02f, -1.63196295e-01f, 3.55715424e-01f, -2.08565239e-02f, 8.64506885e-02f, 1.07739978e-01f, -2.18323410e-01f, 6.26892142e-04f, -5.37690558e-02f,
  -2.68856823e-01f, -1.80156827e-01f, 3.79821174e-02f, -9.41710919e-03f, 1.09295167e-01f, 2.28748113e-01f, 6.69599185e-03f, -2.35365316e-01f, 2.51950830e-01f, -4.70220223e-02f,
  -4.81204782e-03f, 7.34640807e-02f, 8.59413072e-02f, -2.00959668e-01f, -7.38591477e-02f, 4.69346493e-02f, -1.26728415e-01f, 3.65053266e-02f, -8.46161470e-02f, -2.42506936e-01f,
  -1.06410965e-01f, -1.68789346e-02f, -1.57341570e-01f, 1.48616821e-01f, -9.06936675e-02f, 4.57946211e-01f, 5.64939082e-02f, 1.66361272e-01f, 1.25367627e-01f, -1.74119800e-01f,
  -1.25446305e-01f, 1.93469450e-01f, -2.66448259e-01f, 1.30142748e-01f, 1.50999114e-01f, 2.28987914e-02f, -1.02570646e-01f, -1.66612421e-03f, -8.11885074e-02f, -1.37952164e-01f,
  -1.15960181e-01f, 5.69990762e-02f, -1.24223657e-01f, -1.10592216e-01f, 3.26454043e-02f, -1.71970472e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -8.89989287e-02f, 2.57064968e-01f, 3.77608836e-02f, -1.73652485e-01f, -1.89745069e-01f, -6.92637116e-02f, -2.32591659e-01f, -1.56608485e-02f, 1.64118454e-01f, 7.07313493e-02f,
  -1.25788942e-01f, 1.92685664e-01f, 1.23716131e-01f, 1.52318329e-01f, -4.83801588e-02f, -7.30720460e-02f, 1.85809836e-01f, 4.03651506e-01f, -8.97658318e-02f, 4.44594445e-03f,
  -1.39681116e-01f, -8.40621367e-02f, -9.30654556e-02f, 1.19644873e-01f, -2.20469609e-02f, 2.12358564e-01f, -1.29185736e-01f, -4.80949022e-02f, -6.08464256e-02f, -6.34494470e-03f,
  1.06736153e-01f, 1.92133889e-01f, 5.41546568e-02f, -2.06461176e-02f, -1.77545995e-01f, 1.34945005e-01f, 9.14338604e-03f, -6.00696728e-02f, 5.70180453e-02f, -1.46796077e-01f,
  -1.63843885e-01f, 4.55922596e-02f, 9.06195492e-02f, -1.40822576e-02f, -1.73323318e-01f, 1.23660550e-01f, -1.64282396e-01f, -4.11212742e-02f, 2.85997391e-02f, -6.77625611e-02f,
  -1.70475677e-01f, -2.37416569e-02f, 6.87006265e-02f, -7.52342045e-02f, 5.04256822e-02f, -3.23727988e-02f, -2.91086249e-02f, 7.20500648e-02f, -9.04303640e-02f, -2.10960526e-02f,
  -1.10420428e-01f, 1.97494533e-02f, 7.90364370e-02f, -1.10353291e-01f, -5.89176789e-02f, 1.73028767e-01f, 6.84938729e-02f, -2.80701555e-03f, 1.77384555e-01f, -2.29116485e-01f,
  1.48865983e-01f, 1.58979475e-01f, -6.49075285e-02f, 1.38868615e-01f, 1.12107983e-02f, 3.56590360e-01f, 3.12254012e-01f, 2.04335019e-01f, 6.76286742e-02f, 2.12787203e-02f,
  1.91451684e-01f, 5.14738299e-02f, 6.47763163e-02f, 9.89603177e-02f, -2.63055176e-01f, 6.65614158e-02f, -1.03001975e-01f, 4.38523367e-02f, -2.60345638e-01f, 2.01046467e-01f,
  -1.27014667e-01f, -1.97945803e-01f, 1.85412616e-01f, -1.88324690e-01f, 4.61707115e-01f, -1.43226206e-01f, -1.67855360e-02f, -1.40284017e-01f, 2.50879768e-02f, 8.49141181e-02f,
  -4.43586260e-02f, 1.76805362e-01f, 1.84460096e-02f, -8.51546377e-02f, 1.05032295e-01f, 3.21863405e-02f, 1.34482816e-01f, -1.02035083e-01f, 1.47638753e-01f, -6.02994561e-02f,
  -1.17411703e-01f, -1.22035742e-01f, -1.42895356e-01f, -1.14432774e-01f, 2.26934627e-01f, 3.13077904e-02f, 6.74022734e-02f, 6.11476414e-02f, -3.19571346e-02f, -1.12014763e-01f,
  -4.90109064e-02f, -2.01191772e-02f, -3.97435352e-02f, -3.12012006e-02f, 1.35864452e-01f, 7.49107776e-03f, 4.08338755e-02f, 1.91531658e-01f, 1.48606852e-01f, 1.96009696e-01f,
  1.00900874e-01f, -2.77680129e-01f, 2.27344498e-01f, 1.35629714e-01f, 1.01215348e-01f, 1.16232373e-01f, 1.16422296e-01f, 2.50158787e-01f, 1.54161483e-01f, 2.56656021e-01f,
  3.02461773e-01f, -1.39916502e-03f, -2.33846277e-01f, 2.61673719e-01f, 3.40485908e-02f, 3.32557797e-01f, 1.80871814e-01f, 2.51900464e-01f, -2.01380536e-01f, 1.24938786e-01f,
  -1.12187035e-01f, 6.93476871e-02f, -7.27749616e-02f, 2.16187760e-01f, -1.24536440e-01f, -2.17324764e-01f, -5.66793159e-02f, -1.13287970e-01f, 4.52759892e-01f, 2.24946514e-01f,
  -4.93351705e-02f, -2.08078185e-03f, -1.20199077e-01f, -6.50458261e-02f, 3.85456197e-02f, 6.51381239e-02f, 1.67145893e-01f, 5.06241843e-02f, -9.67701226e-02f, -1.63621426e-01f,
  -5.94715998e-02f, 2.51038913e-02f, 3.16693895e-02f, -1.06645331e-01f, -7.89092481e-03f, -1.33888647e-01f, 4.20358311e-03f, 4.82406542e-02f, 2.79938728e-01f, -3.78286131e-02f,
  2.59469062e-01f, -8.67414623e-02f, 8.03425238e-02f, -1.16628101e-02f, 9.87946168e-02f, -1.62497103e-01f, 1.79385796e-01f, 2.20474049e-01f, -1.87039360e-01f, 1.22670606e-01f,
  8.12606812e-02f, -1.15915060e-01f, -3.36192809e-02f, -1.76036045e-01f, 5.71898073e-02f, 1.42247692e-01f, 1.27359048e-01f, -1.61648810e-01f, 4.09579165e-02f, -3.29808220e-02f,
  4.50833887e-02f, -7.44551048e-02f, 5.33676008e-03f, 1.19643927e-01f, 6.63446561e-02f, -1.58933103e-01f, 6.58722296e-02f, 8.19500163e-02f, -7.39230961e-02f, -5.25363088e-02f,
  3.22902412e-03f, -1.37157246e-01f, -1.00032650e-01f, 1.51713133e-01f, -4.66122515e-02f, 4.56324555e-02f, 8.26950185e-03f, -1.60052314e-01f, -7.67713189e-02f, 2.80607250e-02f,
  -8.86396691e-02f, 1.07666463e-01f, -1.45868525e-01f, 9.73287523e-02f, 2.87655652e-01f, 1.97627559e-01f, 2.53385156e-01f, 3.31072539e-01f, -2.99465418e-01f, 2.78107338e-02f,
  3.69251147e-02f, -2.04860643e-01f, 1.54802620e-01f, -2.54125204e-02f, 9.62171555e-02f, 1.51624113e-01f, 1.62063807e-01f, 1.89618841e-01f, 2.85529822e-01f, -5.44353686e-02f,
  2.15145782e-01f, -1.25312597e-01f, -3.40474874e-01f, -1.95238560e-01f, 1.74557924e-01f, -8.83650407e-02f, -9.95978042e-02f, 2.57021636e-01f, -4.54473915e-03f, -7.70680830e-02f,
  1.77573502e-01f, 3.17104995e-01f, -4.01240475e-02f, 2.53589183e-01f, -2.66080685e-02f, -1.28147766e-01f, 2.54769087e-01f, 4.02710617e-01f, 2.68027693e-01f, 2.70316005e-01f,
  -4.45932001e-01f, -7.77576566e-02f, -1.94186077e-01f, 3.60298067e-01f, 1.01176631e-02f, 1.64584160e-01f, 1.98083743e-02f, 1.15534596e-01f, -4.20280129e-01f, 2.02731699e-01f,
  2.20462546e-01f, -9.05386508e-02f, 1.23067573e-01f, 1.83115289e-01f, 7.04065800e-01f, 1.04745522e-01f, 6.38328791e-01f, -6.63931901e-03f, 1.79180503e-01f, -1.35234207e-01f,
  5.80230892e-01f, 2.90238321e-01f, 3.34746808e-01f, 1.95164919e-01f, 1.97623581e-01f, 1.30853087e-01f, -4.23152506e-01f, 3.74907166e-01f, 3.28555375e-01f, 2.25266546e-01f,
  1.94933787e-01f, -1.04693860e-01f, 1.50247971e-02f, 2.63809413e-01f, -1.43062741e-01f, -7.16770142e-02f, 9.81673971e-02f, -4.70240451e-02f, -6.69335276e-02f, 3.57916743e-01f,
  -1.11066498e-01f, 2.09373161e-01f, 1.84034869e-01f, 4.42879973e-03f, -2.02269740e-02f, 3.09862256e-01f, 1.94964394e-01f, 1.08053118e-01f, -1.69731397e-02f, 1.55174121e-01f,
  -8.81936848e-02f, 9.94856432e-02f, 1.66482598e-01f, 1.82765722e-01f, -9.99886915e-02f, 1.68846831e-01f, -6.82509392e-02f, 1.00455292e-01f, -3.08080530e-03f, 1.17145501e-01f,
  1.87082097e-01f, 5.65192997e-02f, 5.88355260e-03f, -1.67750522e-01f, 1.25698090e-01f, -8.89348239e-02f, -1.02367684e-01f, 1.69173688e-01f, -5.56165390e-02f, 1.01848152e-02f,
  4.09835279e-02f, 2.28055656e-01f, -3.90006863e-02f, 1.34889379e-01f, 4.76056002e-02f, 2.81515345e-03f, -1.19053535e-01f, 3.48303705e-01f, -1.36581391e-01f, 2.19928846e-01f,
  -1.73713326e-01f, -5.05068377e-02f, -3.00176051e-02f, 6.68511763e-02f, 1.01466432e-01f, 5.61727844e-02f, -7.18120560e-02f, 3.54477996e-03f, -1.48812562e-01f, -3.93236093e-02f,
  3.17762285e-01f, 6.43764213e-02f, -1.29761752e-02f, -4.61246036e-02f, -5.83218485e-02f, 9.72267166e-02f, 6.67118952e-02f, -1.35832816e-01f, 6.44569546e-02f, -5.53919263e-02f,
  -1.48176417e-01f, 1.67363882e-01f, -1.45674109e-01f, -1.82720758e-02f, -5.10627851e-02f, 5.99410310e-02f, 1.88276300e-03f, -1.40631378e-01f, 1.82677470e-02f, -1.02887347e-01f,
  -1.64009370e-02f, 9.48647186e-02f, 1.61725953e-01f, 1.09985515e-01f, -1.19532049e-01f, -6.20614327e-02f, -1.60766825e-01f, -1.29891723e-01f, -1.12861572e-02f, 8.07532296e-02f,
  1.76961482e-01f, 1.31582469e-01f, 1.49409071e-01f, -1.07621707e-01f, -7.69910403e-03f, -1.57047063e-01f, -2.24647112e-02f, -1.17608741e-01f, -5.63879323e-04f, -1.22950375e-01f,
  -2.93608624e-02f, -1.33766130e-01f, -9.04452503e-02f, 4.43756692e-02f, 7.81171098e-02f, -7.35019669e-02f, -7.54579976e-02f, 1.95835549e-02f, -3.37497517e-02f, 1.45797893e-01f,
  1.51049584e-01f, -1.47163495e-01f, 1.72669664e-01f, -1.36133030e-01f, 1.37914166e-01f, -1.01462625e-01f, 5.48977032e-02f, 1.00547343e-01f, -6.18446134e-02f, 9.39668417e-02f,
  -1.55325666e-01f, -1.52291626e-01f, -4.21949551e-02f, 1.62529320e-01f, 1.15511723e-01f, -4.89656515e-02f, 1.63283840e-01f, 1.63906574e-01f, 2.27618337e-01f, 1.61297694e-01f,
  -7.05380216e-02f, 1.23756438e-01f, -2.33193785e-01f, 6.06538542e-02f, -1.64391426e-03f, 1.40907630e-01f, 6.82790056e-02f, 2.52077579e-01f, -4.79175784e-02f, 2.23602206e-01f,
  2.10483685e-01f, 8.70899931e-02f, 4.53156754e-02f, 7.10677430e-02f, -1.30401449e-02f, -1.96531415e-01f, 1.08832531e-01f, -1.75503075e-01f, -8.10702220e-02f, 1.81816846e-01f,
  -9.18317884e-02f, -5.96087147e-03f, 3.66490632e-02f, 2.07025990e-01f, 4.76564243e-02f, -5.25080301e-02f, -9.33833644e-02f, -1.02596991e-01f, -4.39531766e-02f, 2.08987698e-01f,
  1.50631920e-01f, -2.37558410e-01f, -1.92581508e-02f, 2.37095505e-01f, -1.38890520e-02f, 4.52076383e-02f, 1.78206041e-01f, -4.10383940e-02f, 2.98410817e-03f, -2.63191104e-01f,
  3.92858386e-02f, -1.07331432e-01f, -5.62336901e-03f, 4.94894222e-04f, 2.33477160e-01f, 4.36917484e-01f, 1.84248030e-01f, 1.28182247e-01f, -1.54909402e-01f, 2.02739209e-01f,
  -1.24680260e-02f, -1.47382066e-01f, 1.75468683e-01f, 3.74180228e-01f, -1.41484439e-01f, -1.65149659e-01f, -1.52461380e-02f, 3.33375782e-02f, 2.42290720e-01f, 8.42425302e-02f,
  -5.65064177e-02f, -1.38612643e-01f, 4.20593843e-03f, -1.16252579e-01f, -1.90815534e-02f, 1.47058770e-01f, 2.03506649e-01f, 2.15791747e-01f, 1.38338014e-01f, -1.49178013e-01f,
  1.58076324e-02f, -8.61354917e-02f, -1.05253160e-02f, -1.60124019e-01f, -1.81422085e-01f, 1.87822789e-01f, 6.33385852e-02f, 2.24341780e-01f, 3.28248233e-01f, -8.69075879e-02f,
  -2.71999743e-03f, -3.62519957e-02f, 1.90144122e-01f, -1.18462339e-01f, -4.30380590e-02f, 1.55370951e-01f, -1.35002568e-01f, 1.59415174e-02f, 1.71327293e-01f, 7.83929825e-02f,
  1.67468444e-01f, -1.20328264e-02f, 1.26882449e-01f, -4.15278152e-02f, 1.80813566e-01f, 6.40118122e-02f, -7.03957677e-02f, -1.02583431e-01f, 2.08314493e-01f, -6.23664521e-02f,
  1.54315503e-02f, 9.66860577e-02f, 1.64568290e-01f, 2.27629185e-01f, -2.35878062e-02f, 3.27558480e-02f, 1.39302105e-01f, 1.19914845e-01f, 1.70619428e-01f, -9.73080173e-02f,
  -1.52371004e-01f, -6.24720678e-02f, -1.18201077e-01f, 3.39903124e-02f, -7.46126100e-02f, -7.30905458e-02f, 2.13263128e-02f, -1.32494673e-01f, 1.21257111e-01f, 1.45914733e-01f,
  8.18277299e-02f, -7.99995437e-02f, 3.10265869e-01f, 9.75826457e-02f, 2.39283279e-01f, 1.28088877e-01f, -1.44563224e-02f, -8.79650116e-02f, 1.65654749e-01f, -1.37421519e-01f,
  3.36523622e-01f, 1.30120680e-01f, 1.90791592e-01f, -2.02395618e-02f, 2.19416469e-02f, 3.34029973e-01f, 9.99843478e-02f, -5.04754893e-02f, 9.65237990e-02f, -5.89737445e-02f,
  1.43902913e-01f, -1.19907014e-01f, 6.69675395e-02f, 7.00740814e-02f, 2.14745238e-01f, -4.44452055e-02f, 9.91044864e-02f, 1.11120865e-01f, 1.94429442e-01f, -5.53475954e-02f,
  -4.24087979e-02f, 3.07204247e-01f, 1.40599743e-01f, 2.51865417e-01f, 2.52747208e-01f, -4.30316925e-02f, 1.40144765e-01f, -4.67205830e-02f, 3.99846435e-02f, -1.29345074e-01f,
  -1.10097617e-01f, 3.85186039e-02f, 1.11918431e-02f, 7.88704082e-02f, 1.25679970e-01f, -1.22400008e-01f, 2.26647984e-02f, 3.02674115e-01f, -6.43195659e-02f, 2.47444928e-01f,
  -1.68169588e-01f, 2.30123196e-03f, -3.57917286e-02f, -9.37424414e-03f, -7.28846863e-02f, -4.02086303e-02f, -1.51230702e-02f, 6.48514181e-02f, -1.12734862e-01f, 6.17669243e-03f,
  -1.56396404e-01f, -1.11160524e-01f, 1.15586296e-02f, -1.32565960e-01f, 2.65888385e-02f, -3.55889350e-02f, 2.52805203e-01f, 4.78630960e-02f, 1.84951872e-01f, 1.18689448e-01f,
  9.30612460e-02f, -1.47217900e-01f, -3.39587867e-01f, 2.22609892e-01f, -3.22096139e-01f, -1.16391219e-01f, 9.30089578e-02f, 2.49102250e-01f, 5.76591417e-02f, 3.80484462e-01f,
  -2.50300020e-02f, 1.78404123e-01f, 8.98367018e-02f, 1.92773759e-01f, -6.27071634e-02f, 6.67584121e-01f, -3.59698325e-01f, -3.21320593e-02f, 5.26498370e-02f, 1.19857617e-01f,
  -2.17406034e-01f, 2.33366162e-01f, 4.76488061e-02f, 2.17496768e-01f, -1.64648846e-01f, 1.16440505e-01f, -1.23428531e-01f, 3.14717405e-02f, 1.64055124e-01f, 7.42899328e-02f,
  2.23556623e-01f, 1.84659228e-01f, 2.34947234e-01f, 1.89757153e-01f, 3.91165853e-01f, -3.89598131e-01f, 6.60307586e-01f, 1.40122965e-01f, -1.89833403e-01f, 1.33964270e-01f,
  2.35428989e-01f, 3.90719414e-01f, 9.29540247e-02f, 2.52659917e-01f, -1.73820585e-01f, 1.43208995e-01f, -1.83344603e-01f, -3.68443400e-01f, 2.66876370e-01f, 1.71085015e-01f,
  -4.93317991e-02f, -2.54344996e-02f, -9.63501725e-03f, 1.41456559e-01f, -4.31356244e-02f, -3.27617198e-01f, 3.78117323e-01f, 3.64146411e-01f, 1.61235735e-01f, 3.59246254e-01f,
  3.29806268e-01f, -2.80813038e-01f, -5.54504804e-02f, -9.86162946e-02f, 8.00181925e-02f, -1.16091624e-01f, 1.60157546e-01f, -1.67685971e-01f, -1.83968782e-01f, 2.51755148e-01f,
  -1.48458600e-01f, 1.94300070e-01f, 1.78189371e-02f, -2.38133930e-02f, -1.54305458e-01f, -1.20871775e-01f, -1.02030404e-01f, -2.40418352e-02f, -3.37867141e-02f, 2.82435358e-01f,
  2.05750942e-01f, -1.78914666e-02f, 3.54303151e-01f, 1.21630698e-01f, -1.19865619e-01f, 5.88658713e-02f, -6.69097975e-02f, 1.33251250e-01f, 1.24718837e-01f, -1.72543228e-01f,
  1.25835061e-01f, -1.10712439e-01f, -1.08227916e-01f, -6.64989948e-02f, 7.69894123e-02f, 9.00571123e-02f, 1.26678959e-01f, -1.29189998e-01f, 2.01586813e-01f, 1.74377158e-01f,
  4.56605218e-02f, 6.04354590e-02f, -4.61116992e-02f, -6.97422922e-02f, 1.28164962e-01f, 9.99695528e-03f, 5.65032735e-02f, -1.40680343e-01f, 7.31729791e-02f, -1.44350575e-02f,
  2.27261826e-01f, -4.75090109e-02f, 2.11209163e-01f, 1.54390007e-01f, -5.47354110e-02f, -1.11602090e-01f, -2.77799759e-02f, -7.26429820e-02f, -6.71587959e-02f, 8.79711658e-02f,
  -8.39269012e-02f, -1.69284195e-01f, -9.48160067e-02f, 3.26894894e-02f, 4.88801710e-02f, 7.20561072e-02f, 3.71714860e-01f, 2.71353513e-01f, 2.07172483e-01f, -4.01591435e-02f,
  8.04177076e-02f, -1.73885305e-03f, 3.57617587e-01f, 7.39850774e-02f, -8.16271752e-02f, 1.44082382e-01f, 2.51485050e-01f, -3.41527969e-01f, -1.63291514e-01f, 8.56606588e-02f,
  -1.32041305e-01f, 2.08722338e-01f, -5.29508628e-02f, -1.14140129e-02f, 6.08292282e-01f, 1.29760127e-03f, 2.27765962e-01f, 1.01951011e-01f, 2.42028937e-01f, -1.97075903e-01f,
  3.51179332e-01f, 2.70760924e-01f, 2.25579545e-01f, 2.31450781e-01f, 2.40048230e-01f, 3.13618220e-02f, -1.40163889e-02f, 2.54407972e-01f, 1.73004478e-01f, -8.43407493e-03f,
  1.59525231e-01f, 1.61639191e-02f, 7.91189149e-02f, 7.89983943e-02f, 1.16206467e-01f, 6.23425618e-02f, 3.60752381e-02f, -7.09921448e-03f, -6.60729110e-02f, -2.29481921e-01f,
  -1.66184872e-01f, 6.78592622e-02f, 1.55745909e-01f, -1.07053332e-01f, 1.20602697e-01f, -2.09057853e-02f, 1.77150771e-01f, -1.00546300e-01f, -3.45244408e-02f, -1.33354127e-01f,
  1.81354553e-01f, -1.76348705e-02f, 1.22441798e-01f, 8.35758671e-02f, -5.45512739e-05f, 1.66958824e-01f, 1.33464649e-01f, 2.29342967e-01f, 2.03543797e-01f, -3.97920236e-02f,
  1.90256923e-01f, -4.69331145e-02f, -6.84485659e-02f, 8.87435302e-02f, -1.35504961e-01f, -9.00697038e-02f, -1.96129262e-01f, -1.34890512e-01f, 1.63991481e-01f, 2.87328325e-02f,
  1.45730063e-01f, 4.04241920e-01f, -1.18840434e-01f, 2.15402350e-01f, -1.27981082e-01f, -5.84751330e-02f, 1.45791575e-01f, 1.13942489e-01f, -5.79571128e-02f, -1.27540663e-01f,
  -1.35224700e-01f, -6.33005053e-02f, 1.11073121e-01f, 3.53707820e-02f, 8.75632614e-02f, 1.58092350e-01f, 1.24366768e-01f, -1.60618871e-02f, 1.01794526e-01f, -1.40344694e-01f,
  2.60731820e-02f, -5.88066466e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.49842107e-01f, 3.68021987e-02f, 2.93184608e-01f, -9.88282934e-02f, 2.21461147e-01f, -5.46377152e-02f, -8.00498649e-02f, 1.76938549e-01f, 1.15056939e-01f, 3.71494710e-01f,
  6.50305748e-02f, 1.00314453e-01f, -3.46874557e-02f, 3.17692384e-02f, 3.18100184e-01f, -6.86067939e-02f, -1.03757158e-03f, 7.50258565e-02f, -7.15410337e-02f, 2.84977049e-01f,
  3.09506506e-01f, 6.70745224e-02f, 1.54592112e-01f, 3.16211075e-01f, -2.41259243e-02f, 3.25073674e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.96716895e-02f, 1.70979470e-01f, 1.39871478e-01f, -1.82965577e-01f, -3.34017456e-01f, -3.32045376e-01f, -1.79522131e-02f, 1.54565826e-01f, 7.49969557e-02f, -5.80021460e-03f,
  1.95235521e-01f, -1.61368862e-01f, 1.32443905e-01f, -3.67756672e-02f, -1.67790264e-01f, -1.16057828e-01f, 1.87200621e-01f, 1.06600203e-01f, 1.55417651e-01f, -1.55019477e-01f,
  2.54689783e-01f, -6.84429556e-02f, 5.39512150e-02f, -1.06816068e-01f, -9.41684842e-03f, -1.26088485e-01f, -3.01652104e-01f, -7.62446895e-02f, 2.30169892e-01f, 2.46598452e-01f,
  2.16186136e-01f, -2.27331415e-01f, -2.57365972e-01f, 5.73845543e-02f, -1.87087923e-01f, 2.31043901e-02f, 1.12740565e-02f, 2.51721382e-01f, -2.56934366e-03f, 2.19126213e-02f,
  9.58062857e-02f, -3.44716683e-02f, 1.77803919e-01f, 1.77532941e-01f, -1.52729437e-01f, -2.97758847e-01f, 1.15681037e-01f, -1.16673090e-01f, 1.38751686e-01f, 1.82349812e-02f,
  1.09000258e-01f, 1.35381136e-03f, -4.78099026e-02f, 2.02792823e-01f, -3.52139324e-02f, 1.43026903e-01f, 1.77597374e-01f, 6.63194284e-02f, -1.67996599e-03f, 2.93259025e-01f,
  1.18905984e-01f, 3.96455787e-02f, -1.45666048e-01f, 3.81238014e-02f, -2.19448790e-01f, -1.44335225e-01f, -9.58324522e-02f, 1.27128735e-01f, 3.62522990e-01f, 2.93675959e-01f,
  -6.14418127e-02f, 8.35946873e-02f, -2.94927843e-02f, -1.78472355e-01f, -8.40676352e-02f, 1.17960386e-01f, 1.40830085e-01f, 2.28357688e-01f, 1.79849222e-01f, -1.71727329e-01f,
  4.65899780e-02f, -7.73386955e-02f, 1.79628711e-02f, 1.11171894e-01f, -3.23716044e-01f, -1.01907894e-01f, -9.88571569e-02f, 4.73755645e-03f, 9.01409704e-03f, -3.65046076e-02f,
  3.15351605e-01f, 1.41266197e-01f, 3.09341010e-02f, -1.64554998e-01f, 1.31078765e-01f, -3.95329334e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.79123506e-01f, 1.88406389e-02f, -6.12297431e-02f, -1.04253270e-01f, -1.68358490e-01f, 7.24113658e-02f, 1.32866800e-01f, 3.99377383e-02f, 2.47033276e-02f, -1.59409896e-01f,
  2.76892278e-02f, 1.02167532e-01f, -9.09940228e-02f, -9.74598601e-02f, -1.07827723e-01f, 3.70074958e-02f, -6.18870035e-02f, 5.29770274e-03f, 1.25840500e-01f, 3.63611877e-02f,
  1.50979431e-02f, 1.71063438e-01f, -1.38456121e-01f, -1.65863350e-01f, -1.99144371e-02f, 1.67980760e-01f, -1.12935312e-01f, 1.16510712e-01f, -1.13011330e-01f, 3.70873557e-03f,
  -1.11329727e-01f, -7.57901417e-03f, 4.27677413e-04f, 2.72425026e-01f, 2.98903406e-01f, 1.28303111e-01f, 2.55000472e-01f, -7.96514973e-02f, -1.03883501e-02f, 1.57370806e-01f,
  -1.33978173e-01f, 8.07413161e-02f, -3.21495503e-01f, 1.65554821e-01f, 3.86231579e-02f, 5.53971410e-01f, 7.14622140e-01f, 2.16899030e-02f, 3.78070734e-02f, -1.10484138e-01f,
  -1.74365833e-01f, 3.43896747e-01f, -1.98028803e-01f, -2.03868315e-01f, -2.92312317e-02f, -5.00547653e-03f, -1.33990690e-01f, 9.19573009e-02f, -4.37128395e-02f, -9.56505090e-02f,
  8.94589722e-02f, 1.38241932e-01f, 1.92135796e-01f, -4.90436070e-02f, 8.39980543e-02f, -1.71646565e-01f, -1.06106766e-01f, -1.47089943e-01f, 1.29469275e-01f, 1.48151413e-01f,
  9.72110182e-02f, -1.27310693e-01f, 2.14652270e-01f, 1.62633657e-01f, 5.90008458e-05f, -1.41733640e-03f, -1.67692333e-01f, 1.10641509e-01f, -1.75040275e-01f, 4.94939499e-02f,
  1.75540015e-01f, -6.52365535e-02f, 4.25190330e-02f, 1.52106091e-01f, -4.65558246e-02f, -5.28832618e-03f, 1.81975499e-01f, -5.43012954e-02f, 1.58594847e-01f, 1.16148129e-01f,
  2.77537018e-01f, 5.90396337e-02f, 7.81297460e-02f, -2.03650951e-01f, -1.63463533e-01f, 1.71174891e-02f, -6.06132038e-02f, -9.55819637e-02f, 1.59673765e-01f, -1.38538361e-01f,
  2.49087922e-02f, -7.98847750e-02f, -1.62337467e-01f, 1.50830746e-01f, -1.61980689e-01f, 4.93004965e-03f, 3.26323435e-02f, -1.56047493e-01f, -7.81737082e-03f, 7.60234296e-02f,
  -9.46775153e-02f, -8.43705516e-03f, -6.63394928e-02f, 3.08254473e-02f, -1.17246486e-01f, -7.77105838e-02f, -2.66682599e-02f, -3.04572899e-02f, 1.79168373e-01f, 1.28455102e-01f,
  -3.33870016e-02f, -8.52569193e-02f, 1.23782180e-01f, -1.58620238e-01f, -1.40557364e-01f, -1.07051656e-01f, -9.80099216e-02f, 5.97829632e-02f, 1.27958581e-01f, 1.70300961e-01f,
  -1.37437105e-01f, 5.77795841e-02f, -3.69457781e-01f, -3.28887850e-02f, -8.58500414e-03f, 1.65366888e-01f, 1.76041082e-01f, 2.13761911e-01f, 2.62811333e-01f, 5.67026474e-02f,
  1.19941108e-01f, -4.18193758e-01f, 4.42644686e-01f, 2.35030979e-01f, 1.58917144e-01f, 1.11690566e-01f, -5.57805635e-02f, -1.25919372e-01f, 2.74202138e-01f, 2.92603821e-01f,
  1.69607084e-02f, 1.12654995e-02f, 1.12681963e-01f, 2.18414471e-01f, -2.20643759e-01f, 2.62910038e-01f, 1.81550950e-01f, 3.82767677e-01f, 1.36563271e-01f, -1.21564083e-02f,
  -5.43886386e-02f, 1.42221943e-01f, -2.95601469e-02f, -1.09239765e-01f, 7.05704689e-02f, -1.38007868e-02f, 8.93428251e-02f, -1.55311525e-01f, -1.10020094e-01f, 1.17638201e-01f,
  -1.80598289e-01f, 1.84165969e-01f, 8.81506726e-02f, -2.57197209e-02f, 3.11798275e-01f, 1.14749573e-01f, 5.64733222e-02f, -1.42283395e-01f, 6.07064962e-02f, 1.32377399e-02f,
  -1.09121054e-01f, -1.43291682e-01f, -8.87065604e-02f, 1.31375223e-01f, -6.69471771e-02f, -8.25009942e-02f, 4.09952961e-02f, 2.52684146e-01f, -1.36349387e-02f, 7.76842535e-02f,
  -1.32563904e-01f, 1.99616253e-01f, 2.65577137e-01f, 3.98921035e-02f, 1.86516404e-01f, 2.51695842e-01f, -3.95291708e-02f, 7.45119005e-02f, -9.00547206e-03f, -8.69934186e-02f,
  4.19823319e-01f, 1.18738540e-01f, 3.03447604e-01f, -1.39551952e-01f, 6.37108386e-02f, -7.75988102e-02f, -3.43213439e-01f, 4.04278673e-02f, 1.29511431e-01f, 1.67203069e-01f,
  2.32041012e-02f, 9.60728526e-02f, -1.03827596e-01f, 1.40175432e-01f, -2.93230824e-02f, 2.20195130e-01f, 2.41681654e-02f, -9.62975025e-02f, 5.04544616e-01f, -1.50226101e-01f,
  -1.08327039e-01f, 1.19359396e-01f, 1.68546617e-01f, 1.08428299e-01f, -6.79354146e-02f, -1.24691382e-01f, -2.07390562e-02f, -1.38163632e-02f, 4.61771712e-02f, -1.14757895e-01f,
  -3.41105796e-02f, -1.40296772e-01f, 1.49154454e-01f, -1.30767390e-01f, 1.40588671e-01f, -2.47083381e-02f, 5.77858537e-02f, -1.08557306e-01f, 1.52212203e-01f, -1.64922982e-01f,
  8.58433992e-02f, -1.18313484e-01f, -1.34216771e-02f, -4.63611968e-02f, 9.40453783e-02f, -4.27438468e-02f, 4.37334850e-02f, -2.47723758e-02f, -1.36317030e-01f, -1.54366106e-01f,
  -1.40099332e-01f, -1.15223922e-01f, 7.06390515e-02f, -1.20761499e-01f, -8.71798111e-05f, -1.40961215e-01f, -1.02326684e-01f, -1.44871965e-01f, 1.40167937e-01f, -6.07891642e-02f,
  -3.53075303e-02f, 1.62209868e-01f, 8.24354291e-02f, 8.59927386e-02f, 8.99362043e-02f, 1.74579889e-01f, -1.25991568e-01f, -1.26163125e-01f, 6.73836768e-02f, 7.62201250e-02f,
  -1.56015694e-01f, 7.76909888e-02f, -6.23558015e-02f, 1.59992680e-01f, 5.92580661e-02f, -1.13679789e-01f, 1.55709982e-02f, -2.45974157e-02f, 6.97555244e-02f, -7.49478936e-02f,
  1.02185585e-01f, 4.78078499e-02f, 1.63961034e-02f, -5.89231886e-02f, 1.11507207e-01f, -1.26255527e-01f, -1.26474679e-01f, -1.13235198e-01f, -1.34198934e-01f, 8.49752501e-03f,
  2.82541156e-01f, 2.87387639e-01f, -3.98551971e-02f, -2.88731873e-01f, -1.81197524e-01f, 4.69969362e-02f, -1.90180227e-01f, -1.60619184e-01f, 8.09246823e-02f, 2.95048982e-01f,
  8.91757980e-02f, 5.10775782e-02f, 6.96842372e-01f, 1.64102688e-01f, -1.13988332e-01f, -1.10021712e-04f, 1.67569920e-01f, -1.86900124e-02f, 1.59789443e-01f, 8.45052302e-02f,
  -2.46722531e-02f, 2.10222468e-01f, -1.32498518e-01f, -3.13823581e-01f, 3.39988947e-01f, 2.31499076e-01f, -5.90870790e-02f, 5.73160589e-01f, 2.38397151e-01f, -1.18735977e-01f,
  -1.18763193e-01f, -1.14537470e-01f, -1.49978802e-01f, 1.74285084e-01f, -1.46597326e-01f, 1.37246445e-01f, -1.08934745e-01f, -8.33146572e-02f, -5.21835946e-02f, -1.75053984e-01f,
  -1.26229823e-01f, -1.55958245e-02f, 1.35081694e-01f, -1.14133373e-01f, 4.10554931e-02f, -1.21849015e-01f, -6.78615645e-02f, 1.62522763e-01f, 9.52506512e-02f, -1.72298208e-01f,
  -5.00934236e-02f, -1.25234261e-01f, 7.82058164e-02f, -1.65874198e-01f, -1.25873834e-01f, -1.73346717e-02f, -9.28735137e-02f, 1.71481922e-01f, -6.12317701e-04f, 1.75202750e-02f,
  1.35507867e-01f, -1.34765595e-01f, 2.03403324e-01f, 2.87431955e-01f, 1.00822851e-01f, 4.57597077e-01f, 5.65862767e-02f, -2.77345508e-01f, -2.34967217e-01f, 1.40022218e-01f,
  1.25634253e-01f, 1.26263887e-01f, 1.34548634e-01f, 1.32879362e-01f, 1.25760615e-01f, 6.18227711e-03f, -1.97332688e-02f, -2.92757526e-02f, 1.72905996e-02f, 4.47217524e-02f,
  -1.28142551e-01f, -5.90838455e-02f, 4.90429252e-03f, 9.80466697e-03f, 6.44973591e-02f, 3.71602893e-01f, -3.01163457e-02f, -3.29152554e-01f, 7.39191473e-01f, -1.51133433e-01f,
  -5.91837130e-02f, 3.47320974e-01f, 1.87848881e-01f, 7.35876486e-02f, 1.00942083e-01f, 7.38993511e-02f, 1.21511914e-01f, 1.93601176e-01f, -1.89415179e-04f, -9.27701145e-02f,
  -2.40479689e-02f, 1.25180408e-02f, -2.74636447e-02f, 3.23611833e-02f, 4.86061759e-02f, 5.66835478e-02f, -4.25079465e-03f, 1.03780799e-01f, -3.11149597e-01f, 6.25346601e-02f,
  6.84244931e-02f, 1.50597095e-01f, -1.40756994e-01f, -9.09656137e-02f, -3.54191810e-02f, -4.99420017e-02f, 1.14314184e-01f, 5.69771342e-02f, 6.26630336e-02f, -1.55998483e-01f,
  3.61583412e-01f, 4.02771719e-02f, 2.04663232e-01f, 1.22117996e-01f, 1.56253323e-01f, -1.39965534e-01f, -1.03269167e-01f, -6.39293939e-02f, -1.66620523e-01f, -1.53177604e-01f,
  1.50317058e-01f, 9.15851220e-02f, 1.44669533e-01f, 1.12065904e-01f, -1.02274261e-01f, 1.55840218e-01f, -1.38005419e-02f, 1.50458023e-01f, 1.56752422e-01f, -1.29650056e-01f,
  1.64793462e-01f, 2.09854439e-01f, 1.91029310e-01f, -9.84378830e-02f, -4.79904413e-02f, -7.99015984e-02f, -1.02249689e-01f, 8.79675075e-02f, -6.02556719e-03f, -1.50760025e-01f,
  -1.32516533e-01f, 2.14222088e-01f, -8.43089446e-02f, 7.10684285e-02f, 8.02198946e-02f, -1.24020927e-01f, -1.74806178e-01f, -1.46886259e-01f, 2.83828735e-01f, 2.02802032e-01f,
  2.39014074e-01f, 1.57966241e-01f, 4.03706163e-01f, 3.18922102e-01f, -6.78862780e-02f, -1.24432139e-01f, 4.75725204e-01f, -1.23806350e-01f, 2.81124175e-01f, 1.38461068e-01f,
  -1.35746434e-01f, 4.63581532e-01f, -2.44701281e-01f, 3.33650231e-01f, 1.94207564e-01f, 2.41104499e-01f, 5.37543558e-02f, 5.33612408e-02f, -2.78327882e-01f, -8.63941386e-02f,
  3.11415672e-01f, 4.59953070e-01f, 2.63465017e-01f, 5.90578392e-02f, 6.80913687e-01f, -2.64770240e-01f, 7.99738914e-02f, -5.70303649e-02f, 5.14139188e-03f, 2.01916933e-01f,
  1.21575624e-01f, 2.08440572e-01f, 6.15980802e-03f, 7.06441788e-05f, -3.41392219e-01f, -2.60881335e-01f, 1.25749156e-01f, 7.66485929e-02f, -3.33234183e-02f, 3.30970362e-02f,
  3.49113107e-01f, -2.64410209e-02f, -1.37679771e-01f, -1.07110187e-01f, -8.36537704e-02f, 7.01263919e-02f, 1.09750785e-01f, -4.58362140e-02f, -1.54605508e-02f, -5.41609675e-02f,
  3.10939580e-01f, 1.96404055e-01f, -1.55842468e-01f, -1.22353405e-01f, 6.44218689e-03f, 2.08418936e-01f, 2.71891803e-02f, -4.03908379e-02f, 1.47383958e-01f, 1.68737769e-01f,
  -9.87954214e-02f, 5.53860255e-02f, 1.54870272e-01f, 1.36006907e-01f, 1.63746253e-01f, -2.37818152e-01f, -1.53769031e-02f, 3.79720330e-02f, 3.29494596e-01f, -1.75357506e-01f,
  -1.30585685e-01f, 1.57845154e-01f, 1.43375676e-02f, -1.84721723e-01f, 7.85549879e-02f, 7.17593729e-02f, 6.38216019e-01f, 4.82818604e-01f, 2.50550687e-01f, 5.99479973e-02f,
  -2.42522806e-02f, 3.48625064e-01f, 1.68537423e-01f, 1.25612006e-01f, -1.38533562e-01f, 8.64508525e-02f, 1.52681336e-01f, 5.38978159e-01f, 8.18525553e-02f, 6.58172667e-02f,
  -1.89787164e-01f, 1.47994131e-01f, -7.29815811e-02f, 2.78430432e-01f, 2.28766039e-01f, 2.82614142e-01f, 1.56248450e-01f, 5.15964851e-02f, -1.32743627e-01f, -3.99507761e-01f,
  -1.20099671e-01f, 3.08927819e-02f, -1.72327161e-01f, -9.77490768e-02f, -1.78302482e-01f, 2.21506879e-02f, -1.56911314e-01f, 1.72062978e-01f, 6.89588130e-01f, 1.91092938e-01f,
  -2.34854415e-01f, -8.14610422e-02f, 1.18937515e-01f, -8.15341920e-02f, -8.64592288e-03f, -1.23898514e-01f, -2.39188746e-02f, 1.56908125e-01f, 7.62859806e-02f, -2.22797796e-01f,
  1.90453067e-01f, -1.60476029e-01f, 8.81207809e-02f, 5.06484449e-01f, 5.19941300e-02f, -9.02438238e-02f, -9.03006867e-02f, -8.56153592e-02f, -1.63642094e-01f, -2.01082826e-01f,
  -1.62394807e-01f, -4.34820130e-02f, -2.04337891e-02f, -5.14641777e-02f, 2.83200741e-01f, 1.73835695e-01f, 4.28958893e-01f, -1.23970702e-01f, -1.81489736e-02f, -1.92046463e-01f,
  1.50484696e-01f, 1.49857745e-01f, 2.21692890e-01f, -1.08886257e-01f, -5.05943596e-02f, -2.06235498e-01f, 2.46895596e-01f, 6.82306141e-02f, -1.72308013e-01f, 1.16114408e-01f,
  -9.79946703e-02f, 2.00311571e-01f, -9.94399488e-02f, 1.43489584e-01f, 6.30202293e-02f, 8.62395950e-03f, 9.89013352e-03f, -8.60959142e-02f, 3.86299610e-01f, 1.44824013e-01f,
  1.18283235e-01f, -1.03955001e-01f, 1.73588432e-02f, -1.22676574e-01f, 2.73330927e-01f, 1.48593009e-01f, 2.00763419e-01f, -1.33960828e-01f, 4.07609701e-01f, -9.04827043e-02f,
  -8.49596318e-03f, -3.05856969e-02f, 2.34764278e-01f, 3.33017647e-01f, 1.44404352e-01f, -1.36588722e-01f, 5.19326963e-02f, -1.05289653e-01f, 3.43902767e-01f, -1.10460266e-01f,
  1.74134031e-01f, -9.50341225e-02f, -1.65978621e-03f, 4.36056405e-01f, -1.65588200e-01f, -1.77417547e-01f, -6.33221716e-02f, 9.12718549e-02f, 4.14472744e-02f, -6.13232367e-02f,
  1.73335224e-01f, 8.38586539e-02f, 2.46197373e-01f, 1.58407763e-01f, 6.21283874e-02f, -1.15058728e-01f, -1.02142625e-01f, -3.75896282e-02f, -1.24519020e-01f, -1.28549203e-01f,
  -1.41194716e-01f, -1.45504013e-01f, 1.27471074e-01f, 4.67497334e-02f, 2.49024457e-03f, 9.32791308e-02f, 1.54749408e-01f, -1.24299228e-01f, -8.28891024e-02f, -1.00702532e-01f,
  8.84597600e-02f, -1.36129484e-01f, 1.30056487e-02f, -3.59232840e-03f, 5.44875339e-02f, 1.75897971e-01f, 4.97449264e-02f, 6.44229352e-02f, 5.61000854e-02f, 2.68661708e-01f,
  1.94947913e-01f, -1.24816261e-01f, -1.41232505e-01f, -4.06707898e-02f, -8.59122351e-02f, 2.39071071e-01f, 1.68388531e-01f, -2.39134431e-02f, -7.19231963e-02f, 2.68120132e-03f,
  -8.27884898e-02f, -7.20122969e-03f, -5.93306534e-02f, 7.95773193e-02f, -1.50887176e-01f, -5.56668565e-02f, 1.84162244e-01f, 1.55077219e-01f, 9.80997309e-02f, 7.03948513e-02f,
  -9.74421650e-02f, -7.10237399e-02f, -2.12420821e-01f, 1.50137916e-01f, -1.65497601e-01f, 1.93305627e-01f, 1.53442025e-02f, 1.16880372e-01f, 2.30700135e-01f, -1.04561210e-01f,
  -1.60366923e-01f, 2.87912041e-01f, 3.18251587e-02f, 1.01017162e-01f, 1.15931286e-02f, -2.92537883e-02f, 1.96436226e-01f, 3.89349937e-01f, -2.69210577e-01f, -3.72164547e-01f,
  -8.64783823e-02f, -1.30778491e-01f, 8.12020004e-02f, 9.57334936e-02f, 2.09259301e-01f, 2.94896178e-02f, 1.68366581e-02f, -2.79786110e-01f, 4.51389879e-01f, 5.65466173e-02f,
  -1.13221318e-01f, 1.32803559e-01f, -1.03166260e-01f, -2.34492235e-02f, 1.12445712e-01f, 5.88882379e-02f, 5.29891551e-02f, 1.83194373e-02f, -1.59655288e-01f, -2.81392574e-01f,
  3.61815929e-01f, -8.94360915e-02f, 2.66071379e-01f, 5.65175056e-01f, 8.44948813e-02f, -1.29126504e-01f, 3.37091297e-01f, 2.01128498e-01f, -5.62789813e-02f, -2.93503463e-01f,
  1.49327114e-01f, 2.10440472e-01f, 4.59339201e-01f, 1.18569821e-01f, 2.93823689e-01f, 1.06410580e-02f, 3.28902751e-01f, -1.89990595e-01f, 4.16068360e-03f, 6.50056452e-02f,
  9.46699753e-02f, 4.20320362e-01f, 1.46723524e-01f, -1.24910735e-01f, 6.35679513e-02f, 2.57560879e-01f, 3.69894892e-01f, -1.15945116e-01f, -2.18190365e-02f, -5.37435897e-02f,
  2.40916789e-01f, 5.52679300e-01f, -3.50321084e-01f, -1.27740949e-01f, 8.18441212e-02f, -1.11257315e-01f, 3.89921777e-02f, 2.11796418e-01f, -1.69787500e-02f, -7.22453594e-02f,
  -1.95302777e-02f, 2.38248095e-01f, -6.42764047e-02f, -2.49222472e-01f, 1.20583758e-01f, 1.07731618e-01f, 1.47334278e-01f, -1.36933282e-01f, 1.11754369e-02f, -1.70573555e-02f,
  1.06439166e-01f, -1.68072775e-01f, 1.15023375e-01f, -2.19858959e-02f, 3.08245178e-02f, 1.15013905e-01f, 1.67549238e-01f, -2.91336458e-02f, 1.10327207e-01f, 2.14474544e-01f,
  -1.06419693e-03f, -1.99952796e-02f, -4.21520323e-03f, -8.60182568e-02f, 7.16026053e-02f, 1.69301435e-01f, 9.75238979e-02f, 2.38517940e-01f, 2.91414056e-02f, -1.17954090e-01f,
  2.36464500e-01f, 2.32691109e-01f, 3.01162928e-01f, -1.11882180e-01f, 1.57227665e-01f, 2.00419605e-01f, 2.21340388e-01f, 1.62826374e-01f, 3.91300857e-01f, 1.04839787e-01f,
  3.95244122e-01f, -1.15745701e-01f, 1.37885377e-01f, 2.20304467e-02f, -1.40894979e-01f, -4.26295400e-02f, 2.48439625e-01f, 6.93932846e-02f, 7.36836940e-02f, 1.50586575e-01f,
  -1.03347242e-01f, 1.05532311e-01f, 2.98541605e-01f, 1.84833407e-01f, 7.99033567e-02f, 2.78132111e-01f, 2.59601682e-01f, -1.64731219e-01f, 1.45682395e-01f, -4.85807173e-02f,
  -7.41973966e-02f, -5.24046607e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -1.46279290e-01f, 7.54565224e-02f, -4.31519598e-02f, -9.80902910e-02f, 1.87431127e-01f, -1.45901404e-02f, 2.21703216e-01f, -3.13509777e-02f, -1.36001050e-01f, 1.47326156e-01f,
  9.55691934e-02f, 1.86045185e-01f, 2.32307211e-01f, -1.00135654e-01f, 1.46936610e-01f, 1.33821324e-01f, 2.20064715e-01f, 3.14986348e-01f, 3.18080969e-02f, 3.30446869e-01f,
  -8.91397744e-02f, 2.13908300e-01f, -4.64013219e-02f, 3.29053193e-01f, 7.89434537e-02f, 4.92356382e-02f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.22697733e-01f, -2.93886568e-02f, -1.78310603e-01f, -2.72673070e-01f, -1.85155779e-01f, -6.92465752e-02f, -1.21976927e-01f, 6.50220364e-02f, 1.64542988e-01f, 6.29803240e-02f,
  -1.88578561e-01f, 6.73211738e-03f, 6.40681311e-02f, 2.43191160e-02f, 8.38796794e-02f, -6.85557798e-02f, -9.01116058e-02f, 3.74695919e-02f, -1.34429693e-01f, -3.46229151e-02f,
  3.25039923e-01f, -1.81261465e-01f, -1.19406253e-01f, 1.15999777e-03f, 8.18348676e-03f, -7.20499232e-02f, -1.87927932e-01f, -1.10523701e-01f, 1.98035520e-02f, 1.01590812e-01f,
  -5.03761619e-02f, -7.62689114e-02f, 1.65015176e-01f, -4.11776174e-03f, 1.91938505e-01f, 3.79924253e-02f, 1.82372451e-01f, -9.03366655e-02f, -1.77397832e-01f, -2.13281289e-01f,
  9.88204330e-02f, -1.40771508e-01f, 8.72179419e-02f, -2.05848083e-01f, 6.64983690e-02f, 1.07769817e-01f, 7.70805329e-02f, -5.33737577e-02f, 1.57412812e-01f, 2.35460594e-01f,
  1.73620969e-01f, 1.87006555e-02f, 1.45706102e-01f, -9.04992521e-02f, -2.18334332e-01f, -3.43936495e-02f, -5.77807389e-02f, -1.03006795e-01f, -1.88406110e-01f, -1.19879551e-01f,
  1.73151106e-01f, -8.97719786e-02f, 2.10690368e-02f, 1.00468583e-01f, -2.76818007e-01f, -6.50035813e-02f, -1.69589818e-01f, 7.93372318e-02f, 1.62728652e-01f, 2.06274197e-01f,
  1.88059881e-01f, 5.02578020e-02f, -1.03555456e-01f, 1.50776044e-01f, 1.50531083e-01f, 5.92691973e-02f, 6.59151673e-02f, 1.60294563e-01f, 9.83248502e-02f, 2.81606257e-01f,
  -1.69656754e-01f, 5.81885353e-02f, -5.87936006e-02f, -1.34937644e-01f, -9.81722996e-02f, 1.07163228e-01f, -1.63989514e-01f, -8.53314400e-02f, 1.53134912e-01f, -3.44793871e-02f,
  -1.21560365e-01f, -1.11651562e-01f, 5.11959605e-02f, -1.06265292e-01f, 6.12027496e-02f, -2.11046776e-03f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.14980349e-01f, 4.19890761e-01f, 1.39495254e-01f, -2.65760422e-01f, -1.68002784e-01f, 2.38719538e-01f, -7.07771182e-02f, -1.66740254e-01f, 3.08182955e-01f, -9.68490541e-02f,
  -8.25793669e-02f, -2.59996235e-01f, 5.42068005e-01f, 9.86396074e-02f, -1.15945913e-01f, -1.38508573e-01f, 1.41815364e-01f, 5.95434546e-01f, 1.77440494e-01f, -1.13186194e-02f,
  8.18927228e-01f, 1.40642419e-01f, -5.23317382e-02f, 6.18364736e-02f, 2.63835862e-02f, -2.28920486e-03f, -9.85998437e-02f, -7.59611577e-02f, 1.38212427e-01f, -1.42501788e-02f,
  -1.11082494e-01f, 5.28469086e-01f, -1.81851089e-01f, 1.42699078e-01f, -1.48603827e-01f, -1.09794043e-01f, 5.08139729e-02f, -1.10156693e-01f, 1.65012762e-01f, 1.85919076e-01f,
  -2.00607516e-02f, 3.30523439e-02f, -1.74594551e-01f, -7.06011355e-02f, 1.92104708e-02f, -6.34482354e-02f, 2.78703552e-02f, 4.86945286e-02f, -8.93368572e-02f, 1.38204306e-01f,
  1.43421337e-01f, 2.90920157e-02f, 1.66021718e-03f, -1.85277179e-01f, 1.15708105e-01f, -1.36611015e-01f, -8.59632790e-02f, -6.62315637e-02f, -1.75172493e-01f, 1.06358320e-01f,
  8.26232973e-03f, 1.00208998e-01f, -1.37891859e-01f, -7.22840577e-02f, -8.31905454e-02f, 4.74657118e-02f, -1.22896791e-01f, 2.40803942e-01f, 4.30254668e-01f, -6.26504123e-02f,
  -1.16092287e-01f, -4.81175721e-01f, 2.54219174e-02f, 1.80436790e-01f, 5.15150189e-01f, -6.12891503e-02f, 4.10695076e-01f, 1.56891152e-01f, -3.39694247e-02f, 3.74209702e-01f,
  1.27280235e-01f, 4.69977319e-01f, 3.14684361e-02f, 1.19469441e-01f, 2.89112367e-02f, 2.85475135e-01f, -2.65818864e-01f, -1.29863666e-02f, 3.71997684e-01f, 2.21480597e-02f,
  -7.73026496e-02f, 2.26751536e-01f, 5.76446235e-01f, -2.54133344e-01f, 3.83868158e-01f, -2.31669080e-02f, 2.92805225e-01f, 3.35000366e-01f, 1.65904015e-01f, 2.15301476e-02f,
  -1.00780241e-01f, 2.07123011e-01f, 3.16848932e-03f, 1.00414932e-01f, 1.61109030e-01f, 5.14589958e-02f, -2.57569849e-01f, -1.18359942e-02f, 2.79947042e-01f, 6.99308068e-02f,
  3.98562476e-02f, -1.15260417e-02f, -6.44236580e-02f, 1.48918852e-01f, 2.39114776e-01f, 9.69364867e-02f, 2.26432875e-01f, -1.58125877e-01f, 5.52194528e-02f, 1.60962448e-01f,
  -2.21515864e-01f, 1.91550881e-01f, 1.37348488e-01f, -8.84749964e-02f, -1.95029989e-01f, -1.64581556e-02f, 9.85459387e-02f, 2.18498811e-01f, -1.54301554e-01f, 9.82419625e-02f,
  -1.63426593e-01f, -1.13811210e-01f, -8.59733820e-02f, -1.26650155e-01f, 1.45897388e-01f, -3.60291777e-03f, -7.16623664e-02f, -6.58341572e-02f, 8.38816985e-02f, 1.19181305e-01f,
  5.95228234e-03f, 5.48728853e-02f, 1.33054689e-01f, -9.90140960e-02f, -1.01345025e-01f, 4.58108336e-02f, -1.20317906e-01f, -1.49842247e-01f, -8.47845450e-02f, -1.71789348e-01f,
  4.60511334e-02f, 2.69030444e-02f, 3.95207899e-03f, 1.81888638e-03f, -5.01125082e-02f, -4.69372049e-02f, -3.80048007e-02f, -1.05609380e-01f, -9.07060504e-02f, 1.13516502e-01f,
  -2.25698128e-02f, 4.59314836e-03f, 1.19828442e-02f, 1.12603428e-02f, 1.35475591e-01f, -5.69162779e-02f, 5.72863258e-02f, 1.06247827e-01f, -4.90714610e-02f, 1.58629626e-01f,
  -1.80899277e-01f, 8.73813108e-02f, -2.93481513e-04f, -7.64549449e-02f, 9.01216641e-02f, -1.68949645e-02f, 1.34699255e-01f, -1.67913407e-01f, 1.33409739e-01f, -7.55429491e-02f,
  5.57653955e-04f, 1.10268556e-01f, -4.43779752e-02f, 1.48897678e-01f, 4.26701643e-02f, 4.63739671e-02f, 1.16308123e-01f, -4.13093567e-02f, -8.70056674e-02f, -7.78345838e-02f,
  -6.52116984e-02f, -6.33131936e-02f, -7.87587687e-02f, -1.68855235e-01f, 2.26632860e-02f, -1.45182461e-01f, -1.35093570e-01f, 2.93317344e-02f, 2.83775739e-02f, -9.26845968e-02f,
  9.29911360e-02f, 1.74140692e-01f, -1.47599533e-01f, -6.99873120e-02f, -1.83986157e-01f, 5.90449087e-02f, 6.98578432e-02f, 1.71699803e-02f, 9.69435275e-02f, 9.32760239e-02f,
  -5.17902225e-02f, 3.47301103e-02f, -8.00815783e-03f, -1.55310631e-01f, -1.10726483e-01f, -1.67171344e-01f, 3.82613279e-02f, -8.74969140e-02f, -1.00021705e-01f, 7.95705989e-02f,
  1.98787898e-02f, 1.60811692e-01f, -3.74088362e-02f, 7.46759996e-02f, 4.38045971e-02f, -4.51492071e-02f, -1.18895188e-01f, 2.03940883e-01f, -1.05993263e-01f, -1.60058752e-01f,
  -3.81130958e-03f, -1.44217327e-01f, -7.00789467e-02f, -1.54992700e-01f, -1.14552349e-01f, -1.68249920e-01f, 1.73687756e-01f, -2.37540784e-03f, -9.50166658e-02f, 1.38482988e-01f,
  -1.44044369e-01f, -1.11051098e-01f, -1.31069452e-01f, 8.21667239e-02f, -1.71763241e-01f, -2.83182841e-02f, 1.88983455e-01f, -1.09777525e-01f, 4.42011505e-02f, -5.65885380e-02f,
  1.10033967e-01f, -1.95088126e-02f, -4.62512523e-02f, 9.38712284e-02f, -1.63572043e-01f, 4.93052714e-02f, 3.96342307e-01f, 3.17850500e-01f, 8.98655206e-02f, 3.20401043e-01f,
  -5.06910086e-02f, -1.76587895e-01f, 1.53537720e-01f, 6.06494769e-02f, -3.13115753e-02f, 1.09736912e-01f, 3.20558041e-01f, -1.55655697e-01f, -9.66240466e-02f, 1.14957310e-01f,
  -1.25163987e-01f, -1.32798359e-01f, 1.29665434e-01f, -1.78789765e-01f, -2.70810962e-01f, 4.49742153e-02f, -9.79890600e-02f, 3.33365291e-01f, 6.18074656e-01f, -1.17926389e-01f,
  2.97940463e-01f, 5.86142063e-01f, 1.68525383e-01f, 9.11840051e-02f, -2.28907570e-01f, 6.98594272e-01f, -1.19128004e-01f, 8.55306983e-02f, -1.70392483e-01f, -1.06278352e-01f,
  6.17232956e-02f, 1.13608047e-01f, -1.39414415e-01f, -3.76507156e-02f, 1.65087044e-01f, -3.22990417e-02f, 1.45493239e-01f, 1.22579791e-01f, 3.62269394e-02f, 1.39575690e-01f,
  -5.28368093e-02f, 2.83621214e-02f, -1.31079435e-01f, 5.32630570e-02f, 5.12639545e-02f, 3.01908385e-02f, 1.23375058e-01f, -7.85565302e-02f, -1.13981456e-01f, 2.51575150e-02f,
  -4.85152081e-02f, -2.18802830e-03f, -6.60519823e-02f, -2.86550280e-02f, 5.73225580e-02f, -4.70155478e-02f, 2.97042187e-02f, -1.42321452e-01f, 1.55370504e-01f, -9.81730223e-02f,
  -5.85437119e-02f, 8.28919001e-03f, -1.06117509e-01f, -1.19615853e-01f, -1.24396957e-01f, -1.36905059e-01f, -7.39078000e-02f, -1.35063514e-01f, -5.35193719e-02f, -6.92623630e-02f,
  -3.58570591e-02f, -1.54262722e-01f, 4.43478227e-02f, 3.83445658e-02f, 6.71007559e-02f, 1.11664109e-01f, 1.61440447e-01f, 1.73044071e-01f, 5.84303401e-02f, 4.75014672e-02f,
  -1.00758038e-01f, -8.75325873e-02f, -8.19901377e-02f, -3.19865681e-02f, 8.76057073e-02f, -5.04173860e-02f, -1.37875840e-01f, 6.75101355e-02f, -1.60647765e-01f, -7.39851594e-02f,
  -4.12130542e-03f, -9.17532593e-02f, 2.17706740e-01f, 3.95599455e-01f, 5.35874777e-02f, 3.56381059e-01f, 9.21306387e-03f, -4.37635303e-01f, 3.69164795e-02f, 9.52704921e-02f,
  -6.84619248e-02f, -9.93596762e-02f, 4.34109569e-01f, -1.17072538e-01f, -7.07214847e-02f, -1.49516001e-01f, 1.04932837e-01f, -8.56510028e-02f, -1.02223791e-01f, -2.33938873e-01f,
  -1.55941486e-01f, -1.61772117e-01f, -3.04751456e-01f, 3.88594955e-01f, 1.90081298e-01f, 1.25895903e-01f, 3.12398940e-01f, 6.45702064e-01f, 2.93352660e-02f, -1.78433701e-01f,
  5.46094999e-02f, 4.68748182e-01f, 2.14886278e-01f, 3.33887875e-01f, 1.59012929e-01f, 2.30508238e-01f, 2.26412117e-01f, 7.52172843e-02f, -1.82292834e-01f, 4.68897820e-02f,
  1.18402533e-01f, 5.10734797e-01f, -3.78165543e-02f, -1.02574214e-01f, 3.03942531e-01f, 1.76710144e-01f, -8.84441882e-02f, 1.03306144e-01f, 2.60313749e-02f, 2.62302399e-01f,
  -1.15996778e-01f, -7.90862516e-02f, -1.25758469e-01f, -8.84211436e-02f, -2.65807062e-01f, 1.74035951e-02f, 5.25485635e-01f, 5.39618671e-01f, 9.58857685e-02f, 1.06538199e-01f,
  -7.48188272e-02f, 1.19978115e-01f, 2.37575695e-01f, 8.03409219e-02f, -5.00000007e-02f, -2.33940393e-01f, 3.15237403e-01f, 2.42773499e-02f, 2.39486322e-01f, 3.79188180e-01f,
  -1.35866150e-01f, -3.77807081e-01f, -9.37877037e-03f, -9.11476370e-03f, -7.54592717e-02f, -1.25442157e-02f, 2.33757660e-01f, -1.13030113e-01f, 1.23341076e-01f, 5.30328080e-02f,
  -3.90437841e-02f, 5.22292912e-01f, -1.47693902e-01f, 3.93325120e-01f, 3.18315059e-01f, -1.75314426e-01f, -1.27019286e-01f, 1.83565363e-01f, -7.74758980e-02f, 5.56325138e-01f,
  2.94177011e-02f, 6.21918216e-02f, 2.44833842e-01f, -1.93422846e-02f, 5.86539745e-01f, -1.19433150e-01f, 9.43286344e-02f, -2.21654788e-01f, -6.27664924e-02f, 2.84089614e-02f,
  8.62871588e-04f, -3.56352031e-01f, 9.54352412e-03f, 2.37228513e-01f, 1.08850144e-01f, 4.18219954e-01f, -1.73211187e-01f, -1.40375063e-01f, 2.72098988e-01f, 9.38080698e-02f,
  -1.60778806e-01f, -9.25820097e-02f, -1.75906017e-01f, 6.66850626e-01f, -1.76305864e-02f, 3.34263891e-01f, -8.79727602e-02f, -4.84802127e-02f, -8.06047991e-02f, -6.12228289e-02f,
  4.00784940e-01f, 6.41438961e-01f, -1.69414595e-01f, -2.38522030e-02f, 1.46775693e-01f, 4.01091218e-01f, 5.17257035e-01f, -3.87702435e-01f, 1.38001457e-01f, -2.83844680e-01f,
  8.06132853e-02f, -1.66009650e-01f, -1.10310875e-01f, -1.45828068e-01f, 1.33064449e-01f, 1.00552939e-01f, -7.75900409e-02f, -3.59154418e-02f, -1.18450195e-01f, -2.71315854e-02f,
  -1.62863523e-01f, 1.27515376e-01f, -1.22614421e-01f, 1.38907239e-01f, 1.11924678e-01f, 1.47598445e-01f, -1.61337182e-01f, 1.36438802e-01f, -1.53811350e-01f, 4.11683545e-02f,
  -9.62296650e-02f, -6.67628460e-03f, -1.69338226e-01f, -1.22329481e-01f, 4.73078489e-02f, 4.62602638e-02f, 8.90485197e-02f, 6.98485151e-02f, 1.12174772e-01f, -7.84148425e-02f,
  -1.14209289e-02f, 2.96198130e-02f, -1.69553772e-01f, -5.19117974e-02f, 5.33567853e-02f, -1.37109160e-01f, -3.85993309e-02f, -8.45364109e-02f, -1.33998971e-02f, -7.10031092e-02f,
  1.10074632e-01f, -6.26961812e-02f, 6.77188709e-02f, -1.71965063e-01f, 3.27342562e-02f, -4.04796191e-02f, 1.24126449e-01f, -1.47701964e-01f, 1.99783184e-02f, -1.46549866e-01f,
  3.18302400e-02f, 7.29566589e-02f, -5.98769225e-02f, 4.71012667e-03f, -5.70596308e-02f, 5.98817021e-02f, -1.44099504e-01f, 7.76772499e-02f, 3.77649441e-02f, -8.06687251e-02f,
  -8.88738707e-02f, -7.44030774e-02f, -1.19798638e-01f, 1.41640291e-01f, -4.82536368e-02f, 1.62734032e-01f, -1.63915157e-01f, 6.93434328e-02f, 1.57902390e-01f, -2.43537985e-02f,
  1.55899495e-01f, -1.47524625e-01f, 7.46735260e-02f, 4.90559302e-02f, -1.58876345e-01f, -1.27885975e-02f, 1.98288672e-02f, 7.33732134e-02f, -1.28593016e-02f, -1.16973221e-01f,
  -9.43088010e-02f, -2.36408692e-02f, 1.41040355e-01f, -6.55830726e-02f, -2.99962778e-02f, -7.79299438e-02f, -4.98287454e-02f, -1.25714540e-01f, 8.59672725e-02f, 4.90580648e-02f,
  -5.12280092e-02f, 1.28174767e-01f, -1.15400575e-01f, 6.51478916e-02f, 4.46198508e-02f, 1.99456289e-01f, -1.79615229e-01f, -1.37518615e-01f, 1.50547577e-02f, -5.23317866e-02f,
  1.96580067e-01f, 2.60831654e-01f, -4.85566221e-02f, 2.83627778e-01f, 3.50409150e-02f, -1.69553846e-01f, 7.78998360e-02f, 8.13680589e-02f, -8.13080743e-02f, 9.05803815e-02f,
  -1.27423760e-02f, 2.18214616e-01f, -1.34510845e-01f, -4.71793078e-02f, 2.02303212e-02f, -4.26994599e-02f, -7.92505965e-02f, -2.62370855e-01f, 2.97647774e-01f, 7.94733912e-02f,
  -1.13105185e-01f, -1.34536713e-01f, -1.44022852e-01f, 6.12388998e-02f, -1.67074040e-01f, 5.63205816e-02f, -9.49181095e-02f, 1.26803577e-01f, 6.38042241e-02f, 1.93811476e-01f,
  2.25822166e-01f, -4.20029074e-01f, 2.01399446e-01f, 2.84189671e-01f, -1.08449392e-01f, -1.49335369e-01f, 2.42443040e-01f, -1.73532292e-01f, 1.31245762e-01f, -1.36738494e-01f,
  3.29286337e-01f, -5.84587753e-02f, -7.20962808e-02f, -3.58987987e-01f, -1.26820147e-01f, -1.25967637e-01f, 6.45270273e-02f, 1.57595605e-01f, 8.28944087e-01f, -1.34645283e-01f,
  4.98795420e-01f, -4.14139658e-01f, 1.80124447e-01f, 3.83531302e-01f, -9.43195000e-02f, 6.98201731e-02f, -3.25122833e-01f, 6.54677331e-01f, -1.73325151e-01f, 5.26532412e-01f,
  -2.54394948e-01f, -1.67284250e-01f, -1.83129802e-01f, -7.79547095e-02f, 2.38063201e-01f, -1.68080240e-01f, 1.82476789e-01f, -1.60876766e-01f, 8.58059973e-02f, 7.93053955e-02f,
  1.81304947e-01f, 4.23458740e-02f, 1.07975360e-02f, -1.59033686e-01f, 3.42701077e-02f, 6.64404482e-02f, 1.60476223e-01f, -2.70237565e-01f, -5.90938888e-02f, -9.20723309e-04f,
  -2.14570805e-01f, -1.22978829e-01f, 3.81105006e-01f, -2.41043363e-02f, 2.31829315e-01f, 2.38228485e-01f, -3.52970622e-02f, -6.51518209e-03f, -1.57360122e-01f, 2.11882830e-01f,
  1.34032041e-01f, 5.25691658e-02f, -1.35175273e-01f, 1.01230152e-01f, -1.43027201e-01f, -1.26840994e-01f, 2.18909219e-01f, -7.77604133e-02f, 1.45699129e-01f, 2.07687184e-01f,
  -1.89466015e-01f, -1.10635631e-01f, 3.36013466e-01f, 2.60873467e-01f, -2.60884613e-01f, -1.27249761e-02f, 3.34634222e-02f, 2.47463286e-01f, 2.07390171e-02f, -2.17815027e-01f,
  -2.93742687e-01f, -6.27713501e-02f, -3.69117320e-01f, 1.22467056e-02f, 1.64809436e-01f, 1.70624465e-01f, -8.78073275e-03f, 1.08354799e-01f, 3.26487906e-02f, -1.36182651e-01f,
  2.23146960e-01f, 2.17499062e-01f, -1.05474959e-03f, -7.16465786e-02f, -2.60199178e-02f, 1.77041799e-01f, 1.17880233e-01f, 1.02965221e-01f, -1.71699435e-01f, -3.08316108e-02f,
  -1.17972672e-01f, 9.90597680e-02f, -6.04034699e-02f, -1.02803908e-01f, -2.94720270e-02f, -1.30268812e-01f, 8.66782516e-02f, -2.74995621e-02f, 1.50925681e-01f, -2.62748767e-02f,
  1.55102313e-01f, -4.65827286e-02f, 1.39892802e-01f, -7.69528598e-02f, 5.29119149e-02f, -5.66684268e-02f, -1.08857997e-01f, 1.92582354e-01f, 3.53668891e-02f, 4.94583510e-02f,
  -2.21402477e-02f, 1.43159956e-01f, 1.11110941e-01f, -1.35500208e-01f, 1.46079911e-02f, -8.77113547e-03f, 2.60122061e-01f, 5.09788143e-03f, 1.56964421e-01f, -2.79020816e-01f,
  -1.63684756e-01f, 3.75995249e-01f, 1.14139199e-01f, 5.23525476e-01f, -1.84474308e-02f, -1.49588913e-01f, -2.52417117e-01f, 5.32250293e-02f, 1.99772298e-01f, 1.61067694e-01f,
  -3.16033587e-02f, 4.95538980e-01f, -5.89591749e-02f, 5.86674750e-01f, 8.56842846e-02f, -1.51748434e-01f, 4.41624582e-01f, -3.45051557e-01f, -2.38963515e-02f, 1.70941666e-01f,
  -2.28358418e-01f, 2.66003963e-02f, 2.04081804e-01f, 2.51995832e-01f, 1.49098694e-01f, -2.84791410e-01f, 2.43586674e-02f, 1.18824184e-01f, -1.96113288e-01f, 7.12132528e-02f,
  -1.69639930e-01f, -2.51992464e-01f, 7.66408369e-02f, -1.21501284e-02f, 8.88327435e-02f, 1.56501934e-01f, 1.91312045e-01f, -1.50222391e-01f, -2.13137537e-01f, 1.08801216e-01f,
  1.25827253e-01f, 1.08324349e-01f, -1.30249575e-01f, 2.04127476e-01f, -3.56450714e-02f, 1.51735231e-01f, 6.25582933e-02f, 8.48376527e-02f, 2.21065581e-01f, -1.44211546e-01f,
  2.02040911e-01f, 2.29553059e-01f, -1.84926569e-01f, 1.11324653e-01f, 1.40223369e-01f, 1.79338366e-01f, -1.44195585e-02f, -1.74801964e-02f, -4.00333852e-02f, -1.55928805e-01f,
  7.29840919e-02f, 1.74990177e-01f, 3.88235040e-02f, 4.22427990e-02f, -1.71158351e-02f, 9.25472081e-02f, 1.09084815e-01f, 3.54621619e-01f, -1.67284995e-01f, -1.27786964e-01f,
  -1.38679698e-01f, 7.24213645e-02f, -2.39206433e-01f, -6.54718354e-02f, -4.57660556e-02f, 1.66446641e-01f, -9.71124843e-02f, 1.60212573e-02f, -1.51476115e-01f, -3.02020796e-02f,
  1.33842006e-01f, -1.52363673e-01f, 3.39099839e-02f, 3.62720490e-01f, -2.36831442e-01f, -2.61852238e-02f, -3.98841389e-02f, 1.07576959e-01f, -5.76081164e-02f, 8.57152976e-03f,
  9.52678844e-02f, 1.99122746e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.26956955e-01f, -4.85791564e-02f, 4.43257689e-02f, 3.27767581e-01f, -1.58098817e-01f, -1.79858338e-02f, -2.55438220e-02f, 1.91950351e-01f, 3.49342555e-01f, -1.83371589e-01f,
  3.31652351e-02f, 4.24515754e-01f, 1.49022177e-01f, 5.17824963e-02f, -7.55581781e-02f, -8.17651376e-02f, 4.26650532e-02f, -9.30012465e-02f, -1.18144684e-01f, 2.27603346e-01f,
  1.00789621e-01f, 1.05249591e-01f, -3.65977250e-02f, 3.29979211e-01f, 1.16803600e-02f, 2.46777251e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  5.63183203e-02f, 1.13600045e-01f, -2.45982960e-01f, 1.13474680e-02f, -1.89996064e-01f, 1.06044784e-01f, 1.05585088e-03f, 1.11819781e-01f, -6.26241118e-02f, 4.85523883e-03f,
  1.41584352e-01f, -9.72623304e-02f, -2.88740192e-02f, 1.12255551e-01f, -7.31889546e-01f, -1.89714655e-01f, 6.08696491e-02f, -7.22510219e-01f, -3.32049537e-03f, 2.86945522e-01f,
  6.60605609e-01f, -2.33749747e-02f, -9.40717310e-02f, 8.89436603e-02f, 1.25799729e-02f, -7.08509684e-01f, -1.57141045e-01f, -2.57018418e-03f, -8.91983286e-02f, 5.77867031e-01f,
  2.59675264e-01f, 1.47329092e-01f, 1.41615838e-01f, 4.36435282e-01f, 2.03277156e-01f, 5.19748509e-01f, -1.15349203e-01f, 2.02118903e-02f, 2.44139150e-01f, 1.71464443e-01f,
  -3.94964159e-01f, 2.05223158e-01f, 1.26436939e-02f, 1.24322586e-01f, 5.42652309e-02f, -1.00929908e-01f, -1.70620829e-01f, -9.56988782e-02f, -1.32107779e-01f, -1.95860952e-01f,
  1.75595228e-02f, -6.15901768e-01f, -1.01879211e-02f, 1.43842444e-01f, -7.53729343e-02f, -1.06213227e-01f, 2.55728483e-01f, 6.03388548e-01f, -5.53642847e-02f, -2.76611358e-01f,
  -1.96753502e-01f, 4.28574145e-01f, 4.50924426e-01f, -8.18858563e-04f, -2.95284808e-01f, -1.62765458e-01f, -8.47246647e-02f, 3.63573462e-01f, 3.48189294e-01f, -6.61282837e-02f,
  6.01749539e-01f, -9.88581553e-02f, -1.63524836e-01f, 1.15490697e-01f, 1.09214827e-01f, -1.66790083e-01f, -1.24409072e-01f, -1.54403955e-01f, -9.15340036e-02f, 1.03635289e-01f,
  -1.25668943e-02f, -2.64801711e-01f, -6.20894492e-01f, -5.65023124e-01f, -6.34875298e-01f, -1.36400104e-01f, 1.27590537e-01f, 1.82200685e-01f, -1.71238557e-01f, 8.24218333e-01f,
  7.87389055e-02f, -2.44394258e-01f, -1.13715865e-01f, -9.00506973e-02f, -1.73799247e-01f, -2.05833972e-01f, -1.21258676e-01f, -3.31716478e-01f, -1.31058991e-01f, 1.20609673e-03f,
  -2.80330271e-01f, 7.96403065e-02f, -5.28768063e-01f, -1.53871346e-03f, 3.73068213e-01f, -3.96554559e-01f, 4.06967141e-02f, 1.73874408e-01f, 9.56475437e-02f, -1.66637897e-01f,
  1.53536305e-01f, -1.58122942e-01f, 1.24697551e-01f, 3.41565669e-01f, 2.65400261e-01f, 3.60693127e-01f, 3.16848218e-01f, -3.93045321e-02f, 8.72425959e-02f, -3.43410932e-02f,
  -1.01506732e-01f, -7.53307700e-01f, 3.44250590e-01f, 2.18978018e-01f, -1.56209126e-01f, -5.71322143e-01f, -4.16076519e-02f, -1.51644051e-01f, -1.98804423e-01f, -1.44687220e-02f,
  4.15343232e-02f, -4.05134737e-01f, 3.41128588e-01f, 3.48972559e-01f, 9.36646909e-02f, 1.28557071e-01f, 7.76470900e-01f, -3.03097814e-01f, -5.66012412e-02f, -8.03569779e-02f,
  -1.02708131e-01f, -1.46061435e-01f, -2.91105151e-01f, -1.49584234e-01f, -8.13059285e-02f, 1.42669618e-01f, -1.48986541e-02f, 5.31956494e-01f, 3.33779037e-01f, -2.17129007e-01f,
  -1.37460887e-01f, -1.48677260e-01f, -2.29506090e-01f, -4.08217728e-01f, -1.33176222e-01f, -2.17795715e-01f, -4.77400181e-06f, 2.96002701e-02f, 9.79726389e-03f, -3.25003862e-01f,
  2.38083392e-01f, 3.94594580e-01f, 1.36306748e-01f, -2.35465869e-01f, -2.13939627e-03f, -2.51002997e-01f, 2.00605512e-01f, -3.63999903e-02f, -3.98058683e-01f, 2.63641447e-01f,
  5.08866608e-02f, -1.41523853e-01f, -2.17462145e-02f, -2.15480980e-02f, 6.19224161e-02f, 1.39789507e-01f, 5.77395558e-02f, -7.11734965e-02f, 1.56448305e-01f, 4.04264301e-01f,
  3.41815054e-01f, 1.43821925e-01f, -1.73952281e-01f, 3.52264382e-02f, -1.76637813e-01f, -1.17105722e-01f, -3.25379014e-01f, -3.22693080e-01f, 2.23290578e-01f, 3.42476457e-01f,
  6.71378598e-02f, 2.33264565e-01f, 3.62103879e-01f, 2.90158659e-01f, 1.58753991e-01f, -9.98863801e-02f, 4.50812936e-01f, 7.05449283e-02f, 3.45245212e-01f, -1.77567378e-01f,
  2.25441441e-01f, 3.97688985e-01f, 1.35638967e-01f, -9.56435315e-03f, 3.27476822e-02f, -1.15805574e-01f, 3.08135867e-01f, -4.98224199e-02f, -1.55334413e-01f, 4.16542023e-01f,
  -2.36433923e-01f, 2.91529387e-01f, -7.17960358e-01f, 2.44060289e-02f, -4.43633720e-02f, 1.52165368e-01f, -9.57881063e-02f, 2.03698635e-01f, -2.09283635e-01f, -3.28882337e-01f,
  -1.04538195e-01f, -5.80746457e-02f, -7.25697801e-02f, -2.40588844e-01f, -3.14056337e-01f, -3.91902804e-01f, -4.39955443e-01f, -2.16192901e-01f, -7.34749809e-02f, 2.26197645e-01f,
  -6.95002735e-01f, 1.14752106e-01f, 1.05057381e-01f, -2.89545864e-01f, 8.04238841e-02f, -1.47874027e-01f, -9.15893987e-02f, 3.31422612e-02f, -3.46254706e-01f, 1.01301439e-01f,
  -1.48300946e-01f, -4.12596256e-01f, 4.10468757e-01f, 3.24567929e-02f, 6.07269645e-01f, 1.04163950e-02f, -3.28465886e-02f, 1.60184890e-01f, 3.59577715e-01f, -9.21641216e-02f,
  8.22625831e-02f, 3.57333213e-01f, -2.06818879e-01f, 2.12162539e-01f, -2.23478433e-02f, 2.10947976e-01f, -2.69067846e-02f, -2.72262339e-02f, -3.27065289e-01f, -4.94919494e-02f,
  -2.86058813e-01f, -2.62128413e-01f, -5.10244854e-02f, -1.08451426e-01f, -4.23959136e-01f, -2.12417200e-01f, 2.34254654e-02f, -1.61709294e-01f, -1.72525659e-01f, -1.79080173e-01f,
  6.48805737e-01f, 9.66378897e-02f, -7.47658089e-02f, 1.85124457e-01f, -2.93529600e-01f, -5.64808607e-01f, -2.24830806e-01f, -6.46884590e-02f, -7.21613616e-02f, -6.59084618e-02f,
  1.28305301e-01f, 6.94908619e-01f, 3.29860449e-01f, -1.09946959e-01f, -1.03912599e-01f, -4.94871050e-01f, 7.21866116e-02f, -1.65379286e-01f, -1.11849479e-01f, -4.62423474e-01f,
  -3.31671424e-02f, 1.96346566e-02f, 3.93897027e-01f, 9.04598832e-02f, 6.70674622e-01f, -1.52567759e-01f, 5.47513723e-01f, 4.53513339e-02f, -1.02780059e-01f, 1.39102414e-01f,
  -1.59071714e-01f, 3.85429189e-02f, -5.07976651e-01f, -9.02577117e-02f, -1.75071940e-01f, -4.02414262e-01f, -5.64551651e-01f, 1.80007949e-01f, -1.87688723e-01f, 1.33780628e-01f,
  6.41010934e-03f, 1.41324267e-01f, -1.22967221e-01f, 1.63609779e-03f, -2.33531240e-02f, -2.07169771e-01f, -1.39387278e-02f, 5.53735197e-01f, -1.72422733e-02f, 2.25583315e-02f,
  3.35505038e-01f, -6.95040077e-02f, 2.65337467e-01f, -3.03955168e-01f, -5.50059915e-01f, -2.33050182e-01f, -3.09381515e-01f, -6.65011862e-03f, -5.70782542e-01f, -9.23180655e-02f,
  1.72392175e-01f, -1.40686691e-01f, -2.66032480e-02f, 1.27665579e-01f, 4.39615935e-01f, -5.33971339e-02f, -3.96459773e-02f, 5.62583566e-01f, 5.02837121e-01f, 1.57823756e-01f,
  -1.27651379e-01f, -1.45401165e-01f, 3.63564864e-02f, -3.43711935e-02f, -8.78311135e-03f, -2.62757957e-01f, -1.06407419e-01f, 2.83477157e-01f, -9.72212553e-02f, 9.48048308e-02f,
  -1.58005700e-01f, 3.15115154e-01f, -3.48365009e-01f, -2.55290955e-01f, 1.44830197e-01f, -2.65923947e-01f, -2.30887130e-01f, 1.85820833e-01f, -4.64397907e-01f, 8.33318233e-02f,
  5.55725470e-02f, -3.12197745e-01f, 1.06716514e-01f, 2.15016771e-02f, -1.35991186e-01f, 1.23574190e-01f, 6.18063927e-01f, -4.02225405e-02f, 9.97645855e-02f, 6.30194485e-01f,
  6.80084005e-02f, -1.66371718e-01f, -4.34348911e-01f, -9.60631520e-02f, -4.99846525e-02f, 1.01524904e-01f, -1.73022732e-01f, 9.15888101e-02f, 3.99361342e-01f, 3.75476450e-01f,
  -6.43948242e-02f, -6.04988575e-01f, -2.17747629e-01f, -2.48513952e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.60296264e-02f, -4.81735263e-03f, -7.15302899e-02f, -2.24875182e-01f, 7.10531324e-02f, 2.89048523e-01f, 2.92910039e-01f, -3.36021245e-01f, -9.19991285e-02f, 6.31673932e-02f,
  1.86473310e-01f, 5.52351363e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    