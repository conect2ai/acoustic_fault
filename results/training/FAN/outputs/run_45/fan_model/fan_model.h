/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.20076478e-01f, -6.70789406e-02f, -5.96961081e-02f, -3.00489575e-01f, 1.06421657e-01f, -3.98489423e-02f, -1.46429669e-02f, -9.04806554e-02f, -1.96097746e-01f, -3.79781201e-02f,
  -6.10958971e-02f, -1.49434209e-01f, 2.35569361e-03f, -1.15092911e-01f, -4.25985344e-02f, -4.38186973e-02f, -1.13908365e-01f, -2.38818824e-01f, 6.37699813e-02f, -1.19770482e-01f,
  3.51023786e-02f, -6.42618239e-02f, -9.35894623e-02f, 8.82370323e-02f, -6.09334968e-02f, 6.66388543e-03f, -1.88916102e-01f, 8.66908878e-02f, 1.48988725e-03f, 2.65181661e-02f,
  -3.78813408e-03f, -9.36611816e-02f, 1.48774253e-03f, -7.55508803e-03f, -3.89672667e-02f, 2.84346659e-03f, -3.57067038e-04f, 5.45351282e-02f, 4.37827781e-02f, -2.56716809e-03f,
  -4.61748019e-02f, -2.72114780e-02f, 4.36461158e-02f, 9.31809694e-02f, 6.98285997e-02f, -1.61135290e-03f, 4.65464368e-02f, -2.23438311e-02f, -5.68367587e-03f, 8.19467753e-02f,
  -4.81990539e-02f, 2.56686248e-02f, -6.27033645e-03f, -3.35554816e-02f, 1.46687562e-02f, 4.58762795e-02f, -7.34753758e-02f, -2.17520036e-02f, -3.84323895e-02f, -4.68561053e-02f,
  -3.03792511e-03f, -3.12710879e-03f, -3.05661485e-02f, -8.54574814e-02f, 2.75159925e-02f, -2.52459217e-02f, 3.31406035e-02f, -6.28747493e-02f, 6.74030045e-03f, -2.68281829e-02f,
  -1.47144487e-02f, -3.23494412e-02f, -3.04440707e-02f, 8.34552571e-03f, 5.74957766e-02f, -9.89459455e-02f, -3.30799185e-02f, -5.47218397e-02f, -4.34273630e-02f, -1.01005388e-02f,
  -5.16690090e-02f, 6.89354390e-02f, -5.23414724e-02f, -2.18795203e-02f, 2.11342499e-02f, -1.75055873e-04f, -1.19474810e-02f, 3.21821347e-02f, -8.55491776e-03f, 9.48611498e-02f,
  -6.87381113e-03f, -2.08547577e-01f, -1.30580157e-01f, 1.60231926e-02f, 2.15630978e-02f, 2.02612206e-03f, 3.35097359e-03f, -6.02740534e-02f, 6.89372420e-02f, -1.65283848e-02f,
  -6.29628194e-04f, -3.73863205e-02f, -3.31459381e-02f, -3.36890593e-02f, -1.25617571e-02f, -4.03227955e-02f, -7.13730454e-02f, -6.21921532e-02f, -2.44211480e-02f, -4.94589321e-02f,
  -4.41298969e-02f, -3.11945081e-02f, 3.88241261e-02f, -4.97395471e-02f, 3.65834534e-02f, -6.67722523e-02f, -6.96357293e-03f, -4.30951454e-02f, 7.20802753e-04f, 3.20397713e-03f,
  -2.00554952e-01f, 4.99174535e-01f, -1.03687145e-01f, 3.47794384e-01f, -5.65210022e-02f, 2.87997395e-01f, -4.24996093e-02f, 1.70825034e-01f, 1.34372100e-01f, -7.78992549e-02f,
  -1.42322434e-02f, -6.74240515e-02f, -6.49337769e-02f, 1.73492283e-01f, 1.21160433e-01f, 1.10751539e-01f, 2.52107501e-01f, 8.03337619e-03f, 4.88582775e-02f, 4.13863510e-02f,
  5.11389636e-02f, 3.11267585e-01f, 3.19140330e-02f, 2.29152888e-01f, -6.51723891e-02f, 4.28702123e-02f, -1.51484192e-03f, -1.39236405e-01f, 3.25281769e-02f, 4.54200581e-02f,
  9.34724584e-02f, -5.15982509e-02f, -1.20487161e-01f, -4.93971184e-02f, -3.31397094e-02f, -9.09612998e-02f, -8.99255872e-02f, 1.62717681e-02f, -7.78920129e-02f, 1.85623411e-02f,
  3.42936045e-03f, -1.10735223e-02f, 5.90723455e-02f, -2.92531364e-02f, -1.83793958e-02f, -2.70301364e-02f, 7.76879340e-02f, 7.13123232e-02f, 4.28205822e-03f, -1.77539960e-02f,
  1.03099190e-01f, -2.36042645e-02f, -8.45451355e-02f, 2.45487411e-02f, 4.21048589e-02f, -9.65163764e-03f, -3.28147076e-02f, -1.34711578e-01f, 4.02197316e-02f, -4.86833118e-02f,
  -1.07921818e-02f, -1.92712322e-02f, 7.87387192e-02f, 5.15708141e-02f, -6.58552572e-02f, 5.16343862e-04f, 3.35305557e-02f, -8.70267004e-02f, 3.89500968e-02f, -2.39987094e-02f,
  4.24659327e-02f, 6.50644768e-03f, 9.50538833e-03f, -4.45136987e-02f, -1.30028399e-02f, -7.83472955e-02f, 1.52152320e-02f, -2.83194538e-02f, 1.97135117e-02f, -1.01669403e-02f,
  4.32957597e-02f, -8.45235772e-03f, 8.53000116e-03f, 3.91484424e-02f, -2.67778561e-02f, -7.82413185e-02f, 2.54697762e-02f, 2.68237107e-02f, 1.88026465e-02f, -6.37278333e-02f,
  2.68551428e-02f, -4.42316309e-02f, 6.40213639e-02f, 5.78915179e-02f, -7.27240462e-03f, 3.94335538e-02f, -2.16839947e-02f, 9.52743925e-03f, 7.40165189e-02f, -6.05713157e-03f,
  -9.57482681e-02f, 2.04685722e-02f, -3.75652649e-02f, -2.07945965e-02f, 4.32841703e-02f, 1.09206289e-01f, 1.56315453e-02f, 1.58048254e-02f, 3.07207983e-02f, 3.58574875e-02f,
  -4.14063148e-02f, -1.73007846e-02f, -6.58937404e-03f, 1.89825222e-02f, -9.92378294e-02f, -1.90042760e-02f, 2.23382656e-03f, 4.11121435e-02f, -2.27565095e-02f, 1.29720522e-02f,
  -6.92646444e-01f, -1.37920409e-01f, 7.93140307e-02f, -2.44850993e-01f, -2.23819539e-01f, -7.68064633e-02f, 1.39757171e-02f, -2.65120327e-01f, -3.95787507e-01f, -1.24913312e-01f,
  -3.50462832e-02f, -1.62756920e-01f, 9.06600580e-02f, -3.36511672e-01f, -1.16655841e-01f, -6.42602593e-02f, -1.51507065e-01f, -1.33939177e-01f, -1.11057535e-01f, -2.14479953e-01f,
  -1.62778467e-01f, -2.34794363e-01f, 1.77496731e-01f, -1.47904158e-01f, -1.19771548e-02f, -6.48646941e-03f, 5.37580438e-02f, 7.53025264e-02f, -8.82672146e-02f, 3.90334092e-02f,
  3.67695875e-02f, -1.09449774e-01f, -6.84698448e-02f, -2.51506269e-02f, 4.93623354e-02f, 7.36647546e-02f, 1.52036175e-01f, 1.12224363e-01f, -2.29604542e-02f, 3.42109241e-02f,
  5.38818422e-04f, -3.86074372e-02f, -1.29685119e-01f, -4.13545482e-02f, -1.17983401e-01f, -2.55831126e-02f, -2.82693305e-04f, -1.10494252e-02f, -1.10045336e-02f, -9.00664553e-03f,
  8.10538977e-02f, 8.01908821e-02f, -1.66970845e-02f, 2.45863236e-02f, 3.20632965e-03f, -7.80161768e-02f, 9.74212959e-02f, 4.47633527e-02f, -6.85895756e-02f, -6.56962395e-02f,
  -6.99090809e-02f, -6.61331266e-02f, 6.47945777e-02f, -2.51303464e-02f, 3.50208282e-02f, -4.93936706e-03f, 1.13365483e-02f, -2.16132831e-02f, 1.72662793e-03f, -3.47691178e-02f,
  -5.30853085e-02f, 3.18313576e-03f, -5.23317605e-02f, -8.59362409e-02f, -7.99237937e-03f, -3.26060946e-03f, 6.29200786e-02f, 1.58556215e-02f, 4.42189910e-02f, -2.50982773e-02f,
  4.96749282e-02f, -3.65059860e-02f, 3.60528231e-02f, 9.68878996e-03f, 2.30102707e-02f, 6.97485209e-02f, -7.78246745e-02f, -1.37523897e-02f, 1.12677850e-02f, 4.13353778e-02f,
  9.32298750e-02f, -1.34004176e-01f, -1.73959360e-02f, 3.44632106e-04f, -1.38935773e-02f, -8.52453411e-02f, -6.38636947e-02f, -6.33938983e-02f, -7.08744973e-02f, -4.53088023e-02f,
  4.46648784e-02f, 2.92079654e-02f, -3.58970836e-02f, 2.52159666e-02f, 5.18827625e-02f, 3.36174406e-02f, 6.54640701e-03f, 9.26773436e-03f, -5.20646609e-02f, 3.55113931e-02f,
  1.58970281e-02f, -2.33752187e-02f, 1.32619394e-02f, -3.04617286e-02f, -2.89374292e-02f, 1.32160140e-02f, -8.48595351e-02f, 4.98347916e-02f, 5.62935099e-02f, -6.93746209e-02f,
  2.07286626e-01f, 9.51352119e-02f, -1.15341134e-01f, 1.58502609e-01f, -1.25356033e-01f, 8.34536776e-02f, 2.46986598e-01f, -1.35221124e-01f, 4.21651192e-02f, -1.06586693e-02f,
  1.70055404e-01f, -7.93049261e-02f, 3.94803360e-02f, 1.91692129e-01f, 2.33597830e-01f, 1.07307285e-01f, 2.84475893e-01f, 6.62691817e-02f, 4.72093113e-02f, -7.41382167e-02f,
  1.14918306e-01f, 1.42014205e-01f, 8.52818936e-02f, -8.76463428e-02f, -5.57356961e-02f, -1.06058143e-01f, 1.34287402e-01f, -8.51351544e-02f, 7.05332169e-03f, -1.72679145e-02f,
  -6.48533627e-02f, -1.42007411e-01f, -2.07408443e-02f, 1.43180531e-03f, 1.15883071e-02f, -3.93166244e-02f, 1.81405097e-02f, -4.62116897e-02f, -3.61692831e-02f, -3.11517585e-02f,
  1.39110181e-02f, -1.22560620e-01f, 5.29233292e-02f, 2.38872506e-03f, -1.82282049e-02f, -1.11072354e-01f, -4.95640077e-02f, -2.83818189e-02f, -1.51610434e-01f, -2.57900730e-02f,
  -1.84712429e-02f, -4.48514000e-02f, 1.07521854e-01f, 4.13591368e-03f, 8.33201259e-02f, 1.53637007e-02f, -5.54054268e-02f, 1.07472821e-03f, -4.24203202e-02f, -4.01355363e-02f,
  -6.83692917e-02f, -6.56632287e-03f, -6.69425949e-02f, -1.46242429e-03f, -5.26063470e-03f, -3.38179842e-02f, 7.01785162e-02f, -1.28304034e-01f, -2.65189055e-02f, 4.24320996e-02f,
  -1.51541587e-02f, -2.13200748e-02f, -6.97724074e-02f, -5.51432297e-02f, 3.21835838e-02f, -3.15051526e-02f, 5.05316406e-02f, -6.95746019e-02f, 8.52012560e-02f, 1.71665214e-02f,
  -2.42443979e-02f, -1.35847917e-02f, -4.09402847e-02f, 8.31345990e-02f, 4.83540166e-03f, -4.84177545e-02f, -3.03678941e-02f, -5.22636175e-02f, 1.34437475e-02f, 8.33581463e-02f,
  2.76791990e-01f, 2.65923828e-01f, -3.65615524e-02f, -8.04267675e-02f, 7.41676567e-03f, 5.38881402e-03f, 1.55505585e-02f, -7.54081756e-02f, 8.53424817e-02f, 4.75291684e-02f,
  -9.24230181e-03f, 3.66273429e-03f, -7.81497173e-03f, -4.91971290e-03f, 2.51706280e-02f, 4.15454470e-02f, 3.36981602e-02f, 4.90654297e-02f, 1.17537476e-01f, -1.62304025e-02f,
  -1.96725894e-02f, -1.11123174e-02f, -3.76620926e-02f, -2.93942392e-02f, -4.32495065e-02f, -2.36275629e-03f, 6.87766001e-02f, -1.71687994e-02f, -3.81539911e-02f, 4.00714204e-02f,
  -3.59579891e-01f, -3.17253262e-01f, -2.92219013e-01f, -3.65406573e-01f, -6.52935058e-02f, -1.34537116e-01f, 2.28069440e-01f, 1.70442890e-02f, -1.85238898e-01f, 3.94069880e-01f,
  1.58907339e-01f, 2.59496085e-02f, 2.72271991e-01f, -1.45713324e-02f, -1.50557021e-02f, 1.27880111e-01f, -1.81619197e-01f, 6.48958832e-02f, -7.48720542e-02f, 9.43255723e-02f,
  -6.47899732e-02f, 5.23811057e-02f, 2.74936035e-02f, -6.23771623e-02f, 1.12855881e-01f, -1.75188825e-01f, 2.15466022e-01f, 2.66531520e-02f, 8.00517127e-02f, 1.19705533e-03f,
  5.65945543e-02f, 1.26801193e-01f, -4.46622036e-02f, -7.31513724e-02f, 8.08714982e-03f, -7.26898760e-02f, -3.91858853e-02f, -1.13354707e-02f, -8.68378878e-02f, 9.49819293e-03f,
  5.44810034e-02f, -1.81786083e-02f, 2.86960974e-02f, -3.16015445e-02f, -4.19820435e-02f, -7.25932717e-02f, -1.71999598e-03f, 2.33051311e-02f, 2.71110646e-02f, -4.92894948e-02f,
  -1.54406140e-02f, -3.06308679e-02f, -3.19443718e-02f, 1.30862398e-02f, -1.01530775e-01f, -8.19909722e-02f, -9.11925628e-04f, 2.25190129e-02f, -2.69149188e-02f, -5.45775034e-02f,
  8.40957910e-02f, 1.18299238e-02f, 1.72962714e-02f, 2.10062973e-02f, -1.50734317e-02f, -1.68556068e-02f, -1.19143846e-02f, 1.00882798e-01f, -8.85315463e-02f, 1.01207187e-02f,
  -2.04386450e-02f, -1.89190917e-02f, 2.07108408e-02f, -7.16851503e-02f, -2.85489429e-02f, 1.98328197e-02f, 4.70730439e-02f, 6.26636147e-02f, -2.38768961e-02f, -5.40822484e-02f,
  2.20026933e-02f, -1.82282627e-02f, -2.98098214e-02f, -2.42026877e-02f, 3.35303210e-02f, 3.77179906e-02f, -3.79911587e-02f, 7.10799098e-02f, -2.68568415e-02f, 3.50328460e-02f,
  1.29339574e-02f, 5.11889309e-02f, 2.05048844e-02f, 1.63593143e-02f, -1.17904838e-05f, 4.47761528e-02f, -5.06408364e-02f, 6.66165575e-02f, 2.71198340e-02f, 4.57487162e-03f,
  -2.84753013e-02f, -4.22156900e-02f, -6.18756935e-03f, 1.70599502e-02f, 9.18504037e-03f, 5.53682111e-02f, 2.03132369e-02f, -1.44604249e-02f, 2.61092484e-02f, 2.46973038e-02f,
  5.88454045e-02f, -6.39778823e-02f, -3.36336866e-02f, 3.91560085e-02f, -1.88628417e-02f, 6.05513863e-02f, -8.51081125e-03f, -8.53910893e-02f, 5.66682778e-03f, -7.66868098e-03f,
  -4.08411115e-01f, 1.60359904e-01f, -8.73587355e-02f, -1.64323494e-01f, -4.73435596e-02f, 1.86216995e-01f, 3.74828935e-01f, -9.02055502e-02f, 4.46365774e-02f, 3.33274394e-01f,
  -3.04261055e-02f, 8.06227550e-02f, 1.07190236e-01f, -3.25137116e-02f, -1.61289707e-01f, 2.30795592e-01f, -2.18476444e-01f, 4.79835197e-02f, 1.92401782e-02f, -1.26847103e-01f,
  -1.63440183e-01f, -1.57661930e-01f, -2.08891615e-01f, -1.96433544e-01f, -1.68675154e-01f, -1.58658177e-01f, -1.82467178e-01f, -2.26446930e-02f, -1.86151221e-01f, -6.16205782e-02f,
  -9.69656929e-02f, 3.98288220e-02f, -3.49009931e-02f, -2.01160926e-02f, -7.92713314e-02f, 4.21337597e-02f, 5.02363071e-02f, 2.92125754e-02f, 5.17644687e-03f, -1.00832358e-02f,
  3.93435210e-02f, 1.12136826e-02f, -4.09440733e-02f, -8.38797016e-04f, 3.30085568e-02f, 7.24811107e-02f, -4.16432917e-02f, 6.86342046e-02f, 5.36903143e-02f, 2.04892177e-02f,
  3.22186500e-02f, 5.04731201e-02f, -3.93334718e-04f, -6.94195461e-03f, -1.43981442e-01f, 4.86231744e-02f, 6.06693961e-02f, -4.11891451e-05f, -2.40055881e-02f, 3.06965457e-03f,
  -5.55077866e-02f, 9.12649110e-02f, 6.91644996e-02f, 7.55150691e-02f, 2.23092884e-02f, -5.36365695e-02f, 9.02588665e-03f, -1.77073218e-02f, 2.05170717e-02f, 4.44611069e-03f,
  -1.22334855e-02f, -1.37873413e-02f, -2.28123888e-02f, 1.19078815e-01f, -4.58860137e-02f, 8.62788707e-02f, -4.22920240e-03f, -9.34271328e-03f, -6.89932108e-02f, -1.26846402e-03f,
  1.77179351e-02f, 5.34604788e-02f, 5.42688221e-02f, -7.73239210e-02f, -1.42565295e-02f, 3.37804109e-02f, -1.75169595e-02f, 2.50315182e-02f, -5.24593052e-03f, -5.97133003e-02f,
  -1.14576016e-02f, -2.44184479e-01f, 3.52203287e-02f, -8.10051896e-03f, -1.73604563e-02f, -2.17087585e-02f, 3.42298695e-03f, -1.09131716e-01f, -4.50976491e-02f, -1.79180969e-02f,
  -7.53779784e-02f, 1.29646598e-03f, -1.02148466e-02f, -4.94445348e-03f, -4.23719510e-02f, -6.39575114e-03f, 6.02872856e-03f, 1.59661775e-03f, -8.01251233e-02f, -5.65520711e-02f,
  -3.66913378e-02f, -4.90544550e-02f, 1.15483776e-02f, -4.10139784e-02f, 7.45587572e-02f, -2.06418000e-02f, -4.44275625e-02f, -2.25180993e-03f, -2.31345557e-02f, 2.76495591e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.54718536e-01f, -2.76343197e-01f, -5.74962974e-01f, -3.46070319e-01f, 1.30121574e-01f, -5.16202331e-01f, -4.19641763e-01f, -1.21814452e-01f, 1.00385651e-01f, -1.42526859e-02f,
  -1.99628785e-01f, -2.59172842e-02f, 8.98987204e-02f, -2.38616094e-01f, -2.57229120e-01f, 1.55953448e-02f, -3.75240147e-01f, -1.41885176e-01f, 1.35319885e-02f, -2.68736452e-01f,
  -1.50682852e-01f, -2.06097215e-01f, -3.56401443e-01f, 2.73005515e-02f, -2.89324552e-01f, 1.10944100e-01f, 2.42876291e-01f, 3.30231240e-04f, -1.85419708e-01f, 3.52236032e-02f,
  -1.53910488e-01f, 5.64603098e-02f, -4.66513447e-02f, -2.42818408e-02f, -1.34783357e-01f, -6.74105734e-02f, -8.24299734e-03f, 1.39602059e-02f, 1.39733963e-02f, -5.64249381e-02f,
  -2.04957202e-02f, 5.12134582e-02f, -3.06431670e-02f, 6.49084076e-02f, -2.32003704e-02f, -1.50710354e-02f, -9.78859067e-02f, -1.92032417e-03f, -1.20601626e-02f, -1.72183439e-01f,
  -1.10912867e-01f, -1.21260658e-01f, -1.34369314e-01f, -3.52566619e-03f, -1.80041585e-02f, 2.44816057e-02f, -9.77258906e-02f, 2.92711817e-02f, -2.90216748e-02f, -2.38249172e-02f,
  -2.12189518e-02f, -9.20905825e-03f, -3.46993003e-03f, 3.44234072e-02f, -4.95857783e-02f, -5.91880362e-03f, -1.11703806e-01f, 6.13598078e-02f, 2.33164467e-02f, 1.64520964e-02f,
  3.09675448e-02f, 2.83543835e-03f, 2.80001871e-02f, -3.22860740e-02f, -1.33494094e-01f, 8.61517433e-03f, -2.71627028e-03f, 1.34835187e-02f, -1.80837959e-01f, 2.81049404e-02f,
  8.10336024e-02f, 5.74766425e-03f, 5.58402240e-02f, 1.08498642e-02f, -5.53244315e-02f, 3.21621797e-03f, -3.25503163e-02f, -1.78520568e-02f, -3.22747119e-02f, -5.41568659e-02f,
  -8.51757154e-02f, 5.68905938e-03f, 6.36317804e-02f, -1.90618867e-03f, 8.68118107e-02f, -3.50789838e-02f, -6.64711893e-02f, -9.03367102e-02f, -3.39962170e-02f, 5.15541919e-02f,
  -5.53272031e-02f, 5.71197867e-02f, 3.24533172e-02f, -8.04114416e-02f, -8.31810310e-02f, 3.21752653e-02f, 8.80014673e-02f, 6.48523048e-02f, -3.92665938e-02f, 2.72382256e-02f,
  4.23163697e-02f, 1.33137718e-01f, 1.97213013e-02f, -2.12345123e-02f, -9.70734004e-03f, -4.47575860e-02f, 1.46512777e-01f, 1.35538457e-02f, 2.99744159e-02f, -5.94729325e-03f,
  6.80036247e-01f, -1.78644553e-01f, -3.93781871e-01f, 1.83921084e-01f, 3.89066756e-01f, 2.42854685e-01f, -6.08132817e-02f, 2.03983083e-01f, -1.59660667e-01f, -1.38779832e-02f,
  1.59271762e-01f, -2.47775540e-01f, -3.81463587e-01f, 2.30260104e-01f, 2.64500529e-01f, -3.17596912e-01f, 2.33565778e-01f, 5.08677177e-02f, -7.98239782e-02f, 4.78269421e-02f,
  1.37997707e-02f, 5.33822119e-01f, -5.55859692e-02f, 3.34650785e-01f, 7.82758892e-02f, 4.61239397e-04f, 1.81536958e-01f, -1.52401879e-01f, 2.77244061e-01f, 9.67855230e-02f,
  1.88591965e-02f, -2.57303356e-03f, 3.09709068e-02f, -8.98046941e-02f, 1.14613548e-02f, -2.40915138e-02f, -5.53467497e-02f, 4.66756821e-02f, -1.41815059e-02f, -8.42445940e-02f,
  -1.40998229e-01f, 8.42085760e-03f, -5.81959728e-03f, 4.38286588e-02f, 1.00006163e-01f, 6.05699867e-02f, 6.65861741e-02f, -1.32386503e-03f, -7.66034499e-02f, -6.98775277e-02f,
  -3.40886191e-02f, -6.69881850e-02f, -4.62523736e-02f, -5.45413643e-02f, -5.94998896e-02f, 1.77610144e-02f, -4.63917889e-02f, -8.15662891e-02f, -5.87500334e-02f, 4.49906662e-02f,
  5.16597629e-02f, -4.55543958e-02f, -5.30904299e-03f, 7.46131968e-03f, 8.59833583e-02f, -8.82245309e-04f, 2.31128335e-02f, 1.27790151e-02f, -4.99789156e-02f, 2.50103567e-02f,
  5.58657646e-02f, 5.48824221e-02f, 4.88756001e-02f, 2.75624730e-02f, 1.01979680e-01f, -4.04154621e-02f, -7.65962293e-03f, -1.71575304e-02f, -3.74344215e-02f, -1.21859927e-02f,
  -3.92868854e-02f, 1.58295110e-02f, 9.15927254e-03f, -3.08746472e-02f, 6.69855997e-02f, 2.68318541e-02f, 6.84795529e-02f, -8.11958164e-02f, -2.46421956e-02f, 1.00744748e-02f,
  -1.06942523e-02f, -7.33744428e-02f, -1.09701268e-01f, 4.01634723e-02f, -3.38984095e-02f, 7.00089559e-02f, -2.36050710e-02f, -7.69651905e-02f, -1.27831707e-02f, 5.64740188e-02f,
  1.90595537e-02f, 2.60654022e-03f, -3.92791862e-03f, -3.07296719e-02f, -3.27922441e-02f, 1.33986231e-02f, -7.21280649e-02f, -1.67560559e-02f, 6.58527911e-02f, 7.45686516e-02f,
  3.17460522e-02f, 3.57588264e-03f, -4.41207812e-04f, 3.66181210e-02f, 6.11387528e-02f, -6.59825047e-03f, 3.71679217e-02f, -1.62558574e-02f, 4.74240743e-02f, -1.26267970e-01f,
  7.48571754e-01f, -4.60735649e-01f, 3.06111537e-02f, 2.08396330e-01f, 3.12088847e-01f, -3.07693064e-01f, 4.48091507e-01f, -1.23175599e-01f, 2.25837559e-01f, -3.25889647e-01f,
  3.88527960e-02f, -1.82758093e-01f, 1.69166759e-01f, -2.72139370e-01f, 3.21821660e-01f, 1.56218335e-01f, -9.83220637e-02f, -2.39058547e-02f, 1.77092433e-01f, -7.76307285e-02f,
  2.14216486e-01f, -1.85630359e-02f, 7.87027106e-02f, -2.93122768e-01f, 4.44204882e-02f, -1.27159610e-01f, 1.97663512e-02f, 8.36242922e-03f, -2.51513988e-01f, -1.25882939e-01f,
  6.39332235e-02f, 1.36309355e-01f, 5.83804073e-03f, -7.93847442e-02f, -7.43378624e-02f, -5.22611402e-02f, -7.17625767e-02f, 3.13864052e-02f, 9.81346145e-02f, -4.63906862e-02f,
  1.92801505e-02f, 2.31646299e-02f, -6.32061344e-03f, 9.51241627e-02f, 1.41311381e-02f, 9.44821164e-03f, 1.24753220e-02f, 3.21324170e-02f, 4.01212759e-02f, 2.78961984e-03f,
  2.75287759e-02f, 7.12921936e-03f, 3.91505696e-02f, -1.10744812e-01f, 1.77768841e-02f, 7.75867328e-02f, 7.77542125e-03f, -7.92792886e-02f, 1.13913994e-02f, -6.75375089e-02f,
  -5.59829101e-02f, 1.09423194e-02f, 3.69616672e-02f, 3.67032178e-02f, -2.20469311e-02f, 1.78469606e-02f, 6.23374395e-02f, -4.51974869e-02f, 4.18018959e-02f, -4.21746261e-03f,
  2.04630662e-02f, -1.24357529e-02f, 1.16709648e-02f, 6.25647902e-02f, 1.06218096e-03f, 6.36729896e-02f, 2.79622059e-02f, -1.07210958e-02f, 2.34590434e-02f, 3.92523929e-02f,
  2.03849785e-02f, 8.99780914e-03f, -5.73927574e-02f, 3.83763835e-02f, 8.11346471e-02f, 8.47551040e-03f, -4.59776819e-02f, -5.52523881e-02f, -4.03359234e-02f, -8.73468444e-03f,
  -2.14243427e-01f, -5.34961581e-01f, -4.67394441e-02f, 1.41490707e-02f, -1.14390768e-01f, -6.93463385e-02f, -2.77203955e-02f, -1.44475460e-01f, -6.58909082e-02f, -4.59088199e-02f,
  -4.69139963e-02f, -2.35069338e-02f, -7.08564073e-02f, -6.09806217e-02f, -3.80326398e-02f, -1.06826097e-01f, -7.07684457e-02f, -7.53151029e-02f, -4.50122096e-02f, -5.96420616e-02f,
  -3.84052880e-02f, -7.35203698e-02f, 3.55203473e-03f, 3.71031165e-02f, -3.42589766e-02f, -5.26055507e-02f, -5.46382666e-02f, 7.91161135e-03f, -8.08371603e-02f, 5.39965555e-03f,
  -1.02625728e+00f, -1.20905384e-01f, 6.74630702e-02f, 3.72189283e-01f, -2.34145269e-01f, -4.77687538e-01f, -3.99743080e-01f, 4.65414934e-02f, -1.86517596e-01f, 3.90791558e-02f,
  -2.46516615e-02f, -1.31675184e-01f, 1.54414680e-02f, 3.09638083e-01f, 8.81360620e-02f, 2.71523565e-01f, -1.47415278e-02f, 2.38369051e-02f, 1.10252865e-01f, 5.53093962e-02f,
  9.82467756e-02f, 2.76901692e-01f, 3.14391047e-01f, 1.20350264e-01f, -4.87117097e-02f, 7.49062374e-02f, 2.48423949e-01f, 3.05455886e-02f, 1.17457680e-01f, -6.30059019e-02f,
  -2.35953823e-01f, 2.24919617e-01f, 1.25147685e-01f, 1.03193201e-01f, -9.58807021e-03f, -2.16088831e-01f, -5.36311269e-02f, -3.09715364e-02f, -4.19767052e-02f, -8.62694904e-03f,
  -4.44416851e-02f, -2.26978166e-03f, 1.56367466e-01f, 4.11475524e-02f, -6.87151402e-02f, -1.94354746e-02f, -3.88666429e-02f, -1.29624233e-01f, -4.02468853e-02f, -2.72156112e-02f,
  -1.45489424e-02f, -1.52002200e-02f, -2.97603123e-02f, -2.29522251e-02f, -1.52888792e-02f, 8.90834853e-02f, 5.31784929e-02f, -3.72489952e-02f, -7.16619566e-02f, -6.01942092e-02f,
  6.63327100e-03f, 1.52402418e-02f, -9.96124297e-02f, -6.95736660e-03f, 5.25525920e-02f, 3.00320499e-02f, 3.89352478e-02f, 3.62786129e-02f, -4.76054586e-02f, 1.15553355e-02f,
  -1.27414968e-02f, -1.13653447e-02f, 3.94642055e-02f, -9.31169465e-02f, 6.13460913e-02f, -1.57304239e-02f, 3.48194540e-02f, -5.15994728e-02f, -4.53382619e-02f, -6.59805769e-03f,
  -4.78848480e-02f, -5.15209176e-02f, -7.61777163e-04f, -2.47658137e-02f, 5.98897599e-02f, 1.28008192e-02f, -1.85018100e-04f, -5.50040081e-02f, -2.72253193e-02f, -4.14777920e-02f,
  -2.49489039e-01f, 1.11649506e-01f, -2.02302746e-02f, -1.07079498e-01f, 5.04058190e-02f, 1.57523789e-02f, 9.10088941e-02f, -3.27384621e-02f, 2.57579945e-02f, -4.81972611e-03f,
  -9.53834876e-02f, 2.51853224e-02f, -1.00688182e-01f, 3.26251350e-02f, 6.09695539e-02f, -1.51764620e-02f, 3.66370119e-02f, 2.75585521e-02f, 3.92669700e-02f, 5.09679765e-02f,
  1.79225300e-02f, -4.48428430e-02f, 2.70426869e-02f, -1.85978208e-02f, -1.10718897e-02f, -5.17288037e-03f, -1.07576422e-01f, -4.37114649e-02f, 2.21444126e-02f, -8.80158320e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -1.51755154e-01f, 1.05128609e-01f, 1.92828536e-01f, 4.23834503e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.49750203e-01f, -1.63544267e-01f, 2.49034334e-02f, 2.72295058e-01f, 1.16532922e-01f, 1.80598527e-01f, 5.95463634e-01f, -1.98530197e-01f, 6.51851594e-01f, 2.03546077e-01f,
  5.61905861e-01f, -1.30506232e-01f, 5.13856053e-01f, -2.19198421e-01f, -1.01124644e-02f, 2.08577827e-01f, -1.61657184e-01f, 3.29071015e-01f, 3.39146137e-01f, -2.05230355e-01f,
  3.66917215e-02f, -4.12070215e-01f, 2.50991404e-01f, 4.40667868e-01f, -3.52789946e-02f, -2.50522166e-01f, -4.45586443e-01f, 4.55833137e-01f, -3.60771477e-01f, -3.38018626e-01f,
  -6.76726818e-01f, 2.58631527e-01f, -3.19022238e-01f, 3.41305509e-02f, 6.87146112e-02f, -2.13763595e-01f, 1.75631493e-01f, -3.64449203e-01f, 2.59110272e-01f, 2.35038280e-01f,
  5.23575425e-01f, 2.76830941e-01f, 3.77455831e-01f, 8.45810119e-03f, -3.46768387e-02f, 3.82624447e-01f, -3.45603079e-01f, 3.08976650e-01f, -1.51777819e-01f, 2.00204521e-01f,
  1.60032079e-01f, 2.04064086e-01f, 2.24895090e-01f, 3.07166040e-01f, 3.26847136e-01f, -1.95761114e-01f, 3.17619622e-01f, -5.51431894e-01f, -3.93121898e-01f, -2.68935591e-01f,
  2.33765706e-01f, -3.69826674e-01f, 3.65485609e-01f, -8.55637342e-02f, -6.49847448e-01f, -1.37035578e-01f, 5.73960692e-02f, -4.00548041e-01f, -3.50060314e-01f, -6.48110986e-01f,
  2.44125314e-02f, 5.49345374e-01f, 3.49096984e-01f, -7.53215253e-02f, 2.78957576e-01f, 9.01448131e-02f, 3.75156015e-01f, -4.24683362e-01f, 2.05679938e-01f, 5.44722676e-01f,
  -3.21034521e-01f, 1.65135145e-01f, -6.98011890e-02f, 6.75809681e-02f, -1.07074134e-01f, -2.07961559e-01f, 1.17799856e-01f, 4.90537226e-01f, 5.21302409e-02f, -7.46657252e-02f,
  -1.45441905e-01f, 3.11574847e-01f, 1.11470327e-01f, -6.00734353e-01f, -1.47523537e-01f, 3.68864357e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.04421192e-01f, 4.44838077e-01f, -1.38347358e-01f, 2.08583310e-01f, 8.96643922e-02f, -5.85676730e-01f, -2.87638992e-01f, 4.13626641e-01f, -3.89182061e-01f, 8.94135416e-01f,
  1.08966470e-01f, 1.68786675e-01f, -4.66130912e-01f, 1.93313450e-01f, -2.95640100e-02f, 3.20780814e-01f, 2.44923234e-01f, 2.64999308e-02f, -3.39321017e-01f, 2.35728368e-01f,
  1.53904513e-01f, 2.33902037e-01f, -2.49629602e-01f, 1.15797408e-01f, -1.33735761e-01f, 4.44190204e-01f, 2.00254142e-01f, 2.57189069e-02f, -1.20781148e-02f, 1.89562649e-01f,
  7.03696489e-01f, -2.02479884e-01f, -7.26284385e-02f, 1.34198159e-01f, 2.16635931e-02f, -1.78193972e-01f, -2.36904975e-02f, 3.29361349e-01f, 9.67806652e-02f, -4.06982392e-01f,
  -1.20384386e-03f, 1.56633809e-01f, 7.63390601e-01f, -3.45663011e-01f, 6.63979113e-01f, 2.73726285e-01f, 5.35496101e-02f, -1.41176686e-01f, 3.21282558e-02f, 2.71110833e-01f,
  -1.02571674e-01f, 2.11769745e-01f, -5.88217340e-02f, -5.65015852e-01f, -1.78419113e-01f, 1.25297293e-01f, -3.06265622e-01f, -6.35757267e-01f, -5.01495361e-01f, -4.85358775e-01f,
  -4.42556947e-01f, 2.80406803e-01f, 3.03185076e-01f, 3.53208929e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.32711756e-01f, 2.34348163e-01f, 4.74573597e-02f, -1.96283221e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -8.94226432e-02f, -3.03129613e-01f, -2.76598006e-01f, 9.69413146e-02f, -1.34716526e-01f, -2.27148995e-01f, -3.87497753e-01f, -1.15029946e-01f, 6.77567601e-01f, -4.08846349e-01f,
  3.76699343e-02f, -3.46261621e-01f, 3.27010632e-01f, 2.91005164e-01f, -7.04643279e-02f, 1.19058579e-01f, 2.51625359e-01f, 3.83914888e-01f, 2.81377465e-01f, 1.25150442e-01f,
  2.38932043e-01f, -9.70623940e-02f, -2.19483003e-01f, -3.21957856e-01f, 2.50420928e-01f, 1.93606570e-01f, -5.59153676e-01f, -2.60305285e-01f, 2.37959340e-01f, 2.05474406e-01f,
  -3.85148704e-01f, 4.85004693e-01f, 2.20750347e-01f, -9.51149538e-02f, 1.30133614e-01f, -2.06198115e-02f, 4.52486649e-02f, 1.04173377e-01f, -2.28645489e-01f, -3.96099538e-01f,
  -4.98707891e-02f, 1.84539452e-01f, -5.49251735e-01f, -3.05561244e-01f, 1.35861218e-01f, 2.97995299e-01f, -2.98196793e-01f, 3.47117722e-01f, 6.47018254e-02f, -1.30718881e-02f,
  -3.82625252e-01f, 3.32868755e-01f, -2.19028816e-02f, -1.64164826e-01f, -5.82349598e-01f, 9.35909152e-02f, -3.54162246e-01f, 3.05285677e-02f, -7.43124932e-02f, -2.00829476e-01f,
  -5.31005338e-02f, -2.20477074e-01f, -3.86727631e-01f, 5.23873031e-01f, -8.11058283e-02f, -8.72526169e-01f, -5.02422929e-01f, -3.92182112e-01f, -2.40717386e-03f, 7.70573840e-02f,
  -2.61383295e-01f, -5.63121680e-03f, -3.58865440e-01f, 1.80851981e-01f, 8.44174251e-02f, 1.56442776e-01f, -1.22709274e-01f, 5.94913781e-01f, -7.17780292e-02f, -2.96152145e-01f,
  1.72870472e-01f, 2.19481274e-01f, -2.71957338e-01f, 1.76699474e-01f, -2.28937671e-01f, -9.55288783e-02f, -8.63709971e-02f, -1.36205629e-01f, 1.05095387e-01f, -3.94557059e-01f,
  1.20653147e-02f, -1.49775684e-01f, 3.97860944e-01f, -3.06343108e-01f, -3.19563657e-01f, 3.69938426e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.72890231e-01f, -8.52817595e-02f, 1.73524961e-01f, 3.21623862e-01f, -7.29466230e-02f, 6.91483200e-01f, -6.21233881e-01f, -5.38398206e-01f, -8.67644191e-01f, 9.25244018e-02f,
  -1.22683668e+00f, -7.82079577e-01f, 1.95345774e-01f, 4.42722261e-01f, 1.67127192e-01f, 2.39098936e-01f, 4.92624849e-01f, 9.31291282e-01f, -2.79697198e-02f, 6.44028842e-01f,
  1.70338288e-01f, 3.54084998e-01f, -3.50112230e-01f, 5.55929482e-01f, -5.09491384e-01f, 5.68315871e-02f, -1.93675250e-01f, 3.45132291e-01f, 4.47034240e-01f, -1.30318046e-01f,
  -1.16313958e+00f, 8.41042325e-02f, -8.00315812e-02f, 9.41564813e-02f, -1.89346805e-01f, 1.51807979e-01f, -4.93328303e-01f, -1.93400413e-01f, -6.99629188e-01f, -6.77959144e-01f,
  6.03244126e-01f, -2.92305052e-01f, 2.49631658e-01f, -6.93871558e-01f, 4.57602799e-01f, 3.92036736e-01f, -4.30614203e-01f, 1.12691271e+00f, 6.43787920e-01f, 5.62526822e-01f,
  4.57885832e-01f, 3.23384583e-01f, 1.34284660e-01f, 2.19781697e-01f, 1.49798736e-01f, 4.47101295e-01f, 1.01870263e+00f, -9.10179675e-01f, 8.83789182e-01f, 1.78593010e-01f,
  9.08224404e-01f, 2.84340650e-01f, -1.68754756e-01f, 1.65022593e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.00467050e-01f, 2.60990262e-01f, -1.96884289e-01f, 5.36572039e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.38639033e-01f, 9.71787870e-02f, 5.04502356e-02f, 2.65202790e-01f, 2.00762659e-01f, 2.65944839e-01f, 2.68987030e-01f, 6.70538008e-01f, 5.48585117e-01f, 3.42301190e-01f,
  4.01593894e-01f, -1.06360346e-01f, 4.91999865e-01f, 1.24392927e-01f, -2.53445238e-01f, -2.49825642e-01f, 2.19158921e-02f, -3.26585054e-01f, 3.52475703e-01f, -1.19124770e-01f,
  -7.01335445e-02f, -1.93774953e-01f, 3.47363874e-02f, -2.75273353e-01f, -2.99118698e-01f, -2.82384694e-01f, 3.20849448e-01f, -5.47180712e-01f, 3.59980643e-01f, -5.77427864e-01f,
  1.33558467e-01f, -2.11277395e-01f, 3.81020643e-02f, -3.02085221e-01f, 3.93247344e-02f, 3.30404267e-02f, -1.33601442e-01f, -1.98274031e-01f, 1.77052855e-01f, 1.81396753e-02f,
  1.84707418e-01f, -4.64647263e-01f, 5.30690312e-01f, -3.36510718e-01f, 3.61868143e-01f, -3.68684351e-01f, -2.88249969e-01f, -3.00987124e-01f, 3.86721402e-01f, -2.86157429e-01f,
  2.94552129e-02f, 2.11284354e-01f, -1.42382443e-01f, -5.02321005e-01f, -1.34595092e-02f, 2.70040780e-01f, 4.31777269e-01f, 2.14717075e-01f, 1.07810390e+00f, 6.29553795e-01f,
  -2.53727615e-01f, 5.51758945e-01f, -3.40859592e-01f, 2.55488902e-01f, -1.68521389e-01f, 3.78393799e-01f, 2.35629871e-01f, 3.86013418e-01f, 3.06672871e-01f, 1.99132279e-01f,
  4.99609299e-02f, 9.53133047e-01f, 6.84421182e-01f, -3.71251434e-01f, -1.02424100e-01f, -4.96402800e-01f, 8.71239752e-02f, -2.20094666e-01f, 6.91124424e-02f, -3.93061489e-02f,
  4.40295368e-01f, 1.15284555e-01f, -5.57372253e-03f, -1.31489828e-01f, 2.58779407e-01f, 4.67195243e-01f, -7.30974257e-01f, -4.20342267e-01f, -4.20351952e-01f, -8.67609978e-01f,
  -4.06982571e-01f, -8.83313835e-01f, 8.14895034e-02f, -2.18646631e-01f, -1.10031605e-01f, -3.02765727e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -4.45637107e-02f, -1.85685158e-01f, 1.23966701e-01f, 3.32658798e-01f, 5.31709671e-01f, -4.24097963e-02f, 1.38579392e+00f, 8.57307374e-01f, 7.13980854e-01f, -5.81306577e-01f,
  -4.19084966e-01f, 9.23451662e-01f, -5.96639633e-01f, 4.27169114e-01f, 4.16012883e-01f, 1.87155902e+00f, 3.45863700e-02f, -7.68741012e-01f, -1.15197027e+00f, 5.31900406e-01f,
  -1.33958086e-01f, 3.51371706e-01f, 5.97625017e-01f, 3.88190448e-01f, 3.12251329e-01f, 1.01680458e+00f, 2.95421302e-01f, 1.06424853e-01f, 1.05007160e+00f, 6.63904130e-01f,
  1.24097967e+00f, -9.20924321e-02f, 5.80439627e-01f, 5.35314918e-01f, 7.41702259e-01f, 1.01975143e+00f, 8.84903550e-01f, 8.58433068e-01f, -1.12970424e+00f, 1.00378406e+00f,
  1.02618468e+00f, -2.41812050e-01f, -1.24248564e+00f, 1.60963684e-01f, 5.09353459e-01f, 1.21253431e+00f, -8.34982693e-01f, 4.59029935e-02f, 2.16021374e-01f, 7.66422272e-01f,
  1.01530361e+00f, 2.10625399e-02f, 7.82103181e-01f, 5.58485270e-01f, -1.26548386e+00f, -6.51921332e-01f, -1.16796589e+00f, -1.21537185e+00f, -7.93257117e-01f, -9.34263885e-01f,
  -5.81199050e-01f, -2.18175903e-01f, -3.71719539e-01f, 4.45534348e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  1.99178755e-01f, 4.07279968e-01f, 4.33985293e-01f, 9.00887668e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.23754375e-01f, -7.56144896e-02f, -6.54259980e-01f, -8.79952431e-01f, 2.27801576e-01f, 2.74338096e-01f, -5.21808088e-01f, -5.11373468e-02f, 2.94830531e-01f, 4.73165154e-01f,
  -4.20886695e-01f, -9.73292470e-01f, 4.19175774e-01f, -1.32547379e+00f, -2.07973327e-02f, -1.21352188e-01f, 4.10926819e-01f, 8.35067511e-01f, 1.04673314e+00f, 1.00698912e+00f,
  -1.10625267e+00f, -7.76617885e-01f, 1.05350661e+00f, 8.42986777e-02f, -8.05193484e-01f, 1.57135442e-01f, 6.90132558e-01f, -1.08447003e+00f, 4.06831652e-01f, 1.22156836e-01f,
  -7.59981453e-01f, -5.04217982e-01f, 4.42879826e-01f, 4.89611834e-01f, -1.35755599e+00f, -2.08133981e-02f, 6.77967429e-01f, -5.71350157e-01f, -7.89673328e-01f, -8.50000083e-01f,
  1.73161581e-01f, 4.55037177e-01f, -1.22962856e+00f, 6.12480998e-01f, 2.36257672e-01f, 4.62391317e-01f, -1.64341974e+00f, -9.84191000e-01f, -5.11081159e-01f, 9.11940694e-01f,
  7.84065783e-01f, -9.71199632e-01f, 6.10722780e-01f, -5.70077837e-01f, -9.69192863e-01f, 3.63852620e-01f, -1.07008135e+00f, -6.61447108e-01f, -5.40011287e-01f, -3.65890592e-01f,
  -1.22233081e+00f, -4.40366447e-01f, -5.21741331e-01f, 9.34364557e-01f, 7.25135982e-01f, -9.88076851e-02f, -4.05694783e-01f, 5.18195748e-01f, -2.46660158e-01f, 2.78879076e-01f,
  -3.41033280e-01f, -1.51672006e+00f, -1.18223965e+00f, 4.89047438e-01f, 4.76695955e-01f, 9.77542102e-01f, -3.87925267e-01f, -1.23927367e+00f, 5.10925531e-01f, 4.81768548e-01f,
  9.88184214e-02f, -5.85543692e-01f, -3.26245278e-01f, -1.28537416e+00f, 1.23253629e-01f, 1.51401535e-01f, 4.78725791e-01f, -3.73699605e-01f, -7.39319026e-01f, 5.95408320e-01f,
  2.10481033e-01f, -9.42422867e-01f, 3.20686996e-02f, -8.16164762e-02f, 4.31365162e-01f, -1.27775681e+00f, -1.76872447e-01f, -1.32929221e-01f, 4.62457329e-01f, -3.79280120e-01f,
  8.02964345e-02f, 2.33124301e-01f, -5.48710190e-02f, 2.45234609e-01f, 3.55330348e-01f, -1.64003670e-03f, -5.03314734e-02f, -1.00681508e+00f, -1.00305951e+00f, 8.49100649e-01f,
  -1.32791865e+00f, -2.99475282e-01f, 1.13784742e+00f, -9.48802650e-01f, -6.38403296e-01f, 1.41786468e+00f, 5.55691898e-01f, -8.82292449e-01f, -9.45018351e-01f, 8.68274450e-01f,
  1.46936500e+00f, -2.00088829e-01f, -1.16921473e+00f, 1.30735815e+00f, -2.45864511e-01f, -6.49024129e-01f, -7.57963359e-01f, 5.32781661e-01f, -2.16145013e-02f, -5.36080360e-01f,
  2.61184365e-01f, -1.14413106e+00f, 4.98360366e-01f, 4.54507828e-01f, -7.43897676e-01f, 9.16543156e-02f, 5.96123934e-01f, -2.22115591e-01f, 2.10915506e-01f, 3.31924379e-01f,
  7.44386554e-01f, -2.66720623e-01f, -7.98646986e-01f, -1.45151424e+00f, -8.44199061e-01f, -2.00292155e-01f, -1.40206230e+00f, 9.58029866e-01f, -9.46489275e-01f, 5.61046660e-01f,
  2.19873320e-02f, 1.43425679e+00f, 7.52702773e-01f, -2.02746108e-01f, 3.41891915e-01f, 1.18985581e+00f, -6.81373894e-01f, 1.92488328e-01f, 1.14787564e-01f, -7.58129656e-01f,
  4.29977298e-01f, 3.53880614e-01f, 6.61564291e-01f, -6.41321719e-01f, -4.99388427e-01f, -6.10800385e-01f, 1.15167964e+00f, 9.37528968e-01f, 1.10073435e+00f, -7.72424340e-01f,
  5.73231459e-01f, -5.14999358e-03f, -1.21283019e+00f, -1.04017377e+00f, 7.81280756e-01f, 1.87785596e-01f, -2.77481973e-01f, 2.30901718e-01f, 1.07659340e+00f, 2.74714977e-01f,
  8.03284422e-02f, 6.86003387e-01f, 8.00049156e-02f, -1.64803135e+00f, -9.07638371e-01f, 5.60990512e-01f, -4.26101424e-02f, 1.34990364e-01f, -1.61182463e+00f, -2.23820418e-01f,
  8.16164792e-01f, -4.74595904e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.09144861e-01f, -2.30902806e-02f, -2.57327050e-01f, -2.60595202e-01f, -3.79482090e-01f, -3.37181717e-01f, -1.42890945e-01f, 8.34099472e-01f, -3.53898972e-01f, 5.75494111e-01f,
  -1.36697322e-01f, -3.96006733e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    