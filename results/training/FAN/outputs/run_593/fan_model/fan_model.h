/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.15158451e-01f, 5.28663993e-01f, 4.72559780e-01f, -1.11873433e-01f, 1.70618504e-01f, 2.92909294e-01f, 5.89159429e-01f, 1.46263361e-01f, -1.34372860e-01f, 2.22904637e-01f,
  -9.41066965e-02f, -5.12253761e-01f, -4.28809106e-01f, -2.28162438e-01f, -1.37273550e-01f, 5.24605453e-01f, 4.59419459e-01f, 1.60926059e-02f, -1.26910523e-01f, 7.63968602e-02f,
  8.14768896e-02f, 1.46527678e-01f, -1.84316158e-01f, 5.19273505e-02f, 1.50627092e-01f, -2.63885975e-01f, 1.27130672e-01f, -1.76602639e-02f, 7.95162320e-02f, 3.25801402e-01f,
  -1.13306716e-01f, 2.74074823e-01f, -1.44022062e-01f, -6.05734698e-02f, 1.24760069e-01f, 4.19784077e-02f, -1.05367126e-02f, 1.23336501e-02f, -1.19582694e-02f, 1.12103112e-01f,
  -3.59247671e-03f, -2.34433413e-02f, 7.22860545e-02f, 3.30443010e-02f, 1.57412216e-01f, 1.11466452e-01f, 1.38906270e-01f, 1.42736375e-01f, 4.05079834e-02f, 9.83009040e-02f,
  1.70330688e-01f, 9.88466963e-02f, 1.22668765e-01f, 8.54545310e-02f, 1.79751247e-01f, -3.37358117e-02f, 9.35169160e-02f, 1.60372943e-01f, 6.04979582e-02f, 7.68802315e-02f,
  3.76475155e-02f, -4.04166356e-02f, 1.36033976e-02f, -1.24174282e-02f, -1.00189395e-01f, -1.23534441e-01f, -2.63646822e-02f, -4.76944558e-02f, -5.46611324e-02f, -2.03808434e-02f,
  -5.54103851e-02f, 5.57655171e-02f, -3.60668078e-02f, -5.28044207e-03f, -6.69422597e-02f, 5.26847597e-03f, -2.67431233e-02f, -1.23334276e-02f, -5.05524985e-02f, -5.52789159e-02f,
  -4.91050258e-02f, -8.70660916e-02f, 2.15188246e-02f, -2.33592559e-02f, 2.11578440e-02f, 2.54375972e-02f, -3.79264206e-02f, -5.49508855e-02f, -9.94190052e-02f, -9.91508439e-02f,
  -1.47396579e-01f, -1.11786596e-01f, -4.01270203e-02f, 3.09238266e-02f, 3.35493274e-02f, 2.75757909e-02f, -5.63679077e-02f, 6.77043200e-02f, 8.02672505e-02f, 8.00757185e-02f,
  6.49875263e-03f, -4.47013900e-02f, 5.99601269e-02f, 6.73434138e-02f, -3.38572487e-02f, -5.67894569e-03f, 2.47447416e-02f, -2.95576686e-03f, 2.66514067e-02f, 1.16032556e-01f,
  7.90845454e-02f, 1.09927140e-01f, -1.60156891e-01f, 1.87441602e-03f, 1.15551157e-02f, -1.69219285e-01f, 7.49217197e-02f, -3.19689065e-02f, -1.35351568e-01f, 8.59062448e-02f,
  3.05393785e-01f, -3.08962256e-01f, 9.68223959e-02f, -2.70569533e-01f, -2.12276131e-01f, 1.54713556e-01f, 1.90339535e-01f, 3.42128845e-03f, -2.47926638e-01f, -2.33017445e-01f,
  1.15515538e-01f, 4.95992638e-02f, 6.13535121e-02f, -1.00954277e-02f, 3.89595330e-01f, -1.23060137e-01f, -2.15073198e-01f, 2.18270868e-01f, 4.40208256e-01f, 1.38969660e-01f,
  -1.87639687e-02f, -1.82996884e-01f, 1.29483104e-01f, 2.35377457e-02f, -4.35598493e-01f, 4.05080281e-02f, -1.58180416e-01f, -2.07297802e-01f, 1.28263086e-01f, -4.31586504e-01f,
  2.58966178e-01f, -6.49493113e-02f, 1.00318737e-01f, -7.07553141e-03f, -4.97886539e-02f, 5.01787812e-02f, 8.02552924e-02f, -4.50711586e-02f, 3.17854919e-02f, -1.78800393e-02f,
  2.77963327e-03f, 2.58506858e-03f, 7.43860677e-02f, -4.27001230e-02f, -6.39948770e-02f, -2.79797371e-02f, -6.78489357e-02f, -5.58026275e-03f, 1.47023983e-02f, -7.45844021e-02f,
  -8.23780820e-02f, 3.80524397e-02f, 2.67470200e-02f, -8.62800181e-02f, 7.60660321e-02f, 7.81897176e-03f, 3.27743702e-02f, -3.32173216e-03f, 1.31910682e-01f, -1.36979625e-01f,
  6.15977421e-02f, -1.53619982e-02f, -2.83585470e-02f, -4.32408825e-02f, -2.92694103e-02f, 1.01837339e-02f, -1.24476086e-02f, 4.10814653e-04f, 5.25765633e-03f, -5.38409650e-02f,
  -4.73577790e-02f, -6.19722484e-03f, -3.89952362e-02f, 3.08202077e-02f, -8.22438747e-02f, -3.65260988e-02f, -6.95646135e-03f, 3.21620032e-02f, 2.08393627e-04f, -5.54666705e-02f,
  -1.79028744e-03f, 8.18565115e-02f, -8.62173438e-02f, 3.35810892e-02f, -1.10442247e-02f, -1.65307391e-02f, 4.07792144e-02f, -8.88585299e-02f, -1.85578056e-02f, -4.14572209e-02f,
  6.34343270e-03f, 2.17987821e-01f, 1.48481401e-02f, 1.11024283e-01f, 2.11081542e-02f, -1.40975993e-02f, 2.83113923e-02f, 2.59423200e-02f, 1.61798857e-02f, 3.16046961e-02f,
  1.11690529e-01f, 9.18703899e-02f, 2.01356821e-02f, -6.83901832e-02f, 9.99289677e-02f, 1.60137732e-02f, -2.04040576e-02f, 1.92127172e-02f, 6.95212111e-02f, -1.28026409e-02f,
  -2.89288759e-02f, 5.50014479e-03f, 1.53297223e-02f, -8.66879523e-03f, -1.54070766e-03f, 1.25162482e-01f, -4.33622040e-02f, -3.58649008e-02f, 2.60917574e-01f, -7.81767964e-02f,
  -6.49114475e-02f, 5.03518581e-01f, -3.53869826e-01f, 1.34184793e-01f, -2.84591820e-02f, -3.22113097e-01f, -1.57218382e-01f, -1.86731905e-01f, 1.96813559e-03f, 1.58868954e-01f,
  -7.98110291e-02f, -8.33144784e-02f, -1.14348195e-01f, -1.25353843e-01f, -2.46218473e-01f, 6.56900480e-02f, 2.91924536e-01f, -1.92128852e-01f, -5.60113072e-01f, -1.87717348e-01f,
  1.47505730e-01f, 1.33211643e-01f, 5.24664484e-02f, -3.54806222e-02f, 4.63942081e-01f, 1.74260303e-01f, 9.23915952e-02f, 1.40529677e-01f, 9.99423340e-02f, 8.20688963e-01f,
  -5.06036170e-02f, -3.67283337e-02f, -4.21282426e-02f, 4.67074849e-02f, 9.99662839e-03f, -2.83083897e-02f, 1.41100120e-02f, -1.77605301e-02f, 2.90552247e-02f, -2.18472872e-02f,
  2.71665659e-02f, 4.15160619e-02f, -6.71336725e-02f, -8.83544795e-03f, -2.03638002e-02f, -4.52070124e-02f, -1.09746158e-01f, -4.81576845e-02f, -5.92487957e-03f, -6.63169622e-02f,
  9.47619528e-02f, -5.66191599e-02f, -8.85732472e-02f, -1.03462607e-01f, -1.85293466e-01f, -1.01208180e-01f, -2.46621501e-02f, 4.09898646e-02f, -4.91181090e-02f, 3.50795090e-01f,
  2.44019896e-01f, -1.19408760e-02f, 1.61832385e-02f, 1.18163541e-01f, 4.97058332e-02f, 3.29384878e-02f, 1.30112590e-02f, 2.85400245e-02f, 5.26000112e-02f, 1.92435794e-02f,
  5.79603463e-02f, -1.51743172e-02f, 2.57482082e-02f, 8.67802203e-02f, 1.86482612e-02f, -2.71960851e-02f, -6.90665096e-02f, 1.46649972e-01f, -3.72815819e-04f, 8.33130479e-02f,
  6.33601798e-04f, 1.37665793e-02f, -2.94254888e-02f, 5.53736836e-02f, 3.89869809e-02f, 4.41177376e-03f, -6.56719971e-03f, -1.27260070e-02f, -3.11736427e-02f, 3.51987630e-02f,
  3.66281793e-02f, -2.60510534e-01f, 7.84748197e-02f, -6.17520772e-02f, 2.30557825e-02f, 4.43588913e-04f, 4.86347377e-02f, -2.29280256e-03f, -3.39929946e-02f, -7.19410703e-02f,
  -6.46565259e-02f, -8.75478312e-02f, -1.70435719e-02f, 2.71425191e-02f, -3.30327675e-02f, -7.15027675e-02f, 3.90796810e-02f, -2.33375058e-02f, -6.73592165e-02f, -1.71005316e-02f,
  1.75840873e-02f, -7.94884935e-02f, -1.41377077e-01f, -7.67720342e-02f, -4.79623415e-02f, -6.46054670e-02f, -4.52263169e-02f, -2.16768384e-02f, -2.38055095e-01f, 1.98278606e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.05667448e+00f, -7.39686668e-01f, 6.94193006e-01f, 9.60109290e-03f, -2.43781567e-01f, 1.35856703e-01f, 9.75679513e-03f, 9.20085385e-02f, -9.75257233e-02f, -4.74064276e-02f,
  -2.52968401e-01f, -2.00680479e-01f, -3.44860777e-02f, -1.30787313e-01f, 2.85852998e-01f, 5.25782965e-02f, 1.06467977e-01f, 7.24908113e-01f, 6.94983184e-01f, 1.75586581e-01f,
  -2.60877967e-01f, 1.55544339e-03f, 4.44882780e-01f, 1.78731084e-01f, -2.34360024e-01f, -2.11992219e-01f, 7.96455145e-02f, -9.53701884e-02f, -1.92230344e-01f, -2.09870815e-01f,
  4.52253260e-02f, 3.48713510e-02f, 7.54289795e-03f, -3.76040190e-01f, -9.94329229e-02f, -6.64134175e-02f, -5.07333577e-02f, -2.45331917e-02f, -1.40062958e-01f, -6.45619333e-02f,
  -2.68209547e-01f, -7.43721873e-02f, 2.35303789e-02f, -5.46992160e-02f, 4.23561558e-02f, -7.57427188e-03f, 1.27150834e-01f, 2.68043935e-01f, 2.27604195e-01f, 2.38469243e-02f,
  -2.53391355e-01f, 2.30048541e-02f, 7.11815357e-02f, -3.84203680e-02f, 2.49325544e-01f, 1.26010209e-01f, -5.54264523e-02f, 3.90221477e-02f, 1.60756528e-01f, -6.89770505e-02f,
  1.11858368e-01f, 1.32997230e-01f, 5.70125096e-02f, 1.08099036e-01f, -3.03944461e-02f, 1.15132578e-01f, 3.69794257e-02f, 2.94145904e-02f, 1.66799814e-01f, 1.39665350e-01f,
  -4.61444026e-03f, 1.50233716e-01f, 5.96135296e-03f, 2.56658029e-02f, 4.93018851e-02f, 1.43648669e-01f, -7.98734054e-02f, -3.06491762e-01f, 7.06222877e-02f, 3.91555019e-02f,
  1.16534755e-01f, 6.14369363e-02f, -3.80511582e-02f, 6.54398128e-02f, 1.64521597e-02f, 9.86061320e-02f, -1.85473841e-02f, -3.10175307e-02f, -1.00027248e-02f, -7.96748996e-02f,
  -5.86873651e-01f, 3.55514556e-01f, 2.80808918e-02f, -5.98833431e-03f, -2.70820372e-02f, -2.28993315e-02f, 2.64865695e-03f, -1.63112089e-01f, -2.17379659e-01f, -6.83022812e-02f,
  -1.58103228e-01f, 6.99578077e-02f, 7.19465688e-02f, 9.21071395e-02f, 2.59570181e-01f, -4.97990213e-02f, -1.24054112e-01f, 2.31598541e-02f, 6.50427938e-02f, -1.48148105e-01f,
  -1.80309266e-01f, -7.93274790e-02f, 9.84201878e-02f, 4.70724143e-02f, -1.11910798e-01f, 1.50038749e-01f, -3.08673307e-02f, 9.97217000e-03f, 1.44597337e-01f, -2.39048079e-01f,
  -7.00614631e-01f, -3.68014395e-01f, -8.14072147e-04f, 3.49794656e-01f, 4.29051369e-01f, 5.36564589e-01f, 6.35653138e-01f, 2.79571474e-01f, 1.55643478e-01f, 3.38955671e-02f,
  -3.33200723e-01f, -4.89763975e-01f, -3.20418686e-01f, -1.79992810e-01f, -6.35444000e-02f, 3.85830045e-01f, 4.55074161e-01f, -8.08109865e-02f, -3.05021927e-03f, 1.98527977e-01f,
  1.92401096e-01f, -4.99998666e-02f, -4.33032632e-01f, -1.44179938e-02f, -2.80579720e-02f, 7.64994174e-02f, 3.73766422e-02f, -1.92596719e-01f, -9.07460079e-02f, 5.53403497e-02f,
  -7.09681690e-01f, -4.07850593e-01f, 3.10921655e-06f, -9.94421691e-02f, -2.55755126e-01f, -2.57256210e-01f, -1.59298144e-02f, -1.28728285e-01f, -1.32849768e-01f, -7.52816796e-02f,
  -1.25724435e-01f, -9.54990014e-02f, -5.96248023e-02f, -7.06783757e-02f, -3.87660228e-02f, -4.89645712e-02f, -5.55613264e-02f, -1.33051127e-01f, -2.12893821e-02f, -1.23599492e-01f,
  -6.41416386e-03f, -4.49508727e-02f, -1.11604430e-01f, 1.56647623e-01f, -1.35341017e-02f, 4.66500921e-03f, -1.66004956e-01f, -6.63230196e-02f, -9.92903784e-02f, -1.23209253e-01f,
  1.58263999e-03f, -1.99134335e-01f, 9.05870833e-03f, -3.22709139e-03f, -1.27811739e-02f, -3.45041305e-02f, 8.01048055e-03f, -1.13834873e-01f, 1.06666036e-01f, -4.22300287e-02f,
  -1.11696478e-02f, 1.21370524e-01f, 1.64505616e-01f, 8.27482492e-02f, -6.25207573e-02f, 3.57288904e-02f, 8.59856680e-02f, -1.18478544e-01f, -1.15694106e-01f, 1.13110930e-01f,
  3.84345762e-02f, 8.94179940e-03f, 5.25765400e-03f, 6.96042702e-02f, 1.38099551e-01f, -4.44073901e-02f, -1.65875815e-02f, 1.95651632e-02f, -1.48945609e-02f, 1.28074005e-01f,
  2.14770943e-01f, 1.02383472e-01f, -2.51246449e-02f, 1.73550189e-01f, 1.07215717e-01f, -7.45843723e-02f, 9.84574482e-03f, 1.51631124e-02f, 6.31404147e-02f, 2.11781748e-02f,
  -1.03067942e-02f, 6.80281147e-02f, 9.59241241e-02f, 1.00395493e-01f, 1.18125871e-01f, 7.54966168e-03f, -2.68791784e-02f, 5.92208579e-02f, 1.64923996e-01f, 1.50586024e-01f,
  6.41913265e-02f, 1.85941920e-01f, 8.47476721e-03f, 1.20290719e-01f, 4.54951972e-02f, 2.74705023e-01f, -3.32577527e-02f, -2.90049016e-02f, 1.92679130e-02f, 2.95651615e-01f,
  2.64306456e-01f, -1.73387229e-01f, -3.91021855e-02f, 7.63821900e-01f, 6.79953635e-01f, 4.91095096e-01f, 5.28558075e-01f, 3.76870781e-01f, 3.83570194e-01f, 1.56960934e-01f,
  2.25687146e-01f, 1.25275776e-01f, 2.14040160e-01f, 3.01906895e-02f, 8.82653221e-02f, 3.61689657e-01f, 4.79032516e-01f, -3.41144688e-02f, 1.23432525e-01f, 3.50322217e-01f,
  3.08378339e-01f, 5.88511303e-02f, -9.66306627e-02f, 3.27353389e-03f, -1.80082068e-01f, 3.11773390e-01f, 2.56455213e-01f, -3.27387685e-03f, -1.66398183e-01f, -2.67836809e-01f,
  -4.29471701e-01f, 2.62892582e-02f, 7.23998994e-02f, -1.52330380e-02f, -1.14433855e-01f, -1.45273298e-01f, -3.46378386e-02f, -1.40810594e-01f, -6.23496361e-02f, 1.57166217e-02f,
  -9.98376235e-02f, -1.68737724e-01f, 4.09525372e-02f, -8.15536678e-02f, -6.47832230e-02f, -1.37568161e-01f, -8.85477364e-02f, 1.82729159e-02f, 8.41195360e-02f, -6.74707964e-02f,
  -2.73705702e-02f, -8.42607394e-02f, 1.96047816e-02f, 3.48127224e-02f, -2.99854167e-02f, -1.88619085e-03f, -7.04694539e-02f, -6.65663555e-02f, 2.96662878e-02f, 1.38287827e-01f,
  1.10893678e-02f, -2.29148507e-01f, -1.96104318e-01f, 4.71493416e-02f, -1.36520073e-01f, -4.79785800e-02f, -5.12823053e-02f, 1.33600250e-01f, 1.94697946e-01f, -9.52982008e-02f,
  2.45722253e-02f, 1.91979427e-02f, -8.65289271e-02f, 1.30851179e-01f, -5.57881854e-02f, -4.47881669e-02f, -2.23100930e-01f, -5.79463914e-02f, -1.68823183e-01f, -4.55281027e-02f,
  5.96343577e-02f, -4.57928777e-02f, -2.59073168e-01f, -2.08710879e-01f, -6.45485818e-02f, -7.97950476e-02f, -1.55405566e-01f, -1.51248068e-01f, 2.01522950e-02f, 4.54531126e-02f,
  2.10600123e-01f, 1.56664416e-01f, 1.43349180e-02f, 1.47120282e-02f, -2.21667774e-02f, -2.66146630e-01f, 1.45760685e-01f, -1.21046379e-01f, -1.88253447e-01f, -9.50904842e-03f,
  -3.58480662e-02f, -2.04231396e-01f, -1.23202458e-01f, -1.63589627e-01f, 7.45516419e-02f, 1.12436311e-02f, -2.23532710e-02f, 5.30961081e-02f, -6.67970628e-02f, -1.73276022e-01f,
  -1.73494533e-01f, 1.63300216e-01f, 1.30163178e-01f, 1.82632655e-01f, 2.67124772e-02f, 1.29316404e-01f, -6.68050572e-02f, -4.06659506e-02f, 9.52838510e-02f, 2.68530130e-01f,
  -1.17637503e+00f, 4.40685689e-01f, 6.43360257e-01f, -9.68379796e-01f, -2.51204699e-01f, -5.62856644e-02f, 3.77865523e-01f, -1.52025536e-01f, -4.22355235e-01f, 5.42413712e-01f,
  2.04059601e-01f, 2.05870628e-01f, 3.05431932e-01f, 2.43791640e-01f, 3.03237513e-02f, 5.45075893e-01f, 1.96531460e-01f, -2.35662788e-01f, -3.15152138e-01f, -4.03097868e-01f,
  -3.52549106e-01f, -6.89880311e-01f, -8.80005956e-01f, -2.17006758e-01f, 1.74994692e-01f, 1.58244535e-01f, 2.61823773e-01f, -3.45615298e-01f, 6.00688159e-02f, 2.06412375e-02f,
  5.18419564e-01f, -2.79754072e-01f, 1.11210544e-03f, -3.32710773e-01f, -1.10993311e-02f, -8.14885423e-02f, 4.71648164e-02f, 3.09525952e-02f, 2.10759067e-03f, -5.74810617e-02f,
  -6.60201833e-02f, 5.64845838e-02f, -2.36183420e-01f, 9.15046185e-02f, -2.77647197e-01f, -1.72588304e-01f, -2.86174174e-02f, -7.37480894e-02f, 8.10722187e-02f, 2.09377453e-01f,
  1.30660962e-02f, -1.53930187e-01f, -9.10150632e-02f, 1.63257405e-01f, -4.59546410e-02f, -3.14248390e-02f, 6.93003684e-02f, -1.86509639e-01f, -4.36532013e-02f, 2.29785610e-02f,
  1.27375022e-01f, 2.11610824e-01f, 6.12769313e-02f, -1.37993693e-01f, -1.71506424e-02f, -1.40897157e-02f, 8.85144174e-02f, 2.18976498e-01f, -9.16652940e-03f, 8.11515525e-02f,
  7.22100027e-03f, 5.62328659e-02f, 9.97756422e-02f, 7.81228160e-03f, 4.93215472e-02f, -3.67999636e-02f, 2.18068175e-02f, 8.91531110e-02f, 1.21528365e-01f, -1.86020851e-01f,
  -1.11725871e-02f, 6.58562640e-03f, -1.81616887e-01f, 1.33455008e-01f, -1.07576959e-01f, 7.83697292e-02f, 1.03012472e-01f, -1.18733294e-01f, -1.11793153e-01f, -1.25126511e-01f,
  1.89611733e-01f, -9.64672267e-02f, 7.64230192e-02f, 8.13649446e-02f, 1.57999873e-01f, 4.57167067e-02f, 1.00520149e-01f, -1.19818188e-02f, -3.85689288e-02f, -3.46041359e-02f,
  -1.20029762e-01f, -1.44993916e-01f, 8.07685778e-02f, 1.27397450e-02f, -2.08226547e-01f, -1.32623971e-01f, -8.80277902e-02f, 5.94231412e-02f, 1.12258401e-02f, -1.14044636e-01f,
  6.19672164e-02f, 8.99701342e-02f, 2.82441806e-02f, 1.18189394e-01f, -8.66106525e-02f, 3.29764709e-02f, 3.16668898e-01f, 6.27369881e-02f, 1.83924902e-02f, 1.71965688e-01f,
  1.26135385e+00f, -1.88719153e-01f, -7.45732307e-01f, 5.32862484e-01f, -2.79267132e-01f, -2.68573463e-01f, -7.75146782e-02f, 2.92132765e-01f, 2.02530354e-01f, -1.16608754e-01f,
  -8.77530351e-02f, 6.34921417e-02f, 2.10086405e-01f, 7.10217953e-02f, 3.60027164e-01f, -1.86195225e-01f, -2.82279968e-01f, 9.43346769e-02f, 2.66201317e-01f, 9.88229886e-02f,
  1.18811630e-01f, 2.34078065e-01f, 4.59891468e-01f, 1.00380830e-01f, -3.97951096e-01f, 9.47562456e-02f, -4.83260363e-01f, -5.93283772e-01f, -5.38802207e-01f, -8.54229212e-01f,
  -5.68014264e-01f, -6.41421139e-01f, 5.18310629e-02f, 2.61569396e-02f, -5.72357737e-02f, 2.01628298e-01f, 2.22911492e-01f, 6.66481555e-02f, 1.54669836e-01f, 6.12788871e-02f,
  -1.20494805e-01f, 6.89795688e-02f, 4.91765626e-02f, -6.86509982e-02f, 5.08924574e-03f, -4.08868045e-02f, -1.16293184e-01f, 2.39295512e-02f, -8.41730833e-03f, -1.50183544e-01f,
  -1.73673630e-01f, -2.52101392e-01f, -1.16173133e-01f, -6.43533915e-02f, -2.16717422e-01f, -3.72205190e-02f, -3.02088231e-01f, -2.26247311e-01f, -1.06934257e-01f, -1.14431404e-01f,
  -4.11019428e-03f, -5.62624075e-02f, -1.27561003e-01f, 1.43546574e-02f, 1.65194884e-01f, 2.55974606e-02f, -8.74806792e-02f, 6.37391657e-02f, 9.58837792e-02f, 3.72051261e-02f,
  1.01048902e-01f, -1.39045835e-01f, -3.83886024e-02f, 1.71027422e-01f, -1.04575895e-01f, -1.68670222e-01f, 4.80147973e-02f, 2.45447475e-02f, -6.17870949e-02f, 1.12657681e-01f,
  1.51635230e-01f, -7.75785446e-02f, -4.91870753e-02f, -4.21208590e-02f, -8.16678703e-02f, -1.07779391e-01f, -1.77393407e-01f, -1.80007629e-02f, 1.42731547e-01f, 6.67420402e-02f,
  6.50758266e-01f, -1.46236420e-01f, 8.39124024e-02f, -1.55420629e-02f, -2.77925611e-01f, 1.00582354e-02f, -1.87902108e-01f, -1.05620809e-01f, -1.53695151e-01f, -6.79840073e-02f,
  -2.59019196e-01f, -4.79661785e-02f, -1.48048043e-01f, -1.00779153e-01f, 1.68792605e-01f, -1.28671583e-02f, -9.36688408e-02f, 1.58861116e-01f, -1.33831814e-01f, -1.19117230e-01f,
  5.31353429e-02f, 2.96008378e-01f, 6.47769749e-01f, 2.84780324e-01f, -9.23152044e-02f, 2.90882051e-01f, 1.81028873e-01f, -1.66644324e-02f, 2.55361497e-01f, 6.83285654e-01f,
  1.19587861e-01f, -9.16819051e-02f, 4.30643082e-01f, -1.96970943e-02f, -2.48055696e-01f, -7.89318502e-01f, -1.07270288e+00f, -8.80883992e-01f, -2.55156100e-01f, -9.35117714e-03f,
  -1.36063471e-01f, 2.10268199e-01f, 3.05496544e-01f, 1.89138263e-01f, -1.87803030e-01f, -7.60586560e-02f, 2.70412207e-01f, 5.77228010e-01f, 1.85775042e-01f, -1.00165740e-01f,
  2.01809764e-01f, 4.73725080e-01f, 3.13894898e-01f, -7.81694129e-02f, 3.10018450e-01f, 1.93770245e-01f, 1.49069294e-01f, 1.70703098e-01f, 2.13553488e-01f, 1.06209528e+00f,
  6.77520990e-01f, -3.55018437e-01f, 1.26146808e-01f, 1.03482336e-01f, 7.46787041e-02f, 1.08970016e-01f, 2.95355660e-03f, 1.02361061e-01f, -1.21506155e-01f, 4.46051545e-02f,
  9.79085788e-02f, -3.42080817e-02f, -1.23734802e-01f, 1.36151820e-01f, -1.28321514e-01f, -2.11872328e-02f, -5.58839925e-02f, 2.03224257e-01f, 1.39995366e-01f, 5.63769080e-02f,
  6.42537475e-02f, -1.62143055e-02f, -2.44996890e-01f, -5.27135789e-01f, -2.97204256e-01f, 1.66202679e-01f, -3.09264213e-01f, -1.61012456e-01f, -2.43306786e-01f, 6.49912804e-02f,
  -1.46602258e-01f, -9.64540690e-02f, 9.06597748e-02f, -8.01087245e-02f, -5.21856267e-03f, 1.32815288e-02f, 1.05123051e-01f, -4.81880419e-02f, -1.11706093e-01f, -5.97549835e-03f,
  -6.11327738e-02f, 1.55495584e-01f, 7.27699418e-03f, -1.10155735e-02f, 7.24086091e-02f, 1.49916736e-02f, -4.88368608e-02f, -5.79115264e-02f, -6.20087944e-02f, 7.87684843e-02f,
  2.28712931e-02f, -7.60405287e-02f, 1.85705960e-01f, -1.83976591e-02f, 7.17424229e-02f, 6.51967302e-02f, 6.48431182e-02f, -2.06253648e-01f, -4.45893640e-03f, -3.31139076e-03f,
  2.33134121e-01f, -1.28962040e-01f, 3.78163517e-01f, 4.42852601e-02f, -1.09424945e-02f, 1.76761728e-02f, 9.75181907e-02f, -3.65681238e-02f, 4.42371443e-02f, -1.10797375e-01f,
  -1.14689231e-01f, -6.65044188e-02f, 1.23973161e-01f, 6.75069690e-02f, 9.83771533e-02f, 1.29013106e-01f, -5.26697002e-03f, 1.41807258e-01f, -1.45960245e-02f, -7.52592310e-02f,
  -6.81457818e-02f, -3.17501485e-01f, -1.69991344e-01f, -2.56645858e-01f, -4.47396003e-02f, -1.72400072e-01f, 7.73727596e-02f, 4.39268537e-02f, -1.17607899e-01f, -3.14187735e-01f,
  9.11734045e-01f, 9.22527254e-01f, 4.78156835e-01f, 1.13039173e-01f, 1.20668113e-01f, 2.68263847e-01f, 5.42985559e-01f, 2.35571593e-01f, -2.72116065e-01f, 1.45187289e-01f,
  9.39712450e-02f, -3.74480754e-01f, -2.45405525e-01f, -2.53544867e-01f, 1.93791017e-01f, 2.58287132e-01f, 4.27970812e-02f, -5.92164882e-03f, -1.90017581e-01f, -1.72488168e-01f,
  -1.10067956e-01f, 6.65949285e-02f, 4.42423439e-03f, -1.16868347e-01f, 3.30961823e-01f, -3.30805987e-01f, -1.55991390e-01f, 2.08008751e-01f, 5.27210422e-02f, 4.54730928e-01f,
  5.41551352e-01f, 8.95248771e-01f, -6.86507344e-01f, -2.00028475e-02f, 1.01625152e-01f, -1.96297257e-03f, -1.59632355e-01f, -3.10743779e-01f, -1.57454193e-01f, -1.17915660e-01f,
  4.15226445e-02f, 3.04281879e-02f, 3.21485894e-03f, -1.11597897e-02f, 6.34408146e-02f, 1.15757011e-01f, -1.92614630e-01f, 3.00438982e-02f, 6.66010426e-03f, 1.10660128e-01f,
  -8.58866796e-02f, 6.48221821e-02f, 2.60543972e-01f, -1.41154423e-01f, 1.81349903e-01f, -2.93022454e-01f, -6.58429489e-02f, 1.10146128e-01f, -1.05337188e-01f, 4.71853949e-02f,
  -3.25552762e-01f, 8.15211535e-02f, 3.73853184e-03f, -5.84788844e-02f, -9.06898305e-02f, -3.00362259e-01f, 2.89914035e-03f, 1.35460794e-01f, -9.44361463e-02f, -4.05835658e-02f,
  -1.71853259e-01f, 1.19436197e-02f, 4.28427383e-02f, -2.76825055e-02f, -9.76612642e-02f, -4.36910726e-02f, -1.78968161e-02f, 1.11367125e-02f, -1.60426885e-01f, -1.19986415e-01f,
  -9.38733667e-02f, 1.59071907e-02f, -1.83509126e-01f, 1.90864682e-01f, -6.92222118e-02f, -1.23063764e-02f, -1.46797106e-01f, -1.86220244e-01f, -8.36233348e-02f, -7.62364012e-04f,
  -5.86821258e-01f, -4.46021318e-01f, -8.46217200e-03f, 2.41039485e-01f, 2.02568829e-01f, 6.26031980e-02f, 8.90826583e-02f, 4.46427725e-02f, 1.69190779e-01f, 3.91290635e-02f,
  1.47410706e-01f, -2.91529763e-03f, -5.34664430e-02f, -3.74750234e-02f, -1.70936555e-01f, -8.97898152e-02f, -8.45222920e-02f, 2.00724125e-01f, -4.03488465e-02f, 7.38448352e-02f,
  -8.44731480e-02f, -2.11987481e-01f, -3.94924343e-01f, -1.81923062e-01f, -7.56038502e-02f, -5.86962879e-01f, -4.09120440e-01f, -1.13981605e-01f, -3.23771298e-01f, -4.70218658e-01f,
  -1.31846857e+00f, -5.15624285e-01f, -6.44089937e-01f, -3.55603486e-01f, 2.28651926e-01f, 1.52158588e-01f, 2.63102531e-01f, -2.48555336e-02f, -1.59471810e-01f, -1.86016008e-01f,
  3.07237357e-01f, 2.35757634e-01f, -1.74002592e-02f, 3.75910074e-01f, 2.62362599e-01f, 2.14963093e-01f, 2.09244922e-01f, -2.46971790e-02f, 5.25760293e-01f, 8.84685814e-01f,
  6.67857349e-01f, -1.18363887e-01f, -2.36596540e-01f, 2.70865768e-01f, -2.97278957e-03f, 1.00067534e-01f, -3.23137969e-01f, -2.39009112e-01f, 2.01514244e-01f, -3.15616965e-01f,
  -3.06320965e-01f, -1.85817212e-01f, 3.02779257e-01f, 2.04179242e-01f, 1.44190118e-02f, -3.21047664e-01f, -8.00586641e-02f, -3.80133092e-01f, -1.93816841e-01f, -1.76766276e-01f,
  -3.61188091e-02f, -1.87893331e-01f, -1.11780442e-01f, 7.28559047e-02f, 7.00975209e-02f, -3.54787335e-02f, 9.67916623e-02f, -2.50216365e-01f, -4.12937105e-01f, -4.62491773e-02f,
  2.75285214e-01f, 6.29112571e-02f, -2.19245479e-01f, 1.62617311e-01f, 1.16193198e-01f, -1.44665703e-01f, -1.14605408e-02f, -2.07627848e-01f, -5.15473127e-01f, -1.02869487e+00f,
  5.11204191e-02f, -9.87183154e-02f, 1.02953799e-01f, -1.78901508e-01f, 1.07210398e-01f, -6.79348037e-02f, 2.08049975e-02f, 3.55692923e-01f, 2.31027395e-01f, -2.34766737e-01f,
  1.99513003e-01f, -6.46354333e-02f, -5.15107475e-02f, -2.13614881e-01f, 7.41880983e-02f, -1.28392994e-01f, 1.98923722e-02f, -9.77504775e-02f, 8.22872221e-02f, -1.58026248e-01f,
  2.09088489e-01f, -1.68426812e-01f, -2.09685206e-01f, 6.97751716e-02f, 1.05150029e-01f, 5.87212779e-02f, 6.68807998e-02f, 3.39953154e-02f, -6.87007755e-02f, -1.91050574e-01f,
  -4.66466188e-01f, 4.44894463e-01f, -2.95526326e-01f, 3.63801643e-02f, -1.30610824e-01f, 4.83421050e-02f, -1.30940512e-01f, 5.25802597e-02f, -1.03166752e-01f, -4.08139341e-02f,
  1.36194304e-01f, -2.40292042e-01f, -2.97656953e-01f, 7.25465044e-02f, 1.72933653e-01f, 9.68125463e-02f, 2.12134644e-02f, 5.09075448e-02f, 1.88276753e-01f, -5.83464392e-02f,
  -9.77904424e-02f, -1.45742437e-03f, -4.33108509e-01f, -3.33197981e-01f, 1.55647948e-01f, -2.45526254e-01f, -3.23792130e-01f, -1.93921894e-01f, -5.10089219e-01f, -1.06943452e+00f,
  -4.11099583e-01f, -4.30018485e-01f, -4.18133080e-01f, 2.65188843e-01f, 3.93090516e-01f, -3.56774107e-02f, -7.06289351e-01f, -2.94766992e-01f, 2.62999058e-01f, -2.01808259e-01f,
  -1.44550383e-01f, 1.90583587e-01f, -2.09892109e-01f, -7.02228069e-01f, -1.51704729e+00f, -1.18612647e+00f, -8.65666032e-01f, -9.24542606e-01f, -4.82701391e-01f, 1.08261429e-01f,
  2.71238208e-01f, -1.91374794e-01f, -3.04853469e-01f, -4.78386916e-02f, 4.20879722e-01f, 2.29618594e-01f, 1.09064169e-01f, 4.07684334e-02f, -1.29183233e-01f, -2.40228064e-02f,
  -8.40160698e-02f, -4.12363768e-01f, 3.02734703e-01f, -2.47409657e-01f, 1.50475025e-01f, -1.70870051e-01f, -1.76928893e-01f, -6.33231029e-02f, 7.18693212e-02f, -2.43751317e-01f,
  -6.30743951e-02f, 2.10909948e-01f, 2.79086560e-01f, 2.00860724e-02f, 1.48680165e-01f, -2.09645391e-01f, -7.38428086e-02f, -4.35970247e-01f, -3.79279613e-01f, -7.19814301e-02f,
  7.00421408e-02f, 1.06943965e-01f, -6.16542280e-01f, 8.23900104e-02f, 3.47474925e-02f, 2.75466502e-01f, 1.30738541e-01f, 3.57430905e-01f, -2.89425582e-01f, -5.43684587e-02f,
  5.91187477e-02f, 8.37817565e-02f, 2.60147959e-01f, 1.11493757e-02f, -2.04411924e-01f, 1.76916033e-01f, -6.71397522e-02f, -7.51499459e-02f, 8.66069272e-02f, 7.76580572e-02f,
  1.35742784e-01f, 6.38446286e-02f, 1.41152693e-02f, -6.60959408e-02f, -2.44273450e-02f, 1.39184892e-01f, -1.86559185e-01f, -1.50118604e-01f, -1.12563528e-01f, 8.48328918e-02f,
  -2.49265224e-01f, 2.57731080e-01f, 2.41865441e-01f, -2.15381131e-01f, -2.05271482e-01f, -7.69505203e-02f, -1.11951418e-02f, -2.43661001e-01f, -7.97939226e-02f, -7.17819482e-02f,
  -2.25040838e-01f, -1.29446862e-02f, -3.15238029e-01f, -2.66968638e-01f, 6.94411248e-02f, 9.06772986e-02f, 9.46510881e-02f, -5.21079004e-02f, 8.51714015e-02f, -1.99491411e-01f,
  -3.89405817e-01f, -1.32270800e-02f, 1.76677808e-01f, 2.77262200e-02f, 1.30975947e-01f, -1.07821174e-01f, 1.44810625e-03f, -2.59906739e-01f, -1.62133977e-01f, 2.72519946e-01f,
  6.82231486e-02f, -6.16937339e-01f, -6.33239210e-01f, -4.76705670e-01f, -8.37517977e-02f, -3.70613277e-01f, -6.58429086e-01f, -1.92617476e-01f, -7.07389593e-01f, -4.61333454e-01f,
  -4.31278408e-01f, -3.02538097e-01f, 7.43817210e-01f, -6.86188936e-01f, 3.40120763e-01f, 5.80217361e-01f, 5.86136699e-01f, -1.16117328e-01f, -3.07241499e-01f, 2.99086779e-01f,
  -3.65383118e-01f, -6.86810076e-01f, -6.22759700e-01f, -3.15450758e-01f, -1.20904796e-01f, 6.66553020e-01f, 5.38112998e-01f, 2.74302006e-01f, 2.90120751e-01f, 2.74068207e-01f,
  7.78930783e-02f, -2.15390295e-01f, -4.60244119e-01f, -9.57068950e-02f, -1.98553339e-01f, -1.66167468e-02f, 4.33767438e-02f, -2.76796937e-01f, -2.96855494e-02f, -2.61581302e-01f,
  2.38769636e-01f, -3.59549850e-01f, 1.25441805e-01f, -2.25646809e-01f, -8.46021697e-02f, -8.63201991e-02f, 1.07503660e-01f, -2.04758093e-01f, -8.04562122e-02f, -6.84233522e-03f,
  -2.10090250e-01f, -7.52293691e-03f, -2.27833852e-01f, -3.66687728e-03f, 5.35422154e-02f, 1.13876522e-01f, -2.45907102e-02f, -1.24960877e-01f, -1.34450555e-01f, 8.85138512e-02f,
  -9.44275931e-02f, -2.33405121e-02f, 2.06807884e-03f, 1.07700698e-01f, -1.34882927e-01f, -6.79892898e-02f, -8.34380239e-02f, 4.33619088e-03f, -1.71769299e-02f, 1.18197398e-02f,
  5.62234502e-03f, -5.60988253e-03f, -6.56161383e-02f, 2.28620842e-02f, 7.06757456e-02f, 6.03516102e-02f, -1.04364052e-01f, -9.67983007e-02f, -3.70859578e-02f, -2.17109025e-02f,
  -5.82627617e-02f, -3.37431729e-02f, -5.06828316e-02f, -1.04654104e-01f, -3.79287675e-02f, -1.67187735e-01f, 6.40300140e-02f, -2.07751375e-02f, -5.28145162e-03f, -3.67335789e-02f,
  -6.86031133e-02f, 1.91589557e-02f, 5.47551829e-03f, -1.24572851e-02f, 6.53563961e-02f, 5.14388457e-02f, -1.13990635e-01f, -7.43836313e-02f, -5.54994717e-02f, -2.63865497e-02f,
  -3.73048186e-01f, -2.31011994e-02f, 7.93329105e-02f, -1.50367633e-01f, 2.42824461e-02f, 8.43063556e-03f, -1.75070360e-01f, 3.09668249e-03f, -4.47527654e-02f, -6.93124533e-02f,
  -9.24689472e-02f, -2.12504552e-03f, -2.26883553e-02f, -4.85360250e-02f, 2.55768806e-01f, 8.38189200e-02f, -5.53717688e-02f, -5.66807054e-02f, -1.44352064e-01f, 6.12985007e-02f,
  -2.10397840e-02f, 1.19575091e-01f, 3.71272601e-02f, 1.05271116e-01f, -4.32467461e-02f, 2.20826641e-01f, 1.46069899e-01f, 1.32351801e-01f, 1.76786005e-01f, 4.33257103e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.10129762e+00f, 4.58802402e-01f, -1.76703499e-03f, 7.73284495e-01f, 1.00594509e+00f, 1.05256104e+00f, 4.64608073e-01f, 5.28428257e-01f, 5.82586288e-01f, 1.11947405e+00f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -8.74555409e-02f, -5.80554426e-01f, -3.70442331e-01f, -3.24927092e-01f, -7.11593032e-02f, -3.13103348e-01f, 4.80192341e-02f, -3.72935385e-01f, 2.99967695e-02f, -9.87059847e-02f,
  -4.93108928e-02f, 1.21415295e-01f, -8.58248323e-02f, 3.13108623e-01f, 1.94596931e-01f, -5.86070538e-01f, 9.99322385e-02f, -5.79729676e-04f, -2.43400753e-01f, -1.38513535e-01f,
  5.47630452e-02f, 2.74973989e-01f, 1.86487660e-01f, 2.09447891e-01f, 2.42736891e-01f, -5.36809206e-01f, -4.62298319e-02f, 3.40999603e-01f, 1.98305070e-01f, 7.92640224e-02f,
  5.41982129e-02f, -4.57372278e-01f, 2.11547941e-01f, 2.07888916e-01f, -4.14466746e-02f, 1.07238978e-01f, -6.77218437e-01f, 2.90735781e-01f, 7.55262077e-02f, 5.58802962e-01f,
  -2.71144331e-01f, 5.05584061e-01f, -2.72369117e-01f, 1.54609218e-01f, 3.62234861e-01f, -2.34345034e-01f, -8.32237005e-02f, 2.08828628e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.24309042e-01f, 5.13038278e-01f, 1.91196188e-01f, -5.28272510e-01f, 9.51184094e-01f, -1.60254076e-01f, 6.26485646e-01f, 6.23435974e-01f, -7.72791356e-02f, -1.66983917e-01f,
  1.71099699e+00f, 7.52607360e-02f, -7.90917218e-01f, 8.29895377e-01f, 8.51926431e-02f, 8.08842897e-01f, -4.91927713e-01f, -5.74534953e-01f, -1.39763877e-01f, -6.78401291e-01f,
  7.45910287e-01f, -3.99147928e-01f, -3.98128003e-01f, -1.11431873e+00f, -6.66139543e-01f, 7.71068752e-01f, 7.58337379e-01f, 2.63948113e-01f, 5.60532570e-01f, -6.17779016e-01f,
  3.79970729e-01f, 2.06521928e-01f, 6.92148149e-01f, 8.39958847e-01f, 6.68265462e-01f, -7.21365094e-01f, -8.24597657e-01f, 3.03791761e-01f, -6.06294215e-01f, -1.31201237e-01f,
  6.37015477e-02f, -5.22008657e-01f, 8.09651494e-01f, 2.30302095e-01f, -4.03253824e-01f, 2.65982866e-01f, 9.70326304e-01f, -5.48198640e-01f, 5.33446729e-01f, 2.22982883e-01f,
  5.24285734e-01f, 2.45973364e-01f, -3.46231848e-01f, -2.27118328e-01f, 1.77587941e-01f, 7.80795515e-01f, 1.50339827e-01f, 1.10334504e+00f, 2.49948308e-01f, 5.49051940e-01f,
  -2.92094260e-01f, 2.87114799e-01f, -5.36640994e-02f, 1.25075030e+00f, -2.75644422e-01f, -6.28585279e-01f, -6.34521767e-02f, -2.59063914e-02f, -1.23310111e-01f, -1.54390382e-02f,
  7.11777031e-01f, 2.35943720e-01f, 2.77258009e-01f, 4.26181674e-01f, 4.34622854e-01f, 7.48715699e-02f, 5.86740136e-01f, 8.08563054e-01f, -7.70499945e-01f, -1.04370797e+00f,
  6.70533895e-01f, 8.65256786e-01f, 9.18479487e-02f, -3.77228081e-01f, -1.53007224e-01f, -1.03438294e+00f, -3.59837830e-01f, -3.36046666e-01f, -1.03699219e+00f, 1.39187717e+00f,
  -5.47765255e-01f, 4.38894510e-01f, -2.86456943e-01f, 6.57603383e-01f, 8.15628529e-01f, 8.11204970e-01f, 2.90219903e-01f, -1.30966142e-01f, -9.88187015e-01f, 3.11721951e-01f,
  -5.31331718e-01f, 1.21674347e+00f, -2.47415558e-01f, -7.52606750e-01f, -1.64861664e-01f, -9.77560699e-01f, 5.65281510e-02f, 1.32468140e+00f, 6.79457784e-02f, 4.16473866e-01f,
  7.14568347e-02f, -3.31293404e-01f, -3.28567803e-01f, 4.04910930e-02f, 5.62256873e-01f, 5.23240268e-01f, 9.82727587e-01f, -7.88417518e-01f, 1.40203202e+00f, 8.41701180e-02f,
  -2.10399941e-01f, -4.66020316e-01f, -2.23064944e-02f, 1.30251512e-01f, 1.04898810e+00f, -4.01541233e-01f, -1.18996277e-01f, 3.65165502e-01f, 5.86318076e-01f, 4.60361600e-01f,
  2.80161291e-01f, 1.89108878e-01f, -7.56781816e-01f, -7.92513788e-02f, 6.84262991e-01f, -2.83652335e-01f, -8.53579998e-01f, -3.32422763e-01f, -6.67316079e-01f, 1.41353130e+00f,
  6.89161897e-01f, -3.81930023e-01f, 4.51954365e-01f, -2.73797512e-01f, -1.94500282e-01f, 2.27394179e-01f, -2.99861848e-01f, 6.96967065e-01f, -1.46781981e-01f, 3.31188701e-02f,
  -2.25106731e-01f, 6.27549469e-01f, -9.96718407e-02f, 2.35656008e-01f, -7.84184396e-01f, -1.01877320e+00f, 6.54568076e-01f, 1.37232757e+00f, 9.54390407e-01f, 3.83230597e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.72013402e-01f, 2.55903810e-01f, 7.90159762e-01f, -4.89109129e-01f, 3.13693643e-01f, 1.06592774e+00f, 2.07750410e-01f, 6.63671196e-01f, 6.06174409e-01f, 5.34064114e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  1.33611426e-01f, 7.43043423e-01f, -9.33130682e-01f, -3.52662429e-02f, 4.67500627e-01f, -1.15668368e+00f, 1.28522769e-01f, -2.66505718e-01f, 4.20683563e-01f, -9.95491147e-01f,
  -6.08564839e-02f, 2.31262639e-01f, -5.32204881e-02f, -2.71091461e-01f, -1.25865436e+00f, 5.17586827e-01f, 9.96082544e-01f, -3.64653438e-01f, -7.99322248e-01f, 2.54222145e-03f,
  -7.78444335e-02f, -6.20605111e-01f, 3.66095036e-01f, 1.07159257e+00f, -2.84478486e-01f, -3.47940922e-01f, 4.28020298e-01f, -1.22454059e+00f, -4.64676499e-01f, 4.33424830e-01f,
  -6.39956057e-01f, -1.09589374e+00f, 7.11597681e-01f, 5.13086498e-01f, 5.55497944e-01f, 6.73035026e-01f, 1.24341905e+00f, -7.62244463e-01f, 1.53512701e-01f, -1.10547578e+00f,
  1.67750701e-01f, 1.87861577e-01f, -4.67832386e-01f, 2.79326081e-01f, -1.53451517e-01f, -3.43111977e-02f, 4.02701646e-01f, -6.24806702e-01f, 1.37719452e-01f, -1.07059634e+00f,
  -2.35080823e-01f, 2.98255265e-01f, 2.08642960e-01f, 1.89341247e-01f, -3.27319205e-01f, -6.41857922e-01f, -6.23368502e-01f, 1.74607456e-01f, -1.35914946e+00f, 5.63869655e-01f,
  -1.88936844e-01f, -1.85710061e-02f, -1.54822230e+00f, 7.13676512e-01f, -2.32816011e-01f, 5.75892627e-01f, 8.51882756e-01f, 3.53681982e-01f, -1.33298647e+00f, 8.27241957e-01f,
  -1.17030919e+00f, 2.76027143e-01f, 3.56583923e-01f, -1.84181497e-01f, 2.33572070e-03f, 5.03186166e-01f, -6.48658097e-01f, -4.22201186e-01f, 1.22220732e-01f, 9.54117104e-02f,
  -4.12884921e-01f, -6.21248074e-02f, 9.95690823e-01f, -6.91079021e-01f, -7.77541220e-01f, -3.97607028e-01f, 6.33679211e-01f, -1.29866630e-01f, 7.72779286e-01f, 1.17744602e-01f,
  -1.81557164e-01f, -2.26559341e-01f, -1.12158276e-01f, -1.06255102e+00f, -1.05063879e+00f, -1.15132380e+00f, 8.99539471e-01f, -8.79786134e-01f, -8.12373281e-01f, 5.18378755e-03f,
  -2.32761383e-01f, 1.89539224e-01f, -1.11186445e+00f, -1.77774668e-01f, -6.83022857e-01f, -5.59120238e-01f, -7.04884008e-02f, -1.31692028e+00f, 4.80765522e-01f, 3.09676081e-01f,
  7.51477063e-01f, -1.16688824e+00f, -2.28536904e-01f, 3.66393328e-02f, -5.02467789e-02f, 3.72113138e-01f, 1.78401992e-01f, 7.98488557e-02f, -2.44673684e-01f, -1.44562572e-01f,
  -2.23093867e-01f, 3.98683250e-01f, 2.61962086e-01f, -5.75805068e-01f, -3.82666707e-01f, -8.48398507e-01f, -9.30197299e-01f, 8.05630624e-01f, -8.88796449e-01f, 4.43571866e-01f,
  -4.88146581e-02f, 1.31795049e-01f, -4.17373568e-01f, 5.21433726e-02f, 5.56926608e-01f, -1.09089875e+00f, -1.12992871e+00f, 6.71664059e-01f, -5.27640700e-01f, -8.25372756e-01f,
  -5.09203732e-01f, 2.14023158e-01f, -5.61482131e-01f, -2.73279548e-01f, -4.28636581e-01f, 1.18344925e-01f, 5.46461456e-02f, 3.95713300e-01f, 5.36558665e-02f, 4.27344412e-01f,
  -1.06630397e+00f, -1.03097096e-01f, 4.43881154e-01f, -5.73492587e-01f, -1.50073797e-01f, -3.14198524e-01f, 8.87714386e-01f, -5.92149377e-01f, 4.85537976e-01f, -1.35507897e-01f,
  -4.26741451e-01f, 6.66570961e-02f, -7.53198683e-01f, -2.22329870e-01f, 2.41695002e-01f, 2.16409117e-01f, -5.07109687e-02f, 5.92969418e-01f, -1.17858338e+00f, 6.99810505e-01f,
  -6.80560231e-01f, 5.18078804e-01f, 1.43206924e-01f, -1.00022113e+00f, -4.13105249e-01f, -1.41301632e+00f, 3.10411584e-02f, 2.41405159e-01f, 5.92132151e-01f, -7.66293287e-01f,
  4.53097194e-01f, 5.41413426e-01f, -5.47508836e-01f, -1.74757898e-01f, -9.38292503e-01f, -1.07617426e+00f, -2.25731924e-01f, -4.38383996e-01f, -1.16518259e+00f, 9.92764056e-01f,
  2.75807798e-01f, 5.11831164e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.03739417e-01f, -3.19772996e-02f, 2.55870163e-01f, -5.17912447e-01f, 2.72077233e-01f, 1.76913545e-01f, 2.40147665e-01f, -8.82223397e-02f, -4.36700314e-01f, -2.65234932e-02f,
  -4.81251061e-01f, 5.22009544e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    