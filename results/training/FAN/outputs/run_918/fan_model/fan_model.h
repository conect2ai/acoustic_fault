/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.98565257e-01f, 4.67964150e-02f, 3.41250420e-01f, 1.39086470e-01f, 1.28495157e-01f, -3.47685628e-02f, -5.33379056e-02f, -1.78537980e-01f, -2.69952137e-02f, 1.60040259e-02f,
  5.73147163e-02f, 3.26703377e-02f, 2.06509847e-02f, -1.24700338e-01f, -7.98886716e-02f, -7.25393370e-02f, 2.52577942e-02f, 1.55193165e-01f, 1.27672292e-02f, -2.60025468e-02f,
  -1.62980333e-01f, -3.79171669e-02f, 1.69334218e-01f, -1.01868823e-01f, -3.75114530e-02f, 4.04242463e-02f, 1.56006217e-01f, 3.29755880e-02f, 4.50758599e-02f, 1.26832621e-02f,
  2.99006194e-01f, 1.71826378e-01f, -2.68117487e-02f, -9.21413675e-03f, 1.23520985e-01f, -2.90506352e-02f, -1.41879581e-02f, 8.69678110e-02f, -5.66420108e-02f, -4.67495732e-02f,
  9.75268111e-02f, -1.61407739e-02f, -5.77555504e-03f, -8.14479589e-02f, 6.16101734e-02f, -9.01424736e-02f, -6.80684969e-02f, 5.66213354e-02f, -5.14951609e-02f, 1.44915832e-02f,
  -5.52737936e-02f, 2.20189929e-01f, 2.40163550e-01f, -1.10137463e-01f, -1.41756786e-02f, 8.91560093e-02f, 4.06417251e-02f, 6.90041482e-02f, 6.20570630e-02f, -8.19703266e-02f,
  -7.10706636e-02f, 7.86582828e-02f, -5.60342558e-02f, 1.58068947e-02f, -1.53919170e-02f, 3.54917608e-02f, 8.76228232e-03f, -4.60043587e-02f, -1.46281458e-02f, -5.95452040e-02f,
  1.53069282e-02f, -3.70687619e-02f, 5.02782129e-02f, -6.80754660e-03f, 2.75388416e-02f, -5.72835561e-03f, 1.74993966e-02f, -6.15768209e-02f, 3.71401012e-02f, 3.72441262e-02f,
  -2.64347419e-02f, 1.13780454e-01f, 7.68204927e-02f, -1.39784411e-01f, -1.98435802e-02f, -6.29163086e-02f, 1.33512367e-04f, -9.45001468e-02f, 2.39406172e-02f, -3.15937847e-02f,
  -1.07560366e-01f, 1.04850926e-01f, 2.90663820e-02f, -5.55461422e-02f, 7.66607448e-02f, -6.80371448e-02f, 6.67763725e-02f, 2.70862952e-02f, 1.06197827e-01f, -1.95884295e-02f,
  3.23899500e-02f, 6.07188866e-02f, 3.37559613e-03f, -9.25598200e-03f, -6.18049689e-02f, 1.31437331e-02f, -4.98219915e-02f, 1.20662391e-01f, 3.20963301e-02f, -6.98084608e-02f,
  -8.61582309e-02f, 4.76668067e-02f, 1.90907434e-01f, -5.63980900e-02f, 8.07017311e-02f, 1.19206093e-01f, 1.81735214e-02f, -8.20007920e-02f, 8.85542184e-02f, -1.08708791e-01f,
  -2.05907095e-02f, 1.68877169e-01f, 1.76293775e-01f, -1.73612714e-01f, 4.73585464e-02f, 8.12060237e-02f, 1.07035011e-01f, 8.84291083e-02f, -1.15941323e-01f, 4.07816581e-02f,
  8.86514634e-02f, -8.16921219e-02f, -1.17470426e-02f, 4.60236669e-02f, 1.73176471e-02f, 1.81027159e-01f, 2.02265605e-02f, 1.47579685e-02f, 1.61298120e-03f, 2.53350250e-02f,
  -6.14505932e-02f, -9.66862589e-02f, 6.66947896e-03f, -1.03510767e-01f, -1.73764884e-01f, -8.91449209e-03f, 2.17934381e-02f, -5.48297912e-02f, 5.45667186e-02f, -1.41934484e-01f,
  8.43369961e-02f, -6.76488206e-02f, -4.73709255e-02f, -8.83287415e-02f, -9.20940265e-02f, 6.24531247e-02f, -4.22798917e-02f, 8.99376534e-03f, -6.86377585e-02f, 7.25787953e-02f,
  -2.79630907e-02f, -5.27488254e-02f, 4.02138345e-02f, -5.36556877e-02f, -4.22455855e-02f, -7.94637576e-02f, 3.84474061e-02f, -3.76174040e-02f, -1.25788832e-02f, -1.85446851e-02f,
  -6.16645254e-02f, 3.94906402e-02f, 4.86932807e-02f, 7.86469691e-03f, 3.24663408e-02f, -9.43431456e-04f, 8.79894271e-02f, -1.35180593e-01f, 1.11537591e-01f, 6.57914653e-02f,
  5.48845939e-02f, -1.74723100e-02f, 1.32180694e-02f, 1.98556874e-02f, -4.14285101e-02f, 1.01611149e-02f, -6.23787846e-03f, 8.03252757e-02f, 1.50359597e-03f, 8.31931233e-02f,
  -9.77738388e-03f, -1.06777539e-02f, -6.46398216e-02f, 7.45134137e-04f, -6.15493879e-02f, 5.81796169e-02f, -3.43640298e-02f, -4.99698613e-03f, -1.79020483e-02f, -4.63609844e-02f,
  -3.57234702e-02f, -6.19845651e-02f, -3.32533419e-02f, -6.37263507e-02f, -5.81274778e-02f, -2.39017829e-02f, -4.18146588e-02f, 3.61908413e-02f, 6.70810640e-02f, -5.59947118e-02f,
  2.57715974e-02f, 1.73625797e-01f, -5.12676574e-02f, -4.56355624e-02f, 6.14331551e-02f, 4.58279019e-03f, 3.81581634e-02f, 8.18875581e-02f, -2.47791056e-02f, 1.21987611e-02f,
  -5.58884675e-03f, 4.40502577e-02f, 7.60950074e-02f, -4.47369134e-03f, 8.29204917e-02f, -2.70552728e-02f, 1.29502252e-01f, 7.97246620e-02f, 9.21860337e-02f, 1.28084905e-02f,
  6.18544370e-02f, 1.42574221e-01f, 1.38402089e-01f, 8.23486522e-02f, -3.20265330e-02f, 3.18935961e-02f, 1.64751410e-01f, 8.36586580e-02f, 1.12441763e-01f, 1.47864357e-01f,
  1.57243073e-01f, 1.44957483e-01f, 1.96996123e-01f, -4.72969785e-02f, -7.93948956e-03f, -9.73318666e-02f, 4.49945591e-02f, -1.72536999e-01f, -3.20972688e-02f, -2.12717075e-02f,
  -1.21004954e-01f, -1.56012625e-01f, -1.86650410e-01f, -1.25301957e-01f, 1.48136066e-02f, -4.84578125e-02f, 1.56046987e-01f, 1.01834476e-01f, -1.62800774e-02f, 8.07526112e-02f,
  1.26579730e-02f, 1.53929204e-01f, 6.31038696e-02f, 9.31733027e-02f, 1.70857251e-01f, -7.82398805e-02f, 1.02704994e-01f, 8.54833126e-02f, 1.94641933e-01f, 2.43448690e-01f,
  -4.85925116e-02f, 1.62413582e-01f, -1.20895445e-01f, 2.31713918e-03f, -5.33719808e-02f, 3.99355963e-02f, -2.67799869e-02f, -3.47980931e-02f, -7.79157057e-02f, 2.89489254e-02f,
  8.00679717e-03f, -8.01564939e-03f, 2.39260830e-02f, -2.18834486e-02f, 4.13047858e-02f, -3.80770490e-02f, 8.09052959e-03f, 1.25209153e-01f, -5.33856377e-02f, -2.91449782e-02f,
  -1.74936205e-02f, 2.00618982e-01f, 2.08969098e-02f, -1.73483714e-02f, 9.90510657e-02f, -7.69052878e-02f, 3.10726464e-02f, 8.50412473e-02f, 1.00834121e-03f, 4.63071950e-02f,
  1.40112694e-02f, 4.16515321e-02f, 9.82417613e-02f, -1.99615788e-02f, -2.38085445e-02f, 5.05502559e-02f, 3.79410200e-02f, 5.65755405e-02f, -1.71856228e-02f, 4.38406542e-02f,
  -1.31950239e-02f, 3.31142470e-02f, -7.48433694e-02f, 3.29587273e-02f, -6.28534853e-02f, 3.56923304e-02f, 8.09848085e-02f, -7.58630931e-02f, -2.47207116e-02f, 3.63534763e-02f,
  -7.04744505e-03f, -7.44130462e-04f, -1.44548641e-04f, -1.86167227e-03f, 7.93759432e-03f, 6.04062565e-02f, -3.35286818e-02f, 3.97672616e-02f, -9.90869105e-02f, -1.20803537e-02f,
  -3.35792303e-01f, -2.96218898e-02f, -6.49411678e-02f, -4.03505452e-02f, 3.22799720e-02f, -5.19370195e-03f, -6.40507266e-02f, 6.73448741e-02f, 6.66305497e-02f, -2.46556178e-02f,
  -1.25730243e-02f, -2.10510101e-02f, -5.75911775e-02f, 3.84620689e-02f, -3.02812853e-03f, -4.47280705e-02f, -9.85021964e-02f, -8.12889542e-03f, -9.54108536e-02f, 3.43398564e-02f,
  -6.58561885e-02f, -1.31128609e-01f, -2.06762359e-01f, -2.03355715e-01f, -6.07596636e-02f, -8.47035646e-02f, -4.70002703e-02f, -7.12620243e-02f, -7.04770312e-02f, -2.08701760e-01f,
  2.43243650e-01f, -1.10456988e-01f, 1.19517826e-01f, -1.18744805e-01f, -2.56437391e-01f, -1.59809053e-01f, -1.56929448e-01f, 2.78444868e-02f, -8.08122158e-02f, -1.04821071e-01f,
  -2.08132997e-01f, 9.33091715e-02f, 6.46706820e-02f, 1.37706533e-01f, 2.63687938e-01f, 1.10145405e-01f, 9.87757221e-02f, 2.81979054e-01f, 2.78457880e-01f, -4.12394851e-02f,
  -3.57926823e-02f, 8.55516791e-02f, 2.36662254e-01f, 4.73316908e-02f, -7.40048960e-02f, -2.92684119e-02f, -9.65398997e-02f, -3.71175297e-02f, -2.91910712e-02f, -8.39090794e-02f,
  1.57040320e-02f, 2.63780076e-02f, 1.20719932e-01f, 6.21852465e-02f, -1.07996151e-01f, 1.19548962e-01f, -5.45817427e-02f, 7.48853311e-02f, -7.04044923e-02f, 2.56320275e-03f,
  -9.87433270e-02f, 5.55288754e-02f, -3.48287337e-02f, -8.54218677e-02f, -8.32375214e-02f, 3.91856860e-03f, 1.81692746e-02f, 1.86278999e-01f, 1.90809131e-01f, -3.86014134e-02f,
  -7.66396895e-02f, -1.29450962e-01f, -7.93876220e-03f, -2.10662745e-02f, 1.43260226e-01f, 1.21723004e-01f, -6.49249926e-02f, 5.04493155e-02f, 1.95248291e-01f, -1.30267274e-02f,
  -3.84396389e-02f, 4.90536019e-02f, 1.42593719e-02f, -8.42293538e-03f, 4.95452844e-02f, -2.18642643e-03f, -8.96531716e-02f, -2.49457583e-02f, -2.66360510e-02f, 5.13229594e-02f,
  5.05874045e-02f, -6.89799851e-03f, 6.34988844e-02f, 2.78855432e-02f, 7.77125545e-03f, 6.12756573e-02f, 4.29244675e-02f, 9.30940434e-02f, 4.43388596e-02f, 1.76693015e-02f,
  -3.05348095e-02f, 2.38007009e-02f, 7.33110532e-02f, 5.23383133e-02f, 8.48688465e-03f, 6.57458901e-02f, -4.46642749e-02f, -3.88760469e-03f, 1.23063751e-01f, -6.03240952e-02f,
  4.01147082e-02f, 1.05442256e-01f, 3.69474255e-02f, 1.01853073e-01f, -3.99667695e-02f, 3.59533802e-02f, 2.91711576e-02f, 7.67119378e-02f, -1.62368710e-03f, -2.92317029e-02f,
  -8.83533806e-02f, 7.95090944e-02f, 5.77622280e-02f, 6.56639412e-02f, -1.11247227e-03f, -6.79593757e-02f, -1.91042703e-02f, 5.26987277e-02f, 4.70372923e-02f, 2.70113051e-02f,
  8.03418607e-02f, 1.26082093e-01f, 8.12605992e-02f, 4.98661306e-03f, 7.40892813e-02f, 3.36280167e-02f, 1.31193787e-01f, 1.42479330e-01f, 2.15483189e-01f, 9.16893631e-02f,
  -2.70535409e-01f, 1.21531136e-01f, -1.28367767e-01f, 3.54857333e-02f, 3.22730802e-02f, -3.30780335e-02f, 4.13719937e-02f, 5.08162268e-02f, -1.53163485e-02f, 7.22418949e-02f,
  1.48831800e-01f, -2.74181012e-02f, 1.94723010e-02f, 8.21544230e-03f, 3.12553123e-02f, -7.56664649e-02f, 2.77891848e-02f, -1.91369921e-01f, -7.52824619e-02f, 2.37979088e-02f,
  -3.24247330e-02f, -6.72643185e-02f, -1.52906656e-01f, -1.24799469e-02f, 4.68590744e-02f, -8.39024689e-03f, -4.60861102e-02f, 1.92847871e-03f, -9.79032926e-03f, 6.75231451e-03f,
  -2.09549934e-01f, 2.29659793e-03f, -5.52326366e-02f, 8.97103325e-02f, 1.82997400e-03f, -8.59763846e-03f, -2.06119101e-03f, 5.78142628e-02f, 1.28222611e-02f, 6.03576526e-02f,
  8.61755982e-02f, -1.07600689e-02f, 3.52769569e-02f, -1.04846442e-02f, -6.56538606e-02f, -4.89027202e-02f, -9.32138413e-02f, -1.64646329e-03f, -1.16504699e-01f, 7.08227791e-03f,
  9.21240449e-02f, -4.71252901e-03f, -4.87531237e-02f, -6.70404509e-02f, 5.76275401e-02f, -4.70065810e-02f, -2.38329191e-02f, -1.17263138e-01f, -5.68812191e-02f, -2.13621631e-01f,
  -2.94637717e-02f, -2.77550966e-02f, 5.40117882e-02f, -6.18889891e-02f, -3.60615328e-02f, 4.49323356e-02f, -1.76891480e-02f, -1.31666604e-02f, -3.92404012e-02f, 2.06182878e-02f,
  2.48952638e-02f, 5.52078001e-02f, -7.44635388e-02f, 3.05991471e-02f, -3.01267370e-03f, -5.24504669e-02f, 9.63333696e-02f, -7.05425665e-02f, 4.07333411e-02f, 4.28545987e-03f,
  5.00818603e-02f, -2.13577971e-02f, 1.14176748e-02f, -1.06144398e-02f, -1.59679130e-02f, 1.45073105e-02f, -4.44512628e-02f, 4.24425304e-02f, 4.23274003e-02f, 2.45905723e-02f,
  -1.90966383e-01f, 1.81776062e-01f, -8.46312717e-02f, -1.00649819e-01f, -6.01624474e-02f, -5.87354898e-02f, 6.24626502e-02f, -6.78759068e-02f, 6.03265651e-02f, -2.63270698e-02f,
  7.50286952e-02f, -5.65691963e-02f, 7.09748070e-04f, -5.35233703e-04f, 1.46712810e-02f, -5.80844060e-02f, -4.13264893e-02f, -1.09937318e-01f, 1.08155459e-02f, -4.82524484e-02f,
  -8.97426065e-03f, -1.78836569e-01f, -2.13741183e-01f, -1.56721577e-01f, -4.26909747e-03f, -2.13695392e-02f, -1.14490643e-01f, -1.46116912e-01f, -1.87817067e-01f, -1.60383090e-01f,
  2.05265418e-01f, -2.21613690e-01f, 5.16811758e-02f, 5.27236350e-02f, 8.98850057e-03f, -7.36973584e-02f, -1.57478020e-01f, 1.03207054e-02f, 1.08547416e-02f, 1.08309481e-02f,
  -1.18367255e-01f, 9.17332992e-02f, 1.31280690e-01f, 4.46348488e-02f, 4.12272327e-02f, -5.47348447e-02f, -6.27474561e-02f, 7.20787048e-02f, 1.99980021e-01f, 7.37143159e-02f,
  4.38429490e-02f, 6.78577721e-02f, 5.32034673e-02f, 7.09727481e-02f, -1.30173311e-01f, 6.15366399e-02f, -1.47699058e-01f, -9.49142352e-02f, -1.60710722e-01f, -1.66912779e-01f,
  6.74558803e-02f, -9.26834717e-02f, 8.93069804e-03f, -9.01882350e-03f, 1.18562710e-02f, 5.49952760e-02f, -2.59301346e-02f, 3.41011398e-02f, -6.92503527e-02f, -9.07802880e-02f,
  -1.08368777e-01f, 1.37481298e-02f, -7.89789334e-02f, -1.09528098e-02f, 5.96567988e-02f, -2.99831908e-02f, 7.21966987e-03f, 6.49318323e-02f, -3.67351435e-02f, -1.02233522e-01f,
  -1.44082680e-01f, -4.43739444e-03f, 8.28291103e-02f, -2.43250318e-02f, 4.06288169e-02f, 5.86142689e-02f, 2.87742801e-02f, -7.17971986e-03f, 1.74553301e-02f, 1.54403634e-02f,
  2.41010170e-02f, 3.60365398e-02f, 3.29170972e-02f, -1.40636787e-02f, 3.59515809e-02f, -7.17160255e-02f, 5.48806712e-02f, -6.11453690e-02f, 5.10876365e-02f, -3.89364660e-02f,
  1.96921695e-02f, 4.75891009e-02f, 7.30162933e-02f, 5.93816340e-02f, 8.55664089e-02f, -6.50452375e-02f, -2.54486687e-03f, -6.29059970e-02f, 5.07529490e-02f, -3.97302862e-03f,
  -2.21571531e-02f, 5.80443889e-02f, 4.12685685e-02f, 3.58183235e-02f, 1.68236904e-02f, -2.46002711e-02f, -7.68229812e-02f, -3.18444963e-03f, -5.02916910e-02f, 3.78878647e-03f,
  1.98298171e-01f, 6.97760209e-02f, 8.54545012e-02f, 3.58615536e-03f, 1.42484233e-02f, -9.39316526e-02f, 8.17632675e-03f, 3.05594075e-02f, -1.53849944e-02f, 1.55296586e-02f,
  5.63468635e-02f, 1.06166251e-01f, 1.69167016e-02f, -9.84619930e-03f, 2.37318799e-02f, 2.27923226e-02f, -8.00376236e-02f, 8.78452137e-03f, -9.66412202e-03f, -4.71422821e-03f,
  -4.42934409e-02f, 1.75524667e-01f, 1.64042205e-01f, 1.49628118e-01f, -4.78223450e-02f, 1.25449881e-01f, 4.33943644e-02f, 5.65526225e-02f, 2.43477985e-01f, 1.47921741e-01f,
  1.72118306e-01f, 3.56043249e-01f, 9.48093981e-02f, 6.99324980e-02f, -8.33295882e-02f, -1.56219363e-01f, -8.53232443e-02f, -6.23593703e-02f, -9.24454629e-02f, 6.27783909e-02f,
  5.51498421e-02f, -8.89301002e-02f, -6.20137490e-02f, -6.89410642e-02f, -2.28436869e-02f, 4.32281904e-02f, 2.29794681e-02f, -8.61118436e-02f, -2.31852263e-01f, -1.09348491e-01f,
  4.80015576e-02f, 1.30214924e-02f, 4.02495638e-02f, -8.20804108e-03f, 2.85937563e-02f, -1.97035149e-02f, 1.62302479e-01f, 1.73795044e-01f, 1.31229877e-01f, 2.44021937e-01f,
  2.49101698e-01f, 2.46215820e-01f, -1.17981121e-01f, 2.29355530e-03f, 4.76661213e-02f, 5.36835641e-02f, 6.95326403e-02f, 5.36918594e-03f, -5.39813824e-02f, 4.81225587e-02f,
  -2.05570217e-02f, 8.45169723e-02f, -6.74775010e-03f, 1.09220268e-02f, 1.23595484e-02f, -4.17595096e-02f, 7.22894445e-02f, 6.24330603e-02f, -8.58867832e-04f, 1.43046126e-01f,
  6.24788627e-02f, 1.20796375e-01f, 1.86652830e-03f, -2.76221521e-03f, 4.35790280e-03f, -6.15155660e-02f, 5.66842780e-02f, 9.43455547e-02f, -1.55209312e-02f, 1.10908084e-01f,
  7.51687540e-03f, 1.04565024e-02f, -9.48595058e-04f, -7.04828724e-02f, 1.91256795e-02f, 2.23268773e-02f, -4.34670318e-03f, -4.56165820e-02f, 1.68470796e-02f, 6.48911372e-02f,
  3.08766626e-02f, -1.93734784e-02f, 2.58480553e-02f, -7.41729885e-02f, 5.59385978e-02f, -2.47648843e-02f, -5.20450026e-02f, -3.90407001e-03f, 9.24566295e-03f, 5.96202863e-03f,
  4.81986329e-02f, -1.30363218e-02f, -2.82438360e-02f, 2.27060281e-02f, -2.24270821e-02f, -3.35332789e-02f, 4.72758524e-02f, -4.66472469e-03f, -6.22230098e-02f, -7.42683280e-03f,
  -8.35552216e-02f, -1.29705593e-01f, -1.99679527e-02f, 3.02174613e-02f, 2.03490211e-03f, -4.86978032e-02f, 9.24039707e-02f, 7.75143085e-03f, 6.88832346e-03f, -5.62504008e-02f,
  7.66682578e-03f, 1.50230378e-02f, 2.94976775e-02f, -7.37001300e-02f, -1.16172209e-01f, -3.06512304e-02f, -1.52383409e-02f, -2.84123588e-02f, -7.59343728e-02f, 4.67063375e-02f,
  2.75724940e-02f, -8.97776932e-02f, -9.36437398e-02f, -9.14151222e-02f, 1.56660024e-02f, -1.16858147e-01f, -1.40169680e-01f, -1.50837839e-01f, -6.08367994e-02f, -4.31877524e-02f,
  -4.24279660e-01f, -1.92061961e-01f, -1.26618758e-01f, -2.93578267e-01f, -1.53908193e-01f, -4.70974259e-02f, -8.40993375e-02f, 1.30756237e-02f, -1.80370346e-01f, -2.56692469e-01f,
  -3.67335901e-02f, -6.69214129e-02f, -6.99207932e-02f, -3.10622770e-02f, 3.51983979e-02f, -2.10413128e-01f, -1.61878958e-01f, 5.05760871e-02f, 9.65034068e-02f, 5.67992590e-03f,
  2.84452904e-02f, -1.57374352e-01f, -2.60545146e-02f, -3.23220566e-02f, -1.58003718e-01f, -2.73823850e-02f, -3.07529960e-02f, -7.96727184e-03f, 3.24903242e-02f, -2.86511809e-01f,
  -1.41914800e-01f, -1.06509462e-01f, 1.25786766e-01f, 1.83682088e-02f, -1.07439049e-02f, 2.67334376e-02f, -2.46727336e-02f, 1.01729751e-01f, -1.29541047e-02f, -1.15679368e-01f,
  6.10786080e-02f, -6.30311295e-02f, -1.49963924e-03f, -6.21629506e-02f, -3.50997858e-02f, -3.04590240e-02f, 2.23708656e-02f, -2.12076269e-02f, 4.32096981e-02f, -3.28734368e-02f,
  -2.95489840e-02f, -1.14260912e-02f, 7.10156411e-02f, 1.13026395e-01f, 6.68024942e-02f, -4.82663698e-02f, 5.76437153e-02f, 1.18249640e-01f, 1.51459932e-01f, -2.95650233e-02f,
  -2.96593681e-02f, -4.15422069e-03f, -7.45034218e-03f, 8.93030241e-02f, -5.85996285e-02f, 7.28766918e-02f, -2.72861924e-02f, -1.35368621e-02f, 3.24318297e-02f, 2.21213438e-02f,
  9.67441872e-03f, -3.59119545e-03f, -4.37188335e-02f, -1.90120023e-02f, -5.52370921e-02f, 3.03671397e-02f, -5.69847524e-02f, -8.20322242e-03f, 3.17680724e-02f, -3.98881268e-04f,
  -4.97799367e-02f, 6.96613919e-03f, -6.00948036e-02f, 7.43310004e-02f, 3.46229151e-02f, -8.78434032e-02f, 5.33718131e-02f, 8.17679465e-02f, -7.78472945e-02f, -2.79179942e-02f,
  -1.01377562e-01f, 3.07537675e-01f, -1.94334477e-01f, 1.76733192e-02f, 1.77369192e-02f, 2.14990731e-02f, -1.12469837e-01f, 5.35338819e-02f, -2.18838975e-02f, -5.04418686e-02f,
  8.21661130e-02f, -3.43853720e-02f, -4.33677770e-02f, -6.03843015e-03f, -3.71561311e-02f, -4.61112261e-02f, 3.95978205e-02f, -1.86376031e-02f, 7.53991753e-02f, 5.07997125e-02f,
  2.89381784e-03f, -5.49080707e-02f, 2.00574799e-03f, -6.13924973e-02f, 9.93320495e-02f, 4.33739945e-02f, -1.73777603e-02f, -5.33392280e-02f, 9.84549373e-02f, -1.08133115e-01f,
  -3.65509450e-01f, -1.13040451e-02f, -2.13494405e-01f, -1.76298738e-01f, -8.71367604e-02f, -1.49533704e-01f, -3.99524011e-02f, -1.09813549e-01f, -1.43263340e-02f, -4.35667783e-02f,
  5.08423597e-02f, 1.08711235e-01f, 1.36079013e-01f, 1.02411240e-01f, 1.52276039e-01f, 3.39305005e-03f, 3.58099528e-02f, 2.40981709e-02f, 3.32565680e-02f, 9.69994962e-02f,
  1.12300031e-01f, 7.34795034e-02f, 9.93759371e-04f, -8.76919460e-03f, 9.54050384e-03f, 2.32631043e-02f, 2.19390895e-02f, 7.82810338e-03f, 1.20466068e-01f, 3.80850509e-02f,
  -2.08019480e-01f, -1.62642211e-01f, 6.85814172e-02f, 2.50129756e-02f, 3.70543376e-02f, -7.04986230e-02f, -1.06881231e-01f, -3.38991359e-02f, -7.21805841e-02f, -8.51227120e-02f,
  1.48241939e-02f, -7.01045571e-03f, 5.28951995e-02f, 3.22814845e-02f, 4.72945981e-02f, -9.40552875e-02f, 7.74215022e-03f, 5.24583273e-02f, -2.37442739e-02f, -1.70747172e-02f,
  1.23892494e-01f, 6.49269745e-02f, -1.96945071e-01f, -4.62616533e-02f, -5.25841527e-02f, 3.08660921e-02f, -6.16042577e-02f, 1.62642132e-02f, -6.46868125e-02f, -1.66458085e-01f,
  1.78996231e-02f, 9.77632962e-03f, 4.69955839e-02f, -6.23487644e-02f, 5.24223968e-02f, -3.19430381e-02f, -2.25005820e-02f, 6.16974235e-02f, 2.46673599e-02f, -7.99643919e-02f,
  -2.65689902e-02f, 2.31960192e-02f, 2.49120276e-02f, -2.83387173e-02f, 4.32115644e-02f, -1.82323288e-02f, -2.50164513e-03f, 7.40792230e-02f, 5.74504659e-02f, -7.72727877e-02f,
  5.96350543e-02f, -1.50692919e-02f, 2.27924325e-02f, 9.12249684e-02f, 5.74394092e-02f, -7.39182383e-02f, -6.68075727e-03f, -4.06550020e-02f, -5.61646894e-02f, 9.23178275e-04f,
  -9.22610909e-02f, 2.33717531e-01f, -4.04419340e-02f, -2.34857644e-03f, -1.17618717e-01f, 1.82343945e-02f, -9.67344828e-03f, 4.09706533e-02f, -2.43107863e-02f, -3.98543030e-02f,
  3.38909775e-02f, 3.40160877e-02f, 1.10767856e-02f, -3.37122343e-02f, -4.56340648e-02f, -8.71755034e-02f, 2.10335478e-02f, -6.50442243e-02f, 2.24695932e-02f, -5.21627963e-02f,
  2.24380158e-02f, -7.20221177e-02f, -1.83099285e-01f, -1.41894683e-01f, -1.12065397e-01f, 9.56076197e-03f, -1.41923681e-01f, -1.05607532e-01f, -1.22834645e-01f, -1.67406037e-01f,
  6.02170348e-01f, 1.47342145e-01f, 1.79806739e-01f, 2.55569786e-01f, -2.60253578e-01f, -3.00164431e-01f, -1.98208451e-01f, -1.20073736e-01f, 2.90773250e-02f, 9.81679484e-02f,
  -1.53942294e-02f, 1.45137245e-02f, 5.28199784e-02f, 5.53107448e-02f, 7.47749880e-02f, 9.94296744e-02f, 1.02803804e-01f, 1.17481001e-01f, 5.93760610e-03f, -2.57094443e-01f,
  -1.68239370e-01f, 1.43385842e-01f, 1.87365606e-01f, 2.19487175e-02f, 4.96445745e-02f, 3.30541916e-02f, 1.15296096e-01f, 5.48481308e-02f, 3.30697512e-03f, 2.13337243e-01f,
  5.57043813e-02f, 1.20817959e-01f, -4.39784899e-02f, 9.04090181e-02f, -6.65075472e-03f, 6.04414567e-02f, 6.76257536e-02f, 4.89046276e-02f, -5.30254841e-02f, 9.20668468e-02f,
  -2.55537927e-02f, -3.08746211e-02f, 8.04311186e-02f, 2.44077332e-02f, 6.96405917e-02f, -6.38227239e-02f, 8.49812403e-02f, 1.37076542e-01f, 1.02206714e-01f, -1.06701009e-01f,
  -1.45903364e-01f, -9.27840397e-02f, 8.94038305e-02f, -5.58193214e-03f, -2.07980722e-02f, -6.20127842e-02f, 2.51782406e-02f, -9.80427489e-02f, -3.62768024e-02f, 2.23976880e-01f,
  -4.86844666e-02f, -8.00213683e-03f, -5.06925583e-02f, -3.07883648e-03f, 3.17942761e-02f, -1.46888953e-03f, 3.40107419e-02f, -1.79625433e-02f, -2.91805808e-03f, 2.63794954e-03f,
  -3.40731964e-02f, -3.53965722e-02f, 3.03172972e-02f, -4.47446434e-03f, 1.60989389e-02f, 2.44673919e-02f, -5.02616428e-02f, -2.06940304e-02f, -7.33278738e-03f, -1.26293339e-02f,
  2.50481945e-02f, 1.01676583e-02f, -2.71469150e-02f, 4.76124994e-02f, 6.45767003e-02f, 2.16596108e-02f, 6.52250946e-02f, -9.26582888e-02f, 1.35408267e-02f, 3.10473163e-02f,
  2.91248728e-02f, -1.31404027e-01f, 3.97047959e-02f, -9.64107830e-03f, 4.09462899e-02f, -3.93179171e-02f, -6.69570193e-02f, -1.67389605e-02f, 8.05445611e-02f, 2.30922084e-03f,
  -5.18198917e-03f, 1.85425654e-02f, 6.90411180e-02f, -7.37437680e-02f, -1.07645482e-01f, -9.60331336e-02f, 5.47473840e-02f, -9.99297109e-03f, -8.38684011e-03f, -3.10693849e-02f,
  4.98120226e-02f, 4.46172021e-02f, 3.98899391e-02f, -9.37832668e-02f, -1.02866463e-01f, -3.59714143e-02f, -6.31695241e-02f, -1.10394225e-01f, 2.57893745e-02f, 7.22644571e-03f,
  -1.04633719e-01f, 3.33375245e-01f, 9.58609581e-02f, -1.55073136e-01f, -1.25629425e-01f, 5.90763204e-02f, 2.09500223e-01f, 1.49934292e-01f, -2.55940016e-02f, 1.42894819e-01f,
  -6.34690821e-02f, -6.07579798e-02f, -5.32548726e-02f, -5.35699390e-02f, 1.07396550e-01f, 2.14501888e-01f, 2.83530559e-02f, -3.13578099e-02f, -1.93451494e-02f, -6.87043294e-02f,
  4.17125635e-02f, 4.31032293e-02f, 5.56742102e-02f, -4.82843490e-03f, 3.12631093e-02f, -9.45331752e-02f, 8.51943865e-02f, -8.77544135e-02f, 9.45883095e-02f, -1.04506807e-02f,
  8.01560059e-02f, -7.51907080e-02f, -1.10929780e-01f, -9.99395773e-02f, -9.86913219e-02f, -3.20606604e-02f, -4.57416736e-02f, 6.86580166e-02f, 4.70617712e-02f, -2.90948222e-03f,
  -2.04315055e-02f, -4.23332117e-02f, -5.87110072e-02f, 2.38329191e-02f, 8.21600631e-02f, 4.60435748e-02f, 5.84799983e-02f, 1.39030977e-03f, -1.23570987e-03f, 5.45876138e-02f,
  9.96800363e-02f, -3.76514755e-02f, 1.22606054e-01f, -1.50662651e-02f, 1.76671017e-02f, -1.35013536e-01f, 3.35540883e-02f, 2.53440961e-02f, -2.53138356e-02f, 1.71779379e-01f,
  -5.54545671e-02f, 9.70686844e-04f, 9.85758565e-03f, -5.64155355e-02f, 1.26223015e-02f, -3.05724107e-02f, 2.97875181e-02f, 4.51412648e-02f, -2.41601542e-02f, -1.21012041e-02f,
  1.87126622e-02f, -5.65602221e-02f, 5.47952689e-02f, -4.78655379e-03f, 3.31073557e-03f, -8.26768503e-02f, -4.00893316e-02f, 3.80235016e-02f, 2.67246775e-02f, -5.37364446e-02f,
  4.71924804e-02f, 3.04037761e-02f, -3.48183177e-02f, -3.90276909e-02f, 2.58559342e-02f, -4.27736640e-02f, 7.87335411e-02f, 3.20042074e-02f, -1.14193507e-01f, 4.18116190e-02f,
  -1.60316136e-02f, -6.56945556e-02f, -3.25242989e-02f, 1.01100272e-02f, -5.25400378e-02f, 2.28936318e-02f, 5.75159937e-02f, -7.36475587e-02f, 2.09010253e-03f, 1.23376250e-01f,
  -4.89416160e-02f, 2.65776943e-02f, 6.62036315e-02f, -2.33695526e-02f, -4.30918261e-02f, 1.89286172e-02f, 3.45966481e-02f, 5.29339164e-02f, 7.68044591e-02f, 7.91269541e-02f,
  3.62202525e-02f, 4.59382795e-02f, 5.84536456e-02f, 5.49032874e-02f, 5.68016209e-02f, -1.23690944e-02f, 4.42516133e-02f, 8.06256756e-02f, 2.93968860e-02f, 8.26118439e-02f,
  -2.18249604e-01f, -1.05987459e-01f, -1.25427186e-01f, -2.50280499e-01f, -2.50506222e-01f, -2.37667665e-01f, -2.20403343e-01f, -1.61549315e-01f, -1.40306085e-01f, -1.45419687e-01f,
  -5.08946292e-02f, -1.22784443e-01f, -5.00352569e-02f, -1.02383904e-01f, -2.92309392e-02f, -2.06853896e-01f, -1.18556663e-01f, -4.33438942e-02f, -1.15910105e-01f, -2.09534839e-01f,
  -1.17236033e-01f, -1.85290903e-01f, -2.10689381e-02f, -4.47599515e-02f, -1.05624482e-01f, -4.01542112e-02f, 7.51429051e-02f, -2.00391654e-02f, -8.64691138e-02f, -1.41277969e-01f,
  3.94777581e-02f, -2.43325904e-02f, 1.29419928e-02f, -9.75739434e-02f, -9.01127532e-02f, 4.17042673e-02f, -2.04838384e-02f, 1.09329619e-01f, -8.55853967e-03f, -7.27339368e-03f,
  -5.09053692e-02f, -5.80430925e-02f, -3.47706839e-04f, 2.82093566e-02f, -1.27288222e-03f, 2.04469077e-03f, -3.19825485e-02f, -3.99500690e-02f, 8.40984657e-02f, 2.22201850e-02f,
  4.39831382e-03f, -5.47846183e-02f, 2.82916743e-02f, 7.65284300e-02f, 9.71512124e-02f, -1.20873339e-02f, -4.66619013e-03f, 6.27780333e-02f, 1.28993466e-01f, -2.80794147e-02f,
  -6.40122369e-02f, -1.73584446e-02f, -4.51432467e-02f, 3.72466519e-02f, -3.24087441e-02f, 1.96976699e-02f, 6.82607442e-02f, 5.72826192e-02f, -6.52140304e-02f, 2.18250602e-03f,
  -2.74768770e-02f, 1.55270174e-02f, -5.89222312e-02f, -3.60558145e-02f, 2.08184440e-02f, 9.50054638e-03f, 3.13957478e-03f, -3.79632935e-02f, 6.51195049e-02f, 3.28805149e-02f,
  2.25711055e-02f, 7.80676976e-02f, 2.05934774e-02f, 2.26870663e-02f, -6.52318969e-02f, 3.13180350e-02f, -2.06098836e-02f, -6.62052864e-03f, -2.27577798e-02f, -3.08631603e-02f,
  3.84937115e-02f, -1.08326869e-02f, -2.89473757e-02f, 1.48051027e-02f, 3.35459188e-02f, 4.88766208e-02f, -1.72623228e-02f, 7.78601468e-02f, 1.08654052e-01f, -6.32122979e-02f,
  4.81285043e-02f, 2.76340507e-02f, -2.50803623e-02f, -2.26509105e-02f, -2.35810094e-02f, -1.28048994e-02f, 2.43375041e-02f, -9.55618992e-02f, 8.01478103e-02f, 8.23071823e-02f,
  2.88554076e-02f, -5.59586994e-02f, -4.32758443e-02f, -3.79197998e-03f, 4.82813492e-02f, 3.42846960e-02f, 3.72408889e-02f, -1.78057980e-02f, 5.61473966e-02f, -4.51493636e-02f,
  6.74919225e-04f, -1.63438886e-01f, -3.83619994e-01f, 8.20046738e-02f, 7.30875731e-02f, -1.25952866e-02f, 1.44893229e-01f, 5.26643209e-02f, 7.60664418e-02f, 1.25199426e-02f,
  -3.75008211e-02f, 8.92116055e-02f, 8.30992907e-02f, 9.35261548e-02f, -6.43426329e-02f, -1.07253855e-03f, 4.80943993e-02f, -4.26600166e-02f, 1.16055690e-01f, 4.92362753e-02f,
  1.84730545e-01f, 1.33149832e-01f, -5.04050665e-02f, 6.45078532e-03f, 2.12938860e-02f, -1.07674720e-02f, -1.31691530e-01f, 9.73073579e-03f, -3.27625610e-02f, 1.28568336e-02f,
  -1.64238781e-01f, -2.41482005e-01f, 1.09286584e-01f, 7.62796327e-02f, -3.46267931e-02f, 6.38036104e-03f, -4.11856622e-02f, -1.13573141e-01f, 6.32796716e-03f, 5.30074053e-02f,
  -6.49998337e-02f, 3.12387478e-02f, 4.75302748e-02f, 1.09506594e-02f, -5.33166416e-02f, -1.87517446e-03f, 3.43803759e-03f, 9.46300756e-03f, -1.20302446e-01f, -5.92018664e-02f,
  9.47729647e-02f, 1.55969500e-03f, -9.22566205e-02f, 1.20953387e-02f, -1.27163693e-01f, -4.39153751e-03f, -7.80263171e-02f, -7.95913562e-02f, -1.11068971e-01f, 7.49676749e-02f,
  5.08223027e-02f, 2.77373591e-03f, -5.87905088e-05f, 8.42030793e-02f, -1.16023747e-02f, 2.16480121e-02f, -5.87004907e-02f, -2.95736212e-02f, 1.10413786e-02f, 3.46517302e-02f,
  6.05746470e-02f, -1.62176378e-02f, -1.97635870e-02f, 2.54746303e-02f, -8.15871265e-03f, -6.74852952e-02f, 1.55093533e-03f, -9.00857709e-03f, -1.01870582e-01f, -3.82999703e-02f,
  -4.67049107e-02f, 2.78738104e-02f, -6.28424585e-02f, 4.01903801e-02f, 9.88085940e-03f, -8.70035440e-02f, 7.42667243e-02f, 2.65319813e-02f, 4.74484749e-02f, 9.86825675e-04f,
  2.81742454e-01f, -1.17850050e-01f, 7.46893436e-02f, 1.11384377e-01f, -4.38960493e-02f, -2.67055497e-04f, 4.51385742e-03f, 5.32489792e-02f, -2.16864720e-02f, 1.35035086e-02f,
  -2.27664392e-02f, 6.71898350e-02f, -5.20157330e-02f, -2.42217667e-02f, 8.16213712e-02f, 5.72821796e-02f, 7.50668943e-02f, 3.83726433e-02f, 8.11914429e-02f, -4.19229455e-02f,
  1.29413143e-01f, 1.68549672e-01f, 1.91040620e-01f, 1.40393466e-01f, -1.18318037e-03f, 2.10328579e-01f, 1.09570496e-01f, 1.71285257e-01f, 1.39384687e-01f, 3.32050294e-01f,
  4.08542335e-01f, 2.28045478e-01f, 1.52791850e-03f, 6.67889863e-02f, 1.45331630e-02f, 2.16566309e-01f, 3.09368879e-01f, 4.84788045e-02f, 1.35114109e-02f, 1.27399936e-01f,
  1.18512809e-02f, -2.67192781e-01f, -1.95563823e-01f, -1.68520018e-01f, 7.35755786e-02f, 1.51762515e-01f, 7.79592767e-02f, -8.87661800e-02f, -1.04466796e-01f, -2.81252544e-02f,
  -5.42431921e-02f, 2.96445377e-02f, 8.40618759e-02f, 2.60065403e-02f, 2.95018293e-02f, -2.63921134e-02f, -4.32121418e-02f, 1.05971009e-01f, -2.68278886e-02f, -6.67462274e-02f,
  -7.01391846e-02f, 2.87076861e-01f, -1.00613736e-01f, -3.68349999e-02f, 1.61959976e-02f, 1.09429643e-01f, -1.24592083e-02f, 3.35951969e-02f, 7.43543208e-02f, 2.99896710e-02f,
  -2.49298662e-02f, -5.35568036e-03f, -1.39848545e-01f, 3.15927863e-02f, 7.24736527e-02f, 1.77268758e-02f, 9.10189599e-02f, 2.32430291e-03f, 1.41617341e-03f, 3.70192640e-02f,
  -1.17942458e-02f, 1.16524279e-01f, 1.77261442e-01f, -1.56513543e-03f, -1.08222989e-03f, -8.61676037e-03f, -2.63345502e-02f, 8.99651051e-02f, 1.30724117e-01f, 1.70108989e-01f,
  7.32063651e-02f, 2.83800457e-02f, -3.10448720e-03f, -2.75305882e-02f, 7.45282248e-02f, -3.28943208e-02f, -5.91305979e-02f, -4.07955907e-02f, -5.43203065e-03f, 3.14676277e-02f,
  1.08970543e-02f, 2.32380088e-02f, 5.92089863e-03f, 6.59315735e-02f, -9.20916870e-02f, 9.66084525e-02f, 6.39157593e-02f, -2.15970781e-02f, 8.14630166e-02f, 6.80783167e-02f,
  -1.09145978e-04f, -1.80227775e-02f, -4.47746739e-03f, -1.70438960e-02f, -6.97271600e-02f, 1.74705014e-02f, 3.62848453e-02f, -9.00779366e-02f, 4.93200421e-02f, -9.27967578e-03f,
  -1.28104836e-01f, -6.33643568e-02f, 3.19998129e-03f, 7.70706963e-03f, -9.24680755e-03f, -3.77426483e-02f, -5.17568104e-02f, 5.22398837e-02f, -7.97084570e-02f, 1.33617207e-01f,
  8.23428631e-02f, 4.51498888e-02f, 3.08158528e-02f, -2.29619425e-02f, -1.04254726e-02f, 3.77990156e-02f, 1.18176900e-02f, -2.37403121e-02f, -7.28156045e-02f, 3.66333947e-02f,
  -7.05132931e-02f, 1.31910890e-01f, 8.93551856e-02f, 2.57798731e-02f, 6.44546598e-02f, 5.80322056e-04f, 7.66994283e-02f, 1.48467673e-02f, 1.59050658e-01f, 2.67689824e-01f,
  3.58028680e-01f, 8.61320943e-02f, -2.90853530e-01f, 3.25088091e-02f, -2.42533222e-01f, -2.50873148e-01f, -1.39818370e-01f, -5.42811230e-02f, 5.91843314e-02f, -8.27546939e-02f,
  -1.08011745e-01f, -1.27600431e-01f, -3.03100571e-02f, -9.43311527e-02f, 4.44517359e-02f, -8.33072141e-02f, -1.54532418e-01f, -8.89486894e-02f, -1.38871685e-01f, -1.19485959e-01f,
  2.12740973e-02f, -9.30414423e-02f, 7.35767186e-02f, 1.09681077e-01f, -6.77404776e-02f, -1.19456977e-01f, -3.83634567e-02f, -8.11804608e-02f, 5.71239681e-04f, -8.63439590e-02f,
  -1.35067612e-01f, 1.77893400e-01f, -1.01736568e-01f, 8.99044201e-02f, -1.16602413e-01f, 1.15309246e-01f, -1.79105289e-02f, 1.00995280e-01f, 5.82930399e-03f, -3.64284143e-02f,
  -2.83639897e-02f, 5.65274879e-02f, 6.04090057e-02f, -1.83324032e-02f, -2.06887349e-03f, -2.89884787e-02f, 4.02058288e-02f, -2.32588220e-02f, -1.13844387e-01f, -4.30690795e-02f,
  -4.46915813e-02f, -8.59603286e-02f, 5.93985729e-02f, -3.90069857e-02f, -5.60207739e-02f, -6.27580509e-02f, -5.42213842e-02f, -6.41700402e-02f, -6.69903755e-02f, 1.38339415e-01f,
  -1.16724543e-01f, 2.48368317e-03f, -2.06085369e-02f, -4.21366952e-02f, 2.31384337e-02f, 8.57260376e-02f, -2.70100986e-03f, 1.12844624e-01f, 5.70452362e-02f, 9.04814899e-02f,
  1.88590158e-02f, -5.55820167e-02f, 3.13453637e-02f, 4.78220172e-03f, -2.24258704e-03f, 3.66038494e-02f, 6.41379133e-02f, 1.49795623e-03f, -3.63014545e-03f, 1.49482321e-02f,
  -2.88947560e-02f, 2.34440528e-02f, -1.04679372e-02f, -5.02426177e-03f, 6.41196501e-04f, -5.84347993e-02f, -6.63750432e-03f, 5.31599484e-02f, -2.22578715e-03f, 3.48145030e-02f,
  7.15323836e-02f, -1.53260320e-01f, 9.75522995e-02f, 6.93593025e-02f, -5.23807816e-02f, -9.87750682e-05f, -3.32509875e-02f, 3.65182124e-02f, 3.45822722e-02f, 7.77674392e-02f,
  -6.35656863e-02f, 6.66580275e-02f, 5.73376939e-02f, 1.31853325e-02f, -2.89667975e-02f, -2.58021560e-02f, 1.05049238e-02f, -4.06948961e-02f, -5.86913526e-02f, 6.22734502e-02f,
  5.44001386e-02f, 1.24862812e-01f, 8.40047374e-02f, 1.27246648e-01f, 4.96049412e-02f, 7.42176175e-02f, 9.91976112e-02f, 1.64009519e-02f, 4.31788899e-02f, 1.75635815e-01f,
  6.31757230e-02f, -1.47978425e-01f, -1.36506245e-01f, -1.21039733e-01f, -1.18358187e-01f, -1.53534219e-01f, -1.79218546e-01f, -1.35579228e-01f, 6.18198374e-03f, -6.95671812e-02f,
  2.86677796e-02f, 5.11081563e-03f, -2.32221130e-02f, -5.71981147e-02f, -4.53835875e-02f, -1.00351244e-01f, -1.69766948e-01f, -4.17836756e-02f, 3.68488990e-02f, 2.62794606e-02f,
  -3.64392251e-03f, -2.40540821e-02f, 8.08946565e-02f, 6.15810417e-02f, 7.18069524e-02f, -2.54305769e-02f, -5.41463792e-02f, 6.13329485e-02f, 4.24229614e-02f, -1.81681141e-02f,
  1.55564815e-01f, 3.43779586e-02f, 2.69645527e-02f, 2.20880322e-02f, -4.78600413e-02f, 4.84367944e-02f, -8.04414377e-02f, 9.30093303e-02f, 8.84446800e-02f, -1.52670601e-02f,
  1.37783941e-02f, 4.59697321e-02f, -1.76031720e-02f, -3.25258262e-03f, -6.02138676e-02f, -1.32630467e-02f, -6.59062043e-02f, -3.03972345e-02f, 4.90583815e-02f, -1.49623426e-02f,
  -2.53571421e-02f, 6.49015158e-02f, 1.41615672e-02f, 7.76493084e-03f, -9.13210064e-02f, 5.68077154e-03f, -5.52318059e-02f, 5.76815642e-02f, 3.44150290e-02f, -4.35742773e-02f,
  3.58393155e-02f, 1.96708329e-02f, 4.67623658e-02f, -6.08664453e-02f, 1.78692061e-02f, -4.11865376e-02f, -1.06730849e-01f, 7.18235178e-03f, -5.67457080e-02f, 4.52735722e-02f,
  -6.55333772e-02f, -1.60445869e-02f, -8.86478052e-02f, 4.74846475e-02f, 4.98427562e-02f, -9.63626988e-03f, -1.11978855e-02f, 2.53507141e-02f, 1.37449000e-02f, 4.12070267e-02f,
  6.28679320e-02f, -5.90768680e-02f, 2.26642024e-02f, -7.26879537e-02f, -4.73528504e-02f, -1.68178324e-02f, 1.38444416e-02f, 5.37232459e-02f, 6.20637462e-02f, 1.38886170e-02f,
  9.51571465e-02f, -6.88376799e-02f, -6.66255057e-02f, 7.72366673e-02f, -1.59889236e-02f, 4.58732657e-02f, -4.67187725e-02f, -5.29354773e-02f, 3.66724096e-02f, 3.40712592e-02f,
  -3.11506679e-03f, -9.29740593e-02f, -1.51005657e-02f, 3.99398915e-02f, 8.96695033e-02f, 9.01054814e-02f, -4.98032309e-02f, 3.39182094e-02f, 1.55027788e-02f, 7.10979179e-02f,
  -8.58896151e-02f, -3.43580395e-02f, 6.88236281e-02f, 4.41749990e-02f, -7.98972398e-02f, 8.22038576e-02f, 2.91637741e-02f, -8.13195575e-03f, -6.83930814e-02f, 1.41876917e-02f,
  4.33898091e-01f, -2.67033309e-01f, -3.45236659e-01f, 9.86093432e-02f, -1.54272199e-01f, -1.22647107e-01f, -2.37572744e-01f, -3.50020230e-02f, 1.59540698e-01f, -1.88008428e-01f,
  -1.14789836e-01f, -2.52723582e-02f, -2.90904399e-02f, -7.78243765e-02f, 6.16895631e-02f, -1.80572048e-01f, -6.82660639e-02f, 6.27770722e-02f, 1.95064709e-01f, 1.07440591e-01f,
  1.04753397e-01f, 1.57907516e-01f, 2.56735623e-01f, 1.35423571e-01f, -5.07128052e-02f, -4.89185983e-03f, -1.54061809e-01f, -6.15479946e-02f, -1.04550309e-01f, -1.68967530e-01f,
  -2.68539846e-01f, -9.15633142e-02f, 5.53477556e-02f, 1.08205490e-02f, -5.25152646e-02f, 1.06320783e-01f, 2.91280597e-02f, 5.83664887e-02f, 2.95952577e-02f, -2.97428202e-02f,
  -2.98518613e-02f, 9.30028334e-02f, -2.81783529e-02f, -4.07985970e-02f, -3.69450115e-02f, -1.18038850e-02f, 1.07290111e-01f, 6.67125955e-02f, 5.18156961e-02f, -5.53644896e-02f,
  -1.67319745e-01f, -9.80984769e-04f, 3.15245939e-03f, -1.01388944e-02f, -7.04265013e-02f, -3.67157124e-02f, -1.63665354e-01f, -2.48986986e-02f, -2.16536853e-03f, -1.76569764e-02f,
  1.14736091e-02f, -3.74552235e-02f, -2.28553601e-02f, 6.56069666e-02f, 6.93573877e-02f, -8.73247385e-02f, -6.36557164e-03f, -3.98385413e-02f, 6.80145100e-02f, 2.73159635e-03f,
  6.08687028e-02f, 1.35049000e-02f, -7.06163868e-02f, 4.38572764e-02f, -5.44235967e-02f, 2.69904193e-02f, -7.89276585e-02f, -2.00499296e-02f, -1.53300192e-04f, 5.84442019e-02f,
  9.10064206e-02f, 9.15411673e-03f, -5.04541211e-02f, -1.21081462e-02f, -9.59070623e-02f, 2.10779738e-02f, 2.07491759e-02f, 6.93006590e-02f, 3.26635665e-03f, -1.94156710e-02f,
  8.15697461e-02f, -6.03753515e-02f, -7.74230212e-02f, 7.42279217e-02f, -3.44329067e-02f, 1.18559022e-02f, -9.93023664e-02f, 6.76499456e-02f, -5.71292527e-02f, -1.24741290e-02f,
  -5.84446564e-02f, -3.20890197e-03f, -6.26034960e-02f, -4.50547524e-02f, 1.24607362e-01f, -4.72547486e-03f, 1.09618308e-03f, -1.87366121e-02f, -4.07210253e-02f, 7.58037297e-03f,
  6.42850921e-02f, 4.55011241e-03f, 1.29879087e-01f, -7.07102120e-02f, 3.98667492e-02f, 7.05681592e-02f, -7.54775573e-03f, -4.51227836e-02f, 6.07608259e-02f, 5.32502756e-02f,
  1.82236418e-01f, -1.38356909e-01f, -2.64563173e-01f, 4.36404273e-02f, -1.46733165e-01f, -1.22810304e-01f, -1.57857046e-01f, 3.86163630e-02f, -1.79185513e-02f, -4.68201190e-02f,
  -1.02344722e-01f, 1.79258317e-01f, 6.83664829e-02f, 1.46429494e-01f, -9.60083865e-03f, -1.26813650e-01f, -1.42227307e-01f, -3.01088989e-02f, 1.21392436e-01f, 7.28116408e-02f,
  1.25954986e-01f, -8.63003172e-03f, 5.81632517e-02f, 1.12755656e-01f, 7.94937834e-02f, 9.83628794e-04f, -8.30628127e-02f, -8.91574547e-02f, 7.14556780e-03f, 8.56753588e-02f,
  4.76374440e-02f, -4.77401055e-02f, 2.52167657e-02f, 8.54982808e-02f, 3.57725993e-02f, 9.30638239e-02f, 7.71586178e-03f, 1.87349562e-02f, -6.77765012e-02f, -5.10294177e-02f,
  6.20525740e-02f, -2.85807978e-02f, 7.47394860e-02f, 5.20035159e-03f, 7.72709772e-02f, 8.50805342e-02f, 2.42825709e-02f, 1.15365967e-01f, -3.60451527e-02f, -5.02507240e-02f,
  7.06375465e-02f, -1.39636889e-01f, -3.71267386e-02f, -2.25289329e-03f, 7.22874925e-02f, -1.04419990e-02f, 1.41445271e-04f, 5.65033630e-02f, -2.05988958e-02f, -4.22089286e-02f,
  7.20281675e-02f, 3.90502028e-02f, -7.38599077e-02f, 3.33594941e-02f, -1.07900044e-02f, -1.93810519e-02f, 4.98702899e-02f, -5.29892836e-03f, -4.95873950e-02f, 4.78047058e-02f,
  -5.87781221e-02f, -1.41493743e-02f, -3.13468790e-03f, -1.29304426e-02f, 4.28972160e-03f, -8.57300013e-02f, 6.43670782e-02f, -8.63826424e-02f, 3.52379046e-02f, 4.70615961e-02f,
  2.76313573e-02f, 2.05093753e-02f, 2.52690166e-02f, 1.80129576e-02f, 5.13092242e-02f, 6.02530665e-04f, 8.62340033e-02f, 6.07166216e-02f, 3.41230817e-02f, -1.36771309e-03f,
  6.38445765e-02f, -1.76644370e-01f, 2.82438360e-02f, 1.10580608e-01f, 3.91178206e-02f, -4.12318390e-03f, -2.12055398e-03f, -7.16879517e-02f, 4.73808423e-02f, 2.00154935e-03f,
  1.62504166e-02f, -3.69615518e-02f, 1.84384901e-02f, -3.55166122e-02f, 1.42691620e-02f, 1.46648064e-02f, -7.06399828e-02f, 7.30551630e-02f, -3.11140046e-02f, 4.87398580e-02f,
  -2.82916352e-02f, -7.46238232e-02f, -1.48355365e-02f, -4.83927084e-03f, 2.95989309e-02f, -3.40616144e-02f, -4.07795422e-02f, -6.24508187e-02f, 3.54648083e-02f, 9.56765842e-03f,
  4.83168721e-01f, 2.43924737e-01f, -3.19665581e-01f, 2.21282393e-01f, 2.22203638e-02f, -2.29665533e-01f, -3.87880467e-02f, 9.77367721e-03f, 1.07539967e-01f, 2.91153323e-02f,
  -5.11738025e-02f, 1.24267496e-01f, 3.83197865e-03f, -7.74629563e-02f, -5.77820949e-02f, -4.40659486e-02f, -9.39378962e-02f, -1.51076093e-01f, -1.85985163e-01f, 8.02980438e-02f,
  9.70883369e-02f, 2.14725345e-01f, 1.79342732e-01f, 1.30865768e-01f, 1.62895411e-01f, 9.77104753e-02f, -5.81313390e-03f, 6.49516881e-02f, -5.90459816e-02f, 2.16720775e-01f,
  -1.27620041e-01f, 8.38777423e-02f, -4.28035893e-02f, 1.09063610e-01f, -2.22515203e-02f, -2.68420368e-03f, -5.47141507e-02f, 7.77221844e-02f, 1.72019396e-02f, 1.70297492e-02f,
  8.26411322e-02f, 5.75758405e-02f, 1.61705129e-02f, 1.78644285e-02f, 3.06362547e-02f, 1.05870878e-02f, 9.97095369e-03f, 3.43332253e-03f, 1.50334416e-02f, -1.23160772e-01f,
  8.06714222e-02f, -3.53471050e-03f, -6.92053661e-02f, -5.67959063e-02f, -1.68866947e-01f, 4.90742922e-03f, -1.04977980e-01f, -1.15448255e-02f, -1.96594134e-01f, 1.56464294e-01f,
  -1.35798380e-02f, -6.35187998e-02f, 4.35903408e-02f, 5.85520193e-02f, -8.39415193e-03f, -3.19876485e-02f, 4.95545715e-02f, 3.95716317e-02f, -1.71650052e-02f, 6.72619790e-03f,
  -6.54513435e-03f, -6.34257197e-02f, 2.12752018e-02f, 5.70404045e-02f, 2.26317905e-03f, 4.06330675e-02f, -1.42407622e-02f, 5.16507551e-02f, -2.38666665e-02f, -4.63443175e-02f,
  1.06829843e-02f, 4.58756834e-03f, 4.76200581e-02f, 7.71409785e-03f, -1.96286011e-02f, -7.68671110e-02f, 1.73638966e-02f, -1.91243161e-02f, -8.12155306e-02f, -8.61713476e-03f,
  1.06168844e-01f, -1.94621593e-01f, 2.44960506e-02f, 9.81385037e-02f, 3.87563184e-02f, 2.23124260e-03f, -3.19026038e-02f, -3.29961106e-02f, 2.27390490e-02f, -5.55019565e-02f,
  1.40878987e-02f, -7.13605508e-02f, -2.35981867e-02f, 3.86954695e-02f, -3.97746153e-02f, 2.93115918e-02f, 3.86105627e-02f, -1.95378345e-02f, -3.09229121e-02f, 6.36868877e-03f,
  -4.45294529e-02f, 2.49642394e-02f, 5.80505729e-02f, 2.63871043e-03f, -1.79231707e-02f, -6.32330328e-02f, -5.45442440e-02f, -1.97139792e-02f, -2.63420865e-02f, 1.30496725e-01f,
  -1.07350700e-01f, -3.07664961e-01f, -1.88297600e-01f, 1.26215279e-01f, 6.05776161e-02f, -1.91830307e-01f, -2.96992481e-01f, -7.40658790e-02f, 7.09883869e-02f, -4.65880483e-02f,
  8.37519839e-02f, 1.56123534e-01f, 1.15978248e-01f, 6.14008568e-02f, 1.08159930e-02f, -2.20541015e-01f, -9.67696235e-02f, 4.61408645e-02f, 5.83634675e-02f, 8.29206482e-02f,
  4.28583249e-02f, 4.15042080e-02f, -3.24132740e-02f, 2.39782548e-03f, 4.38482799e-02f, 1.20747410e-01f, 1.14316703e-03f, 6.44961819e-02f, -1.29994571e-01f, -1.55518288e-02f,
  -1.09526329e-01f, 7.49461278e-02f, 1.02960579e-01f, 1.68877795e-01f, -5.44602470e-03f, 2.80596106e-03f, 1.06494164e-03f, 2.52364650e-02f, 7.33568072e-02f, -1.35080758e-02f,
  3.29838283e-02f, 8.16545635e-02f, -1.95441507e-02f, 7.80972093e-02f, -7.44603798e-02f, -1.71725173e-02f, -4.42788787e-02f, 3.52256559e-02f, 5.02497852e-02f, -1.12988381e-02f,
  3.42933871e-02f, 6.15064651e-02f, 2.60827038e-02f, 2.91376039e-02f, 7.09630847e-02f, 6.27935752e-02f, -4.35977839e-02f, -8.00091028e-02f, 1.50699988e-02f, -1.04019366e-01f,
  1.84987541e-02f, -2.01615710e-02f, 1.15484074e-01f, 6.61411509e-02f, -2.00410094e-02f, 8.49088803e-02f, -5.56778759e-02f, 1.08815962e-02f, 6.55984804e-02f, -6.41634315e-02f,
  -3.05417795e-02f, 1.30230077e-02f, 5.98187819e-02f, -8.05981085e-02f, -2.75361929e-02f, 2.25705821e-02f, -6.56259656e-02f, 6.01660367e-03f, -3.47382552e-03f, 3.60521823e-02f,
  4.55400310e-02f, 3.90961766e-02f, 5.93387783e-02f, 5.45744970e-02f, 3.07495743e-02f, -7.86041543e-02f, 3.23672034e-02f, -6.16853079e-03f, -5.71610481e-02f, -1.00275777e-01f,
  -6.33032247e-02f, 3.87483798e-02f, -1.09824345e-01f, 3.83867137e-02f, 2.76542138e-02f, 7.85431787e-02f, 2.53837742e-02f, 3.80026661e-02f, -5.16654365e-03f, -8.88966862e-03f,
  4.46528196e-02f, 5.95205501e-02f, -7.42773013e-03f, -6.13765940e-02f, -1.09175744e-03f, -1.57668125e-02f, -5.27197309e-03f, 3.95670608e-02f, 6.55083880e-02f, -7.63820112e-02f,
  -1.73316933e-02f, -7.04445317e-02f, -1.23407938e-01f, 1.63380448e-02f, 2.93953363e-02f, 7.07234442e-02f, -1.38399392e-01f, -1.03563219e-01f, -1.01730293e-02f, -2.56573588e-01f,
  -1.08234935e-01f, -3.91685478e-02f, -2.39142086e-02f, -3.89430560e-02f, 2.39938736e-01f, 3.12166929e-01f, 3.28765720e-01f, 2.34065354e-02f, 5.02172187e-02f, 3.23272943e-02f,
  7.99640641e-03f, -3.69418189e-02f, -1.36307180e-01f, -1.23833202e-01f, 7.93758035e-02f, 3.63998264e-02f, 2.53841300e-02f, 3.19276340e-02f, 3.99760976e-02f, 1.23878554e-01f,
  2.59497631e-02f, -9.92172956e-03f, -7.85024390e-02f, -1.31753832e-01f, 2.10206341e-02f, 5.93543984e-02f, -1.16125673e-01f, -5.65279499e-02f, -3.17909643e-02f, 7.66957412e-03f,
  -1.26912162e-01f, -1.90157980e-01f, 5.40021770e-02f, 3.26005928e-02f, -1.16148017e-01f, -3.44471671e-02f, 7.31166229e-02f, -3.38484868e-02f, -9.47560146e-02f, -4.08737697e-02f,
  -1.00738462e-03f, 3.66365747e-03f, -4.64016162e-02f, 7.44472840e-04f, 1.57419723e-02f, 1.83224827e-02f, -4.79785055e-02f, -2.03616306e-01f, -1.81499571e-02f, -8.88743028e-02f,
  2.72847041e-02f, -3.16303186e-02f, 8.38216692e-02f, 1.25222839e-03f, -1.14728272e-01f, -5.51845767e-02f, -1.32976603e-02f, -1.28943725e-02f, -7.54744038e-02f, -1.41300008e-01f,
  5.51906601e-02f, 3.32282186e-02f, -5.80010144e-03f, -2.51594428e-02f, -2.74950955e-02f, 4.74605449e-02f, 4.81747603e-03f, 4.56528962e-02f, 6.03358299e-02f, -3.63096769e-04f,
  -1.94271677e-03f, 9.95028298e-03f, -1.70059204e-02f, 5.51951863e-02f, -7.89072812e-02f, 4.93260808e-02f, -3.44596826e-03f, -4.76129986e-02f, 1.74507196e-03f, -2.98441146e-02f,
  -3.64756063e-02f, 1.82328708e-02f, -4.05895934e-02f, -3.14430408e-02f, -1.01306373e-02f, -4.93101440e-02f, 8.97346810e-02f, -6.56188726e-02f, 4.85363714e-02f, -2.92735733e-03f,
  -5.30573865e-03f, 1.31640434e-01f, -1.70310382e-02f, -6.62173182e-02f, 4.58507973e-04f, -5.59264161e-02f, 1.78150255e-02f, -1.14483759e-02f, -4.21629623e-02f, 4.94353175e-02f,
  3.36547457e-02f, -5.72699532e-02f, -3.94932702e-02f, 2.23354492e-02f, 1.06333300e-01f, -4.27809125e-03f, 1.23350762e-01f, 4.88629006e-02f, 5.78784160e-02f, 8.61917902e-03f,
  7.74230808e-02f, 1.81016982e-01f, 1.98676571e-01f, 9.56196859e-02f, -2.74498444e-02f, 1.70458123e-01f, 7.26568028e-02f, 8.38551447e-02f, 6.70550540e-02f, 1.95556611e-01f,
  1.60111904e-01f, 7.94759765e-02f, -5.37797883e-02f, 2.59476632e-01f, 4.93024178e-02f, 2.30076425e-02f, 3.28314863e-02f, 5.75967096e-02f, 1.53428197e-01f, 1.13318905e-01f,
  -1.47496969e-01f, -7.08412305e-02f, -5.13754487e-02f, -1.86500132e-01f, -5.61826006e-02f, 1.58238858e-02f, 7.81790018e-02f, -4.32355665e-02f, -9.45359245e-02f, 5.79694249e-02f,
  5.93865886e-02f, 4.74780425e-02f, -5.10358103e-02f, 1.07035935e-01f, 1.10183828e-01f, -5.92929497e-02f, 1.49302945e-01f, 1.11496598e-01f, 3.38538922e-03f, 1.10542260e-01f,
  -8.63719434e-02f, 1.66218926e-03f, -6.64541349e-02f, 1.94705315e-02f, -3.37462843e-04f, 2.18855012e-02f, 1.99362524e-02f, 4.75385338e-02f, -6.53395578e-02f, 3.11352182e-02f,
  -1.05746835e-01f, -5.29052541e-02f, -6.47083372e-02f, 4.57634516e-02f, 1.24411985e-01f, 6.29382432e-02f, 7.21025020e-02f, -1.41079361e-02f, -6.68927468e-03f, 3.47353704e-02f,
  2.15335385e-05f, -2.25933623e-02f, -6.07901551e-02f, 2.21428610e-02f, -7.84584656e-02f, -9.89547744e-02f, 3.40967774e-02f, 2.20909081e-02f, -2.53074914e-02f, 2.26179615e-01f,
  -6.38834434e-03f, 2.07117926e-02f, -2.35970169e-02f, 1.52320368e-02f, 5.57082035e-02f, -1.29745919e-02f, -8.81424248e-02f, 6.22716285e-02f, -7.64693767e-02f, 9.09328237e-02f,
  -7.27056786e-02f, 4.22578938e-02f, -2.32614037e-02f, 1.43864658e-02f, 4.21170052e-03f, -4.47648158e-03f, -9.61899478e-03f, 1.46674700e-02f, -5.73600382e-02f, -6.49862885e-02f,
  -7.34761581e-02f, 1.94880161e-02f, 3.44549902e-02f, -2.65786201e-02f, 3.63591649e-02f, 4.15900489e-03f, 2.70406175e-02f, -3.11683547e-02f, 2.17526220e-02f, 5.14912046e-02f,
  7.30293095e-02f, -2.63723224e-01f, 7.85051733e-02f, 1.85442064e-02f, 1.54268900e-02f, 7.00939372e-02f, -3.50364111e-02f, -5.54612130e-02f, 2.35850029e-02f, 1.95419900e-02f,
  -7.90282041e-02f, 3.73973846e-02f, 8.37078225e-03f, -5.96407801e-02f, 1.87658686e-02f, -2.20354809e-03f, 1.08645685e-01f, -4.10627499e-02f, -4.00379710e-02f, 4.37964499e-02f,
  1.21264987e-01f, 1.20209634e-01f, 2.53153145e-02f, -2.42742393e-02f, 2.02086624e-02f, 2.78559551e-02f, 4.65889741e-03f, -1.78102506e-04f, -1.06157072e-01f, 1.18595399e-01f,
  -2.23627508e-01f, -5.08243963e-02f, 1.66430667e-01f, 1.88082398e-03f, -9.08923298e-02f, -1.48587927e-01f, -2.38325402e-01f, -2.14519471e-01f, -1.70800954e-01f, -6.81921886e-03f,
  -8.78987759e-02f, 3.02871913e-02f, 1.25470012e-01f, 1.39149159e-01f, 4.07446325e-02f, 5.01445727e-03f, 1.60005838e-01f, 1.18669949e-01f, 1.65732086e-01f, 3.10143293e-03f,
  5.10856844e-02f, 1.61508285e-02f, 1.62042126e-01f, 1.18500307e-01f, 1.95338437e-03f, 1.78446546e-01f, 1.23790570e-01f, 9.82638523e-02f, 1.09445779e-02f, 2.03852698e-01f,
  4.37600166e-02f, -2.20856279e-01f, 6.21568561e-02f, 8.40899572e-02f, 4.99783158e-02f, 5.81902564e-02f, 4.82974127e-02f, -7.01794475e-02f, 2.09394190e-02f, -2.50401869e-02f,
  9.20946971e-02f, -6.37133494e-02f, -5.92746597e-04f, 1.21944081e-02f, -2.71718856e-02f, -7.65812770e-02f, -2.73150932e-02f, -5.04595563e-02f, -3.30019221e-02f, -9.56627354e-02f,
  4.31267880e-02f, -1.01801753e-01f, -6.09501787e-02f, 3.01880669e-02f, -4.97117266e-02f, 8.09031725e-02f, -1.02705114e-01f, -4.96773683e-02f, 9.58725810e-03f, 1.95220634e-02f,
  -6.74739014e-04f, -5.38309999e-02f, 4.95949611e-02f, -4.81478907e-02f, -1.39834732e-02f, -3.02489195e-02f, -2.31989473e-02f, 5.18378057e-02f, 2.29015648e-02f, 6.95777163e-02f,
  -3.84423733e-02f, -6.08072691e-02f, -1.10489724e-03f, 1.38013670e-02f, 9.42734852e-02f, -1.40270144e-02f, 5.93415946e-02f, -4.25304584e-02f, 9.08769593e-02f, -5.75490743e-02f,
  3.27901617e-02f, 1.46987457e-02f, 5.58883473e-02f, 2.55283751e-02f, -5.61233908e-02f, 5.46750948e-02f, -2.20380630e-02f, -5.68393394e-02f, -2.78028734e-02f, -3.72207128e-02f,
  7.51627609e-02f, -1.41008776e-02f, 1.08048104e-01f, 2.62568183e-02f, -6.22486789e-03f, -5.77300899e-02f, 2.93359999e-02f, 9.55318883e-02f, 3.79799143e-03f, 7.65230134e-02f,
  -7.85025880e-02f, 9.00699571e-02f, 6.58903643e-02f, -2.26892028e-02f, 6.70411512e-02f, 4.49673720e-02f, 4.17572334e-02f, -8.80250614e-03f, 2.76971199e-02f, -3.51661444e-02f,
  -4.40859981e-02f, -3.57231833e-02f, -6.79503307e-02f, -1.56699009e-02f, -1.00697331e-01f, 6.24048803e-03f, 5.60483076e-02f, -6.81056678e-02f, -6.34591728e-02f, -4.31550071e-02f,
  -1.09703571e-01f, 1.78790227e-01f, 3.35097462e-01f, -5.37900515e-02f, 5.44380806e-02f, 3.20858151e-01f, 4.27177608e-01f, 1.76998302e-01f, -1.06275231e-01f, 7.36304671e-02f,
  -1.12691000e-01f, -2.37235516e-01f, -1.08950116e-01f, 7.84798618e-03f, 2.01274857e-01f, 2.20220610e-01f, 2.03450680e-01f, -3.20448168e-02f, 4.02642712e-02f, 6.81277737e-02f,
  -8.25309455e-02f, -7.25127831e-02f, -1.78050831e-01f, 2.27063820e-02f, -1.74541786e-01f, -1.10774435e-01f, 8.11339095e-02f, -4.49193753e-02f, -4.29205336e-02f, -8.30289796e-02f,
  -9.64764431e-02f, 6.51773065e-02f, 3.66516374e-02f, -1.66671753e-01f, -5.83432941e-03f, -5.75819388e-02f, 4.61604409e-02f, -8.90221223e-02f, -5.73124401e-02f, -1.87355448e-02f,
  -7.55188093e-02f, -2.59960536e-02f, -5.11842184e-02f, 7.89009873e-03f, -5.57575561e-02f, 6.05158741e-03f, -8.83463845e-02f, -3.59777436e-02f, -1.64063480e-02f, 8.41612592e-02f,
  -7.16589838e-02f, -4.57533970e-02f, 1.36624694e-01f, 5.25039211e-02f, 1.59456413e-02f, -1.29115134e-01f, -1.38583053e-02f, 1.38722938e-02f, 1.22851424e-01f, -2.80114710e-02f,
  3.52907963e-02f, -2.81945616e-02f, 2.40617748e-02f, 6.63022418e-03f, -9.14149079e-03f, -6.39796183e-02f, 5.05865887e-02f, 5.49077578e-02f, -2.77682859e-02f, -3.33208181e-02f,
  1.46254003e-02f, 1.92166097e-03f, 5.45671321e-02f, -2.30785497e-02f, -3.99605185e-02f, 2.93772537e-02f, 4.60459217e-02f, 5.81033295e-03f, -7.52501860e-02f, 1.45048322e-02f,
  -6.74108416e-02f, 2.60838401e-02f, 2.91720107e-02f, -6.18662722e-02f, 2.40779482e-02f, -2.11808942e-02f, -6.78457096e-02f, 3.06557529e-02f, -4.86920439e-02f, -2.15222798e-02f,
  -1.59887418e-01f, 1.10296622e-01f, -7.97629282e-02f, -3.22030298e-02f, -8.02659392e-02f, 1.33003891e-02f, -1.48278475e-02f, -7.74562359e-02f, -5.81599548e-02f, 3.78894294e-03f,
  -3.39927711e-02f, -4.07033451e-02f, 2.72478256e-02f, -4.41907905e-03f, -3.54997665e-02f, -2.10378170e-02f, 4.14258242e-02f, 6.63104327e-03f, -4.41440009e-02f, 5.10599129e-02f,
  6.10372424e-02f, 1.37248755e-01f, -7.65845925e-02f, 1.34298250e-01f, -1.20655484e-02f, 2.96927504e-02f, -8.52188282e-03f, 3.70242596e-02f, 8.23123828e-02f, 1.54243723e-01f,
  -9.20267254e-02f, -9.72433388e-02f, -1.54833227e-01f, -1.23309813e-01f, 5.45049571e-02f, 1.02789715e-01f, 1.56732053e-02f, 4.01964523e-02f, -4.71074544e-02f, 8.56252164e-02f,
  1.58935428e-01f, 8.34494829e-02f, 7.41671072e-03f, -1.45863909e-02f, -1.51076451e-01f, -1.15404516e-01f, -2.08929807e-01f, -2.09938511e-01f, -1.02837935e-01f, 2.01028645e-01f,
  1.77169949e-01f, -1.27040371e-01f, -1.27767459e-01f, -1.46269113e-01f, 2.67130579e-03f, 9.18626487e-02f, -3.99252251e-02f, -7.63649717e-02f, 5.29476963e-02f, -8.14010575e-02f,
  3.19325775e-01f, -1.54896885e-01f, 4.88780774e-02f, 1.27308825e-02f, 6.58227354e-02f, 1.49394805e-02f, 7.88076520e-02f, -1.04140222e-01f, -7.18657374e-02f, -1.58645883e-02f,
  2.80998088e-02f, 2.21961811e-02f, 3.01872357e-03f, -5.14454432e-02f, -4.61202450e-02f, 5.14009856e-02f, -1.66197598e-01f, -2.55523086e-01f, -1.25033081e-01f, 5.31303585e-02f,
  5.19479578e-03f, 1.00616485e-01f, -1.03719473e-01f, 1.04197552e-02f, -1.33742355e-02f, -6.97684586e-02f, 1.16338721e-02f, -5.14661558e-02f, -1.27312720e-01f, 4.34693322e-02f,
  9.17753130e-02f, -1.89490784e-02f, -1.54162729e-02f, 4.49416861e-02f, 2.05872860e-02f, 5.65522537e-02f, 4.67265584e-02f, -7.28449610e-04f, 4.49249893e-02f, -9.56353843e-02f,
  1.98145136e-02f, -2.35986809e-04f, 2.92252731e-02f, -5.55142462e-02f, -5.85532049e-03f, -1.62704829e-02f, 8.35768320e-03f, -3.53553146e-02f, -5.44120409e-02f, -4.92169224e-02f,
  5.14622256e-02f, -1.71225076e-03f, -6.74407855e-02f, -4.93977331e-02f, 1.36301601e-02f, 2.31453981e-02f, 1.17498906e-02f, -4.97211255e-02f, 6.51003644e-02f, 1.57057606e-02f,
  1.09124213e-01f, -1.12815246e-01f, 1.23135641e-01f, -1.96226928e-02f, -7.27052167e-02f, -1.78365596e-02f, 9.32476372e-02f, -7.04026595e-02f, 8.05824995e-02f, 1.41963772e-02f,
  -5.12305312e-02f, -9.92391557e-02f, 7.09011173e-03f, 4.64619808e-02f, 7.09375292e-02f, -1.31575074e-02f, 2.89373752e-02f, -2.75047328e-02f, 3.27515304e-02f, 9.56439748e-02f,
  -1.29074492e-02f, 8.61506239e-02f, 5.47939725e-02f, 8.31875764e-03f, 3.63228843e-02f, 1.38788819e-01f, 5.01566194e-02f, 7.55433813e-02f, 1.08156011e-01f, -1.36757158e-02f,
  5.20614050e-02f, 1.96395397e-01f, -2.31593862e-01f, 8.85311142e-02f, -1.34583443e-01f, -1.37151122e-01f, -2.32058331e-01f, 4.28215973e-02f, 9.16845649e-02f, 2.24497654e-02f,
  1.23775430e-01f, -6.62103435e-03f, 1.01815134e-01f, -5.27978167e-02f, -1.37751848e-01f, -1.46105990e-01f, -2.25873128e-01f, -1.98351547e-01f, -2.06613496e-01f, 4.24891943e-03f,
  -3.05928718e-02f, 4.41775396e-02f, 4.52625528e-02f, -3.88736017e-02f, 7.06250966e-02f, 6.28796890e-02f, -5.35805076e-02f, 7.37016127e-02f, -9.11018923e-02f, 1.09546222e-01f,
  3.88431773e-02f, 1.78281948e-01f, -4.90573980e-02f, 4.12649661e-02f, -4.65311222e-02f, -4.73129302e-02f, 1.25478115e-02f, 3.44512373e-04f, 3.21978750e-03f, -6.72933161e-02f,
  -7.37654641e-02f, -1.38518680e-02f, -1.56901795e-02f, -5.26698269e-02f, 3.43559161e-02f, -3.48952934e-02f, 2.64006779e-02f, 1.29678631e-02f, -3.11701093e-02f, -2.91726869e-02f,
  -7.92267695e-02f, -9.10138413e-02f, -7.41920546e-02f, -9.38846096e-02f, -7.07492009e-02f, -3.53693888e-02f, 1.86806861e-02f, -7.28051644e-04f, 1.34345633e-03f, 2.12261423e-01f,
  -1.29227173e-02f, 2.72331815e-02f, -9.23571885e-02f, 7.92311281e-02f, 2.13777996e-03f, -5.39334007e-02f, 1.27776607e-03f, -6.77919611e-02f, 7.56889582e-04f, 4.74732555e-02f,
  -3.75895053e-02f, -6.47509620e-02f, 4.57979850e-02f, 2.13604104e-02f, 4.06251661e-02f, 1.89968832e-02f, -4.16322351e-02f, 8.94205049e-02f, -7.90364891e-02f, 1.31467180e-02f,
  1.47317527e-02f, -1.28557384e-01f, 5.66979870e-02f, -1.98730305e-02f, -1.01687655e-01f, -3.90164033e-02f, -7.68606514e-02f, -3.60330902e-02f, 8.25332776e-02f, 1.32689197e-02f,
  2.45936587e-01f, -1.29651994e-01f, 4.34467159e-02f, -6.37488253e-03f, -7.93614015e-02f, -6.87924623e-02f, 5.62862400e-03f, 7.25052580e-02f, -2.59743612e-02f, 5.75824864e-02f,
  -6.59922510e-02f, 3.65234613e-02f, 3.16162681e-04f, -3.81498449e-02f, -1.05810322e-01f, -5.69718778e-02f, -6.58195466e-02f, -1.01929046e-01f, -8.93013030e-02f, 7.87410662e-02f,
  -6.03379980e-02f, -1.33109465e-01f, -1.18873306e-01f, -5.80059141e-02f, 4.74248789e-02f, -5.91193475e-02f, 9.12888534e-03f, 8.06168653e-03f, -4.27224599e-02f, 8.85917991e-02f,
  -2.38990277e-01f, 1.68611899e-01f, 2.90980607e-01f, -8.67448002e-02f, 6.95601255e-02f, 5.60038351e-02f, 1.79930091e-01f, -8.70727971e-02f, -6.05975874e-02f, 1.03433728e-01f,
  -3.55856903e-02f, -2.49483213e-01f, -1.25554383e-01f, -6.72346503e-02f, 4.70145941e-02f, 2.24752694e-01f, 3.19488108e-01f, 6.32231161e-02f, 6.28948398e-03f, 1.88387763e-02f,
  5.13750203e-02f, -1.36993937e-02f, -7.44720623e-02f, 2.58643236e-02f, 8.41272548e-02f, 1.44133836e-01f, 2.62902468e-01f, 9.94919911e-02f, 2.47201502e-01f, 3.09649557e-01f,
  2.06670403e-01f, -2.99177561e-02f, -2.58738771e-02f, -7.42198825e-02f, -2.17275694e-03f, -2.97135487e-02f, 8.81068632e-02f, -1.21953161e-02f, -4.27020192e-02f, 8.12916234e-02f,
  -6.68729842e-02f, -8.65715295e-02f, 3.62118222e-02f, -2.91719902e-02f, -8.22692588e-02f, -3.79975103e-02f, -2.73361597e-02f, 2.12448314e-02f, -5.77520728e-02f, -8.85771886e-02f,
  -7.15244412e-02f, -8.92932154e-03f, 6.98054060e-02f, 6.21645339e-02f, 9.38383043e-02f, -3.35416086e-02f, 2.77890265e-02f, 3.49711366e-02f, 1.70243412e-01f, 2.95764536e-01f,
  3.73590551e-02f, 5.04697040e-02f, -6.87283427e-02f, 4.54974510e-02f, -7.06673265e-02f, 1.46174757e-03f, 5.66416569e-02f, -1.10976696e-02f, 7.19311312e-02f, -3.41523252e-02f,
  7.74924038e-03f, 1.80553198e-02f, 3.18463147e-02f, 5.04576117e-02f, 7.79083595e-02f, 3.89431752e-02f, 8.05569291e-02f, 2.46342272e-02f, 2.39753481e-02f, -6.37412444e-02f,
  3.48196588e-02f, -2.73355581e-02f, -3.72890569e-02f, -1.22683281e-02f, 2.37191226e-02f, 1.05436797e-04f, 3.38350013e-02f, -3.04757077e-02f, -3.42748798e-02f, -3.32155973e-02f,
  -1.10144593e-01f, -1.37250125e-01f, 1.21229351e-01f, -6.96632564e-02f, 9.53212082e-02f, 5.52897854e-03f, -2.26706453e-02f, 7.74910813e-03f, -8.89960974e-02f, -4.16528583e-02f,
  -4.56091017e-02f, -9.63625386e-02f, 5.08449227e-02f, -7.52489362e-03f, 2.46120594e-03f, 4.11994196e-02f, -1.64915863e-02f, 4.82692048e-02f, 7.47798127e-04f, -4.11662608e-02f,
  -3.27825844e-02f, 9.53481868e-02f, 2.02116556e-02f, 7.17971623e-02f, 5.66542409e-02f, 4.71509658e-02f, 9.88465399e-02f, 1.37882680e-01f, 9.49398875e-02f, 2.44843677e-01f,
  -1.41249850e-01f, -2.59949446e-01f, 2.13367231e-02f, -1.90302879e-02f, 1.13394916e-01f, 1.14888221e-01f, 1.29773349e-01f, -2.46400256e-02f, -2.09149765e-03f, -1.23877935e-01f,
  2.65716650e-02f, 5.56186168e-03f, -8.45351722e-03f, 1.63297285e-03f, 1.10327378e-01f, -8.28897506e-02f, 4.12291326e-02f, 1.68124586e-01f, 2.70636767e-01f, 2.38251500e-02f,
  -2.65907738e-02f, -1.11088932e-01f, -3.20624337e-02f, 6.18361235e-02f, -3.28501351e-02f, 2.29942556e-02f, -1.40083447e-01f, -4.59776632e-02f, -2.49213316e-02f, -1.18165076e-01f,
  1.27380967e-01f, -2.14134663e-01f, 2.10747615e-01f, -4.44054380e-02f, 5.65962158e-02f, 3.86530794e-02f, -3.68418656e-02f, -7.26244524e-02f, 1.73093993e-02f, 2.66211573e-02f,
  -6.34060353e-02f, -8.00122917e-02f, -4.65330370e-02f, -4.24141884e-02f, 5.51887490e-02f, -2.16050316e-02f, -1.04573101e-01f, 1.45172440e-02f, 2.61829291e-02f, 1.39010083e-02f,
  -1.04210310e-01f, -2.63877548e-02f, -3.58677618e-02f, 4.08967845e-02f, -9.89573821e-02f, 7.59191588e-02f, -1.99683011e-02f, 9.72141977e-04f, 1.71185378e-02f, -8.39184374e-02f,
  -1.51918009e-02f, -4.55771312e-02f, -7.06579462e-02f, -7.66911432e-02f, -6.66579902e-02f, -5.74776046e-02f, 3.21970731e-02f, 5.91997281e-02f, 7.19122589e-02f, -3.24247740e-02f,
  -5.78903444e-02f, -1.05983904e-02f, 7.64311478e-02f, -6.05577081e-02f, -3.90082486e-02f, -4.49241847e-02f, 1.96149945e-02f, -4.28748988e-02f, -2.19058972e-02f, -8.21306035e-02f,
  -3.78461145e-02f, 7.62180425e-03f, -8.37788805e-02f, 5.05034029e-02f, 2.57249940e-02f, 3.09185367e-02f, -5.50157055e-02f, -5.99636585e-02f, 8.41507595e-03f, -4.30068597e-02f,
  -1.83342956e-02f, 1.29046366e-01f, 9.26743168e-03f, 7.68740801e-03f, -2.29603797e-02f, 9.56729334e-03f, 1.86755881e-02f, 6.06620908e-02f, -6.16995879e-02f, 5.92077523e-02f,
  9.50691570e-03f, 8.45345557e-02f, 2.51073018e-02f, -6.99282885e-02f, 1.37721062e-01f, 1.32298097e-02f, 4.50944155e-02f, 1.10995524e-01f, -5.34970462e-02f, -9.73309204e-02f,
  1.60813723e-02f, 6.56614527e-02f, 1.64566070e-01f, 1.02580316e-01f, 3.35880443e-02f, 1.47061542e-01f, 4.07787040e-02f, 1.90031633e-01f, 1.51849017e-01f, 1.40464276e-01f,
  6.37166440e-01f, -1.29876360e-01f, -2.18978465e-01f, 4.74847183e-02f, -8.96380171e-02f, -5.57180308e-02f, -7.05127269e-02f, 1.82124540e-01f, 8.74701366e-02f, -5.17483950e-02f,
  -1.26232401e-01f, 8.86505768e-02f, -5.44180423e-02f, 9.69648361e-02f, 9.65749472e-02f, -1.93216905e-01f, -2.08249196e-01f, 2.16459353e-02f, 2.55285561e-01f, 1.76915616e-01f,
  2.69594453e-02f, 1.60989344e-01f, 2.44710177e-01f, 1.83561742e-01f, -1.88182220e-01f, -1.36028543e-01f, -7.19776973e-02f, -6.48945197e-02f, -1.05529517e-01f, -2.83591360e-01f,
  -2.39718109e-01f, 1.87935665e-01f, 5.06005855e-03f, 7.69019276e-02f, -4.77361865e-02f, 8.09207857e-02f, 3.59589383e-02f, 7.79265240e-02f, 2.75504477e-02f, -2.35089730e-03f,
  -6.78820014e-02f, 7.54864737e-02f, -2.83996835e-02f, -8.07376355e-02f, 4.11370471e-02f, 2.28384286e-02f, 6.65269941e-02f, 1.23112634e-01f, 5.02060466e-02f, -1.67067535e-02f,
  -1.49172992e-01f, -1.34780452e-01f, -3.14849336e-03f, -4.46563922e-02f, 2.51295660e-02f, -7.37031028e-02f, -6.77840551e-03f, -2.09749993e-02f, 4.78741080e-02f, 3.44287567e-02f,
  1.04543306e-02f, -5.73826320e-02f, -5.65177836e-02f, -2.12555006e-02f, 5.54189179e-03f, -1.82816945e-02f, -5.21029606e-02f, 1.32260388e-02f, 1.41693477e-03f, -2.88277231e-02f,
  3.30171362e-02f, -3.17270868e-02f, -2.74346173e-02f, 4.71468270e-02f, -6.03431314e-02f, -1.62609369e-02f, -9.60315485e-03f, -5.73047809e-02f, 4.20385785e-02f, -7.63090560e-03f,
  8.10869485e-02f, -1.77903213e-02f, -3.16712968e-02f, -5.61049618e-02f, -5.42835845e-03f, 1.34542836e-02f, -1.93526689e-02f, -7.60433525e-02f, 4.14928570e-02f, 1.51451929e-02f,
  1.47478981e-02f, 8.70423093e-02f, 1.24884155e-02f, 3.29709761e-02f, -1.21064030e-01f, -8.89763311e-02f, -4.95314896e-02f, -1.68438908e-02f, -6.35560825e-02f, 4.76378202e-02f,
  6.78963885e-02f, 4.15463448e-02f, 8.49596784e-03f, 3.31193209e-02f, 8.74175504e-02f, 4.97163162e-02f, -1.63709782e-02f, 2.18369570e-02f, 3.37418877e-02f, -1.07000828e-01f,
  -2.69334149e-02f, 9.91797224e-02f, 8.16419423e-02f, 1.12678325e-02f, 1.57934194e-03f, 1.39029920e-01f, -5.36130443e-02f, 2.62517966e-02f, 3.21307778e-02f, 1.08506158e-01f,
  -7.20712841e-02f, 2.71073580e-01f, -9.06743854e-02f, -2.60320939e-02f, 9.68848243e-02f, 2.10374027e-01f, 4.10615593e-01f, 2.62517869e-01f, 1.26748398e-01f, 1.39439687e-01f,
  -5.60783260e-02f, -7.45835602e-02f, -1.33023903e-01f, -2.86527909e-02f, 2.36319527e-02f, 1.25595912e-01f, 1.85280278e-01f, -1.79299101e-01f, -9.84405428e-02f, -2.16244929e-03f,
  -6.62933453e-04f, -1.31432220e-01f, -1.34843752e-01f, 4.19422425e-02f, -7.89836794e-03f, -4.70940247e-02f, 4.02048975e-02f, 3.19593139e-02f, -7.49250129e-02f, -1.21830508e-01f,
  -2.86771625e-01f, -9.84477531e-03f, -1.35108328e-03f, 2.11316903e-04f, 2.55988613e-02f, -3.39425839e-02f, -1.30268335e-02f, 6.22482784e-03f, -1.68714598e-02f, 4.76069413e-02f,
  -1.98106803e-02f, -1.09282121e-01f, -7.00759068e-02f, -1.29334345e-01f, 2.69533806e-02f, 2.12205341e-03f, 2.20236052e-02f, 1.14903199e-02f, -4.11243439e-02f, 4.91455756e-02f,
  3.55696119e-02f, 6.12902492e-02f, -6.95727319e-02f, 1.00384206e-01f, 6.71428517e-02f, -3.05792876e-02f, -4.32496481e-02f, 4.48038243e-02f, -7.75456578e-02f, 7.99695104e-02f,
  -3.51269096e-02f, -1.14169074e-02f, -3.20608094e-02f, -1.62580814e-02f, 2.85539236e-02f, 6.43406883e-02f, -2.86784172e-02f, 8.33391305e-03f, 1.47574944e-02f, -3.58746015e-02f,
  4.61311825e-02f, -9.48423147e-03f, -3.97317931e-02f, 7.14821965e-02f, 5.44862486e-02f, -4.04747911e-02f, -4.33546081e-02f, -1.11908065e-02f, -1.25206234e-02f, -3.33663970e-02f,
  -2.92056166e-02f, 3.15499539e-03f, -2.74717249e-02f, 9.39960107e-02f, -6.18931614e-02f, 2.80276984e-02f, -4.69780155e-02f, 5.53293452e-02f, -7.07382113e-02f, 8.53688419e-02f,
  1.59912519e-02f, 5.24006374e-02f, -9.30952057e-02f, -7.70782605e-02f, 2.11518351e-02f, 4.85307015e-02f, 1.04729068e-02f, -2.53364313e-02f, -3.68461609e-02f, -8.07217602e-03f,
  -1.28888804e-02f, -2.48803454e-03f, -3.52121405e-02f, 2.09728461e-02f, -1.67613905e-02f, 1.01222530e-01f, 1.33495301e-01f, -6.02173097e-02f, 1.22607566e-01f, 6.88903779e-02f,
  4.77141961e-02f, 7.05699548e-02f, 5.22616040e-03f, 3.51297185e-02f, -8.76046158e-03f, -4.31183539e-02f, -1.60686777e-03f, 3.27409767e-02f, 7.55101368e-02f, 5.69718666e-02f,
  -3.24710816e-01f, 1.00568332e-01f, -1.12868458e-01f, -2.25530379e-02f, 5.69675639e-02f, 7.89614916e-02f, 1.47443578e-01f, 5.07760905e-02f, 1.13839082e-01f, 3.28148752e-02f,
  -6.62504062e-02f, -1.35913670e-01f, -1.60554931e-01f, -1.42191142e-01f, -1.01671025e-01f, 6.64267316e-02f, 1.09343365e-01f, -1.48605660e-01f, -1.14951134e-01f, -3.60568762e-02f,
  3.16417553e-02f, 8.96379352e-02f, -7.35919625e-02f, 2.75568385e-02f, 1.56974852e-01f, -3.63031193e-03f, 1.03197685e-02f, -5.49111106e-02f, 1.16957299e-01f, 1.40667567e-02f,
  -2.24102169e-01f, -8.94775391e-02f, -9.94791165e-02f, -7.63245998e-03f, -2.86649950e-02f, -8.37902306e-04f, -3.49043706e-03f, 1.68092512e-02f, -2.39101797e-02f, 4.88117114e-02f,
  -2.18947995e-02f, 9.16656107e-02f, -5.66800833e-02f, 1.40940234e-01f, 1.71820354e-02f, 2.61313505e-02f, 3.84891704e-02f, -8.23668912e-02f, 2.61474419e-02f, -4.95172255e-02f,
  3.60797234e-02f, 1.17121423e-02f, -1.33424699e-01f, -3.62592526e-02f, 1.13706589e-02f, -5.70739508e-02f, 8.84021521e-02f, -4.33431566e-02f, 5.41904895e-03f, 1.38022393e-01f,
  5.31331562e-02f, -6.28471971e-02f, 3.33482698e-02f, -5.43001704e-02f, 4.44265604e-02f, 1.95902754e-02f, 4.95794602e-02f, -7.56357610e-02f, 5.95369786e-02f, -9.74098127e-03f,
  -3.69717963e-02f, -8.06223750e-02f, 2.07397677e-02f, 1.61100011e-02f, 2.29780916e-02f, 3.15360688e-02f, -7.10097700e-02f, 1.10281724e-02f, 5.21372445e-02f, 2.02139816e-03f,
  -1.00790218e-01f, -1.87782031e-02f, 5.93508929e-02f, -1.71793960e-02f, 5.47957569e-02f, 1.28276804e-02f, -6.72034547e-02f, -2.44845245e-02f, 1.05637945e-01f, 5.59078297e-03f,
  -1.62526593e-02f, -4.92738150e-02f, -6.13268130e-02f, -4.14585844e-02f, 4.42358777e-02f, -4.95913550e-02f, 3.98059450e-02f, 2.72393599e-02f, -5.60382754e-03f, -1.13447987e-01f,
  -5.04442304e-02f, 1.43068181e-02f, -3.53104398e-02f, 1.13453589e-01f, -6.67180195e-02f, 4.80819121e-02f, -6.51411153e-03f, 3.17610204e-02f, 8.75943340e-03f, 8.13653171e-02f,
  1.20805331e-01f, 3.16574425e-02f, -1.67544588e-01f, -1.27928266e-02f, 3.53124291e-02f, -1.32240817e-01f, -1.56179629e-02f, -6.76209778e-02f, -1.92590967e-01f, -4.21184523e-04f,
  5.71804583e-01f, 9.60790589e-02f, -2.56742775e-01f, 1.20917574e-01f, -1.71375185e-01f, -6.70729056e-02f, -1.11606814e-01f, -1.25600826e-02f, 1.37740210e-01f, 4.38242182e-02f,
  -2.21553855e-02f, -2.45143268e-02f, 5.06712086e-02f, -9.56371576e-02f, 6.86983839e-02f, -9.91369337e-02f, -1.56276420e-01f, 1.59575306e-02f, 2.14749388e-02f, -2.19835769e-02f,
  -1.60007924e-02f, 4.24098484e-02f, 1.19522296e-01f, 3.64538804e-02f, -9.59414467e-02f, -1.25881523e-01f, -1.27513289e-01f, -6.43446518e-04f, -3.81391086e-02f, -6.18777648e-02f,
  -1.12558603e-01f, 8.25535282e-02f, -6.51266519e-03f, 5.79499565e-02f, -1.29809007e-01f, 5.07852994e-02f, 5.82650676e-02f, -2.23412700e-02f, 3.48742679e-02f, 6.69652820e-02f,
  -1.13063520e-02f, 7.49807665e-03f, -2.69794110e-02f, 3.74070853e-02f, 4.16682214e-02f, 5.88262342e-02f, 8.01275000e-02f, -5.32035716e-02f, -7.77851418e-02f, 4.33409065e-02f,
  -9.66224074e-02f, -1.88307762e-02f, -1.00729890e-01f, -7.30582327e-02f, 3.81801613e-02f, 3.25834416e-02f, -9.94478911e-02f, -4.60903347e-02f, -1.21608771e-01f, 1.01909526e-01f,
  -4.78216931e-02f, 2.14194469e-02f, -3.82266827e-02f, 9.67661589e-02f, -4.53546569e-02f, 7.03005418e-02f, -1.08481802e-01f, 3.79484370e-02f, 3.81795689e-03f, 5.11344522e-02f,
  1.00257341e-02f, -1.22655500e-02f, 2.04983000e-02f, 6.05169646e-02f, 6.08333424e-02f, -5.41887134e-02f, 1.16623715e-02f, 6.96064904e-02f, -3.85245085e-02f, 3.04938890e-02f,
  7.84956664e-03f, -2.16236617e-03f, 1.36002200e-02f, -2.48083100e-02f, -1.02895476e-01f, -2.14337017e-02f, -4.50358018e-02f, 3.01977303e-02f, 3.94860506e-02f, -6.89595491e-02f,
  1.46925628e-01f, -1.21219359e-01f, 1.26576781e-01f, 4.59717922e-02f, -2.59307902e-02f, -4.22457457e-02f, -9.20875929e-03f, 2.70193722e-02f, 2.17455216e-02f, -2.05745660e-02f,
  3.40071018e-03f, 7.30533600e-02f, -1.10361297e-02f, -6.77925572e-02f, 5.39153963e-02f, 5.79942875e-02f, -2.34224722e-02f, 3.33096343e-03f, -2.94622127e-02f, -1.78470034e-02f,
  -5.77604622e-02f, -9.94572882e-03f, 1.10135123e-01f, -3.50414552e-02f, 5.60845248e-02f, 4.96807694e-02f, -5.02999909e-02f, 4.96556647e-02f, 7.14160949e-02f, 1.62129983e-01f,
  1.68787137e-01f, 1.54334486e-01f, 1.67616040e-01f, 7.71012483e-03f, 8.22716653e-02f, 2.28814051e-01f, 4.62405235e-01f, 2.24270880e-01f, -4.07276265e-02f, 4.25178446e-02f,
  -1.63429365e-01f, -3.39943290e-01f, -2.14113653e-01f, -5.89459985e-02f, 1.26094505e-01f, 2.49616116e-01f, 2.54537106e-01f, 1.67102680e-01f, 4.51544710e-02f, 8.42010453e-02f,
  -4.44096588e-02f, 1.26442444e-02f, -7.90544078e-02f, 9.77114663e-02f, -5.44225201e-02f, 1.73978899e-02f, 1.69382785e-02f, 1.09850667e-01f, 1.00931652e-01f, 9.97451991e-02f,
  -1.14493877e-01f, 1.43540114e-01f, -5.24199568e-03f, -1.19627006e-01f, -7.55894780e-02f, 1.65586509e-02f, 4.12274711e-02f, 1.99661008e-03f, -3.38761657e-02f, -2.64606625e-02f,
  -8.96650702e-02f, -5.34347408e-02f, 3.42102051e-02f, -6.36249036e-02f, -1.96449761e-03f, 1.53661789e-02f, 6.72429353e-02f, -5.82007167e-04f, 7.13154376e-02f, -4.41658609e-02f,
  -1.06757499e-01f, -2.41428055e-02f, 5.39408214e-02f, 3.06565855e-02f, 6.28449023e-02f, -1.65139176e-02f, 8.70790780e-02f, 1.22205533e-01f, 1.07922584e-01f, 1.59921259e-01f,
  5.36589026e-02f, -3.83069813e-02f, -9.04705469e-03f, 2.51767668e-03f, 2.96594501e-02f, -1.11295395e-01f, 3.42748165e-02f, -4.25047204e-02f, 2.66970042e-02f, -1.60865486e-02f,
  -6.91349898e-03f, -1.86080616e-02f, 4.03019637e-02f, 2.92270649e-02f, -2.28076503e-02f, -2.93069277e-02f, 6.03329949e-02f, -5.26775345e-02f, 4.99744155e-02f, 1.15002757e-02f,
  2.07122751e-02f, -3.19825858e-02f, -3.01472116e-02f, -3.30948457e-02f, -1.27781313e-02f, 4.29438241e-02f, -1.89970396e-02f, -7.29224226e-03f, -8.56466293e-02f, 4.57483567e-02f,
  -1.86015874e-01f, 1.15494686e-03f, -1.25890430e-02f, 5.22053652e-02f, 2.82012695e-03f, -6.13736995e-02f, -9.58470628e-02f, 2.82461550e-02f, -3.10556963e-02f, 8.11223909e-02f,
  3.14675272e-02f, -3.73252779e-02f, 1.32189598e-02f, 1.48633020e-02f, 7.41175041e-02f, 3.04515194e-02f, -9.59785841e-03f, -5.99575192e-02f, 4.21573706e-02f, -1.33789927e-01f,
  2.14560498e-02f, 1.24816641e-01f, 2.90015116e-02f, 1.40553981e-01f, -1.19690150e-02f, 6.21046536e-02f, 1.01744108e-01f, 8.95762593e-02f, 1.92520618e-01f, 2.65487641e-01f,
  -1.24743879e-02f, 1.79587021e-01f, 5.28404601e-02f, 8.72467905e-02f, 1.53927475e-01f, -7.88292065e-02f, -5.81887215e-02f, -1.32408664e-01f, -4.89889756e-02f, 1.28236637e-01f,
  1.65668949e-01f, -8.05183202e-02f, -1.87584251e-01f, -1.10478647e-01f, -2.23328874e-01f, -4.54671010e-02f, -7.23323971e-02f, -1.46153137e-01f, -3.72011423e-01f, -2.48772297e-02f,
  2.76983529e-02f, 7.50430822e-02f, -3.62900048e-02f, 5.59057556e-02f, 8.46998245e-02f, -3.02039664e-02f, 1.47558555e-01f, 8.26895908e-02f, 6.12224936e-02f, 1.79008901e-01f,
  2.11421289e-02f, 1.49601638e-01f, -2.21765578e-01f, 7.69685805e-02f, 7.43214637e-02f, 3.44328843e-02f, 2.97509190e-02f, 1.58702303e-02f, 2.94257514e-02f, -2.05067778e-03f,
  1.08766489e-01f, 7.98643231e-02f, 2.78644413e-02f, 7.24249855e-02f, 2.20202431e-02f, -6.73784837e-02f, 6.53200224e-02f, -1.16289712e-01f, -1.82321351e-02f, 1.04113534e-01f,
  1.56286150e-01f, 6.49853051e-02f, -4.67776917e-02f, 1.58983078e-02f, 9.54610575e-03f, -2.68176515e-02f, 3.19381319e-02f, 1.16142310e-01f, -5.97285200e-03f, 8.86213258e-02f,
  -2.07194742e-02f, 1.36666400e-02f, 7.36120972e-04f, 6.37500435e-02f, -3.69977467e-02f, -4.19650935e-02f, -4.95361648e-02f, 7.16773421e-02f, -5.50858788e-02f, 3.73392795e-05f,
  -2.36617420e-02f, -1.06640449e-02f, 4.62865755e-02f, -3.19259204e-02f, -9.52469371e-03f, 4.44824956e-02f, -2.31975354e-02f, -4.68285382e-02f, 6.40375689e-02f, 4.88983579e-02f,
  -4.12604995e-02f, -1.62636105e-04f, 1.93246212e-02f, -3.46477889e-02f, 2.65695788e-02f, 4.16645668e-02f, -3.70793417e-02f, -1.34378076e-02f, 4.83620875e-02f, 1.11291647e-01f,
  -1.86184853e-01f, -7.48375058e-02f, -6.78719729e-02f, -1.03607439e-01f, 6.91932291e-02f, -1.68585742e-04f, 1.25876097e-02f, 5.40133528e-02f, 4.34467383e-02f, -1.93687752e-02f,
  -3.54424715e-02f, -1.83283910e-02f, 5.43234162e-02f, 1.72617678e-02f, 1.44277094e-02f, -3.05194631e-02f, 1.30865768e-01f, -1.15741223e-01f, -1.00615285e-01f, 1.34839583e-03f,
  9.70704705e-02f, -3.57641727e-02f, -2.72102088e-01f, -8.73508975e-02f, -1.06170781e-01f, -2.76521593e-01f, -1.77391827e-01f, -2.48438511e-02f, -2.01842964e-01f, -1.63459539e-01f,
  1.01572514e-01f, 6.11035526e-02f, 3.42520699e-02f, 1.42934039e-01f, 1.89709857e-01f, 8.60801637e-02f, 4.58644442e-02f, -1.66180395e-02f, 8.67206678e-02f, 9.93721485e-02f,
  -7.16735795e-02f, -8.07032958e-02f, -2.80688219e-02f, -1.18547734e-02f, 1.78336408e-02f, -3.90446112e-02f, 1.79218426e-02f, -1.45799760e-02f, -3.09291482e-02f, -4.08673026e-02f,
  -6.44513294e-02f, 2.16510054e-02f, 6.34518787e-02f, 8.37928280e-02f, 9.79519188e-02f, 9.37876571e-03f, 1.12150230e-01f, -2.21766364e-02f, -8.80051404e-02f, 8.95701051e-02f,
  7.58061409e-02f, -5.94109442e-05f, 7.18327165e-02f, -1.02683030e-01f, 6.43877983e-02f, -7.54065067e-02f, 3.47005539e-02f, -3.74006256e-02f, -7.79150352e-02f, 5.74942231e-02f,
  -8.67013931e-02f, -5.57628982e-02f, 7.31066540e-02f, -7.68706948e-02f, 1.28975082e-02f, 6.14598133e-02f, -3.32746841e-02f, 2.83677108e-03f, -8.15226808e-02f, -1.01694129e-01f,
  1.15891045e-03f, 7.89829716e-02f, 1.36146963e-01f, 3.98549549e-02f, 3.68140526e-02f, -7.84782469e-02f, 8.35167393e-02f, -2.63901032e-03f, -6.86945468e-02f, 1.02226160e-01f,
  -7.53631890e-02f, -7.14171380e-02f, -2.79528312e-02f, 2.62532532e-02f, -2.97888648e-02f, 4.17844243e-02f, -3.80871929e-02f, -3.96831296e-02f, 5.74640818e-02f, 7.98897147e-02f,
  -4.40289527e-02f, -1.40394811e-02f, -4.54353206e-02f, -3.42349373e-02f, -6.58699032e-03f, 9.85365137e-02f, -7.89953396e-02f, -8.82378072e-02f, -4.41390611e-02f, 9.40883439e-03f,
  -4.56554629e-02f, 8.54844227e-02f, 7.92925060e-02f, 9.39059723e-03f, 4.92204633e-03f, -5.44749945e-02f, -7.23997876e-02f, -6.92603365e-02f, 6.15278035e-02f, -7.13500455e-02f,
  3.40356864e-02f, -7.94888660e-03f, 7.92497173e-02f, -1.14587918e-02f, 5.96212372e-02f, -1.59423798e-02f, -2.20210082e-03f, 6.00264445e-02f, 2.74587274e-02f, -4.99643125e-02f,
  3.32634076e-02f, 6.53429255e-02f, 1.21911906e-01f, -3.49947363e-02f, -1.35555761e-02f, 6.37640106e-03f, 3.60238552e-02f, 8.98177624e-02f, -2.61895414e-02f, -3.84229124e-02f,
  8.42834041e-02f, 4.91215624e-02f, 1.44114673e-01f, 4.99647558e-02f, 4.94695157e-02f, 7.52115250e-02f, 9.91062075e-02f, 1.39865518e-01f, 1.27783790e-03f, 5.87133989e-02f,
  -1.75772347e-02f, 1.82014275e-02f, -1.42735496e-01f, -1.27128363e-01f, -9.59051549e-02f, -1.83790196e-02f, -1.39473099e-02f, -3.96000631e-02f, 8.43006279e-03f, 3.98609564e-02f,
  1.16828851e-01f, 9.96287316e-02f, -1.32984206e-01f, -1.14164732e-01f, -2.15791821e-01f, -1.73809409e-01f, -2.49509096e-01f, -3.44785184e-01f, -3.15489739e-01f, -1.98329479e-01f,
  -1.23738475e-01f, -1.91087529e-01f, -2.17966765e-01f, -1.81659520e-01f, -1.36658952e-01f, -3.12658101e-02f, -1.44224197e-01f, -4.40084115e-02f, -1.80999428e-01f, -2.10310712e-01f,
  -2.17477620e-01f, 1.31555423e-01f, 4.70358692e-02f, 5.47083616e-02f, -7.52626956e-02f, 3.90741155e-02f, -1.09983189e-03f, 1.62729323e-02f, 1.17730871e-01f, 5.43534085e-02f,
  2.40268018e-02f, -8.29389319e-02f, 4.63538356e-02f, -9.14280340e-02f, 2.27424968e-02f, -4.20558304e-02f, 6.81841280e-03f, -3.29671912e-02f, -7.74817616e-02f, 6.77904710e-02f,
  9.97809097e-02f, 8.08160007e-02f, 1.20710842e-02f, -3.17863934e-02f, 1.89085025e-02f, 1.15670525e-02f, 1.09306000e-01f, 1.18069381e-01f, 7.54499882e-02f, -8.76487419e-03f,
  2.58485507e-03f, -3.68424878e-02f, 1.72136799e-02f, -2.67193969e-02f, -3.57548450e-03f, 8.86470154e-02f, 5.27888117e-03f, -1.37058655e-02f, 5.44246286e-02f, -2.32189670e-02f,
  4.12335200e-03f, 2.88323332e-02f, 5.99260889e-02f, -2.46156063e-02f, -2.34580114e-02f, -6.09093904e-03f, 4.54804301e-02f, 2.89615449e-02f, -1.81534886e-02f, 6.49354160e-02f,
  5.30249141e-02f, 4.81886342e-02f, 2.92897001e-02f, -1.65561156e-03f, -1.81681290e-02f, -4.05178696e-04f, -2.92792134e-02f, 3.44960652e-02f, 2.82731205e-02f, 4.56362078e-03f,
  -5.60525693e-02f, 9.76919457e-02f, -4.84949313e-02f, 2.43979394e-02f, 2.29411554e-02f, -5.89095615e-02f, 9.68144760e-02f, 5.51794376e-03f, 9.22580808e-02f, -4.19360474e-02f,
  5.22599034e-02f, 8.25158656e-02f, 5.21320365e-02f, 6.12293892e-02f, 7.11520156e-03f, 3.96218821e-02f, 4.33921255e-02f, 7.38855277e-04f, 5.40130846e-02f, -1.37848733e-02f,
  -4.48504835e-02f, 1.11882105e-01f, 6.52208850e-02f, 3.24578863e-03f, 4.92028147e-02f, 9.42430831e-03f, 3.43415812e-02f, -1.69601254e-02f, -6.45745173e-02f, 2.22027600e-02f,
  -1.02241576e-01f, -2.79693156e-01f, 5.13463877e-02f, -3.81664485e-02f, 7.63942255e-03f, 2.14043558e-01f, 1.47642329e-01f, 1.23150900e-01f, -3.87927592e-02f, -7.03971693e-03f,
  -1.65399775e-01f, -1.15933321e-01f, -7.81696290e-02f, 8.11842233e-02f, 1.02105960e-01f, 6.58265278e-02f, 1.51620254e-01f, 2.11057384e-02f, 2.43928432e-01f, 5.57740964e-02f,
  -5.52234240e-02f, -7.79906288e-02f, 5.00937626e-02f, -4.64449376e-02f, -2.33686283e-01f, 3.00376620e-02f, -9.46749467e-03f, -9.65448022e-02f, 5.95054543e-03f, -1.43129900e-01f,
  -2.91501880e-01f, -1.92089930e-01f, 2.26514950e-01f, 1.58345271e-02f, -2.69994270e-02f, -6.17044680e-02f, 8.99355710e-02f, -1.28840521e-01f, -5.44669554e-02f, 1.75077305e-03f,
  -1.34105146e-01f, -2.81592514e-02f, -7.65900686e-02f, -7.46192485e-02f, -8.05168375e-02f, -5.30842021e-02f, -5.15717417e-02f, 7.91457072e-02f, 9.67102032e-03f, -6.33997023e-02f,
  -1.97498314e-02f, -1.01197667e-01f, -3.48827764e-02f, -3.52780777e-03f, -4.97999229e-02f, 1.18837103e-01f, -7.78458863e-02f, 2.08842400e-02f, 1.49598127e-04f, -3.85245010e-02f,
  2.26411633e-02f, 7.39123374e-02f, -4.11133617e-02f, 4.40823697e-02f, -2.66439375e-03f, 8.52987319e-02f, -3.48105580e-02f, -2.50752885e-02f, 2.79844478e-02f, -1.71910524e-02f,
  -5.91060221e-02f, -5.10371872e-04f, -4.68451194e-02f, 1.04263229e-02f, 4.72391844e-02f, -1.95431113e-02f, 1.20409336e-02f, 4.36266288e-02f, -4.02512923e-02f, 2.66897641e-02f,
  -2.98505109e-02f, 6.18546037e-03f, -5.40655851e-03f, -3.77804786e-02f, 1.37444790e-02f, 5.34119681e-02f, -1.34967566e-02f, -5.79281561e-02f, -9.37233418e-02f, -8.14926848e-02f,
  -1.05594151e-01f, 1.92091569e-01f, -1.08291283e-01f, -8.39034840e-02f, -1.78129273e-03f, -6.32924065e-02f, -9.80812758e-02f, 2.53783017e-02f, -4.76628467e-02f, 4.16148789e-02f,
  1.21443067e-02f, 4.20727441e-03f, 8.13982449e-03f, 8.12555943e-03f, 3.78239825e-02f, 5.21932729e-02f, -9.24477354e-03f, 2.90015265e-02f, -2.10168678e-02f, 4.55732411e-03f,
  2.03510411e-02f, 1.54095203e-01f, 7.55839422e-02f, 4.94213216e-02f, 7.11649582e-02f, 1.53571606e-01f, 8.83673877e-02f, -6.42508194e-02f, 1.52966782e-01f, 5.77026345e-02f,
  -7.65436143e-02f, -8.43970329e-02f, -1.83919281e-01f, -2.05619171e-01f, 1.56893637e-02f, 9.12671015e-02f, 2.11011395e-01f, 5.09912074e-02f, 4.92890850e-02f, -3.86755615e-02f,
  8.42691287e-02f, 2.49845479e-02f, 4.27624620e-02f, -4.62224297e-02f, -4.24938127e-02f, -9.67609659e-02f, -2.07642958e-01f, -1.32773951e-01f, 5.09067066e-02f, 1.78492174e-01f,
  1.68657988e-01f, -9.93043259e-02f, -3.57154347e-02f, -1.27165198e-01f, -1.42140284e-01f, 1.29592689e-02f, -1.53292507e-01f, -1.45902514e-01f, 1.72669888e-02f, -1.91635013e-01f,
  -3.85810412e-03f, -8.26806277e-02f, 8.27417597e-02f, 8.35520551e-02f, 6.02809675e-02f, 4.92783869e-03f, -3.25245447e-02f, -1.31339148e-01f, 2.10690405e-02f, -9.20665786e-02f,
  2.58386098e-02f, 3.89484130e-02f, -2.82825045e-02f, 7.44450167e-02f, -7.16324225e-02f, -3.78138870e-02f, -1.58938214e-01f, -9.56193060e-02f, -1.17483333e-01f, 7.21015632e-02f,
  6.35579810e-04f, 9.30671543e-02f, -1.16787860e-02f, -2.20513418e-02f, 3.29195932e-02f, -4.58824672e-02f, 7.48721436e-02f, -7.47327358e-02f, -7.05598965e-02f, -9.36003327e-02f,
  7.91964028e-03f, -7.25597963e-02f, 6.52851239e-02f, -1.90808196e-02f, 8.77657011e-02f, -7.65792206e-02f, -7.83060417e-02f, 5.81731275e-02f, 3.15936990e-02f, 3.69490497e-02f,
  -2.13364772e-02f, 2.53555737e-02f, -5.82180358e-02f, -5.52584007e-02f, 2.49733292e-02f, -1.19247371e-02f, -2.56428104e-02f, -3.14487070e-02f, -7.47427018e-03f, 5.50036505e-02f,
  -5.08635342e-02f, 1.20325787e-02f, 3.94933373e-02f, -8.03786665e-02f, -4.63120565e-02f, -5.90866432e-02f, -3.76415290e-02f, 7.82968402e-02f, -7.28798062e-02f, 2.61999760e-02f,
  -7.88957700e-02f, 6.97762072e-02f, 1.58427507e-02f, 3.07535063e-02f, -3.03696003e-02f, 3.48800384e-02f, -9.79366247e-03f, -3.22183073e-02f, 4.50495854e-02f, 1.39881752e-03f,
  3.49622313e-03f, 5.31820059e-02f, -1.59220211e-02f, -3.78236808e-02f, -4.05971147e-02f, 5.09594381e-02f, 6.15159608e-02f, -1.70417186e-02f, 9.47353151e-03f, 6.03145408e-03f,
  -5.30502573e-02f, 1.43426269e-01f, 1.37119561e-01f, 2.63443068e-02f, 9.60112512e-02f, 3.48658003e-02f, 1.15294695e-01f, 4.52444889e-02f, 1.60006464e-01f, 4.95360233e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.51940519e-01f, 1.36507139e-01f, 1.58413634e-01f, 9.10068024e-03f, 8.40736479e-02f, 1.10939398e-01f, 4.73644994e-02f, 6.57325760e-02f, -6.58171177e-02f, 1.25972316e-01f,
  9.91156027e-02f, -1.27781765e-03f, 6.39825463e-02f, -8.35974962e-02f, 9.64608137e-03f, -2.28349660e-02f, -3.64075750e-02f, 6.92616124e-03f, 1.20036654e-01f, 7.95418471e-02f,
  6.79968623e-03f, 7.89372027e-02f, 1.32127732e-01f, 1.00077540e-02f, 2.38824673e-02f, -9.77818444e-02f, 5.50673716e-03f, 9.81163979e-02f, 5.35026938e-02f, 7.50587881e-02f,
  -3.99022959e-02f, 7.88000450e-02f, -6.82995468e-02f, 1.72753315e-02f, -2.11057235e-02f, 1.41051542e-02f, -7.86267072e-02f, 6.61510304e-02f, 7.39251031e-03f, -1.13018816e-02f,
  2.19204333e-02f, 7.59815350e-02f, 2.39993408e-02f, 6.24340400e-02f, -2.10772976e-02f, -4.00752239e-02f, 5.80382086e-02f, 6.54339418e-02f, -7.52776265e-02f, 6.73151296e-03f,
  -3.65711376e-02f, -6.33124681e-03f, 3.84328254e-02f, -6.10150211e-02f, -4.84684110e-02f, -7.09635839e-02f, 3.71798985e-02f, 3.77066098e-02f, 7.09862038e-02f, 1.19117682e-03f,
  -4.53543440e-02f, -4.24980149e-02f, -4.04473729e-02f, 5.50942682e-02f, 5.97754158e-02f, -6.84334785e-02f, 5.13151810e-02f, -5.41544929e-02f, -1.00259604e-02f, -5.12560606e-02f,
  2.57147271e-02f, -4.17556055e-02f, 1.91485286e-02f, -3.75112928e-02f, -4.48146425e-02f, -8.29152763e-03f, 8.01048875e-02f, 6.66768327e-02f, 8.03829208e-02f, 4.28577662e-02f,
  5.30536398e-02f, 6.62861615e-02f, 9.40442011e-02f, 1.65815167e-02f, 5.83477281e-02f, 3.53533477e-02f, 5.57573847e-02f, 6.58642948e-02f, -5.44012301e-02f, 2.87373029e-02f,
  -1.00969590e-01f, -4.37630266e-02f, 7.99084455e-02f, -1.92012005e-02f, 5.10481652e-03f, -3.64709273e-02f, 3.97499837e-02f, -2.94510908e-02f, -1.97339058e-02f, 3.99833657e-02f,
  -5.43073080e-02f, -7.40254521e-02f, -8.36610645e-02f, -1.02982134e-01f, -9.53623187e-03f, 3.61925848e-02f, -5.90179712e-02f, -1.92909911e-02f, -7.36816600e-02f, -3.31841372e-02f,
  -9.66979265e-02f, 4.09986116e-02f, -3.45022716e-02f, 5.99133447e-02f, -4.71033808e-03f, -1.15612000e-01f, -1.86469331e-02f, -1.15416840e-01f, -1.99213475e-02f, 5.71163595e-02f,
  2.32373532e-02f, 2.15192046e-02f, 1.47978365e-01f, 6.30890429e-02f, -4.27492559e-02f, -8.31623003e-03f, 9.48832408e-02f, -2.12600362e-02f, -4.73313928e-02f, -2.11718790e-02f,
  4.34924439e-02f, 3.73466732e-03f, 6.99573010e-02f, 7.81636983e-02f, -6.70801252e-02f, 5.55264167e-02f, -7.81553518e-03f, 6.29998520e-02f, -1.20364696e-01f, -1.51331261e-01f,
  -9.45060179e-02f, 1.02990388e-03f, -6.40551597e-02f, -2.12322231e-02f, -7.31516406e-02f, 6.44708350e-02f, 1.06111959e-01f, -4.31086086e-02f, -8.81601423e-02f, -9.94838774e-02f,
  -4.23699729e-02f, -6.42542541e-02f, -9.01091099e-02f, -8.23363066e-02f, 8.93071890e-02f, -4.67997491e-02f, -1.02743439e-01f, -7.71784186e-02f, -2.10585501e-02f, -4.99965288e-02f,
  5.80147952e-02f, -7.99259692e-02f, 4.64449711e-02f, -3.86161846e-03f, 7.42349122e-03f, -4.09035124e-02f, -8.23449790e-02f, -3.83408628e-02f, 3.21538635e-02f, 7.37681985e-02f,
  -1.59216523e-02f, -3.45665105e-02f, 7.16053173e-02f, -2.63339970e-02f, 3.62359569e-03f, 3.84542309e-02f, -1.04730772e-02f, 1.48812039e-02f, 2.98420480e-03f, 1.81595273e-02f,
  2.46172473e-02f, 8.63644332e-02f, 8.04444402e-02f, 7.54955411e-02f, 2.73258076e-03f, -7.15160444e-02f, -6.10799268e-02f, -9.41703096e-02f, -3.99299413e-02f, 3.69756296e-02f,
  1.11195492e-02f, 7.01479763e-02f, -6.91579953e-02f, 6.05545677e-02f, -6.34413809e-02f, 7.76920840e-02f, -4.21021916e-02f, 1.01512320e-01f, -6.53532073e-02f, -3.33345644e-02f,
  -8.69677067e-02f, 6.39550239e-02f, 6.65063635e-02f, -8.06610063e-02f, 8.56728852e-03f, 6.27873093e-02f, -8.04754645e-02f, -6.74172267e-02f, -6.23347200e-02f, 7.58172274e-02f,
  -8.43575150e-02f, 1.25976458e-01f, -7.80871958e-02f, 2.94803604e-02f, 1.76589284e-02f, -9.85837355e-03f, -3.36229205e-02f, 6.76837936e-02f, 4.35929596e-02f, 6.84837326e-02f,
  -6.67628599e-03f, -4.82065650e-03f, 1.01001754e-01f, 5.33948690e-02f, -4.44170050e-02f, -9.33213234e-02f, -9.34934989e-02f, 1.61199793e-02f, 4.28455286e-02f, -7.46044666e-02f,
  -9.82952118e-02f, -2.85016019e-02f, -1.60974357e-02f, 4.53569777e-02f, -3.59011441e-02f, 7.23065622e-03f, -6.74300268e-02f, 3.10685840e-02f, -2.72618164e-03f, 5.14273196e-02f,
  2.70342737e-01f, 1.60080537e-01f, 2.37123802e-01f, 3.29223275e-02f, -2.74584186e-03f, 8.79872143e-02f, 8.44753683e-02f, 1.26585424e-01f, 5.00107892e-02f, -6.13149144e-02f,
  -6.30902266e-03f, -6.20932132e-02f, 2.67171506e-02f, 6.91836253e-02f, -1.13883298e-02f, 7.54591003e-02f, 3.96248884e-02f, 6.95895255e-02f, 3.24907973e-02f, -2.57908013e-02f,
  -8.27882811e-02f, 4.12604809e-02f, 1.02327295e-01f, 3.91398044e-03f, 4.28984016e-02f, -3.68484907e-04f, 6.12139702e-02f, 3.61118913e-02f, -3.86822335e-02f, 2.53987568e-03f,
  9.01551768e-02f, 8.35750848e-02f, -1.30123273e-01f, -8.11853930e-02f, -9.74105224e-02f, 6.51327614e-03f, -1.12375012e-02f, -3.60766053e-02f, 2.73657721e-02f, 2.94169392e-02f,
  -9.68505889e-02f, 1.67066287e-02f, 1.29318127e-04f, 5.05453944e-02f, 5.80561385e-02f, 2.25158455e-03f, 5.15653342e-02f, -2.96251732e-03f, 4.60874401e-02f, -6.09048503e-03f,
  -1.24530628e-01f, -1.66743919e-02f, 9.40526500e-02f, 1.41035523e-02f, -2.85742786e-02f, -1.80390440e-02f, 9.48880985e-02f, -1.10520162e-02f, 2.10389588e-02f, 3.45064723e-03f,
  -9.18273628e-02f, -1.89685076e-02f, 4.18628082e-02f, 9.14734453e-02f, 1.54603235e-02f, 6.46495223e-02f, -7.46922642e-02f, -1.70800206e-03f, 6.49424568e-02f, -3.13858967e-03f,
  8.93719122e-02f, 6.07402809e-02f, -4.58014533e-02f, -1.97267216e-02f, -9.01862234e-02f, -6.17792755e-02f, 7.38484859e-02f, -3.44093740e-02f, -3.52589712e-02f, -2.85492577e-02f,
  1.05205610e-01f, -5.55352718e-02f, -4.53768717e-03f, 7.65326098e-02f, -3.40096205e-02f, -1.19695356e-02f, 2.64080763e-02f, -1.64160877e-02f, -3.94304916e-02f, 6.47727847e-02f,
  -2.17380434e-01f, 1.17632046e-01f, 4.73768674e-02f, -6.85487986e-02f, -3.55458981e-03f, -1.15495482e-02f, -3.36303562e-02f, -1.45040173e-02f, -5.69575354e-02f, -6.30162582e-02f,
  -1.52421864e-02f, 8.19715783e-02f, 4.85095754e-02f, -4.56366166e-02f, 6.18354082e-02f, 1.98565219e-02f, -1.10136248e-01f, 8.97214562e-02f, -5.82868010e-02f, 8.98607541e-03f,
  -2.09591519e-02f, -5.43495342e-02f, -8.69804714e-03f, -9.14669856e-02f, -6.48567379e-02f, -2.77452394e-02f, -6.85022622e-02f, -3.13430815e-03f, -6.91488162e-02f, -1.00745641e-01f,
  1.54877442e-03f, -9.01815966e-02f, -2.33058512e-01f, -1.66054610e-02f, -1.14494279e-01f, 4.73439917e-02f, -3.95440012e-02f, -6.16750345e-02f, -9.37431306e-02f, -8.38032290e-02f,
  -2.40278840e-02f, -1.26238158e-02f, -3.37678865e-02f, 6.43462688e-03f, -2.16368698e-02f, -1.25063777e-01f, -2.10790560e-02f, -9.64944512e-02f, 5.74896932e-02f, -5.33209145e-02f,
  -8.85561481e-02f, -1.88912172e-02f, 2.00741328e-02f, -8.75115916e-02f, -1.59415483e-01f, -3.02771153e-03f, -2.17010111e-01f, -1.04303561e-01f, -3.58204655e-02f, -1.24017835e-01f,
  -2.18085170e-01f, -9.39707682e-02f, -2.82064676e-02f, 5.30732386e-02f, -1.27849221e-01f, -7.56996125e-02f, 1.49147387e-03f, -3.01560052e-02f, -2.69714091e-02f, -8.42138305e-02f,
  3.04926317e-02f, 4.32117321e-02f, -1.10025428e-01f, -8.89132917e-02f, 5.57009727e-02f, -3.42631042e-02f, 4.53962088e-02f, -1.07683912e-01f, -1.02707455e-02f, -7.59379119e-02f,
  -7.38082007e-02f, 9.20289084e-02f, 5.43148145e-02f, -7.84562379e-02f, -9.33631137e-02f, -6.52887225e-02f, 2.50426903e-02f, 4.21471447e-02f, -5.09238318e-02f, 3.16640921e-02f,
  6.44312724e-02f, -8.22875053e-02f, 1.70230458e-03f, 6.87102750e-02f, 4.72815894e-02f, 5.44952340e-02f, -5.97504675e-02f, 1.95423905e-02f, -1.53951580e-02f, -4.82336096e-02f,
  -6.40333295e-02f, -7.58635029e-02f, 4.15805988e-02f, -7.47440904e-02f, -2.63316575e-02f, 2.58097891e-02f, 7.43305385e-02f, 3.82544510e-02f, -3.52510368e-03f, 5.73007837e-02f,
  -1.19829290e-02f, -6.78506866e-02f, 6.18049353e-02f, 7.10103512e-02f, 4.04440910e-02f, -6.92853630e-02f, 7.39173219e-02f, 1.47416713e-02f, 6.56500235e-02f, 4.97061796e-02f,
  -7.16684833e-02f, 2.02994477e-02f, -5.61901461e-03f, 8.93358514e-03f, -4.31107879e-02f, 5.05268537e-02f, -5.00765536e-03f, 7.90989026e-02f, -2.09842052e-04f, 9.44034290e-03f,
  -7.51432776e-02f, -3.51508409e-02f, 3.48057784e-02f, 4.11290117e-02f, 6.64565265e-02f, 1.52905174e-02f, 8.99736732e-02f, -7.00966045e-02f, -6.32879231e-03f, -1.37463510e-02f,
  1.04236096e-01f, 6.59290031e-02f, 8.21184590e-02f, 9.07972306e-02f, 3.37304696e-02f, 3.45284492e-02f, -3.69609036e-02f, 6.42975420e-02f, 7.69597739e-02f, 3.10059991e-02f,
  -9.82157290e-02f, 5.51665016e-02f, 6.12580329e-02f, 4.21708785e-02f, 4.84159812e-02f, 2.56463699e-02f, 7.97972083e-02f, -2.00603064e-02f, -9.50868893e-03f, 1.11569680e-01f,
  -5.11694215e-02f, -5.39470762e-02f, -1.02042519e-02f, -5.46555407e-02f, 6.96673617e-02f, 4.54764217e-02f, 2.39241566e-03f, -1.01271413e-01f, -1.37298092e-01f, -4.47285846e-02f,
  -1.37597099e-02f, -4.05691452e-02f, -1.32760391e-01f, 1.33736106e-02f, 5.20773120e-02f, 8.67125690e-02f, -2.70375796e-02f, 8.34147539e-03f, 1.51050817e-02f, 5.84806539e-02f,
  -1.46142310e-02f, -1.85154267e-02f, 3.06390524e-02f, 5.82802743e-02f, 1.49007945e-04f, -6.41402230e-02f, -2.42693145e-02f, 3.69011238e-02f, 3.34343351e-02f, -6.08572289e-02f,
  1.90843157e-02f, -6.12862501e-03f, -5.21131977e-02f, 7.13612288e-02f, -5.22017404e-02f, 6.90369159e-02f, -8.06971565e-02f, -1.71260610e-02f, -1.14831398e-03f, -8.45047683e-02f,
  2.26931889e-02f, -7.29775652e-02f, -1.23455428e-01f, -4.96123396e-02f, 1.83563195e-02f, 2.02278681e-02f, 2.60583088e-02f, 2.10158322e-02f, -7.80821443e-02f, 1.44469161e-02f,
  3.13349478e-02f, -1.01119168e-01f, -8.04100931e-02f, -6.00557476e-02f, 4.65768538e-02f, 3.30401585e-02f, 6.36705607e-02f, -1.85639970e-02f, -7.56711289e-02f, -2.56506056e-02f,
  -8.98502320e-02f, -2.30945908e-02f, -6.96495324e-02f, 4.51687090e-02f, 4.23953272e-02f, -5.72901852e-02f, 1.98876262e-02f, 9.32301804e-02f, 1.04757147e-02f, 2.03261748e-02f,
  -6.66845888e-02f, 7.17212120e-03f, 5.40410019e-02f, -3.87322940e-02f, 5.67117669e-02f, -2.87939981e-02f, -2.89789755e-02f, 9.21395142e-03f, 6.16045035e-02f, 1.21906539e-02f,
  -4.45918292e-02f, -6.60340711e-02f, -2.74261665e-02f, -6.77127540e-02f, -2.54487172e-02f, -1.89638138e-02f, -5.99405430e-02f, -3.30847310e-04f, 1.24352165e-02f, -2.24353988e-02f,
  -1.00771092e-01f, -5.50773144e-02f, -7.32825994e-02f, 3.98846110e-03f, -4.49416563e-02f, -7.35978931e-02f, 3.91406901e-02f, 4.98937964e-02f, -7.83177391e-02f, -7.01215714e-02f,
  -6.53006136e-02f, 6.95772022e-02f, -2.73149889e-02f, -7.06498325e-02f, 2.00235657e-02f, -7.31570274e-03f, -4.16209474e-02f, -2.60209832e-02f, 5.51892668e-02f, 1.15734428e-01f,
  -1.08357124e-01f, 6.59893407e-03f, -1.53873727e-01f, -9.07210782e-02f, 9.94806886e-02f, -1.55530944e-02f, 2.95156380e-04f, -1.00743324e-02f, 5.33989351e-03f, -2.36556698e-02f,
  8.49073753e-02f, -1.20043335e-02f, -4.81613399e-03f, -1.17634706e-01f, -2.17977054e-02f, -1.49851844e-01f, -1.51295707e-01f, -1.33924531e-02f, 2.94874534e-02f, 1.28405079e-01f,
  4.75199446e-02f, -8.76841545e-02f, -1.64216552e-02f, -9.93416607e-02f, -9.01844427e-02f, 4.69243862e-02f, -8.93948972e-02f, 3.56978215e-02f, 8.25408921e-02f, -2.77628321e-02f,
  1.18299812e-01f, 4.66255993e-02f, -8.52635950e-02f, 2.10884288e-02f, -5.60927317e-02f, 1.64585467e-02f, -3.16906385e-02f, -6.62723705e-02f, -1.36704184e-02f, 9.94941406e-03f,
  1.11858454e-02f, 1.01953298e-02f, -1.28094712e-02f, -6.90018162e-02f, -1.21572735e-02f, 1.21926405e-02f, 3.65335448e-03f, -1.21731482e-01f, -6.19880110e-03f, 8.14147443e-02f,
  5.31008020e-02f, 1.30984545e-01f, 5.24233431e-02f, -3.73675786e-02f, 1.49919026e-04f, 1.65525153e-02f, -3.29990499e-02f, 4.56348956e-02f, 5.56601547e-02f, -5.55802658e-02f,
  2.72806063e-02f, -8.95894095e-02f, -4.79364470e-02f, 1.54895112e-02f, -5.63347759e-03f, -2.98778415e-02f, -5.79954199e-02f, -7.14922771e-02f, 6.24061152e-02f, -2.50519179e-02f,
  -2.73157638e-02f, 5.06960973e-02f, -2.90760025e-02f, -1.05141237e-01f, 5.40376231e-02f, -5.15866391e-02f, 2.56177969e-02f, -3.47572081e-02f, 4.34868522e-02f, 3.78022119e-02f,
  -7.42843896e-02f, 1.05096186e-02f, 8.64312127e-02f, -1.34632736e-02f, -1.70307094e-03f, -4.76291589e-02f, -4.21864390e-02f, 2.81144660e-02f, -4.86393757e-02f, 6.81274459e-02f,
  -1.60017293e-02f, -8.92341062e-02f, -1.38312569e-02f, -9.56225023e-02f, -8.87342468e-02f, 2.47897394e-02f, -1.28697287e-02f, -8.81449059e-02f, -9.40152854e-02f, 7.30372816e-02f,
  5.04461899e-02f, 2.43491679e-03f, -3.66359502e-02f, 7.45990053e-02f, -3.86202671e-02f, 9.14286450e-02f, 2.95893475e-02f, 1.86133794e-02f, 2.97340211e-02f, 4.20831218e-02f,
  4.84320298e-02f, -6.24048896e-02f, -7.62055367e-02f, 4.74926829e-03f, 3.03331055e-02f, 7.05169737e-02f, -8.24182332e-02f, -4.75660823e-02f, -1.05158925e-01f, -4.82377596e-02f,
  2.23008059e-02f, 1.14623658e-01f, -4.20463681e-02f, -2.41980143e-03f, -1.66752338e-02f, 8.56854916e-02f, 1.31592840e-01f, -1.16018513e-02f, 1.08618192e-01f, 1.20478012e-01f,
  -4.97098453e-02f, 4.32022698e-02f, -1.43198352e-02f, 8.57553408e-02f, -1.82378590e-02f, 2.20890492e-02f, 1.05187811e-01f, 4.76368852e-02f, 6.44249395e-02f, 2.12117881e-02f,
  -4.58228178e-02f, 2.49624141e-02f, -8.92770439e-02f, -2.45420961e-04f, 1.14365041e-01f, 6.92443848e-02f, 4.18279767e-02f, -1.25772199e-02f, 1.87793188e-02f, -1.13475360e-02f,
  8.69199187e-02f, 8.67475010e-03f, -5.86085021e-02f, -1.01598084e-01f, -5.12462761e-03f, 7.96874836e-02f, -6.15196154e-02f, 1.90265421e-02f, -5.85889257e-03f, 2.69680116e-02f,
  -6.30469397e-02f, -3.93212885e-02f, -5.72734363e-02f, 4.96492088e-02f, 6.50462359e-02f, -5.17496020e-02f, -7.52865449e-02f, 6.30423501e-02f, 1.66284181e-02f, -4.35874052e-02f,
  -2.66731642e-02f, -5.72453067e-02f, -4.19069156e-02f, -3.44287977e-02f, 8.33939016e-02f, 4.78073247e-02f, 3.69412787e-02f, 4.58166376e-02f, 3.43363658e-02f, 6.24312088e-02f,
  -3.47879641e-02f, -2.86966562e-02f, -7.57907853e-02f, -5.09687327e-02f, -2.85430569e-02f, -3.78707028e-03f, -2.52112411e-02f, -9.60563570e-02f, 5.32709621e-02f, -2.34840158e-02f,
  5.48684672e-02f, 2.87987720e-02f, 5.10584563e-02f, -3.83305689e-03f, 3.86603437e-02f, 7.36548286e-03f, 4.12967466e-02f, -9.36946459e-03f, -2.68588010e-02f, 5.96391782e-02f,
  3.73206101e-02f, -2.50521861e-02f, 3.64665166e-02f, -8.42858851e-02f, 6.08594976e-02f, 1.46631536e-03f, -8.89979824e-02f, -1.54830310e-02f, 9.38674714e-03f, 1.29068354e-02f,
  -8.81072804e-02f, -1.34991169e-01f, 8.95878002e-02f, -4.90373075e-02f, -7.82347620e-02f, -9.71758589e-02f, -9.33000892e-02f, 5.21233529e-02f, -6.08684495e-02f, -2.52122562e-02f,
  -2.86994278e-02f, 1.02727050e-02f, 3.29827028e-03f, -1.20832091e-02f, -6.59208000e-02f, -1.03830984e-02f, 3.46116871e-02f, 5.63129857e-02f, 8.00717697e-02f, 1.04449846e-01f,
  8.64896104e-02f, 2.32828930e-02f, 2.03268398e-02f, -4.01899852e-02f, 5.96164651e-02f, -4.71770152e-04f, -2.53430288e-02f, -2.00901199e-02f, -1.81021467e-02f, 8.17609653e-02f,
  -7.36762285e-02f, 2.24135369e-01f, 8.07145387e-02f, -9.38686877e-02f, -1.49300039e-01f, 8.54940638e-02f, 1.17465623e-01f, 1.57912225e-01f, 9.33743194e-02f, 3.70722748e-02f,
  -6.81248158e-02f, 1.82146523e-02f, 1.06084257e-01f, 7.63889402e-02f, 1.80237085e-01f, 1.24070317e-01f, 1.00610472e-01f, -7.98311830e-02f, -1.27114341e-01f, 3.07729281e-02f,
  -5.53396605e-02f, -6.40326962e-02f, -5.45310825e-02f, 3.01401102e-04f, 4.96692285e-02f, 5.11903316e-02f, -1.43104931e-02f, 3.36604975e-02f, 1.97097175e-02f, 3.74262966e-02f,
  2.84491759e-03f, 6.28501773e-02f, -6.12385087e-02f, -1.41648918e-01f, -1.53656706e-01f, 1.08855978e-01f, 8.14266130e-02f, 3.81566249e-02f, 5.39168753e-02f, -8.46653339e-03f,
  -1.01851106e-01f, 6.56516626e-02f, -3.95709313e-02f, -7.17605278e-02f, -3.09932772e-02f, -2.80242115e-02f, -2.41398141e-02f, 5.47165759e-02f, -5.68667874e-02f, -4.20039631e-02f,
  -6.39620796e-02f, -1.29015818e-01f, -1.41245902e-01f, -2.56901495e-02f, -5.44372872e-02f, -9.53516960e-02f, 3.52936089e-02f, -8.36463645e-02f, -1.33881653e-02f, 1.95332635e-02f,
  -6.04417734e-02f, 5.12177125e-02f, 6.12261482e-02f, 2.60577109e-02f, -7.19142929e-02f, 4.97059226e-02f, 7.18011856e-02f, 5.57148866e-02f, 1.11883201e-04f, -8.66971612e-02f,
  4.17269543e-02f, -8.62573981e-02f, 5.97581528e-02f, -8.73751789e-02f, 5.45663908e-02f, -2.12211162e-02f, -3.96627840e-03f, 4.85562347e-02f, 5.73296696e-02f, 6.08093925e-02f,
  7.31960610e-02f, 5.81553951e-02f, -9.12273601e-02f, 6.50146753e-02f, 6.13485724e-02f, -5.02851084e-02f, -1.32341320e-02f, -3.98970842e-02f, -8.24261457e-02f, -5.71885193e-03f,
  -1.61447451e-01f, -6.60258904e-02f, 7.33399019e-02f, 1.06797926e-01f, -4.67779338e-02f, -1.08118430e-02f, -2.91702449e-02f, -2.76268851e-02f, 1.43585792e-02f, -4.07756381e-02f,
  3.09166964e-02f, 3.50815244e-02f, -8.83809030e-02f, 5.79762198e-02f, -6.30007908e-02f, -7.11588413e-02f, 1.45309446e-02f, -4.21847440e-02f, -6.31067157e-02f, -7.87334144e-02f,
  -2.51735803e-02f, -6.92931265e-02f, 7.18392478e-03f, -2.16312241e-02f, -1.61397215e-02f, -1.14864618e-01f, -9.95871946e-02f, 4.03779447e-02f, -1.13947101e-01f, 2.68392693e-02f,
  -7.26770889e-03f, 1.46263704e-01f, 1.51677161e-01f, -9.66564119e-02f, 1.44353658e-01f, 1.77534401e-01f, 2.48320341e-01f, 9.07518491e-02f, -9.14639011e-02f, -1.00571774e-02f,
  5.29661477e-02f, -7.20475093e-02f, -8.85763913e-02f, 2.56571453e-03f, -7.04282746e-02f, -5.48863336e-02f, -1.21139951e-01f, 2.08179257e-03f, -3.99791542e-03f, -1.20817877e-01f,
  -8.29509869e-02f, -8.60489812e-03f, -1.18170135e-01f, -1.18817560e-01f, -1.72639936e-02f, -1.91237807e-01f, -2.56509166e-02f, 5.07884845e-03f, 5.53222261e-02f, -5.03306389e-02f,
  7.49596283e-02f, 2.77190894e-01f, -4.16086614e-02f, 3.97431478e-02f, 1.04879886e-01f, 4.77220863e-02f, -2.78621633e-02f, 5.19820452e-02f, -6.17726613e-03f, -2.68512107e-02f,
  7.27321431e-02f, 5.17789237e-02f, 4.34017070e-02f, 3.35834213e-02f, -1.02107588e-03f, 2.02987306e-02f, -3.38565856e-02f, -5.29974438e-02f, 2.24196096e-03f, 6.29753694e-02f,
  4.37918752e-02f, 2.41651386e-02f, 4.44333367e-02f, 7.80560225e-02f, 6.56970739e-02f, -3.20313536e-02f, 1.34934753e-01f, -6.92069754e-02f, -2.47202404e-02f, -1.47442654e-01f,
  -4.46345061e-02f, 4.85646240e-02f, -7.99689814e-02f, 6.60069659e-02f, -5.67261577e-02f, -3.43387574e-02f, 5.99481575e-02f, 4.58715372e-02f, -2.24265885e-02f, 7.49871954e-02f,
  -5.97043969e-02f, 6.73498660e-02f, -4.20623757e-02f, -7.92429298e-02f, -7.89510980e-02f, 1.94106903e-02f, 3.87556963e-02f, 4.80662324e-02f, -4.22496125e-02f, -7.56964684e-02f,
  7.89458007e-02f, -2.72421762e-02f, 1.56804807e-02f, 4.42187004e-02f, -8.69327970e-03f, 8.91663507e-02f, -2.51340214e-02f, 7.31271580e-02f, 2.57145371e-02f, -7.90704414e-02f,
  -1.75920203e-01f, 2.36451462e-01f, -1.12661175e-01f, -1.02962539e-01f, 5.33587635e-02f, 6.99325576e-02f, 1.12823937e-02f, 2.55766208e-03f, 9.86775607e-02f, -4.01332974e-02f,
  4.77878861e-02f, 7.02758804e-02f, 7.30446130e-02f, -1.68296061e-02f, 2.08877455e-02f, -4.20130454e-02f, 1.37663558e-02f, -1.01923265e-01f, -4.75378707e-02f, 3.93463001e-02f,
  5.99249303e-02f, -2.87968516e-02f, -1.29255831e-01f, -7.20965192e-02f, -1.07690267e-01f, -1.50280818e-01f, 5.97902685e-02f, -1.17346123e-01f, -3.99353430e-02f, -1.03456371e-01f,
  -3.17170955e-02f, -5.93953254e-03f, 3.12329829e-02f, 1.36203811e-01f, 2.11954340e-01f, 1.76218614e-01f, 2.29041487e-01f, 1.50045723e-01f, 1.81428462e-01f, 1.66520312e-01f,
  2.12188825e-01f, 1.26427352e-01f, 1.89928249e-01f, 1.03886582e-01f, 1.01147853e-01f, 1.25130817e-01f, 6.08690567e-02f, -1.76212266e-02f, 5.34085892e-02f, 3.37082408e-02f,
  5.63840121e-02f, 6.60705268e-02f, -1.32786587e-01f, 8.50670338e-02f, 7.85042644e-02f, -1.17738722e-02f, 3.77985686e-02f, 4.78134528e-02f, 1.02233373e-01f, -8.57910737e-02f,
  -1.18504621e-01f, -9.62309241e-02f, -1.15007767e-02f, -4.78822254e-02f, 3.72270285e-03f, -7.87668228e-02f, 6.69227690e-02f, -1.18364714e-01f, -7.09062740e-02f, -1.01946173e-02f,
  3.14729139e-02f, 3.01853521e-03f, 4.52263886e-03f, 1.47006018e-02f, -4.81185280e-02f, -1.99739984e-03f, -9.86454040e-02f, -1.10802606e-01f, -7.11966977e-02f, -7.09187761e-02f,
  7.27825165e-02f, -1.72321126e-02f, 3.97460945e-02f, 3.16560492e-02f, -1.32292574e-02f, 4.10161540e-02f, 1.83015945e-03f, -6.15678355e-02f, 5.27648069e-02f, -6.07165061e-02f,
  6.19760267e-02f, -4.74789850e-02f, 8.04462805e-02f, -1.72859281e-02f, 6.94989637e-02f, -4.16572914e-02f, 6.82686567e-02f, -4.28127497e-03f, 9.65065416e-03f, -3.22032161e-02f,
  2.93296995e-03f, 3.60916108e-02f, 7.54863843e-02f, -6.11815937e-02f, 5.23784086e-02f, 3.19728889e-02f, -6.46291599e-02f, 3.10601555e-02f, -1.91626605e-02f, 3.65797319e-02f,
  1.47610158e-02f, -2.70456169e-02f, -5.40404581e-02f, -1.39516126e-03f, 6.49263710e-02f, 3.41627896e-02f, -1.66517794e-02f, -6.79196641e-02f, -3.42617594e-02f, -6.46247119e-02f,
  8.30527693e-02f, -4.98784531e-04f, 7.24888667e-02f, 5.61764687e-02f, -3.02680749e-02f, -6.99231774e-02f, 7.26441666e-02f, 2.83887470e-03f, 4.60846908e-02f, 4.93898466e-02f,
  -3.75958532e-02f, -3.38752866e-02f, 5.26300408e-02f, -3.57188806e-02f, 1.28304027e-02f, 5.76057658e-02f, -4.18438623e-03f, 1.42071219e-02f, 7.26396441e-02f, -9.92946923e-02f,
  5.28071076e-02f, 5.56856813e-03f, -6.26247525e-02f, -4.26849909e-02f, -3.88577655e-02f, 5.89918420e-02f, -6.61064908e-02f, 1.74499974e-02f, 1.08299181e-02f, -1.07739672e-01f,
  -3.60671878e-02f, 1.17144160e-01f, -7.46408403e-02f, -2.90587712e-02f, -1.99956167e-03f, -7.01337755e-02f, -4.40040305e-02f, 1.27455760e-02f, 3.24919112e-02f, 1.69939324e-02f,
  1.16047515e-02f, 9.46764927e-03f, 6.37643337e-02f, -2.02192203e-03f, -3.21919210e-02f, 7.14272037e-02f, -2.60672960e-02f, -2.97807623e-02f, -5.24801463e-02f, 8.88959616e-02f,
  9.30309296e-02f, 4.03752439e-02f, 2.11089011e-02f, 1.13605447e-01f, 2.36365087e-02f, 5.66505231e-02f, 1.00679711e-01f, -6.84321895e-02f, 6.66402560e-03f, 8.04389492e-02f,
  -4.19544354e-02f, 1.23965092e-01f, 9.48928967e-02f, 5.04125245e-02f, -6.85304254e-02f, 1.98758859e-02f, 7.44464919e-02f, 1.12791192e-02f, 7.21571594e-02f, 9.63933393e-02f,
  2.43971087e-02f, 9.91917625e-02f, -1.91138517e-02f, 4.78989631e-02f, -6.49117902e-02f, 1.05202040e-02f, -4.50372770e-02f, -3.28284949e-02f, 8.28780830e-02f, 1.06810555e-01f,
  5.77693060e-02f, 8.81767273e-02f, 3.01701203e-02f, 7.03214183e-02f, -2.02067886e-02f, -1.26202004e-02f, -4.86711301e-02f, 8.30814540e-02f, 7.06339777e-02f, 1.15120113e-01f,
  -4.68601808e-02f, -1.62322801e-02f, -7.75239943e-03f, 4.60683443e-02f, 7.54027953e-03f, -6.70146495e-02f, 6.40653446e-02f, -6.15555272e-02f, 8.66045579e-02f, 1.61506739e-02f,
  9.46699381e-02f, -4.52186801e-02f, -7.30221048e-02f, -6.29764749e-03f, 4.34521139e-02f, 8.14608634e-02f, 4.10362426e-03f, 3.52058969e-02f, -5.47072254e-02f, -1.55129023e-02f,
  -6.68996200e-02f, 8.73079896e-03f, 3.85396779e-02f, 5.21954037e-02f, 2.85222344e-02f, -8.79771709e-02f, 6.89660683e-02f, 6.65975437e-02f, 8.15881714e-02f, -1.34879937e-02f,
  -7.14893192e-02f, 1.40831126e-02f, -3.85959186e-02f, 4.92333993e-02f, 6.45446107e-02f, 5.19656874e-02f, 3.72674270e-03f, -3.59668881e-02f, 6.25607595e-02f, -6.37388509e-03f,
  8.79767835e-02f, 6.20772038e-03f, 8.66186842e-02f, -4.93823066e-02f, 6.72068596e-02f, 4.89986390e-02f, 7.47346729e-02f, -9.42457642e-04f, -6.12768121e-02f, 6.37516752e-03f,
  3.46989073e-02f, -6.38560131e-02f, 3.19947749e-02f, 7.95514658e-02f, -7.07386807e-02f, 5.02951853e-02f, -3.81969996e-02f, 8.70317593e-03f, 1.20425774e-02f, 6.64745122e-02f,
  4.06958535e-02f, 5.68498261e-02f, -1.09403431e-01f, -6.76222844e-03f, -3.19523131e-03f, -1.18843568e-02f, -1.07375115e-01f, -7.33773857e-02f, 6.16170652e-02f, -1.88828055e-02f,
  -6.46352991e-02f, 5.35638258e-03f, -3.30996774e-02f, 3.27479579e-02f, 3.35125602e-04f, 3.86913866e-02f, -1.21910922e-01f, -9.08381492e-02f, -1.30906165e-01f, -6.24025241e-02f,
  5.75876758e-02f, 2.50717755e-02f, 2.55346764e-02f, -1.62677784e-02f, 7.29177520e-02f, 1.03794560e-01f, -4.37063910e-02f, -4.30748127e-02f, -1.92898717e-02f, 5.89242787e-04f,
  9.75676104e-02f, -5.97290248e-02f, -9.86350775e-02f, -1.13249876e-01f, -9.68562812e-02f, -1.48982815e-02f, 1.06668621e-02f, -9.01877657e-02f, -1.01427630e-01f, -8.28396380e-02f,
  3.73496525e-02f, 4.14522290e-02f, -2.05642171e-02f, 2.42702104e-02f, 6.51928931e-02f, 3.67670581e-02f, 1.22303208e-02f, -7.60970861e-02f, -8.70531350e-02f, -1.54020004e-02f,
  -1.20921306e-01f, -4.36649163e-04f, -8.06659684e-02f, 1.43986964e-03f, 2.20110430e-03f, -6.85754791e-02f, 3.74701130e-03f, -2.69680806e-02f, -1.34143382e-02f, 3.82400453e-02f,
  -8.09752718e-02f, 3.45613286e-02f, -2.80246735e-02f, -1.67550407e-02f, 2.98844669e-02f, -3.39211337e-02f, -7.50425877e-03f, -4.23685722e-02f, -5.13465665e-02f, 6.08773017e-03f,
  -5.01806997e-02f, -3.95481586e-02f, -3.98400389e-02f, 9.11701396e-02f, 5.14192041e-03f, 9.18777101e-03f, -3.84675674e-02f, 2.82202382e-02f, 1.48609513e-02f, 6.70239478e-02f,
  3.30968127e-02f, 9.11646150e-03f, 3.19101661e-02f, -1.37931826e-02f, -9.22093391e-02f, 6.42579868e-02f, -1.81998499e-02f, -2.80191507e-02f, 7.14053735e-02f, 4.59765717e-02f,
  2.70908594e-01f, -1.39643177e-01f, 7.30789006e-02f, -4.07217667e-02f, 8.25394876e-03f, 1.52288633e-03f, -5.25166467e-02f, 1.94730815e-02f, -9.13225785e-02f, 3.87373976e-02f,
  -9.09411684e-02f, 2.98209060e-02f, 1.05504885e-01f, 2.37124655e-02f, 1.43795609e-02f, 4.86190617e-02f, 7.54357278e-02f, -1.12102926e-02f, -8.78324211e-02f, 9.69469696e-02f,
  8.32560360e-02f, 3.17866318e-02f, -1.23597328e-02f, -5.47347739e-02f, -3.89409773e-02f, -2.16992293e-02f, 3.39767858e-02f, 5.41427992e-02f, -6.49248436e-02f, 1.48859605e-01f,
  -1.53600991e-01f, -7.71332532e-02f, 7.03575760e-02f, -1.86952353e-02f, 7.04581887e-02f, 3.68115008e-02f, 6.10213093e-02f, -3.96394432e-02f, -4.82706800e-02f, 7.95987323e-02f,
  -1.79592110e-02f, 4.22493666e-02f, -2.50584614e-02f, 4.14910167e-02f, -5.08007631e-02f, 6.57499135e-02f, 6.68264329e-02f, 4.46853489e-02f, -4.44313921e-02f, 6.89010248e-02f,
  2.43103690e-02f, 2.60186698e-02f, -9.34026986e-02f, -8.92921016e-02f, 1.10298712e-02f, 1.85359120e-02f, -7.16049923e-03f, 8.19442868e-02f, 2.10322961e-02f, 1.67088091e-01f,
  2.66016275e-01f, -1.32098332e-01f, 8.89795870e-02f, -1.65674482e-02f, -3.18363979e-02f, -1.25667443e-02f, 2.03316938e-02f, -4.06056345e-02f, 7.10907253e-03f, -6.01895079e-02f,
  -8.04158747e-02f, -8.18643644e-02f, 8.27453956e-02f, -5.81435822e-02f, 5.32544442e-02f, -6.72506460e-04f, 2.49963682e-02f, -1.32246353e-02f, -3.79491709e-02f, -7.61361197e-02f,
  -6.73162714e-02f, 9.12928209e-02f, -3.17843519e-02f, -8.64770636e-02f, 1.00120902e-03f, -3.76297608e-02f, 1.41075831e-02f, -5.89445718e-02f, 4.40325737e-02f, -1.65380128e-02f,
  2.70564128e-02f, 9.37250629e-02f, -9.63357091e-03f, 2.84290034e-03f, -1.29927434e-02f, 6.17225915e-02f, -3.40004787e-02f, -2.71307379e-02f, 4.57676016e-02f, 6.38349652e-02f,
  1.14449980e-02f, -7.70680904e-02f, 4.66415659e-02f, 6.31395206e-02f, -1.77465845e-02f, 3.93284112e-02f, 8.64325762e-02f, 6.38137534e-02f, 4.56884466e-02f, 5.10865264e-02f,
  -2.62248982e-02f, 5.11242598e-02f, 1.83320940e-02f, 6.55731782e-02f, -4.86295633e-02f, 2.77147302e-03f, -3.85525357e-03f, -3.08666937e-02f, 3.90018970e-02f, -6.64265603e-02f,
  3.24768759e-02f, -1.03733242e-01f, 7.42471889e-02f, -6.49160296e-02f, 2.29123104e-02f, -2.36879550e-02f, 1.16174798e-02f, -5.26553020e-02f, -3.44700143e-02f, -9.30367503e-03f,
  8.17717835e-02f, 2.83806827e-02f, -5.81732206e-02f, 8.13470781e-02f, 7.96499550e-02f, -7.11605847e-02f, 6.23300672e-02f, 4.61834669e-02f, -7.80726373e-02f, 4.00347225e-02f,
  3.54218408e-02f, 4.82843742e-02f, -3.99168804e-02f, 4.56075743e-02f, 8.49350542e-02f, 8.54213163e-02f, 9.15448293e-02f, 9.71448943e-02f, 2.03538518e-02f, -4.63763028e-02f,
  1.36386186e-01f, 9.37235951e-02f, 9.37146768e-02f, 4.48168516e-02f, 5.17578572e-02f, 5.58054410e-02f, 7.24144503e-02f, -6.65910468e-02f, -6.11960888e-02f, 1.55546116e-02f,
  1.47389576e-01f, 1.12093464e-01f, 9.12867785e-02f, -3.68300527e-02f, 2.58583631e-02f, -4.85328399e-02f, -1.75844561e-02f, 3.46137723e-03f, -2.62333862e-02f, -5.11278473e-02f,
  -4.85549383e-02f, -4.80100624e-02f, 3.14905792e-02f, -8.89561977e-03f, 1.08619846e-01f, 8.98693576e-02f, -5.40264770e-02f, 6.16705231e-03f, -4.34086956e-02f, 9.92392972e-02f,
  -1.43902339e-02f, 1.48500279e-01f, -5.34649938e-02f, -7.95164704e-02f, -1.93029642e-02f, -2.68052388e-02f, 8.31638649e-03f, 2.60102898e-02f, 8.45000520e-02f, -2.14065751e-03f,
  -2.76102498e-02f, 7.46808723e-02f, -1.76875008e-04f, -6.83086738e-02f, -9.48937908e-02f, -1.03004679e-01f, 3.53310443e-02f, 3.01144691e-03f, -1.09435305e-01f, -2.27451157e-02f,
  -4.88216281e-02f, 1.18218258e-01f, 5.74399792e-02f, -5.28101772e-02f, -4.30955552e-02f, 5.44202700e-02f, 9.39743519e-02f, -1.94800366e-02f, 2.47297976e-02f, 3.92073840e-02f,
  -2.96297856e-03f, -2.82258671e-02f, 6.35377839e-02f, -9.03319940e-02f, -8.76850560e-02f, 1.21621331e-02f, -3.90054919e-02f, -8.84936824e-02f, 3.33865024e-02f, 5.73198078e-03f,
  -9.45843011e-02f, 4.40612771e-02f, 2.71675497e-04f, -6.67560101e-02f, 1.08050909e-02f, -5.10040186e-02f, -8.43356624e-02f, 7.91102275e-03f, -8.51730704e-02f, -1.00149401e-01f,
  6.33224696e-02f, -2.32846532e-02f, -3.80066484e-02f, 6.76579326e-02f, -1.68379322e-02f, 3.10502537e-02f, -2.61254869e-02f, -3.16899642e-02f, 1.21295741e-02f, -4.76814732e-02f,
  -6.00137152e-02f, -9.77933183e-02f, 6.11126237e-02f, 7.05171227e-02f, 8.99302736e-02f, -3.66182961e-02f, 8.61772150e-02f, 2.97252815e-02f, 8.80297497e-02f, -4.26912792e-02f,
  6.99118897e-02f, 8.58915225e-03f, -3.07668820e-02f, -2.21648384e-02f, -3.65148298e-03f, -9.66182351e-02f, -7.61796013e-02f, -7.08199665e-02f, -8.94297566e-03f, 2.07073577e-02f,
  -5.55713139e-02f, -3.30338627e-02f, -5.09022214e-02f, -1.21991798e-01f, -5.54470010e-02f, -2.46558394e-02f, -7.58138001e-02f, -1.66838877e-02f, -5.36652803e-02f, -4.65765037e-02f,
  1.13208853e-01f, -1.46548510e-01f, -5.35876863e-02f, 2.68525649e-02f, -8.70107263e-02f, -1.71320185e-01f, -3.03374138e-02f, 1.49290776e-02f, 5.22102453e-02f, 2.97259241e-02f,
  4.03328147e-03f, 1.10535279e-01f, -2.53940690e-02f, 8.03216547e-03f, 1.25505641e-01f, -8.86228532e-02f, -5.99941947e-02f, 1.43365160e-01f, 6.67069703e-02f, 9.22468901e-02f,
  -8.21229890e-02f, 5.85534945e-02f, 8.16096887e-02f, 2.17747018e-02f, -2.76756715e-02f, 1.89042017e-02f, 6.92695826e-02f, -1.00068152e-01f, 1.88537315e-03f, 5.78149669e-02f,
  -1.40123129e-01f, 1.60657559e-02f, 2.57255528e-02f, 5.39834462e-02f, 9.65610743e-02f, 9.44544151e-02f, 8.58003497e-02f, 1.24857999e-01f, -4.63472381e-02f, 8.34105313e-02f,
  -2.87620034e-02f, -1.33911171e-03f, -5.03237247e-02f, -5.10531254e-02f, 5.32147586e-02f, 1.00504057e-02f, -1.16502363e-02f, -1.82100181e-02f, 1.30071752e-02f, 4.09826227e-02f,
  -6.35759756e-02f, 4.38446663e-02f, 6.30162358e-02f, -3.11199408e-02f, -3.54091749e-02f, -9.53389704e-03f, -2.23512389e-02f, -4.11280878e-02f, -5.62307537e-02f, 9.06154886e-02f,
  -1.55363427e-02f, -8.78709480e-02f, 1.22781871e-02f, 2.59413570e-02f, -6.86714575e-02f, 6.02397285e-02f, 4.76290844e-02f, -7.16746375e-02f, 1.01371417e-02f, -9.32065547e-02f,
  -2.24123672e-02f, 3.84881422e-02f, 4.35922481e-02f, 6.55176640e-02f, -2.73718070e-02f, -4.31266204e-02f, -2.90533509e-02f, -5.26778288e-02f, -3.91731448e-02f, 1.21654919e-03f,
  -1.94536168e-02f, 9.67125408e-03f, -8.19061697e-02f, -1.50183616e-02f, 4.05296236e-02f, 5.53323142e-03f, -6.84892386e-02f, -1.25900498e-02f, 4.71690036e-02f, -4.79060300e-02f,
  -1.16913863e-01f, 1.50867745e-01f, 4.69249412e-02f, 1.34800449e-01f, -9.58445016e-03f, 1.04410388e-01f, 7.63235567e-03f, 6.59122765e-02f, 7.40812272e-02f, 4.59875241e-02f,
  -6.93097487e-02f, 3.18711773e-02f, 3.02851368e-02f, 7.24822059e-02f, 3.38007994e-02f, 6.66770991e-03f, 6.31986186e-02f, 1.00074023e-01f, -3.75555945e-03f, 3.48126329e-02f,
  -5.21999225e-02f, -7.23245740e-02f, -2.09931508e-02f, 3.43667120e-02f, 1.99275576e-02f, -4.81309891e-02f, 1.25469994e-02f, -1.63082853e-02f, 5.68206329e-03f, -1.05592750e-01f,
  -3.33021879e-01f, 2.26897709e-02f, 1.61614686e-01f, -2.32740164e-01f, -2.29982603e-02f, -5.52637279e-02f, 5.48088066e-02f, 2.69323587e-02f, -6.60478100e-02f, -2.69298144e-02f,
  -2.61636004e-02f, 4.47649322e-02f, -4.18299660e-02f, 5.26583418e-02f, -6.06106874e-03f, 3.85698713e-02f, -3.05989180e-02f, -8.73662308e-02f, 1.28466003e-02f, -9.76260006e-02f,
  -6.45773560e-02f, -1.23968288e-01f, -6.08508252e-02f, -1.05901986e-01f, -8.00660066e-03f, -3.03059630e-02f, 5.30968010e-02f, 4.23525721e-02f, -2.73431391e-02f, -1.05973259e-01f,
  2.81175345e-01f, -8.27056766e-02f, -9.87229124e-03f, 1.08509362e-02f, 5.39282225e-02f, -2.48622540e-02f, -8.23649615e-02f, 8.61248970e-02f, -1.05263211e-01f, -4.06897627e-02f,
  -2.57572643e-02f, 2.19014008e-02f, 7.88794644e-03f, -7.31188878e-02f, -8.82875845e-02f, 7.01139774e-03f, 1.57958400e-02f, 5.12657426e-02f, 1.73549186e-02f, -6.53896332e-02f,
  -7.60674328e-02f, -5.63765951e-02f, 6.52340949e-02f, 3.42811607e-02f, 5.80845997e-02f, -3.00723221e-02f, 1.15083762e-01f, 6.48282245e-02f, 2.44992170e-02f, 4.04070131e-02f,
  -6.22568652e-02f, 3.94244865e-02f, -6.16613775e-02f, 3.34586836e-02f, 3.67739573e-02f, 4.07108255e-02f, -7.32610654e-03f, -6.99945763e-02f, 7.15927035e-02f, -2.35335138e-02f,
  -5.42246290e-02f, 1.15654441e-02f, -5.90704717e-02f, 6.58653826e-02f, 4.42035235e-02f, 7.46417865e-02f, -4.79781739e-02f, -8.19153786e-02f, 4.45955321e-02f, 4.28922884e-02f,
  -5.37629016e-02f, -3.31497332e-03f, 8.80549196e-03f, -6.96441904e-02f, -4.78310660e-02f, 5.03388140e-03f, -5.24742305e-02f, -2.90408134e-02f, 1.71433073e-02f, -1.67696259e-03f,
  1.11933269e-01f, 3.34120020e-02f, -6.28425777e-02f, 2.01684553e-02f, 3.06690615e-02f, 6.16071448e-02f, 4.77906466e-02f, -4.85103726e-02f, 3.49801295e-02f, -6.15041703e-02f,
  2.73167863e-02f, 8.13139975e-02f, 7.07218563e-03f, -6.36574402e-02f, 6.78920448e-02f, -3.02795339e-02f, -1.03292108e-01f, 1.30598294e-03f, -5.92341423e-02f, -1.26356690e-03f,
  -9.05650854e-02f, -9.59403962e-02f, -4.65211309e-02f, -7.07330939e-04f, 1.20363990e-02f, 2.32956223e-02f, 1.62231252e-01f, 3.57555635e-02f, 4.46624272e-02f, 7.88200572e-02f,
  9.30874720e-02f, -4.15564738e-02f, -3.48090543e-03f, 1.40380442e-01f, 4.99500036e-02f, 2.31248140e-02f, -6.51194304e-02f, -8.55450332e-02f, -6.22035563e-03f, 5.48315160e-02f,
  -1.16897188e-01f, 2.79724095e-02f, -3.21430899e-03f, -1.17660388e-01f, -1.31023079e-01f, -5.99963851e-02f, 1.34581000e-01f, -4.20410261e-02f, 7.98946619e-02f, 8.91400129e-02f,
  1.19920716e-01f, 6.90873340e-02f, -2.73083034e-03f, 8.48166496e-02f, 1.34596258e-01f, 1.32081002e-01f, 6.82807416e-02f, 2.20107893e-03f, 1.23062290e-01f, 6.58830106e-02f,
  5.12553900e-02f, -4.64036055e-02f, -5.71545074e-03f, -1.24240834e-02f, -4.84668240e-02f, -4.91342768e-02f, 7.80392531e-03f, -1.51129542e-02f, 1.30873173e-02f, -5.47806434e-02f,
  3.93477306e-02f, -2.04665139e-02f, -3.69773433e-02f, 3.19705419e-02f, -3.71228531e-02f, -4.56837453e-02f, -4.86388840e-02f, 3.36616337e-02f, 4.30888422e-02f, -1.11627139e-01f,
  -1.98085569e-02f, -1.23605300e-02f, -3.46433148e-02f, -1.35395855e-01f, 1.33000994e-02f, -3.41954045e-02f, -7.32811913e-02f, 8.25723261e-02f, -3.14218961e-02f, 5.92563525e-02f,
  -9.72304642e-02f, -3.17609794e-02f, -9.12832841e-02f, -5.80426538e-03f, 2.14104690e-02f, 4.17676494e-02f, -3.55282128e-02f, 3.54006924e-02f, -1.73718873e-02f, -8.18538759e-03f,
  5.94416447e-02f, 6.32772222e-02f, -6.10183999e-02f, 1.93060692e-02f, 1.49818901e-02f, -2.29872242e-02f, 9.08689499e-02f, 3.64010520e-02f, -3.34878033e-03f, -6.74738884e-02f,
  -6.44751415e-02f, 7.37234131e-02f, 5.03626764e-02f, -1.48511240e-02f, -3.31900343e-02f, 3.19647565e-02f, -4.15237993e-02f, 6.49812371e-02f, 1.47610316e-02f, -1.60546135e-02f,
  -3.19461115e-02f, -9.57897082e-02f, -2.94818170e-03f, -4.02597860e-02f, 1.21773094e-01f, 8.27995315e-02f, -7.97277540e-02f, 7.23028183e-02f, -4.10181507e-02f, 4.22152877e-02f,
  -7.93536939e-03f, 3.97089161e-02f, -9.90330726e-02f, -5.83357585e-04f, 5.67623712e-02f, -1.76215004e-02f, 4.99934070e-02f, 8.45764875e-02f, 2.44294126e-02f, -1.70436893e-02f,
  1.05980426e-01f, 9.46146920e-02f, 7.22989738e-02f, 1.96278319e-02f, -4.51203622e-02f, 3.58282067e-02f, 1.12432703e-01f, 6.72320575e-02f, -1.07314643e-02f, 1.57747671e-01f,
  1.42641485e-01f, -7.62724206e-02f, -8.39068741e-02f, -1.64220706e-02f, -1.54269850e-02f, -6.92162812e-02f, -2.84513161e-02f, 2.42933240e-02f, -1.09572429e-02f, -2.98824534e-03f,
  -7.39583075e-02f, -2.42665457e-03f, -5.06852232e-02f, 5.26120067e-02f, 8.37809518e-02f, -4.60400134e-02f, -2.17308588e-02f, -1.06124215e-01f, -4.00679298e-02f, -9.53941047e-02f,
  5.59266247e-02f, -1.00420870e-01f, -7.65930563e-02f, -1.03991985e-01f, -7.59583712e-02f, -1.52923819e-02f, -1.39687032e-01f, -1.28693298e-01f, -5.56406789e-02f, -6.05741553e-02f,
  -6.65730983e-02f, -3.49564143e-02f, 4.13897559e-02f, 4.16536108e-02f, 5.90821169e-02f, -1.93549357e-02f, -4.43196259e-02f, 7.26817697e-02f, -2.24031191e-02f, -7.52729103e-02f,
  4.39899601e-02f, 7.38065615e-02f, 6.74958229e-02f, -7.60363862e-02f, 8.40258878e-03f, -3.22443172e-02f, 4.46453318e-02f, -7.75057822e-02f, 1.30118988e-02f, 1.25159305e-02f,
  -2.61467826e-02f, 3.81440409e-02f, -5.46537973e-02f, -8.26911181e-02f, 3.06337848e-02f, 8.79902020e-02f, 3.36389765e-02f, -2.80442107e-02f, 5.93638653e-03f, -8.16508457e-02f,
  9.03161336e-03f, -6.35466576e-02f, 1.35781979e-02f, 7.91123807e-02f, 1.79849528e-02f, -6.82203025e-02f, -3.51803005e-02f, -6.27516909e-03f, -7.11147562e-02f, 6.59085140e-02f,
  -2.97882874e-02f, 4.91207056e-02f, 1.89295709e-02f, 7.28643611e-02f, -4.42269184e-02f, -6.40370324e-02f, -1.02035906e-02f, 2.00337730e-02f, 6.63114362e-04f, -3.16983201e-02f,
  4.72638197e-02f, -1.06843807e-01f, -9.51764509e-02f, 4.23167413e-03f, -2.89211143e-02f, -1.02679834e-01f, 1.21154552e-02f, -4.44458723e-02f, -1.02151021e-01f, 3.35763879e-02f,
  9.06457305e-02f, 7.71541670e-02f, 2.47822478e-02f, -4.03198064e-05f, 1.26094813e-03f, -6.79344777e-03f, 4.88944836e-02f, 6.51960820e-02f, -3.70268710e-02f, -6.52509406e-02f,
  -7.42313415e-02f, -4.60616685e-02f, -7.74441585e-02f, 7.88559858e-03f, 3.41139100e-02f, 5.84442466e-02f, 1.91239510e-02f, -4.81186286e-02f, -6.23592399e-02f, 2.32512318e-02f,
  -6.93392605e-02f, 8.80073979e-02f, -1.36634929e-03f, 9.31245536e-02f, 6.62378222e-02f, 2.12947316e-02f, 7.53663480e-02f, 4.71482836e-02f, 1.08824698e-02f, 9.63992923e-02f,
  -1.56099930e-01f, 2.00824007e-01f, -1.79719739e-02f, 1.15064211e-01f, -1.16161354e-01f, -1.31339297e-01f, -1.06071286e-01f, -1.30183652e-01f, -4.18282412e-02f, 5.22302389e-02f,
  1.13119081e-01f, -6.15250468e-02f, -9.72072259e-02f, -1.30865678e-01f, -1.53607979e-01f, -2.24872362e-02f, 3.59607302e-02f, -2.66753435e-01f, -3.31779808e-01f, -3.36049318e-01f,
  -1.75801441e-01f, -1.47143662e-01f, -2.17350677e-01f, -3.78091522e-02f, 1.47451714e-01f, -3.30052227e-02f, 2.55147312e-02f, -1.13839982e-02f, 2.96802148e-02f, 2.97820996e-02f,
  1.03021711e-01f, -6.27594069e-02f, -9.99483373e-03f, -1.15071245e-01f, 1.04456954e-01f, -5.93129247e-02f, -8.75882059e-02f, -1.25117917e-02f, 7.50753731e-02f, -8.82266928e-03f,
  5.04682260e-03f, -7.62497410e-02f, -5.58599792e-02f, 9.42711998e-03f, 4.73749489e-02f, -8.02024156e-02f, -3.30795255e-03f, -8.18464458e-02f, -7.20687537e-03f, -2.05797236e-02f,
  2.22293735e-02f, -2.09331941e-02f, 8.23185369e-02f, 3.40462029e-02f, 3.67319211e-04f, -6.23637810e-02f, 1.31823048e-01f, -2.16511060e-02f, 5.46541885e-02f, 1.77881315e-01f,
  4.53042798e-02f, 1.42028779e-02f, 4.74031866e-02f, 4.73268293e-02f, -6.95925811e-03f, 9.82833728e-02f, -4.26809601e-02f, 3.04516349e-02f, -2.25616507e-02f, -4.97120433e-02f,
  4.70739529e-02f, 9.25645232e-02f, -4.75260057e-02f, 7.47428685e-02f, 2.23802701e-02f, -3.15049589e-02f, -3.34703736e-02f, 6.90521523e-02f, -5.25212996e-02f, 5.51202036e-02f,
  -7.27540776e-02f, -2.67409184e-03f, 7.03869760e-02f, -1.46070933e-02f, 5.93516119e-02f, 8.28694478e-02f, -2.50310171e-02f, -4.73078564e-02f, -1.02216661e-01f, -1.12208217e-01f,
  1.51409268e-01f, -1.37516066e-01f, 1.34563565e-01f, -5.11437580e-02f, -4.06023907e-03f, 1.93787254e-02f, 9.19153020e-02f, 7.49524534e-02f, -6.74192309e-02f, 3.82676385e-02f,
  -7.35026225e-02f, 6.92313910e-02f, 5.95168136e-02f, 1.14058387e-02f, -9.61411297e-02f, -5.75685352e-02f, 1.21284820e-01f, -2.42399536e-02f, -7.79027119e-02f, 1.15611143e-01f,
  1.38129085e-01f, -6.37170523e-02f, 4.56468835e-02f, 7.66105130e-02f, -8.65895767e-03f, -3.65526900e-02f, 4.13606726e-02f, 8.08245465e-02f, -6.69037625e-02f, 1.38880759e-01f,
  1.80165336e-01f, 2.72121727e-02f, -2.28960812e-01f, -4.73745540e-02f, 3.00283805e-02f, -1.38434365e-01f, 5.93978912e-03f, -9.85017791e-02f, 2.25247126e-02f, 3.70408036e-02f,
  6.28893301e-02f, 4.58473563e-02f, 7.53833493e-03f, -8.87229443e-02f, -1.96618568e-02f, -1.29088253e-01f, -1.30990431e-01f, -1.88001879e-02f, -1.04747154e-02f, -5.31862443e-03f,
  3.47359814e-02f, -1.77958962e-02f, -4.68286872e-02f, 2.60602627e-02f, -3.81535143e-02f, -7.13504404e-02f, -1.09741129e-01f, 6.14570826e-02f, -1.89303942e-02f, 1.31470319e-02f,
  -1.04135267e-01f, 4.18760702e-02f, -7.73195550e-02f, 1.97302941e-02f, 2.49967501e-02f, -7.26327226e-02f, 5.91484364e-03f, -3.44531685e-02f, 4.47870195e-02f, -1.49251288e-02f,
  -8.06758776e-02f, 1.76101383e-02f, 6.60077631e-02f, -1.24308793e-02f, -2.28403304e-02f, 4.49000895e-02f, -6.63449988e-02f, -1.04206868e-01f, 3.12651545e-02f, -2.53679845e-02f,
  3.53859067e-02f, -7.20605031e-02f, -1.17089815e-01f, -7.27095231e-02f, 2.36114655e-02f, -2.08429433e-02f, -7.86527991e-03f, -2.02404298e-02f, -6.30539283e-02f, 2.61577778e-02f,
  -3.46003436e-02f, 9.17837769e-03f, 2.85623893e-02f, -4.13416028e-02f, 3.15541402e-02f, 2.82419641e-02f, -8.42892155e-02f, 1.04779854e-01f, -6.22178204e-02f, -4.09580730e-02f,
  -5.84477559e-02f, 6.64575994e-02f, 4.63217050e-02f, -6.96928054e-02f, 1.68672856e-03f, -4.10689525e-02f, -1.36807607e-02f, 8.15296471e-02f, -6.69818837e-04f, -3.86575945e-02f,
  2.08176430e-02f, -5.03905006e-02f, -6.26378953e-02f, 4.37739119e-02f, -1.83048025e-02f, -6.22055680e-03f, -3.46811898e-02f, -4.46619559e-03f, -3.90598364e-02f, -8.38526860e-02f,
  9.06361416e-02f, -1.59946322e-01f, -2.20326390e-02f, -2.70931646e-02f, 3.68105359e-02f, 3.67634445e-02f, -4.87517156e-02f, 2.60310844e-02f, -8.06976929e-02f, -5.53128123e-02f,
  6.26307130e-02f, 7.07050040e-02f, 8.42749700e-02f, 2.12117601e-02f, 2.51535065e-02f, -6.69225901e-02f, 3.40688862e-02f, -5.53534701e-02f, 7.83952139e-03f, -6.13673069e-02f,
  -1.78599078e-02f, 1.79837495e-02f, -4.02190126e-02f, -6.87089637e-02f, -7.36514553e-02f, -2.50017457e-02f, -4.28512022e-02f, -4.43794243e-02f, -5.66227585e-02f, 1.08259246e-01f,
  -6.47395523e-03f, 1.17435448e-01f, -6.54180571e-02f, -1.81313716e-02f, 6.14018030e-02f, -4.42375243e-02f, -1.26138762e-01f, -1.28742546e-01f, 7.96456169e-03f, 2.58469954e-02f,
  1.41683459e-01f, 1.40486836e-01f, 2.57041287e-02f, 7.33037591e-02f, -1.28196329e-01f, 3.60870622e-02f, -8.04110765e-02f, -1.89410374e-01f, -1.52504548e-01f, -3.67599763e-02f,
  1.02073900e-01f, 5.93690760e-02f, -2.45337822e-02f, -8.27110559e-02f, 8.85504335e-02f, -1.61898229e-03f, 5.39298356e-02f, 3.23445089e-02f, -5.96131897e-03f, 1.51867598e-01f,
  1.64724767e-01f, -1.86269179e-01f, -7.38320872e-02f, -6.96422756e-02f, 5.35780117e-02f, 2.70248689e-02f, 1.38780922e-02f, -9.37967449e-02f, -7.30984807e-02f, -4.47855592e-02f,
  5.16747944e-02f, -3.43847387e-02f, 5.30333072e-03f, 3.23764980e-02f, -6.09934740e-02f, -9.66450945e-02f, -8.04003999e-02f, -1.28330454e-01f, -1.33455738e-01f, 8.92211590e-03f,
  -7.45163346e-03f, -4.18900959e-02f, -6.36674985e-02f, -5.01389988e-02f, -1.34722337e-01f, -6.45283237e-02f, -3.47478576e-02f, -1.50646186e-02f, -1.54253811e-01f, 4.92243916e-02f,
  1.59014389e-02f, -6.44956157e-02f, 3.70816179e-02f, -3.57170068e-02f, 6.42868206e-02f, 6.40032887e-02f, 4.92385700e-02f, 8.92005190e-02f, -8.08572173e-02f, 7.42579624e-02f,
  3.33651192e-02f, -4.07100208e-02f, 9.48298126e-02f, -3.71771455e-02f, 7.14200884e-02f, -7.85744283e-04f, 5.00287265e-02f, -2.06011571e-02f, 2.34715883e-02f, 8.89457986e-02f,
  -4.92114648e-02f, -9.12395790e-02f, -2.37463191e-02f, -5.15394695e-02f, -2.21889559e-02f, -8.41775462e-02f, 6.12664483e-02f, -5.49862981e-02f, 7.85684213e-02f, 6.72536641e-02f,
  3.09965760e-01f, -7.24967197e-02f, -9.35776066e-03f, -7.57187605e-02f, 9.29649977e-05f, -6.88942242e-03f, 8.45437795e-02f, 1.99602079e-02f, 5.66602461e-02f, -3.49537991e-02f,
  -1.31755993e-02f, -4.88881394e-02f, 1.09326147e-01f, -7.99622089e-02f, -4.05576825e-02f, -7.94833153e-02f, 5.80638386e-02f, -7.48359412e-02f, -5.39561771e-02f, -6.49496913e-02f,
  9.59548578e-02f, 5.87088354e-02f, -6.23568669e-02f, 7.14408085e-02f, 2.49290392e-02f, 2.40607485e-02f, 8.28069746e-02f, 3.50627042e-02f, -4.49135415e-02f, 1.74764544e-01f,
  3.63913067e-02f, -1.37319252e-01f, 8.24501514e-02f, -4.93684895e-02f, -1.07492216e-01f, -5.62773347e-02f, -2.09425427e-02f, -5.42396717e-02f, 1.40179077e-03f, -4.59870286e-02f,
  1.15009015e-02f, 2.68330779e-02f, 9.17497724e-02f, 3.07033695e-02f, 1.05707556e-01f, -5.07611036e-02f, -6.11980371e-02f, 1.66977029e-02f, 9.98654142e-02f, -2.58086938e-02f,
  -8.31319913e-02f, 1.06918272e-02f, 2.94286944e-02f, -4.70278822e-02f, -9.60792229e-02f, 1.38281379e-04f, 8.55953097e-02f, -1.81646012e-02f, -5.35609946e-03f, 7.93920457e-02f,
  3.09544150e-02f, -4.87614200e-02f, 4.59502302e-02f, 4.32260893e-02f, 3.08941510e-02f, 2.73760743e-02f, -3.64603288e-02f, 3.60056981e-02f, 6.21074922e-02f, -9.88919735e-02f,
  7.50402212e-02f, -6.69033825e-03f, 2.72410735e-02f, -7.51761496e-02f, -1.17711969e-01f, -1.01750018e-02f, 1.67579427e-02f, 3.97296473e-02f, 8.04641843e-03f, 5.90743087e-02f,
  6.36877120e-02f, -5.52675501e-02f, 7.54527673e-02f, -3.10312752e-02f, 6.53909072e-02f, 1.57683104e-01f, -2.50521041e-02f, 7.74954334e-02f, 7.64421076e-02f, 1.40543543e-02f,
  -1.21631436e-02f, 1.09366626e-01f, 2.89776307e-02f, 6.83600232e-02f, -1.54250581e-02f, -7.26996397e-04f, 4.26086672e-02f, 1.52849806e-02f, -8.66040140e-02f, 3.55809219e-02f,
  -2.70118620e-02f, 1.80920791e-02f, 4.41002622e-02f, -1.92283932e-02f, -1.29522020e-02f, 6.69977278e-04f, -1.37395766e-02f, 4.84435298e-02f, -4.59213136e-03f, -2.13398077e-02f,
  -4.03104797e-02f, 5.39416857e-02f, -2.89981328e-02f, 3.33298370e-03f, -6.20194227e-02f, 5.13047017e-02f, -3.43041420e-02f, 3.63008566e-02f, 7.10215792e-02f, 6.03524484e-02f,
  2.51224171e-02f, 1.02123827e-01f, 7.57678896e-02f, 8.93642083e-02f, -6.88173762e-03f, 4.15182970e-02f, 1.40473014e-02f, -6.27069315e-03f, -1.28786480e-02f, -5.95907532e-02f,
  2.33827867e-02f, -1.37447054e-03f, -3.83331925e-02f, 1.89437754e-02f, -2.23599910e-03f, 7.92976543e-02f, -5.75103983e-02f, 7.39598647e-02f, -5.82811944e-02f, 5.52969947e-02f,
  -2.19889022e-02f, -1.29033215e-02f, 1.23048618e-01f, -2.37365011e-02f, -2.18577273e-02f, 1.98929995e-01f, 1.29823774e-01f, 4.90104333e-02f, 4.04291525e-02f, -2.19805874e-02f,
  -4.70768213e-02f, -1.89015791e-01f, -2.27940395e-01f, -9.75451544e-02f, -3.03964075e-02f, 1.03736119e-02f, 6.09354675e-02f, -2.79052678e-04f, 2.13533733e-02f, -1.48572087e-01f,
  -2.32126862e-02f, -9.89364609e-02f, -1.53890818e-01f, -3.90094183e-02f, -1.09762698e-01f, -1.71892360e-01f, -2.00877160e-01f, -1.96779892e-01f, -2.86121331e-02f, 6.39322773e-02f,
  -1.11138588e-02f, -1.03479527e-01f, -1.25718117e-01f, -7.06839785e-02f, -4.80721518e-02f, -1.03184007e-01f, -2.08961949e-01f, -7.90855885e-02f, -7.05355257e-02f, -1.71394944e-01f,
  -1.37858123e-01f, -7.56195141e-03f, 7.55867288e-02f, -4.96498980e-02f, -1.06395841e-01f, 2.76037268e-02f, 1.17720533e-02f, 5.91823459e-02f, -4.64662053e-02f, 2.20624842e-02f,
  1.86886347e-03f, 1.09006800e-01f, -1.67290512e-02f, -2.99691502e-02f, 1.11448038e-02f, -9.30164941e-03f, 6.66949600e-02f, -7.75730610e-02f, -3.20111625e-02f, -6.30206317e-02f,
  -7.84790143e-02f, -2.33715307e-02f, -9.89797153e-03f, 1.04151643e-03f, 6.66706115e-02f, 1.05092525e-02f, -1.63845811e-02f, 9.93634481e-03f, -1.41320573e-02f, -1.48588732e-01f,
  6.59851450e-03f, 1.81199033e-02f, 9.36905593e-02f, 8.41532722e-02f, 6.42832890e-02f, -8.40272903e-02f, -2.59836912e-02f, -5.97927161e-03f, 5.88244107e-03f, 5.42434789e-02f,
  -3.68973240e-02f, -2.20329557e-02f, 5.93964942e-02f, -3.56518361e-03f, -4.60829437e-02f, -2.50140652e-02f, -7.93447495e-02f, -9.56522524e-02f, -8.99025500e-02f, -9.00153667e-02f,
  -3.27285454e-02f, 4.46554311e-02f, 1.45720253e-02f, -4.59079705e-02f, 1.56761017e-02f, -4.74824682e-02f, 4.40130681e-02f, -1.25799142e-02f, 8.27630535e-02f, -6.52569011e-02f,
  1.51366843e-02f, 6.29328042e-02f, 1.94091685e-02f, -4.21891473e-02f, 4.04305160e-02f, -4.29973565e-03f, 1.49990441e-02f, -1.06015801e-02f, 5.23784645e-02f, 3.10730166e-03f,
  1.31846331e-02f, 3.58464271e-02f, 3.08621582e-02f, -6.28462806e-02f, 7.05115944e-02f, 4.86973021e-03f, -1.05597805e-02f, -1.02049440e-01f, 5.97008802e-02f, -3.26195396e-02f,
  -1.06409386e-01f, -1.52353033e-01f, -1.35601789e-01f, -1.17747495e-02f, -3.31340432e-02f, -5.33755198e-02f, -1.04658701e-01f, -3.66832986e-02f, -1.50333256e-01f, -1.95582166e-01f,
  1.39359325e-01f, -2.06067085e-01f, 1.95084531e-02f, -7.79127106e-02f, 3.35465418e-03f, 1.39434010e-01f, -2.44818702e-02f, 2.06579696e-02f, -8.74871537e-02f, 8.78827181e-03f,
  2.97522824e-02f, 8.18470269e-02f, -4.65998910e-02f, -1.15490705e-02f, 1.89809408e-02f, -4.29020151e-02f, -3.77876237e-02f, 1.10871322e-01f, 1.61605850e-01f, -1.55666855e-03f,
  2.38881111e-02f, 2.55555343e-02f, 3.99136264e-03f, -9.81031060e-02f, -1.78302273e-01f, -9.01404396e-02f, -9.71509442e-02f, -6.44980893e-02f, -1.36383614e-02f, -1.67108148e-01f,
  -1.02414712e-01f, 1.44795803e-02f, 3.14786807e-02f, -8.60361084e-02f, 1.07286579e-03f, -1.97218508e-02f, 7.58057609e-02f, 3.19208242e-02f, 6.24158494e-02f, -1.12076014e-01f,
  -8.16183165e-02f, -2.32293047e-02f, 1.16910078e-02f, 2.57033622e-03f, 1.45886708e-02f, 8.11379850e-02f, -1.10270403e-01f, 1.04675759e-02f, -6.32642256e-03f, -3.16665992e-02f,
  -3.08512747e-02f, -5.11576235e-02f, 1.10724442e-01f, -1.21093225e-02f, 1.67319700e-02f, 1.10579886e-01f, 3.43078971e-02f, 4.69686911e-02f, 4.43882085e-02f, -1.34813875e-01f,
  4.41608438e-03f, -3.03634591e-02f, -3.91166611e-03f, -6.53466210e-02f, -2.05127522e-02f, -1.01675913e-02f, 6.59553409e-02f, 4.39220890e-02f, -5.66153452e-02f, 8.08602050e-02f,
  5.33655435e-02f, 6.49675354e-02f, -4.77112271e-02f, -6.38104826e-02f, 1.06101781e-02f, 1.20506631e-02f, 1.12907449e-02f, -7.87302256e-02f, -1.27389170e-02f, -5.04994728e-02f,
  3.94535325e-02f, 8.51135701e-02f, -4.28079665e-02f, 1.44139468e-03f, -1.01894811e-01f, 8.35707560e-02f, -1.08843856e-02f, -7.78830647e-02f, 1.97439268e-02f, -1.96998604e-02f,
  4.52705137e-02f, 1.48615837e-01f, -5.49554154e-02f, 7.43703321e-02f, 2.82352660e-02f, -1.34173319e-01f, -2.15259101e-02f, 3.58640291e-02f, 5.93170412e-02f, -5.11997230e-02f,
  -6.76622540e-02f, 7.62311146e-02f, -4.11669500e-02f, -4.39267308e-02f, 1.23782959e-02f, 6.04176428e-03f, 2.84826057e-03f, 4.10641097e-02f, 1.36211480e-03f, -1.44753411e-01f,
  -1.44755945e-01f, 1.88002586e-02f, 1.80046931e-01f, 1.12723559e-01f, 7.62944594e-02f, 6.42687008e-02f, 1.13381341e-01f, 1.19655602e-01f, 3.37628201e-02f, -6.91467449e-02f,
  1.63390324e-01f, -3.46812159e-02f, 1.29592657e-01f, -3.50978076e-02f, 1.02156475e-01f, 1.51449174e-01f, 1.15088224e-01f, -8.92937705e-02f, 3.96037549e-02f, 5.12319319e-02f,
  7.61042833e-02f, 3.80036719e-02f, -1.80277298e-03f, -5.42463511e-02f, -7.98332766e-02f, -7.22665638e-02f, -5.08030839e-02f, -1.70217780e-03f, -4.95733647e-03f, 4.29748818e-02f,
  4.46913466e-02f, 3.02495547e-02f, 9.39977318e-02f, -6.01229593e-02f, 9.41411331e-02f, -4.98049594e-02f, 9.85900015e-02f, -1.42164072e-02f, 8.64869505e-02f, 9.82859805e-02f,
  6.23146184e-02f, -1.38186226e-02f, 1.81197338e-02f, 4.05237339e-02f, -6.39176648e-03f, -6.37538135e-02f, -4.30260114e-02f, 4.80984747e-02f, 5.92663772e-02f, -2.88560223e-02f,
  5.13121039e-02f, 1.40144071e-02f, -2.90321931e-02f, -6.73242882e-02f, 1.47762103e-02f, 3.98738012e-02f, -3.91395912e-02f, -1.20923012e-01f, -1.13080963e-01f, -8.58819410e-02f,
  3.93717811e-02f, 6.22323267e-02f, 7.63781369e-02f, 2.18782499e-02f, 6.83720186e-02f, -5.35778664e-02f, 6.70456793e-03f, 9.94148850e-02f, 7.63867125e-02f, 8.93416405e-02f,
  2.22572070e-02f, 5.36265187e-02f, 9.15390030e-02f, -3.54224332e-02f, -3.30442153e-02f, -5.67285903e-02f, -4.95197885e-02f, 3.26117016e-02f, -6.74699396e-02f, 9.48901996e-02f,
  -5.63434660e-02f, 7.27010071e-02f, 4.36854549e-02f, 4.42972071e-02f, 6.27640337e-02f, -2.23400462e-02f, -5.78892417e-02f, 2.07236093e-02f, 9.94913727e-02f, 3.70984860e-02f,
  9.69093069e-02f, 4.93782014e-02f, 9.57491547e-02f, 2.86148880e-02f, -4.41612042e-02f, -1.67955272e-02f, 1.11140735e-01f, -9.96123254e-03f, 1.10566929e-01f, -1.35227188e-03f,
  -1.83598101e-01f, 6.28495365e-02f, -5.85393459e-02f, 4.36666906e-02f, 9.81691629e-02f, 2.56381333e-02f, 5.08502536e-02f, 2.43433584e-02f, -3.46755013e-02f, -3.88413221e-02f,
  -5.91765903e-02f, -5.17320521e-02f, -1.69348642e-02f, -7.24755824e-02f, 1.57146901e-02f, 8.07415545e-02f, 1.56071065e-02f, -8.83117318e-02f, -5.94507111e-03f, 3.33539397e-02f,
  -5.74767664e-02f, -2.01395098e-02f, -6.57546073e-02f, -1.14040218e-01f, 2.35611461e-02f, -2.86665037e-02f, 3.49337198e-02f, -6.49839863e-02f, -2.60617491e-02f, 1.12759052e-02f,
  -2.33677387e-01f, -5.34733571e-02f, -2.33967118e-02f, -1.88167855e-01f, 8.53484403e-03f, 5.14625348e-02f, -1.89037267e-02f, -8.36891830e-02f, 2.30436642e-02f, -6.99719116e-02f,
  2.45111976e-02f, -1.15458481e-01f, -1.08558089e-01f, 2.81346384e-02f, -6.43586814e-02f, -4.32682410e-02f, 7.90873170e-02f, -4.26601544e-02f, -3.22771780e-02f, 3.72947119e-02f,
  -2.81206165e-02f, -1.57616317e-01f, -7.00217783e-02f, 2.93467436e-02f, -6.29787669e-02f, -1.58309545e-02f, -1.18963763e-01f, -1.42259955e-01f, -5.59875183e-02f, -1.12396218e-01f,
  -4.04137075e-02f, -1.26468211e-01f, 3.93374264e-02f, -3.27107385e-02f, 5.25096618e-02f, -2.28899363e-02f, 3.80213931e-02f, 1.20587163e-02f, -2.14544567e-03f, 4.44860458e-02f,
  -6.69202879e-02f, -1.00735500e-02f, -1.04065798e-01f, 5.44936545e-02f, -5.03278561e-02f, -6.63194358e-02f, -5.80537319e-02f, -5.88735938e-03f, 9.11938250e-02f, 5.96821718e-02f,
  3.60547658e-03f, -2.20475979e-02f, 6.51170127e-03f, 4.83810902e-02f, 1.30500691e-02f, -6.50703674e-03f, 3.47898379e-02f, -2.68516652e-02f, -5.43217547e-02f, 3.50516662e-03f,
  -2.55327229e-03f, -2.30124630e-02f, 9.63797644e-02f, 2.78631672e-02f, 9.73648950e-03f, -8.51115957e-02f, -5.43326400e-02f, 2.83047073e-02f, 6.26316387e-03f, -1.40673462e-02f,
  -8.00287258e-03f, 8.17795768e-02f, 6.84724450e-02f, -5.11677265e-02f, -5.73188551e-02f, 2.99290456e-02f, 1.15913032e-02f, 7.17911348e-02f, 7.33544007e-02f, 1.34991268e-02f,
  5.06404042e-02f, -2.04177462e-02f, 1.55749097e-02f, -3.49178016e-02f, 6.98784962e-02f, 1.00873224e-01f, 4.06950116e-02f, 1.07233576e-01f, -3.44451964e-02f, -2.39324123e-02f,
  -2.08168373e-01f, 1.23305351e-01f, -1.10845417e-01f, 1.89631730e-02f, -3.82826962e-02f, -4.16703671e-02f, -5.39943799e-02f, -4.50959764e-02f, -1.76676940e-02f, -2.62546819e-03f,
  9.04943645e-02f, 4.14063595e-03f, -4.34687249e-02f, 3.36624049e-02f, 4.28832881e-02f, -8.86122056e-04f, 6.77866340e-02f, -6.40752986e-02f, 1.07650615e-01f, 1.01598874e-01f,
  1.26051918e-01f, 6.08423240e-02f, -1.27681876e-02f, 6.11573160e-02f, 8.00844468e-03f, -6.29348382e-02f, -4.76590432e-02f, 8.13456136e-04f, -5.88060133e-02f, -1.01368532e-01f,
  -1.05779685e-01f, -1.39540568e-01f, 4.04855199e-02f, -1.38922229e-01f, 7.49334916e-02f, -2.68272180e-02f, 1.87827796e-02f, 4.38594893e-02f, -1.27271593e-01f, -3.83533165e-02f,
  5.01766987e-02f, 5.90841807e-02f, 4.70818356e-02f, -6.59801438e-02f, -2.20678393e-02f, 3.89804132e-02f, -1.07575178e-01f, 7.72575885e-02f, -1.67648792e-02f, 4.69081178e-02f,
  2.56895348e-02f, -7.73964748e-02f, -2.27344111e-02f, -1.26549929e-01f, -4.69064713e-02f, -1.37742646e-02f, 5.56583470e-03f, -9.13842767e-02f, -1.06804438e-01f, -7.26982132e-02f,
  1.13860846e-01f, 6.18876666e-02f, 9.20078680e-02f, 2.76353918e-02f, -9.25997123e-02f, -5.62122725e-02f, -7.30388761e-02f, -7.60436431e-02f, 4.70104665e-02f, -3.52185289e-03f,
  7.35154934e-03f, -6.96656853e-02f, 3.11991237e-02f, -5.86255826e-02f, -5.72134182e-02f, 3.43178324e-02f, 3.29867937e-02f, -4.15104954e-03f, 3.19181271e-02f, 6.18523099e-02f,
  1.33737931e-02f, -1.38454204e-02f, 9.25155059e-02f, 3.83084714e-02f, -3.53232920e-02f, -1.75597966e-02f, -6.98061660e-02f, -1.00821266e-02f, 9.88819599e-02f, 5.38239554e-02f,
  1.88004281e-02f, -7.25450814e-02f, 9.15862620e-02f, -3.23108025e-02f, -8.06770101e-02f, -9.97259747e-04f, -7.41464198e-02f, 6.84223026e-02f, -4.64785378e-03f, -1.24112219e-02f,
  3.50976996e-02f, -5.95317036e-02f, -7.97122419e-02f, 6.07076753e-03f, 8.46873149e-02f, 5.23020476e-02f, 3.13818157e-02f, -2.90884878e-02f, 1.41552836e-02f, 8.99441727e-03f,
  4.37122509e-02f, 2.27130558e-02f, 5.14261611e-03f, -6.50552958e-02f, -4.80875783e-02f, 1.46309836e-02f, 7.02559650e-02f, 2.74380611e-04f, 2.48084906e-02f, 1.27945151e-02f,
  -2.45344620e-02f, 8.81202593e-02f, 2.22189855e-02f, -1.52217224e-02f, -1.66628398e-02f, 1.92044638e-02f, -4.84697148e-03f, -2.18082480e-02f, -1.05305903e-01f, 8.36945418e-03f,
  -2.14702617e-02f, -3.94496880e-02f, 5.81304319e-02f, 6.90890327e-02f, 5.68547919e-02f, 6.86488822e-02f, 3.56382094e-02f, -1.79641452e-02f, 4.17170450e-02f, -9.29857567e-02f,
  -7.28781149e-02f, 3.41636427e-02f, 1.11471474e-01f, -5.95147815e-03f, 4.87445220e-02f, 5.44795431e-02f, 1.56739037e-02f, 9.61447284e-02f, 4.36820462e-02f, 3.51528451e-02f,
  -2.06090987e-01f, -1.08226493e-01f, 4.95112687e-02f, 1.36395842e-02f, -4.47482616e-02f, 2.10699998e-02f, 1.21044256e-01f, 8.42960030e-02f, -7.58240595e-02f, -5.77040873e-02f,
  -1.01953320e-01f, 1.25968771e-03f, -1.07110530e-01f, 5.60153313e-02f, 1.05637990e-01f, 4.35860269e-02f, 3.29456739e-02f, -4.16358979e-03f, -6.60632085e-03f, -6.54680049e-03f,
  9.32883173e-02f, -7.86757283e-03f, 5.32899015e-02f, -6.52293116e-02f, 8.63320194e-03f, 2.37829937e-03f, 3.81875485e-02f, -6.44511580e-02f, -7.33225495e-02f, 2.57380158e-02f,
  1.18644722e-01f, -6.20171130e-02f, -4.25265506e-02f, -9.79003683e-03f, 6.92429021e-02f, 2.13533677e-02f, 3.44842561e-02f, 9.04036406e-03f, 6.09852225e-02f, 8.02218094e-02f,
  2.01050919e-02f, 1.85825713e-02f, -7.79885650e-02f, -1.37630487e-02f, -5.16773127e-02f, -8.14781263e-02f, 2.05784012e-02f, -1.05471313e-02f, 7.98826441e-02f, 4.78584766e-02f,
  -9.38496143e-02f, 4.25932482e-02f, 2.55221687e-02f, -1.24982940e-02f, -9.10399854e-02f, -4.87511605e-02f, 8.30942690e-02f, 5.63618764e-02f, 2.29858272e-02f, 5.43427393e-02f,
  -6.64975792e-02f, 4.98448834e-02f, 4.67267865e-03f, 9.03230812e-03f, -4.28760797e-02f, 5.71252778e-02f, 6.76738620e-02f, 1.20765176e-02f, -4.86456342e-02f, 7.51501843e-02f,
  5.75070232e-02f, 3.30873616e-02f, 3.02817337e-02f, 6.10967688e-02f, -2.74029095e-02f, -3.83545086e-02f, -5.66549972e-02f, -3.97832952e-02f, 7.48154074e-02f, -5.90704493e-02f,
  -6.04807846e-02f, -7.59737492e-02f, 1.18788658e-02f, 8.66288394e-02f, -2.37818938e-02f, 5.14774360e-02f, -5.47593273e-02f, -7.89917484e-02f, -4.86616865e-02f, 6.20766766e-02f,
  3.43533456e-02f, 3.51113058e-03f, -9.39217880e-02f, -4.62111272e-02f, 2.93291491e-02f, -1.05615772e-01f, -1.48397041e-02f, 8.46445262e-02f, -2.68735401e-02f, 9.86419618e-02f,
  -7.55115673e-02f, -3.06052119e-02f, 9.65345651e-02f, 1.09157890e-01f, 1.29290909e-01f, 2.06908379e-02f, -6.47924319e-02f, -4.62733358e-02f, 4.41693626e-02f, -5.31955995e-03f,
  -2.20402307e-03f, -2.57896874e-02f, 4.02750336e-02f, 3.24388854e-02f, 5.45739122e-02f, 8.72034803e-02f, 1.66078601e-02f, 5.44202477e-02f, 1.29335970e-01f, 3.19769084e-02f,
  1.38219357e-01f, -2.71767676e-02f, -1.59491479e-01f, 9.85015929e-02f, -7.76407048e-02f, -1.58985183e-02f, 1.10226087e-01f, 9.88868028e-02f, 2.61721779e-02f, 9.70456898e-02f,
  -3.47803859e-03f, -8.83475170e-02f, -7.90041238e-02f, 2.69887745e-02f, -7.71528333e-02f, 4.84339483e-02f, 6.75732270e-02f, 7.94496983e-02f, -8.67095441e-02f, 6.59823194e-02f,
  1.45229104e-04f, 3.67869772e-02f, -6.24274090e-02f, -3.81201245e-02f, -3.95953245e-02f, -1.44117158e-02f, -5.35111204e-02f, -6.12800904e-02f, -9.47767645e-02f, -7.18830675e-02f,
  -4.28756550e-02f, -1.34536132e-01f, 1.37654981e-02f, 8.99361521e-02f, -8.87716338e-02f, 1.07515588e-01f, 6.88057318e-02f, -5.82678393e-02f, -4.16300222e-02f, 7.20167756e-02f,
  5.32470942e-02f, -2.24752482e-02f, -5.87937310e-02f, 3.06793582e-02f, -7.40707815e-02f, -8.96282867e-02f, 7.40347011e-03f, -5.09413667e-02f, 4.16124873e-02f, -1.47676868e-02f,
  4.18971069e-02f, -5.75523041e-02f, 7.66011775e-02f, 1.20831598e-02f, -8.34985003e-02f, -3.51690985e-02f, 6.76245093e-02f, 2.10044384e-02f, -3.20304520e-02f, -2.14406755e-02f,
  1.01436988e-01f, 8.24894086e-02f, -5.72469160e-02f, 3.96687612e-02f, 8.87552053e-02f, 3.09117362e-02f, -6.76832795e-02f, -3.03138569e-02f, 2.23838370e-02f, 3.10974917e-03f,
  5.78838922e-02f, -8.32822993e-02f, -7.67378584e-02f, -1.48603031e-02f, -3.34467776e-02f, 1.73051897e-02f, -6.35074601e-02f, 2.76400684e-03f, -2.26860940e-02f, 8.74272734e-02f,
  -2.23413743e-02f, -1.28959343e-02f, 1.34629086e-02f, -3.74549441e-02f, -8.03569555e-02f, -4.74544726e-02f, -7.52824992e-02f, -4.89147678e-02f, 3.99771109e-02f, -8.10629800e-02f,
  7.89376050e-02f, -9.54354033e-02f, 1.28700389e-02f, -5.45342267e-02f, 6.96659982e-02f, 2.62587890e-03f, 7.02377781e-02f, -7.37510845e-02f, 1.70120765e-02f, -5.65608405e-02f,
  -8.76677856e-02f, -6.16409108e-02f, -1.84097849e-02f, 2.63506100e-02f, 1.28284772e-03f, -2.01895572e-02f, -1.82947181e-02f, -8.06056429e-03f, 7.53091357e-04f, 2.43536495e-02f,
  9.57446620e-02f, 7.79038807e-03f, -2.60526668e-02f, -3.53360325e-02f, 2.78627817e-02f, 8.28041285e-02f, 5.88809215e-02f, 5.35414778e-02f, 2.06820993e-03f, 1.68957561e-01f,
  2.46066228e-01f, 1.82566658e-01f, 2.51957208e-01f, 8.34515393e-02f, 1.64739698e-01f, 1.72958925e-01f, 3.00286412e-01f, 6.95272088e-02f, -4.87085767e-02f, 1.17477626e-01f,
  1.83702841e-01f, -3.55907008e-02f, -8.50640759e-02f, -1.02887079e-01f, 4.38614748e-02f, -3.40589508e-02f, -1.63637266e-01f, -5.32175303e-02f, 4.48774826e-03f, -6.95984364e-02f,
  -1.16695687e-01f, -1.66226719e-02f, -1.88999772e-02f, -6.96344078e-02f, 2.81379372e-03f, -1.68929294e-01f, 9.21718255e-02f, 6.37176782e-02f, 7.81687070e-03f, -2.23699629e-01f,
  3.24637480e-02f, 3.13025564e-01f, -1.14332633e-02f, -1.47717282e-01f, 3.43920290e-02f, -7.35640898e-02f, -6.80713952e-02f, -6.08771741e-02f, -6.64591417e-02f, -6.32150704e-03f,
  -2.11767876e-03f, 5.88809028e-02f, -2.59346608e-02f, -8.48894790e-02f, 1.20212935e-01f, 2.95024943e-02f, 5.32995863e-03f, -7.95342326e-02f, -1.63285770e-02f, 2.64609922e-02f,
  4.02910486e-02f, 1.26976833e-01f, 2.31824443e-01f, 1.42303491e-02f, 7.06667751e-02f, -6.92396238e-02f, 4.63352054e-02f, 8.26766193e-02f, -1.36931809e-02f, -1.37954772e-01f,
  -8.50210190e-02f, 6.66868538e-02f, 1.97866224e-02f, 8.64985958e-02f, -8.61658454e-02f, 1.79664083e-02f, -3.91977985e-04f, -6.89987885e-03f, -2.49601416e-02f, 4.83355783e-02f,
  5.25442697e-02f, -2.52093840e-02f, -1.02128517e-02f, 7.48846680e-02f, 6.01223577e-03f, 4.23468985e-02f, 7.35136494e-02f, 6.95361644e-02f, 9.38092098e-02f, 2.31492389e-02f,
  -2.70784460e-02f, 4.66542458e-03f, 6.55428767e-02f, -5.51670119e-02f, 4.59857620e-02f, 4.46378347e-03f, -3.49212922e-02f, 3.35687771e-02f, 7.56984353e-02f, 7.17052817e-02f,
  -1.59982279e-01f, 2.41870031e-01f, -1.41599074e-01f, -1.30096704e-01f, 1.01630837e-01f, -9.21679214e-02f, 2.41438169e-02f, -2.96831094e-02f, 8.41923133e-02f, -6.70261383e-02f,
  9.98245850e-02f, -2.33643828e-03f, 1.09966025e-01f, -1.98915713e-02f, -1.32137556e-02f, -4.16602986e-03f, 1.71297905e-03f, -5.15206754e-02f, 3.57240182e-03f, -3.64782512e-02f,
  -1.24871582e-01f, 1.03808582e-01f, -4.92458232e-02f, 6.46708161e-02f, -3.69093977e-02f, 5.27486298e-03f, -6.76273853e-02f, 1.85278840e-02f, -1.05035007e-02f, -1.61183968e-01f,
  -2.27287307e-01f, -7.90582150e-02f, 5.18524349e-02f, -2.22193763e-01f, -2.60107801e-03f, 5.82148097e-02f, 7.39234015e-02f, -1.00528076e-01f, -2.06093360e-02f, 3.24748643e-02f,
  7.44326785e-02f, 4.70007723e-03f, 9.32705253e-02f, 4.41156887e-02f, 4.09577414e-02f, 6.01436757e-02f, -1.42355800e-01f, -9.07452777e-02f, 4.93222289e-02f, 5.09845139e-03f,
  7.71509185e-02f, -1.19624160e-01f, -2.75220461e-02f, -1.80216618e-02f, -9.78918150e-02f, 5.98206185e-02f, 5.94348125e-02f, -9.82094407e-02f, -1.06723316e-01f, -1.13881007e-01f,
  2.92751580e-01f, -4.75962982e-02f, -4.47766930e-02f, 1.12851942e-02f, 3.39868702e-02f, -1.00061230e-01f, 1.74931716e-02f, 3.20985564e-03f, -2.44592093e-02f, 2.02419516e-02f,
  2.82148980e-02f, -3.70251499e-02f, -2.86324583e-02f, -4.05307002e-02f, -2.82584243e-02f, -2.03262847e-02f, -1.05359793e-01f, -6.92246854e-02f, -1.35845952e-02f, 6.02434352e-02f,
  -6.65906444e-02f, -1.39021799e-01f, 8.69496763e-02f, 1.60156265e-02f, -1.11055680e-01f, -6.50563315e-02f, -2.84089670e-02f, -3.19137350e-02f, -3.35525908e-02f, 7.13799801e-03f,
  -4.20514680e-02f, 1.48412222e-02f, 5.20142987e-02f, -4.08220068e-02f, 8.52904618e-02f, 1.28323706e-02f, -8.40788707e-02f, -4.00105827e-02f, 7.04333410e-02f, 8.16137120e-02f,
  -3.65699828e-02f, 6.22030087e-02f, -1.49361854e-02f, 2.57374183e-03f, 5.05077839e-02f, -5.91697805e-02f, -8.98502488e-03f, -3.68164890e-02f, 7.13330880e-02f, 1.79081503e-02f,
  1.04801049e-02f, 2.12473646e-02f, -9.40468609e-02f, -3.34103219e-02f, -7.32759163e-02f, -1.33261997e-02f, 5.14187198e-03f, -1.23939980e-02f, -6.35483712e-02f, -8.28492716e-02f,
  2.56936640e-01f, -3.47582884e-02f, -9.38598514e-02f, 7.00030942e-03f, -6.30538911e-02f, 3.68126966e-02f, -7.16577694e-02f, -6.16183095e-02f, -7.47096762e-02f, 5.30092642e-02f,
  5.40759936e-02f, 7.53268898e-02f, 5.90223745e-02f, -7.46471509e-02f, -9.45023540e-03f, 2.47457586e-02f, -1.10692121e-01f, -6.63468838e-02f, 2.71505937e-02f, 1.71943884e-02f,
  3.29778567e-02f, -7.07193762e-02f, 6.88740611e-02f, 1.09917045e-01f, 6.25614896e-02f, 9.43522677e-02f, 1.27057523e-01f, 1.19172810e-02f, 8.80951807e-02f, 1.39515877e-01f,
  1.33930296e-01f, 5.23785353e-02f, 1.35046601e-01f, 1.28909037e-01f, 7.09589869e-02f, 1.45962432e-01f, 1.38055488e-01f, -6.43081381e-04f, 8.98069963e-02f, 1.17140725e-01f,
  1.43002585e-01f, -3.51930037e-02f, 9.45938826e-02f, -5.08687384e-02f, -4.60949279e-02f, 6.29713153e-03f, 2.51771174e-02f, 3.45278755e-02f, 6.86666667e-02f, -8.02533329e-02f,
  2.40485258e-02f, 1.94176603e-02f, -3.65409777e-02f, 5.95311113e-02f, -2.07038131e-02f, -3.60335107e-03f, 1.36151966e-02f, 8.11002851e-02f, 7.89255276e-02f, -5.15360162e-02f,
  -6.61882460e-02f, 6.69483617e-02f, -9.32416916e-02f, -3.86037454e-02f, 1.04640923e-01f, 1.30787631e-02f, -6.13446645e-02f, 3.06679197e-02f, -5.44351451e-02f, 4.94498238e-02f,
  1.89645439e-02f, 7.73320645e-02f, -6.86890930e-02f, -8.79636705e-02f, -4.60273288e-02f, -2.85690427e-02f, -7.40548372e-02f, -7.58061931e-02f, 4.11600210e-02f, 6.23516291e-02f,
  -6.63305819e-03f, 6.51161745e-02f, 7.42294863e-02f, 5.23555316e-02f, 5.82653843e-03f, 3.59940119e-02f, -5.93196489e-02f, 6.05679415e-02f, -3.47169004e-02f, -3.80716403e-03f,
  -3.40174735e-02f, 8.76361206e-02f, 6.92495331e-02f, -8.80607143e-02f, 5.23495600e-02f, 3.72649059e-02f, -8.90916213e-02f, -2.99885944e-02f, 1.09080732e-01f, 2.29215552e-03f,
  -7.54138306e-02f, 3.56216319e-02f, -4.85275500e-02f, 1.35867938e-03f, 9.28030536e-02f, -1.21805565e-02f, -7.72696584e-02f, 3.96688245e-02f, 5.49343042e-02f, 4.15779278e-02f,
  -1.74048916e-02f, 7.32856169e-02f, -1.26837464e-02f, 7.48343542e-02f, 4.77096364e-02f, 6.96243793e-02f, -5.00740744e-02f, -1.30717987e-02f, -4.99630347e-04f, -6.65022060e-02f,
  2.48096306e-02f, 9.30360928e-02f, -3.54933031e-02f, 5.71221784e-02f, -1.12569109e-02f, -7.24517480e-02f, 2.34560836e-02f, 5.79794757e-02f, 1.03166001e-02f, -7.18180910e-02f,
  -4.19307575e-02f, -6.30378723e-02f, 9.00940225e-02f, 6.49755150e-02f, -1.79610513e-02f, -1.01555616e-01f, 3.50493155e-02f, -6.19620597e-03f, -4.65147048e-02f, -2.81020924e-02f,
  -3.88312750e-02f, -6.81108311e-02f, -8.24346021e-02f, -5.68725877e-02f, -9.19558778e-02f, 8.42762887e-02f, 8.44022036e-02f, -7.66165629e-02f, -7.60012642e-02f, -3.48335803e-02f,
  2.18029059e-02f, -2.42128707e-02f, -1.15906239e-01f, -2.65811244e-03f, 5.77468462e-02f, 6.70891032e-02f, 3.61034721e-02f, -4.92098089e-03f, -6.07432332e-03f, 7.01014996e-02f,
  4.65615280e-02f, -3.93512845e-02f, 1.55641465e-02f, -7.70258158e-02f, 6.54711446e-04f, 2.86339279e-02f, -5.81667684e-02f, -1.04025036e-01f, 6.84475973e-02f, -1.75383769e-03f,
  -6.13112934e-02f, 1.72605086e-02f, -2.73756050e-02f, -1.01097170e-02f, 2.17356719e-02f, 4.09557410e-02f, -1.99834052e-02f, -4.43520583e-02f, -1.07694767e-01f, -7.90165588e-02f,
  -1.29870534e-01f, -9.81372967e-03f, -4.38701697e-02f, 1.31028527e-02f, 6.37523681e-02f, 2.86516044e-02f, -4.04279977e-02f, -5.87168485e-02f, 6.59387559e-03f, 4.16747518e-02f,
  6.66641816e-02f, -1.29928282e-02f, -3.57149951e-02f, 8.55411589e-02f, 1.47660647e-03f, -8.88088271e-02f, 5.14879730e-03f, 7.29069188e-02f, 9.04509723e-02f, -3.93743552e-02f,
  -6.77261502e-02f, -8.50810707e-02f, 2.78943777e-02f, 6.66260719e-02f, -1.06549100e-03f, 3.62646021e-02f, -2.31211726e-02f, 1.25951571e-02f, 5.20785451e-02f, 2.25606374e-02f,
  3.25102620e-02f, 9.05904919e-02f, 1.92860551e-02f, -4.18577380e-02f, 3.97290438e-02f, 3.09245791e-02f, 5.60190566e-02f, -3.58950812e-03f, 9.09759402e-02f, 4.31846008e-02f,
  4.45211232e-02f, -2.76099611e-02f, 1.27718383e-02f, 5.55216223e-02f, -4.73634116e-02f, -3.98590378e-02f, -5.79466186e-02f, 5.24155609e-02f, 5.80388717e-02f, -7.63831064e-02f,
  8.22786614e-02f, -5.47466986e-02f, -2.82623284e-02f, -6.20577782e-02f, -1.08964026e-01f, 7.91078061e-02f, 5.42899482e-02f, -5.57437614e-02f, -5.57986349e-02f, 4.16645668e-02f,
  6.85829669e-02f, -3.10685243e-02f, -2.64946464e-02f, 6.13668002e-03f, 3.69077884e-02f, -2.88789552e-02f, 6.30471632e-02f, 4.29126285e-02f, 1.28851887e-02f, -2.99644955e-02f,
  -6.63066376e-03f, 5.05545437e-02f, -8.35765153e-04f, -1.24644605e-04f, 7.55913034e-02f, -7.80937001e-02f, 4.92286831e-02f, 4.43164185e-02f, 5.92684634e-02f, 1.05987824e-01f,
  -1.91377383e-02f, -6.73345178e-02f, -1.03341481e-02f, -4.24860828e-02f, 7.67795965e-02f, 6.19514100e-02f, 8.71917009e-02f, -3.16062309e-02f, 8.07573721e-02f, 5.99509552e-02f,
  -1.29274085e-01f, -9.81300995e-02f, 2.04037279e-01f, -1.21257916e-01f, -5.51638156e-02f, -1.49048999e-01f, -1.92988679e-01f, -6.91599920e-02f, -1.13777302e-01f, -1.84404865e-01f,
  -3.33594419e-02f, -6.62162602e-02f, 4.27661575e-02f, -5.66425994e-02f, 2.99612973e-02f, -3.72044928e-02f, 7.52336904e-03f, 1.00894071e-01f, -3.40377241e-02f, -7.68510252e-02f,
  -1.55856490e-01f, 2.62197796e-02f, 2.52883192e-02f, 4.46989350e-02f, -7.40204304e-02f, -7.12349487e-04f, 3.52643691e-02f, -1.78948473e-02f, -2.91703101e-02f, -1.83065996e-01f,
  -1.43769249e-01f, -6.70962930e-02f, 2.68231649e-02f, -3.44993658e-02f, 1.77461915e-02f, 7.28480965e-02f, 2.07743328e-02f, 1.09756224e-01f, 7.09387660e-02f, -1.75499674e-02f,
  6.62441105e-02f, -1.06671602e-01f, -3.43224704e-02f, -8.86631534e-02f, -1.21457661e-02f, 4.73325402e-02f, 8.25334042e-02f, -1.55995153e-02f, 1.10182725e-01f, -6.77507594e-02f,
  -1.10211447e-01f, -6.54989034e-02f, 4.65415418e-02f, -6.72210231e-02f, -4.19488996e-02f, 5.90021200e-02f, -8.42076987e-02f, -1.14611946e-01f, -1.22456197e-02f, -1.76965609e-01f,
  2.56446470e-03f, 1.59658957e-02f, -6.31260872e-02f, -7.06159174e-02f, -5.02741076e-02f, 7.50401914e-02f, -6.78727999e-02f, -4.70660515e-02f, 2.62786653e-02f, -5.36019988e-02f,
  5.04539609e-02f, -1.40763633e-02f, 4.69507091e-02f, -5.10598393e-03f, 5.86741939e-02f, 5.37505597e-02f, -6.70200586e-02f, -5.97533258e-03f, -5.58450148e-02f, -1.02018556e-02f,
  1.06528681e-02f, -1.39722992e-02f, 6.21169545e-02f, 6.49552196e-02f, 5.95232993e-02f, -2.90975869e-02f, 7.65755177e-02f, -2.25563291e-02f, 1.12982630e-03f, 8.22858810e-02f,
  -8.92711356e-02f, 1.87974855e-01f, -7.08967969e-02f, -9.00876671e-02f, -8.02219361e-02f, -4.55150194e-02f, 1.97421163e-02f, 8.43886510e-02f, 6.08559288e-02f, -5.45716248e-02f,
  -9.37607437e-02f, -9.97638777e-02f, -2.33441568e-03f, 3.49692926e-02f, -1.27697065e-01f, -3.65139991e-02f, -1.12349406e-01f, 4.65017073e-02f, 5.12136566e-03f, -4.64013927e-02f,
  -5.13390154e-02f, -1.05777360e-01f, -6.26702681e-02f, -9.95852351e-02f, 3.90555486e-02f, 2.15080976e-02f, -2.31443979e-02f, -1.43513322e-01f, -1.13771677e-01f, -1.87885195e-01f,
  -5.32079041e-02f, 7.49444887e-02f, 3.70573476e-02f, 2.22658692e-03f, -8.82270262e-02f, 4.18952070e-02f, -5.81074171e-02f, -2.08597314e-02f, -8.22971202e-03f, -9.79182273e-02f,
  -2.63085812e-02f, -1.28275827e-01f, 3.18886042e-02f, -7.63643980e-02f, 8.14812556e-02f, 2.05645580e-02f, -5.42553365e-02f, 7.30287880e-02f, 1.21217193e-02f, -2.28687692e-02f,
  1.95977800e-02f, 8.33298564e-02f, -4.86428216e-02f, -6.18184619e-02f, -1.96677260e-02f, 3.49573418e-02f, 2.97118369e-02f, 5.96014690e-03f, 2.46132948e-02f, -5.10579310e-02f,
  -7.62283728e-02f, -1.43168559e-02f, 2.85985786e-02f, -7.20181093e-02f, -6.79494664e-02f, 2.26845942e-03f, -9.54285786e-02f, -8.96839425e-03f, -6.26567975e-02f, 5.66984117e-02f,
  -7.00865835e-02f, -6.38421923e-02f, 5.27581535e-02f, 4.72142473e-02f, -6.27854615e-02f, 5.73974214e-02f, -2.47377995e-02f, 8.47173110e-02f, 1.13702349e-01f, 1.00263357e-01f,
  -6.73094094e-02f, 4.72781882e-02f, -6.31890520e-02f, -6.95427356e-04f, 5.61300963e-02f, 5.08872010e-02f, -1.83706265e-02f, 8.91308561e-02f, 6.36177436e-02f, -4.30406593e-02f,
  4.15763184e-02f, -7.79839307e-02f, 2.35157721e-02f, -2.08516382e-02f, 6.06360696e-02f, 1.32428640e-02f, -7.00543597e-02f, -8.14516023e-02f, -6.45927042e-02f, 7.38012865e-02f,
  1.14041949e-02f, 6.01860620e-02f, 6.23467751e-02f, -1.99036449e-02f, -3.33657092e-03f, 4.26188409e-02f, 2.68773008e-02f, 4.79371361e-02f, 2.63681486e-02f, -1.09698595e-02f,
  5.49136698e-02f, 1.00650430e-01f, -8.36302713e-02f, -9.43571981e-03f, -2.54485346e-02f, -6.15277402e-02f, -3.91421542e-02f, 7.76142403e-02f, -4.91643362e-02f, 1.07491771e-02f,
  -1.38497755e-01f, 3.77231129e-02f, 1.03477342e-02f, -5.49737215e-02f, 5.09491079e-02f, 2.49731708e-02f, -8.95498171e-02f, -7.50795454e-02f, 4.16635387e-02f, -9.66574773e-02f,
  4.51903641e-02f, -3.91240604e-02f, 1.65715311e-02f, 1.16982497e-02f, 9.30732489e-03f, -8.47952217e-02f, 5.81466826e-03f, 6.89530596e-02f, -7.12676644e-02f, 7.82186538e-03f,
  -3.02934498e-02f, -3.21422368e-02f, 6.15055449e-02f, -1.33589674e-02f, 2.69183870e-02f, 5.18500023e-02f, -2.78881639e-02f, -9.14826319e-02f, 7.44313281e-03f, -2.93359905e-02f,
  -1.34964913e-01f, -2.42866855e-02f, 1.05332352e-01f, -4.67308424e-02f, 3.63163613e-02f, 4.47724089e-02f, 1.78190008e-01f, 9.71821100e-02f, 2.79960427e-02f, -8.54870081e-02f,
  4.22192663e-02f, 5.19089261e-03f, -9.15205926e-02f, -1.03853866e-01f, -2.34965910e-03f, 1.18674949e-01f, 6.02002852e-02f, 2.53500436e-02f, -7.17138797e-02f, 6.86236545e-02f,
  -3.04370429e-02f, -1.13591962e-01f, -9.52473357e-02f, -1.31269887e-01f, -4.90199253e-02f, -1.01325400e-01f, -9.69687477e-02f, -6.97862133e-02f, 1.32983448e-02f, -7.87506998e-02f,
  -5.54571822e-02f, 4.65666130e-02f, 9.09954682e-02f, -4.48070467e-02f, 3.08667682e-02f, -2.56551448e-02f, 3.73200402e-02f, -1.29506528e-01f, -8.65581408e-02f, -2.83391979e-02f,
  6.13191649e-02f, -8.13727751e-02f, -3.54622379e-02f, -7.46866092e-02f, -9.50956717e-02f, 4.22000448e-04f, 7.17921928e-02f, -8.89773741e-02f, -4.13258635e-02f, -4.38877605e-02f,
  1.01288781e-01f, 9.83095318e-02f, 3.47018987e-02f, -6.30390048e-02f, 4.37464938e-02f, 7.45576620e-02f, -4.27889526e-02f, 8.25674832e-02f, 2.96720490e-02f, -1.22357206e-02f,
  -6.83138147e-02f, 1.90426223e-02f, 7.45487288e-02f, 3.31320539e-02f, 7.60185272e-02f, 3.20292190e-02f, -8.07821602e-02f, -7.66933262e-02f, 3.69046405e-02f, -2.38793585e-02f,
  5.63832670e-02f, 6.77465349e-02f, -5.99505529e-02f, -1.01466465e-03f, -4.33055237e-02f, 7.93350190e-02f, 2.10722387e-02f, 9.52395797e-02f, -1.98872555e-02f, -1.44926375e-02f,
  -4.65079620e-02f, 2.12597083e-02f, -7.85446167e-02f, -4.08754386e-02f, 2.73112599e-02f, -6.44797385e-02f, -3.93632725e-02f, 1.05198205e-01f, -2.92630959e-02f, -4.43504788e-02f,
  -1.81339413e-01f, -2.79665254e-02f, -9.32062119e-02f, -1.27998376e-02f, 4.88207070e-03f, -5.28696254e-02f, 4.95454073e-02f, -1.81847569e-02f, -8.94290581e-02f, 7.81848058e-02f,
  6.58700168e-02f, 6.64749295e-02f, -7.14388341e-02f, -5.35062179e-02f, -7.04557747e-02f, 5.86320274e-02f, -7.73686916e-02f, 6.10829629e-02f, -3.81606929e-02f, -2.74200700e-02f,
  -3.95721905e-02f, -5.37408004e-03f, 1.82929207e-02f, 5.92353046e-02f, 3.36866528e-02f, 5.20807840e-02f, -8.74795020e-02f, 3.46658044e-02f, 2.83413120e-02f, -9.08417180e-02f,
  1.84498653e-01f, 1.34826764e-01f, -1.20342955e-01f, 8.71155858e-02f, 8.73166472e-02f, -1.29744597e-02f, 4.38261591e-02f, -6.59807026e-02f, 8.82522017e-02f, 6.06629550e-02f,
  1.03627732e-02f, 1.19157638e-02f, -1.55271858e-01f, -3.85587998e-02f, -9.43730921e-02f, -7.40047842e-02f, 2.32385471e-02f, -1.40973419e-01f, -1.05970941e-01f, -8.61068070e-02f,
  6.81519601e-03f, -6.43313527e-02f, 7.19775334e-02f, -5.84508106e-02f, 3.01020499e-02f, -9.26919747e-03f, 2.02687234e-02f, 7.03555569e-02f, -7.30934218e-02f, -1.12430349e-01f,
  -4.41621505e-02f, 4.41322140e-02f, -1.49704948e-01f, 2.54019182e-02f, 4.41767536e-02f, 8.82567242e-02f, -6.51233643e-02f, 9.95090753e-02f, 5.50954714e-02f, -6.07780553e-02f,
  6.55452237e-02f, 5.60168251e-02f, -4.21028696e-02f, -5.54500632e-02f, -6.20099939e-02f, 8.79652239e-03f, 8.41701180e-02f, 1.37028871e-02f, 4.43992345e-03f, -4.95527312e-02f,
  5.97979128e-02f, 7.55253434e-02f, -2.92270146e-02f, 5.02350815e-02f, 1.78484973e-02f, -1.25953123e-01f, -8.41768906e-02f, -1.02023147e-01f, 4.53943722e-02f, 5.51179424e-02f,
  9.42832008e-02f, -1.05885111e-01f, 6.79412764e-03f, 2.58334149e-02f, -1.94722433e-02f, -2.26118751e-02f, -5.37143499e-02f, -6.28191084e-02f, -5.70057519e-02f, 9.73783061e-02f,
  4.97200862e-02f, 1.73433200e-02f, 1.56045854e-02f, 9.92507637e-02f, 7.25765005e-02f, -6.05225898e-02f, -4.11896072e-02f, 7.12641478e-02f, 1.90633454e-03f, 3.84937003e-02f,
  2.87806932e-02f, -8.50206316e-02f, -1.37962578e-02f, -3.04185133e-02f, 7.85535052e-02f, 8.31134543e-02f, 4.27880809e-02f, -6.64965361e-02f, 8.29652790e-03f, -4.10515666e-02f,
  6.78244755e-02f, -1.42451748e-01f, 4.89395931e-02f, 2.88732722e-02f, 7.08946586e-02f, 4.45128642e-02f, -4.39555272e-02f, 1.20340571e-01f, 6.22113992e-04f, -6.37360811e-02f,
  -1.08645730e-01f, -6.44660788e-04f, -5.78157306e-02f, -5.37768081e-02f, 7.69430697e-02f, -5.83684929e-02f, 8.29424784e-02f, 4.59322780e-02f, -4.48796749e-02f, 9.47956368e-02f,
  5.94982170e-02f, 4.26290929e-02f, 1.18202947e-01f, -2.58705989e-02f, 2.72967387e-03f, -2.06806604e-02f, -7.21093565e-02f, 8.41573626e-02f, 5.49999624e-02f, 2.08917126e-01f,
  6.24899417e-02f, 1.72996998e-01f, 9.08121765e-02f, 3.27807516e-02f, 1.71991270e-02f, 2.45257523e-02f, 1.19266845e-01f, 3.12843286e-02f, 6.73245788e-02f, 6.47123083e-02f,
  1.27377868e-01f, 1.07161388e-01f, -1.84195489e-02f, -2.23788992e-02f, 4.85973135e-02f, -2.23746561e-02f, 1.62685700e-02f, -1.15289666e-01f, -8.04254711e-02f, -3.41564827e-02f,
  -4.87829223e-02f, -2.34865714e-02f, -8.95036981e-02f, 6.57981485e-02f, 5.80110587e-02f, -1.37251439e-02f, 8.78804736e-03f, 6.83707893e-02f, -1.11613399e-03f, -3.46975401e-02f,
  -6.24278225e-02f, 4.49611954e-02f, -1.05141468e-01f, 2.82807313e-02f, -5.58026694e-02f, -5.28026596e-02f, 2.76338030e-02f, -2.94854138e-02f, 1.41119668e-02f, -2.84089502e-02f,
  -1.43574588e-02f, -3.17266844e-02f, 7.92247131e-02f, 2.95285154e-02f, 1.23381615e-02f, -2.44905986e-02f, 3.54327373e-02f, -1.00112975e-01f, 1.85864121e-02f, -3.12670576e-03f,
  4.81897220e-02f, -2.29460275e-04f, 9.29930806e-02f, 7.83066452e-02f, -3.28473412e-02f, -9.77529436e-02f, 6.48652315e-02f, 3.35934348e-02f, 6.20237030e-02f, -8.76034573e-02f,
  6.22614883e-02f, 2.29233969e-02f, 5.66697977e-02f, -3.27464640e-02f, 6.54562637e-02f, 1.61062665e-02f, -7.69677758e-02f, 8.64436850e-02f, -1.64697897e-02f, 7.37705007e-02f,
  -2.33600736e-02f, 3.15267108e-02f, -7.90615231e-02f, 2.45553590e-02f, 3.65488194e-02f, 1.61547051e-03f, -4.12813053e-02f, 1.96511839e-02f, -3.66942622e-02f, -7.75779709e-02f,
  5.42858727e-02f, 1.97265074e-02f, -3.98663618e-03f, -2.91569643e-02f, -7.32412934e-02f, -7.56068751e-02f, -1.03382356e-01f, -6.68441877e-02f, 3.67115550e-02f, -6.03900431e-03f,
  8.23912993e-02f, -4.00275774e-02f, -1.15102366e-01f, -6.85883686e-03f, 1.97754782e-02f, -8.65523890e-02f, 1.03244454e-01f, -2.96165105e-02f, -7.44499173e-03f, -5.32224923e-02f,
  -2.85058729e-02f, -1.71269421e-02f, 1.02776743e-01f, 6.06238060e-02f, -2.92863268e-02f, 1.05295619e-02f, -5.24230674e-02f, -4.61118817e-02f, 2.19617467e-02f, -5.52371182e-02f,
  -7.22528473e-02f, 4.08754572e-02f, -6.59572259e-02f, 5.53108081e-02f, 7.66976401e-02f, 1.23950019e-02f, 3.23361112e-03f, -5.24207726e-02f, 3.72028835e-02f, 2.32893787e-02f,
  -1.36367485e-01f, -1.09123230e-01f, -8.12504441e-02f, -7.95789212e-02f, -9.29820240e-02f, -2.12042686e-02f, -1.32278174e-01f, 3.68689261e-02f, -8.26507285e-02f, -8.19824561e-02f,
  -2.13152356e-03f, -8.61278549e-02f, -7.61387944e-02f, -3.29933576e-02f, -1.12273395e-01f, -1.18518718e-01f, -2.15440378e-01f, -1.60106838e-01f, -2.96436343e-02f, -6.91789016e-03f,
  4.75353524e-02f, 5.49688637e-02f, 9.55100264e-03f, -9.57008824e-02f, -6.14794567e-02f, -1.01804696e-01f, -2.81568989e-02f, 5.02493838e-03f, -2.33214311e-02f, -1.26116678e-01f,
  -2.09298842e-02f, -8.75588208e-02f, 1.68338213e-02f, 6.04274310e-02f, 2.30378043e-02f, 1.71370115e-02f, -1.05003633e-01f, 2.24692859e-02f, -8.66073072e-02f, -2.53838785e-02f,
  -4.02948409e-02f, 1.63226351e-02f, -2.50739045e-02f, 8.75974968e-02f, -3.94209325e-02f, 3.51830237e-02f, 1.17624048e-02f, -2.56969836e-02f, -1.09661818e-01f, 9.11803916e-03f,
  -1.00579066e-02f, -4.94292229e-02f, -9.58909318e-02f, 8.54984671e-02f, 1.53521094e-02f, -8.92962292e-02f, 5.17435968e-02f, -1.17835151e-02f, 2.95682605e-02f, -5.66052608e-02f,
  7.06951767e-02f, 4.10426222e-02f, 6.73284754e-02f, -3.10336072e-02f, -2.13048588e-02f, -3.89432870e-02f, -2.55057676e-04f, 5.50627671e-02f, -3.96386273e-02f, 3.51136401e-02f,
  3.89264598e-02f, -8.79426487e-03f, -5.31459525e-02f, 7.46899396e-02f, -9.58675891e-03f, 4.55930941e-02f, 4.78806086e-02f, 5.01134992e-02f, -1.40845384e-02f, 6.88583180e-02f,
  3.85018773e-02f, 8.34459141e-02f, -2.71503106e-02f, -1.01651223e-02f, 1.17211500e-02f, -9.94423404e-02f, 1.54178469e-02f, 2.28428226e-02f, -6.66413009e-02f, 6.14479221e-02f,
  1.09007306e-01f, -2.56944485e-02f, 1.75041724e-02f, 8.20488408e-02f, 2.24889480e-02f, 3.22874635e-02f, -7.43618086e-02f, 7.98206870e-03f, 5.67793399e-02f, 7.95420930e-02f,
  3.38658318e-02f, 7.13916495e-02f, -1.95170101e-02f, 2.66185787e-04f, 1.04046546e-01f, 4.16874178e-02f, -2.78924871e-02f, -3.02125216e-02f, -8.16274807e-02f, -6.82624280e-02f,
  -6.17947057e-02f, -1.33290038e-01f, -7.34768212e-02f, 3.26102935e-02f, 8.90487432e-02f, 4.32752073e-02f, 8.69111791e-02f, 8.40878785e-02f, -1.30228205e-02f, 3.54507565e-02f,
  5.50362058e-02f, -2.21365504e-02f, -8.71517807e-02f, -5.00943959e-02f, 6.52984381e-02f, -5.78995273e-02f, 3.94527465e-02f, -2.67875623e-02f, 1.05055973e-01f, -6.68800697e-02f,
  2.31722519e-02f, -8.86244625e-02f, -1.26199960e-03f, 1.08527280e-02f, -8.98951292e-02f, -7.12831467e-02f, -4.19091471e-02f, -1.43786818e-01f, -1.72213092e-01f, -1.70786530e-01f,
  -9.27297920e-02f, 3.75454016e-02f, 2.10759733e-02f, -1.42351463e-02f, 3.00879627e-02f, -8.71082172e-02f, -2.33265255e-02f, 5.69709949e-02f, -1.49370190e-02f, -1.50072796e-04f,
  -3.46840918e-02f, 1.29080713e-01f, -9.92803182e-03f, -9.59185511e-02f, 1.17714452e-02f, 5.56687191e-02f, 4.68573067e-03f, -6.32315874e-02f, -7.48387352e-02f, 3.27598043e-02f,
  9.10004787e-03f, -4.22960632e-02f, 5.93083315e-02f, -2.95431577e-02f, -6.18662797e-02f, 1.11489389e-02f, 3.55407745e-02f, -3.15542594e-02f, -1.05937764e-01f, -4.41772304e-03f,
  -7.47180656e-02f, -8.31345320e-02f, 6.27813190e-02f, 8.27347115e-02f, -3.12770754e-02f, -2.64360034e-03f, -1.97926555e-02f, 4.95528579e-02f, 7.15866610e-02f, 3.32606398e-02f,
  -3.52092646e-02f, -3.24570872e-02f, -7.07779638e-03f, -9.39713325e-03f, 1.61433928e-02f, 1.00518174e-01f, 7.34338239e-02f, -8.33292380e-02f, -5.17801605e-02f, -7.94562027e-02f,
  2.22991779e-02f, -3.22434232e-02f, 3.92143689e-02f, 7.07716644e-02f, 5.85278422e-02f, 8.88591409e-02f, -1.29551650e-03f, 7.61457980e-02f, 7.21469447e-02f, -9.46926011e-04f,
  -5.95192201e-02f, 1.53705776e-02f, 9.50480029e-02f, 5.77387139e-02f, -5.79725914e-02f, -7.79530108e-02f, 6.59122989e-02f, -3.46948355e-02f, 4.66575287e-02f, 9.30802710e-03f,
  1.29346356e-01f, 5.96837141e-02f, 8.62510428e-02f, -3.49701755e-03f, 9.87536758e-02f, 5.37084825e-02f, 6.40412867e-02f, -7.40753766e-03f, -5.18913828e-02f, -4.79055606e-02f,
  6.93763644e-02f, 1.55691728e-02f, 2.74649188e-02f, 4.47514765e-02f, -3.29077877e-02f, 5.05858064e-02f, -4.31716815e-02f, 3.69299687e-02f, -8.56528208e-02f, -1.01758361e-01f,
  -9.70683843e-02f, 6.62546977e-02f, 1.42038792e-01f, -2.01312266e-02f, -3.54568027e-02f, -5.96679188e-03f, 6.32788837e-02f, -5.17231114e-02f, -6.59750998e-02f, 1.99500881e-02f,
  -2.73161501e-01f, -7.88796023e-02f, 2.60067657e-02f, 8.62957910e-02f, 1.74476653e-01f, 1.35030136e-01f, 9.18316096e-02f, 7.27566099e-03f, -2.15864293e-02f, -4.76653315e-02f,
  -1.12137169e-01f, -6.11105980e-03f, 8.40497315e-02f, 5.27429618e-02f, -4.62606996e-02f, 1.27837628e-01f, 1.13752693e-01f, 3.71973217e-02f, -5.28078573e-03f, -8.22786540e-02f,
  1.27926901e-01f, 2.80371457e-02f, -9.95046347e-02f, 4.18766588e-02f, 1.46455735e-01f, 5.78185618e-02f, 5.36057241e-02f, 2.02023052e-02f, -2.02607047e-02f, 1.13855302e-01f,
  -1.70796767e-01f, -9.09522176e-02f, 1.03299215e-01f, -6.62532970e-02f, -3.51632684e-02f, -1.07156061e-01f, -6.94071874e-02f, 3.98581661e-03f, -4.79321331e-02f, -9.82958451e-02f,
  -4.18164358e-02f, -3.38068567e-02f, -6.27785921e-02f, 3.96153964e-02f, 1.73651837e-02f, 6.51961705e-03f, 8.25595669e-03f, -9.92178470e-02f, -3.49830091e-02f, -1.20130315e-01f,
  1.06110021e-01f, -2.48498563e-02f, -1.26745794e-02f, 3.27465199e-02f, -2.17291974e-02f, -1.01304382e-01f, -8.03689137e-02f, 3.98836024e-02f, -9.99667495e-02f, -1.48554236e-01f,
  3.37688848e-02f, 5.57606630e-02f, -3.69760916e-02f, -6.42210199e-03f, 4.66863774e-02f, 1.03758886e-01f, 1.47907808e-03f, 2.36287597e-03f, 6.13128170e-02f, 8.80582407e-02f,
  -7.30813807e-03f, 1.11229429e-02f, 2.79212501e-02f, -1.30014047e-01f, 1.68818180e-02f, -4.42854427e-02f, -5.76955341e-02f, 6.32593632e-02f, 1.72111411e-02f, 3.63016762e-02f,
  3.72665226e-02f, -7.61075541e-02f, -3.01818643e-02f, 6.48091733e-02f, -8.23228657e-02f, -6.92161545e-02f, -2.77732816e-02f, -4.02309038e-02f, -3.88292260e-02f, -8.78556147e-02f,
  -6.03576414e-02f, 3.97255272e-02f, -9.20951664e-02f, 4.41454947e-02f, 1.82927437e-02f, -4.10373434e-02f, -1.03608795e-01f, 3.23351077e-03f, -2.06256602e-02f, -4.68068421e-02f,
  -7.03116581e-02f, -1.05472781e-01f, -5.74373491e-02f, -2.34256871e-02f, -7.93144107e-02f, 3.68705913e-02f, 7.69297481e-02f, -1.43470429e-02f, -5.99072799e-02f, -3.15286359e-03f,
  8.65211412e-02f, -2.91138049e-02f, -5.63284382e-02f, -6.91230819e-02f, -4.51721996e-02f, -5.30578345e-02f, -1.14597134e-01f, -9.21454653e-02f, -1.37704639e-02f, -4.83869435e-03f,
  7.85275027e-02f, -1.37526199e-01f, -1.63888022e-01f, -1.13254026e-01f, -5.63431531e-02f, 3.39224003e-02f, -1.93765685e-02f, 4.00639251e-02f, -7.83683434e-02f, -1.08757593e-01f,
  -8.93792138e-02f, 6.61612600e-02f, 9.86269563e-02f, 8.77247453e-02f, 5.01576066e-02f, 3.56240720e-02f, -6.20836653e-02f, -1.46458829e-02f, 1.19600194e-02f, -6.12633210e-03f,
  3.19909528e-02f, -4.97763045e-02f, 9.35791899e-03f, 4.74118926e-02f, -1.73980091e-02f, 1.38842417e-02f, -2.78676581e-02f, 2.75026988e-02f, 5.84959239e-02f, -1.09257996e-01f,
  -1.40223950e-01f, -6.06871173e-02f, -2.65015177e-02f, 6.70442507e-02f, -7.27233961e-02f, 4.38777804e-02f, -3.44194137e-02f, 2.17835978e-03f, 7.64358044e-02f, -8.98571312e-02f,
  5.47040254e-03f, -7.84350410e-02f, -2.62387414e-02f, -7.00911433e-02f, 3.15981247e-02f, -9.23642069e-02f, -8.70623291e-02f, -9.44023654e-02f, 3.95410247e-02f, 3.69968005e-02f,
  -8.19852576e-02f, 8.05105194e-02f, -5.69802672e-02f, -6.97829053e-02f, 5.21909148e-02f, 8.61389562e-02f, -2.01456044e-02f, 3.93574089e-02f, -9.83606502e-02f, -7.45092006e-03f,
  -4.95507866e-02f, -6.94864839e-02f, 6.17346168e-02f, 6.96136011e-03f, 8.77640769e-02f, 4.66932990e-02f, 5.72979525e-02f, -1.81610491e-02f, -4.45631929e-02f, -8.68022814e-02f,
  -4.98175286e-02f, -8.21303725e-02f, 2.19261963e-02f, 8.93905163e-02f, 7.44805112e-02f, -1.09454393e-02f, -7.00519606e-02f, 4.02402952e-02f, 2.68497132e-02f, 1.14202835e-02f,
  6.96399808e-02f, 7.27591440e-02f, -6.73553720e-02f, -2.85660904e-02f, -1.40911927e-02f, -4.93968502e-02f, 8.73749778e-02f, 5.69681153e-02f, -2.86797760e-03f, 2.17239149e-02f,
  -1.42444909e-01f, -3.79884243e-03f, 8.69507715e-02f, 6.98203519e-02f, 6.92721233e-02f, 5.88621385e-02f, -3.05044781e-02f, -1.03027076e-01f, 6.86216429e-02f, -3.92332450e-02f,
  -8.84565562e-02f, 1.72915384e-02f, 2.08013188e-02f, -1.74436031e-03f, 5.89474961e-02f, 3.89012359e-02f, 7.13030025e-02f, 8.46604407e-02f, 8.96661580e-02f, 1.48939900e-02f,
  -2.31681927e-03f, 9.34854150e-02f, -4.92182076e-02f, -7.54959062e-02f, -4.50460054e-02f, 1.16834641e-01f, 7.93548767e-03f, -2.00066846e-02f, 2.16333028e-02f, 3.75842825e-02f,
  -1.83105826e-01f, 2.71764793e-03f, -2.55738441e-02f, 1.18207566e-01f, 2.21514300e-01f, 1.11969732e-01f, 2.13156659e-02f, 3.61598632e-03f, 2.54523400e-02f, 3.65147926e-02f,
  1.74268529e-01f, 1.83137074e-01f, -2.84355003e-02f, 9.54416692e-02f, 2.40444932e-02f, 1.71580259e-02f, 9.30794701e-02f, -3.79602127e-02f, -1.17534123e-01f, 6.11732751e-02f,
  2.04674706e-01f, 1.01998553e-01f, -9.00506750e-02f, 8.21886584e-02f, 2.28203401e-01f, 2.72062626e-02f, -4.79839258e-02f, 8.73265415e-02f, 1.46485806e-01f, 2.89911807e-01f,
  2.58479342e-02f, -2.98501011e-02f, -5.47447093e-02f, 1.23428509e-01f, -8.52175523e-03f, -6.03320934e-02f, -2.65972279e-02f, -5.00251423e-04f, -3.15948203e-02f, -8.09641108e-02f,
  8.99098516e-02f, -3.24648730e-02f, 6.82259798e-02f, -7.56178647e-02f, -1.37552559e-01f, -1.40901178e-01f, -9.40916464e-02f, -1.66067153e-01f, -1.00537941e-01f, -3.86112072e-02f,
  1.93045840e-01f, 1.38386562e-01f, -1.40961066e-01f, -1.88546360e-01f, -1.48979858e-01f, 3.99737954e-02f, -1.29707500e-01f, -2.50675194e-02f, -9.93764177e-02f, -1.46047279e-01f,
  -4.96667512e-02f, 7.13010179e-03f, -5.02337962e-02f, -2.88124904e-02f, 2.50805244e-02f, -1.99839640e-02f, 4.57448438e-02f, 5.02090938e-02f, 6.31634817e-02f, -2.33687740e-02f,
  -4.41203006e-02f, -5.13165221e-02f, -8.16270858e-02f, 6.11918569e-02f, 5.49427420e-02f, 9.20565575e-02f, 1.03960924e-01f, -3.93481739e-02f, 1.14852010e-04f, 2.25429479e-02f,
  -3.02571543e-02f, -5.62786236e-02f, 2.08218936e-02f, -6.45716563e-02f, -5.72025124e-03f, 2.80319378e-02f, 5.92149124e-02f, -3.03204264e-02f, -8.71651471e-02f, 4.35702875e-03f,
  -2.18136519e-01f, -1.85337707e-01f, -5.27372584e-04f, -1.09328493e-01f, -1.51496183e-03f, -1.00598276e-01f, 5.40209822e-02f, -7.70132020e-02f, 7.83115476e-02f, -3.86588424e-02f,
  -1.68250464e-02f, -8.19796398e-02f, 1.50432633e-02f, -8.60790983e-02f, 2.09329110e-02f, -1.25391051e-01f, 2.67831646e-02f, -5.54262772e-02f, -1.12469584e-01f, 2.06919238e-02f,
  -9.32725146e-02f, -7.28468820e-02f, -5.31151816e-02f, -7.80787319e-02f, 3.71000916e-03f, -4.78534587e-02f, -1.35687411e-01f, -7.78537542e-02f, -1.78667530e-01f, -1.83351442e-01f,
  -4.65768166e-02f, 6.43062294e-02f, -1.01883180e-01f, -3.72685082e-02f, 4.81695533e-02f, -5.67495935e-02f, -4.06647027e-02f, 5.95841892e-02f, 6.33597374e-02f, 7.21215904e-02f,
  -5.76955117e-02f, -8.87065846e-03f, 4.67875227e-02f, 4.31619696e-02f, 2.98714340e-02f, -2.50109416e-02f, -5.47677651e-03f, -3.81335132e-02f, -9.23963785e-02f, 4.25996929e-02f,
  3.70172635e-02f, 4.65298742e-02f, 5.30100204e-02f, 4.46040034e-02f, 8.49520192e-02f, 4.19406267e-03f, 2.51316093e-02f, 3.57628390e-02f, 9.77068096e-02f, -7.20082372e-02f,
  -9.25795361e-02f, -1.46495789e-01f, 1.53429080e-02f, 1.00042112e-02f, -8.38890076e-02f, -6.95297271e-02f, -1.75589118e-02f, -6.53172880e-02f, -6.44782977e-03f, -6.38103262e-02f,
  -9.29330587e-02f, 6.08040653e-02f, 6.68712929e-02f, -5.66683970e-02f, 8.06883946e-02f, -2.44323350e-02f, 1.98480971e-02f, -7.73614123e-02f, 6.46191463e-02f, -1.38408793e-02f,
  -4.14416939e-02f, -6.63614050e-02f, -1.80544984e-02f, 4.68143374e-02f, -5.56613691e-02f, -3.72178815e-02f, 2.95787770e-03f, 1.07617723e-02f, -1.25185087e-01f, 2.08455864e-02f,
  -2.53570005e-02f, -5.26523255e-02f, -5.84451146e-02f, 9.30486917e-02f, 7.79788047e-02f, 2.92080883e-02f, -2.40280814e-02f, 7.67441317e-02f, 2.66477279e-02f, -8.36295709e-02f,
  -3.94091718e-02f, -4.05829623e-02f, -8.75353508e-05f, -1.63178146e-02f, 2.78027430e-02f, 2.53125816e-03f, 8.16040710e-02f, 9.26597863e-02f, 2.98752338e-02f, -5.56961633e-02f,
  6.22543041e-03f, 5.67610152e-02f, 8.34002346e-02f, -3.86801511e-02f, 6.47691488e-02f, 6.49597868e-02f, -3.17745693e-02f, 9.00130868e-02f, -6.48432374e-02f, -7.12550208e-02f,
  5.71103767e-02f, 4.03483957e-02f, -3.43192406e-02f, 7.16962144e-02f, -1.72116961e-02f, 1.62633427e-03f, -7.22905993e-02f, 7.75285661e-02f, -8.73491690e-02f, 2.05776095e-02f,
  5.03689498e-02f, 6.80283457e-02f, 1.83368456e-02f, 7.53582194e-02f, -4.56534922e-02f, -8.11107457e-02f, -4.28028814e-02f, -5.77440299e-02f, -2.05155089e-02f, -8.69598910e-02f,
  1.20106772e-01f, -1.58118606e-02f, -1.11897796e-01f, -2.93388367e-02f, -2.69508809e-02f, -8.18700939e-02f, -6.19162396e-02f, -4.63411510e-02f, -9.32069346e-02f, -5.09705581e-03f,
  -6.44878745e-02f, -2.63954159e-02f, -2.34696902e-02f, -2.73566763e-03f, 8.06877092e-02f, 2.56782044e-02f, 1.08376881e-02f, 4.25556675e-02f, -2.84038279e-02f, -7.13867024e-02f,
  -4.10442911e-02f, 3.24358456e-02f, -5.69214895e-02f, -4.49914075e-02f, 4.41472456e-02f, -1.07917681e-01f, -1.24633707e-01f, -7.98284039e-02f, 1.13604277e-01f, -1.38785634e-02f,
  1.01859994e-01f, -5.98067865e-02f, 8.20632726e-02f, 3.84051149e-04f, 7.52221122e-02f, -6.86847940e-02f, -3.81903462e-02f, 7.74413953e-03f, 8.01350474e-02f, -5.74941374e-02f,
  2.20238119e-02f, -9.49109122e-02f, -4.38414179e-02f, 1.81941595e-02f, 7.21451417e-02f, -7.44633004e-02f, -4.35224809e-02f, 1.19995810e-02f, -4.04951721e-02f, 4.95323651e-02f,
  3.91223095e-02f, -7.67621771e-02f, -5.17329574e-02f, 1.36517845e-02f, -4.10164259e-02f, 2.48211361e-02f, -1.67105719e-02f, 6.63155243e-02f, -7.85484761e-02f, -9.77048203e-02f,
  1.03425525e-01f, 2.45437548e-02f, -9.29665118e-02f, 5.02955019e-02f, 7.38212019e-02f, 1.21166594e-02f, 4.97560799e-02f, -7.21582547e-02f, 5.67472018e-02f, -4.38532382e-02f,
  4.13207933e-02f, 1.67697519e-02f, -2.92093921e-02f, -8.88579637e-02f, -6.34961128e-02f, 7.47131184e-03f, -5.10670058e-02f, 1.37719633e-02f, 1.07304612e-02f, 7.42298961e-02f,
  3.51880975e-02f, -8.20076615e-02f, 9.66375098e-02f, 6.75866082e-02f, -8.53906646e-02f, -8.24342519e-02f, 5.84416017e-02f, 7.56602064e-02f, 1.78347919e-02f, 7.49192238e-02f,
  4.01737355e-02f, -2.00818591e-02f, -8.64853039e-02f, -3.95123065e-02f, -6.19240142e-02f, -8.83774161e-02f, -1.27424009e-03f, 9.56929326e-02f, 1.51363835e-02f, -7.71698132e-02f,
  7.47760758e-03f, 1.02886997e-01f, -3.48905139e-02f, -7.45952502e-02f, 8.45373888e-03f, 6.04673959e-02f, 3.39244977e-02f, 7.22094327e-02f, 5.89623898e-02f, -7.45431148e-03f,
  -2.57779341e-02f, 3.96627411e-02f, -6.68398887e-02f, 2.23825052e-02f, 1.05254725e-02f, 6.83533549e-02f, -3.75917889e-02f, -4.06039208e-02f, 1.31365480e-02f, -5.56068011e-02f,
  -3.77231054e-02f, -7.58815045e-03f, 1.88579839e-02f, -6.39258251e-02f, -8.09606090e-02f, -4.69571687e-02f, -8.01538453e-02f, -8.90858099e-02f, -2.37295330e-02f, -1.09130748e-01f,
  -8.04295614e-02f, -3.08946557e-02f, -7.42581412e-02f, -1.25746345e-02f, 1.10003404e-01f, 6.64623603e-02f, 1.42586842e-01f, 1.54183850e-01f, 1.93809718e-02f, -3.86755206e-02f,
  -5.89446537e-02f, -4.26544324e-02f, -1.26017556e-01f, -9.81678441e-02f, -5.36496714e-02f, 2.70009171e-02f, -1.19360620e-02f, -5.76464310e-02f, -8.22176486e-02f, 1.11353040e-01f,
  1.39269963e-01f, 8.37621093e-02f, 8.89745355e-03f, 2.35270485e-02f, -3.19206640e-02f, 1.91155467e-02f, -4.93193641e-02f, 4.69028689e-02f, 4.95149894e-03f, -2.90431157e-02f,
  -1.06972195e-01f, -7.06323143e-03f, -2.79299766e-02f, 6.28923848e-02f, -1.35917485e-01f, -3.83528927e-03f, 4.43388149e-02f, 6.38182238e-02f, -6.52662143e-02f, 1.01628922e-01f,
  -1.13126829e-01f, -4.25048023e-02f, -3.99349891e-02f, 1.22025330e-02f, -4.48995940e-02f, 6.59230128e-02f, 9.08313878e-03f, -8.40874314e-02f, -2.24279147e-03f, -4.57193404e-02f,
  3.72448415e-02f, 1.65752172e-02f, -5.28037809e-02f, -9.69853848e-02f, -6.70806393e-02f, -1.85251907e-02f, -1.02259144e-01f, -9.70430598e-02f, -3.82832028e-02f, 8.32427368e-02f,
  -6.00868985e-02f, 1.43724624e-02f, 7.62497410e-02f, -2.83043757e-02f, -5.92051148e-02f, 2.44934973e-03f, 1.00332737e-01f, 1.15378618e-01f, 1.24826051e-01f, 2.53862925e-02f,
  -5.80998361e-02f, -8.71358439e-02f, 1.65030565e-02f, -1.62210409e-02f, -9.22911838e-02f, -5.21098338e-02f, 3.47460248e-02f, 9.07421485e-02f, 6.40725121e-02f, -6.67823665e-03f,
  -7.08609000e-02f, 4.34208177e-02f, 6.95938990e-02f, 5.08335717e-02f, -2.05676276e-02f, -2.79498510e-02f, -7.46705160e-02f, -7.20919052e-04f, -9.17630270e-02f, -3.24613526e-02f,
  2.42010519e-01f, -6.19319007e-02f, 4.37203096e-03f, 5.21429367e-02f, 2.85210013e-02f, -7.14365393e-02f, 3.40772904e-02f, -7.73243383e-02f, 2.38213725e-02f, 1.00818716e-01f,
  6.70108292e-03f, 3.06161996e-02f, -2.83705890e-02f, -1.73409411e-03f, 8.72772187e-02f, -2.63779168e-03f, 2.67975423e-02f, 8.06060582e-02f, -7.55181462e-02f, 1.43032204e-02f,
  5.50957173e-02f, 1.04047582e-01f, 1.12682648e-01f, -6.12573549e-02f, -7.01661259e-02f, 4.01761606e-02f, 1.33334324e-01f, 7.94608667e-02f, 3.14579681e-02f, 2.53989577e-01f,
  7.14721158e-02f, -5.70150129e-02f, -1.06415205e-01f, 6.28913268e-02f, -5.21306023e-02f, -5.31569608e-02f, 3.45342644e-02f, 7.85838291e-02f, 6.84395134e-02f, -3.69498110e-03f,
  5.44349216e-02f, 6.12336844e-02f, -1.09127201e-02f, 2.77226623e-02f, 2.36886051e-02f, -1.03370838e-01f, -2.81405225e-02f, 1.38578173e-02f, 8.08978826e-02f, -4.52777520e-02f,
  -3.00583011e-03f, -6.23470210e-02f, 3.35149504e-02f, 3.76178771e-02f, -4.01254967e-02f, -8.16329867e-02f, -1.51979253e-02f, -4.86862883e-02f, 2.07256060e-02f, 4.61230427e-02f,
  -1.22920416e-01f, -4.09019627e-02f, 2.20844839e-02f, -4.26136032e-02f, 3.04572447e-03f, 5.79659939e-02f, -3.87053378e-02f, -2.97601428e-02f, 1.63099393e-02f, 6.50038272e-02f,
  -8.78732279e-02f, 2.22502928e-02f, 3.49015407e-02f, -4.86386148e-03f, -4.39628288e-02f, 5.10372482e-02f, 8.11087191e-02f, -9.63274986e-02f, -8.29002485e-02f, -3.83815169e-02f,
  4.27999496e-02f, 7.15720281e-02f, 6.88692927e-02f, 6.87983185e-02f, -1.20125730e-02f, -4.56533916e-02f, -7.47275725e-02f, -3.34856249e-02f, 4.82013524e-02f, 3.67338140e-03f,
  2.71490552e-02f, -2.54888218e-02f, -1.92432143e-02f, -5.12625091e-03f, -3.46471108e-02f, -7.32375011e-02f, -8.83732140e-02f, 1.49895838e-02f, 6.32068738e-02f, -8.44364893e-03f,
  -8.45897347e-02f, 1.67470183e-02f, -5.95574155e-02f, 7.25793689e-02f, 8.19304213e-02f, 6.47645667e-02f, -1.13418652e-02f, 4.19115722e-02f, -1.09313298e-02f, -6.93913996e-02f,
  7.36532211e-02f, 8.22209939e-03f, -5.28627448e-02f, -4.41277325e-02f, -5.57074100e-02f, 7.41468146e-02f, -1.36843836e-02f, 7.63994306e-02f, -1.60847474e-02f, 4.43872437e-02f,
  4.11164481e-03f, 1.07341468e-01f, 8.76164436e-02f, 7.26195052e-02f, 5.33046341e-03f, 7.10588470e-02f, -1.17399553e-02f, -4.86035272e-02f, 7.08988160e-02f, -9.68269110e-02f,
  -4.41224724e-02f, -1.05924783e-02f, -8.24582577e-02f, 4.16766554e-02f, 4.27302793e-02f, -8.38475153e-02f, -4.34722789e-02f, 6.28758967e-02f, -1.44740902e-02f, 5.60164191e-02f,
  5.74956499e-02f, 1.95352547e-02f, -1.97733659e-02f, 2.23979037e-02f, -6.05733693e-02f, 7.79389367e-02f, -7.49786943e-02f, 4.80292253e-02f, 4.78244387e-03f, 5.10016605e-02f,
  -1.37591243e-01f, 2.43418757e-02f, -8.51403028e-02f, -2.66967744e-01f, -1.23672122e-02f, -5.41348308e-02f, 1.35206148e-01f, 2.48002112e-02f, -1.48845017e-01f, 1.59960762e-02f,
  -2.77681779e-02f, -1.26534060e-01f, 1.14171626e-02f, -5.39552309e-02f, 1.25420749e-01f, 6.38565421e-02f, -5.13955252e-03f, -9.82766971e-02f, 2.31269468e-02f, 6.61195666e-02f,
  3.02641895e-02f, -1.15571409e-01f, -5.27710281e-02f, -1.34119675e-01f, -1.44571751e-01f, -6.47884011e-02f, -4.94815223e-02f, -1.20543361e-01f, -6.16249703e-02f, -1.77326947e-02f,
  7.89161474e-02f, -3.34793888e-02f, -4.55390066e-02f, -4.70362356e-05f, -1.14954539e-01f, -3.97248305e-02f, -7.05780238e-02f, -6.89092577e-02f, -1.01194642e-01f, -1.23256408e-02f,
  -5.67115322e-02f, 8.55903514e-03f, -1.10873319e-02f, 5.70732467e-02f, -1.72429893e-03f, 3.48062851e-02f, -4.79012392e-02f, -7.29779229e-02f, -6.01746840e-03f, 8.59213024e-02f,
  2.05052849e-02f, 1.74255427e-02f, -3.89148779e-02f, 5.04547870e-03f, 3.59093398e-02f, -1.07071750e-01f, -3.57256755e-02f, -5.84932640e-02f, 5.14921658e-02f, 5.67472503e-02f,
  1.14239149e-01f, 3.60588394e-02f, -7.07221106e-02f, -5.89836501e-02f, 5.80215901e-02f, -1.25759849e-04f, 7.19291195e-02f, 1.27621898e-02f, -8.01062286e-02f, 6.24698885e-02f,
  -3.09147727e-04f, 3.61401327e-02f, 1.89896449e-02f, -6.43565552e-03f, -3.93798575e-03f, -1.63523369e-02f, -3.88835669e-02f, 1.32852018e-01f, -5.18970527e-02f, 5.02072694e-03f,
  2.94710528e-02f, 2.98113581e-02f, 3.28988656e-02f, -1.53961452e-02f, 7.74721578e-02f, -6.66999668e-02f, 7.43092075e-02f, -2.54223514e-02f, -1.86713655e-02f, -1.73475891e-02f,
  -3.66718285e-02f, 1.26667231e-01f, 1.72624364e-02f, -4.21705693e-02f, -1.05885956e-02f, 9.60883405e-03f, -6.18842207e-02f, 3.10906544e-02f, -2.45969091e-02f, -4.14335951e-02f,
  5.86514324e-02f, 3.89424376e-02f, -6.29258752e-02f, 1.90449208e-02f, -7.18296319e-02f, 2.16576997e-02f, -4.90915589e-02f, -4.27565351e-02f, 7.85994157e-02f, 1.32868541e-02f,
  7.42005110e-02f, 4.55642566e-02f, 6.23632036e-02f, 5.91425784e-02f, 5.07760085e-02f, -8.67468566e-02f, 1.09522462e-01f, 2.37632673e-02f, 1.17375627e-01f, 2.24651559e-03f,
  1.55164972e-01f, -1.42903522e-01f, -5.98974153e-02f, 3.87362726e-02f, -5.50133847e-02f, -3.85295637e-02f, -8.12801570e-02f, 6.08671978e-02f, -1.95427313e-02f, 6.28800690e-02f,
  -4.62641194e-02f, 7.11020902e-02f, 1.37690589e-01f, 1.84589058e-01f, 1.41796216e-01f, 4.41445224e-02f, 7.62484819e-02f, 1.52078927e-01f, 2.10381404e-01f, 5.34615330e-02f,
  2.88052242e-02f, -1.77167095e-02f, -4.04513590e-02f, -1.32019920e-02f, -7.98102021e-02f, 7.59160742e-02f, 4.62378338e-02f, -7.82272145e-02f, -5.40373428e-03f, 6.31613191e-03f,
  -6.90744147e-02f, -3.02691013e-02f, 1.55858964e-01f, 8.36601853e-02f, -8.41779709e-02f, -4.02766205e-02f, -1.24208657e-02f, -1.06542774e-01f, -5.71625978e-02f, -2.05183979e-02f,
  1.25602435e-03f, 8.98297578e-02f, -4.53648902e-02f, -1.02218620e-01f, -4.55127396e-02f, 3.08077578e-02f, 1.91556942e-02f, 7.17587769e-03f, 3.01265642e-02f, -1.03345960e-01f,
  4.11589853e-02f, -2.68657021e-02f, 4.17974740e-02f, 6.47751093e-02f, 4.66780365e-02f, 1.53821081e-01f, -1.17393851e-01f, 2.20286380e-02f, 6.33566678e-02f, -4.54423651e-02f,
  -2.26295311e-02f, -6.10259082e-03f, 6.24595501e-04f, 1.05320610e-01f, -2.36526690e-03f, 1.23359583e-01f, 1.77459046e-02f, 8.89038369e-02f, 3.82818505e-02f, 1.95568688e-02f,
  8.27535316e-02f, 4.95301671e-02f, 6.83570607e-03f, 1.05119847e-01f, 1.04125015e-01f, -5.75163029e-03f, -4.72214743e-02f, 2.55625113e-03f, 4.32625301e-02f, -2.83062477e-02f,
  1.00226656e-01f, -1.50292842e-02f, -9.22187343e-02f, 7.69828707e-02f, -2.93596461e-02f, -7.00230002e-02f, -6.85257167e-02f, -2.85422616e-02f, -7.87364170e-02f, 8.08274820e-02f,
  -1.35128304e-01f, 1.42672077e-01f, 6.16174787e-02f, 2.92669050e-02f, -6.49061948e-02f, 1.20006828e-02f, -6.16025366e-02f, 3.68135534e-02f, -6.01936057e-02f, -9.13384482e-02f,
  -1.06959708e-01f, -5.57518899e-02f, -5.99326417e-02f, -5.34399301e-02f, 1.91952586e-02f, -4.87998053e-02f, -1.08684048e-01f, -1.81597956e-02f, 8.33135247e-02f, 2.47755256e-02f,
  2.91664284e-02f, 9.96052474e-02f, 1.04908680e-03f, -1.36594707e-03f, -4.72041704e-02f, 1.94575787e-01f, 5.98855130e-02f, 1.13623142e-02f, 1.40279114e-01f, -6.71958849e-02f,
  -1.76396638e-01f, 1.08749764e-02f, -7.32640997e-02f, 3.88308428e-03f, -8.32191035e-02f, -2.57605612e-02f, -8.08595270e-02f, 2.23431531e-02f, -2.80805565e-02f, -1.46528017e-02f,
  -8.67285505e-02f, 1.10497497e-01f, -6.78973794e-02f, -3.63717712e-02f, -6.00280315e-02f, 2.46146601e-02f, -1.46567494e-01f, -6.19471222e-02f, 7.68375918e-02f, 9.03743654e-02f,
  7.52879158e-02f, -2.58434378e-02f, -2.94418391e-02f, -3.13431583e-02f, -6.48770947e-03f, 8.96597058e-02f, -1.04265742e-03f, -3.39835919e-02f, 1.18175438e-02f, 3.11019295e-03f,
  2.72375971e-01f, -9.78453010e-02f, 4.43050079e-02f, 3.41360178e-03f, -1.07815070e-03f, 6.84794262e-02f, -3.79150547e-02f, -1.40166907e-02f, -5.55262603e-02f, -4.42922823e-02f,
  7.99683575e-03f, -1.38619607e-02f, 4.91455235e-02f, 9.20049250e-02f, 3.59437093e-02f, -4.91298065e-02f, 6.74706250e-02f, -5.36230616e-02f, 8.13041106e-02f, -3.04931030e-03f,
  -3.43258120e-02f, 7.06378967e-02f, -2.14000382e-02f, 3.13854106e-02f, 4.17601578e-02f, 3.61351892e-02f, -2.78905258e-02f, -3.25186998e-02f, -1.37558521e-03f, 6.69075772e-02f,
  -4.17410210e-02f, -6.67163432e-02f, 2.98295468e-02f, -5.30368201e-02f, 2.17532404e-02f, 3.94243039e-02f, 3.90584804e-02f, 4.31660004e-02f, -6.43523708e-02f, 1.47923799e-02f,
  7.97747001e-02f, 4.82089482e-02f, -1.14839831e-02f, -3.04519385e-02f, 1.00618474e-01f, -6.99863136e-02f, -2.11478416e-02f, 6.26865551e-02f, 2.81543899e-02f, -3.50030325e-02f,
  1.13296434e-02f, 2.15776786e-02f, 4.35942449e-02f, 4.98125143e-02f, 5.18084206e-02f, -8.91393945e-02f, -4.84390697e-03f, 6.33415207e-02f, 7.85817131e-02f, -8.40183869e-02f,
  1.61435321e-01f, 6.09512627e-02f, 7.21812546e-02f, -2.05445569e-02f, 1.82466442e-03f, -5.89734167e-02f, -3.32394168e-02f, 1.71571430e-02f, -4.86390740e-02f, -6.35798201e-02f,
  9.55731794e-02f, 1.21799326e-02f, -1.78894890e-03f, -1.72896329e-02f, -1.28552979e-02f, 1.00073531e-01f, -2.52305474e-02f, 6.38236031e-02f, -4.98343781e-02f, 8.84741321e-02f,
  -2.58977339e-02f, -8.72477889e-03f, -7.20431134e-02f, 2.65566502e-02f, -5.80400079e-02f, 2.19453312e-02f, 1.37123495e-01f, 9.31158364e-02f, -4.93662804e-02f, 2.00657137e-02f,
  3.18052202e-01f, -1.25008345e-01f, -1.27166614e-01f, 1.18310042e-02f, 1.37004741e-02f, -1.29442522e-02f, 4.09289636e-02f, 2.35958397e-03f, 1.52181864e-01f, -2.84410827e-02f,
  6.60481378e-02f, 5.40957265e-02f, 1.68310896e-01f, 5.74692599e-02f, 1.20075874e-01f, -8.43369588e-02f, -3.84018533e-02f, 6.64023906e-02f, 4.79209013e-02f, -2.30014324e-02f,
  -3.09614185e-02f, 2.82020587e-02f, -1.39374109e-02f, -6.48708940e-02f, 9.67369415e-04f, 9.76139531e-02f, -6.24243431e-02f, 1.37808686e-02f, -5.52923717e-02f, -7.55848810e-02f,
  -9.28271115e-02f, -4.62420322e-02f, 2.25790385e-02f, 4.66992930e-02f, -8.49156082e-02f, -9.76783708e-02f, 6.89496323e-02f, -4.27263528e-02f, -1.33627076e-02f, -1.17505319e-01f,
  7.10246041e-02f, -7.62766600e-02f, 1.39556164e-02f, 2.62682997e-02f, -6.87686205e-02f, -7.45483860e-02f, 2.20290888e-02f, -8.19223076e-02f, -6.39493763e-03f, 1.56039707e-02f,
  -9.45551880e-03f, -9.12898257e-02f, 7.29323402e-02f, -7.29968026e-02f, 6.93510100e-02f, 9.59288403e-02f, -1.23347484e-01f, -2.13953964e-02f, 6.45710155e-02f, 2.37451103e-02f,
  2.77584307e-02f, 5.36896102e-02f, 4.91976775e-02f, 3.66365677e-03f, 2.20002625e-02f, 7.59614781e-02f, 7.21597746e-02f, -5.17259911e-02f, 6.32506460e-02f, -7.56013617e-02f,
  6.74951635e-03f, -6.47080094e-02f, 1.24890450e-02f, -1.49964530e-03f, -1.51840113e-02f, -5.14176209e-03f, 7.19941854e-02f, -5.57354353e-02f, -8.75061098e-03f, -2.05472130e-02f,
  3.38676646e-02f, -7.67114758e-02f, -7.72262439e-02f, -1.03792854e-01f, -3.26522850e-02f, 8.93081948e-02f, 7.35977441e-02f, 5.79537489e-02f, 8.47753361e-02f, -6.82558864e-03f,
  5.21619208e-02f, 1.19713448e-01f, 9.13000926e-02f, 2.50884034e-02f, 4.58061770e-02f, 1.29959406e-02f, 4.86366786e-02f, 3.89493676e-03f, 1.73516609e-02f, 5.66319609e-03f,
  -7.02528954e-02f, -2.73654982e-02f, -4.71543483e-02f, 6.11409126e-03f, -3.66099291e-02f, -9.27668810e-02f, 4.53503951e-02f, 7.30897039e-02f, -1.27876922e-02f, -1.24500535e-01f,
  -1.28674787e-02f, 9.34474692e-02f, 6.88564330e-02f, 1.38014749e-01f, 9.58042394e-04f, 1.76714793e-01f, 5.68328314e-02f, -4.55021486e-02f, 8.50420222e-02f, -3.46344896e-03f,
  -2.94146910e-02f, 9.23288092e-02f, -5.79008162e-02f, -8.77449363e-02f, -1.53705329e-01f, 1.00112148e-02f, 7.01904893e-02f, 2.92284545e-02f, -5.53015843e-02f, 1.03281990e-01f,
  3.46937180e-02f, -1.13298938e-01f, -4.92550097e-02f, -1.60424009e-01f, -1.21839166e-01f, 8.56587142e-02f, -6.37067035e-02f, -1.34842739e-01f, -1.36056781e-01f, -2.24660277e-01f,
  -1.84841335e-01f, -2.04920933e-01f, -1.20607600e-01f, -1.06212772e-01f, -1.20002171e-02f, -9.53502581e-02f, -5.88037632e-02f, -1.06234595e-01f, -8.71643610e-03f, 3.73405637e-03f,
  6.64385334e-02f, 2.01122090e-02f, -2.51313057e-02f, -1.68872904e-02f, 7.44749084e-02f, 3.83632630e-02f, -4.46120165e-02f, 7.43039325e-02f, 6.94405586e-02f, 5.35017624e-02f,
  -5.38437553e-02f, -2.43475921e-02f, -3.82698514e-02f, -1.04172766e-01f, 1.55210122e-03f, -3.24700074e-03f, 6.22031838e-02f, 3.37671116e-02f, 1.93988122e-02f, 1.16180830e-01f,
  -5.63993119e-02f, -1.21063022e-02f, -8.77992213e-02f, -2.67238319e-02f, 4.58031259e-02f, -7.82433897e-02f, -8.71289000e-02f, -2.15255003e-02f, -7.93434605e-02f, -7.70078599e-03f,
  -1.03065595e-02f, -1.11299399e-02f, 4.60462309e-02f, -3.15138511e-02f, 3.36192958e-02f, 5.15972152e-02f, -5.89421056e-02f, 1.58965439e-02f, -4.79678623e-02f, -2.27272119e-02f,
  -3.30390334e-02f, 4.11490276e-02f, 5.24235517e-02f, 7.51387142e-03f, -6.77490011e-02f, 3.50043811e-02f, -4.86283153e-02f, 6.03779107e-02f, -3.34407613e-02f, -6.19706325e-02f,
  -2.19046883e-02f, 8.46826807e-02f, 3.60959247e-02f, 7.27720559e-02f, -4.25927751e-02f, 7.48975724e-02f, -5.63672669e-02f, -3.84172145e-03f, -9.63639766e-02f, -5.35064079e-02f,
  4.34903204e-02f, -1.26673415e-01f, -7.99487811e-03f, -6.78401813e-02f, 5.01287393e-02f, 1.03949182e-01f, -1.75895821e-02f, 4.71112579e-02f, -6.26669601e-02f, 4.95021790e-02f,
  -1.21107578e-01f, -4.69158553e-02f, 2.19694320e-02f, -8.97155032e-02f, -1.21672653e-01f, -6.11889511e-02f, -2.80258600e-02f, 7.28662917e-03f, 5.53166084e-02f, -1.39669445e-03f,
  1.25498503e-01f, -1.13630496e-01f, 3.76903303e-02f, 9.54566494e-05f, 2.93177590e-02f, -8.19930732e-02f, -6.08674623e-02f, 1.24547509e-02f, -5.83591312e-02f, -3.06830145e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  6.39524683e-02f, 1.07940607e-01f, 1.04612313e-01f, 2.83496715e-02f, 2.80404799e-02f, -1.52269553e-03f, 8.88153687e-02f, 1.56443298e-01f, 1.01148203e-01f, 4.25385274e-02f,
  3.41132544e-02f, 1.27197191e-01f, 1.48018777e-01f, 1.49984623e-03f, 8.42002258e-02f, 4.37708981e-02f, 8.35722592e-03f, -3.74908485e-02f, 1.53545782e-01f, 1.19518586e-01f,
  2.52451926e-01f, 1.18596978e-01f, 5.71630783e-02f, 1.92110598e-01f, 1.05961196e-01f, 4.83687595e-02f, 7.05607012e-02f, -2.84737367e-02f, 1.97892785e-02f, 1.13400601e-01f,
  8.56879279e-02f, -2.88932472e-02f, -4.31422703e-02f, 1.43772379e-01f, 4.06346470e-02f, 3.82433087e-02f, 7.85792544e-02f, 2.95293462e-02f, 1.50750160e-01f, 7.40192831e-02f,
  -6.34314585e-03f, 6.09992351e-03f, 1.63413644e-01f, 1.20113477e-01f, -3.48527431e-02f, 1.94704458e-01f, 8.47514346e-03f, 1.55965760e-01f, 1.36590689e-01f, -1.22781703e-02f,
  9.05018076e-02f, 1.12344816e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -3.09354365e-01f, -2.37412944e-01f, -9.11076665e-02f, 5.61419316e-02f, 2.03053225e-02f, 1.46554574e-01f, -1.15022965e-01f, -4.13368344e-01f, -6.57344982e-02f, -2.79274791e-01f,
  -1.29110575e-01f, -1.03952810e-01f, 2.05349594e-01f, -8.79909247e-02f, -2.45559067e-02f, -1.52082786e-01f, -2.02950686e-01f, -1.53052747e-01f, 1.50544032e-01f, -1.27963126e-01f,
  4.27150913e-02f, 4.40190248e-02f, -2.08454207e-01f, -2.30908051e-01f, -7.13533983e-02f, -1.49904937e-01f, -5.47532856e-01f, 9.94636714e-02f, 1.00567915e-01f, 7.83511475e-02f,
  1.26451373e-01f, -1.08659163e-01f, -2.29489192e-01f, 1.89781800e-01f, -6.79843798e-02f, -2.02879593e-01f, 2.26790756e-02f, -1.93899691e-01f, -2.83624947e-01f, -2.10906103e-01f,
  -8.17020237e-02f, -1.18570231e-01f, 1.66577145e-01f, 5.60383908e-02f, -3.11437637e-01f, 8.33180398e-02f, 8.34631696e-02f, -3.06851894e-01f, -2.28929743e-01f, 1.89543948e-01f,
  1.21951714e-01f, -1.94085702e-01f, 2.26513848e-01f, 1.14684269e-01f, 5.27208686e-01f, 3.15138400e-01f, -1.84116177e-02f, 3.20473790e-01f, -7.03300908e-02f, -1.50432512e-01f,
  -1.58513263e-01f, -2.13120624e-01f, 1.25721544e-01f, 1.62068292e-01f, 2.04670608e-01f, 4.23221290e-02f, 5.14871895e-01f, -1.46692380e-01f, 8.85615051e-02f, 1.47900030e-01f,
  -6.32024780e-02f, -3.54393683e-02f, -1.80104792e-01f, 4.91866209e-02f, 5.76697849e-02f, 3.17560256e-01f, -9.43346769e-02f, -1.91325977e-01f, -5.37758395e-02f, 2.52500266e-01f,
  -1.30105644e-01f, 2.16075182e-01f, -4.09240127e-02f, -1.18669420e-01f, -5.85653260e-02f, -2.25448534e-02f, 4.03780043e-02f, -6.70379121e-03f, -1.71983823e-01f, -1.25212684e-01f,
  1.65937364e-01f, -1.24257550e-01f, -9.25356597e-02f, 5.92564568e-02f, -2.83534467e-01f, 1.78674892e-01f, -2.09510103e-01f, -7.60876909e-02f, 5.66951990e-01f, 1.09663658e-01f,
  -6.05797879e-02f, 1.72020182e-01f, 9.44730639e-02f, -3.70033495e-02f, 3.50005850e-02f, -1.81257389e-02f, 4.39681262e-02f, -7.87241906e-02f, 1.00468926e-01f, 5.03000617e-02f,
  -8.76309350e-03f, 5.88554516e-02f, -4.84487824e-02f, -1.47773743e-01f, 3.46872300e-01f, -2.57963371e-02f, -4.02631750e-03f, 9.64628607e-02f, -4.95596118e-02f, 6.38753399e-02f,
  1.32545710e-01f, 1.41181096e-01f, 4.76485230e-02f, 5.03896624e-02f, -1.10523887e-01f, 7.96833560e-02f, -5.72047457e-02f, -5.06564826e-02f, 1.86698213e-02f, 6.72218949e-03f,
  3.00721284e-02f, -1.65281102e-01f, 1.71493307e-01f, -2.95134727e-02f, 3.80052775e-02f, -2.97335535e-01f, 2.86968678e-01f, 1.39786527e-01f, 8.52292404e-02f, -2.71001041e-01f,
  6.05894178e-02f, 2.66559571e-01f, -3.41266423e-01f, -1.72376961e-01f, -2.03853831e-01f, 3.87173556e-02f, 8.59156996e-02f, 1.14147021e-02f, 1.98398829e-01f, 7.43551925e-02f,
  1.71437502e-01f, 3.67828161e-02f, 2.13441417e-01f, 1.05571240e-01f, 7.37570506e-03f, -7.34964609e-02f, -1.94024310e-01f, -5.81724904e-02f, -2.18220159e-01f, -5.84219880e-02f,
  2.80435622e-01f, -1.96767896e-01f, 5.22257164e-02f, -2.40880311e-01f, 1.85635716e-01f, -3.75865549e-02f, 3.46069753e-01f, 7.13517889e-02f, -4.65193510e-01f, 3.55157316e-01f,
  -1.97618365e-01f, 4.49040294e-01f, -2.37649709e-01f, 4.19975631e-02f, -1.30276069e-01f, 1.52632818e-01f, -2.44581655e-01f, 4.53737117e-02f, 1.95290118e-01f, -4.33811136e-02f,
  1.43082097e-01f, 3.69365956e-03f, 9.15875509e-02f, 1.41482294e-01f, -1.31939230e-02f, 2.32053399e-01f, 1.07573956e-01f, -3.24759066e-01f, -1.06536143e-01f, -1.76010445e-01f,
  6.32181168e-02f, -6.87060729e-02f, -5.22010624e-01f, 2.23553941e-01f, 4.97956991e-01f, -1.92422614e-01f, -5.08495212e-01f, 3.32554549e-01f, -1.34771362e-01f, -5.58773696e-01f,
  -1.17831891e-02f, 1.21457860e-01f, 2.40961507e-01f, 1.84864432e-01f, 7.22513869e-02f, 1.18498266e-01f, 1.91311657e-01f, 2.36718595e-01f, -1.57567829e-01f, -8.45470652e-02f,
  3.43133360e-02f, 9.49121043e-02f, -5.23453839e-02f, 3.09637785e-01f, -3.34830731e-02f, -1.58571586e-01f, -8.52273852e-02f, 1.18357502e-01f, 1.32177472e-01f, -1.08833358e-01f,
  -1.77281111e-01f, 1.94942668e-01f, -2.56194651e-01f, -1.22885434e-02f, -1.40500173e-01f, 2.01896325e-01f, -2.21978482e-02f, 3.23805213e-01f, 8.92041326e-02f, -4.38910723e-02f,
  8.99117664e-02f, -2.36880779e-01f, 1.08103221e-02f, 1.14785112e-01f, 8.58402625e-03f, 1.75083235e-01f, -3.74928489e-02f, 7.32578859e-02f, -9.79494676e-03f, -1.65699683e-02f,
  -1.29451394e-01f, 2.61595100e-02f, -4.26087491e-02f, 1.04295127e-01f, -1.54104769e-01f, 1.75712183e-01f, 2.64132768e-02f, -1.31237969e-01f, -2.86366399e-02f, -2.39398807e-01f,
  1.58790350e-01f, 3.97247635e-02f, 4.45453376e-01f, -1.41802385e-01f, 4.64509547e-01f, -1.36269778e-01f, 7.46512860e-02f, 1.45681426e-01f, 1.86327800e-01f, 4.69001494e-02f,
  1.47281453e-01f, 9.20379981e-02f, 1.46798566e-01f, 1.91197738e-01f, -1.02499790e-01f, 2.20805988e-01f, 6.79220483e-02f, 1.80577368e-01f, -1.13167670e-02f, -3.69936861e-02f,
  1.04650445e-01f, 4.95915115e-02f, -1.93699282e-02f, 2.11857576e-02f, 1.92991629e-01f, -5.90458587e-02f, -4.85106818e-02f, -9.43432972e-02f, -1.33985922e-01f, 7.91893527e-02f,
  -8.79511312e-02f, 1.49307504e-01f, 2.52516657e-01f, 1.62265420e-01f, 6.18300550e-02f, -4.41950783e-02f, 1.97900403e-02f, -1.70081928e-02f, 6.83524832e-02f, 1.80154935e-01f,
  5.41717596e-02f, 2.55502969e-01f, -8.92459787e-03f, 4.57700789e-02f, 9.68531668e-02f, -3.83774117e-02f, 1.97511390e-01f, 4.53635991e-01f, 9.53701138e-02f, 1.02496237e-01f,
  -1.32842824e-01f, 4.55055267e-01f, 3.05935979e-01f, 1.98012307e-01f, -2.36381784e-01f, 2.15034276e-01f, -2.06946358e-01f, -3.98322463e-01f, -3.29235435e-01f, 1.99121479e-02f,
  1.98325679e-01f, -1.35683697e-02f, -2.26689190e-01f, 2.98544914e-01f, -2.11566612e-01f, -2.40999728e-01f, 3.87560785e-01f, -1.33527771e-01f, -4.53377694e-01f, -2.13435546e-01f,
  -2.55909801e-01f, 9.11290422e-02f, 5.45425192e-02f, -2.56026745e-01f, -1.06048308e-01f, -2.22700909e-01f, -2.78669268e-01f, -4.44530621e-02f, -1.49621025e-01f, -4.31950569e-01f,
  2.68495172e-01f, -3.13970238e-01f, -1.78769663e-01f, 1.05255194e-01f, -1.44964559e-02f, -1.14006758e-01f, -1.35350913e-01f, -1.71140075e-01f, -2.00278088e-01f, -1.92311719e-01f,
  4.94625606e-03f, -2.29073063e-01f, 2.50093229e-02f, -1.73400819e-01f, -7.82936960e-02f, -1.55633315e-01f, 2.12408945e-01f, -1.27204685e-02f, -8.53048787e-02f, -1.32830471e-01f,
  -1.32822558e-01f, -1.77155882e-01f, -2.17536569e-01f, 1.55707836e-01f, -1.87817916e-01f, 5.00189438e-02f, -9.03629661e-02f, 8.24990347e-02f, -3.34682390e-02f, 8.05933103e-02f,
  -3.46615613e-02f, -6.78804815e-02f, -7.64716342e-02f, -5.69734871e-02f, -5.41383922e-02f, 4.77652401e-01f, 1.22487947e-01f, -9.76358205e-02f, -7.89666399e-02f, -1.09869629e-01f,
  -6.10354431e-02f, -1.58218935e-01f, 9.47357342e-02f, -3.55166793e-02f, -2.15355024e-01f, 6.38144091e-02f, 8.38649198e-02f, -1.58588499e-01f, 6.09856956e-02f, -3.98470797e-02f,
  1.96717814e-01f, 4.40597162e-02f, -5.52674793e-02f, -1.54636458e-01f, -2.53905773e-01f, 9.74708647e-02f, 1.02441154e-01f, -1.56242803e-01f, -2.29868323e-01f, -1.09920613e-01f,
  2.94960439e-02f, -3.41457278e-01f, -1.65687352e-01f, -3.96246314e-01f, 1.84599534e-02f, 7.27212504e-02f, -9.89532545e-02f, 7.16609955e-02f, 3.05611074e-01f, 1.01617120e-01f,
  5.91343008e-02f, -5.84472492e-02f, -4.47830051e-01f, 1.25801429e-01f, 8.91822875e-02f, -1.49194345e-01f, -1.63169205e-02f, 9.10115466e-02f, 7.01616154e-05f, 2.04814896e-01f,
  1.08423322e-01f, 1.21044226e-01f, -7.28768408e-02f, 2.04886377e-01f, -7.83067476e-03f, -5.16700465e-03f, 1.60878330e-01f, -5.96296825e-02f, -2.27305800e-01f, 7.99324289e-02f,
  1.25245694e-02f, -1.35320425e-01f, -2.97758996e-01f, 1.52359709e-01f, 1.94248138e-03f, -1.17395259e-01f, 2.12616995e-01f, -2.33384088e-01f, -2.61770450e-02f, 2.77757227e-01f,
  2.16837451e-01f, -4.56106156e-01f, 1.41367704e-01f, 2.58331954e-01f, -2.22781479e-01f, -5.06185256e-02f, -1.81337073e-01f, -4.42693867e-02f, -4.16727364e-01f, -2.16541499e-01f,
  -4.52813119e-01f, -2.44513214e-01f, 2.26063296e-01f, -1.29957065e-01f, -2.18467593e-01f, 3.80529374e-01f, 2.41107151e-01f, -1.40777335e-01f, -2.44260296e-01f, 8.92224461e-02f,
  -4.77606237e-01f, 2.82959908e-01f, 1.62728280e-01f, -3.37469995e-01f, -2.25452632e-01f, 1.05810218e-01f, -1.56172588e-01f, 7.55295604e-02f, 2.29606733e-01f, 3.08037519e-01f,
  -5.99993020e-02f, 7.32342228e-02f, -1.83238015e-02f, 9.39903781e-02f, 9.97137204e-02f, 1.52347669e-01f, 1.02974832e-01f, 2.11735785e-01f, 2.75191158e-01f, -7.83911422e-02f,
  -7.18408823e-02f, -2.17430457e-01f, 2.04983931e-02f, -1.00148588e-01f, -1.22224674e-01f, 1.07466541e-01f, 3.86371873e-02f, -4.70187590e-02f, 9.50956643e-02f, -8.42184499e-02f,
  -1.48112953e-01f, 5.91631196e-02f, 1.44264460e-01f, -3.79420966e-02f, 4.59177382e-02f, 4.54287857e-01f, 1.42745137e-01f, 8.75101774e-04f, -1.39527172e-02f, 1.01778973e-02f,
  4.94110659e-02f, -1.04479834e-01f, -8.14645514e-02f, 1.00913055e-01f, 1.19466931e-01f, 3.03311050e-01f, -1.15270592e-01f, -1.18768543e-01f, 2.63832323e-02f, -1.05577424e-01f,
  2.42299587e-02f, 5.45469746e-02f, -1.78852342e-02f, -1.08159073e-02f, -7.42754899e-03f, -1.08982429e-01f, 6.28421642e-03f, 4.03982103e-01f, -1.44280335e-02f, -3.05014495e-02f,
  -7.62263089e-02f, 2.22953707e-01f, 2.16508031e-01f, -2.32487489e-02f, 9.26544964e-02f, -2.04613671e-01f, -5.33307455e-02f, 8.46490115e-02f, 9.29319710e-02f, 1.12481400e-01f,
  2.19472662e-01f, 3.30307394e-01f, -1.34971291e-01f, -2.86790103e-01f, -1.79742306e-01f, -2.08183706e-01f, 4.33388958e-03f, 8.16821381e-02f, 3.02951753e-01f, 1.29797861e-01f,
  2.51730047e-02f, -2.51887757e-02f, -1.35632873e-01f, 1.24022551e-01f, 2.67403089e-02f, -4.54957560e-02f, 1.03005998e-01f, -3.82084131e-01f, -2.55821913e-01f, -1.26218438e-01f,
  -1.03206329e-01f, -3.87606882e-02f, -4.23307018e-03f, 2.10851386e-01f, -4.05553639e-01f, -1.12882376e-01f, 4.79230434e-02f, -1.39643461e-01f, -3.48191196e-03f, 1.76781476e-01f,
  -7.00833201e-02f, -2.21732691e-01f, -7.51605555e-02f, -2.30806962e-01f, 2.02739939e-01f, -2.24769890e-01f, 1.81911469e-01f, 2.74932414e-01f, -2.55859584e-01f, -2.52577871e-01f,
  -1.17689282e-01f, 2.58766443e-01f, -3.75678003e-01f, 1.11984909e-01f, 2.19310418e-01f, 1.87837437e-01f, -1.88984737e-01f, -8.92327540e-03f, -1.86827928e-01f, 5.59870042e-02f,
  -2.75416136e-01f, 9.91616920e-02f, -1.47710457e-01f, -3.39487046e-01f, 1.68330502e-02f, 2.47130990e-01f, -3.60677123e-01f, -2.11575225e-01f, -4.76555228e-01f, 1.42370248e-02f,
  9.74942818e-02f, 1.12491800e-02f, 1.05154619e-03f, 3.88432145e-01f, 2.55603921e-02f, 4.37344760e-01f, -4.29907888e-01f, -1.64404318e-01f, -5.15624993e-02f, 1.34993389e-01f,
  -1.40392393e-01f, -1.85721993e-01f, 4.80765961e-02f, -6.09315634e-02f, 5.41876815e-02f, -4.25891438e-03f, 4.48000729e-02f, -3.40141803e-02f, 1.45926535e-01f, 7.08123669e-02f,
  3.64069431e-03f, 7.47596845e-02f, -8.80369246e-02f, 7.94434994e-02f, 3.33002955e-02f, -8.53218511e-02f, 5.74582636e-01f, 4.08623135e-03f, 1.02566890e-01f, 9.44069624e-02f,
  1.68998033e-01f, -2.15007097e-01f, 4.12166379e-02f, -9.91634279e-03f, -6.07585944e-02f, -6.74580336e-02f, -3.26343030e-02f, -5.58408685e-02f, -4.11185063e-02f, -6.84307367e-02f,
  6.24394976e-02f, 2.39673182e-01f, -2.44532116e-02f, -9.94879976e-02f, 1.36379808e-01f, 1.13666408e-01f, 8.31368938e-02f, 2.24070713e-01f, -1.81929208e-02f, -1.91552594e-01f,
  -2.24152118e-01f, -7.55381659e-02f, -1.09682359e-01f, -8.03022757e-02f, -2.79195067e-02f, -1.96425423e-01f, -8.80730748e-02f, 1.53315868e-02f, -6.54100627e-02f, 3.60165298e-01f,
  7.92771056e-02f, 1.33905873e-01f, 8.34558383e-02f, 2.62019545e-01f, 2.57015288e-01f, 2.00628877e-01f, 2.29199946e-01f, 2.10175529e-01f, 6.50403723e-02f, 1.56960577e-01f,
  4.26485799e-02f, 6.63217530e-03f, -3.70295607e-02f, 1.64299756e-02f, -4.47395474e-01f, 6.91901371e-02f, 1.93233993e-02f, -8.78814887e-03f, -7.62255266e-02f, 6.00856654e-02f,
  6.11799322e-02f, 1.01425566e-01f, -4.36771773e-02f, 1.22494049e-01f, -5.55840321e-04f, 9.49731991e-02f, 2.26366058e-01f, 2.18734458e-01f, 9.58257169e-03f, 3.64667661e-02f,
  1.51247665e-01f, -1.76272184e-01f, 1.59223467e-01f, 2.56937414e-01f, 1.03234366e-01f, -7.35339001e-02f, 5.28767481e-02f, 8.41649100e-02f, -3.44682872e-01f, 1.13196418e-01f,
  -4.15967166e-01f, -1.72238033e-02f, -4.78063263e-02f, 9.80319083e-02f, -4.66696173e-02f, -7.28430897e-02f, -8.98073614e-02f, 1.82302445e-01f, 1.46789566e-01f, -8.56590644e-02f,
  4.64117199e-01f, 2.71722496e-01f, 3.58998746e-01f, -2.12347694e-02f, 3.48478377e-01f, 2.77644973e-02f, 5.18021762e-01f, -3.01438928e-01f, 1.85838535e-01f, 3.51239711e-01f,
  -1.43967614e-01f, -6.18373090e-03f, 3.84726524e-02f, 4.11401421e-01f, -2.41757989e-01f, -1.12635113e-01f, 2.78148681e-01f, 3.30098063e-01f, 1.36844113e-01f, 4.84543294e-01f,
  7.00294003e-02f, -4.13815752e-02f, 4.69585545e-02f, 3.68140399e-01f, 1.13253072e-02f, 5.69311529e-02f, -1.42290001e-03f, -1.40357707e-02f, -1.58797964e-01f, 2.13371605e-01f,
  4.69347537e-02f, -7.22282752e-02f, 4.75463545e-04f, 3.80072333e-02f, -2.18261018e-01f, 1.08972341e-01f, 3.40667628e-02f, 2.31987774e-01f, -1.76648960e-01f, -2.90106814e-02f,
  -1.79800726e-02f, -2.96404839e-01f, 5.86898550e-02f, 7.76362717e-02f, 3.29352707e-01f, 2.29036927e-01f, 3.09363455e-01f, -1.77058831e-01f, -8.51077810e-02f, -1.73358321e-01f,
  -1.63810894e-01f, 3.57955471e-02f, -1.84014872e-01f, -1.74730271e-02f, 3.42205256e-01f, -1.45167172e-01f, -2.29521692e-02f, -2.28839591e-02f, 1.04818761e-01f, -1.81025818e-01f,
  -8.58847145e-03f, -1.21533141e-01f, 3.75687838e-01f, 3.59275565e-02f, 2.91579664e-02f, 1.08164109e-01f, -9.97212082e-02f, -1.99028496e-02f, -2.10578531e-01f, 1.71416089e-01f,
  -6.02412596e-02f, 3.11767787e-01f, 1.36000827e-01f, 1.08102366e-01f, -2.13203087e-01f, -1.21117368e-01f, 3.98469716e-02f, 2.26271927e-01f, 7.65639991e-02f, 2.92798597e-02f,
  -3.67771566e-01f, 2.20233947e-02f, 1.40096888e-01f, 3.52702327e-02f, -2.18969315e-01f, -4.30407003e-02f, 1.56410486e-01f, -5.48825204e-01f, -4.07782495e-02f, 1.66134536e-01f,
  -9.10718292e-02f, 9.97860506e-02f, 1.29335776e-01f, 4.50523607e-02f, 6.38168454e-02f, 8.01494569e-02f, -8.94449949e-02f, 7.79969469e-02f, -1.94385126e-01f, -4.84842509e-02f,
  4.32936661e-02f, 2.67669797e-01f, -1.59714893e-01f, 5.93557255e-03f, 6.40713191e-03f, -6.72332421e-02f, 2.54766941e-02f, 1.49871707e-01f, -2.33972222e-02f, 1.59169808e-01f,
  2.59155899e-01f, 1.11727633e-01f, 5.54903522e-02f, -2.79689223e-01f, -7.65905157e-02f, -3.20668072e-01f, 1.93684414e-01f, -1.00131027e-01f, 2.53025830e-01f, 4.09350574e-01f,
  -2.41411075e-01f, -1.08573496e-01f, 4.02410537e-01f, -4.68515486e-01f, -9.04655308e-02f, 3.74013245e-01f, 2.52203971e-01f, -2.65815914e-01f, -2.39722684e-01f, 2.89629370e-01f,
  1.13651477e-01f, -2.27023326e-02f, 1.24782927e-01f, 2.01987907e-01f, 3.71725231e-01f, -1.12632126e-01f, -3.88015658e-01f, 2.31678501e-01f, 1.39112234e-01f, -3.77986841e-02f,
  -4.01288539e-01f, 1.20770447e-01f, 3.43108833e-01f, -3.24185818e-01f, 2.56394565e-01f, -2.09503487e-01f, -7.59660006e-02f, 2.64176369e-01f, 3.99096489e-01f, 1.41475037e-01f,
  -6.23145001e-03f, -4.82188016e-01f, -2.60267019e-01f, -2.56234825e-01f, 1.98680207e-01f, -1.47358244e-02f, 2.70614862e-01f, -1.56085685e-01f, -3.60081308e-02f, -1.31559417e-01f,
  1.65776998e-01f, 2.70157516e-01f, -1.77953109e-01f, -2.86709338e-01f, 8.82869363e-02f, -2.20163800e-02f, -4.23472710e-02f, 8.30411613e-02f, 1.77224621e-01f, -1.23967536e-01f,
  4.77181515e-03f, -1.00554407e-01f, -2.00573832e-01f, -3.25802304e-02f, -2.52110004e-01f, -4.82475199e-02f, -1.12894051e-01f, -1.69219881e-01f, -2.75899414e-02f, -1.93491384e-01f,
  -1.26192838e-01f, -9.29954425e-02f, 3.14885341e-02f, -2.61108309e-01f, -1.36603147e-01f, -6.06853105e-02f, -5.19700535e-02f, -9.13732201e-02f, 8.51103067e-02f, -7.13513866e-02f,
  -6.51651025e-02f, -1.48764536e-01f, -1.89755216e-01f, -1.30102947e-01f, -1.64997891e-01f, -6.91549033e-02f, -9.74211916e-02f, -2.06200546e-03f, -1.37119427e-01f, -7.50857890e-02f,
  4.33758646e-03f, -3.49211209e-02f, -2.99740694e-02f, -1.70214459e-01f, -1.25037238e-01f, -2.06378326e-02f, -1.08536310e-01f, 2.12121457e-02f, 2.22941469e-02f, -1.72435984e-01f,
  -1.44517764e-01f, -2.03611463e-01f, 1.95078366e-02f, -5.64438589e-02f, -1.68068007e-01f, 1.43178597e-01f, 4.61064250e-04f, -2.42243320e-01f, -3.15757282e-02f, -2.30748802e-02f,
  -2.94081092e-01f, -1.85248271e-01f, -9.77126211e-02f, 4.49972600e-03f, -1.06188476e-01f, -1.25239074e-01f, -1.46502569e-01f, 3.72775551e-03f, -1.80479307e-02f, -1.05661616e-01f,
  -9.32534561e-02f, -8.83460566e-02f, -1.34548679e-01f, -7.69328550e-02f, -8.26285407e-02f, -2.10887283e-01f, -1.82820559e-01f, -2.67696381e-01f, 3.72026004e-02f, 4.47393283e-02f,
  4.63445187e-02f, -1.60965934e-01f, 3.93073708e-02f, -2.93435529e-02f, -4.61371034e-01f, -9.44094658e-02f, 1.03312075e-01f, -2.58785635e-01f, 2.21647844e-01f, -2.66871005e-01f,
  -1.11799113e-01f, -1.52750507e-01f, 3.40984106e-01f, -9.31583643e-02f, 1.37884021e-01f, -2.29764506e-01f, 2.05520138e-01f, -2.52648294e-01f, -2.19757214e-01f, -3.42859685e-01f,
  -1.71506345e-01f, -7.42042437e-02f, 3.29402671e-03f, 1.41603976e-01f, 1.45376325e-01f, 1.49389341e-01f, 1.39519304e-01f, 2.87487119e-01f, -9.44141224e-02f, -8.21831599e-02f,
  2.30672047e-01f, -5.13592437e-02f, -2.80966282e-01f, 2.35260397e-01f, 3.42144579e-01f, -2.40380779e-01f, 1.64149672e-01f, 1.60113387e-02f, 7.34517351e-02f, -2.50245452e-01f,
  1.49591908e-01f, -1.09234348e-01f, -1.60553828e-01f, 7.95461833e-02f, -4.56588529e-02f, -2.56417133e-02f, 1.41274348e-01f, -6.79664686e-02f, 9.55710337e-02f, 2.26536021e-01f,
  -6.63963333e-02f, 3.02614808e-01f, 5.18055931e-02f, -7.83042982e-02f, 8.07575956e-02f, -1.37649057e-02f, -1.15760073e-01f, 5.33368215e-02f, -7.65826181e-02f, -1.12809137e-01f,
  -3.72150987e-02f, -3.71655412e-02f, 7.10712299e-02f, 5.53107411e-02f, -9.26174223e-02f, 1.52546279e-02f, -1.29838035e-01f, -4.84058671e-02f, -1.11602694e-02f, 1.17432296e-01f,
  5.00993505e-02f, -2.28571966e-01f, 4.16166671e-02f, -6.75949827e-03f, 5.11926599e-03f, -4.29543667e-02f, -2.40909271e-02f, 9.51838419e-02f, -1.22006536e-01f, 8.72791931e-02f,
  -1.28347456e-01f, -8.76650661e-02f, 4.76171434e-01f, 3.62304710e-02f, 5.04129767e-01f, 1.81457996e-01f, 5.43674007e-02f, 1.41433775e-01f, -9.88448225e-03f, -7.42643028e-02f,
  8.47120881e-02f, -2.36976035e-02f, 1.76143982e-02f, -1.29579023e-01f, -5.20922951e-02f, 6.81866109e-02f, 1.34884104e-01f, 1.77049324e-01f, -1.38326332e-01f, -1.03846334e-01f,
  -3.99299245e-03f, 1.01764478e-01f, -1.79526687e-01f, 2.11891353e-01f, 1.53106421e-01f, 3.65434922e-02f, -2.88571138e-02f, -6.73899278e-02f, 2.93226540e-01f, 2.52902806e-02f,
  1.05829582e-01f, -6.30106553e-02f, 4.25573438e-02f, -5.21811098e-02f, -2.61655986e-01f, 6.92534074e-02f, 2.49599107e-02f, 7.51560146e-05f, -7.28262588e-03f, -3.90908122e-02f,
  -1.69619963e-01f, -9.85957980e-02f, 1.43035129e-01f, 9.88374427e-02f, 5.84238162e-03f, 1.45256206e-01f, -4.11586374e-01f, -9.18169990e-02f, -2.81217489e-02f, 1.30033746e-01f,
  -1.82817817e-01f, 7.47046173e-02f, 2.74029255e-01f, 9.32970345e-02f, -6.43425807e-02f, 1.10217109e-01f, -3.06139946e-01f, 1.84101954e-01f, -2.36895546e-01f, -2.30812430e-01f,
  -3.33192706e-01f, -1.44194528e-01f, 7.93937873e-03f, -3.89133692e-01f, 2.20824197e-01f, 3.94916236e-01f, -1.03861010e-02f, -5.39834015e-02f, 1.70972154e-01f, -1.50732860e-01f,
  -5.88086396e-02f, -2.19848052e-01f, 4.20243084e-01f, 2.71007061e-01f, -5.08683696e-02f, 3.64276856e-01f, 8.60916525e-02f, -4.91454512e-01f, 3.96855235e-01f, 4.04940933e-01f,
  1.86625555e-01f, 1.39158174e-01f, -7.06786513e-02f, 2.80783921e-02f, 4.89014864e-01f, -2.27771848e-01f, 3.01237643e-01f, -2.84872741e-01f, 3.84058267e-01f, 5.93462139e-02f,
  9.71765146e-02f, 3.10417283e-02f, 7.84330219e-02f, 5.56792691e-02f, 4.31112759e-02f, 6.50355418e-04f, 3.02721094e-02f, -1.31938875e-01f, -1.46442235e-01f, -5.87970912e-02f,
  -1.19291119e-01f, -1.87666751e-02f, 1.30042270e-01f, -1.39029965e-01f, -5.01994453e-02f, -1.00245744e-01f, 2.34035954e-01f, -5.98346107e-02f, -2.36797735e-01f, -1.01458624e-01f,
  -1.75555274e-01f, -5.18733310e-03f, -1.08697645e-01f, 2.59335399e-01f, 1.36091784e-01f, 1.45678371e-02f, 7.41900429e-02f, 1.05492271e-01f, 1.22272313e-01f, 4.62627672e-02f,
  -1.60503425e-02f, -2.42082607e-02f, 3.63132544e-02f, -1.46876827e-01f, -1.69841312e-02f, 1.27978101e-01f, 7.18010291e-02f, -1.62923172e-01f, -9.78254601e-02f, 3.88354138e-02f,
  1.28089443e-01f, 2.66231736e-03f, -7.59374201e-02f, -1.49533242e-01f, -7.20829517e-02f, 2.13712364e-01f, 4.24698293e-02f, -3.77210043e-02f, 9.47221816e-02f, -1.25393525e-01f,
  7.49329031e-02f, -1.48881868e-01f, 9.32969600e-02f, -1.10363409e-01f, -9.87227820e-03f, -7.01812357e-02f, 7.12321028e-02f, -2.51943748e-02f, -1.74167491e-02f, 1.27694219e-01f,
  -6.84866831e-02f, 1.78588718e-01f, 3.47487405e-02f, 1.72340512e-01f, 2.02024072e-01f, 1.18069418e-01f, -1.44829843e-02f, 6.46492913e-02f, -4.74842303e-02f, -7.45672137e-02f,
  -1.29952490e-01f, -5.26246801e-02f, 7.17253238e-02f, 6.80303276e-02f, -5.84971830e-02f, -1.92693114e-01f, 2.79357016e-01f, 3.18138599e-02f, 5.08890264e-02f, -8.41365233e-02f,
  1.20607894e-02f, -1.84644498e-02f, -1.91789139e-02f, 1.12472707e-02f, -6.27479851e-02f, -2.89499342e-01f, 4.27145138e-03f, 1.89477459e-01f, -1.01071618e-01f, 7.41768852e-02f,
  3.35551053e-01f, -2.25463748e-01f, 4.26162779e-01f, -3.79795820e-01f, 1.60905242e-01f, -1.15412347e-01f, 3.76813471e-01f, -4.05396312e-01f, 1.98269203e-01f, 2.95974165e-01f,
  -2.42556021e-01f, -1.83212832e-01f, -1.07844964e-01f, -3.44682634e-01f, -1.14917979e-01f, 1.23117544e-01f, -7.66792446e-02f, 1.21955529e-01f, 5.00690401e-01f, 3.15500110e-01f,
  -1.71450824e-01f, 1.18697718e-01f, 2.26511747e-01f, -5.25690138e-01f, 2.19672337e-01f, 1.17881939e-01f, -1.05127886e-01f, -1.21182889e-01f, -2.92986840e-01f, -3.84727210e-01f,
  -5.37819192e-02f, -3.29710357e-02f, -5.45910239e-01f, 3.56766343e-01f, 2.28369664e-02f, 1.09950416e-01f, -3.97035003e-01f, -5.06801531e-02f, -2.05827244e-02f, -1.03061207e-01f,
  -1.56836465e-01f, -5.82247488e-02f, -5.13814203e-03f, 1.73053026e-01f, -1.07739665e-01f, -2.36558229e-01f, -8.93885940e-02f, -9.01386421e-03f, 7.46788876e-03f, 3.18254493e-02f,
  1.46608785e-01f, 1.59028769e-01f, 4.55840714e-02f, -1.73893303e-01f, 1.92407802e-01f, 1.17012551e-02f, 3.68102007e-02f, 1.73467979e-01f, 2.72675961e-01f, 1.73586570e-02f,
  -1.65814534e-01f, -1.28342584e-01f, 1.84922755e-01f, -5.10843769e-02f, -8.63305181e-02f, -1.70635819e-01f, -4.39619571e-02f, -1.13585554e-01f, -1.62929922e-01f, 1.61866061e-02f,
  -1.16662532e-01f, -1.53832927e-01f, -7.28323907e-02f, -4.81390692e-02f, 1.02136113e-01f, -1.15350239e-01f, -6.76275194e-02f, -5.87888323e-02f, 6.22106530e-02f, 6.15911093e-03f,
  6.04549468e-01f, 5.01530506e-02f, 4.95433696e-02f, -1.06822751e-01f, 2.68420950e-02f, -1.81568876e-01f, -2.25331839e-02f, 5.78852892e-02f, 1.67181436e-02f, -8.75865519e-02f,
  1.15513302e-01f, -1.16839238e-01f, -2.08127111e-01f, 1.06900200e-01f, -7.12217912e-02f, -3.85084189e-02f, 2.65648980e-02f, 1.56629294e-01f, 1.56518016e-02f, -9.94154718e-03f,
  -5.25889844e-02f, -5.71350288e-03f, 5.08623496e-02f, 3.81566398e-02f, 1.31388485e-01f, -7.28466511e-02f, 3.79107259e-02f, -1.00015894e-01f, -6.04114346e-02f, -1.11047529e-01f,
  -4.38681617e-02f, -2.14928687e-02f, 2.09485041e-03f, 7.59420544e-02f, -1.97942704e-01f, 8.97866786e-02f, 1.78120047e-01f, -1.06020890e-01f, -2.84887254e-02f, 5.46864904e-02f,
  -3.21431793e-02f, 4.89938036e-02f, 2.37321064e-01f, -1.34772465e-01f, 9.43560526e-03f, 1.53903574e-01f, 9.30272043e-02f, 2.99132778e-03f, -8.53953436e-02f, 1.72016680e-01f,
  -3.45694542e-01f, 1.03262365e-01f, -3.02141249e-01f, 1.64758205e-01f, -7.19928965e-02f, 1.09011374e-01f, -1.92645103e-01f, -2.44772702e-01f, 2.39523038e-01f, 1.49630144e-01f,
  3.00067663e-01f, -1.63514912e-01f, -6.05491847e-02f, 1.21883005e-01f, -4.29016709e-01f, -4.34495928e-03f, -3.20932567e-01f, -1.69323772e-01f, 6.37040660e-02f, -1.51546389e-01f,
  2.18342036e-01f, 3.48817371e-03f, 4.09533530e-01f, 6.30449876e-02f, 2.89321244e-01f, 3.04517329e-01f, -4.54853624e-01f, -1.93832904e-01f, -1.26709506e-01f, -1.86045825e-01f,
  -2.03113616e-01f, -2.94441998e-01f, 7.98213631e-02f, -7.12217465e-02f, -1.03519239e-01f, 1.25610039e-01f, -1.36653215e-01f, 2.17097625e-02f, -1.61541015e-01f, -1.20391242e-01f,
  2.00445927e-03f, 6.25722334e-02f, 5.75409941e-02f, 2.31041145e-02f, -1.64726809e-01f, -1.49166510e-01f, -1.04481779e-01f, 1.90560564e-01f, 2.39825338e-01f, -5.21519361e-03f,
  -2.16378197e-01f, 3.70515078e-01f, -6.83544427e-02f, -2.50492003e-02f, 1.80016905e-01f, -7.27333724e-02f, 3.12750220e-01f, 1.77324861e-02f, -1.49466708e-01f, 4.43906821e-02f,
  -1.01683713e-01f, -1.10252298e-01f, 1.30112976e-01f, 1.68576375e-01f, 1.93405729e-02f, -1.34062380e-01f, 5.57930291e-01f, -1.14148371e-01f, -6.74003214e-02f, -1.87229827e-01f,
  -1.26250729e-01f, -2.97399685e-02f, -1.52994648e-01f, 2.42284071e-02f, 1.56553715e-01f, 6.33592764e-03f, -6.76412284e-02f, -1.52243122e-01f, -1.91550598e-01f, 5.71432756e-03f,
  3.44480164e-02f, 1.12195961e-01f, -7.29860216e-02f, 1.65729046e-01f, -1.17913269e-01f, 2.54589856e-01f, -2.03506008e-01f, -2.32212208e-02f, -2.53720909e-01f, -4.72600609e-02f,
  -1.91870052e-02f, -7.20371827e-02f, -3.49453092e-02f, -1.49179818e-02f, -5.29812761e-02f, 1.61986917e-01f, 6.28921911e-02f, 1.05438448e-01f, -8.68946910e-02f, 4.57941853e-02f,
  -1.25545025e-01f, -2.28666812e-01f, 1.18420236e-01f, 5.71952015e-02f, -8.76404494e-02f, -1.42744452e-01f, 5.59523180e-02f, -4.40345593e-02f, 6.83997050e-02f, 5.05611673e-02f,
  9.44039002e-02f, -1.33855402e-01f, -3.80075686e-02f, 5.65655455e-02f, 1.00360014e-01f, 9.07145441e-02f, 7.62131214e-02f, 1.27635757e-02f, 6.15680590e-03f, 5.69291525e-02f,
  -7.95908272e-02f, -7.87151456e-02f, -6.91580027e-02f, 2.20828265e-01f, 1.03389725e-01f, 9.06262025e-02f, 3.96396399e-01f, 2.34549105e-01f, 3.31104547e-01f, -2.39131674e-01f,
  3.90189551e-02f, -1.77073166e-01f, 2.89144188e-01f, -4.56478186e-02f, -2.74196416e-01f, 1.15381390e-01f, 1.48646846e-01f, -1.37411490e-01f, -3.57199520e-01f, 3.73117566e-01f,
  -5.27737066e-02f, -2.18535826e-01f, -2.97823995e-01f, -2.93930799e-01f, 5.14249578e-02f, -1.49483144e-01f, 7.03051090e-02f, -6.19039685e-02f, -4.03079003e-01f, 3.88019621e-01f,
  -1.66563258e-01f, -1.33085594e-01f, 3.95651869e-02f, -1.67750329e-01f, 1.84925035e-01f, 2.17233449e-01f, -7.40735084e-02f, -6.15009442e-02f, 2.93423116e-01f, 3.35553706e-01f,
  1.58659115e-01f, 1.71188504e-01f, -1.89177126e-01f, -1.03507787e-02f, 1.83338806e-01f, 1.56386465e-01f, 2.78566092e-01f, -1.12609901e-02f, -1.00253336e-01f, 6.84790239e-02f,
  -3.52623314e-02f, -4.05701902e-03f, 4.98693645e-01f, -3.89261059e-02f, 6.47472963e-03f, -1.12645827e-01f, -7.75404498e-02f, 1.82201505e-01f, -8.07738006e-02f, -2.37621786e-03f,
  -1.94787264e-01f, -1.03200853e-01f, -3.66890873e-03f, -1.48588447e-02f, -6.67832568e-02f, -1.85504645e-01f, 8.40127002e-03f, 9.61381197e-02f, 1.78592592e-01f, -8.43337402e-02f,
  -1.51572376e-02f, -3.44811194e-02f, -5.14603369e-02f, 7.40882695e-01f, -2.50492115e-02f, 1.84930265e-01f, -6.77848235e-02f, 3.35205980e-02f, 6.10336624e-02f, 1.28678188e-01f,
  1.15367882e-01f, 1.52933717e-01f, -1.22690424e-01f, 1.49469659e-01f, -1.01048298e-01f, -7.24242479e-02f, -3.97310704e-02f, -1.89608671e-02f, 6.40957206e-02f, -1.89995579e-02f,
  -1.44893359e-02f, 2.35587619e-02f, -2.81437904e-01f, -8.24929997e-02f, -1.17433473e-01f, -5.56123964e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  7.03029856e-02f, -1.15761617e-02f, -6.70374334e-02f, 4.17044349e-02f, 1.89400073e-02f, 2.83915401e-02f, 6.91091456e-03f, -8.17748457e-02f, -1.65953580e-02f, -1.01644620e-02f,
  -6.71356767e-02f, 1.51123405e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    