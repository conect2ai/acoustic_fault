/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.29252589e-02f, -4.04237628e-01f, -2.29146853e-01f, -3.19403075e-02f, -3.25922757e-01f, 3.25679034e-02f, -1.43178612e-01f, 2.23693877e-01f, 1.44035026e-01f, -1.19037822e-01f,
  -2.34104022e-01f, -9.35711116e-02f, 8.89339671e-02f, 7.29054958e-02f, 2.01818258e-01f, 6.24176338e-02f, -2.60774419e-02f, 1.83639690e-01f, 3.16595167e-01f, 1.94048896e-01f,
  4.35762703e-02f, 4.14193273e-02f, 1.27048925e-01f, 2.24814385e-01f, -1.32807717e-01f, 5.14733046e-02f, -1.23030677e-01f, -2.30857119e-01f, -1.62641868e-01f, -1.39064834e-01f,
  -3.79367948e-01f, -1.97106495e-01f, 1.38799280e-01f, -9.95829776e-02f, -2.06117883e-01f, 3.83415148e-02f, -1.50693273e-02f, -5.76992258e-02f, -4.68412191e-02f, 3.79530862e-02f,
  -1.42277017e-01f, -1.33353010e-01f, -3.90676744e-02f, 1.56241190e-02f, -7.41523653e-02f, 5.53097986e-02f, 8.58337246e-03f, 1.52574629e-01f, -1.34431878e-02f, -7.32088387e-02f,
  -1.56354636e-01f, -1.96473479e-01f, -6.94271699e-02f, 3.53375375e-02f, -7.64731457e-03f, -8.68303515e-03f, -8.49193782e-02f, -1.07180879e-01f, 5.54201677e-02f, -5.26712239e-02f,
  5.15867695e-02f, -4.28784788e-02f, -3.57000828e-02f, -8.76360427e-05f, -5.44898063e-02f, -5.72144948e-02f, -2.38284059e-02f, -2.73481477e-02f, 4.32911478e-02f, -1.21032707e-02f,
  5.15954494e-02f, -3.17035727e-02f, -1.47950538e-02f, -3.78671139e-02f, -9.90706496e-03f, -1.21522076e-01f, -1.50788892e-02f, 1.08091272e-02f, 9.84893646e-04f, -7.10472744e-03f,
  1.18319690e-02f, 9.86490399e-03f, -9.22820717e-02f, 6.09003976e-02f, 4.90739420e-02f, 8.26983005e-02f, 6.28714114e-02f, 1.37595565e-03f, -4.64700535e-03f, -8.31996053e-02f,
  8.08415487e-02f, 8.92864615e-02f, -1.93826426e-02f, 7.92644173e-02f, -2.85547115e-02f, 3.93853523e-02f, -5.38901277e-02f, -5.48527949e-03f, -4.61206697e-02f, 2.80025266e-02f,
  -3.59304026e-02f, 4.26048301e-02f, -1.11691400e-01f, 4.87455986e-02f, 8.28369260e-02f, -8.48624157e-04f, 1.89646482e-02f, 6.83677495e-02f, 3.92114148e-02f, 6.23311698e-02f,
  9.32766572e-02f, 1.44521683e-01f, 2.60305218e-02f, 2.40582358e-02f, 7.72401318e-02f, 9.85185951e-02f, 5.79569526e-02f, 1.11596726e-01f, 1.97610065e-01f, 1.68331638e-01f,
  9.55943942e-01f, 5.34173287e-02f, -3.15344125e-01f, 2.32068434e-01f, -1.72863990e-01f, -1.85501993e-01f, -3.63307536e-01f, -2.31527928e-02f, 1.75822318e-01f, 9.58874822e-02f,
  3.33080851e-02f, 2.67966479e-01f, 1.34562835e-01f, -9.04133767e-02f, -1.30653575e-01f, -2.87982851e-01f, -4.22523975e-01f, -1.72389537e-01f, 4.03973684e-02f, 3.33082527e-02f,
  -8.87866467e-02f, 2.56863236e-02f, 1.47579521e-01f, 2.27061845e-02f, 9.72743481e-02f, -2.01339889e-02f, -2.33895257e-01f, -2.97685359e-02f, -1.50316790e-01f, -1.06009416e-01f,
  3.94824594e-02f, 1.70060053e-01f, -1.53109565e-01f, 2.09059436e-02f, -4.30449173e-02f, 5.85839665e-03f, 2.30728015e-02f, -2.76332796e-02f, 6.83409944e-02f, 2.80110817e-02f,
  -3.91955562e-02f, 9.61753540e-03f, -1.09588340e-01f, -9.07752439e-02f, -3.11497208e-02f, 7.76596665e-02f, -9.68616679e-02f, -7.69334212e-02f, -1.79582894e-01f, -9.49626863e-02f,
  -1.36917785e-01f, 5.97138554e-02f, -5.51622473e-02f, -1.47317395e-01f, -1.26664475e-01f, -7.04822838e-02f, -7.95565248e-02f, -1.20198727e-02f, -5.26892245e-02f, 9.35607851e-02f,
  4.81228577e-03f, -1.26666157e-02f, -1.63000122e-01f, -2.42186966e-03f, -9.04133543e-02f, -9.58517194e-03f, -1.28817186e-01f, -6.63806871e-02f, -4.95506786e-02f, -1.20373191e-02f,
  -7.89730027e-02f, -8.27086642e-02f, -9.82830077e-02f, 4.74878866e-03f, -5.88118993e-02f, -6.42570779e-02f, -8.22585821e-02f, 1.00077651e-02f, -6.50173500e-02f, 1.31536927e-02f,
  -2.57232320e-02f, -1.01899102e-01f, -3.41451056e-02f, -8.85276422e-02f, -1.04044482e-01f, 6.97792415e-03f, 5.58544174e-02f, -8.41392279e-02f, 1.15382886e-02f, 6.17364142e-03f,
  1.48316205e-01f, -2.48112813e-01f, 1.23378776e-01f, -5.84299341e-02f, -2.66285259e-02f, 2.47906446e-02f, -9.40682180e-03f, -4.10517342e-02f, -3.06593236e-02f, -3.09974905e-02f,
  -7.73534998e-02f, -1.51113616e-02f, -2.66601481e-02f, -5.54754660e-02f, -4.17709872e-02f, -3.84865776e-02f, -2.27619801e-02f, -4.00880761e-02f, -7.63956979e-02f, -2.24162620e-02f,
  -6.83739483e-02f, -7.60171413e-02f, 1.15264244e-01f, -1.06675876e-02f, -5.87301562e-04f, -9.23553575e-03f, -3.16844359e-02f, -2.46228985e-02f, -8.86327699e-02f, 1.39984954e-02f,
  -5.62152624e-01f, 1.95055991e-01f, -1.33551536e-02f, -2.50297874e-01f, 2.54249364e-01f, 2.63218611e-01f, 5.43765008e-01f, 8.06306303e-02f, -1.24391168e-01f, 1.41669065e-01f,
  2.52980785e-03f, -3.24545890e-01f, -1.88466191e-01f, -1.16306163e-01f, -7.37686530e-02f, 3.01024377e-01f, 2.81370878e-01f, -2.38696516e-01f, -1.97145537e-01f, 1.66932374e-01f,
  2.16636896e-01f, -4.52290587e-02f, -1.68522462e-01f, -1.03703842e-01f, 2.20427856e-01f, 2.87832301e-02f, 1.96602538e-01f, 1.53898066e-02f, 1.78759426e-01f, 1.66245908e-01f,
  -2.51422673e-02f, -9.68446881e-02f, 4.87080924e-02f, -7.65068904e-02f, -3.84041704e-02f, -6.81463405e-02f, 3.35380137e-02f, -5.26181906e-02f, -6.19665980e-02f, -4.69976813e-02f,
  -9.63357165e-02f, -1.20980434e-01f, -6.58226684e-02f, -2.00450476e-02f, 4.80563529e-02f, 1.00233532e-01f, -6.15490936e-02f, -7.98877180e-02f, -7.95182437e-02f, 1.16220742e-01f,
  1.65686272e-02f, -6.67617237e-03f, -3.45333181e-02f, 4.65933233e-02f, -8.42240676e-02f, -1.16119213e-01f, -1.79848296e-03f, -3.23877744e-02f, -2.19983775e-02f, 5.55096120e-02f,
  1.07494056e-01f, -4.98806350e-02f, 2.81532612e-02f, -5.30738430e-03f, 6.49635913e-03f, 2.93832459e-03f, -3.53637189e-02f, -3.76833081e-02f, -4.05706652e-02f, 5.76431975e-02f,
  -1.04760416e-01f, -6.64561614e-02f, -1.28120333e-01f, 2.57305801e-02f, -3.16684358e-02f, -4.53843176e-02f, 2.43707094e-02f, -8.07222724e-03f, -1.04351565e-01f, -1.43601028e-02f,
  -6.46244437e-02f, -3.61153521e-02f, 4.99658696e-02f, -9.00016651e-02f, -4.52000834e-02f, -6.47219792e-02f, -5.43795377e-02f, -2.77368743e-02f, 3.25252512e-03f, -9.11320746e-03f,
  -2.56744716e-02f, -1.33641288e-01f, 1.31410688e-01f, 1.42013831e-02f, 3.66350450e-02f, 4.28221971e-02f, 4.50828560e-02f, 2.60925833e-02f, 1.23930834e-02f, -1.13507174e-02f,
  2.18822900e-02f, -5.64109944e-02f, 1.08091915e-02f, 8.69181156e-02f, 3.46282646e-02f, 7.78206214e-02f, 4.33423594e-02f, 9.36749205e-02f, 2.75735259e-02f, -1.07544300e-03f,
  1.00038283e-01f, 1.44552544e-01f, 8.84834528e-02f, 6.22840710e-02f, 9.56060290e-02f, 3.28891985e-02f, 1.45181611e-01f, 1.74336165e-01f, 9.77825969e-02f, 3.57806951e-01f,
  -5.73308349e-01f, 2.81143516e-01f, -7.81325325e-02f, -1.01961128e-01f, 3.11442465e-01f, 1.32373422e-01f, 2.92780310e-01f, 1.53223649e-01f, 9.82237905e-02f, 9.37073156e-02f,
  3.77447158e-01f, -6.69459179e-02f, -1.43330380e-01f, -1.11794159e-01f, -2.31265679e-01f, -1.83463730e-02f, -1.40144870e-01f, -4.27405864e-01f, -3.13433856e-01f, 7.70001635e-02f,
  2.73015380e-01f, 1.39396995e-01f, -7.63119161e-02f, -9.99257620e-03f, 1.54947832e-01f, -1.32450089e-01f, 2.16972008e-01f, 1.66986108e-01f, 1.64504841e-01f, -7.38758147e-02f,
  -2.06499130e-01f, 1.35807142e-01f, -7.64532685e-02f, -1.54776452e-02f, 6.65654391e-02f, -7.25546926e-02f, -8.80797673e-03f, -6.46645799e-02f, 1.04106806e-01f, 2.08550673e-02f,
  1.38793752e-01f, 3.53606278e-03f, 4.46104482e-02f, 3.68010290e-02f, 1.13657586e-01f, 7.43126199e-02f, -2.20152619e-03f, -1.02264754e-01f, 4.82163876e-02f, -3.10399700e-02f,
  9.78616849e-02f, 1.27116129e-01f, 6.65965974e-02f, 7.58972764e-02f, 5.07496074e-02f, 3.82079780e-02f, 3.98534052e-02f, 6.47301376e-02f, 4.81721647e-02f, 4.74142982e-03f,
  -5.08402511e-02f, -4.82459590e-02f, 1.53548075e-02f, 1.41079095e-03f, -4.75308858e-02f, 6.66193143e-02f, -9.92232263e-02f, -2.58717984e-02f, 1.65523607e-02f, -6.58407584e-02f,
  1.48985442e-02f, -3.60259973e-02f, -2.68196333e-02f, 1.86913833e-02f, -7.98531994e-02f, 1.12468777e-02f, -7.90171400e-02f, 1.53871598e-02f, 1.72219556e-02f, 6.07227348e-02f,
  -5.23835272e-02f, 2.45703720e-02f, -5.60799092e-02f, -3.32495943e-02f, -2.64732540e-03f, -1.10102631e-01f, -3.71605195e-02f, 1.51076717e-02f, 1.84275825e-02f, -1.92593224e-02f,
  1.16435520e-01f, 1.00317098e-01f, -3.84448953e-02f, 1.64021726e-03f, 3.52842510e-02f, 5.59529476e-02f, -4.19599041e-02f, 2.71164328e-02f, 1.15771018e-01f, 4.35332358e-02f,
  6.53541386e-02f, -2.32336540e-02f, 6.42190874e-02f, 5.26237674e-02f, 3.05375475e-02f, 9.35116783e-02f, 1.10823199e-01f, -6.32955730e-02f, 5.63383512e-02f, 1.17335759e-01f,
  9.86071676e-02f, 2.84387451e-03f, -8.35152268e-02f, -6.53394312e-02f, 1.74962613e-03f, -1.38773784e-01f, 6.17768951e-02f, -3.47625837e-02f, -9.68090519e-02f, -1.09431192e-01f,
  -5.03837705e-01f, -8.85762721e-02f, 2.70862073e-01f, -3.41582090e-01f, -2.07755882e-02f, 2.29927838e-01f, 3.41230720e-01f, 4.29871231e-02f, -2.48532221e-01f, -5.49462587e-02f,
  -1.68934211e-01f, -6.61229566e-02f, -7.85082877e-02f, 5.11949547e-02f, 1.41143814e-01f, 2.12969854e-01f, 1.12112761e-01f, 1.89797059e-01f, 2.99813956e-01f, 1.09089911e-01f,
  -5.69549873e-02f, -1.20192535e-01f, -6.39795959e-02f, -1.49159646e-02f, -1.62578970e-01f, -9.39249545e-02f, -1.54636145e-01f, -1.51301056e-01f, 1.03606619e-01f, -1.73807651e-01f,
  1.49942726e-01f, -7.22390860e-02f, 1.85861498e-01f, 7.12989941e-02f, 1.13073625e-01f, 1.33099735e-01f, 1.30916730e-01f, 1.34897023e-01f, 1.16741590e-01f, 8.67942721e-02f,
  6.31233379e-02f, 1.01523168e-01f, 4.71890084e-02f, 8.05044100e-02f, 4.04900387e-02f, 1.86881691e-01f, 3.13628353e-02f, 1.43125821e-02f, 7.12934807e-02f, 1.14106297e-01f,
  5.98153919e-02f, 4.37561981e-03f, 8.39002896e-03f, 1.74255297e-01f, 7.13852048e-02f, 9.52026099e-02f, -3.39521840e-02f, 2.69885175e-02f, 1.17991664e-01f, -3.82310264e-02f,
  1.31829947e-01f, 2.20240075e-02f, -1.55494772e-02f, -3.65647934e-02f, -2.44331136e-02f, -5.74334199e-03f, -1.26344338e-02f, -3.85578535e-02f, 6.50625229e-02f, -7.26688234e-03f,
  -1.16022490e-02f, 9.21211764e-02f, 6.39657900e-02f, 5.51111326e-02f, 2.55179987e-03f, 2.17022598e-02f, 9.25093889e-03f, -2.36598272e-02f, 3.69032212e-02f, -4.03129719e-02f,
  1.77803263e-02f, 1.47979113e-03f, 4.33851071e-02f, 6.91090152e-02f, 1.13420086e-02f, 3.78192812e-02f, 4.65924926e-02f, 8.07719082e-02f, -8.44492465e-02f, -4.53953147e-02f,
  -1.36460930e-01f, 7.70655796e-02f, 2.49748328e-03f, 2.03884039e-02f, 2.14027129e-02f, 6.58694729e-02f, -4.28334475e-02f, 6.00925609e-02f, 3.82702500e-02f, 6.80353716e-02f,
  9.48434100e-02f, 3.37276086e-02f, 2.66622324e-02f, 5.42873628e-02f, 1.18303373e-01f, 4.78246808e-02f, 3.75158340e-02f, 5.69561264e-03f, 9.19980854e-02f, 4.51042727e-02f,
  1.18662901e-02f, 5.92797287e-02f, -2.12459434e-02f, 7.02411458e-02f, 5.10738418e-02f, 9.48449224e-02f, 1.44473538e-01f, 7.00127333e-02f, 6.08758517e-02f, 9.73285809e-02f,
  -2.39872001e-02f, 3.00462991e-01f, 1.51982337e-01f, 1.13145926e-03f, -2.55764276e-01f, -2.53436565e-01f, -6.19289605e-03f, -2.67441541e-01f, -1.40634701e-01f, 8.09335187e-02f,
  -1.72107518e-01f, -2.99479008e-01f, -1.37640163e-01f, -1.53587684e-01f, -2.31330708e-01f, 1.38255417e-01f, 1.65965840e-01f, 1.32945878e-02f, -3.43015909e-01f, -2.83489734e-01f,
  -2.11102068e-02f, 4.23508584e-02f, -1.00276023e-01f, -2.89465245e-02f, 9.15973932e-02f, -2.02732816e-01f, 1.32397532e-01f, 5.53673469e-02f, -6.74503893e-02f, 4.22295541e-01f,
  8.29406232e-02f, 3.25011164e-02f, -2.32242018e-01f, -1.14353396e-01f, -3.77020543e-03f, -6.60442337e-02f, -1.65659726e-01f, -4.57985848e-02f, -7.39967525e-02f, -1.69092305e-02f,
  -3.89955416e-02f, -1.20597973e-01f, -9.80524346e-02f, -1.48135707e-01f, -4.81122881e-02f, -1.63967445e-01f, 1.00658424e-02f, -5.31650297e-02f, -1.34063616e-01f, -4.01920453e-02f,
  -4.84146737e-02f, -4.06068787e-02f, -1.36095136e-01f, -1.21573478e-01f, -7.91737512e-02f, -2.11127311e-01f, -1.50303409e-01f, -1.40492126e-01f, -7.70037249e-02f, 1.45725623e-01f,
  3.70706916e-02f, 8.28371271e-02f, 4.74924259e-02f, 8.16562176e-02f, 6.49334565e-02f, 4.53985743e-02f, 4.18234915e-02f, 2.16920190e-02f, 6.30394444e-02f, 1.10777862e-01f,
  2.35823225e-02f, 7.02184215e-02f, 4.37500477e-02f, 7.90420547e-02f, 4.51139212e-02f, 2.66291387e-02f, -1.03072235e-02f, 1.14878386e-01f, 8.58428255e-02f, 4.21436206e-02f,
  2.41309535e-02f, 4.09961455e-02f, 1.86759934e-01f, 4.53039594e-02f, 7.24428445e-02f, 5.21132424e-02f, 2.35288590e-02f, 6.28101900e-02f, 3.38414572e-02f, 8.43397900e-02f,
  -1.73853248e-01f, -2.78477073e-01f, -9.76638123e-02f, -9.17787403e-02f, -1.01197787e-01f, -1.09168500e-01f, -5.38443327e-02f, -6.96774349e-02f, -7.72358403e-02f, -3.95266302e-02f,
  -7.99184889e-02f, -6.54066503e-02f, -3.37187685e-02f, -1.83852669e-02f, -1.05543926e-01f, -1.35672659e-01f, -8.15795809e-02f, -1.76097468e-01f, -1.37508675e-01f, -5.97337820e-02f,
  -9.35879722e-02f, -1.91580579e-01f, -3.58574092e-01f, -2.75523216e-01f, -1.92343563e-01f, -4.10793453e-01f, -1.63923651e-01f, -2.42645651e-01f, -3.45949590e-01f, -2.21827000e-01f,
  -2.14279979e-01f, -4.39877570e-01f, -1.69786945e-01f, 2.07477197e-01f, 9.14921761e-02f, -1.95960402e-01f, -4.75801170e-01f, -1.50201321e-01f, 1.40847564e-01f, -7.94415772e-02f,
  8.67643952e-02f, 3.15872014e-01f, 1.11673638e-01f, -2.55652936e-03f, -2.42427140e-01f, -3.98421794e-01f, 7.80324312e-03f, -7.14103952e-02f, 6.01082807e-03f, 1.31918207e-01f,
  1.11629859e-01f, 7.10590482e-02f, 4.78827320e-02f, 2.19662897e-02f, 1.66062340e-01f, 6.15910329e-02f, -8.79942179e-02f, 4.36372943e-02f, -1.65715277e-01f, 5.75664155e-02f,
  -6.55397251e-02f, -2.79461384e-01f, 4.29972075e-02f, 1.74192172e-02f, 4.46339101e-02f, -1.16872296e-01f, -1.46235347e-01f, 3.93900089e-02f, 5.81778288e-02f, 2.78262496e-02f,
  1.04757443e-01f, 4.78698425e-02f, 7.78084025e-02f, -1.15698110e-02f, -1.17334630e-02f, -4.05591168e-02f, 2.77708191e-02f, -4.54867668e-02f, -1.00979671e-01f, -4.55246419e-02f,
  8.64948183e-02f, 4.43939306e-02f, -8.16634521e-02f, -6.17727600e-02f, -1.18992694e-01f, 2.79217251e-02f, -1.65083915e-01f, -1.32362004e-02f, -1.65111378e-01f, -1.53499126e-01f,
  -2.36785728e-02f, 3.31302918e-02f, -6.49156272e-02f, -9.31792781e-02f, -2.44215503e-02f, 2.84209810e-02f, 7.61567429e-02f, 6.04954138e-02f, 6.75668754e-03f, -6.56514317e-02f,
  4.43170406e-02f, -1.44796045e-02f, 2.77579646e-03f, -1.49808712e-02f, 6.64397851e-02f, 2.45230328e-02f, 4.89999726e-02f, 4.94072586e-03f, 3.04517709e-02f, 3.00202649e-02f,
  2.68513896e-02f, 8.62717405e-02f, 1.60846971e-02f, 4.87462766e-02f, -6.52641878e-02f, -5.33063039e-02f, -2.12757178e-02f, -2.41389778e-02f, -5.37541024e-02f, -9.78734568e-02f,
  6.28739297e-02f, -5.37934750e-02f, -7.34911347e-03f, -4.44579162e-02f, 1.12402812e-02f, 2.18385309e-02f, 1.05537660e-02f, -1.66484111e-04f, 4.35474254e-02f, -5.28163761e-02f,
  -6.46172836e-02f, -7.13577643e-02f, -3.70794744e-03f, 8.99868309e-02f, 1.96284950e-02f, -1.10847605e-02f, -5.83211370e-02f, 1.11058332e-01f, 8.36635381e-03f, -4.99600694e-02f,
  -4.81697060e-02f, -4.32722643e-02f, -6.47099987e-02f, -3.01867388e-02f, -4.28070948e-02f, 1.60104670e-02f, -6.94116428e-02f, -4.27090712e-02f, -2.33950630e-01f, -3.07092130e-01f,
  -4.82355893e-01f, 1.42899826e-01f, 4.29255903e-01f, -4.23261881e-01f, -5.71086556e-02f, -2.37395346e-01f, -1.06766626e-01f, -3.17527860e-01f, -2.95131534e-01f, 1.56569090e-02f,
  2.20630113e-02f, 7.23424088e-03f, -6.79315776e-02f, -8.25202912e-02f, -7.64746740e-02f, 6.19961880e-02f, 1.58758089e-01f, 1.35886148e-01f, -2.39593908e-01f, -2.02952728e-01f,
  -1.79617286e-01f, -9.43847820e-02f, -1.29667386e-01f, -5.70546389e-02f, 1.37505263e-01f, -6.08975627e-02f, 2.41231650e-01f, 1.89720050e-01f, 2.06038326e-01f, 3.30964476e-01f,
  4.93240744e-01f, 9.87385362e-02f, -8.30062553e-02f, -8.19016993e-03f, 1.66911185e-01f, -1.89827085e-02f, 9.22238827e-02f, 1.06807999e-01f, 4.41068672e-02f, 3.84540521e-02f,
  2.04511449e-01f, 1.43340593e-02f, 1.45312071e-01f, 1.11658804e-01f, 7.87189305e-02f, 9.14192013e-03f, 5.03865667e-02f, 1.03670103e-03f, 6.91682175e-02f, 6.30203038e-02f,
  9.42578092e-02f, 1.76070079e-01f, 1.90912351e-01f, 1.33057654e-01f, 2.44820341e-02f, 6.48297295e-02f, 1.76480547e-01f, 7.30681792e-02f, 6.92161471e-02f, 7.69857988e-02f,
  1.42342374e-02f, 8.98829550e-02f, 5.08934334e-02f, -6.61838353e-02f, -6.71582967e-02f, -2.48922817e-02f, 9.08559747e-03f, 4.19117929e-03f, -1.06615603e-01f, 5.05736284e-02f,
  -3.91884148e-02f, -5.41647002e-02f, 9.93153639e-03f, -2.46814149e-03f, -2.49722525e-02f, 5.11071384e-02f, -1.25761784e-03f, -4.55054753e-02f, 8.84067342e-02f, -7.79795423e-02f,
  -3.74672636e-02f, -4.14206497e-02f, -1.44482534e-02f, 8.40265676e-03f, 2.63944101e-02f, -1.39348349e-02f, 1.82963032e-02f, -7.62379682e-03f, -1.43999318e-02f, 7.51122832e-03f,
  -1.10793732e-01f, -7.32210949e-02f, 1.37388250e-02f, -6.62614331e-02f, 2.11046170e-02f, 4.61417623e-02f, -4.19224128e-02f, 4.54181544e-02f, -1.97785962e-02f, -7.64538422e-02f,
  -9.32798460e-02f, -1.16876513e-01f, -5.04343631e-03f, 6.79316595e-02f, -1.46150306e-01f, 1.01787597e-02f, -1.85089279e-02f, -1.53222205e-02f, -6.80974349e-02f, 6.09881245e-03f,
  -1.49302751e-01f, -1.68904915e-01f, -2.15598077e-01f, -1.40339971e-01f, -1.08355805e-02f, -1.85489848e-01f, -3.15728853e-03f, -2.01726221e-02f, -1.07529961e-01f, -2.19369367e-01f,
  4.49864656e-01f, 9.24003497e-02f, 1.88942596e-01f, 4.18783836e-02f, -6.61350116e-02f, 1.35205865e-01f, 2.91327477e-01f, 2.58944333e-01f, -7.74539039e-02f, -3.45227532e-02f,
  -1.58727974e-01f, -2.72578508e-01f, -2.86210895e-01f, -2.47524559e-01f, 2.57070005e-01f, 4.38784473e-02f, 2.56283805e-02f, 1.90269262e-01f, 2.26684362e-01f, 4.46318127e-02f,
  -2.24380150e-01f, 3.11377272e-02f, 2.26589918e-01f, 2.30743751e-01f, -1.07610695e-01f, -7.15884715e-02f, -2.13267691e-02f, 7.65019283e-03f, -7.60364383e-02f, 1.30104274e-01f,
  -3.97213064e-02f, 3.27883333e-01f, 7.89281949e-02f, 3.50628830e-02f, -1.17176697e-02f, 1.14001453e-01f, 1.45328805e-01f, 1.26786441e-01f, 6.28607795e-02f, 1.15378179e-01f,
  -4.89921169e-03f, 3.18244216e-03f, -2.20046006e-02f, -6.63188025e-02f, 1.35964319e-01f, 5.37772030e-02f, 1.00373864e-01f, 1.45939916e-01f, 1.42074406e-01f, 9.42806993e-03f,
  -1.89863443e-01f, 1.71918094e-01f, 1.76116034e-01f, 1.37867883e-01f, 1.92240879e-01f, 1.28723845e-01f, 2.27675200e-01f, 2.67705262e-01f, 2.73067772e-01f, 3.02656054e-01f,
  -1.35168999e-01f, 6.47073835e-02f, -5.60289025e-02f, 4.90355603e-02f, -4.08793241e-02f, -4.90031913e-02f, -7.59762973e-02f, -2.18378734e-02f, -3.77974696e-02f, -4.56670001e-02f,
  -6.99456781e-02f, 8.09824653e-03f, -8.55804011e-02f, -1.49854915e-02f, -7.36256540e-02f, 7.23139793e-02f, -3.98732908e-02f, -2.72912416e-03f, -1.25561247e-03f, 3.15663293e-02f,
  -1.21533405e-02f, 8.10658261e-02f, -7.93979391e-02f, 4.05297577e-02f, 1.20305382e-02f, 5.43779917e-02f, -4.40954529e-02f, 2.86235362e-02f, 4.12318949e-03f, 1.03817983e-02f,
  -2.89931566e-01f, 1.06826819e-01f, 3.06865536e-02f, 8.46254230e-02f, -2.84693623e-03f, -6.83308616e-02f, -1.07968047e-01f, 9.82445385e-03f, -6.49686009e-02f, 1.17463335e-01f,
  5.80830127e-02f, 1.09269343e-01f, -5.49770519e-02f, 5.03121642e-03f, 9.14680734e-02f, -1.71219639e-03f, -5.25217056e-02f, 1.94580201e-02f, 4.53975871e-02f, 3.34251076e-02f,
  -7.52313435e-02f, 1.02939889e-01f, 6.40236884e-02f, -2.28275396e-02f, 6.99548423e-02f, 2.50942558e-02f, -4.19009104e-02f, 6.94829226e-02f, 4.17561792e-02f, -2.07823198e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.07649624e+00f, -5.31983316e-01f, 4.74624217e-01f, 2.00479314e-01f, 2.97210906e-02f, 9.54482257e-02f, 3.77797410e-02f, 5.19643091e-02f, 8.93504992e-02f, 3.02184597e-02f,
  -1.62111685e-01f, -5.58623001e-02f, -1.16434842e-01f, -8.13728347e-02f, 1.72179893e-01f, 8.90862644e-02f, 1.02544740e-01f, 4.88224179e-01f, 3.71068567e-01f, 2.31193006e-01f,
  -6.29175156e-02f, 6.76142275e-02f, 2.65772253e-01f, 1.63073570e-01f, -8.12131539e-03f, 3.45040448e-02f, 3.04891281e-02f, -1.83262601e-01f, -7.83458054e-02f, -5.98528981e-03f,
  2.51987785e-01f, 1.83405325e-01f, -1.40911638e-04f, -2.70468682e-01f, -1.70501053e-01f, -3.67425173e-03f, 4.05131616e-02f, -1.14730589e-01f, -1.59608424e-01f, -1.23550102e-01f,
  -2.62517631e-01f, 6.90900907e-03f, -3.89570482e-02f, -8.44640583e-02f, -1.37442006e-02f, -6.26173150e-03f, -2.31809802e-02f, 1.56099245e-01f, 2.99119465e-02f, -4.78413999e-02f,
  -1.76567972e-01f, -5.91314211e-02f, 8.18437859e-02f, -8.05676430e-02f, 5.48482761e-02f, 7.04927221e-02f, 5.70345018e-03f, 8.99133757e-02f, 1.35086134e-01f, 1.59087047e-01f,
  1.91272661e-01f, 1.42077804e-01f, 1.11928880e-01f, 7.55491182e-02f, 3.95927764e-02f, 8.37041885e-02f, 3.58769931e-02f, -6.00185208e-02f, 1.44388214e-01f, 6.18760400e-02f,
  3.88790038e-03f, 1.20136030e-01f, -1.06015634e-02f, -1.28307873e-02f, -1.16596632e-02f, -7.35625923e-02f, -5.46861589e-02f, -1.78409755e-01f, 9.73505974e-02f, -9.14897863e-03f,
  1.25403181e-01f, -8.08031112e-03f, -5.17416373e-02f, 4.11777338e-03f, -6.11033887e-02f, 1.05345577e-01f, 1.66254461e-01f, -9.73780304e-02f, -6.58582821e-02f, -5.19982949e-02f,
  -6.67063892e-01f, -1.91359129e-02f, 2.33017221e-01f, -1.91200264e-02f, -9.18894857e-02f, -1.44026354e-01f, 7.74313733e-02f, -1.70789644e-01f, -2.61170655e-01f, -1.09460630e-01f,
  -8.14167336e-02f, 1.69609766e-02f, -6.34332597e-02f, 8.33474249e-02f, 1.50359586e-01f, -1.18801065e-01f, -4.27075252e-02f, -5.64945005e-02f, -4.19586711e-02f, -3.23095322e-02f,
  -1.09350555e-01f, 4.61567901e-02f, 7.24660158e-02f, 6.73808463e-05f, -2.84658857e-02f, 1.75192803e-01f, 1.52810803e-02f, 5.91077432e-02f, 5.68440147e-02f, -1.74688920e-03f,
  1.57823652e-01f, -5.48073471e-01f, -3.60692292e-01f, -6.33345902e-01f, -3.03853452e-01f, -3.56127061e-02f, -1.24151126e-01f, -2.19883248e-01f, -2.12310106e-01f, -2.74800837e-01f,
  6.08798116e-02f, 3.82459491e-01f, 3.10218602e-01f, 2.85822690e-01f, 2.76846081e-01f, -3.62761945e-01f, -5.47747135e-01f, 1.88328609e-01f, 5.13444304e-01f, 2.22650748e-02f,
  -1.59548357e-01f, -4.01463687e-01f, -1.01132207e-01f, -2.33106688e-01f, -6.14413738e-01f, -6.66887909e-02f, -4.22378689e-01f, -3.45384628e-01f, -1.30297258e-01f, -5.70412457e-01f,
  3.90671343e-01f, 7.72470236e-02f, 1.34895116e-01f, 9.74057019e-02f, -1.84283089e-02f, 1.57237932e-01f, 3.52156572e-02f, -1.50555223e-01f, 3.07244714e-02f, -1.24778070e-01f,
  -2.30380590e-03f, 1.19437434e-01f, 2.24704355e-01f, 4.69678007e-02f, -5.87133020e-02f, 2.04375684e-02f, -7.16424882e-02f, -1.61456332e-01f, -7.85275549e-02f, 7.62328804e-02f,
  -3.14926659e-03f, -5.71292154e-02f, 2.43927743e-02f, -6.89806491e-02f, 4.65174243e-02f, 2.80890763e-01f, 3.38954851e-02f, 9.02671814e-02f, 1.60558149e-01f, -6.71766326e-02f,
  4.47634514e-03f, -2.99332123e-02f, -1.74350571e-02f, 1.23632187e-02f, 1.02850169e-01f, -1.07552623e-02f, -1.79437455e-02f, 1.52913667e-02f, 3.54535226e-03f, -1.32784331e-02f,
  -1.12314500e-01f, -2.86232363e-02f, -2.94774473e-02f, -9.77564976e-02f, -6.75049424e-02f, -5.84743321e-02f, -5.27351536e-02f, -6.87506720e-02f, 1.16818860e-01f, -4.82964329e-02f,
  1.82279542e-01f, 1.10902097e-02f, -1.35829702e-01f, -8.56238678e-02f, -8.39580521e-02f, -4.22789901e-02f, 6.31146878e-02f, -1.70507692e-02f, 5.69281913e-02f, 1.33280503e-02f,
  -2.82151327e-02f, 3.64119053e-01f, 7.07033202e-02f, 8.96246731e-02f, 4.68146019e-02f, -1.36175826e-01f, 4.04180102e-02f, -2.92091016e-02f, 4.17440087e-02f, 8.76420066e-02f,
  1.39592933e-02f, 2.22284302e-01f, -3.49250808e-02f, -5.07296212e-02f, 1.43307105e-01f, 5.79952225e-02f, -3.88552509e-02f, -2.93072574e-02f, -1.14491973e-02f, -7.90873840e-02f,
  -1.42872512e-01f, 5.22110723e-02f, 2.35033900e-01f, 1.13118559e-01f, 1.86721578e-01f, 3.44698071e-01f, 9.07188281e-02f, 1.22443460e-01f, 1.72515690e-01f, -8.89569670e-02f,
  5.52760124e-01f, -1.06904432e-01f, 7.92518318e-01f, 2.85240710e-01f, 1.90321535e-01f, 5.14244795e-01f, 5.17553627e-01f, 2.82233149e-01f, 1.42355725e-01f, 3.06622069e-02f,
  -3.04679155e-01f, -5.52992702e-01f, -4.12631214e-01f, -2.21774489e-01f, 8.73089060e-02f, 1.73291996e-01f, 2.14364991e-01f, 3.46186697e-01f, 3.93561125e-01f, 1.99409530e-01f,
  -2.55809754e-01f, 1.20443977e-01f, 2.84789890e-01f, 1.28519446e-01f, -6.10550791e-02f, -1.75667703e-01f, -1.13472268e-01f, 9.08572301e-02f, -7.73892030e-02f, -1.86245933e-01f,
  3.10060859e-01f, 2.31106594e-01f, -2.41113380e-01f, -2.35998347e-01f, -1.68614969e-01f, 1.49685028e-03f, -3.24091427e-02f, -4.07566056e-02f, -8.56316090e-02f, -4.12833132e-02f,
  -2.23332793e-02f, 4.80808578e-02f, 1.64826289e-01f, -3.25333588e-02f, 9.72808450e-02f, 1.10559449e-01f, -6.28712103e-02f, 8.59950259e-02f, -1.71597190e-02f, -2.54554581e-02f,
  -2.09374607e-01f, 6.71808571e-02f, 1.51133806e-01f, -4.24502492e-02f, 3.67757678e-02f, -1.05624542e-01f, -1.12419605e-01f, -1.57235600e-02f, 6.06151819e-02f, -6.73638433e-02f,
  -9.93515644e-03f, -9.26694348e-02f, -2.66963057e-02f, 7.74879530e-02f, 4.28142026e-02f, 6.33608922e-03f, 6.14068434e-02f, -9.35070310e-03f, -1.67767808e-03f, 7.40100220e-02f,
  -3.84984203e-02f, -1.08916415e-02f, 8.74756053e-02f, 1.86560929e-01f, -9.74360406e-02f, -1.06447497e-02f, 6.24932870e-02f, 3.46339829e-02f, -8.55172947e-02f, -3.91811691e-02f,
  -5.06382845e-02f, 6.59690425e-02f, 2.00669076e-02f, 1.43941537e-01f, -3.92826572e-02f, -1.55980047e-02f, 3.09173185e-02f, -1.35260060e-01f, -2.83437199e-03f, -1.05413273e-01f,
  -2.83019483e-01f, 1.93141237e-01f, -1.01972707e-01f, -2.16812920e-03f, 1.03255875e-01f, 1.81509890e-02f, -3.59998904e-02f, 7.05765337e-02f, 4.79701757e-02f, 1.40787318e-01f,
  8.83134678e-02f, 1.51409775e-01f, 1.89239532e-02f, 6.16742205e-03f, 4.84523661e-02f, 6.60068691e-02f, -2.04775885e-01f, 2.90253032e-02f, 5.93086146e-02f, 1.13559933e-02f,
  -8.83283392e-02f, 2.28796154e-02f, 6.17594197e-02f, 1.37507319e-01f, -9.34534445e-02f, -5.19792698e-02f, 1.25327215e-01f, 3.93388867e-02f, 2.32151955e-01f, 1.30767142e-02f,
  4.56916451e-01f, 3.95706654e-01f, -1.03017844e-01f, 2.51465350e-01f, 1.47009894e-01f, -2.97553856e-02f, 3.52092385e-02f, 2.79148459e-03f, 3.06676445e-03f, 2.08716050e-01f,
  2.60319710e-01f, 2.92778313e-01f, 2.64382482e-01f, 9.18949321e-02f, 5.65508269e-02f, -4.66534821e-03f, 1.97239026e-01f, 4.15179171e-02f, -7.01440424e-02f, 1.51631728e-01f,
  2.71247089e-01f, 7.35400841e-02f, 6.65261503e-03f, -3.22320126e-02f, 3.75886291e-01f, 3.01026314e-01f, 7.06693456e-02f, 1.37465522e-01f, 2.52236396e-01f, 5.59009373e-01f,
  1.92855850e-01f, 3.45124841e-01f, -1.20578617e-01f, 8.74098018e-02f, -3.10915820e-02f, -1.61289111e-01f, -1.13645062e-01f, -9.79300290e-02f, -6.13560043e-02f, -1.54224113e-01f,
  -5.90555146e-02f, 4.61395830e-02f, 1.94092952e-02f, 1.70919690e-02f, -1.59972894e-03f, -1.37321368e-01f, -2.66311374e-02f, -5.98822441e-03f, -1.64754942e-01f, -6.71390295e-02f,
  1.38501167e-01f, -3.97365130e-02f, -1.48079410e-01f, -1.33780494e-01f, -6.09965660e-02f, 5.53616360e-02f, -5.20775914e-02f, 1.50681943e-01f, -1.35221258e-01f, 7.92618170e-02f,
  1.37691945e-01f, 1.40115499e-01f, 1.82518795e-01f, 2.06292525e-01f, 1.13799818e-01f, 1.63109004e-02f, 8.56123457e-04f, -1.39686291e-03f, 5.39773703e-02f, -3.72858606e-02f,
  9.17870998e-02f, 5.98912761e-02f, 3.13323438e-02f, 8.67372304e-02f, 1.15244135e-01f, 1.18999667e-02f, 3.39036323e-02f, -4.19028550e-02f, -3.78152207e-02f, -1.60453953e-02f,
  -1.52571015e-02f, -3.62928808e-02f, -1.44255444e-01f, -5.71412779e-03f, -1.21120565e-01f, 2.66698226e-02f, -1.66645162e-02f, 5.90912737e-02f, -6.55230833e-03f, 7.89877027e-02f,
  -4.53865677e-01f, -2.32945174e-01f, -2.04470102e-03f, 6.40767738e-02f, 2.72608805e-03f, -2.64760032e-02f, 1.22774631e-01f, -1.16570927e-01f, -4.77145705e-03f, 1.66203827e-03f,
  2.90347566e-03f, 8.15896615e-02f, -1.19170928e-02f, 1.72680318e-02f, -1.25227094e-01f, -2.44503934e-02f, -1.14770513e-02f, -1.23669490e-01f, -9.89639312e-02f, -1.70676783e-01f,
  -1.54760644e-01f, -2.69003719e-01f, -3.17890614e-01f, -1.79150924e-01f, 9.44313332e-02f, -8.17738101e-02f, -1.41403362e-01f, -7.52916262e-02f, -1.81974992e-01f, -2.35487476e-01f,
  7.39072382e-01f, 1.79687575e-01f, -1.23012936e+00f, 7.60615841e-02f, -5.85271239e-01f, -5.76117516e-01f, -4.20124024e-01f, 2.88331479e-01f, 4.00629044e-01f, -1.85564458e-01f,
  -1.44743949e-01f, 1.58519730e-01f, -6.87021390e-02f, -1.85798422e-01f, -2.67946184e-01f, -5.64310551e-01f, -6.38332129e-01f, -5.46245754e-01f, -4.11027402e-01f, 3.89281251e-02f,
  -7.30709359e-02f, -6.57542124e-02f, 2.07941011e-02f, -6.08236119e-02f, -1.45203874e-01f, -1.68871075e-01f, -4.06902492e-01f, -1.93451300e-01f, -3.72753471e-01f, -4.60695297e-01f,
  -7.37880290e-01f, -2.65330765e-02f, -1.50514215e-01f, 2.72445291e-01f, -3.87097038e-02f, 1.34176776e-01f, 2.40197573e-02f, 2.53717396e-02f, 1.22753419e-01f, -5.85068092e-02f,
  -1.12232812e-01f, 4.00127098e-02f, 1.65109679e-01f, -4.85154241e-02f, 7.25825429e-02f, 4.41081710e-02f, 2.09772047e-02f, -8.34383890e-02f, -2.48607114e-01f, 7.40107968e-02f,
  2.71527711e-02f, -8.15858692e-02f, -1.83602169e-01f, 1.24826029e-01f, -1.11439936e-01f, -6.31886497e-02f, -1.31452456e-01f, -4.79289070e-02f, -1.60343677e-01f, 8.17272589e-02f,
  2.17585322e-02f, -1.87209190e-03f, 3.87798995e-02f, 6.45488426e-02f, 2.13089883e-01f, 5.87923340e-02f, 8.68630558e-02f, 9.12001282e-02f, 1.12045154e-01f, -7.65482187e-02f,
  2.37584524e-02f, -9.84180253e-03f, 3.50061711e-03f, 4.35220934e-02f, -1.73010886e-01f, -7.65803084e-03f, 6.33744076e-02f, -2.45048460e-02f, 2.17738636e-02f, 7.57913440e-02f,
  1.61414996e-01f, 8.76091644e-02f, 3.06330193e-02f, 3.13320905e-02f, -1.12407073e-01f, -9.09730941e-02f, -6.60721883e-02f, 1.56787455e-01f, 1.86007857e-01f, -2.47651264e-02f,
  2.07328573e-01f, -2.05356508e-01f, -1.98694468e-02f, 1.23802640e-01f, -1.42824590e-01f, -3.20579372e-02f, 1.18969148e-03f, 1.39923245e-01f, 1.62198111e-01f, 1.60908233e-02f,
  1.33807391e-01f, 3.50930393e-02f, 4.09020893e-02f, 1.36304885e-01f, 2.36640964e-02f, -6.06589615e-02f, 1.86496034e-01f, 1.29180923e-01f, 3.47765572e-02f, 5.70039153e-02f,
  1.17112949e-01f, 9.84266251e-02f, 2.39537433e-01f, 1.53200641e-01f, 2.22605422e-01f, 5.71733378e-02f, -3.78883607e-03f, -3.52547467e-02f, -3.93593088e-02f, 3.04563433e-01f,
  -1.13581300e-01f, -2.49595821e-01f, -2.41817981e-01f, 1.89705685e-01f, -1.53122311e-02f, -2.30050713e-01f, -3.56104732e-01f, -3.74636531e-01f, -4.09073476e-03f, -1.13480724e-01f,
  -8.46097097e-02f, 1.37433901e-01f, 1.83321893e-01f, 9.01840180e-02f, 3.37283351e-02f, 2.89156917e-03f, 2.90815920e-01f, 1.75182164e-01f, 3.24201658e-02f, 5.10193445e-02f,
  2.59730160e-01f, -1.02687962e-01f, -1.53059065e-01f, 1.44904643e-01f, 4.03811216e-01f, 2.55490780e-01f, 9.45250690e-02f, 1.72276109e-01f, 1.56987175e-01f, 6.70792639e-01f,
  1.01559401e-01f, 7.94652291e-03f, 2.96177447e-01f, 1.48277447e-01f, 2.03016307e-02f, -1.25108317e-01f, 4.65696044e-02f, -3.62617970e-02f, 9.96659622e-02f, -1.47878498e-01f,
  9.66766924e-02f, -3.09015755e-02f, 6.53691888e-02f, 3.94637063e-02f, -5.73345199e-02f, -4.57005762e-02f, 1.01568997e-02f, 8.08770116e-03f, -3.80074382e-02f, -9.66493711e-02f,
  1.78609148e-01f, -6.94192573e-02f, -2.03543589e-01f, -3.68652977e-02f, -7.14751557e-02f, 2.84886956e-01f, 7.03807687e-03f, 4.14424855e-03f, 2.92442460e-03f, 4.73102517e-02f,
  8.65889192e-02f, -9.16173160e-02f, -4.84169088e-02f, 9.85118300e-02f, 7.81334713e-02f, -5.28762490e-03f, 9.80590284e-02f, 6.39979616e-02f, 3.39239277e-02f, 5.01531251e-02f,
  1.05516702e-01f, -6.10491671e-02f, -4.36770841e-02f, -1.00065701e-01f, 1.15923710e-01f, 7.97773078e-02f, -2.10389718e-02f, 8.49957392e-02f, 1.00534493e-02f, -7.65860751e-02f,
  -2.20576823e-02f, -7.02743232e-02f, 3.83278988e-02f, -8.18654720e-04f, -7.80064985e-02f, 1.34078816e-01f, -2.27569733e-02f, -1.99039970e-02f, -2.33433297e-04f, -3.22414115e-02f,
  -6.09314203e-01f, 2.66362000e-02f, 2.66944766e-01f, 3.92241254e-02f, -1.40619231e-02f, -2.48182435e-02f, 1.88329637e-01f, 7.83045664e-02f, 6.78224042e-02f, -7.15803728e-02f,
  -9.84383747e-02f, 8.02719686e-03f, -1.23851895e-01f, -1.41032696e-01f, -7.29888007e-02f, -9.60968360e-02f, 6.49318993e-02f, 1.09194778e-02f, -5.35937399e-02f, -1.23933949e-01f,
  -2.72967741e-02f, -2.71031708e-01f, -4.46374834e-01f, -1.88779593e-01f, -7.73335770e-02f, 1.37461588e-01f, -1.52580023e-01f, -8.70540664e-02f, -2.50100911e-01f, -4.33723032e-01f,
  -4.54264849e-01f, 8.72487605e-01f, 5.25907949e-02f, -4.11154598e-01f, 3.22716832e-01f, 3.97976547e-01f, 6.97980344e-01f, 2.53816664e-01f, -3.05732846e-01f, 1.52409375e-01f,
  4.16153312e-01f, -1.29170150e-01f, -1.72234997e-01f, -9.32225659e-02f, 1.62508309e-01f, 2.99399793e-01f, 2.15284601e-01f, -2.67847210e-01f, -3.00573647e-01f, -1.17376000e-02f,
  3.33112739e-02f, -2.11117715e-01f, -4.01698977e-01f, -2.44470164e-01f, -2.05365688e-01f, -3.42195779e-01f, 1.59386814e-01f, 9.46191028e-02f, 3.24800193e-01f, -1.99506313e-01f,
  -2.34079450e-01f, 2.91699260e-01f, -2.68838078e-01f, -2.51960665e-01f, 9.45590995e-03f, -2.29437634e-01f, -1.40396178e-01f, -2.13782191e-01f, -5.71631230e-02f, -3.63466889e-02f,
  -4.13282737e-02f, -1.85581036e-02f, 4.75949384e-02f, -1.22560235e-02f, -2.49642543e-02f, -3.37668546e-02f, 6.93845237e-03f, -1.32848829e-01f, -9.14502069e-02f, -1.29274711e-01f,
  1.44147351e-01f, 2.18073741e-01f, 1.99601993e-01f, 2.68055469e-01f, 7.21445158e-02f, -1.63497806e-01f, 2.13314369e-01f, -3.79363224e-02f, 7.09647760e-02f, -2.57369608e-01f,
  -2.32656039e-02f, 9.35225785e-02f, 3.50609384e-02f, 7.14486390e-02f, 3.97508964e-02f, 7.63094425e-02f, -3.96613479e-02f, 5.07448614e-02f, 5.11622466e-02f, 1.86750982e-02f,
  2.84354184e-02f, -1.04448333e-01f, 3.55580226e-02f, 2.72135232e-02f, -8.80076140e-02f, -2.26929057e-02f, 6.70619635e-03f, -1.37602808e-02f, 6.51816353e-02f, 1.47443973e-02f,
  -9.42170098e-02f, -1.42678665e-02f, 1.26816049e-01f, -7.52037689e-02f, 1.49438187e-01f, -4.63550277e-02f, -3.79957333e-02f, 1.69614647e-02f, -2.18457766e-02f, 5.75115569e-02f,
  -5.35494745e-01f, 4.08613801e-01f, -4.23309147e-01f, -5.69184795e-02f, 1.90410718e-01f, 2.92872321e-02f, 9.29226577e-02f, 8.40220228e-02f, 9.12169591e-02f, -7.28902891e-02f,
  6.41137268e-03f, -6.43037492e-04f, 2.66754925e-01f, -8.52139667e-02f, -1.82102874e-01f, -1.01416476e-01f, 1.00272283e-01f, -9.58730653e-02f, -1.22615933e-01f, -3.39226723e-02f,
  4.94759297e-03f, -5.75849675e-02f, -2.06426606e-01f, -5.73728830e-02f, -1.50135294e-01f, -1.35496274e-01f, -4.00092676e-02f, -2.31579930e-01f, -4.11572605e-02f, -3.40694994e-01f,
  -6.24898672e-01f, -6.07251108e-01f, -8.18959922e-02f, -5.05803823e-01f, -2.74624527e-01f, 1.37091521e-03f, -7.26819158e-01f, 1.99399143e-02f, -3.65358219e-02f, -7.69196451e-01f,
  -2.20885232e-01f, 2.63282746e-01f, 6.14995195e-04f, 2.15245843e-01f, 1.22772932e-01f, -7.25630224e-01f, -5.46090066e-01f, 1.53415114e-01f, 8.54024231e-01f, 4.31041092e-01f,
  -2.60731075e-02f, -1.03910007e-01f, 3.68730724e-01f, 1.42991066e-01f, -4.04790878e-01f, -1.76236048e-01f, -4.42415059e-01f, -1.20111227e-01f, -5.86497635e-02f, -7.13557124e-01f,
  -3.87189627e-01f, -1.88241839e-01f, 4.55372512e-01f, 2.68948585e-01f, -1.42828047e-01f, 6.76651001e-02f, -1.14954121e-01f, 5.60217910e-02f, -4.55285273e-02f, -6.61882535e-02f,
  5.60214231e-03f, 1.19522996e-01f, 7.85357356e-02f, 1.36507168e-01f, 4.10848446e-02f, 1.08377673e-01f, 1.91903263e-01f, 1.81932464e-01f, -5.07649966e-03f, -1.60054997e-01f,
  -2.04966709e-01f, -1.55869156e-01f, 8.55934769e-02f, 2.41867647e-01f, 1.77507684e-01f, 2.27293760e-01f, 1.09546170e-01f, 1.80305257e-01f, 2.80791402e-01f, -6.56213284e-01f,
  -1.39940709e-01f, -7.77002349e-02f, 9.02591869e-02f, 1.21939611e-02f, 1.59789473e-01f, -5.28370664e-02f, 5.73567711e-02f, 7.35844821e-02f, 1.75572827e-01f, -1.22400047e-02f,
  2.38141641e-01f, -2.08101571e-02f, 6.28236085e-02f, -2.39783913e-01f, 4.25868332e-02f, 3.17399874e-02f, -1.02176189e-01f, 1.22125477e-01f, 2.94790585e-02f, 1.01891728e-02f,
  8.37102160e-03f, 8.78964961e-02f, -4.32826951e-02f, 1.09866947e-01f, -3.15200984e-02f, 5.44679351e-03f, -1.42965838e-01f, 2.38410890e-01f, 3.72556876e-03f, 1.44296177e-02f,
  -2.79431999e-01f, 4.68075424e-01f, -5.63002110e-01f, 1.15901336e-01f, -2.12469280e-01f, 2.93719899e-02f, -1.90974236e-01f, 1.00923693e-02f, -4.74521630e-02f, -1.44926712e-01f,
  1.68304563e-01f, -2.21149549e-02f, -7.73768276e-02f, 1.93358645e-01f, 8.03454295e-02f, 9.19425935e-02f, -1.58507660e-01f, -2.65048281e-03f, 1.81549624e-01f, 6.92104846e-02f,
  3.36311460e-02f, -1.26743391e-01f, -5.80163449e-02f, -1.13559343e-01f, -1.64527893e-01f, -5.45782782e-02f, -7.66411722e-02f, -3.00966471e-01f, -1.37519926e-01f, -7.82255292e-01f,
  -5.11296391e-01f, 1.18347490e-02f, -5.32756686e-01f, -6.60068452e-01f, 2.52663437e-02f, 2.55835056e-01f, 1.17964074e-02f, 1.73009083e-01f, 1.95723355e-01f, 3.77070904e-02f,
  6.67230561e-02f, 1.27429858e-01f, -2.06628770e-01f, -1.48412526e-01f, -4.95500565e-01f, -3.85901719e-01f, -6.06185615e-01f, -5.72079360e-01f, -1.67447954e-01f, 3.57977897e-01f,
  3.02854121e-01f, -1.17428163e-02f, -3.76306415e-01f, -2.91984659e-02f, 1.83483154e-01f, -1.43918972e-02f, -2.61369497e-01f, -2.97451377e-01f, -8.34287778e-02f, -4.39454556e-01f,
  -1.40202090e-01f, 6.02817722e-02f, 4.92143705e-02f, -6.90245852e-02f, 1.33041054e-01f, 2.04372406e-01f, 2.05111161e-01f, 6.52832985e-02f, 1.22281231e-01f, 1.01203192e-02f,
  -1.60251305e-01f, 2.29208767e-01f, -8.55978355e-02f, 7.19838068e-02f, 5.06079867e-02f, -1.45608168e-02f, -8.76789019e-02f, -1.65577605e-02f, -2.84617860e-02f, 3.74504626e-01f,
  1.67133048e-01f, 1.20643424e-02f, -3.99307072e-01f, 7.53728077e-02f, 1.84787422e-01f, -9.16023459e-03f, 1.16277806e-01f, 1.70127705e-01f, 1.15424499e-01f, 3.14794271e-03f,
  1.54742405e-01f, 1.08434685e-01f, 4.22553159e-02f, 4.93354201e-02f, -6.83022588e-02f, -5.02636619e-02f, -1.15450490e-02f, -1.99159607e-01f, 1.13853931e-01f, -9.68121365e-02f,
  -4.76657366e-03f, 4.36384566e-02f, -1.14707071e-02f, -1.48776457e-01f, -2.61805803e-02f, -1.51988804e-01f, -4.65310961e-02f, -1.57840028e-01f, -3.38678136e-02f, -1.17211364e-01f,
  -1.67439193e-01f, -1.03331171e-01f, -1.49283081e-01f, -5.96830808e-02f, -2.31396593e-02f, 1.92424282e-04f, 1.33763134e-01f, 7.52996877e-02f, 2.76899748e-02f, 2.13915765e-01f,
  -3.54911238e-01f, -1.27250865e-01f, -2.44643837e-02f, -4.15175036e-02f, -1.99186519e-01f, 1.02332644e-01f, -9.47297662e-02f, -3.92601527e-02f, -2.58712500e-01f, 1.47225261e-01f,
  1.76179793e-03f, -1.13180481e-01f, -1.92625627e-01f, 1.35272205e-01f, 7.26619363e-02f, -6.77420432e-03f, -2.18338534e-01f, -2.42182195e-01f, -6.48059249e-02f, 1.93733975e-01f,
  -1.82359993e-01f, -3.67391825e-01f, -5.71856022e-01f, -2.99070805e-01f, 8.59242305e-02f, -2.20615566e-01f, -1.87334642e-01f, 1.08393513e-01f, -1.25828117e-01f, -1.47259012e-01f,
  3.55958313e-01f, 3.94327521e-01f, 5.20034954e-02f, 3.76310170e-01f, 3.82201523e-02f, 7.60305673e-02f, 8.47745761e-02f, 1.69293463e-01f, 2.54676968e-01f, 1.53559223e-01f,
  2.67009825e-01f, 2.49114245e-01f, 3.03712815e-01f, 1.68079928e-01f, 2.06282407e-01f, 1.22888107e-02f, 8.43995623e-03f, -2.34832913e-02f, -3.13765630e-02f, 3.31482962e-02f,
  1.06961913e-02f, -2.13463709e-01f, -2.10377648e-01f, -7.46524241e-03f, 1.18908338e-01f, 1.54780120e-01f, -8.28237534e-02f, -2.31780097e-01f, 1.62737779e-02f, -7.95997959e-03f,
  1.74355239e-01f, 1.48919553e-01f, 3.13909769e-01f, 5.54654859e-02f, 1.85504798e-02f, -4.74398918e-02f, -9.06120464e-02f, -1.36343062e-01f, -4.77006920e-02f, -5.35053993e-03f,
  -1.06171541e-01f, -1.61275476e-01f, -1.59388229e-01f, -1.06409214e-01f, -1.06215827e-01f, -1.18603915e-01f, -1.05428472e-01f, -1.65444072e-02f, 2.00871557e-01f, 1.11347497e-01f,
  4.03799266e-02f, -4.95271832e-02f, -4.31432109e-03f, 9.30082500e-02f, 1.35115206e-01f, 1.09332934e-01f, 2.20285319e-02f, -2.79210005e-02f, -4.69585583e-02f, -8.51432756e-02f,
  2.37190291e-01f, 1.63447663e-01f, 9.71962065e-02f, -6.63125589e-02f, -6.95888177e-02f, -6.98970407e-02f, -1.35461882e-01f, -8.66148919e-02f, -2.02798843e-02f, -1.61489487e-01f,
  -8.60429481e-02f, 1.09809533e-01f, -1.53104007e-01f, 8.99387598e-02f, 1.50706410e-01f, -5.88675588e-02f, -1.17946699e-01f, 7.78492838e-02f, -1.69245586e-01f, -2.80576218e-02f,
  -2.10002679e-02f, -8.56936499e-02f, -1.64751440e-01f, -8.37794617e-02f, 4.25538234e-02f, 7.69226551e-02f, -1.62107885e-01f, -2.75915163e-03f, -1.10257596e-01f, -5.44653796e-02f,
  1.80956021e-01f, 1.26269564e-01f, 1.45295009e-01f, 4.35418785e-02f, -9.06515568e-02f, -2.52053095e-03f, 1.26454234e-01f, 1.07133962e-01f, -4.55646962e-02f, -1.97043084e-02f,
  -9.22350213e-02f, -6.39523268e-02f, -6.62824064e-02f, -7.43692815e-02f, -1.47678047e-01f, -1.90570448e-02f, 5.22419885e-02f, 2.53740370e-01f, 1.07216135e-01f, 1.34804606e-01f,
  8.77172351e-02f, 3.73590291e-02f, 3.01976893e-02f, 4.47474569e-02f, 1.17957570e-01f, 1.05171770e-01f, 2.25551575e-02f, 4.53629345e-02f, -3.15742344e-02f, -6.79188445e-02f,
  -9.80746329e-01f, 8.82253125e-02f, -1.48901381e-02f, -4.86184835e-01f, 3.11246961e-01f, 4.52551275e-01f, 5.46951830e-01f, 1.33375242e-01f, -2.02157885e-01f, 8.55319425e-02f,
  -3.87381297e-03f, -2.83528715e-01f, -1.36417493e-01f, 7.69460425e-02f, 3.19846749e-01f, 4.07978475e-01f, 5.43787301e-01f, 7.78650716e-02f, -4.52735461e-02f, 3.62164676e-02f,
  2.82291770e-01f, -1.69164523e-01f, -4.53460097e-01f, -1.64584905e-01f, -1.54380620e-01f, 3.21590230e-02f, 7.86164030e-02f, -1.29198059e-01f, 2.98449546e-01f, 8.17162618e-02f,
  -2.09758118e-01f, -3.42060924e-01f, 1.35364145e-01f, -1.08714141e-02f, -2.05782235e-01f, -6.77688196e-02f, -2.61178501e-02f, -1.46142453e-01f, -1.71060383e-01f, 3.99436243e-02f,
  -1.92392513e-01f, -5.88071272e-02f, -7.97642693e-02f, 7.22719505e-02f, -1.78696528e-01f, -1.24046333e-01f, 1.13985047e-03f, -1.16151303e-01f, -1.18919671e-01f, 2.33420283e-02f,
  3.39703918e-01f, -4.27551717e-02f, -1.84628412e-01f, 1.20142005e-01f, 1.33322954e-01f, -8.80010352e-02f, 3.75995152e-02f, -9.43860635e-02f, 8.17285627e-02f, -2.87701041e-01f,
  1.44909382e-01f, -3.40553597e-02f, -5.61855137e-02f, -8.72267038e-02f, -1.62403703e-01f, -5.67376539e-02f, 1.65606096e-01f, 7.27253705e-02f, -4.03291266e-03f, -1.66222975e-01f,
  -3.87109257e-02f, 3.94855179e-02f, 1.06422015e-01f, -7.77551085e-02f, -2.44268328e-02f, -4.29071896e-02f, 8.63057002e-02f, -5.87445125e-02f, -1.04530886e-01f, -1.26732597e-02f,
  -3.23308371e-02f, 8.48524738e-04f, -1.48228943e-01f, 1.01868309e-01f, 2.78669208e-01f, -1.74878631e-02f, -6.38930276e-02f, -4.91337553e-02f, -1.04879320e-01f, 2.77049486e-02f,
  -2.98704594e-01f, 2.37464070e-01f, -1.60177857e-01f, 8.81311297e-03f, -1.51102036e-01f, -5.74878417e-02f, -1.42321661e-01f, -3.59128863e-02f, 5.87636977e-02f, 3.74694876e-02f,
  1.52342767e-01f, -1.67347744e-01f, -1.01901531e-01f, 7.95146599e-02f, -2.90288161e-02f, 2.67054215e-02f, 2.32241884e-01f, 2.78736930e-02f, 1.00153230e-01f, -5.07633239e-02f,
  1.12780184e-01f, -1.26025761e-02f, -1.10729210e-01f, 6.82925731e-02f, 9.43949148e-02f, -1.08647846e-01f, 2.99693979e-02f, -1.78945631e-01f, 2.23713398e-01f, -4.64425422e-02f,
  -1.03967321e+00f, 1.17576428e-01f, 3.44280273e-01f, -2.83173740e-01f, -1.05224058e-01f, -2.29648441e-01f, -5.24048880e-02f, -1.73869401e-01f, -1.33551762e-01f, 3.21075678e-01f,
  1.05677061e-01f, -4.16095972e-01f, -5.86604252e-02f, -2.67923504e-01f, -5.46565711e-01f, 1.55816540e-01f, -3.98102999e-02f, -4.65928972e-01f, -9.65890050e-01f, -7.62648284e-01f,
  -6.80752516e-01f, -6.30708039e-01f, -8.13517988e-01f, -3.10896039e-01f, 1.29896030e-01f, -3.27387393e-01f, 2.23407969e-01f, -2.05959529e-01f, -1.50434017e-01f, 1.44277081e-01f,
  5.40707529e-01f, 1.77758291e-01f, -5.95615432e-02f, -2.59458154e-01f, 7.72981569e-02f, -2.01634765e-02f, -4.09697108e-02f, 6.17333576e-02f, -5.47430292e-03f, 1.01980925e-01f,
  -6.24246150e-02f, -8.69634524e-02f, -1.04663379e-01f, 5.31864427e-02f, -8.35017338e-02f, -7.70102665e-02f, 1.37682885e-01f, 1.82201210e-02f, 2.61573792e-02f, 2.94274718e-01f,
  9.37865674e-02f, 2.22461484e-02f, 1.19386859e-01f, 2.60863721e-01f, 2.01366261e-01f, -1.21353246e-01f, 3.28773826e-01f, 1.38834357e-01f, 1.89397305e-01f, 3.24857980e-01f,
  1.16348170e-01f, 4.91145812e-02f, -7.72362351e-02f, 9.41558834e-03f, 1.83406658e-02f, 2.16564015e-02f, 3.60052735e-02f, 1.71168566e-01f, -4.90314700e-03f, -1.65864248e-02f,
  9.38250571e-02f, 1.41826645e-01f, 1.72485821e-02f, 5.30787511e-04f, 5.34609146e-02f, 6.98677227e-02f, 5.57412282e-02f, 7.84199461e-02f, 1.40055388e-01f, 4.84438473e-03f,
  -1.15479894e-01f, 1.50960647e-02f, -7.65296072e-03f, 2.79862974e-02f, -7.90723413e-03f, 6.41096011e-03f, 7.14864060e-02f, -7.48469755e-02f, -1.45732062e-02f, 2.85059516e-03f,
  2.23923966e-01f, -2.60905534e-01f, 6.05319999e-02f, -3.13794264e-03f, 8.94090682e-02f, 1.40054062e-01f, 1.62792057e-02f, -7.43507519e-02f, -7.71890655e-02f, -1.32847205e-01f,
  -1.63403302e-01f, 1.47019653e-03f, 1.37776941e-01f, 1.92049384e-01f, -2.19099730e-01f, -6.06919266e-02f, 1.21631566e-02f, -5.65369204e-02f, 2.79088388e-03f, 1.55631125e-01f,
  1.52903214e-01f, -5.71189187e-02f, -5.26952296e-02f, 1.92760810e-01f, 1.31517261e-01f, -2.48135120e-01f, 1.54268473e-01f, 1.06992289e-01f, -7.59975314e-02f, 1.59292147e-01f,
  -2.43312996e-02f, 1.79879174e-01f, -6.83941662e-01f, -2.08050475e-01f, -4.58622634e-01f, -2.56864339e-01f, 2.94359356e-01f, -1.52189523e-01f, -3.03720653e-01f, -5.38471788e-02f,
  -7.85732418e-02f, 1.64556652e-01f, 8.32459796e-03f, 6.85560629e-02f, 2.55083263e-01f, 6.90752789e-02f, -2.00960159e-01f, -5.93514740e-02f, 2.87375778e-01f, 1.92637831e-01f,
  3.15511733e-01f, 3.12014937e-01f, 2.42322519e-01f, -8.82407743e-03f, -1.51577041e-01f, 8.66573378e-02f, -9.34948027e-02f, -2.46892989e-01f, -2.25606278e-01f, -4.24656689e-01f,
  2.30754703e-01f, -5.94341874e-01f, -3.30007881e-01f, -1.52841374e-01f, -6.90003345e-03f, 1.31403795e-02f, 1.68632060e-01f, 4.31137159e-02f, -5.28111570e-02f, -1.15956314e-01f,
  -2.56629407e-01f, -4.48620915e-02f, 6.08153036e-03f, -3.58667746e-02f, 1.82204574e-01f, 1.96225271e-01f, -1.02023691e-01f, -7.05068707e-02f, -7.30166733e-02f, -6.35119202e-03f,
  -4.78151366e-02f, -2.17229873e-01f, -1.18318513e-01f, 2.08235532e-02f, -1.86981291e-01f, -4.57304455e-02f, -1.22485878e-02f, -1.79007843e-01f, -1.09818399e-01f, -2.18053777e-02f,
  -6.84748143e-02f, 7.48645738e-02f, 1.19245604e-01f, 1.32497072e-01f, 2.10851103e-01f, 5.45440353e-02f, 2.40956634e-01f, 7.70191103e-02f, 2.59964854e-01f, 1.78634599e-01f,
  -2.69524585e-02f, 9.37547311e-02f, 6.57999739e-02f, 1.57992095e-02f, -3.43128741e-02f, -1.21456049e-01f, -2.10806448e-02f, 1.45428449e-01f, -1.01778567e-01f, -2.67410930e-02f,
  1.52823338e-02f, -1.29410803e-01f, 2.56474167e-02f, 5.32252416e-02f, -3.13873917e-01f, -1.50377661e-01f, -1.97315067e-01f, 1.72262177e-01f, 4.35004681e-02f, -5.98012581e-02f,
  5.76972008e-01f, -4.16133642e-01f, 1.33548751e-01f, 9.02725384e-02f, 5.14530810e-04f, -7.47923478e-02f, 6.07857369e-02f, -1.23780996e-01f, 6.94648325e-02f, 1.15608342e-01f,
  -2.01365322e-01f, 5.37384115e-02f, 9.99439433e-02f, 8.52390379e-02f, 2.45910257e-01f, 6.75828829e-02f, 2.21890938e-02f, -7.04487972e-03f, -5.65553643e-02f, -3.56394090e-02f,
  -5.93736134e-02f, 1.07035004e-01f, 3.59510452e-01f, 7.76039064e-02f, 9.33346972e-02f, 1.48105443e-01f, 3.57828349e-01f, 9.74784419e-02f, 1.42593309e-01f, 5.45522094e-01f,
  -6.47173107e-01f, -3.85604382e-01f, -1.90956574e-02f, 9.91547853e-02f, 1.52489781e-01f, 1.35821894e-01f, 8.07676986e-02f, 1.14952862e-01f, 1.09896518e-01f, 9.81848612e-02f,
  1.68622211e-01f, 3.24462414e-01f, 2.73839384e-01f, 2.40670219e-01f, 1.51033714e-01f, 3.05030435e-01f, 1.59425169e-01f, 1.02910616e-01f, 1.59907877e-01f, 1.32855296e-01f,
  3.35199863e-01f, 5.89096826e-03f, -2.32231636e-02f, 6.63328320e-02f, 1.12190209e-01f, 2.88090497e-01f, 8.40500817e-02f, 1.28593445e-01f, 1.60612941e-01f, 1.25846907e-01f,
  6.59274876e-01f, -6.46426156e-02f, 1.04302034e-01f, 8.26090425e-02f, -5.25377616e-02f, -1.97230920e-01f, -1.32224401e-02f, -2.17310309e-01f, -2.46251315e-01f, -3.23622338e-02f,
  2.01312788e-02f, -1.36249349e-01f, -9.30023938e-03f, -1.38475761e-01f, -2.01363325e-01f, -1.25065178e-01f, -1.97283491e-01f, -4.48930971e-02f, 1.07291974e-01f, -4.17863689e-02f,
  8.03674981e-02f, 1.55353844e-01f, 9.61238816e-02f, 7.56741539e-02f, 2.40498688e-02f, 1.78101081e-02f, -7.66513124e-02f, 8.19366276e-02f, 3.96127515e-02f, 6.79594725e-02f,
  4.07871991e-01f, 9.56836119e-02f, 1.17021762e-01f, 1.14663556e-01f, 9.71231014e-02f, 3.80917117e-02f, 1.04889765e-01f, 6.02516532e-02f, 2.06780255e-01f, -4.84287776e-02f,
  3.07715572e-02f, 1.91288739e-01f, 1.07060134e-01f, -3.92976739e-02f, 1.61957145e-01f, -5.08238599e-02f, -2.16999456e-01f, -3.42751741e-02f, 3.25323455e-02f, -4.78620417e-02f,
  3.32582407e-02f, -1.39037296e-01f, -1.34017572e-01f, -1.38039008e-01f, -7.05428272e-02f, -1.81238190e-03f, -8.95962343e-02f, 1.53158493e-02f, -6.31758804e-03f, -5.59364371e-02f,
  4.41510767e-01f, 1.61115214e-01f, 1.20358318e-01f, 5.70140406e-02f, -1.66584224e-01f, -1.95895284e-01f, 8.33390057e-02f, -6.40744939e-02f, -2.33665660e-01f, 8.31356272e-02f,
  -5.45106716e-02f, -1.82448328e-01f, -9.40165669e-02f, -4.29972187e-02f, -9.39452797e-02f, -7.45351315e-02f, -1.15569800e-01f, 8.38916097e-03f, 1.31622925e-01f, -2.99932212e-02f,
  -1.51921883e-01f, 2.42959503e-02f, 2.10220888e-01f, 4.23749425e-02f, 8.15004632e-02f, 2.15250641e-01f, 3.54650505e-02f, 5.56826591e-02f, 2.03724336e-02f, 1.04618795e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.08063960e-01f, 1.46254197e-01f, 4.48091179e-01f, 6.34102225e-01f, 5.80433071e-01f, 6.30964816e-01f, 2.66703516e-01f, 4.27857459e-01f, 3.03176135e-01f, -9.77408215e-02f,
  4.29998100e-01f, 4.05436099e-01f, 4.83508348e-01f, 5.31793296e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.96943700e-01f, -1.03273429e-01f, -9.17920563e-03f, -1.25694618e-01f, 5.86842410e-02f, -2.39876106e-01f, 1.35593072e-01f, 1.52777612e-01f, 1.47941976e-03f, -1.89266168e-02f,
  -9.32995416e-03f, 5.59388362e-02f, -2.60465562e-01f, 9.46503654e-02f, 6.95795864e-02f, 4.05297317e-02f, 1.76216647e-01f, 4.11156006e-02f, 1.46907359e-01f, 4.81467158e-01f,
  5.95447160e-02f, 1.33314654e-01f, -2.11481541e-01f, -4.35157083e-02f, -1.22454949e-01f, -1.94589216e-02f, -4.22615260e-01f, 1.61512122e-01f, 4.62296486e-01f, -8.56691822e-02f,
  -1.11096434e-01f, 2.87023410e-02f, -1.73590124e-01f, 2.98234344e-01f, 1.74879864e-01f, 2.05070138e-01f, -2.92118260e-04f, -4.72903363e-02f, -3.12259197e-01f, 2.29446650e-01f,
  -1.29374668e-01f, -3.49361777e-01f, -3.10762823e-02f, -1.19819961e-01f, 3.08946967e-01f, -1.77111715e-01f, 2.70412236e-01f, 2.25229636e-01f, 3.02149057e-01f, -1.12553723e-01f,
  -1.62320092e-01f, -4.40527022e-01f, -1.58247143e-01f, 2.02888884e-02f, 7.71115581e-03f, 6.84430152e-02f, 1.96501706e-02f, 1.50915429e-01f, 9.10582095e-02f, -1.59521505e-01f,
  -5.21906257e-01f, 1.15282170e-01f, -7.67206773e-02f, 1.88954130e-01f, 5.14488034e-02f, -2.92309433e-01f, 4.43718843e-02f, -1.70204847e-03f, -1.24100417e-01f, 1.98774785e-01f,
  8.41616690e-02f, -2.47151449e-01f, -4.58062766e-03f, 1.45844221e-01f, 2.52713021e-02f, 3.39046746e-01f, 5.24514951e-02f, 1.06355913e-01f, -1.54304817e-01f, -2.06334785e-01f,
  -4.34486508e-01f, -1.43912181e-01f, -1.63578883e-01f, 1.26077816e-01f, 2.03735009e-02f, -1.98591471e-01f, 1.26571596e-01f, 1.62402559e-02f, 1.95470870e-01f, -6.50743023e-02f,
  6.28805012e-02f, 1.27241537e-01f, 5.16113698e-01f, -1.04775749e-01f, 2.43014470e-01f, 1.57569081e-01f, 1.42404847e-02f, -9.76404548e-02f, -1.38334349e-01f, -8.30452964e-02f,
  9.59120989e-02f, -3.99106443e-02f, -4.35482636e-02f, -1.07782960e-01f, 1.20489309e-02f, 5.51524945e-02f, -6.75708577e-02f, 2.05304503e-01f, 1.93037987e-01f, 3.75107899e-02f,
  -1.20710745e-01f, -6.58768117e-02f, -2.91628748e-01f, -1.11683652e-01f, -4.01406288e-01f, 1.97830573e-01f, -2.52598196e-01f, -1.18292617e-02f, 3.35359797e-02f, -7.66711235e-02f,
  1.25029162e-01f, 1.06617630e-01f, 1.58689439e-01f, -1.58289626e-01f, 6.65689766e-01f, -5.59391826e-02f, 3.00266206e-01f, 7.91396275e-02f, -8.89595747e-02f, 6.95373565e-02f,
  -6.99762106e-02f, 9.91391167e-02f, -9.10443068e-02f, 7.72708282e-02f, 1.48715475e-03f, 3.03354189e-02f, 5.63422255e-02f, -2.16472700e-01f, 3.05453371e-02f, 6.97196350e-02f,
  7.45026544e-02f, -1.00176977e-02f, 5.00724167e-02f, 5.38231283e-02f, -4.78650769e-03f, 6.86888769e-02f, 1.17587365e-01f, -2.42189050e-01f, 3.02966446e-01f, 7.65963597e-03f,
  6.50849789e-02f, -3.86672355e-02f, 3.01871095e-02f, -2.42929265e-01f, -9.17774141e-02f, 2.35153735e-01f, -1.71425253e-01f, 1.55447960e-01f, -1.54196247e-01f, 1.38494791e-02f,
  4.03911658e-02f, 1.87335797e-02f, -2.15531066e-02f, -1.02596330e-02f, 1.99704230e-01f, -1.35336265e-01f, 1.92289233e-01f, 8.62636119e-02f, -7.54662382e-04f, -3.39021146e-01f,
  -7.83487633e-02f, -3.24511230e-01f, 1.43584171e-02f, -1.06912434e-01f, 1.04641072e-01f, 6.28943592e-02f, 4.44973618e-01f, -1.50519893e-01f, -2.48565093e-01f, 2.83703744e-01f,
  -5.75361811e-02f, 2.55856127e-01f, -2.97372490e-01f, 1.72896564e-01f, 2.29972750e-01f, 1.93963751e-01f, -2.64429539e-01f, 1.62610844e-01f, -4.78889607e-02f, 9.29847881e-02f,
  5.29182814e-02f, -4.28640358e-02f, 1.06483765e-01f, 3.65825407e-02f, -1.83495626e-01f, -6.18172474e-02f, -1.33124068e-02f, 1.07355013e-01f, 2.34503955e-01f, 3.81688811e-02f,
  1.35909896e-02f, 2.56372755e-03f, -2.37681568e-01f, 3.27343971e-01f, -1.22609936e-01f, 5.43380007e-02f, 1.05316639e-01f, -2.08992511e-01f, 1.14832878e-01f, 1.94055408e-01f,
  1.80094317e-01f, 1.05629794e-01f, 2.72263795e-01f, -3.00615013e-01f, -1.76352561e-01f, -3.97561193e-01f, 2.14005649e-01f, -2.21977189e-01f, -9.83558074e-02f, -1.43882364e-01f,
  2.47670889e-01f, 1.63680196e-01f, 1.09426845e-02f, -8.63890573e-02f, 3.57998163e-02f, 7.17378967e-03f, 5.85901551e-02f, 9.39634070e-03f, 1.65973231e-01f, -1.58949390e-01f,
  7.72964805e-02f, -1.30816177e-01f, 1.43404350e-01f, 8.76232758e-02f, 1.45406485e-01f, -8.01703036e-02f, -7.74941295e-02f, -1.53851941e-01f, -1.78314030e-01f, -1.96507320e-01f,
  -2.49235526e-01f, 2.25918397e-01f, 1.70748994e-01f, 1.10046126e-01f, 3.24104756e-01f, 4.86946590e-02f, 1.70681164e-01f, -2.31010318e-01f, -9.76605788e-02f, 2.46748030e-01f,
  -2.17233241e-01f, 1.44114077e-01f, -1.92272872e-01f, -2.69737422e-01f, 9.39756073e-03f, -1.75665498e-01f, 1.01828925e-01f, 1.02139249e-01f, 2.59941909e-02f, -6.80506751e-02f,
  7.97502920e-02f, 9.48967934e-02f, -1.59388315e-02f, -7.88270012e-02f, 8.90981480e-02f, 2.81109005e-01f, -5.26087843e-02f, -1.04003891e-01f, -3.41384336e-02f, 2.94729006e-02f,
  -2.79610932e-01f, -1.16205223e-01f, -2.11813554e-01f, -1.42805412e-01f, 2.97700375e-01f, 2.00670570e-01f, 1.33922666e-01f, -3.12661856e-01f, -7.43967518e-02f, -1.98582783e-01f,
  -2.54461646e-01f, 5.91013372e-01f, 1.57949492e-01f, -1.63762033e-01f, 1.20490333e-02f, -4.92177866e-02f, -1.86845567e-02f, 2.51520753e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.53207833e-01f, 1.86519116e-01f, 2.60957241e-01f, 5.25907695e-01f, 9.84984562e-02f, 5.55795372e-01f, 1.74825013e-01f, -1.08300582e-01f, -2.98574120e-01f, 3.33459347e-01f,
  1.53121620e-01f, 5.30911088e-01f, 3.37643057e-01f, -2.09901974e-01f, -6.44258633e-02f, -7.10728019e-02f, -3.08139414e-01f, -2.00450212e-01f, -7.79265642e-01f, -2.44306222e-01f,
  -2.70111501e-01f, 1.39820576e-01f, 5.15655935e-01f, -1.85290024e-01f, 4.59585935e-01f, -5.02620876e-01f, 5.31082511e-01f, 2.31870085e-01f, 5.02055705e-01f, 8.38519156e-01f,
  7.21722484e-01f, 1.50513023e-01f, 3.82917017e-01f, 2.81776674e-02f, 4.37805593e-01f, 4.26803082e-01f, 6.55541271e-02f, -1.64319322e-01f, 3.91579181e-01f, 6.52968585e-01f,
  2.29530126e-01f, -2.92234987e-01f, 8.11215490e-02f, -2.11023718e-01f, -3.06976855e-01f, -3.97344828e-01f, 8.41345131e-01f, 3.87399018e-01f, 1.09695411e+00f, 7.58535638e-02f,
  -4.78370786e-02f, -5.78527510e-01f, -3.19877267e-01f, 3.09409797e-01f, -2.97788139e-02f, 6.90920115e-01f, -6.77190199e-02f, 1.53107867e-01f, -5.69664776e-01f, -3.71377379e-01f,
  4.13007766e-01f, -6.49276972e-01f, 7.57301152e-02f, -1.68238238e-01f, 3.32210451e-01f, -2.02731639e-01f, 2.76390433e-01f, 2.02828720e-01f, 1.02451267e-02f, 1.22020515e-02f,
  4.12260920e-01f, 4.93211523e-02f, 1.62644207e-01f, -3.82335633e-02f, 4.17145580e-01f, -4.07146484e-01f, -5.31529039e-02f, -3.92215759e-01f, 6.19610548e-02f, -1.21122248e-01f,
  -2.67805338e-01f, -1.25619397e-01f, 3.55636925e-01f, -2.82963336e-01f, -8.15779492e-02f, 7.59510517e-01f, 1.12968433e+00f, 3.88975829e-01f, -1.71026438e-01f, -6.43856943e-01f,
  4.51171324e-02f, 2.11348295e-01f, -1.30899802e-01f, -2.27736354e-01f, 4.25660983e-02f, 2.08660197e-02f, 1.20451506e-02f, 6.93557337e-02f, -8.42842385e-02f, -1.54887497e-01f,
  -1.38992853e-02f, -8.97449702e-02f, -2.83835024e-01f, 2.83954460e-02f, -6.57117292e-02f, 2.08521798e-01f, 2.12286726e-01f, -3.12958270e-01f, 2.77170330e-01f, -2.76279058e-02f,
  -3.15408140e-01f, 1.30972862e-01f, -2.78073907e-01f, 2.00577043e-02f, 2.77161241e-01f, 4.26737398e-01f, -2.60157257e-01f, -9.18654352e-02f, 4.42644566e-01f, -2.94886589e-01f,
  -1.90508083e-01f, 8.01275194e-01f, 3.31166446e-01f, -1.03881821e-01f, -5.82899272e-01f, 2.52306044e-01f, -7.54606724e-02f, -6.71468675e-02f, 1.90359980e-01f, 5.34744859e-01f,
  1.74502581e-01f, 3.51957887e-01f, 2.45928377e-01f, 1.73148498e-01f, 2.73715347e-01f, 4.17739481e-01f, -4.56133150e-02f, -4.73256223e-03f, 1.64209455e-01f, 6.85962975e-01f,
  -2.67997943e-02f, 1.53384224e-01f, 2.45286196e-01f, -6.78524017e-01f, 1.38372347e-01f, 6.30433500e-01f, 2.11462289e-01f, -2.90442519e-02f, 4.81780827e-01f, 1.13923423e-01f,
  -3.86025868e-02f, -2.88625509e-01f, 3.53685379e-01f, -5.39604366e-01f, -1.75698131e-01f, -3.17887634e-01f, -5.50599582e-03f, 1.80269517e-02f, 9.10531342e-01f, -5.93366742e-04f,
  1.34349287e-01f, -4.68302816e-02f, 8.18517357e-02f, 1.76322818e-01f, -8.90975669e-02f, -1.16782255e-01f, 4.57963735e-01f, 3.64925712e-01f, -4.98276427e-02f, 9.47741792e-02f,
  -4.11099792e-01f, 7.35286117e-01f, -2.24836215e-01f, 3.41723889e-01f, -1.80697113e-01f, -2.47801840e-01f, 3.61462235e-01f, -1.75500602e-01f, -1.68234855e-01f, -1.71541318e-01f,
  -3.80477488e-01f, -2.55890220e-01f, -4.62066457e-02f, 2.55509138e-01f, 4.82179433e-01f, -2.05190033e-01f, 1.44785121e-01f, -1.25317171e-01f, 9.40097690e-01f, 4.39656079e-01f,
  5.78518867e-01f, 6.06983721e-01f, 7.01177642e-02f, 1.70541078e-01f, 2.51835793e-01f, 8.19289759e-02f, 3.44824076e-01f, 2.39517882e-01f, -1.88853040e-01f, 2.97538310e-01f,
  3.47653776e-01f, -4.64624502e-02f, -5.14541328e-01f, -6.23589614e-03f, 5.18915713e-01f, 1.24982171e-01f, 3.09640408e-01f, 6.56730831e-01f, 1.89721391e-01f, -4.20750201e-01f,
  -1.70583442e-01f, -3.52515727e-01f, -3.37565839e-01f, -1.42021244e-02f, -1.14344945e-02f, 3.56806636e-01f, 8.28380883e-01f, 6.62733018e-01f, 5.82038164e-01f, 4.87568341e-02f,
  8.01890016e-01f, 1.96169570e-01f, -8.36225748e-02f, 3.75042826e-01f, 6.09450579e-01f, 2.61021793e-01f, 1.81719720e-01f, 2.00111449e-01f, 1.15925021e-01f, -1.72912762e-01f,
  5.43199182e-01f, 1.72562122e-01f, -2.03695700e-01f, -1.45803228e-01f, 5.25971651e-01f, -1.43909771e-02f, -6.98529005e-01f, 3.08627449e-02f, 1.35851324e-01f, 1.27563640e-01f,
  3.25726956e-01f, -2.41540112e-02f, 5.94052553e-01f, 9.26861167e-02f, -1.20324921e-02f, 4.10236299e-01f, 3.30031008e-01f, 3.92696947e-01f, -1.09785759e+00f, -1.72596529e-01f,
  -1.18790187e-01f, -2.12478101e-01f, -4.29465771e-01f, 2.37471029e-01f, 7.43090570e-01f, 1.23109452e-01f, 2.57664025e-02f, 2.38857821e-01f, 5.27997673e-01f, 6.71405137e-01f,
  -2.19220981e-01f, 5.64102530e-01f, -4.56166863e-01f, -3.23652029e-01f, 2.42489716e-03f, -1.04761250e-01f, 5.95793009e-01f, -8.27906802e-02f, 6.69170737e-01f, -4.32622552e-01f,
  -1.96154951e-03f, 4.00593340e-01f, -3.74183387e-01f, -8.53789747e-01f, -1.50480911e-01f, -8.55547428e-01f, -6.74215734e-01f, 1.39023796e-01f, 6.31459594e-01f, 2.13505164e-01f,
  -1.25429809e-01f, -1.68512627e-01f, 5.57286441e-01f, -1.42866060e-01f, -8.16837966e-01f, 2.59879291e-01f, 3.64710897e-01f, 8.56272429e-02f, 2.10580140e-01f, -1.13214247e-01f,
  -5.94199784e-02f, 1.71651646e-01f, 2.93234080e-01f, 1.04292080e-01f, 3.63416433e-01f, 2.05011874e-01f, 4.07564104e-01f, 5.92197657e-01f, -1.26948938e-01f, -2.56355792e-01f,
  -4.76275325e-01f, 1.08856417e-01f, 7.68670812e-02f, 9.52095911e-02f, -3.84394974e-01f, 1.43349677e-01f, 5.38718760e-01f, 2.50522971e-01f, 2.52917856e-01f, -1.41573220e-01f,
  4.47568856e-02f, 4.58360642e-01f, 2.15917528e-01f, 8.50647449e-01f, -3.00269127e-01f, -2.08190262e-01f, 6.98516607e-01f, -4.75624114e-01f, -4.70058657e-02f, 3.39617096e-02f,
  3.22665304e-01f, -3.50033566e-02f, 1.87779710e-01f, 4.07018065e-01f, 2.82690346e-01f, 9.26327929e-02f, 1.14654817e-01f, 1.56295344e-01f, 1.97169945e-01f, 2.92827308e-01f,
  2.34608740e-01f, -1.66640759e-01f, -3.46402764e-01f, 3.08365561e-02f, -3.20275754e-01f, 2.80906498e-01f, 9.05198324e-03f, -3.24061602e-01f, 3.01979691e-01f, 5.27159989e-01f,
  -3.71363997e-01f, 4.69800979e-01f, 4.34260428e-01f, 7.55470276e-01f, -4.37502831e-01f, 6.01902306e-01f, 1.98769607e-02f, 2.84223467e-01f, -2.12701097e-01f, -4.98731196e-01f,
  4.01672155e-01f, 1.31569400e-01f, 1.24556802e-01f, 1.38118237e-01f, 2.21988425e-01f, -2.27592722e-01f, 5.36102615e-02f, -7.97386318e-02f, -2.33199000e-01f, 4.79506731e-01f,
  -3.88687290e-02f, -6.86400056e-01f, -2.81087104e-02f, 1.89763993e-01f, 3.90420973e-01f, 9.54508260e-02f, 6.22084290e-02f, -1.64480358e-01f, 5.25168180e-01f, 1.78441778e-01f,
  -6.35490417e-02f, -4.40475941e-02f, 1.40061393e-01f, 3.53153765e-01f, 1.91265997e-02f, 1.94572687e-01f, 1.13313282e+00f, -4.54903096e-02f, 4.29048687e-01f, -3.92534882e-01f,
  5.07557392e-01f, 8.81633341e-01f, -7.62534618e-01f, -2.16711551e-01f, 7.07580224e-02f, -2.45352134e-01f, -2.81533927e-01f, 2.19082143e-02f, 2.43570074e-01f, 9.05885175e-02f,
  1.50503099e-01f, -2.00900738e-03f, -1.23631675e-02f, 9.23630297e-02f, 1.49310440e-01f, 2.81799823e-01f, 1.67011872e-01f, -4.33932710e-03f, -2.75152415e-01f, 2.45270073e-01f,
  -5.32288194e-01f, -3.77733618e-01f, 8.55352581e-02f, -2.31301233e-01f, -8.68278649e-03f, 3.01291734e-01f, -4.89847735e-02f, 2.72262573e-01f, 2.28220269e-01f, -9.32865500e-01f,
  -3.27304214e-01f, 7.07299635e-02f, 5.00700831e-01f, -3.33981186e-01f, 1.29654765e-01f, 7.71201134e-01f, 1.31196082e-01f, -5.92318140e-02f, 1.06512509e-01f, -1.12493351e-01f,
  -2.51204036e-02f, -2.44065061e-01f, -1.32663399e-01f, 2.67889202e-01f, -1.52500674e-01f, -3.80581886e-01f, -1.98124871e-01f, -1.15807109e-01f, 3.48353803e-01f, -1.38041556e-01f,
  4.27150726e-01f, 1.93829358e-01f, 6.23413682e-01f, -4.04956192e-02f, 1.46383181e-01f, -4.82421905e-01f, 1.11500442e-01f, 7.93513656e-03f, -7.19735697e-02f, -4.88503138e-04f,
  9.28738654e-01f, -1.21551063e-02f, -2.35038204e-03f, 5.78233749e-02f, 1.32861897e-01f, 7.20819712e-01f, -5.62075138e-01f, 2.85223037e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.53005287e-01f, 3.38436186e-01f, 2.49337047e-01f, -2.33447656e-01f, 4.83250856e-01f, -1.52034312e-01f, 1.47086695e-01f, 4.37021285e-01f, 5.04594684e-01f, 3.72859180e-01f,
  2.31201902e-01f, 1.64672300e-01f, -1.24955187e-02f, 1.80466458e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.30646211e-01f, 1.02489367e-01f, 1.02161858e-02f, -7.99589396e-01f, -1.13943410e+00f, 2.48361483e-01f, -6.98646784e-01f, 2.30200872e-01f, -1.67778477e-01f, -8.43881294e-02f,
  -3.62265706e-02f, -1.00861512e-01f, -5.04780650e-01f, -3.99872869e-01f, -3.54406774e-01f, 6.84928447e-02f, 3.73108596e-01f, -2.84454435e-01f, 9.06813964e-02f, -4.50126648e-01f,
  -2.96868682e-01f, 4.64394212e-01f, -4.09215748e-01f, -7.45428503e-01f, 2.71700263e-01f, -4.87291962e-01f, 2.80069262e-01f, -2.03489348e-01f, 3.61560494e-01f, -1.45744950e-01f,
  -7.41086781e-01f, -6.86488211e-01f, -4.32061665e-02f, -4.26074475e-01f, 5.51300168e-01f, -1.58245564e-01f, -2.03422427e-01f, 6.87488079e-01f, -3.84651646e-02f, -8.76531720e-01f,
  -4.60646003e-01f, 1.90181568e-01f, -2.95003444e-01f, 6.23483777e-01f, 2.45480478e-01f, -9.46981013e-01f, 3.42458069e-01f, -3.76477271e-01f, 3.34265858e-01f, 4.15849239e-01f,
  -4.07018453e-01f, -9.49082434e-01f, 2.82923609e-01f, 3.23911399e-01f, -4.57840174e-01f, -4.73177910e-01f, -6.74268365e-01f, 4.34512168e-01f, -7.80311644e-01f, 2.90179491e-01f,
  4.12513524e-01f, -8.25526297e-01f, 3.09144408e-01f, -1.36086881e-01f, 2.49163002e-01f, 3.24193656e-01f, 7.24656694e-03f, 1.00022733e-01f, -1.97078899e-01f, -1.41800582e-01f,
  8.32351372e-02f, 7.52061009e-02f, -9.93951783e-02f, -2.50685588e-02f, 1.58256054e-01f, -4.99455959e-01f, -6.92489028e-01f, -1.57063752e-01f, 5.87572455e-02f, -3.25635523e-01f,
  -6.72872886e-02f, 8.07323813e-01f, -6.54274523e-01f, 5.83090484e-01f, -7.21848786e-01f, -3.12183410e-01f, -2.99756885e-01f, -3.55272233e-01f, 5.90450227e-01f, -4.09489244e-01f,
  -3.34331572e-01f, 6.81353807e-01f, 4.23866183e-01f, -7.78889954e-01f, -7.02087164e-01f, -3.96460325e-01f, 4.67334270e-01f, 6.51392564e-02f, -5.25582016e-01f, -9.16250408e-01f,
  -1.33971408e-01f, 5.71568012e-02f, 6.38150349e-02f, -8.88592601e-02f, -2.53099412e-01f, -3.40720236e-01f, -2.04487130e-01f, 3.93746823e-01f, -9.43608657e-02f, -4.22676593e-01f,
  1.67373285e-01f, 5.68692386e-01f, -1.49199620e-01f, 2.61401057e-01f, 7.82205090e-02f, -9.04366732e-01f, -1.11260974e+00f, -2.35457525e-01f, -5.58121979e-01f, 6.80066884e-01f,
  4.59453791e-01f, -8.62432063e-01f, -3.97872061e-01f, 1.95454489e-02f, -6.56997621e-01f, 5.65128326e-01f, -1.07058680e+00f, 2.07868233e-01f, -7.86544308e-02f, -4.93698984e-01f,
  4.46497142e-01f, 6.69222891e-01f, 4.02749121e-01f, -1.09974794e-01f, 2.89703440e-02f, 2.61629939e-01f, -2.90260799e-02f, -1.85112372e-01f, 7.56494999e-01f, -9.05413628e-01f,
  9.42242801e-01f, 8.55724439e-02f, -1.31893428e-02f, -4.47753727e-01f, -6.90755427e-01f, 3.61418605e-01f, 1.93270698e-01f, -1.15296292e+00f, -7.10919052e-02f, 2.26293001e-02f,
  -4.93296385e-01f, -2.78311074e-01f, -8.09119791e-02f, 4.01793122e-02f, 3.64379883e-01f, -4.25453365e-01f, -1.53927237e-01f, 3.11558038e-01f, 7.87141621e-02f, 4.84474957e-01f,
  5.22663832e-01f, 3.82999659e-01f, -1.53695866e-01f, 5.25467753e-01f, 4.67327684e-01f, 6.29224330e-02f, 3.83478492e-01f, 6.48240328e-01f, 6.14876986e-01f, -8.08491468e-01f,
  -4.73456353e-01f, 2.60639399e-01f, 7.00431526e-01f, 9.47005674e-02f, -9.83294725e-01f, -4.86765541e-02f, 7.50379503e-01f, 2.18119532e-01f, 6.48051977e-01f, -5.24957716e-01f,
  3.81617129e-01f, -3.04561138e-01f, 1.17284551e-01f, -3.01728576e-01f, -3.82781118e-01f, -2.78563984e-02f, 5.91174006e-01f, -3.50584120e-01f, -7.18060061e-02f, -7.66588628e-01f,
  -3.46911867e-04f, -3.43469739e-01f, -5.21912217e-01f, 2.32075080e-01f, -2.36955121e-01f, -5.86320877e-01f, 1.27723202e-01f, -1.25772625e-01f, 2.56384581e-01f, 2.85756409e-01f,
  5.53988397e-01f, 5.25449276e-01f, -5.85348271e-02f, -5.32183170e-01f, -7.98318535e-02f, 6.08945072e-01f, 3.09762627e-01f, -6.80352032e-01f, 1.05862403e+00f, -9.35801804e-01f,
  -1.60445616e-01f, 4.72621143e-01f, 2.85532117e-01f, -6.22003198e-01f, 2.00223401e-01f, -6.23625875e-01f, -1.10013247e+00f, 2.12278306e-01f, -1.21588969e+00f, -1.35078281e-01f,
  3.02832365e-01f, -1.06733359e-01f, -7.42084920e-01f, -2.90430367e-01f, -4.23098564e-01f, -4.67256159e-01f, -5.08676291e-01f, -3.06548290e-02f, 2.28636675e-02f, -2.42445037e-01f,
  -1.36079550e-01f, -1.88144714e-01f, -4.77955699e-01f, -1.24006778e-01f, -1.95987239e-01f, 2.11759686e-01f, 4.95273769e-01f, -1.30925164e-01f, 4.20915037e-01f, -1.48640424e-01f,
  -1.80967346e-01f, -2.31733456e-01f, 1.15760781e-01f, 3.79323661e-01f, -1.39844805e-01f, -7.30637014e-01f, -4.92365837e-01f, 3.76454771e-01f, 4.90183458e-02f, -8.75832140e-01f,
  -4.66562003e-01f, -9.22268033e-02f, -7.55631849e-02f, 1.26343399e-01f, 3.99428189e-01f, 1.47460312e-01f, 1.45258203e-01f, -3.43600273e-01f, -2.77837127e-01f, 5.57170212e-01f,
  4.56004143e-01f, -1.68543503e-01f, -2.52200246e-01f, -2.12607626e-02f, -3.97773266e-01f, 3.20385188e-01f, -1.74340934e-01f, 6.13260627e-01f, -6.83306515e-01f, 8.10655296e-01f,
  -1.23467982e+00f, 1.06922472e+00f, 8.47787485e-02f, 6.85266852e-01f, -7.64953911e-01f, -4.17371601e-01f, -3.98974985e-01f, -1.31349117e-01f, 7.43567884e-01f, 2.15291753e-01f,
  -3.93798381e-01f, 2.74808526e-01f, -9.54969704e-01f, 4.94901627e-01f, -2.07486391e-01f, -4.24823880e-01f, 4.21480127e-02f, -2.23516926e-01f, 1.42512769e-01f, -2.75184780e-01f,
  3.00965726e-01f, 3.47496510e-01f, 5.73130026e-02f, -1.88384637e-01f, -3.48494858e-01f, -2.25574061e-01f, 4.96001363e-01f, -6.00910902e-01f, 7.32176840e-01f, -2.72321910e-01f,
  -8.85894477e-01f, 4.48362917e-01f, 3.22740704e-01f, 5.72425127e-02f, -1.23231518e+00f, -8.21721077e-01f, -7.78591692e-01f, 3.40481609e-01f, 1.20809644e-01f, -4.76325154e-01f,
  -5.52467823e-01f, -2.63713691e-02f, 1.84923306e-01f, 1.29948080e-01f, 8.25198650e-01f, -2.58347005e-01f, 1.70314774e-01f, -1.32886693e-01f, -2.35365838e-01f, -2.53914446e-01f,
  7.41569325e-02f, -1.94059089e-02f, -3.01405251e-01f, -5.19245207e-01f, 7.29302168e-02f, -2.72526145e-01f, -6.02472052e-02f, 7.73455650e-02f, -2.06093907e-01f, 6.49524868e-01f,
  -2.04227254e-01f, 1.12007752e-01f, 5.98151743e-01f, -5.70170164e-01f, 6.67997539e-01f, 1.53570890e-01f, -5.76561093e-01f, -1.93091527e-01f, 5.02676368e-01f, -3.10971200e-01f,
  -1.33037674e+00f, -5.54056525e-01f, 3.12917471e-01f, 7.41781294e-01f, -3.75885852e-02f, 4.59876031e-01f, -4.12761003e-01f, -7.40899086e-01f, -7.39203990e-02f, -5.16242683e-01f,
  -3.19859773e-01f, -7.27844477e-01f, 2.50633985e-01f, 3.99439424e-01f, 5.97709179e-01f, -8.40965733e-02f, -6.18531287e-01f, 1.66338563e-01f, 4.12719071e-01f, -6.10452630e-02f,
  3.68892521e-01f, 4.35704529e-01f, 5.73477559e-02f, 4.78926562e-02f, -6.98468924e-01f, 1.00739516e-01f, 5.85712075e-01f, 1.53984621e-01f, 7.23073661e-01f, -3.48872066e-01f,
  -3.30347300e-01f, -3.05686742e-01f, -9.85290855e-02f, -7.10778087e-02f, 4.64624792e-01f, -5.38746357e-01f, -4.26710695e-02f, -6.17000639e-01f, -6.44377232e-01f, -1.32007718e-01f,
  -7.50327766e-01f, 8.55250895e-01f, -2.10525036e-01f, 4.75069463e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.38117999e-01f, -1.09923400e-01f, 1.09154038e-01f, -2.11468831e-01f, -6.14189543e-02f, 7.22434372e-02f, 2.26864785e-01f, -2.86465764e-01f, 8.75587091e-02f, 2.14308366e-01f,
  -4.83103096e-02f, 2.88454831e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    