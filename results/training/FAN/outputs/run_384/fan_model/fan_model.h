/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.83484629e-01f, 4.61580642e-02f, -1.55515894e-01f, 2.60635942e-01f, 3.01153570e-01f, -4.80836540e-01f, 1.97843850e-01f, -1.48176877e-02f, 2.61284232e-01f, -1.44985646e-01f,
  2.11355656e-01f, 7.60432780e-02f, 1.07506506e-01f, -4.42873538e-01f, -6.83136433e-02f, -2.30758637e-01f, -3.34040612e-01f, -4.10168543e-02f, 3.50826308e-02f, 1.68620367e-02f,
  2.16339026e-02f, 8.22970942e-02f, -6.52756691e-02f, 1.25024706e-01f, 1.61931906e-02f, 1.22050874e-01f, 2.14512378e-01f, 1.71135351e-01f, -1.59678742e-01f, -6.68320730e-02f,
  -1.36003122e-01f, 1.81905180e-01f, 4.94524911e-02f, -1.21911712e-01f, -2.79834587e-02f, -1.62144471e-02f, 4.10745805e-03f, 2.32077204e-02f, 3.33631262e-02f, -8.28895569e-02f,
  7.23041743e-02f, -1.25431409e-02f, 1.32855494e-02f, 3.12199574e-02f, -6.87368214e-03f, 3.65083292e-02f, -1.44352511e-01f, -1.08936183e-01f, 5.49679138e-02f, -2.49591768e-02f,
  -4.13593799e-02f, -1.63920149e-01f, -1.02888979e-01f, -6.49242625e-02f, 3.31648253e-02f, -4.24152091e-02f, -9.41203982e-02f, -2.69292630e-02f, -2.38974076e-02f, -1.99370459e-02f,
  6.37635067e-02f, 1.73112918e-02f, -2.98380833e-02f, 1.41779976e-02f, -1.19082099e-02f, 6.16675988e-02f, -9.67431813e-03f, 3.39455567e-02f, -2.48377752e-02f, 1.34272233e-01f,
  -1.10900201e-01f, 3.81382182e-02f, 2.94739883e-02f, -3.60672660e-02f, -6.09235540e-02f, 1.00984998e-01f, -2.23142141e-03f, -8.52982921e-04f, -3.24936137e-02f, -6.70703575e-02f,
  1.36687309e-01f, -9.27252099e-02f, 2.26473436e-02f, -6.97871670e-02f, 5.46699204e-02f, -9.68186278e-03f, -6.06501736e-02f, -4.59562009e-03f, -1.81557424e-02f, -1.73230320e-02f,
  -3.13762754e-01f, 2.85174530e-02f, 1.12163723e-01f, 1.18856477e-02f, 5.61044067e-02f, 4.93773110e-02f, 3.32437940e-02f, -2.27345079e-02f, -5.64467236e-02f, 5.39267547e-02f,
  -7.94350728e-02f, -1.59155261e-02f, -9.07423422e-02f, -9.41420067e-03f, -1.63913891e-02f, -6.29848465e-02f, 5.22332639e-02f, 1.07187256e-01f, 1.36600370e-02f, 1.40914321e-02f,
  1.53860018e-01f, 1.09913111e-01f, 5.27645648e-02f, 5.33276983e-02f, -3.03317625e-02f, 1.26378119e-01f, 1.49418369e-01f, 2.33242530e-02f, -6.66943118e-02f, -2.78861988e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.10067427e+00f, 9.13555562e-01f, 4.55183238e-01f, -3.33364233e-02f, -4.62637216e-01f, -1.86396271e-01f, 1.95892885e-01f, 2.89331023e-02f, 3.54324967e-01f, 7.47201502e-01f,
  -2.53035247e-01f, 7.59617329e-01f, 9.24716964e-02f, 5.72643518e-01f, -9.54470277e-01f, 1.73455760e-01f, -1.27176225e-01f, 3.02427679e-01f, -1.20986737e-01f, -8.94891024e-02f,
  -2.32557669e-01f, -2.39756718e-01f, -1.60263419e-01f, 2.87975390e-02f, 4.00977675e-03f, 2.17531070e-01f, -4.28267658e-01f, -3.40628698e-02f, 6.82098791e-02f, -2.34694898e-01f,
  -8.17784727e-01f, 1.49458677e-01f, 3.87343168e-01f, -2.73796283e-02f, -2.57876396e-01f, -2.73678135e-02f, -2.32251510e-01f, 3.84999998e-02f, -3.14087160e-02f, 1.64350674e-01f,
  1.79261323e-02f, 5.67424893e-02f, -6.39660377e-03f, 1.14158422e-01f, 3.34342867e-02f, 1.44049883e-01f, 1.55646190e-01f, -1.69849172e-01f, 3.88305038e-01f, -8.43139216e-02f,
  3.83999318e-01f, 4.85930070e-02f, -1.47517379e-02f, 8.98389742e-02f, -3.32128927e-02f, 1.45521626e-01f, 3.08873109e-03f, -6.51444644e-02f, 1.46366626e-01f, -1.46272168e-01f,
  3.65294963e-02f, 2.03608274e-02f, 7.10053667e-02f, -1.80027410e-01f, 8.96167308e-02f, -3.65742482e-02f, 2.26592749e-01f, -2.05359653e-01f, 1.30368546e-01f, -7.40468651e-02f,
  -2.17376888e-01f, 6.96049780e-02f, -8.31209049e-02f, -4.07744385e-02f, -1.00903027e-01f, 1.36726081e-01f, -7.79415155e-03f, -2.86049508e-02f, -1.62616566e-01f, -1.98330477e-01f,
  5.67435846e-02f, -4.54374366e-02f, 1.27333134e-01f, -2.71133929e-01f, -3.93796563e-02f, -9.55519173e-03f, -1.23713858e-01f, 8.27667862e-02f, -4.64217737e-02f, -3.23420227e-01f,
  -1.18875980e+00f, -7.64811277e-01f, 2.40759831e-02f, 1.19793259e-01f, 1.13070868e-01f, -2.94809649e-03f, -2.98256893e-02f, 8.30802545e-02f, -1.58838615e-01f, -2.21028440e-02f,
  6.15488142e-02f, 6.14675879e-02f, -1.80764645e-01f, -1.75381139e-01f, -8.15227255e-02f, -1.98759511e-01f, -2.06451729e-01f, 5.63271232e-02f, -3.35675657e-01f, -2.10763991e-01f,
  4.98399511e-02f, -1.85168665e-02f, -4.69655544e-03f, -8.98141935e-02f, -1.01066560e-01f, -6.61444366e-02f, -5.10948151e-02f, 2.40641132e-01f, -2.38223284e-01f, 2.61597545e-03f,
  4.70028013e-01f, -5.69516122e-01f, 4.66910273e-01f, 8.54752719e-01f, 2.91402172e-02f, -8.69195223e-01f, -6.96433008e-01f, 1.72511458e-01f, 6.83718324e-01f, -6.75201356e-01f,
  -6.88440129e-02f, -3.79439592e-01f, -5.60333252e-01f, 2.61931300e-01f, 3.99900287e-01f, -1.98318690e-01f, 5.90141773e-01f, -4.65588495e-02f, 4.84245926e-01f, 1.80681497e-01f,
  7.29977906e-01f, 1.96275532e-01f, 3.26900095e-01f, 2.23607108e-01f, 2.65697628e-01f, 3.77744585e-01f, 4.14722115e-01f, -9.75880846e-02f, 1.41330600e-01f, -1.08415343e-01f,
  -4.17392343e-01f, 2.11426705e-01f, 6.46247417e-02f, -2.10914508e-01f, 1.87729403e-01f, -8.37564468e-02f, -2.63552129e-01f, -2.27178067e-01f, -5.26003819e-03f, 1.91101693e-02f,
  -1.72081292e-01f, 1.38918877e-01f, 1.42463163e-01f, 8.06218237e-02f, 2.34871078e-02f, 1.69090107e-01f, 1.96793303e-01f, 5.94515465e-02f, -5.18203480e-03f, -1.73516963e-02f,
  9.33106914e-02f, 6.68479800e-02f, 7.22372830e-02f, -3.81160788e-02f, 9.91269425e-02f, 7.41191730e-02f, 8.65536407e-02f, -5.25797494e-02f, -4.80385823e-03f, 1.79526016e-01f,
  1.29762620e-01f, -1.05410805e-02f, -2.81148180e-02f, 2.27072835e-02f, 4.93981503e-02f, 1.51316017e-01f, 7.71522447e-02f, -2.57194992e-02f, 8.07506591e-02f, -4.81638089e-02f,
  4.54226471e-02f, -1.01685055e-01f, 1.75238580e-01f, 1.75068453e-01f, 4.32307571e-02f, 1.82425097e-01f, -1.65128354e-02f, -3.45825516e-02f, 9.04673338e-02f, -7.58678792e-03f,
  -3.14415582e-02f, -8.18632618e-02f, -5.13847545e-02f, -3.59859988e-02f, -1.04261376e-01f, 3.25322524e-02f, 1.01872437e-01f, 8.16255510e-02f, 1.08581550e-01f, -1.67584494e-02f,
  -8.73756289e-01f, 1.21965438e-01f, -1.61582470e-01f, -2.18275473e-01f, -5.20839281e-02f, -5.72643131e-02f, 1.63665593e-01f, 1.42845809e-01f, -9.80508998e-02f, 9.98498052e-02f,
  -3.56128924e-02f, -4.17834111e-02f, -6.99345246e-02f, 7.30784163e-02f, -4.49052714e-02f, 9.20661092e-02f, 2.29914058e-02f, -5.59270382e-02f, -6.66370317e-02f, 7.92178437e-02f,
  -1.67120975e-02f, -1.49774715e-01f, -1.05059016e-02f, 1.94539666e-01f, -9.19346809e-02f, -1.16946392e-01f, 4.29888181e-02f, 1.59560978e-01f, 4.01890799e-02f, 4.25799415e-02f,
  4.98495162e-01f, -9.74123180e-01f, -3.09702996e-02f, 8.95504832e-01f, 3.17426056e-01f, -1.91282511e-01f, -1.14532083e-01f, 2.33498961e-01f, 1.23941407e-01f, -9.12911475e-01f,
  3.19793150e-02f, -3.33735079e-01f, -5.25675714e-01f, 2.99873173e-01f, 5.61863363e-01f, -5.56602597e-01f, 5.08312941e-01f, -1.61682472e-01f, -3.06629837e-02f, 7.54415616e-02f,
  3.39594722e-01f, 1.47088766e-01f, 2.39206627e-01f, -1.66261375e-01f, 7.36245662e-02f, 4.90613505e-02f, -4.82258424e-02f, -4.12814111e-01f, 2.90107131e-01f, -5.33919185e-02f,
  1.83680981e-01f, 9.14717168e-02f, 5.44614717e-02f, 2.84084398e-02f, 5.83161823e-02f, -7.12243170e-02f, -2.19126604e-02f, -2.98242588e-02f, 4.28516030e-01f, -7.10068345e-02f,
  -9.95372459e-02f, 4.11318503e-02f, 7.18284771e-02f, -1.73248366e-01f, 1.32015094e-01f, -2.55298265e-03f, 7.15232417e-02f, -1.91580318e-02f, 8.97213295e-02f, -1.85420170e-01f,
  -8.19178969e-02f, 1.48065701e-01f, 2.73454577e-01f, -5.81864268e-02f, -2.02072244e-02f, 4.81254905e-02f, -6.17397716e-03f, -9.46712121e-03f, -1.82243611e-03f, -6.06382359e-03f,
  -1.95625067e-01f, 1.80249121e-02f, -2.28211377e-02f, 9.13946107e-02f, 6.84415922e-02f, 1.14137419e-02f, 1.58931792e-01f, -3.20677198e-02f, -7.81943053e-02f, -8.83545876e-02f,
  1.44144550e-01f, 1.34875596e-01f, 5.91892600e-02f, -9.71694440e-02f, 1.14081778e-01f, 6.00777753e-03f, 1.76154897e-02f, -2.28945524e-01f, -4.59023938e-02f, 2.02723801e-01f,
  -1.95245189e-03f, 1.30986214e-01f, -1.41304776e-01f, 7.44584426e-02f, 2.94698495e-02f, -2.66892668e-02f, -6.95409104e-02f, -7.96794966e-02f, 1.40655488e-01f, -5.42887263e-02f,
  -2.54341453e-01f, -1.01133835e+00f, -8.00423473e-02f, 1.42742544e-01f, -2.19457909e-01f, -2.43341133e-01f, -6.98740184e-02f, 1.06147043e-01f, -6.74795806e-02f, -8.73941183e-02f,
  1.12070538e-01f, 7.22894594e-02f, -9.73696932e-02f, 1.37537405e-01f, 2.07769111e-01f, -2.46686384e-01f, -2.02947706e-01f, -9.77480859e-02f, 3.62368737e-04f, -5.70890903e-02f,
  -5.48371971e-02f, -1.14025854e-01f, 8.19891989e-02f, 4.34686877e-02f, -7.72903673e-03f, -1.22655861e-01f, -1.80651307e-01f, -7.86380395e-02f, -8.40944201e-02f, -5.01914807e-02f,
  2.97417432e-01f, -5.67422569e-01f, -3.49226058e-01f, -5.54451823e-01f, -1.67395383e-01f, -5.74537754e-01f, -3.37728828e-01f, -4.92653131e-01f, 5.94544150e-02f, -4.80169833e-01f,
  -4.02184874e-01f, 1.56499267e-01f, 6.04525626e-01f, -6.51051402e-01f, 8.11559260e-01f, 5.40885508e-01f, -7.87674665e-01f, -5.21601558e-01f, 1.81020439e-01f, -5.81042469e-01f,
  -1.87038891e-02f, -5.45529962e-01f, -2.66319633e-01f, -4.99945968e-01f, -5.28230786e-01f, -4.98636961e-01f, -2.44550817e-02f, -4.07043807e-02f, -5.29571176e-01f, -4.60761413e-03f,
  -5.72348721e-02f, 4.07448038e-02f, -9.74796787e-02f, 3.99074182e-02f, -1.90775722e-01f, 3.09232417e-02f, -6.54533952e-02f, 2.30003610e-01f, 3.83628547e-01f, 1.08426578e-01f,
  8.76814947e-02f, 4.68732029e-01f, -2.05753475e-01f, 2.11374611e-01f, -3.76580320e-02f, -6.92230910e-02f, 5.27879633e-02f, -1.05427764e-01f, 7.70766512e-02f, 7.95374885e-02f,
  -1.93974692e-02f, 2.45756097e-02f, -7.18802810e-02f, -3.91994044e-02f, 1.15845285e-01f, -4.95508090e-02f, 8.22502598e-02f, 1.33524388e-01f, 1.63377654e-02f, 9.86953005e-02f,
  -1.83029890e-01f, 1.83317021e-01f, 1.20786846e-01f, -8.87544081e-03f, 2.19582077e-02f, -1.87287703e-01f, 1.42634781e-02f, -1.85638331e-02f, 9.84998494e-02f, -1.54404268e-01f,
  7.01237991e-02f, -1.26810640e-01f, 2.46133193e-01f, -4.84035276e-02f, -3.67813889e-04f, 1.05908982e-01f, 3.10907383e-02f, 1.04500152e-01f, -4.84680235e-02f, 2.20079832e-02f,
  5.41614704e-02f, -1.37173131e-01f, 1.19507298e-01f, 3.89865339e-02f, 2.32192259e-02f, 1.00374371e-01f, 7.38603175e-02f, 1.05298370e-01f, -2.24133372e-01f, 6.46666065e-02f,
  -1.82169914e-01f, -1.96304336e-01f, -1.75353497e-01f, -4.66389284e-02f, -2.59645432e-01f, -2.08945990e-01f, -1.87263295e-01f, -3.15128922e-01f, -1.81383163e-01f, -3.12111005e-02f,
  -1.91460744e-01f, 1.14731461e-01f, -9.83333811e-02f, -2.23244667e-01f, -1.10746086e-01f, -3.74715269e-01f, 2.58024689e-02f, 2.73266695e-02f, -7.19539747e-02f, -1.96420714e-01f,
  -4.63825539e-02f, 3.62674408e-02f, 1.87304631e-01f, -2.41137981e-01f, -8.22100714e-02f, 1.55439544e-02f, 7.43481517e-03f, 9.16720182e-02f, 1.26656532e-01f, 1.88112948e-02f,
  8.72629404e-01f, 9.92078662e-01f, 5.93407631e-01f, 3.98522794e-01f, -4.17724371e-01f, -1.12323344e+00f, -8.64052773e-01f, 1.56938046e-01f, -3.10890675e-01f, 1.47423968e-01f,
  -2.26177663e-01f, 4.75901008e-01f, 2.00615883e-01f, 5.51748395e-01f, -5.71316302e-01f, -1.26045287e-01f, 1.79252967e-01f, 1.37027159e-01f, -1.03702210e-01f, 5.26117980e-01f,
  2.07919762e-01f, -2.26182103e-01f, 4.77997512e-01f, -1.32355228e-01f, 5.42452216e-01f, 5.23312390e-01f, 2.41221473e-01f, -6.27197698e-02f, 4.21319246e-01f, -2.68694937e-01f,
  -1.26374006e-01f, 1.92182139e-01f, 8.34415406e-02f, -6.10632710e-02f, 6.60314113e-02f, 2.51050554e-02f, 1.12369001e-01f, -1.01037823e-01f, -2.43230253e-01f, -6.87402412e-02f,
  1.38939187e-01f, 9.57088470e-02f, -5.64302132e-02f, -1.18592113e-01f, 2.39340052e-01f, 3.87372188e-02f, 1.35667294e-01f, 9.56259668e-02f, 3.13339867e-02f, 3.05176049e-01f,
  2.82077432e-01f, 2.93959886e-01f, 2.09398508e-01f, 2.33906895e-01f, -2.36803927e-02f, 7.01039983e-03f, -2.30639689e-02f, 2.04403535e-01f, 6.55742660e-02f, 1.87443480e-01f,
  1.79338858e-01f, -4.53515165e-02f, 6.42217398e-02f, 2.44995616e-02f, -1.41889498e-01f, -7.78214857e-02f, -1.00210480e-01f, 4.60020937e-02f, -1.08022206e-01f, -6.89503178e-02f,
  -1.84294373e-01f, 7.87388831e-02f, -1.02853648e-01f, -1.46913692e-01f, 6.45355433e-02f, -4.34293523e-02f, -3.50175053e-02f, -1.90442009e-03f, 2.26540416e-02f, 1.11762270e-01f,
  -8.85570124e-02f, -5.55590056e-02f, -8.51225033e-02f, 1.51636571e-01f, -2.26720899e-01f, 5.88940978e-02f, 1.96883440e-01f, 1.25815064e-01f, 3.06319613e-02f, -1.18991874e-01f,
  1.11820385e-01f, 1.04606256e-01f, -1.06647633e-01f, -1.97560653e-01f, -3.57738622e-02f, -4.30011526e-02f, -1.22275516e-01f, 1.78558692e-01f, 1.50067255e-01f, -2.70490319e-01f,
  1.62587225e-01f, -5.34128174e-02f, -1.46347463e-01f, -4.14245483e-03f, -1.01062439e-01f, 7.04732537e-02f, -2.32620426e-02f, -1.72533646e-01f, 1.73177436e-01f, 2.01067969e-01f,
  4.37669083e-02f, -8.01351294e-02f, 6.02190793e-02f, -3.96627247e-01f, 6.58091605e-02f, 7.60713220e-03f, -3.93203311e-02f, -1.08996198e-01f, 2.36802489e-01f, -3.56037766e-02f,
  -1.69733942e-01f, 1.92886554e-02f, 5.44016898e-01f, -2.93090194e-01f, -4.05238241e-01f, 9.29437578e-02f, -1.15294635e-01f, -7.18114898e-02f, 1.19341671e-01f, -3.62855971e-01f,
  -6.92083478e-01f, 1.91568255e-01f, 3.25426072e-01f, -6.51678324e-01f, 1.34451711e+00f, 5.46809077e-01f, -2.11445123e-01f, -1.28137112e-01f, -5.20161651e-02f, -1.04019567e-01f,
  1.36266679e-01f, -6.08138621e-01f, 2.91736037e-01f, -2.52894461e-01f, -6.34653747e-01f, -2.39486530e-01f, 1.26097843e-01f, -1.23132216e-02f, -3.45503956e-01f, -1.27129838e-01f,
  -5.27676880e-01f, -4.78689700e-01f, -2.54157186e-01f, 5.71321584e-02f, -1.26564220e-01f, -7.64730796e-02f, 8.52146745e-02f, -2.26489510e-02f, -9.45586041e-02f, 4.51061763e-02f,
  1.18824273e-01f, 5.58583997e-03f, -1.90286562e-01f, 1.42654240e-01f, -1.23537347e-01f, -8.32364112e-02f, -1.36624381e-01f, -2.45779485e-01f, -1.30352587e-01f, -1.41882300e-01f,
  -8.63322616e-02f, 8.59312434e-03f, -1.66692629e-01f, 1.36713879e-02f, -1.73017047e-02f, -1.62734553e-01f, 1.47834674e-01f, 1.95082486e-01f, -6.29494041e-02f, -3.83444689e-02f,
  1.29351676e-01f, 1.22311361e-01f, -4.16046381e-02f, -4.32733707e-02f, -7.49425218e-02f, -1.60345495e-01f, 5.60969971e-02f, -1.18146919e-01f, 3.88314761e-02f, -1.09045230e-01f,
  -1.99550167e-01f, -2.50979420e-02f, -1.00391835e-01f, -5.91362268e-02f, -7.26677775e-02f, 5.91599792e-02f, 1.52259871e-01f, -1.24451309e-01f, -6.17601024e-03f, -8.68919194e-02f,
  8.08186978e-02f, 9.16971937e-02f, -7.60159940e-02f, -4.15031426e-02f, -2.12739296e-02f, 1.64120406e-01f, -1.41089708e-01f, 9.62102115e-02f, -4.48926762e-02f, 4.98657189e-02f,
  1.15656346e-01f, 5.89242578e-01f, -1.32163897e-01f, -3.06621701e-01f, 9.20564234e-02f, 2.06040759e-02f, 1.78720906e-01f, -6.22020429e-03f, 2.68114716e-01f, 7.96160474e-02f,
  -3.54582518e-02f, -1.47969991e-01f, 9.10522565e-02f, -8.41750577e-03f, 2.77797401e-01f, 4.99028005e-02f, 6.75856322e-02f, 6.91027418e-02f, 3.26496214e-02f, 1.92863643e-02f,
  -1.44696319e-02f, -1.16741270e-01f, 1.68246493e-01f, -1.38385534e-01f, -2.61086673e-01f, -3.86211462e-02f, -3.40782888e-02f, -1.75130188e-01f, 1.27450405e-02f, 7.95733705e-02f,
  8.53194714e-01f, -4.48644757e-01f, -5.04532695e-01f, 1.74312532e-01f, 2.30512530e-01f, 9.63030756e-01f, 8.06589007e-01f, -1.13547914e-01f, 3.49405520e-02f, -1.94338888e-01f,
  3.31801265e-01f, -1.13042690e-01f, -2.83648282e-01f, 8.58542085e-01f, 1.06121671e+00f, 9.76257399e-02f, 7.31535792e-01f, 4.49341178e-01f, -1.71606839e-01f, 2.84367710e-01f,
  2.57316202e-01f, 1.02922165e+00f, -4.08312559e-01f, -2.44064629e-01f, 6.74256504e-01f, -8.27984989e-01f, -4.12529141e-01f, -5.34248471e-01f, -2.76873827e-01f, 3.26297760e-01f,
  1.15286238e-01f, 1.08213804e-03f, -8.89933109e-02f, -1.09085858e-01f, 2.57591112e-03f, 2.40784362e-02f, -4.73022759e-02f, 1.23928972e-01f, -1.59706905e-01f, 7.98109770e-02f,
  6.82544410e-02f, 5.91721050e-02f, 6.89891055e-02f, 4.63826992e-02f, 3.73950869e-01f, -1.73229367e-01f, -4.08768393e-02f, -2.28836879e-01f, -2.64759958e-01f, 1.93620577e-01f,
  1.05970749e-03f, -9.08794105e-02f, 2.29275264e-02f, -1.80148929e-01f, -1.15198277e-01f, -1.67950559e-02f, -1.24489032e-01f, -2.55536765e-01f, 2.27703266e-02f, 2.31545031e-01f,
  9.53836888e-02f, 1.53092757e-01f, 1.49665743e-01f, 3.41361575e-02f, 1.81674197e-01f, -8.91899243e-02f, 1.94753081e-01f, -6.60418421e-02f, -1.25088274e-01f, -2.06994507e-02f,
  -1.52819872e-01f, 7.99682811e-02f, 7.96158388e-02f, 2.67644059e-02f, 1.97530940e-01f, 7.71573856e-02f, -9.25235264e-03f, -1.21154450e-01f, -4.30339128e-02f, -4.86035943e-02f,
  -1.22883901e-01f, 8.17458630e-02f, 2.29557371e-03f, -3.59615535e-02f, -4.13529724e-02f, -3.85327754e-03f, 1.58426836e-01f, 6.72635213e-02f, -1.74986407e-01f, 3.03902701e-02f,
  -1.37397453e-01f, -1.35521397e-01f, -1.76562712e-01f, -1.33867130e-01f, -1.43562883e-01f, 1.81969270e-01f, 7.32142255e-02f, 1.01694211e-01f, -3.73155586e-02f, 2.48087898e-01f,
  1.24673424e-02f, -1.23771615e-01f, -2.36049220e-01f, 1.69074330e-02f, -2.56146580e-01f, 2.08634496e-01f, -5.11487722e-02f, -1.30105212e-01f, -6.85344338e-02f, -2.57779866e-01f,
  -1.24327853e-01f, 3.70422266e-02f, 8.15416351e-02f, -1.24868862e-02f, -1.21592782e-01f, 3.01307533e-02f, 2.15280391e-02f, -5.11318147e-02f, -5.51000573e-02f, -2.56070495e-01f,
  8.37585032e-01f, 3.50766718e-01f, 5.81672013e-01f, 8.00013840e-01f, -2.19592601e-02f, 2.89505601e-01f, 6.61267519e-01f, 3.21960747e-01f, 1.21817827e+00f, -1.35821715e-01f,
  -6.39132619e-01f, 3.01982611e-01f, -3.15997511e-01f, -1.72331780e-01f, -3.60474348e-01f, -2.81868428e-01f, 3.19528937e-01f, 2.60919658e-03f, 6.43098772e-01f, 2.29492739e-01f,
  2.68688649e-01f, -8.81659865e-01f, -4.47745800e-01f, -5.84727168e-01f, -8.43117535e-02f, 3.38005066e-01f, -1.12906575e+00f, -1.11620491e-02f, -6.75360560e-01f, -6.69985116e-02f,
  -3.81689593e-02f, 2.85476804e-01f, -6.07681423e-02f, 1.45205557e-01f, 1.53712526e-01f, 6.68548197e-02f, 4.20794860e-02f, -7.90229812e-02f, 2.86147654e-01f, 1.17107011e-01f,
  -4.73737018e-03f, -2.44787056e-02f, 1.60757929e-01f, -1.53765634e-01f, 2.49391675e-01f, 4.89649475e-02f, 4.55366112e-02f, 2.82842070e-01f, 4.21291664e-02f, -6.47546127e-02f,
  1.05644360e-01f, 1.10042103e-01f, 1.39647350e-01f, 2.68487073e-02f, 1.78026017e-02f, 2.40087137e-01f, 2.55882770e-01f, -8.56440738e-02f, 6.39291257e-02f, 2.91850746e-01f,
  -1.17907591e-01f, 1.49584070e-01f, -3.36929015e-03f, 2.69373860e-02f, -8.44754130e-02f, 4.52506505e-02f, -2.88798232e-02f, -1.60289258e-01f, 1.24185294e-01f, -1.27983645e-01f,
  1.69416249e-01f, 9.01623741e-02f, 2.25531440e-02f, 2.34335333e-01f, -1.36448666e-02f, 7.89784640e-02f, -2.25487530e-01f, -1.47247277e-02f, 2.92091936e-01f, -4.83555607e-02f,
  -8.61587822e-02f, 1.40680745e-01f, -9.50900540e-02f, -1.75111648e-02f, -5.78739718e-02f, -4.46312735e-03f, 3.17855589e-02f, 2.53557619e-02f, -8.21012855e-02f, -1.15159832e-01f,
  -4.43263650e-02f, 1.04242019e-01f, -8.65925662e-03f, -7.40723461e-02f, -1.64592609e-01f, -2.13532642e-01f, -5.38261496e-02f, 5.96262477e-02f, 1.07675776e-01f, -3.51220779e-02f,
  2.18421705e-02f, 6.97534084e-02f, -9.13843587e-02f, -1.18527822e-01f, -2.68770587e-02f, -1.15229249e-01f, 2.81650852e-02f, 9.83792841e-02f, 1.43329337e-01f, -8.72333497e-02f,
  -2.36533239e-01f, 9.15423408e-02f, 1.22592263e-01f, 5.67462705e-02f, 8.31542015e-02f, -1.63284138e-01f, -5.89381717e-03f, 7.98410252e-02f, -9.13585499e-02f, 7.08455145e-02f,
  9.83436257e-02f, -8.31342101e-01f, -8.24912190e-01f, -3.91294867e-01f, 6.09277785e-01f, 6.35124087e-01f, -2.68004894e-01f, -3.06772441e-02f, -8.09320211e-01f, 3.41102540e-01f,
  2.50306249e-01f, -4.72198725e-01f, -6.82438970e-01f, -4.09907758e-01f, -1.69698089e-01f, -8.69929969e-01f, 3.60033959e-01f, 1.02633700e-01f, -3.66314292e-01f, 2.34462887e-01f,
  -9.39754844e-02f, 2.68561125e-01f, -5.63320696e-01f, 4.04780626e-01f, 4.53452796e-01f, 3.55067760e-01f, 8.79713774e-01f, 3.75143327e-02f, 7.55067825e-01f, 2.67302748e-02f,
  -1.80995569e-01f, -2.90084630e-01f, -1.50304139e-01f, -1.34186059e-01f, 2.32990712e-01f, 4.16092545e-01f, 2.44215503e-01f, 3.88623821e-03f, -7.79955611e-02f, -7.32204318e-02f,
  1.19755931e-01f, 4.11000066e-02f, 1.65497214e-02f, -1.94487184e-01f, 1.08199410e-01f, 5.56946397e-02f, -1.55867100e-01f, 7.82234594e-02f, -1.87962934e-01f, -2.76827216e-01f,
  -2.01233476e-01f, 3.59633081e-02f, 5.46885990e-02f, 6.09161984e-03f, -1.94854558e-01f, -4.89255823e-02f, 8.18371996e-02f, 1.38072982e-01f, 3.67942750e-01f, -1.25645250e-01f,
  2.14526907e-01f, 1.88094258e-01f, 3.65466475e-02f, -1.42909333e-01f, -1.26135886e-01f, 6.57792538e-02f, 2.52161715e-02f, 2.98687350e-02f, -9.89913493e-02f, -3.56231444e-02f,
  8.76709670e-02f, -6.73951060e-02f, -5.47058843e-02f, 1.13579899e-01f, 1.13678135e-01f, -6.97557162e-03f, 1.41044602e-01f, 3.53799686e-02f, 6.12553135e-02f, -1.14769474e-01f,
  -2.88793184e-02f, 1.50708869e-01f, 6.42682798e-03f, 7.41073787e-02f, -3.80211435e-02f, -7.74843320e-02f, 7.36603513e-02f, 3.66947427e-02f, -1.76784769e-01f, 2.63758749e-02f,
  1.74933579e-02f, 2.16790363e-01f, -1.74848527e-01f, -7.75047094e-02f, -3.43977958e-02f, 2.75539935e-01f, -5.73906489e-02f, -1.14793323e-01f, 1.43559603e-02f, 3.96288745e-02f,
  3.65558535e-01f, 2.36085594e-01f, 4.17321324e-01f, -7.41293654e-02f, 3.23905014e-02f, 1.31217659e-01f, 2.85807371e-01f, 1.85913682e-01f, 3.24462891e-01f, 2.12740064e-01f,
  2.19057307e-01f, 3.45182866e-01f, 9.96418372e-02f, 1.06934242e-01f, 1.09941810e-01f, 2.94951014e-02f, 1.31551042e-01f, -8.63719508e-02f, 1.25285670e-01f, 8.77826512e-02f,
  -1.25956059e+00f, -5.23597300e-02f, 1.05497265e+00f, -5.62592685e-01f, -9.91640240e-03f, 8.90834570e-01f, 7.04280436e-01f, -9.49064270e-03f, -5.43575644e-01f, -7.08069354e-02f,
  2.44997237e-02f, -3.90356869e-01f, 4.77198631e-01f, 3.68796468e-01f, 6.24207377e-01f, 3.74095798e-01f, 4.31903005e-01f, 1.19348742e-01f, -9.96305197e-02f, -3.21082741e-01f,
  2.07373383e-03f, -1.27852663e-01f, 7.93888986e-01f, -3.73278320e-01f, 2.51190186e-01f, -3.89208436e-01f, -1.54851496e-01f, 6.45575747e-02f, -6.53080270e-02f, 1.48548037e-01f,
  -2.16316283e-01f, -3.55376542e-01f, -1.05919749e-01f, 1.10826246e-01f, 6.03026040e-02f, 9.71603170e-02f, 1.19702548e-01f, 2.01106966e-01f, -1.57879233e-01f, -8.72068852e-02f,
  -1.36224270e-01f, 6.29733950e-02f, -2.06908941e-01f, -9.70264524e-02f, -1.49843127e-01f, -5.04639409e-02f, 1.85549766e-01f, 2.35164419e-01f, 7.93898702e-02f, 3.75227094e-01f,
  3.59996945e-01f, 1.24236397e-01f, 1.85103998e-01f, 9.90544260e-03f, 1.10515140e-01f, 7.41895735e-02f, 1.60680860e-01f, 8.85094330e-02f, 4.33171121e-03f, 8.86798557e-03f,
  -4.22243774e-02f, 8.02510008e-02f, 1.03988059e-01f, -6.18822351e-02f, -9.38780233e-02f, 3.13129760e-02f, -1.40086904e-01f, 2.98267771e-02f, -1.16948396e-01f, -2.41190717e-02f,
  -1.86538771e-02f, -1.07882082e-01f, -7.29707852e-02f, 5.38143776e-02f, -1.33471236e-01f, 8.77684169e-03f, 4.43883538e-02f, -1.73725381e-01f, 9.59101766e-02f, 1.45047724e-01f,
  2.50547975e-02f, 7.68825784e-02f, -3.09890248e-02f, 1.14984270e-02f, -9.47258156e-03f, -6.27741367e-02f, -8.20812955e-02f, 1.93735734e-01f, -1.03533857e-01f, -5.43228500e-02f,
  -4.07072246e-01f, -6.14984572e-01f, -2.43685707e-01f, -2.41589546e-01f, -1.68604970e-01f, -1.31835025e-02f, -4.71652076e-02f, -5.92942461e-02f, -2.20375583e-01f, -1.49296433e-01f,
  -6.14419170e-02f, -2.23132391e-02f, -7.28958920e-02f, -2.50761751e-02f, -2.41453946e-02f, 9.40194651e-02f, -8.86288881e-02f, -2.03699470e-01f, -1.28109455e-01f, -1.37903959e-01f,
  -1.70710847e-01f, -6.79897219e-02f, 1.72150917e-02f, -2.01975122e-01f, -2.19665766e-02f, -8.76955539e-02f, -3.58226985e-01f, -5.58259115e-02f, -5.27393557e-02f, 1.29394680e-01f,
  -4.78156477e-01f, 7.14145064e-01f, -5.59174716e-01f, 7.89338231e-01f, -5.55154920e-01f, 5.67769229e-01f, 7.40893900e-01f, -5.95178567e-02f, 2.82151192e-01f, 7.34004676e-01f,
  3.73021960e-01f, 1.74051970e-01f, 3.13767910e-01f, 1.22036564e+00f, 3.30981940e-01f, 8.24892402e-01f, 1.21138155e+00f, 7.36883879e-01f, 5.24431653e-02f, 3.68032902e-01f,
  6.94480762e-02f, 1.01841176e+00f, 1.25489859e-02f, 4.21669669e-02f, -3.14243644e-01f, -4.60963368e-01f, 1.28183320e-01f, -6.60581291e-01f, 3.12024057e-01f, 1.23606965e-01f,
  1.99403659e-01f, -4.62091230e-02f, -2.18052462e-01f, 4.50645462e-02f, 7.67513588e-02f, -1.09911978e-01f, -1.51368706e-02f, -1.98216572e-01f, -1.56404093e-01f, 6.71334192e-02f,
  7.07786679e-02f, -2.07156409e-02f, 3.13780099e-01f, -1.25732839e-01f, -3.41082841e-01f, -1.75455034e-01f, -9.84272510e-02f, -1.97318330e-01f, 9.95592251e-02f, -2.06453621e-01f,
  -1.45894587e-01f, -4.00956944e-02f, -1.12846419e-01f, 2.65820384e-01f, -1.22211076e-01f, 1.76217426e-02f, 1.69955328e-01f, -1.68908566e-01f, 1.09534323e-01f, 2.41397414e-02f,
  4.05143537e-02f, 2.18856126e-01f, -7.80264959e-02f, -9.13445577e-02f, -6.03289902e-02f, -7.74700344e-02f, 1.40169337e-01f, 4.81350487e-03f, -7.79359490e-02f, 1.40400544e-01f,
  3.15322983e-03f, -1.95504829e-01f, 2.80856583e-02f, -2.59949919e-02f, 2.73619257e-02f, -5.26509471e-02f, -1.49732560e-01f, 3.71764712e-02f, 7.99308643e-02f, -2.25301683e-01f,
  1.61397651e-01f, 1.66795120e-01f, -9.44288075e-02f, 3.84296589e-02f, 2.11590320e-01f, -2.41984501e-01f, 1.51316598e-01f, -1.44870952e-01f, -6.19737022e-02f, -1.19040059e-02f,
  5.12776732e-01f, 7.70334244e-01f, 3.28424573e-02f, 1.25462800e-01f, 1.28626749e-01f, -1.42348334e-01f, 1.76609829e-01f, -2.22557550e-03f, 9.46004912e-02f, 8.69397819e-02f,
  -4.13059369e-02f, 3.42388004e-02f, -5.42169213e-02f, -5.74809909e-02f, 1.21930562e-01f, 1.06859982e-01f, 2.30572060e-01f, 4.31239121e-02f, 1.97119117e-01f, -6.63822442e-02f,
  6.05507102e-03f, 7.18965987e-03f, 1.32255077e-01f, -8.14763159e-02f, 1.33371159e-01f, 1.60479434e-02f, -1.76006481e-01f, -1.16736777e-01f, -2.67384462e-02f, 2.16020465e-01f,
  -5.47070742e-01f, 3.25903356e-01f, 1.89369068e-01f, 9.18876827e-02f, 3.49494219e-02f, 3.79885346e-01f, -4.37549561e-01f, -1.90442055e-02f, -6.98402822e-01f, -7.43718863e-01f,
  -3.01944435e-01f, 3.07475269e-01f, -6.36139154e-01f, 6.79381490e-01f, 7.61908948e-01f, -1.66593641e-01f, 4.65708226e-01f, 1.90031901e-01f, 2.43938595e-01f, 4.21362489e-01f,
  2.99996078e-01f, 4.51016575e-01f, 5.81620872e-01f, 6.64091766e-01f, 4.50662792e-01f, 4.08177733e-01f, -8.52024704e-02f, 5.39839327e-01f, 7.26922989e-01f, 5.94802916e-01f,
  -1.20380828e-02f, -3.81295979e-01f, -5.27363941e-02f, 1.27562523e-01f, -3.03125173e-01f, -2.28449523e-01f, -1.75412744e-02f, 2.85959363e-01f, 9.42498893e-02f, 7.79948384e-02f,
  -1.86440796e-01f, 1.59139380e-01f, 3.00763845e-01f, 7.12698400e-02f, -8.22056830e-02f, 1.17388375e-01f, 2.14378208e-01f, 4.83525619e-02f, 3.42917666e-02f, -3.17029431e-02f,
  1.27652377e-01f, 1.55749023e-01f, -2.84553282e-02f, 1.62237212e-01f, 2.10012764e-01f, -6.94742100e-03f, 6.49703667e-02f, -2.14408487e-02f, 2.58760870e-01f, 6.39593527e-02f,
  -1.33516416e-01f, -9.82036740e-02f, -4.55369428e-02f, -1.25473961e-01f, 4.39253300e-02f, -2.02650234e-01f, 2.75557349e-03f, -4.39151265e-02f, 1.02873489e-01f, -1.03362454e-02f,
  -2.09183563e-02f, 6.59675449e-02f, -1.22020006e-01f, -1.72186438e-02f, -1.41436562e-01f, -2.19680026e-01f, -3.58986259e-02f, 1.14900485e-01f, -1.00889817e-01f, -4.05475646e-02f,
  -1.95931867e-01f, 1.65991291e-01f, 3.06471232e-02f, -1.80868059e-01f, -8.38597789e-02f, -1.42937019e-01f, 7.41266971e-03f, -1.11325234e-01f, 8.18888936e-03f, 1.06496669e-01f,
  -3.61595079e-02f, 8.78170729e-02f, 9.62673128e-02f, 1.64403707e-01f, 6.90141693e-02f, 7.68315569e-02f, 1.39509395e-01f, 1.73427850e-01f, -1.05480932e-01f, -6.89583197e-02f,
  -3.07491332e-01f, 2.48793401e-02f, -2.06961676e-01f, -1.48423880e-01f, 1.95450485e-01f, -2.39653081e-01f, -1.14348337e-01f, -2.08712637e-01f, 3.76438610e-02f, 9.40633938e-02f,
  -4.00266387e-02f, -1.42853469e-01f, 8.83836448e-02f, 3.56467441e-02f, -1.19067676e-01f, -2.27123141e-01f, -2.19524950e-01f, 1.81188643e-01f, 1.27119929e-01f, 1.22591004e-01f,
  -1.91558018e-01f, -6.80041134e-01f, 2.20781177e-01f, 2.25667596e-01f, -1.46178246e-01f, -2.47083083e-01f, 8.65651429e-01f, -7.79011846e-01f, -6.08631730e-01f, -3.61564338e-01f,
  2.39748284e-01f, 2.35875785e-01f, 6.66024208e-01f, 4.94914129e-03f, 6.06151164e-01f, 4.46754992e-01f, 8.39870796e-03f, 1.95534036e-01f, -1.50457509e-02f, -1.71162367e-01f,
  -9.37601626e-02f, -2.43031010e-01f, 3.53693932e-01f, -7.83050358e-01f, -1.18397102e-01f, -2.62459755e-01f, 2.21439719e-01f, 3.38594824e-01f, -2.31143683e-01f, 2.72299498e-01f,
  -2.48855695e-01f, -5.49239993e-01f, 7.03803971e-02f, -2.14104995e-01f, -1.52645350e-01f, 1.09750368e-01f, 2.01806858e-01f, 4.14266378e-01f, 2.32151195e-01f, -1.59567192e-01f,
  1.24451451e-01f, -1.54267237e-01f, -1.16686977e-01f, 9.63008255e-02f, -1.72564566e-01f, -2.67628372e-01f, -1.14460416e-01f, 7.41759762e-02f, -1.44479513e-01f, -1.41656213e-02f,
  -3.46690044e-03f, -9.18636844e-02f, 7.98754320e-02f, 1.47915721e-01f, -1.77625529e-02f, -1.15593486e-01f, 1.71403602e-01f, 2.81956792e-01f, -6.08553700e-02f, -1.00016445e-01f,
  -2.77239978e-01f, -1.38351852e-02f, -9.90698859e-02f, -2.68152636e-02f, 5.70363738e-02f, -2.79305945e-03f, 5.90499006e-02f, 1.43109903e-01f, 2.60295924e-02f, -7.00282678e-02f,
  3.85758691e-02f, -4.29201797e-02f, -1.61805421e-01f, -4.22615372e-02f, 3.79790440e-02f, -6.68405965e-02f, 1.62151471e-01f, 8.80636275e-02f, -3.23135182e-02f, -3.90866436e-02f,
  4.19058427e-02f, 1.30770877e-01f, -1.85308363e-02f, 9.00900289e-02f, -5.74160963e-02f, 1.87176540e-01f, -9.44884270e-02f, -7.18297288e-02f, 4.04284783e-02f, 1.70771167e-01f,
  -3.53705823e-01f, -8.19969416e-01f, -4.33787964e-02f, -1.08741090e-01f, 1.66652709e-01f, -8.81807059e-02f, -2.98563000e-02f, -2.50600874e-01f, -1.36474207e-01f, -7.58586153e-02f,
  -4.71927263e-02f, 2.29045510e-01f, -1.88355684e-01f, 3.81360538e-02f, -5.86185977e-02f, -2.52660699e-02f, 1.99713498e-01f, 5.29403239e-02f, 6.86224550e-02f, -2.35945940e-01f,
  -4.60605100e-02f, 4.27075624e-02f, 8.84011984e-02f, -1.07909031e-01f, -9.89282206e-02f, 9.36574489e-02f, -2.72290200e-01f, -3.14807519e-02f, 1.60433322e-01f, 1.10722911e-02f,
  -1.62442207e+00f, 5.77385366e-01f, -4.31178629e-01f, -9.24969018e-01f, 1.15606740e-01f, -1.05472609e-01f, -4.39527750e-01f, 1.90944389e-01f, -5.67211509e-01f, 4.36863959e-01f,
  1.47703022e-01f, -8.22548687e-01f, 6.75033808e-01f, -2.63611048e-01f, -9.07709301e-01f, 2.66645968e-01f, -4.30073112e-01f, -4.45378244e-01f, 1.39253765e-01f, -2.08792925e-01f,
  -4.09038216e-01f, 8.11486766e-02f, -1.81867823e-01f, 8.76550913e-01f, -4.23054665e-01f, -7.92015269e-02f, 1.32782012e-01f, 6.25967741e-01f, -4.24887270e-01f, 7.47675821e-02f,
  -3.47579271e-01f, -1.23668484e-01f, -2.48008907e-01f, -2.11350415e-02f, -1.16767399e-01f, 1.42545514e-02f, -8.34021568e-02f, 2.64503006e-02f, -3.51354517e-02f, -4.92596291e-02f,
  -1.79004855e-02f, -3.09581831e-02f, -9.97239202e-02f, 1.02793470e-01f, 4.58161645e-02f, 1.36621177e-01f, -7.25532025e-02f, -4.50988710e-02f, -3.52242850e-02f, 2.33748276e-02f,
  -1.16073422e-01f, -1.03858334e-03f, -1.10178262e-01f, -2.78905295e-02f, -1.62315831e-01f, 4.64930525e-03f, -2.21782789e-01f, -1.94146000e-02f, -9.17324200e-02f, 2.37349723e-03f,
  1.73027024e-01f, 7.81351328e-02f, 2.23141760e-02f, 1.79201186e-01f, -3.71177979e-02f, -3.51885892e-02f, 1.01336844e-01f, 9.16316211e-02f, -9.35276374e-02f, 2.09783670e-02f,
  -1.08620591e-01f, -1.72958687e-01f, 4.86629605e-02f, -2.85210013e-02f, -2.68879682e-01f, -2.49351576e-01f, -8.19201618e-02f, -3.67029123e-02f, -1.46350160e-01f, -2.17549689e-02f,
  2.74244733e-02f, -2.07815040e-02f, 2.77238898e-02f, 3.33218239e-02f, 9.12516862e-02f, -1.85134111e-03f, 1.36102930e-01f, 5.41044213e-02f, 1.92124471e-01f, -4.27216738e-02f,
  -4.20627415e-01f, -2.26310432e-01f, -9.96787772e-02f, 8.11061040e-02f, 3.74781080e-02f, 3.50982957e-02f, 9.86924767e-02f, -8.38195384e-02f, 6.79870993e-02f, 5.25219925e-02f,
  -2.62366626e-02f, -1.38754159e-01f, -1.03451930e-01f, -1.27288908e-01f, -4.00651284e-02f, -3.39667127e-02f, -1.66494608e-01f, -1.58368096e-01f, -7.49396533e-02f, 7.23297941e-04f,
  -5.02738655e-02f, -2.13056765e-02f, -2.52526160e-02f, 2.51155179e-02f, -9.62665230e-02f, -6.35347813e-02f, -1.39529556e-01f, 4.88047265e-02f, 1.24891602e-01f, 5.96938618e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.22892427e-01f, 2.08707958e-01f, 1.99194506e-01f, 4.49113250e-01f, 6.96330726e-01f, 1.17002976e+00f, 1.28295183e+00f, 9.71663713e-01f, 9.35721219e-01f, 6.48162663e-01f,
  7.87952065e-01f, 6.00224733e-01f, 5.06837428e-01f, 1.17468154e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -7.73410201e-01f, -1.14088662e-01f, 5.05853117e-01f, -1.28860995e-01f, -1.08510725e-01f, -1.34704673e+00f, -1.33914709e-01f, -1.19297886e+00f, -3.70281965e-01f, -1.54471672e+00f,
  -7.10031629e-01f, 5.69791675e-01f, 1.11992121e+00f, -1.40407896e+00f, 3.71596277e-01f, 1.35018289e-01f, 5.09592414e-01f, -3.97258520e-01f, -1.32722747e+00f, -1.36261117e+00f,
  -6.09639645e-01f, -1.09961107e-01f, 2.13261724e-01f, -1.69743502e+00f, 1.33946538e+00f, -1.45247424e+00f, 4.53636438e-01f, -5.40141106e-01f, 6.84966326e-01f, -7.52385259e-02f,
  -8.22121024e-01f, -9.71311092e-01f, -4.38076466e-01f, 3.18072408e-01f, -7.98569918e-01f, 4.52664942e-01f, 1.01239085e+00f, -1.05872881e+00f, -1.11826289e+00f, -7.69417763e-01f,
  1.00165844e-01f, -1.56444752e+00f, 5.27605295e-01f, -7.34760404e-01f, -2.03822091e-01f, 7.14694798e-01f, -4.65630554e-03f, -1.05996358e+00f, -8.73960972e-01f, 1.53979647e+00f,
  8.87318134e-01f, -8.63788009e-01f, -3.87273043e-01f, 2.08016366e-01f, 1.12891339e-01f, -1.33665824e+00f, -4.55102980e-01f, -3.92333895e-01f, -1.07647038e+00f, -1.35785651e+00f,
  -9.25044954e-01f, -9.93889689e-01f, -3.56593877e-01f, 1.15301728e+00f, -2.02439621e-01f, -2.10700345e+00f, 1.44370526e-01f, -1.06985793e-01f, -1.02811420e+00f, 1.48796320e-01f,
  -9.31863844e-01f, 3.47193927e-01f, -1.10348499e+00f, -8.31655320e-03f, -6.83460355e-01f, 1.14775348e+00f, -1.44693804e+00f, 8.13857317e-01f, -6.33226931e-01f, 3.71907681e-01f,
  3.32198024e-01f, -3.41522336e-01f, -1.55247673e-02f, -2.93826669e-01f, -1.70998681e+00f, -7.01489151e-01f, -5.62619150e-01f, 8.34886730e-01f, 1.30935222e-01f, 9.97679591e-01f,
  -7.17000008e-01f, -5.34971833e-01f, 5.94600558e-01f, 1.57143489e-01f, -6.49794817e-01f, -8.77218127e-01f, -2.91335553e-01f, 8.19505870e-01f, -6.35828853e-01f, 1.14283085e+00f,
  1.02362764e+00f, -5.89653969e-01f, -7.83026755e-01f, -8.93366098e-01f, 5.26446998e-01f, 8.63160908e-01f, -6.22735083e-01f, -2.28264943e-01f, -1.23375583e+00f, -1.05877829e+00f,
  -2.76721776e-01f, -5.57006836e-01f, -8.98684487e-02f, 1.91064820e-01f, -8.62324119e-01f, 3.73299748e-01f, -6.73437893e-01f, 7.43381858e-01f, -2.08799601e-01f, 1.13124657e+00f,
  -9.33697820e-01f, -3.18803102e-01f, -8.72323364e-02f, -9.21674550e-01f, -4.41775918e-01f, -5.85310578e-01f, 7.98811764e-02f, 2.16441840e-01f, -4.70927626e-01f, 7.28321731e-01f,
  -1.08715999e+00f, 7.42848396e-01f, -8.45297202e-02f, -1.29947340e+00f, 1.03330457e+00f, 4.95257586e-01f, -8.87855351e-01f, -7.28812814e-01f, -2.47488394e-01f, -7.09520638e-01f,
  3.45378011e-01f, 4.51095939e-01f, -4.98765230e-01f, -8.94238949e-01f, 3.25341552e-01f, 6.99503958e-01f, -1.01425254e+00f, -9.26029027e-01f, 4.95188721e-02f, 6.20967411e-02f,
  -9.91832554e-01f, 6.08444333e-01f, 2.11653918e-01f, -5.63804269e-01f, -3.82739961e-01f, 6.96714699e-01f, -1.39554071e+00f, 1.77566744e-02f, 1.31254387e+00f, -1.60562813e+00f,
  6.56424582e-01f, 6.88253045e-01f, -1.26307201e+00f, -7.51941860e-01f, -6.20823681e-01f, -1.24630976e+00f, -1.40907139e-01f, -2.44532347e-01f, -1.00502324e+00f, -5.71528554e-01f,
  1.52369261e+00f, -8.66667390e-01f, -3.77148420e-01f, -7.45539367e-01f, -5.95019519e-01f, 5.57803571e-01f, 4.44264859e-01f, -6.05123527e-02f, 1.11034834e+00f, -7.18219340e-01f,
  -3.10239613e-01f, -1.25200593e+00f, 1.06790996e+00f, -5.57966232e-01f, -7.42945492e-01f, 8.72114360e-01f, -4.84316736e-01f, -6.56734943e-01f, -1.29442048e+00f, 1.11679636e-01f,
  -3.09115648e-01f, -1.19029319e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.81168747e-01f, -1.84566423e-01f, -4.75185096e-01f, 6.64999187e-01f, 9.79914308e-01f, -1.45149752e-01f, -9.11728144e-02f, -1.02611423e+00f, -3.09368461e-01f, -3.96166474e-01f,
  6.27379179e-01f, 3.01824100e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    