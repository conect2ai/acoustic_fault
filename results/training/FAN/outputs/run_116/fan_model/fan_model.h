/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.51408359e-02f, 2.80347973e-01f, 2.42659435e-01f, 1.68352142e-01f, -2.81503022e-01f, -7.51236081e-02f, 5.05863167e-02f, 5.34363352e-02f, 8.92003626e-02f, 6.85280636e-02f,
  -1.24058500e-01f, 1.11552499e-01f, 1.08847626e-01f, 2.47411802e-01f, -1.41157016e-01f, 1.11571662e-01f, 1.27831697e-01f, 1.04935862e-01f, 7.34826997e-02f, 5.05902171e-02f,
  -3.80072519e-02f, -6.88830242e-02f, 1.51452839e-01f, 1.37966778e-03f, 5.87502196e-02f, 1.70542896e-02f, -1.26356080e-01f, -4.97645931e-03f, -6.78701103e-02f, -1.51641279e-01f,
  -8.53003338e-02f, 1.52444944e-01f, 2.40501296e-03f, 9.06751901e-02f, -1.07365198e-01f, -9.53873619e-02f, 6.90375641e-02f, 3.27448025e-02f, -3.47855389e-02f, -8.21435675e-02f,
  -1.57434661e-02f, -4.90528196e-02f, -2.32384801e-02f, 1.22294135e-01f, 1.15716523e-02f, 7.01660141e-02f, -2.25760136e-02f, 1.55255780e-01f, 1.38705149e-01f, -6.00116886e-03f,
  1.00692116e-01f, 4.25535925e-02f, 5.47532998e-02f, 3.89243057e-03f, 3.92694324e-02f, -4.37078848e-02f, -7.18699303e-03f, -2.85163615e-02f, -4.58080396e-02f, -1.14606675e-02f,
  7.77546912e-02f, -3.29311453e-02f, 4.16165926e-02f, -1.24445055e-02f, -2.12933905e-02f, -1.49998903e-01f, 8.87030140e-02f, -5.91296069e-02f, -7.47465193e-02f, -8.90838355e-02f,
  -6.14908524e-02f, 5.02558751e-03f, -7.73070827e-02f, 9.08890888e-02f, 5.54750999e-03f, 2.49701235e-02f, -7.15334415e-02f, 3.87676544e-02f, 6.33197427e-02f, -1.50403790e-02f,
  4.29884195e-02f, -1.58174522e-02f, -5.71141504e-02f, -6.07408285e-02f, -6.71199858e-02f, 5.73530234e-02f, 1.12163924e-01f, 1.28384948e-01f, 1.56935286e-02f, -8.53645522e-03f,
  -1.58738300e-01f, -9.74773243e-02f, -3.53421271e-02f, -7.62382671e-02f, 5.98910451e-02f, -1.89013295e-02f, 5.99789582e-02f, 6.47598729e-02f, 5.58686778e-02f, -1.09843217e-01f,
  -8.24993551e-02f, -8.96951854e-02f, -6.04939200e-02f, 5.25095093e-04f, -1.75118577e-02f, -5.97555526e-02f, -5.29810674e-02f, 7.06616193e-02f, -1.08055964e-01f, -5.05818101e-03f,
  1.11645445e-01f, 1.05782030e-02f, -1.00316100e-01f, -1.61651019e-02f, 5.53071275e-02f, -9.24697220e-02f, -6.29055267e-03f, -2.34339070e-02f, -1.23554967e-01f, -1.95343196e-02f,
  -2.30060592e-01f, 2.58818716e-02f, -1.24145217e-01f, 1.88428778e-02f, -7.56886899e-02f, -2.85491288e-01f, -4.24501598e-02f, 1.99363351e-01f, 1.20783493e-01f, 1.55668810e-01f,
  2.19075635e-01f, -6.33790642e-02f, 2.21930191e-01f, 3.25756595e-02f, -1.76491767e-01f, 1.02781400e-01f, -8.48036408e-02f, -6.24529757e-02f, 3.56482193e-02f, 4.17585038e-02f,
  -8.41785688e-03f, 7.47206807e-02f, -5.10828383e-02f, 1.22273318e-01f, -1.10690072e-01f, 1.71873569e-02f, 1.95191830e-01f, 5.06435782e-02f, -6.74257353e-02f, 5.78259379e-02f,
  -1.50375292e-01f, 8.45847055e-02f, -1.69894472e-01f, -1.25801489e-01f, -1.25987753e-01f, -1.72987252e-01f, -9.78175998e-02f, -5.34068979e-02f, -6.75372034e-02f, -4.03754530e-04f,
  -1.40086800e-01f, -1.48451284e-01f, 1.14969634e-01f, -8.02544598e-03f, -7.04747289e-02f, -1.07900769e-01f, -1.09506091e-02f, -5.89702986e-02f, 2.17576139e-02f, -1.44737791e-02f,
  -3.61102298e-02f, -7.76910707e-02f, 4.06503230e-02f, 3.42258066e-02f, -2.48188078e-02f, 7.17059001e-02f, 5.00156917e-02f, -6.50124764e-03f, -6.72152564e-02f, -8.76110569e-02f,
  5.64549826e-02f, -8.42417404e-02f, -5.30061759e-02f, -1.01570934e-02f, 3.39885009e-03f, -1.37882279e-02f, -1.77952088e-02f, -1.53456975e-04f, -1.16285257e-01f, -2.43377406e-02f,
  -2.20390987e-02f, -5.99266291e-02f, 1.11650452e-01f, -1.07376650e-01f, -1.04616120e-01f, 6.03760630e-02f, -6.26677051e-02f, -8.08889121e-02f, -6.90291673e-02f, 1.55429877e-02f,
  1.01129105e-02f, -6.34220317e-02f, 4.85236309e-02f, 3.72030139e-02f, 9.40274168e-03f, -1.03530861e-01f, -4.66265045e-02f, -1.05345115e-01f, 1.74223647e-01f, -1.16658725e-01f,
  8.27456564e-02f, 1.94636300e-01f, 7.74648190e-02f, -2.49675605e-02f, 4.67885938e-03f, -6.58228025e-02f, -3.67818177e-02f, -1.20642008e-02f, -7.30873719e-02f, 8.99386927e-02f,
  -6.74946830e-02f, 1.91056821e-03f, -6.14325143e-02f, -1.35489581e-02f, -2.34810114e-02f, 1.09683111e-01f, 7.90120140e-02f, 2.31464840e-02f, 4.07162830e-02f, 1.14300236e-01f,
  7.08658770e-02f, 6.17793612e-02f, -5.49072847e-02f, 3.51143489e-03f, 9.54100713e-02f, 9.76893231e-02f, 2.26947647e-02f, -1.38706528e-02f, -1.44145966e-01f, -1.25214860e-01f,
  -5.03981471e-01f, -2.29099616e-02f, -4.15990353e-02f, -3.02020550e-01f, -1.21559769e-01f, 3.47080082e-02f, 1.86832145e-01f, -1.39767900e-01f, -1.44450486e-01f, 1.23726405e-01f,
  2.75523774e-03f, -1.40508771e-01f, 2.55638987e-01f, -3.30161631e-01f, -1.92165986e-01f, 1.89781249e-01f, -2.49235794e-01f, -1.18153363e-01f, -9.43652540e-02f, -1.27251267e-01f,
  -1.30755574e-01f, -1.28840744e-01f, -8.68121758e-02f, -1.08760059e-01f, -1.07408427e-01f, 3.84209678e-02f, 1.94935147e-02f, 7.80314207e-02f, -1.41705751e-01f, -3.57018709e-02f,
  -1.54586788e-02f, 3.45244929e-02f, -8.09733942e-02f, 3.65875810e-02f, -2.64919829e-02f, -4.06726040e-02f, 9.59233101e-03f, 2.85451319e-02f, -4.55604345e-02f, -9.34157707e-03f,
  -1.51065190e-03f, -2.61971094e-02f, 2.53090058e-02f, -2.66682561e-02f, -1.06668524e-01f, -9.07163098e-02f, -3.94348912e-02f, -4.51021008e-02f, 2.80678272e-03f, -1.38494782e-02f,
  -5.82629703e-02f, -6.77617937e-02f, -4.57933210e-02f, -2.87528392e-02f, 2.19001099e-02f, -4.17665439e-03f, 1.21154428e-01f, 1.27164617e-01f, 9.36979149e-03f, -4.01541442e-02f,
  -2.21796166e-02f, -5.61658926e-02f, -8.70651603e-02f, -1.00996234e-01f, -1.15208598e-02f, -2.30490398e-02f, -6.37152642e-02f, 1.58579499e-02f, -8.69375281e-03f, -9.15138945e-02f,
  -9.41949636e-02f, -7.21686482e-02f, -2.77711842e-02f, -6.08847477e-02f, -6.76837340e-02f, -6.10973015e-02f, -4.73799407e-02f, 3.20703238e-02f, -1.56107862e-02f, 5.88688953e-03f,
  -3.95994708e-02f, -1.13013806e-02f, 1.02287278e-01f, 9.82950106e-02f, 4.02287580e-03f, -3.63643765e-02f, -7.24325851e-02f, -2.21502408e-02f, 7.18091354e-02f, 2.11466886e-02f,
  7.33598042e-03f, -1.85694937e-02f, 7.61657581e-02f, -1.94885433e-02f, 3.61013152e-02f, -8.23104605e-02f, -3.39638665e-02f, -8.20378512e-02f, 1.39938225e-03f, -2.43362579e-02f,
  -1.11015297e-01f, 7.59538785e-02f, 3.11204102e-02f, -2.23087259e-02f, 6.01874590e-02f, 7.12859035e-02f, 9.63205770e-02f, -5.43322526e-02f, 1.07770059e-02f, -5.92068098e-02f,
  -3.67858782e-02f, 6.44928962e-02f, -4.36150767e-02f, 2.57805455e-02f, 1.33156599e-02f, 5.23420535e-02f, 5.72132990e-02f, 4.25227694e-02f, 1.99950431e-02f, 5.62131070e-02f,
  3.08543921e-01f, 1.59725230e-02f, -2.98416317e-01f, 9.02871862e-02f, 2.52282083e-01f, -1.85532868e-01f, -2.00985044e-01f, 2.81720966e-01f, 2.31593698e-01f, 1.33341039e-02f,
  2.91428603e-02f, -1.26388699e-01f, -1.27037078e-01f, 7.21379742e-02f, 8.29736367e-02f, -1.62781939e-01f, 1.43739041e-02f, -4.14433666e-02f, -7.09049702e-02f, 9.12559628e-02f,
  -3.52266468e-02f, 6.39074966e-02f, -9.81660262e-02f, 1.53549105e-01f, 1.26095012e-01f, 2.85768528e-02f, 1.08614467e-01f, -1.01180300e-01f, 6.84222355e-02f, 1.61200687e-02f,
  5.93572520e-02f, 5.31458706e-02f, -6.86473623e-02f, -5.46757206e-02f, -5.91055155e-02f, -1.32090554e-01f, -1.63382828e-01f, -1.86092347e-01f, -9.95904207e-02f, -1.02463946e-01f,
  -1.14418954e-01f, 5.39222993e-02f, 5.34894764e-02f, 4.36139703e-02f, 1.35215417e-01f, -1.17819652e-01f, -5.84734082e-02f, -3.30256559e-02f, 6.31488278e-04f, 9.66671854e-02f,
  -2.36010086e-02f, -4.04837392e-02f, -1.25542423e-02f, 3.46204117e-02f, 1.41125927e-02f, 3.34991626e-02f, -6.05844893e-02f, -3.79912034e-02f, -3.33844684e-02f, -8.69645849e-02f,
  8.60548168e-02f, -4.66553457e-02f, -5.23369983e-02f, -3.99638899e-02f, -2.22904496e-02f, 3.57920080e-02f, 1.08330548e-02f, -1.07376374e-01f, -1.13986149e-01f, -7.38457665e-02f,
  -7.55704045e-02f, 6.26013801e-02f, 2.06686556e-02f, -5.84236532e-02f, -1.26379998e-02f, 3.69679555e-02f, -1.34098172e-01f, 6.66556880e-05f, -8.40886831e-02f, 7.61470874e-04f,
  -5.94792031e-02f, -3.36467586e-02f, -3.30497995e-02f, 1.11229539e-01f, 3.86368819e-02f, 7.90521130e-02f, 6.81220135e-03f, -6.31606877e-02f, -2.46049161e-03f, -9.22895223e-02f,
  8.08915496e-02f, 1.08248249e-01f, 2.51331218e-02f, -1.55892279e-02f, -8.04489553e-02f, -1.31747708e-01f, -1.19473755e-01f, -5.15919663e-02f, -1.24164931e-01f, -3.65502425e-02f,
  -8.32776502e-02f, 7.46601075e-02f, 1.09339081e-01f, 6.90576807e-02f, 2.89603733e-02f, 2.07093563e-02f, 1.48516297e-02f, -6.91202059e-02f, 1.05499970e-02f, 9.01390612e-02f,
  2.36205216e-02f, 7.55374283e-02f, -1.08408920e-01f, 3.39540653e-02f, 7.77394176e-02f, 7.96346460e-03f, 2.08477005e-01f, -7.12163374e-02f, -1.14025258e-01f, -1.18325159e-01f,
  -3.72703820e-01f, 2.26252794e-01f, 3.73357022e-03f, -1.81819037e-01f, -1.51118949e-01f, -1.21419756e-02f, -1.18387379e-01f, -1.72407329e-01f, -1.54433474e-01f, 6.69761971e-02f,
  -1.84497088e-01f, -8.71303380e-02f, 2.29539052e-02f, 7.67475292e-02f, -2.56651521e-01f, 1.68077514e-01f, -1.26890451e-01f, 3.86791155e-02f, 4.61951345e-02f, -7.59112909e-02f,
  -1.99535757e-01f, 6.49357066e-02f, -1.50469512e-01f, 5.53029999e-02f, -2.08771378e-01f, -1.23293713e-01f, -1.22987829e-01f, -5.63814938e-02f, -1.21038899e-01f, -2.82986816e-02f,
  -5.94394170e-02f, -1.87395379e-01f, 2.24114079e-02f, 4.89333924e-03f, 4.30856720e-02f, -1.37332128e-02f, 9.17984918e-02f, 1.06028892e-01f, -1.10053487e-01f, 4.67356406e-02f,
  1.12843670e-01f, 1.61119774e-02f, 3.16575468e-02f, -2.47827061e-02f, -2.05980726e-02f, 9.61410534e-03f, -2.11258829e-02f, -8.02478492e-02f, 1.83748230e-02f, -5.25389463e-02f,
  -1.44047737e-01f, -1.37763843e-03f, -1.67659204e-02f, -5.00395969e-02f, -7.48531148e-02f, 4.96002808e-02f, 5.22860810e-02f, 7.71192163e-02f, -6.17389344e-02f, 1.76117923e-02f,
  -1.37647629e-01f, 1.28152817e-01f, 1.38424948e-01f, 2.65419297e-03f, 1.66385114e-01f, 6.21831007e-02f, 7.29618445e-02f, 8.59721079e-02f, 1.19108431e-01f, 9.18199793e-02f,
  6.93651438e-02f, 1.58587024e-02f, 3.54508311e-02f, 5.50210141e-02f, 2.72936448e-02f, 1.41627425e-02f, 6.96376413e-02f, -8.34002122e-02f, 4.54537310e-02f, 1.13036141e-01f,
  7.69893304e-02f, 8.10035393e-02f, 3.54194678e-02f, -1.80312749e-02f, 5.65151758e-02f, -9.13942233e-02f, 3.18824798e-02f, -9.63150640e-04f, -5.15717827e-02f, 1.33292712e-02f,
  1.43944994e-02f, -2.39823058e-01f, 5.97185129e-03f, 2.26500165e-02f, 1.35035574e-01f, 9.72321257e-02f, 1.34074941e-01f, 2.03280076e-01f, -3.28396522e-02f, -5.45615405e-02f,
  4.57501821e-02f, 3.95391621e-02f, -1.79847945e-02f, 7.79832825e-02f, 3.60164195e-02f, -7.40062725e-03f, -9.26171839e-02f, -2.70180069e-02f, -1.08648278e-01f, 1.67997312e-02f,
  -1.20064840e-01f, 1.43629441e-04f, 7.39641935e-02f, 1.20746158e-01f, -3.85492072e-02f, -1.32861480e-01f, -1.34154499e-01f, 2.26740129e-02f, 5.92685565e-02f, 9.56209823e-02f,
  -2.03446463e-01f, -3.09466869e-01f, -3.41286920e-02f, -1.75753921e-01f, 6.88414276e-02f, 1.60993800e-01f, -2.25503862e-01f, -1.44211993e-01f, -1.01357825e-01f, -1.75920263e-01f,
  3.87645178e-02f, -1.37612939e-01f, 8.50429237e-02f, -6.99296966e-02f, 2.22970098e-01f, 2.59496301e-01f, -5.94687574e-02f, -1.18890330e-01f, 4.52274196e-02f, -2.20181227e-01f,
  1.35591924e-01f, -4.19269316e-03f, 9.46807861e-02f, -1.96269322e-02f, -6.20706789e-02f, -6.14228062e-02f, -6.34113178e-02f, -4.16148640e-02f, -1.22351060e-02f, 2.28676517e-02f,
  3.19260452e-03f, -2.03626201e-01f, 2.94929966e-02f, 4.02920321e-02f, -1.36405155e-02f, 7.17554912e-02f, 1.90140028e-02f, 1.26536489e-01f, 6.87643141e-02f, -1.30489953e-02f,
  1.51654705e-01f, 1.20474838e-01f, -5.40456921e-02f, 1.36818215e-01f, -2.59072948e-02f, -1.23217842e-02f, 4.32174057e-02f, 1.06167771e-01f, -1.98744368e-02f, -1.70763470e-02f,
  2.07029916e-02f, 1.34583309e-01f, -1.06086470e-02f, 7.65230954e-02f, 1.07507311e-01f, -8.94298777e-02f, -5.71793178e-03f, -9.47541930e-03f, -1.22142090e-02f, -6.95253089e-02f,
  2.86708195e-02f, -4.51857895e-02f, -8.28514397e-02f, -4.12268611e-03f, -8.58449042e-02f, 2.49676090e-02f, 2.72491332e-02f, 8.57062452e-03f, 5.26791215e-02f, -9.46323294e-03f,
  2.60387696e-02f, -5.38187809e-02f, -2.70728804e-02f, 1.08132310e-01f, 4.11734655e-02f, -1.44626677e-01f, 1.12339146e-01f, 8.03986043e-02f, 5.10894023e-02f, 1.89101417e-02f,
  -4.90431562e-02f, -3.28338519e-02f, -1.39362752e-01f, 2.05380414e-02f, -1.26768097e-01f, 6.59906641e-02f, 3.19202468e-02f, -2.77474001e-02f, -8.51468071e-02f, 2.16043685e-02f,
  -2.72234995e-02f, -3.01686466e-01f, 2.68826745e-02f, -4.15658280e-02f, -5.74970804e-03f, 7.32951388e-02f, 1.95176285e-02f, 1.24000490e-01f, -2.73710825e-02f, -4.29842621e-02f,
  1.30582809e-01f, -1.41713265e-02f, -5.69195524e-02f, 1.07224748e-01f, 1.76194273e-02f, -1.19928472e-01f, -6.02184050e-02f, 1.24070130e-01f, 3.38732521e-03f, -6.12010546e-02f,
  -9.23878630e-04f, -5.10593019e-02f, 8.88302401e-02f, -4.04334404e-02f, 7.01817796e-02f, -7.30503574e-02f, -1.24800846e-01f, 5.79148903e-03f, 1.54202864e-01f, 9.56476480e-02f,
  1.28154345e-02f, -2.75866032e-01f, 2.36789227e-01f, 1.57446377e-02f, -1.26854241e-01f, 6.30634055e-02f, 2.91592240e-01f, -4.98727225e-02f, 1.56571358e-01f, -1.82227954e-01f,
  4.95977439e-02f, -1.93610013e-01f, 2.77325392e-01f, -2.47160196e-01f, 3.63698751e-01f, 2.09283277e-01f, -1.18699580e-01f, -1.44603044e-01f, -8.62633064e-02f, -1.35793746e-01f,
  -1.69397984e-02f, -2.64290422e-01f, 1.13016248e-01f, -2.03800008e-01f, -1.57608256e-01f, 1.43758226e-02f, -3.33511457e-02f, 3.85130383e-02f, -2.19449118e-01f, -1.05866417e-01f,
  -5.91855943e-02f, -3.48255411e-02f, 3.06540243e-02f, 9.56868976e-02f, 6.14464320e-02f, 9.77949426e-03f, -3.24111134e-02f, 2.07840670e-02f, 8.13982189e-02f, 2.51411577e-04f,
  -2.82089822e-02f, 4.73712618e-03f, -9.22651514e-02f, -1.38320163e-01f, -7.95917884e-02f, 1.36144906e-02f, 1.94236115e-02f, -4.18305658e-02f, -4.12278734e-02f, -4.47454937e-02f,
  -6.67130202e-03f, -9.87637192e-02f, 6.83099553e-02f, -1.58302002e-02f, 4.64830585e-02f, 7.08996058e-02f, -5.70659041e-02f, 1.70029923e-02f, -8.02345276e-02f, -4.04617265e-02f,
  1.70643441e-02f, 4.22353595e-02f, 7.64227659e-02f, -3.54562048e-03f, -2.93669309e-02f, 4.69757728e-02f, -3.16491574e-02f, -2.87055802e-02f, -1.23049961e-02f, -3.80090177e-02f,
  1.68729424e-02f, -2.11054273e-03f, -1.97777022e-02f, -5.72793297e-02f, -3.35397311e-02f, -3.82486060e-02f, 5.46603650e-02f, -8.56267586e-02f, -3.64151187e-02f, 8.08248967e-02f,
  3.31418104e-02f, 8.09005871e-02f, 1.60955474e-01f, 4.25530113e-02f, 1.47839561e-01f, 5.33136018e-02f, -7.75525570e-02f, -1.06224911e-02f, 5.44852428e-02f, 2.35132538e-02f,
  -1.72027219e-02f, 1.42017892e-02f, 1.25432730e-01f, -1.93620250e-02f, -4.64670099e-02f, -8.02118517e-03f, -3.66373137e-02f, -6.78453073e-02f, -3.59119126e-03f, 1.16637260e-01f,
  -7.23761022e-02f, 6.83802739e-02f, -2.98964791e-02f, -1.25581682e-01f, 1.41264983e-02f, 6.68939948e-02f, 8.07443187e-02f, -8.60551223e-02f, -2.23899679e-03f, -5.31758703e-02f,
  -3.83036025e-02f, 1.16486549e-02f, 6.45028874e-02f, 1.09552750e-02f, -7.50587881e-02f, -2.27731261e-02f, -1.07605807e-01f, -9.54126343e-02f, 3.23150270e-02f, -6.19979315e-02f,
  1.56100571e-01f, 1.77491054e-01f, -9.47368145e-03f, 7.47849569e-02f, -7.84184858e-02f, 1.19245991e-01f, 1.08855993e-01f, 6.44320995e-02f, -3.21464613e-02f, 9.89644974e-02f,
  4.50654477e-02f, 1.29723586e-02f, -5.21780597e-03f, 2.13830352e-01f, 1.11425206e-01f, 1.24491826e-01f, 2.47305796e-01f, 9.85639840e-02f, -9.29714590e-02f, 8.92650187e-02f,
  -3.38840820e-02f, 6.49548247e-02f, 9.67514962e-02f, -1.34217218e-01f, -3.32846795e-03f, -1.52939484e-01f, -1.56240433e-01f, -2.62402952e-01f, -1.47425970e-02f, -8.46514478e-02f,
  1.39976010e-01f, 3.83374058e-02f, 1.94894820e-02f, -1.30828926e-02f, 1.17772311e-01f, 2.14797519e-02f, 2.39448254e-05f, 4.59310925e-03f, -6.97014257e-02f, 3.46438140e-02f,
  2.29848474e-02f, -2.68508811e-02f, -6.59430996e-02f, -7.86821023e-02f, 2.93344329e-03f, -2.27496009e-02f, 5.90354092e-02f, -7.66912624e-02f, 2.55611539e-02f, 5.33055030e-02f,
  2.94534839e-04f, -2.77150385e-02f, -3.63570750e-02f, 3.92995998e-02f, -7.86180198e-02f, 2.27643922e-02f, -3.89006473e-02f, -6.06240816e-02f, -6.26846701e-02f, 8.47631767e-02f,
  3.85158248e-02f, -1.29832506e-01f, -1.07407995e-01f, -9.38257352e-02f, 3.18818982e-03f, -2.09816024e-02f, -7.62656480e-02f, -5.91372401e-02f, -7.61425644e-02f, 2.75194272e-02f,
  -3.27024274e-02f, 3.83615345e-02f, -1.28049865e-01f, -1.29046172e-01f, -4.41402681e-02f, -7.94589743e-02f, -3.97019312e-02f, 7.99476728e-03f, -1.31706282e-01f, -4.50368114e-02f,
  -1.43849235e-02f, 4.67262752e-02f, 8.56776815e-03f, 7.21813813e-02f, 4.98438999e-02f, -1.14983149e-01f, -1.00032454e-02f, -2.75300071e-02f, 3.97991613e-02f, -9.97597817e-04f,
  2.64661878e-01f, 1.66882738e-01f, -5.79471420e-03f, -2.05005538e-02f, 7.00397044e-02f, 3.54924094e-04f, -6.19413070e-02f, -1.26308426e-02f, 7.49958977e-02f, 5.28436117e-02f,
  -1.37154246e-02f, -4.41674627e-02f, -1.24630518e-01f, -4.95443270e-02f, 5.00664040e-02f, 4.67418097e-02f, 4.28888425e-02f, -7.27722719e-02f, 3.52089107e-02f, 4.58504185e-02f,
  -5.03435656e-02f, -2.33292263e-02f, -4.70942631e-02f, 4.31779288e-02f, 2.31756177e-02f, -5.87463640e-02f, -4.36219871e-02f, -8.98921862e-02f, -4.91182581e-02f, 1.53218815e-02f,
  2.94443130e-01f, -1.16164856e-01f, 2.77205080e-01f, 2.72805780e-01f, 2.02482082e-02f, -2.34500915e-01f, 2.22105920e-01f, -4.86557512e-03f, 2.77328491e-01f, -2.04744115e-01f,
  -1.90532893e-01f, 1.75753534e-01f, 8.63088071e-02f, -2.60044068e-01f, 2.43222162e-01f, 3.94135825e-02f, -5.52061535e-02f, 4.10423912e-02f, 9.46985260e-02f, -5.97816296e-02f,
  -5.22375330e-02f, -2.65547812e-01f, 8.17001890e-03f, -2.59673029e-01f, -1.31661832e-01f, 1.02983460e-01f, -8.26022122e-03f, 1.02699585e-01f, -2.65213102e-01f, -4.42859419e-02f,
  -1.30196631e-01f, 1.96684338e-02f, -9.15540010e-03f, -6.45366833e-02f, -6.64474294e-02f, -2.73043979e-02f, -1.49795145e-03f, 2.03739442e-02f, 2.90148538e-02f, 3.53730172e-02f,
  1.31600387e-02f, 4.02842648e-02f, -1.89322576e-01f, -7.06292912e-02f, 1.08889773e-01f, -1.04562091e-02f, 3.21447253e-02f, -6.30013868e-02f, 7.47825429e-02f, -1.42021989e-02f,
  -1.64926276e-02f, -1.23344645e-01f, 3.34380083e-02f, -1.92447621e-02f, 6.77735731e-02f, 3.55008580e-02f, -1.01756910e-02f, -4.13859561e-02f, -1.94675773e-02f, 7.13261217e-02f,
  2.52390746e-03f, -5.94621943e-03f, 5.37391603e-02f, -2.21423153e-02f, -5.80270775e-02f, -4.67197821e-02f, -5.40395640e-02f, -3.30797210e-02f, 6.19663522e-02f, -7.81148225e-02f,
  -2.43504290e-02f, 4.64407168e-02f, -8.48676935e-02f, -8.21029395e-02f, 8.46075118e-02f, -6.82582259e-02f, -1.05944148e-03f, -3.69287096e-02f, 1.62359476e-02f, 4.61405562e-03f,
  6.79177642e-02f, 1.56719740e-02f, -5.70130162e-02f, 2.16231029e-02f, -1.71540156e-02f, 4.69097309e-02f, -2.84606777e-03f, -1.21858008e-02f, -1.72856078e-02f, 4.35589850e-02f,
  9.63394269e-02f, 1.46075472e-01f, -6.09693900e-02f, -6.53127581e-02f, 5.09038344e-02f, -8.80228430e-02f, 7.63167888e-02f, 6.24654181e-02f, 1.43383339e-01f, 1.72710735e-02f,
  -6.63152114e-02f, -4.68183868e-03f, -3.22492160e-02f, -2.80511868e-03f, 5.49219176e-02f, 5.04017323e-02f, 5.71076535e-02f, -1.29016512e-03f, 4.24923301e-02f, -8.06916207e-02f,
  -1.73232406e-01f, -5.47909690e-03f, 9.69019160e-02f, 2.14901306e-02f, -1.23396941e-01f, 6.26890212e-02f, -1.63707463e-03f, -3.05860527e-02f, 1.98853742e-02f, 4.56912816e-02f,
  -1.86941534e-01f, 2.10933149e-01f, -1.41046032e-01f, 1.86702516e-02f, -3.05754691e-01f, -1.87715858e-01f, -1.97430719e-02f, -7.17623010e-02f, 1.83658183e-01f, 1.22166812e-01f,
  -1.47891222e-02f, 1.44689485e-01f, 7.71371648e-02f, 8.50992054e-02f, -1.60425037e-01f, 2.07130700e-01f, 5.00777736e-02f, 3.01177874e-02f, 9.69571546e-02f, -1.99676342e-02f,
  8.16970412e-03f, 8.27890337e-02f, -1.48399156e-02f, -5.25920317e-02f, -1.52634814e-01f, -8.03835019e-02f, -1.22568645e-01f, 2.83882325e-03f, -1.25349611e-01f, -1.71744302e-02f,
  -6.20495752e-02f, 8.87150988e-02f, 1.32653583e-02f, 5.91664091e-02f, -1.04476087e-01f, 7.25001236e-03f, 2.91449763e-02f, 4.12029810e-02f, -4.23679687e-02f, 5.59176244e-02f,
  -9.04544443e-03f, 1.65460445e-02f, -1.00243725e-01f, 4.22586426e-02f, -7.93709159e-02f, 1.41003504e-02f, -3.19312117e-03f, -1.57199308e-01f, 1.21730916e-01f, -7.26915747e-02f,
  5.43004796e-02f, -7.44115114e-02f, -8.26991871e-02f, 1.90366413e-02f, -4.15213071e-02f, 1.09548364e-02f, 8.99314135e-02f, -4.82058562e-02f, -6.78843781e-02f, 5.44219613e-02f,
  -3.59915532e-02f, 1.13166019e-01f, -1.07624494e-02f, 1.88047085e-02f, 1.15330406e-02f, -2.62353886e-02f, 4.74162325e-02f, 1.31571237e-02f, 4.75143045e-02f, 4.90754144e-04f,
  2.97738016e-02f, -1.21585820e-02f, 1.10649437e-01f, 5.20682558e-02f, 6.52597323e-02f, 1.27529046e-02f, -4.16465327e-02f, 8.25470164e-02f, 5.15567958e-02f, -5.88820316e-02f,
  1.08032025e-01f, -6.68431539e-03f, -1.39018362e-02f, 5.22676744e-02f, 2.05034502e-02f, -8.21282491e-02f, 1.04543744e-02f, 1.39777577e-02f, -1.94515809e-02f, -4.32696976e-02f,
  -4.71433215e-02f, 2.31496822e-02f, 6.56921566e-02f, 1.02014385e-01f, 5.40054627e-02f, 4.44460735e-02f, 8.12072381e-02f, 7.79033527e-02f, 3.17135863e-02f, -6.08447520e-03f,
  -2.41798647e-02f, -1.72091722e-02f, -4.99400385e-02f, 2.28906311e-02f, 1.79217104e-02f, 7.79488683e-02f, -4.00131643e-02f, 5.62270135e-02f, -5.63824885e-02f, -6.55455962e-02f,
  -1.32020831e-01f, -1.49685536e-02f, -9.82865393e-02f, -1.04747126e-02f, -3.62309590e-02f, -3.96159180e-02f, -1.07893713e-01f, 1.00666493e-01f, -5.16580939e-02f, 2.00754823e-03f,
  -3.61743122e-02f, 2.21492276e-01f, 4.49313559e-02f, -1.03894524e-01f, -2.37591583e-02f, -3.48363817e-02f, -3.08903344e-02f, 1.72184501e-02f, 2.03090250e-01f, 1.30798161e-01f,
  -2.07637250e-01f, 2.48941928e-01f, -2.19688080e-02f, -6.29185587e-02f, -3.17621589e-01f, 7.31784403e-02f, -1.29089385e-01f, 1.19861057e-02f, 8.76314417e-02f, -1.45752788e-01f,
  2.10806690e-02f, -1.90992042e-01f, -1.57906070e-01f, 1.22233689e-01f, 8.95570889e-02f, 1.34712562e-01f, -3.82265002e-02f, 8.23266655e-02f, -1.56511933e-01f, 3.53671499e-02f,
  -1.28594162e-02f, -6.59922957e-02f, 4.76688929e-02f, 7.42569640e-02f, -1.55646414e-01f, -7.45979622e-02f, -3.89145464e-02f, -1.66793056e-02f, -3.64342183e-02f, -4.34361473e-02f,
  6.83923438e-02f, -4.34000827e-02f, 6.27755523e-02f, 8.06231499e-02f, -6.49474980e-03f, 3.97855341e-02f, -4.40282635e-02f, 7.21146837e-02f, 4.24203239e-02f, -4.72724698e-02f,
  4.66546044e-02f, -2.60411128e-02f, 2.74864379e-02f, 9.41050891e-03f, 2.35991627e-02f, -2.93786414e-02f, 1.87628865e-02f, -4.55267876e-02f, 1.23052500e-01f, 2.22325027e-02f,
  -8.49875957e-02f, 1.68018684e-01f, 7.44131207e-02f, 6.16048984e-02f, -5.79528920e-02f, -8.25897045e-03f, 7.98127055e-02f, 2.31549628e-02f, 3.94302607e-02f, 6.32753223e-02f,
  -2.55067348e-02f, 9.84368473e-02f, -8.24367744e-04f, 9.82995331e-02f, -7.28131235e-02f, 1.62995353e-01f, 8.51785615e-02f, 3.16413492e-02f, 8.52903128e-02f, 1.06527559e-01f,
  5.77890053e-02f, -4.41588201e-02f, -2.19093878e-02f, -2.68473737e-02f, -9.13859159e-02f, -2.42371708e-02f, 1.74023013e-03f, -1.55942636e-02f, -6.11323491e-02f, 4.62944023e-02f,
  -1.01162359e-01f, -6.73851073e-02f, 6.94890767e-02f, -2.46427227e-02f, 3.60575989e-02f, -3.07479333e-02f, 7.73825198e-02f, 1.22199789e-01f, -5.09695821e-02f, 7.42200762e-02f,
  -2.87035829e-03f, 4.05372530e-02f, 5.10694496e-02f, 6.72364756e-02f, -1.02314100e-01f, -3.42481285e-02f, -5.99549077e-02f, 1.35901645e-02f, -5.53533398e-02f, -2.62189470e-02f,
  3.71712483e-02f, -3.76623310e-02f, 5.72511256e-02f, 1.06249146e-01f, 4.19446267e-03f, 3.77466679e-02f, 2.06014048e-02f, -3.35073881e-02f, 1.12915784e-02f, 1.02647375e-02f,
  3.44024777e-01f, 1.89158902e-01f, 3.28664184e-01f, 9.11184549e-02f, 1.14839599e-01f, -2.08856434e-01f, 1.73432063e-02f, 1.63202569e-01f, -3.08907609e-02f, -1.15284905e-01f,
  6.19436800e-02f, 1.77529141e-01f, -5.88349774e-02f, -1.09218977e-01f, 1.27304718e-01f, -2.64703810e-01f, 4.32727020e-03f, -6.18094997e-03f, 2.16094684e-02f, 9.29033160e-02f,
  -2.24611089e-02f, -1.23072229e-01f, 1.54763862e-01f, 8.10703263e-02f, 1.52234480e-01f, 2.07784101e-01f, 1.60431296e-01f, 1.08513571e-01f, 7.54910288e-03f, 1.38434440e-01f,
  -6.80478141e-02f, -1.07942410e-01f, -1.98222950e-01f, -1.54576629e-01f, -6.29822165e-02f, -1.66003898e-01f, -4.19827513e-02f, -1.17666256e-02f, -1.53060839e-01f, -6.81083500e-02f,
  -1.96400695e-02f, -3.30398902e-02f, 5.25775254e-02f, -9.04857889e-02f, 3.65738012e-02f, -7.85870403e-02f, -8.53072852e-03f, 2.84553412e-02f, -2.86473660e-03f, 1.49146587e-01f,
  5.61800897e-02f, 8.90033543e-02f, 3.53654660e-02f, 4.09062430e-02f, 1.05448812e-01f, 1.02467269e-01f, 3.87437306e-02f, 1.63634598e-01f, 6.97694421e-02f, -1.97461322e-02f,
  1.75639172e-03f, -4.31186296e-02f, -9.15428549e-02f, -3.89929004e-02f, 1.01487851e-02f, 2.63983570e-02f, -1.24717556e-01f, -7.08548427e-02f, -2.74630543e-02f, -4.52298298e-02f,
  -1.12795092e-01f, -6.87674135e-02f, -3.33661288e-02f, -6.57803416e-02f, -4.24889959e-02f, 7.84293935e-02f, -4.09692265e-02f, -9.18655843e-02f, -5.39618842e-02f, -4.01254632e-02f,
  -5.90568297e-02f, 1.40303243e-02f, -5.78364991e-02f, -1.80429481e-02f, -3.05968989e-02f, 6.82475194e-02f, -6.44538030e-02f, -8.10027719e-02f, 1.57698058e-02f, -2.10676733e-02f,
  -2.95065325e-02f, -1.46713806e-02f, -1.68950021e-01f, -1.45683303e-01f, -1.32342875e-01f, -1.31524861e-01f, -8.59326720e-02f, 1.21839363e-02f, -1.50252506e-01f, -6.48874789e-02f,
  -2.50142682e-02f, -3.74324694e-02f, 8.86401832e-02f, -9.07917321e-02f, 2.19528116e-02f, -4.23762202e-03f, 1.29001737e-01f, -4.13017571e-02f, -3.47119942e-02f, 5.18244728e-02f,
  5.39857186e-02f, 8.99451226e-02f, -5.04480638e-02f, -2.93957125e-02f, -5.00739962e-02f, 1.54691786e-01f, 9.54522789e-02f, 2.50462499e-02f, -2.10688747e-02f, -6.59624636e-02f,
  6.38399133e-03f, -1.85719714e-01f, 2.92277724e-01f, 1.53670549e-01f, -7.79026141e-03f, -3.00309837e-01f, -4.14884416e-03f, -1.46401688e-01f, -7.01693771e-03f, -2.11468950e-01f,
  5.04518338e-02f, 1.60273612e-01f, 2.06091106e-02f, 5.46589354e-03f, 1.76059440e-01f, 3.04801222e-02f, -9.79271308e-02f, 3.93184572e-02f, -4.97656362e-03f, -4.06869538e-02f,
  9.92338583e-02f, -1.08414650e-01f, 2.17274979e-01f, -2.70802062e-02f, -2.75825877e-02f, 1.24892347e-01f, 4.57954891e-02f, 9.41762477e-02f, -8.58969986e-02f, 1.40624598e-01f,
  -2.29323253e-01f, 7.97629729e-03f, -3.41570489e-02f, -6.70471117e-02f, -1.53615117e-01f, -4.55372222e-02f, -2.63960864e-02f, 7.42325112e-02f, 2.70754658e-02f, -7.31701478e-02f,
  -3.05758584e-02f, -5.73892631e-02f, 1.19665824e-01f, -5.51323965e-03f, -4.63742986e-02f, -5.56764044e-02f, -3.94918118e-03f, -8.32240433e-02f, -8.88102781e-03f, 5.82760051e-02f,
  5.21343276e-02f, 8.54974911e-02f, 2.07788106e-02f, 4.37561721e-02f, 4.72268611e-02f, 5.90436906e-02f, 9.72485170e-02f, 1.21107757e-01f, -7.38579854e-02f, -9.66361165e-02f,
  1.64327919e-01f, -7.57319704e-02f, -9.51525718e-02f, -7.48880729e-02f, -4.74664234e-02f, -2.84135975e-02f, -5.00329286e-02f, 6.28461083e-03f, 8.04707035e-03f, -1.35813594e-01f,
  -1.63821489e-01f, 3.30094658e-02f, -1.00814611e-01f, -7.39095882e-02f, -1.09354027e-01f, 2.94919293e-02f, -8.90658945e-02f, -1.51699916e-01f, -9.05128717e-02f, -5.85491396e-02f,
  -5.16074337e-02f, -1.02338687e-01f, -7.89901316e-02f, -4.29898873e-03f, -4.22664732e-02f, 1.75461560e-01f, -7.99010545e-02f, -7.27035105e-02f, -9.97321587e-03f, -6.76420256e-02f,
  -4.55732554e-01f, -2.67140716e-01f, -9.65432003e-02f, -1.77892774e-01f, -2.04539672e-02f, -1.01070262e-01f, 1.50314914e-02f, -3.26788947e-02f, -1.79387584e-01f, -1.76959857e-01f,
  -5.14147542e-02f, -1.15957476e-01f, -1.00388210e-02f, -1.46982908e-01f, 5.12298904e-02f, -3.94586734e-02f, 2.39174590e-02f, -4.61045951e-02f, -4.62189093e-02f, -4.76907231e-02f,
  8.62528458e-02f, 4.38694507e-02f, 7.85895213e-02f, -7.54670128e-02f, 6.94547519e-02f, 4.02261764e-02f, 6.17685728e-02f, 7.51923770e-02f, 2.76023988e-02f, 2.01951712e-03f,
  4.34151351e-01f, 8.80182460e-02f, 1.15437530e-01f, 2.55253166e-01f, -2.57203966e-01f, -2.85899669e-01f, 1.94479093e-01f, 1.34719377e-02f, 1.35231227e-01f, 4.00139540e-02f,
  -7.91660044e-03f, 1.61926192e-03f, 2.08369359e-01f, 2.18107715e-01f, -4.01839949e-02f, 5.39788678e-02f, -2.57213470e-02f, 3.84295881e-02f, -5.01859095e-03f, 1.63269088e-01f,
  4.46662642e-02f, -5.71699217e-02f, 1.06598392e-01f, -1.16822951e-01f, 7.63381496e-02f, 5.47282286e-02f, -5.53126633e-02f, 3.96693088e-02f, -5.61461858e-02f, -5.87355718e-02f,
  4.88954075e-02f, 2.15750679e-01f, 1.13877572e-01f, -7.52392877e-03f, -1.28306251e-03f, 7.53103346e-02f, 4.15817015e-02f, -1.93235986e-02f, -2.19102520e-02f, -2.09794249e-02f,
  -7.70908818e-02f, -4.09467183e-02f, -1.70451887e-02f, 6.20085448e-02f, -1.10346988e-01f, -6.55824225e-03f, -1.40514314e-01f, -3.87108847e-02f, 1.55066820e-02f, 7.90673569e-02f,
  7.33237937e-02f, -4.45626676e-02f, -4.40155864e-02f, -5.75231388e-02f, -1.29532814e-01f, -1.07966019e-02f, -5.45557141e-02f, 3.09392363e-02f, -5.29487468e-02f, 2.85026357e-02f,
  -9.85392649e-03f, 6.43233359e-02f, 2.82800216e-02f, -2.23639030e-02f, 4.14232612e-02f, -7.65989572e-02f, -1.14357490e-02f, -1.34875804e-01f, 1.43480403e-02f, -3.34253833e-02f,
  -3.89652140e-02f, -1.79446191e-02f, 8.79709199e-02f, 2.52867602e-02f, -6.86410535e-03f, 8.26169252e-02f, -3.87868695e-02f, -1.88041721e-02f, 3.34752053e-02f, -3.81713547e-02f,
  3.81244682e-02f, -3.89853567e-02f, 1.17880320e-02f, -1.95689891e-02f, -2.99026594e-02f, 4.59291274e-04f, -9.23644602e-02f, 1.14308307e-02f, 9.33355987e-02f, -1.61188357e-02f,
  -1.17549613e-01f, 4.49887402e-02f, -8.22294224e-03f, -4.91234772e-02f, -1.51494974e-02f, -1.40363267e-02f, 5.35247512e-02f, -5.47638983e-02f, -8.60022381e-02f, 2.22615432e-03f,
  -1.68142524e-02f, -3.62961926e-02f, -7.58356601e-03f, -5.93006723e-02f, -1.08718723e-01f, -1.56386532e-02f, -8.18832889e-02f, -2.35661566e-02f, -8.37992951e-02f, -6.15457334e-02f,
  -6.40064925e-02f, 1.87175628e-02f, -1.67453270e-02f, -8.44684616e-02f, -9.77763683e-02f, -9.18705985e-02f, -4.40734020e-03f, 3.52360867e-02f, -7.40791485e-02f, -4.55192924e-02f,
  -1.59958079e-01f, 1.42983466e-01f, -1.42707214e-01f, 9.30913761e-02f, -1.90210477e-01f, -3.34776491e-01f, -3.27258445e-02f, -1.32886440e-01f, 1.25300646e-01f, 1.07099876e-01f,
  3.14776646e-03f, 2.49964789e-01f, 1.95165351e-01f, -4.31278758e-02f, 6.93434030e-02f, 1.86582431e-01f, -5.79823405e-02f, 1.27661973e-01f, 1.95681863e-02f, 6.81668445e-02f,
  3.17556486e-02f, 6.26401231e-02f, -9.18822736e-02f, -5.30982763e-02f, -1.21516407e-01f, 2.59279809e-03f, 5.92567353e-03f, 6.90518245e-02f, -5.06164767e-02f, 7.13917986e-02f,
  -1.21878296e-01f, 9.87500548e-02f, -2.33746227e-03f, 1.90782826e-02f, -7.10701197e-02f, -1.22828469e-01f, 1.58285759e-02f, 6.55590817e-02f, 6.74400777e-02f, -5.81189469e-02f,
  4.84972000e-02f, -5.09994440e-02f, 5.89640737e-02f, 1.28937647e-01f, 5.81095815e-02f, 6.10431619e-02f, -7.49772340e-02f, 5.43402368e-03f, 2.28282791e-02f, -4.82254624e-02f,
  -3.11779045e-02f, -6.85207248e-02f, -4.28269394e-02f, 3.47235389e-02f, 2.77786721e-02f, -7.32705444e-02f, 1.94268767e-02f, 2.84772050e-02f, -1.54177574e-02f, -1.19787857e-01f,
  1.17331743e-02f, -3.84531356e-02f, -4.42943946e-02f, -3.29753682e-02f, 1.82600189e-02f, -8.53990763e-02f, 3.43388580e-02f, 9.21620876e-02f, 8.02136492e-03f, 1.19552771e-02f,
  -6.08852021e-02f, -9.33422670e-02f, 8.97072081e-04f, 6.07646555e-02f, -6.72311112e-02f, -9.60875116e-03f, -2.41675992e-02f, 1.18652105e-01f, -2.98682060e-02f, -1.59167200e-01f,
  3.65945622e-02f, 5.47431782e-02f, -5.17906919e-02f, -6.54774979e-02f, -4.10353169e-02f, 4.10121046e-02f, 6.04778938e-02f, -1.47206485e-02f, -3.55078541e-02f, -5.71442135e-02f,
  8.48410651e-02f, 2.09737614e-01f, 3.21580842e-02f, 8.59223977e-02f, -7.69544905e-03f, -1.08448468e-01f, 5.67259900e-02f, -8.30087215e-02f, 4.61320095e-02f, -1.12803981e-01f,
  -1.49595486e-02f, -3.41560366e-03f, -1.46011263e-03f, 1.54615324e-02f, 9.29154754e-02f, -6.08178750e-02f, 9.01601091e-02f, 1.60735190e-01f, 3.40096578e-02f, -6.51639998e-02f,
  6.15740493e-02f, 2.44804155e-02f, -5.69341481e-02f, -1.25893906e-01f, 4.19383459e-02f, -2.19824500e-02f, 2.13768277e-02f, 1.69213638e-02f, 3.02543528e-02f, -2.86861658e-02f,
  -1.67006850e-01f, 2.12166101e-01f, 1.49611861e-01f, -1.32127687e-01f, 7.41925417e-03f, -2.25605726e-01f, -1.32535353e-01f, 1.66774243e-01f, 9.73090008e-02f, -3.01366625e-03f,
  -1.51485741e-01f, 2.13221759e-01f, 7.68848509e-02f, -3.45166832e-01f, -2.20917746e-01f, 5.37743829e-02f, -1.92316398e-01f, -7.46241212e-02f, 4.28324640e-02f, 2.26344373e-02f,
  1.44150168e-01f, -1.95087999e-01f, -5.93178831e-02f, 1.18648112e-01f, -6.51200414e-02f, 2.19935700e-01f, 4.62208986e-02f, 1.99338689e-01f, -9.10834298e-02f, -3.27370465e-02f,
  -1.64935842e-01f, 1.22290030e-02f, 6.87268376e-02f, 4.85361703e-02f, -4.69513834e-02f, -2.59847064e-02f, -9.51613858e-02f, 1.88082410e-03f, 2.44662259e-03f, 5.15465811e-03f,
  2.65202429e-02f, -7.61207119e-02f, -3.92228551e-02f, 6.03122562e-02f, -4.30907421e-02f, 4.89484519e-02f, -2.05853228e-02f, 2.55767144e-02f, 7.26672038e-02f, -1.33027146e-02f,
  6.08995333e-02f, -9.44427252e-02f, -1.31457523e-02f, 3.14443111e-02f, 3.03328969e-02f, -1.60077810e-02f, 3.24014500e-02f, 3.41365300e-02f, -5.79274967e-02f, -1.40595865e-02f,
  -1.99753977e-02f, 5.26870228e-02f, 4.26786020e-02f, -5.17486632e-02f, -1.90810859e-02f, -1.07225843e-01f, 9.23752133e-03f, 2.67239809e-02f, 1.19687477e-02f, 2.89543010e-02f,
  -7.30888546e-02f, -8.85194167e-02f, -2.84328349e-02f, -2.18977556e-02f, -8.94393846e-02f, 4.94088382e-02f, 6.10362962e-02f, -6.61904737e-02f, 4.61573973e-02f, 4.54975292e-02f,
  8.26389641e-02f, -3.19749825e-02f, 3.93641591e-02f, -9.37916990e-03f, -4.19393182e-02f, 1.11666046e-01f, -4.11862275e-03f, 4.97130565e-02f, -6.16645813e-02f, 3.99823301e-02f,
  -1.91390626e-02f, 1.83473304e-01f, -2.20413925e-03f, -5.34727052e-02f, -3.93974641e-03f, -3.44810262e-02f, -2.38740537e-02f, 1.40871018e-01f, 1.78827882e-01f, 1.85437351e-02f,
  3.80497128e-02f, -3.46770883e-02f, -1.36403181e-02f, 2.13286467e-02f, -1.00518323e-01f, 3.93674746e-02f, -1.23150878e-01f, -7.61264795e-03f, -3.67449112e-02f, 9.69670340e-02f,
  7.89894089e-02f, -3.30981314e-02f, 9.84623060e-02f, -4.14847173e-02f, -8.30265433e-02f, 7.03910068e-02f, -4.11592349e-02f, 8.58811885e-02f, -6.45257309e-02f, -6.66086078e-02f,
  -3.84799317e-02f, 2.52752692e-01f, 2.38834292e-01f, 3.14905077e-01f, -1.96868673e-01f, -1.49943143e-01f, 1.98311672e-01f, 3.76974628e-03f, 2.91019231e-01f, 7.33101889e-02f,
  -3.44877653e-02f, 3.85432728e-02f, 1.97209135e-01f, 1.89436406e-01f, -9.05940086e-02f, 2.78000504e-01f, 3.31116989e-02f, 8.91531333e-02f, 5.74956052e-02f, -6.26397431e-02f,
  1.46379704e-02f, -7.48757645e-02f, 1.48041710e-01f, -1.37601539e-01f, -8.44723284e-02f, 2.83044279e-02f, -1.41822964e-01f, -8.29134136e-03f, -1.43100113e-01f, -1.36259377e-01f,
  9.37402770e-02f, 5.23260273e-02f, 3.12546715e-02f, 2.08890401e-02f, -1.53408619e-02f, -1.31199524e-01f, -6.54671192e-02f, -3.58886309e-02f, 4.14818712e-02f, 1.41412586e-01f,
  -1.87186413e-02f, 4.50499356e-02f, 3.13215069e-02f, -9.78812650e-02f, -5.65723926e-02f, 2.06888318e-02f, 7.23040700e-02f, -3.85203660e-02f, 5.57690300e-02f, -1.07235564e-02f,
  7.19801486e-02f, -1.06659094e-02f, -1.82444677e-02f, 4.78825457e-02f, -5.35509996e-02f, 2.31524333e-02f, -2.32280958e-02f, -9.63583440e-02f, 2.97991578e-02f, -2.45046010e-03f,
  -1.51705354e-01f, 3.18214335e-02f, 6.77033619e-04f, 7.07307383e-02f, 3.83453490e-03f, -1.75162628e-02f, -4.01747636e-02f, 2.74884291e-02f, 4.87074107e-02f, 8.16443749e-03f,
  1.51045457e-01f, 5.36615998e-02f, -1.12996846e-02f, -4.06298190e-02f, 8.37173313e-03f, -2.66637583e-03f, -5.95770255e-02f, -3.23931836e-02f, 7.93303922e-02f, 1.10992782e-01f,
  -8.27535428e-03f, -1.55853741e-02f, 8.62765163e-02f, 1.78762507e-02f, 1.05894372e-01f, -1.67861581e-02f, -5.65086976e-02f, -3.45005244e-02f, 7.03870580e-02f, 3.39833349e-02f,
  -1.31803825e-01f, -7.57885352e-02f, 1.18691720e-01f, 8.99546221e-03f, 5.29313348e-02f, -7.84780737e-03f, -1.20225418e-02f, 2.23954171e-02f, 2.31957454e-02f, -4.49603684e-02f,
  -1.41309917e-01f, 7.35365301e-02f, -6.56744763e-02f, -1.46588199e-02f, -1.69854145e-02f, 7.01287016e-02f, 1.66093453e-03f, 1.42309712e-02f, -7.92010054e-02f, -8.65220353e-02f,
  -1.14566013e-01f, 1.33874878e-01f, 8.67642462e-03f, 7.80982152e-02f, -1.04169995e-02f, -3.36773656e-02f, -1.41499504e-01f, 1.25311762e-02f, -8.57154652e-02f, 7.03419745e-02f,
  -9.37358215e-02f, -1.76136494e-01f, -3.56553882e-01f, -1.52234882e-01f, 1.12749018e-01f, 2.36291066e-01f, 1.53757125e-01f, -1.22563086e-01f, -1.29164010e-01f, 1.40685976e-01f,
  1.16478249e-01f, -9.88096222e-02f, 4.97992225e-02f, -5.30996323e-02f, 2.94106584e-02f, 2.69419383e-02f, 3.14893946e-02f, -1.54523435e-03f, -9.69382152e-02f, 1.46685550e-02f,
  -4.44849506e-02f, 1.97793357e-02f, -1.19416080e-01f, -1.31405085e-01f, 1.79781690e-02f, -1.89835846e-01f, 1.14143714e-01f, -2.92064436e-02f, 1.18352540e-01f, 9.59326997e-02f,
  1.74755529e-01f, -2.13953838e-01f, -3.75564955e-02f, -2.29565799e-02f, 2.02557966e-02f, 4.50227223e-02f, 2.49579847e-02f, -2.44730758e-03f, -2.00912412e-02f, 8.41204915e-03f,
  -1.72696393e-02f, 3.41987237e-02f, -2.11030338e-02f, 3.94849926e-02f, 5.76477870e-03f, -9.02113914e-02f, 4.05237190e-02f, -3.56897159e-04f, -7.41251037e-02f, 1.03216678e-01f,
  -4.67751212e-02f, -5.24108149e-02f, -2.11930256e-02f, 7.43429884e-02f, -8.44229460e-02f, -7.95249715e-02f, -1.10678971e-02f, -1.05279066e-01f, 7.53612071e-02f, 1.23319246e-01f,
  -1.01816848e-01f, 3.88717279e-02f, 2.41080709e-02f, 1.78874768e-02f, -4.03200202e-02f, -1.17851429e-04f, 1.31565675e-01f, 5.72503805e-02f, 2.93219555e-02f, 5.53937145e-02f,
  5.40646464e-02f, 4.07328121e-02f, -2.28996053e-02f, -5.81661379e-03f, 5.01901060e-02f, -4.38543446e-02f, 4.84263301e-02f, 9.96343642e-02f, 4.85174134e-02f, -1.51223868e-01f,
  4.16181907e-02f, -1.84025615e-02f, 2.48655770e-03f, 1.41202316e-01f, 5.39667420e-02f, -1.00682490e-01f, 3.09355743e-02f, 2.58129332e-02f, 1.55025478e-02f, 7.80043155e-02f,
  3.42333168e-01f, 8.33744481e-02f, 5.45041151e-02f, 6.66100606e-02f, 9.25827324e-02f, 3.40317376e-03f, -6.81240633e-02f, -6.06913753e-02f, 8.09316412e-02f, 2.80034523e-02f,
  -4.00542654e-02f, 8.50510150e-02f, 8.09845105e-02f, 1.35074034e-01f, -7.09702894e-02f, 7.71261156e-02f, 1.28081217e-01f, 5.43199703e-02f, 1.37429073e-01f, 8.63078386e-02f,
  -7.70473182e-02f, 6.62632845e-03f, -8.11797827e-02f, 2.63237976e-03f, -3.45495604e-02f, 8.92678723e-02f, -6.94127232e-02f, -1.21619359e-01f, 4.98964973e-02f, 1.71065941e-01f,
  5.63064814e-01f, -1.71556532e-01f, -1.35425523e-01f, -3.97715196e-02f, 7.76999891e-02f, -2.80510318e-02f, -1.86092302e-01f, 9.70719755e-02f, 2.05756068e-01f, -2.33869553e-01f,
  -5.37525415e-02f, 9.28087533e-02f, -2.19687790e-01f, -3.62479240e-02f, 1.28283203e-01f, -2.55325526e-01f, -9.12209898e-02f, -7.22881481e-02f, 7.09356293e-02f, 8.04347396e-02f,
  4.64599878e-02f, -7.85850137e-02f, -1.33250982e-01f, -2.89813206e-02f, 1.76919196e-02f, 2.93771420e-02f, -4.10020277e-02f, -9.16315615e-02f, 4.53479290e-02f, -1.90404113e-02f,
  -1.21104652e-02f, -2.89105829e-02f, 1.01166159e-01f, -6.72755123e-05f, -1.33331250e-02f, -1.85431857e-02f, -1.18471056e-01f, -6.57877922e-02f, 3.77912149e-02f, -9.21803191e-02f,
  -1.19330818e-02f, -8.50134343e-02f, 5.58543466e-02f, 6.71375841e-02f, 3.53763700e-02f, 7.10660294e-02f, 2.01363172e-02f, 1.53256670e-01f, -1.85031556e-02f, -5.33862459e-03f,
  6.53390884e-02f, 3.96022163e-02f, -6.52405545e-02f, -1.37563303e-01f, -1.67301670e-02f, -1.89456728e-03f, -1.04097016e-01f, -9.98293981e-02f, -2.91959066e-02f, 1.46872569e-02f,
  -1.11271348e-02f, -1.11902855e-01f, 1.28496333e-03f, 1.10622887e-02f, -4.13899459e-02f, 2.89621651e-02f, 3.86106521e-02f, 1.87209155e-02f, -1.32689578e-02f, -2.53508873e-02f,
  7.57022426e-02f, 9.21584368e-02f, 6.21686392e-02f, 5.18617928e-02f, 1.19384773e-01f, 3.49113233e-02f, -4.40868288e-02f, -8.27656016e-02f, -2.91574113e-02f, 6.51851222e-02f,
  2.66198404e-02f, -5.87026663e-02f, 3.40602361e-02f, -7.86368251e-02f, -8.11084434e-02f, 5.45933545e-02f, 7.87163153e-03f, -4.32791449e-02f, 1.76415611e-02f, -7.93363303e-02f,
  -1.45244837e-01f, -2.52293944e-01f, 6.28852099e-02f, 1.06903156e-02f, -5.55110984e-02f, 6.92912862e-02f, -1.55080706e-02f, 1.08362630e-01f, -4.13106643e-02f, -6.92540482e-02f,
  -2.56937165e-02f, -7.09476043e-03f, 4.57664691e-02f, 2.41231658e-02f, -4.38469760e-02f, -6.33832514e-02f, -1.27699077e-01f, 8.05682130e-03f, -1.40375299e-02f, -4.18517739e-02f,
  1.57863926e-02f, -7.54073774e-03f, -6.05172142e-02f, -6.10907329e-03f, -9.18130763e-03f, -3.30122635e-02f, 2.00120464e-01f, 1.24378884e-02f, -2.66987495e-02f, -7.67387776e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.96877521e-01f, 3.14786166e-01f, 3.57965946e-01f, 4.73021418e-02f, 9.93457437e-02f, 4.01132315e-01f, 4.53631669e-01f, 2.94251561e-01f, 5.26607156e-01f, 2.50085145e-01f,
  8.86144191e-02f, 1.66929558e-01f, 7.85657838e-02f, -3.10845650e-03f, 3.22535813e-01f, 9.49289724e-02f, -1.10749351e-02f, 2.14543894e-01f, 9.83831659e-02f, -1.64927572e-01f,
  -1.70036763e-01f, -6.07705079e-02f, -1.96761459e-01f, -1.05934002e-01f, -6.87541142e-02f, -5.62976785e-02f, -9.29324701e-02f, 2.58822143e-01f, 6.76228404e-02f, 2.76451439e-01f,
  -1.11611173e-01f, -2.80740634e-02f, -2.69414395e-01f, 9.85129178e-02f, -5.62275499e-02f, -8.74213651e-02f, -4.67616990e-02f, 6.38023624e-03f, -1.97158847e-03f, 3.28137353e-02f,
  -7.56134689e-02f, 6.93079503e-03f, 1.20878350e-02f, 7.89129660e-02f, 6.70224130e-02f, 3.71870846e-02f, -6.01926120e-03f, -6.52637482e-02f, 5.12924083e-02f, 8.35517701e-03f,
  -1.20094614e-02f, -4.65504341e-02f, -8.33979100e-02f, 5.18356785e-02f, -5.71985915e-03f, 4.16843630e-02f, 1.07401453e-01f, -9.74869728e-03f, 4.03772332e-02f, 6.82585910e-02f,
  6.99178949e-02f, 6.65019602e-02f, -4.29881513e-02f, -2.10869331e-02f, -2.08647661e-02f, -6.79213777e-02f, 1.45774074e-02f, -7.06238300e-02f, -9.45674852e-02f, -7.36468285e-02f,
  -3.73321548e-02f, -1.68854371e-04f, 5.85108018e-03f, 1.75848952e-03f, 3.42359282e-02f, 5.33144213e-02f, -1.80088997e-01f, 6.23026909e-03f, 4.84208018e-02f, 1.69283524e-02f,
  -3.13491561e-02f, -5.26596420e-02f, 9.43650454e-02f, -2.80243848e-02f, 3.24361734e-02f, 1.03118107e-01f, -3.20986360e-02f, -1.04450695e-01f, 3.45793478e-02f, 5.62174805e-02f,
  3.04655761e-01f, 3.24986130e-01f, -5.23093529e-02f, 1.80463139e-02f, 6.37815297e-02f, -7.94871449e-02f, -2.40604393e-03f, -6.40748665e-02f, 2.30356261e-01f, -3.60277928e-02f,
  -5.22106662e-02f, 3.21845077e-02f, 1.12899624e-01f, 2.15783957e-02f, 1.14092797e-01f, 1.24000862e-01f, -1.37356054e-02f, 1.05434522e-01f, -2.05246322e-02f, 8.06120709e-02f,
  -1.79113835e-01f, 1.00678690e-01f, -1.07545182e-01f, -3.06056403e-02f, -5.63824177e-02f, 5.36814108e-02f, 3.30353789e-02f, 4.98120673e-02f, -2.76369695e-03f, 8.20903108e-03f,
  2.46342018e-01f, 3.77529263e-02f, -4.18558121e-01f, -2.09576145e-01f, -2.51283139e-01f, 3.36289525e-01f, 2.79933602e-01f, 1.20044248e-02f, 2.32064407e-02f, 4.60078806e-01f,
  2.16425538e-01f, 2.67434102e-02f, 2.13596061e-01f, 4.54027653e-01f, 9.72648561e-02f, 2.11243913e-01f, 2.24148080e-01f, 1.87455505e-01f, -7.05416203e-02f, 2.66338050e-01f,
  2.61622462e-02f, 3.91850770e-01f, -9.99568626e-02f, 1.34408087e-01f, 1.55905709e-01f, -2.57135153e-01f, -7.64333755e-02f, -2.36660033e-01f, 9.22619998e-02f, -1.00309988e-02f,
  -3.62754166e-02f, -3.06196772e-02f, -8.12503919e-02f, -6.51596561e-02f, -6.99388012e-02f, -1.77984275e-02f, -1.01189896e-01f, -7.97313973e-02f, -1.52079016e-01f, 4.42436971e-02f,
  4.79210652e-02f, -1.14761796e-02f, 6.64548501e-02f, -6.26633093e-02f, -4.49859984e-02f, -7.16286674e-02f, -1.00327820e-01f, -4.98129353e-02f, 4.37879153e-02f, 5.64083718e-02f,
  -3.41284089e-02f, -8.46391022e-02f, -5.50312065e-02f, -1.12199768e-01f, -1.54739395e-01f, 2.71811299e-02f, 5.28534688e-03f, -7.54800960e-02f, 5.33212088e-02f, -5.90606174e-03f,
  1.67676527e-02f, 7.29080802e-03f, 6.96602017e-02f, 1.77989770e-02f, -1.87641189e-01f, -1.01028942e-01f, 6.48910776e-02f, -2.30510868e-02f, -1.36193573e-01f, 4.97469492e-02f,
  9.66332480e-03f, -5.49043678e-02f, 4.07049321e-02f, 7.94626623e-02f, 9.62530524e-02f, 7.47920796e-02f, -6.77285120e-02f, 1.84601322e-02f, -1.00259213e-02f, -2.31164396e-02f,
  -2.12613009e-02f, 2.23469716e-02f, -4.71097901e-02f, -6.05722852e-02f, -2.61344220e-02f, 5.30333333e-02f, 1.19128056e-01f, 2.73723602e-02f, 1.93611500e-04f, -1.57857001e-01f,
  -1.29257916e-02f, 1.49948716e-01f, 1.31959859e-02f, -6.45055398e-02f, -7.97312483e-02f, 7.17150494e-02f, -2.29958817e-02f, 3.94917801e-02f, -5.18495366e-02f, 6.67770877e-02f,
  -2.54024360e-02f, -8.89527947e-02f, 3.72912474e-02f, -1.57437678e-02f, -1.29271969e-01f, 9.79659855e-02f, 7.42618144e-02f, -8.11975971e-02f, -4.97836471e-02f, -3.13097015e-02f,
  7.04873577e-02f, 5.59349060e-02f, 2.66331602e-02f, -7.04321191e-02f, -2.44131722e-02f, -2.49068327e-02f, 2.74508055e-02f, -6.48487285e-02f, -4.01747078e-02f, -4.52252626e-02f,
  3.17895472e-01f, -5.27364969e-01f, 2.02626795e-01f, 3.04678053e-01f, 4.56003219e-01f, 1.90592363e-01f, 2.49780253e-01f, 1.29738986e-01f, 2.39638448e-01f, -3.47410977e-01f,
  -3.39476168e-02f, -1.45740584e-01f, -1.60056487e-01f, 5.27395941e-02f, 2.04699025e-01f, -3.71679030e-02f, 1.63358562e-02f, -1.52309433e-01f, 3.07489131e-02f, 3.40306014e-03f,
  2.46982679e-01f, 1.64421350e-01f, 2.33460784e-01f, -9.14575160e-02f, 1.87611371e-01f, -7.78339654e-02f, -9.75350514e-02f, 8.43229815e-02f, -1.20928451e-01f, 1.27432913e-01f,
  -6.12000674e-02f, 8.87427032e-02f, -3.34973596e-02f, -1.61799729e-01f, -5.90165891e-02f, 3.97307351e-02f, 2.30844095e-02f, 6.76946267e-02f, 1.08453907e-01f, -6.79389536e-02f,
  -3.46783809e-02f, 2.16238275e-02f, 1.02469072e-01f, 1.04793340e-01f, -6.16092421e-02f, 9.04847682e-03f, 1.14280432e-01f, -5.76251112e-02f, 3.13351043e-02f, 6.28747791e-02f,
  4.91422340e-02f, 1.36325192e-02f, -2.74270941e-02f, -1.39771864e-01f, 1.34968430e-01f, 6.81679770e-02f, 5.04483618e-02f, -4.38654386e-02f, -1.78051665e-02f, 8.42206031e-02f,
  4.44948077e-02f, -6.68226704e-02f, 5.69224730e-02f, -3.76816541e-02f, 7.72660896e-02f, 9.67780128e-02f, -4.87514324e-02f, 4.95886488e-04f, -1.40021771e-01f, -4.46220078e-02f,
  -8.39006901e-02f, 3.26355770e-02f, 8.96996244e-06f, -2.54095346e-02f, -1.50871202e-02f, 7.53183737e-02f, -3.37435342e-02f, -6.58410192e-02f, -2.07864959e-02f, -2.33289134e-02f,
  -1.16346806e-01f, -6.33080199e-04f, -2.91174538e-02f, 2.21019447e-01f, -4.32482250e-02f, -3.32447626e-02f, -1.00543700e-01f, 9.49728116e-02f, 8.58093649e-02f, 5.74606878e-04f,
  -4.56766695e-01f, -3.97914976e-01f, -9.49773863e-02f, -1.13698505e-01f, -2.03709319e-01f, -1.19248457e-01f, -8.20949581e-03f, -1.31643668e-01f, -1.51911646e-01f, 4.05885912e-02f,
  -2.35176962e-02f, 7.67320320e-02f, -6.74208254e-02f, 1.29344389e-01f, -1.17650315e-01f, 2.31689457e-02f, -2.64940616e-02f, -2.77812839e-01f, -1.05497338e-01f, -4.27486375e-02f,
  -6.38660416e-02f, 1.60457415e-03f, -2.28100885e-02f, 9.94607210e-02f, -6.52480498e-02f, 3.45942043e-02f, 1.57749385e-01f, 3.64951678e-02f, 8.62144381e-02f, 3.87265049e-02f,
  -4.22787935e-01f, -2.74536222e-01f, -1.31252006e-01f, 4.64023575e-02f, -2.08297111e-02f, -2.21179485e-01f, -3.23976308e-01f, 5.64647578e-02f, -2.99943596e-01f, -2.01644957e-01f,
  -1.09882899e-01f, 6.82608923e-03f, -3.20407808e-01f, 1.07348017e-01f, 1.28911689e-01f, -1.67418331e-01f, 2.56655663e-01f, 1.22402243e-01f, 1.41134664e-01f, -1.42783555e-03f,
  2.09124744e-01f, 2.27916256e-01f, 4.11801904e-01f, 4.52127129e-01f, 8.45114738e-02f, 3.38200152e-01f, 3.67127538e-01f, 2.37924978e-01f, 4.30163413e-01f, 1.29194841e-01f,
  -1.13044493e-01f, -2.14533031e-01f, -2.92955227e-02f, -1.97115298e-02f, -5.15030362e-02f, 5.47825824e-03f, -2.81370897e-02f, 4.39543612e-02f, -2.24989858e-02f, 7.38649815e-02f,
  -7.27951676e-02f, 1.52696192e-01f, 1.12917595e-01f, 2.26556640e-02f, -4.88408543e-02f, 6.13358095e-02f, 1.70387048e-02f, -5.54370284e-02f, -1.28574790e-02f, -8.15642923e-02f,
  3.02394200e-03f, 7.53039047e-02f, 5.03853112e-02f, 9.95820835e-02f, -2.28293464e-02f, -3.81606370e-02f, 9.83778462e-02f, 9.32856835e-03f, 7.05685392e-02f, 6.00048788e-02f,
  -7.52734542e-02f, 1.01342723e-01f, 4.91546281e-02f, 1.58335175e-02f, -3.94235887e-02f, 2.09157094e-02f, -4.66239452e-02f, 6.14981391e-02f, 9.38531682e-02f, -7.65195042e-02f,
  7.61914700e-02f, -8.59724954e-02f, -4.59105410e-02f, 2.15274077e-02f, 8.35821778e-02f, 2.53774188e-02f, 1.26142368e-01f, 1.14313535e-01f, -1.00500658e-02f, 5.83321303e-02f,
  1.49989715e-02f, 8.38341638e-02f, -3.31214257e-02f, 1.73569582e-02f, -6.01529703e-03f, -6.74654590e-03f, -4.23913263e-02f, -4.63039540e-02f, 6.47464469e-02f, 4.35527377e-02f,
  -9.78001803e-02f, 2.04926860e-02f, 6.83200210e-02f, -6.97851032e-02f, 2.45940574e-02f, 4.42273133e-02f, 5.48216961e-02f, 3.53946462e-02f, 1.70596428e-02f, -9.49704275e-02f,
  1.48517966e-01f, 1.92335933e-01f, -1.28458701e-02f, 4.62194830e-02f, 8.39082152e-02f, -1.16328686e-01f, 8.60378798e-03f, 8.41886736e-03f, 3.47240865e-02f, 9.17183459e-02f,
  -1.75834969e-02f, -1.65010337e-02f, 8.87489319e-02f, 1.35273591e-01f, 3.04933358e-03f, -7.44021833e-02f, -3.95098105e-02f, -9.29694772e-02f, 1.06083006e-01f, 3.13185230e-02f,
  2.00362280e-01f, 2.92610407e-01f, 2.53323913e-01f, 2.99205869e-01f, -1.93092018e-01f, -3.29964548e-01f, -2.99336076e-01f, 1.47977799e-01f, -4.25616577e-02f, -1.28389567e-01f,
  4.72226441e-02f, 4.37172800e-02f, 2.96016410e-03f, 1.76839054e-01f, 3.51138681e-01f, -4.76022018e-03f, 2.77304560e-01f, -4.93642017e-02f, 2.30162777e-02f, 2.91972697e-01f,
  2.70182014e-01f, 2.46049970e-01f, 3.11381072e-01f, 2.22981870e-01f, 5.13940789e-02f, 1.67875752e-01f, 2.08774775e-01f, -7.40629211e-02f, 1.90480366e-01f, -4.30367328e-03f,
  -1.17233947e-01f, 1.16454646e-01f, -2.96279099e-02f, -5.46821579e-02f, 5.52745722e-02f, -6.00004643e-02f, -8.27859193e-02f, -2.59837750e-02f, -1.04334489e-01f, 8.15541833e-04f,
  2.16310546e-02f, -7.71613643e-02f, 1.49517125e-02f, 8.13664943e-02f, -4.97707166e-02f, 3.30500752e-02f, 7.68028647e-02f, -4.30675149e-02f, 3.47801261e-02f, 1.15416415e-01f,
  3.88590409e-03f, -7.34056905e-02f, 9.48732272e-02f, 4.96340841e-02f, -6.97688025e-04f, -3.26394811e-02f, -3.19800638e-02f, 9.79225412e-02f, -1.87307335e-02f, 1.02498837e-01f,
  7.02995807e-02f, -7.52364174e-02f, -9.00920630e-02f, -4.46870551e-02f, 8.82543623e-04f, -7.65684694e-02f, -6.77410886e-02f, 1.82572601e-03f, -2.15096287e-02f, 5.33119440e-02f,
  -2.75841877e-02f, -2.28021648e-02f, -8.31223726e-02f, -2.96087135e-02f, 4.93582673e-02f, -9.91509296e-03f, -2.44750101e-02f, -6.90394565e-02f, -3.94207938e-03f, -2.53949072e-02f,
  -5.94541058e-02f, -2.91552227e-02f, -9.88908485e-02f, -5.67633808e-02f, -9.93316025e-02f, 1.10064149e-01f, 6.16907366e-02f, 5.69455419e-03f, -1.70735382e-02f, 2.32257992e-02f,
  8.47360566e-02f, 4.25904363e-01f, -1.52990194e-02f, -1.71298623e-01f, 3.95779982e-02f, 6.46038502e-02f, 9.57952254e-03f, 1.05580293e-01f, 5.71377389e-02f, 7.57692307e-02f,
  1.30137175e-01f, -1.79486051e-01f, -1.00329228e-01f, 3.36804660e-03f, 3.76872234e-02f, 1.22200646e-01f, 3.75486948e-02f, -3.97384092e-02f, 1.48967430e-01f, 1.69232756e-01f,
  7.58729130e-02f, -3.45186926e-02f, 8.86765122e-02f, -6.98713288e-02f, 8.71048793e-02f, 8.04908946e-03f, -6.45815060e-02f, -2.77016442e-02f, 1.29172713e-01f, 2.61035655e-02f,
  -8.98082912e-01f, 3.11472237e-01f, -4.52633239e-02f, 3.70310172e-02f, -1.77621633e-01f, 1.81787863e-01f, 2.71806329e-01f, 1.06995620e-01f, 6.38780370e-02f, 2.51860470e-01f,
  -4.00366122e-03f, -5.55564985e-02f, 1.18697740e-01f, 2.53213882e-01f, -2.20227942e-01f, 2.18431577e-01f, 8.82622823e-02f, 9.15525928e-02f, 4.49268855e-02f, -8.48012418e-02f,
  -5.00943102e-02f, 4.15990874e-02f, -4.42309938e-02f, 5.26379868e-02f, -2.38517657e-01f, -1.07124388e-01f, -1.16509259e-01f, 3.34630199e-02f, 7.66179115e-02f, 6.74801990e-02f,
  -2.35153764e-01f, -1.87316626e-01f, -3.23796868e-01f, -2.26802990e-01f, -1.80084869e-01f, -4.89232466e-02f, -9.05873850e-02f, -8.38626642e-03f, -6.03697561e-02f, 8.45835358e-02f,
  1.16080996e-02f, -1.49057552e-01f, 8.45666006e-02f, -2.06613746e-02f, -4.82000411e-03f, -6.57998547e-02f, -1.33277783e-02f, 6.87860921e-02f, -7.19829090e-03f, 6.79920390e-02f,
  3.35250096e-03f, -1.08630415e-02f, 2.69534495e-02f, 8.81104991e-02f, -3.43919173e-03f, 1.03635207e-01f, 5.22487387e-02f, -8.76984652e-03f, -1.34662643e-01f, -3.96077521e-02f,
  1.17039181e-01f, -4.07071523e-02f, 3.81244011e-02f, 2.31464431e-02f, 4.45334911e-02f, -6.20690398e-02f, -2.67634559e-02f, -1.24025479e-01f, 4.66343686e-02f, -4.31978367e-02f,
  -6.29583746e-02f, -1.36760389e-02f, -9.67753530e-02f, -7.43229641e-03f, 1.49727792e-01f, 5.72742149e-03f, 2.35332139e-02f, -9.68732759e-02f, 8.97079483e-02f, -2.01527029e-02f,
  2.10289657e-02f, 8.99788272e-03f, 1.01381898e-01f, 1.48091018e-02f, -2.39523575e-02f, -1.69862211e-02f, -2.62243021e-03f, 5.25905229e-02f, 5.87536618e-02f, -6.72868686e-03f,
  -2.98880816e-01f, -3.33487868e-01f, -7.20118731e-02f, -1.38773724e-01f, -1.79100066e-01f, -5.62338792e-02f, 4.40837396e-03f, -8.79099965e-02f, -6.10696003e-02f, -9.71490517e-02f,
  -2.16534510e-02f, -9.38177183e-02f, -1.04380831e-01f, 5.69702275e-02f, 5.23193590e-02f, -1.16247488e-02f, -1.99292451e-02f, 5.41427173e-03f, -1.09758660e-01f, 7.34150931e-02f,
  -1.83493234e-02f, 1.09031179e-03f, 1.14310332e-01f, 9.62446183e-02f, 1.27591460e-03f, -1.85177103e-02f, -1.01022787e-01f, 8.70497227e-02f, -1.20906457e-01f, 4.55202647e-02f,
  3.60415637e-01f, 2.48342976e-01f, 1.91821232e-01f, 3.93255614e-02f, -2.57834673e-01f, -1.25073552e-01f, -7.01394901e-02f, -1.01245910e-01f, 6.71529397e-02f, 1.62733212e-01f,
  -2.84840971e-01f, 5.12525141e-01f, -1.66459754e-01f, -1.24316271e-02f, -4.47724134e-01f, -3.37791145e-01f, -1.29812015e-02f, 1.62410870e-01f, -8.11874121e-02f, 4.68957350e-02f,
  -1.49735793e-01f, -4.48361009e-01f, -1.53400466e-01f, -2.74065644e-01f, 2.09246010e-01f, 2.34368727e-01f, -2.14483425e-01f, -1.68795556e-01f, 2.33319178e-01f, -1.77283853e-01f,
  -4.18830570e-03f, -4.59393300e-02f, 1.24693736e-01f, 8.23808834e-03f, 3.78558859e-02f, 7.53824636e-02f, 8.39201361e-03f, -1.17859341e-01f, -6.78715929e-02f, 3.45235951e-02f,
  7.12759346e-02f, -7.10304976e-02f, 1.94629803e-02f, -9.11031812e-02f, -3.39288190e-02f, 5.30785881e-03f, 6.75868243e-02f, 6.30202964e-02f, 4.92143780e-02f, 1.48698211e-01f,
  1.56764269e-01f, 3.56688052e-02f, 1.02513567e-01f, 3.47823948e-02f, 4.39028852e-02f, 2.79982053e-02f, 3.28396410e-02f, 6.59876391e-02f, 4.85204495e-02f, 9.35263708e-02f,
  2.86313128e-02f, -1.54102668e-01f, -1.10032916e-01f, 3.86467651e-02f, -6.58557266e-02f, -6.57862723e-02f, -7.54111558e-02f, -2.23274529e-02f, 9.25678015e-02f, -3.29310969e-02f,
  -8.04093480e-02f, 1.06625520e-01f, -1.17875583e-01f, 3.67338844e-02f, 7.48680532e-02f, 6.19744696e-02f, -1.18236216e-02f, -9.48702742e-04f, 4.38200682e-02f, -1.95888989e-02f,
  -1.01160817e-01f, -1.09985180e-01f, 9.10110399e-02f, -7.06521655e-03f, -8.77942145e-02f, -9.56478566e-02f, 9.48041379e-02f, 1.08112335e-01f, -2.58724187e-02f, -3.60077508e-02f,
  -3.00313216e-02f, -8.82279128e-02f, 1.03760965e-01f, -5.75324893e-02f, -9.23480541e-02f, 4.14786749e-02f, -1.58810109e-01f, 8.16693902e-02f, 1.74747910e-02f, -5.29473685e-02f,
  1.40621122e-02f, 4.36976068e-02f, -4.68306392e-02f, -4.06090729e-02f, -7.48991268e-04f, 2.55926996e-02f, 8.51187333e-02f, -1.15570780e-02f, -1.25258910e-02f, 7.54384100e-02f,
  -6.02927757e-04f, -9.34093166e-03f, 3.97987142e-02f, -9.48581658e-03f, 4.65299040e-02f, 7.43260160e-02f, 2.13558102e-04f, 1.31010503e-01f, -2.44452059e-02f, -1.46639813e-02f,
  2.38740653e-01f, 7.20434263e-02f, -9.49446782e-02f, 2.12176174e-01f, 1.00770287e-01f, 2.16617182e-01f, 2.28399083e-01f, 1.10505164e-01f, 5.03167927e-01f, -3.51439528e-02f,
  -4.81147552e-03f, -1.94690824e-02f, 4.08105738e-02f, -6.97377771e-02f, 2.34793425e-02f, 2.25645334e-01f, 1.89030483e-01f, 1.05476476e-01f, 2.72413254e-01f, 1.82639901e-02f,
  6.43491969e-02f, 1.48279015e-02f, -3.53045642e-01f, -2.02138841e-01f, -2.70232648e-01f, -2.37293527e-01f, -4.57690269e-01f, -2.00902581e-01f, -2.69694090e-01f, -5.91443330e-02f,
  8.66656099e-03f, 1.23530321e-01f, -1.63805142e-01f, 1.32215712e-02f, 9.30134580e-03f, 2.28146296e-02f, -4.83429544e-02f, -2.74525136e-02f, 9.08274055e-02f, 1.46083876e-01f,
  1.24287158e-01f, 9.48985144e-02f, 9.58703160e-02f, -4.84606102e-02f, -1.00486036e-02f, -2.98926588e-02f, 7.37725347e-02f, -8.21705237e-02f, -6.84323907e-02f, -7.03405291e-02f,
  -1.14131726e-01f, -6.24541640e-02f, 3.96582037e-02f, -1.15355281e-02f, -4.78069447e-02f, 1.04389749e-01f, 4.61250171e-02f, -7.38894567e-02f, -7.37914443e-02f, 1.05695024e-01f,
  2.41681617e-02f, 7.63247386e-02f, -4.81080003e-02f, 2.80278716e-02f, 1.51264761e-02f, -2.95347255e-02f, 4.74446565e-02f, -7.89889600e-03f, 1.86822966e-01f, -9.53604952e-02f,
  4.83368449e-02f, 2.61274688e-02f, 7.46738091e-02f, -1.13187470e-02f, 8.59568045e-02f, -1.67895630e-02f, 4.31368314e-02f, 3.37577052e-02f, 9.08430964e-02f, -7.21549243e-02f,
  -1.16242969e-03f, 6.36649057e-02f, -7.81981349e-02f, -2.76535936e-02f, -3.13680321e-02f, 1.48005277e-01f, 5.74002527e-02f, -3.64208557e-02f, -8.91750082e-02f, 1.59188900e-02f,
  1.09750777e-01f, 2.71667778e-01f, 1.38735548e-02f, -2.27649417e-03f, 1.68059021e-02f, 2.56402008e-02f, 1.28567874e-01f, 7.55936801e-02f, 8.25052410e-02f, 1.31747693e-01f,
  1.45773450e-02f, 2.42337175e-02f, -8.00149664e-02f, -4.90811393e-02f, -4.94480953e-02f, -5.97014986e-02f, 9.74317342e-02f, 4.43999097e-02f, -6.25672489e-02f, -1.91584148e-03f,
  -1.12800315e-01f, 3.58651318e-02f, 1.03992008e-01f, 7.28368014e-02f, 4.85582426e-02f, -7.29202256e-02f, -7.62442276e-02f, -4.01305892e-02f, 7.12005422e-02f, 2.47619469e-02f,
  -7.55691305e-02f, 4.04720902e-01f, 2.55327504e-02f, -1.50948241e-01f, -1.42828763e-01f, 4.73471433e-01f, 1.68916389e-01f, 5.51729463e-02f, -1.31788716e-01f, 9.58937481e-02f,
  -1.53096303e-01f, -1.98434740e-01f, 8.16735625e-02f, 1.80792972e-01f, 1.90745771e-01f, 3.32887799e-01f, 6.49582148e-02f, 7.09507391e-02f, 1.48598120e-01f, 1.17049012e-02f,
  1.08724348e-02f, 1.88860938e-01f, 2.14115694e-01f, 1.32255688e-01f, 2.35982835e-02f, -4.22107428e-02f, -8.01253840e-02f, -7.60664716e-02f, -1.07303716e-01f, -1.71867926e-02f,
  2.11672887e-01f, -7.44334310e-02f, 4.16045636e-02f, 2.66648829e-02f, 1.14335835e-01f, 4.42904010e-02f, 3.28523517e-02f, 8.18914101e-02f, -1.14450425e-01f, -4.36110906e-02f,
  -8.85717273e-02f, -6.22557439e-02f, 6.69440255e-02f, -1.71338886e-01f, -1.06217481e-01f, -9.56836864e-02f, -4.88646515e-03f, -2.70858128e-02f, -1.12720975e-03f, 7.71133751e-02f,
  7.07106814e-02f, 1.04465172e-01f, -1.55672938e-01f, -2.93630525e-03f, -7.54014850e-02f, -3.39681879e-02f, 7.92023167e-02f, 1.00720406e-01f, 6.40958548e-02f, -4.26863171e-02f,
  6.74974620e-02f, 4.29185703e-02f, 7.69524276e-02f, 1.85501913e-03f, 7.10490048e-02f, -2.06106417e-02f, -1.71403602e-01f, 3.12543772e-02f, -3.73568609e-02f, 3.04109287e-02f,
  -5.19500598e-02f, -1.01190247e-01f, -1.33185349e-02f, -2.93775983e-02f, -8.86980444e-02f, 2.04301570e-02f, -7.03386664e-02f, -1.38220992e-02f, -2.96490733e-02f, 9.92936343e-02f,
  -1.35818934e-02f, 2.35137786e-03f, 7.23942146e-02f, -8.30737054e-02f, 8.61310214e-02f, -3.61876860e-02f, -1.56314135e-01f, -2.30256617e-02f, 2.43111216e-02f, -8.61291513e-02f,
  1.40263006e-01f, 5.99844828e-02f, -8.13545100e-03f, -4.62934934e-02f, 1.23155005e-02f, 4.50580344e-02f, 1.07915774e-01f, 5.98756857e-02f, -1.00602731e-01f, 4.92192134e-02f,
  1.24735537e-03f, -2.29682140e-02f, 7.33582722e-03f, -1.24887444e-01f, -2.18880698e-01f, 1.71546087e-01f, 1.97992325e-02f, -4.85356376e-02f, -1.26828954e-01f, -8.68316144e-02f,
  -7.92054087e-03f, -3.34624350e-02f, 5.63722327e-02f, -3.66628580e-02f, -1.45047689e-02f, -1.32605702e-01f, 1.14576846e-01f, -1.00215655e-02f, -2.26479433e-02f, -9.12464783e-02f,
  -4.65436637e-01f, 3.18160594e-01f, 3.49780232e-01f, -3.27832878e-01f, 1.26750663e-01f, 2.71627277e-01f, -1.55542076e-01f, 3.18877876e-01f, 6.48801848e-02f, 4.02868278e-02f,
  -1.20008260e-01f, 2.15172954e-02f, 3.55515555e-02f, -6.05426431e-02f, -6.09905645e-02f, -8.66435394e-02f, -1.47715271e-01f, -1.52361736e-01f, 3.73581145e-03f, -8.71003047e-02f,
  3.74551415e-02f, -2.83448845e-01f, -7.78024644e-03f, 1.83235824e-01f, 4.77385670e-02f, 1.13245949e-01f, -1.61271036e-01f, 8.63951743e-02f, 5.96923232e-02f, 6.94870055e-02f,
  5.05758263e-02f, 3.77048142e-02f, -6.80201547e-03f, 1.26327783e-01f, 1.22643700e-02f, 8.20273068e-03f, 4.88178991e-02f, 9.98555799e-04f, -1.08698957e-01f, 1.31209403e-01f,
  -4.05221023e-02f, 1.33773208e-01f, -1.20115362e-01f, 5.53269088e-02f, 1.60280958e-01f, 1.13968417e-01f, 4.18117419e-02f, 1.68120056e-01f, 1.10063612e-01f, 2.02820674e-01f,
  1.51527748e-01f, 1.61213338e-01f, 2.54895072e-02f, 1.00349672e-02f, 5.28191291e-02f, -6.39754981e-02f, 3.64301205e-02f, 8.69449079e-02f, -4.74671535e-02f, -1.25452757e-01f,
  -5.56727685e-02f, -1.02593087e-01f, 2.06971336e-02f, -1.75834494e-03f, -3.33554558e-02f, 9.07663181e-02f, 8.92110262e-03f, -1.34283885e-01f, 4.22322601e-02f, 8.93937889e-03f,
  -8.12256634e-02f, -9.69940498e-02f, 1.42571852e-02f, 1.16424382e-01f, -3.12547497e-02f, 2.65168492e-02f, -1.34166155e-03f, 2.79123872e-03f, -4.70330901e-02f, -6.83137551e-02f,
  -1.92742154e-03f, -8.09171125e-02f, -9.45102945e-02f, -8.47635418e-02f, 1.03697553e-01f, 4.72628474e-02f, 1.22221656e-01f, 1.62974611e-01f, -1.14527248e-01f, -5.62409572e-02f,
  -1.01246476e-01f, -1.72901630e-01f, -9.85831842e-02f, 6.50643036e-02f, -1.38801932e-02f, 3.83695103e-02f, -5.47640324e-02f, -4.07949090e-02f, -5.60106151e-02f, 2.88267955e-02f,
  1.08347878e-01f, -5.39168231e-02f, -8.95962343e-02f, 8.48100260e-02f, -3.76211777e-02f, 1.64565537e-02f, -1.64855063e-01f, -7.47884214e-02f, 3.74086527e-03f, 1.05673224e-01f,
  8.05796087e-02f, -7.12025762e-02f, -3.25140022e-02f, -1.42439649e-01f, -8.89282227e-02f, -4.01155986e-02f, -8.58348981e-02f, 5.63151576e-02f, -3.58543694e-02f, -1.19519919e-01f,
  -2.88511872e-01f, 1.32135212e-01f, -1.91735268e-01f, -1.39011294e-01f, 5.97003140e-02f, -3.96985829e-01f, -1.01646535e-01f, 7.02157915e-02f, -2.57025622e-02f, 2.71080494e-01f,
  -2.66685113e-02f, 5.12549952e-02f, 9.46055055e-02f, -4.27516788e-01f, -6.28864288e-01f, -2.64889091e-01f, -2.49490574e-01f, -1.57636672e-01f, -3.20941657e-02f, 7.13292137e-02f,
  -1.75852463e-01f, -1.97457448e-01f, -2.66176194e-01f, 1.30184218e-01f, -1.68998297e-02f, 2.00483680e-01f, 1.89347118e-01f, 1.28537476e-01f, 8.80479887e-02f, -1.15009405e-01f,
  -1.21036522e-01f, 1.37153745e-01f, 1.36614278e-01f, -6.41507283e-02f, 7.25165159e-02f, 9.32494178e-02f, 3.01593561e-02f, -8.00768882e-02f, -3.92374732e-02f, 1.66970640e-02f,
  7.29793981e-02f, 3.35081071e-02f, -1.27261234e-02f, 4.04687636e-02f, 5.92189729e-02f, -1.00799777e-01f, 3.73490937e-02f, 2.43846420e-03f, -2.03795619e-02f, -1.10456400e-01f,
  -1.53680332e-02f, -3.09909452e-02f, 4.56978045e-02f, 8.38473886e-02f, -2.53877342e-02f, 6.95129484e-02f, 1.60729513e-02f, 7.74678290e-02f, -1.63186453e-02f, 8.99101608e-04f,
  1.02535613e-01f, -7.69734308e-02f, -1.19264431e-01f, -7.02314526e-02f, 9.98341595e-04f, 4.77455184e-02f, 2.21946631e-02f, 8.89711827e-02f, 1.32090867e-01f, -3.18850055e-02f,
  1.74845122e-02f, -1.22979060e-02f, -9.57011897e-03f, 2.43792627e-02f, 7.85773247e-02f, -5.68629801e-02f, 6.69663250e-02f, 2.06374750e-02f, -1.02886800e-02f, -8.55292305e-02f,
  3.81310247e-02f, -5.37602380e-02f, 1.03709204e-02f, 6.52456805e-02f, -1.40884057e-01f, -1.78870801e-02f, 7.17561245e-02f, -4.64840718e-02f, -3.47310230e-02f, 4.30228412e-02f,
  1.02499567e-01f, 1.85601935e-01f, 5.11317253e-02f, 3.24332826e-02f, 1.66987944e-02f, -1.79150980e-02f, -1.11749813e-01f, -3.17730419e-02f, 3.97352315e-02f, 2.36024894e-02f,
  -2.13849219e-03f, 7.30326548e-02f, 6.90387413e-02f, 7.36940745e-03f, 8.87121782e-02f, -7.47348517e-02f, 9.82569456e-02f, 1.09272271e-01f, 1.69374540e-01f, -4.48825210e-03f,
  5.62863052e-02f, 4.83510643e-02f, 4.50769067e-02f, 5.94472848e-02f, 1.26912996e-01f, 1.31144851e-01f, -9.34468880e-02f, 6.70348108e-02f, 1.28753796e-01f, 1.38239652e-01f,
  -7.62985647e-02f, -2.88781859e-02f, -1.70799047e-01f, -2.60459155e-01f, 1.30022420e-02f, -2.73548871e-01f, -3.53312731e-01f, -4.18262668e-02f, -1.71251997e-01f, 1.69203997e-01f,
  -9.49190408e-02f, -1.05172366e-01f, 1.81402445e-01f, -3.33353549e-01f, -4.03867453e-01f, -1.49310930e-02f, -3.59755427e-01f, -1.21359147e-01f, -1.27721597e-02f, 1.68489534e-02f,
  -9.71677154e-02f, -2.03377753e-01f, -1.15810685e-01f, 2.79217232e-02f, -1.96060464e-01f, 1.02327242e-01f, 1.88847855e-01f, 4.05655727e-02f, -1.43554389e-01f, -2.13459022e-02f,
  -3.40127312e-02f, 3.66618261e-02f, -6.82806373e-02f, 3.23088281e-02f, 2.77674813e-02f, 3.27966921e-02f, 7.80146569e-02f, -2.01876890e-02f, -2.40875091e-02f, -8.63952413e-02f,
  -2.34809555e-02f, 4.19378281e-02f, -3.00792251e-02f, -3.10623888e-02f, -1.46998418e-02f, -8.71780664e-02f, -1.07463546e-01f, 2.33760346e-02f, -4.85677719e-02f, 1.21704405e-02f,
  -1.14412412e-01f, 2.70548966e-02f, -1.09009519e-01f, 1.06896767e-02f, -5.87147139e-02f, -1.20697506e-02f, -4.55079041e-02f, 5.72924912e-02f, -1.82208400e-02f, -4.45605330e-02f,
  5.50828539e-02f, -5.55711985e-02f, -1.21568508e-01f, -1.14546269e-01f, -6.49828464e-02f, 4.14437465e-02f, -1.28571078e-01f, 4.78101745e-02f, 3.28170951e-03f, -6.34690523e-02f,
  -2.41023488e-02f, -1.19909100e-01f, 3.01040504e-02f, -1.02811716e-02f, -7.11838454e-02f, 1.16998330e-01f, -6.38226867e-02f, -1.77298039e-02f, -9.68338847e-02f, -1.06707864e-01f,
  -9.23162419e-03f, -4.45809588e-02f, -7.84255415e-02f, 5.56267276e-02f, -7.18092248e-02f, -3.74233574e-02f, -4.55919951e-02f, -2.84533966e-02f, 4.55984175e-02f, -2.93667708e-02f,
  5.61812483e-02f, 3.40132341e-02f, -4.99444269e-02f, -2.81275180e-03f, -1.55917238e-02f, -2.89569069e-02f, -1.71007961e-02f, -8.92688110e-02f, 2.73041744e-02f, -8.02843347e-02f,
  9.82522219e-03f, -1.52871972e-02f, 1.19450442e-01f, -2.38137841e-02f, -1.45285368e-01f, -1.19725183e-01f, -1.22849568e-04f, 3.70794758e-02f, -1.44895143e-03f, 1.73102797e-03f,
  2.10206918e-02f, 7.80136185e-03f, -8.32975283e-02f, -7.03417361e-02f, 2.71398053e-02f, 6.13518469e-02f, 5.36241718e-02f, 7.00223669e-02f, 4.40401435e-02f, -2.87498310e-02f,
  2.39211932e-01f, -1.00149125e-01f, -4.22762819e-02f, 6.88358918e-02f, 1.01341508e-01f, 2.03547224e-01f, 1.17172994e-01f, -1.06777318e-01f, -4.27829057e-01f, -1.33403122e-01f,
  7.58798942e-02f, 1.43663436e-02f, -1.19662672e-01f, 3.03982258e-01f, 4.51381117e-01f, -1.05963349e-01f, 1.28817320e-01f, 1.60085157e-01f, -1.43939897e-01f, 1.19341657e-01f,
  2.26523709e-02f, 3.62920851e-01f, 8.08250308e-02f, 3.76003385e-02f, 2.20280200e-01f, -1.59368396e-01f, 1.67396665e-01f, -2.17765458e-02f, 1.74247190e-01f, 2.73783833e-01f,
  3.98973972e-02f, -2.40799859e-02f, -5.60193583e-02f, -1.42138265e-02f, 3.94500718e-02f, 7.20173568e-02f, 9.60854292e-02f, 2.55349040e-01f, -1.72242019e-02f, -6.32434338e-02f,
  1.16996877e-01f, 2.56378204e-02f, 6.04463965e-02f, 4.02674004e-02f, 2.89003663e-02f, -3.54798958e-02f, -2.26047114e-01f, -4.02867869e-02f, -1.25370666e-01f, 9.59308594e-02f,
  -6.58953637e-02f, 9.36927423e-02f, -1.29583515e-02f, -6.46712556e-02f, -1.21101752e-01f, -5.39758690e-02f, -5.66477552e-02f, 3.76218967e-02f, 1.03267603e-01f, -5.43784630e-03f,
  1.34214327e-01f, 1.46363126e-02f, 7.72086754e-02f, 3.54761109e-02f, -2.25785188e-02f, -3.59599255e-02f, 1.66322067e-02f, -3.87543775e-02f, -6.78969324e-02f, -1.27244592e-02f,
  -7.34275952e-02f, -4.20824029e-02f, 1.34390499e-02f, 1.56566512e-03f, 3.28275971e-02f, 4.31761704e-02f, 1.36030748e-01f, 5.83885610e-02f, -1.78172424e-01f, -1.94907486e-02f,
  6.38494194e-02f, -8.53092317e-03f, -7.63764083e-02f, -7.68314004e-02f, 3.23434696e-02f, 3.92676555e-02f, 7.92350397e-02f, -4.66859974e-02f, -6.50838464e-02f, 1.28132418e-01f,
  -1.07646338e-03f, 6.18956760e-02f, -1.34047851e-01f, 6.25455528e-02f, -1.20391093e-01f, 5.68153597e-02f, 6.12857081e-02f, 3.40159424e-02f, 5.06529177e-05f, 4.00033258e-02f,
  1.27682492e-01f, -4.26777862e-02f, -2.58410443e-02f, -2.01613065e-02f, 1.60464682e-02f, -1.06822267e-01f, -1.00860722e-01f, -1.17285237e-01f, -1.40133560e-01f, 4.19878215e-02f,
  1.59188043e-02f, -1.44380908e-02f, 1.04847856e-01f, -1.26633774e-02f, -9.75448042e-02f, -1.73637681e-02f, 1.48041882e-02f, -6.75436109e-02f, 1.14471078e-01f, -5.83817996e-02f,
  1.13263704e-01f, -7.65947625e-02f, -1.05409577e-01f, -2.56688267e-01f, -9.06880051e-02f, -1.98144883e-01f, -2.13719964e-01f, -8.90181661e-02f, -2.86188703e-02f, -3.30844559e-02f,
  -1.55419469e-01f, 1.58207074e-01f, 6.14560656e-02f, -3.10037822e-01f, 3.98119748e-01f, 3.31262469e-01f, -2.11843103e-01f, -1.46703705e-01f, -9.68568213e-03f, -2.80848861e-01f,
  -1.23125382e-01f, -2.72834182e-01f, 2.04383433e-02f, -2.46055782e-01f, -3.97946298e-01f, -9.26163122e-02f, 2.65454454e-03f, -2.45227948e-01f, -1.51764080e-01f, -1.15938202e-01f,
  -7.31180385e-02f, -2.27818694e-02f, 1.82351954e-02f, 4.44645323e-02f, -1.00594498e-01f, -2.88319718e-02f, -1.05088681e-01f, 2.26077880e-03f, -1.81546638e-04f, -7.36742187e-03f,
  -4.57136221e-02f, 7.97049999e-02f, -1.72678418e-02f, 3.02105211e-02f, -1.35106564e-01f, -5.21806069e-02f, 2.79973261e-03f, 5.76475030e-03f, 5.76659478e-03f, 3.84579897e-02f,
  -5.16820736e-02f, -2.76957564e-02f, -6.30123019e-02f, 8.66033975e-03f, 1.34771317e-02f, -3.16919461e-02f, 1.42417341e-01f, 7.27706477e-02f, 4.95544577e-04f, -5.60825737e-03f,
  -8.51293951e-02f, -1.24864001e-02f, 3.82889397e-02f, -1.49200317e-02f, 4.81944084e-02f, -6.53621554e-02f, -2.91821081e-02f, 3.34880203e-02f, -3.09294518e-02f, -3.16256657e-02f,
  -2.90921633e-03f, -1.31351743e-02f, 7.19249323e-02f, -9.15969536e-02f, -5.79027981e-02f, 1.37380883e-01f, 1.04141973e-01f, -5.73443547e-02f, -9.39902961e-02f, 5.42527959e-02f,
  -2.43317336e-02f, 1.65685099e-02f, 2.06693285e-03f, -5.40277660e-02f, -1.15581937e-02f, 3.26794274e-02f, -7.73145780e-02f, 5.70413768e-02f, 6.19637594e-02f, -1.17002100e-01f,
  -4.84950319e-02f, -1.32978007e-01f, -1.99682247e-02f, -2.03543324e-02f, 3.53651457e-02f, -1.39427194e-02f, -1.29975230e-01f, -3.30954753e-02f, -1.10730730e-01f, 2.43258756e-02f,
  -1.30047947e-01f, -1.33632803e-02f, -7.70116076e-02f, -5.09033911e-02f, -5.60737997e-02f, -4.98108491e-02f, -1.54759744e-02f, 6.07623272e-02f, -8.28727428e-03f, 6.91457018e-02f,
  1.88115556e-02f, -4.08936962e-02f, -1.43966815e-02f, -2.15065219e-02f, -3.25691178e-02f, 2.40627918e-02f, 2.12112829e-01f, 6.46883063e-03f, -8.05723742e-02f, -5.82639761e-02f,
  -5.44321358e-01f, 3.36548805e-01f, -2.33731940e-01f, 6.48836792e-02f, 1.23512954e-01f, -3.58035773e-01f, 7.78500410e-03f, 1.53851777e-01f, -9.04658437e-02f, 2.35522285e-01f,
  2.76872337e-01f, -1.19186208e-01f, 2.31167376e-01f, 2.94096582e-02f, -5.10153055e-01f, -8.30798000e-02f, -1.56852648e-01f, -7.32353926e-02f, -2.94096079e-02f, 1.58546507e-01f,
  -1.36371642e-01f, 2.06495106e-01f, -1.83822706e-01f, 1.49822667e-01f, 1.09079301e-01f, -7.58087263e-03f, 2.02198327e-01f, 6.28538281e-02f, 1.70176420e-02f, -8.99777934e-02f,
  3.83952400e-03f, 2.04037473e-01f, 7.15538720e-03f, -7.47083202e-02f, -1.23499312e-01f, -5.87388203e-02f, 4.69925255e-02f, -5.35929501e-02f, -1.12692323e-02f, -2.36901715e-02f,
  -6.07718602e-02f, 8.93161818e-02f, 3.98914926e-02f, -6.95502833e-02f, -4.27866867e-03f, -4.69640680e-02f, -9.90831014e-03f, -6.32112101e-02f, 8.47290307e-02f, -4.22666743e-02f,
  -8.28916281e-02f, 3.52262184e-02f, -4.36161906e-02f, 3.12790163e-02f, -3.64785716e-02f, 1.82445273e-02f, -8.51158947e-02f, -1.14712548e-02f, 3.23711634e-02f, -1.17847018e-01f,
  -1.55692637e-01f, 8.42328463e-03f, 1.32224336e-02f, -1.24119353e-02f, 6.44177198e-02f, 7.96470977e-03f, -9.71343275e-03f, 3.53562422e-02f, -1.00548111e-01f, 2.29819659e-02f,
  2.74015069e-02f, 2.40496080e-03f, 6.96077049e-02f, -2.71702334e-02f, -4.83744815e-02f, 2.48284149e-03f, -1.32900625e-01f, 1.22476354e-01f, -7.80369118e-02f, -8.33201595e-03f,
  5.69402836e-02f, 3.29307020e-02f, -2.04659589e-02f, 9.72601175e-02f, 1.15241162e-01f, -2.51544304e-02f, 3.27137560e-02f, -3.56863998e-02f, -1.45027619e-02f, 3.36294645e-04f,
  9.08759609e-02f, 1.38612688e-01f, 9.65666249e-02f, 1.03959106e-02f, -3.45907770e-02f, 1.25909941e-02f, -9.41872597e-02f, -1.71814516e-01f, 4.29740064e-02f, 1.53220119e-03f,
  4.92443703e-03f, 8.85505527e-02f, -2.43929103e-02f, -5.83412014e-02f, -5.38255349e-02f, -1.06955236e-02f, 1.50854498e-01f, 3.08542829e-02f, 7.69754127e-02f, -1.93359330e-02f,
  1.24450773e-02f, 1.08046323e-01f, 4.14370708e-02f, 3.40701230e-02f, -1.76820457e-02f, 3.25745158e-02f, -6.11295365e-02f, 2.71982588e-02f, 9.50305462e-02f, -4.77044731e-02f,
  1.73248976e-01f, -1.55083597e-01f, -1.12224594e-01f, -1.29275948e-01f, -1.95397317e-01f, -1.10538542e-01f, -1.35789784e-02f, -1.99755967e-01f, 1.68584171e-03f, -7.92466998e-02f,
  -2.29792953e-01f, 2.29735225e-01f, 1.87801108e-01f, -3.61193866e-01f, 3.91362876e-01f, 3.99468243e-01f, -1.85435757e-01f, -1.67307351e-02f, -2.43455652e-04f, -2.36665815e-01f,
  -8.22123960e-02f, -1.97651699e-01f, -2.91880164e-02f, -2.02103823e-01f, -3.38109940e-01f, -1.86433434e-01f, -3.67822088e-02f, -2.47257635e-01f, -2.69262671e-01f, -8.92235562e-02f,
  -1.43116042e-01f, 2.88391393e-02f, -2.11388506e-02f, 4.85675633e-02f, -1.56342296e-03f, -1.32187391e-02f, -1.27257019e-01f, 6.92745894e-02f, -2.31865197e-02f, 2.75241192e-02f,
  1.11288689e-01f, 1.13857664e-01f, -6.59972206e-02f, 5.83399571e-02f, -1.17159300e-01f, -7.13862032e-02f, 8.39911774e-02f, -8.94599035e-02f, 4.31112386e-02f, 3.12606022e-02f,
  7.84832835e-02f, -6.14017919e-02f, 1.07699856e-02f, 2.33133864e-02f, 1.55870924e-02f, 4.06266116e-02f, 8.31106752e-02f, 2.62035858e-02f, -5.42464927e-02f, -3.26465629e-02f,
  3.25713307e-02f, 1.81021802e-02f, -5.74071258e-02f, -9.24827605e-02f, 3.64013277e-02f, -5.98202385e-02f, 3.95499207e-02f, 9.52687021e-03f, 5.96964322e-02f, -2.53969408e-03f,
  -6.14748523e-02f, -4.89818957e-03f, -4.67158062e-03f, -2.52976026e-02f, 4.14319756e-03f, 1.70401111e-02f, 2.90926192e-02f, -2.27036439e-02f, -1.32777095e-01f, -2.73269191e-02f,
  6.34498009e-03f, 1.34344632e-02f, 5.10039218e-02f, 1.67082418e-02f, 1.57974381e-02f, 6.73183650e-02f, -8.01912546e-02f, 7.44927456e-05f, -1.22808218e-01f, 3.87426640e-04f,
  -4.66473959e-02f, 3.52378115e-02f, 1.72443334e-02f, 1.19626798e-01f, 2.41527986e-03f, -5.21645769e-02f, -1.07087433e-01f, 7.78997410e-03f, 1.22277774e-02f, 4.89379019e-02f,
  -1.24360316e-01f, 8.40705037e-02f, -1.23903856e-01f, -6.84619918e-02f, -1.90118998e-02f, -1.09508626e-01f, 1.15246333e-01f, -3.56893428e-02f, 6.94230124e-02f, -3.92487124e-02f,
  7.77413920e-02f, 1.74669828e-02f, 2.08539248e-01f, 1.02154277e-01f, 8.86811018e-02f, 1.16842359e-01f, 7.15868026e-02f, 7.36100078e-02f, 8.96127596e-02f, -3.80646400e-02f,
  -2.61754036e-01f, 8.67408048e-03f, -3.45313191e-01f, 2.71462649e-02f, 1.37344301e-01f, 3.35047513e-01f, 2.16384023e-01f, 3.48021742e-03f, -1.81772634e-01f, 4.00607735e-01f,
  4.13153261e-01f, -1.47812441e-01f, 1.49231657e-01f, 4.89895195e-01f, 5.20848809e-03f, 1.16362169e-01f, 3.07264626e-01f, 1.96756348e-01f, -1.94060698e-01f, -1.29915429e-02f,
  -6.51572123e-02f, 2.76487708e-01f, 1.26887694e-01f, 7.86818005e-03f, 1.51240632e-01f, -1.55728415e-01f, 2.63706237e-01f, -7.56420568e-02f, 3.04186195e-01f, 7.18169659e-02f,
  8.71637315e-02f, -1.58354133e-01f, -3.18263695e-02f, -8.36552456e-02f, 4.50496674e-02f, 3.10855452e-02f, 7.84341246e-03f, -7.75910616e-02f, -3.44747305e-02f, -2.97677666e-02f,
  -1.31601393e-01f, -6.99449554e-02f, -3.05177402e-02f, -1.45546393e-02f, -8.74881744e-02f, -5.78859523e-02f, -7.58068403e-03f, 4.05942537e-02f, 4.90619242e-02f, 6.31781071e-02f,
  -3.65104713e-02f, -4.24978100e-02f, -1.44386692e-02f, 9.73595679e-03f, -3.97716500e-02f, -9.03141573e-02f, -1.12105079e-01f, -3.98164755e-03f, 4.05146629e-02f, -4.40031663e-02f,
  2.11828705e-02f, -6.11533560e-02f, 5.54510728e-02f, 9.67241824e-02f, -1.36585785e-02f, 4.84989174e-02f, 1.16394959e-01f, 1.00825079e-01f, -1.43276840e-01f, 1.37860194e-01f,
  -2.49193795e-02f, -7.04139844e-02f, 1.74445249e-02f, 1.33431926e-01f, 7.00168163e-02f, 9.04645696e-02f, -9.39382017e-02f, 1.35457963e-02f, 5.09473570e-02f, 3.93282250e-02f,
  1.33586735e-01f, -1.18132658e-01f, -4.81925858e-03f, 9.38021541e-02f, 3.17056812e-02f, -6.44282326e-02f, 1.10930055e-02f, 6.16992861e-02f, -3.19999680e-02f, -3.07829808e-02f,
  1.96988821e-01f, -5.99104613e-02f, -1.58045199e-02f, 9.30001400e-03f, -5.86996786e-02f, -2.21277541e-03f, -1.63650624e-02f, -9.33299735e-02f, -2.55939905e-02f, -1.02171630e-01f,
  -4.76248935e-02f, -7.49364644e-02f, 5.99320903e-02f, 1.05656952e-01f, -7.21935034e-02f, 3.44608426e-02f, 3.98250557e-02f, 8.55101645e-03f, 4.35533114e-02f, -6.15093159e-03f,
  -2.28167605e-02f, -5.30230738e-02f, -1.22765474e-01f, 3.24412175e-02f, 1.07423645e-02f, 9.30487216e-02f, -6.23708181e-02f, -2.89246347e-02f, 4.46910001e-02f, 5.26514463e-02f,
  -4.12075162e-01f, 1.08320557e-01f, -3.17883790e-01f, -7.03057274e-02f, 2.51730889e-01f, -1.49212927e-01f, -1.65949225e-01f, 1.75493620e-02f, -3.16785686e-02f, 2.18179792e-01f,
  8.35065991e-02f, -6.49130046e-02f, 1.01471916e-02f, -1.84157360e-02f, -3.70613724e-01f, -2.02172339e-01f, -1.21435687e-01f, -5.47221713e-02f, -1.02363519e-01f, -9.04180035e-02f,
  -1.72718957e-01f, 1.94970235e-01f, -2.62475610e-01f, 1.56043380e-01f, 1.88560337e-02f, -4.00089025e-02f, 2.51677245e-01f, -1.93213969e-02f, 1.28458858e-01f, 2.04306077e-02f,
  -6.86541721e-02f, 5.46046048e-02f, -3.34974527e-02f, 1.57324452e-04f, -2.82525662e-02f, -9.36626457e-03f, 3.57753634e-02f, -9.77511145e-03f, 1.16818016e-02f, -9.93969142e-02f,
  3.61952148e-02f, -9.99793783e-03f, -8.79486501e-02f, -2.67345738e-03f, 6.52916208e-02f, 1.56949297e-01f, -9.69031453e-02f, -1.57600138e-02f, -1.39514366e-02f, -8.84818956e-02f,
  -5.89084662e-02f, -4.09700908e-02f, -7.42102340e-02f, -1.44177733e-03f, 6.78891242e-02f, -4.51664403e-02f, 4.96079177e-02f, 7.05737472e-02f, 5.29330783e-03f, 8.36031660e-02f,
  5.59598170e-02f, -5.17135300e-02f, -1.25398552e-02f, 5.02542555e-02f, 9.66624394e-02f, 2.63327975e-02f, -1.15888290e-01f, 1.20179150e-02f, 4.14569825e-02f, 1.09955277e-02f,
  -3.20308730e-02f, -2.33369227e-02f, -2.33643651e-02f, 7.83252995e-03f, 4.13682610e-02f, -9.45872366e-02f, -1.39984697e-01f, 1.04487471e-01f, -4.90807332e-02f, 7.08089694e-02f,
  -2.91935764e-02f, 4.07970976e-03f, -8.85083154e-02f, -7.09101185e-02f, -7.91017041e-02f, 6.59377128e-03f, 1.19738206e-01f, -5.81960827e-02f, -1.02686472e-01f, 3.22654881e-02f,
  1.19969882e-01f, 1.58015534e-01f, -5.31465076e-02f, -8.98257457e-03f, -2.54207794e-02f, 2.07497217e-02f, 2.80522946e-02f, -3.27842683e-02f, 2.36521196e-02f, 2.68036537e-02f,
  2.19898522e-02f, -1.45369666e-02f, -2.07802504e-02f, -2.98623787e-03f, 9.03084315e-03f, 1.39154419e-01f, 1.78065579e-02f, 3.30484530e-04f, 2.14906447e-02f, 8.82658828e-03f,
  6.02683499e-02f, 4.67270501e-02f, -8.41604397e-02f, 1.24545239e-01f, 1.07015483e-01f, -5.33517674e-02f, 7.47406185e-02f, -1.68571025e-02f, 1.29760519e-01f, 1.06215812e-01f,
  2.81286538e-01f, 1.79589197e-01f, 1.97885394e-01f, 2.89705604e-01f, 6.94180280e-02f, 1.81379750e-01f, 1.65006727e-01f, 5.94611838e-02f, 5.05955994e-01f, 1.26673520e-01f,
  -2.30157226e-01f, 2.60066152e-01f, -1.75336093e-01f, 5.66615909e-02f, -2.46870875e-01f, 3.24287149e-03f, 2.05208644e-01f, 1.46609113e-01f, 2.41309941e-01f, 1.88229799e-01f,
  4.66607921e-02f, -2.57217526e-01f, -3.27837050e-01f, -2.38153875e-01f, -1.27443522e-01f, 1.32623225e-01f, -4.44556445e-01f, -1.71067566e-02f, -1.07109502e-01f, -7.47977048e-02f,
  -3.60180088e-03f, 2.75876727e-02f, -9.20689758e-03f, 2.12241486e-02f, 5.98243773e-02f, -2.33949143e-02f, 5.05233780e-02f, -2.83107292e-02f, -2.71198414e-02f, 3.09206974e-02f,
  1.62998512e-01f, 3.71936709e-02f, 7.69609213e-02f, -9.00956243e-02f, 2.51721870e-02f, -4.54105921e-02f, 1.13137409e-01f, 1.06541172e-01f, 4.71003540e-02f, -3.80290858e-02f,
  -3.30962278e-02f, -6.76101167e-03f, 1.84681132e-01f, 9.85101685e-02f, 2.04663463e-02f, 1.08249791e-01f, 7.32956454e-02f, 7.97458272e-03f, 4.84452490e-03f, 1.82465613e-01f,
  -5.69889247e-02f, 5.54804206e-02f, -4.76047695e-02f, -8.92075058e-03f, 6.14720257e-03f, 4.59279865e-02f, 9.46107060e-02f, 7.54918233e-02f, 1.63394213e-01f, 3.46382707e-02f,
  7.62897804e-02f, 2.12350246e-02f, 6.71879873e-02f, 6.19553290e-02f, 4.44683507e-02f, -5.35886623e-02f, 1.77317634e-02f, 5.01316786e-02f, 9.61994082e-02f, -4.84631285e-02f,
  -1.63974330e-01f, 2.73814537e-02f, -6.51928503e-03f, 1.15261097e-02f, -4.72343266e-02f, 4.74193171e-02f, -6.76016584e-02f, 2.36204639e-02f, -1.93763711e-02f, 4.78281155e-02f,
  9.06895101e-02f, 1.87831879e-01f, 7.70209283e-02f, 1.07032441e-01f, 5.71826808e-02f, 4.72376030e-03f, 3.72632481e-02f, 1.12406135e-01f, 4.21008319e-02f, 1.05321854e-02f,
  1.19303100e-01f, 1.02252752e-01f, -1.08790118e-02f, -5.19691594e-02f, -2.18573790e-02f, -3.26128341e-02f, 1.27453223e-01f, 3.79905775e-02f, 2.08935160e-02f, -2.48831287e-02f,
  -7.87332281e-02f, 1.12624608e-01f, 3.31889316e-02f, 5.99915795e-02f, 6.03729263e-02f, 4.28358987e-02f, 2.45150719e-02f, 4.33381600e-03f, 3.57267418e-04f, 1.01658441e-01f,
  -5.21062434e-01f, 3.20952415e-01f, 2.40559801e-01f, -3.72224361e-01f, 2.33559251e-01f, -1.32891938e-01f, -1.87767819e-01f, 2.96005577e-01f, -6.47650063e-02f, 8.01781043e-02f,
  1.08899966e-01f, -3.04285176e-02f, 2.50005066e-01f, -1.56230122e-01f, -2.57938474e-01f, 1.18685409e-01f, -3.79014462e-01f, -1.38536394e-01f, 8.98816362e-02f, 6.53941510e-03f,
  -1.81168556e-01f, -1.17744155e-01f, 8.80315304e-02f, 1.68641955e-01f, 1.33209080e-01f, 1.19617470e-01f, -3.30812961e-01f, 2.00943157e-01f, -1.10319398e-01f, 1.78710092e-02f,
  1.88708633e-01f, 1.96660399e-01f, 1.42911017e-01f, 7.32034519e-02f, 2.91572716e-02f, -7.33848810e-02f, -1.32897034e-01f, -6.56301081e-02f, 6.67152256e-02f, 5.85163059e-03f,
  -1.03828177e-01f, 2.04719491e-02f, 1.09232143e-02f, -3.28530557e-02f, -6.62075803e-02f, 2.52100695e-02f, 2.06679583e-01f, 1.40938871e-02f, 5.43283373e-02f, 7.41788968e-02f,
  6.65195435e-02f, 7.45087676e-03f, -1.44906238e-01f, -1.18185610e-01f, 9.82318446e-03f, 9.16753113e-02f, -8.97362158e-02f, -9.45499167e-02f, -4.42559272e-02f, -5.78957610e-02f,
  -1.23286180e-01f, -8.26528743e-02f, 2.06730491e-03f, 1.34299815e-01f, -4.17692447e-03f, 7.02173635e-02f, -5.98953106e-02f, 2.59158388e-02f, -2.67939940e-02f, -3.38113606e-02f,
  -1.89986192e-02f, 5.70326932e-02f, 9.21118166e-03f, -1.67319819e-01f, -8.83941203e-02f, -5.16564734e-02f, -7.77123421e-02f, 1.01506799e-01f, -1.19327232e-01f, 7.13878348e-02f,
  5.28176799e-02f, -3.91528681e-02f, 1.76512539e-01f, 5.34397364e-02f, 7.36941546e-02f, -9.74680483e-02f, -1.21590748e-01f, -4.08854894e-02f, 1.58440694e-01f, -1.73067391e-01f,
  -6.31877482e-02f, -1.54528856e-01f, 1.01376310e-01f, 1.44321799e-01f, 6.84769601e-02f, -1.50725739e-02f, -1.06343277e-01f, 2.75069829e-02f, -7.35165551e-02f, -1.02115832e-01f,
  -1.72927469e-01f, 4.83392738e-03f, -2.23684818e-01f, -3.06761488e-02f, -2.03524418e-02f, -1.57938972e-02f, -3.21777984e-02f, -3.56998369e-02f, -1.94351487e-05f, -4.72662784e-02f,
  -1.16224632e-01f, -4.06351909e-02f, -6.90230951e-02f, -6.75105229e-02f, -8.50517452e-02f, 2.64574145e-03f, -4.22218107e-02f, -8.26474950e-02f, 2.94849910e-02f, 2.67665796e-02f,
  2.37513930e-01f, -5.60494423e-01f, -3.24210703e-01f, 1.93270922e-01f, 2.99816757e-01f, 1.38549030e-01f, -2.91710794e-01f, 7.04251379e-02f, 1.35965109e-01f, -2.11235344e-01f,
  3.21183167e-02f, -2.14642525e-01f, -4.69504118e-01f, 2.65996188e-01f, 2.48085305e-01f, -3.00288886e-01f, 2.33324409e-01f, 9.82473269e-02f, 3.82942669e-02f, -1.31599814e-01f,
  1.58317104e-01f, 3.19202125e-01f, -1.28783688e-01f, 2.14068651e-01f, 6.23219125e-02f, -1.53329372e-01f, 7.18686953e-02f, -1.01821378e-01f, 2.33251691e-01f, 1.65649951e-01f,
  1.65257901e-02f, 8.43282882e-03f, 9.33842883e-02f, 1.23675123e-01f, -1.99693628e-02f, 3.01447660e-02f, -6.40588999e-02f, 3.30226007e-03f, 1.97130870e-02f, -3.60495858e-02f,
  -4.86046970e-02f, 3.83796915e-02f, 5.81379533e-02f, 4.17201221e-02f, 5.72743528e-02f, 1.13088965e-01f, -1.05894534e-02f, 4.80453335e-02f, -9.62743312e-02f, -1.49561688e-01f,
  -7.26518556e-02f, -5.16127236e-02f, -2.33248994e-02f, -4.81235515e-03f, -1.31633863e-01f, 2.41350587e-02f, -1.59062609e-01f, -1.45995617e-01f, 7.08613684e-03f, 5.57022467e-02f,
  -6.01861477e-02f, -1.70872286e-02f, -1.08756401e-01f, 1.30515397e-01f, -5.61143756e-02f, 6.40317425e-02f, 6.91423491e-02f, -1.03519417e-01f, -4.99298461e-02f, -4.53009866e-02f,
  3.31309363e-02f, 1.61732221e-03f, 1.81540176e-01f, 4.07224260e-02f, 3.98631915e-02f, 1.11211672e-01f, 9.02757049e-02f, -8.45742524e-02f, -5.27132442e-03f, 2.88991407e-02f,
  1.38223141e-01f, 6.55097589e-02f, -1.09829888e-01f, -9.39477906e-02f, 3.95272113e-02f, -9.67608243e-02f, 9.48430225e-02f, -4.82967794e-02f, 2.68661343e-02f, -5.92444688e-02f,
  -1.24819661e-02f, -4.02564108e-01f, -1.16077140e-01f, 5.19463643e-02f, -3.86581309e-02f, 8.05344582e-02f, 4.97665256e-02f, 5.81690017e-03f, 7.72952859e-04f, 2.81844251e-02f,
  -5.63980127e-03f, -1.10073738e-01f, 4.09480520e-02f, 1.42367527e-01f, 1.27329901e-01f, -1.16456531e-01f, -1.20276310e-01f, 9.91598889e-02f, 2.11239606e-02f, -4.74613011e-02f,
  -1.50216576e-02f, -1.66483790e-01f, 1.17140703e-01f, 1.69924032e-02f, -2.85465587e-02f, -7.20944256e-02f, 5.15036983e-03f, 2.99075060e-02f, -2.58806013e-02f, 9.83929262e-03f,
  1.28018141e-01f, -6.92248791e-02f, 2.02640817e-01f, 1.72005050e-04f, 3.18095356e-01f, 3.03421319e-01f, 2.68995911e-01f, 2.91817904e-01f, 4.54081297e-01f, -1.62435785e-01f,
  -1.28332049e-01f, -2.66900063e-01f, -1.40534163e-01f, -1.07398748e-01f, 2.62539238e-01f, 1.46388426e-01f, 2.69897908e-01f, -4.96976748e-02f, 1.88974872e-01f, -2.19733566e-01f,
  -1.26692936e-01f, -1.73551351e-01f, -2.57833093e-01f, -1.59484223e-01f, -2.01403767e-01f, -4.49663624e-02f, -2.81670183e-01f, 3.56490538e-02f, -3.23616296e-01f, 1.03037260e-01f,
  8.35897550e-02f, -1.42360076e-01f, -2.44734809e-02f, -5.82240289e-03f, 3.83795388e-02f, -2.86882911e-02f, -2.57808324e-02f, -8.86064023e-02f, 3.91815156e-02f, -1.42282039e-01f,
  -6.65359944e-02f, -9.50319320e-02f, -1.30498558e-01f, 9.11305472e-03f, 1.14208430e-01f, -6.66037276e-02f, -3.26998308e-02f, -1.76954195e-02f, 1.03997039e-02f, -3.82979885e-02f,
  -2.60355938e-02f, -1.06913194e-01f, 1.24972522e-01f, -1.85643546e-02f, -1.29168080e-02f, 3.18052098e-02f, -1.74767338e-02f, 6.89649284e-02f, -2.34508216e-02f, 6.30242079e-02f,
  -2.36545363e-03f, 1.09286830e-01f, -3.36748436e-02f, -9.69783142e-02f, 5.73727861e-02f, -3.10089323e-04f, 3.91596854e-02f, -6.69213980e-02f, 1.21059999e-01f, 6.21960610e-02f,
  6.38464466e-03f, 2.71073356e-02f, 1.59720734e-01f, 4.34359275e-02f, -3.09912711e-02f, 4.67699468e-02f, 4.69837431e-03f, -4.57417890e-02f, 2.41511408e-02f, 3.72350775e-02f,
  -3.39518487e-02f, 4.88743000e-02f, -4.82291020e-02f, -8.09145793e-02f, 2.43327562e-02f, -4.79892977e-02f, -7.54684359e-02f, -2.99425535e-02f, 8.49404559e-03f, -3.45040448e-02f,
  1.82909057e-01f, 6.69560134e-02f, -1.28301512e-02f, -1.53880775e-01f, 5.31540364e-02f, -8.21493566e-03f, -2.58478206e-02f, 6.56588450e-02f, 3.70628126e-02f, -8.66373554e-02f,
  -3.31695937e-02f, -1.27776474e-01f, -3.70595902e-02f, -8.52033123e-03f, 1.06758084e-02f, -5.96025586e-03f, -4.79325354e-02f, 5.28340228e-02f, 1.36309549e-01f, -5.68968169e-02f,
  -5.83252534e-02f, -6.25799298e-02f, 1.45913977e-02f, -1.25653110e-02f, -3.51822712e-02f, -6.32280484e-02f, -1.42736780e-02f, 2.02842187e-02f, -3.88642251e-02f, 4.45556343e-02f,
  1.67940021e-01f, -4.08995837e-01f, 2.01361105e-01f, -2.11308628e-01f, 2.02725157e-01f, 2.57342786e-01f, 3.70297760e-01f, -3.78611267e-01f, -3.34268570e-01f, -3.52119684e-01f,
  -1.94935706e-02f, 1.11930013e-01f, 2.75775611e-01f, -1.57535687e-01f, 5.88131130e-01f, -1.32208290e-02f, -2.60400772e-01f, 1.25012007e-02f, -1.57900959e-01f, 2.39994493e-03f,
  4.96389950e-03f, -1.48918808e-01f, 1.91640258e-01f, -3.09894413e-01f, 8.82054307e-03f, -2.22252190e-01f, 4.18025674e-03f, 3.06648940e-01f, -1.13058478e-01f, 1.52049392e-01f,
  -4.29478623e-02f, -1.36367381e-01f, 1.42121948e-02f, 1.36686098e-02f, 2.79691741e-02f, 1.11260824e-01f, 1.81611314e-01f, 2.66521454e-01f, -3.05132847e-02f, -8.56062099e-02f,
  1.94789600e-02f, -3.60119008e-02f, -1.57065257e-01f, 1.82506740e-01f, -5.71987182e-02f, -1.79097056e-01f, -9.19635445e-02f, -3.03269662e-02f, -9.23434421e-02f, 6.32014945e-02f,
  -6.95691723e-03f, -6.81660175e-02f, -7.54987523e-02f, -1.49759039e-01f, -4.72834334e-02f, -8.29763710e-02f, -1.65184662e-02f, 2.12540075e-01f, -1.10006534e-01f, -8.27283114e-02f,
  -8.89417306e-02f, 2.56203972e-02f, -5.65168150e-02f, -7.98732489e-02f, 8.08586739e-03f, -8.75383317e-02f, -3.69320549e-02f, -1.28349625e-02f, -4.81578230e-04f, -2.84920000e-02f,
  -7.57563114e-02f, -3.66277527e-03f, 8.47681519e-03f, -5.14265187e-02f, -1.95378792e-02f, -2.55453698e-02f, 1.83531731e-01f, 3.64894746e-03f, -2.59696366e-03f, 3.92234698e-02f,
  -7.31241256e-02f, -7.21307471e-02f, 3.34687345e-02f, -5.28532341e-02f, -8.23920891e-02f, 1.38176769e-01f, -1.52406007e-01f, -3.43231782e-02f, -2.85435710e-02f, 1.46171495e-01f,
  -2.73899268e-02f, -2.38739744e-01f, -3.22988108e-02f, -9.56232846e-02f, 7.62169361e-02f, 3.36304456e-02f, 5.42395748e-03f, -1.12995587e-01f, -5.28494045e-02f, -4.83064204e-02f,
  3.81483100e-02f, -3.99324931e-02f, -7.99031705e-02f, 8.74267593e-02f, -8.94080102e-02f, -9.48084742e-02f, -1.06290221e-01f, -2.87256557e-02f, -5.40374815e-02f, -5.35821058e-02f,
  -3.85616417e-03f, -1.15210064e-01f, 3.94099131e-02f, -1.35751992e-01f, -1.47965476e-01f, 4.57405411e-02f, 1.03392169e-01f, 4.48773727e-02f, -3.79514359e-02f, -7.07730949e-02f,
  -3.02973032e-01f, -3.88589618e-03f, -1.61290869e-01f, -4.08579201e-01f, 1.60107940e-01f, -3.23797554e-01f, -2.37511888e-01f, -1.15069501e-01f, -9.03616101e-02f, -1.96309730e-01f,
  -1.37271091e-01f, 4.48785014e-02f, 2.83099771e-01f, -3.08245152e-01f, 8.33356827e-02f, 1.53558403e-01f, -4.26861495e-01f, -2.09486559e-01f, 1.19499482e-01f, -1.75071374e-01f,
  -4.54125851e-02f, -1.75521404e-01f, -7.12688714e-02f, 3.39991897e-02f, -2.97430366e-01f, -1.40004084e-01f, -1.26718327e-01f, 1.33616894e-01f, -2.60851055e-01f, 1.08312637e-01f,
  -3.17433685e-01f, -2.53259212e-01f, -1.58366039e-01f, -2.27142498e-01f, -1.42753139e-01f, -4.83306684e-02f, -5.27355410e-02f, 1.31067500e-01f, -9.26144347e-02f, 5.00479937e-02f,
  8.25400949e-02f, 2.65576411e-03f, -1.77231252e-01f, 4.81705666e-02f, -6.55601323e-02f, -2.32984740e-02f, -3.77497412e-02f, -1.95825487e-01f, -1.27510205e-01f, 5.04874773e-02f,
  4.39743623e-02f, -8.63571540e-02f, -2.57666320e-01f, -4.16770615e-02f, -2.17146426e-02f, -1.23546794e-01f, -9.78288427e-02f, 4.31689657e-02f, -1.23799212e-01f, -5.85523210e-02f,
  1.07532002e-01f, 1.07722595e-01f, 3.91818658e-02f, 2.01606415e-02f, -1.25998715e-02f, 1.10870607e-01f, 3.45996432e-02f, 1.56613871e-01f, 2.56443620e-02f, -6.93963468e-02f,
  3.63946334e-02f, 5.97931929e-02f, 1.83917005e-02f, -1.03202172e-01f, 1.14895953e-02f, 1.27120186e-02f, 3.36404331e-02f, 1.07520707e-02f, -4.92646433e-02f, -1.07257478e-01f,
  5.03940880e-03f, -5.15612401e-02f, -5.48388949e-03f, -9.47637707e-02f, -9.15908813e-02f, -1.89839974e-02f, 5.17517701e-03f, -2.62007769e-02f, -2.87648235e-02f, 3.52732129e-02f,
  -4.40506577e-01f, -4.51010317e-01f, -1.51686892e-02f, -1.39778003e-01f, 2.31503546e-02f, -5.30413650e-02f, 5.19138947e-02f, -1.09080099e-01f, -1.30749762e-01f, 7.87009075e-02f,
  -8.47455487e-02f, -1.21973552e-01f, -1.32072628e-01f, -9.47175324e-02f, 6.08380213e-02f, -1.13065265e-01f, -6.51458055e-02f, -6.40494376e-02f, -1.38905227e-01f, -3.73429917e-02f,
  -4.20108438e-02f, 2.77463682e-02f, 9.45439711e-02f, -9.99363419e-03f, -5.56156337e-02f, 1.23478929e-02f, 4.79104407e-02f, -6.54794052e-02f, -1.16421707e-01f, 2.20100991e-02f,
  1.97109088e-01f, -1.51242405e-01f, -2.30921105e-01f, -2.34194756e-01f, -2.24755630e-02f, 3.20992410e-01f, -5.27654998e-02f, -6.41343519e-02f, -1.28640905e-01f, 2.49457240e-01f,
  2.00141482e-02f, -2.05015734e-01f, -6.16325811e-02f, -1.95495605e-01f, -2.31130153e-01f, -2.31977820e-01f, -3.86703908e-02f, -4.44709845e-02f, -5.70310988e-02f, 8.68318006e-02f,
  2.62935106e-02f, 4.34560608e-03f, -1.94527641e-01f, 2.03494892e-01f, -6.20252378e-02f, 7.91042596e-02f, 1.87885553e-01f, -3.99801806e-02f, 1.01229161e-01f, 5.35646267e-03f,
  -8.35036412e-02f, 1.60596836e-02f, -7.79705495e-02f, -1.35991685e-02f, 6.84568584e-02f, 1.30847082e-01f, 1.00062147e-01f, -3.83854955e-02f, -6.56831488e-02f, -5.75549863e-02f,
  1.22698717e-01f, -1.75907370e-02f, -1.18686765e-01f, 4.02004123e-02f, 2.91554444e-02f, -4.90624793e-02f, -1.66895300e-01f, 5.25066666e-02f, -1.07923225e-01f, -2.29548253e-02f,
  -1.01619363e-01f, -9.09908116e-02f, 1.41346566e-02f, -1.02034703e-01f, -1.10261880e-01f, -7.43991137e-02f, 6.79340363e-02f, 6.73089316e-03f, 4.84551452e-02f, -1.42701101e-02f,
  1.54431596e-01f, 1.27286658e-01f, 8.99760146e-03f, -1.07428074e-01f, 1.20324232e-02f, -9.70400986e-04f, -2.40875669e-02f, 2.27489183e-03f, -4.20991369e-02f, -2.29559615e-02f,
  -8.39208290e-02f, -3.03760786e-02f, -6.07554521e-03f, 5.97799458e-02f, 3.97948511e-02f, 3.31700966e-02f, 6.32193238e-02f, -6.53265193e-02f, -4.63025644e-02f, -5.17033227e-02f,
  -6.25737309e-02f, -7.29237646e-02f, -1.16342954e-01f, 1.77828576e-02f, -9.32385623e-02f, 2.41230689e-02f, 1.96380522e-02f, 2.25277729e-02f, -1.15433246e-01f, 9.68712792e-02f,
  8.06175768e-02f, 1.63789451e-01f, -9.95293036e-02f, -6.07328899e-02f, 2.97222212e-02f, 9.34235901e-02f, 3.04269921e-02f, 6.00192416e-03f, -3.68876532e-02f, 5.99848591e-02f,
  1.49088457e-01f, -1.79688279e-02f, 1.31707221e-01f, -1.41068017e-02f, -1.00640722e-01f, -8.25025365e-02f, -2.96691176e-03f, -4.05469760e-02f, 6.14685379e-02f, 9.14387703e-02f,
  1.07487321e-01f, -1.50860604e-02f, 2.37702616e-02f, -7.02668279e-02f, -1.59113687e-02f, -1.41162789e-04f, 1.56927735e-01f, 9.24832597e-02f, -2.34968564e-03f, 1.39385741e-02f,
  -4.89014536e-01f, 6.41259328e-02f, -2.76772052e-01f, 4.71742265e-02f, -3.56318116e-01f, -1.07241780e-01f, 7.83126131e-02f, -1.66460738e-01f, 7.59457201e-02f, 3.58606637e-01f,
  1.14734560e-01f, 6.39722347e-02f, 2.11851820e-01f, 1.56221449e-01f, -1.67028427e-01f, 4.17610586e-01f, 3.76641005e-02f, 1.59380347e-01f, -6.69656768e-02f, -1.73345432e-01f,
  -1.66453332e-01f, 4.90612723e-02f, -4.67672870e-02f, -2.01910183e-01f, -2.92578131e-01f, -1.01311363e-01f, -8.43276177e-03f, -2.37545401e-01f, -7.35178366e-02f, -8.25758725e-02f,
  -1.25920504e-01f, -2.54023880e-01f, -3.34258080e-02f, -6.96371570e-02f, -6.55286759e-02f, -1.00257844e-01f, -1.58435479e-01f, 7.29739061e-03f, -7.71177188e-03f, 3.09985895e-02f,
  2.40497850e-02f, -1.33089870e-01f, 1.19075343e-01f, 1.52348861e-01f, -1.36852227e-02f, -1.59704551e-01f, 5.70582263e-02f, 9.27089453e-02f, -7.95384198e-02f, -1.11701079e-02f,
  -4.30445895e-02f, -8.33151955e-03f, 1.28807887e-01f, 1.10402413e-01f, -1.28125980e-01f, 9.49859917e-02f, 1.20024614e-01f, -2.65488904e-02f, -6.25080988e-02f, -2.60093119e-02f,
  -1.07193299e-01f, -3.98924090e-02f, 9.44947675e-02f, -3.03054079e-02f, -2.00990848e-02f, 9.60972756e-02f, 1.53416675e-02f, 1.39066475e-02f, 6.73939213e-02f, -6.17776625e-02f,
  2.49615349e-02f, 7.83950463e-03f, 9.00784694e-03f, 3.76577899e-02f, 1.54394805e-01f, 6.46879226e-02f, 1.03006303e-01f, -8.11911300e-02f, 4.84720245e-02f, 9.10618976e-02f,
  -5.32740634e-03f, -1.71552338e-02f, 8.66596624e-02f, 9.22605023e-02f, -1.66838899e-01f, 3.84695642e-02f, -5.36797009e-02f, 1.13494977e-01f, 1.92055982e-02f, -8.18858817e-02f,
  -1.56081975e-01f, -3.84495020e-01f, 1.05790190e-01f, -7.64057636e-02f, 4.44148704e-02f, -2.99290568e-02f, -1.46215465e-02f, -5.82752861e-02f, -3.84079255e-02f, -9.05570686e-02f,
  7.42058977e-02f, -7.31078256e-03f, -1.96807623e-01f, 4.35401537e-02f, 9.28791463e-02f, -2.31928993e-02f, 1.61058307e-02f, 6.60239952e-03f, -3.30410264e-02f, 3.07080522e-02f,
  1.65669635e-01f, -4.58199494e-02f, 1.06989481e-01f, 6.39992133e-02f, 4.19264399e-02f, 1.28355026e-01f, 2.93389498e-03f, 4.11405377e-02f, -9.02407467e-02f, 4.87135090e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.90232784e-01f, 1.86839283e-01f, 3.06840122e-01f, 1.94859669e-01f, 1.03056438e-01f, 2.38639981e-01f, 1.75845847e-01f, 1.23969845e-01f, 2.96547532e-01f, 3.39648843e-01f,
  2.80448228e-01f, 2.18347400e-01f, 2.54635692e-01f, 2.64376327e-02f, 2.72951961e-01f, 1.44709438e-01f, 1.32777289e-01f, 3.09765786e-01f, 2.74248689e-01f, 3.27421695e-01f,
  1.50628552e-01f, 3.21573317e-01f, 2.20889360e-01f, 3.73370469e-01f, 2.13093832e-01f, 1.38325945e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.17994465e-01f, 2.06968382e-01f, 3.09042111e-02f, -5.19985594e-02f, 3.74409854e-02f, 1.28222629e-01f, -4.71726172e-02f, 1.07439924e-02f, -4.82075789e-04f, -9.77006108e-02f,
  1.60798222e-01f, 1.43498406e-01f, -1.11732287e-02f, 4.37321998e-02f, 5.24740713e-03f, 9.07852426e-02f, -5.39139807e-02f, 7.16008246e-02f, -1.74467266e-01f, -1.02012143e-01f,
  -3.82440090e-02f, -1.77822646e-03f, 1.20612420e-02f, -6.00531809e-02f, 1.71452150e-01f, 1.82079047e-01f, -4.84436490e-02f, 1.35263383e-01f, -1.10329568e-01f, 9.25327241e-02f,
  1.02831826e-01f, 7.35516325e-02f, -5.17555587e-02f, 3.00911907e-03f, 3.19302902e-02f, -4.38230336e-02f, -1.46934390e-02f, 1.55131400e-01f, -1.47658854e-03f, -1.65645793e-01f,
  2.82801926e-01f, -9.70745739e-03f, -8.09952468e-02f, -1.34350017e-01f, -2.07068864e-03f, -2.40552556e-02f, -7.51677677e-02f, -1.13901459e-01f, -1.12037048e-01f, -3.70122306e-02f,
  -1.04696080e-01f, 2.10388720e-01f, -3.02963287e-01f, 1.97508916e-01f, -2.20509291e-01f, -1.88236192e-01f, -1.16041139e-01f, -1.55989259e-01f, 3.09259128e-02f, 8.28927159e-02f,
  2.37745255e-01f, -5.67891523e-02f, 1.92887355e-02f, 2.54838187e-02f, 4.61940728e-02f, 1.05969131e-01f, 2.17460483e-01f, 6.31905124e-02f, 9.91302803e-02f, 1.16488859e-01f,
  1.86474994e-01f, 6.99842870e-02f, 8.59754011e-02f, 4.51946370e-02f, 2.18835577e-01f, 2.49512002e-01f, -1.01352893e-02f, -1.21232094e-02f, 2.22297102e-01f, 1.94917008e-01f,
  -3.22994441e-02f, 5.06758019e-02f, 8.19772035e-02f, -1.37007043e-01f, -5.63259870e-02f, 1.45457014e-01f, 5.39792376e-03f, -7.26051852e-02f, -9.45296721e-04f, 1.15428813e-01f,
  1.31442830e-01f, 1.12485923e-02f, -8.47619697e-02f, -3.26636024e-02f, 2.83338148e-02f, -9.78942588e-02f, -8.10425505e-02f, -1.50822476e-01f, 3.34073082e-02f, -1.33085594e-01f,
  1.30411521e-01f, -8.42327103e-02f, 1.65593982e-01f, 1.97645813e-01f, 9.38970409e-03f, -1.74941495e-01f, -2.17489507e-02f, -8.59081298e-02f, -9.51659530e-02f, -1.52847487e-02f,
  1.43014446e-01f, -4.35360558e-02f, 8.66043754e-03f, 5.66814514e-03f, 3.40661183e-02f, -9.24028456e-02f, -8.73416755e-03f, 2.94272192e-02f, -9.39471647e-03f, -4.15819958e-02f,
  3.01531926e-02f, -9.83928367e-02f, -1.26663893e-01f, 1.95239395e-01f, 2.93152243e-01f, -4.98283692e-02f, 2.28736311e-01f, -1.19218439e-01f, -1.03498593e-01f, 6.79660961e-02f,
  8.98028612e-02f, 1.22412406e-01f, 7.21631870e-02f, -6.42687362e-03f, -7.74934292e-02f, 1.19121902e-01f, -1.13758393e-01f, 1.59913618e-02f, 4.35115024e-02f, 5.81975579e-02f,
  -7.01247454e-02f, 1.00825489e-01f, -9.49419569e-03f, 1.07874330e-02f, -4.81244400e-02f, 5.71865812e-02f, -1.26494199e-01f, -3.91223468e-02f, -4.04697098e-02f, 9.23486277e-02f,
  1.78183392e-02f, 1.57762751e-01f, -5.61257266e-02f, -1.81526735e-01f, -6.16469160e-02f, 7.52277113e-03f, 6.50866404e-02f, 1.55407667e-01f, -6.08071610e-02f, -1.81469679e-01f,
  1.76319182e-02f, 6.49339259e-02f, -3.35225314e-02f, 1.04586380e-02f, 1.05214112e-01f, -1.27313465e-01f, 1.01614162e-01f, 7.75397420e-02f, -3.07484418e-01f, -2.85414726e-01f,
  -2.25913838e-01f, 1.57996893e-01f, 1.90479010e-01f, -2.09633471e-03f, 2.27246620e-02f, 1.12121418e-01f, 1.75921902e-01f, 4.38941196e-02f, -4.43573631e-02f, 6.23722039e-02f,
  5.49125858e-02f, 2.06772164e-01f, 7.45456666e-02f, 8.34803507e-02f, 9.00684074e-02f, 8.15013796e-03f, -7.68256709e-02f, -7.99260959e-02f, -4.89465371e-02f, 1.66419223e-01f,
  1.43366978e-01f, 1.49946675e-01f, -1.35670185e-01f, 8.93570930e-02f, -7.83618074e-03f, -2.00171024e-02f, -3.29420306e-02f, 5.16362227e-02f, 1.38472751e-01f, -1.08760767e-01f,
  5.35069965e-02f, 7.40140080e-02f, -6.04035184e-02f, -4.40583117e-02f, -7.69800097e-02f, 2.59959768e-03f, 8.68836511e-03f, -7.45403320e-02f, 2.54323464e-02f, -1.41279235e-01f,
  1.13081902e-01f, -5.37538789e-02f, 1.40264973e-01f, -1.70329690e-01f, 2.72897303e-01f, -1.56436339e-01f, -2.02547148e-01f, -1.11000009e-01f, 3.41336913e-02f, -1.30399257e-01f,
  -1.99430421e-01f, -2.07829058e-01f, 8.81074965e-02f, -1.68613881e-01f, -2.29191836e-02f, -2.67075330e-01f, -4.25513126e-02f, -1.60855338e-01f, 9.27176848e-02f, 1.16359014e-02f,
  -2.85218626e-01f, 6.94503859e-02f, -5.65079488e-02f, 1.28812805e-01f, 1.71397150e-01f, -2.11120605e-01f, -8.27391893e-02f, 1.57036960e-01f, 3.32494378e-02f, -2.54504800e-01f,
  1.38562784e-01f, 1.37540951e-01f, 1.56439692e-01f, -1.93875227e-02f, -9.57783684e-03f, -1.19242273e-01f, 1.44452304e-01f, 6.86420947e-02f, 7.00374469e-02f, -1.02772646e-01f,
  2.32993111e-01f, 7.18017071e-02f, 3.68450433e-02f, -2.83999562e-01f, 2.12209538e-01f, -2.69244969e-01f, -9.29396003e-02f, 2.83559337e-02f, -9.95649025e-02f, 9.47436392e-02f,
  6.61436692e-02f, 1.13957301e-02f, 9.88326147e-02f, -2.85351537e-02f, 3.82070094e-02f, 4.31893170e-02f, 1.40844613e-01f, 2.88800783e-02f, 6.26727939e-02f, -4.56285477e-02f,
  3.84464115e-02f, -2.65791658e-02f, -3.09708510e-02f, -9.12348330e-02f, -9.90367681e-02f, 2.17840374e-01f, -1.14588358e-01f, -1.90906018e-01f, 1.13049433e-01f, -4.89833988e-02f,
  -2.22778887e-01f, -3.21181379e-02f, 1.13652028e-01f, 4.68344952e-04f, -6.46483228e-02f, 1.21937864e-01f, -1.82342855e-03f, -8.11888427e-02f, 2.19101489e-01f, -1.43669084e-01f,
  3.43304337e-03f, 1.57443658e-01f, 3.43005247e-02f, 9.13200155e-02f, 5.80909774e-02f, 1.70328155e-01f, -2.47108657e-02f, -2.30715483e-01f, -5.76115996e-02f, -1.24844173e-02f,
  2.65686959e-01f, 8.20557624e-02f, 3.04790642e-02f, -8.79227221e-02f, -1.28104046e-01f, -4.63312306e-02f, -1.28583044e-01f, -1.46858677e-01f, -1.19164295e-01f, -1.17563471e-01f,
  1.03347562e-01f, -1.47862315e-01f, 2.16486216e-01f, -6.05128631e-02f, -3.10011841e-02f, 6.91762418e-02f, -2.09961504e-01f, -3.19972336e-01f, 6.74946979e-02f, -7.38803111e-03f,
  9.84558761e-02f, 7.00952783e-02f, 2.20985729e-02f, 8.16751570e-02f, -1.41009882e-01f, -3.52412127e-02f, 4.03974243e-02f, 8.52337778e-02f, 6.67526051e-02f, 2.21704524e-02f,
  2.04916865e-01f, 2.78363507e-02f, 1.55106828e-01f, 1.43132033e-02f, 8.95401463e-03f, 1.59542635e-01f, 7.91837722e-02f, 7.89191425e-02f, -3.78215127e-02f, 1.21223368e-01f,
  -6.33321330e-02f, 8.16020593e-02f, -1.46559151e-02f, 7.88960829e-02f, -2.02877857e-02f, 2.00989991e-02f, 7.59364441e-02f, 2.24460550e-02f, 9.29804295e-02f, 1.00437768e-01f,
  1.69871170e-02f, -1.25762895e-01f, 9.61021259e-02f, 5.36207929e-02f, 8.74493420e-02f, 9.69571993e-02f, -6.70878589e-02f, -1.18188383e-02f, 1.65646076e-01f, -1.61812797e-01f,
  3.88505608e-02f, -8.86905119e-02f, -1.30389079e-01f, 6.62157461e-02f, 3.85999084e-02f, 1.10951185e-01f, 2.45518740e-02f, 3.29737425e-01f, 7.15956986e-02f, -1.21851072e-01f,
  -1.94336072e-01f, -1.74176157e-01f, 1.01358064e-01f, -4.34424542e-02f, -1.79144517e-01f, 5.94573207e-02f, 1.44746527e-01f, 1.30723923e-01f, -1.10402443e-01f, 7.38539174e-02f,
  -2.94060349e-01f, 1.17579021e-01f, -5.60545847e-02f, 3.23679522e-02f, -2.86749331e-03f, -1.81015074e-01f, 1.50943294e-01f, -1.17415637e-02f, 5.79914786e-02f, -2.00392473e-02f,
  3.51122394e-02f, -3.18426453e-02f, -1.61715418e-01f, -6.06292821e-02f, 8.38317350e-02f, -4.91784215e-02f, -2.23331600e-02f, 4.45054956e-02f, 5.90743385e-02f, 1.27457678e-01f,
  -1.06551766e-01f, 1.16264019e-02f, 1.58763960e-01f, 6.02374226e-02f, 6.68721721e-02f, -2.66366787e-02f, -1.32097378e-01f, -8.20703339e-03f, -1.20444700e-01f, 7.29983374e-02f,
  8.23908597e-02f, 1.96459815e-01f, 7.01515451e-02f, -1.20794393e-01f, 1.92561567e-01f, -5.14944755e-02f, 1.78198427e-01f, 2.11153939e-01f, -8.60725492e-02f, -4.37514670e-02f,
  8.70883241e-02f, -1.42194023e-02f, 1.09570660e-01f, 1.71221215e-02f, -2.56980360e-01f, -6.52245432e-02f, 1.14318989e-01f, -1.95169866e-01f, 6.83395937e-02f, 1.80069089e-01f,
  6.72492757e-02f, -1.94169283e-01f, 1.38474211e-01f, 1.37056738e-01f, -7.69082308e-02f, 1.50204152e-01f, -8.40871334e-02f, 1.26434311e-01f, -1.05345316e-01f, 1.95718296e-02f,
  9.72917303e-02f, -2.23191679e-01f, -2.03112200e-01f, 1.38042673e-01f, 1.19334005e-01f, -1.11789845e-01f, 1.61451265e-01f, 1.58233680e-02f, 6.44563064e-02f, -1.15852825e-01f,
  -1.50671214e-01f, -6.02620691e-02f, -1.36434391e-01f, -7.52261132e-02f, -6.56731203e-02f, -1.67030901e-01f, 5.63412048e-02f, -1.10723436e-01f, -9.98123661e-02f, -9.49954540e-02f,
  4.71215025e-02f, -2.94847861e-02f, -1.87814876e-01f, -1.65769219e-01f, 1.32740587e-01f, -3.40844281e-02f, -9.29384604e-02f, 8.94635990e-02f, 5.82341962e-02f, -8.01983252e-02f,
  -4.85342033e-02f, -1.48068806e-02f, -1.17919091e-02f, -8.22687075e-02f, 1.89735442e-01f, -1.15162935e-02f, 8.74436945e-02f, 1.83566427e-03f, -8.03419128e-02f, 1.21375255e-01f,
  -8.34350754e-03f, 1.00331001e-01f, 2.82299425e-02f, 2.68518515e-02f, -1.16503194e-01f, -1.22165538e-01f, 2.31437132e-01f, 4.33772095e-02f, -1.80562809e-01f, 1.42274918e-02f,
  2.91656494e-01f, 3.32341045e-01f, -8.87936950e-02f, -5.12751974e-02f, 1.83159962e-01f, 1.26317202e-03f, -1.06514834e-01f, 1.21830620e-01f, 1.00864589e-01f, 9.94952098e-02f,
  4.97519821e-02f, 1.38147771e-01f, 1.70427803e-02f, 1.38842091e-02f, -1.39925882e-01f, 1.77705377e-01f, -9.23313648e-02f, -8.43529999e-02f, -1.00405097e-01f, 1.71520889e-01f,
  -8.03315565e-02f, 2.10047081e-01f, 1.39384001e-01f, -4.55593839e-02f, 7.60525614e-02f, 3.04927747e-03f, -3.40703577e-02f, -1.00195207e-01f, -5.39737009e-02f, 1.36796087e-01f,
  4.96189035e-02f, 7.05439150e-02f, 1.56065643e-01f, 8.11822042e-02f, 1.43933058e-01f, -2.37793643e-02f, 6.85131103e-02f, 2.53240764e-01f, 4.17511277e-02f, 5.88796213e-02f,
  -5.45393564e-02f, 5.30033261e-02f, -1.46393716e-01f, 1.89639255e-03f, -6.93306699e-02f, 1.48722455e-01f, 4.20685299e-02f, 2.09537335e-02f, 4.27454337e-02f, 8.80767405e-02f,
  4.58366983e-02f, 2.54658610e-01f, 4.22097817e-02f, 1.20175861e-01f, 1.78528816e-01f, 5.51748872e-02f, 2.24945307e-01f, 1.06179520e-01f, -1.35018542e-01f, 1.60868436e-01f,
  1.35214970e-01f, -1.68400630e-01f, 1.57789037e-01f, -2.47036383e-01f, -4.89684381e-02f, -3.73482108e-02f, 5.21202274e-02f, 5.45571111e-02f, 7.98723195e-03f, 1.83594763e-01f,
  -7.50403851e-02f, -3.16850804e-02f, -5.29027320e-02f, 8.97015408e-02f, -1.31796166e-01f, 2.07077324e-01f, -2.36372009e-01f, -1.26580343e-01f, 9.67247412e-02f, 9.56294090e-02f,
  -2.58030295e-01f, 8.68696868e-02f, 1.01414107e-01f, 2.70158052e-01f, -1.68837443e-01f, -3.78423929e-02f, -2.27479897e-02f, -8.37841723e-03f, -5.31619750e-02f, -5.66264503e-02f,
  -1.26417086e-01f, -4.32305299e-02f, -1.85648687e-02f, -1.54861450e-01f, 6.15238324e-02f, 3.70800775e-03f, -9.34176818e-02f, 4.78565805e-02f, -1.17132157e-01f, 7.98932463e-03f,
  -1.19829319e-01f, -8.45572576e-02f, -1.61643662e-02f, 1.69562772e-02f, 1.28789574e-01f, -1.67792976e-01f, 1.23236232e-01f, 9.21735615e-02f, -5.73409838e-04f, 2.86173802e-02f,
  1.67251661e-01f, -1.60676539e-01f, -4.23079804e-02f, -2.20032573e-01f, 6.25299290e-02f, -1.01435885e-01f, -9.26533788e-02f, -9.46991071e-02f, -3.43115121e-01f, 1.14477001e-01f,
  -7.12200850e-02f, -2.07200631e-01f, 1.10062510e-01f, -1.17886931e-01f, 2.11349279e-01f, -9.10982024e-03f, -2.18979225e-01f, 1.29602030e-01f, -1.08557731e-01f, 1.05380096e-01f,
  -1.58745393e-01f, -1.54332846e-01f, -2.63334275e-03f, 1.15055241e-01f, -2.79580522e-02f, 1.42923281e-01f, 1.15222059e-01f, 1.08207792e-01f, 6.38441816e-02f, 1.20159434e-02f,
  4.37007248e-02f, 2.04218298e-01f, -1.81180015e-01f, 5.39094247e-02f, 1.46635130e-01f, -1.33445710e-01f, 6.06052205e-03f, 2.10331410e-01f, 6.70781136e-02f, 2.08347905e-02f,
  4.20100987e-02f, -5.54046109e-02f, 1.09876201e-01f, 2.93435762e-03f, -1.94008239e-02f, 1.47140488e-01f, 8.39728639e-02f, 2.46333033e-02f, -2.41923463e-02f, 2.51008756e-02f,
  2.34617338e-01f, -2.72223894e-02f, 8.47141519e-02f, 1.18006907e-01f, 3.02514136e-02f, 1.11236356e-01f, -4.53294478e-02f, -1.92097556e-02f, -4.58115572e-03f, 1.75885066e-01f,
  2.18224339e-02f, 1.60008460e-01f, -4.13665265e-01f, 2.58883804e-01f, 5.72191775e-02f, 2.83414535e-02f, 1.61640525e-01f, -2.56879404e-02f, 1.54856220e-01f, -1.17288865e-02f,
  -1.18711546e-01f, -4.00184803e-02f, -5.91460615e-02f, 1.17489301e-01f, -9.03133899e-02f, 4.31128219e-02f, 5.54499924e-02f, -2.15810820e-01f, 2.40908816e-01f, 8.70744959e-02f,
  -2.21527174e-01f, -2.73437575e-02f, -1.00172199e-01f, 2.44212151e-01f, 1.22964770e-01f, -1.51758999e-01f, 3.57784927e-02f, 1.24259941e-01f, -8.74321237e-02f, -5.62758595e-02f,
  2.56825071e-02f, -6.43149316e-02f, 7.00659910e-03f, -5.20625152e-02f, 2.97001395e-02f, -2.22341530e-02f, 4.38619498e-03f, -8.73381421e-02f, -1.59860671e-01f, -1.01971015e-01f,
  8.42226446e-02f, -1.18085444e-01f, 7.20991641e-02f, 2.42606327e-01f, 1.34709418e-01f, -4.79689986e-02f, -2.16760337e-02f, 4.34226282e-02f, -5.67397326e-02f, 2.52072886e-02f,
  -1.58914268e-01f, -9.51023400e-03f, -8.49699676e-02f, -6.37827367e-02f, 7.86391795e-02f, -6.56314120e-02f, 3.22896242e-02f, 1.17029041e-01f, -4.96356301e-02f, 6.36336431e-02f,
  -5.26146814e-02f, 1.15554452e-01f, -5.31380698e-02f, 1.53145239e-01f, -2.94935443e-02f, 1.93557158e-01f, -3.07487786e-01f, 1.57560453e-01f, 2.10534275e-01f, 9.44635868e-02f,
  6.07898310e-02f, 7.60152861e-02f, 2.08539456e-01f, 1.50637463e-01f, -3.17438133e-02f, 5.05413041e-02f, -5.91745824e-02f, 2.79562831e-01f, 8.99914503e-02f, 1.28392860e-01f,
  -4.03422602e-02f, -1.89809278e-01f, 3.38364363e-01f, -1.59584612e-01f, -2.25911483e-01f, -3.71119827e-02f, -3.79947796e-02f, 2.84799784e-01f, -6.25547301e-03f, -2.28838235e-01f,
  -7.10167587e-02f, 2.59010136e-01f, -7.75514683e-03f, -8.33837762e-02f, -1.57839283e-01f, 4.63951118e-02f, 8.42470899e-02f, 6.72293678e-02f, -1.36629507e-01f, 8.44783783e-02f,
  -9.08781961e-02f, -3.71475564e-03f, -3.35175872e-01f, -1.70082778e-01f, -1.25705590e-03f, 3.49548697e-01f, -1.27652481e-01f, 2.79102176e-01f, 1.61403179e-01f, -7.82892033e-02f,
  -3.77834141e-02f, -1.56962708e-01f, -1.06179588e-01f, -1.29241258e-01f, -1.46489069e-01f, -8.71774554e-02f, -1.41126662e-01f, -1.68330580e-01f, 2.08177809e-02f, -1.33158922e-01f,
  -1.28454575e-02f, 6.83574378e-02f, 2.50165304e-03f, 5.70704117e-02f, 1.43891603e-01f, 2.87995692e-02f, 6.48453683e-02f, 1.42308027e-01f, 7.59351328e-02f, 1.09269127e-01f,
  -2.34031588e-01f, 1.22057445e-01f, 2.50270724e-01f, 7.14711547e-02f, 8.06180462e-02f, 1.03978044e-03f, 1.50024697e-01f, -1.95985660e-02f, 1.84923150e-02f, 1.93231478e-01f,
  -1.10664271e-01f, 1.66288137e-01f, 8.87397304e-02f, 1.54722519e-02f, -2.05383543e-02f, -9.53542665e-02f, 4.77432236e-02f, -2.61378735e-01f, -8.05724338e-02f, 1.35838374e-01f,
  1.19654447e-01f, 2.13944986e-01f, -2.61003405e-01f, -1.53411746e-01f, -1.23842880e-01f, 2.99389437e-02f, -1.24351569e-01f, -2.06920449e-02f, 2.09056381e-02f, 1.92181021e-02f,
  8.98139477e-02f, 4.85813059e-02f, 1.30555015e-02f, 3.22926082e-02f, -3.38981390e-01f, 1.29565090e-01f, -1.84656560e-01f, -1.46680012e-01f, 1.98455319e-01f, 2.82676697e-01f,
  -3.01642358e-01f, 1.97668642e-01f, 2.24541351e-02f, -3.01928148e-02f, -1.35503665e-01f, 5.50283901e-02f, -2.24982370e-02f, -1.27699062e-01f, -9.09062698e-02f, -4.03986871e-02f,
  -5.43633774e-02f, -4.68653589e-02f, -2.58119643e-01f, -1.43875271e-01f, 9.55355838e-02f, -8.04534405e-02f, -1.58052132e-01f, -1.15445204e-01f, 9.96838510e-02f, -1.53803099e-02f,
  -1.29294989e-03f, 1.46963716e-01f, -4.48185429e-02f, -2.34476447e-01f, 2.03019753e-01f, -7.79743791e-02f, -1.84791163e-01f, -1.18484564e-01f, -1.09447166e-01f, 1.09877307e-02f,
  1.23529039e-01f, 1.71991244e-01f, -8.91968515e-03f, -2.66924663e-03f, 2.89348155e-01f, -4.49038893e-02f, 1.55502453e-01f, 1.17052637e-01f, -2.15341002e-01f, 1.65213898e-01f,
  -1.36883184e-01f, -1.06383292e-02f, 3.12970318e-02f, -1.28282368e-01f, 1.61336839e-01f, -6.46716058e-02f, 1.63122550e-01f, 2.12379918e-01f, -5.35453372e-02f, -3.94632630e-02f,
  1.10323250e-01f, -1.12957433e-02f, -8.38409886e-02f, -3.51903774e-02f, 1.87786669e-02f, -9.36515257e-03f, -1.63374484e-01f, 7.98012912e-02f, 1.26907423e-01f, 1.90908566e-01f,
  8.82121250e-02f, -3.57490107e-02f, -1.90552980e-01f, 9.66618210e-02f, -1.20794093e-02f, -1.99762985e-01f, -7.23553151e-02f, 7.69655406e-03f, 1.18619483e-03f, 4.86453623e-02f,
  -5.49277384e-03f, 7.25143924e-02f, 1.05304614e-01f, -9.17259082e-02f, 1.45300433e-01f, 1.58365637e-01f, 1.35315536e-02f, 1.10998675e-01f, -7.07983375e-02f, -2.15769894e-02f,
  7.68275699e-03f, -4.77937981e-02f, 2.73558144e-02f, -8.00532699e-02f, 1.01067945e-01f, -1.48075432e-01f, 1.38508469e-01f, -9.41368937e-02f, 2.15188146e-01f, -3.94558646e-02f,
  -1.87425479e-01f, -1.31655291e-01f, -1.04670592e-01f, -1.96884155e-01f, -1.30690351e-01f, -8.28617290e-02f, 4.40854505e-02f, -8.78736824e-02f, 1.06545845e-02f, -2.48898968e-01f,
  8.01146869e-03f, -1.32516354e-01f, 1.29409879e-01f, 1.78375896e-02f, -2.61710584e-01f, 2.00311959e-01f, -1.18240327e-01f, 5.87523729e-02f, 5.46013564e-02f, 7.53745856e-03f,
  5.58024906e-02f, 2.40938570e-02f, 8.02309811e-03f, -8.95756558e-02f, 2.93196291e-01f, 2.58186102e-01f, 1.84729159e-01f, -8.37375224e-02f, 1.63562223e-01f, -1.17170081e-01f,
  2.92670786e-01f, 1.33241028e-01f, 8.86508264e-03f, 2.08863779e-03f, 1.96067736e-01f, -8.29174556e-03f, 7.45403618e-02f, -1.47598207e-01f, 2.88711548e-01f, -8.76716077e-02f,
  1.80693358e-01f, -5.22201583e-02f, 3.08663119e-02f, -3.86435241e-02f, -1.15632802e-01f, 4.73392867e-02f, -4.49467748e-02f, -4.46637161e-02f, 4.57559489e-02f, -3.08022136e-03f,
  8.14769790e-02f, -4.59971838e-02f, 6.51321560e-02f, 2.39167929e-01f, -9.70207562e-04f, 7.94566721e-02f, 1.36352867e-01f, -1.35244178e-02f, 7.98791721e-02f, 4.25514020e-02f,
  4.12081070e-02f, 1.92051843e-01f, -2.39726260e-01f, 1.94698244e-01f, 1.79035693e-01f, -7.19566364e-03f, 7.64554441e-02f, 1.00626819e-01f, 1.95241764e-01f, 5.12804203e-02f,
  -3.78171131e-02f, 1.23016201e-01f, -1.96911767e-01f, 1.93592697e-01f, 2.63061989e-02f, -7.29203820e-02f, -2.29528919e-02f, -9.38122049e-02f, 3.90443742e-01f, -2.00068038e-02f,
  -1.64062575e-01f, -2.83775311e-02f, 7.35623762e-03f, 2.40026727e-01f, -1.18610747e-01f, -1.34055585e-01f, 3.16148102e-02f, 1.99916646e-01f, -3.03677116e-02f, 2.33727414e-03f,
  -1.53986318e-02f, 1.26536667e-01f, 1.05629109e-01f, 1.41562894e-01f, -2.16872040e-02f, 1.04559578e-01f, -1.57036766e-01f, 4.59697656e-02f, -2.23509297e-01f, -1.47438869e-01f,
  1.40299737e-01f, 3.25029999e-01f, -1.23115271e-01f, 2.69178599e-01f, -9.64460224e-02f, 5.92918098e-02f, -8.95303115e-02f, 1.34228215e-01f, 6.54986827e-03f, 1.52405471e-01f,
  2.09866893e-02f, 1.61289558e-01f, 9.34274197e-02f, 3.63922305e-02f, -6.10385798e-02f, 7.78292939e-02f, 7.99843669e-02f, -4.73537594e-02f, -9.29956436e-02f, -8.15697387e-02f,
  7.27184564e-02f, 1.56433225e-01f, -1.12183444e-01f, 1.17411107e-01f, -8.61400515e-02f, -6.02137521e-02f, 9.41044986e-02f, 6.11776039e-02f, 3.22264880e-02f, -1.57281265e-01f,
  -1.04745150e-01f, -9.79795381e-02f, -1.74872372e-02f, 1.40248254e-01f, -1.14985898e-01f, 1.28462046e-01f, 1.01831093e-01f, -1.47968039e-01f, 4.00734246e-02f, 6.91995770e-02f,
  -1.92213371e-01f, 1.86358362e-01f, -2.99000353e-01f, -1.45924807e-01f, 2.65058994e-01f, -1.17021743e-02f, -1.16430975e-01f, 1.30022258e-01f, 1.97998509e-01f, -6.51595071e-02f,
  -2.06138894e-01f, 1.57280236e-01f, -3.51089006e-03f, -9.93957594e-02f, -5.50174303e-02f, -1.57624349e-01f, 8.70634243e-03f, -1.92937583e-01f, -1.80175632e-01f, -1.11157537e-01f,
  1.05562367e-01f, 2.71251857e-01f, 2.67651558e-01f, -8.71481225e-02f, -2.04685777e-01f, 6.77982569e-02f, -1.74697086e-01f, -9.44538116e-02f, 1.59553569e-02f, -2.17544362e-02f,
  -6.25399873e-02f, 2.07173303e-01f, 1.66767486e-03f, -3.45911905e-02f, 6.55915216e-02f, 1.04589770e-02f, -1.26630962e-02f, 2.93710940e-02f, 8.54083672e-02f, 7.77505711e-02f,
  6.15420602e-02f, 4.15946133e-02f, -8.36234093e-02f, 1.06224053e-01f, 7.31426775e-02f, 2.39939820e-02f, -5.53195700e-02f, -1.41431568e-02f, 4.85955290e-02f, 1.69161763e-02f,
  5.97355552e-02f, 1.11128032e-01f, 6.97938204e-02f, -4.61364873e-02f, -1.52242467e-01f, 1.59250841e-01f, 6.90843090e-02f, 1.60763234e-01f, -1.32294580e-01f, -6.85141981e-02f,
  2.95501277e-02f, 1.23350382e-01f, 1.52738661e-01f, 6.49580685e-03f, -3.70318623e-04f, 2.06976637e-01f, -8.40875134e-02f, -3.69021408e-02f, 1.54127628e-01f, -1.15113243e-01f,
  -1.90976575e-01f, -5.95832244e-02f, 5.20587377e-02f, 1.87183097e-01f, -7.00967759e-02f, -8.32640938e-03f, 1.63259998e-01f, 9.66746509e-02f, -1.94860652e-01f, 1.04509611e-02f,
  -6.74328282e-02f, 4.37345952e-02f, -2.01363236e-01f, -4.87362258e-02f, 1.90076217e-01f, 1.74232963e-02f, 4.35398780e-02f, 2.07628801e-01f, -1.95135787e-01f, 1.07549459e-01f,
  6.51198551e-02f, -7.48670325e-02f, -7.84846693e-02f, 7.17871338e-02f, -1.36854142e-01f, 1.50618209e-02f, -3.84200588e-02f, -2.19315072e-04f, 4.49332688e-03f, -2.60645542e-02f,
  7.24179223e-02f, -5.60022704e-03f, -1.24182895e-01f, 6.17290772e-02f, -1.80801332e-01f, -1.12836115e-01f, -5.82913943e-02f, -1.11233652e-01f, -6.77765310e-02f, -5.82176298e-02f,
  -8.36879015e-02f, -2.11679965e-01f, -3.20837758e-02f, 1.49013281e-01f, -4.26711626e-02f, 1.08320579e-01f, 1.64976940e-01f, -1.82070717e-01f, -1.04620636e-01f, -1.83026046e-01f,
  -3.83617990e-02f, 1.20578505e-01f, -1.45579502e-01f, -5.23346514e-02f, -2.43320525e-01f, -5.75699881e-02f, 1.32943213e-01f, -1.49321571e-01f, 1.07657211e-03f, -2.07128171e-02f,
  2.41151638e-02f, -5.75604886e-02f, -1.90714315e-01f, 4.89115603e-02f, -1.16224825e-01f, 1.96910381e-01f, -9.12817419e-02f, -2.37912923e-01f, 1.31189778e-01f, 1.44679472e-01f,
  7.18022659e-02f, 1.89694837e-01f, 9.17333737e-02f, 3.71531956e-02f, 6.95110559e-02f, -1.69027187e-02f, 1.77473217e-01f, 1.54408425e-01f, -1.82710424e-01f, 2.15456352e-01f,
  7.87902400e-02f, -1.35219470e-01f, -6.17571920e-03f, 2.72945017e-01f, 6.15504105e-03f, 4.56197262e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.65187085e-01f, 1.03018448e-01f, -5.74048087e-02f, 1.31637588e-01f, 8.87842551e-02f, 1.05070539e-01f, 1.73353940e-01f, 5.21092042e-02f, 8.73689651e-02f, 1.32636428e-01f,
  1.07314192e-01f, 1.67251870e-01f, 1.54470205e-01f, 1.41856655e-01f, 1.45263985e-01f, 3.41785073e-01f, 6.54989034e-02f, 1.61162704e-01f, 1.85274407e-01f, 1.38897538e-01f,
  7.28100240e-02f, 6.82771429e-02f, -3.22578885e-02f, 1.05167145e-03f, -1.69364393e-01f, -1.08099706e-01f, 1.43401772e-02f, 3.72443199e-02f, 9.00843367e-03f, 1.37584969e-01f,
  9.77983400e-02f, -1.41597271e-01f, -4.98463102e-02f, 2.38919929e-01f, 3.45923513e-01f, -7.71166831e-02f, -7.96113610e-02f, -1.73503980e-01f, 3.32900047e-01f, -5.16416393e-02f,
  -3.32866997e-01f, 1.20929196e-01f, 3.79561007e-01f, 5.05207591e-02f, 1.54020339e-01f, 1.47608399e-01f, 5.21285497e-02f, 3.16342294e-01f, 3.08855861e-01f, -5.17895166e-03f,
  -4.13506329e-02f, -2.00130373e-01f, 1.37746796e-01f, 2.68963967e-02f, -2.53008038e-01f, 1.16156705e-01f, 2.91957766e-01f, 1.98549345e-01f, -2.73770571e-01f, 4.90227193e-02f,
  -2.21376166e-01f, 2.13714764e-01f, 3.93168405e-02f, -1.28630921e-01f, 2.10794210e-01f, 1.55549809e-01f, 1.47574961e-01f, 7.70019889e-02f, 1.22961670e-01f, 1.02227651e-01f,
  -2.18189415e-02f, -7.76767954e-02f, 7.94873461e-02f, 4.96111438e-02f, 1.17211476e-01f, 9.73029435e-02f, 3.09326649e-02f, 2.74227828e-01f, 4.13671732e-02f, 7.21173957e-02f,
  1.34642020e-01f, 1.32475987e-01f, 2.27986977e-01f, -2.53904492e-01f, -4.97026695e-03f, -6.47950023e-02f, -4.41050306e-02f, -1.89834833e-01f, 1.43791765e-01f, 4.05476578e-02f,
  1.97865739e-01f, 2.32742846e-01f, -3.43221128e-02f, -2.71853153e-02f, 1.05615973e-01f, 7.08325207e-02f, -1.37460470e-01f, 1.91676483e-01f, -2.55611002e-01f, -1.31858632e-01f,
  1.04913093e-01f, 1.25185391e-02f, 3.95064324e-01f, 8.43499973e-02f, -2.81318221e-02f, 1.61218032e-01f, 1.91537872e-01f, -1.72535226e-01f, -6.92627430e-02f, 1.63596854e-01f,
  3.10577564e-02f, -3.06212068e-01f, -9.94291306e-02f, 1.33674726e-01f, 3.73081177e-01f, 3.72187018e-01f, -2.43555069e-01f, 4.75949883e-01f, -4.78048101e-02f, -9.00345445e-02f,
  -4.16382141e-02f, -3.40687931e-01f, 1.23596586e-01f, 1.42905995e-01f, 3.21871310e-01f, 2.32099995e-01f, 7.31450021e-02f, 1.65060490e-01f, 1.63214833e-01f, -2.20912416e-02f,
  3.39048430e-02f, 5.64125180e-02f, 1.23789921e-01f, -2.04955354e-01f, -2.11428124e-02f, 1.38653785e-01f, 1.58252940e-01f, 5.09870574e-02f, -9.89437550e-02f, -4.29197103e-02f,
  1.65328324e-01f, 5.07886335e-02f, 9.65341479e-02f, 1.08288623e-01f, 1.79673657e-01f, 1.53629839e-01f, -6.28286414e-03f, 3.05644572e-01f, -1.67612076e-01f, 6.36976585e-02f,
  -2.17451498e-01f, 1.73948824e-01f, 9.83252898e-02f, -1.42479271e-01f, 4.26523462e-02f, -9.86865256e-03f, 1.87099904e-01f, 2.71079898e-01f, -6.44183233e-02f, 1.65988669e-01f,
  1.64480031e-01f, 1.34658262e-01f, 2.37330943e-01f, 2.70188957e-01f, -2.29828894e-01f, -5.54660894e-02f, 9.77841020e-02f, -7.85663351e-02f, -2.33687535e-02f, 9.31496918e-03f,
  7.93956369e-02f, 3.67131382e-01f, 2.77275443e-01f, -3.27718332e-02f, 1.78881660e-01f, 2.32141629e-01f, 7.87103251e-02f, 1.72698289e-01f, -1.19431078e-01f, 1.44736841e-01f,
  6.74930811e-02f, 1.96581200e-01f, 8.78462046e-02f, 3.48287039e-02f, 6.21502288e-02f, 3.86258006e-01f, -1.87844425e-01f, -1.94500551e-01f, -1.30183920e-01f, 3.16209674e-01f,
  -1.24156557e-01f, 3.63467902e-01f, -7.69450739e-02f, 1.05425447e-01f, 1.48458540e-01f, -1.20110093e-02f, -2.60109119e-02f, 1.15454234e-02f, 3.16060454e-01f, 4.13730182e-02f,
  1.53318018e-01f, 1.03799641e-01f, 1.83227271e-01f, 9.74414945e-02f, 1.48907632e-01f, -3.66674475e-02f, -8.41936097e-03f, 3.51526029e-02f, 2.86053400e-02f, -4.35673892e-02f,
  1.04036234e-01f, 7.58924261e-02f, -1.19143963e-01f, -2.17379853e-02f, -4.93166409e-02f, 1.82673275e-01f, 3.37308384e-02f, 1.46903126e-02f, 1.43040925e-01f, -2.90714622e-01f,
  1.20066125e-02f, -1.48210704e-01f, -1.54795602e-01f, -8.19499493e-02f, -2.35617399e-01f, -2.59600699e-01f, -1.47776544e-01f, -2.65234411e-02f, 1.12375356e-01f, -1.51374966e-01f,
  1.50526494e-01f, 2.51534969e-01f, -5.81383295e-02f, 1.88914165e-01f, -1.08439870e-01f, 3.35924029e-01f, -2.87966877e-02f, -5.56030422e-02f, 5.05819917e-01f, 1.75513253e-01f,
  -3.07370305e-01f, 1.17495492e-01f, 1.85340330e-01f, 8.25988725e-02f, -3.33948359e-02f, -1.71063438e-01f, 2.87423521e-01f, -4.86040711e-02f, -7.87357315e-02f, 1.69708878e-01f,
  2.34539315e-01f, 1.86249465e-01f, -2.71951929e-02f, -2.11755365e-01f, 2.03548431e-01f, 1.41023695e-01f, 7.62741566e-02f, -7.55934627e-04f, -2.74764430e-02f, 5.82936928e-02f,
  -5.15933968e-02f, -1.01235196e-01f, 9.30382013e-02f, 1.48592532e-01f, 6.40838444e-02f, 3.46861146e-02f, 9.86011792e-03f, -9.04371291e-02f, 5.20794243e-02f, 3.04080397e-02f,
  1.02192380e-01f, 1.04990669e-01f, 1.27452791e-01f, 5.44105135e-02f, -9.91754532e-02f, 2.17224225e-01f, 2.25896146e-02f, 2.40166530e-01f, -2.33348131e-01f, 1.13915890e-01f,
  1.69230178e-01f, 1.15483128e-01f, 2.77178362e-02f, -2.08125457e-01f, 4.60171811e-02f, -6.78858757e-02f, -1.26111344e-01f, 6.96177259e-02f, -5.70036471e-02f, -9.21078697e-02f,
  2.03447491e-01f, 1.81035042e-01f, -1.16935439e-01f, -2.42719933e-01f, -8.69990662e-02f, -6.51902929e-02f, -8.22443664e-02f, 3.86989713e-01f, 3.37922543e-01f, 4.18585658e-01f,
  -1.70110241e-01f, -1.69147640e-01f, 3.31649214e-01f, 2.10038438e-01f, 3.07500008e-02f, 1.80208310e-01f, 2.13663615e-02f, -1.77998524e-02f, 2.77848929e-01f, -1.05859898e-01f,
  2.52715796e-01f, 1.76062152e-01f, -2.40654215e-01f, 4.01463717e-01f, -4.85602021e-02f, 3.20309098e-03f, -6.34821430e-02f, 8.33775848e-02f, 1.00520244e-02f, 2.38923624e-01f,
  -1.22448104e-02f, 3.80371278e-03f, -2.56693573e-03f, 2.55772263e-01f, -3.39117460e-02f, 8.23754892e-02f, 1.15380690e-01f, 1.50962230e-02f, -3.43866795e-02f, 8.53599757e-02f,
  1.88323304e-01f, 5.04212035e-03f, 7.93079063e-02f, 1.46797419e-01f, 1.32375985e-01f, 7.21967742e-02f, -1.94109343e-02f, 2.11948380e-01f, -1.24659702e-01f, 2.49185055e-01f,
  3.69658088e-03f, 1.17318287e-01f, -9.93813500e-02f, 3.06002591e-02f, -1.29952207e-01f, 8.39567408e-02f, 2.16174453e-01f, 2.00475790e-02f, 1.19820811e-01f, -6.03150111e-03f,
  -2.13887945e-01f, -8.11627433e-02f, 2.09801048e-01f, 1.33908376e-01f, -1.75808266e-01f, 3.37834507e-01f, 1.50882021e-01f, -2.76310146e-01f, 1.46781415e-01f, 3.24644387e-01f,
  -1.70286939e-01f, -1.26336977e-01f, -7.14197233e-02f, 2.56423086e-01f, -7.72209913e-02f, 2.60128528e-01f, 2.36204967e-01f, -3.30694288e-01f, -6.58422485e-02f, -8.44824538e-02f,
  -3.95158194e-02f, -1.06478065e-01f, 1.23568960e-01f, 5.98756708e-02f, 1.63407728e-01f, -1.05770610e-01f, 1.95930734e-01f, -1.30011424e-01f, -1.23598352e-01f, 1.52409729e-02f,
  -3.46091211e-01f, -3.91607851e-01f, -4.37622294e-02f, 4.19652015e-01f, 3.15912902e-01f, 1.97890133e-01f, -5.21344356e-02f, 2.09705368e-01f, 3.60057764e-02f, -6.87023625e-02f,
  1.35275856e-01f, 7.65395910e-02f, 1.16857797e-01f, 8.92893374e-02f, 4.74713035e-02f, 1.13670796e-01f, 1.83015332e-01f, 7.42665827e-02f, 1.09484151e-01f, 2.97746897e-01f,
  1.19809657e-01f, 1.74699560e-01f, 1.58108503e-01f, -1.20310094e-02f, 2.35536247e-01f, 1.19600505e-01f, 3.14756222e-02f, 1.21321090e-01f, 1.34374872e-02f, -1.56523183e-01f,
  -1.93183884e-01f, -1.76218785e-02f, 1.75887793e-02f, 3.11628401e-01f, 7.14646578e-02f, -1.00486211e-01f, -1.39110982e-01f, 1.78150803e-01f, 4.40706700e-01f, -1.27806813e-01f,
  -1.64723456e-01f, -2.01394651e-02f, 9.61418748e-02f, -1.09785974e-01f, -1.33431092e-01f, 2.73779333e-01f, 3.33967537e-01f, -6.54060720e-03f, 6.91338256e-02f, 1.06939979e-01f,
  -8.21136981e-02f, 3.22361231e-01f, 4.49876398e-01f, 3.27288121e-01f, -2.40340188e-01f, 1.07757479e-01f, 1.73046768e-01f, 8.97966847e-02f, -1.80545643e-01f, 1.26633227e-01f,
  1.14935011e-01f, 2.99751401e-01f, -1.36194125e-01f, 1.10502996e-01f, -2.03829125e-01f, 4.15980577e-01f, 1.60466149e-01f, 2.82507055e-02f, 5.65026440e-02f, 1.94374591e-01f,
  -3.48281153e-02f, 2.87215233e-01f, 1.72511399e-01f, 1.70609489e-01f, 1.63882419e-01f, 2.46072724e-01f, 3.10370009e-02f, 1.85168684e-01f, 9.81711876e-03f, 1.56414941e-01f,
  1.10400304e-01f, 1.69594288e-01f, 2.22441509e-01f, 1.60001099e-01f, -1.20675052e-02f, 1.75841320e-02f, 1.44457325e-01f, -8.87331516e-02f, 8.55217874e-02f, -1.09850347e-01f,
  1.83847830e-01f, -1.12028204e-01f, -1.98727280e-01f, -4.13456969e-02f, -2.71560967e-01f, 1.09167084e-01f, -2.65655696e-01f, 8.74951929e-02f, 1.61047220e-01f, -8.70926306e-02f,
  3.71741019e-02f, -1.33247212e-01f, 1.90087035e-01f, -2.42909454e-02f, -7.07372800e-02f, 8.13123658e-02f, -2.67030746e-01f, -2.23253682e-01f, 1.06654994e-01f, 4.12427396e-01f,
  2.74453610e-01f, -3.50265086e-01f, 2.84223884e-01f, 6.83579370e-02f, -2.77230859e-01f, 8.97970870e-02f, 4.04214382e-01f, 1.50298774e-01f, -1.01420797e-01f, -2.67632961e-01f,
  4.30083014e-02f, -1.18246049e-01f, -1.34671498e-02f, 9.17146429e-02f, 3.66902530e-01f, -6.75540417e-02f, 2.14481086e-01f, 1.83684722e-01f, -2.53636658e-01f, -1.50411233e-01f,
  1.93319395e-01f, -1.97547972e-01f, 1.89736500e-01f, 1.68480396e-01f, 1.19130954e-01f, 2.03621298e-01f, 4.79803383e-02f, 6.09567314e-02f, 9.34481919e-02f, 1.74086973e-01f,
  -1.01929558e-02f, 1.07474692e-01f, 2.38978282e-01f, 1.76190600e-01f, 2.42722437e-01f, 1.72686875e-01f, 7.03944191e-02f, 1.19546682e-01f, 2.90226966e-01f, 3.01451415e-01f,
  -1.19155124e-01f, 1.75717488e-01f, -1.19777873e-01f, 3.20601650e-02f, -7.23546594e-02f, 1.68162286e-02f, 5.54310605e-02f, 2.17328712e-01f, -6.88752392e-04f, 2.01573789e-01f,
  1.47663563e-01f, 2.46010154e-01f, -4.37811390e-02f, 2.00709775e-01f, 3.24268848e-01f, 1.81429580e-01f, 1.07585065e-01f, 2.94526547e-01f, -1.37305468e-01f, 1.74477383e-01f,
  -5.10388985e-02f, 3.16844545e-02f, 4.42409247e-01f, -2.63466537e-01f, -2.11357802e-01f, 1.01745181e-01f, 6.09807633e-02f, 3.17884654e-01f, 1.55333474e-01f, 2.02744938e-02f,
  9.77871940e-02f, 8.70092586e-02f, -2.95513779e-01f, 2.23974720e-01f, 2.21251734e-02f, 2.29073778e-01f, -1.50903344e-01f, -1.02818280e-01f, 3.48447800e-01f, 2.40193054e-01f,
  -2.80098692e-02f, 2.43737161e-01f, -2.84420718e-02f, 3.19016993e-01f, -5.33812977e-02f, 2.93948323e-01f, 1.27728194e-01f, 2.40633085e-01f, 1.55477822e-01f, 6.32310435e-02f,
  1.41483903e-01f, 8.57809037e-02f, 8.95921811e-02f, 2.18415424e-01f, 6.41427934e-02f, -2.07587760e-02f, 2.28613898e-01f, 1.83964804e-01f, 2.31818900e-01f, 1.93206921e-01f,
  8.31504092e-02f, 3.03742796e-01f, 1.36810303e-01f, 2.82005459e-01f, 2.85084862e-02f, -4.71067540e-02f, -2.01525763e-01f, -3.23637109e-03f, -1.13016963e-01f, 2.40427796e-02f,
  2.84188926e-01f, 2.19616801e-01f, -1.75552920e-01f, 1.07107565e-01f, -1.31629139e-01f, 1.06178656e-01f, 4.46059033e-02f, 1.99952155e-01f, -8.34590122e-02f, -4.35362244e-03f,
  1.05688110e-01f, 2.39460357e-02f, -1.10984214e-01f, 2.68436074e-01f, 1.18502036e-01f, -2.74264485e-01f, 4.79154706e-01f, 3.05225879e-01f, -7.39291981e-02f, 5.59987389e-02f,
  -1.22650124e-01f, 1.06462874e-01f, 1.05125181e-01f, 2.02749968e-01f, -3.05036664e-01f, -1.84051841e-01f, 8.58610868e-02f, 2.04782605e-01f, -3.90222341e-01f, 1.14373602e-01f,
  -2.05362260e-01f, -3.44984770e-01f, 1.28455967e-01f, 5.97868636e-02f, 1.82691053e-01f, 3.68651301e-01f, 1.83118790e-01f, 1.85278699e-01f, -1.73798859e-01f, -7.95642659e-02f,
  9.11171921e-03f, 1.79401115e-01f, 8.25541001e-03f, 6.07692339e-02f, 6.50456399e-02f, 1.87615320e-01f, 5.37031256e-02f, 9.49288160e-03f, 9.53911468e-02f, 9.60589945e-02f,
  -8.25948920e-03f, 1.85333431e-01f, -3.22080702e-02f, 1.64552242e-01f, -8.14014524e-02f, -1.91262797e-01f, 1.99536141e-02f, -6.04795739e-02f, 2.37972394e-01f, -4.58279788e-01f,
  2.09884658e-01f, -6.69645295e-02f, 2.14185610e-01f, -2.97254138e-02f, 9.57123041e-02f, -3.05174470e-01f, -6.55504987e-02f, -2.79023916e-01f, -9.87593606e-02f, -2.06680581e-01f,
  6.67052437e-03f, -2.79096574e-01f, -4.59174901e-01f, -8.69496241e-02f, -3.04909766e-01f, -4.18535501e-01f, 3.13385904e-01f, -5.75966053e-02f, 9.82543826e-03f, 1.98846340e-01f,
  -2.74655730e-01f, 2.47327238e-01f, -9.58680958e-02f, -3.46006192e-02f, 5.50945178e-02f, 4.75817882e-02f, -7.14679211e-02f, -1.17453232e-01f, 1.43529668e-01f, 3.82375717e-01f,
  2.84158468e-01f, 2.04848275e-01f, 1.68718964e-01f, 1.34564593e-01f, 3.32802296e-01f, 3.02396923e-01f, -1.79269269e-01f, -2.24385902e-01f, 4.96756077e-01f, -2.03843066e-03f,
  1.82356089e-01f, 1.61153108e-01f, 3.08518112e-01f, 4.99387868e-02f, -1.49485469e-01f, 1.42876148e-01f, 6.51241615e-02f, 1.86981544e-01f, 2.81738371e-01f, 2.22583145e-01f,
  1.60457432e-01f, 2.52412111e-01f, 1.75048307e-01f, 1.31367326e-01f, 2.46437397e-02f, 1.29861414e-01f, 3.32171284e-03f, 1.56692997e-01f, 2.23371685e-01f, 2.12275848e-01f,
  -1.39015764e-01f, 1.26631223e-02f, 1.37717009e-01f, -8.41964707e-02f, -7.56260082e-02f, 2.73803025e-02f, -1.06068678e-01f, 1.02243766e-01f, -4.99431044e-02f, -1.52341902e-01f,
  -1.55471385e-01f, -1.87371135e-01f, -1.94130331e-01f, 5.41809089e-02f, 1.61401242e-01f, -1.14125438e-01f, -1.95763081e-01f, -1.52312398e-01f, 1.94307528e-02f, -1.27913833e-01f,
  2.57783439e-02f, 8.74797851e-02f, -2.73713559e-01f, -1.16011478e-01f, -3.71352136e-02f, 3.75687271e-01f, -2.36801729e-01f, -1.67732328e-01f, 4.82440412e-01f, -2.22834274e-01f,
  -1.69949204e-01f, 2.27132455e-01f, 2.11399376e-01f, 4.23193574e-02f, 2.76852436e-02f, -1.34925306e-01f, -1.12905830e-01f, -2.87321627e-01f, 1.37314141e-01f, 5.98960109e-02f,
  1.98004827e-01f, -1.42161891e-01f, 2.97593415e-01f, -1.19870938e-02f, -1.68460701e-02f, -2.77895749e-01f, 1.67329282e-01f, -1.38488755e-01f, 7.81089067e-02f, -2.84316414e-03f,
  1.22025169e-01f, 9.78117660e-02f, -8.53492394e-02f, 1.12337619e-01f, 8.54484811e-02f, 6.05081096e-02f, 4.54654433e-02f, 1.17681406e-01f, 2.92476211e-02f, 2.71803308e-02f,
  3.56674045e-02f, 1.82873100e-01f, 5.39331883e-02f, -1.22739738e-02f, 1.88935578e-01f, 6.83923066e-02f, 8.95591080e-02f, 4.82960567e-02f, 6.18001483e-02f, 1.89714581e-01f,
  -8.48051980e-02f, 5.06421328e-02f, 1.04130767e-02f, -2.01388542e-02f, 1.43672943e-01f, -6.52120486e-02f, 2.06438825e-01f, -1.04957268e-01f, -2.04913095e-01f, -8.65367576e-02f,
  -6.32890016e-02f, 9.05066431e-02f, -9.53390822e-02f, 8.84307325e-02f, 2.07400218e-01f, -2.37596408e-01f, 3.16416830e-01f, 2.52302021e-01f, -2.01070204e-01f, -2.30088800e-01f,
  -1.47463277e-01f, 2.92071342e-01f, -2.23976448e-01f, 7.10296482e-02f, 2.70384938e-01f, 1.14640193e-02f, 8.72003511e-02f, -5.89813525e-03f, 9.90564078e-02f, -1.78856403e-01f,
  2.95127183e-01f, -1.00648232e-01f, 2.89041728e-01f, 3.13973695e-01f, 4.65028696e-02f, 2.27606311e-01f, -1.79318562e-01f, 3.15376669e-02f, -1.39725953e-01f, 8.35858136e-02f,
  -9.62641463e-03f, 2.57459641e-01f, 1.40864253e-01f, 6.75324947e-02f, 1.65402163e-02f, -2.30109580e-02f, 6.28860891e-02f, 1.26211077e-01f, -4.00490612e-02f, 7.53099024e-02f,
  -8.24335292e-02f, 2.86589786e-02f, 4.15401766e-03f, 5.69637073e-03f, 1.06675839e-02f, 2.44620204e-01f, -9.36609693e-03f, -3.42893675e-02f, 8.97893682e-02f, 2.55449325e-01f,
  2.12510929e-01f, -3.06949485e-02f, 3.00669931e-02f, -1.62429377e-01f, 6.73091635e-02f, -2.59669691e-01f, 1.07261129e-01f, 2.35122293e-01f, -5.04496172e-02f, 2.31645882e-01f,
  -8.67490470e-02f, -1.79769337e-01f, 9.23445821e-02f, 3.12586844e-01f, 1.68158337e-01f, -4.96412665e-02f, -1.01491079e-01f, 1.22451529e-01f, -1.96385100e-01f, 1.55840933e-01f,
  -3.83558571e-01f, -3.03753644e-01f, 5.79276145e-01f, 4.84142601e-01f, 3.22271824e-01f, -1.99192494e-01f, -2.71009505e-01f, 4.22038734e-02f, -2.65329272e-01f, -2.23137230e-01f,
  8.35150853e-03f, -3.11683953e-01f, 1.04591370e-01f, 1.01321200e-02f, -7.83547983e-02f, -2.69912966e-02f, -7.38791525e-02f, -2.20642276e-02f, -9.24059600e-02f, -3.79728638e-02f,
  3.45909625e-01f, 1.77064210e-01f, 2.62124389e-01f, -2.85394732e-02f, -2.19793379e-01f, -9.43905115e-02f, 5.56906350e-02f, 4.36409041e-02f, 1.55617952e-01f, -6.87821303e-03f,
  4.02080733e-03f, 1.30270123e-01f, 2.06532270e-01f, 1.92814574e-01f, 4.69125919e-02f, 8.01911205e-02f, 2.08266780e-01f, 5.32503985e-02f, -2.79809684e-02f, 1.59542322e-01f,
  1.56659648e-01f, 7.53998617e-03f, 9.45869684e-02f, 1.13098763e-01f, 7.37001374e-02f, 5.04423529e-02f, -3.92710194e-02f, 3.08622986e-01f, -2.73852974e-01f, 1.85939923e-01f,
  2.52848089e-01f, 1.58861116e-01f, -3.12134679e-02f, -1.34934068e-01f, 2.81022545e-02f, -2.58709341e-01f, -1.61556765e-01f, 2.46768426e-02f, -2.11190075e-01f, -7.45053664e-02f,
  -8.44686627e-02f, -6.42661229e-02f, 1.96204290e-01f, -2.68094778e-01f, 2.02455476e-01f, 1.51290745e-01f, -5.41417487e-02f, -9.38616470e-02f, -2.10008159e-01f, 3.82651508e-01f,
  -2.36707732e-01f, -2.01995969e-01f, 2.43228078e-01f, 1.91791266e-01f, 2.98975445e-02f, 7.25386618e-03f, 1.48275942e-01f, -1.34796932e-01f, 2.54878640e-01f, -1.16433486e-01f,
  3.84905159e-01f, 2.42804468e-01f, -1.26402378e-01f, 2.69761950e-01f, -1.38367474e-01f, 5.26753664e-02f, 4.27217782e-01f, 7.28467256e-02f, 1.05409496e-01f, 1.46107763e-01f,
  1.66846842e-01f, 2.10628048e-01f, 2.69154966e-01f, 7.25292861e-02f, 8.27767849e-02f, 1.42189264e-01f, 1.04703061e-01f, 2.43772477e-01f, 1.98405102e-01f, -1.11744221e-05f,
  4.05516624e-01f, 2.61798203e-01f, 2.41262838e-01f, 6.02209456e-02f, 2.34379560e-01f, 4.23439354e-01f, 5.55994548e-02f, 4.14695255e-02f, 7.81214610e-02f, 1.34102434e-01f,
  -3.07018310e-01f, 3.25363167e-02f, -1.32043764e-01f, -5.11566959e-02f, 7.05441162e-02f, 2.16302022e-01f, 1.22304440e-01f, 8.70992094e-02f, -1.18547194e-01f, 1.37693778e-01f,
  1.61651611e-01f, -1.50056463e-02f, 7.42319748e-02f, -1.52413130e-01f, 1.19639374e-01f, 1.78666450e-02f, -1.53619498e-01f, 2.09571317e-01f, 3.50442588e-01f, -5.22932932e-02f,
  3.76774698e-01f, -2.74124444e-01f, -7.09432662e-02f, 4.39195409e-02f, 1.69321582e-01f, -3.31189893e-02f, 2.75631130e-01f, 3.31904799e-01f, -3.58466417e-01f, -2.35139504e-01f,
  3.31868194e-02f, -8.21628328e-03f, -3.77624899e-01f, 1.22479210e-03f, -1.33353412e-01f, -3.39138269e-01f, 1.23250082e-01f, 1.68311089e-01f, -2.47980893e-01f, 2.63424724e-01f,
  4.59248871e-01f, 5.34282513e-02f, -2.48911493e-02f, -2.26904318e-01f, 1.23951800e-01f, -1.36540579e-02f, 8.92055258e-02f, 9.73997936e-02f, -1.25095909e-02f, 4.55531888e-02f,
  1.12250209e-01f, -9.42139328e-03f, 6.65676221e-02f, 1.88421816e-01f, -1.02533758e-01f, -1.33331671e-01f, 2.49847695e-01f, 1.45621076e-01f, 1.62084192e-01f, 1.62168890e-02f,
  1.70329466e-01f, -2.12017205e-02f, 2.41025627e-01f, 3.75920832e-01f, 8.40139613e-02f, -2.54548132e-01f, 7.45530576e-02f, -1.23321787e-01f, -4.90183830e-01f, -2.92696565e-01f,
  3.49620402e-01f, -2.33966820e-02f, 1.78015023e-01f, -7.76933804e-02f, 1.44793883e-01f, -2.17765033e-01f, 3.21039706e-01f, 9.89607498e-02f, -1.58942696e-02f, 1.34731337e-01f,
  -1.72240451e-01f, -2.76274025e-01f, 2.66103536e-01f, 3.74810457e-01f, -3.67685020e-01f, -2.75209099e-02f, 4.71228451e-01f, 5.66547364e-02f, 4.44175959e-01f, 6.31896481e-02f,
  1.56983778e-01f, 3.92980203e-02f, 2.63291836e-01f, 2.17443928e-01f, 2.11623028e-01f, -1.02134876e-01f, 2.85046190e-01f, -2.68477723e-02f, 1.56807452e-01f, 2.54541188e-01f,
  2.48992831e-01f, 1.32031158e-01f, -2.22592652e-01f, -2.70666689e-01f, -1.82999879e-01f, -8.04812461e-02f, 1.00225009e-01f, 1.42904520e-01f, 1.58253372e-01f, 5.38298003e-02f,
  1.69596583e-01f, 8.61882418e-02f, 5.66059984e-02f, 2.03580081e-01f, 3.17577925e-03f, -1.97303165e-02f, 4.07022312e-02f, 1.19076863e-01f, 2.11223904e-02f, 1.50490059e-02f,
  1.63370937e-01f, 1.91304162e-01f, 2.26590186e-02f, -7.37390947e-03f, 2.05379367e-01f, 1.00814357e-01f, 2.42671549e-01f, -5.87581620e-02f, 5.24108000e-02f, -3.50460112e-01f,
  2.36729205e-01f, -3.29271883e-01f, -2.15246409e-01f, 2.02533141e-01f, 2.01655626e-01f, 2.78959543e-01f, -9.71549302e-02f, -3.40402722e-01f, 9.63118747e-02f, 4.22208980e-02f,
  1.92840368e-01f, -8.57399404e-02f, -3.85851562e-01f, 8.03035870e-02f, 1.78722180e-02f, 1.25567272e-01f, 1.54900104e-01f, 2.79259324e-01f, 3.67303789e-01f, 2.19423667e-01f,
  4.89496440e-01f, -1.51811808e-01f, -1.11221924e-01f, 2.96722710e-01f, 8.99908245e-02f, -2.74042428e-01f, -1.50738522e-01f, -1.90532804e-01f, 4.39871281e-01f, -6.07466605e-03f,
  -9.93471965e-02f, 1.61372513e-01f, 8.69294778e-02f, -2.38284003e-02f, 8.28430355e-02f, -2.66796947e-01f, 3.60995203e-01f, 2.64247656e-01f, 2.62430787e-01f, -1.99977055e-01f,
  -4.47611175e-02f, -1.32087752e-01f, 2.78437376e-01f, 4.76264432e-02f, 7.11789504e-02f, 1.20164290e-01f, 1.34625912e-01f, 1.06276415e-01f, -1.10268459e-01f, 1.42013386e-01f,
  -2.32436303e-02f, 1.22185729e-01f, -1.23060476e-02f, 1.63483694e-01f, -2.53854003e-02f, 2.14417368e-01f, 2.55022049e-01f, 2.40801930e-01f, 9.29873586e-02f, 1.37347773e-01f,
  1.06578387e-01f, -1.58766240e-01f, 9.87335294e-02f, 1.70708194e-01f, -8.80724117e-02f, -4.97527383e-02f, 8.85011852e-02f, -3.63210402e-02f, -2.06385434e-01f, 1.74297303e-01f,
  -6.59328466e-03f, 1.68858558e-01f, 1.57954708e-01f, 3.03076524e-02f, 4.87950332e-02f, 2.57092893e-01f, 1.02758870e-01f, -1.99690968e-01f, 9.57243443e-02f, -2.70690564e-02f,
  -2.60544359e-03f, -1.67937577e-01f, -3.95311862e-02f, -4.13346104e-02f, 9.58111882e-02f, -2.48286024e-01f, 5.09207621e-02f, -2.01586202e-01f, -3.63119900e-01f, -1.88968703e-02f,
  4.30051923e-01f, 2.02618375e-01f, 5.01881763e-02f, 7.09504783e-02f, 2.05850288e-01f, 2.75349975e-01f, -2.79625356e-02f, 1.94930568e-01f, -1.28539160e-01f, -4.77691293e-02f,
  -2.78166443e-01f, -2.22676232e-01f, 2.69516140e-01f, 4.39388037e-01f, -6.22321367e-02f, 7.54741952e-02f, 7.72326142e-02f, 1.04398258e-01f, 1.96109656e-02f, -5.11238612e-02f,
  8.08048993e-02f, 7.35270008e-02f, 1.11682266e-01f, 3.47615592e-02f, 1.91153750e-01f, -5.45292310e-02f, 2.26294786e-01f, 1.73943430e-01f, 1.01834722e-01f, -4.84532714e-02f,
  1.09978080e-01f, 3.18290561e-01f, 8.54736045e-02f, -1.01480307e-02f, 1.15822025e-01f, 1.67391211e-01f, -1.84834123e-01f, -2.21798912e-01f, -3.14019732e-02f, -8.05104245e-03f,
  -2.95745451e-02f, -1.91405982e-01f, 1.79443225e-01f, -6.35063648e-02f, -6.66251360e-03f, 1.58013508e-01f, 1.25452936e-01f, -7.71368295e-02f, -1.26890719e-01f, 3.96033488e-02f,
  1.53113365e-01f, -1.92368552e-02f, -9.16138142e-02f, 5.01821153e-02f, 4.26571459e-01f, 1.68594643e-01f, -2.79766321e-01f, -1.41882868e-02f, 2.18078718e-01f, 5.52596338e-02f,
  3.27011645e-01f, -6.11686222e-02f, 3.08897614e-01f, 2.41531968e-01f, -2.69819677e-01f, 5.31136580e-02f, 1.47467047e-01f, 1.97025865e-01f, -2.07230181e-01f, 5.31722121e-02f,
  -1.73361972e-01f, -2.28053063e-01f, 1.77666888e-01f, 1.01485461e-01f, -1.24080747e-01f, 3.14025953e-02f, -9.10770381e-04f, 2.04956569e-02f, 6.25624210e-02f, -6.28871471e-02f,
  2.48254240e-02f, 1.29393175e-01f, -3.35193202e-02f, 4.72016446e-02f, 1.46021232e-01f, 1.00783318e-01f, 1.28122181e-01f, 2.83106685e-01f, 1.03874549e-01f, 8.12545568e-02f,
  -3.07571739e-02f, 6.36268556e-02f, 2.84781933e-01f, 1.31724074e-01f, 4.41943109e-02f, 1.04395978e-01f, 4.02094536e-02f, 1.28704295e-01f, 6.65605962e-02f, 1.83731183e-01f,
  3.73054706e-02f, -1.44123897e-01f, 2.79817078e-02f, -1.57187302e-02f, -8.44832696e-03f, 2.08139122e-02f, -2.65491959e-02f, 1.52625181e-02f, -9.53441560e-02f, 9.26870778e-02f,
  1.10186681e-01f, 1.14195175e-01f, 5.80030680e-02f, -1.88077748e-01f, 1.72732055e-01f, 1.01460554e-01f, -3.14901978e-01f, 1.71773732e-01f, -2.68817663e-01f, -2.07568362e-01f,
  3.28651220e-01f, 4.92472827e-01f, 2.10817635e-01f, 4.55545262e-02f, 3.13605160e-01f, -9.15534347e-02f, -4.21272404e-02f, 3.17640185e-01f, -8.25936496e-02f, -1.17896974e-01f,
  -1.09535113e-01f, -1.10421039e-01f, -1.11246742e-01f, -2.95120925e-01f, -1.92513242e-02f, -7.93120638e-02f, 1.37148991e-01f, 2.01696694e-01f, 2.66684711e-01f, 1.19790509e-02f,
  -1.47078916e-01f, 4.18263860e-02f, -8.86750743e-02f, -1.52887955e-01f, 1.06630147e-01f, 1.27432734e-01f, 1.03087127e-01f, 1.21924736e-01f, 7.57792369e-02f, 1.62414402e-01f,
  1.39425114e-01f, 2.06983924e-01f, 5.42442501e-02f, 1.00443892e-01f, 2.80289531e-01f, 2.41210535e-01f, 1.47504523e-01f, 7.73076862e-02f, 2.50456244e-01f, 2.66525537e-01f,
  1.01500869e-01f, 7.30398968e-02f, 1.13986544e-02f, 6.57570735e-02f, -9.87366140e-02f, 3.02596297e-02f, 4.26602773e-02f, -1.83193851e-02f, -4.97179031e-02f, 1.03289880e-01f,
  -4.33964171e-02f, 7.69968182e-02f, -6.38794899e-02f, 1.54035911e-01f, 6.40683770e-02f, -6.39230534e-02f, 8.08289871e-02f, -5.60176373e-02f, 1.66290909e-01f, 2.45867446e-02f,
  1.71847865e-02f, 1.82895675e-01f, -1.53792126e-03f, 1.21798376e-02f, 3.58915150e-01f, -2.20224544e-01f, -2.22684130e-01f, -8.57252404e-02f, 1.89971685e-01f, 7.04152659e-02f,
  3.23542655e-02f, 1.97627589e-01f, 2.18431354e-01f, -4.39632200e-02f, -2.52479017e-01f, -8.80475044e-02f, 5.32422327e-02f, -1.14403851e-01f, -1.26416847e-01f, -1.38082160e-02f,
  2.79571593e-01f, 1.62753686e-01f, -7.38308057e-02f, 2.93390810e-01f, 1.95521235e-01f, 4.34492193e-02f, 1.27316684e-01f, -1.00878835e-01f, 1.25291422e-01f, 1.55156195e-01f,
  4.68815081e-02f, 1.13366343e-01f, 1.73510741e-02f, 1.49041668e-01f, 1.44995853e-01f, -1.24774888e-01f, 1.08670220e-02f, 1.40859112e-01f, 2.08853647e-01f, 6.37970343e-02f,
  9.45818201e-02f, 1.06489092e-01f, 5.53659052e-02f, -8.13053083e-03f, 2.60972194e-02f, 4.35279608e-02f, 7.08944723e-02f, 1.12717427e-01f, 1.31368950e-01f, -1.76171064e-01f,
  2.14344487e-01f, -2.98518628e-01f, -3.58710229e-01f, 6.57047257e-02f, 3.70566994e-01f, 1.58859193e-01f, 2.62421891e-02f, -1.89013273e-01f, -2.39560660e-02f, -2.06546575e-01f,
  2.01687962e-01f, 4.95564602e-02f, -3.30213666e-01f, 1.39345512e-01f, 1.70777459e-02f, -1.03998654e-01f, 2.35619396e-01f, 4.68692005e-01f, 4.57929187e-02f, -1.61502063e-01f,
  3.88864130e-01f, 4.34833653e-02f, -1.48500562e-01f, 3.39212298e-01f, 1.76336423e-01f, -2.50844747e-01f, -9.64596644e-02f, -1.13051847e-01f, 1.80986255e-01f, -1.69295013e-01f,
  -3.90879950e-03f, 1.00451067e-01f, 9.77699235e-02f, -1.54432148e-01f, 2.51593202e-01f, -3.50313097e-01f, -1.80797651e-02f, 2.53599793e-01f, 9.42489039e-03f, -3.49350691e-01f,
  5.50292023e-02f, 1.88506186e-01f, 3.99799645e-03f, 1.28324926e-01f, 6.01559170e-02f, 1.35793954e-01f, 5.09124696e-02f, 6.68944642e-02f, 1.18570246e-01f, 4.40116264e-02f,
  5.51131666e-02f, -1.20767187e-02f, 2.34752759e-01f, 2.49564603e-01f, 1.59612820e-01f, 2.89275516e-02f, 1.84632279e-02f, 2.77431577e-01f, 1.01668760e-01f, 1.87737510e-01f,
  1.98225249e-02f, -5.92187606e-02f, -7.79836401e-02f, -5.13773151e-02f, 9.07785222e-02f, 1.54692173e-01f, 2.11689323e-01f, -3.28934006e-02f, -1.46588087e-01f, -1.69978440e-01f,
  -1.16048247e-01f, 1.46104679e-01f, -1.48863241e-04f, 5.02550276e-03f, -3.04127425e-01f, -6.95969164e-02f, 1.88394725e-01f, -1.05710521e-01f, -9.92635041e-02f, 2.98147827e-01f,
  3.48001905e-02f, -1.15334459e-01f, 2.65346199e-01f, 2.58010447e-01f, -9.97008383e-02f, 3.36331911e-02f, -3.07908915e-02f, 1.94368154e-01f, 1.66412160e-01f, 2.34247416e-01f,
  -1.57354191e-01f, 1.62020475e-02f, -1.24891378e-01f, 1.44729078e-01f, -2.84923166e-01f, -3.60081467e-04f, -2.40041271e-01f, -1.72547579e-01f, 1.85748681e-01f, 1.28518417e-01f,
  3.95237833e-01f, 3.69422525e-01f, -1.66346982e-01f, 8.44767019e-02f, 1.54754162e-01f, -4.92971092e-02f, 1.61803275e-01f, 9.05097127e-02f, 1.03847161e-01f, 3.15529294e-02f,
  -7.20233470e-02f, 1.05898999e-01f, 1.12201482e-01f, -1.03413850e-01f, 4.18486744e-02f, -5.61758727e-02f, 2.00941086e-01f, 9.87051874e-02f, 1.36017188e-01f, -5.41079529e-02f,
  1.21733230e-02f, 7.72020221e-02f, 1.32714480e-01f, 1.08713895e-01f, 6.08753152e-02f, 2.26736031e-02f, 1.53130852e-03f, -7.86289349e-02f, 1.43121526e-01f, -1.70533016e-01f,
  -9.73670483e-02f, 3.17060463e-02f, 1.55302107e-01f, 9.66330245e-02f, 5.89874908e-02f, -8.08107946e-03f, 1.85327437e-02f, -9.19082835e-02f, 4.95438613e-02f, 1.65124126e-02f,
  -5.70629872e-02f, -1.40533652e-02f, 8.61957744e-02f, 5.30642420e-02f, 3.40994000e-01f, 3.20126802e-01f, 7.70639107e-02f, -3.26567531e-01f, -5.89739010e-02f, 3.93788107e-02f,
  -6.80247992e-02f, 2.00118840e-01f, 1.45179898e-01f, 1.52505720e-02f, -2.61951052e-02f, 7.34449998e-02f, 6.79965764e-02f, 1.85450539e-01f, 9.96198207e-02f, 2.00777695e-01f,
  -9.86602604e-02f, 4.38168421e-02f, 1.02602817e-01f, 9.60235670e-02f, 7.16123544e-03f, 1.75773203e-01f, 2.23141924e-01f, 1.51207834e-01f, 1.51794478e-01f, 2.14402303e-02f,
  1.89063028e-01f, 1.53085431e-02f, 1.04313411e-01f, -6.54009506e-02f, 1.43525541e-01f, 8.89475569e-02f, 1.14588261e-01f, 2.36083344e-01f, 6.56946674e-02f, 1.17719740e-01f,
  3.23901996e-02f, 2.00911120e-01f, -1.01316608e-01f, 1.92875028e-01f, 2.45625079e-01f, 7.21873343e-02f, 1.46911308e-01f, 9.76687223e-02f, 6.81207404e-02f, -1.33861676e-01f,
  2.27465220e-02f, 3.07696700e-01f, -2.35695884e-01f, 1.04105189e-01f, 2.98240989e-01f, 2.05517739e-01f, -1.79735750e-01f, -1.10114388e-01f, -1.58212736e-01f, -2.01641560e-01f,
  -9.95059907e-02f, 1.17244937e-01f, -1.73534408e-01f, -3.72110046e-02f, 1.45338356e-01f, -1.90617159e-01f, 1.67274877e-01f, -2.76306927e-01f, 4.38036732e-02f, -1.29422292e-01f,
  3.29053178e-02f, 1.24809332e-01f, 9.46179032e-02f, 2.74403065e-01f, -3.28108698e-01f, -3.22378755e-01f, 1.03426725e-01f, 1.31808326e-01f, 3.12249571e-01f, 1.11933082e-01f,
  3.21346283e-01f, -3.35435346e-02f, 3.41332346e-01f, 6.39561042e-02f, 3.44101965e-01f, 3.24061930e-01f, -3.19474190e-01f, 3.18673432e-01f, -1.94695801e-01f, -1.26002664e-02f,
  5.89205027e-01f, 4.16672409e-01f, 4.83352877e-02f, 1.32556245e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.23844664e-02f, 1.56894967e-01f, 2.11785249e-02f, 1.18168481e-01f, 7.68508166e-02f, 9.66450050e-02f, 9.99850184e-02f, 1.00755230e-01f, 1.53803110e-01f, 1.61487728e-01f,
  1.66559279e-01f, 1.31687641e-01f, 9.00183842e-02f, 4.52765822e-02f, 1.33669987e-01f, 1.02303579e-01f, 1.00515738e-01f, 1.67132020e-01f, 7.06735328e-02f, 6.05598465e-02f,
  1.56456932e-01f, 1.28038138e-01f, 1.11345626e-01f, 9.01470408e-02f, 1.36620834e-01f, 1.31131679e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.32440920e-02f, 1.42700136e-01f, -1.27835304e-01f, 1.48790106e-01f, 6.56771660e-02f, 1.27612859e-01f, 1.64552495e-01f, -8.68458524e-02f, 1.82897508e-01f, 1.13200709e-01f,
  -2.32027128e-01f, 5.17997332e-02f, 7.70955905e-02f, -2.26557717e-01f, 5.21952622e-02f, -1.52515873e-01f, 9.98974442e-02f, -1.43335294e-02f, 4.95475158e-02f, -1.48621514e-01f,
  -7.44545385e-02f, 1.13314904e-01f, -1.98412076e-01f, 2.27168664e-01f, 1.31383315e-01f, -1.21360175e-01f, 1.00658633e-01f, -2.79864460e-01f, -3.40323672e-02f, -3.25383365e-01f,
  3.77155513e-01f, 2.42160395e-01f, -5.70649281e-02f, 2.04614758e-01f, 2.08469472e-04f, 7.35648349e-03f, -1.71891987e-01f, 2.67407596e-01f, -2.91202217e-01f, -2.79863209e-01f,
  1.38744369e-01f, 2.39430130e-01f, 3.25512975e-01f, 5.45596957e-01f, -4.21546936e-01f, -1.31005317e-01f, 5.37951291e-02f, -4.16088611e-01f, -1.20239891e-01f, -2.26006597e-01f,
  3.67474765e-01f, -2.13987976e-01f, 3.83824766e-01f, -2.99791992e-01f, 1.20943531e-01f, -2.66870022e-01f, -2.71316260e-01f, -2.27174580e-01f, -3.84815663e-01f, -1.49253711e-01f,
  3.45302895e-02f, -4.46255714e-01f, -2.21620146e-02f, 1.89391017e-01f, -1.52576342e-01f, -1.07520260e-01f, 2.50069708e-01f, -2.84291357e-01f, 9.29996818e-02f, 6.08119480e-02f,
  8.96490291e-02f, 2.37116665e-01f, -5.47655784e-02f, 1.06566772e-02f, 2.47185394e-01f, -2.32517347e-01f, -5.03410259e-03f, 7.62621593e-03f, -3.38912010e-01f, 1.96858719e-01f,
  -4.70625907e-02f, -2.27832198e-01f, 3.81518245e-01f, -2.38561988e-01f, 2.04216152e-01f, 2.44768023e-01f, 4.23178583e-01f, 4.50557321e-02f, -8.02424252e-02f, 1.17662415e-01f,
  2.31277630e-01f, -2.98844814e-01f, 2.57019222e-01f, 2.41127327e-01f, -4.44284379e-01f, -3.76016289e-01f, -1.08591385e-01f, 1.10772192e-01f, 1.02997191e-01f, -2.24748686e-01f,
  -2.65132576e-01f, -5.65367602e-02f, -2.68372238e-01f, 2.29937375e-01f, -4.76300836e-01f, 2.73174673e-01f, -3.53838772e-01f, -2.47290079e-02f, -5.47139347e-01f, -4.00181562e-01f,
  -6.34479761e-01f, -4.36024994e-01f, 5.01354873e-01f, -8.06758180e-02f, 1.31839365e-01f, -4.54947263e-01f, 8.10952187e-02f, -5.16368188e-02f, 2.72719473e-01f, 3.60564053e-01f,
  -1.86756015e-01f, 1.24979749e-01f, -3.48683685e-01f, -2.15701222e-01f, 3.33396941e-01f, -1.88084453e-01f, 1.74604550e-01f, -1.44436941e-01f, 2.66931474e-01f, 2.11832821e-01f,
  -5.09955920e-02f, -1.15955494e-01f, -1.17632881e-01f, 1.01859413e-01f, -1.50777800e-02f, -8.02116818e-04f, -8.05266276e-02f, 9.38829333e-02f, 6.14887569e-03f, -2.05008790e-01f,
  3.95007879e-02f, -4.43424508e-02f, -1.93668514e-01f, -4.58699204e-02f, -9.29063559e-02f, -3.73390391e-02f, 9.98767689e-02f, 1.54093839e-02f, -1.65212989e-01f, -1.91104487e-01f,
  1.28010228e-01f, -1.61609814e-01f, -1.51244506e-01f, -2.61105448e-01f, -1.52770147e-01f, -2.43479535e-01f, 2.89029896e-01f, -2.33952478e-01f, 1.38616309e-01f, -9.40437540e-02f,
  -9.61170532e-03f, 1.51807159e-01f, -5.94750717e-02f, 2.57615536e-01f, -2.14678526e-01f, 2.06674244e-02f, -4.28564459e-01f, 1.54670268e-01f, -2.30368346e-01f, 5.65116145e-02f,
  -2.10451216e-01f, -9.38975438e-02f, -2.78324068e-01f, 1.47321954e-01f, -4.68613923e-01f, 2.75014728e-01f, 3.29462528e-01f, 3.66061777e-01f, -4.09124762e-01f, 3.30808133e-01f,
  -3.02261114e-01f, -4.04983729e-01f, -5.50880611e-01f, 2.72128552e-01f, -3.19003761e-01f, -2.61222363e-01f, 2.08075941e-01f, -4.38466370e-01f, -2.18625277e-01f, 2.78551608e-01f,
  -4.30654109e-01f, -1.02381863e-01f, -2.47293279e-01f, 1.73397571e-01f, -2.03314647e-01f, 1.74275935e-01f, -2.76412606e-01f, -2.29962781e-01f, -1.72898322e-01f, -1.37605160e-01f,
  1.98063061e-01f, -9.70088989e-02f, 1.38269305e-01f, -2.96606153e-01f, -2.02893645e-01f, -7.56453648e-02f, -5.33537008e-02f, -4.33391392e-01f, -2.89715081e-01f, -1.64193958e-02f,
  -1.32686555e-01f, -1.56960025e-01f, -1.28351048e-01f, -2.27907270e-01f, -5.26809514e-01f, -1.23324983e-01f, 5.79018705e-02f, -2.39143521e-01f, 4.17816669e-01f, 3.15724283e-01f,
  1.62433609e-01f, 1.44858673e-01f, 4.05509651e-01f, 1.97045416e-01f, 4.89541024e-01f, 3.24681491e-01f, -5.84895199e-04f, 2.81273246e-01f, 2.96629369e-01f, -9.87039208e-02f,
  2.73452699e-01f, -6.77493989e-01f, 2.13421181e-01f, -4.92327243e-01f, 1.48236156e-01f, -2.36494884e-01f, 3.78223330e-01f, -2.07686022e-01f, 3.23546045e-02f, -6.13461852e-01f,
  -1.24743879e-01f, -4.46629435e-01f, 1.43203303e-01f, -1.24600463e-01f, 6.22297488e-02f, -5.15110552e-01f, 2.05389246e-01f, -2.24201545e-01f, 2.59011447e-01f, -2.29208305e-01f,
  -1.85862035e-01f, -3.37692280e-03f, -3.10952634e-01f, -2.34681711e-01f, 6.75399527e-02f, 2.89380133e-01f, 2.51374483e-01f, -1.49296284e-01f, 2.33015388e-01f, -1.35972723e-01f,
  8.06785077e-02f, -1.50372565e-01f, -1.01842642e-01f, 1.39268279e-01f, -2.34332159e-01f, 1.55219138e-01f, -6.80623055e-02f, -4.44714278e-02f, 1.46962469e-02f, -3.02770250e-02f,
  1.10803723e-01f, -5.91595322e-02f, 5.04199117e-02f, 5.52038513e-02f, -9.36914682e-02f, -2.28788126e-02f, 2.01866746e-01f, -1.69414341e-01f, 3.11367214e-02f, -1.68376073e-01f,
  -6.70787320e-02f, -3.52943033e-01f, 3.36385518e-01f, 9.47363526e-02f, 1.89550087e-01f, 4.62937690e-02f, -8.71650726e-02f, 2.47178778e-01f, -2.29781821e-01f, -2.50112623e-01f,
  3.90209444e-02f, 1.51245698e-01f, -9.25832689e-02f, 4.95436043e-01f, 2.17792783e-02f, -2.62289286e-01f, 1.16475150e-01f, 3.68657976e-01f, 3.86361390e-01f, -3.45525563e-01f,
  1.07175380e-01f, -4.84643131e-01f, -5.88469058e-02f, 2.97157526e-01f, -3.27869475e-01f, -1.89807609e-01f, -4.80869748e-02f, -2.07965508e-01f, 3.22186530e-01f, 3.92744899e-01f,
  -3.90226334e-01f, -4.90019292e-01f, -4.05024439e-01f, 2.98279852e-01f, 2.00574368e-01f, 8.24249983e-02f, -6.66523039e-01f, 3.75729889e-01f, 1.79219991e-02f, 2.47959420e-01f,
  8.68434608e-02f, -1.73663095e-01f, 7.98315555e-02f, 4.69730049e-02f, -4.25261334e-02f, -2.74076074e-01f, -1.18128665e-01f, 1.40216425e-01f, 1.53898031e-01f, 8.60110819e-02f,
  -1.41864330e-01f, 3.28262389e-01f, -7.00024590e-02f, 2.56018396e-02f, 1.88739866e-01f, 8.31692964e-02f, 1.32806703e-01f, 7.32578561e-02f, -2.38117695e-01f, -3.45198214e-02f,
  -5.02224304e-02f, 2.55808413e-01f, -2.04696313e-01f, 3.11091721e-01f, 1.25487059e-01f, 3.68833035e-01f, 6.04613572e-02f, 3.33915621e-01f, -2.31459901e-01f, 2.49977484e-01f,
  2.21240118e-01f, -2.14624524e-01f, -1.31269023e-01f, -3.42584103e-01f, 1.38768241e-01f, -3.18068057e-01f, 2.91834563e-01f, -3.52950722e-01f, 3.74282002e-01f, 1.65360704e-01f,
  -1.36834726e-01f, -1.04970850e-01f, -3.79679471e-01f, 3.80300522e-01f, -2.40234528e-02f, -9.98193249e-02f, 1.62215352e-01f, 5.39750904e-02f, -3.56164217e-01f, -4.16152984e-01f,
  1.65794462e-01f, -5.25042117e-01f, -1.11011028e-01f, 1.55168980e-01f, 5.49541414e-02f, -1.01627363e-02f, -1.22261703e-01f, 1.89221069e-01f, -4.24582064e-01f, 9.06027779e-02f,
  3.20031643e-01f, 6.49485737e-02f, 2.48260230e-01f, -5.88119209e-01f, -8.26623514e-02f, -8.65977705e-02f, -2.81413376e-01f, 2.12805465e-01f, 1.15152478e-01f, 1.56686530e-01f,
  5.10973185e-02f, -2.58667499e-01f, 7.99516588e-02f, -3.17402869e-01f, 1.25688523e-01f, -3.05034190e-01f, -6.29577562e-02f, 2.51040876e-01f, 1.35942698e-01f, -3.86067841e-04f,
  -1.33504167e-01f, 1.64118670e-02f, -2.68263638e-01f, 3.10193241e-01f, 1.77837178e-01f, -2.66608387e-01f, 1.91429079e-01f, 2.94580102e-01f, 2.87290841e-01f, -1.51882663e-01f,
  -2.95126677e-01f, 2.08765000e-01f, -1.04514748e-01f, -3.31347883e-01f, -2.30144709e-01f, -3.84284884e-01f, 1.53565764e-01f, -2.35969741e-02f, -3.81550044e-01f, 3.12501341e-01f,
  2.69649714e-01f, 3.35429329e-03f, -4.42791849e-01f, -1.95385188e-01f, -4.90890115e-01f, -2.00987548e-01f, -2.26138249e-01f, -1.31385997e-01f, -1.63684115e-01f, 1.82978928e-01f,
  3.27848524e-01f, 2.41041809e-01f, -5.21158278e-01f, -1.43216670e-01f, -3.53206933e-01f, 2.87962973e-01f, -3.55868876e-01f, 1.82470128e-01f, -6.06512427e-01f, 2.93980986e-01f,
  -3.70186239e-01f, -3.31886858e-01f, 2.27730185e-01f, 2.84157932e-01f, 1.68315873e-01f, 1.85749352e-01f, 4.55621071e-02f, -4.87724513e-01f, -4.54115085e-02f, 1.18143089e-01f,
  -1.07133925e-01f, -8.20342004e-02f, -2.03296021e-01f, 2.29065388e-01f, -4.86807451e-02f, -1.02391392e-02f, 5.50036430e-02f, 1.89823247e-02f, -2.53932476e-02f, -8.65869969e-03f,
  3.11840829e-02f, 9.78069901e-02f, 1.03943802e-01f, -1.32281661e-01f, -5.92956021e-02f, -8.05699378e-02f, -7.14131165e-03f, 2.55602360e-01f, -6.01775832e-02f, 1.32318720e-01f,
  -1.05581634e-01f, -3.33185121e-02f, -3.49057466e-01f, 2.55170912e-01f, 1.87469855e-01f, 3.17284577e-02f, 1.21881917e-01f, -2.97145903e-01f, 1.69691563e-01f, 1.02898464e-01f,
  6.51418716e-02f, -9.99268144e-02f, 5.15355989e-02f, -1.53155819e-01f, 2.63924062e-01f, 1.62863702e-01f, -2.38964900e-01f, 4.55764949e-01f, 2.66131043e-01f, -3.47998857e-01f,
  -1.73977271e-01f, -2.30200335e-01f, 3.52400810e-01f, -2.07527742e-01f, 3.26959610e-01f, 8.49391669e-02f, 2.04336792e-01f, -3.28925222e-01f, -3.63394618e-01f, -4.48711775e-02f,
  -5.03945053e-01f, -3.77743274e-01f, -3.19636077e-01f, -3.00842166e-01f, 2.92767078e-01f, -5.13107926e-02f, -2.00969800e-01f, -1.73241988e-01f, -2.72747487e-01f, 1.63365528e-01f,
  6.71967715e-02f, -8.53435248e-02f, -1.43205732e-01f, 2.69387271e-02f, -6.88769564e-04f, -9.66881737e-02f, -1.52630173e-03f, 1.09398872e-01f, 8.24721381e-02f, -1.57753751e-01f,
  2.96972021e-02f, 1.02407522e-02f, 4.77211252e-02f, -3.25197577e-02f, 8.10799897e-02f, 4.58834916e-02f, -1.45090558e-02f, 1.65314272e-01f, 2.94424538e-02f, -2.15445161e-01f,
  -1.14268951e-01f, -2.04684541e-01f, -2.62516797e-01f, -2.95725763e-01f, -9.61966962e-02f, -1.32522359e-01f, -1.45269573e-01f, 1.27766132e-01f, 2.99211204e-01f, -7.31039196e-02f,
  -2.36742273e-01f, -2.31847391e-01f, -1.43623859e-01f, 2.89753735e-01f, 2.31340766e-01f, 2.31658146e-02f, -1.66828886e-01f, 6.19136840e-02f, -1.67138860e-01f, -1.19995743e-01f,
  2.57815212e-01f, -3.11456416e-02f, -6.55222908e-02f, -3.22296530e-01f, 2.79218256e-01f, 3.83292921e-02f, 2.10248873e-01f, 3.34812552e-01f, -3.93153310e-01f, -2.07853571e-01f,
  -2.62170315e-01f, -1.25025436e-01f, -2.22108230e-01f, 2.88357794e-01f, -3.18393588e-01f, -3.64728689e-01f, 4.70617294e-01f, 3.26870769e-01f, 2.10877508e-02f, -6.87657520e-02f,
  2.44107410e-01f, -4.77236986e-01f, 2.21688032e-01f, -4.04066980e-01f, -2.99933910e-01f, 1.06399857e-01f, -1.57358542e-01f, -3.93808007e-01f, 7.59947300e-02f, 3.35690789e-02f,
  -1.56949237e-01f, -4.05394882e-02f, 2.46243492e-01f, -5.11487499e-02f, -1.79411724e-01f, 1.18771143e-01f, 6.80586472e-02f, 3.05141449e-01f, 7.40167350e-02f, -3.36784810e-01f,
  1.55053977e-02f, 1.43604338e-01f, 1.40040308e-01f, -3.19790170e-02f, 5.99859580e-02f, 1.09414369e-01f, -8.02279338e-02f, -2.03953460e-01f, -2.97793388e-01f, -3.84453356e-01f,
  -2.06356257e-01f, 1.54562324e-01f, -2.48938501e-01f, 4.74903584e-02f, -3.03375959e-01f, 8.06498602e-02f, 1.03640512e-01f, 4.82932597e-01f, -1.98214024e-01f, -2.71503597e-01f,
  3.29932451e-01f, -4.40571845e-01f, -3.39694798e-01f, -2.67732024e-01f, -3.17239016e-01f, 3.68927807e-01f, -2.16053620e-01f, -4.61952657e-01f, -3.82251859e-01f, -4.18595850e-01f,
  -5.82384169e-01f, -5.83079159e-01f, 1.93830673e-02f, 2.60596573e-01f, -2.44406104e-01f, -2.94747740e-01f, -1.38097838e-01f, 2.91988701e-01f, 2.82800317e-01f, 3.67491364e-01f,
  -4.97844726e-01f, 2.49084890e-01f, 3.91699165e-01f, -1.95819363e-01f, -3.04974675e-01f, 8.75265151e-02f, -2.16401845e-01f, -3.05222005e-01f, 6.18473813e-02f, 5.31083107e-01f,
  7.17942491e-02f, -2.07077473e-01f, 5.38742170e-03f, -1.93742123e-02f, -7.52374679e-02f, -5.27224801e-02f, 2.36632317e-01f, -8.41031000e-02f, 5.64368553e-02f, -1.52862128e-02f,
  -5.45396237e-03f, 2.66011775e-01f, 9.96220261e-02f, -1.28293857e-01f, -2.57862329e-01f, 1.91276595e-01f, 1.86809167e-01f, 1.09012060e-01f, -1.94909014e-02f, -2.80438662e-01f,
  1.63149759e-01f, 2.86851466e-01f, 3.96014869e-01f, -1.92723975e-01f, 1.72865003e-01f, 1.39432907e-01f, -5.19033432e-01f, -4.02203918e-01f, 3.06832492e-01f, 1.14262007e-01f,
  -6.55110106e-02f, -2.46304139e-01f, -3.50992948e-01f, -1.27855822e-01f, 1.32762223e-01f, -1.61322847e-01f, 1.90495569e-02f, 3.23713005e-01f, 1.78688705e-01f, -2.71594405e-01f,
  -5.02082944e-01f, -1.19355373e-01f, -1.13940433e-01f, -2.10912183e-01f, 2.18516663e-01f, 4.05939639e-01f, -5.27466178e-01f, -3.92667413e-01f, 3.71519536e-01f, 5.10470450e-01f,
  -5.77544831e-02f, -4.00813729e-01f, 1.44708872e-01f, -3.21884364e-01f, -8.43599886e-02f, -5.31599164e-01f, 2.34956458e-01f, -3.03885281e-01f, -5.63799366e-02f, 1.14528023e-01f,
  -3.01915109e-01f, -6.55925320e-03f, -2.56347150e-01f, 2.31589586e-01f, 4.13947972e-03f, 1.02794491e-01f, 6.83938265e-02f, 1.26423180e-01f, -9.88687575e-02f, -1.89818114e-01f,
  1.02620408e-01f, -8.59961584e-02f, -1.44247621e-01f, -1.98386863e-01f, 1.32176159e-02f, 1.54673547e-01f, -4.11284603e-02f, -1.16764292e-01f, 1.68443620e-01f, 1.35618746e-01f,
  -1.99047491e-01f, 3.45237143e-02f, -6.35339767e-02f, -1.32211134e-01f, -9.88069847e-02f, 2.59628594e-01f, -2.74784535e-01f, 4.35967296e-01f, 1.60030589e-01f, 1.41348392e-01f,
  -2.93883950e-01f, 1.92084670e-01f, -1.34982213e-01f, 1.39616400e-01f, 9.51704234e-02f, -1.83754072e-01f, 2.50355273e-01f, -3.91655900e-02f, -1.32548913e-01f, 2.19039276e-01f,
  -8.53257068e-03f, -1.62135258e-01f, 1.59088105e-01f, -4.42233711e-01f, 4.17963505e-01f, -1.78561717e-01f, -3.51233810e-01f, -2.73878932e-01f, 3.74331810e-02f, 2.12961718e-01f,
  6.72464594e-02f, -1.20132744e-01f, -4.07584250e-01f, 5.03896356e-01f, -4.69328612e-01f, -4.75558728e-01f, -3.95599216e-01f, 2.23322749e-01f, 4.13204968e-01f, -4.36942697e-01f,
  7.51363859e-02f, 3.40566874e-01f, 3.59519988e-01f, 1.86959520e-01f, -4.69490319e-01f, -5.36139272e-02f, -2.63214737e-01f, -4.97602403e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.09757468e-01f, 5.05704358e-02f, -7.24645853e-02f, -1.06332712e-02f, -1.13156848e-02f, -9.28476546e-03f, -4.00025994e-02f, -3.55876833e-02f, -1.01008922e-01f, 5.97994402e-02f,
  2.79113911e-02f, -3.81081030e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    