/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.67915449e-01f, 2.40201920e-01f, -3.65982622e-01f, -9.37710106e-02f, 5.41511644e-03f, 4.35877204e-01f, 1.27549514e-01f, -7.86421299e-02f, -7.19823837e-02f, 3.36124152e-01f,
  -6.85251579e-02f, 9.28711519e-02f, -1.35411441e-01f, 2.74559975e-01f, -3.91081750e-01f, -2.67289042e-01f, 2.90787190e-01f, 2.64708608e-01f, -2.10344508e-01f, 3.42752337e-02f,
  -2.17876807e-01f, 3.26538771e-01f, -3.21386665e-01f, 1.50359243e-01f, 1.34646157e-02f, -8.56386796e-02f, 1.60189848e-02f, -9.02443677e-02f, 2.50067532e-01f, 4.65585031e-02f,
  -5.65691292e-02f, -7.89015889e-02f, -1.77756809e-02f, -4.00138423e-02f, -6.12396421e-03f, 1.72681347e-01f, 2.19914317e-02f, -3.33904587e-02f, -9.18655321e-02f, -3.36655183e-03f,
  8.61533135e-02f, -5.54771274e-02f, 1.34023711e-01f, 6.87650815e-02f, 6.53040409e-02f, -3.80507857e-02f, -1.15275472e-01f, -8.83505866e-02f, -1.58065297e-02f, -1.17451631e-01f,
  -1.18057027e-01f, -2.39570234e-02f, -7.62826726e-02f, 7.95251355e-02f, -7.62437358e-02f, -1.80572644e-03f, 1.70825934e-03f, 7.40754828e-02f, 1.17652610e-01f, 6.26295283e-02f,
  1.38252646e-01f, 1.16180498e-02f, -5.32623045e-02f, -2.27951258e-02f, -6.08406123e-03f, -6.14360422e-02f, 6.12948462e-02f, 3.82421799e-02f, -4.84864861e-02f, -1.90036464e-02f,
  -6.23429120e-02f, 2.73541920e-03f, 5.31880483e-02f, 9.17708781e-03f, -2.38935910e-02f, 3.29348482e-02f, -8.45928788e-02f, 5.01592346e-02f, 2.39957664e-02f, -4.93154675e-02f,
  -6.08958229e-02f, 5.88563038e-03f, 1.60424411e-02f, 1.49159329e-02f, -1.47301825e-02f, -6.25669435e-02f, 3.29344422e-02f, -3.40676792e-02f, -1.10088073e-01f, -4.05094773e-02f,
  2.01083302e-01f, 1.93703339e-01f, -4.13535684e-02f, 7.02544749e-02f, 1.66827310e-02f, -4.27103005e-02f, -1.36466101e-02f, 5.11878505e-02f, 4.14988399e-02f, -2.50537153e-02f,
  4.50640842e-02f, 8.62579867e-02f, -3.98159139e-02f, 5.32354265e-02f, 8.01513530e-03f, 5.46225870e-04f, 3.74468006e-02f, 1.37907863e-01f, 6.72659054e-02f, 1.14157982e-01f,
  4.29558195e-02f, 1.02374136e-01f, -5.01361769e-03f, 9.93440449e-02f, 2.02737778e-01f, -2.01555919e-02f, 1.54820889e-01f, -7.09454045e-02f, 6.23221472e-02f, 3.85513529e-02f,
  1.61131084e-01f, -5.38596570e-01f, -1.65859133e-01f, -4.50617336e-02f, -6.97118640e-02f, -9.97839496e-02f, 3.38306457e-01f, -3.46704006e-01f, -2.99101681e-01f, -1.32012576e-01f,
  -1.16563246e-01f, 3.08474526e-03f, -7.24060610e-02f, -3.20835292e-01f, 2.02979267e-01f, -4.73896451e-02f, -2.12922618e-01f, 8.43725428e-02f, -1.39759749e-01f, -2.05227345e-01f,
  -4.08817232e-02f, -4.64279130e-02f, 1.80180240e-02f, -2.27471724e-01f, -1.79725647e-01f, -1.43564627e-01f, 2.85350859e-01f, 1.16517864e-01f, -7.32075274e-02f, 1.33625135e-01f,
  5.59642203e-02f, -2.15526983e-01f, -9.32348296e-02f, 4.36030999e-02f, -8.70543811e-03f, 1.28909796e-01f, 2.14270756e-01f, 2.05895111e-01f, 8.21170583e-02f, -3.32261808e-02f,
  7.17862770e-02f, 5.13594188e-02f, -3.49447466e-02f, -6.80700503e-03f, -8.56560469e-02f, -3.35255414e-02f, -6.03082329e-02f, -7.26713836e-02f, -1.08042486e-01f, -6.61383383e-03f,
  -9.52579379e-02f, 3.28997746e-02f, -6.41260520e-02f, -1.15392602e-03f, -5.10120206e-03f, -1.40080079e-01f, 1.32393703e-01f, 6.91795722e-02f, 7.93836042e-02f, -1.37726188e-01f,
  -6.36286214e-02f, 4.07541990e-02f, -5.87033853e-02f, 4.91225794e-02f, -3.09001282e-02f, 6.64673671e-02f, 2.24261964e-03f, 1.13939255e-01f, -2.28164736e-02f, -4.08518352e-02f,
  9.81577579e-03f, -3.43626961e-02f, -5.23229949e-02f, -2.46725846e-02f, -2.29897108e-02f, 8.14003311e-03f, 1.09410979e-01f, -6.66979551e-02f, 1.60571225e-02f, 8.64097942e-03f,
  4.48979624e-02f, 1.06440168e-02f, -1.58201379e-04f, 6.70155808e-02f, 1.84806101e-02f, -8.76616687e-03f, -1.01826251e-01f, -8.66419300e-02f, -1.13467602e-02f, 9.75183621e-02f,
  -1.48157999e-01f, -3.19690377e-01f, 3.03722136e-02f, 5.80548234e-02f, 7.39937574e-02f, -1.00555122e-01f, -8.02973378e-03f, -1.07264005e-01f, -1.39524326e-01f, -1.00485859e-02f,
  -8.27412903e-02f, 3.12318150e-02f, -3.64901200e-02f, -1.59200355e-02f, 8.50250050e-02f, -5.66298291e-02f, 1.17571458e-01f, 9.59056690e-02f, 6.02194145e-02f, 3.39718610e-02f,
  8.02937001e-02f, 2.59041302e-02f, 1.70331985e-01f, -6.76274821e-02f, 8.49815980e-02f, 5.37979081e-02f, -1.37818068e-01f, 2.38017756e-02f, 4.52606194e-02f, 9.37835649e-02f,
  2.68450081e-01f, -4.98699218e-01f, -4.61395942e-02f, -1.90800011e-01f, 1.70016348e-01f, 4.15959328e-01f, -1.88137680e-01f, 1.37938529e-01f, 1.65136620e-01f, -4.70039099e-01f,
  -1.97321087e-01f, -3.02362174e-01f, -3.37754250e-01f, -2.01863363e-01f, 4.65072781e-01f, -6.95016459e-02f, 5.50734326e-02f, 1.33009010e-03f, 9.63797346e-02f, -1.49069324e-01f,
  1.40498072e-01f, -1.66402563e-01f, -2.50300556e-01f, -2.08990788e-03f, -1.78692583e-02f, 1.14471972e-01f, -1.17334276e-01f, -7.21000209e-02f, -2.10119672e-02f, -7.22315460e-02f,
  2.61995979e-02f, -1.72617137e-01f, -8.36721621e-03f, -1.16473824e-01f, 8.70543718e-02f, -3.56587283e-02f, -2.74054240e-02f, -6.73245862e-02f, -5.45261502e-02f, -7.70094395e-02f,
  -1.55078605e-01f, 6.58145025e-02f, 9.05078351e-02f, 5.48563302e-02f, 9.01785642e-02f, -1.16031453e-01f, 5.00321537e-02f, 1.06703781e-01f, -2.59875543e-02f, 4.03729901e-02f,
  4.46125120e-02f, 1.04628846e-01f, 7.22565278e-02f, -4.39243242e-02f, 3.42586301e-02f, -6.26033545e-02f, -3.11534759e-02f, 9.76455510e-02f, -1.70389563e-02f, 4.92870957e-02f,
  6.80993795e-02f, -4.13917825e-02f, -1.50887086e-03f, -9.57314521e-02f, 4.70496155e-02f, 3.84333916e-02f, -3.21367420e-02f, -2.36970652e-02f, -1.11396490e-02f, -2.00412963e-02f,
  3.66353802e-02f, 8.90692603e-03f, 8.77668411e-02f, 2.63294447e-02f, 3.91319543e-02f, -3.88394035e-02f, -1.31765492e-02f, -8.82160589e-02f, 2.45732889e-02f, 5.23211360e-02f,
  -3.78776453e-02f, 3.92339565e-02f, -3.41998227e-02f, -6.69977590e-02f, -2.76734568e-02f, -2.89373510e-02f, -8.38797465e-02f, 1.04316950e-01f, -8.14794302e-02f, 7.34322891e-02f,
  9.77657884e-02f, -1.79179639e-01f, 6.94700656e-03f, -3.49311270e-02f, -6.45171702e-02f, 1.66210551e-02f, 7.12989867e-02f, 1.43930271e-01f, -6.74899593e-02f, -8.63367878e-03f,
  5.06174229e-02f, -3.37504894e-02f, -5.76487184e-03f, -4.74481285e-03f, 3.49856019e-02f, 2.87792180e-02f, -1.46057606e-01f, 3.51464711e-02f, -2.59358827e-02f, -5.14675193e-02f,
  -2.65016370e-02f, -8.43159631e-02f, 9.97654200e-02f, 1.02834199e-02f, 7.34966993e-02f, -3.25441584e-02f, 2.19373237e-02f, 5.76497354e-02f, -4.00687903e-02f, -1.44256605e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.01782042e-01f, 1.21675909e-01f, -4.10129189e-01f, 8.71569365e-02f, -1.84870452e-01f, -8.85783602e-03f, -1.62461758e-01f, -1.40672401e-01f, -3.39346081e-01f, 3.59507889e-01f,
  2.32089952e-01f, -9.63965878e-02f, -7.19449818e-02f, 6.41329944e-01f, 2.94529080e-01f, 3.11678767e-01f, 5.90479434e-01f, 2.88217992e-01f, -7.76406452e-02f, 1.77823141e-01f,
  2.50177950e-01f, 7.35558152e-01f, 1.80059969e-01f, 2.08269879e-01f, 7.98200741e-02f, -3.40472043e-01f, 2.04157174e-01f, -4.11503643e-01f, 4.12940919e-01f, 9.36923102e-02f,
  1.82587519e-01f, 1.32174298e-01f, -6.51477054e-02f, 4.85992168e-05f, 4.97525074e-02f, 2.30070688e-02f, -2.19462756e-02f, -3.26945703e-03f, -1.38218462e-01f, -5.58048673e-02f,
  -4.84293103e-02f, 6.51870668e-02f, 2.17383370e-01f, -9.09494087e-02f, -9.40934643e-02f, -6.59219101e-02f, -5.03514446e-02f, -1.13370232e-01f, -2.42951382e-02f, 7.60638788e-02f,
  -1.67072475e-01f, -2.31807865e-02f, -7.16094151e-02f, -3.21035273e-03f, -3.49920467e-02f, -1.52130453e-02f, -1.92609578e-02f, -1.21440291e-01f, 1.08813271e-01f, 9.69211087e-02f,
  1.07486114e-01f, 1.36819154e-01f, 1.16920628e-01f, 6.99959546e-02f, 8.40170458e-02f, 8.26902539e-02f, -2.13198625e-02f, 1.12973889e-02f, -1.00962974e-01f, 9.91394147e-02f,
  -1.23050557e-02f, -1.31012082e-01f, 8.03437904e-02f, -8.25591907e-02f, 1.57633737e-01f, 5.34663610e-02f, -4.93764430e-02f, 3.03492434e-02f, -1.45309269e-01f, -1.42770773e-02f,
  3.79104279e-02f, -1.18562594e-01f, 2.34920420e-02f, 2.27191858e-02f, 1.03610143e-01f, -9.23993289e-02f, 8.16259682e-02f, 5.51650673e-02f, -2.13255212e-01f, -2.67891288e-02f,
  1.38086841e-01f, 2.33460262e-01f, -8.89456943e-02f, 2.84137167e-02f, -6.13147877e-02f, 1.18132986e-01f, 5.60546629e-02f, -9.73238330e-03f, -5.77189364e-02f, 1.14734359e-01f,
  1.78891167e-01f, -1.08541735e-01f, -5.53633682e-02f, 1.07710054e-02f, -5.82699291e-02f, 4.12505269e-02f, 2.74436362e-02f, -8.01573917e-02f, -4.37671207e-02f, 4.66308519e-02f,
  -4.63308692e-02f, 1.73904914e-02f, -4.89250608e-02f, -1.53236222e-02f, 6.56927824e-02f, -9.58117470e-03f, -1.39741018e-01f, -1.28502652e-01f, 6.83484524e-02f, -6.64143041e-02f,
  6.38275087e-01f, 3.58925700e-01f, 3.58868778e-01f, 1.89444795e-02f, -3.02190751e-01f, 5.21112382e-01f, 4.79602486e-01f, -2.53859818e-01f, -2.24637136e-01f, -1.09190792e-01f,
  -4.29422945e-01f, 3.35119843e-01f, 3.56757008e-02f, 1.79813832e-01f, 8.27397332e-02f, -2.69541591e-02f, 1.29741887e-02f, 1.15756422e-01f, 8.06001797e-02f, 2.21000165e-01f,
  -1.27804324e-01f, -3.06024313e-01f, 1.39025524e-01f, -2.25360423e-01f, 5.12113512e-01f, 1.62589492e-03f, -7.18257725e-01f, -1.21042682e-02f, -2.57328033e-01f, -1.81365713e-01f,
  1.69673890e-01f, 9.99469832e-02f, 3.04981947e-01f, 9.12696347e-02f, 2.30700016e-01f, 1.51122019e-01f, -1.43493693e-02f, 6.97874576e-02f, 1.32202879e-02f, 8.05592835e-02f,
  7.09804967e-02f, -1.06576048e-01f, -6.62082955e-02f, -9.84059125e-02f, -6.56632660e-03f, -5.50766364e-02f, 8.09474215e-02f, 1.82473779e-01f, -3.86718921e-02f, 2.65254229e-01f,
  2.28150636e-01f, 2.05506057e-01f, 9.74737946e-03f, -2.30904862e-01f, -1.99697316e-01f, -2.97961354e-01f, 1.13864720e-01f, 8.15362856e-02f, 2.12410875e-02f, 1.00094929e-01f,
  -6.93078563e-02f, 4.12454568e-02f, 2.21879005e-01f, 1.07926086e-01f, 1.73691869e-01f, -3.02360579e-03f, 7.68048242e-02f, -3.12692784e-02f, 1.79067682e-02f, -7.91112632e-02f,
  3.92422415e-02f, 4.89372499e-02f, 1.64739750e-02f, 7.09712058e-02f, 1.56969409e-02f, 1.47705644e-01f, 1.49174944e-01f, -4.43215333e-02f, -2.69346870e-02f, -5.56441396e-03f,
  -2.08719894e-01f, -1.26477733e-01f, 3.59320082e-02f, -1.37574017e-01f, 4.71749902e-02f, -7.73052052e-02f, -1.93097427e-01f, 1.20841630e-01f, 5.16172387e-02f, -5.68299145e-02f,
  -1.03206225e-01f, -1.01273358e-01f, 1.78503156e-01f, 5.92964701e-02f, 7.27924705e-02f, 3.33563477e-01f, 6.19053654e-02f, 1.69094112e-02f, -1.50624663e-01f, 5.61295412e-02f,
  -1.09593779e-01f, 7.28574321e-02f, -1.07559800e-01f, -3.48099284e-02f, -1.30249068e-01f, 8.29075873e-02f, -1.11326113e-01f, -1.51890395e-02f, -7.96640739e-02f, -2.43077412e-01f,
  -8.28454047e-02f, 3.42406444e-02f, 9.87235643e-03f, -1.18286885e-01f, -2.29332402e-01f, 7.06204679e-04f, 1.17927723e-01f, -6.87306821e-02f, -1.40097827e-01f, -1.05082549e-01f,
  2.13062957e-01f, 6.74886048e-01f, 5.97880900e-01f, 6.08460307e-01f, -1.94663331e-01f, -5.50441980e-01f, -4.97482210e-01f, 4.93918449e-01f, 2.77603805e-01f, -1.61709830e-01f,
  -4.47186828e-01f, 4.16662842e-01f, -1.88852698e-01f, 1.79558530e-01f, -4.35209870e-01f, -1.29471987e-01f, -1.39694825e-01f, -1.01520993e-01f, 3.99566621e-01f, 2.05454305e-01f,
  2.29515135e-01f, -3.99493873e-01f, 3.52985084e-01f, 8.80084261e-02f, 3.13125342e-01f, 3.95411313e-01f, -4.82598180e-03f, 5.96027449e-02f, 8.40567574e-02f, -2.82626987e-01f,
  -1.76614717e-01f, 3.39184076e-01f, 3.03538591e-01f, 6.28130436e-02f, 5.02036475e-02f, -1.62725464e-01f, 1.60581190e-02f, -1.03743821e-01f, -3.34214345e-02f, 1.14714270e-02f,
  2.70112529e-02f, 9.47176144e-02f, 8.19449350e-02f, 6.44030864e-04f, 7.16936961e-02f, 2.82569051e-01f, 1.87806547e-01f, 1.50586620e-01f, 1.46271005e-01f, 2.71958470e-01f,
  1.46719322e-01f, 1.01864479e-01f, -4.19169031e-02f, 9.41399764e-03f, 2.27960318e-01f, -1.13444135e-01f, -1.08397365e-01f, 3.30299847e-02f, 8.10747370e-02f, 1.63728222e-01f,
  -6.59302399e-02f, -6.93866834e-02f, -5.56421801e-02f, 1.58202216e-01f, -5.94371445e-02f, -2.35806126e-02f, -3.36847827e-02f, -8.29735473e-02f, -6.56622574e-02f, -1.51083529e-01f,
  -3.05798138e-04f, 2.19695315e-01f, 1.63826663e-02f, -1.29715353e-01f, 3.28935683e-02f, 6.36925921e-02f, -1.20629251e-01f, -9.94239151e-02f, 7.13182241e-02f, 2.75741279e-01f,
  4.31723706e-02f, -2.89318889e-01f, 8.59566331e-02f, -4.45748381e-02f, -1.75217912e-01f, 1.08302988e-01f, 1.14256635e-01f, 7.08135068e-02f, 8.97576883e-02f, 1.34958075e-02f,
  -2.76071131e-01f, 1.74907222e-01f, -8.01329874e-03f, -8.06728564e-03f, 8.86945613e-03f, -7.41996467e-02f, 6.93413839e-02f, 9.97505784e-02f, 3.87489125e-02f, -7.16138929e-02f,
  -6.96470439e-02f, -4.30144779e-02f, -2.07475007e-01f, -5.02934605e-02f, -1.02247655e-01f, -6.36437088e-02f, -9.88025665e-02f, -1.76965594e-01f, -7.44326832e-03f, 2.25768074e-01f,
  8.66433606e-02f, -1.12952657e-01f, -1.86884124e-02f, -4.94116656e-02f, -1.43330604e-01f, -9.25694406e-02f, -7.21098557e-02f, 1.54490650e-01f, 3.45743075e-02f, -6.95192963e-02f,
  -2.17510343e-01f, 1.38937995e-01f, -5.16686618e-01f, -1.35192871e-01f, 3.31070364e-01f, -1.17380515e-01f, -3.06545943e-01f, 1.80127159e-01f, -5.97809672e-01f, 1.51894569e-01f,
  2.19225153e-01f, -5.07869005e-01f, -1.96370468e-01f, -8.12100321e-02f, -1.29076526e-01f, -4.75514919e-01f, 1.34856597e-01f, -1.39629647e-01f, -4.42880929e-01f, 4.00064826e-01f,
  -4.52733487e-02f, 5.03983378e-01f, -6.68726340e-02f, 3.41461927e-01f, 1.97665393e-01f, 1.22770809e-01f, 6.48279250e-01f, 6.84433291e-03f, 3.42651546e-01f, 4.53312136e-02f,
  -2.69612908e-01f, -6.07854351e-02f, -1.47807404e-01f, -2.45047316e-01f, 2.49645457e-01f, 1.52709708e-01f, -2.20408160e-02f, 1.20266065e-01f, -1.09096117e-01f, -5.34448996e-02f,
  2.00376511e-02f, 3.06903757e-02f, -4.43110131e-02f, -8.41838866e-02f, 2.99242046e-02f, 3.40018831e-02f, -4.47384380e-02f, -1.44094914e-01f, -7.58474618e-02f, -2.56406292e-02f,
  -1.09058931e-01f, -5.63673936e-02f, 1.01564959e-01f, -5.75823784e-02f, 4.36718427e-02f, 5.47253229e-02f, 2.40522008e-02f, 1.31092206e-01f, -5.73073775e-02f, 2.16997992e-02f,
  2.19880104e-01f, 1.49569008e-02f, -1.23154968e-01f, -2.42379516e-01f, 3.73251699e-02f, -4.30766754e-02f, -1.66037560e-01f, -3.20390575e-02f, -1.46261245e-01f, 1.12254128e-01f,
  1.35201558e-01f, -6.78261975e-03f, -9.32794064e-02f, 1.56166116e-02f, 1.04170635e-01f, -3.76026481e-02f, 4.16176543e-02f, 9.55831409e-02f, 8.07997584e-02f, -5.89344315e-02f,
  -1.66069612e-01f, 4.28136215e-02f, 2.69041862e-02f, 8.33122507e-02f, -1.16192125e-01f, 1.91729143e-01f, 9.61430520e-02f, 3.22974287e-02f, -8.61868113e-02f, 3.95993553e-02f,
  2.32481822e-01f, 4.41699803e-01f, -3.65880281e-02f, -1.10855073e-01f, -1.10769346e-01f, 1.19576119e-01f, -2.43524805e-01f, -6.97104912e-03f, 7.56044015e-02f, 6.35607690e-02f,
  4.11380738e-01f, 3.51692550e-02f, 1.13930397e-01f, 1.14511415e-01f, -4.25501168e-02f, 3.77687871e-01f, 1.20535512e-02f, -5.46456687e-02f, 1.93557143e-01f, 2.48394832e-01f,
  2.52164036e-01f, 2.38013193e-01f, -1.51557863e-01f, -5.09633049e-02f, 1.40454575e-01f, 1.05368115e-01f, 2.16566280e-01f, -3.63569409e-02f, 7.46425092e-02f, -1.15872279e-01f,
  -1.01213074e+00f, -8.37369859e-02f, -3.04042190e-01f, -9.22741666e-02f, -5.68709016e-01f, -4.74750996e-01f, 2.04994738e-01f, -5.29684603e-01f, -6.50342479e-02f, 5.77707767e-01f,
  1.87888965e-01f, -7.20902607e-02f, 4.80145216e-01f, 2.71186948e-01f, -5.17032087e-01f, 7.82168090e-01f, 1.85251653e-01f, 4.07751024e-01f, -1.44783884e-01f, -2.69076645e-01f,
  -2.90014893e-01f, -3.39088552e-02f, 1.70147270e-01f, -3.58192086e-01f, -6.72805727e-01f, -3.36587161e-01f, 1.02278646e-02f, -2.81705141e-01f, -2.88620502e-01f, -3.70645851e-01f,
  -7.54251957e-01f, -3.45863104e-01f, 1.31687701e-01f, -1.62658691e-01f, -2.33877838e-01f, -4.42290306e-02f, -8.60277414e-02f, 5.47472686e-02f, -1.00479364e-01f, -8.16263482e-02f,
  8.90418738e-02f, -1.41486019e-01f, -5.96100800e-02f, 1.46027774e-01f, -1.39994144e-01f, -3.13015461e-01f, -2.14616522e-01f, -8.54249820e-02f, -1.91626742e-01f, -7.81697482e-02f,
  4.14299034e-02f, -8.54797885e-02f, -6.77072862e-03f, 3.51847485e-02f, -1.30933404e-01f, -6.35049641e-02f, 2.50440482e-02f, 8.94236341e-02f, -1.94425225e-01f, -2.79016346e-01f,
  3.80340107e-02f, 2.04905700e-02f, 1.54611245e-01f, -2.41735727e-02f, 2.06453595e-02f, -4.87515964e-02f, 6.62911832e-02f, 5.66747077e-02f, 1.95893110e-03f, -4.99391593e-02f,
  -7.42458031e-02f, -1.09410428e-01f, -1.65905312e-01f, 5.89546524e-02f, -6.11942261e-03f, 1.65462703e-01f, 1.06208757e-01f, -1.71702951e-01f, 2.33698096e-02f, -2.01037079e-02f,
  7.03599229e-02f, -1.08297847e-01f, 1.36698037e-01f, 1.21140003e-01f, -1.45597374e-02f, 8.48355517e-02f, -3.40662189e-02f, 2.82958336e-03f, 2.80288495e-02f, -1.32431313e-01f,
  -8.32976222e-01f, -6.23241901e-01f, 1.49049405e-02f, -1.16802990e-01f, 9.13534462e-02f, -1.35126822e-02f, 2.54668295e-02f, -6.65757582e-02f, -2.45189905e-01f, 2.55770963e-02f,
  -2.79202666e-02f, 9.62854028e-02f, -2.24352211e-01f, 1.24763466e-01f, 1.89943030e-01f, -8.17134231e-02f, -3.37503268e-03f, 5.36786877e-02f, -1.20423853e-01f, -6.26538396e-02f,
  8.51046816e-02f, 8.87230486e-02f, 1.22144602e-01f, -2.82887537e-02f, 3.37702297e-02f, 3.14821042e-02f, -1.87906325e-01f, -2.80312113e-02f, -2.82882392e-01f, 5.49986325e-02f,
  3.17568630e-01f, 3.06442510e-02f, 3.21723253e-01f, 3.66994888e-01f, -2.98648626e-01f, 4.53336760e-02f, 5.33140242e-01f, -3.70244861e-01f, -6.14005387e-01f, -1.10102542e-01f,
  1.34341165e-01f, 3.17612529e-01f, 4.19458777e-01f, 4.48808938e-01f, 8.92373860e-01f, 1.25666797e-01f, 8.31381828e-02f, -1.56230507e-02f, -2.20890641e-01f, 6.51544109e-02f,
  -9.74911526e-02f, 1.92327544e-01f, 4.36609030e-01f, -2.13931240e-02f, 2.80891031e-01f, 1.35511979e-01f, 3.66606921e-01f, 5.11743367e-01f, 3.14288139e-01f, 4.72813070e-01f,
  -1.05979830e-01f, 8.93929452e-02f, -3.33419517e-02f, -1.28489891e-02f, -9.04672891e-02f, -5.61830550e-02f, 2.49051973e-01f, 3.75352591e-01f, 2.00261977e-02f, -2.70789731e-02f,
  1.00009881e-01f, 5.59637062e-02f, 3.68336700e-02f, 1.21501507e-02f, -2.58746054e-02f, -2.13122323e-01f, -1.06073625e-01f, -2.53134400e-01f, -2.56088022e-02f, 5.41646443e-02f,
  -2.27051824e-02f, -2.31940135e-01f, 5.56626841e-02f, 5.70762455e-02f, 3.59977596e-02f, -1.61569923e-01f, -2.84629408e-02f, 1.33407533e-01f, -7.31666759e-02f, -1.28585339e-01f,
  1.11798368e-01f, -1.58074066e-01f, -8.91725793e-02f, -2.29357090e-03f, -3.47386207e-03f, -3.82815078e-02f, -6.43976405e-02f, 2.45688390e-02f, 3.41477208e-02f, 1.10644549e-02f,
  -1.56421751e-01f, -6.67365119e-02f, -6.81696311e-02f, -2.89757047e-02f, -3.80681381e-02f, -1.97755724e-01f, 1.23519681e-01f, 1.94983706e-01f, -2.24248439e-01f, -2.13386435e-02f,
  -4.49776500e-02f, 1.75602749e-01f, 6.66687414e-02f, -3.20434123e-02f, -7.35795423e-02f, -3.87225300e-02f, 4.89516892e-02f, 1.70361578e-01f, -1.47392437e-01f, 1.79039642e-01f,
  1.36331320e-01f, 5.70193052e-01f, 3.52410488e-02f, -5.09794541e-02f, -1.87256653e-02f, -2.58590542e-02f, 9.86723378e-02f, -4.51092236e-02f, 2.39451021e-01f, -2.08067941e-03f,
  -1.02700265e-02f, 3.95679772e-02f, -1.13016469e-02f, -7.01994821e-02f, -9.63525102e-03f, -1.61387548e-02f, 5.92620112e-02f, -5.18683903e-02f, -7.35992342e-02f, -4.17920277e-02f,
  1.12296656e-01f, 1.51694059e-01f, 1.96210578e-01f, -9.26869512e-02f, -7.94117823e-02f, 1.02011465e-01f, 1.68182682e-02f, -1.42536819e-01f, 4.08047177e-02f, 1.10580333e-01f,
  -6.70523942e-01f, 8.97165835e-01f, -5.81295729e-01f, -1.40540257e-01f, -1.85533181e-01f, 1.09126103e+00f, 7.10908532e-01f, 2.50233084e-01f, 2.86600798e-01f, 6.71409011e-01f,
  4.16882247e-01f, 1.59773797e-01f, 4.24226582e-01f, 5.12989581e-01f, 2.25084811e-01f, 5.45915961e-01f, 3.93759847e-01f, 2.40837485e-01f, 1.29198907e-02f, 4.49087247e-02f,
  -1.34965643e-01f, 4.03444350e-01f, -1.69158265e-01f, 2.91696265e-02f, -3.81159224e-02f, -4.33971286e-01f, -3.71329159e-01f, -3.61270219e-01f, 9.03337598e-02f, 1.79365069e-01f,
  -1.80279985e-02f, -4.40370411e-01f, -3.35404456e-01f, -2.68626392e-01f, -1.61216170e-01f, -1.60070971e-01f, -1.38086095e-01f, -1.72501162e-01f, -2.12802783e-01f, 3.36032100e-02f,
  1.10259540e-01f, 3.83412950e-02f, 6.10332154e-02f, -6.05468601e-02f, 1.44110546e-01f, -4.06292640e-02f, 6.75257146e-02f, -2.70310510e-02f, 1.16913162e-01f, 2.17267983e-02f,
  5.67659363e-02f, -4.63651605e-02f, -3.65728922e-02f, 7.40282983e-02f, 4.44475748e-03f, 1.66920915e-01f, -6.31509647e-02f, 6.51719123e-02f, 1.73493639e-01f, -3.91638139e-03f,
  -9.50550660e-03f, -7.04739466e-02f, 6.86238185e-02f, -1.40275702e-01f, 6.08032569e-02f, -1.43347770e-01f, 1.04290389e-01f, -9.43102688e-02f, -3.33133712e-02f, 1.59121335e-01f,
  -2.48286705e-02f, -8.54366552e-03f, -9.18615758e-02f, 1.90493222e-02f, -1.52608203e-02f, -1.28555045e-01f, -1.36596978e-01f, -3.05586457e-02f, 1.40549792e-02f, 1.93074141e-02f,
  -1.13785133e-01f, 1.78665712e-01f, 9.34795588e-02f, -6.94868490e-02f, 1.12277798e-01f, 3.81093137e-02f, 1.21393256e-01f, 1.27433851e-01f, -3.38684842e-02f, -9.98777077e-02f,
  6.63022041e-01f, 1.84974194e-01f, -4.33419682e-02f, 5.41238524e-02f, -1.41108215e-01f, 1.46831393e-01f, -4.10055928e-02f, 5.56170456e-02f, 2.25938544e-01f, 9.06481519e-02f,
  -2.73453537e-02f, -1.43575445e-01f, -1.00169949e-01f, 1.09954931e-01f, 8.09105709e-02f, 2.77229488e-01f, -9.53058004e-02f, 9.22899880e-03f, -8.08301643e-02f, -9.09148902e-03f,
  -5.98478429e-02f, -1.94827858e-02f, -1.36319160e-01f, -4.74858731e-02f, 6.03767447e-02f, 1.74235366e-02f, -4.57680933e-02f, -1.27180383e-01f, -6.74069524e-02f, 5.03782444e-02f,
  -3.50789279e-01f, 2.11242765e-01f, -2.31646612e-01f, -2.63081700e-01f, 2.49830157e-01f, 1.62599340e-01f, 3.71557549e-02f, 2.87114143e-01f, 5.23681521e-01f, -7.78220072e-02f,
  -1.45055339e-01f, 1.60987452e-01f, 2.90938616e-01f, -3.03780258e-01f, -2.52786100e-01f, 1.01181470e-01f, -3.43556732e-01f, 1.39087617e-01f, 4.00906146e-01f, 1.12073168e-01f,
  -9.06562060e-02f, 1.56919628e-01f, -4.05917525e-01f, 1.39487684e-01f, -3.88587117e-01f, -9.33117867e-02f, -3.93970340e-01f, 3.67307276e-01f, -4.54627663e-01f, 1.53217077e-01f,
  -3.13583553e-01f, 3.52167726e-01f, -3.20801824e-01f, -1.26755387e-01f, -1.98602304e-01f, 8.32007825e-03f, -3.51767195e-03f, 2.45161112e-02f, 1.08346716e-01f, 3.81259248e-02f,
  4.63831313e-02f, 1.33147510e-02f, -5.84837832e-02f, 1.37861148e-01f, -2.78648757e-03f, -1.83835566e-01f, -2.02529922e-01f, -3.07588875e-01f, 1.11642620e-02f, -3.18669640e-02f,
  -1.21571533e-01f, -7.35627636e-02f, -1.74067378e-01f, -6.55245259e-02f, -1.67211592e-01f, -1.23590149e-01f, -1.52891412e-01f, -1.01602614e-01f, -8.91515315e-02f, -3.92030887e-02f,
  2.23758310e-01f, 2.95773715e-01f, -8.56405571e-02f, 7.83363953e-02f, -5.95026761e-02f, -5.42190596e-02f, -4.12754864e-02f, -8.78055766e-02f, -3.77146155e-02f, -6.76193386e-02f,
  -9.30525362e-02f, -3.29895467e-02f, 6.46320283e-02f, -2.77196746e-02f, 4.31091264e-02f, 1.09746084e-01f, -9.58031267e-02f, 1.17279394e-02f, -6.21145144e-02f, -1.38211653e-01f,
  1.81262746e-01f, -6.26123622e-02f, -3.51634957e-02f, -3.70357335e-02f, 1.32886926e-02f, -4.73742932e-02f, 6.14531748e-02f, -1.42842487e-01f, 6.53990582e-02f, 5.36827855e-02f,
  2.15260357e-01f, 4.90690976e-01f, 9.74613503e-02f, -6.88516870e-02f, 1.95947409e-01f, -1.08719975e-01f, 9.27871168e-02f, -7.24874064e-02f, 1.95250556e-01f, 1.41794890e-01f,
  -1.00169331e-01f, -3.71980816e-02f, -1.24413617e-01f, 4.94510867e-02f, -7.99848884e-03f, -4.58324254e-02f, 1.09116651e-01f, 1.26269549e-01f, -5.98243205e-03f, 1.52649004e-02f,
  -1.15894735e-01f, 1.66922450e-01f, -2.93888617e-03f, 6.73833257e-03f, -7.15612397e-02f, -1.82609275e-01f, 1.40437394e-01f, -3.28514315e-02f, -1.57132763e-02f, -4.68691550e-02f,
  -8.81240129e-01f, 7.55780101e-01f, -5.11838719e-02f, -7.41291583e-01f, 3.88847530e-01f, 8.08026120e-02f, -6.15939021e-01f, 1.81021303e-01f, -4.44406062e-01f, -2.03321114e-01f,
  -3.58422041e-01f, -3.05954546e-01f, 4.90102470e-02f, -4.87093717e-01f, -1.78447247e-01f, -8.81799459e-02f, -6.18812203e-01f, -6.06496632e-01f, 2.21690550e-01f, -9.67099890e-02f,
  -7.53533766e-02f, -1.39075860e-01f, -1.03112526e-01f, 5.63109994e-01f, -1.88025266e-01f, 1.28859907e-01f, -5.86387739e-02f, 4.20657754e-01f, -1.92534283e-01f, 1.35862246e-01f,
  -3.04431319e-01f, -5.31485915e-01f, -2.45529428e-01f, -2.17081264e-01f, -1.48092911e-01f, -5.41377328e-02f, -1.43237352e-01f, 6.86347187e-02f, -1.96515583e-02f, -6.76671090e-03f,
  -2.03950498e-02f, 4.14645262e-02f, 4.41607609e-02f, 1.24597028e-01f, -7.48448223e-02f, 7.22291693e-03f, 3.79629880e-02f, -7.57900774e-02f, -2.44578291e-02f, 1.11762531e-01f,
  -1.75825302e-02f, 4.33635488e-02f, 3.65587045e-03f, -1.01218335e-01f, -1.69555712e-02f, -8.40802193e-02f, -4.77398820e-02f, 5.73017597e-02f, -2.14023255e-02f, 8.57373998e-02f,
  4.74532433e-02f, -1.34365544e-01f, -3.14590288e-03f, -9.16651413e-02f, -2.85569653e-02f, -3.43305506e-02f, -1.49346581e-02f, 1.05440794e-02f, -5.04917465e-02f, 5.82378469e-02f,
  -4.76926304e-02f, -4.54806723e-02f, -9.39831790e-03f, -1.04358785e-01f, -2.71540917e-02f, -8.72439072e-02f, 1.52764870e-02f, -9.48627479e-04f, 9.10461172e-02f, 1.04940206e-01f,
  -3.68421115e-02f, -2.41059940e-02f, -1.22520268e-01f, 9.24400240e-02f, -6.47597313e-02f, -2.25456599e-02f, 2.36499067e-02f, 8.63829479e-02f, 5.11233322e-02f, 2.70724911e-02f,
  -2.20051527e-01f, -2.98671246e-01f, -1.05191715e-01f, 2.29372201e-03f, -1.71696972e-02f, 3.71916010e-03f, 2.00625286e-02f, 1.32301688e-01f, -5.32258861e-02f, -2.53401995e-02f,
  -7.86760375e-02f, -1.21094748e-01f, 3.04949470e-02f, -8.58564079e-02f, 7.34717548e-02f, 4.46807854e-02f, -1.00306123e-01f, -1.40378788e-01f, -1.66488528e-01f, 1.11011721e-01f,
  -7.27065206e-02f, -5.67109771e-02f, 9.35885012e-02f, 2.86461189e-02f, -8.56608301e-02f, -8.25858489e-02f, -8.41631927e-03f, 1.45822704e-01f, 4.25277688e-02f, 5.40331099e-03f,
  -1.28061509e+00f, 5.84845066e-01f, 3.41146946e-01f, -3.78448635e-01f, 2.25556031e-01f, 6.57204539e-03f, -8.77475590e-02f, 2.37409547e-01f, -2.00312678e-02f, 2.92201996e-01f,
  3.27718072e-02f, -9.48981866e-02f, 2.95661390e-01f, 4.48688507e-01f, -5.94688416e-01f, 3.16605389e-01f, 1.17946891e-02f, -1.75140604e-01f, 1.75947659e-02f, -1.79592565e-01f,
  -1.03431270e-01f, 7.16758817e-02f, 1.90702662e-01f, 4.00642544e-01f, 2.20151633e-01f, -1.71495408e-01f, -3.08201313e-01f, 1.47811443e-01f, 1.27635553e-01f, 3.76076326e-02f,
  -4.45186943e-01f, -1.87037840e-01f, 4.35862318e-02f, 4.72704209e-02f, -1.61735669e-01f, -5.90294562e-02f, -1.53341070e-01f, -1.21846478e-02f, -5.25950603e-02f, 6.52149469e-02f,
  -8.20730478e-02f, -9.87301394e-03f, 1.66497633e-01f, -3.14113796e-02f, -1.12827040e-01f, 9.71456990e-02f, 2.58366436e-01f, 2.29173824e-02f, 1.76309675e-01f, 9.06072110e-02f,
  2.92074293e-01f, 1.42756268e-01f, 1.09066078e-02f, 7.46724084e-02f, 4.84949760e-02f, 5.63334376e-02f, 6.62007332e-02f, -7.29622543e-02f, -8.43600780e-02f, -1.38759881e-01f,
  -3.97752598e-02f, -1.82270911e-02f, 2.66207308e-02f, -1.07831486e-01f, 2.61519924e-02f, 7.35225081e-02f, 4.20488156e-02f, -9.17345509e-02f, -3.10805067e-02f, -5.50084822e-02f,
  -1.66161787e-02f, -2.54741479e-02f, -7.43309855e-02f, -2.99678482e-02f, -1.54243759e-03f, 1.64557118e-02f, 2.50528324e-02f, 1.17055653e-02f, 3.96330282e-02f, -5.36598302e-02f,
  -7.78456032e-02f, -8.38983431e-02f, -2.64366195e-02f, -5.16132861e-02f, 1.49019603e-02f, -8.93655494e-02f, -6.33266405e-04f, 1.22515626e-01f, -6.42195717e-02f, -1.99505195e-01f,
  -1.02431941e+00f, -7.28904903e-01f, -4.16455939e-02f, -1.45492956e-01f, 1.71380248e-02f, -9.43845436e-02f, 3.26870717e-02f, -2.12767161e-03f, -3.76024693e-02f, -7.77763650e-02f,
  1.26997624e-02f, 1.25321031e-01f, -2.09995314e-01f, -1.36312634e-01f, -2.80394685e-02f, -3.02280821e-02f, -2.19268352e-01f, -1.41468182e-01f, -2.82584101e-01f, -1.85270399e-01f,
  -1.26450583e-01f, -6.24498026e-03f, 8.67795199e-02f, -4.16565426e-02f, -5.47009408e-02f, -1.53279200e-01f, -1.94203645e-01f, 1.03582470e-02f, -9.62716267e-02f, 1.73727781e-01f,
  -5.82266264e-02f, 6.31515145e-01f, 1.26464814e-01f, 3.64916682e-01f, -5.79031743e-02f, -6.69236481e-01f, 3.21755782e-02f, 8.23182836e-02f, -1.32846266e-01f, 5.00148296e-01f,
  -5.17327860e-02f, 3.29152107e-01f, 7.35141989e-03f, -2.80800939e-01f, -1.07190955e+00f, -7.64808476e-01f, -3.23585063e-01f, -5.90128489e-02f, -2.05883682e-01f, 2.95954734e-01f,
  -1.52972177e-01f, -2.09141985e-01f, -9.50061157e-02f, 3.04639041e-01f, 3.63548815e-01f, 4.73696649e-01f, 3.20730031e-01f, 2.08337888e-01f, 2.89930105e-01f, -1.61446229e-01f,
  -1.42054647e-01f, 8.98634940e-02f, 1.06780529e-01f, -5.83436750e-02f, -2.37514116e-02f, 2.05977038e-01f, 1.45481244e-01f, -9.14655104e-02f, -5.32057658e-02f, 1.17018437e-02f,
  9.38146934e-02f, -9.63513255e-02f, -1.07417427e-01f, -1.37127787e-01f, 1.31771967e-01f, 1.15111932e-01f, -1.08301984e-02f, 1.57273114e-01f, 5.15520275e-02f, -3.82157527e-02f,
  7.59117976e-02f, 2.31098626e-02f, 6.94609135e-02f, 1.30643457e-01f, -2.76302341e-02f, 3.83628905e-02f, -8.91758204e-02f, 2.17804294e-02f, 7.91912451e-02f, -1.23917639e-01f,
  -1.03542224e-01f, 1.60182975e-02f, 8.71067271e-02f, 5.81778139e-02f, -1.45261496e-01f, 7.45998994e-02f, 9.57938582e-02f, 6.57349080e-02f, 9.07336697e-02f, -8.43352452e-03f,
  9.74756926e-02f, 9.75853428e-02f, -1.23414556e-02f, 5.03000058e-02f, 6.77783862e-02f, 9.03149843e-02f, 1.25243952e-02f, 2.79464908e-02f, 1.74796637e-02f, -1.23363264e-01f,
  1.08544514e-01f, 3.70343961e-02f, 1.55482188e-01f, 1.04432166e-01f, 3.08559462e-02f, -5.25027737e-02f, 1.14980556e-01f, -1.09999306e-01f, -8.78291652e-02f, 7.69742280e-02f,
  1.31488696e-01f, 1.53653070e-01f, 6.76583871e-02f, 7.26516843e-02f, -3.94236706e-02f, 3.08460500e-02f, -1.48335099e-01f, -1.54878229e-01f, -4.56209742e-02f, -1.40953526e-01f,
  1.37242943e-01f, 1.96685165e-01f, 2.31242612e-01f, -1.15902685e-01f, -3.99534503e-04f, -1.64796144e-01f, 1.79563046e-01f, 7.16470107e-02f, 1.57108158e-01f, 8.29367265e-02f,
  2.59297460e-01f, 1.06153145e-01f, -4.10177745e-02f, 1.50845319e-01f, 7.53186271e-02f, 7.91750848e-02f, 1.04048615e-02f, -4.04793359e-02f, 4.31263214e-03f, 8.45354721e-02f,
  -7.18758702e-01f, -4.62651514e-02f, -2.92532742e-01f, -5.47317445e-01f, 1.02619953e-01f, -4.89275604e-01f, -3.28504175e-01f, 1.55022472e-01f, 1.27300188e-01f, 1.60154775e-01f,
  -1.02380030e-01f, -2.55893290e-01f, 4.68509436e-01f, -4.35068369e-01f, -4.34167862e-01f, 2.03241378e-01f, -4.64482784e-01f, -3.70719433e-01f, 2.19060168e-01f, -4.52154964e-01f,
  -2.05448762e-01f, 4.98673432e-02f, -1.24937885e-01f, 4.33588415e-01f, -1.52738482e-01f, 7.21104890e-02f, 1.37177065e-01f, 4.07424539e-01f, -3.61177653e-01f, 2.02462956e-01f,
  -3.23553711e-01f, 1.45366892e-01f, -9.46981609e-02f, 1.03552423e-01f, -1.24038115e-01f, 7.91647285e-02f, -1.90305978e-01f, 1.24335922e-01f, -1.33250207e-01f, 1.48759214e-02f,
  -1.73234940e-01f, 5.48193604e-02f, 6.00981154e-02f, 1.66064009e-01f, 2.93014441e-02f, 5.34505025e-02f, -9.36144739e-02f, -1.45272657e-01f, 3.08758989e-02f, -2.72974893e-02f,
  -8.14132839e-02f, -1.68511689e-01f, -2.19849512e-01f, 1.38923023e-02f, -1.29093319e-01f, -3.42112072e-02f, -1.20346017e-01f, -6.65272921e-02f, -1.07444584e-01f, -6.08244352e-02f,
  3.68482694e-02f, 1.97825078e-02f, -6.05747066e-02f, 3.58781934e-01f, -5.08641750e-02f, 3.76694500e-02f, 1.40389416e-03f, 5.98911243e-03f, -4.18940596e-02f, -4.55367379e-02f,
  -1.37116715e-01f, -3.67260240e-02f, 1.89266488e-01f, -8.45557228e-02f, -3.41586173e-02f, -1.22992948e-01f, -1.74199834e-01f, 8.04846734e-02f, -1.15653910e-02f, -1.56071112e-01f,
  1.89646333e-02f, -8.87253135e-02f, 1.34103909e-01f, -4.25854027e-02f, -1.36705935e-01f, 1.01047516e-01f, 3.88425961e-02f, -2.46624388e-02f, -8.12817067e-02f, 6.67446712e-03f,
  -5.28207123e-01f, -1.50599912e-01f, 9.17852372e-02f, 1.33675978e-01f, -1.59299925e-01f, -3.40745505e-03f, -1.18227549e-01f, 4.88042785e-03f, -1.02514148e-01f, 1.16697699e-01f,
  2.94705313e-02f, 3.60887460e-02f, -1.56744659e-01f, 1.16718963e-01f, -1.57172725e-01f, -2.53621172e-02f, -2.58677304e-01f, 4.38670861e-03f, -8.91245231e-02f, -9.94248018e-02f,
  -7.82324448e-02f, -7.87261650e-02f, 1.03907734e-02f, 7.30531104e-03f, -8.49400461e-02f, -6.93917274e-02f, -1.65496081e-01f, -9.06625614e-02f, -2.04459522e-02f, 7.56374886e-03f,
  1.33610204e-01f, -4.06502485e-01f, -7.34376729e-01f, -1.12452116e-02f, 7.43503049e-02f, -1.96354195e-01f, -5.76115549e-01f, 1.42517343e-01f, -3.10892165e-01f, 1.15697958e-01f,
  3.27114761e-01f, 3.93904969e-02f, -3.42354685e-01f, 7.44182646e-01f, 4.20198798e-01f, -5.59362248e-02f, 4.95872587e-01f, 3.06676507e-01f, -2.93100136e-03f, -4.25751321e-02f,
  2.94995368e-01f, 5.92252970e-01f, 2.06009418e-01f, 3.55978906e-01f, 2.86587387e-01f, -5.63687831e-02f, 3.11451197e-01f, -2.68211901e-01f, 3.94432008e-01f, 3.31479460e-01f,
  8.93069506e-02f, 1.11659477e-02f, -1.90268412e-01f, -5.98131046e-02f, -8.33604187e-02f, -1.08043358e-01f, -1.27872407e-01f, 6.69879988e-02f, -1.27267361e-01f, -1.08580567e-01f,
  -1.68442339e-01f, 1.14924014e-01f, 6.77959546e-02f, 1.54196694e-02f, -9.98261720e-02f, -1.29872173e-01f, -1.70449793e-01f, 1.05570503e-01f, -1.82625055e-01f, -5.51956519e-02f,
  -2.36121714e-01f, 8.22738484e-02f, 1.77066699e-02f, 1.20287478e-01f, -1.33790806e-01f, -7.53162727e-02f, -1.06912097e-02f, -1.12532996e-01f, 8.89640301e-02f, 1.32234976e-01f,
  1.22098066e-02f, 2.79834829e-02f, -7.83339888e-02f, 7.79893100e-02f, -1.20882601e-01f, -3.45914327e-02f, 1.85457021e-01f, -3.92321758e-02f, -7.29104206e-02f, -1.27165064e-01f,
  4.45176847e-02f, -1.34433001e-01f, 8.64500403e-02f, -8.65736753e-02f, 6.78614974e-02f, 8.58469773e-03f, -1.38704985e-01f, 1.61580779e-02f, -1.31704673e-01f, -9.55263823e-02f,
  -2.54193787e-02f, -6.32666722e-02f, -1.28188908e-01f, 3.70573029e-02f, 8.35783482e-02f, -1.91557985e-02f, 1.96722493e-01f, -8.25811699e-02f, 5.82854711e-02f, 5.22702821e-02f,
  2.35572048e-02f, 9.20231082e-03f, -4.19771969e-02f, 5.80309220e-02f, -6.56041056e-02f, -3.23231565e-03f, 5.83364516e-02f, 4.05890942e-02f, 7.20489398e-03f, -1.76422089e-01f,
  2.02822639e-03f, -9.24934074e-02f, 1.38651267e-01f, 1.47802368e-01f, 1.33276626e-01f, -2.73941606e-02f, -1.99923441e-02f, 2.18393486e-02f, 1.36065865e-02f, 1.14466511e-01f,
  -7.73259029e-02f, -1.12486281e-01f, -1.92283951e-02f, -2.30428621e-01f, 8.65343884e-02f, 1.75495155e-03f, -4.37487513e-02f, 5.63316010e-02f, 9.85507891e-02f, 6.75378144e-02f,
  6.34494543e-01f, -4.46731150e-01f, -4.68501784e-02f, 6.12241983e-01f, -1.03942789e-01f, -2.46986359e-01f, 1.05315186e-01f, -1.98715813e-02f, 8.46663296e-01f, -5.05785644e-01f,
  -3.64179045e-01f, 8.06983784e-02f, 1.59698337e-01f, -4.89878923e-01f, 6.91893339e-01f, 2.21741423e-01f, 1.56534463e-01f, -8.03276375e-02f, 2.02402025e-01f, 1.50874063e-01f,
  3.87417048e-01f, -1.55961782e-01f, -9.01232809e-02f, -3.87573570e-01f, -2.19157934e-01f, -1.75878763e-01f, -2.16223598e-01f, -2.56034315e-01f, -7.81462967e-01f, -2.20392257e-01f,
  -1.34720013e-01f, 1.24964483e-01f, -1.20353125e-01f, -9.61877555e-02f, 1.27112448e-01f, -1.10348031e-01f, -1.31858170e-01f, -9.55392569e-02f, 1.18422225e-01f, 7.61783719e-02f,
  9.10294876e-02f, 8.03223476e-02f, 5.31845689e-02f, 3.41486968e-02f, -2.58702151e-02f, -7.46855065e-02f, 6.84509100e-03f, -1.35670155e-01f, -1.04176074e-01f, -4.52882648e-02f,
  3.69178951e-02f, -8.40825215e-02f, 1.22400768e-01f, -1.09093636e-01f, 2.48655044e-02f, -1.77183449e-02f, -6.20823354e-02f, -8.31438005e-02f, -6.55681565e-02f, 1.31188333e-01f,
  -6.99710697e-02f, 3.58799547e-02f, -2.19927859e-02f, -2.97077931e-02f, 3.23967859e-02f, -4.43262458e-02f, 5.06800972e-03f, -1.40228674e-01f, 1.04023136e-01f, -7.53260478e-02f,
  4.18231785e-02f, -1.81994494e-02f, -1.06440103e-02f, 5.49107678e-02f, 8.72956589e-02f, 1.32106677e-01f, -5.57207242e-02f, -8.28314573e-02f, 2.14777887e-01f, -1.45981843e-02f,
  2.38052905e-02f, 5.04695103e-02f, -1.26236947e-02f, -2.82599870e-02f, -6.73067346e-02f, 7.45100453e-02f, -4.51921523e-02f, -1.18241832e-01f, -7.66291544e-02f, 7.60648251e-02f,
  3.03728003e-02f, 2.60835260e-01f, -4.88674641e-03f, -1.11311421e-01f, -5.57858050e-02f, -3.66448537e-02f, 2.92329658e-02f, -4.46773432e-02f, 2.22286418e-01f, 2.73203030e-02f,
  -6.25328422e-02f, -5.65512329e-02f, 2.51116529e-02f, -7.22492337e-02f, -4.46074009e-02f, 3.88602577e-02f, 8.82210061e-02f, 7.79559314e-02f, 7.08741620e-02f, -7.58400410e-02f,
  -9.34837759e-02f, 4.30612788e-02f, 9.63682830e-02f, 9.23746601e-02f, -1.71701629e-02f, -2.69210692e-02f, 2.13022027e-02f, -9.93383080e-02f, 8.94622505e-02f, 7.48306513e-02f,
  -2.34471440e-01f, -1.41175702e-01f, 6.48499548e-01f, -3.75893295e-01f, 4.20462608e-01f, 6.65863872e-01f, 2.29599774e-01f, -1.39538527e-01f, -4.90267903e-01f, -3.51239413e-01f,
  -2.58497894e-01f, 2.44522840e-01f, 2.78191358e-01f, -3.28113407e-01f, 6.25330687e-01f, 1.77400876e-02f, -2.03495234e-01f, -1.97667494e-01f, -2.63436083e-02f, -1.15614533e-01f,
  -5.92421517e-02f, -5.49252570e-01f, 3.82733583e-01f, -2.15710044e-01f, 5.00248149e-02f, -8.78717452e-02f, -3.67457092e-01f, 4.48062479e-01f, -1.79540023e-01f, 2.00970024e-01f,
  2.33230144e-02f, -3.91520381e-01f, 9.00299251e-02f, 7.34315291e-02f, -2.01319754e-02f, 7.87558183e-02f, 4.91764434e-02f, 1.46119505e-01f, 3.70190479e-02f, -3.38050462e-02f,
  -4.39460836e-02f, 1.40174285e-01f, -2.06972286e-01f, 7.76285902e-02f, 4.34559546e-02f, 1.42369121e-02f, 1.97629407e-01f, 3.00700683e-02f, 1.13459036e-01f, 2.49566361e-01f,
  2.54923999e-01f, 1.89038455e-01f, -2.49324143e-02f, 1.17700594e-02f, 1.97599858e-01f, 1.22046374e-01f, 1.94918476e-02f, 2.92349815e-01f, 4.99483943e-02f, -3.52404602e-02f,
  -8.53359103e-02f, -2.40873750e-02f, 1.28632784e-01f, -2.81807762e-02f, -2.97514964e-02f, 3.66326198e-02f, -6.26877248e-02f, -2.21850965e-02f, 4.34402116e-02f, -2.34366115e-03f,
  8.39623157e-03f, 4.73748660e-03f, -8.53634551e-02f, -3.02291494e-02f, -1.27410904e-01f, -9.81101319e-02f, 3.94532531e-02f, 2.08606888e-02f, -2.48039588e-02f, 9.47218910e-02f,
  -9.76595506e-02f, -1.20108696e-02f, 7.37627372e-02f, -4.48431298e-02f, 1.05231740e-02f, 2.56528258e-02f, -5.28726205e-02f, 8.75742286e-02f, -1.27461523e-01f, 8.95368978e-02f,
  -2.64137655e-01f, -5.54593563e-01f, -2.49260649e-01f, -8.30464959e-02f, -7.08933026e-02f, -4.75457236e-02f, -1.73132777e-01f, 1.50673753e-02f, -9.99601372e-03f, -5.04304580e-02f,
  -4.52465750e-02f, -7.88281038e-02f, -1.82740123e-03f, -3.95895950e-02f, -2.86427769e-03f, -6.12128619e-03f, -8.44262093e-02f, -1.69524819e-01f, 8.58078129e-04f, -3.25297341e-02f,
  -6.50017336e-02f, -4.23120186e-02f, 1.81523766e-02f, -2.19923649e-02f, -1.66723981e-01f, 2.74551176e-02f, -1.59160674e-01f, 1.77275501e-02f, 1.35138810e-01f, -4.37091067e-02f,
  6.19202495e-01f, -1.21491097e-01f, 6.62108541e-01f, 6.41011834e-01f, 3.17877322e-01f, 3.14138085e-01f, 4.65894252e-01f, 4.52166498e-01f, 8.90818477e-01f, -6.04392469e-01f,
  -5.54148674e-01f, 5.59115224e-02f, -7.43893564e-01f, 1.82174847e-01f, 5.92851304e-02f, -3.02049935e-01f, 3.93887430e-01f, -2.65055187e-02f, 3.04235667e-01f, 1.55461252e-01f,
  3.18544775e-01f, -4.86354828e-01f, -1.26466483e-01f, -3.78945768e-01f, 1.24681547e-01f, 3.27669740e-01f, -6.76551640e-01f, -1.37951195e-01f, -9.66863483e-02f, 1.58454537e-01f,
  -4.14546698e-01f, 9.15255174e-02f, -7.67578408e-02f, 2.11501345e-02f, -8.33159983e-02f, 1.34045845e-02f, 6.06912933e-02f, 1.28449369e-02f, 1.59009084e-01f, -3.34629193e-02f,
  -1.23786151e-01f, -5.58119193e-02f, 1.23653695e-01f, -2.36228248e-03f, 2.52216995e-01f, 1.05616026e-01f, 6.64660260e-02f, 4.62818369e-02f, 4.17910852e-02f, 1.37272030e-01f,
  5.63326031e-02f, 9.03053582e-02f, 3.10579054e-02f, 1.07988968e-01f, -2.32122019e-02f, 1.48734227e-01f, 2.13933378e-01f, -2.78092152e-03f, -1.89018883e-02f, 2.22159758e-01f,
  1.53355286e-01f, -8.59875605e-03f, -1.50374383e-01f, -5.52316867e-02f, -2.67817695e-02f, 2.76877955e-02f, -6.29833564e-02f, -1.54927522e-01f, 9.12049934e-02f, -2.85949864e-05f,
  -1.39915003e-02f, -2.83183921e-02f, 1.78663477e-01f, 3.92507426e-02f, -3.38619866e-04f, 9.02525708e-02f, 6.16570542e-05f, 8.74845460e-02f, 9.63184386e-02f, -9.75055736e-04f,
  -2.49376688e-02f, 7.30375126e-02f, -2.04696119e-01f, 7.51897469e-02f, -1.67684481e-02f, -7.37629235e-02f, -3.87803353e-02f, 2.43931368e-01f, -1.00199908e-01f, -2.15072289e-01f,
  -7.29007006e-01f, -4.05556440e-01f, -1.80419594e-01f, -1.53288737e-01f, 4.02974263e-02f, -1.34349838e-01f, 3.58535834e-02f, 5.34977019e-02f, -1.04227014e-01f, 3.26393880e-02f,
  4.97770868e-02f, 3.15601267e-02f, -7.30438381e-02f, 8.79311636e-02f, -7.47950748e-02f, -1.87449157e-01f, -1.59779534e-01f, -6.35942072e-02f, -1.83749139e-01f, -1.23918943e-01f,
  -1.45141035e-01f, -1.25088498e-01f, -4.16047424e-02f, -1.63068827e-02f, 4.78486111e-03f, -1.02028392e-01f, -1.49790078e-01f, 2.85520069e-02f, -1.35596290e-01f, -1.66503694e-02f,
  -8.21497858e-01f, 4.13039997e-02f, -2.19976187e-01f, -6.72379375e-01f, 4.49702948e-01f, 5.01261428e-02f, 2.42512953e-02f, 2.29183406e-01f, -2.15677261e-01f, 3.65835279e-01f,
  1.22990340e-01f, -5.46407998e-01f, 1.31514400e-01f, -6.44980192e-01f, -5.46568096e-01f, -4.98453289e-01f, -7.91066825e-01f, -5.74947059e-01f, -2.83275038e-01f, -3.07779342e-01f,
  -3.26438516e-01f, 6.52700737e-02f, -2.84887254e-01f, 4.76393163e-01f, -2.40842197e-02f, 8.49943683e-02f, 2.94673681e-01f, 3.79478365e-01f, -2.12403014e-01f, -2.20097764e-03f,
  1.21751018e-01f, 1.57826737e-01f, 2.17606410e-01f, 1.32594481e-01f, 1.50264844e-01f, 2.43547261e-02f, 6.51219040e-02f, 1.03268467e-01f, 7.53208250e-02f, 2.84570232e-02f,
  -9.56230760e-02f, -5.62631385e-03f, -2.63900936e-01f, -1.34257628e-02f, 5.96658252e-02f, 6.01941571e-02f, -8.70647877e-02f, -1.55026847e-02f, 4.19547372e-02f, -4.08923507e-01f,
  -1.50633261e-01f, -2.29902461e-01f, -1.55392408e-01f, -1.93973333e-01f, -1.21713288e-01f, -1.57736987e-02f, -1.12952553e-01f, -1.38713554e-01f, 4.96858545e-02f, -1.69176653e-01f,
  -1.48344979e-01f, -4.61193919e-02f, 2.40321428e-01f, 1.54155552e-01f, 1.52725670e-02f, 1.56869024e-01f, 4.30209599e-02f, -1.02035450e-02f, 1.06458282e-02f, 3.03660557e-02f,
  7.61732087e-02f, -9.82315168e-02f, 4.42844443e-02f, -3.70494612e-02f, -1.54981911e-01f, -1.10782996e-01f, 4.99668457e-02f, -1.04596205e-02f, -2.55983621e-01f, 1.48078293e-01f,
  2.58014768e-01f, -8.88560265e-02f, 7.15761408e-02f, 1.73677742e-01f, 1.90445006e-01f, 2.10719518e-04f, -9.36604664e-02f, -1.58557594e-02f, 7.37937614e-02f, -3.78501453e-02f,
  2.00317413e-01f, 7.10301101e-02f, 3.10264260e-01f, 9.60245132e-02f, 1.57358497e-01f, 1.18271463e-01f, -3.64972139e-03f, -1.70349568e-01f, 3.11362706e-02f, -7.58032054e-02f,
  -1.28630176e-01f, 4.68370132e-02f, 7.10092625e-03f, -1.08219407e-01f, 1.87129937e-02f, 9.35899019e-02f, -3.92609835e-02f, 1.94413751e-01f, 1.33609638e-01f, -1.76440720e-02f,
  1.28583953e-01f, 6.39008656e-02f, -1.62329569e-01f, -8.43776837e-02f, -8.79333466e-02f, 1.08400531e-01f, 1.52038410e-01f, 3.47771868e-02f, -1.30797058e-01f, 6.41543940e-02f,
  -6.91238225e-01f, -5.12638032e-01f, 3.06407928e-01f, -7.42050588e-01f, -3.42276484e-01f, 3.26613545e-01f, 3.71111482e-02f, -3.31038892e-01f, -5.49414098e-01f, -3.43911141e-01f,
  -2.19604492e-01f, -1.02397382e-01f, 4.55171317e-01f, -4.01280999e-01f, 9.97839451e-01f, 5.63888609e-01f, -4.58146334e-02f, 9.24618989e-02f, -1.05995037e-01f, -6.28978968e-01f,
  -6.00996614e-02f, -4.26983625e-01f, 3.82838011e-01f, -3.96542281e-01f, -5.88996112e-01f, -4.67915535e-01f, 1.48503110e-01f, 1.04301058e-01f, -1.31117344e-01f, 1.68631881e-01f,
  -4.08929646e-01f, -5.63084781e-01f, -2.34546497e-01f, 8.88573453e-02f, -1.13983311e-01f, -4.33752201e-02f, 2.64406979e-01f, 2.31086612e-01f, 3.56902592e-02f, 5.58499135e-02f,
  2.02498008e-02f, -5.49943633e-02f, -3.11790705e-01f, 7.38576427e-02f, -2.76704341e-01f, -7.68086016e-02f, -4.49027540e-03f, 2.82991510e-02f, -2.88802814e-02f, 6.34369999e-02f,
  -6.27618954e-02f, 5.02564684e-02f, -1.02263317e-01f, 1.88685823e-02f, 5.21591529e-02f, -1.39768928e-01f, 1.01708323e-01f, 5.82484603e-02f, -3.77235115e-02f, -1.30993813e-01f,
  2.02051118e-01f, 3.50568220e-02f, -3.55543531e-02f, -1.00015633e-01f, -7.99087584e-02f, -1.08217128e-01f, -4.02139425e-02f, 6.90620989e-02f, 6.99595213e-02f, -7.92693868e-02f,
  -5.82091510e-02f, -3.81058641e-02f, -1.49689436e-01f, -3.18146832e-02f, -4.88217250e-02f, -1.08403720e-01f, 8.79642069e-02f, -7.35483766e-02f, -1.44744202e-01f, 1.00681083e-02f,
  1.06179416e-02f, 4.33699265e-02f, -1.20047517e-01f, 6.34994283e-02f, -3.24288085e-02f, 1.06772907e-01f, -1.26964524e-01f, -1.92017388e-02f, 8.71555433e-02f, 1.55124530e-01f,
  -6.18269801e-01f, -5.01054883e-01f, -1.52454972e-01f, -1.27546296e-01f, 1.18373241e-02f, 4.38547926e-03f, -1.37177715e-02f, -2.23047256e-01f, 2.08056793e-02f, 4.72506881e-03f,
  -4.21013422e-02f, -3.99046345e-03f, -7.28582591e-02f, -1.43880593e-02f, 4.47228067e-02f, 1.82707794e-02f, -1.77942179e-02f, -1.20731115e-01f, -2.62720808e-02f, -1.64887175e-01f,
  -1.15713604e-01f, -4.62320521e-02f, 1.52213380e-01f, -1.88226849e-01f, 4.87946160e-02f, -7.13709043e-03f, -1.55398518e-01f, 1.15418267e-02f, 1.51413843e-01f, -3.86820994e-02f,
  4.79700536e-01f, 2.04470053e-01f, -3.59020501e-01f, -2.69234449e-01f, -4.89358276e-01f, -5.49165547e-01f, -4.04351264e-01f, -2.50910252e-01f, 7.34600648e-02f, 2.89787054e-01f,
  -4.88897562e-01f, 6.98590279e-01f, 5.34770302e-02f, -4.25420702e-01f, -2.11751550e-01f, 1.35715827e-01f, -3.67417485e-01f, -2.40085781e-01f, -1.67960361e-01f, -1.32362053e-01f,
  -2.32022226e-01f, -4.86090839e-01f, -3.06380033e-01f, -1.92643508e-01f, -3.74497414e-01f, -5.85947260e-02f, -2.51662821e-01f, -2.90153176e-01f, -2.98614502e-01f, -2.09682107e-01f,
  -2.94188768e-01f, 4.44437675e-02f, 3.94744053e-02f, 3.11476856e-01f, -9.95932296e-02f, -6.56921193e-02f, -9.55149382e-02f, -7.80708566e-02f, -7.40817143e-03f, -2.05641985e-02f,
  3.79914284e-01f, 2.22879753e-01f, 1.19846784e-01f, 1.50810927e-01f, 1.01296149e-01f, 1.64638385e-02f, 2.77985889e-03f, -1.54261827e-01f, 8.46952200e-02f, 3.26622017e-02f,
  -3.99256460e-02f, -6.94283843e-02f, -2.18594670e-01f, 1.33543417e-01f, 2.68499348e-02f, -8.42163265e-02f, 1.70219824e-01f, 1.65878460e-01f, 1.82182062e-02f, -3.79611515e-02f,
  -2.46687187e-03f, 2.86253281e-02f, -2.65705716e-02f, -1.54612333e-01f, 6.08516075e-02f, -1.76247627e-01f, -1.05362264e-02f, -1.13397680e-01f, -2.81203706e-02f, -4.91830967e-02f,
  4.19550799e-02f, 8.48158523e-02f, -1.16508484e-01f, -9.15667266e-02f, -7.97492266e-02f, 2.79678971e-01f, -2.23905165e-02f, 3.01872879e-01f, -1.59466103e-01f, 3.81811298e-02f,
  2.57621557e-02f, -1.05406560e-01f, 4.58803773e-02f, -1.55222237e-01f, -3.91285270e-01f, 5.50028235e-02f, -8.73076171e-02f, 8.71674940e-02f, -8.60642791e-02f, -8.75416994e-02f,
  -2.24734358e-02f, 1.61892414e-01f, 1.39351889e-01f, 2.24439710e-01f, 9.96382311e-02f, -1.81155354e-02f, 4.48862463e-02f, 1.49759606e-01f, -6.82800412e-02f, -1.23431601e-01f,
  1.56818330e-01f, 8.84575024e-02f, -9.54069942e-02f, 9.73462090e-02f, 1.10593759e-01f, 6.35198057e-02f, 1.22896738e-01f, 1.33603588e-01f, 5.82918804e-03f, 3.80787393e-03f,
  8.48893672e-02f, 2.05184594e-01f, 2.48583168e-01f, -9.38617886e-05f, 2.33884931e-01f, 1.65269151e-01f, 1.85943142e-01f, 1.61085486e-01f, 6.33566305e-02f, -1.75819263e-01f,
  -2.25879565e-01f, -3.48342419e-01f, 3.27745289e-01f, 8.22516620e-01f, 7.43724257e-02f, -3.13148141e-01f, -1.72301888e-01f, -2.13903815e-01f, 1.93062261e-01f, -6.86088145e-01f,
  -3.56637776e-01f, -4.34666164e-02f, -7.14924157e-01f, 4.55894858e-01f, 6.49435163e-01f, -2.49976054e-01f, 4.70109552e-01f, -4.15574200e-02f, 1.93964973e-01f, -9.25455391e-02f,
  2.78551161e-01f, 3.26483995e-01f, 4.30444211e-01f, 3.82398635e-01f, 2.79381452e-03f, 4.09003645e-01f, 4.25284356e-01f, 1.68117434e-01f, 6.48688614e-01f, 2.66581506e-01f,
  1.81690045e-02f, -1.04749560e-01f, 3.80002782e-02f, 1.91898033e-01f, -4.03215736e-02f, -1.29712403e-01f, 3.98270898e-02f, 1.25512183e-02f, 7.99435452e-02f, 1.22882217e-01f,
  -1.34644479e-01f, 1.88809842e-01f, 1.65749803e-01f, 1.03290724e-02f, 1.30870804e-01f, 3.28704655e-01f, 1.05116025e-01f, -2.32550994e-01f, 9.72074363e-03f, -1.76318720e-01f,
  3.13918758e-03f, -3.31972959e-03f, -4.82004583e-02f, 5.73261678e-02f, 2.24959210e-01f, 2.97376215e-01f, 1.24588795e-01f, -2.79083066e-02f, 1.61442086e-01f, 1.90576792e-01f,
  -2.17116326e-01f, -8.60429928e-03f, -3.04226317e-02f, 8.50554183e-02f, -3.68253589e-02f, -2.39350051e-02f, 7.99143836e-02f, -1.19058236e-01f, 2.27892827e-02f, -1.03275813e-01f,
  2.51517206e-01f, 9.84425843e-02f, -4.70606312e-02f, 8.76642466e-02f, -3.62702534e-02f, -2.41538957e-02f, 3.20512317e-02f, 1.91781279e-02f, -4.65948842e-02f, 6.88778190e-03f,
  -1.28965184e-01f, 1.66805804e-01f, 8.85797944e-03f, -1.28035456e-01f, 9.57214832e-02f, -6.78260252e-02f, -4.56252918e-02f, -1.80100128e-01f, -1.14358049e-02f, -3.85170802e-02f,
  4.53044027e-02f, 3.51772398e-01f, 5.38793169e-02f, 1.93867952e-01f, 1.15392670e-01f, -1.16290152e-01f, 9.73325521e-02f, 1.18357338e-01f, 2.40435928e-01f, -5.28550474e-03f,
  -1.75328106e-01f, 9.43329781e-02f, -8.67328867e-02f, 9.79878679e-02f, 9.25678164e-02f, -4.35403176e-02f, 1.15153939e-01f, 2.54469424e-01f, 2.60128707e-01f, 2.77896859e-02f,
  1.04646675e-01f, -2.69800991e-01f, 1.15628481e-01f, 5.15644886e-02f, -1.35933995e-01f, -2.83457097e-02f, -1.27495959e-01f, 5.79740852e-02f, -5.06471470e-02f, 3.98368239e-02f,
  -5.56158602e-01f, 1.86011076e-01f, 7.63279200e-02f, -7.34518021e-02f, 2.96731234e-01f, 7.13555217e-01f, -1.85620096e-02f, 2.08726108e-01f, 2.21315354e-01f, -2.55339071e-02f,
  -2.85122842e-01f, -2.08667606e-01f, -4.11200911e-01f, -7.59894028e-02f, 2.57343680e-01f, 2.01501802e-01f, 4.22055602e-01f, 3.21030349e-01f, -1.20073110e-01f, -1.00081623e-01f,
  -2.79330045e-01f, -1.52466193e-01f, -4.81198788e-01f, -2.93872245e-02f, -1.43360212e-01f, -1.50854081e-01f, -1.30187675e-01f, -7.75316078e-03f, -5.03767319e-02f, 1.58494458e-01f,
  -1.27222478e-01f, -2.57184505e-01f, -2.72821873e-01f, 6.51906431e-02f, 6.39897585e-02f, 1.33775443e-01f, 3.81964296e-02f, 4.15509660e-03f, -8.27596709e-02f, -9.51998681e-02f,
  -3.84496897e-02f, -4.90033813e-02f, -1.05106935e-01f, 3.06696240e-02f, -3.29999328e-02f, -8.49627629e-02f, -1.47332028e-01f, 1.69334318e-02f, -9.60769802e-02f, 2.17438433e-02f,
  -2.32134119e-01f, -7.36549124e-02f, -6.01655543e-02f, 2.15992525e-01f, -2.09768936e-01f, -3.92618515e-02f, 1.12692483e-01f, -5.66458888e-02f, 1.16660379e-01f, 1.35562465e-01f,
  1.25884116e-01f, 3.17705721e-01f, -2.19410256e-01f, -3.95118780e-02f, -1.37348473e-01f, 3.52732614e-02f, 1.33351564e-01f, -8.57958570e-02f, -4.75286990e-02f, -8.51587728e-02f,
  -4.01627421e-02f, -7.58625418e-02f, -3.95651571e-02f, -4.75512911e-03f, -2.09651031e-02f, 4.39398587e-02f, -2.58910609e-03f, -6.90999394e-03f, 9.06223431e-02f, -7.42434934e-02f,
  1.08597688e-02f, 1.11397207e-01f, -2.10847691e-01f, 7.41749257e-02f, 1.90349847e-01f, -1.46346882e-01f, -4.17812206e-02f, -1.36991307e-01f, -1.34563530e-02f, 1.23580925e-01f,
  4.49281216e-01f, 6.64294600e-01f, -1.92615137e-01f, -1.80933163e-01f, 7.53816217e-02f, 1.89792052e-01f, 1.38358712e-01f, -7.59455711e-02f, 8.13044310e-02f, 1.16784507e-02f,
  1.67721078e-01f, -1.22887604e-01f, 2.05862463e-01f, -5.00331484e-02f, 7.44936988e-02f, -1.25456691e-01f, -7.71605235e-04f, 2.68544197e-01f, 3.62462014e-01f, -2.34101317e-03f,
  -2.41489168e-02f, -1.08487578e-02f, 2.38127783e-02f, -1.33020040e-02f, -5.86204790e-02f, -1.27707282e-02f, 7.74482861e-02f, 3.98347825e-02f, -3.48578058e-02f, 5.49604148e-02f,
  1.04501057e+00f, -8.46108258e-01f, -5.58776021e-01f, 6.06277168e-01f, 5.89265764e-01f, 5.76208949e-01f, 8.41047466e-01f, 3.72498661e-01f, 4.04322833e-01f, -1.45022526e-01f,
  4.10290241e-01f, -5.30334353e-01f, -3.07233006e-01f, 4.80190188e-01f, 4.91609246e-01f, -2.45182328e-02f, 5.40315688e-01f, 1.98143333e-01f, -1.22434691e-01f, -2.12638780e-01f,
  3.08695018e-01f, 4.77571815e-01f, -4.01475839e-02f, -2.17712998e-01f, 2.65402436e-01f, -2.01090828e-01f, -3.89523357e-02f, -2.35663459e-01f, 1.12788290e-01f, 5.82076311e-02f,
  3.93043488e-01f, 1.72824606e-01f, 1.06087610e-01f, -2.63017654e-01f, 4.34747664e-03f, -1.69741511e-02f, 3.10510136e-02f, -3.12715918e-02f, 1.65798083e-01f, 1.93827935e-02f,
  -8.04128498e-02f, 5.71550392e-02f, 5.56620173e-02f, 4.00488153e-02f, 1.37583390e-01f, 1.98583212e-02f, 6.09104112e-02f, 3.64218093e-02f, 3.34028229e-02f, 1.93397868e-02f,
  4.69360501e-03f, -5.77194802e-02f, 9.03751031e-02f, -2.67441105e-02f, -2.47228779e-02f, 1.41310655e-02f, -2.02475414e-02f, -1.09885678e-01f, -7.51501992e-02f, 3.50896604e-02f,
  6.24146052e-02f, -6.52131885e-02f, -4.48613875e-02f, -4.17956077e-02f, -5.45179546e-02f, 5.15787527e-02f, -4.38554548e-02f, -3.75465974e-02f, 2.16488354e-02f, 3.66286002e-02f,
  1.50405839e-01f, 1.11836493e-01f, 7.73583632e-03f, 5.63455857e-02f, 1.02572754e-01f, 9.99980494e-02f, 3.43090035e-02f, 3.71061673e-04f, 7.93974847e-02f, 9.95888785e-02f,
  -5.09948470e-02f, 2.07868144e-02f, -7.36475363e-02f, -1.29087921e-02f, -1.14214987e-01f, 8.69794935e-03f, -8.26257989e-02f, 3.49195190e-02f, 6.24879822e-02f, 5.29753454e-02f,
  -3.57424051e-01f, -6.33612514e-01f, -2.32518036e-02f, -4.87341397e-02f, -1.31150350e-01f, -4.31066714e-02f, -6.74453303e-02f, -3.06245908e-02f, -2.26906702e-01f, 9.70684290e-02f,
  8.18522125e-02f, 1.00125812e-01f, -1.12313859e-01f, -6.38910308e-02f, -1.90910488e-01f, 1.14029115e-02f, -1.82328876e-02f, -1.58394560e-01f, 3.24699283e-02f, -8.16261470e-02f,
  -4.31263484e-02f, 6.86432049e-02f, 4.09710258e-02f, 9.20808092e-02f, 6.18899688e-02f, -4.82513662e-03f, -9.86546725e-02f, -3.94161232e-02f, -3.59293371e-02f, -1.12339079e-01f,
  -4.69674647e-01f, -5.58329582e-01f, -1.92198545e-01f, -3.61295372e-01f, 3.77932303e-02f, 3.58947396e-01f, -4.11552876e-01f, 6.53870702e-02f, -7.01198876e-01f, -2.24810801e-02f,
  1.01907603e-01f, -6.75935566e-01f, -2.45670930e-01f, -2.02055126e-01f, -8.86847004e-02f, -3.91350389e-01f, 2.52307057e-01f, 2.20836997e-01f, -5.57578914e-02f, 4.46928710e-01f,
  1.21059872e-01f, 3.71142238e-01f, 3.57868463e-01f, 5.72381556e-01f, 3.07679743e-01f, 4.39488679e-01f, 6.54044032e-01f, 1.50441602e-01f, 5.46383858e-01f, -7.04563260e-02f,
  -3.28943618e-02f, -2.36474037e-01f, -1.44086732e-02f, -1.64149143e-02f, 3.92513186e-01f, 1.46026462e-01f, 2.32753322e-01f, -3.21473628e-02f, -6.03233948e-02f, -2.40352890e-03f,
  -2.18458064e-02f, -6.21915311e-02f, 8.64378810e-02f, -2.55678475e-01f, -1.23106718e-01f, -1.05112866e-01f, -1.13651931e-01f, 1.24658108e-01f, -1.77065343e-01f, -1.14037469e-01f,
  -9.49980691e-02f, 2.17552781e-02f, 4.93880436e-02f, 8.73772353e-02f, -1.19422376e-01f, -1.54594421e-01f, -5.98358251e-02f, 1.47394910e-01f, -5.15755005e-02f, -1.43816201e-02f,
  3.54192778e-02f, 6.63118511e-02f, 1.58015974e-02f, -1.03983983e-01f, 2.10274011e-02f, -1.09707318e-01f, -2.13229939e-01f, 2.00488674e-03f, -6.08054735e-02f, -4.78659868e-02f,
  -6.42675683e-02f, -1.87994111e-02f, -2.77104825e-01f, 5.10400124e-02f, 1.23255931e-01f, -2.98483167e-02f, 4.48173843e-02f, 4.42966595e-02f, 1.59084678e-01f, 1.04120746e-01f,
  -3.01211357e-01f, 3.64202610e-03f, 7.95639306e-02f, 1.91537291e-02f, -9.35080796e-02f, -1.67573001e-02f, 5.04528619e-02f, -9.79512706e-02f, 1.30913690e-01f, 2.94459369e-02f,
  3.35431814e-01f, 3.54769558e-01f, -2.64735688e-02f, -4.57684621e-02f, 2.71711517e-02f, 7.63860345e-02f, -3.48165892e-02f, -5.34654222e-02f, 6.67695478e-02f, -1.55461244e-02f,
  2.71058261e-01f, 1.95461124e-01f, 2.50291382e-03f, 3.25070620e-02f, 7.10234120e-02f, 1.79240808e-01f, 4.90315668e-02f, 5.19004650e-03f, 1.05226278e-01f, 1.86833337e-01f,
  1.05107650e-01f, 1.82518840e-01f, -4.68440764e-02f, 1.14000514e-01f, 2.95527223e-02f, 5.97223528e-02f, 1.05769083e-01f, 6.56555872e-03f, 2.46518217e-02f, -4.26412709e-02f,
  5.13045013e-01f, -2.63126284e-01f, -4.37902927e-01f, -1.75898075e-01f, 4.66409832e-01f, 4.31127042e-01f, -1.71637163e-01f, -5.98167591e-02f, -1.10822797e-01f, -1.76540688e-02f,
  2.08424836e-01f, -1.05686396e-01f, -6.93808973e-01f, 5.61900496e-01f, 1.63683251e-01f, -4.83104259e-01f, 3.13946694e-01f, 1.06315963e-01f, 2.49258466e-02f, 1.30207941e-01f,
  1.36790365e-01f, 5.60004592e-01f, -2.95138597e-01f, 3.22211534e-01f, 2.47688204e-01f, -2.34340534e-01f, -4.62974608e-02f, -3.49614024e-01f, 1.72639430e-01f, 2.05102980e-01f,
  6.37433901e-02f, 1.06082276e-01f, -7.38808513e-02f, -4.79600355e-02f, 3.79235893e-02f, 1.04570299e-01f, -7.11638108e-02f, -2.02772722e-01f, 1.00686988e-02f, -2.14230473e-04f,
  -5.31219691e-02f, 4.94366549e-02f, 7.51527250e-02f, -1.00842446e-01f, 3.02731454e-01f, 7.89710954e-02f, 3.02563775e-02f, -6.92350268e-02f, -1.26341701e-01f, 4.94359061e-02f,
  -1.32679686e-01f, 1.01122400e-02f, 1.95609167e-01f, -1.59171447e-01f, -2.43239012e-02f, 9.59078744e-02f, -7.77473673e-02f, -1.09322235e-01f, 4.72076179e-04f, 2.13227764e-01f,
  1.01487814e-02f, 3.42889130e-02f, 9.83312428e-02f, 8.82685035e-02f, 1.62005387e-02f, 8.51832889e-03f, 3.12658655e-03f, 2.95397472e-02f, 1.96406599e-02f, 5.83318658e-02f,
  -6.38177246e-02f, -7.33040227e-03f, 4.13876623e-02f, 2.66551226e-02f, 1.39595523e-01f, 1.59997836e-01f, -8.24806467e-03f, -7.30031803e-02f, -1.69250235e-01f, -8.61749146e-03f,
  -1.26707122e-01f, 1.11771092e-01f, -2.61783972e-02f, -5.07776253e-02f, 1.03011690e-01f, -1.17223963e-01f, 5.54120913e-02f, 3.90758887e-02f, -5.50522506e-02f, -7.87266195e-02f,
  -5.07948883e-02f, -1.53747648e-01f, -1.03192307e-01f, -1.03785554e-02f, -1.27366260e-01f, 1.89057410e-01f, -5.63584361e-03f, 1.10348603e-02f, -1.00874864e-01f, 1.54149964e-01f,
  4.18544523e-02f, -5.94069473e-02f, 4.35723849e-02f, 3.74406427e-02f, -1.03565805e-01f, 6.28457144e-02f, -1.35265276e-01f, -1.54319972e-01f, -4.68012728e-02f, -3.58351273e-03f,
  -3.28136161e-02f, 4.62208465e-02f, 1.06930509e-02f, 1.47424147e-01f, 5.70374578e-02f, -1.97137985e-02f, 3.96344475e-02f, -8.52644742e-02f, -5.88370971e-02f, -8.65144730e-02f,
  6.43727064e-01f, -6.35758698e-01f, -2.12506384e-01f, -1.08239509e-01f, 4.93952692e-01f, 5.40130854e-01f, 2.91718900e-01f, -2.86425769e-01f, -4.73680228e-01f, -7.10225403e-01f,
  1.96385071e-01f, -1.99808136e-01f, -6.86446354e-02f, 7.47354627e-02f, 6.45114005e-01f, -1.09600715e-01f, 2.53104836e-01f, 1.59031793e-01f, -6.99868277e-02f, -5.94993634e-03f,
  1.22458160e-01f, 5.00720918e-01f, 2.00011611e-01f, -5.10146990e-02f, 3.97223979e-01f, -2.54357874e-01f, -3.16840224e-03f, -4.70092483e-02f, -8.03816020e-02f, 2.95112848e-01f,
  2.16378003e-01f, -2.28195816e-01f, 3.82730477e-02f, -3.82808819e-02f, -2.28385907e-02f, 1.07160844e-01f, 8.80969539e-02f, 1.86623037e-01f, 4.29023169e-02f, -1.77450508e-01f,
  2.48262938e-02f, 5.21057397e-02f, -1.21670282e-02f, 1.68372065e-01f, -8.06486607e-02f, -9.04446244e-02f, -1.37966737e-01f, 8.37909407e-04f, -1.42178327e-01f, 1.50789944e-02f,
  -4.64337505e-02f, 5.05556799e-02f, 1.40392892e-02f, -3.10485903e-02f, -1.28706262e-01f, -3.53292823e-02f, 4.89371009e-02f, -1.05711266e-01f, -1.64042071e-01f, -1.24324448e-01f,
  1.77447610e-02f, 1.52492672e-01f, 1.79013416e-01f, 8.07302166e-03f, 3.59873101e-02f, -5.68199232e-02f, 9.12977755e-02f, -1.29439840e-02f, -6.94609508e-02f, 9.04059911e-04f,
  3.43915075e-02f, -8.62217918e-02f, 2.07727421e-02f, 4.72980998e-02f, 1.09899268e-01f, 8.92226323e-02f, 2.06592411e-01f, -4.75298315e-02f, -2.99051572e-02f, -3.96228209e-02f,
  1.94835529e-01f, -2.66098157e-02f, -1.39584644e-02f, 5.71342073e-02f, -8.39445926e-03f, 2.74237134e-02f, -1.28622532e-01f, -3.89835574e-02f, -9.96756852e-02f, 2.69182682e-01f,
  -1.80880681e-01f, -6.09901309e-01f, -1.44579545e-01f, -5.21186099e-04f, -5.24839666e-03f, 4.20598239e-02f, 3.37769240e-02f, -6.48037642e-02f, 1.71170477e-02f, -9.92988702e-03f,
  -1.30802346e-02f, 3.92859243e-02f, -4.59771976e-02f, 9.51502174e-02f, 8.66099000e-02f, -9.58308652e-02f, -9.06147808e-03f, 1.88877888e-03f, 3.63089442e-02f, -1.55685604e-01f,
  -1.89810041e-02f, -1.04852535e-01f, -4.86620255e-02f, -2.61799227e-02f, -8.82520527e-02f, 4.13893461e-02f, 4.78298031e-02f, -4.73714359e-02f, 9.16030705e-02f, -7.44587481e-02f,
  -5.32423913e-01f, 6.77390099e-01f, -1.98232695e-01f, -3.95897143e-02f, -5.18153965e-01f, 8.71694803e-01f, 6.76236451e-01f, 4.33678739e-02f, 5.07338196e-02f, 5.57697237e-01f,
  1.78433225e-01f, -3.29105020e-01f, 3.85587871e-01f, 5.74256003e-01f, 7.85801932e-02f, 6.01664543e-01f, 5.18998861e-01f, 2.94406444e-01f, -1.16839908e-01f, 7.31350705e-02f,
  -5.20723984e-02f, 3.73836875e-01f, 4.46161069e-02f, 4.56131063e-02f, -7.37380460e-02f, -2.79678881e-01f, -2.86407351e-01f, -2.33177826e-01f, 2.93546859e-02f, -1.31040409e-01f,
  1.09492943e-01f, -1.46110386e-01f, -6.67560846e-02f, 1.43934458e-01f, 9.35499370e-02f, -9.30111185e-02f, -7.42637515e-02f, -2.19741538e-01f, -2.25198150e-01f, -9.53998417e-02f,
  -9.04523507e-02f, 4.68030721e-02f, 3.26345451e-02f, -1.14439107e-01f, -2.00401425e-01f, -1.21760085e-01f, -6.87080696e-02f, -3.20734456e-02f, 3.69338994e-03f, 3.81299220e-02f,
  4.58253995e-02f, 6.45408556e-02f, 1.06658883e-01f, 1.57017142e-01f, -5.91842942e-02f, 1.25193428e-02f, 2.78773278e-01f, -5.03887385e-02f, 1.24969974e-01f, 4.44231667e-02f,
  -1.43245637e-01f, 2.31008023e-01f, 1.75845861e-01f, -2.70031132e-02f, 5.95467910e-02f, -4.44035269e-02f, -1.10927233e-02f, -4.40693274e-02f, -1.45682409e-01f, 1.89689785e-01f,
  -1.76745839e-02f, -5.76431565e-02f, -2.88893990e-02f, 1.90275520e-01f, -8.04164354e-03f, 8.33457708e-02f, -8.54498670e-02f, -2.35324334e-02f, -9.14466800e-04f, 4.45110388e-02f,
  5.16640805e-02f, 3.95333841e-02f, -1.03952829e-02f, -1.00539126e-01f, 4.28327620e-02f, -1.00643195e-01f, 9.01905936e-04f, 1.90888084e-02f, -9.86515637e-03f, -1.16173958e-03f,
  4.02391613e-01f, 4.67028528e-01f, 4.39683571e-02f, 4.13935333e-02f, 6.13547824e-02f, -2.80740950e-02f, 1.32046923e-01f, 7.13066384e-02f, 9.83865187e-02f, 3.68948765e-02f,
  -3.74961458e-02f, 1.13937698e-01f, 1.38184667e-01f, -1.65328041e-01f, 6.97539598e-02f, 2.13472188e-01f, 1.75186068e-01f, -8.70747492e-02f, 5.57614528e-02f, -1.04910329e-01f,
  1.44151468e-02f, -5.92525490e-03f, 1.14468537e-01f, 3.94742787e-02f, 7.83423334e-02f, 2.97396295e-02f, -9.65064541e-02f, -7.67591894e-02f, 1.31324371e-02f, 1.20384708e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.17640954e-01f, 8.54953289e-01f, 8.10495019e-01f, 5.81447303e-01f, 2.21826330e-01f, 4.03101206e-01f, 5.68257689e-01f, 4.67586935e-01f, 5.14377713e-01f, 4.18615937e-01f,
  7.69634962e-01f, 5.70311129e-01f, 1.57472193e-01f, 9.08314824e-01f, 6.45739138e-01f, 1.00721371e+00f, 6.97535157e-01f, 6.33658171e-01f, 7.09812224e-01f, 1.13190070e-01f,
  4.70203251e-01f, 6.22275770e-01f, 7.31178284e-01f, 3.89172733e-01f, 5.15707910e-01f, 7.53695607e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.48360997e-01f, -1.61797218e-02f, -4.85268414e-01f, 7.19564408e-02f, 2.68368006e-01f, -5.45983493e-01f, 3.18884283e-01f, -1.87183172e-01f, -6.65374875e-01f, -5.76368332e-01f,
  9.20772135e-01f, -2.84256309e-01f, 4.02519345e-01f, -7.49505460e-01f, -9.10463810e-01f, 5.54924786e-01f, 7.95071796e-02f, -1.61184907e-01f, -5.50981686e-02f, -7.81094968e-01f,
  -8.39569747e-01f, -6.32478833e-01f, 7.42198899e-02f, 2.63196319e-01f, -9.80580866e-01f, -3.07348132e-01f, -1.78935692e-01f, -6.71930015e-02f, 1.23491503e-01f, -6.58788264e-01f,
  -3.77564341e-01f, 7.14812517e-01f, -3.16409618e-01f, -1.70026645e-01f, 3.32006544e-01f, 2.37088487e-01f, -4.98343617e-01f, -5.93718328e-02f, 5.17137825e-01f, 1.64010122e-01f,
  -8.10341775e-01f, 2.12916866e-01f, -8.82844567e-01f, 1.88890472e-01f, 6.56042457e-01f, -3.29163730e-01f, -3.65223587e-01f, -6.84635520e-01f, -5.76253116e-01f, -6.42159760e-01f,
  4.67792153e-01f, -3.74672830e-01f, -4.06822443e-01f, -9.61516321e-01f, -6.17786109e-01f, -1.07567596e+00f, -3.22855890e-01f, -7.03144252e-01f, 1.90676332e-01f, 4.28900123e-01f,
  -2.85931863e-02f, 6.68062389e-01f, 4.44675148e-01f, 2.96100736e-01f, -1.98530585e-01f, -2.02240795e-01f, -3.50462526e-01f, 3.96477580e-01f, 6.84421480e-01f, 5.25200844e-01f,
  1.50617585e-01f, -1.02464509e+00f, -5.66419542e-01f, 4.96207923e-02f, -3.80366921e-01f, -1.56391367e-01f, -8.99734139e-01f, -6.51592433e-01f, -1.51669204e-01f, -7.51381442e-02f,
  -4.07899022e-01f, -2.56017447e-01f, 6.06836975e-01f, -6.98256493e-01f, -1.84674382e-01f, 9.67728794e-02f, -1.57239810e-01f, -1.36952549e-01f, -5.64386249e-01f, 8.14479470e-01f,
  6.86524138e-02f, 3.23093712e-01f, 1.73212871e-01f, 5.14315844e-01f, 4.97780323e-01f, -8.48096490e-01f, 1.56424642e-01f, -1.55436575e-01f, -6.33481562e-01f, 1.17237091e-01f,
  -2.91868955e-01f, -4.49273646e-01f, -4.38685805e-01f, -6.47274613e-01f, 1.09798439e-01f, -1.71700567e-01f, 2.88315594e-01f, -9.64226052e-02f, -2.03391880e-01f, 6.84563339e-01f,
  5.70562959e-01f, 6.94856465e-01f, 2.25116774e-01f, 7.23895967e-01f, -2.22953200e-01f, -5.72408140e-01f, -7.24143445e-01f, -7.62152374e-01f, 5.92768073e-01f, -8.44173968e-01f,
  7.05596358e-02f, -4.63186838e-02f, -7.12155819e-01f, -3.22075695e-01f, -1.30794394e+00f, -6.20854616e-01f, -2.69771039e-01f, -8.43514681e-01f, 8.39941800e-02f, 3.08883816e-01f,
  4.80112165e-01f, -6.63922071e-01f, -4.56438720e-01f, 6.11570120e-01f, -3.74256641e-01f, 2.53044933e-01f, 1.05251305e-01f, -6.42867923e-01f, -2.90651917e-01f, -3.40619624e-01f,
  2.25946859e-01f, -1.67831466e-01f, 6.12330854e-01f, 6.89203680e-01f, -1.09203732e+00f, 1.30839078e-02f, -4.13929433e-01f, -9.06251490e-01f, 6.84346974e-01f, 1.38043597e-01f,
  1.91071212e-01f, 5.22348464e-01f, -2.52593875e-01f, -5.22211552e-01f, 1.08115427e-01f, -1.18518281e+00f, 5.78377008e-01f, -2.15385169e-01f, -6.58601597e-02f, 9.98218507e-02f,
  4.04334605e-01f, 1.35665119e-01f, 2.45650530e-01f, 6.55695915e-01f, -2.81343460e-01f, 1.26916021e-01f, -9.19826850e-02f, 3.77132207e-01f, -7.17313290e-01f, -7.19346762e-01f,
  5.67204505e-02f, 3.86613816e-01f, 3.57945651e-01f, 7.78057218e-01f, -7.40671396e-01f, -5.95633388e-01f, -4.51393872e-01f, -6.49572194e-01f, -1.00531197e+00f, 6.11431658e-01f,
  -4.83830273e-01f, 4.51381564e-01f, -9.02268171e-01f, -2.47765645e-01f, 4.63243365e-01f, 5.97099125e-01f, 7.56792307e-01f, -4.49106067e-01f, -6.34501100e-01f, -4.55915391e-01f,
  -1.10306406e+00f, 5.27631283e-01f, -9.41582248e-02f, 6.54500961e-01f, -4.50864464e-01f, -7.02279866e-01f, 1.30363420e-01f, 5.60371459e-01f, -4.05083776e-01f, 9.75688323e-02f,
  -6.04427308e-02f, -5.50257027e-01f, -7.24324763e-01f, -1.18921733e+00f, -5.25295913e-01f, -3.05786222e-01f, -5.18814802e-01f, -1.75903082e-01f, -2.40019590e-01f, 3.17448407e-01f,
  -8.19116890e-01f, 7.39995003e-01f, -2.06135020e-01f, 8.15288365e-01f, 1.64239883e-01f, -7.98103929e-01f, -9.97628093e-01f, 8.86781514e-02f, -4.87562418e-01f, 9.14144039e-01f,
  -5.08262455e-01f, 3.12171370e-01f, 1.53628379e-01f, -6.03462279e-01f, -4.18435335e-01f, -1.74134582e-01f, -5.11811152e-02f, -3.48017424e-01f, 5.36611497e-01f, 3.41897637e-01f,
  7.43878260e-02f, -4.65348482e-01f, 1.45016804e-01f, -3.23461056e-01f, 2.57010013e-01f, -5.56208193e-01f, -2.61063635e-01f, 2.29047090e-01f, 2.42673859e-01f, -7.15076864e-01f,
  -8.70451033e-01f, 4.73920941e-01f, 2.67420292e-01f, 5.83551824e-01f, -3.81569594e-01f, -6.57132268e-01f, 1.13600738e-01f, 5.67896068e-01f, 6.70362115e-01f, -3.95397812e-01f,
  -3.46720994e-01f, -5.16080081e-01f, -2.75953978e-01f, -1.75373834e-02f, -7.33457863e-01f, -7.18916118e-01f, -1.68005481e-01f, -1.98052421e-01f, -4.30500239e-01f, -5.71839750e-01f,
  -5.16561151e-01f, -4.32835639e-01f, 3.43277097e-01f, -5.07629097e-01f, 6.29294097e-01f, 4.62065965e-01f, -5.87689281e-01f, 5.78867137e-01f, -5.59779882e-01f, -4.89881396e-01f,
  -3.98176879e-01f, -3.25829089e-01f, 1.65789545e-01f, -3.52308482e-01f, 3.15109700e-01f, 3.20677400e-01f, -2.65878141e-01f, -5.92970073e-01f, -8.39724064e-01f, -4.29741442e-01f,
  -2.79282838e-01f, 5.87220907e-01f, -2.76263714e-01f, -7.42141306e-01f, 3.26154530e-01f, -5.27393222e-01f, -4.42948848e-01f, -3.36201847e-01f, -4.24942710e-02f, -5.11979938e-01f,
  3.27215463e-01f, -3.42653185e-01f, 7.05973804e-01f, 1.20318951e-02f, -6.77688420e-01f, 2.66112000e-01f, -9.55091774e-01f, -4.05636311e-01f, 7.71631747e-02f, 8.00390482e-01f,
  -6.44906461e-01f, -1.65908903e-01f, -9.02411163e-01f, -6.57416284e-01f, -1.23739116e-01f, -7.51257837e-01f, -3.95931661e-01f, 1.45520762e-01f, 7.86438882e-01f, 2.47490704e-02f,
  -8.32757175e-01f, 9.02963400e-01f, -2.07013488e-01f, -3.37040097e-01f, -3.21548015e-01f, 3.80433388e-02f, -5.70426762e-01f, -8.16530883e-01f, 7.55752981e-01f, -4.40193981e-01f,
  -1.71658203e-01f, 2.91000366e-01f, 5.33682942e-01f, 5.55123746e-01f, 4.66211945e-01f, -1.69379011e-01f, -6.73837960e-01f, -9.11669850e-01f, -5.27900040e-01f, 7.23220587e-01f,
  -6.22976482e-01f, -6.24134064e-01f, -7.24964380e-01f, -9.91146490e-02f, 3.18629146e-01f, -8.70023131e-01f, 5.68815410e-01f, 8.34343806e-02f, -4.13240761e-01f, -3.47643256e-01f,
  -5.60830534e-01f, -5.69105983e-01f, 5.42731225e-01f, -3.01802576e-01f, -1.91301718e-01f, -7.80349731e-01f, 4.65267926e-01f, -1.85628384e-01f, 8.34763348e-01f, -7.76557699e-02f,
  -4.89423156e-01f, -1.97661504e-01f, 1.85981527e-01f, 1.87393576e-01f, 2.30251908e-01f, 3.08272272e-01f, -4.72172230e-01f, -5.21430254e-01f, -5.53190112e-01f, 6.30833149e-01f,
  7.26490974e-01f, -5.98178208e-01f, -1.36511043e-01f, -1.87948555e-01f, -5.42611241e-01f, -4.20456916e-01f, -3.44589472e-01f, 2.06475914e-01f, 8.35524619e-01f, -7.89596081e-01f,
  -5.22632360e-01f, -6.84789419e-01f, 2.60768533e-01f, 6.92046702e-01f, -6.68799698e-01f, -5.99998891e-01f, 5.44617772e-01f, -4.47396278e-01f, -4.15498644e-01f, -7.24586129e-01f,
  -6.74855888e-01f, -1.49627656e-01f, -5.24277389e-01f, -5.97244680e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.78997681e-01f, -1.88497454e-01f, -2.50612557e-01f, -9.41553563e-02f, -2.58667134e-02f, 1.01059906e-01f, 1.75880104e-01f, -7.98589736e-02f, -1.38513580e-01f, 7.96453133e-02f,
  2.98345745e-01f, 1.02187954e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    