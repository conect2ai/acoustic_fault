/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.82449025e-01f, 2.39354014e-01f, -8.58832002e-02f, 3.73191983e-01f, 2.11399242e-01f, -1.29500434e-01f, 7.17176273e-02f, 1.99202105e-01f, 2.70182014e-01f, -1.69673171e-02f,
  2.14230955e-01f, 2.39988398e-02f, 4.50197607e-02f, -4.26293463e-02f, -1.68388247e-01f, -2.13565424e-01f, -9.96237248e-02f, 4.53743488e-02f, 1.44703230e-02f, 2.44477570e-01f,
  2.76144240e-02f, 2.25168318e-01f, -2.56195337e-01f, -5.41305132e-02f, 1.59895763e-01f, 2.11220440e-02f, -9.39527750e-02f, -7.16110319e-02f, -1.64324418e-01f, -1.66260358e-02f,
  5.38414903e-02f, 2.67038941e-01f, -7.75334146e-03f, -1.01716980e-01f, -4.10894351e-03f, -1.49080992e-01f, -5.64831831e-02f, -8.62687007e-02f, -5.11141829e-02f, -2.21236553e-02f,
  -3.92739400e-02f, 4.10680398e-02f, 4.68239598e-02f, 6.57198578e-03f, -1.33146802e-02f, -1.29488120e-02f, -9.87546891e-02f, -3.42427157e-02f, 8.26422311e-03f, -7.19735995e-02f,
  -6.12568296e-03f, 9.97987390e-03f, -1.03494421e-01f, -9.58765745e-02f, 3.56389992e-02f, 1.98824033e-02f, -1.44398466e-01f, -8.06786045e-02f, -9.34233293e-02f, -1.65322144e-03f,
  -2.95486674e-03f, 9.52206254e-02f, 9.50396643e-04f, 2.48077922e-02f, 1.02407753e-01f, 5.63702313e-03f, -2.88157016e-02f, -1.05405591e-01f, -4.09047678e-03f, -6.35378296e-03f,
  5.06786369e-02f, 1.18645318e-02f, 3.41540799e-02f, -7.59387389e-02f, 2.56843679e-02f, 3.07221096e-02f, -8.47282037e-02f, 3.50366980e-02f, 7.10653514e-02f, -2.98001766e-02f,
  7.28320181e-02f, -2.77651455e-02f, 3.79729108e-03f, -9.32442490e-03f, -1.43200718e-02f, 5.26006483e-02f, 3.81764583e-03f, -9.95497871e-03f, -4.98581417e-02f, 1.67849138e-02f,
  8.63455608e-02f, 1.71386451e-01f, 6.64115921e-02f, 4.29329351e-02f, -3.39417160e-02f, -4.23519574e-02f, -5.53347617e-02f, 1.82940681e-02f, -1.05794081e-02f, -2.36582644e-02f,
  3.74337509e-02f, -1.26049304e-02f, -2.54784729e-02f, -5.20254020e-03f, -8.13491568e-02f, 1.26965502e-02f, 3.53428163e-02f, 3.82759869e-02f, -4.18437608e-02f, 1.54716391e-02f,
  2.00567152e-02f, 9.01924632e-03f, -1.02928862e-01f, 5.72308339e-02f, -2.65681613e-02f, -1.42526319e-02f, 8.40093717e-02f, -8.19279067e-03f, -3.81992050e-02f, -3.08273807e-02f,
  4.70550150e-01f, 2.79870033e-01f, 5.58081307e-02f, 2.86832780e-01f, 1.85929120e-01f, -1.85808629e-01f, 1.23787463e-01f, 1.97801426e-01f, 1.96020871e-01f, -1.07916735e-01f,
  2.08497986e-01f, 8.40901509e-02f, 1.20530277e-01f, 2.73754209e-01f, 9.34832469e-02f, -9.25920606e-02f, 5.79293035e-02f, 1.98507663e-02f, 6.96986467e-02f, 1.68762445e-01f,
  8.86060223e-02f, 1.43851280e-01f, 8.30305889e-02f, 7.36532882e-02f, 2.07166106e-01f, -1.87367108e-02f, -6.36170134e-02f, -1.28612936e-01f, -3.71101759e-02f, -8.86564404e-02f,
  1.08372547e-01f, 2.03561082e-01f, 1.15528509e-01f, 4.87882756e-02f, 7.88212791e-02f, -9.66322422e-02f, -6.94669224e-03f, 2.27636043e-02f, -5.52724041e-02f, 1.81375053e-02f,
  5.78105301e-02f, 1.02644145e-01f, -1.75487455e-02f, -7.91355222e-02f, 5.50175272e-02f, 5.96014829e-03f, 5.64869903e-02f, 6.82359040e-02f, 8.43663290e-02f, 1.50202150e-02f,
  5.65126650e-02f, 9.65182781e-02f, -6.68767914e-02f, 1.58005413e-02f, 6.00016639e-02f, -1.32155209e-03f, -8.55545253e-02f, -2.10066307e-02f, 1.37323858e-02f, 8.55399203e-03f,
  -1.63264889e-02f, -7.28922859e-02f, 3.09318304e-02f, 2.46741134e-03f, 4.97257076e-02f, 1.79593991e-02f, -6.70127869e-02f, 9.61221289e-03f, -3.19714323e-02f, 2.62248050e-02f,
  3.99007797e-02f, 1.10732943e-01f, 2.16973256e-02f, -2.37957556e-02f, -1.89868566e-02f, 1.98129304e-02f, 1.71596427e-02f, 2.01996509e-02f, -2.77127661e-02f, -6.66895807e-02f,
  -1.01267230e-02f, -4.48435545e-03f, 1.27465904e-01f, -3.11143510e-02f, -2.40751021e-02f, 2.61609256e-02f, 5.09498343e-02f, 6.00095391e-02f, -1.24375215e-02f, 4.87068901e-03f,
  8.31392631e-02f, -7.38138035e-02f, 6.49068952e-02f, 5.71682528e-02f, -6.54809549e-02f, -1.42325619e-02f, -1.48893688e-02f, 5.37183844e-02f, 3.70591246e-02f, 5.97591326e-02f,
  -2.12191623e-02f, -2.38860976e-02f, -1.17990926e-01f, 1.28927417e-02f, -2.12180279e-02f, 4.48492803e-02f, -3.97218205e-03f, 2.84342580e-02f, 3.71901020e-02f, -3.16314995e-02f,
  1.30796880e-01f, -4.44341972e-02f, -3.73146459e-02f, -1.14960289e-02f, 5.44941926e-04f, -6.14847727e-02f, 6.03274396e-03f, -8.31263587e-02f, -1.04624322e-02f, -8.36403593e-02f,
  5.32695651e-01f, -1.65910944e-01f, 1.91822410e-01f, -4.64937612e-02f, 3.41673046e-02f, 2.19650626e-01f, 7.23635182e-02f, -1.37514099e-01f, 2.75603775e-02f, -2.72028387e-01f,
  -2.03111276e-01f, 3.22392255e-01f, -8.23504776e-02f, -1.43114120e-01f, 3.39765757e-01f, -3.57052274e-02f, -1.40369073e-01f, -9.45116207e-02f, 3.87961566e-02f, -2.82703396e-02f,
  2.30428856e-02f, -2.72424281e-01f, 7.02037290e-02f, -3.01828861e-01f, 5.93326055e-03f, 8.20751116e-02f, -3.26687068e-01f, 8.07180777e-02f, -1.66641146e-01f, 5.52578196e-02f,
  -2.87368875e-02f, -1.17743932e-01f, 2.68465448e-02f, 1.18677199e-01f, 6.26434907e-02f, -1.93324406e-04f, 2.56241369e-03f, 4.12544943e-02f, 5.87271824e-02f, 3.45221534e-02f,
  1.19952135e-01f, -1.53781846e-02f, 3.47753204e-02f, 2.69057453e-02f, 3.56291458e-02f, 1.46232415e-02f, 6.33700490e-02f, 4.52787541e-02f, -6.73644394e-02f, 1.27706796e-01f,
  8.89499858e-02f, 3.61449569e-02f, -2.80138180e-02f, 1.62138678e-02f, 3.25707123e-02f, -8.83374829e-03f, 3.23976651e-02f, 7.80872703e-02f, 3.54219340e-02f, 3.82889770e-02f,
  6.18448015e-03f, 3.09991464e-02f, -5.25070280e-02f, 1.69510935e-02f, -5.50483465e-02f, -2.63338145e-02f, 7.11508235e-03f, -7.55977854e-02f, 1.14119798e-01f, -5.91873452e-02f,
  2.98200399e-02f, 1.99201237e-02f, -5.73118776e-02f, -1.55796567e-02f, -7.85670336e-03f, 5.00897923e-03f, 9.84732807e-02f, -2.75483876e-02f, -3.01538240e-02f, 5.60064241e-02f,
  7.94458296e-03f, -2.82074232e-02f, -3.25765237e-02f, -4.84238230e-02f, -1.45019323e-03f, 7.12595275e-03f, -1.72762021e-01f, -9.96679068e-03f, -6.38803989e-02f, 4.78371158e-02f,
  -7.37204775e-02f, -1.42086923e-01f, -4.18713391e-02f, -1.03208823e-02f, -2.62618382e-02f, 3.39857265e-02f, 6.25860244e-02f, 8.95030214e-04f, -1.96112655e-02f, -3.01034730e-02f,
  -3.55843455e-02f, 4.36402969e-02f, -2.89767068e-02f, 3.14722843e-02f, -5.89427762e-02f, -4.04717475e-02f, -8.19953829e-02f, 1.08999480e-02f, 1.09671224e-02f, -3.71026322e-02f,
  -8.14984590e-02f, 1.61458813e-02f, 6.44889995e-02f, -7.99938366e-02f, -1.22032195e-01f, 1.09373815e-02f, -2.01532412e-02f, -6.15150481e-03f, -7.13117868e-02f, -1.41190942e-02f,
  -3.81518245e-01f, -1.68261275e-01f, 1.22357510e-01f, -1.30856335e-01f, -3.39014828e-02f, -2.46223822e-01f, -9.65734720e-02f, -1.91863775e-01f, -2.97433853e-01f, -2.48691052e-01f,
  -2.19253093e-01f, 1.16126858e-01f, -4.11390923e-02f, -7.21787522e-03f, 2.66503632e-01f, 1.93560541e-01f, 4.44865553e-03f, -3.77171189e-02f, 1.53541446e-01f, -5.92928044e-02f,
  1.51105016e-01f, 1.14729807e-01f, 1.98883370e-01f, 1.44482389e-01f, -1.84856713e-01f, 1.82658453e-02f, 1.49430186e-01f, 1.84057862e-01f, 8.23625401e-02f, 1.60230741e-01f,
  -9.18368027e-02f, -2.76113689e-01f, 2.40721460e-03f, 7.13633373e-02f, -1.00094549e-01f, -3.97508079e-03f, -3.28594609e-03f, 3.76501977e-02f, 3.92796807e-02f, 1.91247035e-02f,
  -5.62676648e-03f, -9.46827233e-03f, 6.68620244e-02f, 1.55161351e-01f, -1.36958241e-01f, -9.67190862e-02f, -9.17932913e-02f, -3.52691747e-02f, -1.94760524e-02f, -5.89054599e-02f,
  -2.62973756e-02f, -1.12574287e-01f, -3.39902341e-02f, 3.58710028e-02f, 5.62393330e-02f, -1.17912509e-01f, 1.28115028e-01f, 4.06533070e-02f, -1.03042692e-01f, -6.59937114e-02f,
  -8.75651687e-02f, 4.80001830e-02f, 2.10419856e-02f, -4.07545827e-02f, 2.18379893e-03f, -2.77297497e-02f, 8.28712806e-02f, 9.50432643e-02f, 7.57949725e-02f, -7.06474110e-02f,
  -3.33190002e-02f, -6.86219931e-02f, -5.09194732e-02f, 1.75998561e-04f, 4.66329269e-02f, -5.96602000e-02f, 9.45652947e-02f, 2.65691318e-02f, 2.39945278e-02f, 3.54125584e-03f,
  -5.19940816e-02f, -2.73074452e-02f, -2.05349717e-02f, 3.60484868e-02f, 1.38302916e-03f, 5.23086637e-02f, 2.70243804e-03f, -2.48208903e-02f, -3.15419696e-02f, 6.82345703e-02f,
  -1.25522092e-01f, 6.08877093e-03f, 2.82285791e-02f, -5.60867637e-02f, 4.92047556e-02f, -4.21802327e-03f, 1.03894651e-01f, -6.89927349e-03f, 1.73552632e-02f, -8.03736970e-02f,
  9.37530026e-03f, 4.12771143e-02f, 1.49182463e-02f, -2.92792004e-02f, 1.67388797e-01f, -4.98192571e-02f, -2.64470559e-02f, 2.68896427e-02f, -4.24515381e-02f, 1.98493935e-02f,
  -1.04756705e-01f, -1.45086609e-02f, 1.39013782e-01f, -2.53921784e-02f, 1.26965381e-02f, 2.52961693e-03f, -1.03825552e-03f, -4.15501371e-02f, 1.78375751e-01f, 2.99062319e-02f,
  3.93059105e-01f, -1.37754772e-02f, -1.30807355e-01f, 4.39836085e-02f, 1.26004696e-01f, -1.73977420e-01f, -1.70449361e-01f, 1.98985949e-01f, 1.91209510e-01f, -7.61755323e-03f,
  1.08784929e-01f, -2.15733483e-01f, 1.35022268e-01f, -1.69386715e-01f, -1.09943904e-01f, -4.79863733e-02f, -1.04444183e-01f, -2.13597491e-01f, 1.29764989e-01f, 2.14521766e-01f,
  1.10812776e-01f, 4.08502519e-02f, -6.53810725e-02f, 1.67925417e-01f, 6.80718347e-02f, 1.46070436e-01f, 2.55121797e-01f, 6.11250810e-02f, -1.86454669e-01f, -8.91495124e-02f,
  -1.24551058e-01f, 1.00035809e-01f, -2.74039190e-02f, 2.67826050e-04f, 4.72154468e-02f, -3.97160426e-02f, -6.69765100e-02f, -2.22449526e-02f, -3.09253391e-02f, -8.91043544e-02f,
  -7.39671290e-02f, -5.33267185e-02f, -6.29064813e-02f, 4.45242925e-03f, -9.45158303e-02f, -5.80126643e-02f, -6.86170161e-02f, 5.69549638e-06f, -9.44610462e-02f, -5.43357246e-02f,
  6.42015692e-03f, -9.78849605e-02f, -3.26304906e-03f, -7.78543651e-02f, 2.41557099e-02f, 6.56574825e-03f, -1.01361707e-01f, -3.44020091e-02f, -8.62175301e-02f, 7.49451369e-02f,
  7.25717396e-02f, 4.93198745e-02f, 5.26442043e-02f, 4.29961681e-02f, -1.68963429e-02f, 5.75072169e-02f, -9.40103233e-02f, -1.07701644e-01f, 1.39413357e-01f, -5.11695980e-04f,
  -3.60248089e-02f, 3.93519402e-02f, 1.14344172e-01f, -1.70273334e-02f, 8.38338211e-02f, 4.99251485e-03f, -1.08074591e-01f, 9.96846631e-02f, 4.86592092e-02f, 1.79633647e-02f,
  -1.74879245e-02f, 4.74895537e-02f, 1.15141990e-02f, -1.72624681e-02f, -8.02446827e-02f, 2.76510846e-02f, -2.26719938e-02f, -2.37895045e-02f, 3.83985601e-02f, -2.54437719e-02f,
  3.92477289e-02f, 1.64200395e-01f, 3.30138095e-02f, -1.02306120e-01f, -3.61008309e-02f, -4.42970684e-03f, 4.74134870e-02f, -6.17126562e-02f, -8.90447646e-02f, 6.17828704e-02f,
  3.21189314e-02f, 3.88778448e-02f, 9.80309024e-03f, 3.43349278e-02f, -5.73415533e-02f, 1.13546573e-01f, -4.04540747e-02f, 5.04440516e-02f, 1.24605428e-02f, 7.80073404e-02f,
  4.36165482e-02f, -3.16449441e-02f, -3.79485004e-02f, 6.87280148e-02f, -8.99231061e-02f, -6.74487129e-02f, 6.60379231e-02f, 2.07187552e-02f, -2.22716052e-02f, -1.46617755e-01f,
  -1.27217799e-01f, 3.01902443e-01f, 1.18774645e-01f, -1.13243386e-01f, 1.06761344e-02f, -3.66366386e-01f, -3.70254010e-01f, 1.47713989e-01f, 2.34400660e-01f, -1.70840602e-02f,
  -1.22529633e-01f, 2.20751852e-01f, 2.24801987e-01f, -3.38161826e-01f, -7.63462782e-02f, 2.33073860e-01f, -3.01107228e-01f, -1.86561599e-01f, 1.67856321e-01f, 4.85272221e-02f,
  4.93001528e-02f, -1.84247553e-01f, 3.53757106e-02f, 1.00958079e-01f, -8.44757482e-02f, 6.16958104e-02f, 1.56850852e-02f, 1.93999276e-01f, -2.27184057e-01f, -1.51116699e-01f,
  -6.03338405e-02f, 1.10914588e-01f, 3.84047329e-02f, 1.64990518e-02f, -1.17285676e-01f, -9.40998197e-02f, -7.85637870e-02f, 5.12389094e-02f, 8.70860368e-02f, 4.10685092e-02f,
  -1.28163220e-02f, -3.43583226e-02f, 1.41734323e-02f, 1.23644084e-01f, -9.15163159e-02f, 9.63150933e-02f, 4.27008010e-02f, -1.23661742e-01f, 9.48406309e-02f, 3.18563692e-02f,
  5.64968474e-02f, -1.40843699e-02f, -9.41831619e-02f, -3.13553140e-02f, 6.01420831e-03f, 1.88717451e-02f, -6.46463335e-02f, -8.07104399e-04f, -4.93871495e-02f, 8.62780865e-03f,
  -5.36517836e-02f, 3.45649347e-02f, -2.87896618e-02f, 9.63566899e-02f, 4.33379039e-02f, -2.76534539e-03f, -1.34407552e-02f, 3.23589891e-02f, -4.31114854e-03f, 7.69898221e-02f,
  -9.34796855e-02f, -2.74862256e-02f, -1.95716470e-02f, -4.14720960e-02f, -5.70461266e-02f, -1.90220997e-02f, -2.58132853e-02f, -3.87590006e-02f, -3.78781110e-02f, -1.36670629e-02f,
  9.42115262e-02f, -1.05025426e-01f, 1.32217810e-01f, -9.20098647e-02f, 6.13720007e-02f, 4.57169898e-02f, -2.50757150e-02f, -4.44852840e-03f, 1.80094745e-02f, -6.08827621e-02f,
  -1.56203926e-01f, 1.38012975e-01f, 8.87754336e-02f, -8.52378905e-02f, 1.11965440e-01f, 8.56968760e-02f, 2.83195022e-02f, 2.65087970e-02f, -6.37850212e-03f, -3.63879837e-02f,
  -1.09131314e-01f, -4.50537242e-02f, -4.98114228e-02f, -3.05999033e-02f, 7.40482751e-03f, 7.20562041e-03f, -9.63694006e-02f, 1.79313757e-02f, -1.11368053e-01f, -2.60455217e-02f,
  -3.29538770e-02f, -2.03399453e-02f, 3.67588475e-02f, 3.33907567e-02f, -1.15915753e-01f, -3.08118481e-02f, 4.03142236e-02f, 2.65485067e-02f, -6.58198968e-02f, 5.88789769e-02f,
  1.98989481e-01f, -2.71324784e-01f, -4.11141664e-01f, 1.61114424e-01f, -2.69104280e-02f, 3.36125121e-03f, 1.88341081e-01f, -1.12994976e-01f, 8.64380077e-02f, 8.45358148e-02f,
  3.27779472e-01f, -1.43802449e-01f, 3.32001559e-02f, 2.00094610e-01f, 2.02154145e-01f, 2.73579210e-01f, 2.43708223e-01f, 2.08369747e-01f, -2.28379131e-03f, -6.73863366e-02f,
  -1.12153990e-02f, 2.51506627e-01f, -2.13544101e-01f, -2.49004394e-01f, -2.18262598e-01f, -2.22997636e-01f, 1.97735712e-01f, -2.26546943e-01f, -3.12712267e-02f, -4.87265270e-03f,
  -6.65676780e-03f, -7.58130103e-04f, -8.34019333e-02f, -6.91540763e-02f, 6.13831021e-02f, 8.18576664e-02f, 1.25473626e-02f, 3.03399451e-02f, 4.70829681e-02f, -1.47555033e-02f,
  -9.16385651e-03f, -5.97007945e-02f, -1.13585452e-02f, 6.44404143e-02f, -1.02887955e-02f, -8.56735855e-02f, -6.72266185e-02f, -9.98303667e-02f, -8.19843262e-03f, -8.47313926e-02f,
  4.90561724e-02f, -9.91390496e-02f, 8.25143140e-03f, 6.03555962e-02f, -8.58525187e-02f, -2.55014952e-02f, -3.68716195e-02f, -9.82999727e-02f, 6.48836270e-02f, 1.97735261e-02f,
  8.73324797e-02f, -6.14035353e-02f, -1.00087464e-01f, -1.08215604e-02f, 2.56174915e-02f, -2.43271813e-02f, 2.01798175e-02f, 1.98153220e-02f, -9.93582159e-02f, 3.62014547e-02f,
  6.15163445e-02f, -4.28246632e-02f, 9.38729011e-03f, -1.50989648e-02f, 3.17308269e-02f, -2.49510407e-02f, -5.20479120e-02f, 1.68343466e-02f, -2.08344012e-02f, -6.52448414e-03f,
  -7.68120680e-03f, 1.24828629e-02f, 8.21488257e-03f, -5.97263174e-03f, 3.91829275e-02f, -2.53843050e-02f, -6.46312237e-02f, -7.38433748e-02f, -4.53999378e-02f, 3.42364516e-03f,
  1.85703456e-01f, 5.47649972e-02f, -2.96032410e-02f, -3.56592685e-02f, 3.35278399e-02f, 4.25245129e-02f, 1.97698027e-04f, -1.40617356e-01f, 6.00818358e-02f, 5.13531603e-02f,
  -5.14520034e-02f, 1.90396961e-02f, -4.18107882e-02f, -8.54654144e-03f, -2.31984034e-02f, -9.21483431e-03f, 2.99180616e-02f, 6.29312620e-02f, -3.58709767e-02f, 5.59918173e-02f,
  -5.61697371e-02f, 4.31854501e-02f, -1.52805401e-02f, -5.19655384e-02f, 6.88643456e-02f, 4.49629165e-02f, 4.73565832e-02f, 8.64479411e-03f, 2.69139875e-02f, 4.10277210e-02f,
  -1.90168604e-01f, -4.92993891e-02f, -9.91426557e-02f, 1.62480474e-01f, 3.40044945e-01f, 1.46930069e-01f, -8.22941139e-02f, 3.22493047e-01f, 2.68247545e-01f, -1.18691660e-01f,
  2.64336318e-01f, -2.80342877e-01f, -1.19339123e-01f, 2.66151905e-01f, -2.76020244e-02f, 1.08368993e-02f, 2.70097673e-01f, 7.09004179e-02f, 5.99044263e-02f, 7.93626532e-02f,
  1.63473845e-01f, 2.57307798e-01f, -1.81954741e-01f, 2.13821486e-01f, 7.30051100e-02f, 2.04049819e-03f, -9.01565924e-02f, -2.08886221e-01f, 1.07755683e-01f, -4.36802879e-02f,
  -9.05872360e-02f, 9.45177078e-02f, -9.79480371e-02f, 4.24065441e-03f, -3.36873680e-02f, -2.17553191e-02f, -1.28625974e-01f, -1.40446201e-01f, -1.03589818e-01f, 1.03635840e-01f,
  -9.71666202e-02f, 9.54821333e-02f, 5.63688129e-02f, -1.24007603e-02f, -4.90846578e-03f, -3.45130004e-02f, 6.49268627e-02f, 8.36534128e-02f, 1.05959363e-01f, -1.10287748e-01f,
  3.96047719e-02f, -3.31973913e-03f, 9.97258797e-02f, 1.05273761e-01f, 3.01325675e-02f, 6.74835593e-02f, -1.38312140e-02f, -1.07052900e-01f, 4.01117392e-02f, 6.44801259e-02f,
  -7.61848092e-02f, -5.30159809e-02f, -4.27435338e-02f, 1.11392019e-02f, 4.47507724e-02f, 6.72773346e-02f, 1.00719146e-02f, -3.27174878e-03f, -6.72104433e-02f, -2.35895030e-02f,
  1.32064253e-01f, -7.41116628e-02f, 8.69002566e-02f, 3.86168878e-03f, -6.99637607e-02f, 1.92599073e-02f, -8.62454623e-02f, 9.00982842e-02f, 7.66493082e-02f, -1.00104325e-01f,
  -2.84953546e-02f, 6.14405312e-02f, -2.46436279e-02f, -3.98008302e-02f, -1.53308520e-02f, 5.12040108e-02f, 8.03625062e-02f, 2.29007099e-02f, -1.12883709e-02f, -4.46638167e-02f,
  -2.39122454e-02f, 1.79776520e-01f, 1.26147773e-02f, 4.26751748e-02f, -8.12275931e-02f, 4.34839725e-02f, -1.50092551e-02f, 1.38368949e-01f, -1.67243909e-02f, 8.37586150e-02f,
  4.31903414e-02f, 4.59684506e-02f, 5.03701866e-02f, 1.52063109e-02f, -5.22556119e-02f, 1.49214372e-01f, -5.79344146e-02f, 7.00079929e-03f, -6.51121512e-03f, 4.82857972e-02f,
  -5.26802577e-02f, 5.92458546e-02f, -8.87701139e-02f, 8.25220421e-02f, 3.71408910e-02f, -3.39074507e-02f, 6.49630502e-02f, 1.08369142e-02f, -4.76222187e-02f, -2.45214738e-02f,
  -1.90660551e-01f, 7.31287450e-02f, -1.12973958e-01f, -2.19125509e-01f, 2.53211241e-02f, -1.79575652e-01f, -2.18267769e-01f, 5.11006452e-02f, -2.72974312e-01f, 2.63656527e-01f,
  1.57863751e-01f, -2.64583647e-01f, 2.97945678e-01f, 8.24058503e-02f, 6.00334220e-02f, 3.18704963e-01f, -2.87711918e-02f, -5.14261462e-02f, -7.86283985e-02f, -1.48476377e-01f,
  -2.11301390e-02f, 1.86009765e-01f, 1.65738270e-01f, 5.32585382e-02f, -6.43112659e-02f, -1.76948443e-01f, 2.67526865e-01f, -2.96738632e-02f, -4.27147001e-02f, 2.21523400e-02f,
  -2.87430901e-02f, -4.76910137e-02f, -1.55444264e-01f, -5.02797142e-02f, 1.89094269e-03f, -8.41081701e-03f, -1.32692838e-02f, -1.43690240e-02f, -4.04029153e-02f, -3.04510221e-02f,
  3.77733447e-03f, -3.43897156e-02f, -6.75787330e-02f, -8.61675665e-02f, -7.68701658e-02f, -4.44954671e-02f, -1.67842358e-02f, -1.70085169e-02f, -7.27447271e-02f, 5.39399348e-02f,
  -4.24095653e-02f, 7.13645071e-02f, -2.63401419e-02f, 1.07034994e-03f, 1.48018114e-02f, -6.98027108e-03f, -2.94896923e-02f, 3.44303623e-02f, 9.43941921e-02f, -3.63560095e-02f,
  6.12061173e-02f, 1.23971677e-03f, 6.69792518e-02f, 4.75290194e-02f, -9.79587343e-03f, 6.67062253e-02f, -3.29862721e-02f, 4.09867279e-02f, 1.31921358e-02f, 9.43773687e-02f,
  4.07013483e-02f, 4.45606783e-02f, -2.44895089e-03f, -2.92953495e-02f, 7.07090646e-02f, -1.82920489e-02f, -3.28639373e-02f, 2.12882645e-03f, -1.47620458e-02f, -3.77302989e-02f,
  3.69371064e-02f, -9.41623822e-02f, 2.00988129e-02f, 1.51917497e-02f, -1.73229288e-04f, 8.25025216e-02f, 5.68471057e-03f, -2.05049142e-02f, -2.06365492e-02f, 7.94892982e-02f,
  1.92982048e-01f, 3.29282105e-01f, 6.45878315e-02f, -8.80999416e-02f, 5.96576668e-02f, 1.12303821e-02f, 3.85477208e-02f, 3.32956165e-02f, -2.76490543e-02f, -1.10615790e-02f,
  -5.81736416e-02f, -1.85565352e-02f, 4.66827750e-02f, 3.07515543e-02f, -2.62550078e-03f, 1.00558333e-01f, 3.99700329e-02f, 5.96355312e-02f, 5.52970618e-02f, 1.73515957e-02f,
  4.30771336e-02f, -8.97256285e-03f, 1.22534055e-02f, 4.36538979e-02f, 1.78950187e-02f, 5.12041571e-03f, 2.22229902e-02f, -4.58419807e-02f, 3.22204269e-02f, 2.65007350e-03f,
  -3.51482570e-01f, -1.14885338e-01f, -2.88151294e-01f, -1.78907618e-01f, 9.88545716e-02f, -1.24268666e-01f, -1.92734867e-01f, -1.02407366e-01f, -2.54115134e-01f, 9.23116729e-02f,
  9.00052711e-02f, -1.85851410e-01f, -9.23533365e-02f, -1.36498511e-02f, -2.05890015e-01f, -5.17790765e-03f, -1.51738286e-01f, -1.57540031e-02f, 2.38665733e-02f, -1.11929983e-01f,
  4.91778692e-03f, 1.37524739e-01f, -8.31531808e-02f, 1.81947574e-01f, -1.17225863e-01f, -5.26307523e-03f, 1.53011069e-01f, 3.15407924e-02f, 1.20980039e-01f, 8.16935003e-02f,
  -1.05308861e-01f, -2.87789464e-01f, -1.47570610e-01f, -8.35464224e-02f, -3.13258581e-02f, -2.77465358e-02f, -2.40850449e-02f, 6.69430047e-02f, -2.54256856e-02f, -2.72200182e-02f,
  6.79894090e-02f, 5.57932518e-02f, 6.55061826e-02f, 4.48988900e-02f, -1.51177287e-01f, 2.09995154e-02f, 1.94464438e-03f, 3.17021869e-02f, 1.41582703e-02f, -4.12161574e-02f,
  -1.22324109e-01f, 3.88173163e-02f, 9.41567298e-04f, 4.15889099e-02f, 6.05835253e-03f, 4.87642586e-02f, 1.26579657e-01f, 2.76988801e-02f, -7.08002299e-02f, -9.73887071e-02f,
  4.86035347e-02f, 1.13998115e-01f, -3.89622562e-02f, -5.05530462e-03f, 5.44174761e-03f, 9.26615819e-02f, -2.21951567e-02f, 2.29524691e-02f, -1.28054898e-02f, -4.29870561e-02f,
  4.57581654e-02f, -8.22145939e-02f, 2.19637919e-02f, -7.78662786e-02f, 5.17303199e-02f, -2.45282073e-02f, 6.77175000e-02f, -5.72828501e-02f, 3.36756557e-03f, -5.66516183e-02f,
  -3.85448262e-02f, -5.05183684e-03f, -5.31021319e-03f, 8.14807341e-02f, 3.04355361e-02f, -6.86948821e-02f, -4.16930765e-02f, -5.18086217e-02f, -4.18021949e-03f, 5.00617549e-02f,
  -1.89039394e-01f, -2.27928892e-01f, -5.06591611e-02f, -3.33196633e-02f, 1.18299909e-02f, -8.42752308e-02f, 3.43129747e-02f, -8.69767293e-02f, -9.98363346e-02f, -1.02451734e-01f,
  2.50898413e-02f, 1.62789016e-03f, 4.74602878e-02f, 1.81367081e-02f, 5.95066957e-02f, -3.62368487e-02f, 2.79183723e-02f, 5.64620867e-02f, 7.26009347e-03f, 3.48361284e-02f,
  3.60516435e-03f, -7.75085166e-02f, -8.53581820e-03f, -7.60660172e-02f, 7.06077367e-02f, 1.06764950e-01f, -1.02875195e-01f, 4.26838137e-02f, 6.44783601e-02f, 1.86432153e-02f,
  -1.59761742e-01f, 4.36878204e-01f, 5.90404496e-02f, -1.97929274e-02f, -3.07250291e-01f, -1.11330710e-01f, 2.61833310e-01f, -5.86889535e-02f, 1.58262461e-01f, 3.35469842e-01f,
  -2.22997427e-01f, 2.40485996e-01f, 1.33292926e-02f, -1.97674662e-01f, -3.59489262e-01f, -1.86018161e-02f, -2.36136928e-01f, -2.43472867e-03f, -4.54010069e-02f, -1.85349926e-01f,
  -1.62877962e-01f, -2.87943095e-01f, -2.41552606e-01f, -2.35266745e-01f, -2.33490303e-01f, 2.42528077e-02f, -2.04559118e-01f, 6.35786057e-02f, -6.90648034e-02f, -4.65651192e-02f,
  -1.36368454e-01f, 2.86546964e-02f, 1.03719212e-01f, 7.89224580e-02f, -1.17693536e-01f, 5.09638488e-02f, 9.42674875e-02f, -4.80639836e-04f, -2.72141863e-02f, -3.81728299e-02f,
  1.18416555e-01f, -7.85523281e-02f, -5.15213050e-02f, -6.02409430e-03f, 6.37975261e-02f, 4.49802428e-02f, -3.88297555e-03f, -1.09854199e-01f, 2.05766819e-02f, -1.57013591e-02f,
  1.33327823e-02f, -2.61570793e-02f, 9.54332501e-02f, -4.72848490e-02f, -6.41623437e-02f, 6.41839877e-02f, 6.44581094e-02f, 8.10121745e-02f, 3.06841582e-02f, 3.31540592e-02f,
  -1.65248744e-03f, 1.93785243e-02f, -9.30520669e-02f, -1.23353802e-01f, 1.63066164e-02f, 8.13883357e-03f, -1.39451828e-02f, -1.23836704e-01f, 1.18731029e-01f, -1.42234853e-02f,
  -7.83382356e-02f, 8.53876248e-02f, 2.39498764e-02f, 5.27328663e-02f, 1.28272906e-01f, 3.93977575e-02f, 5.23687787e-02f, 4.74701077e-02f, -7.80396909e-02f, -3.79088782e-02f,
  3.91198769e-02f, 3.82933989e-02f, 1.59623511e-02f, -6.76393434e-02f, 7.61353076e-02f, 1.51325213e-02f, -2.05663014e-02f, 8.91480371e-02f, 1.33282971e-02f, -4.89715301e-02f,
  -9.07233730e-02f, 7.01036155e-02f, 1.51718715e-02f, -1.98378731e-02f, 5.00735976e-02f, -2.02655829e-02f, 1.40819484e-02f, -1.24849983e-01f, 3.71975787e-02f, -6.35311529e-02f,
  -1.16876915e-01f, -6.69230940e-03f, -1.34909078e-02f, -3.58680412e-02f, -8.80701393e-02f, 6.83670044e-02f, 8.71160813e-03f, 2.83056777e-02f, -4.67728861e-02f, -3.10198832e-02f,
  -3.18294503e-02f, -1.17670998e-01f, 4.14628126e-02f, -1.11815259e-01f, -3.25122215e-02f, -4.83313315e-02f, 9.68257338e-02f, 3.03630196e-02f, -1.27113447e-01f, 1.50232568e-01f,
  2.80506194e-01f, 2.71405786e-01f, 3.29790443e-01f, -8.89359266e-02f, -1.38544664e-01f, -3.83643545e-02f, 1.08475372e-01f, 3.10734343e-02f, 3.08227599e-01f, 2.08154976e-01f,
  -3.68367471e-02f, 2.55354017e-01f, 1.71213970e-01f, 1.73658043e-01f, -2.17900649e-01f, 1.52295902e-01f, -2.17328921e-01f, -4.59676757e-02f, -5.53379282e-02f, -2.51206219e-01f,
  -1.83711663e-01f, -2.83996016e-01f, -1.35236412e-01f, -2.68009037e-01f, -3.94545458e-02f, -1.05465628e-01f, -3.17050844e-01f, 2.83502303e-02f, -1.33164600e-01f, 1.75751016e-01f,
  9.71166492e-02f, 9.19559598e-02f, 1.18951529e-01f, 1.62589356e-01f, -1.31136477e-01f, 7.38464296e-02f, -7.98121914e-02f, -3.77691463e-02f, 1.66175235e-02f, 5.09571135e-02f,
  -1.24587503e-03f, 9.06332210e-03f, -1.24629280e-02f, 1.18816815e-01f, 2.88140262e-03f, 5.66718280e-02f, 1.23587390e-02f, 3.03821787e-02f, 6.51771873e-02f, -2.37898137e-02f,
  2.45739203e-02f, -5.51309958e-02f, -2.23713312e-02f, -1.13821253e-01f, -4.65755835e-02f, 4.97801602e-03f, -1.75030511e-02f, -4.87033315e-02f, 1.70129210e-01f, -5.92664443e-02f,
  -3.28792408e-02f, 4.70331833e-02f, -3.85989733e-02f, 1.12938419e-01f, 9.11249146e-02f, 7.40004182e-02f, 7.05261827e-02f, 6.69741184e-02f, 3.00059766e-02f, -5.53925596e-02f,
  -5.53583428e-02f, 4.93395925e-02f, 1.32680848e-01f, -5.69344312e-02f, -8.82483423e-02f, 5.09978160e-02f, 1.46509400e-02f, -6.61947504e-02f, -1.22657500e-01f, -1.29859615e-02f,
  1.06096417e-01f, -9.57971364e-02f, -1.15105994e-01f, -1.99346282e-02f, 8.27034935e-02f, -2.77695507e-02f, -1.00054383e-01f, 9.62569714e-02f, -1.12491190e-01f, -1.82681624e-02f,
  -1.07959464e-01f, -6.88878372e-02f, 2.70086490e-02f, 1.04756532e-02f, 8.40583518e-02f, -6.16915338e-02f, 9.34205130e-02f, 4.03766781e-02f, -8.62102434e-02f, -8.47404450e-03f,
  -1.49332955e-01f, 4.00793143e-02f, 2.81522721e-02f, -2.51947604e-02f, -5.09889200e-02f, -2.38256641e-02f, -1.08798541e-01f, -3.56201492e-02f, -1.10333733e-01f, -1.29793629e-01f,
  -9.84560996e-02f, -1.67058006e-01f, 8.96709040e-02f, -6.85669929e-02f, -1.13557279e-01f, -5.96232787e-02f, -5.50661515e-03f, 3.18124704e-02f, -3.55563574e-02f, -2.53635347e-02f,
  6.43501384e-03f, 2.14333415e-01f, 7.24523365e-02f, 3.61446798e-01f, -3.15372527e-01f, -3.30082327e-01f, 1.27757750e-02f, -4.05489318e-02f, 3.50387037e-01f, 7.01834187e-02f,
  -3.09318565e-02f, 7.54509941e-02f, 1.68880329e-01f, 1.38453543e-01f, -2.07670145e-02f, 2.60003030e-01f, 1.01636216e-01f, 1.07868388e-01f, 1.69961855e-01f, 7.82979727e-02f,
  1.23736300e-01f, 4.53303754e-02f, -3.23306471e-02f, -1.32265091e-01f, -2.15835601e-01f, -6.85888380e-02f, -1.65646926e-01f, -6.29565716e-02f, -2.12780088e-01f, -1.04247667e-01f,
  3.58551033e-02f, 1.73764944e-01f, 7.09941983e-02f, 3.01969913e-03f, -1.61146857e-02f, -1.33597270e-01f, -1.22449890e-01f, -4.47592512e-02f, 5.53453751e-02f, 2.89986050e-03f,
  5.40122502e-02f, -5.57362922e-02f, 5.63269742e-02f, -1.49347540e-02f, 5.27765937e-02f, 6.72994694e-03f, 1.00228628e-02f, -4.39742208e-02f, -2.06686780e-02f, 2.77558491e-02f,
  2.95089744e-02f, -6.58146441e-02f, -6.15029549e-03f, 3.63702178e-02f, 6.81250840e-02f, 2.60519572e-02f, 3.01812403e-02f, -8.65315273e-02f, -1.20729357e-01f, 8.23445246e-02f,
  -1.18338987e-02f, -4.36545573e-02f, 1.47351401e-03f, 1.75201241e-02f, 5.48554696e-02f, -6.65024742e-02f, -2.85172109e-02f, -8.24790522e-02f, -4.82682362e-02f, -1.81760639e-02f,
  -3.05596795e-02f, 9.34106857e-03f, 8.42087250e-03f, -6.23130947e-02f, 4.93424349e-02f, -7.42799183e-03f, -4.66181748e-02f, -3.78679857e-02f, 1.05382167e-01f, -1.85417552e-02f,
  1.69495528e-03f, 3.14479619e-02f, 4.31789048e-02f, -8.52994099e-02f, 4.42977212e-02f, 3.45348530e-02f, 3.75206210e-02f, -3.14231403e-02f, 8.49785209e-02f, -1.07961364e-01f,
  4.50227456e-03f, 1.18211441e-01f, 7.39932135e-02f, 3.71256541e-03f, 3.46094444e-02f, -4.07260321e-02f, 2.41217483e-02f, -4.29108460e-03f, -3.09640244e-02f, 6.81940392e-02f,
  -1.05807126e-01f, 9.34769586e-03f, -7.09737912e-02f, 4.47329208e-02f, -4.78326157e-02f, 1.42924553e-02f, -1.54209975e-02f, -5.50031699e-02f, -1.07000999e-01f, -1.02219179e-01f,
  3.71034979e-03f, -9.56876902e-04f, -1.29461363e-02f, -4.37115580e-02f, -4.31106985e-02f, -6.27859682e-02f, -7.09295869e-02f, 4.70731705e-02f, -7.47579187e-02f, 8.16234108e-03f,
  2.91110516e-01f, -2.70021379e-01f, 1.30141275e-02f, -2.48923287e-01f, 2.26915479e-01f, 4.19593602e-01f, 2.91854888e-01f, -5.52965105e-02f, -2.21728176e-01f, -2.57400542e-01f,
  7.33088329e-02f, -1.98627055e-01f, -4.48588692e-02f, 4.01222222e-02f, 4.99111265e-01f, 9.12430510e-02f, 1.53912693e-01f, 5.21093560e-03f, -3.00725475e-02f, -1.61905348e-01f,
  -1.57189127e-02f, 1.82440728e-01f, 8.84513110e-02f, -4.81417291e-02f, 9.30230021e-02f, -2.08151057e-01f, -1.69203971e-02f, 2.03079265e-03f, 3.50330994e-02f, 1.66917264e-01f,
  3.63365225e-02f, -1.35981560e-01f, -8.03158432e-02f, -2.44821589e-02f, 1.84899978e-02f, 2.28364207e-02f, 7.89386779e-02f, 9.48828682e-02f, -4.01096046e-03f, -3.37122716e-02f,
  -3.79563347e-02f, 9.87047106e-02f, 2.67679188e-02f, 5.65570667e-02f, -3.59999724e-02f, -9.74484757e-02f, -1.66349439e-03f, 6.12207949e-02f, -2.96141952e-02f, 1.47349406e-02f,
  7.48695582e-02f, 2.11764104e-03f, -6.80948654e-03f, -6.22643605e-02f, -3.66845950e-02f, -1.74372755e-02f, 1.34852286e-02f, 4.09989133e-02f, -2.15582401e-02f, -5.86757027e-02f,
  -3.00854445e-02f, -3.56617644e-02f, 2.65524862e-03f, -3.56547460e-02f, 3.31809409e-02f, -5.57561554e-02f, 5.55192269e-02f, 6.32886216e-02f, -7.36469254e-02f, 4.25297990e-02f,
  1.06316358e-02f, -1.06749032e-02f, 2.36532018e-02f, 3.75300720e-02f, 2.68234853e-02f, -7.60655105e-02f, 8.04997087e-02f, -1.03135772e-01f, 1.31753432e-02f, 7.15689808e-02f,
  -6.10937737e-02f, 4.91973758e-03f, -1.98791306e-02f, 1.11660836e-02f, 5.76048717e-02f, 4.61213440e-02f, -5.01275882e-02f, 6.23233756e-03f, -4.01970372e-02f, 1.03563197e-01f,
  -2.24755937e-03f, -1.78587526e-01f, 1.08507015e-02f, -5.58436252e-02f, -4.55614254e-02f, 2.35537030e-02f, -3.93744856e-02f, 1.03729041e-02f, -5.80785573e-02f, 3.29213813e-02f,
  4.89470400e-02f, -2.24639699e-02f, -7.10259750e-02f, -1.31685380e-02f, -4.83872369e-03f, 4.16296124e-02f, -8.00284669e-02f, 6.64534792e-03f, -4.86511663e-02f, 7.76032452e-03f,
  -4.11965093e-03f, -2.62885410e-02f, 1.72761758e-03f, 8.48165434e-03f, 2.44024699e-03f, -3.42410617e-02f, 4.71048020e-02f, -6.42979741e-02f, 4.41232063e-02f, -4.29862179e-02f,
  5.94905503e-02f, 4.81973767e-01f, 1.38549760e-01f, -2.29164585e-01f, -1.71216160e-01f, -1.80916324e-01f, -2.26342201e-01f, 1.92766592e-01f, -2.22085059e-01f, 1.83944941e-01f,
  -2.91329354e-01f, 2.09080964e-01f, 2.98044309e-02f, -1.55053571e-01f, -3.52304190e-01f, -1.88507870e-01f, -1.05265789e-01f, 2.33769417e-03f, 1.22063763e-01f, 8.08487013e-02f,
  -8.35379958e-02f, -1.65537849e-01f, -9.69538763e-02f, 2.44242460e-01f, -2.72389669e-02f, 2.33122900e-01f, 1.50082231e-01f, 1.01837888e-01f, 4.47105430e-02f, -7.17994049e-02f,
  7.13569373e-02f, 1.24132164e-01f, -5.36631681e-02f, 1.02296937e-02f, -3.03640473e-03f, -1.02668591e-02f, 7.80390128e-02f, 2.29490288e-02f, 2.17496008e-02f, 3.21932905e-03f,
  -1.41750611e-02f, 9.40854847e-02f, -6.06999882e-02f, -7.19193146e-02f, 1.08573996e-01f, 5.73388971e-02f, 1.09374858e-02f, -3.56973261e-02f, 4.60193604e-02f, -1.83431879e-02f,
  -2.10468285e-02f, -3.84776480e-02f, -7.77111668e-03f, 4.76565361e-02f, -1.07408753e-02f, 9.47569218e-03f, -5.47499247e-02f, -3.65703031e-02f, 7.71385729e-02f, 4.86789308e-02f,
  4.53906227e-03f, -4.07340191e-02f, -5.34081757e-02f, 5.87307662e-02f, -1.88187195e-03f, 7.56908767e-03f, 1.52882328e-02f, -2.26630885e-02f, 2.49554962e-02f, 7.86411837e-02f,
  -9.33601782e-02f, 2.76866532e-03f, -1.82501972e-02f, -4.27322127e-02f, 6.78103184e-03f, 2.06240937e-02f, -2.22589783e-02f, 4.12557013e-02f, -1.05467461e-01f, 6.13330351e-03f,
  3.21520381e-02f, 2.15675682e-02f, 1.08085545e-02f, -1.16001721e-02f, 1.94752112e-03f, -7.93905109e-02f, 4.32780199e-02f, 2.36166026e-02f, -2.16026790e-02f, -2.73054242e-02f,
  3.04362029e-01f, 2.89090335e-01f, -8.98827836e-02f, 1.10851891e-01f, 9.37612262e-03f, -3.28572653e-02f, -6.18088357e-02f, -2.57460494e-02f, 1.65895998e-01f, 3.34653445e-02f,
  1.26830479e-02f, -2.80994363e-03f, 1.56041365e-02f, -1.16292788e-02f, -4.70960923e-02f, 1.66269075e-02f, -4.43605706e-02f, -2.32449491e-02f, -1.03952661e-02f, 1.07321642e-01f,
  6.68978170e-02f, 5.54060042e-02f, -3.38245519e-02f, -1.30728548e-02f, 2.55445391e-02f, -5.73323183e-02f, 1.60014302e-01f, -3.42580043e-02f, 5.54089397e-02f, 1.97380204e-02f,
  -2.85930634e-01f, 2.14445651e-01f, -2.68499643e-01f, 3.80160771e-02f, -1.21856116e-01f, -3.69061202e-01f, -1.85907662e-01f, 2.27592420e-02f, -3.41294780e-02f, 2.18350261e-01f,
  3.52474481e-01f, -2.27117479e-01f, 2.35128224e-01f, 8.88299644e-02f, -3.49019617e-01f, 8.77258703e-02f, -1.54323772e-01f, -7.61659443e-02f, -1.12464637e-01f, 3.86728309e-02f,
  5.21353222e-02f, 1.62114933e-01f, -6.82194531e-02f, 1.18532084e-01f, -2.05794908e-02f, -5.59256151e-02f, 2.25198030e-01f, -1.28641784e-01f, -1.27252322e-02f, -1.62680805e-01f,
  -8.20940286e-02f, 1.68570027e-01f, -4.72909510e-02f, -1.61744058e-02f, -1.33953579e-02f, -7.54861906e-02f, -4.84277532e-02f, -5.64400591e-02f, -3.42861265e-02f, 2.07953621e-03f,
  -2.95704976e-03f, -1.46743190e-02f, -5.14256731e-02f, -9.59823728e-02f, -2.53303647e-02f, -6.85485899e-02f, -2.88763382e-02f, 2.92470190e-03f, -2.37431545e-02f, -7.74570704e-02f,
  -2.24957336e-03f, -1.11378888e-02f, -1.19543569e-02f, -6.42286055e-03f, -1.22346193e-01f, -9.47099999e-02f, -4.32677269e-02f, -7.97614604e-02f, -3.16011719e-02f, -1.11076578e-01f,
  2.21509743e-03f, 3.30412425e-02f, 4.59917001e-02f, 4.45682146e-02f, 2.53468510e-02f, 1.30396873e-01f, -3.77693959e-02f, 1.07139751e-01f, -4.70960625e-02f, -7.30838906e-03f,
  -2.25966168e-03f, -2.86532566e-03f, -3.69679136e-03f, -4.59858030e-02f, 8.19723159e-02f, 5.44409193e-02f, -5.72692230e-03f, 7.16221556e-02f, -2.29691528e-02f, 3.43038850e-02f,
  -2.76239626e-02f, -4.54871505e-02f, -5.25870966e-03f, -4.67323773e-02f, -5.06777316e-02f, 2.87751444e-02f, 5.71366400e-02f, 2.22939793e-02f, 2.02040747e-02f, -7.66332597e-02f,
  4.13965732e-02f, 2.19273970e-01f, 4.07588519e-02f, -1.73647702e-03f, 2.70623118e-02f, -2.45613959e-02f, 4.69124466e-02f, -4.01300713e-02f, -1.14498861e-01f, -8.18544626e-02f,
  -1.11296987e-02f, 4.45593782e-02f, -6.75131455e-02f, 2.17124932e-02f, -3.80812809e-02f, 9.34988037e-02f, 6.70361891e-03f, 5.36671020e-02f, -8.92191660e-03f, 2.04318743e-02f,
  2.27480587e-02f, -1.77818276e-02f, -3.18252016e-03f, 8.24861079e-02f, 4.64615412e-02f, 8.06191713e-02f, 8.35763523e-04f, -8.81727785e-02f, 2.45991014e-02f, -4.49733771e-02f,
  3.02371621e-01f, 1.73675328e-01f, -2.03593343e-01f, -9.42681357e-02f, 2.63798445e-01f, 3.43949497e-01f, 1.17870167e-01f, 1.21240214e-01f, 7.21931159e-02f, 7.76628405e-03f,
  -3.79237160e-02f, 1.07385971e-01f, -8.94518122e-02f, -1.28885359e-01f, -1.12381317e-01f, -2.62489706e-01f, -8.89044255e-02f, 2.83274818e-02f, -7.62678981e-02f, 1.35181442e-01f,
  -2.48497054e-02f, 1.18190609e-01f, -2.43900180e-01f, 1.92738771e-01f, 1.05575040e-01f, 6.69194944e-03f, -1.93667486e-01f, -9.90448985e-03f, -5.41382171e-02f, 1.83974374e-02f,
  1.31539911e-01f, 8.28623250e-02f, -1.74631719e-02f, -7.49023184e-02f, 4.19026688e-02f, -1.41397700e-01f, -7.48712644e-02f, -1.30886540e-01f, 8.12551379e-03f, 3.17381658e-02f,
  -7.12698977e-03f, 1.50434479e-01f, 5.90480939e-02f, -3.23600485e-03f, 8.20119679e-02f, -5.54790348e-02f, -1.09081287e-02f, -7.90868178e-02f, 6.21180646e-02f, -8.80560875e-02f,
  -3.20332535e-02f, -8.01298022e-02f, -1.10563133e-02f, 2.23908480e-03f, -9.08961594e-02f, 1.05793960e-01f, -4.72302139e-02f, -7.63486326e-02f, 5.25692664e-02f, 6.97458014e-02f,
  -6.57462627e-02f, -6.15913309e-02f, -4.28324740e-04f, -1.24215335e-03f, 5.03413975e-02f, -5.06081283e-02f, -7.67417625e-02f, -1.11735864e-02f, -5.55232838e-02f, 8.61473158e-02f,
  9.55500901e-02f, -1.27011552e-01f, 1.71050746e-02f, -1.01061694e-01f, -1.11920536e-02f, -3.03906924e-03f, -6.75101355e-02f, 4.32645902e-02f, 8.55707154e-02f, -8.15140605e-02f,
  -4.07745205e-02f, 5.70804849e-02f, 8.38029087e-02f, 1.12009719e-02f, 2.42720619e-02f, -8.43209475e-02f, -5.48590869e-02f, 3.51031236e-02f, -9.47104469e-02f, -1.04939304e-02f,
  1.27962157e-01f, 2.16175109e-01f, -9.82153695e-03f, 1.08266897e-01f, 1.93479117e-02f, -1.35726463e-02f, -9.70716476e-02f, -4.10864549e-03f, -2.44074618e-03f, 7.57233845e-03f,
  -3.54183875e-02f, -1.03624128e-01f, 4.19814102e-02f, 1.76417325e-02f, 9.96391661e-03f, 1.09979577e-01f, 1.25404820e-02f, 3.15653645e-02f, -8.70575290e-03f, 8.29373896e-02f,
  6.70059919e-02f, 3.80928554e-02f, 4.53246273e-02f, 7.56735057e-02f, -3.59866060e-02f, 3.90123650e-02f, 1.00423686e-01f, 5.31921685e-02f, -1.78260007e-03f, -4.30678986e-02f,
  -2.66089886e-01f, -1.48668304e-01f, -1.69983864e-01f, -1.17459096e-01f, -1.04442731e-01f, -1.80214152e-01f, -9.76133868e-02f, -1.57201096e-01f, -2.79668242e-01f, -1.01582713e-01f,
  -3.55481450e-03f, 1.09371416e-01f, 3.49676013e-02f, 6.60277009e-02f, -7.87170529e-02f, 7.08204508e-02f, -1.34576678e-01f, -8.66160020e-02f, 8.48437548e-02f, -1.30088180e-01f,
  -6.42130971e-02f, -2.54110117e-02f, -6.78969398e-02f, -4.78768945e-02f, -1.76881239e-01f, -1.19272992e-01f, -1.18875988e-01f, 8.82714167e-02f, 5.12398854e-02f, 2.41128922e-01f,
  -1.10700928e-01f, -3.37813832e-02f, -9.85012576e-02f, 7.08666518e-02f, -1.28123656e-01f, 1.72521006e-02f, -2.68263649e-03f, 1.11531638e-01f, 7.03922212e-02f, 4.83464412e-02f,
  3.65216099e-02f, -4.65749130e-02f, 1.04669482e-01f, 3.45745645e-02f, -3.41221727e-02f, -7.04776570e-02f, 1.66720673e-02f, -3.90482061e-02f, -4.77403775e-02f, -4.12940830e-02f,
  -4.41588126e-02f, 9.34556946e-02f, -7.98889473e-02f, 8.02345350e-02f, 5.57526462e-02f, -5.97319230e-02f, 7.05860183e-02f, 1.01226740e-01f, -1.78689640e-02f, -3.47816646e-02f,
  1.73387099e-02f, -4.96075414e-02f, -8.56105760e-02f, -6.26414502e-03f, 2.26010941e-02f, 1.86414481e-03f, -1.04088873e-01f, 4.90549281e-02f, 3.33272330e-02f, 2.10371939e-03f,
  -3.37641090e-02f, -8.16828907e-02f, 4.47741188e-02f, -8.89256895e-02f, -3.11640445e-02f, -6.41623065e-02f, -2.96126846e-02f, -3.22422199e-02f, -6.17573150e-02f, 7.50546530e-02f,
  -6.75383359e-02f, -1.02377562e-02f, -9.66699608e-03f, 6.41802922e-02f, -3.88453379e-02f, -1.75696879e-03f, -4.96124849e-02f, -5.08828983e-02f, 2.71130539e-02f, -5.21649644e-02f,
  -2.85654426e-01f, -3.35999936e-01f, -1.04357056e-01f, -6.33918568e-02f, -5.00742681e-02f, 8.39608256e-03f, 4.32101600e-02f, -2.49315500e-02f, -1.14392333e-01f, -6.80619255e-02f,
  -1.25305220e-01f, 8.46238062e-02f, -2.21654326e-02f, 6.15587085e-02f, -4.15616333e-02f, -2.34046467e-02f, -3.76319401e-02f, -1.63414273e-02f, -8.03858340e-02f, -3.66576575e-02f,
  -1.48602903e-01f, -4.72720526e-02f, 1.50919827e-02f, -1.07445948e-01f, 3.74949649e-02f, -2.52330676e-02f, -6.18493892e-02f, 1.44067565e-02f, 6.04102155e-03f, -1.52854184e-02f,
  2.20982626e-01f, 4.61892821e-02f, 3.57852668e-01f, 2.40163609e-01f, -1.06077064e-02f, -6.53196499e-02f, -3.43493931e-02f, 5.84386922e-02f, 2.47242197e-01f, -2.93224096e-01f,
  -1.79655716e-01f, 9.30572599e-02f, -1.42834976e-01f, -3.15919131e-01f, -7.86838084e-02f, -8.90631750e-02f, -1.28264189e-01f, -7.10019022e-02f, 2.33682275e-01f, 7.17196688e-02f,
  1.34513646e-01f, -3.40336293e-01f, -3.01604215e-02f, -2.41096944e-01f, -9.32936668e-02f, 1.15535907e-01f, -2.54272193e-01f, -1.21497221e-01f, -3.54426414e-01f, -2.34232113e-01f,
  1.04039414e-02f, 1.55977355e-02f, 5.00244461e-02f, 1.11423135e-02f, 3.74459215e-02f, -3.16548124e-02f, -8.53890553e-02f, -1.57848582e-01f, 8.69470388e-02f, -3.89876892e-03f,
  -4.14892808e-02f, -8.87462720e-02f, -5.20552173e-02f, -2.68277917e-02f, -4.46376763e-02f, 5.84042184e-02f, 7.50421872e-03f, 7.92525709e-02f, 9.53757390e-03f, 5.13755344e-02f,
  1.10584579e-01f, 2.70308200e-02f, 5.74072413e-02f, -3.51386853e-02f, 7.25966245e-02f, 4.75746393e-02f, 1.23161383e-01f, -7.36670494e-02f, -1.57485846e-02f, 9.97915864e-02f,
  -1.91656258e-02f, 1.65912546e-02f, -7.36977905e-02f, 5.83296493e-02f, -8.23719949e-02f, 7.10214227e-02f, -5.38453497e-02f, -8.13792348e-02f, -1.00141764e-02f, -3.83225200e-03f,
  -1.22943567e-02f, -2.02037580e-02f, -8.42154119e-03f, 4.45137508e-02f, -1.52716711e-02f, 7.67693343e-03f, -1.14632398e-02f, -2.46704072e-02f, 6.41735643e-02f, 2.66493447e-02f,
  -3.69825736e-02f, -2.87393704e-02f, 1.15444236e-01f, -3.59879583e-02f, 6.27673566e-02f, 3.72627340e-02f, 2.53526866e-02f, 4.68995757e-02f, 1.04590759e-01f, -1.89019591e-02f,
  -4.11280058e-02f, -1.78823620e-01f, 4.10131589e-02f, 2.22152416e-02f, -2.20950879e-02f, -4.85373549e-02f, 4.09728556e-04f, 1.28158545e-02f, 4.94786166e-02f, -6.88896552e-02f,
  -6.39175847e-02f, 5.34326024e-02f, -3.00762448e-02f, 5.19253090e-02f, 2.79570166e-02f, 1.26639791e-02f, 1.78694762e-02f, 7.25997379e-03f, -4.73933071e-02f, -6.85857534e-02f,
  -1.07304929e-02f, 3.95234972e-02f, 6.34126589e-02f, -5.33012860e-02f, -2.57280171e-02f, 5.84045751e-03f, -3.79251689e-03f, -1.27397366e-02f, -4.40407544e-02f, -2.50420105e-02f,
  -3.13152879e-01f, 2.77829379e-01f, 2.47628883e-01f, -6.35196688e-03f, -1.19715199e-01f, -4.00992334e-01f, -3.34437996e-01f, 1.96019128e-01f, 1.33773163e-01f, 5.77352084e-02f,
  -1.61165431e-01f, -5.85468337e-02f, 1.60996348e-01f, -2.13239551e-01f, -3.26449007e-01f, 1.18757226e-01f, -1.91110566e-01f, -1.27777502e-01f, 1.50157273e-01f, -8.53681117e-02f,
  3.32498588e-02f, -2.51240760e-01f, 1.15690105e-01f, 1.39972553e-01f, -1.63593933e-01f, 2.52216876e-01f, 8.98725539e-02f, 8.39963406e-02f, -8.29588622e-02f, -2.41367713e-01f,
  -7.38738775e-02f, -1.18696820e-02f, 4.76216897e-02f, 5.21319825e-03f, -2.87661962e-02f, -3.13464217e-02f, -1.42900692e-02f, -4.56924364e-02f, -4.24312018e-02f, 3.80991735e-02f,
  -4.14111614e-02f, -6.51972517e-02f, -3.92834917e-02f, 6.94488594e-03f, -7.84608871e-02f, 3.61567736e-02f, 6.05525076e-02f, -6.31984100e-02f, 3.97298820e-02f, -3.78225744e-02f,
  4.77764904e-02f, 8.39007422e-02f, -4.55425195e-02f, 8.25223774e-02f, 5.20020910e-02f, -4.37924974e-02f, -2.25369576e-02f, -4.12575491e-02f, 1.34027479e-02f, -3.07865813e-02f,
  -1.25793651e-01f, 4.18199450e-02f, 9.21016559e-03f, 5.09810150e-02f, -7.15440735e-02f, -4.01501078e-03f, 5.06917723e-02f, -6.42417073e-02f, 9.85022187e-02f, -5.52037880e-02f,
  1.18271429e-02f, -1.06115090e-02f, 5.47727197e-03f, -4.70637679e-02f, -1.96213834e-02f, 6.71005109e-03f, -4.60506119e-02f, -5.92953488e-02f, 2.23354567e-02f, 8.78819227e-02f,
  -1.72069408e-02f, -3.04228235e-02f, 3.61668766e-02f, 1.47346007e-02f, 3.17611098e-02f, 9.07775760e-02f, 6.31137118e-02f, 5.58668971e-02f, 4.68827337e-02f, -6.53864145e-02f,
  -1.08304590e-01f, 1.03736520e-01f, 1.09795079e-01f, -8.98928475e-03f, 3.01596057e-02f, 1.06638921e-02f, -2.60611195e-02f, 2.62838192e-02f, 4.99638915e-02f, -4.42106761e-02f,
  -1.23749990e-02f, 5.42674474e-02f, 4.55991784e-03f, -9.92191769e-03f, -3.80974151e-02f, 3.22976485e-02f, -3.76049988e-02f, 5.05864695e-02f, -2.71675065e-02f, 4.79759686e-02f,
  -5.05999215e-02f, -5.80001622e-02f, -2.95096785e-02f, -3.10952794e-02f, -6.14957474e-02f, -1.31057855e-02f, -4.58390750e-02f, 4.36351001e-02f, -4.36230674e-02f, 5.74672148e-02f,
  2.26857871e-01f, 1.41450077e-01f, -7.56204501e-02f, -1.71893276e-03f, -2.20546603e-01f, 1.50883412e-02f, -2.55042799e-02f, -1.72352716e-01f, 1.14403620e-01f, 1.10776603e-01f,
  2.12621614e-01f, 1.22399323e-01f, 1.64356455e-01f, 3.15372944e-01f, 9.38717425e-02f, 3.51418376e-01f, 2.32558042e-01f, 1.86392128e-01f, 5.02243042e-02f, -8.67808536e-02f,
  -6.92675114e-02f, -1.36528134e-01f, -1.15408085e-01f, -2.73341835e-01f, -3.70703475e-03f, -3.49173009e-01f, -1.51634216e-01f, -2.58856118e-01f, -1.10615291e-01f, -5.05104214e-02f,
  4.22661006e-02f, 7.68909678e-02f, -8.26012492e-02f, -4.32109311e-02f, -2.95675825e-02f, -8.43655597e-03f, 7.45840312e-04f, -3.08903065e-02f, -3.68760666e-03f, -2.46101301e-02f,
  -6.92472756e-02f, -1.18238814e-02f, -2.07812656e-02f, -5.95265813e-02f, -3.73710990e-02f, 4.09623198e-02f, 1.15205340e-01f, 3.63305882e-02f, -5.26660234e-02f, 1.19272716e-01f,
  7.93763250e-02f, 5.67172505e-02f, 1.16419740e-01f, 4.58914675e-02f, -4.37607653e-02f, 3.14212479e-02f, 8.39908514e-03f, -7.76934698e-02f, 1.43131092e-01f, -4.69084345e-02f,
  -3.41164246e-02f, 4.14728932e-02f, 9.74416360e-02f, -3.31639382e-03f, 7.75652975e-02f, -4.88754362e-02f, -4.14341837e-02f, -9.75773782e-02f, -1.32575005e-01f, -3.67277563e-02f,
  -3.44201587e-02f, -5.79512753e-02f, -4.26493548e-02f, 3.60071249e-02f, 4.53190431e-02f, -5.93284331e-02f, -2.88141370e-02f, 3.84171903e-02f, 6.38004243e-02f, 1.23648062e-01f,
  2.16604713e-02f, -4.67797928e-03f, -1.94768757e-02f, -1.20567949e-02f, 6.18163012e-02f, -1.00141756e-01f, 2.59695165e-02f, 7.10292384e-02f, -2.62369285e-03f, 3.28500941e-02f,
  1.85295772e-02f, -1.06172793e-01f, -5.90938330e-02f, -6.18764907e-02f, 3.63567956e-02f, 5.57615124e-02f, 6.41421378e-02f, -8.34687799e-03f, -2.66957153e-02f, 5.57871275e-02f,
  -1.75135955e-01f, 3.71358581e-02f, 7.70099536e-02f, 7.18953311e-02f, -1.00494944e-01f, 1.02456048e-01f, -4.68718559e-02f, -1.09373562e-01f, -2.01448128e-01f, -3.17615345e-02f,
  4.37061526e-02f, 2.96191555e-02f, 6.91898540e-03f, 2.23677233e-02f, -1.77434944e-02f, -4.21053916e-02f, -3.72818224e-02f, -1.23408101e-01f, 8.71457811e-03f, 6.45647645e-02f,
  -1.83827132e-01f, -1.06179960e-01f, -1.17822319e-01f, -3.45803589e-01f, 2.01495901e-01f, -5.72605804e-02f, -1.86932698e-01f, -1.10746466e-01f, -1.89751208e-01f, -1.36764109e-01f,
  -5.77451959e-02f, 1.39315858e-01f, 2.02728555e-01f, -3.70074838e-01f, 1.23147868e-01f, 5.62319271e-02f, -3.55463535e-01f, -1.84772998e-01f, 1.29614905e-01f, -1.70292869e-01f,
  -1.33197770e-01f, -1.28290534e-01f, -7.53827244e-02f, 5.53013105e-03f, -1.11050107e-01f, -1.50262788e-01f, -5.62687181e-02f, 1.85612947e-01f, -2.02638835e-01f, 1.78087473e-01f,
  4.64533735e-03f, -5.40273450e-02f, -2.43799537e-02f, -3.45434733e-02f, -6.47747889e-02f, -7.35193864e-02f, -3.25035267e-02f, 9.84766409e-02f, 6.57449439e-02f, -6.73716366e-02f,
  4.00620401e-02f, 1.19091630e-01f, 1.24766137e-02f, 1.66612327e-01f, -4.00442444e-02f, 2.70641632e-02f, -1.95454247e-02f, -2.04698667e-02f, -4.21352759e-02f, -1.35203404e-02f,
  -3.90223674e-02f, -5.97916842e-02f, -1.46785095e-01f, -7.74388835e-02f, 2.34999042e-03f, -5.48856519e-02f, -1.39979622e-03f, 8.81498903e-02f, -5.79065159e-02f, -4.53310348e-02f,
  -1.18896388e-03f, 4.79231849e-02f, -3.79909426e-02f, 3.12371664e-02f, -1.25168860e-02f, -4.47994508e-02f, 3.36515270e-02f, 2.89931931e-02f, 7.22394558e-03f, -5.48287071e-02f,
  -4.78602536e-02f, -4.09545004e-02f, 1.36158420e-02f, -1.41102159e-02f, -1.26670733e-01f, -5.37591763e-02f, 2.18409169e-02f, 2.42514983e-02f, -5.13459817e-02f, -1.34535301e-02f,
  8.10774863e-02f, 1.00392792e-02f, 5.89817315e-02f, -2.51686499e-02f, 3.65498401e-02f, 9.04081315e-02f, -3.87616158e-02f, -3.94343100e-02f, 9.48425457e-02f, 2.38703806e-02f,
  -8.63382071e-02f, -1.60862863e-01f, 4.03578244e-02f, 3.88566516e-02f, 5.40735126e-02f, -2.52740690e-03f, -1.10420510e-02f, -3.49019319e-02f, -1.65310558e-02f, 5.92312664e-02f,
  -4.63349260e-02f, -8.19556862e-02f, 2.14703176e-02f, -4.15268466e-02f, 1.72767825e-02f, -3.12521905e-02f, -6.00213893e-02f, 2.42160391e-02f, -3.52635942e-02f, -1.95304248e-02f,
  1.68591905e-02f, 2.79409029e-02f, -5.30639151e-03f, 2.25566849e-02f, -2.04152633e-02f, 6.18161820e-02f, 1.69178788e-02f, -3.42964008e-02f, 1.21752704e-02f, 2.85478514e-02f,
  3.05169225e-01f, 2.56090522e-01f, -2.45539680e-01f, -1.17641643e-01f, -3.23484726e-02f, 4.18117225e-01f, 1.34694636e-01f, 1.02233782e-01f, 9.77079123e-02f, 6.58547953e-02f,
  -9.60307121e-02f, 8.25987756e-02f, 3.36773917e-02f, -7.37915114e-02f, 1.84866503e-01f, 3.49680185e-02f, 1.75416470e-01f, 8.01988095e-02f, -1.46509260e-01f, 1.24174252e-01f,
  -3.23419347e-02f, 4.83054817e-02f, -1.42046049e-01f, -5.31131402e-02f, 7.04065152e-03f, -1.82036921e-01f, -5.04403934e-02f, -8.38154331e-02f, 1.53247649e-02f, 1.05543341e-02f,
  1.32199988e-01f, -1.46586582e-01f, -6.81755599e-03f, -1.35326164e-03f, 1.31521910e-01f, 6.05272241e-02f, -5.90139851e-02f, -1.00059152e-01f, -1.54309437e-01f, -4.45442187e-04f,
  2.89803781e-02f, -2.98812836e-02f, -8.43559876e-02f, -9.36105847e-02f, 3.95330116e-02f, -7.49788657e-02f, -1.41742351e-02f, 5.79249077e-02f, 3.81569192e-02f, -3.73983830e-02f,
  -6.43848702e-02f, 3.23001966e-02f, -2.33972166e-02f, 1.23045240e-02f, 5.23084886e-02f, -7.22317174e-02f, 8.20134655e-02f, -1.66183021e-02f, 8.29177350e-02f, 2.75694933e-02f,
  -9.50895548e-02f, 3.45894434e-02f, -1.51915643e-02f, 1.66172329e-02f, 2.32017543e-02f, -4.44303080e-02f, 1.82292331e-02f, -2.17707828e-04f, -6.27790242e-02f, 5.38247265e-02f,
  1.93639025e-02f, -3.58621292e-02f, -8.82195402e-03f, -9.83183924e-03f, 6.29106164e-02f, -2.48204656e-02f, -4.27623019e-02f, 1.00158378e-02f, -2.21738219e-02f, -5.17036393e-02f,
  -6.94439188e-02f, 2.88193971e-02f, 7.30430111e-02f, 3.05609815e-02f, -2.49087829e-02f, 5.34353144e-02f, 1.57561917e-02f, 3.65899294e-03f, -3.11130770e-02f, 2.36401241e-02f,
  3.21567595e-01f, 1.47214279e-01f, 1.55700259e-02f, 6.63550049e-02f, -4.69415151e-02f, -1.34990923e-02f, -6.30208403e-02f, 3.19174230e-02f, 7.97458515e-02f, 7.26897642e-02f,
  5.20530120e-02f, 2.54298132e-02f, 1.06913596e-01f, 4.63035405e-02f, -1.04858875e-02f, 8.86701420e-03f, 8.26848149e-02f, -2.74690371e-02f, 5.51199801e-02f, 3.83566273e-03f,
  1.41606629e-02f, -1.56341679e-02f, 1.34228244e-02f, 6.19065948e-02f, -1.25875659e-02f, -1.98962633e-02f, 1.12555753e-02f, -6.32558763e-02f, 1.39305703e-02f, -9.22584459e-02f,
  4.13732231e-01f, -9.59293917e-02f, -2.39873547e-02f, 3.08134675e-01f, 1.86341807e-01f, 2.52296887e-02f, 1.36022106e-01f, -4.61075678e-02f, 9.79188234e-02f, -8.02761912e-02f,
  -2.55184919e-02f, -4.80705090e-02f, -3.32425922e-01f, -6.17898293e-02f, -2.13376611e-01f, -3.33015680e-01f, 2.10287496e-01f, 1.40557572e-01f, -8.36162865e-02f, 1.46286935e-01f,
  5.63034415e-02f, -1.71811518e-03f, -1.96861371e-01f, -1.13914207e-01f, 2.97276735e-01f, 2.50757068e-01f, 1.27221167e-01f, -6.34939820e-02f, 2.53698856e-01f, 4.36804444e-02f,
  -1.07906230e-01f, -2.13236753e-02f, -2.73635192e-03f, -1.16070360e-01f, 1.34964541e-01f, 9.38451141e-02f, 1.75528571e-01f, -4.62070368e-02f, -6.99158851e-03f, -7.31672421e-02f,
  2.76392680e-02f, -1.18026175e-01f, 1.87574923e-02f, -1.20097704e-01f, 1.41281724e-01f, 8.92004743e-02f, -3.37630627e-04f, 1.06393285e-01f, -5.32471165e-02f, -4.11305726e-02f,
  1.40399076e-02f, 3.06636794e-03f, 1.29598066e-01f, 1.75967515e-02f, 4.23641391e-02f, -2.50789267e-03f, 2.79929433e-02f, 1.22850768e-01f, 4.21461090e-02f, 8.54252726e-02f,
  -3.36519741e-02f, 2.69908942e-02f, 2.36908142e-02f, -4.25865948e-02f, -2.60962490e-02f, -6.96799834e-04f, 1.06198303e-02f, -4.09429893e-02f, 1.95698384e-02f, 6.24719001e-02f,
  5.58583550e-02f, 2.42448654e-02f, 2.22875327e-02f, 4.03301641e-02f, -3.26637644e-03f, 1.33506507e-02f, 4.44930419e-02f, 6.16639741e-02f, 1.68521404e-01f, -6.73424453e-02f,
  -5.87698407e-02f, -4.46269242e-03f, -6.87088370e-02f, -1.88753027e-02f, -4.06396836e-02f, -6.61624828e-03f, 6.76504225e-02f, -2.65703760e-02f, 1.90564580e-02f, 6.56376630e-02f,
  -1.73871312e-02f, 5.75699471e-02f, -5.74537888e-02f, -1.17909512e-03f, 2.10139249e-02f, 1.96983311e-02f, -5.58774732e-02f, -4.81734425e-02f, -3.86810154e-02f, -1.67796353e-03f,
  1.80327483e-02f, 3.26976031e-02f, 1.38813913e-01f, 6.57345653e-02f, -1.63740776e-02f, -6.04459504e-03f, 4.52982970e-02f, 4.97373603e-02f, 1.12755992e-01f, 3.60232964e-02f,
  3.14667970e-02f, -1.60368963e-05f, -6.04295954e-02f, 7.44727179e-02f, 5.03034666e-02f, 1.28439710e-01f, 5.20246699e-02f, -3.65088545e-02f, -7.99448870e-04f, -1.44356322e-02f,
  4.89715338e-01f, -9.03157368e-02f, 2.05823928e-01f, 2.32152134e-01f, -1.91651165e-01f, 7.06238067e-03f, 4.81469259e-02f, -1.38252065e-01f, 2.13651776e-01f, -2.69564539e-01f,
  -6.24040030e-02f, 3.99054796e-01f, 6.86404407e-02f, -1.76357150e-01f, 4.32939231e-01f, 1.70130521e-01f, 1.25062183e-01f, 1.89393703e-02f, 1.77429110e-01f, 6.86001480e-02f,
  2.14172229e-01f, -2.46712446e-01f, -1.03481628e-01f, -3.17438304e-01f, -1.61855653e-01f, 1.08759785e-02f, -1.02988020e-01f, -9.45483595e-02f, -1.90865815e-01f, -3.07047218e-02f,
  -1.53436869e-01f, -4.73534428e-02f, -7.18610436e-02f, -1.29860759e-01f, 5.17207310e-02f, -6.43246283e-04f, 8.27383101e-02f, 5.17034903e-02f, 1.43056652e-02f, -3.25086750e-02f,
  9.50671434e-02f, 7.10604936e-02f, 2.86819618e-02f, 4.37299833e-02f, -1.53372437e-01f, -2.34360509e-02f, 3.31787765e-02f, -8.82349387e-02f, 3.61884129e-03f, 5.09263128e-02f,
  5.02918847e-02f, 1.18162766e-01f, 1.16761811e-01f, 3.47159654e-02f, 1.08732335e-01f, 2.68231332e-02f, 4.07001860e-02f, 3.83639634e-02f, 9.90501940e-02f, 1.55967707e-02f,
  2.14855392e-02f, 1.04968185e-02f, -3.31993438e-02f, -7.11278170e-02f, 3.67943496e-02f, -1.78827103e-02f, -3.30487862e-02f, -6.74599707e-02f, 5.67992553e-02f, 6.83478490e-02f,
  -3.96812968e-02f, -4.51586992e-02f, -8.06094855e-02f, -1.22089209e-02f, 2.70597637e-03f, -9.03391764e-02f, 7.60250092e-02f, 7.52850203e-03f, 3.32061052e-02f, -3.30320932e-02f,
  -7.44676888e-02f, -5.57711162e-02f, 5.04553728e-02f, -3.34169455e-02f, -1.37657285e-01f, 5.54380789e-02f, 3.79902311e-02f, -6.96069598e-02f, -2.02610511e-02f, 2.24382654e-02f,
  8.85313600e-02f, 2.61618197e-01f, -3.45396213e-02f, -3.07971034e-02f, -1.55728813e-02f, -7.34232068e-02f, -4.01348136e-02f, -1.66407339e-02f, 1.19497404e-02f, 1.11790700e-02f,
  -1.48124173e-02f, -7.43179843e-02f, 5.56470305e-02f, 2.40148138e-02f, -8.20082426e-03f, -1.16608413e-02f, 1.19156567e-02f, 2.92660072e-02f, 7.28817731e-02f, 8.13319981e-02f,
  -5.90969473e-02f, 3.24799605e-02f, -7.65231997e-02f, -7.67485872e-02f, -3.24433818e-02f, 5.10672070e-02f, 1.09551668e-01f, -6.12424836e-02f, 4.83482443e-02f, 2.90899128e-02f,
  -2.57933795e-01f, 3.45440395e-02f, 2.65617937e-01f, -2.30718374e-01f, -1.25444755e-01f, -9.17102862e-03f, 4.10286896e-02f, -1.79130360e-01f, 1.05994523e-01f, -3.82689200e-02f,
  -2.72420496e-01f, 1.60865799e-01f, 3.15762609e-01f, -2.29409888e-01f, 2.76731521e-01f, 2.97280103e-01f, -1.94168121e-01f, -1.59582734e-01f, 1.29108101e-01f, -1.33112907e-01f,
  -5.22624925e-02f, -2.26045609e-01f, 7.14923218e-02f, -1.04927354e-01f, -1.88831732e-01f, -1.16832010e-01f, -9.60992351e-02f, 2.02278361e-01f, -2.81051993e-01f, 6.48472607e-02f,
  -1.45131618e-01f, -3.49595249e-02f, -9.23345685e-02f, 9.22941491e-02f, -9.73374918e-02f, -5.78943491e-02f, 3.45704369e-02f, 1.25047907e-01f, 4.60668840e-02f, -4.29787813e-03f,
  -6.23244280e-03f, 9.50789824e-03f, -6.55346438e-02f, 9.12448987e-02f, 3.05383615e-02f, 4.90059890e-03f, -8.61970335e-03f, -9.84113067e-02f, -3.04234866e-03f, 8.49211812e-02f,
  3.00907381e-02f, 2.50367355e-02f, -7.52272978e-02f, 6.67093834e-03f, 6.81041330e-02f, 2.31642881e-03f, 2.11347975e-02f, 8.76091328e-03f, -9.99313369e-02f, -8.94894078e-02f,
  3.28596309e-02f, 7.57408142e-02f, 9.82351694e-03f, -1.53337214e-02f, -6.52117431e-02f, -1.38407037e-01f, 9.17369872e-02f, 3.13602313e-02f, -3.48218083e-02f, 2.64171343e-02f,
  -5.31647317e-02f, -3.96721587e-02f, -6.49755597e-02f, 4.85152490e-02f, -7.73293823e-02f, -2.92570814e-02f, 5.06517701e-02f, -2.98921615e-02f, -1.08784281e-01f, -8.73175785e-02f,
  7.80093893e-02f, 2.81472541e-02f, 4.42951359e-02f, -4.03521471e-02f, 2.60654390e-02f, 3.31302322e-02f, 4.30810750e-02f, 9.92792938e-03f, 6.89954683e-02f, -1.61204338e-02f,
  -1.24220885e-01f, -3.93198011e-03f, -1.67994399e-03f, 1.47306658e-02f, -3.87600400e-02f, 5.14478087e-02f, 4.69639376e-02f, -2.32280176e-02f, 6.14903644e-02f, 8.51790458e-02f,
  -3.92627791e-02f, -7.44900256e-02f, -7.04586133e-02f, -5.06620388e-03f, 1.91595946e-02f, 4.11293320e-02f, -6.91700503e-02f, 3.40572745e-02f, -8.42163414e-02f, -9.63139385e-02f,
  -2.08292827e-02f, 5.25779799e-02f, 2.91705523e-02f, -6.85651749e-02f, -1.30537003e-01f, -2.13321159e-03f, -2.32951026e-02f, 9.26258489e-02f, 1.68313142e-02f, 6.25638664e-02f,
  -4.96671163e-02f, 1.06425054e-01f, 2.84539551e-01f, -1.68699604e-02f, 3.68540250e-02f, -5.09788357e-02f, 3.76880467e-01f, 1.79432947e-02f, 2.05027804e-01f, 9.26209539e-02f,
  1.46851569e-01f, 1.38480797e-01f, 2.29530245e-01f, 1.42481402e-01f, -1.84803545e-01f, 6.82002380e-02f, -1.28855020e-01f, -3.36134695e-02f, 9.80980173e-02f, -6.95395619e-02f,
  3.24584469e-02f, -8.09086114e-03f, 9.09012109e-02f, -1.27093121e-01f, 1.53570786e-01f, -1.99751630e-01f, -2.55466372e-01f, 1.07802846e-01f, -1.99222937e-01f, 2.27978695e-02f,
  9.14836824e-02f, 1.47299409e-01f, 1.39818579e-01f, 5.94120659e-02f, 2.37944517e-02f, -1.48938477e-01f, -1.52518852e-02f, 5.61742634e-02f, 3.67706269e-02f, -8.92811865e-02f,
  -6.85887635e-02f, 6.87837303e-02f, -1.14275180e-01f, 1.03540095e-02f, 3.73809338e-02f, 2.42949501e-02f, 1.45030499e-01f, -5.45017840e-03f, 2.42297798e-02f, 3.88580821e-02f,
  1.49023503e-01f, -6.36319220e-02f, -7.19876811e-02f, -8.25360231e-03f, -1.40986247e-02f, -2.40017436e-02f, 2.14526821e-02f, -4.82598245e-02f, -8.52469727e-02f, -9.51648206e-02f,
  -8.97364616e-02f, -4.67074849e-02f, 6.29619807e-02f, 5.90064898e-02f, 5.62216416e-02f, -2.58823298e-02f, -4.81632091e-02f, 5.64044481e-03f, 6.69610053e-02f, -2.64454912e-02f,
  -2.35843286e-02f, -1.31954765e-02f, 8.74171406e-02f, -9.91950855e-02f, 1.12472782e-02f, 2.07794216e-02f, 5.94484061e-02f, 3.93890291e-02f, 2.29124390e-02f, 6.28074631e-02f,
  8.53709783e-03f, -1.33089488e-02f, 1.91301599e-01f, -5.99081740e-02f, 6.38129115e-02f, -1.75878964e-02f, -6.20911084e-02f, -5.68021014e-02f, -2.59271488e-02f, -3.23204547e-02f,
  -1.37900829e-01f, -1.91403851e-01f, 8.03067312e-02f, 6.44311532e-02f, 7.21378848e-02f, 3.98418270e-02f, -4.37265784e-02f, -6.82464987e-02f, -1.07306488e-01f, -7.95322880e-02f,
  -1.38953254e-01f, 3.53437685e-03f, -1.34470910e-01f, 2.73022894e-02f, -5.12513071e-02f, 6.22377265e-03f, 9.41197295e-03f, -8.94114673e-02f, -3.43445018e-02f, -7.59845152e-02f,
  -7.77290985e-02f, 4.45083715e-02f, -1.19333647e-01f, 1.22166714e-02f, -6.69411123e-02f, -5.09899631e-02f, -1.29648512e-02f, 2.19352581e-02f, -1.36658832e-01f, -7.71705434e-02f,
  1.82897270e-01f, 3.87807637e-02f, 7.16388822e-02f, -7.36229047e-02f, -4.31895480e-02f, -3.90987515e-01f, -2.39536047e-01f, -1.04212329e-01f, -1.77918330e-01f, -9.47776809e-02f,
  -2.00373322e-01f, 2.69934714e-01f, -4.59267870e-02f, -3.57632875e-01f, -1.88758269e-01f, -1.97634533e-01f, -2.94777870e-01f, -6.25779405e-02f, -5.30099720e-02f, -1.57889295e-02f,
  1.88908749e-03f, -2.39219502e-01f, -3.93677577e-02f, -7.28689227e-03f, 5.92173822e-02f, 3.24018955e-01f, 1.58688858e-01f, 1.42977163e-01f, 3.93334888e-02f, 8.33121222e-03f,
  -9.24964696e-02f, 5.41184433e-02f, -5.94139770e-02f, -4.51908074e-02f, -7.05590174e-02f, 2.23302413e-02f, 3.83491069e-02f, 9.08194184e-02f, 1.71175189e-02f, 5.19184433e-02f,
  6.73281401e-02f, 3.01649813e-02f, -9.96290520e-03f, 3.48491110e-02f, 4.60412316e-02f, 9.03769508e-02f, -4.33242396e-02f, -7.40776882e-02f, 5.60725748e-04f, -4.63593900e-02f,
  -6.04588874e-02f, 5.34681119e-02f, -3.31604742e-02f, 5.70057780e-02f, 6.70419484e-02f, -6.84264600e-02f, -1.06385976e-01f, 2.24879254e-02f, -3.08993869e-02f, -5.02596684e-02f,
  4.87384237e-02f, -3.82472053e-02f, 2.87076663e-02f, 3.50266732e-02f, -3.78196910e-02f, 6.61628544e-02f, 2.56587211e-02f, 4.40578163e-03f, 3.06588616e-02f, -5.09856455e-02f,
  -4.29113917e-02f, -1.59460288e-02f, -5.01436591e-02f, -5.80078848e-02f, 1.68422218e-02f, -5.63598191e-03f, 6.19203709e-02f, 6.25729337e-02f, -6.01133183e-02f, -3.96227129e-02f,
  2.87369471e-02f, -4.55131680e-02f, 1.32466957e-03f, 6.79073036e-02f, -7.35753626e-02f, 1.49481846e-02f, 4.91643585e-02f, 1.56786405e-02f, -2.49069352e-02f, 4.07641865e-02f,
  -1.58050925e-01f, 4.86905836e-02f, -1.37048846e-04f, 3.54487635e-02f, 2.28176974e-02f, 5.74124511e-03f, -7.39349425e-02f, -1.02061965e-03f, 3.53794582e-02f, -1.36392154e-02f,
  3.99754457e-02f, 2.65655313e-02f, -1.29476339e-02f, -3.45285907e-02f, -2.47816946e-02f, -1.28339380e-01f, 3.96984406e-02f, 6.39729276e-02f, -6.18508784e-03f, 9.22225937e-02f,
  2.51246765e-02f, 2.53496747e-02f, 2.79877279e-02f, -8.77110511e-02f, -3.30052804e-03f, 9.46626142e-02f, 4.06289324e-02f, 5.50881922e-02f, 9.05223563e-02f, -2.63368199e-03f,
  -1.42272651e-01f, 1.66381449e-01f, 3.11401099e-01f, 1.73833653e-01f, 1.16217986e-01f, -3.04173410e-01f, -2.25497961e-01f, 5.55598252e-02f, 1.61324888e-01f, -2.02112690e-01f,
  -3.11279558e-02f, 8.53524730e-02f, -5.61660938e-02f, 1.13944218e-01f, -3.23315263e-01f, -1.93900272e-01f, -1.35913178e-01f, -1.54241905e-01f, 1.81290627e-01f, -1.47542730e-02f,
  -9.41047154e-04f, -7.76105523e-02f, 8.05155113e-02f, 2.78485030e-01f, 1.48050234e-01f, 2.02126518e-01f, -2.78392911e-01f, 1.50080591e-01f, -3.32837296e-03f, -9.37749520e-02f,
  -1.23833925e-01f, 2.72596687e-01f, 1.13288745e-01f, 7.58269876e-02f, -7.34297335e-02f, -1.09264322e-01f, -5.90034313e-02f, -1.03799410e-01f, 5.07501811e-02f, 1.98225807e-02f,
  -8.98654014e-02f, 9.83022526e-03f, 4.17654179e-02f, 4.00210917e-02f, 2.60359347e-02f, 1.66966170e-01f, 1.67736784e-01f, 7.61391893e-02f, 1.10819548e-01f, 5.97318299e-02f,
  1.34148315e-01f, 9.15285945e-02f, 5.17928367e-03f, -6.74847513e-02f, -4.21538427e-02f, 1.13325045e-01f, 2.77519915e-02f, -9.52665433e-02f, -7.56986439e-02f, 1.17660813e-01f,
  7.79302791e-02f, 2.36554220e-02f, 6.19171858e-02f, 5.46082519e-02f, -4.43862937e-03f, -4.22742730e-03f, -2.12165322e-02f, -6.39994442e-02f, -1.32019334e-02f, -3.67024876e-02f,
  -6.60124570e-02f, 6.13669790e-02f, 7.53770024e-02f, 8.44067559e-02f, 4.29979153e-02f, -9.27864574e-04f, -8.46800581e-02f, 1.41866365e-02f, -4.31287102e-02f, -4.88228351e-03f,
  5.64973876e-02f, -6.24602176e-02f, -2.25831792e-02f, -7.10782083e-03f, -6.92520887e-02f, 5.51216640e-02f, 7.17457831e-02f, 6.74442053e-02f, 6.51829084e-03f, -8.10965747e-02f,
  -1.83126658e-01f, -1.05166472e-01f, 1.62171863e-03f, -7.03577995e-02f, -8.44466873e-03f, -9.97476503e-02f, 4.81569767e-02f, 9.65735037e-03f, -3.40868384e-02f, 3.24849375e-02f,
  -2.67099813e-02f, -1.19166151e-01f, -9.29319784e-02f, -4.06789780e-02f, -3.26080173e-02f, -4.84571531e-02f, -7.52529353e-02f, -1.14985734e-01f, -1.06046759e-01f, -5.56997061e-02f,
  -4.07210644e-03f, -6.37260228e-02f, -8.29086080e-02f, -1.76280346e-02f, -7.52145275e-02f, -4.53107767e-02f, -4.38813902e-02f, -5.01132337e-03f, 4.60730419e-02f, -5.78687200e-03f,
  3.88358116e-01f, -4.45381850e-01f, -1.24151362e-02f, 7.18764439e-02f, -3.89522128e-02f, 1.34781688e-01f, -7.83498585e-02f, -1.16877511e-01f, 2.28207722e-01f, -3.91550303e-01f,
  -2.75028318e-01f, 5.80293611e-02f, -1.74869344e-01f, -1.77296788e-01f, 4.44541991e-01f, 3.60744931e-02f, 1.45341270e-02f, 1.15484148e-02f, 7.46883973e-02f, -1.48177087e-01f,
  6.03686310e-02f, -1.05206385e-01f, -5.11242002e-02f, -1.72716349e-01f, -1.52253404e-01f, 1.92822050e-02f, -1.47080272e-01f, -1.00712232e-01f, -9.40985680e-02f, 8.11607465e-02f,
  -3.15308347e-02f, -1.10805772e-01f, -7.05939308e-02f, 4.22173738e-02f, -1.24065948e-04f, -5.65789603e-02f, -2.09997203e-02f, 8.59450102e-02f, 8.21993276e-02f, 1.37095880e-02f,
  7.19028488e-02f, 5.43905944e-02f, 3.92218679e-02f, 9.42944642e-03f, -1.46863256e-02f, 5.87671362e-02f, 5.71562583e-03f, -5.53815812e-02f, -6.07819855e-03f, 1.05940783e-02f,
  -5.00490479e-02f, 2.94025871e-03f, 3.96106578e-02f, -1.31648276e-02f, 6.81905448e-02f, 2.07293760e-02f, -1.12191057e-02f, 7.84168718e-04f, 7.57989362e-02f, 5.12010530e-02f,
  6.75915927e-03f, 6.77334592e-02f, -1.39162010e-02f, -4.66545746e-02f, 1.40216490e-02f, -5.84918261e-02f, 2.63873804e-02f, -3.36901620e-02f, 6.85119629e-02f, -5.32831326e-02f,
  5.98341748e-02f, -1.58944912e-02f, -3.32277380e-02f, -4.61196229e-02f, -7.90570024e-03f, 2.22047977e-02f, 2.11233832e-03f, -4.20881361e-02f, 6.23998698e-03f, 6.22490002e-03f,
  1.48777023e-03f, 5.03059886e-02f, 6.93754060e-03f, -5.30781709e-02f, -6.03356101e-02f, 1.34751443e-02f, -3.97595055e-02f, -3.93727422e-02f, -5.55074215e-02f, 5.45633771e-02f,
  -3.59088890e-02f, -1.69885159e-01f, -1.56743601e-02f, -1.33472811e-02f, 3.34010161e-02f, -5.80257364e-02f, 3.51681188e-02f, 2.82455911e-03f, 8.29609577e-03f, -1.44132590e-02f,
  -5.44164181e-02f, -6.31237030e-02f, -9.37056448e-03f, 4.81406339e-02f, 2.66906358e-02f, -4.67028841e-02f, -1.94520932e-02f, 6.44534379e-02f, 2.33359337e-02f, -4.89292108e-02f,
  -9.52637196e-03f, -3.80479880e-02f, -1.97559427e-02f, 7.44842505e-03f, -4.99187522e-02f, -2.14940459e-02f, 7.55037144e-02f, 6.01277128e-02f, -6.40823469e-02f, -1.37677910e-02f,
  -2.56760448e-01f, 1.93340927e-01f, 1.68598086e-01f, -2.04909965e-01f, 1.43685445e-01f, 2.41775006e-01f, 1.47316352e-01f, 1.69592351e-01f, 2.60913938e-01f, -1.12547778e-01f,
  -3.14268842e-02f, -8.83194953e-02f, 1.04810864e-01f, -1.40631378e-01f, -1.10183306e-01f, 1.05680086e-01f, -2.60736167e-01f, -1.17406741e-01f, 4.87621427e-02f, -1.35967538e-01f,
  -8.55386034e-02f, -2.53355712e-01f, -1.01172924e-01f, -1.13568000e-01f, -2.14893997e-01f, -9.08474177e-02f, -2.92696178e-01f, 1.83161676e-01f, -1.84371218e-01f, 1.28043801e-01f,
  1.27868190e-01f, 6.82349205e-02f, -2.25080606e-02f, -4.30492423e-02f, -9.13057774e-02f, 1.18861020e-01f, -3.80599722e-02f, 4.73304912e-02f, 1.57073915e-01f, 8.29292387e-02f,
  -1.06371522e-01f, -6.51887730e-02f, -5.06402403e-02f, 8.72065276e-02f, 9.23596546e-02f, -4.99000028e-03f, -4.01697829e-02f, -7.50112766e-03f, 1.83007903e-02f, 4.10124101e-02f,
  -6.32554367e-02f, -3.83462906e-02f, -1.00211985e-01f, -5.08220755e-02f, -4.94040586e-02f, -8.09870362e-02f, -3.96762304e-02f, 9.95221436e-02f, 1.52520612e-02f, 4.97291833e-02f,
  -3.89618538e-02f, -1.00600049e-02f, -7.76833743e-02f, 9.57440734e-02f, -2.66734548e-02f, -1.93705708e-02f, -1.16520435e-01f, -4.50870954e-02f, -3.99564952e-02f, -9.34780315e-02f,
  -6.27862737e-02f, -9.53289121e-02f, -2.54793037e-02f, 4.35526855e-02f, -6.46472722e-02f, 5.34729548e-02f, -5.93163483e-02f, 3.68913822e-02f, -2.26568673e-02f, -8.83479491e-02f,
  3.88915576e-02f, -1.73658803e-02f, -1.65289007e-02f, -1.75319407e-02f, 9.98662226e-03f, 6.61056256e-03f, -4.22256440e-02f, 5.52380979e-02f, -1.05774663e-02f, -6.82414845e-02f,
  -1.70514937e-02f, -4.38391492e-02f, 3.70970406e-02f, -5.98110482e-02f, 9.40655395e-02f, 2.17543431e-02f, 2.96616126e-02f, -7.39290984e-03f, -1.55872330e-02f, -1.57166366e-02f,
  -4.06191014e-02f, -1.67840850e-02f, -1.24548621e-01f, 1.06781811e-01f, -8.16036423e-04f, 4.66398289e-03f, -6.28811792e-02f, -7.73465186e-02f, -2.59718467e-02f, 1.66219268e-02f,
  -6.71376586e-02f, 2.03144308e-02f, -5.18831611e-02f, -5.49625605e-02f, -3.06688510e-02f, -6.78558499e-02f, 3.68303321e-02f, 2.52519678e-02f, -3.07454448e-02f, -4.77636606e-02f,
  -4.14565742e-01f, 1.86074018e-01f, 1.48478329e-01f, -2.33744085e-01f, -2.30147645e-01f, 9.53802839e-02f, 1.52062088e-01f, -1.60253808e-01f, -3.74000147e-02f, 1.67954057e-01f,
  -2.37120241e-02f, -1.76106207e-02f, 3.07418883e-01f, -3.06214750e-01f, -2.74933845e-01f, 1.52873650e-01f, -1.03557818e-01f, 1.39736354e-01f, -5.81103973e-02f, -1.07877500e-01f,
  -9.08887684e-02f, -3.36938471e-01f, 7.11862296e-02f, -1.38342410e-01f, -2.28267670e-01f, 7.62130097e-02f, -8.03430900e-02f, 5.96894212e-02f, -1.33892909e-01f, -2.11137265e-01f,
  6.13876730e-02f, -1.27885237e-01f, 3.25360075e-02f, 3.76828425e-02f, 3.79348248e-02f, 6.02658540e-02f, 4.31470945e-02f, 9.76398364e-02f, -8.80312994e-02f, -8.32521264e-03f,
  4.24637347e-02f, -5.87136708e-02f, -6.68713301e-02f, -2.11914517e-02f, -4.05809097e-02f, -9.77906063e-02f, -5.68304136e-02f, -3.47226635e-02f, 2.82641258e-02f, -8.31233785e-02f,
  7.24754184e-02f, 9.79358032e-02f, -7.50434175e-02f, 1.80220269e-02f, -4.08260971e-02f, -4.98621315e-02f, 1.14434905e-01f, 5.16339801e-02f, 2.73846239e-02f, -1.23017497e-01f,
  -8.55177343e-02f, -7.07402127e-03f, -6.90832511e-02f, -4.63403501e-02f, -5.37856482e-02f, 7.39628002e-02f, -9.50298309e-02f, 6.41730661e-03f, -3.54654975e-02f, 5.50006479e-02f,
  4.38140985e-03f, 8.68530348e-02f, -1.04460418e-01f, 6.25166064e-03f, -8.23123381e-03f, -4.18536812e-02f, 5.60153760e-02f, 5.78551851e-02f, 3.78682576e-02f, 2.05350518e-02f,
  7.12618232e-02f, 2.09863465e-02f, 2.06303634e-02f, 1.03859119e-01f, 1.21256132e-02f, -6.97599072e-03f, -3.29323821e-02f, 5.03427982e-02f, -3.47517878e-02f, -1.47113679e-02f,
  3.81272379e-03f, -7.31877908e-02f, 1.43853305e-02f, 3.67135815e-02f, 7.86116347e-02f, -7.39732385e-02f, 1.33482432e-02f, -3.54297608e-02f, -5.92890643e-02f, -1.05498591e-02f,
  1.73179489e-02f, -2.00644694e-03f, 3.46612111e-02f, -7.78513923e-02f, 7.78638348e-02f, 5.72880916e-02f, 1.53261304e-01f, 1.26026794e-01f, -6.94768503e-02f, -1.04662403e-01f,
  6.22724034e-02f, -3.08886524e-02f, 5.87453619e-02f, 1.11249303e-02f, 3.32203135e-02f, -4.35773917e-02f, -8.11577216e-02f, 2.89009362e-02f, -6.70632422e-02f, 5.30533530e-02f,
  -5.08314908e-01f, 3.27417254e-01f, 3.23831290e-01f, -1.61796629e-01f, -2.40276545e-01f, 2.89023101e-01f, 3.43317896e-01f, 2.82766949e-02f, -2.22787485e-01f, 3.08161706e-01f,
  9.15221348e-02f, 5.80732599e-02f, 2.21527219e-01f, 8.55690986e-02f, -1.26470670e-01f, 1.83383286e-01f, -2.79640337e-03f, 7.25980848e-03f, 1.29324317e-01f, 1.18504599e-01f,
  -1.13646649e-01f, -7.36257359e-02f, 1.72683269e-01f, -1.04794905e-01f, 6.54637292e-02f, 2.30292790e-02f, -8.07280019e-02f, 8.74356925e-02f, -9.99510363e-02f, 7.68932328e-02f,
  1.58068523e-01f, 2.92463340e-02f, -5.60334548e-02f, -5.55436313e-03f, 7.08215386e-02f, 3.57312225e-02f, 1.10402582e-02f, 6.30618036e-02f, -7.83302337e-02f, -4.15838137e-02f,
  -4.54764394e-03f, -1.17364384e-01f, -5.98995127e-02f, -6.92013577e-02f, -1.12714559e-01f, -1.12075433e-01f, -1.20401569e-02f, 5.56278713e-02f, 6.75369129e-02f, -2.44992953e-02f,
  -6.87910616e-03f, 1.06177323e-01f, 1.60888638e-02f, 3.46559137e-02f, 4.16219160e-02f, 1.79499178e-03f, -1.26791233e-02f, -5.41449524e-02f, -1.00030703e-02f, -7.11625889e-02f,
  -4.71577756e-02f, -1.52779799e-02f, -6.70714770e-04f, 6.64597098e-03f, -4.30085994e-02f, -8.26642907e-04f, -1.52062345e-02f, 2.75944322e-02f, -1.16055692e-02f, 2.01335307e-02f,
  -1.26118258e-01f, -4.01397124e-02f, -5.39724901e-02f, 4.33865003e-02f, -7.00265262e-03f, -6.76085358e-04f, 1.69160627e-02f, 2.32173875e-02f, 6.10375330e-02f, 1.78452901e-04f,
  -2.50422694e-02f, 3.60513502e-03f, 8.55922550e-02f, -1.31810578e-02f, 6.65271580e-02f, -3.97145264e-02f, 4.55911160e-02f, -1.54180601e-02f, 1.00996807e-01f, 3.88819799e-02f,
  1.11422203e-02f, 1.65834621e-01f, 9.96339321e-02f, 3.16199735e-02f, 5.22902533e-02f, -2.98274308e-02f, 5.45460954e-02f, -2.33030468e-02f, -4.08299267e-02f, -3.77961877e-03f,
  -4.68064025e-02f, 7.06249177e-02f, 3.21829207e-02f, -7.29948469e-03f, 6.38346598e-02f, 1.27373144e-01f, 1.05720004e-02f, 5.79840178e-03f, -7.01174363e-02f, -3.14815319e-03f,
  1.10614235e-02f, -4.48015928e-02f, -3.86547893e-02f, 3.89532149e-02f, -8.26491714e-02f, 4.39132005e-02f, -3.97433639e-02f, -1.75451394e-02f, 1.62695535e-02f, 1.73971837e-03f,
  -1.59897670e-01f, -1.35690257e-01f, 3.22440267e-02f, -2.90614694e-01f, 2.05826387e-01f, 2.28779927e-01f, 1.27342805e-01f, 1.18166357e-01f, 1.13068670e-01f, -1.06877476e-01f,
  8.92672613e-02f, -4.17091548e-01f, 2.67627031e-01f, -1.84755400e-01f, -1.36685431e-01f, 2.90104687e-01f, -9.43982154e-02f, -1.26617447e-01f, 1.57280371e-01f, -1.08372189e-01f,
  2.82359053e-03f, -2.35306114e-01f, -4.06485721e-02f, 5.08115441e-02f, -2.11261034e-01f, -1.56376377e-01f, -2.36620814e-01f, 2.00562291e-02f, -1.76109612e-01f, -9.60103571e-02f,
  -2.29886472e-02f, -8.99858102e-02f, 6.52523860e-02f, -4.19055484e-02f, -6.86019883e-02f, 8.77599865e-02f, -9.12726950e-03f, 1.69584695e-02f, 8.23104754e-02f, 7.70894140e-02f,
  -5.48505522e-02f, -6.47286102e-02f, -8.36320221e-02f, 2.90821530e-02f, 5.15788533e-02f, -2.69713486e-03f, 7.26179630e-02f, -7.39747286e-03f, -4.13546339e-02f, 9.61918011e-02f,
  2.76748054e-02f, 6.75673038e-02f, -9.40769613e-02f, -3.02808173e-02f, -3.01545244e-02f, 1.00416839e-01f, -4.77999076e-02f, 3.33413258e-02f, -3.41840126e-02f, -2.34457292e-02f,
  1.40267149e-01f, 5.18739671e-02f, 1.82130598e-02f, 5.45913237e-04f, 2.52632834e-02f, 4.65306733e-03f, 3.96646000e-03f, -7.18278289e-02f, -2.04958534e-03f, -3.33366282e-02f,
  -6.70557469e-02f, -6.16999306e-02f, -5.00133149e-02f, 1.12191491e-01f, 4.80356589e-02f, 5.15920669e-02f, -3.16609698e-03f, -3.48153897e-02f, 2.11464744e-02f, -1.78845804e-02f,
  5.70175275e-02f, 8.64142738e-03f, -1.27292156e-01f, -8.10889248e-03f, 4.84777987e-02f, 3.53883319e-02f, -6.44532442e-02f, 5.59862442e-02f, 6.54031411e-02f, -8.29470344e-04f,
  -1.26601249e-01f, -3.41546893e-01f, 5.52054262e-04f, -5.57674468e-03f, 2.12336946e-02f, -5.72728068e-02f, -4.23500575e-02f, 3.27699967e-02f, -5.21963015e-02f, 7.74830952e-02f,
  9.34628695e-02f, -3.11296154e-02f, -1.21964678e-01f, 1.24382593e-01f, 4.57987003e-02f, 3.54775600e-02f, -8.58556703e-02f, -4.64966297e-02f, -3.22805941e-02f, -8.95431116e-02f,
  -8.00357759e-02f, -2.45629922e-02f, 7.32609630e-02f, -1.58014037e-02f, 7.96383526e-03f, -2.00576112e-02f, -1.02763139e-01f, -1.71920992e-02f, 8.35882723e-02f, 4.54450734e-02f,
  -2.65716851e-01f, 2.87179142e-01f, -1.32463276e-01f, -3.38152558e-01f, -2.38971382e-01f, 2.54846841e-01f, 3.01141918e-01f, -9.00214836e-02f, -3.64974439e-02f, 2.12402523e-01f,
  -1.52439833e-01f, 1.77730694e-01f, 1.26760885e-01f, -2.42287114e-01f, -3.43083680e-01f, 6.90150708e-02f, -5.70180975e-02f, 1.53664231e-01f, 1.25049613e-02f, 6.89378381e-03f,
  -2.10308969e-01f, -1.82128787e-01f, -1.58632517e-01f, -6.36440367e-02f, -1.04795679e-01f, -1.95846409e-02f, 2.76942109e-03f, 1.32080048e-01f, -1.54907867e-01f, -5.14250137e-02f,
  -6.15647947e-03f, -4.09063846e-02f, -9.25218835e-02f, 7.55565166e-02f, -9.73256538e-04f, 4.78334911e-02f, 1.11106724e-01f, 1.02426214e-02f, -6.94058388e-02f, 3.60805616e-02f,
  1.13646872e-01f, -2.95148790e-02f, 6.58980943e-03f, 8.07926133e-02f, -6.57953098e-02f, -4.15958986e-02f, -3.16108763e-02f, -2.86429375e-02f, -4.77440059e-02f, -1.50965787e-02f,
  2.34456584e-02f, -6.59108832e-02f, -6.59384355e-02f, 4.75749075e-02f, 2.42851917e-02f, -4.18318063e-02f, -5.07048219e-02f, 5.91731407e-02f, 1.87183358e-02f, -8.79893079e-02f,
  2.12979894e-02f, 1.84583720e-02f, -8.65154415e-02f, -6.40031183e-03f, -4.27068695e-02f, -2.06197575e-02f, 3.29606645e-02f, -1.10749612e-02f, -1.72768570e-02f, -1.35005079e-02f,
  -8.15832317e-02f, -3.43085937e-02f, -1.14835445e-02f, -2.54298877e-02f, -1.60388574e-02f, -3.96781154e-02f, -4.96556796e-02f, 1.79002900e-03f, -1.22895157e-02f, -6.30544946e-02f,
  1.59242246e-02f, 4.95512970e-02f, 7.84805790e-02f, 3.52522992e-02f, 5.66131994e-02f, 1.33838905e-02f, 3.19044665e-02f, 3.67388651e-02f, 4.84864339e-02f, -3.34834568e-02f,
  1.99621469e-01f, 1.36123285e-01f, -1.75593421e-02f, 3.91410924e-02f, 2.07291078e-02f, -2.27620807e-02f, -2.03010533e-02f, 4.51908745e-02f, 1.51487604e-01f, 1.03954962e-02f,
  2.67473217e-02f, 8.22939500e-02f, 5.15131541e-02f, -6.98030591e-02f, 7.50215575e-02f, 4.44727913e-02f, 6.21283352e-02f, 7.22240880e-02f, 2.65575238e-02f, 3.60458083e-02f,
  -6.76032975e-02f, 1.67390499e-02f, 1.65876676e-03f, 4.66351323e-02f, 1.65561903e-02f, 8.20420533e-02f, 6.84934407e-02f, 2.78573558e-02f, -1.20502310e-02f, 8.37559104e-02f,
  -1.95290238e-01f, 3.30769300e-01f, -1.67020321e-01f, -2.11521327e-01f, -1.81573793e-01f, -9.16655809e-02f, -9.64423344e-02f, 3.57658602e-02f, -3.50717336e-01f, 2.22988665e-01f,
  7.82115459e-02f, 2.85041658e-03f, -1.92009527e-02f, 2.66560346e-01f, -2.67767668e-01f, 6.81881458e-02f, 1.06325738e-01f, -1.89996697e-02f, -2.23150328e-01f, -3.24278744e-03f,
  3.64104658e-02f, 1.56454250e-01f, 1.03515364e-01f, 2.33056262e-01f, -1.04322881e-02f, 3.08756786e-03f, 8.13520327e-02f, -1.29890665e-01f, 3.13338220e-01f, -1.19942784e-01f,
  8.08762480e-03f, -1.89168262e-03f, 1.29099101e-01f, 5.64866401e-02f, -9.75062177e-02f, -9.58468840e-02f, -2.77565420e-02f, -6.62152618e-02f, -1.60368830e-01f, 4.95952219e-02f,
  -2.76153106e-02f, -3.40321139e-02f, 1.01682484e-01f, 2.37694057e-03f, -6.58130273e-02f, 6.74426258e-02f, -3.08326967e-02f, -4.36483398e-02f, 1.23140626e-01f, -1.11904079e-02f,
  -1.11883776e-02f, -8.07490852e-03f, 2.33583841e-02f, -4.37519215e-02f, 3.70491706e-02f, -8.44089016e-02f, -8.85896236e-02f, -1.21479787e-01f, 2.48220004e-02f, -1.15318358e-01f,
  2.13238839e-02f, -1.79914847e-01f, 1.49765939e-01f, -1.44772619e-01f, 2.92889159e-02f, 1.07648680e-02f, 3.93987522e-02f, -5.52286860e-03f, -6.28840029e-02f, -6.79459497e-02f,
  -4.23312970e-02f, 5.99044226e-02f, 5.97346667e-03f, -1.09602466e-01f, -4.24875058e-02f, 5.98178711e-03f, -2.23960821e-02f, -1.64071739e-01f, 3.51995714e-02f, 2.19843034e-02f,
  3.77058759e-02f, -5.53705245e-02f, 1.27303794e-01f, -3.25864293e-02f, 5.30981272e-02f, 2.37097760e-04f, 9.33881011e-03f, 2.55843550e-02f, -1.31758019e-01f, 2.15191375e-02f,
  -6.35375977e-02f, -9.85658094e-02f, 1.02378108e-01f, -2.41180379e-02f, 9.68284607e-02f, 1.11883067e-01f, -1.08750790e-01f, 8.70730728e-02f, 2.68651713e-02f, 2.89437398e-02f,
  7.38721490e-02f, 6.39854372e-03f, -1.14331895e-03f, -9.93375760e-03f, 2.21500024e-02f, 5.54325506e-02f, -8.04967284e-02f, -4.52007838e-02f, 3.12063266e-02f, -2.56069712e-02f,
  6.28025010e-02f, -8.14130828e-02f, -5.64431865e-03f, 3.07382597e-03f, 3.84566374e-02f, 3.04913754e-03f, 1.69398412e-02f, 3.98753863e-03f, -9.38335359e-02f, 6.23148121e-02f,
  4.06388491e-01f, -2.10173503e-01f, -1.80746585e-01f, 2.27642626e-01f, 2.77195364e-01f, 7.68119395e-02f, 1.20141119e-01f, 1.45149156e-01f, -1.32691577e-01f, -2.40217030e-01f,
  2.25656793e-01f, -1.91063330e-01f, -1.68077052e-01f, 6.97428957e-02f, 3.84421974e-01f, -2.41500363e-01f, 1.92097485e-01f, 3.29214595e-02f, -9.64093879e-02f, 1.95338547e-01f,
  9.51307043e-02f, 3.28757852e-01f, 8.51508453e-02f, 3.29480995e-03f, 1.64977700e-01f, -1.17599145e-01f, 1.79226696e-01f, -1.64959297e-01f, 1.48223102e-01f, 1.42202765e-01f,
  8.74141157e-02f, 8.71729404e-02f, -4.50860225e-02f, -8.07400793e-02f, 9.40596014e-02f, 8.44564009e-03f, 2.24436224e-02f, 4.35121395e-02f, 8.98004100e-02f, -7.46790646e-03f,
  -5.70637658e-02f, 3.60159613e-02f, 4.68842871e-02f, -7.54299611e-02f, -5.31274229e-02f, -3.22959456e-03f, -1.15962438e-02f, 1.07415505e-02f, -6.34821355e-02f, 5.12857269e-03f,
  -8.76841620e-02f, -3.08733210e-02f, -5.73623255e-02f, -5.31609766e-02f, 1.30354483e-02f, -1.77593045e-02f, -3.41093726e-02f, -1.56052345e-02f, -5.83677460e-03f, 4.19127867e-02f,
  3.21108960e-02f, -3.65098007e-02f, -7.74808154e-02f, 5.00447862e-02f, 1.74204037e-02f, 4.48749177e-02f, -1.00286320e-01f, 8.32419693e-02f, -6.82823360e-02f, 4.26171906e-02f,
  1.04032472e-01f, 2.64284248e-03f, 5.24898805e-02f, -4.03979719e-02f, 5.66363372e-02f, -1.70871653e-02f, -9.54541378e-03f, -9.99134267e-04f, -9.21443757e-03f, 6.92160428e-02f,
  -4.18638587e-02f, 1.78835669e-03f, -1.74906086e-02f, 2.58480217e-02f, -3.97558622e-02f, -1.37939453e-02f, -1.04491569e-01f, -2.67877467e-02f, 8.11008066e-02f, 2.52986178e-02f,
  6.19280040e-02f, -3.96470055e-02f, 3.14480327e-02f, 7.06002265e-02f, -7.67730698e-02f, -2.87752245e-02f, -1.82291679e-02f, -5.08639812e-02f, -5.09684123e-02f, 2.24027205e-02f,
  4.05488983e-02f, 7.78168440e-03f, -1.99322943e-02f, 3.29232439e-02f, 4.98946980e-02f, -3.75088267e-02f, 2.65234374e-02f, 2.74789147e-02f, 1.25005841e-01f, 3.69098745e-02f,
  1.44057171e-02f, -1.00236014e-02f, 2.89719012e-02f, -2.74262694e-03f, 3.51087860e-04f, 3.56706791e-02f, 3.56832407e-02f, -2.19787285e-02f, 3.85683551e-02f, -9.06097442e-02f,
  -3.35755616e-01f, 3.96132112e-01f, -7.83794001e-02f, -4.60299887e-02f, 7.96023197e-03f, 7.36007541e-02f, -1.63779184e-01f, 2.18697697e-01f, 2.49721091e-02f, 3.03157926e-01f,
  5.39232753e-02f, -6.79697469e-02f, -1.28088444e-01f, 3.64224553e-01f, -4.91627306e-01f, -1.45561725e-01f, 1.82228923e-01f, 8.15483928e-02f, -5.83468266e-02f, 2.99401060e-02f,
  -1.34801820e-01f, 2.51389742e-01f, -4.05363366e-02f, 2.65439749e-01f, 4.06472385e-02f, 5.41247847e-03f, -1.42102525e-01f, -1.69815302e-01f, 1.66097343e-01f, -6.01817220e-02f,
  1.25694752e-01f, 3.70892361e-02f, 3.56723368e-02f, 3.45969945e-02f, 4.77055311e-02f, -2.76345629e-02f, -2.34074146e-02f, -1.70375958e-01f, -7.47772008e-02f, -3.16751131e-04f,
  -1.44327013e-02f, 2.99600177e-02f, 1.49280772e-01f, 1.40779186e-02f, 6.97908551e-02f, 1.03135191e-01f, -9.67035536e-03f, 1.36928977e-02f, 6.98623061e-02f, -2.19429415e-02f,
  -3.11182812e-03f, 1.20234244e-01f, -1.95007622e-02f, 3.00855711e-02f, -5.94152510e-02f, -2.16755047e-02f, 1.39813958e-04f, -1.11713432e-01f, 7.13534933e-03f, -2.18020496e-03f,
  -5.54075800e-02f, 1.26898456e-02f, -4.97793704e-02f, 3.36056687e-02f, -3.88504826e-02f, 5.99956699e-02f, 4.10336219e-02f, 4.24926803e-02f, -3.40935066e-02f, 5.94330626e-03f,
  -1.59984231e-02f, 2.96977460e-02f, 1.01941064e-01f, 3.57291512e-02f, -4.15884964e-02f, 5.97705916e-02f, -7.09132403e-02f, 8.01862478e-02f, 1.94008239e-02f, 2.34767478e-02f,
  4.04487189e-04f, 4.63419501e-03f, 1.30944075e-02f, 1.08961845e-02f, 1.24510890e-02f, -4.60892878e-02f, 1.80288106e-02f, -1.22044347e-02f, -2.24465877e-02f, -1.19303174e-01f,
  4.28572036e-02f, -5.29848319e-03f, -1.38072642e-02f, 4.38887030e-02f, 4.25079465e-03f, 3.88872772e-02f, 1.54447900e-02f, 8.92359838e-02f, -5.09224720e-02f, 4.03695256e-02f,
  -2.27121320e-02f, -2.28845645e-02f, -7.47007504e-02f, -2.81717628e-02f, -4.47892658e-02f, -1.01592377e-01f, -3.48324887e-02f, 3.15764844e-02f, -1.61085967e-02f, 4.18427326e-02f,
  -1.66063346e-02f, -6.04827851e-02f, -6.31911159e-02f, 5.38625345e-02f, 7.93939903e-02f, -5.83317503e-02f, 1.69223100e-02f, 4.40672934e-02f, -4.90468517e-02f, 4.54716086e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.26408398e-01f, 1.78372279e-01f, 1.43784121e-01f, 8.80331099e-02f, -3.41049522e-01f, 2.52171457e-01f, 3.18044811e-01f, 4.81153838e-02f, 1.93309877e-02f, 3.85623395e-01f,
  8.02394822e-02f, -3.88231754e-01f, 2.15126306e-01f, 3.29275995e-01f, -1.08073980e-01f, 3.09987634e-01f, 2.44929880e-01f, 6.54943734e-02f, -4.06876393e-02f, -1.48296893e-01f,
  -1.26945347e-01f, -1.82602748e-01f, 1.73384726e-01f, -2.53765672e-01f, -2.76537895e-01f, -1.51968524e-01f, -2.10912853e-01f, -7.74411559e-02f, -3.36921774e-02f, -1.69364363e-01f,
  -2.78318584e-01f, -3.06746125e-01f, -2.28843406e-01f, -1.23183914e-02f, -1.35290116e-01f, -9.99765396e-02f, 2.15064781e-03f, -8.81917104e-02f, -2.89432053e-02f, -1.55025627e-02f,
  -1.30553260e-01f, -3.69935185e-02f, -9.72545221e-02f, 4.26064096e-02f, -1.51143759e-01f, -1.00817852e-01f, 5.07908582e-04f, 1.93850875e-01f, 5.69538586e-02f, 2.68780999e-02f,
  1.64686292e-01f, 1.37279287e-01f, 1.43709838e-01f, 6.16125986e-02f, 5.77066280e-03f, 4.66340370e-02f, 1.81224287e-01f, 2.21876595e-02f, -1.79928802e-02f, 5.24312584e-03f,
  6.77897483e-02f, -8.24397355e-02f, 1.10289571e-03f, 6.78082136e-03f, 4.32842746e-02f, -3.27506401e-02f, 8.34580336e-04f, 6.72174990e-02f, -4.78071943e-02f, -3.71578187e-02f,
  1.52407428e-02f, -1.01991683e-01f, -2.26192065e-02f, 8.93573612e-02f, 2.68458854e-02f, 6.80045113e-02f, -5.12180757e-03f, -7.60405585e-02f, 1.76172689e-01f, -2.55525112e-03f,
  -4.36115339e-02f, 5.40295318e-02f, -5.79858804e-03f, -1.07909385e-02f, -7.17800390e-03f, 2.32798681e-02f, 8.81259814e-02f, 1.85516819e-01f, 6.37009144e-02f, -9.04980898e-02f,
  -4.81739730e-01f, -3.30762208e-01f, -1.83258161e-01f, -1.42472997e-01f, -7.02084526e-02f, 7.38580385e-03f, 1.53153911e-02f, -4.72606756e-02f, -1.76446676e-01f, 1.74775366e-02f,
  -7.77091691e-03f, 4.92318422e-02f, -6.64429814e-02f, 6.77341875e-03f, 1.29730120e-01f, 1.61510501e-02f, -4.83928099e-02f, -4.80034016e-02f, -1.51983216e-01f, 2.70861331e-02f,
  -6.80469945e-02f, -1.00442924e-01f, 9.36214253e-02f, -9.52499285e-02f, 2.27613095e-02f, 6.39229780e-03f, -2.05035418e-01f, -1.05202738e-02f, -1.72280610e-01f, 8.46507922e-02f,
  -1.60575300e-01f, -3.53079498e-01f, 3.76534432e-01f, -2.50089705e-01f, 1.69084013e-01f, 4.08193260e-01f, 3.72372806e-01f, -2.93400347e-01f, -5.39521337e-01f, -1.30136371e-01f,
  1.85092539e-01f, 1.19493634e-01f, 1.00436449e-01f, -3.60186756e-01f, 3.86958659e-01f, -2.01898664e-01f, -2.57017612e-01f, 2.33927757e-01f, -1.71685338e-01f, 3.72476541e-02f,
  2.34211353e-03f, -2.10227281e-01f, 2.50245512e-01f, -8.16154182e-02f, 1.93835318e-01f, -2.44297739e-02f, 1.29248291e-01f, 2.54819453e-01f, 1.11290783e-01f, 2.02163547e-01f,
  -5.36153652e-02f, -2.50034302e-01f, -6.75742924e-02f, 9.22925323e-02f, 1.10876516e-01f, 1.21059611e-01f, 2.86924362e-01f, 7.83808827e-02f, -4.61529046e-02f, 8.63577127e-02f,
  7.17538148e-02f, -1.89061034e-02f, -1.61070466e-01f, 7.25415796e-02f, -9.36670303e-02f, -1.07501946e-01f, -1.84345424e-01f, 4.49864045e-02f, -6.94186017e-02f, 1.61370914e-02f,
  3.37380357e-02f, -7.30344504e-02f, 1.19949002e-02f, 5.93559928e-02f, -1.23825725e-02f, 6.84197666e-03f, -7.95993879e-02f, 2.09565416e-01f, -5.35399616e-02f, 6.23590872e-02f,
  2.15469301e-02f, -3.60316178e-03f, -1.03146225e-01f, -1.53689489e-01f, -6.33584186e-02f, 4.66382457e-03f, -6.09917520e-03f, -2.65160780e-02f, 7.75625408e-02f, -2.82889102e-02f,
  -3.79025675e-02f, 1.14393689e-01f, -1.25771254e-01f, -8.87303054e-02f, -6.87464252e-02f, -1.77389711e-01f, 2.56076723e-01f, 6.77422136e-02f, -5.57308830e-02f, 1.36309639e-02f,
  -4.66239080e-02f, 8.93019289e-02f, 8.29503611e-02f, 4.51309532e-02f, -5.24516329e-02f, 1.46537378e-01f, -4.38377336e-02f, 3.46373729e-02f, 3.69794965e-02f, 1.84968576e-01f,
  -1.44902706e-01f, -2.18582943e-01f, -3.79998013e-02f, -5.57954684e-02f, 1.59470066e-02f, -7.11081773e-02f, -4.77149747e-02f, -1.49319664e-01f, -3.86400707e-02f, -1.83241479e-02f,
  4.54942137e-02f, 1.03175402e-01f, -1.11685991e-01f, 7.84097984e-02f, 9.53677073e-02f, -8.03001039e-03f, -1.56571135e-01f, -7.06405640e-02f, 2.38930080e-02f, -7.44176731e-02f,
  -2.07316433e-03f, -9.08949301e-02f, 4.40140329e-02f, -1.00672141e-01f, -6.71116933e-02f, 1.28058925e-01f, -6.23901673e-02f, -8.93201828e-02f, 1.45436808e-01f, -1.12167336e-02f,
  1.11473538e-01f, -2.36257538e-01f, -4.20533717e-01f, 8.06719363e-02f, -1.02351464e-01f, 2.65544266e-01f, 5.57402670e-01f, -2.88792759e-01f, -2.21912503e-01f, 3.37621152e-01f,
  4.71001327e-01f, 1.60551444e-01f, 3.43615860e-01f, 5.82441926e-01f, 5.98960519e-02f, 2.22094476e-01f, 4.01257910e-02f, 1.33715451e-01f, -9.55255628e-02f, -2.22008511e-01f,
  -2.36245871e-01f, 1.03773065e-01f, 9.65058208e-02f, -3.64524186e-01f, 2.39492059e-01f, -1.25521183e-01f, 1.27589718e-01f, 1.99744672e-01f, 1.38130747e-02f, 3.75142902e-01f,
  7.97948465e-02f, 2.29944527e-01f, -6.16317354e-02f, -5.41710407e-02f, -8.89175832e-02f, 3.33351456e-02f, 1.02736369e-01f, 1.97947159e-01f, 1.82062760e-01f, -7.04860538e-02f,
  6.85813352e-02f, -5.95668331e-02f, -7.17053488e-02f, 2.18327269e-02f, -3.59303914e-02f, 4.46175598e-02f, 5.89333512e-02f, -1.44137284e-02f, -9.20588300e-02f, 8.46857950e-03f,
  1.61919482e-02f, -5.88924773e-02f, 8.21090937e-02f, 5.52453436e-02f, -7.83128366e-02f, 1.67860594e-02f, -1.38653070e-01f, -7.21964315e-02f, -1.38359755e-01f, -2.45090932e-01f,
  2.76080910e-02f, 3.91773786e-03f, 2.93922443e-02f, 7.61896819e-02f, -4.17659581e-02f, 6.79858029e-02f, 5.89324385e-02f, 7.75947794e-02f, 1.06957473e-01f, 1.45830223e-02f,
  -9.84669253e-02f, -1.25455156e-01f, 7.83692375e-02f, -3.90602536e-02f, -2.64739301e-02f, -3.88003490e-03f, 1.55138783e-02f, 2.35460326e-02f, -2.31679268e-02f, 2.06990223e-02f,
  1.12032056e-01f, 1.91800911e-02f, 3.10315285e-02f, 1.32013276e-01f, -9.32383258e-03f, 2.06817880e-01f, 9.57188010e-02f, -7.59721994e-02f, 1.35288596e-01f, -1.34518564e-01f,
  -1.13926783e-01f, -1.31219730e-01f, 1.41452134e-01f, 6.72947019e-02f, -4.48791590e-03f, 4.51967530e-02f, -2.67383046e-02f, -1.17802441e-01f, -3.33794467e-02f, -1.38865769e-01f,
  -1.70875311e-01f, 5.87275438e-02f, -1.28974423e-01f, 1.25976697e-01f, -6.33272380e-02f, -4.59418893e-02f, 6.60367385e-02f, -2.90418770e-02f, 8.99280906e-02f, -1.08981095e-01f,
  -1.61698032e-02f, 3.92989479e-02f, 1.46275699e-01f, 3.22882012e-02f, -1.01535626e-01f, 7.10568875e-02f, -3.06043923e-02f, 2.81732175e-02f, -1.04391063e-02f, -1.04473636e-01f,
  -1.43190846e-01f, -1.27063364e-01f, -2.79247046e-01f, -3.87076139e-02f, 4.80442196e-01f, -3.20842505e-01f, 3.41022193e-01f, 1.18617259e-01f, 1.38549000e-01f, 1.18968733e-01f,
  3.68849486e-02f, -3.33720893e-01f, -8.64915848e-02f, -3.61270458e-01f, -5.41422129e-01f, -3.41093034e-01f, -4.02849704e-01f, -2.92735398e-01f, -1.67625584e-02f, 1.47296963e-02f,
  -1.41862839e-01f, 2.27331445e-02f, -2.54701316e-01f, 4.13416773e-01f, 3.25795144e-01f, 2.87125230e-01f, 1.09477423e-01f, 1.72113016e-01f, -1.00933611e-02f, -1.38267860e-01f,
  -9.87424925e-02f, 1.50864109e-01f, 4.08368297e-02f, -5.64442463e-02f, 4.73427251e-02f, 1.44990191e-01f, 4.60276008e-02f, 1.17885566e-03f, -5.98701723e-02f, -1.28365576e-01f,
  -3.43058072e-02f, -3.24572399e-02f, -7.96299949e-02f, 8.10981542e-03f, 1.72314152e-01f, -6.06038375e-03f, -5.81656434e-02f, 4.60290499e-02f, 4.35037799e-02f, -2.23064482e-01f,
  -5.77581041e-02f, -1.54017553e-01f, -1.30781736e-02f, -1.47784129e-01f, -5.82497828e-02f, 3.31030204e-03f, 2.48207692e-02f, -9.07240659e-02f, -5.62286563e-02f, 2.94617086e-04f,
  8.07507709e-02f, 1.51945306e-02f, 8.55081975e-02f, 7.64686391e-02f, 5.95497638e-02f, 8.51129517e-02f, -5.07844286e-03f, -6.32643653e-03f, -1.26378133e-03f, 2.44689621e-02f,
  8.22758768e-03f, 3.13192196e-02f, -3.03724036e-02f, -1.82243809e-02f, -8.51989463e-02f, 1.02995321e-01f, 2.40854342e-02f, -2.30352748e-02f, 4.10492681e-02f, -5.70718497e-02f,
  1.84440568e-01f, -4.02148254e-02f, -1.02206163e-01f, 3.20695415e-02f, -1.12065837e-01f, -3.16582508e-02f, 7.93036297e-02f, -5.22303069e-03f, 5.22151217e-02f, 2.47242916e-02f,
  -1.97307095e-01f, -1.29575387e-01f, 6.25682175e-02f, 1.46078439e-02f, -6.03090227e-02f, 4.73805219e-02f, -8.27052221e-02f, 5.35366219e-03f, -2.06629895e-02f, 3.86380740e-02f,
  1.40363732e-02f, 2.29787469e-01f, -5.44271842e-02f, -4.38875742e-02f, 1.02608660e-02f, 3.98892201e-02f, 1.38949482e-02f, 5.84906116e-02f, 1.18301228e-01f, -1.29704013e-01f,
  1.38054475e-01f, -7.61479214e-02f, 9.95588899e-02f, 1.74654424e-01f, 8.80992413e-02f, 7.84002542e-02f, 4.93318513e-02f, 5.99764381e-03f, 1.36497682e-02f, -5.12471646e-02f,
  -9.41735059e-02f, -5.48531823e-02f, 5.29556982e-02f, 1.46006256e-01f, 5.90412766e-02f, -3.10162514e-01f, -1.78233907e-01f, 1.36554211e-01f, -2.45893925e-01f, -1.66344997e-02f,
  1.38423651e-01f, -1.13546327e-01f, -1.08261518e-01f, -3.47330093e-01f, -1.29405528e-01f, -4.07721281e-01f, -8.85261968e-02f, -1.55551538e-01f, -4.63194661e-02f, 3.40016067e-01f,
  1.62908137e-01f, -2.04663694e-01f, 1.71625346e-01f, 1.38976991e-01f, 1.17367044e-01f, 2.84028649e-01f, 4.91306901e-01f, 1.48153752e-01f, 2.47604117e-01f, -1.82167187e-01f,
  -1.82924211e-01f, -5.79527952e-02f, 9.43072289e-02f, -1.68657213e-01f, 2.59115607e-01f, 1.24327138e-01f, 5.54525591e-02f, -1.54326051e-01f, -2.19642222e-02f, -1.04378968e-01f,
  -2.12321710e-02f, -3.05085983e-02f, -1.17729800e-02f, -1.47540510e-01f, -3.35948989e-02f, -3.89487967e-02f, -3.64976898e-02f, 5.23194149e-02f, -9.33958068e-02f, 8.01188871e-02f,
  5.63923195e-02f, 4.15770290e-03f, 2.40380354e-02f, 6.87516481e-02f, 4.89789173e-02f, -5.64575829e-02f, 6.07487485e-02f, 1.86454415e-01f, -1.17245451e-01f, 7.47597814e-02f,
  6.60544112e-02f, 4.94466908e-03f, -1.11952566e-01f, -1.23657890e-01f, -7.54724741e-02f, -4.59221378e-02f, -2.00687975e-01f, -1.41255874e-02f, -3.26668657e-02f, 2.53689033e-03f,
  1.18536338e-01f, 3.15632299e-02f, -2.52557099e-01f, 1.11689650e-01f, 9.59843323e-02f, -4.33340631e-02f, 2.01437864e-02f, 4.92487326e-02f, 1.83850348e-01f, 6.75055832e-02f,
  -1.36117861e-01f, -1.35583118e-01f, -6.07041866e-02f, -3.25824209e-02f, -2.20019668e-01f, 1.70746446e-01f, 9.76762623e-02f, -3.53750885e-02f, 7.22884834e-02f, 9.07411054e-02f,
  1.72714055e-01f, 2.73516536e-01f, 7.95026124e-02f, -1.18952699e-01f, -1.11335076e-01f, 7.18291402e-02f, -1.71118349e-01f, -6.88557252e-02f, 7.58376271e-02f, -5.08644059e-02f,
  2.22696349e-01f, 1.16645962e-01f, 6.26654411e-03f, -1.18816858e-02f, -6.76097870e-02f, 1.54613182e-01f, 1.19006582e-01f, 9.02816579e-02f, 1.07386597e-01f, 1.49456710e-01f,
  2.47047663e-01f, 9.52076458e-04f, -2.60972567e-02f, -9.74664371e-03f, 1.86557427e-01f, 7.50049800e-02f, 9.20581818e-02f, 8.46976340e-02f, -1.69124473e-02f, 7.10741132e-02f,
  -4.09244657e-01f, 2.99423784e-01f, 4.01452661e-01f, -5.33383131e-01f, 1.26780331e-01f, 3.65099669e-01f, -2.49942794e-01f, 2.02259153e-01f, -2.67117977e-01f, -7.23980814e-02f,
  -2.80119002e-01f, 3.57573368e-02f, 7.22913593e-02f, -2.69256532e-01f, -1.19299069e-01f, -6.91041052e-02f, -2.32714280e-01f, -3.21682036e-01f, -2.38831881e-02f, -9.26897004e-02f,
  -1.81422904e-01f, -3.45866978e-01f, 7.21378326e-02f, 3.40410769e-02f, 9.20878351e-02f, 1.03270605e-01f, -1.46935523e-01f, 1.43271998e-01f, -3.43722999e-02f, -8.25945362e-02f,
  -2.57962458e-02f, -1.77720606e-01f, 8.83760229e-02f, 1.67217150e-01f, -2.63301227e-02f, 1.54304691e-02f, 1.31735295e-01f, -8.39965139e-03f, -9.11405236e-02f, -4.68297042e-02f,
  3.26272063e-02f, 1.16702288e-01f, 2.56171320e-02f, 1.59151200e-02f, -1.98358614e-02f, 1.06902733e-01f, 1.56179905e-01f, 1.01800226e-01f, 1.06621809e-01f, 1.19187728e-01f,
  5.61499000e-02f, 1.78367198e-01f, 8.44284073e-02f, 7.57703483e-02f, 9.04226229e-02f, 6.29441738e-02f, -2.39687040e-02f, 1.14701346e-01f, 7.79470205e-02f, 8.51377472e-03f,
  -3.98524813e-02f, -5.85527122e-02f, -1.37329446e-02f, 5.03043383e-02f, -1.29996821e-01f, 1.93500444e-02f, 3.40199918e-02f, -5.97348846e-02f, 5.33816358e-03f, 9.60963890e-02f,
  5.07925823e-02f, 3.58568132e-02f, -8.61095712e-02f, -3.21012437e-02f, -1.25574023e-01f, -8.07141587e-02f, 6.67684376e-02f, 2.50796136e-02f, 3.12108919e-02f, 9.17303488e-02f,
  -1.21135473e-01f, 1.84534304e-02f, -1.03029765e-01f, 6.88051507e-02f, -3.26838456e-02f, 1.10854857e-01f, 8.81631896e-02f, 4.73280624e-02f, -6.27699718e-02f, 4.81419563e-02f,
  3.22658382e-02f, -2.76785642e-01f, 1.52746625e-02f, -3.09173241e-02f, 3.13869826e-02f, -1.71090979e-02f, -1.82137210e-02f, 7.13231638e-02f, -2.85596848e-02f, -6.64269328e-02f,
  -2.02830434e-02f, 2.42706714e-03f, 9.16401818e-02f, 3.55511419e-02f, 2.32671816e-02f, -4.24157642e-02f, -1.00553513e-01f, -1.12868592e-01f, 4.07254659e-02f, 5.03850020e-02f,
  -2.71891942e-03f, -6.53251307e-03f, 2.20136661e-02f, 2.31595282e-02f, -9.88819450e-02f, 4.51005623e-02f, -6.91820756e-02f, -1.44708743e-02f, 5.01226000e-02f, 2.24010609e-02f,
  -2.79964089e-01f, -2.41356626e-01f, -2.85440117e-01f, -3.05617712e-02f, 2.73851633e-01f, -1.02405526e-01f, 3.11900396e-02f, -4.47466858e-02f, -4.93491367e-02f, -4.42389362e-02f,
  8.63008052e-02f, -2.43523538e-01f, -1.22488931e-01f, -2.94216722e-01f, -4.45389181e-01f, -4.89588469e-01f, -2.71272272e-01f, -2.18502253e-01f, -1.59742013e-01f, -1.95131674e-01f,
  -1.43975720e-01f, 1.69773266e-01f, -2.45170310e-01f, 3.56665641e-01f, 1.94138616e-01f, 1.45849422e-01f, 4.29541469e-01f, 3.21107507e-01f, 1.00715064e-01f, 1.31460160e-01f,
  -1.39867440e-02f, -1.45923048e-01f, -3.10559589e-02f, -9.51342657e-02f, -1.04125783e-01f, 1.09453231e-01f, 5.03918082e-02f, 1.11296520e-01f, 1.25435501e-01f, -9.73499194e-02f,
  -4.60767597e-02f, 2.07995743e-01f, 7.83999413e-02f, 7.21923709e-02f, 1.49641961e-01f, 2.38449778e-02f, -8.58036354e-02f, -1.64377004e-01f, 2.97397971e-02f, -1.73339278e-01f,
  -1.91194057e-01f, -1.05369046e-01f, 7.11752698e-02f, -1.11336030e-01f, 6.63380371e-03f, -3.05263735e-02f, -5.71908019e-02f, -1.83041170e-02f, 2.49501392e-02f, 2.21771165e-03f,
  -1.32597843e-02f, 1.70400534e-02f, -1.03445366e-01f, -8.63212626e-03f, -1.35147171e-02f, 1.67957842e-01f, 3.07723116e-02f, -3.98608334e-02f, 1.05695501e-01f, 9.26582739e-02f,
  1.57994881e-01f, 8.18901975e-03f, 3.91338766e-03f, 1.27787637e-02f, -6.66618394e-03f, -1.13084123e-01f, -7.07391724e-02f, -5.58717269e-03f, -8.16885009e-02f, 1.02183913e-04f,
  6.58663660e-02f, 6.71576411e-02f, 1.26267195e-01f, 1.33209035e-01f, -6.35120347e-02f, -6.01830669e-02f, 1.60141155e-01f, -9.62098986e-02f, -1.52536586e-01f, 5.18776365e-02f,
  5.01469523e-02f, -9.16767791e-02f, 9.10792314e-03f, 5.35596386e-02f, 1.26935281e-02f, -7.97935575e-02f, -2.65845228e-02f, -3.24274041e-02f, 6.42136857e-02f, 7.28746206e-02f,
  5.99831231e-02f, 6.97374493e-02f, 1.29564032e-01f, 1.20972674e-02f, 9.37389135e-02f, -8.52983668e-02f, 9.76056885e-03f, 6.67881966e-02f, 1.51302502e-01f, 1.55461535e-01f,
  -1.68394893e-02f, 7.21038282e-02f, 6.00372395e-03f, 9.78118107e-02f, -3.71482372e-02f, -6.18254952e-02f, -3.41436937e-02f, -6.73440993e-02f, -7.59673640e-02f, 9.88068134e-02f,
  1.89506009e-01f, 2.22036943e-01f, 3.51337641e-01f, 2.82172352e-01f, 3.47898126e-01f, 4.67090428e-01f, 2.43168801e-01f, 4.09471810e-01f, 5.98550975e-01f, -1.07867308e-01f,
  -2.38516539e-01f, 6.08328246e-02f, -1.76334813e-01f, 7.17708319e-02f, -9.36086029e-02f, 5.53674027e-02f, 2.24714175e-01f, -1.67553723e-02f, 2.76980758e-01f, 1.28561318e-01f,
  1.64252043e-01f, -2.33800739e-01f, -3.39689165e-01f, -1.70478687e-01f, -1.74380466e-01f, -6.30241558e-02f, -5.60790300e-01f, -1.39225185e-01f, -2.39830166e-01f, 8.71279016e-02f,
  1.67907458e-02f, 1.13300607e-01f, -1.89827859e-01f, -8.63982737e-02f, -1.06962524e-01f, 8.76142830e-02f, -4.06971835e-02f, -3.23167145e-02f, 7.00552240e-02f, 3.32914200e-03f,
  7.88703468e-03f, 1.41644962e-02f, 6.33326098e-02f, 3.01313829e-02f, 1.09833144e-01f, -3.60425636e-02f, 2.38280650e-02f, 7.63671026e-02f, 7.80837843e-03f, 6.37993664e-02f,
  -1.04732774e-01f, -3.67886461e-02f, -3.82271670e-02f, 1.15805961e-01f, -4.32713889e-02f, -4.84846048e-02f, 6.47029802e-02f, -7.00521991e-02f, 1.88381914e-02f, 1.45666391e-01f,
  3.25082727e-02f, 1.52548149e-01f, 1.91132277e-02f, 4.10270803e-02f, -8.52935091e-02f, 4.08253446e-02f, -1.70363978e-01f, -4.03206758e-02f, 4.68102843e-02f, -8.12920630e-02f,
  -3.62280831e-02f, -5.34786321e-02f, 7.85742402e-02f, -3.07095051e-02f, -4.55488898e-02f, 1.29872993e-01f, 1.46360241e-03f, -1.49502475e-02f, 2.67711598e-02f, -6.09709211e-02f,
  9.76334363e-02f, 1.16220573e-02f, -1.31434157e-01f, -3.18174474e-02f, -2.56707557e-02f, -3.11019551e-02f, 3.16766836e-02f, 8.21113288e-02f, -5.12901656e-02f, -1.67219698e-01f,
  2.08243459e-01f, 2.80320019e-01f, -1.10775076e-01f, -7.64266998e-02f, -8.53581354e-03f, -5.07390941e-04f, 9.73001942e-02f, 1.25935033e-01f, 5.30820563e-02f, 1.23825870e-01f,
  3.58113907e-02f, 9.04670209e-02f, -2.41191816e-02f, 8.44659749e-03f, -2.54589599e-02f, 2.71735974e-02f, -4.50773623e-05f, 4.62965593e-02f, -2.95011513e-03f, 9.45847388e-03f,
  -2.89085973e-02f, 4.29081321e-02f, 7.22833723e-02f, -8.07559043e-02f, -3.01602222e-02f, -4.92898673e-02f, 3.33543774e-03f, 1.64789765e-03f, -9.41188168e-03f, -6.57818541e-02f,
  -3.70581560e-02f, -1.78623229e-01f, 5.02242036e-02f, 3.57372999e-01f, -1.08647838e-01f, -2.78939724e-01f, -2.68154800e-01f, -1.39439479e-01f, -3.37131172e-02f, -3.99274021e-01f,
  -1.90140843e-01f, 1.02423094e-01f, -4.16380644e-01f, 3.35662454e-01f, 4.43800241e-01f, -3.86186503e-02f, 2.25899056e-01f, 2.50805225e-02f, 2.19565481e-01f, -1.27937496e-01f,
  2.08807290e-01f, 9.88570154e-02f, 2.83519834e-01f, 1.58765256e-01f, 3.85483950e-02f, 3.39894891e-01f, 4.49426264e-01f, 2.32764795e-01f, 4.58140910e-01f, 3.01408589e-01f,
  -5.85340783e-02f, 4.57631201e-02f, -2.75436565e-02f, 1.19948253e-01f, -8.17721933e-02f, -1.77633062e-01f, 4.15331535e-02f, 1.45774052e-01f, 8.41951650e-03f, 6.54426403e-03f,
  -1.09196067e-01f, 5.22188395e-02f, 6.19005151e-02f, 4.70329858e-02f, -6.59754872e-02f, 1.40212223e-01f, 8.26297700e-02f, -4.41184379e-02f, -4.72629294e-02f, -1.59808308e-01f,
  -2.22225394e-03f, -9.53266993e-02f, -5.52879162e-02f, 2.40602016e-01f, 2.05239952e-01f, 1.05794773e-01f, 9.65834707e-02f, -2.07702871e-02f, 8.48779641e-03f, 2.94979010e-02f,
  -1.79792494e-02f, -1.64195523e-02f, -1.57734513e-01f, -1.18862204e-01f, -7.68998414e-02f, 7.52450600e-02f, 2.99184285e-02f, -5.44834696e-02f, 1.23506822e-01f, -1.60061251e-02f,
  2.19554380e-02f, 8.22850391e-02f, -1.04734585e-01f, -1.44119829e-01f, -3.94421816e-02f, -7.21092299e-02f, 1.38773369e-02f, -1.48635067e-03f, -4.06665727e-02f, -7.36142248e-02f,
  5.72394095e-02f, 5.16873486e-02f, -1.27311468e-01f, -1.22575589e-01f, -1.23908401e-01f, -3.53263575e-03f, 2.49949191e-02f, -3.05230375e-02f, -1.33477360e-01f, 3.09933927e-02f,
  1.05115362e-01f, 4.01221573e-01f, -1.30860088e-02f, 8.54558796e-02f, 1.10221341e-01f, -5.32744499e-03f, 9.89214778e-02f, 3.49194780e-02f, 2.47203320e-01f, 6.96247295e-02f,
  -5.47860097e-03f, 6.45652637e-02f, -7.06654415e-02f, -1.41873620e-02f, 8.38909820e-02f, -8.95955712e-02f, 1.13527656e-01f, 1.83602273e-01f, 1.50622129e-01f, 6.43086731e-02f,
  1.40208956e-02f, -7.37915710e-02f, 8.29096809e-02f, 4.89964187e-02f, -3.23291123e-02f, 1.97648220e-02f, -3.58887054e-02f, -6.63309731e-03f, 1.32969856e-01f, 1.60210818e-01f,
  4.75856841e-01f, 4.54663672e-02f, 3.07462364e-01f, 2.28171781e-01f, 2.45159790e-01f, -3.77174467e-02f, 8.53422806e-02f, 1.39716938e-01f, 1.83906913e-01f, -2.74133444e-01f,
  -1.44829363e-01f, 2.28973195e-01f, -2.24270731e-01f, 5.39220981e-02f, -1.77489728e-01f, -2.16845855e-01f, -1.47328928e-01f, -1.54825523e-01f, 2.16973454e-01f, 1.00628296e-02f,
  3.17073092e-02f, -3.58558744e-01f, 1.38864189e-01f, -2.97749519e-01f, 1.69128999e-01f, 1.63670421e-01f, -4.09093678e-01f, -3.98761630e-02f, -1.89421728e-01f, -1.40241519e-01f,
  6.59696907e-02f, 1.78957626e-01f, 2.58283764e-01f, 1.35656800e-02f, 1.01627558e-01f, 1.20007023e-02f, 7.47447833e-02f, 6.69794008e-02f, 8.16864446e-02f, 6.02592267e-02f,
  5.17119355e-02f, -3.54632847e-02f, -5.15963919e-02f, -6.23866580e-02f, 1.26705855e-01f, 1.42099053e-01f, 1.66272298e-01f, 2.23111629e-01f, 2.38766223e-02f, 2.07896769e-01f,
  2.04739809e-01f, 1.91201791e-01f, 1.55677572e-01f, -1.43325225e-01f, 1.10667765e-01f, 3.94194089e-02f, 2.56646499e-02f, 2.54456364e-02f, 4.00865488e-02f, 1.61100715e-01f,
  -3.30360234e-02f, -6.70035705e-02f, 2.21130066e-02f, 2.14418415e-02f, -9.44502801e-02f, -2.57375706e-02f, 2.24194545e-02f, 5.75789474e-02f, 4.43882309e-02f, -6.65337145e-02f,
  -9.12691504e-02f, 1.60850137e-01f, -9.28484660e-05f, -4.07500844e-03f, -7.46988878e-02f, 1.34782135e-01f, -4.41959128e-02f, -1.28704354e-01f, -1.58507400e-03f, 1.22620324e-02f,
  -6.28997907e-02f, 2.92359535e-02f, -5.38390949e-02f, 9.05878171e-02f, -1.58888936e-01f, -4.63741682e-02f, 5.63270338e-02f, 5.41710109e-02f, 5.54495826e-02f, -9.33252648e-02f,
  -3.33876073e-01f, -6.06923580e-01f, -1.54662766e-02f, 3.31588835e-02f, -1.92142308e-01f, -7.55311027e-02f, 8.14448819e-02f, 8.26435909e-02f, -1.02756917e-01f, -8.88334364e-02f,
  3.20028625e-02f, -5.20437807e-02f, -7.86584318e-02f, 5.17552271e-02f, -5.88735268e-02f, 8.50589052e-02f, -1.37023970e-01f, -1.98786288e-01f, -1.57760624e-02f, -6.09966032e-02f,
  -2.04500277e-02f, 1.40513963e-04f, -2.68374477e-02f, 2.07744185e-02f, -2.94262748e-02f, -8.15370604e-02f, -1.36207879e-01f, -1.51014319e-02f, -1.23256266e-01f, 4.46733125e-02f,
  3.56252864e-02f, 4.74300206e-01f, -3.99217494e-02f, -2.39987761e-01f, -9.16960463e-02f, -3.58828276e-01f, -2.84091949e-01f, -1.07123502e-01f, 1.62511796e-01f, 7.55611435e-02f,
  -2.40737736e-01f, 3.84973109e-01f, 8.87322575e-02f, -2.74438769e-01f, -3.97827566e-01f, -2.16694437e-02f, -3.92000794e-01f, -2.16199234e-01f, 1.44438371e-01f, -1.66076958e-01f,
  1.05961617e-02f, -3.27321351e-01f, -1.36475012e-01f, -9.35846046e-02f, -1.08955838e-01f, 5.47735281e-02f, -3.02979082e-01f, 5.23550063e-03f, -1.90703765e-01f, 8.29954743e-02f,
  -1.82180330e-01f, 6.39220923e-02f, 2.19887309e-02f, -1.20117608e-02f, -2.32137844e-01f, -9.17572901e-02f, -5.79435229e-02f, -4.60912883e-02f, -7.13583902e-02f, 2.81730983e-02f,
  1.03249989e-01f, 1.35283723e-01f, -5.19062355e-02f, 1.24347515e-01f, 5.94960079e-02f, 2.83205956e-02f, -9.38005839e-03f, -1.09876297e-01f, 8.43828321e-02f, 1.18909508e-01f,
  1.52063686e-02f, 3.90529633e-02f, -1.41128823e-01f, 1.53479548e-02f, 4.32074852e-02f, -5.85363284e-02f, -9.15895253e-02f, 2.00830445e-01f, 9.35420766e-02f, 1.28904134e-02f,
  -5.03626652e-02f, -1.46526203e-01f, -7.68000633e-02f, -2.00305060e-02f, -5.70339896e-02f, 5.63800931e-02f, -1.99960684e-03f, -4.00145017e-02f, 2.33836286e-02f, -7.54877850e-02f,
  -8.50652251e-03f, 8.03216696e-02f, -2.59279627e-02f, -1.41586795e-01f, -7.69372210e-02f, -1.89318252e-03f, -7.85111412e-02f, 7.41525441e-02f, 7.05705434e-02f, 5.26285879e-02f,
  5.86796040e-03f, -1.37739748e-01f, 3.46512012e-02f, 4.25078459e-02f, -9.97360721e-02f, -4.08255123e-02f, -3.91230732e-02f, 1.40459940e-01f, -5.24378605e-02f, -8.73965472e-02f,
  -2.78014690e-01f, -3.82339448e-01f, 2.34337039e-02f, 1.32569090e-01f, 3.36685516e-02f, -4.67920350e-03f, -2.11205687e-02f, 9.41401944e-02f, -1.94293603e-01f, -1.07148796e-01f,
  -6.47707880e-02f, -1.22692073e-02f, -1.13981545e-01f, 7.87380040e-02f, -1.68901123e-02f, -1.07589081e-01f, -1.37030154e-01f, -3.63779441e-02f, -1.70088097e-01f, 7.47068822e-02f,
  9.69402306e-03f, 2.21230672e-03f, -2.45998632e-02f, -7.29441196e-02f, 7.65312240e-02f, -7.92295784e-02f, 8.76754224e-02f, 1.86692178e-01f, -1.50124446e-01f, 5.05269356e-02f,
  -2.66931921e-01f, 4.64471467e-02f, -1.58818334e-01f, -3.54708612e-01f, 1.24605112e-02f, -4.72238183e-01f, -3.42943609e-01f, 7.52979144e-02f, 1.32209420e-01f, 1.66274622e-01f,
  1.15279436e-01f, 1.63750976e-01f, 2.73940176e-01f, -1.89945683e-01f, -2.75552988e-01f, 4.73377407e-02f, -3.62874895e-01f, -2.34279022e-01f, -2.17742709e-04f, -1.36707097e-01f,
  -1.71928391e-01f, -4.44991179e-02f, -9.98951495e-02f, 1.56327769e-01f, -2.62378484e-01f, -1.03189766e-01f, -3.72614190e-02f, 3.12169850e-01f, -2.48223275e-01f, 8.98433328e-02f,
  -5.20002730e-02f, 2.54581153e-01f, 7.37569407e-02f, 1.16196252e-01f, -9.74615961e-02f, -9.73138660e-02f, -1.25855997e-01f, 7.68128783e-02f, 5.66577017e-02f, -7.75838643e-03f,
  3.33421603e-02f, 5.90798445e-02f, -1.21824928e-01f, 4.95268330e-02f, 9.49013904e-02f, 5.55359274e-02f, -6.49974719e-02f, -8.92981887e-02f, 5.52324131e-02f, 4.49171513e-02f,
  -4.44010273e-02f, -8.32938962e-03f, -1.52798101e-01f, -4.55654673e-02f, -4.23863381e-02f, 2.77528521e-02f, -1.29970551e-01f, 1.11446446e-02f, -1.28205568e-01f, -1.02034673e-01f,
  -5.51467389e-02f, -1.90715045e-01f, 6.34294972e-02f, -2.49241926e-02f, -2.41119545e-02f, 1.43850848e-01f, 5.32567687e-02f, -1.29732508e-02f, 2.76804585e-02f, -1.96917336e-02f,
  -5.10552973e-02f, -4.88282517e-02f, -1.64513215e-02f, -1.25622362e-01f, 1.33615686e-02f, 2.26407908e-02f, 2.98609994e-02f, 1.72177017e-01f, -1.44630745e-01f, -1.29444703e-01f,
  1.12623416e-01f, -9.32201073e-02f, 1.08219862e-01f, -1.05752379e-01f, -7.53643736e-02f, 1.26038110e-02f, 8.58966820e-03f, 6.65534139e-02f, 9.84427147e-03f, -1.02471545e-01f,
  -1.58520535e-01f, 7.71329552e-02f, 1.50882900e-01f, 7.56502822e-02f, 5.19602327e-05f, -1.87529121e-02f, -9.02520567e-02f, -9.57015604e-02f, -6.98438473e-03f, 5.26567809e-02f,
  -5.63250929e-02f, -7.30923042e-02f, -1.38843849e-01f, 1.01037920e-01f, -9.68462676e-02f, -1.81574315e-01f, 2.24239826e-02f, 8.49572569e-02f, -1.05482504e-01f, 1.00339167e-02f,
  2.85317488e-02f, 7.63583481e-02f, -4.63415198e-02f, -1.01691827e-01f, 2.43733283e-02f, 1.14937350e-02f, -4.60237302e-02f, -2.41897833e-02f, 2.81403568e-02f, 1.44301653e-02f,
  1.46387219e-01f, -3.14188749e-01f, -3.60681385e-01f, -1.85462594e-01f, -3.98310572e-01f, -2.77843416e-01f, -3.52430344e-01f, -2.68144071e-01f, 1.40910521e-02f, 8.36169645e-02f,
  -1.62126809e-01f, 2.17015147e-01f, 1.46297634e-01f, -2.08345905e-01f, 3.00754160e-01f, 3.19061905e-01f, 4.06120680e-02f, 1.51409462e-01f, 5.79710789e-02f, -1.82450309e-01f,
  -1.09598227e-01f, -1.45088315e-01f, -6.07258715e-02f, -2.24185854e-01f, -4.37791765e-01f, -2.27566808e-01f, 1.35926917e-01f, -3.43303591e-01f, -2.34160721e-01f, -1.94823712e-01f,
  -1.41328663e-01f, -1.44740403e-01f, -1.10896155e-01f, 1.13198295e-01f, -1.35325223e-01f, -8.77079368e-02f, -1.47852466e-01f, -3.66181657e-02f, 6.57452717e-02f, -5.77503555e-02f,
  1.29586533e-01f, 1.72422364e-01f, 1.74817871e-02f, 1.28647521e-01f, -3.37514915e-02f, -6.45375624e-02f, -1.27557414e-02f, 6.06122203e-02f, -1.36369884e-01f, 3.99123095e-02f,
  -3.39588081e-03f, -8.15156698e-02f, -2.04204962e-01f, 1.10028431e-01f, -9.43872109e-02f, -4.93184589e-02f, -2.53712572e-02f, -1.01065360e-01f, 4.66220416e-02f, -3.84583771e-02f,
  -4.89241257e-02f, -4.85833101e-02f, -4.36676629e-02f, 4.44411077e-02f, 1.09057836e-01f, -1.33423032e-02f, 7.35491440e-02f, -2.14251541e-02f, -6.08496973e-03f, -1.19167790e-01f,
  -1.07330456e-01f, -3.98200154e-02f, 4.38004211e-02f, 2.96175666e-02f, -3.59743042e-03f, 7.35984072e-02f, -3.98474522e-02f, -1.80729590e-02f, 5.23186568e-03f, 1.21207982e-02f,
  -5.72320595e-02f, 9.79827419e-02f, 5.38999587e-02f, 2.04651989e-03f, 1.53425392e-02f, 2.70527005e-02f, -5.44188097e-02f, 2.01950825e-04f, -6.63869604e-02f, -7.43935704e-02f,
  -4.67365347e-02f, -2.46414483e-01f, 1.81120206e-02f, 1.64904557e-02f, 9.03234258e-03f, 2.07605083e-02f, -1.66984797e-02f, -5.30787185e-02f, -1.26876444e-01f, -8.97859633e-02f,
  1.70451880e-01f, 1.73425213e-01f, -1.15899995e-01f, -4.43714745e-02f, 1.06562555e-01f, -2.54964735e-02f, 7.98602477e-02f, 6.98524639e-02f, -2.49766372e-02f, 4.89897020e-02f,
  -3.39722782e-02f, 5.36551774e-02f, 1.51065841e-01f, 2.11923802e-03f, 6.23229705e-02f, 1.09185658e-01f, 4.91906144e-02f, -7.38476217e-02f, -5.01647666e-02f, 3.85116450e-02f,
  3.84332716e-01f, 2.36156985e-01f, 5.91233671e-02f, 3.30897897e-01f, 2.99986780e-01f, 3.68332475e-01f, 4.08185333e-01f, 3.00943375e-01f, 5.44117808e-01f, -2.34495569e-02f,
  -1.47551835e-01f, 1.90931693e-01f, -3.06259304e-01f, 1.89104304e-01f, -2.53384411e-01f, -1.80141702e-01f, 4.39526528e-01f, 3.50984633e-01f, 3.40790719e-01f, 1.47890642e-01f,
  5.36811426e-02f, -1.39821008e-01f, -3.72472167e-01f, -1.37435868e-01f, 1.20673299e-01f, -6.17902838e-02f, -4.43257332e-01f, -8.75146911e-02f, -2.20758855e-01f, 9.55177173e-02f,
  2.34738979e-02f, 9.93505046e-02f, 4.78818342e-02f, -6.38335571e-02f, 3.92615702e-03f, -7.44938850e-02f, -1.48343146e-01f, -3.68823893e-02f, -3.49660330e-02f, 1.01552829e-01f,
  1.96828432e-02f, -1.81121796e-01f, 4.67542224e-02f, -4.17494774e-02f, 1.69027850e-01f, 5.22579066e-02f, 8.92181136e-03f, 8.95883664e-02f, -2.19631363e-02f, -8.15717056e-02f,
  -7.91852549e-02f, 5.62305041e-02f, 4.22583781e-02f, 1.00772373e-01f, -8.06864724e-02f, 4.93213572e-02f, 2.06761640e-02f, 3.86082605e-02f, 1.30140493e-02f, 1.08916447e-01f,
  -1.50760915e-02f, 1.24908976e-01f, -1.99554637e-02f, -4.29469608e-02f, 7.86254779e-02f, 1.66410822e-02f, 7.50972182e-02f, 3.18213366e-02f, 5.33935167e-02f, 2.57483590e-02f,
  1.36504009e-01f, 6.45072088e-02f, 1.48873091e-01f, 9.78079587e-02f, 1.54750183e-01f, 1.28437504e-01f, -2.15281621e-02f, 2.75161490e-02f, 1.89917788e-01f, -2.11710967e-02f,
  -3.16217132e-02f, 3.64221558e-02f, -5.49463630e-02f, -7.50970989e-02f, -1.25927702e-02f, -2.50269584e-02f, -4.56139119e-03f, -5.46128303e-02f, 1.20051550e-02f, -3.27233300e-02f,
  2.15674639e-01f, 3.10556322e-01f, 4.46485579e-02f, -9.80843417e-03f, -4.02887389e-02f, -2.70340685e-02f, 4.99667451e-02f, 1.47940949e-01f, 1.24108166e-01f, 1.78338755e-02f,
  -4.60523069e-02f, 2.40837839e-02f, 4.93836254e-02f, -1.34637594e-01f, -1.29475653e-01f, 1.00048363e-01f, -8.65668207e-02f, 4.95799705e-02f, 3.59038636e-02f, -5.24601489e-02f,
  8.99002980e-03f, 7.96519518e-02f, 2.78696604e-03f, 1.83816940e-01f, 1.45128727e-01f, -4.86555658e-02f, 1.59639880e-01f, -1.65107977e-02f, -1.02764472e-01f, 8.88391361e-02f,
  -5.58509767e-01f, 4.46668603e-02f, -8.13695118e-02f, -4.21360373e-01f, 2.08723858e-01f, -4.32866486e-03f, -1.02171518e-01f, 2.04313785e-01f, -9.36016254e-03f, 2.53179044e-01f,
  4.52097692e-02f, -4.41710502e-01f, 2.71737695e-01f, -3.67102742e-01f, -2.05182329e-01f, -3.13198239e-01f, -2.46179864e-01f, -3.40474069e-01f, -6.27612174e-02f, -1.34760484e-01f,
  -2.58067012e-01f, -1.28260702e-01f, -1.31375372e-01f, 4.73625213e-01f, -1.45866260e-01f, 1.20920151e-01f, 1.98658332e-01f, 3.21647495e-01f, -1.24606088e-01f, -3.88564318e-02f,
  8.61597136e-02f, -1.59691162e-02f, 9.91530269e-02f, 7.77715370e-02f, 1.29518420e-01f, 1.77930016e-02f, -1.34555437e-02f, 2.20449213e-02f, 8.40125456e-02f, 5.30412160e-02f,
  -6.18796684e-02f, -3.47611941e-02f, -1.35320574e-01f, -1.54260974e-02f, 3.72591950e-02f, 6.65948614e-02f, -1.98081024e-02f, 1.12751890e-02f, 1.52735695e-01f, -2.51871407e-01f,
  2.57880855e-02f, -4.46658172e-02f, -1.22683108e-01f, -8.10405090e-02f, -3.55470888e-02f, 5.35589317e-03f, -1.96396410e-02f, -1.47829279e-01f, -2.90760007e-02f, -7.01728538e-02f,
  -1.12622194e-01f, -1.18500264e-02f, 7.13077337e-02f, 7.98615590e-02f, 1.32738287e-02f, 9.45669413e-02f, -2.75543961e-03f, -3.30851115e-02f, -2.89225392e-03f, -8.65380764e-02f,
  1.07639745e-01f, -9.58142430e-02f, -5.09515479e-02f, -2.13042293e-02f, -1.89395025e-01f, -3.92442010e-02f, 4.43714531e-03f, -5.22950999e-02f, -5.93041144e-02f, 8.85360241e-02f,
  1.30777266e-02f, 1.24454191e-02f, 9.27296653e-02f, 1.37553260e-01f, 1.63808748e-01f, -1.36388163e-03f, -8.89889300e-02f, -6.82344288e-02f, 4.00415435e-02f, 1.90123878e-02f,
  7.06489757e-02f, -6.20869249e-02f, 1.32175490e-01f, 1.91357940e-01f, 5.76525703e-02f, -4.03225794e-02f, -5.83209470e-02f, -7.79641941e-02f, 9.95860919e-02f, -5.89941218e-02f,
  -1.94071643e-02f, 1.33840945e-02f, 9.62450281e-02f, -1.26534998e-01f, 8.51229504e-02f, -4.47169133e-02f, 2.28406042e-02f, 7.12511092e-02f, 1.80181712e-01f, 2.18050014e-02f,
  7.90740997e-02f, 3.37849595e-02f, 4.44313958e-02f, 1.18710637e-01f, -7.00776204e-02f, 1.65507030e-02f, -7.83776641e-02f, -1.71655379e-02f, -5.02297580e-02f, 1.54773016e-02f,
  -6.01244390e-01f, -3.36748809e-02f, 2.78073758e-01f, 2.12130129e-01f, -7.88511112e-02f, -3.06273192e-01f, -4.29003716e-01f, -2.39565000e-01f, -1.76661849e-01f, -3.41966867e-01f,
  -3.84528071e-01f, 2.63197005e-01f, -4.67085391e-01f, 3.17985862e-01f, 3.97993952e-01f, -1.36306763e-01f, 3.15205038e-01f, 8.62600058e-02f, 2.82866538e-01f, 2.05550045e-01f,
  2.77810186e-01f, 2.30376363e-01f, 4.67018545e-01f, 4.80203748e-01f, 2.24612877e-01f, 2.79277712e-01f, 2.40642756e-01f, 4.01226580e-01f, 3.97423178e-01f, 2.19271392e-01f,
  -2.34645888e-01f, -6.45738468e-02f, -2.86999419e-02f, -4.66318950e-02f, -1.11251086e-01f, -1.18836932e-01f, 4.10210043e-02f, 2.45520324e-02f, -4.86709969e-03f, 1.10452240e-02f,
  -4.52538282e-02f, 1.59538373e-01f, 5.43749593e-02f, 2.50460450e-02f, -1.10436253e-01f, 1.96608484e-01f, 1.13882370e-01f, -7.13342577e-02f, 3.39151509e-02f, -8.03471431e-02f,
  5.72798178e-02f, -1.07006572e-01f, -1.26125842e-01f, 9.19557065e-02f, 7.90922642e-02f, -8.27713311e-02f, 1.61186337e-01f, 8.15339088e-02f, 9.43821818e-02f, 1.16838574e-01f,
  -4.22891714e-02f, -2.24357937e-03f, 4.24860511e-03f, -1.53992949e-02f, -7.05109350e-03f, -7.93896616e-02f, -1.25318365e-02f, 1.99622586e-02f, 6.63251728e-02f, -1.59422100e-01f,
  4.22150036e-03f, 1.18203245e-01f, 3.22120599e-02f, -1.05883971e-01f, -4.87906449e-02f, -6.76368102e-02f, 6.47046417e-02f, 1.06008723e-01f, 3.68207805e-02f, 1.36430375e-02f,
  -6.27417490e-02f, 7.27134347e-02f, 8.98980498e-02f, 7.28216663e-04f, -1.60675362e-01f, -9.70460847e-02f, -5.37776910e-02f, -3.97600885e-03f, -1.74815338e-02f, 3.76373939e-02f,
  -2.90759563e-01f, 1.77816451e-01f, 2.50268113e-02f, -7.07679689e-02f, -1.50581283e-04f, -1.87382065e-02f, 6.29310012e-02f, 7.40264505e-02f, 3.82957868e-02f, -3.11199501e-02f,
  -1.50457099e-01f, 6.54698685e-02f, -8.27044696e-02f, -2.38411054e-02f, 1.74185351e-01f, -8.52712989e-02f, -3.17255966e-02f, -1.17791839e-01f, 2.95061637e-02f, 9.06166583e-02f,
  -3.08537427e-02f, -6.23321570e-02f, 1.46868899e-01f, 1.32318899e-01f, -1.25377014e-01f, -1.09448656e-01f, -4.13759686e-02f, -1.15368888e-02f, 1.74928922e-02f, -4.23870422e-02f,
  -3.55715662e-01f, 3.55230182e-01f, 3.31536263e-01f, 1.46828473e-01f, -3.37569058e-01f, -2.69269615e-01f, -8.18051174e-02f, -9.11985859e-02f, 1.16069660e-01f, 3.68208855e-01f,
  -2.07249392e-02f, 3.17458212e-02f, 1.91778645e-01f, 4.18558449e-01f, -1.10650800e-01f, 3.30512464e-01f, 3.55589062e-01f, 2.45404556e-01f, 4.09311205e-02f, -1.64837409e-02f,
  1.10905908e-01f, -1.28139600e-01f, 3.49834323e-01f, -2.34468058e-02f, 1.31452441e-01f, 1.22179165e-01f, 1.94428369e-01f, -1.15580810e-02f, 3.07636321e-01f, -1.73278481e-01f,
  1.34916186e-01f, -2.08064150e-02f, 1.44516826e-01f, 1.20901138e-01f, 1.32212117e-01f, -8.88105258e-02f, 7.41260052e-02f, 4.26936634e-02f, -1.46752775e-01f, 7.44216591e-02f,
  -1.85949102e-01f, 1.08371908e-02f, 8.51134956e-02f, -6.67696595e-02f, -2.23892793e-01f, -5.37658902e-03f, 8.96095484e-02f, 1.16922833e-01f, 9.46832597e-02f, -1.27530200e-02f,
  7.37771913e-02f, 2.65116394e-01f, 5.19617312e-02f, 1.71242788e-01f, -2.91413106e-02f, -2.24310886e-02f, 1.11509390e-01f, 5.12134023e-02f, 1.35561138e-01f, 4.95242849e-02f,
  -1.57892391e-01f, 1.51178017e-01f, 1.53602418e-02f, 1.91377059e-01f, -3.56342667e-03f, -2.97371391e-02f, -1.16439991e-01f, 4.83628400e-02f, -9.26358476e-02f, 1.99504614e-01f,
  9.78240371e-02f, -3.88545799e-03f, -1.02080062e-01f, 8.97169858e-02f, -9.75939073e-03f, 4.21287082e-02f, -6.61509186e-02f, -1.31717905e-01f, 7.94304418e-04f, 3.88538465e-02f,
  3.36397700e-02f, -6.40610754e-02f, 8.00075755e-02f, -2.31670719e-02f, -1.39911305e-02f, 1.03590442e-02f, 1.32572040e-01f, 3.73621620e-02f, 7.37204924e-02f, -1.07381292e-01f,
  4.20570821e-02f, -3.31946388e-02f, 1.33578286e-01f, 1.02600202e-01f, 1.18751839e-01f, 9.62276682e-02f, -7.07633793e-03f, 5.10194898e-02f, -1.89138930e-02f, -1.08939976e-01f,
  -6.08228706e-02f, 2.09065657e-02f, 2.19422597e-02f, -1.73452884e-01f, -8.90458841e-03f, 3.97432148e-02f, 6.18961006e-02f, 3.29047367e-02f, -5.30919693e-02f, 9.83436033e-02f,
  -5.92128858e-02f, -3.97887118e-02f, -5.63418865e-02f, 1.27011901e-02f, 3.48232430e-03f, 2.37709992e-02f, -1.66603565e-01f, 8.75963718e-02f, 2.24719848e-02f, 6.30066767e-02f,
  -3.19839239e-01f, 4.66321319e-01f, -1.03335172e-01f, 2.90652245e-01f, -4.01522696e-01f, 2.67418116e-01f, 4.82164502e-01f, -1.17896050e-01f, 2.36089692e-01f, 4.29325014e-01f,
  -9.89113674e-02f, 1.52058765e-01f, 4.52197753e-02f, 3.36380512e-01f, 2.53493160e-01f, 3.23795080e-01f, 3.82135481e-01f, 2.01364666e-01f, 5.82561307e-02f, 1.15023151e-01f,
  7.47701228e-02f, 3.42458159e-01f, -6.10137060e-02f, -7.37757161e-02f, -1.00894108e-01f, -1.24205835e-01f, -7.81990215e-02f, -2.35836610e-01f, 9.48579609e-02f, -1.88138671e-02f,
  3.36005837e-02f, -4.46148999e-02f, -8.75891652e-03f, -2.78074536e-02f, -5.06578386e-02f, -8.73697698e-02f, -6.42729327e-02f, -9.73291844e-02f, 2.25259014e-03f, 5.24821766e-02f,
  1.11511294e-02f, 4.61161975e-03f, 1.66439787e-01f, 7.26951733e-02f, -7.50705302e-02f, -9.61103961e-02f, -4.05450240e-02f, -5.20674326e-02f, 1.06308833e-01f, -1.09661631e-01f,
  -8.35325941e-02f, 3.79097052e-02f, -6.15610629e-02f, 1.81876451e-01f, -4.28604409e-02f, 7.06084743e-02f, 9.11553577e-02f, -8.73853192e-02f, 1.43755004e-02f, 1.26879588e-01f,
  2.10233834e-02f, 1.42208174e-01f, -6.19328767e-02f, 1.51258148e-03f, 9.01686922e-02f, 1.65723860e-02f, 6.88871518e-02f, 1.22241545e-02f, 2.86330264e-02f, 1.17632570e-02f,
  3.32639702e-02f, -9.37812924e-02f, -5.82263945e-03f, 7.11830482e-02f, 3.97503516e-03f, -4.55452641e-03f, -1.38978451e-01f, 4.39934134e-02f, -2.44412795e-02f, -7.66931474e-02f,
  3.59397866e-02f, 4.68358845e-02f, 6.11244142e-02f, -1.02600403e-01f, 3.56789865e-02f, -8.36740285e-02f, -4.85794758e-03f, -3.77958342e-02f, -4.76659238e-02f, -3.14568020e-02f,
  2.10468024e-01f, 4.03164506e-01f, 6.76541775e-02f, 7.04202652e-02f, 1.71810910e-01f, 1.61298108e-03f, 4.24487367e-02f, 2.24607587e-02f, 3.82266790e-02f, 7.11760670e-02f,
  -5.08690029e-02f, 9.19504613e-02f, -2.64753867e-02f, -1.08670220e-01f, 1.38144210e-01f, 7.11576045e-02f, 1.64870486e-01f, -2.25681160e-02f, 1.33739905e-02f, 2.05229018e-02f,
  1.05088660e-02f, 9.78360791e-03f, 4.14015539e-02f, -5.48135713e-02f, 1.39552141e-02f, -3.92785966e-02f, 2.47968454e-03f, -8.50955099e-02f, -8.22258368e-02f, 1.03311472e-01f,
  -6.05361283e-01f, -1.32260501e-01f, 2.62311310e-01f, -1.12210006e-01f, -2.69938409e-01f, 1.21685900e-01f, 4.90086287e-01f, -3.87718439e-01f, -3.63612175e-01f, -4.93796058e-02f,
  1.10766426e-01f, 3.22206225e-03f, 5.40301800e-01f, 3.31229456e-02f, 2.63031542e-01f, 5.09504616e-01f, -1.29453940e-02f, 1.88207477e-01f, -1.81008801e-01f, -2.98602432e-02f,
  3.70846130e-02f, -1.06436186e-01f, 4.57729101e-01f, -3.26026648e-01f, -1.38317585e-01f, -1.68895558e-01f, 6.88048825e-02f, 2.24945575e-01f, -2.15309441e-01f, -2.62724515e-02f,
  -2.11156327e-02f, -2.98720390e-01f, 1.23120613e-01f, 8.60523258e-04f, 1.73960254e-03f, 9.76949930e-02f, 1.19150609e-01f, 1.57423034e-01f, 9.59405974e-02f, 1.24814846e-01f,
  5.53330854e-02f, -1.86192930e-01f, -1.52982697e-01f, 1.17191290e-02f, -1.73825294e-01f, -7.26331919e-02f, -1.75253749e-01f, -1.78529252e-03f, 1.40714664e-02f, -3.26983817e-02f,
  5.88267706e-02f, -3.49841341e-02f, 2.50178063e-03f, 1.05259784e-01f, 9.21251252e-03f, -1.56522706e-01f, 3.54328305e-02f, 1.21729940e-01f, -2.08074283e-02f, -1.34293661e-01f,
  -1.40324324e-01f, 1.69827461e-01f, 1.34502247e-01f, 5.82352243e-02f, -1.18290596e-01f, -4.69663031e-02f, 1.56907991e-01f, 5.81920892e-02f, -2.21682519e-01f, -1.39539484e-02f,
  -2.19537653e-02f, 4.33445424e-02f, -5.37041612e-02f, -5.34758437e-03f, -1.17958680e-01f, -1.65245924e-02f, 1.31336749e-01f, 1.18281860e-02f, 2.42789043e-03f, -6.82014748e-02f,
  -8.21266919e-02f, -5.78180999e-02f, -7.69714685e-03f, 1.72610343e-01f, 1.22521073e-01f, -5.34682758e-02f, 5.60873887e-05f, 3.15282941e-02f, 6.46193102e-02f, 2.00032428e-01f,
  -1.06400894e-02f, -3.25052977e-01f, 5.88014303e-03f, 3.11758071e-02f, 1.26062244e-01f, -1.55476853e-01f, -1.08051613e-01f, -1.45904273e-01f, 1.13096030e-03f, 1.28588816e-02f,
  -7.37122446e-02f, 7.09825605e-02f, 5.22813722e-02f, 1.00902125e-01f, -7.68000558e-02f, -9.53070298e-02f, 3.28230299e-02f, 1.16600588e-01f, 1.07133716e-01f, -1.31395191e-01f,
  7.74863511e-02f, 4.68557235e-03f, -4.30510975e-02f, -4.11112048e-02f, -3.38072404e-02f, -6.82432018e-03f, -2.09192798e-01f, -8.15544426e-02f, 5.59949428e-02f, 2.32501011e-02f,
  -5.89305520e-01f, 2.18385435e-03f, -1.31740803e-02f, -4.21638310e-01f, -2.97726057e-02f, 4.65011112e-02f, 7.77707398e-02f, -2.26820290e-01f, -2.17519417e-01f, -6.84717745e-02f,
  -4.09915894e-02f, 3.74905579e-02f, 4.41845536e-01f, -2.00922087e-01f, 2.61819690e-01f, 3.35326344e-01f, -2.49361902e-01f, -1.32967427e-01f, -2.49599610e-02f, -2.76379764e-01f,
  -1.70293465e-01f, -2.31547937e-01f, 1.58733875e-01f, -2.17511311e-01f, -3.47062647e-01f, -3.14796507e-01f, -1.14042312e-01f, 1.16975307e-01f, -3.57838333e-01f, 4.05509993e-02f,
  -4.85573053e-01f, -3.86759669e-01f, -1.08144611e-01f, -1.35348782e-01f, -1.19112290e-01f, -2.39630081e-02f, -2.08872072e-02f, 1.95008889e-01f, 3.19472887e-02f, -6.89839944e-03f,
  3.62995751e-02f, -2.39549484e-02f, -1.87093273e-01f, 1.01241097e-01f, -1.13248728e-01f, -1.16133280e-01f, 4.32305969e-02f, -3.24027725e-02f, -3.78883095e-03f, 5.94110303e-02f,
  -6.76880358e-03f, -3.79604138e-02f, -1.44882783e-01f, -9.49411988e-02f, -2.16209292e-02f, -1.44143745e-01f, 2.76978384e-03f, -1.31515227e-02f, -2.02211946e-01f, -1.10765316e-01f,
  1.19178198e-01f, 1.57151237e-01f, -4.76204641e-02f, 5.23722097e-02f, -3.60200158e-03f, -4.25041690e-02f, -3.30680795e-02f, 5.73671274e-02f, 2.98413876e-02f, -1.96634177e-02f,
  -3.22695710e-02f, -4.10150662e-02f, -1.33187950e-01f, -1.35525703e-01f, -5.81365302e-02f, -1.76512804e-02f, 1.24021940e-01f, -8.42228085e-02f, -4.95807044e-02f, -3.89917158e-02f,
  4.45492864e-02f, -2.00344473e-02f, -9.61766094e-02f, 4.90349606e-02f, -9.07675773e-02f, 1.12020388e-01f, -8.24078694e-02f, -9.44759026e-02f, -9.80889201e-02f, 8.20832029e-02f,
  -3.95693779e-01f, -4.52484757e-01f, 3.48293073e-02f, -1.48160368e-01f, 4.59915362e-02f, 1.89004429e-02f, -1.25882272e-02f, -7.73575902e-02f, -1.03540145e-01f, -1.00287519e-01f,
  -1.15153313e-01f, 2.43445579e-03f, -1.31077111e-01f, 2.57706437e-02f, 9.96229798e-02f, 3.87801714e-02f, 1.13180265e-01f, -1.19431309e-01f, -3.37774754e-02f, -1.14416763e-01f,
  7.11761937e-02f, 7.52670020e-02f, 1.13547310e-01f, -1.74209163e-01f, -7.88150355e-03f, -1.04203843e-01f, 1.92220751e-02f, 5.03038801e-02f, -4.42422666e-02f, -2.50300653e-02f,
  -2.15639398e-01f, 4.10643607e-01f, -4.56905067e-02f, -9.23253149e-02f, 7.56297400e-03f, 4.43942398e-01f, 2.96905935e-01f, 3.93670239e-02f, 1.61125988e-01f, 3.13244939e-01f,
  2.14587510e-01f, -1.91515267e-01f, 2.05498248e-01f, 2.42790490e-01f, 1.80238441e-01f, 3.24844450e-01f, 3.19312453e-01f, 2.30012596e-01f, -4.69870903e-02f, -2.20067307e-01f,
  -1.08175196e-01f, 1.31796941e-01f, -1.27422914e-01f, -5.74668944e-02f, 1.04240305e-03f, -2.24057034e-01f, -3.11801940e-01f, -3.11384082e-01f, 6.18800633e-02f, 6.53847158e-02f,
  5.65477721e-02f, -6.06341586e-02f, -4.24799286e-02f, 2.21122671e-02f, 9.23155695e-02f, 2.99800616e-02f, -8.18262529e-03f, -5.72017506e-02f, -1.72974154e-01f, -6.08933531e-02f,
  -1.31373992e-02f, -5.44668734e-02f, 7.84835070e-02f, -9.46165547e-02f, -9.53807011e-02f, -1.42658968e-02f, -8.97680968e-02f, 1.90535504e-02f, -1.19362071e-01f, -6.24087155e-02f,
  -1.54996201e-01f, -1.12983501e-02f, -6.46650940e-02f, -1.30795790e-02f, -4.66223620e-02f, 8.00092071e-02f, 1.15480274e-01f, -4.25314046e-02f, 1.10581741e-01f, 3.62040028e-02f,
  -7.41396248e-02f, 1.66672915e-01f, 3.31211537e-02f, 7.10942671e-02f, 5.24439029e-02f, 8.21319148e-02f, -1.33443680e-02f, -3.33338790e-02f, 6.45069359e-03f, -5.04468307e-02f,
  -8.47061351e-02f, -4.56803553e-02f, -5.65927699e-02f, -1.68213416e-02f, -1.61185991e-02f, 2.34230012e-02f, -8.28108471e-03f, -2.08926499e-02f, -9.53474119e-02f, -3.23304124e-02f,
  -7.01739341e-02f, -2.62800194e-02f, 4.75803018e-03f, 6.11000024e-02f, 9.27899927e-02f, -7.71047696e-02f, 7.46119544e-02f, 4.89617251e-02f, -4.68884781e-02f, 5.57006747e-02f,
  2.62882352e-01f, 3.28538716e-01f, 4.18188870e-02f, -8.36725757e-02f, -3.75029743e-02f, 1.48227334e-01f, 1.44588992e-01f, 6.86430708e-02f, 1.00281388e-01f, 1.34450063e-01f,
  3.76635194e-02f, 6.73362464e-02f, -3.19900215e-02f, -9.87910405e-02f, -9.14460048e-02f, 1.19570578e-02f, -3.23717147e-02f, 1.64384041e-02f, 4.12779003e-02f, -7.72851184e-02f,
  -5.74210957e-02f, -1.65792983e-02f, -6.69138655e-02f, 8.98927748e-02f, 9.93788894e-03f, -1.09941009e-02f, 7.46048870e-04f, -1.10092804e-01f, 3.50903533e-02f, 8.26273188e-02f,
  3.71836066e-01f, -2.64373511e-01f, -2.76649088e-01f, 1.02580488e-01f, -2.99387038e-01f, 2.60170192e-01f, 4.65139717e-01f, -1.01265952e-01f, 3.31811875e-01f, 2.11038411e-01f,
  1.52226225e-01f, 1.70656830e-01f, 3.06258887e-01f, 1.44969612e-01f, 3.41953933e-01f, 3.76687527e-01f, 3.51366252e-01f, 2.97881275e-01f, -6.77880496e-02f, 1.51107818e-01f,
  2.34623086e-02f, 2.86781907e-01f, -1.37953103e-01f, -2.22112283e-01f, -2.26909265e-01f, -4.06319946e-01f, -3.10274869e-01f, -3.00052464e-01f, -3.33285809e-01f, -1.47399053e-01f,
  3.74896862e-02f, -6.29374310e-02f, -5.66561706e-02f, -1.59325730e-02f, -7.74621740e-02f, -6.93229958e-03f, 7.99233913e-02f, 6.96042106e-02f, -5.18192723e-02f, 6.90550357e-02f,
  1.28314480e-01f, 2.16868576e-02f, 8.63249525e-02f, -1.19459555e-01f, 4.90611121e-02f, -2.03642637e-01f, -1.16499260e-01f, -1.42333796e-02f, 2.46047080e-02f, -5.47107272e-02f,
  -1.89973426e-03f, -4.42659631e-02f, 2.68548937e-03f, 1.00357994e-01f, -8.89183208e-02f, -1.24517307e-02f, 9.79406610e-02f, 1.03599001e-02f, 5.94305098e-02f, 9.62794945e-02f,
  -7.09336847e-02f, 1.25013694e-01f, 6.84567615e-02f, 5.63528202e-02f, -6.90834299e-02f, -1.66062117e-01f, 8.89426619e-02f, 6.00646660e-02f, 4.95094657e-02f, 3.71760465e-02f,
  3.09552047e-02f, -8.03425312e-02f, -4.08143848e-02f, 4.20466587e-02f, 7.52268732e-02f, 1.03202164e-01f, 4.88246717e-02f, -6.65966272e-02f, 2.00543888e-02f, -6.11797236e-02f,
  1.21417444e-03f, 3.47269215e-02f, -1.65451672e-02f, -5.93257695e-02f, -3.99886481e-02f, 4.15752083e-02f, 2.32137293e-02f, -1.24499695e-02f, -9.59771033e-03f, 9.33182091e-02f,
  6.33068010e-02f, 1.37298897e-01f, 1.77482348e-02f, -5.41405519e-03f, -8.67922381e-02f, -6.13633879e-02f, 2.34636255e-02f, 4.12605144e-02f, 2.57109273e-02f, 1.65602371e-01f,
  -6.18300661e-02f, 6.41822815e-02f, -6.41730726e-02f, -2.90989410e-02f, -3.64232026e-02f, 5.11910804e-02f, 1.20866358e-01f, -1.04186751e-01f, 2.09857766e-02f, -1.47320732e-01f,
  -8.64538252e-02f, 1.53546751e-01f, 6.64755031e-02f, 1.01414388e-02f, -5.43336384e-02f, -1.57840569e-02f, -3.64671648e-02f, -1.21941589e-01f, 1.92290079e-02f, 8.96580219e-02f,
  2.22083315e-01f, -2.84418225e-01f, 3.00476313e-01f, -3.46474349e-01f, 2.34105647e-01f, 3.23689669e-01f, 2.99766690e-01f, -3.35399210e-01f, -2.91911185e-01f, -4.65047240e-01f,
  -2.05339476e-01f, -2.05607295e-01f, 2.83031851e-01f, -3.26333553e-01f, 5.86214364e-01f, 1.67208508e-01f, -3.57143879e-01f, -3.82556230e-01f, -5.87318949e-02f, -3.27950746e-01f,
  -1.14643514e-01f, -3.95806968e-01f, 1.01372391e-01f, -4.15470600e-01f, -1.95352629e-01f, -2.98621356e-01f, -8.53252634e-02f, 1.05707332e-01f, -3.51587325e-01f, 1.11574315e-01f,
  1.74310237e-01f, -1.25688300e-01f, 9.70432237e-02f, -9.01096612e-02f, 6.24384508e-02f, 1.68065965e-01f, 2.63237357e-02f, 2.08934814e-01f, 4.46669683e-02f, 8.46454967e-03f,
  -6.40939325e-02f, 1.88792311e-02f, -1.64889723e-01f, 9.16788206e-02f, -1.71052694e-01f, -4.27083708e-02f, 3.63989472e-02f, 1.87133588e-02f, 6.66139126e-02f, 1.27529487e-01f,
  1.07673764e-01f, 6.43908754e-02f, -1.46764414e-02f, -1.20749936e-01f, 4.10738736e-02f, -1.03000654e-02f, 1.44644259e-02f, 1.25114113e-01f, -9.07348320e-02f, -4.49389741e-02f,
  -1.22895859e-01f, -8.29463080e-02f, 4.66547608e-02f, -3.11988518e-02f, 3.06458604e-02f, 5.77226654e-02f, -1.80919707e-01f, -4.89112362e-03f, 8.09118971e-02f, 1.06495559e-01f,
  -4.72491756e-02f, -9.80750248e-02f, 2.87178289e-02f, -3.09105627e-02f, -9.25801918e-02f, 1.52312843e-02f, -8.02989397e-03f, 1.26091931e-02f, -8.63435492e-02f, 8.19624513e-02f,
  -6.51206449e-02f, -6.33726716e-02f, 6.66071177e-02f, -1.58239529e-01f, -1.41728502e-02f, 1.62735075e-01f, -1.04211323e-01f, 1.03420883e-01f, -4.18679528e-02f, 7.82327577e-02f,
  -6.60178661e-02f, -2.79121965e-01f, -2.01780740e-02f, -1.26046240e-01f, -4.35757115e-02f, -8.22711550e-03f, -7.67391399e-02f, -1.63934022e-01f, -1.11929528e-01f, 2.00337749e-02f,
  -1.18158430e-01f, -8.37584510e-02f, -5.16133159e-02f, -9.34992358e-02f, -1.55735379e-02f, -5.75882532e-02f, -1.45145789e-01f, 6.79370482e-03f, -3.64615843e-02f, -9.85238999e-02f,
  -1.52463600e-01f, -2.36970961e-01f, 2.22537778e-02f, -8.75857919e-02f, -1.47303686e-01f, -3.74416783e-02f, 2.47775801e-02f, -6.58353418e-02f, -4.43294942e-02f, -9.33924615e-02f,
  4.45746899e-01f, -4.93061244e-01f, 1.78527370e-01f, 3.10709774e-01f, 3.54547799e-01f, -5.80635704e-02f, 2.24375650e-01f, 4.56221662e-02f, 3.23797077e-01f, -5.26047051e-01f,
  2.45047547e-02f, -3.01054835e-01f, -2.50634611e-01f, -2.62223836e-02f, 4.47550356e-01f, -6.14936352e-02f, 1.08755186e-01f, 1.06507009e-02f, 1.52983159e-01f, 1.62824944e-01f,
  3.42243433e-01f, 3.29200998e-02f, 1.55845121e-01f, -1.47579789e-01f, 1.45205259e-01f, -4.91222180e-02f, -1.26345530e-01f, -9.04719383e-02f, -1.80028364e-01f, 2.71751508e-02f,
  1.17572859e-01f, 9.72837731e-02f, 1.15786389e-01f, -7.68085346e-02f, 9.96206403e-02f, -8.97127688e-02f, 2.23323423e-02f, -3.56740318e-02f, 2.60534763e-01f, -5.18754404e-03f,
  -3.05785332e-02f, -8.71578380e-02f, -8.57313722e-03f, 3.56663652e-02f, 1.52524099e-01f, 7.80500695e-02f, 4.34715748e-02f, 9.84154083e-03f, 2.97666388e-03f, -1.07180476e-02f,
  1.52870774e-01f, -8.02062303e-02f, 1.65732622e-01f, -6.20550625e-02f, 1.00607641e-01f, 7.18912408e-02f, -6.04546703e-02f, -1.09479181e-01f, -7.28002042e-02f, -2.35689841e-02f,
  -1.46301031e-01f, 1.44455098e-02f, -5.40232472e-03f, 8.77564624e-02f, 6.39409274e-02f, 8.95021334e-02f, -1.39049655e-02f, -7.70536810e-02f, 1.29865464e-02f, -7.05329627e-02f,
  1.05339780e-01f, 3.77816916e-03f, 7.36513082e-03f, 4.24849205e-02f, 2.75092218e-02f, -2.60979906e-02f, -6.44847602e-02f, -9.00366157e-02f, 1.62164215e-02f, 7.75129199e-02f,
  2.08837772e-03f, 8.97931401e-04f, 5.39667495e-02f, -1.94827598e-02f, -7.77333602e-02f, -3.71133946e-02f, -9.88944843e-02f, 1.48720862e-02f, -1.06837405e-02f, -3.97914164e-02f,
  -2.22027168e-01f, -6.28326416e-01f, -6.04028031e-02f, -5.79445288e-02f, -1.22694477e-01f, -5.35564907e-02f, -5.53775169e-02f, 9.21490323e-03f, -7.83344265e-03f, -2.53709704e-02f,
  -6.42286986e-02f, 6.24525994e-02f, -2.67945230e-02f, 4.98503484e-02f, 8.35454836e-02f, -2.03009583e-02f, -2.61637531e-02f, -2.82100569e-02f, 2.04607584e-02f, -1.16566733e-01f,
  -1.92837864e-02f, -1.00375134e-02f, 6.00489564e-02f, 1.14749096e-01f, -3.35476398e-02f, -2.28819996e-02f, -2.20187884e-02f, 3.90545204e-02f, -1.40716424e-04f, -5.75567931e-02f,
  4.10452694e-01f, -3.19994003e-01f, 1.35115057e-01f, 5.24990082e-01f, 3.01962733e-01f, -9.92517993e-02f, 2.49935955e-01f, 6.87744692e-02f, 4.71332341e-01f, -4.63782161e-01f,
  -8.61471146e-02f, -2.53459901e-01f, -2.14730993e-01f, 1.00462638e-01f, 4.23270226e-01f, -5.89569248e-02f, 1.64345935e-01f, -8.55703652e-02f, 2.32449308e-01f, 4.40850817e-02f,
  3.43243510e-01f, -5.17177805e-02f, 1.68346316e-01f, -2.47809306e-01f, 5.21720648e-02f, 4.46095616e-02f, -1.39707267e-01f, -6.89949282e-03f, -1.41240910e-01f, -8.24413821e-02f,
  -5.52094281e-02f, 2.00977936e-01f, -3.59399617e-02f, -3.12573835e-02f, 3.72318961e-02f, -6.99672177e-02f, 4.23441567e-02f, -6.72893450e-02f, 2.32347056e-01f, -5.39660044e-02f,
  -9.06967074e-02f, 1.31073631e-02f, -6.67304844e-02f, 1.37737198e-02f, 7.74833187e-02f, 9.10557657e-02f, -2.82827616e-02f, -6.95204735e-02f, -4.76704203e-02f, -9.76152793e-02f,
  1.16291530e-02f, 4.11112569e-02f, 9.81812403e-02f, -1.32592246e-01f, 5.71141131e-02f, 1.52859241e-01f, -3.30354199e-02f, -1.35329738e-01f, -4.18179929e-02f, 6.68196976e-02f,
  -3.57815921e-02f, -1.77021883e-02f, -4.83284928e-02f, 4.64061499e-02f, 1.47699267e-02f, 7.14072585e-02f, -4.47005173e-03f, 6.87925238e-03f, 1.82394497e-02f, -5.13897464e-03f,
  3.76093090e-02f, 1.28766969e-02f, 4.70582210e-02f, 1.00294493e-01f, 9.74265411e-02f, 7.01104850e-02f, 3.96070592e-02f, -4.22410890e-02f, 1.41275395e-02f, 1.20207191e-01f,
  -8.56305957e-02f, 4.92957048e-02f, -4.71305065e-02f, -6.51608920e-03f, 5.20815328e-02f, 3.33262645e-02f, -4.86048590e-03f, -1.06192954e-01f, 9.83129665e-02f, 3.64925936e-02f,
  -1.11307643e-01f, -2.25463793e-01f, -8.73391107e-02f, -7.92144015e-02f, 1.35006709e-02f, -9.48740989e-02f, 1.86315868e-02f, -5.45544736e-02f, 1.17535137e-01f, 3.47704114e-03f,
  -1.10913314e-01f, -1.91865545e-02f, -2.69402098e-02f, 1.13266939e-02f, -6.61145709e-03f, -5.41147739e-02f, 8.23044851e-02f, 5.34604527e-02f, 4.79860045e-02f, -7.06072077e-02f,
  -1.18950740e-01f, -9.18986872e-02f, -5.92776984e-02f, 1.02760121e-01f, -1.20551012e-01f, 5.21568442e-03f, 6.67307898e-02f, 1.59656610e-02f, -2.05472447e-02f, -3.93200107e-02f,
  -5.69622695e-01f, 5.47779262e-01f, 4.64815646e-01f, -1.83097661e-01f, 1.04324102e-01f, 2.47840136e-01f, -1.03552923e-01f, 3.20037574e-01f, 3.94100621e-02f, -2.54340470e-02f,
  -2.03641996e-01f, 2.68522888e-01f, 4.71098237e-02f, -1.06533185e-01f, -2.92664051e-01f, -1.02042332e-01f, -8.51981938e-02f, -2.26052254e-01f, 5.66714210e-03f, 3.89027596e-02f,
  -3.87591645e-02f, -3.02330405e-01f, 1.64854348e-01f, 1.68953523e-01f, 2.08906189e-01f, 8.67567137e-02f, -2.70482808e-01f, 1.62940785e-01f, 3.13609801e-02f, 1.26774654e-01f,
  -3.53335083e-01f, -1.73112586e-01f, -1.63649052e-01f, -3.69685218e-02f, -5.93304215e-03f, -3.47638167e-02f, -1.00544132e-01f, -6.74583465e-02f, -1.23439349e-01f, 7.67047480e-02f,
  7.34114945e-02f, 8.18364844e-02f, -6.50698096e-02f, -1.34767415e-02f, 5.23490161e-02f, 1.79209203e-01f, 1.09298982e-01f, 1.60849705e-01f, 1.31100863e-01f, 2.27930963e-01f,
  1.47981539e-01f, 2.07390398e-01f, 4.29786332e-02f, 6.26796950e-03f, 1.00757167e-01f, 4.13701311e-02f, 5.27613088e-02f, 5.43453805e-02f, 7.99388885e-02f, 4.29407395e-02f,
  -5.00517450e-02f, -2.17121676e-01f, -3.77176031e-02f, -8.03372338e-02f, 7.73336068e-02f, 8.19656476e-02f, -6.49959967e-02f, -5.20584174e-02f, -5.70550887e-03f, -6.71243593e-02f,
  4.34308685e-02f, 4.38260753e-03f, -7.86270499e-02f, -1.04248285e-01f, -5.06519303e-02f, -7.28420615e-02f, -8.73861983e-02f, -2.76009273e-02f, 4.56065359e-03f, 5.17782010e-02f,
  -2.85174195e-02f, -1.59839410e-02f, -2.14105900e-02f, -6.35709986e-02f, -1.63449738e-02f, -2.31001079e-02f, -1.03608221e-01f, 1.57934755e-01f, -1.01910912e-01f, -9.51858014e-02f,
  -6.78115964e-01f, -4.21452790e-01f, -2.61287451e-01f, 1.28012942e-02f, -6.22904580e-03f, -1.82851385e-02f, -8.47492814e-02f, 5.56153990e-02f, -1.50424927e-01f, -1.55408517e-01f,
  -1.80263165e-02f, 3.17091942e-02f, -7.22601861e-02f, -8.40594247e-02f, -6.37304559e-02f, -9.38206539e-02f, -8.07869062e-02f, -6.76655918e-02f, -1.23173222e-01f, -6.51638880e-02f,
  -2.68422123e-02f, -1.43525422e-01f, -6.89687654e-02f, 5.44615090e-02f, -2.69250665e-02f, -5.34310378e-02f, 1.55245112e-02f, 4.29374678e-03f, -9.02329609e-02f, -1.50523549e-02f,
  -3.27125788e-01f, -1.53172418e-01f, 1.52871892e-01f, -1.87760830e-01f, 2.48356998e-01f, -8.58573690e-02f, 3.40970121e-02f, 1.69175625e-01f, -2.81318314e-02f, -1.56436041e-01f,
  1.53303519e-01f, -3.17159116e-01f, 2.12182671e-01f, -2.97291011e-01f, -6.88347146e-02f, 6.35178387e-02f, -1.92524165e-01f, -2.54006237e-01f, 1.42344221e-01f, -8.85101706e-02f,
  5.06367572e-02f, -6.99629867e-03f, 2.16939583e-01f, 1.47216082e-01f, 9.13049802e-02f, 7.40531310e-02f, -6.80303900e-03f, 2.90016621e-01f, -1.81154475e-01f, -1.43091613e-02f,
  7.10596144e-02f, -5.27082710e-03f, 1.15641065e-01f, 4.43404764e-02f, -2.48043351e-02f, -3.60105745e-02f, -1.19007476e-01f, 4.86996174e-02f, 9.42371562e-02f, -1.11659780e-01f,
  2.43714056e-03f, -6.38966709e-02f, -9.91675332e-02f, 7.23231882e-02f, 9.02058780e-02f, -2.95889452e-02f, -7.87610039e-02f, 4.96365242e-02f, 1.18574448e-01f, -5.58361672e-02f,
  1.03620619e-01f, -1.14230797e-01f, 3.82204205e-02f, -5.03379107e-02f, 6.85191602e-02f, 5.61951147e-03f, -2.60435995e-02f, -3.30750458e-03f, -4.25862446e-02f, -1.31370962e-01f,
  -1.17033496e-01f, 5.83778694e-02f, 1.44003376e-01f, -5.66211529e-03f, 1.53524801e-01f, 1.30204111e-01f, -7.93473646e-02f, 1.36528742e-02f, 4.66089062e-02f, 8.17969963e-02f,
  1.56243011e-01f, -1.11311473e-01f, 2.60853171e-02f, -2.66790837e-02f, 4.38679680e-02f, -4.37272601e-02f, -5.10962531e-02f, -5.52184209e-02f, 1.22610636e-01f, 1.90494303e-02f,
  -5.43561690e-02f, 1.12943493e-01f, 1.30298212e-02f, -6.16311990e-02f, -2.31810845e-02f, 2.86483094e-02f, 5.38743995e-02f, 1.78373381e-01f, 2.65183090e-03f, 7.68721998e-02f,
  6.19374663e-02f, -1.41067863e-01f, 1.49328545e-01f, -6.86741574e-03f, 6.20631389e-02f, -9.55931768e-02f, -1.37949437e-01f, -1.36858001e-01f, 6.49816915e-02f, 2.10893042e-02f,
  -8.75480920e-02f, 4.34781946e-02f, -1.05814263e-01f, -9.15441513e-02f, -1.04524521e-02f, 4.35761325e-02f, -1.25517100e-01f, -1.69765994e-01f, -6.56718537e-02f, 6.74334243e-02f,
  7.82009140e-02f, 4.64241281e-02f, 7.19614252e-02f, 5.96750267e-02f, -4.28629890e-02f, -3.38000022e-02f, -1.13178179e-01f, 3.45825963e-02f, -4.15041298e-02f, -9.05624330e-02f,
  -1.07264239e-02f, 3.67811948e-01f, 3.55700940e-01f, -5.64117990e-02f, -1.20487846e-01f, 2.46933579e-01f, 3.08454670e-02f, 2.16593817e-01f, 4.04401898e-01f, 8.20496306e-02f,
  -3.76682609e-01f, -3.09129003e-02f, -5.47928959e-02f, -1.36281788e-01f, -3.81112210e-02f, 1.62793189e-01f, 7.27867633e-02f, 6.31148443e-02f, 1.58280194e-01f, -1.20482072e-01f,
  -1.30769596e-01f, -3.96751881e-01f, -3.87825936e-01f, -2.20755979e-01f, -3.15842062e-01f, 1.15266480e-01f, -4.30499345e-01f, 7.98826814e-02f, -1.14855342e-01f, 9.58329290e-02f,
  1.20917104e-01f, 3.34444195e-02f, 1.06758147e-01f, 2.16460407e-01f, 1.33483395e-01f, -1.15635529e-01f, 3.18061002e-02f, 5.41560203e-02f, 1.44932970e-01f, 1.26074657e-01f,
  -5.40983281e-04f, -3.04452237e-02f, 3.38776298e-02f, -3.91537696e-02f, 4.81081083e-02f, -5.87953106e-02f, -1.98416561e-02f, 1.17323205e-01f, -2.81171803e-03f, -3.04861125e-02f,
  6.74398318e-02f, 7.20555857e-02f, 2.62648053e-02f, 7.12285191e-02f, 5.69250248e-02f, 1.55863151e-01f, 1.28190860e-01f, -1.05767235e-01f, -1.49969738e-02f, 1.30723026e-02f,
  -2.83356681e-02f, 8.81432891e-02f, -4.74602319e-02f, -8.06299895e-02f, -1.55030880e-02f, 1.01026759e-01f, 1.47382345e-03f, -1.09550834e-01f, 1.25238046e-01f, -2.79394090e-02f,
  8.90512988e-02f, 1.95624884e-02f, 7.23457038e-02f, 4.33248505e-02f, -1.29253522e-01f, -8.29492733e-02f, -1.23439528e-01f, 1.70301929e-01f, 8.21385831e-02f, -4.58345329e-03f,
  -1.45062566e-01f, 1.09140210e-01f, -6.60541654e-02f, -8.75878558e-02f, -7.04527553e-03f, -3.59148942e-02f, -1.34367228e-01f, -3.71107608e-02f, 1.40014233e-03f, -1.41606182e-01f,
  1.76384464e-01f, 2.17669412e-01f, 7.74092376e-02f, 1.30083665e-01f, 7.53583610e-02f, -1.25595227e-01f, -1.14835110e-02f, 9.23392698e-02f, 1.99349254e-01f, -5.38129807e-02f,
  -3.02827731e-02f, -4.78152968e-02f, 6.28718659e-02f, 1.67280864e-02f, -2.39321217e-02f, -6.02881312e-02f, 9.56620052e-02f, 1.59651414e-01f, 1.47806272e-01f, -2.59133633e-02f,
  -6.84010535e-02f, -2.04427410e-02f, -4.14258838e-02f, -1.03031509e-02f, 3.91766205e-02f, -9.27411318e-02f, 1.88166201e-02f, 1.11142084e-01f, -9.41341668e-02f, 6.30026907e-02f,
  -3.97098660e-01f, 6.05338737e-02f, -1.50674477e-01f, -4.13975686e-01f, 1.43534496e-01f, 1.18005713e-02f, 3.20342891e-02f, 1.35142595e-01f, -2.27804929e-02f, 1.71099305e-01f,
  1.75307781e-01f, -1.37804337e-02f, 1.44480422e-01f, -3.12557876e-01f, -4.39137816e-01f, -3.10944676e-01f, -3.87011945e-01f, -1.74172461e-01f, 5.06420471e-02f, 3.55922915e-02f,
  -1.67946115e-01f, -2.12763056e-01f, -3.41545999e-01f, 1.76601261e-01f, 9.10645630e-03f, 1.07360810e-01f, 2.91683506e-02f, 1.69400156e-01f, -9.20258984e-02f, -1.40321488e-02f,
  -8.03313181e-02f, 4.96743396e-02f, 3.66160236e-02f, 3.82230394e-02f, -6.00314029e-02f, 1.62788823e-01f, 8.48614518e-03f, -9.18982476e-02f, -3.37592177e-02f, 1.58363953e-02f,
  -4.86011133e-02f, -4.14166525e-02f, -8.17215294e-02f, 5.82462363e-03f, 5.16160652e-02f, -2.37702429e-02f, -1.11811489e-01f, 2.76400596e-02f, 1.08040962e-03f, -2.06284672e-02f,
  -1.91851348e-01f, 3.65025341e-03f, 5.90788275e-02f, -7.26041943e-02f, -5.12790121e-02f, 1.34426832e-01f, 6.26695454e-02f, -2.25990973e-02f, 5.08792475e-02f, -1.22976191e-01f,
  1.26081810e-03f, 1.42288193e-01f, -2.07162537e-02f, -1.39457779e-03f, 6.09682575e-02f, 4.65311743e-02f, 4.13433574e-02f, -5.09973280e-02f, 7.86343217e-02f, 2.97809597e-02f,
  -3.52394320e-02f, 5.02369516e-02f, -6.09039608e-03f, 2.59509310e-02f, -7.89144263e-02f, -5.50551265e-02f, -8.82603787e-03f, -6.65288279e-03f, -1.21851549e-01f, 3.64323817e-02f,
  4.85379882e-02f, 5.12993149e-02f, 4.13098820e-02f, -1.04289472e-01f, -2.12698299e-02f, 6.24758042e-02f, 1.20868996e-01f, -1.49942592e-01f, -3.62267680e-02f, 1.07329577e-01f,
  3.75394942e-03f, 2.72266746e-01f, 1.46639556e-01f, 1.13186233e-01f, 1.89194717e-02f, -5.57213090e-03f, -1.24612913e-01f, 1.81490462e-02f, -4.35397662e-02f, 7.03663230e-02f,
  5.18526770e-02f, 1.45409346e-01f, 8.81775394e-02f, -3.63615062e-03f, -3.65321338e-02f, 5.32547832e-02f, -1.45851672e-02f, 9.46912821e-03f, 4.76268232e-02f, -9.80914664e-03f,
  1.28594294e-01f, 1.12244882e-01f, -6.24854714e-02f, 2.72300690e-02f, 1.47067711e-01f, 2.00332124e-02f, 7.41455704e-02f, -3.81905884e-02f, 1.51278600e-02f, 2.69497149e-02f,
  -2.70685226e-01f, 1.24401517e-01f, -4.32118356e-01f, 3.00447851e-01f, 1.31456852e-01f, -1.42641425e-01f, -2.14693919e-01f, 3.17563623e-01f, -2.17978626e-01f, 2.13629842e-01f,
  4.58957493e-01f, -8.68043751e-02f, -2.19065711e-01f, 5.99228919e-01f, 3.25206339e-01f, 2.70777494e-02f, 4.24088776e-01f, 8.89434367e-02f, -7.42856488e-02f, 2.21172720e-01f,
  1.21127710e-01f, 5.41316211e-01f, 2.14070395e-01f, 2.86626786e-01f, 1.85063228e-01f, -7.50095844e-02f, 3.14345479e-01f, -9.36377645e-02f, 4.16878641e-01f, 1.75043881e-01f,
  5.81092276e-02f, 2.14265853e-01f, -4.78459932e-02f, -1.27373084e-01f, -4.02885675e-02f, -2.02113196e-01f, -2.27492169e-01f, -1.14762649e-01f, -5.33571579e-02f, -3.08888163e-02f,
  -1.92394108e-01f, 8.58949944e-02f, 1.32160693e-01f, -2.64113639e-02f, -3.77819538e-02f, 4.86615151e-02f, -6.10988550e-02f, -8.50344542e-03f, -3.11262831e-02f, -3.45238261e-02f,
  -8.64761397e-02f, -3.46212601e-03f, -3.81653123e-02f, 1.96651146e-02f, 3.45811620e-02f, 5.13893776e-02f, -4.74881381e-02f, -1.75027296e-01f, 1.03175072e-02f, 8.19491073e-02f,
  -2.44554896e-02f, 3.45001779e-02f, -1.33441482e-02f, 6.76640421e-02f, 4.94703278e-03f, 1.18924804e-01f, 3.74845117e-02f, -4.39948887e-02f, -1.01927690e-01f, 1.15977407e-01f,
  4.78882492e-02f, -5.28447069e-02f, 4.61292975e-02f, -8.72838795e-02f, 7.86202326e-02f, -6.40958920e-02f, -1.04025319e-01f, 1.71443492e-01f, -3.78173180e-02f, -1.30521487e-02f,
  1.85226332e-02f, 1.71171464e-02f, -4.58015241e-02f, -1.01988792e-01f, -1.73674431e-02f, 2.88598202e-02f, 8.09307024e-02f, 1.01236254e-01f, 5.62925972e-02f, -2.50649154e-02f,
  7.33043626e-02f, 1.63249508e-01f, 1.28364163e-02f, -3.58430706e-02f, 1.19921856e-01f, 1.03457041e-01f, 5.83625436e-02f, -3.82094979e-02f, 5.75960539e-02f, -1.08523190e-01f,
  1.59395561e-02f, -9.16047543e-02f, 2.04000827e-02f, 1.42378196e-01f, 6.89253360e-02f, 3.94967897e-03f, 4.05183472e-02f, -6.21621571e-02f, 1.02247015e-01f, 1.07411861e-01f,
  3.41344550e-02f, -1.03132240e-02f, 8.24483708e-02f, -5.41457646e-02f, 4.32670228e-02f, 3.70857604e-02f, 2.01901998e-02f, -2.03753766e-02f, 8.52078423e-02f, -1.35286739e-02f,
  -8.28032911e-01f, 6.60209596e-01f, 2.01098129e-01f, -1.09542385e-01f, -1.10423334e-01f, -3.65332179e-02f, 4.86390926e-02f, 7.24452808e-02f, -1.80818930e-01f, 4.11903739e-01f,
  2.11200386e-01f, -1.67679824e-02f, 1.83031350e-01f, 3.06119949e-01f, -4.53266531e-01f, -2.39325184e-02f, -5.37454374e-02f, 8.64057764e-02f, -1.23224415e-01f, -2.31368884e-01f,
  -2.29736850e-01f, -1.13281861e-01f, 6.40524849e-02f, 7.20170960e-02f, 2.53051132e-01f, -1.39061268e-02f, -5.79435974e-02f, 1.67546645e-02f, 2.88228780e-01f, 1.85409576e-01f,
  -2.04672471e-01f, -4.30364549e-01f, 1.01330899e-01f, -4.45039831e-02f, -1.86766610e-01f, -3.36089432e-02f, -1.46594569e-02f, 4.53110225e-03f, -1.21212527e-01f, -1.25972256e-01f,
  -8.46078154e-03f, 4.63248864e-02f, -9.19709075e-03f, -9.17189345e-02f, -6.21612519e-02f, -1.20121418e-02f, 1.35461777e-01f, 2.10696891e-01f, -1.12926811e-02f, 1.92289427e-01f,
  1.30731598e-01f, 1.43185079e-01f, 5.26899733e-02f, 1.49875149e-01f, 2.81474963e-02f, 5.65180369e-02f, -5.57045378e-02f, -1.63518786e-02f, 1.30955651e-02f, -9.24926326e-02f,
  -1.94814190e-01f, -3.33624780e-02f, 7.86055252e-02f, 3.63720916e-02f, -6.48386627e-02f, 6.82125315e-02f, 6.64521530e-02f, 4.45224196e-02f, 3.47094275e-02f, -7.87285119e-02f,
  2.95219775e-02f, 3.78444381e-02f, -3.36299501e-02f, -1.32946940e-02f, 3.00459359e-02f, -1.17397666e-01f, -7.88391158e-02f, -5.24111055e-02f, 1.27893947e-02f, 5.14677539e-03f,
  7.21320733e-02f, -1.89200416e-01f, 1.13173924e-01f, -1.15450136e-02f, -1.58357825e-02f, -1.23505399e-01f, 7.43824840e-02f, -2.59836968e-02f, 3.99248824e-02f, -1.07280761e-01f,
  -7.58635461e-01f, -7.02773571e-01f, 8.01673066e-03f, -4.22027260e-02f, -1.27328709e-01f, -1.19784467e-01f, -6.46286830e-02f, 3.05997115e-02f, -2.23380644e-02f, -1.47519112e-01f,
  -4.42152731e-02f, -1.62302479e-02f, -4.53028195e-02f, -1.38481066e-01f, -8.74939039e-02f, 1.26345605e-02f, 3.81931886e-02f, -7.49781206e-02f, -1.77337974e-01f, -4.96894401e-03f,
  6.07245341e-02f, -2.08275225e-02f, 9.88613348e-03f, 2.18127929e-02f, -1.18524335e-01f, -1.83272187e-03f, -5.70429787e-02f, 1.41184002e-01f, -3.43396962e-02f, 7.03532398e-02f,
  2.71689743e-01f, 1.28802210e-01f, 4.78255391e-01f, 3.16457778e-01f, 3.64891849e-02f, 1.74971953e-01f, -2.09866554e-01f, 2.70705730e-01f, 3.70059162e-01f, -1.02865733e-01f,
  -1.93558499e-01f, 2.63014119e-02f, -4.18274581e-01f, 1.44173354e-01f, -2.70009786e-01f, -3.34803164e-01f, 5.64934984e-02f, -5.52926771e-02f, -5.61348610e-02f, 6.20077066e-02f,
  3.54408585e-02f, -4.43418294e-01f, -2.12724437e-03f, -1.77150905e-01f, 3.23159933e-01f, 1.86131105e-01f, -3.85771126e-01f, -1.23159170e-01f, 8.23079497e-02f, -4.05866653e-02f,
  5.62760085e-02f, 5.38538396e-02f, 1.19426481e-01f, 4.36139591e-02f, 8.04508105e-02f, -4.56500351e-02f, -4.90630642e-02f, -2.19313011e-01f, 2.80889049e-02f, 1.04936719e-01f,
  -8.88908841e-03f, -5.29249199e-03f, 7.97947347e-02f, -6.06936328e-02f, 1.84926063e-01f, 1.19432896e-01f, 7.49687478e-02f, 1.51457503e-01f, 1.07824631e-01f, 9.84260663e-02f,
  1.18778393e-01f, 1.01472683e-01f, 1.55478552e-01f, 9.42207035e-03f, 6.42947629e-02f, 1.22422643e-01f, 5.21749370e-02f, 4.07565869e-02f, 7.21124411e-02f, 5.02761193e-02f,
  5.80332428e-02f, -3.21579352e-02f, -1.03452682e-01f, 1.00820614e-02f, -1.28335550e-01f, 9.12308618e-02f, 5.72206117e-02f, -4.02677152e-03f, 1.03068173e-01f, 2.58757453e-02f,
  -4.23193388e-02f, 2.22089738e-02f, 1.00477956e-01f, 6.60311356e-02f, -2.90401764e-02f, 1.15391262e-01f, -4.16310467e-02f, 2.97754239e-02f, 7.16985110e-03f, 3.13332826e-02f,
  -1.43407166e-01f, -7.22101051e-03f, -3.86358202e-02f, 3.78287248e-02f, 4.97241281e-02f, 1.32818660e-02f, 2.48002056e-02f, 1.61140144e-01f, -2.32618656e-02f, -2.24472374e-01f,
  -2.32211471e-01f, -2.51717746e-01f, -6.06973693e-02f, 5.40480204e-03f, -1.74181201e-02f, 3.55726965e-02f, -7.77405202e-02f, 9.11744684e-02f, -8.98029953e-02f, -1.22181483e-01f,
  2.44547706e-02f, -5.45441285e-02f, -7.81169161e-02f, -2.05841754e-02f, -1.76043883e-01f, -2.78285760e-02f, -9.31727514e-02f, -2.78580952e-02f, -8.49376172e-02f, 1.62953921e-02f,
  -1.06106363e-01f, -4.66074832e-02f, 2.14373805e-02f, 1.79804191e-02f, 6.02860115e-02f, -1.36294410e-01f, 1.99228336e-04f, -6.78145513e-03f, -1.84201170e-02f, 2.08426900e-02f,
  1.15878835e-01f, -2.84060906e-03f, -1.95946798e-01f, 8.12416058e-03f, -9.34944153e-02f, -7.42830262e-02f, -7.84808397e-02f, 1.24749422e-01f, 6.80402592e-02f, 1.50924474e-01f,
  1.11655049e-01f, -1.25804558e-01f, 2.09759220e-01f, -9.97413173e-02f, -2.41069391e-01f, -1.52656764e-01f, -8.94654635e-03f, -1.20505117e-01f, -1.15423955e-01f, 2.70550340e-01f,
  1.80001274e-01f, 3.67656313e-02f, -1.41566843e-01f, 3.24017316e-01f, -1.56629115e-01f, -1.86332222e-02f, 1.15508191e-01f, -8.13841522e-02f, -2.16128662e-01f, -2.10972145e-01f,
  -5.23083396e-02f, 1.34173274e-01f, 4.61507961e-02f, -1.04806557e-01f, 4.63515781e-02f, 1.14535868e-01f, 1.51824811e-02f, 4.31521796e-02f, -9.21030119e-02f, 8.30969810e-02f,
  -1.27429366e-02f, -5.24057746e-02f, 2.78051589e-02f, -1.26950145e-01f, -1.41776249e-01f, 4.65889573e-02f, -4.68386412e-02f, -2.03913897e-01f, 1.15861678e-02f, -5.93515784e-02f,
  -1.02994122e-01f, 3.35925780e-02f, 9.12001431e-02f, -5.06716669e-02f, -3.99931818e-02f, -1.15819938e-01f, -4.40866202e-02f, -1.65604591e-01f, -1.77904721e-02f, 5.84759414e-02f,
  1.31915629e-01f, 2.74084322e-02f, -3.09909564e-02f, -1.63993239e-01f, 8.54861215e-02f, 8.79782513e-02f, 8.02011937e-02f, 1.18422918e-01f, -3.58172841e-02f, 3.44728082e-02f,
  -1.47559613e-01f, 2.90731564e-02f, 4.49250452e-02f, -8.86941031e-02f, 8.48166943e-02f, 8.69109482e-03f, -8.08310881e-02f, -7.39519075e-02f, 8.23081210e-02f, -2.38177422e-02f,
  -4.89594638e-02f, -3.16316262e-02f, 3.35164019e-03f, -1.14497051e-01f, -1.90572619e-01f, -4.69976328e-02f, 1.08791739e-01f, 7.69907758e-02f, -9.66160651e-03f, 7.80633092e-02f,
  8.84148628e-02f, 2.68309832e-01f, 1.56360552e-01f, -8.71574655e-02f, 1.20005123e-01f, 1.41856134e-01f, 3.84127460e-02f, 2.36846376e-02f, -1.08924378e-02f, 4.04583365e-02f,
  1.42152309e-01f, 7.82454088e-02f, 1.25851139e-01f, -1.42743245e-01f, -1.15418047e-01f, 1.38352424e-01f, 9.95753258e-02f, -1.14697792e-01f, 4.29127179e-02f, 2.15394244e-01f,
  1.61710635e-01f, 8.15431550e-02f, 2.43395865e-01f, 3.44747715e-02f, 1.53730944e-01f, -7.68321082e-02f, 2.87550106e-03f, -1.53152317e-01f, 1.29470587e-01f, -1.25619099e-01f,
  5.50218880e-01f, 3.77244085e-01f, 2.05497414e-01f, 3.80571634e-01f, -2.38259524e-01f, -1.02531284e-01f, -5.75568378e-02f, -4.17990573e-02f, -1.64092049e-01f, 1.94839269e-01f,
  -2.16023207e-01f, 3.85861665e-01f, -3.84532005e-01f, 3.57847512e-01f, -2.66363531e-01f, -3.59198868e-01f, 1.93580046e-01f, 2.02709913e-01f, -1.61081851e-01f, 3.15644830e-01f,
  -5.28788641e-02f, -1.54880837e-01f, 1.63784921e-02f, -4.30278070e-02f, 3.33799332e-01f, 2.80038834e-01f, -1.82985917e-01f, -1.09606534e-01f, 4.26710337e-01f, -1.29506245e-01f,
  3.14576807e-03f, 4.54182290e-02f, 1.52579755e-01f, 4.76752268e-03f, -1.00518775e-03f, 2.12612763e-01f, 1.90464452e-01f, -1.34262908e-02f, -5.37747331e-02f, -2.49252445e-03f,
  -3.86027796e-06f, -7.42023997e-03f, -6.14194386e-02f, -1.31171942e-02f, 1.85304597e-01f, 1.07296467e-01f, -5.98871941e-03f, 3.94414440e-02f, 4.07971144e-02f, 9.75845233e-02f,
  1.39286727e-01f, 1.26265809e-01f, 1.01876341e-01f, 4.55527604e-02f, -8.64117965e-03f, 4.50696871e-02f, 1.03405513e-01f, 1.31359071e-01f, 3.87719870e-02f, 4.78224196e-02f,
  6.96843266e-02f, 2.53817961e-02f, 3.19071934e-02f, -4.69707027e-02f, 4.69702035e-02f, 4.61699404e-02f, -4.69532460e-02f, -6.82443157e-02f, -1.14211351e-01f, 4.51388136e-02f,
  -7.30052590e-02f, 1.28544211e-01f, -9.80671942e-02f, 2.24326029e-02f, 3.36025357e-02f, 1.36939809e-01f, -6.42327219e-02f, 1.06464028e-01f, 6.37918785e-02f, -1.61263384e-02f,
  -1.21640414e-01f, -3.98567691e-02f, 7.38199279e-02f, -2.09005959e-02f, -5.16203232e-02f, 4.85877022e-02f, 5.29602878e-02f, 1.13909394e-01f, -5.81173562e-02f, -6.71463460e-02f,
  5.15525341e-02f, -1.86893456e-02f, 1.32350866e-02f, 5.87183088e-02f, -1.08782873e-01f, -1.69070307e-02f, 7.39916414e-02f, 1.17350653e-01f, -2.09566709e-02f, -4.91433516e-02f,
  1.75277904e-01f, 5.75572290e-02f, 2.80032177e-02f, 1.85959563e-02f, 4.38790284e-02f, -7.67043456e-02f, -1.92417558e-02f, 4.42866907e-02f, 6.69429377e-02f, 1.24914512e-01f,
  1.03972211e-01f, 7.72451907e-02f, 9.23747867e-02f, -7.67993033e-02f, 5.55493347e-02f, 1.87157467e-02f, 3.60866636e-02f, -5.46719413e-03f, 3.69647108e-02f, -2.52276137e-02f,
  2.29780361e-01f, -1.28279164e-01f, -4.01104778e-01f, -4.07891631e-01f, 3.29136580e-01f, 5.59514999e-01f, -3.85203958e-01f, 1.07187554e-01f, -5.47849536e-01f, -2.28757396e-01f,
  1.25273108e-01f, -2.48840913e-01f, -4.20200169e-01f, 4.66745555e-01f, 3.36893499e-01f, -6.89035580e-02f, 3.13996345e-01f, 2.63971746e-01f, 1.56286791e-01f, 2.62433380e-01f,
  2.43678451e-01f, 5.88154256e-01f, 4.55946065e-02f, 4.98739928e-01f, 3.52926493e-01f, -1.82505697e-01f, -2.80695744e-02f, -2.26749420e-01f, 3.15836698e-01f, 2.65394658e-01f,
  2.11689368e-01f, 4.53018211e-02f, -7.08248094e-02f, 5.85797802e-02f, 6.94235936e-02f, 6.65503070e-02f, -8.42489749e-02f, 5.94883785e-02f, -5.35604320e-02f, -6.24722540e-02f,
  -9.96658877e-02f, 5.04019931e-02f, 9.38207433e-02f, -1.90991685e-02f, 5.23392186e-02f, -6.71924427e-02f, -5.98200485e-02f, -8.93971846e-02f, -1.80136874e-01f, 8.37504566e-02f,
  -1.99597791e-01f, -2.34011821e-02f, -3.12350719e-04f, -9.19329002e-02f, -1.75338462e-01f, -9.42124873e-02f, -1.54356822e-01f, -1.85793668e-01f, 1.02910295e-01f, 1.50546748e-02f,
  4.90246825e-02f, 7.32854009e-02f, 2.30037123e-02f, 8.71472135e-02f, -7.67375827e-02f, -1.84442271e-02f, 7.86956698e-02f, 4.94162142e-02f, -1.43184051e-01f, -1.32483803e-02f,
  -6.69635162e-02f, -3.24785523e-02f, 2.01049950e-02f, 2.31322385e-02f, 3.27530615e-02f, -3.28451730e-02f, 7.25548342e-02f, 1.70454662e-02f, -1.12743184e-01f, -3.66320014e-02f,
  -1.52503513e-02f, 1.06126890e-01f, -1.33139491e-01f, 2.73153298e-02f, 8.72970670e-02f, -2.31879160e-01f, 3.06219682e-02f, -1.10032894e-01f, -1.85002293e-02f, 5.19693904e-02f,
  -4.98018647e-03f, -1.38921440e-01f, -6.87525421e-02f, 1.15255728e-01f, -5.74746951e-02f, 1.54627204e-01f, 6.44583255e-02f, 1.20418072e-01f, -1.75117236e-02f, 2.08442267e-02f,
  4.82526086e-02f, -6.80152774e-02f, 5.89918084e-02f, 5.15787266e-02f, 1.15936473e-01f, 7.97046572e-02f, -3.65548693e-02f, -1.63839236e-01f, -1.45981252e-01f, -1.42938620e-03f,
  -3.93863693e-02f, -4.23011407e-02f, -1.48980960e-01f, 7.46778324e-02f, -1.83354691e-02f, -9.07058939e-02f, 3.11610214e-02f, -9.29823294e-02f, 7.45211989e-02f, -6.86454996e-02f,
  -3.26437682e-01f, 4.77798700e-01f, -3.58654588e-01f, 4.23346832e-02f, -1.42906949e-01f, 5.33282220e-01f, 4.31006014e-01f, 2.33326063e-01f, 5.00514619e-02f, 4.87111092e-01f,
  2.74412572e-01f, -1.15754396e-01f, 2.45481759e-01f, 3.40828449e-01f, 8.84348750e-02f, 3.15973967e-01f, 4.25358832e-01f, 2.92538524e-01f, -1.05752207e-01f, 1.73563793e-01f,
  -8.13765824e-02f, 4.28345174e-01f, -4.41776998e-02f, 9.89345685e-02f, 1.53665822e-02f, -2.16528729e-01f, -7.28695020e-02f, -2.25610420e-01f, 1.68665931e-01f, 9.29442272e-02f,
  1.00749768e-01f, -8.78759548e-02f, -8.52950960e-02f, -5.06927520e-02f, 2.06904095e-02f, -8.85866508e-02f, 5.22822514e-03f, -1.13489404e-01f, -1.34901732e-01f, -4.22261320e-02f,
  -4.86199446e-02f, -6.44179210e-02f, 4.70532328e-02f, 1.77003797e-02f, -4.12995256e-02f, -3.87667604e-02f, -2.73232604e-03f, -2.96680909e-02f, 6.96897805e-02f, -4.15266007e-02f,
  -9.01326444e-03f, 2.32944116e-02f, 4.73716520e-02f, 1.08170427e-01f, -4.27196510e-02f, 2.52318084e-02f, 6.54775091e-03f, -7.40813762e-02f, 1.12968110e-01f, 6.00667633e-02f,
  -7.45130405e-02f, 7.96537772e-02f, 8.86847898e-02f, -9.41365361e-02f, -2.97013875e-02f, -5.33675728e-03f, 9.12284479e-02f, 2.88399197e-02f, -7.83911943e-02f, 1.13277204e-01f,
  -3.92882414e-02f, -9.84347463e-02f, 4.68650050e-02f, 2.57215109e-02f, 8.37332830e-02f, -1.12380102e-01f, -8.16424340e-02f, -5.02575971e-02f, 4.03014151e-03f, 1.35792941e-02f,
  8.20609629e-02f, -4.07458171e-02f, 5.88887371e-02f, -7.77641088e-02f, 3.74931656e-02f, -2.15630475e-02f, 1.19076207e-01f, -6.45172447e-02f, -2.91329175e-02f, -1.03851922e-01f,
  2.83174247e-01f, 4.36136514e-01f, 7.02945665e-02f, 2.61452515e-02f, -6.92186430e-02f, 5.27994856e-02f, 4.40618880e-02f, -9.07039549e-03f, 5.08170985e-02f, -2.83484496e-02f,
  -1.20420240e-01f, -8.09920058e-02f, 4.31169346e-02f, -1.13662206e-01f, 2.52177175e-02f, 1.95704475e-01f, 6.64624274e-02f, -5.86684793e-02f, 4.22097705e-02f, 6.60507157e-02f,
  -9.24211554e-03f, 3.24118547e-02f, -1.24958225e-01f, -3.44255678e-02f, 2.51839757e-02f, 5.79792447e-02f, 1.78979393e-02f, -1.53817371e-01f, 3.05124186e-02f, 1.44787788e-01f,
  -7.82210231e-01f, 2.00187027e-01f, -1.03499621e-01f, -3.88076693e-01f, -2.67557185e-02f, 3.11972536e-02f, -2.40009829e-01f, 2.63752609e-01f, -3.25834490e-02f, 2.31288195e-01f,
  2.16652647e-01f, -3.80951881e-01f, 5.08879960e-01f, -6.22713529e-02f, -3.44078869e-01f, 4.51215953e-01f, -3.81293654e-01f, -1.60068318e-01f, 1.36388183e-01f, -1.47121072e-01f,
  -2.49603629e-01f, -5.47764190e-02f, -8.54522958e-02f, 3.23305845e-01f, -3.36015642e-01f, -1.46650970e-01f, -1.07868850e-01f, 1.46531641e-01f, -2.14578137e-01f, -1.15600370e-01f,
  -2.91166633e-01f, 9.81621966e-02f, -2.79536188e-01f, -1.31919190e-01f, -2.35476017e-01f, -6.14771061e-02f, -1.76052213e-01f, -7.30306879e-02f, -9.24663097e-02f, 6.36509880e-02f,
  -4.10388820e-02f, 1.60276428e-01f, -8.73398185e-02f, 3.17080393e-02f, -2.19393894e-02f, -5.80942966e-02f, 1.19128518e-01f, -2.92741284e-02f, -8.38091876e-03f, 3.13527584e-02f,
  9.57311764e-02f, 3.40779684e-03f, -2.82943081e-02f, 1.08608559e-01f, -1.17763020e-01f, -1.15840957e-01f, -9.26667638e-03f, -1.24409556e-01f, -9.33913216e-02f, -5.12754247e-02f,
  -1.62470080e-02f, -4.45984304e-02f, -7.84623921e-02f, 1.34111224e-02f, -9.91785550e-04f, -7.53552839e-02f, -5.84022589e-02f, -5.06068654e-02f, -9.72420946e-02f, -5.50771691e-02f,
  -5.67983724e-02f, 5.53970737e-03f, 9.36448053e-02f, 1.27850184e-02f, -1.51784152e-01f, -1.12786114e-01f, -4.73929904e-02f, 7.76984021e-02f, 3.29871736e-02f, -1.04274387e-02f,
  -2.47499384e-02f, -7.68981129e-02f, 1.05864018e-01f, 1.07483240e-02f, -1.13054238e-01f, 1.15659818e-01f, 1.04800574e-01f, -3.73524874e-02f, -6.49332553e-02f, -9.26645398e-02f,
  -5.20176232e-01f, -1.60652827e-02f, -1.15810528e-01f, 1.24376519e-02f, -1.34317726e-01f, -2.91674118e-02f, 1.46251433e-02f, -8.18577558e-02f, -7.98631459e-02f, 1.46571010e-01f,
  -1.08285800e-01f, 7.46559873e-02f, 2.05758736e-02f, 5.17275892e-02f, -5.36120720e-02f, -9.32116956e-02f, -1.61534578e-01f, -6.46057725e-02f, -1.46368921e-01f, -5.86017827e-03f,
  1.91251803e-02f, 3.26751396e-02f, -3.41464989e-02f, 4.93648611e-02f, 3.58507521e-02f, -6.62677437e-02f, -9.84468982e-02f, 1.05011113e-01f, 3.61762568e-02f, 6.77789748e-02f,
  4.82813716e-01f, -6.80187762e-01f, 2.07276836e-01f, 2.25007772e-01f, 4.06867534e-01f, 1.06493622e-01f, 2.77063757e-01f, 1.00057915e-01f, 5.95833361e-02f, -5.11615694e-01f,
  -4.19321917e-02f, -1.26084983e-01f, -1.51049718e-01f, -1.24126598e-01f, 4.43117738e-01f, -4.00622301e-02f, 6.30072951e-02f, -1.51079923e-01f, 4.35289815e-02f, -6.13480899e-03f,
  2.45536476e-01f, -1.19301103e-01f, 2.36040890e-01f, -2.61272490e-01f, -1.46808168e-02f, -1.19017838e-02f, -1.63990080e-01f, -8.45552608e-03f, -1.25781760e-01f, 1.55933172e-01f,
  -3.01826578e-02f, -1.28555134e-01f, -8.58590007e-03f, -2.03637525e-01f, -8.75992924e-02f, 2.43993048e-02f, 3.31013724e-02f, 1.44951418e-01f, 8.30185115e-02f, 7.08257221e-03f,
  -4.91283834e-02f, 3.76763605e-02f, 2.41396278e-02f, 1.06719628e-01f, 7.34803407e-03f, 2.85014901e-02f, 4.14583161e-02f, -2.33684685e-02f, 1.91961806e-02f, 1.04234606e-01f,
  4.63820137e-02f, 3.91748361e-02f, 7.99044445e-02f, 3.28833945e-02f, 8.50062296e-02f, 1.78795587e-02f, 1.46867707e-01f, -1.43335713e-03f, 2.08129175e-02f, -3.79720666e-02f,
  1.24446629e-02f, -2.04266561e-03f, -1.28757190e-02f, -2.40287390e-02f, -3.66388932e-02f, 1.62229419e-01f, 2.55850665e-02f, -1.00017779e-01f, -3.08074560e-02f, 1.47521310e-02f,
  6.29797876e-02f, 7.25410059e-02f, 5.06638130e-03f, 4.68308292e-03f, 1.60293747e-02f, 2.43326947e-02f, 2.02788021e-02f, 1.84900630e-02f, -4.57999595e-02f, -4.03363816e-02f,
  -5.42712696e-02f, 8.26242343e-02f, 4.40507531e-02f, 1.23278275e-01f, -2.23096684e-02f, 3.82582545e-02f, -1.97218191e-02f, 7.02042207e-02f, 2.36480441e-02f, -4.18365933e-02f,
  -4.34260845e-01f, -5.57199955e-01f, -1.51890531e-01f, -4.69345227e-02f, -2.27622017e-01f, -1.85051709e-01f, -2.10575052e-02f, -3.48695256e-02f, -2.12024733e-01f, 9.55239311e-02f,
  1.12741301e-02f, 6.66638613e-02f, -9.07768756e-02f, 9.14240431e-04f, -2.11178169e-01f, 1.69876032e-02f, -8.63152519e-02f, -1.45612761e-01f, -1.62766904e-01f, -1.47765696e-01f,
  -3.26131657e-02f, 5.08516328e-03f, 5.04884869e-02f, 1.42232373e-01f, 4.97379899e-02f, -7.68973399e-03f, 7.10461810e-02f, -5.27913682e-02f, 1.21368142e-02f, -1.06975585e-02f,
  -5.50968349e-01f, 4.33918446e-01f, -1.19277686e-02f, 7.07179382e-02f, 8.73676389e-02f, -2.56319433e-01f, 1.34598508e-01f, 5.92881907e-03f, 2.51210272e-01f, 2.64628679e-01f,
  1.04594901e-01f, 3.60063165e-01f, 2.06996262e-01f, 2.61593044e-01f, -4.74111736e-01f, -7.47035444e-02f, -2.63445139e-01f, 3.70460153e-02f, 1.03760906e-01f, 1.42692611e-01f,
  -2.00197667e-01f, 1.60913035e-01f, -2.24625275e-01f, 1.07735313e-01f, 1.90769508e-02f, -1.49611263e-02f, -2.98615307e-01f, 7.00349882e-02f, -9.50482339e-02f, -1.43157497e-01f,
  -3.11351120e-01f, 8.05328041e-02f, -1.32252583e-02f, -1.30612582e-01f, -1.50155783e-01f, -1.79560468e-01f, -9.64441225e-02f, -9.28133205e-02f, 1.43084392e-01f, 7.57225901e-02f,
  5.08499108e-02f, 1.08178323e-02f, 7.97189921e-02f, 4.89557087e-02f, -4.89650480e-03f, 6.88586757e-02f, -6.67298660e-02f, -3.55374105e-02f, 1.04691222e-01f, -7.08455369e-02f,
  8.33398402e-02f, -1.16328299e-01f, -1.62846267e-01f, -1.04775995e-01f, -9.67529342e-02f, 1.75960630e-01f, -1.00959271e-01f, -1.48563609e-01f, -1.38986930e-01f, -4.73227501e-02f,
  3.68094519e-02f, 2.76942793e-02f, 9.12018344e-02f, 1.21262141e-01f, 5.04928268e-02f, -5.67018911e-02f, -5.81460353e-03f, -1.33200437e-01f, 1.23007018e-02f, -3.83567400e-02f,
  -9.87553820e-02f, 4.21852395e-02f, -2.13675052e-02f, -4.40201908e-02f, 3.59778814e-02f, 1.23203754e-01f, -2.98831379e-03f, 2.37976853e-02f, -2.63994753e-01f, -5.39228171e-02f,
  6.72760159e-02f, -6.96123838e-02f, -3.32326293e-02f, -1.42015591e-01f, -9.02154949e-03f, 5.76655418e-02f, -7.61756897e-02f, -1.15878787e-02f, 1.42011046e-02f, -7.89666623e-02f,
  -4.56651866e-01f, -1.19494379e-01f, -1.81442890e-02f, -4.99637425e-02f, 8.66315812e-02f, -9.93917659e-02f, 2.18532383e-02f, -1.11965083e-01f, 4.80487756e-03f, 1.94362868e-02f,
  3.38799469e-02f, -8.97474214e-02f, -1.63254440e-01f, -2.56664644e-04f, 1.28765777e-02f, -1.11165620e-01f, 9.06724557e-02f, -5.50429220e-04f, -6.50344044e-02f, -6.04238883e-02f,
  1.93001889e-02f, 6.00364618e-02f, -4.81809527e-02f, -1.10360943e-01f, -8.26874673e-02f, -2.11364925e-02f, 3.12319230e-02f, 5.79099171e-03f, -5.24269417e-02f, 5.09485677e-02f,
  8.55257064e-02f, 2.02218369e-01f, -5.60239181e-02f, -1.54082388e-01f, -1.25457108e-01f, -4.31917816e-01f, -2.37705693e-01f, -9.04313996e-02f, 8.16627219e-02f, 1.79795250e-01f,
  -2.62127757e-01f, 4.09276843e-01f, -2.38282029e-02f, -2.90334016e-01f, -4.23882812e-01f, -2.62586713e-01f, -3.34167749e-01f, 3.46188620e-02f, 6.94043040e-02f, 2.83434950e-02f,
  -1.95411980e-01f, -3.49980235e-01f, -2.53781497e-01f, -1.36792600e-01f, -1.64013535e-01f, 1.87556505e-01f, -1.95307910e-01f, -2.54279599e-02f, 1.78746898e-02f, -1.59841031e-01f,
  -4.07268219e-02f, -4.14735600e-02f, 3.60821523e-02f, 1.06209248e-01f, -8.94929841e-02f, 1.30591497e-01f, 9.74639729e-02f, -1.20952584e-01f, -4.80693318e-02f, -8.27253237e-03f,
  1.78802013e-01f, -8.97433795e-03f, 1.11590751e-01f, 9.63890459e-03f, 1.28509134e-01f, 1.21113166e-01f, 3.34417447e-02f, 1.69236004e-01f, 7.21896961e-02f, -1.47459824e-02f,
  9.62575227e-02f, 1.45274386e-01f, 4.27012369e-02f, 1.24534294e-01f, 4.28468361e-02f, -6.68387162e-03f, 9.29586310e-03f, 4.87132072e-02f, 1.44623086e-01f, 9.60701331e-02f,
  -5.66875897e-02f, 1.64705999e-02f, 3.42940260e-03f, -1.04825879e-02f, 6.06931038e-02f, -6.62352741e-02f, -7.91968256e-02f, 7.20822886e-02f, 4.96191829e-02f, -6.47868142e-02f,
  -9.34871007e-03f, 5.65996356e-02f, -2.24071760e-02f, 3.93959088e-03f, -5.38546480e-02f, 1.56936601e-01f, 8.72327760e-03f, 5.30086793e-02f, -4.14774865e-02f, -3.31531919e-04f,
  6.26539588e-02f, -1.11211706e-02f, 1.09146252e-01f, -9.01099946e-03f, -6.92985207e-02f, 4.92574088e-03f, 9.96116027e-02f, 1.40802130e-01f, -9.93174016e-02f, -1.63121969e-01f,
  -9.32617337e-02f, -8.66573751e-02f, 1.92647669e-04f, 1.55308798e-01f, 6.97643235e-02f, 1.24825425e-01f, -1.97753459e-02f, -6.76712170e-02f, -1.36242986e-01f, -2.00983533e-03f,
  -3.27581093e-02f, 1.17342927e-01f, 1.56622946e-01f, -4.64250296e-02f, -1.06496904e-02f, -1.04580604e-01f, -4.64138836e-02f, 5.56364022e-02f, -9.11303088e-02f, 5.04290573e-02f,
  1.39004976e-01f, 7.41360188e-02f, -2.98388731e-02f, 5.47260381e-02f, 1.32405370e-01f, 1.81044359e-02f, 1.12459481e-01f, 1.38601825e-01f, 1.80541445e-02f, 1.51233479e-01f,
  2.00958177e-01f, 4.53620344e-01f, 4.61781085e-01f, 5.06689429e-01f, -2.08340585e-01f, -4.15834606e-01f, -3.14415276e-01f, 6.80111572e-02f, 2.72988211e-02f, 6.00979626e-02f,
  -5.52589893e-02f, 3.77793640e-01f, -1.11136749e-01f, 1.60867885e-01f, -4.10318255e-01f, -2.44067103e-01f, -6.55793995e-02f, -6.93025962e-02f, 2.89541297e-02f, 2.20337942e-01f,
  -7.58928061e-03f, -1.21352442e-01f, 2.22503260e-01f, 1.26055377e-02f, 1.15194827e-01f, 3.03174555e-01f, 8.37147236e-02f, 3.08703985e-02f, 3.34649354e-01f, -1.20185770e-01f,
  -7.71788806e-02f, 1.92159027e-01f, 1.34265006e-01f, -4.50384952e-02f, -1.69369541e-02f, -4.91824895e-02f, 3.34174968e-02f, -3.16141807e-02f, 3.30822840e-02f, 5.36024570e-02f,
  3.27626169e-02f, -5.13351522e-02f, 8.24097171e-02f, -3.90220806e-02f, 1.18981197e-03f, 1.52396902e-01f, 5.93698174e-02f, 7.89104998e-02f, 4.70726900e-02f, 1.61527805e-02f,
  1.75398156e-01f, 7.11087808e-02f, 6.91697970e-02f, 4.12287302e-02f, 3.67603227e-02f, 2.31163912e-02f, -7.12770075e-02f, 8.79678205e-02f, 9.43632573e-02f, 1.00160632e-02f,
  -1.10040970e-01f, 2.37184600e-03f, 5.23706600e-02f, 1.24457739e-01f, -2.99588107e-02f, 8.09679478e-02f, 2.41333507e-02f, -9.68218371e-02f, 3.12961079e-02f, 1.49437515e-02f,
  5.69711486e-03f, 7.48102441e-02f, -2.62245652e-03f, 2.04678085e-02f, 5.19977696e-02f, 1.15079656e-01f, 2.28500031e-02f, 4.85484675e-02f, 9.73407850e-02f, 9.27593485e-02f,
  -3.41414921e-02f, -3.18543077e-03f, 6.33748770e-02f, 8.65585264e-03f, -3.55760269e-02f, 2.54981723e-02f, 1.30989686e-01f, 2.32424606e-02f, 3.18997838e-02f, 1.39838057e-02f,
  -1.09384328e-01f, 1.88419521e-01f, -5.06405253e-03f, -1.93988103e-02f, 4.91201840e-02f, -1.07726097e-01f, -6.93272501e-02f, -1.11168216e-03f, 3.63328494e-02f, -8.59476998e-02f,
  9.38918348e-03f, -3.45838889e-02f, -9.74121876e-03f, 2.94085294e-02f, -3.35830972e-02f, 4.11530510e-02f, 1.17344692e-01f, 1.35639891e-01f, 6.13483228e-02f, 3.60267535e-02f,
  9.20469239e-02f, -5.10828122e-02f, -9.62867662e-02f, -5.51850647e-02f, 2.94695199e-02f, 1.74529944e-03f, 2.91402303e-02f, -4.58496995e-02f, -4.47039632e-03f, -1.45122048e-03f,
  1.25500083e-01f, -3.43115360e-01f, -4.56303269e-01f, -3.81893218e-01f, 9.81099084e-02f, 3.82772118e-01f, 3.00498158e-02f, 4.71996553e-02f, -3.38438749e-01f, 1.95117161e-01f,
  2.66012549e-01f, -4.61284786e-01f, 1.88938994e-02f, -1.14646479e-01f, 5.69885504e-03f, -1.63244575e-01f, 1.54199064e-01f, -5.81403151e-02f, -1.90816924e-01f, 2.45514363e-01f,
  -3.91600877e-02f, 1.35329440e-01f, 5.64292781e-02f, 2.37699952e-02f, 1.15258664e-01f, -2.57158354e-02f, 4.22802478e-01f, 5.60678244e-02f, 2.15301499e-01f, 6.14931025e-02f,
  1.36193499e-01f, -1.29851162e-01f, 1.92923099e-02f, -9.14237555e-03f, 2.99771369e-01f, 1.90894663e-01f, 1.92187667e-01f, -6.84332773e-02f, -7.04063615e-03f, 1.03123570e-02f,
  5.17783202e-02f, -1.83796272e-01f, -2.01897725e-01f, 4.05577049e-02f, -6.33895174e-02f, -1.02998376e-01f, -5.94413057e-02f, 9.90882665e-02f, -1.23978771e-01f, 5.67107201e-02f,
  -7.59219974e-02f, -1.22606501e-01f, -5.73865809e-02f, -9.85287055e-02f, -1.87680900e-01f, 7.81034678e-03f, -2.07079295e-02f, 1.03954248e-01f, -1.10044837e-01f, -6.09697355e-03f,
  1.77704468e-02f, 3.15100551e-02f, 3.15148733e-03f, -2.76464731e-01f, -4.52985093e-02f, 1.68057214e-02f, -5.90076596e-02f, -8.08219761e-02f, -1.49411336e-01f, 1.81395188e-01f,
  -5.56471720e-02f, -1.48749143e-01f, 1.11575410e-01f, 2.57981056e-03f, 1.81757450e-01f, -1.61364407e-03f, -2.37260293e-02f, 5.38475551e-02f, -3.01419962e-02f, -1.09819300e-01f,
  -7.39162117e-02f, 9.85879004e-02f, 1.42760903e-01f, 6.84709549e-02f, 2.97875758e-02f, 1.36657894e-01f, -9.35768858e-02f, 2.69482676e-02f, -1.69162136e-02f, -5.76082617e-02f,
  1.28803700e-01f, 1.30555138e-01f, -5.39054945e-02f, -1.21850744e-01f, 4.22790349e-02f, 2.82310456e-01f, -7.37637579e-02f, -2.31237307e-01f, -1.27461515e-02f, 3.21374536e-02f,
  1.44639194e-01f, -1.39146969e-01f, 1.30772069e-01f, 1.16311707e-01f, -3.27389836e-02f, 2.18263909e-01f, 2.22529061e-02f, 1.41041875e-01f, 1.46586373e-01f, -4.87875864e-02f,
  1.02698557e-01f, 1.99151728e-02f, -1.87272742e-01f, -2.46473402e-01f, -2.12542377e-02f, 1.28363267e-01f, 3.61677632e-02f, 4.54323776e-02f, -9.31218192e-02f, -7.55412579e-02f,
  -5.62407613e-01f, 4.68151629e-01f, 6.43081486e-01f, 1.08678408e-01f, 8.43837187e-02f, 2.93893218e-01f, -4.05921042e-02f, 3.60649705e-01f, 3.85608703e-01f, -2.37808406e-01f,
  -2.98887342e-01f, -1.02634937e-01f, 1.91573635e-01f, -2.15644911e-01f, 5.47985256e-01f, 3.33230853e-01f, 3.17766331e-02f, -2.03156009e-01f, 3.54147851e-01f, 6.76882491e-02f,
  3.45412433e-01f, -2.59158373e-01f, 2.76685894e-01f, 1.94097072e-01f, -6.41524121e-02f, 5.57547025e-02f, -2.38861442e-01f, 4.06842679e-01f, -2.60456413e-01f, 1.11826979e-01f,
  -1.66798919e-01f, 7.93620422e-02f, -1.47972539e-01f, 1.28067002e-01f, 4.17721272e-02f, -1.05634704e-01f, -5.64286225e-02f, -1.95591804e-02f, 5.94157912e-02f, -8.70101750e-02f,
  -1.40365869e-01f, 3.96033749e-03f, 2.82248557e-02f, 2.99983062e-02f, 1.40668944e-01f, 2.11229045e-02f, -3.35950963e-02f, -4.19713371e-02f, 5.83012812e-02f, 1.15751170e-01f,
  8.42961743e-02f, -2.33929866e-04f, 5.42589230e-03f, -1.04415879e-01f, 6.07107431e-02f, -2.32866481e-02f, -1.84926689e-02f, 1.81657448e-02f, -7.86154624e-03f, 5.21092266e-02f,
  9.28653926e-02f, 1.72696516e-01f, 4.21578400e-02f, 3.65280174e-02f, 3.12995203e-02f, -4.78726290e-02f, 1.60026029e-02f, -1.46530017e-01f, 1.24175698e-02f, -7.05220029e-02f,
  -1.82741120e-01f, -7.77784139e-02f, -2.97569241e-02f, -7.21195787e-02f, -9.63107962e-03f, -1.03876807e-01f, -4.44293991e-02f, -1.53296247e-01f, 3.93016525e-02f, -6.88476190e-02f,
  -2.26497352e-02f, 1.34650813e-02f, -2.66609732e-02f, 4.62069130e-03f, 5.15206084e-02f, 1.42183090e-02f, 5.37168719e-02f, 3.86114791e-02f, 8.79815035e-03f, 2.95442063e-02f,
  3.49732995e-01f, 3.64344865e-01f, 2.57766377e-02f, -2.46256366e-01f, -2.50498243e-02f, -1.27326306e-02f, 2.04161406e-01f, -9.43936333e-02f, 1.67068750e-01f, 1.05931633e-03f,
  2.13544932e-03f, -1.01767145e-01f, -5.34936301e-02f, -2.96621770e-02f, 9.88889486e-02f, -7.90034363e-04f, -3.13379057e-02f, -3.46679799e-02f, -4.79825996e-02f, 2.05727462e-02f,
  -1.68039292e-01f, 7.60561079e-02f, 3.48972832e-03f, -4.70852330e-02f, -1.02304935e-01f, -1.15289539e-01f, -9.14401636e-02f, -2.67123375e-02f, 3.03475577e-02f, 1.45931263e-02f,
  -1.25565559e-01f, 7.88720474e-02f, -3.74801487e-01f, -2.22188711e-01f, 1.79212138e-01f, -5.81711471e-01f, -4.04871315e-01f, -2.89028976e-02f, 3.63031216e-02f, 2.18584269e-01f,
  -3.19659896e-02f, -3.03449612e-02f, 1.45028576e-01f, -3.44886571e-01f, -5.60332239e-01f, -2.69779176e-01f, -4.80276167e-01f, -3.18790853e-01f, 4.92607709e-03f, 9.17161815e-03f,
  -8.51123184e-02f, -6.81326091e-02f, -2.86139667e-01f, 3.05812240e-01f, -8.68142471e-02f, 2.72576302e-01f, 3.30445886e-01f, 1.43952221e-01f, -6.35369867e-02f, -8.55745822e-02f,
  -1.97601408e-01f, 3.31711508e-02f, -5.81432506e-02f, -5.44177629e-02f, -7.59135261e-02f, 6.94865286e-02f, -7.28735328e-02f, 1.12711266e-02f, 2.30519958e-02f, -1.86826766e-03f,
  1.04860239e-01f, 5.59580438e-02f, -2.22196169e-02f, 9.05440450e-02f, 7.28731900e-02f, 1.67188924e-02f, -1.49126157e-01f, -4.87741418e-02f, -4.20822250e-03f, -9.82329920e-02f,
  -6.41424134e-02f, -4.60005142e-02f, 5.83590157e-02f, 3.33392434e-02f, -2.39072647e-02f, -8.67509171e-02f, -8.45960453e-02f, -7.31338561e-02f, 7.76419416e-02f, -1.84833873e-02f,
  7.00059906e-02f, 1.14326045e-01f, -5.49886711e-02f, -1.04483083e-01f, -5.79987057e-02f, -2.26789676e-02f, 7.89170489e-02f, 2.31518690e-02f, 4.82787602e-02f, -4.47033048e-02f,
  3.56357135e-02f, -3.49809006e-02f, 3.55485268e-02f, -5.46648465e-02f, 1.57158449e-02f, 4.34964225e-02f, -2.48744898e-02f, -3.82779725e-03f, -8.77632108e-03f, -2.35244744e-02f,
  7.96608105e-02f, -7.94321746e-02f, 4.37774360e-02f, 8.60414132e-02f, -1.03341788e-01f, -6.13757363e-03f, 1.14131138e-01f, -1.47602886e-01f, 2.16031261e-02f, -1.89090259e-02f,
  1.88952070e-02f, 2.76520759e-01f, -2.52619535e-02f, 3.77233103e-02f, 5.02262041e-02f, -6.14083149e-02f, -9.69461799e-02f, -6.74220845e-02f, 4.29116897e-02f, 7.29058459e-02f,
  7.63465464e-03f, 5.26915342e-02f, 2.32259501e-02f, 7.16682076e-02f, 3.55549753e-02f, -9.30562615e-02f, 7.45105520e-02f, 7.31001943e-02f, 1.17840350e-01f, 2.64540389e-02f,
  1.81048974e-01f, 2.05425903e-01f, 7.93415084e-02f, 9.80781615e-02f, 8.11209008e-02f, 3.73943709e-02f, 6.29030541e-02f, 4.56234775e-02f, 4.79738228e-02f, -3.86785530e-02f,
  4.56341654e-01f, -2.87721425e-01f, -2.23697051e-01f, 1.15290925e-01f, 1.06087379e-01f, -3.36039305e-01f, -2.52326846e-01f, -1.53662357e-02f, 4.31453675e-01f, -2.06031442e-01f,
  -1.74100310e-01f, -1.86116204e-01f, -1.73656091e-01f, -2.56105989e-01f, 1.25225529e-01f, 1.32573128e-01f, -2.39154816e-01f, -3.04677188e-01f, 2.60254800e-01f, -2.71622032e-01f,
  2.45786697e-01f, -3.16446364e-01f, -8.24688002e-02f, -2.03015685e-01f, -1.82021469e-01f, 7.19446465e-02f, 1.12304963e-01f, -1.89406365e-01f, -3.11502248e-01f, -5.46119884e-02f,
  -7.04226866e-02f, 1.28472432e-01f, 6.82005808e-02f, -8.92602354e-02f, 3.68603840e-02f, 4.47718091e-02f, -4.33348268e-02f, -2.16447085e-01f, 4.26026843e-02f, 3.17278085e-03f,
  -8.10809657e-02f, 1.08420432e-01f, 1.07141607e-03f, -7.35018179e-02f, 9.74444970e-02f, 6.46393299e-02f, 1.20911017e-01f, 1.30427003e-01f, -4.23017591e-02f, 5.30549325e-02f,
  6.97768060e-03f, 9.44970399e-02f, 1.55017599e-01f, -3.18102539e-02f, 1.14869848e-01f, 8.59313458e-02f, -4.15615924e-02f, -1.64008722e-01f, -3.78916264e-02f, 7.47285336e-02f,
  -5.15036285e-02f, 9.90480110e-02f, -3.50283124e-02f, 7.01841116e-02f, -9.48214233e-02f, 2.16429811e-02f, -2.50924807e-02f, -1.64990481e-02f, 7.99168721e-02f, -4.34386916e-02f,
  -1.19007593e-02f, -7.77646666e-03f, 4.62939031e-02f, -8.66739601e-02f, 9.10042301e-02f, 1.56069830e-01f, -7.30245234e-03f, -3.72215211e-02f, 9.04181078e-02f, 9.49348509e-03f,
  5.20237237e-02f, -3.98523957e-02f, -3.64721380e-02f, 9.70349163e-02f, -7.28679821e-02f, -4.78130803e-02f, -7.51270801e-02f, 4.40248176e-02f, 1.23404063e-01f, -3.16578150e-02f,
  -7.79621080e-02f, -2.19097301e-01f, -8.99266005e-02f, -2.60022227e-02f, -2.03096494e-01f, -8.02801475e-02f, -4.00659032e-02f, 3.57012525e-02f, -1.27310708e-01f, -3.11623532e-02f,
  -5.90052083e-02f, 5.98458238e-02f, 1.44653007e-01f, -9.88609390e-04f, -1.23207495e-01f, -1.08595036e-01f, -1.01563506e-01f, 7.94997141e-02f, -1.37109891e-01f, -2.38303486e-02f,
  -1.00058109e-01f, 4.42383550e-02f, -9.53714028e-02f, 9.37530473e-02f, -1.05916575e-01f, -6.62507769e-03f, -4.50763553e-02f, 2.62309443e-02f, -2.20999178e-02f, -1.28536880e-01f,
  5.12087524e-01f, -3.52506101e-01f, -1.64932147e-01f, -1.65190369e-01f, 3.08975458e-01f, 4.34297681e-01f, 4.08989131e-01f, -3.20372641e-01f, -5.29280901e-01f, -4.76787873e-02f,
  1.32977411e-01f, 3.70513014e-02f, 1.78299591e-01f, -2.50099391e-01f, 1.61301091e-01f, -3.26322854e-01f, -1.32603273e-01f, 8.05064961e-02f, -2.33596399e-01f, 2.08656222e-01f,
  3.30077671e-03f, -2.96630114e-02f, -3.09893012e-01f, -1.74195945e-01f, 2.08062842e-01f, 5.17626945e-03f, 2.15707392e-01f, 3.33966255e-01f, -6.24727197e-02f, -1.07990362e-01f,
  -1.17324620e-01f, -1.97168708e-01f, -4.44924422e-02f, -2.70015579e-02f, 2.61100456e-02f, -6.47068582e-03f, 1.93453193e-01f, 9.31904316e-02f, 3.71562727e-02f, -6.35864511e-02f,
  1.41151518e-01f, 1.20966680e-01f, -1.39030367e-01f, -6.41380325e-02f, 4.43879440e-02f, -9.22660902e-02f, -8.83951858e-02f, -3.63707282e-02f, -4.48836945e-02f, 3.90223041e-02f,
  2.78355349e-02f, 1.89888537e-01f, 2.75939256e-02f, -6.36869222e-02f, 9.77877378e-02f, 1.60669927e-02f, 1.45051077e-01f, 1.46780640e-01f, 4.32124846e-02f, 1.12294957e-01f,
  4.66694236e-02f, 1.50460780e-01f, 2.45609209e-01f, -1.03610866e-01f, 1.82980672e-02f, -1.83042631e-01f, -5.54506741e-02f, -7.66402110e-02f, -1.21580642e-02f, -8.21923092e-02f,
  8.05831924e-02f, 7.91422874e-02f, -1.51281372e-01f, -1.60040073e-02f, 9.04667079e-02f, -6.16145097e-02f, 2.37226933e-02f, -1.00282878e-02f, 2.24669389e-02f, 6.88514579e-03f,
  -7.19438493e-02f, 2.75933929e-02f, 8.82566944e-02f, -2.08696648e-02f, -2.87863705e-02f, -9.50832218e-02f, -1.22941956e-01f, 8.03333670e-02f, -1.69043452e-01f, 7.14936107e-02f,
  5.91268465e-02f, -4.87978710e-03f, -1.47519574e-01f, 6.60650944e-03f, -1.93686500e-01f, 2.62671225e-02f, -8.72756690e-02f, -7.72204995e-02f, -4.52441312e-02f, 1.11500435e-02f,
  8.76754150e-02f, 7.99503475e-02f, 2.05094770e-01f, -3.81250754e-02f, -7.34645054e-02f, -5.44838086e-02f, 2.05976054e-01f, 8.87069385e-03f, -6.23848960e-02f, 8.86272490e-02f,
  -6.43692538e-02f, 1.98913500e-01f, -4.84760143e-02f, 7.26240780e-03f, -6.70212954e-02f, 2.25569159e-01f, 1.69441044e-01f, 6.64554238e-02f, 1.04692407e-01f, -1.69488505e-01f,
  4.67963308e-01f, -4.49853957e-01f, 7.14118069e-05f, 4.02259827e-01f, 3.37908208e-01f, 6.68188334e-02f, 5.36645055e-02f, 6.90375641e-02f, 4.46470320e-01f, -3.84548455e-01f,
  3.83312851e-02f, -3.10964286e-01f, -3.73657256e-01f, 3.06209147e-01f, 2.73522466e-01f, -2.64427572e-01f, 3.87518793e-01f, 8.59669745e-02f, 1.89771935e-01f, -2.55113263e-02f,
  3.73673290e-01f, 2.39115059e-01f, -4.29860726e-02f, -1.01512358e-01f, 2.28338707e-02f, 9.79236215e-02f, -1.58625156e-01f, -1.24085933e-01f, 1.48244917e-01f, -1.06817976e-01f,
  7.42271319e-02f, 1.42620489e-01f, 5.85155189e-02f, -5.35788834e-02f, 6.62340149e-02f, 3.10376100e-02f, -5.86382262e-02f, -1.08035184e-01f, 1.96162820e-01f, -4.33848798e-02f,
  -1.36298805e-01f, 5.84105588e-02f, -2.72592138e-02f, 2.28760932e-02f, 1.56337425e-01f, 1.74777135e-02f, 9.17735100e-02f, 6.55032098e-02f, -2.14529522e-02f, -4.20694202e-02f,
  -3.78254466e-02f, 6.77637430e-03f, 1.35095686e-01f, -1.14333024e-03f, 3.54375057e-02f, 1.19315960e-01f, -7.98468366e-02f, -6.54007047e-02f, -5.24435490e-02f, 9.59385186e-02f,
  -8.60220417e-02f, -8.63640085e-02f, -7.95541033e-02f, 6.43014982e-02f, -1.66708808e-02f, 7.48686269e-02f, 8.33281502e-02f, -1.49363549e-02f, 3.94850597e-02f, -8.94545168e-02f,
  1.09113038e-01f, 8.28358158e-02f, 6.10315278e-02f, 3.16574648e-02f, 1.66944750e-02f, 3.45244519e-02f, -7.56741092e-02f, -7.78637230e-02f, 9.39972699e-02f, 1.43060893e-01f,
  -1.91755053e-02f, -1.60453431e-02f, -8.05661529e-02f, 9.32000652e-02f, 7.63683170e-02f, -1.43087000e-01f, -8.59504417e-02f, 4.70610000e-02f, 2.96543185e-02f, -3.01809590e-02f,
  -3.28414775e-02f, -3.97300452e-01f, -5.65553457e-02f, 7.43099153e-02f, -5.86487502e-02f, -2.73650289e-02f, -2.41029132e-02f, 1.19964994e-01f, -7.10089281e-02f, 1.06035687e-01f,
  2.89617979e-04f, 9.62550193e-02f, -1.00824535e-01f, 4.90618795e-02f, 1.12297991e-02f, 3.72552127e-03f, -1.38843819e-01f, -5.44200130e-02f, -2.68939808e-02f, -8.64232332e-02f,
  -6.30041258e-03f, -4.18589860e-02f, -6.18991032e-02f, 4.15494740e-02f, 4.64779250e-02f, -7.72747621e-02f, -7.81654716e-02f, -1.13479514e-02f, -4.33313325e-02f, -7.08087683e-02f,
  -5.57806134e-01f, -4.89747524e-01f, -3.64088684e-01f, -1.40914824e-02f, 3.25546741e-01f, 6.31658077e-01f, -1.28723517e-01f, -1.92153156e-02f, -4.92715031e-01f, -2.31333524e-02f,
  2.54730117e-02f, -4.99198437e-01f, -4.54601675e-01f, -2.21819561e-02f, -2.23451033e-01f, -3.62766087e-01f, 2.57074207e-01f, 5.64340763e-02f, -1.88163862e-01f, -1.12365156e-01f,
  2.54162662e-02f, 3.18647087e-01f, 2.25742217e-02f, 3.78922284e-01f, -2.26992629e-02f, 6.86811283e-02f, 2.16258585e-01f, -1.29073769e-01f, 2.75033891e-01f, 6.96226358e-02f,
  1.38875365e-01f, -1.93434119e-01f, -1.34807616e-01f, -1.96941942e-02f, 1.26169264e-01f, 4.42921668e-02f, 9.09607485e-02f, -1.22774439e-02f, -1.20230718e-02f, -6.04183152e-02f,
  -1.36926100e-01f, 1.23961009e-02f, 1.20079689e-01f, -1.40490174e-01f, -7.50724301e-02f, 1.16608843e-01f, -4.69585434e-02f, 6.86174855e-02f, -1.10478178e-01f, -1.41693041e-01f,
  -1.16225496e-01f, 1.02242827e-01f, -4.35287878e-03f, 1.41003624e-01f, -5.52494340e-02f, -2.85963602e-02f, 9.75504965e-02f, -4.47462276e-02f, -6.89105466e-02f, 6.77524433e-02f,
  6.84153661e-02f, 7.83133879e-02f, 5.50713055e-02f, -7.79498890e-02f, -3.20380367e-02f, 4.56911027e-02f, -4.16002758e-02f, 1.35218203e-02f, -1.25038773e-01f, 2.25931536e-02f,
  6.61101490e-02f, -1.07499324e-01f, -1.68031693e-01f, 1.65930018e-01f, 8.73224512e-02f, 1.73111528e-01f, 7.31335348e-03f, -7.05655618e-03f, 3.57504487e-02f, 4.43769172e-02f,
  -1.38563871e-01f, 5.60404509e-02f, 2.18064710e-02f, 1.26729337e-02f, 6.81118220e-02f, 3.57279815e-02f, 6.39910325e-02f, 5.25388867e-02f, 5.30555621e-02f, 4.21181368e-03f,
  5.26225828e-02f, -1.92420974e-01f, -4.05708179e-02f, 5.98153658e-02f, -4.80972929e-03f, 7.40329502e-03f, -2.37397067e-02f, -3.36823985e-02f, 4.09136526e-02f, 2.64622830e-02f,
  2.17246130e-01f, 1.92071155e-01f, 6.71803057e-02f, 1.35014178e-02f, 1.19910330e-01f, 1.26920462e-01f, 1.53108714e-02f, 3.87457982e-02f, 7.57956132e-02f, 1.60334870e-01f,
  1.00292027e-01f, 1.82369635e-01f, 1.11609966e-01f, 6.56962544e-02f, 2.14556858e-01f, -9.23739746e-02f, 6.75391704e-02f, 2.63126567e-02f, 1.04556745e-02f, -6.29304871e-02f,
  2.42822200e-01f, 1.86496809e-01f, 2.72430182e-01f, 3.55618656e-01f, -4.87693191e-01f, 5.02531603e-02f, 1.11953400e-01f, -1.48406133e-01f, 3.32171410e-01f, 1.78619429e-01f,
  -3.88738275e-01f, 3.59252781e-01f, 1.50311530e-01f, -1.41064852e-01f, 1.72119349e-01f, 3.57241958e-01f, 1.98071823e-01f, 2.76726931e-01f, -8.67446065e-02f, -8.39398578e-02f,
  -1.09784223e-01f, -4.28553194e-01f, -3.80957611e-02f, -3.79087299e-01f, -3.06364805e-01f, 4.14660852e-03f, -4.32744354e-01f, -2.60876387e-01f, -2.80614585e-01f, -2.87190467e-01f,
  -3.94950062e-01f, -2.15775073e-02f, -2.39217393e-02f, 7.74626061e-02f, -4.77121584e-02f, -3.06252334e-02f, 8.54713097e-02f, -4.31450531e-02f, -9.71535295e-02f, -2.21691485e-02f,
  1.57378748e-01f, -1.14170521e-01f, -6.80291653e-02f, -1.13347903e-01f, 3.29366513e-02f, -6.21490292e-02f, -4.07258756e-02f, 3.92210074e-02f, -1.59352124e-02f, -4.93709333e-02f,
  9.15125683e-02f, 2.84065809e-02f, -5.52208023e-03f, 7.17687383e-02f, -3.77884582e-02f, -2.57405057e-03f, 1.58643529e-01f, 3.68494801e-02f, 8.04340243e-02f, -3.68263274e-02f,
  2.64397599e-02f, -3.76969054e-02f, -6.58004433e-02f, -1.22157156e-01f, -6.84570596e-02f, -1.81522723e-02f, 4.91048349e-03f, -9.26486477e-02f, 1.42238766e-01f, -2.53034965e-03f,
  -7.78886825e-02f, 6.61933050e-02f, -1.99077949e-02f, 5.69627099e-02f, 4.63555343e-02f, 1.21861979e-01f, 8.45880508e-02f, -1.85423438e-02f, 1.10138275e-01f, -2.33335458e-02f,
  2.09502596e-02f, 1.46341054e-02f, -1.37338832e-01f, 1.06271077e-02f, -1.24058105e-01f, -2.96994597e-02f, -1.10987447e-01f, 1.73952937e-01f, 9.64658260e-02f, -1.58600032e-01f,
  -2.76374340e-01f, -3.02250329e-02f, 1.32863596e-02f, -5.82296699e-02f, 9.82246920e-02f, -8.52416307e-02f, -6.49058213e-03f, -4.15462367e-02f, -1.54180992e-02f, 7.32100680e-02f,
  5.14263213e-02f, 1.10930860e-01f, 9.59339589e-02f, -2.20423210e-02f, 8.57503191e-02f, -1.34777641e-02f, 8.49240087e-03f, -1.99644966e-03f, -6.49839044e-02f, -1.56285152e-01f,
  7.13926507e-03f, 2.64587766e-03f, 8.42058733e-02f, 1.90591794e-02f, 6.36191443e-02f, -1.85598060e-02f, -5.34730963e-02f, -3.79730240e-02f, -1.75275832e-01f, -3.67488936e-02f,
  2.86872685e-01f, 3.72818470e-01f, 7.84207508e-02f, 9.99293029e-02f, -1.41923636e-01f, -1.78810582e-01f, -2.63192564e-01f, 2.34712079e-01f, -1.39201343e-01f, 1.24732375e-01f,
  1.62279248e-01f, 1.22721292e-01f, 2.01674089e-01f, 1.73467636e-01f, 2.52081156e-02f, -2.71656662e-01f, 3.02654535e-01f, 8.73487815e-02f, -5.27245402e-02f, 3.33077013e-01f,
  2.21911907e-01f, 2.33472645e-01f, 2.10542411e-01f, 1.67870849e-01f, 2.61853665e-01f, 2.15143755e-01f, 2.42909655e-01f, 2.69358582e-03f, 2.42869332e-01f, -1.35253206e-01f,
  6.35148585e-02f, 1.84918553e-01f, -4.70241867e-02f, -1.61889598e-01f, 8.00133720e-02f, -2.85889897e-02f, -5.64588793e-02f, 4.88705896e-02f, 3.42531130e-04f, 6.71872124e-02f,
  6.63283095e-02f, 3.49747576e-02f, -8.95930175e-03f, -9.99214575e-02f, -3.78120057e-02f, 2.97263972e-02f, -6.19692355e-02f, 9.38380733e-02f, -1.32604524e-01f, 1.11651428e-01f,
  7.63939768e-02f, -7.15260510e-04f, 1.42963856e-01f, -1.38711572e-01f, 1.30717382e-01f, -2.62123626e-02f, 4.67675291e-02f, 1.69985563e-01f, -2.83960719e-02f, -1.23493886e-02f,
  1.31396055e-01f, -6.07552789e-02f, -1.06618330e-02f, -3.40233371e-02f, -4.02903035e-02f, -1.75713934e-02f, -1.95822250e-02f, 3.17680687e-02f, -1.75630394e-02f, 3.65052111e-02f,
  -1.59882352e-01f, 3.52027975e-02f, 1.47389369e-02f, 7.02084079e-02f, 6.58497959e-02f, -9.80828628e-02f, 5.00893034e-02f, -4.74749170e-02f, -6.56567588e-02f, -5.85386483e-03f,
  -1.61475375e-01f, -6.77710772e-02f, -1.38748690e-01f, 4.76892330e-02f, -1.05582308e-02f, -4.35216129e-02f, -4.42734314e-03f, 2.27412954e-02f, 4.22350094e-02f, -1.38663698e-03f,
  1.07408442e-01f, 2.85120010e-01f, -3.94376144e-02f, -1.66408926e-01f, -6.13044761e-02f, 5.37601672e-02f, -1.07072480e-01f, 1.13295801e-01f, 1.71257809e-01f, 6.63195401e-02f,
  1.50967956e-01f, -4.82505746e-02f, 7.05421716e-02f, -2.08844859e-02f, 9.74299386e-03f, 1.89786881e-01f, 7.25483755e-03f, -1.20452844e-01f, 4.29754425e-03f, 1.92774922e-01f,
  1.92423966e-02f, 7.71690905e-02f, -2.67674308e-02f, -6.31811246e-02f, 5.42321950e-02f, 1.35336136e-02f, 8.11932702e-03f, 6.99117258e-02f, 1.03967553e-02f, -2.18073986e-02f,
  -5.28564334e-01f, 3.92815890e-03f, -3.97742778e-01f, -1.94369674e-01f, -1.86365008e-01f, -3.28869283e-01f, -2.03886464e-01f, -2.06224531e-01f, 3.80823831e-03f, 3.69431585e-01f,
  1.54058218e-01f, -1.40574411e-01f, 3.69262040e-01f, -5.71494102e-02f, -4.58508134e-01f, 3.00302178e-01f, -1.95928857e-01f, -1.36130527e-01f, 7.73988292e-02f, -3.17954808e-01f,
  -2.47479156e-01f, -6.40915334e-02f, -2.05221802e-01f, 1.04520597e-01f, -2.09310398e-01f, -1.54043734e-01f, 2.93455541e-01f, 3.39346416e-02f, -1.35823786e-01f, -4.41632420e-02f,
  -3.05563331e-01f, -1.83227435e-01f, -1.15847535e-01f, -2.76876315e-02f, -1.42393261e-01f, -3.19965146e-02f, 9.03751329e-03f, -4.46299389e-02f, 1.30977668e-03f, -8.02436471e-02f,
  3.20766419e-02f, -1.19731978e-01f, 3.92666683e-02f, 1.19056925e-01f, -9.74311382e-02f, -9.72645879e-02f, -1.37037829e-01f, 7.15234578e-02f, -6.72186166e-02f, -1.19059339e-01f,
  -1.33423775e-01f, -4.64843176e-02f, -5.61162718e-02f, 1.21631593e-01f, -1.60960462e-02f, 2.34546047e-02f, -3.55610828e-05f, -7.40014836e-02f, -8.83993357e-02f, -5.89886457e-02f,
  -1.28412470e-02f, 3.02739944e-02f, -1.00047968e-01f, 6.43418282e-02f, -5.22571662e-03f, 4.32697386e-02f, -2.20019612e-02f, 1.05992563e-01f, 6.39829636e-02f, -9.34834033e-03f,
  6.05181605e-02f, -5.50864711e-02f, 7.29093477e-02f, 1.52328378e-02f, -2.59808241e-03f, 1.06636792e-01f, 4.93838303e-02f, -6.29606396e-02f, 2.73044016e-02f, -3.40165719e-02f,
  -6.89431950e-02f, -7.47018307e-02f, 3.98351885e-02f, 6.04419969e-03f, -4.40184548e-02f, 3.75891849e-02f, 2.10242812e-02f, -2.31401790e-02f, 3.43163684e-02f, -1.03248537e-01f,
  -4.21901792e-01f, -2.93554842e-01f, 5.42769283e-02f, -9.43736956e-02f, 5.69916703e-02f, -2.69325450e-02f, 8.95891413e-02f, 4.06035362e-03f, 4.48884629e-03f, -2.95194071e-02f,
  -6.01176545e-02f, -6.83130547e-02f, -5.92305325e-02f, 8.34667981e-02f, 3.49056385e-02f, -1.48104671e-02f, 5.11403307e-02f, 2.38872245e-02f, -4.31474522e-02f, -3.54960002e-02f,
  -7.25478027e-03f, 3.07943635e-02f, -2.08552089e-02f, -1.16607416e-02f, 5.48487194e-02f, 2.44141296e-02f, -1.12266444e-01f, 2.31616385e-03f, -6.82107434e-02f, -4.13408838e-02f,
  -5.59696615e-01f, 7.32006192e-01f, -4.18721706e-01f, -2.27090701e-01f, 2.25154027e-01f, 4.45633352e-01f, 2.36070871e-01f, 9.55635086e-02f, -3.30152549e-02f, 3.34086239e-01f,
  2.56557912e-01f, -6.79695532e-02f, 1.69404864e-01f, 3.58304113e-01f, 1.01197742e-01f, 4.11903620e-01f, 3.00844252e-01f, 1.76716939e-01f, 6.81025162e-02f, -3.54239048e-04f,
  -1.55463312e-02f, 4.36100543e-01f, -7.15126004e-03f, 1.40043482e-01f, 9.63653252e-02f, -3.23268175e-01f, -2.73455948e-01f, -1.57943785e-01f, 1.09720893e-01f, 1.05830826e-01f,
  7.54309520e-02f, -4.58916843e-01f, -2.08920702e-01f, -1.51151329e-01f, -7.87389353e-02f, -2.14790598e-01f, -1.29912958e-01f, -1.18660212e-01f, -1.80356964e-01f, -5.14881462e-02f,
  -4.81272228e-02f, 1.52097242e-02f, 3.65243033e-02f, -5.58428876e-02f, 7.18424469e-02f, 6.55575171e-02f, 8.19812939e-02f, 6.49239570e-02f, 9.89447087e-02f, 7.54136667e-02f,
  9.29238722e-02f, 7.46048242e-02f, 9.86188129e-02f, 2.85422131e-02f, 6.12104721e-02f, 5.19925132e-02f, -1.21057471e-02f, -1.27046718e-03f, 1.57280236e-01f, 5.96092083e-02f,
  5.58920652e-02f, -7.90750980e-02f, 2.98982929e-03f, -3.55886184e-02f, -4.11429256e-02f, 9.72175151e-02f, -3.30531895e-02f, -7.11514754e-03f, -1.79966050e-03f, 2.36594886e-01f,
  1.25561312e-01f, 4.16708887e-02f, -7.09481910e-02f, 5.87353595e-02f, 5.05685732e-02f, -4.09437157e-03f, -4.90212254e-02f, 2.42463294e-02f, 2.62288805e-02f, 2.40002237e-02f,
  -1.31337166e-01f, 3.01316235e-04f, 1.31452888e-01f, 1.79280490e-02f, 1.12477299e-02f, -3.11538260e-02f, -1.07758552e-01f, 8.24451372e-02f, 7.51546491e-03f, 3.07691563e-03f,
  2.28864312e-01f, -1.61558419e-01f, -2.33409740e-02f, 1.09300211e-01f, -4.76280004e-02f, 3.61631140e-02f, -1.40060261e-01f, 3.96427559e-03f, 1.41744405e-01f, 2.40114033e-02f,
  -5.24964295e-02f, -9.44842622e-02f, -6.49796575e-02f, 3.00679412e-02f, 6.69994345e-03f, 5.56464531e-02f, -9.23878551e-02f, -8.05230364e-02f, 5.49030565e-02f, -7.99068343e-03f,
  -1.17587142e-01f, -4.98504117e-02f, -1.50267020e-01f, 7.83654004e-02f, 2.24881852e-03f, 4.52494174e-02f, -5.22872694e-02f, -6.42428920e-02f, -4.54573669e-02f, 1.54590122e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.88369688e-02f, 4.40741777e-01f, 3.05133164e-01f, 3.33205402e-01f, 3.10850501e-01f, 4.66928124e-01f, 3.10452551e-01f, 3.47369552e-01f, 2.69452721e-01f, 4.89329338e-01f,
  4.14122730e-01f, 2.07016215e-01f, 1.95913061e-01f, 2.69047797e-01f, 4.66494292e-01f, 3.50684255e-01f, 3.50437015e-01f, 2.77968019e-01f, 2.89163053e-01f, 4.41647232e-01f,
  2.99059838e-01f, 3.60812038e-01f, 3.52576673e-01f, 2.71115780e-01f, 3.44680578e-01f, 2.72312909e-01f, 4.32046831e-01f, 2.41993234e-01f, 3.71076316e-01f, 3.08785290e-01f,
  4.21575129e-01f, 4.10421044e-01f, 4.10963058e-01f, 4.55386013e-01f, 2.49669075e-01f, 4.29159582e-01f, 3.44805628e-01f, 3.62848967e-01f, 2.85897613e-01f, 4.09206271e-01f,
  3.89294654e-01f, 2.95203954e-01f, 6.25882506e-01f, 3.93123716e-01f, 2.66205519e-01f, 5.32430351e-01f, 1.69979706e-01f, 3.86331677e-01f, 5.37256896e-01f, 3.04356873e-01f,
  2.57655889e-01f, 5.39561093e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.26579463e-01f, 6.22294694e-02f, -1.83182701e-01f, -1.51694372e-01f, -5.46975471e-02f, -9.61699784e-02f, -1.55725256e-01f, 8.01790357e-02f, -1.29021317e-01f, -4.41616401e-02f,
  -1.16024077e-01f, 1.11870274e-01f, -3.89798395e-02f, 3.96238156e-02f, -3.16503383e-02f, -1.63511306e-01f, -1.88691974e-01f, -1.38627172e-01f, -1.16721438e-02f, 8.76133516e-02f,
  -2.16198221e-01f, -4.68946844e-02f, 8.74431580e-02f, -7.69671425e-03f, -1.06023468e-01f, 2.44630408e-02f, -7.12116361e-02f, -1.63826093e-01f, -2.07860973e-02f, -1.98648721e-01f,
  1.39467239e-01f, -8.05701539e-02f, -2.26279795e-01f, 1.12041123e-01f, -1.23376675e-01f, -2.30870202e-01f, -4.70691174e-03f, -1.92104638e-01f, -3.01038563e-01f, -2.76229888e-01f,
  -3.44968081e-01f, 3.08953263e-02f, -2.25914210e-01f, -2.68516928e-01f, 2.26353034e-01f, -4.24309112e-02f, 1.69053674e-01f, 2.76069105e-01f, 1.02550797e-01f, -2.32464820e-02f,
  2.73680568e-01f, -1.29719019e-01f, -2.06381544e-01f, 2.67675430e-01f, -4.21473920e-01f, 1.39915362e-01f, -2.25874931e-01f, -9.07617621e-03f, 1.50352791e-01f, -2.72785544e-01f,
  -9.12212953e-02f, -8.10302645e-02f, -3.08884978e-01f, -2.03959700e-02f, 1.90714613e-01f, -2.30999053e-01f, -1.19488828e-01f, -2.82847583e-01f, -8.64808783e-02f, 4.21553224e-01f,
  2.81471521e-01f, 2.06475675e-01f, 1.44111812e-01f, 1.82670131e-01f, -2.29170784e-01f, 1.74863160e-01f, 5.06291151e-01f, -1.77416101e-01f, 3.66488099e-01f, -2.37591892e-01f,
  -2.72841364e-01f, -4.07459170e-01f, -2.01583683e-01f, -5.23113608e-01f, -3.64255637e-01f, -2.85118014e-01f, -3.97230566e-01f, -1.42348662e-01f, 7.94311687e-02f, -3.25631112e-01f,
  -9.49718617e-03f, -4.43376839e-01f, 4.09696370e-01f, 2.58103013e-01f, 4.89338249e-01f, 1.03646539e-01f, 2.40326747e-01f, 8.10783207e-02f, -4.56696481e-01f, -2.89868295e-01f,
  -3.06916982e-01f, -1.50470644e-01f, -1.53786495e-01f, -2.26936042e-01f, -3.08538318e-01f, 7.78840184e-02f, 3.18042964e-01f, -9.66382995e-02f, -6.68108538e-02f, -1.87715694e-01f,
  -1.91227987e-01f, 2.99450606e-01f, 1.47130206e-01f, -2.26632252e-01f, 1.77089974e-01f, -2.70327240e-01f, -1.30769953e-01f, 6.79364875e-02f, -5.49716175e-01f, -3.36929947e-01f,
  -2.45222360e-01f, -4.83334124e-01f, -1.64583892e-01f, 1.87127337e-01f, 1.67582974e-01f, -2.56394804e-01f, 2.77849793e-01f, 2.38696292e-01f, 6.26977475e-04f, -8.83082077e-02f,
  -5.48558757e-02f, 1.18073776e-01f, -1.17759993e-02f, -8.89005587e-02f, -1.28246650e-01f, -1.47769958e-01f, 1.23413339e-01f, -5.41708060e-02f, -3.32402103e-02f, -6.06923923e-03f,
  1.80473506e-01f, -5.51013909e-02f, -3.53855863e-02f, 1.48273975e-01f, 5.31166643e-02f, 9.37887728e-02f, -1.30821690e-01f, -3.00688326e-01f, 3.51438969e-02f, 6.40848875e-02f,
  -2.54270583e-01f, 6.60509840e-02f, 1.86606154e-01f, -1.61642909e-01f, 4.97473544e-03f, -8.12610090e-02f, -1.51273057e-01f, 2.00455070e-01f, -3.92777845e-02f, -2.30622161e-02f,
  1.52547434e-01f, 1.85847819e-01f, 1.02529623e-01f, 1.02758043e-01f, -1.67974994e-01f, 7.77194137e-03f, 3.15671951e-01f, 4.25615162e-01f, -1.19102344e-01f, -4.06665385e-01f,
  7.77605250e-02f, -3.48631352e-01f, 2.35200763e-01f, 4.25587595e-02f, 3.18476945e-01f, -1.18476555e-01f, -4.25536573e-01f, -4.81457375e-02f, -1.79339364e-01f, 3.38368773e-01f,
  1.45429179e-01f, 6.35848716e-02f, 4.34598118e-01f, -3.20214987e-01f, -3.68889540e-01f, -3.20018053e-01f, 3.27979684e-01f, -2.07360893e-01f, 3.97930324e-01f, 9.06504989e-02f,
  -1.06961079e-01f, -3.35914344e-01f, -8.20068717e-02f, -7.46481642e-02f, -2.75156468e-01f, -2.23772898e-01f, -1.22324288e-01f, -4.66510057e-01f, 2.18505785e-02f, -3.44475210e-01f,
  -8.93825069e-02f, 3.01723748e-01f, 4.13208663e-01f, 1.84725970e-01f, -3.89701635e-01f, -9.36886221e-02f, 3.74747485e-01f, -2.14493096e-01f, -3.20914179e-01f, -1.66741192e-01f,
  -1.96626723e-01f, -6.30532503e-02f, -3.23697656e-01f, -2.48692170e-01f, -2.51053393e-01f, -7.55917951e-02f, -4.29496579e-02f, 2.04452366e-01f, -5.88315427e-01f, -5.98566055e-01f,
  -1.28866985e-01f, 1.30268857e-01f, -5.32021880e-01f, -4.42821711e-01f, 2.67653853e-01f, 2.25747064e-01f, 9.35252756e-02f, -2.82431424e-01f, -4.22239751e-01f, -2.50919223e-01f,
  -3.75615686e-01f, -5.26951551e-01f, -2.72462785e-01f, 2.69271165e-01f, -1.54096827e-01f, -4.06606674e-01f, 1.45427078e-01f, 1.49799094e-01f, 5.11236370e-01f, 3.97449821e-01f,
  -4.98750329e-01f, -2.89366722e-01f, -1.69419318e-01f, -2.28460729e-01f, -3.01478863e-01f, 3.14851522e-01f, -4.74759132e-01f, -1.50362462e-01f, 7.99113065e-02f, 3.03750366e-01f,
  -5.60986064e-02f, 5.58263808e-02f, -6.12696111e-01f, 2.32977644e-01f, -4.67195123e-01f, 4.97850239e-01f, -6.71011806e-02f, 1.23049572e-01f, 1.22074008e-01f, -1.21849559e-01f,
  -4.86360956e-03f, -2.84156203e-01f, -1.18498676e-01f, 3.74522209e-02f, 9.76832658e-02f, -1.13857321e-01f, -1.44521400e-01f, -1.82335481e-01f, -1.42240122e-01f, -6.99839815e-02f,
  -3.23333964e-02f, -2.43301373e-02f, 1.16400950e-01f, 5.95751144e-02f, 2.32853536e-02f, -1.53497383e-01f, -1.74755484e-01f, 4.36409786e-02f, -3.56804542e-02f, -1.02355406e-01f,
  -1.63157463e-01f, -1.46753922e-01f, -6.30744621e-02f, 7.50076100e-02f, 7.66845793e-02f, -9.60446596e-02f, -4.40456234e-02f, -1.70173541e-01f, -1.70058608e-01f, 3.70917246e-02f,
  -2.74425596e-01f, 5.05957892e-03f, -3.20282340e-01f, -2.22901199e-02f, -2.17437327e-01f, -1.78892836e-01f, 1.31366357e-01f, 3.03358376e-01f, -2.94908881e-01f, -2.40906969e-01f,
  6.27005026e-02f, 2.19195038e-01f, -2.80100167e-01f, 3.50692928e-01f, -7.61427581e-02f, -1.63540810e-01f, -1.18170097e-01f, 2.41647363e-01f, -3.01913649e-01f, -2.58661509e-01f,
  -5.04647046e-02f, 3.06796312e-01f, -2.41995141e-01f, -2.11566895e-01f, -2.08639279e-01f, -9.30087790e-02f, -2.62848169e-01f, 3.70206088e-02f, -1.68131128e-01f, -1.95926026e-01f,
  -2.74931073e-01f, -3.64042670e-02f, 3.91896330e-02f, 3.25104654e-01f, -1.61313087e-01f, -1.59602776e-01f, -3.15351307e-01f, -2.32556105e-01f, -2.57667035e-01f, 2.24753805e-02f,
  1.75356358e-01f, 1.49384633e-01f, -2.29957074e-01f, 1.29597649e-01f, -1.09606393e-01f, 9.31707695e-02f, -7.71702528e-02f, -2.73776054e-01f, 3.25378865e-01f, -3.17991078e-01f,
  3.32031786e-01f, -2.51716316e-01f, -1.46291330e-01f, -2.52061099e-01f, 1.32159755e-01f, -3.90165538e-01f, 1.47663876e-02f, 3.84821743e-01f, -1.66566595e-01f, -7.05429092e-02f,
  -2.74447322e-01f, -3.11613798e-01f, -2.36265466e-01f, -1.86921522e-01f, -4.04129148e-01f, 1.29914165e-01f, 1.35640711e-01f, -2.21070752e-01f, -1.50908172e-01f, -5.70595190e-02f,
  -2.66719252e-01f, 2.51944572e-01f, -1.57667696e-01f, 5.35698459e-02f, -3.18954229e-01f, 6.11788556e-02f, 4.28080052e-01f, -2.65243262e-01f, -2.64867157e-01f, 1.44138187e-01f,
  -1.27513036e-01f, -2.41132736e-01f, -2.33399227e-01f, -1.37455866e-01f, -4.10637766e-01f, -1.06663458e-01f, -2.42820859e-01f, -1.24691017e-01f, 3.70619655e-01f, 4.97658879e-01f,
  -2.64852524e-01f, -3.22096735e-01f, -1.91721112e-01f, -2.87698865e-01f, 2.50624376e-03f, 5.67484871e-02f, -9.41566974e-02f, -1.17457099e-02f, 3.30480821e-02f, -2.52916068e-01f,
  1.57661294e-03f, 7.12335184e-02f, -2.74401829e-02f, -2.63005346e-01f, -1.91209570e-01f, -3.74978036e-02f, 1.44986838e-01f, -2.94833660e-01f, -1.49144292e-01f, -1.96605548e-01f,
  -4.49223556e-02f, -1.44308284e-01f, 1.96335241e-02f, -5.12289926e-02f, 1.21917479e-01f, -2.04432979e-01f, -8.74446481e-02f, -5.86434789e-02f, -1.29474014e-01f, 1.07151605e-01f,
  7.97884464e-02f, 4.16064598e-02f, -2.49936894e-01f, -1.99385196e-01f, -1.28578499e-01f, -3.93651538e-02f, -2.75166184e-02f, -2.84774322e-02f, -2.13845924e-01f, -1.11103840e-01f,
  -2.08944887e-01f, -8.14154148e-02f, 3.17834616e-01f, -3.43634300e-02f, -3.50592911e-01f, 8.66471156e-02f, 2.62686282e-01f, 3.08301061e-01f, -1.14730611e-01f, -2.17147935e-02f,
  -7.64441788e-02f, 1.30224988e-01f, 1.94501415e-01f, 4.08080608e-01f, 1.50087863e-01f, -1.74577802e-01f, 2.27848347e-02f, 6.45129830e-02f, 1.05120055e-01f, 2.62847334e-01f,
  -1.04331680e-01f, 1.21258900e-01f, -3.03533018e-01f, 2.46687591e-01f, -3.08249563e-01f, -2.78057307e-01f, -2.17336789e-01f, 1.83788314e-01f, 3.95469218e-01f, 2.47698873e-01f,
  3.60734969e-01f, -3.44234794e-01f, 2.54179448e-01f, 9.69999954e-02f, -1.58873815e-02f, 2.70463854e-01f, -4.92949970e-02f, 1.23349346e-01f, -1.45650968e-01f, 1.46768942e-01f,
  -2.93976307e-01f, -4.61588413e-01f, 2.85217255e-01f, 3.37320715e-01f, -2.70825177e-01f, -3.24338078e-02f, 2.01880932e-01f, -2.59341776e-01f, -2.14981616e-01f, -1.40368819e-01f,
  2.59905189e-01f, 4.22769189e-01f, -3.37078422e-01f, -1.14263460e-01f, 2.87238747e-01f, -2.81297773e-01f, -3.90005827e-01f, -3.05601537e-01f, -2.47597359e-02f, 1.98712319e-01f,
  -4.24569756e-01f, -3.45839530e-01f, -4.07853186e-01f, -2.20618039e-01f, -1.47546366e-01f, 1.34049162e-01f, 2.28866592e-01f, -1.45077631e-01f, 2.87785709e-01f, 4.61896211e-02f,
  3.16897660e-01f, -2.56598175e-01f, 1.68187156e-01f, -2.45639011e-01f, -1.68326795e-01f, -2.27984428e-01f, 3.88839215e-01f, -2.99018830e-01f, 4.94599938e-01f, 1.58839285e-01f,
  -3.42016714e-03f, -5.18106520e-01f, -1.45011336e-01f, 2.87820756e-01f, -1.91448480e-01f, -5.13378978e-01f, -1.55459180e-01f, -5.16443014e-01f, -4.43004876e-01f, -2.86075741e-01f,
  2.92565912e-01f, 1.20748617e-02f, -1.49485216e-01f, -9.54104960e-02f, 1.12105690e-01f, -9.64763612e-02f, 1.23013847e-03f, 2.81503111e-01f, -1.42792671e-03f, 7.66094700e-02f,
  1.32210970e-01f, -2.96840649e-02f, 1.57904048e-02f, -1.87311471e-01f, 1.68297127e-01f, 1.53595239e-01f, 3.13704908e-01f, 9.38987285e-02f, 4.41721864e-02f, -4.73864228e-02f,
  3.52500640e-02f, 1.73180565e-01f, 1.50965318e-01f, 1.17010444e-01f, 1.08237229e-01f, -9.59233716e-02f, 2.51534939e-01f, -1.61532983e-01f, -3.19804938e-04f, 1.78121969e-01f,
  1.37896001e-01f, 2.08784088e-01f, -1.81559831e-01f, 5.97766228e-02f, -1.06720263e-02f, -2.93550462e-01f, 1.25636861e-01f, 1.94709271e-01f, 7.03369128e-03f, 2.88021713e-01f,
  -3.87159050e-01f, -1.43610120e-01f, 1.52818784e-01f, 1.81357548e-01f, -1.82878733e-01f, 4.10980910e-01f, -4.06832874e-01f, 6.43062368e-02f, 1.20994858e-01f, 1.41288817e-01f,
  -1.99709058e-01f, -1.21364631e-01f, -1.38364539e-01f, 2.60132253e-01f, 2.52960864e-02f, -2.35563844e-01f, -1.41010851e-01f, 1.81322187e-01f, 7.94075578e-02f, 3.55365515e-01f,
  1.49141401e-02f, 3.32241774e-01f, -1.14930615e-01f, -3.54879498e-01f, -2.79494315e-01f, 3.19379658e-01f, 1.08238153e-01f, -3.11637729e-01f, 3.29999954e-01f, -1.49961919e-01f,
  1.66224822e-01f, 1.88415140e-01f, 3.87297183e-01f, 2.32420936e-01f, 1.18844643e-01f, 1.84379995e-01f, -2.80096978e-01f, 7.52389729e-02f, 2.63273984e-01f, 1.12302572e-01f,
  -5.78086793e-01f, -4.50671822e-01f, -1.12736650e-01f, 4.29063857e-01f, -3.93142521e-01f, 2.67860554e-02f, -1.63045645e-01f, 1.03323840e-01f, -3.03844176e-02f, -3.16802673e-02f,
  -3.00191820e-01f, -3.46117139e-01f, 2.07713827e-01f, 3.57032508e-01f, 1.01976722e-01f, -4.18998897e-01f, 1.20233826e-01f, 2.45797798e-01f, 2.64474172e-02f, -6.71171248e-01f,
  2.98354030e-01f, -1.80517033e-01f, -3.91833365e-01f, 4.77345467e-01f, 2.58383930e-01f, 2.53151923e-01f, -1.35850385e-02f, -2.85391867e-01f, 2.54955500e-01f, 2.26561189e-01f,
  -1.27612889e-01f, -4.52010214e-01f, 3.28111112e-01f, -1.07203722e-01f, 2.55722821e-01f, -2.69474778e-02f, -1.23692438e-01f, -1.99267447e-01f, -4.93702412e-01f, 9.24362689e-02f,
  5.23459554e-01f, -6.97259247e-01f, -2.69102931e-01f, -3.01166952e-01f, -3.74512970e-01f, 2.07387075e-01f, -1.60902873e-01f, -1.69538543e-01f, -1.75142542e-01f, 2.86239058e-01f,
  3.17394882e-02f, 1.55267462e-01f, 2.82296032e-01f, 1.36931315e-01f, 1.42936096e-01f, 2.18530297e-01f, 2.18522817e-01f, 1.17533237e-01f, 1.03345387e-01f, -5.01042269e-02f,
  2.22525150e-01f, 7.78124332e-02f, -9.71072987e-02f, 2.41122738e-01f, 2.78957635e-01f, 1.47763370e-02f, 1.43348619e-01f, 4.39513996e-02f, 2.20777988e-01f, 1.68758243e-01f,
  7.45771676e-02f, 6.18356913e-02f, -1.10755168e-01f, -7.99690485e-02f, 1.47864292e-03f, 7.25053623e-02f, 1.44427910e-01f, 1.00210130e-01f, 2.88321488e-02f, 1.96409076e-01f,
  -1.28340378e-01f, 5.82087412e-02f, 1.60894431e-02f, -4.22216132e-02f, 7.65413418e-02f, -5.78546934e-02f, 2.16737837e-01f, 1.23634391e-01f, 1.63978487e-01f, -6.54676110e-02f,
  1.96996078e-01f, -1.58957481e-01f, -1.73242241e-01f, -9.63534229e-03f, 3.81687433e-01f, 1.82617217e-01f, -1.50086999e-01f, -3.63550484e-01f, 4.32302952e-01f, 2.30325878e-01f,
  3.39055210e-01f, -1.15051024e-01f, 1.83402151e-02f, -2.44014442e-01f, 2.76026845e-01f, -3.47077787e-01f, 1.94181636e-01f, -1.44540891e-01f, 1.77673653e-01f, -1.64236575e-01f,
  2.95766234e-01f, 2.14023720e-02f, 3.50898862e-01f, 3.10415298e-01f, 1.94534734e-02f, -2.59116709e-01f, -1.31926298e-01f, 3.50354135e-01f, 2.85172880e-01f, 1.75280824e-01f,
  9.98124704e-02f, -1.44281797e-03f, 3.51770729e-01f, -3.21196645e-01f, -2.47791260e-01f, -7.95829669e-02f, 6.57542646e-02f, -3.54369909e-01f, -2.58173555e-01f, -3.26620162e-01f,
  -3.52002591e-01f, -3.56425405e-01f, -4.43199417e-03f, 4.48447943e-01f, 2.62531281e-01f, -3.64170820e-01f, -2.51670897e-01f, -1.72409803e-01f, 2.45581374e-01f, 4.02201056e-01f,
  -2.34403074e-01f, 5.03695831e-02f, 2.35001426e-02f, 4.11534041e-01f, -9.69137624e-02f, 1.21145258e-02f, 2.61711985e-01f, 2.98156112e-01f, -5.34158647e-01f, -2.98897594e-01f,
  1.43735297e-02f, -3.15583974e-01f, -2.81197965e-01f, 4.77091759e-01f, 1.80201065e-02f, -4.55778956e-01f, -6.63109183e-01f, -1.07493691e-01f, 1.78560510e-01f, 1.63668431e-02f,
  -5.20315707e-01f, 1.34741604e-01f, -7.19045028e-02f, -3.55444670e-01f, 1.44866183e-01f, -3.87084000e-02f, -1.56049430e-01f, -3.59631062e-01f, 5.31350493e-01f, -2.03223944e-01f,
  -3.72370720e-01f, -6.65943623e-02f, -1.23637035e-01f, -6.60529912e-01f, 4.02383506e-01f, -1.76946551e-01f, -3.92283916e-01f, 3.70742977e-02f, -1.19831212e-01f, -1.20798588e-01f,
  3.00836912e-03f, 6.95613474e-02f, -8.52992535e-02f, 6.68180883e-02f, 4.90782633e-02f, -6.46614432e-02f, -1.61083877e-01f, -1.58191584e-02f, -3.13865915e-02f, 6.24557994e-02f,
  -9.18388218e-02f, 1.19861908e-01f, -2.29861200e-01f, 4.28494159e-03f, 3.42515744e-02f, -5.47288172e-02f, -1.90669119e-01f, 8.77400115e-02f, -2.46529475e-01f, 4.30481620e-02f,
  7.69122094e-02f, 7.00058881e-03f, 1.03861671e-02f, 5.39880879e-02f, 8.38221982e-02f, -7.94942081e-02f, 5.03682047e-02f, -5.92307262e-02f, 1.15696877e-01f, 6.77026585e-02f,
  6.55453876e-02f, 8.89986977e-02f, -1.61120191e-01f, -2.15045512e-01f, -4.57355529e-02f, 1.13279171e-01f, 3.59714955e-01f, 3.53702724e-01f, 1.64921686e-01f, -4.33746248e-01f,
  3.51836145e-01f, -1.26568163e-02f, 4.65754084e-02f, 3.02459925e-01f, -2.27951512e-01f, -2.72189587e-01f, -2.45426193e-01f, 4.82682465e-03f, 2.26849705e-01f, 2.27952451e-01f,
  -1.84657529e-01f, -1.04825951e-01f, 1.12955622e-01f, -1.98129684e-01f, 3.82148087e-01f, 1.19949749e-03f, -1.47081530e-02f, -2.03365877e-01f, -6.71454892e-02f, 3.22301745e-01f,
  -1.54222935e-01f, -1.96558133e-01f, 3.02224398e-01f, -1.94202244e-01f, 3.13840628e-01f, 2.50118107e-01f, 4.29706164e-02f, -3.36052656e-01f, -4.07787085e-01f, 2.68204868e-01f,
  -3.28301072e-01f, -2.46976033e-01f, 3.26090842e-01f, -3.11910987e-01f, 1.38657587e-02f, -3.36923569e-01f, -1.75238073e-01f, 4.00668681e-01f, 4.01676111e-02f, -2.54619002e-01f,
  4.58068587e-02f, 2.55534559e-01f, -3.65213960e-01f, 3.95838410e-01f, -1.96613401e-01f, -3.20645422e-01f, -2.29613334e-01f, 2.75812387e-01f, 2.18900636e-01f, -3.47297668e-01f,
  -3.67756695e-01f, -4.55723584e-01f, -6.64615452e-01f, -6.11576855e-01f, -2.71089792e-01f, 6.80248439e-02f, 1.17543270e-03f, 4.88761485e-01f, 4.80278611e-01f, -3.14414836e-02f,
  2.51496047e-01f, -7.00477064e-02f, -1.45268217e-01f, -3.84877592e-01f, -4.86882776e-01f, 2.99432993e-01f, 7.93936080e-04f, -2.03906402e-01f, -2.84751415e-01f, -4.01469916e-01f,
  -4.43327352e-02f, 4.22162324e-01f, -3.44127536e-01f, -3.43698114e-01f, -2.97295481e-01f, -1.84658051e-01f, -4.70017679e-02f, -5.64651154e-02f, 4.69197810e-01f, -2.83303987e-02f,
  4.83845919e-01f, -9.64098331e-03f, 7.23282844e-02f, -1.91207871e-01f, -1.19465582e-01f, -4.01492178e-01f, -5.67759238e-02f, -1.12529315e-01f, -1.56224770e-02f, -5.07851578e-02f,
  3.36023085e-02f, -2.83899963e-01f, 4.54608724e-03f, -1.32721946e-01f, -1.57418594e-01f, 5.68172671e-02f, -4.55288328e-02f, 5.00113927e-02f, 2.47836318e-02f, 5.98805211e-02f,
  2.14100927e-02f, -2.40744017e-02f, -1.60751734e-02f, -1.57597825e-01f, -1.47465631e-01f, -6.64799586e-02f, 1.31905591e-02f, -2.40353853e-01f, 8.50593969e-02f, -8.01456794e-02f,
  4.19817865e-03f, -1.11570805e-01f, 2.10300479e-02f, -4.37138006e-02f, -3.78626436e-02f, -1.99579880e-01f, -1.63803771e-01f, -8.22139755e-02f, -9.53998044e-02f, -1.83156818e-01f,
  4.34505427e-03f, 7.32211769e-02f, -6.34658635e-02f, -1.34324387e-01f, -6.17391020e-02f, -1.69832721e-01f, 1.07793294e-01f, 2.04428181e-01f, 2.42723867e-01f, 1.08759396e-01f,
  1.44985870e-01f, -2.47231483e-01f, 2.53634363e-01f, 1.19239554e-01f, 7.83874765e-02f, 1.87272788e-03f, 1.81638986e-01f, -1.29319504e-01f, -3.81608531e-02f, 1.63969666e-01f,
  -2.84205943e-01f, 2.08107352e-01f, 1.18599109e-01f, 1.68269023e-01f, 1.95368841e-01f, 1.85415715e-01f, -1.06152311e-01f, -1.56953484e-01f, 2.51665592e-01f, 1.84945524e-01f,
  -2.38559648e-01f, 2.71638304e-01f, -1.87407881e-01f, 3.27058434e-01f, -1.32915407e-01f, 1.81696862e-02f, -2.75016248e-01f, -1.15946151e-01f, 1.18668146e-01f, -1.37867272e-01f,
  -1.17306806e-01f, -2.66208529e-01f, -1.49589956e-01f, -2.14215264e-01f, -2.92577088e-01f, -2.95444787e-01f, -5.92242293e-02f, 8.66222009e-02f, -1.93666309e-01f, -1.69517502e-01f,
  1.84609130e-01f, -9.39967260e-02f, 3.65109324e-01f, 2.96986341e-01f, 4.61024523e-01f, -1.89974651e-01f, 1.00784421e-01f, 9.44485515e-03f, 3.23719345e-02f, -2.09647864e-01f,
  -6.53072223e-02f, 2.28984952e-01f, -1.45046949e-01f, 3.56761888e-02f, 2.35509604e-01f, -2.54276127e-01f, -1.50201485e-01f, -3.09986591e-01f, 8.72149225e-03f, 2.01640520e-02f,
  -6.76709265e-02f, -1.76097468e-01f, -3.36114198e-01f, -1.92358285e-01f, 6.80844337e-02f, -3.36333305e-01f, -2.12692663e-01f, -2.87637115e-01f, 1.40472457e-01f, -8.09970424e-02f,
  -3.85666072e-01f, 2.55366683e-01f, -1.28901199e-01f, -5.46203256e-02f, -8.90993476e-02f, 1.93613574e-01f, 4.02663141e-01f, -1.62183493e-01f, -1.93348840e-01f, -1.43830270e-01f,
  2.18659028e-01f, -2.08387509e-01f, 2.82132268e-01f, -3.30011010e-01f, -1.18287317e-01f, -1.81113258e-01f, 2.74376515e-02f, 3.41657829e-03f, -1.32693693e-01f, 2.37913504e-02f,
  4.82269153e-02f, 5.81355020e-02f, -1.07754961e-01f, 6.44392297e-02f, -1.56454369e-01f, -8.98216963e-02f, 3.37640308e-02f, 7.70289227e-02f, -1.11322522e-01f, 3.53953466e-02f,
  6.57831430e-02f, -1.55126806e-02f, -1.19680725e-01f, 8.82481113e-02f, 5.58236148e-03f, -1.88379928e-01f, 3.37882005e-02f, 6.20661564e-02f, -9.33764055e-02f, 5.46431355e-02f,
  -1.19103473e-02f, -1.86483916e-02f, 2.61000674e-02f, 2.75348220e-02f, -2.64001131e-01f, 4.74433386e-04f, 5.15583344e-02f, -2.69716412e-01f, -8.19508806e-02f, -1.20398924e-01f,
  5.95717877e-03f, -1.12063391e-02f, 1.38053909e-01f, 2.61240542e-01f, -1.18873596e-01f, 2.75728583e-01f, 3.23780924e-01f, 2.76256531e-01f, -1.89302325e-01f, 7.91367292e-02f,
  2.77949303e-01f, -2.60833085e-01f, -1.22039467e-01f, -2.81003445e-01f, 2.62228638e-01f, -2.81181395e-01f, 2.66613722e-01f, 3.34856749e-01f, -1.34864226e-01f, -2.16385514e-01f,
  -6.62584901e-02f, 2.87952363e-01f, -2.55069613e-01f, -1.93830088e-01f, -1.61419451e-01f, 1.97018627e-02f, 1.75704882e-01f, -1.51234791e-01f, -1.47485256e-01f, 1.76852062e-01f,
  1.40723079e-01f, -2.44509697e-01f, -1.85975552e-01f, -1.48522437e-01f, -7.58950710e-02f, -1.08481482e-01f, -2.63918400e-01f, 1.14181653e-01f, 1.90869004e-01f, -1.17932118e-01f,
  -2.14980409e-01f, -1.87281951e-01f, -3.99752766e-01f, -3.21403593e-01f, 3.95914465e-01f, -2.14884803e-01f, -1.46899834e-01f, -2.10772529e-01f, 4.12755847e-01f, -1.66498795e-01f,
  -3.45999062e-01f, -7.93215781e-02f, -2.51058429e-01f, -3.32200259e-01f, -2.73722529e-01f, 3.11927348e-01f, 2.84487516e-01f, 1.74898282e-01f, 2.44078208e-02f, -2.45551318e-01f,
  -2.09189013e-01f, -3.15787345e-01f, -2.25523993e-01f, -1.29112899e-01f, 1.08931050e-01f, -1.16584888e-02f, 1.77564383e-01f, -1.66602716e-01f, -2.87091255e-01f, 3.40850502e-01f,
  -1.89715430e-01f, -7.58644566e-02f, 2.14137763e-01f, 2.05185235e-01f, -2.38553911e-01f, 6.37249053e-02f, -4.09717448e-02f, -2.39541098e-01f, -1.01374254e-01f, -3.09712470e-01f,
  3.70705694e-01f, -1.11422330e-01f, 3.61230880e-01f, 1.25596181e-01f, -1.15787283e-01f, -3.17660421e-01f, -9.91246626e-02f, -4.30001527e-01f, -1.50815127e-02f, 3.35268408e-01f,
  -2.28972971e-01f, -3.91517550e-01f, 1.49941623e-01f, 1.31646395e-01f, -2.47377098e-01f, 1.46071196e-01f, 1.27202675e-01f, 8.80372599e-02f, 1.06829874e-01f, 1.49139285e-01f,
  3.67322415e-02f, 1.93374634e-01f, 8.04482102e-02f, 1.38050824e-01f, 8.76485333e-02f, -2.53996849e-01f, -1.20577633e-01f, -1.80319279e-01f, -1.85164548e-02f, 1.81174390e-02f,
  6.21235482e-02f, -9.44581479e-02f, 2.44402051e-01f, 1.16038203e-01f, -2.26183310e-02f, 1.94460601e-01f, 2.02038940e-02f, 3.70440148e-02f, -5.69625087e-02f, 8.19759592e-02f,
  8.51127058e-02f, -3.66675220e-02f, 1.85221076e-01f, 3.47637311e-02f, -2.66171526e-02f, 1.22542173e-01f, 3.18645462e-02f, -4.63326015e-02f, 8.33139643e-02f, -3.76180381e-01f,
  -2.71984786e-01f, -4.01348658e-02f, 2.75446266e-01f, 3.74182671e-01f, -3.15494418e-01f, -1.46016017e-01f, 4.56555784e-02f, -4.80690509e-01f, -9.02260691e-02f, -1.15926288e-01f,
  -1.54696435e-01f, 4.76189442e-02f, -2.49216378e-01f, 1.64103732e-01f, -1.71841711e-01f, -3.15477610e-01f, -1.90803245e-01f, 2.25787297e-01f, -2.38874741e-02f, -3.41848671e-01f,
  3.33853252e-02f, 4.01634544e-01f, -1.80350356e-02f, -4.76357229e-02f, 3.47290426e-01f, 3.58802944e-01f, 1.87957227e-01f, 1.00726031e-01f, -3.08333099e-01f, 1.96131602e-01f,
  1.74946338e-01f, 1.46602437e-01f, 1.18489921e-01f, 1.15137391e-01f, -3.78581807e-02f, -3.63820463e-01f, 2.15249434e-01f, -3.42247218e-01f, -6.66357204e-02f, 4.84521210e-01f,
  4.68151659e-01f, -3.23502570e-01f, -1.53431073e-01f, -7.42697939e-02f, 7.32335821e-02f, -2.96925128e-01f, -6.31858855e-02f, 7.27541298e-02f, -1.85336694e-01f, -2.28330597e-01f,
  -3.48833650e-02f, -5.33765197e-01f, -4.85280693e-01f, -1.71304181e-01f, -2.12238759e-01f, -4.22672451e-01f, 5.54274142e-01f, 4.01239127e-01f, -2.14217186e-01f, 1.57118857e-01f,
  5.05184770e-01f, 1.68379888e-01f, 8.65476951e-02f, -1.70545354e-01f, 1.28241360e-01f, -3.03765714e-01f, -3.08804423e-01f, -4.12134677e-01f, -5.80298305e-02f, -3.53994280e-01f,
  -3.02825689e-01f, -2.53220975e-01f, -3.54675382e-01f, -3.63419592e-01f, -6.09388351e-01f, 3.14736605e-01f, -3.24666977e-01f, -1.12054236e-01f, -2.62405068e-01f, 1.73052158e-02f,
  9.25045982e-02f, -2.07309365e-01f, -2.84901381e-01f, 4.54951972e-01f, -1.25143617e-01f, -4.62858289e-01f, 1.25130713e-01f, -2.07470596e-01f, -1.93956345e-01f, -4.77352649e-01f,
  5.04658297e-02f, 3.90855633e-02f, -5.74654602e-02f, 9.85485241e-02f, -1.13339734e-03f, 2.93720126e-01f, 3.53707373e-02f, 1.58117011e-01f, -1.24529004e-02f, 1.79790288e-01f,
  2.14601681e-01f, 1.46962544e-02f, -1.72349021e-01f, 7.69575164e-02f, -9.44867283e-02f, 6.68113753e-02f, -8.58801827e-02f, 8.95583034e-02f, -7.91779011e-02f, 1.65158838e-01f,
  -2.04933077e-01f, 1.16877027e-01f, 1.81997448e-01f, -4.99632545e-02f, 6.73509389e-02f, 7.26388171e-02f, -6.64172471e-02f, 1.77600756e-02f, 2.32767642e-01f, -1.38005558e-02f,
  5.80210164e-02f, 1.43254817e-01f, 8.62807930e-02f, 2.36873642e-01f, -6.92599872e-03f, -4.28001843e-02f, 1.26805305e-01f, 3.92166004e-02f, -4.61864769e-02f, -3.47963423e-01f,
  -1.59870997e-01f, -1.24609560e-01f, 1.81408748e-01f, -1.71653807e-01f, -5.92645966e-02f, -2.86314096e-02f, 9.67873931e-02f, 3.22899789e-01f, 1.32407323e-01f, -4.80169624e-01f,
  -4.00186449e-01f, -2.53621578e-01f, 3.03637892e-01f, 3.14234823e-01f, 1.24414161e-01f, -2.54375219e-01f, -1.12693198e-01f, 4.53733355e-02f, -1.19647652e-01f, 7.24911019e-02f,
  1.29440248e-01f, 3.73563945e-01f, -3.01934749e-01f, -3.14889103e-01f, -3.29665333e-01f, 1.05118535e-01f, -2.71721184e-01f, -2.52844751e-01f, -1.00572608e-01f, 2.07311660e-01f,
  -2.34595705e-02f, -7.29790255e-02f, 2.90627539e-01f, -8.20197240e-02f, 3.94068100e-02f, 6.55953167e-03f, -3.35691243e-01f, 2.44836435e-01f, -4.82489169e-01f, 3.42070937e-01f,
  4.24477279e-01f, 1.71458989e-01f, 3.41594338e-01f, -1.92670479e-01f, -4.17961627e-01f, -4.46857423e-01f, -3.14911425e-01f, -8.78723487e-02f, -2.80894697e-01f, -2.88927369e-02f,
  3.53319079e-01f, -3.38659674e-01f, -2.39641890e-01f, -2.56420285e-01f, -2.03781173e-01f, -3.30585241e-01f, -9.49807763e-02f, -2.84169644e-01f, -4.34377789e-01f, -2.60976911e-01f,
  -3.31784993e-01f, -5.44153988e-01f, 8.04832950e-02f, -1.07464612e-01f, 3.20653707e-01f, -3.40347886e-01f, -1.69929534e-01f, -1.04549788e-01f, 2.06711859e-01f, -1.01033814e-01f,
  -3.44447911e-01f, 1.06727118e-02f, -6.72715679e-02f, -2.48552442e-01f, -2.50357330e-01f, 1.40258044e-01f, -1.12060741e-01f, 3.82201523e-01f, -3.17681044e-01f, 3.20173919e-01f,
  -6.94328770e-02f, 3.93503368e-01f, -2.79745013e-01f, 4.46988910e-01f, -2.34016046e-01f, 9.79450494e-02f, 1.12307919e-02f, -3.14977467e-01f, -6.51325583e-02f, -2.84836199e-02f,
  -6.78630322e-02f, 1.00976028e-01f, -1.43876811e-02f, 1.03934452e-01f, -1.37845665e-01f, 5.83905131e-02f, -9.60673243e-02f, -6.82346672e-02f, -1.21658660e-01f, -7.79423863e-02f,
  1.17059544e-01f, -1.23126321e-01f, -1.29360735e-01f, 1.34287432e-01f, 2.68288273e-02f, 2.74851881e-02f, -1.13064550e-01f, 8.08817893e-02f, 1.57850072e-01f, -1.43821596e-03f,
  2.13111155e-02f, 1.22995293e-02f, 8.53915140e-02f, 5.11699878e-02f, 7.48153180e-02f, -8.00709575e-02f, -1.92052141e-01f, 1.10042125e-01f, 2.27573469e-01f, 3.52325179e-02f,
  5.89842461e-02f, 5.24668731e-02f, 6.21779598e-02f, 8.53828490e-02f, 4.21154313e-02f, 9.79392380e-02f, 3.09946723e-02f, 2.24027649e-01f, 2.87892163e-01f, -2.50915557e-01f,
  -2.07331225e-01f, 1.31988540e-01f, -2.58202225e-01f, -2.23480210e-01f, -3.32316011e-01f, -1.98300526e-01f, 2.62181282e-01f, 2.65493482e-01f, -3.30423713e-02f, -2.44843304e-01f,
  2.58978426e-01f, -1.94965303e-01f, 4.11656089e-02f, 1.76030099e-02f, 2.15863362e-01f, 1.15567386e-01f, 5.65683395e-02f, -2.08730951e-01f, 3.83514585e-03f, 3.20006013e-01f,
  2.16341037e-02f, -1.63189843e-01f, 1.97342977e-01f, 3.14203590e-01f, 1.41295835e-01f, -1.75927937e-01f, 2.13832140e-01f, 1.53356418e-01f, 1.59281977e-02f, -2.01435536e-01f,
  4.55870628e-02f, 1.73979878e-01f, -2.91900724e-01f, 2.29998842e-01f, -2.87200779e-01f, 7.62742236e-02f, -8.61097872e-02f, -7.12772012e-02f, 1.61607843e-02f, 2.07320392e-01f,
  -2.84165353e-01f, 7.50668496e-02f, -4.11198318e-01f, 3.84525836e-01f, 3.40436220e-01f, -5.69672398e-02f, -1.56306013e-01f, 2.07504243e-01f, -4.11553144e-01f, 1.80421900e-02f,
  2.17573807e-01f, -1.82858586e-01f, -1.38293013e-01f, -4.33563173e-01f, -4.18100893e-01f, -4.00420487e-01f, -3.45092475e-01f, -2.02936023e-01f, -2.58708179e-01f, 3.33794713e-01f,
  -4.08611447e-01f, 1.74114153e-01f, -3.19242105e-02f, -3.26641500e-01f, 2.02660501e-01f, 4.80375290e-01f, -4.58628982e-02f, 5.06730139e-01f, -2.36369610e-01f, -4.61923391e-01f,
  -4.67834532e-01f, -1.52810454e-01f, 1.86892584e-01f, 3.80718231e-01f, 3.82765561e-01f, -3.18115205e-01f, -1.72380522e-01f, -9.56312567e-02f, -1.09264217e-01f, 9.39716678e-03f,
  -1.73158139e-01f, -2.95876294e-01f, 3.24498981e-01f, 8.74480009e-02f, -4.02335733e-01f, -2.00068757e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.49347690e-02f, 9.08693373e-02f, -7.42596611e-02f, -3.27675603e-02f, 3.35005415e-03f, 5.99415228e-02f, -7.92121217e-02f, -2.97798794e-02f, -3.85210402e-02f, 6.11480745e-03f,
  7.09354058e-02f, 7.02310307e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    