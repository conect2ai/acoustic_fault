/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.71644583e-01f, -1.05775677e-01f, 3.18347305e-01f, -2.95318440e-02f, 1.86293900e-01f, 1.51532382e-01f, 1.74776524e-01f, -9.59564447e-02f, -8.27525184e-02f, 3.41708623e-02f,
  -9.49645936e-02f, -1.28166229e-01f, -2.69282907e-01f, -1.05967641e-01f, 1.34601161e-01f, 1.57192022e-01f, 1.30088106e-01f, 3.40189457e-01f, 2.71798700e-01f, 1.12971336e-01f,
  -1.54132918e-01f, 2.13102266e-01f, 9.29438248e-02f, 1.12739326e-02f, -1.02450199e-01f, -9.79217067e-02f, -4.84027676e-02f, 6.01778999e-02f, -2.11575851e-01f, 4.58096787e-02f,
  2.90930539e-01f, -1.08215719e-01f, 8.76010116e-03f, -1.25936747e-01f, -4.15758640e-02f, -1.21581726e-01f, -1.57599486e-02f, -2.51026284e-02f, -5.68404235e-02f, -1.93960834e-02f,
  -8.43546912e-02f, -1.12459101e-01f, 6.91355243e-02f, 1.65944919e-02f, 1.31797329e-01f, 3.72836217e-02f, 1.42072653e-02f, 7.26147415e-03f, -6.95008785e-02f, 5.21322116e-02f,
  -1.07589632e-01f, 1.98258981e-02f, 1.30546600e-01f, -1.03311352e-01f, -4.71715108e-02f, -6.90894201e-02f, -3.63097852e-03f, -5.18775396e-02f, -1.21578770e-02f, -1.65105276e-02f,
  4.66652289e-02f, 2.65752189e-02f, -8.33569616e-02f, -9.99173522e-03f, -8.84606466e-02f, 8.37863982e-03f, -7.42927566e-02f, 2.12363917e-02f, -6.12325035e-02f, -3.38144526e-02f,
  -2.79397350e-02f, -2.47194897e-02f, 4.36959863e-02f, -1.01783555e-02f, -3.74058187e-02f, 6.37290850e-02f, 3.97167839e-02f, -8.32254887e-02f, -3.22391139e-03f, -5.01696467e-02f,
  -7.90948793e-02f, -4.14457731e-02f, -1.61441136e-02f, 4.18459773e-02f, 2.56859753e-02f, 5.58988797e-03f, -6.23822138e-02f, -5.31461462e-02f, 9.66944732e-03f, -5.20974630e-03f,
  8.74204338e-02f, -2.12337524e-01f, 7.75045063e-03f, -6.07667789e-02f, 2.22247504e-02f, -7.74749070e-02f, -2.62809396e-02f, -1.73786432e-02f, -2.33170819e-02f, -4.50054072e-02f,
  -1.55154224e-02f, 8.76934901e-02f, 2.74650920e-02f, -6.40979409e-02f, 1.56890415e-02f, -8.61770299e-04f, -9.28912461e-02f, 3.65351103e-02f, -1.71215404e-02f, 3.01413275e-02f,
  -1.21045075e-01f, -2.13292893e-02f, -4.67715226e-03f, -4.89026075e-03f, -3.11783887e-02f, 1.00395903e-02f, 3.02525628e-02f, 7.11829141e-02f, 8.30893368e-02f, 4.75548878e-02f,
  1.72984809e-01f, 4.00228649e-01f, 2.58576840e-01f, -9.38151032e-02f, -9.34530571e-02f, 5.12234755e-02f, 4.72884715e-01f, 1.35587335e-01f, -1.65997282e-01f, 1.90425858e-01f,
  -5.76926060e-02f, -3.15446436e-01f, -2.96155423e-01f, -1.35111153e-01f, -2.82049682e-02f, 1.95969045e-01f, 8.08737054e-02f, -3.29427719e-02f, -2.97969252e-01f, -1.36410505e-01f,
  -4.24190238e-02f, 1.24938324e-01f, -3.58538143e-02f, -7.99176544e-02f, 1.89017635e-02f, -1.61820546e-01f, 2.79241472e-01f, 8.91869068e-02f, 3.18848379e-02f, -3.06013525e-02f,
  1.44617677e-01f, 1.38145760e-01f, -1.43146649e-01f, -1.13967501e-01f, 8.06189701e-02f, 4.14787009e-02f, 1.02861561e-01f, 2.75661028e-03f, -1.39496531e-02f, 1.21653467e-01f,
  -4.81718257e-02f, 2.48260275e-02f, 2.27789786e-02f, 8.14134721e-03f, 3.30539979e-02f, 2.28157528e-02f, -3.04336678e-02f, 2.80092899e-02f, 1.03809118e-01f, -3.26625584e-03f,
  2.95317098e-02f, -7.49433273e-03f, 1.10967919e-01f, 5.52025512e-02f, -1.12323180e-01f, -1.23399168e-01f, 3.78224514e-02f, -1.10986298e-02f, 3.10540274e-02f, 2.84665525e-01f,
  6.43171519e-02f, 1.20467246e-01f, -7.38952383e-02f, -2.56804526e-02f, -5.56130111e-02f, 5.99706033e-03f, 2.76912674e-02f, 1.15576563e-02f, -5.02598025e-02f, 8.06974620e-03f,
  -8.34651850e-03f, -3.06807943e-02f, -3.45752761e-02f, 1.03653908e-01f, -7.29048997e-02f, -2.72862762e-02f, 7.36506060e-02f, 3.91639620e-02f, -6.82757571e-02f, 1.20789756e-03f,
  -2.68324763e-02f, 1.89292058e-02f, -6.98066652e-02f, 2.27471273e-02f, 1.35873165e-03f, 5.22971444e-04f, -3.23823728e-02f, 5.44604249e-02f, 7.29005486e-02f, 5.77157326e-02f,
  7.70353079e-02f, -1.27923831e-01f, 1.29006356e-01f, 1.06035024e-02f, 6.21404033e-03f, -2.92842221e-02f, 3.60619873e-02f, 5.20531787e-03f, -4.48212959e-02f, 4.48582917e-02f,
  -1.34561984e-02f, 1.15788355e-02f, -1.09129529e-02f, 2.85244398e-02f, -7.80130252e-02f, -9.02864058e-03f, 6.24381192e-02f, 8.76269583e-03f, -8.18582848e-02f, 6.92757294e-02f,
  2.51573753e-02f, -3.23349098e-03f, 8.25576186e-02f, 8.86987671e-02f, -2.24104226e-02f, -6.43893927e-02f, 1.17223725e-01f, 3.94320823e-02f, 4.58582217e-04f, 3.50840211e-01f,
  -1.46469086e-01f, -3.50230746e-02f, -3.05179030e-01f, 4.21972275e-02f, 9.73149240e-02f, 2.04366028e-01f, 1.67823419e-01f, 1.29085749e-01f, 4.20774780e-02f, 7.13026449e-02f,
  1.14795327e-01f, -6.98653385e-02f, -1.98020339e-01f, -3.76095772e-02f, -1.64782271e-01f, -1.70875385e-01f, -3.09996396e-01f, -3.49743307e-01f, 5.30062914e-02f, 2.44049788e-01f,
  3.58094759e-02f, -2.72256620e-02f, -6.47709742e-02f, 1.14747822e-01f, 1.24961674e-01f, -2.65690172e-03f, -3.35870460e-02f, 3.22358124e-02f, 8.83795097e-02f, -2.52132177e-01f,
  -2.76640747e-02f, 2.40823567e-01f, 5.03477007e-02f, -4.24596742e-02f, -4.00939621e-02f, 3.93333882e-02f, 5.70541956e-02f, 1.16614006e-01f, 9.26855803e-02f, 1.51810143e-02f,
  5.01205288e-02f, -1.10838842e-02f, -9.64971781e-02f, -2.92344894e-02f, 1.33233845e-01f, 3.63178141e-02f, 5.39938919e-02f, -7.11524710e-02f, -5.62571883e-02f, 8.22377428e-02f,
  -2.45427955e-02f, -4.04275246e-02f, 2.75261123e-02f, 3.42555083e-02f, 8.30400661e-02f, -1.07868671e-01f, 1.54163405e-01f, 2.85263974e-02f, -4.51382436e-02f, -1.11219190e-01f,
  5.54661592e-03f, -3.03603765e-02f, 4.56375629e-03f, 6.43143663e-03f, 5.57130687e-02f, 2.12670751e-02f, -4.18620296e-02f, -5.06125353e-02f, 4.13353257e-02f, 5.76199703e-02f,
  3.48789208e-02f, -4.48985733e-02f, -5.07232845e-02f, -6.41476437e-02f, 3.89766097e-02f, -2.97751855e-02f, -4.60484391e-03f, 4.54906113e-02f, 4.27239053e-02f, 5.81856631e-02f,
  4.56640497e-02f, -6.20236546e-02f, -1.93903707e-02f, -3.74812633e-02f, -3.66708003e-02f, -7.74621069e-02f, -7.93654174e-02f, 2.66765486e-02f, -2.28989916e-03f, 5.50613292e-02f,
  -7.87829161e-02f, -3.83757539e-02f, -1.12440795e-01f, 4.09268588e-02f, 2.42420174e-02f, -3.84188183e-02f, 2.59665661e-02f, -9.91786793e-02f, -1.07556060e-02f, 2.88137682e-02f,
  6.98120371e-02f, -2.15751305e-03f, -1.72897032e-03f, 8.02328344e-03f, 1.76882707e-02f, 8.71944726e-02f, -6.48303255e-02f, -1.19507290e-01f, 7.29130441e-03f, -9.65165813e-03f,
  -7.26898201e-03f, 2.35530827e-02f, -1.72426194e-01f, -2.18816437e-02f, -3.24065275e-02f, -1.46631971e-01f, 1.14770466e-02f, -1.09429052e-02f, -2.09999736e-02f, -7.37812230e-03f,
  3.11068028e-01f, -6.34824634e-02f, 2.77159154e-01f, 1.76369831e-01f, 3.06711137e-01f, 2.88796406e-02f, -3.00566424e-02f, -1.90509394e-01f, -1.63321227e-01f, -2.04847916e-03f,
  -2.26022974e-02f, 1.46346595e-02f, 6.63364157e-02f, 8.63182768e-02f, -1.37140853e-02f, -7.74599463e-02f, 1.42283216e-02f, 3.38144600e-01f, 3.16425860e-01f, 2.38538221e-01f,
  1.20414145e-01f, 4.92142111e-01f, 2.67032862e-01f, 3.63036431e-02f, 1.10689178e-01f, 1.05216168e-01f, 8.78620297e-02f, 1.49604365e-01f, -6.37294725e-02f, 1.02814421e-01f,
  1.04195587e-01f, 1.60581842e-02f, -7.00604841e-02f, 3.94881740e-02f, 7.30086192e-02f, -3.85577732e-04f, -2.85862237e-02f, 5.82546107e-02f, -5.15596904e-02f, -6.37864470e-02f,
  -1.80955455e-02f, 6.45602793e-02f, 6.99335113e-02f, 7.18289167e-02f, 1.01280652e-01f, 5.58850309e-03f, 1.63934100e-02f, 4.55286950e-02f, -3.89567874e-02f, 4.01447713e-02f,
  -5.29413186e-02f, -4.01995592e-02f, 3.27004194e-02f, -6.44132942e-02f, -1.41573340e-01f, 1.37419388e-01f, -7.32554197e-02f, -1.12032726e-01f, -1.97557826e-02f, -1.34846509e-01f,
  2.93397065e-03f, 9.27745551e-02f, 4.44448479e-02f, 2.73131393e-02f, 9.22621638e-02f, -4.80618738e-02f, -7.52749667e-02f, 2.43750811e-02f, -4.92508598e-02f, 5.35162576e-02f,
  -5.08330949e-02f, -1.38752265e-02f, -4.54068743e-02f, -9.22859460e-02f, 5.88403828e-02f, -2.49153692e-02f, -7.37926960e-02f, 2.82092802e-02f, -8.76303986e-02f, -4.22597751e-02f,
  5.59817851e-02f, -2.19865199e-02f, 6.01592809e-02f, 2.83314809e-02f, -2.92672049e-02f, 5.98251112e-02f, 8.71673524e-02f, -3.38114761e-02f, -4.86420169e-02f, 1.14034459e-01f,
  1.22810304e-01f, -8.85972679e-02f, -1.53645456e-01f, -1.92485936e-02f, -4.03204225e-02f, -1.63721621e-01f, -6.66081980e-02f, -6.32123053e-02f, -5.91422953e-02f, -6.09775074e-02f,
  -6.72695041e-02f, -4.72843871e-02f, 5.95027693e-02f, -7.71402046e-02f, 2.90404558e-02f, -6.64035678e-02f, 5.26471883e-02f, 4.13550064e-02f, -9.02570263e-02f, -1.66945029e-02f,
  4.06210199e-02f, -7.82104656e-02f, 1.75492000e-02f, -4.65653427e-02f, -2.02272460e-02f, 8.33813548e-02f, -3.39549072e-02f, -7.24540204e-02f, -8.03498328e-02f, -5.65180629e-02f,
  1.32452905e-01f, 2.89405942e-01f, 2.27197200e-01f, 3.55488777e-01f, -1.39197623e-02f, -2.08584607e-01f, 1.23278657e-02f, 5.85100241e-03f, -1.99950719e-03f, 1.84914231e-01f,
  -3.13035473e-02f, -1.91026092e-01f, -7.54463719e-03f, -6.45495281e-02f, -5.67866489e-02f, 4.47081625e-01f, 3.43343168e-01f, 4.41020355e-02f, -3.03022176e-01f, -6.97683990e-02f,
  -7.53765032e-02f, 7.26655424e-02f, -1.17195591e-01f, -7.15194568e-02f, 4.36768234e-01f, -7.64821768e-02f, 2.23591343e-01f, 6.06004298e-02f, -6.57916442e-02f, 5.69784224e-01f,
  2.24945411e-01f, 1.20781362e-01f, -7.95985162e-02f, -1.52953133e-01f, 2.26054769e-02f, 2.79127550e-03f, -5.66177592e-02f, -8.71596858e-03f, -4.17389460e-02f, 2.85861269e-02f,
  1.45950884e-01f, -5.00892513e-02f, -9.20400172e-02f, -2.90888622e-02f, 4.03163992e-02f, 6.77678287e-02f, 5.18003479e-02f, -9.19577759e-03f, 6.07933514e-02f, -1.50620406e-02f,
  2.70291157e-02f, -1.86163913e-02f, 3.26491930e-02f, 5.93050271e-02f, -3.00641675e-02f, -1.74832910e-01f, 1.84027757e-02f, -4.12572213e-02f, -9.27673727e-02f, 1.88893706e-01f,
  -3.14917602e-03f, -4.34724279e-02f, -7.61247128e-02f, -2.07336806e-02f, -5.59836701e-02f, 1.43687529e-02f, 1.11078456e-01f, 2.76672486e-02f, -5.69239259e-02f, -5.70049584e-02f,
  3.47935804e-03f, 1.39343794e-02f, 1.25230663e-02f, 1.44882321e-01f, 4.11777757e-02f, 2.76957657e-02f, 6.90774769e-02f, 3.81033383e-02f, 1.25797382e-02f, 2.00959330e-04f,
  -1.00183271e-01f, -1.11235626e-01f, 9.06077251e-02f, -5.74817844e-02f, 4.18551639e-02f, 1.40932202e-01f, 5.18106520e-02f, -5.63683622e-02f, 4.77963425e-02f, -9.11711678e-02f,
  7.01462179e-02f, -1.28960550e-01f, 2.12283865e-01f, 3.79071347e-02f, 7.57585466e-02f, -9.44405943e-02f, 9.38664600e-02f, 1.17138708e-02f, 1.92185696e-02f, 7.63267800e-02f,
  -2.52116062e-02f, 1.19804949e-01f, 1.68760195e-02f, -8.88465792e-02f, -3.43550108e-02f, 3.11745200e-02f, 9.38707218e-03f, 1.91749651e-02f, -4.97994013e-02f, 2.76344642e-02f,
  3.18356864e-02f, 5.53361140e-02f, -8.66777897e-02f, -4.73232530e-02f, 1.81369409e-02f, -1.26789704e-01f, -6.59504607e-02f, 2.56824289e-02f, -2.62019690e-02f, 2.69813882e-03f,
  3.52505296e-01f, -2.03850284e-01f, -2.42811933e-01f, -1.99981704e-02f, -3.23680669e-01f, -1.74968094e-01f, -3.89562368e-01f, 5.20020723e-02f, 1.47463679e-01f, -1.08443037e-01f,
  -4.31962758e-02f, 2.06395805e-01f, 1.62633553e-01f, 2.91440099e-01f, 3.33535761e-01f, -2.65384048e-01f, -1.85672879e-01f, 7.57305697e-02f, 1.54408857e-01f, -1.27408251e-01f,
  -1.08243130e-01f, -1.81029335e-01f, 2.23627672e-01f, 1.30618334e-01f, -1.22807868e-01f, -4.66494672e-02f, -2.86707938e-01f, -2.77235508e-02f, 1.48131577e-02f, -1.89155340e-01f,
  -2.80012041e-01f, -6.26039207e-02f, 2.87802406e-02f, 5.45877889e-02f, -1.36946216e-01f, 1.06713161e-01f, -1.16359182e-01f, -1.27797738e-01f, 8.17365572e-03f, -6.55114651e-02f,
  -6.15696758e-02f, 4.48288061e-02f, -3.98959666e-02f, -6.09731972e-02f, -1.41011953e-01f, -1.01033843e-03f, 6.83162585e-02f, 1.21084899e-01f, 1.06356576e-01f, -4.77943160e-02f,
  -1.98086668e-02f, -3.86479422e-02f, -5.38347438e-02f, 2.18540821e-02f, 8.51603672e-02f, 6.04911298e-02f, -3.26202018e-03f, 8.61153901e-02f, 1.40514374e-01f, -2.71243732e-02f,
  7.61568025e-02f, -3.58437784e-02f, 2.26224749e-03f, -8.87734350e-03f, 8.08957871e-03f, -5.62538654e-02f, 2.67756055e-03f, -7.04599246e-02f, 5.76916002e-02f, -7.31940567e-02f,
  -3.51994880e-04f, -2.82196933e-03f, -1.43092894e-03f, -2.95408089e-02f, -3.35860178e-02f, 3.21790343e-03f, -5.65496758e-02f, 2.01839954e-03f, -7.67261349e-03f, 3.10475007e-02f,
  2.91477051e-02f, 4.78295237e-02f, -7.56625040e-03f, 3.88495512e-02f, 3.15085463e-02f, 8.33889097e-02f, -2.49975063e-02f, 4.70558181e-03f, -4.90137050e-03f, -3.24156806e-02f,
  -2.42945224e-01f, 2.82971561e-01f, -1.58036426e-01f, 9.47299078e-02f, -1.00014336e-01f, -2.54942849e-02f, -1.09933540e-01f, 7.60451751e-03f, -2.79137231e-02f, -6.04327843e-02f,
  -4.15905677e-02f, 1.55157456e-02f, -4.24033478e-02f, -8.17718823e-03f, -1.93279907e-02f, -9.19592679e-02f, -2.24044938e-02f, -7.28131011e-02f, 2.22614855e-02f, -9.06864554e-02f,
  7.23276436e-02f, 5.44790588e-02f, -2.89689936e-02f, -3.83785851e-02f, -9.89234373e-02f, 7.49558285e-02f, -2.01058090e-01f, -6.19612634e-02f, -4.92051430e-02f, -3.35798174e-01f,
  -4.73899305e-01f, -6.21471591e-02f, 6.63293079e-02f, -2.35639796e-01f, 1.11787558e-01f, 1.17748648e-01f, 3.56801450e-01f, -3.17153372e-02f, -1.95958763e-01f, 9.90225151e-02f,
  -1.30068228e-01f, -1.22879237e-01f, -1.20336358e-02f, 1.75987312e-03f, 2.10725650e-01f, 1.65470287e-01f, 3.11750054e-01f, 2.21765205e-01f, 7.34242573e-02f, -2.17820972e-01f,
  -5.14202639e-02f, -1.45535823e-02f, -1.66688725e-01f, -1.49400756e-01f, -2.68708915e-01f, -1.63928624e-02f, -2.32781898e-02f, -2.22109258e-01f, -1.03053562e-01f, 1.56185463e-01f,
  -2.54733324e-01f, -2.91762829e-01f, 1.42128080e-01f, -1.48641795e-01f, -9.20014679e-02f, -4.79989760e-02f, -1.06738470e-02f, -8.84282961e-02f, -4.97646295e-02f, -1.56816412e-02f,
  -5.33832908e-02f, -8.53613466e-02f, -8.13816562e-02f, -1.05445370e-01f, -2.28277892e-01f, -5.85731082e-02f, -1.54520810e-01f, -1.14983544e-01f, -3.95318754e-02f, -2.26139471e-01f,
  -1.32771909e-01f, -1.73187733e-01f, -1.18561402e-01f, -1.70395151e-01f, -1.85615465e-01f, -7.16129765e-02f, -2.10690975e-01f, -2.21786425e-01f, -7.26055503e-02f, -4.73746397e-02f,
  -2.33854577e-02f, -4.32809480e-02f, 2.01158784e-02f, -1.64677445e-02f, -8.11277423e-03f, 3.71806789e-03f, -2.28894297e-02f, 3.25958580e-02f, 4.49683331e-02f, -2.47252602e-02f,
  6.19256012e-02f, 8.50688946e-03f, -5.94765209e-02f, 1.86862573e-02f, 5.01768775e-02f, -6.34821355e-02f, 1.07975274e-01f, 3.04660909e-02f, -2.60314140e-02f, 6.12253211e-02f,
  4.21618000e-02f, -5.37591167e-02f, -3.00536342e-02f, 1.02649197e-01f, -1.11738825e-02f, 1.31365228e-02f, 3.85663025e-02f, -4.61985543e-02f, -1.63385063e-01f, -2.26261523e-02f,
  8.19033664e-03f, 1.62106052e-01f, -4.35675494e-02f, -2.35527083e-02f, -2.75770482e-03f, 7.43996305e-03f, -4.09522466e-02f, 3.43821384e-02f, -1.40155889e-02f, 1.02694906e-01f,
  -5.86921871e-02f, 1.34204878e-02f, -1.98919736e-02f, -4.58499081e-02f, 1.72925275e-02f, 4.92164455e-02f, 2.34723259e-02f, 7.32563064e-02f, 7.16144443e-02f, -1.61294430e-01f,
  7.50341825e-03f, 9.73671004e-02f, 8.60648304e-02f, 1.39681756e-01f, -4.55960780e-02f, 7.38993585e-02f, 1.16947889e-01f, 4.65364531e-02f, 2.18111500e-01f, 2.04394788e-01f,
  -5.80785386e-02f, -1.91949531e-02f, -3.38137329e-01f, 1.55293301e-01f, 1.41919583e-01f, 1.10684168e-02f, -2.15126246e-01f, -5.87849841e-02f, 1.38873056e-01f, -1.71391293e-01f,
  -6.31710961e-02f, 1.85934469e-01f, 4.70454916e-02f, 8.10549930e-02f, 4.50412109e-02f, -9.99700353e-02f, -5.15561998e-02f, 8.39643925e-03f, 7.73966387e-02f, 1.60729483e-01f,
  1.50830701e-01f, -1.30867660e-02f, 5.49556874e-02f, 9.49246362e-02f, 9.76219848e-02f, 1.34829789e-01f, -8.93059298e-02f, 6.49997815e-02f, 1.22123696e-01f, 2.04923630e-01f,
  -1.07178763e-01f, 1.65324539e-01f, 1.07955039e-01f, 7.90442154e-02f, 7.71251321e-02f, 7.18324408e-02f, 5.70664480e-02f, -6.14105212e-03f, 6.22926913e-02f, 5.32351397e-02f,
  4.87644263e-02f, 1.59923822e-01f, 1.03217602e-01f, 1.48237512e-01f, 1.34586990e-01f, 1.72181241e-02f, 2.18442618e-03f, 5.98254204e-02f, -5.44996820e-02f, -3.26523855e-02f,
  7.39121363e-02f, 6.68590441e-02f, -7.65407309e-02f, 3.02202981e-02f, 3.35395411e-02f, 1.34558633e-01f, -2.99208872e-02f, 8.77222195e-02f, -5.30693717e-02f, -9.70622748e-02f,
  6.42936230e-02f, -2.56462544e-02f, -7.98892304e-02f, -9.31656733e-02f, -1.72718823e-01f, -5.70170879e-02f, 5.94088109e-03f, -3.83081730e-04f, -8.92547593e-02f, -1.02018863e-01f,
  5.81815094e-02f, -4.11081947e-02f, -5.56075983e-02f, -8.22343379e-02f, -4.35693469e-03f, -4.46913131e-02f, -9.73046273e-02f, 6.28481358e-02f, -2.30125450e-02f, -3.54026183e-02f,
  -4.00471240e-02f, -2.08662674e-02f, -1.99591499e-02f, -4.62231115e-02f, -8.57473351e-03f, 4.71167453e-02f, -4.04377766e-02f, 1.63307264e-02f, -9.45640579e-02f, -6.19805679e-02f,
  -5.54907992e-02f, 1.58290163e-01f, -4.44296189e-03f, 1.15869176e-02f, 7.15736374e-02f, 2.67785229e-02f, 5.19286729e-02f, 1.32708251e-01f, 1.70069337e-01f, 4.84923506e-03f,
  3.71888615e-02f, -1.00854943e-02f, 4.10893597e-02f, 9.52554941e-02f, 8.69342536e-02f, 5.14027253e-02f, -2.44078077e-02f, 5.95744187e-03f, -4.27070074e-02f, 2.01139804e-02f,
  -5.85946441e-03f, -8.59057754e-02f, 1.97633617e-02f, -3.54336866e-04f, 6.05608523e-02f, 5.36932535e-02f, -1.31754111e-02f, -1.00100085e-01f, -7.10987672e-02f, -2.32988566e-01f,
  2.77989414e-02f, 7.10860565e-02f, 2.81018049e-01f, -3.53131771e-01f, 2.89047152e-01f, 2.53931671e-01f, 4.07596380e-01f, -6.92659542e-02f, -2.81639457e-01f, 2.86156237e-01f,
  1.08516648e-01f, -1.25932381e-01f, -6.07432909e-02f, 8.13961320e-04f, 6.71446440e-04f, 3.40354800e-01f, 2.79713154e-01f, 7.24416673e-02f, -1.20609328e-02f, 4.81768213e-02f,
  -7.56064430e-02f, 1.12314578e-02f, -1.58431932e-01f, -8.28722492e-02f, 7.87883103e-02f, 8.22217315e-02f, 1.49272606e-01f, 2.26127222e-01f, 2.78596818e-01f, 1.70349017e-01f,
  2.59294122e-01f, 1.37555555e-01f, 4.88745011e-02f, 4.84960712e-02f, 5.95318377e-02f, -9.94017869e-02f, 2.44883560e-02f, 3.85048846e-03f, -3.98802049e-02f, 9.87381563e-02f,
  5.71752079e-02f, 1.27467876e-02f, -1.14409968e-01f, -2.95248739e-02f, -3.39193307e-02f, -2.36161985e-02f, -7.66627770e-03f, -8.69341008e-03f, 8.72661546e-02f, 1.23023964e-01f,
  2.14322031e-01f, 3.10963780e-01f, 2.47432783e-01f, 4.97185402e-02f, -2.92659383e-02f, -6.03259169e-02f, -8.64891335e-03f, 3.78432637e-03f, 1.56605449e-02f, 1.37980387e-01f,
  1.43606573e-01f, -4.26437445e-02f, -8.04371014e-02f, -2.54895631e-02f, -9.22312737e-02f, -3.52020115e-02f, -4.19140123e-02f, -6.70169154e-03f, -1.37166172e-01f, -4.93793637e-02f,
  -5.66050895e-02f, 1.55840889e-02f, -9.83551070e-02f, 2.63120774e-02f, -5.61277661e-03f, -2.90870527e-03f, -2.11960021e-02f, 3.92731093e-03f, -5.28826229e-02f, -6.80403337e-02f,
  1.19812498e-02f, -2.66092643e-02f, 3.50754485e-02f, -1.31772414e-01f, 1.20685071e-01f, -1.08160660e-01f, 4.43996228e-02f, -2.91664973e-02f, 2.67559104e-02f, -6.43193051e-02f,
  -1.67883456e-01f, 1.65234566e-01f, 6.44826442e-02f, -5.73692359e-02f, 2.76182275e-02f, 1.13121346e-01f, 6.82454631e-02f, -1.78720411e-02f, -1.77854598e-02f, 1.11862505e-02f,
  6.63578063e-02f, -1.98470354e-02f, -2.85288156e-03f, 2.72944905e-02f, -6.44313022e-02f, -6.51453529e-03f, 6.80452362e-02f, 4.79932576e-02f, -1.83688931e-03f, 1.16931081e-01f,
  9.75499004e-02f, 1.66958630e-01f, 1.52960598e-01f, 6.36304766e-02f, 7.19162310e-03f, 1.12524442e-01f, 7.20165595e-02f, 1.16326980e-01f, 1.53640106e-01f, 4.70962003e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.28779042e-01f, -7.14631577e-04f, 1.62737906e-01f, 1.30086616e-01f, 2.41237745e-01f, 2.92501837e-01f, 3.63322884e-01f, 1.96026802e-01f, 1.27068996e-01f, 6.25734329e-02f,
  9.08072516e-02f, -3.46497186e-02f, -1.89447433e-01f, -1.01896480e-01f, -1.19826145e-01f, 8.03730488e-02f, 2.36832291e-01f, -8.33168328e-02f, -1.35000855e-01f, 8.25406611e-02f,
  -7.50422180e-02f, -2.63565153e-01f, -2.68938154e-01f, -1.66901916e-01f, -4.49128635e-02f, -1.88357696e-01f, -1.31848752e-01f, -2.05520630e-01f, -2.28184789e-01f, -2.41077811e-01f,
  -9.23098549e-02f, -1.08903914e-03f, 9.29338485e-02f, 2.02475172e-02f, 3.37348282e-02f, -7.49560585e-03f, 9.92467627e-02f, -5.46639636e-02f, -4.92857583e-02f, 6.89620897e-02f,
  1.19737856e-01f, 3.96553241e-03f, 6.61426112e-02f, -6.82579502e-02f, -2.74574663e-02f, 2.21526120e-02f, 1.19420826e-01f, -5.41940331e-02f, 1.29197761e-01f, 1.54582277e-01f,
  9.28185061e-02f, 1.54962406e-01f, 1.91098705e-01f, 1.39125735e-01f, 6.79474026e-02f, 6.89425692e-02f, 1.78666599e-02f, -8.80678967e-02f, -8.18163250e-03f, 3.51146795e-02f,
  8.11285675e-02f, 9.13065225e-02f, 1.80871449e-02f, -4.57261577e-02f, -8.19216482e-03f, -1.62944302e-03f, 5.10501824e-02f, 1.62386358e-01f, -6.99637458e-02f, -2.29147281e-02f,
  1.72287604e-04f, -3.53256688e-02f, 1.08888589e-01f, -1.14611760e-01f, -9.51147079e-03f, 2.83843707e-02f, -2.29903888e-02f, 1.43741071e-01f, 4.98741418e-02f, 8.24315697e-02f,
  2.99927890e-02f, -2.84427535e-02f, -9.99533106e-03f, -2.67534629e-02f, 1.29381167e-02f, 2.18505472e-01f, 1.13011532e-01f, -1.43804085e-02f, 1.06389765e-02f, 1.73647664e-02f,
  8.98934677e-02f, -8.19192908e-04f, -1.87647671e-01f, 5.04930168e-02f, -5.40438183e-02f, -1.96350403e-02f, 3.61807197e-02f, -7.43354559e-02f, 5.78486249e-02f, 1.19489081e-01f,
  1.48045063e-01f, 6.12863712e-02f, -2.96164565e-02f, -3.75475502e-03f, -7.24029243e-02f, 2.24050619e-02f, 2.82730162e-02f, 3.31693441e-02f, 1.64381787e-01f, 1.46806151e-01f,
  1.47794679e-01f, 7.32944906e-02f, 2.39900663e-01f, 1.11010581e-01f, -2.25478262e-02f, -3.27847078e-02f, 1.58633944e-02f, 3.91739570e-02f, 8.10977072e-02f, -1.41658485e-01f,
  2.49501392e-01f, 2.12175831e-01f, -7.48701766e-02f, -3.52623016e-02f, -2.21701771e-01f, -3.67347300e-01f, -3.98145735e-01f, -2.22133193e-02f, 1.18633635e-01f, 1.75434947e-01f,
  2.49834899e-02f, 9.31975842e-02f, -4.19001840e-02f, 2.81922966e-02f, 6.92842230e-02f, -8.71429071e-02f, 6.93634897e-02f, 7.82745481e-02f, -3.28472078e-01f, -2.36840565e-02f,
  1.23459056e-01f, 1.30466251e-02f, -9.28423032e-02f, 1.37873068e-01f, 3.53161901e-01f, 1.27825886e-01f, -4.24083322e-02f, 1.47577852e-01f, 8.91220644e-02f, 6.89300835e-01f,
  1.25432089e-01f, 1.65655971e-01f, -1.80210991e-04f, 1.37391433e-01f, 3.15637365e-02f, 1.02683000e-01f, 5.25207398e-03f, 1.12528995e-01f, 6.63620681e-02f, -2.35426389e-02f,
  5.47095686e-02f, 5.73168881e-02f, -1.35297969e-01f, -7.06566572e-02f, -7.26775676e-02f, 4.68865335e-02f, 7.05435947e-02f, 8.31962656e-03f, 7.94973820e-02f, 4.88751195e-02f,
  1.26598060e-01f, 9.58168060e-02f, -4.88379933e-02f, 1.15591642e-02f, 7.38719851e-02f, -2.49614217e-03f, 5.41962162e-02f, 2.03983232e-01f, 2.55481061e-02f, 3.07337105e-01f,
  -1.28872050e-02f, -1.12822384e-01f, 4.99626063e-03f, -3.51714678e-02f, -4.38446701e-02f, -1.12733096e-01f, 1.53910359e-02f, -1.51308537e-01f, -4.97783646e-02f, -9.03189406e-02f,
  -1.70345128e-01f, 5.29698431e-02f, 1.27583429e-01f, -4.83688861e-02f, 2.58287545e-02f, -5.88300377e-02f, -5.39051834e-03f, 8.71087015e-02f, 1.07546635e-01f, 3.61325368e-02f,
  4.35615964e-02f, 1.06715180e-01f, -1.61042456e-02f, 1.60589159e-01f, 1.36533380e-01f, -1.25585077e-02f, 1.15123011e-01f, -1.89633183e-02f, -4.34263311e-02f, -4.89049666e-02f,
  -1.98372960e-01f, -2.99457014e-01f, 2.91198213e-02f, 1.60602704e-01f, 1.41739815e-01f, 1.68018654e-01f, 1.58975348e-01f, 1.14806339e-01f, -3.35019678e-02f, 7.09449872e-02f,
  5.32018431e-02f, -8.23543295e-02f, -7.39035308e-02f, 4.86021899e-02f, -9.40128565e-02f, 7.95924217e-02f, 1.02270283e-01f, 6.11533560e-02f, 9.51151997e-02f, 1.37310654e-01f,
  1.16336063e-01f, 5.82372025e-03f, -6.76369108e-03f, -1.84308812e-01f, -1.00920089e-01f, -1.15963727e-01f, -1.04774028e-01f, -5.31368367e-02f, -2.18701541e-01f, -2.15645209e-01f,
  7.57416308e-01f, -3.77809815e-02f, 3.03589195e-01f, 3.48127335e-01f, 2.68829584e-01f, 3.26117754e-01f, 5.28184593e-01f, 2.41572499e-01f, 5.88265248e-02f, 1.68719053e-01f,
  8.67041051e-02f, -2.01043531e-01f, -1.19634181e-01f, -3.09310526e-01f, -1.01525635e-01f, -3.07197403e-02f, -4.52637821e-02f, -1.36520177e-01f, 1.17872521e-01f, 1.16972685e-01f,
  -1.24060676e-01f, 1.05088487e-01f, 1.19135991e-01f, 4.27239202e-02f, -7.43714496e-02f, -1.58590645e-01f, -5.19389361e-02f, 1.87455993e-02f, -2.47545511e-01f, -5.57065248e-01f,
  -4.41199392e-01f, -1.07104786e-01f, -1.02483712e-01f, -8.91743079e-02f, 7.36999661e-02f, 7.26325810e-02f, -3.82070132e-02f, 2.97504570e-02f, 2.20793292e-01f, 7.75714591e-02f,
  -1.41677754e-02f, 1.76084302e-02f, -2.75448263e-02f, -2.59647425e-02f, 6.45140037e-02f, 6.45301910e-03f, 8.49414393e-02f, -1.97985061e-02f, -6.95279315e-02f, -1.39558911e-01f,
  -9.68967676e-02f, 6.25611320e-02f, -2.61058584e-02f, -2.20595226e-02f, 7.09390789e-02f, -9.96355992e-03f, -6.64781779e-02f, -5.92977107e-02f, -1.14366494e-01f, 5.17885648e-02f,
  5.20397648e-02f, 1.79341480e-01f, 2.02128235e-02f, -4.02588435e-02f, -3.88204702e-03f, 1.19542539e-01f, 1.22918718e-01f, 2.68353336e-02f, -1.57562853e-03f, 7.41039738e-02f,
  1.58598684e-02f, -1.43686742e-01f, -9.08932462e-02f, 1.00419678e-01f, -1.02108456e-01f, -6.13143481e-02f, -4.22265427e-03f, -1.88016128e-02f, -3.66157219e-02f, -1.12481648e-02f,
  2.22864132e-02f, 1.55068953e-02f, -5.62260151e-02f, -2.12609380e-01f, -1.65885165e-01f, 2.58021858e-02f, -8.51100013e-02f, -6.92401873e-03f, 1.26014307e-01f, 2.29642466e-02f,
  -4.20513153e-01f, -8.88933614e-02f, -9.98888165e-02f, -1.51164949e-01f, 1.31328911e-01f, 9.24525782e-02f, -1.06212996e-01f, -7.78609663e-02f, -4.04407345e-02f, 1.05164945e-01f,
  1.03438206e-01f, -1.57996435e-02f, 1.28512969e-02f, 4.61796783e-02f, 1.55155882e-01f, 9.86881405e-02f, -8.60132277e-02f, 2.53603682e-02f, -1.13555044e-01f, -2.27007177e-02f,
  1.59401409e-02f, 1.74544036e-01f, 6.87811300e-02f, 1.45185798e-01f, -9.23504680e-03f, -4.96458821e-02f, 6.79831728e-02f, 9.35245529e-02f, 6.02093153e-02f, 3.00945133e-01f,
  6.53155267e-01f, 5.13306081e-01f, 2.00893730e-02f, 2.64391396e-03f, 7.65957683e-02f, -4.78256010e-02f, 1.23360060e-01f, 3.43131809e-03f, -9.18413997e-02f, 9.53295156e-02f,
  1.15684964e-01f, -7.21204132e-02f, -1.53828040e-01f, 3.54558937e-02f, 4.84084859e-02f, 1.33290440e-01f, 4.55125608e-03f, 1.61288470e-01f, -1.63073823e-01f, 8.81653503e-02f,
  7.07677305e-02f, 1.48424476e-01f, 2.18548462e-01f, -1.65023282e-02f, 1.76536754e-01f, -1.79625884e-01f, -2.43871398e-02f, 1.99810773e-01f, 1.59533873e-01f, 5.56101084e-01f,
  2.52680719e-01f, 1.81802139e-01f, -2.62365609e-01f, 6.05281517e-02f, -1.42102886e-03f, -2.52404045e-02f, 4.77720611e-02f, 2.88951630e-03f, -6.37464002e-02f, 5.56028709e-02f,
  8.41547400e-02f, 1.20722130e-01f, 1.42042249e-01f, 1.04088426e-01f, 2.93405149e-02f, 3.74921001e-02f, 1.62227340e-02f, 9.06744376e-02f, -1.14604637e-01f, 2.10436583e-02f,
  1.89780071e-01f, 1.01659879e-01f, 1.13206893e-01f, -9.45630446e-02f, 6.04509981e-03f, 9.88675747e-03f, 1.06673412e-01f, 5.06086759e-02f, -1.45447969e-01f, 1.76406145e-01f,
  6.24678992e-02f, 6.29755780e-02f, 9.74056646e-02f, 9.33826044e-02f, 1.31447807e-01f, 3.48031484e-02f, 8.47202688e-02f, 8.38893726e-02f, 1.45860231e-02f, 1.56925946e-01f,
  -4.25557345e-02f, 2.21501477e-02f, -7.86658973e-02f, 5.45999110e-02f, -7.12454990e-02f, 2.51712576e-02f, -1.61608178e-02f, -2.26872116e-02f, 1.75546447e-03f, -4.32575941e-02f,
  8.20528790e-02f, 8.39610100e-02f, -2.25326903e-02f, 1.01396516e-01f, 3.79143050e-03f, -3.37690078e-02f, -3.85133456e-03f, 3.69582660e-02f, -2.82274298e-02f, 9.36530456e-02f,
  -3.93179238e-01f, -3.50891709e-01f, 6.94342107e-02f, 9.68364775e-02f, 4.65689301e-02f, -1.00441858e-01f, 2.03641932e-02f, -7.28387386e-02f, -2.62148976e-02f, -6.36367574e-02f,
  -2.18167938e-02f, -5.48620485e-02f, 1.20231003e-01f, -3.80446203e-02f, -1.29551545e-01f, -1.79745346e-01f, 5.50660007e-02f, -7.49449879e-02f, -2.67313980e-02f, -1.08544856e-01f,
  5.69292121e-02f, -9.02970284e-02f, -1.84895173e-01f, -1.66352853e-01f, -8.69557485e-02f, -2.86999375e-01f, -1.48958564e-01f, -9.27091017e-02f, -2.63286382e-01f, -6.49908632e-02f,
  -1.71581939e-01f, 5.44605516e-02f, 5.04308417e-02f, -9.26906914e-02f, -4.54119183e-02f, -1.54610783e-01f, -1.42834052e-01f, -1.18601710e-01f, -1.32475942e-01f, -9.41524133e-02f,
  -2.52083093e-01f, -1.74215659e-01f, -1.12566061e-01f, 2.17607960e-01f, 9.72468555e-02f, 1.19054519e-01f, 4.48467612e-01f, 3.71083379e-01f, 1.04930371e-01f, 2.18226854e-02f,
  3.03351402e-01f, 1.33760989e-01f, 5.86441346e-02f, 1.24349929e-01f, 1.49758950e-01f, -7.03104436e-02f, 7.77280554e-02f, 1.04152218e-01f, 1.48278847e-01f, 6.23222709e-01f,
  -9.00289640e-02f, -1.41276106e-01f, -7.84405023e-02f, -1.26916856e-01f, 4.80946600e-02f, 1.71178102e-01f, -8.29285830e-02f, 5.56566454e-02f, 4.81985398e-02f, 1.03574350e-01f,
  -3.10761444e-02f, 3.65805365e-02f, -1.33826397e-02f, 2.01911405e-01f, -1.46706894e-01f, -7.11994618e-02f, 1.23371460e-01f, 1.76032513e-01f, -7.02624097e-02f, 3.60766985e-02f,
  1.72800124e-01f, -8.98811147e-02f, -1.72820956e-01f, -1.20885573e-01f, -1.55798331e-01f, -7.54696205e-02f, -1.51307687e-01f, -1.78424362e-02f, -1.10576294e-01f, 1.74008403e-02f,
  -2.38853451e-02f, -1.28698703e-02f, 8.42349827e-02f, -4.28649262e-02f, 1.12183414e-01f, -4.53725494e-02f, 1.25285968e-01f, -3.68860550e-02f, 1.18166231e-01f, 7.05401301e-02f,
  4.87110764e-02f, -4.38896827e-02f, 2.26211883e-02f, 3.74266058e-02f, -8.70139971e-02f, -8.10213480e-03f, 1.71268713e-02f, 7.93599412e-02f, -4.41363566e-02f, 1.42669296e-02f,
  -1.15483571e-02f, 3.91508155e-02f, -2.53406521e-02f, 4.61414196e-02f, -4.96734530e-02f, 3.73431556e-02f, 1.26168765e-02f, -4.42567505e-02f, 1.97429359e-02f, -6.60015047e-02f,
  -3.07760000e-01f, 3.58223952e-02f, -1.72114566e-01f, -8.57727453e-02f, -2.38438416e-02f, 4.64047596e-04f, -3.70558314e-02f, 1.77920312e-02f, -9.74212736e-02f, -8.04187357e-02f,
  -1.43451110e-01f, -6.32708967e-02f, -8.24253708e-02f, 6.31095767e-02f, 1.29409563e-02f, -1.63920283e-01f, 3.16846780e-02f, -3.42364796e-02f, -6.46457672e-02f, 4.99330871e-02f,
  5.39522693e-02f, -3.49172533e-01f, -2.69512713e-01f, -8.74261484e-02f, -1.01918317e-01f, -2.85882294e-01f, -1.30997762e-01f, -2.34333411e-01f, -4.67919350e-01f, -2.47387007e-01f,
  6.86659455e-01f, 8.52402508e-01f, 1.04694009e-01f, 2.91085821e-02f, 4.29333188e-02f, -4.50509526e-02f, 1.71345517e-01f, -3.91706191e-02f, -8.17993283e-02f, 1.78209752e-01f,
  1.28900945e-01f, -4.08326834e-02f, -1.07207065e-02f, -7.80272931e-02f, 1.01435073e-01f, -1.02074869e-01f, -1.93523735e-01f, -6.27326444e-02f, -2.16716453e-01f, -5.49856722e-02f,
  -9.65963379e-02f, -1.76260266e-02f, -3.94042730e-02f, -2.12578718e-02f, 1.73199266e-01f, -8.82925838e-02f, -1.17896236e-01f, 1.22664399e-01f, -2.58689560e-02f, 3.93063545e-01f,
  1.73342243e-01f, 4.86164033e-01f, -2.47972086e-01f, 6.80725649e-02f, -7.22571164e-02f, -1.65167987e-01f, -8.82474333e-02f, -3.14281555e-03f, -2.35443246e-02f, -8.39232374e-03f,
  7.18178749e-02f, 1.97008494e-02f, 7.64027461e-02f, -6.24432713e-02f, 2.96403095e-02f, -1.21275797e-01f, -1.36091217e-01f, -5.33702634e-02f, -1.27834529e-01f, 4.99800965e-02f,
  4.70111445e-02f, 1.49776563e-01f, 2.05578059e-01f, -6.35258034e-02f, -6.69600591e-02f, 2.34726467e-03f, 5.09513840e-02f, 4.45766822e-02f, 3.31536867e-02f, 8.51747096e-02f,
  -8.30227286e-02f, 1.28084242e-01f, 3.43297012e-02f, 7.95670412e-03f, -1.10062994e-01f, -5.42453900e-02f, -6.11722954e-02f, -3.49096470e-02f, -7.53221586e-02f, -2.67836377e-02f,
  -1.25902399e-01f, -4.55982350e-02f, -1.22686207e-01f, -1.34877563e-01f, -1.02947779e-01f, 6.41165078e-02f, 1.05152704e-01f, -3.11174750e-04f, -8.08666125e-02f, 8.86101462e-03f,
  -3.83706540e-02f, -6.51299730e-02f, 3.09287682e-02f, -5.78634962e-02f, 1.83378402e-02f, 1.44011855e-01f, -5.76414466e-02f, 7.50906812e-03f, 7.23523460e-03f, -4.17717434e-02f,
  1.90213416e-03f, 1.91350468e-02f, -1.68675274e-01f, -2.17241291e-02f, 9.23338905e-02f, 2.66805361e-03f, -5.05805425e-02f, -5.50794192e-02f, 4.57286648e-02f, 1.92369267e-01f,
  3.47042233e-02f, 8.57379064e-02f, 5.07449359e-03f, -8.91562626e-02f, -7.63047561e-02f, -1.96681514e-01f, 7.67941959e-03f, -3.81962247e-02f, -1.72516048e-01f, 2.25624312e-02f,
  -1.07772775e-01f, -8.02696422e-02f, -7.83798657e-03f, -1.00257784e-01f, -8.43785256e-02f, -9.06350985e-02f, -9.93709713e-02f, -1.28575535e-02f, -1.77373603e-01f, -1.63045943e-01f,
  7.70977676e-01f, -4.11002576e-01f, -6.04146779e-01f, 3.91564131e-01f, -1.42562553e-01f, -1.19983040e-01f, -3.75991911e-01f, 2.22098470e-01f, 4.20101672e-01f, -1.69448763e-01f,
  -1.80220738e-01f, 1.64326727e-01f, -1.14933796e-01f, -9.59368870e-02f, 1.72775723e-02f, -3.64626676e-01f, -2.75411278e-01f, -1.89226642e-01f, 1.13941908e-01f, 1.98566899e-01f,
  1.11708693e-01f, 2.10110232e-01f, 1.66033581e-01f, 1.39863789e-01f, 7.54641891e-02f, -8.89058039e-02f, -4.30221289e-01f, -1.13566838e-01f, -3.21158648e-01f, -3.89455348e-01f,
  -2.33703345e-01f, -1.61849499e-01f, -2.48141657e-03f, 3.59886736e-02f, 5.40541038e-02f, 1.12477489e-01f, 1.70160942e-02f, -3.63333002e-02f, -4.69565362e-04f, -1.00749791e-01f,
  -7.81471729e-02f, 1.43839167e-02f, 3.03390604e-02f, -1.18626416e-01f, -4.82556857e-02f, 1.81063086e-01f, -5.25113419e-02f, 4.71801311e-03f, -1.05180189e-01f, -3.42360847e-02f,
  -2.38495916e-02f, -1.40967906e-01f, -8.87913704e-02f, -1.45806715e-01f, -1.27331186e-02f, -2.74348464e-02f, -1.91996694e-01f, 3.92221175e-02f, -9.33456421e-02f, -9.97465178e-02f,
  3.40381749e-02f, -2.83178017e-02f, -5.60392765e-03f, 2.46046204e-02f, 2.73362640e-02f, 4.21626717e-02f, -6.13393039e-02f, -3.21481377e-02f, 4.12388444e-02f, 4.22996245e-02f,
  -4.54101004e-02f, -8.07378814e-02f, 2.91610397e-02f, -6.45069107e-02f, -1.42736435e-01f, 4.75579165e-02f, 6.81439117e-02f, -1.37289548e-02f, -3.57272588e-02f, 6.38171211e-02f,
  -1.78925321e-02f, 1.18020423e-01f, -5.40822856e-02f, 5.26441038e-02f, -9.15024057e-02f, 1.31192962e-02f, -8.15210789e-02f, 1.14118736e-02f, 3.73403132e-02f, -3.38962139e-03f,
  2.77118057e-01f, -1.14648670e-01f, 5.09985052e-02f, 2.90973764e-02f, -2.85327015e-03f, 8.69163312e-03f, -3.77229899e-02f, -2.74314955e-02f, -1.70889553e-02f, 6.19479939e-02f,
  -5.19222021e-02f, -3.53588462e-02f, -6.62311018e-02f, -5.88409416e-02f, 3.32049765e-02f, -3.38697657e-02f, 1.01648308e-01f, 1.09784417e-01f, -4.59672734e-02f, -6.03921637e-02f,
  1.32524911e-02f, -5.98785887e-03f, 1.87436029e-01f, -3.27942148e-02f, 1.20678410e-01f, 7.22125173e-02f, -4.55573611e-02f, 6.44982308e-02f, 5.52958697e-02f, 1.59685120e-01f,
  -1.43723801e-01f, -1.43877640e-01f, -7.93864429e-02f, 1.61118716e-01f, 2.12263808e-01f, 4.17200699e-02f, -3.58353108e-01f, 1.52303670e-02f, 2.35647067e-01f, -5.69079034e-02f,
  2.11831674e-01f, 2.35366181e-01f, 1.76612735e-02f, -7.42051676e-02f, -1.23853579e-01f, -1.52726293e-01f, -2.40075350e-01f, -2.05244169e-01f, 5.00177182e-02f, 2.78271943e-01f,
  5.63811101e-02f, -2.35363562e-02f, -9.40503106e-02f, 1.13897458e-01f, 1.13084570e-01f, -1.72064062e-02f, -1.41864434e-01f, -7.61856586e-02f, -1.60075173e-01f, -2.67731667e-01f,
  -3.36740986e-02f, 1.01346694e-01f, -1.22740464e-02f, 2.17505898e-02f, -8.68422911e-02f, -8.11795890e-02f, 5.90943545e-02f, -4.46080118e-02f, 8.66564959e-02f, -2.49879211e-02f,
  1.87244549e-01f, 2.40285769e-02f, 1.37315974e-01f, -8.74339789e-02f, 3.77850868e-02f, 7.53020570e-02f, -9.05721337e-02f, -1.89516023e-02f, -1.23407073e-01f, -1.46846175e-01f,
  2.73282621e-02f, 2.41778567e-01f, -4.11205851e-02f, -2.00772002e-01f, -1.30458876e-01f, -1.37713209e-01f, -2.14303717e-01f, 6.02682419e-02f, -2.81730324e-01f, -4.07750160e-01f,
  -1.00832693e-01f, -9.80880260e-02f, -8.05801302e-02f, -1.07615881e-01f, -1.87330190e-02f, 5.97635210e-02f, -5.65345660e-02f, -1.08014144e-01f, 2.98560578e-02f, -3.42299007e-02f,
  -2.32856013e-02f, 1.69621799e-02f, 1.27717361e-01f, -2.04018168e-02f, -5.31621575e-02f, 7.23194629e-02f, 8.57791305e-02f, -2.54919797e-01f, -9.92873907e-02f, -5.08928597e-02f,
  -7.03213736e-03f, 5.55158826e-03f, 1.09268621e-01f, 7.56580532e-02f, -7.88279995e-02f, -2.04633642e-02f, -1.68956026e-01f, 5.37189767e-02f, 1.08452756e-02f, 3.14212553e-02f,
  8.72436725e-03f, -1.25758737e-01f, 4.23616171e-02f, 4.14941907e-02f, -1.11828819e-02f, 8.26831385e-02f, -5.18991947e-02f, -5.71763255e-02f, 1.19400501e-01f, -1.07592285e-01f,
  -3.17717753e-02f, -1.08163387e-01f, -1.34661794e-02f, -3.54088806e-02f, -3.04495357e-02f, -1.31737143e-01f, -2.25246772e-01f, -2.70577483e-02f, 1.82061624e-02f, 6.16833717e-02f,
  -8.46401602e-02f, -1.46551549e-01f, -2.18438357e-01f, -3.64110947e-01f, -5.07651605e-02f, -1.87062323e-01f, -2.33290106e-01f, -9.18711573e-02f, -1.79916784e-01f, -4.90589797e-01f,
  -3.77094507e-01f, 1.93297535e-01f, -8.32393393e-02f, 1.20012611e-02f, 6.83751702e-02f, -9.52985883e-02f, -2.46705428e-01f, -1.91778168e-01f, 7.00000674e-02f, 1.16390012e-01f,
  5.36502413e-02f, -1.64425477e-01f, -1.30130246e-01f, -2.84017622e-01f, -5.82617879e-01f, -1.42058223e-01f, -2.20858857e-01f, -4.46676403e-01f, -5.27980924e-01f, -2.99296349e-01f,
  -2.48340070e-01f, -2.96497017e-01f, -3.99088293e-01f, -1.08212397e-01f, 3.78349096e-01f, 1.15828924e-01f, 2.23829985e-01f, 8.54673758e-02f, 1.47624969e-01f, 2.17668906e-01f,
  1.49690241e-01f, 6.94342852e-02f, -1.43585145e-01f, -1.80721000e-01f, 1.33309498e-01f, 5.94928786e-02f, -1.29195675e-01f, -3.80441807e-02f, -6.90872455e-03f, -2.19606943e-02f,
  1.37519687e-01f, -1.16393365e-01f, 5.76871354e-03f, 1.34562179e-02f, -1.46132901e-01f, -2.55142897e-01f, -8.97555575e-02f, -1.39532909e-01f, -1.47118717e-01f, 3.49949524e-02f,
  -3.90085131e-02f, 8.59422237e-03f, -7.30360523e-02f, 8.54736120e-02f, -6.37834743e-02f, -1.49555847e-01f, 1.56895146e-01f, 1.53124988e-01f, 5.14211580e-02f, 2.33276397e-01f,
  8.91451538e-03f, 9.27426815e-02f, 7.34522641e-02f, -5.01467008e-03f, -6.46246737e-03f, 5.56729585e-02f, 1.02085367e-01f, -6.42916262e-02f, 5.85361682e-02f, -3.95402461e-02f,
  -1.85798462e-02f, 5.37370443e-02f, 3.57568986e-03f, -1.03151593e-02f, -6.56071166e-03f, 3.56064253e-02f, 4.91584353e-02f, -5.15369549e-02f, -2.74374578e-02f, 4.08301018e-02f,
  -1.48123413e-01f, -1.68733131e-02f, 8.72815922e-02f, -1.92269478e-02f, -2.03363504e-02f, 6.75967801e-03f, -1.05736695e-01f, -7.02014789e-02f, -3.93816317e-03f, 8.96277372e-03f,
  -1.68133751e-02f, -1.82962924e-01f, 6.31727278e-03f, -1.05006509e-01f, 1.21010736e-01f, 1.15826696e-01f, 2.37852875e-02f, 7.58082792e-02f, 5.51409014e-02f, -1.58025742e-01f,
  -2.23278388e-01f, -1.25886187e-01f, 1.41914546e-01f, 1.44688515e-02f, -1.09899499e-01f, -3.28059979e-02f, 2.96911746e-02f, -6.22892659e-03f, -7.43336752e-02f, 9.97466817e-02f,
  -1.94160268e-02f, -2.30884373e-01f, -1.59512237e-01f, -6.69533610e-02f, -1.12141687e-02f, -1.30878732e-01f, -8.30270946e-02f, 2.59626079e-02f, -2.66655415e-01f, -1.37775228e-03f,
  -7.04030216e-01f, 3.63669187e-01f, -2.93772280e-01f, -1.16010539e-01f, 4.43776727e-01f, 4.66798455e-01f, 4.06502068e-01f, 3.20278816e-02f, 2.47128736e-02f, 1.65331572e-01f,
  3.70201953e-02f, 1.27236657e-02f, -1.13242514e-01f, 2.97625754e-02f, -6.38168082e-02f, 2.07049489e-01f, 2.60456741e-01f, -1.71160847e-01f, -3.53200257e-01f, -2.87710503e-02f,
  2.24222437e-01f, -1.05079450e-01f, -4.86385167e-01f, -1.34993866e-01f, 1.21738330e-01f, 5.01841791e-02f, -1.19611025e-01f, -4.70827222e-02f, 2.09472820e-01f, 4.89580750e-01f,
  -3.07784051e-01f, -6.10032603e-02f, -2.78482229e-01f, -6.15962707e-02f, 3.86797301e-02f, -8.07024390e-02f, -8.12941492e-02f, -1.94809765e-01f, -3.95726599e-02f, -1.61924079e-01f,
  -4.88098934e-02f, -1.04251681e-02f, 9.36608687e-02f, -4.54426631e-02f, -1.13821819e-01f, -6.87734485e-02f, 3.71800289e-02f, -2.23427981e-01f, -2.79653639e-01f, -1.28562197e-01f,
  3.80778879e-01f, 1.76680356e-01f, -2.04652116e-01f, 1.08990064e-02f, -2.02766880e-02f, -2.40739379e-02f, -1.41495153e-01f, 5.03926203e-02f, -1.63985536e-01f, 1.46145061e-01f,
  9.72143898e-04f, -4.15237509e-02f, 1.09069601e-01f, -1.48233736e-03f, -4.89008762e-02f, 8.13924819e-02f, 8.75647217e-02f, 1.77964624e-02f, 4.97913097e-05f, -1.10671543e-01f,
  -4.09777202e-02f, 3.13253328e-02f, -4.98622358e-02f, -7.44359270e-02f, -1.17266662e-01f, 3.37102935e-02f, 2.31132098e-02f, 1.24140970e-01f, 1.09899223e-01f, -5.99486716e-02f,
  3.37338634e-02f, -7.55838752e-02f, 2.41887216e-02f, -5.15003353e-02f, 2.61944056e-01f, -1.12150889e-03f, 1.48280948e-01f, 1.39618805e-02f, -4.35980782e-02f, -1.37240037e-01f,
  -2.59103775e-01f, -1.96398851e-02f, -1.21871650e-01f, -1.84366219e-02f, 6.67710826e-02f, -5.47346957e-02f, 1.26219448e-02f, -2.26712171e-02f, -7.79614672e-02f, 1.93919931e-02f,
  -8.66042003e-02f, -8.61743465e-02f, 5.63084297e-02f, 5.58992568e-03f, -1.84043735e-01f, 9.05955303e-03f, 1.49533466e-01f, -4.06991318e-02f, -1.15474137e-02f, 3.39870043e-02f,
  -5.36475182e-02f, -6.90975189e-02f, -1.92039877e-01f, -6.50231466e-02f, -4.52971039e-03f, -4.31060717e-02f, -2.17398301e-01f, -7.53411129e-02f, -2.39680499e-01f, -1.65138096e-01f,
  3.54444355e-01f, 4.34736699e-01f, -5.96981704e-01f, 5.07020414e-01f, -2.65888155e-01f, -1.82423815e-01f, 1.89360842e-01f, 3.15946728e-01f, 2.52504200e-01f, 1.91417545e-01f,
  -2.22038645e-02f, -2.26707652e-01f, -1.43227011e-01f, -2.13137731e-01f, -8.25866684e-02f, 6.57014996e-02f, 2.86014900e-02f, -4.82530415e-01f, -3.78871650e-01f, -9.99281481e-02f,
  2.51339048e-01f, 1.89004242e-01f, 1.82664365e-01f, 5.94701320e-02f, 1.14356212e-01f, 1.11432709e-01f, 1.33322418e-01f, 9.49872937e-03f, -7.58293718e-02f, -3.79306257e-01f,
  -4.27709967e-01f, -1.38083488e-01f, -1.83136553e-01f, 9.94425192e-02f, -4.04984429e-02f, 4.87208515e-02f, -1.04811087e-01f, -2.60385089e-02f, 4.68666255e-02f, -2.13406445e-03f,
  -8.12606364e-02f, 5.82919903e-02f, -9.04641747e-02f, 9.63385552e-02f, 9.91620719e-02f, -1.33882880e-01f, 1.36954129e-01f, -9.16016251e-02f, 9.08214152e-02f, -2.44466681e-02f,
  -1.13629373e-02f, -3.29880446e-01f, -4.01099980e-01f, -1.20983206e-01f, -2.29202211e-01f, -1.61339730e-01f, -9.85359997e-02f, -2.77778924e-01f, -1.20805472e-01f, 1.81996316e-01f,
  -8.02112464e-03f, -1.15102649e-01f, 2.79353801e-02f, -1.73845496e-02f, 1.14676267e-01f, -4.17976938e-02f, -1.07338183e-01f, 1.64668150e-02f, 6.67889118e-02f, 3.61423939e-02f,
  -7.38851279e-02f, -8.96160374e-04f, -3.27676907e-02f, 6.15336262e-02f, 3.55758741e-02f, -3.34049985e-02f, -8.39747712e-02f, 1.20897904e-01f, -1.39190620e-02f, 5.92092909e-02f,
  5.63853458e-02f, -5.70806563e-02f, 4.64683324e-02f, 1.96879003e-02f, 5.32293655e-02f, 5.90811810e-03f, -2.35022735e-02f, -3.05779465e-02f, 8.77902955e-02f, 7.40836784e-02f,
  3.52493584e-01f, -1.77391991e-01f, 4.12877612e-02f, -4.30599041e-02f, -6.37404993e-02f, 1.24195315e-01f, -5.95866293e-02f, 4.30737697e-02f, 7.61212707e-02f, -2.24065315e-02f,
  -1.19843587e-01f, -5.53919643e-04f, 5.14282882e-02f, -5.72385313e-03f, 8.20357539e-03f, -1.07892320e-01f, 2.70427048e-01f, -8.94113928e-02f, 5.11940457e-02f, 2.74432935e-02f,
  2.92333573e-01f, 9.64630991e-02f, 4.69629318e-02f, -5.13092130e-02f, 8.97390619e-02f, -5.56774102e-02f, 4.34214249e-02f, 1.11478172e-01f, -4.74049300e-02f, 4.67990458e-01f,
  -6.52367100e-02f, -2.25820448e-02f, -3.69759984e-02f, 4.79270518e-01f, 3.87634039e-01f, 3.54472518e-01f, 2.44415939e-01f, 2.98254758e-01f, 2.85805166e-01f, 1.82687789e-01f,
  1.85589522e-01f, 3.79265010e-01f, 3.27165991e-01f, 2.33925924e-01f, 7.45137855e-02f, 2.65691131e-01f, 3.75380754e-01f, 9.98820066e-02f, 9.71938670e-02f, 1.80849358e-01f,
  3.18606794e-01f, 1.46460593e-01f, -1.22106731e-01f, 2.75262929e-02f, -9.56481788e-03f, 2.96359956e-01f, 2.10021242e-01f, -4.34055589e-02f, 9.17655304e-02f, 7.06821382e-02f,
  -2.83852667e-01f, -3.19312289e-02f, 1.59593225e-01f, 2.42579300e-02f, -2.24748001e-01f, -2.31450930e-01f, 2.80266628e-02f, -2.16958448e-01f, -8.33314806e-02f, 8.02309811e-02f,
  3.29991169e-02f, -7.30402023e-02f, 2.52598356e-02f, -1.15335293e-01f, -1.47767767e-01f, -6.13677837e-02f, -2.00387865e-01f, -2.71766968e-02f, 2.17714608e-01f, -2.86391415e-02f,
  8.21255594e-02f, -6.49464801e-02f, -2.90191565e-02f, 9.48641151e-02f, 1.49664739e-02f, 8.65704715e-02f, -8.54650065e-02f, -1.41404212e-01f, -4.26028967e-02f, -7.42112994e-02f,
  2.32937306e-01f, 1.02976747e-01f, -5.96118607e-02f, 7.84940496e-02f, -9.31062698e-02f, 2.57470831e-02f, 4.22965772e-02f, 6.07143044e-02f, 5.07837571e-02f, -1.87004700e-01f,
  -2.76951063e-02f, 2.07267672e-01f, 1.70071088e-02f, 8.45225453e-02f, 4.37092483e-02f, 6.21342734e-02f, -1.20605595e-01f, -3.93350087e-02f, -1.66567355e-01f, 2.09085848e-02f,
  4.04530577e-02f, -1.88681539e-02f, -1.62067965e-01f, -1.00919567e-01f, -1.21314190e-02f, 1.69625089e-01f, 9.19345543e-02f, -7.81014236e-03f, 8.08772817e-02f, -1.88414042e-03f,
  1.66918486e-01f, 1.93527594e-01f, 3.44377197e-02f, 1.74692363e-01f, -1.30127430e-01f, -1.98664591e-01f, 8.83040726e-02f, -4.86792140e-02f, -1.16637297e-01f, 4.38323990e-02f,
  -7.60782510e-02f, -1.01830825e-01f, -1.19320676e-01f, -5.62704168e-02f, -6.38320446e-02f, -7.00415671e-02f, -1.05204798e-01f, 8.06826949e-02f, 1.42665386e-01f, -2.99052820e-02f,
  7.01679429e-03f, 6.87575340e-02f, -1.71289430e-03f, -8.59615207e-03f, 7.21755102e-02f, 1.11191392e-01f, -3.63458581e-02f, 1.35350628e-02f, -7.45350271e-02f, -3.50983962e-02f,
  7.82964170e-01f, 2.64497876e-01f, 3.11592907e-01f, -2.24555567e-01f, -1.59003839e-01f, -7.85563961e-02f, 1.96945965e-01f, 2.62787193e-01f, -3.35453730e-03f, 2.51392387e-02f,
  1.26309926e-02f, -3.21931273e-01f, -1.50826588e-01f, -1.13147356e-01f, 2.70138294e-01f, 1.27833739e-01f, 3.72032113e-02f, 1.68196633e-01f, 2.03340203e-01f, 6.62215874e-02f,
  -1.02016136e-01f, 8.48521143e-02f, 2.63703704e-01f, 5.56633398e-02f, 7.11589158e-02f, -2.34955892e-01f, 6.20551445e-02f, 1.46446899e-01f, 1.65048931e-02f, 3.16887572e-02f,
  -1.90503135e-01f, 2.39071399e-01f, -5.83564378e-02f, 1.56580135e-02f, 2.39305887e-02f, 1.36388391e-01f, 3.41461524e-02f, 1.33742914e-01f, -1.73013614e-04f, -6.75085336e-02f,
  -1.45022973e-01f, -3.54089439e-02f, -8.88295770e-02f, 1.06788166e-01f, 1.05663883e-02f, 7.05508217e-02f, 8.06514472e-02f, 1.56009585e-01f, 4.20754738e-02f, -3.59353833e-02f,
  -4.78268638e-02f, 3.06554269e-02f, 6.23673759e-02f, 3.71623337e-02f, -3.29538295e-03f, -2.54486594e-02f, 1.21900767e-01f, 1.09889805e-02f, 4.66325060e-02f, 1.36953473e-01f,
  -9.97487530e-02f, -3.80689204e-02f, -1.86966479e-01f, -8.17490369e-02f, -1.76356375e-01f, -1.86395153e-01f, -1.87555730e-01f, -1.59895539e-01f, -7.28694648e-02f, 4.84770387e-02f,
  -1.71767343e-02f, -1.38192534e-01f, -1.69036731e-01f, -1.32463668e-02f, -7.16569647e-02f, -3.31317335e-02f, -3.87941636e-02f, -1.05455711e-01f, -2.12435007e-01f, -1.26033917e-01f,
  -8.43007118e-03f, 4.84861881e-02f, -5.80169028e-04f, 1.19000049e-02f, 2.55015306e-02f, -2.52554324e-02f, -2.89580971e-02f, 7.39537552e-03f, 1.21314161e-01f, 6.40453491e-03f,
  -2.59964168e-01f, -2.28423938e-01f, -4.28702906e-02f, 5.01349345e-02f, -4.55409959e-02f, 9.10381153e-02f, -1.65005356e-01f, -3.73072438e-02f, -1.09366670e-01f, -5.91848902e-02f,
  -8.31742883e-02f, -5.70873246e-02f, -5.88671640e-02f, -1.05573405e-02f, -1.12830892e-01f, 1.16508699e-03f, -8.30320045e-02f, 5.87811358e-02f, -1.72637314e-01f, -1.97278559e-01f,
  -1.57558784e-01f, -3.00527401e-02f, -6.59731552e-02f, -2.33280994e-02f, -1.56555383e-03f, -1.53532878e-01f, -1.61405951e-01f, -3.04864850e-02f, -1.25754431e-01f, -9.64036770e-03f,
  6.73900604e-01f, 1.53103814e-01f, 3.18172574e-01f, 1.60509884e-01f, 2.79381663e-01f, 3.57167095e-01f, 5.06299734e-01f, 1.71233177e-01f, -1.74626000e-02f, 1.37151212e-01f,
  6.54091761e-02f, -2.19123319e-01f, -2.28565425e-01f, -2.25500569e-01f, 1.06788963e-01f, 5.32651953e-02f, -6.64125383e-02f, 1.20835729e-01f, 1.99953571e-01f, 2.01673746e-01f,
  -2.13139966e-01f, 7.44216666e-02f, 1.63374156e-01f, -4.73709032e-02f, 5.31328470e-03f, -2.38023460e-01f, 1.64422959e-01f, 2.20410064e-01f, -3.02503873e-02f, -2.59636909e-01f,
  -1.56370900e-03f, 4.27913427e-01f, -3.00361484e-01f, -2.10719109e-01f, -4.21807356e-02f, -8.66293907e-02f, -8.44606981e-02f, -2.93810945e-02f, -6.89304620e-02f, -1.17673077e-01f,
  -9.56549868e-02f, 3.64401862e-02f, 5.85255213e-02f, 7.88533911e-02f, 1.65554032e-01f, 4.60972358e-03f, 1.66175097e-01f, -1.28726214e-02f, 2.29376927e-02f, -8.98265615e-02f,
  -1.64312556e-01f, 7.74797127e-02f, 1.75334036e-01f, 2.32510176e-02f, 1.07607186e-01f, -7.43703842e-02f, 1.03242151e-01f, 4.67327759e-02f, 6.81920126e-02f, -7.08590122e-03f,
  -4.29432243e-02f, -1.49543434e-01f, 9.59544629e-02f, 1.21174552e-01f, 1.57742593e-02f, 6.13618568e-02f, -5.82288690e-02f, 3.45880352e-02f, 3.45186144e-02f, 1.48696244e-01f,
  7.97329994e-04f, 2.87139267e-02f, 9.12430882e-02f, 3.93717848e-02f, -2.58589908e-02f, 3.09547614e-02f, 1.09886020e-01f, 8.41370225e-03f, 6.51628003e-02f, 7.14716315e-02f,
  1.83181614e-01f, -7.20959306e-02f, 4.86026295e-02f, 1.03555880e-01f, 6.17396533e-02f, 6.46788105e-02f, -8.59703030e-03f, -3.37897316e-02f, 1.67797937e-03f, -6.69938996e-02f,
  -2.80150920e-01f, 1.32469997e-01f, -1.11295402e-01f, -2.21337583e-02f, 5.54989688e-02f, 3.32946740e-02f, -1.40792385e-01f, -1.56004548e-01f, -1.76761121e-01f, -4.67895865e-02f,
  -6.63682520e-02f, -6.05871491e-02f, 2.21970286e-02f, 1.01952337e-01f, 8.84884298e-02f, -3.22220773e-02f, 1.06451223e-02f, -5.33435829e-02f, -7.99589455e-02f, -9.41040888e-02f,
  -1.23447925e-02f, 6.24807589e-02f, 3.07147875e-02f, -1.38237430e-02f, -8.67805853e-02f, -1.48244366e-01f, -7.57937357e-02f, 3.21297087e-02f, -2.70818714e-02f, 3.02850399e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.70908093e-01f, -5.48690930e-02f, 2.12827176e-01f, -8.31948444e-02f, 1.15741774e-01f, 1.31460235e-01f, 3.06925893e-01f, -1.26917243e-01f, 2.00397387e-01f, 1.64100587e-01f,
  -1.52999878e-01f, 8.92816111e-03f, 3.21686529e-02f, 2.13491321e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.87015476e-03f, -8.45858231e-02f, 2.78497078e-02f, -1.75536290e-01f, 3.45718324e-01f, 1.70071006e-01f, 1.24747194e-02f, 2.37077009e-02f, -8.50211382e-02f, -1.00013360e-01f,
  -1.75900608e-02f, 4.79941666e-02f, -9.92344990e-02f, -6.29117191e-02f, -1.79131478e-01f, -1.53514758e-01f, -1.08543269e-01f, -1.23128276e-02f, -1.34708524e-01f, -1.05406288e-02f,
  -1.71524718e-01f, -2.14382008e-01f, 7.51987249e-02f, -1.96437404e-01f, 2.67297253e-02f, 8.36152881e-02f, 2.18404889e-01f, 1.13838226e-01f, 4.35563296e-01f, 2.09753513e-01f,
  -6.82649463e-02f, -1.28979728e-01f, -2.75941063e-02f, -9.33533236e-02f, 9.86049883e-03f, 4.91137877e-02f, 1.74211189e-01f, 1.35327816e-01f, -7.13066533e-02f, -1.07114110e-02f,
  1.32625103e-01f, 1.72672376e-01f, 2.73342848e-01f, -8.17156285e-02f, 2.59192884e-01f, -3.43851745e-02f, -6.23351522e-02f, 2.08455503e-01f, -1.96353808e-01f, -3.81253064e-02f,
  2.02353634e-02f, -1.72096580e-01f, 3.47688869e-02f, 1.17543235e-01f, 1.81877285e-01f, -1.86138880e-02f, -2.72996366e-01f, -2.36467153e-01f, -6.79731369e-02f, 2.81934207e-03f,
  3.65237631e-02f, 3.20621580e-02f, -5.77410078e-03f, 1.90354465e-03f, -1.25978678e-01f, -7.56476298e-02f, -1.50211193e-02f, 8.92673954e-02f, 1.00585282e-01f, -6.88997582e-02f,
  -2.25089744e-01f, -1.71022817e-01f, 8.24485570e-02f, 1.96186468e-01f, 2.53340423e-01f, 4.08559628e-02f, 3.32919270e-01f, 2.61918511e-02f, -2.88301796e-01f, 3.08002681e-01f,
  -1.62632968e-02f, -1.65407918e-02f, 7.77399465e-02f, 5.74268140e-02f, -1.49301916e-01f, 1.66765496e-01f, 4.11444485e-01f, -3.58918309e-02f, -5.96937299e-01f, -5.17686829e-02f,
  6.37272298e-02f, 2.23928869e-01f, -2.65133619e-01f, 5.41911386e-02f, 1.60924986e-01f, -8.48122463e-02f, 6.05915412e-02f, 2.32529230e-02f, 6.89565670e-03f, 1.45450411e-02f,
  1.83556929e-01f, -1.32319823e-01f, 2.48083547e-02f, 9.58384648e-02f, -2.99862139e-02f, 3.41342896e-01f, -5.71491607e-02f, -2.38231540e-01f, 7.12493015e-03f, -2.25431606e-01f,
  -2.09139045e-02f, 2.01151296e-01f, -5.85096888e-02f, 9.71133038e-02f, -9.12303329e-02f, -2.32787982e-01f, 1.92699492e-01f, -3.92877460e-01f, 1.72973186e-01f, -4.88093525e-01f,
  2.38797560e-01f, -3.42266262e-01f, -2.49546215e-01f, -4.07467633e-01f, 2.58388311e-01f, 1.34347215e-01f, -1.89704616e-02f, -1.56899691e-01f, -6.17875606e-02f, -9.41617563e-02f,
  -5.52502088e-02f, 4.13557589e-02f, -7.29708746e-02f, 8.66896659e-03f, -4.15728241e-03f, 1.71530712e-02f, -1.82315916e-01f, -4.71907854e-02f, 6.64103031e-02f, 3.82348187e-02f,
  -2.38459483e-01f, 1.73356369e-01f, -8.01960751e-02f, -4.08904582e-01f, 5.49817644e-02f, 1.58768773e-01f, 2.48613134e-02f, 1.37962550e-01f, 1.21467978e-01f, 5.82595244e-02f,
  -5.00266813e-02f, 3.10846329e-01f, 1.40797973e-01f, 2.83767581e-01f, 1.54207602e-01f, -3.15764219e-01f, -1.16029531e-01f, -2.50274658e-01f, 1.74016029e-01f, -5.07828183e-02f,
  -1.48251757e-01f, -1.77919775e-01f, -1.96177796e-01f, 3.76025029e-02f, -1.75506890e-01f, -1.48612618e-01f, -9.79377031e-02f, -4.78907302e-02f, -1.89289059e-02f, 1.21424794e-01f,
  4.57519777e-02f, 1.42659768e-02f, -1.35558676e-02f, 1.60855085e-01f, 6.54397085e-02f, 3.58794816e-02f, 1.21929258e-01f, -2.82789357e-02f, -8.24573413e-02f, -3.06406945e-01f,
  3.03636163e-01f, -1.23114310e-01f, 1.57412570e-02f, -1.05490223e-01f, 3.59951824e-01f, -3.27390768e-02f, -3.22435528e-01f, -7.11254627e-02f, 5.24551451e-01f, 9.52224806e-02f,
  3.51624250e-01f, 2.35006511e-01f, -5.16162030e-02f, -1.41845196e-01f, 1.38961701e-02f, -5.07326461e-02f, 2.77290288e-02f, -1.06640272e-01f, -7.20479935e-02f, -1.31117731e-01f,
  7.39466352e-03f, 5.71076944e-02f, 3.25926580e-02f, -7.02203512e-02f, 1.05635680e-01f, 1.84832346e-02f, -3.27915281e-01f, 1.17011130e-01f, 2.39401937e-01f, 9.84205082e-02f,
  1.80495769e-01f, -7.69082084e-02f, 1.94541588e-01f, -1.66571110e-01f, 5.21585494e-02f, -1.54944330e-01f, 1.49566814e-01f, 1.76899418e-01f, 3.86247709e-02f, 4.05118346e-01f,
  2.25451276e-01f, 8.93018544e-02f, -1.74761876e-01f, -3.08716148e-01f, -7.10524991e-02f, -1.89103767e-01f, -6.80548772e-02f, 1.23757586e-01f, 3.25006664e-01f, 5.66016622e-02f,
  1.48752272e-01f, 7.80420080e-02f, -2.70928442e-01f, 1.41930252e-01f, -7.65359253e-02f, 1.15846898e-02f, -1.85914531e-01f, 2.23036587e-01f, -1.54509559e-01f, -3.12333047e-01f,
  1.82690732e-02f, 3.11346501e-01f, 1.29620433e-01f, -2.08521336e-02f, 3.67471308e-01f, -2.98725188e-01f, -4.29901838e-01f, 1.99237615e-01f, 4.26514715e-01f, 2.00909883e-01f,
  2.06046939e-01f, -2.93273926e-01f, 3.54597688e-01f, 1.34613454e-01f, -2.20372945e-01f, 4.48267311e-01f, 6.49262965e-02f, -9.56639946e-02f, -3.36810350e-02f, 9.74457860e-02f,
  -3.62788439e-02f, -4.08381879e-01f, -1.66982055e-01f, 3.04685719e-02f, -1.53127044e-01f, 2.43306607e-01f, 7.19401762e-02f, -3.12121003e-04f, 1.24412879e-01f, -1.81123435e-01f,
  -3.59550506e-01f, 1.86643004e-01f, -1.09829210e-01f, 2.04788268e-01f, 1.63828060e-01f, -9.33361873e-02f, 1.34016842e-01f, -3.89423361e-03f, -7.86428079e-02f, -4.60923500e-02f,
  -1.70515805e-01f, -2.04773128e-01f, -1.95316061e-01f, -1.47343334e-02f, -6.72107577e-01f, -1.78758457e-01f, 7.87719041e-02f, 3.10955405e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.66967645e-01f, 1.86154526e-02f, 5.95166795e-02f, 3.50126803e-01f, 2.31742978e-01f, 6.37245774e-02f, 1.41646251e-01f, 1.32778361e-01f, -6.30246401e-02f, 3.17143381e-01f,
  2.56890595e-01f, 1.33845523e-01f, 1.25890538e-01f, 2.28831008e-01f, -3.56153071e-01f, -2.23064274e-02f, -1.80967301e-01f, 2.82336980e-01f, -6.90927431e-02f, -2.04368144e-01f,
  1.00925654e-01f, 4.18923289e-01f, -6.14878833e-02f, 3.20905596e-01f, 1.69573754e-01f, -2.48360604e-01f, 3.41024697e-01f, -4.95135933e-02f, -2.18984067e-01f, -1.52214974e-01f,
  3.29159270e-03f, 3.84436876e-01f, 3.42792481e-01f, 4.19459902e-02f, 1.94495305e-01f, 4.01582807e-01f, 2.40919560e-01f, 1.77713886e-01f, 2.06068784e-01f, 3.33642811e-02f,
  2.46317193e-01f, 1.02848157e-01f, -1.51748613e-01f, -1.94393933e-01f, 4.39587325e-01f, 4.54005271e-01f, 1.28047913e-01f, -4.21920806e-01f, 2.80538261e-01f, -2.10484892e-01f,
  -3.05623174e-01f, 1.37756303e-01f, -6.77413568e-02f, 4.50120807e-01f, 4.94071364e-01f, 1.82511151e-01f, -5.55201992e-02f, -2.23815322e-01f, -1.73047185e-01f, -4.04433794e-02f,
  -5.70189118e-01f, -5.72346225e-02f, 1.98625222e-01f, 2.67770678e-01f, 7.81817883e-02f, 5.85365668e-02f, 1.54242232e-01f, -2.72655070e-01f, 6.42031193e-01f, 3.50749880e-01f,
  2.95892030e-01f, 6.97529688e-02f, 3.06437433e-01f, -5.33233844e-02f, 3.04218709e-01f, 6.90090954e-02f, 1.32193372e-01f, -3.66494119e-01f, 1.13801718e-01f, 2.05449253e-01f,
  -1.07622901e-02f, -1.06961921e-01f, 2.07564592e-01f, -9.37299058e-02f, -4.44252789e-02f, -5.90987206e-02f, 1.49946380e-02f, 8.01546127e-03f, -4.66985971e-01f, 2.24742383e-01f,
  2.79845476e-01f, 4.03984517e-01f, 4.78512526e-01f, -2.22408816e-01f, -1.37992635e-01f, -2.35315725e-01f, -6.17025681e-02f, 1.16660222e-01f, 4.71686721e-02f, -7.50997886e-02f,
  9.67675671e-02f, 2.17825860e-01f, 7.15433955e-02f, 2.89704688e-02f, 1.30808651e-01f, 8.24868754e-02f, 2.17035756e-01f, 1.57880738e-01f, 2.35687569e-01f, 1.65758833e-01f,
  -1.15409410e-02f, 1.44157931e-01f, -6.46565259e-02f, 1.33752357e-02f, 8.47634450e-02f, -1.92526415e-01f, 4.13934052e-01f, 3.25387746e-01f, -2.87454486e-01f, 1.34062141e-01f,
  -4.96543422e-02f, -3.28556567e-01f, -2.84865141e-01f, -2.42752656e-01f, 6.09260559e-01f, -2.58374922e-02f, 3.61426055e-01f, 5.93054414e-01f, 2.33281717e-01f, 1.81537241e-01f,
  2.10616276e-01f, -9.69859958e-02f, 7.51389503e-01f, 1.64573297e-01f, -8.11450630e-02f, 1.40408305e-02f, -5.51813990e-02f, -1.14032455e-01f, 2.92204201e-01f, 7.49358535e-02f,
  -4.22130615e-01f, 9.78764147e-02f, -3.77650559e-01f, -1.05813719e-01f, -1.74992338e-01f, -2.13236455e-02f, -2.06702128e-01f, -3.36278588e-01f, 4.63671163e-02f, 3.53214592e-02f,
  -2.06365287e-01f, 1.00852422e-01f, -3.05789709e-01f, -7.59268031e-02f, 4.89755452e-01f, 3.64934593e-01f, 4.71747547e-01f, 1.85578972e-01f, 2.03152463e-01f, 1.12707160e-01f,
  1.08580180e-01f, 1.75556213e-01f, 9.64951441e-02f, 2.17096239e-01f, -7.02175424e-02f, 1.75139531e-01f, 6.23347871e-02f, 1.40461445e-01f, 3.24423522e-01f, -5.53044118e-03f,
  3.70223969e-02f, -1.81859788e-02f, 2.90672779e-01f, 7.12174177e-02f, -1.10619552e-01f, 1.45693883e-01f, 2.20657080e-01f, 1.51517287e-01f, 1.16445355e-01f, -6.83872122e-03f,
  -3.33073378e-01f, 3.27300727e-01f, 5.30335128e-01f, 2.31302515e-01f, -5.48602752e-02f, -4.61234599e-02f, 1.22429356e-01f, 5.52154839e-01f, -3.41278046e-01f, 1.23238221e-01f,
  4.54660915e-02f, -2.22981423e-01f, -2.13154199e-04f, 1.02232181e-01f, 1.09545350e-01f, -3.00246459e-02f, -1.53915375e-01f, 5.69767617e-02f, 3.77694555e-02f, 2.49634296e-01f,
  1.07893005e-01f, 3.59212025e-03f, -4.47390266e-02f, -5.95675409e-02f, -9.30423616e-04f, -8.59527215e-02f, -1.50883822e-02f, 1.93397880e-01f, 6.88830316e-02f, -8.72530043e-02f,
  1.84223317e-02f, -2.64822245e-01f, 5.46988174e-02f, -2.45513432e-02f, -1.82975233e-01f, -7.08293989e-02f, 7.50241995e-01f, -9.30231437e-02f, -3.53150606e-01f, -1.44653087e-02f,
  3.11306357e-01f, 5.16804039e-01f, -9.56081599e-02f, 2.06612676e-01f, 1.20849811e-01f, 1.54332668e-01f, -5.89034148e-02f, -1.03749536e-01f, -1.41222715e-01f, 1.95563175e-02f,
  -1.77520793e-02f, -2.41519287e-02f, 1.26006842e-01f, 5.01120165e-02f, 5.85505292e-02f, -2.35531591e-02f, 1.18581757e-01f, 1.83615997e-01f, 2.28323024e-02f, 6.38084188e-02f,
  -1.97841674e-01f, -1.46231860e-01f, 2.89161712e-01f, 2.82239020e-01f, 1.22777015e-01f, -4.24520448e-02f, 1.01183139e-01f, 2.94459343e-01f, -9.89364088e-02f, -5.15113294e-01f,
  7.08538946e-03f, 1.57222636e-02f, -9.78783593e-02f, 4.87885028e-02f, 2.70746797e-01f, -1.84987038e-01f, -1.91037759e-01f, -1.55213252e-02f, 1.13438688e-01f, -3.50241184e-01f,
  1.16895504e-01f, 2.97147304e-01f, -1.05071984e-01f, 9.39300954e-02f, -3.77592117e-01f, -3.59925598e-01f, -2.65842855e-01f, 1.74305886e-01f, -2.54416108e-01f, 1.23228014e-01f,
  1.56976879e-01f, -1.51591733e-01f, -3.17760333e-02f, 1.68591127e-01f, 1.99118689e-01f, -1.99900903e-02f, -1.20127469e-01f, -2.29469076e-01f, 6.00003637e-02f, 3.98760363e-02f,
  -1.08360045e-01f, 4.25111651e-01f, 4.07272547e-01f, 7.02025667e-02f, -2.68047959e-01f, -2.37504646e-01f, -3.30176532e-01f, -2.09296178e-02f, 1.16735827e-02f, 6.40269220e-02f,
  -1.00465873e-02f, -4.75762635e-02f, 9.63109434e-02f, -1.37954265e-01f, -4.24346998e-02f, 1.11139208e-01f, 2.22460225e-01f, 1.21271841e-01f, 2.15213433e-01f, -2.27569100e-02f,
  1.68004975e-01f, -3.95539328e-02f, 7.72309601e-02f, 2.12412477e-01f, -1.27840817e-01f, 1.68176413e-01f, 4.50056717e-02f, 1.12320796e-01f, -2.90161576e-02f, -8.70702192e-02f,
  1.70573927e-02f, 1.46693349e-01f, -6.54290691e-02f, -2.43378401e-01f, -2.80088037e-01f, 1.26203790e-01f, -2.23973259e-01f, 3.91241729e-01f, 1.12844519e-01f, 4.62887660e-02f,
  1.46301016e-01f, -9.89333168e-03f, 1.69952184e-01f, 3.09484065e-01f, 3.95603746e-01f, 1.15462244e-02f, 9.73669719e-03f, -4.56469841e-02f, 4.28457648e-01f, -1.78559627e-02f,
  3.57541054e-01f, 3.22377943e-02f, 1.25131711e-01f, -3.41111004e-01f, -1.62731051e-01f, 1.18195139e-01f, -3.19554538e-01f, -9.64898691e-02f, 5.84842935e-02f, -2.16192737e-01f,
  3.12879860e-01f, -3.64781737e-01f, 7.36612827e-02f, -7.20365822e-01f, 1.05165489e-01f, -6.19888678e-02f, -6.00362709e-03f, -2.38529861e-01f, 3.50435257e-01f, -8.40745941e-02f,
  1.42810136e-01f, -3.15458924e-01f, 2.54088283e-01f, 7.66187385e-02f, -5.28471582e-02f, -1.27883554e-01f, 7.20096603e-02f, 4.19935673e-01f, 1.27522066e-01f, -5.73125631e-02f,
  6.31492063e-02f, -3.60540599e-01f, 2.22893506e-02f, 1.08265378e-01f, -1.99885607e-01f, 2.82348365e-01f, 8.71314784e-04f, -1.24890730e-01f, 2.69941896e-01f, -2.19587564e-01f,
  2.72759832e-02f, -1.64183170e-01f, -1.44415468e-01f, -1.74582198e-01f, -1.00258049e-02f, 1.46403283e-01f, 4.59953517e-01f, 2.25497335e-01f, 1.34125277e-01f, 3.99305284e-01f,
  2.48770729e-01f, 3.23037833e-01f, -2.46473387e-01f, -2.60534495e-01f, -1.00592829e-01f, -9.18227136e-02f, 1.64790377e-01f, 1.49818346e-01f, 6.06535435e-01f, 4.62175980e-02f,
  1.82944760e-01f, 4.98890392e-02f, -6.93461597e-02f, -1.85417563e-01f, -7.91709796e-02f, -3.20083904e-03f, -2.67058194e-01f, 1.53063685e-01f, -3.10012966e-01f, -1.75364837e-01f,
  -8.00758302e-02f, 9.47366729e-02f, -1.48684576e-01f, 4.00450192e-02f, 2.74490684e-01f, -8.08015559e-03f, -3.33497226e-01f, 1.44696787e-01f, 2.70007625e-02f, -1.08120628e-02f,
  3.87027144e-01f, -3.27485561e-01f, 5.23367584e-01f, 1.27060145e-01f, 4.77384068e-02f, 3.15398008e-01f, 1.26238808e-01f, 1.11441992e-01f, 1.76237971e-01f, -2.41714820e-01f,
  2.52405524e-01f, 3.76039743e-02f, 2.77295351e-01f, 4.35629487e-02f, 6.49292096e-02f, -2.05554873e-01f, 2.05644742e-02f, 1.00607798e-02f, -4.28672671e-01f, 1.71028212e-01f,
  4.12353456e-01f, -1.12733193e-01f, 2.91897403e-03f, -1.69155657e-01f, -3.29111189e-01f, -5.23311019e-01f, 5.89355230e-02f, -3.26019615e-01f, -3.50712985e-02f, -1.63182169e-01f,
  2.33862504e-01f, 1.48977963e-02f, 8.81100744e-02f, -2.21511662e-01f, 5.66516876e-01f, 6.87162802e-02f, 3.83424670e-01f, -2.38630563e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.86419895e-02f, 7.00481012e-02f, 1.56096861e-01f, 1.96467206e-01f, 2.71715701e-01f, 2.72449732e-01f, 2.16578171e-01f, -1.27709329e-01f, 2.76241731e-02f, -6.07020333e-02f,
  3.57889920e-01f, 7.23386779e-02f, 7.28083253e-02f, 1.92535326e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.24544659e-01f, 2.30590969e-01f, 2.00892001e-01f, -3.00425082e-03f, -7.33958334e-02f, -2.71825492e-01f, 1.46318361e-01f, -1.06383331e-01f, -1.13510855e-01f, 2.59566694e-01f,
  1.53100654e-01f, 3.50705497e-02f, 2.89976895e-01f, 1.14730056e-02f, -2.37640247e-01f, 4.09510285e-01f, 1.74903795e-01f, 1.72276869e-01f, 1.90534770e-01f, -2.70995438e-01f,
  3.98267776e-01f, -8.51711333e-02f, 3.87527645e-01f, 1.44388363e-01f, -5.06062880e-02f, 1.32001072e-01f, 1.68098626e-03f, 6.55732974e-02f, 6.94718659e-02f, -2.51684725e-01f,
  6.44031214e-03f, -1.70121714e-01f, -5.98149896e-02f, -8.70967433e-02f, -4.43901792e-02f, -9.32187364e-02f, -1.00606769e-01f, -9.11838561e-02f, -1.61943823e-01f, -3.07410359e-01f,
  -1.99063629e-01f, 2.60904074e-01f, -2.25878850e-01f, -3.92844200e-01f, -1.43826082e-01f, 3.60981584e-01f, -3.87834996e-01f, -2.91388690e-01f, 2.97022611e-01f, -2.84644458e-02f,
  5.02832979e-02f, -3.11210245e-01f, 4.15531248e-02f, -6.85109943e-02f, 8.25247914e-02f, -1.18060224e-02f, -2.14694515e-01f, 1.78697228e-01f, 2.00269017e-02f, -2.41121545e-01f,
  -1.02178110e-02f, 1.70115381e-01f, 7.31107444e-02f, 2.36716613e-01f, 3.98863256e-01f, 5.84529266e-02f, 2.79838920e-01f, 1.31895095e-01f, 3.38586479e-01f, 3.35592687e-01f,
  -2.30491892e-01f, 2.43273243e-01f, 2.62565553e-01f, -1.67973325e-01f, 1.20340511e-01f, 2.21966371e-01f, 6.90369383e-02f, -1.96449514e-02f, -9.60452631e-02f, 2.70984899e-02f,
  -7.08389655e-02f, 2.89333910e-01f, 1.51475027e-01f, 7.79885426e-02f, -3.67206186e-01f, 2.39297628e-01f, -2.66400903e-01f, 9.74731520e-02f, -2.01083288e-01f, 1.48981482e-01f,
  -4.53347474e-01f, -6.17849827e-02f, 5.15999459e-02f, -2.56681681e-01f, 7.43823200e-02f, -6.38329387e-02f, -2.77603809e-02f, 1.09803423e-01f, 1.60002172e-01f, 1.14469118e-01f,
  -9.32894833e-03f, 2.50166543e-02f, 3.25513333e-01f, -2.54535675e-02f, 1.15533531e-01f, -1.61400497e-01f, -1.02187404e-02f, -3.73106837e-01f, -1.27691776e-01f, 4.34055924e-01f,
  7.28446320e-02f, -3.98455352e-01f, 3.63317430e-01f, 8.90523866e-02f, 7.69638121e-02f, -1.54560566e-01f, 4.19870168e-02f, -2.42007915e-02f, 2.23045573e-02f, -1.24329776e-01f,
  -2.82524645e-01f, -1.06433272e-01f, 2.22964659e-01f, -5.60379811e-02f, 1.46346524e-01f, -5.04495203e-02f, 1.46206036e-01f, -1.20803937e-02f, -4.72018942e-02f, -1.36634737e-01f,
  -1.37705535e-01f, -3.41264941e-02f, -7.76918381e-02f, -1.73995066e-02f, -3.94415170e-01f, 2.87444055e-01f, 3.44551280e-02f, -6.35299236e-02f, -1.87910289e-01f, 3.45453173e-02f,
  -2.72591233e-01f, -8.80974829e-02f, -3.48455340e-01f, -2.59879202e-01f, -3.94482553e-01f, -1.17585756e-01f, -2.74514705e-01f, 9.53502506e-02f, -2.16426682e-02f, -3.64682749e-02f,
  -2.42272198e-01f, 7.27993697e-02f, 4.25679833e-02f, 1.99145451e-01f, 2.42139831e-01f, 9.49361771e-02f, -2.61654496e-01f, 1.17300823e-01f, -8.17659646e-02f, 2.76409369e-02f,
  3.75962883e-01f, -7.02869073e-02f, -1.58776179e-01f, 3.69292617e-01f, -3.78190982e-03f, 1.86128601e-01f, -2.97394454e-01f, -2.23200381e-01f, 3.22021693e-01f, -1.45742163e-01f,
  1.93758771e-01f, -1.58571184e-01f, -3.91466469e-01f, 3.03395569e-01f, -4.46308665e-02f, -3.71746302e-01f, 6.23222366e-02f, -3.25274885e-01f, -2.15204746e-01f, 4.03886139e-02f,
  -3.08010471e-03f, -9.83823836e-03f, -1.61071062e-01f, -6.38206825e-02f, 6.56022504e-02f, 1.98916852e-01f, 2.59077013e-01f, 1.34990364e-01f, -4.09777686e-02f, 1.49349049e-01f,
  2.07542107e-01f, -4.41371929e-03f, -2.43435070e-01f, -2.05388889e-01f, -7.81468675e-02f, -9.73949209e-02f, -8.58882256e-03f, -3.71486366e-01f, -8.52688700e-02f, 9.49062780e-03f,
  1.28094144e-02f, -1.06130287e-01f, -2.45688200e-01f, -2.28644893e-01f, -4.03355956e-01f, 3.86566967e-01f, -1.22864053e-01f, -3.23811322e-01f, 8.80457163e-02f, -3.45550850e-02f,
  8.63644704e-02f, 1.38306811e-01f, -1.63559958e-01f, -9.82574299e-02f, 1.46357389e-02f, 3.13376705e-03f, -1.28113389e-01f, 2.80493736e-01f, 3.86182517e-01f, 1.14320740e-01f,
  -3.12669814e-01f, 2.20114067e-01f, -1.48654267e-01f, 5.82195222e-02f, -1.08051896e-01f, 2.68793166e-01f, 2.00287908e-01f, -1.30868003e-01f, 2.14888558e-01f, -3.44672531e-01f,
  3.82813871e-01f, 1.26336217e-01f, -2.16694459e-01f, -1.37983382e-01f, 1.11883529e-01f, 2.38963053e-01f, -6.03599921e-02f, 1.92127109e-01f, -1.97525635e-01f, -4.92946617e-03f,
  2.34160945e-01f, 1.35680392e-01f, 2.19335407e-01f, -3.52451988e-02f, 2.35278904e-01f, 1.22055143e-01f, 2.81814009e-01f, -5.74031249e-02f, -2.94121474e-01f, -1.42597124e-01f,
  9.52515081e-02f, -1.78814083e-01f, 3.18123251e-02f, -2.20105588e-01f, 1.08450279e-01f, 7.41648348e-03f, -1.12942442e-01f, -1.95371017e-01f, -1.53712764e-01f, 2.87397146e-01f,
  -1.31522328e-01f, 1.33539122e-02f, -9.11933929e-02f, -1.50957936e-02f, -1.25004143e-01f, 6.87460080e-02f, -9.05474499e-02f, -2.44467631e-01f, 1.05285749e-01f, -1.35140508e-01f,
  1.92662343e-01f, -9.95527655e-02f, 1.43325217e-02f, -3.24124008e-01f, -2.76625276e-01f, -1.76251933e-01f, 3.34537983e-01f, 1.01512931e-01f, 1.18653119e-01f, -3.22351426e-01f,
  7.07199574e-02f, 1.11206703e-01f, 3.62871230e-01f, 1.42445907e-01f, 7.69884586e-02f, 2.10798666e-01f, 8.62382874e-02f, 3.84123772e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.10010155e-01f, 8.91081244e-02f, 5.47350571e-02f, -2.54653811e-01f, 5.97105958e-02f, 1.64746374e-01f, 3.05938035e-01f, 3.08242626e-02f, 1.87873647e-01f, -5.01184352e-02f,
  -1.61098391e-01f, -8.63616243e-02f, -4.61699784e-01f, 3.09785139e-02f, -7.23057911e-02f, -4.04840857e-01f, 2.41999879e-01f, -2.26413667e-01f, 2.36454979e-01f, 1.20368421e-01f,
  -3.76410931e-01f, 7.13789761e-02f, -1.08986050e-01f, 1.89882696e-01f, 2.50516653e-01f, 1.36808470e-01f, -2.15310350e-01f, 1.90724030e-01f, -4.92948562e-01f, 4.04626310e-01f,
  1.09106876e-01f, -3.61224651e-01f, 8.31956267e-02f, 5.73011208e-03f, 9.90596786e-02f, -1.93304531e-02f, 5.81590384e-02f, -4.56290364e-01f, 4.98754770e-01f, 2.31487136e-02f,
  -2.63415247e-01f, 2.76384979e-01f, -1.49900392e-01f, 5.34616485e-02f, -5.59373796e-01f, 4.72819775e-01f, -2.26966307e-01f, 1.63594723e-01f, 5.04543602e-01f, -2.04026282e-01f,
  1.77501589e-01f, -8.42309222e-02f, 3.44855249e-01f, 1.65198579e-01f, 6.86676621e-01f, 1.47500038e-01f, -4.11438882e-01f, -2.05771029e-01f, 3.91581029e-01f, -2.89237648e-01f,
  2.63090730e-02f, 3.84607136e-01f, 1.82849556e-01f, 1.10303126e-01f, 1.04139060e-01f, 3.03082079e-01f, 4.21569914e-01f, -4.44906056e-01f, 2.57045180e-01f, 2.54456401e-01f,
  1.68615595e-01f, 6.30659610e-02f, 3.01576763e-01f, -5.90964317e-01f, -1.21817060e-01f, 9.70900804e-02f, -4.53288071e-02f, 5.49065828e-01f, -1.57708004e-01f, -5.32256901e-01f,
  5.97411990e-02f, -9.58618000e-02f, 4.39150900e-01f, 4.00196046e-01f, -2.65338361e-01f, 4.71432388e-01f, -5.47548346e-02f, 6.81465417e-02f, -2.01699644e-01f, 7.07717761e-02f,
  6.54180869e-02f, 1.42974362e-01f, 1.77610055e-01f, -2.68257767e-01f, 2.73349553e-01f, -2.47622579e-01f, 4.40823853e-01f, 4.15003151e-01f, 3.04146349e-01f, 5.46250582e-01f,
  3.78992975e-01f, 1.89843565e-01f, 3.40869367e-01f, 3.54691118e-01f, 2.68546879e-01f, 5.21146595e-01f, -1.90290436e-02f, 1.40191764e-01f, 3.91105026e-01f, -4.31207180e-01f,
  -2.10886046e-01f, 2.52908170e-01f, 1.34044483e-01f, -1.12363607e-01f, -2.07854658e-02f, 2.44231913e-02f, 3.68213803e-01f, -4.15211581e-02f, 2.69799858e-01f, 1.66179001e-01f,
  4.58428681e-01f, -4.04446095e-01f, 8.57789367e-02f, -1.32029057e-01f, 4.38422889e-01f, 2.20542356e-01f, 6.91252500e-02f, 4.36214209e-01f, 3.27410430e-01f, -2.77178168e-01f,
  -2.70643104e-02f, 1.89628765e-01f, -1.52904183e-01f, -1.91095293e-01f, -1.77734762e-01f, 6.52279193e-03f, -2.51598716e-01f, -4.80369814e-02f, -2.38712981e-01f, -9.50049311e-02f,
  -9.43344831e-02f, 1.85202494e-01f, -8.58967975e-02f, 6.96378410e-01f, 6.68753088e-02f, -1.66338995e-01f, -2.62406707e-01f, -3.62207323e-01f, 2.93370873e-01f, 1.11470163e-01f,
  -5.79535142e-02f, 2.14635506e-01f, -2.25051165e-01f, 2.82297075e-01f, 4.96072799e-01f, 1.61278650e-01f, 5.99817000e-02f, 1.47549495e-01f, 1.30036280e-01f, 2.16786146e-01f,
  -1.54052466e-01f, -2.87838012e-01f, -1.50017694e-01f, 3.47872555e-01f, -2.25250237e-03f, 1.75177351e-01f, -1.39287665e-01f, -8.23367909e-02f, -1.64091095e-01f, 2.95695722e-01f,
  1.82105750e-02f, -4.75370675e-01f, -2.37736791e-01f, -5.52369505e-02f, -3.55344452e-02f, 1.46316499e-01f, 4.00575072e-01f, -3.38916361e-01f, -1.95454836e-01f, -1.03682160e-01f,
  2.50246942e-01f, 2.16530815e-01f, 1.66986316e-01f, 6.42963499e-02f, 3.44114155e-01f, 7.48500973e-02f, 2.95838058e-01f, 3.44407380e-01f, -1.72007591e-01f, 2.76263446e-01f,
  3.12934458e-01f, 2.98478723e-01f, -7.06490269e-03f, -5.73375486e-02f, -1.94114912e-02f, 6.33202970e-01f, 9.46700573e-02f, 3.98715585e-01f, 4.17535841e-01f, -2.65137076e-01f,
  2.59906918e-01f, 1.10392377e-01f, -2.94576466e-01f, -4.45748150e-01f, 4.23491508e-01f, -4.72174764e-01f, -1.68729693e-01f, -1.33378133e-01f, 2.90018290e-01f, -2.39189729e-01f,
  -2.93108195e-01f, 1.85808495e-01f, 7.98528194e-02f, 1.19010299e-01f, -1.00343376e-01f, -1.34835858e-03f, 2.94550538e-01f, 1.32053539e-01f, -7.48013705e-02f, 9.65471193e-03f,
  3.22252542e-01f, 4.84807007e-02f, 1.66781649e-01f, 4.88645732e-01f, 5.53246617e-01f, 3.52967680e-01f, 1.86062187e-01f, -4.57398653e-01f, 3.64147484e-01f, -1.82172194e-01f,
  3.06974053e-01f, 2.02153146e-01f, 2.86805302e-01f, -1.69073611e-01f, 1.57562271e-01f, 1.54478386e-01f, -5.48856080e-01f, 1.12797681e-03f, -2.76778579e-01f, -1.62616745e-01f,
  -4.55181897e-01f, -2.48324379e-01f, 1.69209167e-01f, 5.52417994e-01f, 2.80245095e-01f, -1.00794703e-01f, -7.42644891e-02f, 3.51268560e-01f, 2.74700187e-02f, 4.60744426e-02f,
  -1.47818085e-02f, 1.38478771e-01f, -2.05776662e-01f, 1.11347109e-01f, -1.04233466e-01f, -3.23517650e-01f, -1.52964378e-02f, -7.78162032e-02f, -9.41995978e-02f, 2.01643020e-01f,
  -2.40379259e-01f, 1.07434578e-02f, -3.43341559e-01f, -2.48036399e-01f, 9.49276164e-02f, 1.83186337e-01f, -1.24194678e-02f, -8.48222058e-04f, -3.90975654e-01f, -5.77886067e-02f,
  -1.97955966e-01f, 5.70158064e-01f, 9.61194187e-02f, -1.19539171e-01f, -2.28931084e-01f, -1.46681681e-01f, 2.53994882e-01f, 3.75034548e-02f, 1.35867884e-02f, 2.25826547e-01f,
  1.10995673e-01f, 2.19245836e-01f, 1.83825687e-01f, 2.62069285e-01f, 6.81581944e-02f, 3.49789470e-01f, 7.19580352e-02f, 3.28692973e-01f, 1.70559332e-01f, -1.06194988e-01f,
  -4.30190712e-02f, -2.10102037e-01f, -2.31065631e-01f, 1.08992092e-01f, 2.14823801e-02f, -8.86522010e-02f, -3.12476978e-02f, -1.34661764e-01f, 1.39030233e-01f, 2.38737926e-01f,
  -4.59047228e-01f, -2.90284050e-04f, -1.34679198e-01f, 1.30274385e-01f, -6.27608895e-02f, -1.79801479e-01f, 4.37828034e-01f, 3.79297554e-01f, 1.02613360e-01f, 1.97760090e-01f,
  1.88169137e-01f, 2.91183591e-01f, 4.17837232e-01f, 9.07570049e-02f, -5.60411662e-02f, 1.25422552e-01f, -2.88552027e-02f, 4.22158659e-01f, 1.27873629e-01f, -6.83443621e-02f,
  3.70867461e-01f, 3.23085129e-01f, -1.00541539e-01f, -1.45036161e-01f, 2.46359169e-01f, 1.34661719e-01f, 1.50891796e-01f, 5.62754095e-01f, 1.83922783e-01f, 2.59188563e-01f,
  -2.22760230e-01f, 3.36373091e-01f, -1.47103101e-01f, -4.57096249e-01f, -3.99104327e-01f, -2.19799399e-01f, -6.95072174e-01f, -4.48334128e-01f, -2.22417817e-01f, 5.23077548e-01f,
  2.56616682e-01f, -4.44873810e-01f, -2.98793435e-01f, 4.62015033e-01f, 2.25814968e-01f, 1.86888110e-02f, 4.29594330e-03f, 5.24383038e-02f, 2.17419565e-01f, 3.77875865e-01f,
  -5.12690842e-01f, -3.57960388e-02f, 3.17366809e-01f, 3.30723971e-01f, 3.18774194e-01f, 2.12798506e-01f, 4.94798273e-01f, -4.08476591e-01f, 5.70363820e-01f, 4.12755042e-01f,
  3.33274692e-01f, 3.41501385e-01f, -1.73691809e-01f, 6.27633452e-01f, -2.89257854e-01f, -7.04933032e-02f, -6.43136621e-01f, 2.65899718e-01f, -1.03470832e-01f, 1.92068275e-02f,
  -3.57265845e-02f, -8.79295461e-04f, 5.22948503e-01f, -4.69250023e-01f, 3.93962473e-01f, 1.61587864e-01f, -6.54991925e-01f, -2.19428003e-01f, 5.95680140e-02f, -1.06248811e-01f,
  5.54187298e-02f, -9.01020542e-02f, 1.20655507e-01f, -7.06055984e-02f, 2.08861217e-01f, 3.43950093e-01f, -1.03879906e-01f, 6.74921930e-01f, 2.09773049e-01f, 1.86465338e-01f,
  2.22341776e-01f, 1.86945021e-03f, 5.20000398e-01f, 1.86017290e-01f, 1.19956136e-01f, -1.90911014e-02f, -1.29792502e-03f, -2.74931788e-01f, -2.57518947e-01f, -3.67816053e-02f,
  -2.74713039e-01f, -1.69306621e-01f, -3.74499798e-01f, -2.89465815e-01f, 4.75043893e-01f, 1.16518877e-01f, 2.21638903e-01f, -3.28589231e-01f, -3.71658094e-02f, -1.98221177e-01f,
  2.22659051e-01f, -1.35481849e-01f, 2.16914535e-01f, -5.62551245e-02f, 1.50311425e-01f, 5.71017504e-01f, -1.13225117e-01f, 7.66675547e-02f, 3.91540468e-01f, 4.68969703e-01f,
  7.00307935e-02f, 2.34200090e-01f, 2.78879523e-01f, -1.96910143e-01f, -1.59613848e-01f, -9.38922018e-02f, 1.25806525e-01f, -5.31592667e-01f, 5.07988930e-01f, 3.72488052e-02f,
  3.63310188e-01f, -6.54217154e-02f, 4.33741868e-01f, 1.76652893e-01f, 3.74291986e-01f, -9.69253033e-02f, 1.50940701e-01f, 4.71158117e-01f, 2.81089067e-01f, -1.18221544e-01f,
  3.85857344e-01f, -8.61611515e-02f, -3.46593440e-01f, 7.07068443e-02f, 3.60697687e-01f, -1.14422934e-02f, 4.18474346e-01f, 2.30419889e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  8.26055631e-02f, 2.58241981e-01f, 9.92095023e-02f, 4.02689517e-01f, 8.39374512e-02f, 3.59954275e-02f, 1.90339461e-01f, 8.02315325e-02f, -4.08796668e-02f, 2.55888462e-01f,
  3.03107440e-01f, 3.59492958e-01f, 1.24966256e-01f, -7.24861748e-04f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.08626166e-01f, -6.74987808e-02f, -3.65781099e-01f, -4.12521690e-01f, -3.28174472e-01f, -2.67941296e-01f, -1.76119298e-01f, -3.07736825e-03f, -1.94364518e-01f, 2.12733567e-01f,
  1.69957057e-01f, -2.30810091e-01f, -1.06277816e-01f, 9.21652094e-02f, 1.66896865e-01f, 5.53006679e-02f, -2.06415296e-01f, 1.74693465e-01f, -3.75203826e-02f, -2.64456570e-02f,
  1.67539403e-01f, -1.45168304e-01f, 2.82233298e-01f, 9.56187919e-02f, 5.22778276e-03f, -1.64674565e-01f, 3.13631684e-01f, 5.20873889e-02f, -1.87883139e-01f, -2.88562357e-01f,
  2.37951241e-02f, -2.04736516e-02f, 3.71664800e-02f, 1.79282084e-01f, 1.78125679e-01f, 3.48214984e-01f, 1.61424324e-01f, -1.55948654e-01f, 3.17602754e-01f, -1.47808388e-01f,
  2.43918896e-01f, -1.48460180e-01f, 1.38992757e-01f, 1.82804316e-01f, -9.69039723e-02f, 7.74644241e-02f, 2.13744432e-01f, 6.09840825e-02f, -1.28513575e-01f, 3.10719609e-01f,
  6.57805428e-02f, -1.73127085e-01f, 6.99504241e-02f, -2.17509195e-01f, 1.95206374e-01f, -1.53035641e-01f, -2.03899056e-01f, 2.10288852e-01f, 2.29662269e-01f, 3.55820172e-02f,
  1.60263166e-01f, 2.74085756e-02f, -9.74419788e-02f, -9.62255374e-02f, 2.04365343e-01f, 4.64458428e-02f, 8.14822409e-03f, -1.74111813e-01f, -1.07308239e-01f, 8.92454162e-02f,
  1.96312487e-01f, 5.96518703e-02f, -5.07501103e-02f, 7.00932294e-02f, -2.37791985e-01f, 2.93222815e-01f, -6.98133707e-02f, 1.71102852e-01f, -1.92374140e-01f, -3.88578810e-02f,
  3.16714376e-01f, -3.23861927e-01f, 9.80478972e-02f, 6.51190802e-02f, 2.43954644e-01f, 4.71083224e-02f, -2.08244815e-01f, -1.38675064e-01f, -3.32588315e-01f, 6.18602410e-02f,
  -1.35245249e-01f, -1.98266804e-01f, 2.98234671e-01f, 2.13068143e-01f, 1.33497700e-01f, 5.22429943e-02f, 2.40179859e-02f, -1.35532364e-01f, -2.78759301e-01f, -2.12577835e-01f,
  2.70993173e-01f, -8.33898187e-02f, 9.55557227e-02f, -1.88016176e-01f, -3.12479705e-01f, -3.87438059e-01f, -1.46652803e-01f, -3.95196199e-01f, 1.09723695e-01f, -1.09510422e-01f,
  2.98843235e-01f, 1.12818265e-02f, -2.90588960e-02f, 9.79162753e-02f, -4.35237102e-02f, 1.81802973e-01f, 4.88844961e-02f, -1.63816527e-01f, -1.64806694e-01f, 2.07787618e-01f,
  6.03560321e-02f, -1.78830065e-02f, 1.79566711e-01f, 7.41237700e-02f, -1.35346863e-03f, -3.96260262e-01f, 1.25720590e-01f, -5.85896559e-02f, 1.79463938e-01f, -1.58464804e-01f,
  1.65348411e-01f, 1.13935702e-01f, 2.20554948e-01f, 1.86972260e-01f, 8.92402157e-02f, -9.24419798e-03f, -1.02048034e-04f, -1.69055983e-01f, -5.60541749e-02f, 2.92022061e-02f,
  2.48576581e-01f, -4.58002649e-02f, 8.31458867e-02f, -1.19901195e-01f, 1.91056684e-01f, -1.73486769e-01f, -2.62750417e-01f, -6.14312058e-03f, -9.76219848e-02f, 1.43920332e-01f,
  -3.09810013e-01f, -2.53631085e-01f, -5.18111140e-02f, -3.59918363e-02f, -1.38279855e-01f, -1.59552172e-01f, 3.24355751e-01f, 2.17141792e-01f, 1.66074082e-01f, -2.03215063e-01f,
  3.66117619e-02f, 4.16150868e-01f, -1.79434344e-01f, -6.45898506e-02f, -2.73364037e-01f, -1.14694186e-01f, -1.08559385e-01f, 8.47307034e-03f, 1.80218078e-04f, 1.81603208e-01f,
  -8.06661397e-02f, 2.38493264e-01f, 1.60353348e-01f, -2.29650676e-01f, -6.20206475e-01f, 6.14238493e-02f, 3.91700327e-01f, 2.08195336e-02f, -9.43011716e-02f, 1.26913831e-01f,
  2.18207836e-01f, 7.00263260e-03f, -1.55217528e-01f, -7.29510710e-02f, -2.61651307e-01f, -9.42022651e-02f, -1.16416529e-01f, -2.83900172e-05f, -1.12691782e-01f, 2.78435200e-01f,
  1.07185468e-01f, 1.18925624e-01f, 6.68938830e-02f, -3.95337284e-01f, -1.35147208e-02f, -3.72767210e-01f, -2.54210979e-02f, -4.87252921e-02f, -2.98730820e-01f, 2.01907722e-04f,
  -5.34172840e-02f, 1.78067788e-01f, -3.37412059e-01f, 7.16884509e-02f, -2.87243575e-02f, -1.63401216e-01f, 2.91826725e-01f, -3.59281898e-02f, 2.71899462e-01f, -7.50891417e-02f,
  -2.84837872e-01f, 4.88611311e-02f, -2.56759465e-01f, 2.04324841e-01f, 9.53781754e-02f, 4.12736200e-02f, 9.74273533e-02f, -3.09339136e-01f, -3.08659635e-02f, 7.04411864e-02f,
  -1.95110723e-01f, 9.40875113e-02f, 1.41475037e-01f, 5.21548726e-02f, 2.15707824e-01f, 8.64689052e-02f, 2.63280869e-01f, 1.08837955e-01f, 3.19073230e-01f, -1.14115715e-01f,
  -1.07532432e-02f, -1.24030083e-01f, -1.28582358e-01f, -1.48696467e-01f, 3.51748049e-01f, -1.72046095e-01f, 1.63869292e-01f, 1.38405964e-01f, -2.62334615e-01f, -2.65253663e-01f,
  -3.48606333e-02f, 7.11788312e-02f, -2.08399951e-01f, -1.20847240e-01f, -1.92443073e-01f, 2.35651016e-01f, 1.66875292e-02f, -1.44360960e-01f, 1.01627447e-01f, -8.71110931e-02f,
  -2.96506971e-01f, -3.58915776e-02f, 2.03774244e-01f, 2.80951530e-01f, 1.69868723e-01f, -1.84686705e-02f, -5.34118339e-02f, 3.15289833e-02f, 1.89019576e-01f, 1.52234644e-01f,
  1.08464599e-01f, -5.97721152e-03f, 3.72909568e-02f, 2.20502883e-01f, 1.30532905e-01f, 5.53102195e-02f, 6.11740388e-02f, 2.57877588e-01f, 1.45222142e-01f, 1.34573117e-01f,
  -2.14564025e-01f, 3.04857492e-02f, 2.98855633e-01f, -4.07339297e-02f, -1.85037017e-01f, -6.15041982e-03f, -5.36875837e-02f, -1.87297463e-02f, 9.45578441e-02f, -2.05549002e-01f,
  -5.97869344e-02f, 1.14051744e-01f, 2.09511183e-02f, -2.22213715e-01f, 6.54883534e-02f, 4.13641006e-01f, 1.97691754e-01f, -3.08911413e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.24624053e-01f, 4.22086388e-01f, 5.03002405e-01f, 5.83021820e-01f, 7.32097477e-02f, 2.64733434e-01f, 1.28423855e-01f, 9.63571966e-02f, -4.72168289e-02f, -1.84444003e-02f,
  1.74098626e-01f, 4.62565571e-01f, 4.24895376e-01f, -5.57884634e-01f, -6.09950721e-01f, -2.67461896e-01f, 2.83756435e-01f, -1.62151724e-01f, -1.10321783e-01f, -5.10026403e-02f,
  2.35623829e-02f, 5.22278190e-01f, -4.58931893e-01f, -2.45976612e-01f, 1.89085558e-01f, 1.20358162e-01f, -3.22586387e-01f, -1.87648028e-01f, 3.95766914e-01f, 4.54592526e-01f,
  8.86447802e-02f, 2.83267856e-01f, -1.90906644e-01f, 1.80688560e-01f, 3.24250013e-01f, -3.83965909e-01f, -2.56193370e-01f, 4.33503628e-01f, 3.46624076e-01f, -5.54160058e-01f,
  -1.96728259e-02f, 4.21129674e-01f, -4.98315394e-02f, -3.84593487e-01f, 3.62062991e-01f, -8.03438500e-02f, -2.12126419e-01f, 5.05016625e-01f, 2.94790566e-01f, -5.59561372e-01f,
  1.45373940e-01f, 7.73377180e-01f, -4.80049908e-01f, 1.93023011e-01f, 3.29150483e-02f, 1.81870073e-01f, -2.95823008e-01f, 8.16766471e-02f, 2.21221074e-01f, 2.85277367e-01f,
  3.32623512e-01f, 2.80925423e-01f, -2.12117061e-01f, -6.39748275e-02f, 3.63903880e-01f, 2.19795629e-01f, 1.03973836e-01f, 8.85274634e-02f, 5.78927159e-01f, -2.00354964e-01f,
  3.62655461e-01f, 3.22207212e-01f, -2.13593066e-01f, -6.61674887e-02f, 3.05260003e-01f, -2.29845420e-01f, 2.75344849e-01f, -2.73040652e-01f, 1.53920695e-01f, -2.06786782e-01f,
  1.31282195e-01f, 5.16586185e-01f, 4.65790294e-02f, 4.95828211e-01f, -2.74553686e-01f, 4.50718373e-01f, -1.74447298e-01f, 1.79765522e-01f, 3.80201072e-01f, -2.43968472e-01f,
  -5.87614700e-02f, -2.60554522e-01f, -3.07218671e-01f, 3.84291649e-01f, 7.22627521e-01f, -2.45343167e-02f, 8.65106732e-02f, 1.86413527e-01f, -2.50072151e-01f, 3.60546976e-01f,
  -1.07026272e-01f, 8.26047286e-02f, 8.00317246e-03f, 2.57047534e-01f, 1.83092244e-02f, 5.40726876e-04f, 1.33008603e-02f, 3.05676609e-02f, -1.25095457e-01f, -3.05260062e-01f,
  -1.07942812e-01f, -4.34429765e-01f, 2.99550518e-02f, 1.27279341e-01f, -5.57083413e-02f, -9.64118466e-02f, 3.64766717e-01f, 3.48467529e-01f, -3.93476412e-02f, 1.31262928e-01f,
  1.36672497e-01f, 1.13528250e-02f, -8.11702758e-02f, 1.11386590e-01f, -2.38240898e-01f, -4.40154463e-01f, 3.86952281e-01f, 5.38789153e-01f, 7.07850158e-02f, -7.13929310e-02f,
  2.10462995e-02f, 1.16186343e-01f, -1.93728834e-01f, 1.15991533e-01f, -3.33346933e-01f, 1.49596557e-01f, 7.43549228e-01f, 8.04137886e-01f, -2.74818033e-01f, 5.92555642e-01f,
  -7.99384043e-02f, -3.78240705e-01f, -2.23780751e-01f, -2.75462180e-01f, 8.07203531e-01f, -3.69256675e-01f, -1.35017380e-01f, -6.31250814e-02f, 1.03156954e-01f, 3.15155983e-01f,
  -1.00567631e-01f, 1.37305424e-01f, 2.14027226e-01f, -1.44221619e-01f, 6.58356622e-02f, 2.83121198e-01f, -8.40822980e-02f, 4.53897625e-01f, 7.13887662e-02f, 5.12829483e-01f,
  1.66517645e-01f, 1.80187359e-01f, 9.04605612e-02f, 3.16756040e-01f, -1.96127351e-02f, 9.24545303e-02f, 2.11054549e-01f, 4.11424309e-01f, -2.28600577e-01f, -3.54786873e-01f,
  1.28473505e-01f, 3.07179578e-02f, -2.17451304e-01f, 6.37719214e-01f, 1.34103626e-01f, 5.25636673e-01f, 7.73365125e-02f, 2.44407892e-01f, -7.20283538e-02f, 2.96518266e-01f,
  -2.36952528e-02f, 6.06780574e-02f, 3.67228508e-01f, -4.39239182e-02f, -2.44565874e-01f, 4.79605138e-01f, 2.45381951e-01f, 1.13583349e-01f, 6.14712834e-01f, 4.85785365e-01f,
  7.38028064e-02f, -6.56673610e-01f, 2.86697358e-01f, 5.72469592e-01f, -9.15656984e-02f, 2.89420914e-02f, 2.00555757e-01f, 1.13379233e-01f, 3.24937701e-01f, -9.27221850e-02f,
  -5.71688175e-01f, -4.26306836e-02f, 1.30291671e-01f, 5.81785776e-02f, -2.17350468e-01f, 7.47990459e-02f, 5.09819612e-02f, 2.42821291e-01f, 4.53577459e-01f, 1.73333474e-02f,
  3.73499662e-01f, 4.61308658e-01f, 6.79844856e-01f, -4.30923074e-01f, -2.15486631e-01f, -1.72409952e-01f, -3.36661518e-01f, 3.01074147e-01f, -3.80613089e-01f, 3.30099881e-01f,
  1.64807916e-01f, 2.29823217e-02f, -6.35705531e-01f, -7.27828145e-02f, -2.64182035e-02f, -2.68644601e-01f, -2.55264521e-01f, -3.65340203e-01f, -5.99900968e-02f, 1.81330577e-01f,
  -5.37373126e-02f, 1.01337835e-01f, -3.12320888e-01f, -2.54774988e-01f, 9.65064690e-02f, -2.75106847e-01f, 1.91512853e-01f, 1.21174023e-01f, 2.68268198e-01f, 5.20070314e-01f,
  1.88070640e-01f, 7.47078191e-03f, -2.92547882e-01f, 3.21782708e-01f, 4.88698622e-03f, -2.55898200e-02f, 5.07982969e-01f, 2.40212753e-01f, 2.77753007e-02f, -2.89914548e-01f,
  3.22132349e-01f, 1.32275537e-01f, -3.69488031e-01f, 1.98028088e-01f, 2.47771114e-01f, -1.70712158e-01f, -6.29016152e-03f, 2.11752966e-01f, -4.52952951e-01f, 3.55870634e-01f,
  -3.61759692e-01f, -2.68676728e-01f, -1.37266979e-01f, 3.45756054e-01f, -1.98542058e-01f, -1.87005907e-01f, 5.28165340e-01f, -3.55477363e-01f, 1.41035020e-02f, 6.68258667e-02f,
  4.21740383e-01f, -2.32576095e-02f, -3.77872914e-01f, -1.73535332e-01f, -2.53221095e-01f, 3.97907607e-02f, -6.86566457e-02f, 1.97372168e-01f, 3.17182571e-01f, 4.03514458e-03f,
  -9.89505649e-02f, -2.46571481e-01f, 2.50429720e-01f, 2.00794503e-01f, -8.86428654e-02f, -4.74733889e-01f, 1.20668538e-01f, 3.41160819e-02f, 1.31126225e-01f, 7.37710893e-02f,
  4.11421925e-01f, 2.95724988e-01f, 4.43496376e-01f, -1.38284445e-01f, 1.71921924e-01f, 1.35345995e-01f, 9.53509435e-02f, -3.79321694e-01f, 1.07691795e-01f, -3.84911090e-01f,
  -2.38227189e-01f, 4.55582321e-01f, 6.25523627e-01f, -1.96003914e-01f, -1.11511719e+00f, 4.91515726e-01f, 9.83226746e-02f, -3.35996717e-01f, -3.34066629e-01f, 2.89602488e-01f,
  -1.15391508e-01f, 3.81644875e-01f, 3.99067491e-01f, 9.66124758e-02f, 3.70324850e-01f, 3.27159315e-01f, 4.68879908e-01f, -4.13305819e-01f, 2.72424053e-02f, 1.76056013e-01f,
  1.25286728e-01f, -2.28008717e-01f, -1.30944282e-01f, -3.62878814e-02f, -8.78189504e-02f, 6.68748543e-02f, 1.75972223e-01f, 1.93923265e-02f, 2.76677072e-01f, 2.02153742e-01f,
  -2.92042464e-01f, 2.95380294e-01f, -1.46511137e-01f, -2.73425996e-01f, -1.37779832e-01f, 1.68828502e-01f, 3.75046074e-01f, -1.26632035e-01f, 3.48332256e-01f, 6.78023398e-02f,
  4.55592632e-01f, -1.89634651e-01f, -5.72302975e-02f, 2.00559556e-01f, -6.38021454e-02f, 4.12425190e-01f, -6.73867315e-02f, 3.61896038e-01f, -6.01041131e-02f, -2.79721409e-01f,
  -7.34571040e-01f, 3.14258337e-01f, 1.69503111e-02f, -3.07420313e-01f, -1.07730543e-02f, 4.01765779e-02f, 1.03705198e-01f, 2.32218564e-01f, 2.07964219e-02f, 1.57890111e-01f,
  2.13471889e-01f, 1.37607291e-01f, -2.64079630e-01f, 3.56186152e-01f, -3.92722309e-01f, -2.25642517e-01f, -1.26003951e-01f, -3.59678954e-01f, 3.82165819e-01f, -7.18872011e-01f,
  -1.11530229e-01f, -9.95541289e-02f, 2.49501124e-01f, 1.51750475e-01f, -7.54965782e-01f, -6.95590496e-01f, -1.50976762e-01f, 2.75044233e-01f, -7.07848072e-01f, 2.30027437e-01f,
  3.54935884e-01f, 3.76525223e-01f, 1.77497149e-01f, -1.32931784e-01f, 8.32018778e-02f, 1.40495077e-01f, -1.79706305e-01f, -4.66478586e-01f, -1.56136960e-01f, 3.53072703e-01f,
  7.75013701e-04f, -1.68456525e-01f, 6.99176714e-02f, 3.98885250e-01f, -7.25589246e-02f, -1.30148515e-01f, 4.15163457e-01f, -3.62047017e-01f, -1.91804647e-01f, -1.61027629e-02f,
  7.00741827e-01f, -2.04640076e-01f, -1.31680081e-02f, 5.58936059e-01f, -2.10499778e-01f, 8.18709880e-02f, 1.82467803e-01f, 3.54827464e-01f, 1.34981601e-02f, -1.54772848e-01f,
  2.02198550e-01f, 1.38975799e-01f, -2.54679710e-01f, 5.35651863e-01f, 1.47550613e-01f, -2.02517688e-01f, 8.59741960e-03f, 2.03180641e-01f, 4.76306319e-01f, 8.82734805e-02f,
  5.08032024e-01f, 2.58794487e-01f, 3.53943259e-01f, 1.07195210e-02f, 2.20769346e-01f, 1.98436990e-01f, -8.29927847e-02f, 8.96357000e-02f, -2.85524100e-01f, 3.82531226e-01f,
  1.88770473e-01f, -1.99577779e-01f, -5.16379774e-01f, 2.81589687e-01f, 3.22369576e-01f, -3.72448295e-01f, 6.38482347e-03f, 1.26230344e-01f, -1.88618526e-01f, -1.58975460e-02f,
  1.36013448e-01f, 6.37545884e-01f, -7.42021874e-02f, 3.55004102e-01f, 8.16692531e-01f, 3.09094101e-01f, 1.13272116e-01f, -2.72636771e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.27938882e-01f, 5.57423756e-02f, -1.17704622e-01f, 2.00534299e-01f, 7.03155920e-02f, 2.34167323e-01f, -4.04644385e-02f, 2.02160642e-01f, -5.12342155e-02f, 1.00792177e-01f,
  1.99908808e-01f, 8.98469761e-02f, 1.69581369e-01f, 1.23309810e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  1.00938775e-01f, 5.53064823e-01f, -2.85335541e-01f, -2.82716453e-01f, -1.64327562e-01f, -4.47216064e-01f, 9.68128443e-03f, 2.87318945e-01f, -1.47770897e-01f, 2.08449379e-01f,
  -3.61628771e-01f, -2.00713947e-01f, 4.21501815e-01f, -3.95267189e-01f, -4.63982552e-01f, 6.97325170e-01f, 6.47508278e-02f, -5.68785667e-01f, -2.94986218e-01f, -9.81910247e-03f,
  1.45792872e-01f, -1.83770940e-01f, -7.87327170e-01f, 8.64702910e-02f, -2.28938639e-01f, 3.00415248e-01f, 5.18104911e-01f, 3.48337770e-01f, -4.91770208e-01f, -1.51327029e-01f,
  -3.57453488e-02f, -4.06542480e-01f, -2.93537706e-01f, -3.02345157e-01f, 1.71591714e-01f, 3.74274820e-01f, -5.77084906e-02f, -1.04267374e-01f, 4.85020697e-01f, -4.69871819e-01f,
  2.79866874e-01f, -4.55475807e-01f, -4.71693248e-01f, -5.48132360e-01f, 1.67680308e-01f, 5.83873093e-01f, -6.26910627e-01f, 1.81365877e-01f, -1.14997335e-01f, -1.28024191e-01f,
  9.09158811e-02f, -6.18343651e-01f, 1.40351936e-01f, 2.15470746e-01f, -8.20964500e-02f, -2.17702612e-01f, -7.08281025e-02f, -3.26529682e-01f, -2.59422541e-01f, 3.86586308e-01f,
  1.67849109e-01f, -6.66629374e-01f, -4.07385677e-01f, 3.03385109e-01f, -1.73625499e-01f, 1.42403804e-02f, -1.71753153e-01f, -2.70768907e-02f, -7.18752563e-01f, 3.08582932e-01f,
  3.42438459e-01f, -4.60672349e-01f, 3.04279886e-02f, 6.59813583e-01f, 9.66323167e-03f, -1.10434756e-01f, -3.73610437e-01f, 1.04744211e-01f, -4.46631789e-01f, -5.43497086e-01f,
  2.03529775e-01f, 1.94477603e-01f, 6.19038306e-02f, -7.45784938e-01f, -4.29133922e-01f, -1.65059447e-01f, 1.16871297e-01f, 2.44562060e-01f, -4.23828781e-01f, -2.95044202e-02f,
  2.84968704e-01f, 2.19557211e-01f, -4.58161533e-01f, 3.99739236e-01f, -5.68573236e-01f, 3.26994151e-01f, 6.38083592e-02f, 4.44690645e-01f, 1.46262199e-01f, -1.40052825e-01f,
  7.72481710e-02f, 1.72396451e-01f, 4.04479951e-01f, -3.35708618e-01f, -4.04449522e-01f, -3.49721014e-01f, -1.62724614e-01f, 2.45020255e-01f, -4.45780963e-01f, 5.50810993e-01f,
  1.41562849e-01f, 4.78284687e-01f, 2.68963635e-01f, 5.26413694e-02f, -1.12218924e-01f, 1.41424760e-01f, 1.56951785e-01f, -4.65566367e-01f, -2.95077741e-01f, 4.14771467e-01f,
  -8.39246929e-01f, -2.30698716e-02f, -2.65034646e-01f, -1.56107530e-01f, -7.79576063e-01f, -3.96541804e-01f, 8.88832584e-02f, 3.16228956e-01f, 3.75672966e-01f, -5.56041777e-01f,
  3.52966189e-01f, -4.93958518e-02f, 1.99326519e-02f, 3.04531604e-01f, -2.67715096e-01f, 7.03189254e-01f, 4.22852814e-01f, 2.21349552e-01f, 1.52099775e-02f, -1.97709560e-01f,
  9.45982635e-02f, -3.83946091e-01f, -1.24270067e-01f, -6.25624716e-01f, -6.63136169e-02f, 8.50826502e-01f, -7.12536991e-01f, 6.31350949e-02f, 1.83793351e-01f, -2.14332432e-01f,
  2.94126011e-02f, 4.08493578e-02f, 4.21584435e-02f, 3.52471381e-01f, -4.22870666e-01f, -2.46122360e-01f, 3.47016715e-02f, -1.74286440e-01f, 2.94139028e-01f, -1.82462066e-01f,
  2.24117711e-01f, -2.38523781e-01f, 7.06251860e-02f, 1.93649605e-01f, -1.24628112e-01f, 4.25690800e-01f, -4.24618334e-01f, -1.12829089e-01f, 7.59756416e-02f, 3.10629576e-01f,
  7.10057437e-01f, -5.28686821e-01f, 1.96049228e-01f, -1.70581684e-01f, 9.98734385e-02f, 6.25031814e-02f, 2.95753926e-01f, -4.25789542e-02f, -3.87602821e-02f, -3.35828513e-01f,
  2.24833205e-01f, 2.47670263e-01f, 2.19502091e-01f, -3.70516390e-01f, -1.48379439e-02f, 4.28961813e-02f, 2.33835265e-01f, 4.24093427e-03f, -2.89062768e-01f, -5.01751840e-01f,
  -8.38129036e-03f, -5.49480736e-01f, 4.57038552e-01f, -2.86455333e-01f, -4.97383446e-01f, -1.85797632e-01f, 4.68161643e-01f, 2.10234016e-01f, 1.88389748e-01f, -4.44140196e-01f,
  -3.31416130e-02f, -5.46691000e-01f, -5.08006401e-02f, 1.45770460e-01f, 5.00582755e-01f, -3.17904562e-01f, -2.05290392e-01f, -7.72600323e-02f, -3.38084191e-01f, -4.07703072e-01f,
  -4.22629029e-01f, -8.18974078e-01f, -1.88339055e-01f, -5.62786534e-02f, -7.40366101e-01f, 1.17322072e-01f, 3.30738038e-01f, -6.32451251e-02f, 1.81034088e-01f, -1.84586018e-01f,
  1.44794106e-01f, 1.36530712e-01f, -6.52946085e-02f, 1.84984580e-01f, 3.29835504e-01f, 7.70983770e-02f, 4.44805235e-01f, -2.97033936e-01f, 4.11360078e-02f, -3.42639863e-01f,
  4.48239557e-02f, 2.39823699e-01f, -2.13112250e-01f, -1.04570054e-01f, 1.19030707e-01f, -6.83967024e-02f, 3.43130916e-01f, -3.32314759e-01f, 1.48388389e-02f, -4.09598695e-03f,
  -2.33754769e-01f, -9.65770185e-02f, -7.41417170e-01f, 6.12497091e-01f, -5.83057046e-01f, -3.36329967e-01f, -7.39848092e-02f, -1.57787427e-01f, -3.70947570e-01f, -3.06930602e-01f,
  -7.40669146e-02f, 2.54770488e-01f, -1.38764814e-01f, -2.38974825e-01f, 6.79584779e-03f, 3.00399154e-01f, 4.89906371e-01f, -1.80839986e-01f, 4.56202984e-01f, -2.62782961e-01f,
  2.34147295e-01f, -2.07232639e-01f, 2.22331196e-01f, 5.56640744e-01f, -4.94770296e-02f, -2.71457106e-01f, -4.65009630e-01f, 3.83023411e-01f, -7.15629280e-01f, -5.74302077e-01f,
  5.04313767e-01f, 4.97707427e-01f, -6.54846191e-01f, -5.20504117e-01f, 2.43003428e-01f, -1.63560495e-01f, -7.03684509e-01f, 2.20455036e-01f, 4.50645059e-01f, -3.09566826e-01f,
  -7.32932985e-01f, -9.04041231e-02f, -2.11528137e-01f, -2.63114393e-01f, 1.20332018e-01f, 9.08676460e-02f, -1.91675156e-01f, -3.83769095e-01f, -5.57368279e-01f, 6.09643497e-02f,
  -1.38834104e-01f, 1.46671966e-01f, 3.37434739e-01f, -9.93806496e-02f, -4.30239320e-01f, 8.55527759e-01f, 3.58722448e-01f, 2.58930713e-01f, 3.01561981e-01f, 1.70768380e-01f,
  -3.74220848e-01f, 6.15980089e-01f, 3.66681188e-01f, -6.54742196e-02f, 9.46605857e-03f, 3.98955911e-01f, 3.46106917e-01f, 2.45203227e-01f, -4.55838978e-01f, -5.29242098e-01f,
  -4.06504154e-01f, 2.62147486e-01f, 3.02139997e-01f, -4.38429058e-01f, -4.16896820e-01f, -2.53199160e-01f, -2.06520975e-01f, -6.03068583e-02f, -2.96361417e-01f, 2.77880937e-01f,
  -3.59711498e-01f, -8.03292692e-02f, -1.61798313e-01f, -3.68689626e-01f, 5.73847815e-02f, -3.81095231e-01f, 9.72119197e-02f, -2.35594615e-01f, -2.91748885e-02f, 3.92562337e-02f,
  -4.59043562e-01f, 1.86361045e-01f, 9.40886363e-02f, 6.86121702e-01f, 4.67984527e-01f, 3.00782740e-01f, 2.32186556e-01f, 8.09674799e-01f, 4.17813271e-01f, -1.15614519e-01f,
  1.53427109e-01f, -1.38494805e-01f, 3.46614033e-01f, -3.40414673e-01f, -2.56453574e-01f, -4.62367117e-01f, -3.75309736e-01f, -7.20081031e-01f, -5.48530400e-01f, 2.29510307e-01f,
  2.45491669e-01f, -8.88119563e-02f, 1.11706570e-01f, 4.06729043e-01f, 4.83010554e-05f, 2.31731772e-01f, -1.59455091e-01f, -3.21127415e-01f, -4.22785431e-01f, -1.23701118e-01f,
  -5.98627664e-02f, 2.29043260e-01f, 4.63413715e-01f, 2.03168735e-01f, 3.77661049e-01f, 2.16263980e-01f, 4.43763584e-01f, -2.72837013e-01f, 1.04706585e-01f, 9.62724388e-02f,
  5.34280427e-02f, 6.23632595e-02f, -2.71125585e-01f, 1.86338618e-01f, -7.68360421e-02f, -6.40667081e-01f, 3.22226733e-01f, -3.27021748e-01f, -4.29254472e-01f, -7.37153292e-01f,
  1.50288180e-01f, 8.58494788e-02f, -3.45855683e-01f, -1.02414832e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.00121513e-01f, -4.76139821e-02f, 2.05786183e-01f, -1.89175785e-01f, -1.30080685e-01f, -1.33416532e-02f, 1.21715508e-01f, 5.90423234e-02f, 4.56398353e-02f, -1.09208830e-01f,
  -1.00641124e-01f, 7.63945282e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    