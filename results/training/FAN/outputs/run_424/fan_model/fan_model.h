/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.31233740e-01f, 3.97170007e-01f, 1.28164724e-01f, 2.77184993e-01f, 6.58556819e-03f, 1.80427074e-01f, 2.80716419e-01f, -1.24343205e-02f, 4.40918267e-01f, 9.02115107e-02f,
  -1.72427502e-02f, 1.56190142e-01f, -1.26245677e-01f, 1.59346402e-01f, 8.97635221e-02f, 6.67614266e-02f, 1.89208537e-01f, 1.94126084e-01f, 8.56580585e-02f, 2.04338565e-01f,
  5.77163957e-02f, 2.46940330e-01f, -1.23232320e-01f, -2.10246444e-01f, 1.39292568e-01f, -5.23992553e-02f, 8.76447826e-04f, -1.08375169e-01f, 3.14955488e-02f, -5.51376417e-02f,
  -7.61898234e-02f, -3.59821953e-02f, 4.78094071e-02f, -3.26353833e-02f, 1.42657785e-02f, -8.38652924e-02f, -3.62347625e-02f, -5.90649731e-02f, -6.24237470e-02f, -7.79412920e-03f,
  7.52338395e-02f, -8.68279636e-02f, 1.18663892e-01f, 1.52233792e-02f, 5.52178249e-02f, -2.27387454e-02f, -6.66798130e-02f, 3.58423106e-02f, -2.95607690e-02f, -5.86859845e-02f,
  4.77908365e-02f, -2.22244337e-02f, 5.23159690e-02f, 1.19566523e-01f, -1.18333235e-01f, 3.83541845e-02f, 1.12832189e-02f, -2.70205494e-02f, 1.16682500e-02f, 6.51236549e-02f,
  -5.16910898e-03f, 2.27465434e-03f, -6.40414208e-02f, -3.76537405e-02f, 1.88818127e-02f, 6.95515499e-02f, -5.43791382e-03f, -2.69609527e-03f, 1.14953145e-01f, 1.28087223e-01f,
  6.61543906e-02f, 1.77520532e-02f, 1.35312947e-02f, 1.58707157e-01f, 4.97593209e-02f, 7.90966898e-02f, 1.14505589e-02f, -5.63054271e-02f, 9.45960432e-02f, -1.97787602e-02f,
  5.18648215e-02f, 5.93718402e-02f, -2.74866894e-02f, -5.23708668e-03f, -2.69043501e-02f, -3.67965735e-02f, -1.84269738e-03f, -2.66642403e-03f, -3.38309631e-02f, -2.61994656e-02f,
  1.71517059e-01f, 1.84916973e-01f, -4.69693542e-02f, -1.05440989e-03f, 6.50727376e-02f, -2.91941147e-02f, 8.72526504e-03f, 5.43632992e-02f, 3.60678183e-04f, -2.92943930e-03f,
  -1.52918492e-02f, -3.47454995e-02f, -5.74744977e-02f, 4.83223125e-02f, -5.53382635e-02f, 1.30816167e-02f, -1.04690604e-02f, 4.54932302e-02f, 7.79178068e-02f, 6.23737788e-03f,
  -2.73481421e-02f, 3.76464589e-03f, -7.22777694e-02f, 5.84839657e-02f, 3.88860404e-02f, -5.54635152e-02f, 5.42200804e-02f, -5.93036376e-02f, -9.87306237e-02f, -3.50540467e-02f,
  -5.08549690e-01f, 4.96816933e-01f, -1.59988642e-01f, -2.53686607e-02f, -1.43118024e-01f, 1.57812864e-01f, -1.64755851e-01f, 9.25901085e-02f, -2.75495779e-02f, 3.43530625e-01f,
  8.29861388e-02f, -6.66386634e-02f, 9.06549618e-02f, 1.06769577e-01f, -7.42663220e-02f, 2.02269331e-01f, 9.29106697e-02f, 8.34244415e-02f, -7.91234747e-02f, 3.62007655e-02f,
  -4.94431518e-02f, 1.55720636e-01f, -9.30544063e-02f, 1.29028022e-01f, -1.82717264e-01f, -7.39227831e-02f, 9.22640339e-02f, -6.21437244e-02f, 7.98859522e-02f, -1.17720529e-01f,
  1.42067689e-02f, -2.08333135e-03f, -8.80530700e-02f, 1.36136144e-01f, -4.39249128e-02f, -6.28936104e-03f, 5.79488911e-02f, -9.19562131e-02f, -3.39057781e-02f, 5.19717932e-02f,
  3.49603035e-02f, -2.61586476e-02f, 2.33692024e-03f, 8.71526601e-04f, -1.35487849e-02f, -1.93838701e-02f, -2.58758888e-02f, -9.12830513e-03f, 3.07175387e-02f, 1.95753556e-02f,
  -2.18170341e-02f, 6.74732104e-02f, 3.42603698e-02f, 4.71738018e-02f, -6.42438307e-02f, -2.73269750e-02f, -2.42135767e-02f, 2.02224478e-02f, 2.97787953e-02f, -7.96819944e-03f,
  -2.42418479e-02f, 5.94897866e-02f, -3.43030170e-02f, -2.92830355e-02f, 5.74399419e-05f, -1.00529827e-01f, -3.62232653e-03f, -3.03452574e-02f, -9.65224504e-02f, 4.66825105e-02f,
  -7.21433610e-02f, -4.04221006e-02f, 3.44218723e-02f, 2.99536245e-04f, -3.80197316e-02f, 1.41293798e-02f, 3.73495072e-02f, -4.99908477e-02f, 7.77112041e-03f, -1.17809474e-02f,
  5.28430939e-02f, -1.84000600e-02f, -2.75599584e-02f, -1.46694481e-02f, 3.15984823e-02f, 5.08102216e-02f, 5.26721142e-02f, 4.93055694e-02f, 6.63967952e-02f, -6.34769676e-04f,
  3.16384852e-01f, 2.04533234e-01f, 1.90077964e-02f, 5.13107982e-03f, -4.52111140e-02f, 2.59244666e-02f, 4.45778184e-02f, 4.94719930e-02f, 4.58106063e-02f, 2.41579898e-02f,
  1.20289130e-02f, -2.63569001e-02f, 2.54832790e-03f, 9.94179025e-03f, -4.41041365e-02f, 5.77823594e-02f, 5.83719984e-02f, 2.74558179e-02f, 6.53233603e-02f, -1.11002382e-02f,
  8.55128318e-02f, -6.05225675e-02f, -4.26367186e-02f, -7.06583709e-02f, 4.17858139e-02f, -1.61251556e-02f, -7.32907951e-02f, -4.09063138e-02f, 3.95306051e-02f, 2.32856758e-02f,
  -2.85137922e-01f, 1.04785375e-01f, -2.29797021e-01f, -3.22954178e-01f, -1.03191130e-01f, 3.70943457e-01f, 2.76453108e-01f, -1.66931555e-01f, -2.15423971e-01f, 6.49789944e-02f,
  -1.69107541e-02f, 6.10662065e-02f, 3.33500564e-01f, -2.37766355e-01f, -7.52538815e-02f, 2.21330225e-01f, -8.43449682e-02f, -2.60447767e-02f, -3.71336527e-02f, -2.31839195e-02f,
  -1.09030031e-01f, 9.90956277e-02f, -2.84956302e-02f, -3.72343734e-02f, -1.54339939e-01f, -8.66867900e-02f, 1.17681779e-01f, 8.81410018e-02f, -5.94400838e-02f, 8.29843059e-02f,
  -5.83694279e-02f, 7.47144409e-03f, -1.66329801e-01f, -2.31981501e-02f, 1.01338357e-01f, -2.47808173e-02f, 7.57839018e-03f, 8.44985694e-02f, -3.76188643e-02f, 3.53721119e-02f,
  1.55392185e-01f, -5.14041260e-02f, -3.78686450e-02f, 6.09843619e-02f, -1.48749709e-01f, -8.21737275e-02f, -1.02109872e-01f, -8.62615779e-02f, -4.85270806e-02f, -1.39531400e-02f,
  -1.37157902e-01f, -1.36355296e-01f, -3.71784493e-02f, 6.33404702e-02f, -9.07367654e-03f, 6.00193888e-02f, -1.33690462e-02f, 5.81009164e-02f, -4.78321686e-02f, 3.57219391e-02f,
  5.91411330e-02f, 1.05773687e-01f, 4.28912751e-02f, -4.49687354e-02f, 4.31426354e-02f, -2.08354015e-02f, 1.16624303e-01f, 2.26952434e-02f, 5.60146682e-02f, 5.62458932e-02f,
  -2.09145229e-02f, -3.06931101e-02f, -6.55479953e-02f, -3.47564146e-02f, -1.07743610e-02f, -4.40220203e-04f, 6.10241666e-02f, 5.73551953e-02f, 3.58608328e-02f, -6.32065237e-02f,
  8.44969228e-02f, -8.08740929e-02f, 5.94508164e-02f, 3.57808881e-02f, -2.33440306e-02f, -4.55461666e-02f, -7.60613084e-02f, -5.27238697e-02f, -3.23921554e-02f, 2.82778833e-02f,
  6.36547729e-02f, 2.36243680e-01f, 3.65510806e-02f, -1.30988201e-02f, 9.80123430e-02f, 5.94704710e-02f, -1.95618421e-02f, 3.37892212e-02f, -2.46440526e-02f, 1.31922150e-02f,
  -3.20566185e-02f, 7.22924597e-04f, 2.28057094e-02f, -6.62968820e-03f, 4.06351238e-02f, 6.85296804e-02f, 1.23231346e-02f, -2.61920467e-02f, -1.92897357e-02f, -5.28852753e-02f,
  2.85057705e-02f, 1.03710584e-01f, -5.71276061e-03f, -1.40535519e-01f, -1.31581351e-02f, 8.31315666e-02f, 2.06007697e-02f, -7.49317110e-02f, 5.82391173e-02f, -3.36285541e-03f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.24548972e-01f, 5.70850253e-01f, 3.05832833e-01f, 1.74642995e-01f, -1.11019552e-01f, -6.01918221e-01f, -4.31979269e-01f, 2.34323591e-01f, -1.37434825e-01f, 9.83223319e-02f,
  -8.04030336e-03f, 1.38991699e-01f, 1.96114928e-01f, -1.99526533e-01f, -5.05287409e-01f, -2.34154627e-01f, -2.28539735e-01f, -9.40024927e-02f, -1.93671346e-01f, 2.28609309e-01f,
  -1.48801124e-02f, -2.27896824e-01f, 8.32848251e-02f, 1.09009609e-01f, 4.13964428e-02f, 2.41239637e-01f, 2.90517330e-01f, 5.13273813e-02f, 2.03114986e-01f, -1.06284752e-01f,
  -1.24850914e-01f, 6.82626888e-02f, 9.50498432e-02f, 2.69462783e-02f, 6.71967193e-02f, -2.27811635e-02f, -4.95493189e-02f, -7.57577568e-02f, -8.23625177e-02f, 5.80213517e-02f,
  -1.45060018e-01f, 4.56862971e-02f, -1.46220326e-01f, -1.20978199e-01f, -6.61903387e-03f, 1.73521042e-02f, 8.60493332e-02f, -3.54773109e-03f, 1.46056637e-02f, 7.00749904e-02f,
  1.23225912e-01f, 6.34967536e-02f, 3.49078439e-02f, 6.73552826e-02f, 1.11182116e-01f, -1.11618429e-01f, -1.31947219e-01f, 1.20776691e-01f, 1.22432122e-02f, 2.99324133e-02f,
  8.23122337e-02f, -8.55223238e-02f, -6.12378586e-03f, 3.66833759e-03f, 9.19651315e-02f, -3.10374610e-02f, -8.10759962e-02f, -8.73764902e-02f, -3.54297720e-02f, -1.43038509e-02f,
  -4.76638377e-02f, 3.09189688e-02f, -1.80976495e-01f, -2.63713989e-02f, 7.75258522e-03f, -5.62970378e-02f, -3.71188819e-02f, 8.93118605e-02f, 4.55840640e-02f, -3.13695110e-02f,
  5.39669441e-03f, -3.60565931e-02f, 1.57310188e-01f, -6.92914873e-02f, -5.88380396e-02f, 1.02498434e-01f, 7.57713839e-02f, -2.85994038e-02f, 6.62064878e-03f, -7.12323040e-02f,
  9.40543711e-02f, 4.54664707e-01f, -3.21248472e-02f, -1.14547648e-01f, -1.15149077e-02f, -9.06698126e-03f, -7.86658749e-02f, -7.90636893e-03f, 1.41433507e-01f, -1.57164186e-01f,
  9.19119865e-02f, -5.83979152e-02f, -6.16187640e-02f, -1.17577547e-02f, 7.55866915e-02f, 4.18581963e-02f, 7.64725879e-02f, 1.04592428e-01f, 1.91716272e-02f, 1.45419925e-01f,
  8.06315690e-02f, 1.58115998e-02f, -1.82473317e-01f, -1.41040146e-01f, -9.12177712e-02f, -2.39042286e-02f, 4.05469835e-02f, 2.14768797e-01f, 6.51511401e-02f, 3.96755002e-02f,
  4.49187726e-01f, -1.19883627e-01f, -4.74098891e-01f, -6.85912818e-02f, 1.32838815e-01f, 2.47190654e-01f, 8.61987174e-02f, -4.83409986e-02f, -1.99885279e-01f, 1.67097434e-01f,
  4.84080046e-01f, -3.44601065e-01f, -2.04756975e-01f, 6.00360572e-01f, 1.15845867e-01f, -1.39179438e-01f, 2.60771304e-01f, 1.49347425e-01f, -1.39978692e-01f, 2.84024049e-02f,
  -4.72183302e-02f, 6.63257003e-01f, -3.80340330e-02f, 1.82663023e-01f, 2.25607261e-01f, -3.20069015e-01f, 2.62045562e-01f, -1.49797812e-01f, 1.80320933e-01f, 6.81832582e-02f,
  1.20819055e-01f, 1.25422642e-01f, 5.46859019e-02f, -4.23804075e-02f, -3.98844592e-02f, 4.77986448e-02f, -7.66283497e-02f, -9.28080305e-02f, -6.31130114e-02f, -6.42069280e-02f,
  -1.47251949e-01f, -4.92376229e-03f, 1.13031171e-01f, -5.73694296e-02f, 6.34286180e-03f, -7.55795315e-02f, 2.85293367e-02f, -9.15546343e-03f, -1.11917570e-01f, -3.70415077e-02f,
  -1.33878544e-01f, 1.83063708e-02f, -5.84375635e-02f, -5.94209209e-02f, -4.62371856e-02f, -7.23208068e-03f, -6.08524606e-02f, -1.10886477e-01f, -3.62023003e-02f, -1.84866842e-02f,
  2.14061067e-02f, -5.29897287e-02f, 6.74006343e-02f, 5.48956841e-02f, -2.15331893e-05f, -3.43706943e-02f, 5.33492193e-02f, 1.38252927e-02f, -7.19681755e-02f, 5.29104006e-03f,
  4.85094450e-02f, 4.62009199e-02f, -6.27076477e-02f, 4.02771030e-03f, 8.94691348e-02f, 2.86913128e-03f, 3.49934287e-02f, -1.19607747e-01f, -8.57084543e-02f, 3.44409095e-03f,
  -2.76479740e-02f, -5.62864840e-02f, 2.58004107e-02f, 1.59794316e-01f, -1.35101462e-02f, -5.50401537e-03f, 6.02811165e-02f, -1.29824569e-02f, -1.63426504e-01f, -1.10686004e-01f,
  6.51349500e-02f, -1.50663733e-01f, -7.79037327e-02f, 1.54745067e-03f, -9.62750316e-02f, 1.28524274e-01f, 7.26069603e-03f, 1.46065941e-02f, -1.21725291e-01f, 2.30983216e-02f,
  3.69445272e-02f, -6.57700524e-02f, -1.21511601e-01f, -5.42035466e-03f, -3.18003399e-03f, 1.15652971e-01f, -1.81531906e-02f, 2.97239108e-04f, -1.48722623e-02f, 5.77752404e-02f,
  2.93034539e-02f, 1.15657588e-02f, -1.72844380e-02f, -2.63532102e-02f, -1.08002806e-02f, -6.40229657e-02f, -1.25269666e-01f, -1.99671928e-02f, -2.84659062e-02f, -6.44189045e-02f,
  -2.28758097e-01f, -1.80113852e-01f, -1.54959008e-01f, -4.39297497e-01f, 1.68091029e-01f, -4.91928339e-01f, -6.50255144e-01f, -3.11296154e-02f, 7.17552304e-02f, -1.06170170e-01f,
  -4.46799062e-02f, -1.58627167e-01f, 1.42769337e-01f, -4.96499270e-01f, -1.83105454e-01f, -2.77502201e-02f, -7.31619120e-01f, -4.89374429e-01f, 1.66824207e-01f, -2.60366678e-01f,
  -7.82213360e-02f, -5.89811280e-02f, -3.61486405e-01f, 1.57718912e-01f, -1.97646335e-01f, -1.55864865e-01f, 1.45642534e-01f, 4.30456065e-02f, -2.12520704e-01f, 6.56078905e-02f,
  2.74728029e-03f, 1.03575669e-01f, -7.74709061e-02f, -6.83223605e-02f, -2.22220376e-01f, 6.09371520e-04f, -1.09588988e-01f, -7.43826628e-02f, -8.27076435e-02f, -9.30837244e-02f,
  -1.39826573e-02f, -7.85026699e-03f, -4.07334156e-02f, 2.44549409e-01f, -6.03516847e-02f, -1.05402373e-01f, -5.96605167e-02f, 3.54442596e-02f, -9.85657424e-02f, -6.74318001e-02f,
  -3.34949307e-02f, 1.19457170e-01f, -4.78285439e-02f, 3.39583457e-02f, 2.93416567e-02f, -1.81329213e-02f, -1.04159348e-01f, -5.09179048e-02f, -8.35394263e-02f, -7.33706057e-02f,
  1.02580577e-01f, -7.17824847e-02f, -6.57813996e-02f, 1.25860363e-01f, -1.13421619e-01f, 2.82103810e-02f, -1.35329813e-02f, 1.05607308e-01f, 4.43283608e-03f, -4.98272963e-02f,
  1.54746726e-01f, -2.02602819e-02f, -6.20063953e-02f, -7.21744373e-02f, -5.73081598e-02f, 6.39635429e-04f, 8.58594254e-02f, 8.00222997e-03f, -2.00270250e-01f, 6.04807697e-02f,
  -5.16615398e-02f, 7.21059740e-02f, 4.61269207e-02f, 1.48096025e-01f, -7.84321129e-02f, -5.69677390e-02f, 3.65182385e-02f, 4.48969863e-02f, -6.01332076e-02f, -2.59882491e-02f,
  -5.51670678e-02f, -1.47684321e-01f, 6.19665869e-02f, -3.97490002e-02f, -1.81685779e-02f, -5.16910329e-02f, -5.95194548e-02f, 6.72029927e-02f, -6.82476535e-02f, 4.64185365e-02f,
  -1.37862533e-01f, -2.32088685e-01f, 2.41443515e-02f, 5.53729385e-02f, -9.11181793e-02f, 8.54177624e-02f, -1.22346781e-01f, 5.88112622e-02f, 2.98757292e-03f, 6.07025139e-02f,
  1.20337792e-01f, 3.17401551e-02f, -4.52835634e-02f, -3.75339724e-02f, 2.83798072e-02f, -2.36799866e-02f, 2.76220664e-02f, -9.62985232e-02f, -7.45861307e-02f, 4.13760617e-02f,
  -1.40444368e-01f, 5.30449487e-02f, -3.60356212e-01f, -1.92155361e-01f, -1.59228712e-01f, -3.54121208e-01f, -4.46237803e-01f, -2.55823851e-01f, -1.60245989e-02f, -3.08235437e-02f,
  8.95201936e-02f, 1.74506709e-01f, 7.49082640e-02f, -2.27405310e-01f, 4.71667424e-02f, 1.80502862e-01f, -2.59905577e-01f, -8.87284279e-02f, 2.08539397e-01f, -9.60525200e-02f,
  8.49904791e-02f, -1.40520155e-01f, -3.31027899e-03f, -7.35566393e-02f, -3.37784767e-01f, -2.45048705e-05f, 7.89917558e-02f, 1.71806347e-02f, -2.96726674e-01f, 1.28323615e-01f,
  -1.11530572e-02f, 2.88534999e-01f, -7.71871060e-02f, -2.20142794e-03f, 1.78568549e-02f, -1.92100272e-01f, -2.70860996e-02f, 6.73818886e-02f, -3.20721529e-02f, -2.79528070e-02f,
  2.89879888e-02f, -1.05187036e-01f, 3.43795680e-02f, -7.83236884e-03f, -2.89649125e-02f, -8.56063887e-02f, 2.12654434e-02f, 8.84452313e-02f, -1.27551138e-01f, 5.62941246e-02f,
  -8.58531520e-02f, 4.29167636e-02f, -1.34687290e-01f, 3.86175886e-03f, -4.84908000e-02f, -2.98611224e-02f, 4.35849838e-03f, 4.52007465e-02f, 7.58195519e-02f, -3.78229022e-02f,
  4.90509719e-03f, -5.19327670e-02f, 1.10618934e-01f, 5.44378571e-02f, 1.31796822e-01f, 1.28795102e-01f, 1.45219527e-02f, -1.23879984e-02f, 1.07220627e-01f, 7.40914419e-02f,
  -4.38086167e-02f, 9.91470516e-02f, -4.90336977e-02f, 1.32425362e-02f, 2.02542599e-02f, 8.16649720e-02f, 5.79301082e-02f, 1.05325773e-01f, -7.46484147e-03f, 7.83536956e-02f,
  -1.18738852e-01f, -9.84343737e-02f, 4.43201475e-02f, 1.23521976e-01f, -1.24916350e-02f, -6.90427944e-02f, -6.53973073e-02f, 8.44637007e-02f, -2.93890741e-02f, 2.48388741e-02f,
  1.39857857e-02f, 2.10333630e-01f, 1.07233375e-01f, 1.06439203e-01f, 9.64169800e-02f, 1.21499553e-01f, -4.26984169e-02f, -5.58927236e-03f, 6.14376254e-02f, 6.26124144e-02f,
  -1.69078205e-02f, -1.61975380e-02f, -3.29184197e-02f, -1.53630450e-01f, 5.19192629e-02f, -2.18283143e-02f, 7.54515156e-02f, 4.20217365e-02f, 2.91657858e-02f, 1.22664995e-01f,
  7.92640150e-02f, 1.05925493e-01f, 1.93190854e-02f, 1.02634523e-02f, -6.53996021e-02f, 1.02512417e-02f, 1.36554882e-01f, 2.01086462e-01f, 1.34905145e-01f, -3.63694280e-02f,
  -7.69366205e-01f, 2.16959476e-01f, -1.12434424e-01f, -3.62859279e-01f, -1.07644618e-01f, -7.90783465e-02f, -3.02324265e-01f, 3.33627500e-02f, -1.87503815e-01f, -3.51748466e-02f,
  -2.55602628e-01f, -4.25402401e-03f, 1.87447339e-01f, -8.04218352e-02f, 3.33059467e-02f, 1.90628111e-01f, -1.09507456e-01f, -5.71674407e-02f, 1.09360099e-01f, 9.47132185e-02f,
  2.35233739e-01f, -6.30489960e-02f, 1.66770279e-01f, 1.26257583e-01f, 1.63914412e-02f, -9.18604434e-02f, 1.96201000e-02f, -9.02519524e-02f, -1.76907375e-01f, -1.44198820e-01f,
  -3.01801264e-01f, -3.06601614e-01f, -1.31009206e-01f, -6.35560378e-02f, -1.38410315e-01f, -6.38615936e-02f, -4.33543436e-02f, -1.01600446e-01f, -1.24568924e-01f, 2.06436217e-02f,
  -7.70299509e-02f, 3.69408652e-02f, -7.25352997e-03f, -4.08582576e-02f, 8.82156268e-02f, -4.13313918e-02f, 1.91698715e-01f, -2.46801283e-02f, 1.03388749e-01f, 7.94536695e-02f,
  1.76682975e-02f, 9.91216768e-03f, -7.98855573e-02f, 4.29510698e-02f, 2.80611161e-02f, -1.35500580e-01f, -1.31894117e-02f, -2.71317866e-02f, 7.88454413e-02f, -2.59561278e-02f,
  1.59919679e-01f, 5.23583889e-02f, -1.19780235e-01f, 1.68540813e-02f, -4.77648079e-02f, 7.57376775e-02f, -8.90955329e-02f, 8.18293616e-02f, -6.09926060e-02f, 5.88868335e-02f,
  -6.63936734e-02f, -1.96637195e-02f, 2.23595332e-02f, 1.49419308e-01f, 6.80909213e-03f, -1.47336408e-01f, -1.96958166e-02f, 1.86866466e-02f, 4.62396257e-02f, 7.09379208e-04f,
  5.08958623e-02f, 2.49685831e-02f, -2.70748176e-02f, 8.92377738e-03f, -1.24185160e-01f, 1.34526923e-01f, 1.06907873e-05f, 6.73961490e-02f, 2.75269374e-02f, 3.39594744e-02f,
  -1.93355650e-01f, -2.68929601e-01f, -6.72080815e-02f, -5.20778224e-02f, 8.52464736e-02f, 8.10005516e-03f, 2.28995159e-02f, 2.63401810e-02f, -8.77566785e-02f, -3.73953059e-02f,
  -3.65229920e-02f, -2.21363883e-02f, -4.26481105e-02f, 5.30726202e-02f, 6.21188506e-02f, -6.79390319e-03f, -9.14290398e-02f, -5.36656901e-02f, -2.09646001e-02f, 1.70619395e-02f,
  -1.31400060e-02f, -3.08477376e-02f, 6.74116164e-02f, 1.09526888e-02f, 9.24084894e-03f, 8.93629331e-04f, 7.19958693e-02f, -5.28887510e-02f, -3.53653282e-02f, -4.99264374e-02f,
  -1.12254143e+00f, -5.10655008e-02f, 1.21932931e-01f, -3.73942465e-01f, -2.49606505e-01f, -3.57519507e-01f, 2.60227561e-01f, -2.60327339e-01f, -1.75258487e-01f, 1.04072854e-01f,
  3.28835011e-01f, -1.23582117e-01f, 4.07439113e-01f, 1.44806057e-01f, -9.28059071e-02f, 2.26862460e-01f, -1.23271905e-01f, -1.52271269e-02f, -1.31104309e-02f, -3.55360359e-01f,
  -2.40540311e-01f, 8.93956944e-02f, 1.97239786e-01f, -8.26802552e-02f, -6.99430034e-02f, -2.19468370e-01f, 1.46499798e-01f, 2.10603550e-01f, -2.09871270e-02f, 6.66742772e-02f,
  -3.32083076e-01f, 2.39432398e-02f, -1.40909730e-02f, 5.22142183e-03f, -3.25342268e-02f, 6.24633580e-02f, -1.02785220e-02f, 5.33531010e-02f, -6.29974008e-02f, 2.70283818e-02f,
  -9.53979976e-03f, -1.14389353e-01f, -4.66095507e-02f, 1.58376154e-02f, -6.14628606e-02f, 6.23835996e-02f, -8.29560533e-02f, -2.04869988e-03f, -2.20366828e-02f, 2.28029713e-02f,
  1.09194979e-01f, 2.56813038e-02f, -2.05297302e-02f, 5.11616059e-02f, 8.33517686e-02f, -4.18024287e-02f, 1.86658427e-02f, 3.60024646e-02f, -1.63241297e-01f, -8.90196338e-02f,
  1.82438958e-02f, 6.94217607e-02f, 6.24545924e-02f, -3.31162624e-02f, -1.04417354e-02f, -3.77056445e-03f, 3.25950198e-02f, 1.80130452e-02f, 4.59871907e-03f, 6.73968866e-02f,
  -8.87225121e-02f, -8.46631378e-02f, -8.29657540e-03f, -1.35728763e-02f, -4.37488854e-02f, 1.43241081e-02f, 4.90348078e-02f, -1.09930515e-01f, -3.49204913e-02f, -4.94173765e-02f,
  3.40926349e-02f, 2.37881560e-02f, 2.27077864e-03f, 9.90511701e-02f, -8.42705444e-02f, 8.64703022e-03f, 7.52590075e-02f, -2.32053269e-02f, 2.34184470e-02f, -1.23542659e-02f,
  -7.58937359e-01f, -5.50759733e-01f, 6.23992383e-02f, -5.00438362e-02f, -5.17363362e-02f, -1.35337606e-01f, -1.39538543e-02f, -1.12113133e-01f, -8.09366629e-02f, -2.67037060e-02f,
  -8.54478553e-02f, 3.24574374e-02f, -1.10879757e-01f, 3.20252404e-02f, 9.18380823e-03f, -1.91278793e-02f, -5.80460727e-02f, -6.28476515e-02f, -3.70993353e-02f, -2.44069621e-02f,
  -1.38594517e-02f, -2.80242395e-02f, 2.23500710e-02f, 7.15326294e-02f, -5.96194379e-02f, 1.43958153e-02f, -1.49992391e-01f, -3.90566885e-02f, -4.26695310e-02f, -2.31244471e-02f,
  -6.42838240e-01f, 6.50706887e-02f, 3.63614559e-01f, -4.43229526e-02f, -5.23666944e-03f, 2.85091728e-01f, 1.69141382e-01f, 2.28977889e-01f, 2.75941730e-01f, 3.39584827e-01f,
  1.85194433e-01f, -4.22215723e-02f, 1.53443009e-01f, -2.39544977e-02f, 1.49700090e-01f, 3.92716452e-02f, -7.33207092e-02f, -2.00414389e-01f, -1.40895605e-01f, -1.84935078e-01f,
  -3.11577290e-01f, -1.59185082e-01f, -1.89511091e-01f, 1.50223345e-01f, -2.62618452e-01f, 2.12156046e-02f, -2.68532723e-01f, 1.52221650e-01f, 2.23579332e-02f, 7.87712038e-02f,
  -7.95110837e-02f, 1.56981781e-01f, -7.08256140e-02f, 8.19130763e-02f, 5.59524111e-02f, -3.23740803e-02f, -6.20702207e-02f, 1.90514512e-03f, -5.10501117e-03f, 9.32414383e-02f,
  -1.38420179e-01f, -3.21205817e-02f, -2.00747186e-03f, -8.18835273e-02f, -1.26484726e-02f, 1.71208635e-01f, -4.02693190e-02f, -3.72093022e-02f, -3.15038413e-02f, -1.15068972e-01f,
  3.35984454e-02f, -1.38286531e-01f, -2.17681583e-02f, 1.09240629e-01f, -1.58816185e-02f, -2.98738051e-02f, -9.40936580e-02f, -7.38202631e-02f, -3.06027122e-02f, 1.04485057e-01f,
  -8.71718023e-03f, 4.15841341e-02f, 8.10517520e-02f, 1.48661379e-02f, 1.11315824e-01f, -1.21971615e-01f, 3.08955163e-02f, -1.31580168e-02f, -2.89838687e-02f, -6.70392215e-02f,
  3.34825888e-02f, -3.05041987e-02f, -1.26437575e-01f, -1.01479560e-01f, -1.09222531e-01f, -7.55576640e-02f, -6.51230961e-02f, -3.94477844e-02f, 1.33822458e-02f, -1.24593209e-02f,
  -7.14709088e-02f, -1.80342495e-02f, 1.36988750e-02f, -5.54199480e-02f, 1.33489981e-01f, -2.88242996e-02f, 1.57842934e-02f, -1.14215367e-01f, -3.01069375e-02f, 1.10446420e-02f,
  3.88349712e-01f, 4.33884859e-01f, 1.26583263e-01f, 1.98694952e-02f, -2.42797844e-02f, 3.91487740e-02f, 9.43052322e-02f, -1.71424840e-02f, 1.80058673e-01f, 9.82348174e-02f,
  -4.43936288e-02f, 1.74930450e-02f, -1.31446481e-01f, -9.41731036e-03f, -1.39501840e-02f, 2.76584718e-02f, 3.30533693e-03f, -7.28760054e-03f, 3.20042148e-02f, 3.68350856e-02f,
  -4.21649329e-02f, 1.99664552e-02f, 8.17952864e-03f, -4.09088209e-02f, -3.24649438e-02f, -1.57323793e-01f, -8.82692710e-02f, 7.63733909e-02f, 3.72315310e-02f, 6.91069365e-02f,
  1.39626383e-04f, 4.34191376e-01f, 2.81936914e-01f, 1.31356135e-01f, -1.16659239e-01f, -5.70635378e-01f, -4.46429491e-01f, 7.82227516e-02f, -1.41559392e-01f, 2.06945851e-01f,
  -6.87503219e-02f, 7.88334757e-02f, -1.48735017e-01f, -1.31770521e-01f, -5.51189423e-01f, -3.96354705e-01f, -2.06693515e-01f, -1.14761315e-01f, -1.07250020e-01f, 6.14076629e-02f,
  -1.56002551e-01f, -2.15508282e-01f, -5.82273975e-02f, 1.65893003e-01f, 1.01452790e-01f, 3.19581777e-01f, 1.23185813e-01f, 1.32030129e-01f, 2.00588793e-01f, -4.03047428e-02f,
  -1.88601196e-01f, -3.76700284e-03f, 5.04647307e-02f, -8.79947934e-03f, -1.91354509e-02f, 1.39001846e-01f, 2.74665933e-02f, -6.96719810e-02f, -6.96683116e-03f, 9.51312706e-02f,
  4.06421609e-02f, -8.39529112e-02f, -3.14570265e-03f, -5.55480970e-03f, 7.54863620e-02f, -2.45277155e-02f, 5.32672852e-02f, 4.55676951e-02f, 3.83163057e-03f, 3.69061157e-02f,
  -2.10355967e-02f, 9.98725742e-03f, 1.39599487e-01f, 2.71101687e-02f, 7.64765963e-02f, -1.09330848e-01f, -7.33170062e-02f, -3.05337384e-02f, 3.32849398e-02f, -7.35671967e-02f,
  1.38873592e-01f, -3.33266170e-03f, -9.38270614e-02f, -3.32398899e-03f, -5.54802865e-02f, -7.97855668e-03f, -2.68436950e-02f, -6.33651242e-02f, 1.64754633e-02f, -3.10882665e-02f,
  -4.84251715e-02f, -1.35365613e-02f, -2.33349875e-02f, -7.87886232e-02f, 1.73205771e-02f, -6.14035912e-02f, -9.31388587e-02f, -2.85071228e-02f, -7.18630701e-02f, -1.84585399e-03f,
  2.66435686e-02f, -9.59542617e-02f, 8.50848556e-02f, 6.46617562e-02f, -1.11000128e-01f, 3.75854820e-02f, 6.44610226e-02f, 4.87340381e-03f, 3.00611965e-02f, 4.15020548e-02f,
  -5.14892265e-02f, 3.03167343e-01f, 5.42549901e-02f, -5.75120971e-02f, 5.40966913e-02f, -3.86256389e-02f, -7.18209846e-03f, 1.53848335e-01f, 4.98083122e-02f, -2.32341737e-02f,
  2.39193253e-03f, 2.79349871e-02f, 2.07992643e-02f, 1.73368771e-02f, -7.64643820e-03f, -5.73028177e-02f, -2.87803123e-03f, -3.35104428e-02f, 1.18153743e-01f, 9.40348506e-02f,
  7.98825845e-02f, -1.53662646e-02f, 6.35664836e-02f, 2.10786574e-02f, 3.77718098e-02f, 1.42326906e-01f, 4.44790944e-02f, -7.42133381e-03f, 1.32161956e-02f, 6.36740103e-02f,
  -1.69600710e-01f, -2.19991967e-01f, -1.78922135e-02f, 1.36569709e-01f, 1.09034311e-02f, -1.31706804e-01f, -4.01590437e-01f, 2.50952274e-01f, -2.95302331e-01f, -2.29327500e-01f,
  5.83398156e-02f, -2.15325162e-01f, -1.57041341e-01f, 2.84375139e-02f, 2.31580839e-01f, -3.20029378e-01f, 3.09558272e-01f, 9.77762137e-03f, 3.21831815e-02f, 1.78986639e-01f,
  2.34407321e-01f, 3.79023820e-01f, 3.42573255e-01f, 5.93066454e-01f, 1.69447452e-01f, 3.33393753e-01f, 5.09844124e-01f, 1.37114897e-01f, 4.38887179e-01f, 1.57196641e-01f,
  -1.31297529e-01f, -1.69439048e-01f, 2.83940006e-02f, 1.44097149e-01f, 5.50378300e-02f, -2.07045767e-02f, -1.11384146e-01f, 7.85649754e-04f, -7.39267841e-02f, 7.04682395e-02f,
  -2.94957925e-02f, 9.40103084e-02f, 8.92290175e-02f, 5.59383945e-04f, -9.51276347e-03f, 2.15770137e-02f, -3.01252306e-03f, -1.01853691e-01f, -5.55385388e-02f, -7.06700832e-02f,
  -1.06566586e-01f, -6.85527772e-02f, -1.36071378e-02f, -9.26330965e-03f, 3.07766460e-02f, 7.42409602e-02f, -3.72968353e-02f, -1.50976628e-01f, 5.45672737e-02f, -2.82731410e-02f,
  -6.29972219e-02f, -1.15321241e-02f, 3.93076427e-02f, 6.00389540e-02f, 4.29011369e-03f, 1.46645805e-04f, -1.23518482e-02f, 6.46462943e-03f, 3.18747871e-02f, 1.77303771e-03f,
  1.70317478e-02f, -2.19201073e-02f, 3.04404832e-03f, -9.46604759e-02f, -2.61784289e-02f, -4.33305241e-02f, -4.63738330e-02f, 5.12989890e-03f, -3.79432701e-02f, -6.70757517e-02f,
  -2.67921314e-02f, 2.58768220e-02f, -5.72688095e-02f, -4.20106389e-02f, 2.09687985e-02f, 4.71270718e-02f, -5.85949980e-03f, -2.75482144e-03f, 1.12237096e-01f, 4.01812419e-03f,
  -1.78004622e-01f, 1.49986371e-01f, -8.23584050e-02f, -2.17317156e-02f, 1.57057215e-02f, 9.03233048e-03f, 7.81755075e-02f, -1.41642243e-02f, 1.27231538e-01f, 6.74181134e-02f,
  -2.35246174e-04f, -4.81573120e-03f, -1.16364785e-01f, 1.21592656e-02f, 1.56270877e-01f, 4.41384083e-03f, -5.15615568e-02f, 4.64011095e-02f, 4.80632968e-02f, -2.47379448e-02f,
  5.20689674e-02f, -3.80787961e-02f, 6.26552328e-02f, 1.67187393e-01f, -5.98048652e-03f, -6.59014508e-02f, 8.01081285e-02f, 7.50741884e-02f, 9.93125420e-03f, 4.93418202e-02f,
  -4.13002104e-01f, 1.01704234e-02f, -3.21573794e-01f, -1.18756562e-01f, 3.08130801e-01f, -3.60877156e-01f, 2.39360835e-02f, 3.44879925e-01f, 2.10914039e-03f, 3.17973047e-01f,
  2.29785461e-02f, -2.59917229e-01f, 1.33793848e-02f, -4.10200834e-01f, -7.93722808e-01f, -5.73840618e-01f, -2.79646039e-01f, -1.50292024e-01f, -1.24439314e-01f, 1.46393269e-01f,
  -8.94937813e-02f, 8.68434682e-02f, -2.69445330e-01f, 4.23038274e-01f, 1.13529436e-01f, 2.96862870e-01f, 3.09955865e-01f, 1.42008960e-01f, 9.93107036e-02f, -2.29022838e-02f,
  -6.47915527e-02f, -3.38645615e-02f, 1.01502188e-01f, -2.01487746e-02f, 2.35391967e-02f, 3.99152972e-02f, 2.81251557e-02f, -5.47735915e-02f, -2.78548095e-02f, -2.65766233e-02f,
  -4.99951988e-02f, -3.89618948e-02f, -7.48077482e-02f, -4.94341925e-03f, -6.12111129e-02f, 9.90297832e-03f, -5.30238301e-02f, -5.47109358e-02f, 1.76645622e-01f, -9.65559259e-02f,
  -6.00286871e-02f, -6.67553395e-02f, -1.56217963e-01f, -1.05663523e-01f, -5.56890247e-03f, 1.08363563e-02f, -1.86966553e-01f, -5.89201525e-02f, -1.02976924e-02f, -2.09134445e-03f,
  -1.68720990e-01f, -1.16141709e-02f, 8.58433661e-04f, 3.20349373e-02f, 2.99116839e-02f, 8.42984617e-02f, -1.31078020e-01f, 2.90764105e-02f, 8.36875942e-03f, 2.74919085e-02f,
  -3.66384280e-03f, -2.83354521e-02f, 2.10368237e-03f, -1.69226564e-02f, -1.02379724e-01f, 1.08788565e-01f, -1.20716095e-01f, 1.05865180e-01f, -1.54210683e-02f, -3.37596275e-02f,
  -5.39257266e-02f, -6.08250722e-02f, 4.66156900e-02f, 5.70025891e-02f, 1.09706841e-01f, -4.55803722e-02f, -9.45782289e-02f, -5.96796609e-02f, 3.87070999e-02f, -5.97093515e-02f,
  4.69669886e-02f, 1.97950467e-01f, 4.97675762e-02f, 1.08338460e-01f, 1.36356652e-01f, -6.94990605e-02f, -8.43717083e-02f, -4.15444979e-03f, -7.63148218e-02f, -1.68555845e-02f,
  1.73914403e-01f, 1.20580345e-02f, -1.22097332e-03f, 4.49969843e-02f, 6.44087195e-02f, -8.74659941e-02f, 1.37269020e-01f, 6.32474720e-02f, 6.00992590e-02f, -2.77632531e-02f,
  4.49993052e-02f, 7.75043964e-02f, -6.70130085e-03f, 6.67457357e-02f, -7.31639266e-02f, 4.40965705e-02f, 8.69920626e-02f, 3.74375097e-02f, -4.22572270e-02f, 8.52448773e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.79320335e-01f, -1.53139476e-02f, 4.54388052e-01f, -3.11943263e-01f, -2.34479085e-02f, 1.67318404e-01f, -9.96789485e-02f, 2.36860693e-01f, 3.07864342e-02f, 9.79851186e-02f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -4.95917320e-01f, 3.93241018e-01f, 1.20868541e-01f, 1.83677703e-01f, 5.15996218e-01f, 3.85331988e-01f, -1.95514575e-01f, -6.64298758e-02f, 7.24166110e-02f, 4.71319854e-01f,
  3.57341528e-01f, -3.15985560e-01f, 4.99665350e-01f, -3.49925637e-01f, -4.33702804e-02f, -5.57221830e-01f, -2.28584945e-01f, 3.79627585e-01f, 2.80445278e-01f, -2.50004858e-01f,
  4.88504767e-01f, 2.49712631e-01f, -4.17789780e-02f, -1.99263439e-01f, 1.98304057e-01f, 2.92844981e-01f, 2.27962300e-01f, -1.80221260e-01f, 3.24990273e-01f, -2.06576139e-01f,
  5.26438534e-01f, 1.17134474e-01f, -1.60973266e-01f, -3.06547940e-01f, 1.17606185e-01f, 2.26809308e-01f, 4.27194417e-01f, 1.79188345e-02f, 2.33150604e-05f, 2.34503046e-01f,
  -2.35340640e-01f, -4.02737483e-02f, 1.18097678e-01f, 6.50813878e-02f, 3.59870970e-01f, -3.01094413e-01f, -4.09315586e-01f, -3.90979767e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.60193488e-01f, 1.38325885e-01f, -1.30591139e-01f, -3.81262042e-02f, 2.99497575e-01f, 7.69736245e-02f, 7.41305470e-01f, 1.62110940e-01f, 4.69953716e-02f, -2.94551730e-01f,
  -3.82320702e-01f, -3.19150090e-01f, -3.41902137e-01f, 7.05875158e-01f, 2.08469838e-01f, 6.84855461e-01f, 4.00209397e-01f, 1.30936414e-01f, -9.15820152e-02f, 1.01075292e-01f,
  -5.46564043e-01f, -2.57875204e-01f, 4.65560317e-01f, 5.69027476e-02f, 2.12424815e-01f, -4.43424225e-01f, -2.40112379e-01f, 2.71634124e-02f, -2.89774597e-01f, 4.85015139e-02f,
  2.23104000e-01f, 1.44165590e-01f, 7.28288174e-01f, -5.69502264e-02f, 5.75124919e-01f, -4.64243680e-01f, -4.76356983e-01f, 2.33460620e-01f, 4.26885694e-01f, 1.56764105e-01f,
  3.56024620e-03f, -3.49056482e-01f, 4.30077553e-01f, 1.23940647e+00f, -5.40731382e-03f, 2.10049450e-01f, -3.41744334e-01f, 7.83089697e-01f, 1.55279845e-01f, 2.05572218e-01f,
  -1.93141028e-01f, 2.26389363e-01f, 1.21997640e-01f, -9.52369720e-02f, 4.92913097e-01f, 1.89250976e-01f, 1.40130699e-01f, -3.00027728e-01f, -6.37598634e-01f, -4.44542944e-01f,
  -4.72678304e-01f, 4.28373098e-01f, 4.25369620e-01f, 4.02834639e-02f, 2.72411019e-01f, 2.55108714e-01f, 1.58987731e-01f, 1.59031779e-01f, -5.42461336e-01f, -2.46603295e-01f,
  4.36337054e-01f, 8.30990300e-02f, 4.64625537e-01f, 3.82919125e-02f, 3.08707915e-02f, -1.12124463e-03f, -2.42425978e-01f, 2.43557587e-01f, 4.80260700e-01f, -1.34371713e-01f,
  -9.74317640e-02f, 2.42394686e-01f, 1.33472875e-01f, 8.65058303e-02f, -8.68564993e-02f, -6.20794445e-02f, 1.80388898e-01f, 6.83963358e-01f, 1.72713071e-01f, -1.52114987e-01f,
  -2.47305240e-02f, -4.45702016e-01f, 3.28983158e-01f, 8.95398185e-02f, 2.99015224e-01f, -2.29634702e-01f, 2.81220004e-02f, -2.13004738e-01f, -2.33454943e-01f, 2.15877742e-01f,
  1.83029130e-01f, -4.58303094e-01f, 5.13200052e-02f, 1.68879434e-01f, -1.53126478e-01f, 2.22784400e-01f, 1.75147712e-01f, -3.57177705e-01f, 1.30069509e-01f, 2.41359696e-01f,
  -5.74671566e-01f, -4.65056032e-01f, 4.45567369e-02f, -1.57937869e-01f, 1.67415962e-01f, -9.18501616e-03f, 3.87188613e-01f, 8.34502205e-02f, -8.28808732e-03f, 8.88913453e-01f,
  -1.37025341e-01f, -2.15202600e-01f, 4.15274292e-01f, 9.17997137e-02f, -1.18159562e-01f, -1.94616616e-02f, 6.69678807e-01f, -5.55018708e-02f, 1.63077116e-01f, 3.52502167e-01f,
  2.60614812e-01f, -6.58704877e-01f, -2.21766103e-02f, -1.26607314e-01f, 1.53409034e-01f, -3.06037515e-01f, 5.70253968e-01f, 2.42864713e-01f, 5.43887794e-01f, 4.53520864e-01f,
  3.56799006e-01f, 1.40452847e-01f, 2.15491652e-02f, 3.63996834e-01f, -1.55953143e-03f, -4.76308644e-01f, -5.83287358e-01f, 4.55505013e-01f, -9.48753476e-01f, -5.92659831e-01f,
  -7.57443964e-01f, 8.45091417e-02f, 1.34569570e-01f, -7.24905550e-01f, -4.88738894e-01f, -4.74294722e-01f, -1.12030402e-01f, -3.09374601e-01f, 4.20954645e-01f, 3.85166109e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.25734964e-01f, 1.46036357e-01f, 3.03411573e-01f, 1.55296743e-01f, 5.19111693e-01f, 2.25302979e-01f, 5.40518723e-02f, 2.44881749e-01f, 4.27212417e-01f, 1.69763252e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.08999219e-02f, 2.14834660e-01f, -6.51732683e-02f, -6.13051206e-02f, -1.21715125e-02f, 2.51450181e-01f, -7.01179355e-03f, 1.35442153e-01f, -5.40241525e-02f, 2.56168842e-01f,
  2.26320829e-02f, 2.88105428e-01f, 1.59499794e-01f, 1.22450359e-01f, -4.06446934e-01f, 1.80036217e-01f, 1.49306551e-01f, -5.38209021e-01f, 2.54761577e-01f, 7.31953800e-01f,
  5.15116632e-01f, -5.44394374e-01f, 7.19731078e-02f, 9.27586283e-04f, -3.30321819e-01f, 1.02738991e-01f, 3.87971997e-02f, 1.63466297e-02f, -3.11446875e-01f, 2.77834177e-01f,
  1.95191771e-01f, 2.52435118e-01f, -4.62061390e-02f, 3.68057162e-01f, 1.73081696e-01f, -1.64116651e-01f, -8.26796442e-02f, 3.96216393e-01f, -6.42722398e-02f, 2.97500581e-01f,
  -1.02347620e-01f, 1.98513031e-01f, 2.80202568e-01f, 3.79232317e-01f, 3.68639261e-01f, 2.51878172e-01f, -3.70860815e-01f, -4.30476293e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.07517235e-01f, 2.96427131e-01f, -3.64089936e-01f, -4.72174317e-01f, -8.86439532e-02f, -5.20990007e-02f, -5.72604984e-02f, 2.07379162e-01f, -3.13681930e-01f, 3.08917195e-01f,
  3.61909300e-01f, 6.12814724e-01f, 1.77348688e-01f, 6.18633211e-01f, -6.08975530e-01f, 9.54299986e-01f, 7.40644813e-01f, 1.23153284e-01f, 5.67012906e-01f, 5.09423375e-01f,
  4.21933174e-01f, 6.05774522e-01f, 1.54688861e-02f, -4.10022527e-01f, 7.71983981e-01f, -4.26138402e-04f, -3.77480000e-01f, 1.75247844e-02f, -6.09313846e-01f, 6.39597535e-01f,
  4.19837266e-01f, -4.55136478e-01f, -4.53011394e-01f, -7.70945430e-01f, 3.78072917e-01f, 7.17996716e-01f, 5.30116916e-01f, -2.79926389e-01f, -4.08440471e-01f, -1.06832050e-01f,
  9.01635140e-02f, -2.45141443e-02f, 5.73646486e-01f, -2.59779789e-03f, -7.92840347e-02f, -1.84954360e-01f, 5.13064206e-01f, 8.61896455e-01f, 4.37525697e-02f, 9.82449278e-02f,
  4.22341645e-01f, 8.20880949e-01f, 7.01129735e-01f, 2.44629264e-01f, -3.60589087e-01f, 4.91563529e-02f, -1.76250592e-01f, -1.84653401e-01f, 3.90545279e-01f, 5.77942014e-01f,
  -3.56305897e-01f, 1.88156724e-01f, 1.74784720e-01f, 1.01347113e+00f, 2.48322815e-01f, 3.83861423e-01f, 5.99167764e-01f, -7.12874904e-02f, -2.97072679e-01f, 1.33658215e-01f,
  -1.96059689e-01f, 1.58144191e-01f, 6.87644601e-01f, -3.94497156e-01f, -2.64123101e-02f, 1.39282748e-01f, -1.12056956e-01f, 4.42211807e-01f, 4.14630651e-01f, 7.05054343e-01f,
  2.03812063e-01f, 3.02922755e-01f, 1.87102541e-01f, -1.07146227e+00f, -5.10781109e-02f, -9.02799726e-01f, 9.65537190e-01f, 6.90034211e-01f, 7.97678590e-01f, 6.76850438e-01f,
  7.88774252e-01f, -1.77213743e-01f, 6.88944876e-01f, -2.42347479e-01f, 4.36413854e-01f, -1.09379494e+00f, 4.58720267e-01f, -3.06380779e-01f, 4.13776428e-01f, 9.05516028e-01f,
  6.78456306e-01f, -2.44788036e-01f, 4.77272831e-02f, -2.74745643e-01f, 1.53423727e-01f, -1.76246554e-01f, 2.08253801e-01f, 2.99109556e-02f, -6.41676247e-01f, 3.79425526e-01f,
  8.07759345e-01f, -1.54250562e-01f, -3.30683552e-02f, 7.68654272e-02f, -2.11755425e-01f, -3.13080013e-01f, 3.65754098e-01f, -4.86031592e-01f, 6.09622419e-01f, 2.76593029e-01f,
  -2.84962505e-01f, 5.17918289e-01f, 4.08625811e-01f, 6.08816862e-01f, 2.21469119e-01f, 3.84049267e-01f, -5.10195196e-01f, -2.64939994e-01f, 2.32313275e-01f, 6.50215924e-01f,
  5.56863844e-01f, 9.13606644e-01f, 3.39982331e-01f, 1.01375031e+00f, -9.98617336e-03f, -5.26576877e-01f, 3.17092240e-01f, -2.57993191e-01f, -1.51514754e-01f, 2.01330468e-01f,
  -3.91658425e-01f, 5.05920768e-01f, -1.36201352e-01f, -7.88074613e-01f, -7.56729990e-02f, 4.56067026e-01f, 8.45591784e-01f, -4.04275984e-01f, -1.35212016e+00f, -5.58333158e-01f,
  1.44016162e-01f, 3.23107362e-01f, 9.06681269e-02f, 2.84025688e-02f, 2.12095037e-01f, -1.23982593e-01f, 3.08995783e-01f, -7.27049530e-01f, -3.10943741e-02f, 1.03649342e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -8.86454880e-02f, 7.14050308e-02f, 4.75505553e-02f, 3.55852604e-01f, 3.04980695e-01f, 4.03533608e-01f, 2.94542581e-01f, 1.63944393e-01f, 5.48328161e-01f, 2.82304794e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.72270238e-01f, 1.16561474e-02f, -1.56969741e-01f, -2.53889501e-01f, 5.25152236e-02f, 2.00537682e-01f, -4.63128276e-02f, -2.49128908e-01f, 2.02209055e-01f, 2.38178492e-01f,
  2.84795374e-01f, -8.56646076e-02f, 1.28362566e-01f, -4.49436307e-01f, -4.66761023e-01f, 3.10065687e-01f, -4.89226244e-02f, 2.06149712e-01f, 2.23502219e-02f, 3.39866847e-01f,
  -9.21520218e-02f, 1.49642944e-01f, 1.22710541e-01f, -2.97104776e-01f, 2.56184191e-02f, -1.22115061e-01f, -1.60235345e-01f, 1.99335843e-01f, -2.35221356e-01f, 2.12701693e-01f,
  -1.94862887e-01f, -1.60486579e-01f, 4.76178490e-02f, 9.72202048e-02f, -1.12590767e-01f, 2.62590945e-01f, 3.81445795e-01f, 2.76246905e-01f, 3.21682155e-01f, -1.91624641e-01f,
  3.36286798e-02f, -1.75583944e-01f, -2.81150907e-01f, 1.25963107e-01f, -9.97551456e-02f, 3.60508054e-01f, 5.51248230e-02f, 1.44783497e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  7.08686411e-01f, -3.63507628e-01f, 5.50530910e-01f, -8.65017176e-02f, -7.43880868e-01f, 4.85952467e-01f, -1.83192819e-01f, 4.78397191e-01f, -1.14726114e+00f, -1.48983032e-01f,
  7.60472178e-01f, 4.24716771e-01f, -4.42161895e-02f, -9.28261802e-02f, 8.72420192e-01f, 1.10332763e+00f, 1.81386322e-01f, -3.42776567e-01f, 5.96236289e-02f, -5.45615554e-01f,
  -1.04516995e+00f, -4.53588814e-01f, -2.10298464e-01f, 6.07677698e-01f, -7.86183715e-01f, -5.58601439e-01f, 3.05872560e-01f, 8.16412151e-01f, 1.61509037e-01f, 2.61638016e-01f,
  8.68984014e-02f, -1.90669119e-01f, -1.64440536e+00f, -3.83328319e-01f, -1.52028811e+00f, 3.36285591e-01f, 8.16822290e-01f, -7.27767706e-01f, 9.54682052e-01f, 3.43461245e-01f,
  8.09630692e-01f, 2.58304536e-01f, 4.41491842e-01f, 1.29832312e-01f, 7.58398652e-01f, 3.04506689e-01f, -6.07337117e-01f, -8.25487256e-01f, 9.85416591e-01f, 8.92759323e-01f,
  9.69417155e-01f, -7.32963324e-01f, 7.25779712e-01f, -4.75099534e-01f, -5.94695151e-01f, 8.11064363e-01f, 4.79221970e-01f, 1.11527658e+00f, 3.57785672e-01f, -1.12174585e-01f,
  1.00000441e+00f, -6.22882843e-02f, 9.45990205e-01f, -7.51029134e-01f, 3.51215422e-01f, 2.19506830e-01f, 2.32203886e-01f, 2.29327470e-01f, -9.55649376e-01f, 3.34201962e-01f,
  6.71592116e-01f, 2.85536587e-01f, 1.90945163e-01f, 6.21873736e-01f, 7.84815669e-01f, -2.40511328e-01f, -1.99958235e-01f, -3.31216067e-01f, 1.20468587e-01f, 1.56005013e+00f,
  -2.34920561e-01f, 8.34085941e-02f, -2.16403157e-01f, 1.84376687e-01f, 2.31199712e-01f, -1.75426334e-01f, 1.42544955e-01f, -1.18386775e-01f, 5.21399081e-02f, 5.07028103e-02f,
  -2.43960619e-01f, -3.78521383e-02f, -1.97607279e-01f, -2.49610126e-01f, -7.73604810e-02f, -2.18006194e-01f, 2.07090586e-01f, -2.37928420e-01f, -4.06573899e-02f, 1.37190476e-01f,
  1.83246329e-01f, 2.02487603e-01f, -1.72703683e-01f, -1.00392789e-01f, 1.18814111e-01f, -6.16453448e-03f, -9.60391834e-02f, -1.38005078e-01f, -1.03089780e-01f, -1.91026360e-01f,
  -1.23986274e-01f, 1.25316188e-01f, -6.59814119e-01f, 1.10423326e-01f, -9.71475422e-01f, 1.24644578e+00f, 5.11297762e-01f, 1.06465399e+00f, 9.59363818e-01f, -7.65092447e-02f,
  1.78419679e-01f, 4.92131472e-01f, -6.64014444e-02f, 9.66085866e-02f, -4.36765887e-02f, 4.92016077e-01f, 5.26439771e-02f, 8.23618174e-01f, 5.49144030e-01f, 6.95488989e-01f,
  1.91110194e-01f, 2.97543883e-01f, -7.92352408e-02f, 5.53492367e-01f, 8.05890858e-02f, -2.63628930e-01f, 5.73354840e-01f, -1.25447944e-01f, 1.39467731e-01f, 8.81912172e-01f,
  -8.87884796e-02f, 3.07828486e-01f, -8.17570865e-01f, 1.18703270e+00f, 5.33283591e-01f, 3.72265756e-01f, 1.40935689e-01f, -2.24957660e-01f, 2.41026804e-01f, -7.37259239e-02f,
  3.32714051e-01f, -1.41953379e-01f, -7.86225379e-01f, -1.17708981e-01f, -3.29536527e-01f, 4.63892311e-01f, -1.99426562e-01f, 1.00460148e+00f, -1.16708763e-01f, -4.84003305e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  4.61118966e-01f, 2.36580878e-01f, -3.34444672e-01f, 7.30351150e-01f, 4.46337014e-01f, -2.26255894e-01f, -1.26420796e-01f, 3.54566611e-02f, 3.93329471e-01f, 2.35093370e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -6.35312796e-01f, -4.09246773e-01f, -2.16936082e-01f, -1.35189816e-01f, 2.24647492e-01f, 5.77215478e-03f, 5.64894140e-01f, 5.33676326e-01f, -8.09283078e-01f, -2.11577676e-02f,
  4.76809978e-01f, 5.10924757e-02f, 2.05905139e-01f, -6.45939529e-01f, -1.60176432e+00f, -3.63271534e-01f, -6.52696133e-01f, 2.51894891e-01f, 4.39439833e-01f, -7.46830404e-02f,
  -5.90440392e-01f, 5.53983212e-01f, 7.54063874e-02f, -4.18907046e-01f, 1.06628105e-01f, -3.47430026e-03f, 7.85292089e-02f, 2.48056054e-01f, 2.03153849e-01f, 3.44004273e-01f,
  -7.23270059e-01f, -2.77945668e-01f, 2.84426212e-01f, 5.93883209e-02f, -2.34638229e-01f, -6.71209097e-01f, 2.83798188e-01f, 5.11629224e-01f, -7.76313663e-01f, -6.87042058e-01f,
  5.06417751e-01f, -6.62822127e-01f, 9.84076634e-02f, 5.84730804e-02f, 5.97363189e-02f, 2.54349798e-01f, -5.33701703e-02f, -5.84445149e-02f, 5.79342060e-02f, 3.30466986e-01f,
  -4.82485056e-01f, 7.40984917e-01f, -2.44641110e-01f, -9.57181826e-02f, 1.40717328e-01f, 3.99010330e-01f, 2.27484226e-01f, -3.65031123e-01f, -4.46337670e-01f, -1.59062207e-01f,
  -2.03000024e-01f, -4.80962247e-01f, 6.33735955e-02f, -9.63688731e-01f, 6.13895237e-01f, -1.09131366e-01f, -4.09365863e-01f, 8.07684422e-01f, 7.06714332e-01f, 1.82041749e-01f,
  -2.15748653e-01f, 1.11046605e-01f, 1.87409252e-01f, 3.21812272e-01f, 1.55370936e-01f, 2.17226058e-01f, 1.48172885e-01f, -1.49122620e+00f, -6.77642405e-01f, -4.38807935e-01f,
  5.22002637e-01f, -4.61196542e-01f, 6.08023584e-01f, -5.05690277e-01f, -8.51715803e-01f, -9.49587643e-01f, 4.60258089e-02f, -1.06863904e+00f, -9.77878153e-01f, 7.32760072e-01f,
  1.58929721e-01f, 1.43036872e-01f, 5.97550813e-03f, -7.70720899e-01f, -7.30163097e-01f, -8.61125469e-01f, 3.15055847e-01f, 4.92003590e-01f, 3.48885357e-01f, 2.41848007e-01f,
  6.41827524e-01f, 6.09782636e-01f, 1.11681009e-02f, -8.79806280e-01f, -4.12780821e-01f, -4.71506804e-01f, 5.34364343e-01f, -2.17666149e-01f, -1.69002548e-01f, 2.22855315e-01f,
  4.25914764e-01f, -4.87692475e-01f, -2.48432577e-01f, -1.51357234e-01f, -2.17026860e-01f, 5.80309212e-01f, -5.06577551e-01f, -6.20296597e-01f, -1.04107702e+00f, -6.38426840e-01f,
  4.74004388e-01f, 2.27555651e-02f, -5.02714664e-02f, -1.27733231e-01f, -2.81256903e-02f, -3.58161509e-01f, 1.80972591e-01f, -1.20297325e+00f, -4.73746568e-01f, 1.99992225e-01f,
  -3.32551152e-01f, 9.36267972e-02f, -1.71752229e-01f, 8.23280215e-02f, -6.13462508e-01f, -2.26250384e-02f, -9.44930711e-04f, -4.15443242e-01f, -8.84409666e-01f, -2.02170521e-01f,
  4.96576354e-02f, 2.30646849e-01f, 3.59527767e-01f, 3.27659041e-01f, 6.37235403e-01f, 3.37679267e-01f, 1.13154098e-01f, 4.42226410e-01f, -7.09633827e-01f, -4.94548768e-01f,
  4.58708316e-01f, 2.96957165e-01f, -1.11641109e+00f, -1.36095375e-01f, 4.56483066e-01f, -1.70025021e-01f, -3.00642438e-02f, -5.31772912e-01f, 4.79312316e-02f, -9.24060285e-01f,
  -2.44435728e-01f, -2.12214720e-02f, 2.05805242e-01f, 6.90476373e-02f, 4.77066427e-01f, -9.48690176e-02f, 1.34064347e-01f, 3.24350148e-01f, -5.45197308e-01f, -2.28383928e-03f,
  -8.22991669e-01f, -1.78770781e-01f, -3.46759148e-02f, -1.06280780e+00f, 3.26506108e-01f, 3.56996655e-01f, 1.06612265e-01f, 5.44438697e-02f, -9.79883894e-02f, -4.55627322e-01f,
  1.95964634e-01f, 4.62029934e-01f, 3.37651581e-01f, 2.81481385e-01f, -1.27987671e+00f, -8.83204103e-01f, -2.13517085e-01f, 1.09266192e-01f, -1.99849695e-01f, -7.84503594e-02f,
  4.37172771e-01f, 2.90011674e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.00093234e-01f, 2.76157975e-01f, 8.39306563e-02f, -1.50945857e-01f, -1.44415185e-01f, 5.69048285e-01f, 3.78090918e-01f, 5.76951355e-03f, -2.47254491e-01f, 2.34025139e-02f,
  1.74604639e-01f, 6.95059747e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    