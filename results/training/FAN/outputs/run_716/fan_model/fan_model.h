/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.13545668e-01f, -1.35597467e-01f, -9.98311564e-02f, -8.47548395e-02f, 4.83701490e-02f, -4.59435955e-02f, -1.74469709e-01f, -2.59361546e-02f, 9.40422490e-02f, -1.37825022e-02f,
  3.19243483e-02f, 3.14860523e-01f, 2.20125556e-01f, 3.32627833e-01f, -3.10228765e-02f, -2.32130125e-01f, 1.85356440e-03f, 3.83839570e-03f, 7.92438090e-02f, 5.61495945e-02f,
  2.39572883e-01f, -9.09324288e-02f, -4.32930142e-02f, 1.88001432e-02f, 1.19869418e-01f, 1.08503982e-01f, -8.23985040e-02f, -5.81371672e-02f, 2.22487405e-01f, 1.99442789e-01f,
  -1.36964589e-01f, -1.12670146e-01f, 7.37731904e-02f, 1.65386334e-01f, -9.14273842e-04f, 6.79564849e-03f, -4.82492223e-02f, -2.16443688e-02f, -3.24685350e-02f, 4.28927951e-02f,
  6.71071485e-02f, 4.33470421e-02f, 7.57021531e-02f, 7.40015358e-02f, -5.09999096e-02f, -1.88999064e-02f, 7.10154697e-02f, 1.38143137e-01f, 1.29205793e-01f, -3.48142236e-02f,
  2.20226958e-01f, 8.56548995e-02f, -7.86170736e-03f, 3.85380723e-02f, -6.02303222e-02f, 2.79529765e-02f, 2.02849656e-02f, 1.35734290e-01f, 9.29764658e-02f, 1.63374525e-02f,
  -4.70768213e-02f, 4.54867026e-03f, 6.54071942e-02f, -2.56718211e-02f, 3.72263626e-03f, -3.64167336e-03f, 4.73661721e-02f, -9.83998626e-02f, 6.98190555e-02f, -1.55093327e-01f,
  5.37186675e-02f, -2.15944927e-02f, -5.67967258e-02f, -8.30543861e-02f, -6.81850463e-02f, -5.00900932e-02f, -1.74666196e-02f, -1.02841720e-01f, 8.70260503e-03f, -4.37220559e-04f,
  7.20880702e-02f, 1.30171284e-01f, -1.43007025e-01f, 2.01735497e-02f, 1.98457930e-02f, -1.37390196e-02f, -1.00300655e-01f, 4.12848033e-03f, -6.56454116e-02f, -6.76024631e-02f,
  -1.86973765e-01f, -3.35360840e-02f, 1.61252834e-03f, -8.39801878e-03f, -9.09486599e-03f, 1.00886315e-01f, -5.77618107e-02f, 2.77238730e-02f, -8.23428296e-03f, -6.70627058e-02f,
  -6.91338032e-02f, -4.34485115e-02f, -1.05359787e-02f, 5.90272509e-02f, 7.53985867e-02f, 5.27835044e-04f, -1.92161184e-02f, -6.54265191e-03f, 4.89611328e-02f, 6.58516437e-02f,
  6.72835261e-02f, -3.45581211e-02f, -1.23492695e-01f, 4.62903567e-02f, 2.51583606e-02f, -1.00426786e-01f, -1.27634972e-01f, 3.70861217e-02f, -1.35338098e-01f, -2.73902595e-01f,
  1.28123656e-01f, 3.99885625e-01f, 1.12325810e-01f, 4.80129905e-02f, 6.55047596e-02f, -8.10000226e-02f, -1.22835614e-01f, -8.34122673e-02f, 6.59284741e-02f, 1.90959573e-01f,
  4.68532592e-02f, -8.88211280e-02f, -8.07945877e-02f, -5.99185564e-02f, -1.35983303e-01f, 7.01410621e-02f, 3.55220065e-02f, -7.53503933e-04f, -4.19268072e-01f, -2.64712304e-01f,
  5.60034299e-04f, 1.39095798e-01f, 2.70356275e-02f, -8.29801336e-03f, 2.26762757e-01f, -6.93733543e-02f, 2.47215629e-01f, 2.66105473e-01f, 3.47134620e-02f, 4.47894126e-01f,
  -1.77361915e-04f, 7.16982335e-02f, -2.30476484e-01f, -3.70506495e-02f, 2.47724485e-02f, -7.89372425e-04f, -2.13867519e-02f, 3.91303189e-02f, -2.86100712e-02f, 3.03634722e-02f,
  1.07572921e-01f, 8.94162953e-02f, 6.00792021e-02f, 7.13738725e-02f, 1.53837698e-02f, 8.94417167e-02f, -8.73571727e-03f, 2.94203516e-02f, -4.11773399e-02f, 2.51671299e-02f,
  1.42200708e-01f, -3.63889337e-03f, -9.26301181e-02f, -3.72116491e-02f, -4.58522961e-02f, -8.58085528e-02f, 1.25038952e-01f, 9.92622972e-02f, -1.10731639e-01f, 5.76930568e-02f,
  -1.82064828e-02f, 5.02191558e-02f, -2.37321705e-02f, 1.25133440e-01f, -3.56720462e-02f, -4.79483008e-02f, -6.78691082e-03f, -7.61470348e-02f, -4.29667048e-02f, 5.27983829e-02f,
  -7.93524273e-03f, 2.67551746e-02f, -7.96568096e-02f, 1.58938598e-02f, 3.95637006e-02f, 9.44451317e-02f, 5.09880297e-02f, -1.86117217e-02f, -6.67205825e-02f, 6.87820837e-02f,
  -8.63349512e-02f, -1.48539329e-02f, 7.04698861e-02f, -5.45059480e-02f, 2.51944046e-02f, -8.69808942e-02f, 1.46142334e-01f, -1.11972457e-02f, 3.62848006e-02f, -6.01108484e-02f,
  9.19661224e-02f, -1.71346232e-01f, 2.67595295e-02f, -4.64819893e-02f, -2.34776884e-02f, -3.15284654e-02f, 3.58513519e-02f, -9.78184342e-02f, 3.90914828e-02f, 3.39812934e-02f,
  -1.01245288e-02f, -8.29941183e-02f, 8.18314555e-04f, -4.02040742e-02f, -7.13694692e-02f, -5.93205206e-02f, -8.03158805e-02f, -6.80406541e-02f, -1.97834134e-01f, -1.79412756e-02f,
  9.35683995e-02f, -1.04509212e-01f, -1.78410709e-01f, -1.26276642e-01f, 1.39290961e-02f, -2.22465098e-01f, -3.49038839e-02f, -6.46022931e-02f, -1.17002256e-01f, -5.48648974e-03f,
  -9.33804885e-02f, -1.22869246e-01f, -1.34146154e-01f, -1.88213080e-01f, -8.21278170e-02f, -1.04253806e-01f, 4.28244732e-02f, -4.28322777e-02f, -2.78950445e-02f, -1.85940806e-02f,
  -3.61110866e-02f, -1.34864254e-02f, 1.46131674e-02f, 8.69267806e-02f, 5.20341694e-02f, 5.23701198e-02f, 2.72668973e-02f, 5.82225397e-02f, -1.80429257e-02f, -1.92050889e-01f,
  -7.40373805e-02f, -1.32080823e-01f, -1.72803089e-01f, 1.60239115e-01f, -5.83152808e-02f, 1.79808047e-02f, -3.51685248e-02f, -2.09783375e-01f, 9.37030930e-03f, -1.08952284e-01f,
  5.95743656e-02f, -9.24215987e-02f, 8.56798962e-02f, 2.03777421e-02f, 9.25213769e-02f, 3.74406688e-02f, -2.24687438e-02f, 4.54516746e-02f, 1.04120821e-01f, -1.26773641e-01f,
  1.68904290e-02f, 7.98684061e-02f, 1.12498328e-01f, -4.78344820e-02f, -5.19512370e-02f, -8.93721543e-03f, 9.37343836e-02f, -4.31925096e-02f, 5.51434606e-03f, -3.45641188e-02f,
  6.44959137e-02f, -5.85531779e-02f, 1.39455169e-01f, 1.76131614e-02f, 1.25530856e-02f, 1.55993491e-01f, 1.11352280e-01f, 6.19602799e-02f, 8.46485645e-02f, 6.68057054e-02f,
  6.62085116e-02f, -4.91383113e-02f, 5.48181944e-02f, -7.74315419e-03f, -8.81325230e-02f, 5.41154221e-02f, 9.96267125e-02f, -8.14828032e-04f, 1.05015468e-03f, 4.45696339e-02f,
  5.01580797e-02f, -1.60112306e-02f, -5.91556095e-02f, -1.16457038e-01f, 2.41638198e-02f, 1.06620222e-01f, -2.10148133e-02f, -2.47945432e-02f, -6.13095090e-02f, -5.06438352e-02f,
  -2.17355061e-02f, -3.88871506e-02f, -2.63311155e-02f, -7.73684122e-03f, -1.06710359e-01f, -1.84177697e-01f, -8.28526914e-03f, -5.08349128e-02f, 4.27166224e-02f, -4.55804616e-02f,
  1.00361295e-01f, 1.03253037e-01f, 6.20838404e-02f, 2.56115705e-01f, 3.83057371e-02f, 1.94380105e-01f, 1.49524465e-01f, 1.24451250e-01f, -1.31576005e-02f, -6.34130836e-02f,
  3.02239582e-02f, 8.74021351e-02f, 1.46874204e-01f, -1.35363452e-02f, 1.17423706e-01f, 3.88104618e-02f, 1.45473599e-01f, 1.49193779e-01f, 6.41157478e-02f, 1.18161097e-01f,
  2.39433944e-01f, 7.26593211e-02f, 1.61757603e-01f, 1.42767131e-01f, 1.39857382e-01f, 1.36809126e-01f, 2.50009179e-01f, 1.49156928e-01f, 2.61701494e-01f, 2.30948016e-01f,
  -3.95857878e-02f, -3.71954024e-01f, -2.54782103e-02f, -2.68635243e-01f, -1.38894603e-01f, 3.56166288e-02f, -4.74033728e-02f, 2.54733637e-02f, -7.68369203e-03f, -1.32546917e-01f,
  -1.56392623e-02f, -9.24654528e-02f, -7.09883794e-02f, -7.30814487e-02f, 6.34760782e-02f, -1.04753532e-01f, -7.05648288e-02f, 1.07662939e-01f, 3.26606780e-01f, 1.33751720e-01f,
  -8.61738697e-02f, -4.80261669e-02f, 1.28028631e-01f, 1.40443146e-01f, -3.36742818e-01f, -1.20415166e-02f, -9.31092352e-02f, -5.26795313e-02f, 2.08742004e-02f, -4.81019795e-01f,
  -1.82976890e-02f, -2.11127862e-01f, 7.39089251e-02f, -1.70823887e-01f, -5.60552143e-02f, -1.28485128e-01f, -8.23512301e-02f, -1.28887549e-01f, -1.02266505e-01f, -7.59795681e-02f,
  -8.50222483e-02f, -4.76779267e-02f, -1.43555537e-01f, -9.47368070e-02f, 1.68686360e-02f, -6.61683828e-03f, -5.33538349e-02f, 6.12873435e-02f, -2.28641322e-03f, -1.41477287e-01f,
  -1.52578607e-01f, -1.82420276e-02f, 7.79457167e-02f, -1.79075897e-02f, -2.66502053e-02f, -2.33298098e-03f, -5.51480763e-02f, -1.05476983e-01f, 5.08303978e-02f, -2.37331465e-01f,
  -7.56605938e-02f, -3.48295793e-02f, -2.49453392e-02f, -2.61222962e-02f, 5.56668043e-02f, 2.89770160e-02f, -5.33208959e-02f, 5.58684394e-02f, 1.39833555e-01f, 1.15911879e-01f,
  -7.74888173e-02f, 5.77171855e-02f, 1.59160167e-01f, 5.22456802e-02f, 1.59099162e-01f, 1.57805327e-02f, -1.42980861e-02f, 1.86511055e-02f, 1.69959664e-01f, 1.75311908e-01f,
  1.97147354e-02f, 5.54605722e-02f, 1.13683730e-01f, 1.56191159e-02f, 1.39214341e-02f, 5.88537604e-02f, -1.69774536e-02f, 4.36481647e-02f, 2.46882662e-02f, 1.38233289e-01f,
  -5.75602688e-02f, 7.69332573e-02f, -1.80068552e-01f, -8.25428776e-03f, -6.19663261e-02f, -6.05746098e-02f, -8.03444013e-02f, -5.64041547e-02f, -1.28416002e-01f, -1.27662316e-01f,
  -7.84175396e-02f, -1.42564639e-01f, -1.13400608e-01f, 5.87261915e-02f, -5.97779863e-02f, 2.22101398e-02f, 1.55378887e-02f, -2.74649020e-02f, -1.40394634e-02f, -4.83560599e-02f,
  -8.81553516e-02f, 1.63866460e-01f, 4.59652692e-02f, 5.21241548e-03f, 8.89836103e-02f, 8.44506919e-02f, 1.07070975e-01f, 1.72222462e-02f, 2.60000199e-01f, 3.86336669e-02f,
  -2.11471617e-01f, 2.18208246e-02f, 7.39943609e-02f, -4.90664542e-02f, -1.72549605e-01f, -1.58344537e-01f, -3.92492056e-01f, -2.00788304e-01f, 1.17474079e-01f, -1.04394354e-01f,
  1.43136412e-01f, 3.86340827e-01f, 1.98271409e-01f, 1.86418205e-01f, -8.46599638e-02f, -8.65896270e-02f, -1.57526910e-01f, 1.16168842e-01f, 7.45300502e-02f, -2.79971752e-02f,
  1.07397072e-01f, 4.65887636e-02f, 2.51944233e-02f, 2.02300940e-02f, -1.02362245e-01f, 7.58799314e-02f, 8.80860612e-02f, -4.64795940e-02f, 9.34176147e-02f, -8.61510914e-03f,
  4.30496156e-01f, -1.40174359e-01f, 9.34401825e-02f, 5.09449877e-02f, 6.10719845e-02f, 1.29337737e-03f, -2.79740850e-03f, 4.64549325e-02f, 3.22861858e-02f, 6.88552763e-03f,
  -1.26605555e-02f, 4.95301280e-03f, 1.71658680e-01f, 1.27039164e-01f, 6.59183562e-02f, 5.40467501e-02f, 2.06752634e-03f, 4.81120013e-02f, 7.09989434e-03f, 7.98553526e-02f,
  1.65396571e-01f, 8.25652555e-02f, -8.40588585e-02f, -5.76099381e-02f, -3.45938951e-02f, 7.52250180e-02f, 8.82384256e-02f, 6.80462793e-02f, 5.16498536e-02f, 8.83921459e-02f,
  -8.98375437e-02f, 5.54864779e-02f, 1.20583344e-02f, 1.98584981e-02f, -7.90670589e-02f, -1.64901838e-02f, -3.13938074e-02f, 3.35840471e-02f, -1.21445805e-02f, -2.24184729e-02f,
  2.73656454e-02f, -1.54434741e-01f, 1.27030745e-01f, -9.85243395e-02f, -4.68793325e-02f, -5.39266169e-02f, -1.26065567e-01f, -4.45612110e-02f, -1.86830182e-02f, 3.91208678e-02f,
  -3.78625914e-02f, -9.88452416e-03f, -5.26911095e-02f, 1.12742051e-01f, 1.26553690e-02f, -4.36628722e-02f, 9.29331779e-03f, -5.33456095e-02f, -4.06017946e-03f, -1.03214331e-01f,
  3.55014026e-01f, 8.54036361e-02f, 1.49089647e-02f, 6.57559261e-02f, -4.34949109e-03f, 6.49520084e-02f, 2.69593298e-03f, -4.13027816e-02f, 2.09185965e-02f, 3.18398587e-02f,
  1.28473207e-01f, -1.60677470e-02f, 1.51869971e-02f, -4.71026488e-02f, -2.18768362e-02f, -6.60745725e-02f, -2.15609907e-03f, -7.60965561e-03f, 5.77626415e-02f, -4.54824045e-03f,
  6.71504438e-02f, -2.91001052e-02f, 1.66995712e-02f, -5.38766235e-02f, 5.24511859e-02f, 7.69574335e-03f, 1.63233846e-01f, -2.39925683e-02f, 3.05704474e-02f, -7.04395920e-02f,
  1.79193303e-01f, -2.22451553e-01f, -3.16546410e-01f, 9.30922925e-02f, -2.16340274e-02f, 9.66090709e-02f, 2.84233913e-02f, -3.80740985e-02f, 3.41121815e-02f, -1.65325642e-01f,
  2.50719786e-02f, 2.08285943e-01f, 5.20407632e-02f, 6.58456087e-02f, 2.16144230e-02f, -1.23205014e-01f, -2.19922379e-01f, -4.50243205e-02f, 7.13674575e-02f, -2.25187596e-02f,
  1.75737217e-02f, -1.00113027e-01f, -9.61421952e-02f, -8.57377499e-02f, -1.39406294e-01f, 1.80019692e-01f, -1.18302383e-01f, -1.56452462e-01f, -3.73857241e-04f, -1.70256123e-01f,
  -2.78193299e-02f, -2.32633680e-01f, -7.36480951e-02f, -7.78149590e-02f, -7.04384670e-02f, -9.40135047e-02f, 4.54388233e-03f, -7.56652132e-02f, -8.10671076e-02f, -9.13971961e-02f,
  -1.93828493e-02f, 5.00259735e-02f, 2.55184360e-02f, -1.50545565e-02f, -1.12703905e-01f, 3.80022861e-02f, -1.45025358e-01f, -2.11708918e-01f, -1.74043402e-01f, -1.09025657e-01f,
  -5.30316941e-02f, -1.02242358e-01f, -1.63613111e-01f, -7.13963807e-02f, -1.61913380e-01f, 3.56944837e-02f, -8.26895684e-02f, -1.24719642e-01f, -1.53548762e-01f, -1.80327490e-01f,
  -5.03476225e-02f, -9.73993018e-02f, 5.13563454e-02f, -9.37687419e-03f, 2.20267642e-02f, 2.13181954e-02f, 1.20299377e-01f, 1.20618992e-01f, 1.04565717e-01f, -2.50548720e-02f,
  4.34346460e-02f, -1.43405005e-01f, -1.23493758e-03f, 7.29829893e-02f, 5.87944388e-02f, 7.50791165e-04f, 6.59208000e-02f, 6.75116628e-02f, -2.75445469e-02f, 1.42682284e-01f,
  6.60946891e-02f, 6.52481019e-02f, 1.45219222e-01f, -1.27264939e-03f, 7.50881955e-02f, 8.48453771e-03f, -8.98627471e-03f, 9.40754861e-02f, 7.28779063e-02f, 7.23817423e-02f,
  1.73529267e-01f, -1.93238258e-02f, -5.10751121e-02f, -2.11504921e-02f, 1.49344513e-02f, 6.48586825e-03f, -1.16252407e-01f, -7.29370713e-02f, 4.36382331e-02f, -9.31069106e-02f,
  7.80577809e-02f, -1.80851538e-02f, -1.40525550e-02f, -2.57944949e-02f, -2.97073089e-03f, -1.66254863e-02f, -7.71312267e-02f, 5.45709692e-02f, -9.05856341e-02f, -2.95653977e-02f,
  1.45039279e-02f, 3.26697230e-02f, 6.36502057e-02f, 2.54598204e-02f, 3.64583582e-02f, 1.71755418e-01f, 3.68041210e-02f, 6.41070455e-02f, 4.27153185e-02f, 7.11448025e-03f,
  1.44057110e-01f, 1.23372592e-01f, -8.87559950e-02f, 9.19921044e-03f, -1.15016431e-01f, 2.05695722e-02f, -1.49706192e-02f, -2.78524142e-02f, 8.77393857e-02f, 2.16803867e-02f,
  1.71918079e-01f, 2.82958150e-01f, 2.42437914e-01f, 2.52066642e-01f, 1.70300677e-01f, -8.21665600e-02f, -3.50651108e-02f, 8.08203295e-02f, 8.27723816e-02f, -1.09785825e-01f,
  -1.80534145e-03f, 1.85174391e-01f, 2.08653286e-01f, 1.93168923e-01f, 1.15875630e-02f, 4.63560969e-02f, -1.18218223e-02f, -1.02410205e-02f, 1.45747988e-02f, 2.41091084e-02f,
  4.89677712e-02f, 8.73447284e-02f, 1.50072783e-01f, 2.63111353e-01f, 2.33714834e-01f, 2.75584906e-01f, 1.88084900e-01f, 1.27573892e-01f, 7.01011941e-02f, 2.34739274e-01f,
  1.68218315e-01f, 2.61748910e-01f, 2.18694016e-01f, 1.72957480e-01f, 6.56526387e-02f, 2.13088766e-01f, 1.55720413e-01f, 1.33420482e-01f, 1.58969805e-01f, 1.19230025e-01f,
  1.43510431e-01f, 2.03991786e-01f, 6.37193769e-02f, 5.66528216e-02f, 1.58987805e-01f, 1.84001893e-01f, 3.34249213e-02f, 1.52120069e-02f, 1.85903803e-01f, 6.15678020e-02f,
  7.43402690e-02f, -9.00196433e-02f, -1.39569435e-02f, 3.40125686e-03f, 7.46401446e-03f, 3.23047191e-02f, 3.70778479e-02f, -4.06086147e-02f, -4.51763608e-02f, 7.28387479e-03f,
  1.08913884e-01f, -5.12645282e-02f, 1.39980510e-01f, 4.58777137e-02f, -1.38835862e-01f, -5.13158320e-03f, 3.63846049e-02f, -1.32521261e-02f, 7.76685625e-02f, 1.01987958e-01f,
  -2.65560608e-04f, -5.69894314e-02f, 4.32862043e-02f, 1.94524303e-02f, 4.55933511e-02f, 3.21054719e-02f, -4.61724512e-02f, 4.68663983e-02f, -3.36481668e-02f, 7.99893439e-02f,
  3.45561467e-02f, 2.69172132e-01f, 5.24491817e-02f, 6.97053224e-02f, 1.15213752e-01f, 1.11286126e-01f, 6.43671080e-02f, 4.14290540e-02f, 9.21691880e-02f, 4.58767749e-02f,
  7.32119605e-02f, 1.18239030e-01f, 1.17739126e-01f, 8.86288211e-02f, 1.06689431e-01f, 1.62851617e-01f, 1.23233952e-01f, 3.96872088e-02f, 4.16142941e-02f, 2.98043285e-02f,
  1.88109294e-01f, 6.79864138e-02f, 8.72418582e-02f, 8.47703740e-02f, 5.88492528e-02f, 3.95876095e-02f, 1.19987734e-01f, -6.11835159e-03f, 2.40539208e-01f, 5.37884049e-02f,
  3.58219922e-01f, 1.44558832e-01f, -4.10459563e-02f, 5.25052771e-02f, -2.46767566e-01f, -1.91678628e-01f, -1.42725378e-01f, 1.78706385e-02f, -7.75798112e-02f, -4.20053303e-02f,
  -1.58474252e-01f, -1.03107758e-01f, -1.10907473e-01f, 8.53445828e-02f, 1.73315093e-01f, -1.35120332e-01f, -9.67501476e-03f, 1.36801466e-01f, -1.32251009e-01f, -2.38410160e-01f,
  -2.83549815e-01f, -6.55995235e-02f, 1.45964533e-01f, -2.49061026e-02f, -2.68081725e-01f, -2.84736484e-01f, -2.17171609e-01f, -1.77901670e-01f, -2.05889642e-01f, -2.47768208e-01f,
  -1.38796911e-01f, 2.62367934e-01f, -3.67024578e-02f, -2.17076745e-02f, -2.66831040e-01f, -9.17700753e-02f, -3.58517505e-02f, -2.08516214e-02f, -7.62209967e-02f, 5.04754670e-02f,
  -1.34919569e-01f, -2.20072567e-02f, 5.17239980e-02f, -6.95749745e-02f, 1.28822532e-02f, 3.46168652e-02f, -1.62481256e-02f, 1.71136633e-01f, 5.31462580e-02f, -1.10856090e-02f,
  -7.81673342e-02f, -3.01354118e-02f, 4.87139896e-02f, 1.50245940e-02f, 6.71112537e-02f, -8.68393183e-02f, -1.66530553e-02f, -4.73728869e-03f, 2.81647667e-02f, 1.68531481e-03f,
  -1.88645869e-02f, 2.91344174e-03f, -4.69208183e-03f, 3.11963297e-02f, -3.23248543e-02f, -1.99253578e-02f, 3.70271392e-02f, 8.68344307e-02f, 2.65209191e-03f, 4.19081114e-02f,
  2.84481561e-03f, -9.22732875e-02f, 2.46457234e-02f, 4.13703993e-02f, 5.06984396e-03f, -6.89385757e-02f, -9.47412252e-02f, -1.07759781e-01f, 8.72124657e-02f, -5.36906859e-03f,
  -7.85809681e-02f, -5.64696938e-02f, -3.39165963e-02f, -1.30342180e-02f, 4.02141958e-02f, -2.26574019e-02f, -3.17591913e-02f, -8.87155533e-02f, -3.56725678e-02f, -3.09834071e-02f,
  -2.14559853e-01f, -1.09511971e-01f, -7.48906657e-02f, -3.11202202e-02f, -8.09848830e-02f, -4.04064655e-02f, -1.09903561e-02f, 1.78794173e-04f, -9.93854366e-03f, 2.85700317e-02f,
  -8.75760540e-02f, -5.83623499e-02f, -1.18334524e-01f, -5.28312288e-04f, 1.27614280e-02f, 5.88726904e-03f, -2.35982746e-01f, -8.12823474e-02f, -9.17067379e-02f, -6.01964407e-02f,
  -6.85736611e-02f, -3.63668762e-02f, -5.66423386e-02f, -1.31762445e-01f, 4.01414093e-03f, -1.94984898e-01f, -1.78431794e-01f, -1.17239237e-01f, -1.65608928e-01f, -1.84398219e-01f,
  2.01987669e-01f, 1.30496502e-01f, 8.34766179e-02f, 2.20349967e-01f, 2.04034865e-01f, 1.76279157e-01f, 1.64176732e-01f, 9.29693505e-02f, -4.06785682e-02f, 1.33630559e-01f,
  -2.63033081e-02f, -2.94880420e-01f, -2.76063114e-01f, -8.73731673e-02f, -1.33973122e-01f, -8.12475197e-03f, 1.37934446e-01f, 4.84989733e-02f, -3.09496075e-02f, 1.38316780e-01f,
  4.47711349e-02f, 6.07533045e-02f, 4.37183753e-02f, -9.09509510e-02f, 8.50194246e-02f, -9.22079980e-02f, -8.13701451e-02f, 2.37046997e-03f, -9.31560099e-02f, 2.38307431e-01f,
  -3.41255814e-02f, 2.03206867e-01f, -1.22486196e-01f, -1.06790848e-01f, -1.09992847e-01f, -1.05513558e-01f, 2.54584234e-02f, -7.49211833e-02f, -5.78937121e-02f, 7.02899843e-02f,
  -2.19554752e-02f, -1.62457377e-01f, -1.62242830e-01f, -4.49221060e-02f, 3.09094805e-02f, -3.44637558e-02f, -7.86819146e-04f, -7.46904016e-02f, -5.87460510e-02f, -5.91997057e-02f,
  4.06638756e-02f, 1.52997673e-01f, 6.99808672e-02f, -3.75353396e-02f, -4.30467017e-02f, 5.10950796e-02f, 5.13393320e-02f, 9.43448022e-02f, 3.58006619e-02f, 1.36720866e-01f,
  1.15786359e-01f, 1.03795670e-01f, -2.37271544e-02f, 4.74016219e-02f, 8.08146782e-03f, 3.36185172e-02f, 1.00698449e-01f, 1.82470288e-02f, 1.88380573e-02f, 2.33381595e-02f,
  1.17109992e-01f, 1.82064772e-01f, 3.01479325e-02f, 5.90659976e-02f, 6.50015920e-02f, -4.82823402e-02f, -3.41022722e-02f, 3.75995897e-02f, -4.29040566e-02f, 4.75646481e-02f,
  -1.26164500e-02f, -1.58520602e-02f, 5.30068390e-02f, -1.32207543e-01f, 1.19562805e-01f, 6.41699210e-02f, 5.75644299e-02f, 5.32649979e-02f, 6.73899651e-02f, 1.25110626e-01f,
  -1.26533285e-01f, -1.70979172e-01f, -2.45529152e-02f, -7.49019608e-02f, -4.05188538e-02f, -1.71193376e-01f, -9.77829173e-02f, -1.95835847e-02f, -1.00273505e-01f, -1.11544318e-01f,
  -4.68678847e-02f, 5.37603684e-02f, -3.22808698e-02f, -1.02246664e-01f, 6.81990944e-03f, -4.31822054e-02f, -1.06471375e-01f, -7.09388033e-02f, -1.37593895e-01f, -7.50121335e-03f,
  7.80915003e-03f, 4.09689033e-03f, 6.51836544e-02f, -8.48715529e-02f, 4.48399149e-02f, 1.74696296e-02f, -1.16300717e-01f, -1.02534546e-02f, -1.43104777e-01f, -1.47236153e-01f,
  1.47969395e-01f, -1.49688676e-01f, -3.38783950e-01f, -1.79960683e-01f, -1.71675786e-01f, -2.06281871e-01f, -3.76533717e-01f, -1.76433772e-01f, -2.91380957e-02f, -1.40847251e-01f,
  8.72138068e-02f, 1.44058377e-01f, 1.23053029e-01f, -5.14655560e-02f, -1.27142400e-01f, -2.52121031e-01f, -3.01177949e-01f, -1.10835157e-01f, 8.07451904e-02f, -5.77600077e-02f,
  -8.87513012e-02f, 5.27399071e-02f, 9.46608335e-02f, 4.79427688e-02f, -1.27119392e-01f, 2.08808575e-02f, -1.56343907e-01f, 3.87419052e-02f, 6.00019172e-02f, -1.00576371e-01f,
  -6.02094419e-02f, -5.05388416e-02f, -2.28316225e-02f, 7.88874701e-02f, -9.24656391e-02f, -8.44960138e-02f, -6.33744448e-02f, -1.15890242e-02f, 2.91191135e-02f, -3.94892395e-02f,
  1.32373180e-02f, 2.18222551e-02f, -3.67188379e-02f, 8.91398862e-02f, 3.01392953e-04f, -2.67235059e-02f, 3.29510756e-02f, -1.01798944e-01f, -1.21860899e-01f, -3.79380956e-03f,
  -7.75294006e-02f, 1.59466401e-01f, -6.27304912e-02f, -1.83337390e-01f, -2.39717215e-01f, -5.64571880e-02f, -9.57785398e-02f, -5.29425479e-02f, -4.91122529e-02f, -6.89389408e-02f,
  -1.00528657e-01f, 7.13428557e-02f, 6.97478577e-02f, -5.92466630e-02f, 5.01354858e-02f, 4.97956723e-02f, -3.95531133e-02f, 5.29116578e-02f, 2.56661717e-02f, 3.44164185e-02f,
  8.00218359e-02f, -7.07971677e-02f, 1.40715120e-02f, -1.07992612e-01f, -3.04965042e-02f, 8.60608667e-02f, -1.54875144e-02f, 2.76454482e-02f, 8.77160728e-02f, 1.24204919e-01f,
  -2.33696979e-02f, 3.44819315e-02f, -1.43838283e-02f, -2.67083850e-02f, -3.54850926e-02f, -8.93625095e-02f, -1.00620940e-01f, 2.14733966e-02f, 5.74264629e-03f, 2.28336882e-02f,
  -9.73211303e-02f, -3.91675346e-02f, -3.99455167e-02f, -1.41203552e-01f, -2.46141199e-02f, 4.21046764e-02f, 1.43975755e-02f, 8.11010692e-03f, -6.06270507e-02f, -5.15641309e-02f,
  1.94195788e-02f, -8.51996243e-03f, -2.19112467e-02f, -8.17399025e-02f, 5.93048818e-02f, 2.53116917e-02f, -9.07689054e-03f, -3.64599526e-02f, 3.48127484e-02f, 7.25107044e-02f,
  -1.02625653e-01f, 1.04791045e-01f, 9.32277180e-03f, 5.68498718e-03f, 1.13639776e-02f, -1.02622760e-02f, 6.15541311e-03f, -3.00978441e-02f, 1.08884163e-02f, -6.05928861e-02f,
  6.71040058e-01f, -1.64610445e-01f, -6.36407733e-02f, 1.18443385e-01f, -3.26021105e-01f, -8.48081335e-02f, -2.05237269e-01f, 1.62167430e-01f, -1.77446324e-02f, -1.52962178e-01f,
  -2.09862456e-01f, -1.26160309e-02f, -5.10066971e-02f, -8.81641954e-02f, 7.60771930e-02f, -2.14964509e-01f, -1.88817903e-01f, 1.51303798e-01f, 2.55355477e-01f, 3.73428427e-02f,
  -1.60263613e-01f, 1.69715285e-01f, 3.45395595e-01f, 1.97711170e-01f, -2.09498197e-01f, -4.74600866e-02f, -1.41627401e-01f, -1.42290384e-01f, -1.75154954e-01f, -4.16130781e-01f,
  2.03274339e-02f, 8.53466541e-02f, -1.04013026e-01f, -7.24504441e-02f, -1.64010003e-01f, 7.84476846e-02f, -3.68623175e-02f, -4.37862724e-02f, 2.34740297e-03f, -3.26355956e-02f,
  -1.59238815e-01f, -3.41565907e-02f, -8.13309103e-02f, -1.15345970e-01f, 1.00626014e-01f, 3.59680541e-02f, 6.25885278e-02f, 1.89389154e-01f, 1.30459130e-01f, -8.32433328e-02f,
  -2.75791168e-01f, -1.92201450e-01f, 3.12716439e-02f, -1.71499699e-02f, -1.04261730e-02f, -1.43033832e-01f, -7.64728710e-02f, 1.04199750e-02f, 4.20534983e-02f, 1.51292020e-02f,
  5.08373082e-02f, -9.85532461e-05f, -3.10042705e-02f, 1.05486587e-01f, 2.05397755e-02f, -3.04357838e-02f, -2.40236912e-02f, 6.23640604e-02f, 2.34355778e-02f, 1.15821816e-01f,
  -7.75008323e-03f, 2.68859789e-02f, 1.10627562e-01f, 7.63392225e-02f, -5.85313439e-02f, 4.12634090e-02f, -4.28866446e-02f, -6.82502910e-02f, 3.97696532e-02f, 8.82655606e-02f,
  6.28286824e-02f, 3.18755209e-02f, -2.11423775e-03f, 1.49442464e-01f, -4.85491157e-02f, 6.81606382e-02f, -7.28361905e-02f, 4.15466093e-02f, 2.88498960e-02f, 2.25794837e-02f,
  6.81736991e-02f, -1.53917477e-01f, 7.23493518e-03f, -9.73639041e-02f, -8.68967250e-02f, -2.84469873e-02f, -4.70334142e-02f, -1.06279850e-01f, -9.63921770e-02f, -4.31229509e-02f,
  -9.74691734e-02f, 7.59429261e-02f, -3.65626886e-02f, -3.78899798e-02f, 3.78411263e-02f, -7.26179704e-02f, -1.11088790e-01f, -4.40992303e-02f, -8.90033916e-02f, -1.88748892e-02f,
  -1.10340305e-01f, 1.74270216e-02f, 9.79406461e-02f, -3.53109166e-02f, -6.97212741e-02f, -8.86625201e-02f, -6.30752370e-02f, -1.23120127e-02f, 2.12972444e-02f, 5.03699034e-02f,
  -1.14145018e-01f, 9.47311986e-03f, -3.05533916e-01f, -5.45575507e-02f, -2.80176066e-02f, -2.10876390e-01f, -2.39981771e-01f, -1.29970536e-01f, 6.48446977e-02f, -6.09893017e-02f,
  -2.17057601e-01f, -9.90586448e-03f, -9.85811427e-02f, 8.55183676e-02f, -6.35588169e-02f, -7.09903762e-02f, 1.86579078e-01f, 2.43658498e-02f, -8.98583308e-02f, 1.50216864e-02f,
  4.47776876e-02f, -1.66849382e-02f, -7.20189810e-02f, 3.41087058e-02f, 2.21525222e-01f, -5.52699342e-02f, -1.02507263e-01f, 1.14334226e-01f, 1.39793187e-01f, 4.59292501e-01f,
  2.22340263e-02f, 5.27082570e-03f, 1.12675345e-02f, -2.97188926e-02f, -3.85354795e-02f, -2.80107204e-02f, -1.37564763e-01f, -6.80416748e-02f, -1.05033452e-02f, -7.18753561e-02f,
  -1.27944350e-01f, -4.84769978e-02f, -1.05839416e-01f, -1.98679790e-02f, -7.11631477e-02f, -2.17241254e-02f, -1.26716436e-03f, 5.04892692e-02f, -1.33088976e-01f, -4.12335619e-02f,
  5.03118560e-02f, -1.20675124e-01f, -2.29691103e-01f, -1.23754106e-01f, -1.36125252e-01f, -1.81218654e-01f, -1.53631195e-01f, -1.31929174e-01f, -2.02543259e-01f, -4.36906181e-02f,
  1.27926886e-01f, -1.77091718e-01f, -3.74858789e-02f, 1.29779845e-01f, 4.97588664e-02f, -1.01914011e-01f, 1.60789266e-01f, 1.27814412e-01f, -3.91706824e-02f, 1.77581906e-02f,
  -6.66827336e-02f, -8.33561495e-02f, 5.93640432e-02f, 1.01273634e-01f, -2.25597305e-05f, -9.75457057e-02f, -8.40798095e-02f, -1.10637434e-02f, -4.34871353e-02f, -7.84808695e-02f,
  7.77476802e-02f, 5.96456323e-03f, -6.25502691e-02f, -1.19912205e-03f, 2.31898506e-03f, 9.06303339e-03f, -1.13978349e-01f, -5.78209795e-02f, -1.68316424e-01f, -9.61911213e-03f,
  -9.13246498e-02f, -8.73885900e-02f, 1.69658795e-01f, -3.26365195e-02f, -1.04512237e-01f, -1.60814170e-02f, -7.41618359e-03f, 1.83232687e-02f, -3.37282531e-02f, -5.31416535e-02f,
  -1.21813446e-01f, -8.07084963e-02f, -9.53804404e-02f, -1.22474022e-01f, -1.98028281e-01f, -1.33978665e-01f, -1.59261480e-01f, 1.77739020e-02f, -8.72804299e-02f, -1.38191447e-01f,
  -1.53086796e-01f, -2.33087540e-01f, -1.09223530e-01f, -1.41563136e-02f, -1.07457660e-01f, -1.56042039e-01f, -1.18103705e-01f, -9.38322991e-02f, -2.89202720e-01f, -1.02386691e-01f,
  4.13239479e-01f, -1.64596457e-02f, 1.11411199e-01f, -4.78295498e-02f, -1.65033117e-01f, -1.85388140e-02f, -1.08366190e-02f, 1.95708096e-01f, -1.41421840e-01f, -4.74409722e-02f,
  -8.15138519e-02f, -1.27007186e-01f, 1.41054895e-02f, -5.91184795e-02f, 2.21541554e-01f, -1.11012854e-01f, -1.36320665e-01f, 1.03966147e-01f, 1.76687047e-01f, 1.01685897e-01f,
  -1.02230623e-01f, 2.51193065e-02f, 1.42451316e-01f, 4.48164977e-02f, -2.00515240e-01f, -8.72773081e-02f, -1.54747248e-01f, -1.00032683e-03f, -8.99591073e-02f, -3.60448688e-01f,
  -2.32329909e-02f, 3.63074578e-02f, 1.21678233e-01f, -3.68522480e-02f, -1.22331649e-01f, 9.17737111e-02f, -5.79297580e-02f, -2.13566534e-02f, -4.71284427e-02f, -4.04387116e-02f,
  -1.57146007e-01f, -7.82063231e-02f, -1.41100422e-01f, -1.01638652e-01f, -5.16859442e-02f, -1.64167024e-02f, 1.48270056e-02f, 3.45700942e-02f, 1.32143915e-01f, -5.40154539e-02f,
  -1.88917026e-01f, -2.22865656e-01f, 1.16223225e-03f, -5.09234741e-02f, 7.40993991e-02f, 6.27213195e-02f, -1.10357404e-01f, 6.77712187e-02f, 9.03422311e-02f, 8.89517274e-03f,
  -1.10300118e-02f, 5.96916908e-03f, 1.89518463e-02f, -9.30388365e-03f, -8.13437067e-03f, -4.57021296e-02f, -7.31006712e-02f, -1.60626233e-01f, -2.61242148e-02f, -4.39313315e-02f,
  5.10418527e-02f, -1.21065613e-03f, -1.20076938e-02f, 6.48169667e-02f, 2.45393859e-03f, 4.47671078e-02f, -5.93928546e-02f, -5.38845770e-02f, -1.07501009e-02f, 1.59762613e-02f,
  1.46611659e-02f, -5.32146916e-02f, -4.85509522e-02f, -1.69070233e-02f, -5.04320264e-02f, -4.82856482e-02f, -1.27769411e-01f, -4.11853604e-02f, 1.14370376e-01f, -1.16157206e-02f,
  8.80823508e-02f, 1.27278805e-01f, 7.33747706e-02f, 5.56904897e-02f, 4.16865796e-02f, 8.61724541e-02f, -5.22627346e-02f, 8.01685750e-02f, 1.96402962e-03f, 1.04427360e-01f,
  8.44200030e-02f, 1.17785208e-01f, 9.26418528e-02f, 2.00854056e-02f, 1.10746268e-03f, -9.86142978e-02f, 2.31016520e-02f, -7.38729089e-02f, 2.34083179e-02f, 9.24773701e-03f,
  -2.14853790e-02f, 4.69626524e-02f, 1.11897200e-01f, 3.49761844e-02f, 1.70079134e-02f, 1.67835385e-01f, 8.04150850e-02f, 1.25998855e-01f, 1.86171219e-01f, 2.03551307e-01f,
  3.20788585e-02f, -1.33738473e-01f, -5.15017696e-02f, 2.03081191e-01f, 3.29532735e-02f, 9.94916186e-02f, -1.08301140e-01f, 1.36171937e-01f, 2.02749103e-01f, -5.69495596e-02f,
  -2.87184007e-02f, 8.61603245e-02f, 2.95338165e-02f, 3.58407050e-02f, -4.51770164e-02f, -2.15891480e-01f, -2.03846321e-01f, -8.17987770e-02f, 1.56233296e-01f, 3.33412103e-02f,
  -2.77746506e-02f, 7.83570409e-02f, 5.17747402e-02f, 1.05275452e-01f, -6.51467070e-02f, 1.80852767e-02f, -4.67190742e-02f, 1.96322985e-02f, -7.05936626e-02f, -2.25395486e-01f,
  -1.56791672e-01f, 3.81454302e-04f, -5.39370440e-03f, -1.08411536e-01f, -1.71416905e-02f, 2.81319283e-02f, -1.07117712e-01f, -1.12007961e-01f, -1.16721801e-01f, -9.02507305e-02f,
  -1.01096714e-02f, -9.45601314e-02f, -8.63617212e-02f, 3.24672461e-03f, -1.78811327e-02f, 5.19617051e-02f, -8.24948102e-02f, -1.09243579e-01f, -1.34166345e-01f, -1.35700464e-01f,
  -8.44438821e-02f, -3.17425095e-02f, -7.53853619e-02f, 6.84663877e-02f, -8.91311690e-02f, 2.89415549e-02f, 9.84243955e-03f, -7.20921755e-02f, -3.16203646e-02f, -2.54507333e-01f,
  3.37911621e-02f, 4.11384031e-02f, 2.83625592e-02f, -1.05956368e-01f, 5.27296551e-02f, 1.52342413e-02f, 9.05069783e-02f, 6.07615076e-02f, 7.91325197e-02f, -4.34909649e-02f,
  2.64484733e-02f, -2.15902731e-01f, 7.37559572e-02f, 1.76631883e-02f, 1.70047171e-02f, -1.29763782e-01f, -1.87212881e-02f, -1.37464300e-01f, -7.97654036e-03f, -3.10202111e-02f,
  -4.54652533e-02f, 5.04648127e-03f, -7.46074542e-02f, 7.42377415e-02f, -7.41122216e-02f, -1.06133357e-01f, 1.94057003e-02f, -6.39467761e-02f, 2.91116521e-05f, 1.23404656e-02f,
  9.39311013e-02f, 5.64676486e-02f, -1.29992321e-01f, -2.39026882e-02f, -7.89651349e-02f, -2.37515452e-03f, -4.17954884e-02f, 2.29937630e-03f, 1.48974303e-02f, -2.59583686e-02f,
  4.99881469e-02f, -1.32879913e-01f, -4.39090002e-03f, 1.88326556e-02f, -4.70682569e-02f, -9.44091082e-02f, -1.47186697e-01f, -1.00630358e-01f, -6.64888322e-02f, -1.01998210e-01f,
  -2.20399294e-02f, -1.02728583e-01f, -2.91509200e-02f, -6.38232455e-02f, -8.90003070e-02f, -1.59318671e-02f, -3.24573852e-02f, 1.06748911e-02f, -9.85208992e-03f, -6.99199885e-02f,
  -3.59436832e-02f, 1.95340008e-01f, 1.49715275e-01f, 6.58782795e-02f, -5.41243143e-02f, -5.98177314e-02f, -8.76974128e-03f, 2.37900719e-01f, 1.23640947e-01f, 3.09534613e-02f,
  7.62651712e-02f, 2.52674967e-01f, 2.28279665e-01f, 2.62273133e-01f, 1.65726870e-01f, 1.71882525e-01f, 4.06546406e-02f, 8.40376616e-02f, 2.45010838e-01f, 1.95801958e-01f,
  3.23222056e-02f, 2.33091727e-01f, 2.95665234e-01f, 2.99443662e-01f, 1.09332614e-01f, 2.10340157e-01f, 2.42887199e-01f, 2.18514100e-01f, 8.85373875e-02f, 1.68241877e-02f,
  1.12995602e-01f, 7.34970123e-02f, 1.15218043e-01f, 1.36501610e-01f, 1.60201430e-01f, 2.22521916e-01f, 1.63814649e-01f, 2.55419701e-01f, 9.42745432e-02f, 1.17362246e-01f,
  1.27965525e-01f, 1.24972761e-01f, 9.23854858e-02f, 5.83657809e-02f, 1.50159463e-01f, 1.03827752e-01f, 1.27011746e-01f, 1.84950218e-01f, 1.14846960e-01f, 1.84276998e-01f,
  1.50999114e-01f, 7.13387388e-04f, 1.06743887e-01f, 1.77858829e-01f, 1.39252037e-01f, 1.64042842e-02f, 1.16708532e-01f, 1.45652175e-01f, 2.23236144e-01f, 1.92589879e-01f,
  -8.65550041e-02f, -2.18981668e-01f, -2.20561534e-01f, -1.26828983e-01f, -1.97412193e-01f, -1.18238285e-01f, -3.33435863e-01f, -1.19787060e-01f, -2.25425512e-01f, -1.72979042e-01f,
  -6.77883700e-02f, -1.85252681e-01f, -1.87384546e-01f, -7.34058619e-02f, -1.88102603e-01f, -2.79248953e-01f, -2.45837629e-01f, -9.16846469e-03f, -1.78835303e-01f, -1.84448242e-01f,
  -1.90553874e-01f, -1.55365184e-01f, -1.11795835e-01f, -2.07971200e-01f, -2.52491593e-01f, -1.80704996e-01f, -1.25987679e-01f, -2.39929020e-01f, -2.11068720e-01f, -1.21372484e-01f,
  2.14059487e-01f, 2.92764846e-02f, 1.83164969e-01f, 4.84007746e-02f, 9.69787538e-02f, 2.65047252e-01f, -1.63081605e-02f, 2.00762272e-01f, 1.77771263e-02f, 1.99106142e-01f,
  1.35818288e-01f, 1.58907533e-01f, 1.07737139e-01f, 7.46997520e-02f, 6.07943349e-02f, 1.15768448e-01f, 1.04506820e-01f, 8.97358358e-02f, 1.10049881e-01f, -5.08993231e-02f,
  5.74286431e-02f, -1.12161180e-02f, -7.17291459e-02f, -4.74144928e-02f, 1.23652956e-02f, -1.30999191e-02f, 7.35203996e-02f, 4.32247063e-03f, 1.20579913e-01f, 2.50198901e-01f,
  3.05124044e-01f, 1.96905971e-01f, -8.48276690e-02f, -6.15096390e-02f, -7.30380416e-02f, -4.23267819e-02f, 2.77947754e-01f, 7.37763867e-02f, -2.93577444e-02f, 5.11009432e-02f,
  -8.29301327e-02f, -2.91759282e-01f, -2.04350784e-01f, -9.33526829e-02f, 7.37443566e-02f, 9.18185264e-02f, -1.06779942e-02f, 3.04207746e-02f, 3.75416204e-02f, 1.88937843e-01f,
  6.97392896e-02f, 1.42197251e-01f, 1.16122968e-01f, -4.17878479e-02f, 3.97678874e-02f, -2.26820961e-01f, -1.66932702e-01f, -1.23095393e-01f, -1.01567492e-01f, -2.81981118e-02f,
  -1.65055141e-01f, 4.87347469e-02f, -5.29505499e-02f, 8.86399448e-02f, -1.32600546e-01f, -1.89962592e-02f, -8.22593272e-02f, -6.91468045e-02f, -5.93716204e-02f, 1.77712180e-02f,
  -1.01341806e-01f, -4.41289991e-02f, -5.56886345e-02f, -2.66617406e-02f, 4.41011004e-02f, -4.52813553e-03f, 2.57177837e-02f, 1.01000041e-01f, 6.01193793e-02f, 1.31102905e-01f,
  4.02118079e-03f, 4.42717224e-02f, 2.08364017e-02f, 2.09874157e-02f, -8.25121552e-02f, -3.42597370e-03f, -1.23725682e-01f, 1.63353719e-02f, -4.90147285e-02f, -2.53642481e-02f,
  2.59982832e-02f, -3.86253186e-02f, 5.35533056e-02f, 1.44508313e-02f, 4.81254645e-02f, 8.98813270e-03f, 1.94090512e-02f, 2.93756346e-03f, 8.27069804e-02f, 7.41972998e-02f,
  -2.84591597e-02f, -4.57019769e-02f, -6.99654296e-02f, -2.02818923e-02f, 6.22059144e-02f, 1.18403398e-01f, 6.56495977e-04f, 1.53007507e-02f, 3.82783711e-02f, 8.44163150e-02f,
  2.92090382e-02f, 9.17827934e-02f, -1.86052751e-02f, 1.55889094e-02f, -5.01752738e-03f, -6.36143759e-02f, -1.05390094e-01f, 2.11107824e-02f, -1.10935653e-02f, -9.83306672e-03f,
  -9.47114453e-02f, -3.00491989e-01f, -6.78425282e-03f, -5.10632060e-02f, -4.50685211e-02f, -7.59836137e-02f, -8.77749696e-02f, -3.35725285e-02f, -1.13566533e-01f, 1.60186514e-01f,
  2.69596390e-02f, -2.61397026e-02f, 2.73805615e-02f, -6.88628703e-02f, 4.17511575e-02f, 2.36598570e-02f, 5.06042540e-02f, 5.66710606e-02f, -2.33882591e-02f, 3.94720361e-02f,
  1.97267115e-01f, 1.57936141e-01f, 9.98044293e-03f, 1.13030039e-01f, -9.01664123e-02f, -5.05677909e-02f, -1.70195140e-02f, -8.63277987e-02f, -6.33779466e-02f, 1.42579347e-01f,
  1.38296997e-02f, 2.17298791e-01f, 1.31545901e-01f, -1.28927410e-01f, 1.18175924e-01f, 2.33255833e-01f, 2.63213366e-01f, 2.67339088e-02f, -6.22865930e-02f, 1.43404171e-01f,
  -8.53559226e-02f, -3.18692476e-01f, -2.92763680e-01f, -1.99747980e-01f, -1.85106695e-01f, 4.85573895e-02f, -3.46903466e-02f, -2.50562787e-01f, -2.72008143e-02f, 3.36110033e-02f,
  -3.47375050e-02f, -2.79838946e-02f, 1.00787906e-02f, -1.28248259e-01f, -3.02521754e-02f, -7.21642151e-02f, 2.53752526e-02f, 6.79468289e-02f, 5.37995547e-02f, -1.96755931e-01f,
  -1.29198045e-01f, -1.64329987e-02f, -1.90543383e-01f, -2.50519574e-01f, -1.21597439e-01f, -1.36026114e-01f, -1.35793298e-01f, -1.33624867e-01f, -1.70485809e-01f, -2.02842996e-01f,
  -2.83161074e-01f, -2.00577915e-01f, -3.23515296e-01f, -1.23607956e-01f, -1.91978827e-01f, -7.11717755e-02f, -8.02583396e-02f, -1.84570804e-01f, -1.68800727e-01f, -8.20300952e-02f,
  -2.58590996e-01f, -6.04019426e-02f, -1.33618400e-01f, -2.40598004e-02f, -1.45032763e-01f, -2.21123621e-01f, -1.34111494e-01f, -1.52876914e-01f, 2.12343577e-02f, 3.72383073e-02f,
  6.12549558e-02f, 2.58056577e-02f, 1.03369363e-01f, 9.22193453e-02f, 1.69997394e-01f, 2.67097596e-02f, 1.33146986e-01f, 9.76902246e-02f, 1.25526488e-02f, 8.31474289e-02f,
  2.51340400e-02f, 1.13995142e-01f, 6.85296655e-02f, 5.38083687e-02f, 7.44229034e-02f, 5.56279831e-02f, 7.45498240e-02f, 4.76901233e-02f, 8.35504755e-03f, 1.49029762e-01f,
  1.63439035e-01f, 1.04267471e-01f, 1.11504637e-01f, 1.11156948e-01f, 8.28696936e-02f, 7.18995258e-02f, 1.89120412e-01f, 1.56252846e-01f, 6.40752912e-02f, 1.55622333e-01f,
  -1.48408845e-01f, -2.90520400e-01f, -8.96169022e-02f, -1.15236446e-01f, -1.70685872e-01f, -7.54960626e-02f, -8.31999406e-02f, -6.66455254e-02f, -1.50364473e-01f, -1.71078071e-01f,
  -1.49161860e-01f, -1.14664473e-01f, -1.81855202e-01f, -1.52243704e-01f, -1.46468863e-01f, 1.85412802e-02f, -7.51091912e-02f, -9.76995081e-02f, -2.81511620e-02f, 6.59495825e-03f,
  -1.71001241e-01f, -1.03153743e-01f, -4.87162508e-02f, 3.95190753e-02f, -7.72297233e-02f, -7.83766806e-02f, -1.22205883e-01f, 4.78477869e-03f, -5.81649505e-02f, 1.44015878e-01f,
  -1.18466906e-01f, -1.55564994e-01f, -1.27056226e-01f, 6.31356910e-02f, -4.79783192e-02f, 1.74564570e-02f, -2.15466216e-01f, 6.44061789e-02f, 1.06749415e-01f, -2.32352912e-01f,
  -4.98295426e-02f, 3.02471370e-01f, 1.35067850e-01f, 2.25480184e-01f, 1.37682289e-01f, -2.33264998e-01f, -5.31803556e-02f, 1.46113351e-01f, 2.57895708e-01f, 1.58068433e-01f,
  -9.91786923e-03f, 2.17570039e-03f, 1.85497314e-01f, 9.68244672e-02f, -1.14055030e-01f, -5.24956547e-02f, -8.90373737e-02f, -1.19817927e-01f, -1.88295722e-01f, -2.93105572e-01f,
  -1.65214747e-01f, -4.99749333e-02f, 1.83468595e-01f, 1.93192542e-01f, -4.40119132e-02f, 9.01623666e-02f, -3.19700944e-03f, 9.14932266e-02f, 1.10874660e-01f, 1.16894804e-01f,
  1.60731375e-01f, 6.37560040e-02f, 1.87108904e-01f, 1.82653610e-02f, 2.11665407e-03f, -2.28680149e-02f, 2.23061964e-02f, 7.90630132e-02f, 1.17516160e-01f, 1.72799714e-02f,
  6.32659346e-02f, -6.05453213e-04f, -1.25216201e-01f, 1.55915655e-02f, 5.00468127e-02f, 6.31525218e-02f, 4.74256370e-03f, 3.63623984e-02f, 2.00795997e-02f, -2.79671639e-01f,
  -9.14741084e-02f, 4.48129000e-03f, -4.28724587e-02f, -1.28824964e-01f, -6.66526332e-02f, 3.91574390e-02f, 4.71379198e-02f, 1.12511264e-02f, -9.71413031e-03f, -5.33025153e-02f,
  3.80015932e-02f, -2.58877035e-02f, 7.45294318e-02f, 6.85021207e-02f, -3.53238359e-02f, 2.40562055e-02f, -4.24759537e-02f, -7.94181833e-04f, 1.15615644e-01f, 5.14468402e-02f,
  1.27935419e-02f, 5.42534590e-02f, 7.59052560e-02f, -1.18086077e-02f, 1.73389819e-02f, 4.30947985e-04f, 1.80080999e-02f, 8.34909528e-02f, 1.66997120e-01f, -2.30923686e-02f,
  -1.14242740e-01f, 3.05413514e-01f, -1.25650212e-01f, 8.89826100e-03f, 6.52048215e-02f, -8.85209069e-03f, 1.34555595e-02f, 8.28988701e-02f, 6.99871331e-02f, 6.63977563e-02f,
  9.53387991e-02f, 1.53024808e-01f, 1.03028432e-01f, -5.83432205e-02f, 8.60264450e-02f, 1.02877930e-01f, 4.85266466e-03f, 1.62518527e-02f, 1.65748522e-02f, -7.00246915e-02f,
  2.17235703e-02f, 1.77376473e-03f, -1.81906521e-02f, -6.73015490e-02f, -5.76042086e-02f, 6.37966320e-02f, -5.09339869e-02f, 1.08023556e-02f, -6.74631521e-02f, -2.91877598e-01f,
  6.99749440e-02f, -6.84594661e-02f, -9.60186124e-02f, 8.66345409e-03f, -7.24696070e-02f, -1.16553931e-02f, 2.39175767e-01f, -6.89313561e-02f, -9.60659683e-02f, -1.14711160e-02f,
  -9.42854360e-02f, -6.21613394e-03f, -1.90216098e-02f, 7.71667659e-02f, 1.89959444e-02f, 1.05145842e-01f, 5.95357874e-03f, -6.47536144e-02f, 1.63907245e-01f, 7.62113035e-02f,
  9.91588235e-02f, -4.32611518e-02f, -1.95124701e-01f, -6.04214445e-02f, 4.06719074e-02f, 5.13653532e-02f, -1.47992402e-01f, -2.20539361e-01f, 3.36044701e-03f, -9.59686339e-02f,
  9.80990902e-02f, -3.03599447e-01f, -2.05163858e-04f, 4.60934788e-02f, -8.50302801e-02f, -3.97672467e-02f, -7.22349510e-02f, -7.37655610e-02f, 3.15439478e-02f, 5.32684997e-02f,
  -1.11215644e-01f, -6.30599540e-03f, 5.43810353e-02f, -9.03203115e-02f, -1.23723060e-01f, -1.80985592e-02f, 2.75314674e-02f, 3.94590683e-02f, -6.39806911e-02f, 8.10530558e-02f,
  6.62915483e-02f, 4.00399556e-04f, -3.06421984e-02f, 1.25912456e-02f, 1.66611541e-02f, 8.75509456e-02f, 7.79034896e-03f, -1.90909784e-02f, 2.70163245e-03f, 1.26169920e-01f,
  -4.33943942e-02f, -1.73031881e-01f, -8.92371759e-02f, -6.14920557e-02f, 1.16495848e-01f, -1.05090752e-01f, -1.01656221e-01f, 1.55224223e-02f, 3.70971151e-02f, -5.63381352e-02f,
  -1.46825075e-01f, 4.50748205e-02f, -1.01922669e-01f, -1.12284102e-01f, 4.35395017e-02f, 2.41008331e-03f, -5.30520193e-02f, 5.30955940e-02f, -6.79573715e-02f, 4.85373773e-02f,
  6.85135275e-02f, -1.49209961e-01f, -8.49743634e-02f, 7.09872171e-02f, -1.73690245e-02f, -1.00321576e-01f, 4.37771641e-02f, -7.98639134e-02f, -1.12691030e-01f, 5.04984781e-02f,
  2.62660027e-01f, -2.38769203e-01f, 1.39545426e-01f, 1.12202384e-01f, 1.05149731e-01f, 6.25604540e-02f, -4.45078984e-02f, 7.74285644e-02f, 2.69561484e-02f, -9.58205983e-02f,
  -3.93192731e-02f, 3.42124738e-02f, 3.31299677e-02f, 5.78032546e-02f, 1.80083178e-02f, 3.03095784e-02f, 4.37026192e-03f, 9.17985588e-02f, 4.42639329e-02f, 6.62976205e-02f,
  7.76543841e-02f, 7.62619600e-02f, 5.96228801e-02f, 8.30388665e-02f, -2.23858878e-02f, 1.88672006e-01f, 1.21894807e-01f, 1.67487577e-01f, 1.64255738e-01f, 2.75290757e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.24849567e-01f, 6.72308356e-02f, 2.22242415e-01f, -8.07185192e-03f, -1.04266673e-01f, -4.10328925e-01f, -5.90067029e-01f, -3.78548235e-01f, -2.52793487e-02f, 1.33002186e-02f,
  -1.20478831e-01f, -1.67615712e-02f, -7.44517073e-02f, -1.72702834e-01f, -3.83952290e-01f, -1.52539760e-01f, -2.55675009e-03f, 5.42276390e-02f, -2.83097982e-01f, -3.37966472e-01f,
  -9.23281386e-02f, 6.98131174e-02f, -6.53274590e-03f, 2.81304996e-02f, 1.51848271e-01f, 4.96414043e-02f, 2.09621191e-01f, 1.55612662e-01f, 1.01541974e-01f, 5.87655306e-01f,
  2.67562836e-01f, 2.77253300e-01f, -8.66321325e-02f, 9.00215432e-02f, 1.57180950e-01f, 8.93282890e-02f, 4.82907612e-03f, 1.02101207e-01f, 6.72537759e-02f, -7.58299753e-02f,
  2.85855159e-02f, 5.90438209e-02f, 3.18787433e-02f, -7.67826289e-02f, 4.93318215e-02f, -2.26033572e-03f, 4.05348539e-02f, -7.13899881e-02f, -6.89066276e-02f, 3.45888846e-02f,
  -3.95415118e-04f, -3.19031812e-02f, -8.66174772e-02f, -2.51772732e-01f, -1.03449784e-01f, -4.35114056e-02f, 8.43741000e-02f, 1.84424606e-03f, 5.72050810e-02f, 3.04241069e-02f,
  -1.26867101e-01f, 3.52846235e-02f, -5.65027185e-02f, -5.92163950e-02f, -3.94419506e-02f, -1.22028321e-01f, -6.44917712e-02f, -9.48932543e-02f, -1.13928288e-01f, -4.21848968e-02f,
  7.16197817e-03f, -5.65249771e-02f, 6.84776204e-03f, -1.61807314e-02f, 8.98905918e-02f, 1.27509430e-01f, 1.03910528e-01f, -3.61333899e-02f, 4.12819535e-02f, 7.83341005e-03f,
  -7.38992840e-02f, 8.83075595e-02f, 1.40417323e-01f, -7.60617256e-02f, 3.36030349e-02f, 1.36399344e-02f, 6.15429319e-02f, -5.40243089e-02f, 3.95774320e-02f, 3.45733799e-02f,
  -2.85825431e-02f, -1.12022854e-01f, 2.08112076e-01f, 3.59882563e-02f, 7.66501874e-02f, 1.83621183e-01f, 2.04013333e-01f, 1.99332070e-02f, 1.90703511e-01f, 7.51370639e-02f,
  -5.08729182e-02f, 1.20506696e-01f, 1.17338628e-01f, 1.12164235e-02f, -1.00555364e-03f, 1.83200929e-02f, -4.12394702e-02f, -1.63191501e-02f, -5.55469049e-03f, 1.36941016e-01f,
  8.36883392e-03f, -3.39728534e-01f, -2.17214778e-01f, -1.56112418e-01f, -1.12111777e-01f, -1.11405671e-01f, -9.27206427e-02f, 9.74170491e-02f, -1.14170559e-01f, -2.27559075e-01f,
  -6.71360493e-01f, -7.71864355e-02f, 4.31718260e-01f, -1.87712446e-01f, 2.35353410e-01f, 3.49278152e-01f, 3.80535603e-01f, 8.65985453e-02f, -1.55063510e-01f, 1.49491876e-01f,
  -4.13356423e-02f, -4.22424436e-01f, -3.56142849e-01f, -2.67102450e-01f, -1.84972242e-01f, 2.92130411e-01f, 1.10441923e-01f, -4.49016467e-02f, -6.99942419e-03f, 3.94621678e-02f,
  -1.30765036e-01f, -1.42490372e-01f, -2.24078000e-01f, -1.69615313e-01f, -1.00160293e-01f, -1.26913518e-01f, 3.64130884e-02f, -4.13929448e-02f, 4.46611866e-02f, -7.56688341e-02f,
  3.79626542e-01f, 7.08944276e-02f, 5.88244712e-03f, -9.36490670e-02f, 5.34658618e-02f, 1.25210732e-03f, 7.82407075e-03f, -1.19632073e-02f, -8.18589032e-02f, 1.08206019e-01f,
  3.49769518e-02f, -2.04189937e-03f, 4.58786972e-02f, 9.12201684e-03f, 1.43845946e-01f, 1.14197433e-01f, -2.39242297e-02f, -7.95010552e-02f, -1.09724831e-02f, 1.28665427e-02f,
  -1.49191305e-01f, 1.29537806e-01f, 1.06887557e-01f, -4.59404327e-02f, -2.25114147e-03f, 2.38168240e-02f, 1.03314176e-01f, -3.88204902e-02f, 3.87083031e-02f, -1.00858882e-01f,
  1.65755674e-02f, 5.15028201e-02f, 3.14134173e-02f, -9.20968801e-02f, 2.65491637e-03f, -9.20470059e-03f, 5.48162088e-02f, 1.66491773e-02f, 1.41231222e-02f, 6.99954806e-03f,
  -8.50503817e-02f, -4.94914912e-02f, 1.15505308e-01f, 8.17244053e-02f, -3.02604102e-02f, -1.05429604e-03f, 6.40415847e-02f, 4.58267666e-02f, -4.40396257e-02f, -7.21497387e-02f,
  3.72283310e-02f, 9.34030637e-02f, 8.39631408e-02f, 1.34723961e-01f, 1.08426645e-01f, 4.65996712e-02f, 2.53179837e-02f, -1.13810696e-01f, -1.00621521e-01f, -9.13287513e-03f,
  -5.57255279e-03f, 3.20182219e-02f, -8.93214419e-02f, -1.91305086e-01f, 7.66548365e-02f, -8.05818439e-02f, -1.53823435e-01f, 2.73503587e-02f, 1.14534765e-01f, 2.18415990e-01f,
  4.23468612e-02f, 7.16377497e-02f, 7.30169937e-02f, 9.77175403e-03f, 1.26008645e-01f, 3.00352182e-02f, -4.66553047e-02f, -1.66810602e-02f, 5.43659814e-02f, 1.61270127e-01f,
  -2.68418901e-03f, 4.34431285e-02f, 9.16068479e-02f, 1.05098806e-01f, 5.59157841e-02f, 1.02824725e-01f, 1.22615017e-01f, 1.48830250e-01f, 5.52436188e-02f, -2.72735278e-03f,
  3.96597058e-01f, -1.84166998e-01f, -1.02069087e-01f, 2.97572583e-01f, 7.19603226e-02f, -2.01984778e-01f, -5.88273585e-01f, -2.03330621e-01f, 3.86267900e-01f, -2.34803021e-01f,
  -5.35560586e-02f, 2.58278042e-01f, 4.85227332e-02f, -1.22823715e-01f, -3.52694660e-01f, -5.46299934e-01f, -3.60967427e-01f, -3.19194719e-02f, -5.80241345e-02f, -7.33186752e-02f,
  -5.36990091e-02f, -2.98472960e-02f, 7.80422837e-02f, -2.60806028e-02f, 7.82239288e-02f, 9.41878706e-02f, -2.15214655e-01f, 7.19274953e-02f, -1.86428830e-01f, 1.92002822e-02f,
  6.24851771e-02f, 9.82187763e-02f, -3.88846397e-02f, 4.56921943e-02f, 3.21867876e-02f, -3.58328852e-03f, -1.67045757e-01f, -2.90833935e-02f, -1.42895281e-02f, -1.26270121e-02f,
  -2.00759061e-02f, -1.36219576e-01f, 2.31111884e-01f, 6.38862625e-02f, 9.16934833e-02f, -2.05299035e-02f, -1.49192169e-01f, -3.35487090e-02f, -1.11964002e-01f, -1.80236369e-01f,
  -1.03112496e-01f, -1.12554021e-01f, -8.64587352e-02f, -5.75636886e-02f, -6.77032620e-02f, 1.32432655e-01f, -9.28488821e-02f, -7.39607168e-03f, -1.79206163e-01f, -8.97220969e-02f,
  -8.14300999e-02f, 4.17637154e-02f, -2.89219674e-02f, 2.24971920e-02f, -2.42273640e-02f, 4.44650976e-03f, 7.39405304e-02f, -5.01155816e-02f, -5.76085262e-02f, 2.35640500e-02f,
  -7.65013993e-02f, -9.09309313e-02f, 2.04068772e-03f, -1.96518246e-02f, 1.51813207e-02f, -7.62728974e-02f, -3.41035090e-02f, -2.08598822e-01f, -2.04982031e-02f, -6.07437901e-02f,
  -4.67214510e-02f, 7.89037272e-02f, -1.14673719e-01f, -9.80518162e-02f, -3.50242830e-04f, -7.59131014e-02f, -4.45798039e-02f, -5.89680299e-02f, 6.41612113e-02f, 1.81115642e-02f,
  1.00899301e-01f, -5.25671765e-02f, -5.25890850e-02f, -1.68052271e-01f, -1.47692114e-01f, -1.13037795e-01f, -6.46261051e-02f, -1.22897655e-01f, 1.46258846e-01f, 6.77464204e-03f,
  1.01159057e-02f, -1.27180591e-01f, -5.69927543e-02f, 4.90947030e-02f, 8.82627219e-02f, 7.51308873e-02f, -1.55443013e-01f, -9.24070738e-03f, -5.59107922e-02f, -1.31049767e-01f,
  -1.22500442e-01f, -2.62508929e-01f, 2.86396462e-02f, -2.01611109e-02f, 7.48555362e-02f, 4.00955193e-02f, -9.17115062e-02f, 1.06069125e-01f, -1.12684913e-01f, -2.93097705e-01f,
  9.15784180e-01f, -2.08157390e-01f, -1.20600462e-01f, 2.14701220e-01f, -3.17665666e-01f, -1.96442634e-01f, -2.39214703e-01f, -2.67945062e-02f, 4.16184030e-02f, -1.84010103e-01f,
  4.40820195e-02f, 2.69060791e-01f, 1.44421056e-01f, 8.97757187e-02f, 1.92856327e-01f, -2.69708514e-01f, -2.07928121e-01f, 1.85457885e-01f, 2.24600598e-01f, -4.54285815e-02f,
  -2.66643882e-01f, -1.03665337e-01f, 2.07450852e-01f, 4.08336557e-02f, -1.50693312e-01f, -4.74495478e-02f, -3.00049096e-01f, -2.03543156e-01f, -7.22850114e-02f, -2.15904996e-01f,
  8.90472084e-02f, 2.81922877e-01f, 3.03684063e-02f, 1.51773661e-01f, 8.44322518e-02f, 1.09240614e-01f, 1.37097687e-01f, 8.59745145e-02f, -6.45023063e-02f, 2.65261717e-02f,
  1.67197928e-01f, 4.68109399e-02f, 3.97899523e-02f, -9.71736684e-02f, -7.89196640e-02f, 9.70393196e-02f, -4.21366282e-02f, -8.06113183e-02f, 6.63920045e-02f, -1.14419656e-02f,
  4.41335663e-02f, -6.20338395e-02f, 1.37523189e-01f, -5.76215275e-02f, 8.04340281e-03f, -1.82508640e-02f, -3.09875049e-02f, 9.59788039e-02f, 2.92189158e-02f, -1.60403382e-02f,
  -1.67676896e-01f, 1.06605478e-01f, 4.89969254e-02f, -1.65273435e-02f, 3.07273678e-02f, -5.33340350e-02f, 2.02948973e-02f, 6.44732127e-03f, 3.77763920e-02f, 2.54370496e-02f,
  -5.75603284e-02f, -1.30287066e-01f, 2.47496180e-02f, 3.80256809e-02f, 2.99168844e-02f, -9.09302104e-03f, 1.23368107e-01f, 1.11473985e-01f, -2.41557863e-02f, -2.38072146e-02f,
  8.75465497e-02f, -1.52110159e-02f, -5.80746606e-02f, -1.18033122e-02f, -3.08570080e-02f, -2.56105587e-02f, -2.79179439e-02f, -1.04258396e-02f, -1.27607733e-01f, 9.16381925e-03f,
  -2.91888490e-02f, 1.34748295e-01f, 5.32834306e-02f, 4.51179184e-02f, 2.93479040e-02f, -2.37738825e-02f, 4.33166251e-02f, 7.32572675e-02f, 7.84719512e-02f, -3.27401934e-03f,
  1.29072964e-01f, 1.21992022e-01f, 2.03945618e-02f, -2.13271827e-02f, -1.24381341e-01f, 2.15161708e-03f, -2.75831856e-03f, 9.64809209e-02f, 1.04736909e-01f, -7.95256048e-02f,
  -1.73489098e-02f, -1.63368359e-02f, 2.77364016e-01f, 7.88778474e-04f, 5.98649569e-02f, 1.30584762e-01f, -3.72621454e-02f, 5.09070829e-02f, 3.86002772e-02f, -1.76924780e-01f,
  -2.26868808e-01f, -3.86858433e-02f, 2.24180013e-01f, -2.72969455e-01f, 2.95722991e-01f, 2.68152058e-01f, 5.57137787e-01f, 4.19048816e-02f, -1.57036066e-01f, 6.41734451e-02f,
  -4.54471968e-02f, -1.72431335e-01f, -2.80615658e-01f, -1.62761152e-01f, 7.12370640e-03f, 3.75795126e-01f, 1.72096059e-01f, 4.13801298e-02f, 1.21120259e-01f, 2.63650149e-01f,
  4.34309356e-02f, 5.54584935e-02f, -2.17781216e-01f, -7.82977641e-02f, -1.05473183e-01f, -1.05841450e-01f, 9.26872492e-02f, 3.98243666e-02f, 3.87453698e-02f, -1.27659217e-01f,
  -9.75999236e-02f, -2.15692505e-01f, -3.90610378e-03f, -1.70933604e-01f, -3.07637285e-02f, -1.95315719e-01f, -2.81528309e-02f, -1.17869683e-01f, 3.29465605e-02f, -8.69942643e-03f,
  -1.44542173e-01f, 2.52922978e-02f, -7.96281397e-02f, -6.12310134e-02f, 1.39806494e-02f, -3.47161456e-03f, -6.64673969e-02f, 2.11584605e-02f, -3.28930877e-02f, -7.07115605e-02f,
  6.52068993e-04f, -4.77449968e-02f, -8.43610801e-03f, 1.67203099e-02f, 1.60946660e-02f, -2.08939016e-02f, 5.34760803e-02f, -1.01969121e-02f, -3.52714024e-02f, -1.08737178e-01f,
  9.31194946e-02f, 9.05511603e-02f, -4.87272628e-02f, -9.40341651e-02f, -1.34814177e-02f, 1.40099838e-01f, 7.63121024e-02f, 1.27217427e-01f, 2.51094047e-02f, 6.44055828e-02f,
  7.25088408e-03f, -1.04148492e-01f, -2.18701705e-01f, -9.79599208e-02f, -2.70480495e-02f, -1.00910179e-01f, -6.46481588e-02f, -9.04426947e-02f, -9.45860799e-03f, -2.10084572e-01f,
  -5.12520596e-02f, -4.66493666e-02f, -5.22378460e-02f, 6.26639649e-02f, -5.13891019e-02f, -9.32779834e-02f, -1.32707283e-01f, -8.09100866e-02f, 5.49842753e-02f, -9.60790217e-02f,
  -1.61041051e-01f, -1.04896925e-01f, -1.03144228e-01f, -1.08089760e-01f, -8.47203378e-03f, -3.72703634e-02f, -2.57589042e-01f, -4.07632403e-02f, 1.52116194e-02f, 3.67414095e-02f,
  9.96581614e-02f, -2.42240890e-03f, -2.98503041e-02f, 4.22716588e-02f, 1.14368439e-01f, 7.89495930e-02f, 7.15698674e-02f, 1.06150128e-01f, -5.54744862e-02f, 1.45554962e-02f,
  7.94047490e-02f, 2.21554056e-01f, -3.92614193e-02f, 2.51208972e-02f, -2.75705922e-02f, -1.10978568e-02f, 1.20691024e-01f, 1.42250434e-01f, 1.70203447e-01f, 2.94708967e-01f,
  -7.26865768e-01f, 6.38220459e-02f, 5.08606359e-02f, -6.15637422e-01f, -1.92271337e-01f, -7.85405785e-02f, 2.41574034e-01f, -1.07459292e-01f, -2.84438252e-01f, 2.32077792e-01f,
  9.25023258e-02f, 3.88138704e-02f, 1.54625205e-02f, 2.10631698e-01f, 5.68627659e-03f, 6.67115450e-02f, -1.38695911e-01f, -1.28297105e-01f, -1.04465589e-01f, 2.97588632e-02f,
  -8.54520351e-02f, -3.35061044e-01f, -3.23395282e-01f, -2.12790206e-01f, -1.03905894e-01f, 4.59105298e-02f, 6.26901835e-02f, -2.46134952e-01f, 5.86794056e-02f, -6.82433322e-02f,
  3.09582412e-01f, -1.17243074e-01f, -1.49215773e-01f, -1.46276981e-01f, 9.86893699e-02f, -9.46168229e-02f, 8.51866007e-02f, -8.91350210e-03f, 3.07844765e-02f, -1.02747995e-02f,
  -1.94588125e-01f, 4.67519164e-02f, -5.98031357e-02f, 2.92312130e-02f, 3.11544258e-02f, -4.43668664e-03f, -1.56426951e-02f, -2.78127491e-02f, 1.53964594e-01f, 2.06725851e-01f,
  3.97932716e-02f, -9.07231644e-02f, -1.52727321e-01f, 1.33141100e-01f, -1.91108808e-02f, -1.96325686e-02f, 1.04374230e-01f, -6.92370534e-02f, 1.13472506e-01f, 1.25481814e-01f,
  3.39558274e-02f, 1.63767990e-02f, -7.53992572e-02f, 8.04649387e-03f, 1.71447144e-04f, -1.43143274e-02f, 4.65820134e-02f, 1.29447924e-02f, -6.42450480e-03f, -1.20074794e-01f,
  8.35971460e-02f, -1.10378419e-03f, 3.65884453e-02f, 5.97486645e-02f, 5.47333881e-02f, -1.27691999e-01f, -3.49668786e-02f, 4.38136123e-02f, 8.38048309e-02f, -1.35006011e-02f,
  -5.42987920e-02f, -1.97752453e-02f, -1.12386301e-01f, 1.25962766e-02f, -6.00003228e-02f, -9.24308822e-02f, 2.21061073e-02f, 6.94540739e-02f, -1.69263296e-02f, 1.53253013e-02f,
  2.82355975e-02f, -1.11811429e-01f, -2.53895782e-02f, 8.51436425e-03f, 5.16754063e-03f, -7.52577707e-02f, 8.99815094e-03f, -1.23535849e-01f, -1.04306668e-01f, 1.15173599e-02f,
  -1.27566844e-01f, 1.12792574e-01f, 3.68664823e-02f, -4.48393461e-04f, 7.64960749e-03f, -3.85408774e-02f, -8.61621872e-02f, -9.90378857e-02f, -1.03086933e-01f, 7.98164606e-02f,
  -5.57670631e-02f, -1.27091646e-01f, -1.45328209e-01f, -3.81942131e-02f, -1.15211174e-01f, -2.29520220e-02f, 1.75360650e-01f, 4.01511267e-02f, 1.73748955e-02f, 2.65933555e-02f,
  -4.27927822e-02f, -4.81394142e-01f, -8.11993331e-02f, 1.50941133e-01f, 2.83724725e-01f, 3.15837890e-01f, 2.45604753e-01f, 9.06336010e-02f, 7.80333951e-02f, 4.67970930e-02f,
  -6.08792268e-02f, -1.22071080e-01f, -1.37648284e-01f, -5.94607443e-02f, -8.74991417e-02f, 1.39181644e-01f, 1.37462467e-01f, 5.83887920e-02f, 1.73974186e-01f, 3.07554901e-01f,
  1.76838860e-02f, -8.49701613e-02f, -1.47222951e-01f, 5.69455549e-02f, -6.03734590e-02f, 1.54355213e-01f, -4.05417085e-02f, -1.37982652e-01f, -8.31850693e-02f, -1.06865972e-01f,
  -3.35548103e-01f, -1.64196372e-01f, 2.13732123e-01f, -5.97628839e-02f, 1.84350007e-03f, -8.31564330e-03f, -8.58028012e-04f, -6.64189309e-02f, -8.68845731e-02f, -1.55578166e-01f,
  -7.12529942e-02f, -1.84801489e-01f, 4.16285023e-02f, 1.15941549e-02f, -1.93904802e-01f, 7.28687048e-02f, -2.11677074e-01f, -1.73526347e-01f, -2.07782149e-01f, -1.14503928e-01f,
  -1.88500836e-01f, -9.24805030e-02f, -1.21251486e-01f, -4.39762808e-02f, -2.02141225e-01f, -1.17552951e-01f, -1.56028956e-01f, -9.80328396e-02f, -2.67447919e-01f, -1.72895983e-01f,
  -7.65218660e-02f, -1.06328521e-02f, 8.31507612e-03f, 6.48010373e-02f, 7.87917748e-02f, 8.06832239e-02f, 3.72495241e-02f, -1.24568306e-03f, 1.10900633e-01f, -5.84198609e-02f,
  5.43256477e-02f, 8.12283717e-03f, 2.35772524e-02f, 6.38562217e-02f, 7.75029957e-02f, -1.35584958e-02f, 5.58583252e-02f, -2.74443179e-02f, 9.40986127e-02f, 2.21047997e-01f,
  1.50919640e-02f, 5.31397946e-02f, -7.13741332e-02f, 1.49355829e-02f, 3.62061150e-02f, 6.08296245e-02f, -2.18496472e-02f, -6.28672615e-02f, -5.54454327e-02f, 4.18800488e-02f,
  -7.21248761e-02f, -9.58982930e-02f, 2.60161124e-02f, -6.26645759e-02f, 1.08354583e-01f, -5.48539311e-02f, -2.35890485e-02f, -1.53173208e-01f, 2.08401103e-02f, 7.88248479e-02f,
  2.11395193e-02f, -3.15136760e-02f, -7.62288794e-02f, -6.46669976e-03f, 2.10850686e-01f, 2.09285349e-01f, -9.25584733e-02f, 9.60413069e-02f, -6.28450280e-03f, 1.10022664e-01f,
  -1.87388197e-01f, 1.78766623e-01f, 1.29995808e-01f, 1.45425707e-01f, 5.42779937e-02f, 2.19808608e-01f, 5.64012341e-02f, 1.89565673e-01f, 1.72127590e-01f, 2.49131769e-01f,
  -9.42467824e-02f, -4.63614427e-03f, -5.01459718e-01f, -1.29683450e-01f, -1.81668431e-01f, -1.77484751e-01f, -2.32684836e-02f, 1.95078596e-01f, -8.26707575e-03f, -2.38334909e-01f,
  1.09544955e-01f, 2.01666862e-01f, 7.76016666e-03f, 9.76636820e-03f, 6.26220703e-02f, -2.44017512e-01f, -2.34749764e-01f, -1.89455926e-01f, 2.61250287e-01f, 1.48148790e-01f,
  7.05202818e-02f, 1.29349709e-01f, 1.41254798e-01f, 9.21316445e-02f, -5.46688326e-02f, 3.91080678e-02f, -1.43246874e-01f, -1.74524978e-01f, -2.31480062e-01f, -5.45601130e-01f,
  -7.80328363e-02f, -1.32618546e-01f, 8.35497528e-02f, -2.25190092e-02f, 4.31040935e-02f, 1.82512030e-01f, 1.79596841e-01f, 1.71062231e-01f, 1.91374138e-01f, -2.49848403e-02f,
  -5.02985641e-02f, 4.97707278e-02f, 1.40912265e-01f, -4.36738878e-02f, 2.75394488e-02f, 4.00427990e-02f, 7.58328289e-02f, -4.16072421e-02f, -5.58544844e-02f, -6.29692674e-02f,
  5.30619323e-02f, -1.03636824e-01f, 2.06236988e-02f, 2.58859457e-03f, 5.32003790e-02f, 2.82622892e-02f, 1.16732210e-01f, -9.93242487e-02f, -1.08850248e-01f, 5.27101122e-02f,
  1.40559918e-03f, 5.64111732e-02f, -7.30463862e-02f, 1.28282353e-01f, 8.12772810e-02f, 3.57428640e-02f, 4.27882597e-02f, 9.56698845e-04f, 1.03976808e-01f, 7.83903971e-02f,
  1.24916561e-01f, -1.32513747e-01f, 1.95951406e-02f, -4.66394750e-03f, -3.85634527e-02f, -1.16726212e-01f, -1.33994356e-01f, 7.30757660e-04f, -3.28196064e-02f, -5.26045123e-03f,
  -1.10614635e-01f, -6.33997098e-02f, -9.90165547e-02f, -9.40180123e-02f, -1.71076626e-01f, -1.72277298e-02f, -2.07046881e-01f, 6.68382794e-02f, 9.97301787e-02f, 5.07544354e-02f,
  2.66295195e-01f, -2.44562984e-01f, -3.14025283e-02f, -7.84882084e-02f, -2.60506511e-01f, -8.52151513e-02f, -9.31718498e-02f, -6.07276969e-02f, 1.93492360e-02f, -9.87353176e-03f,
  -2.57198606e-02f, -3.76686566e-02f, 9.38403830e-02f, 1.04224756e-01f, 2.02435225e-01f, 1.14470012e-01f, -1.92421041e-02f, -4.47233804e-02f, -2.16144264e-01f, -9.95251834e-02f,
  -1.76029019e-02f, 2.28219610e-02f, 1.22115955e-01f, -8.52784608e-03f, -1.17440056e-02f, 1.43948942e-01f, 8.12633932e-02f, -1.36020770e-02f, -3.31949368e-02f, 2.22796023e-01f,
  5.54533005e-01f, 3.90298724e-01f, 4.00903523e-01f, 1.83539852e-01f, 7.82647505e-02f, 1.79885864e-01f, 2.06520855e-01f, 1.47426307e-01f, -2.65655536e-02f, 1.43440872e-01f,
  1.75411984e-01f, -1.68739691e-01f, -4.66956683e-02f, -9.36273709e-02f, 4.15044241e-02f, 2.43738685e-02f, -1.39787778e-01f, 1.35280102e-01f, -1.02603703e-03f, 7.27934018e-02f,
  -4.68579233e-02f, -2.86302548e-02f, 2.90595014e-02f, 5.95400184e-02f, 4.87377197e-02f, -1.92891181e-01f, 3.53986910e-03f, 7.29982322e-03f, 1.46984048e-02f, -1.32411674e-01f,
  1.95332661e-01f, 3.26668203e-01f, -1.35969603e-02f, -6.98082373e-02f, 1.48935080e-01f, 2.79847570e-02f, 1.32104933e-01f, 1.60664603e-01f, 1.77898154e-01f, 1.43837929e-01f,
  3.59684601e-02f, 4.82804552e-02f, -5.41067310e-02f, -1.58787277e-02f, 8.88114348e-02f, 7.47477114e-02f, -8.84183031e-03f, 8.19278136e-02f, 5.30556776e-02f, 1.26387075e-01f,
  2.31057182e-02f, 7.07456470e-02f, 1.56818181e-01f, 1.10548377e-01f, 1.06842473e-01f, 2.94655133e-02f, 1.08119480e-01f, 6.45761043e-02f, -1.44909285e-02f, 4.11039740e-02f,
  -9.24193487e-02f, -3.65063325e-02f, 3.01428530e-02f, 2.09218282e-02f, -6.21968620e-02f, -4.57560606e-02f, 1.37164649e-02f, 1.12893961e-01f, -2.15796512e-02f, -1.47379875e-01f,
  -7.98423067e-02f, 6.37171092e-04f, 7.35695064e-02f, 6.90662265e-02f, 1.97380371e-02f, -2.57734070e-03f, 5.06710373e-02f, 1.61833644e-01f, 3.32586393e-02f, -1.34415314e-01f,
  1.56053985e-02f, 9.34920982e-02f, 1.38088642e-02f, -2.92554684e-02f, -3.11779696e-02f, 8.71295556e-02f, -7.06373155e-03f, -3.43029648e-02f, -1.04617383e-02f, -9.08074006e-02f,
  8.35871547e-02f, 2.15226412e-02f, -1.17619477e-01f, -2.15109214e-01f, -1.35051794e-02f, 3.76030356e-02f, 1.49300625e-03f, -4.82807830e-02f, 1.85049754e-02f, 1.06899627e-01f,
  1.44755706e-01f, 1.03936428e-02f, -1.51879899e-02f, -5.42787975e-03f, -3.87494676e-02f, 4.35293131e-02f, -6.53844774e-02f, -4.35837731e-02f, 1.38864070e-02f, 1.16930574e-01f,
  -1.01839378e-01f, -3.95958424e-02f, 1.66673586e-02f, -1.50394952e-03f, -7.08202794e-02f, -1.50402457e-01f, -7.35282823e-02f, 5.58386848e-04f, 4.94422950e-02f, -8.19611475e-02f,
  -2.23357469e-01f, -2.82849580e-01f, -2.28241876e-01f, 8.88533611e-03f, -3.79063338e-02f, 6.76870570e-02f, -9.92311165e-02f, 1.17670298e-01f, 7.56380334e-02f, -2.69686669e-01f,
  -4.94838692e-02f, 3.10834544e-03f, -1.25927523e-01f, 3.22365537e-02f, -1.18453905e-01f, -3.34094971e-01f, -2.95104772e-01f, -1.78947672e-02f, 2.28792801e-01f, 3.02566767e-01f,
  1.88185479e-02f, 1.09907776e-01f, 1.84400044e-02f, 4.88246456e-02f, -1.33686796e-01f, -6.45329729e-02f, -2.17721239e-01f, 6.56166254e-03f, -8.20825920e-02f, -3.25611234e-01f,
  -3.36470723e-01f, 7.55832791e-02f, 1.63912907e-01f, 1.91514581e-01f, -1.43211305e-01f, -6.74148090e-03f, -2.52624489e-02f, -7.62398392e-02f, -8.76484662e-02f, -9.38553810e-02f,
  5.77173792e-02f, 1.43384784e-01f, 9.36398469e-03f, 1.32789791e-01f, 6.01997040e-02f, 1.77688748e-02f, -2.13020090e-02f, 4.11563590e-02f, -1.92525145e-02f, 8.44331905e-02f,
  -5.10126278e-02f, -2.45376024e-02f, 5.63518777e-02f, 5.79963662e-02f, 9.73218232e-02f, -5.40244989e-02f, 3.29114608e-02f, 6.97324648e-02f, 4.63147126e-02f, -2.77687877e-01f,
  -6.74621090e-02f, -4.24175039e-02f, 4.49857451e-02f, 4.78744246e-02f, 2.56334729e-02f, -8.76400694e-02f, -4.73402366e-02f, 9.83730983e-03f, 6.90492168e-02f, -2.25574919e-03f,
  2.00115796e-02f, -2.51667798e-02f, 1.20105259e-02f, -1.15802608e-01f, 1.51829338e-02f, -3.08748279e-02f, -1.60475224e-02f, 4.20700684e-02f, 4.70144562e-02f, -1.39928078e-02f,
  1.09992206e-01f, 6.19978867e-02f, -1.70347523e-02f, 1.91425696e-01f, 6.40932769e-02f, -1.70024931e-02f, -7.79234618e-02f, -9.16407630e-03f, 7.20717907e-02f, 2.96478849e-02f,
  -7.25132376e-02f, 7.38641471e-02f, -2.02137783e-01f, 2.32990887e-02f, -7.07630813e-02f, -5.60561903e-02f, -1.11008778e-01f, 2.69942470e-02f, -4.35848944e-02f, 8.75809193e-02f,
  2.51180172e-01f, -9.19221193e-02f, -6.24925159e-02f, -1.73920374e-02f, 4.13477570e-02f, 1.50962576e-01f, -1.17541127e-01f, -2.28606910e-03f, -5.82671650e-02f, 1.52229592e-01f,
  -1.22556753e-01f, -5.47160916e-02f, -6.65243268e-02f, -1.07160229e-02f, -8.79133493e-02f, -5.91737144e-02f, -1.62214078e-02f, -1.30787930e-02f, -4.75143194e-02f, -2.85363942e-01f,
  -8.29837620e-01f, -1.43862635e-01f, -1.29726052e-01f, -2.00209960e-01f, -1.75175428e-01f, -1.44913927e-01f, -1.10144600e-01f, -1.21847622e-01f, -1.68360367e-01f, -1.38488458e-02f,
  -3.65204699e-02f, 8.06313381e-02f, 4.11312282e-02f, 1.36873648e-01f, 4.70239669e-02f, -7.77842626e-02f, -1.93940595e-01f, -1.26596108e-01f, -6.51958883e-02f, 1.24033809e-01f,
  6.31552115e-02f, -1.34237558e-01f, -1.16407581e-01f, 9.71453672e-04f, -1.54882139e-02f, 1.25906914e-01f, 8.13552588e-02f, -8.02239105e-02f, 8.31844211e-02f, -1.74869806e-01f,
  5.13571739e-01f, -1.09422959e-01f, 7.15628937e-02f, -3.46523821e-02f, -1.20891169e-01f, -3.90572995e-02f, -5.69749475e-02f, 4.13689576e-02f, -8.27349606e-04f, 7.07642883e-02f,
  7.17939362e-02f, -1.31534383e-01f, -8.67331028e-02f, -2.88764108e-03f, -6.72410354e-02f, 6.96964748e-03f, -5.62925264e-02f, -6.18256032e-02f, -2.51877327e-02f, 6.26729950e-02f,
  8.30552876e-02f, -6.37687445e-02f, 1.64298579e-01f, 1.73553839e-01f, 7.65264705e-02f, -4.54015955e-02f, 5.95248565e-02f, 2.52425671e-02f, 5.42029068e-02f, 8.60163048e-02f,
  -7.62819499e-02f, 7.41355121e-02f, 8.73671994e-02f, 5.74093796e-02f, -3.18385959e-02f, 9.38156322e-02f, 1.06397405e-01f, 1.34848699e-01f, 4.55815494e-02f, -1.66367982e-02f,
  7.27756124e-05f, -1.87994968e-02f, 7.97820687e-02f, 1.24265440e-02f, 1.76363215e-02f, -6.23907484e-02f, -1.70546502e-01f, 2.44013280e-01f, 6.45032153e-02f, -9.53344554e-02f,
  -5.74202500e-02f, 1.17101483e-02f, -8.05030689e-02f, -2.67244782e-02f, -1.42181218e-01f, -1.41270339e-01f, -5.91159686e-02f, -1.19674169e-02f, -2.43573934e-02f, -1.81785837e-01f,
  4.40401405e-01f, -6.14663474e-02f, -2.70989537e-02f, 5.25354408e-02f, -2.27161665e-02f, -4.56414297e-02f, 1.44955993e-01f, 1.12885170e-01f, 3.81681956e-02f, 1.51103973e-01f,
  6.05000965e-02f, 5.84891140e-02f, -9.31748971e-02f, 5.28303720e-02f, -7.01460466e-02f, 2.86205020e-02f, -7.13285198e-03f, 1.35244012e-01f, 7.78655410e-02f, 2.02082112e-01f,
  5.20296283e-02f, 9.05295387e-02f, 2.27808312e-01f, 1.35019153e-01f, 4.37779501e-02f, 1.08036799e-02f, 9.03307125e-02f, 7.84461498e-02f, 2.74467450e-02f, -1.04994830e-02f,
  -5.00923574e-01f, 1.96549132e-01f, -1.13984710e-02f, -2.35234439e-01f, 1.53032720e-01f, 7.30174109e-02f, 1.14216127e-01f, 1.03530496e-01f, 3.34509239e-02f, -2.33931635e-02f,
  9.24793109e-02f, 2.23499238e-01f, -9.77103710e-02f, -5.52204438e-02f, -2.74506301e-01f, -2.96894968e-01f, -3.49506348e-01f, -3.44810933e-01f, -9.53002349e-02f, 6.89070970e-02f,
  2.16530971e-02f, -2.27694377e-01f, -3.01785529e-01f, -6.41902387e-02f, 8.02827924e-02f, 5.38090803e-02f, -1.95315540e-01f, -2.19862238e-01f, 1.78983919e-02f, -1.90582901e-01f,
  -7.61189535e-02f, 1.82289645e-01f, -1.47412578e-03f, -7.29949102e-02f, 7.58260349e-03f, -7.72419618e-03f, 8.43089148e-02f, 9.03047994e-02f, 9.82765555e-02f, -3.83134447e-02f,
  -1.21213280e-01f, 8.20802450e-02f, -8.48758779e-03f, 3.75295542e-02f, 2.01926082e-02f, -1.72237232e-02f, 1.34118125e-02f, -5.08406013e-03f, 5.98978475e-02f, 1.44279689e-01f,
  8.56976286e-02f, 5.41642308e-02f, 7.67974630e-02f, 1.09918132e-01f, 4.58437391e-02f, -8.26039687e-02f, 1.44379765e-01f, 7.66766965e-02f, 8.65240768e-02f, -9.46220085e-02f,
  1.15600273e-01f, 8.93971771e-02f, 1.12341978e-01f, -6.96051717e-02f, -1.38775185e-02f, -5.02498671e-02f, -1.72691435e-01f, -1.37228519e-01f, 1.48404418e-02f, -5.02187274e-02f,
  8.81255232e-03f, 1.45436162e-02f, -8.21130425e-02f, -9.50420499e-02f, 4.54173125e-02f, 1.49876913e-02f, -1.08383179e-01f, -3.85698266e-02f, -8.57519954e-02f, -4.67010289e-02f,
  -1.30991125e-02f, -6.45989850e-02f, -1.27074450e-01f, 1.60182659e-02f, -9.18246582e-02f, -7.70800188e-02f, 7.19894022e-02f, 1.68245643e-01f, -8.08167532e-02f, 4.43322621e-02f,
  -2.27435827e-01f, 1.32136270e-02f, -2.00525165e-01f, 1.98492989e-01f, -4.41761501e-02f, -3.69352922e-02f, 2.48078573e-02f, -7.36198053e-02f, -1.31542489e-01f, -1.39165772e-02f,
  -2.28767432e-02f, -4.50224616e-02f, -5.04980721e-02f, -4.83353958e-02f, -8.61446708e-02f, -4.69044857e-02f, -4.63763997e-02f, -1.09297164e-01f, 1.98298935e-02f, 1.08352065e-01f,
  -2.77080964e-02f, -1.45936728e-01f, -1.92463681e-01f, 1.65080633e-02f, -1.02379166e-01f, -8.75469521e-02f, -5.39383069e-02f, 1.22790053e-01f, -4.91636768e-02f, -1.71286345e-01f,
  -2.59403259e-01f, -4.63312984e-01f, 6.00110069e-02f, 1.46745265e-01f, 2.83889681e-01f, 1.90330029e-01f, 1.76048219e-01f, -4.85309698e-02f, -1.94168314e-02f, -4.04020846e-02f,
  -1.33749530e-01f, -4.22762930e-02f, 7.24489382e-03f, -4.16332148e-02f, -5.97264357e-02f, 1.44536167e-01f, 2.00028151e-01f, -9.93273035e-03f, 2.71632701e-01f, 2.16508314e-01f,
  7.26147788e-03f, -5.02111344e-03f, -2.50752896e-01f, 5.19479699e-02f, -3.23135741e-02f, 1.46224380e-01f, 3.81145738e-02f, -1.77907161e-04f, 6.25954717e-02f, -7.44305998e-02f,
  3.43660504e-01f, -1.51841596e-01f, 4.28533778e-02f, -6.43107146e-02f, -6.59548789e-02f, -9.20172408e-02f, 7.41188275e-03f, -5.11367805e-02f, 4.68195975e-02f, 1.14314705e-02f,
  -6.19515218e-02f, 6.46272488e-03f, -3.85191850e-02f, -1.37618899e-01f, 2.64289342e-02f, -3.77904512e-02f, -9.85540897e-02f, -1.20499805e-01f, 9.85857937e-03f, 6.54609650e-02f,
  -4.94375676e-02f, -1.63509399e-01f, 1.34264991e-01f, 8.63035768e-02f, -6.18767701e-02f, -4.32186946e-02f, -1.09324463e-01f, -1.30773857e-01f, -5.33383340e-02f, -3.00975218e-02f,
  1.65476233e-01f, 8.16850066e-02f, 7.21676974e-03f, 5.54655604e-02f, 1.56418741e-01f, 4.31243144e-02f, 1.28996462e-01f, 2.94262655e-02f, -5.35558052e-02f, -1.48228630e-01f,
  3.20136896e-03f, 6.52873814e-02f, -3.73436399e-02f, 8.88007060e-02f, -3.46866958e-02f, -1.10271260e-01f, -2.24801693e-02f, 7.37345293e-02f, -1.01341948e-01f, -1.02902859e-01f,
  -3.28924730e-02f, -5.30323163e-02f, -1.23118065e-01f, -1.07504651e-01f, -5.81382774e-02f, 1.11245625e-01f, 8.23685899e-02f, -3.17428969e-02f, -4.83467653e-02f, -7.02020153e-03f,
  2.54164428e-01f, -4.22178447e-04f, 1.52909845e-01f, -1.74212039e-01f, -5.83894514e-02f, -2.13179603e-01f, 3.53198834e-02f, 5.28193116e-02f, 4.37618420e-02f, 1.82955280e-01f,
  -7.16460794e-02f, -3.03286361e-03f, -9.87785980e-02f, 5.20794094e-03f, 1.23840943e-01f, 1.02060772e-01f, -9.70200971e-02f, 1.05922380e-02f, 3.04329116e-02f, 1.24161199e-01f,
  6.08573342e-03f, 1.30542994e-01f, 2.48049647e-01f, 1.11264564e-01f, 2.18399748e-01f, 1.83879361e-01f, 1.49980038e-01f, 5.90897538e-02f, 9.65464935e-02f, 1.71769813e-01f,
  -2.25821391e-01f, 1.52532503e-01f, -3.39092244e-03f, 3.73189002e-02f, 8.25860128e-02f, -2.40972430e-01f, -1.98595330e-01f, -3.19816470e-02f, 2.47204393e-01f, 2.00466052e-01f,
  1.44572571e-01f, 4.77250963e-02f, 4.39335071e-02f, -1.66993037e-01f, -5.34884155e-01f, -3.21177900e-01f, -2.42051959e-01f, -3.73140603e-01f, -3.56703073e-01f, -3.80518109e-01f,
  -7.36881047e-02f, -7.43013620e-02f, -1.17269129e-01f, 3.07252370e-02f, 2.20196173e-01f, 1.11688502e-01f, 3.14693958e-01f, -3.84800062e-02f, -6.91484064e-02f, 1.15386359e-02f,
  6.28959239e-02f, -1.25346845e-02f, -1.92926943e-01f, -1.15985135e-02f, 1.95674360e-01f, -4.55545299e-02f, -6.47235960e-02f, 1.15806520e-01f, 1.32742688e-01f, 1.77630216e-01f,
  -5.01071662e-03f, 5.39794415e-02f, -4.25866023e-02f, 3.55050415e-02f, -1.96095500e-02f, -8.25387388e-02f, -8.40940475e-02f, -2.11663321e-01f, -6.84817880e-02f, -4.09102328e-02f,
  -8.79140347e-02f, -1.65603250e-01f, -2.87305135e-02f, -1.69290267e-02f, -1.47130623e-01f, -9.13251489e-02f, -3.78143899e-02f, 1.64375640e-02f, -4.54317294e-02f, 2.24539980e-01f,
  -3.85415517e-02f, -2.64578965e-03f, 1.04711764e-01f, -4.10975376e-03f, 3.30739357e-02f, 1.82892568e-02f, 1.22573212e-01f, 6.61781579e-02f, 8.90044644e-02f, 5.33721596e-02f,
  8.14256892e-02f, 4.42092866e-02f, 9.01212096e-02f, 1.71230614e-01f, 1.19617611e-01f, -4.91259359e-02f, 4.63300906e-02f, 9.02177915e-02f, -2.21210793e-02f, 1.61494806e-01f,
  -3.01629957e-02f, 1.11688562e-01f, 9.14146602e-02f, 1.14195183e-01f, -1.03676684e-01f, 4.51822840e-02f, -7.21720457e-02f, -7.51854479e-02f, -5.59337810e-02f, -4.64657024e-02f,
  3.31760734e-01f, -3.08923274e-01f, -1.97962075e-02f, 6.12095045e-03f, 1.48670837e-01f, 8.47689882e-02f, 2.15180859e-01f, 4.85247523e-02f, 1.65091038e-01f, 1.41697347e-01f,
  2.09236965e-02f, 1.21496998e-01f, 1.34720698e-01f, 7.19025210e-02f, 3.74835879e-02f, 4.44820039e-02f, 1.10166986e-02f, 8.78688544e-02f, -8.91887099e-02f, 1.78904608e-01f,
  6.78034201e-02f, 6.22705184e-03f, -2.28782836e-03f, 1.30315825e-01f, -2.40310952e-02f, -1.72210395e-01f, 1.05232604e-01f, 3.53272296e-02f, -1.46665022e-01f, 2.46859670e-01f,
  1.99732140e-01f, -4.22070287e-02f, -9.52863507e-03f, 2.05461726e-01f, -1.52611911e-01f, -1.27312109e-01f, -7.04179406e-02f, 1.11456059e-01f, 3.97732779e-02f, 3.52489315e-02f,
  -3.11886687e-02f, 1.27828985e-01f, 1.61884174e-01f, 1.88288212e-01f, 1.56581506e-01f, 2.32571349e-01f, 2.97361732e-01f, 2.47899368e-01f, 1.36323661e-01f, 1.63722172e-01f,
  1.90547496e-01f, -2.67684441e-02f, -9.15514007e-02f, 1.07715704e-01f, 2.35213488e-01f, 2.12432072e-01f, -1.99404899e-02f, 1.14018932e-01f, 2.29069442e-02f, 4.68578458e-01f,
  -1.28086135e-01f, 7.06672966e-02f, 6.31922036e-02f, -1.46143526e-01f, -1.38594322e-02f, -1.06562555e-01f, -3.23603004e-02f, -1.13357015e-01f, -1.44721791e-01f, -6.05601072e-02f,
  7.04869442e-03f, 2.29331385e-02f, 1.41275182e-01f, 7.19617382e-02f, -6.55789971e-02f, -9.28779412e-03f, 5.28001040e-02f, 5.28854690e-02f, -4.86501865e-02f, -6.96813613e-02f,
  1.44361556e-01f, 3.23927775e-02f, -2.34469712e-01f, -1.26272708e-01f, 8.62392262e-02f, -6.06115721e-02f, 5.03432639e-02f, 4.46195118e-02f, -5.90833016e-02f, 1.33211151e-01f,
  -5.02107032e-02f, -2.88130753e-02f, 1.22966114e-02f, 1.61710665e-01f, 5.62982634e-02f, 9.17590931e-02f, 1.28492668e-01f, 8.79035369e-02f, -2.63496172e-02f, 9.66859162e-02f,
  2.48215478e-02f, 6.83772787e-02f, -2.01456156e-02f, 2.66947765e-02f, -7.06608817e-02f, -3.76268886e-02f, 6.77471980e-02f, 8.43297988e-02f, 9.09321569e-03f, -1.21870093e-01f,
  1.65572986e-01f, 9.73159373e-02f, 1.91643778e-02f, 2.62755454e-01f, 5.76913133e-02f, 1.62587792e-01f, 1.68603361e-01f, -7.00298399e-02f, -5.30566685e-02f, 2.37619760e-03f,
  -5.74710488e-01f, -2.35367626e-01f, 2.14602098e-01f, 1.94161683e-01f, 5.73106445e-02f, -7.80796036e-02f, 6.73464686e-02f, -7.66618326e-02f, -1.92502037e-01f, -9.39893443e-03f,
  -4.32390012e-02f, 5.18589579e-02f, -5.25863282e-02f, 1.02596223e-01f, 1.63893640e-01f, -7.28441477e-02f, 5.64944372e-02f, 1.44022086e-03f, -4.11429964e-02f, -2.16235682e-01f,
  1.18921742e-01f, -5.86089417e-02f, -8.72060880e-02f, -3.94576043e-03f, 8.30722824e-02f, -9.32619497e-02f, -1.52958194e-02f, -1.14527911e-01f, -1.99892148e-01f, 2.38581896e-02f,
  6.01404905e-01f, -4.51183319e-01f, -2.54955232e-01f, 1.00817591e-01f, -1.76242888e-01f, 2.73925141e-02f, -1.95006326e-01f, -5.85553385e-02f, 5.50901592e-02f, -2.39850730e-01f,
  -2.10963972e-02f, 3.99343431e-01f, 2.23095581e-01f, 2.64958113e-01f, 1.48675397e-01f, -2.02475637e-01f, -1.54206678e-01f, 5.27403727e-02f, 2.37781048e-01f, 1.78879816e-02f,
  -4.47384715e-02f, -8.02859589e-02f, -2.55448986e-02f, 5.62013797e-02f, -2.52569258e-01f, -1.23009766e-02f, -3.67246836e-01f, -1.42107964e-01f, -6.46980181e-02f, -2.64649034e-01f,
  -3.49710435e-02f, 3.89433876e-02f, 1.96149107e-02f, 9.73289534e-02f, -6.32859096e-02f, 7.12919086e-02f, -9.13632363e-02f, -2.90800095e-01f, 2.90441830e-02f, -2.43645217e-02f,
  9.76607949e-02f, -3.16147953e-02f, 9.15050507e-02f, -6.20591920e-03f, -1.27769843e-01f, 7.10054208e-03f, -2.30292737e-01f, 4.53443974e-02f, -4.10322286e-02f, -1.25527792e-02f,
  -8.59896094e-02f, -6.09289594e-02f, 1.00469306e-01f, 9.67146084e-02f, 1.44635830e-02f, 9.02434215e-02f, -1.28363878e-01f, -8.82560387e-02f, 1.41056001e-01f, -2.83196300e-01f,
  -1.29088815e-02f, 5.00231199e-02f, 1.17594644e-01f, -9.05068368e-02f, -5.01188263e-02f, 3.34764570e-02f, 1.27218127e-01f, 5.92478141e-02f, -8.07978287e-02f, 3.57985240e-03f,
  5.18365316e-02f, 2.66158096e-02f, 2.80834138e-02f, 6.44243583e-02f, 6.14830218e-02f, -3.56477574e-02f, -2.08752751e-02f, -6.25583157e-02f, 7.40224719e-02f, -5.97306304e-02f,
  1.08913638e-01f, 5.45315556e-02f, -2.59151775e-02f, 8.03067014e-02f, 3.02021466e-02f, 4.72405292e-02f, 3.51135037e-03f, -2.45506670e-02f, -3.28720920e-02f, -7.17352852e-02f,
  -7.90792983e-03f, 2.46273443e-01f, -5.39444610e-02f, 1.35482788e-01f, 2.12841504e-03f, -9.25968066e-02f, 3.01431362e-02f, 1.13443928e-02f, 1.18330615e-02f, 5.35657927e-02f,
  -5.07107191e-02f, -2.55517494e-02f, -1.08981542e-02f, -4.97090667e-02f, -6.16686884e-03f, -3.16036940e-02f, -2.55420692e-02f, 1.17319643e-01f, 1.33116618e-01f, -1.24642581e-01f,
  -1.59107894e-01f, 1.15212366e-01f, 8.84564966e-02f, 1.50780812e-01f, -2.56871269e-03f, 2.08332539e-01f, -4.66529429e-02f, 5.34775713e-03f, 3.27459604e-01f, -8.39092433e-02f,
  -3.93120080e-01f, 2.05407605e-01f, 1.87577784e-01f, -1.21437006e-01f, 2.56662741e-02f, -8.08535516e-02f, 1.80883035e-02f, -1.18722156e-01f, -7.95325413e-02f, 1.92984626e-01f,
  1.65126219e-01f, -1.17780678e-02f, -3.23929638e-02f, -2.70772655e-03f, -3.10197957e-02f, 1.95300549e-01f, 2.51523107e-01f, -1.04699023e-01f, -3.45723867e-01f, -2.34816208e-01f,
  2.09847186e-02f, -1.14781335e-01f, -2.51258254e-01f, -1.08177193e-01f, 1.63528509e-02f, -1.10779174e-01f, 1.96854562e-01f, -5.45765609e-02f, 1.24485396e-01f, 3.91777784e-01f,
  1.61579162e-01f, 3.07850242e-02f, 1.23803683e-01f, -7.78069124e-02f, 5.06890975e-02f, -4.08839546e-02f, 1.89104453e-02f, 1.66272789e-01f, -4.68880348e-02f, -4.88250256e-02f,
  1.76054209e-01f, 1.05969146e-01f, 1.78842582e-02f, -1.74398664e-02f, -1.49971545e-01f, -4.57254872e-02f, -1.81418210e-01f, -1.63493663e-01f, -1.37531027e-01f, -2.39546269e-01f,
  7.86640216e-03f, 1.10311456e-01f, -1.25036528e-03f, -1.29384957e-02f, 4.50773127e-02f, -1.52552843e-01f, 2.16326043e-02f, -1.03828132e-01f, -5.89767396e-02f, -8.10053721e-02f,
  1.03572018e-01f, 1.41598120e-01f, -8.19074959e-02f, 1.06883563e-01f, 3.85973379e-02f, 1.31445557e-01f, 1.08547114e-01f, -4.38953703e-03f, -3.51680652e-03f, -9.00352597e-02f,
  -3.84151302e-02f, -6.64582551e-02f, 5.07247336e-02f, -2.97900266e-03f, 7.41952211e-02f, -1.06287695e-01f, -2.29476020e-02f, 3.25409621e-02f, -9.09818709e-03f, -1.97080226e-04f,
  -8.32119361e-02f, 4.65508960e-02f, 2.92909164e-02f, -6.48818240e-02f, -5.13930852e-03f, 9.83251482e-02f, 1.81152284e-01f, -9.31125507e-02f, -6.03769645e-02f, 7.65300691e-02f,
  -1.70167729e-01f, 9.28854048e-02f, -5.27358567e-03f, -8.86550453e-03f, 1.29827589e-01f, 5.14271706e-02f, 8.66750777e-02f, 2.47756951e-02f, 3.73696014e-02f, -1.87014908e-01f,
  -6.80422932e-02f, -1.31407874e-02f, 1.20614864e-01f, 1.31784678e-02f, -2.07695276e-01f, 1.23469643e-02f, -5.53554371e-02f, -1.59436613e-01f, -2.26424634e-01f, -1.29472747e-01f,
  -1.02658987e-01f, -1.93250582e-01f, -1.57561898e-01f, -2.18293414e-01f, -2.04191372e-01f, -1.89492539e-01f, -1.44439399e-01f, -4.29593399e-02f, -1.83869392e-01f, -1.95673421e-01f,
  -8.01655650e-02f, 3.22552592e-01f, 2.35968083e-01f, -2.87556589e-01f, 1.79746330e-01f, 2.66258150e-01f, 5.98204076e-01f, 1.42289922e-01f, -1.45103812e-01f, 9.65766534e-02f,
  1.56014740e-01f, -3.79595429e-01f, -1.86869502e-01f, -1.38240770e-01f, 2.03238577e-01f, 2.22426400e-01f, 4.05739807e-02f, -2.57539265e-02f, -2.00803772e-01f, 1.94799304e-02f,
  -6.93102702e-02f, 4.42865829e-04f, -2.33223196e-02f, -1.53573707e-01f, -5.95385619e-02f, -1.83865562e-01f, 1.41590402e-01f, 1.66949302e-01f, 1.74191535e-01f, -1.76984400e-01f,
  -2.37350047e-01f, 3.96282077e-01f, -2.33798981e-01f, -1.93201825e-01f, 3.45692113e-02f, -1.83264744e-02f, 3.01151592e-02f, 7.58743053e-03f, -4.25327644e-02f, -6.62620589e-02f,
  1.18049905e-02f, -9.97383799e-03f, 6.80101737e-02f, 1.42048866e-01f, 7.15388730e-02f, 1.36764720e-02f, 6.78607747e-02f, 1.75457299e-02f, 4.39600945e-02f, 6.24574237e-02f,
  9.04184952e-02f, 5.21132071e-03f, 3.04425657e-02f, 5.91830947e-02f, 9.84184146e-02f, -1.07063353e-01f, -7.55990893e-02f, -9.52931494e-02f, 4.15522754e-02f, -1.19276911e-01f,
  -1.77567214e-01f, -7.27509111e-02f, 9.07230377e-02f, 6.86191991e-02f, -1.82067547e-02f, -5.47941364e-02f, -1.55872861e-02f, -1.63997933e-02f, -2.54804604e-02f, -6.41405135e-02f,
  -9.38317627e-02f, -5.32786436e-02f, -9.50805992e-02f, 6.93099797e-02f, -7.57246986e-02f, 2.24560983e-02f, 6.82249516e-02f, 1.31464943e-01f, 9.45240706e-02f, 2.74631716e-02f,
  -7.66488463e-02f, 2.04145219e-02f, -2.63871215e-02f, -6.43188506e-02f, 1.23577602e-01f, -1.95225757e-02f, -1.38509870e-01f, 1.16011307e-01f, -1.61536142e-01f, 3.82324494e-02f,
  -3.04246545e-01f, 3.66877079e-01f, -2.28477255e-01f, -6.19316753e-03f, 9.73323584e-02f, 3.56860235e-02f, -4.01678197e-02f, 2.12503970e-02f, -7.14970753e-02f, -5.47900274e-02f,
  2.01334640e-01f, -3.49509716e-02f, 9.00799632e-02f, 1.16696112e-01f, -1.31119430e-01f, 5.06066578e-03f, -1.26628801e-01f, -9.78709832e-02f, 3.05928779e-03f, -9.24382508e-02f,
  9.46826953e-03f, -1.23739071e-01f, -1.61111638e-01f, -1.74676865e-01f, -3.24468732e-01f, -3.96601468e-01f, -6.22448623e-02f, -7.87899867e-02f, -1.44741656e-02f, -2.07718208e-01f,
  -3.58316511e-01f, -3.20777982e-01f, 4.00984943e-01f, -1.71221830e-02f, -2.48024523e-01f, -3.52995664e-01f, -6.02485538e-01f, -2.52743483e-01f, 3.55027281e-02f, -3.28676254e-01f,
  -2.26064816e-01f, -7.61825293e-02f, 3.18159200e-02f, 1.35050640e-01f, -6.18603230e-02f, -1.16704643e-01f, 8.00112486e-02f, 3.94919097e-01f, 1.14657953e-01f, -4.55217771e-02f,
  -8.75710621e-02f, 1.69862047e-01f, 3.85277599e-01f, 2.16148064e-01f, 4.10369858e-02f, 1.75945505e-01f, 2.92880327e-01f, 2.21046835e-01f, 3.83839421e-02f, 8.93672928e-02f,
  1.15928285e-01f, -1.05371669e-01f, 7.41462782e-03f, -3.82591262e-02f, -3.28676365e-02f, -1.33244917e-01f, -8.26886892e-02f, 1.72077700e-01f, -6.98138997e-02f, 5.67068718e-02f,
  -1.54325917e-01f, -1.71334773e-01f, -5.71073182e-02f, 6.55125007e-02f, 7.96255991e-02f, -3.42592783e-02f, 1.00563273e-01f, 1.64758131e-01f, 1.19442165e-01f, -1.87610462e-01f,
  -2.04844043e-01f, -1.78009912e-01f, 4.20371778e-02f, 7.53054991e-02f, -1.16334073e-01f, 9.52803791e-02f, 4.24319245e-02f, 1.50117964e-01f, 2.23035917e-01f, 4.39953171e-02f,
  -1.71646476e-02f, 2.31304616e-02f, -6.45687655e-02f, -1.06892735e-01f, -2.31360883e-01f, -3.22119631e-02f, -8.04057196e-02f, 6.80205524e-02f, 6.48442358e-02f, -9.47548673e-02f,
  -3.81852388e-02f, 5.09426557e-02f, 6.16132393e-02f, -2.53684632e-02f, 6.69719428e-02f, 1.06954323e-02f, -7.36287162e-02f, 1.36717945e-01f, 1.46968469e-01f, -8.19677860e-02f,
  1.29435109e-02f, 3.59756947e-02f, -5.05047990e-03f, 3.38529758e-02f, 7.31119933e-03f, 6.73904493e-02f, 1.16940632e-01f, 2.64777578e-02f, -6.42297640e-02f, 8.22153501e-03f,
  -4.92017269e-02f, 2.66676068e-01f, -2.57464647e-01f, -1.07117213e-01f, 2.28837859e-02f, 7.60141015e-02f, 7.86832795e-02f, -2.88703237e-02f, -6.51869401e-02f, -1.65574223e-01f,
  -1.00013323e-01f, -1.13111921e-01f, -6.82826042e-02f, 5.22992108e-03f, -1.58863962e-01f, -1.29073337e-01f, -1.37274340e-01f, -2.09877193e-02f, 4.60872911e-02f, -1.71664894e-01f,
  -1.56193420e-01f, -2.16777951e-01f, -2.17401460e-01f, -2.58109868e-01f, -6.85518235e-02f, -1.18591592e-01f, -1.48280069e-01f, -1.01919742e-02f, -1.73867941e-01f, -1.69290751e-01f,
  -1.52670503e-01f, -8.27248842e-02f, -2.10768655e-02f, 4.88438457e-01f, 3.52137089e-01f, 1.38044327e-01f, 9.31798071e-02f, 1.63579464e-01f, 2.38700017e-01f, 1.41127780e-01f,
  2.80875444e-01f, 4.60853815e-01f, 2.62860358e-01f, 3.30116719e-01f, 1.42752260e-01f, 2.48572156e-01f, 2.39814594e-01f, 7.02657457e-03f, 3.14677842e-02f, 2.13126659e-01f,
  2.81366676e-01f, -5.26789948e-02f, -1.58037126e-01f, -1.82152204e-02f, 1.97256804e-01f, 3.44136208e-01f, 9.54730511e-02f, 8.09918568e-02f, 2.12617591e-01f, 3.93308461e-01f,
  6.77992478e-02f, -7.63056874e-02f, 1.63439751e-01f, 7.09804595e-02f, -1.05890580e-01f, -2.30122119e-01f, -7.47336959e-03f, -3.05720996e-02f, -5.08721061e-02f, 1.85775920e-04f,
  1.13571687e-02f, -1.61858410e-01f, 1.11480542e-02f, -1.20266527e-01f, -2.56419539e-01f, -1.86547011e-01f, -2.00150952e-01f, 2.60584727e-02f, 1.49438798e-01f, 7.43799284e-02f,
  1.00638978e-01f, 5.23747876e-02f, 1.02867506e-01f, 7.74701908e-02f, -1.13140270e-01f, 8.96338895e-02f, -8.00317973e-02f, -4.47935313e-02f, -4.71791886e-02f, -4.46958840e-02f,
  1.95501700e-01f, 1.31821588e-01f, 1.06859393e-01f, -2.10740454e-02f, -2.29343940e-02f, -9.28352866e-03f, -1.25002593e-01f, 5.34148030e-02f, 2.47105826e-02f, -1.52996108e-01f,
  7.88672194e-02f, 1.59289882e-01f, 1.51219470e-02f, 8.40616152e-02f, 9.31685567e-02f, 7.42227510e-02f, 6.25169203e-02f, 8.00933968e-03f, -8.97945371e-03f, -3.88781019e-02f,
  -5.25313094e-02f, -7.45786801e-02f, -8.79604146e-02f, -1.50216788e-01f, -5.48521467e-02f, 1.54665262e-01f, 2.96495762e-03f, 3.64178419e-02f, -1.92543920e-02f, 7.89814219e-02f,
  1.96063116e-01f, 1.37571648e-01f, 1.90607801e-01f, 4.23598960e-02f, -1.49998471e-01f, -9.68932733e-02f, 2.23563939e-01f, 2.44007842e-03f, -8.40523988e-02f, 3.10622975e-02f,
  -1.22062199e-01f, -1.35090575e-03f, -8.84204432e-02f, -1.65827438e-01f, -1.05935849e-01f, -7.49523118e-02f, -7.95185491e-02f, 1.38407201e-01f, 1.37139678e-01f, -3.83706093e-02f,
  -1.08349383e-01f, 8.92621130e-02f, 7.57122226e-03f, -6.21054731e-02f, 6.19112588e-02f, 1.00627586e-01f, -1.46619514e-01f, -1.10453144e-01f, -1.90414667e-01f, -1.58229560e-01f,
  -6.71946943e-01f, -1.17521463e-02f, -9.25664231e-02f, -2.59998471e-01f, 1.11130126e-01f, 3.65258127e-01f, 2.58569539e-01f, 1.53744727e-01f, 1.62709365e-03f, -1.03861466e-01f,
  1.83930874e-01f, 1.95657998e-01f, -1.65321112e-01f, 5.24610206e-02f, -6.90020248e-02f, -2.44040638e-01f, -1.78092375e-01f, -1.88870072e-01f, 1.13698401e-01f, 4.14007545e-01f,
  1.72595769e-01f, -2.38160968e-01f, -3.42206985e-01f, -1.37454405e-01f, -4.32890989e-02f, -1.79838598e-01f, -2.62344748e-01f, -2.59540051e-01f, -1.08392216e-01f, -1.33126840e-01f,
  -2.60458916e-01f, 1.03900596e-01f, 1.64614514e-01f, 1.14114717e-01f, -1.10544190e-01f, -5.48247509e-02f, -8.79338905e-02f, -1.34903982e-01f, -1.08084513e-03f, -7.13643357e-02f,
  -5.53212799e-02f, 1.53620303e-01f, -1.06880516e-01f, 4.82867658e-02f, 1.97949465e-02f, 2.53629014e-02f, -3.55856679e-02f, -3.29469554e-02f, -3.42397951e-02f, 1.36708245e-01f,
  1.42518044e-01f, -2.03141533e-02f, -1.05941959e-01f, 1.14966430e-01f, 2.45594829e-01f, -8.19064304e-02f, -9.66617838e-02f, -4.70927246e-02f, -7.27792159e-02f, -2.50723690e-01f,
  9.28628966e-02f, -3.17830630e-02f, 1.38879821e-01f, 4.87023257e-02f, -8.51618964e-03f, 8.96732062e-02f, -1.29500091e-01f, 1.60771325e-01f, -3.77335735e-02f, -4.40446883e-02f,
  -9.17349383e-03f, -2.40200013e-02f, 4.57267128e-02f, -1.49338823e-02f, -1.16017237e-01f, 5.75614311e-02f, 5.64859658e-02f, 5.09085646e-03f, -1.60568476e-01f, 8.09602216e-02f,
  5.57416938e-02f, -1.03762075e-02f, -1.06683686e-01f, 1.44256905e-01f, 5.92699721e-02f, -5.30589893e-02f, -1.23192426e-02f, 7.11890981e-02f, -1.93473455e-02f, 7.90336207e-02f,
  -4.35404420e-01f, 7.99461827e-02f, -3.13002974e-01f, 1.03426330e-01f, -9.51791704e-02f, 3.94251989e-03f, 1.14645511e-02f, 3.38212401e-02f, -2.17585061e-02f, -1.14998132e-01f,
  1.01469301e-01f, 1.84295159e-02f, 2.31672749e-02f, 5.83282225e-02f, 1.32361472e-01f, 6.89318627e-02f, -2.65556499e-02f, -1.87358037e-02f, 1.52393043e-01f, -4.76020053e-02f,
  -1.37240645e-02f, -8.72309282e-02f, -1.94417760e-01f, 1.87592041e-02f, -5.91360405e-02f, -2.57661790e-01f, -1.90555260e-01f, -7.56447688e-02f, -3.23752761e-01f, -5.23446858e-01f,
  -8.59380960e-02f, 4.09345239e-01f, -3.65255624e-01f, 6.09187260e-02f, -2.75953770e-01f, -2.85873026e-01f, -1.39672756e-01f, 1.64327279e-01f, 1.79873556e-01f, 8.62636417e-02f,
  9.05378163e-03f, -1.06728531e-01f, -5.70069775e-02f, -2.07736611e-01f, -8.66839886e-02f, 7.02123269e-02f, -1.68497086e-01f, -3.34114581e-01f, -4.79040563e-01f, -4.58578259e-01f,
  -2.72641331e-01f, -1.97580621e-01f, -1.87728658e-01f, -2.59279478e-02f, -6.14387952e-02f, -1.02060989e-01f, 6.74754381e-02f, -9.83601585e-02f, -2.83189178e-01f, -2.05431178e-01f,
  -9.69959348e-02f, -3.28195065e-01f, -5.06417863e-02f, 1.91210222e-03f, 1.33742452e-01f, 1.23922050e-01f, -8.07721317e-02f, 7.21257702e-02f, 8.86631459e-02f, 2.10590679e-02f,
  -1.24798290e-01f, -9.26118940e-02f, -5.68894558e-02f, 7.37618431e-02f, -1.59284547e-02f, -9.04012024e-02f, 4.13071588e-02f, -6.46809489e-02f, -3.84934433e-02f, 1.33677170e-01f,
  -2.91871764e-02f, -2.16431662e-01f, -1.13401122e-01f, 1.36830704e-03f, 4.63229045e-03f, -2.04655543e-01f, 2.07578763e-02f, -6.77356645e-02f, -1.40858442e-01f, 2.71493882e-01f,
  3.18153687e-02f, 6.10185191e-02f, 1.73738245e-02f, 3.23211737e-02f, 1.02456950e-01f, 7.69169182e-02f, -2.70983074e-02f, 6.87673986e-02f, 4.82506119e-03f, 5.22278212e-02f,
  3.42929289e-02f, -4.15138826e-02f, -1.31569635e-02f, 2.47103274e-02f, -1.19691364e-01f, -1.52261272e-01f, -1.04814512e-03f, -7.65882656e-02f, 7.77008682e-02f, 1.04467338e-02f,
  2.09007282e-02f, 9.59820896e-02f, -1.62952729e-02f, 3.65307853e-02f, -1.63030624e-02f, 1.03449032e-01f, -4.31559868e-02f, 4.79702540e-02f, -5.56978583e-03f, -8.35633278e-02f,
  2.65386641e-01f, -4.21060115e-01f, 1.55572176e-01f, -9.39108357e-02f, -1.86033864e-02f, 1.51478633e-01f, 4.38897610e-02f, 6.89747483e-02f, 2.94928253e-02f, -7.73775876e-02f,
  1.85107701e-02f, 4.86461259e-02f, -8.05140138e-02f, -2.58357190e-02f, 4.21649702e-02f, -1.46239027e-01f, 7.03525841e-02f, 8.80481452e-02f, -7.84003958e-02f, 1.29216254e-01f,
  2.27087259e-01f, 7.56178647e-02f, 7.98783228e-02f, 1.63617641e-01f, 3.43000703e-02f, -1.16367884e-01f, 2.05952123e-01f, 1.74240559e-01f, -8.99210051e-02f, 3.16559553e-01f,
  4.57427174e-01f, 2.86292672e-01f, 1.21228300e-01f, -3.68413441e-02f, -1.27530560e-01f, -1.29346296e-01f, 2.38917843e-02f, -4.21302505e-02f, -1.45995036e-01f, 1.29848674e-01f,
  -1.66129670e-03f, -1.61943242e-01f, -2.59471089e-02f, -1.26276031e-01f, 4.70878463e-03f, 1.36900917e-01f, -3.13264914e-02f, 1.99148003e-02f, -1.31853729e-01f, -6.42007589e-03f,
  -1.24280758e-01f, 1.20599985e-01f, 8.15016776e-02f, 5.68087734e-02f, 5.59657514e-02f, -1.45371959e-01f, -4.07772250e-02f, 2.07297027e-01f, 1.05785311e-03f, 2.67820597e-01f,
  2.61064887e-01f, 4.48066145e-01f, -2.46241823e-01f, -7.56733045e-02f, 2.21650749e-01f, 6.20406941e-02f, 1.03914879e-01f, 1.29338890e-01f, 7.14990869e-02f, 1.23306364e-01f,
  1.06724575e-01f, 2.14120269e-01f, 1.51465639e-01f, -6.07876049e-04f, 9.56206918e-02f, 1.70109808e-01f, 1.53865665e-01f, 2.06440791e-01f, -4.54435796e-02f, 1.01155639e-01f,
  -4.99255061e-02f, 1.01300217e-01f, 6.73105717e-02f, -1.17969140e-01f, 1.13589093e-01f, -4.58824076e-02f, 4.65992205e-02f, 8.67130160e-02f, -6.84970617e-02f, 1.37449324e-01f,
  -5.65535426e-02f, 8.08054432e-02f, 1.69653669e-01f, -2.72296742e-02f, 9.83082578e-02f, 1.00964837e-01f, 1.40486121e-01f, -4.39670384e-02f, -1.54165374e-02f, 1.11934803e-01f,
  2.06699199e-03f, -6.68288991e-02f, 2.89008711e-02f, -3.38923298e-02f, -1.69645682e-01f, -5.07155880e-02f, 2.59333104e-03f, 9.15041491e-02f, 6.59067258e-02f, 8.68559163e-03f,
  -1.97825991e-02f, 4.84691653e-03f, 1.11025438e-01f, 1.10773496e-01f, -3.47056752e-03f, 2.50127967e-02f, -1.41380243e-02f, 1.02698214e-01f, 7.80653208e-02f, 6.80013448e-02f,
  -1.77778274e-01f, -1.48079589e-01f, 2.86334734e-02f, 3.21992598e-02f, 3.10590938e-02f, 1.13325290e-01f, -7.75318146e-02f, -1.89250752e-01f, -1.31300986e-01f, -1.29112462e-02f,
  -2.00953428e-02f, 1.12086482e-01f, 4.77202497e-02f, -1.75093152e-02f, -5.08744642e-02f, -1.14548534e-01f, 3.91197354e-02f, -1.96277663e-01f, -8.53733346e-02f, -2.71724705e-02f,
  -7.14450628e-02f, -2.84831405e-01f, -2.60594428e-01f, -2.29733750e-01f, -4.24522199e-02f, -2.52176642e-01f, -1.50940001e-01f, -1.34339869e-01f, -1.77119151e-01f, -1.62635386e-01f,
  -6.95956171e-01f, 2.26623669e-01f, 2.78123945e-01f, -3.11267376e-01f, 9.90008637e-02f, 1.14928931e-01f, 8.74510854e-02f, -9.48885679e-02f, -1.51690677e-01f, 2.60430723e-01f,
  6.61302656e-02f, -2.35998809e-01f, -9.66475829e-02f, -2.82731988e-02f, -2.83811927e-01f, -3.36387530e-02f, -1.15624584e-01f, -1.82794541e-01f, -3.64370346e-01f, -1.84161901e-01f,
  -2.33817995e-01f, -3.57693523e-01f, -4.16942179e-01f, -2.51123697e-01f, 1.00188088e-02f, -1.62888065e-01f, 1.74944848e-01f, -2.66937595e-02f, 7.64486641e-02f, 3.21967080e-02f,
  1.72829106e-01f, 2.62317330e-01f, 1.05654247e-01f, -1.43677399e-01f, -4.99712415e-02f, -1.30023509e-01f, -8.35905522e-02f, 3.88324782e-02f, -4.21258211e-02f, 9.25481543e-02f,
  -1.72059666e-02f, 6.86633512e-02f, -1.59410343e-01f, 4.36412133e-02f, -1.11048587e-01f, 8.50292330e-04f, 5.23008965e-03f, -4.58101928e-02f, 1.34529084e-01f, 2.80681401e-01f,
  9.52719450e-02f, 9.57635865e-02f, 4.94423695e-02f, 7.39888921e-02f, 8.93071070e-02f, -1.08241692e-01f, 9.36023891e-02f, 1.28875419e-01f, 1.18259571e-01f, 6.55639693e-02f,
  -3.41665521e-02f, -1.11884832e-01f, 3.49443592e-02f, 2.94805374e-02f, -1.70864929e-02f, -3.91461477e-02f, -1.26395851e-01f, -5.19768298e-02f, -1.07736617e-01f, -5.01072519e-02f,
  9.52420384e-02f, 1.29971921e-01f, -6.37307391e-02f, -3.00392266e-02f, -5.26793525e-02f, 7.55235329e-02f, -1.37005821e-01f, -2.39032879e-02f, 6.40511066e-02f, 1.13848016e-01f,
  4.49174158e-02f, 3.51798460e-02f, 5.57757057e-02f, -1.02752831e-03f, 1.83572859e-01f, -2.03293972e-02f, 1.00082740e-01f, 1.39612421e-01f, -7.56437704e-02f, 2.05700770e-02f,
  -1.89455137e-01f, 1.27287149e-01f, -6.35996461e-02f, -3.00966091e-02f, 1.08751938e-01f, 8.79776552e-02f, 2.19141379e-01f, 3.23414057e-02f, 1.45568967e-01f, 1.42504126e-01f,
  1.15520423e-02f, -4.21489030e-02f, -8.57159204e-04f, 3.61786969e-02f, -7.74873346e-02f, -1.27835404e-02f, -2.63369270e-02f, -1.69852320e-02f, 1.23478770e-01f, 9.02739614e-02f,
  3.26935388e-02f, -9.86605808e-02f, -2.21793383e-01f, 1.20889638e-02f, 3.09366509e-02f, -1.24896854e-01f, 2.49406043e-02f, 3.06465314e-03f, 4.05115858e-02f, -8.01844671e-02f,
  2.63290286e-01f, -8.28998908e-02f, 2.60865629e-01f, 1.68172553e-01f, 6.01781942e-02f, 1.24894634e-01f, 2.64306724e-01f, 1.50706246e-01f, -1.48033680e-04f, -1.22588519e-02f,
  -1.51358377e-02f, -5.55369677e-03f, 5.44076078e-02f, 1.62914321e-02f, 1.13039128e-01f, -1.02611028e-01f, -1.23948731e-01f, 8.06496963e-02f, 3.38887393e-01f, 7.48621374e-02f,
  -1.55804474e-02f, -3.55284661e-02f, 8.39055777e-02f, -7.85293058e-03f, -1.98549211e-01f, -1.60589069e-02f, -6.20673895e-02f, -1.88740894e-01f, -1.84771791e-01f, -3.43519986e-01f,
  1.56619385e-01f, -1.39980480e-01f, 4.11616676e-02f, -1.68102011e-01f, -8.38705990e-03f, -2.79867779e-02f, 6.45140633e-02f, 6.92753121e-02f, -6.46157488e-02f, -3.91475782e-02f,
  -5.48527949e-02f, 2.22977623e-02f, 7.13704377e-02f, 8.91109183e-03f, 3.77408974e-02f, -1.28471330e-01f, -1.98379472e-01f, 1.49188265e-02f, 4.28669490e-02f, 4.21845429e-02f,
  -9.81114209e-02f, 1.43280271e-02f, -7.35630654e-03f, -1.69867948e-02f, -2.63719242e-02f, -4.54232842e-02f, 3.45021039e-02f, -5.90017177e-02f, 3.17760669e-02f, 1.63769051e-02f,
  -6.16095141e-02f, -3.23735252e-02f, 5.01606539e-02f, -8.08007419e-02f, -2.10335460e-02f, -3.94791998e-02f, -4.78859060e-02f, -4.31495951e-03f, -6.50823861e-02f, 9.69479457e-02f,
  2.29375847e-02f, -1.30717801e-02f, 2.19217211e-01f, 1.98209539e-01f, 1.73237205e-01f, 5.44135943e-02f, 7.06121549e-02f, 1.24012120e-02f, -4.06295247e-02f, 4.00003865e-02f,
  1.98088378e-01f, 1.45934284e-01f, 8.44379663e-02f, 1.48319632e-01f, 8.93606916e-02f, 1.01649143e-01f, 4.43644449e-03f, 1.12091608e-01f, 6.15179259e-03f, 2.76784096e-02f,
  1.31348729e-01f, -3.73914652e-02f, -1.25720933e-01f, -7.81863406e-02f, -2.20547207e-02f, -2.56863665e-02f, 3.13418396e-02f, -6.07463643e-02f, -1.08074740e-01f, -9.78026818e-03f,
  -9.81433541e-02f, 6.25020266e-02f, -2.39166468e-02f, 2.61316681e-03f, 7.11722150e-02f, 8.45504254e-02f, -1.28294900e-01f, 1.40874073e-01f, -1.85496528e-02f, -2.44985544e-03f,
  -3.89834382e-02f, 7.29637071e-02f, 1.30475417e-01f, 7.72868618e-02f, 6.78181797e-02f, 1.01569571e-01f, 1.27380744e-01f, 8.02140608e-02f, -3.83285508e-02f, 1.54543832e-01f,
  2.07105562e-01f, -2.61681944e-01f, -4.01863515e-01f, 1.44016787e-01f, -2.78849397e-02f, 5.34002110e-03f, -3.37381840e-01f, 1.10636629e-01f, 2.49967232e-01f, -1.57031268e-01f,
  -9.31206718e-02f, 2.40003034e-01f, -3.96051444e-03f, -1.01478443e-01f, -7.07365721e-02f, -5.06440520e-01f, -3.03819478e-01f, -1.16919301e-01f, 1.90101519e-01f, 1.61481097e-01f,
  1.34047613e-01f, 1.00140549e-01f, 7.43585005e-02f, 1.74393564e-01f, -1.54384924e-02f, 8.17868933e-02f, -3.20874423e-01f, -2.62867957e-02f, -2.72475392e-01f, -3.10415775e-01f,
  -6.24268651e-02f, 1.62561700e-01f, -6.77896068e-02f, 2.50389874e-01f, -7.24108070e-02f, 1.29805878e-01f, 1.71375852e-02f, -1.56336740e-01f, 8.99316277e-03f, -1.86968502e-02f,
  1.84608564e-01f, 7.29007497e-02f, 7.37458616e-02f, 1.37966096e-01f, -3.60521823e-02f, 1.25080094e-01f, 7.07142651e-02f, -1.05845714e-02f, -1.28072783e-01f, 5.53071722e-02f,
  -2.13260739e-03f, 3.87674011e-02f, -6.42587245e-02f, -1.04315810e-01f, -1.94344614e-02f, -5.34061491e-02f, -5.03510311e-02f, 3.14295404e-02f, -2.00512633e-01f, -2.48438850e-01f,
  -1.54969078e-02f, 6.67868406e-02f, -2.19492167e-02f, 1.33234799e-01f, 8.73199627e-02f, -6.89837262e-02f, -4.00297008e-02f, -8.80689919e-03f, -2.04802901e-02f, -7.85906166e-02f,
  9.49387774e-02f, -1.84395134e-01f, -6.85034692e-02f, -1.35067850e-01f, -7.18007907e-02f, 7.90011734e-02f, 6.72000572e-02f, -8.66161212e-02f, 9.71826762e-02f, 5.03715873e-02f,
  2.58749607e-03f, 1.75521784e-02f, 9.30713341e-02f, 8.34244490e-02f, -4.43595648e-02f, 4.48074304e-02f, 6.72490895e-02f, -5.04438020e-02f, 1.02178529e-01f, 1.90545171e-02f,
  6.42670840e-02f, -1.46053970e-01f, -8.54963884e-02f, -5.99145107e-02f, 1.84693036e-03f, 1.40354961e-01f, 8.65019485e-02f, 4.20270190e-02f, 1.05972700e-01f, 6.08287379e-02f,
  1.59605503e-01f, 1.09683484e-01f, -2.00248100e-02f, -3.06206383e-02f, -8.98534432e-02f, 4.54318002e-02f, -5.87145053e-03f, 1.11351172e-02f, 3.34426425e-02f, 1.38627529e-01f,
  4.14895527e-02f, -6.89269453e-02f, 4.31756601e-02f, -8.44254121e-02f, -1.14845922e-02f, 9.20877885e-03f, -1.11034088e-01f, -1.13403983e-01f, -1.00134842e-01f, -2.29445800e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.11553469e-01f, 2.55272567e-01f, 3.96911241e-02f, 2.39524990e-01f, 1.39651835e-01f, -1.70881469e-02f, 1.18938178e-01f, 1.20959312e-01f, -1.23742461e-01f, -1.04141913e-01f,
  -1.94732830e-01f, -2.55631432e-02f, -3.46420407e-02f, 1.68687120e-01f, 7.09210616e-03f, 3.92677784e-02f, 9.46414471e-02f, 1.69589698e-01f, 6.31467178e-02f, 1.81080867e-02f,
  -7.89208412e-02f, 2.10179865e-01f, 1.17027372e-01f, 1.16228454e-01f, -4.83246781e-02f, 1.06407329e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.49087414e-01f, 4.77047078e-02f, 8.50034226e-03f, 4.87047732e-02f, 1.32396311e-01f, 6.31148443e-02f, 1.70005903e-01f, 7.51255229e-02f, 1.99465677e-01f, 2.27053627e-01f,
  1.27121747e-01f, 1.14841893e-01f, 4.12341990e-02f, 2.72180280e-03f, -1.17862254e-01f, -5.15679494e-02f, -1.79785322e-02f, -6.31474182e-02f, 3.78253944e-02f, -2.34018452e-02f,
  3.62935394e-01f, -5.36091104e-02f, -8.59669819e-02f, 1.07985452e-01f, -1.31161720e-01f, 1.75505355e-01f, 1.41231224e-01f, 2.11899757e-01f, 1.94227882e-02f, -6.10975474e-02f,
  -6.60134014e-03f, -7.03896582e-02f, -4.54924162e-03f, -7.81608373e-02f, 1.76119972e-02f, 8.44874457e-02f, -1.40012845e-01f, 6.31022966e-03f, 4.38611627e-01f, -7.22891167e-02f,
  1.52781412e-01f, -9.16844830e-02f, 3.76534984e-02f, -8.92778486e-03f, -2.72723377e-01f, -1.52194723e-01f, 2.64150258e-02f, -5.13428301e-02f, -3.88615206e-02f, 5.93204808e-04f,
  -2.49258980e-01f, 1.55481055e-01f, -1.92150176e-01f, -3.00146788e-01f, 1.74649656e-01f, 2.51323670e-01f, 1.02510020e-01f, -1.76625237e-01f, -4.49653380e-02f, 7.95788765e-02f,
  3.60273421e-01f, 2.09542915e-01f, -1.42952487e-01f, -2.44630948e-02f, 1.36264637e-01f, 1.89735088e-02f, -1.07115522e-01f, -1.61724761e-01f, -8.42364505e-02f, -6.24439865e-02f,
  -1.10368803e-02f, -6.36266023e-02f, -4.54208404e-02f, -7.45385140e-02f, 1.51926026e-01f, 5.90453558e-02f, 9.82549489e-02f, 4.94775586e-02f, 5.53721786e-02f, 1.42581956e-02f,
  2.00995170e-02f, 2.63518523e-02f, 6.04204722e-02f, -1.27624333e-01f, -1.81343019e-01f, 1.41636178e-01f, -6.86053187e-02f, -4.65800650e-02f, -3.88682112e-02f, -1.40248574e-02f,
  7.62770027e-02f, -1.05898283e-01f, -3.56672220e-02f, 4.02078666e-02f, 3.65668274e-02f, 1.30047724e-01f, -1.09400824e-01f, 1.04996413e-01f, 1.12531938e-01f, 1.77123733e-02f,
  -2.74404008e-02f, 8.97967517e-02f, -2.97588706e-01f, -1.43827304e-01f, -1.18836567e-01f, 2.85309721e-02f, 9.49663818e-02f, 5.71103022e-02f, 2.40519643e-01f, 2.09343076e-01f,
  -1.26955416e-02f, 2.71840878e-02f, 6.52844831e-02f, -1.78608134e-01f, 3.08558103e-02f, -2.33356673e-02f, 7.49588460e-02f, 2.77011931e-01f, -2.89574176e-01f, -1.65641665e-01f,
  -1.79784074e-01f, 1.68815739e-02f, 1.53470850e-02f, -1.51217341e-01f, -2.16227189e-01f, -3.33286971e-01f, 5.31103574e-02f, 1.19970487e-02f, -2.18952317e-02f, -4.49231863e-02f,
  2.42831577e-02f, -1.49940848e-01f, -4.36115228e-02f, -2.03446954e-01f, -7.06053674e-02f, -5.13416566e-02f, 6.40295297e-02f, 8.52394383e-03f, -1.05586439e-01f, -3.22180651e-02f,
  1.20579386e-02f, -4.80729118e-02f, -1.23467565e-01f, -1.25338426e-02f, 3.05023324e-02f, -5.32376468e-02f, -4.89603588e-03f, 1.07059233e-01f, 1.74832359e-01f, -1.18195705e-01f,
  1.05158627e-01f, 1.67611971e-01f, -2.41939891e-02f, 1.48824498e-01f, 1.56913713e-01f, 1.22337416e-02f, 7.19431341e-02f, 5.55467792e-02f, 5.66728711e-02f, 1.63029898e-02f,
  -4.90410887e-02f, -9.84837953e-03f, 6.73050731e-02f, -6.32821172e-02f, -1.04362415e-02f, -1.91380396e-01f, 1.16744943e-01f, 1.21578492e-01f, 1.39683113e-01f, 5.32651283e-02f,
  2.82523986e-02f, -2.12850854e-01f, -1.95159212e-01f, -1.81432068e-01f, 1.56320572e-01f, -3.24014015e-02f, -2.00282950e-02f, -2.37562478e-01f, -5.74986450e-03f, -3.48981708e-01f,
  1.10482708e-01f, -1.09456226e-01f, 2.73626950e-02f, -5.98812383e-03f, 2.50839800e-01f, -1.52492896e-01f, -2.66321525e-02f, -2.53938884e-01f, 2.42418274e-01f, 3.82600762e-02f,
  -2.35243365e-01f, -1.77535504e-01f, -5.02551496e-02f, -2.53302511e-02f, 7.51328915e-02f, -4.46393825e-02f, -2.09706221e-02f, 2.83823851e-02f, -1.15392935e-02f, 2.15786342e-02f,
  -1.17191046e-01f, 2.52717119e-02f, -1.03244163e-01f, -1.10376425e-01f, -9.18262005e-02f, -6.35933205e-02f, 1.21304311e-01f, -9.80260149e-02f, -1.03607010e-02f, 1.37367740e-01f,
  1.42077059e-02f, 1.49055675e-01f, 2.68412679e-01f, 6.47060107e-03f, -1.90182269e-01f, 7.88455829e-04f, -5.19690178e-02f, -3.20829265e-02f, -8.84842277e-02f, 1.00193076e-01f,
  1.25310108e-01f, -2.16061234e-01f, 6.30287006e-02f, -2.05010816e-01f, -2.46190224e-02f, 8.08403268e-02f, -4.23222402e-04f, 1.33846626e-01f, -5.22834696e-02f, 8.24582875e-02f,
  1.24826215e-01f, 1.21702619e-01f, -2.10040063e-02f, -7.17666522e-02f, 1.88443542e-01f, -7.69429281e-02f, -1.10458955e-01f, -1.57943919e-01f, -1.42761320e-01f, -9.76109803e-02f,
  -3.33602950e-02f, 3.47650684e-02f, 5.54860160e-02f, 1.97312057e-01f, 8.20775256e-02f, -2.12666810e-01f, 2.56726742e-01f, 2.78577119e-01f, -1.27580181e-01f, -6.40085936e-02f,
  8.91869813e-02f, -1.27626404e-01f, 1.45505577e-01f, 2.43108898e-01f, -8.98070708e-02f, -1.74020305e-01f, -9.74934921e-02f, -5.56666888e-02f, -8.43881965e-02f, 6.19678234e-04f,
  6.45885020e-02f, -7.74808154e-02f, -1.99910384e-02f, 3.77154239e-02f, 5.14816716e-02f, 2.35324223e-02f, -6.85299411e-02f, 3.02630160e-02f, 4.42009568e-02f, -5.18837869e-02f,
  -3.97310331e-02f, -1.15038641e-01f, -1.74027815e-01f, 9.88405664e-03f, 4.82378788e-02f, 4.83355597e-02f, -4.81141172e-03f, -1.04888342e-01f, -4.03439030e-02f, 2.44692825e-02f,
  -8.32455754e-02f, 2.40782779e-02f, 2.78730422e-01f, -2.45118532e-02f, 1.31086066e-01f, 1.02489822e-01f, 2.06887890e-02f, 4.93725156e-03f, -6.23630956e-02f, 1.87561721e-01f,
  3.95073295e-02f, 9.11835879e-02f, 1.18942156e-01f, -1.90885365e-02f, 6.85540363e-02f, -2.08854880e-02f, -8.98660906e-03f, 1.17056422e-01f, -1.03206627e-01f, -1.54907435e-01f,
  -1.84082299e-01f, -2.04092085e-01f, 1.20622866e-01f, 3.36287290e-01f, -2.54679788e-02f, 1.79175094e-01f, -2.29127482e-01f, -2.00067207e-01f, 9.21821222e-02f, 5.28022181e-03f,
  -1.70634370e-02f, 1.91214487e-01f, 2.55214691e-01f, 2.46353950e-02f, 3.84462714e-01f, 1.20331012e-01f, 1.03201956e-01f, 1.48586258e-01f, 3.11811059e-03f, 1.62072331e-01f,
  -8.66011679e-02f, 1.60350129e-01f, 3.28729786e-02f, 1.13714240e-01f, 9.17530712e-03f, 2.77304128e-02f, 9.94173810e-02f, -6.18719533e-02f, 3.56847681e-02f, 4.64287326e-02f,
  1.79242477e-01f, -4.36378010e-02f, 1.07712701e-01f, 4.79992218e-02f, -1.31077334e-01f, -2.94093695e-02f, -4.97175893e-03f, 5.28195389e-02f, 1.27114682e-02f, -1.17813408e-01f,
  -1.32589206e-01f, 9.10203308e-02f, 3.92296957e-03f, 8.11426193e-02f, 2.66816076e-02f, -1.51936531e-01f, -1.30389094e-01f, -5.97248040e-02f, -1.25864148e-01f, 1.82085305e-01f,
  -1.17426716e-01f, 2.66687363e-01f, -1.85010970e-01f, -5.12074307e-02f, -1.20916292e-01f, 1.40992522e-01f, -2.05734387e-01f, 4.76398133e-02f, -9.16874036e-02f, -1.63968906e-01f,
  -3.81069370e-02f, 4.57828455e-02f, -4.11047280e-01f, -1.36757677e-03f, 1.33989111e-01f, 1.53809845e-01f, -1.99890565e-02f, 4.76498045e-02f, -9.53627750e-02f, -1.04796505e-02f,
  -1.45218596e-01f, 4.94978810e-03f, 1.12863347e-01f, -1.13614880e-01f, -1.64685041e-01f, 3.88922878e-02f, 2.70245522e-01f, -1.14185162e-01f, -2.29002714e-01f, 1.08442418e-01f,
  1.50419638e-01f, -1.45236075e-01f, 2.43653134e-01f, -4.67367563e-03f, -1.05092794e-01f, -1.84547395e-01f, 1.43332228e-01f, -9.31744203e-02f, 4.56577912e-02f, -1.96314454e-02f,
  -1.21592797e-01f, 2.20121965e-02f, -3.76928337e-02f, -8.80175158e-02f, -8.90325829e-02f, 4.79784934e-03f, -1.47407323e-01f, -1.16296463e-01f, 1.34771559e-02f, 1.47989497e-01f,
  -4.50001732e-02f, 3.08965947e-02f, -4.61566113e-02f, -6.80822227e-03f, -7.52779916e-02f, -9.28698294e-03f, 9.35838521e-02f, -1.29840732e-01f, -8.11527669e-02f, -6.11392874e-03f,
  -1.45107225e-01f, 3.68385576e-02f, 1.60547607e-02f, -2.82681882e-02f, -1.39768317e-01f, 5.49619123e-02f, -8.09961036e-02f, -1.74643129e-01f, 1.75878435e-01f, -4.41417024e-02f,
  -1.30993903e-01f, 2.40221322e-02f, -3.16132642e-02f, 2.37332001e-01f, -2.58009613e-01f, -8.30214173e-02f, 2.10372388e-01f, -7.41663873e-02f, 1.75085947e-01f, -2.69160330e-01f,
  8.56995806e-02f, -4.81319800e-02f, -1.33296624e-01f, -1.84642971e-01f, 1.29511565e-01f, -3.12322557e-01f, 1.06320880e-01f, -7.18633458e-02f, 3.48478630e-02f, -8.20171759e-02f,
  -3.75085101e-02f, -5.11008268e-03f, 1.38647705e-01f, -2.97551334e-01f, -4.03717346e-02f, -1.09344006e-01f, 1.37979120e-01f, -3.01546812e-01f, 1.20989745e-02f, 9.71577242e-02f,
  3.28495279e-02f, 1.64409116e-01f, -6.74450248e-02f, -3.61287929e-02f, 1.65629443e-02f, 4.18830849e-02f, 1.82251465e-02f, 8.32092315e-02f, 2.16231406e-01f, 2.99625099e-02f,
  1.74872741e-01f, 8.39321837e-02f, -1.43390140e-02f, -2.10386906e-02f, 1.44914672e-01f, 1.55662280e-02f, -1.74371228e-02f, -2.45820373e-01f, 5.49795553e-02f, 8.26941133e-02f,
  2.74724234e-02f, -6.95196092e-02f, 2.94482172e-03f, -1.89996567e-02f, 7.21849129e-02f, -3.73619869e-02f, -1.91521749e-01f, 2.69730747e-01f, -1.96944758e-01f, 2.08190322e-01f,
  -1.84660200e-02f, 4.48492281e-02f, 6.74894825e-02f, -3.42948027e-02f, -1.79601535e-01f, 2.32417062e-02f, -1.37480479e-02f, 1.75543860e-01f, -1.75396472e-01f, 1.47919267e-01f,
  2.76805665e-02f, -7.14801550e-02f, 6.10349365e-02f, 1.11179397e-01f, 1.29318442e-02f, -3.01281720e-01f, 1.13990746e-01f, -1.55287802e-01f, 1.90159068e-01f, -4.15756889e-02f,
  -2.58189797e-01f, -3.20339203e-02f, 1.56757794e-02f, 1.37972623e-01f, -4.49609011e-02f, 7.99366310e-02f, -4.29772466e-01f, 4.62530591e-02f, 2.91627869e-02f, -1.31160781e-01f,
  1.14505284e-01f, -1.60071731e-01f, 5.64378276e-02f, 3.49230841e-02f, -5.75232022e-02f, 1.12169161e-01f, -1.48683740e-02f, 1.82555959e-01f, 9.55129415e-03f, 7.81905837e-03f,
  -3.21197510e-02f, 1.27433836e-01f, -9.90072824e-03f, -1.16050154e-01f, -7.65903145e-02f, 1.05689466e-01f, 1.29032388e-01f, -4.01312634e-02f, -7.24470913e-02f, -7.56493807e-02f,
  7.30258003e-02f, 1.15048952e-01f, -8.79651159e-02f, -4.78465110e-03f, -4.51189093e-03f, 4.31198627e-02f, -2.54244078e-02f, 8.92598480e-02f, -1.93259716e-01f, -1.59668788e-01f,
  1.09691761e-01f, -2.45507777e-01f, -5.09666130e-02f, -2.24769980e-01f, -8.22555050e-02f, -5.10376354e-04f, -6.84766695e-02f, -7.92601928e-02f, -3.41779850e-02f, -3.63681349e-04f,
  2.18986288e-01f, 2.46203780e-01f, 8.49000923e-03f, -1.96359772e-02f, -2.27842536e-02f, 1.28059402e-01f, -5.38900197e-02f, -1.58581480e-01f, -1.30437091e-01f, -2.01605931e-01f,
  2.32581228e-01f, -3.29487771e-02f, 7.13872090e-02f, 1.25929415e-01f, 1.63682804e-01f, -1.60353765e-01f, 3.44828725e-01f, -1.07007511e-01f, 3.25184613e-01f, -1.10540241e-01f,
  -2.40535140e-02f, -1.90810412e-01f, 6.30946681e-02f, 3.07319194e-01f, -3.62229012e-02f, -3.08649361e-01f, 1.95718370e-02f, -1.97790600e-02f, 1.08200517e-02f, -8.71359631e-02f,
  1.16376698e-01f, 7.78707266e-02f, 3.18049011e-03f, -7.36730024e-02f, 1.79200098e-02f, -1.25582546e-01f, -7.89541304e-02f, 1.15240440e-02f, -1.41139805e-01f, 7.06377307e-07f,
  -3.35259400e-02f, -8.58709123e-03f, -2.04506870e-02f, -9.90587324e-02f, 1.04700781e-01f, 1.68198091e-03f, 8.89658034e-02f, -2.41088048e-02f, -1.93459511e-01f, 2.16525286e-01f,
  2.00063318e-01f, 1.20050505e-01f, 1.55206829e-01f, -5.69814220e-02f, 1.68158412e-01f, 9.38647017e-02f, 8.66882503e-02f, -1.16430312e-01f, 3.33495587e-02f, -3.87208574e-02f,
  -8.74882657e-03f, -6.41548121e-03f, -2.90641692e-02f, 6.45682290e-02f, 2.11919263e-01f, -1.14004493e-01f, 5.05969286e-01f, 1.48287207e-01f, -1.45095661e-01f, -2.06497788e-01f,
  -1.36468366e-01f, 9.55224186e-02f, -1.03151657e-01f, -2.74684280e-02f, -1.87410749e-02f, 5.95903061e-02f, 3.02409567e-02f, 2.02278033e-01f, 1.86850339e-01f, 2.06823900e-01f,
  -1.11646473e-01f, -3.15336317e-01f, -5.08333929e-02f, 3.12473178e-01f, -1.93808768e-02f, -3.04072741e-02f, 8.55238736e-02f, -2.57611156e-01f, -5.69871627e-02f, 3.76899093e-01f,
  -1.16254643e-01f, 7.60113671e-02f, -4.89128008e-02f, 2.02176347e-02f, 1.02603376e-01f, -1.51651904e-01f, -1.12288587e-01f, 6.31146654e-02f, 3.83400060e-02f, 4.96055074e-02f,
  -2.20843717e-01f, -1.54298041e-02f, 9.04499087e-03f, 1.00551672e-01f, -5.70506342e-02f, -1.39296070e-01f, 4.60246392e-02f, 3.49378884e-02f, 5.09758033e-02f, -9.08211619e-02f,
  3.94226462e-02f, 1.13156270e-02f, -3.77949923e-02f, -1.82387874e-01f, -6.43120110e-02f, -6.50093779e-02f, 7.79921412e-02f, 1.56820402e-01f, -7.97947869e-02f, -8.03111792e-02f,
  2.62368023e-02f, 3.28668915e-02f, -8.22282359e-02f, 3.87780555e-03f, 9.77931470e-02f, 4.77922894e-03f, -8.51244554e-02f, 7.93587510e-03f, -5.01203276e-02f, 1.45517170e-01f,
  -2.12781399e-01f, -4.55811843e-02f, 1.70776963e-01f, 5.22114672e-02f, 8.41258094e-02f, -1.81160390e-01f, 1.66368321e-01f, -7.60442540e-02f, -1.27996936e-01f, -1.77991260e-02f,
  7.50309005e-02f, -3.43047053e-01f, 7.87716061e-02f, -1.95231557e-01f, 2.64290661e-01f, 1.55036882e-01f, 4.69627939e-02f, -3.33795361e-02f, 1.65463969e-01f, -7.66184628e-02f,
  -3.91806737e-02f, -1.97824799e-02f, -5.55982925e-02f, -2.96192259e-01f, -6.08409606e-02f, -4.21374552e-02f, -6.80578575e-02f, -4.53153476e-02f, -7.41284853e-03f, 1.42638152e-02f,
  -3.84046361e-02f, 4.30720113e-02f, -1.13544008e-02f, -1.79542229e-01f, -1.44993514e-02f, -1.56790093e-01f, -7.85169750e-02f, -1.09544091e-01f, 3.25712934e-02f, 2.41274145e-02f,
  -1.68998614e-01f, -3.49546187e-02f, 5.94350584e-02f, 9.80226472e-02f, 4.97062355e-02f, -1.72117501e-01f, -1.31256491e-01f, -9.37115625e-02f, -1.07766815e-01f, -2.65428377e-03f,
  1.44846886e-01f, -2.08287314e-02f, -1.38604924e-01f, 2.82106936e-01f, -1.67901479e-02f, 1.16008393e-01f, 3.29858214e-02f, -6.20766357e-02f, 1.39692575e-01f, -7.21627176e-02f,
  1.23148710e-01f, 4.01011296e-02f, -1.42696723e-01f, -2.30043024e-01f, 1.68897167e-01f, 1.92333221e-01f, -3.43778618e-02f, -2.79993296e-01f, 4.94417027e-02f, 2.28319690e-01f,
  4.15810533e-02f, 2.23366335e-01f, -1.18007444e-01f, 1.28812373e-01f, -8.82528424e-02f, 9.52404067e-02f, 8.24326575e-02f, 2.56392248e-02f, -3.53484243e-01f, -2.10459456e-01f,
  -1.99778453e-01f, 2.23598555e-01f, 1.38645664e-01f, -7.65010342e-02f, -1.74644664e-01f, -1.76970884e-01f, 5.34046143e-02f, 3.02001446e-01f, 8.27665105e-02f, -1.96523383e-01f,
  -1.13185577e-01f, -2.34975085e-01f, 1.36132598e-01f, -3.71555984e-02f, -1.19029254e-01f, 8.78017172e-02f, -5.81426956e-02f, -5.23104519e-02f, -3.09454918e-01f, -8.89082700e-02f,
  -1.96994394e-01f, 6.56789169e-02f, -3.84297557e-02f, 1.38688296e-01f, 4.68289517e-02f, -1.05532641e-02f, 1.04670465e-01f, 2.77097613e-01f, -1.42828226e-02f, -1.06811322e-01f,
  3.29705663e-02f, 1.94249317e-01f, 1.39585435e-02f, -2.88534313e-02f, 1.17551781e-01f, 3.45253246e-03f, 8.50356817e-02f, -2.43761744e-02f, 1.06396094e-01f, -1.37462914e-01f,
  5.70486225e-02f, 3.49956565e-02f, 4.91709411e-02f, -2.55612075e-01f, 6.67172670e-02f, 1.03257164e-01f, 1.99175641e-01f, -1.44685090e-01f, 7.22508952e-02f, 2.42553234e-01f,
  -4.41306122e-02f, -3.54014456e-01f, -8.96884352e-02f, -1.58603430e-01f, -9.10249949e-02f, -1.86131820e-01f, 9.96037200e-03f, -2.22871825e-01f, 3.55072096e-02f, -1.45529523e-01f,
  2.74502188e-01f, 2.81521916e-01f, -6.47410676e-02f, -3.22209954e-01f, -1.16554443e-02f, 1.95827801e-02f, -9.59711298e-02f, -2.65977710e-01f, 3.28415222e-02f, -2.27532804e-01f,
  7.69955292e-02f, -7.03554302e-02f, -5.35041243e-02f, -5.44462986e-02f, -1.42273262e-01f, -8.98871496e-02f, 1.66358620e-01f, -6.57349601e-02f, -2.66410202e-01f, 7.06846192e-02f,
  -3.93222198e-02f, -1.35424882e-01f, -2.61518568e-01f, -5.19725867e-02f, -9.12817419e-02f, 1.38171881e-01f, 4.64719832e-02f, 4.11369950e-02f, -1.42046986e-02f, 9.81288999e-02f,
  1.11297704e-01f, 4.89441864e-02f, -3.64883393e-01f, -5.45184202e-02f, 1.30922183e-01f, -1.08192623e-01f, -1.22732297e-01f, 6.70223450e-03f, 7.17730001e-02f, -8.88280794e-02f,
  -2.10189968e-01f, 2.75254548e-01f, 2.87584234e-02f, 1.49943814e-01f, -2.05598194e-02f, -1.65870637e-02f, 3.97374704e-02f, 4.32258807e-02f, 1.60123318e-01f, 5.97517304e-02f,
  -4.17122900e-01f, -2.25829668e-02f, -1.81104168e-01f, 1.67106152e-01f, 1.09642304e-01f, -8.14589486e-02f, 3.10235262e-01f, -6.22358806e-02f, -2.30806191e-02f, 9.07089338e-02f,
  -1.01784728e-01f, -1.46100879e-01f, 1.91903532e-01f, -2.74654895e-01f, -1.66028701e-02f, 2.41708666e-01f, -7.61834234e-02f, -7.05076531e-02f, -5.99185042e-02f, 8.16522539e-02f,
  2.11916357e-01f, -1.68382317e-01f, -3.73331755e-01f, -2.39123791e-01f, 4.14309688e-02f, -1.40073881e-01f, -4.43938226e-02f, 1.82163380e-02f, -2.31553838e-01f, -2.79390663e-02f,
  7.44869485e-02f, 7.21877441e-02f, -1.89952664e-02f, -2.99687851e-02f, 1.71773851e-01f, -1.18911944e-01f, -2.24825554e-02f, -4.51266170e-02f, -1.24892361e-01f, 2.82215089e-01f,
  -3.05584371e-02f, 1.62367582e-01f, 1.64556533e-01f, 1.44305572e-01f, 6.80276006e-02f, -1.47654384e-01f, 1.99715778e-01f, -1.78759396e-01f, 7.84592032e-02f, -1.24016494e-01f,
  4.43846062e-02f, 9.15901065e-02f, 9.36541054e-03f, 1.77791938e-01f, 1.60029903e-02f, 8.93276408e-02f, -4.84914593e-02f, 2.90187378e-03f, 1.04214676e-01f, -2.28604730e-02f,
  9.86816362e-02f, -5.67287160e-03f, -1.51856378e-01f, 1.33496881e-01f, 1.70016125e-01f, -6.04586154e-02f, 3.77661616e-01f, 9.61783603e-02f, 1.10540718e-01f, -2.85173189e-02f,
  -2.78478544e-02f, -2.63680756e-01f, -8.57664794e-02f, -1.52303919e-01f, -2.40907446e-01f, -1.02973104e-01f, -1.83609143e-01f, -6.59193844e-02f, 1.29361346e-01f, 1.83430851e-01f,
  -4.18095328e-02f, 2.03594655e-01f, -2.60060191e-01f, 6.13687895e-02f, -1.62233151e-02f, 4.11449149e-02f, -2.39735562e-02f, -1.46036670e-01f, -2.19641164e-01f, 1.62700489e-01f,
  -1.17637932e-01f, -3.40535134e-01f, 4.73127142e-02f, -1.63840503e-01f, 9.19373930e-02f, 4.84402329e-02f, -3.51835750e-02f, 1.21343955e-01f, -5.55749005e-03f, -6.75346851e-02f,
  -1.70863688e-01f, -9.69565362e-02f, -1.23294294e-01f, 1.50488421e-01f, 1.31021976e-01f, -3.73580977e-02f, -1.03129232e-02f, 2.25826278e-01f, 2.26767864e-02f, -7.96509162e-02f,
  6.34488761e-02f, -6.51431978e-02f, -4.94685657e-02f, -2.03774214e-01f, 1.12487152e-01f, -1.48309255e-02f, 5.05742989e-03f, 1.18373573e-01f, -6.67259544e-02f, 3.83708701e-02f,
  -7.55510554e-02f, -1.54571906e-01f, -1.64155677e-01f, 6.49519190e-02f, 1.31393686e-01f, -4.98965941e-02f, -1.17552631e-01f, -5.74044511e-02f, 1.65024623e-01f, 1.67537794e-01f,
  -1.58901757e-03f, 8.01752806e-02f, 1.44804910e-01f, 1.54931266e-02f, 1.24454066e-01f, -1.56151310e-01f, 1.85142696e-01f, -6.02751151e-02f, -1.50180146e-01f, -6.27142787e-02f,
  1.49793446e-01f, -2.40412146e-01f, 1.25824586e-01f, 5.01458673e-03f, 4.52110097e-02f, -3.26910838e-02f, -1.22876309e-01f, 5.13321087e-02f, 9.36293602e-02f, -2.37824604e-01f,
  1.42425761e-01f, -7.43657118e-03f, -4.14763242e-02f, -1.03944875e-01f, -4.16799188e-02f, 1.09385207e-01f, 2.86362190e-02f, -2.03218535e-02f, 8.41460600e-02f, 8.56457204e-02f,
  -4.65856045e-02f, 4.53079455e-02f, 8.81888717e-02f, 1.07379556e-01f, -2.17891932e-01f, 1.39706079e-02f, -1.94972500e-01f, -7.56638497e-02f, 6.48860820e-03f, 2.16848366e-02f,
  -7.40626827e-02f, -1.13462973e-02f, 2.40961574e-02f, 1.67614788e-01f, -8.07405785e-02f, -1.43204570e-01f, 1.19701341e-01f, -4.69405428e-02f, 1.07972577e-01f, -2.76346523e-02f,
  -2.53886938e-01f, 6.05313033e-02f, 7.32909329e-03f, -1.54369801e-01f, 1.42163023e-01f, -1.24702729e-01f, 7.40295351e-02f, -6.93617463e-02f, 4.71062325e-02f, 1.86272860e-01f,
  3.16297933e-02f, -1.02898125e-02f, -1.83863342e-01f, 2.08457366e-01f, -2.17998147e-01f, -1.16435662e-01f, 2.41392609e-02f, 1.49818525e-01f, 3.29869628e-01f, 9.31160599e-02f,
  -1.32985011e-01f, 5.73750138e-02f, 1.26964688e-01f, 1.43009454e-01f, 1.09728120e-01f, -5.95831238e-02f, 7.57534476e-03f, -1.89226180e-01f, 7.82925338e-02f, -1.35147661e-01f,
  4.35705930e-02f, 4.60894518e-02f, 3.16699922e-01f, -1.38779655e-01f, -1.78385660e-01f, 3.61147553e-01f, -9.41681042e-02f, 1.05997153e-01f, 4.22735848e-02f, -7.56469974e-03f,
  1.81988552e-01f, 8.14219192e-02f, -7.35708326e-02f, 1.84471935e-01f, 1.33702932e-02f, 5.84678575e-02f, 3.34684104e-02f, -6.19035810e-02f, 4.53116186e-02f, -9.98514220e-02f,
  -3.74774635e-02f, 1.53486401e-01f, 8.98412541e-02f, -7.99013376e-02f, 6.27979189e-02f, 1.70297474e-01f, -5.28002493e-02f, -3.33739296e-02f, 1.66521743e-01f, 6.38187379e-02f,
  1.39426868e-02f, -2.01146349e-01f, 7.98282251e-02f, 1.44875981e-02f, -3.13315317e-02f, 1.80911303e-01f, -1.03742899e-02f, -2.71101475e-01f, 4.98135537e-02f, -3.62738930e-02f,
  1.72805823e-02f, -4.92099226e-02f, 1.69442579e-01f, 1.62619069e-01f, -2.63401806e-01f, -1.85087845e-02f, 1.27151370e-01f, 1.91661641e-01f, -1.86571907e-02f, -7.43788108e-02f,
  -2.50551775e-02f, 2.11394548e-01f, 6.02221452e-02f, -2.13771477e-01f, -1.61091730e-01f, -1.89633936e-01f, 6.76926598e-02f, 1.47494584e-01f, 1.31620288e-01f, 1.44034490e-01f,
  -2.87378486e-02f, -1.57322407e-01f, 3.47771913e-01f, 1.33083895e-01f, -3.30490202e-01f, -1.70846600e-02f, -3.49058099e-02f, 7.92899877e-02f, 2.07624316e-01f, 1.83285162e-01f,
  -7.93378949e-02f, -1.33677393e-01f, 1.44529313e-01f, 1.55415505e-01f, 3.25806737e-02f, 9.23912216e-04f, 3.87083786e-03f, 6.31041303e-02f, 6.49211109e-02f, 1.56792119e-01f,
  2.04730913e-01f, 3.70041169e-02f, -6.76161647e-02f, 4.34137769e-02f, 7.85892829e-02f, 1.72634810e-01f, 3.67535129e-02f, 1.32839903e-01f, 1.24328814e-01f, 3.13177332e-02f,
  5.64405285e-02f, -1.27040595e-01f, 6.76772296e-02f, 6.08504601e-02f, -9.01581496e-02f, 6.31801933e-02f, -7.24452455e-03f, -2.28670407e-02f, 1.33729130e-01f, 6.40255734e-02f,
  -1.93268657e-01f, 1.83616400e-01f, 1.85009539e-02f, 8.47276971e-02f, -4.19597700e-02f, 4.55196798e-02f, -1.81313660e-02f, 7.51575679e-02f, -1.38755023e-01f, -6.63230009e-03f,
  -1.14217468e-01f, -1.03849702e-01f, -1.15906566e-01f, 1.24304123e-01f, 5.55843525e-02f, 1.26508614e-02f, 6.01218008e-02f, -4.24252935e-02f, -1.89134870e-02f, -1.60747603e-01f,
  9.59884096e-03f, -1.76601842e-01f, -1.84361953e-02f, -4.36203144e-02f, -3.93033866e-03f, 2.27640852e-01f, 3.37208100e-02f, 1.46721840e-01f, -1.01298347e-01f, 1.13982752e-01f,
  -1.62046000e-01f, 3.68539058e-02f, -1.65146422e-02f, -3.15068752e-01f, 1.71027943e-01f, -2.05995888e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.66860059e-01f, 9.24150739e-03f, 5.71908206e-02f, -7.34870583e-02f, 2.54476275e-02f, -4.28753607e-02f, 5.03161289e-02f, 8.16997215e-02f, -1.08935609e-01f, -2.43845209e-03f,
  -4.14589085e-02f, 6.91377893e-02f, -1.02372961e-02f, 4.11977433e-02f, -3.36814374e-02f, 2.32823431e-01f, 2.86535593e-03f, 7.05703422e-02f, -4.33349572e-02f, -2.66753227e-01f,
  -1.24428324e-01f, -5.46699315e-02f, -4.45227250e-02f, 5.87159693e-02f, 1.93392307e-01f, 6.97920173e-02f, -1.13227941e-01f, -1.12389505e-01f, 4.94508967e-02f, 2.82549076e-02f,
  -3.93403918e-02f, 8.25541839e-02f, -8.95438530e-03f, 1.10586248e-01f, 2.15813313e-02f, -2.80427858e-02f, -8.64540040e-02f, 6.73204884e-02f, -1.42001003e-01f, 1.83021903e-01f,
  -1.33586243e-01f, 1.31405994e-01f, -1.30305206e-02f, 1.12288781e-01f, 2.57460624e-01f, 1.07101396e-01f, 1.69843018e-01f, -1.22593291e-01f, 8.78122970e-02f, 1.70308247e-01f,
  1.48661092e-01f, 1.16856754e-01f, 1.09536856e-01f, 2.70775259e-01f, -2.68218547e-01f, -3.50643665e-01f, -2.83064067e-01f, 3.61842215e-02f, -4.86822248e-01f, 1.48576677e-01f,
  -5.48503473e-02f, -2.58584142e-01f, 1.70835368e-02f, -6.71491325e-02f, 1.10613264e-01f, 8.51322338e-02f, -1.45775869e-01f, 1.51481673e-01f, 1.71907116e-02f, 2.04237908e-01f,
  4.36999798e-02f, 1.78254336e-01f, 1.55257910e-01f, 1.47474051e-01f, 2.87767231e-01f, 9.76474434e-02f, 8.14987123e-02f, 9.68492851e-02f, 6.44637551e-03f, 5.69372699e-02f,
  1.48468688e-01f, 5.84427789e-02f, -1.56781822e-01f, -1.70456827e-01f, -8.56772512e-02f, 4.29732949e-02f, 3.90444174e-02f, -8.01159441e-02f, 4.56719380e-03f, 3.73236351e-02f,
  -2.76827347e-02f, -7.30548128e-02f, -2.78998502e-02f, -1.07716367e-01f, 9.20020603e-03f, 1.73964322e-01f, -4.23810678e-03f, -1.08169457e-02f, 5.08369021e-02f, 7.79027939e-02f,
  -3.03172469e-02f, 7.74940997e-02f, -1.24857120e-01f, 2.33361069e-02f, -2.64465362e-01f, -1.62800595e-01f, 7.97664300e-02f, 1.05259649e-01f, 2.52346277e-01f, 1.64358690e-01f,
  -1.75277114e-01f, -8.45179111e-02f, 1.05174802e-01f, -8.82148277e-03f, 1.27696157e-01f, 8.48066285e-02f, -1.60213649e-01f, -1.52590349e-01f, -1.28605634e-01f, 5.86093478e-02f,
  -1.21388674e-01f, -1.33534625e-01f, -2.05823287e-01f, 1.10936621e-02f, -1.90455630e-01f, -2.88873225e-01f, 8.63028914e-02f, 1.35531589e-01f, -1.11839371e-02f, 5.96716926e-02f,
  3.88081782e-02f, 2.79353559e-01f, 8.29774961e-02f, 5.91421127e-02f, 5.61951399e-02f, 6.43883571e-02f, -5.77010363e-02f, 6.45781085e-02f, 1.79062590e-01f, 3.02643795e-02f,
  -1.41013697e-01f, -7.03908727e-02f, -6.34240778e-03f, -1.08855963e-01f, -8.64905939e-02f, -1.07562169e-01f, 8.96823183e-02f, 1.43383428e-01f, 1.40420243e-01f, -3.78522463e-02f,
  1.35524064e-01f, 1.07933633e-01f, 5.47194257e-02f, -4.29051407e-02f, -1.00455925e-01f, 4.31222282e-02f, 9.15920660e-02f, -2.72703022e-02f, 3.60975191e-02f, -1.32546157e-01f,
  4.06604595e-02f, -1.15714177e-01f, 8.89642686e-02f, -1.28583565e-01f, 5.46096228e-02f, -2.25426450e-01f, 2.65178323e-01f, 1.08061254e-01f, 2.68250644e-01f, -1.13357931e-01f,
  -2.21216455e-01f, -1.08973719e-02f, -2.17844807e-02f, -2.24767745e-01f, -6.15057163e-02f, 6.23671385e-03f, 2.54667401e-01f, 1.64868116e-01f, 1.46080732e-01f, 7.86253884e-02f,
  -2.02628031e-01f, -3.54592241e-02f, 3.73923331e-02f, -3.58769000e-01f, 5.50814345e-02f, 1.63934663e-01f, 1.30157396e-01f, 1.14275618e-02f, 1.00181159e-02f, 3.94919634e-01f,
  -5.28340451e-02f, 2.26384163e-01f, 2.75219586e-02f, 5.38266748e-02f, 1.65344793e-02f, 3.25660664e-03f, 1.92679856e-02f, -8.97392689e-04f, -4.22496237e-02f, -7.76773393e-02f,
  -7.33443350e-02f, -6.62058070e-02f, 1.16231196e-01f, 6.07992103e-03f, 1.68373838e-01f, -5.50732277e-02f, 1.51486471e-01f, -5.58974259e-02f, 1.49139747e-01f, 4.07404825e-02f,
  2.42328979e-02f, 2.82865800e-02f, -1.97781131e-01f, 6.64462009e-03f, 8.98241028e-02f, 1.51135311e-01f, 6.04019351e-02f, -1.21545881e-01f, -3.36562514e-01f, -6.43240884e-02f,
  3.41002420e-02f, -3.93887199e-02f, 5.61240800e-02f, 3.52295265e-02f, -1.70068443e-01f, 1.68170985e-02f, 9.80137587e-02f, 3.14636789e-02f, -1.21679015e-01f, 1.31627396e-01f,
  -3.83223146e-01f, 5.37517965e-02f, -2.08023950e-01f, -9.78431180e-02f, 1.30703047e-01f, 3.59471709e-01f, 2.04008713e-01f, 2.75023162e-01f, 1.02283821e-01f, -5.74510992e-02f,
  2.13020712e-01f, 1.43449336e-01f, 3.79328063e-04f, 3.22371513e-01f, 4.01052870e-02f, -1.39753059e-01f, -1.06353089e-01f, -1.92875803e-01f, -1.37809664e-01f, -2.48373017e-01f,
  -3.28834238e-03f, 9.32141244e-02f, -1.22595266e-01f, 3.19312736e-02f, 3.89371589e-02f, 1.17716700e-01f, -6.61291694e-03f, -4.96633537e-02f, 9.92398486e-02f, 6.63561979e-03f,
  -2.42634211e-02f, -1.76831901e-01f, -7.78398812e-02f, 4.22438793e-02f, -3.05904690e-02f, 9.63962749e-02f, -4.27663960e-02f, -1.84746850e-02f, 7.85008371e-02f, 1.18870117e-01f,
  -8.75539556e-02f, 1.55350268e-01f, 3.74499559e-02f, 4.29221988e-03f, 2.94663990e-03f, -1.84055064e-02f, -1.57474965e-01f, -6.64381534e-02f, -9.50268134e-02f, -7.43831471e-02f,
  -1.36928171e-01f, -6.43675700e-02f, 1.02195099e-01f, 4.78352308e-02f, -3.33959498e-02f, 7.75476992e-02f, 5.29055782e-02f, -3.57674472e-02f, 6.74880892e-02f, -1.30562261e-01f,
  -1.79135744e-02f, -1.55204177e-01f, 6.79831430e-02f, 3.08013968e-02f, -2.35723659e-01f, -2.04540819e-01f, 2.21121028e-01f, 9.50388834e-02f, -1.88557670e-01f, -3.20655131e-03f,
  -7.60330260e-02f, 1.62283033e-01f, 1.58242434e-01f, 1.40717044e-01f, 1.74802884e-01f, 4.79644015e-02f, 1.22895896e-01f, -2.96322048e-01f, 1.59649625e-02f, 2.39517495e-01f,
  -1.16762124e-01f, -2.92013168e-01f, -2.62123436e-01f, 2.49956191e-01f, -1.45883607e-02f, -3.30362394e-02f, -1.43949509e-01f, 2.69592449e-04f, 4.99635749e-02f, 2.34940097e-01f,
  7.56973168e-03f, -1.73491865e-01f, -2.03650087e-01f, -1.84877753e-01f, 1.44705474e-01f, -5.05051278e-02f, -8.10600668e-02f, 7.74990618e-02f, -1.39141589e-01f, -9.82318819e-03f,
  -2.28517945e-03f, 2.25577932e-02f, -9.00811888e-03f, -7.32510835e-02f, -5.41169494e-02f, 9.61037204e-02f, 2.64208335e-02f, 4.81106974e-02f, 9.79807004e-02f, 2.54880227e-02f,
  -2.79604584e-01f, 1.02278657e-01f, 4.67750579e-02f, 4.29529734e-02f, 3.38016525e-02f, 1.31908774e-01f, 1.71570703e-01f, -8.11179057e-02f, 2.97251381e-02f, 1.74908534e-01f,
  -2.00135142e-01f, 1.26597732e-01f, 1.67268798e-01f, 5.71833476e-02f, -2.28219777e-01f, -3.49535346e-02f, 2.57522881e-01f, 3.57602276e-02f, 1.93373606e-01f, -5.99872367e-03f,
  2.35457182e-01f, 3.17446411e-01f, -1.47594243e-01f, -6.52446598e-02f, -9.97499302e-02f, -3.15280780e-02f, 1.85072795e-01f, 1.89951852e-01f, 2.69728862e-02f, 9.78069901e-02f,
  -4.89513129e-02f, -2.80723572e-01f, 1.59997381e-02f, 2.67292947e-01f, -3.38373274e-01f, -2.07121253e-01f, -2.98895150e-01f, 1.31456509e-01f, 8.65437537e-02f, -2.23074973e-01f,
  -6.98756129e-02f, -1.51590019e-01f, 1.36705860e-01f, 2.45912179e-01f, -8.82134959e-02f, -4.93340380e-02f, 7.37149119e-02f, -3.28167118e-02f, 5.39237820e-02f, -1.27295017e-01f,
  1.76425837e-02f, 9.64110419e-02f, -7.58607406e-03f, 3.18593979e-02f, 6.44792393e-02f, -5.29967807e-02f, -2.72213370e-02f, -8.53808969e-02f, 1.33120060e-01f, 1.71068519e-01f,
  3.40445600e-02f, 1.35558307e-01f, 8.79307240e-02f, 4.17337455e-02f, -1.52283639e-01f, -6.98846160e-03f, 2.74075717e-02f, 2.04382062e-01f, 9.64180976e-02f, -6.60946816e-02f,
  -1.04432337e-01f, 6.84677660e-02f, 3.60056548e-03f, 2.43438799e-02f, 1.14882290e-01f, -9.47133973e-02f, 2.45836359e-02f, 7.62237087e-02f, -1.49865523e-01f, -1.23108905e-02f,
  9.02554914e-02f, 2.65289862e-02f, 1.90269694e-01f, 1.16447143e-01f, 1.76711112e-01f, 2.97509938e-01f, -3.17929685e-02f, -6.66303933e-02f, -4.44411077e-02f, 8.78094956e-02f,
  1.43062100e-01f, 2.33512238e-01f, 2.58953363e-01f, 3.17916982e-02f, 3.64675783e-02f, -9.43864360e-02f, -7.02205524e-02f, 2.47756675e-01f, -2.22610489e-01f, -3.82713646e-01f,
  2.68185940e-02f, -3.84325832e-02f, -7.91182518e-02f, -8.07062164e-02f, -2.10066140e-01f, -4.83384915e-02f, -1.17368862e-01f, 2.45355040e-01f, 7.48154074e-02f, 1.49879768e-01f,
  2.07621500e-01f, -4.11622263e-02f, 3.31350192e-02f, 5.68323322e-02f, 1.06931970e-01f, 1.36939362e-01f, 1.02148116e-01f, 2.95993257e-02f, 1.54057726e-01f, -1.12152677e-02f,
  -8.54253173e-02f, 5.46697043e-02f, 3.96374837e-02f, -2.18217205e-02f, -9.36290622e-02f, -1.98085308e-01f, 9.58623290e-02f, 2.49721453e-01f, -1.80542558e-01f, -1.41557828e-01f,
  1.80240259e-01f, 1.95941836e-01f, 6.67349026e-02f, 3.50174904e-02f, 5.36537357e-02f, -1.37970850e-01f, 1.03199340e-01f, 5.66981025e-02f, 9.38279852e-02f, -8.12594816e-02f,
  6.99828789e-02f, -3.38321850e-02f, -1.25619158e-01f, -2.42735878e-01f, 3.06929260e-01f, -1.95473075e-01f, -7.32062906e-02f, -1.96447954e-01f, 4.71869893e-02f, 4.20516133e-02f,
  -1.78798795e-01f, -1.47404864e-01f, 1.35858431e-01f, 7.67028555e-02f, -1.63711846e-01f, 2.62631744e-01f, -3.56560238e-02f, 8.12612027e-02f, -1.15030028e-01f, -4.66732867e-02f,
  9.77016389e-02f, 1.41675413e-01f, -7.89718330e-02f, -4.05120030e-02f, 2.77057081e-01f, -3.44149326e-03f, 1.18515074e-01f, -8.30602869e-02f, -8.66470188e-02f, -1.84293926e-01f,
  1.18128933e-01f, 1.54566154e-01f, -3.97205465e-02f, 8.80169496e-02f, 3.64939943e-02f, -5.55299558e-02f, 3.01837362e-02f, 1.27397090e-01f, 1.22652069e-01f, -3.73692182e-03f,
  1.77897260e-01f, -7.50764608e-02f, -9.47606862e-02f, 3.19543071e-02f, -2.42117848e-02f, 6.43937616e-03f, 8.43222663e-02f, 5.51938638e-02f, 1.47319734e-01f, 9.65040997e-02f,
  -4.94720191e-02f, 3.41902040e-02f, 9.97825712e-02f, -2.20258906e-01f, 4.85746050e-03f, -1.53431490e-01f, -3.09191272e-02f, 1.92831904e-02f, -2.14718670e-01f, 1.67310834e-01f,
  -1.96949258e-01f, -1.54975772e-01f, 1.45753697e-01f, -1.23888582e-01f, 2.11052112e-02f, -7.81024247e-02f, 7.09523782e-02f, -9.54442620e-02f, -3.24872620e-02f, 6.48003966e-02f,
  -4.21565175e-01f, 1.36322036e-01f, -8.21194425e-03f, -1.57382548e-01f, 2.63328820e-01f, 5.69405444e-02f, 2.09766924e-01f, -2.07886219e-01f, -3.81858647e-02f, -6.46427199e-02f,
  1.82524711e-01f, -8.42101872e-02f, 1.61247432e-01f, -8.09606239e-02f, -1.72079001e-02f, 6.88284039e-02f, 2.21409962e-01f, -1.16382949e-01f, -3.09059948e-01f, 2.58950233e-01f,
  3.26618403e-01f, -2.90392727e-01f, -1.03857897e-01f, -2.87407283e-02f, 7.02270344e-02f, -3.76895592e-02f, -8.00944939e-02f, -6.74353987e-02f, 3.08263842e-02f, -7.16638044e-02f,
  -8.61418471e-02f, -9.69003662e-02f, -4.14723940e-02f, -1.50256872e-01f, -7.72545636e-02f, -4.40305769e-02f, 1.26900390e-01f, 3.66369411e-02f, -3.98998037e-02f, 6.55888692e-02f,
  -7.40735978e-02f, 1.68235821e-03f, 9.18217376e-03f, 5.07679544e-02f, -1.32537469e-01f, -2.25083515e-01f, -1.72800608e-02f, 1.14079984e-02f, 3.01503707e-02f, -2.13330388e-01f,
  -2.86269132e-02f, -3.30118872e-02f, 6.24987967e-02f, 1.83890581e-01f, -1.00402527e-01f, -7.85918236e-02f, -2.62258708e-01f, 2.01406285e-01f, 2.95278151e-03f, -1.11515895e-01f,
  4.89311218e-02f, 3.96869518e-02f, -2.16353517e-02f, -1.62831664e-01f, -1.48974471e-02f, 3.95433664e-01f, -8.25268477e-02f, 4.70769592e-02f, 2.62694716e-01f, -1.29355147e-01f,
  2.23431706e-01f, -6.66729882e-02f, 9.29666609e-02f, 7.81918317e-02f, -7.61898831e-02f, 1.29090860e-01f, 6.84144571e-02f, -1.03745572e-02f, -2.95654893e-01f, 7.75058642e-02f,
  7.05855489e-02f, 4.78898048e-01f, -1.72286853e-01f, -2.95389682e-01f, 5.93818761e-02f, -4.25113142e-01f, 2.28470370e-01f, 1.78239364e-02f, -1.49180843e-02f, -1.35974124e-01f,
  -5.49967326e-02f, 3.74519266e-02f, 2.16901138e-01f, 2.68096291e-02f, 1.31179735e-01f, -8.60386435e-03f, 2.94965953e-02f, 4.13035881e-03f, 2.00414538e-01f, 1.06078736e-01f,
  4.78796335e-03f, 1.62445009e-01f, 1.24800272e-01f, -1.44499093e-01f, 1.01772442e-01f, 7.37881064e-02f, -4.66648377e-02f, -2.97810845e-02f, 8.14391151e-02f, 1.44272387e-01f,
  1.72829013e-02f, 1.36065796e-01f, 1.09565176e-01f, -8.21361244e-02f, 1.20792031e-01f, 9.14469659e-02f, -6.01845421e-02f, 1.33298010e-01f, 4.46096137e-02f, 1.99356318e-01f,
  -2.03141585e-01f, 1.34625077e-01f, 7.35784248e-02f, -1.35669604e-01f, -1.30197704e-01f, 1.24775842e-01f, 1.83405742e-01f, -1.63684577e-01f, 9.34314169e-03f, -1.86945707e-01f,
  2.85810176e-02f, -7.77028576e-02f, -3.37558724e-02f, 1.48637500e-02f, 1.58169977e-02f, -2.08564871e-03f, -2.63835579e-01f, 1.84643850e-01f, -4.48526330e-02f, 1.01817429e-01f,
  -1.33989036e-01f, 2.22055256e-01f, -1.50211602e-01f, -1.56412736e-01f, -3.93455476e-02f, -1.44866660e-01f, 2.34957799e-01f, -1.53728917e-01f, 2.15747312e-01f, 4.05181572e-02f,
  -1.16565786e-01f, -9.49864537e-02f, -1.45058945e-01f, 2.43262261e-01f, 1.16598476e-02f, 9.33932438e-02f, 2.18393847e-01f, 4.50378396e-02f, 1.22272663e-01f, 2.08899900e-01f,
  -7.44080022e-02f, -3.60928364e-02f, 1.98639154e-01f, 5.67549057e-02f, 4.18519862e-02f, 1.49148135e-02f, 1.65583864e-02f, 9.65156332e-02f, 3.39783393e-02f, 1.90083981e-02f,
  1.09726116e-01f, 2.32420787e-01f, -1.04019197e-03f, -1.70426518e-01f, -1.38125092e-01f, 1.17146961e-01f, 7.97432195e-03f, -2.37762034e-01f, -3.21186706e-02f, -1.97530419e-01f,
  1.74246740e-03f, 1.67157248e-01f, -1.75256923e-01f, -6.97271171e-05f, -1.05783008e-01f, 1.97065547e-01f, -1.21830702e-01f, -1.94761008e-01f, 5.98701537e-02f, -3.00361812e-02f,
  -1.47275001e-01f, 1.05784670e-01f, -3.54409814e-01f, 2.77440399e-01f, -1.03589669e-01f, -1.35819763e-01f, 1.56349331e-01f, -3.08574289e-02f, 2.92297989e-01f, 6.02517799e-02f,
  -5.90672046e-02f, -2.21602798e-01f, -1.88381001e-01f, -1.39904410e-01f, 1.29448667e-01f, 2.10258007e-01f, 1.66797489e-02f, -3.91452499e-02f, 1.40276123e-02f, 2.60403305e-01f,
  -3.46766561e-01f, -1.09568089e-01f, -5.69228008e-02f, 7.91604295e-02f, 5.21173142e-02f, -1.25281438e-01f, 2.19985947e-01f, -9.12251100e-02f, 1.28956512e-01f, 1.24463648e-01f,
  -5.97708626e-03f, 3.47146243e-01f, 7.88698345e-02f, 4.20715101e-02f, 1.15657106e-01f, 2.66428649e-01f, 2.76895076e-01f, 2.55808234e-01f, 2.23632470e-01f, 8.84508044e-02f,
  2.40208283e-01f, -1.21235207e-04f, 1.27943024e-01f, 7.93840503e-04f, -4.57197316e-02f, -3.16324979e-02f, 9.31247026e-02f, -7.89917260e-02f, 1.05995327e-01f, 8.06075856e-02f,
  -3.61304842e-02f, 1.34531751e-01f, 8.71441960e-02f, 1.36399880e-01f, 2.48093247e-01f, -1.35309830e-01f, 1.99393764e-01f, 3.12785685e-01f, 1.63547590e-01f, 3.60942222e-02f,
  6.17062412e-02f, -2.15734228e-01f, -2.08587125e-02f, 5.65956496e-02f, 1.62800550e-01f, -1.45932034e-01f, 9.77697074e-02f, -5.46619892e-01f, 1.44520774e-01f, 2.69168559e-02f,
  -2.33934283e-01f, -7.84901232e-02f, -1.09538749e-01f, 8.20499882e-02f, -1.52847156e-01f, -9.14005842e-03f, -1.87531993e-01f, -4.16625524e-03f, -4.88613211e-02f, 1.66079521e-01f,
  1.59744591e-01f, 8.39859769e-02f, -1.89331323e-02f, -3.52512449e-01f, 3.35201204e-01f, 2.54278809e-01f, -6.34018108e-02f, 3.40546846e-01f, 1.37613609e-01f, -2.91392535e-01f,
  -5.64187672e-03f, 3.16906840e-01f, 3.30177210e-02f, -2.14947294e-02f, -6.52060378e-03f, -7.55153149e-02f, 1.85428541e-02f, -1.52019814e-01f, -1.78729326e-01f, -4.84446622e-02f,
  -1.58392191e-01f, -1.70030609e-01f, 4.20350805e-02f, 1.27842069e-01f, -3.93948257e-02f, -3.23847905e-02f, -2.90376861e-02f, 1.29340440e-01f, 9.82186422e-02f, -4.40101102e-02f,
  9.51342955e-02f, 9.12372302e-03f, -2.97344655e-01f, 9.24009457e-02f, 1.52144989e-04f, -8.09700286e-04f, 5.31731062e-02f, 6.51263371e-02f, 1.38132751e-01f, 1.81080867e-02f,
  -5.41623533e-02f, 1.57836035e-01f, -1.13714822e-01f, 1.70381725e-01f, 5.32989465e-02f, -2.64183376e-02f, -1.50018975e-01f, -1.33629873e-01f, 2.58850127e-01f, 6.31193593e-02f,
  -2.78730810e-01f, -2.10463196e-01f, 1.96529642e-01f, 1.91452235e-01f, -2.62644500e-01f, 7.95024633e-02f, 1.33078888e-01f, 4.60512787e-02f, 6.52293265e-02f, 1.65884227e-01f,
  1.15146212e-01f, 9.37332585e-02f, -1.77066145e-03f, -2.95400292e-01f, -1.40486687e-01f, 2.43313625e-01f, -4.12452966e-01f, -1.46163419e-01f, 2.83735897e-02f, 2.20952511e-01f,
  6.01306707e-02f, -6.23266697e-02f, -1.01596378e-01f, 2.11875811e-02f, -5.11255339e-02f, 2.85889417e-01f, 1.01004839e-01f, 2.30151609e-01f, -5.29028848e-02f, 1.74176753e-01f,
  -1.52787745e-01f, -8.50433670e-03f, -1.36958333e-02f, 7.07696453e-02f, 4.99475077e-02f, -8.39195848e-02f, -6.06119595e-02f, 9.16228164e-04f, 2.32410915e-02f, 4.82452065e-02f,
  1.60848405e-02f, 1.48769198e-02f, 8.24890584e-02f, -5.84667362e-02f, -8.81412327e-02f, -1.56891868e-01f, -1.45840403e-02f, -2.04854608e-02f, -5.84757999e-02f, 1.40470505e-01f,
  -1.99963152e-02f, 9.31288749e-02f, -8.96693468e-02f, -1.11557752e-01f, 4.98638377e-02f, 5.31640872e-02f, 3.82698812e-02f, 1.31795660e-01f, -5.78275695e-03f, 6.72758445e-02f,
  -8.04179721e-03f, 8.94162357e-02f, -1.71276167e-01f, 1.32930979e-01f, -2.97451854e-01f, -1.82837948e-01f, -1.16830789e-01f, 3.39988768e-02f, 4.27094363e-02f, 1.07280634e-01f,
  -7.24922791e-02f, 6.78609386e-02f, 1.07594736e-01f, 4.33233473e-03f, 1.04980124e-02f, 9.70682651e-02f, -6.66053360e-03f, 5.00675961e-02f, 2.57411748e-01f, 3.69496271e-02f,
  -3.71169657e-01f, -1.14219233e-01f, -1.30582705e-01f, -2.20660027e-02f, -1.50487259e-01f, 1.82293698e-01f, -2.14894023e-02f, -4.25211191e-01f, 7.35772699e-02f, 1.48245364e-01f,
  6.64348006e-02f, 6.18631020e-02f, 1.42231479e-01f, 1.77477170e-02f, 1.58908963e-01f, -9.11222864e-03f, 8.51849616e-02f, 1.94857076e-01f, 7.44711980e-02f, 2.29563057e-01f,
  2.80072659e-01f, 1.43488199e-01f, 5.83853610e-02f, 9.23538208e-02f, 1.02648281e-01f, -4.96847630e-02f, 1.33415395e-02f, -1.23493429e-02f, 1.76790897e-02f, 1.43201604e-01f,
  -6.15864471e-02f, -7.91801512e-03f, 6.78760111e-02f, 6.06279112e-02f, -1.23107977e-01f, 9.51017514e-02f, 1.22962170e-03f, -9.82934460e-02f, -2.43461085e-03f, -3.28368664e-01f,
  -9.70753580e-02f, -9.36987251e-02f, 9.20669809e-02f, 2.10692696e-02f, -7.75657818e-02f, 8.61413125e-03f, 1.59047037e-01f, -1.14515215e-01f, -4.31251973e-02f, 1.13851137e-01f,
  -1.20749012e-01f, -3.29655737e-01f, 7.80388415e-02f, 2.95178801e-01f, -2.23508805e-01f, 8.74260962e-02f, -1.94150716e-01f, 1.09534539e-01f, 1.21800318e-01f, 2.32210681e-01f,
  -5.40932156e-02f, 4.25085649e-02f, -2.39773020e-01f, -6.03027679e-02f, 1.20302945e-01f, 4.86590341e-02f, 2.27416217e-01f, -6.61703646e-02f, 1.37898475e-01f, 2.15201199e-01f,
  -1.47212237e-01f, 4.08000797e-01f, 2.04788577e-02f, 5.81817217e-02f, 3.19590494e-02f, 1.31163523e-01f, 1.74820542e-01f, 2.17921168e-01f, 9.22502428e-02f, 2.37986706e-02f,
  2.42953554e-01f, 4.17561159e-02f, -5.33840433e-03f, 6.76624179e-02f, 5.45134731e-02f, 1.41909420e-01f, 1.40776917e-01f, 1.82411373e-01f, 1.51622564e-01f, -2.43787039e-02f,
  7.53354207e-02f, -1.25828926e-02f, 4.47261892e-02f, 7.10547417e-02f, 1.63898215e-01f, 9.93926004e-02f, -3.69097628e-02f, -1.52129620e-01f, -1.87599897e-01f, -7.17710108e-02f,
  2.86987275e-01f, 1.08651407e-01f, -1.36823148e-01f, 2.17769638e-01f, 1.27318949e-01f, 1.77132431e-02f, -2.29742944e-01f, 1.65273279e-01f, 1.20278493e-01f, 5.11711873e-02f,
  8.02902207e-02f, -1.41811371e-01f, 9.21654403e-02f, 8.92355889e-02f, -3.43134046e-01f, 6.81136474e-02f, 1.37128830e-01f, -1.27498850e-01f, -2.86477864e-01f, -8.15620795e-02f,
  1.54529035e-01f, -4.66098189e-02f, 1.73565656e-01f, -3.73788834e-01f, -4.51762564e-02f, -2.94607341e-01f, -6.59878254e-02f, -2.29512408e-01f, -1.72560830e-02f, 4.88538116e-01f,
  3.27724636e-01f, -4.57396954e-01f, -1.78594619e-01f, 5.57274409e-02f, 2.69269288e-01f, 7.41940513e-02f, 4.75699306e-02f, -3.84118229e-01f, -6.21465482e-02f, 4.84309765e-03f,
  1.14215501e-01f, 3.86166349e-02f, 2.26440117e-01f, 1.36109754e-01f, -1.12092160e-01f, 8.03775787e-02f, 1.05054893e-01f, -7.86898434e-02f, -2.67436691e-02f, -2.47505903e-02f,
  -4.38074321e-02f, -2.06920728e-02f, 1.98691726e-01f, 1.40678242e-01f, 1.91303901e-02f, 1.16634741e-02f, 4.09832299e-02f, 2.70278960e-01f, -1.79239541e-01f, 2.77273636e-02f,
  1.59998655e-01f, 2.21718520e-01f, 6.92564398e-02f, 1.54846534e-01f, -9.75081623e-02f, -1.18085988e-01f, -1.52116999e-01f, -1.39887705e-01f, 6.83860257e-02f, 1.22717768e-01f,
  4.02205922e-02f, 8.25385973e-02f, 8.67697597e-03f, -2.39859074e-01f, 3.61075103e-01f, -1.68901384e-02f, -1.16465561e-01f, -2.79460917e-03f, 1.49606958e-01f, -4.30687293e-02f,
  -5.70972487e-02f, 6.63129911e-02f, 1.55739225e-02f, 1.19586721e-01f, -2.65024543e-01f, 2.75428563e-01f, 3.12993303e-02f, 8.10105056e-02f, -1.75843254e-01f, -8.49126205e-02f,
  6.84122071e-02f, 2.15421110e-01f, -3.55001278e-02f, 1.52287602e-01f, 2.10401371e-01f, 5.25114685e-03f, 2.27416977e-01f, 7.05802366e-02f, -2.17739061e-01f, 2.42847100e-01f,
  3.99430431e-02f, 2.06428438e-01f, 6.78823963e-02f, 1.38034075e-01f, 5.29779978e-02f, 5.30742705e-02f, 1.45663053e-01f, 1.51235700e-01f, 2.77343970e-02f, 1.35644123e-01f,
  1.40950039e-01f, 4.65306155e-02f, 1.08803213e-01f, 3.26179489e-02f, 5.60868792e-02f, 1.43182367e-01f, 1.83841407e-01f, 2.13571221e-01f, 3.59867476e-02f, 1.41879991e-01f,
  8.61674845e-02f, 3.07574689e-01f, -2.95456916e-01f, 2.45709829e-02f, 6.03326634e-02f, 6.20122626e-02f, 6.14033006e-02f, 5.52119734e-03f, -7.07668290e-02f, 2.97972355e-02f,
  -3.87979075e-02f, -2.03420728e-01f, 7.34887049e-02f, 3.30987200e-03f, 6.07572943e-02f, -1.19371526e-02f, -3.86064895e-03f, -9.13135484e-02f, 1.78626180e-01f, 4.88705980e-03f,
  -3.07017684e-01f, 3.41143161e-02f, -1.09600998e-01f, -3.10101599e-01f, 2.66519547e-01f, 1.82050139e-01f, 2.15841889e-01f, 3.59861404e-02f, -3.88930112e-01f, 2.79437095e-01f,
  1.13524273e-01f, 2.30063125e-01f, -2.05320977e-02f, -1.94028854e-01f, 7.37083703e-02f, 4.59727794e-02f, 1.93481408e-02f, 2.07048833e-01f, 4.97733727e-02f, 3.44768986e-02f,
  4.64060128e-01f, 1.78759955e-02f, -2.73943663e-01f, 1.12017095e-02f, 8.75457972e-02f, 1.94064528e-01f, -1.10871933e-01f, -5.19852154e-02f, 2.60257572e-02f, -6.73212931e-02f,
  1.90694649e-02f, 4.24010679e-03f, 5.23115434e-02f, 1.42710596e-01f, 1.59188211e-01f, 8.15554932e-02f, -8.33726488e-03f, 4.28991541e-02f, 2.01980516e-01f, 1.29141346e-01f,
  1.05586082e-01f, 1.24962427e-01f, -3.24669294e-02f, 1.67103916e-01f, 2.10747477e-02f, -2.85900652e-01f, 1.49847731e-01f, -1.10656053e-01f, -8.18107650e-02f, -1.60187855e-01f,
  -3.13039333e-01f, -5.65352328e-02f, 1.46331236e-01f, 1.97189912e-01f, -3.10782701e-01f, 4.11104023e-01f, -2.05261409e-01f, 1.18495844e-01f, -6.70730248e-02f, 6.78217113e-02f,
  2.73084342e-01f, 8.72488022e-02f, -1.68837443e-01f, -1.36301452e-02f, 2.01028571e-01f, 1.62524715e-01f, -1.25685200e-01f, 7.36747608e-02f, -1.76817745e-01f, -1.96975887e-01f,
  1.56778052e-01f, -2.25733802e-01f, -1.61708631e-02f, -1.70912668e-01f, 7.89932683e-02f, -3.03939939e-01f, -3.41911539e-02f, -5.52922636e-02f, 2.27931738e-01f, 3.38617824e-02f,
  -8.92127752e-02f, 2.56415904e-02f, -8.32440108e-02f, -1.22205086e-01f, -2.38511875e-01f, -3.03678423e-01f, 1.22427255e-01f, -1.68551207e-01f, 2.54656106e-01f, -2.93956608e-01f,
  5.84197789e-02f, -2.58576833e-02f, 8.49816799e-02f, -1.07837468e-02f, 1.10039972e-01f, 1.00139655e-01f, -5.06631136e-02f, 2.71006584e-01f, 2.14240059e-01f, 9.43039432e-02f,
  3.02997348e-03f, 6.68643117e-02f, 4.84768078e-02f, 4.96651828e-02f, 1.11835055e-01f, -2.97377314e-02f, -7.91390464e-02f, 2.26683374e-02f, -2.78000757e-02f, 2.01078355e-01f,
  7.94059411e-03f, 8.26101452e-02f, 4.06500474e-02f, 4.67002057e-02f, 3.14671136e-02f, 9.01834518e-02f, -5.92094474e-02f, 9.60686430e-02f, 1.08408444e-02f, -8.48605260e-02f,
  2.88336128e-02f, -9.26929042e-02f, 2.62490660e-02f, 4.58594263e-02f, -2.97038332e-02f, -1.73828788e-02f, 1.60253465e-01f, -2.14591518e-01f, 5.01257442e-02f, 1.91749796e-01f,
  -1.32171929e-01f, -2.06424922e-01f, -1.10550493e-01f, 8.09350461e-02f, -1.03899881e-01f, 1.00750150e-02f, -7.12657124e-02f, 1.58525065e-01f, 9.06242430e-02f, 1.67322993e-01f,
  -3.34219448e-02f, 1.08308285e-01f, -1.70404017e-01f, -1.53750837e-01f, -5.59394434e-02f, -6.99298903e-02f, 2.00101927e-01f, -4.57815900e-02f, 1.73497975e-01f, 1.95077986e-01f,
  -1.19129330e-01f, 2.34650478e-01f, -9.74656641e-02f, 7.95419216e-02f, -7.13983327e-02f, -5.39033525e-02f, 9.46742520e-02f, 1.18970640e-01f, 6.52763352e-04f, 3.85846160e-02f,
  3.19233723e-02f, 1.32050246e-01f, 2.40846753e-01f, -8.92299116e-02f, -1.60160348e-01f, -1.51235834e-01f, -1.62052289e-01f, 1.62197992e-01f, 5.63552603e-02f, 1.50546841e-02f,
  5.46348207e-02f, 3.94871682e-02f, 1.80553094e-01f, 1.17026731e-01f, 2.15662941e-01f, -2.57779181e-01f, -2.36705959e-01f, -1.02006070e-01f, 5.12976311e-02f, -1.41768873e-01f,
  -1.86007440e-01f, 1.40225083e-01f, -2.04106450e-01f, -3.10493052e-01f, 1.39344245e-01f, -2.52484292e-01f, -4.02150638e-02f, -2.90947463e-02f, 5.20477444e-02f, -1.41980097e-01f,
  -1.87007904e-01f, -7.65673071e-03f, 9.14102122e-02f, 1.43353984e-01f, 2.37835497e-01f, -1.42497689e-01f, 7.30303973e-02f, -2.41243094e-01f, 1.85537487e-01f, -2.87464201e-01f,
  1.45086348e-01f, -1.79539129e-01f, 1.96503520e-01f, -1.97979957e-01f, 1.75257057e-01f, 1.44983575e-01f, -5.23310564e-02f, 3.32361609e-02f, 3.18987370e-01f, -2.08795130e-01f,
  -1.76314563e-01f, 1.84707642e-01f, 1.31217659e-01f, -2.36458942e-01f, -2.05737412e-01f, 6.75043240e-02f, -1.74320862e-01f, 2.00098023e-01f, 1.05738096e-01f, -4.46674824e-02f,
  5.15604354e-02f, 1.57962218e-01f, 5.00301048e-02f, 1.81314379e-01f, 1.37916967e-01f, 2.87420362e-01f, 2.24612042e-01f, 1.74255311e-01f, 4.10574637e-02f, 8.22178368e-03f,
  3.51520181e-02f, 1.05249964e-01f, 2.04308376e-01f, 1.49450898e-01f, -9.19186976e-03f, 7.51042888e-02f, 1.01735376e-01f, 5.49879819e-02f, 3.88654955e-02f, -2.09054604e-01f,
  -1.71684116e-01f, 1.71785727e-01f, -1.11381732e-01f, 4.64023240e-02f, 8.40728059e-02f, 1.62946694e-02f, -4.00855346e-03f, 4.74287756e-02f, 1.23407304e-01f, -5.83332181e-02f,
  -1.25019580e-01f, -1.11625262e-01f, -3.08659524e-02f, -1.93939805e-01f, 6.22435175e-02f, 3.35473120e-02f, 3.14182997e-01f, -3.21153581e-01f, 1.50484040e-01f, -1.08752307e-03f,
  1.33371636e-01f, -1.65810362e-01f, -7.95610324e-02f, -2.19428286e-01f, -1.00108646e-01f, -1.15782395e-01f, -2.35294446e-01f, -1.46011496e-02f, 1.77825848e-03f, -1.72700137e-01f,
  4.07377571e-01f, 1.17845789e-01f, 2.57158488e-01f, -1.48920035e-02f, 2.61273324e-01f, 2.00153172e-01f, -1.01672202e-01f, 8.49603117e-02f, 3.06627095e-01f, -1.25776649e-01f,
  -2.17393115e-01f, -2.65801568e-02f, -4.31930982e-02f, -5.32456301e-02f, 4.45251837e-02f, 1.15431510e-01f, 1.48242220e-01f, 1.79971784e-01f, 1.19587712e-01f, 1.31979585e-01f,
  1.68330610e-01f, 2.32299060e-01f, 2.02268556e-01f, -3.42680067e-02f, -1.80026870e-02f, -1.02002829e-01f, 1.32566765e-01f, -2.81964988e-02f, -9.73559096e-02f, -1.66176140e-01f,
  -8.09010789e-02f, 1.12492502e-01f, 1.98587835e-01f, -6.74330518e-02f, 2.31730267e-02f, 1.53626233e-01f, 1.06936321e-01f, 7.34804198e-02f, -8.66401792e-02f, -1.67462930e-01f,
  -5.42042479e-02f, -1.06356218e-01f, -5.51797561e-02f, -1.62050277e-01f, 1.38737649e-01f, 5.79395778e-02f, -1.25930861e-01f, -1.67893156e-01f, 1.56140894e-01f, -1.41718999e-01f,
  1.65176898e-01f, 1.96045890e-01f, 1.47655100e-01f, -1.13850124e-02f, -1.64339766e-01f, 8.46032500e-02f, -4.81749438e-02f, -8.79920349e-02f, -1.57465160e-01f, -8.78799558e-02f,
  1.03986211e-01f, 1.08267739e-01f, -1.30039737e-01f, 2.18101427e-01f, -1.40920088e-01f, -1.99445888e-01f, 4.52224165e-02f, -3.01056802e-02f, 7.54728988e-02f, -5.68198375e-02f,
  -1.83462966e-02f, 1.36648297e-01f, -8.68091732e-02f, 2.06911907e-01f, 3.37750502e-02f, 5.82649782e-02f, 9.08186585e-02f, -1.12965787e-02f, -1.78139821e-01f, 5.81130059e-03f,
  -9.03758407e-02f, 7.87804052e-02f, -1.23893589e-01f, 1.19283818e-01f, -1.36689916e-01f, 1.14884917e-02f, 4.54416350e-02f, 3.02916579e-02f, 8.18701982e-02f, 2.42443204e-01f,
  2.14113351e-02f, 1.03369266e-01f, 1.39689758e-01f, 1.83469102e-01f, -4.07073610e-02f, -2.97498964e-02f, -2.72142589e-01f, 1.76912874e-01f, 8.13431442e-02f, 7.61649087e-02f,
  -6.79522827e-02f, 7.35873356e-02f, -1.31526440e-01f, -3.04854307e-02f, -5.94730712e-02f, -4.19254333e-01f, -1.21939078e-01f, -1.59800015e-02f, -1.01447236e-02f, 7.60770515e-02f,
  -2.25365594e-01f, -8.85874033e-02f, 6.37424588e-02f, 1.27191558e-01f, -3.33556712e-01f, 1.63067073e-01f, -1.81227341e-01f, -4.81367677e-01f, 1.62939712e-01f, 2.60961086e-01f,
  1.92483782e-03f, -9.11736768e-03f, -1.12189867e-01f, -7.90796503e-02f, 1.33096114e-01f, 2.14201257e-01f, 4.82297316e-02f, -1.00651599e-01f, -3.45789306e-02f, -1.46813571e-01f,
  2.88015991e-01f, 4.69105035e-01f, -1.30859137e-01f, -1.08611409e-03f, 1.82730556e-02f, -5.56164198e-02f, -7.01696351e-02f, 2.33384833e-01f, 1.03276126e-01f, -3.42880756e-01f,
  6.41497970e-02f, 3.35198194e-01f, 3.40673365e-02f, 2.93108284e-01f, -1.55264422e-01f, -3.97967882e-02f, 7.29688331e-02f, -2.73902304e-02f, 1.65145144e-01f, 1.69818208e-01f,
  2.32887268e-01f, 2.67921358e-01f, 1.57421216e-01f, 1.07022561e-01f, 7.74562806e-02f, 1.12601690e-01f, 7.03631938e-02f, 4.29982841e-02f, 3.69988494e-02f, -2.40002900e-01f,
  6.43501384e-03f, 3.47166732e-02f, -2.05344204e-02f, -9.57715362e-02f, -2.55414937e-02f, -1.91997886e-02f, 5.52591942e-02f, -5.02739251e-02f, 5.32831885e-02f, 1.55196413e-01f,
  -6.42042011e-02f, 1.38924345e-01f, -1.09958410e-01f, 2.81831622e-02f, 1.61454991e-01f, 1.87469870e-01f, -2.66507685e-01f, 1.59009442e-01f, -2.80767262e-01f, -9.25799683e-02f,
  -7.22856894e-02f, -4.45916839e-02f, 1.87462583e-01f, 6.02657571e-02f, 1.16236657e-01f, 2.94053018e-01f, -3.21447477e-02f, -3.50988120e-01f, -2.65964363e-02f, -2.51913786e-01f,
  3.90867442e-02f, 2.25471899e-01f, -1.93816140e-01f, -6.46433607e-02f, -2.26285700e-02f, 7.65452832e-02f, -2.86684662e-01f, 3.39870229e-02f, -5.15237451e-01f, 1.32754609e-01f,
  -1.19882062e-01f, -3.24347109e-01f, -1.07350722e-01f, -1.73287373e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -7.07784593e-02f, -1.34324459e-02f, -5.34249749e-03f, 1.03401281e-01f, -2.83281244e-02f, -4.09331080e-03f, -3.83852832e-02f, -1.22683786e-01f, 6.13569245e-02f, 6.26052916e-02f,
  -9.43895727e-02f, 2.34634399e-01f, 7.32576698e-02f, 1.59485918e-02f, 5.09688482e-02f, 8.53273347e-02f, 4.68604192e-02f, 1.15246244e-01f, 1.40617773e-01f, -5.46132550e-02f,
  4.37012464e-02f, -2.40325183e-03f, 1.86431497e-01f, -3.39234844e-02f, 5.18806316e-02f, 1.32209063e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.57698654e-04f, -5.06289601e-02f, -4.56188694e-02f, -2.62303412e-01f, -1.61779583e-01f, -2.10813299e-01f, 9.89638492e-02f, 8.67915675e-02f, -2.83607431e-02f, -1.13383019e-02f,
  8.97496268e-02f, -9.30083916e-02f, -4.61095758e-03f, 1.91023517e-02f, -1.54186273e-03f, 9.79994982e-02f, -2.44154423e-01f, 1.48417622e-01f, 1.03504479e-01f, -9.09606591e-02f,
  7.98446033e-03f, -1.51775390e-01f, 4.36667763e-02f, -7.90593997e-02f, -1.88166231e-01f, 6.34858683e-02f, -1.39046103e-01f, -5.42913796e-03f, -4.63150591e-01f, 3.28282034e-03f,
  -2.82698926e-02f, -5.42457327e-02f, -2.07335204e-01f, -2.98431553e-02f, -8.95900130e-02f, 6.90758154e-02f, 3.32360305e-02f, -5.00097591e-03f, -1.16286926e-01f, 5.75259402e-02f,
  2.88959835e-02f, 4.68969010e-02f, -1.27117690e-02f, -5.43090627e-02f, 1.06843198e-02f, -1.46138100e-02f, 1.88599639e-02f, -1.68541521e-01f, 1.32787496e-01f, -1.11776532e-03f,
  -2.71285981e-01f, 1.29973546e-01f, -4.42006402e-02f, 1.04587868e-01f, 4.47711349e-02f, 1.32316694e-01f, 2.78909057e-01f, -2.03167081e-01f, 8.33038986e-03f, 2.63086390e-02f,
  -1.77714899e-02f, -6.96790665e-02f, 2.68297017e-01f, -1.61183462e-01f, 1.37338489e-01f, 1.73649982e-01f, 9.19980463e-04f, 1.43531069e-01f, -1.85515985e-01f, 4.81763668e-02f,
  -7.85578191e-02f, -1.80011585e-01f, -3.87145579e-02f, -1.73301399e-01f, -5.24674058e-02f, -1.43125653e-01f, 3.32064331e-02f, 6.44641668e-02f, -2.38472633e-02f, 8.74403194e-02f,
  6.69283941e-02f, 7.12475646e-03f, 1.64795429e-01f, -5.02602682e-02f, 2.53120288e-02f, -1.46440908e-01f, 1.03539057e-01f, -3.17421495e-06f, 2.45452616e-02f, -1.63709689e-02f,
  9.35459360e-02f, -1.73810408e-01f, -3.02562684e-01f, 1.05065957e-01f, 4.31344882e-02f, -3.53854239e-01f, -8.37737918e-02f, -1.83141664e-01f, -5.36690950e-02f, -3.66041288e-02f,
  1.52512372e-01f, 9.15363207e-02f, -8.20463076e-02f, 5.89659065e-02f, -1.23726532e-01f, 8.94429311e-02f, -1.08361341e-01f, 1.89510714e-02f, -2.57099837e-01f, -1.67884797e-01f,
  -3.80060710e-02f, 1.59062929e-02f, -5.07484116e-02f, 1.91892654e-01f, -1.89504594e-01f, 1.05743930e-02f, 1.24387145e-01f, -9.71926190e-03f, 1.72090400e-02f, -7.33618885e-02f,
  2.31218815e-01f, 3.06593645e-02f, 1.07558608e-01f, -2.20992446e-01f, 3.06079201e-02f, -2.59838644e-02f, 3.01909983e-01f, 1.87008418e-02f, -1.28673673e-01f, 3.29763093e-03f,
  6.58044368e-02f, 5.29177785e-02f, -9.55646299e-03f, -8.23698118e-02f, 3.11886016e-02f, -9.70282853e-02f, 1.00023851e-01f, 3.92784774e-02f, 1.71322301e-01f, -9.01504084e-02f,
  -2.22610950e-01f, -1.10378183e-01f, 8.41114521e-02f, -1.21689104e-02f, -4.24283445e-02f, 4.14154753e-02f, -1.91150978e-01f, -1.34054078e-02f, 3.74195166e-02f, -7.34883174e-02f,
  -1.55115232e-01f, 4.44001658e-03f, 5.45777716e-02f, 2.65562776e-02f, -3.54091730e-03f, 1.61131337e-01f, -1.71273962e-01f, 1.04219683e-01f, 6.81113303e-02f, -8.08899030e-02f,
  1.15419939e-01f, 7.73492604e-02f, -2.07327511e-02f, 3.51902962e-01f, 6.64619729e-02f, -2.75792908e-02f, -7.65238628e-02f, 3.68895382e-02f, 1.09653555e-01f, 1.06628135e-01f,
  -3.41639630e-02f, -1.38075575e-01f, 8.22087452e-02f, 3.66856121e-02f, -1.18520156e-01f, 5.21887764e-02f, 1.99518964e-01f, 5.60600832e-02f, -7.10306019e-02f, 3.57556343e-02f,
  -9.20867082e-03f, 2.05453232e-01f, 1.79877952e-01f, 1.26802519e-01f, -2.01262962e-02f, -9.19911452e-03f, 4.25863340e-02f, -1.10971861e-01f, -1.61686644e-01f, 4.65171523e-02f,
  4.33739498e-02f, -2.80599352e-02f, 1.84120461e-01f, -3.19266580e-02f, -1.15427161e-02f, -3.34319510e-02f, 1.58343464e-02f, -1.13802679e-01f, -1.65638775e-01f, -1.04096919e-01f,
  -9.94706899e-02f, -5.78925721e-02f, 4.98955920e-02f, 9.57155228e-03f, 7.48886075e-03f, 4.22735848e-02f, -1.79505438e-01f, 1.44534677e-01f, -2.43882369e-02f, -2.34952569e-02f,
  -7.81814456e-02f, -1.06794491e-01f, 1.36499807e-01f, -1.08902089e-01f, -6.23871721e-02f, -6.55558780e-02f, -1.43250287e-01f, 1.71824008e-01f, 5.56134097e-02f, 9.10242274e-02f,
  -7.48691633e-02f, -3.60978656e-02f, 7.33761340e-02f, 2.96007935e-02f, 9.37608033e-02f, -1.02938026e-01f, -1.35733902e-01f, 7.85753652e-02f, 1.09787926e-01f, 1.50768459e-01f,
  6.40946180e-02f, 2.50098649e-02f, 4.68327999e-02f, 8.39288905e-02f, 1.02430629e-02f, -2.67720744e-02f, -5.57875894e-02f, -9.15476307e-02f, 1.57166824e-01f, -2.78016031e-01f,
  -5.37697263e-02f, 1.78814903e-02f, -8.30429718e-02f, 1.03799649e-01f, -1.38050899e-01f, -8.32773279e-03f, -2.49501944e-01f, 1.17833823e-01f, 2.22809404e-01f, -1.41141474e-01f,
  9.62850899e-02f, 1.05803408e-01f, -1.76551342e-01f, 7.70434514e-02f, 1.17974684e-01f, -1.08648813e-03f, 2.06469670e-02f, 1.14466332e-01f, -2.61241887e-02f, 2.82674097e-02f,
  -1.29370426e-03f, 3.86085473e-02f, 6.41116351e-02f, 1.03437252e-01f, 2.07659975e-02f, 9.77591351e-02f, 1.64116189e-01f, 8.52843747e-02f, -2.05816761e-01f, -7.58990124e-02f,
  2.63651133e-01f, -5.44848340e-03f, -4.66527939e-02f, 1.37635112e-01f, 1.51945159e-01f, 1.45036370e-01f, -1.71867125e-02f, -2.27308809e-03f, -1.73335940e-01f, 2.55826443e-01f,
  1.82605594e-01f, -6.68933764e-02f, 2.37366185e-01f, -6.94418177e-02f, 1.77863523e-01f, 1.25128880e-01f, 1.29801631e-01f, 6.38880581e-02f, 8.19871724e-02f, -4.85390164e-02f,
  3.49240154e-02f, -1.44224927e-01f, -6.71908259e-02f, 3.25067863e-02f, 2.84940358e-02f, -2.05691513e-02f, 9.61723030e-02f, -2.76692957e-01f, -7.11318431e-03f, -2.38315761e-03f,
  6.22145124e-02f, 2.58198380e-03f, -8.92530754e-02f, -2.12185271e-02f, 7.78433355e-03f, 1.24070346e-01f, 1.75433844e-01f, -1.68934707e-02f, -1.04748771e-01f, -1.38535216e-01f,
  1.28009215e-01f, -1.89624771e-01f, -1.04402773e-01f, 9.19787958e-02f, -8.67921636e-02f, -1.95124432e-01f, 7.05914125e-02f, 6.13951795e-02f, -2.44413242e-01f, 5.23676351e-02f,
  1.17731117e-01f, -6.10021278e-02f, 1.09202750e-01f, 8.46657064e-03f, -7.01961853e-03f, 4.44897488e-02f, -1.98263815e-03f, 1.21327981e-01f, 6.91346824e-02f, 2.67989654e-02f,
  2.43015531e-02f, 8.31328928e-02f, 3.88562679e-03f, -9.97540727e-02f, -8.24482068e-02f, -1.88477486e-02f, 5.86339496e-02f, 1.74266785e-01f, 6.46382123e-02f, -1.14859745e-01f,
  4.64864112e-02f, -2.51832843e-01f, -1.50372759e-01f, 2.00918447e-02f, 4.82923985e-02f, -1.64232880e-01f, 2.01698586e-01f, -2.10196659e-01f, -2.47387215e-01f, -6.60566539e-02f,
  1.07208323e-02f, -3.26715894e-02f, 1.02565587e-01f, -8.47609490e-02f, -9.95173529e-02f, 2.01990291e-01f, -1.60753608e-01f, 2.61437353e-02f, 3.74879569e-01f, 7.78283775e-02f,
  7.72632957e-02f, 1.61300793e-01f, 2.71090955e-01f, 2.44630367e-01f, 2.00110912e-01f, 3.73099707e-02f, -4.82518598e-02f, 1.78353697e-01f, -1.89023644e-01f, 3.51218730e-02f,
  -1.28585756e-01f, 1.69566572e-01f, 1.40439779e-01f, -3.09689548e-02f, 2.13933393e-01f, 1.09680481e-01f, -7.05990642e-02f, 8.43142122e-02f, 1.91437304e-02f, 2.42947653e-01f,
  -1.59809455e-01f, -3.70146558e-02f, -1.29830152e-01f, 1.97429493e-01f, 4.91854139e-02f, 8.15884024e-02f, -2.25356728e-01f, -2.00471684e-01f, -1.28633603e-01f, -4.06879261e-02f,
  6.23280182e-02f, -9.48457047e-02f, 1.20967031e-02f, 9.59683135e-02f, -1.10522754e-01f, -2.45732099e-01f, 1.31265804e-01f, 6.68279156e-02f, 4.37868275e-02f, -7.94710517e-02f,
  -3.70082647e-01f, -6.92454204e-02f, -9.35833454e-02f, -7.45944157e-02f, 1.70218870e-01f, 1.01658262e-01f, -1.47871330e-01f, 3.09506059e-02f, 4.58217598e-02f, 1.92222036e-02f,
  1.58176348e-01f, -5.93054481e-02f, 9.16276276e-02f, 2.21248642e-01f, 2.32459322e-01f, 1.95559725e-01f, -4.68781106e-02f, 5.74987456e-02f, 8.55687410e-02f, -2.51304239e-01f,
  -3.70102942e-01f, -2.37073712e-02f, -9.69728157e-02f, 2.38405969e-02f, -1.58961251e-01f, -1.80972666e-01f, 1.21611446e-01f, 2.52231419e-01f, -2.32539959e-02f, 2.23030329e-01f,
  -2.02199891e-02f, -2.08335549e-01f, -8.76137838e-02f, 8.64992216e-02f, 1.40456911e-02f, 2.92524129e-01f, -5.74938878e-02f, -2.61702109e-02f, 5.17557859e-02f, 1.48571059e-01f,
  2.13826120e-01f, 1.85781166e-01f, -1.43066179e-02f, -2.92033274e-02f, 1.45421233e-02f, -1.77449420e-01f, -2.67521471e-01f, -1.71730310e-01f, 1.81739599e-01f, 1.38968095e-01f,
  -9.95170549e-02f, 2.34965190e-01f, 9.49792042e-02f, 6.48942441e-02f, 1.64513782e-01f, 5.69249727e-02f, -1.22478634e-01f, 1.78259239e-01f, 1.54747427e-01f, 7.08336383e-02f,
  -1.42706230e-01f, -2.25718897e-02f, -1.43260788e-03f, 6.15317710e-02f, 1.61913455e-01f, 1.25424355e-01f, 1.97050393e-01f, 1.83632284e-01f, -6.25166520e-02f, -1.80638075e-01f,
  -6.60573840e-02f, 7.98630491e-02f, 1.04079939e-01f, -1.40901148e-01f, 1.45095408e-01f, -1.17445871e-01f, 1.32366642e-01f, -2.60620452e-02f, -1.39547307e-02f, -2.43886590e-01f,
  -1.51491007e-02f, -2.38993719e-01f, -1.26690537e-01f, 1.18694454e-01f, 1.55962363e-01f, -1.86495498e-01f, -1.78276956e-01f, 1.25479266e-01f, -1.53594930e-02f, 6.91859005e-03f,
  -2.10671633e-01f, -3.29270273e-01f, -2.75449842e-01f, 8.80104005e-02f, -4.14608344e-02f, -2.41629615e-01f, 1.67808667e-01f, -5.37600927e-02f, -1.51883755e-02f, -1.17819622e-01f,
  -2.41800826e-02f, 2.55279928e-01f, -8.60614609e-03f, 6.10957369e-02f, 2.52403021e-01f, -1.29734710e-01f, 1.18187949e-01f, -2.64949322e-01f, -1.49303779e-01f, 7.26493672e-02f,
  5.50877191e-02f, -2.49986406e-02f, -1.03753135e-01f, -2.24464253e-01f, -3.91941853e-02f, -1.11825010e-02f, 5.70678851e-04f, -1.91803232e-01f, -3.30596715e-01f, 2.26656683e-02f,
  -2.74701148e-01f, 1.00510560e-01f, -2.17997029e-01f, -3.96066681e-02f, -1.89658985e-01f, 2.78682504e-02f, 6.92260414e-02f, 8.31907168e-02f, 8.60484242e-02f, -1.38144478e-01f,
  -3.35676789e-01f, 9.92484018e-02f, -8.67190883e-02f, -2.33955860e-01f, 9.19791535e-02f, 1.61550447e-01f, 2.12794825e-01f, -2.09315762e-01f, -1.22381978e-01f, 1.51006758e-01f,
  -1.57172561e-01f, -4.50574942e-02f, 8.21969733e-02f, -2.19029456e-01f, 8.39464664e-02f, 6.32888228e-02f, -3.67734373e-01f, 4.76268381e-02f, -3.88423502e-02f, 7.57706091e-02f,
  9.84154046e-02f, -9.64677557e-02f, 1.15404382e-01f, 4.25703079e-02f, 9.04318318e-02f, 4.29220386e-02f, -1.01452544e-01f, 7.63412341e-02f, 7.48816356e-02f, 8.38028789e-02f,
  1.88387007e-01f, -1.71585485e-01f, 5.76718338e-02f, 6.27190620e-02f, 1.93580285e-01f, 2.97953546e-01f, 6.89867884e-02f, 2.22606644e-01f, 1.95674092e-01f, -4.04082462e-02f,
  1.66861251e-01f, 7.28786066e-02f, -3.01977117e-02f, 4.73067053e-02f, 2.90720671e-01f, -9.77145061e-02f, 1.02743134e-01f, 1.56519860e-01f, -9.66953710e-02f, -2.70808637e-02f,
  -5.15847653e-02f, -2.02175230e-01f, -1.59201980e-01f, -1.76046506e-01f, 1.54425189e-01f, -1.43982992e-01f, 1.27627641e-01f, -2.77154893e-02f, 9.59475487e-02f, 1.10519864e-01f,
  -2.07309008e-01f, -6.26012385e-02f, -2.12272540e-01f, -8.79849121e-02f, -2.22958550e-02f, -1.47704363e-01f, 1.28943190e-01f, -1.14662275e-01f, -3.77269574e-02f, -1.58974707e-01f,
  -8.69481042e-02f, 1.60373285e-01f, 8.89722109e-02f, -2.08355278e-01f, -5.24119854e-01f, 1.91415355e-01f, -3.63192856e-02f, -2.64164776e-01f, -9.98462923e-03f, 2.11678579e-01f,
  1.66869432e-01f, 5.72154485e-02f, 1.50951117e-01f, 2.25868613e-01f, 1.65071506e-02f, 9.60633084e-02f, -1.72547400e-01f, 4.78322208e-02f, -5.70220351e-02f, -1.99184328e-01f,
  -1.33242443e-01f, -1.34060740e-01f, 2.11743683e-01f, 3.69331658e-01f, -8.65912214e-02f, 1.30266175e-01f, -1.99979693e-01f, -5.74565865e-03f, -6.42779320e-02f, 7.11195990e-02f,
  -7.11190179e-02f, 3.73325087e-02f, 1.99872613e-01f, -1.29251882e-01f, -4.25408557e-02f, -6.69433847e-02f, -1.85944259e-01f, 6.24284148e-02f, 3.73553455e-01f, 1.11684307e-01f,
  -1.03633083e-01f, -8.23861361e-02f, 1.82202429e-01f, -7.32305869e-02f, 2.51540914e-04f, 1.97581388e-02f, 9.88523439e-02f, 3.09088249e-02f, 1.08278573e-01f, -4.76771072e-02f,
  -9.34085622e-02f, 4.65360731e-02f, -1.34817451e-01f, 1.92951128e-01f, 1.80969834e-01f, 4.99742813e-02f, -6.10356107e-02f, 1.54427603e-01f, 1.97037831e-02f, 7.46945739e-02f,
  -1.29802868e-01f, -8.70548263e-02f, -9.77268629e-03f, -6.45298976e-03f, 1.28341494e-02f, 1.83563396e-01f, -1.27670884e-01f, -1.58625301e-02f, -4.89356756e-01f, 1.77709654e-01f,
  -1.77347109e-01f, 1.91183060e-01f, 2.29015425e-02f, 6.09485898e-04f, 1.04428798e-01f, 7.11810291e-02f, -1.22619122e-02f, -1.12157755e-01f, -1.44425318e-01f, -4.58775759e-02f,
  7.07779825e-02f, 9.39621776e-02f, -9.30373073e-02f, -5.85610159e-02f, -6.96543381e-02f, -2.61031203e-02f, -6.82498366e-02f, 1.57502159e-01f, 1.08582802e-01f, -5.81815746e-03f,
  -2.27305174e-01f, -2.79426593e-02f, -8.01943988e-02f, 1.58014297e-01f, 1.86361894e-01f, 1.08971164e-01f, 1.35279700e-01f, 1.34615555e-01f, -3.35436463e-02f, -7.71957263e-02f,
  -5.83371967e-02f, 1.26190796e-01f, 1.75523162e-01f, -1.03747778e-01f, -5.26403449e-03f, 1.81607697e-02f, 5.15922941e-02f, 4.95767295e-02f, 1.16874296e-02f, -2.81348433e-02f,
  5.90774119e-02f, 3.23899202e-02f, 7.51246959e-02f, -1.31847024e-01f, 1.77718669e-01f, 6.87090978e-02f, -9.59920287e-02f, 1.79052129e-02f, 8.00389647e-02f, 4.26700413e-02f,
  3.78628820e-02f, 3.53280306e-02f, -6.59196638e-03f, 1.86009064e-01f, -2.46691138e-01f, 2.44521037e-01f, 1.41005337e-01f, 2.04860136e-01f, 1.26898751e-01f, -1.69120520e-01f,
  1.16908677e-01f, 2.20321804e-01f, -1.52860820e-01f, 1.49072617e-01f, -1.39483646e-01f, -1.02054037e-01f, -3.52505147e-01f, -1.27981812e-01f, 8.15110877e-02f, -2.07546532e-01f,
  -1.19776852e-01f, 7.40793273e-02f, -1.59914717e-01f, -1.33461691e-03f, 7.00124679e-03f, -1.77653164e-01f, -1.29992664e-01f, -2.02430055e-01f, -2.77785093e-01f, -6.51517734e-02f,
  -2.06104085e-01f, -3.73409957e-01f, -6.33117855e-02f, -4.92900945e-02f, 2.16303170e-02f, -1.42388791e-01f, -1.11069471e-01f, 1.44255131e-01f, 5.95872439e-02f, -7.21462220e-02f,
  4.67380732e-02f, 4.06344756e-02f, 1.20786645e-01f, -3.07815164e-01f, 1.16698690e-01f, -1.30886594e-02f, 1.45896584e-01f, 9.06824023e-02f, 2.43526608e-01f, 4.68700640e-02f,
  -3.11339945e-01f, 1.11428939e-01f, 9.62904096e-02f, 1.82902925e-02f, 7.73002878e-02f, -6.59512654e-02f, -9.19686630e-02f, 2.44327844e-03f, -2.85123177e-02f, -6.74056560e-02f,
  -9.00072157e-02f, 1.26483738e-01f, -2.50481404e-02f, 2.44593304e-02f, -1.17532961e-01f, 2.44981885e-01f, 4.41165082e-02f, 7.96533227e-02f, 1.21056497e-01f, 1.45874349e-02f,
  -4.08208817e-02f, -1.37679175e-01f, 4.15353626e-02f, 1.11739911e-01f, -9.27090179e-03f, -1.94684014e-01f, -9.43031833e-02f, 2.28833303e-01f, -1.64159220e-02f, -2.02637896e-01f,
  -1.30812734e-01f, 1.99087694e-01f, -6.26585558e-02f, -1.87067375e-01f, 7.43482932e-02f, -4.95054899e-03f, 9.71142128e-02f, -8.87657981e-04f, 1.35075906e-02f, 2.51836151e-01f,
  3.14481892e-02f, 9.29606054e-03f, -3.39824171e-03f, -7.56226201e-03f, -1.52859256e-01f, 1.86931387e-01f, 1.19002312e-01f, 6.92405105e-02f, -4.43144105e-02f, -1.13180734e-01f,
  -5.70901930e-02f, -6.75176382e-02f, 1.59772620e-01f, -1.13173783e-01f, 1.29227266e-01f, 1.21215098e-01f, 1.12339020e-01f, -4.16227914e-02f, -1.39843911e-01f, -4.50490676e-02f,
  1.07540768e-02f, 1.85654223e-01f, -1.30061164e-01f, -2.21623361e-01f, 1.85180336e-01f, -6.62119165e-02f, 2.78996639e-02f, 1.16299661e-02f, -1.07403718e-01f, -2.49594287e-03f,
  -1.16818108e-01f, -1.13423448e-02f, -1.79282308e-01f, 1.29581215e-02f, -5.76082394e-02f, -1.08702317e-01f, 1.89758968e-02f, 1.30941629e-01f, 5.36471084e-02f, -2.31294259e-02f,
  -4.33007292e-02f, -1.35945588e-01f, 7.26100802e-02f, -1.90367088e-01f, 4.67524752e-02f, 1.24857180e-01f, -1.27577871e-01f, 3.56844902e-01f, -5.59701808e-02f, -2.48658165e-01f,
  1.17307544e-01f, -1.80688635e-01f, 2.46408179e-01f, -8.01139046e-03f, 2.18629420e-01f, 2.71913648e-01f, 1.20418407e-01f, 2.05772027e-01f, 1.29737541e-01f, 9.73032415e-02f,
  3.05687618e-02f, 2.58732447e-03f, 9.61378664e-02f, -3.23428437e-02f, 1.26205102e-01f, -3.80689912e-02f, -1.23798907e-01f, -2.80440543e-02f, 2.42423713e-01f, 4.01267149e-02f,
  1.75534487e-01f, 1.91701815e-01f, 1.24726281e-01f, 2.99791582e-02f, 1.19142033e-01f, -2.53446102e-02f, -3.08828980e-01f, 1.63027093e-01f, 5.33300564e-02f, 3.16791013e-02f,
  3.25530432e-02f, 9.00933146e-03f, -3.16460505e-02f, 4.60914411e-02f, -2.60963172e-01f, 4.92098592e-02f, 2.48397008e-01f, 9.30501148e-02f, -1.00561053e-01f, 8.09082091e-02f,
  -1.80669650e-01f, -4.54854406e-02f, 8.11744556e-02f, -1.76755279e-01f, -1.28037930e-01f, 4.11728732e-02f, -1.49122715e-01f, -7.32515305e-02f, -7.89217055e-02f, 1.98973879e-01f,
  -1.00209944e-01f, -1.58549771e-01f, -6.61303028e-02f, 1.07541233e-01f, 1.42769236e-02f, -9.02468339e-02f, 4.39096838e-02f, 2.34740041e-02f, 1.06536232e-01f, -4.67203446e-02f,
  -1.35863870e-01f, -2.54841745e-02f, -6.20734273e-03f, 5.01895174e-02f, -1.42431170e-01f, -1.04494371e-01f, -9.69071761e-02f, -2.58870244e-01f, -2.33732581e-01f, -1.13026969e-01f,
  -2.10396692e-01f, 2.68615901e-01f, 6.64295331e-02f, -1.81697786e-01f, 7.96028450e-02f, -7.03346953e-02f, 5.24255894e-02f, -6.59914967e-03f, -1.74010117e-02f, -9.25498083e-02f,
  1.24569416e-01f, 7.95481056e-02f, 1.31491780e-01f, 1.44520581e-01f, -2.17952356e-02f, -1.52314454e-01f, -8.41884017e-02f, 1.42291456e-01f, -1.11039773e-01f, 3.80861387e-02f,
  1.06715538e-01f, 1.29287720e-01f, 3.83018400e-03f, -2.45723754e-01f, 1.18616149e-01f, 6.94060177e-02f, -1.89102784e-01f, 3.97594124e-02f, 9.12394002e-02f, -8.94798432e-03f,
  -1.51221916e-01f, 5.19451909e-02f, -2.63387915e-02f, -3.78428511e-02f, -2.83098780e-02f, -7.02876076e-02f, -6.74181879e-02f, -1.06254429e-01f, 9.03197378e-02f, -6.99822158e-02f,
  1.70087308e-01f, 5.22472188e-02f, -7.91947171e-02f, -1.48205802e-01f, 3.62514257e-02f, -4.96226996e-02f, 1.07867084e-01f, -1.43555894e-01f, -1.86752453e-02f, -1.03545962e-02f,
  -5.65065779e-02f, 2.02191714e-02f, 2.21126378e-02f, 1.06728330e-01f, 4.04780842e-02f, 1.92027420e-01f, -1.35602728e-01f, 2.13563338e-01f, 3.83966975e-02f, 2.74583876e-01f,
  -2.87910253e-01f, 4.78374250e-02f, 1.98519975e-01f, 1.86850190e-01f, 1.36547089e-01f, -9.27165300e-02f, 1.67694867e-01f, 1.11973867e-01f, 2.02248283e-02f, -7.72425085e-02f,
  -2.73718610e-02f, 1.14068501e-01f, 7.99133256e-03f, -1.45012334e-01f, -1.92971721e-01f, -1.04731880e-01f, -8.77216831e-02f, -8.33704323e-02f, -1.01955809e-01f, 1.03221633e-01f,
  -4.23154235e-02f, -9.95971486e-02f, -1.33891657e-01f, -2.52707768e-02f, 1.08897358e-01f, -9.58254412e-02f, -1.79292914e-02f, -1.46536836e-02f, 4.93505923e-03f, -1.03230543e-01f,
  2.03155488e-01f, -9.63048264e-02f, 1.65222526e-01f, 4.31891717e-02f, -1.25143364e-01f, -3.93174104e-02f, -2.23341933e-03f, -3.71688455e-02f, 1.41965777e-01f, 1.87360525e-01f,
  3.08659300e-02f, 5.35547584e-02f, 3.14819701e-02f, 1.61469206e-01f, -6.30890429e-02f, 8.99825469e-02f, 7.72755295e-02f, -9.08953920e-02f, -6.68152720e-02f, -8.16336274e-02f,
  1.92560613e-01f, 7.65129030e-02f, 9.81199834e-03f, 2.11242270e-02f, 1.99055880e-01f, -6.90104663e-02f, 4.06339094e-02f, 3.06582954e-02f, 1.09381758e-01f, 2.43765414e-01f,
  8.36721435e-02f, -2.79678404e-01f, 1.47563890e-01f, 9.08496827e-02f, -3.40070873e-02f, -1.50903836e-01f, 1.33743316e-01f, 2.60864556e-01f, 8.99677798e-02f, -1.07697286e-01f,
  2.30897948e-01f, 1.54233769e-01f, 6.86496869e-02f, -8.96142144e-03f, -1.32731378e-01f, 6.01659063e-04f, 2.75403038e-02f, -1.32831395e-01f, -1.71229661e-01f, -2.42189497e-01f,
  1.03204243e-01f, 1.10528179e-01f, 6.65729865e-02f, 2.66682774e-01f, -4.97144535e-02f, -1.28769323e-01f, 1.61549330e-01f, -8.00196975e-02f, 9.99152437e-02f, -6.19108677e-02f,
  -1.02209754e-01f, 9.76931304e-02f, -9.01236907e-02f, 1.49796496e-03f, 6.75972775e-02f, -7.73631632e-02f, -8.26255679e-02f, 2.64586926e-01f, 8.64855722e-02f, 9.32115242e-02f,
  -1.26844451e-01f, 9.54189599e-02f, -1.73855215e-01f, 8.69634226e-02f, -1.24126799e-01f, -2.32630521e-01f, 3.86735946e-02f, -9.85929146e-02f, -1.91115171e-01f, -6.02826327e-02f,
  -1.56851575e-01f, -7.13811666e-02f, -2.57393694e-03f, -1.11152105e-01f, 1.36981532e-01f, 1.24581084e-02f, -1.08626662e-02f, -1.04543686e-01f, 8.97579938e-02f, -2.59807736e-01f,
  -7.68791065e-02f, -3.60340685e-01f, 1.78499028e-01f, 1.34898657e-02f, 2.20749483e-01f, -2.05814004e-01f, 1.98862374e-01f, -2.77492076e-01f, 1.80275500e-01f, -1.78828984e-01f,
  -1.98397897e-02f, -1.76625788e-01f, -2.42901906e-01f, 3.35862100e-01f, -6.75701648e-02f, 5.09920642e-02f, 1.14379436e-01f, 2.95642614e-01f, 1.46067098e-01f, -2.28849780e-02f,
  8.85873064e-02f, 1.39816239e-01f, 1.23666927e-01f, 3.65900900e-03f, -2.45230715e-03f, -1.42990589e-01f, 1.84034109e-02f, 4.05160673e-02f, 1.03320926e-01f, 1.50239274e-01f,
  -8.28136802e-02f, -1.70780923e-02f, -2.08403200e-01f, -7.27371275e-02f, 1.76079739e-02f, -6.57313243e-02f, -9.23615135e-03f, -2.45586000e-02f, -1.57869801e-01f, -1.01213671e-01f,
  -1.52526289e-01f, 2.42084980e-01f, -1.38590276e-01f, -1.02156559e-02f, 1.32251650e-01f, -1.05776519e-01f, 2.60334879e-01f, 2.16079783e-02f, -3.29500362e-02f, -4.14878316e-02f,
  4.45680805e-02f, -3.37316804e-02f, 1.45601019e-01f, 1.42255142e-01f, -1.12506412e-01f, -1.43117076e-02f, -7.01057985e-02f, 3.23811173e-02f, 1.71537161e-01f, -1.55087620e-01f,
  -1.10227659e-01f, 1.22689866e-01f, -4.48560491e-02f, 1.95308924e-01f, 2.99897015e-01f, 2.59723961e-01f, 2.89458167e-02f, 7.51550794e-02f, -1.49329796e-01f, 1.51754841e-01f,
  1.73786104e-01f, -5.52440770e-02f, -2.49501109e-01f, 5.56276320e-03f, 2.85161082e-02f, -1.47738054e-01f, 1.10633783e-01f, -1.10358698e-02f, 2.63320923e-01f, -1.13018006e-01f,
  -2.74912834e-01f, -1.55858025e-01f, -1.00368731e-01f, -1.63580418e-01f, -1.71804398e-01f, -2.07525447e-01f, -2.44072974e-01f, 8.28710273e-02f, -7.16379508e-02f, -3.31330925e-01f,
  1.55211976e-02f, -3.82172652e-02f, 6.20815754e-02f, -2.35600591e-01f, -1.66625395e-01f, 1.14625849e-01f, -1.31919980e-01f, 1.38227686e-01f, -1.29794464e-01f, -3.48524675e-02f,
  8.87520239e-02f, -1.17083110e-01f, 1.03966743e-01f, 1.86131045e-01f, 2.49527574e-01f, -4.07849718e-03f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -5.09694628e-02f, -3.26513359e-03f, 1.27079532e-01f, 3.83718461e-02f, 1.00992680e-01f, -4.07817885e-02f, 1.85264930e-01f, -1.48167904e-03f, 9.42762271e-02f, -3.22945923e-01f,
  2.60555923e-01f, 6.34623319e-02f, 1.90177694e-01f, -1.71290427e-01f, 5.29007474e-03f, 1.31558642e-01f, 5.82747944e-02f, 2.58193761e-01f, -5.59713133e-02f, -3.56289223e-02f,
  -8.88693035e-02f, 1.24035344e-01f, 2.42879093e-01f, -1.72982708e-01f, -3.11333567e-01f, 2.33606294e-01f, 2.97636003e-03f, 2.66559660e-01f, -1.62480935e-01f, 2.08038524e-01f,
  -1.02814823e-01f, 1.90347135e-01f, 1.19288132e-01f, -8.88447091e-02f, 4.60425645e-01f, 1.06128410e-01f, 2.91433692e-01f, 4.52229679e-02f, -1.09628990e-01f, 1.28795221e-01f,
  2.29505047e-01f, 1.54508017e-02f, 4.41739000e-02f, -1.55471876e-01f, 4.81654331e-02f, -8.37184191e-02f, 2.37963349e-01f, -4.00294289e-02f, -2.73203105e-01f, 3.45730633e-01f,
  -3.26343179e-02f, -2.01433450e-01f, -2.46554539e-02f, -2.82685488e-01f, -1.74432546e-01f, 1.62170958e-02f, -3.23975496e-02f, 3.98078412e-01f, 2.51103435e-02f, 1.31726667e-01f,
  1.71706274e-01f, -1.27601430e-01f, -1.40004262e-01f, -1.22939408e-01f, 6.19902760e-02f, 1.04470916e-01f, 1.74626470e-01f, 2.91665107e-01f, 9.18492302e-03f, 5.17635047e-02f,
  -7.86712691e-02f, 7.78620765e-02f, -1.64710190e-02f, 1.51870891e-01f, -8.27144161e-02f, -9.33087543e-02f, -3.65082771e-02f, -7.71033689e-02f, -3.04528791e-02f, -1.05046652e-01f,
  2.67285854e-01f, 1.09240979e-01f, 4.02851775e-02f, -2.16747701e-01f, 2.32495889e-01f, -2.38813147e-01f, -3.39238584e-01f, -2.87498087e-01f, 2.42104113e-01f, -4.83449250e-02f,
  1.60550296e-01f, -2.57156283e-01f, -1.50696024e-01f, 7.39079341e-03f, 2.02059299e-01f, -1.25237241e-01f, 1.55556992e-01f, 1.02596983e-01f, -1.95458755e-01f, 2.53483295e-01f,
  4.70485128e-02f, 1.26689255e-01f, 1.45785376e-01f, 1.93489730e-01f, -1.02240540e-01f, 2.82890111e-01f, 5.19969463e-02f, -1.70772965e-03f, 1.32152379e-01f, 6.90553454e-04f,
  -5.03316969e-02f, -2.13069115e-02f, 1.37349561e-01f, 2.46809453e-01f, 2.94816881e-01f, -6.52124882e-02f, 1.07388660e-01f, -1.97151750e-02f, 2.18199924e-01f, 7.96135236e-03f,
  5.02023511e-02f, 9.90855768e-02f, 1.55569866e-01f, -1.71385750e-01f, 1.72652956e-02f, -4.42178212e-02f, -1.55506030e-01f, 8.57009888e-02f, 2.09265035e-02f, 8.57686251e-03f,
  -5.04490770e-02f, 7.03969970e-03f, 2.94367014e-03f, 1.57116666e-01f, 1.04011200e-01f, 1.22748569e-01f, -7.79015869e-02f, 2.00561836e-01f, -4.71770838e-02f, -1.04200125e-01f,
  -2.55518481e-02f, 1.50266662e-01f, 1.27540320e-01f, -5.09754978e-02f, -3.56621034e-02f, -7.83507824e-02f, -2.23282769e-01f, -2.14647263e-01f, -7.71064088e-02f, 2.70731580e-02f,
  -1.93383377e-02f, 1.71776831e-01f, 1.95564315e-01f, -1.37772441e-01f, 5.64253284e-03f, -1.26791283e-01f, 3.32096577e-01f, -2.14208454e-01f, 1.24481566e-01f, 1.03596814e-01f,
  2.45441124e-01f, -8.21776222e-03f, -1.44310474e-01f, -6.20526224e-02f, -2.26357982e-01f, -1.04841469e-02f, -6.06276914e-02f, 1.75437536e-02f, 1.29413277e-01f, -1.53281182e-01f,
  1.11904338e-01f, 6.98994100e-02f, 2.88826197e-01f, 3.07417035e-01f, -2.91005760e-01f, -2.30049361e-02f, 2.14308158e-01f, -1.47477552e-01f, 2.02833876e-01f, 2.80443102e-01f,
  -9.03079845e-03f, 1.69616938e-02f, 3.18196028e-01f, 2.54286110e-01f, 9.19615477e-02f, 1.99952796e-01f, 6.16641901e-02f, -1.27370320e-02f, 9.74164829e-02f, 5.16495332e-02f,
  -2.63469011e-01f, -1.34681627e-01f, -9.23490897e-02f, 7.23610632e-03f, -3.70158963e-02f, 1.82879027e-02f, -1.76040605e-01f, 1.43738195e-01f, 1.26405373e-01f, -1.91235483e-01f,
  2.47125234e-02f, 8.30319151e-02f, 3.87159176e-02f, 2.30047330e-01f, 5.50250486e-02f, 2.79456638e-02f, 8.72386023e-02f, -9.23107639e-02f, 1.07604012e-01f, 6.52938411e-02f,
  -6.58253580e-02f, -2.94035375e-01f, 1.88378453e-01f, -5.29185347e-02f, 1.35529578e-01f, -2.32633829e-01f, 6.79395124e-02f, 3.62308294e-01f, -1.11758888e-01f, -7.12564141e-02f,
  -3.35916847e-01f, 2.09866211e-01f, -1.67306468e-01f, -1.97737277e-01f, 2.91031152e-01f, 2.17545778e-01f, 3.74754131e-01f, 1.57403305e-01f, 1.74536079e-01f, 9.03893933e-02f,
  2.91657448e-02f, 1.58390179e-01f, -3.00198942e-01f, -6.32861406e-02f, -2.98174769e-01f, -2.41360605e-01f, -1.35814801e-01f, 4.87323501e-04f, 1.87583536e-01f, 3.22193593e-01f,
  -1.25169933e-01f, 2.29934722e-01f, -4.46226805e-01f, -1.88875720e-01f, -2.41101041e-01f, -3.13087612e-01f, 8.36928189e-02f, -7.55119100e-02f, 1.67951316e-01f, 2.15377510e-02f,
  -4.82685789e-02f, -9.55493301e-02f, 1.01452939e-01f, -9.11837295e-02f, -2.78505459e-02f, -1.56893358e-02f, 3.20494711e-01f, 2.07989573e-01f, -6.19301312e-02f, 3.15440446e-02f,
  1.24218248e-01f, 4.81199427e-03f, 8.02383348e-02f, 4.01056185e-02f, 1.43712744e-01f, 2.68814147e-01f, 2.66419142e-01f, 1.97600335e-01f, 2.06932444e-02f, 3.20554763e-01f,
  1.55625775e-01f, -5.91392256e-03f, 1.46848843e-01f, 1.06717758e-01f, 4.36475202e-02f, 2.20201164e-01f, 6.41498268e-02f, -3.96990962e-02f, -2.99692124e-01f, 1.10083021e-01f,
  -4.03698087e-02f, -1.70632675e-01f, -1.71121843e-02f, 6.60069585e-02f, 7.17690811e-02f, -2.11626366e-02f, -1.53286710e-01f, -1.96496934e-01f, 1.81182697e-02f, -1.81121320e-01f,
  -2.32743725e-01f, 2.87789367e-02f, -1.63058117e-01f, 5.22932708e-02f, -2.06661820e-01f, 2.21567005e-01f, -4.75282297e-02f, -1.66427925e-01f, -5.99473864e-02f, -4.84603733e-01f,
  -2.21355315e-02f, 1.23402402e-01f, -2.61912674e-01f, -2.41891295e-01f, 1.64212257e-01f, -6.74372539e-03f, 2.22214535e-01f, -2.58227974e-01f, 7.68229887e-02f, 1.19905407e-02f,
  2.07045376e-01f, -3.72225828e-02f, 9.28568561e-03f, 1.33269737e-02f, 9.12708566e-02f, -3.94548178e-01f, -5.62231347e-04f, 5.85797727e-02f, -4.23992872e-01f, 1.49117738e-01f,
  1.50144979e-01f, 2.92163759e-01f, -1.43603325e-01f, -5.55423042e-03f, 1.48998603e-01f, -1.04184717e-01f, -3.45937945e-02f, 2.32440993e-01f, 2.31911361e-01f, 4.27034572e-02f,
  3.89551781e-02f, 1.21829994e-01f, -1.81862414e-02f, -2.48735212e-02f, -9.96099040e-02f, 7.78437853e-02f, -7.97703266e-02f, -9.95418578e-02f, 2.18502641e-01f, 2.76584681e-02f,
  1.26685485e-01f, 3.19598883e-01f, -9.91191193e-02f, 2.33344704e-01f, -1.05073355e-01f, 6.44772127e-02f, -4.52017486e-02f, 4.12165798e-04f, 4.82991003e-02f, 1.05318986e-01f,
  2.32536092e-01f, 1.53767437e-01f, 9.29985344e-02f, 2.20608756e-01f, 2.21830592e-01f, -1.24071553e-01f, -6.36027521e-03f, 1.68662742e-01f, -8.02961439e-02f, -1.08338483e-02f,
  -2.31571227e-01f, -1.03087537e-01f, 2.00644303e-02f, 1.53666481e-01f, -3.50309310e-05f, -7.25252405e-02f, 2.14746490e-01f, -7.43746897e-03f, -2.15316653e-01f, 1.19401343e-01f,
  -2.97922287e-02f, -3.17249149e-02f, 1.16354451e-01f, -3.86593431e-01f, -1.90128628e-02f, 1.54519841e-01f, 6.46338984e-02f, 1.69592381e-01f, -2.10602984e-01f, 1.03983760e-01f,
  1.03399202e-01f, -2.77682364e-01f, 2.16399040e-02f, -1.35899354e-02f, 3.74190025e-02f, 2.44951740e-01f, -7.09991902e-02f, 2.98614558e-02f, 1.84102893e-01f, 4.16481458e-02f,
  1.29890323e-01f, 2.16627121e-01f, 4.65762578e-02f, 3.24909955e-01f, 8.74842610e-03f, 1.60570070e-01f, 4.74852733e-02f, 2.51446187e-01f, 2.47978210e-01f, 1.67491630e-01f,
  -1.50656149e-01f, 8.17971900e-02f, 3.39744300e-01f, 1.90700725e-01f, -1.28085278e-02f, 1.71740621e-01f, -3.78603846e-01f, 1.35994360e-01f, 1.14206560e-01f, -1.52874619e-01f,
  2.64208704e-01f, -2.34364256e-01f, 2.31306516e-02f, 7.66837448e-02f, 1.75232455e-01f, 1.87069084e-02f, -1.51548356e-01f, 1.79557860e-01f, -8.52967650e-02f, -6.01804435e-01f,
  -3.48593652e-01f, 2.25000441e-01f, -5.01283295e-02f, 5.60675375e-02f, -1.87888905e-01f, -6.28327653e-02f, 3.10281403e-02f, 5.71359601e-03f, -6.55509531e-02f, 5.59641421e-02f,
  -1.08425729e-01f, 1.37933344e-01f, -6.16497658e-02f, 2.91036330e-02f, 3.30769956e-01f, -2.09075242e-01f, 1.33156493e-01f, -1.74397498e-01f, 2.16697320e-01f, -8.39853808e-02f,
  -9.47604552e-02f, 1.26774490e-01f, -8.97531882e-02f, -1.52387526e-02f, 2.79127657e-01f, -6.70758560e-02f, -2.18650863e-01f, 2.30595812e-01f, 1.06618665e-01f, 3.31537724e-01f,
  -1.21972293e-01f, -5.08437790e-02f, -4.40620221e-02f, 4.73138839e-02f, 3.00421357e-01f, -3.93742695e-02f, 1.16149686e-01f, -9.36190039e-02f, 1.16788901e-01f, -2.18730763e-01f,
  7.07322136e-02f, 1.19966894e-01f, 5.84002249e-02f, 1.36760950e-01f, -9.72208828e-02f, 4.52969633e-02f, 3.45874786e-01f, -4.20867167e-02f, 1.43901929e-01f, -1.73329458e-01f,
  -2.29403377e-02f, -2.36426383e-01f, 4.67925668e-02f, -2.56531030e-01f, 1.61549017e-01f, -6.73989430e-02f, -5.54833770e-01f, 6.29440844e-02f, -7.16352230e-03f, -3.72318119e-01f,
  -3.92531604e-01f, -2.16420531e-01f, -3.68828177e-02f, -1.04439057e-01f, 2.99999744e-01f, 2.56724894e-01f, -4.72479612e-02f, 7.04047307e-02f, -1.72391415e-01f, 1.98704481e-01f,
  -9.37379971e-02f, -1.61253139e-01f, -2.35784501e-01f, -2.81756744e-02f, 6.99342340e-02f, 8.55920464e-02f, -7.33366050e-03f, 2.06800863e-01f, -3.10040303e-02f, -1.68662313e-02f,
  8.74212161e-02f, 2.15673387e-01f, -1.67375579e-01f, 1.39170185e-01f, 1.65721655e-01f, 7.51940757e-02f, 8.97516534e-02f, -9.57146809e-02f, -1.94413453e-01f, 2.62691472e-02f,
  3.69265020e-01f, 6.67894930e-02f, 9.31301489e-02f, -4.39713299e-02f, -2.28664540e-02f, 1.70218989e-01f, -3.10286451e-02f, 2.88560521e-03f, 3.96394134e-02f, -3.13004911e-01f,
  2.04266429e-01f, -1.86146591e-02f, -5.72784841e-02f, 9.93641764e-02f, 2.24223062e-02f, -1.47997782e-01f, 8.76363590e-02f, 8.35671276e-02f, 1.81145251e-01f, -1.59701221e-02f,
  -7.26727322e-02f, -2.03701243e-01f, -5.51519282e-02f, -8.72998759e-02f, 1.99496195e-01f, -3.22456986e-01f, 9.53522474e-02f, -1.35658249e-01f, -4.51120399e-02f, -2.02066660e-01f,
  -2.80679226e-01f, -7.72672072e-02f, -1.65342242e-01f, -1.89002514e-01f, 1.55063748e-01f, -2.41083298e-02f, -1.80908218e-02f, -2.56985813e-01f, 3.08474153e-01f, -8.76213908e-02f,
  2.09845215e-01f, 3.36058736e-01f, -1.66732192e-01f, 1.58990592e-01f, -9.37777236e-02f, 1.65920794e-01f, 8.78463909e-02f, -5.77378012e-02f, -9.47164819e-02f, 3.04073930e-01f,
  -7.88619965e-02f, 2.16166243e-01f, -3.32797438e-01f, -1.34704068e-01f, 1.49182752e-01f, -1.09214755e-02f, 8.68043676e-02f, -7.77025297e-02f, -9.42475572e-02f, 2.82944828e-01f,
  1.47463474e-02f, 1.14928074e-01f, -2.20072597e-01f, 9.81236175e-02f, 1.64475173e-01f, -8.01744163e-02f, 1.43862292e-01f, 8.34729150e-02f, -1.05470315e-01f, 1.53936312e-01f,
  6.20702207e-02f, -3.33826020e-02f, -2.78021365e-01f, 1.02030478e-01f, 2.16660313e-02f, 1.42067105e-01f, 8.18870813e-02f, -9.96086001e-02f, -2.20822101e-03f, 1.03496471e-02f,
  4.02785726e-02f, -1.79716632e-01f, 3.75902832e-01f, 3.64463255e-02f, -9.66717005e-02f, -2.70028681e-01f, 2.52556860e-01f, -1.85324714e-01f, -1.43354103e-01f, -1.11474797e-01f,
  2.33986229e-01f, -5.61350808e-02f, 2.36541107e-01f, -1.46234721e-01f, 9.64871868e-02f, -7.50056505e-02f, 9.75146964e-02f, -1.65614605e-01f, 1.65267795e-01f, 4.62905597e-03f,
  7.72364959e-02f, 2.79616386e-01f, -3.82790938e-02f, 1.53779328e-01f, 3.11167855e-02f, 1.83244586e-01f, -1.71657547e-01f, 3.51968914e-01f, 1.93909600e-01f, -6.09605908e-02f,
  1.65739387e-01f, -1.22066818e-01f, 9.32510942e-02f, -5.59919849e-02f, 1.02777742e-01f, 2.52588511e-01f, 2.15567932e-01f, 7.12903738e-02f, 1.38255030e-01f, 9.36876461e-02f,
  -1.36426166e-01f, 6.37142509e-02f, -2.73606032e-02f, -3.77924368e-02f, 6.59439191e-02f, -4.15631086e-02f, 8.64310637e-02f, -3.63770616e-03f, -2.02103615e-01f, 2.59185970e-01f,
  3.12346429e-01f, 1.67353347e-01f, -5.96749038e-02f, 1.68608025e-01f, 1.14144817e-01f, 2.87985094e-02f, -1.31544620e-02f, -5.38265109e-02f, -1.24321289e-01f, 1.43786922e-01f,
  8.67186785e-02f, -1.06332295e-01f, 7.79696703e-02f, 4.66592401e-01f, 9.58792344e-02f, -2.03193408e-02f, -6.17033849e-03f, 8.71153846e-02f, 1.66784182e-01f, 2.37059787e-01f,
  -2.54785195e-02f, -1.20629005e-01f, -2.69743860e-01f, 1.71490356e-01f, 2.39143204e-02f, -1.42326877e-01f, 1.48630962e-01f, -8.53742957e-02f, -9.95354950e-02f, 1.39203101e-01f,
  4.47491929e-02f, -6.16125047e-01f, -3.59967947e-01f, -2.39728540e-01f, -6.57611787e-02f, 2.05679331e-02f, -2.20375568e-01f, 1.62814587e-01f, -2.56526142e-01f, -3.40291969e-02f,
  1.30203145e-03f, 1.66584358e-01f, 3.71295959e-02f, -1.87155426e-01f, -1.50293276e-01f, 2.82725573e-01f, -1.53776944e-01f, 2.42583565e-02f, 2.17658103e-01f, 2.09864691e-01f,
  8.00598711e-02f, -4.56984155e-02f, 3.13835852e-02f, 1.67002082e-01f, 2.03950956e-01f, 2.43760690e-01f, 1.00318357e-01f, -3.65061276e-02f, 2.23571897e-01f, -3.68466854e-01f,
  2.81394497e-02f, 5.05329994e-03f, -1.66818351e-01f, 1.91718534e-01f, 2.12864101e-01f, 2.53621638e-01f, 3.00776958e-02f, -1.27516175e-02f, -1.25477733e-02f, 1.15947396e-01f,
  -1.64733410e-01f, 2.34790176e-01f, -1.36589818e-02f, 1.32969245e-01f, 1.35883912e-02f, -2.94575393e-01f, -7.53201172e-02f, 1.86045989e-01f, 1.24241859e-01f, 2.39377655e-02f,
  1.03128195e-01f, -2.74928119e-02f, 2.54620701e-01f, -9.69502330e-02f, 2.45851353e-01f, -2.89761186e-01f, -3.56934577e-01f, -2.05882236e-01f, 1.53602257e-01f, -1.09678462e-01f,
  4.55851883e-01f, -1.68953001e-01f, -1.73377451e-02f, -1.84180409e-01f, 1.62196860e-01f, -8.44494998e-02f, 1.25228837e-02f, 7.69779533e-02f, -2.34191895e-01f, -5.29159158e-02f,
  -1.97439834e-01f, 2.35905126e-01f, 1.11041658e-01f, 2.96767335e-02f, -1.27452299e-01f, 7.88694806e-03f, 2.82669067e-02f, -4.52539548e-02f, -1.65654913e-01f, -1.02646492e-01f,
  -2.19280669e-03f, -1.03597336e-01f, 1.31213233e-01f, 1.14313565e-01f, 2.58896202e-01f, 9.39227045e-02f, 1.17854699e-01f, 1.01150416e-01f, -7.14295208e-02f, -1.48081686e-02f,
  -8.22301358e-02f, -2.36915812e-01f, -3.85379978e-02f, -1.81352556e-01f, 3.03216338e-01f, -5.83754256e-02f, -1.48579879e-02f, 2.30319127e-01f, 2.76736021e-01f, 1.96366906e-01f,
  5.72828613e-02f, 1.08940460e-01f, -1.56131014e-01f, 7.12270215e-02f, 6.79045990e-02f, -1.29058927e-01f, -1.35186464e-01f, 5.79462424e-02f, 2.23029464e-01f, -2.31332541e-01f,
  -6.42044246e-02f, 3.82210076e-01f, -5.71791781e-04f, 1.75228551e-01f, 3.24852727e-02f, 1.09039687e-01f, 1.06268324e-01f, 9.98187065e-02f, 4.06340510e-02f, 2.66828574e-02f,
  -1.25614762e-01f, 8.99420679e-02f, 1.36382505e-01f, -1.79000437e-01f, 5.91238327e-02f, -1.07206561e-01f, -4.89661433e-02f, 3.73534299e-02f, -1.14390031e-01f, -3.89833361e-01f,
  -4.40096140e-01f, -1.93575397e-01f, -3.84292267e-02f, 1.72888473e-01f, -7.62036964e-02f, -9.17546973e-02f, -1.62962258e-01f, 1.53838456e-01f, 5.72388247e-02f, 2.01429203e-01f,
  5.04544526e-02f, -1.93843856e-01f, -4.86040004e-02f, 2.20351622e-01f, -1.29734278e-01f, -1.38326719e-01f, 2.33877510e-01f, 4.26460616e-02f, 9.64761525e-02f, 1.02451622e-01f,
  2.33629160e-02f, 2.36064151e-01f, -4.01831679e-02f, 2.52486855e-01f, 2.19793141e-01f, -1.21759325e-01f, 1.09559053e-03f, -2.23945111e-01f, -8.33574682e-02f, 1.12568177e-01f,
  2.27627277e-01f, -2.56261043e-02f, -1.83471546e-01f, -2.66544223e-01f, 2.64681011e-01f, 1.92459717e-01f, 1.78819716e-01f, 6.81862459e-02f, -1.68882404e-03f, 8.09129626e-02f,
  1.18930610e-02f, -8.73295218e-02f, -1.05484545e-01f, 7.16993734e-02f, 8.69872645e-02f, -3.71919930e-01f, -2.12033808e-01f, 5.82241267e-02f, 1.46846727e-01f, 4.32606079e-02f,
  -1.10484716e-02f, 2.52022743e-02f, -1.48347571e-01f, 7.04176798e-02f, 3.24692398e-01f, 1.51718810e-01f, -3.05314243e-01f, 1.91597462e-01f, -3.95370871e-01f, 3.15472990e-01f,
  4.15933311e-01f, -6.79174289e-02f, -4.84602116e-02f, 9.92083326e-02f, 5.67360595e-02f, 2.55375225e-02f, 1.30906150e-01f, 3.47721428e-01f, 3.13251793e-01f, -4.08932626e-01f,
  -1.29717395e-01f, -2.95976967e-01f, 3.03739697e-01f, 4.49540839e-02f, -2.29563601e-02f, -1.41320989e-01f, 3.31457593e-02f, -2.59307642e-02f, 9.35364664e-02f, -6.57517165e-02f,
  3.92835699e-02f, 1.57609712e-02f, 5.05486540e-02f, -2.81476617e-01f, -2.31268674e-01f, 2.36674443e-01f, -2.05687135e-01f, 3.95935364e-02f, 2.24867165e-02f, -4.53249291e-02f,
  2.23948509e-01f, 3.39777559e-01f, 5.60280234e-02f, 3.24576378e-01f, -1.35055020e-01f, -3.58494610e-01f, 1.85140185e-02f, 2.22364277e-01f, 1.10787146e-01f, -2.42418274e-02f,
  -6.94952533e-02f, 1.47811756e-01f, -1.51924372e-01f, 1.51544407e-01f, -6.11868277e-02f, -1.92323372e-01f, 1.41281933e-02f, -5.19408770e-02f, 7.78964683e-02f, -7.96162616e-03f,
  -1.02797039e-01f, -2.93113012e-02f, -7.55816102e-02f, -1.12361304e-01f, 1.75196245e-01f, -9.55310911e-02f, 1.36503642e-02f, -5.49828596e-02f, 1.44381952e-02f, 2.43846044e-01f,
  8.22218135e-02f, 2.56228238e-01f, 1.39525443e-01f, 8.48485995e-03f, 7.56299347e-02f, 4.85640615e-02f, 2.21205786e-01f, 3.05048347e-01f, 9.94116068e-02f, 1.34150147e-01f,
  1.25260398e-01f, -2.05338404e-01f, 4.99518253e-02f, 1.53838709e-01f, 1.66959390e-02f, -7.20698088e-02f, 5.94571419e-02f, -1.10018447e-01f, 2.07519174e-01f, 2.48558491e-01f,
  2.40795165e-02f, -1.59255285e-02f, 3.12695295e-01f, -3.54298085e-01f, 2.39451770e-02f, -2.94172429e-02f, -1.06063962e-04f, 3.28540653e-01f, 1.61103737e-02f, -1.49057344e-01f,
  -4.85591233e-01f, 4.13743630e-02f, 2.07705840e-01f, 2.07917079e-01f, -3.63874622e-02f, 9.63332728e-02f, 6.51961118e-02f, -7.56609887e-02f, -9.73233730e-02f, 5.84632009e-02f,
  -1.92491308e-01f, -1.49860904e-01f, 1.15509465e-01f, 2.10331857e-01f, 1.90498754e-02f, 1.13084771e-01f, -2.01111063e-01f, -2.32015736e-02f, 3.14124495e-01f, 9.67914588e-04f,
  2.04443634e-01f, 2.76718259e-01f, -2.27320775e-01f, -3.69084865e-01f, 2.74745398e-03f, 2.27724593e-02f, 4.07310218e-01f, 4.51228805e-02f, -4.05102130e-03f, -2.05385819e-01f,
  4.00694944e-02f, -3.86507660e-01f, 3.45017165e-02f, -2.09716186e-01f, 1.34034723e-01f, -5.32628484e-02f, 1.81023385e-02f, 7.69589767e-02f, -1.45724446e-01f, -3.40012938e-01f,
  -2.10341901e-01f, -3.33115041e-01f, 1.46133646e-01f, -8.41873065e-02f, -1.62989527e-01f, 3.26297045e-01f, 5.01284003e-01f, -1.06295161e-01f, 2.70696372e-01f, 1.71842545e-01f,
  8.95899534e-02f, 2.16740832e-01f, -1.10733114e-01f, -2.89409906e-01f, -1.26469597e-01f, -8.77637491e-02f, -6.81994557e-02f, -7.87712261e-02f, 2.02607289e-02f, 1.15345582e-01f,
  1.11796975e-01f, -2.61496097e-01f, 7.83214495e-02f, 1.50011435e-01f, -1.19528726e-01f, -3.47797722e-02f, -1.42375275e-01f, 2.66172253e-02f, 3.27111930e-02f, -2.89723016e-02f,
  -4.60718982e-02f, 2.13019207e-01f, 1.93150714e-01f, 1.69398308e-01f, -2.17517861e-03f, -2.92728487e-02f, 2.63129801e-01f, 8.96067917e-03f, -1.23831108e-02f, 1.73019785e-02f,
  2.27455586e-01f, 6.25440106e-02f, -5.83714992e-03f, 1.44178241e-01f, 1.23571947e-01f, -2.11940020e-01f, 1.01852223e-01f, 2.38888815e-01f, -6.72455728e-02f, 1.99116334e-01f,
  1.85612425e-01f, -9.21253711e-02f, 1.23783633e-01f, -1.27612427e-01f, -8.77183583e-03f, 1.78353220e-01f, -1.22694217e-01f, -7.30490610e-02f, 3.97875421e-02f, -1.60734802e-01f,
  -1.08117580e-01f, 2.72706836e-01f, -4.24005240e-02f, -2.30767012e-01f, -2.01680124e-01f, -9.41395015e-02f, -5.06533012e-02f, -8.92480761e-02f, -1.80616796e-01f, 2.30574563e-01f,
  -2.38710195e-01f, -9.36897621e-02f, -3.59949805e-02f, 2.50721335e-01f, 1.19412970e-03f, -2.69548595e-03f, 1.59850754e-02f, 4.78168726e-02f, 6.63912073e-02f, 1.83564037e-01f,
  5.52771538e-02f, -2.96152800e-01f, -7.31040314e-02f, -1.93718672e-01f, 5.45679480e-02f, 1.13224223e-01f, 4.13703956e-02f, 2.34228566e-01f, -1.82340950e-01f, 2.30670318e-01f,
  2.30690449e-01f, -1.23222163e-02f, -2.18895916e-02f, -1.07946910e-01f, 2.15634838e-01f, 1.12519927e-01f, 1.42666951e-01f, -1.13337241e-01f, 1.74282521e-01f, 2.34151810e-01f,
  8.65338221e-02f, 7.16042221e-02f, 7.05101416e-02f, 6.24190830e-02f, 4.36392665e-01f, 1.70894653e-01f, 2.34933421e-01f, 1.84341833e-01f, 3.30156952e-01f, 9.89329517e-02f,
  1.42591402e-01f, 3.66680682e-01f, 2.41027772e-01f, 1.37443483e-01f, -1.93825886e-01f, 1.17468424e-01f, 1.56423539e-01f, 3.92803639e-01f, -1.37918338e-01f, 2.71534681e-01f,
  -3.94464172e-02f, 3.29398900e-01f, 1.28421262e-01f, -2.31411815e-01f, 1.53787524e-01f, -2.15147808e-02f, -3.79138470e-01f, 2.38880545e-01f, -2.90948600e-01f, -2.28432462e-01f,
  -5.49126506e-01f, 7.79681355e-02f, 1.03887081e-01f, -4.28582549e-01f, -1.44209918e-02f, 3.07566375e-01f, -5.03734872e-02f, 1.82709515e-01f, -9.98323709e-02f, 1.50804177e-01f,
  -2.23710746e-01f, -2.33328700e-01f, -1.26272172e-01f, 1.53125331e-01f, -2.00889990e-01f, 2.51879860e-02f, 9.46840197e-02f, 1.71887279e-01f, 9.46021676e-02f, -1.40575767e-01f,
  4.97231781e-02f, 1.36317372e-01f, 4.25661832e-01f, -5.86059839e-02f, 1.90377548e-01f, 1.59128696e-01f, 5.76508939e-02f, -3.68247062e-01f, 1.19877614e-01f, -4.22503017e-02f,
  1.82826877e-01f, 1.18711308e-01f, 1.92512557e-01f, -1.73865873e-02f, -6.28821179e-02f, 1.76313356e-01f, -1.26834558e-02f, 1.78868309e-01f, 6.17808253e-02f, 2.49132104e-02f,
  2.18905956e-02f, 6.42913133e-02f, 8.35400224e-02f, -1.47608668e-02f, -3.50298397e-02f, 7.94555875e-04f, 1.36226803e-01f, -3.46665457e-02f, 9.64558646e-02f, 1.31824628e-01f,
  1.79463834e-01f, -1.32227629e-01f, 2.03318283e-01f, -3.80275369e-01f, -1.49987489e-01f, -4.31389898e-01f, 1.65301993e-01f, 4.37387712e-02f, 3.99738699e-01f, -3.59144062e-01f,
  -3.15270334e-01f, -1.03010103e-01f, 7.04190135e-02f, -1.22479722e-01f, 8.36748332e-02f, 7.53579438e-02f, -1.45365134e-01f, 4.52977084e-02f, 3.94882355e-03f, 2.75963426e-01f,
  1.67439446e-01f, 1.97240949e-01f, -2.41098851e-01f, 5.95118105e-02f, 1.81388631e-02f, -5.42171523e-02f, -1.72637001e-01f, -1.26334935e-01f, -4.52150889e-02f, 5.76528721e-02f,
  -7.64080510e-02f, 2.01477602e-01f, 4.70189005e-02f, -7.51170069e-02f, 2.34205097e-01f, -3.84052321e-02f, -2.47754797e-01f, -3.16866413e-02f, 1.19466588e-01f, 7.00657889e-02f,
  -9.15852487e-02f, -1.94935817e-02f, 1.59545019e-01f, -2.43862364e-02f, 1.62671153e-02f, 1.71358153e-01f, 1.32951707e-01f, 9.00466964e-02f, 2.40082681e-01f, -2.59672850e-02f,
  1.07297860e-01f, -1.38565693e-02f, -5.55016845e-02f, -7.08519816e-02f, 1.43557400e-01f, -9.41682383e-02f, 7.50413015e-02f, 7.35320374e-02f, 1.82526261e-01f, 1.42144933e-01f,
  -1.47848159e-01f, 1.34910628e-01f, -2.74888098e-01f, 3.50806341e-02f, 6.08696230e-02f, -2.30803072e-01f, -9.34830233e-02f, -3.39469671e-01f, 2.45113537e-01f, -1.17465816e-01f,
  -2.75242239e-01f, 1.68737322e-01f, -2.22777486e-01f, 6.49384931e-02f, -2.14458331e-01f, 2.37689391e-01f, 7.99541175e-02f, -1.05336219e-01f, 2.12490484e-02f, 3.44221853e-02f,
  1.78652570e-01f, -5.78376949e-02f, 3.15714151e-01f, 2.43711367e-01f, -1.07049465e-01f, 1.67933002e-01f, 1.32057860e-01f, -1.54809341e-01f, -1.10819412e-03f, -7.40018785e-02f,
  -1.22150607e-01f, 1.46949559e-01f, 3.43274951e-01f, 1.18204728e-01f, 6.95334151e-02f, 2.47927383e-01f, -4.02741402e-01f, 8.58548507e-02f, -1.01403236e-01f, 1.27072558e-01f,
  -1.54569134e-01f, 1.48780420e-01f, 4.01046872e-01f, 8.81823972e-02f, 7.61784315e-02f, 3.22508931e-01f, -1.03788510e-01f, -1.21268004e-01f, 2.57941782e-01f, 1.97916348e-02f,
  -2.00615916e-03f, 7.15492517e-02f, -1.09113306e-01f, 2.27887377e-01f, -1.81689277e-01f, 3.31186764e-02f, 2.72703439e-01f, -2.78869588e-02f, 2.81048536e-01f, 2.32348800e-01f,
  2.22186267e-01f, 1.31808937e-01f, -2.56655719e-02f, 1.15410879e-01f, 7.21719861e-02f, 2.07761433e-02f, -2.58418191e-02f, 1.09752312e-01f, 6.59094900e-02f, 1.92714006e-01f,
  6.00404441e-02f, 1.74100965e-01f, 1.98276229e-02f, 9.75056961e-02f, 3.07646781e-01f, 2.47925013e-01f, 2.94921249e-01f, -1.44239202e-01f, -2.98289567e-01f, 2.19281018e-01f,
  -1.26756951e-01f, 4.95220013e-02f, -2.32004881e-01f, 2.91186497e-02f, 3.19529980e-01f, -2.53522217e-01f, -2.75728684e-02f, 2.03333616e-01f, -4.75380681e-02f, -6.53404966e-02f,
  -5.11006534e-01f, 6.31278232e-02f, -3.44943225e-01f, 5.07071242e-02f, -3.56586367e-01f, -3.74813795e-01f, -2.87121356e-01f, 2.64257848e-01f, -2.06749216e-01f, 3.68612826e-01f,
  -4.67159972e-02f, -1.73088014e-01f, -1.30094420e-02f, -2.12493762e-01f, 3.79400849e-01f, -3.09539378e-01f, -2.86302000e-01f, 3.60227019e-01f, -8.22337717e-03f, -3.68380994e-01f,
  1.41927585e-01f, -2.19835997e-01f, 1.41528174e-01f, 2.48815492e-01f, -2.49457248e-02f, 9.05022100e-02f, 1.64920717e-01f, 6.51076883e-02f, 7.65630901e-02f, 2.26177782e-01f,
  8.15985873e-02f, 4.07904461e-02f, 1.56171918e-01f, 6.29216013e-03f, 3.02536696e-01f, -1.05072908e-01f, 1.02780819e-01f, 3.31719488e-01f, -7.82846436e-02f, 2.67832875e-01f,
  3.75756472e-02f, 1.48490623e-01f, 6.05420694e-02f, 2.09475830e-02f, -1.58122092e-01f, -7.70235434e-02f, -4.93867770e-02f, 4.39039152e-03f, 1.15777096e-02f, -1.09982073e-01f,
  -1.65522203e-01f, 3.59872162e-01f, -5.74016906e-02f, -1.19784430e-01f, -2.42209628e-01f, -1.20071702e-01f, -2.19887525e-01f, -1.47829205e-01f, -9.53788385e-02f, 2.33776987e-01f,
  5.81506900e-02f, 5.82014769e-03f, -1.04938880e-01f, 1.71534732e-01f, 2.59377331e-01f, 1.73998564e-01f, 1.15690842e-01f, -2.45933503e-01f, 4.11081500e-02f, 1.70382574e-01f,
  4.02607247e-02f, -1.13469653e-01f, 7.16095418e-02f, -9.83306989e-02f, 7.05872774e-02f, -7.09201917e-02f, -3.17794681e-02f, 3.39060754e-01f, -1.25433013e-01f, 1.90505028e-01f,
  3.09327483e-01f, -2.07312822e-01f, 2.42247790e-01f, -2.24626049e-01f, -5.98603822e-02f, 1.77860320e-01f, 3.49318653e-01f, -1.48097843e-01f, 9.06326249e-02f, -1.72268108e-01f,
  3.08060110e-01f, -5.16609848e-02f, 1.78637818e-01f, 1.58199236e-01f, 6.47332519e-04f, 1.39904946e-01f, 9.44872797e-02f, 1.89846590e-01f, 1.17745243e-01f, 2.56576926e-01f,
  -3.69099602e-02f, 7.84293413e-02f, -1.19038641e-01f, 9.69218537e-02f, 1.67112753e-01f, 1.57809004e-01f, -4.65333201e-02f, 5.45763448e-02f, -1.67209521e-01f, -1.02036424e-01f,
  -1.04680173e-01f, 2.85162687e-01f, -1.53688669e-01f, 3.48883271e-02f, -1.49755970e-01f, 2.37129126e-02f, 2.98416823e-01f, -1.91573754e-01f, 1.19589753e-02f, -1.03928797e-01f,
  9.86678973e-02f, 8.32665265e-02f, -6.20917678e-02f, 1.29349798e-01f, -8.83040577e-03f, -5.21362275e-02f, 8.35402608e-02f, -7.77148157e-02f, 2.33817846e-01f, -6.58328757e-02f,
  -3.97715978e-02f, -2.38411427e-01f, 4.36146334e-02f, 1.13405481e-01f, -2.56967723e-01f, -1.17310010e-01f, 1.97463572e-01f, 1.19873688e-01f, 2.54832566e-01f, -1.05336085e-01f,
  -5.75107001e-02f, 2.90033311e-01f, 8.08089003e-02f, 8.93828124e-02f, 1.78242698e-01f, -7.86155760e-02f, 1.44064322e-01f, -2.99811605e-02f, 1.78276658e-01f, 1.55937210e-01f,
  -2.23158717e-01f, 3.43086459e-02f, 1.14961550e-01f, 1.23247012e-01f, 1.83681875e-01f, -1.11823529e-01f, 1.83067128e-01f, -5.95544316e-02f, -1.06535375e-03f, 2.31939271e-01f,
  -1.72604740e-01f, 2.54707068e-01f, -1.48228526e-01f, -2.13381067e-01f, 5.60992695e-02f, 2.95362920e-01f, 5.54427803e-02f, 3.15673277e-02f, 2.28763238e-01f, 3.08506750e-02f,
  -1.57207191e-01f, -1.51407465e-01f, 8.82116035e-02f, -1.72113359e-01f, -2.11795494e-01f, -8.20926726e-02f, 2.09500760e-01f, -1.67214230e-01f, 2.13458359e-01f, -2.69902289e-01f,
  1.82624623e-01f, -6.03713430e-02f, 2.49936268e-01f, -1.56376008e-02f, 4.98412596e-03f, 7.06384405e-02f, -2.91932672e-01f, -1.01434812e-03f, -2.87922412e-01f, 9.55588967e-02f,
  -1.15882223e-02f, -8.50378424e-02f, -6.97259977e-02f, 1.48897350e-01f, 6.67122100e-03f, -5.28988242e-02f, 1.10647187e-01f, 1.13371853e-02f, 5.97298257e-02f, -2.27523576e-02f,
  9.47196931e-02f, -6.67600706e-02f, 2.11284757e-01f, 1.60830542e-01f, -4.42276672e-02f, 1.26396462e-01f, 2.36608490e-01f, 9.53354985e-02f, 9.76273939e-02f, -1.35666609e-01f,
  -3.69979292e-02f, -7.86102489e-02f, 1.14122577e-01f, 7.22437128e-02f, -3.38594794e-01f, 1.61830142e-01f, -9.53342170e-02f, -9.94811486e-03f, 2.80178338e-01f, 6.76016286e-02f,
  1.92546681e-01f, 8.59003216e-02f, 4.31103297e-02f, 1.72526404e-01f, 6.98234215e-02f, 6.41113669e-02f, -2.09705308e-02f, 2.37096667e-01f, 1.58513084e-01f, -1.97166935e-01f,
  8.09319541e-02f, 1.69654027e-01f, 1.06421657e-01f, -2.89285704e-02f, 1.21398754e-01f, 2.35655770e-01f, -3.12116742e-01f, 2.63707221e-01f, 3.03678632e-01f, 1.43178701e-01f,
  -2.95921043e-02f, -9.55341011e-02f, -3.04426491e-01f, 5.62000096e-01f, 8.89377892e-02f, -4.49338555e-02f, -2.05622390e-01f, 3.97341669e-01f, 1.09010577e-01f, -9.11599845e-02f,
  4.26067673e-02f, -1.00741185e-01f, 9.36210826e-02f, -5.14780879e-02f, -3.10434341e-01f, -2.33456623e-02f, 3.21249701e-02f, -8.35863799e-02f, -1.53520256e-01f, -2.38021642e-01f,
  -4.96659689e-02f, 1.14447124e-01f, -6.27381876e-02f, -3.17255735e-01f, 4.36581522e-02f, -2.80191243e-01f, 1.53129682e-01f, -1.40265673e-01f, -2.57933408e-01f, 3.89717445e-02f,
  -9.30643007e-02f, 2.55505778e-02f, 3.95476930e-02f, 7.28036091e-02f, 2.03904524e-01f, 2.37503618e-01f, 3.21372181e-01f, 6.38163239e-02f, 4.09595929e-02f, -1.77578866e-01f,
  -2.63268501e-02f, 8.59582126e-02f, 7.35611692e-02f, 1.21812802e-02f, 2.18863904e-01f, 4.51540388e-02f, 7.53214732e-02f, 3.32577348e-01f, -7.60660395e-02f, 1.16763413e-01f,
  -1.12329572e-01f, 3.89546826e-02f, 1.48340330e-01f, 5.42495474e-02f, 1.75711870e-01f, 1.24723809e-02f, 1.03248328e-01f, 3.96108665e-02f, -9.11282822e-02f, 2.19232105e-02f,
  2.08561301e-01f, -1.93662848e-02f, -1.90001190e-01f, 2.41126448e-01f, 5.23835272e-02f, 8.02846402e-02f, -8.45185593e-02f, -6.96354508e-02f, 4.15929884e-01f, -5.59646226e-02f,
  2.05592483e-01f, 3.15060794e-01f, 1.49684593e-01f, 3.12779933e-01f, 1.84195191e-01f, 8.81942362e-03f, -1.17319524e-01f, 1.11800924e-01f, -7.67456964e-02f, -2.47106869e-02f,
  1.16961256e-01f, -1.55986426e-02f, -6.64432794e-02f, -9.44474787e-02f, 5.28446697e-02f, 2.41210759e-01f, 3.85454856e-02f, -1.60802990e-01f, 1.93173140e-02f, -1.38193920e-01f,
  2.13372737e-01f, 1.45894885e-01f, 4.24326956e-02f, -7.09382594e-02f, 6.43402785e-02f, 2.01358974e-01f, 1.51054516e-01f, -3.50401402e-02f, 1.25069737e-01f, 4.16749120e-02f,
  3.70476663e-01f, 1.76193435e-02f, -1.02353439e-01f, 7.53178447e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.24415398e-01f, 5.82886897e-02f, 1.05316319e-01f, 1.04402900e-01f, -3.71359214e-02f, 2.00546399e-01f, 1.84341431e-01f, 6.00449368e-02f, -8.19487572e-02f, 8.50459933e-02f,
  1.38133213e-01f, -3.38591225e-02f, -3.05588376e-02f, 3.46319377e-02f, 1.04655825e-01f, 9.38340053e-02f, 9.72116143e-02f, 2.10444167e-01f, 8.50610808e-02f, 1.08394533e-01f,
  2.24127188e-01f, 1.92724377e-01f, 9.12133679e-02f, -9.80156809e-02f, 8.11500289e-03f, 2.21455675e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.58614591e-01f, -2.29943916e-02f, -8.78168084e-03f, 4.84280102e-02f, -6.12008870e-02f, -7.69157484e-02f, 1.51596546e-01f, -1.13452069e-01f, 2.81186402e-02f, 9.24807217e-04f,
  -3.47429439e-02f, -2.55557336e-02f, -2.42563095e-02f, 1.10924706e-01f, -2.47108653e-01f, 6.76267501e-03f, 1.07642069e-01f, 9.09744054e-02f, -6.51521310e-02f, 2.86188647e-02f,
  -3.31015617e-01f, 3.81055400e-02f, 1.10805005e-01f, -1.80593774e-01f, -1.07136026e-01f, -1.28360838e-01f, 4.35473323e-02f, -1.30842850e-01f, -1.86596841e-01f, 8.80285427e-02f,
  -2.27441955e-02f, 1.86252385e-01f, 2.49113604e-01f, 8.39215666e-02f, 2.49346159e-02f, 1.51895722e-02f, -5.72303906e-02f, -1.24025404e-01f, 1.26716062e-01f, -9.73571539e-02f,
  4.65864204e-02f, 1.08886011e-01f, -1.26370981e-01f, 6.85157180e-02f, -7.78834000e-02f, -9.54542458e-02f, -2.39915699e-01f, 1.49321020e-01f, 5.70192076e-02f, 7.64357746e-02f,
  -7.21350312e-02f, 1.02022856e-01f, 8.99373963e-02f, -4.57743090e-03f, -8.87730718e-02f, -2.24223629e-01f, 8.76562297e-03f, 2.03609586e-01f, -1.91614315e-01f, 1.16954120e-02f,
  1.74653158e-01f, -6.11016266e-02f, -1.12128839e-01f, 1.61310390e-01f, -2.82510575e-02f, 1.28424510e-01f, -1.23796269e-01f, -6.44765198e-02f, -2.47976519e-02f, -7.87704960e-02f,
  -3.82595398e-02f, 4.96511422e-02f, -2.26759031e-01f, -6.00619428e-02f, 7.16804042e-02f, -1.05949678e-01f, 1.96373574e-02f, -2.28551030e-01f, -4.07111943e-02f, -1.58873834e-02f,
  -1.89839721e-01f, 7.07226321e-02f, -1.09647149e-02f, -6.69137910e-02f, -9.88658816e-02f, 1.62029102e-01f, 1.54892579e-01f, -5.72366491e-02f, 1.23189263e-01f, 3.46590877e-01f,
  6.67014346e-02f, 8.89941212e-03f, 1.15256071e-01f, 1.99799538e-01f, -2.99674515e-02f, 1.02813520e-01f, 1.71907783e-01f, -1.73769012e-01f, 5.07425778e-02f, -9.81180817e-02f,
  7.19504654e-02f, -1.42976299e-01f, 3.83336358e-02f, 1.66851327e-01f, -2.39480305e-02f, 2.09266946e-01f, 8.07048455e-02f, -1.46719426e-01f, 4.23131064e-02f, -1.24156289e-02f,
  9.90913883e-02f, 1.45025671e-01f, 2.19049886e-01f, 2.05573693e-01f, 7.52618909e-02f, -9.12284926e-02f, -1.28709778e-01f, -9.34398845e-02f, 4.43864353e-02f, 2.11224165e-02f,
  9.20771658e-02f, -7.23974267e-03f, -6.33305311e-02f, -3.45244221e-02f, -4.39353734e-02f, 1.47592217e-01f, -1.85067967e-01f, 1.36677250e-01f, -1.21197484e-01f, 9.25846919e-02f,
  -1.99702326e-02f, 1.30116984e-01f, -1.86210424e-01f, 1.71836391e-01f, -1.02495953e-01f, -1.14269510e-01f, -2.10490540e-01f, -2.59625375e-01f, 2.22150117e-01f, 2.99979709e-02f,
  1.14776976e-01f, -1.80155531e-01f, -8.37543681e-02f, -2.06959751e-02f, -2.65109707e-02f, -3.35690007e-02f, 1.08387187e-01f, 2.07017198e-01f, -3.29372972e-01f, -1.26576215e-01f,
  6.95806369e-02f, -2.07510471e-01f, -5.81695363e-02f, -1.32600427e-01f, -9.57854837e-02f, -1.50059566e-01f, -1.79419592e-01f, 2.17293173e-01f, 9.03655812e-02f, -1.98106945e-01f,
  -3.25688124e-01f, 1.46351904e-01f, 1.45827144e-01f, -1.73531637e-01f, -1.90941125e-01f, 1.78282484e-01f, 5.18886186e-02f, 7.91737065e-02f, 1.49646178e-01f, -1.06339402e-01f,
  7.53221288e-02f, 1.04936682e-01f, -6.34119883e-02f, -2.43219420e-01f, 2.90356129e-01f, 7.85188656e-03f, -2.80579589e-02f, -6.95590973e-02f, -1.00445859e-01f, -6.22553118e-02f,
  -3.85411531e-02f, -7.58356676e-02f, 6.59338525e-03f, -2.24843230e-02f, -1.63870171e-01f, -1.98693261e-01f, 5.93757890e-02f, 4.57994593e-03f, -1.27518103e-01f, -1.11593813e-01f,
  9.62935984e-02f, 1.11139730e-01f, 7.14738294e-02f, 1.73982352e-01f, 5.45171984e-02f, -3.70447175e-03f, -1.89126767e-02f, -9.48545784e-02f, 8.58636945e-02f, -8.27401429e-02f,
  5.61518297e-02f, 1.72968090e-01f, -5.83230630e-02f, 2.93599349e-02f, -3.16692948e-01f, -1.23684015e-02f, 1.18773831e-02f, 2.05589861e-01f, -2.06043243e-01f, 9.38328654e-02f,
  -7.16534406e-02f, 1.01252869e-02f, 7.11031631e-02f, -1.94563996e-02f, -2.59417385e-01f, 4.85415235e-02f, 1.36991903e-01f, -1.76763162e-01f, 4.33933213e-02f, 3.53104882e-02f,
  2.63824552e-01f, -6.44702688e-02f, -1.61574855e-01f, 6.41035214e-02f, 1.23786647e-02f, -1.19221985e-01f, 8.90886188e-02f, 7.64088109e-02f, -1.22893490e-01f, -3.96889113e-02f,
  -1.03581073e-02f, -1.12713747e-01f, -2.37893134e-01f, 2.32888743e-01f, -8.73109475e-02f, -5.96969090e-02f, -9.16740149e-02f, 3.67788784e-02f, -1.00677535e-01f, 6.74640061e-03f,
  -8.09652656e-02f, -1.47280842e-01f, -1.88127175e-01f, -3.89392278e-03f, 1.26729473e-01f, 1.27955198e-01f, -1.50012910e-01f, 1.68614485e-03f, -3.03229038e-02f, 7.81396776e-02f,
  -2.75297724e-02f, -1.47492513e-01f, -9.94938388e-02f, -2.03836292e-01f, 4.85517345e-02f, -2.36460287e-02f, -3.33790511e-01f, -3.10106248e-01f, -1.37804123e-03f, -1.28840253e-01f,
  -2.15250298e-01f, 1.55334800e-01f, 9.77321863e-02f, -1.29778489e-01f, -1.35084882e-01f, 1.50509506e-01f, -2.62387305e-01f, -6.35936260e-02f, 1.20783642e-01f, 9.74726528e-02f,
  -6.12460189e-02f, -3.97506982e-01f, -9.14571732e-02f, -1.68982059e-01f, 9.72511619e-02f, -4.98504825e-02f, -3.51754948e-02f, -3.43289934e-02f, 1.70363769e-01f, -1.87008083e-01f,
  1.12756118e-01f, 2.16309294e-01f, -2.95895875e-01f, -7.29750842e-02f, 2.81851649e-01f, 2.82477327e-02f, 1.38893634e-01f, -2.65718140e-02f, 2.58041501e-01f, -4.78953980e-02f,
  1.78239912e-01f, -4.58939783e-02f, -4.90810461e-02f, -1.27720907e-01f, 3.91058065e-02f, -1.54308289e-01f, 1.16184324e-01f, 2.30730712e-01f, -1.79584939e-02f, 6.36458024e-02f,
  -1.16360582e-01f, 1.21315233e-01f, 1.81336701e-01f, -4.06288654e-02f, -4.63095717e-02f, -4.22567837e-02f, 6.45732088e-03f, -7.55692422e-02f, 1.28849998e-01f, -1.99036077e-01f,
  -9.57056414e-03f, -1.19706526e-01f, 1.34443417e-02f, 1.38869062e-01f, 5.41763492e-02f, -4.88982499e-02f, -1.17773749e-01f, -9.61797908e-02f, -7.31883347e-02f, -2.73620635e-02f,
  2.34259456e-01f, 8.01623687e-02f, 1.98522136e-01f, -1.05002532e-02f, 1.41965345e-01f, 9.93940756e-02f, 7.73419440e-02f, 2.53744692e-01f, -4.04327326e-02f, 9.26962271e-02f,
  1.24592923e-01f, 3.67857069e-02f, -1.09544888e-01f, 1.18714198e-01f, 9.79111493e-02f, 1.40014321e-01f, -6.05512373e-02f, 1.44808963e-01f, 6.09758385e-02f, -2.28080004e-01f,
  -1.31779566e-01f, 1.27903214e-02f, -1.59795787e-02f, -1.22320235e-01f, -2.01098084e-01f, -2.42474869e-01f, -1.37172602e-02f, -1.17448919e-01f, -1.19485527e-01f, 4.26819474e-02f,
  -2.02548839e-02f, -2.12264024e-02f, -8.42651501e-02f, 4.82237674e-02f, -1.85504094e-01f, -2.95437723e-02f, -2.76604537e-02f, 2.39922613e-01f, 4.26679663e-02f, 9.63143557e-02f,
  -7.27214366e-02f, -4.07383777e-02f, 9.48615223e-02f, -1.63567558e-01f, 1.04352131e-01f, -2.09169120e-01f, -6.25350103e-02f, -6.16534501e-02f, 8.15447718e-02f, 7.28308260e-02f,
  9.71326977e-02f, 1.75202057e-01f, -2.87597299e-01f, 1.56416282e-01f, -9.50123444e-02f, 1.43669769e-01f, -1.05905131e-01f, -1.41137376e-01f, 3.63545358e-01f, -8.16578418e-02f,
  6.58154935e-02f, 2.67019048e-02f, 2.29066044e-01f, -4.92052101e-02f, -3.95241827e-02f, -1.26554463e-02f, 6.70548603e-02f, -1.02564789e-01f, -3.71859595e-02f, 6.97935075e-02f,
  1.96895599e-01f, 1.98801812e-02f, -1.54686093e-01f, 6.01078616e-03f, 1.81948692e-01f, -6.40469491e-02f, 1.71288460e-01f, -7.38087893e-02f, -9.79581699e-02f, -2.24695131e-01f,
  -6.95878789e-02f, -6.48896173e-02f, 1.99927270e-01f, 1.09021194e-01f, 2.10213393e-01f, -1.93288714e-01f, -1.32455602e-01f, 1.24253510e-02f, -1.10429816e-01f, -7.59462118e-02f,
  1.70502499e-01f, -2.12483868e-01f, 1.58154055e-01f, -1.12681247e-01f, -1.29999444e-02f, 8.01860169e-02f, -1.96628615e-01f, -3.52721550e-02f, 1.33525893e-01f, 1.28606662e-01f,
  1.47904810e-02f, -1.46399856e-01f, 7.82715231e-02f, -4.46692444e-02f, -8.61370116e-02f, 1.40258148e-01f, -8.58048946e-02f, -1.09167941e-01f, 6.88017532e-02f, 2.70782769e-01f,
  -7.62224942e-02f, -1.27184629e-01f, 2.55812854e-01f, -4.11839364e-03f, 1.40822127e-01f, -1.52247459e-01f, -8.92182812e-02f, -4.25067730e-03f, -9.13533866e-02f, 1.57079250e-01f,
  -7.94555545e-02f, 2.05173139e-02f, 3.01405728e-01f, 5.10874577e-02f, -1.34197190e-01f, 4.06059362e-02f, -1.08053975e-01f, -9.82155502e-02f, 1.76542163e-01f, -1.97724596e-01f,
  5.87108452e-03f, -1.59971062e-02f, 1.15747184e-01f, -6.58985078e-02f, -5.51867932e-02f, -1.84491288e-03f, 2.51305755e-02f, -2.08154954e-02f, -3.40026878e-02f, -7.06288591e-02f,
  -1.07201874e-01f, 1.97327629e-01f, -2.22097740e-01f, -8.65333602e-02f, 4.81948964e-02f, -1.79400340e-01f, -3.40723507e-02f, 9.13180411e-02f, 2.13123366e-01f, -8.09397101e-02f,
  -1.05224997e-01f, -2.66130324e-02f, -1.50342673e-01f, -1.55540869e-01f, -1.82584450e-01f, 1.03201881e-01f, 2.48820484e-01f, -9.45018455e-02f, -1.33122757e-01f, 1.52977286e-02f,
  2.95109272e-01f, 1.14466222e-02f, 1.22370958e-01f, 1.56288184e-02f, -5.45344241e-02f, 5.83922230e-02f, -4.01071757e-02f, 1.91268511e-02f, -5.50733767e-02f, 2.17834100e-01f,
  -1.27471030e-01f, 1.32911965e-01f, 1.08245881e-02f, -3.79557870e-02f, 9.70528126e-02f, 1.41897604e-01f, -2.74694115e-01f, -9.78621170e-02f, -3.49384733e-02f, -1.54679924e-01f,
  1.63505822e-01f, 3.82790565e-02f, -6.61039427e-02f, -1.62946403e-01f, 2.86858976e-02f, 1.02623448e-01f, -1.31778672e-01f, -3.83548476e-02f, -2.15762839e-01f, -6.02045432e-02f,
  -7.45801181e-02f, -5.74924722e-02f, -1.64375767e-01f, 1.90405309e-01f, 9.02419724e-03f, 1.52945086e-01f, -5.52919842e-02f, 4.90924269e-02f, 1.35001168e-01f, -5.93892895e-02f,
  -1.85301006e-01f, 1.93071052e-01f, -8.40224698e-03f, 6.74736127e-02f, -1.14702843e-02f, 2.15163618e-01f, -1.00178309e-01f, 1.86743021e-01f, -2.16392770e-01f, -2.23010033e-01f,
  -2.68455800e-02f, -2.29821596e-02f, 2.67371297e-01f, 1.21803291e-01f, 1.65204585e-01f, 1.94695964e-03f, 1.80397168e-01f, -4.07233506e-01f, 2.51939684e-01f, -6.13579191e-02f,
  2.11933658e-01f, 8.43879730e-02f, 1.82718158e-01f, -7.26263598e-02f, 1.34838205e-02f, 9.96182486e-02f, 3.62924367e-01f, 5.82575612e-02f, -7.45274723e-02f, -9.77215990e-02f,
  -9.52852610e-03f, -2.30176784e-02f, 1.28084615e-01f, 1.85533077e-01f, -2.92844195e-02f, -1.52965426e-01f, -9.81082469e-02f, 1.71418369e-01f, 1.81477785e-01f, 4.14640754e-02f,
  2.13400349e-01f, -9.48926583e-02f, 8.63193572e-02f, -1.17241494e-01f, -1.13491053e-02f, 6.53724093e-03f, 2.76130531e-02f, 6.25517406e-03f, 2.85242554e-02f, 1.95752636e-01f,
  -2.39772826e-01f, 1.99663326e-01f, -3.21352892e-02f, 5.05608357e-02f, -1.20114215e-01f, -7.56496415e-02f, -1.80401295e-01f, -8.05964619e-02f, 2.79261321e-02f, -1.05291806e-01f,
  -1.78387672e-01f, -5.78993410e-02f, -1.23274937e-01f, 7.20003061e-03f, 5.79871945e-02f, -1.94193661e-01f, -1.67730674e-02f, 9.27239582e-02f, -2.98002008e-02f, -1.22498997e-01f,
  -2.21319288e-01f, 3.37266997e-02f, 7.53875226e-02f, 5.39233424e-02f, -2.40398496e-01f, 9.03712586e-02f, -3.38375568e-01f, -1.64805293e-01f, -4.59890142e-02f, 8.37084930e-03f,
  -1.42785683e-01f, -8.54830220e-02f, -4.64329273e-02f, -1.15388878e-01f, -5.96928820e-02f, 2.16896355e-01f, 4.83887643e-02f, -1.94160901e-02f, -6.62820488e-02f, -3.98632959e-02f,
  -1.14915989e-01f, -2.18937740e-01f, -2.93919712e-01f, 1.43884838e-01f, 1.35496542e-01f, -8.51842090e-02f, -6.86521083e-02f, -1.06749624e-01f, 1.56771272e-01f, -9.87452567e-02f,
  -7.24554956e-02f, -9.31881741e-02f, -8.74987841e-02f, -2.03469276e-01f, -3.91446650e-02f, -1.15828149e-01f, 4.27864492e-02f, 1.81782395e-01f, -2.30453625e-01f, 3.13186236e-02f,
  1.99769557e-01f, 1.53456673e-01f, -1.17231458e-01f, -1.19305961e-01f, -4.25588116e-02f, 1.83242574e-01f, 7.61873797e-02f, -1.01662867e-01f, 7.31167123e-02f, 1.15160249e-01f,
  2.05849811e-01f, -1.85052037e-01f, -5.67845777e-02f, -1.05531067e-01f, 7.45746419e-02f, 2.48472132e-02f, -1.34578511e-01f, 1.54718971e-02f, -6.45208284e-02f, -5.54322489e-02f,
  -1.39217926e-02f, -1.24744862e-01f, -1.11656129e-01f, -1.38195688e-02f, 3.48052420e-02f, -1.44154310e-01f, -2.59873837e-01f, -5.28115779e-02f, 3.54831405e-02f, 1.32153079e-01f,
  6.98728263e-02f, 7.63993487e-02f, 8.96440819e-03f, 2.34353170e-03f, -5.64012453e-02f, 9.80380028e-02f, -1.47757515e-01f, -8.76933262e-02f, 4.02927119e-03f, 9.85768512e-02f,
  -1.99363112e-01f, -1.51639938e-01f, 1.35406628e-01f, -4.06827293e-02f, -8.19686875e-02f, -3.52982618e-02f, -2.69563328e-02f, -6.21961430e-02f, 1.22481734e-01f, 1.99133810e-02f,
  -2.67834961e-02f, 2.67122775e-01f, -9.56174061e-02f, 1.40732452e-01f, -1.61525160e-01f, -1.92628369e-01f, 3.27947661e-02f, 7.29863904e-03f, -4.83688489e-02f, 6.75393045e-02f,
  -2.03636050e-01f, -1.27718329e-01f, 4.04852815e-02f, -2.36482676e-02f, -1.38786525e-01f, -2.26602331e-01f, 1.14735946e-01f, 1.08269006e-01f, 1.06342286e-01f, -1.55913845e-01f,
  -7.74627700e-02f, -1.56675681e-01f, -9.88552496e-02f, -1.03840634e-01f, 1.34879174e-02f, 5.30901179e-02f, 1.16245359e-01f, -7.95794502e-02f, -1.46478340e-01f, 1.27729133e-01f,
  2.08454192e-01f, -5.89187071e-03f, 5.19889547e-03f, 3.15106623e-02f, 1.14174455e-01f, 1.82537645e-01f, 1.18762746e-01f, 8.59090388e-02f, 9.49448496e-02f, 1.91242367e-01f,
  -4.83394507e-03f, 6.82965443e-02f, 2.47894138e-01f, -1.96423456e-01f, 1.72871873e-01f, -4.42167446e-02f, -7.55150318e-02f, 2.09670022e-01f, 3.10008172e-02f, -1.55560166e-01f,
  -4.02704269e-01f, -1.17102198e-01f, 6.11327626e-02f, 2.32420549e-01f, 5.24022989e-02f, 6.57966584e-02f, -1.79606900e-01f, -5.84449545e-02f, -5.63202575e-02f, 1.90811023e-01f,
  -1.15088634e-01f, 5.80470897e-02f, 1.45345718e-01f, -5.61734252e-02f, 1.90530100e-03f, -1.34555660e-02f, -1.03806525e-01f, 1.05230235e-01f, 7.80625567e-02f, 1.22415088e-01f,
  1.16024971e-01f, -2.07997844e-01f, -1.01543367e-01f, -1.40779734e-01f, -2.13714123e-01f, 3.92015800e-02f, -1.37552664e-01f, 2.34373137e-02f, -5.24707651e-03f, 6.52069822e-02f,
  -6.78125843e-02f, 2.67831292e-02f, 1.79726094e-01f, 2.82577556e-02f, 8.67927261e-03f, -1.52891994e-01f, 1.56017110e-01f, -3.58677246e-02f, -2.77888089e-01f, 2.21729636e-01f,
  1.10922500e-01f, 5.66677712e-02f, 8.93329009e-02f, 8.74057878e-03f, 6.64404109e-02f, 1.59033448e-01f, -6.72581121e-02f, 1.01433158e-01f, -7.97807276e-02f, -9.79260169e-03f,
  -2.13836610e-01f, 1.71449542e-01f, -1.48716956e-01f, 6.05170205e-02f, -2.70564854e-01f, -1.63763374e-01f, -7.39303529e-02f, 7.06205368e-02f, 9.18048844e-02f, 6.54452965e-02f,
  1.62414357e-01f, -1.24396756e-01f, 5.72393499e-02f, -1.86473597e-02f, 2.78261244e-01f, 2.62590908e-02f, 3.93490605e-02f, 3.05345561e-03f, 5.25060631e-02f, 1.93282273e-02f,
  -8.06496367e-02f, 9.98367444e-02f, 2.05759391e-01f, -1.01319030e-01f, 1.99301943e-01f, -5.47844805e-02f, -2.17705995e-01f, 7.08634779e-02f, 6.06201068e-02f, -4.25404906e-02f,
  3.03597674e-02f, -6.86154887e-02f, -1.47713840e-01f, 1.07654162e-01f, 2.93885887e-01f, 1.76494300e-01f, 1.87867507e-01f, -4.98665906e-02f, 1.86514646e-01f, 2.38239951e-03f,
  7.54005928e-03f, 2.71839369e-02f, 5.93842529e-02f, 6.76098242e-02f, -5.50783128e-02f, 3.61142121e-02f, -1.35821417e-01f, 1.46228045e-01f, 2.95476001e-02f, 1.25316814e-01f,
  -3.52244303e-02f, -5.79383262e-02f, 8.42143446e-02f, 1.59777084e-03f, 9.70756933e-02f, 7.34676495e-02f, 2.50805169e-01f, -1.28710479e-01f, 7.58046210e-02f, -1.77037381e-02f,
  1.60472065e-01f, 1.87973559e-01f, 2.68803351e-02f, -1.16641773e-02f, -8.54009297e-03f, 1.51825296e-02f, 2.07751974e-01f, 3.36071640e-01f, -3.74705270e-02f, 1.41524062e-01f,
  -1.40535414e-01f, -1.92676201e-01f, -8.70451108e-02f, 1.08815745e-01f, -2.99204290e-01f, 2.87804216e-01f, 2.83421930e-02f, -3.33443969e-01f, 1.64343998e-01f, 4.58912887e-02f,
  1.21747702e-02f, -8.23068768e-02f, 1.50335237e-01f, 1.09170310e-01f, -2.31981352e-01f, -5.34572490e-02f, -1.15392014e-01f, 7.31338561e-03f, -1.03090242e-01f, -9.55782980e-02f,
  -2.95654219e-02f, -9.65824425e-02f, -6.70980811e-02f, -8.58295336e-02f, 9.84554291e-02f, -2.69932598e-01f, -9.81106889e-03f, 1.80355102e-01f, -9.88222957e-02f, -1.72614306e-02f,
  1.67594492e-01f, 7.60443285e-02f, 4.37760577e-02f, 1.16011024e-01f, -6.71741664e-02f, 1.84568986e-01f, -3.04629095e-02f, 1.75983846e-01f, 1.43484741e-01f, 2.58593727e-02f,
  -5.93827553e-02f, 8.11774209e-02f, 1.42425194e-01f, -3.76220755e-02f, -3.11722960e-02f, -1.51241422e-01f, 5.79518117e-02f, -5.27220480e-02f, -2.42189571e-01f, 1.74037024e-01f,
  2.45933998e-02f, 2.15386357e-02f, -2.67849654e-01f, -1.26790762e-01f, -3.74011025e-02f, 8.85583833e-02f, -1.91319138e-01f, 2.07599804e-01f, -1.44103318e-01f, -1.48328036e-01f,
  -6.08736537e-02f, 2.29505617e-02f, 2.22585797e-01f, 1.52212620e-01f, 8.17368850e-02f, 2.57011540e-02f, -8.88694599e-02f, -2.40134403e-01f, -9.29316208e-02f, -7.84434527e-02f,
  1.19432330e-01f, -1.38386413e-02f, 1.56338394e-01f, -9.13165212e-02f, -1.45484954e-01f, -1.57447338e-01f, 9.07535106e-02f, 1.35959059e-01f, 1.65884107e-01f, -8.76012892e-02f,
  -2.62834989e-02f, 3.25773098e-02f, 2.17182562e-01f, -9.99306068e-02f, 5.80967367e-02f, 7.06060231e-02f, -7.65836760e-02f, -2.47167237e-02f, 9.53329355e-03f, 1.35583684e-01f,
  1.14039116e-01f, -5.31385839e-02f, -2.40269199e-01f, 1.47789240e-01f, -1.63314164e-01f, 1.04112640e-01f, -2.30056882e-01f, 7.48176128e-02f, 7.65619129e-02f, 1.73364118e-01f,
  -4.28935774e-02f, -1.28286317e-01f, 1.51721328e-01f, 2.37465501e-02f, -2.78181404e-01f, -5.84078953e-02f, -3.26578319e-02f, 4.05733194e-03f, -6.63810074e-02f, -7.04479869e-03f,
  -9.86068621e-02f, -8.68560150e-02f, 1.62858188e-01f, 2.46465534e-01f, 1.19713187e-01f, 8.09271038e-02f, 1.76170588e-01f, -1.57951608e-01f, 3.69010679e-02f, 2.22462729e-01f,
  -1.60901099e-01f, -1.83265373e-01f, -1.41885176e-01f, 1.85717553e-01f, -5.86440926e-03f, -1.46753816e-02f, -2.46290460e-01f, 4.18967269e-02f, 1.41127124e-01f, -7.78060183e-02f,
  1.98377997e-01f, -3.60246450e-01f, -4.06129956e-02f, -4.61396426e-02f, -3.52441543e-03f, -6.08582310e-02f, -1.59017980e-01f, -1.61584944e-01f, 3.61074001e-01f, -1.53417408e-01f,
  -1.78262033e-02f, 1.41264886e-01f, 6.50774240e-02f, 1.85822874e-01f, -1.16907731e-01f, -5.29638119e-03f, -5.00056371e-02f, 1.15327418e-01f, -7.64967725e-02f, -1.16311200e-01f,
  -1.71184704e-01f, 1.59617662e-01f, -8.16898793e-02f, 1.08511306e-01f, 1.42811760e-02f, -2.00408399e-02f, -1.34229019e-01f, -1.31743133e-01f, 3.69102247e-02f, -1.16056643e-01f,
  1.40736979e-02f, 5.69492467e-02f, -1.79598317e-01f, -2.23841835e-02f, -2.20860392e-01f, 1.02430739e-01f, -3.09459995e-02f, 3.31277013e-01f, 1.38689443e-01f, -1.47063747e-01f,
  -6.82906508e-02f, 5.98820567e-04f, 3.97756211e-02f, -8.42143968e-02f, -4.86368835e-02f, 6.16304465e-02f, 1.35670036e-01f, 9.17582139e-02f, -9.36203822e-02f, 1.36727750e-01f,
  2.10868970e-01f, -2.01365739e-01f, -1.98041112e-03f, 7.37035871e-02f, -6.96532801e-02f, 1.42997950e-01f, -1.26880631e-01f, -4.53918474e-03f, 1.23928703e-01f, 9.10613965e-03f,
  -7.16990903e-02f, 1.52828351e-01f, 1.11410759e-01f, -1.91015199e-01f, -4.53049131e-02f, -9.94638726e-02f, -1.82743538e-02f, 1.14149362e-01f, -4.72000316e-02f, -1.12695180e-01f,
  -2.34671399e-01f, -1.74932688e-01f, 2.80702591e-01f, 1.43640442e-03f, -7.43129104e-02f, -2.66659483e-02f, -2.19650358e-01f, -1.50311571e-02f, -9.49667320e-02f, 2.54352558e-02f,
  -5.91301955e-02f, 1.40756769e-02f, 1.28847331e-01f, -1.85812473e-01f, -9.86041129e-02f, 5.28417937e-02f, 1.27910767e-02f, 5.36992364e-02f, 2.14342609e-01f, 1.04250379e-01f,
  1.42965242e-01f, -1.44033313e-01f, 1.36377113e-02f, -1.08370341e-01f, -5.20854034e-02f, -1.41952977e-01f, -2.12439686e-01f, 2.40580179e-02f, -1.24001935e-01f, 1.31608024e-01f,
  6.12502657e-02f, 1.04540065e-01f, 2.17686102e-01f, -8.41469690e-02f, -4.88604745e-03f, -5.53618073e-02f, 1.32166699e-01f, 1.72746498e-02f, 1.36428833e-01f, 1.04786329e-01f,
  8.39184150e-02f, 1.40290722e-01f, -2.11917505e-01f, -1.26309440e-01f, -4.28815670e-02f, 3.14270481e-02f, -7.94776678e-02f, 1.50020391e-01f, 2.66551286e-01f, -1.02837220e-01f,
  -1.03481241e-01f, 1.04981372e-02f, -1.63900480e-01f, 1.31454512e-01f, -1.00880362e-01f, 1.04249351e-01f, -1.63896009e-02f, -9.96715017e-03f, -1.15925297e-01f, 1.53290238e-02f,
  2.16008097e-01f, -9.17359665e-02f, 1.61007345e-02f, -1.17328167e-01f, 1.12629533e-01f, 7.21538216e-02f, -7.17139691e-02f, -6.26231357e-02f, -2.95011103e-01f, 3.10816705e-01f,
  5.52794850e-03f, 9.26665813e-02f, -3.49232852e-01f, 4.84335646e-02f, 2.71588296e-01f, -3.55943516e-02f, -1.78726777e-01f, 7.73560107e-02f, -1.40311182e-01f, -5.03022559e-02f,
  1.47797853e-01f, -1.27848238e-01f, -5.86792678e-02f, 2.14577969e-02f, -2.81723469e-01f, -2.20645238e-02f, 1.28065993e-04f, 1.58028513e-01f, 1.81220904e-01f, -6.48385063e-02f,
  -1.70542225e-01f, 1.06760725e-01f, -2.89434642e-02f, -8.20077881e-02f, 1.13133766e-01f, 6.46231249e-02f, -4.49743457e-02f, 6.82039857e-02f, -1.50081730e-02f, -1.67267490e-02f,
  -1.59145311e-01f, -9.53691155e-02f, 1.18631916e-02f, -2.62483120e-01f, -1.34869721e-02f, -3.41098815e-01f, 2.02341881e-02f, 3.68415527e-02f, -1.24916598e-01f, -7.84160756e-03f,
  2.79750466e-01f, 5.86549342e-02f, -6.07647412e-02f, -1.05432374e-02f, -1.23616584e-01f, 2.81039029e-01f, -1.01154357e-01f, 1.24071732e-01f, 2.16083959e-01f, -2.19090786e-02f,
  -9.61994380e-02f, -1.81815445e-01f, 2.65862882e-01f, 8.73465370e-03f, 8.40281844e-02f, 4.36730050e-02f, -1.23025477e-01f, -8.36355910e-02f, 4.18568216e-03f, 3.18845540e-01f,
  1.14570461e-01f, -3.66650266e-03f, 4.73317318e-02f, -1.61791027e-01f, -1.51592763e-02f, -2.63417494e-02f, -6.52934518e-03f, 8.19813386e-02f, -2.59088367e-01f, 1.03916056e-01f,
  2.77713630e-02f, -9.81533229e-02f, -5.19887209e-02f, 9.74115208e-02f, -3.01458556e-02f, -1.02263182e-01f, -5.26045859e-02f, 1.00048415e-01f, 6.24951124e-02f, -1.94369972e-01f,
  5.44637963e-02f, 7.81888440e-02f, 1.15274312e-03f, 1.61279649e-01f, -1.52585566e-01f, -9.52427275e-03f, 8.07222947e-02f, -3.75811057e-03f, 2.31538489e-02f, 1.55893397e-02f,
  -1.40347630e-01f, 1.67284131e-01f, -1.30300060e-01f, 3.63190956e-02f, 1.48752630e-01f, -2.64335036e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  8.00238475e-02f, -7.17315078e-02f, 9.72283557e-02f, -3.31843719e-02f, 1.99473858e-01f, -1.53631419e-01f, 1.11340672e-01f, 1.91783518e-01f, -4.54794109e-01f, -8.92892331e-02f,
  2.26739019e-01f, -9.35530383e-03f, 1.57753825e-01f, -1.49926215e-01f, -4.75577824e-02f, -1.24466062e-01f, -4.30623353e-01f, -8.02814513e-02f, 3.67605388e-02f, 1.34701997e-01f,
  1.50748510e-02f, 3.57735276e-01f, 1.31278783e-01f, -8.99863765e-02f, 8.12829845e-03f, -4.44069989e-02f, -8.56665820e-02f, -1.19263835e-01f, -1.56764314e-01f, 2.69133836e-01f,
  -1.23694250e-02f, 4.74655330e-02f, 1.59387678e-01f, -1.06410183e-01f, 1.59615055e-01f, 5.07261008e-02f, 9.09772888e-02f, -1.94327891e-01f, 1.77944332e-01f, 1.00879461e-01f,
  1.53219551e-01f, 4.06014800e-01f, -2.03404464e-02f, -6.36471733e-02f, -2.82872617e-01f, -1.24777608e-01f, 1.67851016e-01f, -2.67696455e-02f, 1.30906552e-01f, -1.02669552e-01f,
  1.11821026e-01f, 5.94280325e-02f, -3.33048627e-02f, -2.26726636e-01f, 2.38873754e-02f, -1.18316673e-02f, -1.47450883e-02f, -8.87008458e-02f, 3.52566868e-01f, 8.32227916e-02f,
  1.55692786e-01f, -8.93499702e-02f, -1.69008493e-01f, 6.02393337e-02f, -2.28774771e-02f, -1.34630412e-01f, 4.14262563e-02f, 4.57038879e-02f, 2.09219038e-01f, 2.29451537e-01f,
  1.13442868e-01f, -1.03285396e-02f, 2.15561584e-01f, -2.20637351e-01f, 6.70959204e-02f, 1.08222775e-01f, -1.00124426e-01f, 3.52839112e-01f, 6.39674673e-03f, 3.21530193e-01f,
  1.78367361e-01f, 2.41008863e-01f, -1.99886579e-02f, -1.56386182e-01f, -1.02577217e-01f, -1.38559356e-01f, -2.78958231e-01f, -7.48769799e-03f, 1.00046530e-01f, -3.43987137e-01f,
  1.80137947e-01f, 1.50013939e-01f, 9.67334732e-02f, -4.03325744e-02f, 2.72504419e-01f, -1.08931035e-01f, 9.74601880e-02f, -1.41016826e-01f, -6.45149797e-02f, -2.49041513e-01f,
  -2.58814901e-01f, 2.60288388e-01f, -5.94559871e-02f, -2.88199633e-01f, -4.90366109e-02f, -1.61916375e-01f, 2.97151953e-01f, -1.50549769e-01f, -4.86903563e-02f, -7.17634261e-02f,
  -4.28296685e-01f, -2.11003363e-01f, 7.86571130e-02f, -7.81149883e-03f, 1.54377669e-02f, 1.65183201e-01f, -1.88874125e-01f, -9.45673734e-02f, 2.85531998e-01f, 2.11950585e-01f,
  4.31236066e-02f, -3.59796286e-02f, -4.00284678e-01f, 2.34486982e-01f, 2.73553431e-01f, -4.81657758e-02f, 1.94910452e-01f, 9.30579193e-03f, -2.91416218e-04f, -3.00033003e-01f,
  3.30145508e-01f, -5.88758253e-02f, 8.95616114e-02f, 1.76019073e-01f, 1.37421072e-01f, 1.98883429e-01f, 3.67145002e-01f, -1.31153867e-01f, -1.48239329e-01f, -9.70743895e-02f,
  -8.29901770e-02f, 1.47710308e-01f, -6.73967088e-03f, 9.01429951e-02f, 1.18515836e-02f, 1.41885253e-02f, 4.57961895e-02f, -2.56732762e-01f, 1.62813827e-01f, 3.52478749e-03f,
  -1.66922912e-01f, 2.55444854e-01f, -4.70735319e-02f, 3.58622223e-02f, -1.53309241e-01f, -5.45791211e-03f, 1.35558367e-01f, 1.41668990e-01f, 2.12225989e-01f, 3.84983681e-02f,
  -4.25878316e-02f, -7.24685714e-02f, 1.64166465e-01f, -2.21220866e-01f, -4.59580481e-01f, 2.24483669e-01f, 8.83724615e-02f, -8.40133652e-02f, 1.03673235e-01f, -1.21802747e-01f,
  2.25819349e-02f, -6.97132945e-02f, 2.21018836e-01f, 9.44408923e-02f, 1.25196129e-01f, -4.79761064e-01f, 3.49678136e-02f, -1.16220228e-01f, 1.48530573e-01f, 5.33982776e-02f,
  -8.87911022e-02f, -2.90507853e-01f, 2.05509305e-01f, 3.73688608e-01f, -1.94432169e-01f, -4.31959257e-02f, 3.04509580e-01f, 1.08538255e-01f, 8.82449672e-02f, -1.23918124e-01f,
  9.43061411e-02f, 1.14312708e-01f, -1.32031918e-01f, 1.73744839e-02f, -3.68924886e-02f, -4.49934527e-02f, 1.66653574e-01f, 8.66192728e-02f, -4.69504409e-02f, 1.40840933e-01f,
  2.44728372e-01f, -1.33770024e-02f, -3.17412138e-01f, -1.21262558e-01f, 2.04015404e-01f, 1.48408502e-01f, 1.42112240e-01f, -1.14412926e-01f, -8.59901831e-02f, -8.94569531e-02f,
  -8.91283974e-02f, -1.93779722e-01f, -1.98965684e-01f, -3.74263197e-01f, 4.88034897e-02f, 1.89306960e-01f, -2.26816431e-01f, 1.52533084e-01f, -9.06465352e-02f, -1.80288449e-01f,
  -1.64039552e-01f, -1.29073873e-01f, -2.10942179e-02f, 3.38889472e-02f, 1.73277825e-01f, -2.33849287e-01f, 1.86310359e-03f, 1.37892932e-01f, -1.55925140e-01f, -6.51093423e-02f,
  2.26505548e-01f, -6.50825873e-02f, 1.08071826e-01f, 1.86875582e-01f, -2.65902728e-01f, 1.84252322e-01f, 1.33369267e-01f, -1.04204334e-01f, -1.22854479e-01f, 1.10399053e-01f,
  -3.19273204e-01f, 2.04781637e-01f, -4.64065462e-01f, 8.46286193e-02f, 4.14346516e-01f, -3.10442746e-01f, -7.03936294e-02f, -3.35381292e-02f, 1.21903241e-01f, 2.29129687e-01f,
  1.43625811e-01f, -3.14546436e-01f, -7.03536859e-03f, 6.39272779e-02f, 1.12585386e-03f, 1.41172290e-01f, 2.74787307e-01f, 1.10436738e-01f, 3.93223345e-01f, -1.37736797e-02f,
  7.49570057e-02f, -4.39058803e-03f, 2.91360021e-01f, 5.99445365e-02f, 1.53720781e-01f, -1.02952123e-01f, 1.82048753e-01f, 2.21243829e-01f, 1.18659921e-01f, 5.10262065e-02f,
  2.03334287e-01f, 2.23915935e-01f, -1.60601661e-01f, 6.88538328e-02f, 6.39473349e-02f, 3.91644649e-02f, -9.81559381e-02f, -3.75529863e-02f, -2.44143069e-01f, 1.06721260e-01f,
  5.89245707e-02f, -8.45490620e-02f, -2.10759431e-01f, -3.26861382e-01f, -1.33377621e-02f, 2.52208710e-01f, 1.72246650e-01f, 9.34051573e-02f, -2.10522577e-01f, -3.67028624e-01f,
  1.07137635e-01f, -4.67241462e-03f, -3.18050623e-01f, -2.93900613e-02f, 4.35031950e-01f, 1.84988789e-02f, -2.32185900e-01f, 3.70729506e-01f, -2.96891242e-01f, 1.63569823e-01f,
  6.91951439e-02f, -1.71394162e-02f, 7.83727020e-02f, -2.02940125e-02f, -2.36744657e-01f, -1.70652755e-02f, -3.18354666e-01f, 2.36415163e-01f, 2.31763095e-01f, 2.68115103e-02f,
  -9.74252820e-02f, 1.84666410e-01f, 4.93234992e-02f, 8.75775516e-02f, 3.37550849e-01f, -1.23137206e-01f, 6.90636924e-04f, -2.04939529e-01f, 1.58368364e-01f, -1.36300800e-02f,
  2.01969326e-01f, -2.93677375e-02f, -7.98072442e-02f, 2.75722980e-01f, 2.44531050e-01f, -2.38627270e-02f, -1.70140207e-01f, 1.26891956e-01f, 2.94137150e-02f, 2.78799161e-02f,
  2.62955278e-01f, 8.13128874e-02f, 2.07183450e-01f, -1.25541873e-02f, 6.63216487e-02f, 2.68564910e-01f, 2.04769015e-01f, 3.88328321e-02f, -4.36170474e-02f, -8.87753069e-02f,
  -2.84490019e-01f, -2.18462367e-02f, 1.13811512e-02f, -1.08010329e-01f, -2.79179364e-01f, -2.82880932e-01f, -1.33263871e-01f, -3.32500525e-02f, -2.20479310e-01f, 2.03016698e-01f,
  -2.11967472e-02f, -3.17263126e-01f, 3.60623479e-01f, -2.75596589e-01f, 7.19892457e-02f, -2.83593014e-02f, -8.32604766e-02f, 2.58080244e-01f, 3.50208372e-01f, -1.00793362e-01f,
  -3.81912570e-03f, 2.26699635e-01f, -7.81159997e-02f, 1.57213643e-01f, -8.32051709e-02f, -2.37383962e-01f, -1.05788469e-01f, 1.03665821e-01f, -2.47063339e-01f, 7.27917328e-02f,
  -1.47652045e-01f, 5.07449925e-01f, 3.30232412e-01f, 2.48858199e-01f, -3.84679921e-02f, -2.60043979e-01f, 1.35105044e-01f, 7.60950148e-02f, -1.46134853e-01f, -5.19283041e-02f,
  1.12965152e-01f, -5.67832664e-02f, 1.18233994e-01f, 2.77156234e-01f, -2.21337661e-01f, 2.21438289e-01f, 8.16584453e-02f, 2.39711285e-01f, -6.98213130e-02f, -9.58988518e-02f,
  -1.18227810e-01f, -1.93723738e-01f, 2.75680751e-01f, 2.39097640e-01f, -2.31467366e-01f, 2.48560980e-01f, 2.25374192e-01f, 2.64692783e-01f, 7.97644109e-02f, 1.53616607e-01f,
  2.62748003e-01f, 7.09771290e-02f, 3.10723595e-02f, 6.78768903e-02f, 1.34423181e-01f, -2.70648569e-01f, 1.78648412e-01f, -9.63892564e-02f, 1.74155936e-01f, -1.21511862e-01f,
  2.27340117e-01f, 1.50698602e-01f, -1.62235305e-01f, -3.48160774e-01f, -2.36329399e-02f, 6.94453269e-02f, 1.39940649e-01f, 6.76236078e-02f, -3.34844925e-02f, 2.62943536e-01f,
  1.05564043e-01f, -4.50136922e-02f, -2.51647115e-01f, 6.53830767e-02f, -1.50927052e-01f, -3.22888672e-01f, 3.25606875e-02f, 3.72739024e-02f, 1.95413843e-01f, 2.36565471e-01f,
  7.72715509e-02f, 1.32611230e-01f, -5.46491332e-02f, 2.60843605e-01f, 2.95531563e-02f, -2.24462584e-01f, -1.49588920e-02f, 1.11464307e-01f, 3.79518010e-02f, 7.97702670e-02f,
  2.11469576e-01f, -1.17180280e-01f, -2.37806737e-01f, 1.18918039e-01f, 5.35540171e-02f, 1.49306104e-01f, -1.72774389e-01f, 3.16769704e-02f, 9.40225348e-02f, 1.22605912e-01f,
  1.13882408e-01f, 3.52132991e-02f, 4.11036238e-02f, 4.63613831e-02f, 8.62910077e-02f, -4.24924903e-02f, -1.94880530e-01f, 1.66880250e-01f, 2.61385262e-01f, 2.51541018e-01f,
  7.76369795e-02f, 1.68114156e-01f, 1.12590473e-02f, -2.06876304e-02f, 1.69938803e-01f, -9.23355371e-02f, 1.35929286e-01f, 2.35502347e-01f, 2.39168748e-01f, 3.11795324e-01f,
  1.75867885e-01f, -1.47551998e-01f, 1.83525220e-01f, -9.08523276e-02f, 2.43472621e-01f, 7.09654316e-02f, -1.19060755e-01f, 3.18803668e-01f, 1.22895971e-01f, 9.55996513e-02f,
  1.48443490e-01f, 3.06842234e-02f, 3.52684334e-02f, -5.25487475e-02f, 1.28477933e-02f, -2.13350102e-01f, -7.53466710e-02f, 1.76385418e-01f, 1.90767329e-04f, 1.76136419e-01f,
  1.14815764e-01f, -2.07218483e-01f, -1.03271797e-01f, 4.22839046e-01f, 8.36589113e-02f, -5.48163913e-02f, 2.11285174e-01f, 8.91560912e-02f, 3.12405765e-01f, 3.01112998e-02f,
  -1.42296284e-01f, 4.01603818e-01f, 2.06062391e-01f, 1.68173119e-01f, 1.38725922e-01f, 1.62521958e-01f, 1.06591828e-01f, 2.75171846e-01f, 1.96184501e-01f, 7.40815997e-02f,
  -1.49727553e-01f, -5.19806817e-02f, 8.35488215e-02f, 1.14402473e-01f, 6.62503839e-02f, 8.77377093e-02f, 9.01284814e-02f, -4.21779491e-02f, 1.11763582e-01f, -7.59199858e-02f,
  2.81178970e-02f, 1.31398544e-01f, -1.90278217e-01f, -3.46774198e-02f, -5.99277392e-02f, 2.61850632e-03f, 1.37881577e-01f, -1.26850218e-01f, -2.25073531e-01f, 1.24530077e-01f,
  6.47075847e-03f, -1.44935891e-01f, -4.88277487e-02f, -2.89090157e-01f, -4.70449515e-02f, 2.12299362e-01f, 1.16560087e-01f, 2.95550853e-01f, 5.91619611e-02f, 1.21831238e-01f,
  -1.30638152e-01f, -3.45060647e-01f, 1.61422417e-02f, 6.28890768e-02f, -1.30623713e-01f, -1.48667514e-01f, -1.35147288e-01f, 1.62616640e-01f, 1.35574400e-01f, -1.20996550e-01f,
  -1.36679962e-01f, 2.23099023e-01f, 3.32137227e-01f, -1.22368127e-01f, 2.76697904e-01f, 1.17204465e-01f, 4.19963300e-01f, -5.50337397e-02f, 6.69425502e-02f, 1.71777651e-01f,
  3.43867868e-01f, 1.40036389e-01f, 2.10704864e-03f, -3.06715876e-01f, -9.73401815e-02f, -2.69132912e-01f, -4.55730176e-03f, 2.27357849e-01f, -6.45547137e-02f, -1.78485096e-01f,
  2.63349682e-01f, 4.46512885e-02f, 1.80281401e-01f, 3.15750718e-01f, -2.20596835e-01f, 2.65971422e-01f, 7.75272772e-02f, 9.44950897e-03f, 2.62997717e-01f, -1.37244314e-01f,
  -6.73993155e-02f, 6.66497573e-02f, -1.49139119e-02f, 1.19796200e-02f, 1.42944425e-01f, 1.15852773e-01f, -4.11879532e-02f, -8.78545195e-02f, 5.29458635e-02f, 8.65596309e-02f,
  4.33767706e-01f, -1.08773805e-01f, -2.70345416e-02f, -6.97398465e-03f, 1.75082073e-01f, -1.49753898e-01f, 1.29966484e-02f, -2.37189695e-01f, -1.52606800e-01f, 3.80713969e-01f,
  -1.29406244e-01f, 1.41203642e-01f, -1.95299163e-01f, 1.15284950e-01f, -3.95047292e-02f, 2.18105200e-03f, -5.06394729e-02f, 1.08423591e-01f, -3.78352225e-01f, -3.73355672e-02f,
  3.46907154e-02f, -1.95072442e-02f, -2.32970938e-01f, 1.55350611e-01f, -2.80297786e-01f, -9.39637050e-02f, 1.13234639e-01f, -1.43025160e-01f, 2.93721825e-01f, 2.14626774e-01f,
  4.25102264e-01f, -8.07362944e-02f, -1.26998708e-01f, -1.71818525e-01f, 2.34542727e-01f, 6.50208667e-02f, 1.87133928e-03f, -1.88291878e-01f, -7.37094805e-02f, -1.45191848e-01f,
  1.30881742e-01f, 4.24293131e-01f, 1.60535052e-01f, -1.64082557e-01f, 3.73467147e-01f, -1.58390671e-01f, 9.10409689e-02f, 1.73028633e-01f, 8.64664465e-02f, 1.51480168e-01f,
  1.81571320e-02f, 1.34240180e-01f, 6.65048361e-02f, -2.24328283e-02f, 3.61364931e-02f, 2.81633213e-02f, 6.63599819e-02f, -7.15295896e-02f, -1.25821248e-01f, -2.58844227e-01f,
  2.06532493e-01f, -2.07840681e-01f, 1.02729522e-01f, -3.76315981e-01f, 4.69691232e-02f, -9.60739106e-02f, -1.82930171e-01f, -4.36125137e-02f, -1.21377110e-01f, -2.39711138e-03f,
  -7.63576776e-02f, 8.41915235e-02f, 1.39570996e-01f, 5.09209000e-02f, 1.85101647e-02f, 5.48413023e-02f, -1.77200049e-01f, -1.52727455e-01f, 5.70246205e-02f, 2.81726331e-01f,
  6.21144399e-02f, 5.01032099e-02f, -1.36661753e-01f, -2.65172392e-01f, 1.57721609e-01f, 1.61297936e-02f, -6.69090673e-02f, 1.98678851e-01f, 2.51523376e-01f, 1.67398125e-01f,
  -1.70966778e-02f, 1.93627849e-01f, 4.45564277e-02f, 8.85545556e-03f, 1.57638803e-01f, 1.27218232e-01f, 2.47415066e-01f, -3.28696854e-02f, -8.80907401e-02f, -1.44457564e-01f,
  -2.52057195e-01f, -3.10899168e-01f, -3.77708599e-02f, 1.69994272e-02f, -1.31738529e-01f, 2.04245776e-01f, 1.54860422e-01f, -8.56394395e-02f, 3.82369310e-01f, -4.03068781e-01f,
  -9.54502225e-02f, -1.37341797e-01f, 4.79576178e-02f, -1.25321791e-01f, -5.78775629e-02f, 3.26843560e-02f, 1.04667820e-01f, 1.43086091e-01f, -1.04349880e-02f, 1.76468164e-01f,
  2.40551308e-01f, -1.06971748e-01f, 1.16837583e-01f, -4.93650548e-02f, 1.43881172e-01f, -5.40503114e-02f, 1.27875954e-01f, -4.44731452e-02f, 2.10083291e-01f, -1.31968424e-01f,
  -3.49677615e-02f, -1.22113109e-01f, 1.80917516e-01f, -1.66145399e-01f, -5.14609888e-02f, -2.78142154e-01f, -2.18649477e-01f, 2.03316435e-01f, -7.05679655e-02f, -9.84897241e-02f,
  -2.44480534e-03f, 1.14832766e-01f, -1.33422837e-01f, -1.24715962e-01f, 8.96544382e-02f, 1.44047409e-01f, -2.16043830e-01f, -2.41342131e-02f, 6.37971237e-02f, 1.03777394e-01f,
  -1.52920336e-01f, -5.49136139e-02f, -2.43108302e-01f, 1.23999365e-01f, 2.00417787e-01f, -1.66926503e-01f, 2.73812294e-01f, -7.22160861e-02f, 2.75798470e-01f, -2.34409279e-04f,
  5.22739813e-02f, -2.36854199e-02f, 1.77459911e-01f, 1.46222711e-01f, -1.32512879e-02f, -8.21859464e-02f, 3.64972912e-02f, -1.59496412e-01f, 6.43695751e-03f, 3.54227722e-01f,
  -3.15641537e-02f, -3.10524493e-01f, 1.04552686e-01f, 1.59969466e-04f, 1.01146266e-01f, 1.85163617e-02f, 2.40374237e-01f, 1.47127807e-01f, -2.22662613e-01f, 2.72342592e-01f,
  -6.77565113e-02f, -1.31309107e-01f, -1.81028992e-02f, 5.50919585e-02f, 2.25123167e-01f, 5.11007383e-02f, -8.93293396e-02f, -5.48845343e-02f, 2.51279622e-01f, -1.29146382e-01f,
  1.12398364e-01f, -1.32803798e-01f, -9.55513045e-02f, -2.88229555e-01f, 1.06488233e-02f, -6.28304556e-02f, 1.94986954e-01f, 1.32552162e-01f, -1.13052510e-01f, 4.21959534e-02f,
  1.39646128e-01f, 7.54367188e-02f, -7.70286024e-02f, -1.60477292e-02f, -1.36076421e-01f, -1.18551545e-01f, -1.61937863e-01f, 8.52105580e-03f, -2.57365137e-01f, -2.68016487e-01f,
  -6.22316934e-02f, 1.78517729e-01f, 4.09876220e-02f, -1.69290096e-01f, -3.34810913e-01f, 1.40195861e-01f, 1.47224128e-01f, -2.41077989e-01f, 2.97360718e-01f, -1.64412320e-01f,
  1.52905703e-01f, 1.38827309e-01f, -1.02921560e-01f, -9.92140733e-03f, -2.13142604e-01f, -2.12294608e-01f, 1.42355800e-01f, -3.24616373e-01f, 2.33429670e-01f, 3.44460100e-01f,
  1.61509037e-01f, -2.47477144e-01f, 1.32177204e-01f, 1.65828317e-01f, -3.68500948e-01f, 3.61853808e-01f, -1.14285462e-01f, 1.22474857e-01f, 1.41941726e-01f, -4.67880666e-02f,
  3.00510883e-01f, 9.82912183e-02f, -3.68142873e-01f, 1.80072516e-01f, 4.17687595e-02f, -1.39496690e-02f, 1.08016871e-01f, -1.25867307e-01f, 2.85016268e-01f, 6.22568280e-02f,
  1.01729430e-01f, -7.32240304e-02f, 7.71592855e-02f, -9.68012288e-02f, 3.80406715e-02f, 1.97683439e-01f, -2.18243390e-01f, 1.01831676e-02f, -1.32043913e-01f, -6.00151233e-02f,
  -6.91179633e-02f, -2.42565393e-01f, 1.36844322e-01f, -1.96944624e-01f, 4.30128574e-02f, 2.86178678e-01f, -2.50252753e-01f, -1.02914952e-01f, -3.57916921e-01f, -3.29617977e-01f,
  3.61974239e-01f, -6.04294576e-02f, 1.41344825e-02f, 6.34793714e-02f, -4.76515666e-02f, -1.85433581e-01f, 5.75571470e-02f, 1.85205057e-01f, -1.55477852e-01f, 7.91814625e-02f,
  2.82135546e-01f, -2.02546164e-01f, -1.48583263e-01f, 2.33218670e-01f, -3.13702114e-02f, 6.50197566e-02f, -4.07349952e-02f, 2.56393105e-01f, -2.35523004e-02f, -1.74900204e-01f,
  -1.37956962e-01f, -2.79681593e-01f, -5.16777337e-02f, 2.03969851e-01f, 2.64690779e-02f, -3.74803953e-02f, 3.13664088e-03f, 1.18818976e-01f, -9.37235262e-03f, 4.81715590e-01f,
  2.99772620e-02f, 3.65922451e-02f, -9.08950418e-02f, -2.79833853e-01f, 2.75103807e-01f, 7.03610629e-02f, -1.31562287e-02f, 1.42242491e-01f, 6.05100673e-03f, -3.33433859e-02f,
  4.95066494e-02f, -1.74025238e-01f, 2.12651379e-02f, 7.05107152e-02f, -9.62785855e-02f, 3.36042196e-01f, 7.19136149e-02f, 3.59190330e-02f, -1.01759449e-01f, 1.96312204e-01f,
  -7.94790015e-02f, -2.24133325e-03f, -1.79134607e-01f, -1.77524209e-01f, 1.35292877e-02f, 6.12390460e-03f, 2.94920448e-02f, -1.02717064e-01f, -6.32632449e-02f, -3.38696912e-02f,
  6.44966066e-02f, 1.02747925e-01f, 1.62543863e-01f, -5.91965988e-02f, -1.09711951e-02f, -2.42537647e-01f, -2.28612684e-02f, 1.86274350e-01f, -1.73589550e-02f, -2.72853583e-01f,
  3.12906131e-02f, 1.18105210e-01f, 1.06900640e-01f, -4.15676653e-01f, -9.67316050e-03f, 1.25908375e-01f, 9.02195871e-02f, -9.46140140e-02f, -9.05604567e-03f, 1.01603977e-01f,
  1.64652720e-01f, 1.02244869e-01f, -3.36724780e-02f, 6.83661178e-02f, 1.17076665e-01f, 1.92508206e-01f, 1.84428290e-01f, -1.76698685e-01f, -1.31463334e-01f, -2.63613284e-01f,
  1.16685927e-01f, 1.23156182e-01f, 9.01274905e-02f, 6.76826239e-02f, 1.28535748e-01f, -1.20700635e-01f, -4.44588028e-02f, 1.79681614e-01f, -2.99609065e-01f, 1.88098624e-01f,
  6.51251152e-02f, -6.12496249e-02f, 2.01885030e-01f, 2.10299209e-01f, -4.00633402e-02f, -2.44815394e-01f, 1.84998214e-01f, 4.29575443e-02f, 9.48874950e-02f, -1.72971301e-02f,
  -7.77001902e-02f, -1.29263341e-01f, -1.75852533e-02f, 1.32936865e-01f, 1.59032003e-03f, 1.95404530e-01f, 1.20895706e-01f, 7.04951063e-02f, -4.60980535e-02f, -1.21600918e-01f,
  -1.20342605e-01f, -1.80153087e-01f, -2.94114370e-02f, 7.11278766e-02f, 1.19971931e-01f, 4.02410813e-02f, 1.52528450e-01f, -1.77388325e-01f, -4.24299985e-02f, -2.42691472e-01f,
  -1.57153413e-01f, 3.28637213e-01f, -2.18637456e-06f, -2.87033707e-01f, -1.82085589e-01f, 2.69698173e-01f, 2.49779448e-01f, -5.02050184e-02f, 4.75500822e-02f, 2.07258135e-01f,
  1.94828473e-02f, 1.57884434e-01f, 2.20781267e-01f, 2.16767475e-01f, 2.38971084e-01f, 4.93111014e-02f, 4.66739237e-02f, 1.01558216e-01f, 1.22591540e-01f, 1.63817957e-01f,
  -1.22834116e-01f, -3.19761068e-01f, 3.53846550e-02f, 1.07505761e-01f, -3.67192142e-02f, 2.01751292e-01f, 1.89878851e-01f, -1.30772173e-01f, 1.24550708e-01f, -1.32467031e-01f,
  -3.07294521e-02f, 2.77435631e-02f, -1.98924735e-01f, 1.70187803e-03f, -9.29955766e-02f, -3.35399359e-02f, 2.02425927e-01f, -3.86809371e-02f, 2.12066010e-01f, 1.32765710e-01f,
  1.52137354e-01f, 1.33451775e-01f, 8.23597983e-02f, 2.56838858e-01f, -2.43439991e-03f, 2.27195680e-01f, -2.50059608e-02f, 4.48734164e-01f, 2.54403800e-01f, 1.34629890e-01f,
  -1.65439308e-01f, -1.69989206e-02f, 8.01219270e-02f, 1.94381624e-02f, 5.32086372e-01f, 2.00883094e-02f, -1.31892368e-01f, 1.55237257e-01f, 8.30418766e-02f, -1.09723136e-01f,
  4.76376563e-02f, 5.01061929e-03f, 3.58156860e-01f, -5.14651537e-02f, 6.95604309e-02f, 1.78084359e-01f, -1.64342731e-01f, -1.07585050e-01f, -1.28185347e-01f, 1.57778412e-01f,
  -7.61327147e-02f, -2.11776599e-01f, -1.09848753e-01f, 1.51421741e-01f, -2.68803746e-01f, 1.80212125e-01f, 1.17549598e-01f, -1.09690838e-01f, 8.77127498e-02f, 3.86168063e-01f,
  3.05564962e-02f, 1.14741512e-01f, 1.54430404e-01f, 2.32881710e-01f, 1.13812894e-01f, -2.39190757e-01f, -1.70476049e-01f, 1.69720471e-01f, 1.29886702e-01f, 2.77632594e-01f,
  2.96036541e-01f, 1.94150880e-01f, 2.60946184e-01f, 1.95100620e-01f, -4.49950099e-02f, -5.98559827e-02f, -3.87061201e-02f, -2.26100802e-01f, -8.31330791e-02f, 9.59457681e-02f,
  1.03396595e-01f, -3.33903846e-03f, 1.75107583e-01f, 2.56621927e-01f, 1.60138309e-01f, 3.41126546e-02f, 1.76710561e-01f, 1.45010248e-01f, -1.76823139e-01f, 8.97414386e-02f,
  -7.94347078e-02f, 1.64892867e-01f, 2.31984764e-01f, -7.60029927e-02f, -1.97275236e-01f, -1.03163347e-01f, 2.21522540e-01f, -7.12506939e-04f, 1.53441086e-01f, -1.22054525e-01f,
  -9.45684779e-03f, 2.81848669e-01f, -1.38466135e-01f, -4.14345860e-02f, -1.15401976e-01f, 6.58597425e-02f, 1.63982049e-01f, -1.15223341e-02f, 7.97132403e-02f, -5.16308025e-02f,
  -7.33635351e-02f, -8.07221159e-02f, 8.76575112e-02f, 9.48234200e-02f, -2.48245582e-01f, 1.08735986e-01f, -1.37181908e-01f, -2.53085166e-01f, 2.86902655e-02f, 4.92627583e-02f,
  4.76752184e-02f, 1.55012369e-01f, 5.58449998e-02f, 1.41662046e-01f, -3.48441713e-02f, -1.62847504e-01f, 2.16953680e-01f, 2.51583420e-02f, 8.00012499e-02f, -8.24554861e-02f,
  -8.28186870e-02f, -1.91495717e-01f, -5.38906036e-03f, 2.83677220e-01f, -1.16068907e-01f, 2.66022980e-01f, 1.41807288e-01f, 1.44299552e-01f, 1.67647630e-01f, -3.97762395e-02f,
  1.88429162e-01f, 8.83041099e-02f, -2.47738436e-01f, 1.01278968e-01f, 5.73805198e-02f, -3.76246907e-02f, -4.42174785e-02f, -4.47035730e-01f, 1.67765498e-01f, -3.07670441e-02f,
  -1.33257672e-01f, 1.61352754e-01f, 8.36989880e-02f, -1.01622596e-01f, -2.74483319e-02f, 2.63042543e-02f, -1.82764962e-01f, -1.84967875e-01f, -6.01797588e-02f, -8.44957978e-02f,
  -1.85936123e-01f, 1.71359088e-02f, -1.53829396e-01f, 8.18074681e-03f, 2.24683657e-01f, 1.10791124e-01f, -1.21060219e-02f, 2.91476071e-01f, 6.42960891e-02f, -1.56190753e-01f,
  -6.01655729e-02f, -8.69346261e-02f, -2.08222419e-01f, -3.01052462e-02f, -1.07046161e-02f, -6.45155460e-02f, 4.45801094e-02f, 2.07381636e-01f, 2.04807878e-01f, -3.46509725e-01f,
  3.69318038e-01f, 1.36557937e-01f, 2.03155056e-02f, 1.94333702e-01f, -8.69585872e-02f, 6.67887107e-02f, -1.47667900e-01f, 3.14946860e-01f, -1.09949812e-01f, 1.60963714e-01f,
  3.56434546e-02f, 2.66996324e-01f, 1.13334484e-01f, -8.24473277e-02f, 1.64812565e-01f, -1.50587142e-01f, 1.22576453e-01f, -2.11567476e-01f, 2.85810024e-01f, 5.18071771e-01f,
  -2.30811507e-01f, 1.71151981e-02f, -1.31674916e-01f, 2.13774592e-01f, -2.67221630e-01f, 1.00085981e-01f, 2.43270427e-01f, -8.18124637e-02f, 9.29804742e-02f, 1.55588299e-01f,
  5.96127585e-02f, 2.01382384e-01f, -2.36660376e-01f, 1.03419304e-01f, -1.49824452e-02f, 1.99195832e-01f, -7.32682869e-02f, 1.44379184e-01f, 1.52698651e-01f, 1.80200413e-01f,
  2.63771921e-01f, 2.17972711e-01f, 9.03889537e-03f, 1.49534449e-01f, 8.93359408e-02f, 1.18095733e-01f, 1.10051557e-01f, 1.46246120e-01f, 2.20358565e-01f, -6.40580803e-02f,
  5.36390357e-02f, -2.31942624e-01f, 1.13560840e-01f, 1.74929589e-01f, 1.31827012e-01f, 3.37920070e-01f, 3.01997870e-01f, -8.75867829e-02f, 6.64294185e-03f, 9.12949257e-03f,
  7.34826475e-02f, -8.77843946e-02f, -1.53257370e-01f, 2.79504418e-01f, -1.37683764e-01f, -6.11865334e-02f, -2.08865091e-01f, 3.90305996e-01f, -6.54682964e-02f, 6.54546777e-03f,
  2.73314398e-02f, 3.77747595e-01f, 1.47558346e-01f, -6.53959140e-02f, -9.83040314e-03f, 5.03704101e-02f, 1.48747936e-01f, 7.14205429e-02f, -3.46074402e-01f, 5.12129366e-01f,
  6.05555363e-02f, 1.44359514e-01f, 1.87178746e-01f, 4.50904161e-01f, 2.29127094e-01f, 1.74601987e-01f, 6.47059232e-02f, -1.22021288e-01f, 3.00596617e-02f, -1.94521323e-01f,
  3.98549438e-01f, -2.37503111e-01f, 1.48865595e-01f, -3.22299525e-02f, 1.80411696e-01f, -4.80870567e-02f, -7.62306247e-03f, 4.44290787e-03f, 4.06283289e-02f, -3.29719067e-01f,
  3.10882688e-01f, -3.30743611e-01f, -9.35676601e-03f, -3.57908934e-01f, 3.34010832e-02f, -2.63454374e-02f, -1.30503580e-01f, -5.39719611e-02f, -1.36086866e-01f, -7.70000145e-02f,
  -3.61971557e-01f, -2.43793670e-02f, -1.39043480e-01f, 2.08683923e-01f, -2.98704624e-01f, 3.12846780e-01f, -1.48854956e-01f, -3.87691148e-02f, -1.69480979e-01f, 5.40785901e-02f,
  -2.68880337e-01f, -3.62066448e-01f, -1.01121925e-01f, -1.45150378e-01f, -7.91028887e-02f, -1.30614340e-01f, 1.51184797e-01f, 9.98846665e-02f, 1.22927554e-01f, 1.22930028e-01f,
  3.70088875e-01f, 1.57045931e-01f, 2.61599049e-02f, 7.40192607e-02f, 5.25731444e-02f, -1.61539197e-01f, -8.64261314e-02f, 1.58071309e-01f, -8.05782080e-02f, 1.21809602e-01f,
  -1.16087027e-01f, 1.03985980e-01f, 2.10299179e-01f, -2.36083537e-01f, 1.48668200e-01f, -1.22230850e-01f, -5.97680211e-02f, 2.19638780e-01f, 6.33248501e-03f, 7.69095123e-02f,
  1.28404722e-01f, 2.26190522e-01f, 2.04415053e-01f, 3.59772742e-01f, 2.03975216e-01f, 1.64382070e-01f, 1.48495883e-01f, 3.21964532e-01f, 1.88315466e-01f, -3.23871449e-02f,
  2.97852755e-01f, 1.07750915e-01f, -7.73512572e-03f, 3.12528640e-01f, 1.77002586e-02f, 2.00296000e-01f, -2.02633202e-01f, 3.32691163e-01f, 2.06407428e-01f, 1.28830805e-01f,
  -4.37453575e-02f, 2.24070355e-01f, 1.94331224e-03f, -2.46039048e-01f, 9.78234336e-02f, -1.59812331e-01f, -1.60356700e-01f, -1.53442239e-02f, 2.50049084e-01f, -1.25296444e-01f,
  7.11870641e-02f, -1.64764896e-01f, -1.29109584e-02f, -1.92441925e-01f, -1.30050182e-01f, 1.53511599e-01f, 2.25781217e-01f, -2.89571196e-01f, 2.69268397e-02f, 3.54049385e-01f,
  1.67103991e-01f, -2.22839922e-01f, 6.15964457e-02f, 1.38545424e-01f, -2.05388829e-01f, 2.57096644e-02f, 1.51507840e-01f, 2.26913407e-01f, 3.05087268e-02f, -6.50353283e-02f,
  2.04353258e-01f, 2.03293011e-01f, 1.65596411e-01f, 1.71148498e-02f, -3.90267260e-02f, -2.33433351e-01f, -3.87163870e-02f, 7.63644278e-02f, -2.69534469e-01f, -1.96398869e-02f,
  2.62194574e-01f, 1.31869003e-01f, 1.23442575e-01f, -1.89379796e-01f, 8.67780447e-02f, 6.30243346e-02f, -2.44965777e-01f, 5.33526950e-02f, 2.89114658e-02f, 3.46412659e-01f,
  -1.73429951e-01f, 7.56273195e-02f, -6.10211026e-03f, 1.49806619e-01f, 4.36904766e-02f, 2.68780459e-02f, -1.32427901e-01f, 5.58140874e-02f, 5.08302217e-03f, 7.55993649e-02f,
  3.53923701e-02f, -1.42712697e-01f, 3.85424197e-02f, -1.53290689e-01f, -6.28548488e-02f, 8.53164196e-02f, -1.10918291e-01f, 1.68391898e-01f, -4.40961719e-02f, 3.55745733e-01f,
  3.37994128e-01f, -4.02359128e-01f, -1.68048933e-01f, -2.97779977e-01f, 1.98346645e-01f, 7.50714773e-03f, -2.66863316e-01f, 2.78123826e-01f, -1.52595297e-01f, -1.61726266e-01f,
  4.24825817e-01f, 1.33088157e-01f, 7.58754760e-02f, -1.33010909e-01f, -1.48676291e-01f, 8.67899582e-02f, 3.40272263e-02f, -1.17070153e-01f, 8.75027757e-03f, 1.56211287e-01f,
  -1.42916525e-02f, 9.18100998e-02f, -4.23870564e-01f, -6.69295760e-03f, -3.01536113e-01f, -1.17702290e-01f, 2.15191007e-01f, -1.45789549e-01f, 2.19183549e-01f, 2.47359648e-01f,
  1.77928925e-01f, -8.98270756e-02f, 2.79690959e-02f, -1.27641320e-01f, -3.40616733e-01f, 3.39281619e-01f, -1.98687106e-01f, 2.14997932e-01f, 2.02896610e-01f, 1.41917005e-01f,
  -1.16665415e-01f, 2.63761226e-02f, 2.01471634e-02f, -8.41081068e-02f, 2.76099414e-01f, 6.64922176e-03f, -7.23191500e-02f, -1.88030466e-01f, -1.39424145e-01f, -6.33766036e-03f,
  -6.50550574e-02f, -2.09311992e-01f, 1.65467083e-01f, -1.45854518e-01f, 3.28920633e-01f, 8.23818594e-02f, -5.15857805e-03f, 5.39818332e-02f, 4.27653976e-02f, -7.52883032e-02f,
  -5.19584864e-02f, 4.06791158e-02f, -1.01953328e-01f, -1.88356325e-01f, 6.68190187e-03f, 4.87730242e-02f, -7.58078545e-02f, 6.66271448e-02f, -9.28540081e-02f, -2.98296243e-01f,
  -2.72124678e-01f, -9.16750431e-02f, -1.79982036e-01f, 3.72043073e-01f, -2.96566039e-01f, 1.03676114e-02f, -1.08972229e-01f, 5.19747613e-03f, 2.39125565e-01f, 1.11979425e-01f,
  9.01535600e-02f, 6.53609037e-02f, 1.69662948e-04f, 4.54352349e-02f, -6.64310157e-02f, 2.97911465e-01f, 1.40744254e-01f, 2.43350074e-01f, -3.94361392e-02f, 6.91800490e-02f,
  3.74729000e-02f, 2.36520141e-01f, 1.57642718e-02f, -2.38366082e-01f, 1.83037281e-01f, 2.23696649e-01f, -6.11411706e-02f, 2.65266985e-01f, 3.53264928e-01f, -2.19394580e-01f,
  3.62321854e-01f, -1.08277626e-01f, -2.34332025e-01f, -4.53033336e-02f, 4.00741398e-02f, -1.98248386e-01f, 6.23867176e-02f, 2.43012697e-01f, 1.76319163e-02f, 2.10902050e-01f,
  1.09449243e-02f, 1.03643732e-02f, -3.14271413e-02f, -2.35764217e-02f, -1.51060864e-01f, -4.98778038e-02f, 4.06305760e-01f, 3.12687993e-01f, -3.51687260e-02f, -6.79385755e-03f,
  -9.57566574e-02f, 1.90357447e-01f, 1.37780622e-01f, 2.51116276e-01f, 1.57617107e-01f, 7.73418620e-02f, 1.50724128e-01f, 3.45503449e-01f, 2.80605257e-01f, -4.31027800e-01f,
  3.00729930e-01f, -2.89058924e-01f, 2.09623456e-01f, -2.12318152e-02f, -1.84069544e-01f, 2.77716041e-01f, 8.50005001e-02f, -4.51956391e-02f, 7.69997165e-02f, 1.88696623e-01f,
  -1.44304991e-01f, -5.10956571e-02f, 1.91859543e-01f, -7.71101117e-02f, -1.53320104e-01f, 2.28487924e-01f, 9.16552171e-02f, 8.56867954e-02f, 2.68927872e-01f, -1.65258124e-01f,
  -1.28977522e-02f, 4.26728688e-02f, 2.26688132e-01f, 2.97112942e-01f, 2.96307832e-01f, 2.10889295e-01f, 2.19649002e-01f, 3.89727065e-03f, -1.28294721e-01f, 4.16832566e-01f,
  1.37914494e-01f, 1.72164887e-02f, 1.67460158e-01f, -1.58584461e-01f, -4.42173891e-02f, 2.14420959e-01f, 2.58275062e-01f, 1.54904187e-01f, 5.53824194e-02f, -2.68836971e-02f,
  3.25133115e-01f, -1.12063423e-01f, -1.81043765e-03f, 1.41262472e-01f, 1.97502017e-01f, -8.34446102e-02f, -1.98027007e-02f, 1.77188754e-01f, 3.31515260e-02f, -1.73536286e-01f,
  1.48543179e-01f, 1.10586565e-02f, -9.29476544e-02f, 1.80793926e-01f, -4.40314449e-02f, 3.18378925e-01f, 1.12171270e-01f, 3.95251900e-01f, -2.54676044e-01f, -2.73659766e-01f,
  -4.22598690e-01f, 7.21181259e-02f, -2.39025846e-01f, 2.17206061e-01f, -1.04951844e-01f, -4.06217314e-02f, -1.65047869e-01f, 2.08508268e-01f, -3.12846452e-01f, 3.72533686e-02f,
  8.00857767e-02f, -7.47347176e-02f, 3.10024202e-01f, -2.14157566e-01f, -2.83025712e-01f, -1.49015024e-01f, 1.02858134e-01f, 1.69424042e-01f, -7.09218234e-02f, 1.92702681e-01f,
  2.28414193e-01f, -1.92020774e-01f, 1.08453788e-01f, -1.00065902e-01f, 1.78326860e-01f, -2.33713537e-01f, 2.56992411e-02f, -1.46855824e-02f, -4.52644452e-02f, 2.49381647e-01f,
  -8.27918500e-02f, 3.27604681e-01f, -1.28087951e-02f, -7.37251863e-02f, 2.74041295e-01f, -3.27924527e-02f, 1.28379285e-01f, -2.07235083e-01f, -3.34489375e-01f, 1.19473919e-01f,
  1.66188359e-01f, 2.48538747e-01f, 1.69587553e-01f, 2.71827996e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.87750626e-02f, 6.71958625e-02f, 8.09783116e-02f, 8.34442452e-02f, 5.75462170e-02f, 1.72920376e-01f, 2.17852183e-02f, 1.61003262e-01f, 4.73268926e-02f, 3.84850428e-02f,
  7.30110556e-02f, -2.21775994e-02f, 1.72682464e-01f, 1.48190722e-01f, 3.58550288e-02f, 3.43655795e-02f, -3.41514461e-02f, -2.80156061e-02f, 7.91329965e-02f, 1.18753321e-01f,
  4.60311808e-02f, 6.25434145e-02f, 7.89130479e-02f, 1.96352273e-01f, 1.28666610e-01f, 2.63886787e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.41465867e-01f, -3.30151379e-01f, -1.23854429e-01f, -1.81108341e-01f, 1.02156848e-01f, 1.43938467e-01f, -1.01950979e-02f, -2.41857907e-03f, -1.88707858e-01f, 1.46650195e-01f,
  -1.73508137e-01f, -7.45375976e-02f, -1.80478364e-01f, 6.67366162e-02f, -1.71073452e-01f, 3.68768275e-02f, -1.15346551e-01f, -1.68655798e-01f, -1.22678922e-02f, 5.57919848e-04f,
  7.84322023e-02f, -5.55709973e-02f, 3.51709247e-01f, -9.76502076e-02f, -3.87333870e-01f, -1.83554500e-01f, -2.01419875e-01f, 2.28046730e-01f, 1.63035318e-01f, -9.93941352e-02f,
  1.47159591e-01f, -7.64109269e-02f, -2.44803075e-02f, -2.51545846e-01f, 3.18589211e-01f, 1.59594610e-01f, 2.21860230e-01f, -1.87737793e-01f, 2.99577266e-01f, -1.20399766e-01f,
  -1.91021577e-01f, -3.65468740e-01f, -3.14329326e-01f, -3.21834475e-01f, -1.13146126e-01f, 1.31414443e-01f, 1.47928283e-01f, -3.22482467e-01f, 1.19481593e-01f, -9.70365581e-05f,
  1.12431817e-01f, -1.89927444e-01f, 2.15970591e-01f, -1.05175227e-01f, -1.76427186e-01f, -1.73278570e-01f, 2.12006658e-01f, -2.52459198e-01f, 5.97452372e-02f, -1.59406945e-01f,
  2.19984576e-01f, -4.07138705e-01f, 1.24971144e-01f, -1.83087378e-03f, 1.48000829e-02f, 3.65706757e-02f, 1.60573557e-01f, -1.21791475e-01f, 3.43389884e-02f, -1.20107748e-01f,
  -1.70877069e-01f, 8.60602185e-02f, 6.33630157e-02f, -1.57345861e-01f, 2.54490107e-01f, -1.18186742e-01f, 4.46449704e-02f, 1.60020888e-01f, -1.76726565e-01f, -1.80290237e-01f,
  -9.54108164e-02f, 1.53272167e-01f, -1.57904495e-02f, 9.78705660e-02f, 2.29344487e-01f, -1.26327664e-01f, -1.92863587e-02f, -2.26238385e-01f, -2.77827024e-01f, -1.57623813e-01f,
  2.60515749e-01f, -3.84976715e-01f, -2.58097976e-01f, 1.58114489e-02f, -8.53190422e-02f, -3.08174878e-01f, -1.64924666e-01f, 1.86317086e-01f, -1.63250804e-01f, -1.43086895e-01f,
  -2.53404856e-01f, -1.99272692e-01f, -1.28149942e-01f, -3.56659114e-01f, -2.94606835e-01f, 2.70786911e-01f, -6.73800558e-02f, 1.74053669e-01f, 5.36844544e-02f, -3.01215768e-01f,
  1.50041416e-01f, 1.47365769e-02f, -1.00030385e-01f, -5.96255995e-02f, -3.13489050e-01f, -2.20985934e-01f, 9.65049639e-02f, 1.03316404e-01f, -2.17064276e-01f, -2.37499401e-01f,
  1.64718479e-01f, -2.02508986e-01f, 1.41936511e-01f, 2.19362080e-02f, -8.35191011e-02f, 5.98682500e-02f, -1.21926270e-01f, 1.89890310e-01f, -2.00421944e-01f, 2.13319398e-02f,
  -5.41068381e-03f, -1.13665104e-01f, -4.37993966e-02f, 1.99049219e-01f, -3.86032425e-02f, -2.18190998e-02f, 2.86830455e-01f, 8.48949403e-02f, 1.01605788e-01f, 2.31658787e-01f,
  1.57954127e-01f, -3.53409685e-02f, -3.22193027e-01f, -7.33751282e-02f, 2.02501744e-01f, 7.74078518e-02f, 7.17335492e-02f, -3.33872616e-01f, 2.37397075e-01f, 1.43950239e-01f,
  1.77787304e-01f, 2.58481577e-02f, -1.79992169e-02f, -8.06560218e-02f, 3.06669921e-01f, 4.18058969e-02f, 1.19144611e-01f, -4.61748801e-04f, -5.86697944e-02f, 2.46429861e-01f,
  -1.45337671e-01f, -1.78933349e-02f, 3.83931547e-02f, 2.77935453e-02f, -3.07156801e-01f, 1.80869073e-01f, -1.37575909e-01f, 2.76392400e-01f, 2.28257358e-01f, -3.29748958e-01f,
  -5.43307245e-01f, -3.57900530e-01f, -2.56920964e-01f, -1.43321186e-01f, 1.76026911e-01f, 2.42952287e-01f, 1.68374889e-02f, 1.08947992e-01f, 2.37652045e-02f, -3.32325220e-01f,
  -1.06315933e-01f, -7.34683871e-02f, 2.48752646e-02f, 2.22950548e-01f, -2.50218600e-01f, -5.79836704e-02f, 1.29337177e-01f, -2.05897599e-01f, -1.86361179e-01f, -2.74076074e-01f,
  -1.57564483e-03f, 1.23086564e-01f, 8.53356794e-02f, 1.07878469e-01f, 5.85948536e-03f, 1.15544200e-02f, 2.48729005e-01f, 2.21164778e-01f, -1.08163692e-01f, -1.13297895e-01f,
  -1.15027331e-01f, -1.31181225e-01f, -4.52460349e-02f, 1.06775902e-01f, -4.58371527e-02f, -1.43305555e-01f, -2.66807526e-01f, 1.06079109e-01f, 5.55307753e-02f, 7.10263327e-02f,
  -1.65235013e-01f, 2.46564656e-01f, -8.22469592e-02f, -1.59086421e-01f, -1.46953696e-02f, 1.03451125e-01f, -5.81619777e-02f, -1.44473426e-02f, -3.16624790e-02f, -2.11208656e-01f,
  8.53549838e-02f, 7.34418929e-02f, 5.82138188e-02f, 5.01708239e-02f, -3.51489075e-02f, -7.50524253e-02f, 1.71164364e-01f, -7.08618909e-02f, 1.88399553e-01f, 5.60353138e-02f,
  -1.85158104e-01f, 1.36461869e-01f, 1.44816354e-01f, -3.95818859e-01f, -1.09448910e-01f, -3.66532713e-01f, -2.96216961e-02f, 6.05472736e-02f, -1.50231183e-01f, -2.12981820e-01f,
  -2.61184871e-01f, -2.34860063e-01f, 1.00454889e-01f, 2.15227142e-01f, -2.06213817e-01f, -2.85480887e-01f, 1.24776788e-01f, 1.38273045e-01f, -1.06959483e-02f, 2.28137434e-01f,
  -5.22680581e-01f, -1.87539324e-01f, 1.88654736e-01f, -3.44065607e-01f, -6.94608390e-02f, -1.04679383e-01f, 8.96682497e-03f, 2.07830504e-01f, 5.41440286e-02f, -2.71537360e-02f,
  -3.14863503e-01f, -2.14847162e-01f, -1.93854287e-01f, -2.06014171e-01f, 6.22211210e-02f, -1.35241270e-01f, -1.61974624e-01f, 6.98082447e-02f, -3.42050306e-02f, -6.05089143e-02f,
  2.02339515e-01f, -2.18227267e-01f, -2.40571961e-01f, -3.61382589e-02f, 1.26344144e-01f, 1.54164910e-01f, -2.91018300e-02f, 2.26730466e-01f, -1.87663928e-01f, 1.62555352e-01f,
  2.63757288e-01f, -3.81635427e-02f, -7.64475465e-02f, 2.74733722e-01f, 1.93114713e-01f, -1.28056377e-01f, -2.54969835e-01f, 2.24840984e-01f, 2.04179719e-01f, 1.81127544e-02f,
  1.42244130e-01f, -8.40063244e-02f, 1.24378920e-01f, 9.94080771e-03f, 1.27387475e-02f, 7.17215687e-02f, -1.84491038e-01f, 9.55858678e-02f, -5.87872192e-02f, 2.59051651e-01f,
  -3.47049013e-02f, 7.54222572e-02f, -1.23633541e-01f, -3.03759843e-01f, -2.25782514e-01f, -9.25682560e-02f, 5.89562654e-02f, -4.55428928e-01f, -2.73070037e-01f, -1.83424398e-01f,
  -2.43139863e-01f, -1.28941387e-01f, -1.96307391e-01f, 2.13786483e-01f, -8.15032497e-02f, -1.00633629e-01f, 2.40335807e-01f, -4.06451672e-02f, 2.08235368e-01f, 1.02359913e-01f,
  -7.04937205e-02f, 1.43284976e-01f, -1.86222896e-01f, -9.40328538e-02f, -1.23149201e-01f, -1.72331080e-01f, 1.00098975e-01f, -6.93875104e-02f, 1.46524072e-01f, -1.59727648e-01f,
  -7.90639073e-02f, 4.88159247e-02f, 3.76596814e-03f, -2.64087915e-01f, 1.38338134e-01f, 9.89329964e-02f, 9.97738615e-02f, -3.18692364e-02f, 5.16785532e-02f, -6.61495514e-03f,
  1.12918861e-01f, 2.10282970e-02f, -9.91595313e-02f, 2.99129575e-01f, 1.40385136e-01f, -2.44757816e-01f, -7.76962340e-02f, 3.03521156e-01f, -4.68960255e-02f, -2.35728938e-02f,
  2.45255306e-02f, 8.19621161e-02f, 4.40891869e-02f, 2.02883676e-01f, -1.67003736e-01f, 8.63973796e-02f, 1.60765260e-01f, -1.26273334e-01f, -2.96090990e-01f, 3.90713215e-02f,
  -2.91203499e-01f, -7.75662065e-02f, -1.27520502e-01f, -2.14594170e-01f, 1.75347745e-01f, -3.70539725e-03f, 2.09341347e-01f, -1.82051572e-03f, -2.00893983e-01f, 6.71981126e-02f,
  -2.37548038e-01f, -2.00723991e-01f, 2.12957025e-01f, 1.76302537e-01f, 2.05331013e-01f, 1.01054483e-03f, 5.34513481e-02f, -1.16021559e-01f, -1.93855762e-01f, 3.02219182e-01f,
  3.04590296e-02f, -1.18484553e-02f, 1.06712461e-01f, -5.51665155e-03f, 1.26786470e-01f, 1.07181393e-01f, -2.44552389e-01f, -7.72789717e-02f, 9.55193639e-02f, -6.54820949e-02f,
  9.42265093e-02f, -1.55212343e-01f, -3.35961342e-01f, -1.79390386e-02f, -4.57428321e-02f, -3.40966396e-02f, -2.16104135e-01f, 8.69581178e-02f, -3.60725969e-02f, 2.31525645e-01f,
  -1.30588710e-01f, -1.61978245e-01f, -1.81106199e-02f, -2.45155081e-01f, -2.90428579e-01f, 3.06463033e-01f, -3.68858539e-02f, -8.52829367e-02f, -8.53671655e-02f, 2.09668502e-01f,
  1.22361109e-01f, 9.13554952e-02f, 3.60770494e-01f, -1.03424527e-01f, 3.10596172e-02f, -6.82031810e-02f, -2.69280106e-01f, -1.10120803e-01f, 1.00851581e-02f, -9.31623508e-04f,
  -1.03384875e-01f, -2.64574826e-01f, -4.00078204e-03f, -3.79064083e-01f, 1.43847555e-01f, 1.05111241e-01f, 9.18324441e-02f, -8.63969475e-02f, -1.86465308e-01f, -5.11999130e-01f,
  1.74890622e-01f, 2.63375789e-01f, 1.77239791e-01f, 1.69282675e-01f, 7.21256137e-02f, 5.97274378e-02f, -1.19830042e-01f, -3.51800323e-02f, -3.48474920e-01f, 8.31648782e-02f,
  -3.26883584e-01f, -5.02880931e-01f, 3.82114910e-02f, -2.81055391e-01f, -3.18914533e-01f, 2.51710445e-01f, -4.99218047e-01f, -2.93246359e-01f, -9.10102203e-02f, -4.40341644e-02f,
  1.69915020e-01f, 9.62701291e-02f, 3.38066332e-02f, 4.62506674e-02f, 3.89219858e-02f, -7.97506645e-02f, 1.54207155e-01f, 1.87971275e-02f, 2.05463827e-01f, -8.47910643e-02f,
  5.83330430e-02f, -8.57198425e-03f, 1.23516791e-01f, 5.76294921e-02f, -7.21097589e-02f, -7.99436495e-02f, 8.14316347e-02f, 6.06081784e-02f, -1.89067721e-01f, -3.03664003e-02f,
  3.10240895e-01f, 3.19861501e-01f, -1.42770028e-02f, -1.10133849e-04f, 3.88393760e-01f, 2.15945113e-02f, 2.56766495e-03f, 2.51732886e-01f, 4.04885672e-02f, 7.38067180e-03f,
  -2.85538524e-01f, 2.22973526e-01f, 2.90045202e-01f, 1.21158086e-01f, -1.84264347e-01f, 3.99126150e-02f, -2.06798255e-01f, -4.51584041e-01f, -3.79937261e-01f, 2.06904575e-01f,
  8.90360773e-02f, 2.36049399e-01f, -1.23674147e-01f, -2.02992529e-01f, -1.68199688e-01f, -2.41797671e-01f, -2.99601465e-01f, -1.48965895e-01f, 2.20569789e-01f, 2.24574894e-01f,
  -1.52520597e-01f, -2.70128727e-01f, -1.80626094e-01f, 1.41020134e-01f, 2.11302504e-01f, 7.24092424e-02f, 1.38203353e-01f, -9.39199999e-02f, 1.55099377e-01f, -1.35051921e-01f,
  -3.42566878e-01f, -3.46261382e-01f, 5.17936870e-02f, -1.70073420e-01f, -1.84243619e-01f, 8.26688781e-02f, 3.48764658e-02f, 2.28292555e-01f, 9.00994688e-02f, -7.36006489e-03f,
  6.30675629e-02f, 1.01615392e-01f, -1.02223054e-01f, 1.68522477e-01f, 1.81240797e-01f, 1.74619973e-01f, 1.16546296e-01f, 4.09941435e-01f, -1.79933175e-01f, 3.36974949e-01f,
  -1.31662805e-02f, 1.06620990e-01f, 9.97053012e-02f, -3.75894867e-02f, 2.16440558e-01f, -1.37046650e-01f, 2.64665574e-01f, 3.33506048e-01f, -2.27395315e-02f, 5.79092875e-02f,
  4.83286306e-02f, 2.35043600e-01f, 2.74883181e-01f, 1.94893271e-01f, 1.65115088e-01f, -3.05072144e-02f, 8.76475200e-02f, 2.63320476e-01f, 4.76502068e-02f, -1.27645612e-01f,
  2.17362151e-01f, -1.67321891e-01f, -2.59997189e-01f, -4.79575843e-02f, 2.86178738e-01f, 1.24605894e-01f, -3.35567772e-01f, -5.77449910e-02f, -2.41985887e-01f, -4.36071396e-01f,
  2.74783105e-01f, -3.86075675e-01f, -3.18839699e-01f, 5.78354187e-02f, -6.03526086e-02f, 1.64931357e-01f, 6.40765429e-02f, -3.69097501e-01f, 1.45406440e-01f, 6.71415180e-02f,
  -3.87800150e-02f, 2.08095953e-01f, -2.40096435e-01f, 1.98484331e-01f, -1.22328168e-02f, -2.93974876e-01f, 2.50743121e-01f, -1.50384575e-01f, 8.42579752e-02f, 1.87616646e-01f,
  -8.63178745e-02f, -6.33648112e-02f, 2.02439539e-02f, 7.47734457e-02f, -8.78368095e-02f, 1.22676091e-02f, -2.35437691e-01f, -1.58510223e-01f, 2.39850767e-02f, 2.33584002e-01f,
  1.72532648e-01f, 2.78323174e-01f, 2.48714298e-01f, -7.35209063e-02f, 1.49727091e-01f, 1.13078386e-01f, -9.65467244e-02f, 2.71826297e-01f, -1.29270747e-01f, -3.44538659e-01f,
  2.03105628e-01f, -2.21622571e-01f, -4.14130569e-01f, -2.26965725e-01f, 9.13022757e-02f, -1.70848772e-01f, 3.11939627e-01f, -4.04832929e-01f, 3.55770141e-01f, -3.15258354e-01f,
  -2.70923197e-01f, 3.49996686e-01f, -2.09548324e-02f, 2.04284966e-01f, -9.83595178e-02f, 2.48562723e-01f, 2.37619549e-01f, 1.24723390e-02f, 6.26077801e-02f, 2.69644141e-01f,
  -3.35042238e-01f, -4.10384685e-01f, -2.57557154e-01f, -5.65865785e-02f, -3.80612850e-01f, 2.87313736e-03f, 8.43897536e-02f, 1.34075493e-01f, -4.47592437e-01f, -4.20813143e-01f,
  -2.72668123e-01f, 2.14459840e-02f, -3.02015066e-01f, -2.32132450e-01f, 2.95191985e-02f, -3.15120608e-01f, -2.85085022e-01f, -1.97127014e-01f, -2.94727981e-01f, 2.33714640e-01f,
  1.31627247e-01f, 1.07942238e-01f, -1.21385336e-01f, -8.46103281e-02f, -2.00001523e-03f, 9.17543322e-02f, 1.48247018e-01f, 1.24986075e-01f, -1.63902596e-01f, 2.02194169e-01f,
  -2.11626172e-01f, 3.18248570e-02f, 2.47527491e-02f, -1.75480694e-01f, -3.79395001e-02f, -1.53893247e-01f, -6.81567118e-02f, -2.45902345e-01f, -2.00537711e-01f, -1.71424434e-01f,
  8.07276592e-02f, -4.20646220e-01f, -1.56768307e-01f, -2.18315974e-01f, -3.45154792e-01f, 1.53893173e-01f, 3.18058096e-02f, 2.29060370e-02f, -2.72923082e-01f, -2.25608662e-01f,
  -1.18255533e-01f, -1.56971402e-02f, 1.88224033e-01f, 1.43154217e-02f, -3.67156565e-02f, -2.20688358e-01f, 5.35014048e-02f, 4.33168083e-01f, -4.31899071e-01f, -1.86500922e-01f,
  -3.04511726e-01f, -2.09186152e-01f, -2.95206070e-01f, -3.81434619e-01f, 1.45415723e-01f, 1.78173095e-01f, -4.71890718e-01f, -4.70288515e-01f, -3.97701651e-01f, -4.23358917e-01f,
  -4.14399415e-01f, -3.19488585e-01f, -2.08822403e-05f, -1.19321595e-03f, 2.57986903e-01f, -3.61711144e-01f, 1.68911770e-01f, 2.68087447e-01f, -5.12997389e-01f, -2.51960039e-01f,
  -1.93628982e-01f, 2.04688683e-01f, 1.68047816e-01f, -4.57579881e-01f, -7.56314397e-02f, 6.57704324e-02f, 1.75822303e-01f, 1.76951364e-01f, -1.11947348e-02f, -2.24325582e-01f,
  -1.39787674e-01f, 2.18988076e-01f, 2.45060816e-01f, 1.58929005e-01f, 2.23379254e-01f, -1.34946108e-01f, 1.72442392e-01f, -1.07445503e-02f, -1.85933664e-01f, -1.63583681e-01f,
  -7.98433200e-02f, -1.32954866e-01f, 7.70220831e-02f, -1.57492340e-01f, -1.74883857e-01f, -3.51376504e-01f, 2.66899765e-01f, 1.77179709e-01f, 9.09878686e-02f, 1.17973126e-01f,
  -2.28983238e-01f, -1.82003304e-01f, -2.66869277e-01f, 1.48648232e-01f, 7.80702010e-02f, -1.87390536e-01f, 2.90922940e-01f, -1.39491521e-02f, 2.69090891e-01f, -1.22312449e-01f,
  -1.45171329e-01f, 1.05570503e-01f, 7.98141137e-02f, -2.54100949e-01f, 2.29016051e-01f, 8.75991583e-02f, 2.17341393e-01f, -9.60799977e-02f, -1.93822220e-01f, -1.00700028e-01f,
  2.63246559e-02f, 1.26954049e-01f, 3.87046374e-02f, -1.07606314e-01f, -4.80373502e-01f, 1.41681703e-02f, 6.89794868e-02f, -6.25587329e-02f, 2.62228101e-01f, 1.85286433e-01f,
  -3.37365776e-01f, 2.27534592e-01f, -3.59776437e-01f, 6.11161925e-02f, -1.38478994e-01f, 6.75906986e-02f, -3.61244887e-01f, -3.86149436e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.53657138e-01f, 1.60211533e-01f, 3.83591950e-02f, -3.46408077e-02f, 1.48741975e-01f, -6.25774935e-02f, 7.65101910e-02f, -1.03290729e-01f, -2.57275272e-02f, 9.54737142e-02f,
  -1.29761085e-01f, -1.80163562e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    