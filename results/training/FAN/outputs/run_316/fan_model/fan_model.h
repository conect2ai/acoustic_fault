/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.23594375e-02f, 2.41716340e-01f, 1.87616140e-01f, 4.53976765e-02f, -4.51555699e-02f, -3.22548375e-02f, -1.99896022e-04f, 6.89645484e-02f, 2.82070100e-01f, 3.01128905e-02f,
  -2.35138655e-01f, 1.13722555e-01f, -6.93691969e-02f, -6.71445206e-02f, -1.60913140e-01f, -2.92024687e-02f, 2.57799197e-02f, 1.51489060e-02f, 1.00818291e-01f, -4.73394655e-02f,
  5.91148101e-02f, -1.66923001e-01f, 7.78099755e-03f, -1.11387163e-01f, -1.15064017e-01f, 1.06549941e-01f, -5.96118644e-02f, -3.00248973e-02f, -9.11869258e-02f, -4.74622399e-02f,
  -5.99082485e-02f, 4.79961708e-02f, 2.80166380e-02f, 4.05599661e-02f, -2.25418191e-02f, 1.32691469e-02f, -1.53948516e-02f, -9.47761536e-03f, -4.69007306e-02f, 9.51701328e-02f,
  -2.83344183e-02f, 1.67806037e-02f, -1.65196769e-02f, 6.58463570e-04f, 3.48033980e-02f, 2.39686500e-02f, 2.35305391e-02f, -4.81749289e-02f, 7.63323754e-02f, 1.79931649e-03f,
  1.31253954e-02f, 4.96809917e-05f, -1.77126955e-02f, -2.82846857e-02f, -5.18220998e-02f, 1.06842862e-02f, -3.12840799e-03f, 1.12892063e-02f, -2.51181088e-02f, 1.72451530e-02f,
  7.36405049e-03f, 3.27163078e-02f, -4.59254943e-02f, -7.59820594e-03f, -1.13464743e-02f, 3.80338579e-02f, -5.43424748e-02f, -2.01297645e-02f, -1.93717163e-02f, -6.38677031e-02f,
  -2.59227790e-02f, -4.95531745e-02f, -5.34658320e-02f, 6.50282949e-02f, -6.91937134e-02f, 2.93283761e-02f, -5.55928126e-02f, 3.21943834e-02f, 4.47774716e-02f, 1.13965003e-02f,
  6.45854184e-03f, 4.81679197e-03f, -4.64791991e-02f, 1.67460684e-02f, 1.95777193e-02f, 1.72817763e-02f, 5.92210256e-02f, 3.10793445e-02f, 5.04070893e-03f, -1.04297332e-01f,
  -5.11817336e-02f, -5.60996346e-02f, -2.75034327e-02f, -6.01555267e-03f, -3.15644592e-02f, -3.96882370e-03f, 5.35787679e-02f, 1.43306600e-02f, 4.64146361e-02f, -3.93345654e-02f,
  2.38826461e-02f, -3.84691358e-02f, 7.03385519e-03f, -1.28572918e-02f, 2.71022096e-02f, 8.30525458e-02f, -3.01547069e-03f, -3.12473755e-02f, -1.01737991e-01f, 1.92421041e-02f,
  -1.15026854e-01f, 1.48591600e-04f, 5.19929640e-02f, -3.21118510e-03f, 1.64469983e-02f, -8.99607688e-02f, 1.45092271e-02f, 4.15205806e-02f, -4.30906452e-02f, 3.74567579e-03f,
  -4.61354822e-01f, -1.74741000e-01f, -1.61752239e-01f, -1.69029012e-01f, -4.73113284e-02f, 1.04288682e-01f, 2.60116737e-02f, -1.70438290e-01f, -1.15944505e-01f, 1.48744851e-01f,
  4.59418558e-02f, -2.61109285e-02f, 2.02594519e-01f, -1.52915776e-01f, -2.57933587e-02f, 9.73923579e-02f, -1.86317027e-01f, -2.61517204e-02f, -8.99763331e-02f, -1.12435609e-01f,
  -1.48275346e-01f, 4.23287898e-02f, -1.88104231e-02f, -5.45080639e-02f, -1.60140976e-01f, -7.63895065e-02f, 8.71484950e-02f, 1.79629460e-01f, 6.07695691e-02f, 1.09757975e-01f,
  2.70151813e-03f, 6.27058372e-02f, -3.37551646e-02f, -3.94027270e-02f, 3.81990825e-03f, 2.32646149e-02f, 1.67566910e-02f, 9.34816822e-02f, -6.04315847e-02f, 3.46496813e-02f,
  3.38301848e-04f, -1.88993309e-02f, -3.49201486e-02f, 4.82916459e-02f, -1.13296591e-01f, -9.65616480e-03f, -7.55784661e-02f, -9.31258723e-02f, 1.13851083e-02f, -5.49665578e-02f,
  2.12167110e-02f, -5.93270138e-02f, -5.33991493e-02f, -5.84613979e-02f, -4.98033576e-02f, -8.87947530e-03f, 2.73123216e-02f, 4.50025909e-02f, -2.69965157e-02f, -3.72266397e-02f,
  -4.82010506e-02f, 1.59423929e-02f, -2.03568507e-02f, 1.11759165e-02f, -5.46265841e-02f, -4.95817338e-04f, -1.43783772e-02f, 2.80617606e-02f, -7.91269615e-02f, 2.52968427e-02f,
  1.00389705e-03f, -7.72214606e-02f, 2.56063305e-02f, -3.43456045e-02f, -2.53937989e-02f, 4.21856567e-02f, 1.19632399e-02f, 6.29108250e-02f, -5.81847578e-02f, 2.54378319e-02f,
  5.88588938e-02f, 4.22981791e-02f, 9.65064298e-03f, 5.46094663e-02f, 6.62174970e-02f, 1.23558706e-02f, 8.19225609e-03f, -7.40000745e-03f, -8.53203889e-03f, 5.52646704e-02f,
  -1.39853656e-02f, 1.02395020e-01f, 2.97029968e-02f, -1.27158761e-02f, 1.06718145e-01f, 4.99710403e-02f, -3.58449258e-02f, -3.28096300e-02f, 3.58137079e-02f, 5.87029457e-02f,
  6.35389835e-02f, 2.63129044e-02f, -2.11467389e-02f, -4.00478505e-02f, -3.26400623e-04f, 8.02156329e-02f, 7.69402832e-02f, 3.80694941e-02f, 4.58659679e-02f, 2.29389444e-02f,
  -4.67257714e-03f, 7.58021250e-02f, -3.57249454e-02f, -1.46244168e-02f, 1.83677562e-02f, -1.37821706e-02f, -3.85705978e-02f, -5.18599562e-02f, -4.58417907e-02f, -2.02349890e-02f,
  2.88089454e-01f, -1.64688006e-01f, -4.18170765e-02f, 3.03524047e-01f, 1.10904396e-01f, -2.10662499e-01f, 1.28421076e-02f, 5.34474514e-02f, 4.82275411e-02f, -1.51726827e-01f,
  1.44342348e-01f, -1.05155751e-01f, 3.87132391e-02f, 1.30146101e-01f, 2.21918344e-01f, -4.94789286e-03f, 1.92621067e-01f, -6.58471696e-03f, 8.34077410e-03f, 7.13485703e-02f,
  1.84598282e-01f, 9.82956663e-02f, 1.39574066e-01f, 3.50808054e-02f, 3.35359052e-02f, -1.37145706e-02f, 1.37101844e-01f, -1.33035138e-01f, 4.38498743e-02f, -5.24726287e-02f,
  2.48063151e-02f, 3.64537761e-02f, 7.23557100e-02f, -1.07254513e-01f, 3.21616791e-02f, 6.87496923e-03f, 3.18666501e-03f, 1.32381069e-02f, 4.60125320e-02f, -5.83382025e-02f,
  -8.66434872e-02f, -1.31961610e-02f, -2.75393277e-02f, -6.34663505e-03f, 1.72607452e-02f, 5.63228428e-02f, 4.41186987e-02f, 5.20239621e-02f, 2.64953747e-02f, -3.32112461e-02f,
  4.30796072e-02f, -5.32511016e-03f, -1.85158532e-02f, -2.42835768e-02f, 3.98818143e-02f, -2.30440982e-02f, -8.41829702e-02f, 5.04789278e-02f, -5.12739569e-02f, -1.54068992e-02f,
  3.11201829e-02f, -5.80959432e-02f, -2.74904650e-02f, -2.88864207e-02f, 5.16385771e-04f, 6.51516067e-03f, -3.56901474e-02f, 2.58497652e-02f, -6.07378148e-02f, -1.53315477e-02f,
  -1.36972852e-02f, 5.08411555e-03f, -5.53899212e-03f, 6.96186791e-04f, 2.14180872e-02f, 2.44693551e-02f, -2.64802184e-02f, -3.66223268e-02f, -4.24371660e-03f, 1.61423385e-02f,
  1.48312757e-02f, 2.51091775e-02f, -1.89047083e-02f, 4.01865207e-02f, 4.86618560e-03f, 3.33537906e-02f, 8.90080929e-02f, -4.22147848e-02f, 6.53984118e-03f, 3.14925388e-02f,
  -1.05116226e-01f, -5.07887872e-03f, 4.03928512e-04f, -1.53081166e-02f, -5.04768565e-02f, 4.96589541e-02f, 4.18605469e-03f, 6.77752774e-03f, -6.54876083e-02f, 1.95075795e-02f,
  4.87846360e-02f, 5.34255393e-02f, -8.12144950e-02f, 3.92308235e-02f, -2.27436386e-02f, -3.86203788e-02f, -5.04583642e-02f, -3.48774232e-02f, 3.72226397e-03f, 7.76152760e-02f,
  2.85970531e-02f, -5.26114553e-02f, 2.12065373e-02f, 4.83349934e-02f, 6.05379790e-02f, -9.70250741e-03f, 2.05415934e-02f, -6.43663779e-02f, -4.72122319e-02f, -2.50985287e-02f,
  -2.23570451e-01f, 7.42490888e-02f, -1.42371595e-01f, -6.83719367e-02f, -8.64490047e-02f, -1.02111019e-01f, 4.50378954e-02f, -3.82330902e-02f, -1.91324931e-02f, 1.52077511e-01f,
  2.05341682e-01f, -8.37366506e-02f, 1.67259481e-02f, 1.33631453e-01f, -7.47977048e-02f, 1.55200914e-01f, 3.71427648e-02f, -4.36879508e-02f, -8.80988967e-03f, -9.57693458e-02f,
  -3.42581458e-02f, 1.75341859e-01f, 1.18951529e-01f, 4.18749489e-02f, -2.84818392e-02f, 2.41302150e-05f, 5.71405841e-03f, -1.79562729e-03f, 2.71095112e-02f, 3.10430620e-02f,
  -5.54239042e-02f, -2.84333285e-02f, -1.47395790e-01f, -1.41869888e-01f, -9.38803777e-02f, -8.02659243e-02f, -1.05690204e-01f, -9.34376940e-02f, -7.27508292e-02f, -5.82070416e-03f,
  -5.82976360e-03f, -2.35397257e-02f, -6.55335039e-02f, 8.65418278e-03f, -6.92592189e-02f, 2.15599220e-02f, 3.52643244e-02f, 1.48479985e-02f, -1.04628270e-02f, -2.39699073e-02f,
  1.12800926e-01f, -2.95118261e-02f, 5.69899976e-02f, 3.00446451e-02f, -6.73212409e-02f, 7.22064376e-02f, 2.77598444e-02f, -5.71074151e-02f, -1.63964480e-02f, -4.05758582e-02f,
  -1.55207748e-02f, -5.04818745e-02f, 7.73703083e-02f, 5.31846993e-02f, -1.01884604e-02f, 5.03819361e-02f, 4.02003452e-02f, 5.34370020e-02f, 3.00853979e-02f, -3.64358425e-02f,
  -1.79327168e-02f, -4.88660438e-03f, -4.18517739e-02f, 4.10567932e-02f, 7.93578476e-02f, 6.28878921e-02f, -6.90353615e-03f, 4.41606529e-02f, -6.05819188e-03f, -1.86953582e-02f,
  6.47285432e-02f, -4.10925150e-02f, -1.21206166e-02f, 2.73706373e-02f, 3.83161493e-02f, 1.22935581e-03f, -2.62139980e-02f, 3.59016061e-02f, -3.62484157e-02f, -7.91447684e-02f,
  -1.56200588e-01f, -8.05880278e-02f, 3.74955125e-02f, -3.16557358e-03f, -6.29826486e-02f, -2.56920978e-02f, 3.31383422e-02f, 4.57112119e-03f, 5.76021150e-03f, -4.19014283e-02f,
  2.86672581e-02f, -7.95047879e-02f, -5.10997325e-02f, 9.07801166e-02f, 1.74365584e-02f, 5.28300554e-03f, -5.30589521e-02f, 3.74481198e-03f, 2.50572618e-02f, 6.16910644e-02f,
  8.07515308e-02f, 1.81870572e-02f, -5.49546927e-02f, 2.92392578e-02f, 1.09622236e-02f, -5.93259558e-03f, -8.55051875e-02f, 3.98710417e-03f, 2.26936652e-03f, -1.47412475e-02f,
  -4.30512339e-01f, 1.71547711e-01f, 6.99798623e-03f, 7.50632165e-03f, -1.20499969e-01f, -1.32404491e-01f, -1.44482478e-01f, 1.67439431e-01f, 2.25388929e-02f, 1.05039887e-01f,
  1.50043685e-02f, -9.62554589e-02f, 9.42660272e-02f, -2.26756986e-02f, -2.35205725e-01f, 1.72939584e-01f, 2.17340793e-02f, 8.18922371e-02f, 3.42004411e-02f, 2.90250499e-02f,
  -4.07554880e-02f, -4.36600894e-02f, -6.94062933e-02f, 8.32224563e-02f, -1.13724526e-02f, 6.28491938e-02f, 5.74304387e-02f, 3.29616517e-02f, -2.46323906e-02f, -1.42777129e-03f,
  -9.17847529e-02f, 7.53090829e-02f, -5.28989360e-02f, 1.83338095e-02f, 7.10644992e-04f, -1.73201971e-02f, 5.86770754e-03f, -4.85344753e-02f, 1.31546212e-02f, -1.11337304e-02f,
  -2.57297754e-02f, -3.43846753e-02f, -4.96276878e-02f, 3.94222438e-02f, -4.11556885e-02f, -1.38988327e-02f, -1.10703250e-02f, 6.30021617e-02f, 3.94602679e-02f, -6.06714115e-02f,
  3.61672044e-02f, 3.74237709e-02f, 2.34734919e-02f, 3.09248851e-03f, 5.54735474e-02f, 4.82622767e-04f, -7.05444738e-02f, 1.09353894e-02f, -1.05128326e-02f, 1.09348400e-02f,
  -2.64116116e-02f, -3.47077399e-02f, 9.07215197e-03f, -6.74733594e-02f, -3.19333337e-02f, 1.22671598e-03f, -5.31646349e-02f, -3.17427143e-02f, 5.76367776e-04f, -5.59061440e-03f,
  -5.49227174e-04f, -1.85426138e-02f, 6.08481988e-02f, -4.76203561e-02f, -1.11881502e-01f, -2.26287618e-02f, -4.18886393e-02f, 2.02163383e-02f, 7.08668530e-02f, -3.71525884e-02f,
  1.19094700e-02f, 1.01045920e-02f, 1.75638739e-02f, -1.79043431e-02f, -7.07846554e-03f, -1.23959510e-02f, 3.69972363e-02f, 2.79064849e-02f, -4.25973684e-02f, -4.31616791e-02f,
  1.23125352e-01f, 1.57923520e-01f, 3.72039266e-02f, -5.86367352e-03f, 7.70438612e-02f, 6.02680668e-02f, 1.39125893e-02f, -1.22698359e-02f, 6.28769547e-02f, 2.93250214e-02f,
  3.53662297e-02f, 3.76079790e-02f, 1.80670880e-02f, 2.15956960e-02f, -7.45340958e-02f, 2.75417846e-02f, 2.89679002e-02f, 1.42145867e-03f, -4.98089306e-02f, 4.33715656e-02f,
  6.03020154e-02f, -2.00733282e-02f, 1.89929770e-03f, 1.32944752e-02f, -1.23653477e-02f, -2.34032422e-02f, 8.60898383e-03f, -3.74876894e-02f, -2.33320352e-02f, 1.73296649e-02f,
  -2.96468556e-01f, 8.23631510e-02f, 3.17170843e-02f, -8.40947032e-02f, -6.00203611e-02f, 8.81683379e-02f, 1.66122586e-01f, -8.19217414e-02f, -1.57877594e-01f, 1.16298445e-01f,
  7.69210085e-02f, -3.65263637e-04f, 8.51267427e-02f, 7.40326643e-02f, 9.17889625e-02f, 1.54933408e-01f, -7.13945851e-02f, 4.15969603e-02f, -8.39929655e-02f, -1.10639520e-01f,
  -1.14348359e-01f, -8.64529703e-03f, 1.01077408e-01f, -7.92290643e-02f, 2.34539318e-03f, -1.13977201e-01f, 2.46080291e-02f, -2.20785830e-02f, 7.18444958e-02f, 8.20959508e-02f,
  4.60797129e-03f, -2.16966882e-01f, -4.74349596e-02f, 4.95342910e-02f, -2.98143215e-02f, 1.87062938e-02f, 3.63268666e-02f, 2.35649832e-02f, -9.22083948e-03f, -5.28830364e-02f,
  1.07090071e-01f, -7.60492682e-02f, 3.60858850e-02f, -4.22815233e-03f, 3.63096595e-02f, -2.79124081e-02f, -3.87304537e-02f, 1.11241983e-02f, 3.86041179e-02f, 1.31071225e-01f,
  6.14650324e-02f, 6.35438785e-02f, 2.92646606e-02f, 3.28122675e-02f, 5.04859164e-02f, -3.71877886e-02f, 1.26032149e-02f, 6.89362213e-02f, 3.43320780e-02f, 1.00676874e-02f,
  -4.95762117e-02f, 2.18436308e-02f, 2.63820253e-02f, 4.69040722e-02f, 5.00224205e-03f, 4.36163805e-02f, -5.86792082e-03f, -1.67517399e-04f, 2.81478604e-03f, 1.28693413e-03f,
  -8.73481017e-03f, -5.78633621e-02f, -8.25738162e-02f, 5.81259206e-02f, 2.18767836e-03f, -6.32354096e-02f, 1.88368745e-02f, -4.88165058e-02f, 4.28527407e-02f, -4.98044454e-02f,
  -3.56917344e-02f, 2.40200479e-02f, 3.46080624e-02f, 8.83955788e-03f, -2.03978717e-02f, 2.75630709e-02f, 1.54188676e-02f, 2.56751408e-03f, -6.39907196e-02f, 3.26997135e-03f,
  -1.38000876e-01f, -2.64091134e-01f, -5.16691692e-02f, -8.95031244e-02f, -7.52580911e-02f, 1.01878410e-02f, -1.13410186e-02f, -2.29009874e-02f, 6.05466478e-02f, -3.99543978e-02f,
  2.30858941e-03f, 2.62304191e-02f, -3.84470150e-02f, -1.80616342e-02f, 4.81003802e-03f, -1.03608631e-02f, 2.60994444e-03f, 4.29980569e-02f, -5.36806807e-02f, -8.92822805e-04f,
  -5.08730635e-02f, -9.42392647e-02f, 5.94633780e-02f, -1.09581292e-01f, 2.84983665e-02f, 1.87425371e-02f, -6.61106929e-02f, 8.29035509e-03f, 4.37037796e-02f, 5.22950441e-02f,
  3.33950847e-01f, -1.86452772e-02f, -7.26497471e-02f, 5.63746765e-02f, 1.08406819e-01f, -2.60555726e-02f, 3.75639759e-02f, 1.80716254e-02f, 1.10312618e-01f, -6.27897233e-02f,
  5.17764017e-02f, 4.82208095e-02f, -7.63976425e-02f, -4.43696827e-02f, 2.30753541e-01f, 6.20913282e-02f, 2.98856813e-02f, -1.99922849e-03f, -4.48491191e-03f, -6.40555620e-02f,
  -5.30003011e-03f, -4.29707346e-03f, -4.56862524e-02f, -1.98759586e-02f, 2.21190806e-02f, 3.17372978e-02f, 4.96931896e-02f, 1.28311838e-03f, -1.03466986e-02f, 7.60636553e-02f,
  4.35878970e-02f, -5.81980087e-02f, -7.12357834e-02f, 2.88340747e-02f, -6.98829964e-02f, -5.04092649e-02f, 5.15624098e-02f, -1.72316823e-02f, 7.98854679e-02f, 2.80184560e-02f,
  9.05188993e-02f, -3.16969231e-02f, 3.73980100e-03f, -5.71672358e-02f, -5.44752181e-02f, -4.66014706e-02f, 2.43418626e-02f, -4.19275053e-02f, -3.20123211e-02f, -5.14342338e-02f,
  5.43624815e-03f, 5.16863279e-02f, -5.93351796e-02f, -2.13680305e-02f, -5.02203107e-02f, 5.95116392e-02f, 8.92242044e-03f, -1.62114054e-02f, -8.08386356e-02f, 3.38120572e-02f,
  5.59702795e-03f, -4.64413911e-02f, 7.51449959e-03f, -2.09064167e-02f, -5.83684519e-02f, -4.25875047e-03f, -2.91350149e-02f, -4.09514830e-02f, -6.36999607e-02f, -4.34224382e-02f,
  -5.38979061e-02f, -2.07285117e-03f, -2.15093065e-02f, -4.22715098e-02f, 6.99438527e-03f, 2.03152057e-02f, -2.63787508e-02f, 1.55144371e-03f, 4.77986224e-02f, -8.95877276e-03f,
  -5.54578332e-03f, -3.09797972e-02f, -1.97901428e-02f, -6.76900372e-02f, -3.83798522e-03f, 3.70216630e-02f, 3.15832980e-02f, 3.69144380e-02f, -5.06149419e-02f, -6.10249639e-02f,
  -1.14236355e-01f, -2.74113584e-02f, 2.53907125e-02f, -4.03832942e-02f, 5.16627654e-02f, 6.30787537e-02f, 5.28321341e-02f, -2.01940425e-02f, -4.57015224e-02f, -4.35920358e-02f,
  9.90070403e-02f, -2.15911232e-02f, 2.56695356e-02f, 2.22234558e-02f, -4.62194271e-02f, 2.26628818e-02f, 1.27689715e-03f, 2.91379988e-02f, 3.43077108e-02f, 7.14811087e-02f,
  7.12750927e-02f, -3.70009653e-02f, 4.94165048e-02f, 4.93301935e-02f, 7.78608606e-04f, -6.13651723e-02f, 2.31694672e-02f, -1.73675604e-02f, -1.62698608e-02f, 1.69357155e-02f,
  -7.37075284e-02f, -1.55515701e-01f, -2.07131188e-02f, -1.89534262e-01f, 1.56959310e-01f, 1.10943347e-01f, -1.50708854e-01f, 1.52164012e-01f, -2.36836508e-01f, -1.46146640e-01f,
  4.15314212e-02f, -1.16084620e-01f, -7.53643811e-02f, 7.82874320e-03f, -6.56992719e-02f, -1.29162699e-01f, -4.43850383e-02f, -9.68296602e-02f, -5.83153730e-03f, -1.32996216e-01f,
  -5.38576879e-02f, 7.58691654e-02f, 1.27318886e-03f, 2.14112684e-01f, -4.70741503e-02f, 1.01161581e-02f, 2.59149540e-02f, 6.63838536e-02f, 4.83300611e-02f, 1.25575975e-01f,
  9.31142084e-03f, -1.21857256e-01f, -4.06465083e-02f, 5.20662554e-02f, -6.83458969e-02f, -5.47139049e-02f, 4.08370458e-02f, 3.52137797e-02f, -6.99262023e-02f, 6.45052700e-04f,
  -2.56566089e-02f, 7.75296241e-02f, -2.38965135e-02f, 6.01916984e-02f, -5.09599447e-02f, 4.10035811e-02f, 5.17089013e-03f, 4.19267081e-02f, 9.69374999e-02f, -1.01431292e-02f,
  2.88470909e-02f, 6.27598837e-02f, -1.93923693e-02f, 9.16879252e-03f, -2.53268164e-02f, 6.93088397e-02f, -7.17662573e-02f, 2.44175345e-02f, 3.87313366e-02f, -1.77458730e-02f,
  1.56316739e-02f, 4.86944690e-02f, 4.07039188e-02f, 7.73895979e-02f, -2.02058870e-02f, 8.44328851e-02f, -2.38339044e-02f, 4.77880053e-02f, 3.47495489e-02f, 4.05024663e-02f,
  6.45916164e-02f, -1.78796463e-02f, 5.45228198e-02f, -5.32591389e-03f, -3.68129574e-02f, 4.35553305e-02f, 3.95912156e-02f, -5.04694954e-02f, 4.75604013e-02f, 3.69326435e-02f,
  -2.44383570e-02f, -1.76946986e-02f, -1.31006837e-02f, 6.54833093e-02f, -2.41086795e-03f, -1.69531405e-02f, 2.91891154e-02f, 1.37653034e-02f, 2.35315468e-02f, -2.81535485e-03f,
  -1.45677283e-01f, -1.27479583e-01f, -5.51054515e-02f, 5.23242839e-02f, 4.52960543e-02f, 4.25734296e-02f, -3.07345707e-02f, 9.07323584e-02f, -8.34315829e-03f, -5.33306487e-02f,
  5.36427312e-02f, 5.15363179e-02f, 4.94466536e-02f, -2.93869469e-02f, 4.18099910e-02f, 1.90191399e-02f, 2.38126493e-03f, -2.98976358e-02f, 4.20981683e-02f, -2.05326267e-02f,
  -4.52884771e-02f, 8.48803483e-03f, -2.36603841e-02f, 4.93714632e-03f, 1.86228231e-02f, -4.11052853e-02f, -4.30656970e-03f, 4.42457432e-03f, 1.45626226e-02f, 7.68261822e-03f,
  -2.12384418e-01f, 1.68541163e-01f, 6.35073259e-02f, -8.55416209e-02f, -6.07255697e-02f, -2.16367453e-01f, -3.07113469e-01f, 6.31774366e-02f, -3.13181520e-01f, 1.24011198e-02f,
  -1.83289900e-01f, -3.66029069e-02f, -7.30349347e-02f, -1.34589449e-01f, -4.13597882e-01f, -2.62178272e-01f, -2.23603636e-01f, -1.04612559e-01f, -1.23899452e-01f, 2.52523776e-02f,
  -1.31274592e-02f, -1.89026184e-02f, 4.85541262e-02f, 1.94784999e-01f, 1.01780675e-01f, 2.84999698e-01f, 1.42336428e-01f, 1.12100959e-01f, 1.67352825e-01f, 3.53090465e-02f,
  -1.46926075e-01f, -1.13094084e-01f, 9.41290185e-02f, 4.27115969e-02f, 5.94265871e-02f, 4.13756669e-02f, -1.88099202e-02f, -2.41756774e-02f, -2.51280647e-02f, 2.57760696e-02f,
  -3.17419544e-02f, -1.77099314e-02f, 2.40140446e-02f, -3.43645848e-02f, -3.42357308e-02f, -3.58186178e-02f, 3.93004306e-02f, -9.27841663e-03f, -5.30820675e-02f, 3.43472399e-02f,
  -5.97862415e-02f, 4.41881195e-02f, 3.22523643e-03f, 2.00308301e-02f, 2.60479674e-02f, -8.14473853e-02f, 1.38189141e-02f, 2.32954752e-02f, 7.52285123e-03f, -5.67435995e-02f,
  1.53984064e-02f, 2.80708689e-02f, 3.30390520e-02f, 5.95018081e-02f, -4.83490620e-03f, 3.45548466e-02f, -6.55551255e-02f, 2.50218492e-02f, 8.02292861e-03f, -3.91942970e-02f,
  -2.68019345e-02f, 2.65658721e-02f, -5.57081774e-02f, -2.47788010e-03f, 2.75771432e-02f, 1.24481292e-02f, 1.07752336e-02f, 1.08997356e-02f, -2.35258061e-02f, -5.76376170e-03f,
  -5.50648198e-02f, -2.73248833e-02f, 3.52676027e-02f, 5.85020371e-02f, 1.21127290e-03f, 2.60074195e-02f, 4.65148967e-03f, 1.00193629e-02f, 4.01277021e-02f, -1.80924144e-02f,
  -3.18346247e-02f, 1.41125724e-01f, 2.68592611e-02f, -3.15831788e-02f, -6.00089356e-02f, -4.44306470e-02f, -1.81317013e-02f, 4.58245398e-03f, 5.95636442e-02f, 4.40780297e-02f,
  3.72676551e-02f, -2.15739738e-02f, 1.45113887e-02f, 7.92592540e-02f, 3.25037092e-02f, 9.74841043e-03f, -4.25056592e-02f, 1.93090793e-02f, 2.97035668e-02f, -1.57934632e-02f,
  8.58048424e-02f, -9.87085029e-02f, 5.55458991e-03f, 6.75553828e-02f, 3.75694260e-02f, -1.23852706e-02f, 2.43013091e-02f, 2.80767530e-02f, 8.83839931e-03f, 4.65311197e-04f,
  -1.24909885e-01f, 1.86518162e-01f, 5.27918199e-03f, 4.06878702e-02f, -7.99472034e-02f, 1.44502476e-01f, 2.17779040e-01f, 2.89504696e-02f, 1.66722119e-01f, 1.60889268e-01f,
  5.77748753e-02f, 1.23923473e-01f, 8.47070292e-03f, 1.76064178e-01f, -7.81556070e-02f, 3.09271403e-02f, 1.08275078e-01f, 9.40806419e-02f, 9.89975315e-03f, -5.09329401e-02f,
  -2.71434411e-02f, 2.88947648e-03f, -1.10137433e-01f, -2.26716287e-02f, 1.89849490e-03f, -4.97554727e-02f, -1.58781871e-01f, -1.18413657e-01f, 1.39136491e-02f, -2.13389453e-02f,
  5.72060011e-02f, -1.14027612e-01f, 1.06157400e-01f, -8.80666077e-02f, -8.09679553e-02f, -8.00421312e-02f, -7.20873475e-02f, -6.09935587e-03f, 2.70254407e-02f, -2.77778693e-02f,
  2.37184316e-02f, 4.74426486e-02f, 9.71849784e-02f, -1.51774497e-03f, 6.34094179e-02f, 4.77966368e-02f, 5.39782979e-02f, 1.46987231e-03f, -6.79818094e-02f, -3.04870047e-02f,
  2.75392905e-02f, 3.30133960e-02f, -4.28875349e-02f, -2.49256212e-02f, 4.84388694e-03f, -4.27184291e-02f, -1.84783395e-02f, -6.51102811e-02f, -3.05345729e-02f, -1.84642598e-02f,
  9.64677632e-02f, -1.71181802e-02f, 4.87239398e-02f, -5.62596098e-02f, -5.56522398e-04f, -2.25271005e-02f, 8.37204680e-02f, 1.24295549e-02f, 8.58965723e-05f, 1.43721150e-02f,
  -7.58009776e-02f, 3.46262418e-02f, -1.54560469e-02f, 5.01507521e-02f, 1.58661827e-02f, -2.76988335e-02f, 6.34453900e-04f, -3.70344855e-02f, 1.75896641e-02f, 2.10931916e-02f,
  -2.21697744e-02f, 3.53988037e-02f, -1.59463547e-02f, -5.14078140e-03f, -5.34029678e-02f, -7.06409812e-02f, -3.15076718e-03f, 3.24292965e-02f, 1.03221536e-02f, 3.52035649e-02f,
  -3.01271603e-02f, -1.25430048e-01f, 9.81367379e-02f, 4.01661918e-02f, 4.50682081e-02f, 5.05353287e-02f, 1.57350432e-02f, -6.84553804e-03f, -3.79580446e-03f, -3.76139916e-02f,
  -8.38227347e-02f, -9.39189363e-03f, -1.60841946e-03f, -1.56112108e-02f, 2.34700255e-02f, 5.66317663e-02f, -5.20794280e-02f, -4.86666001e-02f, 8.35421495e-03f, 1.42659270e-03f,
  -2.22724043e-02f, -8.84801149e-02f, -4.91412058e-02f, -3.65941338e-02f, -7.36632496e-02f, 8.55729450e-03f, 1.11464895e-02f, -8.49524960e-02f, 5.33386227e-03f, 7.72413388e-02f,
  -4.66755182e-02f, 2.17996426e-02f, -5.47868051e-02f, 1.78883433e-01f, -5.20029180e-02f, 2.99748212e-01f, 3.97786885e-01f, -1.04692250e-01f, 7.01558515e-02f, 1.86129346e-01f,
  1.39628872e-01f, 1.37768909e-01f, 3.81043665e-02f, 2.05214426e-01f, 2.52223462e-02f, -3.18428352e-02f, 1.55652508e-01f, 1.34460658e-01f, -6.94464073e-02f, 1.40942233e-02f,
  8.06086883e-03f, 4.40952517e-02f, -5.42672165e-02f, -1.47327214e-01f, 1.11480832e-01f, -6.91937208e-02f, 9.46785323e-03f, -8.98051262e-02f, -2.04047468e-02f, 5.47000840e-02f,
  -2.75733732e-02f, -4.29284871e-02f, -6.75352663e-03f, 2.21437104e-02f, 3.83831225e-02f, 5.16962074e-02f, -1.30837061e-03f, 5.50652854e-03f, -8.33779499e-02f, -1.54142529e-02f,
  4.99778390e-02f, -8.14802870e-02f, 2.39285566e-02f, -6.19159453e-02f, -6.84473440e-02f, -1.82421152e-02f, -4.14604209e-02f, 1.47262011e-02f, -3.16225030e-02f, -1.05749220e-01f,
  -4.70067710e-02f, -3.63591015e-02f, 9.05070305e-02f, 6.76202029e-02f, 1.07796127e-02f, 2.58061159e-02f, 1.20888181e-01f, 3.93212922e-02f, -2.55272537e-02f, 2.71985680e-02f,
  6.28012139e-03f, -8.25790968e-03f, -3.17588933e-02f, -7.97927901e-02f, 1.41730942e-02f, -5.81204593e-02f, 7.46404333e-03f, -4.36856635e-02f, 1.67380944e-02f, 6.02360778e-02f,
  1.01757632e-03f, -1.52605297e-02f, -7.16009084e-03f, 8.44432972e-03f, 6.12345748e-02f, 1.19999899e-02f, 3.75198498e-02f, -1.14631690e-02f, 1.61091462e-02f, -2.67068041e-03f,
  2.72192396e-02f, 4.76429127e-02f, 1.95278767e-02f, 6.53692856e-02f, 1.88585483e-02f, 2.41264831e-02f, -6.07432378e-03f, -5.68877272e-02f, 1.50738014e-02f, -5.89328958e-03f,
  1.60129905e-01f, 1.02660455e-01f, -7.73628354e-02f, 8.42688326e-03f, 3.53187844e-02f, -6.62034750e-02f, 5.66620380e-02f, 1.91878863e-02f, 4.27955166e-02f, 5.51745221e-02f,
  -1.23431534e-02f, 2.52491124e-02f, 3.15956697e-02f, 4.47914936e-02f, -2.43508108e-02f, 2.04152539e-02f, 2.85131671e-02f, -3.19070695e-03f, 2.78063938e-02f, 2.39455495e-02f,
  2.08009146e-02f, 1.04355095e-02f, 2.42878217e-02f, 3.00563239e-02f, -3.53878401e-02f, 2.66692657e-02f, 1.78533774e-02f, -3.03647332e-02f, 1.00090876e-02f, -5.82244843e-02f,
  -5.39409705e-02f, 8.37846622e-02f, -3.97228539e-01f, -6.57014474e-02f, -1.99154448e-02f, -3.92785408e-02f, 1.78074427e-02f, -6.69191405e-02f, -7.81124905e-02f, 1.96733341e-01f,
  9.11030471e-02f, -2.18026787e-02f, 3.13647799e-02f, 1.10740373e-02f, 1.00588396e-01f, -2.00121682e-02f, 1.91242069e-01f, 6.84396252e-02f, -1.21927291e-01f, 1.01142570e-01f,
  -4.07307111e-02f, 1.36269033e-01f, -1.08828925e-01f, -4.71536294e-02f, -6.05634823e-02f, -7.17951879e-02f, 1.66347980e-01f, -2.09595621e-01f, 5.17800897e-02f, -6.58365414e-02f,
  2.46730428e-02f, -8.29204023e-02f, 6.73362464e-02f, -3.57989259e-02f, 7.73895998e-03f, 2.88874712e-02f, -3.81473750e-02f, -9.63674709e-02f, -5.27470559e-02f, -1.89363603e-02f,
  8.30984488e-02f, -5.91895655e-02f, 4.54913341e-02f, -9.01459157e-02f, -7.08837584e-02f, -3.14769931e-02f, -5.59056848e-02f, -2.24500429e-02f, -2.96480563e-02f, -7.69481584e-02f,
  -1.93780623e-02f, 8.11432116e-03f, -3.28679644e-02f, 1.98699180e-02f, -3.25993262e-02f, -4.81364727e-02f, -5.56231588e-02f, -6.10703081e-02f, 8.71759206e-02f, -5.95795736e-02f,
  -1.05053090e-01f, 3.69604491e-02f, -1.01105198e-02f, 6.09481335e-02f, 2.84628402e-02f, -2.82270070e-02f, 1.44411027e-02f, -1.13576911e-02f, -2.32437644e-02f, 4.48527709e-02f,
  -7.42060225e-03f, 8.12771469e-02f, -1.09080235e-02f, -1.30278813e-02f, -4.20916416e-02f, 5.29376194e-02f, 2.06551587e-04f, -4.72814962e-02f, 4.48740944e-02f, -2.12780405e-02f,
  3.54020745e-02f, -3.22510079e-02f, 5.50109632e-02f, -2.17066444e-02f, -8.36941600e-02f, -5.51542789e-02f, 5.87635413e-02f, -6.64872378e-02f, 4.41182107e-02f, -1.30833627e-03f,
  2.89813876e-01f, 1.08297132e-01f, 7.30351359e-02f, 8.20502490e-02f, -2.74227485e-02f, 9.97941121e-02f, 2.16486342e-02f, -1.08213564e-02f, 1.98083576e-02f, 3.38933198e-03f,
  1.08336275e-02f, -6.98092021e-03f, -4.29019378e-03f, -1.24581093e-02f, 8.27629864e-02f, -1.68452784e-02f, 7.95857906e-02f, 5.73111698e-02f, 1.22300059e-01f, -1.62863825e-02f,
  2.46700011e-02f, 2.73454096e-02f, 5.43877436e-03f, 9.91345756e-03f, 6.35470003e-02f, 3.39793935e-02f, 6.42449688e-03f, -8.67999569e-02f, -4.13178727e-02f, -2.12446619e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.92445317e-02f, 3.09843943e-02f, -2.04563245e-01f, 2.31191423e-02f, 1.58052787e-01f, 6.87006414e-02f, -1.54754221e-01f, 3.20081674e-02f, -1.45484224e-01f, 4.14074659e-02f,
  1.23154745e-01f, -7.40245283e-02f, -6.47583380e-02f, 1.89974532e-01f, 7.58260787e-02f, -9.75423977e-02f, 2.12023348e-01f, 4.98252213e-02f, -6.53247908e-02f, 6.50551170e-02f,
  -7.52410367e-02f, 2.33661294e-01f, 6.29461333e-02f, 7.65674040e-02f, -1.09450435e-02f, -2.73807877e-04f, 1.75129250e-01f, -7.02716038e-02f, 9.14752707e-02f, 8.42278264e-03f,
  -6.46240041e-02f, 5.66937914e-03f, -1.25511557e-01f, -1.23099968e-01f, -1.44019378e-02f, 1.02599099e-01f, -4.69729938e-02f, -7.43423123e-03f, -3.94946989e-03f, -5.39388508e-02f,
  -1.28995851e-02f, 5.30584641e-02f, -1.58489104e-02f, 3.44306021e-03f, 4.90319096e-02f, 6.77397475e-02f, -2.27820594e-03f, -7.86369294e-02f, 2.95688566e-02f, -6.22051507e-02f,
  3.83210219e-02f, 7.61228129e-02f, 7.65227713e-03f, 8.19370002e-02f, 1.57913901e-02f, -6.07791394e-02f, -4.16981662e-03f, -2.27644704e-02f, 5.80751076e-02f, -1.83519442e-02f,
  -9.43271909e-03f, -3.15192975e-02f, 7.07886592e-02f, 3.08319833e-02f, -1.28370970e-02f, 8.43801424e-02f, -4.13434058e-02f, 3.32971700e-02f, -7.18036667e-02f, -4.67425920e-02f,
  1.26617039e-02f, -3.55986319e-02f, -2.68624090e-02f, -3.80375944e-02f, 1.35941980e-02f, -6.94495589e-02f, -8.78281593e-02f, -4.28422587e-03f, -3.90538983e-02f, 6.61835894e-02f,
  -1.06653459e-01f, -3.29318345e-02f, 5.22429384e-02f, -8.02624673e-02f, 3.12590748e-02f, 5.90381920e-02f, 3.46672870e-02f, -7.57525489e-03f, 2.86062881e-02f, -1.17273824e-02f,
  9.79933962e-02f, 4.32479121e-02f, 2.64425459e-03f, -1.57660153e-02f, 6.00663945e-02f, 1.39080808e-01f, -5.05425781e-02f, -3.78695801e-02f, 3.94807756e-03f, 7.86250457e-02f,
  9.68044773e-02f, -4.08546515e-02f, 1.19591905e-02f, 7.37261996e-02f, -1.01303615e-01f, -6.58079470e-03f, -5.36775663e-02f, 1.69682875e-02f, 1.23352837e-02f, 8.44289511e-02f,
  7.35995993e-02f, -2.41054446e-02f, -5.63930012e-02f, 2.26057805e-02f, -1.43473847e-02f, 6.45206422e-02f, -5.34603186e-02f, 4.25881334e-02f, 1.04793638e-01f, -6.27915487e-02f,
  2.26664133e-02f, 6.16959520e-02f, 5.17275650e-03f, 1.57274485e-01f, -3.30098569e-02f, -1.34746730e-01f, -1.64596856e-01f, 2.46233363e-02f, -1.97138309e-01f, 1.34685412e-01f,
  1.51156320e-03f, 1.63458765e-01f, -1.22923002e-01f, -7.31904467e-04f, -6.14113994e-02f, -2.61145741e-01f, 4.15574312e-02f, 1.31622795e-02f, -9.52210501e-02f, 2.32291013e-01f,
  -3.34141925e-02f, 7.37684369e-02f, 3.91643830e-02f, 3.87532115e-02f, 4.08804826e-02f, 2.18468383e-01f, 1.66819707e-01f, -7.99957663e-02f, 2.28684142e-01f, 3.40319984e-02f,
  -9.35177431e-02f, 3.28648910e-02f, 2.25513093e-02f, -3.30087654e-02f, 5.70153072e-02f, -4.03578877e-02f, 3.13972495e-02f, -1.80546734e-02f, -7.49597922e-02f, 9.34330840e-03f,
  -8.26049037e-03f, -3.43349427e-02f, -4.54439403e-04f, -7.91096911e-02f, 2.51092017e-03f, 2.46560317e-03f, -4.62388434e-02f, 6.05492927e-02f, 1.09896488e-01f, 3.37865874e-02f,
  7.62962550e-02f, -6.88865036e-02f, 2.09160000e-02f, 2.23351363e-02f, -5.22865839e-02f, 4.25430015e-02f, -4.27846424e-02f, -1.01546207e-02f, 1.07592873e-01f, -4.33973968e-03f,
  -4.96950299e-02f, -5.04850708e-02f, -3.94580811e-02f, -8.02987963e-02f, 5.14764152e-02f, -5.94830923e-02f, 5.18864840e-02f, -6.87613636e-02f, -1.06681231e-02f, -1.49061838e-02f,
  -3.73994373e-02f, -2.28791591e-02f, 5.89903072e-02f, 3.84864099e-02f, 7.71996658e-03f, -9.35550109e-02f, -2.63822135e-02f, 2.47283163e-03f, -1.42466994e-02f, -3.32206488e-02f,
  -7.47549832e-02f, 3.95254837e-03f, 2.35541724e-02f, 8.71012826e-03f, 3.46356560e-03f, -3.38420533e-02f, -4.08115797e-02f, 5.87427169e-02f, -8.16087499e-02f, 2.27902662e-02f,
  3.04384753e-02f, 1.47114307e-01f, -1.99525468e-02f, -9.65510160e-02f, -1.86335128e-02f, 1.73063669e-02f, 1.01530887e-01f, 6.55885506e-03f, -1.07683083e-02f, 7.23804627e-03f,
  1.54889394e-02f, -5.10829687e-02f, 4.56079803e-02f, 1.31509104e-03f, -2.30042487e-02f, -1.21665664e-01f, 3.51142213e-02f, 4.60187532e-02f, 1.73995957e-01f, 1.29200906e-01f,
  -1.63831096e-02f, -7.21856281e-02f, 8.88362974e-02f, -4.45871707e-03f, 2.94364989e-02f, 3.62363644e-02f, 9.07552913e-02f, 1.15557052e-02f, 1.87878415e-03f, -2.99340822e-02f,
  1.40568063e-01f, -1.22452445e-01f, -1.96678355e-01f, 2.41067242e-02f, -1.06220447e-01f, -2.51639515e-01f, -3.03488255e-01f, -7.23598897e-02f, 2.74934601e-02f, 3.80294286e-02f,
  -6.67621493e-02f, -2.37313882e-02f, 1.58628553e-01f, -1.17379360e-01f, 7.37574399e-02f, 6.96920082e-02f, -5.83136901e-02f, -4.80241328e-02f, 9.06602293e-02f, 1.91394817e-02f,
  1.36532113e-01f, -1.97585300e-02f, 1.71013828e-02f, -7.69579485e-02f, -1.73031375e-01f, 3.32546979e-02f, 1.63745537e-01f, -1.17928237e-01f, -1.08929314e-01f, -1.54379845e-01f,
  5.12850797e-03f, 1.29624948e-01f, -8.26589316e-02f, -4.95440513e-02f, 2.99133006e-02f, -8.86398032e-02f, -1.22116908e-01f, 1.19705405e-02f, -2.35992167e-02f, -4.16531898e-02f,
  7.20893294e-02f, 1.21901616e-01f, -7.73575380e-02f, -5.64615130e-02f, -6.07534386e-02f, -7.04335198e-02f, -2.53201388e-02f, -1.14127137e-01f, -2.77546458e-02f, 5.83176054e-02f,
  -7.96609595e-02f, 5.14163859e-02f, -1.23338234e-02f, -4.72671762e-02f, 4.59008850e-02f, -8.46688673e-02f, -3.23608667e-02f, 6.13297476e-03f, 6.63779229e-02f, -2.27552950e-02f,
  6.50903732e-02f, 3.36576700e-02f, 7.31958151e-02f, -2.64723971e-02f, -1.25304237e-02f, -1.11321192e-02f, -7.33534917e-02f, -6.81203045e-03f, -6.35336265e-02f, 1.72924867e-03f,
  -3.25300694e-02f, 4.18591015e-02f, -4.07924168e-02f, 3.24241966e-02f, 4.43040766e-02f, -2.78517548e-02f, -5.13379276e-02f, 2.93686017e-02f, 2.38005184e-02f, -5.53723611e-02f,
  7.44315535e-02f, 1.08864844e-01f, -5.89772537e-02f, -1.17482636e-02f, 1.34857651e-02f, 6.19853958e-02f, -3.42304856e-02f, 4.55359742e-02f, -5.92857674e-02f, 7.77990967e-02f,
  -6.43838570e-02f, 1.50142998e-01f, -7.10689351e-02f, -3.00875269e-02f, 3.36947814e-02f, 6.07075058e-02f, 1.93344206e-02f, 8.93112421e-02f, 7.32507631e-02f, -6.24046288e-02f,
  4.99429777e-02f, 4.05080579e-02f, 8.34468976e-02f, -4.29107510e-02f, 1.61761064e-02f, 7.44697750e-02f, 1.10646620e-01f, 8.79850686e-02f, -8.17565173e-02f, 3.76223959e-02f,
  -3.76709849e-02f, 2.38424707e-02f, 6.20701276e-02f, 1.92386808e-03f, 5.05479947e-02f, 3.91047373e-02f, 3.73814516e-02f, 1.26154325e-03f, 7.22729275e-03f, 1.69951208e-02f,
  1.12894282e-01f, -1.28835917e-01f, 1.12466559e-01f, 3.30865160e-02f, 6.80107176e-02f, 8.69757086e-02f, 5.06050736e-02f, -5.30873239e-02f, -1.79024950e-01f, -9.38891619e-02f,
  -3.21318544e-02f, -4.83359024e-02f, 1.30280014e-02f, -3.03721018e-02f, 6.84558824e-02f, 9.67178680e-03f, -4.93486114e-02f, 2.38684975e-02f, 1.20533491e-02f, 1.88068375e-02f,
  -5.49714826e-02f, 3.74985561e-02f, 8.56823474e-02f, -1.34465903e-01f, -1.11259182e-03f, -1.02664694e-01f, -5.68133146e-02f, 8.35317448e-02f, 2.78115813e-02f, 5.32389712e-03f,
  1.32382885e-01f, 4.04169895e-02f, -5.06705530e-02f, 9.18830037e-02f, -6.37968406e-02f, -1.78804602e-02f, -3.63937914e-02f, 2.20345277e-02f, 9.55174118e-03f, -1.42617216e-02f,
  4.37184460e-02f, 3.52808041e-03f, 6.15826622e-02f, -4.74578254e-02f, -6.55415952e-02f, -4.31370586e-02f, 6.65753558e-02f, 7.12216124e-02f, -8.22546799e-03f, 5.84715642e-02f,
  -2.26460192e-02f, 7.14793578e-02f, -2.43850332e-02f, -1.52310301e-02f, -1.37365088e-02f, -1.06130138e-01f, 4.93047684e-02f, 3.81878838e-02f, 6.05745912e-02f, -6.77824616e-02f,
  1.91247314e-02f, 4.55347076e-02f, -8.50601569e-02f, 6.59000501e-02f, 7.91273639e-02f, 2.11535115e-02f, 1.32654235e-02f, -6.87871687e-03f, -1.63896997e-02f, -1.01563670e-02f,
  -3.13742645e-02f, 2.09402554e-02f, 3.26438732e-02f, 1.32820681e-02f, -5.38989939e-02f, 3.42788883e-02f, 7.00164363e-02f, -2.81937085e-02f, -1.02231041e-01f, 2.40712473e-03f,
  -7.21457377e-02f, 5.05604446e-02f, 2.60912348e-02f, -3.33436616e-02f, -6.69900104e-02f, 5.42005189e-02f, -5.75057417e-02f, -4.25673164e-02f, -4.53399941e-02f, 6.06606081e-02f,
  -8.29623416e-02f, -5.05045876e-02f, 1.86766796e-02f, -1.02403313e-02f, -1.14862472e-02f, 3.09043955e-02f, 6.23423345e-02f, -1.96999926e-02f, -8.41528773e-02f, 2.08508149e-02f,
  -6.31652623e-02f, 5.90904877e-02f, 4.81848642e-02f, -7.46198818e-02f, -2.88620945e-02f, -1.09463120e-02f, -8.82534459e-02f, 5.36408722e-02f, -2.92293094e-02f, 3.47455516e-02f,
  -4.33699861e-02f, -5.05563579e-02f, 4.75678854e-02f, -5.20794615e-02f, -3.79042700e-02f, -2.84980889e-02f, 1.53984874e-02f, 2.50605773e-02f, -9.77050141e-02f, 5.53458482e-02f,
  -1.31777003e-01f, 1.74501836e-02f, 1.42446402e-02f, -8.17144439e-02f, -1.07557304e-01f, 7.26070330e-02f, 1.63795710e-01f, -4.43900675e-02f, -7.27214515e-02f, 1.37714684e-01f,
  2.04679910e-02f, -4.85197082e-02f, 1.40977055e-01f, 5.62866218e-02f, -8.19700062e-02f, 9.93722603e-02f, 1.04955763e-01f, 6.98706284e-02f, 7.83488527e-02f, 6.40223399e-02f,
  5.28053939e-02f, 1.45348255e-02f, 4.16156538e-02f, 1.13239311e-01f, -3.12065184e-02f, 1.35586299e-02f, -2.09486932e-02f, -1.01531893e-02f, -8.95894244e-02f, -1.03513002e-01f,
  -9.94988531e-02f, -4.18605767e-02f, -1.26788579e-02f, -1.01145498e-01f, -4.46323268e-02f, 1.68760400e-02f, -9.14432630e-02f, 5.86933456e-02f, 4.62312661e-02f, 6.96871709e-03f,
  1.76043473e-02f, -5.76634854e-02f, -1.07146375e-01f, -7.07006156e-02f, -7.19584972e-02f, 4.75388952e-02f, 2.91536865e-03f, 5.37902266e-02f, 8.96907300e-02f, 6.52043149e-02f,
  3.32795419e-02f, -2.35135630e-02f, -8.32677186e-02f, 8.83166790e-02f, -1.88901294e-02f, 7.06979409e-02f, -9.28133540e-03f, -6.07692041e-02f, -4.85775135e-02f, -8.57738778e-02f,
  -4.63050008e-02f, -6.03107922e-02f, 5.58048114e-02f, 7.92317018e-02f, 5.87123521e-02f, -3.66617925e-02f, -6.38998449e-02f, -1.06704906e-01f, -6.41815513e-02f, 2.33616717e-02f,
  -3.00665922e-03f, 1.35876732e-02f, -6.03861846e-02f, -2.69937329e-02f, 3.27549167e-02f, -7.99746886e-02f, 5.61323166e-02f, 4.59820107e-02f, -6.87583089e-02f, 1.44535815e-02f,
  -8.79243773e-04f, -7.66949281e-02f, -5.03468215e-02f, 2.70357560e-02f, 2.91775744e-02f, -3.77237983e-02f, -3.74340974e-02f, 7.78368190e-02f, 4.59252112e-02f, 7.24826828e-02f,
  -1.19232625e-01f, -6.33470863e-02f, 7.38835707e-03f, 1.24232890e-02f, -4.54012379e-02f, -5.79463094e-02f, 4.61661853e-02f, 3.29474695e-02f, -8.70389864e-02f, -1.45969400e-02f,
  -1.04007937e-01f, -4.54254039e-02f, -1.73282120e-02f, 8.26686621e-03f, -2.94698179e-02f, 3.25778499e-02f, -2.86158994e-02f, -1.37934163e-02f, 8.40372220e-02f, -9.83559936e-02f,
  -7.20380917e-02f, 2.71374788e-02f, 7.95614868e-02f, -1.23733710e-02f, -3.00417524e-02f, -5.60974665e-02f, -1.12007685e-01f, -1.62025113e-02f, -4.79585864e-02f, -9.31085646e-02f,
  -8.90227705e-02f, 1.25406995e-01f, -1.36071533e-01f, -1.60412088e-01f, 2.11839546e-02f, -1.87681839e-01f, -2.02742636e-01f, -9.36248079e-02f, -8.16232059e-03f, -1.63138270e-01f,
  -1.67841628e-01f, 5.96912466e-02f, 7.37352744e-02f, -1.40148252e-01f, 7.17225298e-02f, 1.67953223e-01f, -2.54070133e-01f, -1.85246795e-01f, 1.17251739e-01f, -1.61996201e-01f,
  1.71618462e-02f, 1.90099096e-03f, -7.07704648e-02f, 4.41611791e-03f, -1.14836968e-01f, -3.71397026e-02f, 4.87638377e-02f, -3.74001302e-02f, -1.03377625e-01f, -3.98159660e-02f,
  -9.62434933e-02f, -1.12678468e-01f, -1.52558880e-02f, -3.99004854e-02f, -1.70018926e-01f, 2.67049689e-02f, 2.60616317e-02f, 5.47284521e-02f, -5.31082712e-02f, 2.66463626e-02f,
  3.58970053e-02f, -3.52535620e-02f, -4.13103625e-02f, 7.33780861e-02f, -5.23324162e-02f, -3.60689983e-02f, -4.63847443e-02f, 8.52800161e-03f, 4.21501249e-02f, 5.60464757e-03f,
  -1.20649384e-02f, 5.02573140e-02f, -1.03872567e-02f, -4.26498502e-02f, 4.44998965e-03f, 1.84452944e-02f, 1.37331700e-02f, 5.71468063e-02f, -5.26055172e-02f, 5.31316251e-02f,
  5.77491932e-02f, 1.88234560e-02f, -5.59804067e-02f, 7.70105943e-02f, -9.21750441e-02f, -4.38657962e-02f, -5.64287491e-02f, 1.12575153e-02f, -4.38035540e-02f, -1.47219123e-02f,
  4.36527580e-02f, 2.96222251e-02f, 2.18792148e-02f, 6.94813952e-02f, 2.74947863e-02f, 3.94703671e-02f, 5.45644276e-02f, 1.21303741e-03f, 2.23708600e-02f, 1.60730071e-03f,
  -4.50533144e-02f, -2.17250530e-02f, 6.59331530e-02f, 2.47271918e-02f, -7.54395202e-02f, 1.14327874e-02f, -5.89854121e-02f, -1.06792077e-02f, 8.11471324e-03f, 1.55465532e-04f,
  -1.36575535e-01f, -1.80377916e-01f, 4.07413058e-02f, -5.66546544e-02f, -1.36605336e-03f, -1.50629934e-02f, -3.20982672e-02f, -4.47969362e-02f, -1.15340412e-01f, -1.00297414e-01f,
  -1.23896733e-01f, 3.29898037e-02f, 3.99942957e-02f, -6.97509497e-02f, 8.00458565e-02f, -4.24730070e-02f, -5.08962385e-02f, 3.93030643e-02f, -6.98752329e-02f, 8.92824978e-02f,
  -4.48528454e-02f, -3.29273045e-02f, -4.98102233e-02f, -4.49754521e-02f, 1.54653322e-02f, -1.52883958e-02f, -5.34328371e-02f, 4.00835946e-02f, 5.63209597e-03f, -3.67982723e-02f,
  -4.34619077e-02f, -1.34755835e-01f, -1.91134170e-01f, -2.41253804e-02f, 2.20215190e-02f, 2.51056068e-02f, -1.22397818e-01f, 3.11622340e-02f, -2.16173470e-01f, 9.91243497e-02f,
  1.44966301e-02f, -6.12558909e-02f, -1.13214947e-01f, -5.72473295e-02f, 2.35607643e-02f, -1.76922068e-01f, 9.14497301e-02f, 1.24050140e-01f, -1.21642344e-01f, 8.06256831e-02f,
  1.88681763e-02f, 1.26742914e-01f, -2.62128450e-02f, 1.46797687e-01f, 8.83808881e-02f, 3.26558389e-02f, 1.53126478e-01f, -5.95537275e-02f, 2.10359633e-01f, 1.37791976e-01f,
  -8.84368196e-02f, 2.17190962e-02f, 2.31192820e-02f, -6.87818825e-02f, -2.51748096e-02f, -1.48354471e-02f, 1.00364909e-01f, 1.72387660e-02f, 8.82751774e-03f, -4.41146605e-02f,
  -4.75057438e-02f, 4.68690656e-02f, 5.19718267e-02f, -5.01193590e-02f, -9.97787714e-03f, -6.01380244e-02f, -6.74950257e-02f, 8.25575739e-03f, -4.08097506e-02f, 2.84422375e-02f,
  -5.99903688e-02f, 3.94127816e-02f, 1.65188778e-02f, -5.53554334e-02f, -1.13064190e-03f, 8.83541442e-03f, -1.74407996e-02f, -6.29008412e-02f, -5.91639839e-02f, -3.11837503e-04f,
  3.25078368e-02f, -4.90051927e-03f, -6.68506771e-02f, -4.77565266e-02f, -3.50388810e-02f, -1.95520706e-02f, -4.75531742e-02f, -5.99284191e-03f, -7.37604499e-02f, 1.38327095e-03f,
  3.05910353e-02f, -1.06085632e-02f, -1.16842324e-02f, 3.48495618e-02f, 4.29861471e-02f, 8.74117389e-03f, -9.09574255e-02f, 3.56031321e-02f, 4.12164479e-02f, -2.20931415e-02f,
  -2.29553692e-03f, -1.55611299e-02f, 7.24679930e-03f, -4.71180007e-02f, 7.45115355e-02f, 2.01691296e-02f, 3.28414747e-03f, -5.58948070e-02f, -7.64113814e-02f, -3.05095315e-02f,
  7.10798129e-02f, 7.44092911e-02f, -3.89176197e-02f, 8.79838988e-02f, -4.21790108e-02f, -5.30338176e-02f, 1.58650689e-02f, 9.41812173e-02f, 6.50521889e-02f, 6.10371819e-03f,
  -4.54014866e-03f, -6.98948838e-03f, -1.97034720e-02f, -8.48718882e-02f, 6.61273226e-02f, 7.82953650e-02f, 5.20726293e-02f, -1.30658951e-02f, -3.44945560e-03f, 1.98608749e-02f,
  -1.17359348e-02f, -9.32430327e-02f, 2.18576100e-02f, -6.53599529e-03f, 1.64971873e-02f, -6.57071322e-02f, 1.11359712e-02f, 1.17172338e-02f, -1.33723607e-02f, -1.28410673e-02f,
  2.78359745e-02f, 1.87518269e-01f, -8.65960028e-03f, 1.81323037e-01f, -1.05780043e-01f, -5.98574989e-02f, 3.15820388e-02f, 6.78891987e-02f, 1.69775844e-01f, 1.16641872e-01f,
  5.08119501e-02f, 8.73166993e-02f, 6.08174503e-02f, 2.26064578e-01f, 1.79153681e-01f, 1.31159216e-01f, 1.25268906e-01f, 2.23770700e-02f, 1.03223346e-01f, 1.49704799e-01f,
  8.09835345e-02f, 2.02103883e-01f, -5.03454134e-02f, -1.43711152e-03f, 9.93275791e-02f, -1.07267536e-01f, 2.18340438e-02f, -1.33579090e-01f, 4.30784225e-02f, -5.28348424e-03f,
  5.41506521e-02f, -2.03798320e-02f, -1.07295997e-02f, 4.56908904e-03f, 7.84201622e-02f, -6.27589449e-02f, 7.99326692e-03f, -8.68585184e-02f, -6.37524799e-02f, 6.58225417e-02f,
  -7.93322846e-02f, -6.65164441e-02f, -4.53441776e-02f, -1.78459454e-02f, 7.50469640e-02f, 1.03891250e-02f, 4.12798114e-02f, 1.25833252e-03f, -2.91921496e-02f, -4.44133058e-02f,
  8.04844126e-02f, -5.62065803e-02f, -2.03098450e-02f, 6.39467686e-02f, -6.77267462e-02f, 5.21862246e-02f, 2.62570493e-02f, 3.65457349e-02f, 3.11131775e-03f, 1.14195861e-01f,
  6.93711191e-02f, 4.14448418e-02f, 7.31213987e-02f, -3.59089971e-02f, 2.12404914e-02f, -4.04146165e-02f, 3.47219780e-02f, 6.56348020e-02f, 2.96952203e-02f, 8.92348737e-02f,
  -4.32793871e-02f, -5.65184914e-02f, 9.17144194e-02f, -8.74268648e-04f, 7.70840719e-02f, -5.52859018e-03f, 2.37791240e-02f, 7.25299418e-02f, -6.86969906e-02f, -4.11560386e-02f,
  -6.37442842e-02f, 4.53657918e-02f, 1.03816418e-02f, -3.89303192e-02f, -7.20897540e-02f, -7.49607459e-02f, 7.34782815e-02f, 6.02673851e-02f, 5.63799702e-02f, -6.88546384e-03f,
  1.07420571e-01f, 2.41295561e-01f, 3.04754786e-02f, -7.00941607e-02f, -1.30457496e-02f, -3.57261882e-03f, 6.74522519e-02f, 2.62271371e-02f, -4.69636964e-03f, -3.54669020e-02f,
  5.10449782e-02f, -3.38713289e-03f, -4.41871583e-02f, -3.41763832e-02f, 7.23604113e-02f, 4.16473225e-02f, 8.56214985e-02f, 4.94229421e-02f, 1.09409183e-01f, -3.14564332e-02f,
  -7.68893063e-02f, 9.83201116e-02f, 1.81877110e-02f, -5.35373278e-02f, 1.31476596e-02f, -3.33198644e-02f, 1.05278119e-02f, 2.45405640e-02f, -7.59523828e-03f, 6.54252619e-02f,
  1.49169132e-01f, -5.78624383e-02f, -2.70434599e-02f, -8.05531070e-02f, 5.59286363e-02f, -8.45706090e-03f, 2.40581036e-02f, -5.84343411e-02f, 8.12521875e-02f, -1.41461730e-01f,
  1.11792563e-03f, 8.25567171e-03f, -4.53182776e-03f, -1.43934190e-01f, 1.15776554e-01f, 9.36689042e-03f, 4.15191576e-02f, -8.11721087e-02f, 2.70680990e-02f, -7.05148205e-02f,
  3.33288275e-02f, -4.06700186e-02f, -1.33062899e-01f, -1.35797739e-01f, -1.38011947e-01f, -3.55461016e-02f, -1.43302396e-01f, -1.15631208e-01f, -7.35592544e-02f, -1.59027457e-01f,
  -2.88507920e-02f, 3.24144140e-02f, -5.16653210e-02f, 4.90789395e-03f, -4.90177125e-02f, -5.65650202e-02f, -4.44395468e-02f, -5.72733115e-04f, 7.81845599e-02f, 9.96180102e-02f,
  -4.68321927e-02f, -6.03335984e-02f, -3.61804105e-02f, 5.83077520e-02f, 2.84132995e-02f, 7.43995653e-03f, 2.34358329e-02f, 2.05437597e-02f, -9.23996344e-02f, -2.89913937e-02f,
  -1.59192760e-03f, 2.94321869e-02f, 9.03459862e-02f, -6.22152202e-02f, 4.27815467e-02f, 5.78596741e-02f, 3.42862830e-02f, 4.36961502e-02f, 7.85109773e-03f, -2.22952124e-02f,
  -4.70586494e-02f, 7.16386959e-02f, -6.24268875e-03f, 3.36971320e-02f, -5.02112508e-02f, -2.23055761e-02f, -5.38551807e-03f, 9.06177908e-02f, 1.96946785e-02f, 7.23972693e-02f,
  -5.90780117e-02f, 5.62586077e-02f, 7.85323083e-02f, -2.02426128e-02f, 5.89590073e-02f, 3.97277884e-02f, 7.94162452e-02f, 8.74404237e-02f, 3.11495084e-02f, -9.91110280e-02f,
  7.57753327e-02f, -5.59392795e-02f, -3.40209231e-02f, -6.31652325e-02f, 3.55990529e-02f, 5.48062362e-02f, 2.46168599e-02f, 6.45278208e-03f, -1.26235466e-02f, 3.95910591e-02f,
  6.75913766e-02f, -7.95244128e-02f, -1.00171581e-01f, 3.87123078e-02f, -8.93063769e-02f, 1.68417636e-02f, -2.34652665e-02f, 8.27844068e-02f, 2.00140644e-02f, 3.57887000e-02f,
  -4.13044803e-02f, -1.17485262e-02f, -1.20774042e-02f, -2.96010356e-02f, -9.06939209e-02f, 8.35762769e-02f, 1.88702263e-03f, -5.27253933e-02f, -9.91399437e-02f, -2.40184795e-02f,
  6.79604784e-02f, 4.26771343e-02f, 3.58250774e-02f, -2.17737649e-02f, -5.36417356e-03f, -2.39965133e-02f, -6.97226077e-02f, -1.03432899e-02f, 7.32748434e-02f, -6.17586821e-02f,
  1.26885355e-01f, -1.82726979e-01f, -1.95016786e-02f, 9.95160565e-02f, -3.71427333e-04f, -1.23187423e-01f, -1.47126922e-02f, 1.42416609e-02f, -2.09667720e-02f, -5.17256707e-02f,
  -1.33945616e-02f, 3.59135456e-02f, -4.10512984e-02f, 5.76311611e-02f, 1.26356319e-01f, 4.36764546e-02f, -9.63361282e-03f, 6.36122152e-02f, -6.25351667e-02f, -1.76700912e-02f,
  -2.10812874e-02f, 7.81376734e-02f, 4.27069403e-02f, 4.87295017e-02f, 8.68385360e-02f, 2.01121382e-02f, 1.25430763e-01f, 3.45314220e-02f, 4.21585282e-03f, 1.15260072e-01f,
  4.81380522e-02f, -8.04847851e-02f, 1.66597068e-02f, -4.91234548e-02f, 4.26580235e-02f, -5.73177747e-02f, -8.37674662e-02f, 2.29201689e-02f, 7.32795969e-02f, 2.28353310e-03f,
  -9.21934471e-02f, 8.93133283e-02f, -6.12050034e-02f, -8.04501921e-02f, 5.66638783e-02f, 4.80704457e-02f, -1.93158630e-02f, -3.22782136e-02f, -1.49548119e-02f, 6.29507452e-02f,
  -8.06447640e-02f, 7.31351227e-03f, 2.87080146e-02f, -6.56460598e-02f, -3.37485671e-02f, -6.66771606e-02f, -8.18568170e-02f, -9.37331691e-02f, 9.20190215e-02f, 5.56155741e-02f,
  7.22416416e-02f, 7.58627057e-02f, 1.90846212e-02f, 8.25566426e-02f, 9.85343102e-03f, -6.14808239e-02f, 1.33847902e-02f, -5.65011725e-02f, -4.44895625e-02f, -6.90827286e-03f,
  6.75360262e-02f, -5.32542840e-02f, 7.91793913e-02f, 3.14785503e-02f, -9.63445008e-02f, -4.19266298e-02f, 3.23048420e-02f, -8.25778022e-03f, -2.34468803e-02f, 4.13718671e-02f,
  9.56218094e-02f, 7.01276287e-02f, -6.11154735e-02f, 5.71009889e-02f, -4.56574485e-02f, -6.03406504e-02f, 5.20070828e-02f, 6.56320155e-02f, -8.35614353e-02f, 3.24238911e-02f,
  -1.56295821e-02f, -9.16813686e-02f, 4.36379667e-03f, 4.34833169e-02f, -8.92700776e-02f, 4.25360948e-02f, -3.18770036e-02f, -4.94311750e-02f, 1.01617023e-01f, -4.66955639e-02f,
  -8.43331739e-02f, -7.03823045e-02f, 3.21893096e-02f, -6.32828847e-02f, 2.32440270e-02f, 7.57732941e-03f, 2.83538438e-02f, 6.19732402e-02f, -2.30255965e-02f, 1.88785531e-02f,
  -7.07726553e-02f, 2.48397086e-02f, 7.58564770e-02f, -7.55260810e-02f, -9.10964087e-02f, -8.66432488e-02f, -4.72147316e-02f, -5.13551086e-02f, 4.22333889e-02f, 8.68255049e-02f,
  9.88394115e-03f, -5.78141399e-02f, -2.01797113e-01f, 2.72929650e-02f, 5.93078621e-02f, 7.65255988e-02f, -6.06098846e-02f, 3.32014039e-02f, -7.36365765e-02f, 2.82205101e-02f,
  1.28931999e-01f, -2.02867221e-02f, -1.06658585e-01f, 9.46719870e-02f, 7.93494508e-02f, -1.18908964e-01f, 1.74773589e-01f, 3.60666402e-02f, -1.09421931e-01f, 9.43690166e-03f,
  5.83693050e-02f, 1.56196430e-01f, 4.46514785e-02f, 1.79257989e-01f, -1.91839244e-02f, -1.89828482e-02f, 1.62880659e-01f, 1.63317174e-02f, 2.06921920e-01f, 1.03918456e-01f,
  -1.25021106e-02f, -5.36219738e-02f, 2.17126906e-02f, -4.07080837e-02f, 7.06605390e-02f, 4.15165350e-02f, 2.48068850e-02f, 2.99040526e-02f, -8.42306316e-02f, 1.72960050e-02f,
  8.36866628e-03f, 8.30944628e-03f, 1.50137087e-02f, 6.80800155e-02f, 6.72346950e-02f, -3.44580188e-02f, -6.63058832e-02f, -3.31198089e-02f, -6.94597363e-02f, -1.26055004e-02f,
  -5.45433089e-02f, 5.86481914e-02f, -5.13807684e-02f, -3.38367671e-02f, -8.48800093e-02f, 3.89662534e-02f, 2.55118087e-02f, 6.25041127e-02f, -1.97427738e-02f, -3.37071083e-02f,
  5.80721423e-02f, 7.27414212e-04f, 4.21328284e-02f, -9.63676795e-02f, 4.65394445e-02f, 4.53471330e-05f, 7.33049735e-02f, -5.28970966e-03f, 1.11339958e-02f, 8.66333172e-02f,
  4.65615317e-02f, -4.03351448e-02f, -5.31370454e-02f, 3.62455361e-02f, -2.21581897e-03f, 5.67044411e-03f, -3.02748347e-04f, 1.50918309e-02f, -8.23890492e-02f, -3.93101014e-03f,
  -1.57929119e-02f, -2.97608152e-02f, -2.67563183e-02f, 1.14861414e-01f, 3.92494053e-02f, 5.83183132e-02f, -2.98245046e-02f, -7.20356628e-02f, 4.74584177e-02f, -6.57130331e-02f,
  4.22316305e-02f, 7.09732547e-02f, -1.94261670e-02f, -4.33799550e-02f, 3.60964015e-02f, 8.73286873e-02f, -4.83168699e-02f, -1.44865755e-02f, 4.48218882e-02f, 2.02285927e-02f,
  3.46070752e-02f, 4.62453216e-02f, -3.93461064e-02f, 2.58367807e-02f, 9.80975106e-04f, -9.64955986e-03f, 1.07861552e-02f, 6.43213466e-02f, 1.00176819e-01f, 3.12583148e-02f,
  8.33291933e-02f, 1.16959326e-01f, -7.14841187e-02f, -4.71058488e-02f, 9.60580632e-02f, 5.48321307e-02f, 5.64615354e-02f, -7.11785676e-03f, -6.61806464e-02f, 6.61922339e-03f,
  1.28316298e-01f, 6.09780103e-02f, 1.12783588e-01f, 2.59518996e-02f, -2.66762404e-03f, -1.57963499e-01f, -2.72303615e-02f, -6.29041418e-02f, -5.96617488e-03f, 1.00704625e-01f,
  -4.27813902e-02f, 2.00324059e-01f, -8.14501494e-02f, -1.41579762e-01f, -2.80591875e-01f, -2.33471170e-01f, -2.57579647e-02f, -5.00696078e-02f, -6.23546913e-02f, 3.02297678e-02f,
  -1.37597457e-01f, -9.91373658e-02f, -1.63731620e-01f, -3.60609256e-02f, 7.72596002e-02f, 2.54577696e-01f, 1.03824921e-01f, 6.00674711e-02f, 4.10255976e-02f, -2.05457047e-01f,
  -7.89075568e-02f, -5.03157042e-02f, 1.00517236e-01f, -5.00527397e-03f, 2.26111338e-03f, 2.71044928e-03f, -6.58593047e-03f, -1.33451954e-01f, -7.40647782e-03f, 2.39345543e-02f,
  1.13809541e-01f, 5.66636436e-02f, -1.08053498e-01f, -1.32756727e-02f, 6.87315241e-02f, 1.00376047e-02f, 7.38003328e-02f, 3.48377526e-02f, 8.84876773e-02f, -8.15795083e-03f,
  8.29120055e-02f, -1.99050773e-02f, 7.51795620e-02f, 5.62490374e-02f, -6.00745901e-02f, 4.26823571e-02f, -4.84581068e-02f, 6.22174069e-02f, 1.14732467e-01f, -3.37208086e-03f,
  2.44319979e-02f, 3.16341743e-02f, -7.04082325e-02f, 1.30181666e-02f, -4.41722982e-02f, -5.34954257e-02f, -7.60647804e-02f, 6.70449063e-02f, -3.88518646e-02f, -2.66018081e-02f,
  -1.56501010e-02f, 1.26387160e-02f, -9.91036594e-02f, 1.15175307e-01f, 3.01274145e-03f, 9.23865214e-02f, 7.64574558e-02f, -3.74789760e-02f, 3.82840410e-02f, -7.05912784e-02f,
  4.38012742e-02f, -3.20903771e-02f, 5.76573461e-02f, -3.98864187e-02f, -1.09230146e-01f, -1.75485760e-02f, 2.36068834e-02f, 7.69244414e-03f, -1.60127170e-02f, 2.15774830e-02f,
  6.95334598e-02f, 1.59824684e-01f, -1.57687832e-02f, -4.20561694e-02f, 1.86527427e-02f, 5.31917401e-02f, -4.72232215e-02f, 4.65986133e-02f, -1.33716259e-02f, -7.14090541e-02f,
  9.30047855e-02f, 7.88413733e-02f, 2.30358690e-02f, -6.50830120e-02f, 5.57165174e-03f, 6.55204281e-02f, 2.62519121e-02f, -5.01251183e-02f, 2.61669755e-02f, -1.43109849e-02f,
  1.13086350e-01f, 8.85915607e-02f, -7.00417310e-02f, 3.99310775e-02f, -7.42485560e-03f, 6.83753416e-02f, -4.22607660e-02f, -6.29065856e-02f, 3.06276642e-02f, -3.53721948e-03f,
  -1.26881292e-02f, -9.47359502e-02f, -6.81372359e-02f, -1.05490334e-01f, 5.62988110e-02f, 6.23336174e-02f, -3.05623859e-02f, 8.50676373e-02f, -1.28997982e-01f, -6.23859130e-02f,
  8.80096667e-03f, -7.30206678e-03f, 1.12898024e-02f, -7.57763460e-02f, 3.80897615e-03f, -4.86580543e-02f, -1.38351724e-01f, -2.10202802e-02f, -9.02569108e-03f, -7.85733610e-02f,
  -3.96206453e-02f, -4.80888933e-02f, -1.31977856e-01f, 4.07866761e-02f, -7.88097456e-02f, -9.05778632e-03f, 6.03315756e-02f, -6.05462817e-04f, -3.07959076e-02f, -4.89734821e-02f,
  -7.95600563e-02f, -6.64509684e-02f, 4.44668299e-03f, 7.30436668e-02f, -6.57235831e-02f, 9.55382711e-04f, -7.46395066e-03f, -2.09720284e-02f, -4.59394380e-02f, 9.39480215e-02f,
  -7.18340501e-02f, 8.50445852e-02f, -7.73569420e-02f, 2.12098751e-02f, -1.06106475e-02f, -8.60310998e-03f, -1.58101227e-02f, -7.65992627e-02f, 3.28681432e-02f, 8.06111693e-02f,
  9.55067798e-02f, -8.53687301e-02f, -1.60845146e-02f, -5.09630740e-02f, 1.77999120e-02f, -3.62222083e-03f, -7.78967738e-02f, 4.72940877e-02f, -6.72180904e-03f, -8.55156705e-02f,
  -6.11428134e-02f, 2.45129075e-02f, 4.05406877e-02f, -8.45885873e-02f, -3.57849449e-02f, 1.94920041e-02f, -1.28701963e-02f, 4.29370999e-02f, 1.83914527e-02f, -2.32674927e-03f,
  -2.11356152e-02f, 1.46603473e-02f, 2.70925388e-02f, -3.48757915e-02f, 3.69794257e-02f, -6.05878755e-02f, 7.26596192e-02f, -6.14519566e-02f, 8.55052099e-03f, -2.83712391e-02f,
  -4.41699661e-02f, -8.71756971e-02f, -7.13557079e-02f, 6.99082986e-02f, 6.18318692e-02f, 1.61209572e-02f, -9.19221640e-02f, 4.88920175e-02f, 3.63472104e-02f, -4.16626930e-02f,
  6.10609315e-02f, -4.79914574e-03f, -4.91386801e-02f, 7.21476004e-02f, -5.34632020e-02f, 1.03814371e-01f, -4.94455360e-02f, -9.35888365e-02f, -7.26561844e-02f, 6.84341937e-02f,
  1.33677283e-02f, -6.92741945e-02f, -7.05436990e-02f, 3.88997681e-02f, 2.44168900e-02f, -8.96657407e-02f, -5.70531115e-02f, -3.65460031e-02f, 5.65608330e-02f, 4.20950726e-02f,
  -3.69506143e-03f, 5.91148771e-02f, 3.71537544e-03f, -5.36740907e-02f, -7.28472322e-02f, 7.15927109e-02f, -2.43519805e-02f, 7.96118006e-02f, 1.15602622e-02f, -2.11804025e-02f,
  -7.08742291e-02f, -8.55717361e-02f, -1.82229979e-03f, -3.68375704e-02f, -8.84379968e-02f, 1.11117028e-02f, 2.09977869e-02f, -5.94781190e-02f, -6.01646155e-02f, -3.66510376e-02f,
  2.01170705e-03f, -8.23010802e-02f, 1.39129117e-01f, 2.11765729e-02f, 1.43370479e-01f, 1.31865531e-01f, -3.23319621e-02f, -4.63572778e-02f, 3.21023576e-02f, -5.17256334e-02f,
  -2.70034261e-02f, -8.26972947e-02f, 7.46842101e-02f, -1.41447615e-02f, 6.18179403e-02f, 3.11711766e-02f, -2.61291917e-02f, 9.94841829e-02f, -1.07057475e-01f, 2.48890966e-02f,
  2.59828400e-02f, -1.39394030e-01f, 8.61040428e-02f, 2.69312710e-02f, 1.06412321e-02f, 4.43907268e-02f, 7.50314519e-02f, 7.48911202e-02f, -2.67188810e-02f, -6.28480241e-02f,
  -2.86740493e-02f, -3.79730165e-02f, -5.15822805e-02f, -7.29526877e-02f, -5.82172275e-02f, -5.13145700e-02f, -1.76530220e-02f, 1.93353798e-02f, 2.04289611e-02f, 6.98781237e-02f,
  9.07512382e-02f, -2.17256807e-02f, 7.87562653e-02f, 4.53642868e-02f, -6.33219481e-02f, -4.99372184e-02f, -4.70795482e-02f, 4.28327546e-03f, -6.02955967e-02f, 3.49196866e-02f,
  -2.49566305e-02f, 9.07864794e-02f, 1.62608922e-02f, -7.21927434e-02f, 7.01669091e-03f, 3.32012363e-02f, 4.51343469e-02f, 3.17302495e-02f, -9.28337276e-02f, 5.81482910e-02f,
  -9.73692909e-02f, -1.06199913e-01f, 5.71605973e-02f, 1.19008915e-02f, -4.05468279e-03f, 4.90653403e-02f, 6.60551712e-02f, 5.31167686e-02f, -8.27954635e-02f, -2.00580861e-02f,
  -2.03979295e-02f, 7.79014900e-02f, -4.14144658e-02f, 8.14704895e-02f, -3.45446691e-02f, 6.48994138e-03f, -7.08976910e-02f, -1.98842399e-02f, -1.29802311e-02f, -2.92532053e-02f,
  -8.76640826e-02f, -1.02226742e-01f, -1.84385832e-02f, 2.40785666e-02f, 2.76227761e-02f, -5.26387990e-02f, 4.03967872e-02f, 6.60740361e-02f, -1.10100314e-01f, -5.93160838e-02f,
  6.92363246e-04f, -5.72181121e-02f, -6.15749061e-02f, 2.75881309e-02f, 7.32089058e-02f, 5.45758456e-02f, -3.29207480e-02f, 7.61464378e-03f, 4.14890014e-02f, 5.12201292e-03f,
  9.85516235e-02f, 2.84381490e-03f, -7.53901824e-02f, 1.70203969e-02f, -5.75984195e-02f, 4.08341810e-02f, 6.26193136e-02f, 6.89299777e-02f, -6.13381751e-02f, 6.84671849e-02f,
  -1.97240822e-02f, -1.16288960e-01f, -1.13527298e-01f, -3.02158650e-02f, -1.88953474e-01f, -6.83184788e-02f, 6.95766509e-03f, -1.98389411e-01f, -2.26702824e-01f, -1.34333959e-02f,
  -1.13928542e-01f, -7.77731165e-02f, 1.89632237e-01f, -7.64132217e-02f, 1.42456606e-01f, 1.50846750e-01f, 2.91919746e-02f, -5.81201389e-02f, 1.01933435e-01f, -1.37865648e-01f,
  -3.68145183e-02f, -1.47399932e-01f, 1.24436066e-01f, -5.89093417e-02f, -3.04382518e-02f, -2.01086700e-01f, -4.48645763e-02f, -8.04019347e-03f, -4.31689732e-02f, -8.60294923e-02f,
  2.39473581e-02f, -1.56711474e-01f, -1.02661744e-01f, 1.36647625e-02f, -1.06880981e-02f, -3.63752134e-02f, 7.48069286e-02f, 2.68367827e-02f, -8.37251544e-02f, 3.65702473e-02f,
  5.65961823e-02f, 6.72738627e-02f, 1.92684040e-03f, 6.38723522e-02f, 6.77330345e-02f, -5.65560870e-02f, 1.02876015e-01f, 1.46606276e-02f, -4.98245545e-02f, -3.84977721e-02f,
  -1.94916520e-02f, 8.09026957e-02f, -8.73323157e-02f, -2.21117772e-03f, 4.60987054e-02f, -1.59795191e-02f, 1.35083096e-02f, -2.55598463e-02f, -5.37029356e-02f, -8.72749016e-02f,
  -4.33427393e-02f, 4.22203764e-02f, -2.10755263e-02f, -1.20726764e-01f, 2.27178484e-02f, -2.08933614e-02f, -6.04682229e-02f, -1.97693463e-02f, 2.20873114e-02f, 1.68746375e-02f,
  5.82058802e-02f, 1.45964902e-02f, -1.19661558e-02f, -4.06724773e-02f, -3.48151773e-02f, 3.14450227e-02f, -3.80736701e-02f, -5.50396889e-02f, 6.34389892e-02f, 5.68474689e-03f,
  6.24629743e-02f, -2.55878568e-02f, -3.19133587e-02f, -7.78038427e-02f, 2.80743907e-03f, 2.84293927e-02f, -4.83050272e-02f, 4.33313139e-02f, 3.83493677e-02f, 4.57737595e-02f,
  -1.47385061e-01f, -1.84885725e-01f, -2.64693759e-02f, 2.46226764e-03f, 3.01198140e-02f, -4.80570160e-02f, 4.09556646e-03f, 3.14169079e-02f, -1.09855020e-02f, -1.44565376e-02f,
  -8.69796574e-02f, -3.20666246e-02f, 5.22397272e-02f, -3.66124362e-02f, 9.54631623e-03f, -1.07485525e-01f, -3.22865602e-03f, -4.43271771e-02f, -1.04142047e-01f, -3.35081890e-02f,
  1.26912400e-01f, -1.25305289e-02f, 4.83708456e-03f, 4.67311740e-02f, -5.81770092e-02f, -3.34571935e-02f, 2.22364329e-02f, 1.89132839e-02f, -1.67249739e-02f, 3.60806435e-02f,
  7.24705309e-02f, -2.47085132e-02f, 9.46828257e-03f, 6.65815324e-02f, 6.77676201e-02f, -1.15599772e-02f, 9.55406353e-02f, 3.20892744e-02f, 1.00790076e-02f, 6.99862316e-02f,
  4.62834388e-02f, 5.71405739e-02f, -1.78353151e-03f, 8.00679345e-03f, -5.59625626e-02f, -5.60082542e-03f, 3.75042818e-02f, 5.40025160e-02f, -2.53053848e-02f, -7.10456297e-02f,
  -7.97205493e-02f, -5.67805320e-02f, -2.36139148e-02f, 4.44106795e-02f, 7.37446919e-02f, 5.22338413e-02f, -5.03739119e-02f, -5.73945418e-02f, 1.01511322e-01f, 8.23198110e-02f,
  3.06239445e-02f, -5.42719997e-02f, -7.91061819e-02f, -2.14279275e-02f, -1.55221752e-03f, 6.49796054e-02f, -4.57827188e-02f, 4.18357290e-02f, 9.48175788e-02f, -4.70985100e-02f,
  7.44558275e-02f, -6.05677105e-02f, 2.12834943e-02f, -3.43606807e-02f, -5.85415848e-02f, -1.23167050e-03f, -3.00411787e-02f, 3.56082842e-02f, -6.64578974e-02f, -5.41608185e-02f,
  -1.03545701e-02f, 5.73938247e-03f, 4.88456897e-03f, 8.60441029e-02f, 8.56290385e-02f, -4.82340381e-02f, 7.71670714e-02f, -2.39443090e-02f, -3.89682390e-02f, 8.87432173e-02f,
  -4.81429696e-02f, 7.48633221e-02f, -8.45105052e-02f, -8.59859735e-02f, -2.51846984e-02f, -8.34834427e-02f, 4.03936282e-02f, 3.18195880e-03f, -3.73086135e-04f, -7.90178180e-02f,
  7.35885352e-02f, 4.16826904e-02f, 3.59113924e-02f, 4.66783298e-03f, 1.43211696e-03f, 3.01835593e-04f, 3.04848086e-02f, 5.36763147e-02f, -2.60569286e-02f, 7.07748830e-02f,
  8.76915008e-02f, -7.86071494e-02f, -8.20730031e-02f, -1.83959175e-02f, 7.74827413e-03f, -1.48948422e-02f, 9.31999926e-03f, 5.20561524e-02f, 7.68799037e-02f, 7.36003667e-02f,
  -8.86705425e-03f, -4.29156423e-02f, 1.44566018e-02f, 7.21540451e-02f, 6.54017404e-02f, 3.01897191e-02f, -9.30485204e-02f, -5.38926907e-02f, -2.66098324e-03f, -3.89124416e-02f,
  6.03478998e-02f, 3.61315086e-02f, 7.02641904e-02f, 3.42187025e-02f, -8.25368911e-02f, -7.62680918e-02f, 7.32897744e-02f, 5.99007346e-02f, -4.82033379e-02f, 6.56638816e-02f,
  -9.30044893e-03f, -2.68620253e-02f, -7.68316910e-02f, 1.05428128e-02f, 9.72954929e-02f, -1.68020725e-02f, 9.38354135e-02f, 9.57906395e-02f, -4.72041592e-02f, 9.18236375e-02f,
  -3.56348045e-02f, 1.30672343e-02f, 8.68410915e-02f, 2.33370394e-01f, -1.36572391e-01f, -2.42843833e-02f, -1.06170215e-01f, 4.24838252e-02f, 2.22875863e-01f, -1.01524275e-02f,
  -4.09751199e-03f, 4.87274304e-03f, -2.41639987e-02f, 7.95876384e-02f, 5.22676818e-02f, 1.02899604e-01f, 1.20114923e-01f, 8.14927556e-03f, 1.19377665e-01f, 5.44021651e-02f,
  1.43179102e-02f, 8.29082802e-02f, 6.82907850e-02f, 3.20161916e-02f, -1.47061562e-03f, 8.58333781e-02f, 4.08774428e-02f, -6.26103058e-02f, -9.60967224e-03f, -1.04737684e-01f,
  -6.68451786e-02f, 7.62133300e-02f, -6.54810220e-02f, 4.40020785e-02f, 1.54266078e-02f, -1.03129610e-01f, -1.65733439e-03f, 8.81120749e-03f, 1.54919745e-02f, -3.49966660e-02f,
  -3.94621380e-02f, -6.78936690e-02f, 7.28461705e-03f, -3.58235613e-02f, 6.13837875e-02f, 2.89104264e-02f, 5.92674427e-02f, 8.86342302e-02f, 1.25470484e-04f, 6.98474869e-02f,
  3.58381569e-02f, 1.95026174e-02f, 1.25735030e-02f, 6.15021971e-04f, -3.21563855e-02f, 8.43163878e-02f, -2.27996670e-02f, 3.16373408e-02f, 8.70576724e-02f, 4.52472903e-02f,
  5.97549602e-02f, 5.32190874e-02f, -1.05988272e-02f, 1.75693352e-02f, 7.40082785e-02f, -2.70612519e-02f, 1.23394933e-02f, -1.84018537e-02f, 6.94433004e-02f, 5.36497533e-02f,
  8.98978338e-02f, 4.60869521e-02f, 3.72639485e-02f, 5.67433089e-02f, 6.02417104e-02f, -1.02339527e-02f, -8.78053159e-02f, 2.77253296e-02f, 6.35112030e-03f, -2.92358920e-02f,
  -1.88694317e-02f, -9.40997675e-02f, 9.17101726e-02f, -5.05684800e-02f, 3.76829579e-02f, -5.37321717e-02f, -2.71872915e-02f, 9.61077958e-03f, -4.67207804e-02f, 1.08525231e-02f,
  7.95897022e-02f, 2.42957771e-01f, -2.63909604e-02f, 4.52065170e-02f, 4.85909097e-02f, -4.69212085e-02f, 7.50524402e-02f, -4.56270389e-02f, 1.13459662e-01f, 9.39452946e-02f,
  -1.10949591e-01f, -4.92294841e-02f, -4.68322560e-02f, -8.29484612e-02f, -1.96808893e-02f, 7.99578801e-02f, 3.55454423e-02f, 8.18860158e-02f, -3.05181500e-02f, -7.55332112e-02f,
  5.96146472e-02f, -7.05022663e-02f, -2.26033535e-02f, 6.15694709e-02f, 6.74001947e-02f, 6.01157881e-02f, -3.88336740e-02f, 8.47514644e-02f, -6.01201281e-02f, -2.36195643e-02f,
  -9.82648134e-02f, 1.92886442e-01f, 7.10293949e-02f, -3.48877558e-03f, 1.81725547e-02f, -6.93449229e-02f, -9.39451754e-02f, -2.70020701e-02f, -4.30713221e-02f, 2.91202385e-02f,
  -1.15686208e-01f, 2.31352463e-01f, -1.64282005e-02f, -3.87383029e-02f, -2.29419723e-01f, -1.60313591e-01f, -1.60645798e-01f, -1.01517560e-02f, 8.99920836e-02f, -5.09779826e-02f,
  -1.88468471e-02f, -4.94796038e-02f, -1.03031233e-01f, 6.90227002e-02f, 3.32732424e-02f, 8.22991580e-02f, 1.32324938e-02f, 9.79403779e-03f, -1.03893122e-02f, -8.46023336e-02f,
  1.72515120e-02f, 3.86615992e-02f, 5.82672358e-02f, 1.64692923e-02f, -8.11269786e-03f, 2.02558544e-02f, 2.17448012e-03f, -3.12850885e-02f, -3.61767784e-02f, 6.48154840e-02f,
  7.38699213e-02f, 7.32995197e-02f, 5.56254759e-02f, -6.31888285e-02f, -2.49949768e-02f, 9.00126472e-02f, 1.21600851e-01f, -1.42505625e-04f, -3.04686017e-02f, 6.24248721e-02f,
  8.09980440e-04f, 3.92905064e-02f, 3.36195268e-02f, -8.40210840e-02f, 2.55735032e-02f, -3.47975735e-03f, 1.64275058e-02f, -3.51799019e-02f, 9.89274122e-03f, 1.32916979e-02f,
  5.82142100e-02f, -1.45480810e-02f, 3.98590649e-03f, 3.93418260e-02f, 7.26207867e-02f, -5.58790751e-02f, 7.57829398e-02f, -6.81994557e-02f, -2.36188266e-02f, -6.21036366e-02f,
  -1.20660812e-02f, 5.93907870e-02f, -2.37174332e-02f, 5.11067957e-02f, -5.10552302e-02f, 1.68768000e-02f, -5.71137369e-02f, -6.23881854e-02f, -2.90337820e-02f, 2.26356704e-02f,
  4.19348627e-02f, -4.19519171e-02f, -1.35826413e-02f, 2.47385390e-02f, -1.23764249e-02f, 5.34280837e-02f, 2.16138326e-02f, 6.01447262e-02f, 6.22411864e-03f, -6.98554143e-02f,
  -1.22044489e-01f, -9.64981467e-02f, -5.06301671e-02f, 3.81199829e-02f, -5.79291657e-02f, 2.71755457e-03f, 7.03081023e-03f, 6.30239397e-02f, -7.90156499e-02f, -8.67405236e-02f,
  -5.20020053e-02f, -5.45863844e-02f, -6.49997219e-02f, 7.89569616e-02f, -1.57879188e-03f, -1.24509118e-01f, 1.24093127e-02f, -1.07978135e-02f, 1.42094474e-02f, 9.05212238e-02f,
  1.39179215e-01f, 5.20604514e-02f, 9.32470988e-03f, -1.01042137e-01f, -8.77390150e-03f, -4.90950886e-04f, 4.65292111e-02f, 7.58342147e-02f, -7.38376528e-02f, -6.69226125e-02f,
  1.39953569e-01f, -1.68800309e-01f, 1.60090983e-01f, 2.35504732e-01f, 7.91599527e-02f, -1.81368247e-01f, -1.17720924e-01f, 9.85090807e-02f, 2.07365841e-01f, -1.36550382e-01f,
  3.04150339e-02f, -2.09238544e-01f, -5.30914553e-02f, -4.00998443e-02f, 1.03435144e-01f, -4.26554829e-02f, 3.83514278e-02f, -4.35015075e-02f, 1.38962716e-01f, 1.04565024e-01f,
  1.61869600e-01f, 1.31387264e-01f, 2.22310990e-01f, 1.22290835e-01f, 1.26839623e-01f, 1.81523949e-01f, 4.77660224e-02f, 1.83345843e-02f, 2.15058699e-02f, 2.14862619e-02f,
  3.04586366e-02f, -2.40876321e-02f, -1.41742527e-02f, -7.46827014e-03f, -2.66482625e-02f, -4.51326557e-03f, -5.90832457e-02f, 2.76518799e-02f, 2.35392358e-02f, 7.26025505e-03f,
  -5.43395579e-02f, -1.75395433e-03f, 3.26294191e-02f, 7.12833032e-02f, -7.82451704e-02f, 6.68436438e-02f, 1.15999363e-01f, -3.09966020e-02f, 1.67306680e-02f, 2.81626396e-02f,
  6.32935911e-02f, 2.22641192e-02f, 1.44101884e-02f, -5.44812344e-02f, 1.06801316e-02f, -2.03277394e-02f, 2.93761436e-02f, -6.92152092e-03f, -3.25787477e-02f, 2.35192757e-02f,
  -7.12037086e-02f, 6.35562977e-03f, -3.18812625e-03f, 4.04931558e-03f, -4.88420669e-03f, -1.42982916e-03f, -7.30823949e-02f, -3.81971709e-02f, -2.06284155e-03f, 1.58455856e-02f,
  -3.83679047e-02f, -3.19173634e-02f, 5.34410812e-02f, -4.37186174e-02f, -5.52380271e-02f, 5.45578301e-02f, 1.09146200e-02f, 4.72183898e-02f, -2.69343201e-02f, 4.01271470e-02f,
  3.93162444e-02f, 7.05944076e-02f, -7.90596008e-02f, 4.64812294e-02f, 7.75666675e-03f, -4.88090888e-02f, -3.76359932e-03f, -1.04302354e-02f, 5.11247888e-02f, -2.46245936e-02f,
  -1.93599135e-01f, -8.42796192e-02f, -4.38636988e-02f, -3.76385301e-02f, -3.81621867e-02f, -1.31662577e-01f, 4.72632088e-02f, -4.53276187e-02f, 1.75020221e-04f, 3.32790874e-02f,
  9.28478409e-03f, -1.96168590e-02f, -6.22449853e-02f, 6.05848506e-02f, 2.19829790e-02f, -5.90015873e-02f, 9.30904690e-03f, -8.66829418e-03f, 4.82075922e-02f, -5.40837683e-02f,
  -3.63091612e-03f, -1.12413004e-01f, -4.07154858e-02f, 1.22945406e-01f, 4.84933630e-02f, -7.64925405e-02f, 1.93183199e-02f, -2.50977743e-02f, 4.27786261e-02f, -3.90041880e-02f,
  -5.24732694e-02f, -1.78456381e-01f, -2.82295734e-01f, -7.08486810e-02f, 3.24672796e-02f, -2.19816580e-01f, -2.93226242e-01f, -5.97854406e-02f, -3.63550596e-02f, 1.37776136e-01f,
  8.07770491e-02f, -7.33919069e-02f, 8.72666165e-02f, -2.63199925e-01f, -1.73898220e-01f, -1.04466259e-01f, -3.29361349e-01f, -1.18874304e-01f, -9.83953010e-03f, -1.03390120e-01f,
  -8.20143595e-02f, -1.83207691e-01f, -2.09049597e-01f, 4.70009372e-02f, -1.52145505e-01f, -1.67833199e-03f, 7.74715096e-02f, 6.96398690e-02f, -1.60967380e-01f, -6.73755407e-02f,
  -1.32159591e-01f, 9.41400677e-02f, -5.08318171e-02f, -5.85941924e-03f, -5.93352318e-02f, -6.98006451e-02f, -1.59262605e-02f, -1.44721689e-02f, 7.50618875e-02f, -7.58844465e-02f,
  2.69072521e-02f, -2.68157367e-02f, -1.26778474e-02f, 4.34692986e-02f, 5.35808466e-02f, 4.22045924e-02f, 8.33475124e-03f, 5.71000874e-02f, -1.52731605e-03f, -6.18498214e-02f,
  -3.52447876e-03f, -8.64763930e-02f, -2.47747377e-02f, -1.90786889e-03f, -4.83932793e-02f, -5.50564788e-02f, -2.32847352e-02f, 1.57715492e-02f, -3.99832763e-02f, 2.83182655e-02f,
  8.90127420e-02f, 5.03479876e-02f, 3.51933353e-02f, -2.92071560e-03f, -2.01975256e-02f, 4.36320044e-02f, -3.00970841e-02f, 3.73063609e-02f, 1.19825704e-02f, 3.62977087e-02f,
  4.58832420e-02f, 4.33291979e-02f, -1.16980895e-02f, -5.98539822e-02f, 3.77837047e-02f, 1.28799444e-02f, 4.21409830e-02f, -6.18291507e-03f, -3.81196253e-02f, -1.18748145e-02f,
  -1.78638883e-02f, -1.87803470e-02f, 7.84871504e-02f, 1.88996475e-02f, -1.95914339e-02f, -1.82723086e-02f, -3.56829576e-02f, 1.74713414e-02f, 2.79564261e-02f, -3.75656411e-02f,
  -1.02581317e-02f, -1.06704580e-02f, 2.47570756e-03f, 6.72281906e-02f, 6.36649281e-02f, -3.60120125e-02f, -2.73554046e-02f, -6.55391393e-03f, -4.02200036e-02f, -3.97037789e-02f,
  -6.86581989e-05f, -1.19967684e-02f, 4.44266759e-02f, -2.94484344e-04f, -3.81291062e-02f, -2.96883117e-02f, -5.84240491e-03f, 6.17359346e-03f, -7.63985068e-02f, -5.95381260e-02f,
  1.11549683e-02f, 4.40966375e-02f, 8.36182013e-02f, 3.91284861e-02f, 3.53291184e-02f, 4.95742299e-02f, 2.12451834e-02f, -5.23204729e-02f, -3.77588384e-02f, -3.62522751e-02f,
  -1.79196987e-02f, 3.49431485e-02f, 7.88090155e-02f, -4.28142138e-02f, 1.19477719e-01f, 8.01676437e-02f, 7.95958564e-02f, 1.09937318e-01f, 5.03483340e-02f, 4.46866043e-02f,
  1.00279218e-02f, 3.58782820e-02f, 5.54133989e-02f, -3.49377058e-02f, 5.56664802e-02f, -1.21198604e-02f, -2.27771495e-02f, 6.55448362e-02f, 7.42209256e-02f, 8.41617882e-02f,
  8.49946439e-02f, -9.97482613e-03f, 7.86974207e-02f, -5.74336015e-02f, 7.58041888e-02f, -3.04928441e-02f, 6.00350499e-02f, -9.26372185e-02f, -7.32162818e-02f, 1.53971994e-02f,
  -1.98813602e-02f, 5.92667386e-02f, -3.70824859e-02f, -1.11227706e-02f, 1.71327665e-02f, -7.42187500e-02f, -1.29937408e-02f, -1.93791278e-02f, -9.28433016e-02f, 1.05205411e-02f,
  1.44376667e-04f, -1.99020356e-02f, 1.17101893e-02f, 2.24742014e-02f, -2.64030099e-02f, 9.20489579e-02f, 8.71375501e-02f, -8.17534253e-02f, 3.83882560e-02f, 5.13687683e-03f,
  7.49290809e-02f, 8.56927633e-02f, -7.38831889e-03f, 5.27997836e-02f, -8.36182311e-02f, 1.87085159e-02f, -7.96516985e-02f, 3.58130634e-02f, 3.32273636e-03f, -5.53606600e-02f,
  -1.11365393e-01f, -7.75497109e-02f, 7.42477775e-02f, 1.79713964e-02f, 9.94530991e-02f, 3.09555000e-03f, 7.72327930e-02f, -5.92723489e-02f, -2.77448855e-02f, 1.83104966e-02f,
  8.60890374e-02f, 5.73501401e-02f, -3.37822475e-02f, -4.14521545e-02f, -4.09447439e-02f, -4.96599264e-03f, -4.85349409e-02f, -4.09543223e-04f, -7.40837157e-02f, 6.45712763e-02f,
  8.09015855e-02f, 4.68377732e-02f, -5.22089452e-02f, 7.28538409e-02f, 6.70172647e-02f, -5.72835235e-03f, 2.24396233e-02f, 5.34212217e-02f, 3.93180884e-02f, -6.00856692e-02f,
  3.76397632e-02f, -3.61827686e-02f, 3.63328941e-02f, -4.90351766e-02f, -1.93294287e-02f, -9.23328847e-03f, -1.26857208e-02f, 1.01604573e-01f, 7.82878175e-02f, -6.09123297e-02f,
  -5.05466126e-02f, -4.15165015e-02f, 8.34015086e-02f, -1.44099779e-02f, 1.89960729e-02f, 2.40419898e-02f, 2.76083853e-02f, -6.13111407e-02f, 4.92965356e-02f, 4.59810831e-02f,
  -6.37287796e-02f, -1.11986278e-02f, -6.98074251e-02f, -8.45031068e-02f, 3.63074094e-02f, 3.50656547e-02f, 5.58048077e-02f, 1.83119755e-02f, 9.66116562e-02f, 3.21697704e-02f,
  1.07334301e-01f, -2.79006660e-02f, 1.10321403e-01f, 1.70007825e-01f, 8.28777999e-02f, 7.61046335e-02f, 1.45666134e-02f, 1.62365943e-01f, 2.45574281e-01f, -9.75296274e-02f,
  -1.48119166e-01f, 7.62765259e-02f, 2.30366550e-02f, -1.56003889e-02f, 3.50918397e-02f, -6.90103248e-02f, -1.02211989e-01f, 1.93477273e-02f, 7.50600547e-02f, -1.86916646e-02f,
  1.02258235e-01f, -1.68121159e-01f, -6.35607541e-02f, -6.48697764e-02f, -3.02617159e-02f, -6.16445802e-02f, -5.00039272e-02f, -3.34862024e-02f, -1.21440075e-01f, -4.45555151e-02f,
  1.10866334e-02f, 2.63986178e-03f, 2.41361596e-02f, -3.51492912e-02f, -3.47666675e-03f, -1.81653649e-02f, -7.61517882e-02f, -3.26381507e-03f, 7.67766461e-02f, -6.76284209e-02f,
  7.59441331e-02f, 8.71948674e-02f, 6.95036575e-02f, 3.11338380e-02f, 3.52057964e-02f, -7.87226111e-02f, -6.97873533e-02f, 1.27175720e-02f, 6.99339062e-02f, 1.90076772e-02f,
  9.00263190e-02f, -3.99175920e-02f, -2.04011127e-02f, -9.61619467e-02f, 7.37184733e-02f, -4.59767208e-02f, -2.14792881e-02f, 1.31625980e-02f, 5.06817661e-02f, 3.15877050e-02f,
  5.75988665e-02f, 8.35933387e-02f, -2.87981704e-02f, 7.12185958e-03f, 3.09184100e-02f, 1.56262107e-02f, 3.57973315e-02f, 5.12868688e-02f, 2.86195911e-02f, 3.10635287e-02f,
  1.84403416e-02f, -3.45261469e-02f, 1.48133906e-02f, 2.92717101e-04f, 8.17142949e-02f, -2.27527861e-02f, -5.30227982e-02f, 4.51228991e-02f, 1.11919288e-02f, 5.95311485e-02f,
  -8.23480170e-03f, -4.01305817e-02f, 5.74687719e-02f, 6.91380277e-02f, -2.79210862e-02f, -8.89823288e-02f, -1.56667996e-02f, 7.59193823e-02f, -4.65487391e-02f, 4.15786728e-02f,
  -1.01441413e-01f, -5.48163317e-02f, 1.60655752e-02f, -2.41263714e-02f, -9.89909917e-02f, -7.54418224e-03f, -5.14906459e-02f, 4.02597617e-03f, 6.50213063e-02f, 5.74074611e-02f,
  7.08731636e-02f, 5.51037043e-02f, -6.70596063e-02f, 3.72661315e-02f, -8.16860348e-02f, -9.61191207e-02f, -2.02139691e-02f, 6.98707625e-02f, -3.15378234e-02f, -8.39960575e-02f,
  -2.91295163e-02f, 4.22517071e-03f, -4.64983918e-02f, -6.94969669e-02f, -7.21977502e-02f, -1.57627240e-02f, 1.92565788e-02f, -8.09116066e-02f, -3.26414630e-02f, -3.54384892e-02f,
  2.25112200e-01f, -3.05502981e-01f, -7.05311075e-02f, 1.59495667e-01f, 1.23659074e-01f, -2.24351455e-02f, -1.08881891e-01f, 1.30079861e-03f, -2.87054162e-02f, -2.22012639e-01f,
  1.30367979e-01f, -9.67838243e-02f, -2.56399423e-01f, 1.59245655e-01f, 1.48448586e-01f, -1.43914998e-01f, 1.16164096e-01f, 9.56186727e-02f, -3.07263937e-02f, 2.72113411e-03f,
  8.17789957e-02f, 9.12664458e-02f, 3.40749510e-02f, 6.19469397e-02f, -2.41371877e-02f, 5.47874588e-05f, 1.43027008e-01f, -7.13623986e-02f, 1.31975740e-01f, -3.91755402e-02f,
  -2.92514525e-02f, 3.50702740e-02f, -1.95467263e-03f, 2.91063363e-04f, 2.34729871e-02f, 1.29643371e-02f, -1.07252650e-01f, -2.36465801e-02f, 2.46081501e-02f, -9.48568806e-03f,
  -5.25057316e-02f, -6.25063479e-02f, 1.01430684e-01f, 6.54536188e-02f, -2.70393696e-02f, 6.69992939e-02f, -2.32533831e-02f, -1.65894032e-02f, -1.06220216e-01f, -6.81182928e-03f,
  -5.54137416e-02f, -1.69650894e-02f, 3.62923108e-02f, -1.00278661e-01f, -2.03513466e-02f, 1.04521997e-02f, -3.81937958e-02f, -5.50186783e-02f, 3.58102657e-02f, -4.34016846e-02f,
  -2.21677544e-03f, -1.10799283e-01f, -6.82196915e-02f, 4.13724296e-02f, -2.60279402e-02f, 6.55590221e-02f, 2.52240151e-02f, 7.44684637e-02f, 9.94652603e-03f, 5.56328930e-02f,
  1.92283839e-02f, 7.66000822e-02f, -1.24587202e-02f, -7.74559891e-03f, -4.16153334e-02f, -2.76492648e-02f, -1.10358223e-02f, 6.17947280e-02f, 2.99368296e-02f, 8.84367991e-03f,
  -2.01876741e-02f, 1.08401962e-01f, -6.42354563e-02f, 2.26811748e-02f, -3.95017825e-02f, 3.32469568e-02f, 2.04224791e-02f, 6.63589835e-02f, -2.81837881e-02f, -3.96579877e-02f,
  -2.42655240e-02f, -1.45949259e-01f, -2.07239464e-02f, 1.49928229e-02f, 1.67635027e-02f, -7.59553211e-03f, 2.35363860e-02f, 1.04478449e-02f, 4.03513685e-02f, 9.46202129e-02f,
  -2.38248967e-02f, 1.13057151e-01f, 1.93362981e-02f, 3.95764746e-02f, 4.63766679e-02f, 6.61970302e-02f, -3.08922622e-02f, -3.77219953e-02f, -8.84501487e-02f, 1.96209364e-02f,
  -7.15182275e-02f, 4.59713005e-02f, -5.07898852e-02f, -5.99657260e-02f, -2.48644128e-02f, 4.74542826e-02f, -2.29944214e-02f, 2.49174237e-02f, -1.89445037e-02f, -3.31583433e-02f,
  -6.77981898e-02f, -8.86794366e-03f, -2.21267063e-02f, 6.33267313e-02f, 1.24659598e-01f, 4.74730842e-02f, -5.75809218e-02f, 1.36425048e-02f, -3.44995596e-02f, -1.14660397e-01f,
  3.91686277e-04f, -5.56076169e-02f, -8.86758193e-02f, -2.35323217e-02f, -6.42961636e-02f, -7.60326087e-02f, -1.28987608e-02f, -2.85060331e-02f, 7.96305388e-02f, 5.67463487e-02f,
  5.11807874e-02f, -1.20219789e-01f, -3.16069797e-02f, -4.39494625e-02f, 3.77358273e-02f, 7.86893964e-02f, -1.06124960e-01f, 2.88485531e-02f, 5.38198687e-02f, -1.43958656e-02f,
  -4.60015088e-02f, -6.28987402e-02f, -3.19790617e-02f, -3.96674946e-02f, -4.45986800e-02f, 5.88388406e-02f, 2.36776602e-02f, -5.43633588e-02f, -5.00080548e-03f, 3.78087312e-02f,
  7.39816204e-02f, 6.25815149e-03f, 5.41589148e-02f, -3.86540033e-02f, -5.87247238e-02f, -5.99095225e-03f, -5.65854460e-02f, 8.76581520e-02f, 6.21768832e-02f, -6.55709952e-02f,
  5.71832666e-03f, -2.93616857e-02f, 4.47789617e-02f, 5.84903434e-02f, 1.16437739e-02f, 4.58440222e-02f, 9.05750021e-02f, 2.61772750e-03f, 7.24312514e-02f, 9.00743082e-02f,
  -4.83413488e-02f, 1.34078031e-02f, 6.02594241e-02f, -4.89604585e-02f, -1.19305821e-02f, -7.06993565e-02f, 6.30728109e-03f, -1.25638153e-02f, 8.94912630e-02f, -2.26413179e-02f,
  -4.18718643e-02f, 1.05872244e-01f, -2.56367438e-02f, -3.57636511e-02f, -6.74871635e-03f, -9.12071019e-02f, -2.78309882e-02f, 5.97592816e-02f, 2.12509427e-02f, -6.35040477e-02f,
  3.69091816e-02f, 6.78269714e-02f, -1.32690873e-02f, -1.79217793e-02f, -7.36189708e-02f, 9.12055895e-02f, -5.88108003e-02f, 6.65439516e-02f, 7.58233517e-02f, 5.75161092e-02f,
  -2.35868599e-02f, -6.39423877e-02f, 1.09277731e-02f, -3.82232815e-02f, -6.03831783e-02f, -6.07687235e-02f, -1.41725568e-02f, -3.43943760e-02f, -6.79675862e-02f, -8.59024003e-03f,
  1.44518418e-02f, 8.65655020e-02f, -6.33948445e-02f, -5.71825653e-02f, 6.67310134e-02f, -2.81704571e-02f, 7.00157229e-03f, -7.93598779e-03f, 2.82562487e-02f, -4.81870119e-03f,
  5.01556955e-02f, 1.05411343e-01f, -8.59642625e-02f, 5.86060360e-02f, 5.41776866e-02f, 7.40549490e-02f, 2.42773890e-02f, 2.77573559e-02f, -3.03073291e-04f, -6.13198094e-02f,
  9.41838175e-02f, -1.81618243e-01f, 1.23950452e-01f, 1.03884973e-01f, -2.52585970e-02f, 1.36718556e-01f, 2.70099819e-01f, -1.12052821e-01f, 1.91647038e-02f, -1.63677439e-01f,
  -2.51574852e-02f, 1.01043254e-01f, 1.56017154e-01f, -7.03669116e-02f, 5.61421216e-02f, 1.02950893e-02f, 6.21613450e-02f, 6.87052533e-02f, 2.05813050e-02f, 1.94191653e-02f,
  -3.83268781e-02f, -8.59951600e-02f, -1.44645283e-02f, -2.00220317e-01f, -1.12613298e-01f, -5.90671077e-02f, 2.08931156e-02f, 7.23293647e-02f, -2.47721791e-01f, 4.59800139e-02f,
  -9.52083617e-02f, 1.08723743e-02f, 2.20301989e-02f, -9.85270068e-02f, 4.38551381e-02f, -4.02519964e-02f, 6.73122006e-03f, 5.19406013e-02f, 7.29933977e-02f, 5.47337160e-02f,
  4.08971310e-02f, 3.63106541e-02f, -4.69542183e-02f, 9.24820676e-02f, -9.79287177e-03f, 2.21314095e-02f, 7.60234073e-02f, -9.86209139e-03f, -6.35620654e-02f, 4.95168678e-02f,
  7.19565526e-02f, -4.60998863e-02f, 6.86751828e-02f, -5.03133126e-02f, 1.62061453e-02f, 1.24584660e-02f, -6.18119128e-02f, -6.09023171e-03f, 8.10020976e-03f, -3.89174819e-02f,
  -7.04068318e-02f, -3.82453129e-02f, 6.26892820e-02f, -5.85271604e-02f, -3.91798913e-02f, -4.80256453e-02f, 1.45440996e-02f, -3.61162685e-02f, 1.00426957e-01f, 1.53738894e-02f,
  3.30035537e-02f, 5.35521694e-02f, 4.87308912e-02f, 9.96826813e-02f, -8.75732824e-02f, 1.10512991e-02f, -6.29724562e-02f, -4.08676974e-02f, -1.15359444e-02f, -4.44181636e-02f,
  1.10483570e-02f, 5.12412749e-02f, 6.54167756e-02f, -1.32229887e-02f, -4.13781218e-02f, -3.41841690e-02f, -9.18771774e-02f, 7.85694364e-03f, 7.01046642e-03f, -1.43644586e-02f,
  -7.51308957e-03f, -1.17834710e-01f, -1.18608311e-01f, 2.57625356e-02f, -4.75277938e-02f, -3.28803901e-03f, -7.80548304e-02f, -1.04933359e-01f, -4.21362892e-02f, -8.53370950e-02f,
  4.57097143e-02f, 3.69929969e-02f, -3.07975430e-02f, 3.64426188e-02f, -3.61524634e-02f, -1.00314692e-01f, -4.03084718e-02f, 5.32595441e-02f, -1.54790478e-02f, -2.10347902e-02f,
  6.32059854e-03f, 5.96704008e-03f, 6.68254346e-02f, -3.37811094e-03f, 1.38738751e-03f, 2.50294711e-02f, -2.19949018e-02f, 1.63073174e-03f, 4.92211655e-02f, 5.77123277e-02f,
  1.26495719e-01f, -2.66927630e-02f, -1.33531243e-01f, -4.61273827e-03f, -3.06168925e-02f, -2.80034635e-02f, -5.72837144e-02f, -8.77142244e-04f, -9.91741046e-02f, 7.42199123e-02f,
  8.11726153e-02f, -1.10835858e-01f, -1.61675781e-01f, -7.02780113e-02f, -1.32100746e-01f, -8.37228447e-02f, 6.43105581e-02f, 1.03505580e-02f, -5.09039909e-02f, 3.59311774e-02f,
  -5.73274419e-02f, -4.21548001e-02f, -1.23234369e-01f, -1.93918627e-02f, 7.64405355e-02f, 3.82649750e-02f, -1.23640783e-02f, -5.14233261e-02f, 1.47334427e-01f, 3.56525145e-02f,
  5.80593608e-02f, -2.62910724e-02f, -4.16455418e-02f, 6.25458881e-02f, 8.62381831e-02f, 1.68054610e-01f, 1.09342873e-01f, -5.00036217e-02f, 3.34520824e-02f, 1.83378682e-02f,
  1.01628050e-01f, -5.64431064e-02f, 4.87868441e-03f, -1.12269735e-02f, 4.03298326e-02f, 8.24922398e-02f, 1.26941772e-02f, 3.40849953e-03f, -1.04258716e-01f, 8.87130015e-03f,
  -1.28770441e-01f, 6.70364723e-02f, 4.06236947e-02f, -5.25115728e-02f, 3.45189162e-02f, 3.88924009e-03f, 3.50091606e-02f, 8.95279497e-02f, 1.07723683e-01f, 1.63763445e-02f,
  1.12265639e-01f, -2.63385754e-02f, 7.16069108e-03f, -7.07047954e-02f, -4.33448888e-02f, 4.82141674e-02f, 5.13823926e-02f, -3.02488804e-02f, -7.63880387e-02f, -2.06784047e-02f,
  -7.84940273e-02f, -8.72552320e-02f, 4.42263745e-02f, -5.28523698e-02f, 4.67442162e-02f, 2.70612095e-03f, 1.03293352e-01f, 1.01723768e-01f, -9.82137248e-02f, 5.60213905e-03f,
  -5.94637208e-02f, 6.97544143e-02f, -2.06619296e-02f, -4.06332016e-02f, 3.04261837e-02f, -5.91710843e-02f, 3.85097861e-02f, -9.30685028e-02f, -8.47186595e-02f, 1.68289300e-02f,
  -1.87841570e-03f, -3.80982389e-03f, -1.12685099e-01f, -1.03256078e-02f, -1.90610886e-02f, -2.05814745e-02f, -4.95969839e-02f, 9.37033892e-02f, -4.80170287e-02f, -4.16382141e-02f,
  4.39990461e-02f, -2.72936299e-02f, 8.95618945e-02f, -1.17191076e-02f, 5.25847785e-02f, -7.89975449e-02f, -3.34279984e-02f, 1.16067886e-01f, -5.34668565e-02f, 2.83789653e-02f,
  -3.90800796e-02f, 7.94575736e-02f, 9.29080546e-02f, 1.03493787e-01f, 1.03451759e-01f, 1.17207572e-01f, 2.83780489e-02f, -4.43864390e-02f, 8.28765184e-02f, -7.16887191e-02f,
  -1.67628080e-01f, -1.28200476e-03f, 2.66469494e-02f, -8.33802894e-02f, 1.08682126e-01f, -4.06901464e-02f, -1.10770658e-01f, -2.83134636e-02f, -8.91509745e-03f, 4.93008792e-02f,
  -6.19744807e-02f, 5.56625649e-02f, 7.44802058e-02f, -9.34914500e-03f, -2.31580883e-01f, -1.21022701e-01f, -1.58615708e-01f, -1.05919652e-01f, -3.96785373e-03f, 6.91109374e-02f,
  -1.24791913e-01f, -7.20128641e-02f, -1.43435463e-01f, 1.32192373e-01f, 4.79367236e-03f, -4.62979600e-02f, -7.19391406e-02f, 4.79160398e-02f, -5.43181263e-02f, -5.35365008e-03f,
  -8.98423493e-02f, 1.98291102e-03f, 4.32024933e-02f, -3.13694887e-02f, -3.94407921e-02f, -9.34586767e-03f, -7.74379373e-02f, -6.73678666e-02f, 4.81889807e-02f, -4.87693958e-02f,
  -2.32331939e-02f, -6.51315749e-02f, -1.15153342e-02f, -1.65155046e-02f, -1.84855070e-02f, 2.17381679e-02f, 5.05154021e-02f, -6.24625906e-02f, -3.54510769e-02f, -3.84929255e-02f,
  5.03869317e-02f, 1.66877955e-02f, 2.95910314e-02f, -3.28898616e-02f, -1.35863557e-01f, -8.79628882e-02f, -5.27867302e-02f, 5.22812307e-02f, -2.84051057e-02f, -6.33534864e-02f,
  -1.03236683e-01f, -1.73542518e-02f, 1.18960543e-02f, -3.65174115e-02f, 7.08439276e-02f, 2.02016253e-02f, 2.78707147e-02f, 6.05245344e-02f, -5.03585674e-02f, 1.65406764e-02f,
  -8.66562203e-02f, -2.04080120e-02f, -2.50396971e-02f, -5.74992187e-02f, 8.70654359e-03f, -3.05144936e-02f, -2.06948966e-02f, -2.94187516e-02f, -3.45310047e-02f, 2.42635570e-02f,
  5.46337068e-02f, 3.48107889e-02f, 3.64620462e-02f, 2.22257022e-02f, -2.29451694e-02f, 7.06772879e-02f, 6.16895780e-02f, -3.92458886e-02f, -8.65575299e-02f, 3.75490896e-02f,
  -8.62375200e-02f, -6.51687682e-02f, 1.63657665e-02f, -6.54736832e-02f, -3.91007140e-02f, -1.15238316e-01f, -7.27979690e-02f, -6.85581714e-02f, 3.20569053e-02f, 4.02624831e-02f,
  -2.03827601e-02f, 1.50165067e-03f, -6.46622702e-02f, 5.57298511e-02f, -5.03492206e-02f, -4.23669331e-02f, -1.03394724e-02f, -2.52704155e-02f, -6.36277273e-02f, 8.80289227e-02f,
  6.01179153e-02f, 5.58823720e-02f, -5.11948019e-02f, 4.23499346e-02f, 3.44821275e-03f, 2.86972732e-04f, -1.70190446e-02f, -1.08427241e-01f, 5.59711345e-02f, 6.53005950e-03f,
  -9.76987556e-02f, -7.07429573e-02f, -8.82187188e-02f, -9.86026004e-02f, -1.40194640e-01f, -1.78482190e-01f, -3.36810499e-02f, 1.61621161e-02f, 1.67412862e-01f, 3.63076571e-03f,
  -7.54766390e-02f, 2.19710112e-01f, -4.04639691e-02f, -6.61054105e-02f, -1.70951169e-02f, 1.22791216e-01f, -1.70783654e-01f, -1.02270298e-01f, -4.33705114e-02f, -2.81375367e-02f,
  1.28981192e-03f, -8.98122564e-02f, -1.25488237e-01f, -1.36443079e-01f, -1.03362456e-01f, -2.40810532e-02f, 2.04062089e-02f, -8.60912502e-02f, -1.18623368e-01f, -4.30429801e-02f,
  -1.11345209e-01f, 8.83861184e-02f, -9.36735049e-02f, 4.10447866e-02f, -3.71025503e-02f, -3.03703547e-02f, 2.26641111e-02f, 8.92580524e-02f, -8.76068398e-02f, -9.99819115e-03f,
  -4.36747856e-02f, 3.55026051e-02f, 2.07681283e-02f, -4.37189452e-02f, -7.03620091e-02f, 8.34365115e-02f, -7.98817798e-02f, -5.40598109e-02f, -5.35979755e-02f, 6.82096258e-02f,
  -7.17951125e-03f, -2.07115654e-02f, -1.00458972e-01f, 6.83240443e-02f, -1.29631627e-02f, 2.46752724e-02f, 1.94687229e-02f, 3.19050252e-02f, 2.33647246e-02f, 2.77747326e-02f,
  -5.62089495e-02f, 5.04600927e-02f, -2.38439012e-02f, 1.85965642e-03f, -6.51012883e-02f, -1.92720145e-02f, 4.22907174e-02f, 2.18340289e-02f, -6.03662916e-02f, -4.76236977e-02f,
  -7.59257749e-02f, -6.34809956e-04f, 3.88377681e-02f, -3.16995308e-02f, 5.65027557e-02f, 5.09946756e-02f, 7.30568841e-02f, -1.01396497e-02f, -5.89009263e-02f, -6.02455251e-03f,
  4.01016735e-02f, -7.65796900e-02f, 6.27798662e-02f, -5.91732077e-02f, -6.42516389e-02f, 6.44799322e-02f, 3.60652320e-02f, -7.94480368e-02f, 1.02281779e-01f, 4.07278650e-02f,
  -1.01620756e-01f, 6.26554638e-02f, 9.15934332e-03f, -5.62246889e-02f, -2.36426573e-02f, 2.94660334e-03f, 4.82399687e-02f, -6.95804656e-02f, 1.10611822e-02f, 6.64175078e-02f,
  6.19970523e-02f, 5.53715229e-02f, -7.76357129e-02f, 2.89250836e-02f, 1.22162253e-02f, 2.76335923e-04f, -6.47342950e-02f, 4.60426919e-02f, 3.40485536e-02f, -4.67670560e-02f,
  -8.34945515e-02f, -4.63652015e-02f, -8.05146620e-03f, -4.99391416e-03f, 5.44810295e-02f, 1.11751650e-02f, 6.11856729e-02f, 3.17689544e-03f, 5.37922271e-02f, 4.88608479e-02f,
  -1.34434715e-01f, -8.27447549e-02f, 1.40545322e-02f, 3.97385210e-02f, -5.21298610e-02f, 8.23757797e-02f, 6.90471083e-02f, -9.26791877e-02f, -1.15579799e-01f, 5.02886623e-03f,
  1.00204706e-01f, -8.99685472e-02f, 6.97934702e-02f, 1.08183272e-01f, -1.36682084e-02f, 4.47823759e-03f, -5.76968044e-02f, 1.31462172e-01f, -5.64146563e-02f, -9.56923962e-02f,
  2.35096458e-02f, 1.23863079e-01f, 5.36292493e-02f, 7.90671781e-02f, -5.27720787e-02f, -5.23580424e-02f, 3.17076668e-02f, 1.09095722e-01f, 2.00500917e-02f, 7.46773407e-02f,
  5.82060739e-02f, -1.33881330e-01f, -3.66766565e-02f, -1.48985200e-02f, -3.89403030e-02f, 1.03085702e-02f, -1.77202504e-02f, 1.57136042e-02f, 3.34157199e-02f, -1.67653523e-02f,
  -8.37666690e-02f, -5.25972359e-02f, 4.34020609e-02f, -9.28216577e-02f, -4.04204205e-02f, -4.97520640e-02f, -3.58857661e-02f, -5.26571311e-02f, -6.81328401e-02f, -7.82965124e-02f,
  -1.46734091e-02f, -6.91758655e-03f, -4.78133596e-02f, 2.71804165e-02f, 4.27297801e-02f, -1.33117512e-02f, -3.46445851e-02f, 9.42326114e-02f, -4.14732955e-02f, 5.58457375e-02f,
  5.82651980e-02f, -4.73949760e-02f, -9.14844722e-02f, 6.97138952e-03f, -5.62747195e-02f, 3.71313468e-02f, 2.05368455e-02f, 4.56287339e-02f, -9.62409377e-03f, 9.68376920e-02f,
  -3.27155218e-02f, -1.42204342e-02f, -3.73435281e-02f, -3.54472548e-02f, 6.23220671e-03f, 3.21396850e-02f, 3.82178673e-03f, -6.39727106e-03f, -8.22753063e-04f, -4.34900932e-02f,
  -7.01068789e-02f, -6.56003505e-02f, -7.48941861e-03f, 1.01837032e-02f, -7.80433789e-02f, -5.88001870e-02f, -1.67385358e-02f, 6.87449751e-03f, 1.80980954e-02f, 2.55181803e-03f,
  -1.28308609e-01f, -1.37999460e-01f, 3.68630290e-02f, 1.08563611e-02f, 6.70152158e-03f, 4.20935974e-02f, 4.74982522e-02f, 4.47847247e-02f, -1.24100477e-01f, -9.01702717e-02f,
  3.27827921e-03f, 5.30036772e-03f, 5.68686500e-02f, -9.35943872e-02f, -4.99057844e-02f, 5.75840063e-02f, 3.64471786e-02f, -8.30382109e-02f, -5.14135845e-02f, -2.39605084e-03f,
  2.78680678e-02f, 9.14516114e-03f, 8.48061293e-02f, -7.47288316e-02f, 9.46735963e-02f, 5.72408810e-02f, 4.36703078e-02f, -5.97705133e-02f, -5.67536689e-02f, -8.09195489e-02f,
  1.27250403e-01f, 1.32223417e-03f, -7.11487457e-02f, 1.08233519e-01f, -1.80215850e-01f, -2.36103192e-01f, -6.84579313e-02f, 9.55627710e-02f, -5.12984209e-02f, 2.21782681e-02f,
  -4.03359160e-02f, -4.20239568e-02f, 1.26153409e-01f, 5.74104898e-02f, 6.80317497e-03f, 6.91221580e-02f, -8.58270824e-02f, -9.17430669e-02f, 1.45115461e-02f, 1.69005468e-01f,
  3.22604477e-02f, -8.91023607e-04f, 8.86377096e-02f, 1.19185172e-01f, 1.66438464e-02f, 2.00503655e-02f, 1.39057592e-01f, 9.35903192e-03f, 3.00762802e-02f, -8.89404044e-02f,
  -7.94418976e-02f, 3.54624428e-02f, 5.56706032e-03f, 8.03390238e-03f, -3.01690437e-02f, 4.56622764e-02f, -6.69891387e-02f, -3.91016109e-03f, -5.83694614e-02f, 5.94355874e-02f,
  3.20852883e-02f, 4.46246006e-02f, 2.10497717e-04f, 5.66725470e-02f, -4.39905226e-02f, 9.40116588e-03f, -1.32241584e-02f, -6.35324791e-02f, -7.36732502e-03f, -2.11075451e-02f,
  3.19829732e-02f, 7.04788640e-02f, 4.11639474e-02f, 2.25587618e-02f, 8.81107450e-02f, 4.16755565e-02f, 5.08216619e-02f, -3.04989181e-02f, -7.90861920e-02f, -3.68962102e-02f,
  3.12276632e-02f, 5.66905774e-02f, 5.85447215e-02f, -2.43336931e-02f, -2.34649051e-02f, 5.24080032e-03f, 5.91058470e-02f, -2.39576530e-02f, -3.44518833e-02f, 6.57573566e-02f,
  1.86131056e-02f, -6.11289777e-02f, 5.44281825e-02f, -5.71453907e-02f, 4.95891161e-02f, 2.53854208e-02f, 8.78905952e-02f, 9.15737525e-02f, -9.69315320e-03f, 1.78459343e-02f,
  1.82065759e-02f, 2.81329677e-02f, 3.43265831e-02f, -4.31441404e-02f, -5.81150204e-02f, 3.97766866e-02f, 2.92074010e-02f, 1.15334494e-02f, 3.76563407e-02f, -6.75928295e-02f,
  5.08735627e-02f, 1.45729989e-01f, -2.82229893e-02f, -5.34733408e-04f, -8.53203312e-02f, 3.03026121e-02f, 3.85868689e-03f, -2.65637860e-02f, 7.11128339e-02f, 5.55114970e-02f,
  -1.91175169e-03f, -3.96159030e-02f, 6.07515546e-03f, 6.15966842e-02f, 4.63505350e-02f, 3.50562222e-02f, 3.80363166e-02f, 1.05058393e-02f, 4.19296622e-02f, 9.61852670e-02f,
  5.75092211e-02f, -4.83321734e-02f, -5.64119332e-02f, -1.72865540e-02f, -1.96962189e-02f, 4.98745032e-02f, 4.53371927e-02f, 6.57772571e-02f, 9.03144777e-02f, 7.18387812e-02f,
  2.82807827e-01f, 9.99385193e-02f, 1.20533809e-01f, 1.13923214e-01f, -8.01420510e-02f, -1.36431143e-01f, -1.18667789e-01f, -8.20284560e-02f, 1.70384273e-01f, 5.06151430e-02f,
  -1.11180142e-01f, 3.11347038e-01f, -1.01330526e-01f, 1.34986818e-01f, -1.43954203e-01f, -1.32427916e-01f, -6.52852505e-02f, 1.03839993e-01f, 6.90840185e-02f, 2.56568640e-02f,
  -1.48521867e-02f, -1.64634287e-01f, 2.39309040e-03f, -1.64140329e-01f, 4.01976854e-02f, 7.98927844e-02f, -1.18085757e-01f, -1.58093929e-01f, -1.64804608e-02f, -9.09869075e-02f,
  6.16774112e-02f, -3.63276787e-02f, 3.36463004e-02f, 2.17862558e-02f, 1.23461504e-02f, -1.16703184e-02f, -4.13877564e-03f, -5.67142926e-02f, 2.10598689e-02f, 3.30461599e-02f,
  4.68437523e-02f, -2.25361157e-02f, 8.53559971e-02f, -3.65898870e-02f, -1.15153827e-02f, 3.97184975e-02f, -5.72185405e-03f, 6.91183433e-02f, 4.04512584e-02f, 7.04811588e-02f,
  7.02875331e-02f, 9.18711573e-02f, 5.86725436e-02f, -2.33376473e-02f, -4.78447862e-02f, -2.10106038e-02f, 1.57508720e-02f, -2.43726876e-02f, 5.20446785e-02f, 6.38215169e-02f,
  1.42489215e-02f, -1.00221775e-01f, 4.99872789e-02f, 4.57579829e-02f, -7.69135505e-02f, 2.25939639e-02f, -3.08664721e-02f, -8.79714340e-02f, -2.53713727e-02f, -7.22020352e-03f,
  -1.23516598e-03f, 4.14380385e-03f, 1.60684045e-02f, -1.55553399e-02f, 6.98052198e-02f, 4.65991646e-02f, 2.29714662e-02f, -1.14430845e-01f, -4.20568623e-02f, 6.12293258e-02f,
  -8.92033502e-02f, -1.48604056e-02f, -1.22611290e-02f, 3.53757553e-02f, -1.11924317e-02f, 4.14154194e-02f, -2.71734577e-02f, 5.24803356e-04f, 5.79512380e-02f, -6.03195243e-02f,
  1.45485485e-03f, -1.68534718e-03f, 9.23546180e-02f, 3.31440717e-02f, 2.96141151e-02f, 9.05297622e-02f, -6.86597824e-02f, 3.81765142e-02f, -2.32040249e-02f, -3.45302597e-02f,
  5.93237355e-02f, -7.11242706e-02f, 4.80993427e-02f, 2.65584071e-03f, -5.88424318e-02f, 3.36551070e-02f, -3.11315246e-02f, 2.56573092e-02f, -5.81186824e-03f, -1.66914444e-02f,
  5.87341450e-02f, 3.31968702e-02f, 6.68014809e-02f, 2.91469023e-02f, -2.36964636e-02f, -3.01158288e-03f, 1.02496166e-02f, -4.14963067e-03f, -2.86071002e-02f, 8.21789429e-02f,
  -1.01588666e-01f, 2.08959579e-02f, 8.59607235e-02f, 5.69987409e-02f, -5.37602715e-02f, 8.58644173e-02f, 2.04893902e-01f, 5.67467883e-02f, -6.11554421e-02f, -7.52865151e-02f,
  -6.08675182e-02f, -5.89996800e-02f, 8.92272890e-02f, 2.28871126e-02f, 9.50458720e-02f, -1.27064418e-02f, 9.68962982e-02f, -7.54091516e-02f, -9.05973017e-02f, -3.08759585e-02f,
  -9.19586942e-02f, -2.92172059e-02f, 1.86073095e-01f, 2.69471500e-02f, -3.04302759e-02f, 7.69019052e-02f, -5.74473180e-02f, -7.65008898e-03f, 2.63583544e-03f, -5.68641387e-02f,
  -6.20831512e-02f, -1.37003129e-02f, -6.81262687e-02f, 4.39489447e-02f, -2.02516522e-02f, 6.82676770e-03f, 5.06482907e-02f, -2.80549508e-02f, -3.54045467e-03f, 3.98134328e-02f,
  3.30971442e-02f, 1.41455336e-02f, -1.33649325e-02f, -2.88251415e-02f, -1.07955389e-01f, 1.12802880e-02f, 3.18723358e-02f, 3.42412293e-03f, -1.28006970e-03f, -5.70130069e-04f,
  5.83060645e-02f, 5.68530746e-02f, 8.43957514e-02f, -2.55438779e-02f, -5.81882000e-02f, 1.12561730e-03f, -5.08353338e-02f, 2.68308329e-03f, 3.90139073e-02f, -6.54705614e-02f,
  -1.09244771e-02f, -3.62468734e-02f, 8.31854418e-02f, -4.65847254e-02f, 2.84771603e-02f, -1.91043783e-02f, -3.40646170e-02f, 5.96249960e-02f, 1.91570597e-03f, -3.54977772e-02f,
  2.44612116e-02f, -2.74833906e-02f, 3.24334800e-02f, -4.34308723e-02f, 3.22681889e-02f, 3.07327919e-02f, -3.30843031e-02f, 7.51533359e-02f, 9.34857652e-02f, 6.96501404e-04f,
  -4.42722673e-03f, -6.31303191e-02f, 7.33522326e-02f, 2.04426106e-02f, 8.24653208e-02f, 8.49039182e-02f, 7.01562911e-02f, -7.07093179e-02f, -5.49669145e-04f, 1.26235308e-02f,
  -1.39635235e-01f, -1.56999066e-01f, 6.37216270e-02f, -4.53126766e-02f, 8.52295086e-02f, 5.78709580e-02f, 6.78919926e-02f, -2.86511146e-02f, -4.44141254e-02f, -1.90190990e-02f,
  2.85884179e-02f, 2.76344921e-02f, -9.51213092e-02f, -7.08594024e-02f, 5.49291223e-02f, -3.75759229e-02f, 7.03892559e-02f, -1.06736727e-01f, -6.69756234e-02f, -6.12651780e-02f,
  -6.09359145e-02f, 1.13479290e-02f, -3.54439393e-02f, 5.08059710e-02f, -1.90417003e-02f, -3.40964459e-02f, -2.21561845e-02f, 3.13634872e-02f, -5.63275181e-02f, -4.84501719e-02f,
  4.88735624e-02f, -1.26681715e-01f, 1.82412099e-02f, -6.60843104e-02f, 1.58745721e-01f, -5.47442846e-02f, -8.51666108e-02f, 8.84134099e-02f, 5.80099337e-02f, 2.50088349e-02f,
  -5.49772270e-02f, -2.11908426e-02f, -1.28590420e-01f, 6.84559494e-02f, 3.79991978e-02f, -5.56287356e-02f, 8.16005170e-02f, 6.46990910e-02f, 5.47684804e-02f, 2.53492240e-02f,
  2.09878888e-02f, -4.22554370e-03f, 4.81018126e-02f, 1.03406563e-01f, 3.12560201e-02f, -3.58457677e-02f, -4.61994633e-02f, 2.38420069e-03f, 9.02020186e-02f, 4.23621349e-02f,
  8.85142684e-02f, 2.69929171e-02f, 1.11915171e-02f, 1.89325400e-02f, -7.40498230e-02f, -8.46514627e-02f, 2.53743920e-02f, 9.06706899e-02f, 1.78156104e-02f, -5.12876138e-02f,
  -9.95606109e-02f, -6.24454916e-02f, -1.66228171e-02f, -8.54642168e-02f, -2.49119401e-02f, -2.56524403e-02f, 4.99951430e-02f, 4.26647700e-02f, 7.66185820e-02f, -8.41395557e-02f,
  4.67143171e-02f, 5.43937571e-02f, 7.85090104e-02f, -5.27745625e-03f, 7.21651018e-02f, -8.41396078e-02f, -3.02395262e-02f, -5.12978733e-02f, -8.27643722e-02f, 1.15279772e-03f,
  -3.85778844e-02f, 5.60956970e-02f, 8.61395523e-02f, 7.61190429e-02f, 5.52894399e-02f, 1.06284479e-02f, 8.32632929e-02f, -7.37396404e-02f, 6.83676526e-02f, 1.19440407e-02f,
  5.40662929e-02f, 3.28479484e-02f, 9.55389217e-02f, 1.04845420e-01f, -8.92143995e-02f, -5.22463359e-02f, -3.48685011e-02f, 4.84334741e-04f, 4.08296175e-02f, -3.18810008e-02f,
  3.37044559e-02f, -4.94676046e-02f, 7.18375668e-02f, -1.16698467e-03f, -2.63600405e-02f, -7.83394650e-02f, -5.53802662e-02f, -5.08381315e-02f, 6.36517629e-02f, -5.42113408e-02f,
  -9.88010913e-02f, -1.84831828e-01f, -6.06320277e-02f, 5.48311882e-02f, 8.20879415e-02f, -1.68679666e-03f, -4.56581712e-02f, -7.78376460e-02f, -4.17873263e-02f, 6.93151727e-02f,
  -1.91731825e-02f, -1.67236396e-03f, -9.82093811e-02f, 5.74762076e-02f, 9.13220420e-02f, -3.39877866e-02f, 2.77681947e-02f, 4.73698648e-03f, 6.87999055e-02f, -1.14718489e-02f,
  -6.21734150e-02f, -4.71024550e-02f, 4.65880223e-02f, 2.68923361e-02f, -1.21998787e-02f, -4.89926548e-04f, 1.70758907e-02f, 1.93634871e-02f, -8.05660784e-02f, -4.85648438e-02f,
  -5.24398424e-02f, 3.23410183e-02f, -1.25932008e-01f, -1.85063742e-02f, 1.43910972e-02f, -1.05623908e-01f, -1.26717165e-02f, 1.25926033e-01f, -8.52102041e-02f, 7.89795667e-02f,
  1.26545832e-01f, 9.29246247e-02f, 4.71568145e-02f, 7.36617818e-02f, 9.15885344e-02f, 3.27916420e-03f, 1.27903670e-01f, 9.47834924e-02f, -3.55475470e-02f, 7.00404271e-02f,
  1.45178095e-01f, 2.69911289e-01f, -2.93962322e-02f, 5.90764433e-02f, -1.38804293e-03f, -6.15564063e-02f, 1.71142504e-01f, -4.22176868e-02f, 1.82083949e-01f, 9.85069945e-02f,
  5.30143231e-02f, 8.66535828e-02f, 1.79429315e-02f, 1.29207666e-03f, -2.02682354e-02f, -4.11155112e-02f, 2.54221112e-02f, -1.23642180e-02f, 3.25434469e-02f, -1.82363316e-02f,
  -2.19678786e-02f, 1.71155706e-02f, 9.21539813e-02f, 7.45749846e-02f, -7.35469684e-02f, -3.40531208e-02f, -4.36967872e-02f, 3.49129252e-02f, -3.39435600e-02f, 6.64742198e-03f,
  -4.69689891e-02f, 6.08856976e-03f, 4.78426218e-02f, 4.72807251e-02f, -3.54735404e-02f, 2.47140266e-02f, 1.43053839e-02f, 8.96262527e-02f, -3.96903530e-02f, -2.46828347e-02f,
  1.59594207e-03f, 5.04715443e-02f, -1.26575222e-02f, -2.79823299e-02f, -7.62146935e-02f, -2.06010025e-02f, -4.91294377e-02f, -1.65089983e-02f, 4.83174734e-02f, -6.34377226e-02f,
  -4.35883701e-02f, 5.68914600e-02f, -3.00822593e-02f, 8.03361535e-02f, 1.08997792e-01f, 2.36748997e-03f, 6.88499212e-02f, 8.26851558e-03f, -2.86330245e-02f, 3.32659222e-02f,
  4.13402682e-03f, -1.44888181e-02f, -1.56255644e-02f, 9.98902768e-02f, 3.76520976e-02f, -1.96111407e-02f, 3.78795750e-02f, 3.20050642e-02f, 1.05279696e-03f, 5.74075989e-02f,
  1.53904334e-01f, 1.40266463e-01f, -1.87020712e-02f, -8.88282061e-02f, -3.67346145e-02f, -3.19814533e-02f, -6.50608763e-02f, -2.59470800e-03f, 1.01648634e-02f, -4.49093543e-02f,
  6.79451898e-02f, 8.09841231e-02f, 1.03012249e-01f, -8.24026205e-03f, -7.98170492e-02f, 1.22783847e-01f, 2.94443732e-03f, 1.28252404e-02f, -7.16156214e-02f, 1.03274621e-01f,
  -4.59164232e-02f, 2.60948390e-03f, -8.43380988e-02f, -7.40673020e-02f, -8.70545581e-03f, -1.04548492e-01f, 6.37901714e-03f, -4.27694758e-03f, -3.28594223e-02f, 7.45344386e-02f,
  9.79412571e-02f, -5.61702587e-02f, -9.90905389e-02f, -8.53806585e-02f, 3.39794606e-02f, -1.71045035e-01f, -1.50884002e-01f, -1.62262738e-01f, 4.71290341e-03f, -1.36674479e-01f,
  -8.70064199e-02f, 6.46828022e-03f, 7.21733272e-02f, -1.25074640e-01f, 1.07430138e-01f, 4.03702781e-02f, -1.10418253e-01f, -9.92945358e-02f, 2.90039778e-02f, -9.98293087e-02f,
  6.69765025e-02f, -1.78670570e-01f, 2.56061424e-02f, -1.54392079e-01f, -1.12362921e-01f, -4.67686206e-02f, 6.70297397e-03f, -3.01236901e-02f, -1.03706688e-01f, -1.02279767e-01f,
  -1.13620304e-01f, -4.71698493e-02f, -2.82371342e-02f, -2.88675111e-02f, 3.08863539e-02f, 7.46438187e-03f, -2.12324038e-02f, 4.24233340e-02f, 8.55209306e-02f, 1.66347474e-02f,
  4.42454182e-02f, -4.47772555e-02f, -4.90488186e-02f, 3.73853482e-02f, -6.69309646e-02f, -4.95685898e-02f, 4.75305580e-02f, -3.00646313e-02f, -3.35414335e-02f, -1.96474772e-02f,
  -4.71637733e-02f, -2.32520532e-02f, -3.51381898e-02f, 7.88159482e-03f, -6.29552156e-02f, -5.06522134e-02f, 7.96249360e-02f, -1.28329508e-02f, 2.81030188e-05f, -5.07064350e-02f,
  6.07181750e-02f, -6.07404150e-02f, 8.00532699e-02f, -5.99770865e-04f, 4.52536829e-02f, -5.38548343e-02f, 1.60585716e-02f, 3.69606242e-02f, 6.46267682e-02f, -8.13083872e-02f,
  -5.10224067e-02f, -7.57957175e-02f, -2.62563638e-02f, -1.49879651e-02f, -5.25193773e-02f, 3.52776535e-02f, -4.15134579e-02f, -5.69184497e-02f, -7.28269219e-02f, 3.80766802e-02f,
  1.13615475e-03f, -4.09300253e-02f, -3.11646592e-02f, 6.54112473e-02f, 2.34890021e-02f, -1.76133178e-02f, -4.37173881e-02f, 7.61925662e-03f, 1.80304423e-02f, -2.68684905e-02f,
  -2.70130895e-02f, -5.33918925e-02f, -5.91517501e-02f, -3.02652977e-02f, 6.31918162e-02f, -5.17666265e-02f, 3.93496379e-02f, 5.87385260e-02f, -4.25033234e-02f, 5.44021614e-02f,
  -6.79441988e-02f, 5.75423017e-02f, 4.74855825e-02f, 6.12372197e-02f, -1.04054455e-02f, 4.44258936e-03f, 3.27817835e-02f, 2.04982832e-02f, 4.64227721e-02f, -6.58007637e-02f,
  -2.96630282e-02f, -4.53920811e-02f, -6.24774257e-03f, -3.18583809e-02f, -1.78647302e-02f, -6.78073242e-02f, -2.42829900e-02f, 3.47589031e-02f, 4.49731797e-02f, -1.70259513e-02f,
  -7.14613572e-02f, 6.97527304e-02f, 7.21016824e-02f, -7.30551034e-02f, 2.57975459e-02f, -3.77959833e-02f, -1.71193865e-03f, 7.89277554e-02f, 6.44485503e-02f, -7.06712380e-02f,
  -6.31134585e-02f, 1.09024402e-02f, -8.30694810e-02f, 4.14509326e-02f, 2.04030070e-02f, -3.71472500e-02f, -9.57851559e-02f, 6.61778823e-02f, -9.19815153e-02f, 6.30272627e-02f,
  9.61566269e-02f, 5.09516709e-02f, -3.22135761e-02f, -5.05279154e-02f, -5.70909269e-02f, 5.71316332e-02f, -3.07382317e-04f, 3.89572270e-02f, -4.04011123e-02f, 7.55933821e-02f,
  6.36051781e-03f, -1.66639611e-02f, 6.88116401e-02f, -3.04996073e-02f, -3.03484537e-02f, -8.55807588e-02f, -3.13785598e-02f, -5.89502081e-02f, -6.51113763e-02f, 1.96081158e-02f,
  7.08917230e-02f, -5.77675477e-02f, -2.13602595e-02f, 8.35921392e-02f, 9.90827829e-02f, -3.98881808e-02f, 4.64196429e-02f, 4.57523689e-02f, 9.02828127e-02f, 5.66209666e-02f,
  -7.85391033e-02f, 7.31586106e-03f, 5.49282655e-02f, 6.60996959e-02f, 6.06089234e-02f, -7.59136528e-02f, 5.50645664e-02f, -2.25839689e-02f, -7.26151317e-02f, -3.27337123e-02f,
  -6.47340119e-02f, 6.31155819e-02f, -8.57681558e-02f, 1.51561806e-02f, -1.95687991e-02f, 7.41424592e-05f, -1.14085376e-02f, 6.53397068e-02f, -3.51780504e-02f, 8.76542330e-02f,
  -3.92286386e-03f, -2.63776407e-02f, 8.54117349e-02f, -6.14665747e-02f, -7.37154782e-02f, 6.98156878e-02f, 6.77322969e-02f, 6.32623136e-02f, 1.08683743e-02f, -4.74215411e-02f,
  2.46655550e-02f, -2.86103114e-02f, 3.59695181e-02f, -2.53378116e-02f, 1.75438449e-02f, 2.98123788e-02f, -2.25440729e-02f, 3.37423831e-02f, -2.32399944e-02f, 2.37289760e-02f,
  3.37669551e-02f, -3.60246934e-02f, -5.58839366e-02f, 8.30485150e-02f, -8.25211108e-02f, 7.96229988e-02f, -4.78240959e-02f, 7.43690804e-02f, -4.24483642e-02f, 1.72488485e-02f,
  6.83603361e-02f, 2.67667347e-03f, 7.01278076e-02f, 3.09175197e-02f, -3.21439654e-02f, 1.45505685e-02f, 5.09096831e-02f, -1.95291750e-02f, 1.11728646e-02f, 5.53881750e-02f,
  1.94172841e-02f, 1.56927481e-02f, 3.76985967e-02f, -8.63325447e-02f, 2.49214992e-02f, 1.98376309e-02f, 5.25033893e-03f, 6.08844757e-02f, 7.53354505e-02f, -1.35941599e-02f,
  -9.95187685e-02f, 5.23874126e-02f, -3.44488360e-02f, -1.05701372e-01f, 4.52510901e-02f, 4.49415408e-02f, -4.40144055e-02f, -4.66155121e-03f, -9.69169810e-02f, -2.57912762e-02f,
  3.50201912e-02f, -1.32885128e-01f, -3.01605761e-02f, -1.37007877e-01f, -2.01014742e-01f, -9.84228402e-02f, -1.66483656e-01f, -1.50013342e-01f, -8.02497715e-02f, 2.58619525e-02f,
  -7.29553178e-02f, -4.57639173e-02f, 2.69276332e-02f, 1.51693195e-01f, -1.94902252e-02f, -2.25019194e-02f, 8.56992975e-02f, 1.66386306e-01f, -5.15621156e-03f, -5.53150587e-02f,
  -2.86886636e-02f, -7.79927075e-02f, -3.97033244e-02f, -3.79785113e-02f, -8.66737366e-02f, -2.40210909e-02f, -7.68663734e-02f, -1.33545436e-02f, 1.00196479e-02f, 2.40489356e-02f,
  -3.50898802e-02f, -4.45413329e-02f, 1.63895544e-02f, 3.57943065e-02f, -4.38145474e-02f, -7.53253922e-02f, 5.24011813e-02f, -4.71033268e-02f, -2.17745826e-02f, 2.57248320e-02f,
  -1.54206101e-02f, 2.34296024e-02f, 3.11118979e-02f, 7.49419490e-03f, -2.01266054e-02f, -5.08189835e-02f, -5.29387891e-02f, -5.72274774e-02f, -7.29741678e-02f, -6.26758859e-02f,
  -3.06036230e-02f, -4.00751382e-02f, -1.08525250e-02f, -1.45700071e-02f, -1.55406864e-02f, 1.28030693e-02f, -4.31092530e-02f, -7.30841905e-02f, 7.71566778e-02f, 1.69582702e-02f,
  -2.10356396e-02f, -7.25819618e-02f, 3.31194550e-02f, -4.90469672e-02f, 3.77343409e-03f, 6.18306883e-02f, 4.01691496e-02f, -2.24291887e-02f, -9.42700878e-02f, -1.69673450e-02f,
  5.93926273e-02f, 5.19556329e-02f, -5.00414744e-02f, -6.04990497e-02f, 7.62402415e-02f, -1.98490489e-02f, -5.74425012e-02f, 4.24413644e-02f, 7.13954046e-02f, -4.48597930e-02f,
  2.39633825e-02f, 1.36683881e-02f, 5.67968190e-02f, 2.49182433e-02f, 6.79536909e-02f, 3.66448648e-02f, 3.92377153e-02f, 4.27126437e-02f, -6.26583993e-02f, -5.52373640e-02f,
  5.00991382e-02f, -3.46697196e-02f, -5.09444997e-02f, -4.70151789e-02f, -2.19087340e-02f, -2.96078133e-03f, -1.56337097e-02f, 9.44053307e-02f, -2.03841627e-02f, -8.11229870e-02f,
  -4.12948951e-02f, 5.12918048e-02f, -6.32608160e-02f, -6.14556968e-02f, -8.90250951e-02f, -5.35542890e-03f, 5.21196239e-02f, 5.83596937e-02f, 3.06111090e-02f, -3.38893607e-02f,
  1.68592602e-01f, -1.05483964e-01f, 4.80663143e-02f, -3.57320122e-02f, -4.21845959e-03f, 3.17499973e-02f, 1.43254951e-01f, -1.93591475e-01f, -1.95300832e-01f, -1.52757078e-01f,
  -8.53351429e-02f, 6.80093244e-02f, 1.16600744e-01f, 9.20029264e-03f, 1.40251085e-01f, -2.56109219e-02f, 2.70819347e-02f, 1.07880617e-02f, -9.64669511e-02f, -4.42059189e-02f,
  -8.87209624e-02f, 6.02827929e-02f, 1.10659584e-01f, -6.67392695e-03f, -3.81192341e-02f, -8.63286257e-02f, -4.08626497e-02f, 1.25638276e-01f, -6.49119988e-02f, 5.35338297e-02f,
  6.16458897e-03f, -1.70617662e-02f, -2.21601631e-02f, -3.31648858e-03f, -6.92212284e-02f, 9.69827771e-02f, 1.32907227e-01f, 4.44062101e-03f, 7.49803483e-02f, 4.03242819e-02f,
  -5.73250465e-02f, 3.88782807e-02f, -1.05803922e-01f, 9.38205793e-02f, -8.52373689e-02f, -3.38178687e-02f, -4.73805219e-02f, 7.19931647e-02f, -1.79244217e-03f, -1.42644327e-02f,
  7.10849687e-02f, -1.58977155e-02f, 5.17187975e-02f, 2.38573682e-02f, 5.26506528e-02f, 7.57889897e-02f, 4.78765219e-02f, 3.17389257e-02f, 3.46956365e-02f, -4.39490676e-02f,
  7.69943148e-02f, 4.21867445e-02f, 7.42565375e-03f, -2.93768700e-02f, -5.64799421e-02f, -3.33134793e-02f, -8.56775045e-02f, 6.77092895e-02f, 7.58728525e-03f, -4.09749672e-02f,
  3.01837525e-03f, 1.11451991e-01f, -4.92500737e-02f, 9.55493227e-02f, -8.64514709e-02f, -7.65672252e-02f, 8.79939720e-02f, -8.75418931e-02f, 8.03318545e-02f, -2.92733056e-03f,
  -2.14004908e-02f, 4.25429083e-02f, 2.88704336e-02f, -4.96538393e-02f, 2.47424450e-02f, -2.78711785e-02f, -9.03359950e-02f, 2.84335706e-02f, 1.78903732e-02f, 9.43106711e-02f,
  -6.91740066e-02f, -9.98497829e-02f, 1.57990828e-02f, 1.57288313e-02f, 7.87499622e-02f, 3.53663564e-02f, -4.91504595e-02f, 5.72770312e-02f, 1.53175537e-02f, 6.28449097e-02f,
  3.13577130e-02f, 2.48521939e-02f, -2.06911676e-02f, 7.66248927e-02f, 7.46151432e-02f, 4.20977473e-02f, 4.17129360e-02f, -5.76869771e-03f, 2.43294309e-03f, 1.37309683e-02f,
  5.82477860e-02f, 4.80413213e-02f, -3.00403847e-03f, -2.52316799e-02f, -7.04075620e-02f, -2.49027591e-02f, 4.68032929e-04f, -5.43737933e-02f, 4.79474664e-02f, 5.61840311e-02f,
  3.06010675e-02f, 1.12161105e-02f, 9.11523253e-02f, -2.59365048e-02f, 7.08628148e-02f, 6.72018901e-02f, -5.14694899e-02f, -1.36626447e-02f, 1.76953338e-02f, 8.23724642e-02f,
  -3.59212011e-02f, -2.66486430e-03f, -1.01862513e-01f, -3.36294137e-02f, -1.49612114e-01f, -2.53074821e-02f, -1.19850598e-01f, -2.65715253e-02f, 3.89405340e-02f, 8.43422785e-02f,
  -9.99726430e-02f, 4.60968958e-03f, -2.85985600e-02f, -1.37806525e-02f, 1.59202814e-02f, 4.16105390e-02f, -2.26685200e-02f, 4.01718728e-02f, 3.82741652e-02f, -1.64246801e-02f,
  -7.69272298e-02f, 3.61295901e-02f, 8.59171823e-02f, 5.89165464e-02f, -4.74183597e-02f, 2.65829954e-02f, 8.57546832e-03f, -1.54301515e-02f, 4.92014270e-03f, -1.46201458e-02f,
  -5.26831392e-03f, -9.57530588e-02f, -6.52265847e-02f, 9.86122862e-02f, 5.68429530e-02f, 7.69682229e-02f, 3.25795040e-02f, -5.15498891e-02f, -5.04937656e-02f, -1.54518830e-02f,
  3.64625305e-02f, 8.14139247e-02f, -8.86535123e-02f, -7.40958471e-03f, 2.12590173e-02f, 8.85291845e-02f, 8.29607900e-03f, 1.14967478e-02f, -7.27636646e-03f, -2.42814496e-02f,
  -1.01253681e-01f, 3.69275734e-02f, -8.17200765e-02f, -3.42142880e-02f, -5.38200736e-02f, 8.93877968e-02f, 7.07211643e-02f, 4.40708585e-02f, 5.60396723e-02f, 8.46398622e-02f,
  6.23437390e-02f, -1.24530811e-02f, -7.95264021e-02f, 2.60948185e-02f, -5.02839349e-02f, 1.52214337e-02f, 1.95379481e-02f, -4.40995060e-02f, -7.43021891e-02f, -5.65715367e-03f,
  -3.14291264e-03f, 5.30227944e-02f, -1.65790245e-02f, 6.35456666e-02f, 9.37106460e-02f, -4.28303666e-02f, -2.75627933e-02f, -2.18120813e-02f, -7.50661567e-02f, -4.95479777e-02f,
  -1.47812543e-02f, 1.90197898e-03f, 7.44602680e-02f, -7.97402672e-03f, -1.38653638e-02f, 7.92387500e-02f, -1.26801375e-02f, -7.41020739e-02f, 3.16044986e-02f, -1.39636351e-02f,
  6.27744943e-02f, 3.35570090e-02f, -6.65381178e-02f, -4.27638404e-02f, 6.21363986e-03f, 9.06540360e-03f, -3.27416211e-02f, -2.08788011e-02f, 2.00987048e-02f, -3.62935774e-02f,
  -1.15549117e-02f, 4.60865088e-02f, 6.19644634e-02f, 8.22645053e-02f, -4.38957699e-02f, 9.91157964e-02f, -1.84798688e-02f, -3.56851742e-02f, 1.68019105e-02f, -4.11699191e-02f,
  -2.48343707e-03f, -1.10558882e-01f, -2.57116079e-01f, -1.13314644e-01f, -1.40222877e-01f, -2.72781193e-01f, -1.61093429e-01f, -1.33455560e-01f, 1.27923014e-02f, 1.88363135e-01f,
  6.91082850e-02f, -7.66581446e-02f, 2.12569147e-01f, 4.00141291e-02f, -9.66777951e-02f, 2.31042132e-01f, -2.57867277e-02f, 8.70229155e-02f, 4.59315777e-02f, -9.96126905e-02f,
  -4.17777449e-02f, 1.21039748e-02f, 9.17433202e-02f, -3.84936668e-02f, -1.22822203e-01f, -4.91102180e-03f, 6.49039820e-02f, -8.76002312e-02f, 5.84950000e-02f, 2.04405468e-02f,
  5.97059121e-03f, 7.00978339e-02f, -1.13791779e-01f, 5.70907183e-02f, 7.04152742e-03f, -5.92177548e-02f, -9.62974131e-02f, 2.38912855e-03f, 7.89249688e-02f, -7.26296231e-02f,
  -4.95147593e-02f, -2.87202187e-03f, -7.21623749e-02f, 5.94801828e-02f, 1.38754556e-02f, -1.15594506e-01f, 5.02340496e-03f, 3.91797759e-02f, 2.50029960e-03f, 6.59404248e-02f,
  9.99953412e-03f, -6.19567521e-02f, 3.32431421e-02f, 2.05569975e-02f, 2.36440916e-02f, 2.44564079e-02f, 5.95900938e-02f, -5.84472828e-02f, -1.97960418e-02f, -9.11041722e-03f,
  6.67983666e-02f, -5.11362590e-02f, -5.82475886e-02f, -9.06953439e-02f, 7.86813125e-02f, 8.78429785e-03f, 5.20154424e-02f, 2.06227321e-02f, 6.82104798e-03f, 7.94340745e-02f,
  -5.54355979e-02f, 8.01915582e-03f, 7.63033405e-02f, 4.09301370e-02f, -6.71886653e-02f, 4.98193763e-02f, -1.33424569e-02f, -3.41423936e-02f, -2.14771498e-02f, 4.13917452e-02f,
  3.08212806e-02f, -4.05130461e-02f, 5.25756925e-02f, -4.97551672e-02f, -7.52754835e-03f, 8.63094777e-02f, 9.12552997e-02f, 6.43777400e-02f, 3.69981378e-02f, -6.69066906e-02f,
  -6.21061511e-02f, -7.56366774e-02f, -4.86288853e-02f, -4.27942909e-02f, -5.31315198e-03f, -4.89467382e-02f, 3.26341391e-02f, -6.52095154e-02f, -7.16695841e-03f, 2.33549699e-02f,
  -2.13453695e-02f, -5.54425940e-02f, -5.53904660e-02f, 6.44353256e-02f, -4.88901958e-02f, -5.47493286e-02f, 1.37251522e-02f, -4.64207083e-02f, 3.35330144e-03f, -9.52790305e-02f,
  -6.12104312e-02f, -1.45334424e-03f, 1.88023262e-02f, 1.04823954e-01f, -7.31623322e-02f, 3.44145522e-02f, -4.10545580e-02f, 4.14021462e-02f, -3.24604921e-02f, -5.44775352e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.80361643e-01f, 2.50930160e-01f, 1.58848509e-01f, 1.35240078e-01f, 6.02786727e-02f, 3.71593307e-03f, 5.50423563e-02f, 1.38948083e-01f, 4.33306172e-02f, 7.30015934e-02f,
  1.23093314e-01f, 2.07597852e-01f, 1.06366612e-01f, -1.98101457e-02f, 1.27556413e-01f, -2.24768519e-02f, 1.32055461e-01f, 7.33254477e-02f, 1.90070584e-01f, 1.58108249e-02f,
  3.24078873e-02f, 1.98638543e-01f, 1.43728882e-01f, 1.59306433e-02f, 8.86009708e-02f, 1.27463102e-01f, 2.51351157e-03f, -4.01098169e-02f, 1.12976976e-01f, 6.56575039e-02f,
  1.43026307e-01f, 7.45435879e-02f, 3.28488015e-02f, 1.99906409e-01f, -1.82819311e-02f, -4.61838767e-02f, 5.25499955e-02f, -5.90209197e-03f, -3.84482816e-02f, 5.62857725e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.49983950e-02f, -4.32423353e-02f, -4.49898094e-02f, -4.17744890e-02f, 1.80109963e-02f, 9.96826813e-02f, -8.80571082e-02f, 9.06512439e-02f, -8.85382593e-02f, 2.57880669e-02f,
  -9.56091937e-03f, 1.27104044e-01f, -7.42876381e-02f, -1.26291826e-01f, 1.19830668e-01f, 1.65345639e-01f, 1.17560856e-01f, -7.53619596e-02f, -1.30934194e-01f, 1.77102655e-01f,
  1.42172918e-01f, 1.14658609e-01f, -9.34472866e-03f, 7.60079399e-02f, 1.11446634e-01f, 1.33607343e-01f, -1.52499363e-01f, -3.75468582e-02f, -9.15014744e-02f, 4.73924875e-02f,
  4.17801775e-02f, -3.95413674e-02f, -1.10388540e-01f, 2.32843403e-02f, 5.65077104e-02f, 7.65654491e-04f, -9.35240164e-02f, -1.11634918e-01f, -1.44527614e-01f, 9.65732560e-02f,
  9.10429843e-03f, 1.68967724e-01f, -6.65711910e-02f, -4.29940373e-02f, -1.35794118e-01f, -1.20832637e-01f, -7.28640892e-03f, -4.02024351e-02f, -3.27100605e-02f, 7.12261498e-02f,
  1.00416973e-01f, -3.37653048e-02f, 1.61063328e-01f, -7.90544376e-02f, 3.35001275e-02f, -5.51697724e-02f, 5.55053279e-02f, 5.89754954e-02f, -8.76668692e-02f, 9.44053531e-02f,
  8.64754170e-02f, -1.47805884e-01f, 8.33685100e-02f, -6.08051792e-02f, 1.07483506e-01f, 1.93302616e-01f, 1.09763267e-02f, 1.07953861e-01f, 7.11079091e-02f, 8.63504782e-02f,
  1.34573817e-01f, 1.16377706e-02f, -1.76805019e-01f, 1.05555423e-01f, 3.18229795e-02f, 3.99168395e-02f, -1.34801269e-01f, -1.18395075e-01f, 7.54606947e-02f, -1.73276395e-01f,
  -3.13857198e-01f, -1.77116260e-01f, 1.18647881e-01f, 2.33931132e-02f, -2.02549994e-01f, -1.05253763e-01f, 6.54544905e-02f, 1.12860454e-02f, -5.84717840e-02f, -1.14690781e-01f,
  -1.45171538e-01f, 7.03113973e-02f, -9.60424542e-02f, -1.89849839e-01f, -5.72349541e-02f, -1.06358320e-01f, 1.16275713e-01f, 6.22135438e-02f, 1.03430785e-01f, 1.43089578e-01f,
  1.18021473e-01f, 9.60432645e-03f, -6.22379817e-02f, 1.24508128e-01f, 1.41811965e-04f, -1.13377884e-01f, 1.35814965e-01f, -1.27177984e-01f, -8.78512207e-03f, -3.55904549e-02f,
  1.11921348e-01f, 3.31130773e-02f, 1.25295863e-01f, 2.06787176e-02f, -8.72136354e-02f, -8.86421502e-02f, -1.04342215e-01f, -9.26782042e-02f, -1.05396770e-01f, -1.22189485e-01f,
  1.15090318e-01f, -3.03383474e-03f, -1.02812164e-02f, 4.30412218e-02f, -5.04872166e-02f, 2.11514026e-01f, 9.87222344e-02f, -1.67264745e-01f, 7.94555843e-02f, 1.33150239e-02f,
  -5.76752648e-02f, 1.45733774e-01f, 7.50978813e-02f, 1.11271843e-01f, -1.01355106e-01f, 1.07249180e-02f, -1.23243347e-01f, 8.60506520e-02f, 1.54440096e-02f, 6.79365247e-02f,
  -6.30965307e-02f, -2.86991477e-01f, 2.22083494e-01f, -2.75795162e-03f, -2.38831803e-01f, -2.18530729e-01f, 1.26503870e-01f, -1.16238855e-01f, -7.93456733e-02f, -1.64164647e-01f,
  1.80280715e-01f, 1.96867809e-01f, 3.67952064e-02f, 1.52794510e-01f, 8.67268890e-02f, 1.53059689e-02f, -2.95735728e-02f, -2.01324284e-01f, -1.93705335e-02f, 1.54677913e-01f,
  1.03393309e-01f, 8.90747383e-02f, -3.07598617e-02f, -1.08070560e-02f, -1.31389529e-01f, -1.49049815e-02f, 1.56277679e-02f, 9.51940566e-02f, 1.73582271e-01f, -2.99807801e-03f,
  -7.35426648e-03f, -1.87014088e-01f, -3.46073397e-02f, -3.16471979e-03f, 1.77838326e-01f, -1.49914222e-02f, 1.34747148e-01f, 7.34619349e-02f, -1.70999244e-01f, -6.44929335e-02f,
  1.54876113e-02f, 1.45932540e-01f, 6.95163310e-02f, 1.87980048e-02f, -2.51709223e-02f, 3.82936709e-02f, -9.42765698e-02f, -1.02358554e-02f, -1.33008957e-01f, 1.15150839e-01f,
  5.30456193e-03f, -1.31679624e-01f, -4.21796963e-02f, 1.15899280e-01f, 1.59616992e-01f, -8.40654746e-02f, 2.83306818e-02f, -5.78741543e-02f, -3.33390161e-02f, 5.36051691e-02f,
  -9.95068625e-02f, -3.21837366e-02f, -6.78515062e-02f, 9.71583650e-03f, -1.95118755e-01f, 2.57961184e-01f, -1.09090723e-01f, 1.52913094e-01f, -1.05193682e-01f, 7.18179643e-02f,
  -7.77747110e-02f, -9.43072513e-02f, -2.43723556e-01f, 1.15990892e-01f, 2.61101902e-01f, 1.96863756e-01f, -5.63894510e-02f, -4.90963235e-02f, -1.94528729e-01f, 1.90582983e-02f,
  1.32486165e-01f, -1.59216508e-01f, -8.52387249e-02f, 1.25829596e-02f, -1.78894535e-01f, -2.98000630e-02f, 6.86902320e-03f, -8.13861489e-02f, 8.35801288e-02f, 5.59522174e-02f,
  3.87975462e-02f, 7.78851360e-02f, 2.27617882e-02f, -1.58120573e-01f, -1.82959363e-01f, -1.31882206e-01f, 4.38347906e-02f, -4.28873859e-02f, -2.11733446e-01f, -1.04649648e-01f,
  8.74215364e-02f, -4.71075177e-02f, 4.05789465e-02f, -9.15237516e-02f, 1.27519175e-01f, 1.08714886e-01f, -1.14387140e-01f, 5.26642352e-02f, -9.03291628e-02f, 1.15649752e-01f,
  -1.50800675e-01f, 9.03456360e-02f, -3.96041349e-02f, 1.21303231e-01f, 2.14916561e-02f, 8.16159174e-02f, -1.17037304e-01f, -1.00248694e-01f, -1.45727649e-01f, 1.21245541e-01f,
  1.42539134e-02f, 1.27625212e-01f, 1.12838615e-02f, 1.07688755e-01f, -1.76429138e-01f, -3.24559249e-02f, -1.31782725e-01f, 4.87702750e-02f, -6.08562529e-02f, -2.33969162e-03f,
  1.76651925e-01f, -1.22549661e-01f, -7.30357692e-02f, -2.04897150e-01f, 1.66694835e-01f, -8.91422033e-02f, -5.41995130e-02f, -2.01435626e-01f, -2.73727365e-02f, 1.85433701e-01f,
  7.69622102e-02f, 7.20205083e-02f, 1.95334002e-01f, 3.89029048e-02f, -2.07323760e-01f, 7.92013034e-02f, 1.04283296e-01f, 7.05684349e-02f, 1.49084270e-01f, 1.02049984e-01f,
  6.70136213e-02f, -6.38345256e-02f, 7.03861937e-02f, 4.57507782e-02f, -1.08239651e-01f, -5.39959967e-02f, -7.24146217e-02f, -1.70907602e-01f, 3.50868069e-02f, 4.33440022e-02f,
  9.30256546e-02f, 9.90727693e-02f, 1.33491933e-01f, 3.31367250e-03f, -1.11583062e-01f, -5.38923256e-02f, -7.27886781e-02f, -1.37811508e-02f, -1.94103509e-01f, 1.18258432e-01f,
  -3.57254874e-03f, -1.92643121e-01f, -6.57796785e-02f, 1.03527732e-01f, 1.53929949e-01f, -6.50811642e-02f, 2.97866948e-02f, 2.92705297e-02f, -9.21868812e-03f, 7.52108619e-02f,
  -3.98080610e-02f, 1.91976763e-02f, 2.04707175e-01f, -9.44650620e-02f, -8.48614350e-02f, -1.11142382e-01f, -8.53359550e-02f, 8.52741580e-03f, 1.95152432e-01f, -5.30360825e-02f,
  -1.11540280e-01f, 9.68760625e-03f, -1.07682817e-01f, 3.13148707e-01f, 6.21828400e-02f, 7.84465969e-02f, 3.33803147e-03f, 2.28842065e-01f, 4.15211497e-03f, 2.08623504e-04f,
  -2.74425775e-01f, -6.26898631e-02f, 5.58341742e-02f, 9.51133296e-02f, 7.43457377e-02f, -2.40564078e-01f, 1.15916111e-01f, 1.80076748e-01f, 5.08706570e-02f, 9.80053023e-02f,
  2.16384511e-02f, -8.55054930e-02f, 1.03925958e-01f, 6.42369464e-02f, -4.81345691e-02f, -1.93335444e-01f, 7.78840482e-03f, 2.22412124e-01f, 2.57738262e-01f, -1.46266036e-02f,
  -1.55811861e-01f, -6.46936148e-02f, -1.28373861e-01f, -1.30235460e-02f, 9.83696505e-02f, 3.04295458e-02f, -1.45682618e-01f, -2.37450204e-05f, 7.70506933e-02f, -3.74187902e-02f,
  -1.62261613e-02f, 7.79466704e-02f, 1.34275198e-01f, -8.97887722e-02f, -1.25903800e-01f, 7.89125636e-02f, -6.84019402e-02f, 1.29242823e-01f, 4.17691693e-02f, -9.87830311e-02f,
  -5.97655065e-02f, 9.47376937e-02f, -6.01422414e-02f, 1.42547294e-01f, 8.55708774e-03f, -2.88707446e-02f, 2.06557661e-02f, 1.00150272e-01f, 3.01998807e-03f, -5.78073524e-02f,
  3.17231864e-02f, 8.07695314e-02f, 3.68931070e-02f, 6.25697002e-02f, -1.11669153e-01f, 5.94474189e-02f, 1.02392025e-01f, -1.43374681e-01f, 1.27710700e-01f, 3.56360786e-02f,
  -1.59181625e-01f, -1.30331435e-03f, 1.08619042e-01f, -2.46653393e-01f, -1.17544174e-01f, 1.18117400e-01f, 1.55938402e-01f, 8.69417563e-02f, -1.71379596e-02f, -1.14732563e-01f,
  1.52000546e-01f, 1.55189589e-01f, 9.00242850e-02f, 8.17320347e-02f, -1.01292886e-01f, 1.35567501e-01f, 5.97751103e-02f, 1.33962303e-01f, -7.10416511e-02f, -5.04348055e-02f,
  5.69488667e-02f, -6.40329793e-02f, 1.70936361e-01f, -3.81464809e-02f, 9.75305513e-02f, -1.54617801e-01f, 7.17868954e-02f, -8.08194354e-02f, 1.28578067e-01f, 1.41368985e-01f,
  9.98384133e-02f, -1.17546864e-01f, 1.77246019e-01f, -8.99085999e-02f, -7.24792704e-02f, 9.15996060e-02f, 8.77107456e-02f, 1.00662507e-01f, 7.92192016e-03f, 2.21527535e-02f,
  -8.62089097e-02f, -1.20907724e-01f, 1.46278024e-01f, -8.46938118e-02f, -7.57684633e-02f, -7.11722970e-02f, -1.31106511e-01f, 8.10550600e-02f, -6.90473095e-02f, 6.07529692e-02f,
  -1.51805848e-01f, -4.18006331e-02f, -1.46358043e-01f, -4.82922941e-02f, -1.36158705e-01f, -8.19162130e-02f, 1.01044200e-01f, 1.49823308e-01f, -3.25306989e-02f, -8.91656727e-02f,
  -1.43281817e-02f, 1.40852407e-01f, -1.52012169e-01f, 2.44716685e-02f, 2.23913100e-02f, 6.14502802e-02f, -5.26432917e-02f, 1.23543680e-01f, 2.92642295e-01f, 1.37478158e-01f,
  1.50558427e-02f, 1.30033493e-03f, -7.58224074e-03f, 1.36641949e-01f, -1.24822281e-01f, 1.34739596e-02f, 6.13788478e-02f, 4.53814827e-02f, 1.08530208e-01f, -1.74714819e-01f,
  -1.16797179e-01f, -1.34879515e-01f, -4.04589698e-02f, 7.77433962e-02f, 1.07449688e-01f, -1.47427589e-01f, -5.95125891e-02f, -1.50481109e-02f, 2.14646310e-02f, 1.49739295e-01f,
  -1.57990307e-01f, -2.47610137e-02f, 2.22503971e-02f, -8.85451958e-02f, 7.77550340e-02f, -2.65919622e-02f, -1.02813847e-01f, -5.31014875e-02f, 1.55590102e-01f, 3.18673477e-02f,
  -8.39450508e-02f, -3.92370932e-02f, 1.22990012e-01f, -8.86289030e-03f, 9.20591429e-02f, -1.19830407e-01f, -1.35572791e-01f, -1.76495090e-02f, 1.92815922e-02f, 6.68712482e-02f,
  9.20596197e-02f, -5.85035570e-02f, -1.16191946e-01f, -8.19908902e-02f, -1.37100503e-01f, 6.64422736e-02f, -1.63352694e-02f, -9.72434506e-02f, 4.74497266e-02f, -1.07110329e-01f,
  -1.73642226e-02f, 1.48475349e-01f, 1.09864928e-01f, 1.02211908e-01f, -8.45084339e-02f, -1.35654226e-01f, 6.83308160e-03f, 2.97580212e-02f, -1.35858595e-01f, 2.67773494e-02f,
  4.66900691e-02f, 1.75682157e-01f, 2.01303348e-01f, -2.86743566e-02f, -1.30958036e-01f, -2.74137467e-01f, -8.89142677e-02f, -4.68117893e-02f, -2.36573130e-01f, 7.64713362e-02f,
  -5.07479385e-02f, 5.56217805e-02f, -1.03248209e-01f, -1.46465182e-01f, 4.20430079e-02f, -1.99473128e-02f, -2.15565264e-02f, 4.32821165e-04f, -5.35905510e-02f, 7.20806122e-02f,
  4.49463073e-03f, -1.26148248e-02f, -1.40714645e-01f, 1.45682558e-01f, 1.39392421e-01f, -1.38392344e-01f, 1.10580526e-01f, 5.15392944e-02f, 4.96923290e-02f, -2.33866423e-02f,
  6.96917400e-02f, -5.77723347e-02f, -2.74219997e-02f, 2.27136798e-02f, 7.63774067e-02f, -1.30492344e-01f, 3.72811481e-02f, 1.46556068e-02f, 1.63463414e-01f, -1.69016436e-01f,
  -8.97533223e-02f, -1.14198193e-01f, 1.62603721e-01f, 9.51223373e-02f, 2.26829536e-02f, -1.89976156e-01f, -1.29761189e-01f, 6.53281286e-02f, -1.69381559e-01f, 1.72640625e-02f,
  -1.98156178e-01f, -1.16913244e-01f, -1.40874743e-01f, -4.71675806e-02f, -1.70670934e-02f, -1.35409966e-01f, 3.40878516e-02f, -1.19860336e-01f, -1.69055417e-01f, 7.91905001e-02f,
  1.96859241e-01f, 1.60533011e-01f, -3.38589288e-02f, -1.23674370e-01f, 4.91772629e-02f, 2.15023488e-01f, 9.22881365e-02f, -7.36718476e-02f, -1.16074070e-01f, -3.47884744e-02f,
  1.19831534e-02f, 1.11378953e-01f, 1.33093357e-01f, -5.52576855e-02f, -8.18820223e-02f, -8.11734572e-02f, 6.16945000e-03f, 3.02382912e-02f, -7.05644786e-02f, 4.96608093e-02f,
  7.95165673e-02f, -9.89641398e-02f, -6.33601770e-02f, 2.19376013e-02f, -3.36931869e-02f, -1.51018515e-01f, -2.55581504e-03f, -1.42554402e-01f, 1.59510076e-01f, 1.10509172e-01f,
  -4.23849411e-02f, -1.73999935e-01f, 1.35490775e-01f, 8.02303404e-02f, 6.89302664e-03f, -7.98583180e-02f, -6.47765696e-02f, -2.52090637e-02f, -3.59610021e-02f, 4.59423885e-02f,
  -1.80757970e-01f, 6.91890195e-02f, -2.86297370e-02f, 1.47077918e-01f, -9.45881382e-03f, -1.20428037e-02f, 1.24261132e-03f, 6.39792830e-02f, 4.13107760e-02f, 4.62117866e-02f,
  -1.54525444e-01f, 7.14629516e-02f, -1.34857535e-01f, 2.19578445e-02f, 7.62999728e-02f, -2.31232867e-02f, -7.74550289e-02f, -8.16306397e-02f, -1.93655923e-01f, -1.59947187e-01f,
  -7.83034340e-02f, -5.47732860e-02f, -8.50286931e-02f, -3.46834481e-01f, 2.48869166e-01f, -8.10970739e-02f, -2.10808530e-01f, -2.30971247e-01f, 2.19205305e-01f, -1.14067785e-01f,
  -3.79987657e-02f, -4.84031811e-02f, 4.92075738e-03f, 6.28081034e-04f, 7.56004378e-02f, 1.27083182e-01f, 8.75401571e-02f, -2.73486623e-03f, -4.05821688e-02f, -1.19929044e-02f,
  -1.48882866e-01f, 2.17328489e-01f, 1.19367138e-01f, 5.88786677e-02f, 3.34488577e-03f, 9.07333046e-02f, -1.83765411e-01f, -5.85554130e-02f, -2.25046843e-01f, 3.99948992e-02f,
  1.02550946e-01f, -8.59368443e-02f, 2.13620916e-01f, -2.14810520e-01f, 9.27616954e-02f, 9.38870758e-02f, 1.81570202e-01f, -1.19219631e-01f, 8.39257166e-02f, -9.16789025e-02f,
  -9.11823288e-02f, -5.60517497e-02f, -2.15048008e-02f, 1.66248709e-01f, 8.01985115e-02f, 3.29966955e-02f, 1.21117055e-01f, 7.34982565e-02f, 2.96773762e-03f, -9.01714638e-02f,
  -1.70775130e-01f, -7.66815525e-03f, -1.23502038e-01f, 2.04932038e-02f, 1.25389427e-01f, 7.39091635e-02f, -9.73346680e-02f, 5.77085018e-02f, -1.58732831e-01f, 4.92448919e-02f,
  4.52134944e-02f, 4.43596654e-02f, -9.59937200e-02f, 8.85090530e-02f, 4.77441587e-02f, 1.20669961e-01f, -6.12187870e-02f, -3.70676140e-03f, -9.01457146e-02f, 5.15028797e-02f,
  1.64861470e-01f, -2.05661595e-01f, 1.27482861e-01f, 4.07902785e-02f, 2.69965768e-01f, 6.51384145e-02f, 2.55184826e-02f, -4.98533957e-02f, -4.33696713e-03f, 1.56542987e-01f,
  7.93023631e-02f, 5.74247129e-02f, -1.06530115e-02f, 5.34006543e-02f, 6.65563941e-02f, 2.24323440e-02f, 8.72227401e-02f, -1.01862095e-01f, -8.96974951e-02f, 1.91872612e-01f,
  -4.27934900e-02f, 8.51236954e-02f, -4.96212542e-02f, -1.20413989e-01f, 1.48377037e-02f, 1.20461069e-01f, 1.54850766e-01f, 1.85295343e-01f, -3.56291309e-02f, 8.53784680e-02f,
  1.29824057e-01f, 6.02230690e-02f, 8.91495720e-02f, -1.00089826e-01f, 7.21063465e-02f, -3.41723375e-02f, 9.81126800e-02f, 2.81430632e-02f, 6.08285554e-02f, -1.32966012e-01f,
  1.16977744e-01f, -3.24636921e-02f, -1.04069807e-01f, 1.44996075e-02f, 5.27001433e-02f, -1.26739994e-01f, 3.80159989e-02f, 7.19724745e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.07140795e-03f, 1.10982627e-01f, -1.08866163e-01f, 1.57626808e-01f, -4.14951220e-02f, 8.54002894e-04f, 1.19781166e-01f, 3.92688178e-02f, -1.23398483e-01f, -1.49693713e-02f,
  1.17306948e-01f, -2.23844149e-03f, -7.60485604e-02f, -7.16421604e-02f, 1.92095757e-01f, -1.10981479e-01f, -1.84017092e-01f, -5.32132201e-03f, 5.15089259e-02f, -3.74467373e-02f,
  1.16704158e-01f, -1.21888570e-01f, 6.94686547e-02f, 9.05661434e-02f, 9.50554907e-02f, -4.74159680e-02f, 7.08355531e-02f, -5.08009382e-02f, -2.55243964e-02f, 1.72121786e-02f,
  1.15798995e-01f, -6.29822165e-02f, 3.96062657e-02f, 8.56676325e-02f, -1.52636506e-03f, -1.14907935e-01f, -5.58354147e-02f, -2.84121335e-02f, -6.25155447e-03f, -1.31633796e-03f,
  6.48110658e-02f, -1.10745296e-01f, 1.90284535e-01f, 1.74762160e-02f, -9.92758125e-02f, 9.13933218e-02f, 1.84810951e-01f, -1.12233877e-01f, 8.72841701e-02f, -9.05008540e-02f,
  -3.87238115e-02f, -2.67671589e-02f, -7.66872019e-02f, 1.40191987e-01f, 1.02074504e-01f, 7.93843865e-02f, 7.68394172e-02f, 5.34902178e-02f, -3.62225696e-02f, 1.02241777e-01f,
  1.03058539e-01f, 1.23504326e-01f, -1.07576840e-01f, -4.61865626e-02f, 1.41320378e-01f, 7.58366287e-02f, -2.11665537e-02f, 1.76047012e-01f, 1.57154635e-01f, 1.25364646e-01f,
  1.70822572e-02f, -8.66439342e-02f, 2.70154122e-02f, -7.00367242e-02f, 8.86223912e-02f, 1.24379650e-01f, 1.42387534e-02f, -1.52660593e-01f, 1.62706181e-01f, -9.14289802e-02f,
  5.56427576e-02f, -1.96581662e-01f, -1.58782471e-02f, -1.53390229e-01f, 2.74125822e-02f, 1.67029980e-03f, 9.09837708e-02f, -7.16545507e-02f, -5.90214767e-02f, 2.16359958e-01f,
  -1.54222688e-02f, -5.69582768e-02f, -6.92956075e-02f, 3.61656607e-03f, 2.82038804e-02f, 1.15420945e-01f, 1.70913618e-02f, 1.39121994e-01f, 3.65772322e-02f, 2.16326267e-01f,
  -1.49816096e-01f, -9.58420113e-02f, -1.86142668e-01f, 3.98396477e-02f, 7.77568296e-02f, -4.40954454e-02f, 1.52841017e-01f, -7.90596828e-02f, -7.51763806e-02f, 5.08489348e-02f,
  1.34609267e-01f, 7.11382106e-02f, 4.39542010e-02f, -2.08725724e-02f, -8.91759768e-02f, -1.11807898e-01f, -1.12985872e-01f, -2.15656962e-02f, 1.18795559e-01f, -9.84650776e-02f,
  8.93539786e-02f, -2.99378261e-02f, -1.22390836e-02f, -5.02011273e-03f, 3.71833779e-02f, -1.18787520e-01f, 1.15585811e-01f, -1.15445189e-01f, 2.10195273e-01f, -3.46845835e-02f,
  1.15923107e-01f, -8.59172344e-02f, 6.57149926e-02f, -1.36237174e-01f, 1.96147844e-01f, 2.03762576e-01f, 1.79129511e-01f, -1.58090040e-03f, -8.06964636e-02f, -2.58226823e-02f,
  -1.52116073e-02f, 1.36768296e-01f, -2.43202578e-02f, 2.63508588e-01f, 4.19033080e-01f, 3.87403811e-03f, -1.50312006e-01f, -1.10460803e-01f, 2.09784448e-01f, 1.76727518e-01f,
  -1.04253992e-01f, 2.34047443e-01f, 1.96248278e-01f, 9.42462757e-02f, 2.70556718e-01f, -8.20069462e-02f, 1.86472461e-01f, 2.79868335e-01f, -1.06594991e-02f, 2.20864266e-01f,
  -5.56314439e-02f, 4.63610925e-02f, 1.68314621e-01f, 1.00486793e-01f, 2.03269850e-02f, 1.44914255e-01f, 1.77118286e-01f, -8.41269195e-02f, 9.78973582e-02f, -1.07735703e-02f,
  4.86874804e-02f, 3.18517506e-01f, 1.07486248e-01f, -1.51574925e-01f, -1.61277831e-01f, -1.14723660e-01f, -9.06278789e-02f, 3.38972267e-03f, -1.04091084e-02f, 1.51657075e-01f,
  -6.58203010e-03f, 2.30731368e-01f, -9.12154019e-02f, 1.16908774e-02f, 8.33245963e-02f, 2.74152637e-01f, 7.97647312e-02f, -9.09590125e-02f, 9.31591764e-02f, -7.97723085e-02f,
  9.47966576e-02f, 3.12502742e-01f, 8.52645487e-02f, 1.09464593e-01f, 4.32446077e-02f, 2.81124085e-01f, 2.49871351e-02f, 1.30226701e-01f, 5.95486052e-02f, 4.21003141e-02f,
  -9.66886878e-02f, 1.08055294e-01f, 1.83666021e-01f, 8.58831704e-02f, -2.87972629e-01f, 1.49496093e-01f, 1.10057890e-01f, 3.44711766e-02f, 8.80892053e-02f, -1.68497264e-01f,
  2.86418269e-03f, 2.80469686e-01f, 3.70756179e-01f, -2.73636132e-01f, -9.56341624e-02f, 2.13375151e-01f, 2.45245323e-01f, 2.58572549e-01f, 2.61674970e-02f, 1.69176497e-02f,
  -1.61318541e-01f, -1.43638432e-01f, 2.91002572e-01f, 7.17502534e-02f, -2.25485694e-02f, 1.71084136e-01f, 2.98265368e-01f, 2.49666810e-01f, 8.92678723e-02f, -1.86815038e-02f,
  -8.28546137e-02f, 7.98270777e-02f, -8.47792849e-02f, -3.40359509e-02f, 1.60592258e-01f, 5.14323190e-02f, -5.96394390e-02f, -3.19828577e-02f, 2.48323843e-01f, 1.30743429e-01f,
  -1.23374820e-01f, 1.69582665e-01f, 5.14298938e-02f, -1.55954003e-01f, 1.32584825e-01f, -5.95720671e-02f, -2.13599727e-01f, -1.42730340e-01f, 5.24641909e-02f, 6.35282323e-02f,
  -1.43518195e-01f, -1.67926271e-02f, 2.05086440e-01f, -1.04497746e-01f, -8.57646018e-03f, -3.73621397e-02f, 1.20188378e-01f, 1.42631931e-02f, 6.24473952e-03f, 2.09412977e-01f,
  -5.39224111e-02f, 1.43621922e-01f, 2.03592684e-02f, 2.66137831e-02f, -8.56883973e-02f, 1.63619086e-01f, 1.95482716e-01f, 1.76459938e-01f, -3.25602368e-02f, -1.45904630e-01f,
  1.62642971e-02f, -7.05807582e-02f, 4.17660363e-02f, -1.13233879e-01f, -6.68687671e-02f, 1.73986152e-01f, 3.17873001e-01f, -1.60614029e-01f, -1.03273921e-01f, 1.83144927e-01f,
  1.29278243e-01f, 1.11159250e-01f, 7.94275925e-02f, -6.11710921e-02f, -1.30179346e-01f, -5.06769754e-02f, 2.40581453e-01f, 3.34442668e-02f, -1.25801638e-01f, 4.11092900e-02f,
  3.84168401e-02f, 7.39325210e-02f, -5.17279431e-02f, -1.31967142e-01f, 6.61198050e-02f, 1.72586199e-02f, -2.19263155e-02f, 1.02778159e-01f, -3.22488099e-02f, 1.43286765e-01f,
  1.86435487e-02f, 8.52195993e-02f, 9.04418752e-02f, 9.73442271e-02f, -1.54750198e-01f, 7.86506608e-02f, 8.79821926e-02f, -1.53253898e-01f, 8.12228546e-02f, 1.19847462e-01f,
  -7.08349347e-02f, -4.97854725e-02f, 4.01019398e-03f, 1.91819355e-01f, -2.50516646e-02f, 1.36606991e-01f, 1.52928695e-01f, -7.86782876e-02f, 3.96287302e-03f, -1.80367772e-02f,
  1.03280790e-01f, 1.86741541e-04f, 1.44944131e-01f, 5.24027348e-02f, 1.18340202e-01f, 1.74481884e-01f, 4.36655199e-03f, 5.70170619e-02f, 1.61732070e-03f, -9.26775634e-02f,
  9.19089094e-02f, -1.26514494e-01f, -1.92240313e-01f, 5.53132296e-02f, -2.21834052e-02f, 7.12858886e-02f, 6.45937771e-02f, 6.99648634e-02f, 1.09142162e-01f, 5.15541360e-02f,
  -6.69774786e-02f, -9.76272970e-02f, 3.07902740e-03f, 3.82602036e-01f, 2.37010092e-01f, 1.38283014e-01f, 1.80292740e-01f, -4.35481220e-02f, 2.73950901e-02f, -1.13917060e-01f,
  1.92365825e-01f, 9.19653699e-02f, 1.34359926e-01f, -3.23330541e-03f, 2.05789804e-01f, 1.65566146e-01f, 1.16170548e-01f, -1.17759109e-01f, 2.95495763e-02f, 6.82016984e-02f,
  -1.16113730e-01f, -3.48667465e-02f, -1.78453311e-01f, 2.21198648e-01f, 7.59414136e-02f, -7.00974613e-02f, 9.83576924e-02f, 1.98189523e-02f, -1.40022352e-01f, 1.99271411e-01f,
  2.15778779e-02f, -7.32365921e-02f, 8.70358273e-02f, 4.93271090e-03f, 7.21837953e-02f, -1.54930457e-01f, 6.62993863e-02f, 2.16731444e-01f, 5.12948520e-02f, -8.83436725e-02f,
  -5.95709719e-02f, 7.46898502e-02f, -8.88582096e-02f, 2.70739552e-02f, 1.50027439e-01f, 2.00230703e-01f, 1.46437734e-01f, 3.87301929e-02f, 4.96362783e-02f, 1.15599170e-01f,
  -2.54304204e-02f, 9.39460024e-02f, 1.04779921e-01f, 6.85182959e-02f, 1.42726436e-01f, 5.41456342e-02f, -3.48955095e-02f, 4.10851687e-02f, 2.98921522e-02f, -8.08124319e-02f,
  -2.85660792e-02f, -5.71823344e-02f, 7.44899884e-02f, -1.11995235e-01f, -1.65753022e-01f, 1.26998588e-01f, 2.25188389e-01f, 1.14981912e-01f, -3.30033787e-02f, -5.97182140e-02f,
  4.76551652e-02f, -3.22147012e-02f, 1.67196289e-01f, -8.91547054e-02f, -6.77702650e-02f, 2.03018375e-02f, 9.94224027e-02f, -3.25101130e-02f, -3.36806886e-02f, 3.44183557e-02f,
  8.43595043e-02f, 1.15335800e-01f, 7.95917660e-02f, 5.21683060e-02f, 1.35609642e-01f, -1.71637073e-01f, 5.49950171e-03f, -3.64145711e-02f, -7.18223071e-03f, -3.94908600e-02f,
  -9.11387727e-02f, -5.13598770e-02f, 1.46872178e-01f, -1.28227800e-01f, -6.09003822e-04f, -4.44276221e-02f, -3.26905516e-03f, -9.01125651e-03f, -1.16651848e-01f, 9.12978128e-02f,
  -1.20164476e-01f, -2.40608752e-02f, -8.43541101e-02f, -1.37174930e-02f, 5.52862696e-02f, 3.54808271e-02f, -1.09099917e-01f, 4.75411639e-02f, 1.10038994e-02f, -3.81472185e-02f,
  1.86248481e-01f, 1.49459317e-01f, 2.21544936e-01f, 2.99097240e-01f, 1.45238385e-01f, -6.14484400e-02f, -6.60362393e-02f, 2.43901610e-01f, 1.73915416e-01f, -2.89891101e-02f,
  3.01263690e-01f, 3.52350622e-02f, -2.11597964e-01f, -2.19463855e-01f, 7.15689510e-02f, -1.82912663e-01f, 3.41672893e-03f, -1.54864937e-01f, 1.29292548e-01f, -7.84952543e-04f,
  -2.26839315e-02f, -2.09936440e-01f, -3.44925597e-02f, 1.50834605e-01f, 9.54818428e-02f, -2.38874704e-02f, -5.39442301e-02f, 1.29567847e-01f, 2.74845082e-02f, -3.25210132e-02f,
  1.09089658e-01f, -1.31864235e-01f, -2.14932207e-02f, 3.23561430e-01f, 1.58819437e-01f, -1.06785491e-01f, 7.17377588e-02f, 8.83806869e-02f, 9.13231745e-02f, 1.86475947e-01f,
  1.08095288e-01f, 1.42532781e-01f, 3.45529653e-02f, 2.29113281e-01f, 5.38501516e-02f, 1.68079793e-01f, 2.75039561e-02f, 1.87106922e-01f, -6.98909489e-03f, 5.05195297e-02f,
  -3.14378999e-02f, 1.23774834e-01f, 2.25794598e-01f, 3.33812535e-02f, 7.59280175e-02f, 7.32211396e-03f, -2.19729990e-02f, -9.32620466e-03f, 7.57267931e-03f, -3.82876545e-02f,
  1.05336994e-01f, -4.51748036e-02f, -6.96546733e-02f, -1.82691775e-02f, 3.94260548e-02f, 1.60929993e-01f, 4.76003923e-02f, 1.91460982e-01f, -4.44767065e-02f, 1.25838280e-01f,
  -8.29946324e-02f, -2.26418003e-02f, 5.24027646e-02f, -6.10953011e-02f, 5.09940051e-02f, -9.66745317e-02f, -1.41506016e-01f, -1.36363208e-01f, 1.60424277e-01f, -9.10098776e-02f,
  6.55360669e-02f, 9.16217547e-03f, -1.27007058e-02f, 8.81108269e-02f, 1.03486411e-01f, -2.07240861e-02f, -5.22284843e-02f, 1.00027509e-01f, 1.00240260e-01f, 5.76376691e-02f,
  2.87261773e-02f, 5.73273040e-02f, -6.88260421e-02f, 1.02865659e-01f, -9.64247156e-03f, 5.59565201e-02f, -3.52821946e-02f, 2.05574468e-01f, 1.24375923e-02f, -2.12889723e-02f,
  -1.10553540e-02f, -1.77299213e-02f, -6.02454357e-02f, 9.55564529e-02f, 7.20738024e-02f, 1.33275852e-01f, -6.15831539e-02f, 2.28744745e-02f, 6.58345744e-02f, 6.86537027e-02f,
  8.18364322e-02f, 1.43735811e-01f, 3.55716608e-02f, 1.54296830e-01f, -6.90719262e-02f, -4.78028059e-02f, 1.42732188e-01f, -5.04958723e-03f, -1.12596318e-01f, -7.42204860e-02f,
  -8.08239076e-03f, -8.09355900e-02f, -1.15269525e-02f, -1.39373600e-01f, -2.12563630e-02f, -4.26378548e-02f, -1.16426900e-01f, -2.94061881e-02f, 1.05173498e-01f, 7.78716356e-02f,
  2.49929950e-02f, -8.23854581e-02f, -4.80816960e-02f, -8.52864981e-02f, -4.25705574e-02f, -1.06943272e-01f, -1.34251818e-01f, -1.01734951e-01f, -1.03569373e-01f, 5.43743558e-02f,
  -5.61874025e-02f, -7.27533782e-03f, 2.32319515e-02f, 4.59507853e-02f, 1.42315120e-01f, -5.67735434e-02f, -1.11468643e-01f, -8.78751576e-02f, -4.19638492e-02f, 8.53949487e-02f,
  -5.73197640e-02f, 5.66216372e-02f, 1.17395133e-01f, -4.29800861e-02f, -6.29357398e-02f, 1.48027912e-01f, 9.41333175e-02f, 1.30162567e-01f, 1.54317856e-01f, -8.54794383e-02f,
  1.03375204e-02f, -1.05016511e-02f, -3.01820934e-02f, 4.86353934e-02f, 1.28003180e-01f, 4.92388606e-02f, -5.92503138e-02f, 3.79246101e-02f, -8.37481916e-02f, 1.29614696e-01f,
  1.01899393e-01f, 1.18159205e-01f, 3.58083770e-02f, -1.96879916e-02f, 8.52358043e-02f, -5.11717349e-02f, -8.79336335e-03f, 1.98594984e-02f, 1.66516416e-02f, 1.22159176e-01f,
  1.68061003e-01f, 4.80224602e-02f, -4.86892648e-02f, 5.36320684e-03f, 9.53703299e-02f, 1.14482446e-02f, -1.20834475e-02f, -3.24828476e-02f, -7.77512714e-02f, 4.64085303e-02f,
  1.44617520e-02f, 1.27672926e-01f, 1.16214521e-01f, -4.42976467e-02f, -1.02761470e-01f, -1.54020926e-02f, -6.39148727e-02f, 1.61558360e-01f, -6.34949952e-02f, 4.19975929e-02f,
  1.01744637e-01f, 1.70277767e-02f, -1.52439892e-01f, 1.18539445e-01f, 1.21089026e-01f, -2.31951624e-02f, -3.33979614e-02f, 8.15525874e-02f, 4.06095572e-03f, -8.46745968e-02f,
  -1.04449116e-01f, -7.15324208e-02f, 3.25532481e-02f, 4.37414236e-02f, 1.43770680e-01f, -9.93288904e-02f, -9.16816071e-02f, 1.74026728e-01f, 3.10038663e-02f, 4.46821786e-02f,
  1.05323806e-01f, 2.37100925e-02f, -3.82674895e-02f, 1.32604927e-01f, 1.41400576e-01f, 7.39178583e-02f, -1.69082694e-02f, 1.86947212e-02f, 5.88839017e-02f, 1.21129319e-01f,
  -1.39137521e-01f, -1.91072877e-02f, -1.12149030e-01f, 4.76900116e-02f, 1.26147838e-02f, -4.96742167e-02f, 3.40028107e-02f, 9.29063261e-02f, 1.94518983e-01f, 8.62892345e-02f,
  5.86576946e-02f, 1.36994189e-02f, 8.05108696e-02f, -8.90101567e-02f, -1.23493411e-01f, -7.16473535e-02f, -4.66784500e-02f, -3.67891490e-02f, 1.23572417e-01f, -3.54355276e-02f,
  -4.99050319e-02f, 2.33385369e-01f, 9.74831954e-02f, -4.20273431e-02f, 1.08804032e-01f, 1.48938328e-01f, 1.37731861e-02f, 6.64752116e-03f, 1.09680176e-01f, -1.03201188e-01f,
  1.45938709e-01f, 1.11612119e-01f, 2.46656701e-01f, 3.65388766e-02f, 6.23057894e-02f, -6.12288853e-03f, 5.70873693e-02f, 1.62560388e-01f, 5.49735203e-02f, 1.53238729e-01f,
  1.29243016e-01f, 8.69698972e-02f, -1.76032320e-01f, -2.75931526e-02f, -2.17445940e-01f, 1.43821836e-01f, 1.05116554e-01f, 5.42240627e-02f, 8.34934041e-02f, 3.13366465e-02f,
  8.90986994e-02f, 1.30296111e-01f, 6.91516846e-02f, 1.70576841e-01f, -9.65843052e-02f, 1.50687695e-01f, 1.05530240e-01f, -8.88464749e-02f, -5.40082268e-02f, -9.23347101e-03f,
  1.25175625e-01f, 1.64591968e-01f, 1.78269535e-01f, 3.61721963e-02f, 1.38725773e-01f, 1.14191547e-01f, -1.91935971e-02f, 2.17932817e-02f, 1.06467508e-01f, 4.88481224e-02f,
  7.09629878e-02f, 5.17761558e-02f, -6.48607919e-03f, 1.47562800e-02f, -4.22064029e-03f, 1.60408571e-01f, 1.36549294e-03f, 1.46845490e-01f, 7.40871504e-02f, 1.45188496e-01f,
  2.04130076e-03f, 1.79649711e-01f, 1.75755490e-02f, 5.91645502e-02f, 1.80489533e-02f, -6.08554855e-02f, 2.38594692e-02f, 2.41169110e-01f, 6.21273294e-02f, -4.54285778e-02f,
  -2.29899716e-02f, -1.70433950e-02f, 1.22870259e-01f, 1.32477224e-01f, -4.95240744e-03f, 2.68314555e-02f, 1.74324989e-01f, 5.94754107e-02f, -4.09010090e-02f, 5.09931929e-02f,
  8.63722414e-02f, 1.45926669e-01f, -3.22000347e-02f, 6.97529234e-04f, 1.26102999e-01f, 9.41826105e-02f, -7.07614645e-02f, 1.45193219e-01f, 9.00636017e-02f, -6.89735636e-02f,
  -9.39457044e-02f, -6.95728976e-03f, 5.86442761e-02f, -5.98250516e-02f, 1.87098369e-01f, -2.72045601e-02f, -5.11314087e-02f, 1.58948734e-01f, -8.73656347e-02f, -1.19833976e-01f,
  1.39733136e-01f, -3.13012712e-02f, 8.35410319e-03f, -7.32713863e-02f, 6.21566214e-02f, -4.21581008e-02f, 1.73604980e-01f, -7.03913793e-02f, 3.98741141e-02f, 3.23558412e-02f,
  -1.76343173e-02f, 2.01954857e-01f, -1.03294484e-01f, -9.47334915e-02f, 4.93918881e-02f, 1.99117791e-02f, 1.35712340e-01f, 2.03087144e-02f, 8.86609480e-02f, 1.80338949e-01f,
  1.05765469e-01f, -1.03889495e-01f, -1.10026918e-01f, -5.66299520e-02f, -2.36083232e-02f, -6.39347285e-02f, 9.07579660e-02f, -1.04266573e-02f, 1.49901226e-01f, -9.90853161e-02f,
  -8.68659168e-02f, 1.40425786e-01f, 1.59249473e-02f, 7.50692487e-02f, 3.88292819e-02f, -2.43492406e-02f, -4.52221930e-02f, 5.45115210e-02f, -1.20913543e-01f, -1.19840764e-01f,
  -8.98574144e-02f, -1.31933793e-01f, 3.55328918e-02f, 2.85148602e-02f, -1.87021047e-02f, 6.95418641e-02f, -1.89863965e-02f, 4.17350158e-02f, 4.91728410e-02f, 1.30155429e-01f,
  3.63295190e-02f, 3.04382551e-03f, -9.44440514e-02f, -3.73417065e-02f, -3.34588848e-02f, 5.26736267e-02f, -3.28071378e-02f, -3.98197360e-02f, -8.38790461e-02f, -3.94723639e-02f,
  7.15963468e-02f, -7.05609247e-02f, -6.82895556e-02f, 8.40752274e-02f, 2.44417973e-03f, -3.15882973e-02f, -2.70794723e-02f, 8.46999362e-02f, -1.25177905e-01f, -8.81186798e-02f,
  1.24196243e-02f, 1.96132772e-02f, 2.76915412e-02f, -1.05676517e-01f, 1.01679057e-01f, 3.77478339e-02f, -6.47359267e-02f, 4.50574569e-02f, 1.07725359e-01f, 1.41088413e-02f,
  -1.17826667e-02f, 3.77953090e-02f, 8.87454525e-02f, 7.94095695e-02f, 1.10928454e-01f, 5.02040684e-02f, 7.40728481e-03f, -1.47092175e-02f, -6.56479271e-04f, 6.72857016e-02f,
  6.82177721e-04f, -8.35676342e-02f, -1.11818753e-01f, 1.19314238e-01f, -1.06081299e-01f, 1.19954981e-01f, -1.17473885e-01f, -2.31587477e-02f, -6.17643930e-02f, -2.31319852e-02f,
  5.15987538e-02f, 3.97583134e-02f, 1.06216393e-01f, 1.46983154e-02f, -1.08459994e-01f, -7.13947192e-02f, -3.08348816e-02f, -3.86354066e-02f, -3.35527025e-02f, 1.30947260e-02f,
  9.76410434e-02f, -2.55809110e-02f, 1.43890465e-02f, -6.09293999e-03f, -2.73995381e-02f, -5.30133806e-02f, 6.88800439e-02f, -9.01843235e-02f, 9.24045816e-02f, 5.89457434e-03f,
  5.95016517e-02f, -8.72298926e-02f, 7.85717964e-02f, -7.26840794e-02f, 7.09966868e-02f, -9.71008837e-02f, -3.00345086e-02f, 1.92116611e-02f, -1.06894210e-01f, 8.78317505e-02f,
  9.47967693e-02f, 2.94743124e-02f, -5.10462113e-02f, 8.31196979e-02f, 1.72051191e-02f, -1.27253339e-01f, -1.68123636e-02f, -2.60633379e-02f, -2.03754064e-02f, 4.15244028e-02f,
  3.93610075e-03f, 4.29238714e-02f, 7.72648379e-02f, -4.41550761e-02f, -7.21037909e-02f, -9.51741263e-02f, -9.34618637e-02f, -4.17701118e-02f, 1.05776668e-01f, -4.97710332e-02f,
  1.93499178e-02f, 2.15022750e-02f, -1.06536217e-01f, 8.60059187e-02f, -4.93605360e-02f, 6.72894418e-02f, 3.98291834e-02f, -1.13896299e-02f, -1.16510667e-01f, 1.03527851e-01f,
  1.53626248e-01f, 3.72807421e-02f, 8.95057246e-02f, 1.97907105e-01f, -1.31605387e-01f, 1.72325715e-01f, 1.57459095e-01f, 8.06064066e-03f, -9.02086496e-02f, 1.21535324e-01f,
  -1.85235050e-02f, 3.81816849e-02f, -2.22495273e-02f, 1.44212589e-01f, 5.36885634e-02f, -8.43629837e-02f, -2.65901327e-01f, -9.02325436e-02f, -4.77847792e-02f, -2.72763278e-02f,
  -2.70082265e-01f, -1.13819249e-01f, 7.66277909e-02f, -1.59973606e-01f, -9.53308344e-02f, 1.75176430e-02f, 4.86716069e-02f, 1.63235292e-01f, -3.84524316e-02f, 1.03415400e-01f,
  -6.37331381e-02f, 3.76274511e-02f, -1.51868016e-02f, 1.14316337e-01f, 1.21646911e-01f, -1.08478673e-01f, 7.17075840e-02f, 8.78160074e-02f, 7.63396025e-02f, 5.82677172e-03f,
  -8.61085951e-02f, -1.56008407e-01f, 1.81814373e-01f, -8.25137943e-02f, 2.13127732e-02f, 1.71060771e-01f, 8.70867148e-02f, -9.88285691e-02f, 2.18907192e-01f, 2.99742147e-02f,
  1.71786267e-02f, 2.62379553e-02f, 1.09264165e-01f, -9.40642953e-02f, -8.80845785e-02f, 9.74873677e-02f, 1.31223753e-01f, -5.73525056e-02f, 2.00000450e-01f, 3.07007376e-02f,
  5.85913844e-02f, 1.47134990e-01f, 5.64108305e-02f, -4.60936539e-02f, 1.30779911e-02f, 1.04531221e-01f, 2.71578170e-02f, -8.17684736e-03f, -6.48500174e-02f, 1.34138480e-01f,
  6.76916465e-02f, 7.69072175e-02f, 1.82711244e-01f, 1.48597091e-01f, 2.24535167e-01f, 3.69645841e-02f, 2.09398139e-02f, -1.98446944e-01f, 1.34563223e-01f, 3.03639062e-02f,
  -1.62621543e-01f, -2.65405364e-02f, 1.53758209e-02f, 1.83788016e-01f, -7.27701420e-03f, 3.62020615e-03f, -1.77015215e-01f, -3.52779150e-01f, 5.58610596e-02f, -7.00520128e-02f,
  -1.76458284e-01f, 1.91548914e-01f, 1.12643383e-01f, 1.68784842e-01f, -7.45728165e-02f, -1.95737615e-01f, 1.43897748e-02f, -2.82038637e-02f, -4.53027897e-02f, 5.18566258e-02f,
  1.03439670e-03f, 1.69228435e-01f, 1.90093126e-02f, 8.74969736e-02f, -3.44320424e-02f, 2.76162587e-02f, 2.19686791e-01f, -4.82398607e-02f, 1.57541167e-02f, 5.03162406e-02f,
  1.64304405e-01f, -2.84179021e-02f, 3.99001762e-02f, 1.44673008e-02f, 1.50682300e-01f, -3.15080993e-02f, 4.87969927e-02f, -1.28995612e-01f, 1.77269280e-01f, 6.37720227e-02f,
  1.59292042e-01f, -8.59737769e-02f, -9.33992863e-02f, 1.27258226e-01f, 1.33256093e-01f, 1.15902133e-01f, 1.02453798e-01f, -8.18949100e-03f, 1.01111338e-01f, -4.09498028e-02f,
  -6.82809055e-02f, 4.59900498e-02f, -5.17200679e-02f, 4.67103766e-03f, 9.67333019e-02f, -6.96650445e-02f, -6.65000901e-02f, -2.04944378e-03f, -5.90504929e-02f, -1.12641379e-01f,
  -2.25893542e-01f, -2.38737524e-01f, 2.90193468e-01f, 8.52814019e-02f, -4.24827337e-02f, -1.13744535e-01f, 1.82156973e-02f, -5.44863101e-03f, 1.58969730e-01f, 8.17113668e-02f,
  -7.56546333e-02f, 1.64550662e-01f, 2.55722940e-01f, 2.29351357e-01f, 1.34825692e-01f, 1.04100183e-01f, -3.51902246e-02f, -1.05459109e-01f, 2.11759791e-01f, 1.40680343e-01f,
  -2.36497242e-02f, 1.27088174e-01f, 1.82813898e-01f, -1.32126525e-01f, -6.76502362e-02f, -9.64242499e-03f, -6.02708459e-02f, -6.33122697e-02f, 1.91216275e-01f, 8.39719847e-02f,
  2.05109224e-01f, -5.32565154e-02f, 7.94859231e-02f, -1.34931207e-01f, 2.47116968e-01f, -5.74728437e-02f, -1.17333874e-01f, 1.25561133e-01f, -6.70074672e-02f, -1.35584444e-01f,
  3.17775793e-02f, 1.04170829e-01f, 1.63598154e-02f, -1.18528781e-02f, 1.72692373e-01f, 1.79722086e-01f, -1.38088793e-01f, 6.24138340e-02f, -3.06985043e-02f, 1.83340833e-02f,
  -6.98592886e-02f, 5.87110408e-02f, 1.20819025e-01f, -1.11474991e-02f, 5.71094379e-02f, 2.12421104e-01f, 9.04554874e-02f, 1.87403023e-01f, 1.72190383e-01f, 1.88823089e-01f,
  4.68009412e-02f, 2.05040500e-01f, 9.35699046e-02f, -3.80524099e-02f, 3.62714157e-02f, -2.97805876e-01f, 9.12659466e-02f, -4.16548327e-02f, -2.11006477e-01f, -1.01606973e-01f,
  1.39470816e-01f, 6.81518689e-02f, 5.70045672e-02f, 1.15883976e-01f, -9.59858075e-02f, -1.33458689e-01f, 5.77390045e-02f, 2.92468388e-02f, 3.45268175e-02f, 8.13814476e-02f,
  -9.37722921e-02f, -9.02524143e-02f, 8.78319889e-02f, -4.81573865e-04f, 1.57685339e-01f, 1.26233906e-01f, 3.02677089e-03f, 1.21309042e-01f, 6.05828166e-02f, -1.23033747e-01f,
  9.62412432e-02f, 3.38731497e-03f, 7.51740411e-02f, -3.30907442e-02f, 2.16803715e-01f, -1.25399381e-01f, 1.04986310e-01f, 2.05754623e-01f, 1.06678143e-01f, 1.47924706e-01f,
  9.82949063e-02f, 1.17659405e-01f, -8.45516399e-02f, -2.55205464e-02f, -8.43603313e-02f, -3.42691056e-02f, 2.07449540e-01f, -5.05769514e-02f, 5.76463751e-02f, 2.14109402e-02f,
  -8.68189186e-02f, -8.99796467e-03f, -9.06745791e-02f, -3.44778970e-02f, 2.86809579e-02f, -7.55017847e-02f, 1.57997862e-03f, -1.06308095e-01f, 9.83933881e-02f, -3.86920497e-02f,
  1.11273676e-01f, -5.26225865e-02f, 1.16928630e-01f, 1.31091848e-01f, -2.73183696e-02f, 5.57428338e-02f, -1.27229586e-01f, 1.46321386e-01f, -5.43200970e-02f, -2.80550122e-02f,
  -2.00864132e-02f, -6.03958927e-02f, 1.33102715e-01f, -1.77744646e-02f, 2.02964526e-02f, -8.41345489e-02f, 6.60803020e-02f, -4.43910062e-02f, 1.18717514e-01f, 5.63919358e-02f,
  -1.06031723e-01f, -3.10419351e-02f, 1.51070938e-01f, -5.45583330e-02f, 5.01654409e-02f, 1.66116118e-01f, 8.41956139e-02f, 8.04081373e-03f, 9.56946015e-02f, -3.79833691e-02f,
  -9.59060490e-02f, -8.78630280e-02f, 9.38168988e-02f, -8.46396238e-02f, -6.34627119e-02f, -1.17042074e-02f, -5.52788638e-02f, -4.47384305e-02f, -2.32367702e-02f, 3.27259190e-02f,
  -8.46915245e-02f, 3.51707935e-02f, -3.47073674e-02f, 9.36793461e-02f, -8.70129913e-02f, 3.93525958e-02f, 2.60117240e-02f, -3.82946506e-02f, -6.77838996e-02f, 4.36176211e-02f,
  -2.37267800e-02f, -1.18959583e-01f, -6.99265674e-02f, -6.46372326e-03f, 9.10689831e-02f, 1.05804600e-01f, 6.85881600e-02f, -1.14864223e-01f, 2.77924687e-02f, -2.39499696e-02f,
  1.15326457e-01f, 5.47433905e-02f, 6.43525273e-02f, 1.76310644e-01f, -5.68790659e-02f, 7.87038952e-02f, 1.47521785e-02f, -5.03427237e-02f, 6.62995949e-02f, 1.33726329e-01f,
  3.15083712e-02f, -5.43336757e-02f, 1.01381596e-02f, -1.90049529e-01f, 2.01609716e-01f, -1.55886665e-01f, -2.18708053e-01f, -1.53282747e-01f, 4.64157797e-02f, 1.15268119e-01f,
  3.30937058e-02f, -9.90753770e-02f, 1.39544159e-01f, 1.70545340e-01f, 2.04496160e-01f, 1.52955100e-01f, 1.14844941e-01f, -7.75691941e-02f, -6.81752339e-02f, -1.11942969e-01f,
  6.40271232e-02f, 1.52992969e-02f, 1.53721869e-01f, 4.24801894e-02f, 2.24351734e-01f, 1.79588765e-01f, 5.55549935e-02f, 9.05027911e-02f, -1.54591650e-01f, 1.73351821e-02f,
  8.64566769e-03f, 2.29877550e-02f, -6.24661148e-02f, 6.93934858e-02f, 4.15879004e-02f, -9.91074368e-02f, 1.34082690e-01f, 1.07769435e-03f, -1.58470633e-04f, 1.56537086e-01f,
  -5.77758662e-02f, -9.54930410e-02f, 1.69574954e-02f, 1.47135541e-01f, 7.91715682e-02f, -6.98552057e-02f, 4.63580415e-02f, 1.74459130e-01f, 6.77943379e-02f, -1.18820304e-02f,
  -3.69360410e-02f, -3.81974168e-02f, 6.51175007e-02f, -1.84124149e-02f, 6.68132529e-02f, 1.17279738e-02f, 1.22000784e-01f, 1.43475950e-01f, 1.63876340e-01f, 7.37362057e-02f,
  -4.78496477e-02f, 4.82265987e-02f, -1.01964623e-01f, 8.31874982e-02f, -3.65956649e-02f, -1.17991097e-01f, 1.19813576e-01f, -8.16311240e-02f, 9.14190263e-02f, -6.21224381e-03f,
  -1.56799212e-01f, 5.36826029e-02f, 1.34492964e-02f, -3.44126523e-02f, -4.21689562e-02f, 1.00431859e-01f, 4.90974709e-02f, 1.22392207e-01f, 7.74526596e-02f, 1.34595394e-01f,
  1.32535562e-01f, -8.56375545e-02f, -8.71335045e-02f, 5.20194136e-02f, -7.47805908e-02f, 1.19063025e-02f, -8.89151357e-03f, 1.24897614e-01f, 9.11962762e-02f, 3.50890234e-02f,
  1.03215776e-01f, -7.10002929e-02f, 8.59032571e-02f, 5.19987531e-02f, -8.47188458e-02f, -2.25760825e-02f, -9.87121388e-02f, -7.43768439e-02f, -6.97904592e-03f, 1.11285180e-01f,
  2.03661490e-02f, -1.16146892e-01f, 7.05367029e-02f, 1.63394108e-01f, 1.15586221e-01f, 1.09932058e-01f, -1.06892601e-01f, 6.49764687e-02f, 1.70452490e-01f, -2.21306067e-02f,
  1.39554925e-02f, 1.86718795e-02f, 1.24988675e-01f, 3.35475802e-02f, -8.05139765e-02f, 7.03342929e-02f, -3.30354869e-02f, -8.50560665e-02f, -7.48488605e-02f, 4.07231078e-02f,
  2.20502958e-01f, 3.55020585e-03f, 6.49338067e-02f, -4.47318144e-02f, -4.35956120e-02f, 1.32344007e-01f, 1.22981504e-01f, 4.08477262e-02f, 3.48413102e-02f, 9.69954804e-02f,
  5.96506819e-02f, 7.72491544e-02f, 3.38928588e-02f, -3.11017502e-02f, 1.08341195e-01f, 8.80034789e-02f, 8.78211930e-02f, -4.77775112e-02f, -1.03537619e-01f, 8.32478851e-02f,
  1.79885030e-01f, 2.22820491e-01f, 2.51477212e-02f, 5.19469567e-02f, 1.08252682e-01f, 3.09483870e-03f, 2.10469570e-02f, -3.73156816e-02f, -3.52914035e-02f, -2.75682323e-02f,
  1.07197464e-02f, -1.76247116e-02f, -3.51788141e-02f, 5.06763421e-02f, -9.53149870e-02f, -3.72126177e-02f, -2.11328687e-03f, 9.84661728e-02f, 4.02298756e-02f, -3.48112322e-02f,
  -1.53956056e-01f, 3.02963238e-02f, 3.87021191e-02f, 7.57846683e-02f, 1.11135468e-02f, 4.62309234e-02f, -1.16206422e-01f, 1.68783799e-01f, -9.40996855e-02f, 6.47713989e-02f,
  3.72490175e-02f, 8.74132067e-02f, 5.07059023e-02f, -8.24344680e-02f, -9.67193320e-02f, 1.44939378e-01f, -6.35400265e-02f, -2.68057659e-02f, -8.53902847e-02f, -1.00414734e-02f,
  -2.49349847e-02f, 3.00711170e-02f, 1.15052976e-01f, 1.44722596e-01f, 2.60587752e-01f, 7.96969980e-02f, 1.04666159e-01f, 1.38852552e-01f, 1.52913183e-01f, -7.26026949e-03f,
  1.43735349e-01f, 9.67780277e-02f, -5.81984688e-03f, -9.36692394e-03f, 1.84110999e-01f, 5.62260374e-02f, -2.08677828e-01f, 1.09578930e-01f, -3.60141024e-02f, 1.29934028e-01f,
  -1.15807552e-03f, -1.23669729e-01f, -1.07310019e-01f, 2.54270405e-01f, 7.29284585e-02f, 1.03351586e-01f, -2.70057451e-02f, 3.31740007e-02f, 2.05868572e-01f, -3.30426916e-02f,
  1.27496980e-02f, 4.24587093e-02f, -1.26266733e-01f, 1.89083174e-01f, 3.71284671e-02f, 2.00384557e-02f, -9.55030322e-03f, 4.13877741e-02f, 2.51651481e-02f, 5.11270724e-02f,
  1.55955628e-01f, -9.43730306e-03f, 5.83088435e-02f, 1.21395379e-01f, -1.56310141e-01f, 1.09933302e-01f, 8.26021750e-03f, -4.93522063e-02f, -3.30950394e-02f, -3.67272086e-02f,
  4.25529331e-02f, 9.75766499e-03f, -6.49080500e-02f, 2.06687361e-01f, -8.97863358e-02f, -9.69338641e-02f, 2.54306823e-01f, 3.84771116e-02f, 8.21572617e-02f, 4.08294089e-02f,
  2.94577386e-02f, 1.34529501e-01f, -1.29598513e-01f, -6.22448213e-02f, -8.38794932e-02f, 1.91107750e-01f, -7.82246217e-02f, 1.00159355e-01f, -1.31215125e-01f, -1.09441869e-01f,
  -3.06899361e-02f, -4.79358733e-02f, -7.38244802e-02f, 7.32490942e-02f, -3.81908640e-02f, -1.24769382e-01f, -5.97867221e-02f, 7.47454017e-02f, -5.77808917e-02f, 2.65386775e-02f,
  -1.00662686e-01f, -6.58335462e-02f, -9.12573412e-02f, -6.69118809e-03f, -1.01988278e-01f, 2.79447739e-03f, -4.56374692e-04f, -7.52706230e-02f, -3.80160436e-02f, 4.74805161e-02f,
  -3.87908891e-02f, -4.67965975e-02f, 6.02453277e-02f, 8.92356038e-02f, -7.31518045e-02f, -9.81401354e-02f, 9.96776000e-02f, 1.05746768e-01f, -1.29434392e-02f, -1.30385414e-01f,
  -1.19549185e-01f, -2.56037973e-02f, 9.90103185e-02f, -8.71702563e-03f, 6.73940182e-02f, -2.42259800e-02f, -3.01781185e-02f, 8.75358656e-02f, 3.26998672e-03f, -9.24434885e-02f,
  4.88037802e-02f, 1.19230384e-02f, 3.00133694e-02f, 2.74227485e-02f, -2.52877716e-02f, -1.11278057e-01f, -4.71784323e-02f, -9.26179960e-02f, -5.87251633e-02f, -1.23742156e-01f,
  -3.87258567e-02f, 2.55278386e-02f, -2.69437917e-02f, -2.89688166e-02f, 2.67112833e-02f, 1.02187209e-02f, -1.72947347e-02f, -3.07498854e-02f, -5.97952902e-02f, -7.80187314e-03f,
  7.76056051e-02f, 9.13154557e-02f, 1.42326653e-01f, 2.05619168e-02f, 1.22884028e-02f, -2.83489339e-02f, 1.80381000e-01f, 4.34538499e-02f, 2.43681163e-01f, 2.41750598e-01f,
  1.24492235e-01f, 1.76210806e-01f, 1.26737386e-01f, -1.60556257e-01f, 1.49806187e-01f, 7.60911629e-02f, -2.06982166e-01f, 6.78985715e-02f, 1.67547017e-01f, -3.65834311e-02f,
  -2.28092417e-01f, 9.36381519e-02f, 1.63832814e-01f, -1.79585710e-01f, -1.21466823e-01f, -1.46260979e-02f, 4.79582101e-02f, 9.67086852e-02f, 1.83997065e-01f, -1.94457099e-02f,
  -2.78425273e-02f, 1.09800518e-01f, 1.19513579e-01f, 1.82797387e-02f, 1.00653417e-01f, -9.63302776e-02f, -3.98655497e-02f, 9.08915699e-02f, 6.59926236e-02f, 1.58804581e-01f,
  2.22981963e-02f, -3.12319975e-02f, 1.29404813e-01f, -1.52767658e-01f, 8.57679322e-02f, 2.22759336e-01f, 1.72494739e-01f, 1.48328811e-01f, 2.18500599e-01f, -3.45887057e-02f,
  -8.82728696e-02f, 1.35113642e-01f, 3.30009349e-02f, 1.05726561e-02f, 4.72211912e-02f, 1.71744347e-01f, 1.51711479e-01f, 9.18178353e-03f, 2.61861887e-02f, 1.42411888e-01f,
  -5.72652034e-02f, 2.13761881e-01f, 4.38770540e-02f, 1.34121805e-01f, -1.09794810e-01f, 9.52284411e-02f, -4.34753038e-02f, -1.22518972e-01f, 7.46416897e-02f, -6.00027293e-02f,
  2.48010699e-02f, -2.80690044e-02f, -1.13530466e-02f, -1.13571323e-01f, 8.15776587e-02f, -1.59808490e-02f, -1.05420850e-01f, 9.66261327e-02f, 1.47889927e-02f, -1.23758025e-01f,
  -7.46121332e-02f, -5.00453636e-02f, 1.07079484e-01f, -3.70002501e-02f, -4.02070135e-02f, 1.05478920e-01f, 4.83041592e-02f, -1.88429467e-02f, 2.58371960e-02f, -9.19889659e-03f,
  -1.28967717e-01f, 8.30260068e-02f, -3.09958979e-02f, -5.31405248e-02f, 8.48926827e-02f, -2.48836372e-02f, 4.40633968e-02f, -7.30045140e-02f, 1.00365162e-01f, -1.90929808e-02f,
  2.33513135e-02f, 2.75107026e-02f, 9.50411484e-02f, 1.97221003e-02f, 8.03026110e-02f, -1.16775379e-01f, -5.52058481e-02f, 1.03172317e-01f, 6.75509274e-02f, -9.94306728e-02f,
  -1.07858196e-01f, -5.49968667e-02f, 1.29221067e-01f, 1.01200923e-01f, -5.72283864e-02f, 1.23651110e-01f, -5.96631952e-02f, -6.14328831e-02f, -6.11481816e-02f, 4.47675176e-02f,
  -7.43782893e-02f, 2.67270170e-02f, 1.19079508e-01f, -2.15982869e-02f, -1.03944026e-01f, -3.38638760e-02f, -9.67449471e-02f, -2.91287620e-02f, 2.44574901e-02f, 1.22627772e-01f,
  6.56129122e-02f, 1.52298942e-01f, -6.78659305e-02f, -4.05958332e-02f, 1.74637273e-01f, 7.93174207e-02f, -2.77647488e-02f, -4.27189879e-02f, -8.38760808e-02f, 1.34652048e-01f,
  -3.15040573e-02f, 4.29937243e-02f, -2.05744673e-02f, 1.63632333e-02f, 1.24805011e-01f, -1.17257619e-02f, 4.92891856e-02f, -1.02972992e-01f, 1.14305571e-01f, 6.95855916e-02f,
  6.35975972e-02f, 2.63532456e-02f, 1.05583385e-01f, 5.77366389e-02f, 4.24797796e-02f, 2.30451580e-02f, -4.25637513e-02f, -2.81922184e-02f, 5.62736206e-02f, 1.35438383e-01f,
  -9.52980369e-02f, 7.77387917e-02f, 1.31302893e-01f, 8.29716623e-02f, -8.50423500e-02f, -3.38670500e-02f, -1.14091769e-01f, -9.75605799e-04f, -4.54394259e-02f, -1.09404303e-01f,
  3.92517038e-02f, -1.15794102e-02f, 3.72970253e-02f, -5.03321402e-02f, -1.28449589e-01f, -5.67743331e-02f, 4.45668446e-03f, 7.66473934e-02f, 9.86891519e-03f, -5.21923378e-02f,
  -1.68146025e-02f, 1.08057387e-01f, 1.00459652e-02f, -9.27944705e-02f, -1.09149173e-01f, -6.66363537e-02f, -5.87740205e-02f, 5.58867194e-02f, -9.64518785e-02f, -7.03788996e-02f,
  -3.44526581e-03f, 2.70842984e-02f, 1.03826886e-02f, 1.40013486e-01f, 5.44866025e-02f, 1.55974671e-01f, -1.40200593e-02f, -1.09875686e-02f, 5.43806702e-02f, -4.25392240e-02f,
  1.49410395e-02f, -8.72852728e-02f, 1.95180485e-03f, 2.83147376e-02f, 1.39156625e-01f, 3.08155473e-02f, 4.34503108e-02f, -5.31904735e-02f, 1.23105288e-01f, -1.51225939e-01f,
  -6.67376295e-02f, -1.69968173e-01f, 4.14967500e-02f, 4.49321531e-02f, 1.41390398e-01f, 4.86094840e-02f, -8.82914960e-02f, 8.14203769e-02f, -4.47320901e-02f, 7.97513127e-02f,
  -1.90419313e-02f, -1.17901459e-01f, -1.41801387e-02f, 1.35936424e-01f, -1.75553851e-03f, -1.32387102e-01f, 1.07253417e-02f, 1.11723609e-01f, -1.22243002e-01f, -1.16179161e-01f,
  2.89151613e-02f, 7.00739995e-02f, 1.75823674e-01f, 3.77947614e-02f, -1.40693396e-01f, 1.74638666e-02f, 1.06984809e-01f, 2.69087628e-02f, -7.94121646e-04f, 8.80535692e-02f,
  8.16714391e-02f, -2.53843274e-02f, 1.26216948e-01f, 6.29982352e-02f, -1.26988366e-01f, -5.05978726e-02f, 1.21537618e-01f, -5.43014072e-02f, 1.15713142e-01f, 1.17261894e-01f,
  9.47868638e-03f, -7.47083127e-02f, -1.85615930e-03f, 2.18193932e-03f, 8.94604847e-02f, -9.16258842e-02f, 9.06125605e-02f, -4.49924134e-02f, -5.13703302e-02f, -3.09566017e-02f,
  -4.59629926e-04f, 1.33036777e-01f, -8.62293914e-02f, -4.93342951e-02f, 3.22985910e-02f, -5.25846779e-02f, 1.00493804e-01f, -1.70246158e-02f, -1.09672889e-01f, 1.55528054e-01f,
  -1.06155112e-01f, -1.03850119e-01f, 4.53995680e-03f, -1.08279563e-01f, 1.07146822e-01f, 1.24759832e-02f, 1.30652888e-02f, 5.95970042e-02f, 5.80991134e-02f, 7.39675686e-02f,
  2.42894888e-02f, -8.86887610e-02f, 9.40355510e-02f, 9.08235237e-02f, -1.17713451e-01f, -3.47743444e-02f, 1.47172078e-01f, -1.29806295e-01f, -8.63115042e-02f, 6.68022502e-03f,
  1.61185652e-01f, 5.41475266e-02f, 6.58916235e-02f, 1.25052974e-01f, 2.83953492e-02f, 5.56020401e-02f, -3.00842486e-02f, 1.01635531e-01f, 4.12297174e-02f, -5.50691076e-02f,
  7.12995301e-04f, 4.23792787e-02f, 1.17998257e-01f, 7.07228184e-02f, -1.03367575e-01f, 4.65956628e-02f, 7.00156614e-02f, 2.11789608e-02f, 4.96916398e-02f, -3.41746211e-02f,
  8.93345699e-02f, -3.42993694e-03f, -1.96678713e-02f, -6.76195994e-02f, -2.81702019e-02f, 1.16894990e-01f, -7.72829773e-03f, 1.60625502e-02f, 1.66339483e-02f, 1.05871014e-01f,
  3.09033748e-02f, -2.07455945e-03f, 2.38369964e-02f, 8.13293271e-03f, -8.97122175e-02f, -8.87129456e-02f, 1.00941345e-01f, -5.27704433e-02f, -9.23392475e-02f, -5.27527146e-02f,
  -1.00825563e-01f, -1.13445418e-02f, -3.86799872e-02f, -1.18219502e-01f, 6.97937142e-03f, -7.41898641e-02f, -8.89938325e-02f, -5.74886091e-02f, 9.14948285e-02f, -7.06234723e-02f,
  -1.65912509e-02f, -2.04573758e-02f, -3.53766978e-02f, 1.09945126e-01f, 1.00001410e-01f, -6.23581372e-02f, -2.56520174e-02f, -8.43193941e-03f, -1.10460520e-01f, -6.07979707e-02f,
  -2.65479926e-02f, -1.41209867e-02f, -2.08524242e-02f, -3.37038152e-02f, -1.17853954e-01f, 1.20065317e-01f, 3.01011913e-02f, 4.56937701e-02f, -3.06438040e-02f, -4.53581810e-02f,
  -6.73667490e-02f, 8.41526780e-03f, -5.94605505e-02f, 1.14302203e-01f, 2.64919493e-02f, -6.92318976e-02f, -6.23146594e-02f, -4.53681573e-02f, -9.82652381e-02f, -2.50340216e-02f,
  -6.84278309e-02f, 7.38630295e-02f, 3.33722197e-02f, -9.96976495e-02f, -1.61660137e-03f, 4.92910296e-02f, 1.65438596e-02f, -1.03579290e-01f, -8.66207927e-02f, 3.84937823e-02f,
  8.12836736e-02f, 1.45601621e-03f, 4.33975495e-02f, -6.27291426e-02f, -1.08309895e-01f, -1.01071924e-01f, -8.16893131e-02f, 9.17688534e-02f, 6.65515438e-02f, -8.22762772e-02f,
  -6.92948326e-02f, -9.34907347e-02f, -5.24342544e-02f, -9.00182575e-02f, -1.07632019e-01f, -1.09671533e-01f, -3.81219052e-02f, -6.67126328e-02f, 1.00569330e-01f, 3.80323865e-02f,
  -1.20544314e-01f, 8.09827298e-02f, 1.16925232e-01f, -1.03809044e-01f, -4.10493389e-02f, 7.10092857e-02f, -7.93329328e-02f, 1.93046909e-02f, -5.06814942e-02f, -8.47323835e-02f,
  -9.23436880e-02f, -1.20185517e-01f, 3.98207530e-02f, 9.68630165e-02f, -2.64360663e-02f, -1.15957171e-01f, 2.29552407e-02f, 2.81589315e-03f, 1.02985114e-01f, 7.16196820e-02f,
  -1.21220209e-01f, -9.39666182e-02f, 6.79769143e-02f, 3.81403975e-02f, -1.10034995e-01f, 1.02551490e-01f, 6.04373664e-02f, 5.91512695e-02f, 1.13246970e-01f, -1.04438834e-01f,
  -1.16766589e-02f, -8.60566199e-02f, 6.40192404e-02f, 1.02584668e-01f, -6.30024448e-02f, -8.45583379e-02f, -1.09760143e-01f, 7.46982023e-02f, -1.07352279e-01f, 3.64793763e-02f,
  -4.55886833e-02f, -2.25151870e-02f, 3.67395394e-02f, -3.75924893e-02f, -3.24035436e-02f, 7.27317929e-02f, 1.04480699e-01f, -6.57477826e-02f, 7.77432919e-02f, 1.08930806e-03f,
  -5.99779598e-02f, -2.64134281e-03f, -9.72454920e-02f, -7.72845969e-02f, -6.81212023e-02f, 2.48606633e-02f, -2.58678868e-02f, 9.79314595e-02f, -2.07471102e-02f, -8.65694508e-02f,
  -5.32497242e-02f, -9.83804986e-02f, -7.19591677e-02f, 8.99990723e-02f, -1.04294844e-01f, 2.64556203e-02f, 1.41251519e-01f, -2.97498200e-02f, -2.25069336e-04f, 8.92604962e-02f,
  -3.14380154e-02f, 8.55371505e-02f, -2.99472408e-03f, 6.45865425e-02f, -1.35316914e-02f, 1.30889922e-01f, 1.87864639e-02f, -1.07471105e-02f, 3.49942334e-02f, -1.60034243e-02f,
  -4.00726944e-02f, 1.95157621e-02f, -1.48803703e-02f, 1.11638069e-01f, 6.54448569e-02f, -9.32738706e-02f, 5.43597154e-02f, 5.51128015e-02f, -1.16527967e-01f, 2.45079491e-03f,
  1.16920762e-01f, -2.20963242e-03f, 2.59241052e-02f, -8.81515071e-03f, 1.28224909e-01f, 5.99174090e-02f, 1.23253293e-01f, 1.06081493e-01f, -8.11830610e-02f, -8.83675292e-02f,
  7.27133900e-02f, 6.40391707e-02f, 4.52307947e-02f, -1.12839252e-01f, -1.99604947e-02f, -1.64481811e-02f, 4.08696420e-02f, 1.27035812e-01f, 7.29257464e-02f, 8.60162303e-02f,
  5.23331054e-02f, 5.25205061e-02f, 1.66271240e-01f, -1.23914972e-01f, 7.30733899e-03f, 8.81398767e-02f, 9.30151865e-02f, -1.51348293e-01f, 3.73232700e-02f, 5.84810264e-02f,
  2.05038428e-01f, 1.55802161e-01f, -1.05366990e-01f, 8.40918440e-03f, -4.66013812e-02f, 4.79661897e-02f, 4.66096848e-02f, 1.47229150e-01f, 1.43166363e-01f, 2.04662401e-02f,
  1.21806748e-02f, -1.84456166e-02f, 2.19799634e-02f, 4.72537242e-02f, -3.19595337e-01f, -1.74141824e-01f, 2.28420030e-02f, -1.49659544e-01f, 6.11244738e-02f, -8.93120319e-02f,
  9.34666172e-02f, 3.09639812e-01f, -1.19710527e-01f, -6.42121509e-02f, 6.20044693e-02f, 1.18705742e-01f, -2.28889734e-02f, 1.10925548e-02f, 1.79565296e-01f, 1.02480546e-01f,
  2.21963584e-01f, 4.82807532e-02f, 9.33160409e-02f, 1.49175704e-01f, 1.74206927e-01f, 3.00538778e-01f, -8.95120390e-03f, 1.21613301e-01f, -1.01692401e-01f, -4.08320688e-02f,
  -7.61641636e-02f, -1.10439062e-01f, 2.13661015e-01f, 3.68689522e-02f, 6.17677085e-02f, 5.93920611e-02f, -4.96130697e-02f, -1.93013214e-02f, 1.36074841e-01f, 1.68099925e-02f,
  2.60032117e-01f, -3.93657163e-02f, -3.32582220e-02f, -1.17547788e-01f, 5.00623025e-02f, 2.59193629e-01f, 3.58514898e-02f, -3.54903117e-02f, -9.82551053e-02f, -1.25993034e-02f,
  7.89729878e-02f, 8.82559568e-02f, 1.43852979e-01f, -1.41142076e-02f, 1.12315051e-01f, 1.79691657e-01f, 2.12394856e-02f, -4.19982262e-02f, 2.48445928e-01f, -6.81615248e-02f,
  4.71345633e-02f, 2.70695928e-02f, 1.27068982e-01f, -3.13369296e-02f, -2.33173855e-02f, 5.42581789e-02f, 1.15113631e-01f, 1.15084194e-01f, -4.22682874e-02f, -1.55135229e-01f,
  -4.34343293e-02f, 8.98314193e-02f, -2.43439320e-02f, 6.65792301e-02f, 7.57496711e-03f, -3.98825146e-02f, -1.10219277e-01f, 1.39144927e-01f, 1.08647935e-01f, 1.86450500e-02f,
  -4.26743329e-02f, 1.72541901e-01f, -3.40380743e-02f, -9.38652679e-02f, -6.67411909e-02f, -7.68354088e-02f, -2.05916613e-02f, 2.60867253e-02f, 1.95680141e-01f, 1.88070629e-02f,
  1.15627460e-01f, 1.91463292e-01f, -1.00323871e-01f, 1.31724522e-01f, 1.33994505e-01f, -1.39162034e-01f, 2.00682178e-01f, 7.96293989e-02f, -4.78839576e-02f, 4.31212001e-02f,
  2.03736320e-01f, 6.08302951e-02f, 1.62184723e-02f, -8.19414183e-02f, 2.46696942e-03f, 9.14992914e-02f, -7.71244690e-02f, -5.35159074e-02f, 1.24522321e-01f, -1.01248994e-01f,
  2.95077153e-02f, 1.36117190e-01f, 1.32068425e-01f, 1.33367836e-01f, 1.06593817e-01f, -5.20204976e-02f, 5.03119407e-03f, 2.10961103e-01f, 1.32797956e-01f, -2.95309667e-02f,
  1.60991191e-03f, -7.25618824e-02f, -2.43246257e-01f, -4.59909886e-02f, 2.21967667e-01f, 1.33670419e-01f, -1.19869083e-01f, 1.73776567e-01f, 1.38395056e-01f, 4.11696732e-03f,
  -2.68996507e-01f, 1.00195026e-02f, 2.20810294e-01f, 3.56520385e-01f, 2.49868646e-01f, -4.55204137e-02f, 1.02046639e-01f, 9.06980783e-02f, 1.64076814e-03f, -4.04086001e-02f,
  1.34353384e-01f, 1.55467927e-01f, 8.35537761e-02f, 1.18775144e-01f, 2.06611484e-01f, -1.26156479e-01f, -1.09955892e-01f, -6.06525242e-02f, -2.44874172e-02f, 8.61295760e-02f,
  1.00054210e-02f, -1.16160095e-01f, -2.35061515e-02f, -1.11422002e-01f, 8.50505531e-02f, -4.23745960e-02f, 1.92018136e-01f, -8.92636478e-02f, -5.90098314e-02f, 8.80352557e-02f,
  -8.60571489e-02f, -8.45467150e-02f, 1.29832983e-01f, 8.96138400e-02f, -8.40096101e-02f, -4.62075789e-03f, 1.77513193e-02f, 3.37984115e-02f, 3.08189280e-02f, -3.81533876e-02f,
  -6.10184707e-02f, 4.23924252e-02f, -1.12387247e-01f, 6.38608336e-02f, 9.72515121e-02f, -1.00321621e-02f, -3.14309821e-02f, 5.95770963e-02f, -6.67592464e-03f, 1.89792871e-01f,
  1.31811664e-01f, 1.15909576e-01f, 8.72003511e-02f, 1.69138983e-02f, 9.23006088e-02f, 1.30872980e-01f, 1.29674086e-02f, 9.11793634e-02f, -7.72604048e-02f, -1.32454876e-02f,
  1.22349933e-01f, -1.72372103e-01f, -4.66959551e-02f, -9.06573958e-04f, 2.45860368e-01f, -1.11293934e-01f, -1.46955967e-01f, -1.87323794e-01f, 2.83228457e-02f, 1.97913814e-02f,
  1.07189246e-01f, -3.05002816e-02f, -1.07200267e-02f, -4.71143844e-03f, -6.43458888e-02f, 3.18890139e-02f, 5.82259484e-02f, 5.37038259e-02f, -1.18497685e-01f, 1.82392783e-02f,
  1.54911773e-02f, -1.20171942e-01f, -8.12651515e-02f, 5.40425815e-02f, 2.04002112e-01f, 5.13610989e-02f, 1.58997014e-01f, 8.78437161e-02f, -3.44352461e-02f, 3.55160274e-02f,
  -2.08504777e-02f, -3.27835903e-02f, -1.13428317e-01f, 2.05026697e-02f, 2.10743949e-01f, 1.27073571e-01f, 4.63672541e-02f, 3.92419212e-02f, -7.44053274e-02f, 8.40666667e-02f,
  -9.47262868e-02f, 6.48828298e-02f, -3.09882686e-02f, 5.23275174e-02f, 3.21650542e-02f, -1.46815062e-01f, -5.32437451e-02f, 8.01630598e-03f, 1.61346138e-01f, -3.00938655e-02f,
  1.87733248e-01f, 2.41990879e-01f, 3.01395506e-01f, 1.66457772e-01f, 2.16882542e-01f, 1.15350164e-01f, 7.07976297e-02f, -2.51238514e-02f, -5.43459728e-02f, 2.36371502e-01f,
  2.55457073e-01f, -1.37844440e-02f, -2.98033208e-01f, -1.97280440e-02f, 3.87949020e-01f, -2.41835732e-02f, -4.22737077e-02f, -2.14343965e-01f, 6.62798211e-02f, 5.04765660e-02f,
  6.40496463e-02f, 2.08107933e-01f, -3.10616903e-02f, 2.20304295e-01f, 2.33548239e-01f, -8.10776651e-02f, -6.51629493e-02f, 8.23232234e-02f, 1.05860874e-01f, 1.90837279e-01f,
  9.81890131e-03f, -6.48477301e-02f, -2.55768374e-02f, 1.97836101e-01f, -2.07064934e-02f, 1.74236614e-02f, -6.59798831e-02f, 1.70315374e-02f, 2.79206872e-01f, 1.38980836e-01f,
  -9.33468267e-02f, 2.81441182e-01f, 3.47211994e-02f, 1.44532308e-01f, -1.73226714e-01f, -8.77143964e-02f, -8.49924311e-02f, 6.69960231e-02f, 1.84631571e-01f, 2.00820625e-01f,
  -8.52140337e-02f, 2.02773243e-01f, 1.73779994e-01f, -9.43549126e-02f, -1.23959698e-01f, 1.05506621e-01f, -1.48139335e-02f, 3.59613746e-02f, 1.10007122e-01f, -3.99828851e-02f,
  8.90951902e-02f, 4.95434850e-02f, 1.20736852e-01f, 5.71116013e-03f, 9.78176892e-02f, 1.41940713e-01f, -3.59509811e-02f, -1.01330653e-01f, 1.37383908e-01f, -2.64544133e-02f,
  -2.64483429e-02f, -9.39093158e-02f, -6.95455670e-02f, -4.08730377e-03f, 2.35086996e-02f, -2.83716973e-02f, 5.39455842e-03f, -4.23353240e-02f, 2.70247217e-02f, 2.97011491e-02f,
  -2.38295998e-02f, 1.30257392e-02f, -1.12969585e-01f, 1.22108966e-01f, -1.25937508e-02f, -4.48913537e-02f, -1.42480209e-02f, -2.95760739e-03f, 2.99573112e-02f, 9.20747519e-02f,
  1.45466119e-01f, 1.00982957e-01f, -9.71551836e-02f, 7.65447468e-02f, 9.74701270e-02f, -6.42410144e-02f, 2.32464597e-02f, -9.21463892e-02f, 2.29750201e-03f, 9.24231037e-02f,
  9.50803310e-02f, -1.05777659e-01f, 6.50119856e-02f, 1.12512214e-02f, 4.28963825e-02f, 4.59997263e-03f, -3.33428686e-03f, -6.87502250e-02f, 1.08382843e-01f, -5.34259677e-02f,
  9.37666968e-02f, 1.17160715e-01f, -6.34691194e-02f, -8.87755752e-02f, 1.02511778e-01f, 1.26832262e-01f, -5.12916408e-02f, 1.27159551e-01f, 1.10710278e-01f, 1.14857353e-01f,
  7.74039179e-02f, -1.09041795e-01f, 6.93342388e-02f, -1.27009470e-02f, 3.70118096e-02f, 6.66991174e-02f, 1.21168308e-01f, -5.36030009e-02f, -6.79853931e-02f, 3.17616574e-02f,
  -3.28531526e-02f, -1.26486560e-02f, 5.91563061e-02f, -1.73316821e-02f, 8.55385810e-02f, -2.22026687e-02f, 8.18161145e-02f, 8.88627023e-02f, 5.18272631e-02f, 1.48620708e-02f,
  8.12010318e-02f, -9.44676548e-02f, -8.29826482e-03f, 3.81663926e-02f, 4.36450280e-02f, -1.58788804e-02f, 2.13960230e-01f, 4.11896892e-02f, -3.34320627e-02f, 7.06945639e-03f,
  1.10401727e-01f, 2.07318500e-01f, -2.50350069e-02f, -1.17566912e-02f, 4.59494442e-02f, -1.33291572e-01f, 9.94614512e-02f, 1.20151974e-02f, -4.94003482e-02f, -4.16658558e-02f,
  -8.16168711e-02f, 2.17750385e-01f, 1.17357553e-03f, 9.36278775e-02f, 1.17258504e-02f, -1.00789525e-01f, 1.52668729e-01f, 1.79110989e-01f, 1.32439464e-01f, -3.84612940e-02f,
  5.15194647e-02f, 1.69159144e-01f, -7.85287693e-02f, 6.66995347e-02f, -7.03376457e-02f, 4.13010363e-03f, 1.70332845e-02f, 8.79885554e-02f, -7.94378370e-02f, 2.94696819e-02f,
  1.43615201e-01f, -6.52214885e-02f, 2.21255608e-02f, 2.21463386e-02f, 1.93591341e-02f, 2.15183608e-02f, -7.51524419e-03f, -4.09645624e-02f, 6.41530678e-02f, -1.39807403e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -3.76410000e-02f, 7.17073828e-02f, 1.77093640e-01f, -1.98595524e-02f, 1.53275549e-01f, 1.50227934e-01f, -4.34887176e-03f, 2.18381640e-02f, 1.35451034e-01f, 8.01594704e-02f,
  1.57600373e-01f, 1.25833735e-01f, 8.89114588e-02f, 2.56087277e-02f, -1.19491979e-01f, 5.67249097e-02f, 5.04689105e-03f, 6.83403164e-02f, 4.53033000e-02f, 1.57195404e-01f,
  1.04880750e-01f, -3.99017558e-02f, 3.16353403e-02f, 8.75959322e-02f, 7.33441338e-02f, 3.17730904e-01f, -1.28737673e-01f, 2.89352667e-02f, 8.28154162e-02f, -8.67291540e-02f,
  -7.75886998e-02f, 7.16674626e-02f, 6.68276176e-02f, 7.47000352e-02f, 1.43994257e-01f, 1.93397492e-01f, 7.81851932e-02f, 1.37070701e-01f, -5.31529114e-02f, 1.40292034e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  4.71807867e-02f, -4.20502573e-02f, 1.86745990e-02f, -3.44642699e-02f, -1.21492632e-02f, 2.45386772e-02f, 1.16460569e-01f, -8.20610821e-02f, -1.35413200e-01f, 1.27059259e-02f,
  1.00034595e-01f, -1.47895694e-01f, 5.29828072e-02f, -2.62228698e-01f, -2.18156829e-01f, -7.05070496e-02f, -1.14875279e-01f, 5.00775501e-02f, 6.44772351e-02f, 1.61715046e-01f,
  4.15922515e-02f, -2.24301651e-01f, -1.55086234e-01f, -2.54487488e-02f, -4.76403125e-02f, -1.38817832e-01f, -3.18812882e-03f, -1.95479795e-01f, -1.08606428e-01f, 1.96254589e-02f,
  -1.08576857e-01f, 1.82358533e-01f, 7.69924819e-02f, -2.66535245e-02f, 9.28563997e-02f, 4.19661514e-02f, 1.65022105e-01f, -4.19284813e-02f, 3.28985006e-02f, -2.88254377e-02f,
  -1.27517775e-01f, -1.10912710e-01f, -2.28559524e-02f, 6.83476776e-02f, -1.07681550e-01f, 1.26314417e-01f, 6.19404912e-02f, 1.52768120e-01f, -1.18329693e-02f, -6.86047897e-02f,
  8.09744671e-02f, -2.88793445e-02f, -4.31022421e-02f, -7.57930614e-03f, -1.17570482e-01f, 7.22820982e-02f, -5.58721973e-03f, 1.39172941e-01f, 2.62490660e-02f, -1.93489507e-01f,
  7.35611543e-02f, 2.54948288e-01f, -1.35981515e-01f, 2.52476707e-02f, -5.17148115e-02f, 9.86007825e-02f, 7.83262700e-02f, -3.33067589e-02f, 6.31178543e-02f, -3.49003635e-02f,
  1.97784957e-02f, -5.28924391e-02f, -4.61347029e-02f, -8.61238912e-02f, 2.79882196e-02f, -8.35955963e-02f, 4.55181524e-02f, 1.85420096e-01f, 1.43515421e-02f, -9.79894921e-02f,
  5.68813309e-02f, -9.72023532e-02f, -1.27098501e-01f, 1.35065883e-01f, 1.79503530e-01f, 1.31515041e-01f, 5.35416529e-02f, 8.34593251e-02f, 1.38798431e-01f, 7.56180882e-02f,
  -9.67879370e-02f, 3.14246386e-01f, 2.99811326e-02f, -6.33144751e-02f, -6.58923909e-02f, -1.33105472e-01f, 1.05244562e-01f, -8.98416936e-02f, -2.34369654e-02f, -1.07041538e-01f,
  4.57176715e-02f, -1.30989432e-01f, 8.71636495e-02f, 2.05121282e-02f, 7.66899288e-02f, 1.22484356e-01f, 8.06876644e-02f, -1.02663808e-01f, 1.18011117e-01f, 4.00841981e-02f,
  -6.90934062e-02f, -1.37342766e-01f, -1.23422123e-01f, 1.17463665e-02f, 4.31359150e-02f, 7.80499652e-02f, -5.52750900e-02f, -6.82240725e-02f, -2.66853236e-02f, -3.96466516e-02f,
  -5.56974746e-02f, -8.65449831e-02f, -8.41198713e-02f, 2.86192261e-02f, -3.70261893e-02f, -1.11377284e-01f, 3.57110761e-02f, 6.60379827e-02f, -1.18269004e-01f, -1.35439470e-01f,
  -7.20247179e-02f, -7.31561482e-02f, -9.34583321e-03f, -5.29304780e-02f, 5.04702702e-02f, -5.23538608e-03f, 2.85939034e-02f, 6.37139082e-02f, -2.45463297e-01f, -1.78198770e-01f,
  2.10102022e-01f, -1.86245173e-01f, -1.25751972e-01f, -2.18748346e-01f, 9.44910720e-02f, -2.27186158e-01f, -6.55239373e-02f, 1.33522034e-01f, -1.32414386e-01f, 5.04444279e-02f,
  5.57094067e-02f, -4.19229269e-02f, -2.87439302e-02f, 7.41433278e-02f, 2.37873599e-01f, 9.00121406e-02f, 8.21024701e-02f, 1.54037639e-01f, -1.92150146e-01f, 9.42213610e-02f,
  1.12659141e-01f, 1.04382157e-01f, -1.41352192e-01f, 3.65167260e-02f, 9.84795094e-02f, -7.49522746e-02f, 8.20305645e-02f, -1.11952029e-01f, -7.89077580e-03f, 1.44304797e-01f,
  -1.03027776e-01f, -4.31286730e-02f, 7.82980248e-02f, -6.72871098e-02f, -8.68014321e-02f, -1.13530941e-01f, 8.08116570e-02f, -2.45460302e-01f, -1.32073807e-02f, -9.61956233e-02f,
  -1.38560608e-01f, 1.83769986e-02f, -5.73960431e-02f, -4.50695977e-02f, 6.11924864e-02f, 1.86092809e-01f, 6.26843348e-02f, 4.24608290e-02f, -6.09776303e-02f, 4.93019968e-02f,
  7.07940683e-02f, 1.11380599e-01f, -9.45311114e-02f, 1.42964602e-01f, 1.21844858e-01f, 3.50413807e-02f, 5.43554649e-02f, -1.47918379e-02f, -5.87290563e-02f, 7.92370737e-02f,
  5.42831868e-02f, -8.55962783e-02f, 5.24008833e-02f, 1.63865741e-02f, 1.45309016e-01f, -1.76905245e-01f, -2.47225925e-01f, 5.81055060e-02f, -2.59702772e-01f, -1.49660572e-01f,
  -2.43428275e-01f, 1.87411442e-01f, 8.03862363e-02f, 4.96587344e-02f, -2.30093092e-01f, 4.76707295e-02f, -6.51960522e-02f, 1.08255066e-01f, 1.29584804e-01f, 1.20212942e-01f,
  1.15940101e-01f, 8.06901231e-02f, -1.51476711e-01f, 9.14009735e-02f, 5.00729233e-02f, -1.35655403e-02f, -1.23166993e-01f, -4.60366644e-02f, -1.03010707e-01f, 8.85967091e-02f,
  -7.87889063e-02f, -1.86568439e-01f, 1.26244381e-01f, -1.69504642e-01f, -2.57470775e-02f, 2.09058691e-02f, -1.29502311e-01f, -8.28910097e-02f, 9.72087011e-02f, 3.82013433e-02f,
  7.23070989e-05f, -1.25103652e-01f, -7.31058270e-02f, -1.45414397e-02f, 5.63578047e-02f, 1.28820345e-01f, -2.32506301e-02f, -1.52307758e-02f, -4.69205566e-02f, 6.65840507e-03f,
  9.78742838e-02f, -1.01804860e-01f, 1.75238490e-01f, 1.05951298e-02f, -1.08708732e-01f, 8.20119157e-02f, 4.03825045e-02f, -6.16554618e-02f, 1.12807684e-01f, 1.45176455e-01f,
  -6.74023293e-03f, 5.54703139e-02f, 1.41429216e-01f, 5.75156212e-02f, 1.44083470e-01f, 1.56584904e-01f, 4.46686447e-02f, 2.00977474e-01f, 4.22094092e-02f, 1.47939175e-01f,
  6.72660321e-02f, 6.22219667e-02f, -5.35607822e-02f, 1.07991897e-01f, 4.61667441e-02f, -3.85112278e-02f, 1.20424367e-01f, 7.12266415e-02f, -5.76100200e-02f, -9.80981975e-04f,
  5.04915603e-02f, 2.81818509e-02f, -4.60165292e-02f, 8.36689547e-02f, -1.29598185e-01f, -7.38288611e-02f, 1.35693043e-01f, -1.67585552e-01f, -1.22380696e-01f, -8.81536976e-02f,
  1.43207833e-01f, 1.42123550e-01f, -3.61314341e-02f, 9.13774669e-02f, -9.36880186e-02f, 1.77538335e-01f, 2.18439817e-01f, 9.77705866e-02f, 1.89363509e-02f, -6.43819124e-02f,
  -6.53105900e-02f, 1.23944983e-03f, -1.34959117e-01f, -1.02823846e-01f, -7.68049136e-02f, 2.00275794e-01f, -7.97585547e-02f, 9.65366140e-02f, -1.19991221e-01f, -7.14621618e-02f,
  -3.30189131e-02f, -1.67420669e-03f, 1.19487010e-01f, -1.05710037e-01f, 7.39992857e-02f, 2.47761592e-01f, -1.79584980e-01f, -2.50443041e-01f, -4.25554737e-02f, 4.82099205e-02f,
  -5.44436388e-02f, -8.35372284e-02f, 5.08526675e-02f, 5.02286777e-02f, 1.24449737e-01f, -7.83397704e-02f, -7.88572729e-02f, 1.22918703e-01f, 1.03600733e-01f, -1.33791059e-01f,
  2.43377447e-01f, -2.66101826e-02f, -1.16621673e-01f, 1.34906232e-01f, 2.40895480e-01f, -7.81578496e-02f, -6.23370372e-02f, -4.19197455e-02f, 1.30905896e-01f, -1.32554188e-01f,
  -4.40752469e-02f, -1.12108074e-01f, 2.22932428e-01f, -1.19157635e-01f, 1.00353127e-02f, -1.33815510e-02f, -2.09344029e-01f, -1.39368027e-01f, -2.80562863e-02f, -9.27915201e-02f,
  -1.29519077e-02f, 4.90684398e-02f, -6.07636943e-02f, 1.27828807e-01f, 2.31119562e-02f, -9.71240103e-02f, -1.20691895e-01f, 1.10918321e-01f, -8.93690363e-02f, -1.16607337e-03f,
  7.97148868e-02f, 4.57272045e-02f, 1.83302108e-02f, -1.72827989e-02f, 8.98722261e-02f, 1.13952495e-01f, 1.21611387e-01f, 1.49872318e-01f, -1.04762137e-01f, 1.21863306e-01f,
  7.41033405e-02f, -9.35253277e-02f, 1.10426232e-01f, -4.98660393e-02f, -9.18951556e-02f, 1.08179882e-01f, 9.25153568e-02f, -1.60245523e-01f, -3.48520391e-02f, 1.25856638e-01f,
  -1.68173894e-01f, -7.12605789e-02f, -1.02525994e-01f, -3.34951864e-03f, 6.11566054e-03f, 1.10339418e-01f, -1.12405173e-01f, 1.13253631e-02f, 3.95778893e-03f, 8.16747174e-02f,
  -1.27732903e-02f, -1.13694891e-01f, -2.14147922e-02f, -8.47710967e-02f, -2.03401953e-01f, -7.54915224e-03f, 9.95026901e-04f, -2.74966896e-01f, -2.61132598e-01f, -1.29870638e-01f,
  7.43527412e-02f, -6.11044280e-02f, -5.56238815e-02f, -9.16123483e-03f, -5.06872870e-02f, 5.53843826e-02f, -2.42161572e-01f, 4.42054309e-02f, -7.72309154e-02f, -1.05772085e-01f,
  2.45612726e-01f, 1.60555437e-01f, 2.06410304e-01f, -3.76103469e-03f, -1.54132068e-01f, -7.46411458e-02f, 2.21976060e-02f, -1.19885020e-01f, -1.04609810e-01f, -5.87519966e-02f,
  2.08685130e-01f, 9.58664343e-02f, -7.70329088e-02f, -4.73024286e-02f, 2.56361370e-03f, 9.01900530e-02f, 7.57032540e-04f, 5.58889546e-02f, 1.83513586e-03f, -8.04967061e-02f,
  -2.29640165e-03f, 3.19938511e-02f, 7.65881166e-02f, -2.79423267e-01f, -1.21068574e-01f, 8.10250714e-02f, 1.50281833e-02f, 9.30000842e-02f, -6.52856950e-04f, -1.06934704e-01f,
  -1.52090807e-02f, 1.00276738e-01f, -3.49606993e-03f, -2.31811866e-01f, 1.48573935e-01f, 1.26177877e-01f, -2.59915348e-02f, -2.34861355e-02f, 4.13560262e-03f, 1.47940237e-02f,
  1.45115197e-01f, -1.22554034e-01f, -1.50152035e-02f, -1.04866475e-01f, -1.30660489e-01f, 2.00365074e-02f, 6.11239634e-02f, 1.05542593e-01f, 1.12827867e-01f, 1.51231274e-01f,
  -3.04523110e-02f, -1.03707239e-01f, 1.08254582e-01f, 1.29743099e-01f, -9.72508490e-02f, 2.01246858e-01f, 1.69182315e-01f, -8.68309103e-03f, 2.30375137e-02f, -1.31394655e-01f,
  3.77119780e-02f, -5.44674024e-02f, -1.06227577e-01f, -4.88293581e-02f, -1.14289701e-01f, -2.22690031e-01f, -1.75187588e-01f, -1.79963931e-01f, 1.49668202e-01f, -7.48453513e-02f,
  -9.76776332e-02f, -9.18694492e-03f, 1.05875902e-01f, 1.62189066e-01f, 1.95342395e-02f, -8.95045176e-02f, 4.52100160e-03f, 2.87233349e-02f, -2.34378558e-02f, -1.57655016e-01f,
  -1.67945363e-02f, 9.19813588e-02f, -4.03497852e-02f, 8.55686367e-02f, 6.18165284e-02f, 1.10626340e-01f, -6.55528456e-02f, 1.67329818e-01f, 9.99386311e-02f, 6.12552576e-02f,
  -1.75806731e-02f, 7.56731629e-02f, 8.54468942e-02f, 2.73628607e-02f, -1.93358792e-04f, 1.86471511e-02f, -1.83087215e-03f, -9.57390890e-02f, -9.87414718e-02f, -6.90049455e-02f,
  -3.85234170e-02f, 1.05122246e-01f, -1.05637005e-02f, 2.93243360e-02f, 1.78868756e-01f, 1.57708064e-01f, 1.03356086e-01f, 3.69021446e-02f, 1.94472894e-02f, 2.72535533e-02f,
  1.58392251e-01f, -1.32192904e-02f, 6.48619905e-02f, 1.57424808e-01f, -5.57607077e-02f, 2.18748257e-01f, 3.84079851e-02f, 1.70436010e-01f, -1.20618440e-01f, -1.58732414e-01f,
  -6.91543147e-02f, -1.02210470e-01f, 8.18132088e-02f, -2.01010779e-01f, -8.58261832e-04f, -2.78155133e-02f, -1.23913236e-01f, 4.79238071e-02f, -2.69325733e-01f, -2.93413326e-02f,
  -1.44939706e-01f, -1.52471989e-01f, 1.45718670e-02f, 9.27862152e-02f, 1.44588023e-01f, -7.30388835e-02f, -8.70414376e-02f, -4.24899757e-02f, -1.55972078e-01f, -1.13404892e-01f,
  1.08078830e-01f, -1.00789592e-03f, -8.64673033e-02f, -6.21234104e-02f, 5.99223487e-02f, -6.37680963e-02f, 4.82380949e-02f, 1.43897131e-01f, -4.46442217e-02f, 8.28687008e-03f,
  2.75489315e-02f, 8.09033141e-02f, -8.17544088e-02f, 2.94180028e-02f, 1.39303684e-01f, 8.88567641e-02f, 3.29034738e-02f, 1.03560366e-01f, 4.75271121e-02f, -1.21204570e-01f,
  9.56886411e-02f, -1.67178791e-02f, 7.02907424e-03f, 4.21864241e-02f, 9.47140977e-02f, 1.04047604e-01f, -1.20684721e-01f, -3.51510942e-02f, 1.46402299e-01f, 9.40295905e-02f,
  -1.10905416e-01f, -3.11011039e-02f, -6.04628064e-02f, 7.07559288e-02f, 6.84778467e-02f, -1.09868690e-01f, -1.98254474e-02f, 2.05118232e-03f, -1.80681556e-01f, -1.22189701e-01f,
  -2.48780459e-01f, 1.39748082e-02f, -4.39543910e-02f, 1.71436965e-01f, 1.64095033e-02f, -4.21376228e-02f, -1.24762774e-01f, -1.39805377e-01f, -2.17636406e-01f, 1.36715442e-01f,
  -1.84609387e-02f, -1.81270510e-01f, 1.73503235e-01f, -1.15833916e-01f, -1.08665183e-01f, -1.14995591e-01f, 1.05463080e-01f, 1.29951343e-01f, 7.22428784e-04f, -8.16895217e-02f,
  8.38624015e-02f, 1.51559368e-01f, 8.99877325e-02f, -2.74678562e-02f, 5.77280186e-02f, -1.29948370e-02f, 1.26515165e-01f, -2.31276453e-01f, -1.29977718e-01f, -4.91996594e-02f,
  -2.28760302e-01f, -1.46885682e-02f, -9.50695798e-02f, -5.34183392e-03f, 5.37167825e-02f, -2.55063381e-02f, -5.76214306e-02f, -9.99468192e-02f, 3.39611284e-02f, -7.34067410e-02f,
  1.07243024e-01f, 1.06210483e-03f, -1.24893308e-01f, 1.37780353e-01f, 1.11119114e-01f, -2.22201705e-01f, -3.07246391e-02f, 1.33900344e-01f, 3.10151950e-02f, 1.06310271e-01f,
  4.73719314e-02f, -4.20040265e-03f, -1.19294496e-02f, 9.67656896e-02f, 1.75749101e-02f, 1.18457519e-01f, 1.46585941e-01f, -1.36652607e-02f, 7.30517730e-02f, -1.08675949e-01f,
  4.78061810e-02f, 2.21170876e-02f, -6.72192127e-02f, 1.40667051e-01f, 1.20255107e-03f, -6.54937178e-02f, -1.69616818e-01f, -1.20432258e-01f, 1.51397452e-01f, 1.29166514e-01f,
  -2.96361037e-02f, 1.28287151e-02f, 1.98396936e-01f, -1.00513853e-01f, -9.24672633e-02f, 1.50758117e-01f, -1.12426601e-01f, -2.74612874e-01f, 2.72631664e-02f, -9.37927961e-02f,
  2.77062841e-02f, -1.36987828e-02f, 3.37488507e-03f, -4.24734764e-02f, -2.15572193e-01f, 1.03032753e-01f, -2.18965113e-01f, -1.25141352e-01f, 1.05698377e-01f, -3.15740258e-02f,
  5.98432943e-02f, 1.28096506e-01f, 8.87838006e-02f, -9.21044424e-02f, -5.49736544e-02f, 7.69492239e-02f, 1.20426379e-01f, 5.69216907e-03f, 3.18993218e-02f, 1.46450654e-01f,
  -9.46889222e-02f, 1.24203190e-01f, -2.95119770e-02f, -1.14967465e-01f, 8.39460269e-02f, 1.06871590e-01f, -1.31931305e-01f, -1.91198811e-01f, 2.03161433e-01f, -5.74637167e-02f,
  -1.09443046e-01f, 9.06200707e-02f, -1.25130609e-01f, -5.82387261e-02f, 9.52042267e-02f, -5.95549606e-02f, 8.50707069e-02f, -3.56613472e-03f, 1.93994213e-02f, 1.06763244e-01f,
  1.17620043e-02f, 1.14372797e-01f, 8.09794888e-02f, -7.80120343e-02f, 8.36524442e-02f, -1.78919081e-02f, -2.54693534e-02f, 1.99265838e-01f, 1.11161456e-01f, -1.93393454e-01f,
  1.32367045e-01f, -2.45004669e-01f, -1.06355660e-01f, -4.37536873e-02f, 2.32256636e-01f, 6.19407045e-03f, 1.25400856e-01f, 1.24227069e-01f, 1.20623551e-01f, 2.78717168e-02f,
  -2.37707824e-01f, 2.70713627e-01f, 1.85266703e-01f, 1.00010686e-01f, -9.15180834e-04f, 9.11553651e-02f, -7.02687949e-02f, 3.28865312e-02f, 2.47431733e-03f, -1.84815720e-01f,
  4.18328270e-02f, 1.18576795e-01f, 2.17825510e-02f, -2.31981575e-02f, 1.97541535e-01f, 8.56309384e-02f, 1.66369155e-01f, -1.30883858e-01f, 1.77696586e-01f, 4.14285846e-02f,
  -7.16344938e-02f, -9.30299088e-02f, -7.36482888e-02f, -1.18462868e-01f, -4.15028334e-02f, 1.65723898e-02f, -5.75598329e-02f, 2.43985374e-02f, -8.39854777e-02f, 6.10310957e-02f,
  7.31788808e-03f, -1.19728327e-01f, -1.65504273e-02f, -2.26048306e-02f, -3.50393791e-04f, -1.99321240e-01f, -8.33390951e-02f, -3.22177373e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  9.10352450e-03f, 1.39237806e-01f, 1.03004456e-01f, 1.08939581e-01f, 3.80136445e-03f, -3.52021120e-02f, -5.23928367e-02f, 1.15130514e-01f, 4.90505435e-02f, 2.02631354e-01f,
  1.23548500e-01f, 1.73746720e-01f, -1.14395685e-01f, 1.20027930e-01f, 8.16485807e-02f, 2.42535174e-01f, -7.07156910e-03f, 3.03598642e-01f, 2.64107063e-02f, -9.42740142e-02f,
  1.54435067e-02f, -1.03719503e-01f, 1.20193928e-01f, -2.03919113e-02f, 4.87943105e-02f, -1.20732442e-01f, 7.71523938e-02f, 1.73796210e-02f, 6.82312204e-03f, 2.23748595e-03f,
  1.79226577e-01f, -1.14462085e-01f, -6.29504845e-02f, 1.69549081e-02f, 4.67715748e-02f, 1.75439551e-01f, -4.72840779e-02f, 2.00078972e-02f, 1.24228552e-01f, 1.52839586e-01f,
  -2.05029454e-02f, 5.91645353e-02f, 2.43962798e-02f, -1.21719331e-01f, -2.27713287e-02f, -7.48180896e-02f, -4.78750933e-03f, -1.40302740e-02f, 4.89087030e-02f, 2.43522838e-01f,
  -1.00190066e-01f, -1.07108347e-01f, -1.41864136e-01f, -1.28063366e-01f, -1.30868908e-02f, -2.98819914e-02f, 7.20421672e-02f, 1.84128448e-01f, 6.47289380e-02f, 2.16959044e-01f,
  -1.15732208e-01f, -6.38028607e-02f, 1.86534435e-01f, -1.42701313e-01f, 1.39887437e-01f, 5.02763726e-02f, 1.43781498e-01f, 1.19718969e-01f, 1.93074271e-01f, 1.40437841e-01f,
  3.52724381e-02f, 9.85248908e-02f, 1.90760657e-01f, 2.01117843e-01f, 8.88528079e-02f, 4.84446585e-02f, -1.35627121e-01f, 2.82147408e-01f, 1.44102871e-01f, -2.46569246e-01f,
  1.45988762e-02f, 8.02081674e-02f, 1.79600000e-01f, -1.50686041e-01f, 2.19939396e-01f, -1.16964333e-01f, 1.62919819e-01f, 4.81465645e-02f, 2.00990960e-02f, 6.23120293e-02f,
  -1.73972845e-01f, 9.29501280e-02f, 8.16093758e-02f, -7.38582760e-02f, 1.35383740e-01f, 2.31691480e-01f, -8.58951807e-02f, 1.21552177e-01f, 1.38841480e-01f, -1.87349133e-02f,
  3.35094444e-02f, -3.60199660e-02f, -1.12662762e-01f, 1.70256242e-01f, 2.01329395e-01f, -4.78933528e-02f, 3.24381530e-01f, 3.09189390e-02f, 1.23289183e-01f, -4.03927220e-03f,
  -1.16823010e-01f, -8.71611312e-02f, 1.19277447e-01f, 1.33634463e-01f, 5.36398701e-02f, -1.04604758e-01f, -1.27027959e-01f, 1.44598365e-01f, -4.02548797e-02f, -1.19520389e-01f,
  -5.27519546e-02f, 5.32942824e-02f, -7.20838690e-03f, 5.44379093e-02f, 1.24731772e-01f, -1.77531868e-01f, 6.03019334e-02f, 1.06679566e-01f, 5.44823073e-02f, 3.66416164e-02f,
  -6.35605007e-02f, -5.19561768e-02f, 1.18403792e-01f, 8.15129876e-02f, -1.47776872e-01f, 1.22156367e-01f, -5.19651473e-02f, 2.75546517e-02f, 1.12536430e-01f, -5.54312468e-02f,
  4.21982333e-02f, 9.63924546e-03f, 1.26079321e-01f, -9.88105088e-02f, 1.25990212e-01f, -1.39008328e-01f, -7.64034763e-02f, 7.30940104e-02f, -2.26751104e-01f, -1.22837245e-01f,
  -1.32241204e-01f, 1.34798825e-01f, -7.75286779e-02f, 2.29575019e-02f, 5.30308932e-02f, 2.75108993e-01f, 2.41634846e-01f, 2.75743455e-01f, -1.92169119e-02f, 2.50310898e-01f,
  5.07516041e-02f, -6.42606318e-02f, 5.81252165e-02f, -7.27020726e-02f, 4.02305052e-02f, 4.24848050e-02f, -5.14245480e-02f, 9.25824344e-02f, -2.08724499e-01f, -6.32711649e-02f,
  -4.13761586e-02f, 1.49374619e-01f, 1.14568785e-01f, 1.18320800e-01f, 8.39353502e-02f, 1.29508302e-01f, 2.40162257e-02f, -7.81554431e-02f, 8.68878793e-03f, -2.61806808e-02f,
  1.09944269e-01f, 3.08253802e-02f, -4.20446023e-02f, 5.38905710e-02f, -1.09632522e-01f, 8.73931870e-02f, -1.35076448e-01f, -6.30161464e-02f, -7.29885176e-02f, 1.82482004e-01f,
  -8.61843005e-02f, -1.34405568e-01f, -1.74722150e-02f, 2.27000471e-02f, 1.97870642e-01f, 1.27271518e-01f, 1.28566399e-01f, 1.32201329e-01f, 1.88729256e-01f, 2.30879933e-01f,
  4.69774753e-02f, -6.71603754e-02f, 1.71221957e-01f, -1.85876386e-03f, 1.13308996e-01f, 2.80768070e-02f, -1.74957871e-01f, -1.03548042e-01f, -1.44133762e-01f, -4.30969428e-03f,
  -2.12963328e-01f, 1.89617664e-01f, 1.05717435e-01f, -7.11251125e-02f, -2.86110103e-01f, 7.06481794e-03f, -6.11898936e-02f, -8.35460424e-02f, -1.61275759e-01f, 4.55232300e-02f,
  2.22626269e-01f, 5.24495728e-02f, -6.15552701e-02f, 1.30025730e-01f, 9.61781368e-02f, -5.05083948e-02f, 8.32275823e-02f, 2.35128822e-03f, 4.79962938e-02f, -6.55942038e-02f,
  4.48907446e-03f, 1.56205948e-02f, 1.54521644e-01f, -6.27193004e-02f, 1.06713317e-01f, -9.23695043e-02f, 4.47281636e-02f, 6.04021996e-02f, 4.86611947e-02f, 1.75045282e-01f,
  4.11942229e-02f, -1.06677271e-01f, 6.18349276e-02f, 1.57996602e-02f, 6.78626895e-02f, -4.37155664e-02f, 4.41650525e-02f, 1.13836400e-01f, 9.80403796e-02f, -1.34123355e-01f,
  3.50271054e-02f, -1.51998013e-01f, 1.78455014e-03f, 2.03793883e-01f, -8.31980407e-02f, 3.96664292e-02f, 1.43313155e-01f, 9.57897305e-02f, 1.89927816e-01f, -6.62486851e-02f,
  1.38516307e-01f, 5.86139876e-03f, -2.89845895e-02f, 1.87796816e-01f, 8.12569261e-02f, -1.16551861e-01f, 2.56438315e-01f, -1.21554332e-02f, -7.58710653e-02f, 2.03550830e-01f,
  2.04778761e-01f, 1.87755898e-01f, -1.16175890e-01f, -9.14187059e-02f, 1.29266262e-01f, -2.28618681e-02f, -1.98056415e-01f, -9.76701304e-02f, -1.11820139e-01f, -7.47275725e-02f,
  -2.23407224e-02f, 1.40912294e-01f, -9.31029245e-02f, -1.73061830e-03f, -7.50660971e-02f, 1.34046957e-01f, 1.24582455e-01f, 1.58736929e-01f, -3.41685163e-03f, -2.85239816e-02f,
  5.08570895e-02f, 1.20110316e-02f, -1.56600401e-01f, 3.59275006e-02f, -5.90270162e-02f, -1.23257143e-02f, -1.61599830e-01f, -1.43205956e-01f, -1.08950295e-01f, -1.97337661e-02f,
  -4.87641953e-02f, -5.95993102e-02f, 8.45027491e-02f, 6.59182519e-02f, 6.18214943e-02f, -2.18143631e-02f, 1.04545549e-01f, 9.15788412e-02f, 1.20723568e-01f, 6.38305619e-02f,
  1.07237391e-01f, 9.94709507e-02f, -4.17397507e-02f, -2.39633650e-01f, 8.47820044e-02f, -1.06650129e-01f, -1.33976325e-01f, 2.99008191e-01f, 1.52346678e-02f, 5.95687740e-02f,
  1.23713121e-01f, -3.18239667e-02f, 4.24825810e-02f, 6.32718345e-03f, 4.92454767e-02f, -1.05658993e-01f, -2.82947980e-02f, -3.94370034e-02f, -8.62340778e-02f, -7.02968761e-02f,
  7.04282522e-02f, 8.79687592e-02f, 2.24172641e-02f, -1.06995568e-01f, 4.51477207e-02f, 1.18219312e-02f, -3.27299535e-02f, 1.17824584e-01f, -1.01574488e-01f, 3.94111648e-02f,
  -6.88532963e-02f, -1.90524030e-02f, 4.28311899e-02f, 7.78324436e-03f, 7.44839907e-02f, 1.29805300e-02f, -4.37953882e-02f, 2.80998945e-02f, -9.59498510e-02f, -1.00025848e-01f,
  2.43677795e-02f, -3.48188169e-02f, -7.63112083e-02f, -6.18377775e-02f, -6.50118813e-02f, -5.94604984e-02f, -1.13742873e-01f, 8.39540884e-02f, -3.12676430e-02f, 1.05333947e-01f,
  -8.09433833e-02f, -1.24011666e-01f, -1.00277558e-01f, 7.90657650e-04f, -1.24402925e-01f, 1.11272275e-01f, -4.22846936e-02f, 1.13919951e-01f, -5.06601632e-02f, -8.34944397e-02f,
  9.36440974e-02f, 8.93321238e-04f, 9.66370329e-02f, -3.36041674e-02f, 6.54880330e-02f, 3.20007801e-02f, 5.19369319e-02f, -4.11308147e-02f, 1.56574771e-02f, -1.05013564e-01f,
  -1.02357641e-01f, -7.18030110e-02f, -1.05453648e-01f, -1.19700909e-01f, 5.23609668e-02f, 4.90244962e-02f, -2.19647475e-02f, 7.62797669e-02f, -4.90015522e-02f, 1.16124377e-01f,
  -1.59906894e-02f, 1.07669085e-01f, 1.02903172e-01f, 1.74199864e-02f, 7.45172128e-02f, -3.99588421e-02f, 1.13144048e-01f, -1.83352195e-02f, 5.80489337e-02f, -2.11699679e-01f,
  -5.47029637e-02f, -2.13541344e-01f, -6.09580092e-02f, -6.32575080e-02f, 1.49264589e-01f, -6.08606935e-02f, 1.53172731e-01f, -3.25352252e-02f, -1.41891120e-02f, 8.11932981e-02f,
  2.93707140e-02f, -1.17090181e-01f, -3.46422545e-03f, -9.74198207e-02f, -5.37519827e-02f, 5.22838645e-02f, 1.47151174e-02f, 3.85553651e-02f, -6.02993667e-02f, 6.26741573e-02f,
  -7.94526041e-02f, -2.59235743e-02f, 1.16079040e-01f, -8.44810531e-02f, 1.73826888e-02f, 2.51786381e-01f, 2.63576537e-01f, 4.48251367e-02f, 8.14476460e-02f, 6.90838844e-02f,
  -3.53657305e-02f, 8.61572102e-02f, 9.74108055e-02f, 1.43002525e-01f, 6.74361959e-02f, -5.25861755e-02f, 5.99357150e-02f, -3.43343355e-02f, -4.85884845e-02f, 1.18044019e-02f,
  1.03584919e-02f, 7.30695501e-02f, 1.50614306e-01f, 6.26991540e-02f, -4.48961146e-02f, -1.83890656e-01f, 6.76394403e-02f, 9.59402695e-02f, 5.59498332e-02f, -3.08626443e-02f,
  2.14590177e-01f, -1.69916786e-02f, 1.31334171e-01f, 1.18354715e-01f, -1.00081883e-01f, -4.83085737e-02f, 1.01506047e-01f, -1.48575576e-02f, 2.58972466e-01f, 2.02127442e-01f,
  -1.94665298e-01f, 9.90706086e-02f, 1.06835596e-01f, 1.16344489e-01f, 1.53959975e-01f, 1.89876422e-01f, 1.39914989e-01f, -5.33154979e-02f, -1.73922181e-01f, -1.05705917e-01f,
  -8.10041875e-02f, -9.36989039e-02f, 8.26957822e-02f, -4.58442643e-02f, 7.65555575e-02f, -2.87838317e-02f, -1.23151757e-01f, 2.51015902e-01f, 2.17761006e-02f, 9.36750136e-03f,
  1.42524227e-01f, 3.89464237e-02f, 1.73854321e-01f, 2.24416852e-02f, -3.66355889e-02f, 3.68340015e-02f, -7.93695673e-02f, 2.10184187e-01f, 1.05746677e-02f, -1.74893469e-01f,
  4.29024696e-02f, 4.27017473e-02f, 2.38748670e-01f, 2.13797733e-01f, 1.71443298e-01f, 1.99903816e-01f, 5.26149385e-03f, 1.52620211e-01f, -2.01232806e-02f, -5.60907973e-03f,
  4.39550132e-02f, 1.05931163e-01f, -6.01818925e-03f, 2.21680216e-02f, 1.46931201e-01f, -1.45269260e-01f, -4.99761328e-02f, 2.13325694e-01f, -2.01278552e-01f, 6.56365231e-02f,
  1.41862616e-01f, -8.04926679e-02f, 1.51810125e-01f, 2.72843003e-01f, 1.31457716e-01f, 9.81754810e-02f, -6.52106255e-02f, -1.04602255e-01f, -1.13670453e-01f, 1.06918782e-01f,
  -1.34421423e-01f, -1.63417011e-01f, 6.86850026e-02f, 9.13129821e-02f, -6.05165511e-02f, 1.16186738e-01f, 2.05067396e-01f, 1.27729908e-01f, 1.26167640e-01f, -2.15616733e-01f,
  -1.45569732e-02f, -6.44514412e-02f, -2.98078388e-01f, -1.23153947e-01f, 1.00492448e-01f, 4.78821248e-02f, -6.43086508e-02f, 1.33294120e-01f, 2.19827220e-01f, 8.51717144e-02f,
  2.01772060e-02f, 1.24594323e-01f, 1.90575764e-01f, 2.22368196e-01f, 4.25029807e-02f, 2.22670641e-02f, -8.23216289e-02f, 7.43889734e-02f, -5.96474931e-02f, 8.09501708e-02f,
  -1.92739610e-02f, -1.88288003e-01f, -3.68646383e-01f, -5.56977987e-02f, -2.04042755e-02f, 8.01605508e-02f, 9.30554792e-02f, 1.10164255e-01f, 1.88928902e-01f, 1.83586568e-01f,
  -1.07908010e-01f, -1.66158020e-01f, 9.15120356e-03f, 1.75608054e-01f, 1.25176460e-01f, 4.96903099e-02f, 1.44806923e-03f, -7.87742585e-02f, -3.63119319e-02f, -2.40220949e-01f,
  -1.69122554e-02f, 3.83011214e-02f, 5.97101562e-02f, 4.64585960e-01f, -1.16005674e-01f, 1.61870912e-01f, -3.26500870e-02f, -1.01740658e-01f, 1.88181400e-02f, -1.06625743e-01f,
  -6.89713359e-02f, -1.04995199e-01f, -1.18423350e-01f, 1.22759342e-02f, -5.91570921e-02f, 1.20861143e-01f, -1.16920434e-01f, -1.22444957e-01f, 1.03487141e-01f, -6.57930411e-03f,
  1.95336957e-02f, -1.11063331e-01f, 5.84861189e-02f, -4.16931361e-02f, 2.39991471e-02f, 4.79948446e-02f, -2.80754678e-02f, 1.20694816e-01f, -2.04244629e-02f, -1.13897230e-02f,
  9.45581570e-02f, -1.09901145e-01f, 4.18945625e-02f, 6.04989454e-02f, 1.19292557e-01f, -1.12261847e-01f, 1.24089889e-01f, -1.13725714e-01f, 8.44281837e-02f, -9.44443867e-02f,
  4.39467691e-02f, -2.23288760e-02f, 3.27499658e-02f, -6.17490411e-02f, -6.40937313e-02f, -8.02092627e-02f, -7.40739629e-02f, -8.25107768e-02f, -8.92903581e-02f, -1.97212445e-04f,
  1.23163648e-01f, 1.20287351e-01f, -7.66225457e-02f, -1.13268420e-01f, -1.08969875e-01f, 9.41038728e-02f, -1.00236014e-01f, 1.15920879e-01f, 1.11376122e-01f, 6.79784492e-02f,
  1.05128415e-01f, -4.91167605e-02f, -1.05633058e-01f, -6.32185563e-02f, 1.46913836e-02f, 3.64945382e-02f, -2.55644377e-02f, 1.83766782e-02f, 6.23465888e-02f, -6.24297783e-02f,
  9.99945924e-02f, -9.85510871e-02f, -2.28606090e-02f, 3.88821680e-03f, 1.29774481e-01f, -2.06860509e-02f, 4.93439101e-02f, -1.13408584e-02f, 4.74216938e-02f, 9.24911499e-02f,
  -1.43772429e-02f, -5.33231124e-02f, 1.04723591e-02f, -7.35135153e-02f, -8.93301070e-02f, -1.83452982e-02f, -1.04273073e-01f, 9.81674492e-02f, 9.27810669e-02f, -2.64011230e-02f,
  -6.48983791e-02f, -1.21855780e-01f, -1.07748553e-01f, 5.51001988e-02f, 7.15777650e-03f, -3.00693400e-02f, 8.66366774e-02f, 2.41327006e-02f, -1.14222199e-01f, -8.71251710e-03f,
  -4.64910232e-02f, -8.48402604e-02f, -5.14822416e-02f, -2.14768648e-02f, -6.19716756e-02f, 4.39247340e-02f, 1.49888977e-01f, 5.99333318e-04f, -1.09501682e-01f, -9.31185409e-02f,
  -2.18669744e-03f, -1.00642167e-01f, -1.76891819e-01f, 9.90653932e-02f, -2.46764813e-02f, -4.21636663e-02f, 6.28832504e-02f, 7.27312863e-02f, -1.08202524e-01f, 8.24142173e-02f,
  3.39546949e-02f, 5.06623425e-02f, 4.18348797e-03f, -8.46720040e-02f, -9.47187692e-02f, 4.74962071e-02f, -7.68158436e-02f, 1.79729849e-01f, 8.10078532e-02f, 5.20490110e-02f,
  5.63581660e-02f, 9.06556323e-02f, 1.13644965e-01f, -7.38332570e-02f, 6.94119036e-02f, 8.43390450e-02f, -4.11712527e-02f, -3.97653878e-02f, 1.10566057e-01f, 3.98212336e-02f,
  -2.34905686e-02f, -1.26277819e-01f, -1.21287264e-01f, 1.96188707e-02f, -3.10834199e-02f, 1.20943449e-01f, -1.92862883e-01f, 1.61807820e-01f, 1.42955780e-01f, -9.51149911e-02f,
  3.55578601e-01f, 7.84810632e-03f, 3.23640972e-01f, -2.54997134e-01f, -2.00958893e-01f, 3.12890708e-02f, 3.58975828e-01f, -8.12930688e-02f, 1.96226090e-01f, 4.30109985e-02f,
  7.04497993e-02f, -1.84285462e-01f, -1.62412360e-01f, 6.76451251e-02f, 9.75778997e-02f, -1.78236924e-02f, 9.78555977e-02f, 1.86466664e-01f, -1.66625336e-01f, 1.86108023e-01f,
  4.84023383e-03f, -9.43492278e-02f, -7.46762753e-02f, 1.93665430e-01f, -2.47856587e-01f, 1.21648140e-01f, 1.01619527e-01f, 9.05046016e-02f, 9.50869322e-02f, 1.79175615e-01f,
  4.56104949e-02f, 2.29826912e-01f, 4.23301794e-02f, 1.35847226e-01f, -9.95619744e-02f, 4.90347259e-02f, 1.60117298e-01f, -7.25912973e-02f, 8.41938257e-02f, 6.87741712e-02f,
  3.85937132e-02f, -2.16826089e-02f, -5.66581450e-02f, 9.27515179e-02f, -8.18248242e-02f, 1.90956071e-01f, 3.45521607e-02f, -3.89293469e-02f, -4.49093208e-02f, 1.30266264e-01f,
  -6.78324746e-03f, 2.67989747e-02f, -3.89950089e-02f, 2.96000559e-02f, 3.55171598e-02f, -2.66595115e-03f, -8.73941630e-02f, 8.65177140e-02f, 6.42908514e-02f, 3.28307003e-02f,
  -4.49530631e-02f, 1.25315174e-01f, -9.47909206e-02f, -9.55696851e-02f, 5.20730466e-02f, 1.36166766e-01f, 5.85350916e-02f, -1.05771594e-01f, -1.52215779e-01f, 3.88468173e-03f,
  9.58067626e-02f, -6.13020882e-02f, -8.69656205e-02f, -9.35115963e-02f, 5.62274829e-02f, 2.92023271e-01f, 1.54728875e-01f, 1.44494221e-01f, -6.35363311e-02f, 7.15783145e-03f,
  -1.22260720e-01f, 1.35501727e-01f, 3.17093022e-02f, 9.09162909e-02f, 7.70272762e-02f, -9.16253217e-03f, -7.99419656e-02f, -2.97618024e-02f, -1.19970761e-01f, 1.68443680e-01f,
  -4.72454727e-02f, 1.13571407e-02f, 1.71823263e-01f, 1.09263152e-01f, -7.15318546e-02f, 1.32148329e-03f, 1.32456645e-02f, -7.53179714e-02f, -8.32075998e-02f, 7.55383670e-02f,
  -1.29136245e-03f, -6.39393330e-02f, 9.56883058e-02f, -1.10460132e-01f, 4.91122417e-02f, 1.08305663e-02f, -1.56628534e-01f, 2.15333551e-02f, -4.97892201e-02f, 2.36402657e-02f,
  3.20344530e-02f, 2.86294110e-02f, -4.39572483e-02f, 1.52683049e-01f, 1.22865409e-01f, 1.01417825e-01f, 1.51973411e-01f, -2.02673320e-02f, -4.76535112e-02f, 4.75451984e-02f,
  4.98152561e-02f, -4.78719883e-02f, 7.79473782e-02f, 1.52989954e-01f, 2.85858307e-02f, -1.84811223e-02f, 3.12223993e-02f, -2.72772580e-01f, -7.38907307e-02f, -2.40679473e-01f,
  -1.28336968e-02f, 1.69602662e-01f, 9.84839052e-02f, -1.75906003e-01f, -7.40695819e-02f, 2.25286298e-02f, -4.72845323e-02f, 1.47119373e-01f, -1.22217415e-02f, 5.79311997e-02f,
  -4.38515330e-03f, -3.35353948e-02f, -1.05324969e-01f, 3.19772154e-01f, 1.89009577e-01f, 9.86591205e-02f, -1.58583909e-01f, -5.81080616e-02f, 5.24052419e-02f, 1.19893616e-02f,
  1.98868178e-02f, -8.87042582e-02f, 2.41066426e-01f, -9.36133880e-03f, 2.58971900e-01f, -8.96977112e-02f, 8.93390626e-02f, 1.12870142e-01f, -1.71828852e-03f, 1.69368580e-01f,
  6.74377829e-02f, 9.53205377e-02f, 3.95910703e-02f, -6.35713264e-02f, 8.89269263e-02f, -2.67140828e-02f, -5.33496663e-02f, 5.48000559e-02f, 4.66196090e-02f, -5.41873090e-02f,
  2.25551605e-01f, -1.38137907e-01f, -6.42576218e-02f, 9.30161998e-02f, -9.09898952e-02f, 1.81843638e-01f, -7.69856274e-02f, -3.41248396e-03f, 1.43918574e-01f, -6.03410532e-04f,
  1.46002039e-01f, 2.73488890e-02f, 6.30270615e-02f, -4.21804525e-02f, 8.25509354e-02f, -9.22530740e-02f, 3.85163426e-02f, -6.30500838e-02f, -5.82069866e-02f, -4.05408777e-02f,
  5.84543459e-02f, -1.95143092e-02f, 6.84939791e-03f, -2.75468171e-01f, 3.25595997e-02f, -7.58090392e-02f, -2.19264731e-01f, 1.08966986e-02f, 1.04583710e-01f, 1.71186686e-01f,
  -1.59971938e-01f, 1.18696854e-01f, 1.39963239e-01f, 1.25068575e-01f, 1.90095842e-01f, 2.51574814e-02f, 1.11445092e-01f, 2.44593397e-01f, 8.74180943e-02f, -8.39042142e-02f,
  -1.21780097e-01f, 1.09716952e-01f, -1.09471038e-01f, 9.06332731e-02f, 1.47967704e-03f, -1.14525400e-01f, -1.56179756e-01f, 3.83324339e-03f, 1.20325632e-01f, 3.09487968e-03f,
  -5.09673581e-02f, 5.53974323e-02f, -7.39332438e-02f, 7.05879629e-02f, -4.20778021e-02f, -9.43462700e-02f, -4.38678488e-02f, 1.06564365e-01f, 1.25418693e-01f, -7.44312555e-02f,
  3.04806344e-02f, -1.93203206e-03f, -5.94970286e-02f, -3.92459892e-02f, 1.36997357e-01f, 1.23202929e-03f, 1.88076019e-01f, 3.77848804e-01f, -2.92719044e-02f, 1.36600971e-01f,
  8.69216695e-02f, 2.49493681e-03f, -3.46948579e-02f, -3.11360173e-02f, 7.74052367e-02f, 1.23876385e-01f, 2.55632848e-02f, -7.13157281e-02f, -5.99719994e-02f, -9.16150287e-02f,
  -1.37934342e-01f, 6.46136478e-02f, 1.16963282e-01f, -1.05483085e-01f, -9.27843004e-02f, 6.85563311e-02f, 1.33814335e-01f, 2.97646578e-02f, 4.62962762e-02f, -5.11982851e-02f,
  -1.19386271e-01f, 2.34625228e-02f, -3.73780057e-02f, -2.51364838e-02f, 5.79777770e-02f, -9.17355716e-03f, 1.13753803e-01f, -4.95569827e-03f, 1.56252727e-01f, 3.61976177e-02f,
  -8.54322314e-02f, 1.13284467e-02f, 4.58850116e-02f, -5.42795546e-02f, -1.38027854e-02f, -9.77230221e-02f, -7.64035210e-02f, 1.09992372e-02f, -7.04004765e-02f, -2.00981903e-03f,
  -7.48723820e-02f, 8.60747397e-02f, 8.55404586e-02f, -8.12392160e-02f, -5.64946234e-02f, -6.37489697e-03f, -1.89002473e-02f, -2.54583824e-02f, 8.98473114e-02f, -1.61122784e-01f,
  3.82024259e-03f, -1.90015957e-02f, -5.18639688e-04f, 2.62088217e-02f, -1.18605815e-01f, -1.12506345e-01f, -4.45344821e-02f, 1.41216189e-01f, 5.65850586e-02f, 3.88968848e-02f,
  -7.89253041e-02f, 1.40235633e-01f, 5.21017760e-02f, 3.84716280e-02f, -3.61580513e-02f, 1.21035218e-01f, 9.46554691e-02f, 1.29930824e-01f, 2.37271693e-02f, 8.50333273e-02f,
  2.83401683e-02f, -6.62495643e-02f, 1.50514707e-01f, -1.23980707e-02f, 6.08595870e-02f, 1.52168736e-01f, -1.78718239e-01f, 1.13766305e-01f, 5.79119734e-02f, -1.15664758e-01f,
  1.03584997e-01f, 3.72672491e-02f, 7.78106973e-02f, -1.98019166e-02f, -1.32270660e-02f, -3.81680951e-02f, -1.77760243e-01f, -9.34908688e-02f, -5.37985861e-02f, -8.03645253e-02f,
  -3.63349393e-02f, 7.87747353e-02f, -5.40395826e-02f, 7.09852995e-03f, 1.21636741e-01f, 1.19463190e-01f, -1.17215114e-02f, 6.48505241e-02f, 8.35409481e-03f, 1.03524916e-01f,
  1.07929058e-01f, -8.18597227e-02f, -1.07447512e-01f, 1.48328366e-02f, -4.47306670e-02f, -6.32181168e-02f, -4.82541546e-02f, -4.99071628e-02f, -2.33052466e-02f, 5.43210916e-02f,
  1.15779780e-01f, -3.44356801e-03f, -1.23445332e-01f, -8.46741721e-02f, 6.77439943e-02f, -4.25675176e-02f, 4.93525639e-02f, 1.78291202e-02f, -1.06740408e-01f, -1.19426154e-01f,
  -5.17182201e-02f, 3.25344093e-02f, 3.37722823e-02f, -1.74538344e-01f, 9.86610353e-02f, 2.82640476e-02f, 2.13385765e-02f, -3.98853561e-03f, 3.30011025e-02f, -1.01340525e-02f,
  -6.23251013e-02f, -1.24556832e-01f, 1.20946737e-02f, 9.54763293e-02f, -1.31345019e-01f, 8.94335210e-02f, -6.04740754e-02f, 1.01660356e-01f, -1.14518709e-01f, 8.34490582e-02f,
  -1.21697843e-01f, -1.09036103e-01f, -5.13182282e-02f, 7.34192729e-02f, -5.78386299e-02f, 3.74977849e-02f, 9.11457166e-02f, 1.01341970e-01f, 3.92495766e-02f, 2.79090740e-02f,
  2.97461096e-02f, 3.73642072e-02f, -1.06696628e-01f, 5.62679917e-02f, -8.87279585e-02f, 7.26848841e-02f, -1.47623280e-02f, -4.50948477e-02f, -3.80715467e-02f, -1.09991692e-01f,
  1.51631413e-02f, -5.79074770e-02f, -3.56556475e-02f, 8.80702883e-02f, -2.35354882e-02f, 9.50935185e-02f, -6.64577261e-02f, 1.19859755e-01f, -1.51904449e-02f, -4.65684794e-02f,
  -7.60201178e-03f, -1.23873778e-01f, 1.28526520e-02f, 8.20054635e-02f, 5.91269247e-02f, -9.26631540e-02f, -2.17346046e-02f, -4.25711200e-02f, 8.79272968e-02f, -4.52387752e-03f,
  -1.91740617e-02f, 2.15514749e-02f, -8.03987458e-02f, -1.14121482e-01f, 3.16326916e-02f, -9.63100269e-02f, -1.53889060e-02f, 1.38479760e-02f, 4.49081175e-02f, 8.35361183e-02f,
  -2.21085940e-02f, 2.71377303e-02f, 5.23503385e-02f, 1.88020959e-01f, -6.91460595e-02f, 2.76173294e-01f, 1.73532411e-01f, 2.49376893e-01f, 1.86864182e-01f, 3.29715339e-03f,
  2.06699342e-01f, -7.40026906e-02f, -1.50930267e-02f, -7.57863000e-02f, -2.53990274e-02f, -1.56355515e-01f, -2.17000693e-01f, -6.63907379e-02f, -5.37322126e-02f, -1.64284632e-01f,
  -1.46976069e-01f, 4.60191183e-02f, 7.62962699e-02f, -1.95938304e-01f, -1.03308864e-01f, 1.90804303e-01f, -1.01785541e-01f, 8.86386186e-02f, 1.09553210e-01f, 9.29798111e-02f,
  3.53732817e-02f, -1.44558713e-01f, 1.16099894e-01f, 2.98224211e-01f, 4.76134457e-02f, -6.49118647e-02f, -1.19839914e-01f, -6.55163918e-03f, -1.04986772e-01f, 1.28392112e-02f,
  6.63477704e-02f, -1.33924797e-01f, 2.30003847e-03f, -1.27097011e-01f, 1.08593017e-01f, 8.22470561e-02f, -6.22852296e-02f, -7.21080452e-02f, -1.26268655e-01f, -5.20231724e-02f,
  -7.41028488e-02f, 9.06291083e-02f, 1.68000497e-02f, 3.52194682e-02f, 3.61120924e-02f, -9.64492112e-02f, -5.29932156e-02f, -8.44387263e-02f, 2.60283053e-02f, 5.40652126e-02f,
  2.56392956e-01f, -1.35320425e-01f, 9.24414918e-02f, 2.94172257e-01f, 2.53943857e-02f, 1.77974269e-01f, 1.32557198e-01f, -1.09511659e-01f, 2.99246423e-02f, 1.50177091e-01f,
  1.81269825e-01f, 1.52868286e-01f, -8.30369592e-02f, 1.13299847e-01f, 3.44899483e-02f, 1.74470529e-01f, 1.24294329e-02f, 9.63579491e-02f, -2.53155351e-01f, 2.60502428e-01f,
  6.92177415e-02f, -8.61592405e-03f, -4.50151078e-02f, 1.98562056e-01f, 3.43767963e-02f, -2.42626682e-01f, -4.65349015e-03f, -4.68947887e-02f, -3.48791853e-03f, 1.23234399e-01f,
  7.64295757e-02f, 1.00506134e-01f, -1.79088935e-01f, 6.55402467e-02f, -6.88024387e-02f, -1.73376799e-01f, 1.74711958e-01f, 4.15984094e-02f, 7.34077394e-02f, -8.38889703e-02f,
  1.28692716e-01f, -7.12232962e-02f, 8.92907605e-02f, -3.80228385e-02f, -1.00033671e-01f, 3.86660069e-01f, 2.18525320e-01f, -2.42286339e-01f, 2.10201606e-01f, -1.08733661e-01f,
  -1.13186225e-01f, -7.92748760e-03f, -1.03226282e-01f, 4.39745672e-02f, 2.67855711e-02f, 3.75199348e-01f, 5.73355369e-02f, -1.55678719e-01f, -9.26970392e-02f, 9.42151472e-02f,
  1.05581306e-01f, 1.66859068e-02f, -3.76055874e-02f, -6.74828812e-02f, 9.11420286e-02f, -1.20216265e-01f, 4.33141105e-02f, -1.10106304e-01f, 9.34076146e-04f, 1.03188278e-02f,
  -3.51650105e-03f, 4.37955931e-02f, 1.84699465e-02f, -6.90316185e-02f, -6.76179230e-02f, -6.56927899e-02f, 1.22897690e-02f, -5.32497354e-02f, -4.80218977e-02f, 4.40748893e-02f,
  -1.25251204e-01f, 9.02488306e-02f, 4.81167203e-03f, 5.46173304e-02f, -6.03385121e-02f, 4.54091616e-02f, 8.62338841e-02f, 1.29031032e-01f, -4.10655439e-02f, 1.09045826e-01f,
  -1.10801339e-01f, 8.85579437e-02f, -5.55928051e-03f, 1.11328654e-01f, 1.07999884e-01f, 4.83851433e-02f, -1.31703764e-01f, -4.08088639e-02f, 5.99858314e-02f, -7.99024254e-02f,
  -4.87291254e-02f, 7.10499585e-02f, -8.13357532e-02f, 3.36079523e-02f, -8.37621614e-02f, 2.78591104e-02f, -1.21551901e-01f, -1.90100074e-02f, -3.42681035e-02f, 1.78300205e-03f,
  8.81837234e-02f, 2.63718646e-02f, -3.08693834e-02f, -2.19390243e-02f, 3.88192572e-02f, -6.56867623e-02f, -7.79220462e-02f, 3.02124564e-02f, 7.76347965e-02f, -2.89812274e-02f,
  6.84010535e-02f, 1.11566693e-01f, -1.40510509e-02f, -2.27189269e-02f, 6.18289411e-03f, -1.08875796e-01f, -1.07870430e-01f, 1.35842180e-02f, 1.14149503e-01f, 1.96538996e-02f,
  -1.22746579e-01f, 4.37851734e-02f, 4.68017049e-02f, 8.56593773e-02f, -1.50112838e-01f, -3.91046330e-02f, -1.39955403e-02f, -1.44226238e-01f, -4.41204431e-03f, -1.24141455e-01f,
  2.63385624e-02f, -7.78866932e-03f, -7.54030719e-02f, -1.35442272e-01f, -1.31239429e-01f, -9.52164978e-02f, -2.95306593e-02f, -1.15825176e-01f, -1.14783436e-01f, -1.25265583e-01f,
  1.00579530e-01f, -9.76668447e-02f, -4.45048921e-02f, -4.38234024e-02f, -7.26400595e-03f, -3.44686816e-03f, 1.18976094e-01f, -5.19593619e-03f, 3.92560661e-02f, -1.41305521e-01f,
  1.96844950e-01f, -9.61579606e-02f, -1.63240675e-02f, 1.01927392e-01f, -3.60410623e-02f, 9.04067457e-02f, -6.67914227e-02f, 3.03708203e-02f, -9.82864201e-02f, 3.04209702e-02f,
  2.20224317e-02f, -8.57576877e-02f, -1.18250698e-01f, -1.01786628e-01f, -9.31641236e-02f, 2.62063947e-02f, 8.85479450e-02f, 8.07064399e-02f, 8.87193680e-02f, 3.83671559e-02f,
  -1.19091019e-01f, 3.76641080e-02f, -8.69915262e-02f, 9.13081542e-02f, 7.36558735e-02f, 9.66615751e-02f, 1.31312991e-02f, 2.22450355e-03f, -8.66444930e-02f, -3.37803252e-02f,
  5.54014742e-03f, 5.11035956e-02f, 8.02712142e-02f, 5.23014255e-02f, 2.56569795e-02f, 1.42973974e-01f, 7.85035919e-03f, -2.33656652e-02f, -3.98704261e-02f, 1.07565537e-01f,
  5.34282858e-03f, -6.67137578e-02f, -6.64785653e-02f, 5.86346257e-03f, -3.08754239e-02f, -9.37175080e-02f, 2.37136297e-02f, 9.91368368e-02f, 1.37798235e-01f, -5.87393753e-02f,
  -1.38168260e-01f, 3.55997160e-02f, 7.70040751e-02f, -1.05210692e-01f, 8.36955681e-02f, 9.64452177e-02f, 1.59150511e-01f, -1.44323073e-02f, 4.92075942e-02f, -7.82223493e-02f,
  3.39675099e-02f, 2.98902649e-03f, 1.24591582e-01f, 4.60637771e-02f, -1.11413255e-01f, -1.15842566e-01f, -4.59393449e-02f, -3.02022584e-02f, -2.01630369e-02f, 1.59265876e-01f,
  1.11015864e-01f, -5.94039038e-02f, -5.48943058e-02f, 1.35906637e-01f, 7.71152824e-02f, -3.51523347e-02f, -5.18448465e-02f, -1.70389339e-02f, 1.35584936e-01f, 3.45905498e-02f,
  1.13123782e-01f, -1.15014508e-01f, 1.05633281e-01f, -1.25234416e-02f, -9.21322629e-02f, 4.12011892e-02f, -4.95770946e-02f, 8.63996968e-02f, 1.02124371e-01f, -3.09936255e-02f,
  -6.96999729e-02f, 4.61480720e-03f, -1.15158424e-01f, -7.74267782e-03f, 6.20211894e-03f, -5.61941043e-03f, -3.96051668e-02f, -9.87132713e-02f, 7.52025098e-02f, -5.59704788e-02f,
  -6.04271740e-02f, -8.89581740e-02f, 1.61036570e-03f, 2.08907887e-01f, 3.95638980e-02f, 4.54179160e-02f, 4.69057867e-03f, 1.62270963e-02f, 9.25290734e-02f, 1.88609943e-01f,
  2.04218522e-01f, 5.98899573e-02f, -1.28248394e-01f, 1.12385564e-02f, 1.30333945e-01f, 1.93103164e-01f, 8.34403653e-03f, -2.75653869e-01f, 1.91517442e-01f, -3.12810570e-01f,
  -3.75153236e-02f, -5.20935804e-02f, -5.58414795e-02f, 1.68468013e-01f, 2.31234118e-01f, 1.88327447e-01f, 2.02750862e-01f, 3.07957947e-01f, 2.73475964e-02f, 5.04814386e-01f,
  3.74011755e-01f, 2.05512285e-01f, -1.64879665e-01f, 1.03100874e-01f, 1.50171772e-01f, -8.69689509e-02f, -1.53112859e-01f, 9.06486064e-02f, -1.15567639e-01f, 3.94374244e-02f,
  8.54788795e-02f, -1.71210095e-01f, 1.09775871e-01f, 4.14080054e-01f, 2.22286835e-01f, 5.40441310e-04f, 3.29338133e-01f, 1.00896418e-01f, -5.84586859e-02f, -1.69623390e-01f,
  -9.86124109e-03f, 4.00382951e-02f, -8.61532092e-02f, 2.44616270e-02f, -4.05850299e-02f, -1.07557230e-01f, 1.22857511e-01f, -1.11341886e-01f, 2.67927498e-02f, -9.56138670e-02f,
  -8.96148980e-02f, -1.65369269e-02f, 1.29458413e-01f, 1.62846103e-01f, 8.68560374e-02f, 2.34145567e-01f, -8.06612596e-02f, 1.59697197e-02f, -1.96949486e-02f, -1.24945000e-01f,
  -5.57964817e-02f, 1.50669422e-02f, -6.98910058e-02f, -7.97179490e-02f, -8.36529136e-02f, -3.78089026e-02f, -1.11076467e-01f, 7.80354589e-02f, -9.17362198e-02f, 9.18041691e-02f,
  -6.96876049e-02f, 3.79584432e-02f, 1.29009545e-01f, 7.92390034e-02f, -4.06473801e-02f, 8.40755999e-02f, -1.31781861e-01f, 1.28481328e-01f, -1.36900728e-03f, -1.51996817e-02f,
  6.97848201e-02f, 7.29514426e-03f, 1.79206595e-01f, 1.10527478e-01f, 5.20302132e-02f, -3.09014246e-02f, 1.13197463e-02f, -1.15294971e-01f, -1.14119448e-01f, -8.44119210e-03f,
  -1.03686385e-01f, 1.48778394e-01f, -3.04479524e-02f, -2.53985617e-02f, -5.42574842e-03f, 5.31459749e-02f, -3.76606137e-02f, 3.39738801e-02f, 2.33611446e-02f, -8.63500834e-02f,
  6.25122711e-02f, 4.81063798e-02f, -3.11591793e-02f, 4.57407013e-02f, 1.46183092e-02f, -5.89411100e-03f, 1.06524289e-01f, -9.76630151e-02f, -5.66624943e-03f, -8.78706500e-02f,
  4.74309213e-02f, -7.85712674e-02f, 5.20133339e-02f, -3.10793556e-02f, -3.89974867e-03f, 1.40990689e-01f, 1.30178398e-02f, 8.39271173e-02f, 3.88111100e-02f, -1.16192535e-01f,
  -2.62699090e-02f, -3.64748873e-02f, 6.48834407e-02f, 7.97564164e-02f, -1.72441572e-01f, -1.03329875e-01f, -2.11895499e-02f, -2.76461355e-02f, 2.42802724e-02f, 1.08369090e-01f,
  -4.90519963e-02f, 7.27417544e-02f, -1.68955401e-01f, -1.11166395e-01f, -6.06696419e-02f, -2.46798694e-01f, 1.51787460e-01f, -2.89773960e-02f, 2.41333083e-03f, 1.73088294e-02f,
  3.04064136e-02f, 1.85418930e-02f, 9.10573304e-02f, 8.11954737e-02f, 5.45296557e-02f, 1.24905119e-02f, 2.01275796e-01f, 5.06724566e-02f, -4.97738570e-02f, -7.26426169e-02f,
  -1.84115455e-01f, 1.71010986e-01f, 5.46082854e-03f, 1.62204653e-01f, -1.71405360e-01f, 8.37740526e-02f, 1.29846200e-01f, 7.48244077e-02f, 6.58718571e-02f, 1.07993364e-01f,
  2.15130433e-01f, -9.92237404e-02f, 1.04335234e-01f, -6.13289438e-02f, -3.17850448e-02f, -2.74252426e-02f, -8.80462527e-02f, -3.71363163e-02f, 3.00911330e-02f, 7.24624917e-02f,
  8.63657817e-02f, -7.18806405e-03f, -1.74477667e-01f, -6.50055483e-02f, 1.05754688e-01f, 6.28008917e-02f, 1.07186921e-01f, 2.88567126e-01f, 1.56590700e-01f, -1.10620841e-01f,
  4.32478152e-02f, 1.12639971e-01f, -1.03291862e-01f, 1.44026712e-01f, -1.20530903e-01f, 5.86722419e-02f, -7.01951012e-02f, -1.20799415e-01f, -5.65928221e-02f, -5.24909794e-02f,
  -5.19459695e-02f, 1.08463445e-03f, -4.31565866e-02f, -6.28398806e-02f, 7.53947906e-03f, 9.37989950e-02f, -6.66502938e-02f, 1.25070632e-01f, 3.88347991e-02f, -3.60628590e-02f,
  2.91303042e-02f, -5.49626574e-02f, -1.87602155e-02f, -9.05175358e-02f, 9.41052437e-02f, -3.51915136e-02f, 1.08708419e-01f, 1.00699887e-02f, 4.01290394e-02f, 1.13054872e-01f,
  9.79932770e-03f, -2.58881859e-02f, 2.49516014e-02f, 2.35441700e-02f, -9.26082730e-02f, -1.17417641e-01f, -1.13179542e-01f, 1.31669685e-01f, 6.80125728e-02f, 3.74875148e-03f,
  3.67488489e-02f, -3.24947760e-04f, 8.22108760e-02f, -6.44734800e-02f, -1.15541317e-01f, 1.05795853e-01f, 2.74415943e-03f, -1.02078944e-01f, -5.95987290e-02f, -6.40032813e-02f,
  1.04740165e-01f, 5.12496335e-03f, 2.65302192e-02f, 5.01835309e-02f, 7.97440186e-02f, -1.14052258e-01f, -7.44051188e-02f, 4.54657264e-02f, 9.02430620e-03f, -1.11165568e-01f,
  5.10328561e-02f, 2.76511274e-02f, -2.64053768e-03f, -1.07322633e-01f, 3.74222584e-02f, -1.13241501e-01f, 5.28247990e-02f, 2.33410671e-03f, 8.90999511e-02f, -1.05819538e-01f,
  -3.39044891e-02f, 8.25084746e-02f, -1.10969745e-01f, -1.47640714e-02f, -1.51852313e-02f, 1.74041558e-02f, -1.06220767e-02f, -1.09994948e-01f, 1.15061618e-01f, -1.31268250e-02f,
  -9.59671736e-02f, 1.39811963e-01f, 1.65952668e-01f, 2.42868960e-02f, -3.97092402e-02f, -7.45008364e-02f, 2.38801874e-02f, 7.94148222e-02f, 1.64853875e-02f, 1.12378441e-01f,
  1.81126967e-01f, -2.64587402e-02f, 2.88698990e-02f, 6.96409047e-02f, 3.67155895e-02f, 6.94960207e-02f, 1.04312599e-01f, -7.77782947e-02f, -2.00912338e-02f, 2.68350039e-02f,
  -1.41832335e-02f, 6.07854165e-02f, -1.11354636e-02f, 3.49868909e-02f, -6.92790598e-02f, 9.32435468e-02f, 5.87836429e-02f, 1.43634886e-01f, 1.59632452e-02f, -1.58952214e-02f,
  -4.58755717e-02f, -1.14436708e-01f, 1.26747489e-01f, -5.35688512e-02f, -1.75059624e-02f, -1.32822290e-01f, -1.15355127e-03f, 8.71247202e-02f, -8.61186013e-02f, 3.02011035e-02f,
  -9.19194371e-02f, -3.43002379e-02f, -6.69906437e-02f, 7.33351931e-02f, 8.97311866e-02f, 1.10900700e-01f, -1.29591674e-01f, 2.25435980e-02f, 6.34430796e-02f, -2.41052490e-02f,
  -1.32693639e-02f, -7.94831589e-02f, -5.69891557e-02f, -6.11393750e-02f, -1.74015433e-01f, 6.62749931e-02f, 3.22193839e-02f, 1.38312876e-01f, -2.48886179e-03f, 1.10441469e-01f,
  1.60088018e-01f, -1.07844338e-01f, 7.37162009e-02f, -4.78827544e-02f, -7.45120719e-02f, -1.73685536e-01f, -1.94876064e-02f, -3.22730243e-01f, 6.63343519e-02f, -2.05901325e-01f,
  1.62389562e-01f, 1.03248544e-02f, 8.91714394e-02f, 2.77786460e-02f, 1.38714895e-01f, 7.12332129e-02f, 4.46889810e-02f, 2.09776998e-01f, -2.28900053e-02f, -2.81071752e-01f,
  3.62187810e-02f, -2.41153181e-01f, -1.73081324e-01f, 2.75345951e-01f, 2.32632682e-01f, 1.32149979e-01f, -2.97381785e-02f, 4.16267477e-02f, -6.02341257e-02f, -1.16717376e-01f,
  9.85309333e-02f, 5.55395856e-02f, 1.50780186e-01f, -5.77323474e-02f, 2.50305176e-01f, 1.01394475e-01f, -7.07018971e-02f, 4.00360785e-02f, -6.28945008e-02f, 2.38209546e-01f,
  1.15175501e-01f, 1.86117545e-01f, 5.00594592e-03f, -2.95168534e-02f, 1.70421720e-01f, -8.69736746e-02f, -5.01232743e-02f, -1.20466605e-01f, 2.81656850e-02f, 3.40964139e-01f,
  3.10082912e-01f, -2.24287763e-01f, 2.70883739e-01f, 2.83623099e-01f, 3.04588620e-02f, 7.11442605e-02f, 1.08633727e-01f, -2.39002071e-02f, -8.70864764e-02f, 1.42570138e-01f,
  7.67252371e-02f, -6.62725568e-02f, -1.84048507e-02f, 7.90101737e-02f, 9.12838802e-03f, -8.30534026e-02f, -6.34547770e-02f, 2.23694762e-04f, -1.33720338e-01f, -3.92377051e-03f,
  -1.67179406e-01f, -5.29288650e-02f, 7.02511966e-02f, 7.96587914e-02f, -1.11038990e-01f, 8.96425545e-02f, 5.42634130e-02f, -5.57211600e-02f, -8.99717957e-02f, 5.02305068e-02f,
  -5.65029569e-02f, -5.71559146e-02f, 1.66498646e-01f, 1.52421489e-01f, 5.92318997e-02f, -9.25262868e-02f, -7.32052699e-02f, -3.26327942e-02f, -1.10373653e-01f, 8.57414827e-02f,
  -1.10354796e-01f, -2.76977625e-02f, 8.03298056e-02f, -4.53461669e-02f, 6.75341636e-02f, 5.65906800e-02f, 1.95448240e-03f, 7.35498359e-03f, -7.39764124e-02f, -3.91894504e-02f,
  -2.81083714e-02f, 8.40376392e-02f, 3.67495045e-02f, -7.82559216e-02f, -6.84863478e-02f, -7.03558847e-02f, 1.20521240e-01f, 2.39261631e-02f, -9.33333933e-02f, 2.05575582e-02f,
  7.73634166e-02f, -4.93391939e-02f, -4.27196622e-02f, 3.16911116e-02f, 1.11375727e-01f, 1.59017611e-02f, -5.16214371e-02f, 8.06254372e-02f, 1.23150840e-01f, 4.14694287e-02f,
  1.30209491e-01f, -1.29232377e-01f, 8.84881765e-02f, 1.71345159e-01f, 4.29002233e-02f, 1.80726517e-02f, 1.16961129e-01f, 1.55980393e-01f, 1.92114949e-01f, 6.83718622e-02f,
  -6.85844868e-02f, 7.50517696e-02f, -1.00001641e-01f, 1.76531494e-01f, -1.36323363e-01f, -1.12853937e-01f, -9.53065082e-02f, -3.63291521e-03f, -9.88391638e-02f, -2.39610448e-02f,
  9.13597122e-02f, 6.28699735e-02f, 4.32227291e-02f, -7.72675052e-02f, 9.71311033e-02f, -6.07762262e-02f, -1.19638488e-01f, -1.85757410e-02f, 5.60354367e-02f, -1.63238809e-01f,
  6.40425682e-02f, 2.42944002e-01f, 6.43426999e-02f, 2.15195864e-03f, 3.22865061e-02f, 1.02362879e-01f, 1.32524278e-02f, -9.48525518e-02f, -1.26484007e-01f, 2.81471252e-01f,
  8.13054666e-02f, -1.20937720e-01f, 3.23232859e-02f, 2.85400916e-03f, 4.54454310e-03f, -1.03490606e-01f, -9.47223678e-02f, -6.98815137e-02f, -1.13526843e-01f, 2.50909597e-01f,
  4.34847176e-02f, -3.73491272e-02f, -6.91148080e-03f, 3.78772728e-02f, 2.48952191e-02f, 2.35010237e-02f, -2.72604097e-02f, 1.18400775e-01f, 4.59282845e-02f, -1.47961244e-01f,
  -4.62894328e-03f, 9.73682106e-02f, 1.22887738e-01f, -9.04674828e-02f, -1.65419895e-02f, 2.80485842e-02f, 1.65550038e-01f, 5.06727137e-02f, -4.90711890e-02f, 1.34302661e-01f,
  1.15799956e-01f, 1.55829862e-01f, 9.92479324e-02f, 3.71852443e-02f, 1.36062965e-01f, 2.98512459e-01f, -2.19015613e-01f, -8.41852352e-02f, -3.88673320e-02f, 2.72751421e-01f,
  -1.10245429e-01f, 3.68454933e-01f, 1.92169443e-01f, -2.29647160e-01f, -2.83907384e-01f, -1.88569099e-01f, -4.97744493e-02f, -1.96454003e-01f, -1.10359989e-01f, -1.35829374e-01f,
  3.10567975e-01f, -2.37565130e-01f, -8.74907449e-02f, 1.19036317e-01f, 1.01884730e-01f, -2.80904710e-01f, -1.82760969e-01f, 1.25289500e-01f, 1.81343034e-01f, 3.34819317e-01f,
  6.02190755e-02f, 8.33508521e-02f, -3.13616619e-02f, 1.22145921e-01f, -6.23180270e-02f, 5.28193861e-02f, 2.51362193e-02f, -9.67904255e-02f, -7.83675537e-02f, -3.24439406e-02f,
  1.84073195e-01f, 3.00510526e-01f, -6.28613159e-02f, 3.46332461e-01f, 1.05072893e-02f, -2.67769489e-02f, -7.61834159e-02f, 1.00728057e-01f, -1.46921529e-02f, 8.16339329e-02f,
  -9.36344117e-02f, 1.75038069e-01f, -1.53136387e-01f, 4.20887679e-01f, -2.23069698e-01f, 2.39234865e-02f, 8.78126323e-02f, -1.47743374e-01f, -1.07318535e-01f, 7.69116580e-02f,
  1.40141500e-02f, -1.15547054e-01f, -1.19113736e-01f, -4.15306678e-03f, 1.12926863e-01f, -1.14377160e-02f, -8.80027935e-02f, -1.17540799e-01f, 1.22424826e-01f, -1.42989345e-02f,
  1.09122403e-01f, 2.10409760e-02f, -1.69537757e-02f, 3.63224745e-02f, 8.36299136e-02f, -6.48035482e-02f, 2.21253596e-02f, -6.36721998e-02f, 5.49077690e-02f, -3.19791585e-03f,
  -8.48453268e-02f, 6.85557351e-02f, -9.66954231e-02f, 1.19212143e-01f, -6.47524893e-02f, 2.39016935e-02f, 2.81198490e-02f, -1.13108205e-02f, -2.42452510e-02f, -9.91604626e-02f,
  -1.03219897e-01f, 8.83911103e-02f, 1.05686262e-01f, -3.77662852e-02f, -1.02837950e-01f, 3.72508243e-02f, -9.80977863e-02f, -7.44437203e-02f, 7.05765784e-02f, -5.61796650e-02f,
  -7.94681236e-02f, 1.35930208e-02f, -3.11652273e-02f, 8.19156691e-02f, -3.45132463e-02f, -4.84705716e-02f, -7.55784959e-02f, 5.51547073e-02f, 8.68628994e-02f, -5.24246097e-02f,
  4.56121564e-02f, 8.95858034e-02f, -1.21285059e-01f, 6.69718720e-03f, -9.43310410e-02f, 8.19539651e-02f, -9.72655714e-02f, -9.42643136e-02f, -4.75543886e-02f, -1.50760217e-02f,
  1.13151498e-01f, 5.93474098e-02f, 4.44708839e-02f, 8.02279711e-02f, 1.66713640e-01f, 6.97262660e-02f, -3.16315074e-03f, -2.77721230e-02f, 8.63619521e-02f, 1.07053541e-01f,
  8.02330077e-02f, -1.55479172e-02f, 1.83102831e-01f, -1.17711946e-02f, -8.63276422e-02f, -9.56504494e-02f, -2.23306511e-02f, 1.66791677e-01f, 1.85187891e-01f, 2.14404136e-01f,
  1.16170421e-01f, -2.53010467e-02f, -1.36591032e-01f, 4.13495228e-02f, 7.39221927e-03f, 5.50623015e-02f, -8.82452577e-02f, -3.44735458e-02f, 6.61642179e-02f, 6.30718283e-03f,
  7.51489028e-02f, 2.14815795e-01f, 2.44861171e-02f, 1.49827257e-01f, 1.53122351e-01f, 1.61241665e-01f, 1.63667947e-01f, 1.40597045e-01f, 1.95496418e-02f, -1.65747292e-02f,
  2.26017665e-02f, 6.21157810e-02f, -1.80208415e-01f, -1.19581573e-01f, -5.27459979e-02f, 1.14459008e-01f, -8.03265534e-03f, 7.75633231e-02f, 4.59945910e-02f, 1.23018175e-02f,
  -4.00056727e-02f, -8.91792178e-02f, -1.06410347e-01f, 3.01050418e-03f, -1.22516379e-01f, 1.09090611e-01f, 9.57543775e-02f, -1.12641208e-01f, 7.95095041e-02f, 1.08021788e-01f,
  -1.70035705e-01f, 1.82247549e-01f, 2.03379877e-02f, 1.73184544e-01f, -3.48416902e-02f, -2.12197565e-02f, 1.79615751e-01f, 2.40518019e-01f, 1.76106542e-01f, 1.39499884e-02f,
  7.33239576e-02f, 1.37642339e-01f, 1.11723863e-01f, 2.77984943e-02f, 3.85972969e-02f, 1.51678279e-01f, 1.79830100e-02f, 1.50902882e-01f, 4.64721546e-02f, -1.54019088e-01f,
  -2.79181860e-02f, 1.01109624e-01f, 4.21995111e-02f, 2.07904384e-01f, -1.02011085e-01f, -6.87986091e-02f, -8.40191320e-02f, 8.33108500e-02f, -1.95199892e-01f, 1.31790921e-01f,
  -1.21516690e-01f, -1.34929538e-01f, 5.18738568e-01f, 2.71167699e-03f, 2.01388597e-01f, 3.71100120e-02f, 2.22718250e-02f, -7.22624287e-02f, -3.22707905e-03f, -5.38626537e-02f,
  8.37414414e-02f, 2.72621006e-01f, 1.92520127e-01f, -1.02542259e-01f, 4.42305859e-03f, -7.50664026e-02f, -8.23062360e-02f, 6.47558197e-02f, -2.08244532e-01f, -7.17081362e-03f,
  -6.22992888e-02f, 2.14254521e-02f, -3.56757008e-02f, 1.63799912e-01f, -6.83797523e-02f, -9.39888582e-02f, 4.28200252e-02f, -9.84390825e-03f, 4.17022333e-02f, 3.71164717e-02f,
  -2.95136357e-03f, -5.71238697e-02f, 6.56357706e-02f, 2.53200948e-01f, 9.21610147e-02f, -5.38976630e-03f, 1.46000251e-01f, 1.33247614e-01f, 3.88699733e-02f, 5.82801513e-02f,
  1.39974028e-01f, 2.55983740e-01f, 2.52790272e-01f, 1.91227436e-01f, 5.96114695e-02f, 1.28760815e-01f, 7.84101114e-02f, 2.87585318e-01f, 1.34114251e-01f, 1.53541774e-01f,
  1.17744543e-01f, 2.43122563e-01f, -2.25080222e-01f, -1.76867485e-01f, -1.76977098e-01f, 2.01367632e-01f, -3.04228157e-01f, 1.65875405e-01f, 1.73299789e-01f, -7.54404217e-02f,
  -1.11385390e-01f, -3.00802350e-01f, -3.40030968e-01f, 2.50937659e-02f, -1.53567940e-01f, -1.61105320e-01f, 2.84046024e-01f, -2.63319075e-01f, -1.45186618e-01f, 4.05202881e-02f,
  -1.22982385e-02f, 8.23075548e-02f, 2.79528685e-02f, 6.03666194e-02f, -6.29262701e-02f, 4.05398130e-01f, 1.05697066e-01f, 1.18009187e-01f, -6.09092712e-02f, 2.68709939e-02f,
  8.55815783e-02f, -3.64865772e-02f, -9.86034274e-02f, 9.29466542e-03f, -9.72485170e-02f, -7.32520968e-02f, 1.15603492e-01f, 3.41244578e-01f, 1.19798467e-01f, 1.75573602e-01f,
  8.00245181e-02f, -5.51197901e-02f, -2.99742334e-02f, -5.20540662e-02f, 5.62853664e-02f, -1.20700367e-01f, 9.82255712e-02f, 2.13913426e-01f, -1.03505030e-01f, -1.56087661e-02f,
  -1.49202412e-02f, 2.00266510e-01f, -2.23834049e-02f, 4.87969927e-02f, -4.94942367e-02f, 5.97535307e-03f, -1.41577020e-01f, -9.96202454e-02f, -5.99063039e-02f, 7.86357597e-02f,
  1.33469212e-03f, -1.13682017e-01f, 6.00762181e-02f, 1.75700076e-02f, 2.67557036e-02f, -1.69253722e-02f, -1.00588046e-01f, 9.23136398e-02f, 1.04961731e-02f, -1.15442604e-01f,
  3.08818743e-02f, 6.25733361e-02f, 1.06894694e-01f, -7.85096586e-02f, 3.29426304e-02f, 1.78159997e-02f, 1.04591437e-01f, -2.15031840e-02f, -1.01205766e-01f, -3.72539200e-02f,
  9.06239823e-02f, 2.04325430e-02f, 4.25761454e-02f, 7.33493939e-02f, -7.13669360e-02f, 1.85438152e-02f, 1.49574161e-01f, 9.36144888e-02f, -6.81615174e-02f, -2.83246227e-02f,
  -3.51902135e-02f, 7.52782747e-02f, -8.63904506e-02f, 5.67366928e-03f, -6.16731029e-03f, 7.66436681e-02f, -6.33162484e-02f, 4.75123301e-02f, -1.04428478e-01f, 1.25621900e-01f,
  1.80415660e-02f, 1.65002063e-01f, 3.96728478e-02f, -4.04932387e-02f, 1.65112838e-02f, -2.13042442e-02f, -5.74290492e-02f, -6.46649376e-02f, 9.41063538e-02f, -1.80165470e-02f,
  -9.40512046e-02f, 1.19826369e-01f, 5.92551269e-02f, 5.31858020e-03f, -4.88036834e-02f, 1.01708136e-01f, 8.45192894e-02f, 6.42262921e-02f, 1.92700163e-01f, -8.40622783e-02f,
  -8.90911594e-02f, 1.12238061e-03f, 4.82236929e-02f, 2.77675167e-02f, 1.93042725e-01f, 1.56358451e-01f, 9.97487605e-02f, 1.22368922e-02f, 1.68883055e-01f, 5.83292060e-02f,
  8.53967890e-02f, 2.73796201e-01f, 2.73533911e-01f, -5.31325042e-02f, 2.55653590e-01f, -7.86149651e-02f, 3.74690033e-02f, -5.42959850e-03f, -1.12393737e-01f, 2.28718609e-01f,
  3.22219253e-01f, 9.15950537e-02f, 1.80772230e-01f, 1.59218073e-01f, -6.27111793e-02f, 4.53593165e-01f, 2.08432972e-01f, 2.96968579e-01f, -1.78736225e-02f, -1.30347371e-01f,
  -4.73257154e-02f, -8.14147480e-03f, -5.10096997e-02f, -1.05584659e-01f, -1.08836256e-01f, 1.50689553e-03f, -4.30929661e-02f, 1.30576208e-01f, 5.68805076e-02f, 3.69497359e-01f,
  2.38784596e-01f, 5.35135046e-02f, 3.41550797e-01f, 8.58404413e-02f, 1.52455181e-01f, -9.56931710e-02f, -4.16661091e-02f, 1.14160098e-01f, -3.74378078e-02f, -4.89293635e-02f,
  -4.32326980e-02f, 7.50996172e-02f, 1.12964593e-01f, -3.10954619e-02f, 7.31492117e-02f, -1.60230026e-01f, -5.61133176e-02f, 3.48481864e-01f, 1.47914821e-02f, -4.12706360e-02f,
  7.37196431e-02f, 1.15788698e-01f, 1.33803561e-01f, 2.15538114e-01f, -6.96850047e-02f, 1.09945841e-01f, 1.33609995e-01f, 1.97684884e-01f, 1.65702611e-01f, 1.07520193e-01f,
  3.55071276e-02f, 1.79434106e-01f, -1.04515240e-01f, 4.69440594e-02f, 2.36787926e-02f, -1.91423908e-01f, -2.63469726e-01f, 1.47322610e-01f, -1.84630319e-01f, -1.15742937e-01f,
  -6.36973558e-03f, 7.27337673e-02f, -2.74510887e-02f, -1.31576713e-02f, -7.19175041e-02f, -4.40750644e-02f, 5.00069410e-02f, -7.16110468e-02f, 4.29124862e-01f, 1.43348202e-01f,
  4.93956022e-02f, 1.43128067e-01f, 1.28668353e-01f, 3.21581066e-02f, -8.04008991e-02f, -1.21922642e-01f, -1.24922812e-01f, 6.11291975e-02f, 1.66597337e-01f, 7.44435042e-02f,
  -6.90207928e-02f, -1.04386806e-02f, -1.41704351e-01f, 5.59232198e-02f, -1.64278761e-01f, 6.91818669e-02f, -8.63121822e-02f, -1.60502225e-01f, 1.37379646e-01f, 6.74786642e-02f,
  -6.81464598e-02f, -1.11617848e-01f, -1.25200361e-01f, 8.51056948e-02f, 6.83781505e-02f, 8.02938417e-02f, -6.07071184e-02f, 1.79996304e-02f, -1.08760655e-01f, 1.16339542e-01f,
  -3.26211862e-02f, 3.50935906e-02f, 1.96500465e-01f, 3.13988894e-01f, 1.22838438e-01f, 2.88828053e-02f, 1.12626448e-01f, -1.07823730e-01f, -1.90700172e-03f, -8.99002329e-02f,
  1.30960799e-03f, -1.38246948e-02f, -4.86937258e-03f, 3.81202810e-02f, -3.02669555e-02f, 9.21580121e-02f, -1.07845306e-01f, -9.31350067e-02f, 3.07024103e-02f, 1.28454179e-01f,
  1.43068850e-01f, -5.40943928e-02f, 7.99969733e-02f, -1.35713089e-02f, 5.07119596e-02f, 3.77727151e-02f, 6.19970374e-02f, -6.22498095e-02f, 1.38972729e-01f, -6.29945621e-02f,
  6.62581921e-02f, 3.60361896e-02f, -6.77133128e-02f, 1.51446313e-02f, 1.29193917e-01f, -8.03495198e-02f, 1.17210366e-01f, 1.00452960e-01f, -3.07108760e-02f, -2.13675015e-02f,
  6.06495664e-02f, -9.24404711e-02f, 2.85870768e-02f, 7.39751011e-02f, -9.49769318e-02f, 8.54625404e-02f, 1.12206221e-01f, 1.34269506e-01f, 2.54446641e-02f, -1.60291083e-02f,
  -6.76152334e-02f, -5.86304814e-02f, -1.02536038e-01f, -2.31246334e-02f, 8.44987705e-02f, 6.15059622e-02f, -2.00200174e-02f, 1.03923641e-01f, -1.14480644e-01f, 7.20150843e-02f,
  8.07571411e-02f, -6.63900077e-02f, 1.01697661e-01f, -1.21592775e-01f, -1.00768387e-01f, -8.72652382e-02f, 1.10854261e-01f, -2.23414693e-03f, -5.75270802e-02f, -2.16387846e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  1.26347542e-01f, 1.54584432e-02f, -6.70166686e-02f, 8.87632817e-02f, 1.94925666e-01f, 1.25346566e-02f, -5.99027090e-02f, 7.69883990e-02f, 1.10375166e-01f, -7.29717016e-02f,
  6.91494122e-02f, 1.40887678e-01f, -5.25842886e-03f, -6.26803786e-02f, -3.59430723e-02f, -6.99095726e-02f, -1.01224538e-02f, -5.69810309e-02f, 1.33450732e-01f, 1.50635332e-01f,
  -1.10752225e-01f, 8.46459270e-02f, 1.41866758e-01f, -1.70036256e-02f, -3.64222601e-02f, -9.68104079e-02f, -8.36005658e-02f, -1.97621062e-02f, 7.18653053e-02f, 1.42206162e-01f,
  1.57011688e-01f, 1.64481238e-01f, -3.79378274e-02f, -4.18410152e-02f, 6.27165288e-02f, 3.25413495e-02f, -5.35761751e-02f, -1.66853536e-02f, 1.79926172e-01f, 7.65270647e-03f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.68378174e-01f, -1.49190694e-01f, 3.91560271e-02f, 1.06912695e-01f, 5.82172396e-03f, 1.00297712e-01f, 1.10312149e-01f, -1.97433289e-02f, 1.81161031e-01f, 4.74636480e-02f,
  9.82945412e-03f, -3.33176166e-01f, -2.34479420e-02f, -4.18723933e-02f, -1.71464294e-01f, 1.11826360e-01f, 8.89533088e-02f, -6.40515462e-02f, -1.18636690e-01f, 3.54051262e-01f,
  -1.06872112e-01f, 1.35137945e-01f, -6.44392669e-02f, -4.13409233e-01f, 3.26589108e-01f, -4.71973240e-01f, -2.03145340e-01f, -2.40042567e-01f, 1.66823328e-01f, -5.92769608e-02f,
  -8.04996565e-02f, 1.04608908e-01f, 4.18835431e-02f, 1.09902442e-01f, 1.48292005e-01f, -4.49275970e-02f, 1.01059638e-01f, -4.03676927e-01f, -6.94921985e-02f, -6.15311004e-02f,
  -1.73263967e-01f, -3.32951285e-02f, -2.23633841e-01f, -2.19061419e-01f, 8.52726549e-02f, -2.30486020e-02f, -8.82510692e-02f, -5.19652784e-01f, 1.07485235e-01f, -2.83735573e-01f,
  -2.94722226e-02f, -5.55811748e-02f, -4.57405567e-01f, -8.92644301e-02f, -1.34813681e-01f, 7.16941237e-01f, -1.03705570e-01f, 8.69206265e-02f, 3.67791533e-01f, 5.40587783e-01f,
  -8.77222717e-02f, -3.15960765e-01f, 2.75096059e-01f, -8.40489045e-02f, 1.17520444e-01f, 1.02845185e-01f, 2.00140268e-01f, 6.39535785e-02f, -8.63192827e-02f, -2.65084929e-03f,
  4.14042510e-02f, 2.58994363e-02f, 3.92547585e-02f, -1.76463947e-01f, 5.19207716e-02f, 2.72272378e-01f, -3.38321745e-01f, 6.03202246e-02f, 7.37467259e-02f, -3.04177433e-01f,
  1.52654409e-01f, 9.24586058e-02f, -2.11169779e-01f, -1.56892329e-01f, 9.83588025e-03f, -4.14474070e-01f, 1.07868396e-01f, 7.56929591e-02f, 2.33636484e-01f, -4.85363640e-02f,
  2.74598729e-02f, 2.27107503e-03f, -8.42622221e-02f, 1.00102358e-01f, 5.76518849e-02f, 3.91654074e-01f, 2.46309265e-01f, 3.69468331e-02f, -8.15154836e-02f, 2.24465027e-01f,
  2.86200285e-01f, -1.31332636e-01f, -9.69883800e-02f, 1.06701314e-01f, -1.34006515e-01f, -5.83402626e-02f, -2.51951516e-01f, -3.90669525e-01f, 6.08564653e-02f, 4.82347906e-02f,
  -1.06907293e-01f, 6.67433739e-02f, 8.81762877e-02f, -1.25731438e-01f, 1.04641177e-01f, -8.63961950e-02f, -4.06570613e-01f, -1.00248605e-01f, -4.17511046e-01f, 3.68844986e-01f,
  4.10406925e-02f, 2.16523618e-01f, 1.16293922e-01f, -1.57977328e-01f, 9.70487297e-03f, 4.22571748e-01f, -1.39640365e-02f, -2.05142155e-01f, -1.33012533e-01f, -2.77470946e-01f,
  3.17420177e-02f, 4.38523479e-03f, -2.60368645e-01f, -4.76160459e-02f, 1.97204977e-01f, -1.61815450e-01f, 1.11517422e-01f, -3.92329752e-01f, 1.08211480e-01f, -4.02584761e-01f,
  -2.66698450e-01f, 3.25281560e-01f, 2.96956934e-02f, -1.36575624e-01f, 1.77574962e-01f, 7.74618611e-02f, -1.69157997e-01f, -1.98967323e-01f, -7.33804405e-02f, 3.66319343e-02f,
  -4.65856045e-02f, 4.62423787e-02f, -7.17920810e-03f, 2.12095022e-01f, 2.15806495e-02f, 3.31227034e-02f, -1.61649704e-01f, -8.60544890e-02f, 1.44265413e-01f, -1.04217850e-01f,
  -3.99326563e-01f, 1.07642442e-01f, -1.11168712e-01f, -7.38093108e-02f, 1.53024226e-01f, 1.42933792e-02f, -2.84203559e-01f, -1.26577213e-01f, -6.15800358e-02f, 1.51623264e-02f,
  -3.06291342e-01f, 6.41716085e-03f, -8.88954289e-03f, -1.21504404e-01f, 5.46477176e-03f, 5.22873998e-01f, -2.88858358e-02f, -1.44050092e-01f, -8.02891627e-02f, 1.68486610e-01f,
  -2.18016282e-01f, -3.32873687e-02f, -7.89146696e-04f, -1.03570014e-01f, -5.70879653e-02f, -2.77178645e-01f, -3.91325116e-01f, -5.19304097e-01f, -1.47513226e-01f, 7.73290932e-01f,
  -2.39674121e-01f, 1.97281972e-01f, -2.74594635e-01f, 1.03780977e-01f, -1.65649250e-01f, -2.02204779e-01f, 4.26887395e-03f, -3.64851534e-01f, -3.72984797e-01f, -1.60274208e-02f,
  -1.04015451e-02f, -7.82534629e-02f, 9.18258280e-02f, 1.43682107e-01f, 2.40942046e-01f, -1.42534897e-01f, 2.72423565e-01f, 3.26650500e-01f, -3.60053957e-01f, -1.99304074e-01f,
  2.76473999e-01f, -2.71219820e-01f, -2.58858413e-01f, 3.88695866e-01f, -2.28612930e-01f, -4.37736005e-01f, -1.05429612e-01f, -3.17401618e-01f, 8.67043138e-02f, 1.16375066e-01f,
  -2.66662329e-01f, -3.73375677e-02f, -8.07789937e-02f, -4.69594896e-01f, -1.06889501e-01f, 6.28475770e-02f, 1.92663744e-01f, -4.31694627e-01f, -4.63317521e-02f, 2.41791308e-02f,
  1.99081138e-01f, 1.33430436e-01f, -1.07049234e-01f, -5.44160344e-02f, 4.55888510e-01f, -1.73112050e-01f, 4.56792675e-02f, 9.28156078e-02f, -1.28429800e-01f, -1.55579731e-01f,
  -1.26663551e-01f, 1.12300232e-01f, -9.17899460e-02f, 9.14810076e-02f, 2.89742768e-01f, 1.41922504e-01f, -2.80798059e-02f, -2.79081583e-01f, -8.66231683e-04f, 5.58775812e-02f,
  4.34964359e-01f, 1.20261826e-01f, 2.49906275e-02f, -4.70960855e-01f, 5.14245689e-01f, 9.34520271e-03f, 1.68817118e-01f, 6.91440254e-02f, 4.72981155e-01f, 2.38209054e-01f,
  1.25546694e-01f, 2.36846000e-01f, 2.17410430e-01f, 2.14677379e-01f, 1.06855452e-01f, 3.94662432e-02f, 2.20312804e-01f, 1.14878498e-01f, 2.06207007e-01f, -1.18855484e-01f,
  -2.21092626e-01f, 3.32860947e-01f, 3.39576364e-01f, -2.69427955e-01f, 2.82285392e-01f, -1.84862968e-02f, 1.05960600e-01f, 2.65148371e-01f, 1.04648136e-01f, -1.61222994e-01f,
  1.51171669e-01f, 2.15664685e-01f, -3.13597053e-01f, 3.33737016e-01f, -2.07583994e-01f, -1.05568163e-01f, 9.01046321e-02f, -2.16977134e-01f, -3.57035816e-01f, -7.28502423e-02f,
  1.05119489e-01f, -3.83320481e-01f, 1.54759949e-02f, 1.26458690e-01f, -2.51763791e-01f, -7.18685910e-02f, 1.68411016e-01f, 6.08443990e-02f, 3.18960518e-01f, 1.61018744e-01f,
  1.02568172e-01f, -1.22484945e-01f, -3.59494798e-02f, -1.63276717e-01f, -1.28062651e-01f, 1.55068308e-01f, -1.09626025e-01f, -8.04910362e-02f, 1.56520665e-01f, 1.48960933e-01f,
  3.37027997e-01f, 2.12334201e-01f, 1.16071455e-01f, -1.55746907e-01f, 2.28089377e-01f, 5.82249582e-01f, -3.89649868e-02f, -3.52079868e-01f, 2.29735434e-01f, 3.05552408e-02f,
  1.93032682e-01f, 1.74292026e-03f, -1.79085433e-01f, 2.06578672e-01f, 3.14803839e-01f, 1.10571897e-02f, 9.98064280e-02f, 1.34894907e-01f, -1.20000921e-01f, 1.39612406e-01f,
  -1.12179719e-01f, 1.78832486e-01f, 1.57670498e-01f, -1.43265367e-01f, -4.46728498e-01f, -2.05806509e-01f, -1.08398544e-02f, 2.18557909e-01f, -3.25272381e-01f, 7.30346516e-02f,
  3.19027275e-01f, -3.76130939e-02f, 2.52415687e-01f, -3.65868568e-01f, -1.45346986e-03f, -1.14281490e-01f, 1.05072051e-01f, 8.79940484e-03f, 4.66569006e-01f, -2.62581673e-03f,
  -1.11278921e-01f, 2.19158933e-01f, 5.05243719e-01f, 4.54325452e-02f, 1.67748537e-02f, 4.17643636e-01f, -1.50880054e-01f, -8.25235154e-03f, 2.34108448e-01f, -1.25130877e-01f,
  9.31937620e-02f, 3.84329706e-02f, 2.04587206e-01f, 2.24772960e-01f, 1.24333939e-02f, -1.32040516e-01f, 5.42567708e-02f, -2.97019452e-01f, -8.88635144e-02f, -3.03942472e-01f,
  -1.05107851e-01f, -4.74441871e-02f, 1.56895772e-01f, -3.41966562e-02f, 4.02754582e-02f, 1.28458902e-01f, -1.05901942e-01f, 2.94171162e-02f, -1.77365556e-01f, 1.23935506e-01f,
  9.77581069e-02f, -1.54821679e-01f, -3.13179102e-03f, 4.07576300e-02f, -4.19947915e-02f, 1.05463743e-01f, 5.67533001e-02f, 3.91302817e-02f, -1.47020057e-01f, 9.19909850e-02f,
  -7.50936046e-02f, 2.58968532e-01f, 1.72468182e-02f, 3.30537278e-03f, 2.64970604e-02f, -1.98781550e-01f, -3.38894218e-01f, 1.53719157e-01f, -1.90076858e-01f, -1.15475707e-01f,
  1.21239722e-01f, 2.68541932e-01f, -3.35138649e-01f, 2.71093417e-02f, 2.29245394e-01f, -3.49015534e-01f, 3.27527732e-01f, 4.36464816e-01f, 6.20333441e-02f, 4.93401051e-01f,
  -2.01800525e-01f, -2.60380894e-01f, -1.84857443e-01f, -3.81650440e-02f, 3.21490675e-01f, -4.22655903e-02f, -2.83259362e-01f, -6.22112397e-03f, -8.44335854e-02f, 2.11133182e-01f,
  -9.40704793e-02f, 1.93598568e-01f, -1.36625282e-02f, 1.94829293e-02f, -1.43273011e-01f, -1.00472324e-01f, 9.66165438e-02f, 2.71038055e-01f, 1.13964640e-01f, 8.79322365e-03f,
  1.91970542e-01f, 1.53970227e-01f, -7.08415434e-02f, 2.23212689e-01f, 2.39927061e-02f, 1.79728642e-02f, 4.24385130e-01f, 3.59254926e-02f, 2.05443442e-01f, -2.46299475e-01f,
  1.01475596e-01f, -3.60436201e-01f, -3.90830040e-01f, -3.91921252e-01f, 3.17522255e-03f, 6.11110888e-02f, -3.61233503e-01f, 1.16542503e-01f, -2.82321364e-01f, -3.40562999e-01f,
  -1.20053478e-01f, 6.22342490e-02f, -1.61905199e-01f, -2.99223959e-02f, -2.08369359e-01f, -1.46191925e-01f, -3.09050232e-01f, -2.05674976e-01f, -3.14663321e-01f, -2.93946236e-01f,
  7.58781731e-02f, -7.09819943e-02f, 2.80709088e-01f, -4.60276976e-02f, -3.87744457e-01f, -6.46156222e-02f, 2.17149988e-01f, 8.88719335e-02f, -2.49087423e-01f, 9.40228477e-02f,
  -2.13198170e-01f, -2.67871529e-01f, -4.03043367e-02f, -6.57646284e-02f, 2.07909226e-01f, -1.22187845e-01f, -2.87670046e-01f, -7.62056634e-02f, -1.09283008e-01f, 1.08548909e-01f,
  -4.56777848e-02f, 4.93531488e-02f, 1.12535372e-01f, 3.03253740e-01f, 1.28846064e-01f, 6.27612770e-02f, -3.43299918e-02f, -1.58569328e-02f, 1.45174548e-01f, -6.77744523e-02f,
  -2.56308079e-01f, -1.11997500e-01f, -2.05579363e-02f, 2.39376992e-01f, 2.66219079e-02f, -2.57192492e-01f, 3.55632342e-02f, 3.79401922e-01f, -9.27291904e-03f, -5.76798543e-02f,
  3.30789953e-01f, 7.27884993e-02f, 2.63484232e-02f, 2.48637810e-01f, -3.51602100e-02f, 2.72452533e-01f, 1.56177104e-01f, 3.08061391e-01f, 2.05996886e-01f, -2.39213169e-01f,
  -8.61830264e-02f, 4.87588346e-02f, -6.52523637e-02f, 1.50532862e-02f, -1.37921616e-01f, 1.18306138e-01f, 1.94222316e-01f, -6.74388930e-02f, 6.91474695e-03f, -1.81357950e-01f,
  3.58961076e-02f, -1.03420153e-01f, 1.28507167e-02f, -1.21260397e-01f, -2.75644928e-01f, 1.36726692e-01f, 2.63929725e-01f, -3.66809266e-03f, -3.17262076e-02f, -6.49645776e-02f,
  3.00613403e-01f, -9.87833217e-02f, -1.19895279e-01f, -2.71666706e-01f, 7.27145448e-02f, 3.77958864e-01f, -7.99475014e-02f, -1.28272727e-01f, -1.30001873e-01f, -3.48476946e-01f,
  -1.18408769e-01f, -1.06123455e-01f, 7.99827054e-02f, -3.59242231e-01f, 3.38002473e-01f, 6.05262965e-02f, -4.66979034e-02f, 2.27509469e-01f, 6.72302097e-02f, -8.13463330e-02f,
  3.02340180e-01f, 1.45883426e-01f, -1.64650753e-01f, 9.64253470e-02f, 1.35926977e-02f, -3.43381017e-01f, 4.89464439e-02f, 1.35380730e-01f, -1.17032036e-01f, 5.73253632e-01f,
  1.53712854e-01f, 1.79845810e-01f, -1.06617108e-01f, 1.11112066e-01f, 1.32178888e-01f, -3.14761214e-02f, -1.33405074e-01f, -4.34859812e-01f, -8.72511491e-02f, -1.15910560e-01f,
  7.53211752e-02f, -4.72488254e-01f, 4.43395004e-02f, 2.74214178e-01f, 1.39791280e-01f, -2.17407010e-03f, 1.74782097e-01f, 2.16648370e-01f, -4.04682308e-01f, -3.12660355e-03f,
  -3.71538103e-01f, 4.24432009e-02f, -2.74472833e-01f, -1.95943806e-02f, -4.54532132e-02f, 2.37095341e-01f, 4.05057147e-02f, 2.78939992e-01f, -2.72679061e-01f, 4.30959798e-02f,
  -3.00471008e-01f, -3.63162398e-01f, -2.98643503e-02f, 2.02835590e-01f, -2.18309805e-01f, 2.93490350e-01f, 1.17042646e-01f, -1.46029994e-03f, -5.88064454e-02f, 2.22600192e-01f,
  4.56622005e-01f, 3.54595184e-01f, -2.64860958e-01f, -1.39790818e-01f, 9.86085385e-02f, 8.24430734e-02f, -2.14118868e-01f, 4.18594688e-01f, -4.12107229e-01f, 3.46467234e-02f,
  -9.80960131e-02f, 6.85321018e-02f, -9.85953137e-02f, -2.29751199e-01f, -3.53954494e-01f, -1.50755588e-02f, 6.60675839e-02f, 1.08887866e-01f, -3.02203834e-01f, 5.93797088e-01f,
  -1.25229880e-02f, 7.68499002e-02f, 1.45695776e-01f, -4.77854013e-01f, -8.93569663e-02f, -5.16967922e-02f, -4.02414314e-02f, 1.20769627e-01f, -1.80893302e-01f, 4.38778624e-02f,
  2.74077535e-01f, 3.22664917e-01f, -7.02478066e-02f, 1.40478000e-01f, -1.07570201e-01f, 7.57473484e-02f, -7.19920546e-02f, -3.43011729e-02f, -3.45711917e-01f, -7.25577725e-03f,
  2.06018329e-01f, 1.12061374e-01f, 6.19824650e-03f, -2.28755578e-01f, 2.11745463e-02f, -1.61083356e-01f, -2.39680842e-01f, -1.93750843e-01f, 1.56526536e-01f, 2.86655009e-01f,
  -1.99179187e-01f, -5.94321527e-02f, 1.51194468e-01f, 1.84605047e-01f, 3.60999584e-01f, 2.95929849e-01f, -2.51298815e-01f, -2.46345863e-01f, 3.32234234e-01f, -1.68378398e-01f,
  3.89208719e-02f, -7.56117254e-02f, -3.30373526e-01f, 3.33147407e-01f, -2.45500237e-01f, -2.42934301e-02f, 5.08185506e-01f, 2.99011856e-01f, 2.25872502e-01f, 3.36830467e-02f,
  -3.06884229e-01f, 1.94461402e-02f, 3.29232424e-01f, -9.80595872e-02f, -1.59268364e-01f, -4.12676185e-01f, 1.87946111e-01f, 9.18644890e-02f, 2.73429960e-01f, 1.00161672e-01f,
  1.61138773e-01f, 5.37399910e-02f, 1.32741734e-01f, -1.08889721e-01f, 1.01834625e-01f, -1.67843983e-01f, -1.87463649e-02f, 3.17225039e-01f, -7.17783496e-02f, -8.51475969e-02f,
  -5.64710163e-02f, -1.47393897e-01f, -3.58546257e-01f, 1.13709100e-01f, 7.69329369e-02f, -4.72417027e-01f, -2.11994741e-02f, 2.09278494e-01f, 1.28332213e-01f, -1.43463001e-01f,
  -1.13524042e-01f, -3.17473076e-02f, 1.87114403e-01f, -5.42895161e-02f, 2.80140042e-02f, 1.59472093e-01f, 2.21626073e-01f, -9.38598216e-02f, 3.95307355e-02f, 2.46470302e-01f,
  3.15309286e-01f, 2.07600698e-01f, -1.03440784e-01f, 2.31890604e-01f, 1.00262552e-01f, 9.80024040e-02f, 3.93289655e-01f, -4.22862545e-03f, 1.38386428e-01f, 3.51666272e-01f,
  -1.69744328e-01f, 2.07202494e-01f, 3.54196802e-02f, -7.08164126e-02f, 2.95620650e-01f, 1.02823220e-01f, 3.17758858e-01f, 2.08832219e-01f, -3.47285599e-01f, 2.90277298e-03f,
  2.20072381e-02f, 4.26437408e-01f, 2.56233960e-01f, -6.45950586e-02f, 2.49038056e-01f, -1.21147782e-02f, 2.56122023e-01f, -1.21719547e-01f, -2.48265952e-01f, -2.69752949e-01f,
  -2.17441022e-01f, 6.02079451e-01f, 1.91058964e-01f, -1.53684199e-01f, 8.72547831e-03f, 1.79245453e-02f, 1.81607589e-01f, -1.66639850e-01f, 1.18499741e-01f, 5.80420829e-02f,
  9.25445184e-02f, 1.27821833e-01f, 1.67146735e-02f, 1.64438449e-02f, -3.98327336e-02f, -6.28736019e-02f, 3.60117912e-01f, -1.34972453e-01f, -4.25279359e-05f, -4.15703207e-01f,
  -8.34332332e-02f, -7.12184757e-02f, -1.96043521e-01f, 5.74395545e-02f, -4.09269780e-02f, -1.06493279e-01f, -2.12329239e-01f, -5.26976362e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.42325587e-03f, -8.15664008e-02f, 4.05203141e-02f, 6.20839559e-02f, 8.97498280e-02f, 9.03390124e-02f, 1.37430280e-01f, -8.14658329e-02f, -1.31866977e-01f, 1.17284447e-01f,
  -1.43099904e-01f, -9.85286683e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    