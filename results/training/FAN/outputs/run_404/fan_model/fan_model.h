/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.95165002e-01f, -5.33790648e-01f, -5.03622770e-01f, -5.55598885e-02f, 2.62856007e-01f, -9.99707729e-02f, 2.30284557e-01f, -4.49044928e-02f, 9.04928446e-02f, -2.45653763e-02f,
  2.04949751e-01f, -1.70642048e-01f, 9.31941569e-02f, -7.98562542e-02f, -4.26393636e-02f, -7.56216571e-02f, 3.95908803e-02f, -4.44581769e-02f, 2.68064812e-02f, -3.91812101e-02f,
  -9.73717794e-02f, 8.47184658e-02f, -2.20824987e-01f, -5.51172420e-02f, -1.28461063e-01f, -1.18114054e-01f, 1.34082526e-01f, 3.32211293e-02f, 3.32151651e-02f, 4.35006022e-02f,
  3.53073515e-02f, -4.80394810e-02f, -1.97050750e-01f, -1.67890295e-01f, -1.77183971e-02f, 3.60533521e-02f, 5.27191814e-03f, 8.49184245e-02f, -1.74148567e-02f, -2.50864178e-02f,
  -1.84603879e-04f, -5.65968752e-02f, 5.00067584e-02f, -6.63272887e-02f, -1.69346817e-02f, -9.96952131e-02f, -2.16029957e-02f, -7.46467337e-02f, 7.88956136e-03f, -1.23006165e-01f,
  -8.70316327e-02f, -8.49004239e-02f, -7.07258135e-02f, -1.18195094e-01f, -6.38637459e-03f, -4.47637476e-02f, -4.32332121e-02f, -8.19734484e-03f, -4.38071266e-02f, 1.45746171e-02f,
  -1.84087511e-02f, 1.12192608e-01f, -2.17574388e-02f, 2.91531179e-02f, -7.59952795e-03f, 2.35636756e-02f, -2.02606656e-02f, 4.57708128e-02f, 3.59353796e-02f, 6.58052340e-02f,
  5.64632043e-02f, 1.97688378e-02f, 5.68923056e-02f, -1.20023126e-02f, 3.92738655e-02f, -1.93413533e-03f, 8.12013820e-03f, -5.30008925e-03f, 5.29744178e-02f, 7.00325221e-02f,
  -2.78782900e-02f, 5.55641251e-03f, 1.96880884e-02f, 6.74882680e-02f, -5.25862873e-02f, -1.03526637e-02f, -4.19926234e-02f, -9.31510031e-02f, -2.71692052e-02f, 1.20622955e-01f,
  8.56957436e-02f, 2.45537981e-01f, 1.12403974e-01f, 5.93400337e-02f, -2.56375317e-03f, 1.29538793e-02f, -9.31217000e-02f, -1.21390289e-02f, -5.48114590e-02f, 6.92177862e-02f,
  5.76437265e-02f, 2.23210715e-02f, 2.98795309e-02f, 9.49976593e-03f, -2.90509723e-02f, 1.65153012e-01f, 6.41763285e-02f, 1.03998976e-02f, 1.10598011e-02f, 3.84517238e-02f,
  -4.46348600e-02f, 4.05092835e-02f, 1.30908061e-02f, 4.84792069e-02f, 4.73063216e-02f, 6.85416758e-02f, 4.87631075e-02f, -6.32684492e-03f, 6.37521502e-03f, 2.35457458e-02f,
  -7.55771279e-01f, -1.45703539e-01f, 7.03710318e-02f, -4.35829192e-01f, 8.75288248e-02f, -2.36760825e-01f, -1.17360577e-01f, 8.16564076e-03f, -4.60439950e-01f, -5.49395829e-02f,
  7.70698041e-02f, -2.48923719e-01f, 1.65286615e-01f, -2.75846183e-01f, 2.45951321e-02f, 1.09253034e-01f, -1.72693178e-01f, -9.47993621e-02f, -2.12617666e-02f, -3.89187820e-02f,
  6.53691730e-03f, -2.20711697e-02f, 1.66683972e-01f, 4.72245105e-02f, -2.81848144e-02f, -9.89201292e-02f, 2.07253978e-01f, 1.60557285e-01f, -8.68731886e-02f, -1.25703393e-02f,
  -3.61201204e-02f, 4.78390902e-02f, -4.68411259e-02f, -4.12469767e-02f, -1.10975979e-02f, 6.82738330e-03f, 3.61126252e-02f, 7.67296413e-04f, -1.07782660e-03f, 4.05084938e-02f,
  -3.04630846e-02f, 4.32957821e-02f, -2.82732248e-02f, 7.77761219e-03f, -1.06077142e-01f, -7.78864622e-02f, -7.88801908e-02f, -3.51301245e-02f, 2.60098781e-02f, -1.95817277e-02f,
  -2.47220583e-02f, 2.22506225e-02f, -2.13734824e-02f, -1.03626460e-01f, 3.36245932e-02f, 7.13840872e-02f, -2.74329074e-02f, 1.73390228e-02f, -3.11196167e-02f, -1.07696950e-01f,
  -7.29960129e-02f, -3.57268117e-02f, -5.91653101e-02f, -1.15899723e-02f, -6.98833987e-02f, -2.80717406e-02f, -9.89337801e-04f, 8.55994690e-03f, 9.08108521e-03f, -5.16289882e-02f,
  -2.45634262e-02f, 1.24694677e-02f, -4.15321477e-02f, -3.84786818e-03f, -9.35534537e-02f, -4.22908068e-02f, 1.27984844e-02f, -4.21577990e-02f, -4.19451222e-02f, -1.59342736e-02f,
  8.17203298e-02f, -2.61055492e-02f, -1.35515081e-02f, 6.01509660e-02f, -2.02850923e-02f, 6.29040897e-02f, -2.58162860e-02f, -3.27799581e-02f, 3.35821658e-02f, 2.59570610e-02f,
  1.13121428e-01f, 5.13156019e-02f, 6.44800663e-02f, 1.07765791e-03f, 3.38508636e-02f, 1.43594630e-02f, -5.57232574e-02f, -6.61849752e-02f, 3.55954953e-02f, -5.66978417e-02f,
  -6.21997118e-02f, -7.68695772e-02f, -4.17920910e-02f, -2.06414536e-02f, -2.22818498e-02f, -2.21655481e-02f, 3.89690921e-02f, 7.45237842e-02f, 3.80968815e-03f, 1.30582945e-02f,
  4.00678441e-02f, -5.40225767e-02f, -4.00030799e-02f, -1.40081614e-03f, 2.22252812e-02f, -7.15952143e-02f, -6.42192885e-02f, -1.76025815e-02f, 6.06050231e-02f, -8.49568844e-03f,
  7.95504153e-02f, 3.39257479e-01f, 9.20321494e-02f, -1.50480673e-01f, -1.99874467e-03f, -4.13778335e-01f, -5.47485650e-01f, 1.36481076e-01f, -8.38770643e-02f, 4.97732460e-02f,
  -1.45238280e-01f, -2.69547641e-01f, -3.58201787e-02f, -2.08009660e-01f, -4.61089700e-01f, -1.45758793e-01f, -3.26297075e-01f, -2.54484732e-02f, 7.19094574e-02f, 7.60872811e-02f,
  -9.12628323e-02f, -3.66627201e-02f, -1.19401515e-01f, 2.51138598e-01f, -3.91438641e-02f, 1.38222843e-01f, 2.58966506e-01f, 4.96569201e-02f, 1.69626251e-01f, -1.88376263e-01f,
  6.16643988e-02f, 1.40729129e-01f, -1.76151190e-02f, 4.35332321e-02f, -6.94538653e-02f, 3.73020917e-02f, 9.42084640e-02f, -8.99116918e-02f, 1.32088913e-02f, -1.07623376e-02f,
  3.66972387e-02f, -7.16966093e-02f, -6.05652332e-02f, -5.86932637e-02f, -1.09938299e-02f, 8.71621743e-02f, 2.05615698e-03f, -1.96300875e-02f, -9.96779371e-03f, -2.28007473e-02f,
  -8.15742090e-02f, -3.02840844e-02f, -4.53062914e-02f, -5.65397600e-03f, -4.47299965e-02f, -7.38805830e-02f, -7.64736831e-02f, 2.52994075e-02f, 7.28526758e-03f, 7.02058598e-02f,
  6.85427859e-02f, 4.67960946e-02f, 3.68436053e-02f, 9.23882797e-02f, 1.49892122e-02f, -1.07699139e-02f, 2.76426543e-02f, 6.54640421e-02f, -3.51114497e-02f, 2.72421446e-02f,
  9.82479658e-03f, 3.25181969e-02f, -4.84439731e-02f, -2.31828578e-02f, 3.76185738e-02f, 9.34417360e-04f, 2.52461303e-02f, 2.42235065e-02f, -4.42855135e-02f, -4.50459355e-03f,
  5.10459207e-03f, 2.28813831e-02f, -8.50130618e-02f, 1.03998028e-01f, 2.45769438e-03f, -8.20451081e-02f, -1.00973900e-02f, 9.58977267e-03f, 3.44717801e-02f, -5.84620535e-02f,
  1.88688025e-01f, 1.90149724e-01f, -6.47056922e-02f, 1.54325172e-01f, 8.18698555e-02f, -3.96547727e-02f, -1.03528045e-01f, -2.72653457e-02f, 5.23012988e-02f, 1.59757316e-01f,
  -5.91192860e-03f, 3.56873171e-03f, 2.36405618e-02f, 9.77427978e-03f, 7.31632113e-02f, -2.22368985e-02f, -9.69386660e-03f, -1.85461473e-02f, 7.17051444e-04f, 3.68302800e-02f,
  1.58331677e-01f, -9.75287578e-04f, 1.42769171e-02f, 1.72437890e-03f, 2.56310217e-02f, -2.31124964e-02f, 1.89459845e-02f, 2.42440235e-02f, 8.59468877e-02f, -4.62245159e-02f,
  -4.56125975e-01f, -1.57621995e-01f, 3.52269709e-02f, -4.69758548e-02f, -2.69614220e-01f, -2.62452483e-01f, 2.78546095e-01f, -2.40204453e-01f, -3.19572717e-01f, 1.31777734e-01f,
  -2.74790339e-02f, 1.18913643e-01f, 2.60525107e-01f, -2.37688452e-01f, 1.59162968e-01f, 5.81174605e-02f, -1.33930281e-01f, -2.86212675e-02f, -2.47363806e-01f, 2.85310019e-02f,
  -1.43770814e-01f, -2.78656244e-01f, 1.63366944e-01f, -2.24246547e-01f, 6.65619671e-02f, -5.34832990e-03f, 3.82728904e-01f, 2.59622280e-02f, 3.75933014e-02f, -1.23385124e-01f,
  -1.89643621e-01f, -1.67895705e-01f, -2.71423850e-02f, 1.43074244e-02f, 9.22055077e-03f, 2.01295242e-02f, 8.99076462e-02f, 1.40857488e-01f, -8.90426338e-02f, -3.56816500e-02f,
  6.72595128e-02f, 2.90504526e-02f, -1.50186479e-01f, 4.06185649e-02f, -8.35588947e-02f, -1.20709620e-01f, -2.92275604e-02f, -2.23444384e-02f, 1.92892354e-03f, -3.14137004e-02f,
  2.40881853e-02f, -1.74415447e-02f, -3.96541804e-02f, 2.66857166e-02f, 1.67016070e-02f, -4.27705236e-02f, 9.84181017e-02f, 1.26351759e-01f, 9.18719266e-03f, -5.00532500e-02f,
  -2.08411179e-02f, -4.34492715e-02f, -8.68202373e-03f, -4.78782356e-02f, -1.65133383e-02f, -6.53004795e-02f, 2.47185118e-02f, -8.83866940e-03f, -6.01089187e-02f, 1.05059780e-02f,
  6.17763251e-02f, -6.66500181e-02f, -3.45338918e-02f, -5.20139784e-02f, 3.31635028e-02f, -4.97003868e-02f, 6.23605363e-02f, -1.63623430e-02f, -1.62816588e-02f, 2.57673431e-02f,
  -5.95850013e-02f, -5.91464862e-02f, 3.02111078e-02f, 7.17508793e-02f, -3.39197218e-02f, -8.22753925e-03f, 1.56919559e-04f, -5.81865013e-02f, -1.51966307e-02f, 1.38641521e-01f,
  1.57125250e-01f, 1.54089153e-01f, 1.44168409e-02f, -2.80020237e-02f, 6.25270009e-02f, 3.85028049e-02f, -1.02574721e-01f, -6.95545375e-02f, 9.77851334e-04f, -7.28006214e-02f,
  2.66173808e-03f, 5.13523817e-02f, 1.20008476e-01f, -6.45879358e-02f, 1.29977483e-02f, 9.70757231e-02f, 4.62888926e-02f, -1.64249260e-02f, 3.19491737e-02f, -2.64714286e-03f,
  1.99609678e-02f, -2.15646531e-03f, 4.84249517e-02f, -7.67031834e-02f, -2.82522314e-03f, 9.60138142e-02f, -3.89370099e-02f, -5.35257161e-02f, 2.91657764e-02f, -3.22811864e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.36876631e-02f, -3.44838023e-01f, -8.68640661e-01f, -3.98685068e-01f, 5.51703155e-01f, 5.57357728e-01f, -5.10308981e-01f, 5.68578206e-03f, -7.80035794e-01f, 1.80349648e-01f,
  3.88071626e-01f, -3.06230992e-01f, -7.18435645e-01f, 3.30724828e-02f, 3.08623090e-02f, -6.10032737e-01f, 3.53784353e-01f, 2.03576669e-01f, -3.07827622e-01f, -4.87852469e-02f,
  -2.72568792e-01f, 5.64653099e-01f, -4.13091123e-01f, 5.37895024e-01f, 1.31055892e-01f, -7.35526159e-02f, 5.71468115e-01f, -1.00681491e-01f, 5.74776709e-01f, 3.35892081e-01f,
  9.40895546e-03f, -2.69441038e-01f, -1.06065020e-01f, -7.20317066e-02f, -1.57050882e-02f, 2.28981435e-01f, 4.80344370e-02f, 7.38586485e-02f, -5.60607575e-02f, -1.12903096e-01f,
  -1.02610618e-01f, 1.21813014e-01f, 4.43654507e-03f, -2.67422218e-02f, 1.86964452e-01f, -2.30376758e-02f, -2.55944163e-01f, -9.56946537e-02f, -2.56734133e-01f, -1.04416206e-01f,
  -2.85626829e-01f, -5.32944724e-02f, -3.37537974e-02f, 1.40832376e-03f, -1.93110287e-01f, -3.45630161e-02f, -1.13243125e-02f, 1.82469562e-02f, 1.35325640e-01f, -1.73257720e-02f,
  1.07919261e-01f, 1.09115668e-01f, 8.37815367e-03f, 2.24872697e-02f, -2.44362857e-02f, -3.46318446e-02f, 7.08115697e-02f, -4.58479393e-04f, -6.66662455e-02f, -4.34223525e-02f,
  2.83564795e-02f, 5.96830621e-03f, -5.00928983e-03f, 6.64227679e-02f, 1.31626695e-01f, -8.05299878e-02f, 1.63277596e-01f, 3.67119629e-03f, -1.77600309e-01f, -1.08011015e-01f,
  -7.05830604e-02f, 2.45081782e-02f, -7.70136416e-02f, 6.02756478e-02f, -2.80376785e-02f, -5.99765480e-02f, 7.60220364e-02f, -1.14529356e-01f, -1.10827878e-01f, 9.22798887e-02f,
  -1.56317782e-02f, -6.53276816e-02f, -1.14306167e-01f, 1.35250986e-02f, -3.84925604e-02f, 2.16606662e-01f, 2.08869316e-02f, -5.56718111e-02f, -2.47721355e-02f, -3.86618488e-02f,
  1.77305236e-01f, 3.10771894e-02f, 1.10057697e-01f, 9.12949145e-02f, -6.96779564e-02f, 4.67729121e-02f, 6.07673340e-02f, 1.93076523e-03f, 1.85824364e-01f, 3.08312103e-02f,
  1.13534577e-01f, -2.66991444e-02f, 3.20360996e-02f, 9.84884799e-03f, 1.62651569e-01f, 6.27454091e-03f, 4.58269157e-02f, -6.42314702e-02f, 4.56141531e-02f, -3.65221798e-02f,
  2.97134221e-01f, -7.94670522e-01f, 4.70658153e-01f, 7.21141815e-01f, 1.45909294e-01f, -2.34604046e-01f, 5.22142112e-01f, -3.62823129e-01f, -2.23597258e-01f, -6.70298100e-01f,
  1.62944481e-01f, -2.75425706e-02f, -1.43730223e-01f, 1.84062887e-02f, 1.01974916e+00f, -4.85470332e-02f, 3.22760753e-02f, 5.38845658e-02f, -1.87040374e-01f, -4.67292033e-02f,
  2.82194018e-01f, 1.57720253e-01f, 5.86244285e-01f, -2.09995985e-01f, 2.48349085e-01f, -1.17125839e-01f, 2.39629000e-01f, 2.14035824e-01f, 1.28790587e-01f, 1.45422950e-01f,
  -4.01989281e-01f, -2.13142019e-02f, 1.74210802e-01f, -8.05624276e-02f, -1.18250862e-01f, -4.95220646e-02f, 1.89060092e-01f, 2.68055588e-01f, 1.54102355e-01f, -1.39720276e-01f,
  -4.04188074e-02f, -3.40677574e-02f, -6.50175065e-02f, 1.61712974e-01f, -1.70508586e-02f, -2.52994690e-02f, -8.77092034e-02f, -1.11069150e-01f, -5.82629256e-03f, 5.28528690e-02f,
  -4.24144752e-02f, -6.04801290e-02f, -4.25879844e-02f, 7.68744526e-03f, 1.20775774e-01f, -6.36273846e-02f, 1.04019098e-01f, 1.65714562e-01f, -1.57968640e-01f, 1.97050404e-02f,
  1.30919874e-01f, 4.08251062e-02f, 4.47579473e-02f, -1.54585047e-02f, -4.49339859e-02f, -7.34306499e-02f, 2.71107107e-02f, 1.00180738e-01f, 2.69322433e-02f, -6.50522709e-02f,
  -9.48414281e-02f, 1.20809317e-01f, -2.75798384e-02f, -7.96504617e-02f, 5.69739155e-02f, -1.02221750e-01f, 1.43678635e-01f, -1.40214831e-01f, -2.21359469e-02f, -5.09571889e-03f,
  5.16387895e-02f, 4.72036302e-02f, -7.16770217e-02f, 4.98320274e-02f, 9.13138464e-02f, 2.26802930e-01f, -3.96373942e-02f, -9.89712868e-03f, 7.71195954e-03f, -4.01610741e-03f,
  -6.57849610e-01f, -1.67828947e-01f, -1.85026482e-01f, -8.61216784e-02f, -1.80229887e-01f, -5.82318828e-02f, -1.64420567e-02f, -8.71387050e-02f, 3.43455486e-02f, 6.04703836e-02f,
  -5.48757911e-02f, 8.25602710e-02f, -8.55341926e-02f, -3.73062901e-02f, 9.22199041e-02f, -5.94306923e-03f, 4.25286591e-02f, -9.52300057e-02f, -1.90138665e-03f, -5.84452413e-02f,
  -1.36863694e-01f, 7.24882856e-02f, -1.08275982e-02f, -8.26606899e-02f, -1.32423609e-01f, 1.04066648e-01f, -6.61193132e-02f, -5.17152995e-02f, 5.34424074e-02f, 3.26570086e-02f,
  -4.10396867e-02f, 2.00972617e-01f, -5.95509171e-01f, 8.46713707e-02f, -3.24591130e-01f, 2.45854557e-01f, 4.99286741e-01f, -4.21850055e-01f, -5.09441197e-01f, 4.58069414e-01f,
  5.28498769e-01f, -3.04882616e-01f, 2.75663972e-01f, 9.29279387e-01f, -3.76295030e-01f, 5.61646521e-01f, 4.74252790e-01f, 3.47459078e-01f, -1.53750256e-01f, -1.25178233e-01f,
  -9.93999615e-02f, 8.09055567e-01f, 1.13863103e-01f, -4.56809253e-02f, 9.59567055e-02f, -4.16270733e-01f, 2.87642151e-01f, -2.57930726e-01f, 2.47692496e-01f, -4.99772988e-02f,
  1.45927146e-01f, 1.85288321e-02f, -9.19665843e-02f, -1.41098663e-01f, -5.59039339e-02f, 3.94379236e-02f, -1.70941073e-02f, -2.43088813e-03f, -1.89619437e-01f, 1.60826445e-02f,
  6.37988299e-02f, -1.38746858e-01f, 1.98547281e-02f, -8.78154263e-02f, -3.61049734e-02f, -1.97385117e-01f, -6.37206733e-02f, -1.25752389e-02f, -1.02218250e-02f, 5.82556799e-02f,
  -1.15661532e-01f, -1.84812080e-02f, -4.01936425e-03f, 2.20226459e-02f, -1.65973991e-01f, -9.63986758e-03f, -7.15421280e-03f, -5.77731878e-02f, -2.18679961e-02f, -1.03046410e-01f,
  7.46631026e-02f, 5.36683435e-03f, 1.21022046e-01f, 1.01983801e-01f, -7.51274005e-02f, 6.23440668e-02f, 3.72999609e-02f, 1.20122060e-01f, -1.27277359e-01f, 1.56490266e-01f,
  -2.70108450e-02f, -4.45820915e-04f, -6.14558160e-02f, 5.72222210e-02f, 5.81106842e-02f, 3.04493122e-02f, 2.53807381e-02f, -4.29109633e-02f, 8.05033930e-03f, 1.42085301e-02f,
  9.53682736e-02f, -8.27735439e-02f, 4.59263101e-02f, 2.06014708e-01f, 1.37854451e-02f, -5.47391325e-02f, 1.14481032e-01f, 1.97769236e-02f, 5.72606130e-03f, -1.33215412e-01f,
  3.58182117e-02f, -8.66249087e-04f, 1.35379387e-02f, -1.09493755e-01f, -9.35473572e-03f, 1.42461518e-02f, 4.45300937e-02f, -6.75243363e-02f, 7.17437174e-03f, 4.93702441e-02f,
  -5.79027794e-02f, -7.37796798e-02f, -6.10353500e-02f, 4.91669751e-04f, -1.68085977e-01f, 2.09304944e-01f, 2.13165268e-01f, -1.61679700e-01f, -7.20142499e-02f, -9.64593217e-02f,
  7.83072188e-02f, -6.42873943e-02f, -5.84766679e-02f, -8.01884532e-02f, -2.19373070e-02f, 1.58980228e-02f, -1.78127781e-01f, -9.56165642e-02f, 5.26306480e-02f, -1.77336449e-03f,
  -6.94518626e-01f, -1.65331196e-02f, -1.85158595e-01f, -9.23048258e-01f, 3.24429870e-02f, -4.51228946e-01f, -1.03097737e-01f, -2.73755729e-01f, -2.48217896e-01f, -7.43259564e-02f,
  1.20049417e-01f, -4.04553525e-02f, 5.57938755e-01f, -1.63781401e-02f, -1.20085627e-01f, 3.69027913e-01f, -5.90275526e-01f, -2.67845511e-01f, 9.72698629e-02f, -6.32308424e-01f,
  -2.96712995e-01f, -4.21112105e-02f, -1.05197623e-01f, 1.18927874e-01f, -3.75202864e-01f, -2.66883790e-01f, -1.53988227e-01f, 2.85934448e-01f, -1.81454986e-01f, 3.40163291e-01f,
  -7.62510538e-01f, -3.08263570e-01f, -1.82439521e-01f, -1.35440946e-01f, -2.05291331e-01f, 5.69304340e-02f, -1.29814036e-02f, 2.91728407e-01f, -9.90220066e-03f, -9.79297012e-02f,
  4.02839407e-02f, -3.73916626e-02f, -1.16615877e-01f, 1.43162519e-01f, -6.34137020e-02f, 5.46572655e-02f, 2.44189277e-02f, -1.60073742e-01f, -9.23693702e-02f, 1.40091524e-01f,
  7.12804729e-03f, -2.90373508e-02f, -2.56158262e-01f, 3.41810957e-02f, 1.23402663e-01f, -1.38415694e-01f, -1.90150496e-02f, 6.05408251e-02f, -1.56765968e-01f, -1.84823021e-01f,
  2.53187537e-01f, 4.66421433e-02f, 1.29689083e-01f, -3.23054865e-02f, 1.17016330e-01f, -3.48280296e-02f, 4.48411005e-03f, 1.46268439e-02f, -1.29428506e-02f, 1.43869981e-01f,
  -1.36283085e-01f, -6.17973097e-02f, 4.02210355e-02f, -1.48943037e-01f, 3.16623151e-02f, -3.17047611e-02f, -1.57991443e-02f, -4.01001945e-02f, 3.79379056e-02f, -8.03880766e-02f,
  -7.20497668e-02f, 7.24460185e-02f, 1.65848657e-01f, -4.92826216e-02f, -4.17576656e-02f, 6.84549436e-02f, 1.25705125e-02f, 2.99714394e-02f, -1.61065921e-01f, 3.05163972e-02f,
  -1.04743373e+00f, -8.39625180e-01f, -4.10448797e-02f, -5.91731071e-02f, -6.26471266e-02f, -1.45722196e-01f, 3.88194434e-03f, -6.29109442e-02f, -1.83732376e-01f, -2.11934410e-02f,
  -1.17060833e-01f, -6.85441419e-02f, -1.00444287e-01f, 1.18095437e-02f, 1.08306967e-01f, -3.26269083e-02f, -7.09629729e-02f, -6.78124577e-02f, -2.05808550e-01f, -6.00645542e-02f,
  -1.39941782e-01f, 2.14355625e-02f, 2.09094286e-01f, -5.88009786e-03f, -1.80882141e-01f, -5.34140915e-02f, -9.87884402e-02f, -8.35013688e-02f, -1.61111839e-02f, 6.02366664e-02f,
  1.42945364e-01f, 8.32328737e-01f, 2.42730007e-01f, 5.23230396e-02f, -1.93170711e-01f, -6.82451487e-01f, -2.44319916e-01f, 1.64775308e-02f, -8.90485421e-02f, 3.89101744e-01f,
  -2.92324245e-01f, 5.76643705e-01f, -1.82065845e-01f, 1.72586564e-03f, -1.06949079e+00f, -3.43611926e-01f, -4.25660342e-01f, 8.59732628e-02f, -6.70711398e-02f, -1.01188444e-01f,
  -2.72018135e-01f, -5.62980533e-01f, -1.12953514e-01f, -8.97457823e-02f, 1.27697989e-01f, 3.43762219e-01f, -2.26901531e-01f, 1.01270944e-01f, 1.62408978e-01f, 7.74544999e-02f,
  8.42913911e-02f, 2.75727957e-01f, 1.55215219e-01f, -1.97791755e-02f, -3.74107957e-01f, 6.58936724e-02f, 1.27748609e-01f, 7.25303665e-02f, 8.31110775e-02f, 1.60527769e-02f,
  5.36866896e-02f, -5.41302338e-02f, 3.68432738e-02f, 4.06049658e-03f, 1.27847612e-01f, 1.52697057e-01f, 1.24028161e-01f, 8.19031522e-02f, 1.27316773e-01f, 1.30239397e-01f,
  6.64825365e-02f, 2.81994604e-02f, 2.23910604e-02f, -6.28732070e-02f, -1.55987293e-01f, 1.41525969e-01f, -2.27810070e-02f, 8.07255358e-02f, 4.15045172e-02f, -3.55691947e-02f,
  -7.86785483e-02f, -3.24055031e-02f, -1.18034236e-01f, 9.94632244e-02f, -6.13520518e-02f, 8.78671780e-02f, -6.01185150e-02f, -1.10059023e-01f, 7.56844878e-02f, -1.90364756e-02f,
  -8.59228298e-02f, 5.89491129e-02f, -3.52517143e-02f, -1.00691915e-01f, -2.00763047e-02f, 9.44726076e-03f, -1.77134871e-01f, 1.20499350e-01f, -1.01298966e-01f, -7.63024613e-02f,
  1.73673168e-01f, -8.20924118e-02f, 1.65369490e-03f, -3.04888468e-02f, -8.49016011e-02f, 7.16643687e-03f, -1.73459072e-02f, 1.60979062e-01f, -1.58583615e-02f, -6.92337006e-02f,
  -2.14032695e-01f, -1.31477177e-01f, -4.69302088e-02f, 1.74477119e-02f, 7.84733295e-02f, -3.25931646e-02f, -2.41972342e-01f, 6.55631721e-02f, -3.08431666e-02f, -2.33103447e-02f,
  3.02141011e-02f, 2.43079644e-02f, -1.73886225e-01f, 2.10385416e-02f, 1.31975142e-02f, -9.68624651e-02f, -1.29875749e-01f, 3.31344232e-02f, -1.34175554e-01f, -7.99522102e-02f,
  3.16178054e-02f, 2.26008170e-03f, -5.45216277e-02f, -1.04001082e-01f, 1.36120263e-02f, -4.12967540e-02f, -1.21430901e-03f, 9.40858498e-02f, -8.89258310e-02f, -1.10394165e-01f,
  -2.20135096e-02f, 2.59233296e-01f, -1.91399425e-01f, 6.37105286e-01f, -2.05898926e-01f, -1.65083036e-02f, -4.26924318e-01f, 2.63257802e-01f, -2.58039981e-01f, 6.20039850e-02f,
  2.81925380e-01f, 1.79874793e-01f, -6.43916726e-02f, 8.89636278e-01f, 3.94963592e-01f, -1.62731901e-01f, 5.85691273e-01f, 1.14955291e-01f, -1.02014497e-01f, 4.50698078e-01f,
  2.57891953e-01f, 5.89243770e-01f, 3.76190037e-01f, 4.89215612e-01f, 2.59994268e-01f, 2.55245149e-01f, 5.68238199e-01f, 3.88064981e-02f, 8.46625268e-01f, 2.23301366e-01f,
  -4.50118817e-03f, 3.82492947e-03f, -1.74223974e-01f, -1.38732716e-01f, 1.31692559e-01f, 3.08375843e-02f, 4.86235544e-02f, -6.61392659e-02f, -5.76628037e-02f, 1.43580109e-01f,
  5.49336374e-02f, -2.69062500e-02f, 1.14140347e-01f, 8.08083452e-03f, -2.02119485e-01f, 2.87574809e-02f, -1.02825707e-03f, -3.92100774e-02f, -5.79575896e-02f, -1.45876035e-01f,
  -1.45064965e-01f, 1.25925496e-01f, -4.94821034e-02f, 1.38174713e-01f, 2.66863238e-02f, -2.62568193e-03f, -8.34520236e-02f, -7.40043819e-02f, -8.05338696e-02f, 1.51953131e-01f,
  8.08701515e-02f, -4.34634611e-02f, -5.21090999e-02f, 3.41947153e-02f, 8.28586742e-02f, -7.33772591e-02f, 1.38929963e-01f, 8.82573277e-02f, -2.19333693e-02f, 4.26014839e-03f,
  7.94304907e-02f, 1.31564485e-02f, 7.62808472e-02f, -1.26241237e-01f, 1.71534030e-03f, -1.17087990e-01f, 3.35976705e-02f, -6.68749511e-02f, 8.21928009e-02f, 4.00036387e-02f,
  -2.44164863e-03f, 1.72004163e-01f, 1.26747936e-01f, 7.03071207e-02f, -9.53895673e-02f, -2.16415841e-02f, 2.37449095e-01f, 1.24839954e-01f, -5.49166575e-02f, -5.97057976e-02f,
  2.22119421e-01f, 5.46630621e-01f, 4.79611121e-02f, -1.09124973e-01f, 6.21214844e-02f, 5.93467355e-02f, -7.81581998e-02f, 2.89659977e-01f, 2.48372287e-01f, -1.23893484e-01f,
  9.54556912e-02f, -2.20229998e-01f, -7.08856285e-02f, 8.28015134e-02f, 1.40773118e-01f, 1.18936710e-01f, 7.38808662e-02f, 1.06518455e-01f, 1.98446840e-01f, 3.40962738e-01f,
  7.00033009e-02f, -7.54354000e-02f, 5.32532334e-02f, -1.22916743e-01f, 6.49171323e-02f, -1.94548611e-02f, 5.18425778e-02f, -1.31411543e-02f, 7.94522911e-02f, 1.28195137e-01f,
  5.82797945e-01f, 6.46975264e-02f, 3.28939036e-02f, -1.35684842e-02f, -3.78363967e-01f, -6.06698334e-01f, -3.86977613e-01f, -4.82213736e-01f, 5.05286455e-02f, -2.89927661e-01f,
  -5.08507490e-01f, 5.48427880e-01f, 1.21110156e-01f, -6.23567700e-01f, 3.85545075e-01f, 1.48827836e-01f, -2.23495483e-01f, -1.68198850e-02f, 3.33513953e-02f, -2.50218600e-01f,
  8.09950083e-02f, -6.14888847e-01f, -8.49438086e-02f, -7.72811949e-01f, -4.96767163e-01f, -1.14700064e-01f, -6.60997815e-03f, -3.52500737e-01f, -3.37605208e-01f, -1.20857388e-01f,
  -9.36809182e-02f, 9.61764380e-02f, 2.26464495e-02f, 9.60842445e-02f, -4.98349182e-02f, 3.49058094e-03f, 8.43072757e-02f, 7.24289939e-02f, -1.29729947e-02f, 1.44989625e-01f,
  1.42694414e-01f, 1.04054492e-02f, -2.41356567e-02f, 3.58981453e-02f, -2.12328583e-01f, -3.82564552e-02f, -7.21133277e-02f, 5.64415082e-02f, 2.38016341e-02f, 1.30589306e-02f,
  4.95460145e-02f, 1.22425072e-01f, -1.20203674e-01f, 1.27127618e-01f, -2.41250992e-02f, -1.01206221e-01f, 1.84741110e-01f, 1.39529347e-01f, 5.75202182e-02f, 2.14994416e-01f,
  5.41071175e-03f, 1.19700596e-01f, -2.38322075e-02f, -1.16866030e-01f, -1.20856367e-01f, -1.29418612e-01f, 1.25137176e-02f, -1.04330152e-01f, 8.01932141e-02f, -1.21078320e-01f,
  -2.02172443e-01f, -3.74571942e-02f, -2.28441581e-02f, 1.04732700e-01f, 1.17902691e-02f, 1.16156273e-01f, 8.60321075e-02f, -1.75404362e-02f, -2.24843249e-03f, -2.36928668e-02f,
  -1.90292448e-02f, 3.68098244e-02f, -1.18091606e-01f, 5.00244722e-02f, -3.80945690e-02f, 8.03257972e-02f, 4.70427005e-03f, 1.13046065e-01f, -1.12630159e-01f, 2.41563637e-02f,
  -1.51126593e-01f, -5.44536337e-02f, 2.81690829e-03f, -1.56481668e-01f, 4.52018194e-02f, 1.17713325e-02f, -5.50548546e-02f, -2.11693048e-01f, 5.87898791e-02f, -9.27755535e-02f,
  -6.43739570e-03f, 2.81204358e-02f, 6.63842782e-02f, -2.62052696e-02f, 1.04673296e-01f, -2.32346267e-01f, 1.02290928e-01f, 7.64885992e-02f, -2.29856502e-02f, 2.34975889e-02f,
  7.05031455e-02f, -9.00021568e-03f, 1.63948059e-01f, -1.44944757e-01f, 4.53313813e-02f, 2.26988494e-01f, -9.96613428e-02f, 9.64385271e-02f, 2.41270706e-01f, 4.53235321e-02f,
  -1.34076107e+00f, 5.73366106e-01f, 4.26646918e-01f, -1.13817817e-02f, -3.94811779e-01f, 8.59153628e-01f, 5.80740571e-01f, 1.41915426e-01f, 3.20766628e-01f, 5.36046326e-01f,
  1.47756888e-02f, -1.91664938e-02f, 2.37740710e-01f, 2.84969330e-01f, 2.29032770e-01f, 4.85537440e-01f, 3.12823474e-01f, 3.80826086e-01f, 2.09242374e-01f, -2.60207474e-01f,
  -1.23711206e-01f, -9.28983688e-02f, -3.67298797e-02f, -1.74592540e-01f, -4.09922332e-01f, -3.33652735e-01f, -3.26747984e-01f, 8.16930383e-02f, -1.60614997e-01f, 1.53377935e-01f,
  -3.37597281e-01f, -1.65579319e-01f, -3.45370442e-01f, 1.65239081e-01f, -5.82911111e-02f, -2.35214680e-02f, 1.16581051e-02f, 6.21417835e-02f, -5.80190010e-02f, 6.54912814e-02f,
  -8.96078348e-02f, -4.42240573e-02f, 1.27334297e-01f, -7.93102533e-02f, -7.97056630e-02f, -5.53730354e-02f, -8.82150978e-02f, -2.52273530e-02f, 3.86639088e-02f, -8.91406536e-02f,
  -1.56340629e-01f, 4.17026840e-02f, -5.54740205e-02f, 5.92710674e-02f, -2.23250724e-02f, 7.93775544e-02f, 2.55535841e-01f, 7.14365616e-02f, -7.97194466e-02f, 1.06682569e-01f,
  -9.94359702e-02f, 1.55273378e-01f, -8.75707716e-02f, -5.89455664e-02f, -3.00241541e-02f, -2.96424329e-01f, 6.08656928e-02f, -1.56727638e-02f, 5.76226041e-02f, -1.18273139e-01f,
  -1.16856441e-01f, 1.45805636e-02f, -1.05982170e-01f, 5.59704043e-02f, -8.02573636e-02f, -1.72696859e-02f, -2.88461596e-02f, -4.56629023e-02f, 5.33631351e-03f, 4.65744128e-03f,
  -7.90628642e-02f, 4.02413942e-02f, -1.11893201e-02f, -5.86010367e-02f, -7.80782029e-02f, 1.15354665e-01f, -1.10769533e-01f, -9.38432664e-02f, -7.17194155e-02f, 4.28915396e-02f,
  2.17154697e-01f, 1.40545905e-01f, 4.79582604e-03f, 1.17331304e-01f, -4.07535508e-02f, -3.07346266e-02f, 7.83917680e-02f, -9.70120206e-02f, 2.97727376e-01f, -3.49374563e-02f,
  -1.58133376e-02f, 5.51514402e-02f, -5.89935407e-02f, -4.59147841e-02f, 1.07794993e-01f, 1.89088583e-01f, 3.47128371e-03f, 7.72616640e-02f, 2.53069531e-02f, -4.29978296e-02f,
  -2.46811524e-01f, -2.65954472e-02f, 2.25181691e-02f, -1.13418803e-01f, 9.82230343e-03f, -8.65527838e-02f, -1.99634403e-01f, 2.65202504e-02f, -5.09178899e-02f, -6.74826875e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.20669103e-01f, 4.99954730e-01f, -4.14128462e-03f, 6.31016076e-01f, 2.04503283e-01f, 6.80254698e-01f, 5.68398595e-01f, 7.86982536e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.20395923e-02f, -7.17120692e-02f, 1.40902355e-01f, 1.02318011e-01f, -4.24638428e-02f, 8.34530294e-01f, 5.31039238e-01f, 2.21072435e-01f, -6.27106354e-02f, 1.07772844e-02f,
  -5.65114796e-01f, 2.31324151e-01f, 5.62711805e-02f, 1.21171385e-01f, 2.46787127e-02f, -3.12666520e-02f, -1.58401489e-01f, 6.19580410e-02f, 2.94243902e-01f, 6.22757263e-02f,
  1.65149674e-01f, -7.86968693e-02f, -7.02693462e-02f, 4.29555237e-01f, -2.33405203e-01f, -2.59919822e-01f, 4.98801440e-01f, -5.29873837e-03f, 2.82968909e-01f, -1.06433116e-01f,
  3.40834558e-01f, 8.68676528e-02f, 1.05275307e-02f, -1.98993012e-01f, 7.61860132e-01f, -3.57699208e-03f, -6.38489664e-01f, -5.68240941e-01f, -5.45231938e-01f, -5.08170843e-01f,
  1.37411281e-01f, 1.24528008e-02f, -3.87996525e-01f, -1.28199846e-01f, 1.69352572e-02f, 1.89599678e-01f, 1.78109139e-01f, 1.11942068e-01f, 2.55792528e-01f, 5.88012524e-02f,
  -2.75644153e-01f, -1.88089415e-01f, 5.17594099e-01f, -6.99085370e-02f, 1.93499118e-01f, -1.72472298e-01f, 1.07861705e-01f, 1.57898754e-01f, -4.88435507e-01f, 2.08172619e-01f,
  1.49157524e-01f, -3.77283514e-01f, 2.45938957e-01f, -3.60078424e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.71450961e-01f, 5.25150970e-02f, 1.23257101e+00f, 4.26511914e-01f, -8.96875560e-01f, 6.74147904e-01f, -7.75820911e-01f, -5.90026379e-01f, -7.81602085e-01f, 1.23183846e+00f,
  -4.14023757e-01f, 1.41623423e-01f, -6.29907131e-01f, 3.34980994e-01f, 5.84061027e-01f, 4.34328407e-01f, 1.09481442e+00f, 3.91884178e-01f, 3.17600965e-01f, -3.83034348e-02f,
  8.14336181e-01f, -2.14495492e+00f, -1.12812734e+00f, -1.75304413e+00f, 4.11275387e-01f, 2.80534681e-02f, 3.07044417e-01f, -1.20797288e+00f, -1.15214932e+00f, -3.55864549e-03f,
  4.84005302e-01f, 8.74986470e-01f, 3.97953570e-01f, 8.33827436e-01f, -6.45153165e-01f, 3.89660299e-01f, 1.00165391e+00f, 2.19635099e-01f, 9.23119068e-01f, -2.51482576e-01f,
  1.56202364e+00f, 6.71002924e-01f, 3.55291665e-01f, -6.77755415e-01f, -5.22159755e-01f, 6.39135778e-01f, -1.64738998e-01f, -3.78150940e-01f, 7.46447980e-01f, 4.46852356e-01f,
  3.72376591e-02f, 7.98329413e-01f, 1.78316697e-01f, 1.47586155e+00f, -8.15936148e-01f, -6.03517368e-02f, -2.59549439e-01f, 8.06192815e-01f, 1.22961573e-01f, 1.42557287e+00f,
  4.80043627e-02f, -9.28323150e-01f, -1.43748328e-01f, 7.42147326e-01f, 2.03166798e-01f, 7.97256112e-01f, -3.56873870e-01f, 4.89216626e-01f, -8.40057135e-01f, -4.41978201e-02f,
  -6.05220795e-01f, 1.11180377e+00f, -3.54714274e-01f, 7.94863030e-02f, 9.36882675e-01f, -3.38161811e-02f, -6.04924560e-01f, 1.02974117e+00f, 3.25929254e-01f, 7.82942832e-01f,
  -1.41777024e-01f, -8.44246969e-02f, 7.01843083e-01f, 7.50948846e-01f, -1.22385669e+00f, 9.72687423e-01f, -1.15473986e+00f, 5.06355166e-01f, -1.96330175e-01f, -1.87473401e-01f,
  8.07505250e-01f, 9.81922448e-02f, -7.49002755e-01f, 4.60884243e-01f, -3.35435212e-01f, 1.01176012e+00f, 6.87368393e-01f, 1.13840985e+00f, -5.21025240e-01f, 1.16794884e-01f,
  1.16120112e+00f, 5.05530596e-01f, 2.13862494e-01f, 1.39907193e+00f, 5.60578167e-01f, 8.53581309e-01f, -6.09763026e-01f, 2.58955002e-01f, -5.54832041e-01f, 7.56583631e-01f,
  1.09763002e+00f, -1.98827595e-01f, -5.03196083e-02f, -1.31311908e-01f, 5.18297374e-01f, 9.86239314e-01f, -9.40329850e-01f, 4.00782190e-03f, 1.17988360e+00f, 1.22099273e-01f,
  5.22880435e-01f, -1.29252255e+00f, 8.95213962e-01f, 1.04302597e+00f, 1.67152822e+00f, 2.66881794e-01f, 8.78988206e-01f, 5.86809456e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  9.52416897e-01f, 8.90630782e-01f, 7.78114498e-01f, 9.55078125e-01f, -3.02840918e-01f, 4.29676384e-01f, -2.34712034e-01f, 9.50154066e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -6.03551984e-01f, -1.09070849e+00f, -3.14238034e-02f, -2.92935204e-02f, -4.34966624e-01f, -1.33120775e-01f, -1.21466374e+00f, 1.17588449e+00f, -3.10278684e-01f, -4.09991056e-01f,
  -6.11622155e-01f, -2.08887234e-02f, 7.64200151e-01f, 8.79020154e-01f, -1.21833062e+00f, -4.37464416e-02f, -9.08254981e-01f, 1.87273532e-01f, 4.34469469e-02f, -8.74843597e-01f,
  -6.84744895e-01f, 1.53331205e-01f, 1.29856095e-01f, 1.88128814e-01f, -1.44404674e+00f, 7.01064527e-01f, 3.81251782e-01f, -1.41766083e+00f, 2.10545585e-01f, 9.56758186e-02f,
  -4.40419167e-01f, 3.21085930e-01f, 7.16467425e-02f, -1.04631710e+00f, -6.93585992e-01f, 1.47898048e-01f, -4.63637680e-01f, -4.26015347e-01f, 5.59692204e-01f, -7.94287622e-01f,
  -2.12458879e-01f, 2.32431665e-01f, 8.44890296e-01f, -8.47740829e-01f, -5.00934780e-01f, -5.66148937e-01f, 5.79810083e-01f, -1.17158151e+00f, -7.08013074e-03f, 5.81411123e-01f,
  2.56769717e-01f, -1.41851619e-01f, 8.30447257e-01f, 6.12659693e-01f, -1.28687930e+00f, 9.66001928e-01f, -1.17933559e+00f, -3.05086732e-01f, -1.24681115e+00f, 9.02085006e-01f,
  -1.17071819e+00f, -6.69486284e-01f, -9.77153778e-01f, 3.49362880e-01f, 3.37441266e-01f, 3.41511697e-01f, 6.76533580e-01f, 1.34737985e-02f, 9.67503309e-01f, -2.62160063e-01f,
  1.13665640e+00f, -1.00985563e+00f, 1.00482082e+00f, -1.18828714e+00f, -1.49299696e-01f, 5.28998554e-01f, -3.67488712e-01f, 6.49574101e-01f, -1.26427639e+00f, -6.27904460e-02f,
  2.71053702e-01f, 2.03797206e-01f, -3.81365687e-01f, -6.95383668e-01f, -8.42531979e-01f, 7.62629092e-01f, 6.94474936e-01f, -1.21176291e+00f, 3.92176986e-01f, 8.41271281e-01f,
  -1.12297988e+00f, -3.65884714e-02f, 2.56261379e-01f, 2.99414903e-01f, -3.77533108e-01f, -4.62884337e-01f, 2.55158693e-01f, 6.06045663e-01f, 2.81056881e-01f, 7.74354160e-01f,
  -9.71907794e-01f, -7.57016540e-01f, 1.07352400e+00f, 9.26730752e-01f, 8.53063285e-01f, 1.17400932e+00f, 1.15354523e-01f, 5.83495088e-02f, -1.55605483e+00f, -1.61110580e+00f,
  -6.07210457e-01f, -1.14108992e+00f, -2.74400413e-01f, -8.52497816e-01f, -3.17384936e-02f, -7.01807737e-01f, 1.89780682e-01f, -2.30329812e-01f, -1.16258204e-01f, -2.57207870e-01f,
  1.66894898e-01f, -3.03252459e-01f, -1.24134862e+00f, -1.16981938e-01f, -2.89816141e-01f, -7.29892910e-01f, 9.62193787e-01f, 1.75161988e-01f, -9.67699364e-02f, -1.04587735e-03f,
  2.67241180e-01f, -6.46895051e-01f, 8.76212239e-01f, -7.13431358e-01f, 5.22572219e-01f, -3.30587387e-01f, 5.04336059e-01f, -1.33456135e+00f, 1.09253392e-01f, -1.45941854e+00f,
  9.60128129e-01f, -1.45246476e-01f, 4.94860262e-01f, -2.88147867e-01f, 1.52249411e-01f, 2.00226128e-01f, 1.48677811e-01f, 2.06717700e-01f, -2.94380963e-01f, 5.02502620e-01f,
  -3.87512892e-01f, 4.78429168e-01f, 5.58284640e-01f, -8.32132816e-01f, -4.93961543e-01f, 6.95043504e-01f, 2.30575562e-01f, -2.15148136e-01f, 7.67326593e-01f, -1.33317292e+00f,
  1.87168151e-01f, 7.60306537e-01f, 5.90706198e-03f, 7.82741666e-01f, 1.12601578e+00f, -1.57776743e-01f, -1.34634221e+00f, 3.73374403e-01f, -1.15478384e+00f, -1.08100426e+00f,
  8.63235891e-01f, -7.29206920e-01f, -1.01712263e+00f, -5.73081970e-01f, 5.11437178e-01f, 1.48123771e-01f, 6.93081379e-01f, -4.46359068e-01f, -3.49526495e-01f, 6.31862581e-01f,
  2.73913324e-01f, 6.51394725e-01f, 1.23917091e+00f, 3.00774306e-01f, -4.43627566e-01f, -5.71342945e-01f, -1.16684806e+00f, -1.43645167e+00f, -6.67054772e-01f, -8.54808807e-01f,
  -5.99931300e-01f, 1.03105426e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.48029345e-01f, -1.20606251e-01f, -4.03827220e-01f, 3.11537534e-01f, 1.61011860e-01f, -2.13392124e-01f, 5.09858310e-01f, -1.50202379e-01f, -1.87045842e-01f, 3.08442023e-02f,
  2.59910494e-01f, 3.73364538e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    