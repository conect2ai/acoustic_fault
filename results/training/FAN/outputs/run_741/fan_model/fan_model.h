/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.62308443e-02f, -8.69664252e-02f, 2.73830116e-01f, 1.28529951e-01f, -9.17582831e-04f, -5.52063920e-02f, -1.37011796e-01f, -1.30504429e-01f, -8.88035372e-02f, 1.72244795e-02f,
  -9.55711156e-02f, -1.38905710e-02f, -4.20132019e-02f, -5.20471595e-02f, -1.39590681e-01f, -5.84685057e-02f, 6.17559813e-02f, 1.05689630e-01f, 1.27671599e-01f, 2.62638051e-02f,
  -1.66084301e-02f, 4.58211154e-02f, 4.25300896e-02f, 9.37694535e-02f, 1.20832190e-01f, 1.11740150e-01f, 1.54064894e-01f, 1.90900192e-01f, 5.10891639e-02f, 1.36095271e-01f,
  1.79301381e-01f, -5.74002136e-03f, 5.04945070e-02f, -1.75559018e-02f, 5.45661077e-02f, -2.12226622e-02f, -1.56915430e-02f, 3.39954309e-02f, 2.55923774e-02f, 4.69618179e-02f,
  1.19828083e-01f, 6.22219704e-02f, 6.98195100e-02f, 2.43042801e-02f, 6.43757880e-02f, 1.43297026e-02f, 9.07657444e-02f, 1.18821502e-01f, 1.37606427e-01f, 9.95649546e-02f,
  -6.38058707e-02f, 1.06223226e-01f, 1.54950425e-01f, 6.66156039e-03f, 5.88215999e-02f, 2.60949917e-02f, 1.03390671e-01f, 6.51057363e-02f, 5.30149788e-02f, -3.34519595e-02f,
  -4.10760120e-02f, 9.07111317e-02f, 4.03178148e-02f, -1.54839931e-02f, -1.01872422e-01f, -9.73792933e-03f, 1.55995665e-02f, 5.23569575e-03f, -6.10271208e-02f, -5.06220013e-02f,
  -6.35248125e-02f, 3.51820588e-02f, -4.43792231e-02f, -1.80197340e-02f, -1.29870679e-02f, 3.52441892e-02f, -1.03982605e-01f, 2.35971250e-02f, -3.44359130e-02f, -6.43557590e-03f,
  -4.65495214e-02f, 6.51115403e-02f, 2.99584102e-02f, -3.20614204e-02f, -3.34136710e-02f, -1.19760772e-02f, -6.36033192e-02f, 2.20322586e-03f, -2.67940536e-02f, -6.17512949e-02f,
  -1.04075357e-01f, 2.90381685e-02f, -4.37809527e-02f, -3.76228541e-02f, 7.38461837e-02f, 6.50165752e-02f, 9.87232998e-02f, 7.13196397e-02f, 3.01362183e-02f, -4.61641587e-02f,
  7.20819011e-02f, -1.76995043e-02f, 2.26208847e-02f, 1.10314064e-01f, 1.98732521e-02f, 7.52140880e-02f, -4.85776272e-03f, 1.59418583e-02f, 8.49084258e-02f, 1.50903929e-02f,
  -1.55140450e-02f, -7.70452544e-02f, -1.05812758e-01f, -4.34738323e-02f, -1.06662558e-02f, 1.83165073e-02f, -5.41603267e-02f, -5.68453670e-02f, -7.25844270e-03f, -1.94683239e-01f,
  4.29844916e-01f, -1.21540613e-01f, -2.11988688e-01f, 2.30690688e-01f, -2.32354447e-01f, -2.63175160e-01f, -3.22224468e-01f, 5.05421832e-02f, 2.18747452e-01f, -1.41329050e-01f,
  -1.78862333e-01f, 3.46866995e-02f, 5.75714856e-02f, -8.67413655e-02f, -2.51839235e-02f, -1.76302522e-01f, -1.91552013e-01f, 1.11501038e-01f, 1.18613198e-01f, -1.28034828e-02f,
  -3.58114466e-02f, -1.71760842e-02f, 1.53413519e-01f, 1.35269970e-01f, -1.72825009e-01f, -1.35749012e-01f, -1.77841306e-01f, -5.64670302e-02f, -2.83918172e-01f, -2.41899595e-01f,
  -2.22489104e-01f, 1.41717577e-02f, -9.39688087e-02f, -6.10524565e-02f, -1.29326627e-01f, 7.60832280e-02f, 3.49074788e-02f, 5.21149002e-02f, 1.90095622e-02f, -2.48917881e-02f,
  -7.64384791e-02f, -2.60494780e-02f, 3.30143538e-03f, 9.22311097e-03f, 7.54824840e-04f, -7.02840649e-03f, 2.46467311e-02f, 7.93113634e-02f, -2.11741813e-02f, 4.46779467e-02f,
  -9.43280458e-02f, -7.73799047e-02f, -9.94279087e-02f, -6.28938079e-02f, -3.86989713e-02f, -4.23454046e-02f, -1.96030781e-01f, -1.27650619e-01f, -1.21999927e-01f, -1.10928841e-01f,
  4.24479768e-02f, 2.66019441e-03f, 6.61765411e-02f, 1.19456826e-02f, 7.11216778e-02f, -1.51503067e-02f, 4.83031832e-02f, -1.03590891e-01f, 2.37970054e-03f, -2.17679273e-02f,
  -1.64603314e-03f, -2.54076794e-02f, -2.44517531e-02f, -3.58897299e-02f, -3.84464115e-02f, 1.92988664e-02f, -5.38515076e-02f, -5.22969700e-02f, -4.17641401e-02f, -1.13914479e-02f,
  -5.64201437e-02f, 2.82971300e-02f, 8.76456872e-03f, 1.02955112e-02f, -3.19149643e-02f, -2.94683315e-02f, -9.32686031e-03f, 1.00849848e-02f, 9.86388102e-02f, -4.77729924e-02f,
  6.56930730e-02f, -8.11018720e-02f, 2.95301396e-02f, 8.86039436e-02f, -5.53494729e-02f, 7.48103559e-02f, -1.14460394e-01f, -3.31892855e-02f, -1.68563146e-02f, 2.89030820e-02f,
  -2.55381037e-03f, 2.24084351e-02f, -6.02043085e-02f, -1.19775325e-01f, -7.70464214e-03f, -7.72211887e-03f, -4.79543209e-02f, -1.20396569e-01f, 1.10513447e-02f, 2.78998222e-02f,
  -2.69655548e-02f, 4.22160886e-02f, 2.94273756e-02f, -6.20531514e-02f, -5.16922362e-02f, -1.92476120e-02f, -1.39103532e-01f, -6.02128133e-02f, 9.61099844e-03f, -3.20084207e-02f,
  1.93960488e-01f, 6.12601987e-04f, -2.56430566e-01f, -1.16207674e-01f, -4.64271642e-02f, 7.87819475e-02f, -2.61609592e-02f, 4.61896062e-02f, 2.59700487e-03f, -1.22370407e-01f,
  -1.39962267e-02f, 4.53632660e-02f, -9.03962329e-02f, 2.16441099e-02f, 2.00807098e-02f, -2.59664387e-01f, -1.99014023e-01f, -2.03036934e-01f, -1.26516402e-01f, 4.36222441e-02f,
  -1.03912421e-01f, -1.16039753e-01f, 1.70538779e-02f, 1.01536373e-02f, -7.77358338e-02f, -1.05935685e-01f, -6.23489991e-02f, -6.74902052e-02f, -1.15462892e-01f, -3.21680725e-01f,
  -2.89609581e-01f, 6.09175451e-02f, -2.02556942e-02f, 2.64117587e-02f, -4.04718965e-02f, 4.10987400e-02f, -4.71654236e-02f, -8.77659470e-02f, -7.75506422e-02f, -2.34103296e-02f,
  -1.21986210e-01f, -3.50211095e-03f, -5.06474897e-02f, -6.15170933e-02f, 5.87159693e-02f, -3.28979678e-02f, -4.46808897e-02f, -5.00979275e-02f, -2.29837839e-02f, -1.23557903e-01f,
  -1.24224991e-01f, -1.22031376e-01f, -1.25826359e-01f, 6.76509738e-02f, -4.41256724e-02f, -5.15459366e-02f, -5.52188642e-02f, 6.64776191e-02f, 6.19870499e-02f, -8.23875591e-02f,
  -1.81068201e-02f, 4.90977280e-02f, -1.60252452e-02f, 7.53496960e-02f, -2.69654230e-03f, -2.87774913e-02f, 2.33561341e-02f, 4.13114671e-03f, 9.56364255e-03f, 6.45621940e-02f,
  6.33767666e-03f, 8.56839493e-02f, -1.20780030e-02f, -8.82320572e-03f, 4.60465960e-02f, 2.48693936e-02f, 4.79484275e-02f, 4.79832031e-02f, 5.81401475e-02f, 1.16072886e-01f,
  4.64356542e-02f, 1.02871075e-01f, 3.81953977e-02f, 1.40761748e-01f, 8.76731053e-02f, 9.61348936e-02f, -9.59745236e-03f, 5.40030003e-03f, -2.06330158e-02f, -8.94704461e-03f,
  -2.09906250e-01f, 2.27403492e-01f, -2.30500907e-01f, -3.17793228e-02f, -1.45140961e-01f, -5.25856987e-02f, -5.22638932e-02f, -5.00585660e-02f, -2.95473710e-02f, -7.61482567e-02f,
  -9.20265093e-02f, -1.08040839e-01f, -3.17858942e-02f, -9.88207608e-02f, -8.76054019e-02f, -4.39101495e-02f, -1.06858253e-01f, -1.56942442e-01f, -1.20357340e-02f, -4.20072600e-02f,
  -1.45396525e-02f, -1.32201210e-01f, -1.68695495e-01f, -1.78163171e-01f, -8.35000575e-02f, -9.91469100e-02f, -2.03797027e-01f, -1.62233904e-01f, -1.14977919e-01f, -1.56210929e-01f,
  -1.31470203e-01f, -1.12727344e-01f, -2.18063667e-01f, -1.17359363e-01f, -3.00321635e-02f, -2.21355096e-01f, -2.29001805e-01f, -1.78989470e-01f, -2.85057984e-02f, -4.50326353e-02f,
  1.16763063e-01f, 1.21936135e-01f, 1.77441746e-01f, 6.71363473e-02f, -9.32102930e-03f, -2.13733807e-01f, -1.98199347e-01f, -1.13751143e-01f, -1.42252356e-01f, -7.71170780e-02f,
  -4.30325419e-03f, 5.59433214e-02f, -4.66259308e-02f, 4.97935228e-02f, 9.87024829e-02f, 1.48559377e-01f, 1.06653847e-01f, -4.01246771e-02f, 7.06726685e-02f, -3.99406180e-02f,
  1.17752112e-01f, -1.62373185e-01f, 1.31356776e-01f, 5.18878996e-02f, 1.23480245e-01f, 2.08634846e-02f, 3.46190557e-02f, -2.93085240e-02f, 1.65551901e-01f, 2.38308823e-03f,
  6.70762733e-02f, 4.06882241e-02f, 5.55529669e-02f, 1.16347499e-01f, -4.35916660e-03f, 2.64863241e-02f, 2.44455915e-02f, -7.87924305e-02f, 3.43477726e-02f, 3.68717387e-02f,
  -1.54596404e-03f, -7.44752586e-02f, -1.40938401e-01f, -5.60660027e-02f, 4.05406095e-02f, 1.03401013e-01f, -6.30952185e-03f, 4.23178710e-02f, -1.90471448e-02f, 2.75794789e-02f,
  -3.99532095e-02f, 3.77034023e-02f, 7.03019574e-02f, -6.26559835e-03f, 2.37903930e-02f, 7.24959597e-02f, 1.13827083e-02f, -9.14131925e-02f, 3.85281667e-02f, -3.55940387e-02f,
  6.73992466e-03f, -6.86696172e-02f, -1.49480645e-02f, -4.11777794e-02f, -4.50540334e-02f, -6.28912523e-02f, -8.30295309e-02f, -1.25974678e-02f, -4.58805189e-02f, -3.95747386e-02f,
  -9.56883729e-02f, 4.43960726e-02f, 7.67370835e-02f, -6.42023906e-02f, -1.39504284e-01f, -8.46857131e-02f, -3.77656408e-02f, 5.68836229e-03f, -2.67557167e-02f, -1.62749529e-01f,
  2.78820872e-01f, -4.03321465e-04f, 6.88196952e-03f, -2.85622571e-02f, 1.21387588e-02f, 1.12216599e-01f, 7.06581250e-02f, 4.01045382e-02f, 3.63620967e-02f, 6.56089932e-02f,
  -2.13031489e-02f, 2.45020054e-02f, 2.55982745e-02f, 3.38307805e-02f, 1.38852848e-02f, 6.24455735e-02f, 1.35726407e-01f, -4.09604423e-02f, -1.37018505e-02f, 2.65319720e-02f,
  7.81970695e-02f, -4.14529964e-02f, 2.81497855e-02f, 1.27926573e-01f, 5.28304167e-02f, 6.41555488e-02f, 4.15275432e-02f, 5.36844023e-02f, 5.16252890e-02f, 1.21802397e-01f,
  -1.43594548e-01f, -2.99602300e-01f, -1.03747547e-01f, 3.97292338e-02f, 1.13711149e-01f, -2.62001604e-02f, -1.93115517e-01f, -1.80045664e-01f, -3.54601815e-02f, -1.37302503e-01f,
  -1.56981796e-02f, 1.31980434e-01f, 8.56030807e-02f, -9.89261419e-02f, -1.84021384e-01f, -2.81265706e-01f, -1.95077121e-01f, -7.94199258e-02f, -1.15343079e-01f, -1.09751098e-01f,
  2.69395914e-02f, -9.37080979e-02f, -1.11558490e-01f, -8.42716023e-02f, -6.48089573e-02f, 4.02045250e-02f, -1.55187890e-01f, -1.22228466e-01f, -7.68465996e-02f, -5.97145259e-02f,
  6.61761388e-02f, -1.27396911e-01f, -6.42309859e-02f, -3.15036848e-02f, 3.78323607e-02f, -1.58908784e-01f, -3.57865095e-02f, -1.10526435e-01f, -4.27798107e-02f, -1.32609278e-01f,
  4.35031913e-02f, -1.84230618e-02f, 3.59967276e-02f, -1.01673618e-01f, -6.24922588e-02f, -1.08895019e-01f, -2.16883212e-01f, -2.15965942e-01f, -9.78842825e-02f, -1.41314968e-01f,
  -1.30276933e-01f, -1.21400796e-01f, -7.09400922e-02f, -1.26815051e-01f, -1.68163911e-01f, -4.99245524e-02f, -3.63957211e-02f, -9.39050764e-02f, -8.23875368e-02f, -1.73275605e-01f,
  3.85104455e-02f, 2.18522280e-01f, 1.13311663e-01f, 5.90246171e-02f, 9.32789072e-02f, 2.34057322e-01f, 7.85927922e-02f, 2.03074947e-01f, 8.95516351e-02f, 1.81787580e-01f,
  1.68496341e-01f, 5.11642098e-02f, 1.68399602e-01f, 1.89738259e-01f, 1.82903841e-01f, 1.26429141e-01f, 1.88145459e-01f, 9.58010927e-02f, 1.01283081e-01f, 1.34597003e-01f,
  5.31401224e-02f, 1.50328472e-01f, 1.07902952e-01f, 8.06746781e-02f, 1.70438394e-01f, 7.78118148e-02f, 1.48096979e-01f, 1.78058401e-01f, 1.27171114e-01f, 1.15958788e-01f,
  3.22537236e-02f, -5.76824099e-02f, -8.77026096e-02f, -1.29149631e-01f, -8.92149583e-02f, -1.51308402e-01f, -1.04418144e-01f, -3.68695520e-02f, -8.55880603e-02f, -7.00841546e-02f,
  -8.29653516e-02f, -3.07982396e-02f, -6.22089580e-02f, -1.39027283e-01f, -1.03181079e-01f, -6.33141994e-02f, -1.21769816e-01f, -3.90275158e-02f, -9.09306481e-02f, -1.86176762e-01f,
  -1.83882698e-01f, -5.74526228e-02f, -2.11157929e-03f, -4.89844084e-02f, -8.66457745e-02f, -5.99928871e-02f, 2.07367931e-02f, -8.26306343e-02f, -1.71827823e-01f, -2.17599839e-01f,
  8.17492232e-03f, -2.67251227e-02f, -6.64817095e-02f, -3.79909128e-02f, -9.93201286e-02f, -5.61876819e-02f, -1.76331356e-01f, -8.04039836e-02f, -4.19459864e-03f, -1.13524079e-01f,
  1.03979670e-01f, 1.81217656e-01f, 1.05556101e-01f, 1.14892036e-01f, 1.78127304e-01f, -2.68178452e-02f, -7.46265948e-02f, 1.92365378e-01f, 2.13325113e-01f, 1.65166795e-01f,
  -1.73477065e-02f, 5.86961247e-02f, 2.51220554e-01f, 2.27848321e-01f, -6.73779398e-02f, 8.23732391e-02f, 2.48324834e-02f, -9.13711637e-03f, 1.58797130e-01f, -1.15684584e-01f,
  -1.33005381e-01f, 7.52211884e-02f, 1.10940367e-01f, 8.55736136e-02f, 5.35568707e-02f, 3.49585749e-02f, 1.51298463e-03f, 1.94988772e-02f, 3.33178788e-02f, -2.65951119e-02f,
  3.99715006e-02f, 3.83848622e-02f, -3.06060165e-02f, -4.46519926e-02f, -1.78613067e-02f, 2.61307061e-02f, 2.57955343e-02f, 1.37333930e-01f, 4.61580344e-02f, -6.48228750e-02f,
  4.77595301e-03f, -1.38307931e-02f, -9.91079840e-04f, 7.48456344e-02f, 1.02004344e-02f, 4.90038879e-02f, -9.47607274e-04f, 9.27613601e-02f, 9.50509906e-02f, -1.32830128e-01f,
  -7.96862990e-02f, 2.36632675e-02f, 9.28620249e-02f, 3.09885256e-02f, 6.88220491e-04f, -1.71971321e-02f, 7.46536255e-02f, 4.56014313e-02f, 7.70737529e-02f, -2.15290729e-02f,
  -1.20247863e-02f, 9.62955281e-02f, 6.04620054e-02f, -4.28403467e-02f, 3.65293063e-02f, -6.75351173e-03f, -1.26269888e-02f, 3.73581774e-03f, 9.27627087e-02f, 6.77851588e-02f,
  1.43328300e-02f, -1.42222056e-02f, -3.05360127e-02f, 1.21890903e-01f, 5.70297986e-02f, 2.31436011e-03f, 5.10179140e-02f, 1.14041425e-01f, -4.17905301e-02f, 9.35754701e-02f,
  -6.09458014e-02f, 1.90924436e-01f, -1.15492500e-01f, 1.00661620e-01f, 3.28216068e-02f, 1.12778403e-01f, 3.48708853e-02f, 1.00542068e-01f, 9.45890918e-02f, 8.01326558e-02f,
  6.67680874e-02f, 7.34516010e-02f, 4.91281487e-02f, 5.70938848e-02f, 5.62575534e-02f, -4.09591831e-02f, 6.30114079e-02f, 4.28305082e-02f, 4.57877964e-02f, 6.86659217e-02f,
  3.05789467e-02f, 3.16265978e-05f, -6.24139719e-02f, -5.69728538e-02f, -4.79827411e-02f, 7.01082200e-02f, 1.66852828e-02f, -8.69948491e-02f, -4.42728437e-02f, -2.25007251e-01f,
  2.23137051e-01f, 2.03898922e-01f, 1.26766697e-01f, 1.98875546e-01f, 8.26703906e-02f, 1.60371408e-01f, 3.03247035e-01f, 1.43728822e-01f, 5.68351373e-02f, 3.54685001e-02f,
  -2.76069697e-02f, -1.91013947e-01f, -8.74153748e-02f, -9.54038426e-02f, 8.99124965e-02f, 3.87172475e-02f, 9.58943740e-02f, 1.61354721e-01f, 1.47126719e-01f, 2.72304937e-02f,
  -1.72046479e-02f, 1.81681693e-01f, 9.39783528e-02f, 7.09679648e-02f, 1.49875194e-01f, 1.04027547e-01f, 1.20076761e-01f, 1.36273757e-01f, 1.56730160e-01f, 1.78194597e-01f,
  -1.68286785e-01f, 2.78885305e-01f, -4.58225235e-02f, 1.63999751e-01f, -2.53264233e-02f, 3.51170637e-02f, 1.12072513e-01f, 6.99029211e-03f, 8.83639902e-02f, 1.68392971e-01f,
  8.39527696e-02f, -9.49626137e-03f, 4.69444953e-02f, -1.35425739e-02f, 5.76712228e-02f, 8.48521516e-02f, 1.41072318e-01f, 1.65317714e-01f, 7.53538385e-02f, -1.58111248e-02f,
  -6.86358064e-02f, 1.73756525e-01f, 1.31884560e-01f, 4.54082452e-02f, 8.91068205e-02f, 1.42614901e-01f, 1.80572391e-01f, 8.03995803e-02f, 1.76788703e-01f, 2.69162744e-01f,
  -3.27207521e-02f, 2.41692085e-03f, -4.90826704e-02f, 7.38409609e-02f, -6.51291162e-02f, -1.73690662e-01f, -3.65223326e-02f, 2.12375838e-02f, -9.47360769e-02f, 6.99639469e-02f,
  -7.16603501e-03f, -2.92067323e-02f, -1.01911195e-01f, 2.46791355e-02f, 2.17487384e-02f, 1.02270819e-01f, 5.17715700e-02f, -4.75409580e-03f, -4.60881833e-03f, 4.30635400e-02f,
  1.35540571e-02f, -3.24158184e-02f, -8.60085711e-02f, -6.71470212e-03f, 4.87635955e-02f, 5.08874357e-02f, 2.60597076e-02f, -5.68665341e-02f, 1.08118460e-01f, 1.68997478e-02f,
  -4.30007651e-02f, -1.59164574e-02f, 9.44896713e-02f, 7.48297572e-02f, 1.37283895e-02f, 2.30252184e-02f, 1.33103235e-02f, 5.92417084e-02f, 7.76659325e-02f, 8.42179209e-02f,
  8.36615562e-02f, -1.07851224e-02f, -8.48691091e-02f, 8.55980963e-02f, -2.70264670e-02f, 1.01375818e-01f, 6.60538822e-02f, 6.23082668e-02f, 7.02069253e-02f, 8.81015435e-02f,
  1.13681324e-01f, 1.33671358e-01f, 8.57099667e-02f, 1.98369473e-01f, 1.39533877e-01f, 1.12376146e-01f, 3.08185164e-02f, 1.87061548e-01f, 1.04044482e-01f, 2.86116481e-01f,
  3.13664824e-02f, 3.36497486e-01f, -1.09885082e-01f, -2.02289410e-02f, 2.37888604e-01f, 1.48229092e-01f, 3.42914551e-01f, 2.33554646e-01f, 4.52819876e-02f, 2.43032455e-01f,
  3.70447397e-01f, 3.20055604e-01f, 1.39544934e-01f, 7.25615472e-02f, 2.03452095e-01f, 2.85393335e-02f, -1.17002405e-01f, -1.89692050e-01f, 6.64538741e-02f, 1.85077384e-01f,
  2.65707523e-01f, -1.46221789e-02f, -4.44170274e-02f, -6.75751716e-02f, 3.55383456e-02f, 8.56290907e-02f, -5.72927557e-02f, 8.11641216e-02f, 8.25992301e-02f, -1.78592764e-02f,
  6.95100650e-02f, 8.96573216e-02f, 1.71896797e-02f, 1.21359989e-01f, 1.90913141e-01f, 4.43191342e-02f, 1.06186062e-01f, -1.17260264e-02f, 1.59813255e-01f, 1.16112277e-01f,
  8.31231624e-02f, 1.57018378e-01f, 1.18417270e-01f, 9.15156752e-02f, 6.58145323e-02f, 5.25718275e-03f, 2.59588081e-02f, -7.23984912e-02f, 1.09048449e-01f, 6.72841594e-02f,
  7.59866461e-02f, 5.77366129e-02f, 6.35925308e-02f, -1.93343719e-03f, -1.29469356e-03f, 4.29564342e-02f, 1.15772508e-01f, 1.00748733e-01f, -4.80228029e-02f, -4.57265787e-02f,
  -1.04735292e-01f, -9.50834453e-02f, 1.86415724e-02f, -4.40094508e-02f, -2.08947733e-02f, 4.12393287e-02f, -9.66055542e-02f, -2.37632729e-02f, -1.39649689e-01f, -7.10596591e-02f,
  -7.32219592e-02f, -5.51316291e-02f, 5.05115502e-02f, -1.59485027e-01f, -5.87853529e-02f, -6.83288574e-02f, -4.85784151e-02f, 4.03165668e-02f, -1.52182117e-01f, -1.23123482e-01f,
  -6.28831536e-02f, -1.54040590e-01f, -2.25633699e-02f, -7.24859685e-02f, -1.08782232e-01f, -1.83414966e-01f, -1.35749251e-01f, -1.00128800e-01f, -1.16246939e-01f, -9.03771967e-02f,
  2.42320448e-01f, 5.79096116e-02f, 1.59342974e-01f, 7.31723383e-02f, 5.23779206e-02f, 4.10097763e-02f, 1.13667496e-01f, 8.56114030e-02f, 4.80505489e-02f, 1.33250117e-01f,
  8.37093517e-02f, 8.20926875e-02f, 5.90980947e-02f, -2.09609866e-02f, 7.79981166e-02f, 1.15643628e-01f, 1.54703856e-01f, 1.49283707e-01f, 8.35693702e-02f, 1.28547952e-01f,
  3.11970967e-03f, 1.48279011e-01f, 1.93700284e-01f, 1.61237940e-01f, 4.07630764e-02f, 1.58036888e-01f, 1.39185891e-01f, 2.71364953e-03f, 4.45536263e-02f, 9.57417786e-02f,
  -2.65158743e-01f, -1.80317461e-01f, 8.41729343e-02f, -2.16235980e-01f, 8.66360068e-02f, 7.77015612e-02f, -2.29891613e-02f, -6.19267188e-02f, -5.43929227e-02f, -1.24041200e-01f,
  2.82607842e-02f, -1.23197779e-01f, -1.50330484e-01f, -2.18304917e-02f, 1.30758686e-02f, -2.43687890e-02f, -8.65747333e-02f, -6.81817606e-02f, 4.88454551e-02f, 4.58677746e-02f,
  -5.55236228e-02f, -1.63194850e-01f, -7.03883767e-02f, -1.16888493e-01f, -6.54432252e-02f, -8.83985385e-02f, 9.09614637e-02f, -5.22073060e-02f, 1.06243849e-01f, -1.79122090e-01f,
  1.71640068e-01f, 5.67161068e-02f, 1.89593315e-01f, 6.83584586e-02f, 1.20514281e-01f, 8.84085670e-02f, 5.82555830e-02f, 3.40164453e-02f, 6.15209080e-02f, 1.12312645e-01f,
  1.23434857e-01f, -9.08142142e-03f, 5.88981919e-02f, 3.22571285e-02f, 4.92654927e-02f, 1.36005685e-01f, 3.39734815e-02f, 6.84344471e-02f, -2.55761556e-02f, 6.30637482e-02f,
  -2.40214765e-02f, 7.51972198e-02f, 5.16862310e-02f, 1.17773756e-01f, 6.39804900e-02f, 2.30197646e-02f, 3.65687646e-02f, 5.80236055e-02f, 1.75350219e-01f, 9.02880952e-02f,
  -2.09096801e-02f, -1.78215895e-02f, 5.59598505e-02f, -1.37548456e-02f, -2.42379773e-02f, -1.56598482e-02f, -7.15901777e-02f, 7.73615092e-02f, -3.44556160e-02f, -6.83340952e-02f,
  -1.06531948e-01f, 2.97102649e-02f, -3.10627576e-02f, -9.94346365e-02f, 5.54368645e-02f, -2.36005094e-02f, 2.51566209e-02f, -1.07941978e-01f, -1.63457580e-02f, -7.83181638e-02f,
  1.81130022e-02f, -5.79005219e-02f, -3.97370122e-02f, -7.77262673e-02f, 6.47213981e-02f, -6.65119383e-03f, -4.19512279e-02f, 2.79612336e-02f, 1.10221040e-02f, -4.34842613e-03f,
  1.48094222e-02f, 2.09236309e-01f, 6.16859533e-02f, -1.76332332e-02f, 2.50202026e-02f, 1.64132595e-01f, 1.57466996e-02f, 1.18130527e-01f, -4.43279110e-02f, 4.57883114e-03f,
  7.78642744e-02f, 7.89489076e-02f, -8.45962018e-03f, -8.48421454e-03f, 6.08503558e-02f, 9.64499339e-02f, -3.39416228e-02f, -6.26809075e-02f, 9.87780541e-02f, 6.11400697e-03f,
  -3.59341577e-02f, 8.84096920e-02f, 5.68327159e-02f, 1.01897411e-01f, 7.43236765e-02f, 1.34956136e-01f, 1.40486926e-01f, 1.60608187e-01f, 1.11388415e-01f, -2.80234963e-02f,
  -3.47225040e-01f, 1.09615609e-01f, -2.28271238e-03f, -1.35675713e-01f, -5.01018651e-02f, -2.68582068e-02f, -1.83094963e-01f, -1.70144230e-01f, -6.14320636e-02f, -3.41730639e-02f,
  -7.47202411e-02f, -6.39605001e-02f, -4.83790971e-02f, 2.93363500e-02f, -1.45898953e-01f, -3.75630893e-02f, 1.94153264e-02f, 2.97939051e-02f, -6.08176962e-02f, 3.55828926e-03f,
  8.62037092e-02f, 2.72012316e-02f, -3.80082130e-02f, -6.94644898e-02f, 1.12260997e-01f, -5.31385466e-02f, 4.46403027e-02f, 1.62443191e-01f, 2.16628388e-02f, 1.39424488e-01f,
  -1.32834753e-02f, 8.00460353e-02f, -2.09100470e-02f, -5.77094406e-02f, 3.84746515e-03f, -3.91529500e-02f, -5.69349676e-02f, 6.85080588e-02f, -4.20921370e-02f, 5.86382188e-02f,
  3.18484195e-02f, -3.48221138e-02f, 6.00615628e-02f, 6.11098157e-03f, -4.02794182e-02f, -2.79067401e-02f, -4.80312817e-02f, -5.71252294e-02f, -1.98095664e-02f, 4.37796190e-02f,
  9.99085009e-02f, -1.29781570e-03f, -1.00915156e-01f, -2.09938474e-02f, -1.26530994e-02f, 7.37991109e-02f, 4.36325073e-02f, -4.03852027e-04f, 2.55247252e-03f, 9.26496238e-02f,
  -4.06232700e-02f, -1.69256181e-02f, 7.60045229e-03f, -2.74198465e-02f, -3.40244398e-02f, 8.09519086e-03f, 1.05791025e-01f, 2.46128496e-02f, 3.49326655e-02f, -4.29721102e-02f,
  -6.06470294e-02f, 1.27742002e-02f, 4.37111370e-02f, -2.36728825e-02f, 5.36688231e-03f, -1.04276620e-01f, 3.06441635e-02f, 1.68208536e-02f, 6.79454505e-02f, -8.34557340e-02f,
  1.19675202e-02f, 4.79949936e-02f, -3.06661502e-02f, 4.90312167e-02f, -7.95485750e-02f, -6.08734190e-02f, 6.61183428e-03f, -8.33077803e-02f, -7.73850232e-02f, -8.42777044e-02f,
  -1.11907840e-01f, -6.67339638e-02f, -9.36188027e-02f, -2.11890112e-03f, -5.24560809e-02f, 5.61326668e-02f, 1.30782546e-02f, -7.09139407e-02f, 1.07322387e-01f, 1.03994710e-02f,
  1.13928586e-01f, 1.31311845e-02f, 5.83293661e-02f, -5.36565483e-02f, -7.70970657e-02f, -5.84506169e-02f, -1.65746398e-02f, -1.38856038e-01f, -8.33998173e-02f, 3.10382079e-02f,
  -3.95763777e-02f, -3.16571593e-02f, -2.11549282e-01f, -1.43411696e-01f, -7.21758604e-03f, -1.15061142e-01f, -6.81719333e-02f, -1.46554159e-02f, -1.70409352e-01f, -1.81507736e-01f,
  -2.01997116e-01f, 8.33124742e-02f, -8.38183910e-02f, -6.98638335e-02f, -1.73248455e-01f, -2.00879518e-02f, 7.39508197e-02f, 9.15746987e-02f, -7.21552372e-02f, -1.11473285e-01f,
  4.17597629e-02f, 2.61819586e-02f, 2.44974811e-02f, -2.91161425e-03f, 6.79146200e-02f, -2.14666445e-02f, -1.91414163e-01f, -1.12498328e-01f, -1.72671322e-02f, -4.96883169e-02f,
  4.03383449e-02f, -1.64223969e-01f, -6.62790760e-02f, -2.31185034e-02f, -7.67563134e-02f, -1.55865476e-02f, -7.20025077e-02f, 1.83232781e-02f, 1.37257650e-01f, -1.35903448e-01f,
  -2.15886027e-01f, 1.27797574e-01f, 5.62791862e-02f, 1.87538356e-01f, 1.21694446e-01f, 1.82208896e-01f, 6.81293979e-02f, 1.29884183e-01f, 1.39937505e-01f, 7.26549625e-02f,
  7.05692172e-02f, 1.42446920e-01f, 1.48336217e-01f, 3.46818082e-02f, 7.52786323e-02f, 2.20368411e-02f, 1.86811820e-01f, 5.68727069e-02f, 1.44521788e-01f, 1.24491654e-01f,
  5.81116453e-02f, 6.93306699e-02f, 1.18851684e-01f, 1.98235124e-01f, 1.35085985e-01f, 1.52735412e-01f, 6.56830519e-02f, 8.51436853e-02f, 1.86326653e-01f, 1.12482324e-01f,
  -5.18848188e-02f, -2.46927775e-02f, -1.80807188e-01f, -1.14497259e-01f, -5.35743088e-02f, -6.81707188e-02f, -4.81309779e-02f, -9.38735008e-02f, -1.10133201e-01f, -6.43513650e-02f,
  -2.71317661e-02f, -6.03221133e-02f, -5.51934130e-02f, -6.88102096e-02f, -7.76954815e-02f, -1.11286931e-01f, -1.54165596e-01f, -6.78152367e-02f, 1.38057470e-02f, -9.51442122e-02f,
  -1.42452762e-01f, -4.44930457e-02f, -1.26059860e-01f, -4.31326404e-02f, -3.36142853e-02f, -1.05628774e-01f, -9.74058583e-02f, -1.48781706e-02f, -7.22133517e-02f, -6.57219514e-02f,
  -7.91636854e-02f, 2.15224519e-01f, 1.79456305e-02f, -3.28366011e-02f, 3.57724763e-02f, 4.24377993e-02f, 4.43987511e-02f, 8.23229179e-02f, 1.40126228e-01f, -8.52649938e-03f,
  1.84430465e-01f, 4.14381549e-02f, 2.52597351e-02f, 1.44891635e-01f, 9.89115685e-02f, 1.38182610e-01f, -7.28797261e-03f, 3.86995897e-02f, 9.41585004e-02f, 6.51232153e-02f,
  1.51440993e-01f, 1.86549183e-02f, 1.27906382e-01f, 1.29892796e-01f, 1.15447983e-01f, 6.40850794e-03f, 1.09667175e-01f, 2.69173738e-02f, 1.60256505e-01f, 4.65557091e-02f,
  -4.25636023e-01f, 5.17651774e-02f, -1.58271074e-01f, -7.59623572e-02f, -6.60766661e-02f, -2.52860487e-01f, -3.11661988e-01f, -2.09586918e-01f, 3.40339839e-02f, 9.94071364e-02f,
  8.18095431e-02f, 1.24591306e-01f, 1.42298922e-01f, -4.62448783e-03f, -1.51367784e-01f, -1.08345509e-01f, -1.16651155e-01f, -1.81751668e-01f, -3.33272845e-01f, -1.03498116e-01f,
  7.74629647e-03f, -1.54296845e-01f, -1.06150523e-01f, -1.78457916e-01f, 1.00794196e-01f, -3.15144062e-02f, 1.77070629e-02f, 4.86177206e-03f, 1.56153059e-02f, 1.11986443e-01f,
  -6.68971762e-02f, -1.22079067e-01f, -8.42269063e-02f, -1.36657367e-02f, 8.75584688e-03f, -5.69160702e-03f, -1.62368955e-03f, -1.09658398e-01f, -3.62877510e-02f, 4.66725975e-02f,
  5.22176325e-02f, 4.31302236e-03f, -3.69598083e-02f, 7.55797140e-04f, -4.33731377e-02f, 2.88806297e-03f, -9.69143659e-02f, -1.12632746e-02f, -8.99707060e-03f, 6.77981079e-02f,
  6.32352605e-02f, -6.87825382e-02f, 2.49836259e-02f, -2.27360725e-02f, -7.20465556e-02f, 5.27204163e-02f, 6.83344230e-02f, -7.67453164e-02f, -1.06571727e-01f, -5.83387204e-02f,
  -4.05577645e-02f, -5.79067320e-02f, 5.76964878e-02f, -1.46841770e-02f, 1.01004578e-02f, 3.24112363e-02f, -5.15978336e-02f, 5.93446940e-02f, -4.06684242e-02f, -7.95194730e-02f,
  -3.39996931e-03f, 2.79458403e-03f, -2.67027523e-02f, -7.04715401e-02f, -9.78772156e-03f, -1.16442777e-02f, 1.21890036e-02f, 1.59903464e-03f, -8.71754251e-03f, 1.79969538e-02f,
  2.67741047e-02f, 4.87203673e-02f, -2.91611790e-03f, 3.59640196e-02f, 4.76555154e-02f, -6.13946542e-02f, 2.05611791e-02f, 2.97967740e-03f, 1.53601030e-03f, -8.16787705e-02f,
  7.99754784e-02f, -5.61693795e-02f, 6.41184971e-02f, -8.83290395e-02f, 3.20148841e-02f, 5.27467839e-02f, 9.83648375e-02f, 4.24165688e-02f, -1.26420772e-02f, -2.49887984e-02f,
  2.01357924e-03f, 2.41462830e-02f, -3.99145763e-03f, 1.34564623e-01f, 1.03766546e-02f, -1.86187867e-02f, 8.01294297e-02f, 1.22857490e-03f, -4.25422043e-02f, 5.88654727e-02f,
  1.00424767e-01f, -4.01535518e-02f, -8.31588581e-02f, 1.25274494e-01f, 6.43011779e-02f, 6.88225850e-02f, -5.69455400e-02f, 7.74875581e-02f, -9.66762453e-02f, 4.41837087e-02f,
  6.10177480e-02f, 5.95759675e-02f, 1.44446149e-01f, -3.68801244e-02f, 1.06111698e-01f, 2.02212512e-01f, 1.01078764e-01f, 1.13236964e-01f, -8.68251771e-02f, 1.39622360e-01f,
  -2.24928372e-02f, 1.06297492e-03f, 3.30336504e-02f, 1.33553714e-01f, 2.19950452e-01f, 3.30776542e-01f, 3.05566907e-01f, 1.64561525e-01f, 2.15571433e-01f, 1.11175507e-01f,
  -3.05769015e-02f, 6.87049106e-02f, 2.13943627e-02f, 4.27973606e-02f, 1.58647429e-02f, 5.44536449e-02f, 6.75012395e-02f, 1.29296765e-01f, 8.24256763e-02f, 3.15024033e-02f,
  2.66624629e-01f, 6.09909035e-02f, 2.92731281e-02f, -1.31255746e-01f, 3.17768082e-02f, -1.09349206e-01f, 1.81716923e-02f, 5.50521165e-02f, -7.99784735e-02f, -6.42208848e-03f,
  1.94860250e-02f, 3.00325677e-02f, -8.17661211e-02f, -9.92305577e-02f, -3.31588089e-03f, -6.26976565e-02f, -4.08442281e-02f, 7.25399032e-02f, 3.09206508e-02f, 4.93260249e-02f,
  -8.04760158e-02f, 2.06954940e-03f, 1.37871563e-01f, -1.28004262e-02f, 3.18634883e-02f, 3.53043042e-02f, 8.94256830e-02f, 9.12473276e-02f, 1.70314059e-01f, 6.77389605e-03f,
  1.60904333e-01f, 1.68657620e-02f, -4.46834974e-02f, -8.03146362e-02f, -1.03065662e-01f, -2.74772830e-02f, -1.34043759e-02f, 3.22399437e-02f, -3.04064676e-02f, -2.27954686e-02f,
  -5.71690910e-02f, 1.62792634e-02f, -1.42374158e-01f, -5.63004427e-02f, -2.46524941e-02f, -4.80031073e-02f, -1.59706885e-03f, -4.16587964e-02f, -4.24410813e-02f, -1.39807656e-01f,
  -6.88847974e-02f, -7.66480267e-02f, -6.61824718e-02f, -4.81932163e-02f, 2.92876475e-02f, 3.35138687e-03f, 9.39988270e-02f, -8.36039782e-02f, -4.10398617e-02f, 1.05425902e-01f,
  -8.13428909e-02f, 1.04404008e-02f, -2.95162294e-02f, 9.42034274e-02f, 9.10181627e-02f, 3.65316793e-02f, -4.23773676e-02f, -6.68752044e-02f, -1.34382233e-01f, 2.53268294e-02f,
  -7.06790090e-02f, 4.59901579e-02f, -6.81503341e-02f, 2.25689486e-02f, 2.21635737e-02f, -8.58459324e-02f, -1.18439703e-03f, -1.08645417e-01f, -1.18452862e-01f, -9.42532346e-02f,
  -1.07234620e-01f, -3.34818587e-02f, -5.11007896e-03f, 3.62879485e-02f, 4.10764292e-02f, -2.33282782e-02f, 9.22374949e-02f, 1.01944230e-01f, 1.05319425e-01f, 2.86487350e-03f,
  3.18597764e-01f, 1.96723849e-01f, 6.67351857e-02f, 1.59273773e-01f, -1.11456141e-01f, -1.38843819e-01f, 1.25237659e-01f, 5.63939139e-02f, 2.29460020e-02f, 1.65709630e-01f,
  -3.05244327e-02f, -2.11275056e-01f, -4.48026620e-02f, -1.29761994e-01f, -4.26057652e-02f, 5.73041216e-02f, 1.50635600e-01f, -6.37875423e-02f, -2.92813241e-01f, -2.34815627e-01f,
  -2.38082837e-02f, 6.44787848e-02f, 3.01011670e-02f, 2.09412798e-02f, -5.41994162e-02f, -1.81809545e-01f, 3.23498063e-02f, -3.97266224e-02f, -7.98768997e-02f, 1.38679296e-01f,
  6.11932278e-02f, 3.06413889e-01f, -1.43444151e-01f, -6.00166991e-03f, -2.20355019e-02f, 8.38070363e-02f, 3.63138597e-03f, 5.68335429e-02f, 7.49408230e-02f, 9.79456976e-02f,
  -4.28117812e-02f, 3.52435261e-02f, -1.83801875e-02f, 4.91735600e-02f, 4.15412262e-02f, 2.25830870e-03f, 6.57023340e-02f, 5.60294539e-02f, 3.95223536e-02f, -2.42728367e-02f,
  6.04569120e-03f, 7.31950626e-02f, 1.47836693e-02f, -4.17706110e-02f, -2.69709658e-02f, -6.36655316e-02f, -7.25812316e-02f, 4.28639166e-02f, -1.42770372e-02f, 1.25133127e-01f,
  -5.70574291e-02f, -5.15588485e-02f, -4.12607305e-02f, 3.22315213e-03f, 4.88601103e-02f, 4.72398065e-02f, -7.65525969e-03f, -3.00261788e-02f, -8.33369493e-02f, 3.57341804e-02f,
  -1.65740550e-02f, -4.74939570e-02f, 3.31180990e-02f, 1.75210498e-02f, -1.91205181e-02f, 3.06434091e-03f, -3.91487554e-02f, 1.21171966e-01f, -1.35076558e-02f, 7.21675009e-02f,
  1.17634516e-02f, 4.84871445e-03f, 1.03695557e-01f, 1.71870030e-02f, -6.80982023e-02f, 2.80264206e-02f, 2.60990933e-02f, -6.33869320e-02f, -6.50446936e-02f, -5.40444031e-02f,
  -1.38465017e-02f, -1.04152359e-01f, 9.53115150e-02f, -3.04764207e-03f, 2.80502196e-02f, 4.95053595e-03f, 3.17437388e-02f, 4.13415618e-02f, 6.42021596e-02f, 5.62181622e-02f,
  -8.74176472e-02f, 6.20179884e-02f, 1.75090097e-02f, -3.41376923e-02f, -4.78101000e-02f, -8.58006030e-02f, 2.78028697e-02f, -1.06508029e-03f, 3.42103327e-03f, 5.80467731e-02f,
  6.96625412e-02f, -8.39290917e-02f, -4.16289642e-02f, 5.59389926e-02f, -1.05333120e-01f, -8.87764171e-02f, -8.79877657e-02f, -1.31484807e-01f, -1.82393238e-01f, -3.12928483e-02f,
  -3.81002784e-01f, 2.36362398e-01f, 1.84372976e-01f, -5.23261540e-02f, 2.08263561e-01f, 1.89279601e-01f, 2.60380447e-01f, 7.68274218e-02f, 9.14736558e-03f, 1.84958264e-01f,
  1.16340183e-01f, 4.18303944e-02f, -6.46682903e-02f, 2.22377032e-02f, 3.91043201e-02f, 1.26844555e-01f, 2.45708212e-01f, -1.52018629e-02f, -1.76287785e-01f, -1.38920546e-01f,
  8.54220763e-02f, -3.42992991e-02f, -1.58145115e-01f, 3.50105646e-03f, 5.39029650e-02f, -8.31756145e-02f, 2.04592332e-01f, 7.28932992e-02f, 1.88848659e-01f, 1.32066876e-01f,
  5.22610284e-02f, 8.82754400e-02f, -5.12073422e-03f, -2.33001318e-02f, 1.74256548e-01f, 3.87714058e-02f, 7.12976009e-02f, 1.57697856e-01f, 1.55101582e-01f, 8.40795413e-03f,
  1.59308642e-01f, 1.66401178e-01f, 7.92647153e-02f, 1.86752364e-01f, 3.64437066e-02f, 4.99120057e-02f, 6.40710145e-02f, 1.22916430e-01f, 1.75520793e-01f, 2.04090491e-01f,
  2.02543601e-01f, 1.52395904e-01f, 1.90845847e-01f, 1.79611653e-01f, 6.29621446e-02f, 1.17426999e-01f, 9.56687108e-02f, 7.14237690e-02f, 6.38246909e-03f, 6.04689531e-02f,
  -9.47101936e-02f, -7.96060339e-02f, -6.69298992e-02f, -9.57773030e-02f, -7.33032599e-02f, -1.12170003e-01f, -6.97127432e-02f, -1.44432606e-02f, -2.36224011e-02f, -9.76201370e-02f,
  -1.24632001e-01f, -7.19647184e-02f, -9.35629904e-02f, -6.93377033e-02f, -1.41122833e-01f, -9.91842896e-02f, -1.36288524e-01f, -1.17620684e-01f, -1.26236573e-01f, -1.45160645e-01f,
  -8.68110806e-02f, -1.72478836e-02f, -5.44320382e-02f, -1.10737227e-01f, -6.89924434e-02f, -5.72440252e-02f, -6.15004748e-02f, -9.94507596e-03f, -4.57586683e-02f, -1.16888978e-01f,
  -1.99837744e-01f, 2.12418720e-01f, 8.84000510e-02f, 1.29954919e-01f, 1.47357315e-01f, 1.41621470e-01f, 1.70931906e-01f, 6.17440455e-02f, 1.55432507e-01f, -6.00722909e-04f,
  5.85016161e-02f, -1.09920297e-02f, 1.30208641e-01f, 9.07270685e-02f, -6.05366612e-03f, 5.98510876e-02f, 2.31995836e-01f, 5.04194871e-02f, 1.81768477e-01f, 9.59113166e-02f,
  1.90972641e-01f, 4.59270813e-02f, -2.39081052e-03f, 1.35825261e-01f, 1.38086542e-01f, 1.39899105e-01f, 1.42252043e-01f, 2.44705696e-02f, 8.58770385e-02f, 2.10097041e-02f,
  1.45640925e-01f, -1.33548439e-01f, -1.15760505e-01f, -6.78939521e-02f, -6.23945557e-02f, 1.40740350e-01f, 1.26636446e-01f, 4.42815870e-02f, 8.54425430e-02f, 9.12047178e-02f,
  -1.72777828e-02f, 2.38275919e-02f, 1.21864371e-01f, 9.20013040e-02f, 5.68065941e-02f, -1.16220161e-01f, -1.44330680e-01f, 4.74586189e-02f, 1.96034135e-03f, 1.11886427e-01f,
  -7.98427314e-02f, 1.03008505e-02f, -2.82721743e-02f, -5.41737638e-02f, -7.20454082e-02f, -4.05509174e-02f, -1.45935878e-01f, -8.25221390e-02f, -9.87650156e-02f, -2.61428773e-01f,
  6.72185048e-02f, 2.05957908e-02f, 1.05917037e-01f, 5.36803603e-02f, 3.56728700e-03f, 5.34663945e-02f, 1.38988033e-01f, 5.96162677e-03f, 5.54118566e-02f, -9.23330197e-04f,
  -2.22974829e-02f, 1.06600098e-01f, 2.61105485e-02f, 1.30006182e-03f, 9.20688435e-02f, 1.66886076e-01f, -5.40376268e-02f, -2.83359867e-02f, 6.58611506e-02f, 1.44413710e-01f,
  -3.58895697e-02f, 1.02513976e-01f, 1.57119498e-01f, -7.77395256e-03f, 1.05071612e-01f, 3.91164161e-02f, -4.03794348e-02f, -7.01744333e-02f, 1.67949330e-02f, -3.22684161e-02f,
  -3.34021598e-02f, -8.23179036e-02f, -3.50118242e-02f, -1.74893796e-01f, -7.93499202e-02f, -1.68560296e-01f, -1.83528081e-01f, -1.45573333e-01f, -1.07342355e-01f, -4.78885062e-02f,
  -4.12539914e-02f, -2.13727802e-02f, -1.58101544e-01f, 1.25398701e-02f, -1.19387411e-01f, -3.50192077e-02f, -9.08920914e-02f, -1.64743215e-01f, -1.34043083e-01f, -1.35798389e-02f,
  -1.11795455e-01f, -4.13175933e-02f, -3.35771069e-02f, -6.82882816e-02f, -1.08786888e-01f, -1.49053916e-01f, -1.03768989e-01f, -1.01059295e-01f, 2.18804162e-02f, -5.02684973e-02f,
  1.55582309e-01f, 5.59453666e-02f, 8.09431374e-02f, 8.23353902e-02f, 5.01622669e-02f, -1.79418793e-03f, -1.88012533e-02f, -3.99365909e-02f, 1.09881118e-01f, 1.36424765e-01f,
  7.23489448e-02f, 7.23742768e-02f, 6.95612933e-03f, 4.75695580e-02f, -2.13531181e-02f, -5.36885448e-02f, -6.37878403e-02f, -3.93253863e-02f, -6.89921528e-03f, -6.70748353e-02f,
  3.86385359e-02f, 7.90643319e-02f, 1.10461935e-01f, 1.27477914e-01f, -1.92015283e-02f, 1.29475445e-01f, 1.34790260e-02f, -4.66864333e-02f, 1.91042826e-01f, -1.62117854e-02f,
  -5.92340566e-02f, 2.44121894e-01f, -4.14162040e-01f, -1.51546150e-01f, 5.33496477e-02f, 1.96970124e-02f, 6.38073012e-02f, 1.43867880e-02f, -8.06986988e-02f, 3.91928405e-02f,
  3.73608340e-03f, -3.10487449e-01f, -2.90654540e-01f, -3.07059228e-01f, -3.43402117e-01f, -4.40751463e-02f, -1.90373853e-01f, -4.84547526e-01f, -4.46405888e-01f, -4.87212650e-02f,
  -1.07384343e-02f, -5.87663203e-02f, -2.33028471e-01f, -1.37060344e-01f, -2.24521756e-02f, -1.45550519e-01f, -1.88543811e-01f, -3.49299312e-02f, -8.97108540e-02f, -1.98739260e-01f,
  -2.86164194e-01f, -5.27913086e-02f, -2.23339230e-01f, -6.93729445e-02f, -1.42233372e-01f, -7.69356266e-02f, -7.32650608e-02f, -1.98032200e-01f, -2.98866108e-02f, -8.50823969e-02f,
  -4.51586992e-02f, -1.24852471e-01f, -4.32569273e-02f, -1.64975747e-01f, -2.48400550e-02f, -1.62452549e-01f, -3.41803245e-02f, -2.25443393e-01f, -1.69029251e-01f, -8.19920748e-02f,
  4.10202798e-03f, -8.65981132e-02f, -1.90076441e-01f, -1.14820421e-01f, -1.99717835e-01f, -2.07327127e-01f, -1.24252275e-01f, -1.50013059e-01f, -1.87203631e-01f, 3.59602831e-02f,
  1.00895286e-01f, 5.42791486e-02f, 2.60732919e-02f, 1.10630646e-01f, 1.17586508e-01f, 7.54821375e-02f, 4.94158305e-02f, 9.63752642e-02f, 2.64423266e-02f, 7.69886971e-02f,
  6.00022078e-03f, 7.21845916e-03f, 1.01614021e-01f, 5.77026978e-02f, 4.63508032e-02f, -6.20362465e-04f, 8.02879408e-02f, 9.28707719e-02f, 2.41190288e-02f, 9.72902402e-02f,
  -4.07686234e-02f, 2.92648673e-02f, 4.93017621e-02f, -1.77553203e-02f, 8.39624032e-02f, 6.59550652e-02f, 6.28638864e-02f, 9.15404484e-02f, -1.56533942e-02f, 1.28617227e-01f,
  -7.63825625e-02f, -1.95500627e-01f, -1.47880599e-01f, -1.16177596e-01f, -5.74427173e-02f, -1.09115228e-01f, -1.44496009e-01f, -1.93587616e-02f, -1.33627251e-01f, -1.14820533e-01f,
  -5.28600439e-02f, -1.53639629e-01f, -7.19263330e-02f, -9.70841497e-02f, -1.33526072e-01f, -7.42591396e-02f, -2.07919776e-02f, -1.78563863e-01f, -6.77410141e-02f, -6.11210763e-02f,
  -1.28009450e-02f, -9.56548303e-02f, -2.10189790e-01f, -4.40925062e-02f, -1.28900513e-01f, -1.43300086e-01f, -7.87261352e-02f, -1.83854938e-01f, -1.47304088e-01f, 1.20952888e-03f,
  1.75079018e-01f, -1.39075994e-01f, -3.68128926e-01f, 5.89011908e-02f, -6.66302145e-02f, -2.69411594e-01f, -1.89544067e-01f, -1.61470547e-01f, 7.34592183e-03f, -6.92689717e-02f,
  -9.85529087e-03f, 7.13258386e-02f, 1.01047508e-01f, -4.91695106e-02f, -4.62853648e-02f, -2.50364244e-01f, -2.48586878e-01f, -1.80134639e-01f, -4.36556377e-02f, -4.58624475e-02f,
  3.47596668e-02f, 1.70774564e-01f, 7.24904612e-02f, 1.17415704e-01f, 1.42934650e-01f, 1.34151787e-01f, -1.12275004e-01f, -4.59763333e-02f, -7.65968412e-02f, 1.06356069e-02f,
  5.34397475e-02f, -2.87459772e-02f, -1.12714479e-02f, 8.85284171e-02f, 7.29920045e-02f, 5.97418062e-02f, 5.40152863e-02f, 8.26998651e-02f, 5.18929362e-02f, 1.85915343e-02f,
  4.56149168e-02f, 7.98536185e-03f, -5.84166087e-02f, 6.89484775e-02f, 5.03363535e-02f, 9.39761940e-03f, 1.81908812e-02f, -2.05774494e-02f, -5.41759729e-02f, -2.99222115e-02f,
  4.43599857e-02f, 3.20719741e-02f, -9.33798105e-02f, -1.03296362e-01f, 1.90838822e-03f, 3.03160958e-02f, 6.01488836e-02f, 1.73256919e-02f, -2.69445740e-02f, 1.34230003e-01f,
  5.72331659e-02f, -1.44667700e-01f, -1.04034312e-01f, -8.74710009e-02f, -3.01187094e-02f, -6.36644438e-02f, -1.09739244e-01f, -3.27042751e-02f, -1.22923531e-01f, -5.30512817e-02f,
  -2.22344492e-02f, -2.20589843e-02f, -2.18142867e-02f, -5.38793653e-02f, -2.01115422e-02f, -1.66352138e-01f, -3.78680788e-02f, -5.00342362e-02f, -4.66741296e-03f, -6.39779791e-02f,
  -2.70760432e-02f, -1.60745531e-01f, -1.14386827e-01f, -2.49010604e-02f, -6.77211806e-02f, -4.33488078e-02f, -1.07608445e-01f, -6.82572126e-02f, -6.11133240e-02f, -5.84149547e-02f,
  1.92072928e-01f, -9.19177905e-02f, 1.24679074e-01f, 4.65310477e-02f, 2.08729580e-02f, 4.59291488e-02f, -9.19244904e-03f, 5.81147568e-03f, 2.94452459e-02f, 4.99889627e-02f,
  2.48114187e-02f, -2.68955771e-02f, -1.03476606e-02f, 5.97356237e-04f, -5.49430586e-02f, -2.99966354e-02f, -8.32210947e-03f, -5.36162332e-02f, -1.04115754e-01f, 4.72736955e-02f,
  -8.44642967e-02f, -4.65077870e-02f, -1.25403419e-01f, 4.68025944e-04f, -1.16588071e-01f, -3.84995639e-02f, -1.04389258e-01f, 1.52201233e-02f, -9.47467163e-02f, 9.79749393e-03f,
  -7.42400214e-02f, 1.74304128e-01f, -6.08299188e-02f, 3.51616777e-02f, 1.48054555e-01f, 1.30866706e-01f, 2.64894396e-01f, 1.72496900e-01f, 1.51170284e-01f, 1.30351052e-01f,
  1.25620678e-01f, 2.74031870e-02f, -1.33335873e-01f, -2.15549972e-02f, -1.45129234e-01f, 1.38459951e-01f, 6.42966703e-02f, -1.52917847e-01f, -2.56559789e-01f, -4.67541553e-02f,
  2.73074518e-04f, 4.83887866e-02f, -9.51830018e-03f, -6.83234036e-02f, 2.62856334e-01f, 1.28711030e-01f, 3.60139646e-02f, -2.29009264e-03f, 1.15118213e-01f, 6.16001338e-02f,
  1.45222398e-03f, 8.87330920e-02f, -5.89451380e-02f, 4.73561473e-02f, 1.03500277e-01f, 1.26124948e-01f, 5.84426112e-02f, -6.65168790e-03f, 6.90993071e-02f, 1.56274885e-01f,
  1.17488779e-01f, 2.30571814e-02f, 8.31746459e-02f, 1.59366895e-02f, 1.08499795e-01f, 1.53771460e-01f, 2.64384001e-02f, -6.22402430e-02f, -3.51519771e-02f, 1.35126233e-01f,
  1.31435886e-01f, 1.25573143e-01f, 1.36257544e-01f, 1.51723877e-01f, 1.45229563e-01f, -7.14174286e-02f, 1.39605552e-01f, 4.81424704e-02f, 1.03956871e-01f, 2.65284181e-01f,
  -2.39715911e-02f, -8.98863971e-02f, -6.76597431e-02f, -5.63626066e-02f, -2.24624742e-02f, -1.45692453e-01f, -1.25768930e-01f, -1.03642292e-01f, -7.51908422e-02f, -1.52521774e-01f,
  -8.68671685e-02f, -1.32613763e-01f, -1.71421096e-01f, -7.13961646e-02f, -2.61214562e-02f, -1.55859351e-01f, -4.35231328e-02f, -1.04432758e-02f, -9.28321332e-02f, -1.45482779e-01f,
  -9.41462666e-02f, -1.12508409e-01f, -6.26302287e-02f, -8.70427415e-02f, -9.39384922e-02f, -1.51906192e-01f, -6.18740357e-03f, -2.05358658e-02f, -8.85509476e-02f, 1.12067442e-02f,
  1.94567934e-01f, -3.62818682e-05f, 5.06394058e-02f, 5.67331500e-02f, 1.12744980e-01f, 1.57528091e-02f, 1.03876539e-01f, 7.57870376e-02f, 4.80426699e-02f, 9.66997519e-02f,
  8.05193111e-02f, 2.81698145e-02f, 9.69706178e-02f, 1.14629515e-01f, -5.03910668e-02f, 6.55133575e-02f, 5.77229634e-02f, -5.58626950e-02f, 1.28129289e-01f, 9.81147736e-02f,
  9.09185037e-02f, 1.08915411e-01f, 8.07646886e-02f, 5.50635830e-02f, 4.83628511e-02f, -1.92521065e-02f, 1.69807613e-01f, 1.06673829e-01f, 1.31271213e-01f, 2.74375737e-01f,
  4.86636423e-02f, -7.67814517e-02f, -3.17693144e-01f, -1.14499144e-01f, -7.12149888e-02f, -1.05442673e-01f, -8.04098397e-02f, 9.93512720e-02f, 8.66336599e-02f, -6.17815964e-02f,
  -2.85424050e-02f, 1.16052188e-01f, 2.48600524e-02f, 2.10332256e-02f, -7.80201405e-02f, -1.27930306e-02f, -1.32501602e-01f, -4.90326770e-02f, 2.23437659e-02f, 5.20652272e-02f,
  1.40390754e-01f, 5.31112775e-02f, -1.95467030e-03f, 4.83790925e-03f, -5.57881221e-02f, 7.46554369e-03f, -1.08807698e-01f, 5.71175665e-02f, -3.64252143e-02f, -2.38072947e-02f,
  -1.05341859e-01f, -2.06314623e-01f, -1.49755040e-02f, -8.12382698e-02f, 2.06987001e-02f, 4.31551076e-02f, -3.04880608e-02f, 5.69740012e-02f, -1.02668799e-01f, -4.27594222e-02f,
  -6.52558878e-02f, 1.44144278e-02f, -1.40710801e-01f, 3.80968302e-02f, -9.85405445e-02f, -9.08905547e-03f, 4.73226458e-02f, -1.17699981e-01f, -3.69429812e-02f, 2.53242976e-03f,
  -5.93309216e-02f, -6.54461905e-02f, -5.47203422e-02f, 2.39383113e-02f, -2.65413504e-02f, -1.10258281e-01f, 1.36685502e-02f, -3.20729315e-02f, -1.33374736e-01f, 5.51403686e-02f,
  2.98405476e-02f, 1.36495724e-01f, 6.97893798e-02f, 1.34761885e-01f, 2.00667068e-01f, 8.95948410e-02f, -2.33767531e-03f, 2.42076758e-02f, 1.84450224e-01f, 8.84210393e-02f,
  1.28931105e-01f, -1.29451687e-02f, 5.19247949e-02f, 2.96443421e-02f, 4.31816764e-02f, 2.36978941e-02f, 1.75590850e-02f, 1.49356753e-01f, 7.34321922e-02f, 7.26339146e-02f,
  6.39458150e-02f, 1.20292485e-01f, 9.22578946e-02f, 1.45418465e-01f, -2.05873512e-02f, 7.68304244e-02f, 1.31525910e-02f, 1.24669708e-01f, 1.25821933e-01f, -3.57142538e-02f,
  1.19287021e-01f, -1.29403323e-01f, 1.93941519e-02f, -3.00866626e-02f, 3.71447690e-02f, 1.58544537e-02f, -6.81272000e-02f, 5.93232177e-02f, -3.62031907e-02f, -1.17374927e-01f,
  -1.62141964e-01f, -3.91093902e-02f, -1.68259535e-02f, -3.46818455e-02f, -8.00668001e-02f, -5.28355911e-02f, 8.77641216e-02f, -7.39215016e-02f, -1.21022267e-02f, -8.01300183e-02f,
  -8.27788338e-02f, -1.89271965e-03f, 4.93838787e-02f, 2.54595261e-02f, -1.12394886e-02f, -7.07164630e-02f, 8.61434825e-03f, -6.83688074e-02f, -7.04143941e-02f, 1.19561158e-01f,
  4.37209815e-01f, 3.04198980e-01f, 3.61158289e-02f, 3.40577155e-01f, 1.83232836e-02f, -1.33287728e-01f, -7.95481503e-02f, -5.70836626e-02f, 7.02379197e-02f, 2.49594778e-01f,
  2.08162650e-01f, 1.94925979e-01f, 1.16673544e-01f, 2.21271329e-02f, -8.02870281e-03f, 6.08720593e-02f, -9.35882330e-02f, -1.38960168e-01f, -1.36849016e-01f, -4.46666032e-03f,
  -2.74292398e-02f, 2.24275351e-01f, 2.42448419e-01f, 4.40743864e-02f, 1.85922310e-01f, 4.86747846e-02f, 1.37507021e-01f, 9.46897790e-02f, 7.84458220e-02f, 1.77707940e-01f,
  1.27386838e-01f, 3.65980178e-01f, 5.29316533e-03f, 1.62728637e-01f, 1.81270555e-01f, 9.38072354e-02f, 1.23893045e-01f, 2.27640584e-01f, 1.86965257e-01f, 1.60864726e-01f,
  1.58297494e-01f, 9.60001051e-02f, 1.41963974e-01f, 7.84630850e-02f, 9.13833231e-02f, 1.66477054e-01f, 2.10575104e-01f, 1.83128521e-01f, 2.83606481e-02f, 1.57158881e-01f,
  8.52912664e-02f, 2.20462143e-01f, 1.86916724e-01f, -6.13379516e-02f, 9.09443423e-02f, 5.16174622e-02f, 1.38876557e-01f, 1.03389792e-01f, 8.46123099e-02f, 2.11079657e-01f,
  -1.23292290e-01f, -4.55373600e-02f, -1.42668158e-01f, -1.16539896e-01f, -1.11465961e-01f, -4.63256799e-02f, -3.92534658e-02f, -2.46392712e-02f, -1.62636057e-01f, -8.88366550e-02f,
  -8.54178444e-02f, -5.84196597e-02f, -8.21989998e-02f, -1.03334554e-01f, -1.47032037e-01f, -1.47426808e-02f, -1.24568671e-01f, -1.07904017e-01f, -1.07807606e-01f, -3.13011296e-02f,
  -7.75701851e-02f, -6.67421371e-02f, -8.01689178e-02f, -1.01646796e-01f, -1.58800781e-01f, -1.34556085e-01f, -9.90562439e-02f, -1.06819011e-01f, -7.98532665e-02f, -1.12379715e-02f,
  1.51319131e-01f, 3.67290862e-02f, 1.81764826e-01f, 1.21227503e-01f, 1.54781967e-01f, 1.25579596e-01f, 1.93421841e-01f, 3.50675657e-02f, 1.66313738e-01f, 1.41689643e-01f,
  1.26413345e-01f, 1.69473529e-01f, 1.88742325e-01f, 1.13217108e-01f, 1.04727395e-01f, 1.31824031e-01f, 1.58654153e-01f, 7.95363560e-02f, 4.44559492e-02f, 1.35838792e-01f,
  1.46172509e-01f, 9.50071812e-02f, -1.17291790e-02f, -5.47427265e-03f, 1.16602033e-01f, -2.67769620e-02f, 1.16028786e-02f, 1.20400064e-01f, 3.37017216e-02f, -4.03252343e-04f,
  -2.15233471e-02f, -1.39776975e-01f, -1.04766652e-01f, -1.21818081e-01f, -1.34152412e-01f, -3.28331292e-02f, -1.19144224e-01f, 3.60315628e-02f, -4.81343456e-02f, -7.88322240e-02f,
  -8.52111802e-02f, 1.10854648e-01f, 1.99383944e-02f, 1.77139193e-01f, 2.08017826e-02f, -2.04838425e-01f, -9.19225961e-02f, 7.46140629e-02f, 8.79334509e-02f, 2.89045293e-02f,
  8.22005142e-03f, -6.19817041e-02f, 9.47995558e-02f, 5.78009412e-02f, -2.16796815e-01f, -9.26728845e-02f, -1.60733446e-01f, -9.09532011e-02f, -8.74974802e-02f, -2.90874332e-01f,
  -2.58080274e-01f, 1.81704406e-02f, 2.34884955e-02f, 8.22749510e-02f, 2.30738893e-02f, 1.34424746e-01f, 5.95713034e-02f, 1.78974587e-02f, 1.16414987e-01f, 1.90867409e-02f,
  -1.22319310e-04f, 9.16592553e-02f, 5.09772338e-02f, 8.12598392e-02f, -6.09768890e-02f, 6.91614300e-02f, 5.42169847e-02f, 3.92724536e-02f, 3.56286764e-02f, -6.95259729e-03f,
  1.04645051e-01f, -4.49761637e-02f, 4.62105498e-02f, 1.48514867e-01f, 2.86565442e-02f, 9.23028961e-02f, 1.00290693e-01f, 4.20750072e-03f, 5.56355640e-02f, -1.39000341e-01f,
  8.03260207e-02f, -1.08383838e-02f, -9.64946598e-02f, -5.16626164e-02f, -3.30625810e-02f, -3.22717354e-02f, -1.66853681e-01f, -8.54391232e-02f, -4.89426851e-02f, -1.03095762e-01f,
  -3.11718159e-03f, 2.09889729e-02f, 7.36234263e-02f, 9.96743143e-03f, 3.71292513e-03f, -4.67222854e-02f, 5.82975969e-02f, -1.00565888e-01f, 3.88102629e-03f, -5.80264069e-03f,
  -7.42817745e-02f, -7.75281638e-02f, -9.73099396e-02f, -5.20886667e-02f, -9.56858769e-02f, -9.61243436e-02f, 2.48448998e-02f, 1.60555448e-02f, -2.82869150e-04f, -1.06231108e-01f,
  1.61097929e-01f, 2.90253073e-01f, -7.08160400e-02f, -6.13368722e-03f, 7.04874694e-02f, 2.21069958e-02f, -2.70242319e-02f, 6.07108586e-02f, -2.81991754e-02f, -3.25835869e-02f,
  3.44334096e-02f, -2.08223164e-02f, -8.99315998e-02f, 3.95012796e-02f, -8.22984129e-02f, -7.28776082e-02f, 1.13240490e-02f, -6.08859882e-02f, 5.51829860e-02f, -5.80717809e-02f,
  5.14604263e-02f, -1.43543826e-02f, -4.09651606e-04f, 4.12640125e-02f, -5.46762608e-02f, -1.49475504e-02f, -3.26885097e-02f, 7.76238069e-02f, 8.43806118e-02f, -9.59290937e-02f,
  -1.86745197e-01f, 5.97644001e-02f, 6.30434528e-02f, -7.72318318e-02f, 5.44494726e-02f, -1.07798919e-01f, -7.69811347e-02f, -2.15384319e-01f, -1.96058661e-01f, -4.82905805e-02f,
  4.47193757e-02f, -1.38146982e-01f, -1.91163734e-01f, -1.71732351e-01f, -2.47843355e-01f, -1.02580197e-01f, 4.59036119e-02f, -1.76073462e-01f, -2.36156464e-01f, -1.07212052e-01f,
  -1.26067884e-02f, -1.50909767e-01f, -2.02369511e-01f, -1.38608709e-01f, 2.27262974e-02f, -1.68864176e-01f, 8.04568455e-02f, -1.22366967e-02f, -2.13278830e-03f, 6.74803406e-02f,
  -3.87668982e-02f, -9.16117802e-02f, -2.45942488e-01f, -1.28929079e-01f, -7.80920982e-02f, -1.21177576e-01f, -3.76855843e-02f, -1.26886979e-01f, -1.57956451e-01f, -1.08680956e-01f,
  -6.65683150e-02f, -9.74334925e-02f, -3.83992642e-02f, -9.53825191e-02f, -1.00087300e-01f, -7.40454271e-02f, -1.11531839e-01f, -9.96062309e-02f, -1.26513198e-01f, -6.64910302e-02f,
  4.25367476e-03f, -9.83635485e-02f, -7.27855340e-02f, -1.82326347e-01f, -3.41578536e-02f, -1.51436582e-01f, -1.53713390e-01f, -4.24035899e-02f, -1.78955078e-01f, -1.84877813e-01f,
  1.25289470e-01f, 1.36073485e-01f, 1.75364152e-01f, 1.75645590e-01f, 1.58683285e-01f, 2.76865140e-02f, 8.13504979e-02f, 8.43572840e-02f, 4.03850339e-02f, 7.69034475e-02f,
  1.24961376e-01f, 7.09842965e-02f, 8.93706605e-02f, 6.87468201e-02f, 5.84310293e-02f, 3.00068725e-02f, 3.40823606e-02f, 1.21008523e-01f, 1.41176194e-01f, 5.82608068e-03f,
  1.54999077e-01f, 1.69840544e-01f, 8.05907100e-02f, 1.27447262e-01f, 1.59846798e-01f, 2.08566859e-01f, 1.03230506e-01f, 1.45360023e-01f, 1.03599533e-01f, 2.07651451e-01f,
  -3.50915164e-01f, -4.96876985e-02f, -1.16031498e-01f, -1.43413737e-01f, -1.40110835e-01f, -1.51629701e-01f, -1.59160867e-01f, -1.00334503e-01f, -1.21611983e-01f, -7.52197877e-02f,
  -1.45672321e-01f, -2.43969992e-01f, -1.13533258e-01f, -8.17553848e-02f, -1.46169826e-01f, -1.97139785e-01f, -1.73654214e-01f, -1.24151155e-01f, -1.25218540e-01f, -1.26524821e-01f,
  -6.23167604e-02f, -1.45895630e-01f, -2.29878128e-01f, -2.45895341e-01f, -1.57811061e-01f, -1.65168405e-01f, -1.86481178e-01f, -2.49854252e-01f, -3.02565545e-01f, -3.43933493e-01f,
  -7.25262389e-02f, -9.24686939e-02f, -2.92300373e-01f, 1.85095832e-01f, 1.38439946e-02f, -1.08266316e-01f, -2.27568895e-01f, -6.74597099e-02f, 1.32538259e-01f, 5.90689667e-02f,
  7.99528360e-02f, 1.83636114e-01f, 2.07506523e-01f, 1.02401115e-02f, 6.45156503e-02f, -1.44968078e-01f, -1.85106531e-01f, -3.04354187e-02f, 9.49730426e-02f, 2.13290319e-01f,
  1.30493045e-01f, 7.35419318e-02f, 6.28182665e-02f, 6.90459460e-02f, -1.33019686e-01f, 8.66300333e-03f, -1.63845941e-01f, -1.51490256e-01f, -9.92050916e-02f, -1.18547931e-01f,
  -6.18536770e-02f, -1.26218095e-01f, 2.74022575e-02f, 8.51229206e-02f, -1.18330173e-01f, -6.11931458e-02f, -5.89720272e-02f, -1.32520441e-02f, -5.42001985e-02f, -2.89496239e-02f,
  -5.20638712e-02f, -2.77465768e-03f, 2.80534122e-02f, 5.60768396e-02f, -7.83241615e-02f, 3.78274657e-02f, -3.37610766e-03f, -1.01344705e-01f, -1.36359006e-01f, -5.53808026e-02f,
  -4.14232835e-02f, -1.38574615e-01f, -1.60377741e-01f, -4.04653046e-03f, -2.14146584e-01f, -3.89919020e-02f, -4.72011864e-02f, -3.73626687e-02f, -1.15633138e-01f, 1.10718627e-02f,
  1.74398869e-01f, -4.19797041e-02f, -1.12003408e-01f, -4.11095731e-02f, -9.95842367e-03f, -4.22444604e-02f, 4.99076657e-02f, -4.87659276e-02f, 3.54936086e-02f, 5.67226186e-02f,
  -4.48066778e-02f, -5.79025708e-02f, -1.72175243e-02f, -6.08996116e-03f, 1.07554346e-01f, -9.52358767e-02f, -7.95486867e-02f, 1.65619003e-03f, 1.09697832e-02f, -6.31080717e-02f,
  -2.73782182e-02f, 1.69935487e-02f, 1.41742714e-02f, 4.13026027e-02f, -1.39310705e-02f, 9.22889821e-03f, 3.82216759e-02f, -6.52285293e-02f, -3.37664899e-03f, -8.31788406e-02f,
  2.53545731e-01f, -5.45475669e-02f, 1.76239833e-02f, -2.30245367e-02f, -9.59603414e-02f, -6.46112813e-03f, 4.46386933e-02f, -2.57363338e-02f, -7.80229941e-02f, 2.80200280e-02f,
  -1.22417614e-01f, -1.50922290e-03f, -5.77445850e-02f, -3.59284133e-02f, 5.95451817e-02f, -3.32562556e-03f, 4.25077826e-02f, -1.04286186e-02f, -1.21805933e-03f, -4.70764861e-02f,
  -5.13917506e-02f, 1.16820268e-01f, 1.32092088e-01f, 4.04528230e-02f, -7.69839343e-03f, 1.08119778e-01f, 9.55993235e-02f, -3.78715023e-02f, 3.29684690e-02f, 1.04578882e-01f,
  -4.03103203e-01f, -2.99249381e-01f, -1.16003029e-01f, -4.40199763e-01f, -3.29776913e-01f, -1.57298326e-01f, -2.23594785e-01f, -2.27919683e-01f, -2.68047124e-01f, -2.06982166e-01f,
  -2.63417691e-01f, -1.90049380e-01f, -1.76893249e-01f, -5.90047948e-02f, -1.50865600e-01f, -2.35501483e-01f, -2.13910475e-01f, -9.50142592e-02f, -1.02799490e-01f, -1.49752855e-01f,
  -2.11617783e-01f, -3.19719732e-01f, -1.76557526e-01f, -1.89935192e-01f, -2.18496084e-01f, -1.63916603e-01f, -1.05610035e-01f, -1.30675316e-01f, -1.18397810e-01f, -2.66671062e-01f,
  -2.24037275e-01f, -2.12307915e-01f, -1.10611230e-01f, -1.22726187e-01f, -2.55177736e-01f, -1.64132684e-01f, -2.63337910e-01f, -1.00506522e-01f, -9.45619568e-02f, -2.16146648e-01f,
  -1.97367281e-01f, -2.21959710e-01f, -1.83476657e-01f, -1.26919031e-01f, -2.17497468e-01f, -2.23434448e-01f, -1.55501336e-01f, -1.21710531e-01f, -1.45356178e-01f, -1.36753783e-01f,
  -8.17981809e-02f, -2.63368726e-01f, -2.29758263e-01f, 7.79725611e-03f, -1.28661454e-01f, -1.01856448e-01f, -7.83150122e-02f, -1.11881547e-01f, -1.14840083e-01f, -1.97325468e-01f,
  1.48949713e-01f, 1.78299800e-01f, 1.55311346e-01f, 1.15107670e-01f, 7.17635676e-02f, 8.49501044e-02f, 2.98203491e-02f, 5.30343279e-02f, 1.02234580e-01f, 7.27845505e-02f,
  -3.98341939e-03f, 7.72865489e-03f, 9.00969952e-02f, -3.75090959e-03f, 4.56827832e-03f, 4.16600704e-02f, 1.05173513e-02f, 1.40964389e-02f, 1.78894162e-01f, 2.04729252e-02f,
  3.64098586e-02f, 1.90918237e-01f, 5.31083085e-02f, 6.51156455e-02f, 7.84623548e-02f, 1.29605308e-01f, 1.02534719e-01f, 1.23949975e-01f, 8.61380473e-02f, 5.20377830e-02f,
  -2.34365761e-01f, -1.24032676e-01f, -2.23287329e-01f, -1.80857807e-01f, -1.27357990e-01f, -8.95844474e-02f, -1.97758153e-01f, -2.02835083e-01f, -1.21637605e-01f, -1.96857214e-01f,
  -1.91699296e-01f, -1.71548590e-01f, -1.26492202e-01f, -1.49373814e-01f, -2.18610510e-01f, -1.95116878e-01f, -2.15649292e-01f, -2.04624385e-01f, -5.26083224e-02f, -1.35706708e-01f,
  -9.33581814e-02f, -2.02820033e-01f, -1.18403472e-01f, -8.60954821e-02f, -8.42499435e-02f, -1.48704082e-01f, -8.68290290e-02f, -4.10296470e-02f, -8.08807164e-02f, -2.36598551e-01f,
  4.22648609e-01f, 1.29210696e-01f, 2.38713294e-01f, 1.13002948e-01f, -1.85488552e-01f, -9.21206400e-02f, -1.55729532e-01f, -2.74088979e-02f, -1.90246683e-02f, 4.38864231e-02f,
  1.20152436e-01f, 4.08436209e-02f, 2.54960060e-01f, 1.57752022e-01f, 1.86382696e-01f, 1.94347668e-02f, 8.51375312e-02f, 1.58579737e-01f, 1.18579697e-02f, -2.23541871e-01f,
  -1.33882612e-01f, -1.49478614e-02f, 2.09547639e-01f, 1.88210458e-02f, -7.51982778e-02f, -9.49034244e-02f, 8.99560470e-03f, 7.81743079e-02f, -7.65356123e-02f, 5.25121950e-02f,
  3.06756914e-01f, 2.21081302e-01f, 4.28122580e-02f, 5.81400767e-02f, 1.09629430e-01f, 1.68555170e-01f, 1.41611129e-01f, 7.78412819e-02f, 2.79237162e-02f, 2.04137880e-02f,
  1.23639911e-01f, -6.10428164e-03f, 1.40980631e-01f, 8.84796828e-02f, 2.46959645e-03f, 1.21549197e-01f, 1.72150493e-01f, 1.44803956e-01f, 1.02352932e-01f, 1.32874072e-01f,
  6.83357101e-03f, 2.67099366e-02f, 1.94213688e-01f, 1.15640953e-01f, 1.59453992e-02f, 8.53978470e-02f, 3.71520706e-02f, 8.94721746e-02f, 8.03385898e-02f, 8.47847853e-03f,
  2.22596470e-02f, -7.55199566e-02f, -1.07212856e-01f, -1.18003733e-01f, -8.62580314e-02f, -8.73225480e-02f, -9.16403085e-02f, -7.52594993e-02f, -5.62942363e-02f, -1.14539526e-01f,
  -1.24676757e-01f, 1.63848680e-02f, -6.56033158e-02f, -8.66474807e-02f, -1.47744328e-01f, -1.39498621e-01f, -4.71998565e-02f, -2.54287850e-02f, -1.16614155e-01f, -7.87795112e-02f,
  6.28814939e-03f, -1.29750744e-01f, -9.59243476e-02f, -2.07792342e-01f, 6.73956657e-03f, -6.67500496e-02f, -4.27502133e-02f, -1.22900866e-01f, -1.65126637e-01f, -5.70714958e-02f,
  1.73564449e-01f, 2.51199871e-01f, 1.56735599e-01f, 3.53813805e-02f, 1.13214077e-02f, 6.24539517e-02f, 1.21257327e-01f, 2.57165134e-02f, 6.55798540e-02f, 3.15579921e-02f,
  1.09859399e-01f, 6.07420579e-02f, 5.35513572e-02f, 3.89726833e-02f, 2.37209331e-02f, -5.91964424e-02f, 1.08843394e-01f, 3.45276333e-02f, 6.93891495e-02f, -1.22190854e-02f,
  1.31184101e-01f, 1.72157492e-02f, 2.69527696e-02f, 8.45894739e-02f, -3.52555774e-02f, 1.15401626e-01f, -2.38398127e-02f, 1.51390051e-02f, 7.74885863e-02f, 5.51283024e-02f,
  -4.34216529e-01f, 1.12119481e-01f, -2.79262900e-01f, -1.09213874e-01f, 4.14311104e-02f, -2.08379298e-01f, -7.17146173e-02f, -1.48249671e-01f, -1.24154776e-01f, -1.08019216e-02f,
  1.53464619e-02f, -1.74742341e-01f, -2.19376266e-01f, -2.49540061e-01f, -3.74720663e-01f, -1.34317905e-01f, -3.57367732e-02f, -2.83566475e-01f, -4.37077999e-01f, -1.92229316e-01f,
  -5.46520501e-02f, -1.94203705e-01f, -3.62602264e-01f, -1.65956974e-01f, 6.48086295e-02f, -1.75146013e-02f, 8.12801439e-03f, -3.72779816e-02f, -1.87535733e-02f, 1.02276385e-01f,
  1.66962799e-02f, -1.40655309e-01f, -1.75702274e-01f, -1.30973607e-01f, -6.58598393e-02f, -1.73184082e-01f, -1.41229317e-01f, -6.63349852e-02f, -1.87128603e-01f, -3.43083069e-02f,
  -1.17028594e-01f, -5.99222817e-02f, -1.81729063e-01f, -4.13173139e-02f, -2.02357143e-01f, -5.47069460e-02f, -6.28776997e-02f, -2.33086810e-01f, -2.58931041e-01f, -3.12812515e-02f,
  1.28655089e-03f, -1.55316338e-01f, -1.18249387e-01f, -1.97579429e-01f, -2.63891459e-01f, -1.61497071e-01f, -2.83832606e-02f, -1.82531998e-01f, -1.39551982e-01f, 8.42380747e-02f,
  1.64244711e-01f, 9.25463513e-02f, 1.07971996e-01f, 3.30860429e-02f, 5.17081060e-02f, 1.40175214e-02f, 7.34191388e-02f, 2.87059508e-02f, 7.22677913e-03f, 5.37508726e-02f,
  -5.38736172e-02f, 6.96573108e-02f, 8.96430239e-02f, -1.55048911e-02f, 3.52166072e-02f, 5.24309315e-02f, 3.91087271e-02f, -1.14384936e-02f, 3.74925584e-02f, 2.16384586e-02f,
  5.31788692e-02f, 3.75954583e-02f, 6.19686022e-02f, 9.27790254e-02f, 5.78326099e-02f, 6.25064820e-02f, 2.78734486e-03f, -3.22549976e-02f, 1.12396434e-01f, 6.67099878e-02f,
  1.25679120e-01f, -3.10373932e-01f, 2.97410153e-02f, -8.44031498e-02f, -6.57335743e-02f, -1.55611578e-02f, -1.14735715e-01f, -7.15389550e-02f, -9.04833451e-02f, -1.64552405e-01f,
  -1.36170909e-01f, -1.03409186e-01f, -3.05275638e-02f, -3.19948718e-02f, -7.64294341e-02f, -7.17118904e-02f, -8.48770812e-02f, -8.26907977e-02f, -1.79404050e-01f, -6.23613372e-02f,
  -4.84905876e-02f, -1.23181641e-01f, -1.38466015e-01f, -9.88288820e-02f, 6.81202020e-03f, -1.36748195e-01f, -5.45518175e-02f, 2.09061499e-03f, -2.04504579e-01f, -1.11271761e-01f,
  -3.55403811e-01f, -2.67319642e-02f, 1.97285991e-02f, -5.44615723e-02f, 2.39712074e-01f, 2.04896957e-01f, 1.97105065e-01f, -2.40954403e-02f, -1.14468679e-01f, 1.97915230e-02f,
  1.37532055e-01f, 1.06146328e-01f, 4.17024903e-02f, 5.59587069e-02f, -5.96924219e-03f, 1.19220562e-01f, -2.56320685e-02f, 1.09460028e-02f, -5.13978750e-02f, 7.66826719e-02f,
  9.14880186e-02f, -5.26676290e-02f, -2.04187840e-01f, -7.15368614e-02f, 1.40135974e-01f, 8.65140483e-02f, 6.45332560e-02f, -5.64775653e-02f, 1.00278258e-01f, 7.31464028e-02f,
  2.69771907e-02f, -1.63893193e-01f, 1.16466470e-01f, 1.22276783e-01f, 9.68770161e-02f, 2.07275432e-02f, 8.48883688e-02f, -7.23189712e-02f, 5.16655259e-02f, 1.12438165e-02f,
  5.58849573e-02f, 8.56204554e-02f, 3.47453952e-02f, 9.86891389e-02f, 2.04842854e-02f, -2.43421420e-02f, -1.94064993e-02f, -1.16509341e-01f, 6.13476783e-02f, 8.02492648e-02f,
  1.88710436e-01f, 1.18580095e-01f, 4.73333858e-02f, -1.70269217e-02f, -9.63501073e-03f, 4.83465232e-02f, -4.86161746e-03f, 5.78251667e-02f, -6.16993755e-02f, -5.60404770e-02f,
  1.18864253e-02f, 5.20522110e-02f, 8.46680067e-03f, -2.53067706e-02f, -7.11826934e-03f, 2.22618002e-02f, 7.22315907e-02f, 1.05697639e-01f, 5.48874624e-02f, -5.86716495e-02f,
  9.78972111e-03f, 7.90561922e-03f, 2.55488474e-02f, -4.09408845e-02f, 9.01852325e-02f, -9.47176851e-03f, 4.39271680e-05f, -7.14204609e-02f, 3.25782690e-03f, 5.02003841e-02f,
  -3.67568480e-03f, 1.78251043e-02f, -2.40377337e-02f, -5.17339818e-02f, -2.37612519e-02f, 6.71838922e-03f, 4.48560864e-02f, 3.40495445e-02f, -1.71980970e-02f, 3.23315412e-02f,
  -4.94895279e-02f, -7.42679322e-03f, -6.76929876e-02f, 4.91543412e-02f, -1.13901207e-02f, 8.38938057e-02f, 8.49544182e-02f, 6.05272278e-02f, 7.75265247e-02f, 1.27539515e-01f,
  6.52058125e-02f, 7.41694197e-02f, 8.07991251e-02f, 2.62078214e-02f, 1.04929924e-01f, 1.35645881e-01f, 4.42047380e-02f, 1.08454101e-01f, 6.65410310e-02f, 4.28698100e-02f,
  1.68317836e-02f, 1.45177254e-02f, -4.82991822e-02f, 6.93617985e-02f, 4.81816232e-02f, 1.50348082e-01f, 2.45469455e-02f, 1.14433810e-01f, 4.27800119e-02f, -1.61188431e-02f,
  7.99717009e-02f, 7.48832971e-02f, -1.31100208e-01f, 3.28923054e-02f, 5.08694153e-04f, -1.64493434e-02f, -6.04668260e-02f, -2.89013609e-02f, 9.48135331e-02f, 6.67049810e-02f,
  2.77103856e-03f, 1.70208819e-04f, 2.64397971e-02f, 1.82254929e-02f, 1.75539374e-01f, 1.44495338e-01f, 9.68848392e-02f, 1.93036079e-01f, 6.79272264e-02f, 5.09045720e-02f,
  1.74810022e-01f, 7.56211132e-02f, 1.50498629e-01f, 2.13973194e-01f, 2.12558717e-01f, 1.79468706e-01f, 1.35249928e-01f, 1.42700732e-01f, 1.05057560e-01f, 2.77470618e-01f,
  -2.47116964e-02f, 1.90068465e-02f, 2.24057529e-02f, 1.22922033e-01f, 1.72583237e-01f, 1.09067068e-01f, 2.92834789e-02f, 6.41085804e-02f, 1.63552836e-01f, 1.09233253e-01f,
  6.34898543e-02f, 1.65441200e-01f, 5.69503084e-02f, 1.74262404e-01f, 1.06632918e-01f, 4.99215163e-02f, 2.37709314e-01f, 1.33644491e-01f, 1.90628082e-01f, 1.04448803e-01f,
  1.31304637e-01f, 1.42964855e-01f, 8.63265693e-02f, 1.48222700e-01f, 7.96540156e-02f, 1.76566374e-02f, 6.73320815e-02f, 1.40457265e-02f, 8.11099783e-02f, 1.31788477e-01f,
  4.94722612e-02f, -3.02150734e-02f, -8.78706574e-02f, -6.57973886e-02f, 2.67647766e-02f, 5.05061867e-03f, -9.05529317e-03f, 8.70042071e-02f, -8.95960908e-03f, 1.48807084e-02f,
  -1.07712232e-01f, -5.59592359e-02f, -1.21892113e-02f, -6.61245808e-02f, -3.99189182e-02f, -7.15419278e-02f, -1.03790157e-01f, -3.18609141e-02f, -1.14070568e-02f, -2.81810481e-03f,
  1.28640383e-02f, -1.03035338e-01f, -5.72055615e-02f, -7.07807541e-02f, -1.11097269e-01f, -1.41541570e-01f, -1.00857355e-01f, -1.41208723e-01f, -1.64167628e-01f, -1.49879113e-01f,
  -5.46166934e-02f, 9.69317034e-02f, 4.92364056e-02f, 1.54737726e-01f, 6.92172945e-02f, 8.10408443e-02f, 6.18408956e-02f, 1.69883147e-01f, -2.46603452e-02f, 7.61533380e-02f,
  -2.12709978e-02f, 9.27100480e-02f, 8.06750283e-02f, 1.27352968e-01f, 1.40977949e-01f, 1.89136878e-01f, 1.83885276e-01f, 1.37391999e-01f, 1.39389679e-01f, 1.86046079e-01f,
  1.24824725e-01f, 6.75560236e-02f, -1.83235668e-02f, -4.30392660e-02f, 7.79773816e-02f, -4.40285429e-02f, 5.70916422e-02f, 7.01420307e-02f, 5.19296676e-02f, 1.22541403e-02f,
  3.51105809e-01f, -2.88546920e-01f, -7.55768791e-02f, 1.15336381e-01f, 2.95954011e-02f, -9.22974870e-02f, -1.44391000e-01f, 5.61503842e-02f, 5.76299466e-02f, -1.35028377e-01f,
  -1.80254541e-02f, 1.64986506e-01f, 4.13691252e-02f, -1.82017870e-02f, -3.69614884e-02f, -2.41072297e-01f, -2.65069127e-01f, -7.56785180e-03f, 2.37165272e-01f, 8.76482204e-02f,
  -1.01411961e-01f, -6.55312240e-02f, 4.63785157e-02f, 3.53974998e-02f, -4.83438671e-02f, -2.23386125e-03f, -1.12905532e-01f, -1.19025350e-01f, -3.69210902e-04f, -1.18881620e-01f,
  1.70890391e-02f, -3.41350809e-02f, 9.69275236e-02f, 3.36245000e-02f, -1.79699436e-02f, -1.52379079e-02f, -4.07497250e-02f, 1.40324039e-02f, -1.00557217e-02f, 3.45079862e-02f,
  -8.81459117e-02f, -5.71056828e-02f, -5.52176461e-02f, -8.44440311e-02f, -4.12975773e-02f, 6.19134456e-02f, -3.12428921e-02f, -7.29474379e-03f, 2.12823115e-02f, -5.32476716e-02f,
  -2.06539538e-02f, 3.58262546e-02f, -2.93079633e-02f, 9.99715924e-03f, 3.48479711e-02f, 1.37276687e-02f, 1.95358861e-02f, 3.55424769e-02f, -2.90507860e-02f, -4.57082391e-02f,
  1.18558876e-01f, 4.99408580e-02f, 1.18253902e-02f, 1.23566277e-02f, -1.00058958e-01f, 3.74802127e-02f, -1.56108607e-02f, -7.70699382e-02f, 4.68931012e-02f, -6.01941012e-02f,
  -1.51935946e-02f, 7.07854982e-03f, -3.80197652e-02f, 4.30059321e-02f, -7.17301443e-02f, -4.76638898e-02f, -9.18438733e-02f, 4.35736291e-02f, -8.97827297e-02f, -6.24115486e-03f,
  -7.38961622e-02f, 5.23568057e-02f, -4.33796532e-02f, -3.06153391e-02f, -9.98646244e-02f, -4.53645624e-02f, 5.22916242e-02f, -8.39552432e-02f, -6.62062988e-02f, -8.36440995e-02f,
  -1.07241739e-02f, -7.99744856e-03f, -1.07302547e-01f, 7.38537610e-02f, -7.10140467e-02f, -7.09268600e-02f, 3.18344939e-03f, -2.70970520e-02f, -3.36004682e-02f, 1.33900894e-02f,
  -8.75787660e-02f, 2.67082788e-02f, -2.48853173e-02f, -1.07950754e-01f, -3.13114710e-02f, 5.98652847e-02f, -5.58267087e-02f, 3.76241431e-02f, -6.20883740e-02f, -3.16389315e-02f,
  -1.62518218e-01f, 7.38092214e-02f, 1.64041203e-02f, -8.60360414e-02f, -8.32425654e-02f, -3.63794304e-02f, 4.33956832e-02f, -6.93961829e-02f, 1.18280672e-01f, -5.50696962e-02f,
  1.31721646e-01f, -4.86042500e-02f, -2.16051757e-01f, -1.11045549e-02f, 7.05804378e-02f, 1.29015952e-01f, 1.64047629e-01f, 1.55769944e-01f, 2.60409694e-02f, 4.20478396e-02f,
  7.88642243e-02f, -1.83140859e-02f, 3.64568569e-02f, 7.31631815e-02f, 5.39961904e-02f, -7.16432035e-02f, -8.62707719e-02f, 2.30879132e-02f, 8.14207196e-02f, 1.65514395e-01f,
  3.56739312e-02f, 1.56614464e-02f, 1.18785463e-02f, -7.39758089e-02f, -2.50046849e-01f, -4.70079146e-02f, -2.65555680e-01f, -1.31659687e-01f, -2.09975131e-02f, -1.76701248e-01f,
  -1.02475218e-01f, -4.47911508e-02f, 1.31364152e-01f, 5.58792576e-02f, -7.99332038e-02f, 8.47080126e-02f, 2.48603546e-03f, -8.60145614e-02f, -7.07931593e-02f, -3.84112820e-02f,
  -2.88542863e-02f, -2.01970488e-02f, 7.03526586e-02f, 2.84515824e-02f, 1.31650865e-01f, 6.91713095e-02f, 2.18098462e-02f, 2.75175497e-02f, 1.48079088e-02f, -4.44835648e-02f,
  5.64414524e-02f, -5.00178933e-02f, -5.29871868e-05f, 1.45433009e-01f, 8.36299807e-02f, 1.20658696e-01f, -1.22001305e-01f, -4.58041951e-02f, -9.96994507e-03f, -1.37494519e-01f,
  9.19599012e-02f, -3.52447703e-02f, -2.30414458e-02f, -4.52143736e-02f, 6.29029796e-02f, 2.71651987e-02f, 1.66296456e-02f, -3.30669060e-02f, 3.97477522e-02f, -7.58071914e-02f,
  -9.60585400e-02f, -7.08811134e-02f, 8.35598707e-02f, -1.10663339e-01f, 8.05487949e-03f, 4.56549712e-02f, 1.64883882e-02f, 3.69214453e-02f, 2.13037077e-02f, 2.98082200e-03f,
  2.52037812e-02f, -3.17863747e-02f, -1.08702302e-01f, -7.72213470e-03f, -5.63309453e-02f, -7.77410939e-02f, 3.63113806e-02f, -8.78323093e-02f, -2.62515936e-02f, -5.62270544e-02f,
  1.43296272e-02f, 2.02035189e-01f, 4.47306894e-02f, 6.60900623e-02f, 1.55422539e-02f, -7.35631809e-02f, 1.27585694e-01f, 1.06828017e-02f, 3.46958637e-02f, -3.36282887e-02f,
  1.04808107e-01f, 3.08139101e-02f, 1.65283289e-02f, 9.90839582e-03f, 5.40133528e-02f, 2.77172569e-02f, 1.44592330e-01f, 3.70609500e-02f, 1.61271989e-01f, -8.09258688e-03f,
  1.06232435e-01f, 2.36268938e-01f, 1.63956523e-01f, 1.39434770e-01f, -1.06356191e-02f, 2.25140855e-01f, -7.95582533e-02f, 2.12404225e-03f, 1.64942622e-01f, 1.05471745e-01f,
  -3.57850820e-01f, -8.01572725e-02f, -1.66525319e-01f, -8.30424279e-02f, 1.14188299e-01f, 1.60622761e-01f, 5.14844283e-02f, 4.04123887e-02f, -1.27360180e-01f, -9.29482728e-02f,
  4.90813777e-02f, 1.01599216e-01f, 5.37429191e-02f, -2.37029418e-02f, 3.35760713e-02f, -7.30303377e-02f, -1.46644741e-01f, -3.97812873e-02f, 9.48808268e-02f, 2.49284972e-02f,
  1.54692426e-01f, 3.72224525e-02f, -1.65904313e-01f, -1.00162812e-01f, -8.24274495e-02f, -8.17924365e-02f, -9.59736481e-02f, -2.22493336e-02f, -8.29603374e-02f, -2.63656020e-01f,
  -1.61143586e-01f, -3.03208381e-01f, -6.30077869e-02f, -1.46693707e-01f, -1.31471783e-01f, -1.53936654e-01f, -9.69083086e-02f, -8.16042200e-02f, -1.96716096e-02f, -7.69258440e-02f,
  -5.18086106e-02f, -1.63451567e-01f, -1.45922899e-01f, -4.81397845e-02f, -2.03172177e-01f, -1.12747088e-01f, -1.97960645e-01f, -1.30995795e-01f, -3.92531604e-02f, -7.79303014e-02f,
  -6.54327720e-02f, -1.40058070e-01f, -8.68244693e-02f, -7.73507506e-02f, -1.51033655e-01f, -1.33211061e-01f, -1.10749267e-01f, -1.95256755e-01f, -7.07111359e-02f, -1.40279114e-01f,
  5.41654639e-02f, -4.92478125e-02f, -1.87152028e-02f, -1.42515441e-02f, -3.04838922e-02f, -8.55887085e-02f, -2.60945782e-02f, -1.17478771e-02f, -5.11379763e-02f, -1.59753449e-02f,
  -1.88106652e-02f, -4.56591062e-02f, 3.38504644e-04f, -6.16530553e-02f, -6.00099973e-02f, -6.17117360e-02f, -1.01939552e-01f, 4.06307448e-03f, -6.89566955e-02f, -1.64254233e-01f,
  -4.85953204e-02f, -3.16279344e-02f, -1.21663928e-01f, -7.00899959e-02f, -6.88103139e-02f, -4.83775251e-02f, -1.23275742e-02f, -1.97588634e-02f, 4.07230482e-02f, -5.02019562e-02f,
  7.70718530e-02f, 5.70180640e-02f, -1.57470018e-01f, 1.90070327e-02f, -8.91011283e-02f, -5.83281033e-02f, -1.01374425e-01f, -1.15456216e-01f, -1.42597249e-02f, -1.51304916e-01f,
  -2.80603357e-02f, -1.07258344e-02f, -1.76393869e-03f, -7.65748471e-02f, -2.41738763e-02f, -1.18139945e-01f, -1.17066421e-01f, -1.94986816e-02f, -6.27000406e-02f, -1.17742876e-02f,
  3.18565289e-03f, -7.52834827e-02f, 4.41609770e-02f, 3.04250792e-02f, -7.77317807e-02f, -2.12878622e-02f, 6.55734614e-02f, 3.51391211e-02f, -2.16124728e-02f, -9.39970985e-02f,
  4.44570661e-01f, -5.93813881e-02f, -2.58298159e-01f, 6.70829341e-02f, -9.75506566e-03f, -2.94103902e-02f, 7.84004480e-03f, 2.57427096e-01f, 1.94567218e-01f, 6.41998947e-02f,
  -8.94175619e-02f, 1.18954025e-01f, 9.46024954e-02f, 8.23468864e-02f, 3.09065729e-02f, -1.25951454e-01f, -7.54014924e-02f, -2.88065635e-02f, 1.15527160e-01f, 2.03093514e-01f,
  7.01136142e-02f, -1.30751133e-02f, 2.11497322e-01f, 6.95945397e-02f, -1.18151173e-01f, -2.18564216e-02f, -1.61196187e-01f, -6.97134715e-03f, -1.61805212e-01f, -3.21175873e-01f,
  -1.76030323e-01f, 9.96331125e-02f, 1.06461219e-01f, -2.63320096e-02f, -5.58765978e-02f, 2.24202707e-01f, 9.97816399e-02f, 1.53486446e-01f, 9.13450867e-02f, 3.67792472e-02f,
  1.30451322e-02f, 1.47093162e-01f, -3.38947698e-02f, 1.00933701e-01f, 2.61476776e-03f, 1.10191489e-02f, 7.96982422e-02f, 1.07607007e-01f, 1.16627656e-01f, 6.71994388e-02f,
  -8.60187262e-02f, -6.73711151e-02f, -3.31856795e-02f, 4.08106893e-02f, 1.09128416e-01f, 5.59769683e-02f, -5.19025885e-02f, 1.11695021e-01f, -5.96939493e-03f, 3.77494954e-02f,
  -8.45766999e-03f, -5.52091785e-02f, -1.04812160e-01f, 2.70449799e-02f, -1.34910308e-02f, -1.50445905e-02f, -1.10978007e-01f, -7.52227083e-02f, -1.27087929e-03f, 8.64112750e-03f,
  2.60704570e-02f, -5.53475097e-02f, 7.00602774e-03f, -1.84481833e-02f, -7.24194720e-02f, -7.70471394e-02f, -1.41154438e-01f, -1.20539673e-01f, -6.49455488e-02f, -4.66072187e-02f,
  -2.23585684e-02f, -1.14499368e-01f, -1.06940962e-01f, -6.99330866e-02f, -1.34028748e-01f, -4.44414914e-02f, -5.44108152e-02f, -1.71673857e-02f, -5.81513299e-03f, 8.20402130e-02f,
  2.83372700e-01f, -8.61384906e-03f, 1.14689574e-01f, 4.79768068e-02f, 2.18729209e-02f, 7.88971186e-02f, -2.89445966e-02f, 7.89217204e-02f, -4.87911254e-02f, 1.11886762e-01f,
  -3.60017195e-02f, 1.20482817e-01f, 9.17029604e-02f, 3.26085649e-02f, 1.87570274e-01f, 7.88530186e-02f, -1.02205193e-02f, 2.46372540e-02f, 6.73038810e-02f, 3.70884985e-02f,
  2.58438885e-02f, 1.03706777e-01f, 1.82242215e-01f, 1.11253820e-01f, 8.24546665e-02f, 1.24076180e-01f, 1.13678843e-01f, 1.22351833e-01f, 1.29445001e-01f, 3.00202101e-01f,
  -2.19081938e-01f, -1.60086736e-01f, -1.35614499e-01f, -2.32620075e-01f, -4.05261330e-02f, 1.63503841e-01f, -8.67700297e-03f, 5.05375192e-02f, -1.14169553e-01f, -2.17540801e-01f,
  -5.43941818e-02f, -1.29952252e-01f, 2.83983983e-02f, 2.60392167e-02f, 1.36854395e-01f, 4.64381725e-02f, -3.11771017e-02f, 9.85097606e-03f, 2.27225989e-01f, 7.69127458e-02f,
  -2.06795465e-02f, -3.82664464e-02f, -8.79444033e-02f, 3.20545468e-03f, -1.20417118e-01f, -5.01786284e-02f, -1.43432856e-01f, -5.25370240e-02f, 3.68162319e-02f, -1.51190206e-01f,
  -2.68858910e-01f, -1.39370099e-01f, -4.69861217e-02f, -1.54688461e-02f, -4.77967858e-02f, -1.05421729e-01f, -1.45752309e-03f, -3.34390476e-02f, -7.70532992e-03f, -6.56221434e-02f,
  -1.12015687e-01f, 7.39702722e-03f, -6.21940615e-03f, -6.66590109e-02f, -9.13945436e-02f, 2.61802413e-02f, -1.23778442e-02f, -1.00745477e-01f, 2.14749016e-02f, 1.51486974e-02f,
  2.77401656e-02f, 1.30326347e-02f, 3.07436790e-02f, -6.09395951e-02f, -5.33651486e-02f, -4.65235375e-02f, 4.01098840e-02f, -4.04176004e-02f, -3.72286513e-02f, -1.38379544e-01f,
  -4.21042740e-02f, 1.33885676e-02f, 1.65443942e-01f, 7.81752169e-03f, 1.32607937e-01f, 1.05278239e-01f, -2.56989859e-02f, 7.41620585e-02f, 7.69563541e-02f, 6.77923635e-02f,
  1.56977162e-01f, 6.54624999e-02f, 1.67168546e-02f, 1.30182996e-01f, 6.04616292e-02f, 1.38838470e-01f, 8.29334334e-02f, 1.29303247e-01f, 8.83856863e-02f, 1.51434362e-01f,
  3.08699347e-02f, 3.07908244e-02f, 1.35870859e-01f, 1.05901934e-01f, 1.77000389e-01f, -1.78247516e-03f, 6.02859445e-03f, 6.84656501e-02f, -7.90478848e-03f, -8.66026618e-03f,
  -1.99989453e-01f, 2.25079656e-01f, -1.60857394e-01f, 1.61751695e-02f, 2.64150426e-02f, 2.95993360e-03f, -4.47869077e-02f, -3.45588587e-02f, -9.26745608e-02f, 3.56003679e-02f,
  -8.16918686e-02f, -1.96500476e-02f, 1.78864095e-02f, 5.08041754e-02f, -4.87317368e-02f, -6.54079318e-02f, -2.92876493e-02f, -1.04192132e-02f, 1.24791777e-02f, -1.59163475e-02f,
  7.06078634e-02f, -1.05609670e-01f, -9.25203413e-02f, 8.60083476e-03f, -1.00559175e-01f, 6.20777868e-02f, -8.69221836e-02f, 1.98428389e-02f, -3.49677913e-02f, -1.54813528e-01f,
  2.15485841e-01f, -1.38061807e-01f, -8.83084238e-02f, 1.14205703e-01f, -5.39718345e-02f, -1.20536387e-01f, -1.50266305e-01f, 1.17209964e-01f, 9.93513688e-02f, -5.84171601e-02f,
  -2.07656950e-01f, 5.56286499e-02f, 1.68500006e-01f, 2.41483990e-02f, 1.26676619e-01f, 7.00777471e-02f, 2.02082828e-01f, 1.10251062e-01f, -4.71863803e-03f, -1.09492745e-02f,
  -9.26487800e-03f, 4.83399592e-02f, 8.88615027e-02f, 8.47520158e-02f, -7.75956437e-02f, -5.91172278e-03f, -2.10749153e-02f, -3.68603654e-02f, -1.64908901e-01f, 4.99588773e-02f,
  -2.11770698e-01f, -2.19384328e-01f, 3.24294306e-02f, -5.52438013e-02f, -6.68452159e-02f, -6.81160465e-02f, 3.47905010e-02f, 5.09079322e-02f, 3.09971441e-02f, -1.08145595e-01f,
  -9.86562893e-02f, -9.09970626e-02f, -6.89623505e-02f, -1.50532708e-01f, -5.18359728e-02f, -1.24876544e-01f, -3.20419227e-03f, -1.10440096e-02f, 3.98748219e-02f, -1.18384428e-01f,
  -1.42429188e-01f, -2.15163901e-01f, -4.68169041e-02f, -1.64112255e-01f, -8.39230344e-02f, -8.75412822e-02f, -8.14910606e-02f, -1.39896289e-01f, -1.43940002e-01f, -5.36359549e-02f,
  5.42429350e-02f, 1.09564455e-03f, 4.23104838e-02f, -3.21793184e-02f, 1.01558931e-01f, 5.63306995e-02f, 5.81551418e-02f, 8.74872357e-02f, 7.02892393e-02f, 2.50345059e-02f,
  2.57383790e-02f, 9.74282920e-02f, 1.08209789e-01f, 6.11296184e-02f, 8.98831338e-02f, -1.54052665e-02f, 5.81287295e-02f, 7.12618092e-03f, 9.00022537e-02f, 9.41632502e-03f,
  3.90745811e-02f, 4.49344330e-02f, 2.47304868e-02f, 6.27890825e-02f, -3.82482703e-03f, 6.34688959e-02f, 1.19951919e-01f, -2.92922240e-02f, 6.03085570e-02f, -4.92740534e-02f,
  1.90196767e-01f, -2.33498663e-02f, 4.55944948e-02f, -4.54865880e-02f, -3.21904719e-02f, -1.91687066e-02f, -6.10549524e-02f, 2.63759419e-02f, 6.74419478e-03f, -1.27553595e-02f,
  -3.61189991e-02f, -4.53960374e-02f, 4.74274978e-02f, -9.12230536e-02f, -9.54306796e-02f, -1.05827615e-01f, -8.25416390e-03f, -7.43974745e-02f, -1.09350741e-01f, -1.37194127e-01f,
  3.67168598e-02f, 3.18860710e-02f, 6.46376088e-02f, 2.63722669e-02f, 2.21147835e-02f, 8.05474371e-02f, 5.01601882e-02f, 1.37518011e-02f, 7.22694099e-02f, 1.33636624e-01f,
  -2.74946600e-01f, 2.74001449e-01f, 2.03330085e-01f, -1.32302409e-02f, 9.00194347e-02f, 6.77425265e-02f, 6.66518733e-02f, -5.45920953e-02f, -1.96708277e-01f, 6.72546849e-02f,
  6.61988975e-03f, -1.62521914e-01f, -1.06999375e-01f, -2.03549843e-02f, -9.07736085e-03f, 1.01105198e-01f, 1.26571015e-01f, -6.80579022e-02f, -1.06111981e-01f, -5.76212332e-02f,
  9.46699269e-03f, -2.02415474e-02f, -1.59085333e-01f, -6.20365515e-02f, -9.84765962e-03f, -2.21256897e-01f, 6.38911724e-02f, 5.97313866e-02f, 4.70634922e-02f, 7.85047486e-02f,
  -1.23678623e-02f, 1.36273712e-01f, -1.07507035e-01f, -7.13776797e-02f, 4.30825502e-02f, -1.06853351e-01f, 3.03200297e-02f, 3.28122498e-03f, -6.66026622e-02f, 2.51766872e-02f,
  -8.39685649e-02f, -3.79915698e-03f, 1.25284093e-02f, 2.11979188e-02f, 1.85508355e-02f, -8.56840312e-02f, -3.53393927e-02f, -3.21459621e-02f, -3.06767062e-04f, 4.53217439e-02f,
  3.65326740e-02f, 1.60684790e-02f, 7.71000981e-03f, 4.22164015e-02f, 6.24502124e-03f, -1.27276868e-01f, 3.62276845e-02f, -6.39617667e-02f, -4.11544507e-03f, 8.40469822e-03f,
  -5.81763685e-03f, -2.14681923e-02f, -4.46083210e-02f, 2.38480121e-02f, -9.82428063e-03f, -5.05033880e-02f, -6.40999228e-02f, -1.54724903e-03f, -3.41090783e-02f, -7.09987134e-02f,
  -6.06011525e-02f, -5.56894913e-02f, 5.91652580e-02f, -1.30234301e-01f, -3.54455151e-02f, -9.91231855e-03f, -4.18416224e-02f, 2.73530651e-02f, -1.14082173e-01f, 1.87776668e-03f,
  -1.10895716e-01f, 6.62942976e-02f, -7.73567036e-02f, -2.29796637e-02f, 1.02053520e-04f, 2.65734140e-02f, -5.80848835e-04f, 2.13933382e-02f, -6.49554329e-03f, 2.37104930e-02f,
  -2.50923634e-01f, -2.67318264e-02f, -1.90912019e-02f, 1.34850135e-02f, -3.48152630e-02f, -3.33335437e-02f, -4.30261046e-02f, 2.24255752e-02f, 4.30579334e-02f, -7.16448426e-02f,
  1.11512050e-01f, -3.62692517e-03f, -6.12051226e-02f, -6.46307096e-02f, -3.93405296e-02f, 6.07696269e-03f, -3.92076373e-02f, -1.04537420e-01f, -2.85473303e-03f, -8.69250391e-03f,
  -6.38882965e-02f, -4.61613424e-02f, -1.84145063e-01f, -9.45434198e-02f, 1.83438584e-02f, -1.51695848e-01f, -5.94392382e-02f, -9.36768800e-02f, -1.39871746e-01f, -1.20000474e-01f,
  2.26590812e-01f, -1.18311234e-01f, -1.08809642e-01f, 2.29499951e-01f, 2.31648106e-02f, -9.67550278e-02f, -1.46987244e-01f, 2.95156352e-02f, 7.28118718e-02f, -9.18622911e-02f,
  -9.32100862e-02f, 1.11195363e-01f, 1.35074154e-01f, 8.17058459e-02f, 4.34253775e-02f, -5.37301116e-02f, 1.13037661e-01f, 1.56872556e-01f, 7.02692866e-02f, 3.51850055e-02f,
  1.66394636e-01f, 1.49508119e-01f, 1.97373375e-01f, 1.22174442e-01f, -1.24187162e-02f, 9.44888741e-02f, 2.41460260e-02f, 2.53213905e-02f, -6.60916492e-02f, 1.56587049e-01f,
  4.65782918e-03f, -7.66603723e-02f, -6.90033659e-02f, 1.12037271e-01f, -5.67586347e-02f, 6.38758987e-02f, -6.16778098e-02f, -2.47339513e-02f, 4.14197408e-02f, -3.53939272e-03f,
  -8.01218823e-02f, 3.16775553e-02f, 8.81292671e-03f, 3.05736922e-02f, -4.58266474e-02f, -5.73072247e-02f, 6.02349117e-02f, 7.01324716e-02f, 7.21767619e-02f, -1.17774397e-01f,
  8.05823952e-02f, -1.02487870e-01f, -7.35507011e-02f, -4.99770604e-02f, 1.67202614e-02f, -2.29269043e-02f, -1.58236116e-01f, -1.03639305e-01f, -6.90304339e-02f, -3.69529724e-02f,
  -2.90364306e-02f, 4.67134872e-03f, 5.31595573e-02f, -7.25236237e-02f, 1.91672891e-02f, -7.06538484e-02f, -6.31368998e-03f, -4.85421382e-02f, 6.73598051e-02f, -4.32327576e-02f,
  4.45114225e-02f, -6.60735965e-02f, -1.04731753e-01f, -7.74327517e-02f, -3.50767225e-02f, -1.20193399e-01f, -7.79217184e-02f, -6.46997839e-02f, -8.30771253e-02f, -3.61159667e-02f,
  4.14182842e-02f, -1.03084773e-01f, -9.40880477e-02f, -2.30084211e-02f, -7.20528839e-03f, -2.59596258e-02f, -4.42347750e-02f, -1.26587059e-02f, 3.04687079e-02f, -3.28604169e-02f,
  -7.69338235e-02f, -2.45613400e-02f, -2.11918857e-02f, 4.13459307e-03f, 1.64210871e-02f, -1.34401113e-01f, -2.00251956e-02f, -3.88385961e-03f, -1.36025518e-01f, -1.05108574e-01f,
  -8.80513787e-02f, -4.63224575e-02f, -6.99513629e-02f, 1.76847521e-02f, 2.48423759e-02f, 1.46415653e-02f, -7.15121999e-02f, 5.81843257e-02f, 3.79785784e-02f, -1.07615381e-01f,
  3.21946070e-02f, -1.12602338e-02f, -8.16028565e-03f, -1.62103996e-01f, -5.23540601e-02f, 4.95912693e-02f, -1.53007969e-01f, -9.22187231e-03f, -1.42628953e-01f, -7.55838528e-02f,
  1.42544001e-01f, 4.55548391e-02f, -6.27670735e-02f, -4.62649241e-02f, 1.85350813e-02f, -6.53504208e-02f, 6.75505996e-02f, 4.86601405e-02f, -6.93587661e-02f, -1.29653048e-02f,
  -9.73295122e-02f, -1.46976635e-01f, -3.90542150e-02f, -1.69222932e-02f, 1.73245966e-01f, 1.50219165e-02f, 2.29196206e-01f, 2.55477130e-01f, 1.82851151e-01f, 2.73620300e-02f,
  1.99226737e-02f, 2.22126096e-02f, 1.86713874e-01f, 1.70779750e-01f, -5.54126762e-02f, -9.60120186e-02f, -5.96317612e-02f, 2.61379462e-02f, 6.81129545e-02f, 1.84063151e-01f,
  -3.87232490e-02f, 1.96748897e-02f, 3.21874246e-02f, 1.49965093e-01f, -1.11274971e-02f, 1.03674859e-01f, -2.47874595e-02f, 7.41555616e-02f, -3.07752541e-03f, 2.08452754e-02f,
  -2.09104847e-02f, 9.79448408e-02f, 2.57967059e-02f, 4.82379161e-02f, -1.58075877e-02f, -2.23520994e-02f, 9.09434631e-02f, 7.26658180e-02f, -2.14561410e-02f, 8.80709067e-02f,
  9.46069062e-02f, 1.13082319e-01f, 1.56138511e-02f, 6.30694926e-02f, 9.75433886e-02f, -1.08022699e-02f, -1.44237969e-02f, -3.01006828e-02f, 6.90451562e-02f, -3.73000354e-02f,
  4.47385460e-02f, -1.01106286e-01f, -8.69309753e-02f, -1.01226903e-01f, -3.17339711e-02f, -7.79761150e-02f, -3.73148769e-02f, -3.11971456e-02f, -5.57914376e-02f, -8.44978541e-02f,
  -4.21715453e-02f, 5.05027547e-02f, 1.36060324e-02f, -5.78431524e-02f, -1.13523096e-01f, -4.95492890e-02f, -6.01833276e-02f, -4.96291481e-02f, -1.17938116e-01f, -1.35825858e-01f,
  -7.15616569e-02f, -1.90795735e-02f, -1.10708289e-01f, -3.47016975e-02f, -1.04460958e-02f, 5.42279966e-02f, 3.48801464e-02f, -3.97702008e-02f, -3.17797624e-02f, -2.56433357e-02f,
  -2.07711875e-01f, 1.02264270e-01f, 2.91079190e-03f, 7.70276338e-02f, 1.55549627e-02f, 3.76458801e-02f, 1.20849647e-01f, 2.81448420e-02f, 9.69581380e-02f, 4.27240804e-02f,
  1.25109861e-02f, 9.71536338e-02f, 3.11979726e-02f, 5.56462742e-02f, -2.82212980e-02f, -5.50072268e-02f, 3.21473405e-02f, 4.46611270e-02f, 1.00460708e-01f, -3.34634408e-02f,
  8.40691477e-02f, -1.05497325e-02f, -2.75222808e-02f, 4.60108370e-03f, 5.72862960e-02f, 2.33595259e-02f, -7.37412944e-02f, -6.12354837e-02f, -4.80378494e-02f, -1.13451801e-01f,
  2.12985367e-01f, 2.24071980e-01f, -6.98672459e-02f, 1.98507383e-01f, 4.45056446e-02f, -1.11201897e-01f, 5.03091142e-02f, 3.54033373e-02f, 4.25396673e-02f, 1.02919325e-01f,
  1.54900089e-01f, 5.17309308e-02f, -3.35779339e-02f, -1.19677529e-01f, -6.52274489e-03f, -1.82225462e-02f, 7.43848756e-02f, -7.81793669e-02f, -3.61850977e-01f, -2.24173561e-01f,
  -1.28795177e-01f, 1.07621960e-01f, 4.24064249e-02f, 1.04268761e-02f, 1.47650823e-01f, -1.16671793e-01f, 6.83419332e-02f, 1.99016720e-01f, 1.11172125e-02f, 6.19161353e-02f,
  -1.04094721e-01f, 1.08065933e-01f, -1.99480936e-01f, 1.08796865e-01f, -4.66916636e-02f, -1.07215550e-02f, 3.83046863e-04f, -1.03169642e-01f, 5.85499741e-02f, 3.58480364e-02f,
  1.70561343e-01f, -6.45973012e-02f, 5.02366200e-02f, -1.92807782e-02f, -5.15225604e-02f, -5.47100939e-02f, 2.28085406e-02f, -5.31830378e-02f, 4.01295125e-02f, -9.51598659e-02f,
  2.30394793e-03f, 1.59663260e-02f, 6.07175678e-02f, -7.26072863e-03f, 2.24030856e-02f, -1.15835518e-01f, 3.25005837e-02f, -2.79404093e-02f, -5.12972660e-02f, 6.57592388e-03f,
  -1.15127407e-01f, -3.96434218e-02f, 4.10261452e-02f, 8.08828920e-02f, 1.39865791e-02f, -3.26014757e-02f, 4.56825420e-02f, 7.00258389e-02f, -7.60947764e-02f, 6.30145147e-02f,
  -1.77037809e-02f, 5.53005524e-02f, -3.26430984e-02f, -2.88542826e-02f, 6.25340417e-02f, 5.04916273e-02f, -6.71880972e-03f, 1.09696381e-01f, 2.89051607e-02f, 6.06117882e-02f,
  5.14577404e-02f, 7.19243810e-02f, 8.69477317e-02f, -6.12134598e-02f, -5.37335081e-03f, -1.59782879e-02f, -6.12947308e-02f, 4.49767821e-02f, 3.55483927e-02f, 7.41142035e-02f,
  1.46641314e-01f, -1.06638663e-01f, -1.62036601e-03f, -1.42696053e-02f, -7.89677259e-03f, -5.75867528e-03f, -5.77487685e-02f, -5.56766987e-02f, -8.14306065e-02f, -2.44389214e-02f,
  1.86466761e-02f, 1.95771661e-02f, 4.86696139e-02f, -4.60847281e-02f, -8.58943611e-02f, -4.63938229e-02f, 8.66667107e-02f, 2.07884703e-02f, -1.20384153e-02f, -4.60041501e-02f,
  -1.87986065e-02f, -1.56990029e-02f, -1.05366737e-01f, -4.15012836e-02f, -1.22455336e-01f, -1.39351159e-01f, -4.07500863e-02f, -1.08533658e-01f, -7.21761212e-02f, -5.41574098e-02f,
  2.52424717e-01f, 8.02427903e-02f, 3.68201882e-01f, -5.73909667e-04f, -8.90705958e-02f, 1.38347134e-01f, 1.83575943e-01f, 1.88118860e-01f, -4.19848934e-02f, -4.34973091e-02f,
  -6.75553158e-02f, -1.16407886e-01f, -5.32427132e-02f, 8.78831372e-02f, 3.04553121e-01f, 1.80495143e-01f, 8.28908533e-02f, 3.43977004e-01f, 3.64411354e-01f, 1.82856411e-01f,
  -1.82192717e-02f, 1.29255921e-01f, 1.98765755e-01f, 7.64168650e-02f, 8.86831880e-02f, -2.07976867e-02f, 7.43551776e-02f, 6.14223927e-02f, 3.66203599e-02f, 6.67198300e-02f,
  2.90648431e-01f, 1.16757303e-01f, 9.91189033e-02f, -1.36667853e-02f, 7.50022680e-02f, 1.41496867e-01f, 1.45000696e-01f, 3.03012636e-02f, 1.21323675e-01f, 1.65442660e-01f,
  -5.96434518e-04f, 1.28795117e-01f, 1.25497123e-02f, 6.36311853e-03f, 1.18373856e-01f, 2.27664754e-01f, 1.09444812e-01f, 1.74071059e-01f, 1.19238771e-01f, 2.05321446e-01f,
  -8.40758532e-02f, -4.39622700e-02f, 1.71432719e-01f, 1.26573280e-01f, 1.02990165e-01f, 1.63533032e-01f, 1.64179936e-01f, 2.32321620e-01f, 1.26434132e-01f, 1.52657256e-01f,
  -7.48983771e-02f, -1.29476458e-01f, -4.52245213e-02f, 7.80675048e-03f, -1.15674637e-01f, -8.96836221e-02f, -5.39120883e-02f, -9.50641558e-02f, -1.36250991e-03f, -2.32858099e-02f,
  -8.72116312e-02f, -1.91721823e-02f, -1.17462382e-01f, -6.00740872e-02f, -1.09724566e-01f, -7.36455694e-02f, 2.27020811e-02f, -1.26618102e-01f, -2.66596419e-03f, -1.24727063e-01f,
  1.42498855e-02f, -1.13915265e-01f, -1.11583613e-01f, -2.91510820e-02f, -7.82348737e-02f, -1.34918289e-02f, -3.32732499e-02f, -5.41875837e-03f, -6.12051822e-02f, -1.03588097e-01f,
  9.24183503e-02f, 4.99585122e-02f, 9.06315297e-02f, 1.77900866e-01f, 3.18832956e-02f, 1.51020780e-01f, 7.53416643e-02f, 1.11015603e-01f, 5.22799753e-02f, 1.17129192e-01f,
  8.37440565e-02f, 1.53271005e-01f, 6.70250431e-02f, 8.02601203e-02f, 1.29927427e-01f, 5.94700351e-02f, 1.32768720e-01f, 1.31835252e-01f, 1.83658883e-01f, 1.64269939e-01f,
  9.46397930e-02f, 1.05215117e-01f, 1.01655431e-01f, 1.72448546e-01f, 1.45983413e-01f, 7.43087828e-02f, 2.48780757e-01f, 1.57524168e-01f, 2.11450621e-01f, 1.76614270e-01f,
  -7.57885724e-02f, -3.68339121e-02f, -9.55496877e-02f, -1.05933465e-01f, 2.22872004e-01f, 2.42944524e-01f, 1.63425073e-01f, 8.00634101e-02f, 2.05130130e-02f, 2.18156148e-02f,
  1.21251673e-01f, 1.96162149e-01f, 1.17308065e-01f, 1.32405847e-01f, 1.03620157e-01f, -9.80315283e-02f, -1.53635398e-01f, 3.58221345e-02f, 2.66615570e-01f, 1.50374025e-01f,
  1.38372704e-01f, -1.60968564e-02f, 2.52896398e-02f, 2.75621917e-02f, -3.85597795e-02f, 2.07372546e-01f, -7.43216127e-02f, -2.02349108e-02f, 7.52284303e-02f, -9.90084335e-02f,
  2.98995711e-02f, -7.47403204e-02f, 4.21534106e-02f, 5.00778966e-02f, 6.59850538e-02f, -6.70417324e-02f, 1.57722577e-01f, 2.95553561e-02f, 9.92961749e-02f, -3.53996754e-02f,
  5.65904826e-02f, 8.70421752e-02f, 4.00667086e-05f, 8.23197514e-02f, 6.34053424e-02f, 1.28467426e-01f, -4.70099859e-02f, -1.57762524e-02f, -7.81803355e-02f, -4.77988906e-02f,
  1.10277668e-01f, -4.24409360e-02f, 9.50543210e-02f, 2.54294351e-02f, 5.56722507e-02f, 2.10216120e-02f, -2.02723760e-02f, 1.27987579e-01f, 1.07795060e-01f, -5.63419051e-02f,
  -2.99665779e-02f, -9.83010605e-02f, -6.45718500e-02f, -3.20404172e-02f, 5.54599334e-03f, -1.92357786e-02f, 1.04087302e-02f, -9.15041566e-02f, -1.36842299e-02f, -6.49051219e-02f,
  3.98983993e-03f, -5.72624058e-02f, 9.07777399e-02f, -5.85162230e-02f, 5.08209467e-02f, 6.20291829e-02f, 1.88297369e-02f, -6.29681572e-02f, -2.52822060e-02f, -3.71554792e-02f,
  2.65452955e-02f, -1.04747480e-03f, -1.53204817e-02f, 6.86076060e-02f, -1.84004940e-02f, -3.32720242e-02f, -9.93896741e-03f, -1.34450942e-02f, -2.11672559e-02f, -2.71610543e-03f,
  8.52854773e-02f, 1.73996001e-01f, 3.19450721e-02f, 2.10703555e-02f, -2.68581994e-02f, 9.22899619e-02f, 1.27420202e-02f, 8.64851251e-02f, 2.55700983e-02f, -4.36028317e-02f,
  3.31919082e-02f, -3.42637324e-03f, 1.66615117e-02f, 1.82929635e-03f, 6.02783449e-02f, 1.33130513e-02f, 2.56016199e-02f, -3.45375529e-03f, 5.46218492e-02f, -1.99698731e-02f,
  1.56140595e-04f, 1.31898031e-01f, 5.09601049e-02f, 5.71856722e-02f, 1.25532210e-01f, 1.59449443e-01f, 1.34532362e-01f, 1.24785312e-01f, 1.98191777e-01f, 2.92051155e-02f,
  5.69091477e-02f, 6.48907796e-02f, 2.95403689e-01f, -7.21219704e-02f, -2.37674773e-01f, -2.77145449e-02f, 4.34839651e-02f, -2.70269848e-02f, 5.02285026e-02f, 1.45517707e-01f,
  -8.81625414e-02f, -1.38302013e-01f, -3.83877009e-02f, 2.81600300e-02f, -6.80724531e-03f, 2.08867818e-01f, 9.47823152e-02f, 1.16752684e-01f, 3.63747589e-03f, -3.51920500e-02f,
  -1.10708125e-01f, -1.59173587e-03f, 3.38886119e-02f, 8.07741508e-02f, 8.40106830e-02f, -1.13763891e-01f, 9.10189152e-02f, 2.69554444e-02f, -2.85656744e-04f, 1.24030359e-01f,
  1.98778927e-01f, 3.47171724e-02f, 8.05849433e-02f, 1.47825545e-02f, 8.17295313e-02f, 5.14853001e-02f, 6.37084097e-02f, 1.74868971e-01f, 1.54782971e-02f, 9.86990035e-02f,
  -3.17803547e-02f, 1.07169434e-01f, -4.84800115e-02f, 3.79721560e-02f, 9.64978188e-02f, 9.61003453e-03f, 1.67319313e-01f, 1.48484290e-01f, 1.81929752e-01f, 1.86496660e-01f,
  -5.48916943e-02f, 7.18151182e-02f, 9.23100188e-02f, 1.57962844e-01f, 1.38025880e-01f, -3.02175619e-02f, 6.78158775e-02f, 9.13833678e-02f, 1.83383033e-01f, 1.65324524e-01f,
  -2.27666069e-02f, -5.41292652e-02f, -8.90406594e-02f, 3.09354439e-02f, 6.95802178e-03f, -1.36072896e-02f, -6.01925030e-02f, -1.77022349e-02f, -1.36490330e-01f, -6.60076663e-02f,
  -4.59376946e-02f, 3.94219048e-02f, -6.27717599e-02f, -3.41253132e-02f, -1.17110327e-01f, -4.67657857e-02f, -6.14860430e-02f, -1.23490520e-01f, -3.51813883e-02f, -1.25006601e-01f,
  -2.38522235e-02f, -8.31225812e-02f, -1.04134209e-01f, -1.62540637e-02f, -1.25699833e-01f, -1.15483649e-01f, -1.87127829e-01f, -1.46665812e-01f, -6.29225820e-02f, -1.33053079e-01f,
  1.25550535e-02f, -1.35236615e-02f, -9.45970230e-03f, 6.26716614e-02f, 2.88914368e-02f, 1.20387204e-01f, 3.35433148e-02f, 1.18771560e-01f, 6.33940175e-02f, 1.20923370e-01f,
  8.00693687e-03f, 1.25916665e-02f, 6.19675554e-02f, 1.93432972e-01f, 3.49271782e-02f, 5.24494164e-02f, 1.69779733e-01f, 8.42520073e-02f, 1.06357768e-01f, 2.67690234e-02f,
  1.27034947e-01f, 7.25546852e-02f, 4.08717245e-02f, 3.38314213e-02f, 1.79595742e-02f, 2.99834274e-02f, 7.55063444e-02f, -8.44654161e-03f, 1.00953460e-01f, 1.59516543e-01f,
  1.36855349e-01f, -3.27340849e-02f, 2.47473925e-01f, 1.53607756e-01f, -6.52883798e-02f, -1.11576458e-02f, 1.23146594e-01f, -9.28299502e-03f, 1.83710512e-02f, -3.14512011e-03f,
  -8.27055648e-02f, -8.39927644e-02f, 7.12534189e-02f, 1.15860142e-01f, 1.02346271e-01f, 2.06902415e-01f, 2.41374314e-01f, 2.10467175e-01f, 1.02972150e-01f, -7.63387382e-02f,
  -4.40396331e-02f, 1.60547476e-02f, 2.34873369e-02f, 1.99686196e-02f, -9.14947987e-02f, -3.97904478e-02f, 7.36419410e-02f, -6.01692200e-02f, 1.54384105e-02f, 2.94441655e-02f,
  -1.19748581e-02f, 8.03795010e-02f, -1.21309785e-02f, -1.00745827e-01f, -8.70755762e-02f, -9.02127922e-02f, 1.16369557e-02f, -1.12128146e-01f, -5.24162613e-02f, -9.27758366e-02f,
  -5.37922084e-02f, -1.73036367e-01f, -1.00299291e-01f, -7.95727130e-03f, -3.72439176e-02f, 6.05330896e-03f, -1.92658827e-02f, 3.90705653e-02f, 2.16316506e-02f, 1.33946147e-02f,
  -3.60794477e-02f, 3.62170255e-03f, -3.75686027e-02f, 1.01896729e-02f, -1.41224921e-01f, -1.11659333e-01f, -1.50355875e-01f, -7.00143278e-02f, 6.04177341e-02f, -2.53212973e-02f,
  -5.91779687e-02f, 9.69137177e-02f, 6.19952269e-02f, 6.28154278e-02f, -3.48620117e-02f, -2.81459056e-02f, 4.11460996e-02f, -1.34780658e-02f, -7.71155534e-03f, 6.52749166e-02f,
  9.91715714e-02f, 6.33498728e-02f, 5.34821153e-02f, 1.01678677e-01f, 1.08030640e-01f, 7.82526433e-02f, 2.46623270e-02f, 1.48883477e-01f, -2.27694903e-02f, 1.09257944e-01f,
  2.08169818e-02f, -1.39567312e-02f, 9.47718248e-02f, 2.88000554e-02f, 1.68110177e-01f, 2.02097997e-01f, 6.72919080e-02f, 4.67488542e-02f, 4.44916338e-02f, 6.15067258e-02f,
  -8.49531442e-02f, 6.73291162e-02f, -1.04388200e-01f, -5.47190681e-02f, -4.94742580e-02f, -1.14508241e-01f, -7.18466565e-02f, 9.73481964e-03f, -1.76595092e-01f, -3.79590392e-02f,
  -9.01117176e-03f, -2.53635906e-02f, -9.21716020e-02f, -1.04326420e-01f, -4.88767512e-02f, -1.37867168e-01f, -1.04303874e-01f, -2.55280621e-02f, -1.87902041e-02f, -1.57413557e-01f,
  -3.20704393e-02f, -8.24387819e-02f, -1.32848099e-01f, -1.11662686e-01f, -5.77464923e-02f, -1.26716718e-01f, -1.58522204e-01f, -7.58572668e-02f, -7.80676231e-02f, -1.73164696e-01f,
  -1.91224545e-01f, 5.50241321e-02f, -1.02309741e-01f, -9.99626815e-02f, -1.66969821e-01f, -3.21911901e-01f, -2.37525448e-01f, -1.49373651e-01f, -7.03690872e-02f, -1.66324172e-02f,
  -1.55783266e-01f, -1.98836863e-01f, -1.27760306e-01f, -7.46395141e-02f, -1.11741245e-01f, -9.87689942e-02f, -9.53992233e-02f, -1.24496572e-01f, -2.19224453e-01f, -1.83200687e-01f,
  -2.00975955e-01f, -4.36871371e-04f, -2.89765820e-02f, -7.34485686e-02f, 2.82869693e-02f, -5.97091205e-02f, 3.72911543e-02f, -1.55104315e-02f, -5.51878475e-02f, 1.01251990e-01f,
  -1.42575830e-01f, -1.43190220e-01f, -2.89239764e-01f, -9.24986973e-02f, -2.02568620e-02f, -1.42401516e-01f, -1.25316247e-01f, -1.09710649e-01f, -4.22260351e-02f, -1.65096864e-01f,
  -1.28085181e-01f, -1.21255897e-01f, -1.86384737e-01f, -1.60673901e-01f, -1.05739474e-01f, -1.49960965e-01f, -1.93060711e-01f, -9.83515903e-02f, -1.96078420e-01f, -1.67871788e-01f,
  -1.77057981e-01f, -1.63937718e-01f, -1.16670586e-01f, -1.10391565e-01f, -2.31814027e-01f, -1.45103902e-01f, -1.75552979e-01f, -4.92682308e-02f, -9.34574902e-02f, 2.09688023e-02f,
  3.10390554e-02f, 1.23329125e-01f, 1.52152225e-01f, 1.27748698e-01f, 1.25141576e-01f, 1.78758383e-01f, 1.62506640e-01f, 1.03054315e-01f, 1.96159363e-01f, 2.07903236e-01f,
  1.67030305e-01f, 7.27381855e-02f, 2.12185815e-01f, 1.73169523e-01f, 2.14549258e-01f, 2.88073748e-01f, 1.82412058e-01f, 2.32213661e-01f, 2.39553183e-01f, 2.40477458e-01f,
  2.96875358e-01f, 1.69567361e-01f, 2.61317641e-01f, 2.43170381e-01f, 2.09757537e-01f, 1.89696237e-01f, 1.87522173e-01f, 1.22592777e-01f, 2.34629795e-01f, 1.40071660e-01f,
  -1.51876837e-01f, -3.38035285e-01f, -6.67579025e-02f, -1.89014629e-01f, -9.78258103e-02f, -1.24190323e-01f, -1.96552709e-01f, -7.72973597e-02f, -1.28499553e-01f, -9.94582698e-02f,
  -1.88406527e-01f, -1.79808959e-01f, -8.95338506e-02f, -8.61005262e-02f, -2.43673086e-01f, -2.23941252e-01f, -1.08904146e-01f, -2.19669431e-01f, -2.05418468e-01f, -1.97708055e-01f,
  -8.24521556e-02f, -2.47699052e-01f, -2.39411026e-01f, -2.70556808e-01f, -2.68176466e-01f, -2.88196027e-01f, -1.94762245e-01f, -2.36310646e-01f, -2.00946659e-01f, -2.30822176e-01f,
  -9.68036950e-02f, 5.42179588e-03f, 2.28102475e-01f, -1.59342661e-01f, -2.95997951e-02f, 1.70872182e-01f, 2.18102053e-01f, 1.70262344e-02f, -1.15939163e-01f, -6.35610670e-02f,
  -9.76498723e-02f, -1.53713107e-01f, -1.68206945e-01f, 3.25936750e-02f, 7.57512823e-02f, 5.64144775e-02f, 1.55595750e-01f, 1.57291532e-01f, 1.16775557e-01f, 1.00074314e-01f,
  -1.37294635e-01f, -8.11442286e-02f, 7.86246881e-02f, 7.30803013e-02f, -1.43365249e-01f, -2.29974426e-02f, 8.74002725e-02f, -4.48794775e-02f, 1.79927889e-02f, -1.16339095e-01f,
  -6.08092733e-02f, 9.63525549e-02f, 1.67216837e-01f, 1.09786920e-01f, 1.48844002e-02f, 1.42393976e-01f, 7.50723034e-02f, 5.98054752e-02f, 4.71717119e-02f, 1.10029072e-01f,
  1.20653734e-01f, 1.26210814e-02f, -2.14193147e-02f, 1.89072154e-02f, -4.86910925e-04f, 1.64584577e-01f, 3.08644045e-02f, 1.68752864e-01f, 1.60308629e-01f, 8.45349487e-03f,
  1.33608598e-02f, 7.89032057e-02f, 1.83928415e-01f, 1.80345401e-01f, 1.33964553e-01f, 1.13714449e-01f, 1.73770726e-01f, -2.31314432e-02f, 1.22696020e-01f, -2.80754287e-02f,
  3.46254706e-02f, -8.23371112e-02f, -3.30838375e-02f, 2.32181549e-02f, -1.08887307e-01f, 9.31429677e-03f, -5.57891987e-02f, -1.28802881e-02f, -1.99568942e-02f, -2.53799800e-02f,
  -4.56919596e-02f, 6.17101826e-02f, -7.45556056e-02f, 1.86776202e-02f, -1.13188654e-01f, -2.21011620e-02f, -8.67328141e-03f, -1.37678251e-01f, 2.00426159e-03f, 3.65566425e-02f,
  -2.59550307e-02f, 4.72781882e-02f, -5.20329475e-02f, -2.31426526e-02f, -6.31957278e-02f, 2.41952501e-02f, -7.45123327e-02f, -1.39054149e-01f, -1.19781189e-01f, -1.30262867e-01f,
  -7.99651220e-02f, 2.68363088e-01f, 9.13126022e-02f, 1.18048191e-01f, 9.86900181e-02f, 1.18082158e-01f, 3.06331199e-02f, 1.32028088e-01f, 3.17537412e-02f, 8.52960572e-02f,
  8.14601108e-02f, 1.12387389e-01f, 1.27822384e-01f, 1.65693536e-01f, 1.78144887e-01f, 1.25647187e-01f, 1.03845671e-01f, 3.03804148e-02f, 1.06754079e-01f, 2.24322379e-02f,
  9.99399796e-02f, 9.93321836e-02f, 1.07689850e-01f, 6.62965849e-02f, 8.19982439e-02f, 1.32324085e-01f, 8.83164331e-02f, 1.35638908e-01f, 1.19459018e-01f, 1.54051945e-01f,
  -4.54430521e-01f, -1.89347770e-02f, 1.06285438e-01f, -1.67424887e-01f, 1.52289376e-01f, 1.02666102e-01f, 3.38912338e-01f, 1.06462017e-01f, -5.09680100e-02f, -4.85866368e-02f,
  -1.62336558e-01f, -2.11934611e-01f, -1.45044103e-01f, -9.13699716e-02f, 8.25930536e-02f, 2.10219368e-01f, 1.64437294e-01f, -5.28174872e-03f, 4.83183190e-02f, -5.68855600e-03f,
  -2.81475000e-02f, -1.59233242e-01f, -1.89736381e-01f, -7.53263608e-02f, -1.41282335e-01f, 1.15667982e-02f, -1.02067426e-01f, -1.10597335e-01f, 1.32366359e-01f, 3.31495306e-03f,
  -1.87944546e-01f, -1.89978942e-01f, 5.30971289e-02f, 1.13999657e-02f, -7.12786987e-02f, -1.00760095e-01f, 6.07285611e-02f, -8.80479887e-02f, -1.60558552e-01f, -7.56033659e-02f,
  -6.12524413e-02f, -8.07344541e-02f, -9.64159593e-02f, -1.12153269e-01f, -8.08792561e-02f, -8.76066089e-02f, -1.34658784e-01f, -1.37477100e-01f, -1.57063603e-02f, -2.81427577e-02f,
  4.68990542e-02f, -2.22579017e-02f, -1.17295697e-01f, 1.17690405e-02f, -6.84292102e-03f, 1.30302934e-02f, -2.49601156e-02f, -6.75645788e-05f, -9.84832868e-02f, -6.94499835e-02f,
  1.34227559e-01f, 3.69419791e-02f, 7.05182552e-02f, -4.59920913e-02f, 9.75431595e-03f, -1.85924191e-02f, -1.17415795e-02f, 3.25592160e-02f, 1.09838814e-01f, -5.16579524e-02f,
  9.15966704e-02f, 7.19957426e-02f, -6.82544569e-03f, 2.07438506e-02f, -2.31659077e-02f, 1.88958384e-02f, 3.67613323e-02f, 3.52251306e-02f, -9.46635322e-04f, 7.58126006e-02f,
  -3.07021439e-02f, 4.53421474e-02f, -3.23349610e-02f, 1.73491519e-02f, 3.28086317e-02f, -2.62710615e-04f, 4.62268703e-02f, -5.04511110e-02f, -5.37845306e-02f, 5.85467927e-02f,
  -2.18167469e-01f, 1.76547766e-01f, -2.53447890e-02f, -6.50820211e-02f, -3.52507681e-02f, -5.03543317e-02f, -7.93603659e-02f, -5.80658801e-02f, -8.97953566e-03f, 1.90673973e-02f,
  -4.31846790e-02f, -7.95191005e-02f, -1.50421530e-01f, -3.47727574e-02f, -8.89017135e-02f, 2.08245851e-02f, -8.77101999e-03f, 2.21935962e-03f, -5.35655133e-02f, -3.77392471e-02f,
  -1.03918634e-01f, 7.28417262e-02f, -6.55756965e-02f, 2.11246293e-02f, -8.80345330e-02f, -3.22880372e-02f, 1.32666284e-03f, -1.24166764e-01f, 3.36289331e-02f, 4.89572734e-02f,
  -5.94376028e-02f, 8.87368172e-02f, 1.25880182e-01f, 1.11456968e-01f, 8.54308084e-02f, 1.19026266e-01f, 2.87773907e-01f, 6.41208068e-02f, 4.58488613e-03f, 3.64281498e-02f,
  -1.07246138e-01f, -1.20663993e-01f, -5.18007018e-03f, 3.32389772e-02f, 1.39632761e-01f, 7.31997117e-02f, 1.24775320e-01f, 1.34812057e-01f, 9.65424106e-02f, -4.97641116e-02f,
  1.66343506e-02f, -6.43912610e-03f, -4.32603024e-02f, 7.29049444e-02f, 1.15443533e-02f, -1.32925808e-01f, 8.99552330e-02f, 3.54554690e-02f, -6.48685694e-02f, 6.17709123e-02f,
  -1.20611005e-01f, 8.61872137e-02f, 1.20326452e-01f, 1.09353088e-01f, 7.07001314e-02f, 1.58284068e-01f, 1.40578553e-01f, 6.21798076e-02f, 1.53522894e-01f, 9.06941369e-02f,
  -3.99691872e-02f, 2.14584637e-02f, -1.42350644e-02f, 4.74826135e-02f, 3.72950844e-02f, 8.08039010e-02f, 1.15088075e-01f, 7.24817365e-02f, 1.26297116e-01f, 3.08713317e-03f,
  1.16721652e-01f, -3.68964151e-02f, 8.75357613e-02f, 1.57458126e-03f, 5.39872944e-02f, 7.52751306e-02f, 9.72732827e-02f, 6.75887242e-02f, 5.04851751e-02f, -7.13058785e-02f,
  -5.90066351e-02f, 7.93561935e-02f, 7.73217902e-02f, 1.29880607e-01f, 7.14685619e-02f, 6.11885935e-02f, -5.30684963e-02f, 4.90282550e-02f, 7.81999826e-02f, 1.61694121e-02f,
  -1.84375066e-02f, -3.01409643e-02f, -7.66744663e-04f, -8.12934060e-03f, -6.11751992e-03f, 9.38762128e-02f, -1.63288433e-02f, -3.02495416e-02f, -1.78521741e-02f, 1.13200463e-01f,
  -3.49712521e-02f, 1.27998441e-02f, -2.58004535e-02f, -7.50803575e-02f, -3.92136816e-03f, 7.60969799e-03f, 3.33727375e-02f, -6.69603050e-02f, 4.79921177e-02f, 8.45764205e-03f,
  -1.47986203e-01f, 7.83135891e-02f, -4.14315090e-02f, 3.32434773e-02f, 7.67933726e-02f, 8.14209580e-02f, 1.47453710e-01f, 1.25422984e-01f, 7.29273073e-03f, 7.80000612e-02f,
  -1.14695700e-02f, 2.86129378e-02f, 4.60664891e-02f, 7.18840659e-02f, 1.33242950e-01f, -9.61347204e-03f, 1.03918374e-01f, 3.28699052e-02f, 7.67789036e-03f, 3.61941047e-02f,
  9.47964862e-02f, 1.14031747e-01f, 8.89120549e-02f, 1.28832892e-01f, -2.94043366e-02f, -7.29727466e-03f, -4.11617085e-02f, 3.18068080e-02f, -8.13330710e-03f, 1.48716375e-01f,
  1.17061369e-01f, -1.33576542e-01f, 1.93306774e-01f, -9.06334743e-02f, -2.05815971e-01f, -6.16389588e-02f, -1.14519261e-01f, 1.55728549e-01f, -1.23655554e-02f, -9.64937881e-02f,
  -2.63071090e-01f, -9.83140022e-02f, -1.08291015e-01f, 3.07553280e-02f, 1.71419710e-01f, 1.41699091e-01f, 2.69076556e-01f, 3.31105739e-01f, 2.58651823e-01f, -1.60518810e-01f,
  -1.32011846e-01f, -3.37260440e-02f, 2.69543752e-03f, 1.30358249e-01f, -9.03180018e-02f, 5.19852601e-02f, 1.06699951e-01f, 4.14941758e-02f, -2.03347094e-02f, 2.10086301e-01f,
  -1.55636847e-01f, -1.37949109e-01f, -5.84669486e-02f, -4.29393463e-02f, -9.76708233e-02f, -1.90345589e-02f, -3.61785553e-02f, 3.05126365e-02f, -1.81211531e-02f, -5.01315342e-03f,
  -1.37079746e-01f, -5.50610386e-02f, 1.04940999e-02f, -1.25214001e-02f, 3.26144621e-02f, -4.51456383e-03f, 1.36094287e-01f, 1.75791189e-01f, 8.26164708e-02f, 1.81045420e-02f,
  -1.38260558e-01f, -1.07879266e-01f, -8.27628896e-02f, -7.74549916e-02f, 7.57031292e-02f, -4.18687100e-03f, 3.98586392e-02f, 3.17821652e-02f, 1.11352123e-01f, 1.70814633e-01f,
  -6.88916966e-02f, -5.12361787e-02f, 8.81438851e-02f, -1.28436862e-02f, 3.18511538e-02f, 3.27748284e-02f, 9.59211364e-02f, -8.34029168e-02f, 1.14645101e-02f, 3.67736667e-02f,
  -4.15654369e-02f, 3.25347902e-03f, 7.56037608e-02f, -7.38609657e-02f, -7.10345954e-02f, -6.11212328e-02f, 6.89131990e-02f, -4.94629319e-04f, -7.78543726e-02f, 3.46475095e-02f,
  5.48495948e-02f, 9.16039385e-03f, 5.54882400e-02f, 1.25115857e-01f, -6.32777065e-03f, 1.16882242e-01f, 1.18345376e-02f, -3.78289707e-02f, -6.92175105e-02f, -2.70592924e-02f,
  -4.98305373e-02f, -4.44630124e-02f, 3.00580850e-05f, 3.07976734e-02f, -4.35226299e-02f, 3.63396071e-02f, -6.68594092e-02f, 3.10008321e-02f, -1.32260621e-01f, 1.61819942e-02f,
  1.86035540e-02f, 1.17555084e-02f, -2.72842478e-02f, -3.66657563e-02f, -6.52348772e-02f, -2.27762256e-02f, -9.55777615e-02f, 5.50770424e-02f, 1.00530297e-01f, -4.35915627e-02f,
  -6.26863092e-02f, 4.63140570e-02f, 6.17968151e-03f, -3.41833662e-03f, 5.42553551e-02f, 7.00896457e-02f, 4.01677154e-02f, 6.14746474e-02f, 1.94504969e-02f, 3.26013826e-02f,
  1.68469891e-01f, -2.00030163e-01f, -2.47720808e-01f, 9.81469080e-02f, -1.09334834e-01f, -1.65133625e-01f, -2.68085927e-01f, -1.09428428e-01f, 9.08444151e-02f, -6.86650872e-02f,
  1.93953350e-01f, 2.43875340e-01f, 8.78424048e-02f, 1.20310038e-01f, -1.07357644e-01f, -2.73265928e-01f, -1.73078433e-01f, -3.45539488e-02f, -4.74427186e-04f, -1.07064754e-01f,
  2.35539302e-03f, 6.68775849e-03f, 5.45736067e-02f, -9.57680121e-02f, -1.55012757e-02f, -3.75563349e-03f, -9.28935036e-02f, -1.05831370e-01f, -8.61563832e-02f, -1.00056745e-01f,
  -4.04152367e-03f, 1.49562567e-01f, 4.95563336e-02f, 1.35858178e-01f, 4.75151353e-02f, -4.27629091e-02f, 9.20455996e-03f, -6.09191274e-03f, 4.95963134e-02f, -4.20723334e-02f,
  1.23241812e-01f, 7.86567405e-02f, 1.37200385e-01f, 1.47916274e-02f, 4.73838411e-02f, 4.14786600e-02f, 2.35600006e-02f, -2.52955873e-02f, -7.38708749e-02f, 9.23806354e-02f,
  1.09134592e-01f, 3.40791233e-02f, 5.52101582e-02f, -2.46948320e-02f, 9.30636004e-03f, 9.42266658e-02f, 6.43651327e-03f, 7.44343773e-02f, -1.05323372e-02f, 5.36175095e-04f,
  -1.51438564e-02f, -9.85289514e-02f, -8.75110477e-02f, -6.97183535e-02f, -2.22656950e-02f, 2.28999415e-03f, -9.31499824e-02f, -5.89126199e-02f, -4.16307822e-02f, -9.91606787e-02f,
  -8.56810585e-02f, -7.94480219e-02f, -8.87935385e-02f, -8.34218115e-02f, -6.92688152e-02f, -1.83607973e-02f, -2.89558042e-02f, -1.33622959e-01f, -6.64857551e-02f, -9.75199342e-02f,
  -7.25339875e-02f, -2.53842231e-02f, -2.49734893e-02f, -4.02350463e-02f, -5.78965656e-02f, -6.02283739e-02f, 1.18790073e-02f, -8.25750381e-02f, -5.31469062e-02f, -5.38390072e-04f,
  4.49449494e-02f, 1.16262764e-01f, -9.96211246e-02f, -6.07998036e-02f, -5.10668615e-03f, 2.38144826e-02f, -7.06046075e-02f, 4.51417267e-02f, 1.03614643e-01f, -4.25441265e-02f,
  -4.44347691e-03f, 1.57608669e-02f, -2.38797558e-03f, 7.63729840e-05f, -1.79947130e-02f, -2.48532202e-02f, -9.92872193e-02f, -2.76276674e-02f, 8.32224824e-03f, 2.56262161e-02f,
  -1.11879386e-01f, -9.11483541e-02f, -1.14378549e-01f, -2.20439993e-02f, -5.09157367e-02f, 9.11599919e-02f, -1.66960489e-02f, -1.18575543e-01f, -1.26635760e-01f, -2.36540943e-01f,
  -4.42510247e-02f, 2.33526215e-01f, 1.30701466e-02f, 1.98356375e-01f, 2.00245813e-01f, 5.62248118e-02f, 2.79602319e-01f, 5.64118102e-02f, 1.84452176e-01f, 2.28122041e-01f,
  4.28427495e-02f, 6.46261200e-02f, 1.22470528e-01f, 4.13936786e-02f, 1.31703336e-02f, 3.52797776e-01f, 2.93993890e-01f, 7.05415532e-02f, -1.58661436e-02f, -1.33743500e-02f,
  1.49343342e-01f, 2.56518453e-01f, -6.27167597e-02f, 1.04750313e-01f, 2.33616605e-01f, -3.48685160e-02f, 1.00518167e-01f, 6.97261989e-02f, -2.24957615e-02f, 1.50415897e-01f,
  1.31294131e-01f, -1.77727379e-02f, 1.51074812e-01f, 7.87798539e-02f, 2.12549865e-02f, 2.12954223e-01f, 1.91145927e-01f, 6.32888824e-02f, 1.57820404e-01f, 2.13458776e-01f,
  1.61187932e-01f, 1.63314521e-01f, 8.77605900e-02f, 1.42466649e-01f, 1.57117680e-01f, 1.02574818e-01f, 1.24859348e-01f, 5.82115948e-02f, -1.77972447e-02f, 9.31234658e-02f,
  7.40659311e-02f, 1.10287972e-01f, -6.14599064e-02f, -1.19144265e-02f, -6.66508302e-02f, 4.17165272e-02f, 4.62345518e-02f, -5.53042106e-02f, -6.09631427e-02f, 2.26577461e-01f,
  1.22891240e-01f, -1.37171790e-01f, -1.26643583e-01f, -1.29339650e-01f, -5.70848361e-02f, -6.68589547e-02f, -7.09197670e-02f, -8.32026452e-02f, -3.99717018e-02f, -8.43804926e-02f,
  -5.98046184e-02f, -7.25008696e-02f, -4.47610691e-02f, -4.61012907e-02f, -1.01069756e-01f, -6.07853346e-02f, -3.46514396e-02f, -4.54843938e-02f, -9.50860605e-02f, -1.57220602e-01f,
  -9.68845785e-02f, -5.88693805e-02f, -3.79132740e-02f, -3.07182912e-02f, -1.82264522e-01f, -1.60327628e-01f, -2.35488433e-02f, -1.58782735e-01f, -1.26144111e-01f, 2.54675886e-03f,
  2.04947487e-01f, -8.82187560e-02f, 1.56677976e-01f, 2.77243685e-02f, 1.39396966e-01f, 1.06079943e-01f, 1.40415475e-01f, 2.79907044e-02f, 1.46010190e-01f, 7.06906468e-02f,
  -5.23814792e-03f, 3.81611213e-02f, -2.03049323e-03f, 1.61340341e-01f, 1.19257428e-01f, 1.28435448e-01f, 1.89269975e-01f, 1.12947695e-01f, 6.31888807e-02f, 6.95122182e-02f,
  2.16549531e-01f, 1.09260127e-01f, 1.44562557e-01f, 2.01331168e-01f, 1.86938271e-02f, -7.96974730e-03f, 1.88316405e-01f, 8.98823738e-02f, 6.31599352e-02f, 2.98844308e-01f,
  -7.68394843e-02f, -8.13837573e-02f, -2.58992523e-01f, 8.61022398e-02f, 9.35531110e-02f, -1.99129581e-01f, -2.64131993e-01f, -5.10794967e-02f, -3.65948901e-02f, 5.61380293e-03f,
  1.22477621e-01f, 1.96408648e-02f, -1.08265802e-01f, -1.52198836e-01f, -2.67474353e-01f, -2.01310098e-01f, -2.54509717e-01f, -2.33591124e-01f, -2.49965936e-01f, -4.32875343e-02f,
  -7.27339461e-02f, 5.74716665e-02f, 3.69949937e-02f, -2.38404535e-02f, -3.35901417e-02f, -9.00526494e-02f, -1.02324478e-01f, -1.27302900e-01f, -6.79295277e-03f, -4.57779132e-02f,
  -2.93425024e-01f, -1.50785133e-01f, 8.15278012e-03f, 9.86110121e-02f, 8.61310214e-02f, -6.97147474e-02f, -4.09526266e-02f, -5.75875783e-05f, 4.20430712e-02f, 2.92754006e-02f,
  1.00249223e-01f, 7.96681568e-02f, -4.03843597e-02f, 8.47425982e-02f, -8.57982878e-03f, -5.45105077e-02f, -5.51977977e-02f, -7.44313225e-02f, -9.43712071e-02f, -2.64347158e-02f,
  3.70428860e-02f, 6.11713268e-02f, -2.16622446e-02f, -8.68013799e-02f, -1.44778743e-01f, -7.76537508e-02f, 2.55426373e-02f, -3.52193080e-02f, -3.45757380e-02f, -8.06939229e-02f,
  -9.76780709e-03f, 3.33025604e-02f, 2.24389918e-02f, 6.68276325e-02f, 1.03538493e-02f, 8.52360129e-02f, 6.83059394e-02f, 4.95189317e-02f, 3.05642076e-02f, 5.59772402e-02f,
  2.94711418e-03f, 7.29549527e-02f, 4.38953489e-02f, -6.53010383e-02f, 1.94593407e-02f, 8.25624764e-02f, -6.60605729e-04f, 4.54311483e-02f, 7.62667060e-02f, 2.73018945e-02f,
  2.86825877e-02f, 4.45642807e-02f, 3.47854048e-02f, -2.29486804e-02f, -4.81415689e-02f, -5.17159365e-02f, 1.60001870e-02f, 4.26732488e-02f, 3.93259861e-02f, 1.62788391e-01f,
  -1.02190696e-01f, 9.92803052e-02f, 2.70785368e-03f, -1.05269246e-01f, -4.98339720e-02f, 2.08060760e-02f, 4.84433211e-02f, -7.54563287e-02f, 5.19006327e-02f, -8.06631297e-02f,
  -6.61960840e-02f, -8.88555646e-02f, 2.97102872e-02f, -2.44650128e-03f, 1.12894112e-02f, -1.34506539e-01f, 9.02316999e-03f, -4.47982624e-02f, -2.93390695e-02f, 8.24045092e-02f,
  1.01415157e-01f, -1.07907519e-01f, -1.29050553e-01f, -6.03106320e-02f, 7.58016622e-03f, -3.01305614e-02f, -6.96711540e-02f, -1.34545803e-01f, -1.34926841e-01f, -1.26147792e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.74068487e-01f, -6.02203608e-02f, -3.70923392e-02f, 1.45123126e-02f, 1.14537261e-01f, 1.45671830e-01f, 1.16090417e-01f, -1.04324752e-02f, -9.72559862e-03f, 1.33487498e-02f,
  1.23496037e-02f, 2.22173408e-01f, 1.71475872e-01f, 2.19347343e-01f, 1.51637748e-01f, 2.57001847e-01f, 2.17062309e-01f, 1.24592803e-01f, 1.73915252e-02f, 9.68980491e-02f,
  7.10767359e-02f, -1.24126248e-01f, -5.43019995e-02f, 3.83685492e-02f, 9.32070091e-02f, 6.69770390e-02f, 1.39777958e-01f, 1.42619014e-01f, 2.02353448e-01f, 2.34563604e-01f,
  4.55556452e-01f, -4.42381054e-02f, 4.08345982e-02f, 1.29130650e-02f, -2.53950387e-01f, -1.58938929e-01f, -1.12052165e-01f, -8.50799754e-02f, -1.30062521e-01f, 8.53224173e-02f,
  -1.56992018e-01f, -2.26104289e-01f, -1.06087968e-01f, -7.26989880e-02f, -1.86043859e-01f, -1.18410394e-01f, -1.39888808e-01f, -2.75658164e-02f, 1.16974831e-01f, 1.42046303e-01f,
  8.41895863e-02f, 5.30668423e-02f, 1.30174637e-01f, -1.82703249e-02f, 1.24521181e-01f, 5.74156977e-02f, -8.56405199e-02f, -9.52219218e-02f, -3.81034939e-03f, -3.09957564e-02f,
  2.48811126e-01f, 7.97213167e-02f, 1.18840151e-01f, 1.41622588e-01f, -2.47223470e-02f, -7.54521713e-02f, 7.07193315e-02f, 5.60357496e-02f, 4.36581159e-03f, -8.60043317e-02f,
  -1.89551003e-02f, 1.06649324e-01f, -5.38512133e-02f, 7.45852813e-02f, 8.37882087e-02f, 8.85995328e-02f, 1.32252078e-03f, 7.06348717e-02f, 4.02246006e-02f, -8.25738534e-02f,
  -5.58242276e-02f, 2.91851722e-03f, -2.06507131e-01f, -1.73329562e-01f, -8.83333981e-02f, 5.88497482e-02f, 5.96797206e-02f, 6.34330958e-02f, -9.05098394e-02f, 3.34694907e-02f,
  2.32272252e-01f, 7.10354447e-02f, 1.65767655e-01f, 2.88040694e-02f, -8.07828680e-02f, -1.36649370e-01f, 6.86661974e-02f, 1.16690539e-01f, 4.05997895e-02f, 1.17571928e-01f,
  -7.27772042e-02f, -6.22478090e-02f, -5.80297336e-02f, -4.79268618e-02f, -1.21424511e-01f, -1.30343154e-01f, 3.53592634e-02f, 8.95717591e-02f, 1.16710976e-01f, 1.85915202e-01f,
  8.99252445e-02f, 4.69221547e-02f, 7.65587762e-02f, 1.85020659e-02f, 1.47864506e-01f, 1.06705502e-01f, 4.61603813e-02f, 2.00015549e-02f, 5.70675060e-02f, -1.34180441e-01f,
  -3.14866334e-01f, -4.94765610e-01f, 1.48402125e-01f, 2.20746651e-01f, 3.50522697e-01f, 2.91922450e-01f, 1.83243290e-01f, 3.54442596e-02f, 1.69913527e-02f, -3.96135412e-02f,
  -3.89486641e-01f, -2.79227197e-01f, -1.83054343e-01f, -1.79331467e-01f, -1.68200523e-01f, 2.41186216e-01f, 4.06463861e-01f, 1.47534937e-01f, 1.15148567e-01f, 7.93764591e-02f,
  3.60441618e-02f, 1.71409056e-01f, -9.42671373e-02f, -8.87108296e-02f, 7.32970685e-02f, 1.28605505e-02f, 8.13395828e-02f, 5.00183702e-02f, -3.75371575e-02f, -2.83243414e-02f,
  2.95937750e-02f, -7.90670589e-02f, 1.73475042e-01f, -1.99154377e-01f, -8.87753069e-02f, -1.59785151e-01f, -6.85284361e-02f, -1.02740631e-01f, -9.00151283e-02f, -7.74517134e-02f,
  -3.92886885e-02f, -1.22744575e-01f, 6.72661439e-02f, 3.22134756e-02f, -1.72050111e-02f, -8.23537856e-02f, -7.16142133e-02f, -1.63830191e-01f, -1.62366793e-01f, -1.77878574e-01f,
  -1.08796977e-01f, 3.84377316e-02f, -6.04422903e-03f, -6.76112249e-02f, -1.17175311e-01f, -2.08576005e-02f, -2.63038222e-02f, -1.43901601e-01f, -1.23308852e-01f, -8.62510130e-02f,
  1.48796989e-02f, 2.79176887e-02f, 2.53906753e-03f, -4.55401540e-02f, 1.23197392e-01f, 1.27501413e-01f, 1.90578640e-01f, 2.05102861e-02f, 6.76138029e-02f, 9.58411396e-02f,
  1.52978031e-02f, -1.28999548e-02f, -9.81276780e-02f, 2.30726749e-02f, -4.16900851e-02f, -1.17541023e-01f, -5.72181568e-02f, -1.74576268e-01f, -6.26859590e-02f, -4.01914455e-02f,
  -1.22246146e-02f, -4.65608202e-02f, -6.82225227e-02f, -1.03437737e-01f, -4.92668152e-02f, -1.49484813e-01f, 9.85944644e-03f, -1.57903299e-01f, -7.11485604e-03f, -3.65803689e-02f,
  1.43110782e-01f, 9.08601731e-02f, 2.48636290e-01f, -7.59217143e-02f, -7.57019073e-02f, -1.11011028e-01f, -7.50128785e-03f, -4.45090421e-02f, 9.59726125e-02f, 1.58937290e-01f,
  9.66964960e-02f, 5.80704659e-02f, 9.44297686e-02f, -7.24495500e-02f, 1.33259252e-01f, 6.06899597e-02f, -2.81597357e-02f, -1.01121739e-02f, 4.52020951e-02f, 2.89794747e-02f,
  5.01722097e-02f, 1.21621132e-01f, 6.47020265e-02f, 1.63221478e-01f, 1.07288294e-01f, 1.73909992e-01f, 1.07382707e-01f, 9.48550552e-02f, 8.48829523e-02f, 2.70313859e-01f,
  1.35163441e-01f, -2.95790911e-01f, 2.69926488e-01f, 1.35755897e-01f, 2.87857234e-01f, 2.82102138e-01f, 1.89617053e-01f, 1.53354153e-01f, 9.62835029e-02f, 8.06161240e-02f,
  -2.30729692e-02f, 9.64218602e-02f, 9.38606411e-02f, -1.15738772e-02f, 1.71104148e-02f, 5.57118617e-02f, 4.76559065e-02f, 1.56260952e-01f, 2.37930685e-01f, 3.45086455e-02f,
  -4.32597734e-02f, -2.57872976e-02f, -1.82484835e-01f, -1.43356428e-01f, -2.04709947e-01f, 1.39811590e-01f, -6.38403669e-02f, -1.07419543e-01f, -1.43802106e-01f, -2.84193605e-01f,
  1.41850919e-01f, -1.45859644e-01f, 1.00331806e-01f, -1.45414978e-01f, -1.71263784e-01f, -4.19181436e-02f, -1.23657566e-02f, -1.88799232e-01f, -6.25557303e-02f, -4.38792855e-02f,
  -1.86942816e-01f, -1.48857802e-01f, 7.48734875e-03f, -5.53799653e-03f, 4.78105526e-03f, -1.30347330e-02f, -1.84620336e-01f, -5.64568825e-02f, -3.38365650e-03f, -2.01138239e-02f,
  -1.64376512e-01f, -9.05633867e-02f, 1.95484962e-02f, 6.81539699e-02f, -2.83644833e-02f, 7.10522830e-02f, -6.59268349e-02f, -5.39337061e-02f, -7.68604726e-02f, -3.28564644e-02f,
  4.65182513e-02f, 9.08553898e-02f, -2.36681085e-02f, -1.61449499e-02f, 5.59380651e-02f, 9.18482393e-02f, -2.06881743e-02f, -3.55137847e-02f, 9.06269923e-02f, -1.10370424e-02f,
  -7.09130168e-02f, 7.11385459e-02f, 7.23967180e-02f, -2.94926986e-02f, 1.22643284e-01f, -4.41983156e-02f, 7.90244564e-02f, 2.37854570e-02f, -8.21445286e-02f, -5.66191338e-02f,
  1.06397554e-01f, 8.63017216e-02f, -5.53992093e-02f, -2.18082331e-02f, 1.83859076e-02f, 2.00355854e-02f, 7.88875446e-02f, 1.24520632e-02f, 7.00944336e-03f, 3.84130441e-02f,
  -4.08395715e-02f, 9.33898538e-02f, 3.70315425e-02f, -1.55038178e-01f, -1.28166422e-01f, -1.41527280e-01f, 1.04918689e-01f, -1.39021873e-02f, -1.87300723e-02f, 9.40632541e-03f,
  -5.70177985e-03f, -8.10547993e-02f, -6.54800460e-02f, 3.11452635e-02f, 1.41305715e-01f, 4.89168987e-02f, -1.73855443e-02f, 3.92858498e-02f, -2.99085062e-02f, 3.11614368e-02f,
  -4.75137308e-02f, 1.28665194e-01f, 1.59980342e-01f, 1.24415994e-01f, 1.30684510e-01f, 1.83860302e-01f, 1.39664426e-01f, 9.43211466e-02f, 1.96088076e-01f, 1.25256762e-01f,
  -3.51780295e-01f, -2.75528077e-02f, -1.81801721e-01f, 3.25489163e-01f, 1.97798520e-01f, 4.82715443e-02f, -1.56478323e-02f, 2.33065598e-02f, 6.79995120e-02f, 3.34467255e-02f,
  -5.36910221e-02f, 1.57238752e-01f, 6.14577048e-02f, 1.34810418e-01f, -2.55174991e-02f, 1.05363883e-01f, 2.23733917e-01f, 5.92310838e-02f, -7.90948123e-02f, 3.37049700e-02f,
  1.48843303e-01f, -3.90309817e-03f, -2.13863045e-01f, -9.98295471e-03f, 8.94408077e-02f, 1.60390079e-01f, -3.74142453e-02f, 9.71646607e-02f, 6.79270271e-03f, 2.86288440e-01f,
  -2.75516659e-01f, -1.19215108e-01f, 1.51801601e-01f, 5.33956394e-04f, -1.36788398e-01f, -1.31140262e-01f, -1.42917363e-02f, 5.44625521e-02f, -5.01353741e-02f, -3.65777873e-02f,
  3.14751007e-02f, -8.09118152e-02f, 1.62748411e-01f, 1.30703643e-01f, -4.22080010e-02f, -4.13575806e-02f, -1.35210648e-01f, -1.29443347e-01f, -1.17307499e-01f, -1.88649908e-01f,
  3.24669182e-01f, 1.40056357e-01f, -1.33795813e-01f, 3.34804282e-02f, -6.37576953e-02f, 5.65564297e-02f, -8.68573189e-02f, -4.94296364e-02f, -3.21712643e-01f, -1.86950505e-01f,
  1.02577560e-01f, -1.53815880e-01f, -7.59552345e-02f, -4.66734506e-02f, -8.31865764e-04f, -3.93204615e-02f, 1.09156646e-01f, 3.27694826e-02f, -1.07065421e-02f, -4.96907942e-02f,
  -6.88043311e-02f, -1.33355275e-01f, -8.64781216e-02f, -5.42121613e-03f, 5.96086085e-02f, -6.40673563e-02f, -2.84862164e-02f, -9.20621753e-02f, -1.11186966e-01f, -7.03515336e-02f,
  3.53175849e-02f, 1.53092323e-02f, -1.93397224e-01f, -1.65811423e-02f, 5.45694120e-03f, -1.96120944e-02f, 1.68294471e-04f, -1.55590789e-03f, 2.92549916e-02f, -1.04425540e-02f,
  -2.17023507e-01f, 4.71897982e-02f, 2.42616739e-02f, -2.90466025e-02f, -6.54298440e-02f, -7.98097178e-02f, -1.37384450e-02f, -4.59449589e-02f, -4.11212072e-02f, -3.39299962e-02f,
  -6.53158426e-02f, -2.33076699e-02f, 2.18271837e-02f, 1.18462496e-01f, -1.01706879e-02f, -5.35692181e-03f, -1.38511742e-03f, -1.39204320e-02f, -7.72339897e-03f, -5.79701290e-02f,
  1.20809488e-01f, 4.05529961e-02f, -1.19793408e-01f, -2.91542127e-03f, -1.65385138e-02f, 7.80542791e-02f, -1.32493094e-01f, -8.62723738e-02f, -3.20338696e-01f, -2.40571544e-01f,
  8.61779094e-01f, -2.57900923e-01f, -5.23983359e-01f, 6.33717626e-02f, -1.66074336e-01f, 1.98999420e-02f, 5.01873791e-02f, 2.01966539e-01f, 2.01089978e-01f, -7.61535466e-02f,
  -9.12315249e-02f, 4.35339995e-02f, -1.42830223e-01f, -1.60642222e-01f, 1.18483000e-01f, -3.16359103e-02f, -1.84272513e-01f, -1.82046238e-02f, 1.10557675e-01f, -3.95347830e-03f,
  -9.72974002e-02f, 9.39145386e-02f, 1.68858945e-01f, -1.16791293e-01f, -3.02595049e-01f, -1.04547173e-01f, -4.01328087e-01f, -1.97886139e-01f, -1.71557009e-01f, -4.76006001e-01f,
  -3.37403566e-01f, -2.64132977e-01f, 2.92569585e-02f, -1.05850492e-02f, -1.75165832e-02f, 7.80872256e-02f, 1.58288125e-02f, -7.35528469e-02f, 9.94416997e-02f, -1.42502207e-02f,
  -7.96599165e-02f, -3.98599021e-02f, 4.29857410e-02f, -4.15800661e-02f, 3.68895978e-02f, -5.22494735e-03f, -2.65400615e-02f, 1.98659878e-02f, -1.91518907e-02f, -2.25187857e-02f,
  6.42340339e-04f, 6.15029829e-03f, 3.29219401e-02f, -5.21413311e-02f, -1.46154314e-01f, -2.84811798e-02f, -2.08844438e-01f, -1.49352789e-01f, -1.02326587e-01f, -2.10191999e-02f,
  -1.15726352e-01f, 1.37218431e-01f, -1.59162879e-02f, 2.20349412e-02f, 2.06186473e-01f, 6.58598170e-02f, 7.31510445e-02f, 1.61077350e-01f, 6.36582598e-02f, 2.74581965e-02f,
  -1.31700886e-02f, 2.66122203e-02f, -4.24375869e-02f, 1.58822592e-02f, -5.82039282e-02f, -1.93998348e-02f, 5.36162779e-02f, -4.97836992e-02f, 2.45994814e-02f, 1.67182878e-01f,
  3.47594917e-02f, -1.76554099e-02f, -7.35467076e-02f, -7.58419037e-02f, -5.39096706e-02f, -2.37846142e-03f, -6.95013180e-02f, 2.77758995e-03f, 9.25853197e-03f, -5.82960732e-02f,
  1.65949911e-01f, 2.09887195e-02f, 9.57337022e-02f, -8.05490166e-02f, -1.22852605e-02f, -4.97675166e-02f, -9.92903337e-02f, -3.81490327e-02f, 5.33126146e-02f, -2.04341523e-02f,
  -4.38148938e-02f, 1.02304727e-01f, -2.91542038e-02f, -6.21800572e-02f, 1.09159738e-01f, 4.68099788e-02f, 2.30595795e-03f, 4.02004346e-02f, 6.75013661e-02f, -3.95612121e-02f,
  -1.29010184e-02f, 1.84464797e-01f, 2.69265354e-01f, 6.07317649e-02f, 2.66869110e-03f, 1.46113187e-01f, -2.56947335e-03f, 1.03612319e-01f, 1.01876505e-01f, 3.45565051e-01f,
  -1.28762320e-01f, -1.22750185e-01f, -1.40119269e-01f, -3.07134122e-01f, -1.52642623e-01f, -7.99609870e-02f, -8.75484645e-02f, -1.21466979e-01f, -1.45282552e-01f, -2.43364468e-01f,
  -1.26513913e-01f, 6.88608587e-02f, 1.17942125e-01f, 9.54663455e-02f, 1.61712617e-01f, -1.97265044e-01f, -1.62521005e-01f, 1.19317897e-01f, 2.08168149e-01f, 1.02086648e-01f,
  -5.04722372e-02f, -3.77519540e-02f, -4.66981567e-02f, -8.17698017e-02f, -2.50125021e-01f, -4.21763584e-02f, -2.86032110e-01f, -1.89332858e-01f, -7.25237355e-02f, -3.33770931e-01f,
  2.86538243e-01f, -1.78848773e-01f, 3.53972539e-02f, -1.03487857e-01f, -1.46669850e-01f, -6.53575128e-03f, -4.34448849e-03f, -3.98980156e-02f, -7.20221102e-02f, -1.16788313e-01f,
  -1.87217817e-02f, 4.43914533e-02f, 5.02652898e-02f, -3.33789513e-02f, -6.81443289e-02f, -7.57952183e-02f, -6.34510294e-02f, -3.63883711e-02f, -1.11732692e-01f, 2.95398291e-02f,
  9.67546552e-03f, -7.20058978e-02f, -2.31637098e-02f, -1.02431074e-01f, -8.12707990e-02f, -4.18049470e-03f, -2.60559935e-02f, -7.43173286e-02f, -1.31304070e-01f, -6.56046048e-02f,
  4.52116467e-02f, 8.80813412e-03f, -6.10427931e-02f, 2.40936596e-02f, -2.53334343e-02f, -4.06573638e-02f, -1.06242504e-02f, 4.96974178e-02f, 1.25399809e-02f, -3.06064915e-02f,
  -6.13030232e-02f, -1.39503017e-01f, -1.23931386e-01f, -2.92581990e-02f, -1.31389588e-01f, -1.14332706e-01f, -5.57647869e-02f, 2.44986080e-02f, 1.35477763e-02f, -8.78391340e-02f,
  2.79990342e-02f, -8.23969841e-02f, -9.61467922e-02f, -1.45846754e-01f, -9.24673453e-02f, -1.27859861e-01f, -9.66665596e-02f, 1.63345132e-02f, 1.30344322e-02f, -7.33591616e-02f,
  6.28272220e-02f, 1.98933601e-01f, 1.79111168e-01f, 5.66949584e-02f, -7.88379386e-02f, -1.48300543e-01f, 4.81427982e-02f, 3.56388912e-02f, -2.92625837e-02f, -5.32974228e-02f,
  6.30360395e-02f, 1.26574919e-01f, 7.78255910e-02f, 9.35846474e-03f, 5.91088086e-02f, -2.02257261e-02f, -2.87146792e-02f, 7.51802772e-02f, 7.73705635e-03f, 8.48128274e-03f,
  -4.41704914e-02f, 1.55217275e-02f, 2.48860851e-01f, 4.35866937e-02f, -2.73218621e-02f, 1.71578810e-01f, 9.68122184e-02f, 9.58641097e-02f, 2.25057825e-01f, 7.13388473e-02f,
  -3.80243570e-01f, 2.45541573e-01f, 4.97286797e-01f, -2.79505044e-01f, 1.03787765e-01f, 1.22146249e-01f, 1.78178966e-01f, -3.43617909e-02f, -1.46094307e-01f, 1.57422870e-01f,
  2.38888547e-01f, -1.87434360e-01f, -2.23516710e-02f, -2.29088198e-02f, -8.93613920e-02f, 2.21121550e-01f, 6.09341897e-02f, -5.99364266e-02f, -3.45158130e-01f, -3.11395854e-01f,
  -3.84648621e-01f, -2.92289615e-01f, -1.88229516e-01f, -2.41238475e-01f, -1.07693367e-01f, -1.43206939e-01f, 2.94953018e-01f, 1.20535798e-01f, 2.96610855e-02f, -5.71264625e-02f,
  1.50219887e-01f, 2.56189615e-01f, 2.03891415e-02f, -5.55403298e-03f, 2.11580675e-02f, -6.46651834e-02f, -5.79791628e-02f, 5.61544262e-02f, 7.59427845e-02f, 7.48336837e-02f,
  8.50339755e-02f, -3.40201929e-02f, 1.26701584e-02f, -1.44265741e-01f, -6.57933205e-02f, -9.98157486e-02f, -6.56176209e-02f, 1.01041549e-03f, -5.70826903e-02f, 1.29865050e-01f,
  -1.70459956e-01f, 3.22413892e-02f, 1.38860092e-01f, 2.27580279e-01f, 1.55058220e-01f, -2.81006813e-01f, 1.53876439e-01f, 1.62821934e-02f, 9.60521251e-02f, -2.77202070e-01f,
  -5.56424260e-02f, 8.30842555e-02f, 3.20812874e-02f, 9.30313841e-02f, -1.17199615e-01f, 1.32914990e-01f, 1.50796128e-02f, -4.98627052e-02f, 1.00646846e-01f, -8.02575722e-02f,
  -4.85364944e-02f, 1.88865904e-02f, -4.35017943e-02f, 9.58165377e-02f, -3.79405804e-02f, -4.12375294e-02f, -1.13745160e-01f, -7.22453818e-02f, -7.61542320e-02f, -9.30595119e-03f,
  6.51137717e-03f, -7.66100511e-02f, -3.07783484e-02f, -1.59277484e-01f, 1.06191687e-01f, -1.45776924e-02f, 1.23866173e-02f, -5.54507226e-02f, -1.80309955e-02f, 1.04657017e-01f,
  -1.19877592e-01f, 2.83128321e-01f, -1.27998441e-01f, -4.96662781e-02f, -4.40605395e-02f, -3.99440266e-02f, 7.99237341e-02f, 4.21488518e-03f, -1.86680276e-02f, -6.15506172e-02f,
  7.56145120e-02f, -5.37801944e-02f, 9.03759301e-02f, -2.45603368e-01f, -1.09727025e-01f, -5.24254469e-03f, -3.92391905e-02f, -1.42716572e-01f, 1.76885165e-02f, -1.28726855e-01f,
  -1.30744977e-02f, -2.01250792e-01f, -2.91445524e-01f, -9.52066854e-02f, -8.07342902e-02f, -2.60861129e-01f, -2.82822460e-01f, -2.43975297e-01f, -1.65767312e-01f, -4.07084972e-01f,
  5.28934419e-01f, 2.16021121e-01f, 5.39012887e-02f, 2.51932859e-01f, -2.57247865e-01f, -3.36119503e-01f, -2.15300366e-01f, -4.45766263e-02f, 3.01236391e-01f, 2.90062696e-01f,
  -1.31853804e-01f, -3.29330564e-01f, -2.79686525e-02f, -2.64337867e-01f, -1.63599581e-01f, 1.51978612e-01f, 1.56513397e-02f, -2.03160688e-01f, -5.00516713e-01f, -3.65691215e-01f,
  -2.45928586e-01f, -7.99540281e-02f, 3.62001136e-02f, -3.67346145e-02f, 1.73603237e-01f, -4.06751931e-02f, 2.28865802e-01f, 2.46029701e-02f, -6.07240833e-02f, 2.36116186e-01f,
  8.13974366e-02f, 2.45298311e-01f, -2.54938066e-01f, -1.21168062e-01f, -5.98810539e-02f, 3.19866948e-02f, -1.09002255e-01f, 1.50965706e-01f, 1.98714621e-02f, 1.18644349e-01f,
  -9.62291583e-02f, -1.24042317e-01f, 2.03657113e-02f, -5.77411279e-02f, -8.63612443e-02f, -1.74611509e-01f, 7.48947188e-02f, 8.59269351e-02f, 6.56734109e-02f, 1.02464199e-01f,
  -1.87798992e-01f, -1.01487324e-01f, -1.36980981e-01f, -1.32126838e-01f, 7.22607598e-02f, -1.13092870e-01f, 2.12750323e-02f, 2.88099628e-02f, -1.83812246e-01f, 2.70968407e-01f,
  8.98640454e-02f, -1.98415690e-03f, -1.25207767e-01f, 5.89349829e-02f, 4.86139432e-02f, 8.14300328e-02f, 1.62182748e-02f, -3.90277617e-02f, 3.62927001e-03f, 4.69116047e-02f,
  1.26788486e-02f, 1.52915139e-02f, -5.46910651e-02f, 6.22570291e-02f, 4.99022081e-02f, -1.47244493e-02f, -6.47116303e-02f, 1.48544125e-02f, 6.18189014e-03f, -3.20706554e-02f,
  -1.53446034e-01f, -6.42765686e-02f, -3.71554494e-02f, 5.36148809e-02f, -4.17598039e-02f, 1.74140949e-02f, -1.35520780e-02f, -1.46350995e-01f, 1.11651793e-01f, 6.89409208e-04f,
  5.70552722e-02f, -4.30563629e-01f, 2.34472170e-01f, 1.10948896e-02f, -6.12851344e-02f, -2.97106747e-02f, 1.45902500e-01f, -5.40107340e-02f, 1.06323436e-01f, 6.26519322e-02f,
  -1.73612505e-01f, 5.18765450e-02f, 1.23538196e-01f, 2.68988274e-02f, -1.36400774e-01f, -4.65443060e-02f, 2.84515489e-02f, -9.47351456e-02f, -1.11416757e-01f, 2.00723074e-02f,
  1.82977185e-01f, -1.37668848e-01f, -3.19865532e-02f, -2.21444406e-02f, 2.48585623e-02f, -2.42895022e-01f, -1.10926092e-01f, -1.13479033e-01f, -1.11382306e-01f, 2.75021523e-01f,
  -3.07026893e-01f, -2.35652607e-02f, -7.82836750e-02f, 2.64813304e-01f, 8.45906287e-02f, -4.52468172e-03f, -1.46567225e-02f, 5.95382601e-02f, 1.46485105e-01f, 9.73354951e-02f,
  4.32794318e-02f, 1.05266355e-01f, 2.20277905e-01f, 1.80970341e-01f, 6.41425923e-02f, 2.17899650e-01f, 2.63363957e-01f, 1.62217408e-01f, 2.55465973e-02f, 6.08317815e-02f,
  1.12039551e-01f, 4.78146896e-02f, 2.35370919e-02f, -5.12244296e-04f, 1.64759576e-01f, 2.63244957e-01f, 1.54568017e-01f, 8.51208419e-02f, 2.14043006e-01f, 3.85454357e-01f,
  4.87576611e-03f, -1.37008145e-01f, 1.37892216e-01f, 3.65307182e-02f, -1.16271660e-01f, -3.63153294e-02f, -9.19143036e-02f, -7.47506246e-02f, -4.74174283e-02f, -2.76306532e-02f,
  2.52900459e-02f, -1.05289752e-02f, -2.24544178e-03f, -1.13277733e-01f, -1.19095348e-01f, -1.50084794e-01f, -1.06178775e-01f, 5.06376848e-02f, 1.66324586e-01f, 9.59946122e-03f,
  8.16504508e-02f, -3.77465934e-02f, -4.00369540e-02f, -9.24025849e-02f, 7.00004324e-02f, 9.23391283e-02f, -7.11686239e-02f, -7.44724199e-02f, -1.02490447e-01f, -1.21289417e-01f,
  4.08762917e-02f, -8.57900083e-03f, 7.89427664e-03f, -7.42550299e-04f, -9.76023450e-02f, -6.34831786e-02f, -5.27039468e-02f, -3.04416418e-02f, 3.21120657e-02f, -1.62670806e-01f,
  -1.75027847e-02f, 8.08770508e-02f, 6.07299693e-02f, 1.03122871e-02f, 3.43364514e-02f, 2.33471803e-02f, -6.83453977e-02f, -1.16601385e-01f, -1.46137372e-01f, -2.97397152e-02f,
  -1.00200973e-01f, 2.57636942e-02f, -5.04646190e-02f, 4.45308685e-02f, 1.03680440e-03f, -3.33905555e-02f, 2.92110536e-03f, -8.92618820e-02f, -5.85035346e-02f, -2.31324546e-02f,
  2.32596144e-01f, -6.66945102e-03f, 1.48096666e-01f, 9.99024734e-02f, 4.77469899e-02f, -1.81759037e-02f, 1.27210855e-01f, 5.61515950e-02f, 3.19944248e-02f, 8.55076164e-02f,
  4.33971686e-03f, -1.09542057e-01f, -1.10591292e-01f, -7.57043734e-02f, -1.41909376e-01f, -1.64783418e-01f, -6.86730146e-02f, 1.46424279e-01f, 1.55387893e-01f, -1.27149634e-02f,
  -7.61951879e-02f, -1.02244556e-01f, -9.91399959e-03f, -1.15907982e-01f, -5.29523790e-02f, 1.27265695e-02f, -1.43291786e-01f, -1.89661197e-02f, -1.22373968e-01f, -1.45668700e-01f,
  6.25684738e-01f, -9.85570773e-02f, 2.02962130e-01f, 9.18631479e-02f, 1.93985701e-01f, 2.71244407e-01f, 1.94239363e-01f, 9.59630907e-02f, 1.83898002e-01f, 2.57649515e-02f,
  -1.29719436e-01f, -5.84009551e-02f, -3.35826948e-02f, -8.57788175e-02f, -9.04907659e-02f, 2.51094252e-02f, 1.14403583e-01f, 1.69084191e-01f, 1.28612980e-01f, 2.16019507e-02f,
  -1.07337348e-01f, -7.81229362e-02f, -2.59178765e-02f, 3.80703844e-02f, -6.03562370e-02f, -7.89363608e-02f, -1.41276708e-02f, 3.66037572e-03f, -1.02734104e-01f, -1.33829579e-01f,
  -1.14741966e-01f, -2.95383446e-02f, 6.36972412e-02f, -1.59198374e-01f, 2.73937173e-02f, -1.29193731e-03f, 4.59212363e-02f, 9.21069528e-04f, 8.88888687e-02f, 9.65948030e-02f,
  -1.28675336e-02f, -1.05639569e-01f, -1.39932096e-01f, -2.50047427e-02f, -1.22010643e-02f, -5.97162768e-02f, -1.40584365e-01f, -7.01143667e-02f, -8.87786373e-02f, -2.17677746e-02f,
  -1.76565558e-01f, -3.08975540e-02f, 6.66148076e-03f, -2.80624442e-02f, -8.96435902e-02f, 6.68061376e-02f, 6.71992749e-02f, -5.71362115e-02f, 7.94414729e-02f, 7.44238123e-02f,
  3.41534801e-02f, 7.79873356e-02f, -9.48670879e-02f, -8.22648481e-02f, -1.22421876e-01f, -2.15835357e-03f, 1.33887818e-02f, -4.47662780e-03f, -1.45340420e-03f, -1.30957186e-01f,
  -1.37642816e-01f, -4.16948758e-02f, -1.77388322e-02f, -8.50011781e-02f, -1.95199534e-01f, -9.16298479e-02f, 1.99589189e-02f, -1.14816338e-01f, -1.52353466e-01f, -1.56742349e-01f,
  -5.69265112e-02f, 3.71909142e-02f, -8.90108719e-02f, -9.23489034e-02f, -1.83470920e-01f, -6.61837906e-02f, -9.57940798e-03f, -8.09305161e-02f, -6.32044300e-02f, -7.26480857e-02f,
  -3.86071593e-01f, -2.89049685e-01f, -1.73649296e-01f, -1.22008912e-01f, 6.42321408e-02f, -6.62308559e-02f, -5.82423992e-02f, -6.18272536e-02f, 9.67879295e-02f, 1.93938725e-02f,
  -2.39132531e-02f, 6.15782887e-02f, -1.96289629e-01f, -1.49039939e-01f, 1.65031314e-01f, 6.27248809e-02f, -1.16823845e-01f, 1.03519775e-01f, -2.12455168e-02f, -1.29976287e-01f,
  -8.39697793e-02f, 1.75066352e-01f, 9.52388644e-02f, 4.69733737e-02f, -1.24754133e-02f, 9.04990360e-03f, 4.49478254e-02f, 8.87768343e-02f, 1.09804668e-01f, 1.24420136e-01f,
  5.47202289e-01f, -6.68359101e-02f, 2.18929704e-02f, 2.26217225e-01f, -3.83694582e-02f, -1.29801884e-01f, -1.59143850e-01f, 6.12488165e-02f, 6.00238368e-02f, 1.02751382e-01f,
  4.21661623e-02f, 2.48389274e-01f, 2.57582664e-01f, 2.13398322e-01f, 1.34497181e-01f, -6.80621564e-02f, 1.09088542e-02f, 2.36165687e-01f, 9.59869102e-02f, -5.14704883e-02f,
  -4.41044271e-02f, -1.23792350e-01f, -9.22115333e-03f, 6.94771409e-02f, -1.16193451e-01f, 1.90739916e-03f, -9.99480784e-02f, -1.14957526e-01f, -9.83455628e-02f, -8.13454837e-02f,
  -8.17344412e-02f, -5.30878839e-04f, 2.59821892e-01f, 1.16327792e-01f, -6.79060295e-02f, 1.26498848e-01f, 1.01448866e-02f, 1.17152408e-02f, -7.22591579e-02f, 7.32119381e-02f,
  7.15349242e-02f, -7.72249028e-02f, 3.45255286e-02f, -1.32397294e-01f, -1.34301990e-01f, -6.51999423e-03f, -4.62969095e-02f, 2.60381009e-02f, 1.06724463e-01f, 2.17032786e-02f,
  -6.49934188e-02f, -1.90333966e-02f, -1.18994052e-02f, 7.85139129e-02f, 3.30327302e-02f, 2.72092596e-02f, -4.10936438e-02f, -1.70497429e-02f, -1.36228865e-02f, 6.08663373e-02f,
  1.29572734e-01f, 4.47183140e-02f, -3.62350978e-02f, 2.87952274e-02f, 4.32310253e-02f, 6.19442128e-02f, 2.27338378e-03f, 1.04958691e-01f, 2.45840326e-02f, -1.17149860e-01f,
  -1.30091645e-02f, 1.05018809e-01f, 1.63068697e-02f, 2.70123966e-02f, 1.57571629e-01f, -3.73739414e-02f, -4.38664854e-02f, -1.75554715e-02f, 5.72180599e-02f, -7.69351125e-02f,
  -5.64893819e-02f, 7.40957074e-03f, -3.04211080e-02f, -7.67575353e-02f, -1.27059966e-01f, 9.51985866e-02f, 1.03360020e-01f, -3.86677380e-03f, -7.32978135e-02f, -4.32708003e-02f,
  -2.50761211e-01f, 2.61228651e-01f, 8.03649500e-02f, -6.94801053e-03f, -1.95020568e-02f, -4.01310669e-03f, 1.06968721e-02f, -1.14704696e-02f, 2.24409695e-03f, 1.47769488e-02f,
  -2.89224759e-02f, 2.82769352e-02f, -8.17579105e-02f, -1.57469004e-01f, -1.85872391e-02f, -7.05485116e-04f, -1.12357795e-01f, 3.73721793e-02f, -2.56977342e-02f, -9.05496180e-02f,
  -1.60419289e-02f, 1.38366342e-01f, 7.88240880e-02f, 1.58651739e-01f, 4.46238853e-02f, 1.99048415e-01f, -9.49638709e-03f, 2.72512455e-02f, 2.41235029e-02f, -3.37756388e-02f,
  -8.82101059e-01f, -9.59153697e-02f, 1.00756399e-01f, -3.11732799e-01f, -1.70729131e-01f, 1.63076937e-01f, 1.57661557e-01f, -1.73416525e-01f, -1.73004478e-01f, -2.69527491e-02f,
  7.90362656e-02f, -9.21669230e-02f, -7.47410282e-02f, -3.01735047e-02f, -4.23278920e-02f, 1.03776649e-01f, 6.21395484e-02f, -1.18662335e-01f, -8.92975703e-02f, -6.35702014e-02f,
  -1.40205532e-01f, -1.80502206e-01f, -3.35852593e-01f, -2.80240476e-01f, -4.02596295e-02f, -1.30381495e-01f, -6.60323575e-02f, -5.19590452e-02f, 5.65784909e-02f, -9.36747715e-02f,
  5.24082184e-01f, -6.06796183e-02f, -1.28919765e-01f, -1.57656729e-01f, 5.25109023e-02f, -9.17779952e-02f, 2.88770273e-02f, -4.48837876e-02f, 2.59743948e-02f, 8.17224458e-02f,
  5.16228043e-02f, 3.42739113e-02f, -3.07777878e-02f, 1.01075433e-01f, 3.10441386e-02f, 7.68284500e-02f, 9.01170168e-03f, -1.35674207e-02f, 1.52868211e-01f, 5.20316027e-02f,
  1.21526547e-01f, 6.72124401e-02f, 2.64232129e-01f, 2.04717606e-01f, 6.94807842e-02f, 5.07050939e-02f, 2.16710046e-01f, 7.03552291e-02f, 3.64360251e-02f, 9.73779559e-02f,
  -7.13155270e-02f, -1.53995857e-01f, 4.97924015e-02f, 2.72378661e-02f, 1.19596049e-01f, 2.47549545e-02f, 1.11320838e-01f, 1.22004397e-01f, 3.94769339e-03f, -2.70944815e-02f,
  1.01735760e-02f, 1.17230102e-01f, 7.27479532e-02f, -2.53484701e-03f, -7.63336942e-02f, -6.12494396e-03f, -4.42453939e-03f, 1.03209399e-01f, 1.09964140e-01f, -6.18316419e-02f,
  -8.31255019e-02f, -4.01236974e-02f, -1.40378818e-01f, 8.45465437e-02f, -1.00830533e-02f, 7.59737566e-02f, 1.07641771e-01f, 6.09302595e-02f, -1.39502257e-01f, -1.36524960e-01f,
  3.72574955e-01f, 5.08786216e-02f, -4.51502241e-02f, -1.50031760e-01f, -1.04632668e-01f, -9.17743966e-02f, -1.16470471e-01f, -2.36007981e-02f, 8.85257944e-02f, 1.41665891e-01f,
  9.99332294e-02f, -9.09007043e-02f, 1.16404623e-01f, -2.25695297e-02f, 8.79967660e-02f, -1.23497806e-02f, -1.10577315e-01f, 7.80732036e-02f, -1.27734533e-02f, 1.47378549e-01f,
  -6.54530451e-02f, 6.58071414e-02f, 2.09811136e-01f, 1.02761947e-01f, -7.90376589e-02f, 4.76913080e-02f, 1.73583955e-01f, 1.59969896e-01f, 1.18541270e-01f, -1.74805373e-02f,
  1.14235640e-01f, 4.38165843e-01f, 2.59434700e-01f, -1.04417495e-01f, 2.28430465e-01f, 2.34787256e-01f, 5.23667514e-01f, 2.12328672e-01f, -4.53017130e-02f, 1.87218651e-01f,
  2.17613682e-01f, -2.09653363e-01f, -6.11087494e-02f, -1.95943505e-01f, -3.57648768e-02f, 1.79282531e-01f, -6.02815971e-02f, -1.57133669e-01f, -1.33976743e-01f, -1.10236049e-01f,
  -1.77645266e-01f, 2.20510159e-02f, 8.91076401e-03f, -1.06540859e-01f, -8.93193781e-02f, -2.87174046e-01f, 7.72793740e-02f, 1.17311805e-01f, 2.78520808e-02f, -3.41466367e-01f,
  4.58347565e-03f, 2.59410381e-01f, -2.22475857e-01f, -3.58946137e-02f, 1.90017849e-01f, -5.48914224e-02f, -2.68610823e-03f, 6.69937283e-02f, 1.26044840e-01f, -3.90565358e-02f,
  7.23052546e-02f, 1.07189476e-01f, 2.16315746e-01f, 3.60272862e-02f, 8.75504091e-02f, 1.84985429e-01f, 9.46895406e-02f, -3.46766599e-02f, -7.72610977e-02f, -8.27827305e-03f,
  -3.76014225e-02f, 2.33063951e-01f, 1.80384785e-01f, 4.04761657e-02f, 4.81511764e-02f, -9.44105685e-02f, 2.01933041e-01f, -3.45235295e-03f, -2.26737503e-02f, -2.02621982e-01f,
  4.06397097e-02f, 2.97216214e-02f, 1.21314935e-01f, -2.46479847e-02f, -7.86499605e-02f, -1.34606585e-02f, -1.02632485e-01f, -1.02755735e-02f, -7.65467659e-02f, 4.48133156e-04f,
  5.05541600e-02f, 3.59299742e-02f, -6.53039441e-02f, 1.55781340e-02f, -3.99810076e-02f, 9.30990651e-02f, 7.69963190e-02f, 1.87113956e-02f, 9.93603244e-02f, 5.24764135e-02f,
  -7.06879422e-02f, -1.06253447e-02f, 3.92884202e-02f, -6.21885173e-02f, 6.06697425e-02f, -4.32193279e-02f, -1.31409869e-01f, 4.22750078e-02f, -4.26060408e-02f, -6.31366298e-02f,
  9.20625683e-03f, 1.80903494e-01f, -3.37481230e-01f, -1.72264576e-01f, 7.00789392e-02f, 1.23036742e-01f, -1.19570784e-01f, -1.17421292e-01f, 8.27415437e-02f, -1.45407245e-01f,
  4.50063981e-02f, -1.39116412e-02f, 3.15948315e-02f, 7.04687387e-02f, -1.38443604e-01f, -1.01106331e-01f, 4.50064130e-02f, -1.65140331e-01f, -4.05098386e-02f, 5.53981215e-02f,
  -4.87273894e-02f, 1.50057953e-02f, -1.57589704e-01f, -1.71920925e-01f, -2.88884670e-01f, -2.97569513e-01f, 2.99421623e-02f, -1.18412502e-01f, 3.33698876e-02f, -7.55921230e-02f,
  -6.60522282e-01f, -1.88377917e-01f, 1.95751756e-01f, -4.17735606e-01f, -6.30512983e-02f, 1.22004822e-01f, 9.72438511e-03f, -1.29629210e-01f, -2.60832787e-01f, -1.00784756e-01f,
  8.89556389e-03f, -7.54988054e-04f, -1.53980687e-01f, -1.30791971e-02f, 1.35686070e-01f, -1.17843017e-01f, -7.21383318e-02f, 1.20497748e-01f, 3.22897524e-01f, 1.44847661e-01f,
  -1.73920989e-02f, -1.27902582e-01f, 8.65581408e-02f, 1.20560311e-01f, -2.84850240e-01f, -1.39632104e-02f, -1.37997894e-02f, -1.22931935e-01f, 5.99576766e-03f, -2.39665389e-01f,
  -2.47893721e-01f, -2.10608333e-01f, 3.26176435e-01f, -7.60812387e-02f, 1.79570597e-02f, -2.94790212e-02f, 6.13675229e-02f, 1.01740278e-01f, 1.36112003e-02f, 4.46092971e-02f,
  -1.91778764e-01f, 1.13026567e-01f, -2.22923860e-01f, -4.23277691e-02f, -5.63814119e-03f, -1.87741462e-02f, -2.13381201e-02f, 1.24273986e-01f, 4.46327254e-02f, -6.26594620e-03f,
  -1.24880582e-01f, -9.66817141e-02f, -2.35150665e-01f, 3.77624366e-03f, 3.44270170e-02f, 9.70072672e-02f, 4.04263139e-02f, -8.16006493e-03f, 1.29897967e-01f, -1.95483044e-01f,
  5.51834293e-02f, 1.17921755e-01f, 3.76625247e-02f, 3.52078676e-02f, -2.81079784e-02f, 3.37248035e-02f, -4.37634625e-02f, -5.17031886e-02f, 9.91712213e-02f, -1.75362140e-01f,
  9.26233977e-02f, 1.59974117e-02f, 1.15630783e-01f, 1.25105428e-02f, 5.20404689e-02f, -4.35742363e-02f, -1.11178011e-01f, 6.75930902e-02f, 2.10466571e-02f, 4.21610400e-02f,
  -2.30339710e-02f, 3.37939057e-03f, -1.23966429e-02f, 1.39270388e-02f, -2.03937478e-02f, 1.02473229e-01f, -8.84943642e-03f, -9.60718542e-02f, -5.83498962e-02f, 7.32792355e-03f,
  -2.59432316e-01f, 3.81114811e-01f, -1.39053732e-01f, -6.87312707e-02f, -1.20479763e-01f, 5.76278307e-02f, -1.17439002e-01f, 1.03566453e-01f, 4.85437512e-02f, -5.72385974e-02f,
  4.50978614e-02f, -1.09963983e-01f, -2.84060210e-01f, 5.31987548e-02f, -1.00073576e-01f, -6.49659783e-02f, -1.79212138e-01f, -1.65720001e-01f, 8.51922035e-02f, -4.35282588e-02f,
  -3.19007486e-02f, -1.86554685e-01f, -4.16566789e-01f, -8.58174190e-02f, -2.14517593e-01f, -8.65366533e-02f, -1.86658159e-01f, -2.36203983e-01f, -1.00905240e-01f, -3.68886679e-01f,
  -1.45135403e-01f, 2.80532241e-01f, -4.30671364e-01f, 2.71398872e-01f, 1.64276630e-01f, 4.25204262e-02f, 4.03942645e-01f, 2.52650619e-01f, 8.53650272e-02f, 1.35051236e-01f,
  -1.58342049e-01f, -3.76818031e-01f, -2.78067499e-01f, -2.29124770e-01f, -2.30849311e-01f, 2.76906371e-01f, 3.15022439e-01f, -1.65534899e-01f, -3.79502445e-01f, 7.57243931e-02f,
  3.16936433e-01f, 2.77294606e-01f, 6.98224157e-02f, 3.11609060e-02f, 1.73842207e-01f, 7.07149208e-02f, 1.67850778e-01f, 4.96405549e-02f, -9.48517118e-03f, 1.53791800e-01f,
  -4.65132535e-01f, -2.65191138e-01f, -3.38999331e-02f, -4.52862531e-02f, -4.67992388e-02f, -1.22243680e-01f, -3.77823636e-02f, -1.05335906e-01f, -1.26313746e-01f, -9.40349773e-02f,
  -4.42543067e-02f, -1.13089845e-01f, -3.15826178e-01f, -3.72095294e-02f, -1.81332435e-02f, -1.94170717e-02f, -4.12144139e-02f, -6.21743500e-02f, -3.18844587e-01f, -2.66998678e-01f,
  1.20989308e-02f, -7.00019002e-02f, -2.35885769e-01f, -3.67492810e-02f, -2.72126853e-01f, -1.52834073e-01f, -1.29078388e-01f, -2.64449686e-01f, -2.80028522e-01f, 1.13320738e-01f,
  1.53849712e-02f, -7.52042979e-02f, -5.33936732e-02f, 9.20650810e-02f, 4.39094342e-02f, -4.51034307e-02f, -2.81537510e-02f, -3.12796161e-02f, 5.76194050e-03f, 8.61947518e-03f,
  -1.86724827e-01f, 6.89359531e-02f, -6.39644265e-02f, 1.30775850e-02f, 1.65394824e-02f, -8.15711170e-02f, -2.35953815e-02f, 1.05175331e-01f, -2.00729724e-02f, -5.87914214e-02f,
  8.36309567e-02f, 3.48711535e-02f, 5.92938960e-02f, -8.35863501e-02f, 6.03819080e-02f, -2.09460985e-02f, 3.40177231e-02f, -1.13404073e-01f, -4.17178161e-02f, -1.61581095e-02f,
  3.84415776e-01f, -1.20185435e-01f, -1.56715512e-01f, 1.19107054e-03f, -2.62770206e-02f, -1.67760700e-02f, -2.49592960e-02f, 1.03385873e-01f, 6.22890331e-02f, -1.62110001e-01f,
  -1.23595208e-01f, -1.17684722e-01f, -1.16588525e-01f, -1.79043747e-02f, -5.23607768e-02f, 2.10975595e-02f, 1.98575646e-01f, 1.55912668e-01f, 1.17247485e-01f, 1.07158199e-01f,
  1.79390192e-01f, 3.14184606e-01f, 1.62294790e-01f, 1.60436660e-01f, 1.42376438e-01f, 1.64679781e-01f, 4.80179116e-02f, 1.67277172e-01f, 1.00289965e-02f, 4.51016575e-01f,
  5.80226183e-01f, -1.03099104e-02f, 2.68061399e-01f, 2.75387228e-01f, 2.39204288e-01f, 2.70714313e-01f, 3.51202160e-01f, 2.03354180e-01f, 8.56102705e-02f, 2.04749390e-01f,
  -9.89877209e-02f, -1.84909120e-01f, -1.21008262e-01f, -1.55622259e-01f, 6.36886731e-02f, 1.07359685e-01f, 1.12764150e-01f, 2.57200688e-01f, 2.62551039e-01f, 2.07960889e-01f,
  -3.36263478e-02f, 8.39354619e-02f, 2.72542268e-01f, 1.99237004e-01f, -6.91552535e-02f, 3.45734730e-02f, 1.05296925e-01f, 6.58272430e-02f, 2.33516395e-02f, -1.13995232e-01f,
  -4.94329371e-02f, 1.18871652e-01f, -9.28424075e-02f, -1.93803445e-01f, -1.79797351e-01f, -5.67214340e-02f, 5.60945161e-02f, -7.25364983e-02f, -1.57421336e-01f, -1.09606301e-02f,
  -3.65876704e-02f, 1.44607108e-03f, -6.16886653e-02f, 1.40903341e-02f, 1.06709592e-01f, 2.44607329e-02f, -9.72196739e-03f, 5.87572902e-02f, 5.83473966e-02f, 3.44748311e-02f,
  -1.96665972e-01f, 5.99477701e-02f, 1.36457741e-01f, 1.28376603e-01f, -5.09624323e-03f, -4.98575941e-02f, 9.80648249e-02f, 9.28091779e-02f, 1.17750578e-01f, 5.99389970e-02f,
  4.22117338e-02f, 6.75261468e-02f, 9.17333812e-02f, 2.54255868e-02f, 8.03084373e-02f, -6.12658001e-02f, -6.20990582e-02f, 5.57676293e-02f, 1.38936132e-01f, 2.24076249e-02f,
  1.81071497e-02f, 1.92473438e-02f, 1.06385574e-01f, 8.44424218e-02f, -1.05079845e-01f, 6.25920966e-02f, 7.60029554e-02f, -1.11625299e-01f, 1.58866588e-02f, -9.49695334e-02f,
  2.34704651e-02f, 8.67309645e-02f, 6.38439059e-02f, 1.93582755e-02f, -2.12811325e-02f, 5.68270460e-02f, -6.27766305e-04f, 2.14429162e-02f, -4.54869680e-02f, -2.65109763e-02f,
  -2.10172310e-01f, 4.82341163e-02f, -1.60482436e-01f, -1.39956295e-01f, 7.01106787e-02f, -1.10956922e-01f, -3.75630483e-02f, -9.46993381e-02f, -1.99719101e-01f, -1.25742927e-01f,
  -7.75520355e-02f, 2.05877889e-02f, 1.32959457e-02f, 6.54794350e-02f, 4.44171652e-02f, 9.42980349e-02f, -7.05871359e-02f, 9.60053280e-02f, -1.03027686e-01f, -1.27309449e-02f,
  -7.92496726e-02f, 1.97123900e-01f, 1.30592152e-01f, -1.30868908e-02f, -3.82507108e-02f, 1.34831565e-02f, -4.72944304e-02f, 6.25947267e-02f, 3.53750587e-02f, 6.21235184e-02f,
  3.40635553e-02f, -6.17491966e-03f, -3.21796715e-01f, 6.79765567e-02f, 1.99716985e-02f, -1.62142932e-01f, -9.24725235e-02f, -6.14035428e-02f, 9.54336897e-02f, -1.76017191e-02f,
  9.66966450e-02f, 2.15318143e-01f, 8.14817995e-02f, -6.65792972e-02f, 6.83476701e-02f, -5.49712107e-02f, -1.30209565e-01f, -1.48195788e-01f, -2.09079564e-01f, -1.44957811e-01f,
  -6.00365736e-02f, -1.32993683e-01f, -7.64956102e-02f, -1.11870617e-01f, -1.27515987e-01f, -3.92189622e-02f, -2.05747515e-01f, -2.04206869e-01f, -2.19147220e-01f, -1.24069579e-01f,
  -3.55635881e-02f, -3.05340290e-02f, 9.54112113e-02f, 1.11865364e-01f, 3.45837995e-02f, 7.46403486e-02f, -6.27694428e-02f, 9.64782983e-02f, -1.44821992e-02f, 7.40297586e-02f,
  1.44969597e-02f, -6.90199248e-03f, -1.43819168e-01f, -7.76856691e-02f, -3.79983112e-02f, -1.57680154e-01f, -1.83697566e-02f, 1.93785019e-02f, 7.30759501e-02f, -6.36150176e-03f,
  -1.34190070e-02f, 3.98068652e-02f, -5.46286218e-02f, 3.58109772e-02f, 4.01382446e-02f, 7.53116682e-02f, 3.17713409e-03f, -1.85840763e-02f, 5.58181964e-02f, 2.82916073e-02f,
  1.10231899e-01f, 9.94802788e-02f, -1.07388608e-01f, 3.45071293e-02f, -1.38142630e-02f, -9.05627087e-02f, 2.44740248e-02f, 2.27080062e-02f, -2.73635960e-03f, 2.26178393e-02f,
  2.46443786e-03f, 6.88467324e-02f, -9.05286446e-02f, -6.47614673e-02f, -1.08985960e-01f, -1.61413610e-01f, -1.14355562e-02f, 2.60984227e-02f, -5.83857112e-02f, -2.22760849e-02f,
  3.94050963e-02f, -1.10579751e-01f, -1.66584909e-01f, -1.14959262e-01f, -7.28450418e-02f, -9.62036997e-02f, -1.36324212e-01f, -8.34383294e-02f, 4.89904024e-02f, -7.99875299e-04f,
  1.13512442e-01f, 7.28965029e-02f, 1.43812314e-01f, 1.67352542e-01f, -1.01271063e-01f, -3.82487215e-02f, 2.68650502e-02f, -1.74084995e-02f, 7.55535066e-02f, 9.79019925e-02f,
  9.34499130e-02f, -8.06026161e-02f, -5.47628701e-02f, 1.10569671e-02f, -6.64234683e-02f, -6.95996284e-02f, 3.77965271e-02f, 8.93366933e-02f, -2.05614939e-02f, -7.51452148e-02f,
  -1.10399006e-02f, 1.02627754e-01f, 7.73746520e-02f, 1.22704394e-01f, 1.69232786e-01f, 4.05364260e-02f, -7.01208487e-02f, -7.43849250e-03f, -8.79368186e-03f, 1.12888990e-02f,
  -5.45503557e-01f, 1.51003346e-01f, -3.22327018e-01f, -2.99728125e-01f, 1.51111066e-01f, 2.85439849e-01f, 4.22621846e-01f, 1.12692848e-01f, -4.81746048e-02f, -1.63729209e-02f,
  1.21341251e-01f, 3.20822597e-02f, -1.80559997e-02f, 7.87816495e-02f, 1.38617411e-01f, 1.26165271e-01f, 8.16013440e-02f, -1.14783816e-01f, 1.25391215e-01f, 1.96838826e-01f,
  2.77185768e-01f, -6.20135590e-02f, -3.11678171e-01f, -7.32862279e-02f, -1.63684249e-01f, 1.37334066e-02f, -2.38852888e-01f, -7.07078725e-02f, -1.12616997e-02f, -1.53319061e-01f,
  -1.91827297e-01f, -1.73446611e-01f, 1.46640256e-01f, -4.76043634e-02f, -1.52622208e-01f, -2.62531519e-01f, -1.22899935e-01f, -2.15525925e-01f, -4.79585528e-02f, -1.30782187e-01f,
  -1.85155928e-01f, -1.31011441e-01f, 4.03789245e-02f, 6.19046837e-02f, -4.29009981e-02f, -1.87307019e-02f, 4.83143516e-02f, -6.65338486e-02f, -1.81928456e-01f, -8.15868452e-02f,
  3.06458682e-01f, 2.28596665e-02f, -2.13443488e-01f, 1.58394426e-01f, -7.61449942e-03f, -3.55341882e-02f, -7.57802129e-02f, -4.90698032e-02f, -1.09899566e-01f, -2.84053594e-01f,
  1.46603500e-02f, 1.76402889e-02f, -7.13052973e-02f, 1.19373677e-02f, 9.55972597e-02f, 3.09105013e-02f, -1.84682049e-02f, 8.15942436e-02f, 5.94781041e-02f, 2.34732237e-02f,
  7.08854571e-03f, 4.64592911e-02f, 4.59021181e-02f, -1.13244258e-01f, -1.49096146e-01f, 4.44930457e-02f, 4.68031280e-02f, -8.93767998e-02f, -1.11003220e-01f, -3.65907289e-02f,
  2.03753524e-02f, -3.96293402e-02f, -1.01652957e-01f, 2.35422216e-02f, 1.21257432e-01f, 4.18663919e-02f, -2.14211009e-02f, 2.95285713e-02f, -1.41325267e-02f, -4.53383289e-02f,
  -3.30467612e-01f, 8.77849758e-02f, -1.62996978e-01f, 3.50085646e-02f, -8.41914937e-02f, -1.02753125e-01f, -1.35342717e-01f, -1.89026780e-02f, -4.47612144e-02f, -1.28746557e-03f,
  -2.23916098e-02f, 2.03170478e-02f, -1.04714721e-01f, 1.48747072e-01f, -7.92273805e-02f, -6.85713664e-02f, 1.30798489e-01f, 9.69162136e-02f, 1.01635620e-01f, -4.15204205e-02f,
  8.90433043e-02f, 1.92076042e-02f, -3.51683199e-02f, 3.32181435e-03f, -2.39524860e-02f, -1.63932949e-01f, -2.26174340e-01f, -1.52329415e-01f, -1.20376527e-01f, -2.88712829e-01f,
  6.46837234e-01f, 3.41323495e-01f, 1.03668094e-01f, 4.28463258e-02f, -8.65750983e-02f, -1.73184469e-01f, -1.64663866e-01f, -9.35387835e-02f, 1.03475899e-01f, 1.00474261e-01f,
  9.95211750e-02f, 1.29678681e-01f, 7.10161999e-02f, 3.31580602e-02f, 3.27694342e-02f, -6.09621666e-02f, -1.86029095e-02f, 1.57776505e-01f, 6.69744238e-02f, 2.84300931e-02f,
  4.23476808e-02f, 4.85694855e-02f, 7.43634179e-02f, 8.12654570e-02f, -2.06570644e-02f, -3.37534919e-02f, -1.00809798e-01f, -6.11101091e-02f, -5.81773892e-02f, 1.83582395e-01f,
  3.75114620e-01f, 2.38145038e-01f, 1.21594965e-01f, 8.07672814e-02f, 4.23852680e-03f, 1.56650871e-01f, 1.48048341e-01f, 9.23209116e-02f, 8.13865811e-02f, 2.99398638e-02f,
  1.22796074e-01f, -1.86439008e-02f, 1.06156981e-02f, -1.52676359e-01f, 2.43481174e-02f, 6.47700131e-02f, -9.87210050e-02f, 1.06056802e-01f, -4.77017574e-02f, -4.93631363e-02f,
  -1.22190110e-01f, -1.15327701e-01f, -5.36704250e-02f, -1.51992813e-01f, -8.22746158e-02f, -7.99596384e-02f, -7.83887953e-02f, -6.57847375e-02f, -1.28070787e-01f, 2.79870890e-02f,
  -1.94806326e-02f, -1.24377501e-03f, 6.83918782e-03f, -1.03202946e-01f, -1.28637090e-01f, 1.50283724e-02f, -1.07786059e-02f, -8.28799084e-02f, -2.90135927e-02f, -1.45057485e-01f,
  1.70811042e-02f, -9.73873809e-02f, -9.95052606e-03f, 1.00068547e-01f, 1.34352580e-01f, -1.31184727e-01f, 2.29343828e-02f, 1.04714654e-01f, 8.09380028e-04f, -9.03210491e-02f,
  7.24068061e-02f, 5.86959235e-02f, -1.99746643e-03f, -6.79330081e-02f, 4.40766849e-02f, -5.90807237e-02f, -6.41997755e-02f, -5.76026440e-02f, -5.04361372e-03f, -1.44369364e-01f,
  -6.60801902e-02f, 8.24913308e-02f, 1.31785765e-01f, 1.69863775e-01f, 2.11553983e-02f, 1.19555332e-01f, 1.53051645e-01f, 1.72404364e-01f, 3.66407447e-02f, 3.25287990e-02f,
  8.23752061e-02f, 1.46769688e-01f, 3.61894444e-02f, -1.78483669e-02f, -6.40370995e-02f, 4.44218554e-02f, 4.76103500e-02f, 3.91486380e-03f, 5.34791388e-02f, 1.00837894e-01f,
  -8.24637637e-02f, 2.61203144e-02f, 5.09108305e-02f, -2.36054324e-02f, 7.70526193e-03f, 9.31598321e-02f, -4.67283316e-02f, 5.32195233e-02f, -2.13484429e-02f, -1.72033571e-02f,
  4.45028245e-01f, 1.99639305e-01f, 6.92571048e-04f, 2.32651874e-01f, 6.77806884e-02f, 1.05376735e-01f, 1.59295067e-01f, 2.51874954e-01f, 1.24016754e-01f, 1.86698720e-01f,
  2.34342575e-01f, 2.62684554e-01f, 2.99619555e-01f, 2.08769083e-01f, 1.91392884e-01f, 1.00690588e-01f, 3.06940880e-02f, 4.01138328e-02f, 1.20077930e-01f, 5.36880679e-02f,
  -3.82279381e-02f, -1.86306890e-02f, 3.90017740e-02f, 9.47376117e-02f, -1.13501713e-01f, -2.19864752e-02f, -1.15823746e-02f, -7.32434094e-02f, -8.21193308e-02f, -3.40826772e-02f,
  -2.18183756e-01f, 1.06004372e-01f, 3.54620740e-02f, -5.28783351e-02f, -1.29817054e-01f, -6.17864169e-02f, -1.66572873e-02f, 4.96012978e-02f, 5.25059775e-02f, 3.79839279e-02f,
  -3.08555942e-02f, -1.07659228e-01f, -6.55432343e-02f, -1.55368894e-01f, -8.89164135e-02f, -6.37110472e-02f, 2.11135782e-02f, 1.46555991e-04f, 1.32444203e-01f, -1.02724336e-01f,
  4.20445614e-02f, 3.68789025e-02f, 3.52563225e-02f, 9.90869105e-02f, 6.69047162e-02f, 3.73659544e-02f, 3.07065230e-02f, -7.66301304e-02f, 3.97376902e-02f, 5.86295314e-02f,
  3.42010409e-01f, -6.02836087e-02f, -1.08039461e-01f, -4.47217897e-02f, -8.00731406e-03f, 1.40357530e-02f, -1.13418184e-01f, -1.28478818e-02f, 1.19246915e-03f, -1.71227023e-01f,
  2.84811929e-02f, 6.38684630e-02f, 8.47856253e-02f, 1.99649688e-02f, 3.16308700e-02f, -4.91873883e-02f, -5.20043224e-02f, 8.22315272e-03f, -1.70148566e-01f, 3.85525152e-02f,
  -9.22182053e-02f, -8.12312886e-02f, -2.05149680e-01f, -1.15895510e-01f, -1.43896602e-02f, 6.39058873e-02f, 9.28331632e-03f, 2.72682756e-02f, -6.77753910e-02f, 7.75220096e-02f,
  -2.60076314e-01f, 1.01732440e-01f, 3.17980275e-02f, 3.19564119e-02f, -1.79550573e-01f, -8.99657309e-02f, 3.82374935e-02f, -5.88423237e-02f, -1.02184355e-01f, -1.36588691e-02f,
  -3.58000472e-02f, -1.10302515e-01f, -7.01109394e-02f, -1.68740209e-02f, -4.95588742e-02f, 2.99863005e-03f, -1.25121936e-01f, 6.05241135e-02f, -4.16658148e-02f, 3.01531330e-02f,
  -1.30854100e-01f, 6.65218011e-02f, 1.08892769e-01f, 1.83683750e-03f, -4.88740988e-02f, 1.34789765e-01f, -1.06182262e-01f, -3.16468365e-02f, -6.16418617e-03f, -7.04241991e-02f,
  5.34057319e-01f, -4.64131534e-02f, 3.03064883e-01f, 1.10738859e-01f, 1.13977522e-01f, 2.16569722e-01f, 4.00667369e-01f, 2.11828679e-01f, 9.87431258e-02f, 1.09792888e-01f,
  -1.05736665e-01f, -1.93304643e-01f, -1.92441061e-01f, -8.83793458e-02f, 7.88980871e-02f, 2.24780831e-02f, -2.00275686e-02f, 1.08998306e-01f, 1.88840732e-01f, 1.97054073e-01f,
  -4.48561944e-02f, 3.12278289e-02f, 2.27397323e-01f, 4.88507412e-02f, 2.27572564e-02f, -4.25367877e-02f, 6.95584789e-02f, 2.64051519e-02f, -5.45047522e-02f, -1.14420414e-01f,
  -7.26526156e-02f, 2.79256970e-01f, -1.94061846e-02f, -2.34198824e-01f, 6.55768365e-02f, 2.32861210e-02f, 7.68202990e-02f, -1.14275189e-02f, -1.04990780e-01f, -3.42517383e-02f,
  -1.06543221e-01f, 4.09776857e-03f, 2.64464132e-03f, 6.70507029e-02f, 4.58188839e-02f, -6.27099117e-03f, 2.48054732e-02f, 1.05060846e-01f, -4.33529280e-02f, -5.72139993e-02f,
  -3.36354189e-02f, 1.62803344e-02f, 1.55518040e-01f, 4.78246175e-02f, 5.31460717e-02f, 9.14330184e-02f, -2.47014929e-02f, -4.70046736e-02f, 2.73764431e-02f, 7.88480334e-04f,
  -2.48192698e-02f, -1.01576552e-01f, -7.27673667e-03f, 6.31296411e-02f, 6.64369538e-02f, 1.14178553e-01f, 1.25021666e-01f, -2.11776923e-02f, 9.95055214e-02f, 1.71985850e-01f,
  4.58030328e-02f, 4.66151759e-02f, 1.72555611e-01f, 1.05660178e-01f, 2.99320556e-02f, 5.00540100e-02f, 5.82827430e-04f, 2.28788313e-02f, 1.01488627e-01f, 8.02238733e-02f,
  1.02829285e-01f, 1.79221183e-01f, 2.13035122e-01f, 7.78160915e-02f, 9.77388322e-02f, 2.61091953e-03f, -1.85804777e-02f, -2.68437359e-02f, 8.37797225e-02f, 1.82681128e-01f,
  -3.57285589e-01f, 3.18116814e-01f, -6.37785792e-02f, -1.30842282e-02f, 7.78162181e-02f, -4.44928296e-02f, 1.40311131e-02f, -1.92618929e-02f, -1.84155077e-01f, -3.63819068e-03f,
  -9.67724100e-02f, 7.71347359e-02f, 3.17399949e-02f, 1.00555466e-02f, 5.05230464e-02f, 1.07371807e-01f, -1.21152833e-01f, 8.66768360e-02f, -1.58122241e-01f, -4.20190729e-02f,
  -1.28311485e-01f, 4.59741578e-02f, 8.52015987e-02f, 5.71235903e-02f, -7.50645325e-02f, 4.67161499e-02f, 6.88493252e-02f, -6.05912358e-02f, 4.01434451e-02f, -2.23410670e-02f,
  -2.99300879e-01f, 1.70775950e-02f, -3.04035634e-01f, -1.29381999e-01f, 2.06101406e-02f, 1.41029179e-01f, 2.88960099e-01f, 3.29657495e-01f, -3.58752422e-02f, -1.07792400e-01f,
  1.21383145e-01f, -3.20388824e-02f, -2.51325130e-01f, -3.52664925e-02f, 1.31659746e-01f, -1.02762751e-01f, -1.91110551e-01f, -2.50446171e-01f, 2.40570202e-01f, 3.42304409e-01f,
  2.10394874e-01f, -7.48265982e-02f, 3.09864748e-02f, 6.65665269e-02f, -1.49322391e-01f, -1.62968621e-01f, -3.78974468e-01f, -2.46737406e-01f, -1.44283414e-01f, -3.40862066e-01f,
  -2.48144075e-01f, -1.09041566e-02f, 8.91503394e-02f, -1.02678277e-02f, -1.49507239e-01f, 4.67986278e-02f, 2.12368682e-01f, -3.20994481e-02f, 5.07881269e-02f, 3.61893773e-02f,
  -7.66150057e-02f, 1.22306824e-01f, 1.28620163e-01f, -4.12198901e-02f, 8.16354454e-02f, 2.21608534e-01f, -2.29047984e-02f, -1.15830101e-01f, -1.36553928e-01f, 1.57215707e-02f,
  -7.17806742e-02f, -1.21916421e-01f, -1.62801474e-01f, 1.86191760e-02f, 1.08039426e-02f, -1.36539668e-01f, 5.06591350e-02f, -1.78920664e-02f, -4.99594137e-02f, -2.05332935e-01f,
  6.60632998e-02f, -5.56896180e-02f, -4.05737087e-02f, 1.41746312e-01f, -1.93492956e-02f, -9.93881449e-02f, -1.05643116e-01f, -4.35597226e-02f, 9.97453462e-03f, -1.34827113e-02f,
  -6.66451082e-03f, -8.16357061e-02f, 5.61985932e-02f, -6.78951293e-02f, 1.43666435e-02f, -5.00088967e-02f, 5.10705225e-02f, -1.17600791e-01f, -3.21961567e-02f, -6.81239143e-02f,
  -1.65290199e-02f, -1.26166120e-02f, -2.39535794e-02f, 2.42871139e-02f, -9.17444900e-02f, -8.36539790e-02f, -4.41670092e-03f, 2.27434963e-01f, 1.76542595e-01f, 1.42836109e-01f,
  -1.92038491e-02f, 3.31658721e-02f, -1.67809859e-01f, 1.33503834e-02f, -1.21521540e-01f, -9.52112228e-02f, -1.63358241e-01f, 3.87543254e-03f, -7.67220035e-02f, 2.12208271e-01f,
  1.73362046e-01f, 1.63843006e-01f, -4.81710136e-02f, 1.08459622e-01f, 1.64165556e-01f, 3.11267730e-02f, -6.90247566e-02f, -2.05873623e-01f, -2.19958182e-03f, 4.27608937e-02f,
  -5.84321581e-02f, 2.36114841e-02f, -1.00404538e-01f, -2.40260214e-02f, -1.05445690e-01f, -6.90883994e-02f, -1.00391386e-02f, -5.45264147e-02f, -7.35215694e-02f, 4.25390154e-02f,
  5.16999215e-02f, -7.10110888e-02f, -6.11148663e-02f, 2.06514701e-01f, 3.27604294e-01f, -5.72201498e-02f, -3.90298009e-01f, -3.32725942e-01f, 1.73130408e-01f, 6.91098198e-02f,
  2.49678746e-01f, 2.36480474e-01f, -3.77802290e-02f, -2.60910213e-01f, -6.21327341e-01f, -4.69558358e-01f, -3.47644061e-01f, -3.99580091e-01f, -4.05239850e-01f, -1.22207649e-01f,
  1.03510246e-01f, -7.76859149e-02f, -1.86734691e-01f, 9.82952677e-03f, 2.56883711e-01f, 5.66304065e-02f, 9.74363610e-02f, 5.99526949e-02f, 9.91619453e-02f, 1.32541031e-01f,
  2.34476589e-02f, 1.89882085e-01f, 8.08395445e-02f, 3.66784371e-02f, 2.15565175e-01f, -1.84857082e-02f, -8.68805945e-02f, -2.70513189e-03f, 1.22776330e-01f, -1.02675751e-01f,
  2.16814891e-01f, 9.78927389e-02f, 7.96937644e-02f, 7.13870376e-02f, 5.47988387e-03f, -1.20248735e-01f, -3.87911499e-02f, -1.15243413e-01f, -1.59820169e-01f, -3.52565869e-04f,
  -8.94859713e-03f, -1.79749224e-02f, -1.46153554e-01f, -1.45459101e-01f, -6.21590689e-02f, -1.30286003e-02f, 1.80830508e-02f, 1.74938664e-01f, -1.19914003e-01f, -3.30643132e-02f,
  4.73079048e-02f, 2.31428221e-02f, 8.70714113e-02f, 1.80757348e-03f, -5.74697219e-02f, 9.62839425e-02f, 8.74169692e-02f, -1.17336661e-02f, -7.59014860e-02f, -1.04951498e-03f,
  -4.44005616e-02f, 2.61266120e-02f, 2.50246078e-02f, -8.91361535e-02f, 7.17237405e-03f, 1.93878505e-02f, 1.98757369e-02f, -1.41219199e-01f, -8.00863057e-02f, 2.61113197e-02f,
  -6.44259304e-02f, 1.45188905e-02f, 2.03949511e-01f, 2.37777326e-02f, -9.24048424e-02f, 1.90195553e-02f, 1.49211302e-01f, -5.65684959e-02f, 2.03387924e-02f, 9.94442403e-02f,
  7.68607333e-02f, -1.61550939e-01f, 3.52222100e-02f, -1.02275051e-01f, 9.70839560e-02f, 1.18586645e-01f, 1.88375950e-01f, 4.01722975e-02f, 1.26353115e-01f, -8.22587162e-02f,
  1.60968341e-02f, -4.40528654e-02f, 7.23080561e-02f, 5.66674769e-02f, -3.22859623e-02f, 4.44990322e-02f, -8.93899128e-02f, -3.25578973e-02f, -1.35421604e-01f, 9.64129716e-02f,
  -1.30680576e-01f, -2.08158568e-01f, -2.97766805e-01f, -3.12730938e-01f, 5.70669621e-02f, -9.81139764e-02f, -8.71758536e-02f, 2.89603043e-02f, -1.66635111e-01f, -3.20351958e-01f,
  3.31552595e-01f, 1.20507911e-01f, -9.73727368e-03f, 2.78992653e-01f, 1.08064376e-01f, -1.69830039e-01f, -4.44877237e-01f, -3.23978752e-01f, 5.40703535e-02f, 1.49091035e-01f,
  1.16455920e-01f, 3.04148495e-01f, 1.94415390e-01f, 9.38449502e-02f, -1.21397100e-01f, 3.45062800e-02f, 1.90193877e-01f, 1.03764601e-01f, 6.76944330e-02f, 2.21641615e-01f,
  3.16120416e-01f, 2.31813446e-01f, 1.74367607e-01f, 6.51403442e-02f, 2.91710675e-01f, 2.79517740e-01f, 6.39926940e-02f, 2.77282864e-01f, 1.65248632e-01f, 5.19028306e-01f,
  2.69502640e-01f, 1.37736443e-02f, -6.80117384e-02f, 1.82414263e-01f, 1.05124101e-01f, 9.51302424e-02f, -3.02848499e-02f, -5.54656684e-02f, 3.18208449e-02f, -1.89978126e-02f,
  2.07911089e-01f, 8.13790187e-02f, 5.24685867e-02f, 7.67436549e-02f, 6.87354133e-02f, 6.67883223e-03f, -1.30837291e-01f, -1.09592497e-01f, -9.46416408e-02f, -4.56037149e-02f,
  2.29107738e-01f, 1.35423884e-01f, -8.92749354e-02f, -1.99598506e-01f, -2.23072201e-01f, 7.02987015e-02f, -1.29723161e-01f, 5.14716581e-02f, -2.60498255e-01f, 3.98546085e-02f,
  6.42261654e-02f, 9.09898728e-02f, 6.67880848e-02f, 1.50223479e-01f, 1.36882871e-01f, 6.70895725e-02f, 9.58848298e-02f, -3.93688828e-02f, 1.32938638e-01f, 2.46543791e-02f,
  6.40716329e-02f, 5.57784885e-02f, -1.12883814e-01f, 2.80298833e-02f, 1.28170222e-01f, 3.12092677e-02f, 1.16656087e-02f, -2.68400740e-02f, -2.12188158e-02f, -4.59384061e-02f,
  1.61023751e-01f, -3.59089822e-02f, 1.10819817e-01f, -3.66769135e-02f, 1.69389099e-02f, 8.51668790e-02f, 1.10426836e-01f, 7.95034915e-02f, -2.32000723e-02f, 1.38928354e-01f,
  -3.53428274e-01f, -2.80050755e-01f, 1.25609025e-01f, -1.63937554e-01f, 1.97052453e-02f, -5.75787462e-02f, 1.06892042e-01f, 6.94940388e-02f, 6.72619743e-03f, -3.05495821e-02f,
  -3.97671908e-02f, -1.77725498e-02f, -6.80623204e-02f, -1.50744110e-01f, -7.87475184e-02f, 2.66244989e-02f, -4.12508436e-02f, -6.33971840e-02f, -1.84047401e-01f, -1.81252267e-02f,
  -1.87701300e-01f, -1.92523345e-01f, -1.50500417e-01f, -3.35994691e-01f, -1.30959466e-01f, -5.72799193e-03f, -1.08204342e-01f, -6.92411512e-02f, -2.39734903e-01f, -1.58546403e-01f,
  -4.27092820e-01f, 1.23076186e-01f, -4.35117275e-01f, -4.24294323e-01f, -1.34323016e-01f, 5.55169173e-02f, 2.18424648e-01f, 1.88000694e-01f, 6.51640147e-02f, 1.68885046e-03f,
  -1.56915590e-01f, -2.00196043e-01f, -3.98234963e-01f, -1.98774472e-01f, -1.13946542e-01f, -1.35382980e-01f, -3.46518308e-01f, -3.06204557e-01f, -2.85304278e-01f, 1.70984641e-01f,
  2.00829115e-02f, -3.63329560e-01f, -2.95793712e-01f, -1.32899255e-01f, -5.22282980e-02f, -2.63829619e-01f, -3.21996361e-01f, -1.88085362e-01f, 8.00223053e-02f, -3.24659914e-01f,
  -4.56569761e-01f, -1.45814583e-01f, 2.77447905e-02f, 1.33022657e-02f, -4.05253246e-02f, 6.89823329e-02f, -4.47774446e-03f, -8.20669159e-02f, 1.88508749e-01f, 1.35137171e-01f,
  -1.04920052e-01f, 1.41493186e-01f, -8.65878463e-02f, -9.13614593e-03f, -1.66637763e-01f, 1.49101568e-02f, -7.63842314e-02f, -2.57930774e-02f, 6.70162663e-02f, 2.05467105e-01f,
  1.31389707e-01f, 5.58361858e-02f, 6.65696114e-02f, 1.24730647e-01f, 1.39554977e-01f, -4.12770920e-02f, 1.58755451e-01f, 8.86895508e-02f, 1.08021587e-01f, -1.87432356e-02f,
  8.56577456e-02f, 5.60827628e-02f, -1.30772442e-02f, -2.62807440e-02f, 1.69352561e-01f, -7.97354653e-02f, 2.02968083e-02f, -2.48684660e-02f, -4.39832136e-02f, 1.29269604e-02f,
  5.59509657e-02f, -2.64791958e-02f, -1.34617304e-02f, 1.68454479e-02f, -5.28526232e-02f, -1.02696523e-01f, -6.14745989e-02f, -9.54297781e-02f, 1.10705696e-01f, -3.94276343e-02f,
  2.74674892e-02f, 4.95410301e-02f, -9.46100280e-02f, 7.29875565e-02f, 9.32621732e-02f, -4.98778783e-02f, -3.52257043e-02f, 3.21110375e-02f, 6.62329271e-02f, 9.36054885e-02f,
  -5.63292861e-01f, -2.12506846e-01f, -1.35453641e-01f, 2.36154962e-02f, -2.19155177e-02f, 1.05569892e-01f, -6.28518909e-02f, 5.20592816e-02f, 3.56392451e-02f, -1.16262417e-02f,
  1.59324139e-01f, -3.88071053e-02f, -1.10946521e-01f, 5.59774786e-02f, -4.59696874e-02f, -6.41249865e-02f, 1.62714452e-01f, -5.52650206e-02f, 9.67836455e-02f, 1.65721372e-01f,
  1.60750851e-01f, 5.72105348e-02f, 1.93772539e-02f, -6.61525279e-02f, 1.12840004e-01f, -1.10586286e-01f, -2.43150108e-02f, 1.30276838e-02f, -4.92841490e-02f, 6.51785312e-03f,
  3.83083612e-01f, -3.41829121e-01f, -3.31033915e-01f, 8.24766383e-02f, -2.37261191e-01f, -2.23099723e-01f, -5.79877913e-01f, 3.01716104e-03f, 7.52945170e-02f, -4.55263525e-01f,
  -1.89881533e-01f, 2.63551056e-01f, 5.10672852e-02f, 6.19418584e-02f, 6.72325268e-02f, -5.24390638e-01f, -3.65404665e-01f, 1.83472916e-01f, 4.15597111e-01f, 9.04160291e-02f,
  -1.02042615e-01f, 1.61831573e-01f, 3.30742598e-01f, 1.72977507e-01f, -2.76029199e-01f, 4.24206629e-02f, -1.98523104e-01f, -1.42284676e-01f, -2.54145235e-01f, -3.72517079e-01f,
  -2.93937296e-01f, 2.84618475e-02f, 9.94401202e-02f, 1.58922791e-01f, -1.26813963e-01f, 1.35908902e-01f, -1.21184640e-01f, 1.27958860e-02f, -1.03969209e-01f, -6.03291616e-02f,
  4.87530082e-02f, 1.72103629e-01f, 1.28847152e-01f, 3.74829844e-02f, -1.19063742e-02f, 5.80112450e-02f, 1.00611888e-01f, 8.71532634e-02f, 1.71083044e-02f, -1.58806562e-01f,
  -1.17307581e-01f, -1.09857835e-01f, 9.44546536e-02f, -8.52323472e-02f, 1.47754569e-02f, 2.21627861e-01f, 5.21118715e-02f, 2.93136388e-02f, 8.50265194e-03f, -3.47537488e-01f,
  -1.56410992e-01f, -2.45668050e-02f, -8.14331248e-02f, 2.33379137e-02f, 2.75847130e-02f, -1.88324191e-02f, 3.15722339e-02f, 2.32552681e-02f, 4.16191742e-02f, -5.32578751e-02f,
  1.62380747e-02f, -3.12061664e-02f, 7.35554844e-03f, -3.33159454e-02f, 2.29655299e-02f, 3.97148244e-02f, -2.29536761e-02f, -9.97102037e-02f, 1.83402896e-02f, -2.14860924e-02f,
  1.18705891e-01f, -4.66635786e-02f, 1.16006564e-02f, 9.76379495e-03f, -1.47389770e-02f, 3.17812944e-03f, 6.97203577e-02f, 8.81870613e-02f, 6.35030717e-02f, -2.24217754e-02f,
  1.11134812e-01f, 1.38479039e-01f, -2.45597586e-01f, 1.82832237e-02f, -1.92259587e-02f, -1.07057273e-01f, -1.02362685e-01f, 2.65380275e-03f, 1.87182486e-01f, -6.75888285e-02f,
  9.40355286e-02f, -6.69936165e-02f, -6.44219667e-02f, -1.30081652e-02f, -5.19822426e-02f, -4.20919852e-03f, -7.80180618e-02f, 7.06537589e-02f, 1.03176445e-01f, -9.58402306e-02f,
  -2.52567232e-03f, -3.36534604e-02f, 1.25308512e-02f, -7.28462730e-03f, 5.01978770e-02f, 1.01413280e-01f, -2.94481684e-02f, -1.08132221e-01f, -2.12422311e-02f, -3.87173116e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.94537604e-01f, 4.14841384e-01f, 4.21611667e-01f, 1.76992547e-02f, 4.00376111e-01f, 1.18797705e-01f, 2.05784559e-01f, 3.31600487e-01f, 2.14486390e-01f, 3.93500226e-03f,
  9.25457031e-02f, 3.49751674e-02f, 2.34371200e-01f, 1.40799418e-01f, 3.46381813e-01f, 2.46393383e-01f, -1.35091916e-01f, 5.43407351e-02f, -1.25105083e-01f, 8.64074081e-02f,
  1.43590257e-01f, 1.63178649e-02f, 8.98313522e-02f, 2.33554885e-01f, 1.25155821e-01f, 2.50436872e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  5.32859117e-02f, 1.57653078e-01f, -1.29807979e-01f, 1.24106139e-01f, -5.11145145e-02f, -1.51995504e-02f, -8.41255710e-02f, -5.85641675e-02f, -4.80273739e-02f, 6.30402006e-03f,
  -1.02788977e-01f, 5.75123169e-02f, 1.70641333e-01f, -3.54320183e-02f, 3.34979370e-02f, 7.87715167e-02f, 2.30213497e-02f, -1.81536004e-01f, -2.15938203e-02f, 3.93891521e-02f,
  -2.80477796e-02f, -6.11545183e-02f, -1.28358742e-02f, 3.80850919e-02f, -1.70964934e-02f, -1.26949355e-01f, 2.74189021e-02f, 1.09537430e-02f, 1.17734946e-01f, -2.99258195e-02f,
  1.06211931e-01f, -3.31619591e-03f, 6.78265765e-02f, -2.94807479e-02f, -6.50596200e-03f, 1.21546770e-02f, -1.38527751e-02f, 3.25675830e-02f, -1.49876587e-02f, 2.25706436e-02f,
  8.57407004e-02f, -1.27381057e-01f, -3.39385420e-02f, 4.58636973e-03f, 5.01417443e-02f, 1.67926420e-02f, -6.43055066e-02f, -1.35203555e-01f, -7.93179497e-02f, -8.90853032e-02f,
  -3.80908921e-02f, 1.33690462e-01f, -7.73671046e-02f, -4.25722711e-02f, -1.66901410e-01f, -5.06495722e-02f, 4.18236963e-02f, 1.25757843e-01f, -1.18142188e-01f, -4.86061815e-03f,
  2.08025128e-01f, -5.66356890e-02f, 4.95586731e-02f, 1.08340226e-01f, -5.33697801e-03f, 3.59369665e-02f, -7.30172321e-02f, 1.08338565e-01f, 9.94736776e-02f, 4.01068898e-03f,
  -5.26302215e-03f, -4.09236103e-02f, 1.30418940e-02f, 1.54792657e-02f, -2.02859730e-01f, -1.29415272e-02f, -1.97170243e-01f, 1.18833520e-02f, 1.02673722e-02f, 8.46589059e-02f,
  -3.53786461e-02f, 1.05517000e-01f, -1.53021574e-01f, 1.26835518e-02f, 1.24945030e-01f, -1.65294800e-02f, 1.24422938e-01f, 1.06323786e-01f, 1.01071782e-01f, -1.03152744e-01f,
  -1.48924403e-02f, 7.76752736e-03f, 3.04483585e-02f, 6.80732261e-03f, 5.18873483e-02f, 7.09128901e-02f, 9.55313146e-02f, 1.23676144e-01f, 9.49507803e-02f, -4.31397669e-02f,
  -5.39960228e-02f, 5.56486398e-02f, 1.30153477e-01f, 7.59310052e-02f, 1.32833838e-01f, 9.29899663e-02f, 1.27757257e-02f, -1.57514751e-01f, 5.79852723e-02f, -2.34271154e-01f,
  1.65451646e-01f, 7.00758621e-02f, 1.22448795e-01f, -1.10370144e-01f, -2.28046164e-01f, 2.05557093e-01f, -3.94546241e-02f, 8.02862793e-02f, 6.89901635e-02f, 2.62455493e-01f,
  1.05183095e-01f, 1.34258613e-01f, -1.39093593e-01f, 1.60473987e-01f, -1.15374336e-02f, 1.01153897e-02f, 8.29792470e-02f, 3.65194827e-02f, -6.74846247e-02f, 7.72736669e-02f,
  -3.06364801e-02f, -4.37638275e-02f, 1.04420319e-01f, 5.21124117e-02f, 1.48123279e-01f, -7.36817857e-03f, -7.30636045e-02f, -7.62015134e-02f, -9.74199455e-03f, -1.72065776e-02f,
  3.92907411e-02f, -1.30436778e-01f, 1.00375544e-02f, 1.22226372e-01f, -4.97072227e-02f, 5.81816100e-02f, -3.08849812e-02f, 8.01839456e-02f, -7.26293772e-02f, 8.89300108e-02f,
  4.45421673e-02f, -2.26067062e-02f, 4.56093922e-02f, -7.41697848e-02f, -1.47591252e-02f, -4.10149507e-02f, 7.86416791e-03f, -5.65913543e-02f, 5.38869686e-02f, -2.04620194e-02f,
  3.32284905e-02f, -8.33609886e-03f, 3.89077840e-03f, 2.95004006e-02f, -9.63976607e-02f, -5.45125082e-02f, -1.92896742e-02f, -6.69531003e-02f, -3.54236998e-02f, -2.74444837e-03f,
  1.59106981e-02f, -6.54407293e-02f, -5.69857806e-02f, -3.65124866e-02f, 9.72031429e-02f, 1.62441209e-02f, 5.86858578e-02f, -7.50941411e-02f, -1.31671607e-01f, 1.16333850e-01f,
  -5.97548531e-03f, -8.44059214e-02f, -7.69309849e-02f, 3.73562500e-02f, 4.98220287e-02f, -1.48708388e-01f, -6.83909804e-02f, -1.26892120e-01f, 7.57964887e-03f, -5.96251339e-02f,
  5.25142699e-02f, -1.98822990e-02f, 8.43285918e-02f, -1.08821109e-01f, 8.96854326e-02f, -3.76237929e-02f, 9.18619931e-02f, -1.60676509e-01f, -5.54742031e-02f, 2.18179338e-02f,
  1.51489023e-02f, 5.48013560e-02f, 6.11846074e-02f, 6.82390854e-02f, 1.38793826e-01f, 2.62409041e-04f, 1.01696156e-01f, -4.82923388e-02f, -5.81491441e-02f, -1.57386124e-01f,
  -7.52585009e-02f, -5.86992167e-02f, -7.54722506e-02f, -5.54348007e-02f, 7.92335570e-02f, 9.48936865e-02f, -7.28723928e-02f, -5.38477078e-02f, -1.30867977e-02f, -9.13294330e-02f,
  7.63006285e-02f, 9.44047943e-02f, -4.21442054e-02f, 4.32759933e-02f, -2.12586656e-01f, -9.72303841e-03f, 6.14426434e-02f, 1.50598884e-02f, 4.38668095e-02f, 2.18811501e-02f,
  -1.54489651e-01f, -1.54708058e-01f, -1.45711392e-01f, 6.69268193e-03f, -1.41579419e-01f, -1.35855302e-02f, 1.82235185e-02f, 7.35994875e-02f, -1.37008438e-02f, -5.27259000e-02f,
  2.68687252e-02f, -1.46839907e-02f, -1.49160415e-01f, -8.27704594e-02f, -3.12301755e-01f, -1.37933344e-01f, 2.19335780e-02f, -1.32957757e-01f, 1.41925111e-01f, -1.11783139e-01f,
  -1.09197292e-02f, -2.68037349e-01f, -9.43462923e-02f, 2.65101582e-01f, -4.08639878e-01f, 1.43925428e-01f, -2.34368891e-02f, -3.70896310e-02f, -3.27952541e-02f, 1.71849534e-01f,
  -5.91677940e-03f, -1.38808694e-02f, -4.63854428e-03f, 3.80473658e-02f, -2.25186273e-02f, -2.87142321e-02f, 1.18383870e-01f, -1.60487369e-01f, 8.71513486e-02f, -2.28740554e-02f,
  -1.37783177e-02f, -4.12879325e-02f, -8.09471384e-02f, 4.39892672e-02f, -1.00598417e-01f, -2.07281183e-03f, -8.89429301e-02f, 2.14058608e-01f, 4.69273925e-02f, -7.57605880e-02f,
  -6.12479858e-02f, -3.66604850e-02f, 1.31075487e-01f, 7.91711882e-02f, 4.60874401e-02f, 5.42770736e-02f, 5.59359677e-02f, 2.97552515e-02f, -6.53020665e-03f, -7.72859156e-03f,
  -2.05374420e-01f, 5.56597672e-02f, -1.17200777e-01f, -5.20372018e-02f, 1.11823730e-01f, 8.92604515e-02f, -5.81715815e-03f, 3.46662588e-02f, 3.83048244e-02f, -3.98654528e-02f,
  -5.55979125e-02f, 6.39440268e-02f, -7.28035644e-02f, -6.15907237e-02f, -2.41609700e-02f, -1.38314012e-02f, 4.16190997e-02f, 1.55249983e-01f, -2.05444917e-01f, -5.32604381e-02f,
  8.81402716e-02f, 6.95267841e-02f, -5.77965938e-02f, -1.46014556e-01f, 5.60506992e-02f, 1.32628195e-02f, 1.54848740e-01f, -2.89859297e-03f, 6.27613813e-02f, -5.72050251e-02f,
  -1.83106169e-01f, 1.46764368e-01f, -7.65806660e-02f, -7.48316497e-02f, 3.15073133e-02f, 1.25583246e-01f, 5.04616871e-02f, -1.03233010e-01f, 1.20350488e-01f, 1.16888486e-01f,
  -2.54232436e-02f, 6.97333738e-02f, -9.54703912e-02f, 9.75185260e-02f, 2.49410093e-01f, -2.69604661e-02f, -1.97300732e-01f, -1.02544829e-01f, 1.70325994e-01f, -2.97661096e-01f,
  1.87575012e-01f, 5.63623756e-02f, 3.46152782e-02f, -6.20635524e-02f, 3.74938883e-02f, -9.42202434e-02f, 6.92285970e-03f, 1.37647629e-01f, 1.69652566e-01f, 8.26680043e-04f,
  1.30294874e-01f, 8.82926676e-03f, 1.03610218e-01f, -6.39861226e-02f, -1.05276182e-02f, -9.18295160e-02f, 1.50512934e-01f, 3.95468101e-02f, 3.47698294e-02f, 3.64752896e-02f,
  9.88851674e-03f, 3.35719623e-02f, -2.29061380e-01f, 6.21277690e-02f, 1.70783401e-01f, -1.23571716e-01f, -1.65153034e-02f, -1.42417565e-01f, -1.28848448e-01f, 7.51170516e-02f,
  -2.08100587e-01f, 2.17678785e-01f, 1.89729407e-01f, -2.13740706e-01f, -3.23311910e-02f, 2.50605345e-01f, -1.19647577e-01f, 6.75497437e-03f, -9.96072069e-02f, 1.53095260e-01f,
  2.77092531e-02f, 2.08203793e-02f, 1.21620856e-01f, -3.47426325e-01f, 1.66895017e-01f, 1.39863029e-01f, 4.36605923e-02f, 1.10375606e-01f, -1.42413927e-02f, -2.92277224e-02f,
  -3.04897055e-02f, -1.44092113e-01f, -8.75326470e-02f, 2.86618639e-02f, -5.25740087e-02f, -1.24336042e-01f, -5.28704487e-02f, 8.08934271e-02f, 1.81477472e-01f, -5.96447363e-02f,
  4.19627838e-02f, -6.32867068e-02f, 7.45267794e-02f, 3.98605131e-02f, -2.90017319e-03f, 4.28504720e-02f, -3.99377663e-03f, 6.42903894e-02f, 2.00298820e-02f, 6.04705736e-02f,
  -9.03607979e-02f, -3.22549827e-02f, -1.79066975e-02f, 3.76132242e-02f, 4.99819731e-03f, -1.52572781e-01f, 9.46308374e-02f, -7.49912485e-02f, 4.54112561e-03f, 3.57942544e-02f,
  -9.57575068e-02f, 7.56304488e-02f, 1.44518390e-01f, -5.08552901e-02f, 2.73432154e-02f, 3.32999490e-02f, -8.43644813e-02f, -1.99233685e-02f, 4.05067727e-02f, 2.92214379e-03f,
  1.02634646e-01f, 1.33438677e-01f, 5.52614667e-02f, 1.62117630e-02f, -5.06559573e-02f, 8.68334994e-02f, -1.01737686e-01f, 8.97832308e-03f, -1.92873776e-01f, 3.34084556e-02f,
  -4.58053686e-02f, 1.36177108e-01f, -4.78500426e-02f, -6.01653792e-02f, 8.31531286e-02f, 1.47075057e-02f, -5.31782992e-02f, 1.01889163e-01f, 2.02818081e-01f, 6.52210601e-03f,
  -5.59626296e-02f, -5.03446385e-02f, -9.11457390e-02f, -7.27856979e-02f, -1.52051404e-01f, 8.13066736e-02f, -1.15158357e-01f, 1.43083751e-01f, -1.21231496e-01f, -5.09796850e-02f,
  4.89900261e-02f, -7.49109238e-02f, -7.38424668e-03f, -1.57731455e-02f, -1.32981585e-02f, -1.94432050e-01f, 1.56997275e-02f, -1.65758312e-01f, -1.44421402e-02f, -1.73185784e-02f,
  1.02048367e-01f, 1.81379840e-01f, 5.70909381e-02f, 6.51340485e-02f, -7.97530916e-03f, -5.71747078e-03f, -3.36038023e-02f, 3.10976822e-02f, -8.48196372e-02f, 7.48498365e-02f,
  -8.82188156e-02f, -4.35297303e-02f, 4.04947810e-02f, 3.78453471e-02f, 7.36482590e-02f, -5.52934073e-02f, 9.97273177e-02f, 4.16634791e-02f, -1.21154785e-02f, 1.24857776e-01f,
  -2.37132519e-01f, -1.68697014e-01f, 1.67822942e-01f, 7.68932840e-03f, 1.17089577e-01f, 1.53004646e-01f, -6.67289644e-02f, -1.69662423e-02f, 2.85816174e-02f, 1.73090305e-02f,
  -8.45672190e-02f, 1.57664865e-01f, 8.01147893e-02f, -1.06059894e-01f, 7.55697861e-02f, 1.70753703e-01f, 5.10715507e-02f, -2.40118697e-01f, 1.69110224e-02f, 2.10554779e-01f,
  -1.48873433e-01f, -1.46308437e-01f, 3.36206295e-02f, 1.08869456e-01f, 4.45465222e-02f, -1.52422428e-01f, 5.14864624e-02f, -9.85192135e-03f, 9.42625776e-02f, -1.11406274e-01f,
  4.94283736e-02f, 7.90391937e-02f, 2.20604390e-02f, -8.37322846e-02f, 1.50827225e-02f, 2.12205462e-02f, 3.88923548e-02f, -4.13935967e-02f, 2.54360531e-02f, 6.34266362e-02f,
  1.75318923e-02f, 1.99983101e-02f, 1.70135926e-02f, 3.47820073e-02f, 4.89790440e-02f, -2.22256631e-02f, -1.61660314e-02f, 5.46366423e-02f, 1.79042132e-03f, 3.17736678e-02f,
  -9.75475162e-02f, -1.02368249e-02f, -3.90004180e-02f, 2.43836213e-02f, 6.09732829e-02f, 7.81615749e-02f, 1.14208609e-01f, -1.36731444e-02f, -2.90579554e-02f, 1.54694499e-04f,
  3.51590402e-02f, 7.93908257e-03f, -4.14637588e-02f, 7.36576244e-02f, -1.58377609e-03f, 8.56020153e-02f, 8.92312173e-03f, 2.66794097e-02f, 1.23035975e-01f, -8.09046403e-02f,
  3.55111361e-02f, -9.92974043e-02f, -1.19009405e-01f, 5.19241057e-02f, 1.76112130e-01f, -2.35050474e-03f, -1.83153078e-02f, -5.28688394e-02f, -1.08182132e-02f, 1.58515051e-01f,
  -2.24090680e-01f, -1.13349065e-01f, -1.74179152e-01f, 6.68593124e-02f, -1.08103201e-01f, 3.14927325e-02f, 2.46262521e-01f, -4.00900170e-02f, 7.62837827e-02f, 8.93708989e-02f,
  -8.94446149e-02f, 9.81041119e-02f, -7.89601449e-03f, 8.12707841e-02f, 4.32842225e-03f, -1.30386965e-03f, 2.61093881e-02f, -1.10954024e-01f, 1.03569321e-01f, -9.27015033e-04f,
  -1.62064999e-01f, -6.20573163e-02f, 1.21792242e-01f, 9.67790037e-02f, -1.06326817e-02f, 1.74270824e-01f, -7.85914958e-02f, 9.14606526e-02f, -3.83328758e-02f, -7.01674372e-02f,
  -2.39741299e-02f, 1.83368027e-01f, 9.33921114e-02f, -9.67669785e-02f, 5.43546826e-02f, 9.11472961e-02f, -1.06018476e-01f, -2.62888893e-03f, -9.64923128e-02f, 4.24765497e-02f,
  9.22809169e-02f, -4.10911534e-03f, 3.16035305e-03f, -1.66269079e-01f, -1.09148726e-01f, -2.18531787e-02f, 6.78501427e-02f, -8.36505145e-02f, 2.30437234e-01f, -8.55967626e-02f,
  -1.88210595e-03f, 3.00090909e-01f, -1.26012400e-01f, -1.18294448e-01f, -6.24828227e-02f, 3.00193056e-02f, 2.09389254e-01f, -1.43892258e-01f, 9.33447704e-02f, 2.71609724e-01f,
  -1.69525668e-01f, -2.40863383e-01f, -3.91267873e-02f, -4.06321231e-03f, 1.34853318e-01f, -5.77218868e-02f, -2.31549844e-01f, -1.41895413e-01f, -1.87565908e-01f, -2.12451769e-03f,
  2.13596411e-02f, -2.82947719e-02f, 1.53591773e-02f, -1.08256228e-01f, 1.32023379e-01f, -6.39826879e-02f, -1.70963630e-02f, -6.90740943e-02f, -5.76420641e-03f, 1.51000813e-01f,
  7.84033537e-02f, 4.62618880e-02f, -9.18659940e-02f, -1.41795687e-02f, 8.72925073e-02f, 9.02787000e-02f, 9.32127163e-02f, 1.73491379e-03f, -9.91041809e-02f, -2.24554632e-03f,
  6.06330624e-03f, 7.93161395e-04f, 4.01669415e-03f, 2.86508705e-02f, -8.04772899e-02f, -1.10065855e-01f, -2.09448184e-03f, 4.43261527e-02f, -6.13124967e-02f, 4.03714031e-02f,
  -2.48618610e-02f, -1.04476452e-01f, 6.75956234e-02f, -5.60465902e-02f, -1.29282279e-02f, 8.85259360e-03f, -1.11162756e-03f, -2.74999198e-02f, 1.59878284e-02f, 7.81526119e-02f,
  4.65893634e-02f, -8.38684365e-02f, -1.42402854e-02f, -6.10196628e-02f, 7.45976791e-02f, 5.00249155e-02f, -2.33704094e-02f, -1.81734890e-01f, 1.32748336e-01f, -1.54634221e-02f,
  2.47373462e-01f, 3.80635844e-03f, 2.58267283e-01f, 1.85167461e-04f, 1.20047259e-03f, -1.07441351e-01f, 1.67532578e-01f, -2.05149339e-03f, -2.77144723e-02f, -3.39234397e-02f,
  -1.00734681e-01f, -3.56783122e-02f, -8.03371817e-02f, -3.53861786e-02f, 1.09597161e-01f, -8.86886045e-02f, 3.96454968e-02f, -3.81655730e-02f, -1.28446259e-02f, -8.78964216e-02f,
  -4.84969541e-02f, 9.33325663e-02f, 9.83428359e-02f, -9.48795453e-02f, 6.31167833e-03f, 7.45282769e-02f, 5.65822795e-02f, -8.44507292e-02f, -2.52615631e-01f, 3.23330495e-03f,
  7.17470199e-02f, -2.90754996e-03f, -7.08457455e-02f, 1.79410890e-01f, -6.63576201e-02f, -7.08672926e-02f, -9.43867937e-02f, 1.42162785e-01f, 5.42313326e-03f, 2.09870443e-01f,
  3.99569608e-02f, -6.65944070e-03f, -6.22218139e-02f, 1.89149100e-03f, 3.39507498e-03f, -7.61304200e-02f, -1.44233748e-01f, -5.95025532e-02f, 9.53448191e-02f, -5.98157048e-02f,
  4.01177108e-02f, 4.30294126e-03f, 7.29643553e-02f, -3.94501477e-01f, -6.61936328e-02f, -1.83525369e-01f, 1.02931827e-01f, 1.13923177e-02f, -3.28395851e-02f, 5.57066165e-02f,
  4.22706604e-02f, -7.43102878e-02f, 1.92619506e-02f, 5.45731597e-02f, -5.53099476e-02f, 1.35936767e-01f, -2.08049059e-01f, 2.97011714e-02f, 6.62118495e-02f, -1.34434417e-01f,
  7.74107501e-02f, 9.84923616e-02f, 5.19025400e-02f, 2.14411050e-01f, -1.11565478e-01f, -9.84979197e-02f, 8.80048349e-02f, 2.86517173e-01f, 3.80746350e-02f, 9.27225053e-02f,
  2.83145383e-02f, -1.35946408e-01f, 1.35481758e-02f, 8.87783766e-02f, -3.87564749e-02f, -1.20796286e-01f, 9.24895357e-05f, 8.84917974e-02f, 1.44282132e-01f, -2.58045048e-02f,
  2.17700657e-02f, -9.79876891e-02f, -3.71741578e-02f, 6.72385097e-02f, -6.83583915e-02f, -1.95623919e-01f, -6.07877225e-02f, -7.59931579e-02f, 4.23445180e-02f, 8.33675116e-02f,
  1.11313686e-02f, -1.49801120e-01f, 3.58450338e-02f, 1.71214286e-02f, 1.49600441e-02f, 8.40787366e-02f, 4.15338799e-02f, -9.75224376e-02f, 9.66449454e-02f, -1.00295886e-01f,
  -2.13227384e-02f, -2.03433465e-02f, 9.74647254e-02f, -2.33429801e-02f, -5.03043681e-02f, -8.30681026e-02f, -4.50419523e-02f, 8.48451555e-02f, -1.09600499e-01f, 5.04258163e-02f,
  1.74137335e-02f, 8.10426399e-02f, -1.04570679e-01f, -5.80815540e-05f, -1.10292390e-01f, 6.59827003e-03f, -5.49754780e-03f, 8.55417363e-03f, 8.48673806e-02f, -1.62730321e-01f,
  -1.38963461e-01f, -1.95098650e-02f, 9.05874223e-02f, -3.50317247e-02f, -2.12212369e-01f, 6.86675534e-02f, 5.34182414e-02f, 6.54456392e-02f, 3.84989493e-02f, -2.20295247e-02f,
  3.90216410e-02f, -5.35845235e-02f, 1.38098836e-01f, 2.44712774e-02f, 1.55034773e-02f, 1.89802274e-01f, -2.01185718e-02f, 5.01796678e-02f, 1.49684376e-03f, -4.07976396e-02f,
  -1.21506620e-02f, -5.39662316e-02f, -1.18777275e-01f, 3.12048327e-02f, -8.36065263e-02f, 9.83362272e-02f, -3.85430865e-02f, 5.08060958e-03f, -1.19324371e-01f, -6.21465184e-02f,
  -5.56777269e-02f, -1.51752289e-02f, -2.70164162e-02f, -1.23589441e-01f, 6.86309412e-02f, -6.13854527e-02f, -4.63435166e-02f, 2.85673589e-02f, 7.90435299e-02f, -9.11183506e-02f,
  4.15393673e-02f, -7.23477378e-02f, 8.43348280e-02f, 1.35543346e-01f, -7.94065744e-02f, 8.95702317e-02f, 5.31592518e-02f, -2.37944543e-01f, 1.36518151e-01f, -4.54208069e-02f,
  1.49839178e-01f, -2.37945784e-02f, 9.52745378e-02f, -4.88501787e-02f, 3.99119295e-02f, -1.31434694e-01f, 7.05266297e-02f, 4.08556759e-01f, 4.39219773e-02f, 4.81596291e-02f,
  4.36479561e-02f, 1.74158692e-01f, 8.43327269e-02f, -1.28272474e-01f, 3.56498510e-01f, 1.20167062e-01f, 2.41478495e-02f, 1.62827075e-02f, 1.76888183e-01f, 3.76656502e-02f,
  4.13495637e-02f, 6.15200363e-02f, -1.52569592e-01f, -1.57894835e-01f, -2.33494908e-01f, -2.66162127e-01f, 4.66038808e-02f, -1.12222664e-01f, -6.08483292e-02f, -1.42217735e-02f,
  -3.99534330e-02f, -2.34553553e-02f, -8.06454495e-02f, -1.64772049e-01f, -5.76470280e-03f, 1.51370447e-02f, -8.72951299e-02f, -4.91476282e-02f, -1.19399585e-01f, -7.88447186e-02f,
  9.60225239e-02f, -8.66656676e-02f, -1.90535784e-02f, 1.46362200e-01f, -4.30190563e-02f, 1.07599899e-01f, 8.22244957e-02f, 6.93959594e-02f, -3.02518606e-02f, -3.35792489e-02f,
  -1.39179919e-02f, -1.22777767e-01f, 3.51822786e-02f, -2.53538415e-03f, -3.42433341e-02f, -5.53289503e-02f, -1.44559667e-01f, 4.67421524e-02f, 5.21749295e-02f, 1.15230270e-01f,
  -7.02877268e-02f, -1.17285043e-01f, -6.97106495e-03f, -1.95305213e-01f, -1.26590533e-03f, 4.69995290e-02f, -1.01038247e-01f, -1.15523584e-01f, 5.77497669e-02f, -4.02792953e-02f,
  8.37090537e-02f, -2.00326070e-02f, 1.39618162e-02f, 1.58105288e-02f, 1.67857781e-02f, 1.16688833e-01f, 9.25394297e-02f, 3.22641479e-03f, 2.40873471e-02f, 1.12177968e-01f,
  -6.10386729e-02f, -4.70365696e-02f, -4.26723212e-02f, -2.02152357e-02f, 1.33757787e-02f, 3.77173536e-02f, 4.81670862e-03f, 4.97924164e-02f, 1.74808837e-02f, -7.55291283e-02f,
  1.32020667e-01f, 7.21183196e-02f, -7.37414276e-03f, -1.79355979e-01f, 8.20250437e-03f, -4.26261015e-02f, 2.51263790e-02f, 2.38932580e-01f, -1.85475638e-03f, 9.52747092e-02f,
  -5.63449226e-02f, -2.10318994e-02f, 1.22557990e-01f, 4.95048463e-02f, -9.25384387e-02f, -2.92460080e-02f, 5.39030395e-02f, -1.82711497e-01f, -1.22273095e-01f, -6.38076812e-02f,
  -5.83338784e-03f, -1.53056651e-01f, -1.56483483e-02f, 7.11321682e-02f, -4.80155610e-02f, 1.95719153e-01f, -9.11083817e-02f, -8.53208601e-02f, -5.26199630e-03f, 9.08985808e-02f,
  7.71802217e-02f, -6.14571385e-02f, -2.71810710e-01f, -9.68434066e-02f, -3.86664458e-02f, -3.42862420e-02f, -9.40221399e-02f, -1.21344589e-01f, 5.43338023e-02f, -3.37345272e-01f,
  -2.34070882e-01f, -6.37462139e-02f, -2.42123544e-01f, -1.63253143e-01f, 2.41279099e-02f, 1.74118191e-01f, 6.33410364e-02f, -1.43335583e-02f, 4.70237173e-02f, -9.35468301e-02f,
  5.91827743e-02f, -6.32535890e-02f, -3.06334376e-01f, 2.13712920e-03f, -5.49494065e-02f, -2.51793474e-01f, 7.58923888e-02f, 1.49506116e-02f, 2.70307604e-02f, -2.22648814e-01f,
  1.56481683e-01f, 2.78360676e-02f, 1.11039698e-01f, 1.78228706e-01f, 4.03125025e-02f, 8.69469345e-02f, 4.50423025e-02f, 7.71981757e-03f, 9.30313170e-02f, 1.02777973e-01f,
  -2.58591250e-02f, 1.04715198e-01f, -8.99033993e-03f, 9.61210206e-02f, 1.28775895e-01f, -6.21451982e-05f, 1.83307931e-01f, 2.02148616e-01f, -3.64958458e-02f, 5.44003174e-02f,
  -6.81992769e-02f, 5.05377501e-02f, 8.47705305e-02f, -6.83323434e-03f, -3.08571327e-02f, 6.01570448e-03f, 1.44586504e-01f, 5.97327165e-02f, 1.87308006e-02f, 1.39972568e-01f,
  3.40019651e-02f, -1.11562880e-02f, -4.51169237e-02f, -5.35529554e-02f, -7.29116276e-02f, -1.70650538e-02f, -2.72736158e-02f, 3.45415287e-02f, -4.03743517e-03f, -1.05356276e-01f,
  5.73101006e-02f, 8.19403026e-03f, 3.41392234e-02f, -4.78012301e-02f, -1.96322612e-02f, 5.01770526e-02f, 1.38668686e-01f, -2.85796318e-02f, 1.53981782e-02f, 8.96753743e-02f,
  5.76644903e-03f, 6.42116964e-02f, 6.62985891e-02f, 1.09629810e-01f, 3.93046625e-02f, -2.03236882e-02f, -1.61843479e-01f, -9.15389061e-02f, 1.08197935e-01f, -7.60640157e-03f,
  -5.51425852e-02f, -1.05329543e-01f, -2.87344512e-02f, 2.10383125e-02f, -2.03689837e-04f, 5.35418056e-02f, 1.12539805e-01f, -2.20081285e-01f, 1.82512730e-01f, 4.51894104e-02f,
  -4.30928618e-02f, 2.96677873e-02f, -1.38423920e-01f, 8.42409357e-02f, 4.73263226e-02f, -4.96477960e-03f, -4.41103913e-02f, -7.16915354e-03f, 6.43219054e-02f, -2.13254578e-02f,
  -8.39240626e-02f, 7.97374919e-02f, 1.31291196e-01f, 1.23658432e-02f, -1.22382097e-01f, -2.33760893e-01f, 4.83636670e-02f, -6.76648915e-02f, -3.94598991e-02f, -6.02689907e-02f,
  1.12302877e-01f, -7.21567124e-02f, -5.22519723e-02f, 9.70192924e-02f, -1.16997406e-01f, 6.94389716e-02f, 8.63607079e-02f, 5.47587872e-02f, -3.56511325e-02f, 8.19146261e-03f,
  7.40369130e-03f, 5.91828637e-02f, -1.03864856e-01f, -2.03493282e-01f, 1.48173481e-01f, 4.42907549e-02f, 5.05689234e-02f, 2.79873550e-01f, -7.16898299e-04f, 1.44064231e-02f,
  -4.61878302e-03f, -4.16014828e-02f, 1.96857437e-01f, 1.87132001e-01f, 5.69047928e-02f, 9.69319642e-02f, -1.18575059e-01f, 8.50140527e-02f, 1.61346450e-01f, 1.05118454e-02f,
  3.90191168e-01f, -1.67745993e-01f, -9.52907205e-02f, 1.42997233e-02f, -1.44539177e-01f, -1.09562359e-03f, 1.88848432e-02f, -1.05644159e-01f, -8.70680786e-04f, 2.81108655e-02f,
  3.43611799e-02f, -3.13445836e-01f, 9.65045094e-02f, -2.21975982e-01f, -4.18743566e-02f, -8.82839411e-03f, 1.37090143e-02f, 2.49146651e-02f, -1.38963550e-01f, 1.34132817e-01f,
  5.37658036e-02f, 7.51199648e-02f, -2.83980723e-02f, -9.60254017e-03f, -1.00349942e-02f, -5.97762987e-02f, -1.36724696e-01f, -3.00818291e-02f, 9.59862545e-02f, 4.23923619e-02f,
  1.16262607e-01f, -6.52764514e-02f, 1.13694265e-01f, 1.99411493e-02f, 2.72059198e-02f, -6.50868863e-02f, -1.30351990e-01f, 1.38401594e-02f, -8.56719986e-02f, 1.09655127e-01f,
  -1.83789283e-02f, -3.81822027e-02f, 4.13202710e-04f, 5.15493415e-02f, -9.03957486e-02f, 7.35811219e-02f, -1.07956547e-02f, -7.62456208e-02f, 6.57949075e-02f, -6.26341850e-02f,
  -7.03598000e-03f, -1.06474355e-01f, 4.44463529e-02f, 1.15080671e-02f, -3.08643952e-02f, 8.34190398e-02f, -1.22557804e-01f, -3.20470915e-03f, -9.96845588e-02f, 5.17801009e-02f,
  8.56137276e-02f, -2.28071567e-02f, -9.76289511e-02f, -7.40097165e-02f, 5.76306470e-02f, -3.57191525e-02f, -9.55861360e-02f, 6.93503767e-02f, 7.69898370e-02f, -3.57101448e-02f,
  6.54636547e-02f, 4.52052131e-02f, 3.59114408e-02f, -3.56367715e-02f, 4.86848317e-02f, -1.39717251e-01f, 4.66665737e-02f, -6.86607435e-02f, 4.68565002e-02f, 1.51614724e-02f,
  9.75575522e-02f, 6.67838827e-02f, 2.71297339e-02f, 1.61672145e-01f, -5.15049770e-02f, 2.91744228e-02f, 9.85409170e-02f, -2.45743264e-02f, -4.26190197e-02f, 6.31441697e-02f,
  5.79046719e-02f, 1.23181395e-01f, 1.48361683e-01f, 8.56041983e-02f, -1.08161628e-01f, 2.17916798e-02f, -2.12075919e-01f, -1.68291911e-01f, -7.82224014e-02f, -5.72533160e-02f,
  -4.57792208e-02f, 4.60606143e-02f, -4.58075479e-02f, -5.72080398e-03f, -9.95562896e-02f, -1.05925150e-01f, -1.13555759e-01f, -2.51254052e-01f, 1.98551472e-02f, -2.33752280e-01f,
  -3.33061010e-01f, 1.67360768e-01f, -4.68730032e-02f, 3.87811363e-02f, -4.39888313e-02f, 7.36228656e-04f, -1.26041295e-02f, -6.04536831e-02f, 1.72176898e-01f, -2.32667044e-01f,
  2.01204587e-02f, 1.06827401e-01f, -9.44230258e-02f, -1.06436107e-02f, -1.04519039e-01f, -6.62880912e-02f, 1.13912612e-01f, -1.77249655e-01f, 2.25567333e-02f, 9.85670984e-02f,
  -1.83577448e-01f, -7.54995719e-02f, -1.24999560e-01f, 3.16307321e-02f, 1.15636572e-01f, 1.70572400e-01f, 3.32187682e-01f, -2.63654832e-02f, -4.72268695e-03f, -7.36912116e-02f,
  -3.53435762e-02f, 1.36165053e-01f, -4.10197116e-03f, 9.73985717e-02f, -1.56026445e-02f, 6.64479146e-03f, 9.88322496e-03f, -5.91531210e-02f, -9.64377150e-02f, 6.57784566e-02f,
  -1.67563055e-02f, -2.69472413e-02f, 2.11690608e-02f, -8.49516913e-02f, 7.73340231e-03f, -2.53480859e-02f, -1.08577915e-01f, 2.57335678e-02f, 2.89118290e-02f, 8.76331180e-02f,
  -3.53272930e-02f, 8.60793795e-03f, 1.06864488e-02f, 7.76105598e-02f, 3.88598926e-02f, 6.87620565e-02f, 3.99038084e-02f, -6.58497587e-02f, -4.92725857e-02f, -4.85169552e-02f,
  -8.05513039e-02f, -3.83058861e-02f, -7.40238726e-02f, -9.23030451e-02f, -1.52376574e-02f, 1.29917124e-02f, -9.92146134e-02f, -6.49134815e-02f, -4.96169413e-03f, 4.12021913e-02f,
  -1.98519919e-02f, -4.24414761e-02f, -1.23198014e-02f, -1.34715199e-01f, -3.32087465e-02f, -1.80724233e-01f, -3.97390798e-02f, -1.39584661e-01f, 9.99036133e-02f, 1.97160527e-01f,
  2.56861225e-02f, 2.61679608e-02f, 4.48697209e-02f, -8.11773632e-03f, -8.70416388e-02f, 3.92873846e-02f, 6.84576407e-02f, 6.04002252e-02f, -1.78320840e-01f, 1.07270759e-02f,
  5.02720512e-02f, -1.03905328e-01f, -4.50610444e-02f, 1.81956198e-02f, 2.79367756e-04f, 2.22435370e-02f, 3.30411829e-02f, -1.35032237e-01f, 4.76705423e-03f, -1.27738103e-01f,
  -7.89420679e-02f, -2.97929764e-01f, 8.26737434e-02f, -2.00596657e-02f, -4.51505650e-03f, 3.88044193e-02f, 1.63014363e-02f, -2.43205819e-02f, -3.65633294e-02f, 1.12201743e-01f,
  -1.34919584e-01f, -6.28685281e-02f, -1.47452652e-01f, -1.09172679e-01f, 9.63999927e-02f, 6.38647601e-02f, 4.31876183e-02f, 7.93138742e-02f, 5.38479686e-02f, -9.83660519e-02f,
  1.29221424e-01f, 4.21435572e-02f, 2.20747031e-02f, 2.87708193e-02f, 4.77693975e-02f, 1.49923414e-01f, 8.99770558e-02f, -2.32465751e-02f, 2.06404701e-01f, -9.74208042e-02f,
  8.71734843e-02f, -1.85113177e-01f, 2.09690677e-03f, 1.46837965e-01f, 2.00091079e-02f, 1.39611736e-01f, -6.40249327e-02f, 1.42523944e-02f, 2.74816062e-02f, -2.87214160e-01f,
  1.04430579e-01f, 5.17130010e-02f, 1.67081565e-01f, -1.90677196e-01f, -3.62781465e-01f, 2.34372616e-01f, 6.36812821e-02f, 1.88914984e-01f, -9.86156911e-02f, -3.61136794e-02f,
  -6.44776300e-02f, -2.57735066e-02f, 9.44001675e-02f, -1.03404328e-01f, -3.27147275e-01f, 6.32982701e-02f, -5.75018711e-02f, 1.08455636e-01f, -7.11832941e-02f, -1.94442779e-01f,
  -1.03910930e-01f, -1.50704592e-01f, -1.11633129e-01f, 5.77960387e-02f, -7.51941502e-02f, 9.21043232e-02f, -9.53973271e-03f, -8.05407017e-02f, -1.10946715e-01f, -5.47060184e-02f,
  -5.93389794e-02f, -2.80905981e-02f, -1.01518258e-01f, 8.80387202e-02f, 5.27797639e-02f, 3.20123620e-02f, -3.47746424e-02f, 6.60787383e-03f, 1.00999363e-01f, 1.45890173e-02f,
  -1.16621353e-01f, 6.36700019e-02f, -1.28484175e-01f, 4.26761806e-02f, 8.44609067e-02f, -4.55588140e-02f, -5.62763251e-02f, -1.06176808e-01f, 8.12326521e-02f, 4.69963625e-02f,
  -7.90445805e-02f, -3.02708559e-02f, -1.22262873e-02f, -1.12728797e-01f, 6.39814287e-02f, -5.23605617e-03f, -6.22309744e-02f, -1.22774221e-01f, 5.01617603e-02f, 5.95912104e-03f,
  3.13311480e-02f, 1.19338021e-01f, -2.62475461e-02f, -7.72129605e-03f, 2.02921815e-02f, 1.51797861e-01f, -1.25537738e-01f, -5.99253401e-02f, -6.63487911e-02f, -1.52324047e-02f,
  -1.21035427e-02f, -4.67328392e-02f, 1.71186060e-01f, 2.40579713e-02f, 1.60925716e-01f, 2.06871796e-02f, 2.82558743e-02f, 1.50768394e-02f, -7.22317472e-02f, 4.43287492e-02f,
  7.52862021e-02f, -2.18103696e-02f, -5.58184944e-02f, 4.81556728e-02f, 6.12630174e-02f, 6.37935847e-02f, -4.14784206e-03f, 1.38993129e-01f, 4.47712131e-02f, 6.65173531e-02f,
  -3.43245082e-02f, -3.01813222e-02f, 1.67448342e-01f, -2.44966894e-02f, 8.90917182e-02f, 8.59067142e-02f, 1.16863191e-01f, 6.44276515e-02f, 3.28212678e-02f, -5.42755239e-02f,
  1.56657815e-01f, 2.72338446e-02f, 4.55762111e-02f, -8.28535408e-02f, 5.45587465e-02f, 8.58021621e-03f, 9.72732063e-03f, 6.99098408e-02f, -3.44802551e-02f, -6.52458295e-02f,
  -1.15277395e-01f, -1.61268532e-01f, 2.08284054e-03f, -1.04893759e-01f, 1.46426074e-02f, -1.52183652e-01f, -2.41825089e-01f, 7.54882172e-02f, 1.61953387e-03f, 1.33432806e-01f,
  3.65755409e-02f, -2.38493783e-04f, -3.84236947e-02f, 2.27202624e-02f, 1.37160420e-01f, -9.77876857e-02f, 2.03244269e-01f, -2.34221265e-01f, 6.91515505e-02f, -1.13408394e-01f,
  2.70080063e-02f, -2.93685108e-01f, 2.68673658e-01f, 1.94685951e-01f, 1.33788452e-01f, -7.12077692e-02f, -8.47795904e-02f, 1.87143192e-01f, -1.06077872e-01f, 7.76152089e-02f,
  3.30274850e-02f, 2.80912578e-01f, 3.51732939e-01f, 1.05943136e-01f, 2.29390383e-01f, 1.70347497e-01f, -7.03503704e-03f, -8.97243097e-02f, 4.18284955e-03f, 2.61004847e-02f,
  -7.13621750e-02f, -7.13469684e-02f, -2.34920233e-01f, -1.11772992e-04f, 2.39529070e-02f, -3.29483449e-02f, -5.43105528e-02f, -1.96934156e-02f, -8.40444863e-02f, -5.75619750e-02f,
  4.72662933e-02f, 2.19439976e-02f, -1.83735900e-02f, -5.39945215e-02f, -6.52729198e-02f, 1.04309641e-01f, 3.66080217e-02f, -9.48040187e-02f, 1.67473964e-02f, 4.71740179e-02f,
  8.42993483e-02f, -3.66926682e-03f, -9.85316709e-02f, 6.17525727e-02f, 9.53981206e-02f, 7.09515363e-02f, 1.43105648e-02f, -8.10472816e-02f, 3.24001871e-02f, 4.78405096e-02f,
  -6.06135167e-02f, 4.70093749e-02f, 1.54832436e-03f, -1.03094615e-01f, -1.00349277e-01f, -5.42107932e-02f, -8.29620510e-02f, -4.51549366e-02f, 3.95468101e-02f, 2.84016635e-02f,
  7.99479149e-03f, -4.89420444e-02f, -1.09473012e-01f, 9.08037473e-04f, 1.02816716e-01f, 1.28202602e-01f, -6.46448955e-02f, 1.58624426e-01f, 6.94534853e-02f, -3.52342497e-03f,
  -1.67154819e-01f, 5.92803247e-02f, -3.29770558e-02f, 1.53243825e-01f, -1.51403785e-01f, 1.62843093e-01f, 1.67874083e-01f, -4.19831574e-02f, -1.73165083e-01f, 1.53291285e-01f,
  -2.57458203e-02f, -4.58877459e-02f, -1.16997197e-01f, 8.90535787e-02f, -9.48226545e-03f, -8.08704793e-02f, -1.25209838e-01f, 1.65921211e-01f, 3.01067960e-02f, -3.94903012e-02f,
  -5.14578521e-02f, -2.71880273e-02f, -1.19989559e-01f, 6.30300045e-02f, -1.12743475e-01f, 1.29518494e-01f, 8.73915255e-02f, -3.07741091e-02f, -1.28252164e-01f, 7.51334950e-02f,
  1.10423211e-02f, -7.83686042e-02f, 3.58030312e-02f, -7.77226537e-02f, -3.25796492e-02f, -2.48872787e-01f, 6.65233135e-02f, 5.88384941e-02f, 3.55559811e-02f, -8.86012018e-02f,
  -7.51034245e-02f, 1.76410049e-01f, 1.76171377e-01f, 2.62280013e-02f, 1.95925355e-01f, 1.88738294e-02f, -5.94877899e-02f, -7.58802071e-02f, -1.39890075e-01f, 1.63504943e-01f,
  -9.48414281e-02f, -1.65081173e-01f, -9.37160775e-02f, -2.09944382e-01f, 1.92466438e-01f, 5.42104803e-02f, -6.22624271e-02f, 1.44488707e-01f, -1.30852595e-01f, 4.34203409e-02f,
  3.32032144e-02f, 1.87803179e-01f, 2.07706373e-02f, 2.29643181e-01f, -6.17718846e-02f, -1.34828523e-01f, -6.41080141e-02f, -2.04829387e-02f, 9.50571895e-02f, 1.16022015e-02f,
  1.91353470e-01f, 7.82332122e-02f, 1.09295651e-01f, 9.95741338e-02f, 1.68079641e-02f, 2.00062916e-01f, 2.55142041e-02f, 2.68091857e-02f, -2.81918645e-02f, 1.25018388e-01f,
  9.84984264e-03f, 8.66407380e-02f, -8.85369033e-02f, 1.77511275e-02f, 1.14362970e-01f, -6.51426911e-02f, 1.50515959e-01f, 2.96648871e-02f, -1.03705628e-02f, 8.60129595e-02f,
  -9.50936507e-03f, 1.18682027e-01f, 5.53735048e-02f, 9.34859812e-02f, 4.66679633e-02f, 6.74688742e-02f, 4.01935019e-02f, 1.67496316e-02f, 7.49887228e-02f, 1.19559370e-01f,
  1.76795796e-02f, -7.46237412e-02f, 2.16350835e-02f, -1.65973846e-02f, -2.69076005e-02f, 9.42908227e-02f, 3.87437195e-02f, 7.54667539e-03f, 8.05657208e-02f, 7.46189803e-02f,
  2.79668625e-02f, -6.36893213e-02f, 6.10192940e-02f, 9.30601135e-02f, 4.48901765e-02f, 4.21593562e-02f, -9.12175234e-03f, -3.31206131e-04f, -1.13282097e-03f, -5.72748017e-03f,
  2.28895666e-03f, -6.88169226e-02f, 5.30292792e-03f, 6.40174821e-02f, 2.04875004e-02f, 1.44771814e-01f, 1.00706993e-02f, 2.24150140e-02f, 4.16351259e-02f, -6.40453994e-02f,
  3.37955654e-02f, -1.06574722e-01f, -5.75831495e-02f, 1.76838785e-02f, 1.71828851e-01f, 6.78051338e-02f, 1.04584835e-01f, 3.38869765e-02f, 1.26647443e-01f, 1.96848154e-01f,
  -3.78304836e-03f, -1.01337276e-01f, -1.58482175e-02f, -2.90494431e-02f, -4.15338166e-02f, -3.73038277e-02f, -4.91344184e-03f, 6.41371533e-02f, -1.63450703e-01f, -1.20626008e-02f,
  1.18106000e-01f, 1.01462513e-01f, 1.45479040e-02f, 1.28624300e-02f, -2.54246622e-01f, -2.24871859e-01f, -7.04303905e-02f, -3.11597496e-01f, 7.30802491e-02f, 1.58247184e-02f,
  2.39710230e-02f, 1.22122772e-01f, 1.44721597e-01f, 8.12030509e-02f, 5.50696887e-02f, -8.60059559e-02f, 1.17250763e-01f, 3.30412164e-02f, 6.00804985e-02f, -1.14700213e-01f,
  -5.23546711e-03f, 3.06445211e-02f, 2.32813861e-02f, -6.76555708e-02f, 1.98262438e-01f, 5.55874147e-02f, 1.89955860e-01f, 5.19072302e-02f, 1.78969279e-02f, 1.71700060e-01f,
  -2.02268809e-01f, 7.02336356e-02f, 2.10900217e-01f, 2.26203099e-01f, 5.48032187e-02f, -2.59259921e-02f, -3.00425831e-02f, 2.57972240e-01f, -5.26879430e-02f, 1.23909920e-01f,
  -8.26240424e-03f, -1.70517311e-01f, 4.61919606e-03f, 1.17375515e-02f, 4.26530465e-02f, -2.60036103e-02f, -2.39362508e-01f, -1.80815250e-01f, -1.31140072e-02f, 2.15285048e-01f,
  -4.72848397e-03f, -2.55122781e-01f, 1.14542425e-01f, 1.02509499e-01f, 1.02758091e-02f, -2.87963878e-02f, -7.01563945e-03f, 9.93065387e-02f, -6.83921110e-03f, 1.02144249e-01f,
  -3.26116830e-02f, -2.42016688e-02f, 1.62848365e-02f, -5.64770140e-02f, -1.45484790e-01f, 7.88275674e-02f, 2.83434172e-03f, 5.19368276e-02f, 9.99534503e-02f, 1.22371890e-01f,
  -2.42056716e-02f, -1.02909401e-01f, -5.24547882e-02f, 6.43673465e-02f, -2.42301896e-02f, 3.79062593e-02f, -1.25534475e-01f, 4.35520038e-02f, -2.47433167e-02f, 1.42780781e-01f,
  -3.43668386e-02f, 4.24059592e-02f, 1.71089917e-02f, -4.83784080e-02f, -3.43025997e-02f, 5.03877103e-02f, 1.14925295e-01f, -1.74928814e-01f, 3.71609852e-02f, -3.64303403e-02f,
  4.55317423e-02f, -3.66822630e-02f, 2.60344055e-02f, 1.04941003e-01f, 1.62489295e-01f, -6.03368971e-03f, -1.76363453e-01f, 1.56405158e-02f, 6.25377819e-02f, 1.03990242e-01f,
  1.38368204e-01f, -3.96617875e-02f, -1.65943224e-02f, -6.61768988e-02f, -2.88659800e-03f, -3.39676328e-02f, 8.06302428e-02f, 7.21217170e-02f, -1.84675172e-01f, -7.49580339e-02f,
  -4.86291759e-03f, -2.95997262e-02f, -1.95509270e-01f, -7.35633122e-03f, -6.86537176e-02f, -1.23014703e-01f, -5.04934750e-02f, -1.52342217e-02f, 4.93058637e-02f, -5.25174364e-02f,
  -1.08472176e-01f, 4.09061387e-02f, 9.41518396e-02f, 5.66304959e-02f, -1.19724013e-01f, -4.19844799e-02f, -6.73539098e-03f, -6.85621798e-02f, 5.18659949e-02f, 1.07650660e-01f,
  -3.89049985e-02f, -7.78518841e-02f, 8.72114748e-02f, -1.44982681e-01f, -6.85570315e-02f, -2.46125702e-02f, -6.06864206e-02f, 3.80768292e-02f, -1.06993884e-01f, -6.73354417e-02f,
  -8.34526792e-02f, 4.64817472e-02f, -1.29086187e-03f, 7.99699351e-02f, -3.99751738e-02f, -1.11835495e-01f, 5.59342764e-02f, -2.42273174e-02f, -1.20231643e-01f, 3.78253497e-02f,
  -5.06776460e-02f, -3.86322401e-02f, 5.61551936e-02f, 7.05612451e-02f, 1.19716503e-01f, 2.35577852e-01f, 7.00096712e-02f, -1.31899863e-01f, 2.77775317e-01f, -7.77827799e-02f,
  1.18533662e-02f, -1.81754958e-02f, -6.61609098e-02f, -7.24015757e-03f, 6.08279966e-02f, 1.21852428e-01f, 3.62181887e-02f, -2.01232299e-01f, -2.41688326e-01f, -6.45384789e-02f,
  -1.49093363e-02f, -1.17518120e-01f, 9.46253017e-02f, 1.56097263e-01f, -1.93692278e-02f, -1.57552987e-01f, 7.99898058e-02f, -3.41374613e-02f, -2.27304757e-01f, -2.44511608e-02f,
  1.42169753e-02f, -1.35424510e-01f, 1.20450526e-01f, 4.07323465e-02f, 9.38407108e-02f, -5.14780451e-03f, 4.01830226e-02f, 6.56186836e-03f, -7.16410112e-03f, 2.55655739e-02f,
  1.95201263e-02f, 1.56409323e-01f, 6.04983792e-03f, 4.99899685e-02f, -5.81166074e-02f, -2.40631940e-04f, -5.93247376e-02f, -3.05870548e-02f, -9.06316712e-02f, -1.00982348e-02f,
  -1.41846299e-01f, -1.89601585e-01f, 7.45931640e-02f, -6.37710094e-02f, 4.34017740e-03f, -4.09568623e-02f, 1.22386469e-02f, 9.99841932e-03f, 8.14904347e-02f, -3.84686589e-02f,
  8.06877464e-02f, 2.47057695e-02f, -1.57965109e-01f, -4.35336605e-02f, 5.33440486e-02f, -1.29924402e-01f, 3.05294190e-02f, 8.34287331e-02f, -1.26003861e-01f, -8.99671391e-02f,
  4.28851657e-02f, 2.54310761e-02f, -2.76761595e-02f, -3.68330143e-02f, 1.52747601e-01f, -1.16845174e-02f, 1.63333900e-02f, -3.29922363e-02f, -6.41204743e-03f, -7.11378306e-02f,
  5.78076765e-02f, -3.27310897e-02f, 5.70915639e-03f, 1.48414537e-01f, -2.38865335e-02f, 5.22383768e-03f, 1.09841935e-01f, -2.97642052e-02f, 2.12331824e-02f, -2.06589643e-02f,
  3.02273650e-02f, -2.36563962e-02f, -3.25165652e-02f, 3.07278242e-03f, -2.05982029e-01f, 3.22202221e-02f, -3.67036127e-02f, 3.21350358e-02f, -1.09494962e-01f, -3.10712382e-02f,
  -1.25471979e-01f, -1.75177768e-01f, 1.40389264e-01f, -6.55172989e-02f, -5.58820143e-02f, -4.11247797e-02f, -9.31827538e-03f, -1.13758802e-01f, 8.17820139e-04f, 1.99083574e-02f,
  1.59144863e-01f, 1.98581561e-01f, 9.47405174e-02f, -1.97929982e-02f, 1.52951136e-01f, 9.90346074e-02f, 3.38945538e-02f, 1.27200959e-02f, -8.10512677e-02f, -1.00191757e-01f,
  -6.89641684e-02f, 1.65561348e-01f, -9.20706093e-02f, 1.10611834e-01f, 3.98347601e-02f, 8.15995932e-02f, 1.52640849e-01f, 1.06768087e-01f, 6.42578378e-02f, 7.32369795e-02f,
  -5.89583591e-02f, 1.72543764e-01f, 4.58536558e-02f, -8.44137669e-02f, 1.97474249e-02f, 1.00374892e-01f, 3.62230763e-02f, -1.31962329e-01f, 4.43418398e-02f, -3.47841293e-01f,
  1.17160752e-01f, 4.74507883e-02f, 1.10400580e-02f, -2.59898994e-02f, 1.84651881e-01f, 1.46377474e-01f, -1.12422526e-01f, 5.42173125e-02f, -1.49661126e-02f, 2.96914071e-01f,
  4.58425991e-02f, 1.51936531e-01f, 4.70833778e-02f, 1.18564017e-01f, -1.01812318e-01f, -2.54719377e-01f, 5.27096204e-02f, 1.23474173e-01f, 4.53289039e-02f, -1.70957297e-02f,
  -6.10619932e-02f, 3.89010906e-02f, -1.05159041e-02f, 7.82116130e-02f, 2.64730286e-02f, 1.30602956e-01f, -1.43886107e-04f, 6.94415495e-02f, -4.91555594e-03f, -2.90473783e-03f,
  6.13700263e-02f, 5.92592768e-02f, -3.80683839e-02f, -2.88468450e-02f, 3.11518367e-02f, -1.47838622e-01f, 4.63434607e-02f, -1.12994313e-01f, -7.98045769e-02f, 9.40570608e-03f,
  5.46351969e-02f, 8.18030909e-02f, 3.31382528e-02f, 9.42114666e-02f, -9.32419486e-03f, -5.78903314e-03f, -3.85857224e-02f, 4.23742086e-02f, 1.15507953e-01f, -2.10502259e-02f,
  -3.23780514e-02f, -2.18864977e-02f, -7.84033462e-02f, -4.86505739e-02f, -1.25372475e-02f, -3.00910119e-02f, -8.73657465e-02f, 1.80734470e-02f, 8.98675844e-02f, -7.80002698e-02f,
  1.23043098e-02f, -1.06466770e-01f, -1.18228436e-01f, -3.61336172e-02f, -1.76342484e-02f, -4.95967306e-02f, -1.06369816e-01f, -3.75666879e-02f, 2.63129119e-02f, -1.26191795e-01f,
  -4.64076251e-02f, -2.21821040e-01f, 3.56238186e-02f, -2.31514145e-02f, -1.16788588e-01f, -2.30075326e-02f, -3.22551765e-02f, -8.67920145e-02f, -2.88770329e-02f, 2.87607200e-02f,
  1.65134981e-01f, -1.50239080e-01f, -1.55157700e-01f, -6.67203590e-02f, -9.98040885e-02f, 1.62057593e-01f, 1.05372906e-01f, 1.43304154e-01f, 1.66432485e-01f, 2.55952962e-02f,
  1.29739083e-02f, -7.17816278e-02f, 2.86969095e-01f, -4.21276875e-02f, -1.42965078e-01f, 3.48221026e-02f, 9.28751528e-02f, 6.22389019e-02f, -1.18575133e-01f, 1.18778817e-01f,
  1.14666060e-01f, 1.35215461e-01f, -9.44784880e-02f, 1.07540309e-01f, 7.05195032e-03f, -2.15735175e-02f, -1.74729884e-01f, -3.10370438e-02f, -4.91092578e-02f, 1.48549959e-01f,
  -4.22557294e-02f, -6.24138042e-02f, 7.17281457e-03f, -1.23591222e-01f, 7.14943111e-02f, -2.53266525e-02f, -4.22541052e-02f, -5.17135039e-02f, 2.68184915e-02f, 9.19371564e-03f,
  -1.72016528e-02f, 2.60508537e-01f, 1.63677692e-01f, 1.34824455e-01f, 1.09981960e-02f, 4.03253809e-02f, -2.27267027e-01f, -2.71647088e-02f, -5.48387552e-03f, -1.17331862e-01f,
  -1.02350563e-02f, 6.49625808e-02f, -1.59673348e-01f, 3.66641879e-02f, 3.33131671e-01f, -2.04458073e-01f, 2.83614569e-03f, 2.02338949e-01f, -4.42444682e-02f, -1.72847539e-01f,
  -1.28371745e-01f, 3.18316758e-01f, 1.35318577e-01f, 1.11790493e-01f, 1.37525171e-01f, -1.51131570e-01f, -9.46895685e-03f, -1.48409992e-01f, -2.77347472e-02f, -9.75334346e-02f,
  8.69472027e-02f, -6.16054311e-02f, 2.82936022e-02f, 1.87983923e-02f, -6.69835657e-02f, -2.81291660e-02f, -1.53022751e-01f, 7.97605440e-02f, -9.53389481e-02f, -5.05035184e-02f,
  -8.85274038e-02f, 5.71146868e-02f, -3.58859589e-03f, -3.26634981e-02f, -7.84553960e-02f, -6.36447892e-02f, 5.49049303e-03f, 1.59498647e-01f, 1.00507714e-01f, 8.03730562e-02f,
  -8.79091397e-02f, 2.13187393e-02f, -5.40827923e-02f, 5.33893220e-02f, -5.28424531e-02f, -5.47417887e-02f, -2.46404633e-02f, 4.04647272e-03f, -5.12328707e-02f, -1.00399842e-02f,
  -1.28995553e-02f, 7.69760087e-02f, -3.85158248e-02f, -1.89721733e-02f, 5.16220033e-02f, 6.99125752e-02f, -1.01565130e-01f, -4.46762368e-02f, 9.11739003e-03f, 8.01432356e-02f,
  7.75582120e-02f, 3.05553582e-02f, -9.60292120e-04f, -1.45191073e-01f, 5.79269975e-02f, -7.22648352e-02f, 4.25680131e-02f, 2.70916540e-02f, 1.72418579e-01f, -4.63678390e-02f,
  -4.23666276e-02f, -4.21755761e-03f, 1.94061268e-02f, -2.13002022e-02f, -1.05502434e-01f, -4.27931249e-02f, -2.21847355e-01f, -5.36133759e-02f, -1.05367854e-01f, 1.39018195e-02f,
  -9.00079831e-02f, -1.63536936e-01f, 1.12749696e-01f, -6.76432401e-02f, -9.63584855e-02f, -7.63258189e-02f, 3.35030705e-02f, 5.79110049e-02f, 4.86017391e-02f, -1.67851955e-01f,
  -1.35216136e-02f, 1.24771178e-01f, 6.83854073e-02f, -1.37712821e-01f, -1.00766830e-01f, 3.98717336e-02f, 2.05130413e-01f, 1.90015778e-01f, -4.92152870e-02f, 2.21623242e-01f,
  -5.99503331e-02f, 4.27965485e-02f, -1.12687863e-01f, -6.90794513e-02f, -8.13618302e-02f, -2.57566143e-02f, 7.87137002e-02f, 1.85419489e-02f, 4.43420447e-02f, 7.07642287e-02f,
  -3.07261143e-02f, -9.64524597e-03f, -6.93568587e-02f, -7.88883585e-03f, 1.35395989e-01f, -6.94232583e-02f, -2.54733823e-02f, -1.08306251e-01f, 8.32466260e-02f, 2.01541502e-02f,
  5.80228157e-02f, -9.09357443e-02f, 2.67223511e-02f, 3.35572078e-03f, -1.90613106e-01f, -1.39752463e-01f, -6.33929744e-02f, 3.14562954e-02f, 1.55623004e-01f, 4.55324091e-02f,
  -1.83005109e-01f, 7.90464655e-02f, -2.75352538e-01f, 1.54469788e-01f, 1.97358932e-02f, -1.41409010e-01f, -3.72589454e-02f, 9.90855619e-02f, 1.17197290e-01f, 4.14435714e-02f,
  -1.98488772e-01f, -2.18613341e-01f, -3.51752378e-02f, 3.75612229e-01f, -3.11655793e-02f, -3.02111115e-02f, -2.56547388e-02f, -8.59825388e-02f, -9.13932547e-02f, -7.19882175e-03f,
  -2.48984322e-02f, -1.31197721e-01f, -1.47942370e-02f, -4.46547419e-02f, -3.11988480e-02f, 3.22502404e-02f, 4.95812809e-03f, -4.78933938e-02f, 1.12276375e-01f, -2.60655805e-02f,
  -4.44711931e-02f, -6.49670213e-02f, -2.97353748e-04f, 4.79261614e-02f, -7.95755535e-02f, -2.74676867e-02f, 6.66006804e-02f, 1.54378638e-02f, 1.72997005e-02f, -3.35945785e-02f,
  -5.43970726e-02f, 8.60420242e-02f, 9.07066390e-02f, 8.01042989e-02f, 4.26477753e-02f, 5.37640490e-02f, -3.90936770e-02f, 2.79732179e-02f, 1.64361168e-02f, 5.24892695e-02f,
  -5.53148985e-02f, -2.95767393e-02f, -1.49093438e-02f, 9.37656388e-02f, -1.58650354e-01f, 4.21991125e-02f, -4.03574966e-02f, -3.30358138e-03f, -6.44214600e-02f, 1.80036388e-02f,
  -9.37386379e-02f, -7.32547417e-03f, -3.31066549e-02f, -1.10298106e-02f, -5.21325544e-02f, 8.85766223e-02f, 8.43990818e-02f, -2.13615764e-02f, -7.39920735e-02f, -7.38521665e-02f,
  1.32975355e-01f, -6.07435703e-02f, -6.40074313e-02f, -1.10343553e-01f, 1.15415752e-01f, -2.60525825e-03f, 2.55431682e-02f, -9.46426317e-02f, 9.62878987e-02f, 4.88623865e-02f,
  -4.90613393e-02f, -3.62439044e-02f, 5.46243861e-02f, -4.95862477e-02f, 2.00359728e-02f, 1.59044087e-01f, 1.18687935e-01f, 4.12737802e-02f, 1.99724026e-02f, -7.48464316e-02f,
  4.98640584e-03f, 6.42216727e-02f, -2.83321068e-02f, 3.20916995e-02f, -4.96823005e-02f, -1.83555052e-01f, -6.34368211e-02f, -2.91403141e-02f, -5.43893427e-02f, -1.28074199e-01f,
  8.72093588e-02f, 7.54018053e-02f, -7.27980584e-02f, 1.89900726e-01f, -7.96397775e-03f, -7.78520778e-02f, 4.65637706e-02f, -3.54601741e-02f, 1.00376628e-01f, -1.88206822e-01f,
  -1.02952823e-01f, -4.31129634e-02f, -4.55907136e-02f, 1.04194239e-01f, -2.33640820e-02f, 6.76302472e-04f, -9.32273734e-03f, 2.69060489e-02f, -1.48585811e-01f, -1.67830829e-02f,
  -1.04002796e-01f, 5.47316344e-03f, -7.56499395e-02f, 2.93313891e-01f, -1.23210952e-01f, -8.78087524e-03f, -1.20821735e-03f, 6.01920821e-02f, -2.03299597e-01f, -1.05295762e-01f,
  -3.02893192e-01f, -7.52796070e-04f, 1.70731783e-01f, -2.46878624e-01f, 1.38957262e-01f, 2.24576499e-02f, -1.54718347e-02f, -1.77924871e-01f, 1.52440593e-01f, 2.35030636e-01f,
  6.18342571e-02f, 1.95990168e-02f, -3.26077789e-02f, -7.49708116e-02f, -2.37161927e-02f, -4.84691225e-02f, -3.39308493e-02f, 1.31459653e-01f, -4.47974652e-02f, -3.74754034e-02f,
  8.25533122e-02f, -3.34679708e-03f, -6.02204502e-02f, -1.53250946e-02f, -3.82330194e-02f, -4.19428609e-02f, 1.27124451e-02f, 1.90577991e-02f, -2.21074801e-02f, -8.00701231e-02f,
  1.36337131e-01f, -1.55419257e-04f, -4.86978516e-02f, -7.82271661e-03f, -3.21880274e-04f, -4.77565266e-02f, -3.31826247e-02f, 2.46872772e-02f, 5.59659190e-02f, -3.82070877e-02f,
  5.69081716e-02f, 3.64522301e-02f, -3.65639068e-02f, -7.67162442e-02f, -1.09945171e-01f, -1.02110356e-01f, -8.36995319e-02f, 9.02601108e-02f, 8.98010805e-02f, 1.27935767e-01f,
  -2.83425748e-02f, 3.26321367e-03f, 6.13026656e-02f, 5.46973757e-02f, 2.77130120e-03f, 5.81689775e-02f, 1.21656626e-01f, -1.32640079e-01f, -4.05136049e-02f, 1.99366156e-02f,
  -1.21681340e-01f, -1.70468166e-02f, 3.79087068e-02f, 7.55647421e-02f, -1.41886817e-02f, -6.30261526e-02f, 9.72719789e-02f, -7.77505757e-03f, -4.68996130e-02f, 9.87706929e-02f,
  6.34210333e-02f, -1.05940983e-01f, -2.87145153e-02f, -7.11702630e-02f, -6.75584301e-02f, -4.61992063e-02f, -8.86321347e-03f, 1.30676284e-01f, 1.89666506e-02f, -5.35752103e-02f,
  -1.03534766e-01f, 1.09550804e-01f, 3.10903997e-03f, -7.29741305e-02f, -2.29660049e-02f, 5.81505112e-02f, 1.31792590e-01f, -1.69227317e-01f, -8.66130814e-02f, 4.52353805e-02f,
  -1.27338488e-02f, -8.65091133e-05f, -1.42081186e-01f, 2.45168373e-01f, 1.12361610e-02f, 1.74296200e-01f, -1.45784155e-01f, 6.89652190e-02f, 7.81153888e-02f, -8.20148643e-03f,
  -4.23651822e-02f, 2.28277408e-02f, -3.43725942e-02f, -1.56407908e-01f, -6.40692413e-02f, 4.18251641e-02f, 1.15850434e-01f, -1.23889811e-01f, 3.88178378e-01f, 1.23454571e-01f,
  -8.05672929e-02f, -8.56022015e-02f, 2.26426676e-01f, 8.67801905e-02f, -2.08843708e-01f, 1.22567743e-01f, -9.48401392e-02f, 9.24940873e-03f, 1.63325205e-01f, -1.20391600e-01f,
  -1.96559772e-01f, 7.51861259e-02f, -6.85403794e-02f, -7.77829736e-02f, -1.32155791e-01f, -1.46061569e-01f, 1.87266618e-01f, -2.22921774e-01f, 5.33257365e-01f, 8.79408270e-02f,
  -1.21280298e-01f, -6.14139065e-02f, -9.28686559e-02f, -9.49874148e-02f, -6.80257976e-02f, 1.58800900e-01f, -9.07714888e-02f, 8.01512972e-02f, 6.74442872e-02f, -4.80074257e-01f,
  8.97218287e-02f, -1.04882405e-03f, 6.19281754e-02f, 7.12120309e-02f, 5.03171422e-02f, -1.38342172e-01f, 7.76272491e-02f, 4.70144451e-02f, -3.57578956e-02f, 3.73354927e-02f,
  -1.42685845e-01f, -6.49791881e-02f, -1.54160619e-01f, -1.44618470e-03f, 4.06756513e-02f, 1.11304283e-01f, -1.25282288e-01f, -1.17987134e-02f, 4.05963510e-02f, -7.88589865e-02f,
  -7.17547238e-02f, -5.96338622e-02f, -9.45139378e-02f, -2.25176811e-02f, -3.12393736e-02f, 3.86023684e-03f, 5.77879883e-02f, 5.64758517e-02f, 9.85605363e-03f, -5.94197772e-02f,
  -1.30777627e-01f, -1.07654035e-02f, 1.18068844e-01f, -3.65200490e-02f, 3.72736640e-02f, 7.35757202e-02f, 1.21943150e-02f, 7.30720460e-02f, -6.29382208e-02f, -4.18423787e-02f,
  -4.65745926e-02f, 8.61033276e-02f, 1.26807451e-01f, 3.57453972e-02f, -5.42931370e-02f, -1.72123592e-02f, 5.84425740e-02f, 5.70367388e-02f, -1.37905199e-02f, -1.44585278e-02f,
  -9.50056091e-02f, -2.29063690e-01f, -7.27733411e-03f, -4.93419208e-02f, -3.78241576e-02f, 1.52730746e-02f, -8.66379868e-03f, 8.58521834e-02f, -1.02935933e-01f, 1.27680480e-01f,
  -1.53448969e-01f, 3.63450833e-02f, -9.50877070e-02f, 1.27544031e-01f, -1.35914758e-01f, 3.98764163e-02f, 2.13442728e-01f, 1.88551933e-01f, -1.86734974e-01f, -1.66593269e-02f,
  6.13927916e-02f, -4.07028720e-02f, 1.69640444e-02f, 2.49826591e-02f, -4.68132980e-02f, -1.48647409e-02f, 5.87710887e-02f, -5.13020046e-02f, -4.23681848e-02f, -1.14346541e-01f,
  7.17098713e-02f, 2.21667513e-01f, -4.83460799e-02f, 1.14993736e-01f, -1.53110325e-02f, -3.64040174e-02f, -1.09823234e-01f, 4.41360064e-02f, -1.11998700e-01f, 2.19723117e-02f,
  8.92254859e-02f, 6.60568252e-02f, 7.16550723e-02f, 2.41853166e-02f, 3.09962314e-02f, 3.07203922e-02f, 7.90247694e-02f, 9.31515917e-03f, -9.91906226e-02f, 3.09725553e-02f,
  -2.34450027e-02f, 1.26741212e-02f, -4.49211188e-02f, -2.35510036e-01f, 1.75287247e-01f, -1.35936081e-01f, 1.63249016e-01f, 9.27999616e-02f, 2.06398159e-01f, 4.01788689e-02f,
  -5.98806329e-02f, 2.25863472e-01f, -1.00783743e-01f, 7.13650137e-02f, 1.39076859e-01f, -4.82205339e-02f, -3.86271924e-02f, 1.35036752e-01f, -9.03901877e-04f, 1.76754687e-02f,
  -9.08005089e-02f, 1.00575328e-01f, 7.22794607e-02f, 7.67654492e-05f, -1.53638795e-01f, -2.24170044e-01f, 1.04434408e-01f, -6.51079416e-02f, 5.23313992e-02f, -7.89954141e-02f,
  -2.06085723e-02f, 3.18623669e-02f, 4.58745211e-02f, 9.86673054e-04f, 3.68901785e-03f, 4.56189364e-02f, -6.76999465e-02f, -1.33551225e-01f, -6.79203272e-02f, -5.46878614e-02f,
  -9.84486639e-02f, -8.35790336e-02f, -1.49202585e-01f, -7.77315274e-02f, 1.48259148e-01f, 2.66120266e-02f, 4.04246934e-02f, 2.87959222e-02f, 1.16829074e-03f, 6.39128382e-04f,
  -4.59509082e-02f, -3.63542885e-02f, 3.96458544e-02f, -5.92789389e-02f, -5.98183423e-02f, -4.61003482e-02f, -9.39844102e-02f, -1.23711996e-01f, 9.43124667e-02f, 6.15119226e-02f,
  -2.25335106e-01f, 3.56777124e-02f, -2.33742632e-02f, -1.72667000e-02f, -1.11198761e-02f, 7.37041086e-02f, 2.20490638e-02f, -1.75604187e-02f, 9.10733491e-02f, 1.43445969e-01f,
  -9.29226261e-03f, 8.86825174e-02f, -2.16183327e-02f, 5.92729496e-03f, -5.86659051e-02f, -4.69325557e-02f, -4.12075147e-02f, -6.10101297e-02f, -5.54663576e-02f, 1.62018761e-02f,
  1.35975227e-01f, 5.56289591e-02f, -1.67010166e-02f, -4.53761369e-02f, 2.35802177e-02f, 1.16645023e-01f, -2.22582687e-02f, -5.56072704e-02f, -7.50228912e-02f, -5.63514559e-03f,
  8.87459144e-02f, 1.66421160e-02f, -3.86114381e-02f, 6.61129802e-02f, 6.77392483e-02f, 2.18074799e-01f, 4.47159372e-02f, 1.23644665e-01f, -1.44818900e-02f, -8.74417648e-02f,
  1.03811041e-01f, -8.00331011e-02f, -5.95886149e-02f, -9.30172503e-02f, -1.03909746e-01f, -2.95923501e-02f, -8.67108852e-02f, 1.51145710e-02f, 9.41530149e-03f, 1.96839809e-01f,
  9.18796659e-02f, 1.42184213e-01f, 6.87035620e-02f, 1.02510788e-01f, -2.64552403e-02f, 1.50882363e-01f, 1.79806855e-02f, -5.02032302e-02f, -1.10708065e-01f, 4.07921597e-02f,
  -1.52158529e-01f, -4.61859033e-02f, 2.99355984e-02f, -4.04330567e-02f, 1.78717196e-01f, -8.17419514e-02f, 7.90393874e-02f, -2.27927923e-01f, 9.04696435e-02f, 9.36492607e-02f,
  -1.60300821e-01f, 1.14351690e-01f, 1.80020824e-01f, 6.46899939e-02f, 1.91246435e-01f, 8.13838169e-02f, -2.95471191e-01f, -2.02436641e-01f, -6.78603277e-02f, 5.78864776e-02f,
  1.08029604e-01f, -5.32966144e-02f, -1.24174640e-01f, -1.64944798e-01f, 3.42767209e-01f, -2.36632954e-02f, 8.93258378e-02f, 1.18808068e-01f, 1.34472223e-02f, 3.13488096e-02f,
  -1.00547068e-01f, 2.80270040e-01f, -1.12094395e-01f, -7.21785873e-02f, 2.54595935e-01f, -2.31936965e-02f, -4.79362458e-02f, -1.63696200e-01f, -8.48750994e-02f, -5.92996404e-02f,
  7.63642192e-02f, 2.72460058e-02f, -5.89299053e-02f, 1.31375566e-01f, -8.29762518e-02f, 6.44320846e-02f, -7.99615532e-02f, 1.22689083e-01f, -4.21987511e-02f, 8.35858807e-02f,
  -7.35557526e-02f, 1.83274951e-02f, 4.78427261e-02f, -6.40909150e-02f, 8.74420330e-02f, 5.33326203e-03f, 9.02041346e-02f, -1.16768822e-01f, 3.81904989e-02f, -2.45400239e-02f,
  -3.89495306e-02f, -3.97955552e-02f, 4.09329534e-02f, 2.83368472e-02f, -7.25806877e-02f, 3.23603977e-03f, 6.26794156e-03f, -6.59188479e-02f, 5.02196606e-03f, 4.68613617e-02f,
  -1.79390870e-02f, -9.35497358e-02f, 7.05268756e-02f, -2.14981064e-02f, -5.23275211e-02f, -2.48355418e-02f, 8.25556591e-02f, -8.24870393e-02f, 1.28065972e-02f, 5.28922724e-03f,
  -6.83028775e-04f, 1.19721547e-01f, -2.94953864e-02f, -6.51171580e-02f, 9.01969746e-02f, -3.15405168e-02f, 1.03525154e-01f, -8.60535875e-02f, -1.45344427e-02f, -3.71839739e-02f,
  5.24903871e-02f, -3.29098254e-02f, -3.71144786e-02f, -4.94540632e-02f, 2.76820008e-02f, -3.60440314e-02f, -5.00892960e-02f, -1.13588730e-02f, 2.53468931e-01f, -8.03888217e-02f,
  -7.87280314e-03f, -4.39332984e-02f, -4.51963432e-02f, 4.48609851e-02f, 8.53997841e-02f, 5.48235998e-02f, 1.77622885e-01f, -1.09216288e-01f, -1.50904469e-02f, -2.36395411e-02f,
  1.36444956e-01f, -2.38226466e-02f, -9.61964503e-02f, 7.16880709e-02f, 1.11842602e-01f, 6.76665679e-02f, 2.00403165e-02f, 9.61362850e-03f, 8.67884383e-02f, -6.92031905e-02f,
  -1.32894278e-01f, -2.43136864e-02f, 9.53157060e-03f, -9.52569861e-03f, -1.42089715e-02f, -4.31782007e-02f, -1.82648506e-02f, 3.73630039e-02f, 8.69669318e-02f, -3.77600975e-02f,
  1.08761907e-01f, -2.52949782e-02f, 7.87520856e-02f, 8.43895972e-02f, 8.65307823e-02f, 1.69807039e-02f, 7.91572407e-02f, -4.65480238e-02f, 2.80473996e-02f, -8.52904841e-03f,
  -1.24087594e-01f, 1.02125481e-01f, 2.32047737e-01f, 1.35185838e-01f, -2.14831337e-01f, -1.25015825e-02f, -4.28177677e-02f, -1.38891593e-01f, 1.40719935e-02f, 3.32365674e-03f,
  -1.99923187e-01f, 5.76013252e-02f, 2.27693692e-01f, -1.83481529e-01f, 3.35271657e-02f, 1.30232379e-01f, -1.57138146e-02f, -2.02201083e-01f, -8.83179680e-02f, 2.31249914e-01f,
  3.18599008e-02f, 1.25472888e-01f, 1.92616016e-01f, 1.69902951e-01f, 1.03154592e-01f, 3.17913853e-02f, 3.13077569e-02f, -1.42087847e-01f, -5.65605909e-02f, 2.16697045e-02f,
  -7.54781589e-02f, 6.16264157e-02f, -4.27067466e-02f, -9.25068706e-02f, 1.40418053e-01f, -8.81017148e-02f, -4.97618876e-02f, -5.88173652e-03f, -1.94799323e-02f, 2.54842676e-02f,
  3.24533358e-02f, 8.59860927e-02f, 3.96673270e-02f, -1.55744178e-03f, -3.29397991e-03f, 4.84553277e-02f, -4.80171666e-03f, -1.15088862e-03f, -1.41368108e-02f, 1.01924270e-01f,
  1.72869917e-02f, -1.15784921e-01f, -4.82613742e-02f, 1.14382058e-01f, 6.19026199e-02f, 2.70106774e-02f, 3.04715335e-02f, -1.21051108e-03f, -5.26276743e-03f, 3.22586671e-02f,
  -3.19521315e-02f, -9.36800689e-02f, -4.29838337e-02f, 2.62683034e-02f, -1.15425669e-01f, -3.81227657e-02f, 7.82801881e-02f, 4.31313738e-02f, -1.03015214e-01f, 4.59681936e-02f,
  4.37309034e-02f, 7.97034949e-02f, -2.31376924e-02f, 3.17297764e-02f, -3.00528239e-02f, -1.72341224e-02f, -9.14680064e-02f, -1.57826573e-01f, -1.10691395e-02f, 7.51453713e-02f,
  -6.91904947e-02f, 1.02600262e-01f, 1.05960164e-02f, 6.79190531e-02f, 1.76752377e-02f, -7.47066662e-02f, -3.47367823e-02f, 4.99036014e-02f, 9.92041230e-02f, -2.76939403e-02f,
  3.76585983e-02f, 2.33476460e-02f, -1.14030346e-01f, -6.80151880e-02f, -4.49676067e-02f, 2.43232399e-03f, -7.77281597e-02f, -3.75909731e-04f, -8.35711583e-02f, -2.61930767e-02f,
  1.67018324e-01f, 1.26562312e-01f, 9.35254712e-03f, -1.33796960e-01f, -6.96150810e-02f, -4.25394885e-02f, 2.55565885e-02f, 6.42244518e-02f, -1.09585613e-01f, 1.73332877e-02f,
  -8.97398889e-02f, -1.04532063e-01f, -7.11798444e-02f, -4.46162038e-02f, 3.84193584e-02f, 1.52655188e-02f, 7.14792535e-02f, -4.02071960e-02f, -9.18351859e-02f, -3.87975015e-02f,
  7.73058385e-02f, -5.32720089e-02f, 1.84580907e-02f, -5.33812642e-02f, 1.08138315e-01f, -8.87261182e-02f, -1.61073476e-01f, 1.76416770e-01f, 3.92306596e-02f, -2.00984359e-01f,
  -2.85793375e-02f, 4.38341759e-02f, 8.02361518e-02f, 2.17938155e-01f, -2.02241704e-01f, 8.13236311e-02f, -2.02449098e-01f, 2.51113269e-02f, 1.15162089e-01f, -1.72771469e-01f,
  3.08277607e-01f, 3.74464877e-02f, -8.37753937e-02f, -1.59410745e-01f, -8.02850798e-02f, -1.84362188e-01f, 1.49806753e-01f, -9.29694548e-02f, 3.62097435e-02f, -1.08658999e-01f,
  -1.30300224e-01f, -2.53338128e-01f, 9.58312117e-03f, 8.56382214e-03f, 1.60597086e-01f, -3.69062424e-02f, -4.76077385e-02f, -1.64141342e-01f, 8.06696787e-02f, -2.50797421e-01f,
  -5.54042794e-02f, 7.08683766e-03f, 1.18688688e-01f, -1.00063300e-03f, 1.18191764e-01f, 1.12909907e-02f, -7.11056441e-02f, -2.18371190e-02f, -1.36074498e-01f, -2.52074990e-02f,
  -3.26236598e-02f, 1.37107491e-01f, 2.27548927e-02f, -5.41863814e-02f, 2.21341439e-02f, 4.48075756e-02f, -7.91693106e-02f, -8.88570696e-02f, -3.71356718e-02f, -1.85721233e-01f,
  3.99304256e-02f, -7.90939108e-02f, -1.34911045e-01f, -1.57685671e-02f, 2.89243553e-02f, -3.65302600e-02f, 2.78991573e-02f, -1.31373294e-02f, -7.38277705e-03f, -4.15323973e-02f,
  -4.00827043e-02f, 6.54547289e-02f, 1.50416747e-01f, -1.00998789e-01f, -8.80032592e-03f, -1.29354117e-03f, 2.80754846e-02f, 6.75126538e-02f, 9.88558233e-02f, -5.54767624e-02f,
  -1.48794698e-02f, 2.00080848e-03f, 1.09887533e-01f, 4.06606458e-02f, 1.40038040e-02f, 7.44007751e-02f, -9.78709236e-02f, -3.15375291e-02f, 8.04496035e-02f, -2.97626313e-02f,
  -2.78344732e-02f, -5.14074713e-02f, -1.20906010e-01f, -6.45119976e-03f, -5.64439856e-02f, 1.03880860e-01f, 7.51027390e-02f, -1.58500839e-02f, -2.80024577e-02f, -1.27311006e-01f,
  -1.12872422e-01f, 1.46013573e-02f, -1.65160075e-01f, -2.40986119e-03f, 6.29644841e-02f, 3.65962237e-02f, -8.58662948e-02f, 2.73466273e-03f, 3.44573669e-02f, -1.57242522e-01f,
  -1.26231965e-02f, -3.08070444e-02f, -1.10591367e-01f, 8.81670266e-02f, 3.31885405e-02f, -5.53792007e-02f, 1.80969611e-01f, 3.82244773e-03f, 1.51011441e-02f, 1.04068927e-02f,
  1.00366861e-01f, 1.28165081e-01f, -9.61106867e-02f, -1.73637062e-01f, 7.43140280e-02f, 2.02407330e-01f, -2.49094032e-02f, -7.58253038e-02f, 8.23451951e-02f, 1.03773773e-01f,
  1.44708171e-01f, 2.16799006e-02f, -7.28852600e-02f, 2.19901390e-02f, 9.27382112e-02f, -1.90898672e-01f, -5.56107759e-02f, 2.67289635e-02f, 1.65039506e-02f, -1.63077846e-01f,
  1.67951480e-01f, 7.17865303e-02f, 1.09733164e-01f, -5.67388162e-02f, -2.05528252e-02f, -1.64836004e-01f, 3.80667895e-01f, 1.58848330e-01f, -5.49201407e-02f, -7.69589767e-02f,
  3.32788192e-02f, 6.89192116e-02f, 4.56179082e-02f, 6.48947209e-02f, -4.73333746e-02f, -1.10728033e-01f, -3.36887270e-01f, -1.53831035e-01f, -1.30187124e-01f, 1.55892342e-01f,
  2.50164829e-02f, -4.05095108e-02f, 4.90050316e-02f, 1.80878729e-01f, -1.03117460e-02f, 3.72100547e-02f, 6.60892799e-02f, -8.83987993e-02f, -3.16411033e-02f, -2.24067327e-02f,
  4.40465435e-02f, 6.05883561e-02f, 2.36388780e-02f, 6.72551841e-02f, -5.98323308e-02f, -1.80529635e-02f, 7.00310525e-03f, -6.88105356e-03f, 1.54254558e-02f, -8.04775115e-03f,
  -2.52858028e-02f, -8.15605596e-02f, -1.14735484e-01f, -1.37457652e-02f, 1.98047366e-02f, 3.02396677e-02f, 5.56256771e-02f, -4.78419177e-02f, 2.43281350e-02f, -7.86537901e-02f,
  6.99021667e-02f, 3.23090553e-02f, 3.19841839e-02f, 7.16153383e-02f, -1.15862288e-01f, 5.02019711e-02f, 2.53462996e-02f, -3.31824017e-03f, -1.36562539e-02f, 7.22798705e-02f,
  2.04868186e-02f, 1.33530004e-03f, 7.27510750e-02f, -5.69871701e-02f, 2.11666431e-02f, 4.53759916e-02f, 3.00267115e-02f, 6.15739357e-03f, -4.70942147e-02f, -1.08556658e-01f,
  1.05641723e-01f, -1.63274840e-01f, 7.39748217e-03f, -1.87477432e-02f, 3.55892405e-02f, -9.46898311e-02f, 8.99686571e-03f, 1.35884508e-01f, -8.14156607e-03f, 1.86760761e-02f,
  -1.12026799e-02f, -2.38225190e-03f, 6.60523772e-02f, -2.00282678e-01f, 8.50077942e-02f, 2.49507022e-03f, 5.63930720e-02f, 1.61211178e-01f, 1.21006861e-01f, 1.12180160e-02f,
  -7.27499202e-02f, 5.72366007e-02f, -3.91929410e-02f, -3.96506395e-04f, 5.93901984e-02f, -2.77591962e-02f, 1.47405677e-02f, 3.44903320e-02f, -8.13411698e-02f, -5.49155362e-02f,
  -1.46361142e-01f, 4.93748449e-02f, 5.11051007e-02f, 3.85212563e-02f, -2.48442478e-02f, 2.91944612e-02f, 9.99611095e-02f, 5.08424342e-02f, 1.45005658e-01f, 2.51290441e-01f,
  -2.90828589e-02f, -5.55399582e-02f, 7.47789219e-02f, -5.70921926e-04f, 1.25826463e-01f, -6.84225559e-02f, 2.54441407e-02f, -4.16332074e-02f, -9.14982855e-02f, -7.39065185e-02f,
  -3.69359215e-04f, 1.15069441e-01f, 1.22414336e-01f, -1.43640831e-01f, -9.53027382e-02f, 2.32471421e-01f, 2.10539430e-01f, -1.37116462e-01f, -1.62497342e-01f, 3.62034917e-01f,
  1.47319749e-01f, -6.98871836e-02f, 1.03791744e-01f, 9.32037532e-02f, -5.50511852e-02f, -1.39092356e-01f, 2.61544585e-01f, -1.88777074e-01f, 2.20497232e-02f, 4.39806990e-02f,
  1.54012904e-01f, 1.17118128e-01f, 7.59043824e-03f, 1.66518286e-01f, -4.34121899e-02f, 2.17731029e-01f, 4.54678982e-02f, -3.73378098e-01f, -4.38189022e-02f, -2.38294657e-02f,
  -1.00662462e-01f, 8.98965448e-02f, -1.00715734e-01f, 1.88674390e-01f, 6.14240915e-02f, 4.08200473e-02f, -1.07102431e-02f, -6.92803487e-02f, 3.94524001e-02f, 7.77490251e-03f,
  4.54139076e-02f, 2.75851972e-02f, -3.31289172e-02f, -1.14893746e-02f, 5.91007024e-02f, -4.58945073e-02f, 3.02844457e-02f, -8.32666606e-02f, 3.72913294e-02f, 3.33844498e-02f,
  -8.06579962e-02f, 5.19281067e-02f, 2.63650678e-02f, 7.02253804e-02f, -2.85520051e-02f, 3.91189158e-02f, 9.62854475e-02f, 5.49707003e-02f, 5.11979721e-02f, -1.20277507e-02f,
  -1.91786718e-02f, -2.29352377e-02f, 3.12855616e-02f, -8.47756490e-03f, 1.66603792e-02f, -2.09166110e-02f, 3.75563055e-02f, -7.86322132e-02f, -9.07215942e-03f, 6.58843294e-02f,
  1.43289164e-01f, -9.68988985e-02f, -4.49838191e-02f, -9.15210620e-02f, -6.22726977e-02f, -8.71762075e-03f, -2.20466834e-02f, -3.38628255e-02f, 1.50279269e-01f, -2.53634714e-02f,
  3.72022353e-02f, -4.89464849e-02f, 4.01300564e-02f, 7.24670384e-03f, 1.17272092e-02f, -9.52666625e-02f, -5.08781224e-02f, -9.19285491e-02f, -2.75559667e-02f, -7.74750337e-02f,
  7.44482968e-03f, 3.13672097e-03f, -4.04588804e-02f, -1.20062754e-02f, -1.22275874e-02f, 1.00638881e-01f, -1.70342848e-02f, -9.72115993e-02f, 8.48314241e-02f, 1.36034548e-01f,
  2.58632638e-02f, -1.04929477e-01f, 1.00377455e-01f, -7.06619695e-02f, -1.70432366e-02f, -3.88381705e-02f, 1.06974121e-03f, 1.32942460e-02f, 1.51957124e-01f, -4.09597270e-02f,
  -7.44912475e-02f, 8.67008641e-02f, -7.54629597e-02f, 4.02898751e-02f, -1.21421300e-01f, 7.68020675e-02f, 9.47152302e-02f, -1.20089196e-01f, 1.62815705e-01f, -1.15243547e-01f,
  2.14248169e-02f, -8.84822011e-02f, 4.90270294e-02f, 5.76208904e-02f, -8.28701407e-02f, -1.04388930e-01f, -3.29167559e-03f, -1.28854856e-01f, 8.08869302e-02f, -1.09609976e-01f,
  2.38668367e-01f, 1.16673931e-01f, 1.31770656e-01f, -2.00780970e-03f, 2.85320699e-01f, -6.67802170e-02f, -2.95779645e-01f, -4.97611351e-02f, 5.88976666e-02f, -1.34962965e-02f,
  1.07854754e-01f, 8.96703005e-02f, -2.80872881e-01f, -3.21992129e-01f, -2.32719094e-01f, -9.83109027e-02f, 5.77989779e-02f, -2.25022495e-01f, 1.08726010e-01f, 7.36479238e-02f,
  -8.12529474e-02f, -9.45191607e-02f, -1.16140153e-02f, 1.20068371e-01f, -1.40503392e-01f, 4.26888913e-02f, 9.27674472e-02f, 1.17591508e-01f, 4.97437157e-02f, 2.29125582e-02f,
  -2.69938596e-02f, 1.90576687e-01f, 9.99874845e-02f, -5.05679399e-02f, -1.70327481e-02f, -7.29066655e-02f, -3.07579134e-02f, -3.78734693e-02f, -5.39593175e-02f, -4.41022441e-02f,
  1.07637793e-01f, 9.66605395e-02f, 2.59473138e-02f, 3.16455029e-02f, 4.18681018e-02f, -5.22804186e-02f, 3.71911116e-02f, 5.80277219e-02f, -3.73370014e-02f, 1.55050248e-01f,
  -7.80900973e-06f, 1.09922215e-01f, -4.59700674e-02f, 6.57340884e-02f, -3.20760161e-02f, 1.01475477e-01f, 1.57688767e-01f, 9.15029570e-02f, 1.15821034e-01f, 5.00689857e-02f,
  5.30129299e-02f, 4.65329997e-02f, -1.05396830e-01f, 4.47080508e-02f, 1.11936413e-01f, -8.47010836e-02f, 2.32097916e-02f, 3.45306545e-02f, -2.62204092e-02f, 7.19456896e-02f,
  6.85248971e-02f, 5.75450994e-02f, 4.50250804e-02f, 1.07746132e-01f, 9.12568346e-03f, -3.84761728e-02f, -7.74309635e-02f, -1.02587929e-02f, -1.68674350e-01f, 3.59725847e-04f,
  -1.60380051e-01f, 3.65994871e-02f, 3.25940065e-02f, -5.62201403e-02f, 1.18155390e-01f, -6.69733435e-02f, 1.16318814e-01f, -3.58914174e-02f, -6.42067865e-02f, 1.61010504e-01f,
  1.44387528e-01f, 1.12750992e-01f, -5.29169142e-02f, 1.09267691e-02f, 6.73975572e-02f, -1.23069417e-02f, -1.82741508e-01f, 2.00819280e-02f, -1.73129782e-01f, -6.22230768e-02f,
  -7.01292679e-02f, -1.17786370e-01f, 8.71280283e-02f, 4.21037376e-02f, -8.49317759e-02f, 2.95151602e-02f, 1.52237331e-02f, -1.71361521e-01f, 6.84522912e-02f, -2.17484728e-01f,
  -1.17659867e-01f, 6.30851416e-03f, 9.44413543e-02f, 1.44831866e-01f, 2.48702299e-02f, -7.72152990e-02f, -1.05999470e-01f, -7.22328797e-02f, 1.20145269e-02f, 1.55156493e-01f,
  4.54311781e-02f, -1.36551047e-02f, -9.86749604e-02f, -4.85323928e-02f, -8.76486972e-02f, 7.78005421e-02f, 1.22338749e-01f, -5.70206940e-02f, 1.64377689e-01f, 1.17196903e-01f,
  1.88011900e-01f, 1.07389269e-03f, -7.80964270e-02f, -1.43870026e-01f, 6.03557145e-03f, 4.66302708e-02f, 1.10190652e-01f, -3.68284844e-02f, -5.52488491e-02f, 8.47867057e-02f,
  3.66449580e-02f, -1.01171196e-01f, 8.57580379e-02f, 9.61135849e-02f, -2.76473295e-02f, -5.51461689e-02f, 5.88068664e-02f, 8.26297607e-03f, 8.08856562e-02f, -3.27413052e-01f,
  -2.69684792e-02f, 2.01217517e-01f, -1.23942979e-01f, -2.29357526e-01f, 6.11941591e-02f, 1.26252189e-01f, 3.68651338e-02f, 4.87549081e-02f, 8.69962871e-02f, -7.50541640e-03f,
  -7.83368498e-02f, 2.95213107e-02f, 7.81045016e-03f, 6.87528700e-02f, 4.07488085e-02f, -1.01728328e-01f, -9.89655405e-03f, -7.82357454e-02f, 1.81435701e-03f, 2.98323464e-02f,
  -1.47316670e-02f, -2.70244908e-02f, -6.37957826e-02f, -3.67578045e-02f, -6.09219074e-03f, -5.16676158e-02f, 1.05446735e-02f, -5.10504097e-02f, 2.93895677e-02f, -3.73102427e-02f,
  7.29214326e-02f, 2.08820645e-02f, -7.54512921e-02f, 7.85324946e-02f, 4.41349149e-02f, 2.52241232e-02f, 1.83958694e-01f, 1.03280721e-02f, -1.88056063e-02f, -1.19832426e-01f,
  4.19613086e-02f, 6.34233356e-02f, -2.78560836e-02f, -4.70349751e-02f, -5.58614619e-02f, 1.37155103e-02f, -7.79156312e-02f, 1.34492576e-01f, 1.14717118e-01f, 1.00870863e-01f,
  5.47623523e-02f, -5.11604315e-03f, 1.95223559e-02f, -7.15358704e-02f, 3.27929482e-02f, -3.86100970e-02f, -1.77419633e-01f, -8.68442655e-02f, -1.41472891e-01f, -4.73705865e-02f,
  -8.93935338e-02f, 1.05306931e-01f, 1.03709504e-01f, -9.19140205e-02f, 2.24707536e-02f, 4.51628454e-02f, -2.68011335e-02f, 1.10398933e-01f, -3.90408933e-02f, 1.78447261e-01f,
  -6.92045465e-02f, 3.55306603e-02f, -8.00485462e-02f, -1.87934879e-02f, 1.02730747e-02f, -8.01998749e-02f, 4.42405865e-02f, 1.29458532e-01f, -1.49525031e-01f, -1.54720694e-01f,
  5.11760376e-02f, -3.40946810e-03f, 1.31699637e-01f, -2.67742705e-02f, -1.13111556e-01f, 1.17453979e-02f, 1.32585734e-01f, -1.16679490e-01f, 5.15068881e-02f, -9.06281173e-02f,
  1.96404234e-01f, 4.11013439e-02f, 5.13345040e-02f, 7.40299970e-02f, 3.62270661e-02f, -5.42856902e-02f, -7.22136945e-02f, 2.72556059e-02f, -1.30758598e-01f, 6.66522309e-02f,
  3.71957086e-02f, -1.36612747e-02f, -2.18742881e-02f, 1.38213960e-02f, 8.23827833e-02f, -9.67290625e-02f, 8.40994567e-02f, -2.21339101e-03f, -1.22032072e-02f, 4.71109226e-02f,
  -2.84015298e-01f, 1.42703978e-02f, 2.56927699e-01f, -1.96418107e-01f, 9.82755423e-02f, 1.17984395e-02f, 7.28305578e-02f, 1.27980247e-01f, 8.04615021e-02f, 7.28720203e-02f,
  -2.65653376e-02f, 6.29465878e-02f, 1.37757352e-02f, 1.20802201e-01f, 3.72914597e-02f, 1.25080571e-01f, 2.17165090e-02f, -3.89379673e-02f, -9.97102708e-02f, -6.20534495e-02f,
  -1.89382806e-02f, -3.67083102e-01f, -6.04488291e-02f, 8.68559815e-03f, 3.62087004e-02f, -4.75089625e-02f, 3.12217157e-02f, 1.24980062e-01f, -1.28734395e-01f, -2.19112524e-04f,
  -9.27245915e-02f, -6.24435619e-02f, 2.80592274e-02f, 6.30277470e-02f, 9.35079232e-02f, -3.94330509e-02f, 2.75028497e-02f, -1.52920321e-01f, 5.74299917e-02f, 6.66605011e-02f,
  1.37444679e-02f, 4.34285253e-02f, -3.81322391e-02f, 1.00096673e-01f, 7.53647014e-02f, 1.07525550e-01f, -3.57992109e-03f, -1.11400448e-01f, -3.80455293e-02f, -5.57032600e-02f,
  1.02404103e-01f, 5.90268932e-02f, -1.69732913e-01f, 5.74248517e-03f, 9.41570625e-02f, -3.37347575e-02f, 5.60147502e-02f, 4.92895171e-02f, -5.47536947e-02f, -1.23170927e-01f,
  -7.35958144e-02f, -9.96271148e-02f, -6.33058026e-02f, -1.26990497e-01f, 4.30345684e-02f, -9.27086323e-02f, -4.27155383e-02f, -1.18092127e-01f, 1.83854867e-02f, 4.91680950e-02f,
  6.41938578e-03f, -4.38125096e-02f, -7.82177448e-02f, -5.09294979e-02f, -8.15469027e-02f, -9.40370485e-02f, -9.64047611e-02f, -5.89243993e-02f, -6.49682879e-02f, 1.59157589e-01f,
  -7.79573098e-02f, -5.94523363e-02f, -2.02784874e-02f, -1.26732245e-01f, -8.47442262e-03f, 1.73815981e-01f, 1.97928950e-01f, -7.49941468e-02f, 8.41469225e-03f, 4.11226265e-02f,
  7.24078342e-02f, 1.75380949e-02f, -1.87366866e-02f, -9.14768130e-02f, -7.88860917e-02f, 8.49599019e-02f, -1.59757137e-01f, -3.75728197e-02f, -2.90481132e-02f, 7.77226016e-02f,
  -8.02682638e-02f, -4.65193251e-03f, -1.48032591e-01f, -1.54466018e-01f, -1.42685369e-01f, 7.29922950e-02f, 6.15692176e-02f, 5.83552662e-03f, 1.36496738e-01f, -3.56912427e-02f,
  4.41930406e-02f, -7.49270841e-02f, 1.54615259e-02f, -3.48600335e-02f, -2.58510895e-02f, -2.62249932e-02f, 4.53769676e-02f, 6.31591976e-02f, 1.49198160e-01f, 1.26138151e-01f,
  1.01259820e-01f, -1.41029611e-01f, 3.74208316e-02f, -2.04613470e-02f, 4.34963079e-03f, 8.97254348e-02f, 6.10116450e-03f, 1.76692039e-01f, 9.97737199e-02f, 3.43565121e-02f,
  -7.34541267e-02f, 1.79053873e-01f, -8.21058080e-02f, -6.88352361e-02f, -1.35668457e-01f, 1.12027466e-01f, -1.31042898e-02f, -2.24620640e-01f, 3.29706103e-01f, -5.30234305e-03f,
  2.27295514e-02f, -4.12985636e-03f, -1.24140149e-02f, -1.38429046e-01f, -4.05688547e-02f, -5.11050671e-02f, -2.32183024e-01f, -2.60898080e-02f, -1.64517716e-01f, -3.20778549e-01f,
  2.04297248e-02f, 1.13540336e-01f, -1.08359680e-02f, -8.20225030e-02f, -1.46122342e-02f, 1.07611055e-02f, -9.61357951e-02f, -6.84071556e-02f, -1.10405907e-01f, -9.33561772e-02f,
  -7.25592603e-04f, -6.47634938e-02f, -1.59924366e-02f, -5.37499972e-02f, -2.30777897e-02f, 1.00775547e-01f, -4.10765521e-02f, -7.79660493e-02f, -1.86087526e-02f, 8.05127844e-02f,
  -1.57571256e-01f, 1.95685234e-02f, 2.72133518e-02f, -4.43924312e-03f, 8.24350957e-03f, 5.40700443e-02f, 6.45374432e-02f, -8.99166986e-02f, -4.45944294e-02f, 8.33216012e-02f,
  2.46371701e-03f, -3.92638259e-02f, 9.85308513e-02f, -8.27082992e-02f, -9.31917876e-02f, -9.56253633e-02f, -7.26941377e-02f, -4.13643196e-02f, 8.23870953e-03f, -8.06193054e-02f,
  -5.90342097e-02f, -4.19809576e-03f, -3.85598615e-02f, 6.09400310e-02f, 4.85182134e-03f, -9.37231481e-02f, 3.88214961e-02f, -8.37676749e-02f, 6.52276278e-02f, -4.85950373e-02f,
  -1.86287072e-02f, -4.10624780e-02f, -2.20781267e-01f, 1.09690122e-01f, -1.33610919e-01f, -5.65458052e-02f, 1.22035807e-02f, 1.46021307e-01f, -3.68297063e-02f, -7.45673373e-04f,
  1.59223691e-01f, -3.12738456e-02f, -5.59767522e-02f, 5.97109944e-02f, 1.80378467e-01f, 1.07333250e-01f, -7.99687356e-02f, 6.71360940e-02f, 6.51814938e-02f, -1.78442374e-02f,
  -1.21901497e-01f, -3.37951593e-02f, -8.71302187e-02f, 8.25101808e-02f, -2.00156018e-01f, -1.57167181e-01f, -1.37846604e-01f, -1.02712452e-01f, 1.27453655e-01f, 5.51663153e-02f,
  -9.52723697e-02f, -7.21792225e-03f, -3.94282639e-02f, -8.14779550e-02f, 6.18654396e-03f, -1.64919257e-01f, 1.56619966e-01f, 2.27105580e-02f, -4.59309481e-02f, -8.84643272e-02f,
  -6.88582286e-02f, -1.66891173e-01f, 1.03983507e-01f, 6.05084151e-02f, -4.82605658e-02f, 1.84695050e-01f, 1.80637240e-01f, 8.20875689e-02f, 1.87322661e-01f, -1.04798838e-01f,
  9.01628882e-02f, -5.03226109e-02f, -3.74901220e-02f, -7.80947460e-03f, -1.88676957e-02f, -4.96063987e-03f, -1.88241720e-01f, -9.37527716e-02f, 2.67378360e-01f, 7.80718122e-03f,
  -1.37518877e-02f, 7.24371895e-02f, 7.92039409e-02f, 1.83461815e-01f, 1.29601106e-01f, -1.55178905e-02f, 7.70294294e-02f, 2.22329780e-01f, 4.01650444e-02f, 3.92378941e-02f,
  -2.20957231e-02f, 4.89279851e-02f, 6.42360300e-02f, 9.31622740e-03f, -6.98236823e-02f, -1.80490822e-01f, -5.83737530e-03f, -3.44003171e-01f, -1.99763346e-02f, 9.31205675e-02f,
  1.95173379e-02f, -3.05762272e-02f, 1.10636488e-01f, 3.20415683e-02f, -6.68188781e-02f, 6.25387430e-02f, 4.77126911e-02f, 1.17288783e-01f, 1.34323183e-02f, -6.12048293e-03f,
  -4.08371910e-03f, 6.50052652e-02f, -5.38833290e-02f, 2.92678270e-02f, 9.20283571e-02f, 9.86289904e-02f, 2.06417907e-02f, 5.62691726e-02f, 9.54090133e-02f, -2.55807396e-03f,
  2.55967807e-02f, 2.10367460e-02f, 3.83630022e-02f, 6.89214021e-02f, -4.10257727e-02f, 2.49609817e-02f, -1.29273590e-02f, 6.60656989e-02f, 7.86233395e-02f, -7.02956319e-02f,
  -4.70623784e-02f, -7.55869830e-03f, 1.25265360e-01f, 6.41477257e-02f, -3.62823680e-02f, -5.32089593e-03f, -2.59682164e-02f, -4.16767746e-02f, -3.23699526e-02f, 9.16191563e-02f,
  -3.25229242e-02f, -1.44981639e-02f, -6.73357025e-02f, -3.39461342e-02f, 4.30498086e-02f, -5.23229539e-02f, 3.60387489e-02f, 2.44576689e-02f, 1.61729679e-02f, -2.14613587e-01f,
  -8.23454466e-03f, 5.15552685e-02f, 2.29959600e-02f, -7.05546811e-02f, -9.37073007e-02f, 2.69919969e-02f, 1.41855923e-03f, 1.78596362e-01f, -1.53490260e-01f, -1.88190248e-02f,
  -5.04705496e-02f, 7.33921165e-03f, -8.50383658e-03f, -5.05046174e-02f, 7.44247343e-03f, 2.19920091e-02f, 6.92194775e-02f, 6.83989003e-02f, 1.85857788e-02f, -7.68768862e-02f,
  -1.19557744e-02f, 5.14231697e-02f, -2.04684705e-01f, -6.47700764e-03f, 1.24413110e-01f, -2.72413082e-02f, -1.07543983e-01f, 2.60007512e-02f, 5.71024753e-02f, 2.93609109e-02f,
  -7.29345530e-02f, 1.21083379e-01f, 2.89159920e-02f, 1.12075597e-01f, -1.00595824e-01f, -1.30117953e-01f, -2.70729070e-03f, -6.46911412e-02f, 1.60497755e-01f, 1.79340430e-02f,
  1.34596318e-01f, 1.09250685e-02f, 8.47897958e-03f, 1.66539297e-01f, 1.99441910e-01f, 1.67233899e-01f, 6.18305393e-02f, -9.40292105e-02f, 4.03481051e-02f, -1.03734754e-01f,
  2.98688076e-02f, 7.47254044e-02f, 1.19019769e-01f, -2.27747574e-01f, 7.82174021e-02f, -3.71556636e-03f, 2.42409527e-01f, 1.20370932e-01f, -5.40257320e-02f, 1.50878849e-02f,
  8.62672850e-02f, 1.55753329e-01f, 2.00258076e-01f, 1.08300745e-01f, 1.89245775e-01f, 1.09499186e-01f, -1.86354835e-02f, -7.97331333e-02f, 1.41527206e-01f, 1.30961031e-01f,
  1.86528321e-02f, 4.17654850e-02f, -4.78163138e-02f, -2.71956921e-01f, -4.02997136e-02f, -3.31204355e-01f, 5.38048567e-03f, 2.18591079e-01f, -1.32593736e-01f, -6.50290027e-02f,
  -3.38711850e-02f, 1.58198118e-01f, 6.68438990e-03f, 5.03072962e-02f, -3.82066034e-02f, -1.15318649e-01f, 6.81187660e-02f, -1.17294444e-02f, 5.69360070e-02f, 4.05426584e-02f,
  6.16570301e-02f, -8.21494237e-02f, 5.10619534e-03f, 5.45660891e-02f, 3.11849322e-02f, 3.34571451e-02f, -6.40389090e-03f, 2.10030135e-02f, 6.41398504e-02f, 2.96357386e-02f,
  1.26415014e-01f, -4.68352325e-02f, 2.39329021e-02f, -1.09833730e-02f, -3.80284339e-02f, 1.01466216e-02f, 7.67727718e-02f, -6.46270216e-02f, -6.34120181e-02f, -7.78999850e-02f,
  -2.59099547e-02f, -5.63401543e-02f, -5.98000959e-02f, -4.46664616e-02f, 1.44081712e-01f, 3.98701802e-03f, -3.50765884e-02f, -9.21062455e-02f, -4.66083437e-02f, -8.02332312e-02f,
  -9.08122286e-02f, -1.61233380e-01f, 4.75485139e-02f, 1.41356021e-01f, -9.72724110e-02f, 6.27182052e-02f, -1.96033910e-01f, 8.23359117e-02f, 4.75200638e-02f, -8.47499892e-02f,
  6.42916420e-03f, 1.33438483e-01f, -2.04825684e-01f, 6.81015104e-02f, 9.42852125e-02f, 4.05392088e-02f, -1.24598981e-03f, -3.92130688e-02f, -1.13003664e-01f, 5.12946658e-02f,
  3.17483991e-01f, -5.88747934e-02f, -1.45048536e-02f, 7.52959773e-02f, 5.60267307e-02f, 2.87174676e-02f, -7.99444541e-02f, 9.65168104e-02f, -7.52570927e-02f, 4.57267277e-02f,
  -3.04759145e-02f, 3.52211972e-03f, 2.66914330e-02f, 8.72933343e-02f, 4.81977910e-02f, 6.97548781e-03f, -5.12088761e-02f, -2.08406568e-01f, -1.88253000e-01f, -1.85407802e-01f,
  1.02732126e-02f, 9.13180504e-03f, 6.13303483e-03f, -8.24974012e-03f, 5.70996888e-02f, 6.98034316e-02f, 1.23834633e-03f, -4.14342619e-02f, -4.13339585e-02f, 3.20904627e-02f,
  4.02071252e-02f, 1.17037948e-02f, -2.77629308e-02f, 8.13626125e-02f, 2.97586471e-02f, -9.61571634e-02f, 8.93708766e-02f, 6.88141733e-02f, 1.51947543e-01f, 2.24271879e-01f,
  5.19433320e-02f, -1.39506171e-02f, -3.23194936e-02f, -1.17556661e-01f, 3.05010770e-02f, 7.92978797e-03f, 1.53474301e-01f, 4.88927439e-02f, -1.30034713e-02f, -9.57543403e-02f,
  -1.71303943e-01f, -2.06796840e-01f, 8.83806720e-02f, -4.64152135e-02f, 8.45649920e-04f, -7.44133294e-02f, -1.56053957e-02f, -5.54358289e-02f, -4.81004231e-02f, -8.60508978e-02f,
  2.51217056e-02f, 2.43405417e-01f, -1.45884037e-01f, -2.73584425e-01f, -5.26257604e-02f, -5.15867844e-02f, 6.93495646e-02f, -1.97256673e-02f, 9.56431031e-03f, -1.14653530e-02f,
  -9.39759463e-02f, -6.47279620e-02f, 8.34856704e-02f, -4.38844487e-02f, -3.06350421e-02f, -2.83201616e-02f, -2.52520982e-02f, 1.34886473e-01f, 3.33393924e-02f, 4.32199687e-02f,
  -2.38697343e-02f, 6.26139790e-02f, 8.30334798e-03f, -3.84214800e-03f, 2.19239225e-03f, -1.59101337e-02f, 7.41438791e-02f, 3.43230031e-02f, -5.56596853e-02f, -5.95815927e-02f,
  2.71466764e-04f, 6.80173635e-02f, -4.24709655e-02f, 6.84148166e-04f, -5.30958362e-02f, -5.00117429e-02f, 7.14771226e-02f, 2.82886233e-02f, -8.74601677e-02f, -7.43282214e-02f,
  1.17808934e-02f, -1.37975914e-02f, 5.45989759e-02f, 4.28533033e-02f, 1.36105761e-01f, -2.58672342e-04f, 2.45638825e-02f, 3.44228707e-02f, 1.42050646e-02f, -2.52221432e-02f,
  9.62957069e-02f, -1.10246785e-01f, 8.98122415e-02f, -3.00359670e-02f, 8.36369172e-02f, 1.20314054e-01f, 1.47231951e-01f, 1.74049050e-01f, -5.32230064e-02f, 2.22235192e-02f,
  1.37295246e-01f, 1.26644880e-01f, -2.50659078e-01f, 7.88185745e-02f, -1.25173658e-01f, 9.26058888e-02f, 3.17075476e-02f, 1.54169589e-01f, 7.10418001e-02f, 6.05071820e-02f,
  -6.94487691e-02f, -1.14922717e-01f, -1.11918291e-03f, 4.55764122e-02f, -6.16138317e-02f, -1.03506520e-01f, 3.92137542e-02f, -7.40602836e-02f, -2.47815368e-03f, 4.69696149e-02f,
  4.27803509e-02f, -1.39893308e-01f, -3.60732898e-02f, 3.80692557e-02f, 1.13613099e-01f, 8.49983245e-02f, 8.30480307e-02f, 6.23839125e-02f, 7.16830418e-02f, 8.42291266e-02f,
  -2.12496966e-01f, 1.41334683e-01f, 7.62702152e-02f, -3.34063661e-03f, -5.98858409e-02f, 3.62737142e-02f, 3.88557054e-02f, 3.34219001e-02f, -5.22179604e-02f, -5.60759008e-03f,
  1.12613991e-01f, 1.14230305e-01f, 6.06047176e-02f, 2.87805796e-02f, -9.96526629e-02f, 4.79575805e-02f, -4.74737361e-02f, -9.36349407e-02f, 5.66571169e-02f, -2.31433034e-01f,
  -1.42906979e-01f, -1.15888037e-01f, 3.00358951e-01f, 3.13195996e-02f, -7.12396055e-02f, 3.33693549e-02f, 9.86924395e-02f, 3.30477320e-02f, 2.47875974e-01f, 3.23356062e-01f,
  1.67089142e-02f, 3.33126634e-01f, 1.41772535e-03f, 2.82613449e-02f, -7.77683184e-02f, 4.61215526e-02f, 6.63510934e-02f, -9.38678626e-03f, -9.42494869e-02f, -3.34699869e-01f,
  2.28292823e-01f, 2.04383761e-01f, -1.02758422e-01f, 1.27192959e-01f, -9.74634886e-02f, -2.94453502e-02f, 1.20374197e-02f, -5.89474924e-02f, 1.67605542e-02f, -5.25294244e-02f,
  -1.46950603e-01f, -1.85318649e-01f, -6.93722591e-02f, 3.68368849e-02f, 9.45659354e-02f, -3.25504728e-02f, 1.36625059e-02f, -7.25505576e-02f, -1.14032276e-01f, 1.40403351e-02f,
  -9.46896896e-02f, 1.36942985e-02f, -5.24962135e-03f, 2.10896078e-02f, 3.40768769e-02f, 5.29939160e-02f, 2.72279102e-02f, -8.25985670e-02f, 7.63047785e-02f, -3.49549949e-02f,
  -4.17231545e-02f, -2.78765871e-03f, -4.89044785e-02f, -1.21947683e-01f, 5.02543710e-02f, -2.54347958e-02f, -4.41531129e-02f, -1.19912717e-02f, -1.73031259e-02f, -5.15392572e-02f,
  -4.09115963e-02f, -9.02420282e-02f, -1.39981359e-01f, 7.28979111e-02f, -2.40128469e-02f, -1.62627883e-02f, 3.46727036e-02f, -6.16912432e-02f, -1.26351556e-02f, -1.04550689e-01f,
  -5.31288013e-02f, 1.16475569e-02f, -6.09144894e-03f, 3.75253223e-02f, -8.20980370e-02f, -4.49313177e-03f, -1.70897141e-01f, -6.66438267e-02f, -4.91953827e-03f, 6.91016018e-02f,
  -9.29645374e-02f, -4.33674315e-04f, 1.65493771e-01f, -6.54805005e-02f, 1.10507850e-02f, 1.03713498e-01f, 8.58500525e-02f, 5.21520674e-02f, -7.60595407e-03f, 4.27630991e-02f,
  -1.34662846e-02f, 2.31360761e-03f, -7.92133957e-02f, -9.27428305e-02f, -9.26819071e-02f, 1.34739190e-01f, -1.92850381e-01f, -2.38858238e-02f, -2.03741580e-01f, 6.50471076e-02f,
  -9.72833484e-03f, 2.47058328e-02f, -5.79203442e-02f, -1.73521832e-01f, -4.33463268e-02f, -3.62061337e-02f, 6.36241958e-02f, -9.78782400e-02f, 7.26556405e-02f, 4.20206711e-02f,
  2.96936445e-02f, -1.13902666e-01f, 5.28221652e-02f, -3.29909250e-02f, 2.98121404e-02f, -4.23489362e-02f, 1.25586078e-01f, -3.33827697e-02f, 1.65629148e-01f, 4.32226211e-02f,
  1.66109838e-02f, -2.91000456e-02f, -5.87055273e-02f, 1.81193911e-02f, 2.08059669e-01f, 1.30019039e-01f, 1.18287824e-01f, -7.22985566e-02f, -1.48327485e-01f, -5.93785010e-02f,
  1.60842463e-01f, -6.29230263e-03f, 2.22636372e-01f, 1.07559308e-01f, -4.33241716e-04f, -2.03439593e-01f, -2.62088627e-01f, 1.88268796e-02f, -3.51896957e-02f, 1.07839838e-01f,
  -1.00047551e-01f, 1.01939127e-01f, 7.85876885e-02f, 5.17138578e-02f, 3.31782294e-03f, -7.83206373e-02f, -5.55902682e-02f, 6.33185497e-03f, 6.57113492e-02f, -3.42788011e-01f,
  4.42235395e-02f, -8.37394223e-02f, -9.61226746e-02f, -4.03247327e-02f, -8.56200680e-02f, 1.53548121e-01f, 6.66376054e-02f, -5.71508147e-02f, 3.76952887e-02f, 1.34794995e-01f,
  1.13032028e-01f, -5.65938987e-02f, 1.20961688e-01f, 9.96103585e-02f, -9.96565796e-04f, -4.32784818e-02f, -2.78952476e-02f, 1.01265781e-01f, -2.43354551e-02f, 2.81639881e-02f,
  -5.65868831e-05f, -9.51499678e-03f, 1.59369893e-02f, 8.18475485e-02f, -5.02295643e-02f, 2.83840392e-02f, -4.86037284e-02f, -3.88837531e-02f, -7.05956817e-02f, -9.23850015e-03f,
  -1.60278156e-02f, -1.45646865e-02f, -1.31455034e-01f, 1.37601674e-01f, -5.04811518e-02f, 3.07241585e-02f, -5.98642789e-02f, 1.13259360e-01f, -8.40456877e-03f, 3.56073268e-02f,
  -7.20954547e-03f, -1.56353917e-02f, 5.47304153e-02f, 1.94009189e-02f, -1.13174506e-01f, -2.19854265e-02f, 2.24776156e-02f, 6.45349454e-03f, -8.55551381e-03f, -8.40311423e-02f,
  1.81652270e-02f, -1.24053545e-01f, -1.14178937e-02f, 1.16961338e-01f, 2.22743735e-01f, 1.87604427e-02f, -1.38218343e-01f, 3.79437357e-02f, 6.41755238e-02f, -2.96759028e-02f,
  -6.09757006e-02f, 4.12067436e-02f, 1.54922798e-01f, -1.41529873e-01f, -2.23780908e-02f, -1.75829697e-02f, 1.15061134e-01f, 2.25156382e-01f, 1.19052473e-02f, 2.51014847e-02f,
  1.32220075e-01f, 3.32103930e-02f, 2.62174122e-02f, 1.14298966e-02f, 2.40944684e-01f, 1.17186587e-02f, -1.66245364e-02f, 9.64165106e-02f, 2.24122539e-01f, 1.60529129e-02f,
  -8.44484940e-02f, 4.44097295e-02f, 1.79699864e-02f, 1.40983418e-01f, 6.96101831e-03f, -5.42857796e-02f, -7.88945928e-02f, -1.01545927e-04f, -6.35442212e-02f, 1.21069208e-01f,
  4.92836721e-02f, 4.57137823e-02f, -3.83072756e-02f, -1.59225166e-01f, -1.99127514e-02f, -1.28118858e-01f, -3.42938416e-02f, -1.45181656e-01f, -2.15227827e-01f, -1.13067701e-01f,
  1.41158879e-01f, 7.98776895e-02f, 7.13908449e-02f, 9.67641175e-02f, 2.58241296e-02f, 1.59846410e-01f, 8.52638930e-02f, 4.87628318e-02f, -1.75956294e-01f, 2.60297596e-01f,
  -1.14718594e-01f, -8.95503014e-02f, 7.77933821e-02f, 1.38009921e-01f, -1.26409782e-02f, -2.79987872e-01f, 2.58325279e-01f, -1.86860174e-01f, 7.10479841e-02f, 7.52038369e-03f,
  1.30596563e-01f, 1.01508528e-01f, 2.74841171e-02f, 1.60628974e-01f, 1.25050277e-01f, 6.62207603e-02f, 4.14972045e-02f, -3.31296414e-01f, -2.96625607e-02f, -1.19954892e-01f,
  -7.16412254e-03f, 6.73762697e-04f, -5.38900634e-03f, -2.00133445e-03f, 1.18672978e-02f, 3.05078011e-02f, 3.74795310e-02f, 1.27602845e-01f, -1.01307899e-01f, 5.06200455e-02f,
  6.03079051e-02f, 2.15305351e-02f, -2.45283265e-03f, -6.81776404e-02f, 5.04091717e-02f, 1.16503023e-01f, 5.12762852e-02f, 3.55667435e-02f, -6.40816540e-02f, 2.22023241e-02f,
  4.59668785e-02f, -7.98316896e-02f, -1.88747998e-02f, -8.79068673e-03f, 3.95553634e-02f, 1.03752516e-01f, 5.65819331e-02f, -1.07579909e-01f, -5.50986789e-02f, -5.48520461e-02f,
  -9.20848101e-02f, -7.31704682e-02f, -3.45929824e-02f, 3.26097608e-02f, 1.17570776e-02f, 9.94511768e-02f, -4.71873283e-02f, 1.46544561e-01f, 9.18360204e-02f, 5.32671399e-02f,
  3.60767767e-02f, 4.22448153e-03f, 1.68188196e-02f, 8.48949030e-02f, -2.74258927e-02f, -7.07155094e-03f, 8.71239528e-02f, -1.54698312e-01f, 7.19016716e-02f, -9.47239995e-03f,
  -1.06394909e-01f, 9.27735027e-03f, 1.71268374e-01f, 6.89643845e-02f, 1.47074208e-01f, -1.89912952e-02f, -1.18972458e-01f, 4.22799028e-02f, -2.51914002e-02f, 3.63722630e-02f,
  1.87156856e-01f, -1.10188507e-01f, -1.95664048e-01f, -1.67945642e-02f, 4.78100963e-02f, -8.71490762e-02f, -2.93830149e-02f, 6.60676658e-02f, 5.72043471e-02f, -8.43181387e-02f,
  8.64084661e-02f, -2.27401685e-02f, 1.47010162e-01f, 9.20703933e-02f, -5.29105961e-02f, -1.43884361e-01f, -7.82024860e-02f, -4.55321558e-02f, -3.97777446e-02f, -5.16555868e-02f,
  7.32151046e-02f, 1.40764475e-01f, 1.83954477e-01f, 2.93210000e-02f, -7.31743202e-02f, -1.11588120e-01f, 3.67450481e-03f, -1.51941478e-01f, 8.07090998e-02f, 8.19325969e-02f,
  1.63292095e-01f, -1.32162124e-01f, 1.83171257e-02f, 4.66287695e-02f, 2.78541390e-02f, -8.00473318e-02f, 3.12704332e-02f, 7.65676436e-04f, -2.29969975e-02f, 1.01880848e-01f,
  1.22956738e-01f, 1.93770546e-02f, -5.95806576e-02f, -9.19005498e-02f, 9.40001681e-02f, 1.39387250e-01f, 5.61313033e-02f, -2.44681031e-01f, 4.41490561e-02f, -1.38847515e-01f,
  -5.21105044e-02f, -1.98683124e-02f, 1.68073494e-02f, 2.06159979e-01f, -1.31832153e-01f, -9.28352177e-02f, 2.59218458e-02f, 9.91294160e-02f, -1.53882205e-01f, -2.46298220e-02f,
  -1.29020125e-01f, 2.36423507e-01f, -3.35314870e-02f, -2.83548329e-02f, 2.16128528e-01f, 1.61139429e-01f, 4.69895266e-02f, 8.71201381e-02f, 2.12829486e-02f, -8.21684604e-04f,
  8.56118947e-02f, 7.97986016e-02f, -1.24135546e-01f, 2.89405975e-02f, 1.03733549e-02f, -3.74770463e-02f, 4.74841408e-02f, -1.00937054e-01f, 7.16677755e-02f, 6.63338508e-03f,
  2.28824466e-02f, -1.52206212e-01f, -2.48280838e-02f, 8.76746178e-02f, 4.80174683e-02f, 1.07864350e-01f, -7.87048042e-02f, 1.60105467e-01f, 6.38480186e-02f, -4.45710085e-02f,
  4.08296436e-02f, 6.01250976e-02f, 2.37839594e-02f, 4.53671552e-02f, -6.38476899e-03f, 3.69568504e-02f, -5.27571402e-02f, -5.22612035e-02f, 6.44173771e-02f, 5.23894653e-02f,
  3.13032456e-02f, -6.67157918e-02f, 1.70459840e-02f, 5.70543297e-02f, -5.89502603e-02f, 3.27098854e-02f, -4.40130271e-02f, 9.06101316e-02f, 4.19667698e-02f, 8.92014951e-02f,
  3.65894400e-02f, -4.20934893e-02f, -8.04361552e-02f, 8.52138102e-02f, -1.01005333e-02f, -7.04253986e-02f, -8.91871005e-02f, 3.62347513e-02f, -5.05615473e-02f, 8.99604615e-03f,
  -4.74502482e-02f, 5.06623052e-02f, -5.75719774e-02f, 4.42725047e-02f, 3.21470834e-02f, 7.89836124e-02f, -3.60742095e-03f, -2.84967311e-02f, 2.90879030e-02f, 1.14958867e-01f,
  8.29544440e-02f, 1.40742540e-01f, -2.95187738e-02f, 6.68614060e-02f, -7.43443593e-02f, 7.22218165e-03f, -1.40145365e-02f, 6.77700937e-02f, -1.01279005e-01f, 2.27158312e-02f,
  -1.07223064e-01f, -1.82025060e-02f, 7.18587488e-02f, 1.72942951e-01f, 1.19881757e-01f, 2.94637233e-02f, -1.47748560e-01f, -1.19619280e-01f, 1.53973043e-01f, -1.23145990e-02f,
  -4.28634975e-03f, -7.72373006e-02f, 2.00486496e-01f, -1.88196808e-01f, -4.75001261e-02f, -9.09508113e-03f, 5.87008102e-03f, 1.49261162e-01f, 8.50899816e-02f, -1.56500190e-02f,
  -2.15696990e-02f, -8.93462002e-02f, 1.91767976e-01f, -4.36585285e-02f, -5.22699729e-02f, -1.37044059e-03f, 3.10792048e-02f, 1.08191255e-03f, 7.55040720e-03f, 2.51633525e-01f,
  4.97108400e-02f, -1.57183092e-02f, -2.28483036e-01f, 8.11153576e-02f, 2.11605906e-01f, 1.06446095e-01f, -1.60786346e-01f, -1.25947418e-02f, -1.19351320e-01f, 1.29863933e-01f,
  7.79445609e-03f, -1.04429740e-02f, 2.64639705e-01f, -6.60820529e-02f, -1.31421455e-03f, -1.26042971e-02f, -1.46379590e-01f, -7.58450255e-02f, 8.29274356e-02f, -9.64738950e-02f,
  9.14327279e-02f, -1.32745951e-01f, 9.52838063e-02f, -3.86240512e-01f, 8.56975988e-02f, 5.47822751e-03f, -2.42798943e-02f, 5.71538694e-02f, 1.04943544e-01f, -6.78716376e-02f,
  -4.79027703e-02f, 5.02529927e-02f, -1.05755486e-01f, -1.57045610e-02f, 3.47130443e-03f, 8.93574208e-02f, 6.18473720e-03f, 8.87021273e-02f, -1.19018294e-02f, -2.19026767e-02f,
  4.56307568e-02f, 3.81243019e-03f, 4.56939787e-02f, -1.98519770e-02f, 9.13400017e-03f, -3.42329592e-02f, -5.96161857e-02f, 1.62225857e-01f, -5.99353900e-03f, 5.35086952e-02f,
  1.05766483e-01f, 2.36408953e-02f, -1.43338472e-01f, 7.41306320e-02f, 5.95082045e-02f, -3.28241773e-02f, -6.70842081e-02f, -5.16027175e-02f, 7.32388347e-03f, 1.61565527e-01f,
  -1.18849911e-02f, -8.01912174e-02f, -1.55256269e-02f, 3.36869620e-02f, -1.32028749e-02f, 6.49857372e-02f, 9.51449424e-02f, -3.70411575e-02f, 7.35977665e-02f, 1.68077663e-01f,
  3.79838538e-03f, -9.18059051e-02f, -3.12869996e-02f, -2.59251352e-02f, 4.49202396e-02f, 5.37956357e-02f, 9.55117792e-02f, -2.50362381e-02f, -5.38082607e-02f, -4.13224697e-02f,
  1.81191799e-03f, -5.93479797e-02f, -1.09941252e-01f, -7.20654950e-02f, -1.70247927e-01f, -8.80028680e-02f, -9.71275270e-02f, 8.21657553e-02f, 9.66559630e-03f, 2.48979349e-02f,
  -8.44026580e-02f, -1.00368284e-01f, 4.05373424e-02f, -1.16700090e-01f, -8.30464214e-02f, 4.05444168e-02f, -1.49947122e-01f, -8.00325796e-02f, 1.23326890e-01f, 3.91694112e-03f,
  9.35882926e-02f, -2.43439283e-02f, -1.64896213e-02f, 2.30454393e-02f, 2.64533788e-01f, 1.17337676e-02f, -1.97253237e-03f, -6.60730153e-03f, -1.91794317e-02f, -3.13524979e-05f,
  -9.17657390e-02f, 1.03954732e-01f, 7.45976344e-02f, -1.34635434e-01f, -1.29851708e-02f, -7.59453699e-02f, -3.76957767e-02f, -3.94092016e-02f, 4.19774950e-02f, 2.66768169e-02f,
  -5.92266060e-02f, -9.48683918e-02f, 1.28312439e-01f, -2.15227660e-02f, -1.28191426e-01f, -5.72079681e-02f, 8.33277106e-02f, -3.85548212e-02f, 1.16077349e-01f, -1.95468143e-01f,
  1.15338996e-01f, 8.75894725e-02f, -1.62940666e-01f, -1.53450876e-01f, 2.54209992e-02f, 1.55021980e-01f, 1.41615987e-01f, -1.29329577e-01f, -4.27513272e-01f, -4.49550524e-02f,
  -4.40793991e-01f, 5.43688983e-02f, -4.28643450e-02f, -1.37216479e-01f, 1.43492296e-01f, 5.85849583e-02f, 3.46853212e-02f, -6.41837940e-02f, -8.72798357e-03f, -5.73069137e-03f,
  -2.20091254e-01f, 4.74616796e-01f, 1.43762633e-01f, 7.42643932e-03f, 3.38724367e-02f, -1.03473142e-01f, -1.76755805e-02f, -6.04232308e-03f, -4.30965237e-02f, 7.86778331e-02f,
  -4.88957018e-02f, 6.57410696e-02f, -5.68956658e-02f, -3.23022269e-02f, 1.14381989e-03f, -1.38013899e-01f, 1.39096985e-02f, 1.52409688e-01f, 1.05814524e-01f, 1.01632597e-02f,
  1.35769799e-01f, -1.36368170e-01f, 1.18653970e-02f, -6.29058033e-02f, 4.66381609e-02f, 4.43223007e-02f, -1.11413427e-01f, -9.31774899e-02f, 8.50639567e-02f, 1.47033408e-01f,
  2.42638309e-02f, 5.21463193e-02f, 8.93031433e-02f, 6.49453551e-02f, 5.76869324e-02f, 9.55971237e-03f, -1.16069717e-02f, 5.57568623e-03f, 3.37219499e-02f, 2.61278395e-02f,
  -1.01788551e-01f, -7.18934461e-03f, -3.76114435e-02f, -1.07439816e-01f, -5.14824502e-02f, -1.14769246e-02f, 8.75699054e-03f, -9.31149125e-02f, 1.07187428e-01f, -8.15009847e-02f,
  2.44846251e-02f, 7.44659230e-02f, -5.72257936e-02f, -2.67569311e-02f, -7.21975341e-02f, 4.96506169e-02f, 7.69688860e-02f, 1.36894986e-01f, -5.64311631e-02f, -7.41052404e-02f,
  7.73197711e-02f, 6.88297860e-03f, -4.53165248e-02f, -2.04021353e-02f, -3.40558253e-02f, 5.18365614e-02f, -2.26650149e-01f, 9.80328396e-02f, 6.58441484e-02f, -8.97041261e-02f,
  -6.62700832e-02f, -1.37115389e-01f, -3.48562114e-02f, 1.18397512e-02f, 8.27025808e-03f, -1.45918816e-01f, -2.22485829e-02f, 8.90330523e-02f, 2.94242613e-03f, -6.56467443e-03f,
  3.04270629e-02f, 1.25492876e-02f, 1.17918946e-01f, 8.36895779e-02f, 5.98606654e-02f, -1.31628988e-02f, -3.42691205e-02f, -5.87833440e-03f, -1.12858079e-01f, -1.50173664e-01f,
  -2.28520576e-02f, -1.19234703e-01f, -3.04704886e-02f, 3.66756953e-02f, -1.24911800e-01f, -3.94530408e-02f, -4.80437018e-02f, -8.00462663e-02f, -1.00305956e-02f, -8.13597739e-02f,
  -1.52820677e-01f, 2.40585208e-01f, -4.23675962e-02f, 4.65773754e-02f, -5.34477457e-02f, 1.18661928e-03f, 1.15761213e-01f, -1.37415126e-01f, -1.48651928e-01f, 1.05043994e-02f,
  2.40655139e-01f, -2.22320005e-01f, -1.08428232e-01f, 2.47244770e-03f, -4.64198515e-02f, 2.28425279e-01f, 1.33516595e-01f, 2.20749527e-01f, -1.74300775e-01f, 1.07254229e-01f,
  -7.24033788e-02f, 9.84298587e-02f, -5.18970527e-02f, -5.71536422e-02f, 4.95491847e-02f, 4.14337963e-02f, 2.04112574e-01f, -2.54505426e-01f, -2.38742381e-02f, 1.62045673e-01f,
  -3.88439782e-02f, -5.95322512e-02f, 1.15891676e-02f, -3.87571938e-02f, -6.25506118e-02f, 4.92207259e-02f, 4.35337201e-02f, -3.95862535e-02f, -2.16910150e-02f, 9.36019570e-02f,
  -9.77992788e-02f, -2.03294158e-02f, -4.29295301e-02f, -3.58779239e-03f, 6.53244108e-02f, -7.44629875e-02f, -6.46116063e-02f, -4.96104769e-02f, -9.30472165e-02f, 1.08090602e-01f,
  4.26318496e-02f, 1.23309180e-01f, 9.43398383e-03f, -6.29694387e-02f, 8.15952569e-02f, -1.36680126e-01f, 1.12300077e-02f, 9.09919441e-02f, 2.45642439e-02f, -6.14060089e-02f,
  1.35548279e-01f, -4.66415100e-02f, 7.78778177e-03f, -1.39820397e-01f, 1.42251858e-02f, 6.84872940e-02f, 1.52213583e-02f, 7.01941317e-03f, 1.37932122e-01f, 3.46551985e-02f,
  1.08697720e-01f, 1.04223870e-01f, -8.07457864e-02f, 1.02594018e-01f, 5.58075793e-02f, -3.50318067e-02f, 3.30247506e-02f, -7.42428079e-02f, -1.05678156e-01f, 3.17483470e-02f,
  -8.33258852e-02f, 3.90346870e-02f, -3.27013135e-02f, 8.00873339e-02f, 1.42364189e-01f, -1.44150993e-03f, 6.64580939e-03f, -2.30699833e-02f, -6.69345558e-02f, 1.60173506e-01f,
  -1.43273897e-03f, 3.21375169e-02f, -1.11512095e-02f, -2.33517140e-02f, -1.66821331e-01f, 9.66228098e-02f, 9.88594722e-03f, 7.52546489e-02f, 2.56376676e-02f, 1.10489680e-02f,
  1.73313260e-01f, 2.72145029e-02f, 1.18057402e-02f, 4.83294241e-02f, 1.02176055e-01f, 2.15462178e-01f, -5.34908064e-02f, -5.33079170e-02f, 1.22494407e-01f, 5.34128100e-02f,
  1.74032282e-02f, 9.74774957e-02f, 5.91506697e-02f, -1.41974036e-02f, 1.96931064e-01f, -9.69140530e-02f, -9.79370102e-02f, -5.89914992e-03f, 3.75285260e-02f, -1.84133291e-01f,
  1.97498724e-02f, 3.05801500e-02f, 7.62047097e-02f, -2.67106090e-02f, 2.93003935e-02f, -2.87548602e-02f, -3.97848822e-02f, -6.67893291e-02f, 2.11949050e-02f, 8.27746168e-02f,
  8.48557043e-04f, 1.03206076e-01f, 5.81101179e-02f, -2.31132489e-02f, -2.85633393e-02f, -3.89138162e-02f, -2.47795787e-02f, -6.51320489e-03f, -2.76565123e-02f, -1.78192109e-01f,
  -7.55536929e-02f, -5.53275160e-02f, -1.02055199e-01f, -6.09837361e-02f, -2.03030720e-01f, 3.39629233e-01f, -2.83435397e-02f, -1.18493043e-01f, 2.26741433e-02f, 4.89533357e-02f,
  -1.40209198e-01f, -2.35996060e-02f, -1.55776307e-01f, 1.45131856e-01f, -2.50931364e-02f, -5.46168629e-03f, 1.39425188e-01f, 4.31264713e-02f, 3.48059572e-02f, 7.34058470e-02f,
  -4.20783237e-02f, 2.71313675e-02f, -8.28825980e-02f, 8.51367880e-03f, -6.32721707e-02f, 6.60736766e-03f, -5.51120006e-02f, 6.40702695e-02f, 5.87755628e-02f, 7.65736923e-02f,
  -6.88773692e-02f, -2.16971431e-02f, -7.71826431e-02f, -4.58132802e-03f, -1.76018812e-02f, -2.88555995e-02f, -6.46618530e-02f, -6.93971813e-02f, 5.10491803e-02f, 1.63413156e-02f,
  -1.24783486e-01f, -9.58929360e-02f, 8.63869339e-02f, 1.39368642e-02f, 6.26560301e-02f, 2.97112837e-02f, -5.25207147e-02f, -6.29015639e-02f, 1.14364929e-01f, -1.91994049e-02f,
  1.58077274e-02f, 1.17279962e-01f, 7.98847973e-02f, -6.26342073e-02f, 6.50139675e-02f, -8.13113153e-02f, -8.80454183e-02f, -1.31881312e-01f, -1.00923017e-01f, 3.55575979e-03f,
  -4.35035974e-02f, 9.63167623e-02f, -4.96654138e-02f, 5.10337017e-02f, -9.69721526e-02f, 1.11065529e-01f, -4.44285385e-02f, 3.53729352e-02f, 6.52551576e-02f, 7.13373795e-02f,
  -1.49061410e-02f, -7.10892454e-02f, -1.28952503e-01f, -2.33472302e-03f, -5.55939749e-02f, 4.98878397e-02f, 1.03644647e-01f, -6.39159828e-02f, 2.80553680e-02f, -7.89263844e-03f,
  -5.31819165e-02f, -6.24163523e-02f, 2.56311923e-01f, -9.47658271e-02f, -2.13133488e-02f, 1.30091026e-01f, 6.95168525e-02f, 4.98577692e-02f, 3.13494378e-03f, 1.26681952e-02f,
  6.38487190e-02f, 7.48276636e-02f, -7.83175677e-02f, -1.00055314e-03f, 3.43757346e-02f, -5.96122034e-02f, -2.77235452e-02f, 6.80665001e-02f, 4.90568355e-02f, -1.75581262e-01f,
  -9.90616381e-02f, 1.66199135e-03f, -7.50243142e-02f, -1.57412551e-02f, 7.56875649e-02f, 4.04935628e-02f, 1.76396202e-02f, 1.62309080e-01f, 2.08361000e-01f, -1.17200978e-01f,
  1.03056259e-01f, 2.12592054e-02f, -5.71727343e-02f, 7.06869587e-02f, -6.28670380e-02f, 1.01201855e-01f, 2.50851642e-02f, -6.37995973e-02f, 5.12345135e-02f, -7.43855312e-02f,
  -4.53557670e-02f, 1.79190129e-01f, 4.42976356e-02f, 7.95447752e-02f, 4.85573476e-03f, 1.04799159e-02f, -3.25549506e-02f, 2.80966640e-01f, 1.00677036e-01f, 4.68569733e-02f,
  3.54657769e-02f, -2.83356220e-01f, -4.95637394e-02f, -2.19910681e-01f, 9.16394666e-02f, 1.13855384e-01f, -6.60056248e-02f, -1.56799823e-01f, 5.56785986e-02f, 8.91472921e-02f,
  2.39063337e-01f, -1.87798381e-01f, -7.87016600e-02f, 5.48160151e-02f, -1.39669418e-01f, -1.94281951e-01f, -1.61936637e-02f, -4.17387523e-02f, 7.97948167e-02f, -5.32189012e-02f,
  4.23780493e-02f, 6.94221556e-02f, -7.23754317e-02f, 1.31964451e-02f, -3.20258513e-02f, 4.85085323e-02f, 1.86437350e-02f, -1.20595366e-01f, 5.03776334e-02f, 9.92737710e-02f,
  5.47938906e-02f, -1.19335726e-02f, 9.44060832e-03f, 1.57380059e-01f, 2.88977064e-02f, 1.02061145e-01f, -8.61644894e-02f, 5.62042110e-02f, 1.02568947e-01f, 8.57683644e-02f,
  -2.91298851e-02f, 1.45798042e-01f, -2.80412436e-02f, -6.08711876e-02f, -7.12154880e-02f, 3.33821252e-02f, -3.92366014e-02f, -1.60298832e-02f, 1.41404495e-01f, 1.02092639e-01f,
  6.07959181e-02f, -4.68473695e-02f, -1.07084803e-01f, -4.38150652e-02f, 1.06159002e-01f, 5.26431911e-02f, -2.16224521e-01f, -1.46294478e-02f, -8.00125897e-02f, -4.24471870e-02f,
  1.25114828e-01f, 2.15073247e-02f, 4.05952036e-02f, 1.60072129e-02f, -1.51900789e-02f, 3.32084969e-02f, -6.82962500e-03f, -9.64679047e-02f, 6.43644109e-03f, 4.56552468e-02f,
  7.23043755e-02f, 1.20395701e-02f, 6.56030029e-02f, 3.71247269e-02f, -2.10962728e-01f, 3.64539512e-02f, -9.95962098e-02f, -2.66311970e-02f, 7.44205862e-02f, -3.44864577e-02f,
  9.52787101e-02f, -2.34553311e-02f, -3.17523964e-02f, -5.29611483e-02f, 3.02196462e-02f, -8.19678977e-02f, 1.51887372e-01f, 2.96749789e-02f, -1.68077275e-01f, -4.99502011e-02f,
  3.74398790e-02f, 7.45724365e-02f, 2.45259088e-02f, -2.53070444e-02f, -1.49276718e-01f, -8.80242884e-03f, 1.11618541e-01f, -1.75992548e-01f, 4.08970416e-02f, 1.61498591e-01f,
  -1.49958138e-03f, 6.35019913e-02f, -3.99821438e-02f, -7.44679477e-03f, -2.02863738e-01f, -1.36818171e-01f, 6.84597194e-02f, 9.87234414e-02f, 1.47429496e-01f, 1.48214281e-01f,
  -4.97846194e-02f, -3.53793353e-02f, -1.04518443e-01f, -3.53936963e-02f, 6.61836565e-02f, -1.38240531e-01f, -2.97487751e-02f, -1.02300152e-01f, 1.83831751e-01f, -2.13519502e-02f,
  2.26715833e-01f, -1.56017497e-01f, -8.62071589e-02f, 2.16152579e-01f, 1.57822035e-02f, 2.55462557e-01f, -5.68378754e-02f, 1.58121273e-01f, -2.44868230e-02f, -6.91547804e-03f,
  -3.64978403e-01f, -6.16002642e-02f, -3.01131636e-01f, 1.43390134e-01f, 4.44931760e-02f, -2.36373708e-01f, -6.46257252e-02f, 2.48382296e-02f, -1.26289755e-01f, -1.73010990e-01f,
  9.61481631e-02f, -1.82457700e-01f, -9.51888505e-04f, -6.17261529e-02f, -2.96205040e-02f, 1.91600192e-02f, 2.89377496e-02f, 1.19632609e-01f, -5.11382595e-02f, -7.42078433e-03f,
  1.63035035e-01f, 1.05676278e-01f, -8.32054298e-03f, 8.28591585e-02f, -1.03704650e-02f, 1.77121669e-01f, 9.35650766e-02f, 1.79872457e-02f, 3.96622345e-02f, -1.85090322e-02f,
  -7.73300556e-03f, 1.80530306e-02f, 7.83487502e-03f, 5.27953096e-02f, 2.66506732e-03f, -3.12490053e-02f, 3.01787257e-02f, -6.69797659e-02f, -1.11120744e-02f, -4.27527004e-04f,
  7.36129582e-02f, -3.46775241e-02f, 3.10304035e-02f, 3.67550403e-02f, 3.36757898e-02f, 5.45681603e-02f, 1.60387177e-02f, 3.07571907e-02f, -7.73266107e-02f, 6.17681891e-02f,
  7.51588047e-02f, 1.91220585e-02f, -6.53693900e-02f, -1.63257848e-02f, 1.16885394e-01f, -7.09263328e-03f, 3.67917307e-02f, -1.38097638e-02f, 9.31158885e-02f, -1.19087100e-02f,
  7.70560130e-02f, 1.34295017e-01f, 7.85490964e-03f, 3.92838493e-02f, 1.13658816e-01f, 4.43674566e-04f, -3.55361514e-02f, 8.22484046e-02f, 2.57885661e-02f, 1.33203924e-01f,
  1.06741879e-02f, -8.54525864e-02f, 1.36561900e-01f, 2.24181674e-02f, 6.13335967e-02f, 3.65130529e-02f, 1.35826133e-03f, -1.00545548e-01f, 7.98299462e-02f, 1.82059966e-02f,
  -2.67300382e-02f, 8.21292177e-02f, 6.70808181e-02f, 3.27518545e-02f, -1.22669362e-01f, 1.30846441e-01f, 1.81540456e-02f, -6.21599928e-02f, -1.38356239e-01f, -2.64606643e-02f,
  -5.14098965e-02f, 8.35112482e-02f, 1.15783073e-01f, 4.27228361e-02f, 2.05690507e-02f, -1.05563700e-01f, -4.19045985e-02f, -1.31915584e-01f, 1.12863388e-02f, -2.04283834e-01f,
  -2.64846776e-02f, 5.41275367e-02f, 3.55782695e-02f, 1.61152601e-01f, -4.00474854e-02f, 5.19515611e-02f, -1.48467366e-02f, 3.49911936e-02f, 9.44001786e-03f, 1.06943371e-02f,
  -3.38450409e-02f, -2.15725973e-01f, -2.36159876e-01f, 1.42084613e-01f, 1.34685598e-02f, 1.57881364e-01f, 1.62787810e-01f, -1.20772660e-01f, -6.10781088e-02f, 2.57660057e-02f,
  -1.52157411e-01f, -4.68689390e-02f, 9.74875912e-02f, -6.93534911e-02f, 1.66317329e-01f, -1.29062742e-01f, -7.56887943e-02f, 5.22251166e-02f, 1.71647936e-01f, 1.21265791e-01f,
  -1.43747970e-01f, -5.68243228e-02f, -6.65509775e-02f, 2.09581956e-01f, 1.40837478e-02f, 8.62313248e-03f, 6.48892224e-02f, -6.11615367e-02f, 1.60890013e-01f, 1.39136896e-01f,
  1.88314795e-01f, 5.37992492e-02f, -4.53151576e-02f, 1.91163979e-02f, -1.90686472e-02f, -3.22439782e-02f, -2.98178252e-02f, 4.68640262e-03f, 1.84327006e-01f, -1.15875915e-01f,
  -7.55151268e-03f, -3.93398106e-03f, 2.67382339e-02f, 5.09426668e-02f, -1.24505849e-03f, 1.27374083e-01f, -2.15779021e-02f, 4.71033566e-02f, -1.33921495e-02f, -4.79944870e-02f,
  3.46010327e-02f, -8.58356804e-02f, 3.91498283e-02f, -9.46959779e-02f, -1.08341374e-01f, 3.72225754e-02f, -4.31286655e-02f, 1.42345466e-02f, 1.30796164e-01f, 9.08277854e-02f,
  -3.53152119e-02f, 2.02697236e-02f, -7.94815719e-02f, 7.39964098e-02f, 1.44562395e-02f, 2.19798032e-02f, 1.51361469e-02f, 1.32025573e-02f, -8.18931870e-03f, -5.04977554e-02f,
  7.35533163e-02f, -1.61868483e-02f, -1.07803270e-01f, -1.12203211e-02f, 1.20833345e-01f, -4.58990857e-02f, 7.73347244e-02f, 1.06555276e-01f, 6.36093020e-02f, -1.49136642e-02f,
  2.81669870e-02f, 1.30157456e-01f, 8.70103687e-02f, 1.60032839e-01f, 4.14455533e-02f, 3.88605311e-03f, -3.81597765e-02f, 1.63758118e-02f, 5.81855141e-02f, -1.08817510e-01f,
  3.46045047e-02f, -5.48003577e-02f, 4.88715656e-02f, 8.22040960e-02f, 5.50045706e-02f, 6.53120279e-02f, 2.49101371e-02f, -1.23273414e-02f, 5.20090945e-02f, -6.08545095e-02f,
  -7.69638130e-03f, -6.38796836e-02f, -6.32215962e-02f, 1.12100929e-01f, -5.69809340e-02f, -9.78480428e-02f, -1.64693035e-02f, -6.07952699e-02f, 2.30410978e-01f, -1.27845928e-01f,
  -1.20706588e-01f, -5.23042260e-03f, 8.96557122e-02f, -1.65583059e-01f, 5.70058264e-02f, -1.41256094e-01f, -9.43103246e-03f, -5.63229918e-02f, -4.34439331e-02f, 6.13264628e-02f,
  1.12582343e-02f, 1.38417065e-01f, -1.37167215e-01f, 4.59511466e-02f, -6.25653565e-02f, 7.54318684e-02f, 6.58516139e-02f, 8.00992399e-02f, -1.83121324e-01f, 1.17777092e-02f,
  -3.54451910e-02f, 1.21086299e-01f, 5.22041470e-02f, 2.49013770e-03f, 6.81772456e-02f, -1.93311766e-01f, 8.89053103e-03f, 1.57831386e-01f, -3.90626341e-02f, -4.94332202e-02f,
  3.49598820e-03f, -6.63578452e-04f, -2.48550158e-03f, -1.04572229e-01f, 6.43082336e-02f, -8.54491349e-03f, -8.18819627e-02f, -9.90297571e-02f, -4.42895502e-01f, 2.97983903e-02f,
  -4.31617238e-02f, -8.22366700e-02f, 1.60213575e-01f, -4.76862257e-03f, 5.92917204e-03f, -3.41679603e-01f, -1.30730635e-02f, 1.08400239e-02f, -1.99226961e-01f, 4.37544525e-01f,
  6.60877526e-02f, -1.58070236e-01f, 4.58019711e-02f, -5.35274036e-02f, -5.62572712e-03f, 3.97230759e-02f, 2.06341855e-02f, -6.12487979e-02f, 8.91590044e-02f, -1.76056251e-02f,
  1.15264639e-01f, -7.20353946e-02f, 1.23221641e-02f, 2.99188606e-02f, 4.30626124e-02f, -2.77975444e-02f, -3.67950313e-02f, -8.30352493e-03f, 9.92507711e-02f, -3.13859843e-02f,
  5.39959073e-02f, -4.25660834e-02f, -1.09358616e-01f, -8.16117749e-02f, -1.53138146e-01f, -6.03052713e-02f, -8.53158757e-02f, -5.87222762e-02f, 2.61658281e-02f, 9.70890597e-02f,
  1.86900776e-02f, -7.01695085e-02f, 3.64431329e-02f, 4.84276265e-02f, -1.08067971e-02f, -1.51188731e-01f, -2.17525698e-02f, -1.45916149e-01f, -1.06132008e-01f, 1.86394490e-02f,
  9.67564713e-03f, 4.12872024e-02f, 5.35037145e-02f, -6.93958625e-02f, 8.41423422e-02f, -1.92787871e-03f, -7.07990350e-03f, -8.55027735e-02f, 4.66854498e-02f, -8.63929391e-02f,
  7.22637773e-02f, -2.80658174e-02f, -1.01720162e-01f, -1.91906672e-02f, 4.99620214e-02f, 4.34425063e-02f, 5.02919145e-02f, -6.53861389e-02f, 1.13291048e-01f, -5.80097064e-02f,
  7.13296086e-02f, -1.82798002e-02f, -1.78737678e-02f, 8.67425278e-02f, -1.54265657e-01f, -4.13590558e-02f, -3.86797264e-02f, -7.50465393e-02f, -5.08675128e-02f, -6.28331229e-02f,
  1.24791563e-01f, -3.74334008e-02f, 1.24611869e-01f, 3.69736878e-03f, -5.25792129e-02f, -1.86118600e-03f, -7.23147914e-02f, 9.24534947e-02f, 9.14682262e-03f, -5.47498604e-03f,
  -7.40735382e-02f, 3.41974832e-02f, 1.25720486e-01f, -3.53214592e-02f, 5.88156395e-02f, 4.64290157e-02f, 6.65505826e-02f, 4.45610359e-02f, 2.17323424e-03f, 7.60307908e-02f,
  5.70726730e-02f, 9.09509212e-02f, 1.18950553e-01f, 7.33870193e-02f, 1.02423253e-02f, -1.07053496e-01f, -4.14604843e-02f, 8.64906050e-03f, 2.78626140e-02f, 8.13973173e-02f,
  -1.37642637e-01f, -6.68803826e-02f, -8.50061774e-02f, 5.03585897e-02f, -7.54310191e-02f, 2.92401433e-01f, -3.39965910e-01f, 2.11911127e-01f, -1.11997642e-01f, -1.83230475e-01f,
  9.33130330e-04f, 8.60107690e-02f, -5.66882081e-02f, 2.09776402e-01f, 6.13625050e-02f, -4.73162048e-02f, -2.31515422e-01f, -1.69882908e-01f, 2.05081210e-01f, 1.77040085e-01f,
  1.00198850e-01f, 2.68704630e-02f, -6.80882260e-02f, -8.50483254e-02f, 2.51967795e-02f, 1.45667180e-01f, -3.09462190e-01f, 3.90402675e-01f, -7.49838278e-02f, -1.53428176e-02f,
  5.22528514e-02f, 5.36062382e-02f, -2.06494592e-02f, 5.41010275e-02f, -7.17147142e-02f, 2.85923313e-02f, -7.83697292e-02f, 7.88590312e-03f, -3.53085659e-02f, -1.15774147e-01f,
  -6.26790598e-02f, -1.35327261e-02f, 7.19097108e-02f, 1.15045737e-02f, 5.44692166e-02f, -4.76018377e-02f, -7.85282031e-02f, 1.03924528e-01f, 5.62192202e-02f, -6.26193359e-02f,
  2.50158589e-02f, 2.66451705e-02f, -3.33500504e-02f, -7.23178759e-02f, -5.25159538e-02f, 5.23957647e-02f, 4.93173674e-02f, -3.91063094e-02f, -3.86009552e-02f, -8.68590251e-02f,
  -8.57419372e-02f, 9.54599753e-02f, -2.81826220e-02f, -6.55376688e-02f, -1.75210927e-02f, -6.87074848e-03f, 3.15179825e-02f, -3.88978310e-02f, 2.30198223e-02f, -3.25838961e-02f,
  1.64155122e-02f, 3.38982791e-02f, -1.09718397e-01f, -2.22136918e-03f, -1.55282170e-01f, 8.11100081e-02f, -4.35388424e-02f, -5.52543774e-02f, 9.68730450e-03f, 5.12343086e-02f,
  -5.24126750e-04f, 4.02595662e-02f, 8.94665439e-03f, 3.62108126e-02f, 5.08345440e-02f, -1.01316581e-02f, -2.80984386e-04f, 3.35482620e-02f, 8.46004859e-02f, 9.73354131e-02f,
  4.60845381e-02f, -7.97910020e-02f, 6.18412308e-02f, 9.66727287e-02f, -9.00423005e-02f, 5.20200916e-02f, 9.60054845e-02f, 8.47415533e-03f, 3.55068333e-02f, 1.48327202e-01f,
  -1.03946188e-02f, -2.55201831e-02f, 4.58834134e-02f, 2.76583936e-02f, 5.35228811e-02f, 3.36360447e-02f, 2.87749823e-02f, 4.94529754e-02f, -1.06435455e-01f, -5.91499498e-03f,
  1.45033962e-04f, -1.45173892e-01f, -7.59582072e-02f, -1.15824983e-01f, 1.67209923e-01f, 8.36100951e-02f, -6.92394078e-02f, 6.38020039e-02f, -1.02776289e-01f, -9.50460881e-03f,
  -4.76705134e-02f, -7.65928328e-02f, -5.18260635e-02f, -1.65239200e-01f, -7.14178681e-02f, -1.18087098e-01f, -1.92117199e-01f, 9.05327052e-02f, -7.88795426e-02f, 6.04653582e-02f,
  2.26448253e-02f, -4.79492918e-02f, -9.49806347e-02f, -2.15720683e-02f, -2.04507545e-01f, -1.09035991e-01f, 1.99187011e-01f, 1.07671626e-01f, -1.49347499e-01f, 6.19574673e-02f,
  1.75537262e-02f, 1.78894505e-01f, 1.11327559e-01f, -1.00420080e-01f, -1.23295382e-01f, -6.37222901e-02f, 8.54828209e-02f, -6.09398857e-02f, 1.25675932e-01f, -1.15921266e-01f,
  -1.35590937e-02f, -1.32459968e-01f, 2.97572672e-01f, 1.33903816e-01f, 4.39825235e-03f, -1.51623055e-01f, 6.64835572e-02f, -1.01544857e-01f, 4.85835448e-02f, 3.68555598e-02f,
  -2.19665989e-02f, -4.00771052e-02f, 5.02199270e-02f, -6.03983998e-02f, -2.34795716e-02f, 6.30523711e-02f, 1.39322355e-01f, 1.49584487e-02f, -7.12369755e-02f, 4.81772721e-02f,
  -1.83878392e-02f, 7.21619576e-02f, 4.36029918e-02f, -5.29157408e-02f, -2.80355960e-02f, -2.01154570e-03f, -1.32966498e-02f, 7.28456005e-02f, -2.78768223e-02f, 3.29186395e-03f,
  -2.88976114e-02f, 1.05222851e-01f, 6.87217340e-03f, -4.07511517e-02f, -8.59772041e-03f, -4.08308245e-02f, 1.75553281e-02f, -3.06711998e-02f, -3.95472348e-03f, 8.57811719e-02f,
  1.06050611e-01f, 6.34272620e-02f, -8.15364718e-02f, -6.23540673e-03f, 5.78141585e-02f, -9.64829139e-03f, -1.13148838e-01f, -1.96842160e-02f, -3.13703232e-02f, 7.39964750e-03f,
  1.90780070e-02f, 1.43094361e-01f, 5.78799210e-02f, -1.08158053e-03f, -4.74974066e-02f, 4.32672091e-02f, -1.27903298e-01f, -3.71522307e-02f, 1.25705197e-01f, -1.32275447e-02f,
  1.79619968e-01f, -2.21878327e-02f, 1.82309281e-02f, -1.72485858e-01f, -2.50969902e-02f, -2.03063563e-02f, -1.33199796e-01f, -8.71028937e-03f, 1.63294181e-01f, 8.57613087e-02f,
  -7.84831122e-02f, -1.47649989e-01f, 1.48766197e-03f, -8.00977722e-02f, -2.85344291e-02f, -9.09634605e-02f, 1.06851170e-02f, 4.42659296e-02f, -8.74427259e-02f, -1.39541402e-01f,
  1.62558228e-01f, 7.59013817e-02f, 1.04615502e-01f, 5.53850010e-02f, -1.04258530e-01f, -1.38058793e-02f, 9.60840359e-02f, 5.93918469e-03f, -1.63459331e-02f, -2.59062648e-02f,
  -1.57983467e-01f, 1.92255318e-01f, -9.55465510e-02f, -3.65094952e-02f, -1.09652579e-01f, -7.14158937e-02f, 2.91424636e-02f, 5.07398546e-02f, 2.86445115e-02f, 1.41463224e-02f,
  -3.11396383e-02f, -6.61126450e-02f, -1.92705870e-01f, -1.20836683e-01f, -1.95719767e-03f, 6.65016323e-02f, 6.37993738e-02f, 1.57371517e-02f, -1.22775786e-01f, -1.61962673e-01f,
  -1.38597498e-02f, -4.87042870e-03f, 1.44533873e-01f, 7.33729899e-02f, -1.73921496e-01f, 1.52455673e-01f, -1.57904327e-02f, -7.02821910e-02f, -1.36187762e-01f, 6.95752650e-02f,
  -1.07824877e-01f, -1.25787035e-01f, -1.64991766e-02f, -3.58989507e-01f, 1.23218462e-01f, -1.81325987e-01f, 1.10763330e-02f, -5.32222837e-02f, -2.17720821e-01f, -1.04970045e-01f,
  9.01073515e-02f, 2.89181143e-01f, -1.00351110e-01f, 3.60783696e-01f, -6.02156855e-02f, -3.82793811e-03f, 5.39733693e-02f, -1.05420239e-01f, -7.87866651e-04f, -6.12314120e-02f,
  9.91165787e-02f, -7.80174807e-02f, -8.96035209e-02f, 2.99969912e-02f, 5.00783287e-02f, -1.54735502e-02f, -1.04969703e-01f, -6.58026402e-05f, -1.92240179e-02f, -2.32839026e-02f,
  3.54076326e-02f, -3.87058109e-02f, 5.76651692e-02f, 1.37235180e-01f, 1.23724230e-01f, -7.02206120e-02f, 4.64679971e-02f, -4.94307131e-02f, -7.89906271e-03f, -1.38457358e-01f,
  -1.31673202e-01f, 1.31670218e-02f, 9.32274237e-02f, -3.34850885e-02f, -9.96472090e-02f, -1.61208678e-02f, 1.27734197e-02f, 7.05878390e-03f, 2.83258241e-02f, -1.42580986e-01f,
  1.05247069e-02f, 5.54212965e-02f, -1.35885715e-01f, 1.08174577e-01f, -4.65413928e-02f, -5.23158684e-02f, 1.27941230e-02f, 6.85577169e-02f, 3.00861783e-02f, 7.89427310e-02f,
  -2.54761782e-02f, -8.36603045e-02f, -4.86895023e-03f, -4.59719934e-02f, -4.74288054e-02f, -4.02380303e-02f, 3.66157219e-02f, 2.21693948e-01f, -7.40713626e-03f, 6.64388910e-02f,
  6.33432642e-02f, -3.33968289e-02f, 9.39001217e-02f, 1.70565061e-02f, -9.13397595e-02f, 3.77436690e-02f, 2.99099572e-02f, 3.70382033e-02f, 1.52087072e-02f, 1.72915950e-01f,
  4.43227068e-02f, -4.44550961e-02f, -1.58002257e-01f, 3.61269861e-02f, -1.01695769e-01f, 1.10190123e-01f, 3.90849449e-02f, 2.05848133e-03f, -5.59489727e-02f, -1.58462077e-01f,
  -2.28132308e-02f, -1.11979000e-01f, 1.34438723e-01f, -5.31872921e-02f, -7.08938390e-02f, 7.72664137e-03f, 8.51264149e-02f, 2.76461653e-02f, 3.21155600e-02f, -1.40160590e-01f,
  8.40064213e-02f, -8.32341537e-02f, -2.18606982e-02f, 4.30288613e-02f, 1.08528659e-02f, 4.86364914e-03f, -1.11617900e-01f, 3.30826603e-02f, 2.90528480e-02f, 1.35227211e-03f,
  2.40291163e-01f, 6.45965412e-02f, 4.79017161e-02f, 6.57574683e-02f, -1.76305398e-01f, 6.35807440e-02f, 3.42954546e-02f, -2.75619507e-01f, -9.98462290e-02f, 3.48649323e-02f,
  -2.09365740e-01f, -9.30992439e-02f, 2.06087723e-01f, -1.43351361e-01f, -3.17121833e-03f, -9.65787694e-02f, 7.85616115e-02f, 2.77506392e-02f, 2.77988285e-01f, 1.73816144e-01f,
  -1.48217246e-01f, -4.64415178e-02f, 2.28388570e-02f, 2.77466089e-01f, -5.20224646e-02f, 1.24484412e-01f, -6.42905906e-02f, -4.81769023e-03f, 1.26290740e-02f, -2.52717584e-01f,
  2.64686465e-01f, 9.56995785e-02f, -3.56033482e-02f, 3.99470963e-02f, 6.17784075e-02f, -1.12489328e-01f, 9.54951122e-02f, 6.75193816e-02f, -7.69996494e-02f, 3.61021906e-02f,
  5.21393344e-02f, 8.40442404e-02f, 1.63644012e-02f, -9.24455598e-02f, -1.19113242e-02f, 4.40847315e-02f, -3.36204446e-03f, -2.52313558e-02f, -2.75688190e-02f, -1.49799325e-02f,
  7.18889534e-02f, 3.32054845e-03f, 4.75211553e-02f, -6.68624267e-02f, -3.08961328e-02f, 9.10990983e-02f, 8.85805860e-02f, 6.99331760e-02f, -1.01758726e-01f, -6.46572858e-02f,
  1.40568439e-03f, -1.70503054e-02f, -4.30484228e-02f, 5.15270308e-02f, 3.20089124e-02f, 1.88019693e-01f, -4.35230061e-02f, -2.27233898e-02f, 9.78065580e-02f, -6.14660345e-02f,
  -4.48368676e-02f, 9.10433009e-02f, 2.64591556e-02f, 2.35739630e-02f, 1.16050318e-02f, 9.44049936e-03f, -1.06454946e-01f, 1.12494677e-01f, 1.46989729e-02f, -5.17412126e-02f,
  7.80552775e-02f, 3.51076424e-02f, 5.68296835e-02f, 1.38269126e-01f, -3.49377245e-02f, 8.83463547e-02f, -3.01719867e-02f, -2.13254523e-02f, -7.83272609e-02f, 1.40342191e-01f,
  -1.91143557e-01f, -1.79861858e-02f, -1.38876438e-02f, 2.41523869e-02f, 6.93515921e-03f, -5.04904427e-03f, 1.09876789e-01f, 1.99175719e-02f, -1.17618680e-01f, -2.34383978e-02f,
  8.06562677e-02f, -6.25882857e-03f, -7.14390874e-02f, 3.57421823e-02f, -1.29333800e-02f, 1.46625534e-01f, -1.40367607e-02f, -2.13907901e-02f, 8.37327018e-02f, 1.18526533e-01f,
  -4.26946171e-02f, -1.21613350e-02f, -8.35537389e-02f, -1.03301831e-01f, -1.54002100e-01f, -2.73262933e-02f, -3.90794612e-02f, -1.09111831e-01f, 1.20505519e-01f, 4.57650982e-02f,
  4.50286530e-02f, 1.81266800e-01f, -3.93841155e-02f, -2.87817836e-01f, 1.10669859e-01f, 7.16279075e-02f, 6.42410740e-02f, -1.10399649e-01f, 1.17343046e-01f, 1.29731581e-01f,
  -8.45877528e-02f, -1.55593976e-01f, 1.98648363e-01f, -6.17509708e-02f, -8.71746391e-02f, 8.43433142e-02f, -1.06529467e-01f, 1.65323317e-01f, -1.10100113e-01f, -7.33401775e-02f,
  1.14601709e-01f, 3.73834550e-01f, -1.26917168e-01f, -1.29433066e-01f, -7.12915882e-02f, 6.35087723e-03f, 1.01189695e-01f, -2.36204229e-02f, 5.38340271e-01f, -7.72458091e-02f,
  1.81495026e-02f, -1.07626729e-01f, -5.67770414e-02f, -1.22133918e-01f, 9.09451395e-02f, -1.16401473e-02f, 1.21509463e-01f, 1.47817120e-01f, 3.86823229e-02f, -2.98876464e-01f,
  -3.42240632e-02f, -5.92536256e-02f, -3.55406068e-02f, 4.20637010e-03f, -7.96932280e-02f, 1.39203891e-01f, 1.67779267e-01f, 1.15478218e-01f, 9.70461816e-02f, 4.09068018e-02f,
  -1.26336897e-02f, -1.63932610e-02f, -4.64247391e-02f, 1.69353355e-02f, 1.19190954e-01f, -3.25546153e-02f, 7.61834998e-03f, 1.64406206e-02f, -1.35605326e-02f, -1.38011560e-01f,
  -1.49072632e-02f, 5.35945483e-02f, -9.04171262e-03f, -5.40611409e-02f, 1.55803151e-02f, -6.64712787e-02f, 6.16848543e-02f, 1.69235408e-01f, 1.43183872e-01f, 4.05275300e-02f,
  8.23259056e-02f, 9.54343155e-02f, -2.54929848e-02f, -7.35247582e-02f, -2.84463950e-02f, 3.80720804e-03f, -4.92764125e-03f, 1.44377619e-01f, 3.30145331e-03f, 3.06674130e-02f,
  3.97246843e-03f, 9.66495797e-02f, 2.53929582e-04f, -2.19026431e-02f, -1.01856172e-01f, -8.16675201e-02f, -3.60072851e-02f, -4.84073348e-02f, -6.00117743e-02f, -1.72005109e-02f,
  -5.34076579e-02f, -1.09673843e-01f, -2.69214176e-02f, -3.91464159e-02f, 1.81292534e-01f, -1.14293255e-01f, 6.60683215e-02f, -4.93204482e-02f, 1.74061641e-01f, 1.50109828e-02f,
  -1.37079060e-01f, 1.22489836e-02f, 4.16670777e-02f, -1.53351918e-01f, -3.21360856e-01f, 7.91174024e-02f, 9.80835408e-02f, 1.72443703e-01f, 3.01356874e-02f, 7.79398996e-03f,
  1.79575980e-01f, 7.00126290e-02f, -1.48834130e-02f, -3.78153920e-02f, 1.85689434e-01f, -8.52527469e-02f, 9.60754976e-02f, 6.22976907e-02f, 1.25526309e-01f, 7.20201060e-02f,
  1.55297503e-01f, 7.67097697e-02f, 5.77293113e-02f, 6.06138743e-02f, 8.21245760e-02f, 1.30116176e-02f, -2.99328323e-02f, -8.87179524e-02f, -1.21326879e-01f, -5.23693580e-03f,
  -9.91633348e-03f, 9.65089351e-02f, -6.26338199e-02f, -1.01278260e-01f, 9.95197371e-02f, -9.62807164e-02f, -4.55943011e-02f, -8.97777155e-02f, -2.42137879e-01f, -8.34910870e-02f,
  9.53129306e-03f, 1.46976337e-01f, 1.20293990e-01f, -9.09653082e-02f, 4.34671976e-02f, 8.71143341e-02f, -4.45228219e-02f, -1.50257871e-01f, -6.90072253e-02f, -1.66864231e-01f,
  -3.71892042e-02f, -1.69907719e-01f, 1.03697225e-01f, 9.60150175e-03f, 6.11664355e-02f, -1.75447459e-03f, -4.07638289e-02f, -8.32737312e-02f, 5.89453615e-02f, 1.17362082e-01f,
  -4.66541611e-02f, 3.19250897e-02f, -9.17124227e-02f, 1.81202069e-01f, 1.85543135e-01f, 3.64198233e-04f, 3.20495784e-01f, -1.90008014e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.65953189e-02f, 9.34843943e-02f, 1.36482269e-01f, 2.63356697e-02f, 6.25235513e-02f, 8.88307095e-02f, -2.84851659e-02f, 3.12596560e-02f, 1.29144162e-01f, 9.32191312e-02f,
  6.63914233e-02f, -1.77121488e-03f, -1.60794314e-02f, 8.62942263e-02f, 1.21344902e-01f, 9.76998731e-02f, 2.23674793e-02f, 1.50244758e-01f, 4.15356383e-02f, -5.28891385e-02f,
  1.34999126e-01f, 9.81948450e-02f, 4.33930047e-02f, 2.34970480e-01f, -3.35984193e-02f, 1.34839997e-01f, -2.25685984e-02f, 3.79744731e-02f, 2.74305400e-02f, 9.92468819e-02f,
  1.76901612e-02f, 1.67963296e-01f, 1.30019739e-01f, 1.05668433e-01f, 2.18239129e-01f, 7.58992061e-02f, 9.07256305e-02f, 1.28507078e-01f, 1.78222060e-01f, -4.07957695e-02f,
  1.00420870e-01f, 1.43312633e-01f, -3.12281754e-02f, 2.60701887e-02f, 9.30296257e-03f, 8.42164606e-02f, 1.89282432e-01f, 4.11408395e-02f, 1.87513992e-01f, 7.49723539e-02f,
  9.86502096e-02f, 1.24100290e-01f, 2.10966215e-01f, 5.65843005e-03f, -4.83202524e-02f, 3.94471660e-02f, 7.59270508e-04f, 1.43786237e-01f, -1.20053664e-01f, 3.80481109e-02f,
  -1.44499242e-01f, 2.69935392e-02f, -1.30656615e-01f, 1.76690787e-01f, -9.12171453e-02f, -5.57562187e-02f, 8.52623768e-03f, -1.31800249e-01f, -3.35669774e-03f, -7.57919103e-02f,
  -7.59317353e-02f, 6.59255609e-02f, 3.33911888e-02f, -5.31677231e-02f, -1.57304734e-01f, 1.54615035e-02f, 1.05402336e-01f, -1.02819473e-01f, -1.64046124e-01f, -1.32047221e-01f,
  1.91122919e-01f, 2.55360752e-02f, -5.09561002e-02f, 9.20745209e-02f, 4.74690869e-02f, 1.91550851e-01f, -1.04739495e-01f, -2.68025324e-02f, -8.23322088e-02f, 2.26797294e-02f,
  4.50981669e-02f, 9.10838470e-02f, 3.40180099e-02f, 9.04750451e-02f, -1.01261521e-02f, 1.11434832e-01f, -6.85612038e-02f, -4.28314880e-02f, 2.36718804e-01f, -1.08980142e-01f,
  -1.56767756e-01f, -1.87254593e-01f, -1.47840336e-01f, 2.43574858e-01f, 1.12371594e-01f, -1.88889742e-01f, 3.31680238e-01f, 1.32176995e-01f, 1.38616994e-01f, 1.62285969e-01f,
  -1.61705941e-01f, 1.90212116e-01f, 8.31743926e-02f, -2.04017852e-02f, 2.33216077e-01f, 1.60809383e-01f, 6.56412169e-02f, 2.41763860e-01f, 2.80699842e-02f, -2.34529778e-01f,
  -1.06501117e-01f, -8.56205542e-03f, 3.44998986e-01f, -1.22055352e-01f, -2.82816499e-01f, -2.01754063e-01f, -2.47132272e-01f, 2.68900543e-01f, 5.78774363e-02f, 5.45099974e-02f,
  1.27287656e-01f, 1.22436345e-01f, 4.91928421e-02f, 1.09631449e-01f, 2.25024875e-02f, 2.13750335e-03f, 9.36258137e-02f, 2.05441207e-01f, 8.33405405e-02f, -3.41166742e-02f,
  1.59133822e-01f, 2.21933499e-02f, 3.27047110e-02f, -2.45587202e-03f, 7.17498083e-03f, 6.51320741e-02f, -1.84128080e-02f, 1.49197578e-01f, 9.66543555e-02f, -4.10529971e-02f,
  -1.14214448e-02f, 7.77975284e-03f, 2.47927569e-02f, 1.97256193e-01f, 4.85879630e-02f, -6.77876323e-02f, 8.39290619e-02f, 2.00554416e-01f, 3.15238610e-02f, -1.41334813e-02f,
  -7.67289028e-02f, -7.08510876e-02f, 8.74614250e-03f, 7.31218681e-02f, 8.62228125e-02f, 1.25716731e-01f, 1.50163192e-02f, 5.98377213e-02f, 1.32485256e-01f, 2.28207302e-03f,
  6.30749911e-02f, 1.82688665e-02f, 1.39041185e-01f, -1.63881388e-02f, 1.21655151e-01f, 9.96024907e-02f, 5.76351723e-03f, -4.13146168e-02f, 2.75746919e-02f, -8.61005560e-02f,
  -1.84884965e-02f, 3.67294028e-02f, 2.80708335e-02f, -1.46918101e-02f, -1.90544501e-02f, 1.60574436e-01f, 3.74499895e-03f, 7.90900663e-02f, -5.79196401e-02f, 1.58547331e-02f,
  -2.11332105e-02f, -1.92070808e-02f, 1.03433974e-01f, 2.45778814e-01f, 1.16168812e-01f, -6.58801198e-02f, -9.00023803e-02f, 7.55363181e-02f, -5.32160401e-02f, -5.58576100e-02f,
  1.25672976e-02f, 1.38716266e-01f, -1.24294475e-01f, 3.06128915e-02f, 4.84365970e-02f, -1.44308254e-01f, 1.28106847e-01f, 6.83162808e-02f, -1.96381047e-01f, 2.81620890e-01f,
  -6.11863856e-04f, -1.08808704e-01f, 1.24158457e-01f, -2.66664033e-03f, 7.89553225e-02f, -3.02655268e-02f, 9.10649523e-02f, 1.30799711e-01f, -1.47311077e-01f, -7.84899816e-02f,
  -1.14428602e-01f, 5.01699522e-02f, -8.96016732e-02f, 4.10315618e-02f, 2.83169776e-01f, 1.53533429e-01f, -1.74719766e-02f, -1.67653784e-01f, 1.42615169e-01f, 1.88293830e-01f,
  -1.00022487e-01f, 1.28465176e-01f, 4.05372959e-03f, 1.65220767e-01f, 2.12610766e-01f, -2.05372199e-01f, 1.81568801e-01f, 1.95418194e-01f, -3.81201841e-02f, 1.17855191e-01f,
  -1.75070569e-01f, 6.62538856e-02f, 5.27410090e-01f, 3.34898978e-02f, 7.10352182e-01f, -1.35293165e-02f, -2.19684746e-02f, 2.69145727e-01f, -2.09627762e-01f, 9.87530947e-02f,
  4.72737886e-02f, 1.80350214e-01f, -1.45479411e-01f, -1.53306365e-01f, 2.60907859e-01f, -4.10136133e-01f, 6.92371931e-03f, -1.31245106e-01f, 9.28121358e-02f, 8.68750438e-02f,
  -5.15179150e-02f, 1.20882593e-01f, 3.55439574e-01f, 1.36796638e-01f, 1.97439089e-01f, 3.46871354e-02f, -4.14145030e-02f, 1.39069572e-01f, -1.70504451e-02f, 1.78732991e-01f,
  -9.87102017e-02f, 4.65212725e-02f, -5.99927306e-02f, -2.45982446e-02f, 8.33356157e-02f, -8.63414444e-03f, 2.47281436e-02f, 6.86076730e-02f, -5.96580394e-02f, -7.37596378e-02f,
  -6.15578331e-02f, -3.54994647e-02f, 1.25067070e-01f, 1.12212829e-01f, 1.24116302e-01f, -2.90436856e-02f, 1.23767719e-01f, 7.67982975e-02f, -1.92028359e-01f, 3.14876437e-02f,
  5.19617498e-02f, 2.86908611e-03f, 1.43386545e-02f, 1.46602541e-01f, 1.55596256e-01f, 2.91318968e-02f, 2.07120180e-01f, 1.66437570e-02f, -6.03295444e-03f, 1.67069778e-01f,
  1.02689154e-01f, -9.87313781e-03f, 7.56934956e-02f, 1.05217308e-01f, -1.70671996e-02f, 5.07756993e-02f, 7.44406283e-02f, -5.27567007e-02f, 1.50753722e-01f, 1.02141485e-01f,
  2.66757160e-01f, 3.36171649e-02f, 1.21931769e-01f, -1.60591707e-01f, -4.16021571e-02f, -1.57904506e-01f, -1.20488077e-01f, 1.27713263e-01f, 2.98023243e-02f, -2.48284221e-01f,
  -9.16350633e-02f, -1.58142522e-01f, 5.83379203e-03f, 2.14740504e-02f, 5.30065186e-02f, -1.41473398e-01f, 1.85981408e-01f, 1.40665025e-01f, 7.93252513e-02f, -1.97929442e-02f,
  5.18891811e-01f, 1.89036354e-02f, 1.02172613e-01f, -5.96227236e-02f, -1.39744982e-01f, 5.08849882e-02f, 2.07229495e-01f, 1.80268139e-01f, -6.73618400e-04f, 2.27630988e-01f,
  -2.73440629e-02f, 9.88965034e-02f, -2.84620106e-01f, 1.36503115e-01f, -3.32340375e-02f, 5.44664301e-02f, -1.69367135e-01f, 3.22610065e-02f, -1.66879714e-01f, -1.07685365e-02f,
  -5.89762740e-02f, -8.53416845e-02f, -2.54571944e-01f, -1.03228383e-01f, -3.02442521e-01f, 6.03365898e-02f, -7.98920766e-02f, 1.93007767e-01f, -1.17945597e-02f, -3.30529958e-02f,
  -3.18342037e-02f, 2.26063818e-01f, 6.45009041e-01f, 5.52617363e-04f, -5.41577041e-01f, -1.18150748e-01f, 9.10527557e-02f, -8.11081529e-02f, 9.71824452e-02f, -3.78951848e-01f,
  4.05846238e-02f, -1.65024862e-01f, -3.14904228e-02f, 8.33792984e-02f, -6.97801113e-02f, -1.26768172e-01f, -8.38299245e-02f, 8.44955221e-02f, 1.44840375e-01f, 2.34669819e-01f,
  8.60267878e-02f, 3.80537093e-01f, 1.34922802e-01f, 3.79790068e-01f, 1.50832564e-01f, 2.38046199e-01f, 5.12499027e-02f, 7.59383943e-03f, -3.62933576e-02f, 7.91297331e-02f,
  2.60590576e-02f, 1.38974398e-01f, -1.03610337e-01f, -1.30249308e-02f, -1.72463078e-02f, 7.76854083e-02f, 1.17406435e-01f, 1.00149736e-01f, 3.20285261e-02f, -2.68508401e-02f,
  -4.06413935e-02f, 6.98935911e-02f, -7.08812401e-02f, 6.63089529e-02f, -4.70509492e-02f, -1.72735788e-02f, 4.25300449e-02f, 1.22990340e-01f, 3.21494862e-02f, -1.13628760e-01f,
  2.48568673e-02f, 3.62436548e-02f, -1.58502255e-02f, 1.68201596e-01f, 9.77597758e-02f, 6.07663803e-02f, 1.37676410e-02f, -8.12100470e-02f, -1.33196250e-01f, -7.75055885e-02f,
  1.48324519e-01f, 2.92906798e-02f, -4.11512069e-02f, -7.37608131e-03f, 7.55364746e-02f, 8.58731642e-02f, 7.14380965e-02f, -6.61992431e-02f, 1.39328182e-01f, -5.35017140e-02f,
  3.60116288e-02f, -1.51832789e-01f, 1.58761274e-02f, -3.71844843e-02f, 1.25437796e-01f, 1.12311766e-01f, -1.69619709e-01f, 1.25541955e-01f, -1.95542902e-01f, -3.78460512e-02f,
  -8.62892792e-02f, 6.45492449e-02f, -5.27989715e-02f, 1.88343331e-01f, 5.33495247e-02f, -5.52324057e-02f, -9.68583673e-02f, 1.80721417e-01f, 8.19072053e-02f, 3.29285502e-01f,
  -5.24615310e-02f, 7.08518550e-02f, -1.54476792e-01f, -1.11193359e-01f, -9.71939340e-02f, -5.32999374e-02f, 6.32280260e-02f, 2.10518166e-01f, -3.46721858e-01f, 2.79424395e-02f,
  -6.81917602e-03f, -1.97802857e-02f, 1.33019418e-01f, 9.40590724e-02f, -5.76289222e-02f, 9.63951871e-02f, 4.31317948e-02f, -2.95277864e-01f, 1.95427015e-01f, -4.26764488e-02f,
  2.03122079e-01f, 7.66218826e-02f, 3.26080292e-01f, -8.82510245e-02f, -4.60095843e-03f, 5.61852492e-02f, 1.16569422e-01f, 6.72939718e-02f, -3.01554874e-02f, -3.04142628e-02f,
  2.58269161e-01f, 1.58982828e-01f, 1.14925794e-01f, -1.70609742e-01f, 8.90176594e-02f, 1.66565284e-01f, 1.73313349e-01f, 1.47893727e-01f, 4.50657308e-02f, 8.40972215e-02f,
  -1.88945189e-01f, -8.08107778e-02f, 3.34827125e-01f, -3.76581363e-02f, 7.14255497e-02f, -1.77344903e-01f, -5.80955343e-03f, -2.41361801e-02f, -3.07019148e-02f, 2.64121383e-01f,
  1.50734529e-01f, 2.03867719e-01f, -5.53231500e-02f, 3.61731857e-01f, -3.01237893e-03f, -9.91753861e-03f, -4.75657396e-02f, 4.20349911e-02f, -1.34577245e-01f, 1.59265906e-01f,
  1.85255200e-01f, -4.12709147e-01f, 9.70169231e-02f, 1.91669688e-01f, 1.67954285e-02f, 2.84854561e-01f, -4.29855064e-02f, 9.95400771e-02f, 2.22137883e-01f, 2.58460373e-01f,
  9.75504220e-02f, 1.85357258e-01f, 8.97375941e-02f, 2.94713825e-01f, 2.29117543e-01f, 1.36951834e-01f, 3.29921767e-02f, 8.92986357e-02f, -4.53155860e-02f, -2.03213729e-02f,
  1.14022261e-02f, 1.64686278e-01f, -7.34530985e-02f, 7.30807632e-02f, -4.37036492e-02f, 2.13687003e-01f, 2.44473144e-02f, 1.20136455e-01f, 4.99170162e-02f, 2.77306020e-01f,
  1.81192085e-02f, 2.14254230e-01f, 2.54561216e-01f, 1.64983422e-01f, 1.44172505e-01f, -1.50246486e-01f, 4.33779769e-02f, 2.00126663e-01f, 3.13934535e-02f, 7.25758150e-02f,
  -6.85369372e-02f, -1.76728535e-02f, 1.71973422e-01f, 5.31436177e-03f, 8.27665552e-02f, 8.55367631e-02f, 4.69850041e-02f, 5.39139137e-02f, 1.10203400e-01f, 1.69533923e-01f,
  5.50807156e-02f, 2.49887467e-03f, 1.41639069e-01f, 2.20447078e-01f, -1.17793977e-01f, -1.63738504e-01f, -2.54618134e-02f, 2.52430085e-02f, 1.09692849e-03f, -2.58860171e-01f,
  -6.88223019e-02f, 5.66568673e-02f, 1.46562353e-01f, -3.01477611e-02f, 1.12490378e-01f, 1.44515941e-02f, -2.01820776e-01f, 1.33225322e-01f, -1.24097385e-01f, -7.60164559e-02f,
  -6.73421398e-02f, -8.69513154e-02f, -9.31496471e-02f, -5.37797809e-02f, -1.90089531e-02f, 1.55605972e-01f, -2.01216117e-01f, -1.19626231e-01f, -1.07483804e-01f, -2.19670963e-02f,
  4.35586199e-02f, -4.73563112e-02f, -1.35470614e-01f, -1.97446808e-01f, 1.08660959e-01f, -3.47551703e-01f, 3.79463029e-03f, -1.57038212e-01f, 2.11992890e-01f, -2.85420902e-02f,
  2.23276928e-01f, -2.90863723e-01f, 3.44136283e-02f, 3.01552210e-02f, -4.44640145e-02f, 5.58110923e-02f, 1.75482884e-01f, 1.13799661e-01f, 9.35525224e-02f, 4.64540720e-02f,
  2.03091815e-01f, -3.21922153e-02f, 1.46184549e-01f, 1.42185181e-01f, 3.43463123e-01f, 2.65151978e-01f, 8.51979405e-02f, 1.29809603e-01f, -4.29488271e-01f, 2.23974392e-01f,
  1.75039306e-01f, -4.70934749e-01f, 1.28994972e-01f, -6.12093881e-02f, -1.57598749e-01f, 1.90452069e-01f, 7.48663396e-02f, 3.16841394e-01f, 3.17342095e-02f, -1.11424431e-01f,
  -2.20165566e-01f, 3.63607168e-01f, -3.04474741e-01f, -2.95483768e-01f, 1.13463975e-01f, 3.24909352e-02f, -5.34477159e-02f, 2.66811162e-01f, -8.09408426e-02f, -6.57569319e-02f,
  9.92197823e-03f, 1.80520415e-01f, 9.90383998e-02f, -2.50225365e-02f, 5.52632613e-03f, 1.20396182e-01f, -9.86722559e-02f, -1.90302599e-02f, 5.20060118e-03f, 1.53632507e-01f,
  3.54311913e-02f, -8.15550145e-03f, 5.49553446e-02f, 1.13484167e-01f, 1.75141707e-01f, 5.77693759e-03f, 3.05186827e-02f, 1.05425091e-02f, -1.37109071e-01f, 6.29182905e-02f,
  8.91049281e-02f, 1.41879097e-01f, 5.99314459e-02f, 1.86574027e-01f, 1.66442335e-01f, 1.98286742e-01f, -2.77993828e-02f, 5.00587747e-02f, 4.92717326e-02f, 1.88509911e-01f,
  -4.17622961e-02f, 9.39228609e-02f, 2.42441162e-01f, 1.57616705e-01f, 1.41077653e-01f, 1.78161934e-01f, 1.43778855e-02f, 6.25352636e-02f, 1.91823363e-01f, 1.23664156e-01f,
  -9.83545906e-04f, -2.57141758e-02f, 1.03974022e-01f, 4.46925638e-03f, -7.64334351e-02f, 2.12270319e-01f, 3.11649889e-02f, 1.23943463e-01f, 1.51680352e-03f, 1.75132468e-01f,
  1.27628446e-01f, 3.02763224e-01f, 1.99475169e-01f, 3.03573385e-02f, -7.43903443e-02f, -3.85553576e-02f, 4.31435406e-02f, 1.89292207e-01f, -1.68638706e-01f, -1.10586025e-01f,
  1.40842021e-01f, -4.15942855e-02f, -4.48746420e-02f, -9.15135145e-02f, 2.24375486e-01f, -8.69548246e-02f, -1.19998164e-01f, -1.58368662e-01f, 7.83269405e-02f, -1.86246634e-02f,
  -6.93151578e-02f, 2.39854172e-01f, 3.71466763e-02f, 1.65762473e-02f, -4.01190743e-02f, -6.05200604e-02f, 7.47857094e-02f, 7.74962315e-03f, -1.53630093e-01f, 6.63640574e-02f,
  2.29556803e-02f, -2.72929192e-01f, -9.36788097e-02f, -1.09354295e-01f, -1.30407244e-01f, -5.80300344e-03f, 7.23451525e-02f, 1.95722461e-01f, 1.04565697e-03f, 2.43259192e-01f,
  5.04453145e-02f, -1.58578753e-01f, 1.00630894e-01f, -5.33161825e-03f, 3.68172489e-02f, -4.33738716e-02f, -2.33044386e-01f, 1.29410448e-02f, 1.06988788e-01f, 4.62817177e-02f,
  3.36918682e-02f, 6.41796961e-02f, -7.75327161e-02f, 2.74232998e-02f, -2.06732616e-01f, 7.62498658e-03f, -1.21068925e-01f, -2.45067760e-01f, 2.33143911e-01f, 4.69798535e-01f,
  3.99519615e-02f, 5.42526543e-02f, -2.33520150e-01f, -4.38960381e-02f, 1.44299537e-01f, 1.06453627e-01f, 6.59912871e-03f, 6.92849010e-02f, -3.21455747e-02f, -2.43871748e-01f,
  -1.55669525e-01f, -1.61269188e-01f, 1.17258199e-01f, -2.58068711e-01f, 1.79060921e-01f, 2.41108134e-01f, -1.90529317e-01f, 1.10306010e-01f, 1.28091961e-01f, 1.01296850e-01f,
  1.45569760e-02f, -5.10097519e-02f, 1.01344287e-01f, 3.81017663e-02f, 4.50029857e-02f, -8.06415305e-02f, -1.07481610e-02f, 9.87202525e-02f, 1.26734178e-03f, 1.17543243e-01f,
  4.93742861e-02f, 1.57725334e-01f, 6.26548380e-02f, 4.72601876e-02f, 6.50377274e-02f, 9.55439433e-02f, 1.75371226e-02f, -8.10863357e-03f, -1.65978726e-03f, 8.13881233e-02f,
  6.85237125e-02f, 8.37359019e-03f, -3.54940742e-02f, 8.57914314e-02f, -4.93318364e-02f, 2.27471665e-02f, -6.95186704e-02f, -1.33373169e-02f, -9.37194526e-02f, 1.15211420e-01f,
  2.59463303e-02f, 5.41875847e-02f, 1.27323225e-01f, 2.72398745e-03f, 3.79057904e-03f, 4.12170552e-02f, 1.02833442e-01f, 2.08239853e-02f, 8.28098431e-02f, 7.31561929e-02f,
  5.06351218e-02f, -6.85277209e-02f, -1.97664667e-02f, 6.34586215e-02f, 1.46040507e-02f, 6.99358359e-02f, 3.90261039e-02f, -2.68018190e-02f, 1.48849115e-01f, -2.28754897e-02f,
  7.81546831e-02f, 4.21801843e-02f, -4.07673083e-02f, -1.50154289e-02f, 3.13239098e-02f, 1.10123001e-01f, -7.64640495e-02f, -4.71523292e-02f, -3.80314440e-02f, -7.35262856e-02f,
  -1.46876514e-01f, -6.37395233e-02f, 1.49353996e-01f, -2.56220698e-02f, -2.44248621e-02f, -9.88750532e-02f, 5.99784926e-02f, -8.90739262e-02f, -6.31255656e-02f, 9.24029946e-02f,
  -1.39854059e-01f, 4.60831448e-02f, 1.14234788e-02f, -5.29031940e-02f, 5.53326979e-02f, -1.54799372e-02f, -1.56031712e-03f, 5.88439517e-02f, 1.47629445e-02f, 8.54760036e-02f,
  -6.22708239e-02f, 9.50250775e-02f, 8.06543902e-02f, 8.90197530e-02f, -3.37939756e-03f, 4.08753790e-02f, -4.59683277e-02f, 1.25227302e-01f, -1.13712549e-02f, 4.61519044e-03f,
  8.77173468e-02f, -1.06351525e-02f, -1.00331390e-02f, 1.70095898e-02f, -4.54319194e-02f, 4.56818342e-02f, 1.20180182e-01f, 1.78596508e-02f, -1.56933874e-01f, 6.40055072e-03f,
  6.98490217e-02f, 1.45171853e-02f, 8.33948925e-02f, 2.16134325e-01f, 3.31543207e-01f, 2.44137105e-02f, 1.13337599e-01f, 4.44746941e-01f, 1.92782268e-01f, 1.22777626e-01f,
  9.07680690e-02f, -3.04350764e-01f, -2.46410668e-01f, -7.36508816e-02f, -1.23263700e-02f, 1.06210999e-01f, 1.40056148e-01f, -1.20573916e-01f, 1.26372322e-01f, 1.85058728e-01f,
  1.27224252e-01f, -1.36776537e-01f, 3.02373827e-03f, 3.41472298e-01f, 2.97497176e-02f, 2.55090624e-01f, -5.34150153e-02f, 1.26611158e-01f, 5.65385856e-02f, -7.65270442e-02f,
  7.75516853e-02f, 1.56884462e-01f, -6.43639639e-02f, 5.03208898e-02f, 5.68381175e-02f, 1.50600106e-01f, 9.87101123e-02f, 8.52745846e-02f, 2.79903896e-02f, 6.96426705e-02f,
  -2.49888953e-02f, 7.91033655e-02f, 4.90847193e-02f, 2.07787231e-01f, 8.37878361e-02f, 2.80802585e-02f, 5.73968366e-02f, 1.43227771e-01f, -2.44654678e-02f, 5.74501306e-02f,
  5.77947497e-02f, 5.54345548e-02f, 3.92032787e-02f, -4.99254540e-02f, 9.00187418e-02f, 1.51807413e-01f, 6.06698841e-02f, -8.67926516e-03f, 2.59310752e-01f, 3.55953462e-02f,
  1.62651420e-01f, 6.53709248e-02f, 6.75272048e-02f, 6.38230443e-02f, 5.33116050e-02f, 7.90003464e-02f, 4.41561863e-02f, -4.57487181e-02f, 7.34434277e-02f, 7.25241303e-02f,
  5.94833447e-03f, 5.78786023e-02f, 1.90918982e-01f, 7.57628605e-02f, 1.85230434e-01f, 1.03206195e-01f, 1.85286835e-01f, 3.01229917e-02f, 2.79238850e-01f, 1.70003474e-02f,
  -2.60174125e-01f, -1.14122435e-01f, -6.11927323e-02f, 7.43726641e-02f, -1.12387978e-01f, -6.91934898e-02f, -7.29788654e-03f, -2.34134514e-02f, -1.11013152e-01f, 1.90935284e-01f,
  1.02427788e-01f, -1.24070600e-01f, -1.96022689e-02f, -1.15525335e-01f, 8.06066766e-02f, -1.24480300e-01f, -3.45213972e-02f, -3.68595272e-02f, 1.92371029e-02f, -7.56305903e-02f,
  -8.08929056e-02f, -4.14631180e-02f, 1.60369664e-01f, -1.55946255e-01f, -2.08739102e-01f, -8.62547942e-03f, 2.85578482e-02f, 1.22476466e-01f, 1.30357873e-02f, 1.97085142e-01f,
  -8.81410092e-02f, 9.35063064e-02f, -1.15846723e-01f, 7.34052658e-02f, 1.85133629e-02f, -5.40776886e-02f, 1.59190223e-01f, -1.05058648e-01f, 1.78503573e-01f, 1.07054166e-01f,
  -1.27374053e-01f, 6.05591722e-02f, -7.40174996e-03f, 1.43532276e-01f, 2.60154486e-01f, -3.04427464e-02f, -1.27526820e-01f, -7.94928372e-02f, -2.06440136e-01f, 2.74415940e-01f,
  1.18190251e-01f, -1.18993223e-01f, 3.54009688e-01f, 2.78193485e-02f, 2.16937624e-02f, 1.83177635e-01f, -1.40987232e-01f, 2.38156721e-01f, 7.07256198e-02f, -2.30259329e-01f,
  1.39267594e-02f, 1.46025732e-01f, 4.55411710e-02f, 2.48662636e-01f, -3.41603123e-02f, -3.28186721e-01f, 1.28301114e-01f, 3.13638314e-03f, 2.94055760e-01f, -1.51106507e-01f,
  -4.86013055e-01f, 1.29925311e-01f, -6.53003156e-02f, 2.81778514e-01f, 1.54874504e-01f, 3.23053673e-02f, -1.31537241e-03f, 4.71497029e-02f, 2.68010236e-02f, 7.56727457e-02f,
  1.49413392e-01f, 1.08723687e-02f, 2.57369019e-02f, -8.88874233e-02f, -3.30220349e-02f, -1.15123451e-01f, -1.31226867e-01f, 2.47270018e-01f, -7.77203776e-03f, 1.86970253e-02f,
  -3.70000638e-02f, 4.06319164e-02f, 1.31597385e-01f, -2.36044731e-02f, 2.19283905e-03f, -6.98145851e-02f, -8.88226107e-02f, 1.54735118e-01f, -2.17066407e-01f, -5.08595742e-02f,
  -1.00133820e-02f, 5.77008761e-02f, -9.68869850e-02f, 2.36189384e-02f, -1.06101818e-01f, 1.68843463e-01f, 1.51651829e-01f, -4.71048839e-02f, 1.39958292e-01f, -6.01489097e-02f,
  4.90839817e-02f, -2.56889295e-02f, 7.62280747e-02f, 1.70314498e-02f, -1.17202930e-01f, 4.58877198e-02f, 5.72690368e-02f, -1.03690298e-02f, 7.57067874e-02f, 9.20678526e-02f,
  1.73502922e-01f, 1.93578392e-01f, 7.70077780e-02f, -6.69153705e-02f, -1.69740289e-01f, -7.86622912e-02f, 1.20468311e-01f, -4.88441810e-02f, 2.09434610e-02f, 1.81220487e-01f,
  1.55285716e-01f, -1.08249420e-02f, 2.25862399e-01f, 1.15037508e-01f, -2.30211556e-01f, -8.39911494e-03f, 7.36195371e-02f, -4.48145196e-02f, -3.16418946e-01f, -1.07636571e-01f,
  2.59072512e-01f, -2.14852408e-01f, 5.65327182e-02f, 5.76536059e-02f, -5.14179468e-02f, -3.06536667e-02f, -1.20896548e-02f, -4.31621149e-02f, 1.40261561e-01f, -4.57295552e-02f,
  1.03791788e-01f, -9.84343514e-02f, -3.92061137e-02f, -1.53180957e-01f, 2.48603001e-01f, 2.51789987e-01f, 4.05152403e-02f, 1.85617805e-01f, 2.99268365e-02f, 1.93552136e-01f,
  -2.19377577e-01f, -1.46750733e-01f, 7.85345137e-02f, -4.00063872e-01f, 7.16047436e-02f, 3.68386537e-01f, 1.71522796e-02f, -5.04600257e-02f, -1.77662671e-01f, 2.02696294e-01f,
  1.40815610e-02f, -5.77021986e-02f, 3.37100849e-02f, 6.43869042e-02f, -1.19632371e-01f, -1.85044274e-01f, 1.18234418e-01f, 1.90334599e-02f, 3.19688559e-01f, 1.62953213e-01f,
  2.85033524e-01f, 2.31799513e-01f, -1.83512166e-01f, -6.27482712e-01f, -2.15343572e-02f, 5.76682342e-03f, 4.16428857e-02f, -2.37766095e-02f, -2.77217269e-01f, -6.14312053e-01f,
  -7.62601435e-01f, -3.88133191e-02f, -9.87216979e-02f, -3.92080657e-03f, -1.76340893e-01f, 6.89453110e-02f, 1.02134101e-01f, -2.75599450e-01f, -3.27551544e-01f, 9.96010527e-02f,
  -2.44833723e-01f, 5.80822051e-01f, 7.34625608e-02f, 1.52011141e-01f, 4.06006724e-02f, 2.07135245e-01f, 3.90532427e-02f, 2.26948276e-01f, 2.57580101e-01f, 4.20356914e-03f,
  6.61029890e-02f, 6.32936209e-02f, 9.36515406e-02f, 2.45163023e-01f, 1.92420393e-01f, 1.48252398e-01f, 4.40661423e-02f, 6.70961142e-02f, 5.21165133e-02f, 9.19929519e-02f,
  -1.03411023e-02f, 1.22630922e-02f, 7.16029778e-02f, 1.38667837e-01f, -2.66821822e-03f, 1.98814124e-01f, -6.26796111e-02f, 5.71328662e-02f, 4.60121110e-02f, 7.60363042e-02f,
  -4.16386351e-02f, 5.98296896e-02f, 9.60881859e-02f, 7.97776431e-02f, 4.07418422e-02f, 2.52541341e-02f, 9.46910828e-02f, 1.28810808e-01f, -5.34766130e-02f, 1.11744367e-01f,
  1.41733184e-01f, 7.52281919e-02f, 1.24431938e-01f, 4.39087413e-02f, 6.64803088e-02f, -1.21762685e-01f, 1.36727810e-01f, -8.71255025e-02f, 2.30241287e-02f, 2.50501424e-01f,
  1.03291914e-01f, -6.82338476e-02f, 2.23366514e-01f, 2.49089599e-01f, 1.89756647e-01f, -1.97636083e-01f, 3.83889899e-02f, -1.84081290e-02f, 7.14287385e-02f, -2.53449023e-01f,
  -4.08764184e-02f, -2.24915817e-01f, 1.22445039e-01f, -1.94136605e-01f, 7.27864280e-02f, 1.64393708e-02f, 1.91604830e-02f, -1.61728427e-01f, -9.73634720e-02f, -1.73763484e-01f,
  6.85222223e-02f, -2.09984198e-01f, -8.31669755e-03f, -9.41374227e-02f, -8.82520247e-03f, -1.41013294e-01f, 1.38797611e-01f, 2.16259211e-02f, 2.13413715e-01f, -9.21852216e-02f,
  -7.20721185e-02f, 4.43992242e-02f, -8.57410505e-02f, -1.88037083e-01f, -4.41526026e-02f, -3.23942490e-02f, -7.95961246e-02f, 1.95667982e-01f, -4.53979783e-02f, 1.57866508e-01f,
  1.28923833e-01f, -5.60130365e-02f, 3.15586329e-02f, -1.57674477e-01f, 7.12556392e-02f, 1.18485078e-01f, -2.71333996e-02f, -4.20125537e-02f, -2.27651671e-01f, -6.21635243e-02f,
  7.67815262e-02f, 2.19197739e-02f, 8.76804292e-02f, 1.42782360e-01f, 1.08853623e-01f, 4.04758602e-01f, 1.74861997e-02f, 2.44870752e-01f, 1.76276490e-01f, 1.65455848e-01f,
  -3.00394118e-01f, -7.54788816e-02f, 1.19122364e-01f, -2.21717693e-02f, 2.23927181e-02f, -1.50672585e-01f, -3.12828243e-01f, -5.93855344e-02f, -1.10549502e-01f, -2.91063249e-01f,
  7.38932472e-03f, -1.46363437e-01f, 2.00265452e-01f, -1.22233026e-01f, 1.70876049e-02f, -1.67138457e-01f, -1.06199227e-01f, 5.54705262e-01f, -2.70060927e-01f, 2.85650641e-01f,
  1.44640446e-01f, 1.28623188e-01f, 6.14624508e-02f, -1.11086946e-02f, -4.40749861e-02f, 3.05385720e-02f, -1.26966760e-02f, -8.01116228e-02f, 5.14071574e-03f, 2.53116339e-02f,
  1.13551475e-01f, 9.61872861e-02f, 1.30276056e-02f, 2.80321427e-02f, 8.43201131e-02f, 4.86020669e-02f, 9.02372077e-02f, 9.02828723e-02f, -7.91322589e-02f, 7.03486130e-02f,
  2.51791142e-02f, -2.55385675e-02f, 7.65155032e-02f, 2.26096064e-01f, -9.07343328e-02f, 4.53809053e-02f, -5.37639484e-02f, 1.32845566e-01f, 2.27348320e-02f, 1.92064438e-02f,
  -2.61157993e-02f, 2.91659608e-02f, 1.07689641e-01f, 8.85277689e-02f, 1.22040465e-01f, 4.46723215e-02f, 4.19421047e-02f, -1.54652260e-02f, 9.26216785e-03f, -3.67080932e-03f,
  -2.73676701e-02f, -1.05790393e-02f, 2.60129720e-02f, -5.68226092e-02f, 9.36396644e-02f, 5.27913421e-02f, 1.11654393e-01f, 2.62304973e-02f, 4.01374400e-02f, -2.56064106e-02f,
  1.12386554e-01f, 8.33037049e-02f, 1.58507317e-01f, 1.02848247e-01f, -2.40361288e-01f, 3.14521007e-02f, -7.59653514e-03f, 5.63861132e-02f, -2.28453249e-01f, -9.87340324e-03f,
  -9.04970616e-02f, -1.45780608e-01f, -9.11763757e-02f, 1.45499349e-01f, 8.18861946e-02f, 7.33098835e-02f, 7.46156946e-02f, -4.74491194e-02f, -1.04970559e-01f, -1.87534824e-01f,
  -8.65197703e-02f, -1.91702619e-01f, 7.92916492e-03f, -5.51312091e-03f, -1.85955063e-01f, -3.11731193e-02f, 1.56241536e-01f, -3.02526563e-01f, 1.47078242e-02f, 1.17926292e-01f,
  2.10634619e-02f, -3.81081551e-02f, 5.71411243e-03f, -3.66975344e-03f, 2.07105130e-01f, 2.15492751e-02f, -1.09366082e-01f, 1.03505969e-01f, 1.36231244e-01f, -1.46943680e-03f,
  1.51948825e-01f, -2.86624134e-02f, 3.03511098e-02f, 1.39497176e-01f, -1.45919785e-01f, 1.50611445e-01f, 1.62242085e-01f, 4.78561223e-02f, 3.61500949e-01f, -1.41307175e-01f,
  -1.08916014e-01f, -2.48852950e-02f, 8.51907507e-02f, 1.60288528e-01f, 9.51132178e-02f, 3.98529433e-02f, 2.70796008e-02f, 4.75185104e-02f, 3.16292048e-01f, 5.96511699e-02f,
  9.41883102e-02f, -9.18643624e-02f, 1.24690309e-01f, -1.03523321e-01f, -7.42630810e-02f, 3.45420718e-01f, 1.96005609e-02f, 1.82662770e-01f, -1.48166135e-01f, 7.87348971e-02f,
  5.66615053e-02f, -1.00003611e-02f, 3.86049390e-01f, -1.87610820e-01f, -2.38022983e-01f, -7.63550624e-02f, -3.14968437e-01f, 4.29598510e-01f, 3.64167094e-02f, 6.04507588e-02f,
  1.44695431e-01f, -3.11093172e-03f, 3.19131017e-02f, 7.75858685e-02f, 7.22399577e-02f, 4.18101996e-02f, -6.69904007e-03f, 7.17404783e-02f, -1.13977030e-01f, -2.75026858e-02f,
  -5.17685488e-02f, 9.44513902e-02f, 1.28104404e-01f, 7.55129755e-02f, -2.89373435e-02f, -1.11429438e-01f, 8.25358182e-03f, 1.07067466e-01f, 5.97119890e-03f, -2.48263758e-02f,
  2.73966715e-02f, -1.20757930e-01f, 1.61663204e-01f, 1.14954166e-01f, 2.89865788e-02f, -6.02463707e-02f, 1.40405029e-01f, 1.69554204e-02f, -4.34208699e-02f, 7.44272843e-02f,
  -5.15383333e-02f, 6.59722164e-02f, -1.76573247e-02f, -6.73889220e-02f, -2.87358835e-02f, 1.76137820e-01f, 2.02871874e-01f, -7.68895000e-02f, 8.76358226e-02f, -1.11739254e-02f,
  -2.63989717e-02f, 4.39553112e-02f, 3.59699450e-04f, 1.64660960e-01f, 2.34538317e-02f, 2.03558534e-01f, 7.56315365e-02f, 2.58661695e-02f, 1.11876324e-01f, -1.16450097e-02f,
  -5.75533807e-02f, 2.85910089e-02f, 4.62587737e-02f, 4.38923277e-02f, -9.79957357e-02f, 8.67419243e-02f, 1.04919128e-01f, -1.32566229e-01f, 1.28098782e-02f, 9.52536687e-02f,
  -3.15542938e-03f, -2.13112310e-01f, 2.02351078e-01f, 3.32629159e-02f, 4.94828783e-02f, 9.70616862e-02f, 2.72511896e-02f, 8.33575800e-02f, -6.09485842e-02f, 2.14821607e-01f,
  -1.33170784e-02f, 7.95934945e-02f, 1.25549026e-02f, 3.08001600e-02f, -1.20032905e-02f, 3.16659473e-02f, -7.29248002e-02f, -6.47980720e-02f, -1.56116402e-02f, 6.74725771e-02f,
  -2.67112218e-02f, 4.75474857e-02f, -8.52711499e-02f, 1.52901053e-01f, -3.03285979e-02f, -2.27364656e-02f, -3.45590934e-02f, 3.37750077e-01f, -1.48437321e-01f, -3.94419283e-02f,
  -1.87434793e-01f, -8.11300054e-02f, -1.04920849e-01f, -1.21944830e-01f, -1.60373405e-01f, -2.53897328e-02f, -3.69920999e-01f, 2.58239936e-02f, 4.66692671e-02f, 3.87688875e-02f,
  3.19056541e-01f, 1.40080661e-01f, 1.47257999e-01f, 2.13128105e-01f, 3.54203492e-01f, -2.23982230e-01f, 1.54321995e-02f, 4.69823033e-01f, 2.46376321e-01f, 2.07585692e-01f,
  4.67824079e-02f, -1.93909034e-01f, 1.15688015e-02f, -3.08781564e-01f, 3.60585928e-01f, 2.31704757e-01f, 1.14220127e-01f, -1.00483127e-01f, 3.89952436e-02f, 2.05299765e-01f,
  2.83349901e-02f, -4.90271747e-02f, 1.92329824e-01f, 1.04328953e-01f, 7.13989660e-02f, -1.33676216e-01f, -6.87532593e-03f, 1.00299090e-01f, 6.64222762e-02f, 2.45136172e-01f,
  -5.80018107e-03f, 3.33805345e-02f, -1.09473996e-01f, 4.63941693e-02f, 1.97046891e-01f, 1.82947323e-01f, 1.03634961e-01f, 2.94282101e-02f, 2.73043178e-02f, 8.91176239e-03f,
  1.67066976e-01f, 7.37912580e-02f, 1.23824365e-01f, 1.15531199e-01f, -4.79972549e-02f, 2.25123093e-01f, 9.33179781e-02f, 9.66870114e-02f, 9.19321552e-02f, 6.20602667e-02f,
  4.40106280e-02f, 2.43961841e-01f, 1.10524386e-01f, 3.58768627e-02f, 1.05471611e-01f, 2.19024986e-01f, -3.01052793e-03f, 1.28694817e-01f, 1.01360805e-01f, 9.49049518e-02f,
  2.86121145e-02f, -5.43334568e-03f, 8.23478922e-02f, -6.13517873e-02f, -2.84419465e-03f, -3.51288519e-03f, 4.25926931e-02f, 1.31631792e-01f, 2.09504724e-01f, 3.15974951e-02f,
  1.47625357e-01f, 1.43671349e-01f, 6.84803575e-02f, 1.42234266e-01f, 6.98061287e-02f, 1.35824531e-01f, 4.09740023e-02f, -8.58437493e-02f, -1.60067037e-01f, 1.42926484e-01f,
  3.80448299e-03f, -4.21062224e-02f, 1.47682680e-02f, 2.49218885e-02f, 1.20299198e-01f, 8.26263651e-02f, 2.57649459e-03f, 9.52364281e-02f, 1.49343997e-01f, -1.34035572e-01f,
  -2.83310581e-02f, 2.06809461e-01f, 6.08602203e-02f, 1.42954126e-01f, -2.02589676e-01f, 2.46906027e-01f, -7.51170330e-03f, 5.26048020e-02f, 9.50869992e-02f, -5.52916341e-02f,
  -1.58461809e-01f, 9.54968408e-02f, -1.66747034e-01f, 7.11896643e-02f, 1.31425917e-01f, -2.60631833e-02f, 4.82158130e-03f, -1.96790665e-01f, -3.85756828e-02f, -3.26254256e-02f,
  5.62787466e-02f, -9.56762061e-02f, 8.96852612e-02f, -1.61046460e-01f, -8.94474462e-02f, 9.27740335e-02f, 5.30371815e-02f, 7.89907575e-02f, -3.94635610e-02f, -9.32417214e-02f,
  6.00114912e-02f, 9.24901888e-02f, 1.23185210e-01f, -6.17151149e-02f, -1.69704139e-01f, -1.18307486e-01f, 7.41276070e-02f, 5.59789576e-02f, 6.18612543e-02f, 7.04334155e-02f,
  -6.47039041e-02f, -1.06812067e-01f, -2.55297333e-01f, -1.07964262e-01f, 4.92729872e-01f, 1.09247282e-01f, 7.73964524e-02f, -5.58144711e-02f, -9.05667171e-02f, 2.93611646e-01f,
  4.53536659e-01f, 3.45528871e-01f, 4.16147232e-01f, 7.25778416e-02f, -1.19572669e-01f, 2.80026793e-01f, -1.53668011e-02f, -2.92224251e-02f, 1.45912647e-01f, 7.31368065e-02f,
  2.20928535e-01f, -2.75333703e-01f, 3.04985493e-01f, -1.68340653e-01f, 2.67606191e-02f, 7.05736922e-03f, 1.42777890e-01f, -7.51476269e-04f, 9.44798142e-02f, 9.64201912e-02f,
  8.83789882e-02f, -1.03390925e-01f, 6.67656437e-02f, -1.81215666e-02f, -7.79962912e-02f, -2.48894598e-02f, -1.15105167e-01f, -1.13973372e-01f, 1.51620746e-01f, 1.10300191e-01f,
  9.64354426e-02f, 1.06993377e-01f, 1.27501553e-02f, 8.88778716e-02f, 3.37650515e-02f, 6.35513961e-02f, -7.13876113e-02f, 7.36997277e-02f, 6.29718229e-03f, 6.77157864e-02f,
  -4.76443507e-02f, -9.07432586e-02f, 1.87521689e-02f, 8.77059624e-02f, -1.16367690e-01f, 4.60814424e-02f, 2.79901445e-01f, 6.90702945e-02f, 7.08733797e-02f, 4.22588214e-02f,
  1.77093327e-01f, 2.64137015e-02f, -1.70152802e-02f, 1.20157897e-01f, -3.42257991e-02f, 1.32869646e-01f, -1.35207956e-03f, -5.04678600e-02f, -3.29252034e-02f, 1.75605580e-01f,
  3.49685252e-02f, 1.40206203e-01f, 1.46802843e-01f, -3.67596522e-02f, 3.52549665e-02f, -1.04341939e-01f, 9.65936631e-02f, 1.12869158e-01f, -2.67123163e-01f, 7.18971118e-02f,
  1.10228779e-02f, 1.50244132e-01f, -5.87616768e-03f, -7.74537073e-03f, 1.30827621e-01f, -6.04749061e-02f, -5.78319393e-02f, -2.85880826e-02f, 2.13034913e-01f, 1.31649002e-01f,
  8.10908601e-02f, -4.28662412e-02f, 4.48976383e-02f, 1.76233973e-03f, -8.03267658e-02f, 9.43822712e-02f, -2.62038171e-01f, 1.96069740e-02f, -2.32318267e-01f, -1.07214272e-01f,
  1.29384562e-01f, -6.87703630e-03f, -2.05858015e-02f, -1.10023040e-02f, -1.17204472e-01f, -2.31502905e-01f, -1.85297385e-01f, -9.81191993e-02f, -1.24310613e-01f, -2.68015534e-01f,
  1.23379581e-01f, -1.48647919e-01f, -2.38836974e-01f, 1.75934464e-01f, -1.57358889e-02f, -9.07919928e-02f, 1.68958738e-01f, 1.29484490e-01f, 1.13976046e-01f, 7.33227208e-02f,
  -1.28740951e-01f, -8.28756690e-02f, -7.48572946e-02f, 2.50178248e-01f, -1.79281399e-01f, -6.33601099e-02f, -3.28006968e-02f, -2.77756721e-01f, -1.36309773e-01f, -1.59718767e-01f,
  -1.92300156e-01f, 1.51585132e-01f, 3.23350728e-01f, 4.56102490e-01f, 3.99398338e-03f, 2.01314837e-02f, -1.07432827e-01f, -1.90268889e-01f, 3.08797002e-01f, -8.94887894e-02f,
  -2.73317754e-01f, 2.14511871e-01f, -9.90332291e-03f, -1.67840987e-01f, 8.53830501e-02f, 2.82278862e-02f, 2.30914593e-01f, -2.35947296e-01f, 2.22587213e-01f, 2.83098698e-01f,
  -2.45347694e-02f, 7.79370219e-02f, 7.64996409e-02f, 1.33183211e-01f, 7.17599019e-02f, 2.02126931e-02f, 5.85541651e-02f, -4.60304553e-03f, 2.60327328e-02f, 9.65020359e-02f,
  6.84042349e-02f, 8.44113976e-02f, -1.81500462e-03f, 2.70845927e-02f, -5.42028546e-02f, 6.84306547e-02f, 6.48415312e-02f, 3.24548855e-02f, 2.90263426e-02f, -7.64254779e-02f,
  7.76899531e-02f, 1.30447611e-01f, 1.13791578e-01f, -4.57671471e-02f, 9.33644176e-02f, 5.05786389e-02f, 1.31203104e-02f, 1.74903050e-01f, 9.01295468e-02f, 8.24394822e-02f,
  -3.73321809e-02f, 7.94758722e-02f, 3.16743702e-02f, 1.62941385e-02f, 3.92664783e-02f, 4.80251051e-02f, 1.08919911e-01f, 1.13897569e-01f, 3.40855271e-02f, 6.39930889e-02f,
  2.07713991e-01f, 1.07183255e-01f, 9.95518640e-02f, 5.82762621e-02f, 1.54510871e-01f, -1.35007337e-01f, -2.39461772e-02f, 2.09384724e-01f, 9.56748053e-03f, 1.56813502e-01f,
  9.23138037e-02f, 1.88860312e-01f, 9.99087393e-02f, 1.04969271e-01f, 8.36395621e-02f, 1.55063346e-01f, -1.15636662e-01f, 1.10945195e-01f, -1.89207867e-02f, 1.35989398e-01f,
  2.58142669e-02f, -1.04816966e-01f, 7.50840679e-02f, -5.36434911e-02f, 1.23836599e-01f, -2.66768992e-01f, 1.73713952e-01f, 2.83598877e-03f, -3.81106436e-02f, 9.47438553e-02f,
  1.78650945e-01f, 7.99117014e-02f, -7.96646699e-02f, 2.50719786e-01f, -1.54436722e-01f, 3.40332389e-02f, -2.28188075e-02f, 4.28779684e-02f, 1.13448603e-02f, 1.16006553e-01f,
  -1.39451802e-01f, 2.15105899e-02f, -5.28202802e-02f, -1.89410940e-01f, -1.64288923e-01f, -3.85943018e-02f, -6.29336163e-02f, -2.23906964e-01f, 8.52264687e-02f, 5.53501621e-02f,
  -2.95814108e-02f, 3.57790470e-01f, -6.10883124e-02f, -1.84658706e-01f, -7.89401308e-02f, -2.38320027e-02f, 2.60558706e-02f, -9.02758166e-02f, -2.81698257e-01f, -5.29228337e-02f,
  -2.23678667e-02f, 7.34922960e-02f, -4.50020917e-02f, 1.24141864e-01f, -8.37868080e-03f, 5.14305718e-02f, -2.41607219e-01f, 3.40614915e-02f, -1.04425013e-01f, -1.32388934e-01f,
  1.24686144e-01f, 5.08050382e-01f, 2.06629291e-01f, -2.68097892e-02f, -1.13814659e-01f, -1.69104218e-01f, 1.62108064e-01f, -1.29515797e-01f, 2.84292549e-01f, -9.40253437e-02f,
  1.66334268e-02f, -1.94319680e-01f, 5.02634756e-02f, -9.56064910e-02f, -8.06160495e-02f, -5.53799868e-02f, 2.84368157e-01f, 1.47688851e-01f, -1.15410931e-01f, 4.32116576e-02f,
  -6.60616532e-02f, 8.91647041e-02f, 3.39394808e-02f, -4.34343889e-03f, 2.52645742e-02f, 1.92660779e-01f, 1.09279724e-02f, -8.90192110e-03f, 3.49247381e-02f, 1.90046459e-01f,
  2.00393368e-02f, 1.18684627e-01f, -5.74272536e-02f, 1.34677708e-01f, 5.38784862e-02f, -2.85726674e-02f, 6.45290390e-02f, 3.43202911e-02f, 1.15917109e-01f, 2.68435311e-02f,
  -6.67161942e-02f, 1.66004356e-02f, 4.74388851e-03f, -1.78895462e-02f, 1.00508131e-01f, 8.75462964e-02f, 1.80766314e-01f, -4.57057059e-02f, 7.36204088e-02f, 4.96968701e-02f,
  6.82738051e-02f, -7.06347525e-02f, 5.49300276e-02f, -9.87714529e-03f, 4.20472063e-02f, -5.48362872e-03f, -2.43923701e-02f, 1.93282843e-01f, 1.54714599e-01f, 1.67302296e-01f,
  1.03774160e-01f, 3.58001166e-03f, -7.29837567e-02f, 2.73528714e-02f, 6.68677315e-02f, 1.06861070e-01f, 1.31463185e-01f, 6.76635504e-02f, -1.83804184e-02f, 1.26432091e-01f,
  1.57677289e-02f, -1.66166231e-01f, 1.26361027e-01f, -8.13338235e-02f, 1.42844021e-01f, -8.66516158e-02f, 1.96240731e-02f, -2.96640545e-02f, 1.43229023e-01f, -1.40708119e-01f,
  -1.19356371e-01f, 1.03814416e-01f, 5.29119112e-02f, -1.90872267e-01f, 1.32281318e-01f, -1.44927174e-01f, -2.70830952e-02f, 4.77294922e-02f, 1.76659063e-01f, 1.27246410e-01f,
  9.56136882e-02f, 1.94065303e-01f, 8.76607895e-02f, 9.67528597e-02f, 2.15409458e-01f, 1.61555484e-02f, 2.62332615e-02f, 9.58925560e-02f, -8.81188884e-02f, -5.64394668e-02f,
  -5.14761135e-02f, 2.50035703e-01f, -7.96281174e-02f, 2.75655001e-01f, -3.67296487e-02f, 1.36653706e-01f, -9.27852374e-03f, 2.35955697e-02f, -1.83104277e-01f, 1.36493400e-01f,
  -4.16415073e-02f, -6.84074089e-02f, 8.55134875e-02f, -1.39655307e-01f, 1.63080804e-02f, -2.02591270e-01f, -2.24287033e-01f, -4.03982140e-02f, -2.11653814e-01f, -3.17182131e-02f,
  5.56264333e-02f, -5.67116588e-02f, -4.62442152e-02f, -1.92826807e-01f, 2.22665351e-02f, 3.81570831e-02f, 3.47210079e-01f, -5.38446307e-02f, -3.66199613e-01f, 5.09484589e-01f,
  -2.22224779e-02f, 1.18709952e-01f, 8.45444500e-02f, -9.67834666e-02f, -1.83840483e-01f, -2.97152042e-01f, -4.48336750e-02f, 1.89546887e-02f, 1.75994426e-01f, -2.55374908e-01f,
  1.24340534e-01f, 1.73362389e-01f, -1.35372087e-01f, 2.92431623e-01f, -2.29636598e-02f, 2.73723841e-01f, 1.37183055e-01f, 2.24892154e-01f, 2.71592200e-01f, 1.41131386e-01f,
  1.74619511e-01f, -4.36108187e-02f, 2.27462389e-02f, 7.83460736e-02f, 2.33033951e-02f, 1.28559545e-01f, 2.05117054e-02f, -2.06025457e-03f, 2.48205811e-02f, 6.25699535e-02f,
  1.41689688e-01f, 6.39764071e-02f, 1.75374467e-02f, 5.69849573e-02f, 7.07219467e-02f, 2.23081280e-02f, 8.81716534e-02f, 8.24485794e-02f, 2.61205863e-02f, -1.73662845e-02f,
  6.19317070e-02f, 2.65715476e-02f, 1.04711190e-01f, 3.61373685e-02f, -7.36033618e-02f, 4.09329608e-02f, 5.59083037e-02f, 7.35609606e-02f, 1.83773428e-01f, 1.65290877e-01f,
  1.12867430e-01f, 9.71853957e-02f, -2.71430612e-03f, 1.11813443e-02f, 1.82264820e-01f, 7.36012980e-02f, 1.65278069e-03f, 1.48776965e-02f, -9.70241427e-03f, 8.26221481e-02f,
  -2.31012888e-02f, 7.05690384e-02f, 6.06085584e-02f, -1.28898248e-01f, 9.26948562e-02f, 1.90695122e-01f, -1.74316429e-02f, 6.71254396e-02f, -4.83489893e-02f, -1.55692995e-01f,
  -8.24565589e-02f, -5.09204455e-02f, -6.40062764e-02f, 1.46249220e-01f, -1.94383875e-01f, 1.79755352e-02f, 2.71974385e-01f, 2.57876694e-01f, -1.28842831e-01f, 4.39611636e-02f,
  2.04818025e-02f, 8.06662515e-02f, -1.58087593e-02f, 1.88610733e-01f, 1.43022344e-01f, 5.89620546e-02f, -1.38377264e-01f, 1.73034891e-01f, -1.16795175e-01f, 5.31520881e-03f,
  2.51601599e-02f, 5.77328866e-03f, -1.12831950e-01f, 3.36545259e-02f, -3.11814668e-03f, 1.12662083e-02f, 1.51380301e-01f, 3.24977934e-02f, -4.56771031e-02f, 1.62031844e-01f,
  -7.94171635e-03f, -1.31250829e-01f, 1.43021211e-01f, -1.18749894e-01f, 3.82595807e-02f, -1.64837375e-01f, -4.51370776e-02f, -1.37708575e-01f, -2.00688858e-02f, 1.89820632e-01f,
  9.45258327e-03f, -2.52618752e-02f, -1.04442142e-01f, 2.39031494e-01f, 2.73125827e-01f, 3.64641077e-03f, -1.17291234e-01f, -1.02524370e-01f, 7.10481545e-03f, -7.60322064e-02f,
  2.11001083e-01f, 2.89809436e-01f, 3.73517752e-01f, -4.81874123e-03f, 9.70831141e-02f, 1.68843165e-01f, 3.96560788e-01f, -2.43621171e-01f, 4.08685580e-02f, 1.05891570e-01f,
  -1.16195828e-01f, 9.76980701e-02f, 3.73294055e-01f, 5.41946813e-02f, 2.83102274e-01f, 3.77164245e-01f, -1.14175692e-01f, 2.51233965e-01f, -1.68600291e-01f, 1.56564578e-01f,
  3.12992841e-01f, 9.81938317e-02f, 9.33414884e-03f, -3.25956464e-01f, 1.00732490e-01f, -2.51380622e-01f, 2.43059248e-01f, -1.71299055e-02f, 1.83413792e-02f, -7.92268738e-02f,
  1.37789339e-01f, 4.45581861e-02f, 6.03971072e-02f, -5.68600930e-02f, -1.98808662e-03f, -4.56966534e-02f, 5.72264269e-02f, 9.86344144e-02f, -1.00291714e-01f, 6.08447082e-02f,
  7.38170892e-02f, 8.21993500e-02f, 1.81685686e-02f, 2.43507903e-02f, -9.36063123e-04f, 1.21877961e-01f, 7.39572793e-02f, 2.07673386e-01f, 1.61933213e-01f, 5.58597706e-02f,
  9.71582532e-02f, -9.65029970e-02f, -1.24419414e-01f, 6.52711932e-03f, -8.15980434e-02f, -1.02606773e-01f, -2.16180980e-02f, 3.11327241e-02f, -4.32041958e-02f, 7.03721717e-02f,
  8.07246938e-02f, -4.03182395e-02f, 8.17583352e-02f, -9.10503510e-03f, 1.87519804e-01f, -3.38312984e-02f, 5.39454035e-02f, 1.26102045e-01f, 9.74379033e-02f, 4.52819653e-02f,
  2.52457913e-02f, 1.56317964e-01f, 6.55693859e-02f, -3.75010669e-02f, 1.90879256e-02f, -5.26318187e-03f, -1.53293740e-02f, 1.58998277e-02f, 1.25752136e-01f, 8.36986676e-02f,
  9.23021287e-02f, 9.46177617e-02f, -4.99741286e-02f, 9.15109925e-03f, -2.32347623e-01f, -1.17750205e-01f, 8.63260254e-02f, 6.60272390e-02f, 1.14866629e-01f, -5.22715673e-02f,
  -4.44313101e-02f, 2.84619890e-02f, 2.06325520e-02f, -1.59905225e-01f, 9.31397900e-02f, -7.50069916e-02f, 1.44006237e-01f, 4.82244454e-02f, -1.25815839e-01f, -6.34968355e-02f,
  1.57769993e-01f, 4.41582128e-02f, 7.33960271e-02f, 1.90729156e-01f, 9.72238556e-02f, 2.16988027e-02f, 4.66660112e-02f, -1.33540019e-01f, 7.48560503e-02f, 7.09343776e-02f,
  8.03977102e-02f, 6.38926551e-02f, -4.81760874e-02f, -4.27849795e-04f, -1.70078307e-01f, 1.27953872e-01f, -5.78817651e-02f, 4.83189933e-02f, -5.15277460e-02f, 5.93926124e-02f,
  1.35531172e-01f, -6.10000007e-02f, -1.76192284e-01f, -4.36628126e-02f, -8.82015675e-02f, 1.18647836e-01f, 3.50363888e-02f, -6.21259362e-02f, 2.55146027e-01f, -1.48056835e-01f,
  1.07582867e-01f, 1.96664035e-01f, -3.46012674e-02f, -1.67560931e-02f, -6.77661896e-02f, 2.53119826e-01f, 3.17069024e-01f, -1.70188099e-01f, 2.65185177e-01f, 2.83170473e-02f,
  -3.06492984e-01f, -5.47913052e-02f, -1.17160626e-01f, 7.40587190e-02f, 1.57596171e-01f, 2.13196669e-02f, 5.05559072e-02f, 2.66963989e-01f, -3.01682856e-02f, -1.20027058e-01f,
  2.65745163e-01f, 1.35252744e-01f, -4.03748974e-02f, 4.17596489e-01f, 2.06594393e-01f, -3.62071730e-02f, 7.86710754e-02f, -6.75251186e-02f, 2.12113485e-02f, 4.17529158e-02f,
  1.52943626e-01f, 1.75787926e-01f, 2.89751310e-02f, 2.54305749e-04f, 1.13272769e-02f, 1.38217583e-01f, 2.96365060e-02f, 1.64431244e-01f, 7.57088047e-03f, 1.31468549e-01f,
  3.75634059e-02f, 2.61431914e-02f, 5.07948212e-02f, -5.87767884e-02f, 2.53233276e-02f, 1.33719712e-01f, -3.06206308e-02f, 1.64234325e-01f, -1.42826480e-04f, -1.21314824e-01f,
  -1.29690683e-02f, -6.66342501e-04f, -4.91685048e-02f, -5.06588072e-02f, 1.43938929e-01f, 1.11709848e-01f, 7.16519952e-02f, 1.66609921e-02f, -5.31782694e-02f, 6.14212565e-02f,
  1.03305735e-01f, 9.65911597e-02f, 1.13258488e-01f, 5.65052778e-02f, 1.69158921e-01f, 8.94462541e-02f, 4.22395673e-03f, 1.23240657e-01f, 8.64081755e-02f, 5.49269915e-02f,
  1.11033462e-01f, 1.92842335e-02f, 2.49692239e-02f, -9.15523469e-02f, 9.54016894e-02f, -1.02236636e-01f, 2.58955993e-02f, -4.96841334e-02f, 1.53568506e-01f, 1.13004781e-01f,
  4.13561091e-02f, -1.24366947e-01f, 5.22802696e-02f, 9.40719340e-03f, 4.95184511e-02f, 8.00189674e-02f, -2.03761887e-02f, 7.19363522e-03f, -2.78948545e-01f, 9.67592932e-03f,
  5.53290769e-02f, -7.96614960e-02f, -1.74842798e-03f, -2.90192775e-02f, 1.57915637e-01f, -1.47671208e-01f, 1.17414437e-01f, -2.01853607e-02f, 2.52207786e-01f, 4.23824694e-03f,
  -1.86844170e-02f, 8.72737169e-03f, 3.34506817e-02f, -2.10520625e-02f, 4.00728434e-02f, 1.55415475e-01f, 1.74363762e-01f, 1.70266077e-01f, 1.17619611e-01f, 1.37287214e-01f,
  -1.57541230e-01f, 3.52366696e-05f, -3.47927213e-04f, -2.68502712e-01f, 3.29569392e-02f, 1.00197755e-01f, -1.70871913e-01f, -1.16485484e-01f, -1.62147030e-01f, -3.66369523e-02f,
  8.36157426e-03f, -4.92856391e-02f, -1.34535164e-01f, 3.57932821e-02f, -3.99452224e-02f, -5.10032102e-02f, 2.67056644e-01f, 2.91152358e-01f, 2.27162763e-01f, 1.62901580e-01f,
  2.29539707e-01f, 6.22907951e-02f, -2.08582938e-01f, -4.25987929e-01f, 4.30046134e-02f, -1.75258607e-01f, 1.10740386e-01f, 1.52117293e-03f, -3.78781170e-01f, 1.03228055e-01f,
  4.13710624e-02f, 1.42546162e-01f, -4.53246459e-02f, 3.44496697e-01f, -1.10963516e-01f, 1.19992211e-01f, 1.08679615e-01f, 2.52178222e-01f, 4.71551083e-02f, 1.98911592e-01f,
  -9.62350424e-03f, 2.09967613e-01f, -1.22626215e-01f, 6.73304358e-03f, -6.04077689e-02f, 5.88071868e-02f, -9.64955688e-02f, 1.08848214e-01f, -1.07038468e-01f, 2.72541270e-02f,
  -1.27233565e-01f, -3.86795141e-02f, 1.35297671e-01f, -1.99078908e-03f, -4.32677791e-02f, -2.48120399e-03f, -7.95544609e-02f, -9.11164731e-02f, 9.01476145e-02f, 2.04693880e-02f,
  5.27534224e-02f, 8.37705508e-02f, -2.14200430e-02f, 1.46857137e-02f, -7.75294602e-02f, 8.62904638e-02f, -7.22097903e-02f, -1.29910365e-01f, -8.82658958e-02f, -5.75615279e-02f,
  -3.10522690e-02f, -1.04143821e-01f, -1.83324620e-01f, -2.95020211e-02f, -2.64104288e-02f, 1.57005653e-01f, -7.80023308e-03f, -4.90980782e-02f, -5.07197939e-02f, -2.58484129e-02f,
  8.35601464e-02f, -6.87878728e-02f, 4.16326262e-02f, -6.32951036e-02f, 6.97754920e-02f, -4.26986627e-03f, -6.91393316e-02f, 1.25319827e-02f, -3.95988114e-02f, -4.84488299e-03f,
  3.86382826e-02f, -6.94256052e-02f, 7.70683810e-02f, -8.21319968e-02f, -5.87071739e-02f, 4.61821444e-02f, -7.21680075e-02f, 1.34133790e-02f, -3.95264961e-02f, 6.47120029e-02f,
  9.54072252e-02f, 3.74172553e-02f, 4.33978885e-02f, -6.92361733e-03f, 1.55563712e-01f, 1.13514089e-03f, -1.84128005e-02f, 7.83398822e-02f, -8.24004263e-02f, 3.81532172e-03f,
  2.27141920e-02f, -1.42002786e-02f, -1.01266906e-01f, -1.69584826e-01f, 4.75298911e-02f, 6.14654757e-02f, 2.38983184e-02f, -5.64351976e-02f, -1.38081431e-01f, 1.22668192e-01f,
  8.12832564e-02f, -1.01391725e-01f, -6.48010299e-02f, -7.01625496e-02f, 5.16049005e-02f, -3.68024455e-04f, -5.55587038e-02f, -2.59730127e-02f, 1.64808512e-01f, 2.27987748e-02f,
  3.80212031e-02f, 1.62186384e-01f, -1.15492120e-01f, -1.04004294e-01f, -7.67987501e-03f, -3.56826074e-02f, -2.94197723e-02f, -1.48308218e-01f, 7.16906041e-02f, -6.22108132e-02f,
  4.27458212e-02f, -4.08476703e-02f, 8.61340947e-03f, 1.47405282e-01f, -3.12318921e-01f, -9.84565839e-02f, -1.06779642e-01f, 6.30443841e-02f, -3.22470330e-02f, -1.22434087e-02f,
  -1.61676630e-01f, 7.58066848e-02f, -2.82807112e-01f, 1.55621037e-01f, 2.26889804e-01f, 3.12553316e-01f, 2.31178746e-01f, -1.16225891e-01f, -1.59093931e-01f, -2.76854113e-02f,
  1.46120846e-01f, -1.25742033e-01f, 2.04874963e-01f, 2.00066939e-02f, -3.47319394e-02f, -1.36792019e-01f, -9.99450013e-02f, -2.03451402e-02f, 8.23935680e-03f, -9.15584937e-02f,
  -5.71412519e-02f, 1.03213295e-01f, 1.03855535e-01f, 1.21614262e-01f, -5.73512763e-02f, 7.16298521e-02f, -4.92212027e-02f, 6.31419346e-02f, 1.36564495e-02f, 5.54807112e-02f,
  8.33082795e-02f, 4.91499305e-02f, 4.97102886e-02f, 5.41332513e-02f, 1.67300299e-01f, 4.53089625e-02f, -2.25981921e-02f, 1.74987987e-01f, 1.79289907e-01f, 1.26004696e-01f,
  3.10858730e-02f, 9.82757062e-02f, 9.06343311e-02f, 1.52410895e-01f, -2.79858522e-02f, 1.70174986e-01f, -4.58455682e-02f, 2.71905567e-02f, 1.80750936e-02f, 9.89372507e-02f,
  8.03510174e-02f, 1.05517179e-01f, 1.71472877e-01f, 1.34931818e-01f, 1.47975326e-01f, 2.43193746e-01f, -9.49157344e-04f, 4.50967811e-02f, 4.97495756e-02f, 3.99659537e-02f,
  -4.02348302e-02f, 7.33546168e-02f, 1.76067129e-02f, -7.20086368e-03f, 2.89267227e-02f, 8.68151039e-02f, 1.01450048e-01f, 1.09178737e-01f, 5.46086319e-02f, 1.79245979e-01f,
  4.58455198e-02f, -1.30516991e-01f, 1.85855087e-02f, -6.99463338e-02f, 1.86139211e-01f, -5.21295816e-02f, -3.54057737e-02f, -5.79247363e-02f, 2.66246535e-02f, -1.41947651e-02f,
  -1.33446857e-01f, -6.62131282e-03f, 8.55576396e-02f, 2.85727065e-02f, -9.32481661e-02f, -1.24594450e-01f, -2.47488078e-02f, -7.95583576e-02f, 1.16462469e-01f, 1.90630496e-01f,
  2.10962772e-01f, -8.07126239e-02f, -8.60272050e-02f, -6.51790723e-02f, 1.58169061e-01f, 7.37061352e-02f, 5.91307655e-02f, 1.10907234e-01f, 1.94531400e-02f, -1.15680853e-02f,
  -1.79141983e-02f, -2.21317504e-02f, 1.56241553e-02f, 1.68651760e-01f, -2.50834525e-01f, 1.63220122e-01f, -8.70509967e-02f, -8.19414109e-02f, -2.22284690e-01f, -1.05279326e-01f,
  1.01478189e-01f, 3.22600082e-02f, 9.27278996e-02f, -9.54852551e-02f, 6.73683733e-03f, -2.16876250e-02f, -6.19140714e-02f, -1.31777311e-02f, 8.83034989e-02f, -1.82832643e-01f,
  8.69916379e-02f, -1.79197669e-01f, -4.25087139e-02f, 1.97848544e-01f, 2.55948007e-01f, -1.33935168e-01f, 2.89708883e-01f, 2.50109971e-01f, -1.21007822e-01f, 2.62098730e-01f,
  -7.46974051e-02f, 2.09164053e-01f, 3.80486324e-02f, 6.39031380e-02f, -3.03546250e-01f, -6.92139864e-02f, 2.51050234e-01f, 9.82698798e-02f, -8.43529850e-02f, -2.00695887e-01f,
  -6.22427016e-02f, -8.58879015e-02f, 7.30398148e-02f, -8.08324106e-03f, -7.01386631e-02f, -1.53237313e-01f, -1.08670324e-01f, -2.23888770e-01f, -1.00321006e-02f, 1.05580300e-01f,
  1.26391664e-01f, 7.50186592e-02f, 3.41435820e-02f, 7.74343684e-02f, -5.32886535e-02f, -6.68348819e-02f, 7.68886805e-02f, 2.34955102e-01f, 9.22174156e-02f, 1.81826144e-01f,
  1.27845526e-01f, 2.12562103e-02f, 5.52492142e-02f, 8.62303823e-02f, 1.55264080e-01f, 1.84314325e-01f, -8.36992785e-02f, 2.04798412e-02f, 5.42719215e-02f, 1.24692596e-01f,
  -1.89521611e-02f, 1.09534547e-01f, -4.24616896e-02f, 7.89169595e-02f, 1.81371748e-01f, 5.25676794e-02f, 6.18238049e-03f, 1.63846418e-01f, -5.60741406e-04f, 1.20290436e-01f,
  1.48459701e-02f, 4.76116501e-02f, 1.85124546e-01f, 1.44208908e-01f, 7.81948864e-02f, 9.83828902e-02f, 7.27292523e-02f, 1.39520988e-01f, -3.71100905e-04f, -2.95463391e-02f,
  3.17094773e-02f, 5.24195358e-02f, 6.31415099e-02f, 8.11772496e-02f, 4.44688052e-02f, 8.76199976e-02f, 1.11030407e-01f, 4.84294370e-02f, 2.42209479e-01f, -7.72467777e-02f,
  2.91373730e-01f, 6.15969114e-02f, 3.14507484e-02f, -1.35744512e-01f, 6.94950223e-02f, 5.26885595e-03f, -2.77139563e-02f, -1.26829073e-01f, -1.18353620e-01f, -1.54133677e-01f,
  3.95092331e-02f, -1.56079188e-01f, 2.81539112e-01f, -1.64477885e-01f, -4.62492369e-02f, -9.28417221e-02f, 3.46607491e-02f, -8.88033956e-02f, 5.04223295e-02f, 1.17908195e-01f,
  9.30720270e-02f, -6.62187412e-02f, 1.19661756e-01f, 1.49668315e-02f, 2.35119253e-01f, -1.41556889e-01f, -1.18839651e-01f, -8.64395276e-02f, -1.34417787e-01f, 1.48353860e-01f,
  -7.01200292e-02f, 1.92144677e-01f, -4.40694913e-02f, 2.55524397e-01f, -8.04089308e-02f, 8.78924057e-02f, -1.05358930e-02f, 2.50118941e-01f, 3.24959904e-02f, -2.80378461e-01f,
  9.73732769e-02f, 2.41264571e-02f, 8.05965904e-03f, -1.17503077e-01f, -1.01156540e-01f, 1.23334378e-01f, 1.74962088e-01f, -2.56015420e-01f, -2.29649004e-02f, -1.38785504e-03f,
  -2.07799420e-01f, -1.48119345e-01f, -1.75727278e-01f, -5.03984243e-02f, 3.77681494e-01f, -5.45965508e-02f, -2.23830566e-01f, 4.61398572e-01f, 1.64675221e-01f, -1.08295254e-01f,
  9.82977003e-02f, -3.26436490e-01f, -1.73124373e-02f, -3.74905765e-03f, 2.15481490e-01f, -2.45065883e-01f, 4.70695421e-02f, -3.51130158e-01f, 1.73354253e-01f, 2.04564661e-01f,
  3.57175246e-02f, 9.77592915e-02f, -4.41565901e-01f, 1.37546062e-01f, -8.16531107e-02f, 1.45374507e-01f, 1.47890449e-01f, 1.15537206e-02f, -1.77962705e-03f, 4.86290120e-02f,
  3.53984609e-02f, 2.06350729e-01f, 1.19536020e-01f, 1.75501943e-01f, -1.06804706e-01f, 1.24860033e-01f, 1.15764998e-01f, 2.07071751e-01f, 4.90320809e-02f, 1.99270025e-01f,
  -3.98888998e-02f, -6.39928281e-02f, -9.43273902e-02f, 7.69885909e-03f, 3.33044864e-02f, 7.71237239e-02f, 4.45083231e-02f, 3.23271565e-02f, -2.05347780e-02f, 5.17682284e-02f,
  -7.15427697e-02f, 3.74806970e-02f, 1.00482665e-01f, 6.21299201e-04f, -1.18880183e-01f, -1.77704152e-02f, 3.59434560e-02f, 6.44547446e-03f, -2.12671012e-02f, 2.45578587e-02f,
  4.23133461e-04f, -8.64570364e-02f, -6.78539872e-02f, 2.86074374e-02f, 5.16865179e-02f, -2.60034250e-03f, 1.17712542e-02f, 1.73421428e-02f, 1.19888753e-01f, 2.17272677e-02f,
  -5.75815514e-02f, 1.42157584e-01f, -2.30863113e-02f, 1.77321479e-01f, -4.63892370e-02f, 8.27019382e-03f, 3.94701622e-02f, 2.15279665e-02f, -1.46227270e-01f, -2.91244909e-02f,
  6.12246338e-03f, 8.03650990e-02f, 2.21208222e-02f, -6.71742335e-02f, 1.33223683e-01f, -8.98434371e-02f, 8.05858895e-02f, -1.72958896e-02f, 9.41531509e-02f, -1.15493193e-01f,
  4.54884097e-02f, 1.26168415e-01f, -3.19422446e-02f, 1.38306990e-01f, 2.19778698e-02f, 9.08350050e-02f, 2.23387107e-02f, 1.01486072e-01f, -9.76264700e-02f, 4.62758727e-02f,
  9.74158123e-02f, 2.35782452e-02f, 1.55100282e-02f, 1.99970528e-01f, 1.32103711e-01f, 9.95650440e-02f, -1.61044866e-01f, -2.21671894e-01f, 1.27317593e-01f, -1.48340821e-01f,
  -2.20543910e-02f, 6.15809411e-02f, 1.90015480e-01f, -3.67527455e-02f, 2.50088517e-02f, 1.16735823e-01f, -8.90485346e-02f, -2.20674593e-02f, -4.32125404e-02f, 1.60455592e-02f,
  1.19484209e-01f, -1.36192426e-01f, -1.09276563e-01f, -5.11654234e-03f, -2.49565095e-01f, -5.28930575e-02f, 2.01992810e-01f, -1.02624677e-01f, 2.96219558e-01f, 1.06837817e-01f,
  -4.64600436e-02f, 2.60517299e-01f, -1.23385705e-01f, 1.48693621e-01f, -1.77886724e-01f, -5.65866046e-02f, 3.49305600e-01f, -2.01132223e-01f, -1.48555249e-01f, 1.70735374e-01f,
  -1.52045682e-01f, -3.06749254e-01f, 1.50465533e-01f, -1.79166794e-01f, -6.90835416e-02f, 3.30798864e-01f, -7.48174042e-02f, -1.20085403e-02f, -2.28453025e-01f, 1.90565921e-02f,
  2.56257325e-01f, 8.52866396e-02f, -3.60007375e-01f, -1.33814648e-01f, 1.54979602e-02f, 2.02321522e-02f, 1.27845770e-02f, 1.13956653e-01f, 3.28636318e-02f, 7.51419365e-02f,
  2.81628761e-02f, 8.21955279e-02f, 8.02733079e-02f, 3.77100445e-02f, 7.18892813e-02f, 9.10141170e-02f, -6.76093549e-02f, 8.77330154e-02f, 9.19166133e-02f, 1.31827056e-01f,
  1.59286797e-01f, -1.24016382e-01f, 8.92505273e-02f, 1.50565458e-02f, 8.65526348e-02f, 1.06135830e-01f, 1.74135894e-01f, 9.15814415e-02f, 1.06911086e-01f, 6.02902323e-02f,
  1.41366571e-01f, 7.58174062e-02f, 8.85942578e-02f, 8.60990658e-02f, 2.21486017e-01f, 1.02293104e-01f, -4.84374315e-02f, 1.60126030e-01f, 3.33755538e-02f, 2.73537606e-01f,
  7.64832348e-02f, 1.43520027e-01f, 1.71064317e-01f, 4.76961844e-02f, 1.52291134e-01f, 4.08616811e-02f, 8.58394727e-02f, -4.21046168e-02f, -3.96211259e-02f, 1.35194287e-01f,
  4.01135813e-03f, 1.84714168e-01f, 6.61379751e-03f, 4.02647667e-02f, 1.41832784e-01f, -4.50683162e-02f, 8.53986368e-02f, -8.11636373e-02f, 1.32439226e-01f, 7.29692429e-02f,
  -9.39155594e-02f, 5.35095073e-02f, -2.23547556e-02f, -1.33855522e-01f, 1.69414878e-01f, 4.66796290e-03f, 2.41998583e-01f, -1.80286780e-01f, 4.39596139e-02f, -7.05154762e-02f,
  -1.18869387e-01f, 9.95029956e-02f, 1.02867998e-01f, 1.01404831e-01f, -7.95112550e-03f, 3.47421281e-02f, 6.65641800e-02f, -9.77517217e-02f, 3.16433400e-01f, 4.78606150e-02f,
  -1.29364699e-01f, 2.83696294e-01f, 2.58427504e-02f, 2.15988964e-01f, -4.08045501e-02f, -1.33749515e-01f, -8.69084969e-02f, 3.92098129e-02f, -1.43818945e-01f, 1.02919957e-03f,
  -1.21058442e-03f, 1.00671336e-01f, -1.17589921e-01f, 2.43007481e-01f, -1.26708508e-01f, 4.50969860e-02f, -7.17039779e-02f, -1.02261297e-01f, 1.00227520e-01f, -2.40774035e-01f,
  -1.93131313e-01f, -1.75940320e-01f, -2.10039183e-01f, 4.27277870e-02f, 1.53390646e-01f, 1.43602729e-01f, 3.35303470e-02f, 7.95138255e-02f, -1.43551871e-01f, 2.03981787e-01f,
  4.43798527e-02f, -1.03293173e-01f, -1.34938508e-02f, 4.39340889e-01f, 2.12211996e-01f, -2.48150662e-01f, -3.10055494e-01f, -1.19019635e-01f, -2.94621974e-01f, 1.22907743e-01f,
  5.79619884e-01f, -2.72554308e-01f, -7.89858215e-03f, 2.26512134e-01f, -8.00799653e-02f, -1.14574224e-01f, -1.74433649e-01f, 2.37168238e-01f, 4.34438974e-01f, 2.80616164e-01f,
  3.03869188e-01f, 1.04567192e-01f, 1.61284581e-01f, 6.62464648e-02f, 5.83102591e-02f, 1.57542959e-01f, -1.57154426e-02f, -7.37069324e-02f, -1.55434251e-01f, -9.83376503e-02f,
  1.72674969e-01f, -2.63447538e-02f, 4.93401550e-02f, 2.33143028e-02f, 7.82985464e-02f, 9.90217999e-02f, 1.67815417e-01f, -5.77540584e-02f, 7.97692314e-03f, 5.60841747e-02f,
  -2.00049896e-02f, 2.07637757e-01f, 3.04993782e-02f, 1.36562645e-01f, 1.00640476e-01f, 9.51855853e-02f, -4.02862318e-02f, 4.87132110e-02f, -8.83176550e-02f, 1.61985666e-01f,
  3.61255668e-02f, 5.20354845e-02f, -3.34979594e-02f, 1.99705973e-01f, 1.82515278e-01f, 1.81445926e-02f, -4.25543077e-03f, 2.20996961e-01f, 5.03256023e-02f, 5.73457871e-03f,
  1.99085131e-01f, 8.75348374e-02f, 6.43003955e-02f, 5.52030280e-02f, 9.03695226e-02f, 2.27384679e-02f, 1.08744249e-01f, 1.48500845e-01f, 5.01749441e-02f, 6.58019334e-02f,
  3.14768143e-02f, 1.33489758e-01f, 5.75440526e-02f, 1.71323940e-01f, -2.92618666e-02f, 2.27215260e-01f, 1.84008613e-01f, 4.49962579e-02f, 5.20761311e-02f, -1.26872614e-01f,
  -1.94246545e-01f, 2.39057720e-01f, 1.65586427e-01f, 1.39187753e-01f, 1.94207534e-01f, -1.68442037e-02f, -1.47423491e-01f, 1.22188784e-01f, -3.11696138e-02f, -1.87997326e-01f,
  9.52309966e-02f, -3.95513549e-02f, -6.16236776e-02f, -5.88872880e-02f, 6.56431764e-02f, 2.30693500e-02f, -1.07714869e-01f, 6.31244108e-02f, -1.12522058e-01f, 3.50739248e-02f,
  1.24690413e-01f, -5.94945326e-02f, 6.61458746e-02f, -2.94214845e-01f, 8.24930072e-02f, -8.41615498e-02f, 1.73029914e-01f, -4.44067679e-02f, -8.32350850e-02f, 7.88933784e-03f,
  -1.36349276e-01f, -7.15700686e-02f, -6.37970790e-02f, 4.94427159e-02f, -6.17180578e-03f, -1.36991829e-01f, 6.87707812e-02f, -5.34854569e-02f, 1.20518968e-01f, -1.99922130e-01f,
  -2.38564350e-02f, 1.02544613e-01f, -1.43667743e-01f, 2.10356623e-01f, 1.63151070e-01f, -3.08783025e-01f, 2.84199808e-02f, -5.44524081e-02f, -2.86328256e-01f, -6.26733676e-02f,
  4.49106395e-01f, 1.41690791e-01f, 4.74367030e-02f, -6.20523803e-02f, -4.32982408e-02f, 2.36420169e-01f, 2.48626806e-02f, 5.68756938e-01f, -1.26975372e-01f, -3.29035521e-01f,
  1.34671060e-02f, 2.24004522e-01f, -2.02636689e-01f, -2.79502690e-01f, -2.31788293e-01f, 8.04609060e-02f, 3.96421432e-01f, 5.49607240e-02f, 3.37966144e-01f, 2.55768746e-01f,
  1.93512619e-01f, -1.33870281e-02f, -5.74236996e-02f, 4.16506920e-03f, 1.46823078e-01f, 9.51878726e-02f, 3.79207507e-02f, 2.54607856e-01f, 7.45153874e-02f, 3.44991460e-02f,
  3.65790576e-02f, 6.45532738e-03f, 1.44192100e-01f, 1.53106794e-01f, 8.63707960e-02f, 1.00549288e-01f, 3.88417542e-02f, 1.20747745e-01f, 3.43671069e-02f, -1.59770902e-02f,
  6.68560714e-02f, 7.01477751e-02f, 5.99537157e-02f, 1.16944224e-01f, -5.13675511e-02f, 3.25091593e-02f, -8.32271352e-02f, 7.87479356e-02f, -5.07225879e-02f, 1.25089154e-01f,
  1.84480786e-01f, 7.18345270e-02f, 3.61655019e-02f, 7.67531022e-02f, 8.09970349e-02f, 8.27571899e-02f, 4.96300682e-02f, 4.36787643e-02f, -1.25073893e-02f, -4.59048189e-02f,
  4.43520732e-02f, -5.34926727e-03f, 3.07760239e-02f, 5.38331643e-02f, 2.60704290e-02f, 2.92443465e-02f, -6.74633821e-03f, 2.50244737e-02f, -2.16982774e-02f, 8.53528529e-02f,
  -8.36447477e-02f, -1.29601225e-01f, -3.64511423e-02f, -2.35723466e-01f, 3.88759263e-02f, 1.70348644e-01f, -1.66685849e-01f, 3.44444253e-02f, 1.18474498e-01f, 1.92133576e-01f,
  -3.02110091e-02f, -8.47774222e-02f, 3.47629329e-03f, 1.41866848e-01f, -2.39536688e-01f, -9.83132720e-02f, -1.21629797e-02f, 9.61668119e-02f, -5.10732941e-02f, 1.21460989e-01f,
  1.09724298e-01f, -9.09810588e-02f, 5.77163734e-02f, -7.97909126e-02f, 1.64593384e-01f, 4.40837517e-02f, -2.64967263e-01f, 9.68008861e-02f, 9.43566337e-02f, -1.96898188e-02f,
  2.94038448e-02f, 4.99194115e-02f, 2.91201174e-02f, 8.03502798e-02f, -4.75772843e-02f, 1.14379413e-01f, -1.51462123e-01f, -9.18677971e-02f, -6.02031350e-02f, -2.42957264e-01f,
  5.53300902e-02f, 1.38270468e-01f, -1.01701848e-01f, -4.62144986e-02f, 3.97453457e-02f, -8.70025754e-02f, 3.12556550e-02f, 6.41220659e-02f, 9.51909274e-02f, -1.13125905e-01f,
  -2.48899534e-02f, -1.61300808e-01f, 2.40593940e-01f, 3.37036699e-01f, 1.66353181e-01f, 2.66865373e-01f, 1.53952479e-01f, 1.22774668e-01f, -1.35650307e-01f, -3.19144070e-01f,
  1.28870234e-01f, 5.10373525e-02f, -1.63101569e-01f, 1.24737568e-01f, -3.53748947e-01f, 4.85666133e-02f, 3.49832624e-01f, 7.59703815e-02f, -7.12581724e-02f, 3.59269738e-01f,
  -2.06252277e-01f, -6.69912621e-02f, 7.14172199e-02f, 4.23076153e-01f, 9.12854224e-02f, -2.07808122e-01f, -1.57503590e-01f, 2.19521478e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.82374865e-01f, 1.20361924e-01f, 1.42616943e-01f, 1.37669414e-01f, 1.70290515e-01f, 2.04068646e-01f, 1.51531652e-01f, 8.00820887e-02f, 3.83778028e-02f, 2.77427495e-01f,
  2.03783698e-02f, 7.20060840e-02f, 8.55979994e-02f, 1.20688111e-01f, 2.31750622e-01f, 1.68549225e-01f, 1.97991654e-01f, 1.30777076e-01f, 1.11668855e-01f, -1.44550562e-01f,
  1.59824584e-02f, 1.12280726e-01f, 1.19269714e-01f, 1.05484910e-01f, 2.20788151e-01f, 8.62774625e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  6.97485507e-02f, -1.89658657e-01f, 1.74395591e-01f, -2.77850330e-01f, -1.86346963e-01f, -2.87633598e-01f, 2.32933909e-02f, 6.43166155e-02f, -3.72765101e-02f, 1.09742388e-01f,
  7.69424066e-02f, -3.74447107e-02f, -1.98700465e-02f, 4.67634797e-02f, 5.67571959e-03f, 2.53431289e-03f, -2.09898889e-01f, 1.84855998e-01f, 1.32428065e-01f, -8.63651633e-02f,
  -2.28816438e-02f, -5.03848530e-02f, -1.90235749e-01f, -1.53797641e-01f, -4.05265652e-02f, 2.19939262e-01f, 8.16486254e-02f, -2.52854735e-01f, -1.82740211e-01f, -2.46599868e-01f,
  -3.21817935e-01f, 1.81996152e-01f, -1.20523371e-01f, -2.15659495e-02f, -3.17675412e-01f, 1.73817307e-01f, -1.57920673e-01f, -3.53791676e-02f, 2.27393210e-01f, -9.03403014e-02f,
  -5.36991619e-02f, -3.34882945e-01f, 1.52697816e-01f, 5.38688265e-02f, -6.76228106e-02f, 2.99231142e-01f, 3.98359537e-01f, 5.98501116e-02f, 5.52032366e-02f, 9.36376378e-02f,
  -1.03647739e-01f, 2.62165427e-01f, 1.03853039e-01f, 1.05660707e-01f, -2.13996600e-02f, -2.22907975e-01f, 1.26677528e-01f, -7.88202584e-02f, -8.86606500e-02f, -3.01487267e-01f,
  2.77761191e-01f, -5.25052845e-02f, -2.15703711e-01f, 1.75773636e-01f, -4.48826998e-01f, -3.61760646e-01f, 1.59873366e-01f, 1.19287238e-01f, 2.05612689e-01f, -1.38876319e-01f,
  -1.50729613e-02f, -2.40050070e-02f, 1.69196099e-01f, -1.12970382e-01f, -1.12458713e-01f, -8.11944753e-02f, -1.88910753e-01f, -3.28274310e-01f, 9.21490565e-02f, -3.08976322e-01f,
  -3.99906747e-02f, -2.41742492e-01f, -5.60188629e-02f, -1.78165510e-02f, 6.61498383e-02f, -1.70311883e-01f, -3.81412320e-02f, 3.76072228e-02f, -3.75587672e-01f, 9.55325812e-02f,
  2.43749872e-01f, 1.94392249e-01f, 6.86064269e-03f, -1.74227625e-01f, 2.40415428e-02f, -8.97126794e-02f, -7.09611699e-02f, -1.14212088e-01f, 3.44370157e-01f, 1.93025798e-01f,
  -2.87829578e-01f, 9.64301750e-02f, -1.13298438e-01f, -1.64900810e-01f, 2.46371672e-01f, -4.27662820e-01f, -8.93821195e-02f, -3.13045084e-01f, -1.89534828e-01f, -1.86962008e-01f,
  -1.97667331e-01f, -1.02866068e-01f, -2.35952497e-01f, -3.88381094e-01f, 3.37432772e-02f, -1.71528220e-01f, -1.00166462e-01f, 2.48743761e-02f, -1.16140470e-01f, 3.63597274e-02f,
  1.36872441e-01f, 2.49020994e-01f, -1.29578888e-01f, -2.28036478e-01f, -1.38205379e-01f, 2.31123134e-01f, 1.32177666e-01f, 2.15125382e-01f, -2.04215035e-01f, 1.33459680e-02f,
  -2.61503369e-01f, -3.61079335e-01f, 5.19691184e-02f, -7.95830637e-02f, -2.00904608e-01f, 1.26986295e-01f, 1.05692774e-01f, 2.51645327e-01f, 1.26921341e-01f, 3.89674306e-01f,
  -7.96928927e-02f, 3.08056753e-02f, -1.78905010e-01f, -4.51785773e-02f, 3.78692639e-03f, -2.35872462e-01f, 1.20089673e-01f, -1.09198570e-01f, -7.26359561e-02f, 1.28309652e-01f,
  -1.82032391e-01f, -1.27540797e-01f, 8.65830779e-02f, -2.09278855e-02f, -1.88584164e-01f, -8.33410025e-02f, -2.30438471e-01f, 6.96750544e-03f, -2.51381695e-01f, -7.76452273e-02f,
  1.23498216e-02f, -5.08838035e-02f, -7.48773962e-02f, 1.67376563e-01f, -2.09012628e-01f, -9.96090919e-02f, -4.02774364e-01f, 1.04991920e-01f, -9.33476835e-02f, -1.40776709e-01f,
  4.91504744e-02f, 2.12758377e-01f, 1.01572841e-01f, 2.69159138e-01f, 1.03894688e-01f, -6.98783100e-02f, 1.65133432e-01f, -2.61116564e-01f, 9.01391134e-02f, -8.77218023e-02f,
  -1.24190211e-01f, -4.50749174e-02f, -1.38775349e-01f, 5.45842424e-02f, 2.36435086e-01f, -2.72442639e-01f, -1.78295240e-01f, -1.55113339e-01f, -1.74522728e-01f, 2.01224256e-02f,
  -2.90944800e-03f, -9.61204469e-02f, -1.82961598e-01f, 2.86521852e-01f, 2.56108940e-01f, -1.33768141e-01f, 1.80409491e-01f, -1.81625485e-01f, -2.48430654e-01f, 1.34578392e-01f,
  1.80995643e-01f, -1.57880485e-01f, -2.42479488e-01f, -4.01376300e-02f, -7.34768203e-03f, 2.89772063e-01f, -2.47020066e-01f, 6.28354475e-02f, -2.21468866e-01f, -1.29468590e-01f,
  -6.48197457e-02f, -2.93555856e-02f, 1.84229389e-02f, 2.90420954e-03f, 1.06460415e-01f, -6.76848888e-02f, -3.77935261e-01f, 2.18544886e-01f, -6.77650869e-02f, -4.59804349e-02f,
  -2.72692919e-01f, 2.91734308e-01f, -2.91351303e-02f, 3.50649297e-01f, -7.00592771e-02f, -2.96980232e-01f, 7.50103816e-02f, -7.61040449e-02f, -3.68601561e-01f, 1.60280168e-02f,
  7.45112672e-02f, -3.19930285e-01f, 3.84990841e-01f, 4.07964848e-02f, -5.46955884e-01f, -4.29599583e-01f, 1.36731833e-01f, 1.26268178e-01f, 6.57071292e-01f, 4.43975031e-02f,
  4.45736311e-02f, 5.64958751e-02f, -2.86425412e-01f, 5.09573556e-02f, -3.90839487e-01f, 1.39303252e-01f, -6.69626892e-03f, 1.27626941e-01f, 1.64740235e-01f, 4.78419997e-02f,
  -8.18958913e-04f, 1.96730252e-02f, -8.06238130e-02f, -5.21103382e-01f, -2.20844835e-01f, -1.41068831e-01f, -8.26404095e-02f, 2.04098895e-01f, -5.65659963e-02f, 1.05285667e-01f,
  1.40768841e-01f, 3.67946029e-02f, -2.21119806e-01f, 3.99438441e-02f, 3.68851721e-02f, -2.04561174e-01f, 4.59762998e-02f, -2.89489441e-02f, 9.52418223e-02f, -1.37423780e-02f,
  -7.22901374e-02f, 8.58956128e-02f, 1.52002439e-01f, 6.27778023e-02f, 1.25475094e-01f, -2.01525733e-01f, -4.44892123e-02f, -8.01794827e-02f, 3.17016095e-02f, -6.04345538e-02f,
  -7.08083510e-02f, -8.27810448e-03f, 8.48153606e-02f, 4.31835726e-02f, -2.80021224e-02f, -1.34276852e-01f, -1.81461409e-01f, 6.09454326e-02f, 1.14547081e-01f, -6.94941059e-02f,
  1.13610812e-01f, -1.58341333e-01f, -5.24213761e-02f, -2.23327558e-02f, -7.73904175e-02f, 1.67372778e-01f, -7.19528645e-03f, 2.80858219e-01f, -3.72489132e-02f, -1.13116652e-01f,
  -8.63389373e-02f, -5.10378182e-02f, -2.78426483e-02f, 2.73769572e-02f, 1.89284757e-02f, 1.09804571e-01f, 7.45138973e-02f, 1.52935013e-01f, 2.81335741e-01f, 1.60111666e-01f,
  3.51744473e-01f, -3.61556485e-02f, 1.92181364e-01f, -5.20994663e-01f, 1.36682438e-02f, -3.04517169e-02f, -3.58624995e-01f, 3.78812730e-01f, -1.26925260e-02f, -5.85716590e-03f,
  3.18689235e-02f, -1.43977538e-01f, 2.37801671e-01f, -2.22020134e-01f, 1.94837525e-01f, 8.73903483e-02f, -7.36342967e-02f, -2.49288186e-01f, -1.42737985e-01f, -1.14646830e-01f,
  -1.66573599e-01f, 3.55021179e-01f, -1.82601437e-01f, -8.67713019e-02f, 2.78011262e-01f, 1.12307798e-02f, -1.05314881e-01f, -8.86716768e-02f, -3.26832503e-01f, -2.30319321e-01f,
  2.32894793e-01f, -2.43929192e-01f, -2.95331627e-01f, 1.91958532e-01f, -2.08604723e-01f, 9.57326964e-02f, 1.29723087e-01f, 3.06698561e-01f, -3.05247039e-01f, -2.04579130e-01f,
  9.19332504e-02f, 2.02702999e-01f, 5.04080877e-02f, -4.01059300e-01f, 2.52890661e-02f, 1.03277922e-01f, -2.43667543e-01f, -7.92533159e-02f, 1.60367012e-01f, -1.26882643e-01f,
  -1.27183557e-01f, -3.26449191e-03f, 4.78558093e-01f, 1.82254180e-01f, 2.78492682e-02f, 2.41537943e-01f, -1.10919431e-01f, 2.43124127e-01f, 2.51766086e-01f, -4.10558045e-01f,
  2.70259771e-02f, -1.87799543e-01f, -1.45768732e-01f, -1.77016541e-01f, -4.15687025e-01f, -6.31029978e-02f, -1.09554440e-01f, 1.87288612e-01f, 9.27589536e-02f, 1.29444778e-01f,
  -1.85410783e-01f, -1.57940522e-01f, 1.67574465e-01f, -2.30281219e-01f, -1.30902693e-01f, -1.69102028e-01f, -3.08949053e-01f, 1.24498904e-01f, -2.61022627e-01f, 4.12804671e-02f,
  1.74458668e-01f, -5.42312227e-02f, -1.28143162e-01f, 1.58512935e-01f, -3.12287509e-02f, -8.85255868e-04f, 5.66640720e-02f, -1.09976031e-01f, 1.04886830e-01f, -7.65632465e-02f,
  -1.18169233e-01f, -1.36969447e-01f, 1.25508770e-01f, 1.50737748e-01f, -4.99282070e-02f, -8.66745040e-02f, -4.32359464e-02f, -6.64161379e-03f, 1.56753853e-01f, 3.51087078e-02f,
  -1.07617686e-02f, 4.62091379e-02f, 7.67709836e-02f, -3.04993391e-02f, 1.34817839e-01f, -1.83038130e-01f, 1.34338932e-02f, -1.77253485e-01f, 2.14426324e-01f, -3.13661918e-02f,
  -2.46432260e-01f, -1.21424146e-01f, -2.61203319e-01f, -1.99082419e-02f, -2.87064258e-03f, -2.77433336e-01f, 1.14527894e-02f, -2.63823360e-01f, -3.60194057e-01f, -7.46577606e-02f,
  7.74053335e-02f, -3.33165713e-02f, -1.55227274e-01f, 7.57410601e-02f, -1.46602482e-01f, 3.57802808e-01f, 2.72166044e-01f, 1.33502170e-01f, -1.51268780e-01f, -1.93937540e-01f,
  -1.65796056e-02f, -1.48984328e-01f, -2.54421264e-01f, 9.96516347e-02f, 4.74482588e-02f, -1.34862453e-01f, 2.96298321e-02f, 1.72430187e-01f, 2.34822109e-01f, -2.98579484e-01f,
  2.69424796e-01f, 3.01550627e-01f, -1.76742285e-01f, -2.41286859e-01f, -9.98378471e-02f, 1.68295264e-01f, -7.74162114e-02f, 1.96102798e-01f, -7.60127753e-02f, -3.08224373e-02f,
  5.66944070e-02f, 2.89952066e-02f, -1.42055422e-01f, 3.03655803e-01f, -1.89465478e-01f, 2.64662892e-01f, 1.62794977e-01f, -1.95394859e-01f, 8.62642154e-02f, 1.65239856e-01f,
  6.12193830e-02f, 9.84513387e-02f, 2.29921833e-01f, 7.80953746e-03f, 7.22317919e-02f, 2.56914943e-01f, -1.10664010e-01f, -1.09253712e-01f, 5.97690083e-02f, -6.39152825e-02f,
  -3.23506296e-01f, 5.14407121e-02f, -4.57634836e-01f, 1.02359951e-01f, 7.40745440e-02f, 5.44470474e-02f, -2.77475506e-01f, 3.34925830e-01f, -2.74356365e-01f, 4.50623184e-01f,
  3.07737142e-01f, -3.26414168e-01f, -3.98671597e-01f, -1.28521070e-01f, -2.02341124e-01f, -3.66030127e-01f, -1.33790359e-01f, -4.41061467e-01f, 2.96883881e-01f, -2.09910378e-01f,
  -2.79882520e-01f, -3.82478356e-01f, 2.96558231e-01f, -5.01546204e-01f, -3.45054753e-02f, -4.59388584e-01f, -1.13079384e-01f, -1.36178806e-01f, -3.49930048e-01f, -8.84812772e-02f,
  2.42834061e-01f, -8.58267844e-02f, 2.84019381e-01f, -7.38809779e-02f, 3.01457852e-01f, 4.93373632e-01f, 7.31901005e-02f, 1.26657322e-01f, 1.89642668e-01f, 1.12408973e-01f,
  2.54605431e-02f, -2.07346961e-01f, -1.32428095e-01f, -2.94047594e-01f, -5.86670302e-02f, 1.34871259e-01f, 9.59085822e-02f, 2.65702456e-02f, 2.20825762e-01f, 1.24474624e-02f,
  -1.33197069e-01f, -7.72830546e-02f, -1.22992536e-02f, 5.10181710e-02f, 1.60518169e-01f, 1.36470586e-01f, 1.69871282e-02f, -3.40825804e-02f, 3.75621505e-02f, 2.39676192e-01f,
  1.75502643e-01f, -6.65683523e-02f, 2.40634575e-01f, 2.39209741e-01f, 1.30120024e-01f, -7.44415820e-02f, 9.41089727e-03f, -4.27824594e-02f, 1.64500639e-01f, 1.26095250e-01f,
  8.50861371e-02f, 6.15220424e-03f, 3.42488647e-01f, 6.26915544e-02f, -1.72736868e-02f, 5.09867594e-02f, 1.66793287e-01f, -4.05465672e-03f, -2.22129196e-01f, 1.31905153e-01f,
  5.47004975e-02f, 3.36516947e-02f, 2.13429127e-02f, -2.58159459e-01f, -4.91021127e-01f, 2.68036574e-01f, -1.50770292e-01f, -1.35082453e-01f, 6.67595193e-02f, -3.26455124e-02f,
  3.72326493e-01f, 1.10929050e-01f, 5.80040272e-03f, -1.23696417e-01f, -1.43400043e-01f, 1.21530361e-01f, 3.71992558e-01f, 2.39163963e-03f, -3.44903916e-01f, 8.98240786e-03f,
  -1.12021543e-01f, 3.30024362e-01f, -5.82507253e-02f, 7.40719289e-02f, -1.66344255e-01f, 2.42745727e-01f, 3.35234255e-02f, -5.49631901e-02f, -4.13852073e-02f, -2.13528976e-01f,
  -2.11596563e-01f, -2.09992573e-01f, -2.34403666e-02f, -1.76776528e-01f, 2.30633602e-01f, -1.73449084e-01f, 1.80627599e-01f, -1.51245654e-01f, 1.30738601e-01f, 2.76239246e-01f,
  4.64729995e-01f, -4.39157635e-01f, 1.00919172e-01f, 2.98585687e-02f, -1.89911783e-01f, 3.42803717e-01f, 1.26884118e-01f, -1.45908222e-01f, 5.95512576e-02f, 3.62172842e-01f,
  1.13715783e-01f, 2.84146160e-01f, 3.55647236e-01f, 7.46531785e-02f, -1.05323277e-01f, -1.14816926e-01f, -5.11308610e-01f, -1.88865736e-01f, -4.88656223e-01f, 2.83070892e-01f,
  4.08513285e-02f, -1.44948348e-01f, -1.62602380e-01f, -5.46052098e-01f, -3.22451978e-03f, 9.78777558e-02f, 1.37875274e-01f, 2.73699045e-01f, 2.72906750e-01f, -6.24523312e-02f,
  -4.32379320e-02f, 2.06007913e-01f, -9.87723395e-02f, -6.21483475e-03f, -4.84905252e-03f, -2.89214611e-01f, -1.51356101e-01f, 1.38532698e-01f, 2.59050041e-01f, -2.56245404e-01f,
  5.47556318e-02f, 2.90683173e-02f, 1.73191816e-01f, 5.90399615e-02f, 1.35786850e-02f, 1.31540135e-01f, 2.30292320e-01f, -3.78635488e-02f, 4.73352857e-02f, 2.63571134e-03f,
  -6.53430214e-03f, 1.28081471e-01f, 1.09988481e-01f, 1.18203275e-01f, 1.19289070e-01f, 1.87707674e-02f, -2.05251187e-01f, 1.19838253e-01f, -7.00949356e-02f, 1.25343218e-01f,
  7.07146898e-02f, -8.36142339e-03f, -2.13945538e-01f, 1.49942450e-02f, 4.71151173e-02f, -3.31306487e-01f, 1.78646639e-01f, 2.03696638e-01f, -4.16532606e-02f, 7.40348101e-02f,
  -1.03418984e-01f, 2.64757890e-02f, 1.48769334e-01f, 2.15602651e-01f, -1.69939548e-01f, -4.21955794e-01f, 3.04338872e-01f, 8.27392712e-02f, 3.06770623e-01f, 1.73389956e-01f,
  1.00670725e-01f, 2.70007104e-01f, -1.87258590e-02f, 1.58929184e-01f, 9.36874449e-02f, -2.99325973e-01f, -1.78925600e-02f, 1.45736244e-03f, -4.51567322e-02f, 2.00414836e-01f,
  -5.13730198e-02f, -1.85599893e-01f, -1.07024871e-01f, -7.62253553e-02f, -1.70584857e-01f, 2.19048440e-01f, 2.06415042e-01f, 3.35537255e-01f, -1.55367687e-01f, 2.09198415e-01f,
  1.61962137e-01f, 2.01200657e-02f, 4.09644008e-01f, -3.06005031e-01f, -1.21838532e-01f, 1.74779952e-01f, -4.41261008e-02f, 1.86170176e-01f, 1.04273241e-02f, -6.18153065e-02f,
  4.00233626e-01f, 1.12581760e-01f, 2.68144757e-01f, 1.67735294e-01f, 5.61710708e-02f, -8.43256190e-02f, 2.43032038e-01f, 1.12973541e-01f, -1.99782461e-01f, -1.23324238e-01f,
  -6.06052801e-02f, -2.08614185e-01f, 7.99888894e-02f, -1.40098184e-01f, 1.43071786e-01f, -1.66114703e-01f, 1.69528618e-01f, 1.90161943e-01f, -1.40583172e-01f, -1.95577547e-01f,
  -2.52837300e-01f, -1.55269295e-01f, 1.69922650e-01f, -1.04723521e-01f, -1.46991700e-01f, -2.00868547e-01f, -2.56137550e-01f, -2.44345948e-01f, 4.60055061e-02f, -9.19053704e-02f,
  1.54132947e-01f, 1.64758742e-01f, 4.82942164e-02f, 2.85106391e-01f, 2.56326258e-01f, -1.60835490e-01f, -5.17094970e-01f, -9.13994834e-02f, 1.15418643e-01f, 1.23139746e-01f,
  -8.25375557e-01f, -1.20601051e-01f, -2.01332375e-01f, 2.28724286e-01f, -1.52010202e-01f, -2.79471636e-01f, -1.10923816e-02f, 2.99554437e-01f, -9.82159600e-02f, -3.38285416e-02f,
  -7.50396624e-02f, 5.62959947e-02f, 1.57781675e-01f, 2.41848156e-01f, -8.75217170e-02f, 2.32706323e-01f, -2.75607556e-01f, -5.84698804e-02f, 2.03673802e-02f, 1.04376599e-02f,
  -2.04816580e-01f, -1.65927529e-01f, -1.54783502e-01f, 4.32139635e-02f, 1.59085780e-01f, -2.38128798e-03f, 1.17719367e-01f, 2.45904941e-02f, 1.18691951e-01f, -1.46286786e-01f,
  -8.71366635e-02f, -1.89330671e-02f, 2.14317605e-01f, -9.70786065e-02f, -1.29119575e-01f, 2.23574758e-01f, -4.75822091e-02f, 1.84448436e-02f, 5.62111922e-02f, -4.65946607e-02f,
  9.27853510e-02f, 1.80833206e-01f, 1.01426005e-01f, -1.19935803e-01f, 1.61801562e-01f, -5.47996387e-02f, 2.01078042e-01f, 2.01242417e-01f, 2.93929636e-01f, 2.87868798e-01f,
  -2.01835304e-01f, 8.00142437e-02f, -6.73123747e-02f, 1.60324469e-01f, -1.06111661e-01f, -6.15577661e-02f, 4.56312224e-02f, -3.94668281e-01f, -6.52707517e-02f, -2.36853510e-01f,
  1.06960319e-01f, 1.78903729e-01f, 4.88603897e-02f, -1.01038963e-01f, 8.66164491e-02f, 2.16149881e-01f, -4.85435426e-02f, -9.94934589e-02f, -2.81135648e-01f, 1.63416952e-01f,
  4.42108691e-01f, -1.72763541e-01f, -1.17503926e-01f, 2.96293497e-01f, 2.46345565e-01f, 3.83377761e-01f, 3.04014236e-01f, -1.13751344e-01f, -2.94563651e-01f, 1.48796707e-01f,
  -4.53374892e-01f, 2.33858883e-01f, -6.08139895e-02f, -1.18612505e-01f, -1.88325882e-01f, -4.30876017e-01f, -1.94242790e-01f, 2.60079622e-01f, -1.63804337e-01f, -2.71713972e-01f,
  -4.85306904e-02f, -2.29289383e-01f, -4.88400646e-02f, 2.81776637e-01f, 1.20071985e-01f, 8.20309371e-02f, 5.71583658e-02f, 1.44498900e-01f, 2.34115332e-01f, 2.32647166e-01f,
  9.91432071e-02f, 1.90451875e-01f, -2.92945534e-01f, 3.59587073e-01f, -2.13483557e-01f, -1.05696730e-01f, -9.44948494e-02f, 2.65291721e-01f, -9.04402882e-02f, -1.35316312e-01f,
  1.86411217e-01f, 1.02328435e-01f, 1.03410520e-01f, 1.40209034e-01f, 8.27309024e-03f, -2.70764660e-02f, -4.10694666e-02f, -1.09819166e-01f, 1.32112801e-01f, -2.00738490e-01f,
  -2.85061821e-02f, -2.29034483e-01f, -3.21125746e-01f, 3.85134518e-02f, -1.92735448e-01f, 2.45692000e-01f, 2.28145704e-01f, 2.30059281e-01f, -3.12413871e-01f, 1.92739442e-01f,
  1.02802999e-01f, -1.58600155e-02f, -5.08687854e-01f, 2.46934935e-01f, 1.79685131e-01f, 1.08267337e-01f, -6.04672134e-01f, -3.57304811e-02f, -4.80967045e-01f, -5.88454679e-02f,
  -9.20160711e-02f, 4.30064321e-01f, -1.60674855e-01f, -1.80894271e-01f, -5.35368979e-01f, -3.61675680e-01f, -2.21810877e-01f, -5.22327758e-02f, 3.41243222e-02f, -6.25362620e-02f,
  -1.74843431e-01f, -2.99102783e-01f, -5.45232594e-02f, -1.07386656e-01f, -1.51233628e-01f, -2.53090113e-01f, -1.01091459e-01f, -1.05681047e-01f, -8.09327513e-02f, -2.23381802e-01f,
  -2.85503808e-02f, -1.70535788e-01f, -1.07592478e-01f, -2.39173904e-01f, -2.62266304e-02f, -5.06866118e-03f, -1.25427738e-01f, 4.47640121e-02f, -6.73615187e-03f, -3.76443402e-03f,
  4.13009599e-02f, -5.97459041e-02f, 1.13018276e-02f, -1.50038406e-01f, -1.53127417e-01f, -1.39851436e-01f, -4.29679528e-02f, 3.76606397e-02f, -1.30346984e-01f, 3.19747925e-02f,
  -4.51017469e-02f, -4.77118306e-02f, -1.31786633e-02f, -6.31483048e-02f, -1.94119483e-01f, -1.41957492e-01f, -1.38238207e-01f, 1.28697351e-01f, -2.94949561e-01f, -2.36703634e-01f,
  -7.03420490e-02f, -6.49361908e-02f, -1.13306016e-01f, -1.68547735e-01f, 5.58056831e-02f, -1.84347302e-01f, -5.36277927e-02f, -2.08321773e-02f, -6.35099411e-02f, 6.02846928e-02f,
  4.19021882e-02f, -2.79880702e-01f, -8.59900042e-02f, -2.11502910e-02f, 1.56828444e-02f, -1.42908916e-01f, -4.74846885e-02f, 1.59452915e-01f, -1.85141578e-01f, -2.68313944e-01f,
  8.04289356e-02f, -1.94272488e-01f, 2.06246853e-01f, 1.86373785e-01f, 1.97449513e-02f, 8.82264748e-02f, 2.28871465e-01f, -2.61016726e-01f, 1.02144375e-01f, 4.87372726e-02f,
  1.85995642e-02f, 1.56187013e-01f, -6.71673939e-02f, -1.42598838e-01f, -9.21699330e-02f, 2.13373303e-02f, 2.09586114e-01f, 2.14892030e-01f, -1.78312793e-01f, 2.43787393e-01f,
  -4.42696735e-02f, 2.08980501e-01f, 1.60217866e-01f, -1.62103668e-01f, 1.23869859e-01f, -1.80750787e-01f, -1.14948243e-01f, -1.53579235e-01f, 8.95540789e-02f, -8.95318314e-02f,
  2.75486964e-03f, -9.27681923e-02f, 4.07481313e-01f, 9.46699381e-02f, 5.58229610e-02f, 7.33768195e-02f, 9.07344148e-02f, -4.55070566e-03f, -3.70910674e-01f, 2.48154253e-01f,
  -4.06747073e-01f, 1.95492625e-01f, 1.91110983e-01f, -9.75674763e-02f, 4.17253077e-02f, -3.20440292e-01f, -1.59893796e-01f, -9.88327935e-02f, 9.57792178e-02f, 7.89907053e-02f,
  3.67785767e-02f, -2.63937265e-01f, -3.00745703e-02f, -1.61205739e-01f, 4.82129753e-02f, 1.65591031e-01f, 1.07856609e-01f, -2.40013883e-01f, -1.68696895e-01f, -1.60882488e-01f,
  3.74887139e-01f, 2.12044626e-01f, -3.94018918e-01f, 2.43946612e-01f, -9.89270955e-02f, -2.06789821e-01f, 1.89232714e-02f, 1.51781499e-01f, 9.85681862e-02f, -4.01487976e-01f,
  3.04782651e-02f, -3.37231785e-01f, -1.65456310e-01f, 6.72461167e-02f, 5.57681434e-02f, -5.62586039e-02f, -1.01732433e-01f, -1.08541949e-02f, -1.94395527e-01f, 9.22264308e-02f,
  2.80920476e-01f, 1.35556117e-01f, -2.14601383e-01f, 6.26876056e-02f, -2.93302890e-02f, -1.66209623e-01f, 8.80198181e-02f, -6.40434474e-02f, -6.12151250e-02f, 2.25351721e-01f,
  -6.06609099e-02f, 1.18822575e-01f, 1.23516329e-01f, 1.98092014e-02f, 9.47925225e-02f, -1.51938125e-01f, -2.17348725e-01f, 7.34337717e-02f, 1.91253096e-01f, 2.36710091e-03f,
  1.42201766e-01f, 8.80342945e-02f, -4.31884918e-03f, 9.07325651e-03f, 5.91907278e-02f, 1.10892028e-01f, -9.33922753e-02f, -1.68399006e-01f, -1.16512857e-01f, 5.67577640e-03f,
  -2.98322767e-01f, -1.39972448e-01f, -3.51793557e-01f, -3.83084677e-02f, 3.22562233e-02f, 2.30903015e-01f, 1.20243458e-02f, -2.42475897e-01f, 1.24956697e-01f, 2.04559118e-01f,
  -4.91209984e-01f, 1.83507994e-01f, 3.30219083e-02f, 1.04343452e-01f, -7.46066030e-03f, 3.65280151e-01f, -1.14582919e-01f, 3.19696069e-01f, -2.22021520e-01f, -7.11010769e-02f,
  -9.97669697e-02f, 2.38237083e-01f, 2.01296091e-01f, -1.61312029e-01f, 3.08553159e-01f, 2.07937192e-02f, 1.68381155e-01f, -3.35355908e-01f, 3.06337029e-01f, -2.09945589e-01f,
  -2.39757061e-01f, 1.06798008e-01f, 8.64709616e-02f, 1.19128814e-02f, 2.22433865e-01f, 2.22599775e-01f, 1.00294091e-01f, 3.46846253e-01f, 1.48140892e-01f, 2.28114903e-01f,
  -9.24152732e-02f, -2.65073359e-01f, 2.21291482e-01f, 2.74548918e-01f, -8.00595060e-02f, -2.37773314e-01f, 2.37773463e-01f, 1.20545655e-01f, -3.53238016e-01f, -3.79260570e-01f,
  -1.28362626e-01f, 1.49938453e-03f, -2.38815233e-01f, -7.28605837e-02f, 5.11494540e-02f, -2.03133628e-01f, 2.46416286e-01f, 6.82354495e-02f, -2.66060203e-01f, 1.33736487e-02f,
  6.29359633e-02f, -2.93885022e-02f, 2.53885388e-02f, 2.18132541e-01f, 2.00984374e-01f, 1.21647652e-04f, 1.78314999e-01f, -5.42083494e-02f, -1.00634210e-01f, -2.26891160e-01f,
  -2.57116348e-01f, -2.54582256e-01f, 1.98485583e-01f, -2.19945520e-01f, 6.58394694e-02f, -4.34455462e-02f, 1.68954983e-01f, -4.01625037e-01f, -3.97961289e-01f, -4.55317050e-01f,
  -2.62684643e-01f, 3.00472707e-01f, 1.21977024e-01f, 1.98977605e-01f, 2.50761837e-01f, 1.14464216e-01f, 4.83051501e-02f, 1.76836386e-01f, 4.24201265e-02f, 1.06883138e-01f,
  -6.67240918e-02f, -7.53115192e-02f, -1.26501322e-01f, -7.79627077e-03f, 7.63612706e-03f, -2.38822609e-01f, -5.57022691e-02f, -4.84636091e-02f, 3.15866530e-01f, -1.83553591e-01f,
  -2.31639922e-01f, 9.38187316e-02f, -1.70646563e-01f, -2.94209290e-02f, 2.36498281e-01f, -3.01473439e-02f, 5.82993627e-02f, -2.99910039e-01f, -1.77408736e-02f, -1.03461064e-01f,
  -1.00614153e-01f, 7.33769238e-02f, -1.35261994e-02f, -2.11737588e-01f, -6.95466995e-02f, -1.97821110e-01f, 9.32330862e-02f, -1.39774000e-02f, 1.98189393e-01f, 9.87190828e-02f,
  1.01453997e-01f, -2.31760629e-02f, 8.86761770e-02f, 1.76890165e-01f, 1.08819507e-01f, -2.47360095e-01f, -4.92586121e-02f, -9.54998881e-02f, -2.32408583e-01f, 6.89600408e-03f,
  -2.35297501e-01f, 6.33525774e-02f, 2.98084944e-01f, 1.93841830e-02f, 3.86398703e-01f, -6.21129759e-02f, 2.11730421e-01f, -4.27741677e-01f, -2.76938379e-01f, -3.81319374e-01f,
  -6.83443947e-03f, 9.17446241e-02f, 3.75371575e-01f, -2.67006248e-01f, 3.54709238e-01f, -1.41991794e-01f, 9.03634652e-02f, 1.48886546e-01f, -2.82554060e-01f, 4.25173491e-02f,
  -1.66969374e-01f, 2.84253448e-01f, -1.35382667e-01f, -2.16948196e-01f, -2.21748978e-01f, -9.67410281e-02f, -4.11279500e-02f, -3.47071350e-01f, 1.44695997e-01f, 2.84882784e-01f,
  1.13590106e-01f, 4.32285853e-02f, -1.42931625e-01f, -1.09946109e-01f, -2.96784788e-01f, 2.52051950e-01f, -4.73295778e-01f, 4.12325859e-02f, 2.43909806e-01f, -3.24889362e-01f,
  -8.46371949e-02f, 2.41535455e-01f, -2.27442428e-01f, -2.57183015e-01f, 3.28936219e-01f, -2.77170599e-01f, -1.05719864e-01f, 2.94505119e-01f, -7.91999996e-02f, 3.89125109e-01f,
  1.65993944e-02f, -1.13664277e-01f, 2.67812908e-01f, 1.93126146e-02f, -4.88406718e-01f, -3.24964195e-01f, 2.58888245e-01f, -8.60018004e-03f, 2.02976435e-01f, 1.21995427e-01f,
  1.07381167e-02f, -2.02619091e-01f, -3.23106605e-03f, 2.44097620e-01f, -2.42727622e-01f, 5.59743717e-02f, -1.36212990e-01f, 5.21755703e-02f, 1.74104244e-01f, -1.55261951e-02f,
  -4.45411980e-01f, 9.54108499e-03f, -9.99815315e-02f, -1.77860498e-01f, -1.97347984e-01f, -8.63305777e-02f, 2.61651367e-01f, 2.23406821e-01f, -1.35105982e-01f, -3.35644245e-01f,
  1.16299577e-01f, 2.74326295e-01f, -6.73998296e-02f, 2.20298190e-02f, 5.08806370e-02f, 8.99371058e-02f, 9.29366201e-02f, -3.58800441e-02f, -1.29591733e-01f, -8.88916850e-03f,
  5.80715351e-02f, -6.04220442e-02f, 2.40108836e-02f, -4.67215329e-02f, -1.44988447e-01f, 1.28546627e-02f, -1.58785179e-01f, 8.79085585e-02f, 6.30549937e-02f, -6.34301081e-02f,
  6.06976859e-02f, 8.47861245e-02f, 4.63937074e-02f, 1.63308635e-01f, -1.84493005e-01f, 2.27919802e-01f, -5.41255027e-02f, 1.84080333e-01f, 1.50935546e-01f, 1.36237904e-01f,
  2.78113112e-02f, 5.81663996e-02f, 1.00443147e-01f, 5.30866049e-02f, 1.32063851e-01f, -1.18376926e-01f, 2.16834638e-02f, -1.07000619e-01f, 2.19554648e-01f, 3.58395912e-02f,
  1.98255882e-01f, -2.85881292e-02f, -1.86291724e-01f, 2.30790615e-01f, 5.40399887e-02f, 3.16495933e-02f, 1.40656546e-01f, 1.77787259e-01f, 5.95066929e-03f, 8.56761858e-02f,
  -3.38179655e-02f, -2.59423107e-01f, -1.04983263e-01f, 4.44070399e-01f, -1.74162865e-01f, -2.01642126e-01f, -2.63368577e-01f, 2.78543890e-01f, -6.52797073e-02f, 9.16591957e-02f,
  -2.60203689e-01f, -2.66051054e-01f, -3.54460061e-01f, -4.55468923e-01f, 3.14515352e-01f, 1.98245212e-01f, -2.58098245e-01f, -4.47653094e-03f, 1.04265648e-03f, 9.12172161e-03f,
  -1.28391907e-01f, 1.86177924e-01f, -2.94914067e-01f, 2.09518552e-01f, 2.91380763e-01f, -8.89490917e-02f, 4.11502644e-02f, 3.33006680e-01f, 1.90430731e-01f, 1.12639144e-01f,
  1.43763706e-01f, -1.42754212e-01f, 4.14883345e-02f, -2.39955112e-02f, -5.01674235e-01f, -9.84293595e-02f, 6.39182255e-02f, 2.02191606e-01f, 2.72355616e-01f, 2.64763068e-02f,
  1.92555562e-01f, 5.38724326e-02f, -2.43096977e-01f, 3.02061498e-01f, 2.25636605e-02f, -4.93698493e-02f, 4.21311289e-01f, -5.41639142e-02f, 2.63294816e-01f, -2.62603432e-01f,
  -2.11282670e-01f, 8.09539184e-02f, -7.22719058e-02f, -2.59097368e-01f, -2.79901266e-01f, -3.62853467e-01f, 4.23834443e-01f, -2.28786632e-01f, -4.52574641e-01f, -2.27600813e-01f,
  2.81845927e-01f, 8.86296704e-02f, -3.95171553e-01f, -5.39597571e-01f, -1.00004300e-02f, -2.94029206e-01f, -3.59386981e-01f, -1.52768776e-01f, 1.56021222e-01f, -1.48545668e-01f,
  1.74014181e-01f, -4.01862472e-01f, 2.74482161e-01f, -1.26668602e-01f, 3.66762012e-01f, -1.76872775e-01f, -2.91684847e-02f, 3.17201227e-01f, 1.86090454e-01f, 5.53984269e-02f,
  -1.41207352e-01f, -1.46851808e-01f, -1.40856937e-01f, 1.78854227e-01f, -1.54664546e-01f, 2.51358628e-01f, -1.01137005e-01f, 9.87478718e-02f, 6.30875304e-02f, 4.18970101e-02f,
  6.28807843e-02f, 1.08253345e-01f, 1.23138264e-01f, 8.08493271e-02f, -2.52658755e-01f, -7.51325339e-02f, 1.49414867e-01f, 1.33985817e-01f, -8.02682042e-02f, 8.99409689e-03f,
  -2.10018814e-01f, 1.31979868e-01f, -1.18197963e-01f, 1.80250496e-01f, -5.96224628e-02f, -7.17165472e-04f, -2.08117560e-01f, 1.59171283e-01f, -6.05233721e-02f, -7.15895221e-02f,
  2.03895107e-01f, -7.42961913e-02f, 5.56638017e-02f, 1.75465479e-01f, -6.00091182e-02f, -4.93074879e-02f, 1.02492668e-01f, 1.63532376e-01f, -1.98327109e-01f, -2.03630384e-02f,
  -1.29467577e-01f, -1.93717498e-02f, 9.73132849e-02f, 1.39231101e-01f, 4.09406424e-02f, -2.99575269e-01f, 3.33405048e-01f, 4.40214872e-02f, 1.60368711e-01f, -1.91736698e-01f,
  -2.32543051e-01f, -1.48601353e-01f, 5.83598576e-02f, 3.34650695e-01f, 6.28781924e-03f, 2.05462471e-01f, 2.54114568e-02f, 7.08058476e-02f, 3.82281572e-01f, -2.24326074e-01f,
  2.11793482e-01f, 1.94477469e-01f, 4.41476516e-02f, 1.24246560e-01f, 1.33611023e-01f, -3.01528960e-01f, -9.75996107e-02f, -2.38221854e-01f, -1.12851515e-01f, 2.93970704e-01f,
  -2.59794921e-01f, -2.07836047e-01f, 2.71522850e-01f, 2.26037711e-01f, 4.58705239e-02f, -4.61581916e-01f, 1.59083173e-01f, 1.75540611e-01f, -1.01464041e-01f, 2.54362673e-01f,
  2.01225594e-01f, 1.08099477e-02f, 9.48423296e-02f, -2.44267032e-01f, -2.85832793e-01f, -2.34896705e-01f, 1.66451469e-01f, -3.47028911e-01f, 1.80312544e-01f, -1.07380196e-01f,
  2.47040644e-01f, -3.51980180e-01f, 1.80982903e-01f, 1.34780603e-02f, 5.47997877e-02f, 1.88271493e-01f, -1.84387743e-01f, 1.45491496e-01f, 1.85710847e-01f, -2.13944316e-01f,
  1.80522189e-01f, 2.30165571e-01f, -1.77761570e-01f, -1.55243566e-02f, 1.03154019e-01f, 1.97005644e-01f, -5.50058931e-02f, 9.74934623e-02f, -4.84220646e-02f, -4.34925139e-01f,
  1.82166416e-02f, 8.06561112e-02f, 2.26498961e-01f, 3.20249230e-01f, 2.06874982e-01f, -2.48865515e-01f, 2.69641906e-01f, -4.28815901e-01f, -3.73643398e-01f, -2.57929921e-01f,
  -2.57088304e-01f, -1.33979008e-01f, -7.59131014e-02f, -3.54983717e-01f, -3.18806916e-01f, -3.34165156e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.81304584e-02f, 6.39974326e-02f, -2.25427467e-02f, -6.19798414e-02f, -2.41217520e-02f, -3.56288105e-02f, -9.60794091e-02f, 6.45877123e-02f, -1.37033716e-01f, 3.84012684e-02f,
  5.45234680e-02f, 2.12492198e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    