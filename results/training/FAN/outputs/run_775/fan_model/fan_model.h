/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.04069650e-01f, 2.24856555e-01f, 8.39718699e-01f, -2.05588147e-01f, 1.76638573e-01f, 1.83504611e-01f, 3.44081700e-01f, -5.06877853e-03f, -2.09213600e-01f, 2.12908611e-01f,
  -1.00000456e-01f, -4.46784377e-01f, -2.92758584e-01f, -1.93598360e-01f, -5.47778942e-02f, 3.53320837e-01f, 4.50106680e-01f, 6.99481443e-02f, -2.39133328e-01f, -2.58091658e-01f,
  -9.56992805e-02f, -6.90313727e-02f, -1.32366121e-01f, -7.69935641e-03f, 2.60900743e-02f, -1.50813699e-01f, 3.44485372e-01f, 1.16160966e-01f, 2.96305548e-02f, 1.92761287e-01f,
  3.93381640e-02f, 3.43858786e-02f, -8.34441856e-02f, -1.55716509e-01f, 7.05568045e-02f, -6.00528792e-02f, -5.36667071e-02f, -5.54239377e-02f, -9.22105759e-02f, 5.14706671e-02f,
  -3.78680555e-03f, -6.57801516e-03f, 1.99486688e-02f, -8.09820741e-03f, -1.56192267e-02f, 5.03969975e-02f, 4.58559766e-02f, 7.69193992e-02f, 3.58852930e-02f, 4.47711051e-02f,
  -9.88897588e-03f, 2.65458524e-02f, 1.27294466e-01f, 6.65726811e-02f, 6.13869466e-02f, -1.16142802e-01f, 1.21635348e-01f, -9.50179473e-02f, 1.11764818e-01f, -2.68235691e-02f,
  -3.19873393e-02f, -1.95051283e-02f, -3.45675461e-02f, 2.11412609e-02f, -5.92465624e-02f, 1.34296725e-02f, 1.62848011e-02f, 1.00030527e-02f, -3.11022568e-02f, 1.49234701e-02f,
  3.91004048e-03f, 6.95168152e-02f, 1.05831195e-02f, 3.66383456e-02f, -8.78848694e-03f, 9.99580175e-02f, -1.32450499e-02f, -1.20224087e-02f, -2.04712078e-02f, 1.84279270e-02f,
  -1.84245817e-02f, -1.28502748e-03f, 5.10055050e-02f, 7.70671107e-03f, -2.27355212e-02f, 6.69746250e-02f, -6.95843101e-02f, 2.88477987e-02f, -2.37514302e-02f, 5.28041879e-03f,
  -1.97369546e-01f, 4.81245071e-02f, -6.07615933e-02f, -2.55335905e-02f, 5.51927052e-02f, 2.74794232e-02f, -2.44684294e-02f, 2.57741865e-02f, 1.62982084e-02f, 1.62488017e-02f,
  -4.72564995e-02f, -1.21999241e-01f, 9.70879644e-02f, 5.36174253e-02f, -2.15558279e-02f, -2.36063320e-02f, -1.53683918e-03f, -1.15592822e-01f, -3.46268378e-02f, 5.47079407e-02f,
  3.90303209e-02f, -1.95447449e-02f, -1.87025756e-01f, -5.93331978e-02f, -7.87846446e-02f, -6.44547343e-02f, 2.77056787e-02f, -1.07267099e-02f, -4.86668721e-02f, -3.09595633e-02f,
  -4.25171703e-02f, 4.70268488e-01f, 4.43398282e-02f, 1.21511454e-02f, 4.05186713e-02f, 2.58295178e-01f, 6.72544599e-01f, 2.23756015e-01f, -1.42248556e-01f, 3.13470840e-01f,
  -1.40468061e-01f, -4.04662460e-01f, -3.28090966e-01f, -2.03655690e-01f, 3.04643828e-02f, 5.23447633e-01f, 3.86912137e-01f, -9.57316086e-02f, -2.14739278e-01f, -1.67315692e-01f,
  -7.85011798e-02f, 5.77869862e-02f, -1.57380208e-01f, 4.43095565e-02f, 1.04464531e-01f, -9.89736319e-02f, 3.04479420e-01f, -4.31733951e-02f, 1.04289658e-01f, 2.15830117e-01f,
  -6.66846260e-02f, 6.68364987e-02f, -8.39522704e-02f, -1.20690517e-01f, -1.53267190e-01f, 4.44666296e-02f, 5.17361984e-02f, 5.88400178e-02f, -8.73077437e-02f, 4.34098244e-02f,
  -1.32538512e-01f, -9.57342312e-02f, -5.82778119e-02f, -9.91045497e-03f, 9.81960967e-02f, 1.65740494e-02f, 4.36343513e-02f, 1.67027470e-02f, 5.64127287e-04f, 6.23812675e-02f,
  -1.33020580e-01f, -1.47064775e-01f, 1.28900344e-02f, -2.30481531e-02f, -5.73667400e-02f, -2.15523273e-01f, -3.55975479e-02f, -9.81494188e-02f, 6.81111291e-02f, 2.64424175e-01f,
  -1.01338355e-02f, -2.53849458e-02f, -1.33255254e-02f, -2.43022386e-02f, 4.03065830e-02f, -3.11465710e-02f, 4.45945747e-02f, 1.52475946e-02f, -3.58731039e-02f, 8.02763924e-03f,
  -1.36722066e-02f, 5.04312590e-02f, -3.59513126e-02f, 6.59547448e-02f, -4.64042984e-02f, 1.96955539e-02f, 1.63261872e-02f, 7.13156313e-02f, -6.02777414e-02f, 7.60010555e-02f,
  -7.61386678e-02f, -5.73108234e-02f, -2.52727773e-02f, 5.36455493e-03f, 1.67293735e-02f, 4.17127758e-02f, 1.17524387e-03f, -5.19240685e-02f, -3.51986140e-02f, 1.95580125e-02f,
  1.06069408e-01f, -1.50222883e-01f, 5.65247796e-02f, -5.98753616e-02f, 9.10510123e-03f, -2.33056638e-02f, 2.32593622e-03f, -3.90451811e-02f, -2.27219872e-02f, 8.02477971e-02f,
  3.94950900e-03f, 4.06523161e-02f, 8.73293579e-02f, -2.68822722e-02f, -1.09718796e-02f, 2.21521333e-02f, 3.37902158e-02f, -1.47951217e-02f, 1.99196357e-02f, 2.44546328e-02f,
  6.96185678e-02f, 2.06168860e-01f, 6.40056282e-02f, 1.20159313e-01f, -1.42180910e-02f, 3.37763131e-02f, 1.67241380e-01f, 8.83948058e-02f, 4.80509289e-02f, 5.17677963e-01f,
  5.04575789e-01f, 2.09819585e-01f, -2.89767236e-01f, 2.47488320e-01f, 7.93971960e-03f, -3.10981721e-01f, -3.85460705e-01f, -9.35264081e-02f, 3.06799322e-01f, 6.60861135e-02f,
  -1.41982147e-02f, 1.43228844e-01f, 1.40651586e-02f, -9.73953754e-02f, -3.36219102e-01f, -2.04209313e-01f, -2.64239848e-01f, -2.25213617e-01f, -4.21438456e-01f, -1.17001206e-01f,
  1.13412201e-01f, -3.45324725e-02f, 9.30791646e-02f, -4.07981686e-02f, 2.27421582e-01f, 2.02286616e-02f, 1.10419253e-02f, 5.52613027e-02f, -2.00611241e-02f, 3.52927864e-01f,
  -1.88163749e-03f, 2.70296842e-01f, -2.41648704e-01f, 9.46956035e-03f, 9.93878953e-03f, 5.68230525e-02f, -1.26162311e-02f, 5.00683971e-02f, 5.24805952e-03f, 1.81145594e-02f,
  -8.95567331e-03f, 5.96114248e-02f, 3.01638097e-02f, 7.27585256e-02f, 2.02175435e-02f, -1.61508541e-03f, -3.31671275e-02f, -1.18672028e-02f, -3.56410034e-02f, 5.59233222e-03f,
  8.42583627e-02f, 6.38047904e-02f, -1.41408980e-01f, -7.15605691e-02f, -3.10781375e-02f, 1.27736665e-02f, 6.28840225e-03f, 1.18533611e-01f, -5.46107292e-02f, 1.58667877e-01f,
  -5.23950085e-02f, 1.20463525e-03f, 2.44688410e-02f, 2.33251844e-02f, 4.96315816e-03f, 1.93087108e-04f, 3.82439867e-02f, -5.84857054e-02f, 3.63966934e-02f, -6.51150048e-02f,
  -3.00335269e-02f, 6.17499575e-02f, 1.86463092e-02f, -9.32301208e-03f, -2.74541788e-03f, 5.00376970e-02f, 5.07188700e-02f, -2.25552674e-02f, -3.81978080e-02f, 7.41254538e-02f,
  3.65802497e-02f, -6.14453591e-02f, 1.17529966e-02f, 3.68359126e-02f, 3.46006118e-02f, 1.92867946e-02f, -3.10620591e-02f, 9.30214152e-02f, -1.04754614e-02f, 6.14373013e-02f,
  6.16645142e-02f, -2.18669757e-01f, 2.01276630e-01f, -3.50723192e-02f, 2.23044422e-04f, -1.97281572e-03f, 7.69882500e-02f, 1.53901754e-03f, 1.05007604e-01f, -1.11490590e-02f,
  -7.66449347e-02f, -4.24375758e-02f, -9.16870870e-03f, -1.56665791e-03f, -5.40645644e-02f, -1.01934582e-01f, -5.39943837e-02f, 1.16785581e-03f, -4.26523164e-02f, 8.89784191e-03f,
  -4.06175405e-02f, -1.27517477e-01f, -1.42365903e-01f, -1.10395469e-01f, 3.38767990e-02f, -9.15149897e-02f, -1.46233022e-01f, -9.57066864e-02f, -3.33918333e-01f, -2.05780506e-01f,
  4.01869744e-01f, 2.76218772e-01f, 2.20632672e-01f, 4.54028904e-01f, 4.00531918e-01f, 1.66056871e-01f, 1.89417809e-01f, -1.42675877e-01f, 1.22306985e-03f, 3.20794463e-01f,
  2.12538496e-01f, -5.14602941e-03f, 1.89730637e-02f, -3.15606773e-01f, -3.28324258e-01f, 9.54690427e-02f, 1.12422690e-01f, -2.21865252e-01f, -3.93271834e-01f, -9.14540887e-02f,
  -2.15018019e-02f, 8.64026099e-02f, -9.76572037e-02f, -1.08345591e-01f, 2.48479903e-01f, -2.52397321e-02f, 1.17736086e-01f, 5.03457151e-02f, -4.53467295e-02f, 2.83134669e-01f,
  2.91523695e-01f, 1.63414463e-01f, -1.72663838e-01f, 5.13459630e-02f, 9.51990262e-02f, -1.43734515e-01f, -1.91257671e-02f, -2.23412272e-02f, 1.27207255e-02f, 3.18885781e-02f,
  1.74661651e-01f, 1.22503964e-02f, 7.03120604e-02f, -7.32719153e-02f, 1.89941153e-02f, -3.89369093e-02f, -1.11467332e-01f, -1.03959069e-01f, -8.13023187e-03f, 5.85045330e-02f,
  1.11965261e-01f, 1.91609547e-01f, 1.36787489e-01f, -1.07150272e-01f, -7.20456243e-02f, -5.32520143e-03f, -9.19886492e-03f, -7.16295168e-02f, -6.95539266e-02f, 2.64569204e-02f,
  -1.24121513e-02f, 1.00696377e-01f, 8.30361061e-03f, -1.36215594e-02f, -3.16939615e-02f, 3.27159055e-02f, 4.41394709e-02f, 6.07309863e-03f, -4.53662910e-02f, 3.77874561e-02f,
  -4.36057821e-02f, 1.51472427e-02f, -4.37812172e-02f, 2.16755131e-03f, 1.62831936e-02f, 5.74965999e-02f, -3.49146016e-02f, 1.90827455e-02f, -1.92620568e-02f, -6.05248697e-02f,
  3.71063799e-02f, -7.04027489e-02f, 8.00112784e-02f, -3.85220237e-02f, 4.86156112e-03f, 1.08697778e-02f, -1.07937939e-02f, -6.49928525e-02f, 4.25304752e-03f, 9.82069448e-02f,
  -1.20429792e-01f, -1.93918362e-01f, 1.26319721e-01f, -1.07307442e-01f, 1.11058585e-01f, -2.03794688e-02f, 1.02934182e-01f, 4.17823764e-03f, 4.99039367e-02f, 1.08595528e-02f,
  -6.65764287e-02f, -2.03212723e-02f, 1.38586182e-02f, -7.06244856e-02f, 2.65595298e-02f, -4.60724495e-02f, 6.51426390e-02f, 8.68032426e-02f, -7.43768066e-02f, -1.03158560e-02f,
  -4.69095185e-02f, -4.54893075e-02f, -4.58468720e-02f, 2.86361836e-02f, -8.57735574e-02f, 4.31510769e-02f, 1.60611011e-02f, 6.78096572e-03f, -1.56127378e-01f, 2.13036761e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.11817071e-02f, 1.69732854e-01f, -5.95210083e-02f, 2.69423127e-01f, 3.84498149e-01f, 2.87558019e-01f, 3.59329462e-01f, 3.21960300e-01f, 2.40948021e-01f, 1.72417715e-01f,
  3.52151036e-01f, 3.55548143e-01f, 3.78818512e-01f, 2.60818779e-01f, 2.33368397e-01f, 2.52029300e-01f, 6.59246743e-02f, 4.17912826e-02f, 5.33591881e-02f, 1.09522559e-01f,
  2.41365999e-01f, -2.04547103e-02f, -6.09891415e-02f, 7.39975274e-02f, 1.85615048e-01f, 2.07551003e-01f, 9.38635319e-02f, 6.29481003e-02f, 9.46838036e-02f, 1.19828820e-01f,
  -9.19306651e-02f, -1.74265597e-02f, 1.27463371e-01f, 9.95053872e-02f, 2.76007690e-02f, -1.69995576e-01f, 5.73779680e-02f, -2.51650482e-01f, -1.45108595e-01f, -8.16535726e-02f,
  -4.06400710e-02f, -1.21186011e-01f, 7.90712088e-02f, 1.86747983e-02f, -7.37871975e-02f, -7.78432935e-02f, -4.86880876e-02f, -6.21822737e-02f, 6.43508451e-04f, 4.04271111e-02f,
  9.40487683e-02f, -5.94527908e-02f, -7.88387731e-02f, 1.58939641e-02f, 1.67792812e-01f, 4.43651117e-02f, 4.41740379e-02f, 7.08113313e-02f, 4.85945344e-02f, -1.03618987e-02f,
  1.07789688e-01f, -2.83094030e-02f, 4.49331999e-02f, 3.90989222e-02f, 4.08925936e-02f, 2.48005223e-02f, 2.18609404e-02f, -5.60206734e-02f, 5.24184220e-02f, -5.81440479e-02f,
  3.05189155e-02f, 2.49693487e-02f, -3.59599441e-02f, 1.46929519e-02f, 4.72839102e-02f, -2.15762258e-02f, -9.04406533e-02f, -1.12601779e-02f, -2.06409488e-02f, -5.91453575e-02f,
  3.72168645e-02f, 7.49710191e-04f, -7.62669817e-02f, -5.08261770e-02f, -3.76768149e-02f, 4.05419767e-02f, -2.44126413e-02f, -6.22519515e-02f, 4.91814725e-02f, -9.08514708e-02f,
  -5.81677295e-02f, 9.25193429e-02f, 2.82795746e-02f, -1.05407098e-02f, -5.28682843e-02f, -1.39217481e-01f, 3.33695039e-02f, -8.77964050e-02f, -5.70017695e-02f, -8.20796117e-02f,
  -9.48882028e-02f, -5.58145791e-02f, 1.24758529e-02f, -1.15330584e-01f, -1.75821781e-01f, -1.37311593e-01f, -5.58963455e-02f, 4.72131148e-02f, -5.16278632e-02f, -1.56584740e-01f,
  -1.33906171e-01f, -2.24650204e-01f, -1.04476914e-01f, -9.66640096e-03f, -1.33385491e-02f, 4.71021384e-02f, -1.33974209e-01f, -1.72262207e-01f, -1.13530964e-01f, -9.44191441e-02f,
  9.44474697e-01f, 5.15955746e-01f, 5.22812843e-01f, 1.31863356e-01f, -8.30826834e-02f, -1.37455076e-01f, -1.45129204e-01f, -2.33039454e-01f, -1.69736817e-01f, 1.44639472e-02f,
  2.51850188e-01f, -3.39927375e-02f, -1.00936495e-01f, -6.16929643e-02f, 7.35274865e-04f, -1.38121217e-01f, -1.33972242e-01f, 2.84567922e-01f, 1.53164998e-01f, 8.69110152e-02f,
  -1.29692987e-01f, 2.10158944e-01f, 4.82751161e-01f, 1.38383448e-01f, 5.03309965e-02f, -1.52982026e-01f, 1.28851905e-01f, 3.29235107e-01f, 2.93573439e-01f, 1.96187571e-01f,
  3.43100578e-01f, 7.03976810e-01f, -4.73623931e-01f, -9.27002952e-02f, 1.61693439e-01f, 9.28763822e-02f, -1.29520183e-03f, 1.11576438e-01f, -7.04528987e-02f, -1.05191022e-01f,
  7.54355863e-02f, -1.15176546e-03f, -2.43735760e-02f, -9.17548239e-02f, -4.51693609e-02f, -7.41116852e-02f, -1.11207541e-03f, 5.06787188e-02f, -1.19735114e-01f, -2.85040475e-02f,
  -1.42656669e-01f, 2.52918541e-01f, 1.10453285e-01f, -1.63345426e-01f, -6.83770841e-03f, -3.89189869e-02f, 5.97065277e-02f, -2.89862938e-02f, -4.71442640e-02f, 1.51130045e-02f,
  -9.76009071e-02f, -4.12338562e-02f, 1.05595939e-01f, 1.08463746e-02f, 4.96840179e-02f, -6.84943125e-02f, -1.12768076e-01f, -5.77653721e-02f, 1.18175941e-02f, -2.78695021e-02f,
  -1.37572084e-02f, -4.58474550e-03f, 1.91921853e-02f, -7.39751756e-02f, -6.21360354e-02f, 3.64792459e-02f, 1.02666309e-02f, -3.47528458e-02f, -8.34950432e-03f, 1.79861654e-02f,
  1.44073665e-02f, 1.16206938e-02f, 3.23202834e-02f, -8.28955173e-02f, -1.14907371e-02f, 8.80526677e-02f, -4.68855090e-02f, -6.33844361e-02f, 2.28494662e-03f, 1.64581668e-02f,
  -2.81245917e-01f, 2.96727177e-02f, -2.35666618e-01f, 1.42742191e-02f, 1.29373834e-01f, 1.09257489e-01f, 6.67586476e-02f, 2.13887691e-02f, 1.37756944e-01f, -3.97077063e-03f,
  1.75559372e-01f, 1.30844355e-01f, 4.32270579e-02f, -3.59241180e-02f, -1.02877699e-01f, -7.94682652e-02f, 1.62973572e-02f, 4.25917506e-02f, -1.39302745e-01f, 9.57095101e-02f,
  -1.75059766e-01f, -2.19345972e-01f, -1.41213298e-01f, -3.19914579e-01f, -1.24085419e-01f, -2.04428449e-01f, -1.82194680e-01f, -1.16527177e-01f, -1.12849310e-01f, -2.72309572e-01f,
  -2.41420731e-01f, -1.44615799e-01f, -1.14404656e-01f, 1.59725398e-01f, -3.68853938e-03f, -3.42761993e-01f, -3.81062478e-01f, -3.39581251e-01f, 2.55834013e-02f, -5.53553067e-02f,
  -2.40265995e-01f, 1.35078609e-01f, 1.29723117e-01f, 6.42247275e-02f, -1.44472852e-01f, 7.79665709e-02f, 4.11796302e-01f, 2.79300809e-01f, 5.64563312e-02f, 5.48231788e-02f,
  3.68994325e-01f, 2.89383262e-01f, 1.73309237e-01f, 2.30141178e-01f, 2.15947136e-01f, 3.10853064e-01f, 1.82612002e-01f, 1.80040613e-01f, 5.43377139e-02f, 5.53634346e-01f,
  -2.66163319e-01f, -4.10675466e-01f, 6.59629479e-02f, 5.83500378e-02f, 3.58119495e-02f, -8.63573253e-02f, -4.92634997e-02f, -1.07161477e-01f, -4.97225970e-02f, -1.99503414e-02f,
  9.01330858e-02f, 1.82991959e-02f, 9.62104928e-03f, -4.71596047e-02f, -8.83965567e-02f, -2.09141761e-01f, 5.76805323e-02f, -1.11131761e-02f, -1.29408553e-01f, -6.20857552e-02f,
  1.20679170e-01f, 2.10686754e-02f, -3.35169494e-01f, -3.02974105e-01f, -1.42248914e-01f, 5.63381575e-02f, -1.65297180e-01f, -2.23638251e-01f, -2.66985476e-01f, -2.00789139e-01f,
  -6.14093766e-02f, -3.17899324e-02f, -3.42398346e-03f, -3.09990067e-02f, 7.40200430e-02f, 4.14582752e-02f, 9.21429843e-02f, 4.23974618e-02f, 6.79092631e-02f, 6.10491671e-02f,
  -8.29129741e-02f, -3.19218077e-02f, 1.45898135e-02f, -6.51182905e-02f, -8.17996729e-03f, -1.77742950e-05f, 8.03950429e-02f, -2.44079274e-03f, 1.37821771e-02f, -8.62197205e-03f,
  -6.28941879e-02f, -4.57853451e-02f, 2.01448165e-02f, 2.71400660e-02f, 5.40498011e-02f, 3.09974570e-02f, 4.85862382e-02f, -1.27687737e-01f, -3.81540321e-02f, -1.36774080e-02f,
  -7.87122473e-02f, -2.31171638e-01f, -6.05390705e-02f, 4.54719402e-02f, -7.41972821e-03f, -3.43341716e-02f, -6.55203592e-04f, 1.89868379e-02f, -1.10604942e-01f, -1.34966001e-01f,
  -1.45883143e-01f, -6.25401661e-02f, -1.29974216e-01f, 6.03150297e-03f, -7.57320002e-02f, -7.16923103e-02f, -3.97069007e-02f, 6.48446754e-02f, -2.60579046e-02f, -1.30038887e-01f,
  6.82937503e-02f, -1.05801500e-01f, -2.40193382e-01f, -2.84482986e-01f, -2.51752287e-01f, -7.02099130e-02f, -2.15268716e-01f, -2.67720580e-01f, -3.56914073e-01f, -3.26823801e-01f,
  3.72629255e-01f, 1.36027932e-01f, -7.51059592e-01f, 3.04772675e-01f, -5.22745550e-02f, -3.21724176e-01f, -1.66537791e-01f, 2.40043372e-01f, 3.25828999e-01f, 1.17065825e-01f,
  -6.07099757e-02f, -1.59468323e-01f, -3.02586049e-01f, -3.55925620e-01f, -3.45690489e-01f, -3.09367955e-01f, -3.64781916e-01f, -6.74192786e-01f, -5.72901130e-01f, -2.43072286e-01f,
  -3.39324139e-02f, -1.62221678e-02f, -7.88652971e-02f, -1.23756053e-02f, 1.76460952e-01f, -1.27769243e-02f, -1.02602780e-01f, -1.46799684e-01f, -2.57670194e-01f, -1.74950331e-01f,
  -6.04396760e-01f, 3.03239431e-02f, -2.28318021e-01f, 4.00540344e-02f, -1.19601741e-01f, -5.31628020e-02f, -1.26206856e-02f, -3.90958972e-02f, 2.18716152e-02f, -3.54623906e-02f,
  -8.15498531e-02f, -7.49667883e-02f, -3.56808258e-03f, -1.44810334e-01f, -4.97362725e-02f, -6.55159131e-02f, 6.71569407e-02f, -1.85281098e-01f, -1.25586450e-01f, -6.60626590e-02f,
  -1.00914948e-01f, -2.46373802e-01f, -2.08075374e-01f, 2.37461366e-02f, -9.95156989e-02f, -2.94737726e-01f, -3.90011929e-02f, -3.48027796e-02f, -1.16359286e-01f, 3.84226888e-01f,
  -5.54197840e-02f, -3.83036919e-02f, -1.08335257e-01f, 1.58107027e-01f, -5.51298074e-03f, 3.40066254e-02f, -3.73921208e-02f, 3.18216197e-02f, -1.23579670e-02f, 8.53312910e-02f,
  -1.43691935e-02f, -1.33763105e-02f, 5.52083887e-02f, 4.44411673e-02f, -3.24405953e-02f, -1.85423698e-02f, -2.16502510e-02f, 1.75935421e-02f, -3.46874306e-03f, -4.08078320e-02f,
  -8.27372894e-02f, -2.40152180e-02f, 1.70251541e-02f, 6.53044134e-02f, -1.20773323e-01f, -2.13958360e-02f, -1.65477265e-02f, 9.79389879e-04f, 6.63650632e-02f, -3.54574621e-02f,
  4.07485008e-01f, -3.89791697e-01f, -4.80052605e-02f, 1.75137427e-02f, -1.21177072e-02f, 2.23490559e-02f, 3.12253274e-02f, 5.12196310e-02f, -2.86907759e-02f, -5.50953625e-03f,
  -3.12578827e-02f, -1.89244864e-03f, 4.28616554e-02f, 4.73877974e-02f, -2.91985851e-02f, -1.11337081e-02f, 1.19264640e-01f, -1.86729088e-01f, -1.23280622e-01f, 1.01576783e-01f,
  2.29285553e-01f, 4.75537777e-03f, -4.32573482e-02f, -4.21281233e-02f, -2.50385255e-02f, -2.08659798e-01f, -1.18458100e-01f, -1.36227319e-02f, -1.88120469e-01f, 3.47534984e-01f,
  -5.72471976e-01f, 1.58193976e-01f, 8.94407853e-02f, -3.95622402e-01f, 1.91539302e-01f, 4.10575837e-01f, 5.15127122e-01f, 1.96464732e-01f, -1.69935733e-01f, 5.52032404e-02f,
  1.11316815e-01f, -1.57255217e-01f, -2.24142626e-01f, -1.74585775e-01f, -7.14340955e-02f, -6.22045714e-03f, -2.04594165e-01f, -3.48604500e-01f, -2.53038794e-01f, 1.23335347e-01f,
  -1.70467436e-01f, -3.62078100e-01f, -4.57891166e-01f, -3.70617777e-01f, -2.00542927e-01f, -2.75782049e-01f, -3.26843321e-01f, -2.05815300e-01f, 1.39294952e-01f, -3.87545109e-01f,
  1.20139442e-01f, 2.97552496e-01f, -2.47419961e-02f, -1.83812425e-01f, -9.53662992e-02f, -1.10402152e-01f, -8.11690651e-03f, -1.16377048e-01f, -6.72285706e-02f, -9.99382436e-02f,
  -1.47828106e-02f, -5.58615252e-02f, -1.18753716e-01f, -1.49108777e-02f, -5.73686995e-02f, -1.83599275e-02f, -7.51736015e-02f, -2.49562040e-01f, -1.24960672e-02f, 2.57895708e-01f,
  8.67985711e-02f, 1.35987237e-01f, 3.65820192e-02f, 1.37512818e-01f, 1.22293778e-01f, -1.48990631e-01f, 8.80457908e-02f, -4.33702022e-02f, 7.60950660e-03f, -3.54648203e-01f,
  -7.44724795e-02f, 4.84634377e-02f, 4.73134127e-03f, 5.06312177e-02f, -5.12703555e-04f, -2.52878945e-02f, 2.32452881e-02f, -2.48884074e-02f, 9.65268919e-05f, -1.23241059e-01f,
  1.41444607e-02f, 9.16060060e-02f, -9.84042808e-02f, -7.24367723e-02f, -6.61487207e-02f, 3.36814746e-02f, 2.73351725e-02f, 9.18940734e-03f, 6.33296669e-02f, -7.26793855e-02f,
  -5.85991852e-02f, 4.83195670e-02f, -8.42108801e-02f, -5.99207394e-02f, 1.25454396e-01f, -1.88015532e-02f, 3.02244332e-02f, 7.28718862e-02f, 4.39496525e-02f, 7.87096247e-02f,
  -4.33553934e-01f, 1.37675151e-01f, -2.59604752e-01f, -1.54537454e-01f, -7.23312646e-02f, -4.53805067e-02f, 2.36439779e-02f, -7.46525899e-02f, -5.55349030e-02f, 1.99327730e-02f,
  1.70228139e-01f, -8.70742202e-02f, -8.16282853e-02f, 6.83194399e-02f, -1.32707329e-02f, 1.41537022e-02f, -1.17075920e-01f, -2.08530098e-01f, -4.33047116e-02f, 5.36632277e-02f,
  -9.82058793e-02f, -1.92154929e-01f, -2.42590651e-01f, -1.15979634e-01f, -6.64668083e-02f, -2.78411746e-01f, -4.18712236e-02f, -9.46445391e-02f, -1.21515773e-01f, -4.31565493e-01f,
  1.18971765e+00f, -3.56904447e-01f, 3.18781994e-02f, 3.56277049e-01f, 2.55654193e-02f, 1.53699175e-01f, 8.88584703e-02f, 2.47725416e-02f, 2.14805380e-01f, -4.87934761e-02f,
  -2.09859341e-01f, -6.45957515e-03f, 1.67801101e-02f, -8.03018063e-02f, 2.41009630e-02f, -3.42536755e-02f, -7.14551285e-02f, 1.30003050e-01f, 3.16023082e-01f, 1.46228226e-03f,
  -9.78871882e-02f, -1.60332918e-02f, 2.22540691e-01f, -7.14498237e-02f, -2.49471307e-01f, -1.03973426e-01f, -2.78670996e-01f, -2.35457063e-01f, -2.74587810e-01f, -3.83360356e-01f,
  -1.99505135e-01f, 1.33734224e-02f, 1.21753514e-01f, -7.50360712e-02f, -1.83490351e-01f, -1.08798081e-02f, 1.26214132e-01f, -8.37943926e-02f, 1.09720957e-02f, -1.21085141e-02f,
  -4.13804278e-02f, -3.09600681e-02f, -6.03620186e-02f, -1.13835946e-01f, -2.04467736e-02f, 5.35271876e-02f, -6.10386394e-02f, -3.13666128e-02f, -1.66045934e-01f, -2.76886195e-01f,
  -3.92127961e-01f, -6.45234482e-03f, 1.11423746e-01f, -1.06962971e-01f, -1.43142343e-01f, 1.37974381e-01f, -1.45979911e-01f, -1.20993920e-01f, -7.97547176e-02f, -3.11312787e-02f,
  -1.01455383e-01f, 5.77701107e-02f, 2.50859186e-02f, 7.84629434e-02f, 9.49217305e-02f, 2.25991346e-02f, 4.39337790e-02f, 4.06692214e-02f, 3.82246003e-02f, -7.76038039e-03f,
  1.20567216e-04f, 2.71677580e-02f, 5.02712978e-03f, 7.21482560e-02f, -5.13250008e-02f, -1.98003221e-02f, 2.35456899e-02f, -3.59240919e-02f, 2.88601574e-02f, 3.32636833e-02f,
  1.03974611e-01f, 4.51043807e-02f, -4.34070230e-02f, -8.48656297e-02f, -7.86849931e-02f, 3.65644693e-02f, 3.62370759e-02f, -3.23533379e-02f, -8.17541853e-02f, 9.61220786e-02f,
  2.94726957e-02f, 1.28390253e-01f, 1.57855660e-01f, 2.65295189e-02f, -1.70472451e-02f, -8.70477036e-02f, -5.90381771e-02f, -4.64114025e-02f, -1.61739722e-01f, -2.72667613e-02f,
  -1.00819223e-01f, 9.77892056e-03f, -5.30815870e-02f, -8.37891027e-02f, 2.04687148e-01f, 6.61478788e-02f, -8.88757408e-02f, 7.90379643e-02f, -9.75680575e-02f, -5.47573119e-02f,
  -1.34825617e-01f, 3.24803680e-01f, 4.86413121e-01f, 2.20757782e-01f, 3.19645717e-03f, 4.37343717e-01f, 5.93175143e-02f, 9.10214260e-02f, 3.79415572e-01f, 3.41311336e-01f,
  2.64821261e-01f, 3.54995668e-01f, 1.25880212e-01f, -3.24106999e-02f, -3.25192511e-01f, -9.09748971e-02f, 1.71744630e-01f, 1.95418745e-01f, 1.17975384e-01f, 3.27926688e-02f,
  -3.26116592e-01f, -3.18515420e-01f, 3.75279179e-03f, 5.58343902e-02f, 3.05321723e-01f, 3.79551411e-01f, 3.69406670e-01f, 2.56239355e-01f, 1.31704375e-01f, -2.36188862e-02f,
  -3.66118588e-02f, 4.80985828e-02f, 1.14755377e-01f, 1.31291956e-01f, 1.68516725e-01f, -1.20113850e-01f, 9.27892104e-02f, 5.24563380e-02f, 1.64502431e-02f, 3.50344479e-01f,
  -1.88709516e-02f, 2.09968358e-01f, -5.69082834e-02f, -2.04588339e-01f, -2.40265191e-01f, 6.08621910e-02f, -5.20326546e-04f, 4.16244417e-02f, -1.13526568e-01f, 1.03649430e-01f,
  -1.67282417e-01f, -1.18192276e-02f, -1.97029137e-03f, -9.45984274e-02f, -4.87637781e-02f, -9.07099433e-03f, 4.87200841e-02f, 2.14293420e-01f, 5.58961295e-02f, 3.24513242e-02f,
  -1.10948265e-01f, -2.51836061e-01f, -5.76105975e-02f, 4.60679121e-02f, 1.08595476e-01f, -1.32080421e-01f, -9.55340341e-02f, 7.86651298e-02f, 7.18592405e-02f, 1.22814208e-01f,
  -9.33249444e-02f, 5.66953905e-02f, -6.95659518e-02f, 7.62076825e-02f, -3.75387631e-02f, 2.93329060e-02f, 7.35120922e-02f, -7.97319561e-02f, 1.23676602e-02f, 6.35286793e-02f,
  -6.25177473e-03f, -4.02245345e-03f, 1.42584024e-02f, 5.05117998e-02f, -6.18543252e-02f, -3.06002200e-02f, 2.40824427e-02f, -8.12873896e-03f, -1.39244854e-01f, 2.17483435e-02f,
  -2.45769992e-02f, 3.12516838e-02f, -8.59115273e-02f, 7.77937248e-02f, 3.22063640e-02f, -3.73628438e-02f, -3.64623452e-03f, -8.62801000e-02f, -6.53697597e-03f, -4.01028953e-02f,
  -5.79005703e-02f, -3.95250112e-01f, 1.02963865e-01f, 2.39875540e-01f, -7.06797540e-02f, -1.17953809e-03f, -6.27522916e-02f, -2.33086683e-02f, -6.37642145e-02f, 1.00094326e-01f,
  -6.40780553e-02f, 5.18704914e-02f, -6.70615286e-02f, 9.32181105e-02f, -1.03232644e-01f, -5.37869856e-02f, -7.90034086e-02f, 6.33635297e-02f, 5.53334132e-02f, 8.25772434e-02f,
  -1.13355452e-02f, -6.28774539e-02f, 4.33761068e-02f, -3.38031650e-02f, 3.50331701e-02f, -1.74546987e-01f, -6.79156408e-02f, 3.81641723e-02f, -5.37331924e-02f, 6.89475834e-02f,
  -4.57309753e-01f, 2.28905886e-01f, 2.97196180e-01f, -7.98215996e-03f, -1.76973969e-01f, -3.37894827e-01f, -3.90729785e-01f, -3.73060971e-01f, -1.93297341e-01f, 1.32659748e-01f,
  7.75824487e-02f, 1.61462471e-01f, 2.68773079e-01f, 6.96963593e-02f, -1.94379166e-01f, -1.13055840e-01f, -1.51352480e-01f, -1.80514321e-01f, -2.23360628e-01f, -2.92951673e-01f,
  -1.92629695e-01f, -1.53802916e-01f, -2.50654966e-01f, -1.47478387e-01f, 1.72499135e-01f, 2.53427744e-01f, 2.76955396e-01f, 9.16355550e-02f, -1.17242821e-01f, 2.69741237e-01f,
  8.32980871e-01f, -9.33073759e-02f, -7.93668851e-02f, -1.12030290e-01f, 6.06133007e-02f, -1.47124082e-01f, 6.01324365e-02f, -1.15469219e-02f, -8.30518752e-02f, -1.24639273e-02f,
  9.11032632e-02f, -5.65146618e-02f, 8.73397663e-03f, 3.77852470e-03f, -4.12705727e-02f, -1.60338759e-01f, -1.54270634e-01f, -1.26691744e-01f, -5.46089411e-02f, -6.42232746e-02f,
  -7.21707121e-02f, -1.34939268e-01f, -2.88686622e-02f, -2.76660197e-03f, -1.42108247e-01f, -1.02682345e-01f, 2.12635044e-02f, -9.98965502e-02f, -7.15379938e-02f, 9.72550660e-02f,
  -4.94496785e-02f, 8.34228396e-02f, -1.44261420e-02f, -1.52521702e-02f, 4.94347177e-02f, 4.87431437e-02f, 2.12106705e-02f, 4.04379964e-02f, -2.60832589e-02f, 2.76156943e-02f,
  -2.02098638e-02f, 3.40186208e-02f, -8.01438279e-03f, 6.72056451e-02f, 4.38061729e-02f, -4.69386280e-02f, -5.14770895e-02f, -9.43470523e-02f, -8.64038058e-03f, -5.27552105e-02f,
  3.89782502e-03f, 3.20873447e-02f, 7.73593634e-02f, 1.50367664e-02f, -8.82302746e-02f, -2.76928432e-02f, -4.68227603e-02f, -6.49251393e-04f, -1.75470244e-02f, -5.72418720e-02f,
  5.45433998e-01f, -3.66772413e-01f, 1.19640015e-01f, -1.70359716e-01f, 9.02757496e-02f, -3.24581601e-02f, 1.29480883e-01f, -9.83021259e-02f, 5.40340953e-02f, -1.33692380e-02f,
  -4.82270792e-02f, -3.19984294e-02f, 1.85138613e-01f, 1.01825604e-02f, -7.44804144e-02f, -3.56386639e-02f, -1.03456818e-01f, 2.86695976e-02f, -1.50320336e-01f, 6.12975359e-02f,
  -3.82358395e-02f, -1.35027438e-01f, 1.24415129e-01f, 1.61871016e-01f, -5.30104972e-02f, 1.11007094e-02f, 3.18481982e-01f, 3.53656448e-02f, -2.71418914e-02f, 2.41485462e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -1.43890545e-01f, 7.34335482e-01f, 4.35750753e-01f, 4.85265702e-01f, 4.58382368e-01f, 9.25832510e-01f, 1.37013540e-01f, 4.67188925e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -9.72359776e-01f, -1.23498297e+00f, -2.08600715e-01f, -9.00546551e-01f, -7.64406502e-01f, 8.89331177e-02f, 3.15733701e-01f, -5.05288839e-01f, 2.30948478e-02f, -2.49395460e-01f,
  -1.15145572e-01f, 8.46050739e-01f, 5.56644559e-01f, -1.49989724e-01f, 6.25853762e-02f, -4.94846672e-01f, -1.16083956e+00f, 1.54063255e-01f, 4.26696897e-01f, -4.77780998e-01f,
  -7.17237830e-01f, -9.86648202e-01f, -2.33850658e-01f, -5.39604545e-01f, 7.37597704e-01f, 1.24571733e-01f, -4.53571588e-01f, -3.53080481e-02f, -3.52817059e-01f, 1.24058926e+00f,
  -8.81897360e-02f, -8.40700418e-02f, 5.86717427e-01f, -2.06583649e-01f, 1.18284619e+00f, -8.58269334e-02f, 1.93023071e-01f, -9.90665615e-01f, -2.55750179e-01f, -1.30770445e+00f,
  -6.20857477e-01f, 4.75683540e-01f, 8.07124257e-01f, -7.48529196e-01f, -4.44413036e-01f, -1.40412793e-01f, -3.72418016e-01f, -1.35064244e-01f, 5.16887426e-01f, 5.32344878e-01f,
  5.76582789e-01f, -8.02831873e-02f, 8.37947249e-01f, -1.12031646e-01f, -6.54558465e-02f, -6.53911591e-01f, -3.33861113e-01f, -3.99022102e-01f, -3.49065781e-01f, -3.56744796e-01f,
  1.31415331e+00f, -3.80428761e-01f, -1.01263754e-01f, -4.04679775e-01f, 8.12505543e-01f, -3.46336812e-01f, -8.69235516e-01f, 7.33426213e-01f, -5.41555397e-02f, -3.47116113e-01f,
  7.32898533e-01f, 1.03052288e-01f, 1.93283737e-01f, -1.06304355e-01f, -3.34398091e-01f, 6.86587512e-01f, 3.03702205e-01f, -6.03416860e-01f, 6.16310351e-03f, 5.97378135e-01f,
  -1.34451941e-01f, 6.92087054e-01f, 3.72688502e-01f, 4.78279412e-01f, -1.05288172e+00f, 9.24854219e-01f, 2.27368474e-01f, 7.71596283e-02f, 2.43723020e-01f, -1.56699628e-01f,
  -3.29064764e-02f, 1.13231587e+00f, -6.16310477e-01f, 4.84378606e-01f, 6.10613525e-02f, -9.39131826e-02f, -5.52165136e-02f, 5.10620117e-01f, -1.23983771e-01f, 5.19219518e-01f,
  4.00979102e-01f, 4.91401970e-01f, 7.20979393e-01f, 3.00406396e-01f, -6.57507002e-01f, 9.78217244e-01f, 1.70637697e-01f, -5.89704096e-01f, -6.49754286e-01f, -1.92246050e-01f,
  1.01974952e+00f, -3.88913602e-01f, -3.00322741e-01f, -3.14463824e-01f, 2.11947523e-02f, 1.47142321e-01f, 4.22127366e-01f, 5.51350176e-01f, -1.09390542e-01f, 1.37302712e-01f,
  5.34532309e-01f, -9.41610157e-01f, 8.71701121e-01f, -3.99085313e-01f, -1.63629249e-01f, -3.58776718e-01f, 3.99282813e-01f, -1.81248367e-01f, 5.62976897e-01f, -5.63087881e-01f,
  -2.61786848e-01f, 2.73201376e-01f, 4.32673246e-01f, 5.96283734e-01f, -8.98787022e-01f, 6.16369724e-01f, -1.32055879e-01f, -2.28133678e-01f, -5.72945783e-03f, -6.44703507e-01f,
  -4.35399771e-01f, 1.36794233e+00f, 2.17375562e-01f, -3.13394099e-01f, 3.17007780e-01f, -1.42628774e-01f, -6.19295895e-01f, -1.68938443e-01f, -3.95659804e-01f, -8.01817834e-01f,
  4.24762905e-01f, 1.03034544e+00f, -9.65321437e-02f, 6.52535975e-01f, 8.43124270e-01f, -7.00835139e-02f, -3.17438483e-01f, -5.43437541e-01f, -8.03287089e-01f, 3.48806053e-01f,
  3.02231997e-01f, 4.52186197e-01f, -4.81691867e-01f, 3.96212727e-01f, -2.85968274e-01f, 2.77841210e-01f, -8.49566400e-01f, -1.16072521e-01f, -3.62239391e-01f, -5.59598446e-01f,
  -2.71722555e-01f, -6.57512009e-01f, -8.72899294e-02f, 1.20123299e-02f, -1.19033400e-02f, 1.42872345e+00f, -7.86816299e-01f, -3.02059025e-01f, 4.82546985e-01f, -7.61861026e-01f,
  7.85649955e-01f, 5.25014579e-01f, -1.22917235e-01f, 6.49985135e-01f, -1.54079199e-01f, 1.25336218e+00f, -7.87100196e-01f, -2.75219709e-01f, 5.26524365e-01f, 1.98051095e-01f,
  -2.49143783e-02f, -4.42580253e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.31341213e-01f, 1.02442950e-02f, 5.95488131e-01f, -7.99796432e-02f, -1.80116832e-01f, -7.18745217e-02f, -3.08084220e-01f, -2.53471971e-01f, -5.57531230e-02f, 5.38411811e-02f,
  -1.18115544e-01f, 1.03249229e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    