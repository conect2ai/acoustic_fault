/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.78501514e-02f, -2.16665208e-01f, -1.72287136e-01f, -6.57303110e-02f, -2.53266305e-01f, -2.95095146e-01f, -4.04161394e-01f, -1.22012250e-01f, -2.59023365e-02f, -2.29609698e-01f,
  -3.99693727e-01f, 1.49579480e-01f, 1.70148984e-01f, 2.04700023e-01f, 2.38912329e-01f, 2.68809218e-02f, 2.18222693e-01f, 4.75902945e-01f, 3.62856239e-01f, -9.26470682e-02f,
  4.75585237e-02f, 5.47914207e-02f, 9.81877595e-02f, 1.66722953e-01f, -9.15957091e-04f, 1.22951128e-01f, -3.04708391e-01f, -1.77145526e-01f, -2.36066312e-01f, 3.05334538e-01f,
  1.63494200e-01f, -1.42394170e-01f, -2.57153460e-03f, -1.10927951e-02f, -1.88178029e-02f, 5.88077642e-02f, 4.13314346e-03f, 2.64004022e-02f, -5.24792932e-02f, 4.13209647e-02f,
  -5.17205708e-03f, -6.17913306e-02f, 1.25396401e-01f, 3.74783538e-02f, -1.04002200e-01f, -3.26140150e-02f, 8.75364989e-02f, 5.26033789e-02f, 4.06008735e-02f, -4.07132059e-02f,
  -6.01059645e-02f, -1.22773521e-01f, -2.44845346e-01f, -9.37115252e-02f, -4.89691943e-02f, 8.12007040e-02f, -2.34573305e-01f, 4.50435840e-02f, -3.16486880e-02f, -7.93114081e-02f,
  -6.24431446e-02f, -2.27311552e-02f, 3.01906224e-02f, -7.10574016e-02f, -1.00250943e-02f, -4.35964614e-02f, 3.83129604e-02f, -3.66196930e-02f, 7.90233258e-03f, -2.65884195e-02f,
  1.33120008e-02f, -3.48559767e-02f, 2.22592037e-02f, -1.12876885e-01f, 9.25167724e-02f, -5.01221754e-02f, 3.83184180e-02f, 2.00332608e-02f, -5.89051750e-03f, -1.02518521e-01f,
  3.28344405e-02f, -1.98279656e-02f, 1.11658890e-02f, 6.46084324e-02f, 2.54780930e-02f, 2.26143189e-02f, 1.74625013e-02f, 2.89755035e-02f, -1.70280074e-03f, -3.10082231e-02f,
  -7.49866888e-02f, -3.70979868e-02f, -8.82678758e-03f, 1.00449160e-01f, -4.04230095e-02f, -9.96422246e-02f, -6.64862022e-02f, 4.60540690e-02f, -4.07197736e-02f, -4.08846885e-03f,
  -1.17202923e-01f, -2.69312598e-03f, -6.13660626e-02f, -7.04044150e-03f, -5.75369373e-02f, -9.10003632e-02f, -8.57905000e-02f, 2.74086781e-02f, -8.47807378e-02f, -1.65855289e-01f,
  -5.52477650e-02f, -1.39643773e-01f, 5.37209548e-02f, 8.48107412e-03f, -1.09262019e-01f, 1.15267992e-01f, -3.69755700e-02f, -2.18190160e-02f, -4.46655490e-02f, -2.16346726e-01f,
  5.84987879e-01f, 2.27457255e-01f, -5.32950610e-02f, 5.35308957e-01f, 1.05133792e-02f, -1.54136389e-01f, 1.53025150e-01f, 1.36857197e-01f, 1.46445841e-01f, 2.54513294e-01f,
  -2.40313355e-02f, -2.97289819e-01f, -1.70781448e-01f, -4.42433834e-01f, -2.99244791e-01f, 1.81874156e-01f, 7.07671195e-02f, -2.70474106e-01f, -5.94205797e-01f, -2.21043810e-01f,
  -7.25376680e-02f, 2.37587944e-01f, 5.25128730e-02f, -4.51117493e-02f, 3.80531490e-01f, -1.34146914e-01f, 3.51729900e-01f, 1.66059881e-01f, -1.50833756e-01f, 2.97629982e-01f,
  3.24201696e-02f, 1.05209365e-01f, -1.46365151e-01f, -7.96609074e-02f, -5.07700928e-02f, 7.72496313e-03f, -5.08393459e-02f, 5.23101762e-02f, -7.54682347e-02f, 3.88597697e-02f,
  -1.06899021e-02f, -4.12928918e-03f, 7.44786207e-03f, -6.52098954e-02f, -2.62670685e-02f, -3.06028035e-02f, 2.02564467e-02f, 5.61301690e-03f, -5.57796769e-02f, 2.01185215e-02f,
  -1.28954928e-03f, 4.46245670e-02f, -1.95780862e-02f, 3.02470513e-02f, -1.39420047e-01f, -1.91721484e-01f, -5.01114428e-02f, -8.89000222e-02f, -8.48183483e-02f, 1.83053032e-01f,
  4.20253873e-02f, 1.48618706e-02f, -8.46830159e-02f, 1.81095731e-02f, -3.99182027e-05f, 4.02304828e-02f, -8.79525915e-02f, 2.13315375e-02f, -1.15268230e-01f, 7.63341412e-02f,
  -4.76378500e-02f, -2.65919138e-02f, -1.13694452e-01f, 4.59630601e-02f, -4.25514802e-02f, 2.94019859e-02f, -1.21492324e-02f, 2.73638964e-02f, -1.09129839e-01f, 2.37198584e-02f,
  -7.89143294e-02f, -3.48982145e-03f, 1.07927948e-01f, -1.17028490e-01f, 1.26319779e-02f, -4.33543436e-02f, 1.02683315e-02f, -1.18128741e-02f, 9.09168571e-02f, 3.67145520e-03f,
  7.31888339e-02f, -4.15697813e-01f, 5.18497527e-02f, -4.48793657e-02f, -3.10884621e-02f, 2.51981579e-02f, 1.85961518e-02f, -7.96593651e-02f, 7.49578467e-03f, 4.95786406e-03f,
  -1.17256321e-01f, -1.26633616e-02f, 2.64073387e-02f, -5.51064834e-02f, -9.04151052e-02f, -4.53202203e-02f, -2.15856954e-02f, -3.60261612e-02f, -5.68283014e-02f, 5.81936426e-02f,
  4.75856625e-02f, 9.18335095e-03f, -5.66507541e-02f, -4.60355915e-02f, 1.22598410e-02f, -3.67375612e-02f, -4.12406512e-02f, -2.93112863e-02f, -1.15499288e-01f, 2.98530221e-01f,
  3.48770991e-02f, 1.76994577e-01f, 4.29758966e-01f, 1.43817589e-01f, 4.04991239e-01f, 1.45508841e-01f, 3.55380148e-01f, 2.13727504e-02f, -2.09167376e-01f, 8.47273227e-03f,
  2.07617387e-01f, 6.65032910e-03f, 6.88492432e-02f, 3.73679884e-02f, 3.25914621e-02f, 2.15375960e-01f, 1.14266269e-01f, -6.54309243e-02f, 4.72429842e-02f, 1.56338662e-01f,
  4.43724692e-02f, 1.51632026e-01f, -7.47157633e-02f, -4.56934460e-02f, 1.16307408e-01f, -2.45204363e-02f, 1.45433694e-01f, 4.84075360e-02f, 1.12694353e-02f, 1.25705436e-01f,
  5.29077351e-01f, 2.70549774e-01f, -1.93567038e-01f, -2.54110973e-02f, 9.34398994e-02f, -6.38698637e-02f, 6.59440085e-02f, -8.72424394e-02f, -1.59690082e-01f, -1.37410490e-02f,
  -2.14618165e-02f, -6.60362244e-02f, -8.32857713e-02f, 1.13073858e-02f, 5.13189286e-02f, -5.00465445e-02f, -9.36277285e-02f, -4.72547486e-02f, -3.62959020e-02f, -3.72747816e-02f,
  -6.30991757e-02f, 2.19108202e-02f, 1.20889498e-02f, -1.44225001e-01f, -9.19253156e-02f, -1.04407802e-01f, 3.32689770e-02f, 1.69764422e-02f, -1.30793452e-01f, -9.23060849e-02f,
  -1.97113976e-01f, 4.39302251e-02f, 7.37656131e-02f, 3.32346782e-02f, 4.67396639e-02f, 4.76520136e-03f, -1.78515855e-02f, -1.19830286e-02f, 2.42864918e-02f, 6.44289926e-02f,
  2.17535198e-02f, 8.67587924e-02f, 6.59291446e-02f, 1.11621618e-01f, 2.26807613e-02f, 8.62916261e-02f, 8.88114721e-02f, 3.67527567e-02f, -3.51667181e-02f, -4.22644317e-02f,
  4.83209919e-03f, -4.90474738e-02f, 6.69344068e-02f, 7.99196810e-02f, 6.39754906e-02f, 6.82654828e-02f, 1.81236472e-02f, 6.68746307e-02f, 3.26125622e-02f, -6.68464229e-03f,
  -6.03354126e-02f, -1.26222059e-01f, -2.46862397e-02f, -1.21333398e-01f, -8.53345916e-03f, -1.50348887e-01f, -8.02519396e-02f, -1.96125492e-01f, -7.83883967e-03f, -8.30684695e-03f,
  -7.02257007e-02f, 9.64295957e-03f, 1.12307459e-01f, -4.58181016e-02f, 1.77990068e-02f, -7.43794739e-02f, -3.10924035e-02f, -8.02544877e-03f, -5.01475446e-02f, -1.01892233e-01f,
  -1.14175558e-01f, -7.99115077e-02f, -8.34728032e-02f, -4.90641110e-02f, -9.68685299e-02f, -5.70132434e-02f, -8.40293765e-02f, -8.36418718e-02f, 6.83456985e-03f, -1.16625495e-01f,
  3.66606623e-01f, -2.72680987e-02f, -3.70492578e-01f, -6.10149279e-02f, -1.45023569e-01f, -2.22977828e-02f, -1.59014076e-01f, 6.55262694e-02f, 1.81712210e-01f, -1.33361995e-01f,
  1.77273542e-01f, 4.74331975e-01f, 1.19233154e-01f, 6.29274398e-02f, 1.48703232e-01f, -3.46589804e-01f, -5.36136806e-01f, -2.43139625e-01f, 2.45751753e-01f, 2.63274431e-01f,
  -1.65935569e-02f, -1.07513450e-01f, -3.39984894e-02f, -1.02021709e-01f, -1.25330582e-01f, 2.72265792e-01f, -2.12327152e-01f, -3.53519717e-04f, -5.55504821e-02f, -4.81423497e-01f,
  8.33515450e-02f, 9.74811837e-02f, 8.54403898e-02f, 1.10664554e-02f, 4.27298322e-02f, 3.54360454e-02f, 1.18617982e-01f, 3.65433539e-03f, 8.09954628e-02f, -7.52952695e-03f,
  6.11346588e-02f, 4.95963451e-03f, 6.84243720e-03f, 1.09493136e-02f, 4.12848778e-02f, 4.09994982e-02f, -1.03373073e-01f, -3.98537284e-03f, -2.06268262e-02f, 2.64392458e-02f,
  -1.35040404e-02f, 2.47025769e-03f, 1.89565066e-02f, 1.99635439e-02f, 7.84841850e-02f, -3.88741866e-02f, 1.67590752e-02f, 3.21002640e-02f, 1.64825059e-02f, 5.57109453e-02f,
  1.05134070e-01f, -1.46089972e-03f, -6.75626621e-02f, -5.75151779e-02f, -4.02275622e-02f, -7.85924569e-02f, 1.39582939e-02f, 1.03364047e-03f, -1.27891645e-01f, -5.41033372e-02f,
  -8.73736888e-02f, -6.38882518e-02f, -9.54990983e-02f, 1.09227756e-02f, -8.40947032e-02f, -6.41753227e-02f, -1.61851589e-02f, 1.79482922e-02f, -3.44153345e-02f, -1.09667346e-01f,
  3.57627161e-02f, 3.16371620e-02f, -1.86595879e-02f, -1.48607576e-02f, -1.45512268e-01f, 3.46955517e-03f, -3.76186185e-02f, -8.67021158e-02f, -5.50772101e-02f, -3.64162102e-02f,
  2.70635903e-01f, -5.34522086e-02f, 3.51694115e-02f, 1.58523351e-01f, 1.31513193e-01f, 1.38828963e-01f, 8.93862620e-02f, 5.98293543e-02f, 1.54417649e-01f, 6.26120567e-02f,
  1.17710195e-01f, 1.59729972e-01f, 4.60623428e-02f, -6.52488843e-02f, 5.72927184e-02f, 7.93476999e-02f, 7.02353716e-02f, 1.33034974e-01f, 5.43147549e-02f, -1.78150798e-03f,
  -2.36703735e-02f, 1.16330445e-01f, 2.90503353e-01f, 1.45095065e-01f, 1.81313246e-01f, 2.81515986e-01f, 1.59670472e-01f, 1.80961326e-01f, 2.01717407e-01f, 1.76427200e-01f,
  1.10621941e+00f, -2.80220568e-01f, 2.98220754e-01f, 2.59085506e-01f, -4.05633122e-01f, -1.38188852e-02f, -3.59979779e-01f, -4.66403877e-03f, 2.15807915e-01f, -2.19283509e-03f,
  -1.69478282e-01f, -1.65521041e-01f, 4.65497896e-02f, -1.57675281e-01f, 1.34690091e-01f, -1.86012797e-02f, 1.68659538e-01f, 4.24103588e-01f, 2.14228556e-01f, -3.34622443e-01f,
  -4.29297209e-01f, 1.86421182e-02f, 5.19382179e-01f, 1.44911021e-01f, -1.58905745e-01f, -1.19672067e-01f, 1.25145286e-01f, 1.77019145e-02f, -1.00873984e-01f, -3.00111361e-02f,
  4.23322059e-02f, 1.52222052e-01f, -2.45611183e-02f, 3.21959308e-03f, 1.38487034e-02f, 1.32662013e-01f, 1.60231106e-02f, 1.06414713e-01f, 2.18002610e-02f, 1.08728282e-01f,
  -1.18261511e-02f, 1.62032768e-02f, 9.74873155e-02f, -1.08776756e-01f, 1.39879994e-02f, -2.24753972e-02f, 1.61020175e-01f, 1.47079825e-01f, 1.20434768e-01f, -4.39121015e-02f,
  -1.56345829e-01f, -5.99633120e-02f, 2.71021686e-02f, -2.58545242e-02f, 3.95936519e-02f, 7.74630085e-02f, -1.36879638e-01f, 7.70173743e-02f, 1.84794515e-02f, 1.78911351e-02f,
  1.33599890e-02f, -1.01543218e-02f, -4.03596386e-02f, -2.84321271e-02f, -4.84518846e-03f, -4.67067100e-02f, 1.30411861e-02f, -3.06310076e-02f, -2.83742305e-02f, 4.19923775e-02f,
  -3.80199440e-02f, 6.48243446e-03f, -1.92597881e-02f, 6.04255311e-02f, -4.92569767e-02f, -1.76914576e-02f, 1.72373615e-02f, 4.24483754e-02f, -1.03076054e-02f, 2.63368953e-02f,
  -3.71817723e-02f, 4.87354584e-02f, -1.82148488e-03f, -1.73791274e-02f, -6.83874786e-02f, 6.26211464e-02f, 4.30998596e-04f, -8.00745785e-02f, 1.78542621e-02f, 3.12829278e-02f,
  1.01080993e-02f, 1.03508309e-02f, -1.13001582e-03f, 4.14843895e-02f, 2.17821468e-02f, 6.13284856e-02f, 2.87570134e-02f, -1.72029715e-02f, -2.53889710e-02f, -4.24136631e-02f,
  1.59542286e-03f, 1.37292400e-01f, -1.64868403e-02f, -2.90666912e-02f, -7.00318208e-03f, -2.24955548e-02f, 2.15694420e-02f, -1.31965745e-02f, -5.52021414e-02f, 2.05992684e-02f,
  -1.24685711e-03f, -4.72006053e-02f, 4.46120948e-02f, -2.55589113e-02f, -2.75555104e-02f, -4.47422378e-02f, -3.37473340e-02f, 2.26577092e-02f, 3.78309749e-02f, -4.98331152e-02f,
  -1.42333686e-01f, 1.95850328e-01f, 5.07892728e-01f, -1.87608019e-01f, 1.25719262e-02f, 2.80758172e-01f, 5.58840334e-01f, 3.90980728e-02f, -2.58900702e-01f, 1.49825975e-01f,
  -2.66240798e-02f, -2.65680730e-01f, -2.20252797e-01f, -6.52314872e-02f, 1.41716942e-01f, 3.85760933e-01f, 2.91168571e-01f, 8.96844044e-02f, 2.22957600e-02f, -1.64398141e-02f,
  -9.33206156e-02f, -1.34821400e-01f, -1.95780650e-01f, -2.56546531e-02f, -2.78615374e-02f, -2.90822476e-01f, -1.22079067e-02f, -1.34304672e-01f, 1.29883200e-01f, 1.38580292e-01f,
  1.51420131e-01f, 2.25154623e-01f, 3.71575169e-02f, -1.42760575e-01f, -2.57690642e-02f, -2.40593161e-02f, 6.93815900e-03f, 2.41826158e-02f, -6.70867637e-02f, 9.22891311e-03f,
  -9.38700363e-02f, -5.93221262e-02f, -2.38292031e-02f, -1.04976915e-01f, 5.10906689e-02f, 7.48568326e-02f, -2.24003233e-02f, 8.54156166e-02f, 1.14569440e-01f, 6.39498606e-02f,
  -9.43762362e-02f, 9.93086174e-02f, 1.68364733e-01f, 9.57205519e-02f, 1.64631173e-01f, -1.75545756e-02f, 5.68163469e-02f, 1.88179631e-02f, 1.15237266e-01f, -2.84693204e-02f,
  -5.66209853e-02f, 7.87731539e-03f, -3.52602899e-02f, 6.01771753e-03f, -7.08029643e-02f, -4.52900566e-02f, -3.19577707e-03f, -3.73477228e-02f, -2.76465900e-02f, -5.14051765e-02f,
  7.78397499e-03f, 2.94097438e-02f, -2.33869664e-02f, 6.32533655e-02f, -7.71245062e-02f, 8.48749429e-02f, 6.08677231e-03f, -3.51307392e-02f, -1.87637471e-02f, 1.60081778e-02f,
  -1.50803970e-02f, 3.93035114e-02f, -6.92063570e-02f, -1.41945705e-02f, 4.80147377e-02f, 9.23600420e-02f, -2.79060677e-02f, -5.60929254e-02f, -7.88371563e-02f, 3.13257836e-02f,
  -2.92814910e-01f, 6.21097982e-02f, -4.24011871e-02f, 4.28035483e-02f, -2.28290521e-02f, 1.41738607e-02f, -5.99044887e-03f, 3.92296538e-02f, -2.89776665e-03f, 1.02817535e-01f,
  5.39670885e-02f, -6.88552682e-05f, 4.35937829e-02f, 4.17309962e-02f, -3.01946513e-02f, -1.02034742e-02f, -3.64575014e-02f, -2.87790094e-02f, 3.75635251e-02f, 3.95966209e-02f,
  2.14920156e-02f, 2.35144235e-03f, -1.35737255e-01f, -3.35357562e-02f, -1.36197787e-02f, -1.19347706e-01f, 2.42820643e-02f, -2.63073165e-02f, 1.82091892e-02f, -9.84748378e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.08059903e-02f, -3.23420048e-01f, -2.67092139e-01f, 5.89447796e-01f, 4.53262657e-01f, 5.00226557e-01f, 4.36405927e-01f, 4.22212392e-01f, 2.77194530e-01f, 2.13641480e-01f,
  1.40244355e-02f, 3.22679669e-01f, 3.06646883e-01f, 1.61664844e-01f, 1.18783563e-01f, 3.01229835e-01f, 3.45006675e-01f, -5.57627454e-02f, 3.26506421e-02f, 1.78055599e-01f,
  2.24094838e-01f, 3.05000227e-02f, -3.67298692e-01f, -4.02862206e-02f, 3.08232848e-03f, 2.43671522e-01f, 3.54824699e-02f, -2.46438920e-01f, -2.09945247e-01f, -9.33106020e-02f,
  -5.87478995e-01f, -1.49676487e-01f, 2.32779101e-01f, 4.89158044e-03f, -1.32695973e-01f, -2.88332850e-01f, -2.68091299e-02f, -2.51192451e-01f, -1.88068748e-01f, -1.35173172e-01f,
  -1.27596200e-01f, -1.37784943e-01f, 1.50556520e-01f, -3.29168327e-02f, -1.08987115e-01f, -1.95943564e-01f, -1.19041383e-01f, 2.49759238e-02f, 7.71125406e-02f, -1.92739721e-02f,
  1.45197138e-01f, 9.02274251e-03f, -6.07340820e-02f, 2.14758486e-01f, 6.85141906e-02f, 2.65286565e-02f, -1.01892829e-01f, 6.25313213e-03f, 4.99090441e-02f, 5.26735149e-02f,
  1.84050173e-01f, 5.96904987e-03f, 9.28607732e-02f, 4.03391458e-02f, -3.56589742e-02f, 1.09204561e-01f, 7.38883298e-03f, 1.16620148e-02f, 2.09103003e-01f, -8.71292055e-02f,
  -7.31321871e-02f, 9.78198946e-02f, 6.66843057e-02f, 6.57149926e-02f, 6.33590519e-02f, 8.93482342e-02f, -8.56415108e-02f, 9.89065766e-02f, -5.70990629e-02f, -2.61856876e-02f,
  -1.29937045e-02f, 6.34314269e-02f, -1.30422339e-01f, 2.61326302e-02f, -7.50054196e-02f, 4.46965694e-02f, 4.21891809e-02f, -6.29032403e-02f, 9.34523866e-02f, 8.80343432e-04f,
  -4.24864963e-02f, 2.63361782e-01f, 1.59227684e-01f, 2.48792525e-02f, -7.33046904e-02f, -1.30112395e-01f, 9.51247290e-02f, -3.15584242e-02f, -2.96253800e-01f, -2.19975226e-02f,
  -1.96604468e-02f, -8.28827620e-02f, 4.31400612e-02f, -4.36869450e-02f, -4.28351536e-02f, -3.41559388e-02f, 1.26535952e-01f, 1.21972777e-01f, -3.22324894e-02f, -9.93303061e-02f,
  1.47872791e-02f, 8.57908949e-02f, 1.82344109e-01f, 6.92241192e-02f, 1.87725529e-01f, 1.67224668e-02f, -4.98994626e-02f, -1.15560561e-01f, 7.69471452e-02f, 1.36968598e-01f,
  -4.92944866e-01f, 2.14938134e-01f, 4.12221253e-01f, -3.79973471e-01f, 3.34650964e-01f, 5.00742435e-01f, 4.66962039e-01f, 3.16514552e-01f, -1.54317006e-01f, -6.54247478e-02f,
  4.35601741e-01f, -3.96992862e-01f, -4.29608971e-01f, -4.88677055e-01f, -1.51654094e-01f, 2.48719752e-01f, -3.64967406e-01f, -3.93464983e-01f, -1.28784329e-01f, 1.01091407e-01f,
  -3.52276474e-01f, -5.45326471e-01f, -3.52317691e-01f, 8.35795999e-02f, -2.90759176e-01f, -6.01779640e-01f, -1.21878140e-01f, 6.25279453e-03f, 2.50482500e-01f, -1.29544270e+00f,
  1.79861277e-01f, 4.55815822e-01f, 9.77839455e-02f, -1.85168281e-01f, 9.66302156e-02f, 5.09331413e-02f, 1.54839441e-01f, 3.03243753e-02f, -1.97840817e-02f, -2.26053104e-01f,
  7.54586980e-02f, 3.32919896e-01f, -1.50883004e-01f, 7.32627288e-02f, -3.46077345e-02f, 1.46036878e-01f, 2.47315705e-01f, 1.55388981e-01f, -2.41655990e-01f, 4.01936263e-01f,
  -3.43538105e-01f, 1.51388973e-01f, 2.79054567e-02f, 4.53626275e-01f, -1.05150245e-01f, -2.77766101e-02f, 2.96084136e-01f, 2.17899859e-01f, 4.19889003e-01f, -6.30351722e-01f,
  -9.25982744e-02f, 4.18565832e-02f, 6.30962998e-02f, -9.93309468e-02f, -1.29941538e-01f, 1.00183539e-01f, -5.68823703e-02f, -1.59584343e-01f, 1.84788719e-01f, -6.92621469e-02f,
  1.07165419e-01f, 1.61733732e-01f, -4.72928099e-02f, 1.58537719e-02f, -3.97574715e-02f, 9.74083226e-03f, 9.44807455e-02f, -1.49126798e-01f, 1.46248400e-01f, -4.06251326e-02f,
  -3.93789224e-02f, -2.29971875e-02f, 9.85637754e-02f, -9.51215178e-02f, 1.47349939e-01f, 1.79780871e-02f, 7.84367770e-02f, 1.02088623e-01f, -3.51186134e-02f, 2.39078745e-01f,
  -5.30492127e-01f, 7.11053610e-02f, -5.43191075e-01f, 1.76841527e-01f, 8.12507048e-02f, 8.21662843e-02f, -1.96265817e-01f, 9.09270048e-02f, 4.89329658e-02f, -7.88739920e-02f,
  7.25452825e-02f, 8.39628205e-02f, 3.47654484e-02f, 9.34053287e-02f, -6.39572665e-02f, 2.31947601e-02f, 6.47601932e-02f, -1.23125575e-01f, 7.55209401e-02f, -3.84501815e-02f,
  5.19889668e-02f, -3.63614351e-01f, -8.68069708e-01f, -1.52530121e-02f, -4.35433745e-01f, -4.46386218e-01f, -5.27263522e-01f, -2.82573760e-01f, -3.17251295e-01f, -1.11620545e+00f,
  9.86756980e-01f, -1.02452064e+00f, -2.03736171e-01f, 3.85166258e-01f, 3.25962007e-01f, 4.88149107e-01f, 4.16136608e-02f, 1.77324280e-01f, 3.44355911e-01f, -1.36036426e-01f,
  -5.81235528e-01f, -4.29044247e-01f, -4.68103439e-01f, -3.85281444e-01f, -2.97294587e-01f, -1.04131855e-01f, 1.25326231e-01f, 2.16361862e-02f, 5.04382908e-01f, 5.43959141e-01f,
  2.10252836e-01f, 1.29412413e-01f, -4.94687073e-02f, 6.82661589e-03f, -1.21034205e-01f, 2.13961452e-01f, -2.89331883e-01f, -4.43627596e-01f, -4.83810455e-01f, -7.24992931e-01f,
  -2.46757135e-01f, -3.44189167e-01f, 2.17312053e-01f, 6.15913942e-02f, -1.87878489e-01f, 1.21591613e-01f, 4.32905890e-02f, -1.85152572e-02f, -1.15808481e-02f, 8.75827074e-02f,
  -5.50749563e-02f, 3.65990475e-02f, -5.43768294e-02f, 4.64430312e-03f, 1.12795591e-01f, 5.91804087e-02f, -5.34524061e-02f, -1.63995296e-01f, -1.06135100e-01f, -3.25573944e-02f,
  -2.79425979e-01f, -4.03902084e-02f, -7.86176026e-02f, -2.24189777e-02f, -5.08967452e-02f, 8.13825056e-02f, -1.09574802e-01f, -4.02980484e-02f, -2.93429866e-02f, -1.12186909e-01f,
  -1.18722312e-01f, 6.62499443e-02f, -7.07273930e-02f, 9.42979008e-03f, 1.98983718e-02f, 1.05411761e-01f, 5.90587966e-02f, 3.80293541e-02f, 4.67380695e-02f, 1.48957018e-02f,
  2.24827938e-02f, -4.78845909e-02f, 5.81978597e-02f, -1.90854650e-02f, -8.97547007e-02f, 3.35728228e-02f, 6.96073696e-02f, -3.99163216e-02f, -8.77229869e-02f, 1.05750836e-01f,
  -8.69911835e-02f, 6.18905127e-02f, 2.83462759e-02f, -2.71334890e-02f, 4.25970182e-03f, -2.16216855e-02f, -6.67955121e-03f, -1.01543434e-01f, 4.77616638e-02f, 1.14026412e-01f,
  2.31606066e-02f, -2.10589573e-01f, 5.16007654e-02f, -2.12488711e-01f, 1.26726344e-01f, -1.44525096e-01f, -1.14509933e-01f, -2.85752900e-02f, -4.12779022e-03f, 2.26574726e-02f,
  -5.16059361e-02f, -1.38539508e-01f, -1.14381492e-01f, -2.82108430e-02f, 1.60632089e-01f, 3.60302515e-02f, -9.99705419e-02f, 1.87632181e-02f, 1.09067531e-02f, 3.51296365e-02f,
  2.14648601e-02f, 2.28161171e-01f, 8.92605782e-02f, 1.18987560e-01f, 1.09807946e-01f, 1.81830719e-01f, 2.69207247e-02f, 1.02053061e-01f, 1.35351777e-01f, 3.06544662e-01f,
  -2.77400523e-01f, 1.62459150e-01f, 2.38120660e-01f, 2.04552233e-01f, 4.32055920e-01f, 7.55811483e-02f, 1.16261192e-01f, -3.88685465e-01f, -1.69086546e-01f, 1.25994831e-01f,
  9.05449614e-02f, -7.07288980e-02f, -2.45150477e-01f, -2.00054973e-01f, -3.81838918e-01f, 1.91995919e-01f, 3.91708910e-01f, 2.46151596e-01f, -4.59742427e-01f, -4.01206344e-01f,
  1.13877922e-01f, 1.06356494e-01f, -1.89116091e-01f, -1.16015166e-01f, 1.79226816e-01f, -3.78334582e-01f, -1.29182413e-02f, 2.27605402e-01f, 1.32874906e-01f, 7.34000206e-01f,
  3.89974773e-01f, 2.10091531e-01f, -1.22388735e-01f, 6.79367185e-02f, 2.20227689e-01f, -1.98897511e-01f, 1.50448373e-02f, 1.70843035e-01f, -7.07571907e-03f, 7.13189840e-02f,
  2.40096629e-01f, 1.24552161e-01f, 1.04911953e-01f, -8.63485131e-03f, 1.54776620e-02f, -2.03905836e-01f, -9.34216082e-02f, -8.78433231e-03f, -1.23048484e-01f, -2.33615920e-01f,
  2.42832690e-01f, 3.90998274e-01f, 2.08935007e-01f, -1.54894412e-01f, -2.30151698e-01f, 1.62875146e-01f, -8.64156857e-02f, -1.19709961e-01f, -2.03754172e-01f, -3.21512520e-01f,
  -1.68825969e-01f, 4.55297977e-02f, -6.18607411e-03f, 6.29129857e-02f, -9.99753550e-02f, 9.34958607e-02f, 2.01079428e-01f, -1.36171430e-01f, 5.39854020e-02f, 6.29492179e-02f,
  -7.01047154e-03f, -8.43827948e-02f, 2.41328012e-02f, -1.55112013e-01f, 1.57401655e-02f, 4.76225093e-02f, 1.26097098e-01f, -1.51634831e-02f, 1.68513320e-02f, 9.92664602e-03f,
  -7.44522437e-02f, 1.32989725e-02f, 1.15241759e-01f, -3.02890986e-02f, 1.07160091e-01f, 9.28880349e-02f, 4.41978723e-02f, -1.24218464e-01f, -9.78574455e-02f, 1.90207317e-01f,
  -3.94097000e-01f, -3.12733129e-02f, -1.27813490e-02f, -1.63686834e-02f, 1.36951417e-01f, 1.19278431e-01f, 2.40279630e-01f, -1.64334644e-02f, 1.98527381e-01f, -6.83579370e-02f,
  -4.59153391e-02f, -5.92362918e-02f, 7.37312138e-02f, 7.96278268e-02f, -1.10668041e-01f, 4.84171808e-02f, 2.07335159e-01f, 8.04920346e-02f, -1.05190158e-01f, 9.21383947e-02f,
  -1.26992673e-01f, -3.84407550e-01f, -6.83651865e-01f, -7.59664283e-04f, -2.14359351e-02f, -3.28584373e-01f, -2.94685930e-01f, -1.29272267e-01f, -3.94795030e-01f, -7.99624085e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.65281534e-01f, 2.94910192e-01f, 3.88484359e-01f, 9.29318726e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.54472196e-01f, -2.31884733e-01f, -3.40616703e-01f, 9.03028697e-02f, -3.36356044e-01f, -5.43432355e-01f, 1.07558601e-01f, -8.42572749e-01f, 1.13536706e-02f, 1.52483717e-01f,
  2.27648899e-01f, 3.91178466e-02f, 8.72792378e-02f, 4.17913944e-01f, -1.39455929e-01f, -4.01843846e-01f, 6.46307096e-02f, -1.05488256e-01f, 7.41695426e-03f, 4.71798241e-01f,
  6.11539483e-01f, 4.17872742e-02f, -5.21307588e-01f, 7.19124913e-01f, -1.02475308e-01f, 2.85225570e-01f, -9.14180994e-01f, -7.38067627e-01f, -2.80757993e-01f, 3.04335624e-01f,
  -1.96856380e-01f, 1.59146488e-01f, 2.11695448e-01f, -6.45195916e-02f, -2.94652164e-01f, -2.01302558e-01f, 2.16591209e-01f, -3.64355206e-01f, -6.90257251e-02f, 5.19530892e-01f,
  7.11220577e-02f, 1.50779352e-01f, -2.87164807e-01f, -5.52403219e-02f, -2.63325181e-02f, -2.70147085e-01f, -4.88861799e-01f, 4.91236180e-01f, -1.12289689e-01f, -2.94123385e-02f,
  1.98225409e-01f, 1.38212413e-01f, -6.78987205e-01f, 2.97625512e-01f, 7.59175420e-02f, 7.23906374e-03f, 5.56931011e-02f, -5.11277318e-01f, 2.43167400e-01f, 1.14017451e+00f,
  -2.11070955e-01f, -8.50540325e-02f, 3.03969383e-01f, 2.42878929e-01f, 8.90161097e-02f, -7.79525861e-02f, 3.86001132e-02f, 3.14042643e-02f, 3.91149372e-02f, 5.20365238e-01f,
  6.98660985e-02f, -2.49951124e-01f, -4.35244441e-01f, -1.73565030e-01f, -1.81566611e-01f, -1.84672341e-01f, -5.04839003e-01f, 1.66748781e-02f, -2.96957493e-01f, -1.48152793e-02f,
  -4.82405685e-02f, 2.09443308e-02f, 2.79651862e-02f, 2.99645454e-01f, -5.26503742e-01f, -4.40911911e-02f, -3.66836399e-01f, 8.10567617e-01f, 1.25661105e-01f, -5.19138314e-02f,
  -4.45051074e-01f, 6.61916554e-01f, 2.44425178e-01f, 8.43297020e-02f, -5.28308451e-01f, 2.40510002e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -6.12060666e-01f, 5.25928080e-01f, 4.65838134e-01f, 1.15425527e+00f, 1.33925831e+00f, 1.49854302e-01f, -6.71777487e-01f, 2.59715468e-01f, -8.28017175e-01f, -5.23060799e-01f,
  5.89057684e-01f, -4.51488197e-01f, -3.78760576e-01f, 8.86028886e-01f, -6.44694626e-01f, 9.46860373e-01f, 7.41266668e-01f, 4.61298645e-01f, 3.49898338e-01f, -3.86099041e-01f,
  4.18299854e-01f, 9.83679414e-01f, 7.88624346e-01f, -8.58410001e-01f, 2.03382805e-01f, -6.28109798e-02f, -1.37047425e-01f, -1.23393726e+00f, 3.53523999e-01f, -9.31890130e-01f,
  -4.57364053e-01f, 1.33131516e+00f, 8.28591943e-01f, 5.29000700e-01f, -4.15653795e-01f, 5.57834469e-02f, 1.04039061e+00f, 3.14787567e-01f, 1.00497492e-01f, 5.73768198e-01f,
  -5.00594974e-01f, 6.32108510e-01f, 2.17187703e-01f, -8.85129154e-01f, 3.96812111e-01f, 5.09906232e-01f, 1.58996940e+00f, -6.21237040e-01f, 4.15224463e-01f, -1.58461202e-02f,
  4.21714753e-01f, 2.33306751e-01f, -2.10338369e-01f, 4.58730698e-01f, -3.47278804e-01f, -1.62998188e+00f, -1.52535081e-01f, 5.11762142e-01f, -2.18508840e+00f, 4.00188297e-01f,
  -3.02353919e-01f, 1.10514450e+00f, 1.87485367e-01f, -2.13712320e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  6.29301131e-01f, 9.05028105e-01f, 2.76931882e-01f, 3.24286073e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -9.11741674e-01f, -1.83495551e-01f, -3.12779874e-01f, -9.73620936e-02f, 4.59288746e-01f, -1.22522607e-01f, 1.26191533e+00f, -7.75508657e-02f, -2.19826683e-01f, -8.76717865e-01f,
  -7.33614853e-03f, -1.28662145e+00f, -3.60000342e-01f, -1.05718684e+00f, 2.95038015e-01f, 5.67904055e-01f, 6.75964713e-01f, 2.99098119e-02f, 2.31220573e-01f, 8.23694766e-01f,
  2.05947638e-01f, -6.79778218e-01f, 9.59445655e-01f, -8.83293331e-01f, -1.39559972e+00f, -7.39420176e-01f, 2.92543527e-02f, 2.93372571e-01f, -1.33174241e+00f, 1.96990535e-01f,
  4.40017492e-01f, -1.18928707e+00f, 6.35267198e-01f, 5.05725980e-01f, -2.27814555e-01f, -9.43076909e-02f, 2.80357599e-01f, 2.71081440e-02f, -1.79026946e-01f, -9.40781474e-01f,
  -1.47538865e+00f, 5.75643361e-01f, 1.34074879e+00f, -1.64408398e+00f, 5.82890332e-01f, 1.63845375e-01f, -6.58495009e-01f, -9.25750017e-01f, -9.46587622e-01f, -2.30432183e-01f,
  -5.65316975e-01f, -2.19000936e-01f, -3.90439540e-01f, -3.03755254e-01f, 1.50714815e+00f, 6.38550520e-01f, -4.00613457e-01f, 1.47624457e+00f, 8.40700746e-01f, 1.64232647e+00f,
  -9.27136280e-03f, -1.28484178e+00f, -7.48628378e-01f, 8.90002072e-01f, 1.02250409e+00f, -1.05190146e+00f, 6.19487226e-01f, 2.96951234e-01f, 1.31087989e-01f, 7.37767756e-01f,
  -3.46230865e-01f, -9.53139663e-01f, 7.20350295e-02f, -8.58206570e-01f, 1.34274781e+00f, 6.04921281e-01f, 5.96496224e-01f, -5.79986334e-01f, -2.87026539e-02f, -1.63294524e-01f,
  -1.12560980e-01f, 1.95683315e-01f, 9.26391661e-01f, -3.05583179e-01f, 2.43414506e-01f, 3.30859601e-01f, -1.18764544e+00f, 1.24248517e+00f, -7.91053712e-01f, -8.46184433e-01f,
  -4.31329876e-01f, -1.07796180e+00f, -6.91786632e-02f, -9.77632523e-01f, 6.69533670e-01f, -1.04790497e+00f, -1.04030764e+00f, 7.60114074e-01f, 5.05040586e-01f, -1.75147927e+00f,
  1.51718223e+00f, 4.13737535e-01f, -9.25791323e-01f, -1.48011982e+00f, 1.11443436e+00f, 5.43701410e-01f, -6.04133904e-01f, 1.06742942e+00f, -2.18467489e-01f, 1.45127535e-01f,
  -9.55480695e-01f, -9.43163335e-01f, -5.36481701e-02f, -1.26847744e-01f, -5.30982733e-01f, 2.60137349e-01f, -1.38771033e+00f, -1.62158394e+00f, 5.86257339e-01f, -5.07982612e-01f,
  9.98730063e-01f, -4.60612290e-02f, -9.02099162e-02f, 2.35566199e-02f, -1.47861922e+00f, 8.28765333e-01f, -4.49005038e-01f, -1.51742309e-01f, -1.01802897e+00f, 1.51120320e-01f,
  -1.50086284e+00f, -3.56462747e-01f, -1.38064241e+00f, -6.53968602e-02f, -7.51799285e-01f, -1.02054763e+00f, 1.43638834e-01f, 1.90492105e+00f, -4.07612473e-01f, -4.58980858e-01f,
  -6.50446892e-01f, -6.32719576e-01f, 8.24471116e-01f, -3.55116606e-01f, -7.85729170e-01f, -8.52462590e-01f, -4.26303774e-01f, 1.00429165e+00f, 4.56100821e-01f, 1.47963488e+00f,
  2.58063287e-01f, 1.51902699e+00f, 9.58998203e-01f, -7.32959569e-01f, -6.98301494e-01f, 1.70183092e-01f, 4.70573485e-01f, 4.34236556e-01f, -9.71298695e-01f, -1.51177275e+00f,
  2.43722439e-01f, 3.89275044e-01f, 3.29918206e-01f, 2.07033619e-01f, 1.99067667e-02f, 4.16482031e-01f, -1.30520058e+00f, 5.95183909e-01f, -4.61621046e-01f, -5.52954137e-01f,
  1.50917816e+00f, -9.03602779e-01f, -1.83018279e+00f, 1.03418820e-01f, -6.61973357e-01f, 1.09907389e+00f, 7.35034764e-01f, 5.04810154e-01f, 2.95411255e-02f, 3.30200344e-01f,
  -1.01752913e+00f, -7.16531754e-01f, 7.38398671e-01f, 8.08886468e-01f, 8.95348370e-01f, 3.72780561e-01f, -2.00169420e+00f, 3.67705733e-01f, 1.05884480e+00f, -7.46759713e-01f,
  -4.56308991e-01f, -6.87603951e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.28522545e-01f, 5.15172124e-01f, -2.09594801e-01f, -2.35508502e-01f, -4.39176321e-01f, 5.16239293e-02f, 6.54904485e-01f, 4.21324581e-01f, -2.67588139e-01f, -6.25207245e-01f,
  -4.13156897e-01f, 5.44112623e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    