/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.97410429e-01f, -5.51435538e-02f, -9.50914167e-04f, -1.20485574e-01f, 4.11726981e-02f, -1.82738788e-02f, 9.98810604e-02f, -1.74123183e-01f, -1.17402807e-01f, 1.37605458e-01f,
  3.23905423e-02f, -1.37445135e-02f, 9.83440876e-02f, -9.73237231e-02f, -2.71023333e-01f, -4.32152906e-03f, -6.79510608e-02f, -3.85045935e-03f, -9.19913501e-02f, 1.21957492e-02f,
  -5.42840846e-02f, -1.57020595e-02f, -1.56503189e-02f, 7.86647499e-02f, 3.64330853e-03f, 1.76122896e-02f, 1.19796365e-01f, 1.14074223e-01f, 7.58429542e-02f, 8.13515782e-02f,
  -3.16085443e-02f, 1.18015297e-02f, -1.20842181e-01f, 4.92323516e-03f, 1.50071913e-02f, 2.95661651e-02f, 5.20378835e-02f, 7.30076879e-02f, 5.55795198e-03f, 9.14197601e-03f,
  7.01237097e-02f, 1.29339118e-02f, -7.12272823e-02f, 5.10827824e-02f, -3.96552384e-02f, -1.33827329e-02f, -5.91409467e-02f, -5.53309992e-02f, 7.92808160e-02f, 7.64545705e-03f,
  2.95540206e-02f, 3.34907556e-03f, 4.26002145e-02f, -3.77411135e-02f, 7.27968710e-03f, -1.97036527e-02f, 5.68810217e-02f, 6.13641739e-02f, 1.83262564e-02f, -1.25990845e-02f,
  -1.49255916e-02f, 6.93609193e-02f, 1.25169836e-03f, -6.66674897e-02f, 1.12119447e-02f, -6.97749155e-03f, 4.25491631e-02f, 5.19857705e-02f, -4.22955528e-02f, 3.18598300e-02f,
  2.11265087e-02f, -1.79029237e-02f, 4.02756743e-02f, -2.03265678e-02f, 1.07220272e-02f, -1.58022717e-02f, 3.28566553e-03f, 5.39234765e-02f, 5.98179996e-02f, -3.00175771e-02f,
  -2.09127367e-02f, 5.59720490e-03f, 7.44552761e-02f, 3.24819461e-02f, -1.53866578e-02f, -3.15344147e-02f, 2.33850628e-02f, -6.41627014e-02f, -1.98465679e-02f, -2.21909508e-02f,
  1.52156381e-02f, 4.67759743e-02f, 9.11084190e-02f, 3.21067710e-05f, 2.26009823e-02f, -4.39505167e-02f, -5.60620241e-03f, -1.64200198e-02f, -8.16475041e-03f, -3.38352993e-02f,
  2.50518192e-02f, -2.42730454e-02f, 1.30504668e-01f, -6.61399774e-03f, -2.10828576e-02f, -1.96685027e-02f, 1.01188391e-01f, 3.77797373e-02f, -4.45390753e-02f, -5.58908135e-02f,
  6.65829517e-03f, 5.28563783e-02f, 1.29000209e-02f, 2.16767807e-02f, 2.00834274e-02f, 5.98233901e-02f, -2.63849460e-02f, 5.70968799e-02f, -3.42790149e-02f, -2.26062480e-02f,
  2.79342562e-01f, 2.12282509e-01f, 1.14968218e-01f, 1.19382277e-01f, -1.17336757e-01f, -7.07488274e-03f, 4.30901274e-02f, 8.91085267e-02f, 1.62372887e-01f, 6.70542067e-04f,
  -9.57505926e-02f, 2.50979960e-01f, -8.61087516e-02f, 1.85072526e-01f, -8.13693851e-02f, -8.30372944e-02f, 1.79342061e-01f, 1.78364009e-01f, -1.14974671e-03f, 4.42919321e-02f,
  2.44758688e-02f, 3.80517542e-02f, -1.31956726e-01f, -7.44037181e-02f, 2.91674975e-02f, -5.11902198e-03f, -7.13932067e-02f, -7.83668980e-02f, -1.15012261e-03f, 5.09423651e-02f,
  -1.52695579e-02f, 4.53993306e-02f, -1.81304105e-02f, -3.40443105e-02f, 3.20371613e-02f, -3.69415767e-02f, 8.13305676e-02f, 2.70054862e-02f, -9.22381412e-03f, -8.46697669e-03f,
  8.43219906e-02f, 8.50744024e-02f, -1.51175167e-02f, -4.52823751e-02f, -5.08817192e-03f, 4.64732312e-02f, -2.40083840e-02f, 7.12141469e-02f, 3.17252055e-02f, 1.73845538e-03f,
  9.26192570e-03f, -1.92610808e-02f, -2.38323826e-02f, -4.23975699e-02f, -6.41318783e-03f, -1.39961019e-02f, 9.20291804e-03f, -7.49780377e-03f, 3.21108140e-02f, 1.30225178e-02f,
  8.10731277e-02f, 3.13704973e-03f, -1.71693433e-02f, 1.64712109e-02f, 3.26167271e-02f, 5.77009050e-03f, -8.66736993e-02f, -5.45938350e-02f, 7.67488852e-02f, 4.67757182e-03f,
  1.08140903e-02f, 6.87454268e-02f, 3.90124209e-02f, -4.17847298e-02f, 7.73555711e-02f, -1.72336362e-02f, -5.93617326e-03f, 2.67382897e-02f, -1.31432777e-02f, 3.03012431e-02f,
  -7.98064172e-02f, 3.54671688e-03f, 3.00033856e-02f, -3.13377678e-02f, 1.96656641e-02f, -6.04765154e-02f, 5.66046610e-02f, -1.82491019e-02f, -5.68391867e-02f, -5.68388104e-02f,
  -2.65261228e-03f, 1.08539879e-01f, -4.78589460e-02f, -3.32909673e-02f, -4.78382111e-02f, -6.24237731e-02f, -8.34397878e-03f, 2.53084693e-02f, -6.08273000e-02f, 2.40297895e-02f,
  6.04236014e-02f, -7.58692622e-02f, 5.27475998e-02f, -3.36880460e-02f, -6.28555492e-02f, 5.77580780e-02f, 5.98318800e-02f, -2.99296482e-03f, -6.86334306e-03f, 3.07420455e-02f,
  1.86678134e-02f, -4.11633551e-02f, -2.05630753e-02f, 4.85537201e-02f, -5.46713993e-02f, 2.90697478e-02f, -9.88993794e-03f, 5.55478185e-02f, -5.82983866e-02f, 4.58392873e-02f,
  6.80562183e-02f, -2.24845228e-03f, -2.07287744e-01f, -7.20796585e-02f, 5.54613099e-02f, 3.25058284e-03f, -5.72735593e-02f, -2.20796708e-02f, -1.11737670e-02f, 6.59662485e-02f,
  4.62612808e-02f, 5.35632223e-02f, 1.51538104e-01f, 6.09128661e-02f, 1.77000359e-01f, 1.36196256e-01f, 1.24361761e-01f, 5.92287816e-02f, -8.20327699e-02f, -1.94614995e-02f,
  -3.55291814e-02f, 1.53327972e-01f, -1.00708872e-01f, -6.50107041e-02f, -5.37502952e-02f, -1.56444728e-01f, -7.23197609e-02f, -2.37172823e-02f, -7.77304843e-02f, 1.01400465e-02f,
  -2.97577288e-02f, 4.69862223e-02f, -6.59894347e-02f, -2.87321433e-02f, 3.96004543e-02f, -4.28945050e-02f, -2.23970767e-02f, 1.29411160e-03f, -2.11452926e-03f, 7.72878677e-02f,
  -1.24030681e-02f, -7.33453315e-03f, 1.53403636e-02f, -1.53904464e-02f, -1.41635323e-02f, 3.93525362e-02f, 6.25236379e-03f, -4.33270149e-02f, -1.95685979e-02f, -1.58642810e-02f,
  -7.04581514e-02f, 7.12073501e-03f, -9.72527359e-03f, -6.38936907e-02f, -6.55722469e-02f, -2.77839191e-02f, -2.44117416e-02f, -6.44075498e-02f, -1.32726533e-02f, -4.05852916e-03f,
  1.07464045e-02f, 5.36966175e-02f, 1.41925532e-02f, 2.87039373e-02f, 1.14107290e-02f, 2.40062755e-02f, 4.07911316e-02f, -6.55654399e-03f, -5.21213189e-02f, 3.93850394e-02f,
  -6.17011487e-02f, 1.30424611e-02f, 8.29184987e-03f, 2.75390013e-03f, -7.07943132e-03f, 3.07578929e-02f, 3.30038369e-02f, -2.03915988e-03f, -1.14758402e-01f, 7.99959060e-04f,
  -5.48665598e-02f, 7.40013570e-02f, -3.54427882e-02f, 1.81699079e-02f, 1.03766322e-02f, 3.14736576e-03f, -1.02563724e-02f, 2.43016593e-02f, -5.69504239e-02f, 6.46771044e-02f,
  -1.15063889e-02f, -7.04737660e-03f, -3.38619463e-02f, 1.67485885e-02f, -5.78662306e-02f, 8.55118930e-02f, 5.95191605e-02f, -3.51467878e-02f, 1.62326600e-02f, -3.32901664e-02f,
  1.44282738e-02f, -3.29376906e-02f, 5.17626340e-03f, 2.40582749e-02f, -1.01084751e-03f, 5.08420207e-02f, -1.26966462e-02f, -9.27138031e-02f, -3.34666520e-02f, 1.12859551e-02f,
  4.50577363e-02f, 3.63237038e-02f, -3.16693704e-03f, 3.29808407e-02f, 2.09114980e-02f, -4.95287636e-03f, -1.36457793e-02f, -5.16131260e-02f, 4.89727035e-02f, 3.12102754e-02f,
  1.86138123e-01f, 1.49393559e-01f, 8.69713649e-02f, -5.06839789e-02f, -9.64098424e-02f, -2.14992553e-01f, -3.02015394e-01f, -7.83402845e-03f, -1.42396480e-01f, -1.19272873e-01f,
  -1.29202291e-01f, -5.51808178e-02f, 1.55067176e-03f, -2.35190466e-01f, -3.11576039e-01f, -1.26561835e-01f, -2.59624511e-01f, -7.32004046e-02f, -1.15814023e-01f, 2.79404670e-02f,
  1.64706204e-02f, -4.94711027e-02f, 2.37098429e-02f, 1.63788676e-01f, 1.04381286e-01f, 2.09362432e-01f, 9.39720869e-02f, 1.25650227e-01f, 3.75025570e-02f, -2.25477964e-02f,
  -1.13064818e-01f, 5.35642840e-02f, 2.22916994e-02f, 7.33684525e-02f, 1.83310919e-02f, 8.07289556e-02f, 4.86345636e-03f, 3.95953543e-02f, -2.58056857e-02f, 1.25312805e-02f,
  -4.52797636e-02f, 1.63902976e-02f, 3.78758274e-02f, -3.35053764e-02f, 9.94029120e-02f, -2.44588256e-02f, -6.38364488e-03f, 1.85961314e-02f, -6.47771806e-02f, 2.53327135e-02f,
  3.38085741e-02f, -6.97881740e-04f, 3.63466353e-03f, -4.23808768e-02f, -1.74390338e-02f, -4.60870638e-02f, -9.86474827e-02f, -7.40241408e-02f, -5.29361926e-02f, -1.17106274e-01f,
  3.44995484e-02f, 2.46051606e-02f, 4.76749949e-02f, 1.78094190e-02f, 3.30603756e-02f, 3.28515582e-02f, -1.25438916e-02f, -5.75682037e-02f, 1.59952627e-03f, 4.53662425e-02f,
  -5.10565601e-02f, 3.26521024e-02f, -3.06484774e-02f, 3.62344161e-02f, -4.30437922e-02f, -1.02855815e-02f, 2.66754013e-02f, 2.27143113e-02f, 1.06259678e-02f, 1.39549468e-02f,
  -2.06528115e-03f, 5.29052690e-03f, 4.56665605e-02f, 1.67117417e-02f, -4.08183970e-02f, 2.98047289e-02f, 2.30879450e-04f, 2.29722392e-02f, 5.11504374e-02f, 9.56806075e-03f,
  -1.16735809e-01f, 1.66244153e-02f, -1.81503128e-02f, -5.05907275e-02f, -3.34395133e-02f, 4.77963500e-02f, -4.00519781e-02f, -7.37030730e-02f, 6.42053336e-02f, 1.16189057e-02f,
  1.12004310e-01f, 3.52781601e-02f, -4.22492400e-02f, 2.63801659e-03f, -5.42094447e-02f, -7.06105318e-04f, -1.75578520e-02f, -6.92903064e-03f, -4.89210822e-02f, -2.51536593e-02f,
  7.79975057e-02f, -2.01742984e-02f, -7.40466341e-02f, 3.24470513e-02f, -8.05061087e-02f, -2.49105189e-02f, 7.86117744e-03f, 1.86303426e-02f, -1.16759101e-02f, -4.16546240e-02f,
  -1.36627451e-01f, 1.80559814e-01f, -6.94084913e-02f, -2.09688559e-01f, -9.10456181e-02f, 9.77145061e-02f, 5.03840670e-02f, -4.47842963e-02f, -2.24253684e-01f, 1.95554271e-01f,
  1.26248049e-02f, -6.28138557e-02f, 2.01957986e-01f, -1.20367125e-01f, -8.51465669e-03f, 8.29780251e-02f, -1.20155066e-01f, -1.35978395e-02f, -3.93077284e-02f, -9.73798111e-02f,
  -1.29836693e-01f, 2.16861274e-02f, -1.84554145e-01f, -1.59662906e-02f, -1.54521555e-01f, -1.14956573e-01f, 6.83681965e-02f, 2.08260678e-02f, 6.98680116e-04f, -2.05367580e-02f,
  3.69130634e-02f, -1.66458450e-02f, 6.23291768e-02f, -5.90365939e-02f, -6.97124228e-02f, 2.20556315e-02f, 2.95564607e-02f, 2.84254868e-02f, -3.08676269e-02f, -1.84672698e-02f,
  1.07279252e-02f, 1.01055643e-02f, 1.74128124e-03f, -1.01842163e-02f, 2.94610132e-02f, -7.97281265e-02f, 9.91566759e-03f, 5.15845977e-02f, -1.91715769e-02f, -6.87594712e-02f,
  1.42108900e-02f, -5.00761643e-02f, 4.13942859e-02f, -4.37853001e-02f, -5.69616854e-02f, -3.58868390e-02f, -7.02842474e-02f, -4.06667367e-02f, 5.80185354e-02f, 2.33513582e-02f,
  1.21488072e-01f, -1.56660490e-02f, -7.55176246e-02f, -6.57312199e-02f, -1.66855305e-02f, -5.42546548e-02f, 3.15897120e-03f, -2.35791504e-02f, -6.50541708e-02f, 4.10936167e-03f,
  -7.91862048e-03f, -1.45617686e-02f, -4.57905699e-03f, -6.68088719e-02f, 3.18440609e-02f, -4.01060544e-02f, -4.16425280e-02f, -6.02683090e-02f, 2.87129148e-03f, -4.31512222e-02f,
  6.71430677e-02f, -2.90768780e-02f, 7.93690309e-02f, -5.20509444e-02f, 1.11061428e-02f, -1.12933274e-02f, -1.99344922e-02f, 1.26355216e-02f, 5.70100732e-03f, -1.21732904e-02f,
  1.98317781e-01f, 2.21151084e-01f, -1.38758421e-02f, 2.15631761e-02f, 2.65860986e-02f, 4.00962122e-02f, -3.96922007e-02f, -2.10475158e-02f, 1.24487527e-01f, -3.08450609e-02f,
  4.31896513e-03f, -4.87109870e-02f, 2.06450038e-02f, -5.42293210e-03f, 4.02226485e-02f, 5.40061779e-02f, -5.05667850e-02f, 5.01168706e-02f, 3.70987132e-02f, 7.54415765e-02f,
  2.11276859e-02f, 2.29697842e-02f, -6.57024160e-02f, -5.29464372e-02f, 3.97958942e-02f, 6.14006780e-02f, 9.42947902e-03f, 2.82453932e-02f, -1.95780955e-02f, -3.03597329e-03f,
  -2.77419060e-01f, 1.89882293e-02f, -7.63040334e-02f, -1.27971157e-01f, -8.49903524e-02f, -5.95012819e-03f, -1.06208391e-01f, -4.26144451e-02f, -1.06362514e-01f, 5.68196364e-02f,
  7.86344633e-02f, -1.42812341e-01f, 4.96093407e-02f, -8.52238387e-02f, -3.10057521e-01f, 5.50049283e-02f, -1.38272107e-01f, -4.95303385e-02f, -1.96324084e-02f, -3.67614776e-02f,
  2.22827279e-04f, 4.04947624e-02f, -3.42640653e-02f, 1.16474986e-01f, -4.40081432e-02f, 8.69197920e-02f, 5.73367849e-02f, 1.18350126e-01f, 3.76175791e-02f, -5.76687492e-02f,
  -1.34251937e-01f, -1.88911166e-02f, 4.19090204e-02f, -2.46042348e-02f, 3.07564773e-02f, -6.21339940e-02f, 4.81004454e-02f, -9.34872031e-02f, -1.94206946e-02f, -6.35264814e-02f,
  4.52452749e-02f, -8.47659111e-02f, 8.30935538e-02f, -2.08300333e-02f, -7.35188797e-02f, 2.24377438e-02f, -4.29369546e-02f, -6.94169179e-02f, 1.94186382e-02f, -9.41829849e-03f,
  -9.95174423e-03f, 2.31371876e-02f, 1.21315811e-02f, 2.07675882e-02f, 6.26224130e-02f, -6.84129074e-02f, -7.18722045e-02f, -1.31184142e-02f, 9.89818573e-03f, 2.37269569e-02f,
  -1.64202973e-02f, 3.04963998e-02f, -4.41839248e-02f, 5.91964088e-02f, -4.55612093e-02f, 2.08832901e-02f, -3.88093735e-03f, 4.79105823e-02f, 2.66573392e-02f, -1.69365499e-02f,
  -2.74582347e-03f, -1.88135505e-02f, -4.09852266e-02f, 2.10329834e-02f, 4.25764127e-03f, -3.14085148e-02f, 4.39363346e-02f, 6.78975657e-02f, -6.13167882e-02f, 2.08592135e-02f,
  -3.16439569e-02f, -1.43706314e-02f, -4.00366038e-02f, 7.54419640e-02f, -1.97452903e-02f, -5.75333973e-03f, 5.57187237e-02f, 3.22008878e-02f, 4.38808464e-02f, 3.76721770e-02f,
  3.84249873e-02f, 1.35295197e-01f, 1.02756126e-02f, 1.61659089e-03f, 3.59071302e-03f, 1.50948681e-03f, -6.35472164e-02f, 2.05199774e-02f, 3.75242531e-02f, 5.02623618e-03f,
  2.83120130e-03f, -6.05863892e-02f, -4.86010984e-02f, -3.90313789e-02f, 4.28356454e-02f, 3.70295383e-02f, 3.43693495e-02f, 5.12017198e-02f, 3.26766446e-02f, 1.93926040e-02f,
  3.61858830e-02f, -7.84683600e-03f, -5.91012351e-02f, 4.53911908e-02f, 2.25744694e-02f, 1.77156478e-02f, 2.82902513e-02f, -1.88962016e-02f, 8.16477537e-02f, -2.88091041e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.52849388e-02f, -5.93998469e-02f, 1.70837343e-02f, -7.42175207e-02f, -7.12512359e-02f, -1.00792773e-01f, -1.71783671e-01f, -1.52227294e-03f, 3.38211618e-02f, -4.18661609e-02f,
  -2.29890388e-03f, -1.31502196e-01f, 4.19168584e-02f, -1.12117216e-01f, 8.80241841e-02f, 1.60178497e-01f, -1.15901165e-01f, -4.08440009e-02f, -6.84366971e-02f, -2.22661328e-02f,
  -3.25677195e-03f, -1.49288148e-01f, -4.63983901e-02f, -7.61311576e-02f, -1.03179194e-01f, -3.35210860e-02f, -8.53165016e-02f, -4.44398671e-02f, -2.70927493e-02f, -3.06724142e-02f,
  5.28029315e-02f, 1.41722277e-01f, -1.86963361e-02f, 8.96137506e-02f, -6.39387593e-02f, -5.06931767e-02f, -2.75558271e-02f, 1.27173783e-02f, 3.06754280e-02f, 4.02131975e-02f,
  -9.73170698e-02f, 7.19198734e-02f, -9.25541967e-02f, -3.00521832e-02f, 8.46575648e-02f, -1.44083872e-02f, 1.05183190e-02f, 5.94593473e-02f, -5.49361967e-02f, 6.08081818e-02f,
  1.82092618e-02f, -2.62280963e-02f, 3.91477607e-02f, -7.09417537e-02f, -2.81213671e-02f, -5.87748587e-02f, -5.41295372e-02f, 4.79701534e-02f, 1.15043027e-02f, 6.27572462e-02f,
  -7.11059663e-03f, 1.47330230e-02f, 1.10842735e-02f, 3.85517441e-02f, -5.44455387e-02f, 7.56395757e-02f, 1.95746962e-02f, -5.77908307e-02f, 6.41906485e-02f, 4.34598885e-02f,
  5.64926825e-02f, -4.45127077e-02f, -6.69910684e-02f, -7.47188628e-02f, -4.23007719e-02f, -6.50247112e-02f, -7.54493102e-02f, 1.02247410e-02f, 2.69099455e-02f, 2.31789588e-03f,
  3.80551815e-02f, 4.14997078e-02f, -3.25759966e-03f, 6.24466911e-02f, -3.19182314e-02f, -8.35180134e-02f, -6.13271892e-02f, -1.47606982e-02f, -4.22048382e-02f, -3.22181685e-03f,
  7.81538337e-02f, -5.77375777e-02f, -5.70549667e-02f, 6.01100810e-02f, 8.17486122e-02f, -5.73298186e-02f, 2.90674027e-02f, 5.31165898e-02f, -2.64458936e-02f, 6.65660501e-02f,
  2.58340850e-03f, -1.43456720e-02f, -1.68932078e-03f, 6.37510866e-02f, -6.93197129e-03f, 7.28551373e-02f, 4.22441307e-03f, 4.87818196e-02f, 8.85290280e-03f, -1.08655661e-01f,
  3.36198285e-02f, -6.48454204e-02f, -1.62913988e-03f, 2.08506864e-02f, 6.66134953e-02f, -5.53677119e-02f, 7.71187851e-03f, -7.46930614e-02f, -6.96269944e-02f, -1.26343640e-02f,
  -2.93048173e-02f, -9.13447067e-02f, -5.94189465e-02f, -7.38589615e-02f, -2.24893028e-03f, 5.06278500e-02f, 4.33093198e-02f, -1.38542548e-01f, 2.66673528e-02f, 3.90376672e-02f,
  3.90054472e-02f, 5.65298321e-03f, -4.20206562e-02f, -4.00523879e-02f, 5.58335371e-02f, 5.44888005e-02f, 7.93070346e-02f, 3.28817070e-02f, 8.15158710e-02f, 2.98418030e-02f,
  -5.73206972e-03f, 9.69963744e-02f, 5.59097193e-02f, 7.07138516e-03f, 6.76361620e-02f, 7.53722270e-05f, -1.04875736e-01f, -8.75264332e-02f, -2.94238515e-02f, -1.23907207e-02f,
  9.72031709e-03f, -1.16892807e-01f, -1.56684369e-02f, -8.31755027e-02f, -2.52463110e-02f, 6.56361692e-03f, -3.60094160e-02f, 4.63154316e-02f, 6.34773588e-03f, -8.47785473e-02f,
  -1.63586829e-02f, 9.60102957e-03f, 3.98658030e-03f, 2.87542734e-02f, -2.84827147e-02f, -9.90462229e-02f, -7.05865920e-02f, 3.01563777e-02f, -4.32608984e-02f, 4.36750241e-02f,
  -1.21516502e-02f, -2.26628184e-02f, 6.87544718e-02f, 5.57752810e-02f, -5.01346141e-02f, -1.95441581e-02f, -6.90468252e-02f, 8.55607763e-02f, 5.65692745e-02f, 8.98640379e-02f,
  -5.80089688e-02f, -2.79675759e-02f, 5.52535765e-02f, 3.15398462e-02f, -3.22076790e-02f, -3.05223204e-02f, 1.06886201e-01f, -7.44251460e-02f, 3.44110727e-02f, 6.48819879e-02f,
  5.95867336e-02f, 5.68994954e-02f, 4.38450314e-02f, 3.46196406e-02f, -2.73049008e-02f, 1.16800535e-02f, -4.38196063e-02f, 8.08248520e-02f, 2.01592930e-02f, -5.09453155e-02f,
  6.30848557e-02f, 6.85563534e-02f, -5.39293960e-02f, 5.35867624e-02f, 6.86534420e-02f, -3.82836051e-02f, 8.84032324e-02f, -9.03955549e-02f, 1.94815267e-02f, 4.58111502e-02f,
  7.37471730e-02f, -1.12754256e-02f, 5.08346446e-02f, 7.45159686e-02f, 2.84015425e-02f, -2.48285197e-02f, 4.37532132e-03f, 7.63665065e-02f, -4.31867428e-02f, -4.97572795e-02f,
  4.99286577e-02f, 7.72988945e-02f, -9.02180374e-03f, 5.35951257e-02f, 8.31251219e-02f, -7.62886973e-03f, 7.58948177e-02f, 4.67586480e-02f, -2.09582876e-02f, -7.63564110e-02f,
  -9.89339575e-02f, 2.79194843e-02f, -5.85877970e-02f, -5.17982543e-02f, 8.61510262e-02f, 2.65092179e-02f, 7.59322336e-03f, 5.95119037e-02f, 9.15522575e-02f, -6.27266010e-03f,
  -2.51510739e-01f, -3.34524103e-02f, -5.06602637e-02f, -1.41891420e-01f, -1.27434760e-01f, 3.06163635e-02f, 1.35838345e-01f, -2.03726783e-01f, -6.07426278e-02f, 4.22634073e-02f,
  6.78050816e-02f, -1.21085281e-02f, 9.59242135e-02f, 1.04864210e-01f, -4.84592607e-03f, 1.96068153e-01f, 1.40015837e-02f, 6.38361424e-02f, 9.38830003e-02f, -6.33507296e-02f,
  6.34032041e-02f, 9.64639187e-02f, 1.90338165e-01f, 5.65726049e-02f, 6.41727298e-02f, 1.25105213e-02f, -1.00345790e-01f, 9.80428010e-02f, -3.23129594e-02f, 8.04453418e-02f,
  -1.68552592e-01f, -1.68317303e-01f, -1.42357528e-01f, -1.71103422e-02f, -1.06238507e-01f, -1.39191166e-01f, -1.24719925e-03f, 1.02136962e-01f, -3.85840274e-02f, 7.88546577e-02f,
  -8.94599259e-02f, -4.61686663e-02f, -8.41043070e-02f, 7.75253214e-03f, -3.91841084e-02f, 2.00441349e-02f, 7.81321600e-02f, 3.79760973e-02f, 2.93951184e-02f, 8.01545605e-02f,
  8.23370814e-02f, -6.73640445e-02f, -3.54338475e-02f, 6.74166530e-02f, 8.76307040e-02f, -2.13182215e-02f, 4.23332974e-02f, -4.86702360e-02f, -6.95445016e-02f, -4.45267484e-02f,
  3.49401496e-02f, 5.47562279e-02f, -2.35111415e-02f, -6.23186640e-02f, 3.18765901e-02f, -2.71464847e-02f, 4.12364118e-02f, -3.81442867e-02f, 8.22078660e-02f, -7.39708096e-02f,
  4.52156266e-04f, -5.08428924e-02f, -8.58064964e-02f, -2.98703741e-02f, -1.87293366e-02f, 4.66520637e-02f, 1.08876573e-02f, -1.03286259e-01f, 5.07630222e-02f, 2.00750902e-02f,
  5.36352443e-03f, -2.18688287e-02f, 4.12730388e-02f, -1.51782222e-02f, 2.24340288e-03f, -4.52229567e-02f, 8.61651897e-02f, -3.40442546e-02f, 5.88844009e-02f, -7.93206692e-03f,
  -2.02454492e-01f, -3.23112547e-01f, -5.95158972e-02f, -1.09062344e-01f, -8.30773339e-02f, -6.50471002e-02f, -9.38238204e-02f, -5.94364181e-02f, -1.13154039e-01f, -3.93333249e-02f,
  -2.92117917e-03f, 3.61139961e-02f, 5.52477664e-04f, 4.61380146e-02f, 4.74288352e-02f, -1.44276563e-02f, 1.79595854e-02f, 2.47244984e-02f, 2.08518878e-02f, 1.80720224e-03f,
  4.04995047e-02f, 3.66244465e-02f, 1.65858883e-02f, 7.45411441e-02f, -9.67234969e-02f, -1.00211650e-02f, -7.85984471e-02f, -9.64326113e-02f, 3.04787736e-02f, 5.88169135e-02f,
  -6.04374893e-02f, -2.05611065e-01f, 1.07864931e-01f, -1.01766132e-01f, -1.66912954e-02f, 6.06276914e-02f, 6.51818737e-02f, -1.23233534e-01f, -8.80514309e-02f, -2.44154558e-01f,
  -8.94019082e-02f, 1.13947958e-01f, 6.41106740e-02f, -1.86012566e-01f, 3.43679935e-01f, 1.89686745e-01f, -3.01777618e-03f, -4.81748655e-02f, 5.35480678e-02f, -3.06334477e-02f,
  -7.53974216e-03f, -6.23206310e-02f, 1.44169778e-01f, -1.12411954e-01f, -7.28227869e-02f, -6.68421760e-02f, -3.90524752e-02f, 9.83076077e-03f, -1.35430560e-01f, 7.51174837e-02f,
  -3.61024998e-02f, -5.08576930e-02f, 7.09913522e-02f, 7.33381929e-03f, -7.97857717e-02f, -5.83961606e-02f, 3.49306613e-02f, 1.15647957e-01f, -1.98935699e-02f, 3.53554846e-03f,
  6.16428442e-02f, -7.08771050e-02f, -2.86484174e-02f, -4.70696986e-02f, -8.87199864e-02f, -8.80702734e-02f, -3.19258645e-02f, -1.49499215e-02f, -6.78847507e-02f, 1.02143526e-01f,
  3.21022011e-02f, -1.92833580e-02f, -5.76998107e-02f, 6.07774705e-02f, 7.72112012e-02f, 2.76874825e-02f, 4.97777909e-02f, 1.15959421e-01f, -2.18392462e-02f, -8.06904882e-02f,
  9.32838395e-03f, 1.17991701e-01f, -7.80131817e-02f, -4.92374152e-02f, -3.73854674e-02f, -9.95421261e-02f, -6.98446631e-02f, 2.72929221e-02f, -6.03676029e-02f, -2.35388614e-02f,
  -1.08350776e-02f, 2.65883524e-02f, 1.57273635e-02f, -3.36604677e-02f, 1.38627896e-02f, -7.59840757e-02f, 2.61087436e-02f, -7.19259307e-02f, -3.15153189e-02f, 3.59996594e-02f,
  -2.91754175e-02f, 6.78142980e-02f, -1.21723106e-02f, 2.85568684e-02f, 3.71150374e-02f, 4.04325649e-02f, -7.70319104e-02f, -1.70170292e-02f, -7.36444741e-02f, 8.83298665e-02f,
  -1.82876736e-01f, -8.13379437e-02f, -5.45977382e-03f, -7.26794749e-02f, -7.93764144e-02f, 3.50558162e-02f, 4.14866284e-02f, -6.52532130e-02f, -9.15511325e-02f, 2.83668712e-02f,
  -1.98581852e-02f, -1.18524479e-02f, -5.62087707e-02f, -4.11883965e-02f, 6.18611462e-02f, -1.35772415e-02f, 1.13182738e-02f, 4.82915752e-02f, -5.21665029e-02f, -4.02721167e-02f,
  -2.12284233e-02f, 4.12979946e-02f, 7.00656697e-02f, 4.41635661e-02f, -6.79439306e-02f, -7.97884464e-02f, 2.37689130e-02f, 4.91516814e-02f, -5.57421483e-02f, -5.95690198e-02f,
  1.55265287e-01f, 8.50011781e-02f, 2.18932196e-01f, 2.36656472e-01f, -5.59206866e-02f, -2.86240965e-01f, -3.09618920e-01f, 4.13733348e-02f, -7.90988430e-02f, -1.97940826e-01f,
  -9.11807939e-02f, 1.32783502e-01f, -1.21449359e-01f, 2.33854204e-01f, -2.06471537e-03f, -1.94219761e-02f, 7.60474429e-02f, -3.92640121e-02f, 3.48838104e-04f, 9.09359232e-02f,
  1.28556684e-01f, 4.64200862e-02f, 1.98619366e-01f, 1.31199062e-01f, -1.41237332e-02f, 1.97966337e-01f, 4.90897372e-02f, -8.95052180e-02f, 2.01207802e-01f, 7.42990077e-02f,
  -5.19331098e-02f, 5.60110956e-02f, -5.37158409e-03f, 1.12888860e-02f, 5.58416285e-02f, -1.52943805e-01f, 2.52997829e-03f, -2.06895862e-02f, -2.30174363e-02f, -7.45509788e-02f,
  -6.26524240e-02f, 1.43744815e-02f, 3.61183174e-02f, 4.38881516e-02f, 6.35745283e-03f, 1.36705086e-01f, 2.33221948e-02f, 6.85365722e-02f, 2.14356519e-02f, 2.77707875e-02f,
  1.27201900e-01f, -5.56331575e-02f, 8.37641656e-02f, -1.78375468e-02f, 7.99066573e-02f, 5.42721525e-02f, -3.45038772e-02f, 1.04228444e-01f, -6.26557991e-02f, 2.59591024e-02f,
  -1.02812633e-01f, -6.14455678e-02f, -6.35150746e-02f, -2.94531882e-02f, -3.21841240e-02f, -9.48445871e-03f, 4.48054411e-02f, -7.22394958e-02f, 1.19687812e-02f, 5.31807467e-02f,
  -3.44398711e-03f, 6.62737265e-02f, 3.57718877e-02f, -1.10639870e-01f, 2.81935148e-02f, -2.94192303e-02f, -3.39708254e-02f, 4.81584854e-02f, 9.61670559e-03f, -1.43509936e-02f,
  2.54422594e-02f, -1.30337095e-02f, -3.53149660e-02f, -4.23047207e-02f, -4.01493482e-04f, -1.17879249e-02f, -4.34772372e-02f, 5.61435409e-02f, 3.66973318e-02f, 1.75593384e-02f,
  4.92899166e-03f, 7.61629129e-03f, -1.06137097e-01f, 5.24392538e-02f, 8.50837231e-02f, -1.50905065e-02f, 7.52249882e-02f, 9.79943126e-02f, 1.28759323e-02f, -9.43448171e-02f,
  -3.80842946e-02f, -9.66451094e-02f, 2.72433180e-02f, 2.43163127e-02f, 2.37089060e-02f, -2.35278495e-02f, 3.23286504e-02f, -4.20831004e-03f, -1.52664015e-03f, 5.56962471e-03f,
  -6.31226450e-02f, -1.05586618e-01f, 4.88452688e-02f, -4.61919084e-02f, -2.34582443e-02f, 3.81621718e-02f, -5.52444570e-02f, 3.77618745e-02f, 4.19852510e-02f, -4.99624908e-02f,
  1.04670420e-01f, 4.72769514e-02f, -2.18004752e-02f, 1.86891798e-02f, -1.45925209e-01f, -1.81633055e-01f, -9.86761898e-02f, -8.87852982e-02f, 1.74982823e-03f, 6.21814467e-02f,
  -1.33667171e-01f, 1.34722143e-01f, -1.18168809e-01f, 1.29354432e-01f, 1.00528963e-01f, -3.27368290e-03f, 9.54506770e-02f, 6.61215559e-02f, 2.85706613e-02f, 1.14400722e-01f,
  5.65144718e-02f, 1.05439730e-01f, -3.54474746e-02f, -5.22923954e-02f, 1.05325110e-01f, 4.46685478e-02f, 7.03436211e-02f, -7.12439045e-02f, 2.41344143e-02f, -5.63567085e-03f,
  -9.34378877e-02f, -3.17785181e-02f, 3.17733060e-03f, 4.39804755e-02f, -2.29355525e-02f, -3.37191075e-02f, 3.84538658e-02f, 8.19067657e-03f, 2.34599574e-03f, 1.02915682e-01f,
  1.15419976e-01f, -3.76376733e-02f, 1.88898519e-02f, 5.43204732e-02f, 7.71110281e-02f, 2.83101778e-02f, 7.39806965e-02f, 5.82921058e-02f, 1.79957747e-02f, 7.72200227e-02f,
  3.17605250e-02f, 1.06436364e-01f, -2.36588679e-02f, -7.58934394e-02f, -2.33747400e-02f, -9.90525261e-02f, -7.81606734e-02f, 5.08890748e-02f, 1.14010401e-01f, -5.88474683e-02f,
  1.30956367e-01f, -9.20611843e-02f, 4.93222401e-02f, 4.33396325e-02f, 2.72754319e-02f, 5.78609481e-02f, 1.87208317e-02f, 8.07260070e-03f, -7.39889890e-02f, -1.14353457e-02f,
  5.13441861e-02f, -6.15077764e-02f, 7.73356557e-02f, 1.36133423e-02f, -6.01917803e-02f, 2.01592073e-02f, -2.04261988e-02f, 4.27244371e-03f, -8.53652805e-02f, 1.06019445e-01f,
  -1.90701075e-02f, -9.48979184e-02f, 1.42737543e-02f, 8.94054829e-05f, -5.58537915e-02f, 5.56369275e-02f, 4.61763963e-02f, -2.41525155e-02f, -1.87996905e-02f, -8.40331391e-02f,
  5.75440712e-02f, 8.85661915e-02f, 9.74627659e-02f, 7.61281978e-03f, 5.96062699e-03f, -8.71542990e-02f, -4.93733175e-02f, 8.63583386e-02f, -5.34652546e-02f, 9.87404659e-02f,
  -7.56628141e-02f, 2.65372973e-02f, -4.52565998e-02f, 8.20549726e-02f, -3.69532108e-02f, -7.00190896e-03f, -4.25826944e-02f, 5.10885082e-02f, 3.95909920e-02f, 3.67758311e-02f,
  4.97625433e-02f, 1.26944762e-02f, -7.94353336e-02f, 1.14276400e-03f, -8.72204360e-03f, -1.06565515e-02f, -7.16419006e-03f, -1.93896685e-02f, -6.23912364e-02f, -6.06589504e-02f,
  -2.97579646e-01f, 2.43458170e-02f, 5.89515418e-02f, -1.36031196e-01f, -8.96214098e-02f, 1.72241494e-01f, 1.52778178e-01f, -2.92056557e-02f, -1.48678735e-01f, 4.52202298e-02f,
  4.03688326e-02f, -7.42084309e-02f, 1.24864861e-01f, 1.42040536e-01f, 7.67564029e-02f, 2.09395707e-01f, 1.20169371e-01f, -3.44254561e-02f, -1.67504642e-02f, -8.92864838e-02f,
  -1.02826580e-01f, 1.60640217e-02f, 2.18392953e-01f, -1.00085542e-01f, -3.44276638e-03f, -1.13542438e-01f, 3.21658663e-02f, 6.31979778e-02f, -2.23172940e-02f, 4.13856618e-02f,
  -5.56347147e-02f, -1.40892312e-01f, -2.65864544e-02f, -2.00699233e-02f, 2.20764764e-02f, 3.39700691e-02f, -2.56760493e-02f, -8.30919668e-03f, 2.62930174e-03f, -3.70181277e-02f,
  1.45903286e-02f, 2.51954198e-02f, 1.13949524e-02f, -4.28451747e-02f, -4.14207056e-02f, -5.84891289e-02f, 7.48945028e-03f, 1.69824697e-02f, -3.72517444e-02f, 3.07751466e-02f,
  9.53432843e-02f, 5.54869734e-02f, 2.02549342e-03f, 2.20256783e-02f, 3.94990817e-02f, 6.06857240e-03f, -5.27309887e-02f, 3.28575522e-02f, -4.02358919e-02f, -7.22565576e-02f,
  1.57365184e-02f, -3.64010856e-02f, -2.70629842e-02f, 1.10687697e-02f, -2.65837591e-02f, -1.47677464e-02f, 7.33392611e-02f, 6.93515539e-02f, -5.93000352e-02f, -4.55368496e-02f,
  3.90301794e-02f, -6.31819591e-02f, 2.29296144e-02f, 8.07503760e-02f, -5.81208803e-02f, -7.75281042e-02f, 1.04014069e-01f, -1.62337217e-02f, 3.44361104e-02f, -1.63383912e-02f,
  -3.09922472e-02f, -2.91314274e-02f, -2.39797384e-02f, -5.05842678e-02f, 3.98377739e-02f, 8.33899006e-02f, -3.03742867e-02f, -3.31885405e-02f, 3.64002921e-02f, 6.51380941e-02f,
  -5.14378287e-02f, -1.99943081e-01f, 7.54763186e-03f, 5.96929304e-02f, 8.46727043e-02f, -3.08212116e-02f, -2.50484888e-02f, 1.73957814e-02f, 3.19921486e-02f, 7.46556744e-02f,
  -3.33693251e-02f, -8.01841021e-02f, -5.54189784e-03f, 7.96410441e-02f, -7.77349100e-02f, -2.76473276e-02f, -3.64779420e-02f, -8.82048830e-02f, 3.69684994e-02f, 4.09497768e-02f,
  6.06460460e-02f, -1.15148030e-01f, 4.73974533e-02f, 2.74861325e-02f, -7.48074204e-02f, 4.44400422e-02f, -9.15320739e-02f, 3.03801708e-02f, 3.39058824e-02f, 8.33194330e-02f,
  2.84133404e-02f, -2.06281319e-01f, 3.60002965e-02f, 6.31059036e-02f, -5.54141104e-02f, -3.41532454e-02f, 2.09810257e-01f, 2.94444393e-02f, -1.66889690e-02f, -6.32138327e-02f,
  9.49136466e-02f, -7.73088038e-02f, 5.66313453e-02f, 4.52179695e-03f, 8.96379799e-02f, -4.08873148e-02f, 7.15030283e-02f, -2.46572476e-02f, 2.54177339e-02f, 3.04966066e-02f,
  1.00296818e-01f, -4.77682352e-02f, 3.56411226e-02f, -6.28800914e-02f, 2.52172779e-02f, 2.52397563e-02f, -5.81375137e-02f, 9.99408588e-02f, 7.92504922e-02f, 4.79803830e-02f,
  9.79102999e-02f, 7.94659033e-02f, 1.44632366e-02f, 2.37655565e-02f, 3.96113843e-02f, -5.30443341e-02f, 3.32143046e-02f, 8.53312537e-02f, 4.44296673e-02f, -6.16898702e-04f,
  6.33634254e-02f, 2.24844143e-02f, -4.84033339e-02f, 4.34971936e-02f, 1.03411376e-02f, -2.69579794e-02f, -8.35864469e-02f, 9.98141617e-02f, 1.49637330e-02f, -2.84189526e-02f,
  -5.41890599e-02f, 2.38852706e-02f, -9.84623209e-02f, -1.16069295e-01f, -9.02134031e-02f, -1.58157516e-02f, -9.12938714e-02f, -4.62348573e-02f, -2.85895187e-02f, -4.08624019e-03f,
  2.93658096e-02f, -1.07817352e-02f, -6.20857626e-03f, 1.03018686e-01f, 3.11175324e-02f, 7.50017315e-02f, 6.48360923e-02f, 3.14839035e-02f, -7.76927099e-02f, 5.55277395e-04f,
  -6.00670017e-02f, 5.11661470e-02f, -1.07100897e-01f, 2.42991541e-02f, -1.66603848e-02f, -4.88227047e-02f, -3.51711884e-02f, 2.94242855e-02f, -5.57265803e-02f, -3.93548002e-03f,
  -1.27326315e-02f, -1.42151006e-02f, -4.99764271e-02f, 1.61753371e-02f, -6.15195818e-02f, -5.74771725e-02f, 2.50163134e-02f, -7.46538714e-02f, 1.08445168e-01f, -1.52716804e-02f,
  -5.12769185e-02f, -2.04528511e-01f, -3.21180411e-02f, 5.91118401e-03f, 6.28616288e-02f, -9.27639529e-02f, 3.04762572e-02f, -9.34632644e-02f, -4.42825817e-02f, -1.20685482e-02f,
  2.26239152e-02f, -4.30639423e-02f, -7.49238282e-02f, 8.36548209e-02f, -5.18156439e-02f, 8.59999135e-02f, 6.15975522e-02f, -6.66946247e-02f, -5.59488796e-02f, -3.71176191e-02f,
  -1.08572945e-01f, -1.78534612e-02f, 3.06261890e-02f, -6.57937005e-02f, -2.09066570e-02f, 8.19501653e-02f, -8.21349397e-02f, -4.62547094e-02f, -7.86337703e-02f, 2.73807086e-02f,
  -2.27943603e-02f, -1.23642892e-01f, 1.44002348e-01f, 2.85898261e-02f, 3.74926180e-02f, -2.50588004e-02f, -4.16791737e-02f, -4.45471555e-02f, 2.06026831e-03f, -1.31074771e-01f,
  -8.06245133e-02f, -8.63796007e-03f, -3.36910523e-02f, -1.15169093e-01f, 7.13088587e-02f, 9.97757092e-02f, -2.94815302e-02f, 6.43372387e-02f, 7.02819824e-02f, -4.89601418e-02f,
  3.15711163e-02f, -8.34267512e-02f, 1.09386202e-02f, -8.04389715e-02f, -9.84249264e-02f, 1.71993226e-02f, 3.45190763e-02f, 2.89744847e-02f, 3.16624567e-02f, -5.30172931e-03f,
  3.26478109e-02f, -2.66903397e-02f, 6.39720708e-02f, 7.47808442e-02f, 3.55886202e-03f, -5.12819849e-02f, -4.44922782e-02f, 5.67501597e-02f, 9.06501263e-02f, 4.93914597e-02f,
  -2.70744152e-02f, 2.72598173e-02f, 2.00225804e-02f, 9.53536704e-02f, -4.57845703e-02f, 5.01354635e-02f, 6.65599778e-02f, -3.34062688e-02f, 2.14040671e-02f, 7.44215623e-02f,
  -2.46499032e-02f, 6.66887686e-02f, -3.87620218e-02f, -8.96641761e-02f, 5.91636859e-02f, 5.58410510e-02f, -5.70978969e-02f, 9.67405811e-02f, -2.55086012e-02f, 1.64129119e-02f,
  -7.55680948e-02f, -6.34196550e-02f, -1.16592847e-01f, -7.35467672e-02f, -3.26521136e-02f, 5.10992892e-02f, 7.67998071e-03f, 6.16532825e-02f, 4.94661592e-02f, 3.22718807e-02f,
  -1.15104252e-02f, -4.16993871e-02f, 7.54963011e-02f, 6.54171556e-02f, 5.72170801e-02f, -4.38103639e-02f, 1.63087919e-02f, 9.14848372e-02f, -7.67749697e-02f, -4.05448601e-02f,
  -4.67737839e-02f, 2.67739277e-02f, 5.26161231e-02f, 5.80274202e-02f, 7.75170326e-03f, 5.76623045e-02f, -3.04855686e-02f, -6.98669851e-02f, -7.08203837e-02f, 4.02369164e-02f,
  7.61276633e-02f, -1.16428971e-01f, 3.97273079e-02f, 7.35099688e-02f, -6.12432435e-02f, 3.82844731e-02f, -3.26322429e-02f, 6.64317533e-02f, -6.41927542e-03f, -1.03164509e-01f,
  5.48127741e-02f, 3.59132476e-02f, 8.26817751e-02f, 1.67853348e-02f, -4.23060656e-02f, 2.57428307e-02f, -1.26696043e-02f, -1.24117723e-02f, 2.79613361e-02f, -3.17185856e-02f,
  3.51353362e-02f, 1.19556077e-02f, 3.80643830e-03f, -9.97201428e-02f, -1.44866789e-02f, 6.67763799e-02f, -3.44030596e-02f, -2.61317808e-02f, -2.57666335e-02f, 9.33160931e-02f,
  -4.09172744e-01f, 1.93396449e-01f, -6.99578226e-02f, -1.73435256e-01f, 1.60628185e-02f, -2.65085064e-02f, -3.62993814e-02f, 7.61702880e-02f, 1.02084130e-03f, 2.43619293e-01f,
  1.10857807e-01f, -1.08522005e-01f, 9.25859511e-02f, 1.57995373e-02f, -1.25498772e-01f, 5.04401922e-02f, -1.00838356e-01f, -1.12083450e-01f, -2.03227345e-02f, 3.50247584e-02f,
  -8.63544196e-02f, -2.46200189e-02f, 6.06923029e-02f, 1.28193244e-01f, -6.63315430e-02f, -8.05252641e-02f, 6.63798228e-02f, 6.42354116e-02f, -5.94133586e-02f, 2.23289449e-02f,
  -1.74516831e-02f, -4.24544298e-04f, -9.84071419e-02f, -8.99319947e-02f, -1.63552716e-01f, -1.73966736e-02f, -3.87212038e-02f, -5.48037030e-02f, -1.01195917e-01f, -4.35309894e-02f,
  -6.42149448e-02f, 1.21558718e-01f, -2.18785275e-02f, -1.54993860e-02f, 3.88929509e-02f, 8.35372508e-02f, -4.30926941e-02f, -4.58581038e-02f, 4.25563492e-02f, -1.24717783e-02f,
  9.45103839e-02f, -5.03970422e-02f, 4.57110873e-04f, -4.97442000e-02f, -4.86925105e-03f, 6.74989074e-02f, -1.60665326e-02f, 5.22588007e-02f, 1.40912067e-02f, 2.19448432e-02f,
  1.28658721e-02f, 1.82991382e-02f, 7.85732176e-03f, -3.28078568e-02f, 6.78598657e-02f, 4.05123383e-02f, -1.23851160e-02f, 3.06926053e-02f, 4.81246412e-02f, 4.48665768e-02f,
  -4.35638539e-02f, 1.10447735e-01f, 3.14010195e-02f, -4.39852402e-02f, 2.18433607e-02f, -8.21884349e-02f, 4.08511721e-02f, -5.56282736e-02f, 7.26212095e-03f, 5.01584634e-02f,
  -5.74407838e-02f, 3.23773958e-02f, -4.16143760e-02f, 4.55518551e-02f, 1.69331860e-02f, -3.14058587e-02f, -5.06946035e-02f, -4.23735641e-02f, -5.03437668e-02f, -3.39383595e-02f,
  -1.39157340e-01f, -7.44131878e-02f, -1.64555814e-02f, -7.33651640e-03f, 4.72436696e-02f, -2.86538862e-02f, -5.87484203e-02f, -1.28470371e-02f, -1.08364429e-02f, -5.48962131e-02f,
  -9.89810899e-02f, 5.68154939e-02f, -3.86274494e-02f, -1.12002986e-02f, 2.19728164e-02f, -2.73712305e-03f, 5.35387546e-02f, -1.07176647e-01f, -2.92482190e-02f, 5.23835458e-02f,
  3.60463075e-02f, 1.96370613e-02f, -5.19022625e-03f, -6.12679161e-02f, 1.55898230e-02f, 6.96983784e-02f, -1.60030164e-02f, 4.07817326e-02f, 1.07272882e-02f, 3.75359766e-02f,
  -2.14654192e-01f, 9.76312086e-02f, -1.96404442e-01f, -1.51911587e-01f, -1.55949630e-02f, -3.48350555e-01f, -2.31900528e-01f, -4.89383005e-02f, -3.07524819e-02f, 8.02332908e-03f,
  -1.30130216e-01f, 1.03589207e-01f, 1.51251912e-01f, -1.32336855e-01f, -2.05280595e-02f, 1.94999188e-01f, -2.60491639e-01f, -2.44341239e-01f, 1.95949804e-02f, -2.08595887e-01f,
  -5.10263704e-02f, -2.22235069e-01f, -9.00239572e-02f, -3.92853431e-02f, -2.34664783e-01f, 2.18469836e-02f, -8.66880715e-02f, 1.20491602e-01f, -2.08512247e-01f, -9.97545943e-03f,
  -6.93643764e-02f, 2.57011592e-01f, 7.69200623e-02f, 1.72692705e-02f, -1.03141248e-01f, -9.09874067e-02f, -8.02441463e-02f, -1.40269427e-02f, -5.68818534e-04f, -8.34358707e-02f,
  -2.36193780e-02f, -1.08857341e-02f, 2.26916466e-02f, 7.93337375e-02f, -1.08836047e-01f, -4.48837094e-02f, -7.33207986e-02f, -1.26010448e-01f, 8.05209503e-02f, 1.81182604e-02f,
  4.66065146e-02f, 2.98496000e-02f, -1.02297567e-01f, -3.50804329e-02f, -7.53211509e-03f, 9.57772136e-02f, -7.06489757e-02f, -1.08822547e-01f, -7.13737160e-02f, 2.83335689e-02f,
  -1.98147669e-02f, -5.70205599e-02f, 5.60900709e-03f, 2.18137372e-02f, -5.23907356e-02f, -5.73999584e-02f, 7.30720982e-02f, -4.75132884e-03f, 4.95134853e-02f, 4.84333932e-03f,
  -3.39397416e-02f, -1.87957417e-02f, 7.33955111e-03f, 2.81909164e-02f, -3.55158858e-02f, 2.06613373e-02f, 8.02318659e-03f, 9.51634645e-02f, -6.14092238e-02f, -6.72783256e-02f,
  -1.51793184e-02f, -5.46465106e-02f, 1.72526808e-03f, 1.75621361e-02f, -4.30565812e-02f, 8.22610408e-02f, 2.18749102e-02f, 4.38246801e-02f, 8.00915621e-03f, -1.52618494e-02f,
  -8.45483318e-02f, -1.08477466e-01f, 1.26112252e-01f, -4.58918475e-02f, 6.24827668e-02f, -9.32448879e-02f, 1.01670116e-01f, -1.91288582e-05f, -3.12186554e-02f, -2.10425854e-02f,
  -1.39055625e-01f, -6.29977360e-02f, -9.62656140e-02f, 4.11858670e-02f, -2.93861981e-02f, -4.61138301e-02f, -6.85022771e-03f, -2.08316520e-02f, -3.26234065e-02f, -9.10599306e-02f,
  -6.52187094e-02f, 5.56847863e-02f, -6.03198707e-02f, -1.29156522e-02f, -8.47151503e-02f, -1.12681471e-01f, -2.98554469e-02f, 6.52583316e-02f, 2.68395618e-02f, -5.09841889e-02f,
  2.85177499e-01f, 1.58645716e-02f, 2.46554196e-01f, 3.46959502e-01f, -2.46559083e-02f, -1.22364312e-02f, 4.01459597e-02f, -3.29292682e-03f, 7.00557157e-02f, -1.54178023e-01f,
  6.50456408e-03f, 1.59207925e-01f, -1.56329527e-01f, 1.13624752e-01f, 8.92696902e-03f, -2.35820517e-01f, 4.79875356e-02f, 9.49596688e-02f, -7.51026124e-02f, 3.25343013e-03f,
  1.35822818e-01f, -3.16237174e-02f, 3.31628993e-02f, 5.13136201e-03f, 2.21092194e-01f, 2.12814227e-01f, -5.49923889e-02f, -1.02280471e-02f, 5.80155589e-02f, -8.12933967e-03f,
  -7.58322030e-02f, 4.69911918e-02f, 1.00419760e-01f, -4.54599336e-02f, -7.23717362e-02f, 5.86887496e-03f, 1.48099456e-02f, -1.19192339e-01f, -2.56106220e-02f, 6.04171865e-02f,
  2.37162225e-02f, -2.75884494e-02f, 4.23520384e-03f, 9.11109522e-03f, -3.54097523e-02f, 6.77193562e-03f, -4.32019159e-02f, -1.20368809e-03f, 1.70961525e-02f, 2.35622413e-02f,
  9.31055769e-02f, 2.27515604e-02f, 8.70604515e-02f, -2.72380337e-02f, 9.88485366e-02f, 4.31242734e-02f, -3.33985053e-02f, 3.89066711e-02f, -1.27849227e-03f, 9.14392620e-02f,
  9.07082185e-02f, -3.31691876e-02f, -4.53440379e-03f, -4.59736353e-03f, -4.18696925e-02f, 3.31953377e-03f, 3.45471911e-02f, -3.38458712e-03f, 4.04990762e-02f, -2.61822361e-02f,
  -4.38303081e-03f, 2.06398051e-02f, 1.16989436e-02f, -7.45435059e-02f, 3.72445919e-02f, 5.62036335e-02f, 1.47483945e-02f, -8.49194750e-02f, 2.10072137e-02f, 3.77612710e-02f,
  2.38444805e-02f, 4.61807102e-02f, 3.63584571e-02f, -2.22728364e-02f, -1.31117338e-02f, -7.11872056e-02f, -6.99035302e-02f, -5.63971102e-02f, 2.81481929e-02f, -9.11614075e-02f,
  -1.10376917e-01f, -1.85574263e-01f, 5.47726601e-02f, -2.10928321e-02f, -1.80380344e-02f, -4.29431722e-02f, -6.14805967e-02f, 9.20298100e-02f, -1.05704218e-01f, -1.00539647e-01f,
  -2.70017944e-02f, -2.81919036e-02f, 1.22847473e-02f, -5.19728661e-02f, -3.79367508e-02f, -8.47289786e-02f, 4.74325521e-03f, 4.66799065e-02f, 5.50371036e-02f, -1.54306656e-02f,
  -3.51415239e-02f, -6.15746900e-02f, -5.12820072e-02f, 1.30211905e-01f, -3.20141241e-02f, 1.24456491e-02f, 6.17438443e-02f, 5.20741120e-02f, -1.69028565e-02f, -1.24393441e-02f,
  -2.87389755e-01f, 8.20391625e-02f, 1.59594819e-01f, 1.66699011e-02f, -1.34593382e-01f, 2.38601908e-01f, 3.61770868e-01f, -1.89173520e-01f, -1.87294204e-02f, 2.44956929e-02f,
  -2.60726064e-02f, 2.05224201e-01f, 2.23292187e-01f, 1.67970344e-01f, 3.07312012e-01f, 2.21551299e-01f, -3.61693092e-03f, 1.63438976e-01f, -7.11732581e-02f, -1.70440108e-01f,
  -1.38264552e-01f, -1.53654963e-01f, 1.76904202e-02f, -2.14566126e-01f, -1.06113926e-01f, -1.80975109e-01f, -2.48188935e-02f, 6.77017961e-03f, -1.31073803e-01f, 1.65749013e-01f,
  -1.27493814e-02f, -1.78914249e-01f, -2.71898527e-02f, -4.81269136e-02f, 4.78082150e-02f, -8.30288231e-02f, -2.49626897e-02f, 6.18936643e-02f, -1.20898969e-01f, -7.52121508e-02f,
  -1.66760646e-02f, 2.55736895e-02f, -2.42511984e-02f, -1.55817457e-02f, -5.95684648e-02f, -5.90004474e-02f, -7.32979253e-02f, -6.14520088e-02f, -2.77897529e-02f, -1.02110403e-02f,
  -3.32047008e-02f, -4.05386686e-02f, 6.33215606e-02f, 5.47155850e-02f, -6.64874837e-02f, -2.48823054e-02f, 1.15848444e-01f, 7.43241608e-02f, -3.68560106e-02f, 4.48185764e-02f,
  -2.11141910e-03f, 4.97857332e-02f, -9.06347111e-02f, -5.35013760e-03f, 8.79054964e-02f, -1.30762300e-02f, -5.61151542e-02f, 2.51184385e-02f, 7.28292540e-02f, -3.95825431e-02f,
  -6.99613839e-02f, -6.55233860e-02f, -8.28633904e-02f, -3.03645395e-02f, 3.57284099e-02f, 9.86347347e-03f, -4.41167951e-02f, 2.76286118e-02f, -7.01191276e-02f, 4.80437689e-02f,
  4.06126976e-02f, -3.28587438e-03f, -8.66357144e-03f, -1.83636975e-02f, 1.02713956e-02f, 9.61289462e-03f, -1.70667898e-02f, 7.22871022e-03f, -5.67627698e-02f, 1.05198026e-01f,
  5.59483357e-02f, 1.38910070e-01f, -4.45486382e-02f, -7.69450366e-02f, -1.69728771e-02f, -7.31580928e-02f, 2.68570129e-02f, -2.17083725e-03f, 9.04291645e-02f, -2.44437959e-02f,
  -4.31659520e-02f, 3.64977540e-03f, -7.02288002e-02f, 6.00366294e-02f, 5.67548312e-02f, -2.82962862e-02f, 5.60503155e-02f, 3.86616178e-02f, 4.54026926e-03f, -5.06395847e-02f,
  -9.25923139e-02f, 4.41923440e-02f, -5.19884471e-03f, 2.11713798e-02f, -7.88207725e-02f, -3.07979677e-02f, 1.07599422e-02f, 3.82073261e-02f, -4.59419265e-02f, 8.08654726e-02f,
  2.63409559e-02f, -2.06221431e-01f, -1.70302853e-01f, -1.64914370e-01f, -5.16060516e-02f, -1.47338316e-01f, -1.87289923e-01f, -1.92387402e-01f, -7.79224485e-02f, -1.88188583e-01f,
  -1.04032442e-01f, 3.55427898e-02f, 7.77828321e-02f, -6.35351017e-02f, 2.54168361e-01f, 1.07550003e-01f, -8.75649005e-02f, -4.53647263e-02f, 7.26327524e-02f, -1.97540626e-01f,
  2.88366396e-02f, -1.33317232e-01f, -7.19102984e-03f, -2.24599428e-02f, -8.41137096e-02f, -1.17521361e-01f, 1.61741339e-02f, 2.32381821e-02f, -1.59281909e-01f, 8.22589174e-02f,
  2.04946827e-02f, -4.06715870e-02f, -5.42950481e-02f, -5.16519882e-02f, -4.78346609e-02f, 4.79717404e-02f, -6.28040880e-02f, 2.88432706e-02f, 2.11356767e-02f, -7.20168203e-02f,
  -3.13483849e-02f, 8.21293052e-03f, 4.25395407e-02f, 3.48379947e-02f, 4.65701371e-02f, -1.04879670e-01f, 5.23764407e-03f, 3.88433374e-02f, -6.45610169e-02f, -8.75569880e-02f,
  -9.65000503e-03f, 6.77315751e-03f, -2.61688977e-02f, -7.05158934e-02f, -5.75207993e-02f, 1.30981123e-02f, -3.55485752e-02f, 5.56051247e-02f, 2.07951497e-02f, 4.83893901e-02f,
  -8.27052891e-02f, 2.51910724e-02f, 1.68540515e-02f, 1.76072540e-03f, 1.48327183e-02f, -2.43749022e-02f, -5.61242066e-02f, -3.71478833e-02f, -6.63170889e-02f, 5.29728644e-02f,
  -8.80022421e-02f, -8.22193474e-02f, 4.37113345e-02f, -1.42714772e-02f, 1.25010982e-02f, -8.57516974e-02f, 7.93486387e-02f, -4.25765775e-02f, 2.75321379e-02f, 5.38562797e-02f,
  1.00947790e-01f, 7.51760090e-03f, 3.39100771e-02f, -8.62547383e-02f, 3.99016291e-02f, 5.18950373e-02f, -1.97138786e-02f, 4.14600521e-02f, -4.52115014e-03f, -5.41924611e-02f,
  -5.78190759e-02f, -1.84506223e-01f, -3.15490924e-02f, 4.74152341e-02f, 9.57427174e-03f, 3.07507105e-02f, 3.91531363e-02f, 4.59299460e-02f, 1.97140202e-02f, -5.99378580e-03f,
  -3.96946818e-02f, 4.51399162e-02f, 8.08088332e-02f, -7.37332255e-02f, 5.98655976e-02f, -1.05194658e-01f, 1.79661550e-02f, 6.07920587e-02f, -7.72850290e-02f, -1.60560403e-02f,
  7.67433736e-03f, -6.56176507e-02f, 2.97787730e-02f, -2.30933935e-03f, -6.30133972e-02f, 3.80134583e-02f, 1.18664615e-02f, -6.09511957e-02f, -1.85018461e-02f, -6.86529353e-02f,
  1.04289167e-01f, 4.97295149e-02f, -1.76695678e-02f, 6.36955649e-02f, 2.00669691e-02f, -3.62980403e-02f, 3.73898856e-02f, -5.52809471e-03f, -1.19411657e-02f, 1.12226885e-02f,
  3.84040847e-02f, 2.82019861e-02f, 4.88376804e-02f, 7.70778861e-03f, 7.59533420e-02f, -1.18149132e-01f, -8.79127416e-04f, -8.22396427e-02f, -2.77973078e-02f, 9.95503142e-02f,
  2.57077180e-02f, 1.03497177e-01f, -1.32910758e-02f, 9.74698737e-03f, -6.87170262e-03f, 8.78883824e-02f, -1.11467147e-03f, 6.48454239e-04f, -2.07524113e-02f, 5.30452915e-02f,
  -6.14399761e-02f, 5.73277660e-02f, -1.14132732e-03f, -1.83045398e-02f, -8.12189654e-03f, 2.66656801e-02f, 6.81161061e-02f, -8.06252733e-02f, -2.70698015e-02f, 3.76144648e-02f,
  4.11305986e-02f, 1.10170292e-02f, -1.90910306e-02f, 2.07803436e-02f, 2.93718036e-02f, -6.00256473e-02f, 1.42412614e-02f, -1.67763475e-02f, 7.59550259e-02f, -2.81807985e-02f,
  -4.19064648e-02f, 2.36991197e-02f, 4.18343581e-02f, -3.74141112e-02f, -1.98480319e-02f, -8.34605247e-02f, 6.74924105e-02f, 8.00822526e-02f, 7.93884918e-02f, 2.62079574e-02f,
  -3.83255780e-02f, 8.35976005e-02f, -4.04064320e-02f, 9.47869010e-03f, 6.87194094e-02f, 3.81469615e-02f, 4.09948826e-02f, -7.70006776e-02f, -4.02700827e-02f, -7.68686319e-03f,
  8.19206331e-03f, 6.73779473e-02f, -3.78729738e-02f, -3.36944424e-02f, 2.21528811e-03f, 1.55139649e-02f, -5.93918562e-02f, 9.35512129e-03f, 4.16947827e-02f, -7.85292760e-02f,
  -5.17839193e-02f, 7.72184879e-02f, 8.69653840e-03f, -3.07055861e-02f, -8.75571072e-02f, -5.95872551e-02f, 4.69008908e-02f, -6.94476441e-02f, -4.98727970e-02f, 4.10993621e-02f,
  -8.09773058e-02f, -1.14812830e-03f, -7.58293420e-02f, 4.80030254e-02f, -5.15347049e-02f, 2.58229813e-03f, -2.97374986e-02f, -4.09772471e-02f, 1.60496067e-02f, -2.35990360e-02f,
  -4.43165377e-02f, 2.12395787e-02f, -4.53591198e-02f, -2.59809382e-02f, -3.38178016e-02f, -4.83687073e-02f, -2.82905903e-02f, 1.16489769e-03f, -1.90728642e-02f, -5.81009239e-02f,
  6.47899881e-02f, 5.67020401e-02f, 5.78711331e-02f, -4.50283214e-02f, 5.86227924e-02f, -5.57679348e-02f, 5.42334244e-02f, -1.24616520e-02f, 6.23698458e-02f, 4.97777835e-02f,
  1.73853725e-01f, -3.17321122e-01f, -1.75266922e-01f, 1.09258763e-01f, 2.10122645e-01f, 2.02103972e-01f, 7.53573179e-02f, 6.50947392e-02f, 2.97135245e-02f, -7.84190595e-02f,
  1.18421704e-01f, -1.07521780e-01f, -1.46684393e-01f, 6.29806593e-02f, 2.15745881e-01f, -1.99245825e-01f, 1.14114344e-01f, 2.30131354e-02f, -3.71214785e-02f, -7.08428100e-02f,
  5.51976152e-02f, 2.36274704e-01f, -1.19932026e-01f, 5.02757020e-02f, 1.12712272e-01f, -2.21368410e-02f, 1.08930893e-01f, -7.93782547e-02f, 1.50204837e-01f, 8.33913237e-02f,
  4.01216932e-02f, -1.32398874e-01f, 2.43104212e-02f, -5.69609031e-02f, 2.62797996e-02f, -7.03411996e-02f, 5.57655618e-02f, 3.00221751e-03f, 1.49588315e-02f, -5.57013638e-02f,
  -3.79207209e-02f, 4.45450023e-02f, 2.35007703e-02f, 7.70407915e-02f, -4.22601290e-02f, 5.87411895e-02f, 3.94143388e-02f, -4.22635227e-02f, 1.88208222e-02f, -4.83169444e-02f,
  -5.55232652e-02f, -1.00831799e-01f, -6.57635916e-04f, -5.57577796e-03f, 2.97288708e-02f, 1.53275020e-03f, -6.50223941e-02f, -4.90594581e-02f, 5.08436300e-02f, -7.71066248e-02f,
  4.35051732e-02f, -5.95391765e-02f, -1.15616191e-02f, 2.98764985e-02f, 2.53997035e-02f, 5.70538128e-03f, 1.69759488e-03f, 4.84760851e-02f, 3.77577655e-02f, 8.31475183e-02f,
  6.63818931e-03f, 2.13763453e-02f, -2.16605589e-02f, -9.22224391e-03f, -1.85672939e-02f, -1.91619433e-02f, -5.66081284e-03f, 6.00310490e-02f, -3.10666393e-03f, -4.71253647e-03f,
  -2.54778229e-02f, 5.63574508e-02f, 4.81999032e-02f, 1.07372226e-02f, -4.00669500e-02f, 8.79062042e-02f, 1.07202660e-02f, -4.58434708e-02f, -3.49112228e-02f, -1.39380759e-02f,
  6.25797138e-02f, -1.82575256e-01f, -5.43789081e-02f, -5.44736311e-02f, -8.00774619e-02f, 4.54371274e-02f, -6.92442581e-02f, 5.00502549e-02f, 3.00027411e-02f, -4.72935550e-02f,
  4.21615653e-02f, 3.70622091e-02f, -5.92728704e-02f, 5.76564446e-02f, 1.59355756e-02f, -5.93007123e-03f, -5.70873804e-02f, 8.53455141e-02f, 2.89520994e-02f, 4.50301394e-02f,
  1.92002393e-02f, 5.49547821e-02f, -6.60862848e-02f, -8.32829066e-03f, -2.52995770e-02f, -7.90698305e-02f, -6.04968471e-03f, 3.15004215e-02f, -2.18260102e-02f, 3.61714587e-02f,
  -3.17879394e-02f, -6.17306866e-02f, -1.06527522e-01f, 1.45932138e-02f, 1.11747988e-01f, -7.46719837e-02f, 4.49209139e-02f, -2.59883311e-02f, 6.55175894e-02f, 5.79890907e-02f,
  -4.47083265e-03f, 1.46138640e-02f, -2.95741372e-02f, -1.44925103e-01f, -3.15826293e-03f, 2.45552585e-02f, -9.73089933e-02f, -1.07350349e-01f, -5.50354756e-02f, -8.92429948e-02f,
  -2.73583573e-03f, 2.86789387e-02f, 6.01634197e-02f, -7.67341815e-03f, 3.84504572e-02f, 9.37129855e-02f, -8.83431081e-03f, 1.93984993e-02f, 7.83254206e-03f, 2.45101806e-02f,
  -4.19413373e-02f, -7.73325115e-02f, 2.98525840e-02f, 1.80809963e-02f, 5.08249775e-02f, -5.16057685e-02f, 6.51391745e-02f, 4.44453321e-02f, 7.70388246e-02f, -1.09110689e-02f,
  5.21139875e-02f, -1.58212427e-02f, 6.63310513e-02f, -1.84209161e-02f, -4.02125716e-02f, -3.09682731e-02f, -3.51970904e-02f, -1.24178007e-02f, 4.44785738e-03f, -3.62208262e-02f,
  6.41363859e-02f, -3.66554037e-02f, -5.07536791e-02f, 4.07790989e-02f, -6.07741736e-02f, -4.50441875e-02f, -2.17756312e-02f, -4.35290933e-02f, 6.32513762e-02f, -9.82014090e-03f,
  -1.13668209e-02f, 5.84001876e-02f, -4.50795628e-02f, 3.98119614e-02f, -1.26546377e-03f, 6.23636842e-02f, -2.63791420e-02f, 5.02065048e-02f, -2.22867131e-02f, 8.63595307e-03f,
  -6.21282347e-02f, -5.33231199e-02f, -6.96587488e-02f, 3.43366675e-02f, 6.50907159e-02f, -2.34594475e-02f, -4.55424301e-02f, 2.81851436e-03f, 8.67497735e-03f, -2.05315482e-02f,
  -5.83522469e-02f, 7.55047286e-03f, 7.43049830e-02f, 1.47187551e-02f, 1.30669028e-02f, -7.33351409e-02f, -1.25271669e-02f, 5.05999960e-02f, 9.66475811e-03f, -5.53842485e-02f,
  -1.68853607e-02f, -9.25917104e-02f, 1.86128411e-02f, 4.52064276e-02f, 7.90122002e-02f, 7.07370713e-02f, -2.30201185e-02f, -8.97507444e-02f, -2.76691549e-06f, -6.70107082e-02f,
  -3.19188088e-02f, -4.75714616e-02f, -7.83229768e-02f, -4.84980047e-02f, 6.56440780e-02f, 4.88817953e-02f, -6.45065010e-02f, 1.85712427e-02f, 5.19335084e-03f, 6.30758926e-02f,
  -7.94320777e-02f, 2.53275502e-02f, -3.40233408e-02f, 2.26242784e-02f, -9.45819728e-03f, -2.41983831e-02f, -5.58897741e-02f, 3.18326391e-02f, -5.36614237e-03f, -4.88079302e-02f,
  1.11489423e-01f, 1.91929236e-01f, 5.11695594e-02f, 8.00739378e-02f, -3.85647304e-02f, -1.41090587e-01f, -7.23495558e-02f, -1.42155858e-02f, 2.26118718e-03f, 1.35792851e-01f,
  -7.41714686e-02f, 1.42456025e-01f, 5.44331521e-02f, -7.19462633e-02f, -1.03897519e-01f, -6.67795315e-02f, 3.73130152e-03f, -3.86765487e-02f, -5.04750274e-02f, 2.92628612e-02f,
  -1.10274017e-01f, -5.93774021e-02f, -7.79926926e-02f, 5.33589274e-02f, -5.23015391e-03f, 7.11961836e-02f, 1.07070722e-01f, -8.86017457e-02f, 1.17597073e-01f, -1.17981741e-02f,
  -9.41361859e-02f, -5.59763284e-03f, 1.37803108e-01f, -1.46874199e-02f, -8.38286579e-02f, 2.15269085e-02f, 4.08503460e-03f, 6.82054162e-02f, 4.65160012e-02f, 6.06815703e-02f,
  9.41296667e-02f, 5.68641387e-02f, -1.64242014e-02f, -2.05529574e-02f, -9.16148070e-03f, -4.27161604e-02f, -1.47175770e-02f, -3.03417519e-02f, -6.26601577e-02f, 3.69652510e-02f,
  -8.76570027e-03f, -1.31413331e-02f, 5.58432266e-02f, 5.24573214e-02f, -7.55407140e-02f, -2.83617955e-02f, 3.54970396e-02f, -6.16401173e-02f, 5.79064824e-02f, -6.18645996e-02f,
  -5.84624298e-02f, -9.96509101e-03f, -3.47537026e-02f, -4.82058991e-03f, 1.50110817e-03f, -6.00854531e-02f, 3.32367532e-02f, -3.47761139e-02f, 4.55621555e-02f, 7.44693168e-03f,
  2.10679565e-02f, -1.92239955e-02f, 3.04948445e-02f, -6.68915287e-02f, -7.94506893e-02f, 5.36330342e-02f, -4.48339581e-02f, 2.05000956e-02f, -3.75729799e-02f, 8.81762523e-03f,
  1.39522068e-02f, -6.80801272e-02f, 4.31992114e-03f, -5.40817119e-02f, -8.46921653e-02f, 1.05498666e-02f, -8.00871924e-02f, -2.03856956e-02f, -7.17524663e-02f, 1.72167644e-02f,
  -3.50562297e-02f, 4.19270396e-02f, 6.28973097e-02f, 5.82291894e-02f, 5.90520091e-02f, 9.51943621e-02f, 1.90225914e-02f, 1.91135961e-03f, 7.29725659e-02f, -1.07281379e-01f,
  2.35446170e-02f, 1.19306110e-02f, 5.07638678e-02f, -4.37643416e-02f, -3.26301567e-02f, 2.42568646e-02f, -8.25491175e-02f, 3.63469347e-02f, 9.94626135e-02f, -1.96237639e-02f,
  6.45136014e-02f, -1.78383458e-02f, 8.27957243e-02f, -6.88830987e-02f, 4.59630825e-02f, -2.95640044e-02f, -8.24668705e-02f, 8.20447356e-02f, 8.20572525e-02f, 1.28590232e-02f,
  1.69369459e-01f, 5.77687956e-02f, -6.97785020e-02f, 9.66236070e-02f, -1.62874311e-01f, 1.50513709e-01f, 1.19017281e-01f, 8.29206929e-02f, 1.32438382e-02f, 3.73259559e-02f,
  -4.24345769e-02f, 1.29535064e-01f, 1.09892860e-01f, 8.77548754e-02f, 7.68786147e-02f, 1.23918369e-01f, 1.15513466e-01f, -2.11184565e-02f, -2.35893540e-02f, 1.25026584e-01f,
  8.14605579e-02f, 1.27878547e-01f, 1.47956042e-02f, -1.51589707e-01f, -1.56850852e-02f, -1.02917567e-01f, -1.21608423e-02f, -2.22360827e-02f, -1.21020518e-01f, -2.04030816e-02f,
  3.96830589e-02f, -3.82869057e-02f, -1.15608899e-02f, 7.83812180e-02f, 4.13905941e-02f, 1.27184214e-02f, 8.61028507e-02f, 5.60389385e-02f, 6.51613474e-02f, 3.16208303e-02f,
  1.09604977e-01f, 1.69495326e-02f, 4.55366187e-02f, 1.04639744e-02f, 2.73805880e-03f, -1.45026511e-02f, 2.76148822e-02f, -1.33755086e-02f, -5.38713001e-02f, -6.29272461e-02f,
  3.06995716e-02f, 7.26516098e-02f, 2.48497091e-02f, -8.19245949e-02f, -3.83173376e-02f, -2.96064112e-02f, -5.14564589e-02f, -5.99250197e-02f, 8.15169513e-02f, 2.06254758e-02f,
  2.76847817e-02f, 3.88900600e-02f, 6.99056610e-02f, -2.16334383e-03f, -3.97343608e-03f, -1.05949774e-01f, 6.77058771e-02f, -4.92060836e-03f, -7.14052469e-02f, -9.27591920e-02f,
  3.81762981e-02f, 7.57429674e-02f, 2.90227402e-02f, -5.29699959e-02f, -2.59347074e-02f, -3.64746340e-02f, -7.18379170e-02f, -4.96791154e-02f, -2.53181960e-02f, -1.30455252e-02f,
  -6.30690977e-02f, 9.40014869e-02f, 1.71525348e-02f, 1.58361811e-02f, -3.38878185e-02f, 2.46871356e-02f, 8.78271312e-02f, 5.56309819e-02f, 2.54326500e-02f, -3.89001928e-02f,
  5.64642139e-02f, 1.40874311e-01f, 5.37896156e-02f, -3.17828357e-02f, 1.85756069e-02f, 6.38709664e-02f, 1.60292722e-02f, 7.85278603e-02f, 2.40286868e-02f, 5.17904498e-02f,
  9.39804129e-03f, -6.81940317e-02f, 1.02874063e-01f, 2.64577614e-03f, 5.06883264e-02f, 2.69417819e-02f, 4.61252928e-02f, -7.50144646e-02f, -3.72402854e-02f, -3.56800035e-02f,
  7.06631392e-02f, -5.34382872e-02f, 4.75449078e-02f, 8.11928697e-03f, 6.17985539e-02f, -7.92691186e-02f, -5.53519204e-02f, -6.12362809e-02f, 2.84340177e-02f, -7.63967633e-02f,
  -2.49229386e-01f, 2.88683742e-01f, -2.63750963e-02f, -2.28241786e-01f, -4.79469411e-02f, -1.69312954e-01f, -2.15443805e-01f, 3.51790935e-02f, 6.03197236e-03f, 6.19219728e-02f,
  -1.55586809e-01f, 4.81372662e-02f, 1.06420480e-01f, -8.83020684e-02f, -2.53896952e-01f, -3.15037146e-02f, -2.11242616e-01f, -5.81460912e-03f, 2.28693336e-01f, -1.84156239e-01f,
  -1.47222161e-01f, -1.03206575e-01f, 1.38690053e-02f, 4.28409092e-02f, -1.17537975e-01f, 4.60942928e-03f, -1.93080798e-01f, 6.92131519e-02f, -1.63700581e-02f, 7.68252909e-02f,
  -2.19627261e-01f, -1.18966356e-01f, -1.35425121e-01f, -4.16683741e-02f, -1.18604839e-01f, -3.50334086e-02f, -1.66211471e-01f, -2.73773577e-02f, -3.55984345e-02f, 5.32744788e-02f,
  9.16826576e-02f, -7.40948915e-02f, 6.65865466e-03f, 2.64833607e-02f, -1.24868648e-02f, 3.73222232e-02f, 1.11714311e-01f, 5.99478930e-02f, 2.08008103e-02f, 2.91127879e-02f,
  -2.24947780e-02f, -4.99333963e-02f, -7.07922578e-02f, -1.75765716e-02f, -1.03469700e-01f, -5.63103780e-02f, -3.13896388e-02f, 1.89793482e-02f, 6.73583820e-02f, -3.78744565e-02f,
  8.35643858e-02f, -1.09377995e-01f, 2.21691374e-02f, 1.97290462e-02f, 8.97544995e-02f, -6.83985576e-02f, -5.57411313e-02f, -3.48827280e-02f, -7.12426798e-03f, -1.21678278e-01f,
  -1.40016917e-02f, 6.31046295e-02f, -3.39037739e-02f, -2.79397424e-02f, 2.47356296e-03f, 3.69263925e-02f, -1.08529426e-01f, -1.78209022e-02f, -5.53659722e-02f, 4.93857712e-02f,
  3.88092026e-02f, -8.19903091e-02f, 1.06945939e-01f, -5.88881336e-02f, 4.89125587e-03f, -6.84601888e-02f, 1.55494269e-02f, -1.51510825e-02f, 2.22078096e-02f, -6.77718297e-02f,
  -2.38930941e-01f, -2.74505317e-01f, -5.19560128e-02f, -3.69942524e-02f, -2.32475661e-02f, -1.80563815e-02f, 1.99072883e-02f, 2.69458331e-02f, 9.57727805e-03f, 7.82010204e-04f,
  -7.31766447e-02f, -2.47885752e-02f, -1.25176609e-01f, -1.65551193e-02f, -2.68987409e-04f, -8.85507017e-02f, -5.90861328e-02f, -6.33932054e-02f, -1.76638529e-01f, 4.58899327e-02f,
  -6.47096289e-03f, -4.25147936e-02f, 6.82662502e-02f, -7.40328178e-05f, -1.96515140e-03f, -8.24138075e-02f, -4.20771390e-02f, -1.89145096e-02f, -6.39302284e-02f, -2.17170548e-02f,
  1.42453715e-01f, 1.37121037e-01f, 1.01295404e-01f, 1.97351202e-01f, 5.71676828e-02f, -3.86558697e-02f, 7.25779906e-02f, 1.66044593e-01f, 3.52484256e-01f, -5.65357059e-02f,
  -2.40477733e-02f, 4.53327373e-02f, 7.50360359e-03f, 4.66217361e-02f, 5.23741916e-02f, 9.68785211e-02f, 9.67891738e-02f, 1.19469762e-01f, 1.12620980e-01f, 1.52800158e-01f,
  4.03594226e-02f, -8.06891769e-02f, -1.36281222e-01f, -1.29344240e-01f, -2.96193063e-02f, -9.96082649e-02f, -1.80440024e-01f, -2.08100956e-02f, -1.99583218e-01f, -1.70699015e-01f,
  -4.62043583e-02f, 1.08812660e-01f, 1.45769184e-02f, -9.37951729e-02f, 7.99081028e-02f, -6.15539551e-02f, -8.31963867e-03f, -9.63543504e-02f, 1.05791226e-01f, -6.60461560e-02f,
  -6.58702701e-02f, -9.23131853e-02f, 8.46757218e-02f, -2.33056527e-02f, 6.04341850e-02f, -1.01725087e-01f, -3.11806500e-02f, 6.14966080e-03f, 4.82574105e-02f, 5.63993789e-02f,
  -4.49657664e-02f, 3.63165885e-02f, 5.98711036e-02f, -1.22175902e-01f, 2.22330950e-02f, -6.21311367e-02f, 6.19960800e-02f, -6.87539876e-02f, -4.54315804e-02f, 4.30789515e-02f,
  2.89355014e-02f, 9.67818871e-02f, -7.06069395e-02f, -2.38006413e-02f, 3.70921716e-02f, -1.18963113e-02f, 2.82180086e-02f, -4.60858308e-02f, -1.20464414e-02f, -6.05863780e-02f,
  3.18705812e-02f, -2.44098995e-02f, -3.13048027e-02f, 5.15572429e-02f, 1.10052682e-01f, -3.80377024e-02f, 2.60983557e-02f, -7.60746794e-03f, -2.72185840e-02f, 8.41544867e-02f,
  -5.35983890e-02f, 5.20020304e-03f, 7.89942071e-02f, -2.03215498e-02f, 1.61715541e-02f, -5.41984178e-02f, 9.41477157e-03f, 1.19584361e-02f, 5.92596717e-02f, 5.56739718e-02f,
  1.01180129e-01f, 1.43265069e-01f, 1.23491427e-02f, -5.68778403e-02f, -4.39937860e-02f, -5.11417575e-02f, 7.22797289e-02f, -2.46391352e-02f, 3.24836224e-02f, -1.96379945e-02f,
  -2.41354220e-02f, 4.64096591e-02f, -4.97371368e-02f, -9.32138693e-03f, 3.37981107e-03f, 1.55221839e-02f, 8.30085278e-02f, -6.41232058e-02f, -2.56805755e-02f, 1.68960616e-02f,
  7.33293816e-02f, 7.52022564e-02f, -4.89651132e-03f, -8.44396055e-02f, 1.59076080e-02f, 6.53337780e-03f, -4.43395786e-02f, -3.84061895e-02f, 1.26528842e-02f, -1.38201742e-02f,
  1.36654183e-01f, -6.12087213e-02f, -2.39305541e-01f, -4.35887976e-03f, -5.14946459e-03f, -1.08585566e-01f, 5.23529528e-03f, 9.27420259e-02f, -1.25511959e-01f, 8.20272565e-02f,
  1.85801372e-01f, 3.17411050e-02f, -2.48727780e-02f, 1.51323646e-01f, 1.74474403e-01f, -4.05809730e-02f, 1.65294528e-01f, 6.29528835e-02f, -1.19266985e-02f, 1.98089659e-01f,
  1.05380742e-02f, 1.22586295e-01f, 1.42877474e-01f, 1.67367652e-01f, 1.70456558e-01f, 7.23786876e-02f, 2.45701820e-01f, 7.75448754e-02f, 2.12659180e-01f, 4.04955819e-02f,
  -8.67695138e-02f, 2.03998554e-02f, -4.71127629e-02f, -1.13186285e-01f, 9.55518112e-02f, 5.74859418e-02f, -3.22865532e-03f, 1.21332174e-02f, -5.21998107e-02f, 3.50986533e-02f,
  -9.27302465e-02f, -5.62070161e-02f, -7.13680685e-02f, 6.37809858e-02f, -6.73000887e-02f, 5.72735034e-02f, -1.22996747e-01f, -4.49159294e-02f, -5.61936246e-03f, 1.46041680e-02f,
  2.84303469e-03f, -1.87312402e-02f, -3.74702923e-02f, 8.34429078e-03f, -8.89175087e-02f, -8.75411369e-03f, 2.78339698e-03f, -7.83088524e-03f, -5.53753823e-02f, 2.58277413e-02f,
  9.92155895e-02f, 1.28414785e-03f, 6.35485491e-03f, -4.85648029e-03f, -4.92463866e-03f, -2.43367739e-02f, -4.99643162e-02f, 4.81597967e-02f, 4.67015766e-02f, 4.46244329e-02f,
  7.78437406e-02f, -9.66202002e-03f, 7.36455917e-02f, 8.06225687e-02f, 9.49241873e-03f, -4.00969684e-02f, 4.90822829e-02f, 9.46244150e-02f, 3.50653715e-02f, 1.33499065e-02f,
  4.33251932e-02f, 5.72003610e-02f, 1.28703807e-02f, -5.98077290e-02f, 7.40582645e-02f, -1.46820601e-02f, 9.32730064e-02f, 8.01015198e-02f, -2.06941683e-02f, 3.88318188e-02f,
  9.27174613e-02f, 2.14741439e-01f, -3.47920433e-02f, -7.16501102e-02f, -8.52436200e-02f, 6.94870204e-02f, -1.07219238e-02f, -3.74996699e-02f, 9.09772217e-02f, 3.32195335e-03f,
  1.24498367e-01f, -5.26502356e-03f, 2.40060706e-02f, -3.19473520e-02f, 2.33601108e-02f, 1.27995713e-02f, -3.61452205e-03f, 3.02058738e-02f, 6.18195198e-02f, 4.65513133e-02f,
  2.23064404e-02f, 5.08450419e-02f, 9.02523473e-02f, -1.06437050e-01f, 4.37087603e-02f, -1.34299323e-02f, 4.14010845e-02f, 5.02589867e-02f, -8.00270215e-03f, 3.85607332e-02f,
  9.66386348e-02f, -2.71414787e-01f, 7.25757554e-02f, 8.26589167e-02f, 1.16916053e-01f, 9.65240821e-02f, 5.35279252e-02f, 6.42963201e-02f, 1.32207304e-01f, -1.52183115e-01f,
  -1.23158209e-01f, -1.39011428e-01f, 5.86345308e-02f, -1.59604266e-01f, 2.20451742e-01f, 9.09269005e-02f, -3.30067240e-02f, -4.42540199e-02f, 2.28273440e-02f, -6.13471046e-02f,
  -2.05428563e-02f, -2.47741230e-02f, 2.99771242e-02f, -1.66341215e-01f, -7.31721595e-02f, -8.95544961e-02f, -3.44861671e-02f, -1.62800476e-02f, -9.58299190e-02f, 4.02176641e-02f,
  8.40012729e-02f, -5.24030440e-03f, -6.89678639e-02f, 3.61154936e-02f, -5.73993698e-02f, -1.18174501e-01f, 2.43577398e-02f, 8.81147534e-02f, 4.74823751e-02f, 1.28784981e-02f,
  3.60643677e-02f, -2.23696157e-02f, 5.51787391e-03f, -2.12454796e-02f, -1.48950983e-02f, 7.48643652e-02f, 6.03060413e-04f, -4.88955639e-02f, -3.28808390e-02f, -1.64979454e-02f,
  -2.33147480e-02f, -1.41939707e-02f, 7.15807304e-02f, 1.94665231e-03f, 6.40390217e-02f, -2.30978671e-02f, 7.05968738e-02f, 5.46368062e-02f, -3.92992161e-02f, 1.95354912e-02f,
  -1.22211896e-01f, -4.82808538e-02f, 1.64051764e-02f, 5.79451583e-02f, 2.21737400e-02f, 8.05105194e-02f, -2.52375919e-02f, 3.44989933e-02f, -2.21245922e-02f, 1.05086509e-02f,
  -5.63176489e-03f, 1.45763820e-02f, 9.24341008e-02f, -5.43792807e-02f, -1.60262510e-02f, -4.32219207e-02f, 9.10575595e-03f, 6.87844902e-02f, 9.19152144e-03f, -4.47122529e-02f,
  -1.47449868e-02f, 1.72378235e-02f, 1.10204034e-02f, 1.12460218e-02f, -8.66955295e-02f, 5.93263730e-02f, 5.43098226e-02f, 4.01339345e-02f, 1.66131265e-03f, 8.01716745e-03f,
  -6.33102879e-02f, -1.41861901e-01f, -4.14201543e-02f, -9.73161086e-02f, -7.69250616e-02f, 3.75364684e-02f, -3.91984321e-02f, 5.83766922e-02f, -9.90651734e-03f, -6.14559203e-02f,
  -4.71481085e-02f, -5.55522628e-02f, 3.94224860e-02f, 2.76276469e-02f, -1.27197069e-04f, 1.09342637e-03f, -6.02462478e-02f, -7.57152662e-02f, -8.83684084e-02f, -2.12686062e-02f,
  -9.59654525e-03f, -1.65227782e-02f, 1.00731654e-02f, -4.90172915e-02f, 2.03931192e-03f, 1.65924970e-02f, -1.88650675e-02f, 5.60615249e-02f, -3.57727217e-03f, -7.22998753e-02f,
  -1.35527208e-01f, 1.53926447e-01f, -1.57991961e-01f, -1.63709559e-02f, 1.17660083e-01f, 1.86099440e-01f, 9.52073559e-02f, 4.33876738e-02f, 1.50132835e-01f, 1.64846495e-01f,
  -1.46714477e-02f, -8.67476314e-02f, -6.09254278e-03f, 1.23720631e-01f, 1.17047384e-01f, 1.14962578e-01f, 1.83498099e-01f, 1.20348945e-01f, 1.60127822e-02f, 7.92004019e-02f,
  -1.03890710e-01f, 3.16402279e-02f, -3.65114361e-02f, -1.21000066e-01f, 2.83241365e-02f, -1.73234776e-01f, -7.01868981e-02f, -1.72020167e-01f, 3.21874171e-02f, -1.01006543e-02f,
  -5.07450104e-02f, 8.74293852e-04f, -1.30533785e-01f, 4.48050275e-02f, -1.15345515e-01f, -8.40801653e-03f, -1.13866493e-01f, -1.10798597e-01f, -3.20784114e-02f, -3.56677361e-02f,
  -7.60988519e-02f, 5.70909046e-02f, 8.18128064e-02f, 1.95328090e-02f, -6.08863384e-02f, -4.73364592e-02f, -6.34957328e-02f, 4.28444222e-02f, 9.11023188e-03f, -5.19005470e-02f,
  5.88163026e-02f, -4.06814739e-02f, -4.56344895e-03f, 4.91581857e-02f, 4.80215549e-02f, 6.07364997e-02f, 5.59428707e-02f, -6.15778714e-02f, 7.52877118e-03f, 7.00739473e-02f,
  -4.37642075e-02f, 1.05055720e-01f, -9.22238156e-02f, -3.95940989e-02f, -3.89296119e-03f, -1.01124234e-01f, 7.36311749e-02f, 1.23417526e-02f, -3.78439650e-02f, -1.98048949e-02f,
  4.52529974e-02f, 5.49199171e-02f, -8.50386322e-02f, 5.28211892e-02f, 2.64358260e-02f, 4.51266207e-02f, -9.29367170e-02f, 1.90274268e-02f, 9.96654555e-02f, -4.56923060e-02f,
  -7.01728910e-02f, -3.71538242e-03f, -3.58660705e-02f, -3.05203926e-02f, 1.13469614e-02f, -7.92231932e-02f, 7.30767548e-02f, 7.05272285e-03f, 7.26078451e-02f, -8.88875276e-02f,
  1.56687498e-01f, 4.71371263e-02f, -3.59934047e-02f, 5.16801849e-02f, 6.39553647e-03f, 4.43224646e-02f, -4.93880510e-02f, 5.43441847e-02f, -6.37253299e-02f, 6.86944053e-02f,
  3.99496816e-02f, -9.83802080e-02f, 9.99970641e-03f, -6.16245978e-02f, 3.52859274e-02f, 1.04227230e-01f, 2.32239254e-02f, 6.93330839e-02f, -2.02887971e-02f, 5.23096099e-02f,
  -8.60396996e-02f, -7.86517859e-02f, -2.29296908e-02f, 3.29023153e-02f, 1.79542620e-02f, 3.31056044e-02f, -5.87244853e-02f, -2.13421714e-02f, 7.78335258e-02f, -2.09384877e-02f,
  -1.46462750e-02f, 1.52201071e-01f, -1.11948093e-02f, -9.72620398e-02f, -8.85630697e-02f, -4.44622003e-02f, -3.10783684e-02f, -3.41312261e-03f, 4.18094359e-02f, 6.27660975e-02f,
  2.87973117e-02f, 1.33001506e-01f, 9.13993716e-02f, -7.04414025e-02f, -6.51609711e-03f, -3.59276198e-02f, -5.89348935e-02f, -1.25805497e-01f, -6.54665381e-02f, 1.07738441e-02f,
  -5.03998529e-03f, -9.96764600e-02f, -8.66443738e-02f, -9.51431096e-02f, -7.69646913e-02f, 9.97732654e-02f, -6.02101199e-02f, 1.56258680e-02f, 3.79251107e-03f, 7.92664289e-02f,
  1.43412128e-02f, -1.12231374e-02f, 8.18016529e-02f, -2.06368300e-03f, -6.10021502e-02f, 4.44291085e-02f, 4.55603823e-02f, 5.90820722e-02f, 2.79340725e-02f, -3.91140282e-02f,
  2.18659323e-02f, 4.87889424e-02f, -1.93330701e-02f, 5.86631931e-02f, 9.65129733e-02f, 7.73072913e-02f, -2.22406536e-02f, 5.80615504e-03f, 6.20395541e-02f, 9.93679315e-02f,
  -2.95766145e-02f, 4.41648401e-02f, -5.00942953e-03f, -4.24417630e-02f, 1.03083760e-01f, 6.51058331e-02f, -8.66213143e-02f, 3.17385979e-02f, 5.63989393e-02f, -2.45786328e-02f,
  1.08633088e-02f, 7.05196932e-02f, -3.73158939e-02f, 1.21447906e-01f, 6.46790564e-02f, 3.58740054e-02f, -7.56467730e-02f, -4.81905788e-02f, -3.77500355e-02f, -6.49244785e-02f,
  -4.66754148e-03f, 3.62996422e-02f, -7.01757893e-02f, -7.09173679e-02f, -3.44923846e-02f, -6.02517016e-02f, 8.87397081e-02f, -7.14926869e-02f, 6.20128103e-02f, 6.79516271e-02f,
  -2.16591712e-02f, 8.89624562e-03f, -1.85745619e-02f, 6.28718138e-02f, -9.53222662e-02f, -1.14899334e-02f, 6.46559000e-02f, 1.25651345e-01f, -1.55324079e-02f, -4.99911793e-02f,
  -8.88202712e-03f, -7.10816532e-02f, 8.85028690e-02f, 5.08130230e-02f, 7.84310997e-02f, -3.31992358e-02f, 2.47258171e-02f, 4.00440916e-02f, 9.89736766e-02f, -9.79938135e-02f,
  6.08798899e-02f, -9.71742943e-02f, 1.68174896e-02f, -7.04212040e-02f, -1.39456345e-02f, 9.67222527e-02f, 2.87389439e-02f, -6.74257651e-02f, 8.20898730e-03f, 5.45832561e-03f,
  -8.38403404e-02f, -8.29689391e-03f, -4.74943295e-02f, 2.55215280e-02f, -1.32375835e-02f, 2.14168685e-03f, 9.37838629e-02f, 8.08002055e-02f, 5.83475269e-02f, 7.06554130e-02f,
  -5.72001189e-02f, 7.22146034e-02f, 1.56499445e-01f, -5.95046766e-03f, 3.19405012e-02f, 5.60558662e-02f, -6.68493956e-02f, 1.22676969e-01f, 1.26181200e-01f, 4.10532653e-02f,
  -6.13870136e-02f, 1.85812056e-01f, -7.61429444e-02f, 9.64552443e-03f, -1.68843344e-01f, -3.71031687e-02f, 7.91742746e-03f, -5.15830629e-02f, 1.14208311e-01f, -1.30747934e-03f,
  -1.02120206e-01f, -2.03767955e-01f, -3.39581929e-02f, -3.75491530e-02f, 8.04829691e-03f, -4.57624570e-02f, -2.16650203e-01f, 1.10033881e-02f, -6.09707274e-03f, -9.17153358e-02f,
  -2.52605379e-02f, -2.63009239e-02f, 6.80457950e-02f, 1.81392953e-02f, -1.68290511e-02f, 9.03760567e-02f, 1.86833348e-02f, -5.56479730e-02f, 7.53210261e-02f, 1.02726832e-01f,
  2.69102994e-02f, 4.75313216e-02f, -1.15869464e-02f, 2.85498369e-02f, 9.95261595e-02f, 3.48261893e-02f, -4.81641330e-02f, 1.90038309e-02f, 3.81671712e-02f, -8.64274707e-03f,
  2.54100189e-02f, 1.04601890e-01f, -4.06676903e-02f, -2.77288184e-02f, -2.06150375e-02f, 7.18515739e-02f, 6.52657300e-02f, -3.12444661e-02f, 2.53307596e-02f, -1.81528032e-02f,
  -3.61514241e-02f, -5.10766059e-02f, -3.86123173e-02f, -3.42338234e-02f, -1.42379934e-02f, -3.62487733e-02f, -7.41308704e-02f, -8.73749331e-02f, -3.98407765e-02f, -5.19274361e-03f,
  2.15726183e-03f, -5.79317212e-02f, 4.56628576e-02f, -1.63446609e-02f, -3.78267653e-02f, -1.41594866e-02f, -9.87726822e-03f, 3.40668336e-02f, -4.53358591e-02f, -2.13166419e-02f,
  -5.59016503e-03f, 7.52150640e-02f, 3.16963275e-03f, -8.37469622e-02f, 1.26982823e-01f, 5.25645316e-02f, -1.13244522e-02f, -7.05925049e-03f, -4.49706614e-02f, -2.29226146e-02f,
  -2.94336062e-02f, -6.25775605e-02f, 1.05498766e-03f, 7.05995932e-02f, -4.25200500e-02f, 2.82916911e-02f, -6.41240254e-02f, 9.14357752e-02f, -3.18852477e-02f, 5.77516407e-02f,
  -7.11059710e-03f, 8.77800286e-02f, 8.64609852e-02f, -2.69175563e-02f, -4.49928194e-02f, -6.54027015e-02f, -2.13474315e-02f, -4.56123836e-02f, 5.38507514e-02f, -3.28635164e-02f,
  6.21896274e-02f, -6.64727911e-02f, 5.56657277e-02f, 1.27296969e-02f, 6.10961728e-02f, -3.77664603e-02f, -2.08315551e-02f, 5.27835079e-02f, -5.96237220e-02f, -1.42775392e-02f,
  -1.30672038e-01f, 3.13931666e-02f, 1.25836179e-01f, -2.18474828e-02f, 1.19260103e-02f, -3.10389441e-03f, 1.38108179e-01f, -5.65787517e-02f, -1.58607617e-01f, -1.66875273e-01f,
  -3.19536366e-02f, 8.66516307e-02f, 1.03971228e-01f, -3.54404747e-02f, 2.20770702e-01f, 1.33790612e-01f, 1.47842467e-02f, -1.98363513e-02f, -2.31376663e-02f, -1.09665729e-02f,
  -2.81590112e-02f, -4.61031720e-02f, 1.18048690e-01f, -1.19020946e-01f, 2.37501338e-02f, -5.17753139e-02f, -5.20684710e-03f, 1.67441621e-01f, -1.02504127e-01f, 3.77794541e-02f,
  -9.07126442e-02f, 1.61507409e-02f, -7.75012895e-02f, 6.86333552e-02f, 9.30481479e-02f, 4.05588513e-03f, 1.06563598e-01f, 1.30528271e-01f, -1.42521784e-02f, -1.88777056e-02f,
  -8.00686330e-03f, -8.54766592e-02f, -2.27390490e-02f, 9.16469917e-02f, 1.03752688e-02f, -5.28077260e-02f, 8.11454281e-02f, 3.65673564e-02f, -3.57074514e-02f, -6.83459342e-02f,
  1.57332495e-02f, 4.46813367e-02f, -6.92337528e-02f, -3.93939670e-03f, 3.03651057e-02f, -8.10801610e-02f, -6.65100813e-02f, 1.02613568e-01f, 8.40005875e-02f, -6.94649592e-02f,
  6.35978207e-02f, 7.97385722e-03f, 8.36201906e-02f, -2.47494411e-02f, -4.88015115e-02f, -1.24650083e-01f, 1.02666594e-01f, -7.25566819e-02f, -8.59965235e-02f, 8.22914019e-02f,
  -8.08916986e-02f, 6.76633092e-03f, 9.82260257e-02f, 3.84184271e-02f, -9.54948459e-03f, 3.50681022e-02f, -5.14778607e-02f, 6.50194893e-03f, 4.18478400e-02f, -5.67294136e-02f,
  2.16689501e-02f, 7.30131790e-02f, 7.56546482e-02f, -4.88340259e-02f, 7.94833060e-03f, 4.13735285e-02f, 1.02552436e-01f, 8.74701962e-02f, -4.00877371e-02f, -3.30270790e-02f,
  -6.91456273e-02f, -1.22504249e-01f, 3.82282212e-02f, -1.21951766e-01f, -1.30985631e-02f, -9.39323159e-04f, 3.06936819e-02f, 2.03622300e-02f, 7.91589469e-02f, 6.34083748e-02f,
  2.37284154e-02f, -1.24558089e-02f, -6.95656165e-02f, -8.75745267e-02f, -6.37506992e-02f, -7.16765746e-02f, -3.93491834e-02f, -1.15972180e-02f, 2.07849629e-02f, -1.13959253e-01f,
  -2.92400625e-02f, 3.47957686e-02f, -1.97142921e-02f, 4.22536209e-02f, 4.10141982e-02f, -9.85201299e-02f, 5.08615281e-04f, -4.87771630e-02f, 2.19417568e-02f, -5.91181144e-02f,
  3.20752896e-02f, -1.52730234e-02f, -1.91465899e-01f, 7.72444680e-02f, 1.55957699e-01f, 1.06309786e-01f, 8.60496610e-02f, -8.09416696e-02f, -1.69276163e-01f, 6.88737854e-02f,
  1.29277840e-01f, -8.73905048e-03f, -9.87398624e-02f, 9.04611945e-02f, 7.91436210e-02f, 1.33241545e-02f, 1.06083736e-01f, -4.11536545e-03f, -1.25017315e-01f, -9.48228985e-02f,
  -8.94263536e-02f, 8.17305520e-02f, -9.71645862e-02f, 1.61938697e-01f, 9.09390971e-02f, -1.88803449e-02f, 1.20396130e-01f, 3.90620716e-02f, 1.45963341e-01f, 7.18327016e-02f,
  -2.85672443e-03f, 3.45099680e-02f, 5.79685122e-02f, -9.47535783e-02f, 2.52821855e-02f, 8.71655419e-02f, -6.48499876e-02f, -9.98368300e-03f, 4.71949428e-02f, -7.35013857e-02f,
  6.00569807e-02f, 2.86828857e-02f, -1.62794106e-02f, -7.38715753e-02f, 5.90688325e-02f, 6.56913444e-02f, 1.52361738e-02f, 2.57301945e-02f, -5.83785512e-02f, 4.23930101e-02f,
  -4.64132354e-02f, 8.40558261e-02f, -3.56943682e-02f, 7.87977222e-03f, 4.35626023e-02f, 1.85036119e-02f, -3.60427499e-02f, 3.51716429e-02f, -4.32935022e-02f, -9.78334174e-02f,
  -8.63706786e-03f, -6.49525970e-02f, -2.56060995e-02f, 5.85088134e-02f, 1.82934143e-02f, 7.95506686e-02f, 4.10123020e-02f, 1.00346446e-01f, -4.99733053e-02f, 6.11854941e-02f,
  4.17356752e-02f, 3.32334824e-02f, 6.09866753e-02f, -5.38935252e-02f, 1.16181327e-03f, -6.47580400e-02f, 5.71326017e-02f, 4.76474836e-02f, -4.02338356e-02f, 4.64634039e-02f,
  5.81066273e-02f, -3.02993972e-02f, -2.46771518e-02f, 8.07637945e-02f, 4.30953354e-02f, -3.91796231e-02f, -2.34525139e-03f, -6.33459240e-02f, -3.26162912e-02f, 1.99891292e-02f,
  -3.22078802e-02f, -3.50400731e-02f, -7.26635084e-02f, -3.67707200e-02f, 3.53245437e-02f, -2.73946878e-02f, -2.32186913e-02f, 2.03406177e-02f, -8.53098407e-02f, 4.26564217e-02f,
  -4.65761572e-02f, 5.50079383e-02f, 6.88000992e-02f, 2.23204922e-02f, 9.64435264e-02f, 3.52451243e-02f, -8.57291371e-02f, 2.18996201e-02f, 9.26694125e-02f, 7.48800412e-02f,
  3.63032706e-02f, 2.73776650e-02f, 2.95069143e-02f, -3.06006856e-02f, 5.82819358e-02f, -5.21509573e-02f, 8.65981728e-02f, 5.00036702e-02f, 2.64852419e-02f, -2.09852513e-02f,
  -2.22102460e-02f, 9.22455266e-02f, 2.65901834e-02f, 7.53107574e-03f, -1.36128692e-02f, -1.06077351e-01f, 4.24686112e-02f, -2.31917836e-02f, 1.70611087e-02f, -2.11810581e-02f,
  2.82272380e-02f, 9.50465649e-02f, 8.04910287e-02f, 1.70236066e-01f, 7.15006441e-02f, 1.60135731e-01f, 9.45380051e-03f, 8.99519250e-02f, 5.85506260e-02f, 1.33524984e-01f,
  1.71774834e-01f, 5.18891774e-02f, 1.23905391e-01f, -2.91416235e-03f, -5.81087060e-02f, 9.09215678e-03f, 1.48005083e-01f, -6.58962578e-02f, 4.29950282e-02f, 4.49915379e-02f,
  1.98243838e-02f, 8.88852403e-02f, 6.59706965e-02f, 4.05672304e-02f, 1.05305575e-02f, -8.72202441e-02f, -7.14982226e-02f, -9.25554633e-02f, 3.52866128e-02f, 7.56854117e-02f,
  -7.42986426e-02f, 5.68596683e-02f, -2.16997992e-02f, 3.58023159e-02f, 1.48405721e-02f, -9.42386314e-02f, 4.07495499e-02f, 8.23227316e-03f, 4.82480414e-02f, 3.78224775e-02f,
  -9.09716040e-02f, 1.73993856e-02f, 3.98292020e-03f, 5.02210855e-02f, 3.85854840e-02f, 1.67730469e-02f, 8.08984116e-02f, 1.46451052e-02f, 6.23785593e-02f, 3.22365314e-02f,
  -4.30845320e-02f, -4.00691256e-02f, -6.99464083e-02f, -5.76362535e-02f, 3.32876295e-02f, 1.44242998e-02f, 3.73792090e-02f, 5.50987311e-02f, -7.88881481e-02f, 9.47254896e-03f,
  6.62143826e-02f, 2.57695024e-03f, 2.71090958e-02f, 1.10851517e-02f, -4.81157862e-02f, 4.94481716e-03f, -4.84093279e-02f, 8.12481046e-02f, -3.72508019e-02f, 8.20908025e-02f,
  -1.29708070e-02f, 6.39206320e-02f, 6.10276014e-02f, -6.05093502e-02f, 4.61766347e-02f, 6.51277974e-03f, -3.48629616e-02f, -4.23147492e-02f, -1.12949945e-02f, -1.50872553e-02f,
  1.46752095e-03f, 8.13838020e-02f, 7.63368979e-02f, 5.87135786e-03f, 1.74309313e-02f, -3.11258081e-02f, -9.38172191e-02f, -2.24473737e-02f, 8.27749148e-02f, 9.10822749e-02f,
  5.86835295e-02f, 1.42636606e-02f, -8.80066678e-02f, 1.58061460e-02f, -6.34502992e-02f, 9.23499763e-02f, 1.07132472e-01f, -2.80988179e-02f, -6.13141954e-02f, 3.21398340e-02f,
  -2.86656413e-02f, 3.86265926e-02f, -9.68830287e-03f, -4.55998816e-02f, -7.21673891e-02f, 6.29886091e-02f, -5.91124147e-02f, 1.00927819e-02f, -4.33507450e-02f, 7.02758655e-02f,
  -7.40311965e-02f, 3.97932231e-02f, 3.73969078e-02f, 1.57191921e-02f, 2.45536231e-02f, -1.35031911e-02f, -1.34714484e-01f, 8.19509104e-02f, 1.79080740e-01f, 4.88620400e-02f,
  -1.56859607e-02f, 1.22173660e-01f, 8.82978886e-02f, 5.86120784e-02f, -1.87928736e-01f, -2.53315661e-02f, -1.63847476e-01f, 3.85477877e-04f, 4.80709691e-03f, -5.66703640e-03f,
  -8.82390812e-02f, -1.61355227e-01f, -7.16011897e-02f, -8.58059153e-02f, 9.84343048e-03f, -1.32585792e-02f, -4.64426801e-02f, -3.31560411e-02f, -1.07818030e-01f, 4.09003571e-02f,
  -3.34502272e-02f, 1.47731066e-01f, 1.11981526e-01f, 1.30229950e-01f, 2.23559253e-02f, -5.96656427e-02f, -2.98301037e-02f, 6.56109303e-02f, 3.28729898e-02f, 7.73947081e-03f,
  -5.90942912e-02f, -7.81138390e-02f, 2.75226533e-02f, 8.81093666e-02f, 7.45888427e-02f, 1.10796101e-01f, 1.26324082e-02f, -2.61268206e-02f, 1.84529964e-02f, -8.45371746e-04f,
  1.13669457e-02f, 7.06188753e-02f, 1.71511341e-02f, 2.45099403e-02f, 1.96865741e-02f, 8.89604762e-02f, 4.93662544e-02f, -7.33553097e-02f, -7.39858374e-02f, -6.81446344e-02f,
  7.00516850e-02f, 2.96645314e-02f, 1.28226606e-02f, 1.05241083e-01f, 4.26697209e-02f, -1.66067556e-02f, 2.55204402e-02f, 1.02985548e-02f, -6.61061928e-02f, 3.39158054e-04f,
  -4.99300547e-02f, -5.40615432e-02f, 7.56697208e-02f, -2.53620781e-02f, -1.06841587e-01f, 1.39681688e-02f, -4.19513620e-02f, -3.90204825e-02f, 6.71279337e-03f, -9.41771939e-02f,
  3.05678346e-03f, 3.33785005e-02f, -6.59567267e-02f, -1.50801921e-02f, 5.77808544e-03f, -2.58610789e-02f, 9.53920931e-02f, 1.28269114e-03f, -7.83083588e-02f, -8.06418806e-02f,
  -3.92667018e-02f, 9.11943167e-02f, -3.97007242e-02f, 8.51422101e-02f, -4.86786254e-02f, 5.31058833e-02f, -4.44341488e-02f, 3.58135104e-02f, -3.75987329e-02f, 4.99190297e-04f,
  3.13444585e-02f, 6.00910634e-02f, -8.11481252e-02f, -2.14514863e-02f, 8.64439532e-02f, -7.32104480e-02f, 4.25535627e-02f, 6.34301752e-02f, -4.40536439e-02f, 7.28063881e-02f,
  -6.72974959e-02f, 7.71500915e-02f, -4.65148762e-02f, 3.09967622e-02f, -6.58365935e-02f, -1.28437381e-03f, -3.77432560e-03f, 2.43987981e-02f, 4.90972437e-02f, 5.55396341e-02f,
  -1.45662963e-01f, 3.50731947e-02f, 6.53433949e-02f, -9.74603519e-02f, -1.32941395e-01f, 1.03295460e-01f, 1.47563562e-01f, -1.44486949e-01f, -3.32902162e-03f, 4.78291102e-02f,
  -1.18933665e-02f, -7.90805295e-02f, 2.96322480e-02f, 1.27563611e-01f, 7.65249953e-02f, 8.18693340e-02f, 5.37969992e-02f, 1.67253166e-02f, -5.46685494e-02f, -1.19260214e-01f,
  -8.04988071e-02f, 7.05695972e-02f, 1.15309931e-01f, -9.31743830e-02f, 7.25122765e-02f, -1.12630002e-01f, -6.29682168e-02f, -9.90864858e-02f, 4.78935689e-02f, 3.04828845e-02f,
  -5.54067641e-02f, -5.09855486e-02f, -8.98708531e-04f, 6.24292716e-02f, -1.03158548e-01f, 4.47902046e-02f, -8.06381553e-03f, -3.89180630e-02f, 1.72992926e-02f, -4.44010794e-02f,
  -2.55068708e-02f, -1.10526428e-01f, 1.72527768e-02f, 6.91087469e-02f, 1.56215942e-02f, 4.62243892e-02f, -5.42893447e-02f, 2.85657570e-02f, -5.78579642e-02f, 8.29012841e-02f,
  -3.75590548e-02f, 1.15369745e-02f, 7.90468305e-02f, 7.88901150e-02f, 1.02019981e-01f, 7.01654842e-03f, -3.59367579e-02f, -4.71160794e-03f, -4.35945950e-02f, 7.29385689e-02f,
  4.76214848e-02f, 2.52494924e-02f, -6.24603890e-02f, 6.00846298e-02f, 2.56587774e-03f, 2.35992353e-02f, -1.13779204e-02f, 7.83243105e-02f, 7.68227577e-02f, -5.77020226e-04f,
  -4.89741005e-02f, 8.58978257e-02f, 5.19906469e-02f, 4.71369736e-02f, 9.43733975e-02f, -7.76818469e-02f, 6.14995770e-02f, -1.86494384e-02f, -7.07998574e-02f, -3.87772322e-02f,
  1.24596367e-02f, 1.44348305e-03f, 9.30745974e-02f, 1.09154761e-01f, 6.75150827e-02f, 1.77602172e-02f, -7.58456215e-02f, 8.35098177e-02f, 3.99944186e-02f, -5.76482788e-02f,
  -2.39384379e-02f, -1.41193360e-01f, -1.01033203e-01f, 2.31071655e-02f, -9.75392088e-02f, 1.18025793e-02f, 4.19425219e-02f, 9.96403582e-03f, 5.68932407e-02f, 4.81027178e-02f,
  2.69734338e-02f, 7.33322576e-02f, -3.58946957e-02f, 9.55053512e-03f, -1.29159205e-02f, 7.42697567e-02f, -8.10587779e-02f, -9.13267285e-02f, 7.34521449e-02f, 6.23333789e-02f,
  -6.95777535e-02f, -2.91230679e-02f, 1.71178847e-03f, -9.32930484e-02f, -3.60308215e-02f, 3.11700087e-02f, -1.37252156e-02f, 4.03522253e-02f, 9.26119369e-03f, 8.16806480e-02f,
  3.00740004e-01f, -2.11631238e-01f, -2.78850853e-01f, 1.17319107e-01f, 1.90980017e-01f, 1.01192363e-01f, -1.10201143e-01f, 2.23388784e-02f, -1.23500697e-01f, -1.83828011e-01f,
  1.54211298e-01f, -1.69050276e-01f, -2.78017521e-01f, 2.33423352e-01f, 1.89687639e-01f, -8.55445787e-02f, 2.52628505e-01f, 2.60213297e-02f, -7.63648301e-02f, -1.15290070e-02f,
  1.56660214e-01f, 3.23729873e-01f, 7.08997920e-02f, 1.03132218e-01f, 1.60561413e-01f, -6.76614558e-03f, 1.41430438e-01f, -9.62616056e-02f, 1.86552897e-01f, 2.05686092e-01f,
  3.80748846e-02f, 5.79769015e-02f, -2.20611580e-02f, 5.30140102e-02f, -3.49878557e-02f, 5.38396789e-03f, -1.21694311e-01f, 3.81640568e-02f, -4.82610427e-02f, -4.17130515e-02f,
  -2.92674303e-02f, 6.91350549e-02f, 1.06172040e-01f, -2.57707071e-02f, 6.01729639e-02f, 2.72959247e-02f, 2.96759848e-02f, -5.63442335e-02f, -3.56326811e-02f, 3.01550850e-02f,
  -1.55030116e-01f, 8.93529058e-02f, -4.97580878e-02f, -3.18039698e-03f, -1.21167777e-02f, -2.51144674e-02f, -3.00562587e-02f, -1.11329660e-01f, 5.79263307e-02f, 6.37239218e-02f,
  1.13916188e-01f, -3.52982152e-03f, 2.52888130e-04f, -5.55123808e-03f, 6.17187992e-02f, 1.87922213e-02f, -6.02196110e-03f, -5.00753298e-02f, -8.64558518e-02f, -5.43171680e-03f,
  1.07781477e-02f, -2.24082619e-02f, 6.72817603e-02f, 1.60345100e-02f, -3.51871178e-02f, -3.63148302e-02f, -2.48674396e-02f, -4.07112688e-02f, -6.19167276e-02f, 6.28075302e-02f,
  -5.25391772e-02f, -4.02294584e-02f, -2.94242112e-04f, 1.76228695e-02f, 4.18988131e-02f, -2.32331944e-03f, 2.42985319e-02f, -8.91539454e-02f, -5.36703542e-02f, 6.21123761e-02f,
  -6.93728402e-02f, -1.15699686e-01f, -1.02395825e-01f, 4.73352112e-02f, 5.07678231e-03f, 8.71507600e-02f, -8.87249261e-02f, 8.05248842e-02f, -2.14231703e-02f, 7.95266777e-02f,
  5.50518632e-02f, 8.61059502e-03f, -8.22445843e-03f, 5.08907512e-02f, 7.87085593e-02f, -1.69534702e-02f, -6.97927549e-02f, -4.07562442e-02f, -4.75324988e-02f, 2.77472136e-04f,
  2.10816655e-02f, 1.37937686e-03f, 1.72624085e-02f, 2.76174787e-02f, -3.21909273e-03f, 5.58761917e-02f, 1.74432732e-02f, 4.93283905e-02f, -1.86998118e-02f, -1.14218757e-01f,
  1.45474046e-01f, -1.40813783e-01f, -2.16040984e-01f, 1.67899597e-02f, -1.32499278e-01f, 1.39620364e-01f, 4.10294533e-02f, -1.34356454e-01f, -2.13318810e-01f, 1.00424111e-01f,
  1.14758238e-01f, 5.88785969e-02f, 4.56825942e-02f, 2.29005203e-01f, 1.60827726e-01f, 5.61195165e-02f, 2.42949188e-01f, 3.13321613e-02f, -8.35425407e-02f, -8.33392516e-02f,
  -3.70792858e-02f, 2.86960959e-01f, 8.80406275e-02f, 2.78387256e-02f, 4.06386741e-02f, -1.16310157e-01f, 9.58862230e-02f, -8.53151530e-02f, 1.34118199e-01f, 4.71073650e-02f,
  1.02353655e-01f, -1.00448869e-01f, 1.81687586e-02f, -2.52469182e-02f, -2.54952651e-03f, -1.70601103e-02f, 5.95042966e-02f, 9.08280611e-02f, 1.87687532e-04f, -4.82556857e-02f,
  -6.50566816e-02f, -5.04051968e-02f, -7.90846422e-02f, 3.92018035e-02f, 4.57001887e-02f, -1.11544766e-01f, -2.47284845e-02f, -3.49164866e-02f, 1.23848375e-02f, 6.80540949e-02f,
  -1.23890296e-01f, -4.42569703e-02f, 4.22420725e-03f, 9.45744477e-03f, -6.17624745e-02f, 7.64520466e-03f, -1.46730542e-02f, -1.69888120e-02f, -1.05324335e-01f, -4.40120809e-02f,
  -1.27195669e-02f, -3.76125537e-02f, -6.20775996e-03f, 1.03525398e-02f, -4.13129032e-02f, 1.26411319e-01f, -8.62222817e-03f, 7.79026374e-02f, -5.71343973e-02f, 4.05706838e-02f,
  1.13579407e-02f, 5.45893470e-03f, -6.67264909e-02f, -5.30684739e-02f, -4.13617156e-02f, 5.12376893e-03f, 1.34535432e-02f, 3.50726955e-02f, -8.29697773e-02f, -3.80177796e-02f,
  5.66078126e-02f, -4.84217927e-02f, 5.83634190e-02f, 6.13019951e-02f, -8.08759704e-02f, 4.40852791e-02f, 7.51307160e-02f, 1.03522921e-02f, 4.67704013e-02f, 1.83766114e-03f,
  -4.27269489e-02f, -1.37925789e-01f, -3.21289226e-02f, -6.21959083e-02f, 7.07422011e-03f, -7.19525963e-02f, 8.36676806e-02f, -6.92589805e-02f, -1.18543943e-02f, -6.30939826e-02f,
  -5.51028475e-02f, 2.83827726e-02f, -3.50700947e-03f, -7.06198812e-02f, -7.63104856e-02f, -7.54540786e-02f, 5.28521314e-02f, 5.62222581e-03f, -2.84828953e-02f, -4.10629734e-02f,
  6.19223751e-02f, -4.44870442e-02f, 7.26152360e-02f, -1.81260724e-02f, -3.29444781e-02f, -6.34996668e-02f, -8.19316655e-02f, -8.81836936e-02f, -5.84705584e-02f, -1.15592189e-01f,
  -8.69642124e-02f, 2.57592425e-02f, -7.27153569e-02f, 1.66781113e-01f, -5.52008748e-02f, -1.20283738e-01f, -1.38561055e-02f, -4.85826172e-02f, -2.52804346e-02f, 4.99085337e-02f,
  1.19962603e-01f, -4.38294560e-03f, -1.12641407e-02f, 1.09100036e-01f, 2.57000588e-02f, 3.33232097e-02f, 6.41595514e-04f, 7.34658390e-02f, 3.46181728e-02f, 7.87591264e-02f,
  1.43663496e-01f, 1.61300883e-01f, 2.07022563e-01f, 1.09446526e-01f, 5.35637923e-02f, 1.57258898e-01f, 1.27185330e-01f, 5.11351377e-02f, 1.69860467e-01f, -2.87634190e-02f,
  4.34205011e-02f, -1.63929071e-02f, -3.08680236e-02f, -1.09004583e-02f, 4.18928964e-03f, 2.21862346e-02f, 7.45104104e-02f, 6.67176470e-02f, 8.90080929e-02f, -1.51045658e-02f,
  4.30562757e-02f, 8.04121941e-02f, -6.15025237e-02f, -4.59608994e-02f, -3.19331361e-04f, -8.21128041e-02f, 4.50781807e-02f, 2.67339647e-02f, -1.00701034e-01f, 1.70339178e-02f,
  -1.59151759e-02f, 2.13657925e-03f, -8.12195241e-03f, 8.64669308e-03f, -1.90416519e-02f, 4.41879854e-02f, 9.30179562e-03f, 9.99727473e-03f, 4.88821678e-02f, 3.51716690e-02f,
  1.54865775e-02f, 2.79596029e-03f, 4.76087891e-02f, 1.92488525e-02f, 8.51376802e-02f, -9.17858407e-02f, -2.82959938e-02f, -2.98676696e-02f, -6.23386465e-02f, 1.78172030e-02f,
  9.00944471e-02f, -4.76364978e-03f, 2.23589176e-03f, -1.53372372e-02f, 6.55368641e-02f, 7.25227371e-02f, -2.88131293e-02f, 4.62235175e-02f, -8.40203166e-02f, -3.02311443e-02f,
  5.41514121e-02f, 5.55744432e-02f, 9.03214663e-02f, -3.94835547e-02f, -1.24820564e-02f, -3.51478979e-02f, 1.16449839e-03f, 3.88625525e-02f, -3.37801911e-02f, -6.14267327e-02f,
  -7.05582350e-02f, 9.17228777e-03f, 7.35422000e-02f, -9.25127193e-02f, -8.58066678e-02f, -4.05768771e-03f, 2.55387300e-03f, -4.33206744e-02f, -5.59571423e-02f, 5.41481338e-02f,
  -1.11562811e-01f, 7.30929151e-02f, -1.54713746e-02f, -3.91496234e-02f, 8.95991400e-02f, 5.35333306e-02f, 4.15527672e-02f, 1.69408564e-02f, 4.37914580e-02f, 4.49026935e-02f,
  2.11092457e-02f, -6.41821176e-02f, -1.89548712e-02f, 1.81633551e-02f, 6.67832196e-02f, -6.79762810e-02f, 1.06539190e-01f, -4.38004546e-02f, -6.79350644e-02f, 3.75482487e-03f,
  1.12070881e-01f, 3.27947401e-02f, 1.67186052e-01f, -1.19638935e-01f, -1.15582682e-01f, -1.37720942e-01f, -1.96756572e-01f, -1.25986964e-01f, 8.90379772e-02f, -3.96564305e-02f,
  -9.57129151e-02f, 2.30942056e-01f, -3.75964455e-02f, -1.11805774e-01f, 4.70018685e-02f, 6.40915558e-02f, -5.79054803e-02f, 5.83785437e-02f, -3.10420501e-03f, -3.61037888e-02f,
  -2.96602920e-02f, -2.61883318e-01f, -5.43376058e-02f, -6.53876737e-02f, -4.95327413e-02f, -1.39666675e-02f, -4.41560000e-02f, -1.00838728e-01f, -1.40598032e-03f, 2.09645815e-02f,
  -1.13190785e-01f, 2.04434767e-02f, -5.23993149e-02f, 4.16449122e-02f, -1.88919492e-02f, 4.65918630e-02f, -6.30840808e-02f, -8.69055316e-02f, -5.33980019e-02f, -4.20016833e-02f,
  -2.08751094e-02f, 3.18408534e-02f, 8.24153125e-02f, 9.10382438e-03f, -1.01438850e-01f, 9.92294773e-02f, -8.78303349e-02f, -1.05025597e-01f, 8.79419744e-02f, -2.23626960e-02f,
  1.56243891e-02f, 7.73510709e-02f, 5.70307560e-02f, 6.79516792e-02f, 7.45853856e-02f, 7.18309637e-03f, 6.79746270e-02f, 6.40999824e-02f, -2.47120969e-02f, 9.14167166e-02f,
  -3.76997329e-02f, -7.58717805e-02f, -2.09698062e-02f, 2.96712071e-02f, -3.83612998e-02f, -3.96176539e-02f, 1.62263159e-02f, -1.44798507e-03f, -9.74311978e-02f, -9.76461619e-02f,
  -4.27639000e-02f, 6.83617033e-03f, -3.54805775e-02f, 3.24831903e-02f, -1.24027155e-01f, -4.13597524e-02f, 9.13316458e-02f, -9.49519798e-02f, 2.71216854e-02f, 5.76104932e-02f,
  -8.14203769e-02f, -2.58907187e-03f, -8.27686936e-02f, -6.21495619e-02f, 6.35134578e-02f, 6.14274107e-03f, 5.45274466e-02f, 3.23955789e-02f, -2.47597713e-02f, 4.04043384e-02f,
  -8.49903896e-02f, -1.79442078e-01f, 1.62576847e-02f, -9.06633139e-02f, -4.88637462e-02f, -4.76423800e-02f, -7.62041146e-03f, 1.10731004e-02f, -7.86679909e-02f, 2.00943854e-02f,
  -8.23632106e-02f, 2.56653912e-02f, 9.76945460e-02f, 5.47104254e-02f, -1.04127459e-01f, 1.78841669e-02f, -4.67774346e-02f, 4.04609665e-02f, -2.16635671e-02f, 4.87765074e-02f,
  -2.85055414e-02f, 8.70772004e-02f, 3.90596762e-02f, -6.59307912e-02f, 2.80975848e-02f, 2.21781898e-02f, 1.11285076e-01f, 6.84576035e-02f, 4.12421972e-02f, 4.79903333e-02f,
  -9.59168896e-02f, 1.37711212e-01f, -1.69215202e-02f, 5.84014803e-02f, -5.49819740e-03f, -7.15282038e-02f, -6.66167587e-02f, 6.51503727e-02f, -3.46579999e-02f, -3.15776132e-02f,
  8.50529447e-02f, -8.24855566e-02f, -5.01782037e-02f, 9.16219950e-02f, -6.06615357e-02f, 5.11544105e-03f, -1.19415196e-02f, -1.68542285e-02f, 1.05510853e-01f, 2.58105863e-02f,
  1.13028236e-01f, 8.59660953e-02f, 1.39904454e-01f, -6.47472916e-03f, 3.07111014e-02f, 2.84014679e-02f, -2.06741598e-02f, -1.15915630e-02f, -3.38213108e-02f, -9.31207165e-02f,
  -7.92181864e-02f, -2.79675797e-02f, -4.30213585e-02f, -4.41711582e-02f, 7.45052248e-02f, 3.32646072e-02f, -6.31700903e-02f, -2.01442391e-02f, -6.59467652e-02f, 4.31420840e-03f,
  2.29289737e-02f, -4.99774627e-02f, -6.60884455e-02f, 7.74179492e-03f, 5.25035039e-02f, -5.87581880e-02f, 1.00878797e-01f, 5.74305356e-02f, 7.37746581e-02f, 5.96648417e-02f,
  8.50168616e-02f, -1.73242353e-02f, 1.04715481e-01f, -6.88639805e-02f, -1.99337397e-02f, 1.60743929e-02f, -1.04740979e-02f, 4.72813174e-02f, -6.49762824e-02f, -2.05847174e-02f,
  -3.32925767e-02f, -6.01271130e-02f, 4.52039018e-02f, 6.87185898e-02f, 7.13516101e-02f, 6.09939508e-02f, -5.55486567e-02f, -4.56229411e-02f, -8.85872021e-02f, 8.74029249e-02f,
  -2.32590418e-02f, 6.19626231e-02f, 5.86491488e-02f, -9.17986557e-02f, -3.33874784e-02f, -6.27369285e-02f, -4.93194722e-02f, -4.75852415e-02f, -7.54022226e-02f, -1.33624123e-02f,
  -4.74271737e-02f, -1.01954132e-01f, 2.98578460e-02f, 2.32775584e-02f, -7.84877837e-02f, 3.54927033e-02f, 7.50837550e-02f, 4.95334975e-02f, 5.38301021e-02f, 7.33847842e-02f,
  -2.10840851e-02f, 5.11827841e-02f, -1.07413083e-02f, 1.89770311e-02f, 5.30252121e-02f, -8.43224302e-02f, 1.01705524e-03f, 6.44355863e-02f, 8.58625919e-02f, -8.85672495e-02f,
  -4.32715975e-02f, 5.65111376e-02f, -3.79894339e-02f, -1.80753395e-02f, -5.38260788e-02f, -9.76841003e-02f, 9.97095276e-03f, 6.48229495e-02f, -4.06238101e-02f, 7.67763555e-02f,
  -1.82546228e-02f, -6.14866316e-02f, -1.46554718e-02f, -7.35647976e-02f, 7.57311583e-02f, -9.90516786e-03f, -7.90795013e-02f, 5.57194185e-03f, 5.76555356e-02f, -4.90818135e-02f,
  -6.82623358e-03f, -1.27997145e-01f, -3.99581343e-02f, -1.37861565e-01f, 1.14469729e-01f, 2.29874719e-02f, 6.05602600e-02f, 1.45566911e-02f, -1.95101760e-02f, -1.36794254e-01f,
  -9.13259387e-02f, -1.28868967e-01f, 9.32362825e-02f, -1.97169166e-02f, 3.24002355e-02f, -7.86071792e-02f, 4.30096015e-02f, -1.24141000e-01f, -1.27693899e-02f, 5.06740436e-02f,
  -7.42374808e-02f, -8.38704407e-02f, 7.06973225e-02f, 7.00464239e-04f, 4.46663890e-03f, -3.09279617e-02f, 1.06509170e-02f, 5.15143983e-02f, -4.68591154e-02f, 4.57046321e-03f,
  2.92340294e-03f, -8.53837468e-03f, 7.95954466e-02f, -2.48420034e-02f, 8.62627253e-02f, 5.62250391e-02f, 5.89945838e-02f, 1.04284868e-01f, 7.46968091e-02f, 5.71513921e-03f,
  9.07457471e-02f, 3.62264551e-02f, 4.98228706e-02f, 5.41800680e-03f, -2.82665007e-02f, -3.10895639e-03f, -8.04440677e-02f, 3.19230109e-02f, -2.19623409e-02f, -2.44747326e-02f,
  -3.55880372e-02f, 6.42734841e-02f, -9.55469310e-02f, -9.90579464e-03f, 2.41576228e-02f, 6.03992827e-02f, -3.59018557e-02f, 6.74742237e-02f, -4.87997346e-02f, -9.37807113e-02f,
  2.52192989e-02f, 9.00468696e-03f, 6.46690875e-02f, 4.70959544e-02f, -7.35333189e-03f, 1.44251226e-03f, 3.03191412e-02f, 1.73707970e-03f, -1.35484591e-01f, 7.66266957e-02f,
  1.71717238e-02f, -6.90733269e-02f, 8.60754922e-02f, -3.92538421e-02f, -9.22761783e-02f, 7.11384416e-02f, -5.27331829e-02f, 4.62689325e-02f, -6.55972064e-02f, 7.86734819e-02f,
  -9.95991006e-03f, -2.91967150e-02f, 6.71438128e-02f, 4.65751737e-02f, 7.93236047e-02f, 4.36661243e-02f, -3.47988196e-02f, -3.57976444e-02f, 4.08850331e-03f, 8.89803097e-02f,
  8.46905038e-02f, 3.70337628e-02f, 2.71800328e-02f, -1.81518076e-03f, 5.23681045e-02f, 9.29550081e-02f, -4.37989384e-02f, -8.84146802e-03f, -1.23416791e-02f, 4.81360145e-02f,
  4.18436639e-02f, 6.45769536e-02f, 7.35697523e-02f, -1.32652456e-02f, -9.43275169e-02f, 8.64918306e-02f, -8.05102736e-02f, 7.11232424e-02f, -4.06700186e-03f, -1.01687992e-02f,
  -5.65899909e-03f, -2.17195158e-03f, -8.02557170e-02f, -9.10619795e-02f, -7.00840279e-02f, 2.42827069e-02f, -7.32211769e-02f, -3.68983229e-03f, 2.49793325e-02f, 6.70485524e-03f,
  1.10834278e-01f, -5.11708036e-02f, 2.52455696e-02f, 4.01397608e-02f, 6.92446344e-03f, -4.58346456e-02f, 1.44356266e-01f, 8.22959393e-02f, 1.79197975e-02f, 2.33113635e-02f,
  7.06704780e-02f, 5.10291681e-02f, -3.87255847e-02f, 7.75215924e-02f, 3.07390466e-02f, 1.02707297e-01f, -5.51536381e-02f, 7.93712512e-02f, 5.24923131e-02f, 9.62372720e-02f,
  9.12582353e-02f, -9.12826881e-02f, 2.31916141e-02f, -8.78191143e-02f, 9.17674974e-03f, 7.04595521e-02f, -9.14624035e-02f, 6.54570526e-04f, -2.91834269e-02f, -2.83973496e-02f,
  5.55263944e-02f, 1.02585265e-02f, 3.60907093e-02f, -2.98266821e-02f, 4.46729548e-02f, -6.05601594e-02f, -5.44551983e-02f, -1.31753730e-02f, 2.68749264e-03f, -5.01805730e-02f,
  -7.91479498e-02f, -4.44706269e-02f, 6.17280714e-02f, -9.30773690e-02f, -2.30025090e-02f, -1.20483385e-02f, -7.01786876e-02f, 6.74431026e-02f, 4.85145114e-02f, 9.25800353e-02f,
  1.04512341e-01f, 8.73700753e-02f, 8.92151222e-02f, -2.49280967e-02f, 4.80301678e-02f, -8.73212740e-02f, -8.34732428e-02f, -7.07305148e-02f, -3.32501531e-02f, -6.95025921e-02f,
  3.38141508e-02f, -6.46152273e-02f, 1.89419910e-02f, -6.66916817e-02f, 6.31608739e-02f, -1.46688018e-02f, 2.38332897e-02f, -6.75564557e-02f, 3.74085978e-02f, -8.27479884e-02f,
  5.63260950e-02f, 2.47982796e-02f, -1.50767509e-02f, 2.41598859e-02f, -7.88992420e-02f, 7.13040531e-02f, -2.11628759e-03f, 4.27591354e-02f, 6.76424652e-02f, -7.91275948e-02f,
  6.08105250e-02f, 7.21383318e-02f, -2.82400213e-02f, 3.48769575e-02f, -6.47068694e-02f, 6.06738888e-02f, 1.05649047e-01f, 3.48890722e-02f, 5.24458848e-02f, -6.38694614e-02f,
  -4.45364416e-02f, -1.31666899e-01f, 5.85735105e-02f, -3.50807942e-02f, -1.04736030e-01f, -3.04483939e-02f, -7.71435201e-02f, 1.37539506e-02f, 9.86547023e-02f, 9.73981246e-02f,
  -8.55643377e-02f, 8.27113092e-02f, 4.21673246e-02f, -4.07591695e-03f, 5.43146282e-02f, 6.01180382e-02f, -5.06290048e-02f, 1.88976545e-02f, -2.80696191e-02f, 2.11806856e-02f,
  3.96894552e-02f, -1.52954431e-02f, -5.73317930e-02f, 5.10932058e-02f, -1.01963341e-01f, 4.96130586e-02f, -1.00136131e-01f, -6.66562691e-02f, 5.87452091e-02f, -2.72316970e-02f,
  7.75592476e-02f, -1.91165000e-01f, 1.51285812e-01f, 8.39385688e-02f, 1.34959355e-01f, 8.72392580e-02f, 5.46805821e-02f, -1.02771372e-01f, -1.37470052e-01f, -2.01224402e-01f,
  -3.29818502e-02f, 8.70700330e-02f, 6.79476410e-02f, 4.65324223e-02f, 6.94294944e-02f, 7.21194223e-02f, 6.23725355e-02f, -2.92462464e-02f, 3.70566510e-02f, -7.48818442e-02f,
  9.89522561e-02f, -5.71142063e-02f, 4.98429127e-02f, -1.97767187e-02f, 1.14290833e-01f, 4.94337380e-02f, 5.80319092e-02f, 1.68021202e-01f, 5.18513881e-02f, 1.31894484e-01f,
  -4.85579967e-02f, -9.52078477e-02f, -8.00629184e-02f, -8.92280489e-02f, 2.22930014e-02f, 2.59261578e-02f, 6.65378571e-02f, 9.26040672e-03f, -1.22955712e-02f, 6.16420209e-02f,
  2.40025427e-02f, 9.43214968e-02f, -7.54084438e-02f, 2.24587601e-02f, -1.36035355e-02f, 9.67178121e-02f, 8.63326713e-02f, -3.24718328e-03f, 4.77513149e-02f, 1.18743375e-01f,
  -5.88628538e-02f, 4.98087257e-02f, 1.98580115e-03f, -8.13941360e-02f, 6.35748878e-02f, -1.29383788e-01f, -6.59756115e-05f, -4.86439001e-03f, -1.57960765e-02f, -3.20984982e-02f,
  8.97923782e-02f, 7.80768991e-02f, -2.38439236e-02f, -1.28940530e-02f, 5.87148312e-03f, 2.26547546e-03f, -4.00168635e-02f, -3.65218259e-02f, -5.30685782e-02f, -1.95960142e-02f,
  -1.53498175e-02f, 8.20614174e-02f, 2.83606965e-02f, -8.81665647e-02f, 7.31036067e-02f, 4.96601388e-02f, -6.06952002e-03f, 7.13080764e-02f, 3.74919968e-03f, 7.25232856e-03f,
  -1.23470522e-01f, -7.91497901e-03f, 5.98363727e-02f, 3.47354710e-02f, 2.92544495e-02f, -5.30023351e-02f, -1.42493229e-02f, 4.78897020e-02f, 8.56054202e-02f, 9.90447551e-02f,
  -1.46836579e-01f, -7.57049993e-02f, -3.46836299e-02f, 4.03991081e-02f, 4.71958145e-02f, 5.63973971e-02f, 1.96204130e-02f, -1.92705821e-02f, 5.44170178e-02f, 4.69328314e-02f,
  -3.45550850e-02f, 7.07304776e-02f, -8.72247592e-02f, -1.00702317e-02f, 5.42190894e-02f, -8.60855654e-02f, -5.06593622e-02f, -9.55040008e-02f, -1.24992706e-01f, 2.01111417e-02f,
  -4.20492180e-02f, -3.45644914e-02f, -1.35687459e-02f, -5.04437014e-02f, -6.29407912e-02f, -6.74202219e-02f, -7.23374262e-02f, -1.26804290e-02f, 8.82438943e-02f, 1.02566630e-01f,
  -1.00368317e-02f, 6.92685077e-04f, 8.74979049e-02f, 5.19806109e-02f, 7.68445954e-02f, 2.10327402e-01f, 2.44462192e-01f, 3.29659358e-02f, 1.41160771e-01f, 7.05139199e-03f,
  -6.31216243e-02f, -4.25711982e-02f, -4.50622253e-02f, 1.39679145e-02f, 6.28682598e-02f, 9.00366753e-02f, 1.02300316e-01f, -8.17976519e-03f, 3.85809131e-02f, -7.50548840e-02f,
  2.74894759e-02f, -6.54949248e-02f, 6.23615012e-02f, -2.03166768e-01f, -1.70812204e-01f, -1.57547176e-01f, -1.34696752e-01f, -6.75319508e-02f, -1.39755726e-01f, -1.42697701e-02f,
  4.20549810e-02f, 5.04098721e-02f, 3.40382755e-02f, 2.98271459e-02f, 3.42747080e-03f, -3.66065614e-02f, 2.21914775e-03f, 5.38940169e-02f, 4.86099124e-02f, 1.03586972e-01f,
  1.41892992e-02f, -5.10713421e-02f, 8.35452080e-02f, 7.74816722e-02f, 2.72067860e-02f, 1.65930334e-02f, -5.14493696e-02f, 3.74402478e-03f, 7.92890489e-02f, 6.05486594e-02f,
  4.28360887e-02f, 6.08483478e-02f, -1.00537360e-01f, -1.27512291e-02f, -8.90807621e-03f, 1.55724753e-02f, 4.16114032e-02f, -6.41499907e-02f, -5.03327660e-02f, 6.66099414e-02f,
  2.79392116e-02f, -6.67611435e-02f, 4.56286129e-03f, -6.42098812e-03f, -5.99522553e-02f, -2.96725407e-02f, -2.91069113e-02f, -2.80264709e-02f, -2.71228254e-02f, -1.88522204e-03f,
  7.93991312e-02f, 3.80033590e-02f, 8.08960944e-02f, 3.39151360e-02f, 6.22389577e-02f, -7.33531415e-02f, 5.55015542e-02f, -6.78774342e-02f, 2.10656766e-02f, 3.30758728e-02f,
  -6.56419247e-02f, 5.32789901e-02f, -9.86120552e-02f, -6.02847748e-02f, -1.75753590e-02f, -1.11006357e-01f, -6.67686909e-02f, -8.18351284e-02f, 1.49776246e-02f, -1.83476005e-02f,
  -5.25149480e-02f, 3.97021696e-02f, 4.92992178e-02f, -1.59836560e-03f, -2.16893256e-02f, 1.84231978e-02f, 7.24602938e-02f, -1.91871040e-02f, 5.89637198e-02f, -2.06918474e-02f,
  -4.43414822e-02f, -5.10683656e-02f, 1.10772856e-01f, -1.02305159e-01f, -3.43645252e-02f, -3.27229016e-02f, 5.38061187e-02f, 1.57785062e-02f, 6.99818926e-03f, -4.33890186e-02f,
  -3.58283482e-02f, -2.70351283e-02f, -3.05634327e-02f, -1.24016277e-01f, -2.58982163e-02f, -2.84167118e-02f, -2.97292927e-03f, 2.37058885e-02f, 6.24176264e-02f, -6.20797537e-02f,
  -7.67721236e-02f, 1.95380181e-01f, -7.39552602e-02f, -1.68470055e-01f, 4.81742918e-02f, -6.89474046e-02f, -4.22883667e-02f, 4.32967348e-03f, -9.28188115e-02f, 8.76565799e-02f,
  -1.80315282e-02f, -5.42386621e-02f, -4.17193351e-03f, 1.05720595e-01f, -1.76217869e-01f, 8.03152379e-03f, 5.59646264e-02f, 3.86213255e-03f, -7.03880414e-02f, 7.80446082e-02f,
  -1.21965684e-01f, 1.00586526e-01f, -1.19455978e-01f, 1.40382454e-01f, -6.34647831e-02f, -4.89192195e-02f, -2.35033389e-02f, 1.16596684e-01f, -8.14072415e-02f, 5.88374138e-02f,
  6.28287196e-02f, -1.62282567e-02f, -1.16760746e-01f, -6.66449666e-02f, -9.04027596e-02f, 1.69385429e-02f, -4.72939834e-02f, -8.43967646e-02f, -5.43742031e-02f, 3.49443778e-02f,
  -5.97869121e-02f, -5.31512350e-02f, -4.82179336e-02f, -7.21148327e-02f, -9.28125679e-02f, 4.57762890e-02f, 1.45503250e-03f, -5.06412014e-02f, -7.58223385e-02f, 3.16227251e-03f,
  -6.89589307e-02f, 8.37977380e-02f, -4.89754118e-02f, 2.80814208e-02f, -4.24301475e-02f, -2.86010113e-02f, 1.17831472e-02f, -8.22061375e-02f, -6.07614294e-02f, 1.98249202e-02f,
  -1.65982042e-02f, -5.45055531e-02f, 1.03733316e-01f, 3.14807892e-02f, -1.01121522e-01f, -6.25789165e-02f, -6.87326416e-02f, -7.03853220e-02f, 2.16360539e-02f, 5.64768761e-02f,
  -9.09000337e-02f, -5.98491877e-02f, -2.54603289e-02f, 6.82670176e-02f, 8.65524337e-02f, -5.82913943e-02f, 6.28520101e-02f, -7.47506917e-02f, -1.40844574e-02f, -8.26228932e-02f,
  -2.98785381e-02f, 6.61830306e-02f, -7.17436522e-02f, -3.31184566e-02f, -7.80799761e-02f, -5.11325374e-02f, 4.41780798e-02f, -3.75116207e-02f, -2.98957340e-02f, 7.89148659e-02f,
  7.27149919e-02f, -2.64061224e-02f, 8.31041858e-02f, 4.71219085e-02f, -7.92353004e-02f, 1.99242425e-03f, -3.14286575e-02f, 4.78116572e-02f, -1.84405763e-02f, -6.86823390e-03f,
  -3.58826965e-02f, 6.02362305e-02f, 1.80624407e-02f, -7.90601596e-02f, -1.10995946e-02f, -7.74023235e-02f, 7.09449425e-02f, -1.10759243e-01f, -3.02847996e-02f, -1.69977583e-02f,
  -7.67682940e-02f, 1.13087166e-02f, -5.43152876e-02f, -4.07026820e-02f, -6.39715269e-02f, 7.92361051e-02f, -2.83865575e-02f, -6.22326024e-02f, -1.24169700e-02f, 4.78753634e-02f,
  7.97835458e-03f, -1.22921541e-02f, 5.80112301e-02f, 1.23819768e-01f, 5.43567613e-02f, 1.76296402e-02f, -1.05151638e-01f, 1.00363135e-01f, -1.07262000e-01f, -5.42245172e-02f,
  3.62056680e-02f, 4.09368463e-02f, 7.69352028e-03f, -1.80034116e-02f, -4.30493057e-02f, -1.59792408e-01f, 2.78017446e-02f, -4.59407717e-02f, -6.23792857e-02f, 7.06856996e-02f,
  -2.66734045e-02f, -5.23258485e-02f, 9.97696817e-02f, -1.04400245e-02f, 6.65974393e-02f, 1.36838287e-01f, 3.87725122e-02f, -5.03308419e-03f, 5.27516976e-02f, -9.01969597e-02f,
  4.56257118e-03f, -9.71708074e-02f, -4.89325374e-02f, -7.73532391e-02f, 7.22556263e-02f, -1.55945290e-02f, -1.17562460e-02f, 4.65265214e-02f, 5.12499064e-02f, 4.44584489e-02f,
  3.77502665e-02f, 1.96402147e-02f, 9.22536924e-02f, 4.59200144e-02f, -3.15507762e-02f, -5.07390685e-02f, 2.14016368e-03f, 8.71377438e-02f, -1.21319771e-01f, -7.36294612e-02f,
  -4.14391309e-02f, 7.68898726e-02f, 1.31369665e-01f, 8.16134587e-02f, 9.21084955e-02f, 2.56855488e-02f, -5.36809377e-02f, 1.68168787e-02f, -1.33359630e-03f, 9.72922426e-03f,
  7.03012059e-03f, 6.44666106e-02f, -3.04389056e-02f, 4.36438024e-02f, 1.78742930e-02f, 6.66668937e-02f, 3.78833227e-02f, 6.00809939e-02f, 9.35014244e-03f, -7.38902912e-02f,
  -5.58870472e-02f, -4.33620811e-02f, -1.47668198e-02f, -4.07845303e-02f, 9.87373367e-02f, -2.03852616e-02f, -9.07039735e-03f, -2.64323521e-02f, 5.57243749e-02f, -3.45147364e-02f,
  -5.94049878e-03f, -1.07740378e-02f, -1.62824579e-02f, 2.69935075e-02f, 4.91092028e-03f, 1.41641870e-02f, 2.87165847e-02f, 5.15761413e-03f, 1.75021794e-02f, 1.56997945e-02f,
  7.89401978e-02f, 8.80858377e-02f, -4.14775088e-02f, -1.62486471e-02f, 2.50252727e-02f, 1.05578534e-01f, 1.14661995e-02f, 3.93866152e-02f, 3.84331159e-02f, -2.26699430e-02f,
  -6.79507330e-02f, 3.63779552e-02f, 4.89357375e-02f, -3.45305428e-02f, -7.90212080e-02f, 2.68152095e-02f, -7.27319717e-02f, -8.92323256e-03f, -9.42824595e-03f, -3.05811362e-03f,
  1.88206676e-02f, 6.49768189e-02f, -2.94889659e-02f, 5.04214279e-02f, 5.36286570e-02f, 6.20406680e-02f, -2.68662516e-02f, 4.32040393e-02f, -5.77045009e-02f, -2.19269320e-02f,
  7.29826465e-02f, 1.47791365e-02f, 1.81602553e-01f, -5.15620708e-02f, -3.24800313e-02f, 8.54262933e-02f, 1.19102206e-02f, 1.03651378e-02f, 5.40403724e-02f, -2.12324053e-01f,
  -1.33395478e-01f, -1.76242013e-02f, 9.46221724e-02f, -1.37477666e-01f, 2.20713496e-01f, 1.01688644e-02f, -3.05111390e-02f, -1.02142490e-01f, -1.65521335e-02f, -1.12246893e-01f,
  9.13949609e-02f, -1.44323424e-01f, -3.15709822e-02f, -9.08006653e-02f, -1.06956586e-01f, -2.00370066e-02f, -7.48415217e-02f, -5.59409894e-02f, 1.87104158e-02f, -4.01036665e-02f,
  -8.23495239e-02f, -9.67003256e-02f, -7.78033435e-02f, -7.13855624e-02f, -5.89888766e-02f, 5.13321050e-02f, -2.48839911e-02f, -7.78887197e-02f, 9.24381316e-02f, -2.52924338e-02f,
  -5.05288728e-02f, 5.29420860e-02f, 3.36130783e-02f, 1.79634092e-03f, 4.82858345e-02f, 4.83662821e-03f, 1.21969935e-02f, -5.82271665e-02f, 7.44146407e-02f, 9.21654701e-02f,
  5.55351004e-03f, -8.60967636e-02f, 2.32422762e-02f, -1.06411718e-01f, -1.39057385e-02f, -9.33996513e-02f, -9.19393897e-02f, 2.90033445e-02f, -5.72147854e-02f, 4.21648100e-02f,
  5.35055697e-02f, 8.39884728e-02f, -4.53653596e-02f, 1.08033545e-01f, -3.38887423e-02f, -2.25792304e-02f, 1.87580064e-02f, 9.02009457e-02f, 2.02066209e-02f, 5.36092259e-02f,
  6.09125495e-02f, -8.43462050e-02f, -5.52833192e-02f, -4.64069657e-03f, -6.75865486e-02f, -9.22856387e-03f, 7.39304945e-02f, -6.00971878e-02f, -1.49946474e-02f, -4.90686968e-02f,
  -7.50857517e-02f, -7.05690831e-02f, -2.28098389e-02f, 1.70349628e-02f, 4.38713431e-02f, 4.13213819e-02f, -4.15194444e-02f, 3.18682939e-02f, -4.33438632e-04f, -8.11325982e-02f,
  -1.92488134e-01f, -1.65164411e-01f, -3.61473523e-02f, -6.09391592e-02f, 5.74107245e-02f, 3.29816304e-02f, -5.94039522e-02f, -5.49766310e-02f, -1.73930568e-03f, -5.19631840e-02f,
  -3.19186561e-02f, 2.96684704e-03f, 5.19893840e-02f, -8.55068788e-02f, -5.65712936e-02f, 3.82453017e-02f, -8.99586380e-02f, -9.94986668e-03f, -8.69430229e-02f, -4.67231683e-02f,
  -4.60874699e-02f, 3.61159518e-02f, 5.92100583e-02f, 4.36298437e-02f, -6.53813630e-02f, 7.76057318e-02f, 1.31368020e-03f, 2.42463052e-02f, 2.84468103e-02f, 3.60364132e-02f,
  -1.26401842e-01f, 6.50417283e-02f, 1.74450036e-02f, -2.24485919e-01f, -8.08678381e-03f, -9.20729488e-02f, -3.51312757e-02f, 7.86833614e-02f, -1.07724443e-01f, 8.46137479e-02f,
  -2.45811045e-02f, -4.81565595e-02f, 1.38859808e-01f, -8.33090544e-02f, -9.88968164e-02f, 7.86841586e-02f, -9.66973603e-02f, -2.34194454e-02f, 2.39486489e-02f, -8.47157687e-02f,
  -4.12746072e-02f, -1.44274319e-02f, -2.64515076e-02f, 1.02256782e-01f, -2.15391964e-02f, 3.75333093e-02f, 5.34172356e-02f, -3.71933132e-02f, 3.95878069e-02f, 6.06733859e-02f,
  -2.12991554e-02f, 8.25380757e-02f, 7.27157714e-03f, -9.35686380e-03f, 5.24371080e-02f, -1.71667617e-02f, 9.98176355e-03f, -6.84713796e-02f, 5.54522164e-02f, 9.06702951e-02f,
  -3.81278172e-02f, 9.62569863e-02f, 2.47968454e-02f, 3.03296763e-02f, -5.74571528e-02f, 9.04813223e-03f, 9.17923227e-02f, -1.50401583e-02f, -4.38757688e-02f, -2.79799495e-02f,
  -4.57640253e-02f, 2.28534592e-03f, 1.15671242e-02f, -2.95880754e-02f, -2.77157836e-02f, 4.38076295e-02f, -1.09324425e-01f, 5.69302449e-03f, -4.20802459e-02f, -8.13814178e-02f,
  3.07229217e-02f, 7.02430829e-02f, -1.69595368e-02f, 3.66652682e-02f, -6.13234332e-03f, -6.16055820e-03f, -5.90796769e-03f, 6.48347341e-05f, -8.77920762e-02f, 3.89083363e-02f,
  4.32522483e-02f, -4.62419502e-02f, 1.05730027e-01f, -7.64449909e-02f, -5.74876145e-02f, 3.04204319e-02f, -4.54366170e-02f, -6.93684770e-03f, -5.05321287e-02f, 6.31897077e-02f,
  1.07578635e-01f, 4.56458591e-02f, -1.86596310e-03f, -5.77444211e-02f, 7.80734569e-02f, 2.33426853e-03f, -5.68037741e-02f, -2.62326896e-02f, 8.53983834e-02f, 6.15028059e-03f,
  4.31531072e-02f, -5.03101647e-02f, 6.15603924e-02f, 5.49119748e-02f, 1.36389234e-03f, -1.03368368e-02f, 8.05904567e-02f, -9.53363255e-02f, -8.32534507e-02f, -5.86930364e-02f,
  -5.47288172e-02f, 4.35590930e-02f, 1.16278203e-02f, 2.69572753e-02f, 6.01889417e-02f, -1.67930068e-03f, 6.70647845e-02f, -2.17159335e-02f, -9.75270271e-02f, 6.68644607e-02f,
  5.53822704e-02f, 7.18651619e-03f, -4.29242523e-03f, -6.63864799e-03f, 2.35693045e-02f, -8.93756896e-02f, -2.37815380e-02f, 4.52292413e-02f, -5.47865331e-02f, -6.87209666e-02f,
  1.33964330e-01f, -2.75979072e-01f, 2.76138783e-01f, 8.79337713e-02f, 1.22535683e-01f, 1.20170832e-01f, 1.91825226e-01f, -1.10895425e-01f, 3.48169878e-02f, -2.90723830e-01f,
  -4.62222286e-02f, 8.72361884e-02f, -7.15627242e-03f, 2.35277303e-02f, 2.28516787e-01f, -6.96269572e-02f, -1.05952665e-01f, 4.71761785e-02f, -1.36270048e-02f, 8.25094730e-02f,
  -3.26164663e-02f, -1.01604298e-01f, 1.32756233e-01f, -1.64619282e-01f, 1.64531648e-01f, -6.51095286e-02f, -8.11705291e-02f, 9.43407714e-02f, -1.18779913e-01f, -6.44974187e-02f,
  -7.75045380e-02f, -3.21480855e-02f, 1.54197618e-01f, 3.02758589e-02f, -2.37427223e-02f, -1.40879275e-02f, -1.40649546e-02f, 1.22506224e-01f, -3.85991205e-03f, -8.03031027e-02f,
  -1.26591593e-03f, 3.57219130e-02f, -5.69595285e-02f, 1.78788174e-02f, 7.20538050e-02f, 2.87569053e-02f, 6.82490766e-02f, 1.03126556e-01f, -3.15000899e-02f, -4.02592309e-02f,
  5.93857504e-02f, -1.45552587e-02f, 6.12788536e-02f, -3.63236293e-02f, 7.65631422e-02f, 6.31488264e-02f, 5.77150322e-02f, 3.54651571e-03f, 1.14581222e-02f, 4.26784158e-02f,
  5.30696772e-02f, -2.20018793e-02f, 3.92906554e-02f, -3.68612595e-02f, 8.79575592e-03f, -6.83824867e-02f, -6.88185841e-02f, -4.49606366e-02f, 8.00589249e-02f, -6.33069500e-02f,
  8.00670460e-02f, -4.62502241e-02f, 3.59582435e-03f, -4.25285436e-02f, 6.45258417e-03f, -8.63783155e-03f, -1.22295269e-05f, -3.70770926e-03f, -2.31265947e-02f, 7.24150091e-02f,
  3.15421559e-02f, -4.96664178e-03f, -6.14846200e-02f, 3.10686789e-02f, -5.48460744e-02f, 5.28036095e-02f, -7.15475604e-02f, -9.54613611e-02f, 6.21188711e-03f, 1.14862017e-01f,
  -1.48650259e-01f, -2.38319859e-01f, -3.90186608e-02f, -5.24483584e-02f, 3.38307358e-02f, 4.36067320e-02f, -2.10033078e-02f, -7.30356574e-02f, -2.29138006e-02f, 3.92482616e-02f,
  -5.20107453e-04f, -2.45140330e-03f, -4.19876464e-02f, -4.26274762e-02f, 2.00598147e-02f, -4.57730554e-02f, 6.06654137e-02f, -5.69734201e-02f, 4.17739749e-02f, 1.32449372e-02f,
  2.11934038e-02f, -2.08750442e-02f, 5.10835201e-02f, -4.37258603e-03f, -5.01964018e-02f, 1.53893810e-02f, -3.79009657e-02f, -1.60962362e-02f, -7.71513283e-02f, -8.92252028e-02f,
  1.70830246e-02f, -1.01211190e-01f, -3.95173244e-02f, 2.04610806e-02f, -1.04994997e-02f, -9.07773003e-02f, -5.93897142e-02f, -6.12505153e-02f, 1.25320163e-02f, -1.37241751e-01f,
  -9.21166539e-02f, 4.54716124e-02f, -7.44421855e-02f, -1.02767035e-01f, 1.59579851e-02f, 5.88619485e-02f, -1.11209616e-01f, 6.50500041e-03f, 4.48793992e-02f, -4.32707109e-02f,
  1.95130091e-02f, -3.10941190e-02f, 1.30335921e-02f, 5.73296973e-04f, -1.11091949e-01f, -7.02139512e-02f, 4.80709672e-02f, -6.14587776e-02f, -2.13758294e-02f, 9.15314779e-02f,
  -1.02846593e-01f, -5.87488413e-02f, -3.29861417e-02f, 6.19533882e-02f, 5.87751449e-04f, -5.79749458e-02f, 7.63306320e-02f, 8.75419825e-02f, 1.02829868e-02f, -8.46719295e-02f,
  9.73873946e-04f, 2.63827927e-02f, -4.75666299e-03f, -4.38539498e-02f, 4.72972617e-02f, -1.55780567e-02f, -3.33248824e-02f, 1.77623928e-02f, -5.58959134e-02f, -3.87764187e-03f,
  7.96615258e-02f, -2.29838900e-02f, 3.17393281e-02f, 2.24324986e-02f, 7.28363916e-02f, 4.97246757e-02f, 1.00669838e-01f, 7.03582987e-02f, -4.23177071e-02f, 2.62702480e-02f,
  -5.66023460e-04f, -7.85036832e-02f, 3.87834880e-04f, -7.13892654e-02f, -3.80465835e-02f, 3.31901312e-02f, 2.04844661e-02f, 6.77960813e-02f, 2.98485402e-02f, 4.91074845e-03f,
  1.59591530e-02f, 7.44024366e-02f, 5.97904995e-03f, -8.94137099e-02f, 3.23117827e-04f, -3.37858126e-02f, 3.54248732e-02f, -4.25569937e-02f, -4.52349707e-02f, 3.47966179e-02f,
  6.59090132e-02f, 3.26869600e-02f, 1.33730313e-02f, -7.38588721e-02f, 3.91351758e-03f, -4.96478342e-02f, -2.74094753e-02f, 3.10377255e-02f, -5.87252676e-02f, -4.93796282e-02f,
  -1.53387964e-01f, -6.12377301e-02f, 2.32801456e-02f, 3.90531532e-02f, -1.13994911e-01f, -5.13288379e-02f, 8.98475423e-02f, 7.49570280e-02f, -3.10935583e-02f, -6.88929157e-03f,
  8.64291638e-02f, -9.27815884e-02f, 2.18750555e-02f, 2.21443772e-02f, -4.61621135e-02f, 6.96634576e-02f, -5.48146293e-02f, -2.72966642e-02f, -9.82672647e-02f, 7.60439187e-02f,
  5.67539223e-03f, -6.28705742e-03f, -2.44356208e-02f, 1.70429256e-02f, 1.35453595e-02f, -2.11663637e-03f, 2.89634224e-02f, -2.92025339e-02f, -1.50322691e-02f, -2.49919984e-02f,
  -5.74031025e-02f, 7.18148276e-02f, 4.39054184e-02f, 1.41746610e-01f, -1.71471402e-01f, -3.08883369e-01f, -2.45597348e-01f, -5.84237017e-02f, -4.94343080e-02f, -7.85129368e-02f,
  4.25941274e-02f, 2.08788402e-02f, -5.81981763e-02f, 8.52831230e-02f, 2.48210326e-01f, 7.34280497e-02f, 1.00411855e-01f, -2.56133322e-02f, 1.11937836e-01f, 6.71170950e-02f,
  2.18138546e-01f, 1.13626599e-01f, 2.75270939e-01f, 7.75714442e-02f, 7.26255700e-02f, 1.46796077e-01f, 2.51174331e-01f, 8.13565701e-02f, 1.41647622e-01f, 1.06233224e-01f,
  -1.33176846e-02f, 6.67220429e-02f, 1.41338948e-02f, 8.33508093e-04f, -8.37792158e-02f, -1.14017315e-01f, -6.25268519e-02f, -3.20228785e-02f, -1.96415815e-03f, -1.64237898e-02f,
  9.64005478e-03f, -6.07444858e-03f, -6.12222813e-02f, -9.06647649e-03f, -7.41612613e-02f, 8.75895321e-02f, 7.16650411e-02f, -2.52317004e-02f, -9.16965678e-03f, -3.74992937e-02f,
  4.37062122e-02f, 3.65795456e-02f, -7.91101083e-02f, 5.98673187e-02f, 1.07499301e-01f, 2.44011488e-02f, -1.50798662e-02f, 8.77179801e-02f, -6.30713105e-02f, -4.11953777e-02f,
  -3.01085208e-02f, -3.99724357e-02f, -2.67907046e-02f, -3.42321880e-02f, -2.00858433e-02f, 1.51780723e-02f, 1.02352817e-02f, 6.70394450e-02f, -1.10403709e-02f, 6.47420213e-02f,
  -2.38083079e-02f, -2.52815690e-02f, 3.64737213e-02f, -6.09733835e-02f, -2.79635936e-02f, -2.23552976e-02f, 1.84357800e-02f, 3.79998051e-02f, 5.25719933e-02f, 5.62387006e-03f,
  -6.95318431e-02f, 4.27118987e-02f, -1.79204736e-02f, -6.35202229e-03f, -9.21869129e-02f, 7.15338588e-02f, 1.04332425e-01f, -7.30195120e-02f, -5.93167841e-02f, -6.00341335e-02f,
  3.18132006e-02f, 2.55063862e-01f, -1.05571292e-01f, 1.72327179e-02f, 2.54303124e-02f, 2.72564050e-02f, 1.43632684e-02f, -1.63931493e-02f, 3.11149880e-02f, -7.20987469e-02f,
  4.54733148e-02f, 1.93031654e-02f, 3.23205702e-02f, -5.73538095e-02f, -1.24509512e-02f, -4.74144593e-02f, -3.16399988e-03f, 4.00263555e-02f, 3.37254442e-02f, 1.14149712e-01f,
  1.85133552e-03f, -8.04613307e-02f, 2.97577083e-02f, 2.45592799e-02f, 6.16866015e-02f, -4.19822000e-02f, -2.10525971e-02f, -4.39081080e-02f, 9.25542712e-02f, 2.82459427e-02f,
  -1.63210884e-01f, 1.10263720e-01f, -1.63365856e-01f, -6.87793717e-02f, -1.96446717e-01f, 1.62279382e-01f, 1.09946996e-01f, -1.02428317e-01f, -1.13026246e-01f, 1.45802081e-01f,
  1.47042036e-01f, -1.02711655e-01f, 2.07432523e-01f, 2.24706665e-01f, 2.43539666e-03f, 2.40813538e-01f, 1.92366809e-01f, 1.75894096e-01f, -3.07017304e-02f, -1.79992747e-02f,
  -4.28540409e-02f, 1.59764722e-01f, 1.84925959e-01f, 4.36482169e-02f, 7.78354285e-03f, -2.00650752e-01f, -8.40431675e-02f, -7.58906454e-02f, 5.99752665e-02f, -2.10150257e-02f,
  1.55413449e-01f, -1.33713363e-02f, -6.97337673e-04f, -3.33239920e-02f, 4.27230913e-03f, 1.57770736e-03f, -1.55005674e-03f, -2.99677532e-02f, -6.15157485e-02f, -7.07966369e-03f,
  3.22033875e-02f, -9.12713110e-02f, 5.03527187e-02f, -7.49694034e-02f, -6.15994930e-02f, -3.51235718e-02f, -7.85204768e-02f, -3.33249941e-02f, 2.61524855e-03f, -1.15395039e-02f,
  -3.95413116e-02f, -4.64054048e-02f, -1.34180430e-02f, -1.95415989e-02f, -3.93832214e-02f, -3.03076599e-02f, 2.88175493e-02f, 3.52022685e-02f, -5.42007834e-02f, -7.61265904e-02f,
  -2.97075114e-03f, -5.92671372e-02f, 1.31782725e-01f, 5.63178435e-02f, 2.57253889e-02f, 3.63598727e-02f, 3.03757880e-02f, -4.02218103e-02f, -8.12803358e-02f, 7.99889639e-02f,
  7.16936728e-03f, -7.76251778e-02f, 6.73421845e-02f, -3.05357873e-02f, -2.56564450e-02f, 5.83570637e-02f, -1.66402142e-02f, -1.52833182e-02f, 1.29144629e-02f, 4.60028797e-02f,
  -1.89722683e-02f, -4.02969457e-02f, 6.05824664e-02f, 6.42719343e-02f, -2.63337865e-02f, -5.75420074e-03f, 1.43818455e-02f, 4.15753685e-02f, -2.71107573e-02f, -3.06599978e-02f,
  -2.95696631e-02f, -1.55260777e-02f, 4.77674119e-02f, -1.53374244e-02f, -1.50272762e-02f, 6.72028959e-02f, 2.87671909e-02f, 1.89242663e-03f, -9.99509543e-02f, -3.93224582e-02f,
  -7.53649790e-03f, -5.22877350e-02f, 2.61696447e-02f, -8.28702450e-02f, -1.06767572e-01f, 4.11655642e-02f, 1.83779001e-02f, 4.43841554e-02f, -7.18706027e-02f, -4.69435565e-02f,
  5.16320318e-02f, 6.55361116e-02f, -5.20279296e-02f, -2.98294835e-02f, 6.78496761e-03f, 2.29815915e-02f, -6.19487390e-02f, -2.67672576e-02f, 2.19796747e-02f, -7.79493228e-02f,
  1.63885385e-01f, -1.68148254e-03f, -4.60352339e-02f, -8.83243382e-02f, -3.63328531e-02f, 1.70733668e-02f, 6.99703693e-02f, -1.42082572e-02f, -1.46400645e-01f, -5.49455807e-02f,
  -3.69459726e-02f, -1.38940036e-01f, -1.44465547e-02f, 1.09482072e-01f, -1.90285593e-02f, -6.45567402e-02f, 3.09946779e-02f, -4.76189069e-02f, -1.09677449e-01f, -6.72894809e-03f,
  6.09806329e-02f, 4.94841523e-02f, -8.78460184e-02f, 4.40902933e-02f, 9.11451653e-02f, -8.04667696e-02f, -3.81454490e-02f, 2.57979687e-02f, 8.24144632e-02f, -7.04955775e-03f,
  1.12956591e-01f, -6.53451681e-02f, 3.27538215e-02f, -4.77746055e-02f, 5.66726997e-02f, 9.93402861e-03f, -2.25130301e-02f, 4.45551425e-02f, 3.72985527e-02f, -6.60026446e-02f,
  8.72820914e-02f, -7.43279606e-02f, -4.82477695e-02f, -3.73071283e-02f, -5.51194586e-02f, 1.99000761e-02f, -1.57183167e-02f, -4.96750288e-02f, -6.51606470e-02f, -4.63094525e-02f,
  5.74697033e-02f, -7.96845332e-02f, -2.33797282e-02f, -6.03163242e-02f, -4.28558290e-02f, -7.86276236e-02f, -8.04416761e-02f, -4.25680391e-02f, 1.78803653e-02f, 3.78940031e-02f,
  5.32133579e-02f, -5.85619397e-02f, 4.52272296e-02f, 2.78107878e-02f, 2.21502483e-02f, -7.91835710e-02f, 5.58867119e-02f, 2.06852574e-02f, -4.06348854e-02f, 8.11595395e-02f,
  6.61195591e-02f, -1.23908957e-02f, 5.18064201e-02f, -3.60014364e-02f, 5.89895137e-02f, 6.20500967e-02f, -4.71243002e-02f, -2.67575309e-02f, -3.81393395e-02f, 3.99669446e-02f,
  -6.32895082e-02f, 3.56833823e-02f, -1.88608598e-02f, -7.45872408e-02f, -5.93427345e-02f, -8.22472945e-02f, -6.92324713e-02f, -3.41655090e-02f, -3.48104462e-02f, 5.41060492e-02f,
  1.09299935e-01f, 6.85623437e-02f, -3.30236554e-02f, 5.38934432e-02f, -5.83099760e-02f, -6.53295144e-02f, -4.10860404e-02f, -8.18266794e-02f, -4.42843288e-02f, 9.96595025e-02f,
  -1.10621732e-02f, 8.27568024e-02f, -2.48204339e-02f, -3.80221121e-02f, -2.79850718e-02f, 4.84213121e-02f, 9.88758430e-02f, 8.97724461e-03f, 3.75294201e-02f, -1.50922919e-02f,
  2.94288788e-02f, 8.30628499e-02f, -1.07406192e-02f, 3.39600593e-02f, 6.71611726e-02f, 7.28712380e-02f, -8.26255884e-03f, 7.27013946e-02f, 1.60460807e-02f, 6.51042238e-02f,
  -5.32555729e-02f, -1.19146466e-01f, -6.10317215e-02f, 3.02921375e-03f, 1.15063153e-01f, 5.30274063e-02f, -3.85708176e-02f, 4.77547869e-02f, -5.99145778e-02f, -2.57065333e-02f,
  1.12054413e-02f, -2.89074902e-04f, -6.42013699e-02f, -7.33977780e-02f, 6.26503080e-02f, -2.72430014e-02f, 4.40717787e-02f, -6.01983443e-02f, -2.39817053e-02f, -4.07056697e-02f,
  -3.41059156e-02f, 9.16431248e-02f, 7.53424643e-03f, -4.25114594e-02f, 4.16352414e-03f, 2.04832945e-02f, -1.78424828e-03f, 1.71438232e-02f, -1.56242661e-02f, -8.02926719e-03f,
  -3.29097584e-02f, -7.04663023e-02f, 7.35268891e-02f, 8.70811939e-02f, -4.04699054e-03f, 1.05720781e-01f, -8.11608788e-03f, 2.14285310e-02f, -1.18897604e-02f, 9.10003707e-02f,
  -9.43549573e-02f, -5.75064942e-02f, 4.73318659e-02f, 6.96393312e-04f, 4.30242307e-02f, -1.89344008e-02f, 3.77067886e-02f, 5.30556291e-02f, -5.22320196e-02f, -5.46622425e-02f,
  -1.00220628e-01f, -9.89248231e-03f, 2.98271812e-02f, -9.38526075e-03f, -7.30399713e-02f, -3.04730292e-02f, -4.05500941e-02f, -1.01779960e-01f, 1.32398168e-02f, -3.97840887e-02f,
  7.70400986e-02f, 1.43118494e-03f, 3.21269445e-02f, 2.72366703e-02f, 2.91422997e-02f, 5.45038171e-02f, 6.59820810e-02f, 4.81245182e-02f, 5.55408411e-02f, -3.37522477e-02f,
  -3.64008732e-02f, -8.14063698e-02f, -7.94045534e-03f, -4.36215363e-02f, 4.63742130e-02f, 3.21615934e-02f, -2.52326820e-02f, 7.20243249e-03f, 3.26066762e-02f, 7.77400658e-02f,
  -1.66130662e-02f, 3.04639898e-02f, 8.24993104e-02f, -6.34562671e-02f, 6.96026832e-02f, -7.87039399e-02f, 6.23884015e-02f, 3.31730507e-02f, 4.08319794e-02f, 1.52914096e-02f,
  1.62398221e-03f, 2.42841076e-02f, 8.05992708e-02f, 4.18797210e-02f, 6.08936474e-02f, 8.93664658e-02f, 5.82145043e-02f, -3.08785941e-02f, 7.47802109e-02f, 3.99480388e-02f,
  6.67290587e-04f, -7.32208416e-02f, 8.75354409e-02f, 2.82951929e-02f, -2.43127439e-02f, 7.04677403e-02f, -1.00450508e-01f, -3.13622355e-02f, 2.09666397e-02f, 4.39926051e-02f,
  -5.12203574e-02f, -2.27439497e-02f, 8.21814910e-02f, 6.51884228e-02f, -4.68011759e-02f, -2.15333700e-02f, -2.65322253e-02f, -5.75521216e-02f, -6.73504025e-02f, -8.05576448e-04f,
  -8.85710716e-02f, -2.04912126e-02f, -7.38393702e-03f, -1.96097270e-02f, 9.18532610e-02f, 1.74536891e-02f, 9.88685638e-02f, 2.40986235e-02f, 1.73979625e-02f, -1.84984103e-01f,
  -9.62664112e-02f, -1.50265157e-01f, 3.12313195e-02f, -6.25240281e-02f, 9.15060937e-02f, 9.06142518e-02f, -4.62105200e-02f, -1.30021855e-01f, 8.59280154e-02f, -1.51431002e-02f,
  6.08516671e-02f, 2.60857809e-02f, 1.16767466e-01f, 1.37818409e-02f, 5.19583039e-02f, -9.68122631e-02f, -7.05874637e-02f, 1.21597290e-01f, -6.40217960e-02f, 5.46791926e-02f,
  -2.15354897e-02f, -9.47215632e-02f, -7.77123123e-02f, -9.82567891e-02f, -2.84104571e-02f, 8.39558244e-02f, -6.31722854e-04f, 7.66277388e-02f, -4.59152870e-02f, 7.35825300e-02f,
  2.81282924e-02f, -2.04683952e-02f, -9.52227041e-03f, -1.92325767e-02f, 4.35814522e-02f, 7.56108090e-02f, -3.73643637e-02f, 1.89370252e-02f, -7.21987039e-02f, 4.43933345e-02f,
  1.18154444e-01f, -3.44545022e-02f, 2.09776908e-02f, -4.69706841e-02f, 1.59970038e-02f, -1.73775796e-02f, -2.32330095e-02f, -6.98753297e-02f, -1.54289994e-02f, -8.64118896e-03f,
  -3.66731957e-02f, -4.43724617e-02f, -3.51668969e-02f, -7.65824243e-02f, 6.47695288e-02f, 5.94889075e-02f, 8.07934254e-02f, -7.53082111e-02f, 5.64200692e-02f, -2.59788837e-02f,
  -3.98409180e-02f, -3.83142643e-02f, 1.41410008e-02f, -5.34965098e-02f, -5.50903119e-02f, -6.94794441e-03f, -8.16199705e-02f, -1.07567608e-01f, 8.87165871e-03f, -1.55641828e-02f,
  1.85859706e-02f, -2.25084946e-02f, 6.17269874e-02f, -7.08566383e-02f, -7.24527761e-02f, -8.63805935e-02f, -1.18735451e-02f, 1.47299860e-02f, 2.71587260e-02f, 1.29891681e-02f,
  -9.22737122e-02f, -7.90928677e-02f, -8.54053944e-02f, -4.02218737e-02f, -1.05219364e-01f, -5.47007211e-02f, -1.80829521e-02f, 1.34428320e-02f, -6.43811077e-02f, 1.46590248e-02f,
  -5.16422465e-02f, -8.75519738e-02f, 6.57202210e-03f, -2.02721488e-02f, -1.04594259e-02f, -6.53610704e-03f, -8.97038803e-02f, -5.84241785e-02f, -7.06954685e-04f, 2.43337825e-02f,
  -7.81446695e-02f, -5.67425378e-02f, 4.08126786e-03f, -7.58516490e-02f, 3.21637876e-02f, 2.68445238e-02f, -7.41257891e-02f, 8.51511117e-03f, 3.55630554e-02f, 4.47192900e-02f,
  1.97932124e-02f, 5.93236610e-02f, 7.34743625e-02f, 2.42185779e-03f, 3.43313850e-02f, -9.90555733e-02f, -1.08818658e-01f, 9.73208994e-02f, 5.00913560e-02f, 3.75738107e-02f,
  5.72464615e-02f, -5.20530678e-02f, 1.24903858e-01f, -1.22964598e-01f, -1.45499986e-02f, 3.10102906e-02f, -2.01810777e-01f, -1.14764147e-01f, 4.23244461e-02f, -5.15108779e-02f,
  -8.88349041e-02f, -1.83579013e-01f, -1.71219990e-01f, -2.55225841e-02f, -6.75242618e-02f, -1.44873187e-03f, -3.63881071e-03f, 1.36995986e-02f, -2.33836081e-02f, 1.07302899e-02f,
  7.60996193e-02f, 6.10699207e-02f, 1.06563732e-01f, 2.21014246e-02f, 7.52079673e-03f, -9.72258747e-02f, 2.66599469e-02f, 4.81918314e-03f, 1.42959394e-02f, -3.18468884e-02f,
  4.66436148e-02f, -6.74409494e-02f, 2.45447960e-02f, 2.92461049e-02f, -9.09216478e-02f, 9.45368260e-02f, 2.95306626e-03f, 9.71620604e-02f, 4.81154956e-02f, -7.66834468e-02f,
  1.28779551e-02f, -4.17271033e-02f, -1.14447840e-01f, -2.06707381e-02f, -6.03014976e-03f, -3.57144105e-04f, -1.48077160e-02f, -8.51120893e-03f, -3.36373039e-02f, -3.80915627e-02f,
  2.39846148e-02f, -7.62810260e-02f, 4.51271841e-03f, 6.73041418e-02f, -1.01672225e-02f, 1.09819397e-01f, -1.69955157e-02f, -1.47759374e-02f, -1.95032060e-02f, 3.64784449e-02f,
  -9.90034197e-04f, 5.34879118e-02f, 3.04872505e-02f, 1.73289701e-02f, 2.59305835e-02f, 3.39101814e-02f, 2.70731058e-02f, 3.06787100e-02f, -1.94228324e-03f, -8.44953433e-02f,
  4.99699963e-03f, -7.33535644e-03f, 5.54836914e-02f, 2.12701410e-02f, 1.29289543e-02f, 1.77245978e-02f, -7.62283355e-02f, 5.03932908e-02f, 7.24180490e-02f, 4.09007678e-03f,
  -5.14003932e-02f, 1.50308013e-02f, -6.07566163e-02f, 2.90566683e-02f, -3.42062637e-02f, 5.89112155e-02f, -1.04948513e-01f, 4.54308279e-02f, 3.38017987e-03f, 1.67967528e-02f,
  2.90777888e-02f, 2.47992110e-02f, -4.28558625e-02f, -2.09227279e-02f, 8.12858064e-03f, 5.45019582e-02f, 3.05784866e-02f, -6.55521154e-02f, -7.20765442e-02f, -2.42495034e-02f,
  4.77066934e-02f, -4.81288545e-02f, 5.12226932e-02f, -8.75157639e-02f, -4.62867171e-02f, 4.74694781e-02f, -7.59719536e-02f, -7.92171899e-03f, -3.36403511e-02f, -3.26229334e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.87682789e-03f, 1.33340955e-02f, 1.32931203e-01f, 2.22995222e-01f, 2.52572536e-01f, 1.06923632e-01f, 4.52005193e-02f, 1.63240865e-01f, 7.72128627e-02f, 2.33638808e-01f,
  1.94265589e-01f, 2.55475312e-01f, 3.46431077e-01f, 1.53718174e-01f, -9.42643434e-02f, 1.34014547e-01f, -3.46316062e-02f, 5.05035743e-02f, 1.04106031e-01f, 2.64665216e-01f,
  7.52333850e-02f, 8.90908018e-02f, 1.54921189e-01f, 5.06106988e-02f, -1.83969401e-02f, 1.43092871e-01f, 1.03586525e-01f, 4.57129963e-02f, 7.50449998e-03f, 5.61979786e-03f,
  -1.21315867e-02f, 1.54575974e-01f, 8.73225257e-02f, 2.63789576e-02f, 1.36910871e-01f, 7.10444003e-02f, 8.33497643e-02f, 6.04993626e-02f, 9.25277248e-02f, 2.40662366e-01f,
  1.75066084e-01f, 5.33482283e-02f, 1.47195920e-01f, 1.93334036e-02f, 2.19003841e-01f, -2.48271655e-02f, 1.65244322e-02f, 8.94944295e-02f, 4.18582037e-02f, -1.92629974e-02f,
  5.12631461e-02f, -4.43886593e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.41888261e-01f, -1.10721774e-01f, -7.47400988e-03f, -1.21016428e-01f, -1.35517359e-01f, -1.78292334e-01f, -1.55502334e-01f, 1.32720377e-02f, 1.80370688e-01f, 7.15410858e-02f,
  -5.84048312e-03f, -9.15825143e-02f, 3.36022563e-02f, 1.16308071e-01f, -2.59759109e-02f, 5.29714897e-02f, 1.62937999e-01f, 8.78896564e-02f, -6.57063574e-02f, -1.35219738e-01f,
  -1.20028295e-01f, -6.99794665e-02f, 2.54671812e-01f, -1.08665964e-02f, -5.47753945e-02f, 1.42311141e-01f, -8.40927288e-02f, 2.82541439e-02f, 2.87401285e-02f, -7.31858164e-02f,
  -9.94333774e-02f, 1.21803708e-01f, 7.10268468e-02f, 1.19069330e-02f, 8.51429328e-02f, -3.55694182e-02f, -1.77930444e-02f, -7.48767629e-02f, -1.36269316e-01f, 5.65080233e-02f,
  -6.67311624e-02f, 1.24368332e-01f, 1.01833910e-01f, 1.22741021e-01f, 5.53580113e-02f, -5.48287183e-02f, 4.63487022e-03f, 4.82848212e-02f, -1.38851628e-01f, -1.34536490e-01f,
  -9.67784896e-02f, -2.59460025e-02f, 6.49775490e-02f, -1.16025418e-01f, 5.05422130e-02f, -1.10063292e-02f, -1.31981879e-01f, 1.40826926e-02f, 2.19135463e-01f, 6.27702475e-02f,
  4.62133735e-02f, 6.71253130e-02f, 1.06448524e-01f, -6.09174892e-02f, 2.10962389e-02f, 6.40918463e-02f, -7.15812966e-02f, 8.44995677e-02f, -2.55956617e-03f, 1.52998492e-01f,
  1.49081498e-01f, -1.70161098e-01f, -2.99533773e-02f, -1.80804878e-01f, -8.16838909e-03f, -6.94642067e-02f, -1.38036266e-01f, 5.87715842e-02f, 2.09698796e-01f, 8.30149949e-02f,
  -1.95177913e-01f, -1.14607796e-01f, 8.65767077e-02f, 1.50362715e-01f, 1.18980199e-01f, 8.93655047e-02f, -1.30357906e-01f, -9.21226740e-02f, 8.66807103e-02f, 6.82194754e-02f,
  -1.53813986e-02f, 1.14142047e-02f, 8.39949846e-02f, -1.29119441e-01f, 4.76061925e-02f, -1.95328102e-01f, -1.31333560e-01f, -5.91702759e-02f, 1.18345238e-01f, -1.47236595e-02f,
  -8.74128342e-02f, -4.00836244e-02f, 4.44859415e-02f, -2.36334112e-02f, 1.95633881e-02f, -1.46355465e-01f, 5.32771014e-02f, -1.33757442e-01f, 1.36168584e-01f, 8.74227434e-02f,
  -6.62471354e-02f, -1.26997232e-01f, 9.61246565e-02f, -9.64073278e-03f, 2.74489690e-02f, 1.67838559e-02f, 1.11202626e-02f, 4.21670005e-02f, -2.57533137e-02f, -1.12541646e-01f,
  1.30797893e-01f, 6.19465001e-02f, -1.29271597e-01f, 1.44742325e-01f, 8.45245793e-02f, 6.46351799e-02f, 8.56331736e-02f, 2.25299317e-03f, -1.20823346e-01f, 4.94476669e-02f,
  -9.38794687e-02f, -1.07809976e-01f, 1.27851255e-02f, -2.45366748e-02f, 1.54788541e-02f, -1.46248892e-01f, -1.71479129e-03f, 2.34286413e-02f, 7.74354190e-02f, -1.56438321e-01f,
  -8.59622285e-02f, 3.08344383e-02f, 5.73103270e-03f, 1.18499383e-01f, -1.17739201e-01f, -5.55942804e-02f, 8.11715871e-02f, 2.85689253e-02f, -2.55413689e-02f, -1.35468125e-01f,
  -2.23072290e-01f, 4.52954583e-02f, -3.74657400e-02f, 9.36853141e-02f, 1.24482609e-01f, 2.79214501e-01f, -1.02940306e-01f, -1.31187469e-01f, -5.30926436e-02f, -1.91095293e-01f,
  1.69947464e-02f, 3.20446454e-02f, 1.23416297e-02f, 7.36057237e-02f, 4.32243943e-02f, -1.69794425e-01f, -2.53422502e-02f, 1.60947964e-01f, -1.26089022e-01f, -1.34536341e-01f,
  -3.77536267e-02f, 2.28427231e-01f, 8.59695971e-02f, 5.58842607e-02f, 1.50134396e-02f, -3.66373657e-04f, 1.28777087e-01f, 8.35610330e-02f, 1.33227125e-01f, -4.23136614e-02f,
  -1.46636413e-02f, 1.32206842e-01f, -1.18052222e-01f, -1.46169201e-01f, 1.09320112e-01f, 1.10401690e-01f, -1.27468452e-01f, -9.86819342e-02f, 1.52196720e-01f, 1.05671898e-01f,
  9.04439483e-03f, 5.68860024e-02f, 1.89884212e-02f, -1.25415996e-01f, 1.20741092e-01f, 1.17764264e-01f, -9.35934708e-02f, 1.27528295e-01f, 3.49646248e-02f, -4.08672448e-03f,
  -1.56093687e-01f, 2.64354974e-01f, -2.14554459e-01f, 1.20827757e-01f, -5.70370518e-02f, -1.03988141e-01f, 8.17321464e-02f, -6.22412190e-03f, 3.33976895e-02f, -5.94236739e-02f,
  -8.32371265e-02f, 1.50045231e-01f, -4.29397747e-02f, -6.53092638e-02f, 3.73679306e-03f, 2.21234977e-01f, -1.45038754e-01f, 1.44128963e-01f, 4.49308492e-02f, -6.54501170e-02f,
  8.20717122e-03f, 6.31447956e-02f, -1.36864707e-01f, 1.57298580e-01f, -1.06066838e-01f, 2.29391586e-02f, 1.09815234e-02f, -9.93811190e-02f, -1.87221915e-02f, -6.49811625e-02f,
  1.11408094e-02f, -3.36410329e-02f, 1.19903404e-02f, 3.45435329e-02f, 1.72167011e-02f, -5.65311275e-02f, 2.53767166e-02f, 2.05507483e-02f, 1.44872084e-01f, 7.03659132e-02f,
  -7.03146160e-02f, -2.28744689e-02f, 8.67081285e-02f, -1.41513571e-01f, -6.56299889e-02f, -3.21094543e-02f, 1.21862730e-02f, -3.85195240e-02f, 1.28204837e-01f, 5.27042225e-02f,
  -1.06936544e-02f, -6.80070221e-02f, -1.28706381e-01f, 1.86062790e-02f, 8.40334445e-02f, 1.61090285e-01f, 1.36074051e-01f, 6.65411204e-02f, -4.35465463e-02f, 2.01968595e-01f,
  -3.83824413e-03f, -1.16564152e-04f, -2.34687701e-03f, -2.09001034e-01f, 6.30458295e-02f, -2.43365504e-02f, -5.23936413e-02f, -4.89628911e-02f, 1.41308680e-01f, -2.99928859e-02f,
  2.07817391e-03f, 1.38731107e-01f, 6.11521257e-03f, -3.77886966e-02f, 2.84493268e-02f, 6.34263232e-02f, 1.32827759e-01f, -4.12378497e-02f, 1.91587165e-01f, -5.60436733e-02f,
  4.99817804e-02f, 2.33897284e-01f, -2.79286578e-02f, -8.37107524e-02f, 3.17806639e-02f, -9.21048298e-02f, -1.00675896e-01f, 3.19893472e-02f, -5.36760949e-02f, -1.87307835e-01f,
  7.43309110e-02f, -1.16438068e-01f, 7.56789446e-02f, 4.24464196e-02f, 1.85135424e-01f, -1.47388145e-01f, 7.89135247e-02f, -1.18250757e-01f, 2.43640710e-02f, -2.61076335e-02f,
  7.13266507e-02f, -1.77828506e-01f, 6.18057661e-02f, -9.45873931e-02f, 1.22018950e-02f, 1.08353987e-01f, 1.36148751e-01f, 1.28743514e-01f, -1.32686257e-01f, -1.38164818e-01f,
  2.25166485e-01f, -1.00825623e-01f, 2.49738514e-01f, 5.30208871e-02f, -2.46771574e-02f, 3.42875794e-02f, 2.66154222e-02f, 6.92717060e-02f, 1.67137295e-01f, 4.68610302e-02f,
  6.79484010e-02f, 9.34859440e-02f, 9.64586735e-02f, -1.75135303e-02f, 2.04408795e-01f, 1.19512081e-01f, 5.64619191e-02f, 5.77821620e-02f, -3.21007594e-02f, -1.39062256e-01f,
  2.73175031e-01f, -1.65491644e-02f, 2.70486679e-02f, 2.92515941e-03f, -6.09556166e-03f, -1.12129478e-02f, -1.86439261e-01f, -2.58072633e-02f, 1.16914771e-01f, -1.19848363e-02f,
  -3.40107866e-02f, 1.45044893e-01f, -2.00002298e-01f, -6.66269213e-02f, 2.17832118e-01f, -1.35422409e-01f, -6.43774346e-02f, -1.71949372e-01f, 5.00159978e-04f, -4.98697385e-02f,
  6.46000355e-02f, -1.32818371e-01f, -1.55107245e-01f, 5.14907651e-02f, -1.34850740e-01f, 2.31551994e-02f, 5.08029771e-04f, 4.83168438e-02f, 1.44968629e-01f, 1.58683304e-02f,
  2.53617130e-02f, -8.86307508e-02f, 1.47718862e-01f, -4.80871350e-02f, 8.10264274e-02f, 3.46283838e-02f, -1.27657413e-01f, 5.62734455e-02f, 4.59396020e-02f, 6.62344648e-03f,
  4.85808179e-02f, -2.46673506e-02f, 8.23825076e-02f, -4.04045843e-02f, -1.41122788e-02f, 4.74432558e-02f, 9.38911140e-02f, -2.25969795e-02f, 1.35137094e-02f, 2.21981272e-01f,
  -3.46380956e-02f, -9.84630734e-02f, -2.65417009e-04f, -1.17427014e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.34478480e-02f, -6.02765419e-02f, 7.18054101e-02f, -7.48345107e-02f, 1.08747624e-01f, 9.38835647e-03f, -9.85824093e-02f, 2.36913431e-02f, -5.65975569e-02f, -8.45757350e-02f,
  -1.03862807e-01f, 3.79342549e-02f, 6.78344741e-02f, 5.01806177e-02f, 1.75494537e-01f, 1.76453441e-02f, 1.94535544e-03f, 1.06328046e-02f, -4.24722955e-02f, 8.67114067e-02f,
  -7.39602968e-02f, 1.78367540e-01f, 9.39992890e-02f, -8.28037262e-02f, 4.98404428e-02f, 7.01157451e-02f, -6.39691576e-03f, 6.21929485e-03f, 1.13925745e-03f, 6.42162263e-02f,
  1.39974561e-02f, 1.32092476e-01f, -2.69326894e-03f, 9.56803910e-04f, 4.15245034e-02f, 5.57472035e-02f, -6.33416250e-02f, 3.99915576e-02f, 1.27578890e-02f, -1.27676487e-01f,
  1.39964685e-01f, -6.80880994e-02f, 4.20628190e-02f, -1.24414101e-01f, 8.12620670e-02f, 9.67392176e-02f, -4.78918143e-02f, 1.25454560e-01f, 1.23279996e-01f, 1.21044360e-01f,
  1.41076282e-01f, 1.26819804e-01f, 2.98880693e-02f, -3.65770869e-02f, 2.66203210e-02f, -8.52488726e-02f, -3.70092653e-02f, 6.16396181e-02f, 3.08389626e-02f, 9.27657187e-02f,
  -1.16143510e-01f, -3.53304185e-02f, -6.15133941e-02f, 1.07265174e-01f, 9.18630809e-02f, 2.36516148e-01f, 1.07970528e-01f, 2.02717543e-01f, 1.30053058e-01f, 2.35204369e-01f,
  -2.63180822e-01f, 2.54778415e-01f, 4.91587520e-02f, 1.04506947e-01f, -2.68162996e-01f, -2.35938251e-01f, -2.39449423e-02f, -6.58845007e-02f, 4.25434783e-02f, -2.87818033e-02f,
  3.21124882e-01f, 1.09807134e-01f, -1.19547904e-01f, 9.48447287e-02f, 4.09223922e-02f, -9.55299214e-02f, -2.37157214e-02f, 3.51738632e-01f, 1.58536121e-01f, -6.00132830e-02f,
  9.40806493e-02f, -8.03078637e-02f, -1.25515789e-01f, 1.58042982e-01f, 1.82519644e-01f, 1.73713750e-04f, 2.21438125e-01f, 8.73645917e-02f, -2.64390539e-02f, -9.23658088e-02f,
  5.52770942e-02f, 1.75039306e-01f, 3.85965072e-02f, -6.74180090e-02f, 7.75913373e-02f, 5.25393672e-02f, -3.66983302e-02f, -5.74435852e-02f, -1.58411451e-02f, 1.36144206e-01f,
  1.55595466e-01f, -4.38123345e-02f, -3.13623669e-03f, 5.66030927e-02f, 1.20884046e-01f, 8.88874978e-02f, -1.10261910e-01f, 5.75069636e-02f, 9.17337835e-02f, -9.61034298e-02f,
  2.64675438e-01f, -9.04495418e-02f, 2.26342991e-01f, -1.74892828e-01f, -1.12321690e-01f, -1.06882915e-01f, -2.85683051e-02f, -5.09095229e-02f, 2.71639079e-01f, 6.64044544e-02f,
  3.24387759e-01f, 2.18279406e-01f, 3.44570249e-01f, 3.18526477e-01f, 1.14183463e-01f, 8.72650743e-03f, -1.97862983e-01f, -4.03977484e-02f, -1.72592476e-02f, 1.37209776e-03f,
  -2.33651530e-02f, 6.73883930e-02f, 2.93595701e-01f, 2.50369877e-01f, -5.08582890e-02f, 3.89480516e-02f, 2.14896858e-01f, -2.91358940e-02f, 1.06056683e-01f, 3.75904031e-02f,
  1.15868442e-01f, 4.84885238e-02f, 3.06990564e-01f, 2.54869857e-03f, -3.91717814e-02f, -2.61190534e-01f, -2.62853000e-02f, 3.46228704e-02f, 8.02472681e-02f, 3.15657794e-01f,
  6.50850534e-02f, -2.13298276e-01f, 1.91587135e-02f, 4.27887659e-04f, 1.92637533e-01f, 2.47325286e-01f, 1.75249428e-01f, -9.91092771e-02f, -9.14979205e-02f, 2.14703977e-01f,
  1.21258289e-01f, -2.30075121e-01f, -1.72727793e-01f, -2.04421636e-02f, 2.32160181e-01f, -6.55638650e-02f, 1.30575016e-01f, 7.45881423e-02f, 1.51473030e-01f, 4.37242053e-02f,
  7.82426596e-02f, -6.36583343e-02f, 5.34681864e-02f, 1.50014848e-01f, 1.37991428e-01f, -2.19233381e-03f, -1.25991166e-01f, 1.68586314e-01f, -1.57909125e-01f, -1.23881951e-01f,
  1.30759582e-01f, 7.18475878e-02f, -1.01831861e-01f, 1.87571086e-02f, 8.00740123e-02f, -8.60804990e-02f, -4.07074168e-02f, 5.10434015e-03f, -3.72636653e-02f, -1.25336960e-01f,
  1.22280598e-01f, -6.54077977e-02f, -5.85310906e-03f, 1.14223696e-01f, 2.80263573e-02f, -5.39988019e-02f, 1.63472265e-01f, 1.06996186e-01f, 7.83413053e-02f, -7.12050200e-02f,
  -6.02283068e-02f, 6.64254650e-02f, 3.08040045e-02f, 1.02324218e-01f, -2.08722465e-02f, 2.98025291e-02f, 5.17259128e-02f, -9.67525542e-02f, -2.69190222e-02f, 1.02409586e-01f,
  -1.02394909e-01f, -2.72844397e-02f, -3.60612571e-02f, -7.95795843e-02f, -1.45755723e-01f, -4.32060435e-02f, -9.55767855e-02f, -8.46616998e-02f, 5.82927316e-02f, -1.50786284e-02f,
  -2.68103257e-02f, 1.02845065e-01f, 1.04559153e-01f, 9.38405991e-02f, -7.63554201e-02f, 8.67223218e-02f, 2.05285400e-02f, 1.26050800e-01f, 9.19636339e-02f, -2.73192804e-02f,
  -1.13148630e-01f, 8.50463882e-02f, -2.38180105e-02f, 3.45284380e-02f, -2.67637633e-02f, -9.63711590e-02f, -1.69059355e-02f, -2.74499934e-02f, 5.55509441e-02f, -4.18967977e-02f,
  3.52189653e-02f, 1.16787195e-01f, 3.42342481e-02f, -9.65627208e-02f, 6.30572140e-02f, 3.05655822e-02f, 3.07576984e-01f, 2.54365802e-01f, 2.66373068e-01f, 3.11258167e-01f,
  8.44626129e-02f, 1.34894297e-01f, -1.79598019e-01f, -8.44396278e-02f, -1.29415333e-01f, -2.58119524e-01f, -2.17537627e-01f, -2.92576164e-01f, -9.23845619e-02f, -3.46950279e-03f,
  1.75710902e-01f, 2.54616201e-01f, -1.57654643e-01f, -5.35999984e-02f, 5.05329631e-02f, 2.85762399e-01f, 5.52269667e-02f, 1.64189246e-02f, -1.97277498e-02f, 2.10281849e-01f,
  2.36655504e-01f, 4.69179973e-02f, 1.07777445e-02f, 1.70027152e-01f, 4.55585308e-02f, -1.04589410e-01f, 1.20847650e-01f, -8.42078775e-03f, -8.37702602e-02f, -8.26430917e-02f,
  3.08112830e-01f, 1.07924789e-01f, -3.07477117e-02f, -5.59237190e-02f, 2.40090922e-01f, 1.88093353e-02f, -1.01716004e-01f, -1.23582989e-01f, 1.84192061e-01f, 1.16804871e-03f,
  -5.93880601e-02f, -1.42590448e-01f, 3.13827656e-02f, 7.28326589e-02f, 1.62320092e-01f, 1.63915515e-01f, 1.05429158e-01f, 2.76882857e-01f, -1.39056981e-01f, -9.66729373e-02f,
  2.17463419e-01f, -9.65728760e-02f, 3.40582103e-01f, -4.90845256e-02f, -1.55236021e-01f, 1.18864357e-01f, 6.06385395e-02f, -2.81984359e-02f, 2.28794739e-01f, -1.19423017e-01f,
  -2.66008954e-02f, -6.19882718e-04f, 1.67760745e-01f, -1.09255528e-02f, -2.10719220e-02f, 5.95556609e-02f, 8.94170254e-02f, -8.62995833e-02f, -5.48475683e-02f, 9.83486399e-02f,
  9.03734937e-02f, 1.10817634e-01f, -3.86535712e-02f, -6.09489493e-02f, 7.95123652e-02f, -9.59802046e-02f, 2.33644769e-01f, 2.71351403e-03f, 2.43261941e-02f, -9.83863026e-02f,
  -1.56120146e-02f, 6.78893700e-02f, 1.32050797e-01f, -2.64057871e-02f, -7.01265037e-02f, 9.34897885e-02f, 1.58809200e-02f, -9.96847004e-02f, -1.10209621e-01f, 9.63972136e-02f,
  4.48202901e-02f, 1.25295473e-02f, 2.69090869e-02f, 1.60706937e-01f, -2.98950970e-02f, -1.23402126e-01f, 7.57561922e-02f, -9.96917188e-02f, 5.75973764e-02f, -3.45039703e-02f,
  1.66471317e-01f, 3.03617902e-02f, -1.26432419e-01f, -1.42401606e-02f, -2.94517018e-02f, 1.37536332e-01f, 7.27327988e-02f, -3.53399962e-02f, -7.91710336e-03f, 2.74877786e-03f,
  -5.92682846e-02f, -6.35583177e-02f, -5.77252433e-02f, -4.80345674e-02f, 5.04914634e-02f, -6.91543221e-02f, 4.17501666e-02f, 1.28832132e-01f, 2.67838627e-01f, -6.75842911e-02f,
  -1.05594860e-04f, -1.10036723e-01f, -9.03545171e-02f, 4.18291166e-02f, 5.22395335e-02f, -2.05190927e-02f, 1.11368917e-01f, -6.14743419e-02f, 7.69297257e-02f, 4.25826609e-02f,
  -4.02973369e-02f, -2.56209988e-02f, 5.42404130e-02f, -7.56230876e-02f, 1.15736127e-01f, -6.26649484e-02f, 7.48905391e-02f, -2.04544514e-02f, 9.93136242e-02f, -3.80176418e-02f,
  -9.71493721e-02f, 9.92332119e-03f, -6.65646940e-02f, -3.33419256e-02f, -4.14163945e-03f, -1.56385284e-02f, -8.32779855e-02f, 3.03757098e-02f, 6.69833496e-02f, -1.61758214e-02f,
  -1.07267320e-01f, -7.32291043e-02f, -1.10692047e-01f, 1.08306604e-02f, -2.60578771e-03f, 1.70812644e-02f, 7.54734799e-02f, -3.64246294e-02f, -7.45595694e-02f, 3.09349727e-02f,
  3.71169075e-02f, -7.12693706e-02f, -4.87728156e-02f, 4.60114777e-02f, 1.34768561e-01f, 3.75296958e-02f, 5.15325069e-02f, 3.43392752e-02f, 1.80332452e-01f, 5.65689020e-02f,
  2.76836548e-02f, 9.06301513e-02f, -1.17223881e-01f, 7.59350881e-02f, -1.05962135e-01f, 7.00962245e-02f, 1.26563430e-01f, -8.98223072e-02f, 1.11220762e-01f, 5.27413487e-02f,
  -5.75050376e-02f, 3.63253057e-02f, -1.00861609e-01f, 1.90602601e-01f, 1.33481219e-01f, -1.01456061e-01f, 2.88174059e-02f, 2.53702439e-02f, 1.68237269e-01f, 1.54840410e-01f,
  4.25441302e-02f, 5.47404252e-02f, 3.45878333e-01f, 5.82347326e-02f, 1.88348219e-02f, 5.79665750e-02f, 8.51541981e-02f, -1.25502661e-01f, 2.11439341e-01f, -1.69722233e-02f,
  -6.28666356e-02f, 9.12919641e-02f, -8.31759200e-02f, 1.91179454e-01f, 1.18657343e-01f, 2.07108483e-01f, -2.33846474e-02f, -2.35782620e-02f, 6.46287575e-02f, -1.29096897e-03f,
  9.11912024e-02f, 8.97752792e-02f, 3.06099862e-01f, 5.60282394e-02f, -3.02988235e-02f, 2.61946991e-02f, 3.66123877e-02f, 1.58194542e-01f, 1.46941707e-01f, -1.68415289e-02f,
  -5.34390472e-02f, 2.36779779e-01f, -8.71338397e-02f, 1.42036229e-01f, -8.31412822e-02f, -9.06006172e-02f, 1.47465378e-01f, 1.19503085e-02f, 1.97676882e-01f, -4.38755900e-02f,
  1.05666079e-01f, 1.92468055e-02f, 1.90402627e-01f, 1.37701541e-01f, 6.82827830e-02f, 2.45876014e-02f, -3.33298296e-02f, 1.48088299e-02f, 1.53059229e-01f, 7.26691559e-02f,
  2.21987888e-02f, 1.64013892e-01f, 9.48375389e-02f, 9.00988057e-02f, -9.82368458e-03f, 5.21534011e-02f, 3.11220855e-01f, 5.75504862e-02f, -1.11748220e-03f, -9.50069278e-02f,
  -1.83867607e-02f, -1.08578682e-01f, 3.84152532e-02f, 1.38709284e-02f, 1.67373672e-01f, -9.57253501e-02f, -5.40348794e-03f, 9.72750410e-02f, -9.31857433e-03f, 1.18551776e-01f,
  3.09536699e-02f, -1.83834463e-01f, 7.93659464e-02f, -1.97611600e-01f, -3.67410369e-02f, 1.18351460e-01f, -4.31471244e-02f, 2.14696792e-03f, 4.72335927e-02f, 5.76180145e-02f,
  -1.09552145e-01f, -1.46386931e-02f, 6.16669469e-02f, -1.41024828e-01f, -7.50996619e-02f, 1.12802356e-01f, 1.39353678e-01f, 4.52554338e-02f, -3.74464802e-02f, 6.94075003e-02f,
  -9.43088010e-02f, 4.08647815e-03f, 3.90982581e-03f, -1.34223565e-01f, 2.18233317e-01f, -1.24591030e-01f, 1.61564887e-01f, 1.78978503e-01f, -9.39148590e-02f, -5.65392636e-02f,
  9.70390067e-02f, -5.30591682e-02f, 8.09319764e-02f, 2.05804296e-02f, 8.27143416e-02f, -4.01763767e-02f, -1.14653043e-01f, -6.96886852e-02f, -7.64344484e-02f, 5.84893599e-02f,
  -1.09037617e-02f, 3.86078954e-02f, -6.18046671e-02f, -3.06404778e-03f, -6.47080168e-02f, 4.70725223e-02f, 1.45845547e-01f, 4.69674282e-02f, 6.23433664e-02f, -6.20347485e-02f,
  -9.18735191e-03f, 2.38739755e-02f, -4.00522240e-02f, -9.15282667e-02f, -2.05355380e-02f, -3.27359661e-02f, 1.25876591e-01f, 1.51711881e-01f, 1.42225936e-01f, 4.07217583e-03f,
  1.23217724e-01f, 2.58332845e-02f, -3.87794226e-01f, 5.34063727e-02f, -1.20064477e-02f, 1.07034445e-01f, -2.98784643e-01f, -1.22619852e-01f, 9.33433399e-02f, -3.34592797e-02f,
  -1.23499371e-01f, -4.30643298e-02f, 3.15278858e-01f, 8.03347304e-02f, -7.59689286e-02f, 2.49188114e-02f, 2.93599255e-02f, -8.18907619e-02f, -8.16052314e-03f, 2.35768914e-01f,
  -1.07391909e-01f, -1.39224768e-01f, 7.23389611e-02f, 1.26756206e-01f, -9.95997638e-02f, 2.90071703e-02f, 7.59230852e-02f, -8.19850862e-02f, 1.79219782e-01f, 4.46116664e-02f,
  1.08141556e-01f, 1.41716883e-01f, 5.61948232e-02f, 1.36879250e-01f, -2.77513964e-03f, -7.18586221e-02f, 6.84760809e-02f, -5.07704876e-02f, -1.61820337e-01f, 2.58938521e-01f,
  -8.60808883e-04f, 1.46407351e-01f, -3.41187716e-02f, 1.98903367e-01f, -2.15134360e-02f, 1.52720332e-01f, 2.79963482e-02f, 1.18184634e-01f, -1.16309077e-01f, 1.24529593e-01f,
  -2.41837595e-02f, -1.24902517e-01f, -4.87620346e-02f, -1.14748538e-01f, 1.33332014e-01f, 3.85047086e-02f, -5.43439016e-02f, -3.37987281e-02f, -8.41949657e-02f, -4.70646843e-02f,
  1.30408049e-01f, -4.38971147e-02f, -7.31670558e-02f, -6.99002435e-03f, -9.47723985e-02f, 3.27765234e-02f, 1.52706075e-02f, 3.08404602e-02f, 1.00673854e-01f, 1.28508151e-01f,
  -8.47035497e-02f, -2.41774116e-02f, -5.26954830e-02f, 1.10631838e-01f, 1.11862890e-01f, -7.81621113e-02f, 3.81778628e-02f, -3.25263739e-02f, 1.08511724e-01f, 1.71683133e-02f,
  3.70604023e-02f, -2.16438621e-02f, 1.57759517e-01f, 9.97619629e-02f, -8.99567902e-02f, -3.64951417e-02f, -1.15600243e-01f, 1.15185149e-01f, 7.81577826e-02f, 1.15932710e-01f,
  2.38008220e-02f, 1.74191803e-01f, -8.54168609e-02f, 1.42842025e-01f, 6.67038336e-02f, -6.79484801e-04f, 2.57129557e-02f, 2.35180445e-02f, -6.53258935e-02f, 1.10905237e-01f,
  2.27643587e-02f, 7.89457560e-02f, 3.14752124e-02f, 1.04544677e-01f, 5.08228801e-02f, -9.09135342e-02f, -4.84921336e-02f, 1.12979099e-01f, -8.81121531e-02f, 4.22078334e-02f,
  -2.52319183e-02f, -3.20025235e-02f, 1.22462273e-01f, -1.13034949e-01f, 2.26518158e-02f, -1.04942590e-01f, -3.92803699e-02f, -4.29070741e-02f, 1.36749208e-01f, -7.05495700e-02f,
  6.86185881e-02f, 1.12374663e-01f, 1.26931176e-01f, 1.26748979e-01f, -2.08778493e-02f, 3.00047863e-02f, 6.78349063e-02f, 5.25691211e-02f, -3.32863927e-02f, 8.10828619e-03f,
  1.21420719e-01f, 7.77176917e-02f, 9.57594961e-02f, -9.81556997e-02f, 2.30216496e-02f, 5.54805957e-02f, 1.19175285e-01f, 9.12138894e-02f, 1.59921855e-01f, 7.54326433e-02f,
  7.28031993e-02f, 8.30052644e-02f, 1.41618550e-01f, 6.26975968e-02f, -1.09971933e-01f, 8.79996121e-02f, 1.40648514e-01f, -6.67939410e-02f, 1.27360895e-01f, -4.52978164e-02f,
  -6.75147399e-02f, 3.90465781e-02f, -3.24648917e-02f, -1.23092890e-01f, 7.92465433e-02f, -1.96099710e-02f, -1.00152291e-01f, 1.49521660e-02f, -7.91787803e-02f, 7.40881041e-02f,
  -1.79533251e-02f, -4.41964045e-02f, 1.51783720e-01f, -7.49915168e-02f, 5.87225035e-02f, 2.73349062e-02f, -9.77082402e-02f, -1.72811337e-02f, -6.00515716e-02f, -1.18015833e-01f,
  5.44759668e-02f, 6.03914931e-02f, 1.03438094e-01f, 7.78139681e-02f, 2.17240155e-02f, 8.48857090e-02f, -8.10314938e-02f, -1.14853559e-02f, -1.82440765e-02f, -7.98535421e-02f,
  1.05481535e-01f, -3.45206559e-02f, 9.26385820e-02f, 1.47758871e-01f, 9.79836658e-02f, 3.61626456e-03f, 1.20329961e-01f, 2.06010100e-02f, 3.59332785e-02f, -3.98187004e-02f,
  1.15385000e-02f, 4.43765186e-02f, 1.19485660e-02f, 8.48908871e-02f, -1.52010068e-01f, -9.01379064e-02f, 8.24673176e-02f, -3.46254930e-02f, -1.34529009e-01f, -9.26250312e-03f,
  1.43692151e-01f, 3.63325439e-02f, -9.02893841e-02f, -1.52045675e-02f, 1.25843123e-01f, 1.66466579e-01f, 3.32311206e-02f, 8.36270750e-02f, 6.85499460e-02f, -9.78940949e-02f,
  1.03206694e-01f, 1.68735832e-01f, -5.20911580e-03f, 1.49787396e-01f, -7.75193945e-02f, 1.31236836e-02f, -6.58766031e-02f, 5.73415905e-02f, -1.14553250e-01f, 7.07021281e-02f,
  -6.92980140e-02f, 1.01354770e-01f, -7.44840056e-02f, -2.82106921e-02f, 5.44187576e-02f, -1.24235630e-01f, -2.77133808e-02f, 8.31159353e-02f, 4.56737168e-03f, -6.23492859e-02f,
  -4.24830914e-02f, -3.33224908e-02f, 1.08475089e-01f, 1.54325545e-01f, 2.05407381e-01f, -7.05580413e-03f, -2.70682480e-02f, -5.55910207e-02f, 1.07066937e-01f, 5.22680283e-02f,
  -9.85995531e-02f, -3.03037148e-02f, 1.48520783e-01f, -9.78956819e-02f, 1.60665996e-03f, 7.77827948e-02f, 1.69261530e-01f, -1.49862543e-01f, -4.52638278e-03f, -1.28530592e-01f,
  -2.51019429e-02f, 1.37820959e-01f, 1.07493386e-01f, 4.24747579e-02f, 2.57876907e-02f, 7.01842308e-02f, -1.04198847e-02f, 1.66664541e-01f, -1.26695454e-01f, 1.85992748e-01f,
  1.07839175e-01f, 1.10370107e-01f, -5.53441010e-02f, 9.37039182e-02f, 5.79880923e-02f, -7.17882589e-02f, -4.11291011e-02f, 1.28049865e-01f, 1.00786248e-02f, 1.25540823e-01f,
  -8.59560594e-02f, -7.74575621e-02f, 5.41404542e-03f, 1.69550419e-01f, 2.96272874e-01f, 1.79536298e-01f, 1.14967085e-01f, 1.18440837e-01f, -2.17351001e-02f, -9.01930407e-02f,
  7.99664706e-02f, 1.23185106e-01f, 3.51962671e-02f, 3.01779211e-01f, 6.96173683e-02f, -1.36326969e-01f, -4.97449636e-02f, 1.16189077e-01f, 1.67185903e-01f, 1.63831249e-01f,
  4.30913605e-02f, -3.26526128e-02f, -5.43249436e-02f, 1.34605885e-01f, -1.32021800e-01f, 5.64733567e-03f, -1.56594768e-01f, -2.27308199e-02f, 2.25409180e-01f, 5.65123837e-03f,
  -1.53141357e-02f, -9.84864496e-03f, -9.29362476e-02f, 1.40978009e-01f, 1.57407656e-01f, -7.36267939e-02f, 4.29746769e-02f, 7.13285431e-02f, -1.15324482e-01f, 5.22357523e-02f,
  -6.36365563e-02f, -1.44696936e-01f, -7.34365806e-02f, 3.02756820e-02f, -2.76158545e-02f, 1.23191416e-01f, -1.12633668e-02f, -4.78394292e-02f, 7.59366676e-02f, -4.29144315e-02f,
  -6.28238171e-02f, 8.29121470e-02f, 4.89935726e-02f, 1.17295638e-01f, 2.35154573e-03f, 7.57290348e-02f, -2.25757603e-02f, -2.87907431e-04f, -8.82093981e-02f, -9.66469496e-02f,
  -1.10665232e-01f, 4.41573262e-02f, 2.16314439e-02f, 6.96367621e-02f, 1.56569872e-02f, -7.59696811e-02f, -1.10500596e-01f, 3.71404625e-02f, -7.81693775e-03f, 5.38250655e-02f,
  -2.47464217e-02f, -1.19009852e-01f, 1.16790272e-02f, 3.28241214e-02f, -1.12857893e-01f, 1.28893815e-02f, 1.12208366e-01f, -8.65639225e-02f, 8.48511532e-02f, 7.69454688e-02f,
  1.99669078e-02f, -4.57704999e-02f, 1.09354630e-01f, 2.90565304e-02f, -6.91180006e-02f, -1.20129948e-02f, -7.58598819e-02f, 2.08242461e-02f, 2.57920083e-02f, -7.85006210e-02f,
  -8.18360150e-02f, 1.49274953e-02f, 6.61686733e-02f, 3.19448747e-02f, -9.23617110e-02f, -2.95836595e-04f, 8.78278688e-02f, -2.97969393e-02f, 7.26284459e-02f, -9.53324363e-02f,
  6.92542503e-03f, -3.07954978e-02f, 3.30095887e-02f, 5.01541048e-02f, 2.35474333e-02f, -9.61883515e-02f, -1.06520459e-01f, -1.10398522e-02f, 1.19905043e-02f, 3.48167978e-02f,
  8.74644816e-02f, -8.78455564e-02f, -6.16503581e-02f, 7.44883344e-02f, -2.61179660e-03f, -3.24319080e-02f, 8.52559879e-02f, 8.44583437e-02f, -2.34418828e-02f, 1.09000280e-02f,
  -1.39113858e-01f, -6.97043017e-02f, -1.07752040e-01f, -6.13497347e-02f, 2.51418930e-02f, 1.03367075e-01f, -2.86211316e-02f, 5.84794730e-02f, 3.03620193e-02f, 5.20843901e-02f,
  -4.49721329e-02f, 1.20383881e-01f, 1.11577809e-02f, 1.59529433e-01f, 8.35013986e-02f, -9.61636081e-02f, -6.38885722e-02f, 4.77155484e-02f, 1.22952409e-01f, -4.84293550e-02f,
  1.12396717e-01f, -2.24312674e-03f, 1.01254962e-01f, 2.51902584e-02f, -1.77005250e-02f, 3.15561667e-02f, -1.06800139e-01f, -1.86276734e-02f, 5.72746471e-02f, -7.39722997e-02f,
  6.26831502e-02f, -6.00847602e-03f, -5.91401234e-02f, -2.19852421e-02f, 6.13372028e-02f, 9.31269303e-02f, 8.29031393e-02f, 9.93826315e-02f, -1.38267621e-01f, -4.51051518e-02f,
  -8.56393650e-02f, -1.08628385e-01f, 4.60021421e-02f, -5.28879203e-02f, 2.59776339e-02f, -3.61213833e-02f, 8.08445513e-02f, -3.89758311e-02f, -3.91973294e-02f, 4.93736677e-02f,
  6.72308058e-02f, 5.38964272e-02f, 7.72738596e-03f, 5.74713200e-02f, 4.35144007e-02f, -6.02353886e-02f, 1.19561531e-01f, -9.69571024e-02f, 8.52689669e-02f, 6.97449222e-02f,
  -1.51348472e-01f, 3.04034185e-02f, 7.75422528e-02f, 4.23984379e-02f, 2.12499034e-02f, 4.46347743e-02f, 1.31371245e-01f, -3.50366570e-02f, 4.88405898e-02f, 6.77124113e-02f,
  1.40480012e-01f, 2.62094587e-02f, 1.07856818e-01f, -9.25273374e-02f, 5.85478954e-02f, 1.06223620e-01f, 1.88070521e-01f, -9.88512263e-02f, 1.51419774e-01f, 5.30193234e-03f,
  1.96845867e-02f, -1.80341855e-01f, -4.96524572e-02f, 7.45159164e-02f, -2.96688825e-02f, 1.40009537e-01f, 1.10054485e-01f, -2.11844333e-02f, 7.82636926e-02f, -3.22474800e-02f,
  4.43547294e-02f, 2.85105743e-02f, 3.74736115e-02f, -7.91119933e-02f, 1.68511122e-01f, 1.50291454e-02f, -6.61287755e-02f, 1.41419461e-02f, 1.01324804e-01f, 1.84314623e-02f,
  3.90117317e-02f, 5.02950177e-02f, -3.99772488e-02f, -1.22570448e-01f, -4.14352957e-03f, 9.44167972e-02f, 5.53740002e-02f, -1.17560858e-02f, -3.42573375e-02f, 4.64670658e-02f,
  -1.30095005e-01f, 7.09031895e-02f, 2.32023373e-01f, 9.78977382e-02f, -6.46164268e-02f, -5.63907996e-02f, 8.30744803e-02f, -6.30060732e-02f, 3.19511853e-02f, 7.88721815e-02f,
  -5.60267828e-02f, 6.25339001e-02f, -6.03201501e-02f, 1.14216320e-01f, 1.18047781e-01f, 6.79707527e-02f, 1.05447449e-01f, -3.08969207e-02f, -9.44989994e-02f, 4.54659835e-02f,
  -5.47621138e-02f, -2.79951449e-02f, 5.11764772e-02f, 3.99497040e-02f, -6.95939884e-02f, 2.21739337e-02f, -5.74544258e-02f, 9.35885236e-02f, -7.89149255e-02f, 1.48971495e-03f,
  -7.26995245e-02f, 3.93257365e-02f, 3.32098715e-02f, -8.26804042e-02f, 1.26152560e-01f, -9.96692777e-02f, -1.09983623e-01f, 2.48121307e-03f, 2.85459813e-02f, 1.14822403e-01f,
  -1.53369866e-02f, -4.45261486e-02f, -6.14708997e-02f, -6.93039894e-02f, 7.80687435e-03f, -7.29055032e-02f, 1.27121553e-01f, -1.15106620e-01f, -7.58539066e-02f, 6.81044832e-02f,
  1.01528414e-01f, -1.03449933e-01f, -6.72316626e-02f, 4.25395258e-02f, 1.32639021e-01f, -7.54158869e-02f, -1.00915089e-01f, 6.16035797e-03f, 4.18624803e-02f, -4.89899330e-02f,
  6.48504123e-02f, 3.20025086e-02f, 8.47318098e-02f, 6.75734356e-02f, -2.42696907e-02f, 1.36738554e-01f, -1.19621251e-02f, 9.57350880e-02f, 5.27614430e-02f, 1.09114222e-01f,
  -7.33046383e-02f, 1.05671965e-01f, 4.76145633e-02f, 4.53564711e-02f, 2.94890217e-02f, -8.03753734e-02f, 1.37052357e-01f, 1.23923354e-01f, -1.12161957e-01f, 1.04030490e-01f,
  -6.31162971e-02f, 1.89175352e-01f, 1.21891893e-01f, -1.10667504e-01f, 8.35229978e-02f, -2.60937512e-02f, -4.18025069e-02f, -3.46456319e-02f, 1.59303114e-01f, 1.00037448e-01f,
  9.20644999e-02f, -1.02464832e-01f, 7.31666535e-02f, -2.79254783e-02f, 1.02029741e-01f, -9.07002576e-03f, -2.62224022e-02f, 3.65799591e-02f, 3.26482207e-02f, -5.34855127e-02f,
  -1.11380205e-01f, -5.39578982e-02f, 1.00912891e-01f, 4.94671538e-02f, -2.46695075e-02f, 4.85177413e-02f, -1.01543404e-01f, 1.31491706e-01f, 6.80104503e-03f, -7.44760260e-02f,
  9.63153616e-02f, -1.22657847e-02f, 1.02925174e-01f, -4.99116369e-02f, -3.58134024e-02f, 5.74422330e-02f, -1.93459336e-02f, 1.85406730e-02f, -7.10195825e-02f, 1.20033752e-02f,
  9.71961394e-02f, 5.07600680e-02f, 8.24832395e-02f, -4.40457799e-02f, -7.18462318e-02f, -2.35082246e-02f, -2.15855464e-02f, 7.75767630e-03f, -1.28075451e-01f, 3.60683985e-02f,
  -7.60027617e-02f, -4.76216152e-02f, 1.09919325e-01f, -8.96483734e-02f, -1.50971655e-02f, 4.05659266e-02f, -5.08176535e-02f, 1.81828111e-01f, -1.98996672e-03f, 8.62172768e-02f,
  1.30334824e-01f, -7.84491152e-02f, 1.07648537e-01f, 2.31727250e-02f, -8.76565948e-02f, 1.42182633e-01f, -1.36355966e-01f, 9.37772468e-02f, -5.12858666e-02f, -3.32948193e-02f,
  -2.57086251e-02f, -1.33030340e-01f, 1.62608758e-01f, -8.76070652e-03f, -1.02333523e-01f, 5.17385160e-05f, 9.34076309e-02f, 1.33739665e-01f, -1.00955419e-01f, 1.20534159e-01f,
  -1.33097991e-01f, -9.01880208e-04f, -8.45291466e-02f, 4.92376229e-03f, 4.81211357e-02f, -5.36739826e-02f, -3.39029469e-02f, 1.35319531e-01f, 9.80052948e-02f, 3.91179211e-02f,
  -3.72939669e-02f, -5.99909313e-02f, 1.02230050e-01f, -5.20370156e-02f, -1.37020975e-01f, 1.65932521e-01f, -9.33148935e-02f, -9.98081639e-02f, -8.04046616e-02f, 1.21839747e-01f,
  -4.25760867e-04f, 1.38262868e-01f, 3.55569422e-02f, -4.49467413e-02f, 3.51618975e-02f, -5.68310656e-02f, 9.07673221e-03f, -3.77764218e-02f, 1.34035572e-01f, -2.69140508e-02f,
  -3.12790982e-02f, 3.74576673e-02f, 1.01563439e-01f, 8.11280459e-02f, -1.49650471e-02f, -4.73223105e-02f, 4.88150753e-02f, 1.19322337e-01f, -9.61881131e-02f, -3.87445875e-02f,
  4.26805057e-02f, -7.57508501e-02f, 1.65542364e-01f, -5.69990389e-02f, 1.43943980e-01f, -4.01043743e-02f, -1.63512737e-01f, 1.80635810e-01f, -1.35940686e-01f, 1.35978639e-01f,
  -9.47866365e-02f, -1.47243038e-01f, -9.60761383e-02f, -6.92840070e-02f, 1.10466152e-01f, 3.03059146e-02f, 1.12525886e-02f, 9.12405774e-02f, -8.53762478e-02f, -4.12310250e-02f,
  -2.33967789e-02f, -1.23512298e-01f, 4.69300300e-02f, 2.05087245e-01f, -3.22111174e-02f, -8.15144628e-02f, 1.00892019e-02f, -7.05722161e-03f, -7.91981146e-02f, 8.95199925e-02f,
  -3.76851149e-02f, 4.18275446e-02f, 8.62196684e-02f, 4.40023653e-02f, 3.89353931e-02f, -7.74446726e-02f, -3.60874906e-02f, 1.80507991e-02f, 1.03790261e-01f, -1.18731752e-01f,
  1.31183520e-01f, -8.26583207e-02f, -5.70381507e-02f, -6.56263977e-02f, 6.91929385e-02f, 3.26590566e-03f, 1.62604138e-01f, 4.31844220e-02f, -4.71326560e-02f, 6.37728954e-03f,
  6.30051121e-02f, 1.25508420e-02f, -2.59363782e-02f, -8.92643407e-02f, 1.43760189e-01f, -8.11609849e-02f, 4.15330641e-02f, 1.03673898e-01f, -9.22659934e-02f, -1.24730701e-02f,
  -8.87425151e-03f, -8.23714733e-02f, -6.93840906e-02f, -2.27569919e-02f, 4.37303595e-02f, 1.06094750e-02f, -2.10789330e-02f, 2.18398228e-01f, 1.15413517e-01f, 4.46289685e-03f,
  1.37115136e-01f, -2.18328640e-01f, 1.60931081e-01f, 2.06676632e-01f, -1.95980016e-02f, 1.28644824e-01f, 1.04600340e-01f, 5.02333371e-03f, 1.12419873e-01f, 1.38193637e-01f,
  1.17226958e-01f, 9.04848799e-02f, 6.54788837e-02f, -7.71663487e-02f, 7.09294109e-03f, 2.20061123e-01f, 4.03014719e-01f, 5.81907434e-03f, 2.96498891e-02f, 2.75741249e-01f,
  -3.63587029e-02f, 1.28297925e-01f, 5.74889593e-02f, 9.47562978e-02f, -7.64759704e-02f, 2.70369738e-01f, -1.64803118e-01f, 6.29405156e-02f, 9.36813653e-02f, -4.71473746e-02f,
  1.33523107e-01f, 3.27841528e-02f, 6.60380721e-02f, 8.18151422e-03f, 7.96929374e-02f, 1.19621947e-01f, 6.61791414e-02f, 1.45768598e-01f, 1.04165070e-01f, -2.53965128e-02f,
  1.54998288e-01f, -8.38916078e-02f, 1.06070064e-01f, -1.21123865e-01f, 9.22178030e-02f, -1.85524032e-01f, -1.09033170e-03f, -1.48317441e-01f, 1.52563199e-01f, 2.38017857e-01f,
  -1.22252377e-02f, 1.09969117e-01f, 1.23136595e-01f, 4.12831083e-02f, -3.85615639e-02f, -2.81440206e-02f, -8.99773762e-02f, 1.89931765e-01f, 1.61579251e-01f, 1.26056224e-01f,
  1.38659865e-01f, 5.85048646e-02f, 2.18092993e-01f, 4.23849188e-02f, 2.61162847e-01f, -9.71936435e-02f, 4.78442982e-02f, -1.13978952e-01f, 2.94578284e-01f, 2.65377581e-01f,
  -8.25116634e-02f, 2.61020791e-02f, 1.34400994e-01f, -1.01476513e-01f, -1.34642079e-01f, -2.56424909e-03f, -3.05013359e-02f, 6.81553632e-02f, -1.57706946e-01f, 2.75476456e-01f,
  5.69993705e-02f, -1.63033441e-01f, 9.64942481e-03f, -8.57864469e-02f, -6.71290904e-02f, 8.19497854e-02f, -6.81625456e-02f, 1.01681314e-01f, 5.77168502e-02f, 2.30605751e-01f,
  7.57588074e-02f, 5.88827357e-02f, -9.81416255e-02f, 4.26313691e-02f, -1.87857449e-02f, -7.71155208e-02f, 1.47445835e-02f, 7.00599421e-03f, 7.74909109e-02f, -2.50932924e-03f,
  2.07739566e-02f, 9.68536809e-02f, 1.25293881e-01f, 6.66765422e-02f, -1.69552535e-01f, 8.36404413e-02f, 8.86378512e-02f, -7.28605390e-02f, -1.48364991e-01f, -9.54269618e-03f,
  2.66371399e-01f, -4.82145092e-03f, -1.54909655e-01f, 3.34857106e-02f, -1.70176923e-01f, -1.20064773e-01f, -1.04511745e-01f, 1.20363571e-01f, 5.55050410e-02f, -3.14064696e-02f,
  -4.43617851e-02f, -1.13675177e-01f, 2.01263949e-01f, 2.55076438e-01f, 3.99229601e-02f, -3.67413685e-02f, 1.52984455e-01f, 1.60935357e-01f, -8.47189724e-02f, 8.97260085e-02f,
  2.04191014e-01f, -2.40903944e-01f, 9.31722373e-02f, 2.85151806e-02f, -1.43139631e-01f, 1.07295409e-01f, 8.89481679e-02f, -1.14024337e-03f, -4.90580536e-02f, 1.32488877e-01f,
  2.05417469e-01f, 6.83222935e-02f, -1.46770358e-01f, 6.60712644e-02f, 2.02642288e-02f, -5.28690182e-02f, 1.73082218e-01f, 1.15834191e-01f, -9.95626748e-02f, 6.32593483e-02f,
  -1.05893433e-01f, 9.80982631e-02f, 3.11394818e-02f, -1.36965573e-01f, -1.71928868e-01f, 1.93134338e-01f, -7.65582025e-02f, 2.51434922e-01f, -1.37415558e-01f, -9.41980109e-02f,
  -8.47752467e-02f, 1.46593377e-01f, 1.93765648e-02f, -1.43382326e-01f, 2.01792091e-01f, 2.54593909e-01f, 2.83046812e-01f, 7.44882822e-02f, -1.52177826e-01f, 8.27203542e-02f,
  6.53945655e-02f, -7.71630406e-02f, -3.05228005e-03f, 8.67422894e-02f, 2.95289867e-02f, -2.34165471e-02f, -1.61417320e-01f, -6.35076761e-02f, -1.64587244e-01f, 6.10322831e-03f,
  7.16827288e-02f, 3.13056916e-01f, -2.12288033e-02f, 1.36773512e-01f, -4.97272052e-02f, -3.55866551e-02f, 1.63823903e-01f, 8.82818699e-02f, -2.04626620e-02f, 3.87316160e-02f,
  -8.31497386e-02f, 1.64972126e-01f, -2.00332880e-01f, 8.96703154e-02f, 1.37251884e-01f, -1.11260131e-01f, -1.33843333e-01f, -1.82590470e-01f, 1.81266144e-02f, 1.14562735e-01f,
  1.39156980e-02f, 6.62342012e-02f, 1.54430926e-01f, 4.07198109e-02f, -1.29196763e-01f, -3.33712883e-02f, -1.38288457e-02f, -1.59319505e-01f, -3.33015211e-02f, 1.55025065e-01f,
  -1.34755755e-02f, 3.58742438e-02f, -8.66099074e-02f, 2.24760994e-01f, -3.45787555e-02f, 5.44634648e-03f, 4.90865298e-02f, -1.45379119e-02f, -2.35334113e-02f, 4.60779443e-02f,
  4.78801094e-02f, 7.89212286e-02f, -1.10894516e-01f, -1.29420042e-01f, 5.81926201e-03f, 2.45583609e-01f, 1.50649659e-02f, -1.14728138e-01f, -1.14757061e-01f, 4.34272617e-01f,
  1.19356632e-01f, -2.80627832e-02f, 8.16431567e-02f, -1.23113051e-01f, 8.88347179e-02f, -4.25795317e-02f, 5.47910407e-02f, -5.69870044e-03f, -2.06596247e-04f, 8.66133124e-02f,
  -3.50339897e-03f, -4.15026434e-02f, 4.75876518e-02f, 1.29933089e-01f, -6.35117069e-02f, 5.94538823e-02f, -4.85609360e-02f, 1.12247262e-02f, -3.20078321e-02f, 2.74638385e-02f,
  1.21068284e-01f, 2.02062679e-03f, 1.44651905e-01f, 1.64832816e-01f, 1.83860630e-01f, 3.91341224e-02f, 3.05534285e-02f, -6.06550165e-02f, -1.34404421e-01f, 1.11899540e-01f,
  -5.04312513e-04f, 1.87721163e-01f, -1.95937380e-02f, -4.97927479e-02f, -8.52237195e-02f, -1.55190572e-01f, -6.82193488e-02f, -5.23380749e-02f, -1.44169927e-01f, -1.60909556e-02f,
  -5.29013202e-02f, 6.24767095e-02f, -1.46929286e-02f, -2.86509171e-02f, 2.10489836e-02f, -1.13217182e-01f, 1.12204753e-01f, 1.45134311e-02f, -8.33949372e-02f, 1.30029947e-01f,
  1.79518852e-02f, 6.01792196e-03f, 6.40997663e-02f, 4.49715629e-02f, -1.21757925e-01f, -8.50076824e-02f, 1.32434294e-01f, 9.34076682e-03f, -8.55687633e-02f, 8.45405683e-02f,
  -8.10062047e-05f, -6.66198656e-02f, -7.07235336e-02f, -1.37895316e-01f, -1.43849149e-01f, 8.41194689e-02f, 8.01427960e-02f, 1.56745479e-01f, 1.06129356e-01f, 7.63856024e-02f,
  -6.74950033e-02f, -4.38680425e-02f, 1.07213303e-01f, 1.26492858e-01f, -4.10063714e-02f, -1.86750852e-02f, 3.33123631e-03f, -6.64798990e-02f, 1.56153694e-01f, -9.17104334e-02f,
  1.98043580e-03f, -6.99507073e-02f, 1.13889650e-02f, -9.25312191e-02f, 1.50797337e-01f, -1.69449300e-02f, 2.40227222e-01f, 2.03811675e-01f, 3.97701748e-02f, 1.31210849e-01f,
  4.61575650e-02f, -1.16139397e-01f, 1.30053267e-01f, 1.41930148e-01f, 2.79054921e-02f, 1.79515019e-01f, 1.51759341e-01f, -7.52947405e-02f, 2.76623368e-01f, 1.43403053e-01f,
  -6.64349496e-02f, -2.28062216e-02f, 2.48971835e-01f, 1.04322225e-01f, 6.36312217e-02f, 1.18633673e-01f, 2.44058982e-01f, -1.50342450e-01f, 2.20624488e-02f, 1.10205114e-01f,
  6.79447949e-02f, -1.52227297e-01f, 2.92256735e-02f, -1.31182641e-01f, -1.32776305e-01f, 1.94936112e-01f, -2.01236144e-01f, 1.24380842e-01f, 2.61781681e-02f, -6.77247941e-02f,
  -6.90476224e-02f, -1.16695829e-01f, 2.16031864e-01f, 9.46883783e-02f, -3.34390178e-02f, 1.95173789e-02f, 5.10807298e-02f, -9.49679017e-02f, 1.65652230e-01f, 1.07014701e-01f,
  9.90585089e-02f, 9.78658944e-02f, 1.63484946e-01f, 9.26253106e-03f, 1.00724891e-01f, -1.33885667e-01f, 1.51042745e-01f, 3.92214023e-02f, 1.74453944e-01f, 2.07464457e-01f,
  8.46977383e-02f, 2.15371493e-02f, 1.24448866e-01f, 1.51899263e-01f, 1.78690422e-02f, 5.94186038e-02f, 1.64350256e-01f, 2.12663189e-02f, 1.58423614e-02f, 4.19367626e-02f,
  5.99031635e-02f, -1.20506309e-01f, 3.57729644e-02f, -4.79618274e-02f, -2.50777621e-02f, -1.86658732e-03f, 4.86616902e-02f, -6.59228563e-02f, -5.85057633e-03f, -1.24736845e-01f,
  -1.17580570e-01f, 7.57760257e-02f, 1.22115836e-01f, -8.32235217e-02f, 1.04731180e-01f, -9.65839028e-02f, 9.18990895e-02f, 2.75311433e-02f, -8.29498023e-02f, 4.96127978e-02f,
  2.58828588e-02f, 2.61384677e-02f, 6.79761991e-02f, 8.24917927e-02f, 2.90437955e-02f, -5.72635606e-03f, -1.00534394e-01f, 2.02895491e-03f, 1.16903856e-01f, -1.22322679e-01f,
  -1.03878699e-01f, -2.56677140e-02f, -5.14185391e-02f, 1.61330402e-01f, -2.18100436e-02f, -4.92901653e-02f, -2.46612821e-02f, -3.70333865e-02f, 8.07696208e-02f, -1.29845262e-01f,
  7.22383708e-02f, 1.01401284e-01f, 1.73030108e-01f, -8.88783485e-02f, -1.40356854e-01f, -4.50540595e-02f, 2.85378508e-02f, -7.23915547e-02f, -1.99180320e-02f, 7.76332915e-02f,
  8.12269896e-02f, -1.03022614e-02f, -5.79921827e-02f, -9.44756120e-02f, -4.45934199e-02f, 2.52827276e-02f, -2.93927416e-02f, -1.25970431e-02f, 1.05602592e-01f, -3.20602171e-02f,
  3.29275765e-02f, 1.33529399e-03f, 5.19628637e-02f, 1.72752872e-01f, 7.41219521e-02f, -5.30581875e-03f, -6.78932443e-02f, 8.92380923e-02f, 4.27796356e-02f, -1.72673464e-01f,
  1.13638304e-01f, -2.67735440e-02f, -8.34714374e-05f, -2.83865556e-02f, -1.12441212e-01f, 1.28622413e-01f, 1.03938475e-01f, 2.39769854e-02f, 1.38449548e-02f, 6.93597123e-02f,
  6.72583356e-02f, -3.72634605e-02f, -1.08533725e-02f, -3.85183878e-02f, -8.70408788e-02f, 1.00265853e-01f, 9.50236693e-02f, -2.47945040e-02f, -5.84632717e-02f, 1.56229466e-01f,
  4.30060960e-02f, 5.86954057e-02f, -1.32983536e-01f, -1.22794911e-01f, -1.75047457e-01f, 4.05311808e-02f, 6.78028390e-02f, 5.21552525e-02f, -3.78330313e-02f, -6.96952045e-02f,
  2.84745544e-02f, 1.43820979e-02f, 1.73739661e-02f, -1.85782611e-02f, 4.05269936e-02f, 4.72425930e-02f, 4.59277034e-02f, 1.21060580e-01f, -1.03906646e-01f, -7.45597854e-02f,
  -8.23735669e-02f, -6.05733022e-02f, 2.21781321e-02f, -1.26151517e-01f, -9.22067277e-03f, -1.73354335e-02f, -5.70435598e-02f, 2.36921329e-02f, 1.38393745e-01f, -8.39790404e-02f,
  -1.15525305e-01f, 1.14856377e-01f, 8.22476298e-02f, -9.69135910e-02f, 9.17834118e-02f, -1.52993584e-02f, 1.33531019e-01f, 1.05113909e-01f, 6.11331165e-02f, 7.75363818e-02f,
  -2.67457329e-02f, -6.10766001e-02f, -1.79342061e-01f, 2.44292151e-02f, -2.73289513e-02f, 5.40404841e-02f, -1.55302152e-01f, -1.86321624e-02f, -1.27007991e-01f, -8.50853771e-02f,
  -1.69986576e-01f, -2.30398737e-02f, 2.82650590e-01f, -9.70701745e-04f, -1.31885484e-01f, 6.42582104e-02f, 1.06615521e-01f, -1.25097051e-01f, -7.07152262e-02f, 2.30527088e-01f,
  -1.61692306e-01f, -9.78211239e-02f, 1.36585250e-01f, 1.29281148e-01f, 1.57675035e-02f, 1.21682249e-01f, 5.34120277e-02f, -7.53720477e-02f, 1.20686397e-01f, 1.86769798e-01f,
  -7.42228627e-02f, 9.12213400e-02f, 6.67783478e-03f, 5.23761883e-02f, -9.53945145e-02f, 1.63369864e-01f, 3.66397649e-02f, 1.09545931e-01f, 4.62196916e-02f, 3.30068082e-01f,
  1.64575636e-01f, 2.08137900e-01f, -7.73327872e-02f, 4.94659916e-02f, -1.15138620e-01f, 1.41591817e-01f, 6.01387657e-02f, -1.39514327e-01f, 1.05546057e-01f, 8.14914703e-02f,
  -8.28619301e-02f, 5.32750878e-03f, 1.26816463e-02f, 1.13854714e-01f, 1.94850713e-01f, -5.06722555e-02f, 9.21509787e-02f, -6.21086955e-02f, 7.56570026e-02f, -7.37197250e-02f,
  1.42748058e-01f, -3.23943943e-02f, 1.91839486e-01f, 2.35161066e-01f, 5.25873043e-02f, 4.94758636e-02f, -1.11629985e-01f, 2.94511672e-02f, -4.17293934e-03f, 2.36294512e-02f,
  -9.62266400e-02f, 1.27051204e-01f, 1.79730013e-01f, -2.19151378e-02f, 1.92908213e-01f, 1.48186162e-01f, -4.45543602e-02f, 8.86449590e-02f, 1.17586829e-01f, 1.30718857e-01f,
  1.05007313e-01f, 2.29106978e-01f, 2.89583266e-01f, -1.32856265e-01f, -5.39653674e-02f, 9.59212184e-02f, 6.43772306e-03f, -1.15086079e-01f, 4.32817750e-02f, 5.66434413e-02f,
  -9.56122130e-02f, 3.05975705e-01f, -2.30016038e-02f, -8.12631249e-02f, 1.03745267e-01f, 5.10101281e-02f, 1.47724122e-01f, 4.24649641e-02f, 9.21825618e-02f, -5.10101542e-02f,
  -2.86578052e-02f, 2.57965829e-02f, 1.10952340e-01f, 3.11444048e-02f, -1.71128064e-01f, -4.58135307e-02f, 2.20329657e-01f, 9.53669325e-02f, 1.13116130e-01f, 8.06404799e-02f,
  1.13911919e-01f, -8.25583488e-02f, -7.28720054e-02f, 5.45343244e-03f, 2.45898083e-01f, 1.61557123e-01f, -6.22361302e-02f, 6.23156317e-02f, 1.16040237e-01f, -8.71623605e-02f,
  -8.91513564e-03f, 3.48063931e-02f, 2.08747596e-01f, 1.62007734e-01f, 3.91802117e-02f, -5.10334447e-02f, 4.11755629e-02f, 1.07376002e-01f, -4.06825021e-02f, 9.92173851e-02f,
  -1.56695381e-01f, -1.28821731e-01f, 1.18802376e-01f, -1.03188820e-01f, -5.92828505e-02f, -9.51052234e-02f, 2.05356143e-02f, 1.16176000e-02f, 1.30013958e-01f, -1.00852735e-01f,
  9.91286412e-02f, 9.17143524e-02f, 1.02106310e-01f, 4.42119613e-02f, -3.72689962e-02f, 4.05010357e-02f, 1.07341245e-01f, -2.22470835e-02f, -1.25505477e-01f, 5.68679534e-02f,
  3.14957425e-02f, 1.93821825e-02f, 6.05519712e-02f, -1.63908061e-02f, 8.30638185e-02f, 5.74958995e-02f, -1.38661429e-01f, 5.21459952e-02f, 3.23214494e-02f, -1.01351224e-01f,
  6.93268776e-02f, -3.46935876e-02f, -1.15153864e-01f, -4.85158525e-03f, 6.83121011e-02f, 9.67605039e-02f, -5.41360416e-02f, 2.14093193e-01f, -2.05868669e-02f, 8.75668228e-02f,
  -2.38125324e-02f, 2.62632184e-02f, 1.16116583e-01f, 1.62001234e-02f, -1.83882844e-03f, 1.27872705e-01f, 1.10683441e-01f, -7.78276771e-02f, -1.29821124e-02f, -6.21947721e-02f,
  -9.59809422e-02f, -9.20931697e-02f, 9.08513591e-02f, 1.61966190e-01f, -4.57208697e-03f, 1.46640286e-01f, 1.04626283e-01f, 5.69320060e-02f, -4.64992076e-02f, 1.33745044e-01f,
  8.10071602e-02f, 8.78746659e-02f, 5.07249795e-02f, 2.51355879e-02f, -6.65674582e-02f, 9.01791155e-02f, 9.60502476e-02f, -6.19501956e-02f, -5.13118841e-02f, 7.11351708e-02f,
  6.95741083e-03f, 9.35935155e-02f, 3.49622481e-02f, 2.91579124e-02f, -1.20610885e-01f, 3.32233054e-03f, -7.53055066e-02f, 1.41459629e-02f, -9.56692100e-02f, -9.99954939e-02f,
  -9.58996341e-02f, -9.17792618e-02f, 1.67177781e-01f, 1.14534467e-01f, 7.29140174e-03f, 1.03370443e-01f, 2.76047755e-02f, -9.11117867e-02f, 1.14628397e-01f, -1.32784680e-01f,
  1.07973173e-01f, -3.49542312e-02f, 1.27661154e-01f, 2.47818716e-02f, -3.94413434e-02f, 6.19941428e-02f, -1.17072146e-02f, 3.66293006e-02f, -1.20359242e-01f, -1.01512507e-01f,
  -9.58915576e-02f, -2.58921925e-02f, 8.69940072e-02f, -1.25921732e-02f, 3.05956863e-02f, -6.40552491e-02f, 1.20754085e-01f, -7.59566054e-02f, 8.92862156e-02f, 5.21310940e-02f,
  1.37358651e-01f, 2.36217249e-02f, 1.41099527e-01f, -1.08410813e-01f, -7.60969743e-02f, 7.59320974e-05f, -8.09038952e-02f, 9.29653645e-03f, 1.35594338e-01f, -3.21368575e-02f,
  -8.81524533e-02f, -2.86426730e-02f, 1.42575860e-01f, 2.07102701e-01f, 2.22377449e-01f, 2.56688520e-02f, 2.60395527e-01f, 2.48278715e-02f, 1.29459634e-01f, -8.54699910e-02f,
  6.44392073e-02f, -1.26711518e-01f, 1.74411938e-01f, 1.92909203e-02f, -6.78834543e-02f, 4.39271033e-02f, 2.68733740e-01f, 9.33891982e-02f, 6.92685181e-03f, -3.77963372e-02f,
  2.45332778e-01f, 1.60761341e-01f, 7.28973895e-02f, 2.66483426e-01f, 1.00125626e-01f, -3.52175459e-02f, 1.55054405e-01f, 1.97237004e-02f, -3.16776633e-02f, -1.53692693e-01f,
  -7.12906010e-03f, -1.26674414e-01f, 4.40622307e-02f, -3.77086224e-03f, -1.81007817e-01f, -8.32061917e-02f, -7.20402226e-02f, 6.92269653e-02f, -7.08305687e-02f, 6.29473180e-02f,
  1.72145218e-02f, 9.12554041e-02f, 1.47303576e-02f, 9.76970568e-02f, 7.09303394e-02f, -5.19509353e-02f, 1.70260206e-01f, 4.43795808e-02f, -1.39635205e-01f, 1.25896558e-01f,
  1.15391620e-01f, -5.04481345e-02f, 3.05909533e-02f, 1.41757771e-01f, 1.50038600e-01f, -1.28306225e-01f, -2.47881617e-02f, 9.07748565e-02f, 2.40760334e-02f, -1.12275138e-01f,
  -7.41100833e-02f, 2.74902433e-01f, 1.32666513e-01f, 9.62591323e-04f, 1.05944648e-02f, -1.28864616e-01f, 9.54446122e-02f, 4.62644361e-03f, 4.55089360e-02f, -2.61108652e-02f,
  6.46338100e-03f, 5.22489958e-02f, -5.38889803e-02f, -1.09182499e-01f, 8.41223728e-03f, 6.24089688e-02f, 1.13045545e-02f, 2.30675079e-02f, -6.17102422e-02f, 1.04728989e-01f,
  -5.84056322e-03f, -3.36438492e-02f, 1.05656154e-01f, 4.60216925e-02f, 1.59733266e-01f, -2.89022159e-02f, -8.35717842e-02f, 1.04956575e-01f, -9.34707299e-02f, -1.42346010e-01f,
  1.32903442e-01f, -1.08743049e-01f, -3.42169963e-02f, 1.39562262e-03f, -4.03863899e-02f, -8.06030259e-02f, -1.90205071e-02f, -1.40160499e-02f, -2.43546963e-02f, -4.04486619e-02f,
  2.82676481e-02f, 8.96039009e-02f, 7.08759353e-02f, -1.16349377e-01f, 9.36799198e-02f, 6.57810122e-02f, 6.08605854e-02f, -1.04198314e-01f, 6.54291734e-02f, -4.89321053e-02f,
  1.59708634e-01f, 6.18023681e-04f, 9.50238854e-02f, 6.06214367e-02f, -9.00015682e-02f, -6.06752699e-03f, -6.98284879e-02f, 4.32811081e-02f, -3.86669375e-02f, -9.47382152e-02f,
  8.84994864e-02f, 6.13620207e-02f, -7.00599775e-02f, -2.56530512e-02f, 1.03853844e-01f, 1.30747199e-01f, 1.00532241e-01f, -1.05426870e-01f, -7.76060894e-02f, -4.72477488e-02f,
  -7.54682943e-02f, 6.08463511e-02f, -7.08430856e-02f, 5.23348711e-02f, -2.88166888e-02f, 6.63744211e-02f, 7.89040700e-02f, 3.29656973e-02f, 1.26414463e-01f, -6.16140701e-02f,
  1.10914007e-01f, -1.71918850e-02f, 1.10667929e-01f, 1.57914776e-02f, -1.05346255e-01f, 1.09187357e-01f, -3.44675779e-02f, 2.37892568e-02f, -9.79064628e-02f, 7.11666197e-02f,
  1.32129833e-01f, 2.21197004e-03f, 7.98787400e-02f, -1.04405515e-01f, 7.19923526e-02f, -7.33386502e-02f, 7.80208036e-02f, 1.80571288e-01f, 3.05926129e-02f, 1.15906097e-01f,
  -2.23654155e-02f, -1.01983093e-01f, -1.12096272e-01f, 4.75768186e-02f, 1.21749282e-01f, -1.26117930e-01f, -1.24262132e-01f, 4.89442088e-02f, 6.88032955e-02f, -1.52203342e-04f,
  8.91554058e-02f, -1.39091447e-01f, -1.12090304e-01f, 5.86951673e-02f, 1.70470878e-01f, 9.86901000e-02f, 1.15086492e-02f, 2.33094450e-02f, -6.10159934e-02f, 1.01856172e-01f,
  5.00818007e-02f, 5.24502248e-02f, -3.28908451e-02f, -7.52909258e-02f, -9.47074071e-02f, 5.41865416e-02f, 1.37028053e-01f, -2.61924639e-02f, -4.87594008e-02f, -6.80586994e-02f,
  -6.25097826e-02f, 1.31848291e-01f, -5.01629449e-02f, -5.30168936e-02f, 3.20092961e-02f, 7.93693140e-02f, 1.94453429e-02f, -8.06191713e-02f, 2.86679957e-02f, -2.31108686e-04f,
  -1.38962060e-01f, 1.04074061e-01f, 1.23475321e-01f, 2.06747111e-02f, -1.03875369e-01f, 1.10668115e-01f, 9.51938778e-02f, -1.82728935e-02f, 6.99464381e-02f, -6.19436391e-02f,
  1.23240724e-01f, -2.80877128e-02f, 1.82203157e-03f, -2.37847529e-02f, -2.25031767e-02f, 3.76369506e-02f, 5.04599065e-02f, -5.29534146e-02f, 1.76450685e-02f, 1.60879701e-01f,
  6.37317002e-02f, 7.94132426e-02f, 2.43893564e-02f, -4.38818559e-02f, -3.58336009e-02f, 6.27570674e-02f, -1.30968556e-01f, 9.10664909e-03f, -4.04327251e-02f, 1.08772844e-01f,
  1.70292258e-02f, -2.89543886e-02f, -2.71752998e-02f, 1.13873212e-02f, 1.24099813e-01f, -6.71420023e-02f, 1.44049693e-02f, 1.98376343e-01f, 6.21658079e-02f, 1.42674848e-01f,
  4.97403294e-02f, -2.89990343e-02f, -3.78325023e-02f, 1.21858977e-01f, 6.91362545e-02f, -9.87975821e-02f, -6.84058070e-02f, 2.97628567e-02f, -1.03294708e-01f, 9.30283442e-02f,
  -1.01271249e-01f, 4.84106541e-02f, 9.66213048e-02f, 3.19871753e-02f, -7.16481805e-02f, -7.01357052e-02f, 8.75265598e-02f, 7.16900378e-02f, 2.39245623e-01f, 2.24983133e-03f,
  2.31735021e-01f, 1.50406972e-01f, 1.07230701e-01f, 1.29484817e-01f, 3.01340297e-02f, 1.51173085e-01f, -2.22678944e-01f, 3.53991330e-01f, 3.02654393e-02f, 5.48974983e-03f,
  -1.69353522e-02f, -6.72273636e-02f, 2.77238786e-02f, -1.02314748e-01f, 1.88928172e-01f, 1.88326791e-01f, -3.35374512e-02f, -3.19144875e-02f, 6.22162260e-02f, 2.02681661e-01f,
  3.13664705e-01f, 1.10778846e-01f, -2.50798792e-01f, -5.54964431e-02f, -6.68293163e-02f, -1.84784770e-01f, 4.66370396e-03f, 1.97605729e-01f, -5.01894280e-02f, 3.68108779e-01f,
  -9.14524600e-04f, -2.75987219e-02f, -9.76582021e-02f, -8.02376401e-03f, 1.54985234e-01f, 2.68852562e-01f, -2.54144594e-02f, -9.70614478e-02f, -6.10385239e-02f, 1.59748301e-01f,
  3.53352353e-02f, -1.07302129e-01f, -1.94068998e-01f, -7.58432001e-02f, 1.54680669e-01f, 1.45611629e-01f, -6.00519814e-02f, 6.73332363e-02f, 5.15226610e-02f, 8.96924511e-02f,
  8.66024941e-02f, 1.31271586e-01f, 9.24008787e-02f, -2.00010145e-05f, 1.24715246e-01f, 1.30309612e-01f, -1.05571464e-01f, -1.24545299e-01f, -8.37659463e-02f, 9.02632847e-02f,
  1.17481716e-01f, 2.16140896e-01f, 7.34766126e-02f, 1.34347841e-01f, 1.07313775e-01f, 4.54857126e-02f, -7.11091533e-02f, 1.50785968e-01f, -1.37744755e-01f, 1.25708073e-01f,
  2.26695746e-01f, -2.51557738e-01f, -6.45827577e-02f, -2.36033410e-01f, 9.02924463e-02f, -5.75168468e-02f, -3.35824229e-02f, -2.53960900e-02f, 8.34855735e-02f, 1.23515636e-01f,
  5.46415150e-02f, 1.59557655e-01f, 1.25515267e-01f, -2.62825303e-02f, 1.01740547e-01f, 1.12650797e-01f, 1.56388003e-02f, 1.53154790e-01f, 7.68531114e-02f, 1.66915610e-01f,
  -1.14127249e-01f, -9.49161351e-02f, 1.56558916e-01f, -4.83320933e-03f, 1.38001412e-01f, 1.41958162e-01f, 1.16345011e-01f, 2.23477930e-02f, -2.46086419e-02f, -7.49316737e-02f,
  -2.10338403e-02f, -3.61452512e-02f, 1.20831653e-01f, -3.57156545e-02f, 1.10564545e-01f, 2.88456857e-01f, 1.95098937e-01f, -1.09443806e-01f, -4.09013219e-02f, -1.33779645e-01f,
  -2.86770090e-02f, -2.94426102e-02f, 4.48219143e-02f, 5.85738756e-02f, -9.76874679e-02f, 4.23143692e-02f, -1.05017744e-01f, -1.38230100e-01f, -3.59689966e-02f, 9.56096351e-02f,
  -1.30790472e-01f, -3.08469180e-02f, 4.63400483e-02f, 1.09805249e-01f, 5.61934523e-02f, -1.00316308e-01f, -8.09861273e-02f, -5.89637272e-02f, -2.77253352e-02f, -1.23730481e-01f,
  2.20923349e-02f, -1.11435011e-01f, 1.59077924e-02f, -6.07020110e-02f, 1.12473644e-01f, -8.09515119e-02f, -1.35793224e-01f, 7.47067155e-03f, -5.81927411e-02f, 2.17904225e-02f,
  -9.02251899e-03f, -4.68978211e-02f, -3.58722247e-02f, 5.96262030e-02f, -2.49594487e-02f, 1.02605037e-01f, 1.16190434e-01f, -1.16986915e-01f, -1.10941067e-01f, -6.76199719e-02f,
  -5.14466800e-02f, -4.71579283e-03f, 3.96370068e-02f, 1.20094977e-02f, 6.62514183e-04f, 1.09196074e-01f, -8.25398639e-02f, 2.41752025e-02f, -4.21803631e-03f, -5.80644235e-02f,
  -5.26961312e-02f, -9.13286135e-02f, -1.63532495e-02f, -4.75933701e-02f, -7.59008527e-02f, 1.19042352e-01f, -1.11695133e-01f, -9.85217616e-02f, 5.58913760e-02f, -5.09769954e-02f,
  7.90860504e-02f, -9.88622010e-02f, -3.62432264e-02f, 1.15266047e-01f, -9.34451744e-02f, -2.37289183e-02f, -1.01320315e-02f, 5.82669787e-02f, -3.04527935e-02f, 2.59652473e-02f,
  1.61440056e-02f, -5.41121559e-03f, 1.50377573e-02f, -1.12502791e-01f, -4.53125499e-02f, -5.10118157e-02f, 5.03369654e-03f, -5.82280047e-02f, -3.69585529e-02f, -4.16552275e-03f,
  1.35032833e-01f, -5.16102500e-02f, 1.45563677e-01f, 8.23873207e-02f, -3.47740129e-02f, -5.95468394e-02f, -1.24504566e-01f, -1.72681540e-01f, 8.13587382e-02f, 1.34036168e-02f,
  -1.80622920e-01f, -1.50709808e-01f, -3.89849618e-02f, -2.08361465e-02f, 1.25195280e-01f, 1.60572723e-01f, 1.49528772e-01f, 7.96248987e-02f, -2.14876235e-02f, 1.37051702e-01f,
  7.75406063e-02f, -4.08084691e-02f, 1.88150167e-01f, 5.52233867e-02f, 8.78246874e-02f, 2.23982558e-01f, -8.28640386e-02f, 1.53555080e-01f, 9.76257119e-03f, 9.07987505e-02f,
  -1.38580073e-02f, -8.32059011e-02f, -8.78624767e-02f, -8.12378451e-02f, 1.49304450e-01f, -1.47351682e-01f, -3.28238681e-02f, -8.40505287e-02f, 4.02169563e-02f, -2.22745854e-02f,
  2.71589290e-02f, -7.82206133e-02f, 6.13652989e-02f, 1.58867568e-01f, 8.87883827e-02f, 7.53008127e-02f, -4.12581824e-02f, -5.38131706e-02f, -2.28344537e-02f, -1.97821409e-02f,
  1.43999845e-01f, 6.05494156e-02f, -9.22935270e-03f, 4.37556952e-02f, 1.22989461e-01f, 8.00028667e-02f, 1.89688399e-01f, 1.47120565e-01f, -2.25250889e-02f, -5.22371233e-02f,
  -7.91791230e-02f, -6.71416447e-02f, -1.58848036e-02f, -4.11131568e-02f, 1.07853010e-01f, 3.72592695e-02f, 1.08638890e-01f, 1.94542602e-01f, 1.98934749e-02f, 8.30357969e-02f,
  -2.08066627e-02f, 1.04893759e-01f, -2.30267290e-02f, -2.13799626e-02f, -6.17251173e-02f, -2.09246919e-01f, -5.52048497e-02f, -4.44387197e-02f, -7.82592744e-02f, 2.53421307e-01f,
  8.46216083e-02f, -1.02684990e-01f, 2.34062336e-02f, -7.15019703e-02f, 1.46832481e-01f, -7.45395869e-02f, 2.67382599e-02f, -7.34772161e-02f, 2.87958324e-01f, 1.81243494e-01f,
  9.20516178e-02f, -4.20707315e-02f, -1.24332525e-01f, -9.23273563e-02f, 1.00901842e-01f, -9.91413444e-02f, -4.91423868e-02f, -2.70393454e-02f, 1.00937940e-01f, 8.30942299e-03f,
  1.25863910e-01f, 6.63400516e-02f, 1.46579966e-01f, 1.14671566e-01f, -2.49888692e-02f, 3.97205912e-02f, 7.43578076e-02f, -3.27538140e-02f, -6.24688677e-02f, -5.06462492e-02f,
  4.77090888e-02f, -1.16468608e-01f, -7.12023675e-02f, 5.13896942e-02f, 8.62586126e-02f, 1.35540232e-01f, -6.56276643e-02f, -8.01719949e-02f, -9.15639009e-03f, -1.87447276e-02f,
  1.87429711e-01f, 1.65293202e-01f, -1.03433363e-01f, -1.31226122e-01f, 3.80084217e-02f, -2.55031069e-03f, -9.93095934e-02f, -5.19975945e-02f, 2.09417706e-03f, 4.44182232e-02f,
  8.42189193e-02f, -1.02392107e-01f, -7.73119777e-02f, -1.00816108e-01f, -1.69738218e-01f, -2.82282420e-02f, -4.86725643e-02f, -2.02785935e-02f, -1.33283325e-02f, -1.71527073e-01f,
  -7.51244090e-03f, 1.55897578e-02f, 1.11507401e-01f, 1.34136572e-01f, 1.76425121e-04f, -3.75735834e-02f, 4.30563129e-02f, 1.29561320e-01f, 1.28743619e-01f, 3.47841270e-02f,
  3.99074666e-02f, 1.04732454e-01f, -1.29136771e-01f, -5.02342358e-02f, -3.40492725e-02f, 1.52801305e-01f, -8.42356905e-02f, 1.02631308e-01f, -7.75095150e-02f, -6.71039075e-02f,
  9.63965654e-02f, -2.58193221e-02f, 4.56781033e-03f, -7.84975216e-02f, 7.06399083e-02f, 4.71252874e-02f, 5.71779627e-03f, 1.00511596e-01f, 7.26197800e-03f, 5.13558229e-03f,
  -1.30017083e-02f, 7.67485350e-02f, 3.18782683e-03f, 4.49839048e-02f, -9.17830912e-04f, 4.11617421e-02f, 4.89200093e-02f, 1.04456045e-01f, 1.47364587e-01f, 1.29412897e-02f,
  -3.22291888e-02f, 6.32654652e-02f, 1.23420432e-01f, 2.73314249e-02f, -1.47905219e-02f, 5.04037039e-03f, 1.32530704e-01f, -3.93529460e-02f, -5.72778992e-02f, 6.00536987e-02f,
  1.14728749e-01f, 4.88019809e-02f, 2.03506579e-03f, 1.30840406e-01f, -2.61015743e-02f, 5.46407178e-02f, 4.44957465e-02f, -2.26994902e-02f, 3.42971981e-02f, -3.67777497e-02f,
  3.75675820e-02f, -1.28087133e-01f, 8.77234433e-03f, 7.76817426e-02f, 8.51820260e-02f, 4.64703664e-02f, 1.42566204e-01f, -8.90935734e-02f, -6.91674501e-02f, 6.75403774e-02f,
  1.46952599e-01f, 1.17477611e-01f, 2.51465999e-02f, 6.58076853e-02f, -5.94239086e-02f, -1.23719454e-01f, 1.55182853e-01f, -6.29625022e-02f, -8.38418826e-02f, 2.91023944e-02f,
  -1.26441464e-01f, -9.49643180e-02f, 8.83829743e-02f, 7.65048191e-02f, 3.18932906e-02f, -8.28796253e-02f, -1.10566139e-01f, 1.58658341e-01f, 6.75464720e-02f, 2.47323643e-02f,
  9.54657793e-02f, -9.33167189e-02f, 5.59964217e-03f, -1.12567402e-01f, 8.68865103e-02f, -9.22597293e-03f, 8.20853263e-02f, 1.31416306e-01f, -9.67500582e-02f, -7.95599744e-02f,
  -1.01544380e-01f, 3.33084702e-03f, 3.13497637e-03f, 6.77797049e-02f, -4.03396226e-02f, -1.10437937e-01f, 2.97528468e-02f, -6.63456693e-02f, -1.50701739e-02f, -7.58307055e-02f,
  -1.08723931e-01f, 8.18314701e-02f, -3.28027457e-02f, -6.49814084e-02f, -3.59144509e-02f, -8.09356496e-02f, 1.62450746e-01f, 2.51136627e-02f, 1.50842711e-01f, -1.67363122e-01f,
  2.90764540e-01f, 1.78523690e-01f, -1.24490194e-01f, 1.22029148e-01f, 1.53431788e-01f, -7.54490718e-02f, 1.39915168e-01f, -1.55500114e-01f, -1.07513100e-01f, -5.20186545e-03f,
  -8.82174075e-02f, -6.46684840e-02f, 8.66731033e-02f, 1.68585792e-01f, 7.69821834e-03f, -1.18936054e-01f, -5.71292154e-02f, 9.75214839e-02f, -7.56980330e-02f, -1.30813986e-01f,
  2.37389669e-01f, -5.76485693e-03f, 5.72916530e-02f, 1.42718563e-02f, -1.24710426e-01f, 6.33177459e-02f, 2.47626588e-01f, -1.07325464e-01f, 1.47101805e-01f, 3.05722386e-01f,
  -1.20273471e-01f, 3.51222068e-01f, 1.14794582e-01f, 5.72900251e-02f, -1.56420339e-02f, 2.47208681e-02f, 1.02789044e-01f, 3.33265588e-02f, 9.90351941e-03f, 1.28609300e-01f,
  1.44787282e-01f, -4.83630076e-02f, -1.58503205e-01f, -4.91769388e-02f, 1.99241508e-02f, 1.28240705e-01f, -1.66407153e-01f, 1.53645158e-01f, 2.19551146e-01f, 1.33452505e-01f,
  4.55040820e-02f, -6.74739480e-02f, -1.91461578e-01f, -1.26079217e-01f, 1.82375580e-01f, 2.48891845e-01f, 1.70917228e-01f, 1.45472482e-01f, -2.38106586e-02f, 3.64293866e-02f,
  -6.43198937e-02f, -4.76244874e-02f, -6.53663203e-02f, -5.98261543e-02f, 1.89996343e-02f, -1.71111561e-02f, -7.03234375e-02f, 8.72733071e-02f, -8.72578993e-02f, -1.11561395e-01f,
  3.06619499e-02f, -2.83023100e-02f, 7.12476596e-02f, -3.57566401e-02f, 1.91866141e-02f, 3.59490663e-02f, 3.21899205e-02f, -3.35343252e-03f, -9.24188867e-02f, -1.25081781e-02f,
  1.28702387e-01f, -8.24738964e-02f, -5.43437600e-02f, -3.70546281e-02f, -1.11540049e-01f, 1.34464189e-01f, 1.09344810e-01f, 5.67948781e-02f, 1.27668723e-01f, -6.11594133e-02f,
  -4.15445268e-02f, -1.21018544e-01f, -1.20097257e-01f, -2.84326058e-02f, -5.19269593e-02f, -7.48836622e-02f, -1.05273686e-01f, -1.08737294e-02f, -5.16961925e-02f, 1.27277263e-02f,
  -3.65599953e-02f, -7.93666393e-02f, -9.40050185e-02f, 9.25434902e-02f, 4.66742404e-02f, -8.82281214e-02f, -3.41527984e-02f, 4.75207642e-02f, -7.84862693e-03f, 9.68071725e-03f,
  -2.34182477e-02f, 1.22366913e-01f, -7.67399371e-03f, -2.13616807e-02f, 1.54422279e-02f, -5.14829382e-02f, 8.49976614e-02f, 7.98417181e-02f, 7.53590167e-02f, 3.90623957e-02f,
  -8.75423383e-03f, -3.56576331e-02f, 1.28306495e-02f, 2.71966644e-02f, 1.07808523e-01f, -6.59595877e-02f, 7.01620281e-02f, 1.50371790e-01f, 1.88897729e-01f, 8.48510489e-02f,
  2.72499323e-02f, 2.25543622e-02f, -1.50112078e-01f, -4.65385988e-02f, 1.57581195e-01f, 1.21370673e-01f, -1.03985555e-01f, -9.47497115e-02f, -1.26585573e-01f, -7.53924325e-02f,
  -7.94797484e-03f, 4.81486805e-02f, 5.00086881e-02f, 4.98905033e-02f, 9.47997719e-02f, 8.88642389e-03f, -7.13805929e-02f, 1.22918449e-01f, 1.54898718e-01f, 1.41796032e-02f,
  -1.10321797e-01f, -1.25782609e-01f, -9.12690982e-02f, 5.84428534e-02f, 1.08492985e-01f, 4.57745269e-02f, 1.44935641e-02f, -3.65140550e-02f, -6.94131851e-02f, 1.10842846e-01f,
  -1.85591299e-02f, 1.23191103e-02f, -2.75226198e-02f, 9.12763644e-03f, -9.43157524e-02f, 6.77855825e-03f, 2.01105997e-02f, -4.44349907e-02f, 3.29573043e-02f, -1.05230719e-01f,
  -3.62927318e-02f, 5.32757305e-02f, 1.01097777e-01f, -3.09407860e-02f, -3.66749614e-03f, 1.18083104e-01f, -6.98062181e-02f, 7.91929848e-03f, -3.60256508e-02f, -2.29969639e-02f,
  5.80721200e-02f, 2.27672346e-02f, -4.28195149e-02f, 2.96956263e-02f, 1.02069415e-01f, -1.22982254e-02f, -3.63242328e-02f, 1.78787094e-02f, -8.43938962e-02f, 8.31369087e-02f,
  -5.77267669e-02f, -3.00499834e-02f, -9.34066549e-02f, -1.78565215e-02f, -1.17039785e-01f, 5.43925129e-02f, -1.29940599e-01f, -9.95047018e-02f, -3.42669785e-02f, 7.42916986e-02f,
  -6.39552698e-02f, 6.21516444e-02f, 9.60027725e-02f, -9.30314139e-02f, 5.06475680e-02f, -8.41322169e-02f, -4.82586259e-03f, 3.39974687e-02f, -2.60374919e-02f, -9.75637808e-02f,
  -2.33325344e-02f, -2.72969957e-02f, -8.84885788e-02f, 1.15873635e-01f, 1.11378610e-01f, -6.43186271e-02f, -1.07203476e-01f, -2.76635159e-02f, 1.50005566e-03f, 1.07629530e-01f,
  -1.49677489e-02f, -1.16365321e-01f, -6.43404946e-02f, -6.84870705e-02f, -2.49444563e-02f, -8.00186396e-02f, -1.86284557e-02f, 1.36254042e-01f, 5.45473397e-02f, -1.28282323e-01f,
  6.93070367e-02f, 1.08834095e-01f, -3.26871164e-02f, -1.04990661e-01f, 5.58282211e-02f, -1.10448003e-01f, -4.43441682e-02f, -1.00047559e-01f, 7.73935989e-02f, -4.10862677e-02f,
  -6.63453490e-02f, 5.42347692e-02f, 9.76392105e-02f, -6.34242669e-02f, -5.84000051e-02f, -4.33651023e-02f, -4.56878655e-02f, -1.02236904e-01f, 9.81554613e-02f, -1.16654322e-01f,
  1.02999233e-01f, -1.27739102e-01f, 3.79337929e-02f, 2.13392749e-01f, 1.34047866e-01f, 2.04094183e-02f, 2.25784898e-01f, 1.38093904e-01f, -2.48317085e-02f, 7.92686418e-02f,
  1.12936576e-03f, -2.08096758e-01f, -7.83745944e-02f, -2.82055000e-03f, 5.95462508e-02f, 2.25049891e-02f, 6.69121295e-02f, -5.31521020e-03f, 5.55578433e-02f, 9.54324901e-02f,
  1.50514454e-01f, -3.13692950e-02f, -5.43894731e-02f, -7.85566419e-02f, -7.39216879e-02f, 1.51561111e-01f, 2.45126411e-01f, 5.77368252e-02f, -2.38514561e-02f, 1.12886444e-01f,
  -1.39485091e-01f, -7.57151917e-02f, 1.88114315e-01f, -2.47006193e-02f, 1.34148568e-01f, 6.21092506e-02f, -4.64987531e-02f, -1.30029991e-02f, 4.73240837e-02f, -9.25984308e-02f,
  9.13705528e-02f, 3.42132784e-02f, 1.80548310e-01f, -4.02893275e-02f, 2.60920096e-02f, 1.48034006e-01f, 9.83957276e-02f, 1.23259360e-02f, 8.74890238e-02f, 1.39841095e-01f,
  -5.42449728e-02f, 1.48826808e-01f, -2.47505922e-02f, 5.40995821e-02f, -7.29950890e-02f, -6.66645542e-02f, 5.43853752e-02f, -5.40373623e-02f, 1.50672063e-01f, -9.49762464e-02f,
  1.90210834e-01f, 6.27324358e-02f, 3.15126441e-02f, -4.39036079e-02f, -8.96857753e-02f, -5.47858700e-03f, 8.30131620e-02f, 1.23472422e-01f, -7.21887425e-02f, 8.88422411e-03f,
  -8.48323107e-02f, -4.87334579e-02f, 1.36803329e-01f, -2.04717591e-02f, -5.10389060e-02f, 3.78179029e-02f, 2.45944411e-02f, 3.54101434e-02f, 3.24195996e-03f, -1.06470957e-01f,
  -2.18660664e-02f, 2.20395010e-02f, 1.29733130e-01f, 2.08966471e-02f, -5.27975224e-02f, 1.04219772e-01f, 4.19677887e-03f, 2.34651472e-02f, -5.15406094e-02f, -6.92683086e-02f,
  -8.08434281e-03f, 6.60925582e-02f, 1.28817230e-01f, -8.73920098e-02f, -6.52949736e-02f, -6.20230325e-02f, 1.06872171e-01f, 1.81485251e-01f, -9.54661444e-02f, 1.23580217e-01f,
  -6.67333826e-02f, -1.31550923e-01f, 1.97588746e-02f, -9.85309929e-02f, 1.03846148e-01f, 5.58193699e-02f, -8.92500877e-02f, -1.54484215e-03f, 1.42546697e-02f, -8.04302841e-02f,
  9.52071995e-02f, -3.79990600e-02f, -1.36735857e-01f, 3.39314491e-02f, -9.30249840e-02f, -8.57951567e-02f, 1.02287024e-01f, -7.92535096e-02f, 1.25534192e-01f, -9.58376285e-03f,
  -1.10514872e-01f, -4.13586497e-02f, 7.63110518e-02f, 6.59047738e-02f, 3.79156321e-02f, 1.37523696e-01f, 8.30088705e-02f, 1.55324731e-02f, 1.27476454e-01f, 8.53563398e-02f,
  1.65445030e-01f, 2.38524075e-03f, -3.88554856e-02f, -3.38839320e-03f, -4.67145517e-02f, 1.21390492e-01f, 7.13750115e-03f, 1.20981872e-01f, -1.02373414e-01f, -6.70406520e-02f,
  -8.10550451e-02f, -1.08628176e-01f, 1.12109192e-01f, 3.91416252e-02f, -3.96774001e-02f, 4.22829054e-02f, 1.67011663e-01f, 1.16539776e-01f, -5.13133965e-02f, -1.24191940e-01f,
  1.49624184e-01f, 1.06640579e-02f, -1.99376941e-02f, -3.05657294e-02f, 1.10015780e-01f, 5.92740178e-02f, -3.07118818e-02f, 1.48841918e-01f, -5.88249750e-02f, -6.15735315e-02f,
  7.50971213e-02f, 1.17118113e-01f, 1.72266990e-01f, 1.31934043e-02f, 1.23658411e-01f, -8.98028165e-03f, -2.50070877e-02f, 7.03742653e-02f, 4.10290109e-03f, -1.09404929e-01f,
  4.78239283e-02f, -1.20816771e-02f, -1.01241738e-01f, 4.97789271e-02f, -4.98216599e-02f, 1.27285689e-01f, -2.37993095e-02f, -5.47335371e-02f, 3.63760330e-02f, -9.58525985e-02f,
  1.21472627e-01f, 1.68531075e-01f, -5.63579286e-03f, 5.02340309e-03f, -1.05758421e-01f, 7.55038531e-03f, 6.93905801e-02f, -1.38876671e-02f, 1.59873441e-01f, -3.39973085e-02f,
  -1.58915874e-02f, 1.16519868e-01f, -9.34734568e-02f, 2.79684514e-02f, 1.50716782e-01f, 5.75959273e-02f, 1.83312327e-01f, 3.34724516e-01f, 4.13191803e-02f, 1.67152435e-01f,
  -3.36887091e-01f, -1.35725677e-01f, -2.28005946e-02f, -1.59919485e-01f, -3.07593405e-01f, -2.13458404e-01f, 1.53143957e-01f, 1.26162797e-01f, 3.31867784e-02f, 3.31132710e-01f,
  1.05574474e-01f, 6.92180917e-02f, 4.37497534e-02f, 2.24876162e-02f, 1.23719841e-01f, -1.20011270e-01f, 2.36825347e-01f, 1.41852289e-01f, -2.02121632e-03f, 2.23120481e-01f,
  -6.62654862e-02f, 1.20176099e-01f, 1.20610617e-01f, -1.27509147e-01f, 1.06331863e-01f, 1.36298716e-01f, 1.47696689e-01f, -1.08884618e-01f, 3.23623866e-01f, 2.42848601e-02f,
  3.10054049e-02f, -2.61649344e-04f, 7.82128945e-02f, -1.10938147e-01f, 1.57060679e-02f, 7.28675500e-02f, 9.62192714e-02f, 1.84168324e-01f, -1.60570145e-01f, 2.79958062e-02f,
  8.69892091e-02f, 1.97470281e-02f, 3.73892151e-02f, 2.86586992e-02f, 1.92936882e-01f, 2.38161340e-01f, -5.40285520e-02f, 1.37777608e-02f, 2.82496333e-01f, -8.09412673e-02f,
  2.72211879e-01f, 1.68174610e-01f, 7.70937726e-02f, -1.78084642e-01f, 7.59234801e-02f, 1.44026339e-01f, 1.58996746e-01f, 3.96249332e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  3.07085589e-02f, 1.42235383e-01f, 3.58801812e-01f, -1.24049395e-01f, 1.59259304e-01f, 6.74450621e-02f, 4.01029177e-02f, 2.15742648e-01f, 1.32741407e-01f, 1.09021999e-01f,
  9.19818357e-02f, 1.62775621e-01f, -3.12975608e-02f, 1.24213770e-01f, 1.27681717e-01f, -1.33103933e-02f, 1.30559728e-01f, 6.23762682e-02f, 1.33243680e-01f, 1.39949173e-01f,
  4.31525446e-02f, 2.07536608e-01f, 2.99042046e-01f, 2.62702972e-01f, 5.79038113e-02f, 1.58799052e-01f, 5.49849756e-02f, 6.93270341e-02f, 9.56711844e-02f, 1.29972607e-01f,
  1.39257401e-01f, 9.40930396e-02f, 8.04494917e-02f, 1.96548462e-01f, 2.17536073e-02f, 3.45666148e-02f, 1.51595855e-02f, 2.79022455e-01f, 5.76812439e-02f, -9.94886234e-02f,
  1.31401420e-01f, 1.06010139e-01f, 7.07327202e-02f, -2.94492394e-02f, 1.66418329e-01f, 9.03175920e-02f, -9.05407593e-03f, 1.74814537e-02f, 2.72891540e-02f, 1.50531843e-01f,
  6.49678037e-02f, 9.07070935e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  6.53494298e-02f, -9.15027857e-02f, -1.91286448e-02f, -1.09975807e-01f, -4.29707579e-02f, 7.14967474e-02f, -1.22944191e-02f, -8.35426897e-02f, -1.53291628e-01f, -7.76175503e-03f,
  9.04515907e-02f, 4.16925624e-02f, 1.17970735e-01f, 1.12494878e-01f, 2.89018482e-01f, 8.91883969e-02f, -5.13584875e-02f, -3.89267243e-02f, -1.28666740e-02f, -1.52871817e-01f,
  -4.96607274e-02f, -9.03696418e-02f, -9.31541324e-02f, 6.65566623e-02f, -1.02488354e-01f, 4.37074080e-02f, -9.43179503e-02f, -5.13731949e-02f, 3.86646315e-02f, 6.17547818e-02f,
  3.71181332e-02f, -5.98194972e-02f, 1.36364534e-01f, 2.18863506e-02f, 8.33512023e-02f, -1.28037229e-01f, -1.63336486e-01f, 9.46554914e-02f, 1.56279936e-01f, -8.08361620e-02f,
  -9.32226330e-02f, -2.17361614e-01f, 8.16816613e-02f, -8.53994414e-02f, 2.67170998e-03f, 6.69906586e-02f, 3.64206918e-02f, 6.53570592e-02f, 5.97336479e-02f, 2.33858839e-01f,
  -1.19318329e-01f, -5.77413961e-02f, -5.99055039e-03f, -2.73529235e-02f, -1.13642499e-01f, 4.79363762e-02f, -1.08819306e-02f, -8.02716166e-02f, 9.36052874e-02f, 1.13624454e-01f,
  -2.32163668e-02f, 4.84168828e-02f, -7.00511411e-02f, -3.67915742e-02f, 6.71646595e-02f, -7.34226480e-02f, 1.84626564e-01f, 1.18517920e-01f, -1.26678407e-01f, 1.88431859e-01f,
  -2.78757095e-01f, 1.93913877e-01f, 2.49622881e-01f, -8.80899373e-03f, 1.29324362e-01f, 2.00562030e-01f, -1.05815493e-01f, 3.72468792e-02f, -3.64989303e-02f, -8.61483887e-02f,
  2.17127949e-01f, 5.11263497e-05f, -2.96880808e-02f, -1.86731797e-02f, -1.11424044e-01f, -1.75958440e-01f, -7.79448226e-02f, 6.65070117e-02f, -1.56638473e-02f, -1.17226779e-01f,
  -1.74701866e-02f, -6.40530065e-02f, -3.49340141e-02f, 1.07649818e-01f, -5.57658859e-02f, -3.85542884e-02f, -9.07516330e-02f, -8.31463560e-02f, -9.67267081e-02f, -1.88461870e-01f,
  -8.16940218e-02f, 6.09347858e-02f, 4.49913729e-04f, -4.91377525e-02f, 6.68891147e-02f, -1.24849137e-02f, -1.04712844e-01f, -1.61745116e-01f, -8.06563068e-03f, 9.59726423e-02f,
  -8.12058374e-02f, 1.22453561e-02f, -1.88031986e-01f, -1.61179647e-01f, 2.01737676e-02f, -1.16642155e-01f, 5.17079458e-02f, 2.17823267e-01f, 3.47815007e-02f, -5.65616339e-02f,
  -1.52796790e-01f, -1.85102969e-02f, 1.07084304e-01f, 1.53588690e-02f, -1.12830035e-01f, 8.66576806e-02f, 8.07052595e-04f, 1.59571897e-02f, -1.09093785e-01f, -9.57323760e-02f,
  -1.61788359e-01f, 3.68723366e-03f, -2.60286689e-01f, -1.95405498e-01f, 1.37671754e-01f, 1.56608447e-01f, -2.25328989e-02f, -2.27520242e-02f, 1.93812564e-01f, -4.54147384e-02f,
  1.06884345e-01f, -1.86559707e-01f, -2.87823379e-03f, 1.05968736e-01f, 1.57649100e-01f, -5.83205409e-02f, -1.28621245e-02f, -2.70432397e-03f, -5.91645315e-02f, -1.29962906e-01f,
  -4.87039834e-02f, 5.36405817e-02f, 2.64115687e-02f, -9.03110877e-02f, -8.29240307e-02f, -1.58650950e-02f, -3.56188277e-04f, 7.45199248e-02f, -1.10726885e-01f, -1.81643099e-01f,
  -3.54610495e-02f, 1.96444422e-01f, -1.24811092e-02f, 1.65521801e-01f, -1.10479549e-01f, -2.03946114e-01f, 1.44387066e-01f, 4.77444381e-02f, 9.55291018e-02f, -1.19808562e-01f,
  2.10933253e-01f, -5.17481891e-03f, 7.81657845e-02f, 1.93201587e-01f, -3.10871657e-02f, -9.84310582e-02f, 6.22078329e-02f, -1.50131553e-01f, 5.50011657e-02f, -4.79549216e-03f,
  -8.22849758e-03f, 8.56173784e-02f, 8.64458680e-02f, 1.76381856e-01f, -5.73340915e-02f, -2.92657446e-02f, -1.16873413e-01f, 4.14644144e-02f, 7.26819932e-02f, 1.09635323e-01f,
  -9.53960568e-02f, 8.21728408e-02f, -8.38322863e-02f, -2.04435751e-01f, -1.20236792e-01f, -1.01666890e-01f, -1.23630948e-01f, -1.29262254e-01f, 1.20522775e-01f, 4.20395397e-02f,
  1.50065079e-01f, -1.01487808e-01f, 1.28673287e-02f, 1.43690109e-01f, 8.28417838e-02f, 7.72404438e-03f, -8.12262520e-02f, 5.40907942e-02f, 1.91225391e-02f, -4.01450768e-02f,
  5.22483997e-02f, 6.52640015e-02f, -1.33941829e-01f, 4.71442938e-02f, 9.06678066e-02f, 5.35310321e-02f, 8.55539069e-02f, -1.04798906e-01f, -9.25054997e-02f, 5.83811942e-03f,
  -1.40250055e-03f, -4.38765809e-02f, 1.18919335e-01f, 9.30497199e-02f, -3.79482210e-02f, -1.27202228e-01f, 7.12024346e-02f, 2.60256439e-01f, 5.34209944e-02f, -4.35117893e-02f,
  1.59317497e-02f, 6.09105490e-02f, 7.07534924e-02f, 2.42317785e-02f, -1.78578556e-01f, 2.15842035e-02f, -1.11636452e-01f, -4.76357667e-03f, 8.57403502e-02f, 8.90248567e-02f,
  1.38091981e-01f, -2.67233074e-01f, -3.85651551e-02f, -7.95311034e-02f, -9.84257236e-02f, -1.47349954e-01f, -7.86672384e-02f, 8.92441496e-02f, 2.13993430e-01f, -9.28126425e-02f,
  2.49530096e-02f, 1.16683394e-01f, 8.58060941e-02f, 2.95100006e-04f, 5.20918146e-02f, 6.07106723e-02f, 1.31821528e-01f, 1.08716369e-01f, 1.22896649e-01f, -3.55601236e-02f,
  9.66072977e-02f, 1.45457536e-01f, -9.46633797e-03f, -1.27304345e-01f, -7.56135955e-02f, -1.58679217e-01f, -2.17749849e-01f, 2.05807239e-01f, 4.44224030e-02f, 7.65631497e-02f,
  -8.46778527e-02f, -1.20774508e-01f, -8.52032751e-02f, 5.29405326e-02f, -3.08189262e-02f, 9.72469151e-02f, -2.12301537e-02f, 1.23789802e-01f, -6.22259416e-02f, -1.82987414e-02f,
  -7.35004395e-02f, -6.48191106e-03f, 3.57816182e-02f, -3.49698253e-02f, -2.65415926e-02f, -3.93065391e-03f, 1.31906837e-01f, 6.61457181e-02f, -1.05267633e-02f, -1.28795937e-01f,
  1.32074326e-01f, 1.19196177e-01f, 6.92110211e-02f, 8.85749310e-02f, -2.27675050e-01f, -5.18002957e-02f, -6.79838583e-02f, 9.21212211e-02f, -1.84948087e-01f, 9.57103912e-03f,
  1.43977404e-01f, -9.72492322e-02f, 8.24568868e-02f, -1.26537398e-01f, -1.27351563e-02f, 4.24170718e-02f, 1.19660599e-02f, 5.42008951e-02f, -1.77109629e-01f, -7.67419487e-02f,
  -1.45232409e-01f, -1.11441210e-01f, 2.97993928e-01f, -5.48679940e-02f, 7.74719194e-02f, -2.74427310e-02f, -6.53562555e-03f, -1.13507062e-02f, 3.61538492e-02f, -1.19433776e-01f,
  8.08795393e-02f, 1.31528899e-01f, -1.68022905e-02f, -1.31930793e-02f, -1.24274433e-01f, 4.70700301e-03f, 6.97087795e-02f, 9.70849320e-02f, -1.06787672e-02f, -5.30171320e-02f,
  1.81799829e-01f, 7.91428164e-02f, 3.35248858e-02f, -4.47680540e-02f, 3.63603801e-01f, -8.60532969e-02f, 9.25904289e-02f, 2.64863018e-02f, -3.01284976e-02f, -5.92646375e-02f,
  -5.04810177e-03f, -2.01287583e-01f, -5.60611626e-03f, 6.99416082e-03f, 7.52663463e-02f, 1.93120912e-01f, -7.18236193e-02f, 1.05049148e-01f, -6.98665623e-03f, 1.55150607e-01f,
  -1.17172174e-01f, -9.73494053e-02f, -8.19635242e-02f, 1.14344150e-01f, 2.39741169e-02f, -1.42387375e-01f, -1.44598335e-01f, -7.30155781e-02f, -2.24065199e-03f, 5.95751666e-02f,
  -4.52402867e-02f, -2.17206553e-01f, 2.03529969e-02f, -7.55722821e-02f, -9.67807621e-02f, 4.20182608e-02f, -9.35909972e-02f, -5.07376045e-02f, -2.83787586e-02f, 1.27699301e-01f,
  -9.85469744e-02f, -1.44124730e-02f, 1.11194290e-01f, 1.66082397e-01f, -1.08359076e-01f, 7.56490007e-02f, -2.00322941e-01f, -3.20222625e-03f, 2.24658605e-02f, -1.05639562e-01f,
  -9.87149104e-02f, 2.19278876e-02f, 4.99244556e-02f, 7.37067312e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -2.13498762e-03f, 8.35150927e-02f, 9.39068273e-02f, 2.71179285e-02f, -9.34467390e-02f, 1.33074239e-01f, 3.49175297e-02f, -1.45864189e-01f, 1.09345324e-01f, 1.84228644e-01f,
  6.20806217e-02f, -1.82090253e-01f, 1.58445742e-02f, 3.29958946e-01f, 1.72016084e-01f, -9.38223079e-02f, 3.10969651e-01f, -7.40653425e-02f, 6.53798599e-03f, 7.18827322e-02f,
  3.95450033e-02f, 8.63317698e-02f, 9.64236036e-02f, -1.66890230e-02f, 1.04933687e-01f, 1.20038919e-01f, 7.87805095e-02f, 8.28616247e-02f, 9.21008140e-02f, 1.09828547e-01f,
  7.13939369e-02f, -6.55434951e-02f, 7.78556690e-02f, 1.74847066e-01f, -2.97719002e-01f, -1.03602387e-01f, 2.00990766e-01f, -1.47351041e-01f, -6.65350109e-02f, -1.22485518e-01f,
  -1.37129590e-01f, 8.00536349e-02f, 2.24451363e-01f, 3.95964123e-02f, -6.29086718e-02f, -9.70389917e-02f, -6.44395640e-03f, -1.51033849e-02f, 6.54326705e-03f, 3.82548608e-02f,
  5.04510477e-02f, -2.52930466e-02f, 1.45836294e-01f, 2.24667385e-01f, 1.35480940e-01f, -7.82217681e-02f, -3.46386805e-02f, 6.86447024e-02f, 6.57650828e-02f, 2.21364629e-02f,
  8.68673474e-02f, -1.12993307e-01f, 1.86639190e-01f, 3.74531776e-01f, -8.99497941e-02f, 5.65165691e-02f, -1.26893178e-01f, -3.20701264e-02f, -1.31431520e-01f, -3.96387689e-02f,
  -7.51583874e-02f, 1.17893293e-01f, -6.11620508e-02f, 4.68117334e-02f, -5.24594933e-02f, -1.25409648e-01f, -8.47789571e-02f, -9.45970863e-02f, 8.29213634e-02f, -8.81971046e-02f,
  7.93205276e-02f, -8.35974813e-02f, 1.03790663e-01f, 7.22170472e-02f, 1.11288525e-01f, 7.40442351e-02f, -2.19023768e-02f, -5.07881632e-03f, -1.07444786e-01f, 6.48651645e-02f,
  -1.19267732e-01f, -1.25384731e-02f, 9.25447792e-02f, 1.19735099e-01f, -5.23284972e-02f, 1.16793953e-01f, -8.99653658e-02f, -6.27616346e-02f, -6.89463466e-02f, 2.68445797e-02f,
  -1.93357021e-02f, -6.64150715e-02f, 1.01093568e-01f, -6.00464568e-02f, 1.36789083e-01f, -1.15538612e-01f, 3.86884697e-02f, -1.42683391e-04f, 3.20324600e-02f, -3.40721011e-02f,
  7.37173706e-02f, -8.78307596e-03f, -1.57167241e-02f, 3.08494791e-02f, -7.82040432e-02f, 1.26282424e-01f, 1.08331479e-02f, 1.31053349e-03f, 8.21321160e-02f, -5.71792796e-02f,
  -1.04695298e-02f, 9.73279253e-02f, 7.80182928e-02f, -9.20551270e-02f, 1.27205193e-01f, -9.00589079e-02f, -8.21958780e-02f, 8.71961638e-02f, 2.01284617e-01f, 1.63507283e-01f,
  1.70578644e-01f, -3.85365225e-02f, 2.39270195e-01f, 1.17603339e-01f, -3.56111936e-02f, -2.31880054e-01f, 8.77534524e-02f, 1.02321267e-01f, -6.54361546e-02f, -1.90496087e-01f,
  -1.42988041e-01f, 7.45043308e-02f, -5.74794002e-02f, -1.31356776e-01f, 2.77807610e-03f, 4.45416011e-02f, 6.14227615e-02f, -1.44036743e-03f, 5.79659678e-02f, 2.09746197e-01f,
  2.56715603e-02f, -2.24936148e-03f, 3.25171724e-02f, 2.04567239e-01f, -5.15142009e-02f, 6.42259419e-02f, -1.08275525e-01f, 1.00111485e-01f, 1.49955586e-01f, 1.11719467e-01f,
  8.25853795e-02f, 8.14680308e-02f, 1.38262317e-01f, -1.75570995e-02f, 7.76884928e-02f, 6.94153756e-02f, -6.00693449e-02f, 9.72120911e-02f, 5.40030599e-02f, 1.71136141e-01f,
  -5.15573435e-02f, 6.46771118e-02f, -3.33828032e-02f, -7.58355707e-02f, -7.97823742e-02f, 7.05247745e-02f, 8.98986533e-02f, 3.00256163e-01f, 1.63292304e-01f, 1.98750459e-02f,
  -2.57168729e-02f, -1.30984515e-01f, 1.16175286e-01f, -1.54747427e-01f, -3.21330018e-02f, 1.34444684e-01f, -8.17585886e-02f, -1.62758119e-02f, 3.14530171e-03f, -1.12616509e-01f,
  2.72794086e-02f, 1.31651564e-02f, 1.34073809e-01f, 1.50250107e-01f, -4.51187603e-03f, 2.47496367e-02f, 1.76100671e-01f, 7.64303468e-03f, 6.21354021e-02f, 1.74324110e-01f,
  1.68652087e-01f, -1.73457474e-01f, 1.01490542e-01f, 2.61597894e-02f, -3.32447179e-02f, 4.71269228e-02f, -3.58073004e-02f, -1.14187822e-02f, 2.69225150e-01f, -9.62805822e-02f,
  1.38563573e-01f, 9.24460217e-02f, 3.30934371e-03f, -2.62635946e-02f, 1.72072481e-02f, 3.28156129e-02f, -1.20790534e-01f, -1.15036607e-01f, -7.51350075e-02f, 8.96796137e-02f,
  -1.52720794e-01f, -8.70671347e-02f, 1.51125789e-02f, -3.27281542e-02f, 5.17792478e-02f, -1.58198074e-01f, -1.19294323e-01f, 2.97481716e-01f, 2.44118050e-01f, -1.21310636e-01f,
  -1.44900698e-02f, -8.46904702e-03f, 7.05005750e-02f, -7.55116567e-02f, -2.05957294e-01f, 6.07175268e-02f, 8.92757252e-02f, 1.05059542e-01f, 4.22196947e-02f, 1.06327534e-01f,
  -5.01650721e-02f, -2.79424310e-01f, 2.83477724e-01f, -8.26688409e-02f, 1.26563698e-01f, 1.78995356e-01f, -4.55882587e-02f, 1.23501025e-01f, 1.68364376e-01f, 9.50025544e-02f,
  -9.30154324e-02f, -4.33866270e-02f, 1.19844899e-01f, -1.26393661e-01f, 2.87296642e-02f, 3.20287012e-02f, -5.86879142e-02f, 2.18868345e-01f, 2.14717686e-02f, 9.08955708e-02f,
  6.96690604e-02f, 8.88233073e-03f, 3.63136679e-02f, -1.29757170e-03f, 1.67842954e-02f, -1.63918763e-01f, 1.39030933e-01f, 1.52888149e-02f, 5.54141328e-02f, -9.54359584e-03f,
  2.28562087e-01f, -7.70560950e-02f, 1.63347512e-01f, -1.13980517e-01f, -4.25880663e-02f, -8.14170688e-02f, 1.23187706e-01f, -2.82833111e-02f, -9.35883075e-02f, 1.06505506e-01f,
  1.18873708e-01f, 1.51954755e-01f, 2.19851714e-02f, 7.03151058e-03f, 1.14968248e-01f, -2.40147393e-02f, -2.68548001e-02f, 2.58195121e-02f, 1.19115151e-01f, -8.58331621e-02f,
  -1.02782533e-01f, -1.42272636e-01f, -2.77402513e-02f, 4.35749367e-02f, -4.91192788e-02f, -4.62484136e-02f, 5.08140065e-02f, 6.66487089e-04f, 1.84878558e-01f, -4.40016091e-02f,
  1.36263296e-01f, -3.78031246e-02f, -8.98482576e-02f, 5.54063059e-02f, -5.41273952e-02f, -3.96358967e-02f, 3.31367068e-02f, 3.15637477e-02f, 1.04689814e-01f, -1.78725012e-02f,
  1.14370091e-02f, 1.04746014e-01f, 5.93586788e-02f, 1.23586005e-03f, 3.54114287e-02f, 7.54956603e-02f, -5.86911887e-02f, -6.16666721e-03f, 3.77909117e-03f, 2.71115899e-01f,
  1.48186117e-01f, 1.22200213e-01f, 1.46173999e-01f, 1.46320298e-01f, 1.41729966e-01f, 8.85765404e-02f, -1.02855384e-01f, -2.18210071e-01f, -2.28922084e-01f, 1.57492667e-01f,
  7.19372630e-02f, -2.09712815e-02f, -1.47993928e-02f, 2.66380936e-01f, 2.41958573e-01f, 3.19865905e-02f, -7.55227059e-02f, 1.57798886e-01f, -4.48350050e-03f, 1.99485928e-01f,
  -3.75835449e-02f, -1.26239806e-02f, 8.55920687e-02f, 7.40837976e-02f, 5.28803989e-02f, -3.44593376e-02f, 1.32435402e-02f, 4.94066253e-02f, 8.09352174e-02f, -1.24671275e-03f,
  -2.80893650e-02f, 8.86493847e-02f, 9.89834964e-02f, 9.20667574e-02f, 6.43075705e-02f, 5.42841628e-02f, -2.06693634e-01f, 1.80972695e-01f, -5.45263328e-02f, -8.77564698e-02f,
  1.50277140e-03f, 1.01169251e-01f, 3.40643898e-03f, -1.26848429e-01f, -6.26756847e-02f, -6.54261708e-02f, 1.22474143e-02f, -5.35997003e-02f, 9.19196531e-02f, 2.24508449e-01f,
  -8.91184360e-02f, -3.81029695e-02f, -1.82140395e-01f, -1.27558917e-01f, -4.80360277e-02f, 4.74327356e-02f, 1.29949808e-01f, -1.26359642e-01f, 1.02488235e-01f, 7.37569714e-03f,
  5.66998981e-02f, 6.75954595e-02f, 3.48092020e-02f, -1.85904339e-01f, 2.08470691e-02f, -9.76153929e-03f, 6.17582351e-02f, 1.26683116e-01f, 1.67119145e-01f, 1.46105051e-01f,
  -1.59748808e-01f, 6.72136545e-02f, -3.86161208e-02f, -5.82954809e-02f, 1.88010111e-01f, 2.10908845e-01f, 1.30007833e-01f, 1.00928552e-01f, 2.32704192e-01f, -9.23980176e-02f,
  2.26704568e-01f, -1.73687279e-01f, 1.43106982e-01f, 1.35609031e-01f, 8.76933932e-02f, 7.51405135e-02f, -5.18990234e-02f, 1.28111377e-01f, -9.71346647e-02f, 4.60755490e-02f,
  -3.18281613e-02f, 4.30892706e-02f, -5.56763597e-02f, -7.13310018e-02f, -9.30960923e-02f, -5.73350154e-02f, -8.05399008e-03f, -1.70814529e-01f, 5.15263826e-02f, -7.40023106e-02f,
  9.71201584e-02f, -8.27432126e-02f, -1.98137328e-01f, 5.23964427e-02f, 3.92236449e-02f, -9.68176723e-02f, -4.97506484e-02f, -2.53543630e-02f, -3.17288861e-02f, 1.10570133e-01f,
  2.63686553e-02f, -6.89498335e-02f, 4.68528047e-02f, -3.56953740e-02f, -4.94208410e-02f, 1.09411709e-01f, -3.55241820e-02f, -1.86750907e-02f, -7.57430047e-02f, 1.05690084e-01f,
  1.34463340e-01f, -8.86033997e-02f, 6.58162162e-02f, 5.18979654e-02f, 1.25049055e-01f, -1.38715342e-01f, 1.04469871e-02f, 1.87630922e-01f, 4.20601927e-02f, 1.68237388e-01f,
  -9.48850513e-02f, 5.54726496e-02f, -4.50052805e-02f, 4.54296693e-02f, 2.65423447e-01f, -2.77234018e-02f, -5.01208287e-03f, 1.02543004e-01f, 1.60477296e-01f, -9.99083072e-02f,
  8.92763585e-02f, -6.11437708e-02f, -1.12194180e-01f, -8.44616815e-02f, -3.83800715e-02f, -5.96370883e-02f, 1.04414321e-01f, -6.44477233e-02f, -8.28066468e-03f, 1.07423507e-01f,
  1.88437030e-02f, -2.52660811e-02f, 1.06266394e-01f, 8.85149166e-02f, -1.33073986e-01f, 8.10751878e-03f, -5.32025434e-02f, 2.02062633e-02f, 5.88214071e-03f, 9.44052190e-02f,
  -1.43444404e-01f, 3.46311092e-01f, -4.15816857e-03f, 4.81225736e-02f, 2.18248919e-01f, -1.00147173e-01f, 9.95215923e-02f, 1.03556886e-01f, -5.63418791e-02f, 1.94127947e-01f,
  2.62775123e-01f, 1.82410538e-01f, -3.17403674e-02f, -9.73140355e-03f, -9.56904739e-02f, 7.77630582e-02f, 1.76400423e-01f, 2.48355474e-02f, 1.29274368e-01f, -7.85078928e-02f,
  2.04337716e-01f, -1.47736713e-01f, 1.44303650e-01f, -9.98837054e-02f, 5.61094284e-03f, -2.25433484e-02f, 4.76779453e-02f, 1.01172440e-01f, -9.11459848e-02f, 9.40011665e-02f,
  4.42114957e-02f, 2.59208888e-01f, 1.27923191e-01f, 1.36956066e-01f, 5.51081263e-03f, -5.56461960e-02f, 1.83493376e-01f, 7.59804770e-02f, -7.22753108e-02f, -2.44713910e-02f,
  -1.28232479e-01f, 9.14234444e-02f, -8.61290321e-02f, -1.44125372e-01f, 9.52959806e-02f, 1.88089222e-01f, -1.09277807e-01f, -8.92378315e-02f, -8.74454435e-03f, 1.21721111e-01f,
  1.98629592e-02f, -1.16768964e-01f, 1.62743866e-01f, 2.12118834e-01f, -8.56951401e-02f, 3.15395114e-03f, 1.05504863e-01f, -1.08661065e-02f, 1.08160213e-01f, 3.20734903e-02f,
  5.72120398e-02f, 2.79013030e-02f, -6.03829548e-02f, -7.74291251e-03f, 7.38869086e-02f, -1.08280621e-01f, -1.06038354e-01f, -1.57418147e-01f, -6.16280623e-02f, 1.01916671e-01f,
  -1.14519224e-01f, -7.31205270e-02f, -1.50582558e-02f, 1.64490908e-01f, 3.81922559e-03f, 1.12012953e-01f, -1.52068093e-01f, -5.33287302e-02f, -1.01550691e-01f, -3.26669626e-02f,
  -3.25721428e-02f, 2.87121870e-02f, -5.79506867e-02f, -6.11323677e-02f, 1.19545780e-01f, -2.11297956e-04f, -3.31703611e-02f, -7.53605962e-02f, 8.72459039e-02f, -1.02935635e-01f,
  1.03749454e-01f, 7.98114613e-02f, 1.41038880e-01f, 7.80703425e-02f, 1.66191056e-01f, 2.01454222e-01f, -1.16827991e-02f, 8.69184881e-02f, 9.22142118e-02f, 6.90210387e-02f,
  -1.61542431e-01f, 9.85352322e-02f, 1.26640901e-01f, 1.65265165e-02f, -1.62846699e-01f, -7.55076706e-02f, -2.04438716e-02f, 9.75948572e-02f, 4.29169945e-02f, 1.87431619e-01f,
  3.30989808e-02f, -2.44240146e-02f, -1.07423984e-01f, 1.53322786e-01f, 2.90599428e-02f, 2.79498994e-01f, 1.12184420e-01f, 1.60897672e-01f, 5.81550859e-02f, -5.29820472e-02f,
  -1.13833724e-02f, 8.36014077e-02f, -9.21954811e-02f, -1.69932377e-02f, 2.28140667e-01f, 1.92011870e-03f, 4.23098262e-03f, -1.20744027e-01f, 1.08692229e-01f, -2.01704018e-02f,
  -2.48602599e-01f, -1.86395217e-02f, -9.25689414e-02f, 7.50934184e-02f, 8.60409811e-02f, 4.73640934e-02f, -4.75031026e-02f, -4.67932187e-02f, 2.11603090e-01f, -3.87523957e-02f,
  6.14009947e-02f, -6.86558187e-02f, 5.88545762e-03f, -5.34959994e-02f, 1.25681207e-01f, 3.54926176e-02f, -3.16637539e-04f, 4.54156324e-02f, 6.81021437e-02f, 1.64755240e-01f,
  -1.17123194e-01f, -6.28974959e-02f, 1.75931618e-01f, -9.89662111e-02f, 1.26633346e-01f, 5.53691797e-02f, 1.37884453e-01f, -1.40331239e-01f, 4.25612666e-02f, 2.13841975e-01f,
  1.12904243e-01f, 1.24939717e-01f, -6.64515346e-02f, -7.99980164e-02f, 1.33485958e-01f, 1.78880364e-01f, 9.49196965e-02f, -2.19728753e-01f, 1.36314332e-01f, 7.61245042e-02f,
  -2.12563217e-01f, 6.71108738e-02f, -8.22526962e-02f, 2.80125976e-01f, -1.87618509e-01f, -1.08886622e-01f, -8.32154900e-02f, 1.54975429e-01f, -2.49462966e-02f, 2.84275264e-01f,
  5.50643764e-02f, 3.12499702e-01f, 1.14584289e-01f, -5.13685010e-02f, 5.14353551e-02f, 3.85771878e-02f, 1.00142613e-01f, 2.13245731e-02f, 1.21407323e-01f, -8.25255513e-02f,
  1.98060811e-01f, 9.88036469e-02f, -2.96607055e-02f, 6.84707761e-02f, -3.61205079e-02f, 2.10000813e-01f, 2.15990096e-01f, -3.22651677e-02f, -1.37761340e-01f, 1.08480386e-01f,
  -1.18467085e-01f, 3.03150505e-01f, -1.53778404e-01f, -4.37389575e-02f, -6.87782615e-02f, 1.55429365e-02f, -1.97023712e-02f, 2.65792459e-02f, 1.15322769e-01f, -5.28491288e-02f,
  5.94910048e-03f, -1.35563854e-02f, 1.18956184e-02f, -6.92753643e-02f, 1.25169545e-01f, 4.31579351e-02f, 4.12554085e-01f, 6.46330640e-02f, -5.79249859e-02f, -8.73177573e-02f,
  2.23744810e-01f, 1.20014928e-01f, 3.01514212e-02f, -1.12387799e-01f, 4.22365889e-02f, -3.40149254e-02f, 1.21306837e-01f, 3.09490878e-03f, -3.30389328e-02f, -1.04414105e-01f,
  -1.05535336e-01f, 1.11173235e-01f, 1.12299725e-01f, 8.03804323e-02f, -8.47835187e-03f, 5.28970733e-02f, 5.19329421e-02f, -4.43105698e-02f, -9.46991295e-02f, 1.13781514e-02f,
  1.30864069e-01f, -4.34530079e-02f, 1.04659237e-02f, 4.85635884e-02f, 9.04314443e-02f, 1.71255264e-02f, 6.06359132e-02f, -4.00107205e-02f, -9.10681859e-02f, -6.97954595e-02f,
  -7.45004565e-02f, 1.01556502e-01f, 5.33004329e-02f, -1.89589560e-02f, -4.90874471e-03f, -6.66032638e-03f, -1.27859693e-02f, 1.12234525e-01f, 1.53468847e-01f, 1.42439693e-01f,
  1.07972838e-01f, -6.00488856e-02f, -1.04359113e-01f, 1.32550195e-01f, 9.32023600e-02f, -2.36998796e-02f, -1.21797688e-01f, 1.37303114e-01f, -5.75171486e-02f, -5.61477803e-02f,
  7.57905990e-02f, 4.38034609e-02f, -3.97558548e-02f, -6.53627813e-02f, -3.19875255e-02f, 9.97120962e-02f, 1.62288593e-03f, -1.98342279e-03f, -8.10789317e-02f, 1.08090565e-01f,
  9.74420011e-02f, -7.98679665e-02f, 7.98412189e-02f, 9.64282751e-02f, -5.37173934e-02f, -3.26369554e-02f, -2.82750316e-02f, -1.61602404e-02f, 7.35991746e-02f, -7.21730739e-02f,
  1.38264850e-01f, -8.88478309e-02f, -6.33993298e-02f, 6.96335584e-02f, 5.83802462e-02f, 1.82291381e-02f, -7.75166228e-02f, 7.21221045e-02f, 4.15441394e-02f, -6.60913140e-02f,
  1.09663643e-01f, 2.34904006e-01f, 2.20664918e-01f, -1.17675006e-01f, -4.84768450e-02f, 7.41054583e-03f, 6.54648244e-02f, -1.87394731e-02f, 1.29184648e-02f, 1.59751728e-01f,
  -5.05414139e-03f, 2.85204209e-04f, -9.90438536e-02f, 8.32316428e-02f, 1.10428885e-01f, 6.11845739e-02f, 2.46663745e-02f, 1.16397209e-01f, 1.40073985e-01f, 1.45000033e-02f,
  1.38819739e-01f, -2.00851053e-01f, 5.85023640e-03f, 5.76943643e-02f, -6.83171153e-02f, -3.63333076e-02f, -2.70539112e-02f, 6.82598427e-02f, -1.14313690e-02f, 1.90134458e-02f,
  -6.47674203e-02f, 8.77808109e-02f, -3.75090390e-02f, -1.90177560e-02f, 2.44354568e-02f, -6.69561923e-02f, -1.32286668e-01f, 2.26403266e-01f, -1.01781942e-01f, -9.51324999e-02f,
  -2.43863743e-02f, 1.35014877e-01f, 1.29924551e-01f, 1.16792642e-01f, -2.03974941e-03f, -3.18442732e-02f, 8.14319924e-02f, 7.39532635e-02f, 4.29237336e-02f, 3.16998288e-02f,
  3.60098109e-02f, 1.17848635e-01f, 3.24898399e-02f, -1.30697951e-01f, -3.03197298e-02f, -5.25901951e-02f, -3.46863307e-02f, -4.97696456e-03f, 8.53023455e-02f, 7.01649338e-02f,
  7.06240460e-02f, 3.87151577e-02f, -5.18283024e-02f, 1.85272396e-02f, 2.95342952e-02f, 9.68914405e-02f, -1.16784930e-01f, 1.10650018e-01f, 4.10618149e-02f, 2.72191614e-02f,
  1.77797601e-02f, 1.22141667e-01f, 7.03223422e-02f, 9.72484350e-02f, 1.16842529e-02f, 1.03379056e-01f, 1.24176629e-01f, -2.50048041e-02f, 8.19285884e-02f, 7.34602511e-02f,
  -1.14813671e-01f, -2.77483743e-02f, -7.11435527e-02f, 4.98250574e-02f, 6.90897554e-02f, -4.26827818e-02f, 4.48981160e-03f, 3.05355415e-02f, 1.34298965e-01f, -8.10577273e-02f,
  8.96096900e-02f, 7.17475638e-02f, 1.32621648e-02f, 4.71361866e-03f, -1.05783999e-01f, 7.89372325e-02f, -5.77900484e-02f, -6.96283132e-02f, 2.03578994e-02f, 1.38692558e-01f,
  -8.95770788e-02f, -2.52440246e-03f, 7.76868761e-02f, 6.55827746e-02f, 1.45086557e-01f, 1.02067962e-01f, -9.07736793e-02f, -8.37385356e-02f, 7.75408447e-02f, 9.24703553e-02f,
  6.13115653e-02f, -1.99011192e-02f, 6.46938384e-02f, 1.19014248e-01f, -6.82681277e-02f, 9.20897871e-02f, -7.53384382e-02f, -1.26421988e-01f, 8.93465579e-02f, -1.31330729e-01f,
  -1.28086939e-01f, 1.21217566e-02f, 2.60459390e-02f, -6.49988055e-02f, -9.02427509e-02f, -6.98978826e-02f, 2.57861316e-02f, -1.56644601e-02f, -4.99891043e-02f, -9.00418386e-02f,
  -1.04116626e-01f, -4.69933543e-03f, 2.23380588e-02f, -3.07681561e-02f, -2.56154500e-03f, -4.78947051e-02f, 1.10382009e-02f, -1.26291811e-01f, -1.84078794e-03f, -2.26874221e-02f,
  -8.18498060e-02f, -3.21508087e-02f, 3.69870737e-02f, -4.47782017e-02f, 6.53346777e-02f, -4.81297486e-02f, -3.67668271e-02f, 9.99255925e-02f, 3.01285498e-02f, -1.32680992e-02f,
  1.89454649e-02f, -5.04203439e-02f, 7.91832954e-02f, -2.32320116e-03f, -6.37587979e-02f, 9.83411372e-02f, -2.63729002e-02f, -1.31305220e-04f, -7.81380907e-02f, -5.48576601e-02f,
  -7.62980571e-03f, -6.48272485e-02f, -6.75409660e-02f, 7.11357668e-02f, 8.84986967e-02f, 2.04949919e-02f, -1.43485293e-02f, -8.44899490e-02f, 5.39675653e-02f, 8.50579590e-02f,
  -3.94961312e-02f, 8.11739936e-02f, -1.04497142e-01f, -1.17672563e-01f, -6.38070405e-02f, 6.08194880e-02f, 5.61008416e-02f, -3.37407142e-02f, -1.07075371e-01f, -2.57737003e-02f,
  1.27192035e-01f, 1.91233054e-01f, -3.31137404e-02f, 1.07826784e-01f, 1.84524328e-01f, 1.28852636e-01f, -2.10944214e-03f, 1.65124699e-01f, 2.53032386e-01f, 2.11745519e-02f,
  1.64221719e-01f, -1.57258436e-02f, -7.15669105e-03f, 1.49757087e-01f, -2.30196357e-01f, 1.12492442e-01f, 3.18579108e-01f, -6.47453368e-02f, -1.14521034e-01f, -1.61772728e-01f,
  1.25982299e-01f, 2.59359837e-01f, 1.08251750e-01f, -2.11895201e-02f, -6.91506267e-02f, 1.26842763e-02f, -3.27041969e-02f, 5.78561276e-02f, -5.92900664e-02f, -1.41452432e-01f,
  -8.98065493e-02f, 1.06183223e-01f, 1.72441695e-02f, -3.10215745e-02f, -1.40852571e-01f, 9.18232203e-02f, 2.61988938e-01f, -6.18280610e-03f, -1.44173339e-01f, 7.16350824e-02f,
  7.38407895e-02f, 8.28514844e-02f, -2.62725763e-02f, 1.46336630e-02f, 7.44504258e-02f, -1.31848797e-01f, -6.18400127e-02f, -9.71545056e-02f, 8.77196640e-02f, -9.78377089e-02f,
  2.50227123e-01f, -3.75394225e-02f, 1.43029138e-01f, -7.71977976e-02f, 6.00347202e-03f, -2.15256568e-02f, 5.30573577e-02f, 6.27435371e-02f, -1.47103220e-01f, 9.01962370e-02f,
  4.08759154e-02f, 7.46509880e-02f, 1.17438912e-01f, 3.21559459e-01f, 1.23666190e-01f, 1.12457238e-01f, 1.00571036e-01f, 1.05344467e-01f, 1.83496565e-01f, -1.31719382e-02f,
  1.26883864e-01f, -1.29049510e-01f, 5.19303456e-02f, -7.16582611e-02f, 9.43512097e-03f, -6.65665045e-02f, 1.29330039e-01f, -1.26305282e-01f, 1.48727864e-01f, -2.85301581e-02f,
  -1.10207468e-01f, 1.11254826e-01f, -7.27754682e-02f, -1.18441924e-01f, 9.68501642e-02f, -3.31610739e-02f, 2.60519125e-02f, -1.80037208e-02f, -6.30048569e-04f, 8.74635503e-02f,
  -8.95169005e-02f, -1.30317062e-01f, 1.11188227e-02f, 9.83637646e-02f, 5.79700731e-02f, 8.27364847e-02f, -1.43166319e-01f, 2.01682672e-01f, 2.64524341e-01f, -1.07163563e-01f,
  -1.30904555e-01f, 1.89835086e-01f, 1.25456542e-01f, -8.45822766e-02f, -1.34876162e-01f, -3.97966951e-02f, 1.32389411e-01f, -4.58978601e-02f, 5.01476116e-02f, 7.82955959e-02f,
  -4.18065898e-02f, 8.99441540e-02f, 2.48078909e-02f, 5.83653599e-02f, -1.48001164e-01f, 3.24847661e-02f, 6.14306889e-02f, 4.98661064e-02f, -1.38664814e-02f, -8.10206309e-02f,
  1.16023906e-01f, -1.22353852e-01f, 4.42207046e-02f, -1.16226515e-02f, -2.03823466e-02f, 3.93188186e-02f, -1.18903056e-01f, -3.26340608e-02f, 4.77204286e-02f, 7.27821216e-02f,
  7.96771944e-02f, -3.99011225e-02f, -9.77530479e-02f, -9.90832597e-02f, 7.90347159e-02f, -8.77255723e-02f, -2.78440844e-02f, -1.88645884e-01f, -3.99103649e-02f, 9.08071324e-02f,
  -1.29133146e-02f, 8.27678889e-02f, -7.98435062e-02f, 7.67569244e-02f, 2.24230327e-02f, 5.19209467e-02f, 4.81120683e-02f, 1.65940478e-01f, -3.03374622e-02f, -3.48374583e-02f,
  1.08981460e-01f, -1.22863268e-02f, 1.23740368e-01f, 1.51603416e-01f, -1.23140067e-01f, -2.54164524e-02f, 4.41297293e-02f, 8.87225568e-02f, -6.68025985e-02f, -1.41780660e-01f,
  2.88756974e-02f, 8.32474045e-03f, -4.84774932e-02f, 2.65083641e-01f, 9.35110003e-02f, -9.59782451e-02f, 2.58703902e-02f, -1.69192906e-02f, -7.63695501e-03f, -3.00768986e-02f,
  1.90149266e-02f, -4.31071259e-02f, 7.00052381e-02f, 1.67916641e-01f, 1.11420928e-02f, -3.42915654e-02f, 1.40263766e-01f, -1.31357446e-01f, 2.07310736e-01f, -5.12300469e-02f,
  4.24160101e-02f, 1.37577191e-01f, 1.12178512e-01f, 9.91117284e-02f, 1.00310892e-01f, -1.12059891e-01f, -8.16020668e-02f, -2.22803187e-02f, 2.22887501e-01f, -8.56639817e-02f,
  1.03439070e-01f, 1.07179821e-01f, 1.06875405e-01f, 5.08247912e-02f, 5.04959896e-02f, 1.29755318e-01f, 1.26277417e-01f, 1.69287603e-02f, 1.62740126e-01f, -1.54360160e-01f,
  -1.45992652e-01f, 3.32792103e-02f, -8.42337608e-02f, -1.59084439e-01f, 1.36232421e-01f, 8.13852623e-02f, -1.28083810e-01f, -8.92992318e-02f, -2.10628375e-01f, 2.02479661e-01f,
  5.50816320e-02f, 2.03025088e-01f, 3.95319685e-02f, 9.60363522e-02f, 1.54021299e-02f, 4.18386934e-03f, 1.72729567e-01f, 1.89019620e-01f, -3.72861549e-02f, 2.33073588e-02f,
  2.01273546e-01f, -1.05520487e-01f, -7.30881244e-02f, -4.35460657e-02f, -9.60812792e-02f, 1.79758474e-01f, 1.59460932e-01f, 1.31947890e-01f, -7.59191290e-02f, 1.29901737e-01f,
  -1.10218348e-02f, -4.06855531e-02f, 3.36862355e-02f, 1.59853369e-01f, 3.30566354e-02f, -4.65598777e-02f, -1.10301509e-01f, 1.08632803e-01f, 1.09956749e-01f, -1.13953024e-01f,
  -1.39804007e-02f, -1.08176796e-02f, 9.05354619e-02f, 9.24541652e-02f, -1.81103107e-02f, -6.31609112e-02f, 1.14199817e-01f, 1.12059087e-01f, 8.05105455e-03f, -2.00548675e-02f,
  -1.35785133e-01f, 2.43033357e-02f, 1.20158188e-01f, 1.13646403e-01f, 1.09292805e-01f, 1.06437162e-01f, 2.78525114e-01f, 1.27238229e-01f, 3.41369361e-01f, 2.42959365e-01f,
  2.67552376e-01f, -5.45944506e-03f, -2.81757087e-01f, 2.64906466e-01f, 4.84037250e-02f, -1.20630629e-01f, 1.09506384e-01f, 4.11480367e-01f, -3.02999746e-02f, -2.97772914e-01f,
  2.86818296e-01f, -7.68807232e-02f, 3.11846137e-01f, -1.09821245e-01f, 1.91322535e-01f, 2.68437237e-01f, 5.48354685e-02f, -2.78290242e-01f, 5.26527166e-02f, 1.23365805e-01f,
  -1.96810126e-01f, -1.83839619e-01f, -1.59068018e-01f, -1.06971100e-01f, 9.37514007e-02f, 1.05407678e-01f, 9.19139385e-02f, -1.40966862e-01f, -1.74199775e-01f, 7.64147863e-02f,
  3.05106103e-01f, 4.40433830e-01f, -1.67380840e-01f, 4.43927422e-02f, 2.15011075e-01f, 1.63330421e-01f, 9.88391712e-02f, -2.65811056e-01f, 2.30375957e-02f, 1.13855064e-01f,
  1.07702374e-01f, 4.92976636e-01f, 1.19099952e-01f, 1.18493132e-01f, -7.35262483e-02f, -2.01952994e-01f, -2.68494841e-02f, -1.44353151e-01f, -1.21814907e-01f, 2.83063333e-02f,
  -1.90752372e-01f, 3.97617109e-02f, 4.08652008e-01f, -8.39358419e-02f, 1.77331880e-01f, -3.94332707e-02f, 1.29915029e-01f, -1.16461311e-02f, -2.25621797e-02f, -2.09767446e-01f,
  1.71225369e-01f, 6.81800321e-02f, 2.79023677e-01f, 1.13567770e-01f, 1.72911271e-01f, 1.20538987e-01f, -1.42990276e-01f, -1.31416276e-01f, -3.84536274e-02f, -6.47640228e-02f,
  1.10132813e-01f, 1.66399866e-01f, 7.13461414e-02f, 3.48485857e-01f, 5.02755009e-02f, -1.27513468e-01f, 9.70802382e-02f, 7.00522214e-02f, 8.95209461e-02f, 1.31255344e-01f,
  6.44253716e-02f, 1.38626933e-01f, -1.03517979e-01f, 4.05905843e-02f, -3.57494093e-02f, -4.01707273e-03f, 7.66573623e-02f, -6.69767335e-02f, -8.01906884e-02f, 2.09983978e-02f,
  1.24188416e-01f, -1.22471340e-02f, 1.04290254e-01f, -2.53934145e-01f, -8.03202242e-02f, -1.74630865e-01f, -1.72614142e-01f, 1.61938995e-01f, -1.43436164e-01f, -8.71602893e-02f,
  -1.67384014e-01f, 5.11830114e-02f, 3.30274440e-02f, 2.10344493e-02f, -5.83139285e-02f, -1.55196954e-02f, 9.18332562e-02f, -1.05331585e-01f, 2.09521968e-02f, 2.56257236e-01f,
  -5.17941825e-02f, -1.11031756e-01f, -5.17606139e-02f, -4.59896997e-02f, 8.35653096e-02f, -5.62815480e-02f, 2.27180853e-01f, -7.57257342e-02f, 1.17420964e-01f, -6.31165737e-03f,
  1.59404188e-01f, 1.14373259e-01f, -4.68095504e-02f, 3.18396604e-03f, -5.75939007e-02f, 9.77899283e-02f, 3.88454273e-02f, 2.95666549e-02f, 8.28027651e-02f, -5.53071760e-02f,
  -7.44354799e-02f, 1.29968435e-01f, 6.59264773e-02f, -8.68839696e-02f, 8.90307724e-02f, 1.16792761e-01f, -8.30192864e-02f, 7.46335983e-02f, 2.02675015e-01f, -9.71868709e-02f,
  1.10892572e-01f, -1.24187998e-01f, -9.18477178e-02f, -3.38337081e-03f, 9.61460266e-03f, -4.05306071e-02f, -1.27720550e-01f, 1.06222868e-01f, -4.63871583e-02f, 4.22502384e-02f,
  5.31045981e-02f, -2.73250267e-02f, -4.24600095e-02f, 8.48838389e-02f, -1.07319646e-01f, 8.19135234e-02f, 4.83618081e-02f, -1.87338796e-02f, 1.15274809e-01f, -7.73968771e-02f,
  -7.58272707e-02f, -3.88014540e-02f, 7.32279196e-02f, 2.11968403e-02f, -1.46083152e-02f, -8.41426179e-02f, -5.30099384e-02f, 5.75913936e-02f, 1.82148870e-02f, 6.87479675e-02f,
  -8.33245292e-02f, -2.31692847e-02f, -6.65019229e-02f, -2.81494819e-02f, 1.09733678e-01f, -1.01830088e-01f, -2.78762672e-02f, 1.31372005e-01f, -1.14531979e-01f, -9.53564718e-02f,
  -8.49890709e-02f, -5.50576393e-03f, 5.92746213e-02f, -8.26091990e-02f, -1.72896066e-03f, 2.24289671e-02f, 5.49775101e-02f, 8.41610879e-02f, 8.33973959e-02f, 5.22779636e-02f,
  -1.62489107e-03f, 1.89981923e-01f, 7.14671090e-02f, 4.16860618e-02f, 4.20918204e-02f, -1.36255667e-01f, -1.42479673e-01f, -5.61008789e-02f, -4.17625830e-02f, -9.06228274e-02f,
  -1.15670383e-01f, 1.45663083e-01f, 1.25965127e-03f, -1.21253505e-01f, 3.81955914e-02f, -5.41888699e-02f, -6.61607683e-02f, 1.31598726e-01f, -1.96000952e-02f, -3.45767289e-02f,
  7.67365023e-02f, -1.33359894e-01f, 7.05257282e-02f, 7.35481977e-02f, 8.28254819e-02f, 8.30137283e-02f, -1.09924011e-01f, -2.73433905e-02f, 4.83019045e-03f, 1.00296699e-01f,
  5.95484152e-02f, -4.57598530e-02f, 3.36703248e-02f, 6.12024851e-02f, -6.30603433e-02f, 7.86369219e-02f, -1.28598988e-01f, 2.30164900e-02f, -3.07775382e-02f, 4.70412262e-02f,
  -6.25665486e-02f, 4.54809815e-02f, 4.04667184e-02f, -5.59029132e-02f, -1.10415004e-01f, -6.17798045e-02f, -3.06713432e-02f, 2.27639079e-01f, -3.66582796e-02f, -4.45390977e-02f,
  -5.23559451e-02f, 1.09140776e-01f, 7.19530359e-02f, -5.67766093e-02f, 6.07120208e-02f, -1.04050115e-01f, -4.50233556e-02f, -9.26970318e-02f, 2.15925127e-02f, -1.14725128e-01f,
  -6.31689876e-02f, -9.18945894e-02f, -5.75685240e-02f, 7.54253380e-03f, 9.53610241e-02f, -1.18209114e-02f, 7.45156780e-03f, -5.57869039e-02f, 1.01488568e-01f, -8.57727900e-02f,
  4.08922136e-02f, 2.03410946e-02f, -7.92596042e-02f, 1.09323539e-01f, -6.07088506e-02f, -5.68706430e-02f, -1.09134749e-01f, 2.80756727e-02f, -1.07669264e-01f, -1.74223464e-02f,
  -6.66731829e-03f, 1.00372262e-01f, -9.02562812e-02f, 1.91165835e-01f, 1.47973314e-01f, 4.82029878e-02f, 5.64878918e-02f, 4.34115296e-03f, -1.24706559e-01f, 9.46720615e-02f,
  -6.15629926e-02f, -4.59688641e-02f, 2.99527850e-02f, -6.73767477e-02f, 8.52357820e-02f, 8.31846986e-03f, 8.43187943e-02f, 2.13499755e-01f, 1.33106157e-01f, -1.08500183e-01f,
  -1.65278483e-02f, -6.22789040e-02f, -6.51240125e-02f, 1.27416998e-01f, -6.26705140e-02f, 6.64258823e-02f, -4.50049527e-02f, 1.54150203e-01f, 5.26768491e-02f, 7.30220079e-02f,
  1.45577192e-01f, -1.05803832e-01f, 2.01984823e-01f, -4.02614363e-02f, -1.81176365e-04f, -1.51671737e-01f, 8.52521434e-02f, 1.21573970e-01f, 2.07153812e-01f, 3.68856080e-02f,
  -1.02024801e-01f, -1.10913120e-01f, -1.00868037e-02f, -5.00020385e-02f, 4.73518558e-02f, -1.21498585e-01f, 1.11505076e-01f, -6.08214363e-02f, -3.83338220e-02f, -1.70571990e-02f,
  -1.32842049e-01f, 1.27809867e-01f, -1.05574980e-01f, 1.50448516e-01f, 4.71574850e-02f, 1.29483819e-01f, 2.04307631e-01f, -7.67802028e-03f, 9.03551746e-03f, 4.40874845e-02f,
  2.46331021e-02f, 2.44360045e-02f, 3.27226937e-01f, 2.31510326e-02f, 4.28645164e-02f, 3.10159591e-03f, 1.95357352e-02f, 9.48288664e-02f, -9.96669084e-02f, 1.08166993e-01f,
  -3.73101309e-02f, -1.81314647e-02f, 4.83553223e-02f, 6.33759946e-02f, -1.94160670e-01f, 9.87846553e-02f, -1.04040347e-01f, 6.50331527e-02f, 1.52852938e-01f, -2.93025915e-02f,
  -1.40559137e-01f, 1.10229775e-02f, 2.79420689e-02f, 8.02221298e-02f, 3.75374556e-02f, 5.15607931e-02f, 1.01239443e-01f, 4.14035544e-02f, -2.88789030e-02f, -5.39183989e-02f,
  8.49881917e-02f, -2.98087811e-03f, -1.23222567e-01f, 1.22232676e-01f, -5.95207838e-03f, 9.75028127e-02f, -5.17222695e-02f, -1.16302967e-01f, 1.95004061e-01f, 9.66927856e-02f,
  7.11636320e-02f, -3.84112448e-02f, -2.82861829e-01f, 3.18583548e-02f, -6.11396767e-02f, 5.22252880e-02f, 6.28279671e-02f, 2.43389085e-02f, -6.40009865e-02f, 2.50635117e-01f,
  2.04989731e-01f, 1.08326741e-01f, 1.53889194e-01f, 4.03065011e-02f, 2.32106328e-01f, 8.44042227e-02f, -3.99670415e-02f, 2.06035867e-01f, 1.25965886e-02f, -9.43381190e-02f,
  -9.12352130e-02f, 2.72708923e-01f, 1.10620201e-01f, -5.26504517e-02f, 2.68591523e-01f, 1.15197577e-01f, 6.16840832e-02f, 9.35238004e-02f, 1.33571953e-01f, 2.27323279e-01f,
  -4.17039543e-02f, -1.97652727e-01f, -1.11956440e-01f, 6.29201308e-02f, -1.93394169e-01f, -1.26407310e-01f, 4.12469134e-02f, 3.77633758e-02f, -4.99357432e-02f, -8.10420420e-03f,
  -2.09871456e-02f, -6.13288730e-02f, -9.72941145e-03f, 4.48907353e-02f, 3.05118471e-01f, 2.24355310e-01f, -4.84989844e-02f, -3.62647027e-02f, 1.34204119e-01f, 2.41383463e-02f,
  3.21877562e-02f, -2.77741868e-02f, 7.66249895e-02f, -1.01062462e-01f, -5.78066893e-02f, 3.55172396e-01f, 1.38592765e-01f, -1.87323950e-02f, -1.06091917e-01f, -6.87787831e-02f,
  6.48727119e-02f, -2.51855813e-02f, 2.70025861e-02f, -6.90656379e-02f, 7.55067319e-02f, -3.61888520e-02f, 1.94953710e-01f, 1.77905415e-04f, 6.54959008e-02f, 7.39064142e-02f,
  3.66973095e-02f, 1.32338122e-01f, -1.01772323e-01f, -2.06692651e-01f, -1.24517985e-01f, -9.63572226e-03f, 2.72562839e-02f, -6.64226338e-02f, -5.68435080e-02f, 9.87771992e-03f,
  -6.28576502e-02f, 2.87882593e-02f, 1.00693181e-01f, -3.06025036e-02f, -1.25939503e-01f, 2.46963240e-02f, -7.25896936e-03f, 4.13979925e-02f, 1.25759828e-03f, -7.58630559e-02f,
  1.39695361e-01f, 7.01372996e-02f, -2.85195317e-02f, -4.61608963e-03f, 1.01336755e-01f, 2.83998884e-02f, 1.46613503e-02f, -4.12131175e-02f, 1.14883885e-01f, -1.03518227e-03f,
  1.16055258e-01f, 3.89031768e-02f, -2.60695424e-02f, 3.75398584e-02f, 8.58165622e-02f, -6.24124967e-02f, 5.43269627e-02f, -2.74611488e-02f, -9.29927155e-02f, -3.15273739e-02f,
  5.04969573e-03f, -1.36199713e-01f, -6.73333090e-03f, 1.07391011e-02f, 9.11862105e-02f, 6.01854511e-02f, -1.18625052e-01f, 2.62320600e-02f, -7.01408135e-03f, 7.38348365e-02f,
  7.50722885e-02f, 1.16307609e-01f, 1.31882876e-01f, -5.02769230e-03f, 1.05049059e-01f, 9.22620371e-02f, 1.27034143e-01f, 1.50634974e-01f, -6.70211986e-02f, 6.96414709e-02f,
  -7.21864849e-02f, 1.24899618e-01f, -7.61870444e-02f, 1.11419618e-01f, 8.57296884e-02f, -6.47757053e-02f, -2.86234785e-02f, 1.48340583e-01f, 9.09890980e-02f, -2.31736511e-01f,
  -1.39578164e-01f, 1.42469078e-01f, -5.28582111e-02f, -1.65599540e-01f, -8.49236026e-02f, 7.25002810e-02f, 1.04304910e-01f, 1.94211021e-01f, 1.14427218e-02f, 3.66864204e-02f,
  1.37664452e-01f, 5.84193431e-02f, 2.53989488e-01f, 1.78567208e-02f, 2.66778946e-01f, -1.12205498e-01f, -9.46618542e-02f, 3.34361158e-02f, 3.85276005e-02f, -1.70559645e-01f,
  8.70355815e-02f, 8.72377530e-02f, 6.28555790e-02f, -1.58903345e-01f, -1.08109318e-01f, 4.68726037e-03f, 3.40060815e-02f, 2.12553572e-02f, 5.02707101e-02f, -2.22331448e-03f,
  -7.61582330e-02f, 1.14977382e-01f, 5.67353889e-02f, -7.57208169e-02f, -7.44566917e-02f, 5.96495420e-02f, 2.47001722e-01f, -1.69099085e-02f, 8.81027728e-02f, -1.54392257e-01f,
  -1.99229661e-02f, 1.02951474e-01f, -4.09586504e-02f, 2.19972223e-01f, 7.54216388e-02f, -1.55080371e-02f, -1.99648179e-02f, -2.49496736e-02f, -1.11976422e-01f, 3.35070677e-02f,
  1.22868620e-01f, -7.23303482e-02f, 1.54852401e-02f, 1.08905420e-01f, -9.03844163e-02f, -3.43757570e-02f, 1.28149390e-02f, 5.88798895e-02f, 1.48401320e-01f, 1.16350353e-01f,
  -9.29172188e-02f, 8.70908499e-02f, -6.16608448e-02f, -7.45300055e-02f, -9.00522172e-02f, -3.67828980e-02f, 3.82218398e-02f, 7.70029947e-02f, 1.84001960e-02f, 8.30786452e-02f,
  6.71967492e-02f, -8.35055709e-02f, -1.13384806e-01f, 6.27739504e-02f, 8.27385560e-02f, 7.83562958e-02f, 1.26742408e-01f, -5.82682118e-02f, -6.27814233e-02f, 6.28186017e-02f,
  -5.41215576e-02f, 1.32617846e-01f, -1.13919750e-01f, 5.92965893e-02f, 7.00874627e-02f, 7.96061158e-02f, 6.91395327e-02f, -4.84019518e-03f, -2.49397010e-03f, 4.75548133e-02f,
  -3.03207133e-02f, 9.31229219e-02f, -1.02289133e-01f, 1.06118090e-01f, 6.63450956e-02f, 3.97120193e-02f, 5.08520892e-03f, -1.66888740e-02f, 8.97175074e-03f, -1.09459653e-01f,
  3.45340706e-02f, 1.06898040e-01f, 4.86430265e-02f, 4.85213697e-02f, -6.00350574e-02f, -6.97239786e-02f, -3.19972895e-02f, -7.80643523e-02f, -5.38698323e-02f, -4.87158298e-02f,
  -9.81338546e-02f, -2.83547956e-03f, 9.57165882e-02f, -2.66322885e-02f, 1.30581334e-01f, 1.01292118e-01f, 6.91614598e-02f, -7.82039464e-02f, 8.08665995e-03f, 9.61177424e-02f,
  -1.08018853e-01f, 9.37200934e-02f, -1.59210898e-02f, 6.05098568e-02f, 1.29612312e-01f, -2.68920213e-02f, 5.74915111e-02f, 1.14849374e-01f, -5.23126759e-02f, 2.38875207e-02f,
  -7.44684860e-02f, -5.91173768e-02f, -5.59506156e-02f, -8.34092572e-02f, -1.00195982e-01f, -1.88313741e-02f, -4.10918146e-02f, -3.86196971e-02f, 4.33694161e-02f, 1.19215399e-01f,
  7.66375959e-02f, -6.08939156e-02f, 2.23593097e-02f, -4.25207578e-02f, 7.88393468e-02f, 1.34142399e-01f, -6.82368577e-02f, 7.04364106e-02f, -4.16973867e-02f, -1.05934381e-01f,
  3.01535539e-02f, 6.98011369e-02f, -1.75916161e-02f, -6.59457892e-02f, 1.05137326e-01f, -2.75092833e-02f, -8.67493916e-03f, 8.14870074e-02f, 1.53821055e-02f, 1.15389796e-02f,
  -7.30307996e-02f, 4.44261916e-03f, 6.68302760e-04f, 1.10102504e-01f, -7.23556206e-02f, -1.18705466e-01f, 2.21182778e-02f, -9.12801623e-02f, -1.25170395e-01f, -6.41412288e-02f,
  2.54684296e-02f, 6.73599243e-02f, -3.05224396e-02f, 1.05372585e-01f, -2.46280134e-02f, 5.52468710e-02f, -5.06063402e-02f, -1.75042581e-02f, -1.11592248e-01f, 5.38386442e-02f,
  1.19894639e-01f, 5.08973412e-02f, -5.31642549e-02f, 1.28246506e-03f, 1.27436593e-01f, -5.86291142e-02f, 9.35998708e-02f, 3.31075899e-02f, -2.51725819e-02f, -3.81162949e-03f,
  -5.15541919e-02f, -7.30994940e-02f, 1.71916008e-01f, 5.53084351e-02f, 1.33967817e-01f, 2.51571853e-02f, -7.15725124e-02f, 8.22639540e-02f, 7.73740634e-02f, -1.46217421e-01f,
  1.40442327e-02f, 8.23301896e-02f, 4.11844254e-02f, -1.75393093e-02f, 1.16333395e-01f, -1.72691140e-02f, -3.73405963e-02f, -3.43002775e-03f, 9.71024707e-02f, 2.45871827e-01f,
  3.08619440e-02f, -8.65318850e-02f, -1.00364096e-01f, 1.16640195e-01f, -1.35251656e-01f, -2.82250568e-02f, 5.05001210e-02f, 7.40885884e-02f, 1.41475394e-01f, 1.00207485e-01f,
  2.98095215e-02f, -9.86162722e-02f, -3.67165171e-02f, -3.47870700e-02f, 5.12981750e-02f, 2.75999814e-01f, 8.33179709e-03f, 7.36478493e-02f, 1.25484377e-01f, 1.32356524e-01f,
  1.34003118e-01f, 1.11790530e-01f, 4.59105223e-02f, 4.59049568e-02f, 5.34032332e-03f, 2.51413167e-01f, -2.58971043e-02f, -1.30304202e-01f, 2.50794627e-02f, -1.60838068e-01f,
  7.60411322e-02f, -8.08196738e-02f, -7.96099454e-02f, 7.83604756e-02f, -5.22405133e-02f, 1.87397465e-01f, 2.11673468e-01f, -9.14821774e-02f, -6.28443807e-02f, 2.44865566e-02f,
  1.48061588e-01f, 1.45513013e-01f, 6.37905970e-02f, -3.43150273e-02f, -4.88971919e-02f, -3.90159525e-02f, 7.49831647e-02f, 1.16093248e-01f, -2.24443257e-01f, -9.00062080e-03f,
  -3.81762870e-02f, 1.94321603e-01f, -6.11382835e-02f, 3.22803967e-02f, 1.82298720e-01f, 1.23879105e-01f, 1.36897758e-01f, 1.82475317e-02f, 2.26366162e-01f, 3.82881728e-03f,
  3.77035618e-01f, 3.35441753e-02f, 8.89335424e-02f, -6.51290044e-02f, 6.44517839e-02f, 5.27213849e-02f, -3.48213478e-03f, 6.20861761e-02f, 2.01207753e-02f, -1.54625103e-01f,
  -6.58099726e-02f, -8.38313028e-02f, 7.88484886e-02f, 2.42192391e-02f, -3.50288756e-04f, -1.86716825e-01f, 4.28632796e-02f, -5.02895862e-02f, -6.90310746e-02f, 1.14018813e-01f,
  -1.23549588e-01f, -2.20483188e-02f, 1.08469151e-01f, 4.48974892e-02f, -8.55907612e-03f, -1.64801374e-01f, 2.04507828e-01f, -2.64978819e-02f, 1.20865606e-01f, 1.22486353e-01f,
  1.26169980e-01f, -2.82894578e-02f, 2.53649857e-02f, -6.42341655e-03f, -4.16777097e-02f, 3.15042064e-02f, 1.73077025e-02f, 5.99040911e-02f, 8.69884118e-02f, -5.49938343e-02f,
  -3.91635112e-02f, 7.04309866e-02f, -3.76135111e-02f, -2.88924109e-02f, 1.38265595e-01f, -7.58961067e-02f, -5.98164350e-02f, 2.61379272e-01f, 2.17684075e-01f, 1.71413407e-01f,
  -2.21185833e-02f, 3.99110131e-02f, 1.48261651e-01f, 1.30154505e-01f, -5.90810813e-02f, -7.11184889e-02f, -6.90757483e-02f, 6.50172904e-02f, -1.74049959e-01f, 8.76984149e-02f,
  -1.12431526e-01f, 9.27179959e-03f, -4.43758294e-02f, 7.82714561e-02f, 1.51148066e-01f, -3.34362090e-02f, -4.80093509e-02f, 1.64621010e-01f, 3.98539752e-02f, 4.35452722e-02f,
  6.85894936e-02f, 9.46737602e-02f, 1.14431167e-02f, -5.43550402e-02f, -6.27788156e-02f, 9.86934006e-02f, -4.00421098e-02f, 9.39548910e-02f, -4.09314744e-02f, 1.32389992e-01f,
  -1.17627926e-01f, -4.85963933e-02f, 9.85871777e-02f, 2.23527819e-01f, 9.89448205e-02f, -6.99557289e-02f, -1.68880612e-01f, 6.51347488e-02f, -5.00098206e-02f, 8.24690759e-02f,
  -6.78122491e-02f, -8.36977437e-02f, -5.35693616e-02f, -9.72394347e-02f, -7.75321648e-02f, -8.10114220e-02f, -1.02060519e-01f, -5.54729030e-02f, 5.90771921e-02f, -1.31319603e-02f,
  -2.41955854e-02f, 1.20830923e-01f, 9.73743945e-02f, -4.28016111e-02f, 1.27480984e-01f, 1.03514358e-01f, -7.46841207e-02f, -9.71165113e-03f, 4.20089252e-02f, -1.08629890e-01f,
  1.24735981e-01f, -4.53785211e-02f, 7.00174645e-02f, 1.90748572e-01f, 2.21118838e-01f, 7.39504173e-02f, 1.65028870e-02f, 5.11813127e-02f, -2.08787788e-02f, -1.34764090e-01f,
  -2.99431346e-02f, 9.77880135e-02f, -1.47622913e-01f, -5.93239591e-02f, -5.22324853e-02f, -4.00118120e-02f, 1.02702484e-01f, 7.20541254e-02f, -1.91414058e-01f, 1.87842876e-01f,
  -9.79251564e-02f, 2.01948836e-01f, -9.53891948e-02f, 6.95463791e-02f, -5.15337624e-02f, -3.11694369e-02f, 9.67767015e-02f, -4.11584228e-02f, -6.97498694e-02f, 1.14988228e-02f,
  -3.54617946e-02f, -8.07575360e-02f, -6.51394278e-02f, 4.28326577e-02f, -3.55512835e-02f, 2.33491406e-01f, -8.87865946e-02f, -1.05673522e-01f, 1.15312897e-01f, 6.71530366e-02f,
  2.63331622e-01f, -1.47973925e-01f, 1.16865663e-02f, 5.44768460e-02f, 1.09543391e-01f, 1.36778489e-01f, -1.19073078e-01f, -7.75859430e-02f, 1.20732211e-01f, -3.11711896e-03f,
  7.77570009e-02f, 2.31976256e-01f, -1.02563679e-01f, -1.26309350e-01f, 4.25785892e-02f, -6.98081478e-02f, 6.70800731e-02f, -1.59018338e-01f, -8.24384242e-02f, -1.60174649e-02f,
  8.07837471e-02f, -6.06584623e-02f, 1.08979158e-01f, 2.68704724e-02f, 5.25735877e-02f, 1.52061701e-01f, 1.49607763e-03f, -1.54593915e-01f, 1.67002212e-02f, -3.78643465e-03f,
  -2.10405923e-02f, -2.88367085e-02f, 9.17803794e-02f, 8.98458660e-02f, -5.84153645e-03f, -7.42763132e-02f, 3.57064158e-02f, 1.01759396e-01f, 1.59011468e-01f, 8.85367095e-02f,
  1.87482480e-02f, 1.09480470e-01f, 7.53703788e-02f, 1.13226429e-01f, 1.35964617e-01f, 1.85706168e-01f, -5.94549589e-02f, -1.29628479e-01f, -7.22422674e-02f, 1.21583976e-01f,
  -9.52401310e-02f, -3.85198444e-02f, 4.49223183e-02f, 8.06380138e-02f, -3.79040139e-03f, 2.69248299e-02f, 6.46276176e-02f, -4.72143032e-02f, 9.12466720e-02f, 1.91314772e-01f,
  1.71627209e-01f, 1.04876406e-01f, 9.08936486e-02f, -6.31793514e-02f, 1.81759626e-01f, -3.58228087e-02f, 6.64113238e-02f, 6.25307932e-02f, 2.26932708e-02f, 1.72794033e-02f,
  -8.27986002e-03f, 1.62385538e-01f, 9.22085419e-02f, 7.53966570e-02f, 1.40847161e-01f, -1.37957767e-01f, 7.96726570e-02f, -1.22784927e-01f, 1.57631755e-01f, 1.04492359e-01f,
  -1.30307861e-02f, -2.23139450e-02f, -1.38963910e-03f, 1.10606968e-01f, 2.47387476e-02f, -9.16376263e-02f, 1.59654543e-02f, 3.49676050e-02f, -1.29821464e-01f, -3.07301432e-02f,
  2.11577527e-02f, 2.75433242e-01f, 1.49139136e-01f, 2.11843878e-01f, 2.95285811e-03f, 2.71301627e-01f, -5.30630872e-02f, -1.37645364e-01f, -1.73977807e-01f, 1.64206222e-01f,
  2.24085808e-01f, -5.62712885e-02f, -4.52501848e-02f, -1.14835508e-01f, 2.18887448e-01f, -4.70972769e-02f, -1.51684992e-02f, 1.28203616e-01f, 3.59172910e-03f, -1.51801437e-01f,
  -2.06051990e-01f, -8.79586339e-02f, 8.02484006e-02f, -8.04288406e-03f, -1.50642812e-01f, 2.37559989e-01f, 7.02237859e-02f, -1.01344690e-01f, -5.90569973e-02f, 1.06288388e-01f,
  7.57832751e-02f, 1.71195239e-01f, -3.66591662e-02f, 1.23735480e-01f, 3.25051174e-02f, -1.42070696e-01f, 2.28925003e-03f, 3.36096995e-02f, 2.08808139e-01f, -2.90142745e-03f,
  -1.22142158e-01f, -1.77713744e-02f, 3.23270977e-01f, 1.05318151e-01f, -1.37368694e-01f, 1.02381587e-01f, 1.59895532e-02f, 2.55240146e-02f, -2.27961456e-03f, 4.43362981e-01f,
  -1.45628080e-01f, -1.17519028e-01f, -5.42659238e-02f, -1.35776922e-01f, -4.08847928e-02f, -1.19209617e-01f, -4.47739996e-02f, 2.23921966e-02f, 2.67204233e-02f, -1.82674155e-02f,
  -2.13138759e-01f, 8.48950073e-02f, -5.24753220e-02f, 1.68917794e-02f, -5.15453778e-02f, 1.37616470e-01f, -1.00838847e-01f, 1.02316894e-01f, 1.17437564e-01f, -8.84572044e-02f,
  2.98129655e-02f, -4.61042151e-02f, -1.89288072e-02f, 2.73145502e-03f, -1.17164731e-01f, -3.46650835e-03f, 5.20850457e-02f, -2.13098824e-02f, -4.10191864e-02f, -3.01968004e-03f,
  -4.37083542e-02f, -4.47706692e-02f, -2.75256652e-02f, 1.32759929e-01f, -4.74977791e-02f, 5.09069785e-02f, 8.60328153e-02f, -7.53678987e-03f, 1.20692343e-01f, 2.25760881e-02f,
  2.38467101e-02f, 1.03062473e-01f, 5.78282750e-04f, -4.75193746e-02f, 2.64045186e-02f, 5.13462722e-02f, 1.38014490e-02f, -5.45326248e-02f, -3.21282148e-02f, -5.71717061e-02f,
  3.99491712e-02f, 1.34574667e-01f, -9.14984867e-02f, 6.59683049e-02f, -9.70267579e-02f, 1.42173797e-01f, 2.85760835e-02f, -1.04937971e-01f, 2.80970912e-02f, 5.57381883e-02f,
  9.84716415e-02f, 7.52515811e-03f, -6.66161999e-03f, -1.06042720e-01f, -9.08546448e-02f, -9.82134342e-02f, 7.00996742e-02f, -9.50276181e-02f, -3.27153020e-02f, 3.57549712e-02f,
  -1.05272494e-01f, -5.77264130e-02f, -1.12202771e-01f, 1.08328335e-01f, -9.48025808e-02f, 8.86058286e-02f, 4.78825569e-02f, -2.70430520e-02f, -3.08240764e-02f, -1.09857336e-01f,
  5.04656637e-04f, 4.65320274e-02f, -6.20297790e-02f, -1.13911889e-01f, -8.51049572e-02f, 1.28094986e-01f, 6.71223700e-02f, -7.52203688e-02f, -6.28204718e-02f, -1.16366260e-02f,
  8.03451166e-02f, 5.45929894e-02f, 8.50844309e-02f, 9.59109962e-02f, -4.34519723e-02f, 2.12579686e-03f, 2.86939368e-02f, -1.17515415e-01f, 8.58056694e-02f, 1.33457482e-01f,
  1.45420870e-02f, 1.46549223e-02f, -5.91593012e-02f, 9.97057632e-02f, -3.29225138e-02f, 1.04869772e-02f, -1.79873570e-03f, -1.18204594e-01f, 1.06214002e-01f, 7.14638382e-02f,
  -4.97014113e-02f, -1.43531309e-02f, -1.47299785e-02f, -1.35687470e-01f, -1.96336638e-02f, -4.94376123e-02f, -1.01690903e-01f, -1.13398461e-02f, 2.21452881e-02f, 2.72723641e-02f,
  -2.73924340e-02f, -2.51488723e-02f, -9.39911306e-02f, 7.17733577e-02f, -1.00310162e-01f, 5.76094538e-02f, -1.23576961e-01f, 3.04591414e-02f, 8.04413110e-02f, 7.11376369e-02f,
  -5.78262694e-02f, 6.01455122e-02f, -5.52569283e-03f, 2.76670288e-02f, -4.17331457e-02f, -6.58087954e-02f, 4.39929552e-02f, -1.09624648e-02f, 1.18141994e-01f, 1.97148789e-02f,
  -7.63245225e-02f, 1.48783311e-01f, 3.65631245e-02f, 1.44077808e-01f, 2.00498939e-01f, 1.95817873e-01f, 6.34896010e-02f, 2.31051758e-01f, -6.37705550e-02f, -7.48854280e-02f,
  6.16931356e-02f, 2.32500121e-01f, -1.09798484e-01f, -1.69531144e-02f, -2.59221252e-02f, 9.92562100e-02f, 9.07225236e-02f, -2.75590867e-02f, -1.98320404e-01f, 1.35727569e-01f,
  -1.32467389e-01f, 1.27406726e-02f, -1.53837696e-01f, -1.54009297e-01f, 4.90287691e-02f, 7.96218887e-02f, -2.92602535e-02f, 8.16220120e-02f, 1.12544440e-01f, 7.49895200e-02f,
  3.50561887e-02f, 9.81489345e-02f, 1.48420017e-02f, 3.68492529e-02f, 6.43148199e-02f, 3.14485461e-01f, 1.76580310e-01f, -1.08264662e-01f, -7.46140024e-03f, 9.61870770e-04f,
  6.63629472e-02f, -7.25737810e-02f, -1.02884345e-01f, -1.33588254e-01f, 1.15862206e-01f, -1.32348463e-01f, -7.47744888e-02f, 7.87292887e-03f, -1.20461039e-01f, 5.74291274e-02f,
  -1.09948203e-01f, 1.86259389e-01f, -1.23055317e-01f, -1.06311798e-01f, -1.74273048e-02f, 3.05800773e-02f, -1.12135813e-01f, -1.88610125e-02f, -1.61935225e-01f, -1.30319014e-01f,
  7.42604136e-02f, -7.97876120e-02f, 4.30916995e-02f, 7.53494427e-02f, -1.33735463e-01f, -7.52016827e-02f, -7.47875720e-02f, -7.17231259e-02f, 5.61282523e-02f, 1.34711802e-01f,
  -1.16327666e-02f, 3.21342871e-02f, -4.91074622e-02f, -4.61188480e-02f, 1.45727307e-01f, -9.12294239e-02f, 9.88627598e-02f, -7.85089880e-02f, 1.17572747e-01f, 5.49429618e-02f,
  -1.27815798e-01f, -4.68089171e-02f, 7.48528242e-02f, -3.54315005e-02f, 6.54373169e-02f, 4.15935367e-02f, -1.18771061e-01f, 2.42519248e-02f, 1.01346299e-01f, -1.01731174e-01f,
  1.31891463e-02f, -2.60002129e-02f, 8.87335539e-02f, -1.22070871e-02f, -1.14695825e-01f, 4.50551063e-02f, -3.88657264e-02f, 3.11095323e-02f, 8.04230273e-02f, -1.12117303e-03f,
  -1.07148699e-01f, 3.65934558e-02f, 4.66875769e-02f, -2.93818433e-02f, 1.51606826e-02f, 9.42673832e-02f, 1.17498659e-01f, -1.27161983e-02f, -5.93489930e-02f, 1.29572585e-01f,
  -3.40861157e-02f, -1.15770698e-01f, 2.03521419e-02f, -1.90420710e-02f, -1.34099005e-02f, -7.51535296e-02f, -4.49367873e-02f, 6.91326186e-02f, -8.14401284e-02f, 2.92759240e-02f,
  -4.11431901e-02f, -6.65425584e-02f, -2.10082512e-02f, 3.30798253e-02f, -5.78508228e-02f, 6.29768819e-02f, -4.64819930e-02f, 8.41422677e-02f, 6.01803400e-02f, -3.49332504e-02f,
  1.41908512e-01f, -2.57466584e-02f, -6.95599914e-02f, 1.34944916e-01f, -5.43795861e-02f, 1.66319370e-01f, 2.21776962e-01f, -2.32145220e-01f, -1.88049972e-01f, 9.50812623e-02f,
  2.91394055e-01f, 2.30930150e-02f, -2.82186475e-02f, -5.00696599e-02f, 3.94442350e-01f, 4.51167449e-02f, -1.86353818e-01f, 8.40774775e-02f, 9.66617092e-02f, -5.14418855e-02f,
  2.12496463e-02f, 9.77645367e-02f, 1.92912757e-01f, 1.36200771e-01f, 9.92618725e-02f, 3.48673344e-01f, 6.93987161e-02f, 9.30683911e-02f, 2.09762767e-01f, -1.62541568e-02f,
  1.13327861e-01f, -4.93273735e-02f, 3.76621038e-02f, 4.40837711e-01f, -5.50748073e-02f, -2.02697948e-01f, -1.11861631e-01f, -4.95533012e-02f, 2.83015400e-01f, -1.69621930e-01f,
  -1.04017220e-01f, -2.82498617e-02f, 3.80290091e-01f, 8.31931233e-02f, -1.16104759e-01f, 1.53505579e-01f, 3.49161611e-03f, -1.29576266e-01f, 1.21761829e-01f, 3.86501878e-01f,
  -9.27599221e-02f, 8.28950405e-02f, 4.18695323e-02f, -1.30785722e-02f, -9.70666707e-02f, -8.72207507e-02f, -1.33626044e-01f, -4.81358916e-02f, -4.66058627e-02f, -2.08439548e-02f,
  -1.13825820e-01f, 7.32039511e-02f, 1.35366559e-01f, -4.51431014e-02f, 1.13735281e-01f, 5.79091236e-02f, 1.15647977e-02f, -4.43002805e-02f, 1.16008066e-01f, -6.83510974e-02f,
  -7.78085515e-02f, 5.43057099e-02f, 1.86208971e-02f, 1.62063420e-01f, 1.23675279e-01f, -7.06245974e-02f, -6.04037708e-03f, 2.15558782e-01f, -8.05813447e-02f, 6.53333887e-02f,
  3.07625026e-01f, -3.79011445e-02f, 2.69780401e-02f, -7.64420033e-02f, -1.03202268e-01f, 2.31604606e-01f, 7.08630085e-02f, -1.14967979e-01f, 2.38567386e-02f, 1.78924426e-02f,
  4.43390850e-03f, 6.97533339e-02f, -1.00638084e-01f, 8.77536684e-02f, -3.54194604e-02f, -8.60073641e-02f, 2.37520169e-02f, -7.90420026e-02f, -1.72167882e-01f, -4.96252254e-02f,
  3.11593246e-02f, -1.34944037e-01f, 1.22688949e-01f, -4.28838991e-02f, 4.87177260e-02f, 8.50218460e-02f, 1.32128432e-01f, 5.48762716e-02f, -1.12830764e-02f, 4.05067317e-02f,
  9.18610543e-02f, -9.89030972e-02f, -9.12325010e-02f, 6.35329932e-02f, 5.15906699e-02f, 9.39298347e-02f, 1.91967145e-01f, -6.78863972e-02f, 1.59838930e-01f, 3.46695408e-02f,
  -1.98294476e-01f, -1.21680973e-02f, -1.33194387e-01f, -1.04610629e-01f, -1.76878483e-03f, -1.07749529e-01f, -8.49538967e-02f, 3.03611070e-01f, 7.67697915e-02f, 1.04367226e-01f,
  9.79458988e-02f, 1.60066456e-01f, 1.33922443e-01f, 1.91590577e-01f, 1.07554570e-01f, 1.00252822e-01f, 1.55336156e-01f, 1.36103839e-01f, 2.87025236e-02f, -7.28000700e-02f,
  -9.00667086e-02f, 9.10430476e-02f, -3.97234000e-02f, 5.51236570e-02f, -3.67121212e-02f, -2.82674581e-02f, -4.31067601e-04f, -1.66632049e-02f, -1.52637526e-01f, -1.74961872e-02f,
  -7.31325075e-02f, 7.48784980e-03f, -6.61877245e-02f, -4.96033207e-02f, -7.33713582e-02f, -9.48578343e-02f, -1.22527555e-01f, 4.47185114e-02f, 1.62330940e-02f, 1.42801896e-01f,
  2.69970503e-02f, 1.25165120e-01f, -7.84383491e-02f, 8.16768035e-02f, 1.45759910e-01f, 1.00871645e-01f, 3.26200202e-02f, -8.19879845e-02f, 1.77324906e-01f, 2.52229482e-01f,
  1.35767274e-02f, 8.96994770e-02f, 8.95341262e-02f, 1.18575037e-01f, -7.85245523e-02f, 7.74862915e-02f, 1.03712175e-03f, -1.36115616e-02f, -8.68549347e-02f, 6.80814683e-02f,
  1.29605308e-01f, -1.93967912e-02f, 1.06751174e-01f, -1.06458940e-01f, -4.38368432e-02f, -1.27181122e-02f, -3.50467339e-02f, 7.93841332e-02f, 3.09883319e-02f, -6.41585588e-02f,
  -2.70895511e-02f, -6.29753619e-02f, 8.29364508e-02f, 1.75515860e-01f, 9.68426168e-02f, -5.35215698e-02f, -2.84546218e-03f, 1.95008531e-01f, -1.93171836e-02f, 9.05857310e-02f,
  -1.06325187e-01f, -3.45306918e-02f, 9.87178683e-02f, -9.99043882e-02f, 9.26088467e-02f, 2.67557085e-01f, 2.94890422e-02f, 6.86676428e-02f, 2.30926976e-01f, -1.35576800e-01f,
  -3.54605056e-02f, -5.98578341e-03f, 2.27873847e-01f, 1.80545509e-01f, -5.12192510e-02f, 1.85996722e-02f, 4.07233499e-02f, 1.85574248e-01f, -4.47140187e-02f, 9.84223783e-02f,
  1.50804603e-02f, 8.23778138e-02f, 1.57956108e-02f, 5.68884388e-02f, 5.25029656e-03f, -1.18403144e-01f, -1.92629054e-01f, -6.61424845e-02f, 1.84257805e-01f, -1.23479016e-01f,
  -1.79940268e-01f, -5.44160008e-02f, -1.50187179e-01f, 1.18538707e-01f, 9.42098126e-02f, -2.34871451e-02f, 6.24597110e-02f, -9.94055271e-02f, -1.37454653e-02f, 3.80203351e-02f,
  -6.20062910e-02f, -5.80962040e-02f, 2.20018327e-01f, -3.26281376e-02f, -8.06299038e-03f, 2.07980812e-01f, 2.13398617e-02f, -1.39860824e-01f, 1.15904100e-01f, 5.62680289e-02f,
  4.65341732e-02f, -3.72356251e-02f, 1.25760049e-01f, -1.36132076e-01f, 1.26829162e-01f, 2.37870693e-01f, -3.57727073e-02f, -4.12104987e-02f, 4.21390049e-02f, 2.17987671e-01f,
  -5.69061451e-02f, 1.73352048e-01f, -1.40951768e-01f, 1.55181184e-01f, -6.52958006e-02f, 7.32288733e-02f, 2.19382457e-02f, 7.01830834e-02f, -3.75507586e-02f, 2.46835634e-01f,
  3.23396921e-01f, -1.14903726e-01f, 2.93284476e-01f, 5.34772947e-02f, -1.57886982e-01f, 1.81450561e-01f, 1.34230658e-01f, 7.41247386e-02f, -1.14723541e-01f, -2.52664257e-02f,
  8.71008411e-02f, 9.96563863e-03f, 7.01652989e-02f, -1.03373125e-01f, -1.35330006e-01f, -8.33062530e-02f, -6.40432024e-03f, 4.79639582e-02f, 1.10428654e-01f, 6.45378698e-03f,
  -1.62932307e-01f, -1.85959697e-01f, 6.08610474e-02f, 4.47214246e-02f, -1.18456304e-01f, -1.01491272e-01f, -1.07130297e-01f, 5.18108942e-02f, 3.36476676e-02f, -1.07778423e-01f,
  1.43600434e-01f, 6.83499798e-02f, -1.08887091e-01f, 1.35701165e-01f, -1.56676695e-01f, -8.25999081e-02f, 1.05349440e-03f, -1.34867415e-01f, 1.34293482e-01f, 2.22480223e-01f,
  7.91923776e-02f, -5.64592406e-02f, -2.88448147e-02f, 8.08200240e-02f, 2.39890441e-02f, 2.09992211e-02f, 5.22528104e-02f, -4.94269133e-02f, 1.84420645e-01f, 3.17962915e-01f,
  -6.83510005e-02f, 4.12283801e-02f, -2.44646538e-02f, 1.29641816e-01f, -1.35232508e-01f, -5.97465932e-02f, 1.03007481e-01f, -6.21156581e-03f, 1.51594400e-01f, 1.64753363e-01f,
  1.11208722e-01f, -5.03894985e-02f, 1.30536463e-02f, 1.63423449e-01f, 5.67259379e-02f, 1.36300949e-02f, 1.97168633e-01f, 1.13803474e-02f, -1.37335226e-01f, 1.22950509e-01f,
  7.50865564e-02f, -2.94234585e-02f, -5.63085601e-02f, 4.48369980e-03f, 1.11494355e-01f, 4.11317945e-02f, -1.30909801e-01f, -1.12760581e-01f, -5.71094751e-02f, -4.32272181e-02f,
  9.37467143e-02f, -8.01082030e-02f, 1.32366046e-01f, 1.66687388e-02f, -9.34877619e-02f, 7.19163790e-02f, 1.73069701e-01f, -4.45200130e-02f, 9.77159590e-02f, -5.21954447e-02f,
  1.58587977e-01f, 1.36418968e-01f, 8.97530541e-02f, 5.33805303e-02f, -1.20199695e-02f, -1.12638555e-01f, 4.48326068e-03f, 5.03375754e-02f, 1.14428408e-01f, -7.10487440e-02f,
  8.15826356e-02f, 1.76297370e-02f, 1.75416648e-01f, 6.53039068e-02f, -1.20635061e-02f, 2.79154722e-02f, -1.17778905e-01f, -6.56327605e-02f, -5.96865453e-03f, 1.28379211e-01f,
  1.58438072e-01f, 9.23967063e-02f, -9.86595079e-02f, 2.74014592e-01f, 4.78676632e-02f, 2.09977821e-01f, 1.10582933e-01f, 4.32088636e-02f, 7.67741576e-02f, 3.66094112e-02f,
  6.37879819e-02f, -7.12466165e-02f, -7.38487393e-02f, 1.17560651e-03f, -6.09112717e-03f, 1.28807360e-02f, -1.71118148e-03f, -1.77250989e-02f, 1.55838370e-01f, -3.25732343e-02f,
  -6.41781613e-02f, -1.04826011e-01f, -5.51278368e-02f, 9.91979912e-02f, 8.39274898e-02f, -7.55684152e-02f, 5.71048111e-02f, -1.16895422e-01f, 7.94827342e-02f, 3.23082842e-02f,
  1.24866962e-01f, -7.09913447e-02f, -6.93169534e-02f, -6.06798455e-02f, -4.28864919e-02f, -5.21456338e-02f, -8.55857730e-02f, -6.92778751e-02f, 1.82967633e-01f, 7.68646747e-02f,
  -6.23645298e-02f, 1.51147038e-01f, 1.50483921e-02f, -1.35951757e-01f, 7.00510368e-02f, 4.83839884e-02f, 5.95460348e-02f, -1.18610129e-01f, 1.16560413e-02f, 3.46099734e-02f,
  -7.23991916e-02f, -9.79868975e-03f, -2.77372245e-02f, 7.77617544e-02f, 2.30925363e-02f, -1.38463527e-01f, -7.79049769e-02f, 5.27162254e-02f, -5.87908402e-02f, -8.81716143e-03f,
  -6.68043410e-03f, -8.54942873e-02f, 1.35771409e-01f, 9.13123488e-02f, -9.69017223e-02f, -4.66230102e-02f, -9.56083164e-02f, -1.00364514e-01f, -1.03563126e-02f, -6.24474175e-02f,
  1.26571640e-01f, -7.99237117e-02f, -2.34526277e-01f, -4.57018167e-02f, 1.45327672e-01f, -2.14747638e-02f, -2.84732524e-02f, -5.69342412e-02f, 1.11461170e-02f, -7.19575807e-02f,
  5.82365505e-02f, 1.52487919e-01f, 1.66494578e-01f, -6.83933794e-02f, 6.33614138e-02f, 5.82322553e-02f, -9.44397822e-02f, 2.04705492e-01f, 1.01341054e-01f, -6.01589084e-02f,
  -1.38825327e-02f, 1.71142578e-01f, 1.89209849e-01f, 1.78152740e-01f, 2.56904517e-03f, 1.92066617e-02f, 1.92885682e-01f, 1.11465357e-01f, 1.32955343e-01f, -3.90542708e-02f,
  1.13226801e-01f, 5.01309223e-02f, -1.00875266e-01f, -8.43738988e-02f, -6.38117567e-02f, -1.10526152e-01f, 2.08845749e-01f, -7.83944279e-02f, -1.56187743e-01f, -1.27145737e-01f,
  2.07668528e-01f, 1.33475557e-01f, -2.95981262e-02f, -8.27530101e-02f, 9.67771783e-02f, -1.02261908e-01f, -1.05579376e-01f, 8.02343488e-02f, 7.27450103e-02f, 1.24055613e-02f,
  1.41072795e-01f, 1.50480002e-01f, 3.09711937e-02f, 1.06040969e-01f, 3.63815241e-02f, -4.85464558e-02f, 5.35598882e-02f, -3.93334357e-03f, -2.55505890e-02f, 5.00149131e-02f,
  1.52267337e-01f, 2.73887396e-01f, 9.40797627e-02f, 1.73702642e-01f, -2.92725302e-03f, 4.27254327e-02f, 2.45078608e-01f, 1.41663149e-01f, -7.08150193e-02f, 3.41241956e-02f,
  -1.96359172e-01f, 9.98106152e-02f, 1.65631771e-01f, 7.80835971e-02f, 9.89773050e-02f, 4.17540083e-03f, 3.34725738e-01f, 2.50056814e-02f, 6.69555217e-02f, 1.76515523e-02f,
  1.32138478e-02f, -1.85561657e-01f, 3.93008851e-02f, -6.02999479e-02f, 1.25605330e-01f, 4.06652652e-02f, -1.30292580e-01f, 2.09885195e-01f, 1.26664313e-02f, 7.51938820e-02f,
  -5.67324236e-02f, -4.07796726e-02f, -7.75549188e-02f, -1.04127452e-01f, 1.25363737e-01f, -3.43769304e-02f, 1.28528491e-01f, -5.55954203e-02f, -3.76504920e-02f, -5.88922128e-02f,
  1.17308594e-01f, -6.21352121e-02f, -1.92903157e-03f, 3.81368957e-02f, 4.34406735e-02f, -4.25987169e-02f, -6.15075156e-02f, 1.67459086e-01f, 2.32402310e-02f, -1.16118550e-01f,
  -2.97737159e-02f, 2.28322014e-01f, -7.80517422e-03f, -5.43561690e-02f, -1.56843320e-01f, -8.86840597e-02f, -1.15871124e-01f, 1.34530753e-01f, -2.65000891e-02f, -1.50089641e-03f,
  7.98589140e-02f, 1.77312922e-02f, 5.03351167e-02f, -1.35486692e-01f, 1.80560648e-02f, 6.41334653e-02f, -9.72966775e-02f, -6.15731068e-03f, 9.26271155e-02f, -4.10490744e-02f,
  -8.83626342e-02f, -1.01018079e-01f, -1.09822243e-01f, -6.71308786e-02f, 1.22777395e-01f, -6.96204277e-03f, 1.14565723e-01f, -5.66786714e-02f, -9.41352919e-02f, 9.63472724e-02f,
  -2.66310815e-02f, 3.73456925e-02f, -6.54043779e-02f, -1.04598857e-01f, -7.23186657e-02f, -9.06258374e-02f, -6.28525168e-02f, -7.07675591e-02f, 1.20480366e-01f, 1.23118281e-01f,
  5.52007332e-02f, -8.84842649e-02f, -9.12214965e-02f, -3.20542306e-02f, -4.25596572e-02f, 9.66529623e-02f, 9.42470580e-02f, 6.74423501e-02f, -1.18248105e-01f, -1.03678636e-01f,
  -9.48859304e-02f, 3.27897146e-02f, -1.51398387e-02f, -7.00170323e-02f, -9.25196931e-02f, 9.39602405e-02f, 9.44536403e-02f, -6.30850345e-02f, -4.81204204e-02f, -5.94017468e-02f,
  1.24709317e-02f, -3.00861476e-03f, 1.13655224e-01f, 1.11557521e-01f, -7.04637617e-02f, 1.73805542e-02f, -8.58407989e-02f, -1.18960515e-01f, -8.41236040e-02f, -8.20791572e-02f,
  -7.51621127e-02f, 9.48355272e-02f, 2.67002732e-02f, 5.16645759e-02f, -1.21241041e-01f, -1.46756405e-02f, -6.80594370e-02f, -9.41427872e-02f, 7.33020753e-02f, 4.56304178e-02f,
  -9.17836130e-02f, -1.66471452e-02f, 8.56257603e-02f, -5.78173772e-02f, -1.00053735e-01f, -3.47745419e-02f, -1.11485876e-01f, -7.22177252e-02f, 6.75368309e-02f, -2.85501475e-03f,
  -1.03641279e-01f, -1.93489157e-02f, -1.00049451e-01f, -1.09305844e-01f, -1.33848742e-01f, -1.19928308e-01f, 9.82881412e-02f, 5.28344186e-03f, -9.53399166e-02f, 7.20684752e-02f,
  9.09713879e-02f, -5.64538650e-02f, -4.40891460e-02f, 8.53011161e-02f, 2.45690551e-02f, 1.16775461e-01f, -8.17305222e-02f, -1.10784650e-01f, -9.39974785e-02f, -6.95885941e-02f,
  -7.88931549e-02f, 4.21108707e-04f, 6.54644938e-03f, -8.02424476e-02f, -3.27421576e-02f, 1.33431613e-01f, -1.95498597e-02f, -5.10622673e-02f, 8.75765160e-02f, -4.49003167e-02f,
  -3.76392491e-02f, 3.00903860e-02f, -3.16506512e-02f, 1.28523350e-01f, -1.11452140e-01f, -6.06847741e-02f, -1.05833095e-02f, 1.51095781e-02f, -5.23418980e-03f, -3.89374569e-02f,
  -1.30788703e-02f, 1.10722795e-01f, -1.05027832e-01f, -2.32083853e-02f, -7.84230903e-02f, -3.74527462e-02f, 1.22586504e-01f, -4.80236039e-02f, 1.15328804e-01f, 7.60849565e-02f,
  -1.45465340e-02f, 8.01181197e-02f, 6.14844337e-02f, -1.77227799e-02f, 5.19417003e-02f, 8.97717923e-02f, 1.75560221e-01f, 2.15531543e-01f, 1.88759398e-02f, 1.43714249e-01f,
  -2.13077486e-01f, 8.25553462e-02f, -3.44546586e-02f, 6.20025508e-02f, 6.69787358e-03f, 1.07986189e-01f, 8.40479210e-02f, 1.03709675e-01f, 1.43479630e-01f, 7.77004147e-03f,
  7.33554512e-02f, 1.02809764e-01f, -1.13467515e-01f, 2.94556785e-02f, -1.52150184e-01f, -2.14865003e-02f, 1.70095060e-02f, 7.17755929e-02f, -1.38436064e-01f, 4.49676588e-02f,
  -1.11329397e-02f, 2.88294200e-02f, 2.28995457e-02f, 9.40474793e-02f, 1.09390385e-01f, 1.42696306e-01f, -7.35789957e-03f, 2.13774424e-02f, 7.98866525e-02f, 8.91905352e-02f,
  -1.73776655e-03f, 3.07102278e-02f, 2.21666813e-01f, -1.25483930e-01f, -5.49102910e-02f, -1.14155367e-01f, 9.85061005e-02f, -7.53816441e-02f, -1.03072852e-01f, -2.09023748e-02f,
  -3.92998233e-02f, -1.05044022e-01f, 8.56712461e-02f, 1.36814952e-01f, -1.88283727e-01f, -4.07994352e-02f, 8.71364027e-02f, -5.50422061e-04f, 1.57663524e-02f, -9.89665389e-02f,
  -7.48645067e-02f, 4.85655181e-02f, -4.82616387e-03f, -7.70072779e-03f, -1.05912730e-01f, -6.04744628e-02f, 1.14957795e-01f, -8.16468000e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  8.81713852e-02f, 2.03508101e-02f, 1.47568420e-01f, 1.17058516e-01f, 1.11384061e-03f, 1.57325417e-02f, 5.34553975e-02f, -2.52504218e-02f, 1.43977955e-01f, -1.09495357e-01f,
  1.82065889e-01f, -8.00891668e-02f, -7.24247796e-03f, 7.23748803e-02f, -6.74471166e-03f, 6.92767128e-02f, 1.29464656e-01f, 7.77962506e-02f, -6.22931402e-04f, 2.67261118e-01f,
  2.07334429e-01f, -3.13213654e-02f, 1.78311571e-01f, 1.60639938e-02f, 1.64595291e-01f, 5.32613397e-02f, 1.04074106e-01f, -7.01491013e-02f, -1.09454952e-02f, -6.37672767e-02f,
  -2.88766138e-02f, 5.38239330e-02f, 1.14267312e-01f, 1.54627427e-01f, -4.08362858e-02f, 2.16557696e-01f, -1.96542237e-02f, -7.31661022e-02f, 2.01646999e-01f, 6.28245324e-02f,
  -2.52357367e-02f, 8.25094059e-02f, 1.03176944e-01f, 1.61796823e-01f, 3.86133678e-02f, -5.66975102e-02f, -1.98206468e-03f, 6.21505342e-02f, 2.94720158e-02f, -1.19115993e-01f,
  -7.76465386e-02f, 1.65515780e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  7.82167539e-02f, -7.29533434e-02f, -3.49907398e-01f, -7.07902536e-02f, 1.18618011e-01f, 6.10087290e-02f, 4.25597690e-02f, -7.32354075e-02f, 2.92631656e-01f, 1.79019555e-01f,
  5.96677214e-02f, 3.80227226e-03f, -4.89333540e-01f, 1.08988486e-01f, -2.86052674e-01f, 1.79222047e-01f, -1.70149431e-01f, 5.25407679e-02f, 8.10953826e-02f, -2.83175915e-01f,
  -7.36963451e-02f, -9.89108086e-02f, -2.82777578e-01f, 1.04618348e-01f, 2.14833375e-02f, -1.22734584e-01f, -3.62445936e-02f, -3.09656173e-01f, -7.74642229e-02f, 1.84097320e-01f,
  5.11106290e-02f, 6.63069367e-01f, -1.15254357e-01f, 7.99051300e-02f, -3.71114798e-02f, 1.05358422e-01f, -7.86671340e-02f, 4.66363668e-01f, 4.54173377e-03f, 2.96910018e-01f,
  -1.44542065e-02f, -3.39224413e-02f, 3.59539211e-01f, 1.72264442e-01f, -1.27274469e-02f, -2.17053205e-01f, 2.18823016e-01f, -2.52999306e-01f, -7.31996670e-02f, -7.91565478e-02f,
  -9.11723301e-02f, -2.36207526e-02f, -3.16384822e-01f, -4.91665266e-02f, -1.69258863e-01f, -3.78232449e-01f, -3.69379222e-01f, -9.48383734e-02f, 4.03393395e-02f, -1.46452606e-01f,
  1.23271585e-01f, 6.56189620e-02f, -6.20965362e-02f, -4.58142459e-02f, -9.05400887e-02f, -5.19594848e-02f, 2.16067247e-02f, -2.27357578e-02f, -2.92190135e-01f, -1.43890679e-01f,
  -4.91201818e-01f, -1.14737585e-01f, 1.01230666e-01f, 2.84064054e-01f, 3.75032127e-01f, -3.83035451e-01f, -2.91546077e-01f, -1.14898980e-01f, 9.32525396e-02f, 3.92980874e-01f,
  -1.30895630e-01f, -2.28065878e-01f, -1.84300523e-02f, 1.24422096e-01f, -1.89926952e-01f, -7.62925297e-02f, 5.29985964e-01f, 1.10759094e-01f, -1.13980979e-01f, 7.89438114e-02f,
  7.63358027e-02f, 1.49703801e-01f, -2.65702438e-02f, 2.98441619e-01f, -9.87874269e-02f, 4.29975510e-01f, 3.51758972e-02f, -1.66680321e-01f, -1.09836176e-01f, 3.48109156e-01f,
  -2.75059640e-01f, 1.83621004e-01f, 2.65407730e-02f, -2.59641290e-01f, -3.37091237e-02f, -4.76775914e-02f, 2.64466554e-01f, -1.82577625e-01f, 1.49528861e-01f, -2.57266939e-01f,
  9.95703042e-02f, -2.15242535e-01f, -1.07389420e-01f, -4.53993045e-02f, -2.19082281e-01f, -6.76339865e-02f, -2.09221765e-01f, -2.72714317e-01f, 7.76721491e-03f, 1.69380940e-02f,
  -3.06550950e-01f, 5.69113940e-02f, -7.29546472e-02f, -2.01735452e-01f, -2.95149475e-01f, 1.14753813e-01f, 6.63299263e-02f, -2.65839547e-01f, -4.01217729e-01f, 2.09517274e-02f,
  6.84802681e-02f, 5.41231856e-02f, 1.62131608e-01f, -1.30530670e-01f, -2.98340321e-01f, -8.61209352e-03f, -1.44744158e-01f, 2.15843588e-01f, 1.51060954e-01f, -3.43038201e-01f,
  8.82546008e-02f, -5.02127856e-02f, 2.04358786e-01f, 2.50835121e-01f, -9.76662189e-02f, -3.11931968e-01f, -8.01623836e-02f, 3.08377236e-01f, 1.31660238e-01f, -6.83037862e-02f,
  1.95242196e-01f, 1.66584291e-02f, -1.21094689e-01f, 8.53019506e-02f, 8.53632316e-02f, 4.96988624e-01f, -1.34671375e-01f, 1.84079885e-01f, 1.26683846e-01f, -4.91941422e-01f,
  -2.80817419e-01f, -2.13818654e-01f, 1.42628644e-02f, 8.90349373e-02f, 1.10583857e-01f, -2.73339450e-01f, 1.97043419e-01f, -9.34701115e-02f, 9.12533700e-02f, -1.60658106e-01f,
  -6.59556407e-03f, -2.53050268e-01f, 2.75468349e-01f, 7.52883777e-02f, -7.50784203e-02f, -2.28743583e-01f, 7.03583956e-02f, -8.07863027e-02f, -1.40646964e-01f, 1.67836085e-01f,
  -3.57411146e-01f, 2.13487893e-01f, 3.46753150e-01f, 6.39045462e-02f, 4.84349113e-03f, 2.87395507e-01f, -1.82951260e-02f, -2.37305999e-01f, -6.17294535e-02f, -6.90730512e-02f,
  2.34083068e-02f, -1.55117333e-01f, -2.42046967e-01f, -1.58584058e-01f, 2.17997253e-01f, -2.21326038e-01f, 1.20391399e-01f, -1.72479019e-01f, 2.47536898e-01f, -2.67671973e-01f,
  6.74868152e-02f, -1.36358231e-01f, -3.81636798e-01f, 1.11034624e-01f, -2.93633342e-01f, 4.22684550e-02f, 1.50536835e-01f, -8.06198418e-02f, -1.09175593e-01f, 8.72651413e-02f,
  -2.79787749e-01f, 1.84405848e-01f, -1.12737797e-01f, -2.38982618e-01f, -2.55364567e-01f, -1.21878281e-01f, -9.71819758e-02f, -1.11849019e-02f, 4.58862260e-02f, -1.56995863e-01f,
  3.73708844e-01f, -1.37704074e-01f, 1.40345827e-01f, -2.10495159e-01f, -2.47040093e-01f, 4.59698662e-02f, -5.98598383e-02f, 3.44949327e-02f, -1.69996738e-01f, 1.95954200e-02f,
  -6.65676445e-02f, 1.03483014e-01f, 5.85692115e-02f, -7.77172148e-02f, -1.01264305e-01f, -2.68102586e-01f, -1.92580044e-01f, 5.98342344e-02f, 2.35584695e-02f, 5.21358013e-01f,
  9.72118676e-02f, -1.11254297e-01f, 3.56165975e-01f, 6.55141380e-03f, 7.02195704e-01f, -2.12176472e-01f, 1.35900294e-02f, -2.89322853e-01f, -3.77971619e-01f, -2.36023888e-01f,
  1.27429396e-01f, -8.11438709e-02f, 2.50011444e-01f, 9.41226333e-02f, 4.01852131e-02f, 1.10846914e-01f, -4.45822887e-02f, 2.40765125e-01f, -9.61506292e-02f, 2.68515237e-02f,
  -3.59681249e-02f, -9.23980847e-02f, 3.56914699e-01f, 1.38182774e-01f, 3.57568562e-01f, -1.84782536e-03f, -3.66722435e-01f, 3.07596982e-01f, 1.07791973e-02f, -1.65442470e-02f,
  -3.23267013e-01f, -2.86601633e-01f, 2.32110709e-01f, -2.78429855e-02f, 7.16067329e-02f, 5.08481897e-02f, -4.09830287e-02f, 5.48603535e-02f, -2.53434300e-01f, -1.28525987e-01f,
  1.15258597e-01f, -1.09028235e-01f, 7.52866045e-02f, -9.96114463e-02f, -5.76762892e-02f, -7.38319829e-02f, -2.28994846e-01f, 3.48760962e-01f, -3.67503539e-02f, 8.77200533e-03f,
  -1.86200708e-01f, -1.78190798e-01f, 6.83321729e-02f, 2.54009422e-02f, -8.80919397e-02f, 1.59234852e-01f, -1.49026394e-01f, 8.52647945e-02f, 5.83550967e-02f, 4.40154165e-01f,
  -2.51677215e-01f, 4.81831701e-03f, 6.84592593e-03f, 3.59065831e-01f, 5.15052900e-02f, -3.96425948e-02f, -1.12153098e-01f, 1.61267363e-03f, 3.01533252e-01f, 8.25115666e-02f,
  5.70812039e-02f, -1.95945919e-01f, 1.01950966e-01f, 5.98325543e-02f, -7.11960867e-02f, 1.23438254e-01f, 3.16171855e-01f, -7.09960982e-02f, -6.36891201e-02f, 2.33688086e-01f,
  3.24294925e-01f, 2.04708219e-01f, 3.42398852e-01f, 2.93472260e-01f, 1.18149452e-01f, 3.43689084e-01f, 3.92108969e-03f, 7.85580799e-02f, 2.25140005e-02f, 1.04311891e-01f,
  3.83807391e-01f, 2.64498204e-01f, 1.00555988e-02f, -9.40694809e-02f, -1.38434514e-01f, 2.01370299e-01f, 2.62360007e-01f, 8.53411183e-02f, 3.89483958e-01f, -2.94709861e-01f,
  4.69347276e-02f, 3.32631171e-01f, -8.13761353e-03f, -7.64662549e-02f, 1.29439443e-01f, -1.17792211e-01f, 3.19806747e-02f, -5.46487086e-02f, -1.89207792e-02f, 2.25101858e-01f,
  8.95540342e-02f, 2.97794819e-01f, 2.19232917e-01f, 1.62523687e-01f, 1.22453861e-01f, -2.32657149e-01f, -1.87932923e-01f, 4.30132039e-02f, -2.88429186e-02f, -3.02922934e-01f,
  -3.19907703e-02f, 1.11713134e-01f, 1.29458785e-01f, 1.42013570e-02f, 1.92783177e-01f, -2.58869678e-01f, -9.94069502e-02f, -2.48970807e-01f, -1.27601558e-02f, -1.62671953e-02f,
  -2.39554703e-01f, -1.40591040e-01f, -1.76879957e-01f, -2.04798222e-01f, -1.93973869e-01f, 2.78166652e-01f, 2.55134612e-01f, -1.88900784e-01f, 1.16546191e-01f, 1.56226575e-01f,
  1.60373583e-01f, -1.34318501e-01f, -1.02800734e-01f, -9.73304212e-02f, 2.92210728e-01f, 1.96376324e-01f, 2.72830307e-01f, 1.42990768e-01f, 1.37057051e-01f, 3.98135573e-01f,
  -4.47396785e-01f, 2.75980085e-01f, 1.35044744e-02f, -1.88651755e-01f, -1.71628579e-01f, -9.04629305e-02f, 1.62576348e-01f, 2.94905100e-02f, 1.63720906e-01f, 1.59740403e-01f,
  2.19321668e-01f, -2.18212992e-01f, 1.54241353e-01f, 4.07762416e-02f, 2.78233051e-01f, -1.38032004e-01f, -2.01894775e-01f, -4.68516722e-02f, 9.01050940e-02f, 3.75227333e-04f,
  -1.05655529e-01f, 5.37363946e-01f, -1.47011101e-01f, -8.33195746e-02f, -1.86186373e-01f, -3.86826277e-01f, 1.99232370e-01f, 3.30355987e-02f, -5.93799613e-02f, -1.14427231e-01f,
  3.39118481e-01f, -2.97326982e-01f, -1.36119896e-03f, -8.27871040e-02f, -1.70220688e-01f, 5.38863987e-02f, -2.85695910e-01f, 1.67599499e-01f, -4.68665920e-02f, -2.38902122e-01f,
  -2.62605339e-01f, 3.52915674e-02f, -6.29821196e-02f, 1.08521722e-01f, -8.72884020e-02f, 5.36881946e-02f, -3.80020082e-01f, 3.85212362e-01f, -3.38317603e-02f, 3.90197635e-01f,
  1.62615687e-01f, 1.59537330e-01f, 5.79625145e-02f, -2.98977736e-03f, 5.17626815e-02f, -1.60877910e-02f, -5.63963726e-02f, -1.01852693e-01f, -2.36651232e-03f, -2.44949594e-01f,
  -2.53857523e-01f, -1.86952889e-01f, -4.59492475e-01f, -1.98393226e-01f, 1.11009151e-01f, -1.39977321e-01f, 2.35717103e-01f, 7.38216937e-02f, -1.09750308e-01f, 1.11297807e-02f,
  3.12792271e-01f, 5.19510321e-02f, 6.22389093e-02f, -1.52947068e-01f, 1.36883914e-01f, -2.78751943e-02f, -2.64188826e-01f, 4.30233985e-01f, -1.32487804e-01f, 2.90208608e-01f,
  -1.22007176e-01f, 7.10610580e-03f, -1.18837543e-01f, -6.68061376e-02f, 1.46550061e-02f, -1.73739567e-01f, 1.10739702e-02f, 1.48146138e-01f, 2.03053966e-01f, -4.31452215e-01f,
  -4.88549083e-01f, -5.28461039e-02f, -1.18584685e-01f, 6.94908723e-02f, -1.75367063e-03f, -4.05207217e-01f, -1.05292812e-01f, -3.89411524e-02f, -9.26623493e-02f, -6.36153966e-02f,
  -2.15542465e-01f, -1.35911740e-02f, -1.34685144e-01f, 2.88818508e-01f, 1.85516421e-02f, 1.82506725e-01f, -3.18917166e-03f, 5.09084314e-02f, 1.60968155e-01f, -2.78464612e-02f,
  3.92712951e-01f, -3.67501490e-02f, -4.01688889e-02f, -5.78406407e-03f, -1.41005218e-01f, 2.03963712e-01f, -1.22382529e-01f, 3.97307575e-01f, -8.15594867e-02f, 1.17180469e-02f,
  -5.50088026e-02f, -1.53262401e-02f, -9.58982930e-02f, -2.78004646e-01f, -1.84424505e-01f, 9.29970853e-03f, -2.26427183e-01f, -3.25617164e-01f, -2.19172165e-01f, -1.14697985e-01f,
  -1.96282759e-01f, 1.64617732e-01f, 2.52121806e-01f, -4.53291386e-01f, -2.43136641e-02f, -9.43313316e-02f, 6.44408688e-02f, -3.48010242e-01f, -1.67207301e-01f, 3.16225290e-01f,
  -2.10742503e-01f, -6.63964078e-02f, 3.06662053e-01f, 3.03832263e-01f, 5.16726971e-01f, -1.24487370e-01f, 1.40711784e-01f, 7.67621621e-02f, 4.24132161e-02f, -8.47497433e-02f,
  -1.54477777e-02f, 1.23686686e-01f, 3.65299225e-01f, -4.88839597e-01f, 3.31897378e-01f, 1.12934271e-02f, -6.72604365e-04f, 2.19943494e-01f, -1.57821193e-01f, -1.54212028e-01f,
  4.55888063e-02f, -7.96537623e-02f, 4.46778759e-02f, 4.05852459e-02f, 4.25407067e-02f, -1.13309965e-01f, 2.06880495e-02f, 2.13685423e-01f, 2.91711818e-02f, -1.79536089e-01f,
  6.14462867e-02f, -1.12386040e-01f, -1.11151047e-01f, -3.65069136e-02f, 1.00970389e-02f, 1.50844865e-02f, 1.92151908e-02f, 1.14756161e-02f, -2.03500930e-02f, 5.26134409e-02f,
  -1.10273995e-01f, 1.33712873e-01f, -2.60816514e-01f, -1.02489382e-01f, -9.25398171e-02f, 2.18089186e-02f, 4.81186919e-02f, -3.12966257e-01f, -1.31288454e-01f, 1.69433150e-02f,
  -1.72447979e-01f, -1.33696064e-01f, -8.52981731e-02f, 4.54691708e-01f, 2.52271652e-01f, 4.85013351e-02f, -4.45287526e-01f, 1.31255820e-01f, 1.72277182e-01f, 4.18588258e-02f,
  -3.35272521e-01f, 2.02552885e-01f, 9.80311446e-03f, -1.33170664e-01f, 4.30332720e-02f, -1.73324466e-01f, -2.06509978e-01f, -1.04669156e-02f, -2.30201036e-01f, -4.84242775e-02f,
  -9.88955796e-02f, 1.70090482e-01f, -9.37261358e-02f, 1.71557758e-02f, -2.61533260e-01f, 1.14039563e-01f, -3.11867893e-01f, 1.31026804e-01f, -1.40275314e-01f, 1.99929461e-01f,
  -1.85320258e-01f, -1.12133324e-01f, 3.82695675e-01f, 5.35063893e-02f, 2.22260803e-01f, 3.82973284e-01f, 5.34506589e-02f, 6.13547862e-02f, -2.51135859e-03f, 2.53871411e-01f,
  -7.59425983e-02f, -8.14131647e-02f, 2.43725687e-01f, -3.17836046e-01f, -8.94201547e-02f, 3.73835713e-02f, 3.72159183e-02f, -5.38544729e-02f, -2.35444844e-01f, 5.66534922e-02f,
  -1.06476983e-02f, 3.10995653e-02f, 4.20743704e-01f, 3.52396250e-01f, -1.03628181e-01f, 1.46658540e-01f, -2.68722385e-01f, -7.87363499e-02f, -5.11731505e-02f, 1.55872181e-02f,
  4.80504036e-01f, 4.04321820e-01f, 2.03269437e-01f, 2.30855495e-01f, 3.23226750e-01f, 4.77774084e-01f, 3.56649339e-01f, 2.15401024e-01f, -4.08570945e-01f, -4.04131949e-01f,
  3.44525933e-01f, 8.57932195e-02f, -4.28079754e-01f, -7.83087984e-02f, 1.71067342e-01f, -1.58161893e-01f, -3.68471406e-02f, 3.10486346e-01f, -9.18219090e-02f, -2.55700320e-01f,
  -5.56670539e-02f, -2.21776932e-01f, -4.66946959e-02f, 4.17466015e-02f, -1.56608865e-01f, -1.43621191e-01f, -1.46370247e-01f, -1.46047682e-01f, 2.47796163e-01f, -2.46628940e-01f,
  3.64106558e-02f, 4.81335551e-01f, 9.16487575e-02f, 7.66264722e-02f, 1.75498560e-01f, -6.95423335e-02f, -4.01607715e-02f, 2.68409520e-01f, -1.50142729e-01f, -1.64233580e-01f,
  -1.26546934e-01f, 1.96525306e-02f, 1.71593223e-02f, -2.61014640e-01f, 9.29243639e-02f, 3.03392678e-01f, -1.95055619e-01f, 3.56523931e-01f, 3.03691477e-02f, -1.32823199e-01f,
  4.16955590e-01f, 5.72300367e-02f, -1.59077108e-01f, -2.47260764e-01f, 2.49238580e-01f, -3.04962486e-01f, -9.77025181e-02f, -1.76095620e-01f, 2.60531038e-01f, -3.54786724e-01f,
  9.56183821e-02f, -1.32402852e-01f, -3.92391672e-03f, 3.33035558e-01f, -3.56919020e-02f, 6.24726787e-02f, -1.95680469e-01f, -1.29036754e-01f, 2.38800764e-01f, 1.84097558e-01f,
  4.49536383e-01f, -8.88172090e-02f, -4.03254092e-01f, -2.12922752e-01f, 9.48327184e-02f, 1.87356383e-01f, 3.06882888e-01f, -1.04342669e-01f, 3.55820149e-01f, -2.72117168e-01f,
  -2.80916262e-02f, 3.70319784e-01f, -4.79928814e-02f, -1.44098237e-01f, 1.70808092e-01f, 8.60939920e-02f, 2.88628265e-02f, -2.05479711e-02f, 2.98322678e-01f, -1.41575962e-01f,
  -7.28874356e-02f, -1.99583933e-01f, -1.51368484e-01f, -6.72966242e-02f, -1.63563207e-01f, -5.28348088e-01f, 3.05328339e-01f, -9.98094678e-03f, 2.20521942e-01f, -5.60804410e-03f,
  1.05836555e-01f, -2.18674287e-01f, -1.78523231e-02f, -2.74031945e-02f, 4.81758937e-02f, 1.79981947e-01f, -2.34047085e-01f, -1.88663900e-01f, 2.42255405e-02f, 9.25252140e-02f,
  -2.60653019e-01f, 2.51653790e-01f, -7.31956661e-02f, 2.76893694e-02f, 1.59258768e-01f, -5.80353178e-02f, 2.32187167e-01f, 9.76007781e-04f, 1.38561474e-02f, 7.54031762e-02f,
  1.03836074e-01f, 7.44849294e-02f, 1.14837095e-01f, -8.43085274e-02f, 2.14305237e-01f, 4.66214344e-02f, -2.97664758e-02f, 9.98159796e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.64436445e-02f, 8.90444666e-02f, -3.49597670e-02f, -1.64095953e-01f, 5.95375784e-02f, 1.46142468e-01f, -6.39639376e-03f, -2.76290715e-01f, -2.67366096e-02f, -2.16471717e-01f,
  2.08324581e-01f, 1.02476396e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    