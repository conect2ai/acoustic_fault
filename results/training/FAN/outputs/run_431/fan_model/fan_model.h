/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.91506577e-01f, 1.70046702e-01f, 8.68319273e-02f, 2.95305610e-01f, -1.29833221e-01f, -1.00492060e-01f, 3.67681868e-03f, -5.78834908e-03f, 2.34199181e-01f, 1.51252955e-01f,
  -1.24322407e-01f, 3.58876169e-01f, -7.08925398e-03f, 1.83214605e-01f, 1.43090293e-01f, 2.32123304e-02f, 2.58558899e-01f, 2.26102844e-01f, 2.21360568e-02f, 1.63127661e-01f,
  2.01723129e-02f, 1.17641516e-01f, -6.39609173e-02f, -2.03455731e-01f, 3.69142443e-02f, -1.18505761e-01f, 3.58250290e-02f, -2.33281180e-01f, -1.24723446e-02f, -3.86946909e-02f,
  3.47388051e-02f, 9.01406556e-02f, -6.67736977e-02f, 1.36320936e-02f, 3.25321965e-02f, -2.99520716e-02f, -6.99538831e-03f, -1.90391555e-01f, -4.02253903e-02f, -1.16365790e-01f,
  1.10259302e-01f, -4.00486030e-02f, 3.12934481e-02f, -1.47508765e-02f, -8.97260830e-02f, -5.06580286e-02f, 2.54208818e-02f, 4.90066372e-02f, -2.56189406e-02f, -5.32071106e-04f,
  -1.43945981e-02f, -3.03866193e-02f, 4.65016998e-02f, 7.24730641e-02f, -1.84306186e-02f, 5.43656982e-02f, -5.55265360e-02f, 2.25002114e-02f, 1.09199546e-01f, 1.02779781e-02f,
  1.91247638e-03f, 4.24182266e-02f, -7.09541664e-02f, -2.50615459e-02f, 2.97699645e-02f, 3.66120152e-02f, -4.27992679e-02f, 1.03943190e-02f, 2.16856059e-02f, -7.22731203e-02f,
  3.76741886e-02f, -8.97799656e-02f, 6.38904870e-02f, -3.54562365e-02f, 8.73341784e-02f, -1.56477327e-03f, 6.56582937e-02f, -9.12684947e-03f, -4.66662645e-02f, -5.82323177e-03f,
  7.57841840e-02f, 6.60715178e-02f, -1.15030985e-02f, -1.38742924e-02f, -6.90812096e-02f, 6.87928731e-03f, -2.60959841e-05f, 1.35760345e-02f, 7.57950097e-02f, -8.51248875e-02f,
  2.15937540e-01f, 7.76924044e-02f, 3.73492832e-03f, 3.64693766e-03f, -2.65952945e-03f, -2.13412810e-02f, 6.70732092e-03f, -4.17802529e-03f, 8.82593021e-02f, 1.59704648e-02f,
  -8.96894708e-02f, 5.28512187e-02f, 6.12852089e-02f, -1.15583390e-02f, 4.80343588e-02f, 7.92335197e-02f, 2.22719125e-02f, -4.78887372e-02f, 7.81626403e-02f, 1.47074647e-02f,
  2.18745880e-03f, -1.98601699e-03f, -6.33024275e-02f, -5.20799458e-02f, 3.32394764e-02f, -1.69406608e-02f, 2.85124034e-02f, -9.35217598e-04f, -7.87336975e-02f, 7.34442994e-02f,
  2.94854969e-01f, 1.40821993e-01f, 6.61534965e-02f, 1.50046334e-01f, 2.16798648e-01f, 1.09614499e-01f, 1.60928205e-01f, 2.13193238e-01f, 3.76136452e-01f, 1.55718982e-01f,
  2.68754035e-01f, -1.08941227e-01f, 3.26391645e-02f, -4.33318838e-02f, -3.08264852e-01f, -1.80407599e-01f, -1.25856891e-01f, 1.92209836e-02f, -1.05932802e-01f, 1.58321753e-01f,
  -7.56478012e-02f, 1.14772061e-03f, -2.49178335e-01f, 7.58075118e-02f, 1.98628120e-02f, 1.26583770e-01f, -1.86189517e-01f, -9.43285152e-02f, 5.35710268e-02f, 8.12874176e-03f,
  1.45056657e-02f, 1.53676882e-01f, 7.82550871e-02f, 2.57328786e-02f, 7.10343271e-02f, 5.64213730e-02f, -9.55845341e-02f, 4.68929783e-02f, 3.38311121e-02f, 1.07483156e-01f,
  -4.64298502e-02f, 1.05472077e-02f, 2.51258723e-02f, 2.77875084e-03f, 6.06023856e-02f, 1.01133049e-01f, 1.39491800e-02f, 1.05241360e-02f, 2.01383904e-02f, -1.18014939e-01f,
  1.00203313e-01f, 1.40572889e-02f, -8.48039016e-02f, -8.99345055e-03f, -6.40260354e-02f, 1.22451566e-01f, -1.40465526e-02f, -1.10930242e-01f, 3.80521715e-02f, 6.04683161e-02f,
  -3.28426855e-03f, 1.62780527e-02f, 1.37568526e-02f, 3.82706262e-02f, -3.82477343e-02f, 7.64072463e-02f, -3.04869395e-02f, 2.08717473e-02f, 2.55429428e-02f, 5.18236123e-02f,
  1.02063335e-01f, -1.25194490e-01f, 4.24282625e-02f, -3.09230238e-02f, -8.32090750e-02f, 1.38264194e-01f, -8.66826251e-02f, 1.30666271e-02f, -1.43575780e-02f, -2.66176965e-02f,
  -4.15130444e-02f, 3.46436314e-02f, -4.59124409e-02f, -7.87412561e-03f, 1.94264829e-01f, -8.72007310e-02f, -5.67332618e-02f, -1.31989727e-02f, -1.35930497e-02f, -6.88733235e-02f,
  -2.41956059e-02f, 1.59589812e-01f, 2.84869578e-02f, 9.35033634e-02f, -7.37894807e-05f, -6.72723427e-02f, -1.76940709e-02f, -7.07401559e-02f, -3.24749313e-02f, 2.46848650e-02f,
  -2.07833555e-02f, -2.92849634e-02f, 5.53616835e-03f, 2.19479091e-02f, 5.15752472e-03f, -2.90666334e-03f, 1.04941698e-02f, -1.13707343e-02f, 2.73323711e-02f, -2.87148114e-02f,
  5.51401600e-02f, 1.34603545e-01f, 6.38914481e-02f, -2.23316364e-02f, 2.50475970e-03f, -2.94169709e-02f, 8.41532052e-02f, 1.38165206e-02f, -1.37192279e-01f, -2.12612122e-01f,
  -3.21460813e-01f, -3.32284063e-01f, 1.46559685e-01f, -1.92641079e-01f, 8.82935897e-02f, -2.96817899e-01f, -1.64443210e-01f, -1.01341782e-02f, 1.25705540e-01f, -5.30180752e-01f,
  -3.65348943e-02f, -1.07244290e-01f, 6.45278627e-03f, -2.63087064e-01f, 3.91515851e-01f, 4.81609702e-02f, -2.57393360e-01f, -1.59778893e-01f, 6.33273348e-02f, -8.55695680e-02f,
  1.18642911e-01f, -1.54544428e-01f, 2.24241346e-01f, -3.87549885e-02f, -2.44060960e-02f, -2.17826702e-02f, -3.57964896e-02f, 8.51300135e-02f, -6.26122653e-02f, 6.46108016e-02f,
  8.59315768e-02f, -6.98502129e-03f, -1.06950691e-02f, 1.89898610e-02f, -2.22997926e-02f, -4.74063717e-02f, -5.19751906e-02f, -3.39333005e-02f, 6.71961531e-02f, 3.01904362e-02f,
  -1.89792458e-02f, 8.89614075e-02f, 1.41736027e-02f, -9.95228905e-03f, 4.55264375e-02f, 4.55517806e-02f, 6.30102456e-02f, -3.48106474e-02f, -8.64247791e-03f, 3.80356349e-02f,
  2.16820687e-02f, -2.38057785e-03f, 1.02298893e-03f, -1.56139266e-02f, 4.92693409e-02f, -3.61955203e-02f, -1.35283135e-02f, 5.30164801e-02f, -4.01212797e-02f, -2.09917724e-02f,
  -2.57798508e-02f, -2.83538215e-02f, -3.34183685e-02f, -3.68141127e-03f, -5.72696365e-02f, -5.38263395e-02f, -7.47825624e-03f, -1.20611019e-01f, 6.59907889e-03f, -6.42134845e-02f,
  -5.64856045e-02f, -5.33435382e-02f, -2.28083935e-02f, -1.38150482e-02f, -1.55812725e-02f, -1.17921360e-01f, -9.78248846e-03f, -1.14537859e-02f, -4.65321653e-02f, 6.96328580e-02f,
  -5.98661900e-02f, -2.60645654e-02f, -1.89648736e-02f, 3.96417789e-02f, -4.40656096e-02f, 9.80993640e-03f, -7.98803195e-02f, 8.21005106e-02f, 2.02316437e-02f, -2.40052752e-02f,
  2.10460629e-02f, -1.62468240e-01f, 6.50592297e-02f, -3.83878276e-02f, 6.07387014e-02f, -9.56212804e-02f, 6.27030507e-02f, 8.44596177e-02f, -5.07921875e-02f, 4.43485938e-02f,
  -5.86357862e-02f, 6.72513545e-02f, 4.72451672e-02f, 5.25556691e-02f, 2.82267109e-02f, 1.56318005e-02f, -9.83769260e-03f, 3.57194319e-02f, 6.66710660e-02f, -1.02831228e-02f,
  -2.35225260e-02f, -3.17915604e-02f, -1.18049665e-03f, 2.84410138e-02f, -5.46047203e-02f, -1.63778067e-02f, 2.72761211e-02f, 3.20402831e-02f, -3.01326476e-02f, 3.66894938e-02f,
  1.43378377e-01f, 2.87739515e-01f, 3.15022856e-01f, 1.05332196e-01f, -1.01577789e-02f, -3.30345392e-01f, -2.05856055e-01f, 1.34717405e-01f, 2.36267358e-01f, -1.19882651e-01f,
  -1.71380326e-01f, 1.91847980e-01f, 1.57690823e-01f, -1.53726250e-01f, -1.35694891e-01f, 7.03166872e-02f, -2.61913035e-02f, -5.39428219e-02f, 7.13504404e-02f, 1.00958876e-01f,
  6.21778816e-02f, -2.37171486e-01f, 8.24382603e-02f, -1.77705035e-01f, 7.14520663e-02f, 3.62903923e-02f, -2.01360863e-02f, 1.69305932e-02f, -1.91112980e-01f, -1.60219565e-01f,
  -1.24307685e-01f, 1.06209271e-01f, -3.08580883e-02f, -3.41586024e-02f, 1.28986675e-03f, -4.13995050e-02f, -4.80112694e-02f, -6.95031211e-02f, 1.01878047e-02f, -1.77573762e-03f,
  1.49504817e-03f, -1.24529907e-02f, -3.12235355e-02f, -2.25169063e-02f, -4.48654406e-02f, 3.30013447e-02f, 2.68417820e-02f, 1.58097483e-02f, 6.01109639e-02f, 5.35181761e-02f,
  9.14820358e-02f, -4.83242562e-03f, 3.08892261e-02f, -3.77858952e-02f, 7.15266615e-02f, 2.18294803e-02f, 4.32422236e-02f, 1.67319570e-02f, 1.68672558e-02f, -2.77083535e-02f,
  -3.24481167e-02f, 1.42600294e-02f, 3.99921052e-02f, 2.55458392e-02f, 4.44718078e-03f, -2.87202559e-02f, 7.76661141e-03f, -1.90432873e-02f, 1.16033487e-01f, -6.37352839e-02f,
  3.60068493e-02f, -1.63972378e-02f, -1.85366869e-02f, -1.87281668e-02f, 7.20025599e-03f, -3.41029838e-02f, -2.04836372e-02f, 2.24682242e-02f, 5.73385879e-02f, 6.10648766e-02f,
  -7.01162359e-03f, -2.50127614e-05f, 1.66624226e-02f, -2.42009782e-03f, -1.45910634e-02f, 1.66815072e-02f, 1.38273183e-03f, 6.01315871e-02f, 7.75090307e-02f, 1.00431656e-02f,
  -8.36628303e-02f, -3.72237861e-02f, -2.44514458e-03f, 2.81085651e-02f, -1.03114480e-02f, 6.02496378e-02f, -5.44264447e-04f, 1.89295430e-02f, -2.00826228e-02f, 5.67204645e-03f,
  -7.08950125e-03f, -8.65543857e-02f, -5.81841879e-02f, 5.08556664e-02f, 5.99184725e-03f, -5.00088073e-02f, -4.79195043e-02f, 5.19954115e-02f, -4.27852795e-02f, -5.67361785e-05f,
  -6.33837581e-02f, 3.52667682e-02f, 3.57492082e-02f, 2.44817641e-02f, -2.92661358e-02f, -8.78848415e-03f, -2.76144277e-02f, 6.67791953e-03f, -4.48792949e-02f, 4.13598344e-02f,
  2.87759095e-01f, -2.65394032e-01f, 5.43290265e-02f, 1.12881601e-01f, -9.53783048e-04f, 3.15036207e-01f, 2.15930730e-01f, -9.44097042e-02f, 1.77032307e-01f, -1.68200791e-01f,
  6.23156456e-03f, -3.47141586e-02f, 3.56971212e-02f, 1.16019823e-01f, 5.59858203e-01f, 2.42065623e-01f, 2.43726611e-01f, 4.17231694e-02f, 5.30839078e-02f, 1.44945700e-02f,
  6.43158704e-02f, 6.65315194e-03f, 8.46893564e-02f, -2.02758640e-01f, -9.98430923e-02f, -2.35120013e-01f, -1.29474714e-01f, -8.52723047e-02f, -1.35607198e-01f, 4.89485487e-02f,
  1.11553565e-01f, -3.44174504e-02f, -7.48117864e-02f, 1.85175147e-03f, -3.34299989e-02f, 8.43136013e-03f, 2.67534256e-02f, 2.20216927e-03f, 2.90581621e-02f, -9.41243693e-02f,
  1.54562267e-02f, -2.92117577e-02f, 1.81956757e-02f, -2.42653433e-02f, 1.01429876e-02f, -4.26894519e-03f, -5.99339828e-02f, 4.39407453e-02f, 2.94669364e-02f, 7.83028007e-02f,
  4.27822918e-02f, 9.49499756e-03f, 3.97329479e-02f, 4.93246783e-03f, 2.72048246e-02f, -2.59800977e-03f, 6.05758429e-02f, -5.95480436e-03f, -4.26902436e-03f, 1.60248410e-02f,
  -1.34916641e-02f, -3.46701927e-02f, -3.05117536e-02f, -3.06052584e-02f, 6.12435006e-02f, 2.25046705e-02f, 5.63912988e-02f, 2.87427790e-02f, 3.69155742e-02f, -1.04460598e-03f,
  3.69092822e-02f, 2.18960512e-02f, -1.04997284e-03f, 4.22340296e-02f, 2.30975319e-02f, 2.32305676e-02f, -1.65273324e-02f, 6.29856135e-04f, 2.45623235e-02f, -1.54559305e-02f,
  3.21207829e-02f, 3.06757335e-02f, -4.12608236e-02f, 1.69868337e-03f, 1.18588218e-02f, 4.46162298e-02f, -4.60331813e-02f, -4.13192762e-03f, -2.20911596e-02f, -6.06423197e-03f,
  3.48489657e-02f, -1.85361892e-01f, -3.20201702e-02f, -9.42223147e-02f, 4.77251085e-03f, 5.08104712e-02f, 4.80610840e-02f, -5.31370826e-02f, -5.71613982e-02f, -5.09652123e-02f,
  -2.70249955e-02f, 3.61998156e-02f, -3.64658460e-02f, 4.28919494e-02f, -2.42213234e-02f, 1.59601718e-02f, -2.32060179e-02f, -7.86159560e-03f, -6.66540042e-02f, -1.02211274e-02f,
  -3.81515361e-02f, -5.21319546e-03f, 2.43403688e-02f, -7.35683590e-02f, -3.31645869e-02f, 8.55198223e-03f, -5.25192842e-02f, 1.36796422e-02f, -1.17717423e-02f, 1.14201400e-02f,
  3.36121529e-01f, -6.21456765e-02f, 4.52928208e-02f, 1.56015337e-01f, 1.23700291e-01f, -1.50878817e-01f, -3.60082507e-01f, 1.42709792e-01f, -2.10542262e-01f, -1.18425600e-01f,
  -1.92425027e-02f, -7.82508999e-02f, -2.51322746e-01f, -1.00627162e-01f, -2.02622116e-01f, -2.66325027e-01f, -1.20005034e-01f, -5.72843179e-02f, -1.86507300e-01f, 9.56878588e-02f,
  1.93023067e-02f, 1.15512259e-01f, -5.94764091e-02f, 1.55119315e-01f, 2.15955347e-01f, 2.12195367e-01f, 1.51685998e-01f, 1.44541049e-02f, 2.20214412e-01f, -7.82313198e-02f,
  -2.52851602e-02f, -4.49334122e-02f, 5.25020510e-02f, -2.82772705e-02f, -1.32936407e-02f, 7.20759183e-02f, 2.29102802e-02f, -4.20265198e-02f, 2.40481775e-02f, -5.50914295e-02f,
  1.07134823e-02f, 8.37147087e-02f, 1.98424608e-02f, -8.50403216e-03f, -6.30294438e-03f, -1.75233036e-02f, 5.29101752e-02f, 3.23149562e-02f, -2.08659135e-02f, 1.12948284e-01f,
  -1.08431522e-02f, 7.46527463e-02f, 9.96249076e-03f, -4.15436924e-02f, 5.71234636e-02f, -2.79869121e-02f, -1.65853370e-02f, 5.72250150e-02f, 3.41596152e-03f, 5.40999463e-03f,
  3.90117280e-02f, 1.27337258e-02f, -3.30619141e-02f, 4.55492511e-02f, -2.15951502e-02f, 7.32375607e-02f, 2.22352035e-02f, -6.01210296e-02f, 8.59030709e-03f, -1.43190548e-02f,
  4.67426851e-02f, -3.15134451e-02f, 1.41183371e-02f, -5.24375103e-02f, -8.67177173e-02f, 2.37156241e-03f, -1.82271330e-03f, 3.65763274e-03f, -1.39879053e-02f, 1.20318308e-02f,
  -8.11184719e-02f, -5.94354123e-02f, -6.52514724e-03f, -2.73054671e-02f, -4.68079187e-02f, 6.24976642e-02f, 2.54753698e-02f, 2.45420132e-02f, 4.55125831e-02f, 4.93430495e-02f,
  -1.56993583e-01f, -2.13293880e-01f, -4.60633403e-03f, 4.05949391e-02f, -1.38184637e-01f, 5.35969324e-02f, -4.67579924e-02f, 3.12671699e-02f, 3.49892564e-02f, 2.68902332e-02f,
  3.95568125e-02f, -1.32031331e-03f, 1.12336986e-02f, 1.22331241e-02f, 3.00069414e-02f, -9.13068652e-03f, -4.46386226e-02f, 1.85262039e-02f, -4.76700161e-03f, 2.42800601e-02f,
  6.48357049e-02f, -1.63938440e-02f, 3.27517390e-02f, 2.60039736e-02f, 3.49974148e-02f, -3.77408303e-02f, 1.07807741e-02f, 2.97062043e-02f, -1.82750579e-02f, -1.02614954e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.12501004e-01f, -5.33208370e-01f, -5.13578281e-02f, -6.96759671e-02f, -1.15424385e-02f, -4.36621338e-01f, -1.08009474e-02f, -3.08599651e-01f, -1.07310846e-01f, -2.35923558e-01f,
  1.42947227e-01f, 2.28334442e-01f, 2.40670785e-01f, -3.08167994e-01f, 3.97504449e-01f, 1.15505233e-01f, -3.71667385e-01f, -5.71829043e-02f, -1.58546224e-01f, -2.01119602e-01f,
  -1.21268526e-01f, -8.44790265e-02f, 1.29928350e-01f, -2.87185043e-01f, -1.88491195e-01f, -1.10549793e-01f, 2.17728600e-01f, 1.53728751e-02f, -1.86943591e-01f, 6.87330738e-02f,
  -3.24920446e-01f, 8.10435265e-02f, 1.45174354e-01f, 3.75279970e-02f, 2.01550610e-02f, 2.94108386e-03f, 6.80990592e-02f, 2.36923605e-01f, 7.22788125e-02f, 2.02289789e-06f,
  4.01480384e-02f, -1.23400547e-01f, -1.48807913e-01f, -5.56105003e-02f, -1.08342536e-01f, 5.78774437e-02f, 4.42965776e-02f, -9.23789367e-02f, -1.81887746e-02f, 7.46956095e-02f,
  1.45802286e-03f, 5.36309481e-02f, -8.89102891e-02f, 1.47484159e-02f, 9.91987661e-02f, -8.72469917e-02f, 2.20519807e-02f, 8.36651325e-02f, 3.70023698e-02f, -1.36889145e-01f,
  8.65374506e-02f, 1.49811208e-02f, 1.55384958e-01f, -1.09519809e-02f, -2.60506291e-02f, -3.24500799e-02f, -5.28180972e-02f, 1.07895128e-01f, -4.82051112e-02f, -6.06698170e-02f,
  -7.50165880e-02f, 7.14689419e-02f, 4.66087088e-02f, -5.67602227e-03f, -7.24160448e-02f, 9.92951766e-02f, 1.40532088e-02f, -3.92160639e-02f, -7.18391389e-02f, -9.96887535e-02f,
  1.29902333e-01f, 9.65912011e-04f, 4.84668985e-02f, 6.84902817e-02f, 4.17764559e-02f, 1.24745928e-01f, -8.07087645e-02f, 1.35988235e-01f, 8.93501937e-02f, -1.76731795e-02f,
  -4.93187338e-01f, -1.80037186e-01f, -6.43563597e-03f, 1.38811683e-02f, 1.22806719e-02f, 3.01797427e-02f, -4.25819382e-02f, -1.42521217e-01f, -6.05591685e-02f, 5.28716063e-03f,
  -6.27060607e-02f, 1.30298063e-01f, 1.04929339e-02f, 3.05217188e-02f, -5.86388372e-02f, 6.72901142e-03f, -6.63607940e-02f, -5.57358339e-02f, 3.88754010e-02f, 1.35177458e-02f,
  5.03225438e-02f, 3.84578817e-02f, 1.47005811e-01f, -1.81951392e-02f, -1.59569383e-02f, 1.13622248e-01f, -1.63822934e-01f, -2.30477210e-02f, -3.14331912e-02f, 5.81296980e-02f,
  1.06642924e-01f, -3.61876488e-01f, 9.47047845e-02f, 7.21931756e-01f, -9.55724157e-03f, -2.44029254e-01f, -3.22855890e-01f, 2.09612444e-01f, 4.46846746e-02f, -3.06352407e-01f,
  1.58590138e-01f, -2.41058782e-01f, -1.96928144e-01f, 9.89647806e-02f, 3.45362633e-01f, -2.65116751e-01f, 1.00473337e-01f, -6.18222728e-02f, 7.47003257e-02f, 4.40097898e-02f,
  2.03700334e-01f, 3.08747053e-01f, 2.84467459e-01f, 4.36153233e-01f, 9.70628038e-02f, 3.22224736e-01f, 3.19277465e-01f, 1.13578588e-01f, 2.52334327e-01f, 1.03784233e-01f,
  -2.30895132e-01f, -1.75704539e-01f, 1.33533105e-01f, 1.71007719e-02f, -6.61692116e-03f, -1.10436670e-01f, -7.10449293e-02f, -1.28519356e-01f, 1.90836579e-01f, -1.46086039e-02f,
  -2.75662597e-02f, -2.67996509e-02f, 9.66585875e-02f, 5.11143431e-02f, -1.65087968e-01f, 1.18929282e-01f, 8.23951215e-02f, -4.87734145e-03f, -6.67085201e-02f, -5.15178367e-02f,
  -1.80497319e-02f, 1.71338879e-02f, 8.78026187e-02f, 1.88629087e-02f, 1.59075350e-01f, -4.62688319e-02f, 7.10821226e-02f, 4.91164923e-02f, -2.20003854e-02f, 1.06233366e-01f,
  -5.40000573e-02f, 2.16437057e-02f, -2.14712452e-02f, 8.58033374e-02f, 2.18858197e-03f, 3.20462906e-03f, -1.07829953e-02f, 6.89299256e-02f, -1.04519494e-01f, 8.03651214e-02f,
  4.94237170e-02f, 8.11048076e-02f, 2.94192154e-02f, -1.27834352e-02f, 4.70362641e-02f, -5.70898578e-02f, 2.85351612e-02f, 1.02966852e-01f, -5.66184185e-02f, -2.33818088e-02f,
  -2.35705618e-02f, 3.72772291e-02f, -2.56261360e-02f, 2.79777050e-02f, 6.24145418e-02f, -2.04984751e-02f, -2.19028275e-02f, -2.23326311e-03f, -1.66744515e-02f, -3.51641662e-02f,
  -3.92270058e-01f, 1.20531105e-01f, -1.57023780e-02f, 8.16515982e-02f, 3.03225890e-02f, 4.80914265e-02f, 3.50112282e-03f, 6.45428672e-02f, -5.43937832e-02f, -2.95877196e-02f,
  1.48358911e-01f, -3.99745852e-02f, -1.92990676e-01f, 2.96565685e-02f, 7.44544342e-02f, -5.88226020e-02f, -7.67978579e-02f, 6.00047670e-02f, 7.17037991e-02f, 1.01542726e-01f,
  -3.32554765e-02f, -6.40629381e-02f, 9.62458700e-02f, 4.17040177e-02f, -6.49412498e-02f, 3.31682190e-02f, -1.70747861e-02f, 6.15768880e-03f, 5.15521728e-02f, 1.72650088e-02f,
  3.17611724e-01f, 1.85010210e-01f, -2.54101247e-01f, 1.08978003e-01f, -2.53393948e-01f, -2.96916366e-02f, -3.68891060e-01f, 1.12504028e-01f, -1.81082323e-01f, 1.23421967e-01f,
  9.66374725e-02f, 1.26538962e-01f, -2.80190129e-02f, 4.69937772e-01f, 4.14879829e-01f, 1.42670125e-01f, 3.07466686e-01f, 8.42363015e-02f, 3.19269649e-03f, 3.02529156e-01f,
  6.19890913e-02f, 4.48780954e-01f, 3.23771924e-01f, 3.24009418e-01f, 3.58328894e-02f, -7.64241815e-02f, 2.66938388e-01f, -6.32804930e-02f, 2.23120615e-01f, 4.04875688e-02f,
  8.12263116e-02f, -7.85693377e-02f, -2.50814576e-02f, -9.91359800e-02f, -7.82873947e-03f, 2.46536266e-02f, -5.62108606e-02f, -4.51409183e-02f, -1.16937757e-01f, -4.79944386e-02f,
  -3.44727673e-02f, 4.49518859e-02f, 1.29238898e-02f, -3.69844548e-02f, -5.38934842e-02f, -1.60149232e-01f, -3.92660759e-02f, 3.32735404e-02f, 5.54718859e-02f, -5.20928344e-03f,
  4.40814532e-03f, -2.03752723e-02f, -4.18376476e-02f, -1.23492792e-01f, -2.03869659e-02f, 1.75064001e-02f, -4.68852967e-02f, -6.83054104e-02f, -1.40989229e-01f, 8.82387534e-02f,
  3.19200009e-02f, 3.17816660e-02f, 7.13545829e-02f, 3.82989384e-02f, 8.07761624e-02f, 3.93498242e-02f, 2.49074847e-02f, 8.25312436e-02f, 1.05881523e-02f, 1.72869340e-02f,
  7.60163441e-02f, 7.53559992e-02f, -5.96688502e-03f, -5.53151779e-02f, 6.43450171e-02f, 2.02665739e-02f, -5.66708036e-02f, 5.64165451e-02f, -5.47736660e-02f, 4.46988456e-02f,
  -2.86635477e-02f, 5.64280637e-02f, 1.35388989e-02f, -7.20929503e-02f, -4.15408099e-03f, -9.02529210e-02f, 9.42072570e-02f, -1.55677292e-02f, -9.12477374e-02f, -3.05383075e-02f,
  9.73840877e-02f, 1.63757265e-01f, -1.72433001e-03f, -6.17604032e-02f, -1.21041663e-01f, 1.50466144e-01f, 3.23631056e-02f, 1.55709475e-01f, 2.42088456e-02f, 1.72940657e-01f,
  6.96473792e-02f, -1.79488100e-02f, -6.91370340e-04f, 1.20051615e-02f, -4.21319418e-02f, 2.59673744e-01f, 3.94553877e-02f, -1.58588409e-01f, 2.62407423e-03f, 8.88292417e-02f,
  1.08490020e-01f, -1.17182925e-01f, 4.96570468e-02f, -1.34085372e-01f, -1.59026217e-02f, -4.58051600e-02f, -8.11200365e-02f, -8.59531164e-02f, 1.00313567e-01f, -1.74593478e-02f,
  -1.15146303e+00f, 1.98388040e-01f, -3.36342841e-01f, -3.42882365e-01f, -3.56694818e-01f, -3.75907838e-01f, -2.54497468e-01f, -6.10053539e-02f, 1.05103083e-01f, 2.41498590e-01f,
  9.82798287e-04f, -1.28410131e-01f, 2.02217415e-01f, -9.85369459e-02f, -1.56464413e-01f, 3.99993926e-01f, -1.39487967e-01f, -1.41210496e-01f, 1.05067119e-02f, -2.97124118e-01f,
  -1.84167743e-01f, -1.42300248e-01f, -1.58090413e-01f, -2.21501980e-02f, -1.75992250e-01f, -1.46789640e-01f, -5.08491360e-02f, -1.29233792e-01f, -2.19315171e-01f, -7.39136934e-02f,
  -1.24329314e-01f, 6.51937053e-02f, -2.70395987e-02f, -8.75561312e-02f, -2.19768047e-01f, -1.85698643e-01f, -5.91126345e-02f, -1.01018272e-01f, -9.90293920e-02f, -7.54868686e-02f,
  -4.19146493e-02f, -4.89454940e-02f, -6.25917912e-02f, -1.60962027e-02f, -1.51982516e-01f, -1.32175898e-02f, -7.61540681e-02f, 5.80402948e-02f, 1.47553295e-01f, -2.88825929e-02f,
  8.71907920e-03f, -1.42226554e-03f, -1.05515413e-01f, 3.30642611e-02f, -4.25059460e-02f, 1.29165910e-02f, 6.57456070e-02f, -8.78733993e-02f, -5.33744581e-02f, 1.46484142e-02f,
  -9.34245735e-02f, -4.29673381e-02f, 2.63706762e-02f, 1.30955689e-02f, 5.87839112e-02f, -1.58980256e-03f, -1.88927595e-02f, 5.44168241e-02f, -9.94895101e-02f, -5.25939912e-02f,
  -2.53936592e-02f, -2.72334404e-02f, -6.17977567e-02f, 3.44724790e-03f, -1.02070086e-01f, 3.26567218e-02f, -3.40889804e-02f, -4.33523878e-02f, 6.10584915e-02f, -4.62488979e-02f,
  2.63983775e-02f, -2.33775657e-02f, 6.59510493e-02f, 1.48494616e-02f, 3.92729342e-02f, 6.06868900e-02f, 2.75087375e-02f, -2.97682323e-02f, 5.44410571e-03f, -1.86232880e-01f,
  -4.07824814e-01f, -2.34485239e-01f, 1.27776369e-01f, 2.02971627e-03f, 4.78118472e-02f, 6.38619214e-02f, -8.22366867e-03f, -6.84687635e-03f, -1.74339823e-02f, -2.52764300e-02f,
  -3.65859345e-02f, -7.10565597e-02f, 4.61548455e-02f, -2.95584020e-03f, 3.61927412e-02f, 1.59144536e-01f, -4.87217791e-02f, 3.51671479e-03f, -1.45907238e-01f, 1.47404205e-02f,
  -3.42729613e-02f, -4.36821356e-02f, 6.71319738e-02f, -9.46601853e-02f, -1.49144838e-03f, -6.28007129e-02f, -8.80299881e-02f, 3.75145487e-02f, -1.78517833e-01f, -8.88438057e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -5.66803068e-02f, -4.39738780e-01f, -4.15268876e-02f, -2.84245383e-04f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.50675350e-01f, -8.99925679e-02f, 8.57789889e-02f, 1.59989834e-01f, -3.08040947e-01f, 3.91322583e-01f, -3.26819420e-01f, -3.86928946e-01f, -3.47978145e-01f, 1.20637104e-01f,
  -5.79267859e-01f, 6.68900162e-02f, -8.91764462e-03f, -2.60075659e-01f, -1.90026909e-01f, 1.19139709e-01f, -2.83985469e-03f, -3.51286888e-01f, -1.52151927e-01f, 1.29217833e-01f,
  5.12762129e-01f, -6.52325749e-02f, -3.63246202e-01f, 1.64002597e-01f, 1.20244145e-01f, -9.42760855e-02f, 4.91459109e-02f, -1.30452618e-01f, -1.53116971e-01f, -3.49888116e-01f,
  -3.01329434e-01f, 7.83427283e-02f, 3.26859176e-01f, -1.21125653e-01f, -5.50352871e-01f, 1.69461891e-01f, 5.92958136e-03f, 3.75988215e-01f, -3.46309632e-01f, -3.76627356e-01f,
  -2.92598400e-02f, -1.05404034e-01f, -1.11614995e-01f, -3.26516107e-02f, 4.77617979e-01f, -1.46120146e-01f, -7.15154558e-02f, 3.48250359e-01f, -1.72948420e-01f, -2.39568111e-02f,
  2.50667334e-01f, 7.70961866e-02f, -4.03553486e-01f, -1.09892078e-01f, -1.34423152e-01f, 4.70391333e-01f, -5.68754300e-02f, 5.58994591e-01f, -4.94465560e-01f, 5.14888465e-01f,
  -4.33595836e-01f, 3.40212993e-02f, -2.42009282e-01f, 8.45785886e-02f, 8.54656920e-02f, 1.55678958e-01f, 4.45063055e-01f, 4.00554925e-01f, -6.10516369e-01f, 4.02791768e-01f,
  -3.30421329e-01f, 1.32128522e-01f, 2.04257101e-01f, 1.60117313e-01f, 1.96157470e-01f, -1.16760664e-01f, -6.93126768e-02f, -3.59512299e-01f, -4.79454011e-01f, -3.33757490e-01f,
  -3.98426056e-01f, -9.39415619e-02f, 6.07247790e-03f, 1.49577111e-01f, 3.95593971e-01f, -2.09618546e-02f, 7.48151317e-02f, 1.13325305e-01f, 1.73812225e-01f, 1.75519228e-01f,
  1.54629067e-01f, -3.75019521e-01f, 9.84980687e-02f, -2.95442104e-01f, 5.74401468e-02f, 4.53113586e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.59808376e-02f, 2.68213838e-01f, -2.03607306e-01f, -4.45517808e-01f, 2.36414209e-01f, 1.69639081e-01f, 5.67467451e-01f, -8.06983635e-02f, -3.52181494e-01f, 9.47411895e-01f,
  -5.25435269e-01f, 8.58739242e-02f, -6.97539225e-02f, -1.62498027e-01f, 3.81195873e-01f, -4.71840411e-01f, 1.27044663e-01f, 4.92902935e-01f, 3.10980882e-02f, -4.09191668e-01f,
  2.53855765e-01f, 4.61677432e-01f, 2.71298766e-01f, 4.10116076e-01f, -8.62819135e-01f, -2.75876284e-01f, -5.10021627e-01f, 4.24008518e-01f, -6.12620600e-02f, -8.09085846e-01f,
  1.39015555e-01f, -5.94267786e-01f, -3.13726306e-01f, -2.60348767e-01f, 1.50302798e-01f, 7.15398192e-01f, 6.62906229e-01f, 6.30904377e-01f, -4.78018560e-02f, -4.72482294e-03f,
  4.48823154e-01f, 9.39374030e-01f, -8.25059861e-02f, 1.00159824e-01f, -2.58332074e-01f, 2.73142517e-01f, 2.34626740e-01f, 5.46350814e-02f, 5.62506080e-01f, 2.11662471e-01f,
  -3.16217579e-02f, 1.64681077e-02f, 3.25944424e-01f, -3.04038107e-01f, 5.76283634e-01f, 3.77667211e-02f, -9.74070370e-01f, -2.07730740e-01f, 6.07205510e-01f, -4.63194400e-01f,
  -5.28547585e-01f, -7.76496947e-01f, 3.83183241e-01f, 2.63215005e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.47197086e-01f, 3.52414966e-01f, 6.17229044e-02f, 9.09358114e-02f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.48135298e-01f, -6.46647036e-01f, 7.88367748e-01f, 4.41200614e-01f, 6.35915399e-01f, 4.88581717e-01f, 2.36255482e-01f, 4.13276613e-01f, 2.27375239e-01f, 6.25610769e-01f,
  5.81719816e-01f, 1.80575967e-01f, 2.12045964e-02f, 2.76166439e-01f, 2.96225965e-01f, 4.24312115e-01f, 3.29219550e-01f, 7.66651183e-02f, -2.78601438e-01f, -2.37183005e-01f,
  -2.18494818e-01f, -1.22359484e-01f, -5.57051599e-01f, 1.36400893e-01f, 2.76721045e-02f, -5.27228594e-01f, 1.68317661e-01f, 2.67286628e-01f, -3.07021320e-01f, -6.04392648e-01f,
  1.19360305e-01f, -2.12721884e-01f, 1.04053520e-01f, 4.39872593e-01f, -1.72568783e-01f, 2.36701947e-02f, 3.81908327e-01f, -1.65167764e-01f, 5.16721547e-01f, 5.78506589e-01f,
  -8.89613479e-02f, -4.88387316e-01f, -3.22922587e-01f, 1.11460197e+00f, 1.08616045e-02f, -3.79565328e-01f, -2.64473911e-02f, 3.47693786e-02f, -3.52900416e-01f, -4.23807830e-01f,
  4.18067217e-01f, 4.95495856e-01f, 2.26729125e-01f, -1.08279631e-01f, -5.29397726e-01f, -3.42446446e-01f, -8.84294271e-01f, 5.00298262e-01f, -4.89934674e-03f, -5.20887017e-01f,
  1.87802225e-01f, 4.12541598e-01f, 2.25372589e-03f, 9.40133929e-02f, 2.79208925e-02f, -2.55662024e-01f, 9.97033119e-02f, 3.72171044e-01f, -4.29126799e-01f, 5.97230196e-02f,
  -5.66198468e-01f, -2.25180522e-01f, -1.74893439e-01f, -5.86547732e-01f, -4.74860549e-01f, 6.04401678e-02f, -7.79035389e-02f, -3.10111374e-01f, -2.71001428e-01f, -4.01457995e-02f,
  2.74207324e-01f, -3.01329672e-01f, -7.86637589e-02f, 1.27928615e-01f, -6.09441400e-02f, -5.01641408e-02f, -3.04314733e-01f, 4.54966784e-01f, -4.37999129e-01f, -4.03649092e-01f,
  -3.00471455e-01f, 1.18093528e-01f, 5.55128679e-02f, -2.48568505e-01f, 3.62058789e-01f, 7.11042702e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.69517949e-01f, 4.15967941e-01f, -2.29328394e-01f, 8.74012709e-02f, -9.36346129e-02f, -6.74618920e-03f, -7.77590990e-01f, -2.35826433e-01f, -5.63597322e-01f, -4.17350292e-01f,
  -3.92100438e-02f, 5.05467713e-01f, -3.31517234e-02f, 4.24316108e-01f, -2.39264175e-01f, 9.40974176e-01f, -3.83288376e-02f, 7.26193964e-01f, 2.18305439e-01f, -1.78221092e-01f,
  -5.30476570e-02f, 7.74745941e-01f, -2.15547115e-01f, -3.67927670e-01f, 3.55834723e-01f, -1.96530297e-01f, -2.38151044e-01f, 3.40452313e-01f, 2.50786304e-01f, 1.01688504e+00f,
  -4.35607135e-01f, 1.21367288e+00f, 2.57500976e-01f, 7.63768017e-01f, 4.48306203e-01f, 4.78420198e-01f, 4.21396017e-01f, 3.49641442e-01f, 3.17074478e-01f, 1.33368984e-01f,
  1.09935331e+00f, 7.21827030e-01f, 7.54496515e-01f, 6.12302840e-01f, -1.18802333e+00f, -1.42301023e-01f, 5.03647804e-01f, -7.11218119e-02f, 8.85271609e-01f, -3.31014961e-01f,
  4.47395325e-01f, 8.89368892e-01f, 3.56105030e-01f, -1.04686208e-01f, -3.27443361e-01f, 4.35501158e-01f, -7.26117432e-01f, -1.28507420e-01f, -1.56910449e-01f, 1.57550946e-01f,
  9.10650849e-01f, 1.06648318e-01f, 1.11397898e+00f, -8.56236815e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.82173753e-01f, 3.78503323e-01f, 7.50887036e-01f, 6.14016771e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -3.20185035e-01f, -3.18436712e-01f, -2.74575800e-01f, -2.84875870e-01f, -7.15334043e-02f, -4.31591779e-01f, 6.10532641e-01f, 1.50175542e-02f, 6.43715262e-01f, -9.49446380e-01f,
  -5.03473341e-01f, -2.74682939e-01f, -4.62022752e-01f, -2.37095207e-02f, 1.82825193e-01f, -1.53380007e-01f, -3.83720160e-01f, -1.81102604e-01f, 5.06479144e-01f, 2.91585833e-01f,
  -2.21981034e-01f, 3.94495547e-01f, 6.29375458e-01f, -2.90474519e-02f, -4.39219296e-01f, 5.33043683e-01f, -4.88246351e-01f, -7.46124208e-01f, 1.40081897e-01f, -2.12011352e-01f,
  3.17296714e-01f, -2.25439608e-01f, -2.10228369e-01f, -5.59690714e-01f, -1.27705798e-01f, 4.29711729e-01f, 1.36093542e-01f, 6.60934523e-02f, -1.09925168e-03f, -2.10627690e-01f,
  -7.57389247e-01f, 6.46091461e-01f, 3.81288409e-01f, -1.57392651e-01f, -4.51490104e-01f, 1.63143482e-02f, -3.44827682e-01f, 3.05742681e-01f, -1.09962195e-01f, 5.04903138e-01f,
  -8.20834458e-01f, -1.12786099e-01f, 9.42848548e-02f, -5.91439418e-02f, -5.28556943e-01f, 1.18400358e-01f, 4.17723089e-01f, -6.69328690e-01f, 4.83280838e-01f, 6.95141435e-01f,
  -2.91070621e-02f, -2.72634029e-01f, -2.10520297e-01f, 3.25655878e-01f, 3.38728517e-01f, -1.72542170e-01f, 8.76485035e-02f, 1.57486767e-01f, -1.51572645e-01f, -4.29319255e-02f,
  -6.43814623e-01f, 4.05538976e-02f, -2.10660145e-01f, 7.16646135e-01f, 6.39969468e-01f, 2.31222957e-01f, 1.39042005e-01f, -6.46442100e-02f, -5.05211949e-01f, 1.59352720e-01f,
  -2.64154207e-02f, -1.79315075e-01f, -9.89113525e-02f, -4.70137864e-04f, -4.72775131e-01f, -5.89258432e-01f, 4.50960070e-01f, -6.78301096e-01f, 2.36213524e-02f, 7.69038424e-02f,
  -3.16921264e-01f, -2.80727655e-01f, 3.61154497e-01f, 3.03432703e-01f, 5.05726814e-01f, -2.32644096e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -6.59020320e-02f, -1.19688010e+00f, 1.52934849e-01f, -5.40947020e-02f, 2.11748108e-01f, -1.33132949e-01f, 1.13122737e+00f, -1.16627061e+00f, -1.09849834e+00f, 1.76992524e+00f,
  3.49947251e-02f, 3.81483108e-01f, 3.09398532e-01f, 5.91719627e-01f, 1.62976250e-01f, 1.23613191e+00f, -1.80296957e-01f, 1.41894412e+00f, -5.76852262e-01f, 3.23823482e-01f,
  8.92929137e-01f, -8.96815583e-02f, 1.02189291e+00f, -2.79363804e-02f, 1.70694339e+00f, -8.87209058e-01f, 1.22142859e-01f, 9.00465727e-01f, 1.02827087e-01f, -5.50277293e-01f,
  6.23410225e-01f, 8.94220412e-01f, 7.32383132e-01f, 4.12818432e-01f, 7.31681347e-01f, -6.50307775e-01f, 1.87841520e-01f, -7.65616477e-01f, 4.78044778e-01f, -1.51119262e-01f,
  1.12831903e+00f, -8.28379691e-01f, 1.24260522e-02f, -6.99233785e-02f, 8.62047315e-01f, 1.17468250e+00f, 8.01551759e-01f, -1.12009478e+00f, 8.01533088e-03f, 5.05268037e-01f,
  6.00162983e-01f, 1.71066284e-01f, 1.77872907e-02f, 3.26364845e-01f, 1.11536980e+00f, -3.15885216e-01f, -7.05320001e-01f, -2.11119071e-01f, -9.78729367e-01f, -1.28050971e+00f,
  -5.59772730e-01f, -5.24196744e-01f, 1.64776146e+00f, -6.06226981e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  3.51733983e-01f, 5.62517941e-01f, 5.24424076e-01f, 4.71096426e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  6.55254781e-01f, -1.24149060e+00f, -8.44757140e-01f, 4.90272939e-01f, 3.05732284e-02f, 9.22008157e-02f, -4.53586549e-01f, -4.15138513e-01f, 2.95472026e-01f, 8.11937571e-01f,
  -3.86584431e-01f, -7.90549908e-03f, -1.04123080e+00f, -3.16261739e-01f, 1.05438173e+00f, -1.18109715e+00f, -2.31878787e-01f, -5.19720912e-01f, 2.97855556e-01f, -4.89520669e-01f,
  -5.53430438e-01f, -4.43567544e-01f, 7.04080582e-01f, -7.84400225e-01f, -1.41573399e-01f, -6.55011535e-01f, 7.87597179e-01f, 8.91910672e-01f, 4.62528169e-01f, -1.76500297e+00f,
  1.46763951e-01f, -7.85174966e-01f, -1.18511248e+00f, 1.20038009e+00f, 1.49465477e+00f, 1.11280715e+00f, -8.70131433e-01f, 4.00675684e-01f, 1.13938773e+00f, -7.75064349e-01f,
  1.11727428e+00f, 1.08772707e+00f, 1.20109141e+00f, -1.60955179e+00f, 2.22148299e-01f, -9.71746504e-01f, -1.22124648e+00f, -9.96501923e-01f, -6.15248144e-01f, -1.01720202e+00f,
  -3.09932977e-01f, -5.91297030e-01f, -2.66770542e-01f, -1.46131647e+00f, 6.33226097e-01f, 4.83126760e-01f, -1.31782264e-01f, -5.05935073e-01f, 1.00933909e+00f, -4.03997213e-01f,
  -1.33773673e+00f, 2.10181206e-01f, 3.57509851e-01f, 6.09131217e-01f, 2.16581121e-01f, 1.31046534e-01f, -1.04597628e-01f, 1.42525733e-01f, -1.20198238e+00f, 3.65030795e-01f,
  1.27837145e+00f, 1.73915401e-01f, -5.85363209e-01f, 1.49994600e+00f, 5.76074958e-01f, 3.89812797e-01f, -4.51470196e-01f, 7.91834652e-01f, -4.48375762e-01f, 2.18649786e-02f,
  -1.13482118e+00f, 1.01904643e+00f, 2.77766511e-02f, 5.87482274e-01f, 9.96500015e-01f, 3.71302754e-01f, -4.47243065e-01f, -5.87707698e-01f, -1.07771933e+00f, -6.13160551e-01f,
  1.22840405e-01f, 1.27583933e+00f, -1.11220926e-01f, 3.23059797e-01f, 1.84216484e-01f, -1.25517392e+00f, -7.90451646e-01f, -6.84646428e-01f, 7.25540221e-01f, 3.34845454e-01f,
  5.18154539e-02f, 7.36540198e-01f, -1.00471723e+00f, 9.55652475e-01f, 5.43856859e-01f, -9.11636174e-01f, -1.13038707e+00f, 1.70903787e-01f, -1.52239949e-01f, 1.50531337e-01f,
  -9.03579772e-01f, 3.15349102e-01f, 1.01133609e+00f, -3.59327912e-01f, 2.51386642e-01f, -8.38982582e-01f, 1.20045161e+00f, -1.32352158e-01f, -2.45981693e-01f, -1.16933918e+00f,
  -1.14522076e+00f, 1.04062557e+00f, -2.56185412e-01f, -1.32381570e+00f, -1.20221424e+00f, 1.11234200e+00f, -4.30208445e-01f, -1.03475571e+00f, -7.47250319e-02f, -5.82782686e-01f,
  -1.41071463e+00f, -5.23082316e-01f, -8.06053132e-02f, -9.86679852e-01f, -4.77057695e-01f, -8.85696471e-01f, 4.03093725e-01f, 7.60040224e-01f, 5.75760067e-01f, -4.99023229e-01f,
  3.85032386e-01f, 3.16805124e-01f, -1.58921814e+00f, -1.15779531e+00f, 8.11201632e-01f, 1.21739149e+00f, -7.23173141e-01f, 3.23066413e-01f, -5.16690731e-01f, 9.30745244e-01f,
  6.28726259e-02f, 7.17375040e-01f, -4.01497453e-01f, -9.59361434e-01f, -1.17560089e+00f, -8.19960088e-02f, -1.59852612e+00f, -9.27651823e-02f, 6.54251516e-01f, 1.73168749e-01f,
  1.00244761e+00f, -6.23377204e-01f, 3.63515377e-01f, -8.92686188e-01f, -7.52127349e-01f, -1.17318165e+00f, 2.76818305e-01f, 1.45607725e-01f, 1.00276744e+00f, 2.62167633e-01f,
  -6.05818272e-01f, 4.50564250e-02f, 1.96272396e-02f, -9.76584971e-01f, -1.46249667e-01f, 5.96875191e-01f, 5.68655491e-01f, 4.94186163e-01f, -7.28768170e-01f, -7.02995896e-01f,
  8.71830165e-01f, 5.96545219e-01f, -6.96590304e-01f, 9.90121782e-01f, 8.96805823e-01f, -6.09591007e-01f, -7.76371658e-01f, 6.42695189e-01f, 7.76104450e-01f, -1.32797348e+00f,
  -1.21438861e+00f, -1.11545324e+00f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.26739934e-01f, -4.02437359e-01f, 9.00251150e-01f, -3.19471508e-01f, -3.76199633e-01f, -1.44515783e-01f, 5.59604354e-02f, 9.05292928e-01f, -6.33261621e-01f, 3.78821604e-02f,
  -1.94468811e-01f, 4.71009970e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    