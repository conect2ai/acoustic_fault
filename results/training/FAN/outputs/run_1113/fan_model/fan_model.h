/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.66227537e-01f, -3.04085284e-01f, 5.26966006e-02f, 1.23248836e-02f, 1.55691952e-02f, 1.60747301e-02f, -1.87727064e-01f, -1.76921040e-01f, -3.23243476e-02f, -1.54271349e-01f,
  -1.31096855e-01f, -7.65702873e-02f, -5.68745993e-02f, -9.96265467e-03f, -8.68536308e-02f, -8.90757237e-03f, 1.32999286e-01f, 1.35017827e-01f, -3.53343673e-02f, -2.08065778e-01f,
  -1.51929602e-01f, 6.52783588e-02f, -4.20861179e-03f, 1.45736756e-02f, -1.45540580e-01f, -9.07597467e-02f, -5.54387234e-02f, 1.60155855e-02f, -1.56832770e-01f, -1.23613738e-01f,
  -3.35534573e-01f, -2.17162669e-01f, -1.24265060e-01f, -1.45437643e-01f, -5.66272773e-02f, -1.94791153e-01f, -1.43747419e-01f, -1.38067491e-02f, -1.17777936e-01f, -1.11711554e-01f,
  -1.60219997e-01f, -1.22214250e-01f, -1.79839447e-01f, -5.89397177e-02f, -1.75368831e-01f, -8.93579647e-02f, -8.29484388e-02f, -4.78238538e-02f, -1.62334945e-02f, -1.87645480e-01f,
  -1.42280236e-01f, -1.58560887e-01f, -1.00936189e-01f, -2.54652966e-02f, -5.17075956e-02f, -1.55366242e-01f, -1.06884748e-01f, -1.64552093e-01f, -4.77449186e-02f, -2.00442120e-01f,
  4.47350442e-02f, 1.57305449e-01f, 9.95294377e-02f, 1.66139811e-01f, 4.23961617e-02f, 7.79266208e-02f, 1.90838292e-01f, 1.22527711e-01f, 1.85379013e-01f, 1.01465143e-01f,
  9.88609865e-02f, 1.35401800e-01f, 1.46149948e-01f, 7.28625804e-02f, 3.56439166e-02f, 2.07696006e-01f, 8.71741027e-02f, 1.15941852e-01f, 4.92622405e-02f, 1.62000209e-01f,
  1.55600473e-01f, 1.40358567e-01f, 1.20739050e-01f, 1.13500535e-01f, 1.19410619e-01f, 1.73331991e-01f, 4.53537442e-02f, 1.43887728e-01f, 5.64703345e-02f, 2.06798002e-01f,
  -1.58299401e-01f, -4.98979772e-03f, -1.64511010e-01f, -1.06810734e-01f, -1.53520241e-01f, -1.68178692e-01f, -1.33054152e-01f, -1.05481736e-01f, -1.41946912e-01f, -1.03596196e-01f,
  -6.63007125e-02f, -1.00554980e-01f, -1.30298898e-01f, -1.41488373e-01f, -4.62439433e-02f, -1.96035549e-01f, -1.90229580e-01f, -1.93236381e-01f, -1.52300701e-01f, -2.27225184e-01f,
  -1.63680270e-01f, -1.83197796e-01f, -2.52456278e-01f, -1.06579222e-01f, -1.22317068e-01f, -1.35320380e-01f, -1.29355729e-01f, -1.67823628e-01f, -8.32936838e-02f, -2.53600180e-01f,
  -6.09876849e-02f, 6.93930313e-02f, -4.14201200e-01f, 1.27107516e-01f, 1.21573411e-01f, 8.93429946e-03f, 1.45927250e-01f, 3.11194211e-02f, -1.15596382e-02f, -2.26801727e-02f,
  -1.02263518e-01f, -6.30246252e-02f, -3.52315195e-02f, -1.24042928e-01f, -5.45521155e-02f, 4.04293574e-02f, 7.26945251e-02f, -2.11087883e-01f, -1.93357989e-01f, 3.00004613e-02f,
  1.78468809e-01f, -6.50875121e-02f, -7.41494521e-02f, -1.03588346e-02f, 2.10302416e-02f, 6.78089261e-03f, -1.34510338e-01f, -1.06303552e-02f, -5.00915162e-02f, 8.50497335e-02f,
  -3.83391142e-01f, -7.24003837e-02f, -3.54553456e-04f, 1.20814674e-01f, -4.38004583e-02f, 4.89494987e-02f, -4.76112179e-02f, -5.09993248e-02f, -6.56148642e-02f, -3.41385938e-02f,
  -6.73504770e-02f, -4.13662894e-03f, -7.11971000e-02f, -5.10462560e-02f, -1.04735829e-01f, -5.95134392e-04f, 2.54116096e-02f, -1.67429358e-01f, -4.80157472e-02f, -1.42162457e-01f,
  1.14421405e-01f, -3.42722004e-03f, -1.26831636e-01f, -2.92802658e-02f, -9.34477746e-02f, -6.00751154e-02f, -8.25864449e-02f, -1.98640190e-02f, -1.69616684e-01f, -1.05487406e-01f,
  2.70034336e-02f, -6.46121502e-02f, 1.16326526e-01f, 5.30947931e-02f, 1.86846823e-01f, -2.56927335e-03f, 1.21520422e-01f, 1.04988575e-01f, 6.21245056e-03f, -1.76537354e-02f,
  3.22126783e-02f, 3.23921330e-02f, -2.15052422e-02f, -3.42144109e-02f, -5.54141961e-02f, 4.07346673e-02f, -2.59624086e-02f, 7.14606419e-02f, 3.57081369e-02f, 1.65587477e-02f,
  6.03078790e-02f, 8.81985616e-05f, 4.99666892e-02f, 4.09568883e-02f, 9.26751494e-02f, -1.64103769e-02f, -6.58117160e-02f, 1.22005092e-02f, -1.18066436e-02f, 4.96806540e-02f,
  -3.21598835e-02f, -1.00654632e-01f, -2.62145866e-02f, -3.29362042e-02f, -3.24940942e-02f, 4.37627872e-03f, -7.21264770e-03f, -7.18260463e-03f, 1.54983364e-02f, 1.31937983e-02f,
  -8.83408189e-02f, -4.47993772e-03f, -1.23191178e-01f, -7.25435540e-02f, -9.00704563e-02f, 3.36051248e-02f, 1.05161034e-01f, -6.91036358e-02f, -8.18103831e-03f, 2.03042254e-02f,
  1.39397204e-01f, 6.16204105e-02f, -1.19144106e-02f, 4.69948649e-02f, -1.07837215e-01f, -1.36370882e-01f, -1.70710266e-01f, -1.19450711e-01f, -5.48479185e-02f, 1.58467725e-01f,
  3.53519142e-01f, 3.83355767e-01f, -5.90123460e-02f, 1.29396290e-01f, 1.73730832e-02f, -8.52437839e-02f, 1.36047512e-01f, -1.47343585e-02f, -5.02769016e-02f, 1.18660569e-01f,
  4.11049612e-02f, 2.44140759e-01f, 2.06817970e-01f, 6.78437352e-02f, 2.14294091e-01f, 2.34822184e-01f, -4.08040732e-03f, 1.35046735e-01f, 1.58330172e-01f, 1.66428149e-01f,
  2.67172217e-01f, 1.97638780e-01f, 1.73331618e-01f, 6.46118671e-02f, 1.37460724e-01f, 9.48681608e-02f, 1.57836992e-02f, -2.15002280e-02f, 4.00702804e-02f, 2.74581462e-01f,
  2.92274415e-01f, -7.46338964e-02f, 1.79237146e-02f, 5.11849746e-02f, 3.11355740e-02f, 7.16313138e-04f, 1.41641319e-01f, -6.43329555e-03f, 6.15202403e-03f, 1.51950130e-02f,
  4.37281467e-02f, 2.10969578e-02f, 1.24820195e-01f, 1.08006291e-01f, 7.85492435e-02f, 4.56069177e-03f, -2.52621174e-02f, 5.07451817e-02f, 6.82120249e-02f, 1.49852216e-01f,
  1.92813888e-01f, -3.95427160e-02f, -5.21778315e-02f, -1.06162652e-01f, -6.06929362e-02f, 2.24145851e-03f, -5.26682008e-04f, -1.97107550e-02f, -2.79727243e-02f, 4.94467169e-02f,
  3.40706669e-02f, -7.59619847e-02f, 3.39699490e-03f, -3.74393053e-02f, -1.72162410e-02f, -4.02365737e-02f, 1.72507912e-02f, -6.07211031e-02f, 7.10749952e-03f, -7.55058900e-02f,
  1.07345469e-02f, -8.09183270e-02f, 1.53022613e-02f, 1.13530397e-01f, -1.43269952e-02f, 6.87580258e-02f, -7.10379472e-03f, 1.25226110e-01f, -5.06533384e-02f, -5.75704016e-02f,
  1.51932249e-02f, -8.53572935e-02f, -9.88201201e-02f, 6.27565831e-02f, -3.67958695e-02f, -5.55232577e-02f, -2.53635719e-02f, -2.21176576e-02f, -7.72258192e-02f, -8.84108469e-02f,
  2.72505343e-01f, -1.59129798e-01f, 1.67749390e-01f, 2.24131346e-02f, -2.39438756e-04f, -2.46872809e-02f, 1.97092188e-03f, 5.58590032e-02f, 5.01351170e-02f, 8.45144391e-02f,
  8.46721977e-02f, 1.66041076e-01f, 1.25586286e-01f, 4.35653366e-02f, 4.87306863e-02f, 8.22448358e-02f, 2.38098372e-02f, 8.81760791e-02f, 1.02500496e-02f, 6.51458949e-02f,
  1.15445986e-01f, 3.38976644e-02f, 1.11223437e-01f, 8.73119012e-02f, -4.17782553e-02f, 7.20519647e-02f, 4.37960774e-02f, 1.20178752e-01f, 1.61265768e-02f, 2.29947850e-01f,
  -2.08377048e-01f, 3.03156555e-01f, 2.84603626e-01f, -1.95370346e-01f, -1.00114822e-01f, -1.43757999e-01f, -6.82285577e-02f, -2.58642256e-01f, -2.43554458e-01f, -4.25278172e-02f,
  1.85501963e-01f, -7.09894225e-02f, 2.16386048e-03f, -6.41798228e-02f, -5.67905866e-02f, -6.55157045e-02f, -1.61554649e-01f, -7.70890936e-02f, -1.98156297e-01f, -1.25984803e-01f,
  -1.89115614e-01f, -2.15868074e-02f, 1.08892033e-02f, -9.19799283e-02f, 8.65626428e-03f, -7.59431766e-03f, 7.62409270e-02f, 1.05466269e-01f, 5.48427477e-02f, 2.89268140e-02f,
  1.98590457e-01f, 1.49214149e-01f, -2.41616055e-01f, -1.35663122e-01f, 1.31207868e-01f, 2.87951622e-02f, -9.34913158e-02f, -5.23957126e-02f, -3.18740644e-02f, -2.15485785e-03f,
  1.25445751e-02f, 1.63193867e-02f, -1.43148800e-05f, 1.05204759e-02f, 2.18505990e-02f, 8.36391095e-03f, -9.53286216e-02f, -1.06271863e-01f, -2.41049845e-02f, -1.13006216e-03f,
  -8.79705027e-02f, 7.56809562e-02f, -5.33878617e-02f, -2.94448598e-03f, -3.39134634e-02f, -7.04437047e-02f, 3.72864939e-02f, 4.96641472e-02f, -8.48035291e-02f, 1.34919919e-02f,
  -1.19575486e-01f, 2.43332312e-02f, 2.68148556e-02f, 1.45526798e-02f, 6.83658421e-02f, 2.63511781e-02f, 1.03298109e-02f, 9.76440758e-02f, -2.01524664e-02f, 5.08890003e-02f,
  7.16884658e-02f, 4.38419767e-02f, -2.64680535e-02f, 1.48670916e-02f, 4.17003259e-02f, -3.23618576e-03f, -5.27813248e-02f, 6.86561316e-03f, 4.48374338e-02f, -2.72375923e-02f,
  1.06619805e-01f, -2.86008082e-02f, 4.21526507e-02f, 3.21277790e-02f, -1.64535642e-02f, 2.45517911e-03f, -1.06339626e-01f, 3.10579892e-02f, 6.38398975e-02f, -1.02216946e-02f,
  -2.44369045e-01f, 1.10743651e-02f, -1.11103058e-01f, -2.11552098e-01f, -9.36266482e-02f, -6.55280799e-02f, -8.08337405e-02f, -8.80940259e-02f, -2.75251828e-02f, -1.47398457e-01f,
  5.88300452e-03f, -1.62663296e-01f, -6.49598241e-02f, -5.58351688e-02f, -4.23603244e-02f, -1.87671512e-01f, -1.06249496e-01f, -1.35555625e-01f, -7.97310695e-02f, -1.59524903e-02f,
  -1.20877415e-01f, -2.06145599e-01f, -2.08418623e-01f, -2.24707395e-01f, -9.85037088e-02f, -1.84357092e-01f, -1.42960355e-01f, -1.40481845e-01f, -2.28108749e-01f, -2.93019027e-01f,
  -1.77782565e-01f, 2.17871517e-02f, -1.97165627e-02f, -2.13709753e-02f, -3.36280745e-03f, -1.98629975e-01f, -2.40439057e-01f, -2.02918887e-01f, -1.99702531e-02f, 3.06321937e-03f,
  1.72262251e-01f, -3.99943143e-02f, 1.78098492e-02f, -1.26215488e-01f, -2.83863425e-01f, -2.62226611e-01f, -2.11398676e-01f, -2.56445527e-01f, -2.27458686e-01f, -1.26708329e-01f,
  -7.14774355e-02f, -1.08544067e-01f, -8.02958012e-02f, -1.38167694e-01f, -1.96770072e-01f, -2.06623808e-01f, -1.62656993e-01f, -9.35960263e-02f, -1.94648206e-01f, -2.80813634e-01f,
  -5.22395112e-02f, -5.79106025e-02f, 7.88505841e-03f, 7.08188536e-03f, 2.81968899e-02f, -2.82500274e-02f, -1.78518873e-02f, -8.83413479e-02f, 4.54918034e-02f, -6.08030567e-03f,
  6.75356090e-02f, 6.53296534e-04f, -6.66820332e-02f, 8.03857204e-03f, -5.66019975e-02f, -4.02068049e-02f, -7.40557313e-02f, 1.04635991e-02f, -2.96139494e-02f, 4.13899794e-02f,
  1.00936413e-01f, -2.15533394e-02f, -1.02858013e-02f, -6.40146360e-02f, 1.50243435e-02f, -7.15314746e-02f, 2.74925157e-02f, -1.51845828e-01f, -5.00963330e-02f, -2.27279156e-01f,
  9.46650207e-02f, -4.08519581e-02f, 1.97891388e-02f, 1.33573547e-01f, 2.82559078e-02f, 5.36002666e-02f, -5.34077026e-02f, -1.31209567e-01f, -9.23608243e-02f, 1.23743489e-02f,
  7.34026730e-02f, 6.16344996e-03f, 8.49123448e-02f, -1.44831643e-01f, -6.72688186e-02f, -1.11697428e-01f, -1.28428966e-01f, -1.53654516e-01f, -3.17164250e-02f, -5.29265143e-02f,
  2.07176562e-02f, 2.46989746e-02f, 3.96909788e-02f, 4.26707529e-02f, -6.05380535e-02f, 4.40932922e-02f, 8.29972774e-02f, 2.09008045e-02f, -2.51599886e-02f, -4.50053848e-02f,
  1.13582015e-02f, 1.73554830e-02f, -7.57288486e-02f, -1.90210372e-01f, -9.09163058e-03f, -1.08382311e-02f, -2.11020932e-02f, 4.13083285e-02f, 4.92026359e-02f, -9.32620987e-02f,
  -9.35389698e-02f, 3.17816809e-02f, -2.76965350e-02f, -1.42653771e-02f, -1.26143217e-01f, -6.42027408e-02f, -7.49528557e-02f, -9.19324830e-02f, -5.69869764e-02f, 6.34487793e-02f,
  -7.41856312e-03f, -4.49494123e-02f, -1.08874083e-01f, -7.69579858e-02f, -1.03787914e-01f, -2.52496693e-02f, -1.11151673e-01f, -1.07336298e-01f, -1.59985811e-01f, -1.80415809e-01f,
  4.10387754e-01f, -1.05914816e-01f, -1.80425961e-02f, 1.17242918e-03f, -2.46664613e-01f, -2.39503205e-01f, -2.38314331e-01f, 2.60521052e-03f, -1.95326470e-02f, -2.11159158e-02f,
  -3.96925993e-02f, 7.46534169e-02f, 1.36756837e-01f, 2.10900158e-01f, 2.03335762e-01f, -4.41983379e-02f, 3.32631208e-02f, 2.88474709e-01f, 5.64353429e-02f, -5.22871055e-02f,
  -1.96735650e-01f, -5.16116135e-02f, 5.34194522e-03f, 7.15352744e-02f, -1.44431755e-01f, 8.74184594e-02f, -5.88268824e-02f, -1.65556088e-01f, -4.94901091e-02f, 3.19534391e-02f,
  2.09918156e-01f, -6.78691268e-02f, 1.05483674e-01f, 2.17580814e-02f, -1.44781053e-01f, 9.00246054e-02f, -5.42811938e-02f, -6.45139068e-02f, -9.88100246e-02f, 6.16659038e-02f,
  -1.07234091e-01f, -1.87962092e-02f, -6.99621588e-02f, -1.46838173e-03f, -7.84544349e-02f, -8.76722783e-02f, -4.61618304e-02f, 1.05815560e-01f, -5.07631265e-02f, -8.32693353e-02f,
  -1.90464363e-01f, -1.43664137e-01f, 1.70299299e-02f, -4.04436179e-02f, -3.30321379e-02f, 1.87467355e-02f, -2.93103643e-02f, -1.34364516e-01f, -9.92829204e-02f, 1.34305045e-01f,
  1.06380828e-01f, -4.09732126e-02f, 7.35733612e-03f, 4.86003794e-02f, 4.22788411e-02f, 6.95936903e-02f, -1.84515845e-02f, 4.35393415e-02f, -3.59928273e-02f, -1.16381049e-02f,
  1.05553165e-01f, 9.61842760e-03f, 2.14190613e-02f, 5.03105074e-02f, 5.04445285e-02f, -7.37995058e-02f, 4.07764427e-02f, 2.94887405e-02f, 7.92234316e-02f, -4.13401984e-02f,
  -1.28650421e-03f, 8.43306258e-02f, -2.71417685e-02f, -3.58428434e-02f, 3.74581702e-02f, 3.07027735e-02f, 1.25326365e-01f, -1.62520800e-02f, 4.27334309e-02f, 3.94804776e-02f,
  1.92493424e-01f, -6.51615784e-02f, 1.25006735e-01f, -4.84813452e-02f, -2.26234868e-02f, -7.33545795e-02f, 3.13894525e-02f, 2.03376096e-02f, -2.86304392e-02f, -3.89458612e-02f,
  -4.03212644e-02f, 7.24741444e-02f, -1.94742810e-02f, -2.76161004e-02f, -7.64726326e-02f, 3.10684908e-02f, -4.44075093e-02f, 1.55058717e-02f, -7.65979737e-02f, -2.22112779e-02f,
  -1.81148555e-02f, 1.38589948e-01f, 1.96348161e-01f, 1.11023612e-01f, -1.26930922e-02f, 1.02924667e-01f, -5.61537733e-03f, 6.07372709e-02f, 2.47649252e-02f, 4.50360440e-02f,
  -3.17601532e-01f, -7.09447488e-02f, 6.54011965e-02f, -7.44486526e-02f, 8.16932544e-02f, 2.71892309e-01f, 2.42733300e-01f, 4.62766066e-02f, 1.72170755e-02f, -3.42086777e-02f,
  -5.80169670e-02f, -8.15302655e-02f, -1.17075339e-01f, -6.65647313e-02f, -2.72558685e-02f, -2.52072979e-03f, 3.92124169e-02f, -6.69240281e-02f, 1.36579037e-01f, 3.97356004e-02f,
  -3.29607017e-02f, -1.29626364e-01f, -1.73057750e-01f, -9.72134396e-02f, -1.82947278e-01f, -2.18786374e-01f, -1.22031786e-01f, -2.51714941e-02f, -7.71822482e-02f, -2.65049845e-01f,
  -2.78297991e-01f, 1.24645732e-01f, -7.70884519e-03f, -9.88486856e-02f, -5.81778623e-02f, -1.48430601e-01f, -1.28108725e-01f, -3.71300206e-02f, -7.01348409e-02f, -3.22715603e-02f,
  5.21853752e-02f, 8.49446580e-02f, 5.85148372e-02f, 9.58981812e-02f, 2.77539832e-03f, 6.42322823e-02f, 1.95620093e-03f, 7.38746896e-02f, -6.58313036e-02f, 6.90500019e-03f,
  -3.10489312e-02f, 6.30301386e-02f, 6.88212365e-03f, 1.18334414e-02f, 2.54091192e-02f, -2.18894668e-02f, -7.22199120e-03f, -9.94730592e-02f, -1.18488505e-01f, -1.55789495e-01f,
  -1.33658051e-01f, -1.46367596e-02f, 7.85298645e-02f, -1.13178372e-04f, 1.38459271e-02f, -8.94380920e-03f, 8.70668143e-02f, -3.23200189e-02f, 3.04693691e-02f, 5.65587319e-02f,
  9.24437866e-02f, 4.60983180e-02f, 2.74033695e-02f, -3.20874192e-02f, -1.10569224e-01f, 1.05125576e-01f, 2.72637066e-02f, -1.83214825e-02f, 4.09067832e-02f, -3.31904702e-02f,
  9.23007876e-02f, 7.00027496e-02f, 3.95940691e-02f, 1.15083560e-01f, 9.66952145e-02f, 8.32024217e-02f, 6.40676767e-02f, 4.90544289e-02f, 3.45419198e-02f, -2.77146660e-02f,
  -1.74167231e-01f, 4.13320959e-02f, -8.72318372e-02f, 8.10732394e-02f, -3.69389541e-03f, -5.13214655e-02f, -9.07252915e-03f, -3.25836837e-02f, -2.23233309e-02f, -5.35978153e-02f,
  -6.41609356e-02f, -8.91515911e-02f, -8.73847827e-02f, -7.91640952e-03f, -6.24230206e-02f, 2.17527542e-02f, 2.44548768e-02f, -1.99960992e-02f, -5.69884619e-03f, -3.29734758e-03f,
  -8.69120732e-02f, -7.58399293e-02f, -1.36557236e-01f, -5.99956848e-02f, -5.04542664e-02f, -1.82485417e-01f, -1.81467012e-01f, -1.90137774e-01f, -7.67939612e-02f, -3.02947134e-01f,
  8.50795731e-02f, 1.30949169e-01f, 3.05414200e-01f, 1.39710248e-01f, -7.34741688e-02f, 3.08757331e-02f, 1.53646627e-02f, -2.56641284e-02f, -1.33299232e-01f, 7.71230608e-02f,
  -1.98334366e-01f, -2.44253084e-01f, -1.80754513e-01f, -1.85937107e-01f, -7.57455379e-02f, 1.21400759e-01f, 2.86442310e-01f, 1.51864365e-01f, -2.25564707e-02f, 6.27029408e-03f,
  6.23537563e-02f, 1.80103987e-01f, 3.33079137e-02f, 7.38384575e-02f, 1.89549804e-01f, 1.40283436e-01f, 2.71212041e-01f, 2.14530364e-01f, 2.34092593e-01f, 3.31007957e-01f,
  2.35343218e-01f, 1.04239531e-01f, -8.20799097e-02f, -3.77502702e-02f, -3.44657637e-02f, 6.96446821e-02f, 6.76762238e-02f, 1.58123560e-02f, -1.34156227e-01f, 4.64495383e-02f,
  -6.93339258e-02f, -6.32061735e-02f, 7.69051630e-03f, 4.96559739e-02f, -7.31046274e-02f, -7.87309930e-03f, 5.51652163e-03f, 1.03768408e-02f, 3.24614309e-02f, 4.03089635e-02f,
  -3.85158658e-02f, 7.81721547e-02f, 1.41049266e-01f, 3.80917378e-02f, 4.67417836e-02f, 5.87024875e-02f, 9.20040607e-02f, 1.45377204e-01f, 5.57346195e-02f, 2.98749894e-01f,
  -2.54755262e-02f, 4.16596271e-02f, 5.61693870e-03f, -1.97995007e-02f, -7.31929168e-02f, -1.14903525e-02f, -1.31349377e-02f, -2.20320164e-03f, -3.09318118e-02f, 2.28598155e-02f,
  9.42650717e-03f, 1.31223327e-03f, -6.22820631e-02f, 7.62732849e-02f, 2.24815472e-03f, 1.22487836e-01f, 1.09238409e-01f, 2.44362673e-05f, -6.07893355e-02f, -6.25883117e-02f,
  1.99299473e-02f, -6.34187087e-02f, -4.42328230e-02f, 4.51674759e-02f, -3.20723057e-02f, -1.92488842e-02f, -1.29675949e-02f, -4.05067168e-02f, -3.51253971e-02f, 4.82260399e-02f,
  -7.41945431e-02f, -2.77175367e-01f, 8.74833241e-02f, -1.84257496e-02f, 1.14942849e-01f, -1.14866467e-02f, -2.21618544e-03f, -2.72846296e-02f, -1.08184092e-01f, 9.36893821e-02f,
  -3.76120359e-02f, -8.06098655e-02f, -1.50910243e-02f, -3.21596898e-02f, 2.12806575e-02f, -1.61212720e-02f, 2.37747822e-02f, 1.10747991e-02f, 1.51110003e-02f, 1.11372747e-01f,
  3.76681425e-02f, 1.38941646e-01f, 7.87552372e-02f, 1.76670086e-02f, 5.84528111e-02f, -1.30813466e-02f, 1.45706013e-01f, 8.80263373e-02f, 6.39285296e-02f, 1.04735658e-01f,
  -3.03205959e-02f, -2.44662672e-01f, 6.79085404e-02f, -1.15018435e-01f, -5.29149249e-02f, -1.19961537e-01f, -2.47843847e-01f, -3.30895372e-02f, 5.85417263e-02f, -1.16143420e-01f,
  2.94476952e-02f, 2.05323130e-01f, 1.76539421e-01f, 2.45014340e-01f, 2.67478466e-01f, -1.46611199e-01f, -6.12613559e-02f, 1.79398954e-01f, 3.28324854e-01f, 1.07207291e-01f,
  -1.09069847e-01f, -9.26510245e-02f, 7.61906505e-02f, 7.17649013e-02f, -1.52059451e-01f, 1.56021500e-02f, -1.34117320e-01f, -1.33093059e-01f, -1.62854135e-01f, -2.86337316e-01f,
  6.23706840e-02f, -1.51138544e-01f, 2.03511924e-01f, 9.45990831e-02f, 1.26413982e-02f, 1.58626765e-01f, 3.25748548e-02f, 1.78311706e-01f, -8.46990012e-03f, 7.56823504e-03f,
  -2.45770011e-02f, 1.41233671e-02f, -2.54240055e-02f, 5.16882092e-02f, 7.68696666e-02f, 1.80331431e-02f, 7.99606219e-02f, 1.58373788e-01f, 6.86988905e-02f, 6.45070747e-02f,
  -8.69734883e-02f, -1.35874704e-01f, 3.45035717e-02f, 1.74090371e-03f, 8.99740309e-02f, 4.97003905e-02f, 1.43109551e-02f, -7.90795218e-03f, 4.06393372e-02f, -5.81104830e-02f,
  8.54270998e-04f, -2.99824551e-02f, -2.78860107e-02f, -2.30556224e-02f, -2.20092926e-02f, -2.83002518e-02f, -3.14341001e-02f, -1.20976560e-01f, -5.23224100e-02f, -3.86505597e-03f,
  5.53086437e-02f, -2.83924267e-02f, 4.18338971e-03f, -6.30264059e-02f, -2.98368800e-02f, -6.99352771e-02f, -1.28303487e-02f, -4.66863113e-03f, -2.18181815e-02f, 4.15582359e-02f,
  -3.64465602e-02f, 2.72706132e-02f, -6.95570139e-03f, 2.59566735e-02f, -5.93177378e-02f, -1.25781018e-02f, -2.23185513e-02f, 8.95913988e-02f, -7.34705776e-02f, -7.66696632e-02f,
  2.02212736e-01f, 1.07377671e-01f, -7.67294616e-02f, 1.66745588e-01f, -2.15134304e-02f, 6.21466823e-02f, -1.07647208e-02f, 4.58226986e-02f, 6.89527243e-02f, 3.29774469e-02f,
  7.75292367e-02f, 6.65186718e-02f, -4.42397818e-02f, -1.28756128e-02f, 5.79424948e-02f, 1.31011773e-02f, -6.11051731e-02f, 5.36078215e-03f, 8.76035616e-02f, 3.97761632e-03f,
  -1.75393615e-02f, -9.12095159e-02f, 8.65482092e-02f, -1.34733384e-02f, 1.65122449e-02f, 4.67190966e-02f, 5.44961840e-02f, 5.53997830e-02f, 1.02459460e-01f, -2.42986158e-02f,
  -2.96814859e-01f, 7.26336837e-02f, 2.61637062e-01f, 1.83769893e-02f, -1.11036576e-01f, -2.01441441e-02f, -1.19908676e-01f, -1.88327193e-01f, -2.22606048e-01f, -2.63306219e-02f,
  -2.15875551e-01f, -3.22792798e-01f, -1.13395587e-01f, -1.02089800e-01f, -9.65022296e-02f, 5.32801449e-02f, 1.79154754e-01f, 8.87498707e-02f, -1.52007446e-01f, -2.01010942e-01f,
  -7.51979351e-02f, -1.18099816e-01f, -7.47089684e-02f, -9.34949815e-02f, 2.74970401e-02f, -1.07729733e-01f, 8.76869410e-02f, 2.35177018e-02f, -3.64970714e-02f, 8.97582434e-03f,
  -3.84720005e-02f, -9.01769549e-02f, -7.05672503e-02f, -5.31222373e-02f, -1.33552551e-02f, -5.56023605e-03f, -3.14281769e-02f, -4.32890989e-02f, -1.94052801e-01f, -9.56030041e-02f,
  -1.15177795e-01f, -1.50581911e-01f, -2.67263874e-02f, -1.75898254e-01f, -1.92920834e-01f, -1.40736327e-01f, -6.14883862e-02f, -6.09093122e-02f, -3.20977382e-02f, 5.53449476e-03f,
  -1.02563910e-02f, -1.95475236e-01f, -8.36724639e-02f, -5.42349704e-02f, 1.41885309e-02f, -1.49670970e-02f, -6.19257465e-02f, -9.26307887e-02f, -1.82981163e-01f, -2.27709323e-01f,
  1.49184793e-01f, 1.71257168e-01f, 6.89244494e-02f, -6.60660341e-02f, -3.98915708e-02f, -3.49745899e-02f, 5.09361848e-02f, -1.85794234e-02f, 3.18438858e-02f, -8.99495557e-04f,
  -9.44455527e-03f, 8.50821882e-02f, 1.55207785e-02f, 1.06828496e-01f, 1.07462481e-02f, 1.06937125e-01f, -6.95334375e-02f, 1.22664999e-02f, -2.85975318e-02f, 1.64251979e-02f,
  -3.33127156e-02f, 1.30398095e-01f, 6.32081926e-02f, -4.40004095e-02f, 3.66137102e-02f, 4.81346203e-03f, -3.73127870e-02f, -4.10117581e-03f, 5.86199313e-02f, -6.54643774e-02f,
  -3.47934693e-01f, -7.63381645e-02f, -5.20766154e-02f, -1.41023576e-01f, -6.39840215e-03f, -8.81127417e-02f, -1.21754505e-01f, -7.17142299e-02f, -1.58986777e-01f, -1.26409292e-01f,
  -2.04164952e-01f, -5.49231209e-02f, -5.92887141e-02f, -1.16576217e-01f, -2.15597212e-01f, -2.24383518e-01f, -5.54900244e-02f, -1.05656162e-01f, -1.72792614e-01f, -1.09962016e-01f,
  -9.74662751e-02f, -1.93465754e-01f, -2.14422733e-01f, -2.38467082e-01f, -8.51766542e-02f, -1.94672346e-01f, -9.50538442e-02f, -2.26396814e-01f, -1.17161795e-01f, -1.26934618e-01f,
  5.91731489e-01f, 4.04651500e-02f, 6.29641348e-03f, 4.49600607e-01f, 2.24094197e-01f, 3.33731249e-02f, -1.61013052e-01f, -4.80263634e-03f, 2.37749383e-01f, 1.85457543e-01f,
  2.19188780e-01f, 2.40803435e-01f, 1.09242961e-01f, 8.29071924e-02f, 4.19631787e-02f, -1.65954798e-01f, -1.37924030e-01f, 6.33860826e-02f, 1.97287574e-02f, -2.17676964e-02f,
  7.52220675e-02f, 2.34023601e-01f, 2.22473398e-01f, 1.00815825e-01f, 2.74879694e-01f, 1.67336896e-01f, 9.38895270e-02f, 1.52191907e-01f, 6.48520812e-02f, 1.69519648e-01f,
  2.58067697e-01f, 5.00387013e-01f, 8.41849297e-02f, 2.02025607e-01f, 2.84501702e-01f, 1.43884659e-01f, 1.38260067e-01f, 2.92593688e-01f, 2.37687513e-01f, 2.85528362e-01f,
  2.22873583e-01f, 1.71332732e-01f, 2.25445956e-01f, 1.17101125e-01f, 2.33104900e-01f, 2.68762976e-01f, 1.22815147e-01f, 9.47473347e-02f, 1.60326719e-01f, 1.24806538e-01f,
  3.40913720e-02f, 1.22978188e-01f, 2.78137505e-01f, 1.28591999e-01f, 1.73961416e-01f, 9.49427262e-02f, 2.36315072e-01f, 1.27737358e-01f, 1.11212581e-01f, 2.60281861e-01f,
  -1.03443012e-01f, -5.48264049e-02f, -2.74580196e-02f, -1.19588234e-01f, -1.67190194e-01f, -6.95430860e-02f, -1.61618255e-02f, -5.31065613e-02f, -1.81089014e-01f, -1.29155279e-03f,
  -1.37013137e-01f, -1.32023618e-01f, -2.81356014e-02f, 5.61990887e-02f, -3.56416814e-02f, -6.51665181e-02f, -1.48270056e-01f, -1.50334775e-01f, -1.68884266e-02f, -4.89590168e-02f,
  8.45268555e-03f, -1.75304696e-01f, -2.49851756e-02f, -1.93308190e-01f, -1.04362972e-01f, -1.44964069e-01f, -9.07999650e-02f, -1.66008640e-02f, 3.37169580e-02f, -2.44106539e-03f,
  2.55995065e-01f, 6.81151971e-02f, 1.09231964e-01f, 1.65872931e-01f, 1.98024482e-01f, 2.10483357e-01f, 1.30453140e-01f, 1.39908686e-01f, 2.00841740e-01f, 1.98282763e-01f,
  2.78187275e-01f, 1.70321390e-01f, 2.02854827e-01f, 1.17644630e-01f, 1.75180480e-01f, 9.19137225e-02f, 6.78803846e-02f, 9.42519456e-02f, 5.70403039e-02f, 1.66855156e-01f,
  -4.09323536e-02f, 4.48888876e-02f, 1.93833947e-01f, 8.11364725e-02f, 1.15102768e-01f, 9.61718559e-02f, 6.04138561e-02f, 4.45958376e-02f, 7.21856952e-02f, 5.45037650e-02f,
  -3.06909587e-02f, -2.04385698e-01f, 1.85849875e-01f, -6.12820983e-02f, 8.22535083e-02f, -7.16839805e-02f, -2.21444711e-01f, -8.30012858e-02f, 4.37176079e-02f, -2.26334751e-01f,
  -4.47135828e-02f, 6.57834262e-02f, -2.20095944e-02f, -1.59495100e-01f, -2.79060960e-01f, -3.81964386e-01f, -1.85843691e-01f, 4.85082157e-02f, -1.09669961e-01f, -6.58587515e-02f,
  -2.10033432e-01f, 5.66151589e-02f, 2.12666184e-01f, 1.15117773e-01f, 4.49046828e-02f, 8.98381509e-03f, 7.35840797e-02f, 1.48554415e-01f, 1.18369991e-02f, -1.37224626e-02f,
  -1.09001487e-01f, 1.72169551e-01f, -6.34063482e-02f, 2.54356619e-02f, 8.19415525e-02f, -1.20658835e-03f, 2.19339058e-02f, 1.25322238e-01f, 8.40011314e-02f, -8.33543167e-02f,
  7.96093866e-02f, -2.90197041e-02f, 1.00230373e-01f, -1.54065033e-02f, -7.50247464e-02f, -1.00198232e-01f, -4.15127538e-02f, 1.41927954e-02f, 2.57841535e-02f, 2.81069838e-02f,
  -7.12144002e-02f, 2.80417074e-02f, 3.22291516e-02f, -8.39736089e-02f, 9.40391049e-02f, 6.28762916e-02f, 3.31702605e-02f, 6.61981478e-02f, 1.61489889e-01f, -8.47688615e-02f,
  -7.03956261e-02f, -3.81084643e-02f, -8.65111575e-02f, -3.34387347e-02f, -1.31435663e-01f, -7.78606981e-02f, -1.09663427e-01f, -1.72133446e-01f, -8.79121013e-03f, -2.01429389e-02f,
  -4.12504971e-02f, -2.14388594e-02f, -6.86193928e-02f, -4.48134318e-02f, -6.22211881e-02f, 4.37484384e-02f, -5.05022332e-02f, -1.37131393e-01f, 1.95283685e-02f, 3.28326598e-02f,
  -6.37274794e-03f, -5.87423407e-02f, 3.65712456e-02f, -8.16815495e-02f, 3.85602228e-02f, -1.11212820e-01f, 6.45421562e-04f, -1.24876089e-02f, -1.18272398e-02f, 5.30149555e-03f,
  -1.90504551e-01f, 2.42935285e-01f, -1.08659253e-01f, -1.13525584e-01f, -4.35592346e-02f, -5.64311072e-03f, 1.62049904e-02f, 3.50547917e-02f, 1.10040896e-01f, -7.31706098e-02f,
  5.77901527e-02f, 2.54965052e-02f, 4.96441573e-02f, -2.35285107e-02f, 6.39645802e-03f, 2.05629300e-02f, -1.82051882e-01f, -9.29179564e-02f, -5.89938238e-02f, -7.15149008e-03f,
  -8.72201771e-02f, -1.87165827e-01f, -1.97729856e-01f, -7.80092031e-02f, -7.44732991e-02f, 1.40883615e-02f, -3.73720229e-02f, -6.85380995e-02f, -2.03687593e-01f, -2.78856337e-01f,
  -5.72497666e-01f, -7.84301609e-02f, 1.72692180e-01f, -3.10259312e-01f, 2.45449662e-01f, 4.10682440e-01f, 3.93925846e-01f, 9.38474759e-02f, -2.40439907e-01f, -1.82701601e-03f,
  -3.83455157e-02f, -1.55011669e-01f, -2.27399364e-01f, -1.11355595e-02f, 1.70151278e-01f, 3.39463651e-01f, 2.81678945e-01f, -1.16635785e-02f, 9.59591866e-02f, 3.58830802e-02f,
  -3.73348370e-02f, -6.38515204e-02f, -2.39282444e-01f, -1.50633708e-01f, -2.54002988e-01f, -4.33142669e-02f, -6.07597455e-02f, -8.89785439e-02f, 1.85505599e-01f, -1.65960759e-01f,
  -7.16499090e-02f, -2.64614791e-01f, 6.10377453e-02f, -1.38593882e-01f, -3.02629527e-02f, -1.37069494e-01f, 2.20802575e-02f, -2.18271479e-01f, -1.47229046e-01f, -4.07520533e-02f,
  -1.77242696e-01f, -1.55850202e-01f, -3.87177765e-02f, -4.90312884e-03f, -1.15591012e-01f, -9.10551250e-02f, -9.89220217e-02f, -1.12313911e-01f, -3.66956815e-02f, -8.17762241e-02f,
  -7.99272358e-02f, -6.43363744e-02f, 7.66123161e-02f, 1.14225656e-01f, 6.80868253e-02f, -8.15301389e-02f, 6.63394481e-02f, -1.29498050e-01f, 6.97519183e-02f, -1.27022028e-01f,
  9.60139632e-02f, 1.35920957e-01f, 8.80156308e-02f, 9.06066969e-03f, 8.04244429e-02f, -1.64943840e-02f, 5.65597229e-02f, 6.27002865e-02f, 6.90421909e-02f, 2.34524254e-02f,
  8.58959649e-03f, 6.83665872e-02f, 2.66661178e-02f, -3.40007036e-03f, 2.38278997e-03f, -4.71138908e-03f, 1.20420709e-01f, -1.62365679e-02f, 6.19415641e-02f, 1.34890890e-02f,
  -2.07850691e-02f, -4.57906462e-02f, -4.34630476e-02f, 3.95441800e-02f, 2.95664109e-02f, 1.88947842e-02f, -3.79179195e-02f, -5.79222105e-02f, -7.00785173e-03f, -5.40751498e-03f,
  -1.22547530e-01f, 1.15780227e-01f, -1.24478802e-01f, -1.18263811e-01f, -1.41169935e-01f, -1.03049256e-01f, -1.21809855e-01f, -3.69180627e-02f, -7.14764968e-02f, -4.28131968e-02f,
  -4.58474271e-02f, -4.26994935e-02f, -7.29032680e-02f, 2.19979901e-02f, 2.29250155e-02f, 3.94446813e-02f, -8.13497454e-02f, 4.43317601e-03f, 6.95425458e-03f, -6.58819219e-03f,
  1.06394407e-03f, 3.87423038e-02f, 9.91855934e-02f, 6.39444217e-02f, -4.91895042e-02f, 3.21861133e-02f, 5.76035343e-02f, 3.05146556e-02f, 5.27767986e-02f, 4.99013066e-02f,
  2.37029061e-01f, 2.49639988e-01f, 2.82681912e-01f, -2.23628376e-02f, -2.07228556e-01f, -4.28599901e-02f, 1.94646399e-02f, -1.94440670e-02f, -1.60888791e-01f, 1.88308597e-01f,
  1.65302947e-01f, 7.35152215e-02f, 4.54185084e-02f, -1.57857668e-02f, 7.41211995e-02f, -3.17900367e-02f, -6.24106312e-03f, 3.45429108e-02f, -1.21310085e-01f, -1.74952820e-01f,
  -1.70838952e-01f, -5.06334193e-02f, 1.30563183e-03f, 2.64446102e-02f, -3.42254974e-02f, -1.27726629e-01f, 1.84198245e-01f, 1.56725556e-01f, 4.40322459e-02f, 1.43499464e-01f,
  1.68819487e-01f, 1.80475146e-01f, -2.68049479e-01f, -2.04511493e-01f, 3.64553407e-02f, -6.60867319e-02f, -1.22627921e-01f, 5.26046120e-02f, -3.26140895e-02f, 1.53919337e-02f,
  6.37224242e-02f, -4.66967002e-02f, -2.58975639e-03f, -5.42670041e-02f, 3.04173194e-02f, -5.78523651e-02f, -1.32949445e-02f, 8.39902312e-02f, 9.11852643e-02f, 7.12720603e-02f,
  -6.97276890e-02f, 6.98836744e-02f, 2.14192703e-01f, -3.53573449e-02f, 2.66965460e-02f, 9.57822893e-03f, 1.46104500e-01f, -8.11078474e-02f, 1.01148218e-01f, -1.26365861e-02f,
  -9.85284522e-02f, 4.98409197e-02f, -2.53103804e-02f, 6.89157173e-02f, 5.11345267e-02f, 4.21246774e-02f, 1.34163588e-01f, 6.53362796e-02f, -4.21511419e-02f, 7.68805742e-02f,
  5.14305234e-02f, 9.60321948e-02f, 1.10174216e-01f, 9.99114737e-02f, -4.35122382e-03f, 1.18054442e-01f, 6.98499158e-02f, 5.71794920e-02f, 1.31222859e-01f, 5.92076359e-03f,
  6.07214943e-02f, 8.00976977e-02f, 4.73017618e-02f, 4.55761328e-02f, 8.64933655e-02f, -6.93721557e-03f, -6.15626872e-02f, 8.89727697e-02f, 4.01310287e-02f, 5.74776530e-02f,
  -1.72139719e-01f, -4.58714738e-03f, -9.89257544e-03f, -1.76814143e-02f, -9.17481482e-02f, -4.21170406e-02f, 2.05052756e-02f, -6.91928789e-02f, 3.19224261e-02f, 2.06717830e-02f,
  -6.56692013e-02f, 4.71386053e-02f, -4.45685871e-02f, -8.72904584e-02f, -4.63499874e-02f, -2.29003020e-02f, 3.30797955e-02f, -7.95920268e-02f, -7.21197203e-02f, 1.88521687e-02f,
  -1.10776372e-01f, 9.92682576e-03f, -6.32616282e-02f, 5.02334237e-02f, -2.63545457e-02f, -1.59229949e-01f, -7.83505142e-02f, -5.86932003e-02f, -7.28616044e-02f, -1.06310844e-01f,
  4.05421466e-01f, -2.64748454e-01f, 1.11928903e-01f, 6.69491813e-02f, -5.48135564e-02f, 8.22013915e-02f, -4.70867418e-02f, 8.80000517e-02f, 4.69704904e-02f, -1.95298791e-02f,
  -3.57261449e-02f, 2.69616991e-01f, 1.19699039e-01f, 2.69805968e-01f, 2.33635396e-01f, 2.05213465e-02f, 1.30109653e-01f, 4.60014880e-01f, 4.45362449e-01f, 3.27085108e-01f,
  1.90089077e-01f, 2.00456187e-01f, 2.16304660e-01f, 2.77224362e-01f, 2.54929275e-03f, 1.91247687e-01f, 3.93813699e-02f, 3.11869979e-02f, 1.03985019e-01f, 7.91332647e-02f,
  6.03726842e-02f, 4.43244204e-02f, 2.04716086e-01f, 1.14481129e-01f, 7.45073855e-02f, 1.35278359e-01f, 3.99413295e-02f, 1.42429434e-02f, 1.09876424e-01f, -8.42844136e-03f,
  8.58565569e-02f, 1.53492332e-01f, 3.64519954e-02f, 1.46666765e-01f, 1.76537871e-01f, 7.36393183e-02f, 4.59915288e-02f, 2.66568512e-01f, 2.24375844e-01f, -9.63801239e-03f,
  8.12334344e-02f, 2.03045607e-01f, 1.46405295e-01f, 4.35576448e-03f, 9.66635644e-02f, 2.76276171e-01f, 1.12658955e-01f, 1.27269611e-01f, 1.70789808e-01f, -1.48327714e-02f,
  -6.12752773e-02f, 7.96088204e-03f, -7.76735395e-02f, -1.59493387e-01f, -9.09420177e-02f, -5.28497621e-02f, -5.17882183e-02f, -5.60338795e-02f, -2.33303644e-02f, -3.69382799e-02f,
  -1.35649115e-01f, -7.06201941e-02f, -5.63775226e-02f, -1.01403110e-01f, -1.31757185e-01f, -2.23118011e-02f, -6.79923734e-03f, -8.74008760e-02f, -1.18502423e-01f, -3.72365415e-02f,
  -1.77651960e-02f, -7.41625428e-02f, -3.30798551e-02f, -1.28025472e-01f, -1.67349130e-02f, -1.25770867e-02f, -5.75815402e-02f, -9.50350389e-02f, -4.51210216e-02f, -8.41675848e-02f,
  -1.42460719e-01f, 1.86146066e-01f, 1.22894064e-01f, 1.77346140e-01f, 1.15979193e-02f, 3.05590732e-03f, 7.28771612e-02f, 1.03714943e-01f, 1.14350520e-01f, 9.20681059e-02f,
  1.50612846e-01f, 7.67002925e-02f, 4.43312265e-02f, 4.88336906e-02f, 9.37748551e-02f, 7.39340782e-02f, 6.26075128e-03f, 1.21734925e-01f, 1.12853840e-01f, 4.86463169e-03f,
  4.57529500e-02f, 1.80918545e-01f, 1.94972202e-01f, 1.74238577e-01f, 1.31359145e-01f, 2.01329261e-01f, 5.99785075e-02f, 9.77998227e-02f, 2.91370869e-01f, 4.66743782e-02f,
  3.02675575e-01f, -1.01585977e-01f, -1.86287835e-01f, 1.54179811e-01f, -1.67231336e-01f, -2.74049133e-01f, -3.90811682e-01f, -1.71178430e-01f, 1.78449184e-01f, -8.98847729e-02f,
  1.23385698e-01f, 1.61829561e-01f, 1.69659153e-01f, 9.18396786e-02f, -1.09259203e-01f, -1.86076984e-01f, -2.10425258e-01f, -4.50669713e-02f, -1.19737638e-02f, 2.01271728e-01f,
  2.03023568e-01f, 3.32845241e-01f, 3.34964335e-01f, 2.31571779e-01f, 2.04522789e-01f, 1.93209782e-01f, 5.28163612e-02f, 1.11681297e-01f, 4.10004221e-02f, 1.74355313e-01f,
  5.80171645e-02f, 1.21255457e-01f, -1.49610005e-02f, 1.50755256e-01f, 1.60521105e-01f, 9.11496431e-02f, 1.02870800e-01f, 1.47676885e-01f, 7.71235898e-02f, 7.58952126e-02f,
  9.78758782e-02f, 1.17166460e-01f, 1.05811551e-01f, 1.74918234e-01f, 2.11514175e-01f, 1.94204852e-01f, 2.46709138e-01f, 1.12158619e-01f, 1.86670616e-01f, 3.69058661e-02f,
  1.57569945e-01f, 8.42430815e-02f, -2.47184765e-02f, 9.06745251e-03f, 1.01837136e-01f, 1.34694591e-01f, -8.90764035e-03f, 1.39233142e-01f, -3.63489315e-02f, 1.41466692e-01f,
  6.27888367e-02f, -5.04038297e-02f, -3.08759343e-02f, -1.12428954e-02f, -4.40905020e-02f, -2.19974183e-02f, -7.49480426e-02f, -8.86394922e-03f, -3.36773805e-02f, 7.85229132e-02f,
  -5.54349124e-02f, 4.18983307e-03f, 1.51941497e-02f, 3.33325146e-03f, 1.06674634e-01f, -2.98280269e-03f, 3.83096114e-02f, 2.73325890e-02f, 2.36471407e-02f, 3.39144953e-02f,
  -7.08497642e-03f, -1.10090993e-01f, 4.42109928e-02f, 9.60637331e-02f, 7.52176717e-03f, -8.60572755e-02f, 3.54264490e-02f, -1.10175759e-02f, 1.62377600e-02f, -3.62138860e-02f,
  2.70866185e-01f, -1.70362547e-01f, 1.48895709e-02f, 8.90094265e-02f, 4.51188833e-02f, 1.12552963e-01f, -2.79476065e-02f, 1.00930698e-01f, 8.82945880e-02f, 3.31804566e-02f,
  1.15204766e-01f, 4.08743136e-02f, 5.22252806e-02f, 5.86435124e-02f, 1.50290532e-02f, -1.10147037e-02f, 7.26195574e-02f, 7.13670030e-02f, 2.19248571e-02f, 1.30832359e-01f,
  6.82832226e-02f, -2.28891429e-02f, -1.16083764e-01f, -1.06713176e-01f, -6.38224781e-02f, -1.11454919e-01f, -1.59696881e-02f, 1.62505321e-02f, -2.14889273e-01f, -3.81208919e-02f,
  -8.02333206e-02f, 1.98968902e-01f, 3.04102272e-01f, 2.75397301e-01f, 3.05842131e-01f, 1.68255866e-01f, 2.49573529e-01f, 2.25784168e-01f, 4.56083305e-02f, 2.23340854e-01f,
  7.49237984e-02f, -7.95795098e-02f, -6.43811077e-02f, -1.17389016e-01f, -1.76166162e-01f, 3.48973036e-01f, 2.22379208e-01f, -1.08713716e-01f, -2.26222679e-01f, -9.88307074e-02f,
  -2.28918139e-02f, 1.82003679e-03f, -1.55242364e-04f, -1.07720844e-01f, 7.86624253e-02f, 3.94277349e-02f, 3.40991288e-01f, 2.01296329e-01f, 5.79597168e-02f, 1.62196651e-01f,
  2.52259761e-01f, -1.18377013e-02f, 2.71205194e-02f, -6.17419668e-02f, 4.20591719e-02f, -3.81937623e-02f, 1.14133619e-01f, 3.74849364e-02f, -7.42150992e-02f, 1.19824201e-01f,
  8.11982676e-02f, 1.22285597e-02f, 3.36030386e-02f, 2.94297580e-02f, 3.14775817e-02f, 9.11654159e-02f, 5.29303513e-02f, -1.03695251e-01f, 4.28170078e-02f, 2.13456862e-02f,
  9.28608701e-02f, 7.84481987e-02f, 9.92906466e-02f, 4.45070826e-02f, 5.17388899e-03f, -2.98737828e-02f, 1.63910896e-01f, -6.46740124e-02f, -2.16745418e-02f, 2.07414508e-01f,
  -1.55017480e-01f, -9.86181200e-02f, -5.31247444e-02f, -1.31129935e-01f, 2.27667624e-03f, -1.01904795e-01f, -1.40907727e-02f, -9.93562583e-03f, -1.34881079e-01f, -3.96842919e-02f,
  -3.86645794e-02f, -1.31936327e-01f, -1.28277779e-01f, -7.57408887e-02f, 4.21007397e-03f, -1.99199095e-02f, -6.61386400e-02f, -8.66847560e-02f, -1.18887998e-01f, 1.70320366e-03f,
  -1.36757404e-01f, -5.85748740e-02f, -3.97871435e-02f, -5.71872294e-02f, -1.43455535e-01f, -4.37345095e-02f, -3.00013032e-02f, -1.67513192e-01f, -5.68167195e-02f, -8.83003473e-02f,
  3.22576016e-01f, 3.39660645e-02f, 6.06962778e-02f, -1.35593303e-02f, 1.91981480e-01f, 2.70534251e-02f, 1.68217361e-01f, 7.75670959e-03f, 7.99073502e-02f, 3.71370539e-02f,
  -3.75206172e-02f, 9.36197788e-02f, 5.97829670e-02f, 6.50863871e-02f, 8.15387368e-02f, 1.48420393e-01f, 1.26053095e-01f, 9.51960012e-02f, 8.04783627e-02f, 5.02353795e-02f,
  9.63206142e-02f, 9.33198258e-02f, 1.82589680e-01f, 1.66649386e-01f, 9.77348313e-02f, 1.07200049e-01f, 2.00967014e-01f, 1.81185544e-01f, 2.04399571e-01f, 2.63919294e-01f,
  1.76615596e-01f, 2.66176462e-01f, -3.16654235e-01f, -2.02518720e-02f, -2.50588566e-01f, -2.33725220e-01f, -1.48998037e-01f, 2.24060863e-02f, 9.33575183e-02f, -3.35521661e-02f,
  -6.49125502e-03f, 3.88104934e-03f, 6.82490692e-03f, -1.24165967e-01f, -7.17709437e-02f, -1.91469699e-01f, -1.06866136e-01f, -1.22565605e-01f, -2.17124283e-01f, 5.50940223e-02f,
  1.89507440e-01f, 1.56832173e-01f, 8.26084912e-02f, 4.33106301e-03f, 2.53598928e-01f, 6.48764372e-02f, 1.15175113e-01f, -2.97903400e-02f, 5.51283243e-04f, 8.55386555e-02f,
  -2.93798037e-02f, -1.59127131e-01f, -3.89362685e-02f, -9.66401324e-02f, -1.01424055e-02f, 1.97264981e-02f, -3.01361568e-02f, 5.92265464e-02f, -6.87551498e-03f, 7.47482255e-02f,
  -1.24824889e-01f, -3.55795138e-02f, -4.69428152e-02f, 1.08684450e-01f, 2.28339639e-02f, -2.57989336e-02f, -3.88777852e-02f, -4.33124267e-02f, -2.97743864e-02f, 1.12634990e-02f,
  -6.57262877e-02f, -1.52106389e-01f, -1.24447815e-01f, -1.52076706e-01f, -4.78797369e-02f, -8.40056092e-02f, -2.11679917e-02f, 2.49337927e-02f, -4.55462188e-02f, 2.21878409e-01f,
  4.46295962e-02f, 1.15889937e-01f, 6.53935298e-02f, 4.20857593e-02f, 1.20961607e-01f, -3.83050665e-02f, 7.24692177e-03f, 7.66694248e-02f, 1.21342547e-01f, 9.97614861e-02f,
  2.65347888e-04f, 9.52077433e-02f, 8.13843831e-02f, 3.22642736e-02f, 8.80127922e-02f, -6.68841600e-02f, -1.74176265e-02f, 9.82114393e-03f, 7.63368160e-02f, 4.58121859e-02f,
  1.10247537e-01f, 2.70632748e-02f, 1.12616655e-03f, 8.65918845e-02f, -5.14965551e-03f, -7.15204924e-02f, 3.29875536e-02f, 1.45537317e-01f, 5.46950148e-03f, -5.44433817e-02f,
  3.11117589e-01f, -2.70862222e-01f, -3.71417888e-02f, 5.58181517e-02f, -1.21388383e-01f, 6.25941902e-03f, -9.10138711e-03f, -3.26836184e-02f, -1.45678781e-02f, -1.31992446e-02f,
  -1.14278041e-01f, 1.81804206e-02f, -5.60035408e-02f, -1.11042745e-02f, 4.91116755e-02f, -4.45294939e-03f, -3.65736783e-02f, -7.75454938e-02f, -8.66144374e-02f, 2.12708320e-02f,
  3.36941816e-02f, -1.30974010e-01f, -7.02461973e-02f, -8.81117806e-02f, -1.10329576e-01f, -1.80047527e-01f, 4.32905741e-02f, 7.49715939e-02f, -2.06634372e-01f, 2.29295999e-01f,
  2.46022761e-01f, 1.97738986e-02f, 2.09703967e-02f, 1.97046101e-01f, 1.36765152e-01f, 1.10917002e-01f, 1.50516421e-01f, 1.59793496e-01f, 1.44157931e-01f, 8.03335235e-02f,
  -2.73582965e-01f, -2.98542500e-01f, -9.42431241e-02f, -2.50641346e-01f, -4.01555598e-02f, 3.15013975e-01f, 2.82146066e-01f, 5.89394681e-02f, -1.03222691e-01f, -1.82683766e-01f,
  -5.28656319e-03f, 1.47083357e-01f, 2.33922377e-02f, -6.79807054e-05f, 1.46627977e-01f, 3.94283235e-02f, 8.19042847e-02f, 3.32836360e-02f, 1.89640336e-02f, 3.17941040e-01f,
  -1.77310541e-01f, 7.01171309e-02f, -8.56302828e-02f, -1.35335818e-01f, -3.34758908e-02f, 8.48224238e-02f, 1.01913400e-01f, 4.77316305e-02f, 5.49044088e-02f, 1.66240662e-01f,
  -5.35180680e-02f, -9.12157446e-02f, 2.06965655e-02f, 1.11090384e-01f, 6.58786893e-02f, 3.33430469e-02f, 8.94252583e-02f, 6.76275641e-02f, 7.19926320e-03f, -7.72473365e-02f,
  -6.95661232e-02f, 7.24641159e-02f, -3.61946449e-02f, -4.78288271e-02f, -6.51062280e-02f, -1.06868148e-01f, 5.22135571e-03f, -6.33147433e-02f, -2.97479611e-02f, 1.32414654e-01f,
  6.08149916e-03f, -2.64731590e-02f, -2.68990565e-02f, 2.60593165e-02f, 4.75984737e-02f, 6.30774722e-02f, 1.59782879e-02f, -4.41751778e-02f, 3.13413106e-02f, -3.53913531e-02f,
  3.05404118e-03f, -5.95944338e-02f, -2.96619404e-02f, -6.65312111e-02f, -3.36667150e-02f, -1.93979274e-02f, -5.87574206e-02f, -2.85194051e-02f, -7.11785555e-02f, -3.78246419e-02f,
  1.06286220e-02f, -1.10650070e-01f, -3.07252277e-02f, -5.06536774e-02f, -9.65957902e-03f, 1.27801369e-03f, 3.70686278e-02f, -9.41938311e-02f, -5.03706671e-02f, 4.50613871e-02f,
  -4.52888496e-02f, -1.51311308e-01f, 9.00808573e-02f, 2.15384439e-02f, -2.09837928e-02f, -8.89576748e-02f, -5.41938953e-02f, -5.57299182e-02f, 9.44282413e-02f, 5.08855172e-02f,
  -4.88586873e-02f, -5.04148453e-02f, 5.07089309e-02f, -4.25912766e-03f, -4.05895663e-03f, 7.07356585e-03f, -1.92482919e-02f, 1.70123130e-02f, 7.18736881e-03f, 4.45184819e-02f,
  3.48479487e-02f, 1.82442039e-01f, 5.93376234e-02f, 6.40726984e-02f, -1.01262769e-02f, -1.55177275e-02f, -9.42085590e-03f, 3.85048315e-02f, -1.53847914e-02f, 2.99371749e-01f,
  -5.56381345e-01f, 3.64830017e-01f, 1.83200333e-02f, -1.28913864e-01f, 1.44728839e-01f, 2.73836777e-02f, 1.31995380e-01f, -1.42541498e-01f, -6.88031465e-02f, 1.75227374e-01f,
  1.49961188e-01f, 1.98794574e-01f, 9.93078426e-02f, 7.59167820e-02f, 7.82190859e-02f, 9.15319473e-02f, 1.05947532e-01f, -1.63130000e-01f, -2.34036803e-01f, -2.46329993e-01f,
  1.88435510e-01f, 5.99994920e-02f, -1.97999030e-01f, -9.79344323e-02f, 6.98326603e-02f, 2.33980324e-02f, 2.25099444e-01f, 1.49659380e-01f, 8.63587037e-02f, 1.78626329e-01f,
  1.63694583e-02f, -2.39324316e-01f, -1.48574322e-01f, 9.18284729e-02f, -3.14381048e-02f, -8.31764415e-02f, -1.93009600e-02f, -1.64270729e-01f, -8.04991350e-02f, -5.63866608e-02f,
  -7.59370029e-02f, -7.55053014e-02f, 4.88952249e-02f, -1.78161915e-02f, -3.92303467e-02f, -2.93866210e-02f, -1.24732135e-02f, -4.29075919e-02f, -1.02965675e-01f, -5.12066716e-03f,
  2.22851411e-01f, 1.76000167e-02f, -9.76711605e-03f, 6.53706342e-02f, -9.05985385e-02f, 7.73890093e-02f, -1.22871809e-02f, -1.33986264e-01f, -5.65047190e-02f, -7.59532452e-02f,
  4.09217700e-02f, -7.11999610e-02f, -4.88586836e-02f, -3.46773677e-02f, 1.98435839e-02f, -9.01952758e-03f, 1.63093731e-02f, 5.69304004e-02f, -5.38665317e-02f, 1.77196413e-02f,
  -2.11682450e-02f, 7.27942735e-02f, -1.57414719e-01f, -1.15489043e-01f, 5.43954112e-02f, -5.53805232e-02f, -2.37771310e-02f, 1.69064652e-03f, 3.44371349e-02f, -2.24858914e-02f,
  1.22583909e-02f, -7.80354813e-02f, -1.55288149e-02f, -5.38992137e-02f, -9.24642105e-03f, -6.96312487e-02f, -1.08226694e-01f, -1.58801824e-02f, -7.78425438e-03f, -6.48315549e-02f,
  1.15603477e-01f, 7.34959096e-02f, -8.71555507e-03f, -1.14743367e-01f, 1.93382017e-02f, -6.41481057e-02f, -3.30227576e-02f, -9.08289552e-02f, 2.47369427e-02f, -8.69259313e-02f,
  -2.30587609e-02f, -7.73493648e-02f, -2.17560325e-02f, 6.09393157e-02f, -1.20766617e-01f, -5.57159968e-02f, 1.51603073e-01f, 7.67337158e-02f, -6.17585890e-02f, -3.80593650e-02f,
  1.22570194e-01f, 4.25814837e-03f, -3.65880616e-02f, 1.09405369e-01f, -9.52708796e-02f, 1.02694198e-01f, 4.26032674e-03f, -8.89137834e-02f, 8.55456572e-03f, 4.33941977e-03f,
  -1.59173444e-01f, -4.89041716e-01f, 8.02065954e-02f, -9.55966562e-02f, 3.34748328e-02f, -3.82627733e-02f, -1.94541276e-01f, -2.01414883e-01f, -1.93285555e-01f, -5.27745560e-02f,
  -1.90871790e-01f, -2.31719520e-02f, -1.09420717e-01f, -1.28973171e-01f, 2.27129087e-03f, -6.13597184e-02f, 5.35755195e-02f, 1.92774236e-01f, 2.58760184e-01f, 6.22859746e-02f,
  -9.79804546e-02f, -3.30047570e-02f, 4.63406853e-02f, 1.45429894e-02f, -1.96407408e-01f, -5.75277582e-02f, -9.67192724e-02f, -6.52637854e-02f, 4.29630466e-02f, 8.80583078e-02f,
  2.02500433e-01f, -2.05593452e-01f, 5.72485328e-02f, -1.36834368e-01f, -1.31277516e-01f, -1.97921976e-01f, -1.76514611e-02f, -2.05581918e-01f, -1.90088078e-01f, -1.36454254e-01f,
  -1.09373890e-01f, -1.23119198e-01f, -1.49980173e-01f, -1.08825892e-01f, -1.30601674e-01f, -1.17462300e-01f, -1.17982730e-01f, -5.56040555e-02f, -7.07627609e-02f, -2.54204810e-01f,
  -8.83345082e-02f, 8.30468070e-03f, 6.14617281e-02f, -1.42967492e-01f, -1.26792207e-01f, 3.91210541e-02f, -1.37771532e-01f, -9.67587978e-02f, 2.15056017e-02f, -1.16995849e-01f,
  1.75241947e-01f, 5.90643622e-02f, 3.87553833e-02f, 5.78299612e-02f, 8.79049227e-02f, 1.28476515e-01f, 1.49170220e-01f, 1.07791401e-01f, 8.38092119e-02f, 1.79076213e-02f,
  1.30556613e-01f, 1.26846611e-01f, 1.38801690e-02f, 1.24567494e-01f, 1.25493526e-01f, 1.05495684e-01f, 1.81973770e-01f, 4.70318496e-02f, 2.59220630e-01f, 8.58590677e-02f,
  9.59437788e-02f, 2.56664276e-01f, 1.37376919e-01f, 1.60993725e-01f, 1.32376656e-01f, 1.73988476e-01f, 8.16670582e-02f, 2.35695168e-02f, 1.27334595e-02f, 1.27398390e-02f,
  -1.72945887e-01f, -2.00277120e-02f, -1.37626787e-03f, -5.45920692e-02f, -1.43800639e-02f, 2.20789537e-02f, -1.01356275e-01f, -7.49092177e-02f, -1.82354510e-01f, 8.73487536e-03f,
  -1.35231152e-01f, -9.47631374e-02f, -1.07994504e-01f, -1.37798384e-01f, -7.38924369e-03f, -8.43340717e-03f, -1.60635397e-01f, -5.40197715e-02f, -2.47380007e-02f, -8.84333178e-02f,
  -1.81256562e-01f, 5.34440465e-02f, 1.33360878e-01f, 2.57226918e-02f, -4.33297455e-02f, 1.15932383e-01f, -6.71508387e-02f, -4.69285809e-02f, -2.00672392e-02f, 3.62954102e-02f,
  -1.81380242e-01f, 2.48964399e-01f, 1.21939354e-01f, 1.09943643e-01f, 2.19061509e-01f, 6.66390732e-02f, 1.20521046e-01f, -2.85401824e-03f, 5.56810871e-02f, 2.07796901e-01f,
  2.58764267e-01f, 1.37656868e-01f, 2.86990076e-01f, 1.54567808e-01f, -6.48784116e-02f, -3.79124843e-02f, 9.90369078e-03f, -1.12960730e-02f, 1.81933399e-02f, -4.33333702e-02f,
  7.77749810e-03f, -6.42554536e-02f, -2.17935607e-01f, -8.45822692e-02f, 8.01872909e-02f, 1.44695565e-01f, 1.42012835e-01f, -4.16930430e-02f, -4.50539999e-02f, 3.07868198e-02f,
  3.13276380e-01f, -1.52299047e-01f, -1.09606139e-01f, -1.30831733e-01f, -6.99878263e-04f, -1.18029974e-02f, -1.88515894e-02f, -1.52355041e-02f, -1.09750152e-01f, -5.62539436e-02f,
  -1.00290820e-01f, 7.65783340e-03f, 6.18587136e-02f, 6.42150044e-02f, -8.88132453e-02f, -1.62427619e-01f, -6.18996881e-02f, -6.40202612e-02f, -3.63509171e-02f, 1.17317969e-02f,
  -3.07412129e-02f, -4.45581451e-02f, -1.24765420e-02f, -5.70836104e-02f, -3.52128781e-02f, -7.32289255e-02f, -2.18029264e-02f, -4.14601266e-02f, -1.68749064e-01f, -3.08053307e-02f,
  -9.64932814e-02f, 1.38865054e-01f, 1.06131367e-01f, 2.83621904e-02f, -5.19215837e-02f, 2.26095319e-02f, 1.24411099e-03f, 8.25426430e-02f, -9.49966311e-02f, -1.56472344e-02f,
  -9.81259625e-03f, 2.26811599e-02f, 2.07008868e-02f, -3.47200036e-02f, 6.69960901e-02f, 2.12141704e-02f, 1.20375594e-02f, 4.64435965e-02f, -3.12535278e-02f, -2.12622620e-02f,
  -1.68569442e-02f, -1.05598338e-01f, -1.06717749e-02f, -6.55703619e-02f, -3.20150107e-02f, 5.07232472e-02f, 8.86839032e-02f, 5.96619584e-02f, 9.51398443e-03f, -3.68769956e-03f,
  2.47324482e-01f, -6.87088519e-02f, 1.46422246e-02f, -1.56987578e-01f, -5.88458404e-02f, -8.48789886e-02f, 3.40709686e-02f, -1.37371436e-01f, 4.00006771e-02f, -1.08435661e-01f,
  -1.42341554e-01f, 1.82445683e-02f, 5.70836216e-02f, -7.41135702e-02f, -1.02558829e-01f, -3.26463096e-02f, -7.50587434e-02f, -6.88204588e-03f, -9.89234895e-02f, -1.11226708e-01f,
  -1.97494086e-02f, -1.10721208e-01f, 8.93250331e-02f, 2.29614927e-03f, -6.55413494e-02f, -4.23030779e-02f, 4.58835885e-02f, 1.94554087e-02f, -2.46252529e-02f, -1.29815832e-01f,
  1.27243221e-01f, 1.70645490e-01f, 3.00558239e-01f, -5.81977852e-02f, -5.10568768e-02f, 2.28255689e-01f, 2.31535465e-01f, 1.24988571e-01f, -7.91641399e-02f, 1.08312160e-01f,
  -1.58897731e-02f, -1.81473166e-01f, -1.09296188e-01f, 4.95573552e-03f, 1.11987758e-02f, 1.15043752e-01f, 2.98082326e-02f, 9.15096104e-02f, 6.62321746e-02f, -4.44754511e-02f,
  -1.89132243e-01f, -1.73393607e-01f, 6.66644378e-03f, -8.15979391e-03f, -2.21202672e-01f, -1.66073531e-01f, 8.24246332e-02f, -1.14592187e-01f, -4.41172123e-02f, -1.67513117e-01f,
  -1.80236474e-01f, -6.50502294e-02f, -9.62647423e-02f, -1.98889270e-01f, -1.44301742e-01f, -1.61251083e-01f, -4.75731641e-02f, -8.75837579e-02f, -1.70829922e-01f, -1.66313142e-01f,
  -2.15054974e-01f, -1.57821700e-01f, -1.36411980e-01f, -1.06199056e-01f, -2.00230449e-01f, -9.16088149e-02f, -3.63142863e-02f, -8.75176936e-02f, -5.82241528e-02f, -8.57743993e-02f,
  -1.43507957e-01f, -1.55675590e-01f, 6.37023449e-02f, -1.08304940e-01f, -5.34101278e-02f, -1.38866991e-01f, -1.30314484e-01f, -2.30839074e-01f, -1.34458736e-01f, -1.84196159e-01f,
  -3.35117988e-02f, 1.36626139e-01f, 1.13650739e-01f, 1.79975942e-01f, 1.22339211e-01f, 2.49900192e-01f, 1.78118974e-01f, 1.40995428e-01f, 9.50263888e-02f, 1.56171560e-01f,
  1.40875816e-01f, 1.40573874e-01f, 1.46192983e-01f, 1.42027363e-01f, 5.90025038e-02f, 1.32483631e-01f, 1.62863299e-01f, 1.48047119e-01f, 1.10767871e-01f, 1.45064965e-01f,
  1.51605844e-01f, 2.02118471e-01f, 1.34445533e-01f, 7.21910894e-02f, 9.72388312e-02f, 8.42140615e-02f, 4.18178253e-02f, 5.81213161e-02f, 1.09878384e-01f, 7.42345601e-02f,
  -8.49128440e-02f, 7.44346753e-02f, -1.72886610e-01f, -1.62605256e-01f, -1.20887317e-01f, -7.25524575e-02f, -1.81152463e-01f, -8.25095549e-02f, -1.64221972e-01f, -1.19383246e-01f,
  -8.95445645e-02f, -4.96020317e-02f, -9.55261886e-02f, -9.68666002e-02f, -4.40628491e-02f, -1.26579434e-01f, -1.64483607e-01f, -1.21645048e-01f, -5.62419668e-02f, -1.06324129e-01f,
  -1.34302706e-01f, 2.71554068e-02f, 1.44882798e-01f, -1.87958386e-02f, -6.13590553e-02f, 5.72189465e-02f, 6.59977123e-02f, -6.77686417e-03f, 4.11029607e-02f, 4.36722534e-03f,
  -1.94781218e-02f, 1.72957599e-01f, 5.21916449e-01f, -1.17481574e-01f, 1.48981720e-01f, 1.42470524e-01f, 1.08868152e-01f, -3.91228348e-02f, -1.13796219e-01f, -2.67260373e-02f,
  -1.82089239e-01f, -4.41669434e-01f, -2.61735648e-01f, -2.59019941e-01f, -1.27675295e-01f, 1.23351060e-01f, 2.39349350e-01f, 1.21109180e-01f, -8.79073609e-03f, -8.74484479e-02f,
  -7.32788220e-02f, -4.24017943e-02f, 6.47924244e-02f, 6.35028034e-02f, -2.12743375e-02f, -1.57584950e-01f, 2.58835465e-01f, 1.17785566e-01f, 2.35438123e-01f, 8.82277265e-02f,
  1.38403192e-01f, 2.11810410e-01f, -3.72996666e-02f, -1.74361363e-01f, -2.90732039e-03f, 6.92474544e-02f, 1.44470911e-02f, 9.35067758e-02f, 2.00507026e-02f, -3.48183233e-03f,
  -1.93305109e-02f, -2.94167008e-02f, -8.34747627e-02f, -7.76910409e-02f, 4.73977290e-02f, 1.13210536e-03f, 5.08410931e-02f, -3.50954011e-02f, -2.12859549e-02f, 2.90566366e-02f,
  -1.20164320e-01f, 3.74982953e-02f, 7.91283622e-02f, 8.02909881e-02f, 3.09936088e-02f, -2.44025718e-02f, 7.87148401e-02f, 1.05118282e-01f, 1.02885991e-01f, 1.28676504e-01f,
  9.97590646e-02f, 5.81565388e-02f, 5.56334294e-02f, -5.87365068e-02f, -1.11733168e-01f, 4.58861478e-02f, -2.19756085e-02f, 3.37032825e-02f, -7.07979053e-02f, 5.09314127e-02f,
  4.46840860e-02f, 1.02152601e-01f, -3.00503317e-02f, 7.80768320e-02f, 2.00407859e-03f, 5.80817088e-02f, 1.11669421e-01f, 3.56769189e-02f, -4.56120959e-03f, -3.27367112e-02f,
  -5.97224943e-02f, 1.78132877e-02f, -9.77945998e-02f, -8.76465291e-02f, 5.10418862e-02f, 5.17341606e-02f, 6.17675222e-02f, 2.63894293e-02f, -5.30984402e-02f, 1.14033975e-01f,
  -3.84961694e-01f, 7.14447424e-02f, -1.84841767e-01f, -9.55950916e-02f, 4.90672067e-02f, -2.24295370e-02f, -1.38668180e-01f, -5.80738075e-02f, -5.39135002e-02f, -1.59207080e-03f,
  -2.60398053e-02f, -9.84769315e-02f, -4.72301692e-02f, -1.09329216e-01f, -1.85593307e-01f, -1.09858438e-01f, -1.60028994e-01f, -7.59534538e-02f, -6.46468848e-02f, 5.28306365e-02f,
  -6.38897866e-02f, -1.20382030e-02f, -1.09244414e-01f, -1.53647140e-01f, -1.02983281e-01f, -2.25710541e-01f, -1.26234502e-01f, 5.03964163e-02f, -7.41043314e-02f, -2.13691607e-01f,
  2.30837509e-01f, -4.09562886e-01f, -2.25624040e-01f, 2.53867768e-02f, -7.89828375e-02f, -2.38896653e-01f, -2.58534670e-01f, -1.13855690e-01f, -8.97741020e-02f, -2.28106543e-01f,
  -1.11184269e-01f, 1.80345029e-01f, 1.87290147e-01f, 1.80078343e-01f, 8.59104171e-02f, -2.68061042e-01f, -2.40471169e-01f, 8.35653245e-02f, 2.65863866e-01f, 7.56988451e-02f,
  -1.26765696e-02f, 1.04955830e-01f, 7.65506327e-02f, 1.14589864e-02f, -1.84747532e-01f, -1.35046495e-02f, -1.16330601e-01f, -1.52674258e-01f, -1.57621980e-01f, -2.79317051e-01f,
  -1.67299822e-01f, -2.75579572e-01f, 5.80553003e-02f, 6.45240769e-02f, 2.18498558e-02f, -7.37499679e-03f, 1.89318601e-02f, -4.06049713e-02f, -8.76135007e-02f, -1.44439712e-01f,
  -8.29369947e-02f, 3.35975476e-02f, 2.74023097e-02f, -1.77114306e-03f, -5.76820113e-02f, -3.46949138e-02f, 4.49754996e-03f, 1.19404225e-02f, 2.46167928e-02f, -1.77183688e-01f,
  -1.01135917e-01f, -1.37308508e-01f, -8.00339878e-03f, -7.00532347e-02f, -7.83849061e-02f, -2.90638357e-02f, -8.71789455e-02f, -1.78542182e-01f, -4.64767702e-02f, -9.04182270e-02f,
  1.40347317e-01f, -1.10125840e-02f, 1.48752145e-03f, -5.11833578e-02f, 6.82434738e-02f, -2.56372504e-02f, -2.69575678e-02f, 3.96470819e-03f, 5.90994880e-02f, -5.91834746e-02f,
  9.73937847e-03f, -2.39609089e-03f, 1.98402610e-02f, -3.13684195e-02f, -4.50018495e-02f, 1.06155872e-02f, -9.17112306e-02f, -5.89898676e-02f, 2.78368476e-03f, -1.09181218e-01f,
  9.29813012e-02f, -4.71965373e-02f, 5.40675968e-03f, 2.02907305e-02f, 2.06317063e-02f, -6.58171810e-03f, 6.06222264e-02f, 2.94076595e-02f, 5.68808615e-02f, -1.03150398e-01f,
  1.81698054e-01f, 1.69623524e-01f, -3.23142484e-02f, -3.96868661e-02f, -1.41126871e-01f, 2.60843560e-02f, -3.68966088e-02f, -1.10385805e-01f, -3.40729430e-02f, -4.15286161e-02f,
  -1.13271877e-01f, -5.05157327e-03f, 9.59035661e-03f, -8.29331055e-02f, -7.12239789e-03f, -5.82239553e-02f, -2.46696044e-02f, -1.43060535e-02f, -1.16323810e-02f, -8.78650472e-02f,
  -1.10883333e-01f, -8.26678723e-02f, -2.40262318e-02f, -3.29634100e-02f, -7.55610391e-02f, 7.83845931e-02f, 6.00882689e-04f, -8.06102622e-03f, 8.28662515e-02f, 6.24524355e-02f,
  -2.32059937e-02f, -2.02523321e-01f, 1.43851131e-01f, -3.35508734e-01f, -1.68173045e-01f, 1.61159456e-01f, 9.68148932e-02f, 1.62905812e-01f, -2.19361112e-01f, -2.99635321e-01f,
  -2.96817452e-01f, -1.43936858e-01f, -2.08224788e-01f, 1.00768954e-01f, 2.38152221e-01f, -1.16952933e-01f, -3.26191448e-02f, 2.35352486e-01f, 3.30456764e-01f, 2.34963790e-01f,
  -6.06076829e-02f, -1.31445989e-01f, 6.77622482e-02f, 6.55860081e-03f, -1.49227932e-01f, -1.39912441e-01f, -2.18192965e-01f, -1.91539079e-01f, -1.00210406e-01f, -1.95325464e-01f,
  2.76813153e-02f, 1.48520008e-01f, 7.17280731e-02f, -1.65045261e-01f, -1.83682188e-01f, -5.62686808e-02f, 1.54200080e-03f, -2.53255889e-02f, -2.54365020e-02f, -9.31985825e-02f,
  -2.04313889e-01f, 1.51361646e-02f, -9.05423388e-02f, -1.30660203e-03f, -7.91217294e-03f, -5.45708835e-02f, -6.11868836e-02f, 1.10278234e-01f, 3.82907800e-02f, 7.95504004e-02f,
  -1.90726593e-01f, -8.43418017e-02f, 1.93419680e-02f, 3.44585329e-02f, 5.60183227e-02f, 2.10956251e-03f, 8.48347545e-02f, 1.45290717e-01f, 1.68671049e-02f, -3.97373810e-02f,
  -9.60291736e-03f, -5.72195612e-02f, 3.62584889e-02f, 9.08371806e-03f, 4.91274484e-02f, -2.69283615e-02f, -6.24600835e-02f, 5.67077883e-02f, -6.18882850e-03f, -1.30149424e-02f,
  -2.70173270e-02f, 9.34220850e-03f, 8.48055333e-02f, -6.80638477e-02f, -7.93371201e-02f, -8.30162223e-03f, -2.00628880e-02f, 2.68574115e-02f, 7.06504658e-02f, -3.24480198e-02f,
  7.68851396e-03f, 7.78870359e-02f, -9.15395170e-02f, 9.88687500e-02f, -1.02256984e-03f, 3.56470756e-02f, 5.90818152e-02f, -1.63221708e-03f, -5.08217737e-02f, -5.84797151e-02f,
  -2.57106483e-01f, 1.32281795e-01f, -1.76832173e-02f, 1.29067704e-01f, -8.05481896e-02f, 2.63989512e-02f, -6.64424375e-02f, -7.17635453e-03f, -8.78726840e-02f, 4.87982891e-02f,
  6.12182617e-02f, 1.37181416e-01f, -6.30924106e-02f, -2.09812876e-02f, 2.12699175e-03f, -2.38113888e-02f, -1.43699020e-01f, -2.48546642e-03f, -2.70023998e-02f, -1.73268002e-02f,
  -7.20974803e-02f, 4.32904102e-02f, -8.86130482e-02f, -9.46318582e-02f, 4.03771140e-02f, 7.52036134e-03f, 2.40918435e-03f, 4.36663143e-02f, 8.95019993e-02f, -2.53371060e-01f,
  6.09488070e-01f, 1.38563579e-02f, 1.73923343e-01f, 4.65562269e-02f, -1.71071172e-01f, -2.34892458e-01f, -2.98944652e-01f, -2.56112386e-02f, 5.96330948e-02f, 5.66751696e-03f,
  5.67928441e-02f, 1.52970225e-01f, 1.72241449e-01f, 1.18753016e-01f, 1.37141123e-01f, 7.25998804e-02f, 1.31224811e-01f, 3.48587275e-01f, 1.18097074e-01f, -8.54412317e-02f,
  -1.30905673e-01f, 8.39481205e-02f, 1.87442899e-01f, 7.15477690e-02f, -9.23126936e-02f, -5.13728149e-02f, 4.19838466e-02f, -3.59962881e-02f, 3.09246071e-02f, -7.21082976e-03f,
  5.65305017e-02f, 1.82121232e-01f, 1.94532737e-01f, 2.77276039e-01f, 1.33016154e-01f, 1.20706722e-01f, 1.45046890e-01f, 9.08754617e-02f, 1.87290266e-01f, 1.53737282e-02f,
  1.19954675e-01f, 2.08777547e-01f, 1.03844792e-01f, 3.18489708e-02f, 6.99567199e-02f, 7.53503665e-02f, 8.66214558e-02f, 1.44007564e-01f, 5.41909933e-02f, 1.28216267e-01f,
  8.60605389e-02f, 2.70171985e-02f, 1.47617176e-01f, 8.03638920e-02f, 1.41992703e-01f, 2.43299261e-01f, 5.93730770e-02f, 1.31786734e-01f, 2.02297658e-01f, 1.21610560e-01f,
  -8.92137289e-02f, -8.69040042e-02f, -1.38751656e-01f, -1.19018078e-01f, -1.82796791e-01f, -2.04517350e-01f, -1.11558788e-01f, -1.46431834e-01f, -1.14177145e-01f, -9.71018523e-02f,
  -1.17895029e-01f, -1.36791214e-01f, -1.29810244e-01f, -6.26089275e-02f, -1.12639539e-01f, -7.22591802e-02f, -1.44620776e-01f, -5.38247116e-02f, -1.31048664e-01f, -1.39872536e-01f,
  -4.20793332e-02f, -1.58011690e-01f, -9.38979313e-02f, -5.13590127e-02f, -1.04181319e-01f, -8.86694863e-02f, -7.95379356e-02f, -8.44199732e-02f, -1.14250712e-01f, -1.76764891e-01f,
  1.67070124e-02f, 3.31933409e-01f, 7.23895058e-02f, 1.01268128e-01f, 1.04737632e-01f, 1.23698570e-01f, 1.58374876e-01f, 1.77371681e-01f, 1.42298922e-01f, 1.28605634e-01f,
  3.64388302e-02f, 1.96468011e-01f, 1.45737439e-01f, 1.11694865e-01f, 1.32347330e-01f, 1.53164312e-01f, 5.53831086e-02f, 9.93176326e-02f, 4.47820798e-02f, 5.76138273e-02f,
  8.61574262e-02f, 1.18243739e-01f, 7.21322820e-02f, -2.61363070e-02f, 2.90463157e-02f, 1.85552806e-01f, 3.59533262e-03f, -1.34497853e-02f, 1.23047829e-01f, 6.27580732e-02f,
  -1.44874498e-01f, 2.57965237e-01f, 2.03734770e-01f, -1.05237057e-02f, 2.00887963e-01f, 2.77523488e-01f, 3.51500034e-01f, 5.90572134e-02f, 2.05945950e-02f, 2.43685246e-01f,
  1.89893574e-01f, 6.44185115e-03f, -5.36400005e-02f, -2.94446945e-02f, 4.52761017e-02f, 2.46658847e-01f, 1.74558893e-01f, -1.09092310e-01f, -5.51223978e-02f, 1.61595479e-01f,
  3.98360454e-02f, -1.78840891e-01f, -1.03314869e-01f, -1.65129393e-01f, -3.58347744e-02f, -1.53914288e-01f, 8.04865509e-02f, 7.24992454e-02f, 1.89812273e-01f, 3.52692194e-02f,
  1.05413020e-01f, 9.37973931e-02f, -2.61272967e-01f, -1.60244972e-01f, -2.14089394e-01f, -2.03734785e-01f, -1.52457148e-01f, -2.37795010e-01f, -6.28695711e-02f, -7.97719881e-02f,
  -7.14644343e-02f, -1.52644500e-01f, -1.11582533e-01f, -5.99611029e-02f, -5.70300519e-02f, -7.49697536e-02f, -9.99735817e-02f, -6.67842478e-02f, -1.29499346e-01f, -7.30809271e-02f,
  -4.57180180e-02f, 7.91369006e-02f, -1.61975354e-01f, -6.48951083e-02f, -2.23223902e-02f, -8.10129344e-02f, -1.22859009e-01f, -2.00020634e-02f, -1.67678207e-01f, -2.04111576e-01f,
  2.78812125e-02f, 6.50091246e-02f, 8.65556002e-02f, 1.06011510e-01f, 7.15979040e-02f, 1.20805018e-01f, 4.64602374e-02f, 1.34585455e-01f, 8.29213932e-02f, -3.69266607e-02f,
  2.08775192e-01f, 1.42292529e-01f, 1.57881513e-01f, 1.01307735e-01f, 1.66458279e-01f, 1.57411665e-01f, 1.33606419e-01f, 1.42365277e-01f, 4.59477790e-02f, 8.78401846e-02f,
  1.46529660e-01f, 1.00176260e-01f, 1.00628182e-01f, 7.37621114e-02f, 2.70741850e-01f, 1.21507168e-01f, 1.21477120e-01f, 1.93481162e-01f, 6.95025250e-02f, 2.06636488e-01f,
  -4.17859405e-01f, -1.95945293e-01f, -1.03145540e-01f, -1.60744146e-01f, -1.32198051e-01f, -1.33433804e-01f, -1.03274278e-01f, -2.40847021e-01f, -1.95623994e-01f, -1.25475958e-01f,
  -2.69171037e-02f, -1.30223185e-01f, -6.26952574e-02f, -1.93224922e-01f, -1.48342460e-01f, -6.47831112e-02f, -1.95486888e-01f, -1.55687287e-01f, -1.02624305e-01f, -1.55330911e-01f,
  -1.68334562e-02f, -8.97208527e-02f, -2.70969272e-01f, -1.94581300e-01f, -1.47030249e-01f, -2.74511188e-01f, -2.26797670e-01f, -1.44701928e-01f, -2.40450397e-01f, -1.34940594e-01f,
  -1.48197815e-01f, -3.52799743e-01f, -1.82925820e-01f, -1.57636963e-02f, -1.40785873e-01f, -3.30458969e-01f, -4.50970531e-01f, -2.67576575e-01f, -2.69209705e-02f, -1.83078527e-01f,
  -5.84069900e-02f, 2.55957633e-01f, 1.50216237e-01f, 2.86346227e-01f, 3.09576988e-02f, -1.47854775e-01f, -4.40454744e-02f, 2.72119105e-01f, 1.09831266e-01f, -2.72080563e-02f,
  3.81859988e-02f, 1.77706443e-02f, 1.75914958e-01f, 1.88559324e-01f, 1.60204440e-01f, 2.26629496e-01f, -6.16860855e-03f, 6.41754195e-02f, -4.21502888e-02f, 1.92341179e-01f,
  -3.82074602e-02f, -1.74755052e-01f, 6.48060888e-02f, 9.80851874e-02f, 3.88896354e-02f, -2.48934552e-02f, 1.04271285e-02f, 4.16733418e-03f, 1.36902239e-02f, 7.07340389e-02f,
  1.15136430e-01f, 7.74807259e-02f, 1.07333787e-01f, 7.93663785e-03f, -6.04910515e-02f, -2.01391410e-02f, 6.18732302e-03f, 8.54861140e-02f, 9.68284383e-02f, 8.75682477e-03f,
  6.71527460e-02f, -7.96903595e-02f, -1.77406058e-01f, -1.31651759e-01f, 8.10914710e-02f, 1.12272821e-01f, -1.10990241e-01f, 3.31852511e-02f, -5.69891371e-02f, -1.20557554e-01f,
  1.05450869e-01f, -3.55141833e-02f, 2.06582230e-02f, 6.31562714e-03f, -4.75699306e-02f, 4.88285497e-02f, 2.44576354e-02f, 5.96056459e-03f, 3.60438004e-02f, -5.73166013e-02f,
  2.55303439e-02f, -2.68159676e-02f, -4.75883298e-02f, -5.86229004e-02f, 1.83846168e-02f, -8.28408673e-02f, -2.15284135e-02f, 2.01073778e-03f, 1.16937971e-02f, -2.48315856e-02f,
  1.08468374e-02f, 7.66496547e-03f, 3.29654403e-02f, 8.65561515e-02f, -7.88778886e-02f, 8.03656727e-02f, -1.41307088e-02f, -5.15485555e-02f, 2.62422301e-02f, -4.32514511e-02f,
  -2.44496718e-01f, 4.95079048e-02f, 6.69343546e-02f, 6.34172335e-02f, -3.41392644e-02f, 1.51888095e-02f, 3.22139487e-02f, 9.29007754e-02f, 3.16863470e-02f, -1.26662301e-02f,
  2.24159639e-02f, -7.50658587e-02f, -9.23335627e-02f, 1.84667557e-02f, -1.56279206e-02f, -6.39625937e-02f, -1.98967531e-02f, -1.11320047e-02f, 2.38025952e-02f, -8.62631723e-02f,
  -5.70573611e-03f, -1.41969949e-01f, -1.36358336e-01f, -4.58659604e-02f, -8.65624845e-02f, 6.23781718e-02f, -5.98597936e-02f, -4.47378680e-02f, -1.28551811e-01f, -1.73186019e-01f,
  4.88330305e-01f, 4.54491265e-02f, 8.66806414e-03f, 3.43063027e-01f, -1.08342536e-01f, -3.58798921e-01f, -3.88681501e-01f, -2.02302381e-01f, 1.32865742e-01f, -3.20670791e-02f,
  8.18281770e-02f, 1.17226481e-01f, 4.80597131e-02f, -1.28111586e-01f, -2.40410954e-01f, -1.88561797e-01f, -6.93683028e-02f, 3.82919982e-02f, -2.54481465e-01f, -2.23665357e-01f,
  -6.70836121e-02f, 1.29935429e-01f, 8.72442052e-02f, 8.91921967e-02f, 1.09999776e-01f, 3.86572666e-02f, 1.92274541e-01f, 7.47160837e-02f, -6.92086443e-02f, 2.66375184e-01f,
  8.73812847e-03f, 2.45411143e-01f, -1.70861930e-02f, 7.00645521e-02f, -9.35039204e-03f, 5.08709587e-02f, 3.03928088e-03f, 1.15830392e-01f, -6.61056815e-03f, 1.00748077e-01f,
  2.02761255e-02f, 2.89574564e-02f, 1.37748331e-01f, 2.31191535e-02f, -1.32040447e-02f, -3.78425531e-02f, 4.95529035e-03f, 5.36178574e-02f, 6.07484169e-02f, 3.68461460e-02f,
  -2.41691992e-02f, 7.58295367e-03f, 6.12618439e-02f, -1.30899400e-01f, 3.84887122e-03f, 6.06099479e-02f, -3.36197913e-02f, -2.40905420e-03f, -4.18541133e-02f, 7.83503652e-02f,
  -5.43552749e-02f, 6.03124034e-03f, -1.02962986e-01f, 5.70927374e-02f, -8.19693431e-02f, 3.05028800e-02f, 7.34991059e-02f, 1.73043888e-02f, -1.55642956e-01f, 2.31618136e-02f,
  7.37652788e-03f, -1.55820586e-02f, -1.29322372e-02f, 5.28729893e-02f, -3.32723372e-02f, 1.98602360e-02f, -3.91045175e-02f, -4.68520969e-02f, 7.73314685e-02f, 1.92305679e-03f,
  3.72724012e-02f, 4.74657565e-02f, 1.22080781e-02f, -8.70377347e-02f, 3.56304459e-02f, 4.61298712e-02f, 1.81710646e-02f, -5.36740795e-02f, -6.90536648e-02f, 6.20388538e-02f,
  -1.28887385e-01f, -1.32583067e-01f, 6.03024103e-03f, 2.70379111e-02f, 8.84136856e-02f, 6.36493489e-02f, 2.50994153e-02f, 5.53751662e-02f, 1.20953478e-01f, -4.41067554e-02f,
  -1.77117325e-02f, -1.46223968e-02f, -1.84648018e-02f, -4.32597212e-02f, -8.40980262e-02f, -3.09518892e-02f, 1.01834469e-01f, 1.80497840e-02f, 1.07726327e-03f, -3.57319578e-03f,
  -4.22959775e-02f, -5.37182689e-02f, -9.55882370e-02f, -8.91777873e-02f, -7.05344379e-02f, -3.84205393e-02f, -1.18242420e-01f, -2.01093256e-01f, -7.79057816e-02f, -8.26799423e-02f,
  7.94780329e-02f, 1.60032902e-02f, -1.45584300e-01f, 9.88752022e-02f, -1.78454250e-01f, -1.79390669e-01f, -4.43947986e-02f, 5.71950190e-02f, 1.38846517e-01f, 1.24380812e-01f,
  -1.98697165e-01f, -2.83221751e-01f, -8.52228031e-02f, -1.19159542e-01f, -2.10396498e-02f, 1.18999451e-01f, 1.05095960e-01f, 2.52109347e-03f, -4.69064415e-02f, 1.57265570e-02f,
  1.12237714e-01f, 1.32990614e-01f, 1.24364704e-01f, 7.26976097e-02f, 1.10783570e-01f, -7.08527416e-02f, 1.05688214e-01f, 1.35516509e-01f, 2.48600859e-02f, 1.79115057e-01f,
  -3.47718596e-02f, -1.25640869e-01f, 7.38067701e-02f, -8.60294849e-02f, -1.46882117e-01f, 8.22125450e-02f, -3.45057286e-02f, 8.11944306e-02f, -6.77056611e-02f, 1.17606990e-01f,
  2.92586647e-02f, 7.05004483e-02f, -7.89410695e-02f, 4.23345082e-02f, 2.50341389e-02f, 2.41585821e-02f, 1.52387887e-01f, 1.43759787e-01f, 1.13278426e-01f, 1.01505741e-01f,
  -3.25699784e-02f, -1.48184982e-03f, -6.87113702e-02f, -1.77102126e-02f, 1.59301218e-02f, -1.20966777e-01f, -3.97225469e-02f, -7.56175518e-02f, 5.07780835e-02f, 1.98135018e-01f,
  5.67574687e-02f, -5.22054955e-02f, -8.71170126e-03f, 8.88197497e-02f, 4.22652662e-02f, -1.17841333e-01f, 3.52856778e-02f, 3.58529389e-02f, 4.74426039e-02f, 9.03260112e-02f,
  -5.80672584e-02f, 3.32840048e-02f, 4.37228940e-02f, -3.92151028e-02f, 6.79875016e-02f, 8.50727707e-02f, -7.84750879e-02f, 5.28967083e-02f, 1.05694175e-01f, -1.79852303e-02f,
  -8.84354413e-02f, 1.08340904e-02f, 1.07354864e-01f, -4.23989408e-02f, 1.23514058e-02f, -2.49125175e-02f, 8.54672492e-03f, -9.78110805e-02f, -3.06634698e-02f, 1.01923585e-01f,
  7.13618547e-02f, -1.84086084e-01f, 4.80510592e-02f, 3.14596109e-03f, 6.39373884e-02f, -4.25454229e-02f, -3.55576202e-02f, 5.06154448e-02f, -9.62153971e-02f, -6.12307526e-03f,
  -8.66611600e-02f, -1.85514893e-02f, 5.37910797e-02f, -1.05984882e-02f, 8.19682404e-02f, 1.38180003e-01f, 1.36034787e-01f, 1.62370466e-02f, 4.43817563e-02f, 3.38065773e-02f,
  7.94662237e-02f, 8.34305733e-02f, -1.10232346e-01f, 7.60622462e-03f, -6.85833097e-02f, -3.19312476e-02f, 1.39263468e-02f, 9.86397415e-02f, -8.22848603e-02f, 2.67205954e-01f,
  -1.53324325e-02f, -3.82199496e-01f, 6.06410801e-02f, 1.73669830e-02f, 1.14996366e-01f, 1.20709399e-02f, -1.60970554e-01f, -4.48704511e-02f, 2.36178972e-02f, -4.25153039e-02f,
  1.54342309e-01f, 1.80046052e-01f, 1.39754772e-01f, 1.93979919e-01f, -2.71488614e-02f, -4.23234552e-02f, -9.14815161e-03f, 5.63496426e-02f, 1.32222205e-01f, 4.40561473e-02f,
  4.22182307e-03f, -1.16269626e-01f, 5.02392538e-02f, 7.92672932e-02f, -3.57516073e-02f, -3.23305093e-03f, -5.62507324e-02f, -3.42650786e-02f, 4.43533249e-02f, -1.32198319e-01f,
  8.71802419e-02f, -1.65603220e-01f, 1.80059910e-01f, 7.55887628e-02f, 4.01181430e-02f, -5.28651522e-03f, -6.01306446e-02f, -7.89364148e-03f, 2.73939855e-02f, -5.94476201e-02f,
  -3.67268845e-02f, -3.37126143e-02f, -1.34947905e-02f, -7.39430950e-04f, 1.54141989e-02f, 2.98150051e-02f, -5.00532761e-02f, 4.38869605e-03f, 2.31656302e-02f, -1.04617812e-01f,
  3.97849679e-02f, 2.88273338e-02f, 6.99424893e-02f, -5.40495180e-02f, 1.84423681e-02f, 6.72083572e-02f, 4.70084604e-03f, -1.57648753e-02f, -6.60733320e-03f, -1.07077397e-01f,
  -3.74271832e-02f, 9.37485993e-02f, 2.00817827e-02f, 5.45162596e-02f, 5.54146105e-03f, 1.69658773e-02f, 2.32675597e-02f, -3.85517739e-02f, 3.03236395e-02f, -4.68826443e-02f,
  -6.34757951e-02f, -5.87291457e-03f, 8.00952613e-02f, -5.04165180e-02f, 6.11970611e-02f, -4.09771577e-02f, 3.07495836e-02f, -6.32088780e-02f, 1.03016570e-02f, 2.92222425e-02f,
  8.70885625e-02f, -2.89932024e-02f, -6.53605908e-02f, -4.25998904e-02f, -5.91675825e-02f, -7.14846477e-02f, 3.98965031e-02f, -5.74309267e-02f, -6.58692867e-02f, 3.93905900e-02f,
  2.51835674e-01f, 1.60695404e-01f, 1.40603468e-01f, -4.31555547e-02f, -6.01823330e-02f, -3.05640586e-02f, 4.26096767e-02f, 7.34336153e-02f, 7.80853331e-02f, 8.28789696e-02f,
  -4.76248525e-02f, -4.84130755e-02f, -4.43858057e-02f, -3.17435451e-02f, 5.77535853e-02f, 9.55406949e-02f, 1.73573978e-02f, 2.05712523e-02f, 1.07217990e-01f, 4.54483368e-02f,
  9.19714570e-02f, 8.24818760e-02f, 6.95308521e-02f, 2.31769402e-02f, -2.02860665e-02f, 9.34233069e-02f, 4.23904182e-03f, 1.52480170e-01f, 5.03947474e-02f, 1.15017854e-01f,
  -1.35330120e-02f, 2.61500090e-01f, 4.56509233e-01f, -1.12190686e-01f, -1.07220195e-01f, 1.29606575e-01f, 9.20687392e-02f, -5.53520210e-03f, -5.73555008e-02f, 6.57705441e-02f,
  -8.06077123e-02f, -2.76226163e-01f, -8.68521854e-02f, -3.62186506e-02f, -6.18893988e-02f, 2.18675032e-01f, 1.67615980e-01f, 2.08010152e-02f, -1.30471244e-01f, -2.13155411e-02f,
  -1.51510775e-01f, -1.45248309e-01f, -2.10611969e-02f, -9.42057893e-02f, -1.89431999e-02f, -1.90557003e-01f, 8.05100426e-02f, -9.49405506e-02f, 1.51855558e-01f, 4.18589115e-02f,
  3.52508426e-01f, 1.62197262e-01f, 4.38044220e-02f, -6.93901330e-02f, 1.35082722e-01f, 1.74290285e-01f, 1.15860991e-01f, 6.91490695e-02f, 1.03327289e-01f, 1.22329406e-01f,
  -1.58755411e-03f, -5.62617322e-04f, 7.78961033e-02f, 3.90707329e-02f, 1.35582373e-01f, 4.11736108e-02f, 1.34147078e-01f, 1.63077354e-01f, 1.86687812e-01f, 2.05806404e-01f,
  -2.57290881e-02f, -9.18972585e-03f, 6.95113912e-02f, 8.69019181e-02f, 1.26812026e-01f, -2.27906220e-02f, 4.83768247e-02f, 1.16279326e-01f, 9.90888700e-02f, 1.96224883e-01f,
  3.46833915e-02f, 1.11891836e-01f, 1.66693628e-02f, 2.30622329e-02f, -3.63220945e-02f, -1.39212504e-01f, -1.57005429e-01f, -1.17220215e-01f, -6.09147139e-02f, 3.35758878e-03f,
  -4.41687480e-02f, 4.68094237e-02f, -3.64517421e-02f, -6.52366206e-02f, -5.01836203e-02f, -3.69267426e-02f, -8.65298435e-02f, -3.02168969e-02f, -5.35619780e-02f, 1.29233841e-02f,
  -8.93754959e-02f, -1.04698919e-01f, -1.55935092e-02f, -1.89873539e-02f, 6.78107738e-02f, -1.03973523e-01f, 3.58629674e-02f, -2.33220439e-02f, -1.18856475e-01f, -1.09721780e-01f,
  -1.75594494e-01f, 8.89009535e-02f, 2.36009538e-01f, 3.18429470e-02f, 6.56505153e-02f, 2.40111630e-02f, 8.79587233e-02f, 1.92964092e-01f, 1.81086473e-02f, 1.59452289e-01f,
  -4.31191809e-02f, 7.67598450e-02f, 7.73542896e-02f, 1.03538163e-01f, 7.36890957e-02f, 8.79824534e-02f, 1.78674415e-01f, 6.74220547e-02f, 1.25438303e-01f, 1.30925030e-01f,
  8.09976906e-02f, 5.94072342e-02f, 1.06196567e-01f, 7.53029361e-02f, 1.08763322e-01f, -6.17358312e-02f, 4.71415184e-02f, 4.74359952e-02f, 1.80795819e-01f, 1.91872895e-01f,
  1.63093418e-01f, -2.94931531e-01f, -1.52299717e-01f, -1.15888165e-02f, -4.62802909e-02f, -1.42039523e-01f, -1.36748314e-01f, -4.61702421e-02f, -7.32708275e-02f, -2.45946273e-01f,
  -2.32896551e-01f, -5.59784919e-02f, -6.91000894e-02f, 7.52924755e-02f, 1.36275202e-01f, -2.36581564e-02f, 1.06636267e-02f, 1.95343941e-01f, 2.40978122e-01f, 1.33104220e-01f,
  5.47162853e-02f, 1.79529950e-01f, 1.91758096e-01f, -1.29049178e-02f, -1.30730361e-01f, -1.04971424e-01f, -9.56277922e-02f, 4.66284305e-02f, -1.28217444e-01f, -1.30776260e-02f,
  -1.89139798e-01f, -1.32814735e-01f, 4.35780920e-02f, -5.19809350e-02f, -1.29912540e-01f, -1.35134816e-01f, -7.44886277e-03f, -1.25483379e-01f, -1.55548915e-01f, -1.59888454e-02f,
  -2.04652492e-02f, -1.56257600e-01f, -3.93069834e-02f, -1.43535465e-01f, -3.89135927e-02f, -1.01385899e-01f, -1.44334752e-02f, 1.38323437e-02f, -1.38623267e-01f, -2.15521395e-01f,
  -1.46626681e-01f, 3.70854847e-02f, -9.50603187e-02f, -1.46523654e-01f, -1.81474537e-01f, 2.84343809e-02f, -1.78342313e-01f, -1.05337389e-01f, -1.53808102e-01f, -1.22117490e-01f,
  1.75060689e-01f, 6.29496723e-02f, 4.98577720e-03f, 4.77653518e-02f, 1.10351548e-01f, -6.60766512e-02f, 8.52078721e-02f, 1.10568665e-01f, 1.30858809e-01f, 4.93456284e-03f,
  -4.78086993e-03f, 8.74328166e-02f, 3.21388468e-02f, 1.47563498e-02f, 8.45894068e-02f, 1.15233712e-01f, 1.96461808e-02f, 1.16507217e-01f, 3.68068516e-02f, 6.24584854e-02f,
  9.24851149e-02f, 7.58475214e-02f, 1.24752417e-01f, -2.42084288e-03f, 1.02540791e-01f, 5.48994802e-02f, 1.20964870e-01f, 3.00929453e-02f, 9.63186771e-02f, 6.85123801e-02f,
  -9.51489061e-02f, 6.24115914e-02f, -1.16552971e-01f, -5.60649298e-02f, -8.23628157e-02f, -1.36776000e-01f, -1.54425010e-01f, -4.60587740e-02f, -1.44846037e-01f, -6.10575937e-02f,
  -1.44373477e-01f, -2.53232308e-02f, -1.14507593e-01f, -7.39915296e-02f, -5.82027882e-02f, -8.58808681e-02f, -8.61079544e-02f, -7.63051659e-02f, -5.88867478e-02f, -1.56247750e-01f,
  -1.68247491e-01f, -5.04153334e-02f, -7.68276751e-02f, -1.53134555e-01f, -5.21551184e-02f, -5.02402075e-02f, -1.57492444e-01f, -2.16507867e-01f, -2.35539153e-02f, -2.74887890e-01f,
  9.71677974e-02f, 8.93909186e-02f, 2.02425286e-01f, 4.12002712e-01f, 2.86973447e-01f, 1.30169690e-01f, 8.74240547e-02f, 1.53275073e-01f, 1.15562923e-01f, 2.05101982e-01f,
  1.70199782e-01f, 2.89278954e-01f, 1.77920610e-01f, 2.43101969e-01f, 2.21910745e-01f, 1.17391199e-01f, 2.16800213e-01f, 1.50101393e-01f, 1.65218711e-01f, 3.20806891e-01f,
  3.49705338e-01f, 3.70066911e-01f, 3.30538601e-01f, 3.15306515e-01f, 2.07000703e-01f, 3.10092181e-01f, 2.93628275e-01f, 2.41627812e-01f, 2.56074041e-01f, 3.92744333e-01f,
  3.80919613e-02f, -3.47935036e-02f, 5.30569516e-02f, 1.56970963e-01f, 2.16322869e-01f, 1.19028622e-02f, 8.00383911e-02f, 4.28947359e-02f, 3.83291468e-02f, 1.75238639e-01f,
  1.81089029e-01f, 2.08567232e-01f, 2.00062543e-01f, 9.34013054e-02f, 1.27506644e-01f, 9.31854993e-02f, 1.13500908e-01f, 1.16791211e-01f, 9.71248895e-02f, 9.72774476e-02f,
  1.43953830e-01f, 1.19421504e-01f, 1.36227533e-01f, 1.34308189e-02f, 9.50312391e-02f, 5.78240417e-02f, 8.53951797e-02f, 2.97846440e-02f, 1.57948390e-01f, 7.22326785e-02f,
  -2.33998857e-02f, -1.78647280e-01f, -1.46021694e-02f, -7.77935833e-02f, -1.03288919e-01f, -8.79951715e-02f, -8.99352320e-03f, -8.61387420e-03f, -1.80892169e-01f, -9.62404236e-02f,
  -4.98601757e-02f, -8.63527358e-02f, -1.52926724e-02f, -2.17730440e-02f, -3.32149267e-02f, -3.74645665e-02f, -1.27958283e-02f, -1.52370483e-01f, -8.84916335e-02f, -2.84984298e-02f,
  -1.24070771e-01f, -7.12730139e-02f, -7.57740140e-02f, -8.97043198e-02f, -1.51028810e-02f, 1.79681052e-02f, -4.47154827e-02f, -1.26536459e-01f, -1.48046240e-01f, -1.55125022e-01f,
  1.16216555e-01f, 5.04512638e-02f, 7.44987652e-02f, 4.65289615e-02f, 3.06073464e-02f, 6.05086759e-02f, 4.99167256e-02f, 8.91458243e-02f, 4.85340431e-02f, 1.02581717e-01f,
  -4.83615976e-03f, 3.18903215e-02f, 1.02676228e-01f, 1.00131728e-01f, 1.86428294e-01f, 9.31636244e-02f, 7.36926943e-02f, 2.09414735e-01f, 1.43845946e-01f, 8.01533982e-02f,
  7.80772716e-02f, 5.03290957e-03f, -4.88316156e-02f, -1.39873298e-02f, 5.43743856e-02f, 2.01097261e-02f, 7.33804926e-02f, 4.00959663e-02f, -2.14305036e-02f, 9.57777202e-02f,
  3.24927866e-01f, -1.70505121e-01f, 4.39568888e-03f, -2.78845371e-04f, 7.17137083e-02f, 2.67285466e-01f, 3.90304983e-01f, 1.96320757e-01f, 4.62010168e-02f, -1.06254004e-01f,
  -1.81553394e-01f, -2.17805222e-01f, -1.54467657e-01f, -8.04153755e-02f, 1.82221219e-01f, 1.25126317e-01f, 4.85327952e-02f, 1.10088803e-01f, 1.38084814e-01f, 1.57009035e-01f,
  7.87069276e-02f, -6.95440099e-02f, 3.94069739e-02f, -4.98627834e-02f, -1.36088327e-01f, -9.52962264e-02f, -2.43330881e-01f, -2.00740337e-01f, 2.39080787e-02f, -1.98886096e-01f,
  -2.44401902e-01f, -1.61329225e-01f, 2.02999655e-02f, -7.19606057e-02f, -9.72226039e-02f, -3.25306393e-02f, 3.86512764e-02f, -1.87804326e-01f, -4.50427346e-02f, -9.91327241e-02f,
  -3.91899869e-02f, -4.52548154e-02f, -7.63767809e-02f, -2.87600718e-02f, -3.68889794e-02f, -5.80270961e-02f, -3.36932130e-02f, -5.78064881e-02f, 3.33171263e-02f, -1.37093022e-01f,
  -1.29316032e-01f, 3.04547437e-02f, 1.84438117e-02f, 7.93066844e-02f, 2.61499956e-02f, -1.56498775e-02f, -1.04893297e-01f, -1.08882234e-01f, 5.98982647e-02f, -3.40906419e-02f,
  -2.43478678e-02f, -1.98566038e-02f, 6.14945553e-02f, 2.99652964e-02f, 3.13132741e-02f, -3.80915701e-02f, 3.13178971e-02f, -1.47288935e-02f, 3.72310989e-02f, -1.31055191e-01f,
  -7.69301737e-03f, 9.81205050e-03f, 9.16373134e-02f, 9.62322392e-03f, -6.82552308e-02f, 1.19365333e-02f, 1.33339241e-01f, -4.08226363e-02f, -6.79839700e-02f, -4.31286218e-03f,
  -9.02249217e-02f, 1.77556016e-02f, -1.22112399e-02f, -4.96237241e-02f, 1.42560480e-02f, -1.69552080e-02f, -4.95700501e-02f, -1.09322235e-01f, -8.19067582e-02f, -6.70860987e-03f,
  -5.85184991e-02f, 1.59987301e-01f, 2.58989390e-02f, 1.02821980e-02f, -5.17111905e-02f, -7.74874911e-02f, -8.84393752e-02f, 2.65408028e-02f, -1.55948028e-02f, -1.04498323e-02f,
  -3.56427431e-02f, -1.81938186e-02f, -5.81824519e-02f, 2.88943555e-02f, 1.64736271e-01f, 7.60161802e-02f, -4.07404825e-02f, 6.67470172e-02f, -6.83133453e-02f, 1.06053276e-03f,
  6.24925978e-02f, 1.19128399e-01f, 1.94545329e-01f, 1.91304199e-02f, -5.69357909e-02f, 1.92345932e-01f, 5.86842932e-02f, 1.17545277e-02f, 9.37543735e-02f, 1.39057696e-01f,
  -3.02871466e-01f, -5.65249510e-02f, 5.47643788e-02f, 5.54250404e-02f, -6.04355000e-02f, -2.68497497e-01f, -2.05962747e-01f, -1.70816153e-01f, -9.83856097e-02f, -1.26521915e-01f,
  -1.76810130e-01f, -2.04558030e-01f, -3.22705209e-02f, -8.53391215e-02f, -1.58695206e-01f, 3.90341952e-02f, 5.01275435e-02f, -2.47896463e-02f, -1.44139722e-01f, -2.60397434e-01f,
  -8.77724029e-03f, -1.13961354e-01f, -1.25542298e-01f, -2.27883998e-02f, -1.90327049e-03f, -6.72100559e-02f, -3.06737446e-03f, -8.22882354e-02f, -6.53200084e-03f, 1.81563675e-01f,
  -1.64236173e-01f, -1.90559104e-01f, -1.69357479e-01f, -1.29489228e-01f, -1.99829131e-01f, -4.05276343e-02f, -1.03679553e-01f, -1.10345416e-01f, -9.60192755e-02f, -1.63396373e-01f,
  -6.01899885e-02f, -1.79325178e-01f, -9.90504697e-02f, -1.41634628e-01f, -1.15928389e-01f, -1.77200660e-01f, -1.95968281e-02f, -2.07344815e-02f, -1.72717974e-01f, -1.72122031e-01f,
  -1.41474754e-01f, -1.92730293e-01f, -2.34448165e-01f, -1.18935183e-01f, -4.53677364e-02f, -1.08292304e-01f, -2.01620296e-01f, -4.66249734e-02f, -2.70663291e-01f, -1.47115931e-01f,
  -7.56910397e-03f, 6.27206787e-02f, 7.43463188e-02f, 1.35520399e-01f, 2.01731697e-01f, 1.62162393e-01f, 2.86407530e-01f, 9.45413485e-02f, 1.42139688e-01f, 2.83978820e-01f,
  1.06973633e-01f, 1.44703001e-01f, 3.00700277e-01f, 1.20161325e-01f, 1.71625435e-01f, 2.36182466e-01f, 1.16451278e-01f, 2.45122582e-01f, 1.57737643e-01f, 2.55610526e-01f,
  2.90487558e-01f, 1.31528243e-01f, 2.64435530e-01f, 1.99067056e-01f, 2.40124270e-01f, 1.72125310e-01f, 1.27118796e-01f, 6.84185624e-02f, 2.10504234e-01f, 1.89702064e-01f,
  -1.82945043e-01f, -2.33618617e-01f, -6.55957237e-02f, -1.57758072e-01f, -8.12419057e-02f, -1.08807676e-01f, -1.74655348e-01f, -1.06397599e-01f, -1.82604387e-01f, -1.02969885e-01f,
  -2.62220323e-01f, -1.45710871e-01f, -1.71584442e-01f, -7.33464509e-02f, -2.37978041e-01f, -1.72476530e-01f, -1.61871061e-01f, -1.78676993e-01f, -5.74688651e-02f, -6.90379366e-02f,
  -1.40987799e-01f, -1.99643418e-01f, -3.72727454e-01f, -1.73130587e-01f, -1.41277790e-01f, -2.22047299e-01f, -2.32889429e-01f, -2.35406697e-01f, -3.75303030e-01f, -2.66046375e-01f,
  2.87593585e-02f, -3.11429277e-02f, 2.98617274e-01f, 1.27206057e-01f, -6.96675628e-02f, -1.29076079e-01f, -3.40438157e-01f, -2.15447336e-01f, 1.35397494e-01f, 2.50352807e-02f,
  7.07800463e-02f, -7.02400971e-03f, 1.28904402e-01f, -2.83205323e-02f, -6.58971220e-02f, 6.08310550e-02f, 1.97446123e-01f, 4.62612025e-02f, -9.08873007e-02f, -2.94139475e-01f,
  -1.78948700e-01f, -6.90592229e-02f, -4.45480226e-03f, -1.06439209e-02f, -7.34094977e-02f, 1.21299513e-01f, 1.91070691e-01f, 4.27412950e-02f, -2.17440724e-02f, 2.13640347e-01f,
  2.54657477e-01f, -4.14796211e-02f, 6.63694665e-02f, 4.95634153e-02f, -6.23552827e-03f, 2.53246166e-02f, 9.82772186e-02f, 1.42862707e-01f, 1.18716463e-01f, 2.20826659e-02f,
  7.00061321e-02f, 5.81866922e-03f, 1.78316282e-03f, -6.93619102e-02f, -9.74204112e-03f, -8.01459402e-02f, -3.12495567e-02f, 8.63469392e-02f, 2.57073473e-02f, -2.96521913e-02f,
  5.66917248e-02f, 5.72511554e-02f, 5.09824529e-02f, 7.69865364e-02f, 4.29798942e-03f, 1.16766997e-01f, 3.00795697e-02f, 1.34163944e-03f, 1.08011261e-01f, -3.04837991e-02f,
  1.16556443e-01f, 6.48593828e-02f, -2.88425088e-02f, -1.06426850e-01f, -1.70952782e-01f, -1.30466614e-02f, -8.04961473e-02f, -1.45027906e-01f, -7.48751909e-02f, -4.38544974e-02f,
  -1.12808466e-01f, -8.16508010e-03f, -3.42439935e-02f, -8.33302587e-02f, 2.93530487e-02f, -7.03438297e-02f, -3.37668173e-02f, -1.21296262e-02f, -6.52704611e-02f, -1.79281104e-02f,
  -1.22366041e-01f, 1.01084588e-02f, -1.08808549e-02f, -4.63165226e-04f, -1.34537490e-02f, 2.87310705e-02f, -4.14447375e-02f, -3.39053459e-02f, -4.26541083e-02f, -9.74666402e-02f,
  6.20926730e-02f, 3.22950743e-02f, 1.13273412e-01f, 2.27567274e-02f, 1.15250394e-01f, 3.70710045e-02f, 1.35806680e-01f, 1.23952039e-01f, 7.44740814e-02f, 7.65617713e-02f,
  -9.47168097e-02f, 1.73912160e-02f, -2.76518636e-03f, 3.46252993e-02f, 6.06094999e-03f, 1.14421258e-02f, 8.37834850e-02f, 1.60361186e-01f, 7.01074228e-02f, 7.45781809e-02f,
  1.45418033e-01f, -3.84524055e-02f, 5.27789816e-02f, -2.89651449e-03f, -3.77470106e-02f, 1.76910639e-01f, -7.23314821e-04f, 4.45222184e-02f, 1.39457598e-01f, 6.96077645e-02f,
  3.81897062e-01f, 6.19393885e-02f, 2.98623294e-01f, 9.87297073e-02f, 1.17287293e-01f, 8.19426179e-02f, -1.12137295e-01f, -5.02096228e-02f, -5.19236699e-02f, 9.38023999e-02f,
  1.13024719e-01f, 8.05342570e-02f, -1.03971466e-01f, -2.80154478e-02f, -9.68040824e-02f, 2.33267806e-02f, 8.20488334e-02f, 1.79713920e-01f, 8.46740678e-02f, 9.03894752e-02f,
  5.82863204e-02f, -3.59545834e-02f, 1.75506115e-01f, 3.65526900e-02f, 2.64643967e-01f, 5.98767623e-02f, 2.16646075e-01f, 2.38180518e-01f, 2.26499081e-01f, 3.25414717e-01f,
  2.89716780e-01f, 1.88328505e-01f, -1.60885558e-01f, 3.00776772e-02f, 9.40229893e-02f, -3.16003896e-03f, -2.61058602e-02f, 5.87271564e-02f, -3.17642130e-02f, 1.09458044e-02f,
  1.71813250e-01f, 2.54220832e-02f, 9.48316902e-02f, 4.37582210e-02f, 4.38304506e-02f, 1.73876733e-02f, -5.81798032e-02f, 9.72608775e-02f, 7.56226107e-02f, 1.52541578e-01f,
  2.58441288e-02f, 3.39916408e-01f, 1.98943213e-01f, -2.35603191e-02f, 1.04499767e-02f, 9.97355059e-02f, 1.22309841e-01f, 1.02975309e-01f, 1.37631536e-01f, 1.88896805e-01f,
  -8.06460716e-03f, -1.83745380e-02f, -1.94843821e-02f, -5.07372171e-02f, -4.50691730e-02f, -4.09855880e-02f, 6.32731095e-02f, -4.26440276e-02f, -8.15482512e-02f, -4.39011380e-02f,
  -9.75140929e-02f, -3.14269401e-02f, -1.70476013e-03f, -9.86154154e-02f, -1.43714756e-01f, -1.81624014e-02f, -2.50938833e-02f, -6.38227761e-02f, 1.11252861e-02f, -7.39973485e-02f,
  -2.89372168e-02f, -4.66906130e-02f, -6.86587021e-02f, -6.80508688e-02f, -5.19956909e-02f, -4.84878256e-04f, -1.29119426e-01f, -8.20115283e-02f, -1.44838199e-01f, -9.73404422e-02f,
  -3.57506394e-01f, -6.35946766e-02f, 6.18210901e-03f, -6.65371493e-02f, 1.59466878e-01f, -1.46089140e-02f, 1.04024298e-01f, 9.32535082e-02f, 1.45001695e-01f, -1.65851247e-02f,
  1.46618947e-01f, 4.28701155e-02f, -1.54114384e-02f, 8.03580806e-02f, 8.26305673e-02f, 9.31519642e-02f, -2.00260766e-02f, 5.98471202e-02f, 8.26588571e-02f, 9.43841189e-02f,
  -4.60419506e-02f, 1.22181855e-01f, 1.07636437e-01f, -6.95793144e-03f, 1.16834112e-01f, 8.28960389e-02f, 1.06482893e-01f, 6.43599257e-02f, 6.48190305e-02f, -5.57124056e-02f,
  5.69527447e-01f, 1.20668843e-01f, -7.09939227e-02f, 3.12973619e-01f, 2.15481803e-01f, 1.61706984e-01f, 7.27529973e-02f, 2.34388545e-01f, 2.80695111e-01f, 9.25469026e-02f,
  1.11464001e-01f, -1.04920611e-01f, -1.80298746e-01f, -2.08720312e-01f, -1.66368321e-01f, -7.41958842e-02f, -2.09488288e-01f, -1.47817180e-01f, -5.61747812e-02f, -1.89338047e-02f,
  5.04529327e-02f, 1.21620245e-01f, 1.32965803e-01f, -1.05958749e-02f, 6.82097003e-02f, -5.44098727e-02f, -9.51760709e-02f, 6.77696839e-02f, -1.52993947e-01f, -1.36270538e-01f,
  -7.53408372e-02f, 3.33137900e-01f, -1.34671368e-02f, 7.92587548e-03f, 9.49219242e-02f, 1.03607759e-01f, 8.65208060e-02f, 7.34666735e-02f, 1.54618472e-01f, 9.75891948e-02f,
  1.33043900e-01f, 8.19654167e-02f, 9.72948298e-02f, 6.76991045e-03f, 1.97283864e-01f, 1.49446845e-01f, 1.47709444e-01f, 1.38938814e-01f, 9.99044925e-02f, 5.40105477e-02f,
  -8.64995550e-03f, 6.29706979e-02f, 7.86928162e-02f, 8.46621692e-02f, 4.78889383e-02f, 4.13172320e-02f, 1.24387443e-01f, 1.10067800e-01f, 1.54331177e-01f, 1.84508681e-01f,
  -2.53842790e-02f, 1.36778206e-02f, -6.90458529e-03f, 6.47617280e-02f, -3.35067548e-02f, -4.77907173e-02f, -5.79089634e-02f, 1.44724157e-02f, -6.15001954e-02f, -5.50579987e-02f,
  -3.67271006e-02f, -1.08641498e-01f, 4.00027148e-02f, -7.48183869e-04f, -9.43669304e-02f, 1.61403138e-02f, -9.90075804e-03f, -1.39260381e-01f, -1.28045142e-01f, -7.07098395e-02f,
  2.04860419e-02f, -3.38251740e-02f, 4.31511663e-02f, -1.29464015e-01f, -6.51859269e-02f, -1.21365190e-02f, 4.35263142e-02f, -1.48270562e-01f, 5.43310978e-02f, 1.16706118e-02f,
  1.64435849e-01f, -2.44203508e-02f, 1.36756092e-01f, 5.73827997e-02f, 1.22182101e-01f, -3.03039961e-02f, 1.16377585e-02f, 4.93168794e-02f, 4.23222147e-02f, 8.10987651e-02f,
  -3.75720561e-02f, 1.28846243e-01f, 7.62431696e-02f, 6.01873919e-02f, -1.66566093e-02f, 3.54962312e-02f, 9.51567292e-02f, 8.76500979e-02f, -5.82326166e-02f, 7.55586848e-02f,
  9.62441489e-02f, 1.13138236e-01f, 9.04023871e-02f, 3.10626868e-02f, 1.05185635e-01f, 8.63416865e-02f, -4.24904423e-03f, 9.95387509e-03f, -6.48961496e-03f, 2.04542145e-01f,
  2.18179643e-01f, 2.59202003e-01f, 6.32796064e-03f, -2.41992101e-01f, -2.25426733e-01f, 9.04065594e-02f, 2.61771649e-01f, 1.12738289e-01f, -1.37442201e-01f, 3.01524512e-02f,
  5.72649166e-02f, -1.23957835e-01f, -5.43014072e-02f, -1.33914903e-01f, 1.55585155e-01f, 1.31672919e-01f, 9.09405388e-03f, -1.55493289e-01f, -2.34404624e-01f, -2.33783305e-01f,
  -3.61524016e-01f, -2.52422988e-01f, -1.47774473e-01f, -7.35880509e-02f, -2.60877341e-01f, -2.25005344e-01f, 4.17830162e-02f, -1.21355571e-01f, 7.61358887e-02f, -2.28199601e-01f,
  -3.59789521e-01f, -5.24188438e-03f, -1.54743120e-01f, 5.81019325e-03f, -4.53062095e-02f, -2.69766692e-02f, -8.73633474e-02f, -8.64806995e-02f, 4.00484204e-02f, -1.42362654e-01f,
  -1.19263224e-01f, -1.15033284e-01f, -7.70679535e-03f, -1.84974745e-01f, -7.37558901e-02f, -8.25351849e-02f, 3.52460779e-02f, 3.54729891e-02f, -3.41675654e-02f, -4.52679433e-02f,
  -4.50821109e-02f, -3.58005390e-02f, 1.78460509e-01f, 6.48790225e-02f, -2.40092110e-02f, -7.38784000e-02f, 5.22672944e-02f, -5.18115573e-02f, 3.98639217e-02f, -1.84934124e-01f,
  1.38638809e-01f, -2.08015349e-02f, 3.01101115e-02f, -3.32437754e-02f, 5.78822494e-02f, 4.45464477e-02f, -2.87047471e-03f, 5.18576913e-02f, -1.95710007e-02f, 4.65239547e-02f,
  2.99437232e-02f, 6.14085235e-02f, 4.41400781e-02f, 5.05984724e-02f, -8.71951878e-03f, 3.53496186e-02f, 3.12419441e-02f, 5.69801740e-02f, 1.03316747e-01f, 9.40154959e-03f,
  8.88958052e-02f, 2.46900991e-02f, 4.19683196e-02f, 1.64852683e-02f, 2.08834950e-02f, 5.32860234e-02f, -4.50038388e-02f, 1.01191707e-01f, -6.98232232e-03f, 9.68218595e-02f,
  -1.73227176e-01f, 2.08905816e-01f, -2.51411915e-01f, -1.95882872e-01f, -2.95292083e-02f, -7.27896169e-02f, -1.19353652e-01f, -1.27217844e-01f, -1.56100422e-01f, -7.26369098e-02f,
  -3.85913327e-02f, -2.57836729e-02f, -4.76705618e-02f, -1.40843511e-01f, -1.33643642e-01f, -1.97366700e-01f, -1.49500289e-03f, -1.17725119e-01f, -4.87196585e-03f, -2.16882862e-02f,
  6.16197586e-02f, -3.03770099e-02f, -8.96625742e-02f, -3.92817296e-02f, -6.61366656e-02f, -1.49047496e-02f, -2.09384754e-01f, -9.42418128e-02f, -9.59160086e-03f, -3.06467265e-02f,
  -3.05751294e-01f, -1.07381783e-01f, 2.40370885e-01f, -1.02647737e-01f, 3.66458595e-02f, 1.45074263e-01f, 1.91983491e-01f, -8.64394475e-03f, -1.19259737e-01f, 1.08146213e-01f,
  3.01790563e-03f, -9.80899632e-02f, -7.99985602e-02f, -1.07224267e-02f, 2.46902965e-02f, 3.88433784e-02f, 8.08707327e-02f, 5.90590537e-02f, 4.38592210e-02f, -2.95033306e-02f,
  -4.66908999e-02f, -1.57501787e-01f, -3.03670615e-01f, -8.13029781e-02f, 1.11045809e-02f, -1.12956434e-01f, -1.03152417e-01f, -1.27611041e-01f, -8.09854344e-02f, 4.39807326e-02f,
  1.24309830e-01f, -1.56799749e-01f, 4.00280720e-03f, -8.63005146e-02f, -2.92374361e-02f, -3.60727496e-02f, 4.33031395e-02f, -1.01736732e-01f, -3.65786776e-02f, -3.48055549e-02f,
  1.30143324e-02f, -6.16964977e-03f, 2.48434730e-02f, -1.01993583e-01f, -6.14253804e-03f, -2.94528808e-02f, -2.14936301e-01f, -1.35806680e-01f, -1.01162285e-01f, -2.34386221e-01f,
  -7.02297464e-02f, 5.87714650e-02f, -7.08289593e-02f, -1.67303607e-01f, -1.52548179e-01f, -1.68742374e-01f, -8.00482258e-02f, -1.18451752e-01f, -2.37245299e-02f, -9.92987156e-02f,
  1.97090551e-01f, 1.47363782e-01f, 1.59813985e-01f, 5.99764213e-02f, 3.70025747e-02f, 1.01578459e-01f, 1.20714754e-01f, 1.24562763e-01f, 1.23300500e-01f, 1.42275900e-01f,
  1.05007485e-01f, 1.00865111e-01f, 1.20204575e-01f, 7.49780685e-02f, 1.33084029e-01f, 1.15910180e-01f, 9.98021141e-02f, 2.86358856e-02f, 9.59874690e-03f, 1.06747700e-02f,
  9.47847441e-02f, 2.11568117e-01f, 1.41256854e-01f, 1.38265282e-01f, 1.73599288e-01f, 1.29096359e-01f, 1.06759451e-01f, 1.71587188e-02f, 1.70722201e-01f, 1.54467835e-03f,
  -1.49674147e-01f, -1.11731142e-01f, -3.79811078e-02f, -1.39343038e-01f, -4.16616015e-02f, -1.81602493e-01f, -9.11446959e-02f, -2.11167157e-01f, -7.64354691e-02f, 1.83535963e-02f,
  -2.30626925e-03f, -1.54851362e-01f, -1.10046059e-01f, -1.73173532e-01f, -9.03768912e-02f, -1.34034216e-01f, -1.29086807e-01f, -7.17396811e-02f, -7.06129223e-02f, -1.82222724e-01f,
  -1.85361043e-01f, -2.04557497e-02f, 1.67354718e-02f, -1.44636422e-01f, -8.53118375e-02f, -3.39950137e-02f, 6.36181459e-02f, 1.96349397e-02f, 8.33639782e-03f, -4.29792926e-02f,
  -2.24964052e-01f, 8.82750452e-02f, 5.30041568e-02f, -2.06374973e-01f, -1.03698291e-01f, -1.50850266e-02f, 1.65552303e-01f, 2.52156146e-02f, -1.28211990e-01f, -4.31990661e-02f,
  -3.03202450e-01f, -3.65794927e-01f, -2.56161958e-01f, -1.55739963e-01f, -2.31390391e-02f, 4.82462160e-02f, 1.45355940e-01f, 8.80918428e-02f, -1.04855314e-01f, -2.07637608e-01f,
  -1.76090017e-01f, -4.26525585e-02f, 5.52378874e-03f, -1.41796032e-02f, -4.26037684e-02f, -1.85430832e-02f, 4.34808135e-02f, 6.03441522e-02f, 3.20809186e-02f, 9.96613652e-02f,
  -4.87949960e-02f, -2.64519989e-01f, -7.51171336e-02f, -2.26558834e-01f, -4.13030349e-02f, -1.61499068e-01f, -9.97106954e-02f, -1.15220927e-01f, -1.97251394e-01f, -4.35338318e-02f,
  -2.19981030e-01f, -2.17413396e-01f, -1.35347500e-01f, -9.93912518e-02f, -1.08629100e-01f, -1.07456610e-01f, -1.24162897e-01f, 2.42521334e-03f, -1.18915662e-01f, -1.02605917e-01f,
  -2.29145706e-01f, -2.30565935e-01f, -1.49788216e-01f, -9.18403715e-02f, -2.76552178e-02f, -9.60223377e-02f, 2.34178510e-02f, -7.71065503e-02f, 3.32762413e-02f, -2.56544389e-02f,
  8.36698860e-02f, 1.51398340e-02f, 8.51609185e-03f, 1.14846028e-01f, 1.28699929e-01f, 9.55180898e-02f, 8.93291980e-02f, 7.26606399e-02f, 5.26868366e-02f, 1.58535406e-01f,
  1.03194706e-01f, 3.47596891e-02f, 1.73956558e-01f, 1.95087060e-01f, 4.68297228e-02f, 5.42770177e-02f, 4.67578806e-02f, 1.26164347e-01f, 5.36125302e-02f, 1.28020540e-01f,
  7.94158876e-02f, 1.07271284e-01f, 6.21768869e-02f, 1.62583187e-01f, 1.16739981e-01f, 1.65731475e-01f, -2.61473563e-02f, -3.86858955e-02f, 3.24228890e-02f, 3.83044444e-02f,
  -2.00623527e-01f, -1.53245538e-01f, -2.61418462e-01f, -1.35805190e-01f, -1.94959000e-01f, -1.76481500e-01f, -1.76282078e-01f, -1.23379715e-01f, -1.97064996e-01f, -1.63763374e-01f,
  -1.17991768e-01f, -8.62974301e-02f, -9.74262431e-02f, -7.13380948e-02f, -1.28973648e-01f, -1.43984452e-01f, -1.67440817e-01f, -7.03361109e-02f, -1.58002213e-01f, -2.47270837e-01f,
  -4.78473939e-02f, -7.88791105e-02f, -1.49266586e-01f, -7.05896318e-02f, -2.03614235e-01f, -1.98656753e-01f, -3.66333015e-02f, -8.47861692e-02f, -1.33312168e-02f, -3.44325695e-03f,
  9.44450498e-02f, 1.06070206e-01f, 3.02605689e-01f, -9.59760100e-02f, -2.23355427e-01f, -3.01360279e-01f, -3.59511971e-01f, -1.66750565e-01f, -4.38213348e-02f, -2.18773093e-02f,
  8.24824199e-02f, 4.01557058e-01f, 4.22320247e-01f, 3.19583297e-01f, 1.20778508e-01f, -1.32695781e-02f, -1.27250627e-01f, 3.07370514e-01f, 1.82831466e-01f, -1.66157670e-02f,
  -1.13190256e-01f, -2.79739965e-02f, 1.94684476e-01f, 1.61033154e-01f, 5.49589731e-02f, 2.24115834e-01f, 8.45118910e-02f, -2.29871143e-02f, -2.95382068e-02f, 9.14241560e-03f,
  3.06802392e-01f, 1.15460031e-01f, 1.15048431e-01f, 1.13933988e-01f, 1.63822830e-01f, 1.15269996e-01f, 1.45910248e-01f, 1.77041113e-01f, 2.17285976e-01f, 1.54063538e-01f,
  6.68802857e-02f, 1.44648939e-01f, 2.39131406e-01f, 1.41126886e-01f, 1.40573174e-01f, 1.28812358e-01f, 4.92010228e-02f, 1.35034487e-01f, 1.92263618e-01f, 1.48130447e-01f,
  5.34117268e-03f, 6.75657466e-02f, 4.71267700e-02f, 5.87813929e-02f, 1.26761734e-01f, 1.60779878e-01f, 1.48468226e-01f, 1.28902584e-01f, 3.35428566e-02f, 7.80880898e-02f,
  -1.95121869e-01f, -5.62977493e-02f, 1.17578488e-02f, -1.59773573e-01f, -6.46719262e-02f, -8.94952714e-02f, -2.33108345e-02f, -2.85897702e-02f, -5.23204394e-02f, -1.79322381e-02f,
  -1.13864141e-02f, -1.12504452e-01f, -1.47134131e-02f, -4.54520341e-03f, 5.48895150e-02f, -4.00110222e-02f, -8.72220770e-02f, -2.48513911e-02f, 4.17774655e-02f, -7.11525008e-02f,
  -3.94330285e-02f, 3.12893353e-02f, 2.36799996e-02f, 6.22552261e-02f, -1.38370907e-02f, 1.76262185e-02f, -1.38579160e-01f, 2.35861577e-02f, -4.40254994e-02f, -2.37046229e-03f,
  1.84052527e-01f, 8.60969797e-02f, 6.10754900e-02f, 6.21581040e-02f, 4.75999899e-02f, 6.22011982e-02f, 2.91146841e-02f, 1.06721200e-01f, 1.46750629e-01f, 6.24325871e-02f,
  1.55563056e-01f, 1.30018666e-01f, 1.60700485e-01f, 3.13369632e-02f, 1.00366063e-01f, 6.55185506e-02f, -5.86484186e-02f, 1.28146082e-01f, 1.18026711e-01f, 5.73484302e-02f,
  3.60775031e-02f, -1.25871077e-01f, 9.62946117e-02f, 5.36096655e-02f, -2.16288567e-02f, 2.15440989e-02f, 3.22471857e-02f, 6.74435571e-02f, -1.27856219e-02f, -1.15191147e-01f,
  6.88650236e-02f, 2.68091951e-02f, 9.91738364e-02f, 1.82973266e-01f, 1.72951929e-02f, -1.28017604e-01f, -6.64162785e-02f, -2.19114751e-01f, -2.34524962e-02f, -1.07567020e-01f,
  -2.04129264e-01f, -1.19437054e-01f, -3.98688018e-02f, 7.53304316e-03f, -5.06198499e-03f, 4.56230938e-02f, 6.16923161e-02f, 1.17899321e-01f, -9.71101895e-02f, -6.62878901e-02f,
  -1.76708046e-02f, -3.16555239e-02f, -7.26883486e-02f, -4.34817700e-03f, 3.91186737e-02f, -4.76176813e-02f, -1.38041526e-02f, 2.96189394e-02f, 4.42848243e-02f, 7.65914768e-02f,
  -2.42010489e-01f, -8.18024799e-02f, -8.52842480e-02f, 5.58612728e-03f, -1.26222134e-01f, -1.26424477e-01f, -4.48977686e-02f, 3.01786489e-03f, 3.19670551e-02f, -1.13297604e-01f,
  -1.96108711e-03f, -3.32561298e-03f, -2.32970826e-02f, -1.21614657e-01f, -8.79879072e-02f, -9.70631912e-02f, -3.53688039e-02f, 1.24684302e-02f, -1.03164293e-01f, -1.07850410e-01f,
  -2.27011344e-03f, 6.81878487e-03f, -1.44689023e-01f, -1.40562013e-01f, -1.33638740e-01f, 4.19046953e-02f, -7.49861673e-02f, 1.37509536e-02f, -1.80544659e-01f, -1.26026094e-01f,
  1.30060658e-01f, 5.43841114e-03f, -8.51541683e-02f, -5.49589768e-02f, -2.46377080e-03f, -4.61352915e-02f, 6.36134744e-02f, -1.36706643e-02f, -7.99676329e-02f, -4.58368398e-02f,
  -2.86331195e-02f, -3.68761495e-02f, 8.55302736e-02f, 2.29946803e-03f, 9.20912176e-02f, 6.06687833e-03f, 1.00573748e-01f, -1.09985238e-02f, 4.14569192e-02f, -6.93202578e-03f,
  5.40442057e-02f, -2.43043117e-02f, 9.65156220e-03f, 1.68422721e-02f, 7.50867426e-02f, -1.97011102e-02f, 7.91900232e-02f, -1.16114601e-01f, 7.92849883e-02f, 6.99801371e-02f,
  -2.57666379e-01f, -1.19541399e-01f, -4.22564670e-02f, -7.12025091e-02f, 1.14785917e-02f, -2.47979704e-02f, 2.28985958e-02f, 2.02257046e-03f, -2.29341723e-02f, -1.59894839e-01f,
  -1.60850599e-01f, 1.95310414e-02f, -1.29970610e-01f, -1.50498033e-01f, -1.42417654e-01f, -1.22681856e-01f, -9.74483490e-02f, 2.88327169e-02f, -4.63860221e-02f, -1.30868331e-01f,
  -1.46555141e-01f, -2.33342052e-01f, -1.43187702e-01f, -2.29902059e-01f, -2.94878688e-02f, -7.95316026e-02f, -1.22976407e-01f, -1.31109223e-01f, -2.16465563e-01f, -1.88457236e-01f,
  2.18836054e-01f, -1.19212177e-02f, 1.30890623e-01f, 3.51311266e-02f, -1.39561176e-01f, -1.30108118e-01f, -1.24232121e-01f, 1.60431257e-03f, -1.51228353e-01f, -5.17208241e-02f,
  -2.74617612e-01f, -1.04553036e-01f, -1.33496583e-01f, -1.19246449e-02f, 1.18528567e-01f, 4.09591533e-02f, 1.48201272e-01f, 2.30084360e-01f, 9.17923525e-02f, 1.00780971e-01f,
  4.07579802e-02f, 2.08842948e-01f, 2.88061857e-01f, 2.54312396e-01f, 6.59984797e-02f, 1.39331222e-01f, 1.93381295e-01f, 2.37272769e-01f, 7.58112371e-02f, 2.51924872e-01f,
  -9.76969078e-02f, 1.09035559e-01f, -2.27590427e-02f, -5.39052561e-02f, -1.05169378e-01f, -3.25380005e-02f, -8.38348083e-03f, 5.07149063e-02f, -1.14502169e-01f, -6.39757514e-02f,
  -1.47431463e-01f, -6.24593869e-02f, 1.89994241e-03f, -8.79359245e-02f, -4.28659003e-03f, 3.17767188e-02f, 1.17358901e-01f, -4.69406042e-03f, 8.60712379e-02f, -8.87018293e-02f,
  -1.32144123e-01f, -6.51460811e-02f, -5.27562201e-03f, 7.06689209e-02f, 9.61537361e-02f, 3.83483984e-06f, 1.02138653e-01f, 1.51079213e-02f, 1.55317843e-01f, 4.36563566e-02f,
  -4.77201939e-02f, 3.77039649e-02f, 3.24610397e-02f, 1.16136177e-02f, 3.83508764e-02f, 3.43436785e-02f, 2.02622283e-02f, 5.69986645e-03f, 5.30611351e-03f, -5.87541936e-03f,
  2.40365546e-02f, 8.09201784e-03f, -1.22814979e-02f, 1.00150169e-03f, 1.08625293e-01f, 1.12693109e-01f, -3.77675183e-02f, 4.27352190e-02f, 1.16270930e-01f, 2.98382454e-02f,
  -2.74427924e-02f, 1.05522163e-01f, -5.62774763e-02f, -4.55884151e-02f, -1.64178982e-02f, 7.88358413e-03f, 8.38670880e-02f, -3.75629775e-02f, -1.37138227e-02f, 4.70451452e-02f,
  -5.67393675e-02f, 3.37563567e-02f, -6.58610016e-02f, -1.82442293e-02f, -3.57295945e-02f, -2.06208713e-02f, -1.81759983e-01f, -6.03320189e-02f, -1.07423551e-01f, -1.05490327e-01f,
  -4.76387292e-02f, -3.30140851e-02f, -1.28145278e-01f, 4.82596718e-02f, -4.11626548e-02f, -6.13601459e-03f, -5.90901189e-02f, 2.50136871e-02f, -4.24808823e-02f, -2.66813096e-02f,
  -5.51640727e-02f, 5.88153154e-02f, -6.91579059e-02f, -3.38726155e-02f, 4.21884246e-02f, 4.55512963e-02f, 2.72945110e-02f, -1.12655848e-01f, 4.98823356e-03f, -1.06845878e-01f,
  -9.10842866e-02f, 2.17901111e-01f, -2.26776917e-02f, -2.97858685e-01f, 7.26828277e-02f, 3.32201481e-01f, 4.03841317e-01f, 1.57046705e-01f, -2.21167654e-01f, 1.54238552e-01f,
  3.27356428e-01f, 7.84463063e-02f, 1.43129185e-01f, 7.14537129e-02f, 1.05720796e-01f, -7.72593170e-02f, -1.22451052e-01f, -1.44144282e-01f, -1.12671897e-01f, 4.73394580e-02f,
  -1.19103588e-01f, -3.00550640e-01f, -2.56225288e-01f, -3.17493789e-02f, -1.95680365e-01f, -4.25877497e-02f, -1.26507029e-01f, -1.67866014e-02f, 1.69348761e-01f, -2.87611127e-01f,
  2.13862121e-01f, 2.08964854e-01f, -1.72328521e-02f, -3.26131471e-02f, -1.96096301e-02f, -2.40095593e-02f, 9.71623063e-02f, -9.41024441e-03f, 5.10900421e-03f, -1.12557679e-01f,
  5.85541055e-02f, 1.49044814e-02f, 8.67291391e-02f, -3.08195800e-02f, 3.26626599e-02f, 1.03446297e-01f, -1.38092143e-02f, -1.00582562e-01f, -9.56660807e-02f, 7.05862418e-02f,
  1.46991722e-02f, -4.29107025e-02f, 1.78906973e-02f, 6.20251410e-02f, 1.62404627e-02f, -1.25430673e-02f, 1.64691135e-02f, 1.06343431e-02f, 1.03863321e-01f, -5.01995645e-02f,
  -1.14220873e-01f, -6.40070885e-02f, 6.31483793e-02f, -1.81403607e-02f, -5.21641597e-03f, -7.43626803e-02f, 5.23974746e-02f, 4.73126993e-02f, -2.21901983e-02f, -7.60706961e-02f,
  7.83501863e-02f, 6.91085383e-02f, -6.10686168e-02f, -4.55671772e-02f, -2.51820218e-02f, -5.38863093e-02f, 1.32331380e-03f, -4.18338291e-02f, 8.19906592e-02f, 6.35494515e-02f,
  -6.42784536e-02f, 6.58779666e-02f, -5.42370928e-03f, -4.10368443e-02f, 1.55659486e-02f, -1.10506646e-01f, 1.04078362e-02f, 4.21045497e-02f, 8.30473155e-02f, 1.56321824e-02f,
  -1.46394998e-01f, 1.55435264e-01f, -7.94947669e-02f, -4.48258221e-03f, -8.10401738e-02f, 2.94090305e-02f, 2.92990636e-02f, -2.07877206e-03f, 4.29738313e-02f, 3.85285579e-02f,
  4.00477760e-02f, 6.65870234e-02f, 1.26296267e-01f, -8.05716217e-03f, -3.04157194e-02f, 1.10446028e-02f, 1.22809205e-02f, -1.63472537e-02f, -5.44669889e-02f, -6.88914722e-03f,
  -1.39640778e-01f, -1.40725216e-02f, 2.89683826e-02f, -1.68224592e-02f, -5.21436967e-02f, -5.26115485e-02f, -3.23837996e-02f, -1.17181636e-01f, 8.09708759e-02f, -1.65272057e-01f,
  5.42418420e-01f, -2.51888573e-01f, 1.18715383e-01f, 1.85087219e-01f, 1.73932478e-01f, 4.42001633e-02f, -1.66896313e-01f, -4.73311320e-02f, -5.96215157e-03f, -1.12326391e-01f,
  7.40230903e-02f, 4.42205369e-02f, 1.14785440e-01f, 7.63971806e-02f, 6.29914179e-02f, -7.48392045e-02f, -4.38814685e-02f, 1.94492579e-01f, 2.00963274e-01f, 1.41661361e-01f,
  2.90408749e-02f, 5.41384844e-03f, 2.28009641e-01f, 1.30587563e-01f, -1.66762307e-01f, -7.51095712e-02f, -1.11636072e-01f, 4.48431335e-02f, 1.38062034e-02f, -3.02624311e-02f,
  4.21473496e-02f, 9.88310203e-02f, 5.43057732e-02f, 1.46344423e-01f, 6.57045003e-03f, 1.20712645e-01f, 9.63987187e-02f, 1.19845696e-01f, 5.62743954e-02f, 3.23170200e-02f,
  1.06519043e-01f, 1.15807734e-01f, 9.71841738e-02f, -7.17679635e-02f, 9.32591408e-02f, -4.78973752e-03f, -7.77224302e-02f, 1.11623354e-01f, 3.90757062e-02f, 1.67978299e-03f,
  -1.03910156e-01f, 8.09942707e-02f, 2.16720030e-01f, -4.59867939e-02f, -4.99674343e-02f, 1.16010360e-01f, -2.78752507e-03f, 3.77563350e-02f, 8.43654212e-04f, -2.62355227e-02f,
  -7.26173222e-02f, 2.95552108e-02f, -2.52439994e-02f, -3.14304382e-02f, -5.11992425e-02f, 4.22979146e-02f, -6.62421957e-02f, -5.70407510e-03f, 1.71458889e-02f, 1.77228339e-02f,
  1.11149810e-02f, 5.70172034e-02f, -1.01565495e-02f, 5.28222462e-03f, 3.99005041e-02f, 1.52861830e-02f, 4.36482616e-02f, -1.42813429e-01f, -2.87925005e-02f, 6.86987564e-02f,
  1.16670072e-01f, 7.12023303e-02f, 8.88523864e-05f, -1.19497418e-01f, -5.76560758e-02f, 3.47182453e-02f, 6.04022853e-02f, -4.76441309e-02f, -7.17949122e-02f, 7.18189105e-02f,
  -2.27798417e-01f, 1.33067086e-01f, 7.13526607e-02f, 2.28609350e-02f, 7.39783840e-03f, -5.07549150e-03f, -6.86326809e-03f, -5.80431037e-02f, 8.06849301e-02f, -6.67232694e-03f,
  5.48252985e-02f, -1.82706844e-02f, 7.37317279e-02f, -5.96756488e-02f, 1.14455424e-01f, -5.00606298e-02f, -1.94467381e-02f, 4.20214385e-02f, -3.80350612e-02f, -9.91145968e-02f,
  -4.99174781e-02f, 1.31311595e-01f, 9.79975611e-02f, 4.02433127e-02f, 1.93131901e-02f, 1.46967322e-01f, 3.20944376e-02f, -1.81972068e-02f, 8.66346359e-02f, -1.49778500e-01f,
  2.26081178e-01f, 3.92999768e-01f, 2.63604522e-01f, 9.38931853e-03f, -4.14447822e-02f, 1.87647060e-01f, 3.01283062e-01f, 1.31955162e-01f, -8.62062946e-02f, -1.43540036e-02f,
  -9.67032462e-02f, -2.57306218e-01f, -2.49064326e-01f, -2.45775774e-01f, -4.84081730e-02f, 1.64930090e-01f, 4.76280972e-02f, 1.21020459e-01f, 4.18322608e-02f, -4.58661877e-02f,
  -1.35755539e-01f, 8.83082580e-03f, 1.20349027e-01f, 1.20887505e-02f, 5.20086810e-02f, -5.23244627e-02f, 1.38674095e-01f, 1.88498527e-01f, 1.70786068e-01f, 1.27285063e-01f,
  1.30081102e-01f, 3.64035845e-01f, -6.47479203e-03f, 5.09704463e-02f, 1.20406244e-02f, 5.63084744e-02f, 1.27338707e-01f, 1.18241616e-01f, 1.04833707e-01f, 6.35199770e-02f,
  1.00082912e-01f, -3.54635455e-02f, 9.25093815e-02f, 1.16378672e-01f, 1.47890016e-01f, 1.06214657e-01f, 1.06714994e-01f, 1.20312065e-01f, 1.19272031e-01f, 1.07027106e-01f,
  6.01286441e-02f, 6.38752207e-02f, 1.79515660e-01f, 3.95492688e-02f, 2.29915410e-01f, 1.31060615e-01f, 2.71219254e-01f, 1.48648515e-01f, 2.04366669e-01f, 2.27142990e-01f,
  1.32950082e-01f, -4.32205275e-02f, -1.12323761e-01f, -2.04398800e-02f, -7.68023655e-02f, -5.18532321e-02f, -8.81509110e-02f, -1.14406206e-01f, -4.11052667e-02f, -1.12798400e-01f,
  -9.11296904e-02f, -1.56411245e-01f, -1.41787857e-01f, -4.17149886e-02f, -2.19277665e-01f, -7.07211494e-02f, -1.23640142e-01f, -7.37231597e-02f, -1.14318922e-01f, -8.69674012e-02f,
  -5.87635674e-02f, -1.40579164e-01f, -1.08363286e-01f, -1.44124910e-01f, -5.40018268e-02f, -1.17600262e-01f, -4.44031022e-02f, -7.42302462e-02f, -3.15276682e-02f, -5.12368605e-02f,
  -1.64631963e-01f, -8.26679394e-02f, 6.22461140e-02f, 6.49033934e-02f, 1.66403905e-01f, 2.56897379e-02f, 7.02166408e-02f, 1.45842746e-01f, -3.76324095e-02f, 2.22273201e-01f,
  7.47288913e-02f, 1.93765704e-02f, 1.84427761e-02f, 4.63324226e-02f, 7.69244432e-02f, 6.05671406e-02f, 1.42473593e-01f, 1.14700615e-01f, 5.47847338e-02f, 1.49545714e-01f,
  6.22248650e-02f, 6.14455268e-02f, 6.27031848e-02f, 1.14255242e-01f, 8.36072341e-02f, 5.24218008e-02f, 1.00193843e-01f, 1.93959102e-01f, 1.22955590e-01f, 3.10118139e-01f,
  -5.13558447e-01f, -3.17393124e-01f, 2.01191694e-01f, -4.31637419e-03f, 2.03712448e-01f, 1.48948804e-01f, 8.63623321e-02f, -1.00052141e-01f, 4.95751202e-02f, -5.13204746e-03f,
  -1.28838774e-02f, 6.21833131e-02f, 6.78448975e-02f, 1.37197554e-01f, -7.82357976e-02f, 4.94357198e-02f, 2.84268498e-01f, 1.17707498e-01f, 2.79955328e-01f, 8.14853460e-02f,
  1.54799804e-01f, -1.19452327e-01f, -2.84675866e-01f, 2.57113799e-02f, 5.47356643e-02f, 1.28746808e-01f, -3.41998972e-02f, -1.29243717e-01f, 1.27935290e-01f, 7.61147141e-02f,
  8.49449486e-02f, -1.95135280e-01f, 2.55766511e-01f, 9.58287120e-02f, 8.63278359e-02f, 6.10867515e-02f, 1.51362047e-01f, 3.05430731e-04f, 1.51649982e-01f, 8.18273425e-02f,
  1.19084090e-01f, 3.32315676e-02f, 6.51955828e-02f, 4.91384454e-02f, -2.55449973e-02f, 4.97174114e-02f, -5.69658950e-02f, 4.90565151e-02f, 1.25074342e-01f, 1.20595917e-01f,
  1.44389167e-01f, 7.47812390e-02f, 6.39784932e-02f, 1.12944894e-01f, 8.40946585e-02f, 1.75937176e-01f, -2.56907977e-02f, 1.40852973e-01f, 1.41133696e-01f, -1.58946753e-01f,
  1.91786382e-02f, -7.43136704e-02f, -9.32852998e-02f, -1.40560806e-01f, -1.24608330e-01f, -1.96648296e-02f, -3.60402614e-02f, -3.91235873e-02f, -9.55840722e-02f, -6.83724359e-02f,
  -9.07772332e-02f, -8.46518576e-02f, -7.46554211e-02f, -1.30505636e-01f, -6.03648610e-02f, -6.79504275e-02f, -9.94972587e-02f, -8.77210200e-02f, -1.11368336e-01f, -1.12119488e-01f,
  -1.33909985e-01f, -9.33738351e-02f, -6.19138964e-02f, -6.99715689e-02f, -1.72768869e-02f, -9.91621092e-02f, -8.84351879e-02f, -2.12114211e-02f, -6.34723082e-02f, -1.45659953e-01f,
  -9.51833650e-02f, 1.43928483e-01f, 2.01551691e-01f, 1.06212333e-01f, 1.11310519e-01f, 1.58129022e-01f, 1.57530621e-01f, 1.88795403e-01f, 8.68842378e-02f, 3.42636891e-02f,
  5.53751402e-02f, 9.59423110e-02f, 3.86482552e-02f, 1.30691379e-01f, 1.97953075e-01f, 2.22678691e-01f, 1.45188764e-01f, 1.00095324e-01f, 1.56490415e-01f, 7.97862113e-02f,
  1.17562100e-01f, 5.18060923e-02f, 1.41943902e-01f, 9.43617448e-02f, 1.04127482e-01f, 3.08490783e-01f, 1.29821941e-01f, 7.13305846e-02f, 2.01127827e-01f, -8.70606676e-03f,
  -5.56666851e-01f, 4.47471470e-01f, -3.41804326e-01f, -1.23143196e-01f, 2.23903090e-01f, 5.81426099e-02f, 1.23800062e-01f, 7.51806572e-02f, -5.23472838e-02f, 1.00066707e-01f,
  2.34739318e-01f, 1.40658556e-03f, 2.53661089e-02f, -6.56788275e-02f, -8.55844095e-02f, 7.32368305e-02f, 5.24868704e-02f, -1.99207574e-01f, -2.30132774e-01f, -5.74672921e-03f,
  1.77733913e-01f, 8.67314115e-02f, -2.23518237e-01f, -5.18817455e-02f, 2.90656060e-01f, 9.44556519e-02f, 1.01207331e-01f, 1.28226623e-01f, 1.67257562e-01f, 1.53380483e-01f,
  1.30843267e-01f, 6.92670583e-05f, -5.62607870e-02f, 1.78944618e-01f, 1.45148054e-01f, -2.22084820e-02f, -8.81697983e-03f, 7.75552262e-03f, 9.35036391e-02f, -2.40416341e-02f,
  1.48382962e-01f, 6.76839352e-02f, 8.39095712e-02f, 1.26490593e-01f, 7.58306086e-02f, 4.15050760e-02f, -2.83536334e-02f, -1.32588133e-01f, -1.03769019e-01f, 3.02788857e-02f,
  2.46972412e-01f, 2.04778403e-01f, 5.63732199e-02f, 9.98714492e-02f, 1.47581808e-02f, -1.61286779e-02f, 1.36316270e-01f, 1.26838550e-01f, -7.00453892e-02f, 1.07235707e-01f,
  3.01540662e-02f, -5.39657734e-02f, 4.15710360e-02f, -7.69249052e-02f, 6.97469786e-02f, -4.12060097e-02f, -7.15692714e-02f, 9.33786761e-03f, -1.39597338e-02f, -9.92376171e-03f,
  -4.23184969e-02f, -3.00786123e-02f, -8.05373862e-02f, -5.52915968e-03f, -1.57414917e-02f, -5.65120056e-02f, 1.30586559e-02f, 2.25771349e-02f, -2.64143515e-02f, -2.81146392e-02f,
  -3.51309516e-02f, -7.83408657e-02f, -7.27674216e-02f, 7.15960981e-03f, -4.23601549e-03f, -4.45168801e-02f, -1.06046526e-02f, -8.09066091e-03f, 8.04810897e-02f, -4.86814603e-02f,
  -8.75778869e-02f, -1.19808383e-01f, 6.30980581e-02f, 4.76657562e-02f, 8.12440813e-02f, 1.38718765e-02f, 1.31114796e-01f, -3.90135497e-02f, 2.69668978e-02f, 5.01180766e-03f,
  9.18191001e-02f, 3.15629542e-02f, -1.90852005e-02f, 1.06426828e-01f, 4.11285870e-02f, 7.57642463e-02f, 1.45597503e-01f, -5.15838005e-02f, -5.04840203e-02f, 9.68127772e-02f,
  1.54012024e-01f, -5.95642887e-02f, -5.78506067e-02f, -9.70729664e-02f, 2.75383471e-03f, -4.34873253e-02f, -6.76499456e-02f, -1.17281144e-02f, -1.44175127e-01f, -2.25349758e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.26959407e-02f, -1.21510649e+00f, -2.56188035e-01f, -5.87256253e-01f, -5.28284371e-01f, -4.83028829e-01f, -1.21281517e+00f, -2.82020003e-01f, 1.51691586e-01f, -8.06347609e-01f,
  -1.81573048e-01f, 6.68763578e-01f, 3.19572508e-01f, 3.50935608e-01f, 4.67271805e-01f, -8.09676290e-01f, -4.50020015e-01f, 5.54002106e-01f, 9.43988621e-01f, -2.50891954e-01f,
  -4.39563364e-01f, -1.90658793e-01f, 5.04338682e-01f, 7.27282614e-02f, -9.96435165e-01f, -8.78869221e-02f, -6.21000051e-01f, -5.04609823e-01f, -5.25229692e-01f, -1.18590665e+00f,
  -4.04013515e-01f, -7.52008408e-02f, 4.19886768e-01f, 5.72684288e-01f, -1.41194597e-01f, 2.52472967e-01f, 3.61058451e-02f, 2.56682456e-01f, 1.55214235e-01f, -9.09211207e-03f,
  -4.41556089e-02f, 2.65349090e-01f, 1.10390581e-01f, 3.46065722e-02f, -2.08263844e-01f, 2.77074039e-01f, -1.26047414e-02f, 1.80273756e-01f, 1.19733170e-01f, -2.61727273e-01f,
  -7.34442890e-01f, -4.20872808e-01f, -1.09616838e-01f, -2.64459997e-01f, 2.61932462e-01f, 3.23094040e-01f, -2.22079441e-01f, -3.76516581e-01f, 1.14185922e-01f, -1.52622461e+00f,
  -3.85505795e-01f, -1.05661534e-01f, -1.46054685e-01f, -1.56761296e-02f, 8.36313963e-02f, -1.73189733e-02f, 1.56663790e-01f, -9.56738591e-02f, 5.62258586e-02f, -1.45597339e-01f,
  2.12119669e-02f, 9.44098011e-02f, 3.58458698e-01f, -1.53233662e-01f, -9.29972902e-03f, -1.02131285e-01f, -5.10864332e-02f, -2.08868608e-01f, 3.53934355e-02f, -3.36765009e-03f,
  1.17523044e-01f, -1.12229310e-01f, 4.61009704e-03f, 7.89291784e-02f, -9.24771354e-02f, 1.76748067e-01f, 9.78995487e-02f, -3.21593545e-02f, -2.76753038e-01f, 1.31478876e-01f,
  7.41859376e-02f, 7.70134866e-01f, -2.64579952e-01f, 1.90084055e-01f, -3.85222211e-02f, 1.23102486e-01f, -1.25368372e-01f, 2.99552143e-01f, 2.16284111e-01f, -4.71970737e-02f,
  -1.22083001e-01f, -1.80740103e-01f, -6.99207857e-02f, -1.79331020e-01f, 2.27052514e-02f, -1.21006481e-02f, -3.30503851e-01f, -2.07444325e-01f, 1.56491175e-01f, -1.68085262e-01f,
  -2.24744707e-01f, -8.56141374e-02f, -5.12511618e-02f, -2.87135661e-01f, -4.15238261e-01f, 1.83558092e-01f, -3.82302254e-01f, -4.85458136e-01f, 1.62376553e-01f, -9.34398830e-01f,
  -2.35353723e-01f, -1.41778216e-02f, 5.94680488e-01f, 2.20106721e-01f, -2.73570567e-01f, -6.33342743e-01f, -6.56280935e-01f, -1.80396721e-01f, 2.74016321e-01f, -1.76234812e-01f,
  -5.07219613e-01f, -8.75175670e-02f, 1.64713442e-01f, 1.25929967e-01f, -2.01749846e-01f, -5.48318103e-02f, 4.17436391e-01f, 3.69955033e-01f, -9.17422846e-02f, -5.27575254e-01f,
  -1.90509066e-01f, -8.73365253e-03f, 6.72969818e-02f, 3.20225596e-01f, 5.61963618e-01f, 1.34859204e-01f, 5.28328776e-01f, 1.66350350e-01f, -7.14521259e-02f, 8.57025445e-01f,
  -1.46299526e-01f, 6.13784902e-02f, -1.15257733e-01f, -2.11796630e-02f, 1.63185567e-01f, 1.08625665e-01f, 1.07138604e-01f, 4.98674393e-01f, 1.54267065e-03f, 1.25571296e-01f,
  1.96386967e-02f, 6.56088591e-02f, 1.58403143e-02f, 1.23334853e-02f, -1.87429398e-01f, -2.31060788e-01f, 2.22045302e-01f, 2.48774737e-01f, 3.47070366e-01f, -1.63149938e-01f,
  -1.31942511e-01f, -4.97203350e-01f, -3.58133644e-01f, -6.18022829e-02f, 2.55655169e-01f, -7.72405118e-02f, -1.33467495e-01f, 7.99530372e-02f, -7.05421492e-02f, 2.50650287e-01f,
  -9.05465633e-02f, -4.56406772e-02f, 6.61487952e-02f, 2.03903720e-01f, 1.26543203e-02f, 1.70133822e-02f, 8.22934359e-02f, -8.43780190e-02f, 5.08977734e-02f, 9.95250866e-02f,
  1.36571929e-01f, 6.55189455e-02f, 1.28134876e-01f, 2.65628994e-02f, 5.81159890e-02f, 1.00670785e-01f, 1.08924724e-01f, -5.27967028e-02f, -1.37514979e-01f, 2.75484845e-02f,
  -7.45315030e-02f, 3.53094265e-02f, 3.03198665e-01f, 3.75338405e-01f, -2.36676764e-02f, 1.26002878e-01f, 1.38128430e-01f, -7.28197321e-02f, 9.45297703e-02f, -1.24864116e-01f,
  -1.51818439e-01f, -4.13436085e-01f, 7.05196261e-02f, 1.82207465e-01f, -2.89808549e-02f, 8.73825550e-02f, 1.55694216e-01f, -1.43188238e-01f, -2.93786731e-02f, -1.55016288e-01f,
  -2.21112162e-01f, -1.79973885e-01f, 4.87600500e-03f, 1.44013792e-01f, -2.18148172e-01f, 1.58844038e-03f, -1.09776780e-01f, -1.73783228e-01f, -9.25622508e-02f, 4.34134975e-02f,
  2.53003240e-01f, -5.66890061e-01f, -8.56841624e-01f, -4.20064628e-01f, -8.28328878e-02f, -4.85258758e-01f, -2.39003301e-01f, -2.20192492e-01f, -5.73225558e-01f, -7.43205786e-01f,
  1.27949429e+00f, 9.78445038e-02f, -1.15366912e+00f, 7.19379544e-01f, -4.27296728e-01f, -7.71293163e-01f, -5.95933914e-01f, 4.36297923e-01f, 5.48927665e-01f, -4.48838659e-02f,
  -3.60995591e-01f, 1.97104335e-01f, 1.89094953e-02f, -2.17478499e-01f, -3.14163268e-01f, -5.92566788e-01f, -6.00408375e-01f, -4.87412691e-01f, -3.77253473e-01f, 2.12885171e-01f,
  2.06417188e-01f, 3.78264934e-01f, 4.99572009e-01f, 6.17822073e-02f, 3.58773798e-01f, -2.74350476e-02f, -3.83348137e-01f, 3.04492619e-02f, -4.13755387e-01f, 1.26082636e-02f,
  -4.91221130e-01f, 3.36522609e-01f, -5.90034902e-01f, 1.34504229e-01f, -2.08753034e-01f, 2.65532792e-01f, 3.90068255e-02f, 4.07878198e-02f, 1.68054193e-01f, 9.42647830e-02f,
  -1.15311034e-01f, 7.63658360e-02f, -9.00087729e-02f, -6.24466734e-03f, 1.69701248e-01f, 1.43448517e-01f, 8.39854032e-02f, 2.73420773e-02f, 6.26600161e-03f, -1.10146590e-01f,
  -1.33510837e-02f, -3.91364634e-01f, -5.46918333e-01f, -2.87984818e-01f, -2.67190635e-01f, -1.81606710e-01f, -9.12125409e-02f, 8.19393024e-02f, -4.38912600e-01f, 4.76319373e-01f,
  -4.98385541e-02f, -1.76407360e-02f, 4.50876392e-02f, 1.38849560e-02f, 3.71560693e-01f, -4.83191982e-02f, 8.20290521e-02f, 4.65921126e-02f, 7.60866776e-02f, 1.17090233e-01f,
  -4.71470580e-02f, -2.11268701e-02f, -2.89989309e-03f, 4.17376347e-02f, 1.18469834e-01f, -1.04908854e-01f, -6.34327456e-02f, -7.24007487e-02f, 7.67927468e-02f, 1.07057214e-01f,
  -4.67918105e-02f, -1.03481151e-01f, -3.80668640e-02f, 6.26251325e-02f, -1.53877616e-01f, -1.60126388e-02f, -1.08321512e-03f, 9.47999507e-02f, 1.94625169e-01f, -5.71313836e-02f,
  3.54273617e-01f, -5.73131442e-01f, 2.61376828e-01f, -6.28863201e-02f, -9.65629146e-02f, -1.18540481e-01f, 1.53977811e-01f, -1.10181421e-02f, 2.53894329e-01f, 8.81842673e-02f,
  7.88189098e-03f, 6.86833560e-02f, -2.73466036e-02f, 4.06205021e-02f, 6.93448558e-02f, -2.56110542e-03f, 7.31416494e-02f, -1.86475441e-01f, -9.56025645e-02f, 3.89990732e-02f,
  1.38982415e-01f, -1.49804056e-01f, -5.54376747e-03f, -1.54807940e-01f, 9.15484205e-02f, -1.08372614e-01f, -1.03774771e-01f, -4.75045443e-02f, -4.64270741e-01f, 3.49988163e-01f,
  8.10814559e-01f, -3.44295472e-01f, -4.09264654e-01f, 2.30637297e-01f, 5.44290803e-02f, -5.59089594e-02f, 6.61017746e-02f, 8.70062560e-02f, 7.04318956e-02f, -2.72424202e-02f,
  -1.49693772e-01f, -1.08927444e-01f, -7.69499168e-02f, -1.31088972e-01f, 2.10952889e-02f, -2.09580478e-03f, -5.58751859e-02f, 6.11936077e-02f, 1.35635793e-01f, 1.45904288e-01f,
  -2.00661961e-02f, 1.90795600e-01f, 1.08667135e-01f, 5.55430278e-02f, -3.03685784e-01f, -1.59780413e-01f, -2.48675987e-01f, -1.36473998e-01f, -3.17952424e-01f, -2.48205498e-01f,
  -5.34506500e-01f, -2.55512387e-01f, 1.06983013e-01f, 7.41287023e-02f, -2.36421917e-02f, 6.96192086e-02f, -9.22934618e-03f, 1.17556311e-01f, 2.05676541e-01f, 1.51259318e-01f,
  5.72873726e-02f, -3.42656076e-02f, 8.97042640e-03f, -1.22143887e-01f, -1.97969563e-03f, 5.73823303e-02f, 3.11413240e-02f, -9.13319550e-03f, -1.22685947e-01f, -2.04657406e-01f,
  -2.31074840e-01f, -2.03906582e-03f, -8.15241877e-03f, 2.93193366e-02f, 2.42913850e-02f, -8.57948214e-02f, -1.18814625e-01f, -5.44489920e-02f, 1.39087690e-02f, 1.27172038e-01f,
  -6.58713561e-03f, -3.47062051e-02f, -9.17489976e-02f, -2.85050068e-02f, 1.60429657e-01f, 2.23280504e-01f, 1.29021972e-01f, 6.74616620e-02f, 1.43775111e-03f, 3.04151792e-02f,
  8.98019969e-02f, -1.70301020e-01f, 3.36204097e-02f, 2.02844411e-01f, -5.26847839e-02f, -2.26395994e-01f, 3.02379131e-02f, -3.32482643e-02f, -8.77228826e-02f, -7.33230039e-02f,
  -2.21784227e-02f, -1.12920880e-01f, -6.14487119e-02f, -1.14921652e-01f, -2.12434903e-01f, -8.37569460e-02f, -2.06460476e-01f, -1.27700984e-01f, -3.50140631e-02f, -5.52076772e-02f,
  -1.99065134e-01f, -2.59283543e-01f, 1.19783998e-01f, -1.84885457e-01f, -6.56132326e-02f, -1.24978229e-01f, -3.11722875e-01f, -1.28182955e-02f, 4.87104692e-02f, 1.72620248e-02f,
  -9.62533727e-02f, 3.21936095e-03f, -2.91461051e-02f, -4.09371927e-02f, 3.03203911e-01f, 1.48309097e-01f, 3.52184959e-02f, -6.89918697e-02f, 1.57432543e-04f, -1.60436198e-01f,
  -1.45288065e-01f, 1.90567836e-01f, 5.33604249e-02f, 6.93062246e-02f, 1.85488716e-01f, 1.38912275e-01f, 1.50199398e-01f, 1.14541508e-01f, 1.14572316e-01f, 4.90308195e-01f,
  -8.79799902e-01f, -2.38559961e-01f, -1.24822035e-02f, -2.03298442e-02f, 2.76050389e-01f, 1.50482804e-01f, 1.38975769e-01f, 1.14248917e-01f, -4.88904454e-02f, -8.65959749e-02f,
  -1.35257453e-01f, -7.13222399e-02f, -1.43821478e-01f, -1.18389398e-01f, -1.59795314e-01f, 9.20257717e-02f, 1.27334774e-01f, -1.16461284e-01f, -1.21941417e-02f, 1.87934801e-01f,
  3.35805081e-02f, -9.06034708e-02f, -1.48760542e-01f, -1.08506404e-01f, 2.38629669e-01f, 1.99957006e-02f, 1.47644300e-02f, 4.41206507e-02f, 3.12918164e-02f, 1.85419381e-01f,
  3.96600932e-01f, -4.06873137e-01f, -5.55441342e-03f, -1.31258115e-01f, -4.06519510e-02f, -8.56926590e-02f, -5.85316159e-02f, 4.70645055e-02f, -1.65488552e-02f, 2.54717410e-01f,
  -1.24462293e-02f, -8.32639113e-02f, -1.32688418e-01f, 1.47738650e-01f, 1.67064413e-01f, 9.18740705e-02f, 7.68249556e-02f, 5.07118255e-02f, 5.59903346e-02f, 1.56212404e-01f,
  9.18528363e-02f, 6.70175105e-02f, 2.46827245e-01f, -3.88113805e-03f, -8.95220861e-02f, -1.67900547e-02f, 6.75198203e-03f, -6.96718181e-03f, -6.02613613e-02f, 5.40956035e-02f,
  -1.25870064e-01f, 2.26800233e-01f, 2.69418360e-05f, -1.48611749e-02f, -1.05089083e-01f, 3.01288004e-04f, 2.23762318e-01f, 1.25191346e-01f, -5.00342175e-02f, 1.31917722e-03f,
  1.57893598e-01f, 3.39574218e-02f, -1.14468992e-01f, 9.95275378e-03f, -1.51942492e-01f, 5.65069765e-02f, -7.64663294e-02f, -1.67263988e-02f, -1.19824626e-01f, -5.11319973e-02f,
  -5.58874570e-02f, 1.78232744e-01f, -2.44276542e-02f, 5.67474738e-02f, 8.79285485e-02f, 9.48439389e-02f, 7.80759230e-02f, -1.10519402e-01f, 1.73271876e-02f, 1.15249470e-01f,
  5.32142043e-01f, -5.42576492e-01f, 2.20950842e-02f, -1.64584983e-02f, 6.21030554e-02f, -5.31287268e-02f, -7.70555660e-02f, 4.68558706e-02f, 1.48615092e-01f, 9.11654532e-02f,
  7.27008134e-02f, 4.07641977e-02f, -1.22478195e-02f, 9.99187827e-02f, 1.52796297e-03f, 4.78480794e-02f, 4.52562645e-02f, 6.31473288e-02f, 2.73860767e-02f, 1.77827954e-01f,
  1.94956139e-01f, 1.18644550e-01f, 2.55671620e-01f, 1.26362294e-01f, 2.75857951e-02f, 1.65534899e-01f, 9.27684680e-02f, 1.48274913e-01f, 2.45996565e-02f, 1.58294722e-01f,
  -7.43372083e-01f, 8.07953358e-01f, 4.57147211e-01f, -6.45413935e-01f, 2.02100009e-01f, 7.15111315e-01f, 1.13300395e+00f, 2.84937441e-01f, -3.43689561e-01f, 2.69525703e-02f,
  3.79524636e-03f, -4.58634228e-01f, -1.86460331e-01f, -7.80037567e-02f, 3.06329310e-01f, 5.20148814e-01f, 2.79143602e-01f, -1.12974882e-01f, -1.67934939e-01f, -3.41404341e-02f,
  -7.63521120e-02f, -2.19997168e-01f, -2.89142936e-01f, -1.74398318e-01f, -2.33777165e-01f, -3.86005878e-01f, -4.48116288e-03f, -9.35125053e-02f, 3.31893951e-01f, -2.48339877e-01f,
  -5.84907115e-01f, 9.28144976e-02f, -1.37551680e-01f, -2.29398221e-01f, -8.02446306e-02f, 4.14751917e-02f, 1.03143439e-01f, -1.23568244e-01f, 8.31369981e-02f, 9.29853842e-02f,
  -1.12309478e-01f, 4.60512079e-02f, -1.28175393e-01f, -8.41296539e-02f, -1.12173846e-03f, 2.72318661e-01f, 1.74133956e-01f, 1.11180596e-01f, -8.55212659e-03f, 5.76505587e-02f,
  1.52164668e-01f, -9.22495946e-02f, -2.92362887e-02f, 3.23827237e-01f, 3.44139189e-01f, -2.79215485e-01f, 3.17847170e-02f, -1.12923011e-01f, 1.19631119e-01f, -3.30227792e-01f,
  -6.51859269e-02f, 1.46415293e-01f, 1.78111941e-01f, 7.67274350e-02f, 6.19204678e-02f, -5.24707064e-02f, -3.59337367e-02f, -3.38905714e-02f, 1.91531479e-02f, 2.68679094e-02f,
  1.77372798e-01f, -1.73547432e-01f, -7.92081729e-02f, -3.60410549e-02f, -3.84840876e-01f, -8.51647928e-02f, 7.24292696e-02f, -5.46072833e-02f, -1.79193970e-02f, 1.13807172e-01f,
  -4.49270234e-02f, 1.16531728e-02f, -1.34495646e-01f, -9.07138512e-02f, 4.66052033e-02f, -6.46716729e-02f, -1.54845536e-01f, -2.98010558e-02f, -2.61262059e-01f, 4.75194827e-02f,
  -4.74382937e-01f, 4.67082471e-01f, -5.70318580e-01f, 2.69671660e-02f, -5.59776351e-02f, 2.57039398e-01f, 7.14994073e-02f, 1.08287960e-01f, -7.36563746e-03f, -1.10694682e-02f,
  2.54545540e-01f, -2.00788110e-01f, -1.28746107e-01f, 1.36243254e-01f, 5.93343657e-03f, 3.16669792e-02f, 4.09158990e-02f, -1.95222706e-01f, 1.41710090e-02f, -2.13558018e-01f,
  1.25280157e-01f, -2.15424493e-01f, -6.91084325e-01f, -2.36290738e-01f, -3.76481265e-01f, -8.87592494e-01f, -3.72261643e-01f, -3.87917161e-01f, -2.91489605e-02f, -2.91045070e-01f,
  -4.68546271e-01f, 4.86426234e-01f, 1.69783592e-01f, -2.13628128e-01f, 1.71898410e-01f, 3.68358284e-01f, 6.49324715e-01f, 3.19527268e-01f, -9.90298390e-02f, 3.03235084e-01f,
  6.97933808e-02f, -3.82383674e-01f, -2.88313776e-01f, -2.21182764e-01f, -1.32652104e-01f, 4.07563180e-01f, 1.07363231e-01f, -2.17759326e-01f, -2.91595936e-01f, -1.67578191e-01f,
  -1.56092703e-01f, -1.17867664e-01f, -2.35400289e-01f, -1.47982135e-01f, -7.28336647e-02f, -2.84464568e-01f, 1.90316573e-01f, 1.31214380e-01f, -5.22834323e-02f, -2.29010254e-01f,
  -6.86938092e-02f, -6.62953183e-02f, -3.80131751e-01f, -3.39008451e-01f, -2.73265280e-02f, 2.04061326e-02f, 6.01382330e-02f, 1.32253051e-01f, 1.00445114e-01f, 1.63224772e-01f,
  -1.10430315e-01f, -5.37754335e-02f, 1.18771242e-02f, 1.34676367e-01f, -1.70921301e-03f, 1.65119506e-02f, 1.02500310e-02f, 2.09155604e-02f, -4.33059856e-02f, 7.13728443e-02f,
  5.32840788e-02f, 1.14220351e-01f, 7.33831152e-02f, -3.16635817e-02f, 3.45274620e-02f, -2.15611771e-01f, 1.04706205e-01f, -1.24940716e-01f, -1.21454231e-01f, -8.52475539e-02f,
  -1.10449687e-01f, 2.15704348e-02f, -5.25295027e-02f, -7.16254264e-02f, 2.50789169e-02f, 7.98533764e-03f, 3.65487412e-02f, 1.41516790e-01f, 5.32120913e-02f, 1.18754273e-02f,
  2.20481262e-01f, 3.74900579e-01f, 3.10207844e-01f, 3.80343735e-01f, 1.47293404e-01f, 1.01619959e-01f, 8.47712234e-02f, 2.62807548e-01f, 1.18285865e-01f, 1.86621547e-01f,
  -9.63800699e-02f, 1.52687326e-01f, 9.49051082e-02f, 1.40021473e-01f, 2.51486421e-01f, 1.17755450e-01f, 3.41795608e-02f, 2.25176439e-01f, 4.37504277e-02f, 1.39844716e-01f,
  -1.27677858e-01f, -2.03576460e-02f, -1.87717214e-01f, -1.17696136e-01f, 5.16310111e-02f, 6.54406250e-02f, -3.85817438e-02f, 1.03548989e-01f, 8.95238966e-02f, 1.37313142e-01f,
  -3.56806777e-02f, 1.32330462e-01f, 2.21949950e-01f, 1.01090342e-01f, 4.24307995e-02f, 9.07045305e-02f, 8.08527321e-02f, 7.84355123e-03f, -6.26866147e-02f, 1.31831132e-02f,
  1.54503629e-01f, 1.72735095e-01f, 1.03331462e-01f, 7.14323893e-02f, 5.68089075e-02f, -7.51788914e-02f, 1.52064338e-01f, 2.37702802e-02f, 1.31347835e-01f, 2.50689119e-01f,
  7.93332338e-01f, -2.04656690e-01f, 2.88502485e-01f, 8.36107507e-02f, 9.61687565e-02f, 2.50340432e-01f, 7.26981238e-02f, 8.74762908e-02f, 1.16645910e-01f, 4.98543344e-02f,
  3.81960981e-02f, 2.58949518e-01f, 8.79434571e-02f, 3.05507006e-03f, 2.80286651e-02f, -1.07660994e-01f, 4.23977384e-03f, 2.71630079e-01f, 3.17063272e-01f, 2.16040134e-01f,
  1.08870305e-02f, -3.25634815e-02f, -8.27853754e-02f, -2.30663083e-03f, -9.46754813e-02f, -2.66555343e-02f, -1.77361280e-01f, -2.42233127e-01f, -1.92593902e-01f, -1.76457614e-01f,
  1.93688005e-01f, 9.96851847e-02f, 1.00838862e-01f, -1.46918759e-01f, 6.27563745e-02f, -1.64447576e-01f, 6.62815273e-02f, 1.28383376e-02f, -1.19364172e-01f, -2.26454318e-01f,
  -1.00865729e-01f, 3.76075283e-02f, 1.11657485e-01f, 3.28142731e-03f, -4.12411690e-02f, -1.86230463e-03f, -5.61482124e-02f, -2.18896158e-02f, -3.06048505e-02f, 3.34519632e-02f,
  -3.49683571e-03f, 6.60052150e-02f, 1.78568840e-01f, 9.31614190e-02f, -6.79167435e-02f, 1.13549098e-01f, 9.09447372e-02f, 8.47426504e-02f, 8.43484029e-02f, 5.42523386e-03f,
  -8.35063830e-02f, 1.78132996e-01f, 1.93127677e-01f, 1.17993005e-01f, 1.94245622e-01f, 1.50881454e-01f, -2.07800921e-02f, -5.86131625e-02f, 8.82226601e-02f, 1.97147563e-01f,
  1.04190812e-01f, -7.57574588e-02f, -1.31400585e-01f, -3.47008333e-02f, 5.76531291e-02f, 1.10904761e-01f, 1.60111949e-01f, -8.78809094e-02f, -2.76504401e-02f, -1.27641186e-01f,
  1.20350681e-01f, 3.26436870e-02f, 1.11228362e-01f, -1.81537420e-02f, -1.35000120e-03f, 1.74058005e-01f, 1.07044920e-01f, 1.77508313e-02f, 2.36315671e-02f, 5.09763807e-02f,
  -2.70126432e-01f, -1.30712673e-01f, 7.79579356e-02f, -4.19255719e-02f, -1.37981862e-01f, -8.15641284e-02f, -9.82591808e-02f, -1.32688642e-01f, -2.55469561e-01f, -2.36215785e-01f,
  -1.50629252e-01f, -2.59195417e-02f, -1.08921705e-02f, 4.88807373e-02f, 1.40445575e-01f, 5.82559779e-02f, 8.84730369e-03f, 1.30413085e-01f, -8.70118812e-02f, -1.30175740e-01f,
  -3.47095467e-02f, 8.96663070e-02f, 1.93392932e-01f, 1.97923020e-01f, -4.13243026e-02f, 2.07783103e-01f, 1.74975060e-02f, 1.20180860e-01f, 8.33105147e-02f, 1.45480409e-01f,
  5.37527978e-01f, -4.41102773e-01f, 2.15526000e-02f, 3.74716818e-01f, 2.85252422e-01f, 6.35712519e-02f, -9.45738554e-02f, 2.01310068e-02f, 1.35990828e-01f, 7.23506734e-02f,
  1.60005555e-01f, 3.46854508e-01f, 3.30783099e-01f, 8.62273499e-02f, 7.86656141e-02f, -1.00896344e-01f, -5.82795776e-02f, 2.43943557e-01f, 1.71299592e-01f, 1.65962592e-01f,
  7.13538602e-02f, 4.95557375e-02f, -1.92749116e-03f, 5.45183532e-02f, 6.51506037e-02f, 2.78018445e-01f, -6.69049621e-02f, 2.15199292e-02f, 8.14232379e-02f, -2.44535301e-02f,
  -7.15817437e-02f, -6.94722161e-02f, 2.40692019e-01f, 6.61077350e-02f, 2.15028506e-02f, -1.70369059e-01f, -1.50968619e-02f, -7.59997517e-02f, -1.12319559e-01f, -1.25680730e-01f,
  2.30903998e-02f, -1.08392492e-01f, -8.00410584e-02f, -9.34040025e-02f, -9.37051624e-02f, -2.98026800e-02f, -9.90553349e-02f, -6.39574751e-02f, -4.26308624e-02f, -2.67304797e-02f,
  5.71729504e-02f, 1.31239444e-01f, 1.05016775e-01f, 6.11683801e-02f, 1.27995212e-03f, 2.14598313e-01f, -3.78794260e-02f, 3.34633738e-02f, 3.39772343e-03f, -1.20852515e-01f,
  2.59060323e-01f, 3.47553566e-02f, 1.32822841e-01f, 9.40890312e-02f, 1.16339959e-01f, 6.21753708e-02f, -5.83306588e-02f, 1.20721469e-02f, 2.19255865e-01f, 3.90942283e-02f,
  5.45724072e-02f, 4.96155247e-02f, -9.27779824e-02f, 3.00799217e-02f, 1.89299583e-01f, 1.40776113e-01f, -8.96240100e-02f, -5.20920418e-02f, 1.34687826e-01f, 2.07354873e-01f,
  2.08513603e-01f, 1.57147460e-02f, 2.39089392e-02f, -4.87361476e-02f, -8.04208964e-02f, 7.67732263e-02f, 6.83880523e-02f, 5.83940595e-02f, 5.49948029e-02f, 1.65074646e-01f,
  -3.27090025e-01f, 2.61760890e-01f, 1.37804240e-01f, 7.21019283e-02f, -1.04274131e-01f, -1.85903326e-01f, 1.64815471e-01f, 9.33378562e-03f, -1.13491096e-01f, -1.25605434e-01f,
  -5.07625937e-02f, -6.62022308e-02f, -3.48439030e-02f, -5.82532585e-02f, 5.92720173e-02f, 7.34447837e-02f, 8.23951364e-02f, -4.45204079e-02f, -1.31993473e-01f, -1.28519744e-01f,
  -1.92035645e-01f, 5.06558316e-03f, -1.21431975e-02f, -6.93998560e-02f, -5.22329360e-02f, 2.35349536e-01f, -3.33897099e-02f, 5.28910756e-03f, 3.69715467e-02f, -1.02485172e-01f,
  7.24839926e-01f, 3.18271786e-01f, 3.94485235e-01f, 2.76361734e-01f, -1.13255300e-01f, -7.65126348e-02f, 2.37939153e-02f, 1.46210156e-02f, -1.92385241e-01f, 1.62321664e-02f,
  -7.56712407e-02f, -1.92777708e-01f, -1.85911372e-01f, -1.18842795e-01f, 1.30200014e-01f, -1.20828375e-02f, 7.11148605e-02f, 2.89640933e-01f, 1.92858219e-01f, 2.42532164e-01f,
  1.82119668e-01f, 4.94446695e-01f, 6.35208130e-01f, 1.49810120e-01f, 1.01676233e-01f, -5.05931966e-04f, 7.14407414e-02f, 3.52132946e-01f, 1.13768622e-01f, 3.35924268e-01f,
  3.04225087e-01f, 2.59403676e-01f, -4.05933708e-01f, -1.28282294e-01f, 8.72882456e-02f, 1.73436955e-01f, 1.17419042e-01f, 3.72249596e-02f, 5.79753779e-02f, 2.01988127e-02f,
  -1.52823642e-01f, 9.26409140e-02f, 4.47308160e-02f, 4.75992598e-02f, 1.36181325e-01f, -1.23663038e-01f, 1.20016158e-01f, -4.44024429e-02f, -7.64458091e-04f, -8.50232095e-02f,
  -9.70848948e-02f, -7.52687305e-02f, 3.27627957e-02f, -1.54504716e-01f, -6.99955821e-02f, -1.51543036e-01f, -4.52703498e-02f, -1.12753317e-01f, -1.26164526e-01f, 2.19257958e-02f,
  -2.10286856e-01f, -5.12993298e-02f, 2.39825472e-01f, 1.69510037e-01f, 1.81389868e-01f, -7.26183206e-02f, -1.75565585e-01f, -1.13634765e-02f, 1.79291606e-01f, 1.48505583e-01f,
  7.48977736e-02f, 3.81745160e-01f, 2.35914052e-01f, 1.66611075e-01f, -1.83534369e-01f, 1.79206312e-01f, 1.71352535e-01f, -4.86063883e-02f, 4.95053641e-02f, 1.41149029e-01f,
  2.63841152e-01f, 1.01496689e-01f, 2.42580116e-01f, 2.35401005e-01f, -5.76257370e-02f, -8.41770843e-02f, 1.21172681e-01f, 1.43585265e-01f, 9.17813629e-02f, 9.34851170e-02f,
  -5.34036197e-02f, -1.15994014e-01f, 2.06395872e-02f, 3.66846994e-02f, 1.12240635e-01f, 1.06043657e-02f, -8.45411643e-02f, -3.98121551e-02f, -1.03479117e-01f, -1.91468950e-02f,
  -3.06291133e-02f, -1.10500351e-01f, -2.93537285e-02f, 1.70402765e-01f, 1.93392336e-02f, -1.71254743e-02f, 3.35264280e-02f, -1.64229855e-01f, -6.71090260e-02f, -1.62209347e-01f,
  -1.43873855e-01f, -9.40223560e-02f, -6.09744899e-02f, -2.25771502e-01f, -1.06684297e-01f, -3.02316874e-01f, -1.19413435e-01f, -1.69798076e-01f, -1.80761740e-01f, -4.84811850e-02f,
  4.94691171e-02f, 7.84846902e-01f, 3.17683339e-01f, 1.57451406e-01f, 4.28314060e-01f, 1.63310207e-03f, -2.99320612e-02f, -1.13131709e-01f, 1.04610406e-01f, 4.04298902e-01f,
  2.52339989e-01f, -3.81027341e-01f, 6.68040514e-02f, -2.64831096e-01f, -6.08236730e-01f, 1.62744284e-01f, 2.20001519e-01f, -3.75182003e-01f, -9.04334843e-01f, -6.54233992e-01f,
  -3.22680920e-01f, -2.50251472e-01f, -4.64634269e-01f, -3.33651602e-01f, 4.70293373e-01f, -1.44900113e-01f, 4.61017042e-01f, 4.23689812e-01f, 1.47463158e-01f, 6.42073870e-01f,
  3.76258463e-01f, 6.65822208e-01f, -4.12215620e-01f, 1.46856651e-01f, 2.75410295e-01f, -2.44417191e-01f, -2.39856020e-01f, 2.11495474e-01f, -1.71381906e-02f, 1.76527724e-01f,
  3.18659782e-01f, 9.69521180e-02f, 2.66140699e-01f, 1.07175015e-01f, 1.27721597e-02f, -2.85318285e-01f, -1.01990670e-01f, -3.39806885e-01f, -1.64669052e-01f, 8.24477673e-02f,
  1.05798254e-02f, 1.69017419e-01f, 3.83648276e-01f, 4.50762957e-02f, 2.27840558e-01f, -2.16317356e-01f, 1.03694350e-01f, 1.12252375e-02f, -1.07194625e-01f, 3.49675417e-01f,
  -1.30373001e-01f, 1.11845315e-01f, 7.61167109e-02f, 7.81195015e-02f, -1.54845759e-01f, 1.75868541e-01f, 1.42790198e-01f, 4.70271707e-02f, -8.18568245e-02f, -3.75187099e-02f,
  -2.87398100e-02f, -1.01161800e-01f, 6.05378151e-02f, 2.48939227e-02f, -2.20717430e-01f, 7.89692551e-02f, 4.68862476e-03f, -2.73584157e-01f, 5.39278388e-02f, 2.12994572e-02f,
  1.19890040e-02f, 6.02434948e-02f, 4.71084705e-03f, -3.01217645e-01f, 3.80336978e-02f, 5.61830886e-02f, -8.71141478e-02f, -1.16930425e-01f, -1.31896809e-01f, 8.01309794e-02f,
  -2.84021050e-01f, -1.43130764e-01f, 3.41261085e-03f, -2.43732765e-01f, 6.08601011e-02f, 1.52920216e-01f, 1.29733130e-01f, -2.63742089e-01f, 2.79693007e-01f, -2.51145571e-01f,
  -1.27606392e-01f, -1.45047382e-01f, 1.84807017e-01f, -9.26792473e-02f, -3.83706450e-01f, -5.67461252e-02f, -1.49641767e-01f, -2.32880600e-02f, -2.72231430e-01f, 2.17741784e-02f,
  -1.21123470e-01f, -6.46417856e-01f, -3.66143078e-01f, -2.44786963e-01f, -6.69446364e-02f, -7.54679441e-01f, -1.42530724e-01f, -3.20849031e-01f, -4.32442755e-01f, -5.15334666e-01f,
  7.24200606e-01f, 4.54287201e-01f, 4.02986079e-01f, 1.43823624e-01f, -4.27787937e-03f, 5.99911958e-02f, 4.06519435e-02f, 3.17230681e-03f, 2.11068112e-02f, 1.66509315e-01f,
  2.35952586e-01f, 2.02884391e-01f, 4.83622663e-02f, 6.97556660e-02f, 8.63099620e-02f, -3.01921636e-01f, -2.77235746e-01f, -1.54230336e-03f, 9.99600217e-02f, -1.25442788e-01f,
  -3.89984339e-01f, -7.50357881e-02f, 2.20421121e-01f, 1.36902481e-01f, 3.99782285e-02f, -1.37092009e-01f, 1.16799168e-01f, 1.03874862e-01f, 5.98515831e-02f, -2.62820125e-01f,
  3.72177549e-02f, 4.80856299e-01f, -1.18388645e-01f, 8.69716704e-02f, 3.74257058e-01f, 2.39507139e-01f, 1.09568745e-01f, 2.01530263e-01f, 5.71552888e-02f, -1.47915166e-02f,
  1.82717413e-01f, 2.52488226e-01f, 5.94136901e-02f, 2.24522781e-02f, 8.94847363e-02f, 1.93555921e-01f, 2.11192280e-01f, -5.21998033e-02f, 5.47245611e-03f, 8.76623169e-02f,
  9.19599012e-02f, 1.12149470e-01f, 6.26724586e-02f, -4.23454419e-02f, 8.79970565e-02f, 9.87718180e-02f, 1.71007842e-01f, 1.47613853e-01f, 1.72996968e-01f, -1.48709593e-02f,
  2.01204136e-01f, -7.38461390e-02f, 2.09939584e-01f, 1.30819812e-01f, 2.72949431e-02f, -5.47893010e-02f, -8.60367268e-02f, -8.06930363e-02f, 8.24079141e-02f, 8.63223672e-02f,
  2.60006581e-02f, 6.54424056e-02f, 1.03704512e-01f, -8.38078037e-02f, 1.14928432e-01f, 8.62817690e-02f, 3.12177441e-03f, 1.30441472e-01f, 2.02123687e-01f, 2.18233585e-01f,
  1.79741666e-01f, -7.81361088e-02f, 1.32245347e-01f, 1.63440764e-01f, 3.91378105e-02f, -2.57084537e-02f, -3.19155715e-02f, 6.01488203e-02f, -6.38184696e-02f, -1.37954995e-01f,
  -4.43963595e-02f, 5.18338561e-01f, -1.36037007e-01f, 1.18568242e-01f, 1.24416813e-01f, 2.10741982e-01f, 1.82546481e-01f, 3.67617235e-03f, 6.39350526e-03f, -3.39198746e-02f,
  4.55195531e-02f, 4.52729501e-02f, 3.00460309e-02f, -3.93925942e-02f, -1.90251358e-02f, 1.81908719e-02f, 1.20706812e-01f, -6.24793693e-02f, 2.82454025e-03f, 8.60235319e-02f,
  9.59319435e-03f, -6.57666698e-02f, -1.68430619e-02f, -1.57175027e-02f, -1.51309341e-01f, -8.66706595e-02f, -1.28667980e-01f, -2.10974608e-02f, -1.19127044e-02f, -1.65164918e-01f,
  -5.14889896e-01f, 3.65325123e-01f, -1.04449475e+00f, 2.30772510e-01f, 4.51027632e-01f, -3.60725552e-01f, -4.34189349e-01f, -4.99765188e-01f, 2.78272718e-01f, 2.89568126e-01f,
  5.34662068e-01f, 4.58116382e-01f, -1.66796461e-01f, -2.39969492e-01f, -7.40742505e-01f, -1.78661034e-01f, -1.51482910e-01f, -8.41205835e-01f, -8.65903974e-01f, 5.20257987e-02f,
  7.15630233e-01f, 1.80142924e-01f, -3.45473051e-01f, -2.94467330e-01f, 5.97405493e-01f, 4.30967629e-01f, 6.88082576e-02f, 2.09670603e-01f, 1.99733034e-01f, 3.65546256e-01f,
  5.95693057e-03f, -4.56770986e-01f, 8.10252316e-03f, 3.28717023e-01f, 4.05514330e-01f, -2.31158614e-01f, -2.05677241e-01f, -1.29357889e-01f, -1.38478696e-01f, -2.13249098e-03f,
  2.45671034e-01f, -6.64148107e-02f, 1.17317662e-01f, 8.06835573e-03f, 6.73250258e-02f, -2.53016740e-01f, -3.63969386e-01f, -6.50246859e-01f, -7.68348336e-01f, -2.75773704e-01f,
  4.11516875e-01f, 5.20468295e-01f, -7.39002466e-01f, -3.16665918e-01f, -4.59894150e-01f, -1.47743806e-01f, -3.60931069e-01f, -2.62234449e-01f, -7.15341091e-01f, -3.17770392e-01f,
  6.36563823e-02f, -6.70185909e-02f, -1.04950801e-01f, -3.53301615e-02f, 1.07031256e-01f, 7.72567168e-02f, 5.33928983e-02f, 9.03897882e-02f, 8.16804096e-02f, -2.21229810e-02f,
  -1.43307775e-01f, -2.00667996e-02f, -1.59354895e-01f, -5.22135645e-02f, -6.54787049e-02f, 9.60000977e-02f, 3.33122127e-02f, -8.14552754e-02f, -2.55944937e-01f, 6.87831938e-02f,
  5.54417074e-03f, -3.56341433e-03f, 3.30189139e-01f, -8.96811709e-02f, 1.34310767e-01f, -8.72074664e-02f, 1.66880935e-01f, 2.18490228e-01f, -2.59886622e-01f, 4.21761200e-02f,
  4.45967913e-01f, 8.45435113e-02f, 2.68270876e-02f, 1.84553891e-01f, 4.46581505e-02f, -3.89839336e-02f, 1.52514935e-01f, 9.40280110e-02f, -7.82636255e-02f, -1.66198030e-01f,
  -1.33099899e-01f, -2.64267415e-01f, 4.55912352e-02f, -7.16485828e-02f, -1.47232354e-01f, -4.64052968e-02f, 1.23988584e-01f, 1.29627198e-01f, -1.42463997e-01f, 2.55353034e-01f,
  -4.81634848e-02f, -5.09150624e-02f, -2.09969953e-01f, -3.79949510e-01f, 2.18502164e-01f, -2.01609701e-01f, -2.39627436e-01f, -2.47825938e-03f, -5.16283691e-01f, -8.82352814e-02f,
  9.16264355e-01f, -6.44488215e-01f, -8.36479425e-01f, 4.73335683e-01f, 9.46700126e-02f, 5.57096899e-02f, 1.56171545e-01f, 4.75881726e-01f, 3.69169056e-01f, -1.49673879e-01f,
  -2.29809657e-01f, 3.41950096e-02f, -2.13205725e-01f, -9.43004042e-02f, 5.50079271e-02f, -2.43657917e-01f, -3.66829753e-01f, -1.21531643e-01f, 5.40031552e-01f, 5.54589510e-01f,
  2.93270141e-01f, 4.14737731e-01f, 3.22719723e-01f, 2.06538871e-01f, -1.66867197e-01f, -4.21056040e-02f, -5.40535390e-01f, -3.22504014e-01f, -2.98747182e-01f, -7.11215734e-01f,
  -5.33764780e-01f, -3.39635044e-01f, 1.21721268e-01f, -3.48387584e-02f, -2.21191689e-01f, 9.84446108e-02f, 1.48221448e-01f, 4.34867758e-03f, 4.94050570e-02f, 2.57074237e-02f,
  -1.22773170e-01f, 6.26084954e-02f, 1.19017279e-02f, -2.26161582e-03f, 1.48165241e-01f, 1.17511310e-01f, -9.72598866e-02f, -3.10162492e-02f, -1.44844666e-01f, -1.90957516e-01f,
  -1.84329167e-01f, 4.60231341e-02f, -9.98662561e-02f, -2.64949035e-02f, 1.23632364e-02f, -1.05164550e-01f, -1.16204284e-01f, 4.88566756e-02f, -1.71364069e-01f, -1.09708503e-01f,
  7.59897009e-02f, -1.00449190e-01f, -8.46581310e-02f, -1.91412140e-02f, 9.63945314e-02f, -1.03946961e-01f, 7.09060486e-03f, -5.88489957e-02f, -3.99003029e-02f, 1.13898247e-01f,
  1.13904029e-01f, -1.32641628e-01f, -3.26196440e-02f, -6.47553131e-02f, -7.54805207e-02f, -7.49463961e-02f, 1.12721592e-03f, -1.23647777e-02f, -1.28832668e-01f, 1.33518904e-01f,
  7.34098852e-02f, -1.64762527e-01f, -9.92179736e-02f, -6.67639775e-03f, -1.25968441e-01f, -2.21232846e-02f, -8.20390042e-03f, -6.69972748e-02f, 6.92612156e-02f, 9.31471661e-02f,
  3.73719811e-01f, -4.59737629e-02f, -1.00447461e-01f, 8.84373263e-02f, -2.35364512e-01f, -1.37741178e-01f, -2.62473643e-01f, -7.43795186e-02f, -1.05261788e-01f, -1.31096497e-01f,
  -6.71902150e-02f, 2.83450596e-02f, -1.66609064e-01f, -1.03946544e-01f, 2.20878690e-01f, -1.22319348e-01f, -4.65433300e-02f, 1.65499616e-02f, -8.44107047e-02f, 4.39047739e-02f,
  2.76277750e-03f, 1.82019681e-01f, 3.49355847e-01f, 3.81232053e-02f, 1.46483080e-02f, 1.79391518e-01f, 4.50352691e-02f, 5.18969633e-02f, 1.31007105e-01f, 4.18224901e-01f,
  -1.60712826e+00f, -4.56035763e-01f, -1.66505188e-01f, -5.87757766e-01f, 4.52467203e-01f, 3.06387842e-01f, -2.00384911e-02f, -4.15702730e-01f, -2.93569744e-01f, -3.83015662e-01f,
  7.54749253e-02f, 2.03753844e-01f, 3.69992182e-02f, 2.44723827e-01f, -1.96894020e-01f, 3.41783255e-01f, 6.94863498e-01f, 1.81763127e-01f, 8.25790688e-02f, 1.83727711e-01f,
  3.06624234e-01f, -2.05036059e-01f, -4.51559424e-01f, 3.65787484e-02f, 2.01938935e-02f, 9.25993249e-02f, 6.16250336e-02f, 9.65098143e-02f, 2.76910543e-01f, 2.04323396e-01f,
  -6.79602981e-01f, -8.07497859e-01f, 5.26278496e-01f, 1.46966368e-01f, -1.07269995e-02f, -2.97158152e-01f, -1.73050493e-01f, -1.82771310e-01f, 1.85577363e-01f, 1.53656546e-02f,
  8.56241137e-02f, 2.49023568e-02f, 6.95552155e-02f, 1.00500830e-01f, -2.46331751e-01f, -2.43327022e-01f, -7.34801814e-02f, -1.82369724e-01f, -3.35754633e-01f, -2.93817848e-01f,
  5.27374744e-01f, 1.41121313e-01f, -3.72433245e-01f, 2.68362641e-01f, -1.01504967e-01f, 6.04333915e-02f, -5.53099439e-02f, -1.81278020e-01f, -4.54761505e-01f, -8.78750205e-01f,
  -7.90294260e-03f, 1.38435915e-01f, 1.37096131e-02f, -1.64804339e-01f, 6.88824803e-02f, 1.88977167e-01f, 4.97443527e-02f, 1.23051539e-01f, 7.38944933e-02f, -1.71256229e-01f,
  1.70768037e-01f, 6.46180883e-02f, 1.45842999e-01f, -1.49291888e-01f, 7.64642730e-02f, -1.16082340e-01f, 1.08972467e-01f, -4.00556475e-02f, -5.36980713e-03f, -1.28644079e-01f,
  1.70253646e-02f, -1.27145946e-01f, -1.26367941e-01f, 6.86197057e-02f, 1.85474567e-02f, 3.79896648e-02f, -2.31286839e-01f, 8.78557116e-02f, -1.06505938e-01f, -1.38593391e-01f,
  -3.94168466e-01f, 4.96399194e-01f, -3.59451294e-01f, -8.50972012e-02f, -2.10731655e-01f, 2.75874622e-02f, 7.79083557e-03f, 1.05644047e-01f, -5.18211955e-03f, -9.84565765e-02f,
  1.86269358e-02f, -1.25380233e-01f, -1.41752109e-01f, 2.43277252e-01f, -8.10708478e-02f, -6.17423169e-02f, 1.62781149e-01f, 1.62343308e-01f, 1.15096219e-01f, -3.12704802e-03f,
  -1.39491316e-02f, -2.88383782e-01f, -6.00876212e-01f, -2.43697524e-01f, -6.47982880e-02f, -4.03169066e-01f, -3.67231905e-01f, -2.41475001e-01f, -5.19560933e-01f, -9.26003337e-01f,
  -5.39876103e-01f, -2.82568902e-01f, -4.56846863e-01f, -9.80941534e-01f, -1.88271642e-01f, 2.89146990e-01f, 7.85963386e-02f, -5.45789115e-02f, -3.06554586e-01f, -5.83985865e-01f,
  -2.50664167e-02f, 2.74286509e-01f, -1.22475736e-01f, 1.09511241e-01f, 2.31964990e-01f, -5.17532110e-01f, -5.55635035e-01f, 4.53012735e-02f, 4.72875506e-01f, 4.44619358e-01f,
  1.29694372e-01f, -3.66862774e-01f, -1.50385812e-01f, -1.27452044e-02f, -5.97601414e-01f, -1.41312867e-01f, -5.53696573e-01f, -1.76603064e-01f, 2.15922982e-01f, -6.71380103e-01f,
  -5.58581531e-01f, 1.12413615e-01f, 2.49931768e-01f, 2.10843965e-01f, -2.97627002e-01f, -4.43834886e-02f, -1.32038034e-02f, -1.74560979e-01f, -3.86550054e-02f, -1.51731938e-01f,
  2.76930183e-02f, 1.24449767e-01f, -1.10886931e-01f, -1.48075968e-02f, -2.71121681e-01f, -2.27479581e-02f, -1.60109729e-01f, 6.99099749e-02f, 5.80440052e-02f, 1.41215906e-01f,
  1.68288440e-01f, 1.89665854e-01f, 2.85552312e-02f, 2.15504855e-01f, 1.70175582e-01f, 1.85039848e-01f, 9.35207084e-02f, 4.69290912e-01f, 3.47243607e-01f, -3.34683299e-01f,
  8.93199593e-02f, -1.32213801e-01f, 1.19715422e-01f, 5.97404949e-02f, -2.20313389e-02f, 1.06719956e-01f, -2.74373963e-02f, -7.32942820e-02f, 1.44029528e-01f, -2.94745509e-02f,
  5.68710547e-03f, 1.10565238e-01f, -6.59017637e-03f, -3.51642147e-02f, -6.01401106e-02f, 5.00511639e-02f, 3.85385044e-02f, -7.19449148e-02f, -8.23630765e-02f, -5.29694408e-02f,
  1.12696767e-01f, 3.04058921e-02f, -3.25607695e-02f, 1.04779437e-01f, 2.85218716e-01f, -1.21557184e-01f, 1.17208846e-01f, 2.24428982e-01f, -5.62725663e-02f, 1.32081136e-01f,
  -7.16710448e-01f, 4.79071528e-01f, -4.46879536e-01f, 1.39908910e-01f, -9.72262919e-02f, 5.36743142e-02f, -1.44782647e-01f, -1.12302817e-01f, -1.61582440e-01f, -1.86101660e-01f,
  1.27461478e-01f, -1.32219121e-01f, -8.40943009e-02f, 7.21469671e-02f, -1.68157034e-02f, 7.50149637e-02f, 2.30148248e-02f, -1.06616490e-01f, 2.14080051e-01f, 2.06271391e-02f,
  2.14897878e-02f, 5.36207594e-02f, -6.62727579e-02f, -1.11940607e-01f, 9.83719751e-02f, 1.74599409e-01f, 4.61930186e-02f, 1.26038611e-01f, 1.80081964e-01f, -3.62932771e-01f,
  4.85252529e-01f, 6.93385005e-01f, 2.51574546e-01f, 3.27994406e-01f, 1.95956483e-01f, 4.07255739e-01f, 6.92324281e-01f, 4.15428430e-01f, 2.44121030e-01f, 2.67758727e-01f,
  2.32412547e-01f, 1.18458614e-01f, 1.26192898e-01f, 1.51219398e-01f, 2.84698218e-01f, 4.25573140e-01f, 2.76947409e-01f, 1.86044320e-01f, 3.44723426e-02f, 2.62280181e-02f,
  1.69874027e-01f, -1.59676988e-02f, 1.59278363e-02f, 1.74503237e-01f, 9.31276456e-02f, 2.31127329e-02f, 2.52351969e-01f, 5.07581271e-02f, 2.37326786e-01f, 1.35167256e-01f,
  -3.43706638e-01f, 1.07787028e-01f, -1.42771974e-01f, -8.16944316e-02f, -1.67087063e-01f, -1.06863700e-01f, -5.05895987e-02f, -5.16191423e-02f, -9.64537635e-02f, -5.17205559e-02f,
  -1.79944873e-01f, -1.52415112e-01f, -4.58882712e-02f, -9.80245173e-02f, -1.84905112e-01f, -1.27247304e-01f, 1.61465872e-02f, 4.52516265e-02f, 1.47828758e-01f, 8.68631676e-02f,
  -5.08931372e-03f, -1.65462285e-01f, -3.41025268e-04f, 6.11065812e-02f, 1.53904349e-01f, -1.49524033e-01f, 1.36023276e-02f, -8.42289105e-02f, -4.88161156e-03f, 5.44581600e-02f,
  6.88259676e-02f, 2.25478441e-01f, 6.88049793e-02f, -5.48115000e-02f, -1.82167962e-02f, -2.26040989e-01f, -6.70162812e-02f, 4.81878184e-02f, 1.20658815e-01f, -3.43842842e-02f,
  -1.40885934e-01f, -6.04099222e-02f, 5.30513451e-02f, -2.56076306e-01f, -1.43916875e-01f, -2.33708024e-02f, -1.91020556e-02f, -7.89683461e-02f, -1.48256242e-01f, 5.17503433e-02f,
  -1.25373855e-01f, 3.26407962e-02f, -2.39520952e-01f, 6.14609942e-03f, -1.35587007e-01f, -1.06309481e-01f, -1.38013527e-01f, -3.39959450e-02f, -1.39003217e-01f, 2.69233789e-02f,
  1.04637742e-02f, -7.98338428e-02f, 3.57532874e-02f, 2.35993251e-01f, 4.51089479e-02f, -8.17645639e-02f, 1.05550699e-01f, -1.08405232e-01f, -2.03225732e-01f, 3.50771435e-02f,
  4.97692600e-02f, 2.38794889e-02f, 2.48122178e-02f, -1.12022467e-01f, -1.79669276e-01f, -2.27835357e-01f, 5.78785539e-02f, 1.90928653e-01f, 3.26196551e-02f, 3.99182029e-02f,
  8.66530091e-02f, -4.70383875e-02f, 4.17574085e-02f, -5.91788739e-02f, -1.87013820e-02f, -1.79788545e-01f, -1.34532660e-01f, -1.77773759e-01f, -1.42739505e-01f, -1.72310144e-01f,
  6.48421794e-02f, 2.64691096e-03f, -5.45796931e-01f, 2.94381734e-02f, 4.89715815e-01f, -5.68501502e-02f, -2.98784554e-01f, -2.84699440e-01f, 2.77489075e-04f, 4.14626375e-02f,
  5.56734741e-01f, 2.11170763e-01f, -6.29754722e-01f, -6.89423501e-01f, -1.21507800e+00f, -8.86658728e-01f, -8.54875863e-01f, -1.04832423e+00f, -7.75569558e-01f, 4.15684938e-01f,
  6.73071742e-01f, 1.44089743e-01f, -4.30996776e-01f, -3.60745609e-01f, 1.65894911e-01f, -8.23511332e-02f, -2.09955722e-01f, 8.87800157e-02f, -6.44405931e-02f, -1.23545833e-01f,
  -1.15181431e-01f, 7.36126676e-02f, 1.04804978e-01f, 7.38495365e-02f, 3.70566010e-01f, 4.35991101e-02f, 6.74187988e-02f, -1.09388769e-01f, 1.24009535e-01f, -1.43293768e-01f,
  1.64480254e-01f, 1.12050407e-01f, 8.91581774e-02f, -5.55963479e-02f, 1.51447907e-01f, -1.03823610e-01f, 1.30298520e-02f, -2.62277156e-01f, -1.68021411e-01f, 2.38734975e-01f,
  3.48987877e-01f, 3.65378410e-01f, -4.10565168e-01f, -1.89927012e-01f, -2.50363618e-01f, -2.27166072e-01f, 1.87130496e-02f, 9.85143110e-02f, -3.72796446e-01f, -1.51659682e-01f,
  -7.18298182e-03f, -1.24989688e-01f, 3.45959544e-01f, 4.09409329e-02f, -5.05236126e-02f, 2.03238279e-01f, -9.33480784e-02f, -1.34426430e-01f, -6.20556846e-02f, 2.85379309e-02f,
  3.84909809e-02f, 2.05354869e-01f, 5.87362722e-02f, -5.74520044e-02f, -1.21020652e-01f, -6.47054091e-02f, -5.90845346e-02f, -1.69684350e-01f, -1.87566385e-01f, 4.77330126e-02f,
  -1.35394037e-01f, -7.58735761e-02f, 2.62726933e-01f, -1.33714125e-01f, -6.09144976e-04f, -2.48528272e-01f, -9.06501934e-02f, -2.33410358e-01f, -1.66597776e-03f, -1.26857430e-01f,
  -2.02851489e-01f, -8.64890665e-02f, -3.86712909e-01f, -3.11249793e-01f, -1.93774492e-01f, 2.84948081e-01f, 3.87454964e-02f, 3.19950879e-02f, 9.08339396e-02f, -2.62308307e-02f,
  -5.42583242e-02f, 1.98681410e-02f, 6.02695048e-02f, -5.54877566e-03f, -2.07010210e-02f, -1.80099830e-01f, 3.77636473e-03f, 2.37959921e-02f, -3.84894788e-01f, 4.79846179e-01f,
  -1.76302362e-02f, -3.90407354e-01f, -5.93320787e-01f, -2.73121506e-01f, 1.28296211e-01f, -4.65563089e-01f, -3.54745477e-01f, -2.46130332e-01f, -7.01728880e-01f, -3.93556058e-01f,
  -7.22357333e-01f, -2.76135355e-01f, -1.15344666e-01f, -7.25802660e-01f, -3.22860867e-01f, -1.65663302e-01f, -3.21354061e-01f, -1.14047557e-01f, -3.71402502e-01f, -6.06359839e-01f,
  3.07993531e-01f, 9.43565011e-01f, 4.36883539e-01f, 3.92475337e-01f, -6.10693032e-03f, -7.37753630e-01f, -8.29150856e-01f, -2.97362417e-01f, 4.70963776e-01f, 4.12605435e-01f,
  1.77228987e-01f, -2.11355120e-01f, -1.82947889e-01f, -2.34620169e-01f, -1.82157621e-01f, 7.29510635e-02f, -4.37423527e-01f, -2.66373664e-01f, -2.50640690e-01f, -5.87085783e-01f,
  5.59469163e-01f, 3.27187777e-02f, 4.83562946e-02f, -1.27454568e-02f, -3.29975113e-02f, -1.26778684e-03f, 9.01869610e-02f, -3.25456798e-01f, -1.69181731e-02f, -5.10045588e-02f,
  -8.36549923e-02f, 1.40449986e-01f, -5.03318086e-02f, -1.74562931e-02f, -2.53624558e-01f, 1.52965833e-03f, -2.84133017e-01f, -2.41077766e-01f, -1.11328259e-01f, 1.07673749e-01f,
  8.00591335e-02f, -1.12740010e-01f, 2.29440510e-01f, 1.71739295e-01f, 1.90147653e-01f, -1.40056685e-02f, 2.72153884e-01f, 2.02239797e-01f, -7.82408863e-02f, -3.21003765e-01f,
  -9.07122269e-02f, -5.45953698e-02f, -1.04884624e-01f, -7.87335709e-02f, -1.32815108e-01f, -1.17298283e-01f, -1.07996603e-02f, 6.78379983e-02f, 1.17080227e-01f, 1.52482959e-02f,
  3.56852543e-04f, -6.74368739e-02f, 1.22127235e-01f, 8.05867463e-02f, -4.82666567e-02f, -2.35729590e-01f, 3.56936157e-02f, -4.19806764e-02f, -2.77093612e-02f, -1.63002610e-01f,
  2.23195162e-02f, 8.72500166e-02f, -1.90278843e-01f, 3.84286158e-02f, -2.12549239e-01f, -2.11240351e-01f, -6.55025691e-02f, 9.41527709e-02f, -4.26256619e-02f, -9.21765119e-02f,
  5.40208220e-01f, 6.09242469e-02f, 2.42712125e-02f, 1.45639360e-01f, -2.96094090e-01f, -1.96563914e-01f, -1.12588275e-02f, -8.78514871e-02f, 4.58543897e-02f, 2.10096851e-01f,
  3.05634439e-01f, 1.61834866e-01f, -2.57190168e-01f, -1.46311760e-01f, -1.24434248e-01f, 7.75486454e-02f, -4.53799725e-01f, -1.86026618e-01f, -2.45784238e-01f, -1.85742706e-01f,
  -4.19289589e-01f, -1.59501985e-01f, 5.91453761e-02f, -1.97615810e-02f, 1.18170576e-02f, 1.42823800e-01f, 2.91566819e-01f, 2.63989449e-01f, -1.06599651e-01f, -3.81583691e-01f,
  2.76394039e-01f, -5.05523920e-01f, -3.53759617e-01f, -3.38175297e-01f, -2.66578555e-01f, 1.13611683e-01f, -1.23569623e-01f, 7.96436891e-02f, 1.30592167e-01f, -3.38136226e-01f,
  -9.37903002e-02f, 1.98781669e-01f, 1.04967533e-02f, -1.48098320e-01f, -8.46154690e-02f, -4.01089996e-01f, -3.71773958e-01f, -1.37300462e-01f, 3.26434195e-01f, 2.92103142e-01f,
  -7.32728988e-02f, -8.84961039e-02f, -2.69319378e-02f, 1.20863933e-02f, -2.82945246e-01f, -1.43759444e-01f, -2.52549618e-01f, -1.43909961e-01f, -1.52020857e-01f, -4.73146260e-01f,
  -1.75632447e-01f, 1.80841655e-01f, 2.17250392e-01f, 5.93855754e-02f, -1.13473281e-01f, 7.00672865e-02f, -7.84139708e-02f, -7.31578395e-02f, 8.17435384e-02f, -1.01494148e-01f,
  -1.03847357e-02f, -8.03149641e-02f, 1.20746322e-01f, 6.93130568e-02f, 8.97817537e-02f, 4.40086238e-02f, 1.22742958e-01f, 1.51448503e-01f, 2.73486022e-02f, -1.47252008e-01f,
  -1.85114462e-02f, 7.69689903e-02f, 8.92399400e-02f, 1.51677772e-01f, 2.99834281e-01f, 9.85184833e-02f, 5.26959896e-02f, 8.26087520e-02f, 1.85468093e-01f, 7.60997161e-02f,
  3.75044346e-02f, 6.55084848e-02f, 1.70761600e-01f, 2.38213554e-01f, 1.98971793e-01f, 2.17572540e-01f, 8.98626074e-02f, 6.13106750e-02f, 1.01468004e-01f, 9.15996954e-02f,
  -3.80400345e-02f, 1.15292609e-01f, 1.41584694e-01f, 4.36195463e-04f, -3.02155986e-02f, -6.82927519e-02f, 8.16613287e-02f, 5.00219800e-02f, 1.04206000e-02f, 4.23727818e-02f,
  9.74338204e-02f, -3.75247300e-02f, -2.69433796e-01f, -7.60472342e-02f, -1.18466116e-01f, -6.25224933e-02f, -3.66951637e-02f, 8.35440084e-02f, -8.26429948e-02f, -4.78596538e-02f,
  -8.94541144e-02f, 2.29437739e-01f, -1.83408577e-02f, 3.45786996e-02f, 3.81952077e-02f, -3.09889596e-02f, 8.34073573e-02f, -9.72141027e-02f, -1.33819088e-01f, -1.50050223e-02f,
  8.20810124e-02f, 3.64209600e-02f, -1.20768905e-01f, 1.19957283e-01f, 1.40987813e-01f, 1.75560057e-01f, 1.05466165e-01f, 3.73412296e-02f, 1.00001146e-03f, -7.45941475e-02f,
  -1.86510056e-01f, 2.06003100e-01f, 2.04485673e-02f, 1.15949951e-01f, 2.43348509e-01f, 2.70788781e-02f, 4.55949232e-02f, 1.67063884e-02f, 1.04176417e-01f, -6.07541874e-02f,
  6.78896829e-02f, 3.78502727e-01f, -9.07927990e-01f, -1.07738581e-02f, -8.57010841e-01f, -8.34540069e-01f, -2.32518360e-01f, 2.28375256e-01f, 1.36762917e-01f, 2.55572617e-01f,
  5.65639846e-02f, -1.86830282e-01f, 1.45491287e-01f, -2.07683235e-01f, -1.56158417e-01f, 2.71926016e-01f, -4.29801196e-02f, -7.54510403e-01f, -1.20442486e+00f, -1.11097181e+00f,
  -5.23335636e-01f, -3.95002484e-01f, -5.63122809e-01f, -4.64156091e-01f, -6.09796792e-02f, -3.63024920e-01f, 1.35000080e-01f, -3.24626178e-01f, -4.34862822e-01f, -1.12754077e-01f,
  -1.98403805e-01f, -2.30589479e-01f, -2.79820740e-01f, -1.95204660e-01f, 4.72601429e-02f, -8.77687708e-03f, -2.80881315e-01f, 6.25857562e-02f, 7.02700019e-02f, 4.78720926e-02f,
  -1.42000884e-01f, -4.11427051e-01f, -3.53356093e-01f, -3.24759275e-01f, -3.75679642e-01f, -4.94325966e-01f, -9.21464115e-02f, -3.70483309e-01f, 4.53130566e-02f, -1.75330877e-01f,
  -3.43458384e-01f, -5.71628809e-01f, -2.50423729e-01f, 1.19412050e-01f, -9.74773094e-02f, -2.60768563e-01f, -2.25329429e-01f, -3.40592206e-01f, -2.33010486e-01f, 5.33181667e-01f,
  8.97322372e-02f, 2.34119236e-01f, -1.38654515e-01f, 7.62844756e-02f, 1.07798830e-01f, 9.34801996e-02f, -3.96186933e-02f, -4.77260500e-02f, -2.80703680e-05f, 1.97961554e-03f,
  -1.46314288e-02f, 1.23274386e-01f, -1.08363762e-01f, 1.48893565e-01f, 7.96329696e-03f, -1.92109928e-01f, 1.19715203e-02f, 1.15373626e-01f, 5.57880253e-02f, 8.05536956e-02f,
  -1.07038796e-01f, -1.82554111e-01f, 2.49602944e-02f, -8.21084343e-03f, -4.27976483e-03f, 4.63174284e-02f, 1.12615516e-02f, -7.10311085e-02f, -2.99893860e-02f, -1.83590800e-01f,
  6.25107944e-01f, -2.28536308e-01f, 7.62770414e-01f, 4.49577831e-02f, 6.89824868e-04f, -3.64759751e-02f, 1.51513398e-01f, -1.05923980e-01f, 3.08890641e-02f, -2.62576759e-01f,
  -3.42499018e-01f, -9.57339555e-02f, 3.48211080e-02f, 2.67415424e-03f, -2.01480970e-01f, -8.07291418e-02f, 2.57831156e-01f, -1.03750497e-01f, -1.60493720e-02f, -7.74539709e-02f,
  2.52951264e-01f, 1.06440239e-01f, 1.54147282e-01f, 5.14870942e-01f, 1.67635158e-01f, -1.22980401e-01f, 2.98708022e-01f, -8.45236033e-02f, 2.50046421e-02f, 8.34661424e-01f,
  9.99135435e-01f, 2.75981486e-01f, -2.66016215e-01f, 1.35518014e-01f, -1.72909498e-01f, -6.00598194e-02f, -1.34100327e-02f, 1.07194774e-01f, 1.48815259e-01f, 2.61304796e-01f,
  3.79107445e-01f, 3.90508533e-01f, 3.43846887e-01f, 1.51498437e-01f, 1.48624122e-01f, -1.60630345e-01f, -2.78810680e-01f, -1.41838625e-01f, -2.59020608e-02f, -4.34369296e-02f,
  3.95056680e-02f, -1.42312795e-01f, -1.49167306e-03f, -1.28694614e-02f, -1.85165644e-01f, 2.79398859e-02f, -1.09700158e-01f, -1.26820073e-01f, -2.35696197e-01f, -3.35985184e-01f,
  -6.39718592e-01f, -1.43865854e-01f, 3.70130390e-02f, 1.36725381e-01f, -4.62119915e-02f, 1.83410943e-01f, 4.17490043e-02f, 1.08262122e-01f, 1.94182947e-01f, -1.59358475e-02f,
  -9.53024067e-03f, 4.86372411e-02f, -5.71766077e-03f, 1.29428739e-02f, -5.69356345e-02f, -9.53658745e-02f, 1.04483970e-01f, 6.57065362e-02f, -4.77580167e-02f, 9.87352505e-02f,
  -1.09988730e-02f, 2.57414859e-03f, -8.31635445e-02f, 3.41355316e-02f, 4.87832800e-02f, 4.89944145e-02f, 3.17435078e-02f, -8.54859278e-02f, -3.33558880e-02f, 8.95582139e-02f,
  5.42367026e-02f, 5.79237044e-02f, 4.13667150e-02f, 3.08153816e-02f, 1.43335164e-01f, 5.73912896e-02f, 2.37837713e-02f, 2.38235220e-02f, 6.10627308e-02f, 1.23893544e-01f,
  4.84967269e-02f, -7.16327652e-02f, -1.15136959e-01f, -6.98788418e-03f, 3.39517072e-02f, -1.33369073e-01f, -4.91393209e-02f, -9.86906737e-02f, -7.98383504e-02f, -4.72491886e-03f,
  -1.09073617e-01f, 6.66690757e-03f, -6.38909638e-02f, -1.68601543e-01f, -5.73846102e-02f, 5.98821454e-02f, -5.21666333e-02f, 3.32543105e-02f, 4.88221832e-02f, 7.34912157e-02f,
  -2.84648806e-01f, -1.57222927e-01f, -1.33136408e-02f, -2.88725868e-02f, -8.43190104e-02f, 7.09992498e-02f, -2.73993593e-02f, -7.74877220e-02f, -2.14503407e-01f, -1.19056173e-01f,
  -1.53683856e-01f, -9.54693854e-02f, -4.53860909e-02f, -1.13231009e-02f, 5.65786585e-02f, -1.10017531e-01f, 1.78410158e-01f, 1.34713456e-01f, 3.38862487e-03f, -2.22009514e-02f,
  -1.13273822e-02f, 1.13258101e-01f, 7.51077309e-02f, 6.38467968e-02f, 9.24158618e-02f, 1.07063442e-01f, -5.52392798e-03f, -6.32743314e-02f, -6.40574284e-03f, 2.06493273e-01f,
  1.08594966e+00f, -1.21375807e-02f, -1.09788127e-01f, 5.25861606e-02f, -4.32109505e-01f, -4.89835083e-01f, -3.47535193e-01f, -1.08030543e-01f, 9.82350707e-02f, 1.17064402e-01f,
  2.89005395e-02f, 2.07094073e-01f, 1.72517031e-01f, 1.15696728e-01f, 1.36710525e-01f, -8.01714957e-02f, -8.94147381e-02f, 2.16412768e-01f, 1.74514085e-01f, 3.72060429e-04f,
  -4.67753746e-02f, 1.99588820e-01f, 3.56691837e-01f, 8.57425258e-02f, 5.91663755e-02f, 8.80603120e-02f, -8.68488699e-02f, -1.49309456e-01f, -1.63367823e-01f, 5.87960444e-02f,
  -8.01893622e-02f, 9.40490812e-02f, 9.54233781e-02f, 6.46029338e-02f, 2.44000880e-03f, 1.52444541e-01f, 1.68889746e-01f, -1.56145366e-02f, 2.87446715e-02f, -1.24283940e-01f,
  8.97240564e-02f, 6.22538552e-02f, -1.76083017e-02f, -9.30467546e-02f, -2.18439102e-01f, -1.10202208e-01f, 2.02917308e-02f, -1.78310983e-02f, -1.28879800e-01f, -1.67646006e-01f,
  -8.55861530e-02f, -9.96568576e-02f, -3.47683340e-01f, -1.91688389e-01f, 7.63547421e-02f, -2.39108149e-02f, -1.30827740e-01f, -1.08519286e-01f, -8.14705640e-02f, 6.61711767e-02f,
  -1.87332973e-01f, 5.87759875e-02f, -9.42561328e-02f, -2.08407968e-01f, -1.19602785e-01f, 9.33615398e-03f, -3.92983332e-02f, -8.97502378e-02f, 8.17837566e-02f, 4.43959087e-02f,
  -1.48831412e-01f, -7.40840808e-02f, -7.13036805e-02f, 7.75767118e-02f, 1.94414750e-01f, -1.36449456e-01f, -6.19874708e-02f, 7.98885943e-04f, -1.11503690e-01f, 1.97641402e-02f,
  8.03304277e-03f, -6.50895163e-02f, 4.19113785e-03f, -3.41632701e-02f, -7.83521682e-02f, -1.33078441e-01f, -4.58040088e-02f, 2.38947775e-02f, -7.00700954e-02f, 9.32722092e-02f,
  -1.11479320e-01f, 6.82733804e-02f, 3.47945213e-01f, 2.92472541e-01f, 4.90831807e-02f, 1.45860225e-01f, 1.12475127e-01f, -4.67291623e-02f, -9.38727520e-03f, -1.17485017e-01f,
  -8.72757062e-02f, 1.98738992e-01f, 5.40333726e-02f, 8.95069093e-02f, -9.35089123e-03f, 4.89472002e-02f, 1.67072684e-01f, 1.30523473e-01f, 3.29477116e-02f, -5.58552928e-02f,
  -4.51976508e-02f, -1.01591118e-01f, -2.10071355e-02f, 6.62483498e-02f, 6.57109693e-02f, 1.45038664e-01f, -4.49228510e-02f, 6.69441745e-03f, -4.17974479e-02f, 7.71701336e-02f,
  -1.24683276e-01f, -5.64238131e-01f, 1.12303354e-01f, 4.56619859e-01f, 4.64047521e-01f, 3.63997817e-01f, 7.61028752e-02f, 3.08761030e-01f, 4.43724751e-01f, 1.13280088e-01f,
  -7.72698820e-02f, 3.30764025e-01f, 2.82910436e-01f, 1.79252654e-01f, 2.13525563e-01f, 2.93930739e-01f, 4.12735343e-01f, 2.80433387e-01f, 2.75743067e-01f, 1.77618161e-01f,
  3.90393078e-01f, 1.95974723e-01f, 3.35722836e-03f, 3.08117680e-02f, 1.17304735e-01f, 3.48964334e-01f, 1.21091604e-01f, -2.10366119e-02f, 3.90611514e-02f, 1.07932851e-01f,
  -1.18292734e-01f, -2.36817434e-01f, 2.46725067e-01f, -9.01735574e-02f, -2.05150634e-01f, -2.40753442e-01f, 4.93249577e-03f, -1.21225730e-01f, -2.31350482e-01f, 1.72111131e-02f,
  -1.27331555e-01f, -1.53580070e-01f, -1.12906002e-01f, -9.12137106e-02f, -1.17436416e-01f, -1.63570315e-01f, -1.49383709e-01f, -7.14488029e-02f, 3.36450227e-02f, -1.19871445e-01f,
  2.50171293e-02f, -7.64994463e-03f, -8.76342319e-03f, 1.40910923e-01f, 1.57007918e-01f, 4.46922146e-02f, -1.87458441e-01f, -8.30660164e-02f, 7.17255995e-02f, 3.70996781e-02f,
  7.73497596e-02f, 7.03384802e-02f, 9.43638831e-02f, 1.17538929e-01f, 2.01658130e-01f, 1.69797435e-01f, 1.48094818e-01f, 1.46932647e-01f, 1.72254652e-01f, 1.03250831e-01f,
  7.71457627e-02f, 2.07911059e-01f, 1.25232726e-01f, 7.59069016e-03f, 1.53168291e-01f, -2.06290968e-02f, -4.10147123e-02f, -8.57937559e-02f, -6.58948347e-02f, -4.44562919e-02f,
  1.28020927e-01f, -4.43865135e-02f, -2.58331597e-01f, -5.10460101e-02f, -1.24042779e-01f, 6.24290900e-03f, 1.45406634e-01f, -1.52954897e-02f, 2.52162814e-02f, -1.80328991e-02f,
  2.19861656e-01f, 1.31248146e-01f, 1.37533814e-01f, -4.32129018e-02f, -1.36827230e-01f, -3.44513714e-01f, -3.92505247e-03f, -3.92920673e-02f, -1.71093598e-01f, 2.33331528e-02f,
  -8.08616877e-02f, -1.03969179e-01f, -6.20175190e-02f, -4.72713299e-02f, 1.40634298e-01f, 1.30097806e-01f, -1.72165796e-01f, 1.00652955e-01f, 7.98024610e-02f, -1.05377503e-01f,
  -7.95540437e-02f, 1.61267936e-01f, 1.64594427e-01f, 3.46678704e-01f, 2.08782747e-01f, 3.54053497e-01f, 1.35079220e-01f, 1.15257822e-01f, 1.65726289e-01f, 1.71438590e-01f,
  5.88252306e-01f, 2.10564107e-01f, 2.53206104e-01f, 3.59645963e-01f, 3.71359646e-01f, 1.30898029e-01f, -8.51874799e-02f, -2.43856534e-01f, -7.80979767e-02f, 1.86771303e-01f,
  3.58782828e-01f, 3.04591864e-01f, 1.89040542e-01f, 2.12890133e-01f, 3.40271480e-02f, -7.31234550e-02f, -3.56276408e-02f, 7.81066716e-02f, 1.36380464e-01f, 2.46677533e-01f,
  3.09515238e-01f, 1.43618658e-01f, 1.36396870e-01f, 1.94908995e-02f, 1.91235185e-01f, 2.21397877e-01f, 1.16425514e-01f, 3.20356637e-01f, 3.20274264e-01f, 3.56931955e-01f,
  1.76928967e-01f, 4.71804850e-02f, -3.02134424e-01f, 3.18074003e-02f, 2.27473661e-01f, -1.44240901e-01f, -1.21990234e-01f, -2.08579093e-01f, 1.92948338e-02f, -1.18703403e-01f,
  1.31326109e-01f, 3.45004685e-02f, 4.40402143e-02f, -5.69372065e-02f, -5.16612306e-02f, -7.87844136e-02f, -1.21917903e-01f, -1.59227267e-01f, -1.44909427e-01f, -1.11944988e-01f,
  2.98559248e-01f, 2.22665280e-01f, -5.09963147e-02f, -1.09108567e-01f, 7.56776705e-02f, 5.21675162e-02f, -5.61184511e-02f, 5.46858273e-02f, -1.28039688e-01f, 1.27032427e-02f,
  1.06803074e-01f, 2.38891214e-01f, 2.69476950e-01f, -1.10057347e-01f, 3.03819235e-02f, -1.16098695e-01f, -6.97557256e-02f, 2.02950940e-01f, 1.09880693e-01f, -4.28972431e-02f,
  -9.67963133e-03f, 2.44599041e-02f, -1.66731313e-01f, 5.06015942e-02f, 1.12510026e-01f, 1.83092982e-01f, 1.37427002e-01f, -4.31830995e-02f, 1.34931743e-01f, -6.81062862e-02f,
  -1.66655574e-02f, -9.57519189e-02f, -1.10285886e-01f, -1.77133858e-01f, -2.20130891e-01f, -2.75679752e-02f, 3.20447907e-02f, 7.73335919e-02f, 6.73073307e-02f, -4.87983339e-02f,
  -3.61005217e-01f, -9.61552002e-03f, -1.42221048e-01f, -1.79042861e-01f, 7.61876330e-02f, -8.90808925e-02f, 1.85268268e-01f, -9.25625861e-03f, -2.71130372e-02f, -2.11557075e-01f,
  6.44557849e-02f, 4.74058762e-02f, -4.47901450e-02f, -1.96502879e-01f, -1.67837933e-01f, -2.27033556e-01f, -2.79567689e-02f, 2.68408144e-03f, -2.24168018e-01f, -3.70225199e-02f,
  -1.04396120e-01f, -1.49020195e-01f, -1.96775213e-01f, -2.49069810e-01f, -1.36369884e-01f, -1.82206541e-01f, -1.35056883e-01f, -9.06005353e-02f, -1.89249650e-01f, -3.40538889e-01f,
  -3.52124780e-01f, -2.34933108e-01f, 3.24076861e-01f, -6.38459399e-02f, -7.91235566e-02f, -4.45226192e-01f, -7.68243790e-01f, -6.43899202e-01f, -2.00238660e-01f, -2.82148808e-01f,
  -7.27171004e-02f, 3.05550903e-01f, 4.77504104e-01f, -9.65763852e-02f, -4.38458025e-01f, -4.81675327e-01f, -2.95911074e-01f, -2.46094123e-01f, -4.00390595e-01f, -6.34233475e-01f,
  -5.33379674e-01f, -4.46753830e-01f, -3.27664644e-01f, -2.59640574e-01f, 1.97210744e-01f, 2.46864304e-01f, 2.95369387e-01f, 2.53673084e-02f, 1.14261303e-02f, 2.88699269e-01f,
  1.68722734e-01f, 3.62011828e-02f, -1.06595293e-01f, -1.88051268e-01f, -1.22116119e-01f, -2.85343360e-02f, -6.74717268e-03f, 2.17474513e-02f, 4.15154919e-02f, -9.22318101e-02f,
  -7.35497400e-02f, 5.68426363e-02f, 1.21319331e-01f, 3.83670814e-02f, -4.91725393e-02f, -2.88852453e-02f, -1.95427716e-01f, -8.17380250e-02f, -9.93536487e-02f, -3.61465476e-02f,
  -3.05598117e-02f, -7.99668282e-02f, 4.08005975e-02f, -1.21113092e-01f, -6.06656931e-02f, 1.24161623e-01f, 1.16386347e-01f, 8.73614009e-03f, 5.11165150e-02f, 3.36750373e-02f,
  -9.26635414e-02f, 4.96049151e-02f, -8.73835981e-02f, 1.60532221e-01f, -6.23975806e-02f, 8.37197453e-02f, -2.80765835e-02f, -1.42835781e-01f, -4.81833741e-02f, -1.09415442e-01f,
  2.09395308e-02f, 1.39693677e-01f, -1.72300488e-01f, 6.07658587e-02f, -1.26838014e-01f, -8.56322646e-02f, -9.99644995e-02f, -7.31785148e-02f, -3.34544741e-02f, -1.30622551e-01f,
  -3.23201530e-02f, -8.74336138e-02f, 1.39683411e-01f, -9.97150242e-02f, -9.65133682e-02f, -1.09610841e-01f, -6.11578561e-02f, 8.79605487e-03f, -2.52021197e-02f, 8.86081252e-03f,
  2.15160027e-02f, 4.51769195e-02f, 1.66377515e-01f, -3.72526683e-02f, 1.27672374e-01f, 7.83627555e-02f, 1.44504398e-01f, 5.62063754e-02f, 1.33783415e-01f, -5.85011169e-02f,
  1.28814131e-01f, 7.21516758e-02f, 1.10295705e-01f, -7.49178976e-02f, 1.92735828e-02f, 5.91763742e-02f, -1.35057077e-01f, -9.65796690e-03f, 1.41999379e-01f, 9.04162414e-03f,
  -1.87429264e-01f, -1.27141237e-01f, 4.37800847e-02f, -6.49749907e-03f, -1.68038800e-03f, 2.40824267e-01f, 2.53577828e-01f, 1.36675030e-01f, 2.29050055e-01f, -7.39789009e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.68362260e-01f, 8.20390284e-01f, 8.83781254e-01f, 5.81995428e-01f, 4.78200912e-01f, 7.74930596e-01f, 8.30420434e-01f, 5.39486468e-01f, 4.44437683e-01f, 6.86776817e-01f,
  5.76584578e-01f, 4.27560568e-01f, 3.38535845e-01f, 8.39882672e-01f, 9.00805295e-01f, 1.38236418e-01f, 3.06051522e-01f, 5.42478085e-01f, 4.57256794e-01f, -3.95970009e-02f,
  6.09155118e-01f, 4.14500624e-01f, 6.60883546e-01f, 4.82309520e-01f, 5.79194009e-01f, 4.36745316e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.51346818e-01f, 5.99718606e-03f, -8.77894983e-02f, 2.03769878e-01f, -7.75091425e-02f, 1.46374898e-03f, -1.90804705e-01f, -3.18439960e-01f, -2.97099203e-01f, -1.88828677e-01f,
  1.16047524e-01f, -2.14016899e-01f, 2.30525266e-02f, -1.40021041e-01f, 5.86551726e-02f, -2.41924673e-01f, -1.81334063e-01f, -1.86066955e-01f, -2.41496503e-01f, -1.83516175e-01f,
  -1.32794768e-01f, -2.29094148e-01f, -1.24476463e-01f, 6.50839061e-02f, -1.82197139e-01f, 2.60448959e-02f, -3.07791121e-02f, -1.69764027e-01f, -2.18360305e-01f, -1.48865893e-01f,
  -9.05158669e-02f, -5.35810972e-03f, -3.19487959e-01f, 4.22943607e-02f, 4.23170291e-02f, 2.53716353e-02f, 4.73625027e-02f, -9.17287245e-02f, -8.99119824e-02f, 8.73192959e-03f,
  -1.05524443e-01f, -8.26452300e-02f, -4.63402458e-02f, -5.39859347e-02f, -4.55774739e-02f, -1.86439529e-01f, -1.62591770e-01f, 4.22397032e-02f, -1.39489800e-01f, 5.05741686e-02f,
  -2.47153565e-02f, 2.08042301e-02f, 5.75678684e-02f, -1.10745868e-02f, -1.09419059e-02f, -4.99857031e-03f, -1.99575201e-01f, 1.01350129e-01f, 1.96493063e-02f, 1.09909521e-02f,
  4.34406511e-02f, 5.14128879e-02f, 2.52595514e-01f, -2.02256486e-01f, -2.75604248e-01f, 1.81717530e-01f, 2.99406469e-01f, -1.45005509e-01f, 2.59970933e-01f, -2.01552495e-01f,
  -3.37349027e-01f, -1.50404006e-01f, -2.68395066e-01f, -2.27581829e-01f, -2.93034464e-01f, 2.51218885e-01f, 3.95813227e-01f, -3.18549052e-02f, -1.25908419e-01f, 1.93591818e-01f,
  -2.11240098e-01f, 4.21099700e-02f, 3.17562930e-02f, -1.86592668e-01f, -2.00750679e-03f, -4.79987636e-03f, -1.00418173e-01f, -1.08446799e-01f, -4.51879382e-01f, -2.81173557e-01f,
  1.31749719e-01f, -2.12938905e-01f, 8.15127939e-02f, 2.50665620e-02f, -3.51093635e-02f, -8.49175379e-02f, -8.11725575e-03f, 1.72532305e-01f, -6.69657672e-03f, 7.16752112e-02f,
  1.55304000e-01f, -4.58112359e-02f, 2.82023013e-01f, -5.22117853e-01f, 4.98234928e-01f, 6.60393806e-03f, 9.95567590e-02f, -2.60510534e-01f, -7.04815269e-01f, -2.57954448e-01f,
  -3.90835613e-01f, 7.47728348e-02f, -1.21413386e+00f, 1.26956254e-01f, 7.74795189e-02f, 5.06507456e-01f, 9.79644433e-02f, 4.38808471e-01f, -2.17963487e-01f, 3.64661962e-01f,
  3.31162423e-01f, 3.84017080e-01f, -3.25091511e-01f, -1.43887416e-01f, -2.09214211e-01f, -7.00493932e-01f, -2.97618836e-01f, -5.09116590e-01f, 2.39597857e-02f, -1.56864077e-02f,
  -2.09691465e-01f, 1.84553843e-02f, 1.04132839e-01f, -1.50686070e-01f, 9.90099758e-02f, 7.92045668e-02f, -2.00595707e-01f, -1.43526392e-02f, -7.96248466e-02f, 5.94031624e-02f,
  1.18397571e-01f, -4.20279019e-02f, -5.11012711e-02f, 1.68626204e-01f, -1.50716268e-02f, 1.05538644e-01f, 9.77279544e-02f, 6.03298135e-02f, 2.64012571e-02f, -1.42326221e-01f,
  -4.73767146e-02f, -1.22123532e-01f, -2.10199580e-01f, -5.05114757e-02f, -1.50979280e-01f, -1.94128439e-01f, 1.99840710e-01f, 9.18269828e-02f, 5.09877875e-02f, -9.53755751e-02f,
  1.02976613e-01f, 1.54114529e-01f, -6.98967203e-02f, 2.49160845e-02f, -1.69015244e-01f, -3.84268425e-02f, 1.25178769e-01f, 6.38623387e-02f, -7.18527241e-03f, -1.23345861e-02f,
  3.65702156e-03f, 5.41661866e-02f, 1.01957232e-01f, 2.59197075e-02f, 1.34628162e-01f, 2.70212945e-02f, 1.40192524e-01f, 1.75322130e-01f, -1.95248052e-01f, -1.56159282e-01f,
  -2.40552220e-02f, 1.98792815e-01f, -1.23348013e-01f, 9.97709930e-02f, 4.24344718e-01f, -2.07036033e-01f, -4.32387441e-01f, 2.73061246e-01f, -1.32188141e-01f, 1.00333765e-01f,
  -5.25616780e-02f, -2.23673001e-01f, -4.82720248e-02f, 1.22909009e-01f, 6.60571968e-03f, -1.81743965e-01f, -1.85132608e-01f, -2.92950630e-01f, -1.26388833e-01f, 5.99736609e-02f,
  8.98873582e-02f, 1.74341872e-01f, -4.31532115e-01f, 3.94592464e-01f, 9.73648727e-02f, 2.45034069e-01f, 3.63503359e-02f, 2.48492256e-01f, 1.36035562e-01f, -2.49647766e-01f,
  1.25216946e-01f, -2.14639157e-01f, 6.64533675e-02f, 1.03042684e-01f, 9.44085345e-02f, -1.85578629e-01f, -2.19993088e-02f, -1.55511603e-01f, 1.77931696e-01f, 1.54522210e-01f,
  4.07944322e-02f, -1.41896401e-02f, 1.41638145e-01f, -1.75599322e-01f, -5.80143668e-02f, 2.61981308e-01f, 3.13166678e-01f, -1.22551084e-01f, 3.71656716e-02f, -2.32213661e-01f,
  9.17864025e-01f, -7.85519361e-01f, -1.28534406e-01f, 1.36446521e-01f, -4.25490290e-01f, -8.45315695e-01f, -3.92491192e-01f, 2.51146704e-01f, 3.84711683e-01f, -1.92552656e-02f,
  -4.91730332e-01f, -2.35321335e-02f, -1.44194043e+00f, 1.18230432e-01f, -1.19530022e+00f, 4.20776159e-01f, 8.99672434e-02f, -1.35333538e+00f, 1.89686954e-01f, 3.64735246e-01f,
  -1.96577776e-02f, 3.04890186e-01f, 2.02840030e-01f, 1.82239294e-01f, 3.43179405e-01f, -1.08016044e-01f, -1.56202480e-01f, 9.61958990e-02f, 1.46961480e-01f, 8.19083024e-03f,
  1.12121187e-01f, 1.37712592e-02f, 1.26814961e-01f, 7.81074092e-02f, 4.00067605e-02f, 6.28196821e-02f, 1.52353942e-02f, -3.82174030e-02f, -8.76259431e-03f, 5.45242876e-02f,
  4.45131063e-02f, 1.98651657e-01f, 6.82119355e-02f, 3.56499664e-02f, 1.02751911e-01f, 3.72152999e-02f, 1.06372781e-01f, 1.15343638e-01f, 1.53450564e-01f, 4.39402871e-02f,
  -1.49759859e-01f, -4.64176312e-02f, 1.21028684e-01f, 2.31222868e-01f, -1.56439751e-01f, 2.41084605e-01f, 9.78122875e-02f, 5.27358241e-02f, -3.65433544e-02f, -1.93129852e-02f,
  2.13381991e-01f, 1.37682766e-01f, 3.07651376e-03f, 6.18439391e-02f, 3.18586648e-01f, -3.97297032e-02f, 1.22997221e-02f, 9.37796086e-02f, -1.75212836e-03f, 7.95343295e-02f,
  7.92958215e-02f, 1.37563080e-01f, -2.16812491e-02f, 6.35953248e-02f, 2.98544653e-02f, 1.10762812e-01f, -7.25672692e-02f, 2.07506448e-01f, -2.52436459e-01f, -2.41538823e-01f,
  1.40527010e-01f, 2.44742632e-01f, 1.37376152e-02f, 1.03424728e-01f, -1.08367935e-01f, 4.34401184e-01f, 2.00367793e-01f, -2.27898240e-01f, 2.36433342e-01f, -1.18207432e-01f,
  1.99229922e-02f, 9.14942920e-02f, 2.59696782e-01f, -3.42994392e-01f, -2.65418172e-01f, -3.93610179e-01f, -1.42466053e-01f, 1.26230091e-01f, -4.17531580e-02f, 6.91296384e-02f,
  1.48381203e-01f, 4.22511518e-01f, 3.33358571e-02f, 2.13763013e-01f, -2.10504338e-01f, 3.09217662e-01f, 7.48334229e-02f, -1.52573913e-01f, 4.93596382e-02f, -1.10239156e-01f,
  2.46796757e-01f, 1.81933463e-01f, -1.31871060e-01f, 2.27635652e-01f, 2.63676971e-01f, -3.92846055e-02f, -2.47602120e-01f, 2.11372636e-02f, -1.91104084e-01f, 5.01963273e-02f,
  2.84087390e-01f, 1.86493412e-01f, 2.03347102e-01f, -3.07277918e-01f, 8.32932442e-02f, -1.72743827e-01f, 6.35743290e-02f, -3.88678402e-01f, 9.02576208e-01f, 7.33620346e-01f,
  -1.02138817e+00f, 4.73806560e-02f, -1.51609197e-01f, -6.70108274e-02f, -5.45518756e-01f, -1.23269707e-01f, 8.81575495e-02f, -2.03142405e-01f, -7.19952762e-01f, 2.21620947e-01f,
  -7.79318869e-01f, -1.92882299e-01f, 7.25608289e-01f, -2.81152949e-02f, -5.11762440e-01f, -5.18475175e-01f, -4.53300178e-01f, -5.87003417e-02f, -9.29876208e-01f, -2.00057954e-01f,
  7.66663626e-02f, -1.35029241e-01f, -3.27449054e-01f, 7.69363269e-02f, -1.02812886e-01f, 1.55779392e-01f, -1.66853830e-01f, -7.67966509e-02f, 2.17059463e-01f, 5.16384132e-02f,
  -2.32534558e-01f, -3.25229943e-01f, 7.01370388e-02f, 2.38819718e-02f, -1.14241660e-01f, 2.48785213e-01f, -4.03871298e-01f, 3.17182019e-02f, -5.24245612e-02f, -2.33093634e-01f,
  5.98097816e-02f, 1.08116239e-01f, -1.53324708e-01f, -7.24297315e-02f, -7.16289878e-02f, 7.65483379e-02f, -3.33262682e-02f, -8.17216039e-02f, 9.60758626e-02f, -1.24419995e-01f,
  1.23301364e-01f, 1.93892494e-01f, 5.72270490e-02f, -3.84416759e-01f, -7.17171505e-02f, 1.36613816e-01f, 7.08102584e-02f, -2.29387060e-01f, 2.97831818e-02f, 1.82200745e-01f,
  2.76231598e-02f, -5.74724600e-02f, 1.88611150e-02f, -1.11449808e-01f, -5.17842826e-03f, 1.91654295e-01f, -4.85416986e-02f, -5.93462307e-03f, -7.69283324e-02f, -2.57935137e-01f,
  -5.21757007e-01f, -3.61476779e-01f, -1.31927356e-01f, 1.89257190e-02f, 1.47476858e-02f, -2.30994821e-01f, -3.58016565e-02f, -2.22565338e-01f, 7.37475753e-02f, 2.85771191e-01f,
  -3.80102485e-01f, -2.60163974e-02f, -7.14461431e-02f, 1.26257241e-01f, 2.64863372e-02f, -2.65464514e-01f, 8.46186802e-02f, 8.61461520e-01f, -1.03878357e-01f, -2.30565086e-01f,
  -3.66227388e-01f, -1.71679959e-01f, -4.62139428e-01f, -3.11550587e-01f, 3.33805203e-01f, -5.49780242e-02f, -3.40604596e-02f, -1.12285882e-01f, 4.67522264e-01f, -4.84609067e-01f,
  3.56134832e-01f, -4.24878150e-02f, 3.36139500e-01f, -4.76023763e-01f, -6.42857969e-01f, -1.33806497e-01f, -2.93236952e-02f, 5.20956516e-01f, -1.39226690e-01f, -1.91312358e-01f,
  1.10274933e-01f, 2.69569457e-03f, -5.12688747e-03f, -6.76266924e-02f, -1.98860973e-01f, 7.10314274e-01f, -1.88807890e-01f, -3.59504819e-01f, -1.55642673e-01f, -1.80759877e-01f,
  6.91458955e-02f, 1.14113286e-01f, -1.41802594e-01f, -2.02689216e-01f, 4.33324724e-01f, 4.63051945e-01f, -9.32085887e-03f, -6.02193534e-01f, -1.36462533e+00f, -6.74260318e-01f,
  5.95741495e-02f, 8.75078261e-01f, 5.59289813e-01f, -5.99989202e-04f, -5.39270282e-01f, -6.11545146e-01f, 4.37235162e-02f, -6.93849325e-01f, -2.68344078e-02f, -1.14706230e+00f,
  5.96671581e-01f, 6.96834207e-01f, -6.83323562e-01f, 8.61056894e-02f, -7.97045883e-03f, 1.01694651e-01f, -1.93064362e-02f, -2.72151589e-01f, -6.42887533e-01f, -1.37537032e-01f,
  -5.96213818e-01f, -2.94285417e-01f, 6.14049658e-02f, 1.04324646e-01f, -2.10203230e-01f, -2.33138755e-01f, -4.25318688e-01f, 5.18726259e-02f, 3.84249203e-02f, 2.43925825e-02f,
  3.73442583e-02f, 1.00970007e-01f, 4.25910018e-02f, -3.08988005e-01f, 2.89566785e-01f, 1.89761043e-01f, -1.26709351e-02f, 2.69221693e-01f, 1.43296402e-02f, -2.14385450e-01f,
  1.09575242e-01f, 8.62803459e-02f, -3.17825645e-01f, 1.63744330e-01f, 4.47935611e-02f, 2.75730398e-02f, -3.74481492e-02f, -7.48832300e-02f, -1.95980798e-02f, 3.55796739e-02f,
  1.74929827e-01f, 3.13576579e-01f, 1.40727172e-02f, -1.39475718e-01f, 1.65192828e-01f, -1.79728553e-01f, -8.81135240e-02f, -3.09703529e-01f, -1.06027015e-02f, -5.71069978e-02f,
  2.62397323e-02f, 9.20974612e-02f, -3.42821255e-02f, -1.40597001e-01f, -1.73018038e-01f, 1.61993250e-01f, 1.72405899e-01f, -1.97604746e-01f, 1.58322662e-01f, -1.59308434e-01f,
  -1.55216036e-02f, -9.27902237e-02f, 5.51287504e-03f, 5.72708659e-02f, 7.28234742e-03f, -3.47438604e-01f, 1.77539319e-01f, -2.24702567e-01f, -2.81085610e-01f, 2.95879364e-01f,
  -3.24797958e-01f, 2.84629911e-02f, -1.17009424e-01f, 1.78542137e-01f, 2.44774356e-01f, -4.98811841e-01f, 1.17689610e-01f, -1.71467125e-01f, 1.80692419e-01f, 3.01745092e-03f,
  -1.49133243e-02f, 1.69476550e-02f, 2.63955928e-02f, -3.43918353e-02f, 1.60816349e-02f, -7.82553628e-02f, 2.55751699e-01f, -3.20066780e-01f, -3.35160613e-01f, -5.91957644e-02f,
  -2.14399740e-01f, 2.46027783e-02f, 2.75763363e-01f, -1.50616720e-01f, -4.28242050e-02f, 6.92543834e-02f, -1.58144921e-01f, -1.11920990e-01f, -2.96804309e-01f, 2.08525434e-01f,
  3.33071917e-01f, -4.14601862e-02f, -5.17287217e-02f, 1.00535356e-01f, -1.65219500e-03f, -1.45643815e-01f, -6.00581840e-02f, -1.19388230e-01f, -2.02511385e-01f, 1.69594601e-01f,
  -2.42468759e-01f, -3.75263356e-02f, -1.58041529e-02f, 5.57526201e-02f, -9.44302697e-03f, 5.97808123e-01f, 5.33970110e-02f, -4.44410056e-01f, 8.21932256e-02f, -3.65829498e-01f,
  1.54902995e-01f, 8.96769948e-03f, -1.08597450e-01f, -1.04583836e+00f, 7.35743225e-01f, 4.22501042e-02f, 9.64994356e-02f, -1.11447918e+00f, -2.57484108e-01f, -4.81515378e-01f,
  1.55793518e-01f, 2.03334436e-01f, -9.76993069e-02f, -1.88298732e-01f, 2.59549677e-01f, 1.56582654e-01f, -2.65851080e-01f, -6.15272373e-02f, -7.76446164e-01f, 5.65425158e-01f,
  -1.12904437e-01f, 5.90474636e-04f, 9.68506560e-02f, 2.27729678e-01f, 5.45176826e-02f, 1.64916277e-01f, 1.35834217e-01f, 1.67541876e-01f, 1.30601346e-01f, 6.66185319e-02f,
  6.05372004e-02f, 2.03686655e-01f, 1.58689767e-01f, -5.67347519e-02f, -2.92863213e-02f, 2.40806211e-02f, 8.18573385e-02f, -1.39148375e-02f, 1.37630925e-01f, 5.47464862e-02f,
  2.90254176e-01f, -3.38416621e-02f, -9.57033709e-02f, 1.33786842e-01f, 1.27956346e-01f, 1.50277808e-01f, 2.06304207e-01f, -1.44956827e-01f, 1.25624359e-01f, 1.65048838e-01f,
  8.27202573e-03f, 1.49725959e-01f, 5.45435511e-02f, 4.49480936e-02f, -3.40537839e-02f, 1.44038349e-01f, 9.18286294e-02f, 5.47054075e-02f, -7.34976381e-02f, 1.48642153e-01f,
  -1.89142153e-02f, 2.58161109e-02f, 1.39063388e-01f, -1.61359444e-01f, 2.72636320e-02f, 2.95389746e-03f, 6.85851602e-03f, 8.68693590e-02f, -5.81036210e-02f, -2.15288531e-02f,
  1.51111618e-01f, -1.11675538e-01f, 3.72685730e-01f, 6.72830418e-02f, -3.85236651e-01f, 1.38356477e-01f, 2.44631961e-01f, -1.29533291e-01f, -1.63665384e-01f, -3.27079505e-01f,
  -8.35030973e-02f, 5.38035929e-02f, -3.12400728e-01f, -1.46815211e-01f, -1.12237968e-01f, 3.33501841e-03f, 1.31466001e-01f, 2.43252113e-01f, 5.01501322e-01f, 3.44790846e-01f,
  2.04080656e-01f, -2.05124915e-01f, -1.42872542e-01f, -1.08725000e-02f, -2.98146367e-01f, 1.63048998e-01f, -4.12994176e-01f, -9.40037593e-02f, -1.00109220e-01f, -2.44890347e-01f,
  -5.00859804e-02f, 3.60905766e-01f, 8.34627748e-02f, -3.70118283e-02f, -4.97673564e-02f, -2.01075345e-01f, 1.41129643e-01f, -1.02345318e-01f, -2.22442836e-01f, -2.94492304e-01f,
  2.32968703e-01f, 1.50203258e-01f, -2.31305674e-01f, -8.65216479e-02f, -3.14637750e-01f, -9.92420390e-02f, 1.06156498e-01f, -1.87478229e-01f, -4.48661238e-01f, -1.45779029e-01f,
  -3.58437270e-01f, -6.95312098e-02f, -2.87168175e-01f, -8.93795669e-01f, 8.58235300e-01f, 3.91106486e-01f, 7.50792250e-02f, -2.58697420e-01f, 2.62489676e-01f, -7.42908835e-01f,
  -4.06868458e-01f, 1.33270502e-01f, -1.00592947e+00f, -1.93294287e-01f, 4.70857888e-01f, 5.30052841e-01f, -1.07583785e+00f, -7.28088856e-01f, 1.76067203e-02f, 1.99710168e-02f,
  -5.11484146e-01f, -1.68707475e-01f, 6.90006137e-01f, 3.76797408e-01f, 8.77999812e-02f, -1.00798793e-01f, -1.73658073e-01f, -5.79472184e-01f, -3.91324563e-03f, -1.72671862e-02f,
  -6.58768266e-02f, 5.92771433e-02f, 2.16134619e-02f, -6.77657723e-02f, -2.37197056e-02f, -2.47965842e-01f, 7.56785348e-02f, -7.07299784e-02f, 2.99341530e-02f, 9.03644487e-02f,
  -1.60090238e-01f, -1.92309126e-01f, -7.23517984e-02f, -9.33931321e-02f, -7.25337490e-02f, 5.68519980e-02f, -1.29417911e-01f, 5.60866296e-02f, 1.83177397e-01f, 1.27357632e-01f,
  -6.66593164e-02f, 2.34251190e-02f, 8.19230303e-02f, 9.29042175e-02f, 9.33281332e-02f, 8.73170197e-02f, 8.20104927e-02f, -1.75006866e-01f, -8.56086239e-02f, -1.21313274e-01f,
  4.18367051e-03f, -1.12056769e-02f, -3.88225317e-02f, 1.25307560e-01f, -3.62108834e-02f, -3.61276641e-02f, -9.25208852e-02f, 1.45949587e-01f, 2.63571590e-01f, 6.19234256e-02f,
  4.24567668e-04f, -4.58215326e-02f, -6.02428019e-02f, -1.00842901e-01f, 7.17552900e-02f, 1.61669388e-01f, 1.76442653e-01f, -1.05554476e-01f, 2.15732723e-01f, 5.37983440e-02f,
  -4.60664593e-02f, 3.06446135e-01f, 1.93118989e-01f, -2.39373893e-01f, 2.63023019e-01f, -1.75828665e-01f, 3.36613804e-01f, -1.25695676e-01f, 2.57481307e-01f, 1.25124186e-01f,
  7.15396879e-03f, -4.13822204e-01f, 2.46629223e-01f, 1.93044171e-01f, 2.32383117e-01f, -1.89955950e-01f, 2.53813863e-01f, 3.07383895e-01f, -2.73998350e-01f, -2.10124001e-01f,
  -1.80560440e-01f, 4.80956584e-02f, 3.63324761e-01f, -2.45093971e-01f, 2.62307763e-01f, 3.18910897e-01f, 1.77019179e-01f, 3.77409101e-01f, 2.10869446e-01f, 3.58817786e-01f,
  -2.33949587e-01f, 2.15269610e-01f, 2.05354303e-01f, 2.16786280e-01f, -2.88446695e-01f, 1.45733133e-01f, 1.76887810e-02f, 2.07523122e-01f, 1.89262517e-02f, -1.71174556e-01f,
  -1.78794816e-01f, 1.13789089e-01f, 1.74363256e-01f, 2.11232081e-01f, 4.12335582e-02f, -3.77158135e-01f, 2.73184311e-02f, 3.06287408e-01f, -3.55268925e-01f, -2.45645583e-01f,
  -7.68614233e-01f, 7.15681970e-01f, 7.28708982e-01f, -1.75653517e-01f, -1.57631144e-01f, -2.17326850e-01f, -5.69917679e-01f, -1.17245600e-01f, -5.14923334e-01f, 4.37760264e-01f,
  2.26570800e-01f, -2.08599474e-02f, -1.10991871e+00f, -5.04136920e-01f, -9.72617030e-01f, -3.85082304e-01f, 2.01030716e-01f, -1.07667255e+00f, -5.58979154e-01f, -5.08952856e-01f,
  -5.29932022e-01f, -3.60326767e-02f, 5.81556678e-01f, -5.29739976e-01f, 2.76125595e-02f, -4.49352890e-01f, -1.63136572e-01f, -2.28496015e-01f, -1.09221943e-01f, 1.39721811e-01f,
  -3.17776725e-02f, -1.77547589e-01f, -1.81657314e-01f, 1.58706289e-02f, -2.32608199e-01f, -1.14974879e-01f, -8.48168433e-02f, -1.34534180e-01f, -1.75004497e-01f, -4.96017039e-02f,
  2.75978399e-03f, 1.06762648e-01f, 6.29951954e-02f, -1.57921493e-01f, -2.15989947e-01f, -3.84451449e-01f, -1.01061650e-01f, -3.05674151e-02f, 4.77658287e-02f, -1.77285075e-01f,
  -7.27896988e-02f, -1.27729639e-01f, -1.29495889e-01f, -1.34480968e-02f, 1.72806695e-01f, -2.94516645e-02f, -9.32857394e-02f, -1.34938896e-01f, -2.23028913e-01f, -8.72034878e-02f,
  -1.21931367e-01f, -8.05877596e-02f, -2.18540058e-01f, -1.31581903e-01f, -7.55113438e-02f, -1.82733968e-01f, 8.69055241e-02f, -3.32482196e-02f, -5.04209101e-02f, -6.25018869e-03f,
  -2.32351363e-01f, 5.37956581e-02f, -1.02884099e-01f, -9.49028432e-02f, -2.98873074e-02f, -1.02274582e-01f, -2.50667542e-01f, 8.06392953e-02f, 7.48005360e-02f, -2.74551660e-03f,
  -2.29919419e-01f, -1.12788521e-01f, -1.02937132e-01f, 1.10739700e-01f, -5.67863025e-02f, -9.86412019e-02f, 9.38938335e-02f, -1.74809456e-01f, -2.08659485e-01f, 1.44189551e-01f,
  -1.99252173e-01f, -1.55223638e-01f, -3.03655565e-01f, 1.79807156e-01f, -5.89338271e-03f, 2.13974267e-01f, 3.10420781e-01f, -1.49936005e-01f, 9.25909802e-02f, 4.32171077e-02f,
  -1.41849741e-01f, -1.78403750e-01f, -3.85419093e-03f, -2.02823430e-01f, 8.40889364e-02f, 2.26110950e-01f, -1.66717023e-01f, -6.53182715e-02f, -7.72035047e-02f, -2.21767575e-01f,
  -5.27352914e-02f, 4.12552170e-02f, 1.14359945e-01f, 1.75190672e-01f, -1.84540808e-01f, -2.62976706e-01f, 1.94648933e-02f, -1.58892721e-02f, 1.74108967e-01f, 1.32257327e-01f,
  -1.99423805e-01f, 7.84581378e-02f, -7.17977434e-02f, -1.86602883e-02f, -3.30860198e-01f, -2.84270756e-02f, 2.17821538e-01f, 2.46637374e-01f, -9.52446878e-01f, 1.69812471e-01f,
  -2.29321167e-01f, -4.89522487e-01f, 2.53947169e-01f, 4.54260409e-01f, 3.42211425e-02f, -2.84323931e-01f, -1.38314798e-01f, -6.40025973e-01f, 1.76600486e-01f, -1.15365602e-01f,
  4.01383400e-01f, -4.01096255e-01f, 9.11581933e-01f, -4.10820544e-01f, 1.85497597e-01f, -5.15138805e-01f, -8.40331793e-01f, -3.33786607e-01f, -5.91364622e-01f, -2.84340173e-01f,
  -3.56843263e-01f, 3.22377026e-01f, -1.63448617e-01f, -4.19692516e-01f, 5.61789051e-02f, 1.82824861e-02f, 2.20923796e-01f, -3.77636850e-01f, -4.00983751e-01f, 1.12541787e-01f,
  3.64907905e-02f, -1.84760150e-02f, 3.46208751e-01f, 1.32604867e-01f, 1.48268506e-01f, 3.11428569e-02f, -4.82124947e-02f, -3.28838751e-02f, 1.93463955e-02f, 2.38412209e-02f,
  -1.59987479e-01f, 6.42037615e-02f, -3.34616676e-02f, -5.90850152e-02f, -2.53098220e-01f, 3.24149758e-01f, 9.56566110e-02f, 1.73056662e-01f, 1.48726463e-01f, 3.12886275e-02f,
  8.60234946e-02f, 1.61817903e-03f, -5.96800297e-02f, 1.58972979e-01f, 1.41656950e-01f, 1.17658883e-01f, 1.19449556e-01f, 7.70242885e-02f, 2.77312081e-02f, -4.15440321e-01f,
  1.82972625e-01f, -4.21176432e-03f, 1.75033897e-01f, -7.88332298e-02f, 1.51946470e-01f, -2.60303020e-01f, 7.07284212e-02f, 2.05136146e-02f, 1.31754160e-01f, 1.43838793e-01f,
  6.92707002e-02f, -9.97664407e-02f, -1.29749164e-01f, -7.76019990e-02f, -1.74173843e-02f, 2.12423563e-01f, -4.39813659e-02f, -5.04463390e-02f, -1.10345252e-01f, -2.35174224e-01f,
  5.37548866e-03f, -2.58055806e-01f, 7.20352173e-01f, -1.38700873e-01f, 8.61591026e-02f, 2.10443571e-01f, -3.21962744e-01f, 5.53565085e-01f, -6.03160381e-01f, 2.47723386e-01f,
  -4.76207256e-01f, 2.47123152e-01f, -3.97084713e-01f, 7.45252430e-01f, -4.68180835e-01f, 4.33766484e-01f, -1.49485826e-01f, 1.92334577e-01f, 2.56739616e-01f, 6.30849451e-02f,
  3.43416363e-01f, -1.53209388e-01f, -7.33093694e-02f, -3.22635680e-01f, -2.06921712e-01f, 3.85810286e-01f, 2.86029978e-03f, 2.48874694e-01f, 7.34111071e-02f, -1.75202321e-02f,
  5.46879649e-01f, -7.65437260e-02f, 1.78398401e-01f, 1.64673656e-01f, 1.36333078e-01f, -2.86226302e-01f, 1.81007117e-01f, 1.36248738e-01f, -3.41090709e-01f, -1.60683349e-01f,
  1.33352607e-01f, -4.04669613e-01f, 4.96779174e-01f, 3.47773075e-01f, 2.79571652e-01f, -3.71208668e-01f, -3.79661441e-01f, -4.94567677e-02f, -1.15880609e+00f, 6.41820908e-01f,
  1.22625612e-01f, -1.71549723e-01f, 1.56394750e-01f, 2.29736269e-01f, 8.85945708e-02f, 1.36987612e-01f, -3.64267737e-01f, -4.91023868e-01f, -2.80505747e-01f, 9.03456867e-01f,
  6.92300871e-02f, -5.50872922e-01f, -2.03406468e-01f, -3.28709066e-01f, -5.18024564e-01f, 2.64657550e-02f, -8.70917320e-01f, -4.33956653e-01f, -1.13458142e-01f, 2.59566009e-01f,
  -6.29917085e-01f, -2.71470565e-02f, -1.49710327e-02f, 8.48712400e-02f, -2.96960585e-04f, 1.20769843e-01f, 1.76578417e-01f, 1.06334813e-01f, -1.32833468e-02f, 2.66525269e-01f,
  8.84782225e-02f, 3.54916789e-02f, -1.30737945e-01f, -6.83879182e-02f, -1.74188599e-01f, 5.91023713e-02f, 4.64774631e-02f, -3.86821687e-01f, -1.24546085e-02f, -5.84841110e-02f,
  2.13736609e-01f, 7.19525218e-02f, 1.31743088e-01f, -1.44924149e-01f, -9.80188847e-02f, 1.66980579e-01f, 1.20582357e-01f, -1.11784369e-01f, -6.05746964e-03f, 6.34999201e-02f,
  -2.49365330e-01f, -2.51733482e-01f, -7.38876760e-02f, 2.00496823e-01f, -1.78490520e-01f, -6.17673472e-02f, 4.52566408e-02f, -2.65068710e-01f, -6.16014935e-02f, -5.01911491e-02f,
  -6.93594217e-02f, -6.16731085e-02f, -2.20831379e-01f, -2.17630696e-02f, 1.78315654e-01f, -1.86029941e-01f, 1.55740161e-03f, 8.73105526e-02f, -9.30633247e-02f, -1.09143227e-01f,
  1.41008524e-02f, 6.57625869e-02f, -2.02441320e-01f, -3.02344095e-02f, 6.16174452e-02f, 1.91451967e-01f, 3.39780748e-01f, 4.57223386e-01f, -6.94436654e-02f, -2.33795375e-01f,
  5.35003915e-02f, -2.89632976e-01f, 1.90289710e-02f, 1.72958046e-01f, 1.10472135e-01f, -3.79254699e-01f, 2.73776874e-02f, -1.22409828e-01f, 1.99576199e-01f, -2.64728186e-03f,
  1.22340605e-01f, -2.53297180e-01f, 3.44326526e-01f, 9.53962132e-02f, 1.34926230e-01f, -2.77648032e-01f, -3.31696123e-01f, 8.50686580e-02f, -4.28803980e-01f, 2.30715439e-01f,
  -1.58099279e-01f, 3.75515372e-01f, 3.10572714e-01f, -2.49728411e-02f, 3.25479694e-02f, -2.67899215e-01f, -1.68668702e-02f, -3.25427740e-03f, -3.85060906e-01f, 1.58471599e-01f,
  1.18383482e-01f, 4.17658120e-01f, -5.96376956e-02f, -3.92463505e-01f, 5.49782300e-03f, -1.40308261e-01f, 9.86590981e-02f, 2.07746714e-01f, -5.48133701e-02f, -2.48003408e-01f,
  3.52441013e-01f, -3.58498991e-01f, 9.62556452e-02f, 3.73338461e-01f, -7.89706171e-01f, -5.59044257e-03f, 1.85384125e-01f, -3.01513791e-01f, 7.24849328e-02f, -1.15694320e+00f,
  -2.93030292e-01f, 1.02382809e-01f, 3.34387958e-01f, 9.01986137e-02f, 2.81453818e-01f, 3.17059979e-02f, 8.16144705e-01f, -8.83766055e-01f, 4.02174681e-01f, -5.18772185e-01f,
  -5.38660467e-01f, 8.72107446e-01f, -4.03589159e-01f, -5.02985537e-01f, -1.00269580e+00f, -6.52049184e-01f, 2.18020678e-01f, -2.43993074e-01f, 3.58372808e-01f, 5.25103927e-01f,
  -1.55273722e-02f, -1.27669081e-01f, 4.14530300e-02f, 9.57973227e-02f, 2.68010180e-02f, 1.23156749e-01f, -5.63256741e-02f, 2.83950001e-01f, -3.93246971e-02f, -8.64753202e-02f,
  2.60246918e-02f, -1.83355570e-01f, 8.80490169e-02f, 8.83085132e-02f, -1.78335518e-01f, 2.26429459e-02f, 3.89813296e-02f, 7.87701532e-02f, -2.88582351e-02f, 1.04113474e-01f,
  1.07366994e-01f, 7.91175812e-02f, 1.34722412e-01f, 1.48200050e-01f, -6.38808217e-03f, 2.17249110e-01f, -8.13185945e-02f, 9.55607966e-02f, 2.59298086e-01f, -3.19679201e-01f,
  2.62488946e-02f, 2.08863318e-02f, -3.93507183e-02f, -4.10036556e-03f, -1.61095383e-03f, 2.89738365e-02f, -2.20192354e-02f, 8.49895105e-02f, 1.03979789e-01f, 5.51038533e-02f,
  1.43318819e-02f, 7.06702545e-02f, 1.06819652e-01f, -1.28424883e-01f, -1.86325103e-01f, 1.39646069e-03f, 1.24283135e-01f, 1.85237870e-01f, 8.97212401e-02f, 5.50256446e-02f,
  3.18834960e-01f, -2.24719957e-01f, -1.30623681e-02f, 4.70214516e-01f, 2.44570244e-02f, -1.29576236e-01f, 5.17832756e-01f, -2.90958285e-01f, 1.60407841e-01f, 3.75833333e-01f,
  -6.70655444e-02f, -1.30921677e-01f, -3.61773431e-01f, 4.70724583e-01f, 1.86794296e-01f, -2.97567517e-01f, -1.49265945e-01f, 2.19503358e-01f, 3.66778851e-01f, -4.52552319e-01f,
  4.91883457e-01f, 2.44948417e-01f, 5.42227328e-01f, 1.07104555e-01f, -4.58538473e-01f, 9.54862908e-02f, 4.88717966e-02f, -3.38453472e-01f, -1.54104620e-01f, -2.71435171e-01f,
  -4.15581077e-01f, 1.54251177e-02f, 3.97551417e-01f, 1.01868086e-01f, -3.51728827e-01f, -1.85211748e-01f, -3.98568153e-01f, -2.02003017e-01f, -7.59249777e-02f, -3.00780922e-01f,
  -2.93938398e-01f, -4.83337462e-01f, 4.36787456e-01f, 2.26289138e-01f, 2.16652572e-01f, -2.00064212e-01f, -3.22113186e-01f, 2.66051799e-01f, -4.15367305e-01f, -1.69196546e-01f,
  3.66866589e-01f, 2.24492580e-01f, -5.17826498e-01f, -2.35981002e-01f, -9.14380550e-01f, -2.89234251e-01f, 6.12064123e-01f, -3.56771886e-01f, 8.22418705e-02f, 2.46096030e-01f,
  -3.83217543e-01f, 9.02841985e-02f, -5.65000355e-01f, -7.86903024e-01f, -2.36237302e-01f, -5.37304640e-01f, -5.36885560e-01f, -5.61456561e-01f, -2.91384518e-01f, -8.32533717e-01f,
  1.06775808e+00f, 3.58469710e-02f, 2.64505744e-01f, -6.26758516e-01f, -3.63536149e-01f, -1.23703487e-01f, -1.81469604e-01f, 3.95288289e-01f, 3.38810543e-03f, -8.98206793e-03f,
  1.96390763e-01f, 5.65435886e-02f, 1.49184331e-01f, -1.01838177e-02f, 1.58547193e-01f, 1.27809150e-02f, -2.18957290e-01f, -2.44588442e-02f, 1.18688852e-01f, -1.51700387e-02f,
  3.10690314e-01f, -1.97001249e-01f, 1.40897915e-01f, 1.38863996e-01f, 5.00806868e-02f, -1.31109208e-01f, 2.28528544e-01f, 6.10650815e-02f, 4.12553102e-02f, 2.34756678e-01f,
  2.05472186e-01f, -5.48236966e-02f, -1.30370557e-01f, 2.26135459e-02f, 3.05535961e-02f, 8.56335387e-02f, -2.43468925e-01f, 1.64555699e-01f, 1.75882906e-01f, -4.83468100e-02f,
  -1.04469843e-01f, 1.30760372e-01f, 1.42874569e-01f, 3.63226801e-01f, 3.31445858e-02f, 1.72484979e-01f, -2.71216296e-02f, -1.19990751e-01f, 3.16946805e-02f, 1.64241970e-01f,
  -3.50697525e-02f, -3.96977328e-02f, 5.56085669e-02f, 1.66091517e-01f, 2.46807728e-02f, 5.99332200e-03f, -2.61675894e-01f, 4.55142483e-02f, 2.83025056e-01f, -8.14782158e-02f,
  1.75242051e-02f, -1.46320298e-01f, 1.54169694e-01f, 7.67795369e-02f, -5.00164688e-01f, 2.99911410e-01f, 2.20132068e-01f, -3.47052515e-01f, 1.13913581e-01f, 2.45903164e-01f,
  1.96636692e-01f, -5.12932539e-02f, 4.77595448e-01f, -1.12101987e-01f, -1.77396521e-01f, 7.22186863e-02f, -4.01138723e-01f, 1.00232914e-01f, -6.19817935e-02f, -1.34270266e-01f,
  2.03615911e-02f, 1.93485215e-01f, 4.59293932e-01f, -3.27729195e-01f, 2.18703017e-01f, 7.63216838e-02f, 3.02645624e-01f, -6.48414195e-01f, 1.10837206e-01f, -1.16862394e-02f,
  -2.46223226e-01f, 2.41108552e-01f, -1.41183838e-01f, 5.84872440e-02f, 2.22177327e-01f, -1.83275998e-01f, -6.96173161e-02f, 2.52725393e-01f, 3.47183406e-01f, 5.71101189e-01f,
  4.95295189e-02f, 5.42342439e-02f, -9.65689868e-02f, -2.29984485e-02f, 1.71062171e-01f, 7.21020639e-01f, 3.04943889e-01f, 2.18341034e-02f, -3.50526690e-01f, 2.29459107e-01f,
  -3.16922098e-01f, -9.74681497e-01f, -4.88556087e-01f, -2.86259294e-01f, -4.75701064e-01f, 7.09283054e-01f, 5.15688896e-01f, -2.59583462e-02f, -2.52132505e-01f, 2.63141960e-01f,
  7.71077275e-01f, 1.61160350e-01f, -5.09026229e-01f, -6.70727253e-01f, -9.58000422e-01f, -5.15571870e-02f, 2.85760134e-01f, 6.31836653e-02f, -4.86774966e-02f, -2.51244992e-01f,
  -5.71322680e-01f, -2.46691212e-01f, -4.74168837e-01f, -6.26160800e-01f, 2.72791088e-01f, -2.82397151e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.73420030e-01f, -6.45927759e-03f, 1.24148332e-01f, 1.02278627e-01f, -9.82709602e-03f, -1.19250178e-01f, 1.01597346e-02f, 4.62108701e-02f, 9.65201259e-02f, 8.04557875e-02f,
  2.13388398e-01f, 8.18579793e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    