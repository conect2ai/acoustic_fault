/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.78627297e-01f, 4.52330947e-01f, -5.50129235e-01f, 3.25742692e-01f, 4.95691448e-01f, -3.04945046e-03f, 1.43519372e-01f, -1.69467866e-01f, 1.84826821e-01f, 2.63865530e-01f,
  2.87718475e-01f, 2.41885900e-01f, 6.51464760e-02f, -1.63235098e-01f, -3.79927367e-01f, -6.59891292e-02f, -1.02284260e-01f, -4.04755443e-01f, -3.43320817e-01f, 8.59949645e-03f,
  3.62801313e-01f, 2.01040909e-01f, -2.18516693e-01f, -1.73605666e-01f, 2.58563042e-01f, 1.75401330e-01f, -9.19240788e-02f, 2.26775602e-01f, 1.66891053e-01f, 1.44644231e-01f,
  1.73304081e-01f, -1.22399516e-01f, -6.20237812e-02f, 1.42681211e-01f, 1.09271094e-01f, -2.98486836e-02f, -3.63501683e-02f, -9.77351964e-02f, 4.32817712e-02f, -2.39153989e-02f,
  7.14399368e-02f, 9.79612861e-03f, 9.83504727e-02f, -1.82844754e-02f, 7.29725063e-02f, -3.50502394e-02f, -1.92839518e-01f, -2.79422015e-01f, -1.34597585e-01f, -7.51669239e-03f,
  2.52160907e-01f, 1.95434660e-01f, -3.29075195e-02f, -5.21098413e-02f, -1.86669111e-01f, -1.93986185e-02f, -4.31638882e-02f, -6.65433258e-02f, -2.08559275e-01f, 1.08269155e-01f,
  4.33508344e-02f, -1.60537343e-02f, -6.77453056e-02f, -9.37528983e-02f, 6.29459545e-02f, 3.02614365e-03f, -1.02815531e-01f, 5.66551276e-02f, -7.13426247e-02f, -5.18761501e-02f,
  -5.19285128e-02f, 1.18551124e-02f, -2.12058313e-02f, -1.71926431e-02f, -5.10519594e-02f, -3.11974045e-02f, 9.62154195e-02f, -2.11493261e-02f, 1.84213165e-02f, -6.31832331e-02f,
  3.30408290e-02f, -4.54346910e-02f, 2.79783178e-02f, -5.93505278e-02f, -7.35447630e-02f, -6.03554025e-02f, -4.40251641e-02f, -2.65054200e-02f, -2.49057785e-02f, -7.71237090e-02f,
  3.71337682e-01f, -1.61334366e-01f, 1.74403429e-01f, -2.06842184e-01f, 1.43539011e-01f, -5.82528524e-02f, 8.57674107e-02f, -4.35900688e-02f, 8.86185467e-02f, -3.47750708e-02f,
  -8.48970097e-03f, -4.73651066e-02f, 8.74967799e-02f, 2.09663324e-02f, 2.57233270e-02f, 3.41894329e-02f, 2.36646399e-01f, 8.58346894e-02f, 1.81755871e-02f, -2.13690586e-02f,
  1.10446043e-01f, 1.49636969e-01f, 3.46374243e-01f, 1.45673007e-01f, 1.43706620e-01f, 2.08902016e-01f, 1.64484501e-01f, 2.31686443e-01f, 1.61535233e-01f, 3.91390949e-01f,
  4.27253306e-01f, 1.85279250e-01f, 2.30642244e-01f, 1.41047090e-01f, -4.46604043e-01f, -4.40278530e-01f, -4.20945019e-01f, -2.55199075e-01f, 1.05275633e-02f, 1.14164874e-01f,
  5.32261916e-02f, 3.26284796e-01f, 4.48047757e-01f, 2.90876895e-01f, 1.80198088e-01f, 6.88252449e-02f, 3.76451388e-02f, 2.30974182e-01f, -7.65004531e-02f, -4.08434272e-01f,
  -1.55030400e-01f, -3.00869066e-02f, 3.00935775e-01f, 9.88298357e-02f, 1.19811632e-01f, 1.55273557e-01f, 1.14369400e-01f, 4.89034615e-02f, -2.16177907e-02f, 4.09470677e-01f,
  4.69738126e-01f, 3.49801145e-02f, -2.46990025e-02f, 1.81512728e-01f, 9.00104865e-02f, 8.71780962e-02f, 1.00887597e-01f, 1.84990168e-01f, 9.70483273e-02f, 1.41069680e-01f,
  1.01724222e-01f, 1.93165392e-01f, 1.14390641e-01f, 1.08081229e-01f, 2.79331319e-02f, 5.15775941e-02f, 7.19274729e-02f, 2.19105095e-01f, 1.37387663e-01f, 1.07835773e-02f,
  -7.06437230e-03f, -2.80108619e-02f, -1.27629610e-02f, -2.35230569e-02f, 1.02420628e-01f, 1.52620003e-01f, -9.90772806e-03f, 6.02523051e-02f, 9.71937776e-02f, 1.91223577e-01f,
  -2.02044383e-01f, -5.11042923e-02f, -1.15467556e-01f, -1.32539896e-02f, -5.34247644e-02f, 2.45720651e-02f, -2.81654876e-02f, -2.77859215e-02f, -5.13314009e-02f, -5.26607595e-02f,
  -3.66519354e-02f, -4.28320505e-02f, -1.44101486e-01f, -1.21805370e-02f, -2.95241065e-02f, -3.05923000e-02f, -1.35461777e-01f, 2.06386503e-02f, 2.64027044e-02f, -5.65747842e-02f,
  2.24663354e-02f, -1.44818472e-02f, -5.84723167e-02f, 1.66728813e-02f, -9.55465436e-02f, -1.15054380e-02f, -5.75934760e-02f, -1.18741289e-01f, -6.59988448e-02f, -9.05458033e-02f,
  2.63404131e-01f, 5.09336172e-03f, 2.72205114e-01f, 1.16722800e-01f, 7.51441866e-02f, 1.36965603e-01f, 8.32296535e-02f, 9.82853919e-02f, 6.98215142e-02f, 8.05037245e-02f,
  7.63371736e-02f, 6.94473311e-02f, 6.55169562e-02f, -4.58269659e-03f, -2.40666941e-02f, 3.28689143e-02f, -1.11079989e-02f, 7.60872588e-02f, 8.42185989e-02f, 3.28928642e-02f,
  1.49612531e-01f, -6.16141818e-02f, 1.00304745e-01f, 7.85916001e-02f, 4.54765558e-03f, -4.46275286e-02f, 1.28118470e-01f, -6.62665861e-03f, 5.56174815e-02f, 1.45670891e-01f,
  -1.79649547e-01f, 4.17997479e-01f, 1.32961348e-01f, 2.25857999e-02f, 2.14610044e-02f, 1.20004909e-02f, 4.81958926e-01f, 8.74479935e-02f, -3.72480601e-02f, 2.30391741e-01f,
  -2.02271968e-01f, -4.52515393e-01f, -2.13666409e-01f, -2.93170691e-01f, -1.33156776e-01f, 4.18490827e-01f, 3.54301602e-01f, -1.05835617e-01f, -3.29133123e-01f, -9.23613608e-02f,
  2.18456537e-02f, 1.69022754e-01f, -1.82228491e-01f, -8.55579600e-02f, 2.28654847e-01f, -2.96974089e-02f, 3.34982127e-01f, 1.22806177e-01f, -2.15981696e-02f, 4.45481598e-01f,
  1.00054219e-01f, -1.32015049e-01f, -1.63630322e-01f, -2.17274070e-01f, -7.84440488e-02f, -3.44217084e-02f, -8.04963484e-02f, -1.06594659e-01f, -1.12226002e-01f, 6.65479852e-03f,
  -1.09258793e-01f, -7.54522234e-02f, -6.85714036e-02f, -4.26737629e-02f, -7.21391439e-02f, 9.14991647e-03f, 1.28103606e-02f, -1.16265632e-01f, -2.02686310e-01f, -1.61580499e-02f,
  -3.63258831e-02f, -1.13237321e-01f, -1.94447413e-02f, -9.55791473e-02f, -1.24091424e-01f, -2.13659704e-01f, 7.72091448e-02f, -7.22449496e-02f, -1.08544037e-01f, 2.87467748e-01f,
  4.57517803e-03f, 9.69634429e-02f, -2.61990726e-02f, 8.37580487e-02f, 4.86646853e-02f, -8.56843665e-02f, 2.11840961e-02f, 8.62776041e-02f, -3.93981449e-02f, 2.54699122e-02f,
  -6.65650964e-02f, 9.78293736e-03f, -4.84210029e-02f, 2.07165778e-02f, -5.11631705e-02f, 2.88209766e-02f, 9.03593958e-04f, 5.05477376e-03f, -6.23879544e-02f, 3.84060331e-02f,
  -5.37902750e-02f, -5.25149703e-02f, -2.08451384e-05f, -4.67640720e-03f, -6.02882132e-02f, -3.37190107e-02f, 4.59332392e-02f, -5.06079420e-02f, -4.88626137e-02f, -6.67480286e-03f,
  4.88464050e-02f, -3.51974428e-01f, 3.47823650e-02f, -8.71708095e-02f, -6.36295676e-02f, -1.10679366e-01f, -2.01096665e-02f, -1.01709813e-01f, -6.48724437e-02f, -9.46245901e-03f,
  -1.24849997e-01f, -3.33650932e-02f, -4.04510722e-02f, -1.08129010e-02f, 3.41851078e-02f, -3.03922910e-02f, 3.33518982e-02f, 4.39092740e-02f, -4.16788049e-02f, 9.40312520e-02f,
  8.22190568e-03f, 4.76561524e-02f, 6.86254352e-02f, 6.47644401e-02f, -3.79000045e-02f, -3.28509100e-02f, 1.47911042e-01f, 1.08325668e-01f, -4.77476232e-02f, 3.63977402e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.40348160e-01f, 7.36788988e-01f, -4.57647353e-01f, 2.79707193e-01f, -2.01606075e-03f, -1.02514632e-01f, 1.12705819e-01f, 3.77345860e-01f, 4.23507780e-01f, 4.32695657e-01f,
  2.03664079e-01f, 3.91713291e-01f, 2.54612207e-01f, 2.47929305e-01f, 2.36135811e-01f, 3.12644988e-01f, 4.60106373e-01f, -4.23019081e-02f, -3.00115824e-01f, 9.41760540e-02f,
  4.61789548e-01f, 1.55568615e-01f, -1.94115207e-01f, 1.42503651e-02f, 4.47603732e-01f, 2.06186756e-01f, 1.48907036e-01f, 1.33305371e-01f, 1.48447245e-01f, 5.57391822e-01f,
  -2.93496326e-02f, -4.72425707e-02f, -6.99539855e-02f, 1.34811476e-01f, -2.53223181e-01f, -9.28919315e-02f, -1.44846395e-01f, -9.89895016e-02f, -1.37894908e-02f, 7.42262602e-02f,
  -3.84794152e-03f, -6.12208061e-02f, -7.31163844e-02f, -2.04699077e-02f, -1.58592522e-01f, -4.11757827e-02f, 6.75461292e-02f, 9.52480435e-02f, 1.40263155e-01f, -9.99171287e-03f,
  2.08442330e-01f, -1.20954812e-01f, -2.34779850e-01f, -1.66616723e-01f, -1.18250467e-01f, -1.73523813e-01f, -1.53048888e-01f, -2.85269301e-02f, -1.43450439e-01f, 2.57955994e-02f,
  -1.07575797e-01f, 2.52605844e-02f, -1.06311873e-01f, 7.96470568e-02f, -6.76075742e-02f, -7.92451054e-02f, -6.75577857e-03f, 2.95450650e-02f, -1.37055546e-01f, -1.03714973e-01f,
  3.42573575e-03f, -6.23516589e-02f, -1.50032789e-01f, -5.71003146e-02f, 1.46244660e-01f, 6.11701561e-03f, -1.30379736e-01f, -1.37042571e-02f, -1.58381492e-01f, -1.44626275e-02f,
  -2.37391263e-01f, -8.92020091e-02f, -1.44761592e-01f, 2.18146364e-03f, 4.02033292e-02f, -1.23241909e-01f, -7.12236837e-02f, -5.09824678e-02f, 1.22403987e-01f, 1.00655526e-01f,
  5.09404540e-01f, -4.98987973e-01f, 2.62761474e-01f, 2.92969018e-01f, -1.47036344e-01f, -9.95812416e-02f, -7.95599967e-02f, 5.96039277e-03f, 1.75767448e-02f, 7.52325654e-02f,
  -1.54176205e-01f, -4.78079021e-02f, 9.08922404e-02f, -1.11826330e-01f, -2.74977773e-01f, -3.99835035e-02f, 1.34687498e-01f, 1.92925289e-01f, 2.44064823e-01f, 1.35814622e-01f,
  3.57663520e-02f, -1.92209752e-03f, -1.56863764e-01f, -3.68124656e-02f, -2.36002766e-02f, 2.19090078e-02f, -3.35871786e-01f, -1.05744734e-01f, -1.85112298e-01f, -8.52682292e-02f,
  -1.09675622e+00f, -6.73947707e-02f, -2.46960849e-01f, -2.82846987e-01f, 4.56206769e-01f, -1.66652352e-01f, -7.43686020e-01f, -5.38240135e-01f, 2.04893544e-01f, 3.57915848e-01f,
  7.81465590e-01f, 3.58083814e-01f, -8.73312056e-02f, -5.75197816e-01f, -1.85152507e+00f, -1.05057943e+00f, -1.02618003e+00f, -1.54890132e+00f, -1.23990762e+00f, 3.00501641e-02f,
  2.08048716e-01f, -6.83928430e-01f, -1.12098718e+00f, -2.38801077e-01f, 1.24148118e+00f, 4.96422172e-01f, 2.77147561e-01f, 2.09544599e-01f, 2.82195091e-01f, 3.15822482e-01f,
  3.64989817e-01f, 7.47375712e-02f, -9.69999805e-02f, -1.07899169e-02f, 4.95331287e-01f, 6.11695200e-02f, -6.94134086e-02f, 1.85948778e-02f, 1.09472990e-01f, -1.61717102e-01f,
  4.30682153e-01f, 1.69202805e-01f, 1.09798849e-01f, -1.89945534e-01f, -1.34684399e-01f, -5.56506395e-01f, -4.05518979e-01f, -8.20298254e-01f, -6.47314548e-01f, 3.33209001e-02f,
  1.63892806e-01f, 2.84145594e-01f, -6.78066134e-01f, -1.29955903e-01f, -1.51025832e-01f, -3.35511714e-01f, 3.92170072e-01f, 6.36891842e-01f, -1.71695754e-01f, -4.66690399e-02f,
  3.64941172e-02f, -8.08978155e-02f, -1.33363921e-02f, -8.34846422e-02f, -2.63934582e-01f, 2.43506581e-01f, -7.28458911e-02f, -9.48102325e-02f, -2.07486320e-02f, -5.76872118e-02f,
  3.01980227e-02f, 1.24115169e-01f, 3.87476981e-02f, -1.06193937e-01f, 1.65277347e-01f, -8.33414420e-02f, 8.08464438e-02f, -8.03624839e-02f, -1.38067245e-01f, -5.91131411e-02f,
  -2.41581827e-01f, 5.95551617e-02f, 9.54099819e-02f, 7.98853040e-02f, -6.40371395e-03f, -8.75196978e-02f, 1.15966171e-01f, 2.91156024e-01f, -7.01926881e-03f, -4.56528505e-03f,
  -7.67774880e-02f, -3.15965354e-01f, -1.62662223e-01f, -7.24959224e-02f, -6.51753368e-03f, 2.35009849e-01f, 1.28421694e-01f, -1.15175329e-01f, 1.77009016e-01f, -3.45168740e-01f,
  -1.49791792e-01f, -2.75498062e-01f, 1.55150771e-01f, 2.19847225e-02f, -1.67821839e-01f, -1.38860688e-01f, -1.34221613e-01f, -8.03624764e-02f, -6.55671954e-02f, 3.34605306e-01f,
  -7.55815953e-02f, -4.18097198e-01f, -9.84310150e-01f, -4.82964218e-01f, 5.30445017e-02f, -3.53800476e-01f, 1.44900801e-03f, 1.02863222e-01f, -7.27968097e-01f, -7.83582270e-01f,
  1.58027780e+00f, -8.76562536e-01f, 1.30382031e-01f, 4.52136487e-01f, 6.64828420e-02f, -4.13432539e-01f, -7.03495860e-01f, -3.61175984e-01f, 1.38843566e-01f, -1.39493316e-01f,
  -4.24187064e-01f, 1.75970644e-01f, -1.13461949e-01f, -1.39462471e-01f, -2.58662939e-01f, 3.88156297e-03f, 2.80447572e-01f, 4.73255605e-01f, 4.80683744e-01f, 3.49379241e-01f,
  1.87053397e-01f, 1.47521734e-01f, 2.68486768e-01f, 5.42428531e-02f, 1.86354682e-01f, 4.07833785e-01f, -2.77436018e-01f, -1.61360279e-01f, -1.46500096e-01f, 8.51585448e-01f,
  2.70474136e-01f, -9.46617350e-02f, 1.38253614e-01f, -1.37648448e-01f, -2.21868068e-01f, 9.96058434e-02f, 1.90513134e-01f, -2.22121738e-02f, -6.58809915e-02f, -5.21005243e-02f,
  1.36902016e-02f, 9.87543464e-02f, 8.63398090e-02f, -1.29608558e-02f, -9.77020115e-02f, 9.96492617e-03f, -1.15688846e-01f, 6.72004446e-02f, -2.50447355e-02f, -9.07029361e-02f,
  -9.34055448e-02f, 1.62002668e-01f, -1.30268246e-01f, -2.94839650e-01f, -1.43311560e-01f, 8.51157457e-02f, -4.21806931e-01f, 3.14080864e-02f, -1.77367195e-01f, 6.56347796e-02f,
  9.54838693e-02f, 2.69711912e-02f, 2.07848381e-02f, 4.45993841e-02f, -1.49422204e-02f, 8.10105056e-02f, 1.04960375e-01f, -8.59443247e-02f, 7.72172958e-02f, 3.71591076e-02f,
  5.76708140e-03f, 2.38552932e-02f, -3.24865952e-02f, 4.64036353e-02f, 1.97877046e-02f, -9.49864462e-03f, 1.26515538e-01f, -1.50402382e-01f, -5.29701822e-02f, 2.94953864e-02f,
  1.74520090e-01f, 3.76450345e-02f, -8.13006461e-02f, -1.91751882e-01f, -1.11180678e-01f, -4.61344384e-02f, 1.51240796e-01f, -1.52915448e-01f, -9.61260721e-02f, -1.65804159e-02f,
  -3.28172237e-01f, -2.44116172e-01f, 5.13129592e-01f, 1.49706960e-01f, 2.08968252e-01f, -1.03480443e-01f, 1.01461507e-01f, 6.99553415e-02f, -1.49741294e-02f, -4.55916449e-02f,
  -1.74892426e-01f, 3.46590243e-02f, -2.16211691e-01f, -7.90132508e-02f, 8.58273208e-02f, -1.08766034e-02f, -4.32934314e-02f, 8.94664079e-02f, -2.05830544e-01f, -2.03905240e-01f,
  -2.21719116e-01f, 5.12512326e-02f, 2.64923096e-01f, -2.39719898e-02f, -2.03201063e-02f, 3.96039754e-01f, -1.13557845e-01f, -5.71775436e-02f, 1.35993529e-02f, -1.26943262e-02f,
  -1.00716972e+00f, -7.46453464e-01f, -3.27358365e-01f, -2.10974455e+00f, -4.50111866e-01f, 3.06647509e-01f, 4.19868194e-02f, -6.35828897e-02f, -7.04151690e-01f, -6.70713365e-01f,
  1.40180692e-01f, 8.84433329e-01f, 3.08436066e-01f, 6.67914987e-01f, 8.93457413e-01f, -5.69397926e-01f, -6.49925888e-01f, 5.81542313e-01f, 1.49912405e+00f, 1.02567840e+00f,
  4.24353108e-02f, -4.38383043e-01f, -2.12749094e-01f, -2.35722661e-01f, -1.25880170e+00f, 1.57449454e-01f, -7.37064421e-01f, -5.71601689e-01f, 1.03959262e-01f, -1.25876939e+00f,
  9.26837474e-02f, -6.78636014e-01f, 4.58463222e-01f, 1.47588223e-01f, -2.08689407e-01f, -3.40087675e-02f, 7.05767199e-02f, -2.71290898e-01f, 1.18216507e-01f, -3.40476811e-01f,
  -3.42363566e-01f, 8.19463432e-02f, 6.18857890e-02f, -2.00405670e-03f, -2.06113532e-01f, 3.49411671e-03f, -3.25160295e-01f, -8.65635872e-02f, -1.07192129e-01f, 6.96360171e-02f,
  -1.49318740e-01f, 1.76329054e-02f, -6.83390424e-02f, -2.43018232e-02f, 1.70330822e-01f, 3.18718284e-01f, 2.56754756e-01f, 1.20479628e-01f, 2.65156448e-01f, -6.21596932e-01f,
  -8.59536976e-03f, 4.17393595e-02f, -3.11585274e-02f, -3.14630941e-02f, -2.13844348e-02f, 7.69665465e-02f, -6.86959624e-02f, 4.08194549e-02f, 1.49703950e-01f, 7.74283260e-02f,
  4.99904826e-02f, 5.62588349e-02f, 3.79765183e-02f, -1.25229016e-01f, -3.20693962e-02f, -2.43224129e-01f, -1.09757915e-01f, -9.42235664e-02f, -1.31924659e-01f, -2.52131462e-01f,
  1.17005594e-01f, -1.41814305e-02f, -2.10941702e-01f, 1.76970348e-01f, 1.36002317e-01f, -8.08949322e-02f, 4.08003628e-02f, 1.68802500e-01f, 1.45363230e-02f, -2.16836017e-02f,
  -6.36482760e-02f, 4.89928693e-01f, -2.44117349e-01f, 1.51116565e-01f, -2.86258817e-01f, -1.35827661e-01f, -1.66089311e-01f, -7.66915828e-02f, -1.57816306e-01f, 1.32072885e-02f,
  1.44017622e-01f, 1.12227783e-01f, -2.82876372e-01f, -8.78036302e-03f, 1.06251247e-01f, -1.75157636e-01f, 4.28817682e-02f, -1.24112435e-01f, 2.30567660e-02f, -1.86807707e-01f,
  -1.15318976e-01f, 1.10237449e-01f, 2.62644142e-01f, 2.04915684e-02f, 1.10154152e-02f, 4.99878287e-01f, 2.29348809e-01f, 1.02480344e-01f, 4.39500064e-01f, -3.93817246e-01f,
  1.64275777e+00f, 7.11099684e-01f, 7.87109852e-01f, 7.28739798e-02f, -3.27961147e-01f, -2.66635388e-01f, 3.43718678e-02f, -6.27043620e-02f, -3.97941470e-01f, 1.20830357e-01f,
  2.65806794e-01f, -6.61436394e-02f, 9.37175602e-02f, 2.99655311e-02f, 3.17304611e-01f, -1.86786667e-01f, -3.35740656e-01f, 3.71127516e-01f, 3.26961398e-01f, -2.67577767e-02f,
  -3.87439460e-01f, 1.69949159e-01f, 5.98622441e-01f, 8.64996240e-02f, -1.52332529e-01f, -3.33362430e-01f, 5.89126945e-02f, 1.00053854e-01f, 8.66303742e-02f, -9.50549394e-02f,
  6.62423909e-01f, 5.96213579e-01f, -3.91785681e-01f, -2.09416166e-01f, 1.22365743e-01f, -3.63218263e-02f, -8.75483826e-02f, 1.40861087e-02f, -5.49605787e-02f, -2.34721810e-01f,
  -4.36070785e-02f, 1.56201884e-01f, 9.25398320e-02f, -9.71739888e-02f, 1.92351304e-02f, -4.36402522e-02f, 1.12249732e-01f, 1.34916544e-01f, 1.35624543e-01f, 1.79185763e-01f,
  -1.34931803e-01f, 1.00634873e-01f, 2.64204014e-02f, -2.09390029e-01f, 1.57439634e-01f, -8.36906657e-02f, 1.25260487e-01f, 4.88890596e-02f, 4.13522646e-02f, -1.25636593e-01f,
  3.44489329e-02f, 1.37048841e-01f, 1.70308515e-01f, -1.63088769e-01f, 7.91118294e-02f, -5.58998436e-02f, -1.07302390e-01f, -1.56262100e-01f, 2.63314359e-02f, 1.00166671e-01f,
  -2.15188608e-01f, 4.17116657e-02f, 5.19843809e-02f, -1.62812606e-01f, -1.87450573e-02f, 1.88125834e-01f, 6.32707551e-02f, 7.42595643e-02f, 4.66006808e-02f, 6.09347560e-02f,
  9.69754532e-02f, 4.19755727e-02f, 1.87062413e-01f, 1.40133753e-01f, -9.98730212e-02f, -4.27356176e-02f, -5.45495488e-02f, -1.11962184e-02f, -6.06320687e-02f, -3.89716290e-02f,
  -4.61102337e-01f, 3.66224527e-01f, -1.41577706e-01f, 1.53938502e-01f, 7.45661110e-02f, 1.44293860e-01f, 2.60177478e-02f, -7.89223388e-02f, -1.22886047e-01f, -8.78504738e-02f,
  -7.42874146e-02f, 1.31008193e-01f, 2.31770530e-01f, 9.08805653e-02f, -1.16193779e-01f, -1.10841408e-01f, -2.78958194e-02f, 8.17665309e-02f, 1.00244217e-01f, -2.31121797e-02f,
  -2.71694995e-02f, -2.39737183e-01f, -2.08635107e-01f, -2.71382391e-01f, -2.08461791e-01f, -3.33239198e-01f, -1.83594629e-01f, -7.13310763e-02f, -6.76707849e-02f, -4.50521618e-01f,
  1.08545315e+00f, -2.63594747e-01f, -1.81235361e+00f, 6.62360072e-01f, -7.06904113e-01f, -7.07493842e-01f, -5.96913636e-01f, 8.59756321e-02f, 4.46855336e-01f, -2.35523880e-01f,
  -4.32554215e-01f, 1.47240341e-01f, -2.04736575e-01f, -1.03916802e-01f, 1.48742422e-01f, -6.99399173e-01f, -5.50940871e-01f, -1.53729305e-01f, 5.16718661e-04f, 3.06625843e-01f,
  5.70120037e-01f, 1.04855227e+00f, 1.28330064e+00f, 4.47919577e-01f, -4.55271117e-02f, -1.36214390e-01f, -4.56819296e-01f, -1.27175767e-02f, -4.70541745e-01f, -3.59792978e-01f,
  -7.86575854e-01f, -3.67838204e-01f, -2.85497487e-01f, 3.96719724e-01f, -2.52027333e-01f, 8.90392661e-02f, -6.06228858e-02f, -1.21415973e-01f, -1.34104192e-01f, 8.80289823e-02f,
  -2.20921576e-01f, 1.89186007e-01f, -1.63471222e-01f, -2.76055951e-02f, 1.41792551e-01f, -1.22597270e-01f, 2.59909034e-01f, -3.63514461e-02f, -3.26537132e-01f, -4.68687922e-01f,
  -2.57354844e-02f, -4.14244264e-01f, -1.09506238e+00f, -1.62127867e-01f, -4.63602155e-01f, 8.85917991e-02f, -3.17567497e-01f, -3.29425424e-01f, -4.74444747e-01f, 2.36658305e-01f,
  1.70997128e-01f, 6.36277795e-02f, -1.31601661e-01f, 3.48951481e-02f, 1.89577490e-01f, -1.51552439e-01f, -4.82341498e-02f, 1.06234718e-02f, 3.38275760e-01f, 7.31780799e-03f,
  -3.25763784e-02f, -3.55143398e-02f, 1.59549329e-03f, -7.89135247e-02f, -2.01878906e-03f, -1.68240875e-01f, -1.57708317e-01f, 8.77186209e-02f, -1.52565494e-01f, 1.71295911e-01f,
  -1.82188243e-01f, -1.78172037e-01f, -7.11991861e-02f, 1.36905104e-01f, -1.67429864e-01f, -3.09032016e-02f, -1.95685830e-02f, 2.20816880e-01f, 1.92880183e-01f, -5.10857292e-02f,
  4.41542089e-01f, -1.32175107e-02f, -8.86927694e-02f, 3.09724025e-02f, -1.09670974e-01f, -2.41752341e-02f, 5.99921457e-02f, -1.81725749e-03f, 1.48386257e-02f, 2.60137999e-03f,
  -9.84300394e-03f, 8.07014555e-02f, -2.72351950e-02f, 1.57537073e-01f, -1.61313154e-02f, -6.41979054e-02f, 7.31533617e-02f, -2.47151673e-01f, 2.60096341e-02f, 2.18736157e-01f,
  3.53138894e-01f, -9.77253094e-02f, -1.32838994e-01f, -1.09271251e-01f, 1.49628103e-01f, -1.80074692e-01f, -1.09456725e-01f, -9.76521298e-02f, -5.65077901e-01f, 3.37816805e-01f,
  9.23454523e-01f, -8.61929417e-01f, 2.05759093e-01f, 5.94258189e-01f, 5.53902984e-01f, 5.77923298e-01f, 3.55454654e-01f, 4.19531137e-01f, 4.77090776e-01f, 4.48292531e-02f,
  -1.41512752e-01f, 5.24321906e-02f, 7.66194463e-02f, -3.33559811e-02f, 9.20716971e-02f, 1.31843463e-01f, 2.48221099e-01f, 3.16010237e-01f, 5.92859685e-01f, 1.22200012e-01f,
  3.22560444e-02f, 1.86686963e-01f, 2.30449349e-01f, 7.40370005e-02f, -2.11504921e-01f, 2.73986280e-01f, 4.49529067e-02f, -4.48285341e-02f, -3.92143607e-01f, -5.68165660e-01f,
  -9.18313265e-01f, -2.63681918e-01f, 1.86227351e-01f, -4.34457511e-02f, -3.17608237e-01f, -1.20243371e-01f, -4.95341979e-02f, -1.63358629e-01f, -1.36629328e-01f, 2.47625578e-02f,
  -1.02681600e-01f, -1.46980941e-01f, -4.27375622e-02f, -5.56595391e-04f, 7.87608400e-02f, 9.86285284e-02f, 2.65236408e-03f, 8.39071572e-02f, -9.76722613e-02f, -1.84818283e-01f,
  -2.63435781e-01f, -1.13032602e-01f, 1.15092576e-01f, 1.49518415e-01f, -3.99939045e-02f, 1.72607601e-01f, -2.34269917e-01f, -2.29054257e-01f, 1.28994301e-01f, -1.39846681e-02f,
  1.73070520e-01f, -1.09930471e-01f, 2.04615742e-02f, -1.97715797e-02f, 1.07588954e-01f, 9.76966023e-02f, -6.12344705e-02f, 9.69333127e-02f, 2.88339764e-01f, 1.18843213e-01f,
  1.03108302e-01f, 3.10855433e-02f, 2.01952383e-02f, 1.14266023e-01f, 2.01272517e-02f, -8.23922735e-03f, -1.66804880e-01f, -6.61405474e-02f, 4.30954546e-02f, 4.72124703e-02f,
  4.44076210e-02f, -1.00963742e-01f, -1.72436863e-01f, -1.79393604e-01f, -2.15759993e-01f, -1.30298436e-02f, -6.12869263e-02f, -5.03904708e-02f, 1.43062040e-01f, -7.53731793e-03f,
  -6.19754158e-02f, 5.77523708e-01f, -1.76604316e-01f, -1.64646253e-01f, -5.02444953e-02f, -8.86584595e-02f, -4.41024080e-02f, -2.45020583e-01f, -2.26062939e-01f, -6.26231134e-02f,
  -1.12165980e-01f, -1.11719355e-01f, -1.52471408e-01f, -1.25536114e-01f, 2.12514549e-01f, 2.05373049e-01f, -1.90359920e-01f, 4.98221256e-02f, -1.50917724e-01f, -2.39954874e-01f,
  -5.18265627e-02f, 3.97798628e-01f, 2.80087262e-01f, 3.81239563e-01f, 1.25869229e-01f, 4.36368138e-01f, 4.15949412e-02f, -3.51370610e-02f, 3.90687048e-01f, 3.84673506e-01f,
  9.74134505e-01f, 3.77501577e-01f, -1.10314250e+00f, 3.42918962e-01f, -9.54083681e-01f, -9.53191161e-01f, -6.32825494e-01f, -6.59361389e-03f, 3.43205959e-01f, -2.80006438e-01f,
  -4.47710641e-02f, 4.69698310e-01f, 7.95718670e-01f, 8.53354037e-02f, 2.76778620e-02f, -2.25318313e-01f, -5.60490727e-01f, -4.56993341e-01f, -9.44607258e-01f, -1.27385581e+00f,
  -8.02441239e-01f, -5.12952924e-01f, -2.06499040e-01f, -1.14329189e-01f, 1.71190783e-01f, 1.42407253e-01f, -3.32127661e-02f, -2.67195493e-01f, -5.06304026e-01f, -3.29854012e-01f,
  -5.16136624e-02f, 2.26383973e-02f, -1.13201169e-02f, 4.63736691e-02f, 2.43106827e-01f, 2.65169889e-01f, 1.26658320e-01f, 2.02845648e-01f, 3.79400909e-01f, 1.45131886e-01f,
  3.08013894e-02f, -6.59804866e-02f, 9.65896249e-02f, -1.06592752e-01f, -4.51970175e-02f, -2.02192143e-01f, -5.30486554e-02f, -3.57293002e-02f, 1.13364950e-01f, -1.49208039e-01f,
  -2.81061143e-01f, -3.62824947e-01f, 4.21213284e-02f, -4.47292365e-02f, -1.62815720e-01f, -2.75031812e-02f, -7.77241513e-02f, -1.38929993e-01f, -1.02049492e-01f, 3.60153258e-01f,
  3.29501145e-02f, 2.69685477e-01f, -1.27733007e-01f, -4.40157838e-02f, 1.55497268e-01f, 1.43623292e-01f, 4.94888052e-02f, 2.91656610e-02f, -4.61676121e-02f, 7.50263333e-02f,
  6.81944937e-02f, 5.27645368e-03f, 4.61021252e-02f, 1.06782384e-01f, -9.37262848e-02f, -1.09292559e-01f, -3.83561812e-02f, -4.31475937e-02f, 2.59543601e-02f, 9.32646766e-02f,
  4.63326834e-02f, -5.94719984e-02f, 5.61820492e-02f, -4.19812426e-02f, -2.84258872e-01f, 3.92654054e-02f, -2.40639281e-02f, -1.31754339e-01f, 3.17300335e-02f, -9.93143916e-02f,
  8.47265005e-01f, -1.30776286e-01f, 5.17018020e-01f, 3.16980220e-02f, -1.93104427e-02f, 1.28207043e-01f, 8.88339952e-02f, -2.44903192e-02f, 5.81434108e-02f, -1.63469046e-01f,
  -3.32720160e-01f, 7.97743350e-02f, 6.98664337e-02f, -1.39823541e-01f, -1.51943594e-01f, -1.81096539e-01f, -5.02796508e-02f, -1.59203023e-01f, -1.88911840e-01f, -1.52653858e-01f,
  -7.76744187e-02f, -1.97934341e-02f, 3.62223238e-01f, 1.33716062e-01f, 5.10224812e-02f, 1.26138926e-01f, 1.46602094e-01f, 7.83441812e-02f, 1.95679516e-02f, 4.78037536e-01f,
  -1.18259084e+00f, -5.88928521e-01f, 2.10650548e-01f, -7.05896085e-03f, 2.70421237e-01f, -5.04329979e-01f, -9.54438508e-01f, -8.13087225e-01f, -2.80534923e-01f, -2.12740809e-01f,
  2.76320189e-01f, 6.32273495e-01f, 6.94992602e-01f, 5.08315682e-01f, -1.78378448e-02f, -2.34420657e-01f, 1.21791460e-01f, 3.75371635e-01f, 2.48516485e-01f, -7.15809539e-02f,
  2.57767767e-01f, 6.87813014e-02f, 9.05434787e-02f, 1.08652655e-02f, 9.31202993e-02f, 6.14535570e-01f, 3.01287144e-01f, 2.64489084e-01f, 1.72202170e-01f, 3.48341346e-01f,
  5.00997901e-01f, -5.42248368e-01f, 3.39091003e-01f, 3.00109029e-01f, 3.02554071e-01f, -2.52625942e-01f, -1.06484093e-01f, -7.72013292e-02f, -1.49243817e-01f, -1.72407210e-01f,
  1.62013799e-01f, 8.14442784e-02f, 1.53714091e-01f, 9.74318162e-02f, -1.59020603e-01f, -7.38967061e-02f, -1.74745411e-01f, -9.82952118e-02f, -3.80862541e-02f, -1.00093395e-01f,
  1.38616353e-01f, -3.98371108e-02f, -5.08593991e-02f, -6.03317618e-02f, -3.08863193e-01f, 3.78325433e-01f, 4.55231741e-02f, -9.74854156e-02f, 3.74289192e-02f, -1.99677706e-01f,
  1.49360150e-01f, -1.39795092e-03f, 5.13431318e-02f, 9.84665975e-02f, 8.69055614e-02f, -9.99733061e-02f, -5.66337723e-03f, 3.30157913e-02f, 1.80117823e-02f, -1.70393527e-01f,
  4.40620445e-02f, 8.65676254e-02f, -1.40870243e-01f, -1.39032602e-01f, 2.59943962e-01f, -6.87264353e-02f, -1.08004585e-01f, -1.76984183e-02f, 8.46627653e-02f, -3.18005495e-02f,
  6.05057068e-02f, -5.90962991e-02f, 1.23096012e-01f, 3.98546644e-02f, -7.43446648e-02f, 6.69518411e-02f, 1.24344463e-02f, 4.92006494e-03f, 6.98094815e-02f, -6.43428639e-02f,
  2.14707598e-01f, 4.51955348e-01f, 2.54371371e-02f, -1.41297907e-01f, -7.96664059e-02f, -1.80431083e-01f, 7.76120797e-02f, -3.45979864e-03f, 1.92678481e-01f, -1.15840733e-01f,
  -1.84905585e-02f, -1.11278728e-01f, -1.15180835e-02f, -1.04190735e-02f, 1.09538287e-01f, 1.37052462e-02f, -7.04186857e-02f, 1.47664130e-01f, 4.66373470e-03f, -1.58091262e-02f,
  -1.74637690e-01f, -3.27405185e-01f, -1.42462045e-01f, 3.34111601e-02f, -6.22175038e-02f, 2.17908695e-01f, 1.11748509e-01f, -8.13657343e-02f, 4.14971411e-02f, -1.48127720e-01f,
  -1.10070932e+00f, 9.57534969e-01f, 1.00309312e+00f, -3.74758273e-01f, 5.04118025e-01f, 2.71245450e-01f, 5.67450702e-01f, -3.52791101e-01f, -6.41057909e-01f, 3.87531042e-01f,
  2.10082024e-01f, -6.51659727e-01f, -1.91070110e-01f, -2.69880563e-01f, -2.87550688e-01f, 6.80857420e-01f, 1.01476109e+00f, 3.90029214e-02f, -7.72165954e-01f, -7.02412128e-01f,
  -2.45443344e-01f, -3.17805171e-01f, -4.64413434e-01f, 1.90505553e-02f, 1.79673553e-01f, -5.21425247e-01f, 5.88669598e-01f, 2.45305553e-01f, 6.07939541e-01f, 7.73556888e-01f,
  -2.85014182e-01f, 1.88374773e-01f, -3.29188347e-01f, -1.54827282e-01f, 2.70745009e-01f, -4.74808887e-02f, 4.63144518e-02f, -3.73683758e-02f, 3.03770125e-01f, 2.76814342e-01f,
  2.62275655e-02f, 2.29048565e-01f, 2.80767709e-01f, -2.67247688e-02f, -3.20356041e-01f, -4.29424107e-01f, -9.05608833e-02f, -2.48881400e-01f, -2.65806377e-01f, -1.05635196e-01f,
  3.02288562e-01f, 1.60217360e-01f, 9.01407152e-02f, 3.01037468e-02f, 1.32858008e-01f, -2.81751841e-01f, 1.64399967e-01f, -5.09110868e-01f, -2.30355561e-01f, -4.83963639e-01f,
  -1.49960905e-01f, 9.29005072e-02f, 1.17206037e-01f, -8.03942531e-02f, -8.68528895e-03f, 6.24905676e-02f, -8.93880555e-04f, 4.12923563e-03f, 1.75242305e-01f, -1.55565172e-01f,
  1.28520474e-01f, -2.80598640e-01f, -9.38217863e-02f, 2.24355936e-01f, 4.21858393e-02f, -7.34282658e-02f, 1.46750554e-01f, 2.15109251e-02f, 1.58511978e-02f, 4.58163954e-02f,
  -1.55261448e-02f, -7.82007445e-03f, -1.16912425e-02f, -3.02076608e-01f, 3.64333451e-01f, 8.85961577e-02f, -4.73386906e-02f, 9.47052799e-03f, -1.04710191e-01f, 1.46647051e-01f,
  -6.98003471e-01f, 4.67221707e-01f, -5.56736052e-01f, -2.23738365e-02f, 9.68192667e-02f, 1.82851646e-02f, 1.00825593e-01f, 3.32958177e-02f, -1.94793165e-01f, -2.47153267e-01f,
  -7.96982050e-02f, -1.15367688e-01f, 9.03336033e-02f, 1.02130271e-01f, -5.09970069e-01f, -2.62888558e-02f, 8.45981538e-02f, -1.18545264e-01f, -2.07000062e-01f, -1.29646704e-01f,
  3.73725265e-01f, -5.66554964e-01f, -9.40155029e-01f, -4.16060120e-01f, -3.39009792e-01f, -1.00847471e+00f, -3.53279740e-01f, -7.54075050e-01f, -5.90503514e-01f, -7.54853904e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.96086490e-01f, 5.62118530e-01f, 1.37020004e+00f, 1.25301278e+00f, 1.32688344e+00f, 1.76286900e+00f, 1.38194537e+00f, 6.25179410e-01f, 1.13399708e+00f, 1.48652720e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.24677014e-01f, -5.56860387e-01f, -1.06412077e+00f, -6.29474044e-01f, -7.51993597e-01f, -3.43821198e-01f, -7.90257931e-01f, 3.69320780e-01f, -7.93543875e-01f, 4.74535853e-01f,
  -1.99408248e-01f, 8.48286152e-01f, -7.78869510e-01f, -7.22386956e-01f, -6.36891603e-01f, -1.60033345e+00f, 4.94021773e-01f, -1.68966919e-01f, -5.15009761e-01f, -2.29207307e-01f,
  6.28674150e-01f, -9.79421020e-01f, -1.89266846e-01f, -1.49228549e+00f, 2.85783440e-01f, 3.95797372e-01f, 3.43210399e-01f, -1.94670364e-01f, 4.97898430e-01f, 6.07060432e-01f,
  -1.74833551e-01f, -1.46457160e+00f, -9.09371614e-01f, 2.46344253e-01f, -6.16027741e-03f, -9.36663568e-01f, 5.67161858e-01f, -7.47875571e-01f, -1.93511176e+00f, -1.09978306e+00f,
  -3.58227670e-01f, -4.10112261e-04f, 2.10433111e-01f, 6.93949044e-01f, -2.87600402e-02f, -1.07236421e+00f, 1.23481870e+00f, 1.30629897e-01f, 2.57881749e-02f, -2.32786983e-01f,
  2.92028159e-01f, -4.04814482e-01f, -8.53159070e-01f, -3.93129408e-01f, -8.62237871e-01f, 2.60714382e-01f, -9.01022673e-01f, 1.31354272e+00f, -1.43986452e+00f, -1.86302221e+00f,
  -1.92248613e-01f, -1.00734079e+00f, -2.17558098e+00f, 9.12729502e-01f, 4.00045067e-01f, 1.59762144e-01f, -2.95455694e-01f, -2.17148602e-01f, 5.07772207e-01f, -3.74640465e-01f,
  2.53861636e-01f, 8.24335158e-01f, -5.90593934e-01f, -1.19461906e+00f, -3.36705089e-01f, -7.20171630e-01f, 7.07779229e-02f, 7.05308735e-01f, 8.03690553e-02f, -1.80494994e-01f,
  -3.26269388e-01f, 4.19927269e-01f, 6.94349408e-01f, 7.16248393e-01f, 3.66105080e-01f, 6.88744724e-01f, 3.50441098e-01f, -3.42679739e-01f, -5.22029757e-01f, -1.21284628e+00f,
  -8.96517992e-01f, 1.21418846e+00f, 1.85496509e-01f, 7.72628903e-01f, -1.00521922e+00f, -1.84151971e+00f, 1.19426958e-02f, -3.68722439e-01f, -6.12993315e-02f, -1.24291897e+00f,
  1.12028623e+00f, 3.07917625e-01f, 4.38656569e-01f, -1.50502229e+00f, 8.75153065e-01f, -1.04558408e+00f, 7.59094894e-01f, 2.69173503e-01f, -1.48431528e+00f, -7.83445954e-01f,
  -1.13642955e+00f, -9.10542160e-02f, -1.02810059e-02f, -1.96214333e-01f, -3.84744592e-02f, 1.56204365e-02f, 9.75293946e-03f, 2.03252286e-01f, 4.77449208e-01f, -2.29506955e-01f,
  -4.32590485e-01f, -7.82892346e-01f, -1.36894798e+00f, -6.57114029e-01f, -9.56063047e-02f, -8.57644618e-01f, 3.13954949e-01f, 9.85967636e-01f, 4.95377958e-01f, -1.46369919e-01f,
  5.22286773e-01f, 3.39951843e-01f, -6.76882863e-01f, 5.48655927e-01f, -9.14634466e-01f, -8.44546497e-01f, 1.16180730e+00f, 4.52158362e-01f, -1.28283417e+00f, -1.09688425e+00f,
  7.03681529e-01f, -1.02779984e+00f, -5.83165467e-01f, -1.52786136e-01f, 3.37648213e-01f, -7.50553086e-02f, 6.92367852e-01f, 1.26918769e+00f, 5.97550213e-01f, -1.97134882e-01f,
  5.23107871e-02f, 3.83638829e-01f, 7.67615497e-01f, -2.26080251e+00f, -2.85472900e-01f, 1.76623046e-01f, -1.30866265e+00f, -7.98657954e-01f, 9.79390085e-01f, 1.33396760e-01f,
  -2.85691291e-01f, 2.29983315e-01f, 3.71560901e-01f, 6.68348193e-01f, 7.05372393e-01f, 1.11048770e+00f, -3.05546731e-01f, -2.57972628e-01f, -1.10133410e+00f, 1.04442382e+00f,
  -6.84540212e-01f, -1.70372593e+00f, -5.92609942e-01f, 1.32679805e-01f, 8.88075292e-01f, -1.29478455e+00f, 4.06748623e-01f, 2.67653346e-01f, 1.71099693e-01f, -1.44708857e-01f,
  -4.30568308e-01f, 5.98161817e-02f, -2.15926275e-01f, -3.98250997e-01f, -1.84277821e+00f, -6.47500932e-01f, 1.27610636e+00f, -1.66601956e+00f, -1.93521336e-01f, -7.92686045e-01f,
  -1.16602325e+00f, 6.66763127e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.46410823e-01f, -3.08503598e-01f, 1.07210748e-01f, 3.26328814e-01f, 9.02691334e-02f, 2.58430913e-02f, -3.30973789e-02f, -5.48177660e-01f, 2.13448033e-01f, -7.73591042e-01f,
  -7.40157485e-01f, 3.72041166e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    