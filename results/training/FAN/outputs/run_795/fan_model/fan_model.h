/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.44738898e-01f, 1.24989003e-01f, 7.96951279e-02f, -4.72032204e-02f, 1.41870096e-01f, 9.07238424e-02f, 2.66339898e-01f, -6.98848069e-02f, -1.24552362e-01f, 1.24687493e-01f,
  3.58002186e-02f, -1.33830965e-01f, -9.43099558e-02f, -1.22492291e-01f, -1.60413116e-01f, 4.28192466e-02f, 7.60601163e-02f, -1.44406259e-01f, -1.33907974e-01f, -3.63585390e-02f,
  -1.55619741e-03f, -8.38046074e-02f, -2.10277855e-01f, -2.15617806e-01f, 1.66735038e-01f, -1.69600204e-01f, -2.47891322e-02f, 7.53698051e-02f, 4.05756310e-02f, 2.59007394e-01f,
  2.41418615e-01f, 2.38777697e-01f, -1.29070595e-01f, -6.32259473e-02f, 7.27654845e-02f, 1.02363952e-01f, 5.76564260e-02f, 2.02340167e-03f, -1.25429425e-02f, 2.41769664e-02f,
  1.12213835e-01f, -1.83811653e-02f, 3.46062556e-02f, -7.90221058e-03f, 3.73267308e-02f, 8.45799968e-02f, 5.55411465e-02f, -1.57572478e-02f, 1.12109920e-02f, 1.36035681e-01f,
  -3.82585712e-02f, 6.23630919e-02f, 1.07940748e-01f, -1.00649506e-01f, 5.13585173e-02f, -1.57093480e-02f, 4.74735834e-02f, 2.49094586e-03f, -8.28730091e-02f, 2.42049266e-02f,
  -3.34886461e-02f, -7.15267360e-02f, 7.25588575e-02f, -6.08606972e-02f, -1.72071103e-02f, 6.49906397e-02f, -4.41614352e-02f, 4.19948623e-02f, -6.09802380e-02f, 3.53302136e-02f,
  6.30169548e-03f, -1.33966208e-02f, -3.05726510e-02f, -1.55158490e-02f, -6.73213005e-02f, 3.18665840e-02f, 7.69168651e-03f, -1.11782765e-02f, 7.36967474e-02f, 1.15633495e-02f,
  7.19746500e-02f, 3.87946591e-02f, -3.79448310e-02f, -1.17647108e-02f, 5.80320731e-02f, -1.61541346e-02f, -3.72076221e-02f, -6.10132590e-02f, -1.77536141e-02f, 3.66860963e-02f,
  -1.30920321e-01f, -2.42207572e-01f, -7.84340035e-03f, 2.80402917e-02f, 2.47051939e-02f, -3.29415910e-02f, 2.18266062e-02f, -2.49097086e-02f, 6.89773560e-02f, 5.25501482e-02f,
  1.20056622e-01f, 1.03878237e-01f, -1.73538679e-03f, -6.71724696e-03f, -3.54533419e-02f, -2.80532315e-02f, 2.01243293e-02f, -9.10421659e-05f, -6.67722300e-02f, 7.37404078e-02f,
  -5.74068464e-02f, -3.87699381e-02f, -4.87544276e-02f, 5.25971362e-03f, -6.63021803e-02f, -3.86806088e-03f, -4.08646911e-02f, -5.46774976e-02f, -1.82347503e-02f, -1.69061989e-01f,
  -1.34834588e-01f, -2.07844123e-01f, -9.50052664e-02f, 1.32741198e-01f, -1.66106988e-02f, 6.58462122e-02f, -3.37170511e-01f, -5.20396754e-02f, 1.79529294e-01f, -1.56820416e-01f,
  1.64145470e-01f, 3.66211832e-01f, 2.30981097e-01f, 1.17425896e-01f, -9.90247428e-02f, -3.27682674e-01f, -2.68217713e-01f, -1.97008122e-02f, 2.67510444e-01f, 6.03400990e-02f,
  1.85746297e-01f, -4.12932597e-02f, 4.58140001e-02f, 1.00316055e-01f, -2.15760276e-01f, 3.66929501e-01f, -1.07120372e-01f, -1.91884071e-01f, -6.22149594e-02f, -4.66447979e-01f,
  2.77803876e-02f, -2.31482849e-01f, 7.92982355e-02f, 2.95334565e-03f, -3.18069048e-02f, -6.24668133e-03f, -2.61045713e-02f, -6.23976626e-02f, 1.05003193e-01f, -4.53357585e-04f,
  5.83387204e-02f, 6.18560202e-02f, 8.49360377e-02f, 4.38003466e-02f, -4.51794863e-02f, -2.05223961e-03f, -3.17236781e-02f, -1.26402557e-01f, -1.47920111e-02f, -6.85552582e-02f,
  4.66194935e-02f, 1.05140498e-03f, -9.89469290e-02f, -6.55097514e-02f, 2.89977584e-02f, 1.65465623e-01f, -1.06787076e-02f, -1.54083729e-01f, -9.37289968e-02f, -3.73461574e-01f,
  4.13724259e-02f, -3.72263603e-02f, 4.00420465e-02f, -7.99211338e-02f, 6.81974143e-02f, -2.40054820e-02f, -2.83431858e-02f, 7.47654960e-02f, -3.67639959e-02f, -6.92111775e-02f,
  4.00738791e-02f, 6.13696547e-03f, 1.39680086e-02f, -2.17955094e-02f, 3.70643139e-02f, -3.22870649e-02f, 1.23865288e-02f, -7.88513850e-03f, 6.32715672e-02f, -4.52209413e-02f,
  1.31245945e-02f, -4.84389551e-02f, -4.17340398e-02f, -6.07561469e-02f, 2.63977647e-02f, 3.45580280e-02f, -9.89540014e-03f, 4.12632264e-02f, 4.74388897e-02f, -4.65232991e-02f,
  1.21288635e-01f, 4.22091261e-02f, -2.79051457e-02f, 4.02837177e-04f, 6.31783158e-02f, -7.46661937e-03f, 6.77372739e-02f, 1.73057884e-03f, 4.69670519e-02f, 3.44023593e-02f,
  2.03088745e-02f, 3.05450731e-03f, 2.63146646e-02f, -4.24083956e-02f, 1.76806911e-03f, -2.19818354e-02f, 7.36103058e-02f, 4.64203842e-02f, -6.84757368e-04f, 3.98691818e-02f,
  1.56402420e-02f, -5.93512803e-02f, 5.91435805e-02f, -4.23212908e-02f, -3.33261490e-02f, 7.57571310e-02f, 1.15860878e-02f, -9.98042896e-03f, 8.29829182e-03f, -3.86958793e-02f,
  6.82166398e-01f, 2.36328214e-01f, -6.84176832e-02f, 5.07351458e-01f, 3.24147999e-01f, 9.93012786e-02f, 2.52620935e-01f, 7.92592466e-02f, 4.06079479e-02f, 1.24830261e-01f,
  2.63066925e-02f, 8.41562822e-02f, -4.74049933e-02f, -2.94935796e-02f, 1.09584760e-02f, 1.60530165e-01f, 9.68514979e-02f, -1.36895075e-01f, 4.86926548e-02f, 1.44029990e-01f,
  3.41838039e-02f, 2.68009186e-01f, 2.82998066e-02f, -3.48209701e-02f, 1.36391461e-01f, -1.15744844e-01f, -1.57047417e-02f, 4.60218005e-02f, -7.10013658e-02f, 1.45433009e-01f,
  -9.53917354e-02f, 2.24012971e-01f, -1.21799849e-01f, 1.00646012e-01f, -4.54632975e-02f, -1.07453026e-01f, 9.87785980e-02f, 3.58585455e-02f, 2.54646838e-02f, -1.96754429e-02f,
  4.01159786e-02f, -5.12822084e-02f, 8.96691978e-02f, -5.43367676e-02f, 1.14300713e-01f, 2.05376297e-02f, -7.58056492e-02f, 3.91324647e-02f, -1.17508434e-01f, -7.06742778e-02f,
  1.13415033e-01f, -1.28012616e-02f, 4.78765443e-02f, -6.66308627e-02f, -1.23353891e-01f, -2.37013064e-02f, -7.90463462e-02f, -5.99858686e-02f, -1.64998308e-01f, 2.71670204e-02f,
  5.13180308e-02f, -5.40644713e-02f, -1.81372836e-02f, 2.81421393e-02f, 4.88854647e-02f, -1.18873240e-02f, -5.06823650e-03f, 1.05493039e-01f, -3.47168520e-02f, 6.02974258e-02f,
  5.91229089e-03f, 1.24632893e-02f, -9.54204879e-04f, 9.96728614e-02f, -2.61333063e-02f, 2.08026599e-02f, 1.28523901e-03f, 3.94603647e-02f, -6.04922362e-02f, -2.22058333e-02f,
  1.54896313e-02f, -1.24968037e-01f, -1.01473033e-02f, -7.60757700e-02f, -5.52195907e-02f, 5.48917390e-02f, -4.56053391e-02f, 5.80334999e-02f, 5.80500299e-03f, -5.21003362e-03f,
  2.05572516e-01f, -2.08573639e-01f, 4.32204306e-02f, -1.05484657e-01f, 4.91120033e-02f, -3.68832275e-02f, -1.78974960e-02f, -4.40169424e-02f, 3.41321714e-02f, -2.54082456e-02f,
  9.51919798e-03f, 4.49309731e-03f, -2.28688512e-02f, -8.31898525e-02f, 3.42524471e-03f, -4.88658296e-03f, 1.86135378e-02f, 1.53021645e-02f, 3.03228013e-03f, -7.72222281e-02f,
  -5.90703450e-02f, 6.65440038e-02f, 1.08290136e-01f, 2.13363077e-02f, 7.97977448e-02f, 1.60218611e-01f, -2.71064546e-02f, -4.04459201e-02f, -6.15082942e-02f, 7.65601993e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.42056847e-01f, 3.54993552e-01f, 3.61780785e-02f, -2.90424556e-01f, 1.55596897e-01f, 2.92761743e-01f, 4.81471092e-01f, 1.31008759e-01f, -1.54098362e-01f, 1.04377434e-01f,
  8.90539363e-02f, -1.77038476e-01f, -1.26897678e-01f, 5.62783284e-03f, 1.17753372e-01f, 2.96961337e-01f, 1.96612433e-01f, -1.01932429e-01f, -6.99759722e-02f, 1.04938708e-01f,
  5.40722571e-02f, -1.28948599e-01f, -1.93664476e-01f, -7.84627646e-02f, -2.00649157e-01f, -2.98807561e-01f, -9.94245615e-03f, 1.37311518e-02f, 2.25594789e-01f, -1.94125026e-01f,
  -4.32020128e-02f, 7.30968788e-02f, -5.58468839e-03f, -1.91617280e-01f, 2.49432698e-02f, -1.06934756e-01f, -2.15435922e-02f, -1.29650995e-01f, 5.32787107e-02f, 7.28283152e-02f,
  3.94688547e-03f, -8.45396146e-02f, 8.77920014e-04f, -9.44374800e-02f, -6.32131323e-02f, -4.56562415e-02f, 2.94991340e-02f, 7.24269450e-03f, 1.11120800e-02f, 4.41811327e-03f,
  1.33738428e-01f, 1.43727660e-01f, 2.57207572e-01f, 9.84641016e-02f, 4.41926382e-02f, 4.80486378e-02f, 4.49701771e-02f, -9.25321281e-02f, 1.42276987e-01f, -1.80290774e-01f,
  4.85084429e-02f, -2.05105208e-02f, 2.65927636e-03f, -2.62751468e-02f, -2.63499748e-02f, -1.89033244e-02f, -9.30298027e-03f, 4.86591868e-02f, 2.70824274e-03f, -8.69058743e-02f,
  8.58849846e-03f, 8.33020136e-02f, -2.17107311e-02f, -5.07574566e-02f, -9.17364135e-02f, 6.63260743e-02f, 6.93069622e-02f, 7.38236010e-02f, 3.34464409e-03f, 1.00112176e-02f,
  -1.42431185e-02f, 6.04513139e-02f, -1.14816176e-02f, 4.98157972e-03f, 7.65448064e-02f, 1.74055882e-02f, -2.08001565e-02f, 4.96798046e-02f, -8.89811143e-02f, 1.05582429e-02f,
  -1.70834869e-01f, 2.64240563e-01f, -1.09522842e-01f, -1.45077398e-02f, -1.92674417e-02f, -1.01807965e-02f, -5.01555502e-02f, 5.09714410e-02f, -5.87741286e-03f, 6.80998489e-02f,
  -6.62328005e-02f, -7.76154846e-02f, 3.00703607e-02f, -6.54410645e-02f, -8.63691568e-02f, 3.25118229e-02f, 7.97710419e-02f, -5.45488819e-02f, 8.39750916e-02f, -4.73022684e-02f,
  1.25994682e-01f, 1.34229600e-01f, -1.07676826e-01f, -1.49057608e-03f, 5.02606444e-02f, 2.14427747e-02f, -4.37552854e-02f, -7.69508556e-02f, 8.43001623e-03f, -2.52971202e-01f,
  -2.40905210e-01f, 2.83915102e-01f, -4.73609529e-02f, 1.45495296e-01f, 1.32592037e-01f, 1.66138992e-01f, 4.14041698e-01f, 3.21660131e-01f, 6.30188733e-02f, -3.79393175e-02f,
  3.78398150e-02f, -1.03456892e-01f, 1.46825731e-01f, 9.32733119e-02f, 2.69658774e-01f, 2.41837308e-01f, 2.99361706e-01f, -6.07018210e-02f, -1.29326209e-01f, -3.19244079e-02f,
  1.05990596e-01f, -9.76159871e-02f, -2.13770732e-01f, -3.24276276e-02f, 8.46661925e-02f, 1.80753842e-02f, 1.08233675e-01f, 3.74130085e-02f, -2.70076352e-03f, 4.68399338e-02f,
  -1.95811495e-01f, 4.41268049e-02f, 6.35237526e-03f, -3.39497738e-02f, 1.19539881e-02f, -1.03170171e-01f, -9.54851657e-02f, -1.24598332e-01f, -7.85921812e-02f, -1.13463670e-01f,
  2.07358096e-02f, -8.61192569e-02f, 1.48592308e-01f, 4.19968404e-02f, -6.91071004e-02f, -1.03081875e-01f, -5.07062534e-04f, 1.24596898e-02f, 1.13268875e-01f, -1.06825586e-02f,
  -2.65723355e-02f, -1.50625065e-01f, -1.05234861e-01f, 9.22888666e-02f, 1.34621724e-01f, -2.86922697e-02f, 8.93371776e-02f, 1.11325152e-01f, 1.29421756e-01f, 5.62179871e-02f,
  -8.35025832e-02f, -7.64725916e-03f, 7.63614327e-02f, 8.12005531e-03f, -1.00838635e-02f, -1.30757401e-02f, 1.23184435e-02f, -2.02034786e-02f, 3.83501612e-02f, -9.72254723e-02f,
  8.18504617e-02f, -6.84373155e-02f, 4.16995771e-02f, 6.58162236e-02f, -2.09036078e-02f, -8.22752640e-02f, 3.86356302e-02f, 1.05975727e-02f, -1.19521424e-01f, 5.21595031e-02f,
  2.10562646e-02f, -1.31064644e-02f, 6.35545552e-02f, 2.15025488e-02f, 7.30811665e-03f, 3.26607898e-02f, -6.97859079e-02f, -7.27301985e-02f, 6.88597653e-03f, -5.44491112e-02f,
  3.37007158e-02f, 4.59839106e-02f, -1.02556139e-01f, 9.32764262e-02f, -4.16217186e-03f, -5.02057001e-02f, 7.32365996e-02f, -3.30772139e-02f, 1.32486913e-02f, -6.73353393e-03f,
  1.00283036e-02f, 4.15603071e-03f, 7.08303377e-02f, -5.00098132e-02f, -1.06629148e-01f, -2.57231016e-02f, 2.08416767e-02f, 5.64899035e-02f, 1.78295486e-02f, -3.49492542e-02f,
  1.98347494e-02f, -5.97773306e-02f, -9.74191055e-02f, 2.66815140e-03f, -3.58754024e-02f, -3.61076221e-02f, -2.81469394e-02f, -6.89793155e-02f, 8.77506062e-02f, 5.47957495e-02f,
  -5.15514836e-02f, 1.22359164e-01f, -5.60947478e-01f, -2.27274641e-01f, -3.77349585e-01f, -1.82961732e-01f, -2.39825502e-01f, 9.27922353e-02f, 2.25341227e-02f, -2.04049170e-01f,
  -1.10027827e-02f, 7.17645809e-02f, 7.29230940e-02f, -7.95104578e-02f, 2.16254834e-02f, -3.31535339e-01f, -4.45036560e-01f, -2.90912658e-01f, -1.50260940e-01f, -7.57159945e-03f,
  -1.55626640e-01f, -3.48547667e-01f, -1.80772275e-01f, -5.58436066e-02f, -8.46583024e-02f, -5.99931255e-02f, -3.11208457e-01f, -2.37869307e-01f, -1.70575649e-01f, -4.18692529e-01f,
  -9.43128914e-02f, -4.67175730e-02f, -1.39279701e-02f, -1.51513526e-02f, -1.27747580e-01f, 8.48532766e-02f, 6.31669536e-02f, 4.03213920e-03f, 5.96472714e-03f, 5.11969179e-02f,
  -6.99353218e-02f, -3.77357975e-02f, -9.13064405e-02f, -2.80819051e-02f, 1.82261057e-02f, -8.47373232e-02f, -1.65862553e-02f, 2.43609771e-02f, -1.30236251e-02f, 1.18528061e-01f,
  -7.32715707e-03f, -1.12580964e-02f, 8.09418038e-02f, 1.02642581e-01f, 1.33022413e-01f, -5.88353723e-02f, 1.12435907e-01f, 9.39205363e-02f, 7.31337890e-02f, 1.93905622e-01f,
  -7.11691082e-02f, 1.54682890e-01f, 1.06477797e-01f, -2.30220724e-02f, -2.40369812e-02f, 5.39463386e-02f, 2.42920918e-03f, 2.41456330e-02f, 3.21649611e-02f, 5.08454889e-02f,
  2.38240813e-03f, -4.25561033e-02f, -2.44062878e-02f, 6.29386827e-02f, -3.55481692e-02f, 8.33940282e-02f, -7.42473500e-03f, 9.83020440e-02f, -2.72260830e-02f, 3.54968533e-02f,
  -3.93537059e-02f, 6.80946931e-02f, -9.90220159e-02f, 4.42062579e-02f, -1.19863115e-01f, -5.64431027e-02f, 1.95597135e-03f, 1.39982980e-02f, 3.01606189e-02f, -7.82716647e-02f,
  4.32735533e-01f, -2.61142731e-01f, 2.42544990e-02f, 1.55750170e-01f, -5.84284775e-02f, 5.51594868e-02f, 5.18094860e-02f, 2.45671477e-02f, -5.90089448e-02f, -1.33319921e-03f,
  6.15359619e-02f, 7.28446171e-02f, -1.21314049e-01f, 3.61574329e-02f, -5.07226251e-02f, 9.61048063e-03f, 6.69235066e-02f, -4.69102263e-02f, -3.01349442e-02f, 1.14042640e-01f,
  4.23999615e-02f, 1.08135603e-01f, 2.46295989e-01f, 2.36966953e-01f, 1.24143727e-01f, -4.86289822e-02f, 1.45594105e-01f, 8.31362233e-02f, -1.45828724e-02f, 3.25527132e-01f,
  -2.99491435e-01f, -2.54969865e-01f, 4.25032914e-01f, -2.41023928e-01f, -2.62044407e-02f, 1.90617159e-01f, 2.03991979e-01f, -7.40830675e-02f, -1.14506863e-01f, 5.18850796e-02f,
  -1.77282721e-01f, -1.29993826e-01f, -7.04961270e-02f, -1.25475898e-01f, -9.87784564e-02f, 9.90896299e-02f, 3.46917706e-03f, 1.22499950e-01f, 3.24780405e-01f, 1.78351134e-01f,
  7.68474489e-02f, 7.70567805e-02f, -1.29807130e-01f, -7.18832016e-02f, 1.50699252e-02f, 1.49032161e-01f, -2.77196486e-02f, -6.02850951e-02f, -1.22112177e-01f, -2.90511716e-02f,
  4.18668360e-01f, -3.68268162e-01f, -1.15740364e-02f, -4.35621738e-01f, -3.98331136e-02f, -6.35640025e-02f, 7.56636187e-02f, -4.19524647e-02f, -7.62877241e-02f, 3.30877192e-02f,
  -1.39026046e-01f, -5.63927628e-02f, -6.57299459e-02f, -3.10836267e-02f, -2.61963159e-02f, 3.73345502e-02f, -1.48890659e-01f, -5.18776588e-02f, -7.32812956e-02f, -5.72769605e-02f,
  -6.32920340e-02f, 2.68713273e-02f, 2.17483547e-02f, -4.37132269e-02f, -1.25425696e-01f, -4.94175404e-02f, -7.52430931e-02f, -1.46017522e-01f, -2.01471984e-01f, -4.16114740e-02f,
  -1.66796949e-02f, 1.11739650e-01f, 1.13030588e-02f, 1.05414251e-02f, -5.20671494e-02f, 1.97953526e-02f, 4.91201133e-02f, 5.25116064e-02f, 4.85201590e-02f, 8.34176987e-02f,
  -1.57978833e-02f, 2.30637547e-02f, 5.36446534e-02f, 1.49573607e-03f, -1.08036816e-01f, -4.04956937e-02f, 8.50026384e-02f, 3.93000506e-02f, -1.01132877e-01f, -4.91361879e-02f,
  -7.30441362e-02f, 3.78865190e-02f, 3.32898297e-03f, 2.96763871e-02f, -1.24048948e-01f, -2.43585818e-02f, 1.02515863e-02f, 1.57829989e-02f, 8.10166672e-02f, -9.47699100e-02f,
  1.44181237e-01f, -1.05840296e-01f, 1.80686295e-01f, 1.22840488e-02f, 2.22405605e-02f, -4.12873104e-02f, -4.18617167e-02f, 9.32289928e-04f, -3.00172456e-02f, 5.06962873e-02f,
  -2.44982466e-02f, 9.58683118e-02f, 2.30529252e-02f, 5.44110462e-02f, 1.04081526e-01f, 1.05678804e-01f, -1.31223276e-01f, 9.35786888e-02f, -1.15973227e-01f, -2.47411244e-02f,
  -4.24563736e-02f, 1.92592815e-01f, 2.83424795e-01f, 2.26600483e-01f, 3.54565531e-02f, 1.79324657e-01f, 3.10516387e-01f, 1.94560081e-01f, 1.82927653e-01f, 3.75763088e-01f,
  2.31073558e-01f, -4.45254743e-01f, 1.29503548e-01f, 2.56507754e-01f, 2.53268868e-01f, 3.31242114e-01f, 3.09821337e-01f, 1.75329491e-01f, 6.72066361e-02f, 5.27668223e-02f,
  -1.31202593e-01f, 1.02505259e-01f, 2.60721482e-02f, 3.32168639e-02f, 7.22236633e-02f, 8.99393111e-02f, 1.39032766e-01f, 1.14871532e-01f, 2.58528739e-01f, 1.63277999e-01f,
  2.27427259e-02f, -1.34972915e-01f, -1.47899389e-01f, -8.05028826e-02f, -1.35346323e-01f, 1.10148393e-01f, -6.97181821e-02f, -1.16160542e-01f, -1.34322643e-01f, 9.14816856e-02f,
  -1.90358371e-01f, -6.03918396e-02f, 3.04205239e-01f, 7.20215077e-03f, -1.61956266e-01f, 4.21224870e-02f, 5.43953143e-02f, -1.34400696e-01f, -7.70359337e-02f, 6.83356076e-02f,
  -8.71625245e-02f, -8.94931182e-02f, 6.66947588e-02f, -5.01858592e-02f, -1.15553461e-01f, 6.58455938e-02f, -8.83881152e-02f, 4.59031910e-02f, 4.09229435e-02f, -9.58703365e-03f,
  -4.63135280e-02f, -1.20900072e-01f, -1.44706070e-01f, 3.75602208e-02f, 4.06584032e-02f, -2.49228068e-03f, -1.72939315e-01f, -6.70966506e-02f, 3.01823691e-02f, 3.58021110e-02f,
  4.31287400e-02f, 4.10577096e-02f, 9.91266407e-03f, -9.06067528e-03f, 4.22691740e-02f, -1.95050221e-02f, 7.30567053e-02f, -2.37822216e-02f, 3.76589708e-02f, -2.59893816e-02f,
  3.06651499e-02f, 5.39800972e-02f, -1.31268809e-02f, 9.79540274e-02f, 1.92207042e-02f, -1.31011405e-03f, -1.13795989e-03f, 5.14829485e-03f, 1.07225683e-02f, 2.09484417e-02f,
  -2.41506174e-02f, 7.55401794e-04f, -4.49435711e-02f, -9.00197923e-02f, 1.02060325e-02f, 5.40520772e-02f, 1.48957688e-02f, 2.21563056e-02f, -4.76221927e-02f, -5.21643870e-02f,
  -2.28580087e-02f, 7.13004023e-02f, 1.60681114e-01f, -4.30706292e-02f, -4.92138565e-02f, -1.25066996e-01f, -3.76098529e-02f, 1.48907453e-02f, -1.24200150e-01f, -3.79576385e-02f,
  -1.66234940e-01f, 2.21312102e-02f, -9.90510434e-02f, -8.86075348e-02f, 3.38319838e-02f, -4.62470651e-02f, -3.70970853e-02f, 3.56887244e-02f, 7.06645325e-02f, -1.04030140e-01f,
  2.13211235e-02f, 1.68416366e-01f, 2.18506753e-01f, 1.77910984e-01f, -4.61496115e-02f, 5.56002893e-02f, 9.93449092e-02f, -5.60106302e-04f, 1.14159159e-01f, 1.67561948e-01f,
  -6.05411291e-01f, -8.57584253e-02f, -1.21427633e-01f, -1.12233564e-01f, 1.67214066e-01f, 1.07550785e-01f, 1.67065606e-01f, 1.61638334e-01f, -1.14900479e-02f, -1.17868908e-01f,
  -6.61602616e-02f, -1.66696072e-01f, -1.25177428e-01f, -1.49462715e-01f, -4.64811400e-02f, -1.82995036e-01f, -8.46022069e-02f, -2.81301558e-01f, 1.16727501e-02f, 1.89748302e-01f,
  1.43540934e-01f, -9.86740217e-02f, -2.38288879e-01f, 5.80205582e-02f, 3.07105575e-02f, -6.25023022e-02f, -1.12271331e-01f, -1.49971535e-02f, 1.89852547e-02f, -2.18740493e-01f,
  -2.05142260e-01f, 2.92062759e-02f, -4.13428806e-02f, -1.38166994e-01f, -9.49094743e-02f, -1.18770711e-01f, 1.54821454e-02f, -5.29961810e-02f, -8.78175534e-03f, 1.17828499e-03f,
  -7.32606202e-02f, 7.55964685e-03f, -3.95110883e-02f, -1.10929124e-02f, 4.70829103e-03f, 2.51488443e-02f, -9.80424732e-02f, -1.53493211e-01f, -1.22478776e-01f, 6.90265819e-02f,
  2.72984225e-02f, 7.12939128e-02f, -8.96428153e-02f, 1.23637468e-01f, 3.46838497e-02f, -1.87731266e-01f, -2.30830833e-02f, -3.26749086e-02f, -5.53352125e-02f, -2.37325341e-01f,
  -7.73718301e-03f, -5.30857630e-02f, -4.80902232e-02f, 1.00747637e-01f, -4.06828374e-02f, -3.47781256e-02f, 8.50499608e-04f, 1.55122634e-02f, 7.68584386e-02f, -5.09367846e-02f,
  4.29952368e-02f, 1.47209186e-02f, -2.61869002e-02f, 5.05127236e-02f, -3.56289558e-02f, 1.32543342e-02f, 1.41401626e-02f, -4.48193401e-02f, -1.97410025e-02f, -1.09299324e-01f,
  -6.26060441e-02f, 1.97404511e-02f, -1.47956554e-02f, -1.28947059e-02f, -8.89043808e-02f, -4.91575859e-02f, 5.75941568e-03f, 6.77017123e-02f, -2.10576691e-03f, 6.86136559e-02f,
  -1.86337337e-01f, -1.06994934e-01f, -1.39286757e-01f, -5.45448624e-03f, -4.70325351e-02f, -6.27954602e-02f, -3.39350440e-02f, -8.44430029e-02f, -2.64036842e-02f, 5.29218349e-04f,
  3.50032710e-02f, -2.05861367e-02f, -5.07694185e-02f, 3.19767632e-02f, 2.07658540e-02f, 6.04657345e-02f, -1.07024327e-01f, -6.46604821e-02f, 2.99879275e-02f, -8.29706863e-02f,
  -1.49828464e-01f, -6.25857189e-02f, -1.48851886e-01f, -7.37047270e-02f, -1.03154946e-02f, -9.48654041e-02f, -1.11202657e-01f, -4.08880040e-02f, -1.22321121e-01f, -3.25584292e-01f,
  4.00329471e-01f, -6.35820106e-02f, 2.21462905e-01f, 8.51216018e-02f, -2.32633669e-02f, 1.29838049e-01f, -5.36236279e-02f, 1.17269047e-01f, 5.87199181e-02f, 2.13007996e-04f,
  -5.62597848e-02f, -2.49032434e-02f, -5.81250861e-02f, 4.04849686e-02f, 6.93884641e-02f, 2.59414054e-02f, -6.29627183e-02f, 1.63814247e-01f, 2.80782700e-01f, 1.81680217e-01f,
  1.45062795e-02f, 5.56117333e-02f, 1.44650057e-01f, 9.85096842e-02f, 5.03424034e-02f, 1.18231647e-01f, -6.51243106e-02f, 2.71560457e-02f, -5.10481261e-02f, 4.85805348e-02f,
  1.47599429e-01f, 1.52207136e-01f, -6.51941914e-03f, -5.69710433e-02f, -2.93448437e-02f, -7.16796443e-02f, 8.83433893e-02f, 9.25207734e-02f, 1.34023149e-02f, -6.42915741e-02f,
  3.69060673e-02f, -1.99990422e-02f, -9.34655815e-02f, 4.19142731e-02f, -5.74598983e-02f, -1.18889362e-02f, -4.80572730e-02f, 1.76831018e-02f, -1.67182274e-02f, -5.77316098e-02f,
  -2.04419449e-01f, -7.75044039e-02f, 9.16543826e-02f, 1.24581847e-02f, 4.81608883e-03f, -2.77666189e-02f, 6.02010451e-02f, -1.81453594e-03f, 4.12892587e-02f, -1.76895075e-02f,
  -3.61833163e-02f, -3.05218566e-02f, 2.87206266e-02f, 2.12660376e-02f, 3.82534191e-02f, 6.41401559e-02f, -3.07766199e-02f, 3.36483084e-02f, -9.29382369e-02f, -7.27931559e-02f,
  -2.34189779e-02f, 3.85333486e-02f, -5.19874319e-02f, 1.05855346e-01f, 2.35183425e-02f, -2.72020996e-02f, 2.81558884e-03f, 5.43941781e-02f, -7.31596798e-02f, -6.85230419e-02f,
  8.84388387e-02f, -3.78723294e-02f, -4.89880405e-02f, 4.38298658e-02f, 3.23126912e-02f, 3.53617035e-02f, 3.91832367e-02f, 5.45676835e-02f, -8.61310363e-02f, -5.52290231e-02f,
  -1.51148945e-01f, -1.86112970e-02f, -1.06719822e-01f, -2.23730803e-02f, 6.69714510e-02f, 3.44493352e-02f, 2.74206931e-03f, -2.04576142e-02f, 1.12604603e-01f, 1.17898704e-02f,
  5.84420413e-02f, 4.28905897e-02f, -5.00263125e-02f, 7.30122104e-02f, 2.16989405e-02f, 1.34330988e-01f, -1.91928204e-02f, 1.03657238e-01f, 1.69239379e-02f, 6.93036020e-02f,
  1.53693669e-02f, 7.16631413e-02f, 1.86847210e-01f, 2.50867400e-02f, 3.62919942e-02f, 1.51900202e-01f, 8.52321163e-02f, 1.67047754e-01f, 1.38132736e-01f, 3.57665308e-02f,
  -1.10667814e-02f, 1.52444672e-02f, -9.04139057e-02f, 1.37352571e-01f, -5.98674119e-02f, -5.35431504e-02f, -1.12142473e-01f, -1.45153135e-01f, 3.20264325e-02f, 8.59071617e-04f,
  -5.03685176e-02f, -4.48606461e-02f, 6.62638545e-02f, -2.12930348e-02f, -1.49425432e-01f, -1.02877878e-01f, -6.54164702e-02f, -1.40362903e-01f, -1.61704093e-01f, -1.91111431e-01f,
  -9.92543772e-02f, 4.36826013e-02f, 4.77591623e-03f, -5.82787059e-02f, 3.72262746e-02f, -1.15296366e-02f, -2.71003731e-02f, -5.99216670e-02f, -8.78891274e-02f, -1.13404006e-01f,
  1.00893071e-02f, -7.01481476e-02f, -3.03857885e-02f, -4.28409204e-02f, 5.53256385e-02f, 3.11292298e-02f, -3.47263142e-02f, -1.91101171e-02f, -4.15580682e-02f, 4.29960005e-02f,
  1.59642193e-02f, -1.48409098e-01f, -5.55915609e-02f, -1.00939736e-01f, -7.44058415e-02f, -1.49105653e-01f, 4.00388129e-02f, 1.62997935e-02f, -3.74034792e-02f, -2.44483929e-02f,
  -1.28994733e-01f, -4.75116000e-02f, -1.44499257e-01f, -1.06126063e-01f, -1.41280636e-01f, 1.65732224e-02f, -1.64067790e-01f, -4.40605730e-02f, -2.18348145e-01f, -4.63921465e-02f,
  -8.42171013e-02f, -1.15245074e-01f, -7.37046376e-02f, 4.16125841e-02f, 2.19309144e-02f, 4.84160781e-02f, 1.73902065e-02f, -4.49615456e-02f, -5.72060868e-02f, 6.08482547e-02f,
  1.24624483e-02f, 2.21329108e-02f, -1.52398776e-02f, 4.09352444e-02f, 6.93926066e-02f, 2.30382122e-02f, 1.63436756e-02f, -8.27165321e-03f, -5.95410131e-02f, 3.13327536e-02f,
  -4.66535753e-03f, 1.61405280e-02f, 3.04719731e-02f, 4.41174246e-02f, -4.62307408e-02f, 5.68847544e-02f, -2.76177786e-02f, -1.24917991e-01f, 1.78116634e-02f, 2.59690103e-03f,
  1.47033423e-01f, 2.32341280e-03f, -6.04584056e-04f, -1.25737116e-01f, -2.02002190e-02f, 9.82684642e-02f, 4.30246443e-03f, -6.06134459e-02f, 8.84748399e-02f, 2.51739584e-02f,
  -2.18966696e-02f, -4.50022556e-02f, -3.45076458e-03f, 3.16824876e-02f, -1.45408899e-01f, -1.40458629e-01f, 3.80187854e-02f, -1.20762967e-01f, -2.23138416e-03f, -6.63482994e-02f,
  8.98247659e-02f, 3.30559053e-02f, -5.59374429e-02f, 8.19025636e-02f, -7.13454336e-02f, -4.19743769e-02f, 1.77092627e-02f, -7.78653473e-02f, -9.62498188e-02f, 1.40322447e-01f,
  2.03354463e-01f, 2.68083513e-01f, -1.39632389e-01f, -1.88366100e-02f, -3.08415890e-01f, -1.33896425e-01f, -6.08150437e-02f, 1.31609976e-01f, 1.15050860e-01f, 8.16892311e-02f,
  -2.64049828e-01f, -1.71321884e-01f, -7.35291094e-02f, -2.73527741e-03f, 8.55944082e-02f, 3.04005951e-01f, 2.37854615e-01f, 4.55389433e-02f, -5.58347516e-02f, -7.64139323e-03f,
  5.44245988e-02f, 1.38548836e-01f, 9.55042541e-02f, 1.61547020e-01f, 2.28880778e-01f, -3.97649445e-02f, 2.48499736e-02f, 3.21984626e-02f, -6.78833053e-02f, 1.85191989e-01f,
  -1.33416250e-01f, -2.77961731e-01f, -8.65404457e-02f, -1.46009266e-01f, -1.77017123e-01f, -2.58019194e-03f, -2.05181148e-02f, -4.04918119e-02f, -4.09144834e-02f, 2.42435075e-02f,
  -1.25835687e-01f, -1.64218172e-02f, 2.58508269e-02f, 4.88418192e-02f, 6.94201291e-02f, 5.00377640e-02f, 4.60305028e-02f, -2.87187453e-02f, -5.52011952e-02f, -1.19961746e-01f,
  -6.65364191e-02f, -1.14775941e-01f, -2.72330642e-01f, -4.66208719e-03f, -1.52380049e-01f, -1.72111154e-01f, -1.59182504e-01f, -7.87877738e-02f, -2.60403723e-01f, 1.58149198e-01f,
  1.71822328e-02f, 3.18219396e-03f, -4.35991697e-02f, -2.31164377e-02f, 3.58517915e-02f, -3.85380089e-02f, -9.58757664e-05f, 2.53524482e-02f, 1.86195355e-02f, 3.42077352e-02f,
  -5.99077344e-02f, 1.94271225e-02f, -7.26714581e-02f, -1.38360132e-02f, 4.73509803e-02f, -4.59492169e-02f, 2.89615635e-02f, 7.42594972e-02f, -6.61873519e-02f, 2.80162301e-02f,
  1.07731409e-02f, -7.98454732e-02f, -4.33191378e-03f, -6.32130355e-02f, 7.22269043e-02f, -2.06746571e-02f, 6.20508119e-02f, -7.54145766e-03f, 1.60992760e-02f, -8.81154910e-02f,
  1.54752731e-01f, -4.09669250e-01f, 8.29609483e-02f, 5.91966696e-02f, 1.01714337e-03f, -9.06786509e-03f, -1.39480056e-02f, -4.07615043e-02f, 6.49182731e-03f, 9.55160111e-02f,
  -1.31686896e-01f, 2.66568176e-02f, -9.51140560e-03f, -2.63570789e-02f, 2.49073841e-03f, 5.17738089e-02f, 1.46931112e-01f, -6.43114746e-02f, 6.21967129e-02f, 3.97151634e-02f,
  1.95492655e-01f, 1.64846763e-01f, 8.10583308e-02f, -3.53436209e-02f, 2.68095061e-02f, -7.86595643e-02f, -8.52764025e-03f, -2.34701973e-03f, -9.84808579e-02f, 3.48596483e-01f,
  5.21255672e-01f, -1.44923419e-01f, -4.37299550e-01f, -1.06658880e-02f, -1.12985142e-01f, -5.08363033e-03f, -1.05654791e-01f, 1.97459653e-01f, 1.67755857e-01f, -8.78101364e-02f,
  -1.39604762e-01f, 1.50258288e-01f, -2.29577888e-02f, 8.78971517e-02f, 8.31230655e-02f, -1.78026706e-01f, -2.28807077e-01f, -7.49564692e-02f, 1.84987351e-01f, 1.55461237e-01f,
  9.10874922e-03f, -1.36420003e-03f, 1.42904699e-01f, 4.93124761e-02f, -1.25687301e-01f, 4.88538072e-02f, -3.32303703e-01f, -1.54574737e-01f, -1.89978391e-01f, -3.37308437e-01f,
  -3.88408601e-01f, 1.33438438e-01f, -3.73205617e-02f, 2.24468783e-02f, -1.35159299e-01f, 4.94739646e-03f, -6.58756196e-02f, -9.20909643e-03f, 4.83020674e-03f, -9.40483510e-02f,
  -6.43215925e-02f, -8.74556787e-03f, 5.64672460e-04f, -2.94281300e-02f, 9.79174208e-03f, 5.97953200e-02f, -6.33824617e-02f, 2.25077476e-02f, 6.66997768e-03f, -7.34167621e-02f,
  -2.04511359e-01f, -5.13439290e-02f, 2.74578258e-02f, -2.17506997e-02f, -9.19586346e-02f, 2.09557004e-02f, -6.76108599e-02f, -1.26996890e-01f, -2.98158992e-02f, -1.79286420e-01f,
  -1.37076393e-01f, -5.55272140e-02f, -2.99080908e-02f, 3.24010625e-02f, 6.31407797e-02f, -6.82936329e-03f, -7.65420124e-03f, -1.17856249e-01f, 8.02120268e-02f, -7.57345278e-03f,
  -9.55955498e-03f, -2.78449208e-02f, 6.95523759e-03f, -4.20187600e-03f, -1.34497181e-01f, -3.09884176e-02f, 1.73672158e-02f, -4.59277369e-02f, -3.33560146e-02f, 2.91834995e-02f,
  8.68517458e-02f, 2.08358224e-02f, 2.51072310e-02f, 4.47345264e-02f, -2.10222863e-02f, -4.16108482e-02f, -8.96272436e-03f, 2.98332050e-02f, 2.57608155e-03f, 1.11854672e-01f,
  1.02166034e-01f, 3.87895927e-02f, -1.80829302e-05f, 1.00379884e-01f, 5.75780449e-03f, -2.80548986e-02f, -6.53983355e-02f, -1.87358540e-02f, 2.35975459e-02f, -1.37671633e-02f,
  4.36563678e-02f, 6.05385676e-02f, -6.35578707e-02f, -4.02950831e-02f, 4.96523678e-02f, 1.46349380e-02f, -9.88962967e-03f, 8.16241130e-02f, 5.29005118e-02f, -4.51052636e-02f,
  -5.28452806e-02f, 1.26454860e-01f, 1.61565617e-01f, 6.84936941e-02f, 9.04103145e-02f, 1.90679267e-01f, 8.43255688e-03f, 6.42139241e-02f, 1.54123485e-01f, 8.40768144e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.94322848e-01f, -1.00231528e-01f, 6.24287367e-01f, -8.21687579e-02f, 1.99192122e-01f, 3.14002395e-01f, -1.30857844e-02f, 1.08127929e-01f, 6.48968756e-01f, 1.41954899e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.03863925e-01f, -5.07476091e-01f, -2.47380421e-01f, -3.76698256e-01f, 4.72915918e-01f, -1.57564312e-01f, -4.88883406e-01f, -7.26117417e-02f, 7.48961940e-02f, -3.34312111e-01f,
  2.62662470e-02f, 6.09146692e-02f, 8.65456760e-02f, 2.94007454e-02f, -4.18953806e-01f, 4.54014391e-01f, -5.94937168e-02f, -3.36555481e-01f, -3.51494610e-01f, -5.67340143e-02f,
  4.01885986e-01f, 7.91211128e-02f, 6.22511864e-01f, 3.11348438e-01f, 6.66193664e-02f, -4.25705969e-01f, 1.05085403e-01f, 5.89963794e-01f, -1.88111961e-01f, -3.06273818e-01f,
  -3.74359578e-01f, -1.58807963e-01f, -1.54203311e-01f, -5.96856363e-02f, -2.29171917e-01f, -5.70237637e-01f, 4.63553548e-01f, -6.25423431e-01f, 1.19729549e-01f, -2.27059647e-01f,
  3.51969242e-01f, -1.47332028e-01f, -2.84519404e-01f, 9.49880034e-02f, -4.86503839e-01f, -2.60210872e-01f, 1.08686447e-01f, 3.64711136e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  9.65434164e-02f, -2.52535969e-01f, 1.22803926e-01f, 6.09615482e-02f, -3.67657691e-01f, 9.96658057e-02f, -7.96561390e-02f, -1.98007762e-01f, -1.46690324e-01f, -1.74577802e-01f,
  -1.80604577e-01f, -2.17752278e-01f, -8.07473287e-02f, -2.34388337e-01f, 2.14386865e-01f, 2.72770636e-02f, 3.45631808e-01f, 8.77963006e-01f, 1.26406476e-01f, -2.85185963e-01f,
  4.75982964e-01f, -6.73474431e-01f, 5.45886979e-02f, -3.81032139e-01f, 6.99292064e-01f, 4.88834649e-01f, -3.17087710e-01f, 8.41553435e-02f, -2.89218754e-01f, 4.98589873e-01f,
  5.13091505e-01f, -5.50701201e-01f, 4.65753436e-01f, 2.00246081e-01f, 1.63931906e-01f, 4.89512533e-02f, 4.36259598e-01f, 1.01114318e-01f, -3.37138951e-01f, 5.79043739e-02f,
  7.41753459e-01f, 5.72897255e-01f, 6.79995239e-01f, 1.40709072e-01f, -2.72513807e-01f, 1.95194706e-01f, 3.30282539e-01f, 5.37396550e-01f, 5.14338493e-01f, 9.10478085e-02f,
  -4.08880949e-01f, 4.06123698e-01f, -4.48304474e-01f, 2.42927760e-01f, 9.54450309e-01f, 6.37486339e-01f, 3.60281140e-01f, -4.81673867e-01f, -3.66390854e-01f, 7.65646577e-01f,
  -2.41221249e-01f, -1.96107537e-01f, 2.48594478e-01f, -3.97837549e-01f, -4.49069701e-02f, -1.48969069e-01f, 4.05033445e-03f, -2.24215791e-01f, 4.59290475e-01f, 2.57699694e-02f,
  2.01019436e-01f, 3.82154703e-01f, 8.97115052e-01f, -3.54095399e-01f, 2.24776909e-01f, 5.61492562e-01f, -2.04003677e-01f, -5.45465834e-02f, 4.63685207e-02f, 3.75882953e-01f,
  5.02281010e-01f, -7.07742050e-02f, 2.64914185e-01f, -1.74248785e-01f, 3.21473092e-01f, 2.07916468e-01f, -5.40838689e-02f, 4.40435886e-01f, 5.38067043e-01f, 1.99525461e-01f,
  6.55390561e-01f, 1.90119043e-01f, 1.48574054e-01f, -1.39332106e-02f, 1.55722216e-01f, 2.74618566e-01f, 2.19417483e-01f, -1.04927756e-01f, -1.49173021e-01f, -3.89480591e-01f,
  -7.68363848e-02f, 1.64203763e-01f, -8.04794207e-02f, 4.40239012e-02f, 4.26033050e-01f, -3.07278723e-01f, 1.03929363e-01f, 2.75755823e-01f, -1.99665390e-02f, 2.30650336e-01f,
  2.89180011e-01f, 1.74300224e-01f, 3.65073353e-01f, 3.10623720e-02f, 3.54729444e-01f, -9.60374549e-02f, -7.26958573e-01f, 8.06416392e-01f, -8.10621455e-02f, 1.61244020e-01f,
  2.08942056e-01f, 1.48940142e-02f, 3.95172760e-02f, -1.95387959e-01f, -2.45189160e-01f, 5.47118001e-02f, 9.01043773e-01f, 1.31787822e-01f, 1.65485024e-01f, -1.05783075e-01f,
  -1.45380184e-01f, 2.21015871e-01f, -2.80941904e-01f, 1.40048917e-02f, 4.07271534e-01f, -1.85753226e-01f, 4.23532128e-02f, -4.00111601e-02f, -1.88580617e-01f, -3.49798575e-02f,
  4.19872522e-01f, 1.33827999e-01f, -8.99590254e-02f, 1.32607529e-02f, 5.00345409e-01f, 4.56388563e-01f, 1.64933279e-01f, 2.28619918e-01f, -1.78709313e-01f, 3.47733319e-01f,
  -5.73383942e-02f, -2.04028174e-01f, 9.27576646e-02f, 6.42276585e-01f, 2.99358308e-01f, -1.40387565e-01f, -7.03179231e-03f, -2.43256822e-01f, 2.01894119e-01f, -1.87425032e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -1.37123272e-01f, 7.96097875e-01f, 2.47949198e-01f, 4.31431621e-01f, 2.15062454e-01f, 1.80469632e-01f, -1.29515395e-01f, 3.32671963e-02f, 6.66056722e-02f, 1.51073277e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.68368065e-01f, -3.97742450e-01f, -1.91316113e-01f, -3.76982152e-01f, -2.77500097e-02f, -5.58930039e-01f, 2.09725499e-01f, -5.11867225e-01f, -2.42297724e-01f, 3.03923130e-01f,
  -2.58281343e-02f, 1.27608567e-01f, -1.31898537e-01f, 3.63458186e-01f, 1.28489211e-01f, 1.78318709e-01f, 2.14042872e-01f, -3.16121519e-01f, 1.94680274e-01f, 7.89524289e-04f,
  1.42362162e-01f, 9.14213881e-02f, -5.38780820e-03f, -5.71987741e-02f, -3.38368297e-01f, 5.47449589e-01f, 1.84726149e-01f, -4.24687386e-01f, 2.96382368e-01f, 4.77776200e-01f,
  -2.87408739e-01f, -3.38070691e-01f, -1.39270678e-01f, -2.81300157e-01f, 1.15121426e-02f, 6.25313818e-02f, 5.91152132e-01f, 1.11825861e-01f, -7.70482123e-02f, -4.20594625e-02f,
  -3.48044574e-01f, 3.75045985e-01f, 2.17440560e-01f, -1.82454154e-01f, 2.26953462e-01f, 1.73317105e-01f, 2.22497359e-01f, -3.13325316e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.38710898e-01f, -5.84886745e-02f, -2.02130303e-01f, -6.71041787e-01f, 2.43432030e-01f, -8.34169745e-01f, 1.44432425e-01f, -5.02469599e-01f, -9.14445221e-02f, 9.93026733e-01f,
  -1.93186209e-01f, 2.98840851e-01f, -1.78562850e-01f, 6.23789251e-01f, 1.24204904e-01f, 5.07743835e-01f, -1.71532318e-01f, -4.65295792e-01f, -3.48578006e-01f, -1.41427862e-02f,
  -8.61588717e-02f, 2.26801097e-01f, -2.26935912e-02f, 3.25500399e-01f, -1.72462000e-03f, 2.01327965e-01f, 2.37887621e-01f, -9.65462476e-02f, -6.29549995e-02f, -3.09560061e-01f,
  2.28589997e-01f, 2.67327011e-01f, 4.69299376e-01f, 6.20168865e-01f, 3.94456476e-01f, -2.60515302e-01f, 3.52924556e-01f, -4.50232446e-01f, -6.88206777e-02f, 2.10183606e-01f,
  -1.81818128e-01f, 9.96136963e-01f, -1.57429017e-02f, -1.48603335e-01f, -1.34309724e-01f, -3.15891445e-01f, -9.82755609e-03f, 1.55048728e-01f, 1.73652664e-01f, -4.74806828e-03f,
  9.96736214e-02f, 1.16780706e-01f, -2.95421809e-01f, -2.82421291e-01f, 1.90228298e-01f, -1.82162896e-02f, -1.87103942e-01f, 1.47027493e-01f, -1.36338666e-01f, -1.45565495e-01f,
  -4.10426892e-02f, 2.68830389e-01f, 5.30754849e-02f, 1.18236303e-01f, -3.89281005e-01f, -1.33046910e-01f, -3.39359492e-01f, 2.54718084e-02f, -5.63624382e-01f, -7.94616461e-01f,
  8.28387663e-02f, -1.82520732e-01f, 1.07580686e+00f, -1.70384988e-01f, 6.68355882e-01f, 6.13108933e-01f, 3.15525681e-01f, 7.59190798e-01f, -4.36826199e-01f, 3.19689929e-01f,
  -1.24623850e-01f, 1.08925365e-01f, -3.67258012e-01f, 3.64475876e-01f, -7.34123513e-02f, -2.26655886e-01f, 1.63822651e-01f, 1.75883114e-01f, 4.70528722e-01f, -4.94926900e-01f,
  7.43448734e-02f, 2.70756632e-01f, -1.02045104e-01f, -3.74995291e-01f, -3.76064450e-01f, 1.82696387e-01f, 3.97244483e-01f, -9.34150144e-02f, 4.67859447e-01f, -3.62725347e-01f,
  2.33034487e-03f, 2.02022150e-01f, 2.53722966e-01f, 6.45273089e-01f, -1.57804996e-01f, 3.81799400e-01f, 1.27356783e-01f, -1.49181128e-01f, 1.43179558e-02f, 4.95701373e-01f,
  8.82858709e-02f, 1.20647952e-01f, 8.87583077e-01f, 6.02497160e-01f, 7.40522265e-01f, -5.52405119e-01f, -1.01494837e+00f, 1.38754532e-01f, -3.05322498e-01f, 1.41795862e+00f,
  3.78867358e-01f, -5.55232584e-01f, -6.70705020e-01f, -6.08385541e-03f, -1.85891926e-01f, 3.28524001e-02f, 1.09435789e-01f, 5.54184079e-01f, 1.71727449e-01f, 4.49092865e-01f,
  3.76635641e-01f, 7.46354401e-01f, 5.93433082e-01f, 9.44331586e-01f, 1.00023836e-01f, 7.73647964e-01f, 6.24597073e-01f, 1.19456582e-01f, 9.21129405e-01f, 7.46154845e-01f,
  3.61803353e-01f, -4.05388355e-01f, -2.06599578e-01f, -3.76311421e-01f, 2.50825994e-02f, -2.08619460e-02f, 1.52990326e-01f, -7.96040148e-02f, -2.83638239e-01f, -3.45102012e-01f,
  3.03881705e-01f, -2.91631877e-01f, -2.03160290e-02f, 1.37173003e-02f, -2.13299602e-01f, -1.93246454e-01f, 9.20268372e-02f, 3.79182905e-01f, 2.20994741e-01f, 1.91607565e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  6.67972744e-01f, -1.88927114e-01f, 3.65557045e-01f, -1.00649580e-01f, 1.33286297e-01f, 1.32111549e-01f, -1.98475510e-01f, 6.07135534e-01f, 4.66220915e-01f, -6.47168010e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.05366558e-01f, 1.45716339e-01f, 5.80519363e-02f, -1.89540967e-01f, -2.01006249e-01f, 4.15965438e-01f, -7.75850058e-01f, 3.18511039e-01f, -3.86740208e-01f, 1.97823346e-01f,
  3.23153645e-01f, 2.75156677e-01f, -2.99904853e-01f, -1.32563090e+00f, 6.18938088e-01f, -1.54166743e-01f, -1.30026713e-01f, -7.13848233e-01f, -3.03566873e-01f, 1.44676283e-01f,
  -8.39615524e-01f, -1.21580660e+00f, 1.10867610e-02f, -7.53180310e-02f, -3.19388986e-01f, 1.34201542e-01f, 3.42284232e-01f, 7.24352539e-01f, -8.80083740e-01f, -5.47039092e-01f,
  4.58292305e-01f, 1.35030985e-01f, -6.81143582e-01f, 2.66667813e-01f, 6.18309140e-01f, -6.79180264e-01f, 3.80990736e-04f, -4.28460836e-01f, -6.87858701e-01f, 1.29838660e-01f,
  -4.07642387e-02f, 2.50090323e-02f, -1.26132512e+00f, 6.69643208e-02f, 2.56303605e-03f, 1.08671820e+00f, 2.57553488e-01f, -2.52902657e-01f, 3.57192993e-01f, -3.74365836e-01f,
  -5.73696136e-01f, -7.07096577e-01f, 5.11763096e-01f, 7.11275697e-01f, -5.38893528e-02f, 4.99449641e-01f, 1.50257662e-01f, -1.36852771e-01f, -5.26929617e-01f, -3.91161263e-01f,
  4.42410856e-01f, -4.29865062e-01f, 5.34000933e-01f, -3.10092062e-01f, -9.89693031e-02f, 5.07042170e-01f, 4.31022137e-01f, 1.31271631e-01f, 4.62363958e-01f, 5.60273707e-01f,
  -6.14617229e-01f, -4.44640875e-01f, 1.82956427e-01f, -1.58945218e-01f, -5.52044094e-01f, -1.24481812e-01f, 1.15346156e-01f, -1.90964103e-01f, 9.43784773e-01f, -1.86895698e-01f,
  -8.35064948e-02f, 5.19087493e-01f, 1.31276175e-02f, -2.92720973e-01f, -8.07123184e-01f, -5.73586702e-01f, -4.03534770e-01f, -1.47592217e-01f, -4.70585167e-01f, -1.61844984e-01f,
  5.22070348e-01f, -2.51831681e-01f, 3.16659451e-01f, 1.91132054e-01f, 8.66827816e-02f, -2.52524942e-01f, 5.23209870e-02f, 2.94359475e-01f, 6.74782038e-01f, 3.85027051e-01f,
  4.64609146e-01f, -4.73659575e-01f, 7.50910640e-01f, -3.07043456e-02f, -3.12575281e-01f, 4.08527672e-01f, 3.32165182e-01f, -4.11759093e-02f, 1.00841053e-01f, 2.07992923e-02f,
  -1.13902950e+00f, 5.76841295e-01f, -4.02510911e-01f, -5.13485253e-01f, -5.41601181e-01f, 6.66230798e-01f, 4.22817588e-01f, 7.13962197e-01f, 3.35874617e-01f, -1.51533484e-01f,
  1.83186233e-01f, -4.63830940e-02f, 5.85376024e-01f, -1.43557712e-01f, -2.75899041e-02f, -6.69351161e-01f, -7.25826423e-04f, -2.73394585e-01f, 1.83006942e-01f, -4.45526004e-01f,
  -7.91117311e-01f, 2.72340894e-01f, -9.55321193e-02f, -2.81985670e-01f, 8.17262530e-02f, -5.47129847e-02f, -5.53080499e-01f, -1.64978772e-01f, 8.53759944e-01f, 4.25321043e-01f,
  -2.07115978e-01f, 4.12690848e-01f, -9.19966877e-01f, 1.75288230e-01f, 1.07535112e+00f, 5.58288395e-01f, 1.92554876e-01f, -3.31521556e-02f, -6.55465247e-03f, -4.47188288e-01f,
  -7.09459856e-02f, -2.42135882e-01f, 6.48009479e-01f, 9.53640863e-02f, -1.39425531e-01f, -1.83918908e-01f, 3.20442736e-01f, 1.10211194e+00f, -8.61686647e-01f, -1.09004132e-01f,
  -1.63710579e-01f, -8.70471597e-01f, -7.12063074e-01f, 1.41031623e-01f, -1.05414152e-01f, 6.91568945e-03f, -6.72772110e-01f, 2.88304955e-01f, -1.46106452e-01f, 2.61046439e-01f,
  -3.53749245e-01f, 4.26317900e-01f, 1.65964082e-01f, 9.46461737e-01f, 3.38652241e-03f, 1.07318059e-01f, 2.81429261e-01f, 1.16913281e-01f, 2.90993363e-01f, 9.20258939e-01f,
  5.27560413e-01f, 5.73083520e-01f, 9.24063265e-01f, -3.02898496e-01f, 9.74672854e-01f, 1.46883745e-02f, -4.83753771e-01f, 4.27665785e-02f, -3.54395777e-01f, -5.83336890e-01f,
  -8.35873783e-01f, -6.42813519e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.24453656e-01f, -5.83615638e-02f, 9.17849094e-02f, 1.25178948e-01f, -2.76879340e-01f, 1.45541073e-03f, 3.25195044e-01f, -5.21412864e-02f, -1.37797087e-01f, 3.16261768e-01f,
  -7.20667183e-01f, 3.85404974e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    