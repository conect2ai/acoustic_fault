/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.67308402e-01f, 4.25168991e-01f, 7.16961995e-02f, -2.70997677e-02f, 3.78040314e-01f, 8.23598877e-02f, 5.05919695e-01f, -1.47694200e-01f, -2.76713073e-01f, 2.01222926e-01f,
  2.13239297e-01f, -1.16696663e-01f, 8.04723874e-02f, -1.70483977e-01f, -2.64406383e-01f, 1.80302665e-01f, 1.21679083e-01f, -3.10731113e-01f, -3.44282776e-01f, -1.79489087e-02f,
  1.28740475e-01f, -1.41887041e-02f, -4.33974624e-01f, -1.17443956e-01f, 2.72081316e-01f, 1.11218676e-01f, 2.88113028e-01f, 3.43550108e-02f, 1.72532722e-02f, 1.92979306e-01f,
  -1.54271480e-02f, 1.41518667e-01f, -7.33894408e-02f, -5.46511970e-02f, 7.28028640e-02f, -1.45742029e-01f, -3.46945203e-03f, -1.23413496e-01f, -2.01658625e-02f, 5.16145602e-02f,
  1.04453759e-02f, -1.18536450e-01f, -2.29397137e-02f, 2.29879320e-02f, -5.69100715e-02f, -1.03759147e-01f, -7.91923255e-02f, -1.78344235e-01f, -6.51529878e-02f, 1.59461826e-01f,
  1.40302628e-01f, 7.33912364e-02f, 5.93270957e-02f, 6.53146952e-02f, -6.38301745e-02f, -1.50987789e-01f, -6.30342662e-02f, -1.09361708e-01f, -1.43146828e-01f, -1.53964177e-01f,
  -5.51766381e-02f, 8.09109882e-02f, 5.66308796e-02f, 3.75513062e-02f, 8.74969736e-02f, 1.91100426e-02f, 5.16477749e-02f, 5.61729893e-02f, -1.48152476e-02f, -6.44044857e-03f,
  4.69801836e-02f, 7.37389550e-02f, 7.34177753e-02f, 4.97483872e-02f, 1.04877084e-01f, 2.26238500e-02f, 5.70045635e-02f, 3.83866616e-02f, 2.76800897e-02f, 7.52325431e-02f,
  -4.15596217e-02f, -3.31508033e-02f, 1.01538086e-02f, 6.93471432e-02f, -5.28127924e-02f, -3.80473863e-03f, 2.42874548e-02f, 6.22033291e-02f, -1.32633355e-02f, -2.78683696e-02f,
  -1.68514885e-02f, -5.14511764e-02f, 3.94461714e-02f, -8.85041244e-03f, -3.36070247e-02f, -4.37613614e-02f, 8.18776637e-02f, -2.15952788e-02f, 4.59885895e-02f, 2.78541502e-02f,
  3.17371115e-02f, -1.45502731e-01f, 2.95646284e-02f, -1.63602568e-02f, -4.54108305e-02f, 6.22307695e-03f, 1.20069599e-02f, 3.35061066e-02f, 3.37504297e-02f, -5.78675559e-03f,
  -9.52939391e-02f, -1.20724961e-01f, -6.65341690e-02f, -5.08590080e-02f, -3.00434008e-02f, -6.33463115e-02f, 9.24832821e-02f, -7.32761770e-02f, -9.03802738e-02f, -2.27852482e-02f,
  8.60044658e-01f, -2.61472881e-01f, -4.94814694e-01f, 4.84972984e-01f, -9.65690464e-02f, -5.01843132e-02f, -1.58391610e-01f, 1.09386899e-01f, 2.42777810e-01f, -1.57789558e-01f,
  -8.95378515e-02f, 4.28557992e-02f, -6.87793866e-02f, -1.25022858e-01f, 2.04040799e-02f, -2.15948403e-01f, -3.10281634e-01f, -3.81740667e-02f, 1.60881102e-01f, 1.65508971e-01f,
  9.78951156e-02f, 7.25165308e-02f, 2.01402128e-01f, 5.67694604e-02f, -4.94955247e-03f, 1.04484901e-01f, -3.28051358e-01f, -1.81931511e-01f, -2.06262752e-01f, -1.56124964e-01f,
  -1.85372278e-01f, -9.23305303e-02f, -5.41721620e-02f, 5.27446382e-02f, -1.88818395e-01f, 8.15996230e-02f, 9.52850506e-02f, -3.37176211e-02f, 2.16543451e-02f, -9.43286717e-03f,
  -5.71636595e-02f, 2.38428153e-02f, 1.64887507e-03f, -9.89530310e-02f, 7.36317337e-02f, 4.66254726e-02f, -8.89358073e-02f, -4.18053987e-03f, -6.75008306e-03f, -2.99519487e-02f,
  1.93529557e-02f, -2.84221340e-02f, -1.76041350e-01f, -2.33277027e-02f, 1.74039733e-02f, -7.03400970e-02f, -1.04104944e-01f, -7.53268898e-02f, -4.89646308e-02f, 1.12222090e-01f,
  5.37579916e-02f, -4.60680909e-02f, -4.26543914e-02f, 1.07433898e-02f, 9.17546377e-02f, -3.23788151e-02f, 1.17379203e-02f, 2.07989309e-02f, 5.65442815e-02f, -1.63327958e-02f,
  -1.42341470e-02f, 1.29981786e-02f, -5.16828224e-02f, 1.99853741e-02f, -1.27298608e-02f, -9.16375741e-02f, 6.52598888e-02f, -4.68135840e-04f, -5.50492555e-02f, 1.92030855e-02f,
  5.98831363e-02f, -2.08311304e-02f, -1.29049132e-02f, 3.44236344e-02f, -7.90932775e-02f, -1.94190964e-02f, -5.93250804e-03f, 2.10092906e-02f, 1.87632833e-02f, 4.87058610e-03f,
  1.97455257e-01f, -1.64998993e-01f, 1.32701039e-01f, 1.78272761e-02f, 6.98803784e-03f, -4.45894152e-02f, -1.16610462e-02f, -2.72806957e-02f, -7.93438330e-02f, 5.58692180e-02f,
  2.49498188e-02f, 2.67032683e-02f, 8.98322649e-03f, -3.47939581e-02f, 6.38156086e-02f, 4.64473628e-02f, 5.82922772e-02f, -2.44053639e-02f, -1.81673262e-02f, -2.90317498e-02f,
  4.58425395e-02f, 6.92709386e-02f, 1.89272255e-01f, 6.70666993e-02f, 5.27857840e-02f, 8.32120925e-02f, -8.27739537e-02f, 6.62787035e-02f, 5.18142357e-02f, 2.41517290e-01f,
  4.51617986e-01f, 1.14813551e-01f, 2.63241321e-01f, 2.01100782e-01f, -6.52375817e-02f, -2.48983055e-01f, -2.11519226e-01f, -1.25510395e-01f, 1.07623167e-01f, 9.75515321e-02f,
  2.57982731e-01f, -3.63901025e-03f, -2.45064404e-02f, -7.40889162e-02f, -1.21866427e-01f, -9.38745812e-02f, -3.02334763e-02f, 5.21653183e-02f, -2.00735494e-01f, -2.60607481e-01f,
  -1.90903917e-01f, 2.71076143e-01f, 2.98298657e-01f, -6.89286441e-02f, 1.38584688e-01f, -1.39024273e-01f, 3.21086317e-01f, 2.55324036e-01f, 3.46132778e-02f, 3.44601989e-01f,
  2.66025454e-01f, 1.71250850e-01f, -1.59846812e-01f, 3.20470072e-02f, 9.24428254e-02f, -5.88563969e-03f, -2.38724239e-02f, 1.31814837e-01f, -2.11917870e-02f, 7.75448903e-02f,
  9.83390734e-02f, 9.76050943e-02f, -1.34667447e-02f, 5.87404706e-02f, 9.78377014e-02f, 7.81559274e-02f, 1.01682983e-01f, 1.33861542e-01f, 1.05781458e-01f, 4.76551428e-02f,
  8.73813480e-02f, 1.33043721e-01f, 9.70076919e-02f, -3.91583517e-02f, 1.47330780e-02f, -4.14622687e-02f, 3.27622034e-02f, 9.44667235e-02f, -1.26765929e-02f, 1.86109915e-01f,
  -1.52845606e-01f, 5.56415953e-02f, -2.63956754e-04f, 4.42459024e-02f, 6.66807368e-02f, -4.46569436e-04f, 6.82637270e-04f, 8.40269960e-03f, -6.21432997e-02f, 1.14432625e-01f,
  1.83376279e-02f, -2.55932100e-03f, 4.01861109e-02f, 7.07150623e-02f, 4.46021222e-02f, 1.22963145e-01f, -1.86059158e-02f, 3.76818068e-02f, 4.92807776e-02f, 1.01689599e-01f,
  6.63659424e-02f, 1.07384332e-01f, 1.04612149e-01f, 2.25355513e-02f, 4.39757742e-02f, 4.62317988e-02f, 3.90082202e-03f, 1.54211866e-02f, -3.18305977e-02f, 1.01276420e-01f,
  7.32477978e-02f, -1.99153706e-01f, 4.27097939e-02f, -5.47434688e-02f, -1.32409425e-03f, -1.24797095e-02f, 4.52326536e-02f, -7.19221905e-02f, 2.26714909e-02f, 1.58441775e-02f,
  -1.04375355e-01f, -8.71141553e-02f, 7.94510469e-02f, -3.47306244e-02f, -1.48177277e-02f, -2.63693482e-02f, 2.05739699e-02f, -6.21744655e-02f, -6.50243610e-02f, 5.87384403e-03f,
  -5.22746369e-02f, -7.46391714e-02f, -1.21168002e-01f, -9.50036049e-02f, 2.23413315e-02f, -1.73727721e-01f, -4.28466238e-02f, -8.81860033e-02f, -1.61297902e-01f, -2.00454861e-01f,
  9.60745662e-02f, 7.64244497e-01f, -6.31477460e-02f, 1.18031546e-01f, -1.71224326e-01f, -3.06837827e-01f, -4.02701683e-02f, 6.42693862e-02f, 1.05740756e-01f, 2.00548679e-01f,
  1.18718430e-01f, -9.12689120e-02f, -3.21403928e-02f, 1.02337655e-02f, -4.71745804e-03f, 1.18738160e-01f, 1.36217996e-02f, -1.25901192e-01f, -3.54497701e-01f, -1.85187280e-01f,
  1.23448238e-01f, 3.42843384e-01f, 3.65441680e-01f, 1.74043819e-01f, 2.46463865e-01f, -1.82202011e-02f, 3.01021278e-01f, 1.61417007e-01f, 1.77700624e-01f, 4.15902466e-01f,
  -2.62017939e-02f, 3.23183119e-01f, -9.12946388e-02f, 1.44494817e-01f, 6.92236125e-02f, 7.52157718e-02f, 3.84448282e-02f, 1.49058729e-01f, 7.20308423e-02f, 1.51298955e-01f,
  1.35288939e-01f, 1.06160142e-01f, 2.62107365e-02f, 1.44456506e-01f, 5.17957434e-02f, 8.80847052e-02f, 1.83562219e-01f, 2.28650346e-01f, 1.41925052e-01f, 1.44160882e-01f,
  6.94182217e-02f, 5.70322424e-02f, -5.27479798e-02f, 1.09168932e-01f, 1.65154442e-01f, -1.23831537e-02f, 1.45945609e-01f, 1.62244767e-01f, 5.62076010e-02f, 2.66200393e-01f,
  3.58802304e-02f, -4.31049764e-02f, -8.66015330e-02f, 4.00511362e-02f, 2.59638466e-02f, -2.72483788e-02f, -4.88911830e-02f, -2.31569093e-02f, -4.29793783e-02f, 8.94315448e-03f,
  -4.24542241e-02f, 2.03534085e-02f, 3.07097342e-02f, 5.09109199e-02f, 1.36972368e-02f, 1.56421270e-02f, -6.67359754e-02f, 5.57637960e-02f, -4.10281904e-02f, 9.98688117e-03f,
  2.13801451e-02f, -9.34798717e-02f, -1.99760348e-02f, 3.02615613e-02f, 1.94792710e-02f, -1.90207958e-02f, -1.63414702e-02f, -2.71842089e-02f, -8.33951309e-02f, 8.08937922e-02f,
  -3.31379138e-02f, -1.26179308e-01f, 1.44668370e-01f, 1.21438086e-01f, 4.33781259e-02f, 1.06291540e-01f, 1.12512536e-01f, 1.50645435e-01f, 1.03940971e-01f, 6.46750703e-02f,
  9.55673158e-02f, 2.49855686e-03f, 1.28967866e-01f, 4.82079163e-02f, 9.88733303e-03f, 4.71371831e-03f, 1.37764215e-01f, 1.58836935e-02f, 9.65363905e-02f, 1.34031311e-01f,
  1.83128193e-01f, -2.98353541e-03f, -7.57841319e-02f, -3.08343358e-02f, 3.65661904e-02f, -1.00933954e-01f, 9.32921562e-03f, 4.65909094e-02f, -1.67079017e-01f, 1.60950422e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.55606712e-02f, -1.12970591e-01f, -8.08877826e-01f, -1.80494964e-01f, -1.11952424e+00f, -9.51958001e-01f, -6.55131340e-01f, -3.58866930e-01f, -5.06437980e-02f, -2.46852428e-01f,
  -2.21054763e-01f, -4.14123898e-03f, 3.98168206e-01f, -2.87176102e-01f, -4.29245651e-01f, -4.25203353e-01f, -5.50213814e-01f, -5.76657593e-01f, -9.82684255e-01f, -1.26970673e+00f,
  -8.73694122e-01f, -6.99770987e-01f, -5.41956127e-01f, -2.63978183e-01f, -8.09582397e-02f, 1.08041771e-01f, 2.78370287e-02f, -4.47743744e-01f, -5.45567274e-01f, -2.78812557e-01f,
  1.98469445e-01f, -4.45960671e-01f, -1.87570810e-01f, -1.77666709e-01f, 1.27347354e-02f, 1.10759087e-01f, -7.20804781e-02f, 1.42411187e-01f, 1.27117455e-01f, -3.72543149e-02f,
  -2.12571517e-01f, -2.98553467e-01f, -1.15285017e-01f, -1.70580372e-01f, -1.88111618e-01f, -2.40557894e-01f, -3.35582234e-02f, -1.60241514e-01f, 3.84765938e-02f, 8.65980238e-02f,
  -1.93558574e-01f, -3.49945694e-01f, -4.13043462e-02f, -2.72437409e-02f, -6.56083897e-02f, -6.82817474e-02f, 2.26440683e-01f, -8.98211971e-02f, 4.22665104e-02f, 3.42817426e-01f,
  2.63363719e-02f, 3.65073174e-01f, 1.82236768e-02f, -1.25817418e-01f, 9.81271490e-02f, 1.66382313e-01f, 3.66063304e-02f, 1.66163281e-01f, -5.58047071e-02f, 1.49138808e-01f,
  1.26580134e-01f, -2.11420134e-02f, 9.02273133e-02f, 1.28576726e-01f, 1.24680588e-03f, -1.83673590e-01f, 2.86687911e-03f, 1.90118942e-02f, 1.42712325e-01f, 4.32942398e-02f,
  -9.66513529e-02f, -1.72172990e-02f, 1.95149779e-02f, 1.20129116e-01f, -2.13262409e-01f, -9.42786783e-02f, -1.02155752e-01f, -3.97762917e-02f, 1.62348058e-02f, -2.04020754e-01f,
  6.47996187e-01f, -5.21592975e-01f, 1.40314013e-01f, 1.62170026e-02f, 1.62333131e-01f, 1.57306656e-01f, 7.19928816e-02f, 9.44438055e-02f, 1.65258408e-01f, -4.23336551e-02f,
  -1.73633814e-01f, 4.76439334e-02f, 9.52977464e-02f, 6.65961355e-02f, -1.45019904e-01f, -1.37956455e-01f, -6.11618608e-02f, -4.16471176e-02f, -8.41920748e-02f, 2.66704261e-01f,
  1.45397663e-01f, 2.93086260e-03f, 2.53896922e-01f, 2.80673653e-01f, 1.78823620e-02f, -2.20108218e-02f, 2.46262237e-01f, 1.53420597e-01f, 1.46331921e-01f, 5.80994427e-01f,
  1.09586334e+00f, -5.05030341e-02f, 7.59935558e-01f, 1.20207043e-02f, 5.60262576e-02f, 4.17751968e-01f, 6.00996315e-01f, 2.57616818e-01f, -2.63804253e-02f, 6.26377463e-02f,
  -5.35123527e-01f, -7.44634986e-01f, -7.06972480e-01f, -3.75106126e-01f, -6.60220087e-02f, 3.85973543e-01f, 4.41282660e-01f, 4.73886281e-01f, 4.26615775e-01f, 1.64629146e-01f,
  -2.05932334e-01f, 2.37957418e-01f, 2.90659577e-01f, 8.21507350e-02f, 7.86281303e-02f, -2.02222541e-01f, 7.22469762e-02f, 2.11736321e-01f, -1.36543185e-01f, 5.31949878e-01f,
  2.83274412e-01f, 4.82816011e-01f, -2.38094464e-01f, -2.98270792e-01f, -1.10982977e-01f, 5.41562103e-02f, 7.17707500e-02f, 8.89172107e-02f, -1.74720436e-01f, 3.62618342e-02f,
  -1.10377543e-01f, -6.23408034e-02f, 3.78808603e-02f, 4.51535955e-02f, 1.59426510e-01f, 6.55477643e-02f, 5.48214316e-02f, 2.19067130e-02f, -5.66639714e-02f, -1.80249989e-01f,
  -3.82193565e-01f, -6.27334863e-02f, 1.47548646e-01f, -1.53138250e-01f, -1.26403779e-01f, -1.86129168e-01f, -4.80000600e-02f, 6.05073236e-02f, -8.81687105e-02f, 1.52225226e-01f,
  -1.09571300e-01f, 5.77801056e-02f, 2.73335073e-02f, 6.43276721e-02f, -2.93786023e-02f, 3.36940065e-02f, -2.99357548e-02f, -2.02337295e-01f, 1.07314803e-01f, 2.46370643e-01f,
  -1.57576278e-01f, 4.13525477e-02f, -2.72754095e-02f, 3.53605747e-02f, -1.58562109e-01f, 1.24178946e-01f, 1.43869445e-01f, 2.15571579e-02f, -1.19267046e-01f, 8.23842511e-02f,
  -1.08028822e-01f, 1.44567862e-01f, -7.66403824e-02f, 4.10504341e-02f, -5.90009689e-02f, -4.79715914e-02f, 4.05077860e-02f, -9.66705903e-02f, -1.77573204e-01f, 5.59357256e-02f,
  -5.69541812e-01f, -7.31159329e-01f, 1.39403914e-03f, -7.49863535e-02f, 1.68098986e-01f, -9.29343253e-02f, -6.98669488e-03f, -1.74170360e-01f, -3.64972986e-02f, 2.45836247e-02f,
  -6.56927526e-02f, -2.99073639e-03f, -8.48212186e-03f, 6.77541196e-02f, 7.37040415e-02f, -1.07805938e-01f, -2.63801575e-01f, 1.03879556e-01f, -9.54751447e-02f, -8.78775213e-03f,
  -1.99250326e-01f, 3.97711322e-02f, -3.32389511e-02f, -1.86188400e-01f, -2.43549332e-01f, -9.16541070e-02f, 6.11801259e-03f, -6.69178367e-03f, -5.66235185e-03f, -1.68977767e-01f,
  2.69913703e-01f, 6.33666813e-01f, -6.36404812e-01f, 3.45541805e-01f, 4.80210125e-01f, 5.70404112e-01f, 1.08562326e+00f, 4.32567894e-01f, 1.83039457e-01f, 2.87261665e-01f,
  1.35681152e-01f, -1.83029100e-01f, -1.65405616e-01f, -5.07606566e-01f, -4.68114205e-02f, 2.39928827e-01f, 1.50956959e-01f, -4.09684747e-01f, -3.83617014e-01f, -6.75452501e-02f,
  2.57072538e-01f, 4.53764677e-01f, 7.34085143e-02f, 6.76955655e-02f, 1.00454018e-01f, -1.19009659e-01f, 1.47191301e-01f, 1.46559164e-01f, 4.77362499e-02f, -6.78175211e-01f,
  -1.05043292e+00f, 7.28199109e-02f, -1.71580195e-01f, 5.04405536e-02f, -9.18957517e-02f, -1.44267976e-01f, -1.28335446e-01f, -1.91634849e-01f, 3.73396724e-02f, -3.59259285e-02f,
  -1.16911307e-01f, -3.81910801e-02f, 4.91451286e-02f, -9.63285118e-02f, 1.16286546e-01f, -8.79265275e-03f, 7.50596151e-02f, -1.01334617e-01f, -7.19780698e-02f, -2.19856590e-01f,
  -5.84579110e-02f, 5.17043322e-02f, -4.89611104e-02f, 4.40218672e-02f, -1.07354984e-01f, -2.21901163e-01f, -9.39826295e-02f, -1.05564713e-01f, -5.86811639e-02f, -1.48643777e-01f,
  6.28926326e-03f, -5.15367202e-02f, -8.09733793e-02f, 8.59702751e-02f, 1.76608801e-01f, -7.77276009e-02f, -7.42865056e-02f, -2.42287144e-02f, 5.00672832e-02f, 5.42598628e-02f,
  -1.21584192e-01f, -6.70481399e-02f, -1.53397754e-01f, 3.73704694e-02f, -9.10217762e-02f, -1.71331223e-03f, -1.27128810e-01f, 4.87176441e-02f, -1.78258121e-01f, 1.89779773e-01f,
  1.24477670e-02f, 8.96965861e-02f, 1.01454630e-02f, -1.32982284e-01f, -3.94288674e-02f, -1.52397558e-01f, -1.14984967e-01f, -8.25692192e-02f, 5.84314391e-02f, 2.83781320e-01f,
  1.99525416e-01f, -3.05870525e-03f, -2.15496853e-01f, -8.68045315e-02f, -7.69507932e-03f, -2.31364146e-02f, -3.69469188e-02f, -1.48409635e-01f, 7.59527981e-02f, -9.52802449e-02f,
  4.87185409e-03f, -1.32514030e-01f, -1.20466568e-01f, -9.05965492e-02f, 2.94448994e-02f, 8.63409787e-02f, 3.99016738e-02f, -3.95428613e-02f, -4.22006771e-02f, -1.47461057e-01f,
  1.37357458e-01f, -2.12145317e-02f, -2.28941038e-01f, -6.20841747e-03f, -1.75178185e-01f, -3.90329142e-03f, 5.07191606e-02f, -5.06435372e-02f, 6.07569069e-02f, 2.70491958e-01f,
  -4.41058159e-01f, 2.83549368e-01f, -3.98612708e-01f, 3.98824841e-01f, 6.91932499e-01f, -6.57924190e-02f, -3.20587307e-01f, -4.35468674e-01f, 1.60275757e-01f, 2.23487332e-01f,
  1.23500444e-01f, 2.22103253e-01f, 5.31531917e-03f, -1.92397181e-02f, -5.33390820e-01f, 1.35664746e-01f, 3.85066479e-01f, -2.91006267e-01f, -8.70713234e-01f, -3.73153836e-01f,
  4.94488358e-01f, 6.84736222e-02f, -4.22663569e-01f, -4.08525378e-01f, 6.21743917e-01f, 5.25962859e-02f, -5.21596475e-03f, 3.81771475e-01f, 1.67737484e-01f, 1.13712633e+00f,
  1.64721712e-01f, -2.55120900e-02f, -5.09880364e-01f, 5.00090942e-02f, 1.50997996e-01f, -1.08629957e-01f, -1.12742275e-01f, -6.66445866e-02f, 4.63767014e-02f, -2.16792718e-01f,
  3.41145813e-01f, -2.30090749e-02f, 3.45568538e-01f, -4.91988212e-02f, -1.80633396e-01f, -2.12744236e-01f, -1.66401312e-01f, -4.06424761e-01f, -4.32093352e-01f, -1.15381084e-01f,
  5.20748734e-01f, 3.94692212e-01f, -2.20356703e-01f, -2.74441481e-01f, -1.25830665e-01f, 1.10155027e-02f, -2.00458318e-01f, 8.91597569e-02f, -6.08928859e-01f, 2.70962715e-01f,
  -1.69174392e-02f, -6.55416101e-02f, 9.40859839e-02f, 4.12331447e-02f, -4.46600653e-02f, 6.68197796e-02f, 1.33863792e-01f, -1.08112574e-01f, 1.02264799e-01f, -1.59460917e-01f,
  5.96039630e-02f, -8.30249339e-02f, -1.55847460e-01f, -5.97038604e-02f, -8.73431042e-02f, 6.97172955e-02f, -6.91813752e-02f, -1.62265256e-01f, -1.45379111e-01f, -1.31722555e-01f,
  1.48280198e-02f, -6.71821972e-03f, 6.48747459e-02f, -3.52344438e-02f, 7.76525885e-02f, -1.27039421e-02f, 1.38372704e-01f, -3.71573381e-02f, -6.80085495e-02f, 2.77311265e-01f,
  -7.30176270e-02f, -4.57919568e-01f, 1.82425201e-01f, -1.01247795e-01f, 1.61050811e-01f, -1.84162874e-02f, 1.34867638e-01f, -3.17496173e-02f, 1.26868710e-01f, -1.25812382e-01f,
  -2.14045733e-01f, -4.13694829e-02f, -1.73016824e-02f, 6.06831238e-02f, -8.21744651e-02f, -1.85083486e-02f, 3.13574463e-01f, -4.72059920e-02f, -2.19382554e-01f, -7.93304201e-03f,
  -2.94644479e-02f, -2.80990392e-01f, -4.46819365e-01f, -1.63532808e-01f, 1.11624241e-01f, -3.51769030e-01f, -2.10291237e-01f, -1.12076499e-01f, -5.01288533e-01f, -3.19977075e-01f,
  4.57981259e-01f, -5.13117075e-01f, 1.71260640e-01f, 5.49768567e-01f, 1.06247857e-01f, -2.74950445e-01f, -3.76608849e-01f, 5.96529506e-02f, 3.45346093e-01f, 5.85307181e-02f,
  3.89101692e-02f, 4.35789466e-01f, 3.45470160e-01f, 2.67603755e-01f, 2.03558743e-01f, 1.69623643e-01f, 4.63302732e-01f, 5.08471131e-01f, 2.03669518e-01f, 2.61440754e-01f,
  3.89016956e-01f, 1.23454556e-01f, -8.33848566e-02f, 2.47821808e-01f, 2.46122718e-01f, 3.26927543e-01f, -1.35370614e-02f, -1.17381543e-01f, -1.31733865e-01f, 6.69205010e-01f,
  6.04769848e-02f, -1.32578254e-01f, 4.04625922e-01f, -4.79035340e-02f, -5.70390858e-02f, -7.18997866e-02f, -7.65675381e-02f, -1.84617504e-01f, -1.09634273e-01f, -5.22417352e-02f,
  -1.15467519e-01f, -2.92025059e-02f, -4.01017182e-02f, -7.96529427e-02f, -7.58420676e-02f, 1.42489010e-02f, 6.09271191e-02f, 1.11858010e-01f, 8.01261142e-02f, 1.04068881e-02f,
  5.67239188e-02f, -1.28089130e-01f, -3.60744417e-01f, -1.04786374e-01f, 7.67005086e-02f, 1.58212885e-01f, 1.14724971e-03f, -4.76496015e-03f, -3.68455499e-02f, 8.73019844e-02f,
  2.03539997e-01f, 1.18757769e-01f, -4.92007360e-02f, 1.99503213e-01f, 2.87731737e-01f, 6.37385100e-02f, 1.23471431e-01f, -3.74943502e-02f, 1.70742095e-01f, -5.58473282e-02f,
  5.06488793e-02f, 1.55799419e-01f, 1.13554813e-01f, 9.19705927e-02f, 1.24702580e-01f, -1.26196086e-01f, -3.70758250e-02f, -4.36140895e-02f, -7.45293545e-03f, -1.95471287e-01f,
  -5.43086529e-02f, 8.47035795e-02f, -1.25889760e-03f, -8.22454169e-02f, 1.29090901e-02f, 2.20338419e-01f, 1.62572801e-01f, -1.01066567e-01f, -1.81875095e-01f, -4.35951836e-02f,
  -7.36727774e-01f, -9.32815447e-02f, 5.31753302e-01f, 8.31140727e-02f, -6.94749877e-02f, -2.40025207e-01f, 5.66903055e-02f, -1.37305051e-01f, -2.01437682e-01f, 2.20548268e-02f,
  -4.06063139e-01f, -1.04941905e-01f, -1.75021589e-01f, -2.54070424e-02f, -6.77863285e-02f, -2.09123224e-01f, -6.87837005e-02f, 6.08725995e-02f, -1.73489302e-01f, -2.04898715e-01f,
  -2.23037243e-01f, -1.19652025e-01f, -3.41539979e-01f, -1.36190563e-01f, -7.15249926e-02f, 7.76615590e-02f, -1.76295877e-01f, -1.21789806e-01f, -1.78406522e-01f, -1.73234269e-01f,
  -5.22447288e-01f, -1.16970293e-01f, 4.24529046e-01f, -4.74617660e-01f, 3.26205790e-01f, -2.81681791e-02f, 5.54391265e-01f, -1.05398364e-01f, -4.29421395e-01f, 4.88756627e-01f,
  -2.22994685e-01f, -6.38259053e-01f, -2.57724345e-01f, -4.20678735e-01f, -3.11911643e-01f, 6.44545317e-01f, 3.11219931e-01f, -8.25483277e-02f, -1.99234724e-01f, -8.68469775e-02f,
  6.98508099e-02f, 6.97211595e-03f, -4.87578869e-01f, -7.85222203e-02f, 2.37209737e-01f, -2.09439501e-01f, 3.79774809e-01f, -2.88048774e-01f, -3.51434022e-01f, -5.32899462e-02f,
  5.39038122e-01f, -4.60257351e-01f, -4.05945145e-02f, -4.02773768e-01f, 1.30410224e-01f, -1.24185309e-01f, 1.11922346e-01f, -2.86873952e-02f, -9.96974483e-02f, 1.78990234e-02f,
  -1.75222546e-01f, -7.70926252e-02f, -3.45776707e-01f, -9.05783623e-02f, 4.18949351e-02f, 2.34695282e-02f, -6.35587424e-03f, -1.95360988e-01f, -2.00014457e-01f, 1.99399158e-01f,
  1.04650132e-01f, -2.17899177e-02f, 9.41105187e-04f, -9.36777741e-02f, -1.30454704e-01f, -3.26136172e-01f, 3.66412550e-02f, -2.06428334e-01f, -3.45061272e-01f, 3.49434525e-01f,
  8.51987526e-02f, 1.72807246e-01f, 2.64710095e-02f, 7.41263330e-02f, 9.82650071e-02f, -6.89541027e-02f, 1.02325799e-02f, 2.28820536e-02f, 6.33571297e-02f, 6.57129586e-02f,
  2.44678389e-02f, 9.27734748e-02f, -7.72213638e-02f, 1.69933867e-02f, 2.21932661e-02f, -1.65094703e-01f, -4.01624888e-02f, -5.22894971e-03f, -5.28119579e-02f, -1.17168084e-01f,
  -1.03041120e-01f, -7.20137963e-03f, 3.45614552e-02f, 3.95265371e-02f, -1.18121557e-01f, -1.19239338e-01f, 8.19511861e-02f, -5.52814975e-02f, -1.14060715e-02f, -5.09147309e-02f,
  2.31016040e-01f, -5.16509950e-01f, 2.46740714e-01f, -1.22729912e-02f, 7.68374652e-02f, -4.36990708e-02f, -6.93386793e-02f, -1.12557067e-02f, -3.78616117e-02f, 1.43818706e-02f,
  -2.84860492e-01f, 2.79681925e-02f, 1.27504664e-02f, 1.25691220e-01f, 1.19754925e-01f, 5.28696701e-02f, -9.32496712e-02f, -2.20991988e-02f, -9.55296680e-02f, 2.95250746e-03f,
  1.30544260e-01f, 1.60272896e-01f, 1.50847748e-01f, 5.04598431e-02f, -1.66824926e-02f, 7.87841454e-02f, 2.93504089e-01f, 1.96492448e-01f, -2.49444563e-02f, 8.64430845e-01f,
  -1.58145487e+00f, 1.08045779e-01f, 4.60065082e-02f, -9.00282800e-01f, 5.82312606e-03f, 1.63912565e-01f, 3.53448123e-01f, 2.69923568e-01f, 1.84668470e-02f, 3.25513512e-01f,
  1.90814927e-01f, -4.58758056e-01f, -5.78938246e-01f, 1.35918096e-01f, -1.73034191e-01f, 1.18412741e-01f, -4.96797949e-01f, -9.37214255e-01f, -5.73041618e-01f, 3.99859458e-01f,
  -2.97234226e-02f, -9.10920322e-01f, -9.05711591e-01f, -2.18543500e-01f, 3.06312859e-01f, -2.85737604e-01f, -3.26101363e-01f, -4.13525909e-01f, 4.24441338e-01f, -2.33543858e-01f,
  -7.43819773e-02f, -1.16560176e-01f, 1.05026782e-01f, -8.21211711e-02f, 1.22909009e-01f, -8.93295258e-02f, 6.25968128e-02f, -1.26283512e-01f, -9.17484984e-02f, 3.67634520e-02f,
  -2.45671660e-01f, 1.25343964e-01f, -2.99980909e-01f, 7.19455779e-02f, -1.79858789e-01f, 3.97786461e-02f, -3.05777113e-03f, -1.10177696e-01f, 7.94923380e-02f, 4.02047127e-01f,
  1.81986108e-01f, 5.24270609e-02f, -1.82317436e-01f, 3.12581420e-01f, 2.62469441e-01f, -1.82973295e-01f, 2.43446052e-01f, 1.00256220e-01f, 1.99039087e-01f, 1.05056815e-01f,
  8.13652668e-03f, 3.86228263e-02f, 2.76126973e-02f, -2.21708808e-02f, -2.73303259e-02f, 4.18218784e-02f, -5.88461570e-02f, -1.05184644e-01f, 4.34313342e-02f, -7.72802830e-02f,
  1.54507682e-01f, 4.79461253e-03f, -4.23117504e-02f, -9.43361968e-02f, 9.00177807e-02f, -2.50605419e-02f, -1.22575529e-01f, 1.84601266e-02f, 3.54325660e-02f, 3.71674821e-02f,
  2.70781778e-02f, 7.32520744e-02f, -1.22217558e-01f, 6.61073104e-02f, 1.01599939e-01f, -1.47931827e-02f, 7.33556002e-02f, 1.62946414e-02f, 6.57848921e-03f, 4.76879589e-02f,
  -4.68081385e-01f, -8.47828283e-04f, -4.18942451e-01f, 6.08977601e-02f, -4.31884788e-02f, 1.56944215e-01f, -7.61094317e-02f, 1.81295753e-01f, -9.32286158e-02f, 9.43211780e-04f,
  2.12900415e-01f, -7.97050297e-02f, -5.31200282e-02f, 9.96297151e-02f, -7.25080520e-02f, 1.38253523e-02f, 9.92947072e-02f, -1.50075212e-01f, -1.09425243e-02f, 3.00943516e-02f,
  2.98405066e-02f, 4.60546501e-02f, -4.10352677e-01f, -1.09390682e-02f, -3.37001793e-02f, -2.25148737e-01f, -1.16928935e-01f, 7.12582171e-02f, -3.17668281e-02f, 3.30364369e-02f,
  -4.25388545e-01f, -8.45783472e-01f, -9.09852311e-02f, -6.47210032e-02f, -1.01625048e-01f, -1.88270077e-01f, -9.55284238e-01f, -2.22098514e-01f, 2.93933541e-01f, -6.17722929e-01f,
  -3.28845888e-01f, 1.84039071e-01f, -3.07757795e-01f, -8.27577710e-02f, -4.28198814e-01f, -1.06514776e+00f, -6.14561677e-01f, 5.60049415e-02f, 4.83886570e-01f, 6.38651490e-01f,
  2.72696137e-01f, 1.37141511e-01f, 3.87825072e-01f, 2.12342784e-01f, 2.06307061e-02f, 1.79839075e-01f, -2.61615396e-01f, 6.37474284e-02f, -3.77999693e-01f, -3.53543222e-01f,
  -4.77494806e-01f, -5.24646163e-01f, 2.85999238e-01f, -3.09351962e-02f, -2.71879323e-02f, -1.27311707e-01f, -1.04780644e-02f, -2.06762448e-01f, 3.41245867e-02f, -3.67974676e-02f,
  -3.01190525e-01f, -1.02159930e-02f, -2.19715461e-02f, 1.62030905e-01f, 1.18311085e-01f, 2.31727213e-02f, 1.73357382e-01f, -1.90887526e-02f, -2.99960613e-01f, -6.82434589e-02f,
  4.71595228e-02f, -2.77463496e-02f, -2.56487548e-01f, -5.67548573e-02f, -1.09932996e-01f, 1.90997005e-01f, 1.51489601e-01f, 2.68159211e-01f, -1.79314807e-01f, -4.40868586e-01f,
  2.28603389e-02f, 8.70172307e-02f, 1.02888308e-01f, 7.09939748e-02f, 2.75334250e-02f, -1.10365994e-01f, -2.05018353e-02f, -1.87866688e-01f, 1.51838750e-01f, -1.61752835e-01f,
  1.11196123e-01f, -1.45500135e-02f, -3.44871469e-02f, -3.16983387e-02f, 7.22257495e-02f, -2.24307906e-02f, -1.40556455e-01f, -1.21413186e-01f, 5.94291789e-03f, 9.99361929e-03f,
  -1.98883656e-02f, 2.25477323e-01f, -4.67576608e-02f, 1.64340705e-01f, -1.09423555e-01f, 1.95407961e-02f, -1.63248241e-01f, 1.63904694e-03f, -8.41883644e-02f, -1.54747024e-01f,
  1.43229350e-01f, 1.57658592e-01f, -4.88490790e-01f, 3.35419886e-02f, -1.38393223e-01f, -4.67117280e-02f, -3.40147913e-02f, 9.32849124e-02f, -4.87628691e-02f, -2.36222763e-02f,
  -3.29205170e-02f, -2.10550874e-02f, -2.33492404e-01f, 2.18738109e-01f, 1.94037378e-01f, 9.24593583e-02f, -4.06411916e-01f, 5.49585186e-02f, 2.48277877e-02f, 1.74824491e-01f,
  -1.01468422e-01f, -4.08929259e-01f, -3.29725266e-01f, -2.94285685e-01f, -2.17341766e-01f, -2.14997023e-01f, -1.52354315e-01f, -2.52152443e-01f, -5.71969211e-01f, -8.19625080e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.02151942e+00f, 8.85734200e-01f, 1.19138741e+00f, 5.26490450e-01f, 5.80870628e-01f, 1.05232239e+00f, 2.97415495e-01f, 6.37581706e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -7.00840913e-03f, -2.26820722e-01f, -2.64679372e-01f, -9.79544828e-04f, -4.82867733e-02f, 2.82503784e-01f, -4.80180532e-01f, 1.86439194e-02f, -3.07774395e-01f, 3.51120621e-01f,
  -1.31643057e-01f, 1.53907776e-01f, 2.08734889e-02f, 1.73980385e-01f, 5.59306443e-01f, 2.71293879e-01f, 8.42398405e-02f, -4.44898307e-01f, 3.69585827e-02f, -2.70789303e-02f,
  4.18132804e-02f, 5.21809757e-01f, 8.51742029e-02f, 2.29439922e-02f, 3.34871858e-02f, -2.92849660e-01f, -2.75058776e-01f, -7.13745281e-02f, 4.17917907e-01f, -6.02603853e-01f,
  3.31130505e-01f, 3.74268025e-01f, 1.45968854e-01f, 9.14372921e-01f, 2.71097809e-01f, -7.85312951e-02f, 2.66966432e-01f, -1.01746452e+00f, 2.20069185e-01f, -2.57925391e-01f,
  1.39474854e-01f, 3.77941906e-01f, -6.72799721e-02f, 1.60216928e-01f, -2.57973075e-01f, 3.25705819e-02f, -3.48187387e-01f, -6.21664412e-02f, 4.27056670e-01f, -6.10408187e-02f,
  -2.43871789e-02f, -1.14363767e-01f, -5.34816325e-01f, 7.41180956e-01f, -1.37718886e-01f, 8.66797566e-02f, -1.11175261e-01f, -2.33507514e-01f, 3.36485207e-01f, -1.95034564e-01f,
  -2.74239391e-01f, 3.90155822e-01f, -7.87697658e-02f, 7.20834360e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.97500193e-01f, 7.27416277e-01f, 6.11351021e-02f, -1.62340440e-02f, -8.00791264e-01f, 6.00439131e-01f, 7.66513705e-01f, 7.20750988e-01f, 9.63977724e-02f, 3.03842694e-01f,
  -1.18905592e+00f, 1.17773819e+00f, 5.47477186e-01f, -5.00996828e-01f, 1.90001875e-01f, 9.11622465e-01f, -2.90310472e-01f, 2.74918735e-01f, -1.03663437e-01f, -4.02680086e-03f,
  1.87666371e-01f, 8.40412974e-01f, 3.16357166e-01f, 6.36337176e-02f, 7.49279916e-01f, -7.11705327e-01f, 5.69414258e-01f, 1.18037534e+00f, 7.58481443e-01f, -9.20016885e-01f,
  -5.82979977e-01f, 7.50788078e-02f, 7.78593063e-01f, 4.43388700e-01f, 3.45388353e-01f, 4.26963031e-01f, 3.22654933e-01f, -3.99074525e-01f, 6.49496436e-01f, 8.56232405e-01f,
  7.02723801e-01f, 2.79175103e-01f, 9.73369062e-01f, -3.45120966e-01f, -6.40314519e-01f, 1.02406442e+00f, -1.17391869e-02f, -5.28626382e-01f, -1.01044285e+00f, -4.88387138e-01f,
  6.65310621e-01f, 5.09733796e-01f, -9.98748600e-01f, 5.10551989e-01f, -5.73501527e-01f, -1.66636601e-01f, 4.52373803e-01f, 1.36595696e-01f, 9.18492556e-01f, -5.31635821e-01f,
  5.39901018e-01f, -5.38720131e-01f, -3.16272527e-01f, 3.79193485e-01f, 1.33041024e-01f, 1.49993494e-01f, 4.34181333e-01f, 6.63624227e-01f, -1.86244994e-01f, -7.15608746e-02f,
  2.96100914e-01f, 4.89504606e-01f, 5.49833775e-02f, 5.62878728e-01f, 1.06551683e+00f, 1.81808949e+00f, -2.33425677e-01f, 7.35298514e-01f, -4.23253253e-02f, -1.24279246e-01f,
  5.52064240e-01f, 5.58888376e-01f, 1.86856657e-01f, 8.62023979e-02f, -1.33450282e+00f, 1.25804043e+00f, 8.02784413e-02f, -3.48629802e-01f, 4.51892674e-01f, 1.16120064e+00f,
  2.47735873e-01f, -8.09125960e-01f, 3.76332611e-01f, 3.92965138e-01f, -4.87657666e-01f, 3.89549226e-01f, 5.30156374e-01f, 6.47615433e-01f, 6.39566839e-01f, 7.57913649e-01f,
  -4.47354019e-01f, -3.93506557e-01f, 1.06887281e-01f, 1.62423223e-01f, 8.78265500e-01f, -9.87312794e-01f, 5.92322826e-01f, 3.91435713e-01f, 2.70368606e-01f, 2.27823257e-02f,
  1.63312197e+00f, 1.51837766e+00f, 3.03534389e-01f, -3.89259696e-01f, 5.99216707e-02f, 3.56522441e-01f, 2.31622741e-01f, 9.71233308e-01f, -1.02609551e+00f, -2.92830586e-01f,
  8.48729670e-01f, -7.89554492e-02f, 1.99959978e-01f, 2.54917964e-02f, 5.98209262e-01f, 1.26805472e+00f, 5.17735362e-01f, -2.74371624e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.37437621e-01f, 7.66388953e-01f, -1.85844764e-01f, 6.67789221e-01f, 2.11990535e-01f, 4.49260533e-01f, 1.49233818e-01f, 2.53491729e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -3.96637172e-01f, 1.88595429e-01f, -7.73192823e-01f, 1.65305331e-01f, -6.90481514e-02f, -8.67889881e-01f, -9.99817193e-01f, 8.94186914e-01f, 1.48106620e-01f, -2.56754905e-01f,
  -5.18789113e-01f, 2.08794653e-01f, -9.22919691e-01f, -2.83466168e-02f, 4.67749059e-01f, -3.50356072e-01f, -1.31157622e-01f, 3.45292747e-01f, 2.34657437e-01f, 1.65037200e-01f,
  -9.44610775e-01f, 3.15810531e-01f, -1.99029177e-01f, -4.37401235e-01f, -2.51164466e-01f, 4.55175996e-01f, -1.06865013e+00f, 7.12724209e-01f, -7.66311646e-01f, 4.84322548e-01f,
  -3.97199661e-01f, 2.72260785e-01f, 7.27426052e-01f, -4.56212729e-01f, 2.45301217e-01f, 3.20543289e-01f, 8.31671238e-01f, 1.39956975e+00f, 4.85083491e-01f, -7.61580169e-02f,
  1.65520832e-01f, -3.37483346e-01f, -7.65889347e-01f, 6.27972126e-01f, -6.41268551e-01f, 2.17132464e-01f, 5.43735802e-01f, -1.45961773e+00f, -1.61620164e+00f, 1.84772655e-01f,
  3.20651323e-01f, -1.65847406e-01f, -6.20691240e-01f, 2.82528937e-01f, -1.08221877e+00f, -3.51294249e-01f, -5.41087091e-01f, -1.74733913e+00f, -1.41446456e-01f, -1.25104368e+00f,
  -2.30089709e-01f, -1.82163930e+00f, 6.66662812e-01f, 4.07454491e-01f, 6.34234250e-02f, -5.92995323e-02f, 4.63731468e-01f, -3.77376884e-01f, 1.24365127e+00f, 7.62718499e-01f,
  6.69234216e-01f, -6.52828753e-01f, 3.87334637e-02f, 2.82706410e-01f, 4.97805297e-01f, -8.60776544e-01f, -2.98252076e-01f, -6.05036676e-01f, 4.15550172e-01f, -3.95961195e-01f,
  7.21687615e-01f, 2.79637486e-01f, 5.42419493e-01f, -6.95058465e-01f, -9.33795929e-01f, -5.65311849e-01f, -1.11224425e+00f, 8.95143151e-01f, -3.93031865e-01f, 4.38804403e-02f,
  5.02335906e-01f, 7.72551596e-02f, 1.66495722e-02f, -3.14455181e-02f, -1.03182435e-01f, -5.62262684e-02f, -8.17771435e-01f, 7.84556448e-01f, -1.33376300e-01f, -3.17010015e-01f,
  2.75112569e-01f, 5.74467897e-01f, 4.88441706e-01f, -8.34845304e-01f, 6.63158357e-01f, -3.19365948e-01f, -6.87241375e-01f, -4.42338914e-01f, 1.98699757e-01f, 8.58088970e-01f,
  -1.63474834e+00f, -6.28559291e-01f, -9.47567225e-02f, 2.52631754e-01f, 4.08802480e-02f, 6.46294560e-03f, -2.59839483e-02f, -8.53286982e-01f, -2.20313981e-01f, -8.21463227e-01f,
  -2.28687480e-01f, 6.04294300e-01f, -1.12029779e+00f, 3.54302466e-01f, 2.95866221e-01f, -7.55000770e-01f, -3.58839065e-01f, 2.13919267e-01f, 5.75200140e-01f, -6.36087418e-01f,
  1.10944219e-01f, -5.14293194e-01f, 7.92297900e-01f, -2.46555224e-01f, 7.93881178e-01f, 4.90066260e-01f, -7.24757016e-01f, -5.77498555e-01f, -1.74565300e-01f, -1.07986093e-01f,
  4.90958504e-02f, 8.73614907e-01f, -1.55262768e+00f, 5.11983335e-01f, -3.09645116e-01f, -3.75958115e-01f, 1.94700733e-02f, 1.67080741e-02f, 5.85875427e-03f, 5.72182357e-01f,
  2.86881447e-01f, 2.73388416e-01f, 7.70914257e-01f, 6.92020953e-01f, -1.03504729e+00f, -1.07062924e+00f, 2.87920624e-01f, -5.93441308e-01f, -1.87155262e-01f, -7.92124212e-01f,
  1.27226010e-01f, -1.28915215e+00f, -9.75151837e-01f, 1.20295063e-01f, -1.99015334e-01f, -7.90750623e-01f, 7.24084556e-01f, 2.75462329e-01f, -1.14487720e+00f, -1.09221137e+00f,
  9.09145832e-01f, -1.76685357e+00f, -6.42860115e-01f, -6.62074506e-01f, -1.25155494e-01f, 6.44692004e-01f, 4.32032406e-01f, -5.08606493e-01f, -1.03255057e+00f, 8.46353114e-01f,
  4.04899627e-01f, -7.34886765e-01f, 2.64853507e-01f, -3.65622371e-01f, -1.06573975e+00f, -2.61405319e-01f, 9.21071947e-01f, 1.11600794e-01f, 5.64684868e-01f, 4.53474708e-02f,
  -1.26203954e+00f, -1.52152503e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.56266946e-01f, 1.21425979e-01f, -3.39680523e-01f, -5.35464048e-01f, -2.44136840e-01f, -4.69582796e-01f, 3.35798085e-01f, 2.47543946e-01f, 1.84101209e-01f, 1.90734401e-01f,
  -3.68299901e-01f, -1.02305096e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    