/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.59261540e-01f, 1.51408479e-01f, -3.27193826e-01f, -5.64092435e-02f, -1.29122257e-01f, -1.33663177e-01f, -3.74569036e-02f, 7.59766325e-02f, 5.21865003e-02f, -5.58805428e-02f,
  1.12114191e-01f, -7.21994564e-02f, -2.21843213e-01f, -1.43734023e-01f, -1.87993169e-01f, -2.51384020e-01f, -3.10820311e-01f, -2.33534500e-01f, -2.50242621e-01f, -4.21326682e-02f,
  -7.73899257e-02f, -8.64861012e-02f, -1.74562056e-02f, -6.63158521e-02f, 6.52942136e-02f, -4.02078629e-02f, -1.42886803e-01f, -2.81331819e-02f, -1.20730519e-01f, -9.62155014e-02f,
  -2.18661875e-01f, 1.73527047e-01f, 3.05849984e-02f, -1.81890056e-02f, 4.75616641e-02f, 4.26768251e-02f, 2.22505853e-02f, -3.02040502e-02f, 3.48185003e-02f, -3.51035930e-02f,
  -1.45851094e-02f, 9.12809223e-02f, -3.04305721e-02f, -3.75130773e-02f, 6.75092638e-02f, 5.72718913e-03f, -2.59279702e-02f, -1.40897185e-01f, 2.42701229e-02f, 1.08785212e-01f,
  1.11378595e-01f, 3.80052230e-03f, -2.05507334e-02f, -3.14924568e-02f, -1.18428972e-02f, -5.13575673e-02f, 1.13329388e-01f, 7.80923963e-02f, 5.25294058e-02f, 4.19731773e-02f,
  -4.96012978e-02f, 3.07457335e-02f, 6.71213269e-02f, 4.90994332e-03f, 1.32862572e-02f, -1.26812411e-02f, -2.13499484e-03f, -1.10985432e-02f, 4.69658617e-03f, -3.23065110e-02f,
  8.64057709e-03f, -5.26149385e-02f, -4.61924672e-02f, -6.88402215e-03f, -1.01921290e-01f, 2.15240140e-02f, 2.78876163e-02f, -3.51175480e-02f, 1.40571252e-01f, 6.83088526e-02f,
  -1.84156597e-02f, -2.48955353e-03f, 1.98895391e-02f, -3.71274282e-03f, -5.27090989e-02f, -1.28921732e-01f, 1.80470087e-02f, -2.99309753e-02f, 2.96070669e-02f, -6.30261702e-03f,
  -1.37162775e-01f, -1.17423929e-01f, -3.30323018e-02f, 5.53217977e-02f, 5.28282560e-02f, 4.28536572e-02f, 3.33442260e-03f, -2.15342008e-02f, 5.29395677e-02f, -4.23036627e-02f,
  1.41789183e-01f, 7.16904690e-03f, -4.69788499e-02f, 6.96034580e-02f, -8.43182653e-02f, -1.33613488e-02f, 7.85245225e-02f, -1.15508726e-02f, -2.72020064e-02f, 1.75548375e-01f,
  -2.14627339e-03f, -7.46445870e-03f, 6.47788569e-02f, -1.87343825e-02f, -5.57485735e-03f, -1.26223892e-01f, -1.97853670e-02f, 1.86905842e-02f, -5.19447513e-02f, 8.63119513e-02f,
  -9.23255831e-02f, 1.06255338e-01f, 2.30799511e-01f, -6.50920346e-02f, 2.26444006e-02f, -7.10201487e-02f, -2.91799083e-02f, -2.38873690e-01f, -2.50837922e-01f, -1.29973590e-01f,
  -1.38370097e-01f, -2.35308975e-01f, -1.90598145e-01f, -7.40052527e-03f, 9.28302407e-02f, 1.94341600e-01f, 2.45892450e-01f, 2.13547811e-01f, 4.05485788e-03f, -2.10481361e-02f,
  -7.81020056e-03f, 3.88153605e-02f, -1.29694775e-01f, -1.54451564e-01f, 4.42936551e-03f, -1.39437065e-01f, 1.52740339e-02f, 1.98538393e-01f, 1.52754411e-01f, 2.38201961e-01f,
  1.08139202e-01f, 1.08843237e-01f, -1.53434547e-02f, 2.06120014e-02f, 1.15568660e-01f, 5.55454148e-03f, -3.62804011e-02f, -6.43170392e-03f, -8.82130414e-02f, -5.36778122e-02f,
  8.40862915e-02f, -4.69503365e-02f, 5.06462157e-02f, 5.63162789e-02f, -7.78050646e-02f, -2.24584453e-02f, 5.16252853e-02f, 1.39092579e-01f, 2.83343773e-02f, -8.81714821e-02f,
  -5.46462052e-02f, 1.81149662e-01f, 1.54461652e-01f, 4.50682547e-03f, 2.28529461e-02f, 1.20461341e-02f, -6.63671736e-03f, 1.27960145e-01f, 4.59884666e-02f, -7.80306906e-02f,
  4.67985719e-02f, 7.73134083e-02f, 1.01785392e-01f, 1.74013659e-01f, 7.40690157e-02f, 2.52195913e-02f, 8.39891955e-02f, 7.61426613e-02f, 7.71965384e-02f, 3.69992591e-02f,
  7.46201873e-02f, 1.43258318e-01f, 4.99770828e-02f, -3.59424725e-02f, -7.51979724e-02f, 1.03872851e-01f, 1.05046898e-01f, -1.11439824e-02f, 7.58125633e-02f, 4.54720445e-02f,
  7.89235979e-02f, 8.32516253e-02f, 6.98006600e-02f, 1.12249861e-02f, 1.17344655e-01f, 5.40898666e-02f, 1.63450569e-01f, 1.23619169e-01f, 3.80514674e-02f, 6.99524283e-02f,
  -3.01208496e-01f, 1.31950349e-01f, 1.14055714e-02f, -8.48616213e-02f, -1.72354188e-02f, -8.30595121e-02f, -2.40104403e-02f, -7.96036124e-02f, 3.03279702e-02f, 4.01567258e-02f,
  -2.80487277e-02f, 1.77858751e-02f, 3.38578410e-02f, -5.75758405e-02f, -1.40194893e-02f, -2.93948036e-02f, -3.54261473e-02f, -2.26817168e-02f, 2.47020368e-02f, -4.19642292e-02f,
  -1.25121936e-01f, -1.33193821e-01f, -1.68368787e-01f, -9.61336643e-02f, -7.39973644e-03f, -1.41361088e-01f, 1.19723342e-02f, -1.11133672e-01f, -1.07215732e-01f, -1.68211401e-01f,
  2.93999076e-01f, -4.71270010e-02f, 3.96292448e-01f, 1.28685579e-01f, -8.47704932e-02f, -1.44097403e-01f, -1.06733389e-01f, -8.75127614e-02f, 6.03774097e-03f, 9.52051394e-03f,
  9.81123466e-03f, -2.01956794e-01f, 1.16601577e-02f, 1.89526845e-02f, 8.70478675e-02f, 1.32840201e-01f, 1.84075534e-01f, 3.24216545e-01f, 9.70374718e-02f, -1.27497181e-01f,
  -1.89943746e-01f, 1.24400593e-01f, 1.19700611e-01f, -5.85316028e-03f, -2.35162377e-02f, -1.42133534e-01f, 2.00564265e-01f, 2.74485163e-02f, -1.26172572e-01f, 1.41029075e-01f,
  3.63446474e-01f, 1.34867340e-01f, 7.87046179e-02f, 2.67751031e-02f, 2.23949123e-02f, 4.78585735e-02f, 1.91482436e-02f, 2.56292000e-02f, -1.11701405e-02f, 6.63488954e-02f,
  7.49536231e-02f, 1.99585743e-02f, -1.50214061e-02f, 6.08051158e-02f, 6.46129400e-02f, 5.37064262e-02f, -5.59052802e-04f, 1.88858941e-01f, 1.87377170e-01f, 7.90585801e-02f,
  -9.26970392e-02f, 3.37920189e-02f, 1.18548512e-01f, 3.45832333e-02f, 5.36683537e-02f, 1.19506016e-01f, 1.44265769e-02f, 5.03665581e-02f, 2.01932844e-02f, 3.66749265e-03f,
  -2.10978966e-02f, 3.31162587e-02f, 2.28117723e-02f, -5.27808852e-02f, -4.92643714e-02f, 6.79790750e-02f, -2.32960302e-02f, 1.62846185e-02f, -7.06586838e-02f, 6.70394674e-02f,
  -2.38174405e-02f, -2.79331040e-02f, 2.89464220e-02f, 2.94595882e-02f, -1.73059590e-02f, 1.46797008e-03f, 9.84709430e-03f, 5.01008816e-02f, -3.87866311e-02f, 5.07310554e-02f,
  -1.00800185e-04f, 2.04221755e-02f, 5.58689237e-02f, -6.42099082e-02f, 1.76575109e-02f, -1.17781442e-02f, 6.98146876e-03f, -7.12112486e-02f, -9.51352157e-03f, 9.56887528e-02f,
  1.78568345e-02f, 1.93705950e-02f, 1.85428098e-01f, 2.85333395e-02f, 6.56114966e-02f, 7.07284883e-02f, -9.30783432e-03f, -2.88136248e-02f, 1.06181115e-01f, 4.61606681e-02f,
  -3.78080979e-02f, 1.23443939e-02f, 9.06714797e-02f, 1.05719268e-01f, 1.95069462e-02f, 5.92700504e-02f, -7.91323371e-03f, -4.04704027e-02f, 4.48249169e-02f, -4.28027334e-03f,
  -3.16992998e-02f, 8.58575553e-02f, 6.33654967e-02f, 1.27247080e-01f, -4.16141450e-02f, 5.24551310e-02f, 8.21882561e-02f, 1.88171323e-02f, 1.63754299e-01f, 7.63961002e-02f,
  -1.46370679e-01f, -2.40219384e-01f, 3.23055275e-02f, -1.41507909e-01f, -9.18293186e-03f, 8.06418359e-02f, 1.06864488e-02f, -1.25024423e-01f, -1.71457767e-01f, -7.60583952e-02f,
  -2.75087319e-02f, -2.91761905e-01f, -2.53107131e-01f, -2.20316887e-01f, -6.73739985e-02f, 1.95747409e-02f, -1.18414640e-01f, -1.29249334e-01f, -8.65180884e-03f, -9.46072191e-02f,
  -2.17690423e-01f, -2.31970221e-01f, -1.95767298e-01f, -1.02234378e-01f, -2.26051033e-01f, -2.50615120e-01f, -1.63123116e-01f, -9.91268679e-02f, -9.52021331e-02f, -2.47813493e-01f,
  8.15120190e-02f, 5.71692549e-03f, -2.02815048e-02f, -9.12572592e-02f, -2.07392946e-02f, 1.28491065e-02f, -3.83559912e-02f, -6.74093589e-02f, -3.22228782e-02f, -9.56632569e-02f,
  -3.60793546e-02f, -5.16683757e-02f, -5.26833460e-02f, -9.95278209e-02f, -8.66835713e-02f, -2.34994646e-02f, -5.24564348e-02f, -1.05008721e-01f, -1.07383184e-01f, -1.53879505e-02f,
  -6.18747100e-02f, 6.72413828e-03f, -3.53324153e-02f, -2.19990369e-02f, -2.29317490e-02f, -7.71894157e-02f, -6.56538308e-02f, -2.20340639e-02f, -5.35006858e-02f, -1.75093383e-01f,
  5.84362708e-02f, 1.46268591e-01f, -5.74920885e-03f, 4.07725796e-02f, 1.68764219e-02f, -3.64008397e-02f, -2.68672109e-02f, -2.36803247e-03f, 9.32270512e-02f, 3.05971391e-02f,
  -9.48331412e-03f, 8.96366239e-02f, 5.24189807e-02f, 4.55139987e-02f, -3.25559787e-02f, 1.65948763e-01f, 1.29783675e-01f, 4.05805819e-02f, -3.63193043e-02f, 1.58153236e-01f,
  -9.93099436e-03f, 1.00662157e-01f, -1.18431570e-02f, 7.30525032e-02f, -3.79018253e-03f, 5.31967916e-02f, 8.57978389e-02f, 9.76191014e-02f, 1.06317185e-01f, 6.46882728e-02f,
  -1.77259654e-01f, -2.14347579e-02f, -1.53730109e-01f, -8.31884891e-02f, 3.45805809e-02f, -1.42539814e-01f, -3.66762504e-02f, -6.89033493e-02f, -1.71776354e-01f, -7.12672919e-02f,
  -5.77690266e-02f, -1.38351694e-01f, -1.14429504e-01f, -2.06568420e-01f, -2.49405261e-02f, -2.51319520e-02f, -2.96432953e-02f, -1.48454890e-01f, -1.76577449e-01f, -7.42850360e-03f,
  -5.95896086e-03f, -9.06195790e-02f, 1.16214715e-02f, -5.31572402e-02f, -8.88236836e-02f, 7.88366701e-03f, -4.60770838e-02f, 1.72379066e-03f, -1.09413741e-02f, -9.09350142e-02f,
  -3.97191167e-01f, -2.46115744e-01f, -7.41834790e-02f, -2.10233226e-01f, -2.24224135e-01f, -2.36096401e-02f, -1.21676363e-01f, -1.01931006e-01f, -8.31636563e-02f, -2.21802339e-01f,
  -1.41966656e-01f, 1.53973743e-01f, 1.41314730e-01f, 3.09120342e-02f, 5.82883954e-02f, -4.93606739e-02f, -1.45492435e-01f, 1.53204510e-02f, 1.73414811e-01f, -9.81834135e-04f,
  -1.35239109e-01f, -9.92352292e-02f, -4.59662974e-02f, -5.64554222e-02f, -2.15067178e-01f, -5.18139964e-03f, -4.71930020e-02f, -1.56379983e-01f, -1.24711059e-01f, -3.62749130e-01f,
  -1.98321030e-01f, -2.39956751e-01f, 9.97121707e-02f, -1.08850382e-01f, -5.25930077e-02f, 1.88374482e-02f, -1.61245205e-02f, -9.24657732e-02f, 3.45725589e-03f, -2.87835039e-02f,
  -9.67076197e-02f, -7.81617872e-03f, -1.37418792e-01f, -4.20613942e-04f, -1.70914099e-01f, -4.10644561e-02f, 1.26144420e-02f, -6.60981387e-02f, -3.95460390e-02f, -2.38083373e-03f,
  -1.30615905e-01f, -1.12323575e-01f, -1.71732277e-01f, 5.91120310e-02f, -3.23549286e-02f, -9.06894356e-02f, -8.65862519e-02f, -2.12039072e-02f, -8.86140298e-03f, -2.58935869e-01f,
  -9.28443000e-02f, -2.25328114e-02f, -9.38616134e-03f, -4.69621345e-02f, 3.53254378e-03f, -5.80479950e-02f, -7.18636215e-02f, 4.02969727e-03f, 4.25406843e-02f, -7.54293427e-02f,
  5.70876002e-02f, -9.79019180e-02f, -2.60324795e-02f, -1.94982477e-02f, 5.83999082e-02f, -8.26924890e-02f, 3.59624065e-02f, 7.30379857e-03f, -2.13427693e-02f, 9.68093332e-03f,
  2.29789340e-03f, 3.53249852e-05f, -2.83348057e-02f, -7.88700767e-03f, -6.55916035e-02f, -2.12958008e-02f, 6.15046881e-02f, 8.68185163e-02f, -4.56092209e-02f, -1.08581446e-01f,
  3.94940563e-02f, 1.76000521e-01f, -1.37812912e-01f, -8.34344886e-03f, -1.97166894e-02f, -8.60335976e-02f, -4.54794206e-02f, -3.36067602e-02f, -5.71574569e-02f, -6.74211904e-02f,
  -1.01431631e-01f, 9.67748743e-03f, -1.13425747e-01f, -9.96852946e-03f, 3.15000676e-02f, -8.11497122e-02f, -7.34604523e-02f, -9.53777134e-02f, 7.02852383e-03f, -5.58463223e-02f,
  -8.64781961e-02f, 1.83976330e-02f, -4.78394367e-02f, -7.72598684e-02f, -1.04952522e-01f, 4.15988499e-03f, -8.53232816e-02f, -1.15133554e-01f, 5.33448756e-02f, -4.23455890e-03f,
  1.24373533e-01f, -5.66266812e-02f, -2.19987288e-01f, 2.70883981e-02f, 1.06211685e-01f, 5.60328253e-02f, 5.36484681e-02f, 9.88125056e-02f, 6.03977125e-03f, -1.95020344e-02f,
  1.99481994e-02f, 4.20379713e-02f, -6.24013804e-02f, 7.44572878e-02f, -5.35420366e-02f, -9.82838422e-02f, -2.77746379e-01f, -5.32090776e-02f, 8.60218704e-02f, 9.99983996e-02f,
  1.49531662e-01f, 6.84152469e-02f, -2.49774707e-03f, 3.55039351e-02f, 1.28351972e-02f, 9.37187001e-02f, -6.97803646e-02f, -4.59292382e-02f, -1.91594251e-02f, -1.77942395e-01f,
  -2.40450010e-01f, -1.64744139e-01f, -5.40629495e-03f, -7.03564957e-02f, -4.13549989e-02f, -1.59115523e-01f, -8.10448825e-02f, -2.60630567e-02f, -3.82169671e-02f, -6.83620572e-02f,
  -7.84474760e-02f, -7.06915930e-02f, -7.95651674e-02f, -1.20934941e-01f, -5.75919524e-02f, -2.95627322e-02f, -1.76876158e-01f, -1.66715130e-01f, -1.98806286e-01f, -1.78681150e-01f,
  -1.30545199e-01f, 3.66963446e-02f, -1.61789954e-01f, -3.66536453e-02f, -1.77011788e-01f, -1.55370355e-01f, -1.48023590e-01f, -5.86905964e-02f, -7.91975334e-02f, -1.45825833e-01f,
  8.46071541e-02f, 1.32780567e-01f, 1.44938961e-01f, -3.15963887e-02f, 1.27259821e-01f, 1.70750767e-01f, -1.06621115e-02f, 4.61790487e-02f, 1.18648022e-01f, 3.10222562e-02f,
  1.89064190e-01f, 9.45556015e-02f, 6.40831366e-02f, 9.44941863e-02f, 4.24602963e-02f, 6.71445578e-02f, 1.28040150e-01f, 1.34496480e-01f, 8.03167373e-02f, 1.46904975e-01f,
  3.90557349e-02f, 6.76885992e-02f, 1.46312952e-01f, 9.11987573e-02f, 7.50882551e-02f, 4.58940417e-02f, 1.06156170e-01f, 7.16206878e-02f, 1.09771498e-01f, 5.00492612e-03f,
  2.77761947e-02f, -1.66329406e-02f, -1.55805930e-01f, -1.25430971e-01f, -3.00950594e-02f, -2.73531601e-02f, -3.53590101e-02f, -8.49947110e-02f, -5.19666784e-02f, -8.76185542e-04f,
  -1.46478964e-02f, -7.37666860e-02f, -6.04568645e-02f, -2.19357852e-02f, 4.55676280e-02f, -4.66987789e-02f, -1.72711626e-01f, -5.99803142e-02f, -1.22206025e-01f, -4.72771488e-02f,
  -6.36761785e-02f, 2.62304372e-03f, -1.34623870e-01f, -1.77279357e-02f, -9.62434486e-02f, -4.00079489e-02f, -1.01163231e-01f, -1.28702866e-02f, -1.05928749e-01f, -1.73013940e-01f,
  -4.91011590e-01f, 4.31934863e-01f, 1.45008355e-01f, 3.27415541e-02f, 6.15893118e-02f, -3.13735455e-02f, 6.43789247e-02f, 2.26037521e-02f, 2.49083359e-02f, 1.06142506e-01f,
  1.69576064e-01f, -2.23465636e-02f, 6.34257346e-02f, 6.93207532e-02f, -1.15546037e-03f, 1.40196085e-01f, 1.70036748e-01f, -1.47053450e-01f, -3.50533903e-01f, -1.75668940e-01f,
  6.91080615e-02f, 3.06239631e-02f, -1.64120093e-01f, -5.62631525e-02f, 9.00387168e-02f, 1.24295112e-02f, 1.05510786e-01f, 2.10012034e-01f, 2.42905289e-01f, 4.10751700e-01f,
  4.94812056e-02f, 3.46638896e-02f, -4.21710014e-02f, -1.06452918e-02f, 1.39535829e-01f, -6.11301395e-04f, -6.14869855e-02f, -3.09674386e-02f, -3.06999348e-02f, -2.56515909e-02f,
  1.35308564e-01f, 4.48785722e-03f, -1.84522327e-02f, 4.57900316e-02f, 5.10519519e-02f, -3.24150398e-02f, 1.10378183e-01f, 4.67496626e-02f, 6.73067346e-02f, 9.84324217e-02f,
  1.09206960e-01f, 1.04404241e-01f, 8.38074386e-02f, 1.09866008e-01f, 1.20133750e-01f, -4.83791046e-02f, 1.40712529e-01f, 4.90345843e-02f, 2.22071595e-02f, 1.76760256e-01f,
  -5.53405732e-02f, -5.31356409e-02f, 7.55405501e-02f, -3.17820087e-02f, -3.87035273e-02f, -8.54560360e-03f, -3.55301090e-02f, 5.64508000e-03f, 1.67092569e-02f, -4.00816277e-02f,
  1.83925405e-02f, -3.74996997e-02f, 1.01774256e-03f, -1.79107941e-04f, 4.93511185e-02f, 6.47666454e-02f, -5.08604664e-03f, 5.49260415e-02f, -1.60779897e-02f, -6.15430549e-02f,
  -5.48279174e-02f, -9.18817427e-03f, -1.35489656e-02f, -5.09347022e-02f, 4.94365729e-02f, 4.19409573e-02f, -1.39623880e-02f, -3.75473425e-02f, -4.55763042e-02f, -1.45212421e-02f,
  -1.23745903e-01f, 5.32816015e-02f, 1.84915513e-02f, 8.07146728e-02f, 2.58831736e-02f, 7.77465776e-02f, 1.78794876e-01f, 4.85125855e-02f, 4.63297479e-02f, 7.21022263e-02f,
  9.97876972e-02f, -5.80053702e-02f, 1.74291804e-02f, 2.06640828e-02f, 1.01036404e-03f, 1.65049043e-02f, 1.31052792e-01f, -1.01898601e-02f, 9.52293128e-02f, 1.25730693e-01f,
  1.07616708e-01f, 6.16492815e-02f, -5.84771372e-02f, 1.32885158e-01f, 2.09272821e-02f, 4.22670553e-03f, 7.59679675e-02f, -1.38905169e-02f, -9.41541195e-02f, -3.72178964e-02f,
  -1.23240590e-01f, -1.07033767e-01f, -1.95517942e-01f, -3.47107679e-01f, -1.99364588e-01f, -7.13615343e-02f, -1.21466748e-01f, 3.36682722e-02f, -6.34845048e-02f, -1.90303862e-01f,
  -4.50573117e-02f, -6.36155456e-02f, -9.67006981e-02f, 5.99414036e-02f, 1.23574637e-01f, -6.56399429e-02f, -7.68745765e-02f, 4.61145565e-02f, 1.48194537e-01f, -6.57948032e-02f,
  -1.74914181e-01f, -1.68381125e-01f, 6.31418675e-02f, 3.34238000e-02f, -1.05625451e-01f, -4.66398746e-02f, -1.17601670e-01f, -4.75863516e-02f, -7.51354843e-02f, -1.28023118e-01f,
  -1.59267351e-01f, -4.45295982e-02f, 1.61297143e-01f, 9.80191529e-02f, -3.92127521e-02f, 1.22280225e-01f, 1.06927687e-02f, 1.32012412e-01f, 1.71223164e-01f, 1.17682450e-01f,
  -8.95691663e-02f, 1.03083976e-01f, 2.62264325e-03f, 6.60338625e-02f, 1.19821697e-01f, 1.45421885e-02f, 1.32261738e-01f, 4.06731330e-02f, 1.39877528e-01f, 5.84024191e-02f,
  9.58919898e-02f, 5.45517318e-02f, 9.59164724e-02f, 2.11852908e-01f, 2.14120761e-01f, -1.21981185e-02f, 1.59713477e-01f, 1.64230913e-01f, 1.82701111e-01f, 1.81217015e-01f,
  -8.19299668e-02f, 1.05939150e-01f, -5.77333104e-03f, -1.10086780e-02f, 4.30334583e-02f, 1.19261695e-02f, -7.04674348e-02f, -1.38082318e-02f, 7.05761388e-02f, -2.80940123e-02f,
  -4.86908481e-02f, 1.76434796e-02f, 4.97443229e-02f, 5.17847715e-04f, -3.47458608e-02f, -9.41345468e-02f, -2.50109229e-02f, -5.36002181e-02f, -2.92438641e-03f, -1.67520791e-02f,
  -7.77516514e-02f, 7.02226833e-02f, -9.34971347e-02f, 8.15661252e-02f, -9.28154739e-04f, 1.73460972e-02f, 2.14035660e-02f, 1.20611005e-02f, 1.31748281e-02f, -8.11564848e-02f,
  3.08980551e-02f, 8.47282261e-02f, 4.00674418e-02f, 9.14492533e-02f, 4.56035789e-03f, 8.91678333e-02f, 2.29195855e-03f, 1.81241080e-01f, 6.60098195e-02f, 8.07742849e-02f,
  4.69177514e-02f, 8.80983192e-03f, 1.00331344e-01f, 1.36058062e-01f, 1.60163213e-02f, 4.35950235e-02f, 1.98095329e-02f, -1.07336976e-02f, 1.19400404e-01f, 6.68451637e-02f,
  9.59794745e-02f, 6.36363849e-02f, 5.44694327e-02f, 1.39723450e-01f, 2.11410448e-01f, 9.34567899e-02f, 1.69084400e-01f, 1.55660048e-01f, 1.57482967e-01f, 1.90346733e-01f,
  2.16290504e-01f, -4.33773771e-02f, 2.67795891e-01f, 3.37015912e-02f, -2.93743107e-02f, 5.21399193e-02f, -1.92258786e-03f, -7.69916475e-02f, -3.36333029e-02f, 8.96182433e-02f,
  -1.02055036e-01f, -1.72802284e-01f, -4.38378341e-02f, -8.93698037e-02f, 7.18545541e-02f, 2.19054371e-02f, 2.40819510e-02f, 7.90179297e-02f, 1.94374204e-01f, -6.39591292e-02f,
  -9.10744071e-02f, 1.06054239e-01f, 2.56535292e-01f, -5.54790581e-03f, -6.14642873e-02f, -6.44263402e-02f, -8.15353841e-02f, 2.70917919e-02f, -7.40079209e-02f, -2.62111574e-01f,
  8.06145892e-02f, 1.62489824e-02f, -2.70519685e-02f, 4.92915474e-02f, 8.07652529e-03f, -3.78332660e-02f, -5.88708855e-02f, 2.48806328e-02f, 2.92197987e-02f, 3.12200803e-02f,
  -4.89181280e-02f, -9.08547789e-02f, -8.25924650e-02f, -6.15511797e-02f, -3.99393104e-02f, 6.31251978e-03f, 3.63264084e-02f, 1.17699550e-02f, 1.40044314e-03f, 1.27027854e-02f,
  -8.92179683e-02f, -1.04106560e-01f, 7.93669000e-02f, -9.00086462e-02f, -2.41886042e-02f, -8.74413550e-02f, 1.24484925e-02f, -2.84219328e-02f, 2.28071795e-03f, -9.55711678e-02f,
  -2.83621196e-02f, 3.58637422e-03f, 8.92157033e-02f, 6.01535216e-02f, 1.09159432e-01f, 9.98668224e-02f, 9.48139206e-02f, 1.40475363e-01f, 1.74219329e-02f, 1.14559665e-01f,
  1.73829108e-01f, 5.76137900e-02f, 1.10656641e-01f, 9.79039818e-02f, 1.78215429e-02f, 1.12535909e-01f, 1.36191398e-01f, 4.05300334e-02f, 1.37902081e-01f, 9.56051946e-02f,
  5.10460027e-02f, -5.54383872e-03f, 1.17811717e-01f, -5.06856572e-03f, 1.02768447e-02f, 8.00642744e-02f, 2.15965826e-02f, 1.06971748e-01f, 1.16746023e-01f, 6.81961142e-03f,
  -1.30779650e-02f, 3.96651924e-02f, 7.49585629e-02f, 4.09216210e-02f, 1.06896169e-01f, 1.42068388e-02f, 4.81338501e-02f, 5.49954548e-02f, 2.66067050e-02f, 1.14742573e-02f,
  3.25694717e-02f, 1.40924640e-02f, 7.68319219e-02f, 1.84919182e-02f, 7.64926970e-02f, 4.77460735e-02f, -2.93440763e-02f, -6.88763633e-02f, 1.07321013e-02f, 2.84489207e-02f,
  -5.13203107e-02f, 5.60047813e-02f, 4.90899198e-02f, 5.56903146e-02f, -5.81012107e-03f, 6.80307969e-02f, 4.23002318e-02f, -3.97620499e-02f, 1.85259715e-01f, 1.34197086e-01f,
  5.78678176e-02f, 3.71444214e-04f, -2.77477596e-03f, -1.17418468e-01f, 5.38500883e-02f, 1.16651610e-01f, 2.52127767e-01f, 4.31227079e-03f, -1.29903466e-01f, 1.76148206e-01f,
  -5.34249842e-02f, -1.67717233e-01f, -5.00964783e-02f, -9.10663977e-02f, 2.32394170e-02f, 3.31136614e-01f, 3.19062114e-01f, 4.27132547e-02f, -1.23718761e-01f, -1.36827216e-01f,
  4.93288133e-03f, 3.24264877e-02f, 3.60952467e-02f, -1.13766983e-01f, -9.15411562e-02f, -1.12188607e-01f, -3.51959793e-03f, 7.48696849e-02f, -3.60663771e-03f, -4.90894578e-02f,
  1.63334310e-02f, -9.14278552e-02f, -1.24324083e-01f, -2.14181975e-01f, -1.34278774e-01f, -1.16395213e-01f, -4.04072441e-02f, -7.51444697e-02f, -9.39215571e-02f, -1.56503484e-01f,
  -2.12921232e-01f, -8.12452361e-02f, -1.81533620e-01f, -2.03280360e-01f, -1.79960698e-01f, -1.89235538e-01f, -1.88623406e-02f, -1.40492141e-01f, -1.35549024e-01f, -7.56456107e-02f,
  -2.25524098e-01f, -2.24065185e-01f, -9.72850844e-02f, -1.45826191e-01f, -6.28807098e-02f, -1.51403442e-01f, -1.67218283e-01f, -1.08012907e-01f, -3.85437012e-02f, 1.76397767e-02f,
  2.68412195e-02f, -3.50994468e-02f, 1.16230868e-01f, 4.68610935e-02f, 9.49195176e-02f, 9.25713703e-02f, 8.41908231e-02f, 8.11082348e-02f, 1.45196706e-01f, 1.23093687e-01f,
  3.56831402e-02f, -2.85632219e-02f, 3.16252857e-02f, 1.31490886e-01f, 1.64539129e-01f, -2.07271166e-02f, 5.07731782e-03f, 3.16948518e-02f, 2.64194682e-02f, 9.24931616e-02f,
  -3.53209786e-02f, 2.04959773e-02f, -8.12283009e-02f, -7.69320577e-02f, 8.70296061e-02f, 5.71857989e-02f, -1.12040201e-02f, 5.76105900e-02f, -4.99627329e-02f, -3.22414488e-02f,
  6.38299733e-02f, -8.88749957e-02f, -1.07936867e-01f, 9.60520934e-03f, -1.14462189e-01f, -9.62349474e-02f, 8.14296454e-02f, 3.07261739e-02f, -1.24876253e-01f, -8.33304971e-02f,
  -2.20422938e-01f, -1.82402164e-01f, -6.78967014e-02f, -5.14751300e-02f, -1.03313997e-01f, -5.94998412e-02f, -4.47308905e-02f, 3.35105471e-02f, -1.46333888e-01f, -1.57370731e-01f,
  -1.03954803e-02f, 4.99184825e-04f, 3.09424587e-02f, -1.99892707e-02f, -1.30301788e-01f, -7.20140636e-02f, 3.72653268e-02f, -1.07878707e-01f, -2.47923080e-02f, 1.92839473e-01f,
  1.66579932e-01f, 3.98920387e-01f, -1.02073260e-01f, 1.06891535e-01f, -7.19534382e-02f, -8.86352584e-02f, 3.39055270e-01f, 3.99080710e-03f, -4.61579077e-02f, 2.03780085e-01f,
  -1.82022862e-02f, -2.54358560e-01f, -1.55668676e-01f, -1.29326627e-01f, -1.35864794e-01f, 2.01088861e-01f, 1.21519312e-01f, -1.56979799e-01f, -3.20527583e-01f, -2.15809401e-02f,
  5.81992678e-02f, 1.78349644e-01f, 1.21211946e-01f, -2.66533829e-02f, 1.12865664e-01f, -2.66296446e-01f, 4.93664145e-02f, 7.99130052e-02f, 1.74079966e-02f, 2.26899207e-01f,
  -1.78565964e-01f, 2.26191536e-01f, -2.30908588e-01f, -7.09228069e-02f, -3.10464781e-02f, 4.85756435e-02f, 1.10466303e-02f, 5.15292101e-02f, 7.90878609e-02f, 7.67565221e-02f,
  1.53282816e-02f, 9.56599414e-02f, -5.82961477e-02f, 4.28734832e-02f, 1.23009302e-01f, -2.96828267e-03f, 7.41356537e-02f, 3.96617725e-02f, -1.11614309e-01f, -2.01233923e-02f,
  6.47917092e-02f, 1.47380546e-01f, -4.92591085e-03f, 1.11559946e-02f, -1.10071316e-01f, -1.88507438e-01f, -5.71349114e-02f, -5.77361956e-02f, -1.29519030e-01f, 1.69718504e-01f,
  -3.55117843e-02f, 1.95936654e-02f, 2.19749361e-02f, 9.26340148e-02f, 1.09399110e-01f, -3.75255458e-02f, -9.32618103e-04f, 5.03472891e-03f, -3.53867672e-02f, 7.88879097e-02f,
  -2.16916259e-02f, 5.16365655e-02f, -1.38643850e-02f, 7.79287666e-02f, 8.47964175e-03f, 3.95716801e-02f, -2.95221880e-02f, 7.57235587e-02f, -5.59443720e-02f, 4.29008342e-02f,
  2.58951373e-02f, -9.92979929e-02f, 5.99616915e-02f, 2.48296056e-02f, 2.51972340e-02f, 2.81185601e-02f, 9.20655578e-02f, 7.60455756e-03f, 8.90322924e-02f, 1.38785103e-02f,
  -8.53855386e-02f, -1.77701131e-01f, -2.03222055e-02f, -5.90602569e-02f, -8.28979462e-02f, -1.39261261e-01f, -3.09633743e-02f, -5.14299981e-02f, 1.44074848e-02f, -3.36761214e-02f,
  5.33875357e-03f, -6.48285903e-04f, 1.99097488e-02f, -9.88616981e-03f, 1.53996078e-02f, -9.60734189e-02f, 5.37630245e-02f, -2.47323103e-02f, -8.57955068e-02f, 3.79850343e-02f,
  -6.87353313e-02f, -2.31154896e-02f, -3.99246663e-02f, -8.22969526e-02f, -2.41218880e-02f, -8.37813094e-02f, -3.75009589e-02f, -1.59072354e-02f, -1.68258518e-01f, 1.39813066e-01f,
  2.74967160e-02f, 1.89669743e-01f, 2.29190797e-01f, 5.13593741e-02f, 1.02365777e-01f, -1.44559130e-01f, -1.02290303e-01f, -2.52650589e-01f, -1.16295457e-01f, 1.59161404e-01f,
  -1.11969665e-01f, -2.47525349e-01f, -1.49047524e-01f, -2.08213300e-01f, -1.48661315e-01f, 7.39774555e-02f, 2.90573686e-01f, 1.14065342e-01f, -2.49218702e-01f, -2.01797917e-01f,
  -8.59273672e-02f, 1.12265237e-01f, 1.65571235e-02f, 2.37938040e-03f, -2.70998199e-02f, -8.45879242e-02f, 1.68117121e-01f, 7.70110860e-02f, -7.97701329e-02f, 2.08638042e-01f,
  2.07484081e-01f, 1.71665698e-01f, -4.68469970e-02f, -2.00822912e-02f, 2.21956577e-02f, -1.58344418e-01f, -4.85473499e-03f, 9.52466801e-02f, -6.34651119e-03f, 4.99622822e-02f,
  5.03116213e-02f, -9.92801785e-02f, 3.24121900e-02f, 3.86495702e-02f, -1.11451469e-01f, 1.15050154e-03f, 5.54530956e-02f, -2.78447717e-02f, 1.33699700e-02f, -1.85038149e-02f,
  1.00437097e-01f, 5.64435050e-02f, -4.91464213e-02f, -1.09168246e-01f, -8.41801986e-02f, 6.56212401e-03f, -6.90364018e-02f, -4.40287329e-02f, -1.43022597e-01f, 3.15898582e-02f,
  7.05264451e-04f, 7.57119730e-02f, 2.55868305e-02f, 1.10515930e-01f, -2.52446672e-03f, 8.34176093e-02f, 6.01209626e-02f, 3.76238301e-02f, -1.54881403e-02f, 3.87185551e-02f,
  9.45240408e-02f, 5.25574386e-03f, 6.78119361e-02f, 1.22100189e-02f, 1.55589869e-02f, 1.20700151e-01f, -1.02140635e-01f, 1.66289043e-02f, 2.13211309e-02f, -6.54249080e-03f,
  -1.49169946e-02f, -7.33936429e-02f, 7.38820210e-02f, -2.89430562e-02f, -7.87947029e-02f, -1.99142583e-02f, 3.01810000e-02f, 2.95493044e-02f, 1.01192072e-02f, 1.26433432e-01f,
  -1.47827730e-01f, -4.02589180e-02f, 6.74702302e-02f, -9.52362642e-02f, -1.48279322e-02f, 1.29226688e-02f, -2.23581884e-02f, -2.54024994e-02f, -5.52393831e-02f, -2.71055871e-03f,
  -4.83691469e-02f, -3.61186117e-02f, 2.86024101e-02f, 2.73543340e-03f, -1.16664797e-01f, -1.97350211e-03f, 4.86282296e-02f, 5.88539168e-02f, -1.13592379e-01f, -5.13689294e-02f,
  4.35132869e-02f, -1.69612929e-01f, -1.88754484e-01f, 8.13474730e-02f, 5.23884781e-04f, -2.09185719e-01f, -1.12243153e-01f, -1.73374489e-01f, -2.34443769e-01f, -3.33899073e-02f,
  -2.09379554e-01f, -6.11580573e-02f, 3.81973207e-01f, -2.30882511e-01f, 2.24821836e-01f, 3.97938311e-01f, 3.05734545e-01f, 1.36457592e-01f, 2.45450493e-02f, -1.31849749e-02f,
  5.45428209e-02f, -6.85321987e-02f, -9.75843577e-04f, 1.59269627e-02f, 1.58162042e-01f, -6.76075509e-03f, -2.09804460e-01f, -7.54853114e-02f, 2.03053981e-01f, 8.67786556e-02f,
  -9.54135284e-02f, -1.89597309e-01f, -1.00916788e-01f, -9.42681208e-02f, -1.28875151e-01f, 4.47675958e-02f, 1.16708083e-02f, -4.09498625e-02f, 1.56153068e-01f, -3.06553245e-01f,
  4.76142094e-02f, 1.17308713e-01f, 5.17967604e-02f, -8.80922675e-02f, 6.72138929e-02f, 3.54276560e-02f, 1.30597511e-02f, -5.00758179e-02f, -2.71596592e-02f, 5.15567549e-02f,
  -2.27009412e-02f, 1.21447630e-02f, 4.11156304e-02f, 2.87160482e-02f, -6.45036995e-03f, -4.51714694e-02f, -2.92303450e-02f, 1.76193956e-02f, 2.12577339e-02f, 1.39614269e-01f,
  -3.04573178e-02f, -3.15143652e-02f, 1.47018284e-01f, 5.15746139e-02f, 9.11065564e-02f, 8.85597765e-02f, 1.19451389e-01f, 5.82826100e-02f, 1.97733298e-01f, -7.09531456e-02f,
  -9.79517773e-02f, -4.28906828e-02f, 1.01930238e-01f, 6.35134727e-02f, 6.19628653e-03f, 3.75847854e-02f, 2.99357958e-02f, -2.73183323e-02f, -2.92918123e-02f, -3.49792987e-02f,
  2.38010641e-02f, -6.75213188e-02f, 1.27006117e-02f, 3.85912471e-02f, 2.51512136e-02f, -7.06516802e-02f, 2.87054852e-02f, -5.23144938e-02f, 2.71593705e-02f, 5.70945069e-02f,
  5.35027543e-03f, -4.30339947e-03f, -7.83702079e-03f, 3.44444700e-02f, -4.38693948e-02f, -5.61977690e-03f, -4.36338931e-02f, -2.83846464e-02f, 5.77279367e-02f, 2.47428752e-02f,
  -1.81564525e-01f, 2.11320102e-01f, -1.14325061e-01f, -7.80455172e-02f, 3.77412848e-02f, 4.52915244e-02f, -5.10780364e-02f, 4.76517752e-02f, 3.35035436e-02f, 6.42626509e-02f,
  1.40138581e-01f, 5.94433099e-02f, 5.64156333e-03f, 2.44776476e-02f, 4.45480458e-03f, 3.33684720e-02f, 1.25506930e-02f, 2.60758530e-02f, 9.40873697e-02f, 8.33619758e-02f,
  -6.43241182e-02f, 3.54762077e-02f, 7.55660832e-02f, 1.31860012e-02f, -5.80752315e-03f, 1.07710496e-01f, 8.69933218e-02f, 3.94388027e-02f, 1.43559128e-01f, -5.85672669e-02f,
  1.78315088e-01f, 2.43067853e-02f, 1.37523994e-01f, 9.54027399e-02f, 1.84056044e-01f, 8.74428600e-02f, 1.17291689e-01f, 1.25439882e-01f, 2.27569602e-02f, 1.02138691e-01f,
  1.08720351e-03f, 6.29582480e-02f, 1.59014896e-01f, 1.02283806e-01f, 7.10740760e-02f, 1.08197838e-01f, 2.03493267e-01f, 1.80973426e-01f, 2.17674509e-01f, 9.03412178e-02f,
  7.00957477e-02f, 1.96962561e-02f, -7.86091238e-02f, 8.83713216e-02f, 1.05944514e-01f, 1.39583230e-01f, -3.87821868e-02f, 1.31741296e-02f, -4.80751321e-02f, 8.07990208e-02f,
  2.05855832e-01f, 3.40083204e-02f, 9.94433910e-02f, 9.10733268e-02f, -4.46554885e-04f, 9.48127285e-02f, 2.16408484e-02f, 8.32907036e-02f, 7.96838179e-02f, 1.03941813e-01f,
  1.08538955e-01f, 2.25150771e-02f, -2.34519951e-02f, 5.15404195e-02f, -4.52105924e-02f, 4.75514159e-02f, 4.95867338e-03f, -3.10820490e-02f, 7.36569315e-02f, 1.06483191e-01f,
  -1.33870253e-02f, -3.72706689e-02f, 1.59649774e-01f, 7.29334056e-02f, 8.00757855e-02f, 3.84993292e-02f, -5.09360172e-02f, 5.84766641e-02f, 9.15511698e-03f, 1.59888677e-02f,
  -1.04301304e-01f, -2.22491734e-02f, -4.70237024e-02f, -8.02758634e-02f, 2.10115314e-02f, 7.85404593e-02f, -9.31394473e-03f, 1.22093149e-02f, 6.23885281e-02f, -1.25528993e-02f,
  3.40202898e-02f, -9.19285193e-02f, 1.94877256e-02f, -4.06120382e-02f, 7.10906880e-03f, 6.95670396e-02f, 6.35463372e-03f, -3.16569097e-02f, 2.56973337e-02f, 1.51514523e-02f,
  -2.11544670e-02f, -1.32188043e-02f, 4.22549099e-02f, 9.99048278e-02f, 5.27159572e-02f, 4.43134643e-02f, -5.06080640e-03f, -3.32242362e-02f, 4.48085889e-02f, 1.38412684e-03f,
  1.40905917e-01f, -2.18976036e-01f, 1.01151101e-01f, -9.97753162e-03f, 1.32401576e-02f, -6.38999566e-02f, -5.32252342e-02f, -6.51342794e-02f, 5.37460148e-02f, 1.36169642e-02f,
  8.28708038e-02f, 5.78066111e-02f, 1.07339568e-01f, -7.12228417e-02f, 2.29646470e-02f, 7.83512965e-02f, -5.87790310e-02f, 5.48195504e-02f, 9.39858984e-03f, 4.14041849e-03f,
  8.65573809e-02f, 1.02803528e-01f, 1.15020044e-01f, 1.39305294e-01f, -5.93645312e-03f, 1.86627269e-01f, 5.06911911e-02f, 8.10278021e-03f, 2.65879612e-02f, 1.42231300e-01f,
  1.62220299e-02f, 2.88247347e-01f, 2.55336940e-01f, 2.60186940e-02f, 1.73667103e-01f, 2.19119847e-01f, 4.34541881e-01f, 2.54917443e-02f, -7.93812945e-02f, 1.49515659e-01f,
  1.13423597e-02f, -1.70805782e-01f, -8.90762135e-02f, -3.87538224e-02f, -1.71035994e-02f, 2.67915308e-01f, 3.03602993e-01f, 2.65304800e-02f, -1.41722113e-01f, 5.20452596e-02f,
  -3.57366563e-03f, 3.78262177e-02f, -9.94113386e-02f, -2.28801393e-03f, 1.38556600e-01f, -1.04814760e-01f, 4.79521491e-02f, -3.28332633e-02f, 1.33382380e-01f, 2.50799477e-01f,
  1.58858076e-01f, -6.66687042e-02f, 9.69874766e-03f, -3.49625088e-02f, 1.03807107e-01f, 4.90965992e-02f, 5.61676361e-02f, 5.29305749e-02f, 2.49674451e-02f, 7.60339126e-02f,
  -1.15206623e-02f, 2.96626217e-03f, -4.70977686e-02f, -5.92103377e-02f, 3.51754241e-02f, -2.69258837e-03f, -8.76503438e-02f, -2.28733346e-02f, -5.16858809e-02f, 6.84397668e-02f,
  1.83312744e-02f, -4.56149690e-03f, 8.56940001e-02f, -3.36673297e-02f, 1.19169084e-02f, -1.07851490e-01f, 9.36236307e-02f, -1.51772164e-02f, -6.81602350e-03f, 7.87368044e-03f,
  2.45625954e-02f, -1.77078845e-03f, -4.26915027e-02f, -1.29830325e-02f, -8.42608288e-02f, -9.20063853e-02f, 1.13858760e-03f, 2.26282398e-03f, -6.80909827e-02f, -4.98744361e-02f,
  -1.17566265e-01f, -7.17192739e-02f, -9.37929749e-02f, -2.97524109e-02f, -6.80463091e-02f, -1.27095491e-01f, -1.05099283e-01f, -2.44525429e-02f, -6.38361499e-02f, -9.75514501e-02f,
  -9.76969451e-02f, -5.23534380e-02f, -9.13918316e-02f, -5.04286401e-03f, 1.67609211e-02f, -1.41110525e-01f, -1.06823713e-01f, -1.82906523e-01f, -1.34693041e-01f, -3.63064967e-02f,
  1.60435978e-02f, 1.19595667e-02f, 8.20197538e-02f, 1.32530585e-01f, 6.40301928e-02f, 4.85697873e-02f, -2.71606422e-03f, 1.01098694e-01f, 6.10681139e-02f, 1.18398055e-01f,
  9.85171124e-02f, 1.11048698e-01f, 7.60554448e-02f, 5.89953065e-02f, 3.03665921e-02f, -1.16379010e-02f, 8.43039006e-02f, 6.87190071e-02f, -2.00298838e-02f, 5.36358766e-02f,
  1.09836936e-01f, 1.96094066e-01f, 5.88768572e-02f, 1.01280212e-01f, 1.90851055e-02f, 8.12018216e-02f, 1.62312791e-01f, 1.01944655e-01f, 5.95457740e-02f, 2.03031033e-01f,
  -2.50433862e-01f, 8.98734182e-02f, 8.25615004e-02f, -1.88336093e-02f, 1.32799163e-01f, -4.64274548e-02f, -1.59224257e-01f, -1.53286487e-01f, 1.20869458e-01f, 6.25768770e-03f,
  7.05787912e-02f, 3.41011994e-02f, 1.73580125e-02f, 1.19306214e-01f, -1.97136730e-01f, 5.50869331e-02f, 8.84201601e-02f, -4.19999361e-02f, -1.14079304e-01f, -3.97275127e-02f,
  -4.39322032e-02f, -1.21910416e-01f, -1.35036353e-02f, 6.51597455e-02f, 1.55495852e-01f, 1.07108951e-01f, 1.66840851e-01f, 1.63646221e-01f, 1.59928441e-01f, 2.24376425e-01f,
  5.86315580e-02f, 7.09090829e-02f, 1.83845088e-02f, 2.01384984e-02f, 1.60329297e-01f, -6.78569376e-02f, 1.60505734e-02f, 4.07270677e-02f, 6.94065094e-02f, 1.26720697e-01f,
  8.34886655e-02f, 1.15713529e-01f, -4.29340862e-02f, 2.32484210e-02f, 4.74183727e-03f, 6.86542243e-02f, 1.81028321e-01f, -1.05466892e-03f, -2.07333639e-02f, 1.35871023e-01f,
  4.69474830e-02f, 8.99774581e-02f, 3.42501216e-02f, 1.06083944e-01f, 4.19959687e-02f, 4.53602932e-02f, 4.04916257e-02f, 1.27181411e-01f, 1.31435201e-01f, 1.38131633e-01f,
  -9.51525196e-02f, -1.04128897e-01f, 7.70381391e-02f, -1.10482417e-01f, -6.92177564e-02f, -7.80455694e-02f, 3.12117301e-02f, -9.48048085e-02f, -5.49890548e-02f, -8.81061181e-02f,
  -7.93524012e-02f, -9.53205973e-02f, -5.36595881e-02f, -1.37670651e-01f, -2.20432486e-02f, -1.06162041e-01f, -9.40068290e-02f, -1.05361499e-01f, -7.97332153e-02f, -3.34142596e-02f,
  -5.79026267e-02f, 3.30526195e-02f, 1.59351639e-02f, 1.42721469e-02f, -4.71999645e-02f, -2.49919016e-02f, -1.21470764e-02f, -1.11380912e-01f, -1.20701373e-01f, -3.15523781e-02f,
  -2.09866494e-01f, 8.14922154e-02f, 1.92638095e-02f, -2.86570974e-02f, 9.38766971e-02f, 5.18349819e-02f, 6.98046461e-02f, 1.51874542e-01f, 1.15001842e-01f, -5.29427417e-02f,
  -2.41199285e-02f, 5.17307129e-03f, 6.11165427e-02f, 6.80673793e-02f, 2.64275633e-02f, 2.93424223e-02f, 5.05415490e-03f, 7.99630657e-02f, -1.67051479e-02f, 9.83140692e-02f,
  -2.80709155e-02f, -3.58539596e-02f, -1.32633463e-01f, -2.40467042e-02f, 3.70311812e-02f, -1.13065429e-01f, -7.29103014e-02f, -1.04308864e-02f, -1.09638698e-01f, -1.99672893e-01f,
  -3.94763470e-01f, -1.95443407e-01f, -1.75694451e-01f, -1.73554182e-01f, -1.19848065e-01f, -3.07622641e-01f, -4.15315449e-01f, -3.68887246e-01f, -1.35136247e-01f, -1.49279803e-01f,
  -1.91751629e-01f, -2.84323096e-02f, -1.10701159e-01f, -9.79097709e-02f, -1.73283443e-01f, -1.78544641e-01f, -8.03537071e-02f, -7.45493174e-02f, -1.73761711e-01f, -1.25318587e-01f,
  9.78613039e-04f, -6.91808462e-02f, -8.43077153e-02f, -8.18684176e-02f, -3.54151651e-02f, -9.90026817e-02f, -3.41397300e-02f, 1.16300816e-02f, -4.56169657e-02f, 2.11204827e-01f,
  -9.13853869e-02f, -1.23690411e-01f, -1.74239576e-01f, -3.34504768e-02f, -2.53904350e-02f, -5.38252518e-02f, -2.03645721e-01f, -8.64617452e-02f, -2.63080336e-02f, -5.50921075e-02f,
  -9.26468223e-02f, -9.68383178e-02f, -5.75451963e-02f, -7.33533874e-02f, -1.25723928e-01f, -1.38711110e-01f, -6.13533780e-02f, -1.82763427e-01f, -1.00412130e-01f, -2.73209717e-02f,
  1.91989932e-02f, -5.31350821e-02f, -1.15042165e-01f, -1.56142741e-01f, -1.47709474e-01f, 5.86900976e-04f, -9.03610885e-02f, -1.43136606e-01f, -2.09241539e-01f, -5.55711016e-02f,
  1.73903286e-01f, 1.96328193e-01f, 1.20955050e-01f, 1.75863318e-02f, 6.87193796e-02f, 1.38178587e-01f, 1.39751472e-02f, 9.37837437e-02f, 2.48597674e-02f, 2.71828044e-02f,
  1.26104727e-01f, 5.73470891e-02f, 1.45261168e-01f, 1.19628180e-02f, 9.69193652e-02f, 1.06102563e-01f, 3.00042797e-02f, 3.15577090e-02f, 1.17499143e-01f, -8.70839134e-03f,
  -9.36918613e-03f, 5.88656962e-02f, 8.88038129e-02f, 5.76617643e-02f, 1.02288902e-01f, 7.20352232e-02f, 6.59792274e-02f, 1.05183825e-01f, 3.09652742e-02f, 1.51437923e-01f,
  -2.75103062e-01f, -1.71327725e-01f, -2.17889428e-01f, -2.08898813e-01f, -2.06873462e-01f, -1.13207497e-01f, -1.60928473e-01f, -2.77048573e-02f, -1.82863414e-01f, -2.43171468e-01f,
  -1.17683485e-01f, -2.01940492e-01f, -1.28253490e-01f, -1.13253288e-01f, -2.36333236e-01f, -2.49254629e-01f, -1.71564668e-01f, -9.35643315e-02f, -1.67806089e-01f, -1.82381332e-01f,
  -1.99894503e-01f, -1.88998654e-01f, -2.56351322e-01f, -2.34605402e-01f, -1.17273271e-01f, -2.40504414e-01f, -1.93457708e-01f, -2.41900966e-01f, -1.95362106e-01f, -3.84947926e-01f,
  -3.57394248e-01f, -3.12179148e-01f, -4.31240946e-02f, -2.83450276e-01f, -1.48325577e-01f, -1.76856980e-01f, -2.64442295e-01f, -1.81260064e-01f, -1.50366887e-01f, -1.17056042e-01f,
  -4.91462611e-02f, 2.19927683e-01f, 8.25734064e-02f, 1.38251483e-01f, 1.13964364e-01f, -2.82082140e-01f, -3.09996188e-01f, 5.15805148e-02f, 2.07244515e-01f, 5.83149977e-02f,
  -1.56804249e-01f, -1.94394857e-01f, -5.81195876e-02f, -2.75877751e-02f, -2.63878345e-01f, 8.84800181e-02f, -1.35707393e-01f, -2.04787612e-01f, 2.78626941e-03f, -2.08897814e-01f,
  2.11244866e-01f, -1.40390903e-01f, 4.85305525e-02f, -1.08814649e-01f, -6.47855476e-02f, -3.27300839e-02f, -4.36500832e-02f, -7.18498826e-02f, -7.24469945e-02f, -1.94399238e-01f,
  -8.43120143e-02f, -1.25904620e-01f, 1.54594472e-02f, 4.58477437e-03f, -4.14342806e-02f, -7.06909448e-02f, -9.13330242e-02f, 1.34651326e-02f, -2.21756548e-02f, 4.61285748e-02f,
  -8.66035149e-02f, -1.40226662e-01f, -1.20717734e-01f, -7.99022242e-02f, -9.45105851e-02f, -8.94607455e-02f, -7.32628107e-02f, -1.27668709e-01f, -1.09329939e-01f, -1.15741313e-01f,
  -5.04116714e-02f, -1.53231099e-02f, 1.11081665e-02f, 2.05049422e-02f, 4.19933088e-02f, 4.90812063e-02f, 2.47363467e-02f, 6.35581762e-02f, 9.80158895e-03f, 8.14543739e-02f,
  1.54551849e-01f, 6.25039041e-02f, 5.50212264e-02f, 1.14538394e-01f, 5.25160357e-02f, 7.83306286e-02f, 6.77901357e-02f, -2.91933343e-02f, 7.29255229e-02f, 6.39767796e-02f,
  8.08310360e-02f, 3.02849691e-02f, -4.06301618e-02f, 3.03870812e-02f, 5.05637713e-02f, -5.58116613e-03f, 4.37651351e-02f, 4.76241559e-02f, 2.26252638e-02f, 4.19539027e-02f,
  3.98271978e-02f, 1.37370139e-01f, -9.64180902e-02f, -4.78061810e-02f, -6.90840930e-02f, -1.35466337e-01f, -6.12663925e-02f, -2.95957495e-02f, -1.00830957e-01f, -1.27883807e-01f,
  -3.58854346e-02f, -1.39565557e-01f, 3.89964357e-02f, -9.50470418e-02f, -6.00984460e-03f, -1.49643570e-01f, -1.41863957e-01f, -2.54490413e-02f, -9.05085951e-02f, -1.21581584e-01f,
  -1.98016062e-01f, -7.93863460e-02f, 5.52594438e-02f, -8.53229463e-02f, -2.66656876e-02f, -2.05366388e-02f, -1.01218507e-01f, -8.24549496e-02f, -1.66160706e-02f, -2.23801509e-01f,
  -5.83599448e-01f, -1.92788437e-01f, -8.43880326e-02f, -1.36235401e-01f, 8.49396363e-02f, 6.53171837e-02f, 9.23839770e-03f, 7.65041634e-02f, 1.99679136e-02f, -1.38148041e-02f,
  -1.42977806e-02f, 8.37385952e-02f, 1.90022271e-02f, 1.88888028e-01f, -9.41206329e-03f, -6.14572503e-02f, -2.45333239e-02f, 3.95328552e-02f, 1.58432052e-01f, 1.95451245e-01f,
  1.03435822e-01f, -4.82731275e-02f, -8.85621384e-02f, 1.40323294e-02f, 7.15855211e-02f, 2.35202149e-01f, -1.86373256e-02f, -4.06386405e-02f, 2.04969779e-01f, -8.63232277e-03f,
  -5.00455648e-02f, -1.80511326e-02f, 1.95558563e-01f, 1.42872095e-01f, 2.00356394e-02f, 1.79448202e-02f, 1.97604094e-02f, 5.49151860e-02f, 3.56044546e-02f, -3.55321285e-03f,
  1.25160739e-01f, -4.50957287e-03f, 4.85961810e-02f, 1.05271190e-01f, -1.55183300e-02f, 6.20531626e-02f, 9.91199166e-03f, -9.57871079e-02f, 3.03064678e-02f, 2.07961574e-02f,
  3.07640731e-02f, -3.58232968e-02f, 5.16423844e-02f, 1.75807223e-01f, 1.45763651e-01f, 9.02874917e-02f, 5.48473448e-02f, 2.01800331e-01f, 1.41702130e-01f, 6.03573658e-02f,
  -2.50185691e-02f, 2.49294043e-02f, -4.48383130e-02f, -1.37787927e-02f, -1.13047898e-01f, -4.17461395e-02f, -1.58684760e-01f, -1.71265975e-02f, -2.45128423e-02f, -5.89027815e-02f,
  -7.59772062e-02f, -4.68124337e-02f, -6.70520589e-02f, -5.51835150e-02f, -2.98712272e-02f, -2.90034618e-03f, -8.23143646e-02f, -4.27753329e-02f, -2.06423085e-02f, -1.52316794e-01f,
  -6.90735057e-02f, 4.89409380e-02f, -9.92583930e-02f, -9.70559195e-02f, -3.09124012e-02f, -5.62235527e-02f, 5.71368560e-02f, 2.66993474e-02f, -5.94568439e-02f, -1.32033108e-02f,
  -1.54943481e-01f, 3.58546781e-03f, -1.87604576e-02f, 7.97393993e-02f, 1.00814275e-01f, 1.83175370e-01f, 6.77701309e-02f, 1.17633142e-01f, 8.13471228e-02f, 8.13823566e-02f,
  6.05470724e-02f, 5.26155233e-02f, 1.05941072e-02f, 2.72839535e-02f, 6.78726062e-02f, 1.99421328e-02f, 4.58307043e-02f, 6.59345239e-02f, 1.05971165e-01f, 1.47549674e-01f,
  4.02667150e-02f, 9.96056050e-02f, -1.25416636e-01f, 4.68152389e-02f, 9.90986824e-02f, -4.96106572e-04f, 9.88906696e-02f, 4.12699170e-02f, 1.62514299e-02f, -1.07651383e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.48164999e-01f, -4.49201129e-02f, -2.53055878e-02f, 1.07121300e-02f, 2.09826171e-01f, 2.29474138e-02f, -1.89763069e-01f, -1.19095638e-01f, 5.24173258e-03f, -2.79803928e-02f,
  9.53203291e-02f, 2.56603539e-01f, 1.52397871e-01f, 1.18049175e-01f, -1.70402631e-01f, -1.54581740e-01f, -8.93227011e-03f, 2.32532155e-02f, 7.71932825e-02f, 1.46587327e-01f,
  1.48639038e-01f, -5.91459684e-02f, -2.30576396e-01f, -3.94213609e-02f, -5.84509270e-03f, -8.08977038e-02f, -1.22177765e-01f, -2.11318061e-02f, -2.24779379e-02f, -1.50123447e-01f,
  -6.17781207e-02f, -4.41740341e-02f, 7.65173659e-02f, 5.08449897e-02f, -4.35181102e-03f, -2.91764259e-01f, -9.49938074e-02f, -5.52860163e-02f, 8.11347663e-02f, -4.92125414e-02f,
  1.55952737e-01f, 1.09109327e-01f, 5.51989488e-02f, 5.23310527e-02f, -1.02168441e-01f, -1.18108444e-01f, 1.23776615e-01f, -6.00323305e-02f, -2.82787144e-01f, -8.65280405e-02f,
  1.11614324e-01f, 1.04004301e-01f, -6.70473799e-02f, -1.27388522e-01f, -3.54682267e-01f, -3.76129299e-02f, -1.56354904e-01f, -2.35100180e-01f, -3.28728437e-01f, -4.97829556e-01f,
  1.52188852e-01f, 1.71265364e-01f, 1.20109051e-01f, 6.93587437e-02f, 1.27091277e-02f, 1.01135686e-01f, 5.13228029e-02f, 1.85251236e-01f, 1.05696909e-01f, -1.18588731e-01f,
  1.31974950e-01f, 1.45772755e-01f, 4.96589318e-02f, 1.38624106e-02f, 3.23294476e-02f, 4.32043821e-02f, -1.24062195e-01f, -6.27610758e-02f, -4.74359803e-02f, -4.31382321e-02f,
  1.08454801e-01f, 2.54298206e-02f, 3.80227491e-02f, -8.59074146e-02f, 3.58722471e-02f, -3.63627844e-03f, 8.73399004e-02f, 1.01607196e-01f, -1.04291566e-01f, -8.85935575e-02f,
  -2.25152001e-01f, 2.79515117e-01f, -6.15280941e-02f, 1.03389330e-01f, 1.05813064e-01f, 5.68774380e-02f, 3.01960874e-02f, 3.77584472e-02f, -3.85860130e-02f, -9.95599031e-02f,
  -1.74830735e-01f, -1.35952100e-01f, -1.57785624e-01f, 1.17122950e-02f, -8.87285825e-03f, 1.96493734e-02f, 4.70165871e-02f, 2.38634482e-01f, -1.15557775e-01f, -1.13023996e-01f,
  -1.70015261e-01f, -4.38437611e-02f, -2.07502544e-01f, -1.54613808e-01f, -1.02816068e-01f, -5.10327332e-02f, -2.37619817e-01f, -1.90095693e-01f, -3.84727746e-01f, -4.81169611e-01f,
  4.59759757e-02f, -2.68809915e-01f, -5.35907745e-01f, -2.40200832e-02f, -3.90157133e-01f, -2.94180185e-01f, -1.76313668e-01f, 5.45463897e-03f, -9.29878801e-02f, -2.29720443e-01f,
  -7.70717636e-02f, 1.98782697e-01f, -2.26872656e-02f, -3.13947797e-02f, 1.81395188e-01f, -1.14066161e-01f, -3.31262678e-01f, -2.40735635e-01f, -1.36689335e-01f, -1.62521839e-01f,
  -1.93383574e-01f, -6.32679164e-02f, -1.79664474e-02f, 5.44245653e-02f, -6.48819134e-02f, 1.08946443e-01f, -1.89103395e-01f, -2.07463950e-01f, -1.19414262e-01f, -1.10188246e-01f,
  1.02236405e-01f, -5.23183681e-02f, -5.42127900e-02f, -1.01879679e-01f, -8.94560516e-02f, 8.06856230e-02f, -1.06923759e-01f, -8.62252414e-02f, -1.64752211e-02f, -7.77794654e-03f,
  -1.15285330e-01f, 5.89975268e-02f, 8.81743729e-02f, 1.23907022e-01f, 2.60766670e-02f, 2.38451101e-02f, -1.48277432e-01f, -1.06548876e-01f, -2.44945034e-01f, -1.12176821e-01f,
  -1.08603455e-01f, -1.15816385e-01f, 5.56889549e-03f, -1.20388642e-01f, -9.36736465e-02f, -1.36247218e-01f, -9.52652693e-02f, 1.62898172e-02f, -8.21786467e-03f, 5.72718233e-02f,
  -3.68615314e-02f, 6.91000223e-02f, 3.62108415e-03f, -2.21698619e-02f, 6.66759834e-02f, -2.98817661e-02f, 1.23286910e-01f, 2.25621700e-01f, 2.33825557e-02f, 5.31591587e-02f,
  9.04269237e-03f, -9.69520509e-02f, -1.17239393e-01f, -2.09186878e-02f, -8.37538242e-02f, -5.03266491e-02f, -9.19564962e-02f, 2.04714859e-04f, -1.57811083e-02f, -5.04592061e-02f,
  -1.52574003e-01f, 2.02288460e-02f, -1.63408834e-02f, 3.33396085e-02f, -8.09662938e-02f, -6.02762327e-02f, 1.56793222e-01f, 4.28928584e-02f, 1.11256458e-01f, 2.58790161e-02f,
  3.01446617e-01f, -2.37066314e-01f, 7.07270578e-02f, 1.70030192e-01f, 9.31649432e-02f, -7.95306414e-02f, -1.53392302e-02f, -1.57712530e-02f, -6.90810829e-02f, 8.28444138e-02f,
  -1.75589219e-01f, -2.63529480e-03f, 9.08559263e-02f, 1.12488844e-01f, 7.11601526e-02f, -4.86727655e-02f, -2.34205071e-02f, -8.14145729e-02f, 1.15063181e-02f, -9.81950238e-02f,
  -3.81191075e-02f, -2.84013357e-02f, 1.46073833e-01f, 9.00537297e-02f, 1.12173110e-01f, 1.09048903e-01f, 1.03272773e-01f, 7.54021108e-02f, 1.61493957e-01f, 1.45454720e-01f,
  5.65739930e-01f, -1.88644767e-01f, 2.54654229e-01f, 5.40339202e-02f, 4.02855352e-02f, 1.81451023e-01f, 1.09064393e-01f, 7.82493129e-02f, -9.44600701e-02f, -3.68882306e-02f,
  -3.03170204e-01f, -2.44493335e-01f, -2.25799605e-01f, -4.28667329e-02f, 2.57094298e-02f, 8.81224796e-02f, 1.37498617e-01f, 3.38347286e-01f, 3.56553465e-01f, 1.21526673e-01f,
  -1.18540265e-01f, 1.09036267e-01f, 2.64271915e-01f, 4.49381731e-02f, -1.29867867e-01f, -4.94255871e-02f, 8.76777526e-03f, 5.34955226e-02f, -9.09959152e-02f, -2.92201843e-02f,
  -3.41801047e-02f, 2.06283957e-01f, -1.63700297e-01f, -1.24900639e-01f, -4.49337512e-02f, -8.61593187e-02f, -1.20431893e-01f, -8.84148479e-02f, -3.16971652e-02f, -1.88469775e-02f,
  -1.28695853e-02f, -1.15638882e-01f, -1.73384920e-01f, -4.23370972e-02f, 7.04734698e-02f, -2.83529665e-02f, -8.66601840e-02f, 2.38209069e-02f, 1.84309185e-02f, -3.16089764e-02f,
  -2.51566350e-01f, -1.20381527e-01f, 6.26144707e-02f, -1.28240064e-01f, 4.73765247e-02f, 3.77586968e-02f, 1.51521359e-02f, -6.20866008e-02f, 5.30539453e-02f, 1.57107729e-02f,
  -2.50209887e-02f, -1.59527212e-02f, -7.05462769e-02f, -5.81444881e-04f, -3.15376953e-03f, 3.82358320e-02f, -3.02556269e-02f, 6.98837340e-02f, -8.89718998e-03f, -1.67822111e-02f,
  -2.41983548e-01f, -1.75515730e-02f, -3.54978815e-02f, -8.63920078e-02f, -6.68583512e-02f, -8.44502300e-02f, 8.96256492e-02f, -7.80254304e-02f, -7.29914010e-02f, -1.48955300e-01f,
  -1.84258848e-01f, 4.93549593e-02f, -1.23601571e-01f, -9.08447281e-02f, -1.30385116e-01f, -1.15283765e-01f, -6.38027713e-02f, -1.38870731e-01f, -1.04951568e-01f, -1.37274414e-01f,
  -4.45487678e-01f, -1.80845514e-01f, -1.27973661e-01f, 6.54435381e-02f, 9.27551165e-02f, -2.83896402e-02f, 3.63423191e-02f, -8.66575390e-02f, 6.85452223e-02f, 1.24603532e-01f,
  1.67106405e-01f, 7.59507790e-02f, -1.57440796e-01f, -1.03151292e-01f, 3.33541706e-02f, 1.04095094e-01f, -2.21893862e-01f, 4.53587659e-02f, 4.38360460e-02f, -7.34374002e-02f,
  -1.69740498e-01f, 1.33206889e-01f, 4.52163331e-02f, -4.92041782e-02f, -2.21579690e-02f, 1.40313655e-01f, -4.63473983e-02f, 1.27905235e-01f, 8.30425546e-02f, 6.28474429e-02f,
  -4.01152134e-01f, -2.23737940e-01f, 1.22837439e-01f, -3.17117482e-01f, 3.95415425e-01f, 5.27121544e-01f, 5.93409419e-01f, 3.23195070e-01f, -3.69062391e-03f, -3.25140506e-02f,
  -2.61935771e-01f, -3.29941273e-01f, -3.89526129e-01f, -5.80917299e-02f, 2.35342998e-02f, 2.44080380e-01f, 1.62723765e-01f, -7.11190626e-02f, 2.05766365e-01f, 3.64405572e-01f,
  9.34899077e-02f, -2.18282729e-01f, -2.19689384e-01f, -1.78893626e-01f, -3.75921458e-01f, -1.12762816e-01f, -2.80041486e-01f, -7.70920143e-03f, 6.13215715e-02f, -1.46100596e-01f,
  -1.43366203e-01f, -4.75692675e-02f, 1.87171102e-01f, -7.87008405e-02f, -1.44061655e-01f, -7.14048147e-02f, 9.98339336e-03f, -1.63930252e-01f, -1.24529131e-01f, -2.84115914e-02f,
  -1.68789759e-01f, -2.39595538e-03f, -5.65929562e-02f, 5.52916080e-02f, 3.20518762e-02f, -1.16463117e-02f, -7.74196759e-02f, -3.57038006e-02f, -6.41434491e-02f, 1.10330857e-01f,
  -5.80697916e-02f, 1.03447646e-01f, 5.71369864e-02f, 1.34121865e-01f, 1.31113112e-01f, -1.20042032e-02f, -1.13081992e-01f, 6.81486577e-02f, 4.10368815e-02f, -1.72598690e-01f,
  -3.00440099e-02f, -1.38803169e-01f, 4.46734391e-02f, 1.04983421e-02f, 8.06600973e-02f, 5.29144146e-02f, 8.27288255e-02f, 6.66622892e-02f, 6.29329085e-02f, -8.22030753e-02f,
  7.20587447e-02f, 9.36127454e-02f, 8.32791477e-02f, -7.46676922e-02f, -1.41830981e-01f, 2.13577654e-02f, 5.90371862e-02f, -6.24712855e-02f, -7.72309452e-02f, -1.93246994e-02f,
  5.21868542e-02f, 9.94636044e-02f, -1.11802951e-01f, -1.00362279e-01f, 9.08217877e-02f, -1.67033911e-01f, -3.25978510e-02f, 2.61459425e-02f, -2.49776766e-02f, 6.17222907e-03f,
  -3.23128164e-01f, 2.97348052e-01f, 4.86050323e-02f, -5.25896996e-02f, -6.46328330e-02f, -1.45793602e-01f, -1.20101199e-01f, -7.56918564e-02f, -4.99886787e-03f, 6.98147342e-02f,
  4.97826301e-02f, -7.07264841e-02f, -9.09914672e-02f, 1.96363255e-02f, 9.38379690e-02f, 9.37640783e-04f, 4.47201382e-05f, 1.11866938e-02f, 1.14841543e-01f, -1.90775935e-02f,
  3.04314028e-02f, 1.55508786e-01f, 7.99577907e-02f, 9.55956578e-02f, 5.58309630e-02f, 8.52855593e-02f, -4.64662462e-02f, 9.99352336e-02f, 1.22266456e-01f, -7.54529610e-02f,
  8.69488537e-01f, -1.36667907e-01f, 1.74171403e-01f, 6.18243068e-02f, -3.19374353e-01f, -2.85162419e-01f, -2.13367835e-01f, -7.59882331e-02f, -1.36162750e-02f, -1.28650703e-02f,
  9.75842178e-02f, 2.32650295e-01f, 2.57750779e-01f, 8.77914950e-02f, 2.83780158e-01f, 3.05160079e-02f, -7.46074468e-02f, 4.20250237e-01f, 3.80113721e-01f, 1.60749704e-01f,
  -1.60225138e-01f, -1.42366542e-02f, 3.60530019e-01f, 2.05061078e-01f, -1.31507710e-01f, 6.53029829e-02f, -1.57211259e-01f, -4.70720120e-02f, -8.54723752e-02f, 5.86556606e-02f,
  8.00806005e-03f, 2.48549312e-01f, -1.85456965e-02f, 1.94470957e-01f, -9.28922743e-02f, -3.98687720e-02f, -2.48073097e-02f, -5.77438287e-02f, -4.34623621e-02f, -1.58426479e-01f,
  -1.02508157e-01f, 4.34676334e-02f, -1.54028200e-02f, -1.16463140e-01f, -8.45653564e-02f, -1.41841844e-01f, 5.83123304e-02f, 8.62335563e-02f, 1.64929345e-01f, -6.67801918e-03f,
  -6.50277436e-02f, -3.06377206e-02f, 3.12582366e-02f, -5.70563078e-02f, -7.21160993e-02f, 6.01984337e-02f, -3.73939909e-02f, -1.84398144e-02f, 8.52266252e-02f, -1.78320631e-02f,
  5.33078760e-02f, 7.87363201e-02f, 1.25095874e-01f, 6.68902919e-02f, 6.58197105e-02f, 2.78235935e-02f, 7.41393045e-02f, -2.44066175e-02f, 1.25009671e-01f, 3.07902141e-04f,
  -5.73695041e-02f, 6.56457767e-02f, 2.54506674e-02f, 1.05258739e-02f, 5.97188063e-03f, -4.68583219e-02f, -1.00437149e-01f, -2.23056506e-02f, 1.16775213e-02f, -5.11251800e-02f,
  1.26759764e-02f, 2.30574664e-02f, 5.92128411e-02f, -1.03206402e-02f, 1.77582782e-02f, -7.07072020e-02f, 5.47893695e-04f, -1.45620555e-01f, 2.07389630e-02f, 1.15196835e-02f,
  -6.32873237e-01f, 1.21125899e-01f, 1.58329934e-01f, 1.01598434e-01f, -6.53283894e-02f, -1.56826954e-02f, 1.35562709e-02f, 3.21230069e-02f, -1.15247592e-01f, -1.49783671e-01f,
  -4.69030105e-02f, 1.51431561e-01f, -4.61346954e-02f, -4.96027805e-02f, -1.34565402e-02f, -7.89698437e-02f, -4.11622263e-02f, 1.11577861e-01f, 4.50118096e-05f, -1.29402368e-04f,
  -1.07506983e-01f, -1.23839140e-01f, 6.85333535e-02f, -1.28156945e-01f, -6.71946406e-02f, 1.36371359e-01f, -6.61342517e-02f, -9.79938805e-02f, 1.19417764e-01f, -1.38161302e-01f,
  7.00748265e-01f, -6.57504871e-02f, -4.49037224e-01f, -3.47119174e-03f, -2.62568176e-01f, -1.21711142e-01f, -1.80280298e-01f, 4.83012162e-02f, 1.24665447e-01f, -1.70951173e-01f,
  9.87239629e-02f, 4.69631433e-01f, 2.51661032e-01f, 1.80022851e-01f, 1.50501847e-01f, -2.42463753e-01f, -4.08687085e-01f, -4.91397381e-02f, 1.37422800e-01f, 2.72390116e-02f,
  -7.63341412e-02f, -5.56645133e-02f, -3.30352634e-02f, 2.72454112e-03f, -1.33075267e-01f, 2.01704334e-02f, -2.81830579e-01f, -2.51428545e-01f, -1.31524548e-01f, -2.71203339e-01f,
  -3.68393511e-01f, -4.91131470e-02f, 1.67698637e-01f, 1.49735808e-01f, -1.04275048e-02f, 1.33347139e-01f, 6.86739832e-02f, 5.25197312e-02f, 1.34035408e-01f, -2.69830711e-02f,
  -7.16632009e-02f, -1.65862516e-02f, -9.45861042e-02f, -7.67836943e-02f, -9.56957936e-02f, -1.41011685e-01f, -4.19118032e-02f, 1.86740793e-02f, 2.83445120e-02f, -1.49153816e-02f,
  2.68172100e-03f, 3.05468459e-02f, 8.92233551e-02f, 7.05082417e-02f, 8.49478170e-02f, 2.73380857e-02f, 7.56392777e-02f, 1.14219770e-01f, 6.25952557e-02f, 2.91151907e-02f,
  3.33431624e-02f, 1.20618239e-01f, 1.05015986e-01f, 1.03493780e-01f, -3.51228826e-02f, 6.69501424e-02f, 7.38809779e-02f, 2.76199821e-02f, -5.85254915e-02f, 5.86546510e-02f,
  3.56722102e-02f, -1.75043806e-01f, 1.64493918e-02f, -9.35007706e-02f, 8.85753147e-03f, 3.03813685e-02f, 2.90534366e-02f, -6.86300471e-02f, -4.10389714e-02f, 9.50945988e-02f,
  -3.04047875e-02f, 6.39600903e-02f, -1.22053407e-01f, -6.23311624e-02f, -7.02782497e-02f, -3.73978950e-02f, 6.38926076e-03f, 2.60115005e-02f, -5.80995344e-02f, -2.76900567e-02f,
  -1.32735088e-01f, 1.19560830e-01f, -2.45331004e-02f, 1.47965223e-01f, -1.01540051e-01f, -5.44281639e-02f, 4.89248820e-02f, -9.09445137e-02f, -9.88311470e-02f, -5.31492792e-02f,
  -3.85096073e-02f, -4.96404022e-02f, 3.76984186e-04f, -2.64631044e-02f, -8.00856110e-03f, -9.10058804e-03f, 4.56864201e-02f, 1.18799120e-01f, -5.30561991e-02f, -1.37927294e-01f,
  -4.81864288e-02f, 1.39840364e-01f, 1.94964424e-01f, 1.04795158e-01f, 1.00191973e-01f, 8.08208287e-02f, -8.32479969e-02f, -1.42485583e-02f, 1.32602232e-03f, -2.84567028e-02f,
  -2.98129946e-01f, 3.26627702e-01f, -1.20994128e-01f, 2.68051028e-01f, 2.24760219e-01f, 2.81523794e-01f, 2.41838992e-01f, 1.71329081e-01f, 1.73173144e-01f, 1.04981579e-01f,
  1.23890065e-01f, 1.31355494e-01f, 7.54940510e-02f, 1.29741028e-01f, 2.52872378e-01f, 2.67164081e-01f, 2.43672490e-01f, 2.45616622e-02f, -9.57925469e-02f, 1.17572144e-01f,
  1.77697867e-01f, 1.31894425e-01f, -8.52383301e-02f, 4.39515002e-02f, 1.55636176e-01f, 1.61292851e-01f, 1.73952356e-02f, 1.94315732e-01f, 2.43296742e-01f, 1.74622953e-01f,
  -4.46900241e-02f, -1.55964158e-02f, -3.51868533e-02f, 3.39256413e-02f, -1.30760714e-01f, -1.78311512e-01f, 6.43879315e-03f, -1.28178075e-01f, -9.49443206e-02f, -1.05676644e-01f,
  -5.65054156e-02f, -2.97986809e-02f, 2.22602114e-03f, -2.23838557e-02f, -8.79966468e-02f, -1.20413668e-01f, -1.64404482e-01f, -3.33217643e-02f, 1.45373702e-01f, 6.08970374e-02f,
  1.35432258e-01f, -4.77121845e-02f, 3.57720554e-02f, -1.79247204e-02f, 1.38168156e-01f, 4.99889217e-02f, -5.40069789e-02f, 3.14389654e-02f, -4.53290120e-02f, -1.69296667e-01f,
  1.12881169e-01f, 5.46335950e-02f, 4.10312694e-03f, -1.89800620e-01f, -1.80263817e-01f, -1.47377208e-01f, -2.33991947e-02f, 9.92418304e-02f, 5.28969131e-02f, -5.57138398e-02f,
  2.78671682e-02f, -2.45120954e-02f, -3.12818177e-02f, -8.17167237e-02f, 2.45956425e-02f, 9.72412303e-02f, 3.77312899e-02f, -1.02375261e-03f, -4.80106249e-02f, -7.33073875e-02f,
  5.66229448e-02f, 5.81838638e-02f, -3.14359665e-02f, -5.34749590e-02f, -1.06955310e-02f, 1.05913719e-02f, -5.97254746e-02f, 6.03164621e-02f, -3.42791490e-02f, 3.74460556e-02f,
  2.22549751e-01f, -1.36882183e-03f, -4.43078391e-02f, 1.43793762e-01f, 5.72116636e-02f, 2.82748248e-02f, 1.78700294e-02f, -1.75854899e-02f, -1.18130781e-02f, -4.37519066e-02f,
  -1.03246242e-01f, -5.24489470e-02f, -1.57208517e-02f, -2.63556745e-02f, -9.89459231e-02f, -7.54891559e-02f, -4.11476865e-02f, 1.36523247e-01f, 2.13832304e-01f, 3.33744287e-02f,
  7.08470419e-02f, -2.60772444e-02f, -3.46672684e-02f, -3.50852162e-02f, 1.02048414e-02f, -2.62890309e-02f, -8.77246112e-02f, -1.01772761e-02f, -1.68381885e-01f, -2.46912852e-01f,
  -5.09071648e-01f, -2.10656039e-02f, 1.03066318e-01f, -5.40767431e-01f, -1.17249258e-01f, 1.35481909e-01f, -9.16061401e-02f, -5.04684299e-02f, -2.07946852e-01f, -2.86763936e-01f,
  -8.58050138e-02f, 4.42846343e-02f, -1.04373902e-01f, 1.13885909e-01f, 1.98180485e-03f, -2.91516751e-01f, -3.26661944e-01f, 3.34409177e-02f, 3.35297018e-01f, 3.53637815e-01f,
  -3.98318190e-03f, -1.63087681e-01f, -1.27415404e-01f, -9.87220276e-03f, -2.40133494e-01f, -1.58961102e-01f, -2.83572286e-01f, -1.36970550e-01f, 1.58440776e-03f, -4.54804152e-01f,
  -2.31151849e-01f, 4.18304726e-02f, 8.77907351e-02f, 2.14269217e-02f, -1.10803686e-01f, -8.93165916e-02f, 8.77684578e-02f, -1.18301846e-01f, 2.95722391e-02f, -5.67243434e-03f,
  -5.28740436e-02f, 1.29547164e-01f, -6.61121681e-02f, 3.08772456e-02f, -1.82115007e-02f, -4.31683399e-02f, 6.79682121e-02f, 1.55615747e-01f, 1.13671338e-02f, 9.21806917e-02f,
  4.76032197e-02f, -1.24666467e-01f, -9.06672850e-02f, 7.42714182e-02f, 1.72000587e-01f, 1.74178630e-02f, 8.65634754e-02f, 2.17332780e-01f, 2.65301555e-01f, -3.17161947e-01f,
  -1.19375728e-01f, 1.00252032e-02f, 1.39651358e-01f, -2.55205259e-02f, -7.85276517e-02f, -1.10750638e-01f, -3.62832919e-02f, -8.97748321e-02f, 3.93688977e-02f, 2.57116612e-02f,
  4.26746253e-03f, -7.55851669e-03f, 7.95850605e-02f, -8.89644772e-02f, 3.87487747e-02f, -4.07035872e-02f, 1.04982769e-02f, 9.63258818e-02f, -6.42280802e-02f, -1.29016419e-03f,
  -1.92186218e-02f, -1.49428677e-02f, -4.79862541e-02f, 5.30341752e-02f, -3.69223254e-03f, -1.00221537e-01f, 7.30091780e-02f, 2.63675690e-01f, 5.92606962e-02f, 1.91119507e-01f,
  -1.73107833e-01f, 7.57193789e-02f, -4.93999124e-01f, -1.16872741e-02f, -2.26304457e-01f, 5.25136618e-03f, -7.95431137e-02f, 5.86744621e-02f, 6.06788741e-03f, -4.31794971e-02f,
  1.59394369e-01f, -8.95754918e-02f, -7.85713270e-02f, -2.91767363e-02f, 3.63698862e-02f, 2.37794183e-02f, -6.66527003e-02f, -8.17013830e-02f, 7.87275508e-02f, 1.24534424e-02f,
  1.76231784e-03f, -2.88624521e-02f, -9.16924030e-02f, -4.24147770e-02f, -9.35792923e-02f, -3.14163193e-02f, -1.86071210e-02f, 7.61657059e-02f, 6.95476495e-03f, -2.16973543e-01f,
  -1.03954136e+00f, -2.55791307e-03f, 3.15403223e-01f, -5.82876444e-01f, -3.00932974e-01f, -2.84655392e-01f, 6.09722249e-02f, -3.21277440e-01f, -3.36613089e-01f, 6.28471375e-02f,
  1.09668799e-01f, -8.64482820e-02f, 1.12639718e-01f, -2.59645879e-02f, -1.22367859e-01f, 1.91568539e-01f, -9.11848545e-02f, -2.78460622e-01f, -4.76080030e-01f, -3.19900602e-01f,
  -1.79255769e-01f, -4.29190725e-01f, -6.52032435e-01f, -2.49754071e-01f, -1.05856068e-03f, -8.91828090e-02f, 3.25188637e-02f, -1.90166622e-01f, 4.50148620e-02f, 5.46727143e-02f,
  4.21957254e-01f, -2.94543415e-01f, -1.49955317e-01f, -2.27462843e-01f, 1.05645424e-02f, -9.96540487e-02f, -7.94687197e-02f, -3.24843340e-02f, 5.05694710e-02f, 1.84196346e-02f,
  -1.21032253e-01f, -4.96830344e-02f, -6.20784573e-02f, -7.43468702e-02f, -1.74462453e-01f, -9.72206239e-03f, 4.07143161e-02f, -7.11562624e-03f, -6.37878105e-02f, 2.16050968e-01f,
  1.11089379e-01f, -3.22972126e-02f, 6.78084046e-02f, 8.80015269e-02f, 2.34542135e-02f, -1.24016233e-01f, 1.15279034e-01f, -4.94413748e-02f, 7.59548098e-02f, 1.56002305e-02f,
  6.62605539e-02f, 1.63226247e-01f, 5.26013523e-02f, 4.37669344e-02f, 6.24241270e-02f, 3.25472057e-02f, 4.77576032e-02f, 3.30705456e-02f, -7.65876248e-02f, -8.88444856e-03f,
  7.77740851e-02f, -5.73707707e-02f, -8.14855099e-03f, -4.59225178e-02f, 9.95760262e-02f, -1.28300041e-01f, -8.81851688e-02f, 1.01152442e-01f, -5.39208949e-03f, -1.38456643e-01f,
  -6.44888431e-02f, 1.56303719e-02f, 6.55668005e-02f, 7.44234212e-03f, -4.04756377e-03f, -7.02381507e-02f, 4.93441112e-02f, 3.03018223e-02f, 1.92178264e-02f, -1.68279693e-01f,
  1.65017188e-01f, -2.17386127e-01f, -7.77092110e-03f, -1.45266065e-02f, -7.87608102e-02f, 1.24128886e-01f, 1.30507618e-01f, -3.24239619e-02f, -2.81186216e-02f, 5.31124957e-02f,
  -8.07674602e-02f, 4.09163870e-02f, 4.00255620e-02f, 1.13201089e-01f, -3.96308750e-02f, 5.94583750e-02f, 8.63976926e-02f, -7.78786764e-02f, 1.35424864e-02f, 1.30517870e-01f,
  8.38067383e-02f, -2.68063229e-03f, 1.88867245e-02f, 7.73433149e-02f, 4.83417325e-02f, -2.59203855e-02f, 2.31022596e-01f, 9.19054300e-02f, 1.08534068e-01f, 2.50168502e-01f,
  -4.03991520e-01f, -2.31313616e-01f, 1.16858631e-01f, 1.91595092e-01f, 2.10996270e-01f, 3.55119258e-01f, 2.62301892e-01f, 1.22134596e-01f, 1.89534098e-01f, 1.39887080e-01f,
  9.96893495e-02f, 2.12634116e-01f, 1.08823933e-01f, 1.83974534e-01f, 2.09689289e-01f, 2.49549702e-01f, 2.80873090e-01f, 2.86309719e-02f, 2.01995328e-01f, 2.11302802e-01f,
  8.54948461e-02f, -8.69405866e-02f, -2.22421765e-01f, -1.75504070e-02f, -6.86329305e-02f, 1.08528338e-01f, 4.45308946e-02f, -1.32739646e-02f, 5.15739024e-02f, -2.44471636e-02f,
  1.84967682e-01f, -7.60576800e-02f, 1.44227996e-01f, -3.74177806e-02f, -2.37933323e-01f, -2.21878171e-01f, 2.70524845e-02f, -1.80750176e-01f, -3.05885226e-02f, 3.64302061e-02f,
  1.10663818e-02f, -6.62308559e-02f, -8.16655383e-02f, -1.90702543e-01f, -1.90697938e-01f, -7.64461681e-02f, -2.04041317e-01f, -2.39340998e-02f, 2.62851920e-02f, 5.58169261e-02f,
  -5.35715371e-02f, -4.78431694e-02f, 1.05912477e-01f, 8.34597796e-02f, 5.90111502e-02f, 5.83882146e-02f, -7.32845142e-02f, -5.80253154e-02f, 3.02888025e-02f, -1.53770760e-01f,
  1.28336906e-01f, 1.16957843e-01f, -6.35126978e-02f, 1.34213850e-01f, 1.12422286e-02f, -6.99487478e-02f, 1.16396837e-01f, 7.40393177e-02f, 1.98486373e-01f, -1.76363334e-01f,
  -6.44190386e-02f, 1.86071366e-01f, 1.41764268e-01f, 1.05915256e-01f, 5.77766933e-02f, -1.24077313e-02f, -4.38857414e-02f, -1.47331385e-02f, -5.59369177e-02f, -4.25051004e-02f,
  -2.27778014e-02f, -3.53568941e-02f, -6.89904913e-02f, -7.62118697e-02f, -7.38047250e-03f, 4.62470949e-02f, 2.31965575e-02f, 3.67989624e-03f, -7.81759694e-02f, -2.54407316e-03f,
  2.75480658e-01f, 1.32724434e-01f, 1.60853967e-01f, -1.06676526e-01f, -2.19839290e-01f, -1.30349502e-01f, 2.73818504e-02f, -1.13588452e-01f, -4.52071428e-03f, 1.07048839e-01f,
  -5.83035089e-02f, 4.10910510e-03f, 1.14035653e-03f, -3.78718860e-02f, -1.58192694e-01f, -4.55758832e-02f, -2.88546346e-02f, 1.32981867e-01f, 9.76423621e-02f, 6.10726178e-02f,
  2.67850328e-02f, 1.33221477e-01f, 2.27288082e-01f, 1.37831002e-01f, 1.57404184e-01f, 7.40036741e-02f, 6.10759072e-02f, -4.36556302e-02f, 2.35328842e-02f, -2.56098863e-02f,
  -3.40092108e-02f, -1.75080746e-01f, -2.56506294e-01f, 3.51593383e-02f, -6.89241365e-02f, -1.23672225e-02f, -3.32015395e-01f, 4.56536049e-03f, 5.08873574e-02f, -3.00466180e-01f,
  -1.47830928e-02f, 1.61279246e-01f, -1.16705336e-01f, -5.30492552e-02f, -2.86483169e-01f, -5.21685541e-01f, -4.36018348e-01f, -2.46517062e-01f, 1.11279376e-01f, 2.82369226e-01f,
  1.65557265e-01f, -1.59628298e-02f, 1.09436370e-01f, 5.75157031e-02f, -3.65131162e-02f, -5.00729270e-02f, -3.43268305e-01f, -1.69883206e-01f, -6.98313266e-02f, -1.95716381e-01f,
  -3.28046560e-01f, 1.78094732e-03f, -5.58891445e-02f, 1.06263958e-01f, -6.55037612e-02f, -1.50208265e-01f, -5.80470562e-02f, -1.97452139e-02f, -5.66317961e-02f, 7.72231910e-03f,
  1.08202085e-01f, 1.35131106e-01f, 2.57005170e-02f, -2.87751853e-02f, 1.19749598e-01f, 1.98728859e-01f, -1.01173818e-01f, 3.93335782e-02f, -5.36153018e-02f, 6.40714243e-02f,
  -4.94512543e-02f, -2.42229048e-02f, -1.14698887e-01f, -9.08011720e-02f, -6.59628958e-02f, 3.15114260e-02f, 1.21320285e-01f, 7.01994002e-02f, 2.04436411e-03f, -2.34175622e-01f,
  -3.89801823e-02f, -6.80388883e-02f, -5.81144243e-02f, 7.00209066e-02f, 4.54147942e-02f, -1.73014522e-01f, 5.58717065e-02f, -1.46634087e-01f, -1.94434021e-02f, 5.20451628e-02f,
  1.16647417e-02f, -3.48280109e-02f, -3.00308671e-02f, -4.26718220e-02f, -1.05062768e-01f, 4.70873155e-02f, -1.08540937e-01f, -4.51529399e-02f, -2.91763041e-02f, 6.03418648e-02f,
  9.82855782e-02f, 1.75481196e-02f, -3.19250450e-02f, -3.03610433e-02f, -3.49431969e-02f, -9.02645066e-02f, 4.59298939e-02f, 1.68514289e-02f, 1.68888822e-01f, 9.08447057e-02f,
  -1.11391671e-01f, -7.34069198e-02f, -2.75606096e-01f, -1.18619828e-02f, -9.51332375e-02f, -3.41521874e-02f, -8.34957585e-02f, 3.12005002e-02f, 2.65495293e-02f, 3.67081128e-02f,
  1.83674559e-01f, 1.69288758e-02f, -6.48252741e-02f, 8.41058940e-02f, 5.70269674e-02f, 1.06157005e-01f, -2.28303298e-02f, -8.77911597e-02f, -7.91691095e-02f, 2.32124329e-01f,
  -2.20635049e-02f, -1.38875842e-01f, -5.92054240e-02f, -1.62792932e-02f, -3.30562796e-03f, -3.83643471e-02f, -8.96293670e-02f, -3.95822078e-02f, -1.86579227e-01f, -3.48816186e-01f,
  2.87706077e-01f, -3.57590646e-01f, 1.65402800e-01f, 3.36602867e-01f, 5.35152666e-03f, -2.13602528e-01f, -7.12290406e-01f, -2.25104541e-01f, 2.25848094e-01f, -2.14162201e-01f,
  1.17246814e-01f, 4.08715159e-01f, 3.02089274e-01f, 2.23260805e-01f, -1.59628958e-01f, -3.48189861e-01f, -2.68793166e-01f, 2.63789356e-01f, 2.00468808e-01f, -1.28054142e-01f,
  -8.49103853e-02f, -2.95537021e-02f, 1.38828233e-01f, -2.11236365e-02f, -1.60245582e-01f, 1.58900786e-02f, -1.05692938e-01f, -3.42083499e-02f, -1.11952610e-01f, -1.84050724e-01f,
  1.20034680e-01f, -4.07309234e-02f, 7.02257678e-02f, 1.73153907e-01f, 1.71741813e-01f, 7.49900704e-04f, -7.11788684e-02f, 1.90345347e-02f, -7.94042572e-02f, -1.29956707e-01f,
  2.03630686e-01f, -1.28416866e-01f, 2.63476253e-01f, 9.33236852e-02f, -1.26319915e-01f, -2.04181597e-01f, -1.00526765e-01f, -1.08814061e-01f, -7.88194910e-02f, -3.20611209e-01f,
  -1.35577187e-01f, 9.41454805e-03f, 5.06709367e-02f, -1.86791062e-01f, -2.92550236e-01f, 1.62058398e-01f, -3.39792430e-01f, -7.43628815e-02f, -7.74322152e-02f, -4.10026491e-01f,
  -9.75622684e-02f, 1.03343345e-01f, -2.48692781e-02f, -1.41527802e-01f, -1.44125253e-01f, -1.08438373e-01f, 1.36467800e-01f, 1.20170541e-01f, 1.19636962e-02f, -2.96528563e-02f,
  -3.23824883e-02f, 3.03049176e-03f, -1.12351282e-02f, -8.92147869e-02f, 8.37323740e-02f, 4.78386991e-02f, -3.10654938e-02f, -3.23056430e-02f, 1.13341548e-01f, -1.30112469e-01f,
  3.00722271e-02f, 2.53994986e-02f, 1.37856891e-02f, -9.08637643e-02f, -1.43605977e-01f, 2.71548005e-03f, 9.66544002e-02f, 1.85093209e-02f, 4.44334857e-02f, -7.97142386e-02f,
  1.29531279e-01f, 1.98670521e-01f, -5.61429746e-02f, -8.52896646e-03f, 1.55149614e-02f, -5.77130727e-02f, 3.81433554e-02f, 2.19181683e-02f, 1.51996285e-01f, 1.07304677e-02f,
  -3.27339768e-03f, -1.49346404e-02f, 5.51924407e-02f, -1.31505653e-01f, -3.93739752e-02f, -8.42021778e-02f, 1.63840514e-03f, 1.86034977e-01f, -4.35009599e-02f, -6.26204759e-02f,
  -1.61492899e-01f, -1.38398021e-01f, 1.91543907e-01f, 3.00835911e-02f, -1.00875311e-01f, 1.83344021e-01f, -1.13194308e-03f, -2.62808837e-02f, 6.60360456e-02f, -3.55880082e-01f,
  2.26701275e-02f, 2.74057925e-01f, -3.26893836e-01f, 2.98282921e-01f, 2.38253877e-01f, 1.74186170e-01f, 7.58116394e-02f, -4.89070639e-03f, 1.57082334e-01f, 4.91989627e-02f,
  2.76711285e-01f, 2.94200808e-01f, 1.66485101e-01f, 9.64855626e-02f, -9.20583829e-02f, -7.06176599e-03f, 8.91973078e-02f, -2.25195587e-01f, -1.89325973e-01f, 3.22702415e-02f,
  2.78736681e-01f, 6.57367557e-02f, -2.40300909e-01f, -3.14191617e-02f, 1.99582711e-01f, 1.90159842e-01f, 6.31762296e-02f, 2.06658527e-01f, 1.25124738e-01f, 1.83361664e-01f,
  -9.71565098e-02f, 1.36104614e-01f, -1.57429308e-01f, 1.65007114e-01f, -5.65394014e-03f, -2.43494242e-01f, -1.22302301e-01f, -2.58055478e-01f, -8.66266787e-02f, -3.63257714e-02f,
  1.61696494e-01f, 1.38527853e-02f, 1.86980516e-01f, 4.30852622e-02f, -5.78659475e-02f, -7.17789307e-02f, -2.11298555e-01f, -2.19445825e-01f, -1.42424226e-01f, -1.05237536e-01f,
  2.17787147e-01f, 2.09526360e-01f, -1.39111459e-01f, -2.58317720e-02f, -5.05496264e-02f, 2.91017611e-02f, 2.94519193e-03f, 1.03797086e-01f, -9.99842584e-02f, -3.89069086e-03f,
  4.78354730e-02f, 2.96747126e-02f, 7.39879608e-02f, -5.55496139e-04f, 1.54540762e-01f, 1.62112132e-01f, 1.11784600e-01f, 6.13156781e-02f, 5.01923598e-02f, -1.62443653e-01f,
  5.82355447e-02f, -1.10741757e-01f, -6.89573959e-02f, -1.01801753e-01f, 1.04458123e-01f, 1.11328498e-01f, -1.48871588e-02f, -8.59173313e-02f, -2.72280443e-02f, 8.05355161e-02f,
  1.40841469e-01f, -1.76628083e-02f, 2.64512841e-04f, -1.01793729e-01f, -7.93554410e-02f, -3.60427573e-02f, 9.03386399e-02f, 7.32486323e-02f, 5.20061515e-02f, 1.63672194e-01f,
  1.98749434e-02f, -6.45097299e-03f, -3.54766683e-03f, 5.55012822e-02f, -5.00715859e-02f, -1.24387361e-01f, 4.38081101e-02f, -1.26468495e-01f, -6.01581261e-02f, -3.94338481e-02f,
  -4.13436815e-02f, -6.35993034e-02f, 5.74713610e-02f, -1.09087922e-01f, -1.08702332e-01f, -8.45954716e-02f, 4.94309794e-03f, -5.56276478e-02f, -4.61737849e-02f, -2.40040839e-01f,
  -1.72468558e-01f, -1.92539573e-01f, -1.13818578e-01f, -1.25227928e-01f, -1.38609648e-01f, 3.73728126e-02f, -1.19439512e-01f, -7.96079934e-02f, -1.83751673e-01f, -1.34400740e-01f,
  7.99789608e-01f, 2.06931494e-02f, 8.89969468e-02f, 1.30761236e-01f, 4.02294435e-02f, 2.89564967e-01f, 2.38923356e-01f, 9.59183350e-02f, 1.41371757e-01f, 1.60011694e-01f,
  2.26138145e-01f, 1.27293453e-01f, 2.94141658e-02f, -1.11491978e-01f, 3.93681116e-02f, -1.27260387e-01f, -1.32279828e-01f, 5.96739277e-02f, 1.44610390e-01f, 5.89202084e-02f,
  -1.44770950e-01f, 3.89360264e-02f, 8.55783075e-02f, -5.27368188e-02f, -2.16503233e-01f, -1.74332231e-01f, -4.57581840e-02f, -1.34943306e-01f, -1.00677714e-01f, -4.64909941e-01f,
  -3.21265876e-01f, 1.96923375e-01f, -7.36185089e-02f, -8.67854729e-02f, -2.18065120e-02f, 1.16017386e-01f, 6.31072298e-02f, 1.50505751e-02f, 1.10955492e-01f, 2.69630048e-02f,
  -1.11506209e-01f, 3.38895321e-02f, 1.30683944e-01f, 1.50127545e-01f, 2.98198801e-03f, -7.60004390e-03f, 1.01118073e-01f, 9.87464786e-02f, -5.82886767e-03f, 1.35125965e-03f,
  1.22444872e-02f, 1.84890777e-01f, 1.35585666e-01f, 6.50609210e-02f, 1.43732548e-01f, 5.36245406e-02f, 1.02185540e-01f, 9.19387564e-02f, 1.75279245e-01f, -7.04868557e-03f,
  -1.22069120e-01f, 4.79911566e-02f, 8.28399584e-02f, 2.28819996e-01f, 1.83369949e-01f, 9.81119871e-02f, 5.35332896e-02f, 2.65287645e-02f, -9.98932053e-04f, -6.30256161e-02f,
  4.21585515e-02f, 1.07250504e-01f, 1.85665131e-01f, -2.78121959e-02f, -1.23447282e-02f, -9.83660854e-03f, -7.43926503e-03f, 9.47815552e-02f, -6.69195876e-03f, 5.69867007e-02f,
  5.85812889e-02f, -1.67078435e-01f, -1.26879573e-01f, -8.63760039e-02f, 6.46502152e-02f, -3.67085859e-02f, -1.18759476e-01f, 1.11879997e-01f, -9.07359347e-02f, -5.26267625e-02f,
  -2.00917631e-01f, 3.32711905e-01f, -1.11426786e-01f, -1.61933079e-01f, -9.29787681e-02f, -4.12913747e-02f, -1.11171110e-02f, -9.87819582e-03f, -1.46522850e-01f, -6.23943061e-02f,
  1.46828396e-02f, -8.36389139e-02f, -1.86759222e-03f, 7.31372833e-02f, -1.24520983e-03f, -7.56407902e-02f, 5.59171401e-02f, 2.61140782e-02f, -1.12702489e-01f, -2.78343916e-01f,
  -1.59305245e-01f, 5.25016002e-02f, 1.62728980e-01f, 7.47548789e-02f, -1.12945646e-01f, -7.13379821e-03f, -1.22924976e-01f, -5.84891923e-02f, 3.93871218e-02f, -3.45745645e-02f,
  6.82212353e-01f, 2.77217954e-01f, 1.36688590e-01f, 8.33640322e-02f, 1.35493070e-01f, 2.40853772e-01f, 4.11688447e-01f, 2.15534821e-01f, -8.68578162e-03f, 1.05640970e-01f,
  9.71963555e-02f, 1.38731375e-02f, -5.88828139e-02f, -1.26651255e-02f, 1.06741942e-01f, -2.25279126e-02f, -1.22801520e-01f, -8.55846256e-02f, 1.71762593e-02f, 2.95070615e-02f,
  -3.07332557e-02f, -3.85001861e-02f, 2.17498645e-01f, 3.42280678e-02f, -5.37742637e-02f, 2.57637780e-02f, 6.23649769e-02f, 9.20397341e-02f, -8.48652348e-02f, -4.59975414e-02f,
  -1.76082924e-01f, 3.66718918e-01f, -2.37267375e-01f, -1.44539565e-01f, -1.24699911e-02f, -3.63308229e-02f, 8.45456496e-03f, -3.91108841e-02f, -7.02963248e-02f, -1.44632772e-01f,
  1.60699990e-02f, -8.23114961e-02f, -7.20453411e-02f, 1.80043243e-02f, -5.19532226e-02f, -5.10850064e-02f, 7.13654757e-02f, -2.20627002e-02f, -3.54558341e-02f, -5.47092557e-02f,
  -7.90003389e-02f, -5.48125096e-02f, 6.21064380e-02f, 1.55622782e-02f, 1.19268820e-01f, -3.39209400e-02f, 1.50771942e-02f, -3.51033770e-02f, 3.67816794e-03f, -2.09566355e-02f,
  -8.29890966e-02f, 1.21965118e-01f, 8.59110057e-02f, -6.31589144e-02f, -4.39748680e-03f, -3.26866172e-02f, -7.82230124e-02f, -3.37258615e-02f, -8.29386897e-03f, -2.10835263e-02f,
  -7.36620352e-02f, 3.41440947e-03f, -2.39050344e-01f, 4.29282598e-02f, -1.10409476e-01f, -1.08712517e-01f, 2.19890233e-02f, 1.16234683e-01f, 1.29287569e-02f, 4.48933616e-02f,
  -6.79318607e-02f, -1.73940528e-02f, 9.62081775e-02f, 8.34244583e-03f, -1.02618791e-01f, 7.44696259e-02f, -1.97558150e-01f, -5.35346158e-02f, 7.04365000e-02f, 9.60552841e-02f,
  -3.08897048e-01f, -3.06925364e-02f, -1.29547030e-01f, -1.26653209e-01f, 4.63888310e-02f, -8.09053238e-03f, 6.49786368e-02f, -1.08523183e-01f, -6.60632923e-02f, -6.17501624e-02f,
  1.04128331e-01f, 1.07617164e-02f, 2.09207721e-02f, -1.21120187e-02f, 2.10820530e-02f, 5.62967453e-03f, 5.78301288e-02f, 3.91351469e-02f, -3.43288071e-02f, -1.00529036e-02f,
  -1.22461937e-01f, -1.13532618e-01f, -1.79153122e-02f, -2.20909920e-02f, -8.00719336e-02f, -1.06732376e-01f, -1.24738753e-01f, -8.89214426e-02f, -1.34984031e-02f, -4.97204028e-02f,
  -1.56358898e-01f, -4.84994054e-02f, -9.72689614e-02f, 1.49240894e-02f, -1.78563073e-02f, -2.37653688e-01f, -5.10867774e-01f, -2.17971981e-01f, -9.59958415e-03f, -1.30648583e-01f,
  -9.00677405e-03f, 6.47126064e-02f, 9.67538506e-02f, -1.87012125e-02f, -1.47804590e-02f, 2.86694672e-02f, 2.20776051e-01f, 2.47169718e-01f, 8.66311789e-02f, -3.21680959e-03f,
  2.10372150e-01f, 2.39804104e-01f, 1.70774534e-01f, 7.45196417e-02f, 2.93785453e-01f, 1.82776839e-01f, 1.02772102e-01f, 3.02929819e-01f, 2.22238973e-01f, 4.23238069e-01f,
  -1.11998402e-01f, -2.44077936e-01f, -4.86649238e-02f, -7.76650058e-03f, 1.62636742e-01f, 1.29651083e-02f, 1.15994819e-01f, 2.97394805e-02f, -2.53959298e-02f, -4.29676585e-02f,
  1.38492689e-01f, 1.67547479e-01f, 2.46520317e-03f, -1.24435611e-02f, -4.92380187e-02f, -8.61037970e-02f, -3.19584906e-02f, -6.39640540e-02f, -2.05045819e-01f, -1.84371233e-01f,
  1.11363232e-01f, -2.12745517e-02f, -2.47590244e-01f, -2.80593067e-01f, -1.72499493e-01f, 3.91619280e-02f, 1.83941219e-02f, 7.36187845e-02f, -8.25442523e-02f, 1.73141609e-03f,
  -5.59143499e-02f, 6.98021054e-02f, 9.42592695e-02f, 6.54122159e-02f, 3.42645384e-02f, 3.03225890e-02f, 7.96912983e-02f, 1.81103662e-01f, 1.89690758e-02f, 9.43072513e-03f,
  -1.36839956e-01f, -1.07681252e-01f, -1.27181429e-02f, -3.49974185e-02f, 3.82438563e-02f, 6.63302392e-02f, 5.82593679e-02f, 2.74280775e-02f, 1.53385317e-02f, 1.44052031e-02f,
  -6.62982138e-03f, -6.66267872e-02f, 9.71513316e-02f, 6.55753985e-02f, 2.96380334e-02f, 3.75929549e-02f, 6.79841638e-02f, -7.02805296e-02f, -4.51498143e-02f, 3.77000198e-02f,
  -2.06218421e-01f, -8.54100138e-02f, 5.14391623e-02f, 5.98335043e-02f, 1.53808668e-01f, -4.65092398e-02f, 1.10158101e-01f, 6.11896962e-02f, 6.26645759e-02f, -2.84515806e-02f,
  -3.85443941e-02f, 9.23126563e-02f, -1.19878426e-01f, -5.24160601e-02f, -4.11261059e-02f, -1.29120469e-01f, 5.17607704e-02f, -5.83803356e-02f, 1.13938302e-02f, 2.91147921e-03f,
  -1.99608371e-01f, -2.45879769e-01f, -3.48743707e-01f, -4.25113827e-01f, -8.78342018e-02f, -5.85524552e-02f, -2.82671805e-02f, -9.81993526e-02f, -2.07168341e-01f, -2.19111815e-01f,
  1.20980747e-01f, 2.11788435e-03f, -7.99658969e-02f, 3.31444949e-01f, 9.17124003e-02f, 1.72493562e-01f, 2.96269387e-01f, 1.53864488e-01f, 2.84377206e-02f, 1.12108767e-01f,
  1.55044883e-01f, 9.95946825e-02f, 1.87959075e-01f, 3.18921879e-02f, 1.12772785e-01f, 7.55061880e-02f, 6.57998547e-02f, 6.68772981e-02f, 8.91965181e-02f, 9.71294940e-02f,
  1.13564692e-01f, -4.02873680e-02f, 4.45942394e-02f, -6.35702088e-02f, 1.56534746e-01f, 2.02648211e-02f, 7.87926242e-02f, 1.87204275e-02f, 8.44450966e-02f, 6.71692118e-02f,
  -2.97755480e-01f, -1.08110579e-03f, 5.52331284e-02f, 5.81231108e-03f, -1.05368584e-01f, -2.06249788e-01f, -1.17160454e-01f, -2.12135449e-01f, -1.02198832e-01f, -4.36979458e-02f,
  -1.20897710e-01f, -1.11919977e-01f, 6.56619743e-02f, -9.62829366e-02f, -6.10794174e-03f, 2.01022755e-02f, -9.62741151e-02f, -2.30763722e-02f, 1.93804819e-02f, -6.66886047e-02f,
  1.06698431e-01f, 5.81501834e-02f, -6.43135458e-02f, 6.67865351e-02f, -2.02808045e-02f, 6.27502725e-02f, 3.96158211e-02f, -4.78801914e-02f, -5.02667166e-02f, 4.86229965e-03f,
  1.48350969e-01f, -1.11391628e-02f, 1.57364890e-01f, 3.68533470e-02f, 1.70906603e-01f, 8.12759548e-02f, 1.12736970e-01f, 1.00248680e-01f, 1.87956631e-01f, -1.80911906e-02f,
  2.97330320e-02f, 1.71027966e-02f, -8.45922381e-02f, 9.95112807e-02f, 1.66888639e-01f, 1.07161319e-02f, -1.29444659e-01f, 7.06135184e-02f, 5.54097630e-03f, 5.16288821e-03f,
  1.28894687e-01f, 8.78466368e-02f, 9.29529965e-02f, 8.99779871e-02f, -1.84198376e-02f, 1.16337784e-01f, 1.35637552e-01f, 9.93677229e-02f, 1.07669175e-01f, -5.89584641e-04f,
  -1.92044422e-01f, 4.16309834e-02f, 3.43640000e-02f, 3.48213874e-02f, 4.16425243e-02f, -1.00074276e-01f, 1.30438060e-01f, -1.47389621e-01f, -4.11025882e-02f, -1.44266039e-01f,
  -9.88751743e-03f, -7.02475756e-02f, 9.88013595e-02f, 7.54255727e-02f, 3.58798206e-02f, -3.17190192e-03f, -2.35805660e-02f, 8.13819095e-02f, 2.27387762e-03f, -5.61778508e-02f,
  9.39062238e-02f, 2.00621076e-02f, -1.63249180e-01f, 2.86366534e-03f, 6.03254400e-02f, -4.17339429e-02f, -3.09052020e-02f, -1.04034066e-01f, -1.62319187e-02f, -5.19062504e-02f,
  -6.04489027e-03f, 5.61686993e-01f, 1.74820319e-01f, -2.43049264e-01f, 2.45251730e-01f, 2.99268067e-01f, 6.38003647e-01f, 1.13057271e-01f, -2.69037843e-01f, 1.60982653e-01f,
  2.87458658e-01f, -1.97852194e-01f, -8.34427848e-02f, -1.43814133e-02f, 3.18519212e-02f, 1.98870867e-01f, 7.07204565e-02f, -2.23125577e-01f, -3.67288470e-01f, -1.43297702e-01f,
  -1.60992548e-01f, -1.83687076e-01f, -2.98298538e-01f, -1.72542080e-01f, 3.11857890e-02f, -1.22706085e-01f, 2.23698154e-01f, 1.07662447e-01f, 1.96629703e-01f, -4.06291746e-02f,
  -5.96897975e-02f, 3.35732520e-01f, -4.44807947e-01f, -1.10648341e-01f, 1.54006928e-01f, -2.48937368e-01f, -1.53361455e-01f, -6.67131916e-02f, 9.92070418e-03f, -1.83262333e-01f,
  6.37554526e-02f, 6.06936663e-02f, 5.07651493e-02f, -7.11741373e-02f, -7.02912435e-02f, -1.18481465e-01f, -2.48525646e-02f, -5.14199734e-02f, -6.70682117e-02f, -8.48208368e-02f,
  1.62135303e-01f, 5.90409115e-02f, 3.21229547e-01f, 9.66061652e-02f, 8.86955112e-02f, -5.40266111e-02f, 2.70052105e-01f, 2.93445922e-02f, 3.55603620e-02f, -6.27801716e-02f,
  -2.84465309e-02f, 1.99783519e-01f, 1.08256005e-01f, 5.07663339e-02f, -6.01756610e-02f, 2.51557082e-02f, -8.72673988e-02f, 5.62412106e-02f, 8.12316593e-03f, -3.70527059e-02f,
  -6.05385415e-02f, -4.91015241e-02f, -1.31195351e-01f, 6.49910495e-02f, -6.33450076e-02f, 1.94802005e-02f, -7.23224133e-02f, -6.16618395e-02f, 4.85545024e-03f, -4.67327125e-02f,
  8.73322412e-03f, -6.29569590e-02f, 1.22294761e-01f, -1.23552650e-01f, 3.53559516e-02f, -4.18979749e-02f, -5.31062372e-02f, -4.77870144e-02f, -5.63384555e-02f, 4.27054986e-03f,
  -3.69463146e-01f, 8.63998383e-02f, -2.52546012e-01f, -5.82509376e-02f, 1.03410147e-01f, -5.95414601e-02f, -1.17832934e-03f, 9.62272063e-02f, 7.87914246e-02f, -1.18972383e-01f,
  1.11845918e-01f, -1.34161010e-01f, 6.80962875e-02f, -5.29924221e-02f, -2.53127068e-01f, 1.37897447e-01f, 2.94222441e-02f, -1.26475826e-01f, -1.53547496e-01f, -1.28011912e-01f,
  -1.43504098e-01f, -2.02942640e-01f, -3.17729086e-01f, -8.39570388e-02f, -1.45493090e-01f, -3.16018462e-01f, -5.46290949e-02f, -1.45727023e-01f, 5.24236262e-02f, -2.09095642e-01f,
  6.98424935e-01f, 1.09231733e-02f, -7.31795192e-01f, 2.63666928e-01f, -2.97946781e-01f, -1.25463903e-01f, -2.81270351e-02f, 2.05270231e-01f, 3.09541672e-01f, -2.65547186e-02f,
  -1.77291676e-01f, -1.97365098e-02f, -1.65458508e-02f, -1.71734110e-01f, 1.12234786e-01f, -5.96025884e-02f, -1.96189061e-01f, -2.70321846e-01f, -2.66245097e-01f, 4.75042034e-03f,
  -1.06664337e-02f, 2.06191152e-01f, 1.75463289e-01f, -1.11737279e-02f, -5.68761304e-02f, -4.04637605e-02f, -1.87864438e-01f, -1.31887615e-01f, -2.10314751e-01f, -1.42995775e-01f,
  -3.95335436e-01f, -2.75652736e-01f, -2.62041956e-01f, 1.05492406e-01f, -3.57017703e-02f, -7.11732544e-03f, -1.71925247e-01f, -1.24427646e-01f, -1.36394296e-02f, -8.14984143e-02f,
  -2.87487566e-01f, -1.17474973e-01f, -2.17612177e-01f, 1.97938364e-03f, -5.55701703e-02f, 7.59050027e-02f, 1.04438335e-01f, -8.85874256e-02f, -2.61270162e-02f, -1.40234172e-01f,
  -5.22482321e-02f, -5.34974337e-02f, -2.90542990e-01f, -1.22276537e-01f, -2.82462865e-01f, -1.22248314e-01f, -1.88599482e-01f, -1.58483937e-01f, -1.99237645e-01f, 1.09522365e-01f,
  1.24520101e-01f, -1.20293200e-01f, 1.32667040e-02f, 1.07494712e-01f, 1.54957995e-01f, -8.48816559e-02f, -1.02019021e-02f, 6.83385879e-02f, 3.98187861e-02f, 3.35835069e-02f,
  -7.27114305e-02f, -6.03649840e-02f, 3.91312130e-02f, -5.63712902e-02f, -6.63315738e-03f, -2.22020177e-03f, -1.44742250e-01f, 6.99383765e-02f, 8.54109302e-02f, 1.50034446e-02f,
  1.19158067e-02f, -3.76554430e-02f, -6.90547451e-02f, -2.05517579e-02f, -1.61190927e-01f, -6.47885129e-02f, -3.43270265e-02f, -6.09203568e-03f, 1.03044599e-01f, 2.92545035e-02f,
  3.52027029e-01f, -1.04940869e-01f, -1.14721069e-02f, -3.27869207e-02f, 5.63283041e-02f, -1.10214107e-01f, 6.75610686e-03f, -4.50831763e-02f, 4.14480045e-02f, -8.51891488e-02f,
  -7.65516460e-02f, -1.66057944e-01f, -3.69461849e-02f, 2.54642265e-03f, 8.06477666e-02f, 9.28201526e-03f, 1.66826114e-01f, -4.51903194e-02f, 2.08272725e-01f, -3.74867469e-02f,
  1.74901053e-01f, 2.60559052e-01f, 1.06090978e-01f, 9.13366899e-02f, 1.42419845e-01f, 1.37677863e-01f, 4.04343046e-02f, -2.75056083e-02f, 7.48604089e-02f, 2.72294879e-01f,
  3.39086801e-01f, -1.89498588e-01f, 5.05514920e-01f, 3.79943810e-02f, -5.11434749e-02f, 4.52902615e-02f, 2.91127890e-01f, 1.31459862e-01f, -1.01417713e-01f, -4.70191725e-02f,
  -2.13102564e-01f, -1.57490268e-01f, -3.92658040e-02f, -1.53157815e-01f, 9.96473357e-02f, 2.19670776e-02f, 6.09357667e-04f, 3.61158490e-01f, 2.59885401e-01f, 1.38947040e-01f,
  -1.90282673e-01f, 5.77010773e-02f, 2.19969019e-01f, 8.57413486e-02f, -1.61019135e-02f, -1.25016898e-01f, 9.27311778e-02f, -3.99386212e-02f, -4.33214158e-02f, -5.09149767e-02f,
  3.01330090e-01f, 1.07008263e-01f, -1.43852159e-01f, -2.32051119e-01f, -2.92414743e-02f, 7.40753487e-02f, 2.90965289e-02f, 7.97274858e-02f, -1.31629094e-01f, 3.81137915e-02f,
  -1.29500702e-01f, 4.61523607e-02f, 7.35202245e-03f, 9.59960893e-02f, 4.98052277e-02f, -3.53776999e-02f, 1.14313275e-01f, 1.60272583e-01f, -1.20645612e-02f, 4.50630672e-02f,
  -1.07224248e-01f, -7.59475380e-02f, 8.62307474e-02f, -3.01980302e-02f, 7.01425150e-02f, 6.08019121e-02f, -4.66950089e-02f, 2.17325799e-02f, 1.10329930e-02f, -4.53625023e-02f,
  -5.93144968e-02f, -9.17270109e-02f, 1.59659702e-02f, 9.02931839e-02f, 9.65669453e-02f, 3.49933766e-02f, 4.01048921e-02f, -1.87997594e-02f, 5.50296642e-02f, 1.40172228e-01f,
  1.56889200e-01f, 9.41745862e-02f, 9.75927562e-02f, 1.37134179e-01f, 1.19075486e-02f, 3.59350443e-02f, 1.75390869e-01f, -1.82010196e-02f, 7.06803054e-02f, 3.20368037e-02f,
  4.06424440e-02f, 9.80010107e-02f, 3.31885517e-02f, 2.60466456e-01f, 6.43909052e-02f, 4.93024550e-02f, 6.15812242e-02f, 1.00979798e-01f, 7.35163316e-02f, 6.73418567e-02f,
  -7.50992622e-04f, -1.78445913e-02f, -1.21328503e-01f, -2.00289652e-01f, 4.64612953e-02f, -7.54465386e-02f, -1.30294273e-02f, -1.42040439e-02f, -6.03908896e-02f, -7.01858550e-02f,
  3.08042765e-03f, 7.43268430e-02f, 4.66635004e-02f, 4.93488275e-02f, 1.79893285e-01f, -3.93085331e-02f, -1.36319727e-01f, -4.36157919e-02f, -8.80976021e-02f, -5.45929000e-03f,
  -1.00243211e-01f, -1.03755571e-01f, 8.73274878e-02f, -1.12200782e-01f, -1.04312561e-01f, -4.71262708e-02f, 3.98120768e-02f, -2.03808378e-02f, 9.34281498e-02f, -6.33687526e-03f,
  -2.16843337e-02f, -4.03937042e-01f, -3.95530462e-01f, -3.68288934e-01f, -2.64348060e-01f, -2.44559601e-01f, -2.07840443e-01f, -3.82998362e-02f, -9.58422199e-02f, -3.33862960e-01f,
  -1.01266362e-01f, 2.22723693e-01f, -2.05267575e-02f, 8.25416744e-02f, 1.03033386e-01f, -3.74579161e-01f, -4.33876097e-01f, -1.52048796e-01f, 2.48187721e-01f, 1.91966563e-01f,
  -6.91149011e-02f, -2.72693057e-02f, 1.12891095e-02f, -1.09612584e-01f, -1.60452276e-01f, -9.83508304e-02f, -3.75975102e-01f, -2.23083526e-01f, -2.21628129e-01f, -4.58967566e-01f,
  -8.16825926e-02f, -5.32779396e-02f, -3.96284126e-02f, 9.62047353e-02f, -5.00016175e-02f, -2.68450622e-02f, 1.98207293e-02f, -1.59436196e-01f, 3.68218459e-02f, -1.07101217e-01f,
  2.55904663e-02f, 4.30948883e-02f, 9.62409098e-03f, 4.60619107e-02f, -1.85083086e-03f, 9.93412286e-02f, 9.67701823e-02f, 2.69044880e-02f, -1.08528733e-01f, -8.89486223e-02f,
  4.18151729e-02f, -2.46830471e-02f, 1.47115335e-01f, 1.59258053e-01f, 9.88965556e-02f, 1.70283690e-01f, 5.55923507e-02f, 1.15112469e-01f, 1.58621296e-01f, 1.30676463e-01f,
  -6.26069754e-02f, 1.39740389e-02f, 7.76235461e-02f, 2.07321912e-01f, 1.44387245e-01f, 1.01959109e-01f, 1.36118615e-02f, 1.50222301e-01f, 1.67341381e-01f, 2.98086591e-02f,
  -1.00188898e-02f, -6.38656020e-02f, 3.53179947e-02f, 1.68833435e-02f, -1.22295124e-02f, -8.07255208e-02f, 4.42500040e-02f, 2.51538604e-02f, 1.47763863e-01f, -8.68672729e-02f,
  1.30007669e-01f, -7.66849965e-02f, -1.26644438e-02f, -6.41720518e-02f, -1.59794673e-01f, 3.64424512e-02f, -4.58785743e-02f, -1.14068851e-01f, -1.14493705e-01f, -2.42394343e-01f,
  1.91480711e-01f, -3.31657864e-02f, -1.01225607e-01f, 2.29674634e-02f, -5.70614375e-02f, -3.79396975e-02f, -1.74521301e-02f, -1.86097734e-02f, 1.29055278e-02f, 2.21765861e-02f,
  1.21776573e-01f, 4.71729860e-02f, 6.67847171e-02f, 1.11374296e-02f, 3.15870456e-02f, 1.27748296e-01f, 6.56434298e-02f, 1.40076637e-01f, -2.80178729e-02f, -8.55538771e-02f,
  -5.93109727e-02f, 1.45224229e-01f, 2.37354338e-01f, 1.25025678e-02f, 1.46511033e-01f, 2.06647009e-01f, 1.46178335e-01f, 5.49802668e-02f, 2.81062406e-02f, 9.94838923e-02f,
  6.22383207e-02f, -9.95092094e-02f, -7.68222585e-02f, 3.37680936e-01f, 1.98772758e-01f, -1.36933357e-01f, -4.89962667e-01f, -2.58684129e-01f, 1.32652074e-01f, 1.29623711e-02f,
  1.40516190e-02f, 2.22611263e-01f, -5.88949919e-02f, -1.96676970e-01f, -6.08456790e-01f, -3.54884863e-01f, -1.98498219e-01f, -3.90173346e-01f, -4.70025569e-01f, -1.84945092e-01f,
  1.46121338e-01f, -1.39367841e-02f, -1.82239637e-01f, -4.34101559e-02f, 1.56516761e-01f, 3.52630322e-03f, 2.88692266e-02f, 8.11193809e-02f, -4.80573252e-03f, 2.90817857e-01f,
  -8.47770870e-02f, 2.33226772e-02f, -8.95747973e-04f, -4.53236885e-02f, -8.23888462e-03f, 7.56637135e-04f, -6.34934157e-02f, -5.12191700e-03f, 7.27107823e-02f, -9.41489730e-03f,
  8.57791975e-02f, -4.27323803e-02f, 1.27086729e-01f, -6.79228827e-02f, -2.44496047e-01f, -1.41502365e-01f, -6.78622276e-02f, -2.11354896e-01f, -2.61903465e-01f, -7.36440644e-02f,
  1.80068444e-02f, 1.42645333e-02f, -2.17038602e-01f, -1.68560430e-01f, -2.09333196e-01f, 2.22150944e-02f, -1.32053584e-01f, -8.34728498e-03f, -2.00947970e-01f, 3.91648374e-02f,
  4.39708754e-02f, 3.46021280e-02f, -1.37238717e-02f, 2.63791140e-02f, 4.28446084e-02f, 2.09332213e-01f, -8.94356705e-03f, -1.31335422e-01f, 3.75325792e-02f, -1.49756940e-02f,
  4.51742746e-02f, 4.89680022e-02f, 1.33487463e-01f, 4.89091617e-04f, -1.22775957e-02f, -9.44565311e-02f, -1.25066400e-01f, -3.11348103e-02f, -8.51218626e-02f, -9.59775969e-02f,
  -1.38999587e-02f, 7.39441141e-02f, 1.28073856e-01f, -6.95388615e-02f, -4.40948009e-02f, -1.58769518e-01f, 1.19667634e-01f, -1.21000402e-01f, -1.18934587e-02f, -1.23378858e-01f,
  -1.12094432e-02f, -1.65217355e-01f, 6.51331916e-02f, -1.44042134e-01f, 4.08514477e-02f, -4.01305035e-02f, 8.93065147e-03f, -5.38978875e-02f, 2.60306876e-02f, -1.61475137e-01f,
  -7.39963651e-02f, -1.93049479e-02f, 7.38690719e-02f, -3.26277316e-02f, -8.57411474e-02f, -1.36163766e-02f, -2.25436032e-01f, 5.41924424e-02f, -1.61277071e-01f, 9.54026729e-02f,
  -7.64234588e-02f, -2.18095973e-01f, -1.17530309e-01f, 2.85468176e-02f, 1.19074143e-01f, -1.57806464e-02f, -2.04715475e-01f, -1.31867290e-01f, -3.19069982e-01f, -1.96924627e-01f,
  6.88020825e-01f, -1.66882381e-01f, 3.91600698e-01f, 1.96005881e-01f, 1.29424483e-01f, 1.83861345e-01f, 5.19504882e-02f, -1.10719325e-02f, 1.08346500e-01f, -3.19522433e-02f,
  -6.79956675e-02f, -7.61449486e-02f, -2.31630933e-02f, -4.70164120e-02f, 3.82925794e-02f, -5.68434857e-02f, -7.44329989e-02f, 2.59319574e-01f, 2.45170638e-01f, 1.48013756e-01f,
  -1.40190287e-03f, -5.77369705e-02f, 1.33774847e-01f, 1.29617825e-01f, -6.87337965e-02f, -1.26384228e-01f, 4.45364080e-02f, -8.29072818e-02f, -1.01511981e-02f, -1.80011421e-01f,
  -8.79557431e-02f, 2.11012766e-01f, 7.68918768e-02f, -1.04999401e-01f, -6.79538473e-02f, -9.98732522e-02f, -6.70785271e-03f, -9.34545472e-02f, -2.21097752e-01f, -1.28609791e-01f,
  3.49147292e-03f, -1.56529690e-03f, -1.29312024e-01f, 2.89722513e-02f, 7.86636025e-02f, -3.72280031e-02f, -6.89411536e-02f, 3.43038864e-03f, -4.67981845e-02f, -1.19055584e-01f,
  -2.34614417e-01f, 1.54085327e-02f, 1.11275025e-01f, 4.53295978e-03f, 2.91643012e-02f, 8.95108432e-02f, 2.82434188e-02f, -5.60221598e-02f, -3.74705605e-02f, 7.58302137e-02f,
  -3.97573858e-02f, 1.14686809e-01f, 6.63242638e-02f, -1.95115327e-03f, -6.49088770e-02f, -3.70101295e-02f, -8.85504112e-03f, -1.05743363e-01f, 4.95222658e-02f, -2.83626914e-02f,
  -9.98720601e-02f, 1.58642232e-02f, -7.95916189e-03f, 4.31932472e-02f, 1.53987687e-02f, 1.86990593e-02f, -3.35552581e-02f, -5.43552218e-04f, 1.30867481e-01f, 3.23811807e-02f,
  9.38419998e-02f, -5.21188863e-02f, 9.67996716e-02f, -1.22610535e-02f, -1.20391473e-02f, 1.13707796e-01f, 3.55388932e-02f, -8.96388143e-02f, 2.51962785e-02f, 5.50113022e-02f,
  -4.49230462e-01f, 4.50063571e-02f, -4.67758067e-02f, -2.11072385e-01f, 4.63748500e-02f, -1.68711077e-02f, -3.89559567e-02f, 2.40117777e-02f, -2.22705036e-01f, -4.95084040e-02f,
  -3.30343656e-02f, -9.60217714e-02f, 5.38638532e-02f, -7.57166222e-02f, -4.03230935e-02f, -5.19894809e-02f, -1.36819676e-01f, 3.14395577e-02f, -1.27276406e-01f, -1.62067905e-01f,
  -1.53901175e-01f, 1.29707292e-01f, 8.79100412e-02f, 1.48885213e-02f, 9.54376906e-03f, 1.78500917e-02f, -7.88855627e-02f, 6.24044873e-02f, -3.68280634e-02f, 4.58286330e-02f,
  -4.49292034e-01f, -1.50287509e-01f, -3.90200049e-01f, -1.71851809e-03f, 3.43639404e-01f, 2.27115527e-01f, 2.65897840e-01f, 1.67331770e-01f, -8.17578565e-03f, -1.40426710e-01f,
  1.30040776e-02f, 1.39190346e-01f, 6.61743358e-02f, 9.27984416e-02f, 5.58778979e-02f, -1.79931633e-02f, 1.43275857e-01f, 4.92337979e-02f, 2.84619033e-01f, 3.52949083e-01f,
  3.17539155e-01f, 1.24992430e-02f, -1.65997550e-01f, -8.06525163e-03f, -4.42895219e-02f, -1.40406238e-02f, -1.91818237e-01f, -6.96450323e-02f, -6.35312404e-03f, -2.68637240e-01f,
  -3.14843804e-01f, -2.69081205e-01f, 1.23746417e-01f, -2.01751869e-02f, -1.36294335e-01f, -1.69130415e-01f, -6.84989765e-02f, -2.03051254e-01f, -1.15731299e-01f, -1.53568044e-01f,
  -1.17176734e-01f, -2.96615008e-02f, 3.44806872e-02f, 1.16341241e-01f, -1.71437915e-02f, 1.59734115e-02f, -4.24717925e-02f, -1.78499460e-01f, -3.69393229e-01f, 2.02872455e-02f,
  2.77268112e-01f, 1.97543651e-01f, -2.03752920e-01f, 1.34331360e-01f, -2.44666740e-01f, -7.82266632e-02f, -2.09210515e-01f, -1.65415093e-01f, -3.31471711e-01f, -4.21934009e-01f,
  1.05264969e-01f, -5.96630834e-02f, -8.27214345e-02f, 6.96419924e-03f, -2.26153992e-02f, 2.72476254e-03f, 5.61550632e-02f, 1.66964680e-01f, 5.27985841e-02f, -1.05325490e-01f,
  1.65818278e-02f, 6.42929077e-02f, 1.56501070e-01f, -4.35659923e-02f, -2.35464107e-02f, 2.39316951e-02f, -6.10959774e-04f, -1.90301333e-02f, 2.10962491e-03f, -1.61175206e-02f,
  2.17203982e-02f, -9.57455561e-02f, 4.91198488e-02f, 1.10756651e-01f, 5.17269969e-02f, 1.07226953e-01f, 5.90165257e-02f, 1.11966819e-01f, -1.95618033e-01f, -1.29245207e-01f,
  -1.52384982e-01f, 1.04455322e-01f, -1.46324292e-01f, 1.33024693e-01f, -1.06874280e-01f, 2.64779776e-02f, -1.32830190e-02f, -5.89151680e-02f, -8.86903852e-02f, -6.25925362e-02f,
  -3.00877169e-02f, -6.54136343e-03f, -1.29023358e-01f, 6.31410107e-02f, 3.73254158e-02f, 7.15898648e-02f, 2.11300631e-03f, 5.44065461e-02f, 3.41753922e-02f, -2.46854704e-02f,
  -9.74770933e-02f, 5.19272201e-02f, -1.82286143e-01f, -1.11626849e-01f, 5.36157526e-02f, -1.54638784e-02f, -2.31395647e-01f, -6.71917871e-02f, -1.86561435e-01f, -2.37534732e-01f,
  8.19326863e-02f, -2.11792603e-01f, 3.22156012e-01f, 9.26362127e-02f, 1.98460653e-01f, 1.79667056e-01f, 1.23685449e-01f, 1.12619951e-01f, 4.59648259e-02f, -4.88138422e-02f,
  -1.99234948e-01f, -1.01417236e-01f, -2.29072183e-01f, -8.90882239e-02f, -4.76489477e-02f, 1.22000801e-03f, 1.85855582e-01f, 9.92633775e-02f, 3.06883037e-01f, 2.01676697e-01f,
  -2.83205081e-02f, 1.26457706e-01f, -5.54327630e-02f, -3.33882757e-02f, -1.15746893e-01f, -6.03744350e-02f, -6.24662898e-02f, -8.70186910e-02f, -1.75090209e-01f, -9.02226865e-02f,
  8.75285268e-02f, -2.30103120e-01f, 1.34719536e-01f, -1.22874603e-01f, -2.78931315e-04f, -7.71289738e-03f, 6.09760545e-02f, -6.17302135e-02f, 2.31267996e-02f, 4.08111475e-02f,
  3.94647159e-02f, -1.18740946e-02f, -1.62962392e-01f, -9.28291753e-02f, 6.90897554e-02f, -1.31504973e-02f, -5.52164987e-02f, -1.28401309e-01f, 1.56855141e-03f, 2.16304213e-02f,
  -8.73785242e-02f, 5.84395826e-02f, 2.05021426e-02f, 8.90172049e-02f, 1.54002846e-04f, -8.34835768e-02f, -2.01281719e-02f, -1.17471285e-01f, -1.65421311e-02f, 6.45814911e-02f,
  3.19429725e-01f, 9.65242460e-02f, -8.19664598e-02f, 1.91078577e-02f, -1.07443325e-01f, 8.70215744e-02f, -6.57775719e-03f, 7.02767596e-02f, 3.39037478e-02f, -1.47070689e-02f,
  -9.23924968e-02f, -2.74580698e-02f, -2.24663615e-02f, 3.70068625e-02f, 4.24510660e-03f, 8.46044999e-03f, 8.33616406e-02f, 1.59794558e-02f, -1.93942606e-01f, -1.95719272e-01f,
  -1.51216358e-01f, 9.12571698e-03f, 1.66987106e-02f, -1.78156242e-01f, -1.64371893e-01f, 3.47689167e-02f, -2.35588737e-02f, -1.63678497e-01f, -1.21908754e-01f, -4.58935462e-03f,
  -3.23333666e-02f, -2.70474225e-01f, -8.16097017e-05f, -6.39334470e-02f, -1.82005279e-02f, -1.34776145e-01f, -7.55555779e-02f, -5.75098209e-02f, 1.43140227e-01f, 5.15875481e-02f,
  1.27186760e-01f, 1.40344901e-02f, -5.31592667e-02f, -4.99253646e-02f, 1.94776624e-01f, 7.85669163e-02f, -1.26898205e-02f, 8.18251073e-02f, 5.09379543e-02f, 4.34389189e-02f,
  7.91271999e-02f, 2.37857118e-01f, 2.65944600e-01f, 1.15175322e-01f, 6.33185431e-02f, 1.20753147e-01f, 1.69754982e-01f, 1.13303967e-01f, 1.51044011e-01f, 2.74119049e-01f,
  3.73377860e-01f, 2.48271421e-01f, 1.48176253e-01f, 1.92222595e-01f, 9.36757401e-02f, -1.73514336e-01f, -1.79554775e-01f, -1.44763649e-01f, -9.74796936e-02f, 6.24439269e-02f,
  1.89765587e-01f, -1.11879560e-03f, -2.08651219e-02f, -1.44033015e-01f, -1.73847541e-01f, -1.09067462e-01f, -2.22989425e-01f, -2.28352472e-01f, -3.61227483e-01f, -2.79179245e-01f,
  -2.24082813e-01f, -9.15468261e-02f, 6.73420057e-02f, -1.12856977e-01f, 1.53302342e-01f, -7.18243718e-02f, -1.06189623e-01f, 1.13268204e-01f, 3.09178922e-02f, 1.48035392e-01f,
  2.94943154e-01f, 4.32653517e-01f, 5.39071020e-03f, 8.48362744e-02f, 1.21159971e-01f, -7.11761229e-03f, 1.17203802e-01f, 1.16393179e-01f, 4.74017933e-02f, -2.47167200e-02f,
  1.23314150e-01f, 4.64343764e-02f, 8.34860131e-02f, -5.21239117e-02f, 8.23938176e-02f, -2.55860738e-03f, 1.01699628e-01f, 7.50126038e-03f, 9.75538194e-02f, 1.49233997e-01f,
  9.04275179e-02f, 1.53951496e-01f, 1.21635839e-01f, -3.99604961e-02f, 3.44726555e-02f, 3.78154940e-03f, 1.58278391e-01f, 1.12764925e-01f, 8.69887620e-02f, 5.71768880e-02f,
  -3.74916703e-01f, -7.00355172e-02f, 8.53626058e-03f, -2.03434043e-02f, 1.85395423e-02f, 2.01560259e-02f, -1.02533147e-01f, -2.86754165e-02f, -1.30147845e-01f, 3.30886580e-02f,
  -5.36402082e-03f, 1.14773490e-01f, 6.40238076e-02f, 3.84651683e-02f, -2.57789958e-02f, 1.61964372e-01f, 9.56200883e-02f, 1.47755161e-01f, 1.51246980e-01f, 8.99247080e-02f,
  1.18820831e-01f, 5.09613268e-02f, 3.30174752e-02f, -2.93615507e-04f, 4.60545868e-02f, -4.96582724e-02f, 2.16518585e-02f, 5.52492253e-02f, -3.84660736e-02f, -3.37211713e-02f,
  1.35751635e-01f, 5.71236238e-02f, 4.42470796e-02f, 1.41400238e-02f, 1.36680201e-01f, 1.64165109e-01f, 1.13003045e-01f, 1.11711204e-01f, 1.97714746e-01f, 4.50641699e-02f,
  1.49761140e-01f, 2.10829247e-02f, 8.20021853e-02f, 1.03818171e-01f, -1.01384513e-01f, 6.70464635e-02f, 5.39320055e-03f, 8.71923938e-02f, -4.66404520e-02f, 1.55214190e-01f,
  -1.08635295e-02f, -1.36232555e-01f, 2.92208511e-02f, -8.26211497e-02f, -6.21486828e-02f, -1.03133358e-01f, 3.76972258e-02f, -4.69002537e-02f, -8.85201693e-02f, -2.19909042e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.58912331e-01f, 9.04944316e-02f, 2.51730442e-01f, 2.51135349e-01f, 4.22485292e-01f, 1.47558644e-01f, -1.02421425e-01f, 1.10865422e-01f, 2.98374951e-01f, 2.15907156e-01f,
  -4.72045541e-02f, 3.00104439e-01f, 6.48645312e-02f, 1.76505372e-01f, -4.51427586e-02f, 2.57135123e-01f, -8.89480785e-02f, 1.97985649e-01f, 1.50470898e-01f, 1.93905011e-01f,
  -8.83054063e-02f, 6.45813271e-02f, 3.03430587e-01f, -5.78521891e-03f, -2.25245014e-01f, 1.27076015e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.60160156e-02f, 8.18312727e-03f, 1.42382029e-02f, 4.76275831e-02f, -2.68865726e-03f, -1.00662932e-01f, -7.05756173e-02f, -1.63782597e-01f, -3.43082510e-02f, 1.14003479e-01f,
  -8.60288516e-02f, -1.54804438e-01f, 3.96638773e-02f, 1.12193361e-01f, 2.58160383e-02f, 3.62456106e-02f, -1.20783553e-01f, 2.66907346e-02f, -9.38548148e-02f, -1.85438812e-01f,
  3.69368233e-02f, 2.35990927e-01f, -1.64962083e-01f, 1.34144127e-01f, -1.12573706e-01f, -1.39485642e-01f, 2.87699401e-02f, -8.50205496e-02f, -8.71764272e-02f, -3.17170471e-01f,
  1.13659561e-01f, -2.94394642e-02f, 2.62999418e-03f, -1.85149014e-01f, -4.61732261e-02f, 6.98605701e-02f, 1.72779307e-01f, 7.32617918e-03f, 1.13594249e-01f, -3.65539901e-02f,
  -1.18256338e-01f, -2.57755399e-01f, 2.06554353e-01f, 2.29806319e-01f, 8.37937817e-02f, 1.72512844e-01f, -1.69139042e-01f, 1.16171297e-02f, 2.93753177e-01f, 5.15689254e-01f,
  -9.18409079e-02f, -1.21346310e-01f, -1.86575353e-01f, -2.98136845e-02f, 2.92826649e-02f, -2.74403244e-01f, -1.22412942e-01f, -3.71780805e-03f, -2.06541717e-02f, -3.66321392e-02f,
  -5.84109090e-02f, -1.44046145e-02f, 1.07582770e-01f, 9.53590646e-02f, -2.23712460e-03f, -2.05621973e-01f, -5.33880442e-02f, -9.75935534e-02f, 5.63933179e-02f, -9.80254561e-02f,
  3.81998196e-02f, 2.89784484e-02f, -7.77224600e-02f, -1.06907925e-02f, -9.59860086e-02f, -4.13633250e-02f, 6.61418065e-02f, -8.34723935e-02f, -7.99731314e-02f, 9.22605991e-02f,
  2.90918462e-02f, 9.31565017e-02f, -2.91923806e-02f, 1.72305733e-01f, -9.05816481e-02f, -4.16000374e-03f, 1.08525753e-02f, -7.36292154e-02f, -5.27338795e-02f, 9.99338180e-02f,
  -2.30873376e-02f, 4.04049605e-02f, 8.30992870e-03f, 2.63618290e-01f, 2.31446370e-01f, -1.13238961e-01f, 4.39364240e-02f, 2.04498991e-01f, -3.98046188e-02f, -6.16538711e-02f,
  -3.15273181e-02f, -1.44426599e-01f, -1.07708596e-01f, 1.83690667e-01f, 9.68532450e-03f, -2.67536789e-01f, -3.19541357e-02f, -8.67076144e-02f, 5.31295761e-02f, -3.62896800e-01f,
  -9.02179405e-02f, -1.74783111e-01f, -5.37730902e-02f, -2.27951445e-02f, 1.89109802e-01f, 1.54003836e-02f, 1.30420253e-01f, 7.78228566e-02f, -6.75327256e-02f, 2.84102708e-01f,
  2.43511453e-01f, 7.54076466e-02f, -7.56442994e-02f, 2.90673852e-01f, 2.00713333e-02f, -4.15508986e-01f, 7.82281831e-02f, 1.55150339e-01f, -8.73433203e-02f, 7.59821534e-02f,
  1.22306883e-01f, -8.83599445e-02f, -1.23692445e-01f, -3.13274525e-02f, -2.77883410e-02f, 3.19694402e-03f, 5.63533865e-02f, -4.64935936e-02f, 4.73530479e-02f, -1.14677660e-01f,
  1.11801863e-01f, 4.20976207e-02f, -7.26149306e-02f, -9.90590304e-02f, -3.03883255e-02f, -4.80023511e-02f, 4.17362340e-02f, -6.14654236e-02f, -1.72265515e-01f, -7.67501369e-02f,
  -1.36079982e-01f, 7.58409426e-02f, 1.30649790e-01f, -4.02815593e-03f, 5.22224605e-03f, -3.58006507e-02f, -1.33791612e-02f, -1.01289906e-01f, -1.08343206e-01f, 7.16758743e-02f,
  -8.52819160e-02f, -1.23361759e-01f, 1.46190822e-01f, -3.10534872e-02f, -2.49909051e-02f, 6.49156496e-02f, -5.16657382e-02f, 2.78006434e-01f, -1.29874557e-01f, -1.76015213e-01f,
  -2.66954713e-02f, 9.38758850e-02f, -1.49486572e-01f, -4.94073480e-02f, 4.13406223e-01f, 2.86483206e-02f, 1.86324775e-01f, 7.23755583e-02f, -8.96600112e-02f, -2.19950173e-03f,
  -1.04943283e-01f, 1.57832474e-01f, -7.63641149e-02f, -1.19313560e-01f, 2.13458166e-01f, -8.61040577e-02f, 1.59686521e-01f, 1.36582553e-01f, -1.75696537e-01f, 5.56750484e-02f,
  -1.77062869e-01f, -1.65442660e-01f, 1.46511123e-01f, 1.33262686e-02f, -9.29513052e-02f, -1.55877337e-01f, -1.46716505e-01f, -7.25618191e-03f, 5.74174523e-02f, 5.49577847e-02f,
  -9.10190493e-02f, -5.45200184e-02f, -1.68357193e-01f, -1.80283844e-01f, -1.87983811e-01f, -3.99675407e-03f, -7.60913640e-02f, 5.91332763e-02f, 3.40832472e-02f, 3.96819487e-02f,
  -1.22233093e-01f, 1.81071520e-01f, 2.08533362e-01f, 3.70751247e-02f, -2.46500578e-02f, 4.45031840e-03f, -1.40895784e-01f, 1.70974225e-01f, -1.67197719e-01f, -1.81331247e-01f,
  -1.41288802e-01f, 7.14259297e-02f, 1.57881275e-01f, 1.18928455e-01f, -4.79925312e-02f, 8.42812564e-03f, 9.49540883e-02f, 3.52310613e-02f, -6.24914765e-02f, -8.01729038e-02f,
  1.19564578e-01f, -3.36296521e-02f, -7.41102174e-02f, 1.99303225e-01f, -1.76256262e-02f, -2.11089343e-01f, 1.63393527e-01f, 8.26551989e-02f, 1.62387714e-01f, -1.15971342e-01f,
  9.14628804e-03f, -2.07872525e-01f, 1.45843908e-01f, -4.85838242e-02f, 9.40724835e-02f, 1.16256699e-01f, 2.83789705e-03f, 5.12582660e-01f, -2.38446876e-01f, 3.92098501e-02f,
  -3.40206265e-01f, 1.70665801e-01f, -6.31586090e-03f, -1.15104429e-01f, -9.37943831e-02f, 1.37665957e-01f, -1.66331828e-01f, -6.64248765e-02f, -5.59082255e-02f, -7.99781010e-02f,
  1.30208999e-01f, -7.09759444e-02f, -7.56592751e-02f, 4.42809165e-02f, 5.90313133e-03f, -6.03442341e-02f, 8.66631791e-02f, 2.07660377e-01f, -9.58417449e-03f, 1.13184042e-01f,
  1.49132431e-01f, 6.18883893e-02f, 5.79709262e-02f, 3.30988094e-02f, -4.12130952e-02f, 1.81271240e-01f, -6.12369105e-02f, -1.95705980e-01f, -4.20436971e-02f, -1.23996638e-01f,
  5.95355481e-02f, 5.89841902e-02f, 2.32043818e-01f, -9.04687941e-02f, 1.96586564e-01f, 3.53997760e-02f, -1.56782076e-01f, -3.46188307e-01f, -7.71205276e-02f, 5.55807315e-02f,
  -4.68337648e-02f, 2.60702763e-02f, -5.00668660e-02f, 1.83736607e-02f, -5.90596497e-02f, 6.82997927e-02f, -2.92516053e-01f, -7.96365738e-02f, -3.20960104e-01f, 1.83074415e-01f,
  1.00447983e-01f, -2.03159332e-01f, 5.90786487e-02f, 8.18491802e-02f, 1.45527810e-01f, -1.12408906e-01f, 1.81301206e-01f, 8.69018883e-02f, 1.96901709e-02f, -1.01005182e-01f,
  7.00881556e-02f, -4.49307114e-01f, 2.93926597e-01f, -1.88364059e-01f, -8.60710144e-02f, 8.73001367e-02f, -2.48268127e-01f, 2.43830413e-01f, 2.48152539e-02f, 9.69166011e-02f,
  8.93835202e-02f, 7.19985962e-02f, 4.86854231e-03f, -1.81582179e-02f, 4.95339707e-02f, 1.93052343e-03f, 4.80101518e-02f, 1.80451095e-01f, -3.18683498e-02f, 1.32299572e-01f,
  -1.47901466e-02f, -1.48652317e-02f, -6.60563484e-02f, 3.48818377e-02f, -2.40775961e-02f, -2.88598500e-02f, 1.55520722e-01f, -7.79163986e-02f, 6.54890239e-02f, -4.37416658e-02f,
  -6.06815517e-03f, -1.62020788e-01f, -1.98942050e-02f, -1.24942474e-01f, -2.28735171e-02f, 2.78989464e-01f, -1.13195613e-01f, -1.15726948e-01f, 1.66454867e-01f, 3.08690965e-01f,
  2.02536255e-01f, 1.97191611e-01f, -7.18484372e-02f, 1.85745090e-01f, 5.89574948e-02f, 8.40142136e-04f, -1.20182790e-01f, -2.07106963e-01f, 1.07001523e-02f, -1.06545866e-01f,
  -5.67744263e-02f, -2.73016933e-03f, -4.04982299e-01f, 5.76444864e-02f, 6.13758378e-02f, -1.68769002e-01f, 4.20729339e-01f, -1.75080448e-01f, -2.81618178e-01f, -1.41937956e-01f,
  9.19504985e-02f, -1.16964117e-01f, 1.37070492e-01f, -1.78982802e-02f, 6.72962815e-02f, 4.02072430e-01f, 6.34453744e-02f, 1.16596200e-01f, -5.82073219e-02f, 7.71549270e-02f,
  -1.81654513e-01f, -5.08424304e-02f, -7.10441470e-02f, -1.44908288e-02f, 3.42079476e-02f, -9.42512229e-02f, 9.80421230e-02f, 6.62297904e-02f, 9.34550390e-02f, 1.33794118e-02f,
  1.89274445e-01f, 1.26907855e-01f, -5.03643416e-02f, 9.49749798e-02f, 1.48472318e-03f, 1.33025780e-01f, 1.58328354e-01f, -2.32960153e-02f, 4.43814658e-02f, 9.48169976e-02f,
  3.67278457e-02f, -2.00448886e-01f, 1.22613415e-01f, 1.44047692e-01f, -1.32818937e-01f, 3.92928123e-02f, 1.49882317e-01f, -8.09630379e-02f, -1.08846582e-01f, 1.16436101e-01f,
  3.07832509e-01f, 1.40299082e-01f, -3.55950892e-02f, -1.24751311e-02f, -1.43761218e-01f, 3.23730022e-01f, -8.07480067e-02f, -3.95297036e-02f, -9.73069444e-02f, -2.15397403e-01f,
  -1.52963907e-01f, -1.48998201e-01f, 1.33778498e-01f, 3.01490072e-02f, 1.20135553e-01f, 1.86114416e-01f, -4.88896102e-01f, -5.73895983e-02f, -2.71348152e-02f, -2.06741214e-01f,
  2.45043114e-01f, 1.36312857e-01f, -2.72415370e-01f, -7.57346824e-02f, 8.47322121e-02f, 7.71289095e-02f, 1.29924029e-01f, -3.06552857e-01f, 4.63169925e-02f, 4.73189235e-01f,
  -1.25809863e-01f, 1.41180614e-02f, -4.24949825e-03f, -5.46117797e-02f, -8.12850147e-02f, 1.10427879e-01f, 1.09298132e-01f, -1.20818809e-01f, -1.80258274e-01f, -5.11218570e-02f,
  -2.08940953e-01f, -1.03001900e-01f, -2.23833509e-02f, -1.58437729e-01f, -1.95289448e-01f, -2.26522222e-01f, -9.72196925e-03f, -5.39492704e-02f, 2.95678210e-02f, 4.26087007e-02f,
  -9.47006047e-02f, 5.33225425e-02f, 1.17878832e-01f, -8.15719813e-02f, -1.16497308e-01f, 5.34392670e-02f, -2.02319577e-01f, 5.91898523e-02f, -1.00902818e-01f, -2.17129458e-02f,
  1.73410457e-02f, -1.79326132e-01f, 4.78981063e-02f, -1.53903499e-01f, -1.11770131e-01f, -6.43720478e-02f, -1.11806683e-01f, -9.79654118e-02f, -2.24356383e-01f, -1.79374412e-01f,
  1.60422772e-01f, -2.09660351e-01f, 3.45836468e-02f, 7.04152361e-02f, 1.85524095e-02f, 1.60214916e-01f, 2.03934275e-02f, 6.27427176e-02f, -1.42898887e-01f, -4.40913923e-02f,
  3.30451988e-02f, 9.52590629e-02f, -9.95324627e-02f, -1.48568898e-02f, -7.44285509e-02f, -1.13831364e-01f, 7.33200088e-02f, 1.50021568e-01f, 2.50377953e-01f, -1.20983444e-01f,
  -1.08410068e-01f, 1.27011225e-01f, 7.60282353e-02f, -3.81140351e-01f, 1.94718838e-01f, -1.59440711e-01f, 2.96796113e-01f, 1.21610686e-01f, -7.77337179e-02f, 5.09070419e-02f,
  -1.78964138e-01f, -3.98104712e-02f, 4.85864654e-02f, -5.94462603e-02f, 1.69725437e-02f, -1.68143548e-02f, 1.60777256e-01f, -6.66360930e-02f, 3.10628295e-01f, 1.39549270e-01f,
  -4.80463402e-03f, -3.86077142e-03f, 5.29069938e-02f, 1.03929147e-01f, 2.51255989e-01f, -8.04662332e-03f, 5.54719009e-02f, 3.95592786e-02f, 1.29022375e-02f, -1.03882730e-01f,
  1.58540815e-01f, -7.69848228e-02f, 5.16782887e-02f, 2.54497349e-01f, 4.56749685e-02f, 2.03279674e-01f, 4.07659560e-02f, -1.36696890e-01f, 4.03955467e-02f, 1.19123407e-01f,
  1.38408050e-01f, -5.38107082e-02f, 9.16458368e-02f, -5.35796508e-02f, 7.77154267e-02f, 3.37147713e-02f, -1.33840635e-01f, -8.60094652e-02f, 5.85196652e-02f, -1.22641683e-01f,
  -1.78496540e-01f, -9.44809839e-02f, 3.95447388e-02f, -1.14150845e-01f, 3.08186382e-01f, -4.38090228e-03f, -3.58191431e-02f, -3.29596490e-01f, -6.27229735e-03f, -6.89368472e-02f,
  -1.59345120e-01f, 1.04245909e-01f, -1.82257071e-02f, 1.61130488e-01f, -1.96861178e-02f, -6.92997202e-02f, 1.20109981e-02f, -2.01692000e-01f, 1.41280234e-01f, 1.07401296e-01f,
  2.18910426e-02f, -4.78528813e-02f, 2.56020069e-01f, -3.30527306e-01f, -6.41803220e-02f, -1.31088465e-01f, 5.17157055e-02f, -6.83501437e-02f, -3.43137495e-02f, -1.59448236e-02f,
  -6.48242887e-03f, -1.83777343e-02f, -2.24519223e-02f, -5.23802675e-02f, 2.28902493e-02f, 6.12812303e-02f, 1.16074368e-01f, -1.04213111e-01f, 3.30478698e-02f, -7.02486187e-02f,
  -9.99083593e-02f, 1.16261147e-01f, -6.12653152e-04f, -1.05895847e-01f, 8.77923444e-02f, 6.96395291e-03f, 1.97131000e-02f, -2.04134464e-01f, 9.40652341e-02f, -1.82676390e-01f,
  -8.28926638e-02f, -4.02588993e-02f, -1.80857442e-02f, 5.46760624e-03f, 2.65775412e-01f, 1.06996648e-01f, -2.82998174e-01f, -8.45835637e-03f, -2.08450351e-02f, 1.01023570e-01f,
  -9.60166305e-02f, -1.73857883e-01f, -1.11990042e-01f, -1.19403444e-01f, 2.48118006e-02f, -1.07174978e-01f, -7.03488514e-02f, 1.59192190e-01f, -2.87073851e-01f, 1.69364318e-01f,
  -7.45682642e-02f, 5.64582162e-02f, -5.95376901e-02f, -4.86797541e-02f, 1.17884710e-01f, -2.72216827e-01f, 1.87457204e-01f, 2.49167517e-01f, -4.70412225e-02f, -2.53090888e-01f,
  1.20611615e-01f, 1.66159704e-01f, 3.18303347e-01f, -1.06872104e-01f, 2.62599379e-01f, -6.54651597e-02f, 3.35993990e-03f, 3.31775814e-01f, -1.53466552e-01f, -1.24354117e-01f,
  -1.00615978e-01f, -9.41130593e-02f, 1.09479293e-01f, 1.62188843e-01f, 1.27060682e-01f, 9.19560567e-02f, -1.02913305e-02f, -3.76305804e-02f, 1.25439346e-01f, -2.15733461e-02f,
  -2.07607001e-02f, -2.30089426e-02f, 1.22153647e-01f, 8.71680751e-02f, -7.94447884e-02f, -4.56974432e-02f, -7.29684085e-02f, -4.22249287e-02f, 2.42074206e-03f, -3.06451693e-02f,
  -7.64850825e-02f, -3.61509100e-02f, -4.61022332e-02f, -6.19386248e-02f, 9.10669714e-02f, -5.00504710e-02f, -2.11760774e-02f, 2.28490215e-02f, 1.76538780e-01f, 1.04179222e-03f,
  -4.98635024e-02f, -1.01025060e-01f, -1.40079632e-01f, 8.76694694e-02f, -2.10300251e-03f, 7.50908861e-03f, 3.53368334e-02f, 1.20065600e-01f, -3.96482617e-01f, 2.12467536e-01f,
  -5.99002168e-02f, -1.90519795e-01f, 1.81427702e-01f, -1.91381156e-01f, -6.26156898e-03f, -1.88771397e-01f, 2.85080403e-01f, 1.51670901e-02f, -1.83270350e-01f, -1.49093747e-01f,
  1.10408507e-01f, 2.75703371e-01f, 7.76532367e-02f, -1.29809514e-01f, 1.69981241e-01f, 1.07583953e-02f, 2.40463212e-01f, -9.21608228e-03f, -1.42758191e-01f, -3.43765736e-01f,
  1.35395393e-01f, -1.65360540e-01f, -1.72121659e-01f, -8.02549273e-02f, 2.24503025e-01f, 1.78651914e-01f, 1.33120224e-01f, 8.71618539e-02f, -9.12668705e-02f, 2.61329282e-02f,
  2.72091895e-01f, 8.13056678e-02f, -1.59825519e-01f, -3.73956785e-02f, -1.25283942e-01f, -1.22805215e-01f, 1.11117169e-01f, -3.65288109e-02f, -5.51842377e-02f, 3.10443882e-02f,
  5.73258363e-02f, 8.79944582e-03f, 1.01977266e-01f, 2.50637028e-02f, 2.36259654e-01f, 2.07524091e-01f, 2.45532617e-02f, 1.19166590e-01f, -8.97565112e-02f, -2.10020170e-01f,
  -7.46040121e-02f, -1.84485763e-02f, -8.30960348e-02f, -1.62084103e-01f, 1.87128931e-01f, -4.89475168e-02f, 1.27807543e-01f, -4.35531102e-02f, 1.30851984e-01f, 1.29262313e-01f,
  5.20629324e-02f, 4.02477905e-02f, -5.80685288e-02f, -1.95753813e-01f, 7.20685571e-02f, -8.31710361e-03f, 3.89655799e-01f, 2.12938264e-02f, -1.22718543e-01f, -1.30766844e-02f,
  -1.05547369e-01f, -4.39769514e-02f, -2.25819975e-01f, 2.95477450e-01f, -1.56694204e-01f, 1.17195755e-01f, -2.33036024e-03f, -5.50948419e-02f, 2.01978032e-02f, 1.41314298e-01f,
  -3.09201386e-02f, 9.08011049e-02f, 8.58703032e-02f, -5.54009415e-02f, 1.72866002e-01f, -1.88533083e-01f, -5.37712649e-02f, 9.45860296e-02f, 1.03205591e-01f, 2.57501323e-02f,
  -3.20315622e-02f, -8.55682194e-02f, -1.30006433e-01f, -2.93608773e-02f, -1.59060583e-01f, 4.83291037e-02f, 2.72991974e-02f, -5.25856055e-02f, -1.00140937e-01f, -5.69412895e-02f,
  -2.03572571e-01f, 1.32088423e-01f, -1.31539315e-01f, -4.34606485e-02f, 7.46310577e-02f, -1.15444429e-01f, 5.31417727e-02f, 2.57178973e-02f, 1.10521935e-01f, 1.73676476e-01f,
  1.45802563e-02f, -2.43512690e-01f, -2.83264890e-02f, -1.61028162e-01f, -1.19327642e-01f, -3.94411087e-02f, -4.10367921e-02f, 8.90318230e-02f, 2.39806343e-02f, 4.67145480e-02f,
  -7.09722191e-02f, 3.14386860e-02f, 1.66649893e-02f, 1.30897880e-01f, -5.13994247e-02f, -8.94800797e-02f, -3.55213463e-01f, -2.02568114e-01f, 9.42320228e-02f, 2.60771036e-01f,
  2.57203549e-01f, -1.93080101e-02f, 6.80805892e-02f, 6.76871762e-02f, -3.92766535e-01f, -2.25848168e-01f, 5.24532236e-02f, -2.20652372e-01f, -2.69974824e-02f, 2.02885360e-01f,
  5.09687103e-02f, -1.72295362e-01f, -1.75803408e-01f, 1.97498575e-01f, -7.33613363e-03f, 1.90667093e-01f, 3.35053839e-02f, -1.85184464e-01f, 1.21857531e-01f, -2.24535674e-01f,
  4.60475944e-02f, 7.06730559e-02f, 2.18001734e-02f, -1.85848661e-02f, -2.70587564e-01f, 7.49182552e-02f, -1.94678590e-01f, 3.87618504e-02f, -1.49518535e-01f, 4.08960208e-02f,
  -2.95381490e-02f, -9.93886441e-02f, -1.43410727e-01f, -2.24650353e-01f, -2.52847493e-01f, -1.49234921e-01f, -3.02425660e-02f, -9.43202451e-02f, 8.79353285e-02f, -1.14145778e-01f,
  -8.50536749e-02f, -2.37610608e-01f, 2.73059875e-01f, -1.38649382e-02f, -7.44081065e-02f, -1.73679627e-02f, -7.98181742e-02f, 2.11447347e-02f, -2.02117249e-01f, -1.78270206e-01f,
  4.77643199e-02f, -1.02276236e-01f, 6.23428710e-02f, -1.27791181e-01f, 8.22571740e-02f, 1.41042545e-01f, 6.48191795e-02f, 9.55279022e-02f, 4.80781682e-02f, 1.01138391e-01f,
  1.15742348e-01f, -1.00955591e-02f, 2.16677204e-01f, 3.14904183e-01f, 3.14582050e-01f, 4.21785414e-02f, 1.19728580e-01f, 3.03541064e-01f, -1.16076432e-01f, 1.47729024e-01f,
  -2.18870252e-01f, -7.14555755e-02f, -1.32061198e-01f, -1.70452610e-01f, 3.34336087e-02f, -1.28935082e-02f, -4.98053990e-02f, 1.96781710e-01f, -2.72802889e-01f, -2.44152732e-02f,
  -3.25611569e-02f, -3.37802768e-01f, -1.00407191e-01f, 9.92293656e-02f, 4.66753729e-02f, -4.61764187e-02f, -1.49006784e-01f, -4.65383382e-05f, -7.11615831e-02f, -5.29786199e-02f,
  4.80385460e-02f, 5.48061952e-02f, -7.18268156e-02f, -1.69386324e-02f, 3.50890830e-02f, -1.05642766e-01f, 2.94807702e-02f, 2.28751376e-02f, -2.38275260e-01f, 8.13571811e-02f,
  -2.34174746e-04f, -1.42032811e-02f, -7.64299929e-02f, -1.20130219e-01f, -1.40345246e-01f, -2.68444680e-02f, 1.03942767e-01f, -9.13751647e-02f, 1.76650763e-01f, -1.12126350e-01f,
  -1.40988916e-01f, 1.11313462e-01f, -2.38678142e-01f, -1.36171713e-01f, -1.07946008e-01f, 7.33383745e-02f, 1.18502215e-01f, 7.63876811e-02f, -6.45413324e-02f, -1.82840358e-02f,
  1.97734252e-01f, 6.46609301e-03f, 1.23585045e-01f, -9.68302712e-02f, 1.23347707e-01f, -1.65378660e-01f, -1.19639672e-01f, 5.03414981e-02f, -1.24969408e-01f, -9.99099389e-02f,
  2.96751577e-02f, 1.19673282e-01f, 1.50951684e-01f, -1.21159539e-01f, -3.71101536e-02f, -1.51148275e-01f, 1.28014117e-01f, -1.02261886e-01f, -1.06905058e-01f, 1.36755615e-01f,
  1.61851555e-01f, 2.97984213e-01f, -2.33008683e-01f, 4.26812805e-02f, 8.50781575e-02f, 4.70853150e-02f, -1.47297144e-01f, 1.81281772e-02f, -1.75778985e-01f, -1.24166524e-02f,
  -1.66001599e-02f, -1.50459796e-01f, 1.31575406e-01f, -9.60579067e-02f, -4.58762683e-02f, -2.65176152e-03f, 2.31490787e-02f, 1.25808060e-01f, 2.65444741e-02f, -6.00106977e-02f,
  2.77605802e-02f, -8.14578086e-02f, 5.88864870e-02f, -1.23804891e-02f, -2.66799591e-02f, -6.24032803e-02f, 1.85276158e-02f, 3.00163031e-02f, -1.20163411e-02f, 5.70294261e-02f,
  -3.12664621e-02f, 1.01532422e-01f, -4.96056303e-02f, 7.72810429e-02f, 2.15123333e-02f, 1.90517530e-01f, 6.81171715e-02f, -6.39225617e-02f, -1.46483004e-01f, 5.66484034e-02f,
  9.12873000e-02f, -1.31460994e-01f, -5.83618432e-02f, -7.05899596e-02f, 6.60184994e-02f, 1.69986397e-01f, 9.78552774e-02f, -2.60453466e-02f, 5.92605360e-02f, -8.54900852e-02f,
  -3.04932445e-02f, -2.72263706e-01f, 1.89740703e-01f, 9.72853750e-02f, -7.84727260e-02f, 1.15880683e-01f, -2.46458232e-01f, 2.16074586e-02f, 2.46117219e-01f, 2.12263435e-01f,
  -2.62646731e-02f, 8.67792219e-02f, -5.60432300e-02f, 1.38611421e-01f, 1.35380387e-01f, -3.39064211e-01f, 1.62044205e-02f, -5.45317382e-02f, 1.73318386e-02f, 2.09154516e-01f,
  -5.31017184e-02f, -3.10602691e-02f, -5.36876284e-02f, -1.49850115e-01f, 2.49304250e-02f, 4.21177596e-02f, -1.07173331e-01f, -1.35881277e-02f, 5.32916375e-02f, -8.13895464e-02f,
  1.32815912e-01f, 6.39366731e-02f, -5.24548348e-03f, -2.60381736e-02f, -8.86848643e-02f, -3.61027978e-02f, 9.71208215e-02f, 1.08513147e-01f, 2.92008705e-02f, 5.58902994e-02f,
  1.78080663e-01f, -1.31478077e-02f, 3.65870148e-02f, 6.28794655e-02f, 3.57241966e-02f, 6.30147010e-02f, 3.38923419e-03f, 2.36331895e-02f, -1.15793496e-01f, -7.44013563e-02f,
  1.57229871e-01f, -5.11931963e-02f, 5.19281588e-02f, 2.10498914e-01f, -2.47551631e-02f, -1.51148155e-01f, -2.13682860e-01f, 2.13527568e-02f, -5.70563413e-02f, 1.24151455e-02f,
  -1.88878924e-01f, -2.43413657e-01f, -1.73966765e-01f, 1.34553999e-01f, 1.42275423e-01f, -1.44978896e-01f, 3.24571222e-01f, 2.44484916e-01f, 3.39915864e-02f, -1.60821199e-01f,
  -3.40062499e-01f, -6.69297501e-02f, 1.23947978e-01f, 1.47396345e-02f, 1.44559164e-02f, -1.92730632e-02f, 1.13889582e-01f, 5.14381379e-02f, -1.47790849e-01f, -3.13195497e-01f,
  2.47216508e-01f, 1.06013641e-01f, -6.27379417e-02f, 1.62326023e-01f, 8.70973691e-02f, -4.07259792e-01f, -8.00898597e-02f, 8.03927481e-02f, 2.40431409e-02f, -4.50970680e-02f,
  1.20364301e-01f, -6.21045101e-03f, 1.00096442e-01f, 4.41937707e-02f, -5.84976450e-02f, -9.41223577e-02f, 6.84015304e-02f, 8.16113800e-02f, 5.88434935e-02f, -1.59456357e-02f,
  2.08160114e-02f, -8.21427628e-02f, -1.38749138e-01f, -1.61302209e-01f, -1.01554915e-02f, -1.03983730e-01f, -1.06542438e-01f, -1.68583348e-01f, -3.01280990e-02f, 2.51687337e-02f,
  -1.11438558e-01f, -7.23496005e-02f, 1.45660453e-02f, -1.18427955e-01f, -1.22647874e-01f, 5.83007187e-02f, -1.51536748e-01f, -1.10636927e-01f, -1.98067427e-01f, -1.48945022e-02f,
  5.87392636e-02f, 1.17025159e-01f, 3.13605368e-02f, -1.00023299e-02f, 1.64851949e-01f, 8.64544883e-02f, -3.62678111e-01f, 2.36887876e-02f, 7.15291947e-02f, -1.00986153e-01f,
  -2.04445645e-02f, 5.10141551e-02f, 1.93052609e-02f, -2.22922355e-01f, 9.71662849e-02f, 2.01920345e-01f, -1.74255654e-01f, -8.60086307e-02f, -2.25196153e-01f, -5.96898980e-02f,
  -4.35774587e-02f, -1.09880589e-01f, 9.04708505e-02f, -3.69454235e-01f, -7.15144910e-03f, 2.41415054e-02f, 2.63594240e-01f, -6.25002086e-02f, 1.57708481e-01f, 6.08025454e-02f,
  2.14196220e-01f, -1.92976952e-01f, -1.22470520e-01f, 7.15391114e-02f, -2.54059285e-02f, -6.60887733e-02f, 7.19464794e-02f, -1.62412915e-02f, -6.29986450e-02f, -8.38317946e-02f,
  7.70627987e-03f, -1.46830594e-02f, -9.72541943e-02f, 2.99093574e-02f, -2.34110311e-01f, -3.98844704e-02f, -9.22363251e-02f, -6.04539178e-02f, -1.31489903e-01f, 2.19669472e-02f,
  2.09200457e-02f, 2.25578118e-02f, -1.26826972e-01f, -2.32621953e-01f, -1.35781849e-02f, 5.98728582e-02f, 5.26126698e-02f, 1.84756130e-01f, 5.94311133e-02f, -6.20424673e-02f,
  2.12641470e-02f, -2.09132046e-01f, -1.12780504e-01f, 2.48949509e-02f, 2.52016867e-03f, -1.22856446e-01f, 1.28044307e-01f, 1.66254491e-01f, 5.70538417e-02f, 1.01345070e-01f,
  2.33639508e-01f, -4.86776792e-02f, -2.41708495e-02f, 1.58094689e-01f, -1.80289656e-01f, -4.87859547e-02f, 3.48093435e-02f, 2.58981287e-01f, -6.16994277e-02f, 9.43347290e-02f,
  1.99997827e-01f, 2.34353855e-01f, 8.88298154e-02f, -1.96209639e-01f, -7.77022541e-02f, 2.33648330e-01f, -1.10750809e-01f, 8.26537982e-03f, -3.47463310e-01f, -2.26859614e-01f,
  -3.55146900e-02f, 2.85510570e-01f, -1.34155020e-01f, 3.28521132e-01f, -1.08802624e-01f, -2.71058679e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.69504389e-01f, 3.01132709e-01f, 2.12368861e-01f, 6.45995364e-02f, 3.67193297e-02f, 2.78686732e-01f, 1.83231220e-01f, 2.29033396e-01f, 2.23531410e-01f, 1.92878962e-01f,
  3.86473127e-02f, 1.27242059e-01f, 4.27304469e-02f, 1.52505815e-01f, 1.64097354e-01f, 1.78882495e-01f, -2.04090145e-03f, 1.22285329e-01f, 1.51406378e-01f, -2.66108155e-01f,
  2.22510055e-01f, 1.30121648e-01f, 2.01412842e-01f, -1.04004078e-01f, -1.06488883e-01f, -1.48895577e-01f, -5.62222637e-02f, 2.06668332e-01f, 5.51642291e-02f, 1.84690997e-01f,
  4.06987928e-02f, 2.17137992e-01f, -2.27215275e-01f, 6.75594211e-02f, 6.11280538e-02f, 5.85517623e-02f, -4.20969538e-02f, -2.17371210e-01f, -2.04759240e-01f, -3.52611914e-02f,
  2.95073599e-01f, 3.34905893e-01f, 1.12958588e-01f, -3.61316681e-01f, -1.18190825e-01f, -1.03640720e-01f, -3.48229975e-01f, -2.67658055e-01f, -1.17338546e-01f, -5.28701544e-02f,
  -1.41501529e-02f, 1.46780759e-01f, 1.95577726e-01f, -2.57318895e-02f, -9.77206826e-02f, 4.41305339e-01f, 9.30034090e-03f, 5.06541312e-01f, -9.15421918e-03f, -1.35250896e-01f,
  2.96883792e-01f, -4.77363408e-01f, -1.10566691e-01f, 8.70248396e-03f, -1.99981928e-01f, 3.15034352e-02f, 1.18253186e-01f, 9.08953175e-02f, 1.61395609e-01f, -6.82375655e-02f,
  2.01740175e-01f, 6.26963973e-02f, 2.76406091e-02f, 5.14885634e-02f, 2.11556137e-01f, 1.37377962e-01f, 5.56966879e-05f, 2.27627233e-01f, 2.27468863e-01f, 7.99806565e-02f,
  -5.96439652e-02f, 2.76316345e-01f, 1.79247465e-02f, 1.19154081e-01f, -2.48951316e-01f, -1.84054926e-01f, -1.32105216e-01f, -2.09699973e-01f, 2.07507670e-01f, -1.74010247e-01f,
  2.20764726e-01f, 7.38034770e-02f, -9.53353271e-02f, 3.65165323e-01f, -1.23660892e-01f, -6.78332672e-02f, 7.16415122e-02f, -6.00026250e-02f, 3.08687240e-02f, 1.25026092e-01f,
  -8.74676034e-02f, 6.93689138e-02f, -1.74822286e-02f, 2.70446483e-02f, -4.64785308e-01f, -7.76051730e-02f, -3.68232727e-01f, 5.12433425e-02f, -9.38632116e-02f, -1.20377980e-01f,
  -1.30731210e-01f, -2.15584114e-01f, 1.50234684e-01f, -7.77787045e-02f, 3.25609028e-01f, 1.64333835e-01f, -9.05546546e-02f, 3.16046476e-01f, 7.34411478e-02f, -3.82748127e-01f,
  3.88527781e-01f, -3.05507720e-01f, 1.68576032e-01f, 3.37148666e-01f, -1.83170527e-01f, 1.74986571e-01f, -6.83560669e-02f, 5.14729582e-02f, 1.57499492e-01f, 1.21888548e-01f,
  -1.18971325e-01f, 8.49163607e-02f, -8.76737908e-02f, -1.07559346e-01f, -2.13695168e-01f, 5.95012717e-02f, -1.65482294e-02f, -3.95577922e-02f, 1.21549532e-01f, 1.31741166e-01f,
  9.53163020e-03f, 1.35339564e-02f, -1.41462058e-01f, 1.03694886e-01f, 2.09808070e-03f, 3.87677774e-02f, 2.88113281e-02f, 6.58366689e-03f, -2.95225997e-02f, -1.34270536e-02f,
  9.75603387e-02f, -2.87737735e-02f, 8.12982470e-02f, -6.99962825e-02f, 1.47981390e-01f, 1.27355143e-01f, -2.67747164e-01f, -2.25674063e-01f, -3.34918261e-01f, 3.29444468e-01f,
  -3.90661992e-02f, -2.62036771e-01f, 1.92904085e-01f, 1.96169630e-01f, 1.16694361e-01f, 3.56885105e-01f, 1.25756189e-01f, 6.49768710e-02f, -5.60711548e-02f, 4.84562039e-01f,
  1.36416957e-01f, 6.63319454e-02f, -2.99183339e-01f, 3.96709770e-01f, -1.98086649e-01f, -3.17369342e-01f, 3.10637146e-01f, 1.46097010e-02f, -1.94190949e-01f, -2.37716157e-02f,
  -3.56027186e-01f, 2.20101506e-01f, -7.17771426e-02f, -3.22195217e-02f, 1.90042779e-02f, 6.86450908e-03f, 1.93526059e-01f, 1.00588687e-02f, -9.97943133e-02f, 3.68514836e-01f,
  -1.44458964e-01f, -2.39221454e-01f, 6.27023876e-02f, 8.83976743e-02f, 5.07036299e-02f, 1.70059964e-01f, 1.36520891e-02f, -1.77541688e-01f, 4.41682413e-02f, -1.18410639e-01f,
  7.29504153e-02f, 1.13175467e-01f, 2.73326665e-01f, 1.92071483e-01f, 3.24286491e-01f, 3.92061360e-02f, 1.84065968e-01f, 1.07074015e-01f, 1.01385871e-02f, 6.05285205e-02f,
  5.45307063e-02f, 1.43337056e-01f, -2.98657089e-01f, -1.05486445e-01f, -1.98671386e-01f, -8.40967929e-04f, 1.98933065e-01f, -3.57246757e-01f, 8.92136097e-02f, -5.80674186e-02f,
  -4.03751582e-02f, -1.19212270e-01f, -4.09645051e-01f, -1.41743883e-01f, 1.10312872e-01f, -8.90945718e-02f, -1.41011119e-01f, 2.33785789e-02f, 6.63585067e-02f, 3.80269289e-02f,
  -1.01792865e-01f, 2.45850801e-01f, -1.44542098e-01f, -2.52449393e-01f, 9.11075026e-02f, 2.99639106e-01f, -8.13177824e-02f, 9.03425366e-02f, -2.41712585e-01f, -1.84513815e-02f,
  2.60797381e-01f, 2.65388370e-01f, 8.48780870e-02f, 9.42616686e-02f, -6.78973570e-02f, -6.60140365e-02f, 3.71141098e-02f, -4.28306073e-01f, 2.31119484e-01f, 1.30186288e-03f,
  2.40094051e-01f, 9.73527059e-02f, -6.74483255e-02f, 1.51698798e-01f, -2.30501369e-01f, 2.89474018e-02f, -8.30546618e-02f, 4.49762531e-02f, -1.35984287e-01f, -1.39220849e-01f,
  -1.18672445e-01f, -1.01939797e-01f, 7.41566867e-02f, 1.63516533e-02f, 1.93895549e-01f, 1.04880348e-01f, 2.06709951e-01f, 1.52291194e-01f, -2.09818169e-01f, -3.27845216e-02f,
  5.64657385e-03f, 1.68340296e-01f, 1.84781209e-01f, 1.19993821e-01f, -1.90802757e-02f, -4.22806926e-02f, -3.98091003e-02f, -3.41868103e-01f, 8.76933187e-02f, 2.92769782e-02f,
  1.16300665e-01f, 4.98256050e-02f, -1.09784827e-01f, 3.95436352e-03f, -2.56572247e-01f, -5.72310202e-02f, 7.19047990e-03f, 1.23317026e-01f, -5.70894293e-02f, -1.70008570e-01f,
  4.88569736e-02f, 8.15365985e-02f, -9.18237716e-02f, 2.18491003e-01f, 1.33210108e-01f, -2.20405646e-02f, -8.10956582e-02f, 2.92662799e-01f, -7.47011527e-02f, -1.83483198e-01f,
  1.01386872e-03f, 3.05385321e-01f, -1.13668386e-02f, -1.24164000e-02f, 2.87488401e-01f, -5.97442798e-02f, 2.04184905e-01f, -1.43133014e-01f, -2.79372126e-01f, 3.42454225e-01f,
  5.68664297e-02f, 1.75298452e-01f, -1.15438432e-01f, -2.42647573e-01f, 7.94973038e-03f, 1.59323007e-01f, 3.46212760e-02f, 2.45134160e-01f, -2.02294439e-01f, 4.54539619e-02f,
  6.29845113e-02f, 1.88629061e-01f, -2.64263991e-02f, 1.20215468e-01f, 2.51810383e-02f, 1.57424152e-01f, 3.57706137e-02f, 8.78750458e-02f, -6.06684051e-02f, 1.12980949e-02f,
  2.32106984e-01f, 8.30729753e-02f, -4.55718450e-02f, -2.45158598e-02f, 9.07867327e-02f, -1.11776264e-02f, -3.84227838e-03f, 8.32251087e-02f, 9.74091217e-02f, -1.23084448e-01f,
  1.43467382e-01f, 2.44211201e-02f, 1.41234353e-01f, 6.50978228e-03f, 2.16212779e-01f, 4.72176298e-02f, 1.27480388e-01f, 8.53905603e-02f, 6.80738837e-02f, 2.43511107e-02f,
  1.18338548e-01f, -8.55830833e-02f, 9.15977582e-02f, 3.37660238e-02f, 1.16996258e-01f, 3.35953273e-02f, -8.07401687e-02f, 8.93092081e-02f, 1.92113206e-01f, -1.82898879e-01f,
  6.35617599e-03f, 6.67552710e-01f, -2.33880833e-01f, -9.26189646e-02f, 9.90286618e-02f, 7.64289126e-02f, -2.80489326e-01f, 3.04054797e-01f, -1.83904260e-01f, -3.30959350e-01f,
  -9.28207412e-02f, -4.55744639e-02f, -2.33124539e-01f, 2.08948717e-01f, 9.07253399e-02f, -9.39542130e-02f, 1.21777579e-01f, 1.56604126e-01f, 3.73174436e-03f, 1.10279299e-01f,
  5.04331551e-02f, 4.94474739e-01f, 1.50640056e-01f, 4.69249673e-03f, -3.38080712e-02f, 1.40415281e-01f, 1.88446224e-01f, 1.05893016e-01f, 5.01419529e-02f, 8.31483379e-02f,
  -6.40874729e-02f, -3.31294723e-02f, -4.87650409e-02f, -5.39084449e-02f, 7.81561062e-02f, -1.37571454e-01f, 1.32275224e-01f, 1.46813914e-02f, 1.43199697e-01f, 1.91973876e-02f,
  6.53232336e-02f, -7.78183714e-02f, 1.74717322e-01f, 2.20650032e-01f, -7.50591531e-02f, 6.65953308e-02f, 1.31828740e-01f, -4.90607880e-02f, 7.23282918e-02f, 4.18063737e-02f,
  1.13517985e-01f, 2.69568115e-02f, -1.02486581e-01f, -1.74310446e-01f, 3.26053798e-02f, 2.45855540e-01f, 1.17558442e-01f, -1.30035996e-01f, 1.21814631e-01f, -4.44871671e-02f,
  3.92733999e-02f, 1.47829074e-02f, 1.89002603e-01f, 1.66078940e-01f, -1.26425987e-02f, -1.83939695e-01f, 1.67741939e-01f, 1.19570084e-01f, 2.51312971e-01f, -8.28182697e-02f,
  1.27568603e-01f, 2.48137429e-01f, 7.83252642e-02f, 4.01461065e-01f, 1.22510061e-01f, 3.40214550e-01f, 1.13853440e-01f, -3.39331180e-01f, 3.38945305e-03f, 2.39234060e-01f,
  9.15498808e-02f, -2.72613078e-01f, -9.81428921e-02f, 2.01830745e-01f, 2.53907442e-01f, -1.25122592e-01f, -3.48497857e-03f, -1.07894614e-01f, 2.00338989e-01f, 1.50060356e-01f,
  8.89772102e-02f, 1.63737953e-01f, 2.14273646e-01f, 7.77649507e-02f, 7.58941844e-02f, -8.70058313e-02f, 2.64801562e-01f, 1.47217559e-02f, 2.22008333e-01f, 1.38291597e-01f,
  1.12575196e-01f, 1.27936512e-01f, 2.40110844e-01f, 4.05491740e-02f, 1.62591919e-01f, 1.54399261e-01f, 6.88792169e-02f, 1.36285245e-01f, -3.52168307e-02f, -8.28643367e-02f,
  -8.93186182e-02f, 2.68691659e-01f, 2.29827791e-01f, -2.61385199e-02f, 2.82761157e-01f, -2.46705115e-02f, 3.41648459e-02f, -3.03600985e-03f, -7.32508153e-02f, 1.30329207e-01f,
  -2.23650470e-01f, -1.27975985e-01f, -1.71510592e-01f, -1.52065568e-02f, 7.88682178e-02f, 1.49819449e-01f, 1.57072991e-01f, 6.69120625e-02f, -3.11186552e-01f, 1.54709175e-01f,
  -2.42061555e-01f, 3.94622386e-01f, -1.34135261e-01f, 1.28666401e-01f, 3.60801071e-01f, -3.67755204e-01f, 5.75970300e-02f, -1.46998689e-01f, -1.01766706e-01f, 1.69768468e-01f,
  -1.36276588e-01f, 1.87363431e-01f, 1.90142505e-02f, 1.84946805e-02f, 4.18689162e-01f, -2.02576980e-01f, 1.53116480e-01f, -3.28120887e-02f, -5.28449826e-02f, 1.45853937e-01f,
  3.61988097e-02f, -1.45624736e-02f, 1.32621214e-01f, 6.77458663e-03f, 3.31107341e-02f, 1.23216368e-01f, 1.53103933e-01f, -2.01207381e-02f, 5.54459579e-02f, 9.15058255e-02f,
  1.60257787e-01f, 4.88593839e-02f, 8.24714825e-02f, 7.72206066e-03f, 2.06989750e-01f, -2.95324009e-02f, 8.95751119e-02f, 3.41163576e-02f, 2.19814017e-01f, 5.51841557e-02f,
  3.20781261e-01f, -2.89830983e-01f, -3.62833999e-02f, 9.00496021e-02f, 1.24253660e-01f, 1.10475495e-01f, 1.88734770e-01f, -3.92854333e-01f, 1.23346530e-01f, 1.75652146e-01f,
  -8.43316913e-02f, -2.02752411e-01f, -1.66276366e-01f, 1.78318337e-01f, 3.69027001e-03f, 9.77922603e-02f, -6.40810877e-02f, -7.36414045e-02f, 1.05720848e-01f, 3.54104340e-02f,
  2.20523551e-01f, 1.21000357e-01f, 2.58383363e-01f, 4.03921336e-01f, -6.91852793e-02f, -8.21077749e-02f, -4.06690598e-01f, 2.75148034e-01f, 2.62502700e-01f, -7.44742677e-02f,
  1.67437449e-01f, 6.12111203e-02f, -2.25365996e-01f, -1.44882321e-01f, -2.40757212e-01f, 1.35456130e-01f, -7.02103376e-02f, -3.25106770e-01f, -1.35788083e-01f, 2.09572300e-01f,
  1.24796256e-01f, -1.66122228e-01f, 2.48298168e-01f, 2.36483663e-01f, 1.74152255e-01f, -3.80375177e-01f, 1.70657456e-01f, 1.75000623e-01f, 3.51806059e-02f, 3.03733438e-01f,
  1.59052432e-01f, 2.17395738e-01f, 2.25353494e-01f, 1.00841835e-01f, 7.97453001e-02f, 2.08193451e-01f, -4.19128360e-03f, 1.23211622e-01f, -4.74972576e-02f, 2.27099746e-01f,
  3.37463394e-02f, 2.13467255e-01f, 4.00879973e-04f, 1.66461945e-01f, 8.05694535e-02f, -3.92541379e-01f, 1.90604299e-01f, 2.73739457e-01f, 4.88842316e-02f, -1.50222167e-01f,
  -1.18027128e-01f, -3.45734414e-03f, -4.33519721e-01f, 1.92938037e-02f, -4.67337705e-02f, 1.62002474e-01f, 2.95303464e-01f, -1.34128243e-01f, 5.71238771e-02f, 1.17721103e-01f,
  1.68757106e-03f, 9.84166265e-02f, -1.36313289e-01f, -1.15168013e-01f, -1.37470160e-02f, -4.46990132e-01f, 1.20750368e-01f, -1.78796619e-01f, 5.36874950e-01f, -1.49929196e-01f,
  1.92136452e-01f, 7.62571162e-03f, -4.77206469e-01f, 7.57985562e-02f, 1.06411912e-01f, 7.32513890e-02f, 2.30399534e-01f, -1.24934457e-01f, 9.62582082e-02f, 3.75286967e-01f,
  1.40658885e-01f, -2.25200485e-02f, -2.42082939e-01f, 1.95694402e-01f, -2.36266509e-01f, 1.35670751e-01f, 1.72944307e-01f, -9.98357236e-02f, -1.75459638e-01f, 9.88692939e-02f,
  1.49122015e-01f, 1.02993228e-01f, 1.26271397e-01f, 1.74825981e-01f, -3.74305770e-02f, 3.40949968e-02f, 3.74043733e-02f, -2.45757736e-02f, 1.78465217e-01f, 1.44146055e-01f,
  1.98472187e-01f, -2.25947108e-02f, 1.46541253e-01f, 1.73594758e-01f, 5.56366146e-02f, -4.39070277e-02f, 1.03352003e-01f, 1.45894825e-01f, 4.37857136e-02f, -3.75561812e-03f,
  -1.93900019e-01f, 2.42280707e-01f, 9.55140218e-02f, -8.72024074e-02f, 2.71247029e-02f, -1.17827952e-01f, -2.72411674e-01f, 8.29776302e-02f, 2.85361633e-02f, -1.21492326e-01f,
  -1.45858169e-01f, 1.64796308e-01f, 1.62396997e-01f, -6.35403469e-02f, -4.38799821e-02f, -4.27096933e-02f, -7.89751410e-02f, -1.52434170e-01f, -2.17797250e-01f, 2.80975997e-01f,
  1.74990684e-01f, 6.44665286e-02f, 3.73762310e-01f, 1.84685573e-01f, 2.16207784e-02f, -1.09972864e-01f, -1.22925341e-01f, 1.07904702e-01f, -5.15729450e-02f, 2.65611023e-01f,
  -2.08859611e-02f, 2.37679154e-01f, 1.17610197e-03f, -3.09766263e-01f, 2.43643299e-01f, -1.35091633e-01f, 2.22390041e-01f, 1.26172826e-01f, 1.91322759e-01f, -2.00294971e-01f,
  2.98612088e-01f, -1.38012007e-01f, -1.73068672e-01f, -2.17151158e-02f, 4.71916161e-02f, 1.43411666e-01f, 1.13362178e-01f, 4.45320569e-02f, 1.87713206e-01f, 4.74138372e-02f,
  2.07019061e-01f, 1.80359438e-01f, 2.13386640e-02f, 1.87919959e-01f, 1.70519292e-01f, 1.46440163e-01f, 2.08535381e-02f, 1.49933457e-01f, 5.46525121e-02f, 1.83642909e-01f,
  1.88414425e-01f, 1.35024652e-01f, 2.59456664e-01f, -8.25746432e-02f, 2.26961747e-01f, 3.45924534e-02f, 5.95706515e-03f, 6.74193501e-02f, -2.09947616e-01f, 2.33727783e-01f,
  -7.85864592e-02f, -1.23464085e-01f, -1.12774417e-01f, -4.00275625e-02f, 1.84606403e-01f, 7.42848068e-02f, -1.72357842e-01f, -5.30965552e-02f, 2.73294985e-01f, 3.91555345e-03f,
  1.09679431e-01f, -5.24579287e-02f, 4.15655851e-01f, -5.62196262e-02f, -1.64671708e-02f, -2.37206206e-01f, 1.12168364e-01f, -2.75738001e-01f, -4.12333533e-02f, 1.41823322e-01f,
  -7.36158118e-02f, -1.52399585e-01f, 1.83681905e-01f, 4.34877634e-01f, 1.57400563e-01f, -1.62542135e-01f, -9.42943767e-02f, 3.57473910e-01f, 3.72718908e-02f, 1.80830926e-01f,
  -2.57214278e-01f, -1.18846362e-02f, -3.51615578e-01f, 4.23870504e-01f, 1.04585746e-02f, -1.06327645e-01f, -2.85685420e-01f, 1.60075918e-01f, 1.75146788e-01f, 2.46378809e-01f,
  1.77770391e-01f, 9.28514600e-02f, 9.79820490e-02f, 2.12672740e-01f, 1.12902056e-02f, -8.63192454e-02f, 4.81717661e-02f, 1.28197819e-01f, 1.56316921e-01f, -2.57672463e-02f,
  2.29554176e-01f, 4.14716452e-02f, -6.71649054e-02f, 2.08876997e-01f, 1.25717029e-01f, 5.77638857e-02f, 2.38059714e-01f, -8.88481215e-02f, -2.60943711e-01f, 1.34531558e-01f,
  2.13808045e-01f, 4.01331335e-02f, 9.12782624e-02f, -2.49158770e-01f, 1.92636922e-02f, 3.15554743e-03f, 1.88304588e-01f, -2.02882081e-01f, -2.96653748e-01f, 8.19135904e-02f,
  2.15864018e-01f, -3.64011712e-02f, -3.08440864e-01f, -1.68956846e-01f, 4.99970429e-02f, -1.02504827e-01f, -3.05169433e-01f, 3.08136046e-01f, 5.73462807e-03f, -4.67479490e-02f,
  1.93865195e-01f, 5.68133816e-02f, -5.48104979e-02f, -2.67909527e-01f, 9.63633657e-02f, 7.95780718e-02f, -2.30184421e-01f, 3.96626621e-01f, 2.32571095e-01f, 1.64452381e-02f,
  1.47426948e-01f, -3.47474188e-01f, 6.12395294e-02f, 2.04188928e-01f, 1.18125536e-01f, 1.24109238e-01f, 7.06356540e-02f, -2.61127591e-01f, 2.90810585e-01f, -3.14000726e-01f,
  -1.73690096e-01f, -1.88939184e-01f, 4.59006429e-02f, 9.79014859e-02f, 6.36849031e-02f, 2.00704396e-01f, -7.52076413e-03f, 1.19046926e-01f, 2.58720428e-01f, 7.47245178e-02f,
  2.17393160e-01f, -9.02804919e-03f, 2.49657974e-01f, 8.42995122e-02f, -4.82654981e-02f, 1.07102096e-01f, 2.05286354e-01f, -6.31043836e-02f, 1.23143405e-01f, 1.30412266e-01f,
  1.29457161e-01f, 3.28349292e-01f, 2.78490949e-02f, 8.63325745e-02f, -1.44686386e-01f, -1.06825478e-01f, 1.73786521e-01f, 2.29895756e-01f, -8.51187631e-02f, -2.30532467e-01f,
  1.76087245e-02f, 3.39687616e-01f, 1.72708452e-01f, -1.58058926e-01f, -3.68245766e-02f, 1.19464651e-01f, 4.03499678e-02f, 1.00600615e-01f, -4.11232337e-02f, -1.05793245e-01f,
  2.21403778e-01f, 1.13749385e-01f, -1.78990185e-01f, -2.32294783e-01f, -8.94782022e-02f, -9.32638347e-02f, 1.67026669e-01f, -1.41498223e-01f, 2.03911051e-01f, 1.15579121e-01f,
  -3.06030083e-02f, 1.21409418e-02f, 1.67788476e-01f, -1.88745365e-01f, 1.06836766e-01f, 2.89050061e-02f, -1.87759414e-01f, 4.73426104e-01f, 2.08410949e-01f, -1.93160564e-01f,
  -3.50738198e-01f, 2.86973476e-01f, -2.64441758e-01f, -6.54953346e-02f, -1.04722276e-01f, 1.43275619e-01f, 6.27397001e-02f, 2.66604591e-02f, 8.36994648e-02f, 2.27930918e-01f,
  2.36850739e-01f, 2.18622059e-01f, 3.21393311e-01f, -1.63703710e-02f, 1.26242116e-01f, 2.58259918e-03f, 2.23114774e-01f, 1.62496999e-01f, 4.51614670e-02f, -8.17319751e-03f,
  2.83198476e-01f, 1.18223563e-01f, 8.40194821e-02f, 2.29970738e-01f, 1.66205212e-01f, -1.28893116e-02f, -1.07218787e-01f, 2.12574184e-01f, -6.29060492e-02f, -2.56449401e-01f,
  -1.19272701e-01f, -4.60874513e-02f, -1.03005387e-01f, -1.80796787e-01f, 2.22106427e-01f, 3.02042991e-01f, 2.01007366e-01f, -2.95119315e-01f, 1.07143417e-01f, 1.82602003e-01f,
  1.60157636e-01f, -5.03220633e-02f, 2.92785256e-03f, -1.34677634e-01f, -7.65318945e-02f, 1.42798796e-01f, 1.59105241e-01f, -1.81729030e-02f, 3.22927088e-02f, -8.46182853e-02f,
  -2.70502325e-02f, -2.08625659e-01f, 1.42839119e-01f, -1.00355394e-01f, -1.84255496e-01f, 8.52316692e-02f, 2.47935895e-02f, -4.57743943e-01f, -4.25226651e-02f, 3.40326250e-01f,
  -8.07210628e-04f, -3.63272369e-01f, 2.06286043e-01f, 1.10034965e-01f, -3.60708199e-02f, 1.46245360e-01f, 1.26364678e-01f, -1.83469594e-01f, 2.08367899e-01f, -1.01593889e-01f,
  -9.12825614e-02f, -8.72432962e-02f, 2.23996304e-02f, -4.75106798e-02f, -1.79993033e-01f, -5.35749048e-02f, -4.41126153e-02f, -1.14091657e-01f, -6.38080165e-02f, -1.09814592e-02f,
  7.38610327e-02f, -9.92966257e-03f, 1.60128579e-01f, 2.48405454e-03f, -1.86021283e-01f, -6.85522053e-03f, 1.39718696e-01f, 1.15798071e-01f, 1.24685533e-01f, 3.59322242e-02f,
  -2.05640063e-01f, -3.34891975e-02f, -1.14730105e-01f, -8.96156579e-02f, -6.11827383e-03f, -1.85729414e-01f, -1.11492939e-01f, 2.11154632e-02f, -1.36468351e-01f, -2.68790811e-01f,
  -3.90963368e-02f, -1.29889503e-01f, 6.99792504e-02f, -1.64498463e-01f, -3.79519723e-02f, -1.27909603e-02f, 1.61977466e-02f, 1.00691669e-01f, 7.36652389e-02f, 1.46775573e-01f,
  7.17352033e-02f, -9.08405110e-02f, 4.65523332e-01f, 3.39416325e-01f, 3.66161689e-02f, 1.51325539e-01f, -2.82074243e-01f, 1.21069044e-01f, 3.25267255e-01f, 2.51741379e-01f,
  1.50374621e-01f, 1.91848680e-01f, 9.56378877e-02f, -1.93696573e-01f, 1.28551200e-01f, -5.86181700e-01f, 2.34085973e-02f, -2.93302774e-01f, 3.14888179e-01f, -4.61335182e-02f,
  2.69014776e-01f, 8.83273035e-02f, 1.18830666e-01f, 6.11235201e-02f, 2.47823477e-01f, 1.30146429e-01f, 9.69706699e-02f, 3.05375993e-01f, 1.75217405e-01f, 1.34292379e-01f,
  1.02543078e-01f, 2.19213665e-01f, 1.60550758e-01f, 3.63618821e-01f, -7.58584365e-02f, 1.15411557e-01f, 3.75052005e-01f, 8.23985562e-02f, -3.41100246e-02f, 1.07034765e-01f,
  1.48762658e-01f, 1.61334015e-02f, 6.87393099e-02f, -9.72946454e-03f, 5.57524189e-02f, 1.77661419e-01f, 9.67662260e-02f, 3.56924206e-01f, -3.62209673e-03f, -5.77213168e-02f,
  2.20168769e-01f, 1.38896793e-01f, -2.09486172e-01f, -4.30026680e-01f, 3.09994984e-02f, 1.82311893e-01f, -1.10194109e-01f, -7.25934952e-02f, 1.39588609e-01f, 1.30316978e-02f,
  2.61105239e-01f, 1.00951582e-01f, 2.32786313e-01f, 2.85564288e-02f, 1.09149497e-02f, -3.44196200e-01f, 4.22354728e-01f, 5.73334983e-03f, 2.30398830e-02f, 2.63913721e-01f,
  1.85499072e-01f, -1.37087945e-02f, 4.43965662e-03f, 6.69626653e-01f, 3.92303169e-02f, 2.05828071e-01f, 8.98938254e-02f, -8.50917920e-02f, -3.02814972e-02f, 1.31614655e-01f,
  -6.32562041e-02f, 7.95592964e-02f, 2.44934228e-03f, 3.84198949e-02f, 2.28339300e-01f, 3.08920513e-03f, -2.89890260e-01f, -5.00766151e-02f, -4.60910685e-02f, -3.18764686e-03f,
  -1.33769974e-01f, -3.91044393e-02f, -2.40242273e-01f, -1.63587272e-01f, -1.13262206e-01f, -4.94106300e-02f, -3.49799357e-02f, 1.28510773e-01f, 4.37815115e-02f, 1.28393292e-01f,
  4.77378294e-02f, -3.72338332e-02f, -8.20410922e-02f, 1.11143351e-01f, 4.39942218e-02f, -4.66388054e-02f, -1.42787516e-01f, 1.18511021e-02f, -2.00612381e-01f, -1.47500783e-01f,
  -1.18930325e-01f, 5.03764562e-02f, 1.43978104e-01f, -2.39602759e-01f, -1.60926238e-01f, 8.13688263e-02f, -2.08681360e-01f, -3.12665850e-01f, -2.45991692e-01f, -1.03599224e-02f,
  4.58654091e-02f, -1.59904152e-01f, -1.86517969e-01f, 2.50529610e-02f, 2.46056300e-02f, 3.88384126e-02f, 1.44361675e-01f, 4.90551926e-02f, 2.14817766e-02f, 5.35701290e-02f,
  4.28856790e-01f, 4.58343513e-02f, -1.27712995e-01f, 1.21778391e-01f, -2.30391771e-01f, 3.51365134e-02f, 1.60294563e-01f, 1.50501311e-01f, 1.60746902e-01f, 1.12122193e-01f,
  3.63253150e-03f, 5.81135228e-02f, 2.79809348e-02f, -4.61431563e-01f, -1.55453449e-02f, -7.35658929e-02f, 3.24825913e-01f, 1.50481574e-05f, 2.10603118e-01f, 1.99480131e-01f,
  4.47715707e-02f, -6.15664311e-02f, 1.79410309e-01f, 1.00264877e-01f, 5.83274197e-03f, 2.56528825e-01f, 1.67129692e-02f, 1.11281201e-01f, 1.58179000e-01f, 3.38207185e-02f,
  7.26340264e-02f, 3.04647610e-02f, 1.96432769e-01f, 1.08875938e-01f, -9.60233808e-02f, 9.58245471e-02f, 1.54820874e-01f, 6.16755672e-02f, 1.90459386e-01f, -7.98864290e-03f,
  3.67275365e-02f, -1.72887519e-01f, 3.53363380e-02f, 3.03606014e-03f, 5.46125546e-02f, -2.17682645e-01f, -1.84988547e-02f, -1.11084811e-01f, -2.12594077e-01f, -7.68603757e-02f,
  -3.37590538e-02f, -1.00090086e-01f, 1.18812419e-01f, -2.45897532e-01f, 9.65165999e-03f, -3.98652181e-02f, 1.54897898e-01f, 4.86294702e-02f, 2.27009311e-01f, -3.30791436e-03f,
  7.33032152e-02f, -2.46530235e-01f, -8.61814842e-02f, -4.19853985e-01f, 3.79031688e-01f, 7.35033453e-02f, 8.88002291e-02f, -1.13288596e-01f, -4.31884438e-01f, -1.38801575e-01f,
  2.36280620e-01f, 1.64521530e-01f, 1.51375175e-01f, -5.25472939e-01f, -2.16880679e-01f, 4.90697533e-01f, 7.92369395e-02f, -4.07483310e-01f, 2.11465985e-01f, -3.46433669e-02f,
  -2.17288621e-02f, 2.00926036e-01f, 8.68565068e-02f, 3.41777243e-02f, 1.04080029e-01f, 7.68439993e-02f, -9.38361213e-02f, -1.19943619e-01f, -8.02469999e-02f, -9.45880637e-03f,
  4.06314582e-02f, -7.59374723e-02f, 7.93238264e-03f, -2.79199809e-01f, -9.06737223e-02f, -1.33220330e-02f, -1.29362389e-01f, 1.06789708e-01f, -2.73170799e-01f, 7.79159665e-02f,
  1.59043267e-01f, 6.08124491e-03f, 5.00138067e-02f, -4.59652990e-02f, 6.20161146e-02f, 2.22239166e-01f, 1.11481711e-01f, -2.37076208e-01f, -4.65830155e-02f, 1.60790145e-01f,
  -8.53578970e-02f, 3.59932870e-01f, 8.08783919e-02f, -9.33705792e-02f, -5.73779903e-02f, 1.65482908e-01f, 1.11685611e-01f, 1.30602131e-02f, -1.67271346e-01f, 1.02594041e-03f,
  -6.57253489e-02f, -8.81171320e-03f, -2.93725710e-02f, 2.84258336e-01f, 2.83937901e-01f, 1.97587796e-02f, -3.25203538e-01f, 4.14549619e-01f, -3.06806087e-01f, -2.56876685e-02f,
  2.20496729e-01f, 3.06157857e-01f, 1.38188481e-01f, 2.86111683e-01f, 1.29939854e-01f, -3.17446828e-01f, 6.67121708e-02f, -3.81006181e-01f, -2.14703321e-01f, 1.85519829e-01f,
  7.68984407e-02f, 2.72190928e-01f, -3.28165106e-02f, -3.51533502e-01f, 3.70940976e-02f, 8.57022554e-02f, -2.31035635e-01f, 5.01047075e-01f, 1.25189070e-02f, -1.81912556e-01f,
  1.72811329e-01f, 2.15015694e-01f, 2.60592252e-01f, 6.14086874e-02f, 2.14628391e-02f, 5.92905544e-02f, 1.90115288e-01f, 2.08003104e-01f, 4.21126395e-01f, 2.09447533e-01f,
  1.67825520e-02f, 3.93781951e-03f, 8.76543019e-03f, 1.57436416e-01f, 4.41707410e-02f, 8.79808068e-02f, 5.48927635e-02f, 3.51651236e-02f, 2.64195129e-02f, -1.40447289e-01f,
  -1.00003436e-01f, -7.30526149e-02f, 7.40534440e-02f, 1.65946364e-01f, 1.89708218e-01f, 1.49461254e-01f, 4.37181219e-02f, -3.27133052e-02f, 3.73661816e-02f, -2.56406039e-01f,
  -2.44479641e-01f, 8.86825174e-02f, 1.79350202e-03f, -2.84386817e-02f, -2.17935219e-02f, -1.56894997e-02f, 1.03602476e-01f, 1.97935879e-01f, 7.62944818e-02f, 1.84409861e-02f,
  -2.86449194e-01f, 2.57238150e-01f, -4.37613875e-02f, -2.56895702e-02f, -1.37854144e-01f, 2.42997557e-01f, 5.26987493e-01f, 1.84403092e-01f, -1.79491583e-02f, -5.23736849e-02f,
  -3.94032076e-02f, -1.72001839e-01f, -3.07973117e-01f, 6.10541366e-02f, -1.06184036e-01f, 2.46629700e-01f, -3.33118349e-01f, -1.52002886e-01f, 2.92703658e-01f, -1.61897495e-01f,
  -3.48233610e-01f, 1.74253225e-01f, -1.75018460e-01f, -3.93370181e-01f, 3.07233900e-01f, 1.57158121e-01f, 1.95490554e-01f, 1.72387972e-01f, 2.05311283e-01f, 1.23821206e-01f,
  2.37333938e-01f, 3.06768239e-01f, 2.19159037e-01f, -2.44296491e-02f, 1.28300115e-01f, -9.74363759e-02f, 1.13773517e-01f, -1.67170152e-01f, 7.50683248e-02f, 1.59085304e-01f,
  -3.31840068e-02f, 6.54014349e-02f, 2.85124272e-01f, -3.93426299e-01f, 8.14281404e-02f, 3.11079264e-01f, -7.30050877e-02f, 1.38924554e-01f, 8.90450403e-02f, -2.21321341e-02f,
  7.14552552e-02f, 1.86192304e-01f, 1.62574053e-01f, -3.11716467e-01f, -9.69346166e-02f, 2.46247962e-01f, 1.47706032e-01f, 2.13107467e-02f, 2.94098537e-02f, 1.28061790e-02f,
  -2.96738837e-02f, 1.72749788e-01f, 1.12284116e-01f, 1.79062113e-02f, 1.92735761e-01f, 1.86139449e-01f, 8.02472327e-03f, -1.97003275e-01f, -2.59282470e-01f, 2.33989999e-01f,
  4.22803998e-01f, 1.42521337e-01f, -3.47238153e-01f, 5.25692701e-02f, -4.38023448e-01f, -2.25287184e-01f, -3.36666793e-01f, 1.11991741e-01f, -1.57455489e-01f, -2.62409560e-02f,
  -2.97427624e-01f, 1.97093278e-01f, 1.77225143e-01f, -6.18153885e-02f, 2.92599767e-01f, 2.10799687e-02f, 2.40650788e-01f, -5.37993848e-01f, 1.30548432e-01f, 1.44228175e-01f,
  1.82137176e-01f, 1.31399795e-01f, 5.80377951e-02f, 9.91355553e-02f, 1.06251113e-01f, 1.04080722e-01f, 7.76653811e-02f, 1.68805271e-01f, -3.39672081e-02f, -2.66947243e-02f,
  8.38924348e-02f, -3.17283161e-02f, -4.46393434e-03f, 1.44101024e-01f, 2.20835462e-01f, 3.91335636e-02f, 1.24806963e-01f, -1.11783914e-01f, 9.63270366e-02f, 2.48136595e-02f,
  -6.58576936e-02f, 3.95166837e-02f, -2.12651324e-02f, 2.25399673e-01f, -1.41544804e-01f, 3.09482273e-02f, -1.06049761e-01f, -2.14903820e-02f, 2.19727457e-01f, -1.63622871e-01f,
  -2.68438607e-02f, 3.59281227e-02f, 2.90709674e-01f, 1.26606449e-01f, 1.76662594e-01f, 1.25313118e-01f, 3.59279424e-01f, -1.39194921e-01f, -1.96669484e-03f, -2.62258112e-01f,
  9.80253890e-02f, -2.01029077e-01f, -1.54718280e-01f, 1.30891383e-01f, 4.62042481e-01f, -1.65389597e-01f, 4.82321270e-02f, 1.91059858e-01f, 1.27642751e-01f, -3.46467912e-01f,
  -2.71380424e-01f, 1.56250015e-01f, -2.41082665e-02f, 5.82294073e-04f, -2.88206726e-01f, 1.40781432e-01f, -1.14597507e-01f, 2.08608463e-01f, -2.80989334e-02f, 8.87477130e-04f,
  -6.35852069e-02f, 2.10108355e-01f, -6.92652762e-02f, 3.75890099e-02f, 1.67667046e-01f, 8.22715089e-02f, 3.38512778e-01f, 2.83666760e-01f, 3.29558969e-01f, 1.86867222e-01f,
  2.67050743e-01f, 4.64391075e-02f, 2.46503964e-01f, 2.62296706e-01f, 1.74101554e-02f, 1.04704499e-01f, 1.37487650e-01f, 8.55847895e-02f, 2.47844204e-01f, 2.12517545e-01f,
  1.07128389e-01f, 9.86431912e-02f, 6.67396933e-02f, 1.27201915e-01f, -2.18036875e-01f, -2.75633540e-02f, -1.33402780e-01f, -9.38955545e-02f, 3.42800170e-01f, -2.44354755e-02f,
  2.59107143e-01f, 3.35501075e-01f, 1.47902984e-02f, -2.95085698e-01f, -1.38768747e-01f, -2.27198541e-01f, 1.80346128e-02f, -5.06768748e-02f, -1.11436822e-01f, -2.44601294e-01f,
  -4.00620066e-02f, 6.11796882e-03f, 2.24772751e-01f, -1.49312049e-01f, 1.75945029e-01f, -1.64326597e-02f, -2.02505346e-02f, -2.28256583e-01f, -1.23911574e-01f, -2.05597073e-01f,
  8.62884372e-02f, -1.36631131e-01f, -1.08656675e-01f, -1.54480472e-01f, 1.48163989e-01f, 2.68165290e-01f, -2.81785689e-02f, -5.82458913e-01f, 4.49183613e-01f, -1.89103708e-02f,
  -5.34275696e-02f, 1.49791077e-01f, 6.34996369e-02f, -3.07317495e-01f, 1.95163533e-01f, -1.31145656e-01f, -9.55784917e-02f, 1.69225901e-01f, 2.68669724e-02f, 1.41484872e-01f,
  1.56564459e-01f, 6.89811781e-02f, 3.23737338e-02f, 3.05045079e-02f, 3.51937413e-02f, 1.31452560e-01f, 6.93452777e-03f, 3.52187827e-02f, 1.23887658e-01f, -8.60997301e-04f,
  1.29997015e-01f, -5.58860321e-03f, -4.99441475e-02f, -6.71695098e-02f, 2.32616693e-01f, -8.16757977e-02f, -5.26117533e-02f, 1.35938495e-01f, 3.26988921e-02f, -3.07046399e-02f,
  -7.47034848e-02f, 5.75638227e-02f, 8.82555544e-02f, 1.72794182e-02f, -1.64185733e-01f, -2.15357393e-01f, 9.52471942e-02f, 4.02296335e-02f, 1.06247263e-02f, -1.28165916e-01f,
  2.41607592e-01f, 5.82441390e-02f, 3.70680764e-02f, 1.51647791e-01f, 2.31079802e-01f, 6.70472607e-02f, -3.09816808e-01f, -3.06008428e-01f, -3.62977013e-02f, -8.28620717e-02f,
  -2.79643148e-01f, 1.56960279e-01f, 4.27057534e-01f, -1.86430752e-01f, 1.16083153e-01f, 3.25674057e-01f, 5.13474829e-02f, -1.12758674e-01f, -1.47362649e-01f, 3.53198439e-01f,
  -6.18043244e-02f, 6.05981275e-02f, -1.76439345e-01f, -3.33357677e-02f, 3.36785883e-01f, 3.62668306e-01f, -2.12918501e-02f, -1.83135942e-02f, -8.12401548e-02f, 2.46969283e-01f,
  6.07999088e-03f, 8.48935321e-02f, 3.45982052e-02f, 3.00842896e-02f, 1.77616060e-01f, 1.96044251e-01f, 1.81640118e-01f, -1.18266337e-01f, -4.42993641e-02f, -6.05712235e-02f,
  2.98929840e-01f, 6.59547597e-02f, -5.78105524e-02f, 1.21396668e-01f, 1.91312134e-01f, -8.99317116e-02f, 3.02711129e-03f, 4.31132801e-02f, -2.60966886e-02f, 3.40534806e-01f,
  -2.47725084e-01f, -1.80562973e-01f, -7.34994635e-02f, -2.11920775e-02f, -4.43889424e-02f, 2.58556694e-01f, -9.19569097e-03f, -1.57797024e-01f, 7.91380256e-02f, 2.39989176e-01f,
  -6.34608567e-02f, -1.23656400e-01f, 1.00349881e-01f, 8.42809826e-02f, -1.72726214e-01f, 1.01107322e-01f, 8.68876725e-02f, 6.73891380e-02f, 2.24795282e-01f, 1.19125113e-01f,
  -2.00192019e-01f, 3.05079520e-01f, -1.53130516e-01f, 1.32571310e-01f, 1.71805471e-01f, -2.13199779e-01f, 1.95044994e-01f, 1.54752666e-02f, 4.94696386e-02f, -3.42610292e-02f,
  3.39026928e-01f, -2.00028583e-01f, -1.50507435e-01f, 6.59062564e-02f, 9.28076953e-02f, 3.49997878e-01f, 2.01718658e-01f, -4.89141852e-01f, 7.41460696e-02f, 4.54534501e-01f,
  -3.88793610e-02f, 3.67922127e-01f, -1.48285925e-01f, -1.38954679e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  9.54338610e-02f, 6.20279228e-03f, -2.97401249e-02f, 1.14338491e-02f, 2.67782286e-02f, 2.64941081e-02f, 1.65409550e-01f, 2.76842982e-01f, 8.97052884e-02f, 2.62464970e-01f,
  2.01322764e-01f, 2.52554268e-01f, 8.26421380e-02f, 2.01624170e-01f, 1.92278296e-01f, -1.85423180e-01f, 3.74809355e-02f, -1.51836097e-01f, 1.61247626e-01f, 1.95710003e-01f,
  2.85181433e-01f, 2.08113998e-01f, 7.90053606e-02f, 2.31442228e-01f, 1.73233390e-01f, 1.08017266e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  9.69913229e-02f, 2.76630700e-01f, 5.58978356e-02f, 2.85426527e-01f, 8.55015218e-02f, 2.00960383e-01f, 4.05269824e-02f, 2.68818468e-01f, 2.10015044e-01f, 1.28217667e-01f,
  -5.72047867e-02f, 1.74376845e-01f, 3.00830696e-03f, -1.93671416e-02f, -5.60166202e-02f, 1.02085024e-01f, -7.80168409e-03f, -2.71873832e-01f, -1.29497379e-01f, -1.57396257e-01f,
  1.98504865e-01f, -2.49589281e-03f, -1.48311302e-01f, 2.27631807e-01f, 1.29073724e-01f, 4.12275493e-02f, 4.73954119e-02f, 1.26707047e-01f, -1.35702938e-01f, 1.11762241e-01f,
  -1.10047683e-01f, 2.64240690e-02f, -1.36908203e-01f, -2.21259445e-01f, -4.68795635e-02f, -5.34369498e-02f, -5.86819164e-02f, 1.60859048e-01f, -2.37497956e-01f, 9.02199298e-02f,
  -1.54985428e-01f, -4.43101674e-02f, 3.25478725e-02f, 5.82778417e-02f, -1.08923525e-01f, 2.41659582e-02f, -3.50964963e-02f, -2.16479190e-02f, -1.41247943e-01f, 1.64772496e-01f,
  -2.14032196e-02f, -6.31759241e-02f, 2.35082909e-01f, -2.35039189e-01f, 1.33979646e-02f, -1.14506572e-01f, 1.21602751e-01f, -6.89538047e-02f, -1.42978966e-01f, -2.90809944e-02f,
  1.16806388e-01f, 1.48623034e-01f, 1.16422608e-01f, -2.49154158e-02f, -4.58621755e-02f, 2.23704442e-01f, 2.08035652e-02f, -5.91825545e-02f, -5.50516136e-02f, -2.50958979e-01f,
  6.71524256e-02f, 6.16722554e-03f, 5.79825044e-02f, -4.55356799e-02f, -4.57495041e-02f, -7.52585977e-02f, -1.06975548e-01f, -1.36062369e-01f, 1.14404805e-01f, 9.25799087e-02f,
  2.31055006e-01f, -9.17410627e-02f, 9.00670141e-02f, -9.25833136e-02f, -2.90567726e-01f, 2.68471777e-01f, -1.29604802e-01f, 1.05909742e-01f, 1.78993717e-01f, -8.51441268e-03f,
  2.41834521e-01f, -1.82400756e-02f, 1.22507334e-01f, 2.77406454e-01f, -1.77394643e-01f, -4.09825534e-01f, -2.67847657e-01f, 3.54635119e-02f, 6.88670874e-02f, 4.27119434e-02f,
  1.90087214e-01f, -4.78415862e-02f, -5.18219993e-02f, 5.68359718e-02f, 3.11842076e-02f, 1.16414286e-01f, -3.52372825e-02f, 2.70439554e-02f, 2.24740401e-01f, -1.43753409e-01f,
  6.79610148e-02f, -1.27460375e-01f, 2.39153933e-02f, 1.12784086e-02f, 8.72401521e-03f, 4.18896368e-03f, -2.99561233e-03f, 1.79496184e-01f, 5.13405055e-02f, 7.05184191e-02f,
  -1.15896761e-01f, -1.64076954e-01f, 1.36014849e-01f, 2.64860503e-03f, 8.53406042e-02f, -2.40753844e-01f, 1.94248900e-01f, -1.03812732e-01f, 1.32748917e-01f, -1.05442137e-01f,
  -2.99104571e-01f, -3.20364088e-02f, -1.02242664e-01f, 9.36068818e-02f, -1.19209729e-01f, -4.03597504e-02f, -5.44519164e-02f, -9.14918911e-03f, 1.64235309e-02f, -6.31748214e-02f,
  -1.66409373e-01f, -2.03995347e-01f, 2.39922315e-01f, -8.10014084e-02f, 9.65611562e-02f, -1.10257097e-01f, -2.14644857e-02f, 6.20256066e-02f, 1.29479229e-01f, -9.68421623e-02f,
  1.53312862e-01f, -1.47952018e-02f, -3.24527770e-02f, -8.46979115e-03f, -5.47469035e-02f, 1.50393441e-01f, -1.67869031e-01f, 3.92100140e-02f, 1.42980844e-01f, 2.99977362e-01f,
  -1.02598639e-02f, -1.05438605e-01f, 1.77253529e-01f, 3.52127478e-02f, -8.46778974e-02f, -1.83715373e-01f, 3.14497441e-01f, 6.43622950e-02f, -1.12436764e-01f, 1.43218450e-02f,
  -7.23836571e-02f, 1.51480883e-02f, -1.31353036e-01f, -1.02407232e-01f, -2.41203442e-01f, 1.78706765e-01f, -3.07658687e-02f, 1.65806308e-01f, 1.42981380e-01f, -6.46281540e-02f,
  1.72754332e-01f, -5.77581748e-02f, 3.23913898e-03f, 1.48392484e-01f, -9.18746591e-02f, -7.33397305e-02f, -1.46558031e-01f, -1.52914375e-01f, -2.30833814e-02f, 1.79439947e-01f,
  2.27602143e-02f, -5.01684286e-02f, 1.16955049e-01f, 1.89347968e-01f, -2.98956513e-01f, 1.32147759e-01f, 1.24148145e-01f, -1.82852931e-02f, -2.32018530e-02f, -1.40449367e-02f,
  1.24459237e-01f, 1.84828594e-01f, 7.07768202e-02f, 2.19162598e-01f, 2.00178191e-01f, 4.41973247e-02f, -9.77278277e-02f, -3.49077694e-02f, 1.94851235e-01f, -2.44362816e-01f,
  -1.17567800e-01f, 2.49069676e-01f, 3.41564655e-01f, -2.60552019e-01f, 8.20674747e-03f, 1.33222789e-01f, -6.81063160e-02f, 2.25544706e-01f, 1.34909093e-01f, -7.36884326e-02f,
  -3.09430361e-01f, -2.23708570e-01f, 9.51809809e-02f, 2.57574022e-01f, -8.61753989e-03f, -1.22576050e-01f, -2.81695068e-01f, -1.06689118e-01f, -1.28748091e-02f, 1.18033722e-01f,
  1.67835206e-01f, -1.68473616e-01f, -7.29413033e-02f, -6.79793134e-02f, -1.51965141e-01f, -1.17583930e-01f, 1.69555888e-01f, -1.54730424e-01f, -1.03920631e-01f, 1.42873108e-01f,
  1.62381932e-01f, 1.24099009e-01f, 1.61000311e-01f, 5.69305383e-02f, 1.78012803e-01f, -9.72301960e-02f, -2.35878211e-03f, -9.45044085e-02f, -1.21220700e-01f, -5.92352897e-02f,
  -2.05945328e-01f, -6.81386515e-02f, 4.36865352e-02f, 3.24400663e-02f, -6.16607368e-02f, -5.16668297e-02f, -1.97178628e-02f, -1.20229729e-01f, -2.33350202e-01f, 9.02462229e-02f,
  5.94997965e-02f, 9.34068859e-02f, 1.20090067e-01f, 2.03023106e-01f, 1.64543375e-01f, 1.71938330e-01f, 1.02538779e-01f, -5.62939942e-02f, -1.17992245e-01f, 8.18561986e-02f,
  1.59333795e-02f, -2.31353045e-02f, -3.43214069e-03f, -2.78370559e-01f, 9.82443169e-02f, 1.30177245e-01f, 6.20650351e-02f, 1.32386833e-01f, 3.47271144e-01f, -5.38339056e-02f,
  7.91472942e-02f, -6.67266771e-02f, 4.24121283e-02f, 3.42449509e-02f, -1.68645233e-01f, -3.67942490e-02f, 1.72981992e-01f, 9.48985517e-02f, 1.20443240e-01f, -7.54180476e-02f,
  8.48836675e-02f, -8.72450471e-02f, 3.63641679e-02f, -2.43170381e-01f, 9.01144147e-02f, -2.08579823e-01f, -1.62677824e-01f, -9.99058187e-02f, 1.93586648e-02f, -1.75366372e-01f,
  8.17734376e-02f, -4.47582640e-02f, 4.81141284e-02f, -1.18753230e-02f, 5.33636883e-02f, 1.36257991e-01f, 1.26354173e-01f, 7.48678595e-02f, 8.90143886e-02f, 6.33229688e-02f,
  1.90202191e-01f, -4.13242131e-02f, -1.21139131e-01f, -1.75699443e-01f, -1.68405399e-01f, 1.14614859e-01f, 1.49140293e-02f, 1.12046398e-01f, 1.36561245e-01f, -1.89278588e-01f,
  -4.54071946e-02f, -1.84052348e-01f, 9.29861795e-03f, 4.61695530e-02f, 1.44504502e-01f, -1.92681089e-01f, 2.19289977e-02f, 1.81842804e-01f, -4.91693877e-02f, -7.30459392e-02f,
  -1.76126193e-02f, -4.72769886e-02f, 1.63666934e-01f, -3.94172743e-02f, -1.05382100e-01f, -1.56298831e-01f, -1.91013560e-01f, 1.69218540e-01f, -1.88657701e-01f, 2.89233383e-02f,
  1.90017730e-01f, 2.97123250e-02f, 1.59959301e-01f, 1.05927758e-01f, 2.32755076e-02f, -1.26448408e-01f, 1.87589511e-01f, -1.21094465e-01f, -3.93897109e-02f, -3.10922831e-01f,
  -1.31216183e-01f, -8.12812895e-02f, -6.56511411e-02f, 6.87071905e-02f, -7.23915249e-02f, -3.55377905e-02f, -1.00345410e-01f, 8.91854912e-02f, -3.08655798e-01f, 4.50311080e-02f,
  4.08611260e-02f, -5.17130829e-02f, 6.79902881e-02f, 1.51061848e-01f, 6.79538026e-02f, 9.50962678e-03f, -1.34065256e-01f, 1.11252844e-01f, 7.23669007e-02f, -4.11514286e-03f,
  -2.98606418e-02f, 9.91774127e-02f, -1.95017159e-01f, -3.61006446e-02f, 4.30385619e-02f, -8.63121301e-02f, 6.12064190e-02f, 1.53598115e-01f, 9.24257413e-02f, -1.36653140e-01f,
  4.85587008e-02f, -2.78439015e-01f, -1.52424321e-01f, 3.97635661e-02f, 1.13451026e-01f, 1.09711565e-01f, -1.98351145e-02f, 9.20392275e-02f, -5.28843850e-02f, 1.58587452e-02f,
  -5.55569120e-02f, 1.00947201e-01f, -5.44925891e-02f, -7.78605929e-03f, 8.38491917e-02f, -7.65054524e-02f, 1.37685850e-01f, 4.65590917e-02f, 6.80259541e-02f, -1.08763397e-01f,
  -1.82224780e-01f, -9.78923142e-02f, -2.74883300e-01f, 1.15235522e-01f, 2.90390342e-01f, -3.16069812e-01f, 8.99872556e-02f, -1.68364063e-01f, -9.25795175e-03f, 7.88305029e-02f,
  -2.02715829e-01f, -1.60943091e-01f, -2.60804415e-01f, -4.98823263e-02f, -1.03685558e-01f, 1.99171558e-01f, 1.57781556e-01f, -2.13353690e-02f, -3.20827037e-01f, -1.04001984e-01f,
  -1.97106209e-02f, -9.39979702e-02f, 2.76572965e-02f, -1.80716574e-01f, -1.79866895e-01f, -1.89814210e-01f, 1.00525707e-04f, -7.13923797e-02f, -1.38371438e-01f, -1.57567993e-01f,
  3.13777812e-02f, 1.72396436e-01f, -2.48919204e-02f, -4.75297533e-02f, 7.95408338e-03f, 3.90407257e-02f, 1.92776009e-01f, -1.30823821e-01f, 1.32124322e-02f, -2.30620541e-02f,
  -1.39710948e-01f, 9.16704461e-02f, -1.05176382e-01f, 3.97322066e-02f, -8.80795270e-02f, 1.73430126e-02f, -1.88940927e-01f, -6.57987073e-02f, -1.24727793e-01f, -1.91417336e-01f,
  -1.60443559e-02f, -2.24519551e-01f, -1.32735176e-02f, 4.58399393e-02f, 2.81106383e-02f, -5.88829406e-02f, 2.87460871e-02f, -6.88691363e-02f, -8.23653340e-02f, 8.99002329e-02f,
  3.85240912e-02f, 1.65452242e-01f, 5.56312688e-02f, -6.27129078e-02f, 1.04377277e-01f, 6.44582883e-02f, 5.13249189e-02f, 4.98992838e-02f, 9.41290781e-02f, 2.06630975e-02f,
  1.95511773e-01f, 1.78551655e-02f, -5.22655435e-03f, -2.27676645e-01f, -1.62967041e-01f, -2.00627699e-01f, -3.91560495e-02f, -1.14890069e-01f, 2.74880409e-01f, 1.45150110e-01f,
  -3.34697217e-02f, -1.02539651e-01f, 8.04869051e-04f, 2.22054973e-01f, -3.11315060e-01f, -2.57688686e-02f, 2.36030668e-01f, 6.99535981e-02f, 4.88248691e-02f, 1.92387462e-01f,
  1.74157321e-01f, -1.95388675e-01f, -1.39955714e-01f, 5.59575222e-02f, -1.25158936e-01f, 2.02636309e-02f, -3.37437168e-02f, 1.59587145e-01f, -8.09615925e-02f, -6.85975030e-02f,
  -1.02557413e-01f, 1.19741671e-01f, 8.23948011e-02f, 1.33992374e-01f, 4.93868031e-02f, -2.15177804e-01f, -4.52373959e-02f, -2.56981820e-01f, -1.89021565e-02f, 1.19581968e-02f,
  7.96648562e-02f, -1.55697912e-01f, -1.02514856e-01f, -1.64098203e-01f, -3.16414773e-01f, -1.33974150e-01f, -2.75269091e-01f, 5.36937313e-03f, -4.68957946e-02f, -2.50493407e-01f,
  4.97190021e-02f, 1.59047712e-02f, 1.67682469e-01f, -4.81592081e-02f, -7.70201907e-02f, 2.12347165e-01f, -6.37811571e-02f, -4.11782712e-02f, 2.37700306e-02f, -8.14806893e-02f,
  6.42201379e-02f, 2.87151694e-01f, -1.70161843e-01f, -8.41521025e-02f, 6.96891993e-02f, -3.06290478e-01f, -8.78748447e-02f, 1.05445413e-02f, -5.40213436e-02f, 1.21028401e-01f,
  -1.68743014e-01f, -2.19536781e-01f, 2.64670998e-01f, 1.32620990e-01f, 1.82220414e-01f, -1.81330830e-01f, -3.52412835e-02f, 1.65362656e-01f, 4.47041802e-02f, -4.28581715e-01f,
  -4.39722463e-02f, -1.72337681e-01f, -8.02216306e-03f, 8.15108791e-02f, -2.10337132e-01f, 6.81626275e-02f, 7.98077658e-02f, -8.96319300e-02f, 2.11778015e-01f, 1.17155395e-01f,
  9.88237187e-02f, -1.73975959e-01f, 4.55049388e-02f, 5.63624464e-02f, 2.94595994e-02f, 2.05875292e-01f, 6.99108019e-02f, -1.30452579e-02f, 6.80675581e-02f, -1.14049956e-01f,
  7.61869103e-02f, 2.92763531e-01f, 1.62842661e-01f, -3.71708684e-02f, -1.06101390e-02f, -2.83219784e-01f, -1.82536226e-02f, -2.36004442e-01f, 4.35352810e-02f, 4.55440301e-03f,
  2.14676797e-01f, 9.88750532e-03f, -1.44882083e-01f, 4.38105240e-02f, -1.78990319e-01f, 4.91927899e-02f, -1.41473889e-01f, 2.15049218e-02f, 1.63308635e-01f, -1.31054614e-02f,
  1.13627173e-01f, -1.15250155e-01f, -1.20892622e-01f, -3.25937510e-01f, -1.38471425e-01f, -3.94646749e-02f, 1.59371480e-01f, -1.83373362e-01f, -2.74780113e-02f, -8.31712689e-03f,
  -4.42429371e-02f, -1.22327611e-01f, -3.71794254e-02f, -2.37654507e-01f, 1.63594484e-01f, -1.56713918e-01f, 1.79462507e-01f, 1.39257103e-01f, -1.57305673e-01f, 2.17786372e-01f,
  1.63096264e-01f, 2.62623802e-02f, -1.80028379e-01f, 1.61981523e-01f, -5.60755767e-02f, 3.75697319e-03f, 1.28413543e-01f, -1.48182109e-01f, 2.48246461e-01f, 2.47407913e-01f,
  -8.48537758e-02f, -4.24181595e-02f, 6.25661016e-02f, -8.31634253e-02f, -1.11467540e-01f, 1.06346086e-01f, -5.93422689e-02f, -2.13433374e-02f, 7.68007934e-02f, 1.09372236e-01f,
  -1.21022269e-01f, 2.11984605e-01f, 1.55324817e-01f, 1.36509970e-01f, -1.37965500e-01f, -2.14865237e-01f, 1.03523187e-01f, -1.13573782e-01f, 9.49550048e-02f, 8.59063268e-02f,
  -1.28732666e-01f, 6.16743825e-02f, 1.17991604e-01f, -1.42046615e-01f, -8.47615153e-02f, 1.44308627e-01f, -4.72301878e-02f, 8.00771266e-02f, -1.88544858e-02f, -3.37020196e-02f,
  -1.79314554e-01f, 1.17007650e-01f, -1.35109574e-01f, 8.09401681e-04f, 2.36939907e-01f, 6.47395477e-02f, 1.16548568e-01f, 3.00015599e-01f, -8.42549931e-03f, -2.31020123e-01f,
  3.50270510e-01f, -1.58445165e-01f, -4.40649837e-02f, 1.30393967e-01f, 2.09769636e-01f, 7.33918250e-02f, 3.45461927e-02f, 1.76974148e-01f, 2.46051326e-01f, 2.71057367e-01f,
  -4.79728393e-02f, 1.35382444e-01f, 1.05257146e-01f, 2.05712430e-02f, -1.73784494e-02f, 1.42833635e-01f, 1.78856030e-01f, -1.40286982e-01f, 1.79712564e-01f, -2.08983831e-02f,
  -3.63619067e-02f, 1.78985652e-02f, 6.14478812e-02f, -2.01653868e-01f, -1.52620580e-02f, -2.77033076e-02f, -2.30723456e-01f, -3.47046368e-02f, -1.14242196e-01f, -1.45194232e-01f,
  7.81554431e-02f, 5.41070662e-02f, -4.02629077e-02f, 8.68951455e-02f, -8.54114890e-02f, 7.80699551e-02f, 9.30661112e-02f, -2.10235447e-01f, -1.66294724e-02f, -1.17216647e-01f,
  -2.21360877e-01f, 2.23233372e-01f, -2.24315748e-01f, 5.33410311e-02f, 1.77913621e-01f, -4.08262620e-03f, -3.25009137e-01f, -3.12552005e-02f, 7.38107786e-02f, -1.85517922e-01f,
  -1.09503590e-01f, -2.28939205e-01f, 9.75130945e-02f, 7.26409480e-02f, 7.33054727e-02f, -3.58811729e-02f, 6.05764799e-02f, -2.14868784e-01f, 8.08317885e-02f, -2.67361011e-02f,
  8.29319432e-02f, -1.84627905e-01f, -1.71257377e-01f, 3.14171553e-01f, -2.34647721e-01f, 1.29819080e-01f, -5.37650324e-02f, 3.87877636e-02f, 1.03474297e-01f, -1.21088199e-01f,
  1.10687070e-01f, -3.81978638e-02f, -1.70437261e-01f, -3.30509171e-02f, 3.32227312e-02f, -2.18465656e-01f, -1.30536377e-01f, 2.77917441e-02f, 4.08291340e-01f, -2.47404099e-01f,
  -2.45862380e-01f, 2.50038505e-01f, -1.34811946e-03f, 1.33803368e-01f, 3.21697183e-02f, 9.01680961e-02f, 1.72543406e-01f, -1.08479179e-01f, -1.06622450e-01f, -1.59090996e-01f,
  -5.47872707e-02f, -6.83688000e-02f, -6.84054345e-02f, 2.52188444e-01f, -7.68611655e-02f, -1.28188208e-01f, 4.29543247e-03f, 4.31967676e-02f, 7.72256926e-02f, 7.45798945e-02f,
  -8.16698223e-02f, 3.54513340e-02f, 1.11511149e-01f, -6.30225465e-02f, 1.88316405e-01f, -7.75367543e-02f, 2.06191376e-01f, -1.38597339e-01f, -3.13301831e-02f, 3.20488028e-02f,
  1.11752622e-01f, 5.74502647e-02f, 9.56425741e-02f, 8.60815495e-02f, 1.69783846e-01f, 2.24939838e-01f, -7.05589131e-02f, -1.56619489e-01f, -1.94090143e-01f, 2.12939177e-02f,
  1.57548428e-01f, -1.52896285e-01f, 2.46773697e-02f, -2.27994815e-01f, 1.74510762e-01f, 1.40519232e-01f, 9.24087986e-02f, 2.64833063e-01f, 2.76980940e-02f, 3.19228858e-01f,
  9.67673436e-02f, 1.19266436e-01f, 1.36741474e-02f, -8.13433230e-02f, 6.66969121e-02f, -2.39284366e-01f, -1.03064582e-01f, -3.24694097e-01f, 4.16870378e-02f, -1.59993634e-01f,
  -1.27646878e-01f, 1.53266311e-01f, 2.10385457e-01f, 5.19137643e-02f, -1.07806578e-01f, 7.91373998e-02f, -2.11319953e-01f, 1.16402633e-01f, -1.26015395e-01f, -4.05667983e-02f,
  -2.19773963e-01f, -1.82488821e-02f, 2.38677680e-01f, 8.58176053e-02f, -1.57335222e-01f, 1.45973757e-01f, 6.26604930e-02f, 4.94794780e-03f, -1.12875015e-01f, 1.78506851e-01f,
  7.27922320e-02f, 1.08968746e-02f, -2.94193067e-02f, 5.60765620e-03f, 9.69035923e-02f, 1.51547894e-01f, -8.21398869e-02f, -3.27302873e-01f, 1.81816574e-02f, 9.84451845e-02f,
  7.30407760e-02f, 1.37694627e-01f, -3.27074155e-02f, -9.68986563e-03f, -8.35370347e-02f, -2.35058695e-01f, -6.92162439e-02f, -1.16853796e-01f, 1.07091874e-01f, -9.99138728e-02f,
  -1.29528940e-01f, 3.77123337e-03f, 1.20009147e-01f, -3.03524863e-02f, -7.80721605e-02f, 1.64988071e-01f, -1.07161559e-01f, 1.51867867e-01f, -3.29941213e-01f, 1.08353436e-01f,
  2.36029655e-01f, -9.39247981e-02f, -2.56134659e-01f, -2.65768200e-01f, -4.03468348e-02f, -2.93384492e-01f, -2.60956675e-01f, 4.96510928e-03f, -9.97296870e-02f, 1.88478380e-02f,
  7.04443604e-02f, -1.74296334e-01f, 2.97706813e-01f, -4.16150093e-02f, 3.75156522e-01f, 1.37671217e-01f, -2.44166598e-01f, 2.08734661e-01f, 2.99289733e-01f, -1.98079318e-01f,
  5.29939458e-02f, -1.61395773e-01f, 2.16593623e-01f, -3.77372690e-02f, 2.00663749e-02f, 1.27379015e-01f, 6.76012784e-02f, 1.35635249e-02f, 1.10494964e-01f, 6.39487728e-02f,
  1.65136397e-01f, 1.04451617e-02f, -7.00836489e-03f, -8.98401067e-02f, 3.58779691e-02f, 2.08732665e-01f, -3.64051363e-03f, 1.85727656e-01f, 9.28837657e-02f, 3.19859348e-02f,
  6.04897551e-02f, 8.45885798e-02f, -1.04234330e-01f, -8.18676502e-02f, -1.85135528e-01f, -5.72774671e-02f, -1.49204150e-01f, -1.36616761e-02f, -6.25395253e-02f, 1.05048291e-01f,
  9.01382118e-02f, -1.09181121e-01f, -5.33712506e-02f, -2.16902331e-01f, -6.49183467e-02f, -1.50514916e-01f, 3.41861299e-03f, 3.62823606e-02f, -5.35261910e-03f, -1.84287578e-01f,
  -8.71967971e-02f, -8.65890831e-02f, 7.83970132e-02f, -4.25026305e-02f, 3.48207466e-02f, 1.89387396e-01f, -2.54047692e-01f, 1.64171353e-01f, 1.19662471e-03f, 2.78954685e-01f,
  -1.87667489e-01f, 1.28391266e-01f, 1.94098622e-01f, -2.21433230e-02f, 1.82328686e-01f, 1.69106707e-01f, -5.07286750e-02f, -5.97107932e-02f, -3.17248851e-01f, 1.31315202e-01f,
  1.96454912e-01f, -4.74030562e-02f, -1.03324875e-01f, 3.61144066e-01f, -5.38371950e-02f, 1.66035071e-01f, 2.16774479e-01f, 1.07961610e-01f, 1.01092272e-01f, -1.78011924e-01f,
  7.76603371e-02f, 1.14484854e-01f, -3.02869640e-02f, -1.65124029e-01f, -1.72829092e-01f, 1.46884501e-01f, 1.59433391e-02f, -5.07064946e-02f, -1.47068366e-01f, -2.64807679e-02f,
  3.13771337e-01f, 4.09732684e-02f, -1.07559882e-01f, 3.63219418e-02f, -1.10107839e-01f, -2.65922636e-01f, -1.16698541e-01f, 1.39100328e-01f, 9.43184942e-02f, 2.63031535e-02f,
  -7.02504814e-02f, -3.16293798e-02f, 1.54106691e-01f, -1.71010360e-01f, -2.73223297e-04f, -3.61958444e-02f, -1.55337611e-02f, -3.33478190e-02f, 4.66997847e-02f, -1.00342125e-01f,
  6.44615740e-02f, 3.11546903e-02f, -9.53085423e-02f, 1.10316044e-02f, 1.50038794e-01f, 8.73412937e-02f, 3.46104130e-02f, -4.60764393e-02f, 4.26438265e-02f, -1.82617575e-01f,
  -3.57567489e-01f, 1.56748295e-01f, -1.29095361e-01f, -6.07155310e-03f, 2.29634836e-01f, 6.67605875e-03f, -3.55353095e-02f, 9.78433639e-02f, 3.35897833e-01f, 2.13700294e-01f,
  1.27428472e-01f, -2.94083267e-01f, -1.40198274e-02f, 3.01560368e-02f, 3.02250326e-01f, -8.26562569e-02f, -1.90575272e-02f, -1.56656250e-01f, 6.94996538e-03f, 1.32905975e-01f,
  2.80323714e-01f, 1.89297318e-01f, 1.82701454e-01f, 3.90182324e-02f, -3.38590704e-04f, 1.77862793e-01f, -2.07551848e-02f, -1.30490586e-01f, -6.92798570e-02f, -1.15000211e-01f,
  -4.04759496e-02f, -1.31639451e-01f, -2.01914191e-01f, 2.34432712e-01f, 2.80208103e-02f, -6.95238858e-02f, 8.03993549e-03f, -2.14076221e-01f, 4.36339416e-02f, -7.63007402e-02f,
  -5.98261356e-02f, 7.60785788e-02f, 1.85045063e-01f, -3.05896923e-02f, -3.16760852e-04f, 1.36277422e-01f, 2.27586344e-01f, 1.24167437e-02f, -2.78382599e-01f, -6.31080195e-02f,
  2.00357754e-02f, 9.77503657e-02f, 9.63573307e-02f, -1.08638376e-01f, -1.18956387e-01f, 1.84233524e-02f, 3.53229567e-02f, -1.91574395e-01f, 2.69351806e-02f, -1.45878926e-01f,
  2.30932832e-01f, -2.23051384e-01f, -7.18801022e-02f, -3.33183676e-01f, 2.86365747e-01f, -6.58758804e-02f, -1.68356746e-01f, 4.59393524e-02f, 2.15930268e-01f, 3.03963065e-01f,
  -1.69380367e-01f, 1.03754865e-03f, 1.49537250e-01f, -1.64634898e-01f, -7.23837991e-04f, 3.84362065e-03f, -1.57193184e-01f, 8.30232129e-02f, 9.87113938e-02f, -5.21892831e-02f,
  -9.31418389e-02f, -5.30492291e-02f, 2.51550227e-01f, 2.26988599e-01f, -1.83183596e-01f, -4.88922782e-02f, -1.17081823e-02f, 2.76980191e-01f, 1.65960982e-01f, 1.29665574e-02f,
  6.74250200e-02f, -1.96708113e-01f, -4.64290529e-02f, 1.64926827e-01f, -1.76065430e-01f, 1.21672697e-01f, 5.79505078e-02f, -3.91763300e-02f, -9.21063796e-02f, -1.22795142e-02f,
  4.68697995e-02f, 5.30872159e-02f, -1.62157372e-01f, -1.84592605e-01f, -1.25396654e-01f, 5.90414405e-02f, 3.84652689e-02f, 1.70431912e-01f, -6.37621880e-02f, -5.81454933e-02f,
  9.97290853e-03f, 2.79650535e-03f, -2.59942561e-01f, 1.37769267e-01f, 4.08315985e-03f, -1.53079227e-01f, 2.43108114e-03f, -8.79702568e-02f, 1.03475889e-02f, -1.26535088e-01f,
  -8.71141255e-02f, 1.11488119e-01f, -9.13482979e-02f, 7.33677521e-02f, -1.15539245e-01f, 3.90274115e-02f, 1.20162533e-03f, -2.55791217e-01f, -6.35701120e-02f, -1.11568406e-01f,
  -2.49680713e-01f, 2.86367834e-02f, 1.25092372e-01f, 2.19748825e-01f, -1.15800664e-01f, 7.16198608e-02f, 2.58985430e-01f, 3.13029349e-01f, -5.87392189e-02f, 2.47337162e-01f,
  -1.06669869e-02f, -1.90397069e-01f, -2.79416889e-01f, -1.85374871e-01f, -9.16328356e-02f, -1.85022682e-01f, 2.87377089e-01f, 1.03078164e-01f, 5.03281243e-02f, 7.25346953e-02f,
  8.19964856e-02f, -6.97852075e-02f, -3.97522375e-02f, -5.80182113e-02f, 2.06320956e-01f, -4.27810699e-02f, -5.05337827e-02f, -1.27107933e-01f, 3.78306583e-02f, -6.85081780e-02f,
  -4.74125929e-02f, -6.61507249e-02f, -8.62211138e-02f, 6.47958219e-02f, -1.88122898e-01f, 7.17967227e-02f, 1.70832947e-01f, 1.93733767e-01f, -1.12752333e-01f, 1.49112239e-01f,
  -1.10104039e-01f, 8.53601750e-03f, 8.64774063e-02f, 1.32425159e-01f, 1.51837036e-01f, 8.94445330e-02f, -3.60787138e-02f, 6.00601807e-02f, -7.83998519e-03f, 1.42925590e-01f,
  -2.19789490e-01f, -6.05568215e-02f, -9.31714401e-02f, -1.35203078e-01f, 1.39152437e-01f, -1.65911317e-01f, 2.82122921e-02f, -1.02102272e-01f, -8.52122530e-02f, 3.00069273e-01f,
  -1.34127796e-01f, -5.17832302e-03f, 2.07224160e-01f, 7.16084987e-02f, 2.95099635e-02f, -6.71203807e-02f, 3.35953087e-02f, -7.57512525e-02f, 9.97045115e-02f, -1.17447577e-01f,
  -1.13948444e-02f, -1.41259521e-01f, -2.46693224e-01f, -2.03634351e-01f, -1.97343305e-01f, 6.28684461e-02f, 8.35950226e-02f, 1.22483028e-02f, -1.25118747e-01f, 2.13474408e-01f,
  -2.22445413e-01f, 2.71289051e-01f, 3.23844366e-02f, 1.97004527e-02f, 1.79434270e-01f, 2.89357137e-02f, -7.28290528e-03f, 7.49760447e-03f, -5.37247434e-02f, 2.06593126e-01f,
  -3.30588520e-02f, 5.10402629e-03f, -3.11662094e-03f, 8.14149976e-02f, -3.27692367e-04f, 9.16948095e-02f, -9.51462612e-03f, 3.92575189e-03f, 7.87990913e-02f, 1.75071359e-01f,
  -2.05777362e-01f, -3.93157631e-01f, 2.58549750e-02f, -1.08306319e-01f, -1.56269327e-01f, 1.04585342e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.02502309e-01f, 8.78229588e-02f, -2.59387910e-01f, 3.14505100e-02f, 2.23455578e-01f, -2.14840621e-01f, 9.14076492e-02f, -2.67163873e-01f, 1.82011575e-01f, 1.55777037e-01f,
  3.84590685e-01f, 3.85908522e-02f, 3.19909900e-02f, -4.50927317e-02f, 1.37897760e-01f, -7.75919929e-02f, 4.54960287e-01f, 2.01945826e-02f, -1.07544824e-01f, 2.59563237e-01f,
  -4.20813560e-02f, 5.19422106e-02f, -1.19754396e-01f, 2.97437459e-01f, -1.27310380e-01f, -4.54357192e-02f, 2.81521738e-01f, -4.68756631e-02f, 1.01676546e-01f, 8.69002938e-03f,
  1.38610676e-01f, -1.36594325e-01f, -4.09033000e-01f, -7.43265077e-02f, 1.13984123e-01f, 1.55098423e-01f, -1.56231523e-02f, 8.26079622e-02f, 1.18244581e-01f, 4.57389683e-01f,
  1.04141794e-01f, 4.06827986e-01f, 1.95521668e-01f, -1.38097033e-02f, 1.18715540e-01f, -4.97452691e-02f, -1.18504688e-01f, -8.05513859e-02f, 1.69761389e-01f, 1.55084297e-01f,
  2.39803091e-01f, -9.02071744e-02f, -1.66808322e-01f, 3.04405332e-01f, 3.40228140e-01f, 2.59140760e-01f, 1.89892933e-01f, -5.85411955e-03f, -1.51204720e-01f, -5.58299363e-01f,
  -4.06979285e-02f, 1.17934257e-01f, 2.33180374e-01f, 2.37561986e-01f, -2.27392465e-01f, -3.95596884e-02f, -7.03097731e-02f, -3.71141136e-01f, 1.26298312e-02f, -1.10696964e-02f,
  -8.95272568e-02f, -2.69348234e-01f, 1.66305795e-01f, 2.34832436e-01f, 3.78342599e-01f, -4.02606316e-02f, -2.32609600e-01f, 1.80531368e-01f, 4.62871604e-02f, -1.84772968e-01f,
  2.92253882e-01f, -2.23757133e-01f, -8.34061429e-02f, -4.24184948e-01f, -7.25018531e-02f, -3.28638852e-01f, 5.17613702e-02f, -4.84712183e-01f, 2.29025766e-01f, 4.44529831e-01f,
  -9.24049541e-02f, -3.86915132e-02f, 2.72313952e-01f, -1.03174292e-01f, 1.35723382e-01f, 2.90995464e-02f, 9.19002593e-02f, 1.07218578e-01f, -5.57164311e-01f, -3.23312022e-02f,
  -1.82440341e-01f, -2.69239992e-01f, 3.45354915e-01f, -3.32947761e-01f, -5.07424176e-02f, -1.42271385e-01f, 1.46492362e-01f, 2.35741690e-01f, 2.16685951e-01f, -1.66272253e-01f,
  1.48424029e-01f, 7.88981616e-02f, 3.00475568e-01f, -6.73849043e-03f, 3.40485871e-01f, -1.76466219e-02f, -1.17756180e-01f, 7.66092241e-02f, 5.18300906e-02f, -3.88215818e-02f,
  -6.17065012e-01f, -2.83946514e-01f, -1.60799786e-01f, 2.50872791e-01f, -4.37910371e-02f, -2.91120023e-01f, -2.31835082e-01f, -1.58617213e-01f, 2.94861645e-01f, 1.24975383e-01f,
  8.94240960e-02f, 2.76708215e-01f, 7.44801015e-02f, 2.45468393e-01f, 2.77833194e-01f, 4.58190501e-01f, 2.01006323e-01f, 2.66924351e-01f, 2.13369012e-01f, -6.56572878e-02f,
  -9.08820480e-02f, -1.48168340e-01f, 3.15769315e-01f, 2.62003005e-01f, 9.97073427e-02f, 5.16472571e-02f, -1.20946206e-01f, -3.12371939e-01f, 1.72978520e-01f, 2.92091459e-01f,
  9.08015575e-03f, 3.87127697e-01f, 4.63454723e-01f, 3.09923470e-01f, 7.44467154e-02f, -3.60259414e-01f, 2.43442997e-01f, 2.40980282e-01f, -1.76891938e-01f, -3.44436377e-01f,
  -2.67247081e-01f, 1.06796019e-01f, 2.52479408e-02f, -3.90952319e-01f, -1.08997174e-01f, 5.20996571e-01f, -2.14633092e-01f, 2.96384215e-01f, -2.16051973e-02f, 1.05425954e-01f,
  2.17861459e-01f, -7.05380142e-02f, -6.95640175e-03f, 3.32977027e-01f, 1.26422420e-01f, -2.60296702e-01f, 1.48707805e-02f, 3.74502540e-01f, -7.00103119e-02f, 3.56528699e-01f,
  1.63362175e-01f, -1.98006272e-01f, 9.80049074e-02f, -8.22208971e-02f, -2.39507049e-01f, 5.70710599e-01f, 4.21419024e-01f, 2.46910423e-01f, 2.74385810e-01f, 6.35299087e-02f,
  1.71328440e-01f, 4.23037022e-01f, 7.88597092e-02f, -1.21587008e-01f, 8.26353673e-03f, -1.97985366e-01f, -8.97120386e-02f, -8.93498138e-02f, -1.34526771e-02f, -1.52732238e-01f,
  -1.44179061e-01f, -1.52481750e-01f, 7.78628886e-02f, -1.02911837e-01f, 3.39322612e-02f, 2.34433487e-01f, 1.51271850e-01f, 3.15660328e-01f, -3.09660792e-01f, 2.73944676e-01f,
  1.07660763e-01f, -1.12698209e-02f, -2.38331690e-01f, 1.87703162e-01f, -2.35724613e-01f, 1.71431273e-01f, -6.84669092e-02f, -1.06108962e-02f, -8.14739466e-02f, 3.88897434e-02f,
  4.34021801e-01f, 4.25623000e-01f, -1.65101811e-01f, -4.34244335e-01f, -5.19375391e-02f, -3.81430574e-02f, -7.09078237e-02f, 1.06044076e-01f, -1.51395658e-02f, 1.32543132e-01f,
  2.18956247e-02f, 1.49554685e-01f, 9.13220569e-02f, 1.93835855e-01f, 2.64912218e-01f, 9.81013291e-03f, -5.86652271e-02f, 1.16208918e-01f, 2.03303412e-01f, -4.52548452e-02f,
  6.82571456e-02f, 5.75556047e-03f, 1.85496718e-01f, -9.68799740e-02f, -2.24324055e-02f, 3.67388986e-02f, 3.43929380e-02f, 6.67691156e-02f, -6.26050457e-02f, 2.38038853e-01f,
  3.74605268e-01f, 9.24727321e-02f, -8.18408560e-03f, -1.89125106e-01f, 1.69218361e-01f, 6.50173426e-02f, 2.15030983e-01f, 2.45808750e-01f, 2.47698963e-01f, 4.86607589e-02f,
  1.16743222e-01f, 5.40864944e-01f, 2.11091176e-01f, 3.27353150e-01f, 6.77374080e-02f, 2.39865765e-01f, -4.13311832e-02f, 3.45668972e-01f, 9.56855789e-02f, 1.98003024e-01f,
  3.22137415e-01f, 8.45075473e-02f, -9.89118032e-03f, 1.91945314e-01f, -1.02751143e-01f, -1.02524012e-01f, 6.58321917e-01f, -3.28153312e-01f, 2.12325454e-01f, 4.12201509e-02f,
  -4.28059362e-02f, -2.18148574e-01f, -1.66771844e-01f, 5.56462854e-02f, -1.34714076e-03f, -1.59706339e-01f, 2.26991937e-01f, 5.14560223e-01f, -7.26851821e-02f, -5.81425428e-02f,
  -1.18891567e-01f, 3.62191051e-01f, -2.62535930e-01f, -9.88437757e-02f, 3.14535201e-01f, 1.37090638e-01f, -2.43534252e-01f, 3.29968482e-02f, -1.00375950e-01f, -1.06114008e-01f,
  -1.90592125e-01f, 2.75545925e-01f, 7.73701966e-02f, 1.68470547e-01f, -8.82995352e-02f, 1.03265375e-01f, 5.54991029e-02f, 3.68879765e-01f, 3.42118472e-01f, -1.13294788e-01f,
  -9.12882760e-02f, -1.83189660e-01f, 4.47989732e-01f, -3.12260658e-01f, -3.18527132e-01f, -3.89546603e-02f, 1.50701120e-01f, 4.66938168e-01f, 6.20801821e-02f, 1.86840758e-01f,
  -7.77283013e-02f, 1.02096811e-01f, -3.94468099e-01f, -1.24187879e-01f, 1.91547200e-01f, -5.39723299e-02f, -4.68543917e-02f, -1.46743149e-01f, 4.06425059e-01f, 1.85057104e-01f,
  2.27973506e-01f, 5.60522415e-02f, -6.59338906e-02f, 6.98540434e-02f, -4.68458496e-02f, 3.82009357e-01f, -6.65239245e-02f, -4.09056656e-02f, -1.39372088e-02f, 8.43934640e-02f,
  -1.09227255e-01f, -1.77692398e-01f, -1.30923197e-01f, 1.36878163e-01f, 3.62017602e-02f, 1.45108372e-01f, -8.02539885e-02f, 2.24824205e-01f, 1.80037200e-01f, 4.34885263e-01f,
  1.42247424e-01f, 1.05015576e-01f, 3.99839617e-02f, -2.07653776e-01f, -3.86858970e-01f, 6.60907552e-02f, 1.70124799e-01f, -1.54474959e-01f, 1.83896452e-01f, -2.44783625e-01f,
  -1.83391392e-01f, 2.07608759e-01f, -4.40178216e-01f, -3.70916463e-02f, 2.32332706e-01f, -5.38538471e-02f, 2.32017804e-02f, 7.56973550e-02f, 2.44549781e-01f, -1.44918516e-01f,
  3.90109092e-01f, -3.21933359e-01f, 6.27947971e-02f, 4.23099566e-03f, 2.98302859e-01f, -6.36732299e-03f, -1.52835220e-01f, -3.78588736e-01f, 2.02886418e-01f, 1.35436133e-01f,
  -3.58905554e-01f, -3.58339176e-02f, -6.63059130e-02f, 7.62678459e-02f, 2.17462450e-01f, 2.98812658e-01f, 6.64825365e-02f, 1.87505692e-01f, -2.62380511e-01f, 4.58812326e-01f,
  9.69293937e-02f, 9.63848159e-02f, 3.29663664e-01f, 9.13819857e-03f, -3.29761277e-03f, 1.51494637e-01f, -4.89012226e-02f, 1.56678297e-02f, 2.52484411e-01f, 4.88007106e-02f,
  4.36316393e-02f, 2.10036576e-01f, -9.08603817e-02f, -4.49261487e-01f, 2.50460982e-01f, -1.32574543e-01f, -1.13237120e-01f, -1.41901970e-01f, 3.15695524e-01f, 2.73556441e-01f,
  -4.38612640e-01f, 2.32994273e-01f, -3.05800345e-02f, 4.07945186e-01f, 7.80951902e-02f, 5.00137985e-01f, -4.56067286e-02f, -3.26654732e-01f, -1.49797335e-01f, 9.90229994e-02f,
  1.18819177e-01f, -2.75738031e-01f, 4.34475660e-01f, 1.22110277e-01f, -3.47026944e-01f, 1.04594305e-01f, -2.20525205e-01f, -1.37649491e-01f, -1.34891301e-01f, -5.03339581e-02f,
  2.02085316e-01f, 9.15857926e-02f, 6.88248873e-02f, -1.44798815e-01f, 2.19632164e-01f, 1.94617242e-01f, 1.42838225e-01f, -1.90849409e-01f, 1.11983091e-01f, -2.13064745e-01f,
  -5.00020944e-02f, -2.41251871e-01f, 1.04773693e-01f, 3.69641781e-01f, 1.37832403e-01f, 4.45923030e-01f, -9.64890793e-03f, -2.51694815e-03f, 1.26455780e-02f, -2.11261302e-01f,
  -2.94856224e-02f, 1.53568000e-01f, 2.02413067e-01f, 2.59606987e-01f, 1.73682958e-01f, 1.31262362e-01f, -8.94127190e-02f, 1.88346580e-01f, 1.35211825e-01f, 1.25691667e-01f,
  2.00981006e-01f, 2.51944453e-01f, 1.53212026e-01f, -1.12550497e-01f, 1.04493521e-01f, 1.93897903e-01f, 2.02225111e-02f, 4.30398405e-01f, 3.62387788e-03f, 7.59530738e-02f,
  2.08456680e-01f, -1.86699122e-01f, -1.02343157e-01f, -4.00564671e-01f, -1.59350842e-01f, -2.28537232e-01f, -3.18180978e-01f, -5.81752241e-01f, 2.62394488e-01f, -1.47293597e-01f,
  1.95278332e-01f, 8.87063965e-02f, 1.87441051e-01f, 1.08314961e-01f, -4.86287355e-01f, 2.06785589e-01f, -3.27174924e-02f, -2.79703408e-01f, 2.53810644e-01f, -4.44978140e-02f,
  3.61572266e-01f, 1.50493845e-01f, -2.20653251e-01f, 1.17299864e-02f, -2.26124134e-02f, 2.32544094e-01f, -3.52474391e-01f, 3.11856776e-01f, -3.16898257e-01f, 2.45927349e-01f,
  2.90663779e-01f, -1.68623254e-01f, 8.51238891e-02f, 3.82873379e-02f, 1.98633417e-01f, 3.52234542e-01f, 1.93063930e-01f, 3.48860660e-04f, 3.60509455e-01f, 1.17715485e-01f,
  1.97204486e-01f, 1.31928355e-01f, 6.93595335e-02f, -1.73149109e-01f, 3.79794985e-02f, 7.71765411e-02f, 5.72082773e-02f, 1.48640364e-01f, 1.96026135e-02f, 1.37687951e-01f,
  -1.63302988e-01f, -3.42146098e-03f, 1.83824226e-01f, -1.10246101e-02f, 1.68714002e-01f, 3.33183885e-01f, -6.58879578e-02f, 1.72319591e-01f, -3.25332619e-02f, -1.82918072e-01f,
  2.77501941e-01f, 1.30205408e-01f, -3.68016392e-01f, -1.44162297e-01f, -6.15544468e-02f, -4.42623824e-01f, -2.49802768e-01f, -2.72054821e-01f, -2.55703986e-01f, 3.11977029e-01f,
  -2.77588636e-01f, -1.95173681e-01f, 2.48937815e-01f, 1.12519898e-01f, 2.12387145e-01f, -1.78652272e-01f, 2.61328608e-01f, 1.85515434e-01f, -1.17985249e-01f, -1.21069342e-01f,
  5.81191443e-02f, -2.66527295e-01f, 3.75882179e-01f, -1.86088189e-01f, 1.40215576e-01f, 2.14768291e-01f, -1.19331628e-01f, 1.26978308e-01f, 4.49739724e-01f, 2.69677579e-01f,
  2.12446868e-01f, 8.02472010e-02f, -1.85778346e-02f, -1.36974782e-01f, 1.30686343e-01f, 5.10105379e-02f, 8.79732072e-02f, 1.87131703e-01f, 6.23802952e-02f, -1.63002849e-01f,
  1.49720088e-01f, 4.35139090e-01f, 1.01200536e-01f, 2.33689114e-01f, 8.86383057e-02f, -2.67667234e-01f, 2.96369083e-02f, 8.03070664e-02f, 3.99705246e-02f, -2.23740593e-01f,
  -4.36680317e-02f, 1.44091368e-01f, -3.63559835e-02f, 2.05838773e-02f, 6.73055276e-02f, 8.14865343e-03f, 1.16852924e-01f, -5.23465574e-02f, -4.01981287e-02f, 1.89058587e-01f,
  2.81033695e-01f, 6.00625873e-02f, -7.85133615e-02f, 3.63072604e-01f, -4.45489250e-02f, -9.10176411e-02f, 9.05491710e-02f, -3.04417759e-01f, 1.88477933e-01f, -7.60209113e-02f,
  1.61533639e-01f, 5.05148172e-02f, -2.97127873e-01f, 1.60266325e-01f, 2.65471667e-01f, 8.91292915e-02f, 4.57338840e-02f, 3.19299787e-01f, 3.92213076e-01f, 1.34665489e-01f,
  -5.31289494e-03f, 2.69595385e-01f, -2.64597774e-01f, -1.65016651e-01f, 4.01353002e-01f, -4.64574665e-01f, -2.92302687e-02f, -1.85863048e-01f, 1.31594583e-01f, 3.82295670e-03f,
  -1.88476831e-01f, -1.33023083e-01f, -1.71288088e-01f, 2.72251666e-01f, 1.60041247e-02f, 2.59930313e-01f, -8.23460966e-02f, 8.37966129e-02f, 4.10027280e-02f, -3.44496906e-01f,
  3.41719151e-01f, -2.29030952e-01f, 4.00645472e-02f, 1.87748611e-01f, -5.37287118e-03f, 1.89735666e-01f, 1.70645356e-01f, 2.02623174e-01f, -2.43639797e-01f, 9.90409106e-02f,
  -1.15306355e-01f, 4.15044911e-02f, 4.43548650e-01f, -6.47546500e-02f, -3.69797945e-01f, 3.61411236e-02f, 1.39098659e-01f, 3.21610898e-01f, -3.16986203e-01f, -2.52825826e-01f,
  -2.54070699e-01f, 1.02751628e-02f, -5.87648191e-02f, 3.87722664e-02f, 7.68565908e-02f, 1.26458749e-01f, -1.73717573e-01f, 4.80905205e-01f, 2.43472736e-02f, -3.54212105e-01f,
  4.49034333e-01f, -8.52562785e-02f, 3.31630290e-01f, 2.01134473e-01f, 1.02984920e-01f, -5.80860525e-02f, -1.09320931e-01f, -1.08612981e-02f, 1.71874598e-01f, 1.40013292e-01f,
  -1.68604571e-02f, 2.87209064e-01f, 1.51274860e-01f, 9.26353261e-02f, -1.14918193e-02f, 2.96597868e-01f, 1.67775288e-01f, -2.53373832e-01f, 9.92180333e-02f, 9.65884402e-02f,
  -3.06551486e-01f, 6.73704967e-02f, -2.22983837e-01f, 2.23530278e-01f, -2.88890991e-02f, 2.02403381e-01f, -7.42088556e-02f, 9.40813422e-02f, 3.30520123e-02f, -8.25956613e-02f,
  3.60355042e-02f, 2.13353708e-01f, 5.54595888e-02f, 1.10052913e-01f, -2.56215453e-01f, -1.23163844e-02f, 1.15426861e-01f, 2.95630008e-01f, -2.04095934e-02f, -2.61555582e-01f,
  -2.43183255e-01f, 3.45210105e-01f, -4.24402297e-01f, 6.02726825e-02f, 1.34322882e-01f, 1.29192658e-02f, 5.34035787e-02f, -7.65568018e-02f, 1.82102457e-01f, 1.70000553e-01f,
  9.07476842e-02f, -2.51610056e-02f, 9.89070237e-02f, -6.48690090e-02f, 2.58812904e-02f, 7.05032200e-02f, 5.30489981e-02f, 3.03567410e-01f, -8.68872255e-02f, 3.33986372e-01f,
  -2.18255743e-02f, -1.51119649e-01f, 6.03839643e-02f, -3.61446589e-02f, -1.94788259e-02f, -2.73033045e-02f, -1.91270381e-01f, 8.32458436e-02f, -1.76303219e-02f, 1.42978683e-01f,
  -3.04437965e-01f, 4.30643290e-01f, 6.52956888e-02f, 4.70739067e-01f, 8.52333903e-02f, -9.08765718e-02f, 4.77307849e-02f, -1.47807360e-01f, -1.68856412e-01f, 1.02990139e-02f,
  6.67499304e-02f, -4.00465578e-02f, 8.84374827e-02f, -7.41216391e-02f, -1.70795172e-01f, 1.40110165e-01f, -2.44716704e-01f, 3.70646976e-02f, -3.54458466e-02f, 9.33543295e-02f,
  1.93301648e-01f, 5.56454547e-02f, 1.43731669e-01f, -1.43880621e-01f, 3.27012211e-01f, -1.45559534e-01f, 2.15942949e-01f, 1.42531209e-02f, 2.85970271e-01f, 1.14411667e-01f,
  -7.81864002e-02f, -1.54326916e-01f, 2.33556598e-01f, 3.66021931e-01f, -1.72956347e-01f, 3.16162467e-01f, -1.26837283e-01f, -9.49437469e-02f, 2.42151469e-01f, 4.99616683e-01f,
  -2.77205229e-01f, 1.39670834e-01f, -2.60536134e-01f, 2.42555863e-03f, 2.28563130e-01f, -1.16966002e-01f, 5.38031012e-03f, 2.83385161e-02f, -3.85001674e-03f, -5.13634980e-02f,
  1.07433990e-01f, -3.86577435e-02f, -1.71106849e-02f, 1.62216891e-02f, 2.62571096e-01f, 9.00817961e-02f, -1.86689839e-01f, 1.26750097e-01f, -2.57476866e-01f, -3.27965200e-01f,
  -5.31307817e-01f, 1.30846724e-01f, -2.75629818e-01f, -4.64851968e-02f, -9.46099758e-02f, 8.45120996e-02f, -1.08951204e-01f, 1.89828336e-01f, -9.08650905e-02f, 1.48768816e-02f,
  -4.01816182e-02f, -2.02099428e-01f, 2.32644096e-01f, 2.74185408e-02f, 3.84799957e-01f, 3.86629440e-02f, -7.38884360e-02f, 1.27500176e-01f, 2.97309995e-01f, 9.43021178e-02f,
  8.87288600e-02f, 3.56465988e-02f, -1.37904054e-02f, -1.97627731e-02f, 1.66807756e-01f, -3.45123559e-02f, 2.81005949e-01f, 4.11345400e-02f, 5.01620397e-02f, -1.06516160e-01f,
  2.49581337e-01f, 2.61918902e-01f, 3.72060761e-02f, 8.55555311e-02f, 8.64296928e-02f, -2.08026350e-01f, -1.55545190e-01f, 2.22896188e-01f, 1.47188799e-02f, 2.44107798e-01f,
  6.10116422e-02f, -8.71877223e-02f, 2.63529301e-01f, 2.65025556e-01f, 1.94539484e-02f, 7.09044486e-02f, 9.88608971e-02f, 1.39874846e-01f, 2.63707757e-01f, 2.68675417e-01f,
  3.55259895e-01f, 1.04261607e-01f, 3.75861436e-01f, 2.20511094e-01f, 2.46557295e-01f, -6.27091358e-05f, 1.04138218e-01f, 4.44269300e-01f, 2.01134458e-01f, 1.81348234e-01f,
  1.59059204e-02f, 1.00849196e-01f, 7.58798122e-01f, -5.07787354e-02f, 1.13951109e-01f, 4.56559777e-01f, 3.24108213e-01f, 1.06696226e-01f, 3.41280222e-01f, 1.23641871e-01f,
  2.24436700e-01f, 1.04471840e-01f, -1.51134813e-02f, 5.19190580e-02f, -1.54351130e-01f, -1.35732293e-01f, -3.46408896e-02f, 4.08205867e-01f, -9.19208024e-03f, -1.89501300e-01f,
  2.79396176e-02f, 2.05799505e-01f, -2.81198800e-01f, 3.58468831e-01f, -2.04368308e-01f, -4.54655737e-01f, 2.94758201e-01f, 1.59888893e-01f, -2.85556197e-01f, 1.49483621e-01f,
  1.83029965e-01f, 9.22517106e-02f, 3.47006470e-01f, 3.36477786e-01f, 6.77597746e-02f, -8.74119923e-02f, 1.52692199e-01f, -1.28712744e-01f, 5.14557846e-02f, -1.57529309e-01f,
  -6.08268343e-02f, -4.88185614e-01f, -5.36888540e-02f, 1.44743830e-01f, 1.04498439e-01f, 2.95161784e-01f, -1.45156849e-02f, -2.20760256e-02f, -3.00906867e-01f, 6.04211129e-02f,
  3.77835006e-01f, -5.35843857e-02f, 1.17268622e-01f, 8.29227567e-02f, 2.81566828e-01f, 2.23463312e-01f, 1.37262359e-01f, 1.75751597e-01f, -4.26378064e-02f, 2.60172457e-01f,
  9.03876051e-02f, 5.78234680e-02f, -5.00237457e-02f, -8.48175734e-02f, 2.58732617e-01f, 4.47696328e-01f, 1.09885447e-01f, 7.64619261e-02f, 4.67396557e-01f, -6.73827231e-02f,
  2.48218756e-02f, -3.79356623e-01f, 1.55285999e-01f, 1.76456541e-01f, -2.88639069e-01f, 1.40174069e-02f, 4.69672650e-01f, -1.30262718e-01f, 8.72218832e-02f, 3.72285694e-02f,
  9.84581769e-04f, -8.94060060e-02f, 1.06324546e-01f, -3.63997519e-01f, 5.72843738e-02f, -3.43125492e-01f, -1.22476168e-01f, 7.56627172e-02f, -1.85049281e-01f, -3.23098421e-01f,
  1.34809762e-01f, -1.84650701e-02f, -1.22602597e-01f, 2.79984593e-01f, 1.27405405e-01f, 3.37352097e-01f, 2.76870430e-01f, -2.22890681e-04f, 5.26199900e-02f, 2.72826366e-02f,
  4.28776056e-01f, 1.08964413e-01f, 1.61997139e-01f, -3.07852298e-01f, 2.39950851e-01f, 1.70318097e-01f, 3.19145083e-01f, -9.50867161e-02f, 2.21833333e-01f, -5.88602535e-02f,
  1.46345407e-01f, 2.00803325e-01f, -6.59836978e-02f, 1.95086315e-01f, 1.42756730e-01f, 9.93837416e-02f, 2.24549547e-01f, -1.11080036e-01f, 9.08008367e-02f, 4.11297865e-02f,
  -4.98532429e-02f, 3.65591887e-03f, 1.44793093e-01f, 8.74452442e-02f, -1.28792793e-01f, 2.54676044e-01f, -1.26111418e-01f, 1.70096889e-01f, -1.15343250e-01f, 2.80792385e-01f,
  1.90653995e-01f, -3.07646185e-01f, -1.11253776e-01f, 1.07746117e-01f, -2.30465457e-01f, -3.44050050e-01f, 6.76177964e-02f, 2.31032535e-01f, -4.86714616e-02f, 2.14880958e-01f,
  1.91439345e-01f, 3.01696718e-01f, 9.33354348e-02f, -2.91233838e-01f, -1.55169191e-03f, 1.65520221e-01f, 1.58617660e-01f, -2.74187952e-01f, 3.95795405e-02f, 1.14003252e-02f,
  2.60853797e-01f, 3.18183750e-01f, -1.16344392e-01f, 3.54338586e-02f, 1.29255150e-02f, 6.28358126e-02f, 1.26670778e-01f, 1.63304895e-01f, 2.00533867e-01f, -4.33088653e-02f,
  2.59201109e-01f, -2.28943437e-01f, 9.90035757e-02f, 1.88828722e-01f, -1.53710674e-02f, 1.43340856e-01f, 3.35053086e-01f, -2.28981584e-01f, -8.10441598e-02f, -1.08284980e-01f,
  -2.30767339e-01f, 2.89139539e-01f, 8.90649855e-03f, 6.12877682e-02f, 2.42293477e-01f, 2.93828726e-01f, 4.48583215e-01f, 4.14348468e-02f, -9.36973244e-02f, 2.82916367e-01f,
  6.04347326e-02f, 3.05943012e-01f, -1.31197467e-01f, -2.13933617e-01f, -3.91125679e-02f, 6.51365370e-02f, 1.02632545e-01f, -6.35055006e-02f, -4.74831118e-04f, 1.34618953e-01f,
  8.72138441e-02f, 2.07486525e-01f, 1.78813916e-02f, 1.31964818e-01f, 2.64595240e-01f, -8.77911299e-02f, -1.33977324e-01f, 2.28888690e-01f, -2.69868612e-01f, -2.01279417e-01f,
  -1.45482659e-01f, 2.66589880e-01f, 1.29793525e-01f, 2.17029318e-01f, -1.72012851e-01f, 1.60737894e-03f, -2.52682716e-01f, -9.80971828e-02f, 3.25408071e-01f, 2.36929923e-01f,
  -2.83426065e-02f, 1.61975011e-01f, -1.00201271e-01f, 3.73954803e-01f, -1.56404406e-01f, 1.86445087e-01f, -5.83946556e-02f, 1.25673875e-01f, -2.66053081e-02f, 1.71283573e-01f,
  -1.41672686e-01f, 1.62759483e-01f, -1.16300046e-01f, 7.30713382e-02f, -4.88179512e-02f, 1.16298862e-01f, 4.33070958e-01f, 8.81122872e-02f, -5.93019016e-02f, -1.75261348e-01f,
  4.99234200e-01f, 9.98224020e-02f, -6.76872358e-02f, -2.98867702e-01f, 4.77132164e-02f, 5.48892140e-01f, 3.74794775e-03f, 1.07938059e-01f, -1.60491347e-01f, -2.41510212e-01f,
  -3.31876844e-01f, -7.31346980e-02f, -3.58117759e-01f, -5.33356145e-02f, -2.20822748e-02f, -5.39298892e-01f, -2.31713772e-01f, -6.90248683e-02f, 2.00387165e-01f, -4.04535949e-01f,
  4.32972461e-02f, -9.48847607e-02f, -1.28917366e-01f, -2.34035343e-01f, 8.00967216e-02f, 2.18316689e-01f, -1.58704370e-01f, 3.56653571e-01f, -3.53106320e-01f, 1.14587322e-01f,
  -1.74584344e-01f, -8.53452459e-02f, -3.23374331e-01f, -2.82046795e-01f, -1.80064529e-01f, 1.00879304e-01f, -1.51492611e-01f, -3.10329109e-01f, 1.24438345e-01f, -1.98013827e-01f,
  -1.01557441e-01f, -1.25054225e-01f, 2.57191926e-01f, 3.41523401e-02f, -2.96123505e-01f, 7.58328438e-02f, 2.28166968e-01f, 1.61415949e-01f, 1.89552978e-01f, 2.13316858e-01f,
  9.23584253e-02f, -3.81968431e-02f, -1.07528716e-02f, 1.06564455e-01f, 2.81667978e-01f, 1.94202170e-01f, 1.17281407e-01f, 1.48964569e-01f, -4.33767252e-02f, -1.12349853e-01f,
  -1.39085710e-01f, 6.29266128e-02f, 2.18507629e-02f, 3.30348641e-01f, 2.35697299e-01f, 1.60390213e-01f, 6.17937595e-02f, -8.76682997e-02f, 5.05399071e-02f, 2.42527612e-02f,
  3.34769845e-01f, -6.71900809e-02f, 1.85146034e-01f, 2.78958380e-01f, -1.88654259e-01f, 3.65015209e-01f, 2.09120452e-01f, 3.57457176e-02f, 2.26656944e-01f, -7.05482950e-03f,
  1.12092867e-01f, 2.26659968e-01f, 8.34499449e-02f, 6.67597950e-02f, -1.26754373e-01f, 1.85382992e-01f, 3.06665778e-01f, -1.76092926e-02f, -3.84623068e-03f, 2.40182038e-02f,
  -1.80403590e-02f, -1.00997664e-01f, -1.78930357e-01f, 4.76828039e-01f, -2.10709065e-01f, 2.92345416e-02f, 2.72747755e-01f, 1.54580772e-01f, 1.83540136e-01f, -3.03593516e-01f,
  -2.12609813e-01f, 2.81437725e-01f, -4.34342414e-01f, -2.70076245e-01f, -1.44672647e-01f, 1.71895802e-01f, 4.29010242e-02f, -4.06210154e-01f, 1.91182449e-01f, 2.56993383e-01f,
  -5.13161778e-01f, 2.47426294e-02f, 1.95385702e-02f, -2.89130956e-03f, 9.60477442e-02f, -4.94379759e-01f, 1.14440501e-01f, 2.84443438e-01f, 2.21603364e-01f, -6.86096728e-01f,
  -4.70189862e-02f, 1.76219627e-01f, -7.70832747e-02f, 3.41687836e-02f, 8.18805322e-02f, 3.49348672e-02f, 1.46146640e-01f, -2.40541101e-02f, -3.19823980e-01f, 2.34402493e-01f,
  4.60944593e-01f, 2.88563222e-01f, 3.63511592e-01f, -4.06191111e-01f, 3.83847088e-01f, 9.56192017e-02f, 2.57443991e-02f, 4.94490638e-02f, 1.96453527e-01f, 1.70557126e-01f,
  2.14712486e-01f, 1.94614485e-01f, 1.43770635e-01f, 1.11568257e-01f, 1.32919922e-02f, 1.52461044e-02f, 2.04341710e-01f, 3.89407389e-02f, -4.80379947e-02f, 1.15327269e-01f,
  -1.57982484e-01f, 1.64758369e-01f, 1.88940987e-01f, -5.21462023e-01f, 3.38854730e-01f, -1.42605871e-01f, -1.43326819e-01f, 1.00280821e-01f, -3.22218835e-01f, 1.74467415e-02f,
  9.28206071e-02f, 4.36117440e-01f, -2.84388900e-01f, 1.35482222e-01f, 8.78160521e-02f, 2.17775196e-01f, 4.01182026e-02f, -2.12512076e-01f, -1.03306770e-01f, -1.43512979e-01f,
  -3.38161200e-01f, -8.52630809e-02f, 2.76384145e-01f, 1.44773200e-01f, -1.52736425e-01f, -1.12097144e-01f, 2.67209224e-02f, 2.49027666e-02f, -1.91148818e-02f, 3.22316825e-01f,
  1.44889414e-01f, 2.41435811e-01f, 5.52341938e-01f, 5.71015701e-02f, 1.62709802e-01f, -1.11060642e-01f, 1.97730325e-02f, -1.67747110e-01f, 2.18549520e-01f, 3.43612134e-02f,
  8.06039125e-02f, -8.23098794e-02f, -1.65083140e-01f, -2.37819418e-01f, 4.05042738e-01f, 5.59160352e-01f, 2.53896732e-02f, 2.05057323e-01f, 9.08129290e-02f, -2.19356492e-01f,
  5.29316291e-02f, -3.81955802e-01f, 2.20501378e-01f, 9.34840739e-02f, 4.99874353e-01f, 5.29708676e-02f, -9.37474146e-02f, 2.40071893e-01f, -1.38248011e-01f, 1.41936898e-01f,
  1.59558475e-01f, 1.21135719e-01f, 1.86954945e-01f, 3.24070781e-01f, 2.14406699e-01f, -2.15654388e-01f, 6.20009899e-02f, -3.06540221e-01f, 1.40877083e-01f, 2.59263426e-01f,
  -1.97244689e-01f, 3.95111948e-01f, 2.93170333e-01f, -9.30181593e-02f, -1.32569358e-01f, -3.16644698e-01f, 4.07076702e-02f, -7.36096129e-02f, -3.26748997e-01f, -5.26998699e-01f,
  1.84616804e-01f, -3.80046755e-01f, 7.19599351e-02f, 1.81135833e-01f, -1.93048920e-03f, -1.45981601e-02f, -2.15732276e-01f, 1.95990473e-01f, -7.02290535e-02f, -6.83095828e-02f,
  2.54073083e-01f, -1.23759590e-01f, 2.03075051e-01f, -7.61849284e-02f, 9.40641202e-03f, 1.10074691e-01f, 3.12938690e-01f, -2.26915106e-02f, -3.33266735e-01f, 3.85255635e-01f,
  -1.92840308e-01f, 1.29458934e-01f, 2.63607539e-02f, -1.86773986e-01f, 2.26409823e-01f, -7.49549046e-02f, 1.32910833e-01f, 3.29795033e-02f, 2.84053564e-01f, 2.40771249e-01f,
  2.34464362e-01f, 7.58989435e-03f, 2.22654089e-01f, 3.92822847e-02f, -1.28720671e-01f, 2.77676404e-01f, -1.16311714e-01f, 2.10211247e-01f, -1.59060523e-01f, -1.64799005e-01f,
  2.18731239e-01f, -1.01643488e-01f, 3.21826502e-03f, -1.46180047e-02f, 3.50157142e-01f, -1.91254809e-01f, 4.48693261e-02f, -1.17689177e-01f, -9.93808880e-02f, 1.20372720e-01f,
  4.15845722e-01f, 2.21201554e-01f, -2.23260164e-01f, 2.37656638e-01f, -7.39943013e-02f, 2.36368123e-02f, -1.37674898e-01f, 2.82590508e-01f, -7.44925812e-02f, 2.89917644e-02f,
  1.50317699e-01f, -3.35513711e-01f, 3.38503569e-02f, -1.77545309e-01f, -1.31910726e-01f, -1.97173700e-01f, -1.05653152e-01f, -1.50235713e-01f, 1.88273102e-01f, -3.64900492e-02f,
  2.29858965e-01f, -9.91686657e-02f, -2.97620267e-01f, 1.53736055e-01f, 2.56455511e-01f, 2.74842709e-01f, 6.02525994e-02f, 1.23567477e-01f, 4.19071943e-01f, 1.67345777e-01f,
  -4.00606950e-04f, -5.97937405e-02f, 4.88718301e-02f, -9.34677199e-02f, -1.08836338e-01f, -1.67299494e-01f, -2.21739992e-01f, 4.03740466e-01f, 7.98452795e-02f, 2.15476811e-01f,
  -1.15629189e-01f, 3.14761281e-01f, -3.42763588e-02f, -3.37443054e-01f, -2.88587827e-02f, -8.02394152e-02f, 1.72846317e-01f, 2.14224622e-01f, -2.55193375e-03f, 3.25243890e-01f,
  -1.39622003e-01f, 6.78951293e-02f, 3.21863592e-02f, 4.97264825e-02f, -1.17510289e-03f, -2.42665216e-01f, 4.14998494e-02f, 1.82562381e-01f, 1.29983142e-01f, -6.31132945e-02f,
  2.73296952e-01f, -1.30580366e-01f, -3.22665602e-01f, 4.38376337e-01f, 3.18647474e-02f, -5.99128101e-03f, -3.99767384e-02f, 1.19758561e-01f, 1.59470213e-03f, -1.91737771e-01f,
  -4.37156498e-01f, 2.40427211e-01f, -3.10181439e-01f, -1.87116917e-02f, 1.78053230e-01f, 3.03083956e-01f, 3.15134317e-01f, 2.45097011e-01f, -9.59785134e-02f, 3.85421626e-02f,
  -4.25005890e-02f, -3.44450921e-01f, 2.15568747e-02f, 1.08786516e-01f, 3.10873210e-01f, -1.03578284e-01f, -9.84001309e-02f, 1.93233445e-01f, 2.35361338e-01f, 2.32405245e-01f,
  -3.09037026e-02f, 1.54561505e-01f, 1.10867852e-02f, 1.04165711e-01f, 1.32563218e-01f, -1.01438247e-01f, 1.75454050e-01f, -2.39391312e-01f, 2.49639496e-01f, -2.33290240e-01f,
  7.02253133e-02f, 1.93327203e-01f, 1.42294839e-01f, 2.47602433e-01f, 8.66206437e-02f, 3.34526226e-02f, 1.03419416e-01f, -5.99243194e-02f, -3.63555282e-01f, 2.22806603e-01f,
  -1.22046448e-01f, 4.08204868e-02f, 1.65717736e-01f, 2.04504207e-02f, -2.07023695e-01f, -5.10966890e-02f, 1.52486637e-02f, 7.07949549e-02f, -1.53047338e-01f, -7.67422467e-02f,
  1.40328258e-01f, 3.36671472e-02f, 1.44782379e-01f, 2.43690372e-01f, 3.13431054e-01f, -3.56313139e-02f, 1.07981473e-01f, 2.45708317e-01f, -1.63434073e-01f, 1.68661207e-01f,
  -1.91743746e-01f, -1.26098096e-01f, 3.28173518e-01f, -2.28656799e-01f, 3.56793553e-01f, 1.09398186e-01f, 2.54651681e-02f, 1.49599928e-02f, -1.14157379e-01f, -1.05927356e-01f,
  8.83637890e-02f, -4.40357745e-01f, -1.32233083e-01f, 1.80584088e-01f, 1.37686506e-01f, -9.14897695e-02f, -3.83839399e-01f, 7.64810666e-02f, -3.15138519e-01f, 6.60622641e-02f,
  2.12996170e-01f, -1.21429719e-01f, 1.99452583e-02f, -2.96283901e-01f, 3.33960354e-02f, 3.55441421e-01f, 9.59624052e-02f, -2.02349231e-01f, -7.13616759e-02f, 3.42116326e-01f,
  4.94344998e-03f, 3.03707272e-01f, -7.32096436e-04f, 3.83045852e-01f, 5.19663654e-02f, 4.35794070e-02f, -1.50173917e-01f, -9.76728424e-02f, 3.38596672e-01f, 5.92943728e-01f,
  1.70082256e-01f, -1.09324545e-01f, -4.60657990e-03f, -2.44552702e-01f, -1.86111793e-01f, 2.95557827e-01f, 5.90638407e-02f, 2.62510538e-01f, -1.74169838e-01f, 2.10853040e-01f,
  6.07310720e-02f, 3.10423523e-01f, 9.76770185e-04f, 8.10018852e-02f, 2.32434407e-01f, 3.40326093e-02f, 1.32694757e-02f, 8.10099170e-02f, -2.62712240e-01f, -2.13318408e-01f,
  4.11212415e-01f, -1.37755439e-01f, 2.98609555e-01f, 1.95938218e-02f, 4.40927595e-02f, -1.58874854e-01f, 2.77110040e-01f, 2.60887802e-01f, -4.40525357e-03f, 1.88594103e-01f,
  4.64679837e-01f, -2.41996020e-01f, -2.29313448e-01f, 5.12378216e-02f, -1.93961009e-01f, 3.80852334e-02f, -1.21242054e-01f, -1.67093024e-01f, -3.54130179e-01f, -1.34797320e-01f,
  1.34292066e-01f, -1.20235115e-01f, -2.68108517e-01f, 1.34238079e-01f, 4.00846392e-01f, 1.28006235e-01f, -1.21625587e-01f, 5.47128431e-02f, 1.34329215e-01f, -3.87091368e-01f,
  -6.56541856e-03f, 1.50658572e-02f, 1.42564476e-01f, -1.37962634e-03f, -3.80417407e-02f, 2.68431157e-01f, -3.68613116e-02f, 4.18894857e-01f, 1.42941043e-01f, -9.86359492e-02f,
  2.57234693e-01f, -3.36985916e-01f, -1.78170264e-01f, -1.66642040e-01f, 2.34339207e-01f, 1.39320925e-01f, 2.69191474e-01f, 3.23980123e-01f, 1.84876308e-01f, -7.93470964e-02f,
  3.10069472e-02f, 3.05962320e-02f, 3.39849517e-02f, -4.93274704e-02f, 3.38558286e-01f, -6.11817688e-02f, 5.75817339e-02f, 3.42367738e-01f, 1.57761902e-01f, 1.76768392e-01f,
  1.89766139e-01f, 2.37682953e-01f, 2.27405980e-01f, -1.47164911e-01f, 8.96592960e-02f, -9.21515375e-02f, 1.23620622e-01f, 1.40178397e-01f, -1.09995984e-01f, -7.77953714e-02f,
  4.38294679e-01f, -1.74322993e-01f, 2.76521266e-01f, -1.54097319e-01f, 3.86348903e-01f, 1.98637441e-01f, 1.41192988e-01f, -4.02158350e-01f, -2.33320221e-02f, -3.43792945e-01f,
  -5.98162003e-02f, 1.02498107e-01f, -1.14542298e-01f, 2.66898155e-01f, -2.54837990e-01f, -1.13845639e-01f, 6.96225383e-04f, 1.08062401e-01f, 8.18414092e-02f, -2.78242864e-02f,
  -2.97355413e-01f, -1.10261813e-01f, 1.54025540e-01f, 2.75587887e-01f, 2.89086133e-01f, -1.85623437e-01f, -9.66574326e-02f, 2.57471651e-01f, 1.45127287e-03f, 2.19194621e-01f,
  -4.74019684e-02f, 4.08728749e-01f, 5.09835146e-02f, 3.01424991e-02f, -1.89522147e-01f, -1.56390190e-01f, -3.63211408e-02f, 1.63046002e-01f, -2.62883771e-02f, -1.33751795e-01f,
  2.17845023e-01f, -1.86691806e-01f, -2.05810405e-02f, 3.83719921e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.68190032e-01f, 2.15282694e-01f, 2.40988538e-01f, -8.63910168e-02f, 1.69388726e-01f, 1.03793293e-01f, 1.30006120e-01f, 6.21006452e-02f, 7.80523047e-02f, 2.78666049e-01f,
  2.60937691e-01f, 3.83196026e-02f, 1.84393331e-01f, 3.02046686e-01f, 6.30288646e-02f, 1.46090463e-01f, 2.44988605e-01f, -5.29342368e-02f, 9.37992632e-02f, 5.95930256e-02f,
  1.26921788e-01f, 4.32935394e-02f, -3.79708670e-02f, 1.81315973e-01f, 1.50752023e-01f, 1.71554714e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  6.65572006e-03f, -2.02028051e-01f, -6.42590150e-02f, -2.97929019e-01f, -2.10773095e-01f, 6.78456351e-02f, 1.12318009e-01f, 7.20004216e-02f, 2.12636620e-01f, 2.19890885e-02f,
  -2.22339705e-01f, -3.26731712e-01f, 1.77386031e-02f, 1.43461481e-01f, -1.00827618e-02f, -2.10578293e-01f, -4.85767014e-02f, -1.47171676e-01f, -2.49896348e-01f, -1.22479089e-01f,
  -7.72890747e-02f, -1.53957665e-01f, 1.65136203e-01f, -2.58684963e-01f, -3.46105583e-02f, 1.80021390e-01f, 2.05288470e-01f, -1.97789460e-01f, -4.60611247e-02f, -1.39294654e-01f,
  -9.31990147e-02f, -8.02380741e-02f, -3.62399709e-03f, -7.41947768e-03f, -2.74259925e-01f, -1.31677315e-01f, 2.46889204e-01f, 1.78247407e-01f, 1.96023509e-01f, -5.91889061e-02f,
  2.60743592e-02f, 2.25349784e-01f, -4.46285009e-01f, -1.61702827e-01f, -2.87413955e-01f, -8.09127986e-02f, -2.94705108e-02f, 6.78646043e-02f, -2.18406022e-01f, -2.67560095e-01f,
  2.56855160e-01f, -2.85282761e-01f, -4.27894562e-01f, -1.17466729e-02f, 3.65352184e-02f, 3.12890083e-01f, 1.68040976e-01f, -3.41997738e-03f, -4.37319577e-02f, 2.76307195e-01f,
  6.22061752e-02f, -4.90978003e-01f, 5.74286394e-02f, -5.01408279e-01f, -2.42944248e-03f, -5.21207750e-02f, 3.80117558e-02f, -2.36450315e-01f, -8.28655735e-02f, 2.41019338e-01f,
  -3.16334032e-02f, 4.91177551e-02f, -4.49063420e-01f, -1.70467824e-01f, 1.68764114e-01f, 2.88356930e-01f, 3.43016773e-01f, -3.61956626e-01f, 1.09959491e-01f, -1.62528425e-01f,
  -3.01779687e-01f, 2.33176559e-01f, 1.87324122e-01f, -4.09699440e-01f, 1.68254033e-01f, 2.70764641e-02f, 5.85960923e-03f, 1.21067978e-01f, -5.10638431e-02f, -2.60312464e-02f,
  -3.45285493e-03f, 2.55385906e-01f, -2.34685674e-01f, -1.50949970e-01f, -1.05792113e-01f, -2.26066783e-02f, 1.83649644e-01f, -1.53452724e-01f, -2.05172643e-01f, -3.03819656e-01f,
  -1.22393988e-01f, -1.63296118e-01f, 2.65109122e-01f, -7.45238811e-02f, -2.73366272e-01f, 4.77074981e-02f, -3.45139205e-01f, 2.22446695e-01f, -2.28576615e-01f, -3.51829231e-01f,
  5.59380911e-02f, -1.99932396e-01f, -1.06076352e-01f, 1.08792827e-01f, 1.29061952e-01f, 1.83746099e-01f, 3.02563220e-01f, 2.57084250e-01f, -1.16207257e-01f, 3.19374502e-02f,
  -1.18416868e-01f, -1.78615507e-02f, -3.07949036e-01f, 1.59422681e-01f, 2.20863000e-01f, 2.13300027e-02f, -4.38647211e-01f, -1.10107586e-01f, -1.37945339e-02f, 8.93198401e-02f,
  9.46179405e-02f, 2.55068719e-01f, -2.51976371e-01f, -9.82581526e-02f, -2.86850967e-02f, -1.05555691e-01f, -1.44301325e-01f, 5.16463853e-02f, -3.36618423e-01f, 4.33522426e-02f,
  4.87412810e-02f, 1.24629021e-01f, 1.62235141e-01f, 8.06488246e-02f, 1.63034856e-01f, 7.39925057e-02f, 1.44692212e-01f, -1.24162018e-01f, 8.92983377e-02f, 5.68499207e-01f,
  -2.90694177e-01f, 2.41419137e-01f, -1.50012717e-01f, -3.47564459e-01f, 3.65143687e-01f, -3.73351835e-02f, -1.38515785e-01f, -9.24191400e-02f, 4.09682184e-01f, 2.03811496e-01f,
  -1.09014638e-01f, 1.84577256e-01f, 3.51470768e-01f, -1.73165709e-01f, -3.60946544e-02f, -3.74629274e-02f, 2.15615369e-02f, -4.16112751e-01f, -2.54893273e-01f, -1.98806867e-01f,
  -7.51264840e-02f, -2.54518092e-01f, 5.20940721e-02f, 2.29897574e-01f, 3.69312257e-01f, 8.12466592e-02f, -1.99226260e-01f, 1.18089035e-01f, 4.17233966e-02f, -5.90121448e-01f,
  1.95762917e-01f, -6.83721453e-02f, 4.93304543e-02f, 3.86987954e-01f, -3.22070181e-01f, 7.41563812e-02f, 2.77160376e-01f, -3.90497856e-02f, -1.11301966e-01f, -3.61721843e-01f,
  2.49181464e-01f, -5.26136696e-01f, 1.89641446e-01f, 3.17370296e-01f, -2.51541942e-01f, -4.32461917e-01f, -1.01055223e-02f, -1.64734587e-01f, -1.50223792e-01f, -1.55088022e-01f,
  -2.41076318e-03f, 7.82336146e-02f, -8.55828077e-03f, 1.33066073e-01f, 1.05335146e-01f, 8.38788971e-02f, 1.41674474e-01f, -1.39111942e-02f, 8.03215727e-02f, -6.65836502e-03f,
  1.55347988e-01f, -2.86326408e-01f, 2.67524067e-02f, 3.52310717e-01f, -7.13215172e-02f, -5.31004608e-01f, 4.16368425e-01f, -3.12405109e-01f, -2.38497794e-01f, -4.22354966e-01f,
  3.57739747e-01f, 3.12314540e-01f, 2.09551200e-01f, -2.37203822e-01f, 1.79289967e-01f, 4.53889191e-01f, 2.11931586e-01f, -6.68219402e-02f, 3.74205559e-01f, 8.15229937e-02f,
  -2.79614896e-01f, -6.59899116e-02f, 2.54052728e-01f, 2.63029546e-01f, -4.77419555e-01f, -3.41801435e-01f, -3.08179349e-01f, 1.55823395e-01f, 2.01363355e-01f, -6.47069961e-02f,
  -5.41767359e-01f, -4.21604998e-02f, -7.14715958e-01f, -7.52754092e-01f, -2.61294425e-01f, -3.88706744e-01f, -5.42891502e-01f, -8.49905312e-02f, 7.54590407e-02f, 1.43009454e-01f,
  3.18818212e-01f, -1.35037407e-01f, -1.25792503e-01f, 8.13640654e-02f, -1.45868108e-01f, -1.31118968e-01f, -1.71786144e-01f, -1.69103220e-01f, 1.71091586e-01f, 3.61964732e-01f,
  1.62319928e-01f, 1.29836559e-01f, -1.12493351e-01f, 3.67318988e-01f, -2.85491534e-03f, 3.48295093e-01f, 5.63442111e-02f, -1.39182895e-01f, -1.49196506e-01f, -4.49737102e-01f,
  -2.21831858e-01f, 2.69800629e-02f, -7.64625296e-02f, 8.61024857e-02f, 1.33336157e-01f, 4.17823017e-01f, 2.52471149e-01f, -4.39504057e-01f, -7.89217725e-02f, 2.28548586e-01f,
  9.34470817e-02f, -1.15779124e-01f, -1.48937032e-01f, -1.89575583e-01f, 4.09689173e-02f, -9.55899432e-02f, 6.93705007e-02f, 2.33761728e-01f, -3.76952708e-01f, -1.25321418e-01f,
  3.55669856e-01f, 1.46338388e-01f, -3.59932333e-01f, 2.27628425e-01f, 1.55819487e-02f, 7.00565800e-02f, 2.02605441e-01f, -2.03817263e-01f, -1.07803799e-01f, -2.03862786e-01f,
  -5.27954288e-02f, -3.45887095e-02f, -4.04364020e-02f, -5.21378577e-01f, 1.86671168e-01f, -2.90806741e-01f, -1.73976477e-02f, 1.19846381e-01f, 2.23520491e-02f, -2.15254650e-01f,
  -9.96547490e-02f, -2.06225410e-01f, 2.11037844e-01f, 2.06812173e-02f, 3.71061675e-02f, 1.16092294e-01f, -4.27409530e-01f, -1.74599737e-01f, 2.44914010e-01f, 1.87304333e-01f,
  1.70720130e-01f, 2.23832995e-01f, 2.41609588e-01f, 1.45682588e-01f, 1.02543183e-01f, 1.04736455e-01f, 3.84726725e-03f, -7.50398263e-02f, 4.31770474e-01f, -1.54087886e-01f,
  1.36315078e-01f, -1.08835027e-01f, 8.22089389e-02f, 2.72801936e-01f, 1.70797586e-01f, 3.39924097e-02f, 1.96563020e-01f, -1.92846283e-02f, 1.23453416e-01f, 1.81251287e-01f,
  1.95883885e-01f, -1.11969910e-03f, -6.47154450e-02f, -1.75709024e-01f, -1.95734918e-01f, -3.34883004e-01f, -1.22556105e-01f, -3.07805408e-02f, -2.03722537e-01f, 2.77826041e-01f,
  -1.32518396e-01f, 1.62559122e-01f, -1.00161240e-01f, 2.59271830e-01f, 3.54869664e-01f, 4.19095963e-01f, 1.62058532e-01f, 1.05993330e-01f, 8.70142952e-02f, -4.29546267e-01f,
  1.52254790e-01f, 7.04852194e-02f, 1.41527191e-01f, 5.25673479e-03f, 2.25079820e-01f, -3.76170248e-01f, -1.93291008e-01f, -1.78800777e-01f, 2.52746224e-01f, 1.55948326e-01f,
  1.67860333e-02f, 3.45892042e-01f, -4.86979693e-01f, 4.85213585e-02f, 4.43998605e-01f, -2.70533562e-01f, -2.60761201e-01f, 7.41282180e-02f, -4.15111959e-01f, -1.02418326e-02f,
  1.45258754e-01f, -2.04549938e-01f, 1.30310342e-01f, -2.32156307e-01f, 2.02372089e-01f, -3.19910049e-01f, 4.67389114e-02f, -7.92652294e-02f, 4.54393700e-02f, -2.56229425e-03f,
  -3.46483082e-01f, 5.68791628e-02f, -4.88063209e-02f, 2.11557403e-01f, 1.78484038e-01f, -4.98436168e-02f, 1.64074272e-01f, 2.13769495e-01f, -1.88338146e-01f, -1.38401851e-01f,
  1.56599700e-01f, 1.61448777e-01f, 2.74207354e-01f, 1.04188621e-01f, -3.60629261e-02f, -2.70053148e-01f, 1.03323972e-02f, 1.16358809e-02f, -8.46192520e-03f, 2.57597715e-01f,
  2.96957165e-01f, 8.19982588e-02f, -5.36004901e-02f, 4.29987371e-01f, -3.07781965e-01f, 3.97738636e-01f, 3.09645861e-01f, 8.05187523e-02f, -9.46521685e-02f, -1.99715108e-01f,
  -3.51671338e-01f, 2.87970245e-01f, -4.09993976e-01f, -4.73437309e-01f, -7.06547976e-01f, -1.54892504e-01f, 3.14739436e-01f, -2.19579190e-01f, 2.45570496e-01f, 9.11594927e-02f,
  1.03039168e-01f, 2.64191449e-01f, 3.17784816e-01f, -1.16973311e-01f, 1.97824072e-02f, 9.33421776e-02f, 1.18759632e-01f, 2.40607530e-01f, 1.14434943e-01f, -9.05399472e-02f,
  -1.69161007e-01f, -5.38758695e-01f, -2.01038584e-01f, -1.32116050e-01f, -2.93130398e-01f, 1.14451401e-01f, -1.28206508e-02f, -9.86727104e-02f, -9.00460556e-02f, 1.84073031e-01f,
  1.76546589e-01f, 1.23037659e-02f, -8.82724747e-02f, -2.85227954e-01f, 2.73424894e-01f, -1.60302848e-01f, -1.74233809e-01f, 7.10687265e-02f, -1.28674373e-01f, 5.76553158e-02f,
  -2.17293352e-01f, 6.07693121e-02f, 1.34998681e-02f, -9.26213861e-02f, -6.86737895e-02f, 2.02766761e-01f, -1.51739389e-01f, -1.44428372e-01f, -2.02921778e-01f, -3.34974885e-01f,
  2.45161623e-01f, -2.19173610e-01f, 1.10175334e-01f, 5.24793342e-02f, -1.20976679e-01f, -1.14087433e-01f, 9.88364145e-02f, -2.81059682e-01f, -2.20763579e-01f, 1.85473591e-01f,
  2.45703742e-01f, -1.86208978e-01f, -2.91763544e-01f, 4.91110645e-02f, -2.02368617e-01f, 1.82977930e-01f, -4.84141111e-02f, -4.78871763e-02f, 2.69429266e-01f, -2.11679284e-02f,
  -9.75967646e-02f, -1.08957201e-01f, -4.46418971e-01f, 1.35814711e-01f, -3.69140446e-01f, 1.02900594e-01f, 1.15267761e-01f, -2.93947607e-01f, -1.43026292e-01f, 3.60154696e-02f,
  -3.95336211e-01f, -2.43170515e-01f, -3.61107029e-02f, -2.81981900e-02f, -6.73757434e-01f, -1.54938385e-01f, -2.32284054e-01f, 1.37316719e-01f, -1.40465602e-01f, 2.85643429e-01f,
  -5.30293286e-01f, 2.64607549e-01f, 2.07051352e-01f, 1.11974068e-01f, 1.15095310e-01f, 1.20161153e-01f, -4.83761840e-02f, -2.31349200e-01f, 3.65722366e-02f, -2.97775358e-01f,
  -1.48297101e-01f, 2.20594749e-01f, 7.37902820e-02f, -2.53402978e-01f, -2.55017161e-01f, -1.28861919e-01f, -2.64203310e-01f, 1.73088580e-01f, 1.08783826e-01f, -1.12413362e-01f,
  -3.24852228e-01f, 3.16181839e-01f, -1.94425941e-01f, -1.00267284e-01f, 3.71939927e-01f, 3.34845334e-02f, -1.81117937e-01f, 4.72157985e-01f, -3.34355921e-01f, 2.39576157e-02f,
  -2.07569972e-01f, -2.06701532e-01f, 1.36531070e-01f, -2.05811515e-01f, -4.68218373e-03f, 2.56763130e-01f, -2.95350283e-01f, 1.66497171e-01f, 3.44980031e-01f, -2.02930078e-01f,
  -4.66801167e-01f, 3.13851893e-01f, -3.04929286e-01f, -2.31187865e-01f, 2.37090630e-03f, 1.82572901e-01f, 2.39204332e-01f, -2.57850289e-01f, 3.18310022e-01f, -1.80179715e-01f,
  -9.99913439e-02f, 1.53880998e-01f, 2.78089225e-01f, -5.44684887e-01f, -3.73710692e-01f, 1.81328639e-01f, -1.76251784e-01f, -1.74061209e-01f, -4.57491368e-01f, 2.79015273e-01f,
  -2.04184175e-01f, -3.39107275e-01f, 1.56660661e-01f, -5.71819954e-02f, -4.29894000e-01f, -3.13697755e-02f, -4.42494377e-02f, 1.03354976e-01f, -3.46736610e-01f, -8.89241472e-02f,
  2.36620009e-01f, 1.91197366e-01f, 2.67774284e-01f, -3.34635610e-03f, 3.13717633e-01f, -5.01768142e-02f, 2.21757218e-01f, 2.59197980e-01f, -2.85897613e-01f, -5.30572981e-03f,
  6.29937202e-02f, -3.28233577e-02f, -7.75917619e-02f, -2.38978922e-01f, -3.21101546e-01f, 4.33245627e-03f, -3.26711774e-01f, 3.74954730e-01f, 2.56159812e-01f, 1.32102534e-01f,
  2.73550928e-01f, -9.81948376e-02f, 5.26163653e-02f, -2.10628524e-01f, 3.33828896e-01f, -3.97204608e-01f, 3.32305461e-01f, -9.70556214e-02f, -4.28125143e-01f, -1.00146681e-01f,
  -1.62519738e-01f, 9.96280983e-02f, 9.28266123e-02f, 1.74466774e-01f, 2.16095567e-01f, -4.13022459e-01f, -2.05722511e-01f, -5.27602375e-01f, 2.19465747e-01f, -4.64981169e-01f,
  -9.68568102e-02f, 2.31369138e-01f, -6.32436424e-02f, -1.08289361e-01f, -2.62851268e-01f, -4.49925005e-01f, -7.03716055e-02f, 1.02039687e-01f, 2.00903445e-01f, 1.56198470e-02f,
  2.24926800e-01f, -1.66819114e-02f, -6.93938613e-01f, -4.55041915e-01f, 1.92755967e-01f, -3.98674875e-01f, -1.53827429e-01f, 8.22811499e-02f, 5.19430675e-02f, 1.63224787e-01f,
  4.88679074e-02f, -2.29191825e-01f, -2.67425627e-01f, -3.82751529e-03f, -2.66022910e-03f, 8.32661428e-03f, 9.38920379e-02f, -3.79979193e-01f, 1.83564108e-02f, -3.68333042e-01f,
  -1.30952686e-01f, 1.29042760e-01f, -1.31950736e-01f, 1.26493558e-01f, -6.22247905e-02f, 3.81553806e-02f, -2.43999973e-01f, -7.88881555e-02f, -3.61433208e-01f, 1.98060483e-01f,
  1.60023406e-01f, -1.87416524e-01f, -4.07247394e-01f, 2.43906274e-01f, -2.74920255e-01f, -1.32536337e-01f, -2.80214828e-02f, 2.30130553e-01f, -8.47135782e-02f, -1.57130912e-01f,
  1.43031985e-01f, -1.76113039e-01f, 1.16630895e-02f, -2.38395974e-01f, -1.22902011e-02f, -2.57425576e-01f, 1.66860655e-01f, -2.74679810e-02f, -5.01178443e-01f, -1.70689866e-01f,
  1.11253567e-01f, 1.92384183e-01f, -4.53455955e-01f, 2.36503497e-01f, 2.46483475e-01f, -3.08153480e-01f, -6.32974207e-02f, -2.29036689e-01f, -1.14162430e-01f, 2.52079785e-01f,
  -1.29953280e-01f, -3.57586294e-01f, 3.16006064e-01f, -2.92432874e-01f, -3.05863351e-01f, -4.64297652e-01f, 3.06214839e-01f, 1.93059310e-01f, -8.32289532e-02f, -5.27761459e-01f,
  -1.30119219e-01f, -4.65365052e-01f, 2.45645523e-01f, -3.58973026e-01f, 1.04351021e-01f, 2.01468498e-01f, -2.98398346e-01f, -2.10802093e-01f, 5.62446192e-02f, 9.76319462e-02f,
  8.86698812e-02f, 1.27173349e-01f, 1.48631439e-01f, -4.37036306e-02f, -2.21546859e-01f, -9.17836502e-02f, 6.86842427e-02f, 7.94006139e-02f, -1.67298883e-01f, 1.85943887e-01f,
  -2.05821209e-02f, 6.77688569e-02f, -5.69578260e-02f, -5.31939209e-01f, -2.36182541e-01f, 3.64128530e-01f, 1.29578426e-01f, 1.44747555e-01f, -2.41058409e-01f, 1.99556112e-01f,
  2.44834259e-01f, 1.04819953e-01f, -4.39552628e-02f, 4.12397198e-02f, -3.10328454e-02f, -1.20657958e-01f, 2.68601418e-01f, -1.40584663e-01f, -2.67404407e-01f, 3.64866406e-01f,
  2.52601385e-01f, -3.51804584e-01f, 1.43944561e-01f, 5.53561807e-01f, -2.07197353e-01f, -7.07999766e-02f, 2.87074763e-02f, 1.33201301e-01f, 1.73499793e-01f, -2.07392201e-01f,
  -3.45435500e-01f, 2.89269835e-01f, -1.32984579e-01f, -1.30192861e-01f, -5.23134887e-01f, 1.60133347e-01f, 1.82464570e-01f, -1.91338539e-01f, -7.42193937e-01f, -9.93479565e-02f,
  -1.76457047e-01f, -3.09917718e-01f, -2.94865876e-01f, -4.77028996e-01f, -4.25332367e-01f, 9.56447572e-02f, 1.78163692e-01f, 1.58926681e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.83395535e-01f, -9.75002050e-02f, 1.00345135e-01f, -1.02423832e-01f, -1.83738247e-02f, 8.18969682e-04f, -1.61809158e-02f, 4.23456393e-02f, 5.78483716e-02f, -5.11810444e-02f,
  7.27953315e-02f, 7.53369778e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    