/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.65142083e-01f, 4.64976206e-02f, -2.02792078e-01f, -1.45674199e-01f, -1.39503792e-01f, 4.59651314e-02f, 1.69340134e-01f, -2.40571946e-01f, -1.44835427e-01f, 1.14417963e-01f,
  -8.76989514e-02f, -1.14298746e-01f, 1.59931645e-01f, -1.17715277e-01f, -1.01633817e-02f, 9.03390273e-02f, -9.81169045e-02f, -1.11308530e-01f, -2.76813526e-02f, -1.55988500e-01f,
  -5.06520383e-02f, -4.06939015e-02f, -3.36668827e-02f, -7.57132843e-02f, -1.07987270e-01f, -1.23760514e-01f, 3.30837369e-02f, 5.58155254e-02f, -1.16138317e-01f, -9.82369296e-03f,
  5.81101030e-02f, -8.58240351e-02f, -9.94105712e-02f, -8.37087855e-02f, -1.27024278e-02f, -9.97393299e-03f, 6.04776554e-02f, 1.27852604e-01f, -3.08750253e-02f, 2.49578673e-02f,
  5.63965291e-02f, 7.25054219e-02f, -1.08426046e-02f, -3.08562499e-02f, 5.16186329e-03f, -4.67642881e-02f, -3.54164504e-02f, 2.36394592e-02f, 2.14570924e-03f, -2.67759934e-02f,
  -4.76570241e-02f, -7.58194551e-02f, -2.03156471e-02f, 1.03542015e-01f, -3.12929042e-02f, 2.25920812e-03f, -2.45597083e-02f, 3.89359705e-02f, 1.39629925e-02f, -5.66997714e-02f,
  5.00429273e-02f, 3.70444916e-02f, 2.08252426e-02f, 6.50046468e-02f, 7.58408830e-02f, -4.43015993e-02f, 2.63291094e-02f, 2.84392219e-02f, 4.10487205e-02f, 5.98768762e-04f,
  -6.64726868e-02f, -9.24490020e-03f, 2.49534026e-02f, -6.19959179e-03f, 6.50187880e-02f, 1.93574522e-02f, 1.24251740e-02f, -6.38623014e-02f, 2.74347551e-02f, -3.94845232e-02f,
  1.74163729e-02f, -8.86852853e-03f, 3.41780786e-03f, 9.06164106e-03f, 1.38786184e-02f, -5.21857962e-02f, -8.09680820e-02f, 5.92782022e-03f, -8.26003924e-02f, 3.37746739e-03f,
  1.13745898e-01f, -1.96238421e-02f, 2.84460858e-02f, -6.21027173e-03f, 3.03417873e-02f, -1.75373089e-02f, 1.10467486e-01f, -7.81887174e-02f, -8.07566475e-03f, 3.01251542e-02f,
  -6.53951541e-02f, -3.19499522e-02f, 1.47774341e-02f, 2.00177431e-02f, 4.31032591e-02f, -5.31512983e-02f, 5.49733005e-02f, -4.51104641e-02f, -4.43465449e-02f, 2.13640882e-03f,
  -2.06382517e-02f, -3.07378620e-02f, 2.19363589e-02f, -3.63544263e-02f, -2.07781512e-02f, 4.18303646e-02f, 8.42562318e-03f, -2.42634229e-02f, 7.86660016e-02f, 4.17411812e-02f,
  5.07047288e-02f, -3.96352336e-02f, 3.53819668e-01f, 3.52160335e-02f, 1.45363852e-01f, -3.05471290e-02f, 2.01979931e-02f, -3.15618366e-02f, 1.31523520e-01f, -2.16507599e-01f,
  -7.67405704e-02f, -4.41930406e-02f, -5.40514700e-02f, 9.13289655e-03f, -2.73203682e-02f, -1.63457319e-01f, -5.64076900e-02f, 5.21189086e-02f, 1.02786496e-01f, -2.61713769e-02f,
  9.93179977e-02f, -9.26758721e-02f, 9.55653787e-02f, 9.20784287e-03f, 1.00240514e-01f, 1.51874730e-02f, -1.17460176e-01f, 1.38019904e-01f, 1.36402547e-01f, 1.10728033e-01f,
  1.00766674e-01f, 8.49077702e-02f, 7.99693093e-02f, 2.53007300e-02f, 3.80551964e-02f, -8.80992971e-03f, 3.78787033e-02f, 8.55155662e-02f, 2.77944524e-02f, 6.38353173e-03f,
  5.37919216e-02f, 5.50793186e-02f, -1.38855875e-02f, -1.21244127e-02f, 7.56542385e-02f, 3.82777639e-02f, 5.17644659e-02f, 3.21415439e-02f, 4.62857494e-03f, 4.21464778e-02f,
  1.19564787e-01f, 1.08899035e-01f, 2.45176591e-02f, 3.73293199e-02f, 2.67076921e-02f, 2.78390907e-02f, -1.32526020e-02f, 6.62114322e-02f, 1.06828501e-02f, -1.83731932e-02f,
  -1.88156143e-02f, -4.34320308e-02f, 3.44719291e-02f, 3.81683558e-02f, 2.31934246e-02f, -3.18017206e-03f, -1.55500975e-02f, -7.24932030e-02f, 4.53134105e-02f, -1.55908661e-02f,
  -9.63169709e-03f, 2.07826328e-02f, 6.77957460e-02f, 6.42611831e-02f, -7.71047994e-02f, -4.17447835e-03f, -2.87897624e-02f, -1.36805624e-02f, 3.28779183e-02f, 7.08019882e-02f,
  -3.09206564e-02f, 1.43754864e-02f, -5.78861963e-03f, 2.88493372e-02f, -2.72050011e-03f, 6.61819577e-02f, 2.32901052e-02f, 2.87863445e-02f, 4.17418871e-03f, -8.37927312e-02f,
  -1.42818943e-01f, -1.86553895e-01f, -6.75468594e-02f, 7.45841563e-02f, -2.29945164e-02f, -1.03496708e-01f, -2.24525444e-02f, 1.99454594e-02f, -6.76791370e-02f, -3.96493785e-02f,
  -5.40014356e-02f, -1.96306761e-02f, -2.52172016e-02f, 4.68320027e-02f, 3.13217305e-02f, -6.85971156e-02f, -2.28627827e-02f, -6.76077604e-02f, -7.67519325e-02f, 6.02011196e-03f,
  -6.76942095e-02f, -6.22247122e-02f, 1.36802485e-02f, 3.08475383e-02f, -8.09436291e-02f, 2.55285576e-02f, 3.81228924e-02f, 2.89684478e-02f, 1.70311034e-02f, 2.84467340e-02f,
  -2.52847344e-01f, 5.23907989e-02f, -1.06115140e-01f, -1.48758441e-01f, -2.51364727e-02f, -5.08021191e-02f, -4.42281738e-02f, -8.89616311e-02f, 7.14277551e-02f, 6.63767532e-02f,
  -1.26556203e-01f, -1.43983923e-02f, 6.85860217e-02f, -1.30526647e-01f, 4.05505858e-02f, 1.45893365e-01f, 1.46695934e-02f, 1.88394226e-02f, 5.90513535e-02f, -2.72629820e-02f,
  1.79185364e-02f, -1.14952028e-01f, -4.78106514e-02f, -6.77698329e-02f, -8.91605765e-02f, -1.22857861e-01f, -3.90808135e-02f, -4.76994105e-02f, -9.62560549e-02f, -4.83581908e-02f,
  9.89843253e-03f, 2.80350093e-02f, -8.82449821e-02f, 1.18694447e-01f, -3.14926244e-02f, -5.91543987e-02f, -1.24965294e-03f, -6.99627399e-03f, -1.36456788e-02f, 5.14277928e-02f,
  4.24183235e-02f, -2.12116260e-02f, 2.42302492e-02f, -2.52724849e-02f, -5.25865369e-02f, -1.97423249e-02f, -6.86072186e-02f, -7.63687640e-02f, -7.65508935e-02f, -2.18157358e-02f,
  3.56097743e-02f, 7.00679328e-03f, -2.16422621e-02f, 4.89450730e-02f, -1.01090834e-01f, -8.51563811e-02f, 5.17649157e-03f, -8.73907432e-02f, 1.55617772e-02f, 4.26491238e-02f,
  7.44747370e-02f, -7.15282410e-02f, 3.81797515e-02f, -4.07266878e-02f, -6.96990490e-02f, -2.92261112e-02f, -3.00229192e-02f, -6.64314106e-02f, -4.66098487e-02f, -7.60983601e-02f,
  -1.42403161e-02f, -4.18201126e-02f, -3.50020975e-02f, 6.15332536e-02f, 5.27076833e-02f, -3.82318795e-02f, -5.90306148e-02f, 3.48461010e-02f, -4.03164513e-02f, 1.46760810e-02f,
  -4.36093621e-02f, 4.33973484e-02f, 2.62749959e-02f, 8.10017884e-02f, -7.81112015e-02f, -7.79527128e-02f, 7.41854757e-02f, -1.25370435e-02f, 3.66414823e-02f, 1.59684625e-02f,
  4.72345762e-02f, 1.61324948e-01f, 7.08174184e-02f, 3.81533876e-02f, -1.04607774e-04f, 4.46123108e-02f, 5.10791205e-02f, -1.29386818e-03f, -2.09440403e-02f, -5.28616086e-02f,
  1.10172987e-01f, -9.27032456e-02f, -5.17472439e-03f, -6.65059835e-02f, -3.43081132e-02f, -7.35879512e-05f, -1.18598733e-02f, 1.71907414e-02f, -1.24756191e-02f, -1.43240774e-02f,
  -6.26227707e-02f, 8.04294795e-02f, 7.54131153e-02f, 2.86337938e-02f, 3.25003552e-04f, 5.76058105e-02f, -7.55273411e-03f, 3.67963910e-02f, 5.10570295e-02f, 1.22433910e-02f,
  -7.48084113e-02f, 1.98761880e-01f, 2.01189518e-01f, -8.67541358e-02f, -2.13025324e-02f, 6.70999587e-02f, 1.97776914e-01f, -7.78211206e-02f, 5.99469058e-02f, 1.25558704e-01f,
  -1.21743488e-03f, 2.06387028e-01f, 6.29813671e-02f, 4.16715862e-03f, -2.40637615e-01f, 3.80603634e-02f, 8.06641206e-03f, 1.05801240e-01f, 6.99741617e-02f, 9.83999297e-03f,
  -1.70141216e-02f, -8.52660183e-03f, -1.34240137e-02f, -2.68033035e-02f, 6.20089136e-02f, -1.05459969e-02f, -2.06947058e-01f, 7.18966872e-02f, -7.30088651e-02f, 6.90110959e-03f,
  -3.35524194e-02f, 6.28197193e-02f, 9.74486619e-02f, 8.04885402e-02f, -8.51107296e-03f, -7.18021244e-02f, 4.47198376e-02f, 3.19340602e-02f, 1.31089916e-03f, 1.29547250e-02f,
  1.70736406e-02f, 3.76838706e-02f, 7.19646662e-02f, -6.07944354e-02f, 1.06332675e-02f, -3.58152688e-02f, -1.41863106e-02f, -7.90840201e-03f, 8.95008817e-03f, 4.95691895e-02f,
  5.49818203e-02f, 1.46515910e-02f, 5.40608279e-02f, -2.59633251e-02f, 1.22231580e-02f, -1.60651281e-02f, -1.62229352e-02f, 6.31586611e-02f, -3.97416949e-03f, -2.87252013e-02f,
  -5.56479022e-02f, 5.06369062e-02f, -2.50904914e-02f, 1.77797675e-02f, -3.27188782e-02f, -3.88256274e-02f, 3.01142875e-02f, 1.17030907e-02f, 4.75558788e-02f, -6.03541955e-02f,
  -4.74769995e-02f, 1.21865449e-02f, -1.21397097e-02f, 2.73070112e-02f, 5.98761253e-02f, 5.42786941e-02f, -5.47459722e-02f, -6.62944512e-03f, -2.28912872e-03f, -5.69032542e-02f,
  -5.61969690e-02f, -7.76739269e-02f, 2.51873881e-02f, 1.37039637e-02f, -7.94293825e-03f, -4.26666327e-02f, -5.84989749e-02f, 2.53475625e-02f, 4.19523800e-03f, 1.86694264e-02f,
  2.33401153e-02f, 7.49642178e-02f, -3.33267078e-03f, -3.67316790e-02f, 1.58465281e-02f, 3.87845933e-02f, 1.67964548e-02f, -3.17471288e-02f, 1.41793313e-02f, -9.36868116e-02f,
  -3.62909138e-02f, -2.46234890e-02f, -6.91564754e-02f, -2.48449738e-03f, -1.14524337e-02f, -2.19401997e-02f, 4.24832106e-02f, 4.29802993e-03f, 2.11083125e-02f, -8.92286468e-03f,
  1.62786637e-02f, -3.06772739e-02f, -3.45047154e-02f, 3.44512588e-03f, 6.82471134e-03f, -4.64726612e-02f, -5.35927936e-02f, 7.14322031e-02f, -8.05469528e-02f, 2.46555153e-02f,
  -1.45876080e-01f, 2.26393759e-01f, 1.40908137e-01f, -2.18810886e-01f, -8.16313666e-04f, -1.26988724e-01f, -3.36601108e-01f, 4.49885614e-02f, -1.03472628e-01f, 1.12028353e-01f,
  -1.16498314e-01f, 4.33678403e-02f, -1.13250036e-02f, -4.11640014e-03f, -3.19871306e-01f, -6.17503896e-02f, -2.41446480e-01f, -4.00941409e-02f, -5.34452237e-02f, -6.97356388e-02f,
  -9.83358100e-02f, -1.81370378e-01f, -9.03224747e-04f, 7.06186891e-02f, 1.61379222e-02f, 6.68374151e-02f, -6.47754297e-02f, 1.14962282e-02f, 3.42478976e-02f, 1.28536969e-01f,
  8.94445479e-02f, 4.48125564e-02f, 9.12073106e-02f, 6.22939644e-03f, -4.10445370e-02f, 1.01178102e-01f, 6.40396378e-04f, 3.33337635e-02f, -2.87280884e-02f, 7.05501363e-02f,
  1.86939575e-02f, -9.69589339e-04f, 1.05531709e-02f, 3.09064928e-02f, -4.90613692e-02f, -1.77125391e-02f, -2.32926803e-03f, -2.69199461e-02f, 5.13923094e-02f, 6.03810176e-02f,
  5.85069600e-03f, 1.61205232e-02f, -2.16440242e-02f, 2.17919182e-02f, -7.10662454e-02f, 7.48391729e-03f, -4.42580655e-02f, 1.31042777e-02f, 5.36367707e-02f, -1.25439689e-02f,
  5.14934584e-02f, -8.90248641e-02f, -6.66470546e-03f, -4.95029567e-03f, 3.89389805e-02f, 3.08078397e-02f, -4.38956209e-02f, -4.24065217e-02f, 1.42109925e-02f, -2.51395851e-02f,
  5.70694869e-03f, 2.50781775e-02f, -2.86452044e-02f, 5.23262518e-03f, 7.07258657e-02f, -3.50351445e-02f, 7.07593784e-02f, 1.65109839e-02f, -1.53902518e-02f, -3.86995845e-03f,
  -9.28054377e-02f, -4.67417166e-02f, 4.84936722e-02f, -5.80590926e-02f, -4.05957922e-02f, -1.95763949e-02f, -2.85533611e-02f, 6.18071221e-02f, 1.06425267e-02f, -4.17506434e-02f,
  -5.10593951e-02f, -7.28916228e-02f, -7.73320394e-03f, 6.30206764e-02f, 4.65166941e-02f, -4.97567318e-02f, -4.37373035e-02f, -9.41117574e-03f, 1.20087685e-02f, -6.76461607e-02f,
  9.46886186e-03f, 5.24334796e-03f, -1.19699566e-02f, -1.35690449e-02f, 1.90581027e-02f, -5.53035326e-02f, -2.76659876e-02f, 6.10338226e-02f, 2.39043497e-03f, 1.99721963e-03f,
  -1.66328531e-02f, -2.92421505e-02f, 4.20247354e-02f, 2.95378901e-02f, 7.20466999e-03f, -3.45673319e-03f, -8.98466930e-02f, -5.69604859e-02f, 5.11383777e-03f, 1.48408599e-02f,
  3.23525488e-01f, 5.73090762e-02f, 1.51924819e-01f, 2.36123249e-01f, 5.86137436e-02f, -1.86353996e-01f, -1.11182518e-01f, 1.21145703e-01f, 2.92072415e-01f, -4.27875482e-02f,
  1.11683868e-01f, 3.48600596e-02f, -6.50049597e-02f, 7.65580311e-02f, 1.69841722e-01f, -3.02188229e-02f, 1.97391734e-01f, 2.51456611e-02f, 9.92351696e-02f, 6.50826767e-02f,
  8.17960799e-02f, 3.45455632e-02f, 1.24902800e-01f, -1.05598241e-01f, 8.65159482e-02f, 9.37897339e-02f, 5.61516210e-02f, -5.56735918e-02f, 4.05504517e-02f, -7.52758011e-02f,
  -2.02957615e-02f, -1.58803109e-02f, 1.00505687e-01f, -3.16766575e-02f, 2.04553232e-02f, -5.03828153e-02f, -4.66408283e-02f, 4.27986979e-02f, 8.70397612e-02f, 4.98139597e-02f,
  -6.85559809e-02f, 1.26247201e-02f, 1.30875427e-02f, 4.11677472e-02f, -2.26006377e-02f, -8.84381905e-02f, -2.09348332e-02f, 6.04483485e-02f, 4.85575683e-02f, -2.54009347e-02f,
  -3.28417532e-02f, -7.85491255e-04f, 1.15002692e-02f, 2.44456641e-02f, 9.87057537e-02f, -2.68512089e-02f, -6.82557523e-02f, -8.09130594e-02f, 5.82060441e-02f, 6.82578981e-02f,
  -6.45662844e-02f, -2.45714076e-02f, -2.82508675e-02f, -5.67304017e-03f, 1.59975654e-03f, 2.39809845e-02f, 5.17533384e-02f, 1.99659709e-02f, 6.95577338e-02f, 2.81763319e-02f,
  2.16730684e-03f, 7.74183795e-02f, 3.29438485e-02f, 4.22525443e-02f, -3.76486629e-02f, 8.73428583e-03f, -4.54960279e-02f, -1.50939003e-02f, 4.27319901e-03f, 7.96438605e-02f,
  4.69667017e-02f, -9.74594906e-04f, -3.33665567e-03f, -8.85869265e-02f, -1.56450253e-02f, -4.74756286e-02f, 3.29588503e-02f, 3.96525040e-02f, -1.27376709e-03f, -1.99452844e-02f,
  -1.21815853e-01f, -3.77344266e-02f, -2.89486740e-02f, 5.02593927e-02f, -5.22856638e-02f, 2.22145095e-02f, 8.05022866e-02f, -6.07300662e-02f, -2.44746804e-02f, -4.13305387e-02f,
  -5.69732822e-02f, -1.21880490e-02f, 1.56344865e-02f, 2.33233236e-02f, -2.28913967e-03f, -7.51746967e-02f, -3.64034367e-03f, 1.21222891e-01f, 3.27972174e-02f, 4.48572040e-02f,
  -6.89674690e-02f, -8.15296397e-02f, 7.13367909e-02f, -5.28034987e-04f, -7.64020234e-02f, 1.12791928e-02f, -4.95711118e-02f, -2.50458755e-02f, 4.07136343e-02f, 2.15429515e-02f,
  2.23489821e-01f, 6.00669235e-02f, -1.21156417e-01f, -2.71156393e-02f, 6.83005527e-02f, 2.69813817e-02f, -1.30334347e-01f, 4.24164012e-02f, -5.97428977e-02f, -6.64491439e-03f,
  2.48146635e-02f, -7.02148080e-02f, -1.22867636e-01f, -2.84828874e-03f, -2.35382751e-01f, -1.88844621e-01f, 7.02776983e-02f, 1.25968203e-01f, -1.21616505e-01f, 5.37371412e-02f,
  -1.15991056e-01f, 3.50064621e-03f, -1.57717943e-01f, 7.06475601e-02f, 1.17495127e-01f, 1.17944255e-01f, -5.86271808e-02f, -7.03695491e-02f, 7.97523037e-02f, 1.95145253e-02f,
  6.62331581e-02f, -3.38187665e-02f, -3.67614478e-02f, 3.93068530e-02f, -6.37507439e-02f, 9.15809199e-02f, -6.13847263e-02f, -1.25417933e-02f, -1.32240821e-02f, 4.10635099e-02f,
  5.17147891e-02f, 3.70426662e-02f, 3.62768695e-02f, 7.16700628e-02f, 5.35330400e-02f, 3.45687219e-03f, -2.29229797e-02f, 3.07396464e-02f, 3.12525146e-02f, 8.03255960e-02f,
  -2.71371603e-02f, 5.09045608e-02f, 7.14028999e-02f, 3.48459557e-02f, -5.19838221e-02f, -2.85640880e-02f, 2.53293701e-02f, -6.08093617e-03f, -1.04027623e-02f, -6.10837117e-02f,
  -2.32499978e-03f, -2.03632787e-02f, 1.96479317e-02f, 4.72819135e-02f, -3.86648551e-02f, -4.82424721e-02f, 3.05088540e-03f, -1.64182112e-02f, 1.09634101e-02f, -9.92515218e-03f,
  2.60129422e-02f, 6.26920015e-02f, 2.97441594e-02f, -4.46375124e-02f, 1.21709285e-02f, 3.56080686e-03f, 6.26297444e-02f, -1.85353756e-02f, 2.86832843e-02f, -4.19796258e-02f,
  -4.15935069e-02f, -6.16638139e-02f, 1.47997933e-02f, 2.38585062e-02f, -3.84361632e-02f, 3.55775058e-02f, 2.41707433e-02f, -4.21816893e-02f, -1.08214812e-02f, 6.89001158e-02f,
  -6.28182606e-04f, -3.03040482e-02f, -9.31410119e-03f, -5.91487512e-02f, 3.97891887e-02f, -3.56454030e-02f, 1.45793315e-02f, 6.66375905e-02f, -4.41219881e-02f, -7.40118548e-02f,
  6.29836991e-02f, -3.71555239e-02f, -2.51611825e-02f, -2.16542520e-02f, 2.70223971e-02f, -4.48349901e-02f, -3.84448543e-02f, -8.13024864e-02f, -8.96899179e-02f, 8.26880112e-02f,
  4.98201028e-02f, 2.08518412e-02f, 7.44592249e-02f, 1.18101174e-02f, 3.56556214e-02f, 6.19490370e-02f, 5.51407635e-02f, 1.90229081e-02f, 5.91118261e-02f, -4.76008095e-02f,
  2.36827210e-01f, 1.74881712e-01f, 3.48907560e-01f, 9.53094810e-02f, -2.00544342e-01f, 1.99282125e-01f, 2.58724064e-01f, -1.34433359e-02f, 2.16751862e-02f, -2.90222839e-02f,
  -1.09541059e-01f, 6.59848675e-02f, 8.07501152e-02f, -3.74640226e-02f, 1.16364814e-01f, 7.87010714e-02f, 1.82488769e-01f, 1.25125363e-01f, -4.55029048e-02f, 1.13180138e-01f,
  6.53676391e-02f, -6.73783496e-02f, 1.05755039e-01f, -1.29675701e-01f, 1.23353302e-01f, 4.15395685e-02f, -4.39816639e-02f, 4.91989367e-02f, -5.44673465e-02f, -2.46479223e-03f,
  -1.98110864e-02f, -7.48916669e-03f, 6.28381148e-02f, 7.11239055e-02f, 1.40174091e-01f, 6.03649952e-02f, 7.32508227e-02f, -2.36335639e-02f, 6.93119839e-02f, 5.11588901e-02f,
  1.07747339e-01f, -6.65415078e-02f, 2.75528003e-02f, -4.97360043e-02f, 2.37119454e-03f, 3.31495404e-02f, -6.39144406e-02f, -5.01676202e-02f, 2.81823310e-03f, 4.58085462e-02f,
  7.34227747e-02f, 4.83667478e-03f, 3.66467088e-02f, -5.53412829e-03f, -7.09988084e-03f, -1.76607165e-02f, 2.08269432e-02f, -5.60037903e-02f, 1.60096120e-02f, 4.63132784e-02f,
  -2.81881890e-03f, -2.43441737e-03f, -2.61717457e-02f, -2.31374763e-02f, 3.23447064e-02f, 1.45746432e-02f, -2.65161525e-02f, 1.49707096e-02f, -4.24305955e-03f, -7.09183440e-02f,
  3.20961177e-02f, -2.23295260e-02f, 4.78549898e-02f, 3.50886062e-02f, 1.04407948e-02f, -3.48683097e-05f, 5.98263144e-02f, -4.24964316e-02f, 4.30083508e-03f, 2.87351478e-02f,
  -1.09114647e-02f, 1.12367338e-02f, 6.19096356e-03f, -2.22847164e-02f, -8.05171859e-03f, 2.99967709e-03f, 3.98863964e-02f, -1.01811148e-01f, 5.02280295e-02f, 1.73242074e-02f,
  4.16563898e-02f, -9.81581304e-03f, -4.99771945e-02f, -1.88559666e-02f, -3.39560583e-02f, -4.81630210e-03f, -5.24972305e-02f, 3.80860604e-02f, -2.43784413e-02f, 5.21252267e-02f,
  4.63955896e-03f, 1.39673920e-02f, 2.91030575e-03f, -3.25065367e-02f, 3.73882502e-02f, -1.71385687e-02f, 9.60744619e-02f, 5.93227819e-02f, -5.83082438e-03f, -4.87123197e-03f,
  -6.10807911e-02f, 2.58363374e-02f, -1.77761018e-02f, 3.34574729e-02f, -1.60768256e-02f, 6.21908419e-02f, -2.16734633e-02f, 5.53584062e-02f, 2.83746719e-02f, 1.38984332e-02f,
  -1.36677399e-01f, 1.92105826e-02f, 6.26020804e-02f, -1.13944195e-01f, -1.31368414e-02f, -6.56472370e-02f, 5.85045666e-03f, -1.47199735e-01f, 3.34362127e-02f, 8.18258598e-02f,
  -6.20287806e-02f, 7.66235963e-02f, -2.87802946e-02f, -2.59108096e-01f, -2.71643698e-01f, -1.88828912e-02f, -1.45947635e-01f, -4.89058979e-02f, -1.25204548e-01f, 8.36816430e-03f,
  -1.33697465e-01f, -1.92276374e-01f, -2.14732707e-01f, -8.89607221e-02f, -3.54049057e-02f, 3.30488831e-02f, 4.85503152e-02f, 1.14512838e-01f, 4.17998545e-02f, -7.23654702e-02f,
  -8.90845731e-02f, 1.96954329e-02f, 1.11262865e-01f, 3.26655284e-02f, 9.13237873e-03f, 7.80594200e-02f, 1.10353231e-02f, 4.76345010e-02f, -4.12976258e-02f, -2.76114754e-02f,
  1.16772525e-01f, -3.29525396e-02f, -3.27609144e-02f, -2.72649638e-02f, -8.30374956e-02f, -4.03399281e-02f, -4.56326529e-02f, 5.35251014e-02f, 6.63528442e-02f, -7.55763799e-02f,
  -5.54751419e-03f, -2.07551587e-02f, -4.29720096e-02f, 2.38142516e-02f, -5.79050882e-03f, -1.71170756e-02f, -3.05359047e-02f, -1.57498382e-02f, 3.76498736e-02f, 9.78062768e-03f,
  1.23378141e-02f, 7.73351938e-02f, -2.55558025e-02f, 2.53503155e-02f, -1.71692856e-02f, -5.01973629e-02f, 3.42185958e-03f, 1.25959376e-02f, 3.61030027e-02f, -1.82309803e-02f,
  5.33153675e-02f, -3.85406031e-03f, 3.34514566e-02f, 2.75308769e-02f, -4.56012115e-02f, -2.52132751e-02f, 1.26555609e-02f, 1.52681591e-02f, 7.82258660e-02f, -6.10624142e-02f,
  2.42398363e-02f, -5.10388687e-02f, 2.47522048e-03f, 3.07505345e-03f, -3.80846113e-03f, -8.93574655e-02f, -1.54675273e-02f, -5.00353277e-02f, -1.40738385e-02f, 7.30981631e-03f,
  -4.45836484e-02f, 1.41667217e-01f, -3.67113501e-02f, -5.44271618e-03f, 8.83085504e-02f, 6.29448518e-02f, -2.21551657e-02f, -1.10649720e-01f, 6.78735897e-02f, -4.38736081e-02f,
  7.63449669e-02f, -2.91780736e-02f, -1.83279195e-03f, 5.21712610e-03f, -2.26037465e-02f, -3.02108116e-02f, 8.48391280e-02f, -9.08741902e-04f, -4.13473360e-02f, 5.56423627e-02f,
  -1.40089169e-02f, 8.36693496e-02f, 2.50832532e-02f, -2.67453380e-02f, -1.43289324e-02f, 2.95866188e-02f, 7.01728761e-02f, 9.56012383e-02f, -1.10929571e-02f, 1.83829665e-02f,
  -3.74532819e-01f, -1.24759369e-01f, -1.44145399e-01f, -2.15700164e-01f, -9.61741433e-03f, 9.28450823e-02f, -1.96867920e-02f, -1.22252613e-01f, -2.48194516e-01f, 5.45480009e-03f,
  1.18702114e-01f, 1.71846226e-02f, 3.10104210e-02f, -1.20439798e-01f, 2.35178694e-02f, 4.34962176e-02f, -7.58875608e-02f, -1.25160592e-03f, -4.75664027e-02f, -1.33024246e-01f,
  -1.26118079e-01f, 5.47441235e-03f, -5.15594818e-02f, 9.40091908e-02f, -7.02580363e-02f, -2.00583842e-02f, 1.23114809e-01f, 1.32184163e-01f, 3.71327214e-02f, -3.14741954e-03f,
  4.84586768e-02f, -1.34073362e-01f, -4.98415828e-02f, 5.10934703e-02f, 3.76934297e-02f, -3.19491103e-02f, 8.49644244e-02f, 1.12404391e-01f, 8.37695971e-03f, -4.67806384e-02f,
  2.41270978e-02f, -7.46878162e-02f, 1.48059996e-02f, 1.81890149e-02f, 2.73436047e-02f, -1.36093302e-02f, 4.23985384e-02f, -2.90992912e-02f, -3.52859311e-02f, 3.55223753e-02f,
  -4.30357121e-02f, 5.55573963e-03f, -3.62590738e-02f, -2.14386662e-03f, -3.33277090e-03f, 8.18604138e-03f, -3.42553221e-02f, 2.12625451e-02f, -1.30899549e-02f, -4.95494008e-02f,
  -3.18170153e-03f, 5.53732924e-02f, -1.84094943e-02f, -1.71339400e-02f, -6.80975467e-02f, 7.36559927e-02f, 1.64437760e-02f, 2.26587951e-02f, -1.01689985e-02f, -9.26145911e-03f,
  -7.05523556e-03f, 1.06680701e-02f, -7.72501752e-02f, -1.96129363e-02f, -4.90381457e-02f, 5.97666427e-02f, 7.84434453e-02f, -2.43070219e-02f, -1.69283748e-02f, 4.84795608e-02f,
  4.42169309e-02f, -2.20450144e-02f, -3.21136788e-02f, 4.30749878e-02f, 6.01909915e-03f, 3.86874117e-02f, -3.66492779e-04f, -2.28816215e-02f, 4.63854037e-02f, 9.99271218e-03f,
  -3.20329443e-02f, -1.64987803e-01f, 9.24477295e-04f, 8.10476691e-02f, -7.72229955e-02f, 1.77789200e-02f, -2.23041419e-02f, -7.91160837e-02f, -2.69192830e-03f, -7.70830661e-02f,
  -1.08049940e-02f, 8.18390697e-02f, 2.69615371e-02f, -7.91290961e-03f, -3.76247577e-02f, -8.88196453e-02f, -1.58518017e-03f, 1.02276076e-02f, -3.13014127e-02f, 6.90241170e-04f,
  -5.89518948e-03f, 8.07459950e-02f, 3.98695953e-02f, 3.64174955e-02f, 4.74676676e-02f, 7.17362738e-04f, -3.43881510e-02f, 4.68048826e-03f, 5.00121266e-02f, 2.32997481e-02f,
  -1.92028090e-01f, -1.26174554e-01f, -1.32645309e-01f, -1.72074623e-02f, 2.28722304e-01f, 4.03421581e-01f, 3.48451495e-01f, 9.44049936e-03f, -2.83078142e-02f, 1.31555945e-01f,
  8.82905200e-02f, -6.27321750e-02f, -1.11227855e-01f, 6.65259063e-02f, -4.04650643e-02f, -8.67654383e-02f, 4.22690064e-02f, 8.86678919e-02f, -1.22042552e-01f, -1.37879429e-02f,
  -8.98435041e-02f, 1.27379045e-01f, -7.26978779e-02f, -2.41755638e-02f, 4.07222882e-02f, -1.28564537e-02f, -3.67753650e-03f, -6.88390955e-02f, 8.05961862e-02f, 7.21054226e-02f,
  7.85928369e-02f, -6.37739003e-02f, -5.53943403e-02f, -2.17863526e-02f, 1.00040540e-01f, 8.83868709e-02f, 7.45795518e-02f, 3.31585035e-02f, -2.63710655e-02f, 4.32869792e-02f,
  -1.27648388e-03f, -4.47756536e-02f, -2.28485353e-02f, 2.59829033e-02f, 3.40921283e-02f, -5.57727292e-02f, -2.14561168e-02f, -4.11834270e-02f, -3.03434003e-02f, -4.75253239e-02f,
  -1.50660835e-02f, 4.53309342e-02f, 1.47391399e-02f, -2.01213062e-02f, 3.16472761e-02f, -2.36794781e-02f, -5.96588738e-02f, -3.46621848e-03f, 1.23581804e-01f, 3.51526514e-02f,
  1.55552116e-03f, 4.15040441e-02f, -1.04398257e-03f, -7.58870021e-02f, 3.50635536e-02f, -6.40959740e-02f, 5.47769591e-02f, -1.42641198e-02f, 4.54053655e-02f, -1.86431222e-03f,
  6.36181012e-02f, -2.17069108e-02f, 2.16881000e-02f, -1.95575543e-02f, 4.94079962e-02f, -4.45291735e-02f, 4.09330912e-02f, -1.72331240e-02f, 2.99092270e-02f, -4.32662182e-02f,
  -7.62349367e-02f, -4.08796174e-03f, -1.26417670e-02f, 4.49094325e-02f, -3.42490361e-03f, 3.89175937e-02f, 4.12743986e-02f, 1.38258440e-02f, -4.84094061e-02f, 3.93338278e-02f,
  1.20532386e-01f, -3.11800372e-02f, 3.04564070e-02f, 4.24882397e-02f, 5.69901569e-03f, -2.47809235e-02f, -3.57373618e-02f, -4.33682390e-02f, -6.79230019e-02f, 2.88660079e-02f,
  -3.63606960e-02f, 1.30685268e-03f, 4.35459651e-02f, -4.81181480e-02f, -4.29815799e-03f, 6.38830215e-02f, -1.24070374e-02f, 3.03421225e-02f, 9.70320553e-02f, 2.52371747e-02f,
  1.62161291e-02f, 5.38732037e-02f, -1.17251268e-02f, 6.65632114e-02f, 1.63087621e-02f, 4.75629158e-02f, 3.14552076e-02f, 4.35573496e-02f, 1.08126020e-02f, -3.09021082e-02f,
  4.44004744e-01f, -6.55981451e-02f, -1.69425029e-02f, 6.33260012e-02f, 1.32732943e-01f, 1.60624851e-02f, 7.45972991e-02f, 5.20287780e-03f, 1.18866973e-01f, -6.04500547e-02f,
  -4.50074375e-02f, 1.97202325e-01f, -1.45701304e-01f, 1.06376082e-01f, 1.14172854e-01f, -9.96887386e-02f, 7.86888003e-02f, -6.16236515e-02f, 2.92246249e-02f, 9.43600088e-02f,
  3.83935198e-02f, 1.31951243e-01f, 2.76150573e-02f, -2.53973939e-02f, 1.02808423e-01f, -3.09723206e-02f, 3.50461365e-03f, -2.38931309e-02f, -5.86126447e-02f, 6.49533495e-02f,
  -4.62297862e-03f, 5.11039011e-02f, -3.12618762e-02f, 1.82119571e-02f, 3.84512022e-02f, 1.83032602e-02f, -2.66945772e-02f, 7.85476416e-02f, -5.39894886e-02f, -2.20293645e-02f,
  -1.29671674e-03f, -4.50676074e-03f, 1.05213374e-02f, -2.68045440e-02f, 6.85004517e-02f, -7.25078210e-02f, -8.69192649e-03f, -1.63394343e-02f, -2.50429921e-02f, -5.27179353e-02f,
  -7.42138699e-02f, -3.95237245e-02f, -1.45399201e-04f, 4.85459641e-02f, -5.91857992e-02f, 4.66615930e-02f, -4.02599387e-02f, 3.51735801e-02f, 1.12327514e-02f, 3.85595150e-02f,
  1.04179636e-01f, -4.27780934e-02f, -6.13682531e-02f, 2.93616857e-02f, 4.01231088e-02f, 7.68468762e-03f, -9.14264992e-02f, 6.40059337e-02f, -1.67730276e-03f, 5.65563254e-02f,
  3.70952003e-02f, 3.03898919e-02f, -1.74137820e-02f, 4.70450521e-02f, 9.19050574e-02f, -2.69029364e-02f, 5.39559387e-02f, 2.16751429e-03f, 4.67877537e-02f, -3.49843316e-02f,
  5.52277919e-03f, 3.63985226e-02f, -5.81423789e-02f, 2.64836513e-02f, 1.97059195e-02f, -4.55203205e-02f, -6.25719354e-02f, -1.86379775e-02f, -9.77540687e-02f, -7.91817531e-02f,
  2.69858912e-02f, -2.10561212e-02f, 4.96732369e-02f, 6.94649890e-02f, 3.73570509e-02f, 5.63330501e-02f, 4.41481993e-02f, -1.49314227e-02f, 2.13392712e-02f, -3.00973672e-02f,
  -3.30703110e-02f, -3.49417562e-03f, 1.06178805e-01f, 8.86865053e-03f, -1.70048885e-02f, -2.87036458e-03f, 4.42983024e-02f, -5.59757799e-02f, -2.29253639e-02f, -2.77833566e-02f,
  -6.60125837e-02f, -2.30430346e-02f, -2.38985438e-02f, 6.84675574e-02f, 6.84845075e-02f, -7.14067742e-02f, -1.78580862e-02f, -2.30197124e-02f, 7.50153698e-03f, 5.50700650e-02f,
  -1.90018505e-01f, 1.86099872e-01f, 1.12938128e-01f, -1.87973559e-01f, 1.79521311e-02f, -2.09276527e-01f, -2.57438958e-01f, 2.72296574e-02f, 2.25591868e-01f, -5.58093749e-02f,
  -1.42479956e-01f, 9.06435326e-02f, 8.76858607e-02f, -1.28510341e-01f, 5.54601885e-02f, 9.97797698e-02f, -1.40642866e-01f, -1.16418801e-01f, 2.00849101e-01f, -2.36022756e-01f,
  3.72896865e-02f, -1.73782095e-01f, -6.82016388e-02f, -9.53662470e-02f, -1.54082686e-01f, 3.16571333e-02f, -1.65848732e-01f, 8.14200044e-02f, -1.31812930e-01f, 8.85240957e-02f,
  1.10132305e-03f, 7.93510899e-02f, -1.04300175e-02f, -1.70317944e-02f, -7.17535764e-02f, -6.66552931e-02f, -3.56921181e-02f, 4.38387832e-03f, 2.11696941e-02f, -1.23481229e-02f,
  -3.05353049e-02f, 3.08139827e-02f, 9.25350655e-03f, 7.79507756e-02f, 5.24484739e-03f, 2.29506586e-02f, 1.16669219e-02f, -3.52666117e-02f, -2.20281258e-02f, 5.02036959e-02f,
  -4.86414805e-02f, 1.97490747e-03f, -6.36916533e-02f, -4.54999954e-02f, 3.44972238e-02f, -2.59244703e-02f, -7.91270379e-03f, -5.96653996e-03f, 7.16779456e-02f, 1.25334039e-02f,
  -9.65878926e-03f, 6.81622606e-03f, -1.00518756e-01f, 3.10031753e-02f, -2.48909611e-02f, -2.29297783e-02f, 1.69525854e-02f, -4.34007868e-03f, 1.84809265e-03f, -1.33170476e-02f,
  -1.30749699e-02f, 7.23758247e-03f, 2.86538508e-02f, -6.21058829e-02f, -5.29971793e-02f, -2.36776890e-03f, 1.25015611e-02f, -3.74223688e-03f, -1.97874103e-02f, -1.52142188e-02f,
  1.71300229e-02f, -2.21093148e-02f, -2.91288104e-02f, -2.60805376e-02f, 6.61968887e-02f, 1.74486991e-02f, 4.87294383e-02f, 5.25446348e-02f, -5.38246632e-02f, -2.57095806e-02f,
  -9.87946466e-02f, -2.61404719e-02f, -1.76994782e-02f, 9.42131132e-03f, 5.73784001e-02f, -3.08594164e-02f, 8.97277072e-02f, -7.71391531e-03f, 9.63363983e-03f, 5.81207499e-02f,
  -1.03473075e-01f, -4.48469222e-02f, 1.11290785e-02f, -8.42550956e-03f, 4.78250384e-02f, 6.50538877e-03f, -8.23810697e-02f, -1.07743181e-02f, -1.89505629e-02f, -5.51104024e-02f,
  -7.01052099e-02f, -4.88694049e-02f, 1.23335468e-03f, 1.19536724e-02f, -6.17193617e-02f, -5.72029762e-02f, -3.59313264e-02f, -3.18922661e-02f, 3.16218287e-02f, 4.36674282e-02f,
  3.21339816e-02f, -8.54240432e-02f, -1.11860916e-01f, -6.80502206e-02f, -1.22449458e-01f, 2.27991164e-01f, 7.75465220e-02f, -1.52771488e-01f, 1.35267466e-01f, -8.00924525e-02f,
  1.13301136e-01f, 7.86187798e-02f, 1.55834779e-01f, 1.30971193e-01f, 4.42730129e-01f, 3.32423151e-01f, 1.60953358e-01f, 1.35288864e-01f, 2.02323310e-02f, -1.21415734e-01f,
  8.50626267e-03f, 2.36242227e-02f, -9.22978297e-02f, -2.24737614e-01f, -1.58136234e-01f, -3.95468950e-01f, -1.80830121e-01f, -1.83113798e-01f, -1.47045627e-01f, 7.38765746e-02f,
  8.18897188e-02f, 8.28798488e-02f, -2.63819285e-02f, -2.87911259e-02f, -5.98073341e-02f, -5.37733845e-02f, 2.97894469e-03f, 6.76506758e-02f, -3.37491408e-02f, -2.97131743e-02f,
  8.28746632e-02f, -1.23099815e-02f, -2.10740510e-02f, 5.82802445e-02f, -7.71348476e-02f, 3.65023455e-03f, 4.07636799e-02f, -2.05831882e-02f, -7.88859352e-02f, 8.74557123e-02f,
  1.56345014e-02f, -3.31850676e-03f, -6.57136664e-02f, 5.06415330e-02f, 2.77702380e-02f, 1.09693278e-02f, 1.40138092e-02f, -4.61508930e-02f, -2.35981252e-02f, -1.22527750e-02f,
  4.53901961e-02f, -5.89729548e-02f, -1.44910184e-03f, -1.37054203e-02f, 2.78321007e-04f, -1.74894184e-02f, -6.17447263e-03f, 7.17580244e-02f, -3.24256644e-02f, 3.85771990e-02f,
  1.68356039e-02f, -4.70644273e-02f, -4.72364156e-03f, 1.88627234e-03f, -7.94534758e-02f, -4.16360945e-02f, -5.94376214e-02f, 6.64707050e-02f, 6.29524281e-03f, 2.51923222e-02f,
  -8.91922880e-03f, 2.43914407e-02f, -8.36238414e-02f, -5.71552515e-02f, 3.87217328e-02f, -2.13065576e-02f, 2.40924619e-02f, -5.51624969e-03f, -5.26921637e-02f, 3.77705172e-02f,
  1.26278713e-01f, -2.42704991e-03f, -6.56386837e-02f, -4.55149002e-02f, 2.24771351e-02f, 5.75861856e-02f, 3.05366255e-02f, -8.08170624e-03f, 4.03627120e-02f, 5.96891865e-02f,
  -9.30375606e-02f, -4.56794463e-02f, -1.39350845e-02f, -1.97273307e-02f, 2.74315290e-02f, 5.52564226e-02f, -6.47201762e-02f, -4.60479967e-02f, -3.47294807e-02f, 3.08178663e-02f,
  -1.19784229e-01f, 5.34013845e-02f, 1.61222089e-02f, -1.31263301e-01f, 6.74837176e-03f, -2.84254812e-02f, -2.30883528e-02f, -4.00258374e-04f, 1.63571946e-02f, 6.43328503e-02f,
  6.75915256e-02f, 2.87653714e-01f, -1.10095337e-01f, 9.62966029e-03f, -9.03039202e-02f, -2.66533554e-01f, -2.09644809e-01f, -7.84290209e-02f, -1.34602904e-01f, 1.19033925e-01f,
  1.54707655e-02f, 5.82652614e-02f, 4.74852622e-02f, -7.38851652e-02f, -2.62644321e-01f, -2.05766439e-01f, -1.13017574e-01f, -2.76539624e-02f, 8.81640688e-02f, 9.24980193e-02f,
  -1.11862153e-01f, 3.76062393e-02f, 2.15492863e-02f, 1.10211574e-01f, 1.56662002e-01f, 1.82231426e-01f, 1.84131607e-01f, 6.12666458e-02f, 1.04584523e-01f, -8.59731808e-02f,
  1.19934715e-02f, 7.76571780e-02f, 7.81977624e-02f, 2.83133462e-02f, 5.88417947e-02f, 7.15941712e-02f, 2.84726135e-02f, -3.29250544e-02f, -4.80095483e-03f, 3.77893336e-02f,
  7.94492289e-02f, -7.27777258e-02f, -9.50244516e-02f, -8.40816051e-02f, 2.44026147e-02f, 7.93880504e-03f, -2.89479904e-02f, 5.10414876e-02f, -3.61803323e-02f, 6.61903876e-04f,
  4.00314219e-02f, 1.90952409e-03f, 4.06597480e-02f, 3.60414721e-02f, 8.41856450e-02f, 5.64982370e-02f, -9.44271982e-02f, -4.85192500e-02f, 4.96295607e-03f, -3.13875005e-02f,
  9.72009823e-02f, 4.45383079e-02f, 4.11822870e-02f, 3.73988561e-02f, 5.99251799e-02f, -5.73439859e-02f, 2.36787777e-02f, -1.19473906e-02f, 2.22176611e-02f, -3.32618430e-02f,
  -3.69338877e-02f, 1.48809180e-02f, -9.44074541e-02f, -6.51214048e-02f, 2.49282345e-02f, -2.27788761e-02f, 6.33566035e-03f, -6.89377561e-02f, 4.49290387e-02f, -1.46849826e-02f,
  -6.71904907e-03f, -3.68520766e-02f, 1.07648307e-02f, 2.13255547e-02f, 2.23891307e-02f, 3.66438739e-02f, 1.68664921e-02f, -6.43185750e-02f, -2.80205859e-03f, 3.64751108e-02f,
  1.96680188e-01f, 1.56277657e-01f, 6.35291710e-02f, -4.75974055e-03f, 4.31322381e-02f, 8.12516287e-02f, 6.91497251e-02f, -2.67840046e-02f, 2.81298161e-02f, 4.02523093e-02f,
  -4.02749740e-02f, -1.49286268e-02f, 4.72616926e-02f, 1.86499245e-02f, -1.34093454e-04f, -3.35755907e-02f, -1.38943698e-02f, 8.31695870e-02f, 6.91625625e-02f, 8.33149403e-02f,
  6.11153133e-02f, -3.18727829e-02f, -3.36772799e-02f, 3.09327487e-02f, 6.82810992e-02f, -1.92538016e-02f, 5.17222509e-02f, 3.00249346e-02f, -4.57246825e-02f, 2.56902212e-03f,
  3.78785402e-01f, -2.44924858e-01f, 1.63280755e-01f, -1.92035586e-01f, -7.61527717e-02f, -1.29865602e-01f, 4.92664687e-02f, -1.24549931e-02f, 4.55888733e-02f, -9.64849293e-02f,
  2.06145011e-02f, 3.76434810e-02f, 1.39571294e-01f, -3.05620432e-01f, -3.94816659e-02f, -5.01547866e-02f, -2.99343079e-01f, -4.10608910e-02f, -1.00792803e-01f, -1.80034582e-02f,
  2.89902389e-02f, -3.24510396e-01f, -7.39122629e-02f, -2.17662469e-01f, -1.29533872e-01f, 4.51047160e-02f, -5.92952669e-02f, 5.08668870e-02f, -2.14161694e-01f, -9.24416631e-02f,
  -9.44602536e-04f, 9.06009749e-02f, 7.16344863e-02f, 8.36950168e-02f, -1.77627709e-02f, 4.43010926e-02f, -8.51931237e-03f, -1.59376778e-03f, 1.03765473e-01f, 1.19169464e-03f,
  2.68769059e-02f, 1.80999134e-02f, -6.71939850e-02f, 8.92536491e-02f, 3.96358520e-02f, -6.30199118e-03f, -1.07772965e-02f, 1.05856145e-02f, 4.18488942e-02f, 1.57982591e-04f,
  -6.40003905e-02f, -3.60552035e-02f, -4.01195921e-02f, -6.48347735e-02f, 3.03456187e-02f, -6.55478388e-02f, 1.29282018e-02f, -2.05842336e-03f, 4.41830568e-02f, -8.73444695e-03f,
  3.45261730e-02f, 8.34657699e-02f, 4.34799492e-02f, -1.04438271e-02f, -5.16645834e-02f, 9.91691649e-03f, -1.96827250e-03f, -8.77072103e-03f, -5.72954491e-02f, -9.08147022e-02f,
  -1.60111710e-02f, -6.79243472e-04f, 1.24749057e-02f, 1.55221084e-02f, -3.38714905e-02f, 2.01196689e-03f, 7.26229162e-04f, 3.68700996e-02f, 3.98251228e-02f, -3.79112288e-02f,
  2.44781766e-02f, 1.71705689e-02f, -3.77033763e-02f, -1.45475157e-02f, -1.08618587e-02f, 2.74229143e-03f, -1.06352065e-02f, -1.30799459e-02f, -5.89072099e-03f, 5.07570393e-02f,
  -1.01732135e-01f, -1.33679658e-01f, 4.14520688e-02f, 4.56698574e-02f, -8.93196650e-03f, 1.45914052e-02f, -9.63453576e-03f, 2.89552342e-02f, -1.31105082e-02f, 4.09766398e-02f,
  6.85284957e-02f, -2.71622296e-02f, 8.46593827e-02f, -4.27958705e-02f, -4.99721207e-02f, -6.24318048e-02f, -5.21421097e-02f, -4.62797135e-02f, -9.12278816e-02f, -8.16012025e-02f,
  -1.84222516e-02f, -7.56595982e-04f, 3.04791797e-02f, -6.43670112e-02f, 3.33244763e-02f, -1.28870104e-02f, 9.04247072e-03f, -2.00652927e-02f, -4.87139337e-02f, -8.45849980e-03f,
  2.48359814e-01f, -6.06257282e-02f, -5.43815158e-02f, 2.16502309e-01f, 2.43029501e-02f, 1.81952864e-01f, 1.58045039e-01f, -8.01364332e-02f, -7.89092705e-02f, 3.93441543e-02f,
  9.22415406e-02f, -1.40590385e-01f, -1.25830928e-02f, 2.00462073e-01f, 1.22720376e-02f, -9.90965068e-02f, 2.09432855e-01f, 9.68102664e-02f, -1.29645437e-01f, -7.06526125e-03f,
  9.22097266e-03f, 1.38829038e-01f, -6.05565310e-02f, -8.61988962e-03f, 1.37347311e-01f, 1.30292715e-03f, 6.31522983e-02f, -1.46369170e-02f, 1.37079209e-01f, -3.26414406e-02f,
  6.80771694e-02f, -4.69378801e-03f, 1.93727426e-02f, -7.32248351e-02f, 4.47978601e-02f, 6.00009114e-02f, 1.09350704e-01f, 9.39836446e-03f, 7.25161433e-02f, -6.70804903e-02f,
  5.18252328e-02f, -3.66125046e-03f, 5.39466478e-02f, 3.80172357e-02f, 1.24031836e-02f, -7.50112012e-02f, -3.40803042e-02f, -1.16398139e-02f, -8.15389827e-02f, -2.17368715e-02f,
  -4.01241668e-02f, 2.88164653e-02f, 5.33130914e-02f, -3.57188582e-02f, -1.44881001e-02f, -4.61681075e-02f, 1.00008445e-02f, -4.10692506e-02f, -6.69133104e-03f, -3.55492383e-02f,
  5.67003451e-02f, 7.88907520e-03f, -4.20251973e-02f, 6.69270009e-02f, -5.51954135e-02f, -7.95820355e-03f, 7.29548782e-02f, -2.79020853e-02f, -2.31955610e-02f, -3.79562415e-02f,
  1.82817318e-02f, 2.66073700e-02f, 9.73776914e-03f, -2.86114309e-02f, 7.42982104e-02f, 1.00765690e-01f, 9.58749726e-02f, -6.28907792e-03f, 3.35676130e-03f, -8.82720482e-03f,
  -5.51647507e-02f, -4.93865348e-02f, -1.84658784e-02f, 1.02834709e-01f, -1.33014703e-02f, 9.19774175e-03f, -7.32594822e-03f, -1.56408045e-02f, 4.87694377e-03f, 9.50963646e-02f,
  -1.23258019e-02f, -1.43457040e-01f, -1.03167847e-01f, 6.63794577e-04f, -6.56478480e-02f, -1.91867333e-02f, 4.81161140e-02f, 9.12066200e-04f, -9.45410505e-02f, 4.54272851e-02f,
  4.85776141e-02f, 4.49025333e-02f, -6.12163842e-02f, -1.50442570e-02f, 5.56172803e-02f, -4.05765250e-02f, -2.27244273e-02f, -2.50239652e-02f, 2.66699623e-02f, -6.01622835e-02f,
  -5.74464314e-02f, 5.59062883e-03f, 2.90171392e-02f, 2.18484942e-02f, 9.48220789e-02f, 5.77388937e-03f, -8.82555842e-02f, 2.71512214e-02f, -2.32900456e-02f, -2.42974516e-02f,
  1.03615955e-01f, 1.08682394e-01f, 2.03600079e-01f, 1.81948483e-01f, -5.21535333e-03f, -1.61848679e-01f, 6.24735691e-02f, 7.02017024e-02f, 7.91243836e-02f, -1.12666003e-01f,
  -8.37899894e-02f, 2.50786126e-01f, 2.70462874e-02f, 6.86633587e-02f, -8.43397751e-02f, 8.97860751e-02f, -1.07424408e-01f, -8.79600458e-03f, 9.51241702e-02f, -4.00264002e-03f,
  -1.41690299e-02f, -8.02458823e-02f, 7.96892494e-02f, -8.64213705e-02f, 4.76118252e-02f, 2.79506645e-03f, -1.69931710e-01f, 1.33691709e-02f, -1.46203041e-01f, -6.44664317e-02f,
  -4.43393402e-02f, 1.70615494e-01f, 7.94395879e-02f, -5.79072461e-02f, -1.97356325e-02f, -9.61429533e-03f, -7.06492364e-02f, 4.58438061e-02f, 2.82260007e-04f, -6.53902888e-02f,
  -2.20278017e-02f, 1.75665109e-03f, 3.03949900e-02f, 2.48302333e-02f, 4.78737839e-02f, 5.03233522e-02f, 4.61843126e-02f, 2.43384764e-02f, -5.42144617e-03f, 1.41622592e-02f,
  6.54326752e-02f, 9.25488099e-02f, 3.58222835e-02f, -1.01866126e-01f, 7.85393566e-02f, -7.69773673e-04f, 4.04798910e-02f, -8.11011810e-03f, -7.19675049e-02f, -6.44363556e-03f,
  6.50016814e-02f, 3.60097103e-02f, 6.43077269e-02f, -6.87166154e-02f, 1.08285397e-02f, -4.34969030e-02f, -2.57396530e-02f, -4.06664796e-02f, 3.28424945e-02f, -1.72373988e-02f,
  -3.15375961e-02f, -4.05609608e-02f, -8.28550849e-03f, -7.51592126e-03f, 6.38295487e-02f, -2.34130453e-02f, 3.48100513e-02f, -8.00485443e-03f, 3.12061491e-03f, -1.89173110e-02f,
  6.34159073e-02f, -5.91893159e-02f, 2.58983541e-02f, 3.35941799e-02f, 8.56765173e-03f, 6.17780164e-02f, 5.39365597e-02f, 4.90208603e-02f, 2.60782931e-02f, 3.95137966e-02f,
  -2.90974826e-01f, -1.24546692e-01f, -6.60064518e-02f, -6.43331856e-02f, -4.22155373e-02f, -8.84243175e-02f, 3.82245295e-02f, 1.43483160e-02f, -1.38452481e-02f, -1.89826451e-02f,
  8.38765409e-04f, 1.88661702e-02f, -5.61704002e-02f, -2.97329500e-02f, 2.07756199e-02f, 1.78630613e-02f, 3.04496475e-02f, -3.83896902e-02f, -4.19448502e-02f, -6.33477792e-02f,
  3.62738967e-02f, -1.81905348e-02f, -6.86898828e-02f, 6.58491701e-02f, -5.09269023e-03f, 3.65733355e-02f, 1.61921084e-02f, -2.44748462e-02f, 2.50436552e-02f, -1.20654935e-02f,
  1.01505443e-01f, -9.24177654e-03f, 1.45180926e-01f, -3.32630612e-02f, 2.29947388e-01f, 1.35151312e-01f, 7.34995157e-02f, 1.69192091e-01f, -3.21244113e-02f, -1.50736347e-01f,
  4.48291674e-02f, -3.97837572e-02f, -1.88808754e-01f, -3.04981358e-02f, 8.02832320e-02f, -8.73756558e-02f, 6.14148844e-03f, -4.73241694e-02f, 1.38394162e-02f, -3.56850214e-02f,
  -2.38331277e-02f, 6.56647235e-02f, -7.76235536e-02f, 2.66328789e-02f, 2.65908521e-02f, -5.49546489e-03f, -1.17841288e-02f, 3.76792736e-02f, 7.25382194e-02f, 6.80248290e-02f,
  4.45043631e-02f, 8.68737921e-02f, 6.31441325e-02f, -2.21577790e-02f, 1.10326454e-01f, 1.34536130e-02f, -4.38500643e-02f, 7.71821216e-02f, 1.89671200e-02f, 4.73826863e-02f,
  7.44676543e-03f, -3.48873995e-02f, 3.45802754e-02f, -1.53595433e-02f, 1.80520467e-03f, -9.80243739e-03f, -5.22927046e-02f, 3.67795005e-02f, 7.55768409e-03f, 1.13470014e-02f,
  3.21290158e-02f, -1.24450643e-02f, -5.93338497e-02f, -2.23969854e-02f, -4.17034812e-02f, 5.78543842e-02f, 5.25528900e-02f, 3.93051431e-02f, 1.12940585e-02f, -2.49044579e-02f,
  8.94935653e-02f, -5.21172695e-02f, 2.29096822e-02f, -3.45165990e-02f, 3.91684957e-02f, 9.95056983e-03f, 1.50061818e-02f, 1.32755702e-02f, 9.42493230e-03f, -9.97722521e-02f,
  2.64136530e-02f, -4.82117943e-02f, 1.59469564e-02f, 3.85122038e-02f, 3.71600874e-02f, 8.58265068e-03f, 5.98530732e-02f, -2.78313439e-02f, -1.45884342e-02f, -1.64035261e-02f,
  -4.45227735e-02f, -1.54436249e-02f, -6.91325516e-02f, 1.21435253e-02f, 7.18009025e-02f, -6.42156377e-02f, 2.78969556e-02f, 2.04306170e-02f, -8.79277289e-02f, 1.64714754e-02f,
  -2.05441136e-02f, -1.27725899e-01f, 5.39163090e-02f, 1.54864071e-02f, -4.84890826e-02f, 8.02162066e-02f, 3.35917994e-02f, 4.58927415e-02f, -1.39557235e-02f, -1.09624667e-02f,
  7.41616711e-02f, 4.79988828e-02f, -7.06261583e-03f, 6.09280318e-02f, -4.84645516e-02f, 8.65966156e-02f, -3.31027322e-02f, -2.69148238e-02f, 7.62676150e-02f, 5.83600719e-03f,
  1.51810879e-02f, 2.42754836e-02f, -1.16342586e-02f, 2.82429699e-02f, -1.04684709e-02f, -1.58395302e-02f, 7.86078442e-03f, -1.61946528e-02f, 1.74856652e-02f, 5.34086786e-02f,
  2.21256316e-02f, -2.39360526e-01f, -2.91335415e-02f, -7.97097608e-02f, 3.81528959e-02f, 9.47236829e-03f, -1.10114522e-01f, 1.03382438e-01f, -1.02784596e-01f, -2.28931025e-01f,
  -7.03047439e-02f, -1.84598088e-01f, -9.32728425e-02f, 3.27071846e-02f, 1.32628113e-01f, 1.23117834e-01f, 7.42883831e-02f, -3.60610336e-02f, 3.46044265e-02f, -3.46439518e-03f,
  1.61183476e-01f, 6.66005239e-02f, 2.70983666e-01f, 3.74703035e-02f, 3.24601345e-02f, -1.10096171e-01f, -6.63090544e-03f, 4.67201546e-02f, -3.36505733e-02f, 9.85124633e-02f,
  8.33605379e-02f, -4.78681251e-02f, -4.59979847e-02f, 7.03923628e-02f, -1.07809808e-02f, 8.18538759e-03f, -3.08228731e-02f, 8.73550400e-02f, 5.75277172e-02f, -8.03245530e-02f,
  -2.95331273e-02f, 1.53104472e-03f, 2.33366434e-02f, -1.22176670e-02f, -5.97805604e-02f, 5.75681515e-02f, 1.15716374e-02f, 6.64996207e-02f, -4.21280526e-02f, 6.15231656e-02f,
  2.44215373e-02f, 9.39398818e-03f, -3.74392159e-02f, -2.02448387e-02f, 4.20921333e-02f, -8.98188949e-02f, -5.94755560e-02f, -5.88945299e-02f, -1.04359929e-02f, -3.03228907e-02f,
  -2.99358908e-02f, -1.17939422e-02f, -1.76153723e-02f, 3.87457050e-02f, 1.20159807e-02f, -3.25840116e-02f, -1.36621119e-02f, 7.04644844e-02f, -6.19973205e-02f, -3.55366133e-02f,
  1.13947382e-02f, 2.85800472e-02f, 4.08330485e-02f, 8.60711467e-03f, -6.00221604e-02f, 4.91161132e-04f, -9.21286549e-03f, 4.19240259e-02f, 3.22308503e-02f, 1.00601371e-02f,
  9.72156320e-03f, -6.84898719e-02f, -6.44733757e-02f, 4.79529127e-02f, -2.87619978e-02f, -6.88063055e-02f, -3.47403735e-02f, -4.95639965e-02f, 4.07817550e-02f, -2.47928724e-02f,
  -5.09419255e-02f, -2.03109771e-01f, 2.02448927e-02f, -5.56176044e-02f, 6.08929321e-02f, 4.77363268e-04f, 3.14910635e-02f, -2.19602939e-02f, -6.75567240e-02f, -6.25373516e-03f,
  -4.27148230e-02f, 3.12225483e-02f, -9.70888659e-02f, -2.50386484e-02f, -3.11773270e-02f, -5.87371886e-02f, -1.82771441e-02f, -5.10584079e-02f, -2.09193733e-02f, -5.83799481e-02f,
  -4.14204858e-02f, -3.63692641e-03f, -2.98492867e-03f, 5.27055860e-02f, 4.74285111e-02f, 2.40299087e-02f, 4.27342951e-02f, 1.66532176e-03f, 1.63736325e-02f, -1.07614975e-02f,
  -2.09360763e-01f, 2.48260885e-01f, -2.03663677e-01f, -1.53125912e-01f, -5.91628999e-02f, -1.02287486e-01f, -1.33655235e-01f, 4.41033579e-03f, -1.20448925e-01f, 2.03567609e-01f,
  1.06451310e-01f, -1.19634859e-01f, 2.49547940e-02f, 6.91529214e-02f, -9.05182585e-02f, 8.49129781e-02f, 7.44133741e-02f, 3.24228108e-02f, -6.59328923e-02f, 7.14445189e-02f,
  2.76207887e-02f, 2.97532268e-02f, -3.62938531e-02f, 4.31763753e-02f, -1.32121637e-01f, -1.18633816e-02f, 1.58752725e-01f, -8.75563473e-02f, 6.58159778e-02f, -7.48310238e-02f,
  7.57909045e-02f, -6.07804358e-02f, 6.71048164e-02f, 1.02325631e-02f, 3.55471857e-02f, 8.09556767e-02f, -5.99687211e-02f, -3.58245894e-02f, -4.38725911e-02f, -3.28437909e-02f,
  -3.40881161e-02f, 9.63405371e-02f, 8.53564125e-03f, 6.32175729e-02f, -1.36807496e-02f, -9.37382281e-02f, -7.42444098e-02f, 4.31427099e-02f, 1.11714033e-02f, -7.10863173e-02f,
  3.72809656e-02f, 6.30072504e-02f, 2.05039866e-02f, 5.00638410e-02f, 3.99211682e-02f, -1.79062001e-02f, -4.28216085e-02f, -1.04245216e-01f, 6.50669709e-02f, -4.94176373e-02f,
  -1.21773414e-01f, 6.12455830e-02f, -6.17592037e-02f, 5.89956082e-02f, -2.74199583e-02f, 5.82827069e-02f, -5.03969043e-02f, 4.64043468e-02f, 4.01215740e-02f, 2.64511984e-02f,
  1.60596520e-02f, -2.12477706e-02f, 2.98597068e-02f, 7.44098276e-02f, -1.93491410e-02f, -4.55962270e-02f, 8.77507925e-02f, 9.31759849e-02f, 6.23565987e-02f, 8.14643968e-03f,
  -2.90997159e-02f, 3.46009098e-02f, 2.72490978e-02f, -2.54252255e-02f, -4.90018819e-03f, -1.78085957e-02f, 1.00617267e-01f, 3.02973539e-02f, -5.77936992e-02f, -4.25501578e-02f,
  3.41134697e-01f, 2.31749594e-01f, -3.76286358e-03f, 7.18152849e-03f, 7.83575997e-02f, 5.89001328e-02f, -1.73063483e-02f, 5.19880615e-02f, 2.98689250e-02f, 1.73295848e-02f,
  1.88747868e-02f, 5.18566146e-02f, 9.00610816e-03f, -6.81752041e-02f, 2.28241142e-02f, 3.86304483e-02f, 5.38213737e-02f, 3.48293893e-02f, 1.16939217e-01f, 3.90979163e-02f,
  8.38996544e-02f, -1.99013054e-02f, -6.48587793e-02f, -4.17396352e-02f, 5.26696735e-04f, -1.64905805e-02f, 3.74595150e-02f, -3.47102992e-02f, -3.03326678e-02f, 1.94646753e-02f,
  1.51718929e-01f, 3.60223763e-02f, 2.89916806e-02f, -6.59205690e-02f, 1.79243699e-01f, 7.60064647e-02f, -1.66397862e-04f, 4.15425934e-02f, 7.36165047e-02f, -1.33850425e-01f,
  -1.59788832e-01f, -1.92936584e-01f, -1.08895920e-01f, -2.52919912e-01f, -1.83279976e-01f, -1.30087942e-01f, -1.99188367e-01f, -1.21007703e-01f, -3.50914299e-02f, -2.28081346e-02f,
  -1.12336315e-01f, -2.45355144e-01f, -2.77403623e-01f, -6.76193386e-02f, -7.28968829e-02f, 4.00317200e-02f, -2.08905518e-01f, -5.41985966e-02f, -1.38702378e-01f, -1.23624206e-01f,
  -7.14989305e-02f, 5.16318232e-02f, -3.81334648e-02f, -1.35815446e-03f, 4.40153554e-02f, 4.12437283e-02f, -7.07419403e-03f, 1.50058120e-02f, 1.85226854e-02f, -2.91280132e-02f,
  -2.21396051e-03f, 5.81274405e-02f, -1.04297707e-02f, 2.62314407e-03f, 2.83059571e-02f, 8.19952935e-02f, -1.87400018e-03f, 3.95082729e-03f, 1.33147147e-02f, -8.44125897e-02f,
  1.11697847e-02f, 2.47033257e-02f, 4.11071368e-02f, 4.93789241e-02f, 9.16107371e-03f, -6.04414344e-02f, 7.05202576e-03f, -3.10856402e-02f, -6.56078476e-03f, -3.09211877e-03f,
  3.60419452e-02f, 4.25377972e-02f, -4.23659869e-02f, 2.89380755e-02f, 2.85063609e-02f, -8.22895672e-03f, -1.08618215e-01f, -3.46995853e-02f, 5.47464564e-02f, 2.15165596e-02f,
  -1.38072204e-02f, -6.90272748e-02f, 1.06186909e-03f, 3.10728159e-02f, 1.61631382e-03f, 1.32464003e-02f, 2.49051880e-02f, 9.56984516e-03f, 6.69213245e-04f, 3.13243344e-02f,
  -6.57182513e-03f, 1.48471268e-02f, -4.08557132e-02f, 3.67726274e-02f, -3.66693214e-02f, 2.91497651e-02f, -7.14831352e-02f, -5.83502743e-03f, -6.16388544e-02f, -3.30254659e-02f,
  -2.06579361e-03f, -6.44711256e-02f, -3.84987965e-02f, -4.64772694e-02f, -3.02055175e-03f, 1.09211691e-01f, -2.22028159e-02f, 3.81129310e-02f, 3.21697593e-02f, 3.79127599e-02f,
  -2.74027232e-02f, -6.59023300e-02f, 1.11975893e-02f, 2.80276574e-02f, -2.30482742e-02f, -4.14038971e-02f, -4.48694415e-02f, 3.40163894e-02f, -1.07786031e-02f, 5.08189350e-02f,
  -3.91261047e-03f, 5.34318425e-02f, 9.12829209e-03f, 9.97781157e-02f, 6.58896053e-03f, -1.59790628e-02f, 4.20087911e-02f, -2.48869564e-02f, 4.40296568e-02f, 4.71411236e-02f,
  -2.62160629e-01f, -1.02527715e-01f, 6.20652549e-02f, -5.20313308e-02f, -2.86435857e-02f, -2.30778884e-02f, 1.91226885e-01f, -1.34165421e-01f, -1.78191572e-01f, 1.95282344e-02f,
  5.14770746e-02f, -1.26617730e-01f, 1.71367660e-01f, 1.10201672e-01f, 9.77659784e-03f, 8.60515088e-02f, 6.25537038e-02f, -1.39914468e-01f, 6.63021952e-02f, -4.04308103e-02f,
  -9.52244624e-02f, 6.70358762e-02f, 2.37968996e-01f, 2.68933717e-02f, 4.34244378e-03f, 6.20091334e-02f, -2.98986752e-02f, 1.11979231e-01f, -7.35319853e-02f, -8.50341935e-03f,
  -1.03866242e-01f, -1.46216333e-01f, 7.88715295e-03f, 5.12274764e-02f, -1.63053197e-03f, 8.64659324e-02f, -9.62160341e-03f, 6.32952750e-02f, 6.97412267e-02f, 7.68747404e-02f,
  -1.45148989e-02f, -1.90555900e-02f, 4.18152250e-02f, 6.29340485e-02f, -4.52138409e-02f, -3.84354144e-02f, -5.14761023e-02f, 4.44479249e-02f, 5.73162511e-02f, 4.09485474e-02f,
  -1.57998037e-02f, 5.53090647e-02f, -1.39770368e-02f, -2.53159516e-02f, 3.18152979e-02f, 3.02711185e-02f, 2.55766716e-02f, 2.42535956e-02f, -4.43425141e-02f, -3.51553634e-02f,
  1.48841515e-02f, 3.17219608e-02f, 2.12768838e-02f, 2.58603934e-02f, -2.56046541e-02f, -1.37762092e-02f, -3.33301090e-02f, 2.89398376e-02f, -8.71749967e-02f, -1.67102218e-02f,
  2.79621426e-02f, -2.71458384e-02f, 1.32486196e-02f, -1.10124927e-02f, -5.83046824e-02f, 1.03028705e-02f, 5.60499802e-02f, -4.10182625e-02f, -2.77110506e-02f, -1.82514172e-02f,
  -4.64167483e-02f, -5.52667789e-02f, 5.86651452e-02f, -3.05039510e-02f, 3.25033739e-02f, 6.37206482e-03f, 3.23676784e-03f, -1.25204787e-01f, 5.90863340e-02f, 4.00722809e-02f,
  -3.20234090e-01f, -3.48395020e-01f, -1.59150045e-02f, -3.14225815e-02f, 7.19487667e-02f, 1.41838826e-02f, 1.54799903e-02f, 6.44994304e-02f, -1.00963689e-01f, 6.38842583e-02f,
  -4.46914956e-02f, -6.80177510e-02f, -2.09762286e-02f, 3.24690044e-02f, 3.89732867e-02f, -2.58099940e-02f, -1.09308409e-02f, 3.40890326e-02f, -7.55148157e-02f, 3.63186151e-02f,
  1.39902048e-02f, -4.84427884e-02f, -3.80503177e-03f, -3.37037668e-02f, -5.48918992e-02f, -1.71136092e-02f, -1.14742108e-01f, -9.50052869e-03f, -2.41591390e-02f, -3.85838654e-03f,
  -1.56280950e-01f, 2.73202844e-02f, 1.76943809e-01f, 1.78728074e-01f, 1.63305588e-02f, 3.52936447e-01f, 4.43212390e-01f, 8.71909261e-02f, 2.08572894e-01f, 6.48217574e-02f,
  8.35571066e-02f, 1.61675751e-01f, 8.07850882e-02f, 2.71688998e-01f, 2.23213300e-01f, 1.14142559e-01f, 1.85939223e-01f, 1.12115383e-01f, -9.55933928e-02f, -1.08819306e-01f,
  -1.07786767e-01f, -4.68002539e-03f, 1.20455131e-01f, -7.85813108e-02f, 2.62293182e-02f, -1.86428547e-01f, -8.44113156e-02f, 3.04560065e-02f, 2.79488135e-02f, 1.35571107e-01f,
  -2.61232741e-02f, -1.66361749e-01f, 7.86936581e-02f, 4.12330441e-02f, -6.58633783e-02f, -1.13811595e-02f, -2.97353547e-02f, -3.70569378e-02f, -4.53023799e-02f, 3.88032123e-02f,
  -2.32084300e-02f, 5.56769222e-03f, -1.19732162e-02f, 6.67331889e-02f, 4.72693853e-02f, 4.24167030e-02f, -4.86706495e-02f, -2.72344053e-02f, 3.42493951e-02f, -8.10350850e-03f,
  5.92571460e-02f, 3.05538420e-02f, 2.78281700e-02f, 3.90192196e-02f, 6.76779300e-02f, -1.27520729e-02f, 2.89426539e-02f, 3.43974605e-02f, 8.96076392e-03f, 6.68444857e-02f,
  -5.94906099e-02f, 1.37981027e-03f, -5.56262918e-02f, 2.65809298e-02f, -1.82922613e-02f, -2.50687841e-02f, 5.62081151e-02f, -8.33840296e-03f, -1.57982819e-02f, 2.02370454e-02f,
  7.81797338e-04f, -9.51016415e-03f, -4.59501445e-02f, 6.28266204e-03f, -2.33079158e-02f, -1.92841180e-02f, -4.26895246e-02f, -3.37976031e-02f, 3.29205655e-02f, 1.78779401e-02f,
  5.37388138e-02f, -1.33098299e-02f, 5.36351278e-02f, -5.66576459e-02f, 3.81141342e-02f, 3.38380821e-02f, 1.46108121e-03f, 3.68860364e-02f, -4.72140685e-03f, 2.20492501e-02f,
  -1.30385077e-02f, -1.89834401e-01f, 2.74704676e-02f, 3.13924626e-02f, 5.63697442e-02f, 4.12540548e-02f, -1.34303309e-02f, 7.02375025e-02f, 4.79540788e-02f, -4.80389642e-03f,
  -3.80157456e-02f, 2.91983001e-02f, -2.58547477e-02f, -1.33389123e-02f, -3.05190645e-02f, -8.14331323e-03f, 2.36636703e-03f, 3.37363929e-02f, -4.57696021e-02f, -4.20427397e-02f,
  -6.65050671e-02f, -1.03985094e-01f, 3.93768921e-02f, 4.72571328e-03f, -1.05173532e-02f, -2.75025014e-02f, -7.92203564e-03f, -4.10072133e-02f, -4.65510525e-02f, 5.49733900e-02f,
  -2.44674265e-01f, -4.84538786e-02f, -1.92592982e-02f, -2.07978681e-01f, -6.88970312e-02f, 4.18416038e-03f, 4.44265604e-02f, -2.71674041e-02f, -7.71388412e-02f, -2.10685227e-02f,
  7.72938952e-02f, -1.08020693e-01f, 1.90432578e-01f, -1.94976386e-02f, -1.28086165e-01f, 7.08493739e-02f, -1.81682900e-01f, -3.62902470e-02f, -4.73892391e-02f, -1.46613836e-01f,
  -1.09491691e-01f, 7.13586062e-03f, 2.22238805e-02f, 6.77035898e-02f, 1.11435009e-02f, 3.80536281e-02f, -7.77580356e-03f, 7.82478042e-03f, 2.19118204e-02f, -5.97465336e-02f,
  -1.00269392e-01f, -8.31108317e-02f, 9.75901783e-02f, -6.41070381e-02f, 4.67320532e-03f, -3.28689143e-02f, -7.36195222e-02f, 9.15340930e-02f, 8.43649730e-03f, 7.71533325e-02f,
  1.83838680e-02f, -7.39574060e-02f, -4.21451405e-04f, 3.62625830e-02f, 5.38630486e-02f, 3.95864509e-02f, -3.36352587e-02f, 1.09907473e-02f, 3.45694013e-02f, -2.54588444e-02f,
  3.87201235e-02f, -3.17411125e-02f, 5.00350408e-02f, -1.24980067e-03f, -6.16943575e-02f, 1.28752682e-02f, -6.98768422e-02f, -5.91456629e-02f, -5.50904498e-02f, -1.32952081e-02f,
  1.03554046e-02f, -5.29370196e-02f, 1.07417352e-01f, 5.47367986e-03f, 7.69137666e-02f, 1.59896445e-02f, 4.70659286e-02f, -1.51062869e-02f, 6.92402273e-02f, -1.04721282e-02f,
  3.59040722e-02f, -4.02984247e-02f, 2.65135337e-02f, 7.08492994e-02f, 5.24563268e-02f, 2.56261192e-02f, 4.50061262e-02f, -4.97924797e-02f, 5.67126684e-02f, -4.85758670e-02f,
  5.89588843e-02f, 5.34454584e-02f, -7.15819001e-02f, 1.93816293e-02f, 3.44949886e-02f, 7.61363655e-02f, 1.77186802e-02f, 9.03698578e-02f, -6.22850358e-02f, 3.83489653e-02f,
  -2.17585370e-01f, -3.25959325e-01f, -1.24119567e-02f, -2.61311885e-02f, -1.27201481e-02f, 3.19686085e-02f, 2.77249180e-02f, -2.68297605e-02f, -6.00972399e-02f, -9.22300369e-02f,
  8.10439698e-03f, 7.62311071e-02f, -1.09012082e-01f, -2.15577241e-02f, -2.18149815e-02f, -4.41589169e-02f, -4.75086607e-02f, -1.16747953e-01f, -1.37964943e-02f, -7.95754939e-02f,
  -3.14896517e-02f, -5.15368879e-02f, -1.74174737e-02f, 2.12571844e-02f, 5.13717905e-02f, -5.27188145e-02f, -9.14519206e-02f, 8.90265161e-04f, -8.16029757e-02f, -2.53929906e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.39885232e-01f, 1.24340102e-01f, 6.99070022e-02f, -1.39057919e-01f, 3.24510261e-02f, -2.25903522e-02f, -1.85317874e-01f, 1.19179919e-01f, -5.69879601e-04f, -4.82700765e-02f,
  -1.72783285e-02f, -6.26150444e-02f, 8.17593187e-02f, -8.51181597e-02f, -5.15341312e-02f, -3.09773944e-02f, -1.00055262e-01f, -1.88023988e-02f, -5.06617734e-03f, 7.02718971e-03f,
  -1.06127925e-01f, -5.09127341e-02f, 1.57657973e-02f, 1.41808763e-01f, 5.60072027e-02f, 5.06499931e-02f, -7.44305551e-02f, -5.78767955e-02f, 6.11774512e-02f, -8.47103670e-02f,
  -8.24798644e-02f, -8.36343989e-02f, -9.09975246e-02f, 7.88494647e-02f, -1.10436566e-01f, -5.47415838e-02f, -7.05154166e-02f, 3.75174470e-02f, -3.15063000e-02f, -6.92544132e-02f,
  -4.25168350e-02f, -4.36546840e-02f, 3.10551375e-02f, 9.25778821e-02f, 7.10431561e-02f, 3.53121534e-02f, 1.47679457e-02f, -9.22738612e-02f, 1.08522207e-01f, -4.37084138e-02f,
  4.41881530e-02f, 5.68579398e-02f, 3.04596815e-02f, -5.43265678e-02f, 7.53078684e-02f, -5.80795147e-02f, 2.72998754e-02f, 4.43548374e-02f, 4.98293452e-02f, 2.46761180e-02f,
  -5.71374521e-02f, -7.90012553e-02f, -5.63257821e-02f, -1.41706718e-02f, -3.29271257e-02f, -1.25316875e-02f, 1.21067627e-03f, -1.25276083e-02f, -1.05638076e-02f, -1.07861541e-01f,
  -7.16039985e-02f, -3.73331830e-02f, 1.35141471e-02f, 3.04208491e-02f, -8.62551853e-02f, 7.41932169e-02f, -1.02138065e-01f, 3.16241221e-03f, -2.18912419e-02f, 1.21920640e-02f,
  -1.78930713e-04f, -3.68958600e-02f, -6.37916848e-02f, 7.25036114e-02f, 1.51157696e-02f, -8.00513849e-02f, -3.27006243e-02f, 7.82670174e-03f, -6.77974373e-02f, -6.45184442e-02f,
  -7.22890943e-02f, -8.87070522e-02f, 9.88206360e-03f, 5.45217246e-02f, -7.94935003e-02f, 1.95783935e-02f, 6.46348000e-02f, -3.18680108e-02f, 4.47221734e-02f, 9.81395021e-02f,
  -7.10134506e-02f, 3.15438993e-02f, -6.04237653e-02f, 6.13729283e-02f, -8.53126589e-03f, -3.34008187e-02f, -9.83406603e-03f, -6.42396584e-02f, 1.45925710e-03f, 1.89049859e-02f,
  -3.09140999e-02f, -4.28809552e-03f, -3.15866768e-02f, -8.93565069e-04f, -1.06015215e-02f, -5.75591475e-02f, -3.66635695e-02f, -4.71477993e-02f, 4.12052497e-02f, -2.37141550e-02f,
  -1.51588410e-01f, -1.42605677e-01f, -8.57633725e-02f, -5.54243065e-02f, -5.64880259e-02f, 2.82820081e-04f, -4.36465815e-02f, 8.79434049e-02f, -1.67160019e-01f, -1.65804163e-01f,
  2.15459242e-02f, -6.31480664e-02f, -1.31968215e-01f, -1.16267096e-04f, 9.72177386e-02f, -1.16532922e-01f, 5.38343750e-02f, 4.23101857e-02f, -1.32605657e-02f, 7.78438598e-02f,
  1.46366030e-01f, 1.36707053e-01f, 1.58301443e-01f, 2.21294209e-01f, 2.94219106e-02f, 1.47256523e-01f, 9.95723233e-02f, 3.14774588e-02f, 1.80191815e-01f, 1.13148436e-01f,
  -5.41624539e-02f, 3.06736380e-02f, -4.65371087e-02f, 4.09692153e-02f, 2.41960753e-02f, -1.83320511e-02f, 1.23354541e-02f, -9.82031971e-03f, 2.51177717e-02f, -5.92484921e-02f,
  -1.75213385e-02f, -4.62391265e-02f, 7.99431801e-02f, 1.08442202e-01f, 2.54175551e-02f, 1.20599270e-02f, -8.14365689e-04f, -5.67145050e-02f, 3.28068808e-02f, 4.52504754e-02f,
  -1.29500534e-02f, 7.86663145e-02f, 4.67965081e-02f, -6.82469457e-02f, 1.05561167e-02f, 1.05498172e-02f, -1.65351943e-04f, -3.55870910e-02f, 5.26321270e-02f, -3.97636071e-02f,
  7.18468651e-02f, 1.92162786e-02f, -8.70130509e-02f, 3.01281270e-02f, -8.70229397e-03f, 3.26861255e-02f, 1.49471471e-02f, 5.28684221e-02f, 3.99100669e-02f, -7.03970566e-02f,
  2.94263437e-02f, -6.74962401e-02f, -6.90639392e-02f, -6.42648637e-02f, -2.73650512e-02f, -5.46606891e-02f, 4.62601930e-02f, 6.78597465e-02f, -4.02554777e-03f, -4.01674286e-02f,
  -1.74994897e-02f, 5.88268973e-02f, 5.63208759e-02f, -3.15896645e-02f, 1.44563429e-02f, 2.86072716e-02f, 8.72260146e-03f, 2.84540225e-02f, -2.18876041e-02f, 4.12193965e-03f,
  -7.51789212e-02f, 4.63250577e-02f, 2.53677871e-02f, -2.55024191e-02f, 7.69509375e-02f, -5.70652299e-02f, 3.20460321e-03f, 5.69299310e-02f, 3.20673957e-02f, 3.85537408e-02f,
  1.98810194e-02f, 2.81624142e-02f, -6.82489276e-02f, -6.08416907e-02f, -1.32507291e-02f, 7.48067573e-02f, 1.50160091e-02f, 6.33971468e-02f, -3.05292532e-02f, 5.58171049e-02f,
  -5.42407371e-02f, -3.50837074e-02f, 4.39550616e-02f, -3.90990190e-02f, -9.08856839e-03f, -7.53328949e-02f, 7.87897035e-02f, 4.07482125e-02f, 9.19224247e-02f, -3.60123962e-02f,
  -9.31591541e-02f, 2.79400200e-01f, -1.62006393e-01f, 1.01741053e-01f, -5.96668459e-02f, 2.72313893e-01f, 2.38653719e-01f, 1.06181115e-01f, 2.63579488e-01f, 2.61152148e-01f,
  1.15080588e-01f, 1.02712259e-01f, 6.76973462e-02f, 2.10423693e-01f, -1.99145973e-02f, 1.74899802e-01f, 2.46810690e-01f, 2.10459784e-01f, 1.01808459e-01f, 1.16730042e-01f,
  -3.16344313e-02f, 1.59273550e-01f, -1.06949970e-01f, -2.41210274e-02f, 2.75110155e-02f, -1.57189101e-01f, -1.78367332e-01f, -1.44405663e-01f, 7.12403059e-02f, 2.55446397e-02f,
  1.06051259e-01f, 7.13426806e-03f, -1.04637817e-01f, -4.96199876e-02f, -4.51755077e-02f, 1.26213767e-02f, -7.27976263e-02f, -6.52595833e-02f, -5.06892428e-02f, 4.80583571e-02f,
  -1.44762155e-02f, -6.96300492e-02f, 6.35630935e-02f, -2.06353199e-02f, -4.21323031e-02f, -1.34042278e-03f, -3.00266892e-02f, -3.25662121e-02f, 3.58041236e-03f, -2.38122828e-02f,
  -2.74456525e-03f, 3.23828645e-02f, -1.09149492e-03f, 7.20238015e-02f, -8.66145194e-02f, 3.62594724e-02f, 9.18332487e-02f, -1.91941857e-02f, -5.18015074e-03f, 6.06342182e-02f,
  2.85765007e-02f, 2.18833927e-02f, 2.90329810e-02f, -5.42910807e-02f, -4.98627238e-02f, 2.94545945e-02f, -3.50373797e-02f, -1.51016843e-02f, -4.67611589e-02f, -2.46926304e-02f,
  2.25876160e-02f, -3.69168855e-02f, 3.83827835e-02f, 1.22656776e-02f, 9.65170283e-03f, 3.19138356e-02f, -4.78406586e-02f, 8.95063430e-02f, -3.01107927e-03f, -2.35792659e-02f,
  5.60718291e-02f, 8.49424489e-03f, -1.29526074e-04f, 2.84708049e-02f, 4.78838459e-02f, -7.76480138e-03f, -6.23970199e-03f, -1.60137322e-02f, -2.98791192e-03f, -9.81493387e-03f,
  1.56093180e-01f, 1.79030195e-01f, 7.18856752e-02f, -5.17378151e-02f, 5.08914376e-03f, -4.09075767e-02f, 5.96479662e-02f, 5.83677441e-02f, 9.69907939e-02f, -4.92828786e-02f,
  8.08503013e-03f, 3.02278940e-02f, -5.80748136e-04f, 7.24405795e-02f, 6.05477244e-02f, 7.10578412e-02f, -7.28567876e-03f, 5.53921685e-02f, 8.52761939e-02f, -1.11770080e-02f,
  -4.74577621e-02f, -4.21457067e-02f, 2.74966862e-02f, -4.97557595e-02f, 2.21452396e-02f, 2.59971879e-02f, -8.02104082e-03f, -3.81322578e-02f, 2.40278207e-02f, 4.66551520e-02f,
  -1.39970213e-01f, 3.80539782e-02f, 6.99970946e-02f, -6.16544150e-02f, -8.78936127e-02f, -5.90131916e-02f, 5.16407862e-02f, -4.42290641e-02f, 2.80689280e-02f, -2.26208791e-02f,
  6.11049868e-03f, -3.62290908e-03f, 4.34561931e-02f, -7.38000423e-02f, -2.05950602e-03f, -5.12254015e-02f, -1.92865450e-02f, 3.85052338e-02f, 6.38112500e-02f, 1.07402392e-01f,
  4.55572568e-02f, 6.36688024e-02f, -4.90419678e-02f, 1.94570869e-02f, 7.84002244e-02f, -5.53055480e-03f, -3.85125652e-02f, 6.25306219e-02f, 1.68960206e-02f, 5.14486879e-02f,
  -5.93832508e-02f, -4.62748744e-02f, 3.80167775e-02f, 6.53971061e-02f, -4.18366231e-02f, -8.39218032e-03f, -6.52144924e-02f, -5.60347363e-02f, -3.96649837e-02f, 3.10316142e-02f,
  -8.53319839e-02f, -9.08322167e-03f, -5.69927730e-02f, -3.30418646e-02f, -4.11864109e-02f, -2.39732452e-02f, 2.39575356e-02f, -6.74888585e-03f, -1.43871503e-02f, 4.72504757e-02f,
  3.43475230e-02f, -4.37896699e-03f, 4.57750633e-03f, 2.21047085e-02f, -7.53943250e-02f, 5.99846849e-03f, 5.55382073e-02f, 4.52813245e-02f, 4.29513380e-02f, 5.62288426e-03f,
  -3.75693874e-03f, 5.55564314e-02f, 6.13596179e-02f, -2.13325024e-02f, -6.85553998e-02f, 4.74447832e-02f, 4.40066308e-02f, 8.50002915e-02f, -5.58083467e-02f, -8.73566419e-02f,
  8.31760839e-02f, 3.42848748e-02f, 4.38457914e-02f, 2.80464236e-02f, -1.68465730e-03f, -2.99332459e-02f, 6.31670505e-02f, 7.29072541e-02f, -3.66913304e-02f, 4.61076126e-02f,
  2.14935150e-02f, 8.17487240e-02f, 2.67284997e-02f, -2.25521177e-02f, -9.08467025e-02f, -5.48035651e-02f, 2.80078361e-03f, 3.92390564e-02f, 6.02387264e-02f, -5.60397340e-04f,
  8.67261440e-02f, 4.46090102e-02f, -1.91062000e-02f, 8.12775493e-02f, 6.51430786e-02f, -4.63844091e-02f, 4.72445637e-02f, 6.75154291e-03f, 5.27325757e-02f, -7.79061168e-02f,
  -8.49193987e-03f, -4.50125411e-02f, 1.28237279e-02f, 2.26086527e-02f, -2.93049011e-02f, -3.52181122e-03f, 8.19846988e-02f, 8.21708329e-03f, -3.96378599e-02f, 3.70706841e-02f,
  -1.40604535e-02f, -4.89470661e-02f, 8.27576369e-02f, -7.26932799e-03f, 2.01509874e-02f, 1.64729133e-02f, 4.35965694e-02f, -8.06693882e-02f, -3.84406745e-02f, -7.28895888e-02f,
  3.83624248e-02f, 4.27552983e-02f, -5.05336970e-02f, 6.53450331e-03f, -6.20688908e-02f, -1.48682728e-01f, -1.36474147e-01f, -2.87296940e-02f, -4.23585549e-02f, 2.13914793e-02f,
  -4.33484949e-02f, -3.60658467e-02f, -1.23234876e-02f, 1.61958695e-03f, -3.42472903e-02f, 1.34406149e-01f, -9.93348360e-02f, 1.77740981e-03f, 7.14628249e-02f, -6.02950975e-02f,
  1.17948100e-01f, 1.80037264e-02f, -2.36319341e-02f, 7.91946203e-02f, -1.06890343e-01f, 4.71446440e-02f, 1.00092337e-01f, -3.23227309e-02f, -1.71430800e-02f, 4.50548120e-02f,
  5.48093356e-02f, 6.03793114e-02f, -1.63999796e-02f, 1.51812956e-02f, -3.71540673e-02f, 1.01965750e-02f, -1.79461148e-02f, 3.84802371e-02f, -2.12566834e-03f, -2.63526905e-02f,
  7.14074597e-02f, -5.42951114e-02f, 5.54931276e-02f, -3.92289273e-02f, -1.86702590e-02f, -2.62310393e-02f, 4.90772054e-02f, -8.59169848e-03f, -1.03589751e-01f, 1.83161926e-02f,
  -1.02600805e-01f, 7.81273767e-02f, -5.75043336e-02f, -3.46122943e-02f, -5.35004437e-02f, -1.13200687e-01f, -3.85395624e-02f, -6.43396080e-02f, 1.17806913e-02f, 4.32355590e-02f,
  5.82036003e-02f, 5.54721318e-02f, 7.52267018e-02f, -4.73882370e-02f, -4.55147848e-02f, 5.96087128e-02f, -4.30961512e-02f, 4.58784513e-02f, -1.95284523e-02f, 1.27877751e-02f,
  3.89375426e-02f, 4.80981618e-02f, -4.24481928e-03f, -6.66102916e-02f, 7.16660321e-02f, -1.00572467e-01f, 1.55512104e-02f, 8.12724680e-02f, 4.93858978e-02f, 6.65624533e-03f,
  -7.36027956e-02f, -1.63648073e-02f, -6.25599697e-02f, -1.04787759e-02f, 2.34944541e-02f, 9.98499058e-03f, -4.56219800e-02f, -5.54206036e-02f, -3.53690200e-02f, -2.61040181e-02f,
  5.45114130e-02f, -1.07174916e-02f, -4.80415188e-02f, -4.70387638e-02f, -7.36987740e-02f, 6.23203488e-03f, -8.86277258e-02f, 9.29823741e-02f, 4.30146232e-02f, 1.97389964e-02f,
  -6.18579648e-02f, -1.12339398e-02f, 5.57904728e-02f, 3.46002951e-02f, 4.03782465e-02f, -5.21103069e-02f, 4.91564013e-02f, 5.70928305e-02f, 3.04804053e-02f, 7.87804835e-03f,
  7.20656663e-02f, 7.21364375e-03f, 7.16893701e-03f, 6.33096099e-02f, 1.70383640e-02f, -9.73453894e-02f, 1.97721180e-02f, 5.48477694e-02f, -3.25506926e-02f, 5.77973351e-02f,
  -1.57125786e-01f, -8.86333287e-02f, 4.07443196e-02f, -7.43583515e-02f, 1.45399729e-02f, -1.21692298e-02f, 4.96988036e-02f, -3.43888961e-02f, -3.77601720e-02f, 7.88880661e-02f,
  8.50831419e-02f, -1.16742358e-01f, 1.26061933e-02f, -4.63081747e-02f, 2.51952857e-02f, -4.48976420e-02f, 6.23482354e-02f, 7.83404857e-02f, -7.84763396e-02f, -5.26020974e-02f,
  9.93870781e-04f, 1.59343779e-01f, 1.69965513e-02f, 1.58760324e-01f, -4.24221791e-02f, 3.98352742e-02f, -3.86734270e-02f, 5.14256116e-03f, 1.38543919e-01f, 9.41588134e-02f,
  4.39198166e-02f, -1.37674153e-01f, -7.55812451e-02f, -9.00877938e-02f, -2.94371806e-02f, 9.76797100e-03f, -8.80418271e-02f, 4.58514392e-02f, 1.61099304e-02f, 6.97165281e-02f,
  -4.48390730e-02f, -1.87402554e-02f, -6.45416901e-02f, 1.42406225e-02f, 2.16653086e-02f, -7.52383639e-05f, 4.32633907e-02f, 3.06599047e-02f, -6.52625039e-02f, 3.38936709e-02f,
  -1.77843235e-02f, 2.97660232e-02f, -5.68975471e-02f, 2.80194562e-02f, 6.63716942e-02f, 7.89415135e-05f, 5.86922280e-02f, 3.63196805e-02f, -3.94570865e-02f, 8.90523121e-02f,
  8.86514857e-02f, -4.19130689e-03f, -5.16379578e-03f, 3.16621512e-02f, -7.12625235e-02f, -5.57408482e-02f, 4.99445572e-02f, -2.68037561e-02f, -2.56617740e-02f, -8.51891655e-03f,
  -7.11328760e-02f, -4.49457876e-02f, 2.66057644e-02f, 8.75715911e-02f, -6.79664165e-02f, 5.23972027e-02f, -9.13513750e-02f, -1.09982528e-02f, 4.22939025e-02f, 6.88770860e-02f,
  -6.38021454e-02f, -1.97599875e-03f, -4.39166352e-02f, -8.95967111e-02f, 8.80355239e-02f, 6.18542619e-02f, -3.04501876e-02f, 4.50073108e-02f, -7.93104768e-02f, -4.88293171e-03f,
  -7.84826130e-02f, 1.51942857e-02f, 5.98588847e-02f, -6.65250570e-02f, 6.07684515e-02f, 4.18898389e-02f, 2.61724629e-02f, -3.48627456e-02f, -2.52660811e-02f, -3.14043686e-02f,
  -1.93529911e-02f, -8.13966915e-02f, 3.72829251e-02f, -1.86485592e-02f, 2.80704461e-02f, 2.75661014e-02f, -2.08023190e-02f, -1.78132243e-02f, -4.93083298e-02f, 8.02810937e-02f,
  -2.01459676e-02f, 8.78509358e-02f, 1.81041043e-02f, 7.86274597e-02f, -2.70711053e-02f, 8.24688934e-03f, -5.15059642e-02f, -2.81939004e-02f, -1.87519491e-02f, 5.64893223e-02f,
  1.99023202e-01f, -4.78317402e-02f, -1.42587289e-01f, -6.70344457e-02f, -1.36486903e-01f, -1.04013868e-01f, -8.57934058e-02f, -9.89733264e-02f, 3.52905976e-04f, 6.88068941e-02f,
  -9.24817398e-02f, 1.11326925e-01f, 6.19372353e-02f, -3.24537084e-02f, -3.22826728e-02f, -3.39271538e-02f, -1.03010960e-01f, 5.73661812e-02f, 1.06453989e-03f, 5.95923625e-02f,
  -6.67649414e-03f, -4.48043533e-02f, -9.00977254e-02f, -1.40997709e-03f, -1.19517751e-01f, 2.39925962e-02f, 5.19781299e-02f, 1.39274159e-02f, -1.01927795e-01f, 1.85439363e-02f,
  -7.05959722e-02f, -5.67380935e-02f, -4.72140051e-02f, 6.34999946e-02f, 8.23128819e-02f, 6.24262691e-02f, 4.50562648e-02f, -3.10164504e-02f, -3.59683074e-02f, 2.14942992e-02f,
  7.21257105e-02f, -8.31267983e-02f, -1.00902626e-02f, -1.95175465e-02f, 9.37932879e-02f, -3.39544527e-02f, -3.31807062e-02f, 7.56193027e-02f, -4.35067080e-02f, 8.02514851e-02f,
  9.57401544e-02f, 6.99018687e-02f, -7.82578140e-02f, -8.70682225e-02f, 6.87957034e-02f, -5.12661226e-02f, 1.08221425e-02f, -1.38032772e-02f, 7.79149979e-02f, -5.42093627e-03f,
  -3.60116921e-02f, 3.12651657e-02f, 2.32431218e-02f, 1.86565425e-02f, 5.79941692e-03f, -1.15362652e-01f, -6.96610138e-02f, -5.52172624e-02f, -9.30274799e-02f, 7.68803656e-02f,
  4.13310379e-02f, 3.90216010e-03f, 4.40823101e-02f, 7.93775357e-03f, -4.58303764e-02f, 7.43406191e-02f, 9.88983661e-02f, 5.42917401e-02f, -9.59622711e-02f, -3.99940945e-02f,
  -1.02090903e-01f, -6.52203523e-03f, -8.24010819e-02f, 1.64008681e-02f, -8.10085610e-02f, -6.24636263e-02f, 1.87314227e-02f, -5.34752980e-02f, -1.96417179e-02f, 8.64740387e-02f,
  -7.92651922e-02f, 4.75789933e-03f, -1.11903057e-01f, 6.38307333e-02f, 4.81016748e-02f, -6.73243031e-02f, -2.75986642e-02f, 6.35573640e-02f, -9.00128111e-02f, -1.59162991e-02f,
  4.44749631e-02f, -1.82581274e-03f, 9.11729783e-02f, -4.31007706e-02f, -4.98794168e-02f, 3.48924473e-02f, 5.09591475e-02f, -8.51301104e-03f, -7.06796274e-02f, -7.68900141e-02f,
  3.72279878e-03f, 1.10769589e-02f, 3.69806997e-02f, 5.39441146e-02f, -1.60688963e-02f, 1.22634480e-02f, -3.72545272e-02f, -6.49539530e-02f, -5.76316677e-02f, -3.89374816e-03f,
  -1.38365310e-02f, 5.44513911e-02f, 1.11832097e-01f, -3.91576700e-02f, -1.61457974e-02f, 1.41217396e-01f, 7.10380077e-02f, -1.47073716e-01f, -3.41904238e-02f, -1.17488084e-02f,
  -4.22866791e-02f, 1.32043347e-01f, -5.32794259e-02f, 7.03711733e-02f, 3.09034772e-02f, 6.82678074e-02f, -1.64737608e-02f, 1.49217278e-01f, 1.08797112e-02f, 1.23658972e-02f,
  5.52542228e-03f, -9.39382389e-02f, 5.77509217e-02f, -1.59802318e-01f, -5.64084649e-02f, -5.32790013e-02f, 2.86828168e-02f, 8.67062956e-02f, -6.67048171e-02f, 4.34218980e-02f,
  7.89592490e-02f, 6.62727281e-02f, 4.52619381e-02f, 9.48065743e-02f, -8.84862989e-02f, 6.39906526e-02f, 1.08597443e-01f, 3.62803787e-02f, -2.11202968e-02f, 5.14387991e-03f,
  4.75464948e-02f, -5.86364828e-02f, 1.18794870e-02f, 1.77282747e-02f, -3.74813527e-02f, 3.12262829e-02f, -7.65803531e-02f, -4.25335951e-02f, 8.56022537e-02f, 7.56479567e-03f,
  2.99963774e-03f, -4.43632156e-03f, 3.46302018e-02f, 1.07005596e-01f, 8.70158523e-02f, -6.13551866e-03f, 6.32474646e-02f, 5.97462729e-02f, 9.64317545e-02f, -1.58280581e-02f,
  -4.36977111e-02f, -4.57137004e-02f, -2.55784160e-03f, -5.04663140e-02f, 1.90833826e-02f, 5.02427388e-03f, -6.42862394e-02f, 2.19004258e-04f, 7.82953799e-02f, -2.63880789e-02f,
  7.65106753e-02f, 6.57024607e-02f, -2.12208331e-02f, -4.69333306e-02f, 2.64114067e-02f, -4.25031297e-02f, -4.52431338e-03f, 8.14370960e-02f, -2.74607893e-02f, -9.02960449e-02f,
  6.27944246e-02f, 1.11959353e-02f, 1.17799528e-02f, 1.85898617e-02f, -5.11199087e-02f, 2.17336249e-02f, 4.22549285e-02f, 3.00241783e-02f, 1.40939560e-02f, 4.87153865e-02f,
  -1.20330369e-03f, 4.76548523e-02f, 5.69613613e-02f, 6.18387770e-04f, -1.87404007e-02f, -5.42312898e-02f, 7.89342821e-02f, -8.16461071e-02f, 1.77557003e-02f, -8.17287415e-02f,
  -8.78901221e-03f, -4.79397476e-02f, 2.79937475e-03f, 2.71985237e-03f, 5.76347373e-02f, -9.50327292e-02f, 8.31613466e-02f, 8.50234367e-03f, -3.70701924e-02f, -7.98329264e-02f,
  6.80715516e-02f, 2.03280151e-02f, 9.88190472e-02f, -4.11065891e-02f, 4.67805658e-03f, -4.11321744e-02f, -2.98655760e-02f, 4.60362248e-02f, -7.32652238e-03f, 1.81022976e-02f,
  -4.92439419e-02f, -9.52799246e-02f, -1.42477825e-01f, 9.39806029e-02f, 1.13749452e-01f, 1.13075422e-02f, 3.69010754e-02f, 2.46375799e-02f, 7.19879642e-02f, 3.44156288e-02f,
  -9.05324966e-02f, -1.47294849e-01f, -1.73367396e-01f, 1.23843569e-02f, 8.81136283e-02f, -4.80312556e-02f, 5.20256720e-02f, -1.85122471e-02f, 6.62461743e-02f, -7.35833719e-02f,
  1.17940255e-01f, 9.78011265e-02f, 5.70377819e-02f, 3.37910913e-02f, -8.48590285e-02f, -4.37566498e-03f, 3.45649896e-03f, 3.89097212e-03f, 9.90513414e-02f, -2.65145730e-02f,
  4.98537719e-02f, -6.05207719e-02f, 2.52985172e-02f, 8.31747949e-02f, 4.25279215e-02f, 5.56001477e-02f, -1.85950231e-02f, 4.79131639e-02f, -9.22064669e-03f, 7.00431317e-03f,
  1.56577509e-02f, 1.36228846e-02f, 6.60709571e-04f, -2.68432554e-02f, 1.01258077e-01f, 3.47556956e-02f, -5.80809265e-02f, -3.82575989e-02f, -3.70507613e-02f, -7.06050694e-02f,
  -1.10231601e-01f, 7.01009203e-03f, 3.16054635e-02f, -5.58333397e-02f, -7.30181485e-02f, -4.00566831e-02f, -7.63271824e-02f, -1.16045587e-01f, -1.42759169e-02f, -2.80395616e-02f,
  -7.85325002e-03f, -2.08332743e-02f, -2.66437251e-02f, 5.52334078e-02f, 5.20374589e-02f, -3.63603048e-02f, 5.91813549e-02f, -7.72195533e-02f, 5.16012460e-02f, -8.80759880e-02f,
  -3.24034691e-02f, 8.10607374e-02f, -3.86241041e-02f, 5.92885837e-02f, 6.29747361e-02f, -7.05377311e-02f, 5.08154519e-02f, -5.22952266e-02f, -4.72794566e-03f, -5.90148307e-02f,
  -1.09458687e-02f, -2.66279615e-02f, 2.82076877e-02f, 9.56750587e-02f, 5.43085635e-02f, -6.43242002e-02f, 2.39659138e-02f, -7.20939562e-02f, 1.59455612e-02f, 4.32580411e-02f,
  -2.14920323e-02f, -6.81095496e-02f, 3.41933891e-02f, 2.10779421e-02f, 3.27390283e-02f, 6.65436164e-02f, -2.03670431e-02f, 6.06677569e-02f, -1.05065899e-02f, 2.70021278e-02f,
  -4.41632234e-02f, 3.43676247e-02f, 7.72192255e-02f, 1.57575088e-03f, -1.70860235e-02f, -9.50653777e-02f, -7.01638162e-02f, -2.62299199e-02f, 6.95156166e-03f, 4.09438573e-02f,
  3.26113030e-02f, -5.03318049e-02f, -9.91402566e-02f, 1.13463756e-02f, 5.94988987e-02f, -1.26474667e-02f, 3.27082798e-02f, -2.49060895e-02f, -8.16325098e-02f, -5.41267619e-02f,
  7.60435984e-02f, 9.27601457e-02f, -1.73365548e-01f, -5.25291860e-02f, -6.11890443e-02f, 1.81282163e-01f, 1.79216079e-02f, 1.01644300e-01f, -5.44647649e-02f, 1.39649346e-01f,
  -1.30444178e-02f, 3.61985974e-02f, 6.36079535e-02f, 2.30013534e-01f, -6.30802661e-03f, -2.53845565e-02f, 1.84461594e-01f, 7.94096738e-02f, -4.29991074e-02f, 9.00648460e-02f,
  3.62253152e-02f, 1.70481235e-01f, -9.92101207e-02f, -2.91523486e-02f, -1.15844365e-02f, -3.48379351e-02f, 3.10460720e-02f, -2.77115777e-02f, -9.02426615e-03f, -4.22134213e-02f,
  5.67187071e-02f, -3.39803956e-02f, -3.25310379e-02f, -5.07845059e-02f, -1.48621472e-02f, 3.05861537e-03f, -3.10211368e-02f, 5.93218803e-02f, 4.79362905e-02f, -3.23624946e-02f,
  2.33696010e-02f, -3.55986431e-02f, 2.39590537e-02f, -1.25806266e-02f, 2.37423219e-02f, 3.19227315e-02f, -3.84444110e-02f, -3.49429101e-02f, 2.29626913e-02f, 4.50521819e-02f,
  -1.12273544e-01f, -3.47151533e-02f, 2.85607316e-02f, -9.06993896e-02f, -7.67673850e-02f, -2.09153723e-02f, -1.78024828e-04f, 1.38445748e-02f, 2.60841362e-02f, -6.28077313e-02f,
  3.27572040e-02f, -8.43087360e-02f, -4.35377769e-02f, 4.07548621e-02f, 3.50593366e-02f, 5.81674986e-02f, 1.30182886e-02f, -8.80865604e-02f, -6.88253045e-02f, -7.10261520e-03f,
  -3.67063060e-02f, 4.13903370e-02f, 5.78202941e-02f, 6.99116811e-02f, 3.68262045e-02f, 2.13381276e-02f, -2.34778728e-02f, -7.68749639e-02f, -3.12016234e-02f, 2.02413928e-02f,
  5.97082712e-02f, 1.15149440e-02f, -1.81828197e-02f, -2.08244119e-02f, -5.29338755e-02f, 2.84313168e-02f, 1.97343789e-02f, 7.47660547e-02f, -1.71704926e-02f, -2.01857630e-02f,
  -2.49395240e-02f, 1.44316986e-01f, -8.02405085e-03f, -5.47856316e-02f, 1.18246758e-02f, -2.22397540e-02f, 2.35487963e-03f, 7.52871931e-02f, 4.84750606e-02f, 9.16415751e-02f,
  -4.48459797e-02f, 2.28487458e-02f, -2.93887723e-02f, 5.88789992e-02f, -4.94136028e-02f, 1.24535505e-02f, 7.40773454e-02f, 1.77968349e-02f, -4.20664325e-02f, -4.87287603e-02f,
  -6.90440685e-02f, 9.40767303e-02f, -6.55917525e-02f, 1.07281478e-02f, -4.09155758e-03f, -1.85728949e-02f, -4.87203933e-02f, -7.30057657e-02f, -5.88799715e-02f, 7.39940703e-02f,
  1.17455006e-01f, -1.06678545e-01f, -8.17688406e-02f, -1.27964079e-01f, -2.30370134e-01f, -7.21547678e-02f, 5.72621487e-02f, -1.67939276e-01f, 1.91310290e-02f, 9.86907184e-02f,
  -1.12316802e-01f, 9.71412808e-02f, 7.07927719e-02f, -5.76508716e-02f, 3.70585956e-02f, 1.71250626e-01f, 2.72617470e-02f, -4.34214398e-02f, 4.78541292e-02f, -5.16490676e-02f,
  -8.17063153e-02f, -8.54297355e-02f, 5.22977337e-02f, -1.66434556e-01f, -3.09749786e-02f, -1.49954129e-02f, 2.21705325e-02f, -1.11589879e-01f, -9.42060426e-02f, -6.96592778e-02f,
  -5.92476092e-02f, -1.40888395e-03f, -9.19425860e-02f, 2.25124415e-03f, 8.18026662e-02f, -4.59506027e-02f, -5.62384874e-02f, 3.40199582e-02f, 1.49420253e-03f, -6.91225305e-02f,
  -8.27323087e-03f, -8.63040388e-02f, 3.30298953e-02f, -6.48011863e-02f, 1.80831607e-02f, -8.10487121e-02f, -3.63363549e-02f, -4.90744673e-02f, 7.43421316e-02f, -6.12012409e-02f,
  -3.83020565e-02f, -9.65486318e-02f, -1.90615188e-02f, 2.90583968e-02f, 1.51195731e-02f, -1.20533844e-02f, 7.64885768e-02f, 6.70031011e-02f, -6.75888807e-02f, 1.02311196e-02f,
  3.26525643e-02f, -6.62222356e-02f, -5.54904379e-02f, -3.76655348e-02f, 7.18404725e-02f, -8.14258829e-02f, 1.40943415e-02f, -2.57696249e-02f, 2.53712200e-02f, 1.55795179e-02f,
  -4.20473926e-02f, -1.70547552e-02f, 7.84582123e-02f, 1.99891441e-03f, -4.30854186e-02f, -1.06506227e-02f, 1.04052171e-01f, -5.51228831e-03f, 3.05120256e-02f, -2.46711262e-02f,
  4.06779954e-03f, -2.70009991e-02f, 1.17919352e-02f, 5.04120886e-02f, 2.94860136e-02f, 6.00088723e-02f, -2.03143060e-02f, 4.77910973e-02f, 3.86623293e-02f, -3.29976268e-02f,
  -8.71827751e-02f, -1.08464308e-01f, -1.24339771e-03f, 2.67959293e-02f, 4.54748562e-03f, -2.72475779e-02f, -1.63377281e-02f, 3.81007269e-02f, 7.15503236e-03f, -8.31770673e-02f,
  -5.22854179e-02f, 4.19758856e-02f, -7.37003610e-02f, 1.12625388e-02f, -9.32282284e-02f, 8.40281025e-02f, 6.23891130e-02f, 5.80295213e-02f, -4.69598435e-02f, -8.57654288e-02f,
  5.57638109e-02f, 5.86102754e-02f, 7.79933482e-02f, -9.24725737e-03f, 3.91374268e-02f, 4.17046025e-02f, -1.95159819e-02f, -1.50458412e-02f, -4.55067027e-03f, -5.46470508e-02f,
  -4.95406277e-02f, -4.04358841e-02f, -1.02700181e-01f, 2.75401808e-02f, -6.03139400e-02f, -2.31426805e-01f, -9.40970182e-02f, 1.00874305e-01f, -1.54526398e-01f, 2.94103771e-02f,
  8.81308597e-03f, -7.52006173e-02f, 8.30775946e-02f, 3.83208618e-02f, 4.69910018e-02f, -5.83690852e-02f, -2.78122667e-02f, -4.51400988e-02f, 2.18498670e-02f, 4.85412478e-02f,
  1.49174303e-01f, 1.06422774e-01f, 3.73264030e-02f, 9.32532921e-02f, -1.75879151e-02f, 3.46233733e-02f, 2.25060850e-01f, 8.96423832e-02f, 5.18125258e-02f, -5.85882813e-02f,
  4.93793897e-02f, 2.57516317e-02f, -5.78662343e-02f, -5.19694239e-02f, 8.50843862e-02f, -8.79852250e-02f, -5.39129339e-02f, 4.14990447e-02f, -6.35295035e-03f, 4.44004918e-03f,
  -3.45195979e-02f, 1.83836240e-02f, 3.40744630e-02f, 3.46540399e-02f, -5.74066713e-02f, -4.65366505e-02f, 7.04146102e-02f, -9.25327390e-02f, -1.48279523e-03f, -5.01588508e-02f,
  7.38558248e-02f, -6.68158159e-02f, -4.94459309e-02f, 5.19462908e-03f, 5.84622100e-02f, 2.39932574e-02f, -4.06255899e-03f, 7.28105605e-02f, 2.43297033e-02f, 5.12562282e-02f,
  7.37090856e-02f, 4.87886649e-03f, -2.50826986e-03f, -8.54115933e-03f, -3.83870751e-02f, 1.83287729e-02f, 5.15585877e-02f, 3.15147191e-02f, -7.71015063e-02f, -6.21850230e-02f,
  9.62533355e-02f, -7.16613457e-02f, 2.52174363e-02f, 5.95438257e-02f, -9.38197784e-03f, 4.22856398e-02f, -2.70195655e-03f, -1.51648941e-02f, -4.29383432e-03f, -6.58511594e-02f,
  4.15509082e-02f, -7.08780065e-02f, 7.47848954e-03f, 8.32964778e-02f, -7.30061084e-02f, 2.13653618e-03f, 1.13058522e-01f, -7.01637343e-02f, -2.36795228e-02f, 9.50146653e-03f,
  9.21907574e-02f, 2.85421908e-01f, 1.54926907e-02f, 1.31838704e-02f, -3.19188014e-02f, -6.90169409e-02f, -8.09666514e-02f, -1.12908818e-02f, 1.23103848e-02f, 3.46518978e-02f,
  5.40965088e-02f, 2.11708620e-02f, -2.90602036e-02f, 3.23545523e-02f, 7.48551562e-02f, 2.59547066e-02f, 3.88714299e-02f, 7.15986043e-02f, -8.23576152e-02f, 1.10235885e-01f,
  7.11324215e-02f, 4.94644651e-03f, -5.29091656e-02f, 1.99815650e-02f, 1.01087786e-01f, 6.39523985e-03f, 1.05421143e-02f, 8.90347585e-02f, 2.43109884e-03f, -4.56288718e-02f,
  -9.01259556e-02f, 7.42758214e-02f, -7.73143545e-02f, -1.14504240e-01f, 7.25108460e-02f, -6.20881133e-02f, -6.52242824e-02f, 1.03976175e-01f, -8.38157663e-04f, -4.91406992e-02f,
  -2.91058030e-02f, 1.10014819e-01f, 6.72887117e-02f, -7.98295364e-02f, -8.53526816e-02f, -6.51616156e-02f, 7.99694434e-02f, 3.77565287e-02f, -1.14969397e-02f, 9.94310305e-02f,
  4.74465601e-02f, 2.53907740e-02f, -5.77715151e-02f, 1.57334991e-02f, 9.05557945e-02f, 1.95255806e-03f, 9.83006060e-02f, 1.01918310e-01f, 1.24307066e-01f, 1.09027140e-01f,
  -2.86875870e-02f, -4.09735404e-02f, -4.92330007e-02f, 8.72330889e-02f, 4.44181561e-02f, 2.70250961e-02f, 2.36703604e-02f, -7.21212253e-02f, 6.50656894e-02f, 8.41710716e-02f,
  4.74201143e-02f, -1.42798256e-02f, -2.45680921e-02f, -7.26930052e-02f, -2.30326746e-02f, 1.02602705e-01f, -4.26134355e-02f, 1.05579365e-02f, 6.61462871e-03f, 4.91649099e-02f,
  -9.27620903e-02f, -8.47055316e-02f, 3.66890021e-02f, 8.36609900e-02f, -7.79973343e-02f, -4.74459827e-02f, 4.64793891e-02f, 9.43753794e-02f, 6.05013557e-02f, 2.74287574e-02f,
  -8.72381777e-03f, -4.50111218e-02f, -6.28242716e-02f, -8.80967826e-03f, 6.76757395e-02f, -8.75435621e-02f, 6.12321235e-02f, -5.84097356e-02f, 5.14623243e-03f, 6.26726449e-02f,
  2.54600551e-02f, 5.30669987e-02f, 2.38323007e-02f, -7.16700871e-03f, 3.61597501e-02f, 5.07804751e-02f, 4.44165757e-03f, 2.54439954e-02f, -6.02910556e-02f, 7.75381401e-02f,
  -8.38222951e-02f, 1.00682965e-02f, 8.48886371e-02f, -5.42245544e-02f, 7.13250935e-02f, 2.94825900e-02f, -6.96928725e-02f, -2.18058936e-03f, 7.77783915e-02f, 1.11308320e-04f,
  4.11811434e-02f, 1.01339303e-01f, -3.84415872e-02f, 4.56269272e-02f, 3.30369174e-02f, -3.02589908e-02f, 4.90730144e-02f, 6.69087619e-02f, -1.00481883e-01f, -4.05076705e-02f,
  7.63192177e-02f, 7.26419408e-03f, 3.79760470e-03f, -5.16185984e-02f, 3.42318378e-02f, 2.20624357e-02f, 2.43293662e-02f, -9.85793695e-02f, 1.26548167e-02f, -5.25464416e-02f,
  7.04090446e-02f, 4.82504964e-02f, -2.78089419e-02f, 4.75833192e-02f, -9.82497260e-02f, -5.27978837e-02f, 7.34916553e-02f, -1.25884917e-02f, -4.68847826e-02f, 6.46362603e-02f,
  1.84461884e-02f, 1.17002971e-01f, -1.38134155e-02f, 7.37550855e-02f, -5.64681329e-02f, -1.07162014e-01f, -1.13176577e-01f, -1.41891241e-02f, 4.08869470e-03f, -6.42168000e-02f,
  1.57808345e-02f, 1.38202667e-01f, 6.32532965e-03f, 4.03309613e-02f, 1.18945591e-01f, -6.30231276e-02f, 1.33018419e-01f, 5.24869040e-02f, 1.24290958e-01f, 1.76771522e-01f,
  1.54223636e-01f, 1.15508065e-01f, 1.04206175e-01f, 1.13949686e-01f, -5.47720455e-02f, 1.16063453e-01f, 9.31332931e-02f, -8.26597214e-02f, 8.90763178e-02f, 2.06763088e-03f,
  -8.50935355e-02f, 5.29827252e-02f, -3.68357562e-02f, 1.91405304e-02f, -7.81655759e-02f, 3.25570535e-03f, -2.38067545e-02f, -7.97778070e-02f, 1.12137578e-01f, -3.73207331e-02f,
  -6.47407910e-03f, 6.63795695e-02f, 7.74101773e-03f, -6.99893385e-03f, 5.58242202e-02f, 4.59414683e-02f, -2.92026009e-02f, -6.23009764e-02f, 8.83786287e-03f, -2.79906206e-02f,
  2.58443560e-02f, -5.12749441e-02f, 8.02602991e-02f, -2.58738338e-03f, 8.24651718e-02f, -6.55207187e-02f, -7.13199005e-02f, 3.72635014e-02f, -1.02263065e-02f, 8.91296715e-02f,
  7.81058297e-02f, 5.85929677e-02f, 5.31012714e-02f, 1.00387193e-01f, -3.79181607e-03f, 6.71371631e-03f, -8.66034348e-03f, -4.64437455e-02f, 2.88767423e-02f, 3.74071933e-02f,
  2.12035887e-02f, -6.42536432e-02f, 4.82024401e-02f, 3.75410542e-02f, 4.78705764e-02f, 5.74880429e-02f, -3.72586623e-02f, 5.94314970e-02f, 4.60924916e-02f, -5.82043789e-02f,
  -3.61623056e-02f, 2.28661504e-02f, 1.87746864e-02f, 2.76772864e-02f, -9.36602056e-03f, -5.41893169e-02f, -2.26577949e-02f, 1.96302719e-02f, 4.89819795e-02f, 5.41724823e-02f,
  8.75455216e-02f, 1.76789999e-01f, -7.16519579e-02f, 2.82946397e-02f, 2.50499841e-04f, 1.26555692e-02f, 7.09099509e-03f, 3.30707692e-02f, 1.85124688e-02f, -4.58321609e-02f,
  6.83737695e-02f, -3.32206786e-02f, -9.16823596e-02f, 3.45176458e-02f, -4.27308977e-02f, 8.92341062e-02f, 5.16576804e-02f, 4.16055545e-02f, -4.08712178e-02f, -5.10416143e-02f,
  5.59164844e-02f, -1.16424643e-01f, -2.31508259e-02f, 9.26347263e-03f, -4.30612601e-02f, 3.14925052e-02f, -3.68377231e-02f, -6.01707548e-02f, -7.32580125e-02f, 4.31316830e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.93669489e-02f, 1.30471736e-01f, 7.45414197e-02f, 3.19229439e-02f, -2.08458453e-02f, 9.76089984e-02f, 6.71810433e-02f, -6.11746870e-03f, -4.17713597e-02f, 4.39657532e-02f,
  8.66826251e-02f, 9.26079229e-02f, -4.92114313e-02f, 3.69223729e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.26985654e-02f, -5.24234511e-02f, 3.09998617e-02f, -8.17456990e-02f, 7.58456066e-02f, -1.10290773e-01f, 1.24842152e-01f, 1.40069202e-01f, -7.06396401e-02f, -4.80387397e-02f,
  -1.37784511e-01f, -8.23169947e-02f, -6.67387396e-02f, 1.41439657e-03f, -1.02832504e-01f, -3.06236967e-02f, -7.30545670e-02f, -4.43881713e-02f, -1.09409153e-01f, 1.25189617e-01f,
  9.49287191e-02f, 2.03870628e-02f, 1.35177732e-01f, -1.92426115e-01f, -6.32964075e-02f, -1.41034331e-02f, -2.19298244e-01f, -1.05122980e-02f, -2.41461366e-01f, -1.84747383e-01f,
  2.02556267e-01f, 5.93451150e-02f, -1.48655176e-01f, -6.32094666e-02f, -7.83724785e-02f, -2.21447069e-02f, 1.19666167e-01f, -2.58914024e-01f, -1.82643272e-02f, 2.26624176e-01f,
  -1.61003992e-01f, 6.25990108e-02f, -8.20071101e-02f, -7.52235055e-02f, -8.52207169e-02f, 2.19354928e-01f, -1.53439552e-01f, -1.73877642e-01f, -1.58757970e-01f, -7.07754344e-02f,
  -3.32955532e-02f, 2.50620376e-02f, 7.23181441e-02f, 4.98805530e-02f, -2.86017787e-02f, -1.03320971e-01f, -5.27454987e-02f, -9.36826598e-03f, 7.19781071e-02f, 3.66691239e-02f,
  -5.77866770e-02f, 4.80593294e-02f, 4.72134054e-02f, 1.19662911e-01f, 1.16055392e-01f, -1.38741601e-02f, 7.41083696e-02f, 1.29216075e-01f, 1.77311942e-01f, 6.11337870e-02f,
  1.28542572e-01f, 1.27866909e-01f, 1.70455441e-01f, 6.85915537e-03f, 1.55955121e-01f, -1.48764253e-02f, 1.41085654e-01f, 1.01163492e-01f, -9.86967469e-04f, 7.18552470e-02f,
  4.83094156e-03f, 1.19180448e-01f, 6.58186898e-02f, 1.51006401e-01f, -1.11939326e-01f, -2.91467141e-02f, 5.02734184e-02f, -4.35331948e-02f, 1.16989426e-01f, 9.93628874e-02f,
  -2.62958501e-02f, -3.10126878e-02f, -1.59506232e-01f, -2.21693501e-01f, -3.53967175e-02f, -2.18907952e-01f, 1.52420267e-01f, -1.19532041e-01f, -5.70721626e-02f, 2.02597111e-01f,
  -4.82530594e-02f, -1.35554850e-01f, 1.48443803e-01f, -3.27127069e-01f, 1.20388843e-01f, 1.34113550e-01f, 8.81523713e-02f, 7.53941946e-04f, 1.22797064e-01f, -2.88259145e-02f,
  7.18712881e-02f, 1.76946566e-01f, 2.76543289e-01f, 5.83682768e-02f, -1.58123538e-01f, -1.83133893e-02f, -1.42937839e-01f, 8.29417109e-02f, -3.66880447e-02f, 7.08662346e-02f,
  -3.16814892e-02f, 1.53014153e-01f, 9.46559086e-02f, -9.72626582e-02f, 6.24195561e-02f, -1.13262668e-01f, -1.32870719e-01f, 9.27849486e-03f, -1.04262177e-02f, -8.44275355e-02f,
  -8.73211548e-02f, -1.93942934e-02f, 1.69747263e-01f, 7.93733522e-02f, -1.90011617e-02f, 7.77027681e-02f, -1.24245413e-01f, 1.69112831e-01f, -5.56115285e-02f, 4.28068712e-02f,
  -6.63552657e-02f, 3.19739059e-02f, -3.22815292e-02f, -1.30623933e-02f, -8.69946852e-02f, -3.73748392e-02f, 4.16503884e-02f, 9.11040511e-03f, 1.16336577e-01f, -8.80184844e-02f,
  -7.40237683e-02f, -9.79326293e-02f, 1.24465406e-01f, 1.65918782e-01f, -1.33629948e-01f, 6.30802661e-02f, -1.49252012e-01f, -1.45269394e-01f, -3.10844965e-02f, 8.38012062e-03f,
  -3.97400409e-02f, -8.35567489e-02f, 1.48767754e-01f, 2.11962044e-01f, 6.52124956e-02f, -1.82854190e-01f, 1.92748532e-01f, -8.05115402e-02f, -1.26826257e-01f, 1.92303866e-01f,
  -1.99044198e-01f, -6.25659674e-02f, -3.76194119e-02f, 1.14504457e-01f, 2.87622605e-02f, -1.52924910e-01f, 4.81754839e-02f, -1.55627877e-01f, -4.40367609e-02f, 1.14810534e-01f,
  1.74652696e-01f, 4.67427038e-02f, -4.44675162e-02f, 3.97044457e-02f, 1.24283522e-01f, 4.96396832e-02f, 1.03913687e-01f, 1.32034808e-01f, 1.66978277e-02f, 3.87670770e-02f,
  -3.12373042e-02f, -1.47438422e-01f, -8.08802545e-02f, -8.56687427e-02f, -1.36847153e-01f, -3.11016627e-02f, 7.00133592e-02f, -1.06491685e-01f, 9.51490253e-02f, 5.67986928e-02f,
  -7.03693330e-02f, 1.19011939e-01f, -1.58484295e-01f, -1.25816897e-01f, -1.10197812e-01f, 1.88677832e-02f, -5.63511532e-03f, -2.09903508e-01f, -1.70455694e-01f, -1.08954668e-01f,
  -1.44703314e-01f, -8.78579170e-03f, -9.20841768e-02f, -1.85336873e-01f, 2.24807598e-02f, -1.70246914e-01f, -2.36516185e-02f, 6.56974167e-02f, -1.44090369e-01f, -3.47461998e-02f,
  -2.25173354e-01f, -2.96727978e-02f, -8.61260369e-02f, 9.58708897e-02f, -1.18408397e-01f, 3.30833234e-02f, 1.34414032e-01f, 3.91734205e-02f, -8.21439922e-02f, -2.62168229e-01f,
  5.41271195e-02f, -4.43214700e-02f, -1.54297620e-01f, 8.63145739e-02f, -1.28518507e-01f, 6.07650504e-02f, 2.05629081e-01f, 4.69730608e-02f, -1.71909705e-01f, -2.19716690e-02f,
  1.22506909e-01f, 1.35541841e-01f, -1.31851211e-01f, 5.48081771e-02f, 4.30861441e-03f, -4.82729077e-02f, -3.29702767e-03f, 1.26931548e-01f, -9.27137807e-02f, -9.57071036e-02f,
  3.85528952e-02f, 1.68617032e-02f, 3.50526422e-02f, -4.07522507e-02f, 5.31019233e-02f, -1.24651855e-02f, -1.99731458e-02f, -7.83190280e-02f, -1.15916915e-01f, -1.95939224e-02f,
  5.18089347e-02f, 2.52789631e-02f, -1.24081068e-01f, -9.83958319e-02f, -1.42994568e-01f, -5.48847131e-02f, 3.83054502e-02f, -6.27806038e-02f, -2.83396542e-02f, -6.63264841e-02f,
  1.53707370e-01f, -4.10759300e-02f, -8.96345004e-02f, -1.04073234e-01f, -1.03958674e-01f, -2.60467771e-02f, 5.41581959e-02f, 1.17681980e-01f, 9.08893794e-02f, -4.43181023e-02f,
  2.84470543e-02f, 1.19111225e-01f, -1.98632970e-01f, 5.24959378e-02f, 1.42584398e-01f, 1.76092470e-03f, -1.98649883e-01f, -7.82930404e-02f, -1.80705022e-02f, 6.81702942e-02f,
  1.24092489e-01f, 2.25058377e-01f, -8.11660588e-02f, 1.88647658e-02f, 9.88785475e-02f, 1.03780270e-01f, -2.55792409e-01f, 8.72110017e-03f, -1.25989601e-01f, 7.11158589e-02f,
  -1.74413055e-01f, 2.96778530e-01f, 1.14556309e-02f, -7.81014711e-02f, 7.18183815e-02f, -1.27811641e-01f, -1.41303703e-01f, -2.95318104e-02f, 3.25612307e-01f, -6.16632681e-03f,
  1.19045138e-01f, -1.00405954e-01f, 5.00294305e-02f, 8.77164677e-02f, 5.46255633e-02f, 2.27673411e-01f, -2.87031494e-02f, -2.90626232e-02f, 9.23260301e-02f, 4.96303737e-02f,
  1.12628482e-01f, 5.47876284e-02f, 1.84918698e-02f, -1.20983541e-01f, -1.22894228e-01f, 5.14590740e-02f, -1.66208550e-01f, 1.25529114e-02f, -4.01746854e-02f, -2.01938916e-02f,
  1.58061475e-01f, 8.97989273e-02f, 2.21433088e-01f, 1.05481576e-02f, -5.42215183e-02f, 4.27548354e-03f, 1.59842670e-01f, -5.63243479e-02f, -1.78515855e-02f, -1.11806400e-01f,
  -1.85611963e-01f, 8.44302848e-02f, 3.73998694e-02f, 4.64413352e-02f, 5.28678903e-03f, -1.11070693e-01f, 1.73972800e-01f, -1.59708381e-01f, 6.92464188e-02f, -8.48984644e-02f,
  3.90178114e-02f, -7.97068626e-02f, 2.41152063e-01f, 6.63351342e-02f, -1.70283206e-02f, -1.26964776e-02f, 1.24411501e-01f, -9.67585146e-02f, 6.36742637e-02f, -1.49574623e-01f,
  3.20500970e-01f, 1.29659086e-01f, 8.91697556e-02f, 1.62098750e-01f, -7.61723565e-03f, -1.69809222e-01f, 8.23593661e-02f, 4.79352139e-02f, 1.83900580e-01f, -3.79140526e-02f,
  -1.03735380e-01f, -6.15802072e-02f, -1.07205607e-01f, 3.88326570e-02f, -8.08484629e-02f, -1.69875219e-01f, -6.86357245e-02f, 1.34665459e-01f, -8.08590129e-02f, -5.29793948e-02f,
  -2.88704433e-03f, -1.44922972e-01f, -8.23618546e-02f, -9.29271728e-02f, -1.17264271e-01f, 1.11447752e-01f, -4.35999557e-02f, -3.95035297e-02f, -9.35606360e-02f, -1.49454772e-01f,
  1.21710193e-03f, 4.96745817e-02f, -8.79315138e-02f, 6.38275221e-02f, -2.09869951e-01f, -6.56486750e-02f, -1.81900918e-01f, -2.84013525e-02f, -7.59138959e-03f, -1.27940476e-01f,
  4.24698628e-02f, -7.86847025e-02f, 2.05772370e-02f, 3.97456475e-02f, 2.80098952e-02f, -1.21116579e-01f, -2.85730977e-02f, -8.71592835e-02f, -3.15886289e-02f, 4.74992730e-02f,
  -3.98591124e-02f, 1.10177971e-01f, -8.16940889e-02f, 3.02481204e-01f, 1.88271480e-03f, -6.25587776e-02f, -1.31653786e-01f, 1.70499936e-01f, 7.45597482e-02f, -1.06833585e-01f,
  -8.16314220e-02f, 1.01420522e-01f, -1.85769826e-01f, 1.49641082e-01f, -4.34489064e-02f, -2.30555952e-01f, -5.96941449e-02f, -5.43423705e-02f, 3.06613371e-02f, 2.40692645e-02f,
  -9.59116779e-03f, -1.04996912e-01f, -2.74282575e-01f, 1.32176772e-01f, 9.73476395e-02f, -2.82180924e-02f, -1.68168381e-01f, -7.32263848e-02f, -4.24567051e-02f, 1.28290057e-01f,
  5.37955239e-02f, 2.76224855e-02f, -1.42802775e-01f, -3.29502975e-03f, -4.34502065e-02f, 2.24479035e-01f, 1.09126791e-01f, 8.17841589e-02f, 4.81045954e-02f, 2.25354992e-02f,
  -6.60558417e-02f, -2.45231204e-02f, 3.23066302e-02f, -9.27118212e-02f, 7.39335343e-02f, -1.19626792e-02f, -1.69421688e-01f, 3.60429310e-03f, -1.30383864e-01f, 3.67025957e-02f,
  -9.82881486e-02f, 7.11370111e-02f, 6.90670088e-02f, -1.41763641e-02f, 3.67963947e-02f, 5.68492860e-02f, -1.03981942e-01f, 1.52647877e-02f, -1.30676404e-02f, -1.11428417e-01f,
  1.14684999e-01f, -1.32671684e-01f, 8.31979737e-02f, -9.33783129e-02f, -1.28120184e-01f, 7.22629279e-02f, 4.45016334e-03f, 1.59856141e-01f, -1.53867006e-01f, 3.54916826e-02f,
  -2.79751718e-01f, -3.44582722e-02f, 2.12545261e-01f, 1.18342191e-01f, -1.47816196e-01f, -1.60626665e-01f, 5.49948402e-02f, 4.11882326e-02f, -1.92278072e-01f, 8.42289627e-02f,
  -2.43810862e-01f, 2.04903353e-02f, 1.84191335e-02f, 5.85708991e-02f, 7.68853053e-02f, -9.65173095e-02f, -1.63715914e-01f, 2.98391115e-02f, 1.36783764e-01f, 1.45953193e-01f,
  -1.07367963e-01f, 8.13436061e-02f, 5.86479418e-02f, 2.25805677e-02f, -1.12569079e-01f, -9.72362012e-02f, 1.01821013e-01f, 5.23872636e-02f, 4.14824598e-02f, 1.58053339e-01f,
  -6.64265975e-02f, -2.92248614e-02f, -1.36992401e-02f, -1.38076216e-01f, -1.03955023e-01f, 4.58287969e-02f, -9.60183963e-02f, 6.90349489e-02f, -5.84763587e-02f, -2.29290947e-02f,
  6.88963532e-02f, -6.14761226e-02f, -2.31486946e-01f, -1.09931715e-01f, -1.17554970e-01f, -7.80205280e-02f, -4.87494282e-03f, -1.11849979e-01f, -9.19920858e-03f, 6.20336756e-02f,
  -8.64252970e-02f, 4.99097072e-03f, 1.13304168e-01f, -2.70437170e-03f, 1.44595087e-01f, -1.29178248e-03f, -8.76010582e-02f, -1.18125051e-01f, -1.05647251e-01f, 9.25069004e-02f,
  5.14760762e-02f, -6.35113055e-03f, -4.27414514e-02f, 6.79734349e-02f, -6.73274472e-02f, 5.44119701e-02f, -2.95071572e-01f, -2.49909922e-01f, 1.11162804e-01f, 2.59180784e-01f,
  8.96748826e-02f, 1.56275511e-01f, 4.80739549e-02f, -9.21882540e-02f, 1.20884404e-02f, -7.07158074e-02f, -2.03318253e-01f, 6.19150102e-02f, 2.09034048e-03f, -1.91756219e-01f,
  8.88618082e-02f, -2.24140510e-01f, 7.48243555e-02f, -7.70054534e-02f, 2.24452272e-01f, -1.47111705e-02f, 4.83656153e-02f, -6.81691989e-02f, 2.12697223e-01f, 2.76986440e-03f,
  -5.44326268e-02f, 5.74567728e-02f, -1.85286105e-02f, 1.48371579e-02f, -7.16668963e-02f, 9.09980163e-02f, -2.03459769e-01f, 4.26910445e-02f, -3.52556072e-02f, 4.50331457e-02f,
  3.03298119e-03f, -1.31483257e-01f, -1.39857829e-01f, -5.32918945e-02f, 5.47029600e-02f, -1.31470948e-01f, -9.63957235e-02f, 2.74198484e-02f, 4.55889627e-02f, -1.10082343e-01f,
  -1.53214410e-01f, -1.71647370e-01f, -1.49166062e-01f, 3.78720462e-02f, 3.76094505e-02f, 9.50065162e-03f, 5.13016954e-02f, -2.01692984e-01f, -1.05518371e-01f, -3.49536277e-02f,
  -9.46265161e-02f, -1.08265780e-01f, -4.64669019e-02f, -1.80039048e-01f, 3.81521173e-02f, -1.59638464e-01f, 1.57120511e-01f, -7.69467503e-02f, 1.43904462e-01f, -1.69303566e-01f,
  -8.84682611e-02f, -1.34708345e-01f, 1.47009298e-01f, -2.48521015e-01f, -9.49046575e-03f, -4.45496989e-03f, -1.94393098e-01f, 2.61653006e-01f, -4.38347794e-02f, -1.90199558e-02f,
  9.62709635e-02f, 1.36638105e-01f, -2.11457878e-01f, -7.54183605e-02f, 5.13674431e-02f, -1.65726304e-01f, 1.73689947e-02f, 9.59362313e-02f, 1.52352557e-01f, 6.40449524e-02f,
  -9.10813268e-03f, 4.28150818e-02f, 1.70952324e-02f, -7.49141797e-02f, 5.97867109e-02f, 2.77944617e-02f, -1.77353751e-02f, 6.47956654e-02f, -1.06715942e-02f, 1.95650786e-01f,
  -5.68790399e-02f, -9.08819810e-02f, 2.31340621e-02f, -4.24444415e-02f, 1.18351102e-01f, 7.14550689e-02f, -2.81073209e-02f, 3.35749872e-02f, -1.57182723e-01f, 8.93617049e-03f,
  -1.08613566e-01f, -1.47163644e-02f, -4.93138507e-02f, 8.73503238e-02f, 5.30675016e-02f, -7.42447749e-02f, 5.90999164e-02f, -9.24413055e-02f, 4.08523679e-02f, 1.21114500e-01f,
  -9.38609242e-03f, 7.27391541e-02f, -8.98794904e-02f, -4.05925959e-02f, 8.47753957e-02f, 1.17645018e-01f, -1.99291304e-01f, 4.53070365e-02f, 1.37587994e-01f, 1.33046582e-01f,
  -1.57307461e-01f, 1.85551047e-01f, -3.56284864e-02f, -5.16663343e-02f, -6.20107576e-02f, 1.58126101e-01f, -4.47803400e-02f, -1.88020453e-01f, -1.23186380e-01f, 1.35917708e-01f,
  -1.22655630e-01f, 1.85925767e-01f, -2.03444138e-01f, -1.47598669e-01f, -1.20005943e-01f, 1.23682968e-01f, -2.07534549e-03f, -1.46534815e-01f, 1.17865242e-02f, 7.97234699e-02f,
  2.59254314e-02f, -6.63141012e-02f, 2.49641389e-01f, 3.24667059e-02f, 1.01927117e-01f, 2.94361152e-02f, 1.65566042e-01f, 3.59554887e-02f, -4.76871319e-02f, 1.37286931e-01f,
  7.05341697e-02f, -1.12160899e-01f, -6.68630973e-02f, -1.27490237e-01f, -5.75072989e-02f, 6.44418523e-02f, -3.69550101e-02f, 1.03168570e-01f, 4.08490486e-02f, 8.52501094e-02f,
  -6.36365041e-02f, 2.92714480e-02f, 6.41473979e-02f, -4.66047041e-02f, -3.33593786e-02f, -7.47012421e-02f, -1.08828723e-01f, 1.07251547e-01f, 1.39544070e-01f, -2.00574155e-04f,
  -1.22012198e-01f, 2.18121093e-02f, -7.76091367e-02f, -1.20789722e-01f, -1.01481162e-01f, -6.45164168e-03f, -1.50183648e-01f, -1.89879626e-01f, -1.19566783e-01f, 1.99646875e-01f,
  -8.50382596e-02f, 1.94247454e-01f, 1.50879830e-01f, -1.47606820e-01f, -1.05952024e-01f, -1.68745726e-01f, -1.43347727e-02f, 7.49863461e-02f, -1.27236515e-01f, -4.73361388e-02f,
  -2.81431712e-02f, 1.82712018e-01f, 2.63283968e-01f, -1.36455148e-01f, -8.41363072e-02f, -4.35214415e-02f, 9.45308506e-02f, -1.99784525e-03f, -7.56467506e-03f, -6.44183457e-02f,
  6.96104690e-02f, 1.88063439e-02f, 9.00778547e-02f, 6.77131563e-02f, 2.09853109e-02f, -1.74643874e-01f, 1.65090397e-01f, 3.80984768e-02f, -2.10576411e-02f, -6.73963502e-02f,
  1.22514911e-01f, 3.73477824e-02f, -8.51082802e-02f, -3.27931009e-02f, 8.12662542e-02f, 1.83269847e-02f, 1.39569985e-02f, -1.03535414e-01f, 6.95408285e-02f, -3.38597409e-02f,
  6.29087612e-02f, -4.94381450e-02f, -1.77510396e-01f, -1.35926381e-01f, 1.66226357e-01f, 2.29722671e-02f, -1.12341151e-01f, 4.23062108e-02f, -7.90952370e-02f, -1.30081341e-01f,
  -1.79028930e-03f, 1.47079185e-01f, 7.39676952e-02f, 8.49598870e-02f, -6.04864769e-02f, -4.64149974e-02f, 4.53332551e-02f, -1.37527972e-01f, 1.44956321e-01f, 1.24161460e-01f,
  -8.36980492e-02f, 1.15246149e-02f, -1.81802601e-01f, -3.30522321e-02f, -1.71879306e-02f, 3.10752280e-02f, -2.13829838e-02f, 1.44029319e-01f, -1.16295286e-01f, -2.32528634e-02f,
  -3.98706570e-02f, -3.15961167e-02f, -1.11608610e-01f, -1.37265071e-01f, -1.11613795e-01f, 3.00698966e-01f, -8.74156207e-02f, 1.66543331e-02f, -2.16577902e-01f, -2.59002060e-01f,
  9.98557955e-02f, 9.94579047e-02f, 5.04526831e-02f, 1.23498686e-01f, 1.57752886e-01f, -2.75238212e-02f, 3.71006913e-02f, -9.58642177e-03f, 1.80022880e-01f, -9.98764187e-02f,
  2.34849881e-02f, 1.28751278e-01f, 5.35437241e-02f, 9.82664432e-03f, -4.87133749e-02f, -1.61102846e-01f, 9.31378603e-02f, -1.15509806e-02f, -1.66377172e-01f, 1.68371219e-02f,
  1.37918487e-01f, 9.68812704e-02f, 1.44623697e-01f, -1.45660967e-01f, -9.83842090e-02f, -3.33331451e-02f, -5.51986024e-02f, -3.25683802e-02f, -6.64455071e-02f, -1.51410758e-01f,
  -5.83808422e-02f, 9.58200917e-02f, -3.72426445e-03f, 7.82119930e-02f, -3.18077505e-02f, 7.13160485e-02f, 4.40779775e-02f, 2.26598009e-02f, 9.88357589e-02f, -3.17725204e-02f,
  -1.42161593e-01f, 7.90064931e-02f, 1.71649065e-02f, -4.67357971e-02f, -1.37907222e-01f, -7.06195273e-03f, -6.28996566e-02f, 1.57761306e-01f, -7.54171386e-02f, -8.75490811e-03f,
  1.19830063e-02f, -7.65593499e-02f, -1.26200274e-01f, 1.00535840e-01f, 8.04898664e-02f, -8.18126425e-02f, -1.90822892e-02f, 2.84011424e-01f, 1.02733254e-01f, -1.38949454e-01f,
  1.10412769e-01f, -1.68347046e-01f, 8.85162428e-02f, 1.42137364e-01f, -1.14013225e-01f, 8.53191689e-02f, 3.80430669e-02f, -7.83665553e-02f, -1.30570710e-01f, 6.41566217e-02f,
  2.49507800e-01f, -1.38532132e-01f, -5.67842126e-02f, -6.10488951e-02f, 2.22065136e-01f, 8.96980017e-02f, -4.49702457e-05f, 8.80567431e-02f, 7.88573027e-02f, 7.32234344e-02f,
  5.74512370e-02f, 9.14949849e-02f, 1.09743401e-01f, -3.09065096e-02f, -1.24194078e-01f, 2.56467965e-02f, -1.16826519e-01f, -9.25731733e-02f, -8.73741508e-02f, 4.24737670e-02f,
  -1.29279956e-01f, 1.52580626e-02f, -1.53748915e-02f, 7.30911046e-02f, 1.04503464e-02f, -1.55338556e-01f, 8.04008916e-02f, 1.28448129e-01f, 1.16484284e-01f, 1.37164053e-02f,
  6.16811663e-02f, 1.50934175e-01f, 1.70640752e-01f, -1.35392860e-01f, 3.39153558e-02f, -4.22760211e-02f, -2.31456738e-02f, -1.83385666e-02f, 5.08359037e-02f, -5.20544052e-02f,
  -1.17379829e-01f, -3.86303701e-02f, -3.04674655e-02f, -8.44739377e-02f, 1.06937237e-01f, 3.11880767e-01f, -1.07642934e-01f, 1.77056253e-01f, 5.08277491e-03f, 2.50025988e-01f,
  7.13658184e-02f, -1.45464271e-01f, -2.10034922e-01f, 1.66456714e-01f, -3.90715271e-01f, 2.46129960e-01f, 6.49499521e-02f, -5.23153283e-02f, 8.08447003e-02f, -8.14483538e-02f,
  -2.13927686e-01f, 1.18564069e-01f, 1.45446330e-01f, -7.43126273e-02f, -3.49500954e-01f, 1.07659280e-01f, 1.36681750e-01f, 8.88142511e-02f, -9.37187523e-02f, 1.35477453e-01f,
  2.48044766e-02f, 1.93987507e-02f, -5.32746501e-02f, -1.54466778e-02f, -7.87200332e-02f, -6.26746491e-02f, -1.81002110e-01f, 1.12017125e-01f, 1.68829799e-01f, 1.16134070e-01f,
  -1.09697774e-01f, -4.68559563e-02f, 5.04469499e-02f, -1.14986569e-01f, -1.18765250e-01f, -1.59818858e-01f, 2.49977806e-03f, 1.34986147e-01f, -4.73467708e-02f, -1.62264183e-01f,
  -1.37821510e-01f, 4.94116880e-02f, 2.56550554e-02f, -4.23987471e-02f, 3.15545755e-03f, -4.31843847e-02f, -2.91490089e-02f, -1.55750886e-01f, -5.36484346e-02f, 8.06812122e-02f,
  -1.05623886e-01f, -1.91359326e-01f, -4.49992670e-03f, 1.49592897e-02f, 9.75745395e-02f, -2.12544024e-01f, 1.40621901e-01f, 3.52723971e-02f, 1.09841958e-01f, -1.93076544e-02f,
  2.89861411e-01f, 1.98641289e-02f, 1.46739021e-01f, -2.09729344e-01f, -2.86817461e-01f, 1.48614552e-02f, 6.26418181e-03f, -1.33909434e-01f, -1.15223207e-01f, -1.67359468e-02f,
  -1.59546077e-01f, 9.26786512e-02f, -5.50770611e-02f, 1.21581525e-01f, 1.48447491e-02f, 1.80963665e-01f, 1.36176199e-01f, -2.29479834e-01f, -4.43994328e-02f, -8.10847059e-02f,
  4.65994366e-02f, -2.01094430e-02f, -2.15875246e-02f, 8.92282091e-03f, -4.40369993e-02f, 4.76911888e-02f, -7.67354891e-02f, -6.98317867e-03f, -3.71909738e-02f, 1.24032970e-03f,
  -6.85497299e-02f, 4.24978286e-02f, 6.02135099e-02f, 9.78555605e-02f, 3.13095003e-02f, 1.24973170e-01f, 1.09181039e-01f, -7.33986348e-02f, -1.62044048e-01f, 3.47205773e-02f,
  1.06039777e-01f, 3.54264751e-02f, -1.20623879e-01f, 1.63060799e-02f, 6.72651753e-02f, -8.91278535e-02f, -4.26316485e-02f, -1.34660125e-01f, -3.59879546e-02f, 7.66082481e-02f,
  -5.29279932e-02f, 5.01681492e-02f, -7.08342269e-02f, 9.90631357e-02f, 7.23306537e-02f, 1.46983042e-01f, 3.87240648e-02f, 1.43206239e-01f, -8.03127661e-02f, -1.04345515e-01f,
  3.80053148e-02f, -6.33324012e-02f, 2.28922609e-02f, 1.23379707e-01f, -2.72755083e-02f, 5.05195186e-03f, -1.86828285e-01f, 1.32206734e-02f, 4.43929136e-02f, -1.41652629e-01f,
  5.05979583e-02f, 7.39037544e-02f, -8.35312456e-02f, -1.13946892e-01f, 2.38000244e-01f, -6.16789749e-03f, 5.97047694e-02f, 4.18053269e-02f, 2.11451411e-01f, -1.49935231e-01f,
  2.06590280e-01f, 1.54159024e-01f, -1.38027892e-01f, 1.60505757e-01f, -4.33438830e-02f, 1.12984531e-01f, -1.93249136e-01f, 7.94530511e-02f, 5.38158119e-02f, -7.96255097e-02f,
  -7.89444968e-02f, -4.52651642e-02f, 9.43169370e-02f, -1.60651371e-01f, 3.00663896e-02f, -1.22919209e-01f, 1.13225348e-01f, 4.49301787e-02f, -1.69510260e-01f, 7.08556548e-02f,
  -6.38228506e-02f, -4.71281111e-02f, 1.16530478e-01f, -1.08719781e-01f, 1.18095446e-02f, 7.79411867e-02f, -4.90474142e-02f, -1.26448378e-01f, -1.64930433e-01f, -1.34261936e-01f,
  -1.20835595e-01f, -1.66820765e-01f, 6.51871935e-02f, -8.88423324e-02f, -1.01835415e-01f, 3.20001505e-02f, -2.77619883e-02f, 6.20422326e-03f, -1.09518245e-01f, -2.55875289e-01f,
  4.36215959e-02f, -6.66332021e-02f, 2.03729291e-02f, -1.03308335e-01f, -2.04346433e-01f, -6.78476319e-02f, -1.45765081e-01f, -1.54972225e-01f, 1.08147152e-01f, 1.14578687e-01f,
  -6.91620708e-02f, -1.68793559e-01f, -1.01167616e-02f, 9.54674333e-02f, 5.64536229e-02f, -2.54039109e-01f, -1.29493162e-01f, 1.14693925e-01f, -6.73707351e-02f, 2.14135394e-01f,
  -1.95366412e-01f, 2.60445401e-02f, 6.56123608e-02f, 1.79756135e-01f, -7.60776475e-02f, -1.21025536e-02f, -1.37810871e-01f, -6.79678544e-02f, -5.59162125e-02f, -3.86665687e-02f,
  8.70920643e-02f, -4.24040556e-02f, 9.40424204e-02f, -1.14128880e-01f, 1.16382778e-01f, -5.95265925e-02f, 1.41762018e-01f, 1.21757671e-01f, -7.84470290e-02f, 3.60899232e-02f,
  3.11215203e-02f, 1.72060415e-01f, 2.04623919e-02f, 6.83735088e-02f, -1.13169387e-01f, 1.33235544e-01f, 5.92782386e-02f, -1.90613091e-01f, -3.10276244e-02f, 8.14804211e-02f,
  -3.01708914e-02f, 2.46377587e-02f, -2.67964691e-01f, -5.77082448e-02f, -2.09056616e-01f, -2.99330428e-02f, -6.71291538e-03f, -3.03276926e-02f, 6.05510920e-03f, -9.86358225e-02f,
  2.80120224e-02f, 4.88534197e-02f, 1.03429414e-01f, -1.59275711e-01f, -8.82008597e-02f, -2.14148432e-01f, 1.71306655e-02f, 4.76430394e-02f, -1.65210277e-01f, 1.49808511e-01f,
  -2.38204360e-01f, -1.27878133e-02f, -4.88390289e-02f, -6.34307116e-02f, -6.03209324e-02f, -1.22822717e-01f, -9.80948657e-03f, 5.12342304e-02f, 9.42610059e-05f, 1.50664523e-02f,
  1.90644071e-01f, 2.65634954e-02f, -2.95383543e-01f, -1.10522442e-01f, -9.77904350e-02f, -3.97705920e-02f, 1.35096818e-01f, 4.62263376e-02f, 2.22264417e-02f, -1.56009421e-01f,
  -1.19140945e-01f, -3.56378108e-02f, -5.93223609e-02f, 1.26629665e-01f, 9.82785001e-02f, -1.10738479e-01f, 1.33311063e-01f, -6.86452091e-02f, 7.83417448e-02f, -1.68723598e-01f,
  7.97382742e-02f, -6.79768175e-02f, 5.41751347e-02f, 1.73859894e-01f, -2.50257663e-02f, 9.02431607e-02f, 1.53570116e-01f, -9.36694220e-02f, 6.78207353e-03f, 7.52002969e-02f,
  1.21292956e-02f, 3.30199823e-02f, 6.68637902e-02f, -7.97914118e-02f, 3.68346181e-03f, 1.65132992e-02f, 1.70557499e-01f, -3.45046557e-02f, -6.67462572e-02f, 6.98116794e-02f,
  3.98137160e-02f, -7.68936947e-02f, -4.34216075e-02f, 4.63196961e-03f, -9.91409738e-03f, -3.43842315e-03f, -4.95831342e-03f, -1.45910494e-02f, 2.28841901e-02f, -6.66293502e-03f,
  6.00648299e-02f, 1.80884734e-01f, 4.20536213e-02f, 1.83892339e-01f, 1.24353081e-01f, 9.95833576e-02f, -8.03744420e-02f, -1.56383112e-01f, 5.93170896e-02f, -5.88645414e-02f,
  6.35105148e-02f, -6.36347085e-02f, 2.66527049e-02f, 8.45183432e-02f, 1.71392128e-01f, -2.41990820e-01f, -1.00781158e-01f, -8.93438160e-02f, 8.28392953e-02f, -4.95381420e-03f,
  9.96920615e-02f, -2.17515677e-01f, -1.46775842e-01f, 3.16263765e-01f, 1.97409227e-01f, 1.85910583e-01f, -3.24543491e-02f, 1.34853655e-02f, 8.75971392e-02f, -5.79202361e-02f,
  -8.75829607e-02f, -7.91701395e-03f, -7.18407929e-02f, -3.76561396e-02f, 1.20643832e-01f, -4.78478847e-03f, 1.31313145e-01f, -1.63743883e-01f, -1.80274814e-01f, -1.13396041e-01f,
  1.48465242e-02f, 2.70059034e-02f, 1.47136062e-01f, 3.01155169e-03f, -9.49666202e-02f, -1.28707305e-01f, 6.87451586e-02f, 9.73200724e-02f, 7.02785999e-02f, -4.85725217e-02f,
  2.56059747e-02f, -3.82202305e-02f, 1.47803441e-01f, -5.06540798e-02f, -1.45353079e-01f, 7.36222342e-02f, 1.90343484e-01f, 6.51434660e-02f, 9.05900542e-03f, -4.73996326e-02f,
  -1.44784033e-01f, -6.95897788e-02f, -4.31589969e-02f, 1.90587621e-02f, 4.11825292e-02f, -1.12047851e-01f, 2.56517917e-01f, -1.11349918e-01f, 1.47104070e-01f, -1.13492645e-01f,
  -1.87969971e-02f, 7.53432661e-02f, 7.79725909e-02f, -2.08289139e-02f, -1.13306955e-01f, 1.34675801e-01f, -8.21832791e-02f, 1.45813795e-02f, -2.15448514e-01f, 9.17541832e-02f,
  7.49834403e-02f, -3.54606621e-02f, 9.14357826e-02f, 2.15285689e-01f, -1.57187618e-02f, -6.88538551e-02f, 1.19446173e-01f, 6.54637218e-02f, -1.65090531e-01f, 2.10811794e-02f,
  -4.60589007e-02f, -6.24457709e-02f, -1.34274200e-01f, -2.26839036e-02f, -6.06144033e-02f, -2.99148709e-02f, -8.68440643e-02f, -4.86174971e-03f, 1.25423804e-01f, -3.33067379e-03f,
  -2.07165912e-01f, -9.46616530e-02f, -2.59746425e-02f, 3.85079756e-02f, -3.87601815e-02f, -3.19921412e-03f, -8.31663087e-02f, -2.87809782e-02f, 1.59748644e-01f, 2.35739239e-02f,
  -5.45739196e-02f, -1.55602813e-01f, 3.44668739e-02f, 2.63640396e-02f, 1.26520256e-02f, 1.71677712e-02f, -1.52027771e-01f, 7.27707073e-02f, 5.80493398e-02f, -7.09420145e-02f,
  -6.07616156e-02f, 7.83872232e-02f, -7.04880152e-03f, 1.57292513e-03f, -1.15295025e-02f, 3.48369889e-02f, -1.86906427e-01f, -2.61831671e-01f, -1.27190664e-01f, 3.26914281e-01f,
  -1.53655276e-01f, 2.80281454e-01f, -4.29375060e-02f, 5.72502501e-02f, -2.78925627e-01f, -8.47858563e-02f, -1.72542874e-02f, 7.44768828e-02f, 2.15617344e-01f, 1.55179128e-01f,
  -1.10186078e-01f, 2.39018634e-01f, 3.47160101e-01f, -1.66924924e-01f, -7.20038116e-02f, -1.70089945e-01f, -5.03714494e-02f, -1.57042950e-01f, -3.38848047e-02f, -1.06906071e-01f,
  -7.76846567e-03f, -9.23991669e-03f, 5.36541492e-02f, 8.71741120e-03f, -5.52467145e-02f, -1.50050610e-01f, 7.27220029e-02f, -7.71161467e-02f, -6.45879135e-02f, -1.33836016e-01f,
  1.91547409e-01f, -5.14994077e-02f, -8.57388377e-02f, 1.05593121e-02f, 8.81927982e-02f, -1.60191566e-01f, -4.64746878e-02f, -1.88415572e-01f, 8.94779712e-02f, -1.82113983e-02f,
  3.49476025e-03f, -1.25819743e-01f, -1.17212132e-01f, 1.36020603e-02f, -7.96151906e-02f, 2.63316743e-02f, 1.21540070e-01f, 1.07467882e-01f, 4.68907617e-02f, 4.39213403e-02f,
  1.58879668e-01f, -1.46325842e-01f, 1.82625968e-02f, -5.26516363e-02f, 7.67987594e-02f, -1.11796521e-01f, 9.02978256e-02f, 1.16267689e-01f, -1.09735377e-01f, -7.71505237e-02f,
  1.25140697e-01f, 3.19683813e-02f, 1.52852371e-01f, -3.99159342e-02f, 6.98431656e-02f, -4.32387255e-02f, -5.43796495e-02f, -1.78283483e-01f, 2.63404362e-02f, 1.39985874e-01f,
  1.79616109e-01f, -7.18077123e-02f, 6.72812685e-02f, 2.01904163e-01f, 2.35247970e-01f, -1.95057988e-01f, -8.41850564e-02f, -1.41548216e-01f, -3.41512822e-03f, 9.88412499e-02f,
  3.24749909e-02f, 1.76566496e-01f, 5.28910644e-02f, -1.43298328e-01f, 2.18206450e-01f, -7.96230361e-02f, -2.03236677e-02f, -1.27516478e-01f, -6.25147596e-02f, -1.26545563e-01f,
  1.28498361e-01f, -5.56405559e-02f, -9.24390927e-02f, -1.03131242e-01f, 2.44504269e-02f, -1.70354135e-02f, 4.43886407e-03f, 4.36841063e-02f, -1.05105549e-01f, -2.32405886e-01f,
  -4.21471745e-02f, 4.16904651e-02f, 2.84384564e-02f, 8.07612613e-02f, -1.73711926e-02f, -1.09093346e-01f, 7.38759786e-02f, -6.16930872e-02f, 1.11976556e-01f, 1.22034490e-01f,
  -4.28110212e-02f, 1.68806165e-02f, 3.37826088e-02f, -1.14157289e-01f, 9.00062695e-02f, -5.50668202e-02f, 7.37730265e-02f, -1.27513662e-01f, 2.74444558e-02f, -2.08229714e-04f,
  1.96972638e-02f, -7.87266195e-02f, -7.83002749e-02f, -1.70353860e-01f, -9.95197296e-02f, -9.78922937e-04f, 8.61508325e-02f, 9.42989960e-02f, -1.20016553e-01f, -6.17322885e-02f,
  -2.09617838e-01f, -1.57220110e-01f, 6.64929375e-02f, -1.17272638e-01f, -1.40563563e-01f, -1.46982998e-01f, 1.61712795e-01f, -3.77673134e-02f, 4.85819243e-02f, -1.27700016e-01f,
  3.85011211e-02f, -6.00688569e-02f, -1.79987729e-01f, 1.44244075e-01f, 4.24205000e-03f, 8.97736773e-02f, 2.23205924e-01f, 2.03417152e-01f, -2.30581939e-01f, 1.57532752e-01f,
  -6.83360100e-02f, -4.13065031e-02f, -7.43352715e-03f, 1.83064550e-01f, 1.83918457e-02f, 5.38211428e-02f, 1.37476891e-01f, 3.56329195e-02f, -5.16018420e-02f, -1.03439867e-01f,
  -6.06175847e-02f, 1.23536266e-01f, -1.16488300e-01f, 1.27358645e-01f, 1.33887632e-02f, 3.70208845e-02f, -2.32386701e-02f, 4.94851544e-02f, -1.21976696e-01f, 8.64578709e-02f,
  2.44668834e-02f, -6.81719333e-02f, 1.08420260e-01f, -2.54750345e-02f, -1.19375288e-01f, -2.59790048e-02f, -3.59396450e-02f, 7.18838871e-02f, -1.57496065e-01f, -6.59517497e-02f,
  9.84798819e-02f, -1.91050336e-01f, -7.41540417e-02f, -5.76522760e-02f, 7.07556605e-02f, -1.90678388e-02f, 7.08593726e-02f, -3.24347764e-02f, 5.09679802e-02f, -1.52898416e-01f,
  1.00871325e-01f, 8.60149264e-02f, -2.30503470e-01f, 1.15455195e-01f, -6.45193979e-02f, 1.31884977e-01f, -1.50598556e-01f, 1.04811370e-01f, -2.72067159e-01f, 9.91535187e-02f,
  1.66406855e-01f, -5.28091900e-02f, -1.59972027e-01f, -4.73056994e-02f, 1.50840431e-02f, 1.35860428e-01f, -1.71087235e-01f, -1.86131336e-02f, -1.88159496e-01f, 6.28450364e-02f,
  3.92153785e-02f, 4.08199839e-02f, -2.17768863e-01f, 7.86308497e-02f, -1.28152072e-01f, -8.86852443e-02f, 1.07058361e-01f, 1.94511235e-01f, 1.09090954e-01f, 4.08800170e-02f,
  1.21940486e-01f, 1.30326912e-01f, 3.74386832e-02f, -1.37789488e-01f, 6.40501976e-02f, -4.88805138e-02f, -6.57992736e-02f, 1.75709486e-01f, 1.12155274e-01f, 4.21493277e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.12340085e-01f, 1.12573624e-01f, 1.15137845e-01f, 7.44046569e-02f, -1.79873081e-03f, 8.14382806e-02f, 1.37346581e-01f, 1.35737851e-01f, 1.26620904e-01f, -5.98389879e-02f,
  4.26801108e-02f, 1.03974111e-01f, 1.06445275e-01f, 1.14810929e-01f, -4.49319817e-02f, -1.16566680e-01f, -3.49597968e-02f, 6.05016574e-02f, -8.05983692e-02f, 4.81569096e-02f,
  -5.25782816e-03f, -1.28126591e-01f, -2.52059493e-02f, 2.53261300e-03f, -3.45606282e-02f, -8.35780278e-02f, -6.56214356e-02f, 4.10610437e-02f, 6.12800457e-02f, 1.01537138e-01f,
  1.38230786e-01f, -1.29870484e-02f, -1.80560350e-02f, -1.55619666e-01f, 8.69375467e-02f, -1.18130647e-01f, 2.01815926e-02f, -1.29609749e-01f, 1.46285161e-01f, -7.44387284e-02f,
  -8.73173103e-02f, 1.16867594e-01f, 8.18050057e-02f, -1.08410284e-01f, 4.64585759e-02f, -6.94050193e-02f, -1.41932890e-01f, 2.14040000e-02f, -7.35815167e-02f, 9.24172327e-02f,
  5.76552339e-02f, -2.39310339e-02f, -9.59558561e-02f, -8.38216469e-02f, 8.81493688e-02f, -8.22928082e-03f, 4.09043245e-02f, -7.52095133e-02f, 4.55678441e-02f, 3.47165503e-02f,
  7.77137056e-02f, -9.78406742e-02f, 2.19531413e-02f, 7.62034431e-02f, 9.11019817e-02f, -6.30684122e-02f, -1.60288457e-02f, 6.07886985e-02f, 8.91290829e-02f, 4.80955653e-02f,
  2.98956991e-03f, -5.54097183e-02f, -2.62428652e-02f, -3.24411355e-02f, 1.02945544e-01f, -9.15778801e-02f, 1.47626307e-02f, 4.71038260e-02f, 1.16563387e-01f, -2.08132528e-02f,
  -4.48813802e-03f, 1.49737731e-01f, -7.88386837e-02f, 5.63763939e-02f, 1.30578071e-01f, -5.36086001e-02f, 3.75141166e-02f, -1.17488176e-01f, 1.49100140e-01f, 1.28651187e-02f,
  7.50440583e-02f, 1.25172958e-01f, -1.05452619e-01f, -7.74370134e-02f, -7.65224397e-02f, 1.40401185e-01f, -1.25509650e-01f, 1.13980368e-01f, 7.47877732e-02f, 3.83590013e-02f,
  -4.40590754e-02f, -7.22426400e-02f, 1.23681411e-01f, -1.01834536e-01f, -1.62281185e-01f, -3.66590247e-02f, -1.55394882e-01f, -2.73814742e-02f, 2.10780576e-02f, 1.14462838e-01f,
  6.64590299e-02f, -1.56511083e-01f, -1.57899231e-01f, -1.49055403e-02f, 1.01022944e-01f, -6.18742220e-02f, 1.46899587e-02f, -4.00647409e-02f, 3.16482708e-02f, -8.29396546e-02f,
  6.98822513e-02f, -1.32573500e-01f, 3.97177599e-02f, -1.15819937e-02f, 1.05375431e-01f, 1.25873327e-01f, 1.30328303e-02f, 5.39509393e-02f, 2.07371954e-02f, 1.22977711e-01f,
  6.65505603e-02f, -2.24189134e-03f, 8.10319930e-02f, -7.04725087e-02f, -5.93130924e-02f, 5.66565432e-02f, -9.00720730e-02f, -7.12923706e-02f, -2.39182170e-02f, 1.13325650e-02f,
  4.20219488e-02f, 7.53904432e-02f, 8.39631557e-02f, -6.75039291e-02f, 1.48253422e-02f, 7.65968859e-02f, -2.25696377e-02f, -2.97257844e-02f, 1.75533891e-02f, 1.15583256e-01f,
  -3.88302505e-02f, -4.23028693e-02f, 7.04763457e-03f, 8.00249130e-02f, -1.05091058e-01f, 1.22519337e-01f, 7.22844675e-02f, 1.63318450e-03f, -9.56126451e-02f, 1.73488259e-02f,
  -1.09285615e-01f, 1.30502164e-01f, 1.17339410e-01f, -1.60155352e-02f, 7.54966214e-02f, 1.45255595e-01f, 3.13912407e-02f, -1.09216578e-01f, -1.13574423e-01f, -1.16816044e-01f,
  4.70376275e-02f, -9.36102401e-03f, 9.24663022e-02f, 5.07469550e-02f, 5.81627525e-02f, 1.33626595e-01f, -1.19451724e-01f, -2.43819691e-02f, 4.59273346e-02f, -9.99531373e-02f,
  7.84915965e-03f, 1.24765910e-01f, -1.05356961e-01f, 1.07666440e-01f, -4.72983234e-02f, -3.25145274e-02f, 5.50782382e-02f, -1.09305546e-01f, -7.82451406e-02f, -2.40230355e-02f,
  1.31028399e-01f, -8.35839212e-02f, 1.83096811e-01f, 9.60200205e-02f, -4.28189822e-02f, 6.01355657e-02f, -5.02407476e-02f, 4.42224182e-03f, 2.62959264e-02f, 1.21934816e-01f,
  9.65428650e-02f, 1.30922452e-01f, 1.80371612e-01f, 1.24968454e-01f, 1.53927237e-01f, -1.59522340e-01f, -1.55798607e-02f, 2.26115495e-01f, 2.03463584e-01f, -5.45051582e-02f,
  1.67045057e-01f, 1.90655529e-01f, 3.25467922e-02f, 1.16346300e-01f, 9.25432816e-02f, 6.90414831e-02f, 1.65545970e-01f, -4.85732071e-02f, -1.33593127e-01f, -6.39793426e-02f,
  7.40958750e-02f, 2.50253715e-02f, -4.82628196e-02f, 2.36837000e-01f, 1.21960305e-01f, 2.30591834e-01f, -1.43287420e-01f, 2.03147195e-02f, 7.81406239e-02f, -1.01329133e-01f,
  -2.32443511e-01f, 8.00823122e-02f, 1.82907224e-01f, -4.30394523e-02f, -3.84905599e-02f, -9.45461914e-02f, -2.77348727e-01f, 1.05943464e-01f, 9.76031348e-02f, -1.02922730e-01f,
  -4.76744324e-02f, -6.73590973e-02f, -9.46355611e-02f, -9.42105707e-03f, -6.71674684e-02f, 3.37502137e-02f, -1.12495959e-01f, -1.12038434e-01f, 4.63482514e-02f, 1.42060697e-01f,
  -1.19288735e-01f, -7.50814900e-02f, 1.14035361e-01f, -4.00999226e-02f, -3.20586003e-02f, -9.00793597e-02f, 1.62593871e-01f, 1.78576842e-01f, 1.47735700e-01f, 8.24736133e-02f,
  1.68210164e-01f, 1.91980481e-01f, 1.49747878e-01f, -1.32835750e-02f, 1.94616511e-01f, 9.71922427e-02f, 1.15799166e-01f, 4.53582592e-03f, 1.75815299e-01f, 3.05288881e-01f,
  1.56902343e-01f, 8.90287086e-02f, -6.87938407e-02f, 2.45624200e-01f, -9.65103954e-02f, 1.15785204e-01f, 1.80997491e-01f, 7.89706185e-02f, 5.00022694e-02f, -9.45087075e-02f,
  -2.37603136e-03f, 3.31320435e-01f, -1.47977173e-01f, 1.08810522e-01f, 1.91820487e-01f, 4.81211841e-02f, -2.89184958e-01f, -1.46980092e-01f, -1.00787766e-02f, 8.22822154e-02f,
  1.57083914e-01f, -5.02542965e-03f, -3.58957738e-01f, 2.58147895e-01f, 2.10746258e-01f, -1.92904696e-01f, -1.89521104e-01f, -2.77113289e-01f, -2.23836359e-02f, -2.54990071e-01f,
  5.03557734e-02f, 1.19488738e-01f, -1.18998185e-01f, 2.76876628e-01f, 2.19619617e-01f, 3.04866761e-01f, 1.31208539e-01f, 5.73914833e-02f, 1.00103416e-01f, 1.75507903e-01f,
  6.83624074e-02f, 3.72634418e-02f, -7.45076919e-03f, 5.45430407e-02f, -3.76129523e-02f, -9.26417783e-02f, 8.31594318e-02f, -3.44369817e-03f, -1.06335007e-01f, 9.13468823e-02f,
  4.54514846e-02f, -6.89080581e-02f, 4.97099049e-02f, -6.94676936e-02f, 2.94550508e-02f, -5.68564497e-02f, -4.47888998e-03f, 1.26131654e-01f, -9.13809538e-02f, 7.35265836e-02f,
  -2.43194196e-02f, -3.10570691e-02f, 1.06589891e-01f, -8.05327296e-02f, 2.92948429e-02f, 1.15624452e-02f, 9.54142660e-02f, 7.20899478e-02f, 1.42487764e-01f, 3.94127816e-02f,
  1.23344399e-01f, -8.00973270e-03f, 2.38458067e-02f, 1.27611607e-01f, 6.55119345e-02f, -1.02548853e-01f, 7.51028210e-02f, -1.52478889e-02f, -4.34707210e-04f, 9.78525132e-02f,
  -8.99872258e-02f, -3.57069150e-02f, -7.40282983e-02f, -1.06874600e-01f, -9.23630744e-02f, -6.63504973e-02f, -6.62289485e-02f, -9.60421115e-02f, -1.57697171e-01f, -7.02637807e-02f,
  -3.55845690e-02f, -2.49323156e-02f, 8.47505108e-02f, -5.83506376e-03f, -1.84376296e-02f, -1.12707894e-02f, -1.43412083e-01f, 1.35561883e-01f, -1.20205373e-01f, -7.11767524e-02f,
  -6.10448532e-02f, 3.49303335e-02f, -1.24505319e-01f, 7.88982883e-02f, 4.94181104e-02f, 9.37771872e-02f, -5.57461008e-02f, 8.01910609e-02f, -4.19097617e-02f, -1.03337340e-01f,
  4.31808410e-03f, -2.47091744e-02f, -4.70445827e-02f, 5.12744635e-02f, -5.44682965e-02f, 1.45581156e-01f, 2.14974899e-02f, -2.91367508e-02f, -1.00851394e-01f, -1.57138165e-02f,
  1.29634157e-01f, -8.12078342e-02f, -1.03051208e-01f, 4.39434536e-02f, 4.31569256e-02f, -7.58906752e-02f, -4.08209153e-02f, 4.54110429e-02f, 1.05717227e-01f, 3.20743956e-02f,
  -4.23977822e-02f, 7.47830644e-02f, 1.06112435e-01f, -2.34847292e-02f, 1.59583926e-01f, -4.86448705e-02f, 3.90432477e-02f, 1.66989155e-02f, 8.17205012e-02f, -6.78270077e-03f,
  -1.63800836e-01f, -3.06092463e-02f, -1.51721224e-01f, 1.71039119e-01f, -1.49208695e-01f, -5.63991778e-02f, -2.44055018e-01f, 6.72226772e-02f, 1.91450238e-01f, -6.29872903e-02f,
  -1.26628429e-01f, 1.18462384e-01f, -1.07977420e-01f, 7.15404302e-02f, -1.57611556e-02f, -4.66292426e-02f, 1.24498658e-01f, -1.47337988e-01f, -1.09676830e-01f, 5.64645976e-02f,
  1.69509903e-01f, -2.40745954e-02f, -1.39930293e-01f, 2.19176456e-01f, 1.35488436e-01f, -1.33757278e-01f, -1.50030673e-01f, 6.32085428e-02f, 1.53000224e-02f, 1.36408703e-02f,
  3.80256772e-02f, 3.20247933e-02f, 4.26929891e-02f, 1.71793718e-02f, 1.28506884e-01f, 7.65123591e-02f, -5.34284487e-03f, -9.58790909e-03f, 1.69115633e-01f, -2.94425357e-02f,
  6.41550571e-02f, 4.18242253e-02f, 3.95673290e-02f, 1.00946896e-01f, 1.29925683e-02f, 4.97330949e-02f, 7.82161057e-02f, -5.00372890e-03f, -1.55681430e-03f, 5.81512898e-02f,
  1.74069807e-01f, -6.21747039e-02f, -7.08710775e-02f, 1.83190271e-01f, 2.41109580e-01f, -7.34955072e-02f, 1.66468784e-01f, 1.16520412e-01f, 8.76356810e-02f, 9.84770060e-02f,
  1.20966047e-01f, 8.98515284e-02f, 1.08643658e-01f, -6.39502406e-02f, -6.37174957e-03f, -6.86647743e-02f, 1.84497505e-01f, -2.07958564e-01f, 1.96207181e-01f, 1.44970655e-01f,
  1.82189748e-01f, 1.33879647e-01f, -1.30682588e-01f, -8.79129618e-02f, 2.04941452e-01f, 1.82912238e-02f, 6.19513504e-02f, 2.42186308e-01f, 1.52653992e-01f, 1.11370943e-01f,
  2.49220356e-02f, -2.32431758e-02f, -1.49043575e-01f, -2.54532397e-02f, 1.83390871e-01f, -3.08611125e-01f, -1.81669313e-02f, -1.83164626e-01f, 2.17959676e-02f, -4.80236597e-02f,
  2.73682535e-01f, -1.03134885e-01f, -9.26593393e-02f, -7.71919042e-02f, 1.36855334e-01f, -3.23383957e-02f, 3.98245342e-02f, 1.70661375e-01f, 1.10084943e-01f, 5.57854362e-02f,
  8.55461508e-02f, 5.72134219e-02f, 6.73451796e-02f, -9.61644277e-02f, -1.15741059e-01f, -4.79110107e-02f, 1.12363860e-01f, -7.68252015e-02f, 4.96536642e-02f, -3.00948750e-02f,
  1.41484037e-01f, -8.06181133e-02f, -1.03979148e-01f, -9.63554904e-03f, 6.36247024e-02f, -4.94316556e-02f, 1.50804743e-01f, -1.41674643e-02f, -8.25609826e-03f, 1.54549628e-01f,
  5.92565425e-02f, 2.23212969e-03f, -4.66852039e-02f, -1.00566663e-01f, 1.25380221e-03f, 7.42479339e-02f, 1.21630572e-01f, -7.77971223e-02f, -3.85325551e-02f, 1.79987103e-01f,
  -4.26819734e-03f, 8.01233798e-02f, 1.78407151e-02f, 2.21757051e-02f, -8.82064551e-02f, 4.29938547e-02f, 4.54102010e-02f, -1.15876429e-01f, -1.15119949e-01f, 1.07068621e-01f,
  1.68775320e-01f, -8.19565281e-02f, 9.09010842e-02f, -4.20474261e-02f, -6.83413446e-02f, -1.60027698e-01f, 1.11241909e-02f, 1.08644247e-01f, -2.28123758e-02f, 2.14497559e-02f,
  8.48485343e-03f, -3.93760353e-02f, -1.50816338e-02f, -6.24540895e-02f, 1.60744384e-01f, -1.01249538e-01f, 6.46132156e-02f, -9.26724672e-02f, -2.48200297e-02f, 1.17755152e-01f,
  1.17375985e-01f, -5.16886450e-02f, 1.17782481e-01f, -1.41810710e-02f, -7.64176473e-02f, 1.05890475e-01f, 2.30922438e-02f, 4.32193279e-02f, -5.02996752e-03f, 5.50512075e-02f,
  1.01175763e-01f, -1.48915956e-02f, 1.88397244e-01f, 1.25983730e-01f, -1.35276942e-02f, 2.73532216e-02f, 1.59822434e-01f, 2.81858686e-02f, -5.53478748e-02f, 1.05876528e-01f,
  -1.51446247e-02f, -8.85816943e-03f, 2.66898591e-02f, 1.11046508e-01f, 3.07616629e-02f, 1.11637088e-02f, 6.20238930e-02f, 6.32122830e-02f, 1.74779385e-01f, 1.61931932e-01f,
  5.82873933e-02f, -2.29664892e-01f, 1.11951798e-01f, -1.87297106e-01f, -2.10435882e-01f, -2.33527832e-02f, 2.44074404e-01f, 1.20045744e-01f, -1.51059508e-01f, -7.77391940e-02f,
  -1.32391527e-01f, -9.88229066e-02f, 2.33667016e-01f, 1.22918272e-02f, -1.61991626e-01f, -1.94374129e-01f, -1.08871283e-02f, 1.98490009e-01f, 4.22338434e-02f, 1.33435100e-01f,
  3.57779145e-01f, -2.75908530e-01f, 1.19923986e-01f, 9.58462358e-02f, 6.72087744e-02f, 2.71819178e-02f, 7.83569738e-02f, 2.95450479e-01f, -1.89015165e-01f, -1.27531782e-01f,
  -1.04780927e-01f, 1.00374877e-01f, -2.53547058e-02f, 4.61814925e-02f, 2.31044486e-01f, -1.75361767e-01f, -1.37798563e-01f, 4.34293114e-02f, -5.74086569e-02f, -4.55852132e-03f,
  1.20930485e-01f, 1.71482399e-01f, 3.19330916e-02f, 3.28470133e-02f, 5.27992919e-02f, 1.95072010e-01f, 2.57848836e-02f, 4.58636135e-03f, 6.63348958e-02f, 2.61753909e-02f,
  2.26744130e-01f, 1.39895588e-01f, -3.79810296e-02f, 4.74192388e-02f, 1.64368525e-01f, -5.48539646e-02f, 1.01121306e-01f, 5.23105301e-02f, 9.73571166e-02f, 1.28116144e-03f,
  1.20120175e-01f, 1.31008580e-01f, -1.01705361e-02f, 2.28495583e-01f, 1.21648669e-01f, -9.26208645e-02f, 1.55392900e-01f, -9.92571265e-02f, 1.96752995e-01f, 1.61488533e-01f,
  -8.14342573e-02f, 1.10793203e-01f, 1.39989546e-02f, 5.60720377e-02f, 3.07182483e-02f, 1.20919766e-02f, 1.05835520e-01f, 9.48840976e-02f, -1.30070731e-01f, 4.37542610e-02f,
  -8.30689743e-02f, 2.82390323e-03f, -9.97605640e-03f, 9.12938863e-02f, 6.04584627e-02f, -3.23946476e-02f, 6.11122996e-02f, 2.23520007e-02f, 4.54498827e-02f, 1.37644961e-01f,
  1.20444968e-01f, 3.03682890e-02f, 9.84901339e-02f, 3.24582420e-02f, 8.64846185e-02f, 1.42806530e-01f, -2.63829250e-02f, 1.03430040e-01f, -5.04172668e-02f, -1.11386240e-01f,
  -4.90794368e-02f, 3.13640409e-03f, 1.27194136e-01f, 1.78879232e-03f, -7.58222863e-02f, -2.60526780e-02f, 1.19485594e-01f, 1.18230648e-01f, 6.09896854e-02f, 5.17821126e-02f,
  4.32165824e-02f, -6.81635439e-02f, 9.24295411e-02f, 1.17151484e-01f, 2.93893944e-02f, -5.01416028e-02f, 6.10963255e-02f, 5.25795389e-04f, -1.00512303e-01f, 2.04112474e-02f,
  -2.39210352e-02f, 1.41154215e-01f, 7.23425895e-02f, -7.53768310e-02f, 1.98852140e-02f, 1.37372643e-01f, 1.17378451e-01f, -1.06636062e-01f, 3.18684913e-02f, -9.73401591e-02f,
  1.34657798e-02f, 3.29719111e-02f, 5.77097908e-02f, -1.15943447e-01f, -1.46573454e-01f, 9.31674019e-02f, -1.74184978e-01f, 8.99946690e-02f, 4.96594124e-02f, -1.92927923e-02f,
  1.03823051e-01f, 2.32634936e-02f, 2.63147969e-02f, -3.82143818e-02f, -4.57551517e-02f, 1.53895598e-02f, -2.10375369e-01f, 1.38097644e-01f, -7.70346299e-02f, 8.25107470e-02f,
  9.42693353e-02f, -7.15973899e-02f, -1.39241397e-01f, -8.21928307e-02f, 8.40141997e-02f, 1.52661130e-01f, -5.64721711e-02f, -3.20939310e-02f, -1.14569746e-01f, 1.67336166e-01f,
  8.16794559e-02f, -1.23778597e-01f, 1.28248319e-01f, 9.20135826e-02f, -1.54016510e-01f, 1.08447842e-01f, -8.36210921e-02f, -1.23152956e-01f, -1.03612654e-01f, -5.05813584e-02f,
  -1.00842923e-01f, 1.11296721e-01f, -5.84936067e-02f, -1.05896734e-01f, -1.59972776e-02f, 1.69066414e-01f, 6.95109144e-02f, 1.29406244e-01f, 7.95733258e-02f, -7.37123517e-03f,
  1.17886454e-01f, 9.83761922e-02f, -4.75982651e-02f, -3.83437462e-02f, 1.14335313e-01f, 1.62397534e-01f, 1.30654618e-01f, 1.76258147e-01f, -6.61733653e-03f, -8.06676149e-02f,
  7.51271611e-03f, 8.56609792e-02f, -8.43350068e-02f, -2.10363612e-01f, -3.65748033e-02f, 3.11372634e-02f, -1.38992295e-01f, 2.43475679e-02f, 9.81017873e-02f, -7.36670271e-02f,
  1.92392379e-01f, 6.74126521e-02f, -1.92846268e-01f, -1.78530023e-01f, 9.01514143e-02f, 2.49669123e-02f, -3.48678492e-02f, 3.59506644e-02f, -8.43111649e-02f, -6.88297153e-02f,
  1.88393936e-01f, -8.74254182e-02f, -1.26718089e-01f, -3.80706005e-02f, -5.66356517e-02f, -1.64004222e-01f, -1.29012600e-01f, -1.33904546e-01f, -7.31172636e-02f, 2.08058897e-02f,
  -2.03850842e-03f, 1.05794659e-02f, 1.62510291e-01f, -7.35919774e-02f, 1.55723423e-01f, -1.46065699e-02f, -1.34824693e-01f, -4.68391180e-02f, 1.74333498e-01f, 1.32966474e-01f,
  -8.99430364e-02f, 1.83732480e-01f, 5.67013100e-02f, -1.17448121e-01f, 1.03381656e-01f, -1.06286161e-01f, 3.26053053e-02f, -3.01712770e-02f, -4.12082523e-02f, 2.01953817e-02f,
  6.87582195e-02f, 6.17890097e-02f, -6.24290155e-03f, -9.37939659e-02f, -7.01844841e-02f, 9.05181468e-03f, -5.97992465e-02f, 9.12946463e-02f, -7.10412636e-02f, -9.43934470e-02f,
  -6.34166226e-02f, -1.06840260e-01f, -9.23389976e-04f, -4.09579761e-02f, -7.39940926e-02f, -7.74584338e-02f, -6.36150092e-02f, -6.80961832e-02f, -4.28177323e-03f, -6.69564977e-02f,
  1.14029966e-01f, 1.56541709e-02f, -8.26146640e-03f, 5.68955988e-02f, 6.90153912e-02f, -7.82701522e-02f, -7.72017688e-02f, 6.62513226e-02f, 4.29964922e-02f, 1.18312135e-01f,
  9.24588516e-02f, 3.71719636e-02f, -6.97696805e-02f, 7.25159049e-02f, -8.14521569e-04f, 7.53716975e-02f, -1.38045792e-02f, -6.20733537e-02f, -8.59718323e-02f, 7.12283477e-02f,
  1.12979189e-02f, -7.29790851e-02f, 8.88885483e-02f, 1.06796615e-01f, -9.04593542e-02f, 2.41642334e-02f, -2.22832710e-02f, -1.17336437e-01f, 2.70457696e-02f, 4.23733294e-02f,
  6.63679093e-02f, 1.22283138e-02f, -2.64217649e-02f, 6.53792173e-02f, -1.11745246e-01f, 5.54859601e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.18259348e-01f, 1.66588575e-01f, 6.41224682e-02f, 1.19888917e-01f, 1.37489259e-01f, -2.80611478e-02f, 1.21337466e-01f, 1.05994307e-01f, -3.26611958e-02f, 1.03241861e-01f,
  -1.46665908e-02f, 9.96679217e-02f, 7.44129047e-02f, -1.07153609e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.48403123e-02f, -1.74336150e-01f, 1.37883469e-01f, 1.50651455e-01f, -9.21494514e-02f, -2.36613601e-02f, -8.46288875e-02f, 2.64165197e-02f, 1.52327731e-01f, 1.55407146e-01f,
  -1.80384889e-02f, 8.15070495e-02f, 2.60440316e-02f, -6.40010983e-02f, 2.47654364e-01f, 1.42602548e-01f, 1.96801778e-02f, -7.06131086e-02f, 5.19571081e-02f, -1.05141088e-01f,
  2.11432099e-01f, -1.11152463e-01f, -4.93790694e-02f, 6.65802509e-02f, 8.96918848e-02f, -8.68084207e-02f, 2.14477465e-01f, 7.49344677e-02f, -8.08125436e-02f, -1.59216881e-01f,
  2.34625652e-01f, -2.15167537e-01f, -1.15881339e-01f, -7.04429895e-02f, 2.38863260e-01f, -1.08657993e-01f, -6.04692176e-02f, -1.78125203e-01f, 6.17403165e-02f, -1.83930099e-01f,
  1.52326897e-01f, 7.20508397e-03f, 3.99211608e-02f, 3.55223939e-02f, -7.57758990e-02f, 3.40062603e-02f, 7.78847886e-03f, 2.54167467e-01f, 1.31585136e-01f, -1.30243808e-01f,
  1.16892345e-02f, 4.20421129e-03f, -7.71962926e-02f, -2.66423244e-02f, 4.03951779e-02f, 5.13051450e-02f, -2.54970223e-01f, 1.93973362e-01f, -9.45160463e-02f, 1.29473666e-02f,
  3.14692687e-03f, -6.39452413e-02f, -4.12296038e-03f, 4.07682285e-02f, -4.39719260e-02f, 3.83449830e-02f, -5.31577095e-02f, -3.54547128e-02f, 1.31815240e-01f, -2.91654617e-02f,
  6.97127506e-02f, -3.83347133e-03f, 1.03560030e-01f, -3.36435586e-02f, 6.26140460e-02f, 6.82487041e-02f, -1.08328789e-01f, -4.76976000e-02f, -7.64739886e-02f, -1.06905177e-01f,
  5.95825575e-02f, 1.01627424e-01f, 1.44917428e-01f, 1.12767611e-02f, 8.67110565e-02f, 2.26930752e-02f, -3.15034464e-02f, -3.37338634e-02f, 9.01169032e-02f, 1.32381946e-01f,
  -6.34871423e-02f, 1.20245367e-01f, 6.25256263e-03f, 1.55932069e-01f, -2.80919045e-01f, 2.80215442e-01f, 9.60050151e-02f, -6.03161193e-02f, -1.96981296e-01f, 1.48804516e-01f,
  -1.04456590e-02f, -8.41148123e-02f, 8.52540806e-02f, 1.57040790e-01f, -9.26328227e-02f, 7.32397661e-02f, -1.23548843e-01f, 9.58498195e-02f, -1.43102154e-01f, -1.49970338e-01f,
  -2.41511059e-03f, -1.19742908e-01f, -1.95561722e-02f, 1.64710626e-01f, -7.57062361e-02f, 7.92680960e-03f, 4.89440337e-02f, 8.78178626e-02f, 1.27359882e-01f, -8.89572874e-02f,
  3.35780196e-02f, -8.60982388e-03f, 5.35621382e-02f, -2.26063430e-01f, -2.29179766e-02f, 9.19903442e-02f, 1.72314588e-02f, 2.44087614e-02f, 4.16847020e-02f, 2.19078004e-01f,
  -1.10285031e-02f, 1.85908098e-02f, -4.96326163e-02f, -8.88376555e-04f, 2.35478673e-02f, -1.33531252e-02f, 2.81350166e-02f, -1.16446309e-01f, 6.57847896e-02f, 4.25624438e-02f,
  -2.91830935e-02f, 1.39059976e-01f, -8.55389703e-03f, -1.13315415e-02f, 1.11227863e-01f, 1.58427164e-01f, -8.16986039e-02f, 1.46170378e-01f, -5.42186126e-02f, 3.64391766e-02f,
  -9.52425674e-02f, -1.00549996e-01f, -1.08272105e-01f, 1.07450970e-01f, 3.09953503e-02f, -2.11998057e-02f, 1.33497164e-01f, -1.55926108e-01f, 5.37674408e-03f, 1.32961795e-01f,
  2.21039087e-01f, 1.19441368e-01f, -7.71247456e-03f, 1.32742733e-01f, -1.96168005e-01f, -5.29061481e-02f, 6.30835071e-02f, 1.35858983e-01f, 1.89325996e-02f, 2.30518281e-01f,
  8.58049318e-02f, 2.13279903e-01f, -2.04466745e-01f, -2.17185970e-02f, -1.88240573e-01f, 1.77473575e-01f, -1.52415454e-01f, 2.02364832e-01f, 4.31297868e-02f, 9.70153436e-02f,
  -1.33209720e-01f, 1.48452535e-01f, -2.63490915e-01f, -1.00450598e-01f, 1.81966707e-01f, 1.03787117e-01f, -3.76855806e-02f, 1.24571070e-01f, 1.42919691e-03f, 1.82602238e-02f,
  -5.83315194e-02f, -1.43465148e-02f, -5.44438064e-02f, -2.53631294e-01f, 4.98824939e-02f, 5.73564917e-02f, -1.38563767e-01f, 8.56108516e-02f, -2.67012534e-03f, 1.02501780e-01f,
  1.38979837e-01f, 1.43414527e-01f, -3.71835823e-03f, 6.98341280e-02f, 1.04765221e-01f, 1.82383768e-02f, 1.65405557e-01f, 1.60084590e-02f, -2.99557019e-02f, 1.63823858e-01f,
  1.60576463e-01f, -3.60056758e-03f, -2.37190742e-02f, 1.28285661e-01f, 9.64327753e-02f, 2.01896340e-01f, -1.31169006e-01f, 7.87862018e-02f, 4.18296158e-02f, 1.30310014e-01f,
  -6.20665178e-02f, 1.59737855e-01f, 1.07693281e-02f, -4.13452126e-02f, -1.64534569e-01f, -4.83680069e-02f, -6.37727305e-02f, -6.06035767e-03f, 1.96877003e-01f, -1.03506073e-01f,
  1.03945188e-01f, -1.83782652e-01f, 1.06199570e-01f, -1.69406459e-01f, 2.67077629e-02f, 4.96792868e-02f, 5.60563505e-02f, 4.80947271e-02f, 1.77543432e-01f, -6.97446838e-02f,
  6.96158037e-02f, -1.15417555e-01f, 1.15786038e-01f, -3.90762351e-02f, 1.88797526e-02f, -8.98621455e-02f, 5.62601201e-02f, 1.49026224e-02f, 1.39380498e-02f, 1.21931098e-01f,
  1.09994963e-01f, 2.45656110e-02f, -1.46163583e-01f, 4.01649736e-02f, 1.42142355e-01f, 1.14770330e-01f, 5.60164116e-02f, -2.76306897e-01f, -8.43431354e-02f, 1.46990150e-01f,
  1.52556911e-01f, 7.11412579e-02f, 5.61281405e-02f, 1.27854243e-01f, -2.33992208e-02f, 7.88164809e-02f, -3.33917923e-02f, -4.09668423e-02f, -3.51006836e-02f, 9.41319466e-02f,
  2.12565005e-01f, 9.83746946e-02f, 6.17034324e-02f, -7.78822079e-02f, 9.14805196e-03f, -6.44487739e-02f, -4.50073779e-02f, 2.80742019e-01f, 1.75115556e-01f, -6.25904799e-02f,
  1.23045363e-01f, -2.29182556e-01f, 1.85254246e-01f, 2.23946556e-01f, 2.43436880e-02f, 8.67237449e-02f, 2.62573928e-01f, -3.12132269e-01f, -1.18727930e-01f, -9.91779491e-02f,
  -7.55640119e-02f, 8.21061581e-02f, 1.18353330e-01f, -1.88029066e-01f, 2.58995414e-01f, -1.55835018e-01f, -8.74356478e-02f, -1.58695549e-01f, -1.62346095e-01f, -1.16735883e-01f,
  2.29244635e-01f, -1.48571432e-01f, 5.10961302e-02f, 9.03738365e-02f, 6.47856519e-02f, -8.35765153e-02f, 6.03233986e-02f, 5.79090863e-02f, -1.03560783e-01f, -1.79640800e-02f,
  1.48021102e-01f, -5.01154810e-02f, -2.78601766e-01f, -1.21086128e-01f, -3.18000950e-02f, -4.87723351e-02f, 1.22045010e-01f, 6.21100441e-02f, -6.63251281e-02f, 7.19890594e-02f,
  -8.06208178e-02f, -8.68986547e-02f, 9.68463495e-02f, -1.57321706e-01f, -6.10398613e-02f, 3.51403345e-04f, 1.24425493e-01f, -8.16102475e-02f, -1.24117792e-01f, -4.58396878e-03f,
  -6.70941593e-03f, -1.14466563e-01f, 5.48933260e-02f, 3.72362119e-04f, -1.22446651e-02f, 3.46201696e-02f, -5.35116531e-02f, -7.94225484e-02f, -1.44858390e-01f, 9.69450995e-02f,
  7.31363147e-02f, -1.26720458e-01f, 8.62985030e-02f, -9.63753462e-02f, 8.42676964e-03f, -1.44774849e-02f, -1.06575228e-01f, -9.05433446e-02f, -4.66527194e-02f, -2.27980524e-01f,
  -3.85350399e-02f, -8.53893459e-02f, -1.13415986e-01f, -7.76327774e-02f, 5.16036488e-02f, 9.73169059e-02f, -1.46702733e-02f, -7.50435516e-02f, 7.02479631e-02f, 1.30303517e-01f,
  1.76005408e-01f, 4.48637716e-02f, 7.12863952e-02f, -1.07296169e-01f, -1.64942462e-02f, 3.70695591e-02f, -9.14895236e-02f, -1.41782565e-02f, -9.26909968e-02f, -5.33649623e-02f,
  8.94694999e-02f, -1.23046212e-01f, -6.45154109e-03f, -6.04362302e-02f, -1.33474827e-01f, 4.32444066e-02f, -9.65005383e-02f, -1.18592151e-01f, -8.41404498e-02f, 1.25936508e-01f,
  9.39068794e-02f, -1.18789122e-01f, 1.11718796e-01f, 3.29667814e-02f, -7.21084327e-02f, 1.11296110e-01f, -1.16580404e-01f, -1.20372929e-01f, -7.87848830e-02f, -1.73760243e-02f,
  -1.08061500e-01f, 1.12213783e-01f, -7.14242011e-02f, 1.05379976e-01f, -1.71967167e-02f, -1.29969507e-01f, -6.51559886e-03f, 3.34415846e-02f, -1.21230498e-01f, 4.51857522e-02f,
  1.42440054e-04f, 3.48602124e-02f, -6.25409633e-02f, 1.33400068e-01f, 7.35022202e-02f, -1.83678284e-01f, 3.98276076e-02f, -1.71886563e-01f, 2.03375574e-02f, -2.98822112e-02f,
  2.29836721e-02f, -5.62757850e-02f, -3.01312972e-02f, -8.80698413e-02f, 3.68943028e-02f, -7.95966461e-02f, -1.04822874e-01f, 1.28765315e-01f, 3.14475179e-01f, -8.93286243e-02f,
  -9.57997888e-02f, -1.53923169e-01f, -7.36031532e-02f, -8.85759592e-02f, 1.22732736e-01f, -2.60919910e-02f, 1.03168711e-01f, -1.25462085e-01f, -1.62751153e-01f, 9.34802555e-03f,
  -2.06657529e-01f, -1.58101600e-02f, 1.40492037e-01f, -1.68530762e-01f, 1.18948124e-01f, -2.06409469e-01f, -1.29064307e-01f, 3.57225202e-02f, -2.72958189e-01f, -3.68522368e-02f,
  -5.04586771e-02f, 4.10800390e-02f, 5.56334518e-02f, 4.78597879e-02f, 1.45316198e-01f, 4.13632169e-02f, 2.13837743e-01f, -2.09220350e-02f, 3.07364762e-02f, -1.20036587e-01f,
  -8.10718685e-02f, -1.41048729e-01f, -3.46442088e-02f, -6.12106547e-02f, -2.62607597e-02f, 8.32015947e-02f, 1.23419508e-01f, -6.22512884e-02f, 1.07217021e-01f, 2.44722562e-03f,
  -2.86000185e-02f, 8.82577598e-02f, -4.48499471e-02f, 3.99277434e-02f, 1.18804052e-01f, -9.49990470e-03f, -7.09625334e-02f, -2.00096481e-02f, -1.89987700e-02f, -8.76252800e-02f,
  4.18567546e-02f, 3.40584777e-02f, -1.00736089e-01f, -3.48924398e-02f, -8.22635368e-02f, -2.47756660e-01f, 8.01316053e-02f, -2.02736199e-01f, 2.14403421e-01f, -5.78614846e-02f,
  2.62368955e-02f, 3.11639179e-02f, -3.62245664e-02f, -2.37025589e-01f, -4.13858220e-02f, 8.44678283e-02f, -7.68482685e-02f, -8.36199746e-02f, 1.89195514e-01f, 2.46632814e-01f,
  5.91514586e-03f, 7.27675706e-02f, -3.15449797e-02f, 1.18152745e-01f, -2.23134771e-01f, 1.39263928e-01f, -3.77396762e-04f, -2.08869994e-01f, -2.79025808e-02f, -1.12970628e-01f,
  -7.88264498e-02f, 7.08442256e-02f, -2.82266647e-01f, 1.02137782e-01f, -1.43409342e-01f, 1.80473149e-01f, -4.13032770e-02f, 2.63810456e-01f, -1.98091641e-02f, 6.77298829e-02f,
  -5.47860898e-02f, 2.08109319e-02f, 1.20507509e-01f, 3.73906851e-01f, 1.82513520e-02f, 5.22064567e-02f, 1.26447812e-01f, 6.76627904e-02f, 9.80615169e-02f, 1.38782769e-01f,
  1.01629682e-01f, 1.03991374e-01f, 6.87705912e-03f, 3.98309380e-02f, 1.82396039e-01f, 6.81026885e-03f, -7.83826411e-02f, 2.14696318e-01f, 4.21696864e-02f, 8.13165214e-03f,
  1.26948804e-01f, 2.27528661e-01f, -7.45066330e-02f, -1.49562925e-01f, -7.57204890e-02f, -5.83194941e-02f, -6.48150146e-02f, 1.87230468e-01f, -6.44262210e-02f, -7.30395541e-02f,
  -2.20327415e-02f, 1.64748967e-01f, -2.36343324e-01f, 2.52982229e-01f, 1.14493810e-01f, 2.79755116e-01f, -6.16092868e-02f, 1.63371280e-01f, -1.06681790e-02f, 5.07236533e-02f,
  -5.95940351e-02f, 1.18169725e-01f, 6.68603703e-02f, 5.72497062e-02f, 1.53889105e-01f, 2.17132136e-01f, -2.96847433e-01f, -1.78695656e-02f, -9.08183493e-03f, 2.98426114e-02f,
  -1.00030065e-01f, 2.39644438e-01f, 5.91002405e-02f, 1.64554626e-01f, 1.09519303e-01f, 5.01097878e-03f, -2.11125776e-01f, -6.88989609e-02f, 1.47356763e-01f, 1.46092936e-01f,
  -1.09825678e-01f, 1.38526395e-01f, 1.15307368e-01f, 1.53679535e-01f, 1.10290989e-01f, -8.75191912e-02f, 6.91194739e-03f, 2.07905754e-01f, -8.76769572e-02f, -8.94184709e-02f,
  -2.35807076e-02f, 6.25573769e-02f, -3.40385246e-03f, -3.07879075e-02f, -1.64216310e-02f, -4.53492999e-02f, 6.30413322e-03f, -1.70712575e-01f, -6.55497685e-02f, 1.44938789e-02f,
  -3.11434656e-01f, -6.83417171e-02f, 4.02234569e-02f, -5.19402251e-02f, 1.02460440e-02f, 1.70559645e-01f, 1.60965353e-01f, -2.30852544e-01f, -8.73190071e-03f, -6.20689355e-02f,
  9.47700217e-02f, 4.47047539e-02f, -1.95768431e-01f, -1.62026569e-01f, 2.64444835e-02f, -6.97428957e-02f, 2.69130501e-03f, 1.10076249e-01f, 1.51414350e-01f, -9.22717378e-02f,
  1.12404332e-01f, -4.40965034e-02f, -1.62747651e-01f, 8.70516151e-02f, -1.66970432e-01f, 2.48534158e-01f, 3.79739590e-02f, 5.06843626e-02f, 4.78026681e-02f, -9.75264162e-02f,
  -2.90555745e-01f, 2.04023406e-01f, -3.20077300e-01f, -6.64907843e-02f, -8.82844999e-02f, 6.63315654e-02f, -1.09150440e-01f, 1.14324586e-02f, 5.29285967e-02f, 1.92140177e-01f,
  -2.95384705e-01f, 1.69597998e-01f, 7.20419958e-02f, 2.52421163e-02f, -1.37486070e-01f, 1.79188251e-01f, 1.46878257e-01f, 1.73229769e-01f, -7.27715120e-02f, 1.08706400e-01f,
  1.56016931e-01f, -1.11888424e-01f, 6.93896087e-04f, 1.81098849e-01f, 1.17214911e-01f, -3.22289318e-02f, -7.23620132e-02f, -6.82322085e-02f, 5.89325428e-02f, 1.56062931e-01f,
  1.13872536e-01f, 3.63090187e-02f, 7.82576799e-02f, 1.27795953e-02f, 5.83091117e-02f, 1.14852943e-01f, 1.18817739e-01f, 2.99372017e-01f, 4.27647978e-02f, -4.57956083e-02f,
  3.18970121e-02f, 2.00390145e-02f, 1.53894439e-01f, 2.19490775e-03f, 9.78586599e-02f, 2.33985975e-01f, 1.76482096e-01f, 2.57908612e-01f, 2.01424196e-01f, 6.35713413e-02f,
  -1.06647938e-01f, -9.71981734e-02f, 1.72259167e-01f, -1.10665075e-01f, 1.81891456e-01f, 1.06082909e-01f, -1.14817090e-01f, 4.42458130e-03f, 1.29287913e-02f, -2.49645263e-01f,
  -9.37567353e-02f, -4.12984602e-02f, 1.59493998e-01f, -5.70953451e-03f, -7.11188242e-02f, -1.24079905e-01f, 4.79015075e-02f, 2.25581199e-01f, 8.53473991e-02f, 4.33066189e-02f,
  -4.66648787e-02f, -1.94072966e-02f, -5.72994575e-02f, -8.81173015e-02f, -1.91277474e-01f, 8.34246911e-03f, -6.90432936e-02f, -1.79480240e-02f, 1.04418524e-01f, 5.30079901e-02f,
  -4.75823991e-02f, 1.04564801e-01f, -1.38355583e-01f, -1.31784780e-02f, 1.18526883e-01f, 1.99600622e-01f, -1.13298818e-01f, 1.97196677e-01f, -2.26015355e-02f, -1.06954068e-01f,
  6.55561388e-02f, -2.84819491e-02f, -1.02434292e-01f, 3.65754329e-02f, -1.15074910e-01f, -1.75481334e-01f, -3.01680081e-02f, -6.23367131e-02f, -5.17736413e-02f, 3.58380266e-02f,
  9.76025015e-02f, 5.60768507e-02f, -1.08492367e-01f, -6.64310828e-02f, -9.01276097e-02f, -7.70147368e-02f, 3.37009095e-02f, -1.46070838e-01f, -1.93021055e-02f, 2.79607028e-01f,
  -1.98186338e-02f, 2.44835973e-01f, 1.83462784e-01f, 1.97442770e-02f, -2.57178098e-01f, 1.78152859e-01f, 2.83036560e-01f, -7.48835951e-02f, 1.03714108e-01f, 8.48960653e-02f,
  -1.64365977e-01f, -1.65286645e-01f, -3.79361375e-03f, -3.45658115e-03f, -3.37975062e-02f, -1.13097876e-02f, 2.77061254e-01f, 2.29244098e-01f, -2.58877009e-01f, -1.45477712e-01f,
  8.77072215e-02f, -1.24558844e-01f, 1.45864695e-01f, 2.81458527e-01f, 1.03108883e-01f, 1.50525406e-01f, 2.01234128e-03f, 1.17852176e-02f, -4.58346792e-02f, 4.81956303e-02f,
  -2.20791977e-02f, -4.96045779e-03f, 3.31275612e-02f, -1.14437632e-01f, -1.85534239e-01f, 7.73748234e-02f, 1.66707158e-01f, 6.94995597e-02f, -4.59248275e-02f, 2.27622911e-01f,
  -2.52959486e-02f, 4.68542241e-02f, 6.01914935e-02f, 1.42690524e-01f, -1.03391245e-01f, 2.27413345e-02f, -6.83893785e-02f, 2.54543126e-02f, 2.22562887e-02f, -9.54139531e-02f,
  -6.10782169e-02f, -1.53917804e-01f, 7.55117461e-02f, -7.12102046e-04f, -1.17023349e-01f, -7.18639493e-02f, 1.32455021e-01f, -9.44623277e-02f, 8.62985626e-02f, 1.34198338e-01f,
  5.18328277e-03f, 1.45109698e-01f, -8.65665544e-03f, -4.16721739e-02f, 7.74157494e-02f, 3.06968968e-02f, -1.49665788e-01f, 1.01055562e-01f, -2.45604590e-01f, 2.52874583e-01f,
  1.60915136e-01f, 9.60371643e-02f, -1.17806114e-01f, -1.90796424e-02f, 7.02449977e-02f, 2.26661876e-01f, 1.96130015e-02f, 2.49472052e-01f, 4.29581665e-03f, -8.56111050e-02f,
  -1.80862918e-02f, 1.57649040e-01f, -1.70966193e-01f, -1.01882175e-01f, 9.15456116e-02f, -2.64197052e-01f, -5.78211993e-02f, 2.50122845e-01f, -1.34516105e-01f, -3.90099697e-02f,
  6.73743337e-02f, 8.39873552e-02f, 1.39545128e-01f, 1.15952976e-01f, 7.86689147e-02f, 9.09496918e-02f, 2.19780821e-02f, -3.02686781e-01f, 3.47770452e-02f, 4.62775566e-02f,
  -7.52440020e-02f, -9.85946506e-02f, 4.99117039e-02f, -2.64698356e-01f, 6.38133287e-02f, 7.93795884e-02f, -9.76985022e-02f, -5.84590994e-02f, -9.04997513e-02f, -1.79278050e-02f,
  -1.09995961e-01f, 7.28148744e-02f, 1.93611458e-02f, 6.30076081e-02f, -5.77560589e-02f, 1.15439080e-01f, -3.13715972e-02f, 2.13491675e-02f, -6.21478483e-02f, -1.02162108e-01f,
  6.55504838e-02f, -1.19280562e-01f, 6.47898391e-02f, 1.26569614e-01f, -4.99325395e-02f, 7.43154883e-02f, -1.07734770e-01f, -1.68970332e-01f, 1.93568505e-02f, 1.60673819e-02f,
  -1.57796114e-03f, 3.65473032e-02f, 2.99406886e-01f, -2.38729045e-01f, 4.93463548e-03f, -2.03499585e-01f, -1.47283286e-01f, -6.57177120e-02f, -2.95716189e-02f, -1.53583139e-01f,
  2.06581235e-01f, -1.30135387e-01f, -1.73717812e-01f, -3.04062711e-03f, -1.34620875e-01f, -2.12256774e-01f, 1.56290412e-01f, 1.52138442e-01f, -3.34472470e-02f, 2.07479864e-01f,
  -8.97385553e-02f, -7.97505677e-02f, -6.09838823e-03f, -3.86596262e-03f, 1.05006918e-01f, 1.90881640e-01f, 1.40657991e-01f, -3.66126075e-02f, -1.99953705e-01f, 5.91543168e-02f,
  -4.78383340e-02f, 4.37068939e-02f, 1.74457178e-01f, -6.12338260e-02f, -1.94876701e-01f, 1.27505004e-01f, -1.47147387e-01f, 5.08213788e-02f, -3.10174767e-02f, -6.37665093e-02f,
  -9.82991755e-02f, 1.15492843e-01f, 1.88065886e-01f, -6.38574213e-02f, 4.84687909e-02f, -1.56757563e-01f, 2.46091317e-02f, 8.56568739e-02f, 1.11602776e-01f, -4.27849554e-02f,
  1.40760047e-02f, 4.68039326e-02f, 4.13283333e-02f, -2.53641605e-02f, 1.47420585e-01f, 5.42648844e-02f, 1.11271709e-01f, -4.01542820e-02f, 2.50554029e-02f, 6.09549023e-02f,
  -7.87632167e-02f, -1.65587738e-01f, -1.14612848e-01f, -2.49361902e-01f, -2.53473967e-01f, -1.60518229e-01f, 1.54800117e-01f, 3.99420373e-02f, -1.55323207e-01f, -1.12340972e-01f,
  -1.86598495e-01f, -5.17912954e-02f, -2.14764923e-01f, 1.12915851e-01f, -1.92372754e-01f, 1.59486294e-01f, -5.75269163e-02f, 2.56236315e-01f, -2.52863407e-01f, -1.65760472e-01f,
  -2.50536781e-02f, 2.03390703e-01f, -2.13364363e-01f, 2.03673299e-02f, -2.65281439e-01f, -5.24389446e-02f, 2.71766633e-02f, -1.83918715e-01f, 4.29381505e-02f, 3.43438983e-02f,
  -1.04401326e-02f, 5.92646450e-02f, 1.34136319e-01f, 1.10979021e-01f, -1.11181617e-01f, 9.94646102e-02f, 1.00529172e-01f, 1.02851130e-01f, -3.15017924e-02f, 4.40937765e-02f,
  2.89188623e-02f, 3.37159038e-02f, -1.34696160e-02f, -2.38247499e-01f, 8.71061012e-02f, -1.74535841e-01f, -1.29967108e-01f, -1.70696840e-01f, 3.64622809e-02f, -1.44620165e-02f,
  -5.17651066e-02f, -1.39822327e-02f, -9.74257365e-02f, -6.40357956e-02f, -6.28014058e-02f, 4.94034076e-03f, -6.89228252e-02f, -1.09326132e-01f, -1.41442120e-01f, 7.57256225e-02f,
  6.41424432e-02f, -1.64341666e-02f, 4.16989885e-02f, 9.69170183e-02f, -9.69163850e-02f, -1.27426490e-01f, -1.61851302e-01f, -1.08463302e-01f, -1.35030411e-02f, -1.03557727e-03f,
  1.45607948e-01f, 2.90904734e-02f, -2.00621590e-01f, 2.27581598e-02f, 3.09416205e-02f, -1.01235963e-01f, -1.39563411e-01f, -8.36297683e-03f, -3.38736475e-02f, 4.44570035e-02f,
  3.64449173e-02f, 1.79435566e-01f, -7.53072426e-02f, -1.63088962e-01f, 1.21919690e-02f, 2.46186703e-02f, -1.20723426e-01f, 1.46226853e-01f, -2.24202842e-01f, -7.96611682e-02f,
  -3.63627076e-02f, -3.20764557e-02f, -8.24725702e-02f, 1.72422543e-01f, -2.49202877e-01f, 8.70233551e-02f, -4.52841595e-02f, 2.78382897e-01f, 1.04488455e-01f, 5.54614961e-02f,
  -1.05502330e-01f, -7.14104697e-02f, 1.21617414e-01f, 7.59277791e-02f, -1.46446496e-01f, 9.47587937e-02f, 8.95639658e-02f, 1.51239127e-01f, -9.95980725e-02f, -7.03005716e-02f,
  5.72705567e-02f, 3.91331837e-02f, -7.03307390e-02f, -1.40370473e-01f, 1.59470364e-01f, -4.70005535e-02f, 2.75753606e-02f, -1.30476743e-01f, -9.73523408e-02f, -5.20368293e-02f,
  -4.13900148e-03f, -1.87959298e-01f, 8.43912736e-02f, 7.07466751e-02f, 1.04535073e-02f, -1.40262514e-01f, 7.01825470e-02f, -1.55445248e-01f, 6.99312836e-02f, -1.29409179e-01f,
  -1.08161986e-01f, -1.31402373e-01f, -7.66336843e-02f, -1.83924392e-01f, -2.44472787e-01f, 2.23539278e-01f, 1.23178959e-01f, -1.33279264e-01f, 1.14583977e-01f, -2.30704680e-01f,
  -9.79309306e-02f, 2.62238383e-01f, -2.34184831e-01f, 1.82188630e-01f, 8.80988240e-02f, 2.21519217e-01f, -2.26587895e-03f, 7.06263781e-02f, -6.26988560e-02f, 3.13967131e-02f,
  5.51656298e-02f, -2.29727581e-01f, -1.34417582e-02f, 3.83623093e-02f, -2.96127852e-02f, 1.59517564e-02f, 9.15230885e-02f, -1.90590844e-01f, 1.38235345e-01f, 4.81901467e-02f,
  1.21395215e-01f, -3.15047324e-01f, 6.18571881e-03f, 1.92988619e-01f, 2.86308546e-02f, -3.98385152e-02f, 5.46465814e-02f, -1.27244825e-02f, 8.14910904e-02f, 2.04541862e-01f,
  -1.47584304e-01f, 2.00382564e-02f, -8.45891163e-02f, 5.87075762e-02f, 1.33090988e-02f, 3.38356271e-02f, 1.96634069e-01f, 1.81972014e-03f, 1.24524660e-01f, -7.31678531e-02f,
  -4.11057249e-02f, -1.19577900e-01f, -1.35926366e-01f, 1.19544469e-01f, 1.09932818e-01f, 1.73984930e-01f, -1.09566838e-01f, 2.01203242e-01f, 7.60363340e-02f, -1.47071749e-01f,
  -9.44169089e-02f, -8.43798742e-03f, -5.16717099e-02f, 6.77005798e-02f, 8.23119953e-02f, -4.33460549e-02f, -5.72182201e-02f, 9.48412642e-02f, 1.08757630e-01f, 1.53730949e-02f,
  -4.74983752e-02f, 2.11159393e-01f, 1.39827922e-01f, 1.36268377e-01f, 2.70347167e-02f, 5.47579452e-02f, 6.80504516e-02f, -3.09611131e-02f, 1.85180053e-01f, -1.16986461e-01f,
  1.58368513e-01f, 2.27574259e-02f, -2.10515738e-01f, 6.19387850e-02f, -2.35724583e-01f, 8.70481953e-02f, -1.21145975e-02f, -7.01754540e-02f, -1.58138752e-01f, 1.02167912e-01f,
  -3.49609628e-02f, 2.68491656e-01f, -2.84669131e-01f, -1.01675838e-01f, -1.11590497e-01f, 3.60248476e-01f, 3.92512120e-02f, -1.50598615e-01f, 1.23027191e-01f, -1.07627800e-02f,
  1.52651608e-01f, -1.16022788e-01f, 8.49560946e-02f, -4.80661318e-02f, -8.35624188e-02f, -1.94333062e-01f, -4.83206026e-02f, -1.27222449e-01f, -1.09187132e-02f, -1.14046082e-01f,
  -8.85748267e-02f, -1.68585643e-01f, -2.96868035e-03f, 1.00854300e-01f, -2.69676093e-02f, 2.24570632e-02f, -1.51195452e-01f, -1.94968507e-01f, -1.01624861e-01f, -1.62062958e-01f,
  -1.27908736e-01f, -1.09037869e-01f, 7.12826243e-03f, 1.84756562e-01f, 5.49088381e-02f, -4.61324526e-04f, 8.66026338e-03f, -1.55337468e-01f, -1.11460276e-01f, -2.20975205e-01f,
  -7.05775693e-02f, -9.70339850e-02f, 4.14291434e-02f, -8.11074078e-02f, -8.14786032e-02f, 3.88848595e-02f, -2.21566349e-01f, 4.48990874e-02f, 1.43306151e-01f, -5.90703189e-02f,
  1.03604510e-01f, 2.02089831e-01f, -1.02191061e-01f, 1.95852160e-01f, -2.28809625e-01f, -1.79858819e-01f, -7.43195340e-02f, 1.55499697e-01f, -6.73320377e-03f, 8.63419250e-02f,
  -2.81926662e-01f, -1.58025399e-01f, -5.89265721e-04f, 7.95856044e-02f, -5.83865345e-02f, 2.50305176e-01f, -4.85901125e-02f, -1.15088634e-01f, 1.46850288e-01f, 7.32652098e-02f,
  -8.97654071e-02f, -1.63328707e-01f, 7.01507851e-02f, 9.53741148e-02f, -9.43630040e-02f, -1.23579241e-01f, 4.01935056e-02f, 1.70691058e-01f, -1.41681908e-02f, 2.37182900e-01f,
  1.32515579e-01f, 5.08254990e-02f, 1.48360237e-01f, 2.28996754e-01f, -6.75454661e-02f, -3.39562483e-02f, -1.21024558e-02f, -2.81458292e-02f, -1.77255180e-02f, -1.33910868e-02f,
  7.93137327e-02f, -4.52286713e-02f, 8.90785307e-02f, 1.81771100e-01f, 1.10367243e-03f, 8.95963386e-02f, 1.16429679e-01f, -6.55448958e-02f, 1.27334157e-02f, 1.06199056e-01f,
  1.63110420e-01f, 1.64057568e-01f, 4.25237156e-02f, 1.17661934e-02f, 2.25087255e-02f, 1.01114579e-01f, -8.22708160e-02f, 6.63578808e-02f, 1.22073971e-01f, -9.40577760e-02f,
  2.27880612e-01f, 3.96026634e-02f, 5.64576536e-02f, 1.36482626e-01f, -7.16238990e-02f, 4.67526093e-02f, -5.82132163e-03f, -2.41450574e-02f, 1.65741369e-01f, 1.08094484e-01f,
  4.02841382e-02f, -1.73758253e-01f, 2.80005969e-02f, -1.50055170e-01f, 1.78596526e-01f, 2.68522948e-01f, 1.10088497e-01f, 1.09453686e-01f, -4.84450050e-02f, -1.11337334e-01f,
  1.38607323e-01f, 1.29725426e-01f, 1.75109461e-01f, -1.79384515e-01f, 1.36024192e-01f, -9.22027752e-02f, -2.65099611e-02f, -1.52715622e-02f, -3.81812230e-02f, -8.46618637e-02f,
  -6.26549423e-02f, -4.45604995e-02f, 3.93073410e-02f, 6.70787990e-02f, -1.25778884e-01f, 6.32389858e-02f, 8.08193460e-02f, -6.32991269e-02f, -1.10330544e-01f, 1.40994117e-01f,
  1.00868652e-02f, -1.38890475e-01f, 1.40071139e-01f, 1.09048620e-01f, 6.14150912e-02f, 2.00119466e-01f, 3.89588736e-02f, 3.88106331e-02f, 1.19164839e-01f, -3.63382921e-02f,
  3.53908464e-02f, -2.13775039e-01f, -1.28832370e-01f, -7.88193271e-02f, 2.40801834e-02f, 5.00987545e-02f, 1.14865839e-01f, 1.73485223e-02f, -1.32675646e-02f, -1.11976720e-01f,
  9.18289125e-02f, -1.70296989e-02f, 9.20826867e-02f, -9.88688394e-02f, 2.16699705e-01f, 7.04335645e-02f, -1.79549485e-01f, 5.68401739e-02f, 1.93745475e-02f, -7.05227926e-02f,
  1.70004487e-01f, -6.93083182e-02f, 2.28644013e-01f, -1.08836211e-01f, -1.38287455e-01f, 1.55402929e-01f, -1.79123968e-01f, 3.53918485e-02f, 1.18961304e-01f, -8.50002542e-02f,
  -7.55461305e-02f, 3.76757868e-02f, 2.67244093e-02f, -4.98068072e-02f, -2.67490596e-01f, -2.92463601e-03f, 6.21471480e-02f, 2.44819187e-02f, -1.54211551e-01f, 3.13136369e-01f,
  -3.63185257e-02f, 9.53499079e-02f, -5.57149798e-02f, -1.12551944e-02f, 1.84131250e-01f, -1.01902336e-01f, 7.67680556e-02f, -2.08009798e-02f, 1.71447396e-01f, 2.44881082e-02f,
  -9.57850832e-03f, 8.43317136e-02f, 1.47049315e-02f, -8.89527351e-02f, 9.90563817e-03f, 1.11189008e-01f, -5.78853535e-03f, 6.89139888e-02f, -1.85353830e-01f, -1.33409813e-01f,
  -1.02145776e-01f, -3.95795330e-02f, 4.50668857e-02f, 1.43231200e-02f, 1.13092083e-02f, 2.19453603e-01f, 8.31381083e-02f, 2.31408551e-02f, 1.47542372e-01f, -3.58248241e-02f,
  5.43141318e-03f, 1.56961784e-01f, -6.96348073e-03f, 2.19301626e-01f, -1.50256976e-01f, -1.15254290e-01f, 9.76319835e-02f, 5.76288253e-02f, 7.86981266e-03f, 2.10799143e-01f,
  8.37142952e-03f, -7.20004961e-02f, 1.52838483e-01f, -1.70126960e-01f, -1.94196090e-01f, -9.31777433e-02f, -8.73381421e-02f, -1.21673554e-01f, 6.11817464e-02f, -2.32673675e-01f,
  1.50230616e-01f, 1.09291270e-01f, 1.19943202e-01f, 1.55688241e-01f, -4.08262238e-02f, -6.91814572e-02f, -1.99601278e-02f, -9.16963592e-02f, 1.10963754e-01f, -1.15110345e-01f,
  1.40166372e-01f, 3.25450674e-02f, 1.05791919e-01f, 3.45914103e-02f, 8.54647625e-03f, 1.66892946e-01f, -2.28266865e-01f, 1.17976293e-01f, -1.60978556e-01f, 6.63074553e-02f,
  2.51091104e-02f, -4.92024012e-02f, -7.14512765e-02f, 5.69668189e-02f, 1.58309087e-01f, 9.03963968e-02f, -2.65395851e-03f, -2.63665587e-01f, 1.22476481e-01f, 1.24999918e-02f,
  1.58130061e-02f, -9.38453972e-02f, 8.40380862e-02f, 6.41955733e-02f, -1.08265214e-01f, -8.93825516e-02f, 2.21671015e-02f, -1.06932364e-01f, 1.63671061e-01f, -8.19617976e-03f,
  -9.61135477e-02f, -3.63129042e-02f, 9.62847099e-02f, -1.09465562e-01f, -1.21582784e-01f, -2.71060258e-01f, -1.87431108e-02f, -2.99242646e-01f, -1.77808329e-02f, 2.34247118e-01f,
  -2.18142867e-02f, 2.68311985e-02f, 6.27339259e-02f, -2.02449009e-01f, -5.81732914e-02f, 2.91075528e-01f, -1.70794427e-01f, 2.18638435e-01f, 1.45972386e-01f, 1.21539608e-01f,
  -1.44065142e-01f, -9.22867134e-02f, -3.01351864e-02f, 4.82127182e-02f, -2.08297395e-03f, -1.75258875e-01f, 6.24642484e-02f, 1.56946152e-01f, -4.94066579e-03f, -5.19292951e-02f,
  -6.40806779e-02f, -4.39162329e-02f, 6.42855465e-02f, 1.43933520e-01f, 3.09466012e-02f, -1.93199188e-01f, -1.05907261e-01f, 1.91965267e-01f, -2.63684597e-02f, -7.98888505e-03f,
  1.52692711e-02f, -4.55624200e-02f, -1.15209296e-01f, 1.87752217e-01f, -4.51116003e-02f, 1.63075421e-02f, 2.26954445e-02f, 3.91924009e-02f, 5.71357226e-03f, 8.08286071e-02f,
  6.93738312e-02f, -1.37967780e-01f, 4.60018292e-02f, -3.55807804e-02f, -1.12170316e-02f, 6.79953992e-02f, 2.13811249e-01f, 1.59603372e-01f, -8.68654922e-02f, 3.11007653e-03f,
  5.40543199e-02f, 6.03589183e-03f, -8.97824019e-02f, -1.16382591e-01f, -1.04178116e-01f, -8.78193695e-03f, -6.52065640e-03f, 8.98809731e-02f, 1.59082413e-01f, 8.60637426e-02f,
  5.37405908e-02f, -5.91691248e-02f, -2.71494150e-01f, 4.89130653e-02f, 1.45696491e-01f, 1.44245148e-01f, 1.65227950e-01f, -2.17969373e-01f, 5.82908876e-02f, 2.02309370e-01f,
  -5.21557815e-02f, 6.74186368e-03f, -3.58987972e-02f, 1.48347199e-01f, -2.95636733e-03f, 3.02803963e-01f, -5.77065423e-02f, -2.77381279e-02f, 1.37502030e-01f, -1.53899550e-01f,
  1.49015367e-01f, 8.95937532e-02f, 7.77409226e-02f, 1.42360613e-01f, 7.09595382e-02f, -2.96341509e-01f, 5.90018257e-02f, 3.37477475e-02f, 7.51192961e-03f, -2.01082259e-01f,
  7.47765973e-02f, 2.10086584e-01f, -9.27470550e-02f, 1.07707456e-01f, 1.61923960e-01f, -1.22491166e-01f, -1.94817111e-02f, 5.11418767e-02f, 1.45348072e-01f, 9.23828483e-02f,
  -8.70832577e-02f, -5.96054345e-02f, 1.42027913e-02f, 1.01204641e-01f, -9.72227231e-02f, 2.37802304e-02f, 5.06486595e-02f, 6.66427910e-02f, 3.48220952e-02f, 1.13389932e-01f,
  2.31639831e-03f, -2.00842723e-01f, 1.02556743e-01f, -1.12125777e-01f, 1.11566754e-02f, -8.32792297e-02f, -1.03144534e-01f, 4.21314351e-02f, -8.33123028e-02f, -4.64187711e-02f,
  -4.11346257e-02f, -1.95380777e-01f, 8.28825161e-02f, -1.77173674e-01f, 3.80282439e-02f, -9.43242237e-02f, 2.60701142e-02f, 9.44043025e-02f, 8.88537094e-02f, -7.04292953e-02f,
  -1.63477764e-01f, -1.20649457e-01f, 7.32591152e-02f, 1.34096295e-01f, -2.53419019e-02f, -1.38055861e-01f, -1.99364647e-01f, 1.90679505e-01f, -2.21173406e-01f, 1.21116519e-01f,
  1.59209996e-01f, -9.81066972e-02f, 1.95255965e-01f, -1.56856239e-01f, 1.19244710e-01f, 7.41711110e-02f, 3.05426158e-02f, -1.30470872e-01f, 6.85569718e-02f, -2.23259911e-01f,
  2.03186646e-01f, 9.02635511e-03f, 1.60160169e-01f, -2.60116160e-01f, 1.03490598e-01f, 1.76853940e-01f, 8.43751654e-02f, -5.63846640e-02f, -4.60820198e-02f, 9.32326838e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -9.74386057e-04f, -1.48843318e-01f, 2.34529465e-01f, 1.16877900e-02f, 1.14665091e-01f, 3.63295302e-02f, 3.42332758e-02f, 7.12363347e-02f, 5.05323187e-02f, 5.14185242e-02f,
  -9.47951619e-03f, 4.86566639e-03f, 4.88747396e-02f, 4.52210748e-04f, 2.37030126e-02f, 1.93444356e-01f, 1.97331458e-01f, 2.18724549e-01f, 2.05251843e-01f, -9.81252193e-02f,
  7.83810858e-03f, -1.87434003e-01f, 5.25823012e-02f, 1.60165817e-01f, -3.06041464e-02f, 1.10285267e-01f, 1.96052969e-01f, 1.78338010e-02f, -5.52085340e-02f, -2.75292784e-01f,
  1.47757709e-01f, -1.35760978e-01f, -2.22042128e-02f, -2.94372648e-01f, 7.81084970e-02f, -1.35532126e-01f, -1.63547486e-01f, -1.87553614e-01f, -1.57686383e-01f, -2.88125146e-02f,
  6.20330088e-02f, 2.13155508e-01f, -5.01437709e-02f, 1.57606471e-02f, -1.64609224e-01f, 1.79535523e-01f, -2.73718029e-01f, 1.57605171e-01f, -2.13021170e-02f, -3.13239656e-02f,
  5.15023945e-03f, -1.88429747e-02f, -3.56957619e-03f, 1.62217274e-01f, -1.94698066e-01f, 6.01705201e-02f, 5.04987277e-02f, 1.06638603e-01f, 3.12613659e-02f, 3.36300611e-01f,
  2.15584058e-02f, 1.35765508e-01f, 1.28403246e-01f, -2.38478817e-02f, 8.69916826e-02f, 1.97022781e-01f, 2.39731953e-01f, -1.34396121e-01f, 9.09871683e-02f, 1.31628260e-01f,
  2.87987739e-01f, 1.48613140e-01f, 1.89523369e-01f, -1.09882034e-01f, 2.07345977e-01f, 2.05738340e-02f, 1.74948759e-02f, -1.77915543e-02f, 4.10876051e-02f, -7.79233873e-02f,
  6.74857274e-02f, -1.45192668e-01f, 9.79058817e-02f, 1.04737513e-01f, 1.79318130e-01f, 2.42943645e-01f, 2.48286143e-01f, -6.34426344e-03f, 2.80290127e-01f, -2.55922437e-01f,
  1.60883948e-01f, -1.42683312e-01f, -2.80345201e-01f, 1.85803249e-01f, -1.39160097e-01f, 1.37215257e-01f, -9.00188610e-02f, 1.25199035e-01f, -1.53345466e-01f, 1.88117340e-01f,
  8.12659692e-03f, 2.77413368e-01f, -1.38845056e-01f, 3.01890552e-01f, -2.70178676e-01f, -1.22852877e-01f, -3.86018336e-01f, -1.15932815e-01f, 1.51976660e-01f, 4.56159003e-02f,
  1.69522792e-01f, -9.22108218e-02f, -1.85792282e-01f, -6.76734820e-02f, -1.30235717e-01f, -2.76501887e-02f, 1.37169063e-01f, 1.38413697e-01f, 4.71933126e-01f, 6.50487915e-02f,
  1.11479037e-01f, -1.63603704e-02f, -4.52720327e-03f, -1.97250634e-01f, 2.82897651e-01f, 1.57267917e-02f, -1.01019010e-01f, 1.11130606e-02f, -5.18056005e-02f, 8.06132182e-02f,
  -2.61038747e-02f, -5.13302274e-02f, 1.33371711e-01f, 1.26059279e-01f, -5.26752248e-02f, 1.21651851e-01f, -1.05531506e-01f, 6.11353572e-03f, 6.96271062e-02f, 4.63442132e-02f,
  -7.75833726e-02f, 1.16322905e-01f, 1.18857317e-01f, 4.39490657e-03f, 1.30687311e-01f, -9.24089104e-02f, 3.08628064e-02f, -8.84109214e-02f, 1.07706144e-01f, -5.25398217e-02f,
  1.97057035e-02f, -4.17125709e-02f, -4.76006716e-02f, -1.12715781e-01f, 1.24049798e-01f, 4.07989919e-02f, -1.20478563e-01f, 2.89837942e-02f, -5.89928441e-02f, 8.07887167e-02f,
  1.31489322e-01f, -1.29963666e-01f, 5.85171208e-02f, -8.50810558e-02f, -3.67755145e-02f, 5.66549487e-02f, -7.50210043e-03f, 1.30123198e-01f, 3.38872522e-02f, -6.91868663e-02f,
  -1.08549200e-01f, 2.16560122e-02f, -8.55912715e-02f, 5.87345250e-02f, -4.09212857e-02f, 7.25901052e-02f, -2.33527087e-03f, -4.57061501e-03f, 9.48942080e-02f, 6.19214214e-02f,
  7.41311088e-02f, -8.69270787e-02f, 5.84131628e-02f, 2.83701289e-02f, 8.24416243e-03f, -8.69502053e-02f, -7.95792192e-02f, 8.91694874e-02f, 1.23364385e-02f, -6.88078851e-02f,
  -1.24024898e-01f, 4.61005345e-02f, 1.20373070e-01f, 2.48535469e-01f, 6.53193444e-02f, -9.01181176e-02f, 1.16792142e-01f, 1.66191623e-01f, -2.24476159e-02f, 1.37865663e-01f,
  2.22315550e-01f, -8.59927312e-02f, 1.62076980e-01f, 1.02133609e-01f, 2.34671727e-01f, 9.46253836e-02f, -5.16854525e-02f, 2.74114218e-02f, 5.12523167e-02f, 4.49152105e-03f,
  -2.34707491e-03f, 9.84659418e-02f, 7.16340169e-02f, -8.12948272e-02f, 7.49086365e-02f, 1.46967724e-01f, 1.92561790e-01f, 8.76895115e-02f, -4.16529775e-02f, -1.71399057e-01f,
  -2.40601271e-01f, 8.86004884e-03f, -8.38923901e-02f, 1.21937223e-01f, -1.29450783e-01f, 3.07418913e-01f, 8.20545107e-02f, 1.27277032e-01f, -9.84126627e-02f, 1.31585136e-01f,
  -1.63353577e-01f, 1.46469727e-01f, 1.49462208e-01f, -8.25741738e-02f, -7.16294497e-02f, 8.41755494e-02f, -1.51701212e-01f, -3.20580341e-02f, -5.55830523e-02f, 5.61180487e-02f,
  -1.01383030e-01f, -1.02367826e-01f, -6.02414832e-03f, 8.35587382e-02f, 2.74414569e-02f, 1.70301229e-01f, -6.65856153e-02f, 1.32488809e-03f, -2.77953874e-03f, 3.78268808e-01f,
  6.42771497e-02f, -2.30723992e-02f, 5.18810712e-02f, -9.55905542e-02f, 1.57686844e-01f, 7.33758733e-02f, -1.28871826e-02f, 3.64379175e-02f, 9.35338438e-02f, 1.30594119e-01f,
  -6.58152252e-02f, -3.35880108e-02f, 3.62938978e-02f, 1.38793558e-01f, -2.27765813e-02f, -5.77810733e-03f, 1.46363929e-01f, 1.44922994e-02f, -8.18336606e-02f, 3.03572994e-02f,
  1.78558752e-02f, 6.10175207e-02f, 7.89353028e-02f, -4.43444252e-02f, 3.67129780e-02f, 8.08587149e-02f, 1.92683801e-01f, 5.78589477e-02f, 1.42966762e-01f, 5.23337014e-02f,
  1.20915473e-01f, -6.55022413e-02f, -7.31992349e-02f, 5.65875880e-02f, 7.20724165e-02f, -2.61921465e-01f, 2.65849512e-02f, 8.08389485e-03f, 2.26903195e-03f, -2.44193688e-01f,
  -1.70700073e-01f, -1.52392415e-02f, -2.31317937e-01f, -1.77333385e-01f, -1.25731722e-01f, -3.84328403e-02f, -2.00264752e-01f, 2.60681242e-01f, -1.53533340e-01f, -1.48525819e-01f,
  1.44892216e-01f, 7.16681853e-02f, -1.64925814e-01f, 1.50169998e-01f, 1.61309734e-01f, -3.78194116e-02f, 1.18132956e-01f, 1.03697933e-01f, 1.30921185e-01f, 3.35395709e-02f,
  -9.32477862e-02f, 1.16908170e-01f, 9.96830463e-02f, -1.67020813e-01f, -9.01722535e-02f, 2.84275204e-01f, 1.59132376e-01f, 1.00373231e-01f, -1.79901004e-01f, -1.16048858e-01f,
  9.36180577e-02f, -5.05232625e-02f, 3.70165333e-02f, 1.74947202e-01f, 1.16725579e-01f, 1.94093138e-01f, 9.67843309e-02f, 7.56352842e-02f, -2.43608858e-02f, -6.14130422e-02f,
  1.28356501e-01f, -3.09419166e-02f, 1.28215075e-01f, 6.39771149e-02f, 1.23055710e-03f, 1.40732184e-01f, 1.98244110e-01f, 1.74652085e-01f, 1.80536225e-01f, -6.84307218e-02f,
  7.31425267e-03f, -9.58125815e-02f, 1.78245261e-01f, 9.23675820e-02f, 6.71381652e-02f, 2.45010883e-01f, 1.33546665e-01f, -4.66439547e-03f, 1.22857958e-01f, 1.03445850e-01f,
  -6.78823739e-02f, 5.33009730e-02f, 1.54140815e-01f, -2.30304033e-01f, 3.99572998e-02f, 1.13553904e-01f, -1.18932672e-01f, 4.28688247e-03f, -4.88581322e-02f, 7.82865882e-02f,
  1.24924742e-01f, -5.06277531e-02f, 1.96592227e-01f, 1.56694382e-01f, -1.31063551e-01f, 1.15907833e-01f, -6.39603585e-02f, 7.79897943e-02f, 2.55931079e-01f, 1.08847275e-01f,
  -5.06802602e-03f, 7.96334222e-02f, 7.19227418e-02f, -2.83922311e-02f, 7.32532442e-02f, 9.07572359e-02f, -7.99050629e-02f, -4.21717167e-02f, 6.80366158e-02f, 1.64134473e-01f,
  7.59140477e-02f, 4.71358858e-02f, -1.96302421e-02f, -1.20762102e-02f, 1.68314099e-01f, 2.52875462e-02f, -1.21879339e-01f, 2.06298813e-01f, 1.68439627e-01f, 2.05248132e-01f,
  1.19138010e-01f, 1.85374856e-01f, -2.93040331e-02f, 1.20740838e-01f, 1.19257746e-02f, -4.73564081e-02f, 1.60051838e-01f, 5.10265529e-02f, 8.75369012e-02f, 2.14419693e-01f,
  1.06913432e-01f, 2.46788025e-01f, 2.74870366e-01f, -7.99560221e-05f, 2.09915116e-01f, -2.58934908e-02f, 3.40425894e-02f, 8.27452987e-02f, 1.48056328e-01f, 2.89754987e-01f,
  2.13927731e-01f, 2.90232867e-01f, 1.64158046e-01f, 2.08003610e-01f, -1.19636841e-01f, -2.46699139e-01f, -5.29475696e-03f, -8.46747085e-02f, 2.11161852e-01f, 1.96268499e-01f,
  -1.67942002e-01f, -1.03743605e-01f, 1.93965152e-01f, -1.95952877e-01f, 9.74345207e-02f, -1.47904441e-01f, 2.48673931e-01f, 6.92970827e-02f, 1.31875932e-01f, -1.38543472e-01f,
  -2.23051626e-02f, 1.89009607e-01f, 2.19583049e-01f, 1.28999516e-01f, 3.63638289e-02f, 8.02111998e-02f, 6.46288367e-03f, 1.16319128e-03f, 6.18011467e-02f, -1.05238095e-01f,
  -1.41693071e-01f, -1.03827082e-01f, -7.62157589e-02f, 1.45176455e-01f, 1.71341956e-01f, 4.89150956e-02f, -1.05545819e-01f, -1.02670349e-01f, 2.28921641e-02f, -8.29406083e-02f,
  -8.87575373e-02f, 1.69091418e-01f, -9.16942880e-02f, 7.51896203e-02f, 1.44884989e-01f, 7.49114715e-03f, 3.99067923e-02f, 9.39462110e-02f, -1.08930804e-01f, 5.02344929e-02f,
  1.14300728e-01f, -1.52811613e-02f, 3.43438536e-02f, 1.54497266e-01f, -6.36621043e-02f, 1.35847554e-01f, 7.89128318e-02f, 8.00540745e-02f, 4.40697931e-02f, 1.78796485e-01f,
  1.57411605e-01f, 8.05467740e-03f, -1.31448191e-02f, 3.56941298e-02f, 2.41220482e-02f, 9.45021063e-02f, 1.89008430e-01f, 1.96700856e-01f, -1.79979026e-01f, -4.58544381e-02f,
  1.10934086e-01f, 1.01020232e-01f, 1.17281631e-01f, 3.12931299e-01f, 1.62931178e-02f, -1.78038970e-01f, 1.58583634e-02f, -1.01305142e-01f, -1.53096989e-01f, -1.76641911e-01f,
  2.39469811e-01f, 1.71419948e-01f, -9.93142184e-03f, -6.51798397e-02f, 1.67451024e-01f, -7.86883682e-02f, 1.05361871e-01f, 7.14009479e-02f, -1.52913444e-02f, -2.44723577e-02f,
  1.12900242e-01f, 1.02893062e-01f, 1.23819955e-01f, 4.03075945e-03f, 9.51779336e-02f, 1.03445560e-01f, -8.76550972e-02f, -9.34254751e-02f, -1.09717585e-01f, -8.36711004e-02f,
  -1.15326621e-01f, 4.01746407e-02f, -5.97827025e-02f, 1.40719801e-01f, 1.04080267e-01f, 1.68523908e-01f, -6.85582459e-02f, -1.09484166e-01f, 5.64270690e-02f, 7.12965205e-02f,
  4.86923102e-03f, 7.22694322e-02f, -4.69328351e-02f, -6.76815584e-02f, -5.16801234e-03f, -6.16511106e-02f, 7.85325840e-02f, 1.28875654e-02f, -4.51253764e-02f, 1.22397274e-01f,
  1.28702551e-01f, 2.43011396e-02f, -1.11819610e-01f, -3.07540465e-02f, 8.25465620e-02f, -3.15055139e-02f, -1.06646541e-04f, -2.44696066e-03f, 9.15224478e-03f, 3.57160941e-02f,
  1.06146708e-01f, -5.84091842e-02f, -2.01118499e-01f, 1.74136505e-01f, 9.79750082e-02f, 2.77196970e-02f, 3.41398306e-02f, 5.38113853e-03f, 9.36253443e-02f, -4.75951172e-02f,
  2.23903358e-02f, 6.49130950e-03f, -8.30046907e-02f, 7.73546100e-03f, -2.40853280e-02f, 6.88218549e-02f, 3.75323966e-02f, 3.12060490e-02f, 8.54748264e-02f, -1.72023326e-01f,
  1.55696813e-02f, 6.39213622e-02f, 1.14843532e-01f, 1.53459996e-01f, 6.00411408e-02f, 6.35766983e-02f, 1.30495757e-01f, 1.07940547e-01f, -3.76863331e-02f, 1.12025335e-01f,
  -2.83298176e-02f, 4.78679836e-02f, -1.08269781e-01f, 6.99111894e-02f, -4.17847699e-03f, 9.40245986e-02f, 8.95137712e-02f, -7.73719847e-02f, -4.05986188e-03f, 1.70644745e-01f,
  -7.66553283e-02f, -6.89038411e-02f, 5.53856939e-02f, 1.44562826e-01f, 4.92145978e-02f, -1.84273683e-02f, 1.10160217e-01f, 4.92214970e-02f, 1.47574186e-01f, 1.31524112e-02f,
  2.38830686e-01f, 6.68726116e-03f, 1.64283231e-01f, 5.11657111e-02f, 1.08510725e-01f, 3.51646766e-02f, -3.87831032e-02f, -7.22026266e-03f, -1.70966461e-02f, -8.22743960e-03f,
  1.42896384e-01f, 1.92989167e-02f, 7.70442784e-02f, 1.07185496e-02f, 6.18397780e-02f, 1.15860611e-01f, -9.51261446e-02f, -9.78957117e-03f, -1.43314749e-01f, 1.44173041e-01f,
  -7.33433217e-02f, 1.23579234e-01f, 2.61549234e-01f, -1.22461721e-01f, -6.78704083e-02f, -9.60257351e-02f, -1.72180817e-01f, -8.94878432e-02f, -6.64783418e-02f, 9.26493779e-02f,
  8.96864086e-02f, -1.81719512e-01f, 2.17594147e-01f, -1.47596776e-01f, 3.91545743e-02f, -2.68426333e-02f, 1.73821330e-01f, -6.07093275e-02f, -5.52183017e-02f, -4.97490801e-02f,
  3.65058184e-01f, -7.75194764e-02f, 1.61732897e-01f, -6.30063117e-02f, 1.35388136e-01f, -1.24135561e-01f, 5.41404709e-02f, -1.72459975e-01f, 1.67200685e-01f, 9.02799740e-02f,
  -4.62143421e-02f, -5.98288476e-02f, -7.55631402e-02f, -9.34343487e-02f, 1.23791359e-01f, 5.71417529e-03f, 5.40214963e-03f, 1.21686153e-01f, -9.14272964e-02f, -1.89126842e-02f,
  8.53306204e-02f, 1.18372060e-01f, 5.20004481e-02f, 3.56600084e-03f, -5.64014167e-02f, -3.94731052e-02f, 1.09949127e-01f, 6.39207521e-03f, -1.03991427e-01f, -1.05963677e-01f,
  -4.09068801e-02f, 3.32481973e-02f, 7.36675933e-02f, 1.38678640e-01f, -3.51815782e-02f, -1.44544333e-01f, 1.56816393e-02f, 3.42047065e-02f, -1.25449538e-01f, -1.16067782e-01f,
  1.63676903e-01f, -7.67582878e-02f, -1.52743235e-01f, 9.21791345e-02f, 1.04648560e-01f, -1.17424160e-01f, 8.84179920e-02f, 2.58267466e-02f, -4.89167236e-02f, -2.07380392e-02f,
  5.62197790e-02f, -8.55035111e-02f, 4.27701361e-02f, -4.64557223e-02f, -1.19671345e-01f, -2.10430548e-02f, -2.49369573e-02f, -1.34253325e-02f, -1.14303017e-02f, -1.88004673e-01f,
  -7.58611262e-02f, -1.38534710e-01f, -1.43273130e-01f, 1.51719272e-01f, -5.73313981e-03f, 4.85695228e-02f, 5.96294329e-02f, 1.73988909e-01f, -2.81125754e-02f, 1.24854438e-01f,
  7.45918229e-02f, -8.06252286e-02f, 4.38473932e-02f, -4.92985025e-02f, -7.21465796e-02f, 2.81001866e-01f, 6.52078986e-02f, -9.50878486e-02f, 1.09249186e-02f, -5.35491519e-02f,
  1.43919721e-01f, 6.85629249e-02f, 1.73425406e-01f, 5.13135875e-03f, 1.16172127e-01f, -3.13080028e-02f, 1.19858980e-01f, 1.29946738e-01f, -1.29688561e-01f, 6.50000498e-02f,
  2.44130213e-02f, 3.13835554e-02f, -2.28656968e-03f, -3.53069641e-02f, 1.03839099e-01f, 8.04384332e-03f, 5.02328351e-02f, -1.06191590e-01f, 1.74395114e-01f, 5.78467287e-02f,
  -1.05536781e-01f, -1.02498397e-01f, -5.95092513e-02f, -3.61612551e-02f, -6.73597530e-02f, 1.03472315e-01f, 6.56745136e-02f, -8.57154131e-02f, -2.48633251e-02f, 5.54093532e-02f,
  -2.38868177e-01f, -7.21265897e-02f, -2.37531662e-01f, 3.57720256e-01f, 1.38981983e-01f, -4.62443829e-02f, -3.05837691e-02f, 4.98059765e-02f, -3.13101441e-01f, 9.98747274e-02f,
  -1.79392979e-01f, -3.18073072e-02f, -8.09991267e-03f, 5.32236695e-02f, 8.03257748e-02f, -1.35886997e-01f, -2.19199508e-02f, 2.34190926e-01f, -1.05343997e-01f, -1.43030705e-03f,
  -3.34082320e-02f, 1.94918409e-01f, -1.11741044e-01f, -5.91777377e-02f, -2.72729769e-02f, -1.95016004e-02f, 2.05461562e-01f, 5.53887822e-02f, 4.44133729e-02f, -3.12417396e-03f,
  8.81551392e-03f, 4.34631519e-02f, 1.53400719e-01f, 5.67315891e-02f, 6.68513030e-02f, -4.25878912e-03f, -1.68176349e-02f, -8.89459103e-02f, 7.55010322e-02f, -3.78219001e-02f,
  -5.74762151e-02f, -7.44701102e-02f, -2.17060968e-01f, 5.49566187e-02f, -1.98663250e-02f, 4.45270762e-02f, 9.02689546e-02f, 4.16656174e-02f, 2.25680158e-01f, 2.28962868e-01f,
  1.35356143e-01f, 1.14929199e-01f, 1.03291627e-02f, -1.56590536e-01f, -2.25590449e-02f, 2.32603098e-03f, -1.04717091e-01f, 4.93434966e-02f, -9.49803181e-03f, 3.33052431e-03f,
  3.25152427e-02f, -2.81627119e-01f, -6.47983328e-02f, 1.68556854e-01f, -1.10086516e-01f, -2.22261879e-03f, -1.78044122e-02f, 2.02986866e-01f, -1.80201173e-01f, -3.42692831e-03f,
  -1.22053228e-01f, -2.71178216e-01f, 1.29486397e-02f, 1.41399369e-01f, -1.44460529e-01f, -1.00525536e-01f, 9.39529240e-02f, -6.03819750e-02f, -6.93990663e-02f, 3.11570130e-02f,
  -3.56217590e-03f, 1.34230345e-01f, 2.83351988e-01f, 6.37584776e-02f, 5.67163005e-02f, -6.94737881e-02f, -1.39939845e-01f, -1.77369773e-01f, 4.91355844e-02f, 1.15830705e-01f,
  -2.06769839e-01f, -5.69004826e-02f, -6.98882118e-02f, -7.35456347e-02f, 1.15258910e-01f, -2.38113501e-03f, 2.61638053e-02f, -1.26758412e-01f, -4.99396473e-02f, -6.37612911e-03f,
  -1.92910538e-03f, -1.50362086e-02f, -6.45156428e-02f, -2.23224983e-02f, 1.10536791e-01f, 9.83439088e-02f, 6.18591495e-02f, 1.34750223e-02f, 1.99581236e-02f, 6.04586750e-02f,
  4.68132906e-02f, 9.69195887e-02f, 1.62239894e-02f, -2.53139678e-02f, 5.22612371e-02f, 2.94293817e-02f, -8.03202167e-02f, -3.61091904e-02f, 1.16143636e-02f, 6.39377311e-02f,
  1.79350690e-03f, -1.99865904e-02f, 1.41296694e-02f, -5.13138808e-03f, 1.67234540e-02f, -5.20678125e-02f, -1.33809730e-01f, -1.71417475e-01f, -1.14138210e-02f, -7.88977221e-02f,
  3.80678996e-02f, 7.64463544e-02f, -1.15969576e-01f, 1.59633189e-01f, -1.01869486e-01f, -1.61787748e-01f, 8.81351233e-02f, 5.40717617e-02f, 1.74385216e-02f, 1.34660080e-01f,
  -7.20525682e-02f, -3.81383784e-02f, -6.90136999e-02f, -8.36132616e-02f, -1.31200984e-01f, -7.56612793e-03f, -1.12908818e-01f, 4.90901805e-02f, -3.56859639e-02f, -5.05665056e-02f,
  -1.04281649e-01f, 2.19578803e-01f, 1.50078133e-01f, 1.23872541e-01f, 6.22169301e-03f, -9.57175344e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.91685408e-02f, 1.43420905e-01f, 7.48666003e-02f, 1.06262691e-01f, 1.10355906e-01f, -1.86203923e-02f, 1.64857417e-01f, 1.58591513e-02f, -6.34651408e-02f, 3.92691791e-02f,
  3.01740449e-02f, 1.18004687e-01f, 6.27207905e-02f, 8.56338367e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.45014122e-01f, -6.02839366e-02f, -2.40655467e-01f, -2.00087443e-01f, -3.25455755e-01f, -9.79465395e-02f, -1.53219894e-01f, -4.11891490e-01f, 2.32820630e-01f, -4.16133642e-01f,
  -2.40047649e-01f, 2.63592690e-01f, -4.72525582e-02f, -6.38898462e-02f, 2.53994856e-02f, -3.65582913e-01f, -7.65394345e-02f, 1.34001777e-01f, -7.82750472e-02f, -2.95357078e-01f,
  -6.44455180e-02f, -2.09812269e-01f, -1.97386652e-01f, 7.58976303e-03f, 4.95786034e-02f, 8.13479200e-02f, 2.79903542e-02f, -3.73792619e-01f, 4.85852659e-02f, -5.01730964e-02f,
  1.30514666e-01f, -7.82367662e-02f, -3.18524688e-01f, -3.10547411e-01f, 4.58611511e-02f, 1.67005032e-01f, 1.16927829e-02f, 1.13757830e-02f, 2.60748714e-01f, -3.99650395e-01f,
  -1.64207324e-01f, -3.31105053e-01f, -4.25760657e-01f, -2.54959702e-01f, 3.13732117e-01f, -1.19170845e-01f, -4.09586877e-02f, -2.38870725e-01f, -1.12878405e-01f, 1.21692583e-01f,
  -2.04991609e-01f, 6.98213726e-02f, -7.88530409e-02f, -3.20082605e-01f, -2.37551272e-01f, 8.29641297e-02f, 3.40677351e-01f, 3.49029273e-01f, 2.12973393e-02f, 4.16828364e-01f,
  -6.40254617e-02f, -2.83186108e-01f, 1.69326812e-01f, -1.34265780e-01f, -9.08624753e-03f, 4.00279053e-02f, 7.99176842e-02f, 4.25921530e-02f, 4.65336144e-02f, -5.84339071e-03f,
  1.99092150e-01f, 1.61699787e-01f, -1.72884688e-01f, 2.48585299e-01f, -4.48823750e-01f, 8.54457542e-02f, 1.47767872e-01f, 1.01701200e-01f, 1.81049392e-01f, -5.82811050e-02f,
  -2.35288441e-01f, -1.56977445e-01f, -2.35139757e-01f, -1.74366683e-01f, 9.53892991e-02f, -1.04771025e-01f, -1.45548776e-01f, 1.69412777e-01f, -1.65704370e-01f, 9.16050002e-02f,
  2.43856432e-03f, 2.00073093e-01f, 2.33307421e-01f, 2.51797587e-01f, -1.63772807e-01f, 1.56569719e-01f, -2.83257514e-01f, 3.41868609e-01f, -3.74162287e-01f, 3.01278830e-01f,
  1.79441720e-01f, -1.11404605e-01f, -1.81652695e-01f, -5.47442377e-01f, -3.03249002e-01f, -3.67367506e-01f, 3.94283175e-01f, -2.25055635e-01f, 2.17581749e-01f, 2.07341477e-01f,
  1.99894920e-01f, -1.04862809e-01f, -1.65767763e-02f, -3.41540217e-01f, -2.63292283e-01f, -4.25911576e-01f, -1.59724608e-01f, 2.25844793e-02f, -1.86438635e-01f, 1.49013624e-01f,
  5.96966445e-01f, 4.06275690e-01f, 1.03492714e-01f, -8.01317319e-02f, 1.14420860e-03f, -1.41131505e-01f, -1.67808160e-01f, -7.70769045e-02f, -1.34278566e-01f, 7.76724890e-02f,
  -1.41256154e-01f, 6.79756403e-02f, 1.30856767e-01f, -1.86714102e-02f, -1.36416242e-01f, 8.44574049e-02f, 1.63469128e-02f, -2.23115236e-02f, -4.48923826e-01f, 2.64233202e-01f,
  -2.68033385e-01f, 2.94700593e-01f, 1.40728250e-01f, -6.77702203e-02f, 1.80333123e-01f, 8.47323388e-02f, -4.33554471e-01f, -4.24617156e-02f, -4.43783402e-01f, 6.51412234e-02f,
  1.12791315e-01f, 2.13478021e-02f, 3.77776287e-02f, 1.16429448e-01f, -1.82102874e-01f, 1.33935541e-01f, -1.55132562e-01f, 8.22204947e-02f, 7.77959526e-02f, 1.47257358e-01f,
  3.32241416e-01f, 1.73861176e-01f, 2.64677018e-01f, 1.33983195e-01f, 5.34975752e-02f, -3.18196893e-01f, 1.95540160e-01f, -5.30788787e-02f, -1.01530828e-01f, 2.12012529e-01f,
  3.58161144e-02f, -2.97936320e-01f, 9.31330025e-02f, 3.43922436e-01f, 1.67556241e-01f, -9.84078348e-02f, 2.46881366e-01f, 6.42466471e-02f, 3.29382449e-01f, -5.20424187e-01f,
  8.04782659e-02f, -2.34088644e-01f, 3.76043051e-01f, 2.80328780e-01f, 5.34083486e-01f, -1.95122793e-01f, -5.54234721e-02f, -2.58544832e-01f, -1.05412684e-01f, -2.08266675e-01f,
  -1.83022052e-01f, 1.02815084e-01f, -3.08217019e-01f, -2.34339640e-01f, 4.23633493e-02f, 1.28952309e-01f, 1.98947564e-01f, -1.39349941e-02f, 4.79682488e-03f, 1.32514641e-01f,
  6.01645298e-02f, 1.86339214e-01f, -2.83738151e-02f, -6.57954738e-02f, -1.16304405e-01f, 2.23118514e-01f, -4.36323732e-01f, 4.48328406e-02f, -2.22427636e-01f, 1.13321424e-01f,
  -9.66274217e-02f, -2.99435891e-02f, -2.01205716e-01f, -4.75047715e-02f, -1.83951259e-01f, 2.32527335e-03f, -4.88579087e-02f, -4.78597283e-01f, 5.48457801e-02f, 5.90683110e-02f,
  -2.91654319e-01f, -2.98796892e-01f, -1.54625103e-01f, -7.17034563e-02f, -2.26347148e-01f, 3.07583749e-01f, 4.20398206e-01f, -5.10223806e-01f, -3.49432230e-01f, 2.83544391e-01f,
  1.98791642e-03f, 1.22763492e-01f, 2.54501477e-02f, 2.50204682e-01f, -1.09319925e-01f, 2.74809599e-01f, 1.23283707e-01f, -3.20819020e-01f, 1.83816746e-01f, 3.33973676e-01f,
  -2.23654211e-02f, 3.44907194e-01f, -3.99033546e-01f, 4.81544882e-01f, -7.12779611e-02f, 1.81426808e-01f, 6.83505237e-02f, -2.60710031e-01f, -4.50524598e-01f, -1.33551165e-01f,
  -4.76836087e-03f, -1.09668814e-01f, -1.69165403e-01f, -1.97281931e-02f, 3.56253922e-01f, -6.29995614e-02f, 3.52319956e-01f, 2.41191551e-01f, -6.04208410e-02f, 7.61210471e-02f,
  -2.21448705e-01f, 9.26415697e-02f, -1.52583703e-01f, 9.74644423e-02f, 3.43926579e-01f, 3.09013072e-02f, 2.46512964e-02f, -3.44183832e-01f, 3.38663876e-01f, 1.10355010e-02f,
  -2.52307028e-01f, -8.96567032e-02f, 2.74222195e-01f, -2.56238192e-01f, 1.13632493e-01f, 1.45470232e-01f, 1.65376678e-01f, 2.31838617e-02f, 1.43666267e-01f, 2.69610316e-01f,
  -2.51301765e-01f, 1.48063734e-01f, -1.39095530e-01f, -2.81356156e-01f, -2.75890362e-02f, 4.77782637e-01f, -6.36172667e-02f, -1.78619340e-01f, -1.69577333e-03f, -2.27013022e-01f,
  -2.30619207e-01f, -3.03185582e-01f, -2.82533705e-01f, 1.87584862e-01f, 4.81153816e-01f, 2.87052870e-01f, -3.03563714e-01f, 3.64660412e-01f, -4.33474898e-01f, -5.04895970e-02f,
  7.66477287e-02f, -9.37921256e-02f, -1.01657130e-01f, 4.37062204e-01f, 2.32072264e-01f, 3.52913797e-01f, -6.18901141e-02f, 5.74713588e-01f, 2.15328857e-01f, -2.39701718e-01f,
  1.17924541e-01f, 6.22314438e-02f, -1.03931248e-01f, -2.64699668e-01f, -1.32059887e-01f, 1.08745351e-01f, -5.82224131e-02f, -1.91319212e-01f, 1.13172039e-01f, 1.12389382e-02f,
  -4.65338565e-02f, 2.06258789e-01f, -6.96837604e-02f, -2.08323091e-01f, -3.13499153e-01f, -1.12648316e-01f, 1.01130046e-01f, 1.41806260e-01f, 2.62200415e-01f, -1.20157778e-01f,
  1.49109080e-01f, -3.22257668e-01f, 1.12678163e-01f, -1.48509666e-01f, 5.57773948e-01f, 2.97130018e-01f, -4.13774937e-01f, 1.16702884e-01f, 2.08051220e-01f, 1.77762717e-01f,
  1.41380906e-01f, -1.11034550e-01f, -2.56121159e-01f, 1.08655570e-02f, 1.53888792e-01f, 1.11827791e-01f, 2.04165988e-02f, -2.98480451e-01f, 1.38322800e-01f, 1.72542006e-01f,
  -1.93787992e-01f, -5.41497841e-02f, -2.42904723e-01f, 3.56734097e-02f, -2.86470741e-01f, 1.22422054e-01f, -3.93636078e-01f, 9.39106718e-02f, 2.72882402e-01f, 9.56705511e-02f,
  -2.46537309e-02f, -2.38109529e-01f, 4.21688408e-01f, 6.66382164e-02f, -2.29865819e-01f, -2.84909755e-01f, 1.87338814e-01f, -3.73910993e-01f, -3.11599225e-01f, -2.85317004e-01f,
  -8.51561353e-02f, 3.92861396e-01f, -1.28840998e-01f, 3.11295837e-01f, -4.37917858e-01f, -1.78853676e-01f, 6.71133474e-02f, -1.26518413e-01f, -1.78630844e-01f, 1.11811638e-01f,
  7.07573369e-02f, -2.20466256e-01f, -5.00715226e-02f, -1.43773034e-01f, -2.87528843e-01f, -1.84400007e-01f, 2.06977248e-01f, -3.64934541e-02f, 2.92341411e-01f, 1.62119977e-02f,
  1.30183250e-01f, -4.12844032e-01f, 4.18007523e-01f, 2.80021369e-01f, 1.55299604e-01f, -3.00069898e-01f, -2.15235889e-01f, -1.86635241e-01f, -2.94195205e-01f, -6.55027153e-03f,
  5.63272741e-03f, 1.80695787e-01f, 3.64856899e-01f, 4.10865340e-03f, -1.32650182e-01f, 1.37147620e-01f, -1.68631487e-02f, 9.79910046e-03f, 1.86466813e-01f, 2.56415665e-01f,
  -3.14514369e-01f, 2.31560767e-01f, 2.03476861e-01f, 2.69116253e-01f, 1.56618118e-01f, 1.78921103e-01f, 2.89028734e-01f, -1.81201875e-01f, 5.35671525e-02f, 1.37425601e-01f,
  -1.61398306e-01f, -2.33828813e-01f, 3.52871716e-01f, 2.27130607e-01f, 1.79789752e-01f, -1.27714977e-01f, 2.54902780e-01f, 2.93685757e-02f, -4.52916712e-01f, 2.99773902e-01f,
  -3.35926116e-01f, 5.95333017e-02f, -1.28141806e-01f, -1.35526150e-01f, 5.71202517e-01f, -5.33088982e-01f, -7.58177638e-02f, 1.33846123e-02f, 1.53807819e-01f, -2.98772845e-02f,
  -1.15747049e-01f, -8.60995799e-02f, -1.17924727e-01f, -8.34802762e-02f, 1.29747465e-01f, -8.69861618e-02f, -2.12710261e-01f, 2.53401250e-01f, -3.52660678e-02f, -1.55881986e-01f,
  1.16207555e-01f, 1.47174180e-01f, 1.96142033e-01f, -1.32632898e-02f, -2.06528932e-01f, -8.75128135e-02f, -2.79717326e-01f, -1.60261184e-01f, 2.40199327e-01f, 8.44129324e-02f,
  -5.52860461e-02f, 7.31522664e-02f, 2.19119832e-01f, -1.18935265e-01f, 6.69686720e-02f, 8.94355923e-02f, 2.06109479e-01f, -2.47791603e-01f, -2.05697969e-01f, 1.25640333e-01f,
  1.30949840e-01f, -1.77966192e-01f, -1.51490375e-01f, -3.35467368e-01f, 2.41816223e-01f, 1.90595016e-01f, 5.20291254e-02f, -2.39468336e-01f, -2.20963195e-01f, -2.48375744e-01f,
  -2.35259384e-01f, 3.07737052e-01f, -4.51527894e-01f, -1.42971918e-01f, 2.53035933e-01f, 2.45482638e-01f, -5.24467647e-01f, -1.95051610e-01f, -1.03042826e-01f, 2.58481234e-01f,
  -2.50573039e-01f, -1.68210939e-01f, 2.02703223e-01f, -3.77080113e-01f, 6.59184232e-02f, -1.64731536e-02f, 5.16352177e-01f, 4.00470048e-01f, -2.11084381e-01f, 1.83328420e-01f,
  -8.17756057e-02f, 1.49523556e-01f, -1.12650044e-01f, -8.39357227e-02f, -2.86344945e-01f, 6.00696951e-02f, 2.50651091e-01f, 4.76642340e-01f, -1.37116890e-02f, -1.75515473e-01f,
  -3.96704912e-01f, -8.15737173e-02f, -8.92036781e-02f, 9.78762656e-02f, 9.97124612e-02f, -3.67608368e-02f, 7.48538896e-02f, 1.05659857e-01f, -2.75258534e-02f, 1.28341436e-01f,
  -2.32729644e-01f, 4.65963315e-03f, 5.31853288e-02f, -1.86924506e-02f, 7.57110789e-02f, -2.25030959e-01f, 1.18515447e-01f, 3.12336404e-02f, 2.26235818e-02f, -3.88677828e-02f,
  -2.37495154e-01f, -2.01842725e-01f, -5.89191308e-03f, -4.78946865e-02f, -1.71666473e-01f, -9.44257304e-02f, -1.45645484e-01f, 2.29001477e-01f, 5.64359799e-02f, 4.90297154e-02f,
  -4.47345525e-02f, -5.85723519e-01f, 8.95196721e-02f, 3.98367316e-01f, 1.00871436e-01f, 1.69136018e-01f, 3.88371557e-01f, -2.92759761e-02f, 2.75465965e-01f, 1.41955227e-01f,
  -6.38807893e-01f, 1.42503008e-01f, 1.00077810e-02f, 4.83199686e-01f, 2.57728964e-01f, -3.09394568e-01f, 1.95761755e-01f, 3.85043174e-01f, -3.86009812e-01f, 3.63483220e-01f,
  4.06454653e-01f, -7.99841136e-02f, 2.45678246e-01f, -2.31606171e-01f, 1.08337723e-01f, 3.50414693e-01f, -1.37088642e-01f, 2.63010949e-01f, -7.14786947e-02f, -1.63760141e-01f,
  1.35589078e-01f, -4.75238217e-03f, 8.79936591e-02f, 4.35695708e-01f, -1.96597412e-01f, -1.29577862e-02f, -1.91124409e-01f, 1.58378467e-01f, -5.76712610e-03f, 5.02042957e-02f,
  -3.94449174e-01f, 9.88671854e-02f, 2.24341780e-01f, 3.35527599e-01f, -3.28837931e-01f, 9.73673239e-02f, 5.04216999e-02f, -1.13998339e-01f, -8.01642388e-02f, -3.48716080e-01f,
  3.60477678e-02f, 2.72345006e-01f, 1.64974526e-01f, 1.99252889e-01f, 6.37955964e-02f, 1.37412161e-01f, 2.78195411e-01f, 1.50370002e-01f, 1.51885077e-01f, -2.43377537e-01f,
  1.03491716e-01f, 2.40999386e-01f, -2.51348436e-01f, -2.10467875e-01f, 2.36107513e-01f, 1.47551313e-01f, -5.88045046e-02f, -6.61560223e-02f, 3.92843097e-01f, -5.61177909e-01f,
  -4.54465985e-01f, -7.96138272e-02f, -1.07772812e-01f, -4.34251904e-01f, 4.88211960e-02f, 3.27436328e-01f, 1.70146197e-01f, -3.94350320e-01f, -3.85971218e-01f, 2.24243343e-01f,
  -3.70737523e-01f, -2.48541251e-01f, 2.19755515e-01f, -1.53924748e-01f, -3.86786580e-01f, 2.16933593e-01f, 1.28213629e-01f, -6.55206665e-02f, 2.64103618e-02f, -4.05910462e-01f,
  3.63946557e-01f, -2.67340243e-01f, -1.84277177e-01f, -1.37866467e-01f, -3.27955262e-04f, 3.17930542e-02f, 1.44475728e-01f, -1.83714509e-01f, 2.08500743e-01f, 1.71962053e-01f,
  1.31942987e-01f, -2.57763177e-01f, -2.37751871e-01f, 1.29189610e-01f, 3.08137983e-01f, -6.96872622e-02f, 6.30219281e-02f, 6.47737980e-02f, -3.99395883e-01f, -1.05767526e-01f,
  1.11696705e-01f, 3.48743737e-01f, -1.19972825e-01f, 3.65699798e-01f, -6.29005283e-02f, 1.16507925e-01f, 1.68218404e-01f, 4.75891903e-02f, 2.05120414e-01f, -5.00578173e-02f,
  7.67714828e-02f, -1.05885230e-01f, 1.69272304e-01f, 4.89624925e-02f, 1.26467004e-01f, -2.57982492e-01f, 3.77224863e-01f, 2.49884188e-01f, -1.64037883e-01f, -1.83258459e-01f,
  -1.23100907e-01f, -2.98839748e-01f, -1.36315152e-01f, 2.15552673e-01f, 3.30034554e-01f, 1.09663814e-01f, 3.64733845e-01f, 3.46138477e-01f, -6.52597111e-04f, 2.75174886e-01f,
  -6.64866865e-02f, -1.58960044e-01f, 2.24536121e-01f, 1.09580413e-01f, -3.05016264e-02f, 1.19195506e-01f, -3.13844346e-03f, -2.17971072e-01f, -1.65244594e-01f, -3.28315109e-01f,
  2.06193000e-01f, 1.08024731e-01f, 8.19808915e-02f, -6.30177185e-02f, 1.50023237e-01f, 2.59269893e-01f, -6.40568286e-02f, 5.58701977e-02f, -5.62261464e-03f, -2.60777980e-01f,
  -8.52823332e-02f, 3.13975215e-01f, 3.58982623e-01f, 4.23781276e-02f, 1.23955853e-01f, 8.66661817e-02f, 7.16032088e-02f, 7.07900450e-02f, 1.27946168e-01f, -1.31675228e-02f,
  8.01668614e-02f, -1.35143548e-01f, -9.00221895e-03f, -1.72482982e-01f, 7.97651038e-02f, -1.30387396e-01f, 1.29676446e-01f, 1.41258746e-01f, -4.75574046e-01f, -1.92587048e-01f,
  3.39233167e-02f, -2.08596170e-01f, -1.50358826e-02f, 7.42986007e-03f, 1.75922632e-01f, 8.98569971e-02f, -3.49125490e-02f, -2.88134128e-01f, 8.89234319e-02f, 1.01123743e-01f,
  -9.62951481e-02f, 2.94515282e-01f, -3.85478765e-01f, -9.53796506e-03f, 3.29751492e-01f, 3.61958444e-01f, 3.01631778e-01f, 2.10110426e-01f, 4.03596312e-01f, -4.31528836e-01f,
  -3.12386453e-01f, -1.39934063e-01f, 4.80759442e-02f, -3.68720852e-02f, 4.46505100e-01f, 1.11009879e-02f, 2.85870850e-01f, 3.44290495e-01f, -3.32180381e-01f, 1.52166784e-02f,
  -3.17767709e-01f, 2.45871432e-02f, -2.55938023e-01f, -3.04354101e-01f, -3.28936204e-02f, 2.80235082e-01f, -1.21307978e-02f, 3.31408441e-01f, -1.17293629e-03f, -3.08520317e-01f,
  -3.76544267e-01f, -8.27878863e-02f, -4.57656980e-02f, -5.03083952e-02f, 2.02098534e-01f, 4.07615513e-01f, -2.05073245e-02f, 9.32201371e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.18551448e-02f, 1.08657004e-02f, -1.58230178e-02f, 2.96260547e-02f, 1.48076797e-02f, 1.16639756e-01f, 2.94602122e-02f, -5.67751564e-02f, -1.35123180e-02f, -1.71574894e-02f,
  -1.61774725e-01f, 1.16843907e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    