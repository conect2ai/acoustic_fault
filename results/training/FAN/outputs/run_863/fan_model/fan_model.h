/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.34818602e-01f, 1.74166933e-01f, 3.67642820e-01f, -1.37700036e-01f, 6.69731051e-02f, -1.20194919e-01f, -1.20597966e-01f, -5.39146550e-02f, -1.38093337e-01f, 2.68070865e-02f,
  1.22338561e-02f, -7.38076866e-02f, -1.64558720e-02f, 9.58934501e-02f, -3.28506269e-02f, 3.26605104e-02f, 1.23605989e-01f, 2.68440619e-02f, -1.98938057e-01f, -8.52635503e-02f,
  -6.85788617e-02f, -4.75985222e-02f, 2.88110506e-02f, 1.76421106e-02f, 6.25313893e-02f, -1.98136732e-01f, 2.13114887e-01f, 1.22364551e-01f, 2.23238900e-01f, 2.91881800e-01f,
  -1.07277567e-02f, 1.43372729e-01f, -2.13575847e-02f, 1.34556442e-02f, 9.27780271e-02f, -1.07786842e-01f, -2.65848208e-02f, 5.26855849e-02f, 2.12572552e-02f, 2.79269982e-02f,
  7.29261786e-02f, -1.60919894e-02f, -4.51695360e-03f, 1.23868510e-03f, 5.76277077e-03f, -6.20791093e-02f, 3.44671346e-02f, 5.76588064e-02f, 1.62695125e-02f, 5.65830432e-03f,
  1.30501300e-01f, 1.68652818e-01f, -4.55469526e-02f, 5.05453628e-03f, 8.23153183e-02f, 1.53136346e-02f, 1.01110945e-02f, 4.93308483e-03f, -3.11364997e-02f, -2.88018305e-02f,
  -7.32367709e-02f, 3.34705152e-02f, -3.45032513e-02f, 4.88996394e-02f, -6.90614060e-02f, 4.16297279e-02f, 2.74352506e-02f, -1.21092005e-02f, 9.51588247e-03f, -3.58963124e-02f,
  2.56156158e-02f, -1.68454144e-02f, -3.84704806e-02f, -1.98319834e-02f, -2.34854110e-02f, 8.52479115e-02f, -1.10275233e-02f, -3.55479904e-02f, 7.87198842e-02f, -1.28030416e-03f,
  -3.28406766e-02f, 3.20959203e-02f, 5.74139468e-02f, -1.36587638e-02f, 8.79013091e-02f, 5.96516840e-02f, 1.93035100e-02f, -4.19854326e-03f, -8.37369934e-02f, 1.54987630e-02f,
  -2.45616287e-01f, 1.74692586e-01f, -7.63693377e-02f, -6.97835833e-02f, -2.89110187e-02f, 3.10253818e-02f, 3.15906443e-02f, 1.53244566e-02f, 5.02420329e-02f, -4.14754748e-02f,
  1.59988925e-03f, -4.77554761e-02f, 7.02510327e-02f, -2.26959847e-02f, -4.04172800e-02f, -8.42200294e-02f, 1.34974737e-02f, -6.34123608e-02f, 1.68069193e-04f, -1.21458564e-02f,
  -4.04590508e-03f, -1.29974782e-01f, -2.81419873e-01f, -7.30776191e-02f, -1.16630487e-01f, -2.29702383e-01f, -1.96162462e-01f, -7.36763105e-02f, -1.85263082e-01f, -3.95967245e-01f,
  6.17412984e-01f, -3.41861039e-01f, -7.59417517e-03f, 1.52833208e-01f, -2.10671827e-01f, -1.52479351e-01f, -3.69795501e-01f, -9.53002423e-02f, 1.84770852e-01f, -2.51124084e-01f,
  -1.77739933e-01f, 1.30777031e-01f, 1.45649821e-01f, 8.64400044e-02f, 7.15193748e-02f, -1.02516472e-01f, -1.86339676e-01f, 2.14999348e-01f, 4.39794779e-01f, -1.14761420e-01f,
  -1.39868617e-01f, -5.71649056e-04f, 2.86209047e-01f, 3.25965509e-02f, -1.73755065e-01f, 1.75488606e-01f, -4.09754179e-02f, 3.78503068e-03f, -4.49924618e-02f, -1.36349469e-01f,
  4.03653868e-02f, -1.10393181e-01f, 7.65059888e-02f, 5.02262041e-02f, -8.74294490e-02f, 6.13123477e-02f, 5.91266388e-03f, 7.66327679e-02f, 6.06917553e-02f, -1.38397992e-03f,
  -4.20835391e-02f, 3.11891343e-02f, 2.44282410e-02f, -5.85727766e-02f, -2.71361899e-02f, 3.86575540e-03f, 1.46416072e-02f, 5.85333295e-02f, 6.73378855e-02f, -5.08766100e-02f,
  -6.32253513e-02f, 2.75841858e-02f, -1.11035876e-01f, -7.73296803e-02f, 1.69239156e-02f, 4.72361818e-02f, -8.01308379e-02f, -9.67395082e-02f, 3.42214061e-03f, -4.59437035e-02f,
  -4.63553891e-02f, 5.42924963e-02f, -3.48506682e-02f, -4.50655440e-04f, 2.63377037e-02f, -3.80541869e-02f, 4.12496738e-02f, 2.84951460e-02f, 2.41300743e-03f, 4.16317172e-02f,
  -1.57084558e-02f, -6.96481243e-02f, 1.98208261e-02f, -5.34953848e-02f, 1.66729093e-02f, 1.79833658e-02f, -1.82796940e-02f, -2.26630475e-02f, 1.23511804e-02f, 2.57251561e-02f,
  3.54558602e-02f, -4.92544733e-02f, 1.63742993e-02f, -7.86586315e-04f, 2.24350858e-02f, 1.89352240e-02f, 3.98449600e-02f, -1.99797247e-02f, -1.55724743e-02f, -1.78070739e-02f,
  3.80080976e-02f, 7.22240359e-02f, -3.43620665e-02f, -6.10891846e-04f, 3.88533957e-02f, 6.82661161e-02f, -6.55621961e-02f, 4.72878665e-02f, 1.12817138e-02f, -5.17144613e-02f,
  -1.59956347e-02f, -4.38788161e-03f, -6.10215366e-02f, -1.54699255e-02f, 4.29105237e-02f, -2.70542707e-02f, -3.03028598e-02f, 8.49402472e-02f, -3.02456040e-02f, 3.45993671e-04f,
  -2.42681094e-02f, 4.97967079e-02f, 1.41567752e-01f, 5.50414063e-02f, -8.13814625e-02f, 4.47419100e-02f, -7.03495592e-02f, 4.84821126e-02f, 7.88471401e-02f, 7.10443109e-02f,
  -9.24970508e-02f, -6.31847605e-02f, -1.45265922e-01f, 2.50064820e-01f, 7.83010796e-02f, -1.72237471e-01f, -4.99591470e-01f, -1.27842814e-01f, 8.82222354e-02f, -1.83060709e-02f,
  1.33994952e-01f, 2.43898645e-01f, 1.62671313e-01f, 1.44196704e-01f, -2.09571704e-01f, -2.99038261e-01f, -2.69769341e-01f, -1.01570442e-01f, -2.86694951e-02f, 8.79140794e-02f,
  1.65510789e-01f, 5.03253303e-02f, 1.00589216e-01f, -4.02130745e-02f, 1.28832068e-02f, 3.17874819e-01f, 5.83297573e-02f, 1.41878864e-02f, 1.22204818e-01f, -4.24221717e-02f,
  1.10028468e-01f, -1.52158916e-01f, 2.42023338e-02f, 5.88104911e-02f, 5.86298108e-03f, -9.10028741e-02f, -3.23857814e-02f, -2.10119057e-02f, -2.48204870e-03f, -1.81792472e-02f,
  1.45047233e-01f, 3.92513499e-02f, -1.67120602e-02f, 6.95218518e-02f, -2.47745607e-02f, -4.04308476e-02f, -1.40998796e-01f, -4.17986624e-02f, -1.54740453e-01f, -1.69764273e-02f,
  1.51634604e-01f, 8.50947481e-03f, -1.21646961e-02f, -8.88707191e-02f, -7.03318119e-02f, 6.30981028e-02f, -2.01337319e-02f, -1.83552485e-02f, -7.20919818e-02f, 9.96222794e-02f,
  -4.35855836e-02f, -2.56829578e-02f, -2.95044319e-03f, 5.13304584e-02f, -5.47827128e-03f, -4.33759019e-02f, 1.68697315e-03f, 6.23652339e-02f, -3.46335433e-02f, 2.31504869e-02f,
  -1.39561621e-02f, -4.71559241e-02f, -3.19089592e-02f, -1.31318644e-02f, 5.58593310e-02f, -3.86814475e-02f, -1.09883025e-02f, 2.68710461e-02f, 4.09536846e-02f, -2.07371637e-02f,
  9.46736410e-02f, -4.05070297e-02f, -2.25114450e-03f, 2.32904050e-02f, 2.31453460e-02f, 3.85660911e-03f, 1.48320952e-02f, -7.58994557e-03f, -5.89829981e-02f, -3.83899361e-02f,
  1.99439570e-01f, -4.47437055e-02f, 3.89157496e-02f, -2.42744163e-02f, 8.79915133e-02f, 3.51987667e-02f, 9.46630016e-02f, 3.58715765e-02f, 1.87236164e-02f, 2.28574872e-02f,
  1.02291806e-02f, -2.74613518e-02f, -1.14208870e-02f, 1.80916116e-02f, 3.09906155e-02f, 5.09028230e-03f, 6.20223582e-02f, 8.12420771e-02f, 3.42486612e-02f, 3.91202569e-02f,
  -4.37150477e-03f, 8.03995579e-02f, 9.09788162e-02f, -2.40204632e-02f, 2.07324382e-02f, -1.01095997e-02f, -3.69297042e-02f, 2.85997838e-02f, -7.13967904e-02f, -2.52696685e-02f,
  -1.53569162e-01f, -1.43366545e-01f, 1.84439689e-01f, -1.29347980e-01f, -1.47232607e-01f, 4.83315401e-02f, -3.84501033e-02f, -1.56826615e-01f, -1.47154927e-01f, 8.07867795e-02f,
  -1.00572314e-02f, -3.73795740e-02f, 1.07595623e-01f, 1.48886889e-01f, 2.26787433e-01f, 1.88956186e-01f, 1.49874717e-01f, 2.54508257e-01f, 2.74307996e-01f, 7.20662400e-02f,
  1.64045453e-01f, 1.16005309e-01f, 1.66842286e-02f, 1.03649341e-01f, -2.88270060e-02f, 7.79655799e-02f, -2.25677770e-02f, 4.53544557e-02f, 7.15584774e-03f, 5.56769371e-02f,
  1.63561419e-01f, -1.08391523e-01f, 1.46163881e-01f, 1.83859952e-02f, 5.07219099e-02f, 1.10822410e-04f, 9.78271738e-02f, -1.73808523e-02f, -3.49800773e-02f, 5.21780625e-02f,
  1.65957063e-02f, -2.95781903e-02f, 1.30685056e-02f, -2.68004667e-02f, 9.38540399e-02f, 1.32996038e-01f, 5.97474501e-02f, 4.18275110e-02f, 1.38089761e-01f, -2.93060672e-02f,
  -8.60632360e-02f, -8.84384289e-02f, -4.93074618e-02f, -5.70570864e-02f, 4.83330013e-03f, -1.06444597e-01f, 5.80734154e-03f, -8.73808116e-02f, -4.16761637e-02f, -7.82366097e-02f,
  -1.77970365e-01f, 5.04259206e-02f, -4.22399631e-03f, -1.38622196e-02f, -7.36325979e-02f, 1.07655292e-02f, -1.14274370e-02f, -5.36485426e-02f, -6.28982671e-03f, 2.36224681e-02f,
  2.38801148e-02f, 2.93688755e-02f, -3.89302149e-02f, -1.19266305e-02f, 9.65711921e-02f, -3.64313368e-03f, -5.06798029e-02f, 9.30682104e-03f, 5.91491126e-02f, 4.02814746e-02f,
  1.43430689e-02f, -2.14522821e-03f, 3.52475531e-02f, 3.61202583e-02f, -5.57069741e-02f, 1.31550780e-03f, 1.31522799e-02f, -7.08651543e-02f, -1.56747084e-02f, 6.82241023e-02f,
  2.27976330e-02f, 1.11418523e-01f, 8.86127818e-03f, 3.74889560e-02f, -2.91515682e-02f, -7.86954463e-02f, -5.36491796e-02f, 1.16863158e-02f, -3.99888344e-02f, 2.59861872e-02f,
  -4.76951487e-02f, -7.41445401e-04f, 5.50170057e-02f, 4.31138240e-02f, 5.52874245e-02f, -3.07080727e-02f, -6.84828311e-02f, 4.80747372e-02f, -6.82923757e-03f, -6.93928450e-02f,
  -7.97609314e-02f, -3.45466845e-02f, 1.02078184e-01f, -2.86445338e-02f, -6.45270646e-02f, 5.40758148e-02f, 1.16654903e-01f, -1.04668336e-02f, 1.04434021e-01f, -9.56770591e-03f,
  2.98583776e-01f, -1.75473675e-01f, 2.50984490e-01f, 3.78710926e-01f, 3.34354699e-01f, 1.63068295e-01f, 7.85117522e-02f, 8.60201642e-02f, 1.00956611e-01f, -1.00498274e-02f,
  -3.70690487e-02f, 6.65161461e-02f, -4.70816866e-02f, -8.00626278e-02f, -2.39682873e-03f, -3.84161919e-02f, 1.07993543e-01f, 1.67656541e-02f, 1.41522497e-01f, 1.72208458e-01f,
  2.72284262e-02f, 2.26506963e-01f, 1.39738977e-01f, 1.48661193e-02f, 1.70980304e-01f, 5.79808429e-02f, 6.86540678e-02f, 3.65824960e-02f, -1.04715198e-01f, 2.28501856e-01f,
  1.76850691e-01f, 3.00161660e-01f, 4.27552089e-02f, 7.79237878e-03f, 7.92000666e-02f, -8.12474266e-02f, 1.45736158e-01f, 6.14222027e-02f, -7.42676258e-02f, 4.27728519e-02f,
  7.23078027e-02f, -2.48750579e-02f, -2.45535672e-02f, 3.70716676e-02f, -2.00494267e-02f, 7.76622146e-02f, -8.75196755e-02f, 2.11264882e-02f, -4.31172587e-02f, 3.49130146e-02f,
  -8.49978477e-02f, 8.08276683e-02f, 7.06423670e-02f, -5.13972975e-02f, -1.06264830e-01f, 3.29520484e-03f, 1.09326765e-02f, 3.99615169e-02f, 7.59689882e-02f, -6.21077046e-02f,
  -2.74960753e-02f, -4.92106937e-03f, 7.54813617e-03f, -1.88562889e-02f, -5.06162457e-02f, -7.34851882e-02f, -6.80235550e-02f, -4.50992025e-03f, -1.90320034e-02f, 1.05774635e-02f,
  -1.48972049e-02f, 2.98224539e-02f, -3.92836370e-02f, 4.75374050e-02f, -2.98008434e-02f, 1.93978716e-02f, -3.36458012e-02f, 1.17348414e-03f, 2.62761805e-02f, -2.83311643e-02f,
  1.46742705e-02f, 3.07664350e-02f, 1.37006212e-02f, -3.03027090e-02f, 2.12734379e-02f, 3.40225850e-03f, -1.44072678e-02f, -2.86747664e-02f, 2.34373007e-03f, 1.70580670e-02f,
  -9.23568010e-02f, -8.79537687e-02f, 6.27601743e-02f, -4.59093489e-02f, 4.98155085e-03f, -6.33588508e-02f, 5.24081849e-03f, -8.12896565e-02f, -2.15097368e-02f, 1.56663191e-02f,
  6.55799583e-02f, 4.02996838e-02f, 3.53016704e-02f, 6.48687631e-02f, 1.31377548e-01f, 3.12733874e-02f, -8.12109783e-02f, 2.35838965e-02f, -1.01341717e-01f, -4.72385287e-02f,
  -8.02557915e-02f, -6.53624535e-02f, 2.60706432e-02f, -5.81718124e-02f, -6.64390549e-02f, 3.29764038e-02f, 8.78525991e-03f, -7.07835332e-02f, -2.35894136e-02f, -1.89320937e-01f,
  -5.69175780e-01f, 1.59182236e-01f, -1.67065486e-01f, -4.01438415e-01f, -2.45415792e-01f, 9.24616307e-02f, 7.94061795e-02f, 5.42610548e-02f, -3.04326452e-02f, -9.15594846e-02f,
  -1.00471295e-01f, -3.06829251e-02f, -9.60718375e-03f, 4.63554524e-02f, 7.81479701e-02f, 8.54042619e-02f, -1.77851930e-01f, -6.45234575e-03f, -4.16504871e-03f, 4.57279272e-02f,
  8.97803083e-02f, -2.88097918e-01f, -2.89158136e-01f, 1.32476777e-01f, -3.05592678e-02f, 4.19003591e-02f, -2.18994662e-01f, -9.37778726e-02f, 4.12800498e-02f, -4.18647230e-01f,
  1.05878070e-01f, 1.59545690e-02f, -5.42134643e-02f, -4.24484387e-02f, 9.74660181e-03f, 8.90820846e-02f, 3.39229256e-02f, 3.62436995e-02f, 4.78003733e-02f, 2.93234717e-02f,
  -8.68947357e-02f, -5.28413802e-03f, -1.03225887e-01f, -3.56684662e-02f, 5.12718409e-03f, 3.70943546e-02f, 1.24521768e-02f, 1.71554573e-02f, -9.31197079e-04f, 9.34079960e-02f,
  -2.98544783e-02f, -5.89261353e-02f, -6.36529103e-02f, 1.43658191e-01f, 9.92604643e-02f, -5.12867384e-02f, 2.10399881e-01f, 1.70072094e-02f, 1.13548391e-01f, -7.51877800e-02f,
  1.09510450e-02f, 5.51454499e-02f, -1.42132137e-02f, -1.08298678e-02f, -9.04049501e-02f, 2.04684585e-02f, 6.25894126e-03f, -4.67540510e-03f, -2.39318353e-03f, -3.13860853e-03f,
  -5.56883728e-03f, -4.44758795e-02f, 4.46152203e-02f, -4.22041910e-03f, -2.68561244e-02f, -4.56826761e-02f, 3.20854671e-02f, -1.47550879e-02f, 4.25976664e-02f, -5.05930819e-02f,
  1.99235254e-03f, 9.64152962e-02f, -1.23700406e-03f, 1.09217852e-01f, -3.23567800e-02f, -2.71927584e-02f, -5.07338233e-02f, 6.89280629e-02f, -3.84797640e-02f, -2.99519170e-02f,
  -9.60718766e-02f, -7.47476369e-02f, -3.21546160e-02f, 1.31233871e-01f, -4.07723747e-02f, 1.68428104e-02f, -9.59473997e-02f, -2.14697197e-02f, -4.49868217e-02f, 3.55096608e-02f,
  -2.31465623e-02f, 6.87741041e-02f, -2.60693748e-02f, 7.34988302e-02f, 4.72950116e-02f, -9.38266609e-03f, -1.03247494e-01f, -2.14847252e-02f, 4.25539650e-02f, 5.15757091e-02f,
  -1.98416933e-02f, 2.40978114e-02f, 2.45301649e-02f, 6.80913702e-02f, -1.84721071e-02f, -6.85298815e-02f, 6.17875904e-02f, 3.41790430e-02f, -2.21741409e-03f, -6.45820424e-03f,
  -2.27734536e-01f, -1.05328716e-01f, -8.83175805e-02f, -1.05739608e-01f, 1.28642647e-02f, 1.04234852e-01f, -9.93546937e-03f, -3.13039124e-02f, 7.73334801e-02f, -1.16238058e-01f,
  8.96753669e-02f, 2.88476437e-01f, 2.80059371e-02f, 1.04066566e-01f, -1.33684486e-01f, -1.31542847e-01f, -1.45356134e-01f, -7.69552141e-02f, -3.83828469e-02f, 1.08498529e-01f,
  -7.97659606e-02f, -1.20454371e-01f, -1.31414041e-01f, -8.83374140e-02f, 5.33166900e-02f, 7.93672800e-02f, -2.83710379e-02f, 1.02477267e-01f, 8.67554247e-02f, -1.65249735e-01f,
  9.13685337e-02f, 5.74644208e-02f, 9.87863466e-02f, -3.50757688e-02f, 3.78721319e-02f, -1.79606122e-05f, 2.56803446e-02f, 5.65812066e-02f, 1.42053664e-01f, -6.34124726e-02f,
  -1.33983763e-02f, 9.50169712e-02f, 1.06879309e-01f, -4.97500859e-02f, -9.03970655e-03f, -6.33039251e-02f, -7.53166005e-02f, -2.39736140e-02f, -4.06302735e-02f, -4.50763814e-02f,
  -1.71841700e-02f, 1.02014527e-01f, -1.16694406e-01f, -8.14199895e-02f, -5.98027222e-02f, 2.30605677e-02f, 7.86927789e-02f, -4.34433520e-02f, 9.40761045e-02f, -1.27836704e-01f,
  -1.25000449e-02f, 4.36776243e-02f, -2.53710561e-02f, -5.60485013e-03f, -1.03933282e-01f, -1.74622168e-03f, 8.07305947e-02f, -6.70747757e-02f, 6.97308183e-02f, -4.42936346e-02f,
  4.08375300e-02f, -2.53989100e-02f, 5.39011769e-02f, -7.93592110e-02f, 3.70942093e-02f, 4.62552756e-02f, 1.88013110e-02f, -1.01134643e-01f, -1.61097236e-02f, -2.13022344e-02f,
  -4.82903384e-02f, 3.23072933e-02f, -4.89570461e-02f, 2.41677910e-02f, -2.98196659e-03f, -6.11988269e-03f, -6.99692518e-02f, -1.70399025e-02f, 9.73979235e-02f, 1.14407027e-02f,
  -5.60143776e-02f, 2.26715967e-01f, 6.33981312e-03f, -2.96916068e-02f, 6.19775280e-02f, -9.80594312e-04f, 2.12476905e-02f, 1.46099844e-03f, 3.29253078e-02f, 7.27210147e-03f,
  -3.77928987e-02f, -7.68181216e-03f, 4.10663411e-02f, 8.01714957e-02f, 3.57861295e-02f, 4.59267460e-02f, -9.74789709e-02f, -8.61251876e-02f, 7.94527382e-02f, -6.11450560e-02f,
  -1.36593789e-01f, -2.16823682e-01f, -2.45974839e-01f, -7.69214928e-02f, 2.99600232e-02f, -3.30711380e-02f, 1.33197708e-02f, 3.00153182e-03f, 2.76839975e-02f, -3.03196609e-01f,
  -6.12403825e-02f, 4.10051525e-01f, -7.20150024e-02f, 5.45669682e-02f, -2.32869834e-01f, -3.13840449e-01f, -2.03628480e-01f, -6.35440126e-02f, -1.91957280e-02f, 2.94629205e-02f,
  -1.02565959e-01f, 4.21196669e-02f, 1.89011574e-01f, 1.79277301e-01f, -7.55822752e-04f, 1.18781306e-01f, -8.61597713e-03f, -3.15924548e-02f, -1.79293290e-01f, -1.38903439e-01f,
  6.09848537e-02f, 3.59612368e-02f, -6.13551661e-02f, 1.55994669e-01f, 2.80485898e-01f, 9.97258723e-02f, -2.76045781e-02f, -6.05348758e-02f, 9.17102024e-03f, 2.28709310e-01f,
  -3.36737074e-02f, -1.52010813e-01f, -7.26179704e-02f, 4.69602132e-03f, 5.69395125e-02f, 1.35352341e-02f, 1.72028318e-02f, 1.41073182e-01f, 4.53803279e-02f, 3.51320989e-02f,
  -1.27022741e-02f, -4.93602268e-02f, 4.25401442e-02f, 1.25262156e-01f, -1.96607132e-02f, -3.57917100e-02f, 5.50039783e-02f, 1.52155876e-01f, 1.70107350e-01f, -7.01407045e-02f,
  1.75143294e-02f, -1.60018101e-01f, -5.03204167e-02f, -5.23921102e-02f, -2.16129776e-02f, -6.74475729e-02f, -8.16801190e-02f, 5.85149601e-02f, -1.01256825e-01f, 1.43201172e-01f,
  2.23102681e-02f, -5.93417585e-02f, -5.55016473e-02f, -9.03654378e-03f, 3.72000895e-02f, -6.91435672e-03f, 6.93538738e-03f, -2.04092655e-02f, -4.13961485e-02f, 8.96305591e-02f,
  -1.54620437e-02f, -4.69894744e-02f, 8.00511613e-02f, -2.37578489e-02f, 6.99311122e-02f, 2.80449558e-02f, -3.61328721e-02f, 6.85645342e-02f, -3.00797243e-02f, -7.78376218e-03f,
  3.42453755e-02f, -1.15894713e-01f, 4.62577157e-02f, 3.90644409e-02f, 3.45872566e-02f, -1.17004579e-02f, 3.18513485e-03f, -3.57972123e-02f, 1.05251260e-01f, -4.64921556e-02f,
  1.66999146e-01f, -2.87536770e-01f, 8.66277516e-02f, 4.57646027e-02f, -4.40886989e-03f, 1.55644622e-02f, -4.55387915e-03f, -1.05565771e-01f, -2.95984782e-02f, 4.22388054e-02f,
  -5.08455224e-02f, -9.69660748e-03f, 1.13514990e-01f, 4.66703326e-02f, -2.19660606e-02f, -6.09655529e-02f, 1.61920860e-02f, 8.57791584e-03f, -8.30513686e-02f, 6.14727400e-02f,
  7.49005228e-02f, -4.94099744e-02f, -1.69341527e-02f, -5.69252260e-02f, 7.79707804e-02f, -1.25622675e-01f, 1.27014657e-02f, -7.49040861e-03f, -1.12247057e-01f, 1.15664616e-01f,
  -1.05038501e-01f, -3.82072665e-02f, -5.91803864e-02f, 6.55336604e-02f, -1.30346313e-01f, 1.03173137e-01f, -4.73562218e-02f, 2.44743586e-01f, 1.65642127e-01f, -8.59904364e-02f,
  3.97596620e-02f, 4.88977171e-02f, -5.55695556e-02f, 2.86983177e-02f, -2.34821886e-02f, -4.19799201e-02f, -1.77422643e-01f, -6.51094764e-02f, -3.18500847e-02f, 1.29276499e-01f,
  2.50995848e-02f, -6.83939308e-02f, -7.85940886e-02f, 9.24163684e-02f, -1.05768278e-01f, 7.57505223e-02f, -2.10244000e-01f, -6.26713932e-02f, -1.45723253e-01f, -4.51508880e-01f,
  -2.35085547e-01f, -4.73861806e-02f, 4.64899652e-02f, -6.79787248e-02f, -3.90464850e-02f, 2.43677432e-03f, 1.28708214e-01f, -1.47372887e-01f, -4.56361249e-02f, -1.75940245e-02f,
  -1.02622271e-01f, -3.14784236e-02f, -5.42642698e-02f, -3.07078715e-02f, -6.29966408e-02f, 5.08977398e-02f, 5.80508672e-02f, -5.30737042e-02f, -1.12937558e-02f, 3.86782549e-02f,
  -4.67178561e-02f, -4.49154042e-02f, 3.95092648e-03f, 4.33812011e-03f, 1.03197522e-01f, -3.92943993e-02f, -2.02611964e-02f, -9.41746309e-03f, -8.16862583e-02f, -1.42751917e-01f,
  -4.67285626e-02f, -3.31653245e-02f, 9.41126980e-03f, 2.03220472e-02f, 2.91803357e-04f, 4.27551977e-02f, -4.58108671e-02f, -5.41983694e-02f, 2.87003685e-02f, 4.87429835e-02f,
  1.75078586e-02f, 5.13369665e-02f, 1.73579324e-02f, -4.77068133e-05f, -2.87566707e-02f, 1.35393245e-02f, -4.45677675e-02f, -7.77820423e-02f, -7.79872909e-02f, -2.99062394e-02f,
  -5.70759512e-02f, -3.11163235e-02f, -3.86536531e-02f, 1.51434988e-02f, -5.98934805e-03f, -3.94265875e-02f, 3.89991179e-02f, 9.31214076e-03f, -7.85106327e-03f, -5.64229600e-02f,
  2.18498141e-01f, 5.83796091e-02f, 3.07766609e-02f, 5.74304070e-03f, -1.00214563e-01f, 2.13630907e-02f, -3.62672769e-02f, 5.64362295e-02f, -2.54468638e-02f, -5.39064594e-02f,
  7.78903216e-02f, 3.26967649e-02f, -4.73626480e-02f, -4.77915816e-02f, 1.00350961e-01f, 1.76810864e-02f, -6.75726309e-02f, -8.55647549e-02f, 4.09625582e-02f, 2.07527690e-02f,
  4.68968712e-02f, -8.71056411e-03f, 4.53632437e-02f, -1.41781699e-02f, -4.06012870e-02f, -1.59934144e-02f, -2.44187401e-03f, 1.95729621e-02f, 4.12496030e-02f, 1.08879909e-01f,
  3.86314429e-02f, 1.76652506e-01f, 6.65033534e-02f, -3.14165861e-03f, 5.37695400e-02f, 9.74388719e-02f, 2.99202472e-01f, 1.65662855e-01f, -9.33629945e-02f, 6.43740520e-02f,
  3.50700431e-02f, 4.41990048e-02f, 1.14000171e-01f, 1.15272529e-01f, 9.21271858e-04f, 5.46620823e-02f, -1.28838681e-02f, 3.81596051e-02f, -1.62050370e-02f, -1.15668401e-01f,
  -4.75794822e-02f, -4.21601199e-02f, -1.24974445e-01f, 2.81855427e-02f, -2.50638407e-02f, 1.29552975e-01f, -1.97456721e-02f, 4.48910929e-02f, 2.46926378e-02f, 7.92428851e-02f,
  8.92933458e-02f, -2.21266448e-02f, -3.57922204e-02f, 5.37023731e-02f, -3.33338901e-02f, 3.34487073e-02f, 5.71655035e-02f, -2.44291853e-02f, 4.33596298e-02f, 5.37050031e-02f,
  -5.71244769e-02f, -9.06203389e-02f, 5.51935658e-02f, -8.96549895e-02f, -1.15894824e-02f, -6.32051677e-02f, -9.63633135e-02f, -7.25091770e-02f, -6.65542102e-05f, -5.77024519e-02f,
  -1.37835108e-02f, -9.89825353e-02f, 5.18880272e-03f, -3.67551297e-02f, -3.86484191e-02f, -5.85857965e-02f, 5.77084199e-02f, 3.39088887e-02f, 2.63107549e-02f, 1.17472157e-01f,
  7.20311627e-02f, -7.04016015e-02f, 2.52841128e-04f, -1.79895386e-02f, 5.24493754e-02f, 1.68032702e-02f, 2.09524464e-02f, 6.64845780e-02f, 2.52817255e-02f, 6.98954836e-02f,
  -1.02945312e-03f, -8.51929560e-02f, -2.58332863e-02f, -7.94635266e-02f, 5.99028869e-03f, 3.72070111e-02f, -2.27100272e-02f, 9.52142254e-02f, -1.03606015e-01f, -1.66934710e-02f,
  1.46239232e-02f, -3.40727493e-02f, -2.97661815e-02f, -7.85456002e-02f, 8.35746340e-03f, -5.18855862e-02f, -5.72016723e-02f, 1.97595246e-02f, 1.22512259e-01f, -4.82715257e-02f,
  2.49254286e-01f, -4.27960977e-02f, 4.23073098e-02f, 3.40032540e-02f, 1.70191359e-02f, -6.82342499e-02f, -2.76574809e-02f, -2.92289797e-02f, -1.07044123e-01f, 4.77326959e-02f,
  2.73126103e-02f, -4.51965034e-02f, 6.14115521e-02f, 7.97660202e-02f, 4.78051677e-02f, 7.29562789e-02f, 2.98781674e-02f, -4.88742813e-03f, -7.14730769e-02f, -8.43692496e-02f,
  -4.64264862e-03f, 1.41177207e-01f, 7.31915459e-02f, 2.07349285e-01f, 6.84504062e-02f, 9.31418985e-02f, 1.70012191e-01f, 1.38956413e-01f, 2.32599154e-01f, 5.09474099e-01f,
  -7.94298667e-03f, 2.11885292e-02f, -1.09323032e-01f, 3.32116708e-02f, 1.73137173e-01f, 1.60918534e-01f, 1.13080963e-01f, 7.01777115e-02f, -5.54324687e-02f, 1.33036710e-02f,
  -5.93502373e-02f, 2.13626772e-02f, 4.40992266e-02f, 2.31633205e-02f, 1.36018157e-01f, -4.24527116e-02f, -6.41926602e-02f, 8.31062645e-02f, 6.48051547e-03f, 8.59460533e-02f,
  -1.51110729e-02f, -6.78041056e-02f, -9.05369744e-02f, 4.54403684e-02f, -1.34816080e-01f, -1.16107240e-02f, -1.07441820e-01f, -1.06490828e-01f, -3.04300003e-02f, -2.21876159e-01f,
  -3.71569872e-01f, -8.45395103e-02f, 6.43516183e-02f, 1.58388913e-02f, 1.28642016e-03f, -3.96078750e-02f, -9.14930832e-03f, -4.07882631e-02f, 1.50592662e-02f, 8.32990091e-03f,
  4.04509017e-03f, -6.30433783e-02f, 2.07297914e-02f, 3.13317738e-02f, -4.55812141e-02f, -7.39453882e-02f, -2.50478890e-02f, 2.23836564e-02f, 1.88285802e-02f, -8.89413506e-02f,
  -5.03669158e-02f, -2.33062152e-02f, 1.72848552e-02f, 1.68635156e-02f, -1.17565016e-03f, 9.20435041e-02f, -8.25241357e-02f, -5.91759048e-02f, 4.05006558e-02f, -1.91257134e-01f,
  -9.38930316e-04f, -7.03939572e-02f, 3.18638533e-02f, -2.45139878e-02f, -6.57380093e-03f, 6.56859903e-03f, -8.50205272e-02f, -5.50952880e-03f, 7.15568438e-02f, 1.72177225e-03f,
  -2.34615803e-02f, -9.30791069e-03f, -5.71774170e-02f, 3.44222151e-02f, -1.89726837e-02f, 3.30086835e-02f, 2.56613530e-02f, 2.90206969e-02f, 4.78230081e-02f, -5.16568907e-02f,
  4.30556014e-02f, -8.23041890e-03f, -1.58148333e-02f, -5.24899103e-02f, 7.61046559e-02f, 8.18828195e-02f, -1.36620179e-02f, 2.43634544e-02f, -4.78235818e-02f, 7.43362606e-02f,
  -9.73218158e-02f, 2.21642941e-01f, -1.23616084e-01f, -2.26221178e-02f, 1.86416879e-02f, 5.16878627e-02f, -2.64807921e-02f, -2.96369530e-02f, -2.87819766e-02f, -1.19910913e-03f,
  5.10220416e-02f, 4.43870686e-02f, 1.63241923e-02f, 5.75940385e-02f, 6.59724399e-02f, 4.32439484e-02f, -2.97729727e-02f, 4.42031287e-02f, 2.05972157e-02f, -3.89381051e-02f,
  5.50264381e-02f, 3.60023640e-02f, 2.11873222e-02f, -7.91889951e-02f, -4.03299928e-03f, -6.20216597e-03f, -2.59014834e-02f, -6.41757846e-02f, 5.87116443e-02f, 9.16266292e-02f,
  -3.59425724e-01f, -1.81334794e-01f, 1.88583195e-01f, -7.11933821e-02f, 4.96400613e-03f, 1.10638738e-01f, 1.26326025e-01f, -1.14771210e-01f, -1.44776002e-01f, -1.07545592e-02f,
  -9.05421525e-02f, -1.50564060e-01f, 1.54104397e-01f, -2.02894602e-02f, 4.77770939e-02f, 8.83221701e-02f, 2.35339507e-01f, 2.71102898e-02f, 1.50608003e-01f, -1.65899977e-01f,
  8.38073492e-02f, -8.66239965e-02f, -1.33864388e-01f, -1.54769838e-01f, -9.33665549e-04f, 8.42856839e-02f, 1.50649399e-01f, -1.13871813e-01f, -9.61540341e-02f, -7.79244676e-03f,
  1.74220800e-02f, -3.90472591e-01f, 2.25651219e-01f, -1.11834377e-01f, 3.73135810e-03f, -2.44515855e-02f, -7.00416118e-02f, 4.74599823e-02f, 5.60144484e-02f, -8.43862146e-02f,
  4.77385707e-02f, -1.15396246e-01f, 4.49708626e-02f, 3.24336141e-02f, -6.58301339e-02f, -2.25540884e-02f, -1.14704713e-01f, -1.10781223e-01f, -3.51373740e-02f, -7.08334520e-02f,
  6.13970235e-02f, -2.27364078e-01f, -1.32977456e-01f, 3.14946361e-02f, 5.61425053e-02f, -4.91911508e-02f, -8.99514407e-02f, -4.63398993e-02f, -4.46863845e-02f, -4.92204838e-02f,
  2.97808256e-02f, -7.58094713e-02f, -1.30723473e-02f, -1.49024986e-02f, 4.88366047e-03f, 2.52757221e-02f, 5.01833595e-02f, -1.70765314e-02f, 4.04204465e-02f, -3.23230820e-03f,
  9.27169155e-03f, 6.02956722e-03f, 6.17864318e-02f, -1.02013061e-02f, 7.46873440e-03f, 8.98818485e-03f, -1.48790488e-02f, 8.38998985e-03f, 2.77262125e-02f, -5.00648469e-02f,
  -4.17716317e-02f, 9.45292041e-03f, 1.66861601e-02f, 5.38717955e-02f, -5.32899313e-02f, 2.22730711e-02f, 9.41501185e-03f, -3.37304324e-02f, -3.57948206e-02f, -8.67204964e-02f,
  1.78289577e-01f, 1.06245153e-01f, 1.50970817e-02f, -1.38753196e-02f, 3.99493724e-02f, -5.67910112e-02f, 5.99806793e-02f, -4.86156903e-02f, 3.85368243e-02f, -1.24605121e-02f,
  -6.44976795e-02f, 1.51066305e-02f, 6.69162050e-02f, -3.28116827e-02f, 9.49116722e-02f, -9.33752023e-03f, -4.42929566e-02f, 9.69733596e-02f, -2.69093160e-02f, 5.52812442e-02f,
  -2.14468013e-03f, 2.37582363e-02f, 7.43934512e-02f, 6.38682395e-02f, -4.95529622e-02f, 5.77751175e-02f, 1.42679185e-01f, 1.07154168e-01f, 8.18233117e-02f, 9.75045934e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.87894163e-02f, -1.11101873e-01f, 6.29226193e-02f, 2.62726750e-02f, -4.65330370e-02f, -9.49146152e-02f, -1.03973523e-01f, -1.15477040e-01f, -7.46176019e-02f, 6.12702034e-02f,
  -1.01781890e-01f, -2.05064844e-02f, 1.07106820e-01f, 1.10222906e-01f, -9.90831293e-03f, -1.17148601e-01f, -5.04886657e-02f, 6.01164065e-02f, 3.77891920e-05f, 2.94976048e-02f,
  2.14316547e-02f, -7.17149302e-02f, -5.63899428e-02f, 3.24294157e-02f, -1.03597946e-01f, -1.37412027e-02f, -1.50158508e-02f, 1.11729056e-02f, 3.12978700e-02f, -9.53672528e-02f,
  2.66422570e-01f, 5.50456829e-02f, -1.37211503e-02f, -1.78272314e-02f, 4.20525968e-02f, 1.38732353e-02f, 3.71169858e-03f, -9.58676860e-02f, -9.91820395e-02f, 7.52719343e-02f,
  5.64981736e-02f, 2.35905331e-02f, -1.31021603e-03f, 8.12868997e-02f, 1.89209338e-02f, 5.08698076e-02f, 1.59410369e-02f, -4.52194624e-02f, -8.08840171e-02f, -7.92339817e-02f,
  -3.37674692e-02f, -3.13248970e-02f, 7.11347684e-02f, 8.64906982e-03f, -4.34541628e-02f, 6.38942793e-02f, -9.80877355e-02f, -1.18625760e-01f, -1.21506572e-01f, -7.19830617e-02f,
  5.35182133e-02f, -2.40831613e-03f, -1.03114128e-01f, 3.80866602e-02f, -1.42507618e-02f, 2.93851625e-02f, -3.98098081e-02f, -1.52864382e-02f, 4.43262281e-03f, -2.39781234e-02f,
  -8.58131349e-02f, -7.72221386e-03f, -1.21495584e-02f, 4.07839864e-02f, -4.47548740e-02f, -8.66567269e-02f, 2.88598463e-02f, 2.92551033e-02f, -9.58888307e-02f, -5.42858839e-02f,
  -7.31743649e-02f, 9.48084518e-03f, -4.38991413e-02f, -4.52936739e-02f, -1.17070600e-01f, 5.43178841e-02f, -4.17560115e-02f, 4.11338508e-02f, 1.18731380e-01f, -3.21181044e-02f,
  1.06432386e-01f, -7.18637166e-05f, 1.27688795e-01f, 5.60005419e-02f, -1.07831933e-01f, -4.95472960e-02f, -3.85389589e-02f, -3.34435366e-02f, -1.37594361e-02f, -1.59740690e-02f,
  6.24159910e-02f, 6.06394522e-02f, -2.37065591e-02f, -1.21074822e-02f, 3.17319408e-02f, -8.09284225e-02f, -8.68611932e-02f, 3.52598689e-02f, -4.53474335e-02f, -1.38550531e-02f,
  -9.84197259e-02f, 4.53885496e-02f, 4.42593209e-02f, 1.30612195e-01f, 2.48694457e-02f, 8.38452056e-02f, 8.06980729e-02f, -2.24788859e-03f, 5.97331934e-02f, 1.39818668e-01f,
  6.28686175e-02f, -4.46519777e-02f, 5.46694994e-02f, 1.03114560e-01f, -3.76098268e-02f, -1.22195177e-01f, -7.35187754e-02f, -6.99313879e-02f, -1.12987533e-02f, 8.59029964e-02f,
  -1.89619679e-02f, -6.78854138e-02f, 9.70526785e-02f, -5.15952818e-02f, -1.46387108e-02f, -6.51947036e-02f, -2.10085344e-02f, -5.21881739e-03f, -4.47451659e-02f, 1.61041804e-02f,
  -3.60218100e-02f, 8.97066891e-02f, -2.73740161e-02f, 1.01693235e-02f, -2.96665356e-02f, 8.21875036e-02f, 1.13924071e-01f, 2.29920894e-02f, -1.45387556e-02f, 9.05876309e-02f,
  1.44112837e-02f, 2.83382870e-02f, -8.24946836e-02f, 7.17743188e-02f, -1.75375100e-02f, -2.51057325e-03f, -1.33221429e-02f, 8.01370759e-03f, 6.20393790e-02f, -2.20016818e-02f,
  -5.49948066e-02f, -4.23431098e-02f, 2.48813964e-02f, -1.07224971e-01f, 3.52977738e-02f, -4.64326479e-02f, 2.42361128e-02f, 7.64809698e-02f, 6.70834333e-02f, 7.68587217e-02f,
  3.67840491e-02f, -2.24834252e-02f, -1.08100548e-01f, 1.53005505e-02f, -2.50757467e-02f, -9.12124515e-02f, -1.01233363e-01f, -9.18505639e-02f, -5.62305599e-02f, -3.50552984e-02f,
  -9.09371451e-02f, -4.36025336e-02f, 3.42852250e-02f, -8.06881860e-02f, -1.12586416e-01f, 4.56939228e-02f, 3.57659236e-02f, -8.51001740e-02f, -9.36168712e-03f, 5.22512794e-02f,
  4.19966504e-02f, -3.04138754e-02f, -5.44755608e-02f, -8.30820575e-02f, -6.36695623e-02f, 7.33139217e-02f, -5.02834506e-02f, 5.50707504e-02f, 7.99551383e-02f, 1.25410501e-02f,
  -4.70400415e-02f, -2.23723296e-02f, -3.16860788e-02f, -3.16182561e-02f, -3.42414677e-02f, -3.31434123e-02f, -8.84687901e-02f, 5.34979515e-02f, 1.68349314e-02f, -3.31515111e-02f,
  -5.03051989e-02f, 1.11805694e-02f, 9.81939957e-02f, 2.19964273e-02f, -2.65845694e-02f, 3.30961719e-02f, 1.03129998e-01f, -2.32365616e-02f, 1.64851081e-04f, -8.97610113e-02f,
  -5.38891703e-02f, -1.25843128e-02f, -4.49962765e-02f, 1.69181414e-02f, 6.37679547e-02f, -7.20011890e-02f, -4.12495025e-02f, 1.38099678e-02f, 7.17447922e-02f, 4.54500923e-03f,
  -5.57977408e-02f, 5.81537858e-02f, 6.39187023e-02f, -5.70709445e-02f, 3.87311913e-02f, 1.26175284e-02f, 5.21495193e-02f, -1.01105489e-01f, -4.45641391e-02f, -2.24484596e-02f,
  -2.41547376e-01f, -1.68686166e-01f, -2.18758941e-01f, 6.30135983e-02f, -3.78145576e-02f, 1.30179778e-01f, -4.90121655e-02f, 8.47491696e-02f, 3.35933119e-02f, -2.01998562e-01f,
  -9.44024697e-03f, -1.92548502e-02f, -1.19497560e-01f, -5.67387454e-02f, -7.03479424e-02f, -1.89039797e-01f, -1.24689981e-01f, -2.19552398e-01f, 3.63321565e-02f, 2.25266144e-01f,
  7.14174658e-02f, -1.21955806e-02f, -2.57872604e-02f, 1.48277044e-01f, -1.73911639e-02f, 5.73015362e-02f, -1.01500684e-02f, -4.39876355e-02f, 1.76661506e-01f, -3.85024436e-02f,
  -1.75610304e-01f, 2.10687239e-02f, 1.40357107e-01f, 1.29508292e-02f, -2.23253556e-02f, -3.73798236e-02f, -8.59880522e-02f, -1.10120671e-02f, -1.96277369e-02f, -5.30855469e-02f,
  -3.31289843e-02f, -4.22130479e-03f, 4.86643054e-02f, 3.02882288e-02f, -2.80559584e-02f, -8.48523080e-02f, -1.34227484e-01f, -1.60585240e-01f, -5.53848855e-02f, -1.45481050e-01f,
  -9.67590362e-02f, -3.30395028e-02f, -2.63995081e-02f, 1.52036086e-01f, -5.16910143e-02f, -1.86745562e-02f, 6.06429838e-02f, 6.18237779e-02f, 1.65021107e-01f, 3.35239880e-02f,
  1.86808277e-02f, -3.13979574e-02f, -9.24737155e-02f, -1.86976343e-02f, -8.78828093e-02f, 4.45665419e-02f, 6.89100921e-02f, 7.62796625e-02f, 7.99110159e-02f, -1.01314247e-01f,
  -5.26053160e-02f, 1.48023833e-02f, 5.27245626e-02f, -6.00373037e-02f, -2.12178491e-02f, 7.19145313e-02f, 3.92660238e-02f, -1.24520604e-02f, 3.38216946e-02f, 1.37438104e-02f,
  -1.13695562e-01f, 1.97514333e-03f, 7.13275280e-04f, 4.37432490e-02f, -1.16532028e-01f, 8.98282137e-03f, 7.50461221e-02f, -6.89340755e-02f, -5.68220317e-02f, 7.33245313e-02f,
  9.16847400e-03f, 1.16897352e-01f, -3.82006019e-02f, 1.92355905e-02f, -2.17893422e-02f, -6.17741607e-02f, -6.34507909e-02f, 2.59349030e-02f, 2.80985441e-02f, -6.80841692e-03f,
  -8.16150606e-02f, -5.84855899e-02f, -8.51524249e-03f, -4.13282737e-02f, -2.79098395e-02f, -7.42437765e-02f, 1.93643458e-02f, 2.27730237e-02f, -4.11447138e-02f, -4.41583339e-03f,
  -4.86979149e-02f, -1.17187053e-01f, -5.12702540e-02f, 2.16952823e-02f, -4.87321839e-02f, -4.84977104e-03f, 5.19557158e-03f, 1.07774280e-01f, 4.41334881e-02f, -1.88670725e-01f,
  7.94657245e-02f, -1.28231803e-02f, -1.75165944e-02f, -3.80797125e-02f, 5.63391782e-02f, 2.64231092e-03f, -4.20140801e-03f, 1.26667500e-01f, -1.32231042e-03f, 1.67243674e-01f,
  1.74901426e-01f, 2.19620109e-01f, 1.89774767e-01f, 2.14231983e-01f, 1.48549899e-01f, 6.08653910e-02f, -1.35356665e-01f, -7.43148252e-02f, 8.06636587e-02f, 2.51780730e-02f,
  -4.83333059e-02f, 2.73715965e-02f, 2.38485318e-02f, -3.68903503e-02f, -1.10746831e-01f, 9.59913880e-02f, 7.97734968e-03f, -1.69439554e-01f, 4.51359749e-02f, -1.15183942e-01f,
  8.02419484e-02f, -6.25198334e-02f, 1.26341701e-01f, 8.15177113e-02f, -1.44123167e-01f, -5.25809042e-02f, -1.66492052e-02f, 6.05153516e-02f, 4.48929779e-02f, 1.32378675e-02f,
  -5.90183884e-02f, -4.67799045e-02f, -5.94192445e-02f, -1.70413628e-02f, -9.79512930e-02f, 6.39907569e-02f, -5.22847138e-02f, -2.88716704e-02f, -3.13808694e-02f, 1.01560548e-01f,
  6.12490885e-02f, -4.94109392e-02f, 1.58747420e-01f, 1.44942313e-01f, 4.92685884e-02f, 4.20568660e-02f, -1.53290406e-02f, -3.69046517e-02f, 3.39892916e-02f, 5.24632335e-02f,
  7.26596937e-02f, 4.11353298e-02f, -5.07875048e-02f, 5.53295389e-02f, 5.40571250e-02f, 6.88764155e-02f, -5.19225039e-02f, 5.01343906e-02f, -1.27800321e-02f, -1.14444286e-01f,
  1.82148144e-02f, 1.13865323e-01f, -8.96476489e-03f, 4.24633734e-02f, -2.15217173e-02f, -3.90548371e-02f, -1.11754224e-01f, 5.86196110e-02f, 7.45157525e-02f, -2.94586997e-02f,
  2.25557089e-02f, -6.46006921e-03f, -2.30701454e-02f, -9.17934403e-02f, -6.94998279e-02f, 4.76645352e-03f, -4.25019022e-03f, 1.22309923e-02f, 3.64042521e-02f, 3.43452170e-02f,
  -2.11515371e-02f, 1.38782188e-01f, 3.91404442e-02f, 6.89419033e-03f, -1.04102269e-01f, -2.51121800e-02f, 8.48004669e-02f, -6.03504404e-02f, -3.13975140e-02f, -9.05195177e-02f,
  1.36987761e-01f, -3.06817386e-02f, 1.47488900e-03f, -8.81613716e-02f, 1.61240529e-03f, 6.45958781e-02f, 5.69347776e-02f, 1.27570033e-01f, 3.09373178e-02f, -9.47395805e-03f,
  1.95725150e-02f, 1.54632658e-01f, 2.00352877e-01f, 1.73680186e-01f, 3.89915369e-02f, 1.54746443e-01f, 9.61655676e-02f, -8.18902105e-02f, -1.58766080e-02f, 4.14858982e-02f,
  -1.80030875e-02f, 1.65590525e-01f, 3.10763642e-02f, 1.66475147e-01f, 1.57970577e-01f, 1.70375153e-01f, 1.88022122e-01f, 1.73115447e-01f, 1.17687240e-01f, 8.83964077e-03f,
  1.25508371e-03f, 5.78977168e-02f, 9.00750235e-02f, -2.59159319e-02f, 2.64935680e-02f, 3.20701152e-02f, 1.07237823e-01f, 5.24913892e-02f, 2.54587568e-02f, 5.14679439e-02f,
  6.41136020e-02f, -6.42505661e-02f, 8.19128156e-02f, -4.60902229e-03f, 6.71683252e-02f, 6.21992163e-02f, 1.19599618e-03f, 1.39661252e-01f, -9.38717555e-03f, -3.38687301e-02f,
  -6.28494695e-02f, 2.52602249e-01f, -5.97420149e-02f, 6.38426617e-02f, 2.70290356e-02f, -6.00456633e-02f, 1.41899167e-02f, 2.84229703e-02f, -1.64751951e-02f, 1.69920903e-02f,
  -1.70023646e-02f, -2.52132285e-02f, 8.38377699e-02f, -5.89435659e-02f, 1.02125041e-01f, 9.31000337e-02f, -6.07822351e-02f, -6.58738837e-02f, 7.67678767e-02f, -2.18729805e-02f,
  3.81605215e-02f, 9.30654705e-02f, 1.29238348e-02f, -1.16623165e-02f, 8.25190619e-02f, 7.88481832e-02f, 6.33006319e-02f, 6.15264997e-02f, 6.01360165e-02f, -7.87762180e-02f,
  -7.81416222e-02f, -1.08735591e-01f, -3.38907093e-02f, -5.97108342e-02f, 1.28945606e-02f, -3.58142816e-02f, 8.44852701e-02f, 1.29371688e-01f, 2.68078092e-02f, -1.40393050e-02f,
  -1.58983171e-02f, 3.37534286e-02f, 7.27114454e-02f, -2.99633835e-02f, -5.27730063e-02f, -5.56639135e-02f, 2.75998674e-02f, -3.65771316e-02f, 3.16226073e-02f, 8.45230892e-02f,
  7.35153630e-02f, -1.59495100e-02f, 4.01375815e-02f, -2.47115623e-02f, 3.21925245e-02f, 7.11258203e-02f, -8.52098465e-02f, 6.91890568e-02f, -7.85771608e-02f, -1.23612573e-02f,
  1.07174926e-01f, 1.05500907e-01f, 4.21648622e-02f, 2.57433616e-02f, 1.39713705e-01f, 1.05770715e-02f, 5.86344190e-02f, -3.02354060e-02f, 6.68536574e-02f, 3.43625396e-02f,
  -6.37672022e-02f, 5.57050575e-03f, 3.96548249e-02f, -5.54171391e-02f, -6.37252852e-02f, 1.52539962e-03f, 2.45367363e-02f, 8.15683678e-02f, 4.53151390e-02f, -1.02195563e-02f,
  -1.05973698e-01f, -8.34371597e-02f, -1.80258751e-02f, -3.47029157e-02f, 3.35086845e-02f, -8.31549391e-02f, -2.93563511e-02f, -6.70874789e-02f, 1.27724474e-02f, -9.52374842e-03f,
  -1.89831808e-01f, -2.75923554e-02f, -8.41304958e-02f, -2.52809692e-02f, 1.00067407e-01f, 1.65401608e-01f, 2.66215578e-03f, 2.21070088e-02f, 4.39884067e-02f, 3.49734463e-02f,
  -5.22508956e-02f, 3.88267860e-02f, -8.74188542e-02f, -7.16040730e-02f, -9.62921977e-02f, -1.49681181e-01f, -5.58741875e-02f, -1.99302226e-01f, -3.90285701e-02f, 7.74660483e-02f,
  -9.64794233e-02f, -6.53747395e-02f, -1.42641172e-01f, 1.17501654e-02f, -4.65552546e-02f, -1.36278167e-01f, -8.21956620e-02f, -1.07751593e-01f, -1.02458268e-01f, -1.21908307e-01f,
  -1.01267576e-01f, 4.63842601e-02f, 1.78272165e-02f, 4.85941656e-02f, -2.39441097e-02f, 3.70668992e-02f, -4.61141914e-02f, -3.41477431e-02f, -3.54980375e-03f, -9.97425523e-03f,
  3.47742103e-02f, 7.38779604e-02f, 7.17373937e-02f, 2.10276991e-02f, 8.88955444e-02f, 7.33290240e-02f, 7.66151249e-02f, -3.74995880e-02f, 4.12596054e-02f, 9.88717675e-02f,
  9.46517438e-02f, 1.17474705e-01f, 1.22728357e-02f, 1.22282831e-02f, 1.35357484e-01f, 3.55885327e-02f, 3.29845101e-02f, 7.10055679e-02f, -1.73018463e-02f, -5.31909876e-02f,
  -1.14117395e-02f, -9.80494991e-02f, -3.68445702e-02f, 8.29976872e-02f, 7.33198449e-02f, 6.50251806e-02f, -7.70308524e-02f, -9.96476486e-02f, -2.28002928e-02f, 7.95230940e-02f,
  2.75900997e-02f, 6.53384626e-02f, -4.59765494e-02f, -9.53514054e-02f, 5.00287600e-02f, -1.24211600e-02f, -7.07912892e-02f, -4.03840914e-02f, 5.71709909e-02f, -5.58593050e-02f,
  4.37166318e-02f, 8.04203749e-02f, 5.13580069e-02f, -5.87671921e-02f, 3.97344232e-02f, 4.96697128e-02f, -5.04860422e-04f, 6.77694427e-03f, 7.82364756e-02f, -5.78157268e-02f,
  -1.27454609e-01f, 6.71412051e-03f, -6.66536838e-02f, -3.06264777e-03f, 3.75181367e-03f, 1.42228631e-02f, 1.21755833e-02f, 9.40161850e-03f, 5.43778166e-02f, 2.24884581e-02f,
  7.50065371e-02f, -1.10931648e-02f, 1.46499472e-02f, 1.22703174e-02f, 4.47024554e-02f, -6.23454787e-02f, -1.07057467e-02f, -4.43211310e-02f, -2.29893643e-02f, 1.08044907e-01f,
  4.89490256e-02f, -8.13696980e-02f, -5.92028797e-02f, 1.76585112e-02f, -4.29713773e-03f, -1.63106278e-01f, -1.47943094e-01f, 3.44055779e-02f, -1.44129902e-01f, -1.12571239e-01f,
  1.68099105e-02f, -4.42736745e-02f, -1.51576055e-02f, 1.32666260e-01f, -1.06402664e-02f, -1.10251993e-01f, -1.54942479e-02f, -7.43146762e-02f, 6.56367987e-02f, -8.50065574e-02f,
  -1.24086738e-01f, 2.37799063e-02f, -8.92171487e-02f, -1.13418713e-01f, 1.99223775e-03f, -6.11509532e-02f, 3.43986377e-02f, 8.32717568e-02f, 1.85482912e-02f, 1.26934871e-02f,
  4.59217541e-02f, 7.32883364e-02f, -2.17875503e-02f, 1.31052583e-01f, 2.36590151e-02f, 3.76089737e-02f, 4.16516028e-02f, 6.90947771e-02f, 3.70301157e-02f, 7.43903816e-02f,
  -8.32688138e-02f, -6.97727734e-03f, -4.57704403e-02f, -6.53064926e-04f, -8.55513439e-02f, -5.64961731e-02f, 5.52734546e-02f, 7.33594447e-02f, -7.49004185e-02f, -7.49537870e-02f,
  -1.06135476e-02f, -3.48109119e-02f, -8.58976021e-02f, -2.29170471e-02f, -8.02049190e-02f, 8.05745944e-02f, -2.89030802e-02f, 6.46930337e-02f, -3.69126424e-02f, -5.39944135e-02f,
  -5.83043024e-02f, 4.93485760e-03f, -8.64610970e-02f, 5.04666343e-02f, 2.92518958e-02f, -6.25785068e-02f, -8.14043805e-02f, 2.23718043e-02f, 7.88535774e-02f, 1.16698802e-01f,
  8.89401436e-02f, -7.78016448e-02f, -1.29223270e-02f, 7.81432241e-02f, 4.07864414e-02f, -8.62185960e-04f, 1.90415271e-02f, 5.96262217e-02f, -1.71985407e-03f, -7.19585940e-02f,
  -3.28021385e-02f, 5.90495125e-04f, 5.90053648e-02f, 5.23766465e-02f, 8.83697495e-02f, 7.00511504e-03f, 5.28208213e-03f, -4.63888422e-03f, -4.71734144e-02f, -5.45978248e-02f,
  -3.95165198e-02f, 8.53673443e-02f, -1.02602050e-01f, -3.82750854e-02f, 4.33031619e-02f, 6.85431138e-02f, -8.63539949e-02f, 4.65219133e-02f, -2.92619169e-02f, 1.20491209e-02f,
  5.34670539e-02f, 3.84651497e-02f, 4.56965268e-02f, -2.30600089e-02f, -2.51882356e-02f, 6.27853274e-02f, -7.96883330e-02f, 5.86217307e-02f, -9.66971144e-02f, 3.29581611e-02f,
  3.24505232e-02f, 2.67505702e-02f, 2.02382766e-02f, 3.65364179e-02f, 6.26372993e-02f, -4.48888401e-03f, -3.78099270e-02f, 4.69570272e-02f, -1.03766739e-01f, -2.40670070e-02f,
  -1.32790785e-02f, 2.76773386e-02f, 1.06111087e-03f, 1.00059453e-02f, 1.25737097e-02f, -7.58083835e-02f, 8.53115246e-02f, 5.76413684e-02f, 7.67231584e-02f, 9.70908701e-02f,
  -2.32516691e-01f, -5.26729859e-02f, 6.45684004e-02f, 1.99585706e-01f, 2.93458313e-01f, 2.72776484e-01f, 2.57907897e-01f, 2.62507975e-01f, 1.34669438e-01f, 6.76273704e-02f,
  -4.62460965e-02f, 1.61140531e-01f, 1.61740929e-01f, 5.60207351e-04f, 5.72063401e-02f, 9.23960656e-02f, 1.65472165e-01f, -4.87742852e-03f, 6.33131713e-02f, 1.34842172e-01f,
  1.59711480e-01f, -4.33127955e-03f, -2.29859695e-01f, -1.63576268e-02f, 2.24462017e-01f, 1.55126229e-01f, -1.64882205e-02f, 5.37047815e-03f, 1.64461776e-03f, 1.30653843e-01f,
  -2.38641217e-01f, -2.20711559e-01f, 1.53529346e-01f, -5.86625859e-02f, -1.04478762e-01f, -1.04511887e-01f, -4.93995622e-02f, 1.68505330e-02f, -6.15263171e-02f, -5.87441325e-02f,
  -3.18716541e-02f, -7.46133849e-02f, 1.37424886e-01f, -5.60161769e-02f, -2.21338458e-02f, -1.94651261e-02f, -6.39584139e-02f, -3.73692042e-03f, 6.98621199e-02f, -2.63585690e-02f,
  9.35605988e-02f, -3.86712216e-02f, -8.30603391e-02f, 4.50724103e-02f, 1.48258746e-01f, -5.85559830e-02f, 5.82329324e-03f, -4.90207598e-02f, 5.13804369e-02f, -3.25347409e-02f,
  -1.75355021e-02f, -2.28900965e-02f, 3.68928500e-02f, -1.39221996e-02f, -8.73637199e-03f, 4.15178128e-02f, 1.00257970e-01f, 3.44606936e-02f, 5.77106550e-02f, -2.07988657e-02f,
  -1.46592883e-02f, 6.22364022e-02f, -3.86551730e-02f, -5.25209634e-03f, 6.16387390e-02f, 3.65317054e-02f, 5.15459552e-02f, -7.51743913e-02f, -9.07068774e-02f, -3.12041637e-04f,
  4.47148383e-02f, -2.84132939e-02f, -9.52788144e-02f, 1.79092139e-02f, 2.42845025e-02f, -4.38559502e-02f, 2.48434488e-02f, -7.78026655e-02f, -2.32476164e-02f, 4.41610999e-02f,
  1.54765502e-01f, -8.52566808e-02f, 2.89108995e-02f, -3.81469317e-02f, 3.90361808e-02f, -1.11211531e-01f, 1.72938425e-02f, -5.79327159e-02f, -1.98900178e-02f, 5.32446988e-02f,
  6.68233493e-03f, 1.39211887e-03f, 9.12949517e-02f, 3.85024142e-03f, -2.08956655e-02f, -6.79819733e-02f, -2.18005553e-02f, 4.48603518e-02f, -3.40584032e-02f, -1.05894417e-01f,
  4.55599129e-02f, 1.53063366e-03f, 6.37319498e-03f, 1.37826502e-01f, 3.21052819e-02f, 6.70721307e-02f, -4.34291027e-02f, -5.27865924e-02f, -1.73197314e-03f, -1.34526789e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.55088185e-02f, -1.09100193e-02f, 6.64926469e-02f, 2.37202086e-02f, -6.10147044e-02f, 2.00496819e-02f, -2.80525833e-02f, -2.14825213e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.09697782e-01f, 2.09739596e-01f, -2.21126333e-01f, -1.70216024e-01f, -1.34985000e-01f, 4.01595054e-04f, -2.68760175e-01f, -1.26278281e-01f, -3.04922163e-01f, 2.40138575e-01f,
  -1.56631500e-01f, 4.70184535e-02f, 1.60547256e-01f, -6.32728543e-03f, 9.08089280e-02f, -3.46997052e-01f, -4.85512801e-02f, -2.02161729e-01f, -1.23016380e-01f, 4.45504606e-01f,
  -1.32630169e-01f, -2.32294500e-01f, -3.15115243e-01f, -2.25171864e-01f, -3.39470692e-02f, 2.07886726e-01f, -1.40103370e-01f, -1.52844071e-01f, 3.04843243e-02f, 3.66072208e-02f,
  8.90409723e-02f, -2.44851872e-01f, -1.83833182e-01f, -2.08738238e-01f, 4.76808622e-02f, 1.44941941e-01f, 7.60149807e-02f, 2.56834682e-02f, -1.64030984e-01f, 8.81448686e-02f,
  1.76594943e-01f, 2.16258273e-01f, 1.56638071e-01f, -7.27114454e-02f, 3.65326732e-01f, -4.26037490e-01f, -3.36157471e-01f, -2.14487061e-01f, 1.18018411e-01f, -2.04815760e-01f,
  8.53364170e-02f, 1.21753458e-02f, -2.11094052e-01f, -2.60247797e-01f, -3.64785222e-03f, 2.55485713e-01f, -4.28386517e-02f, 9.07592550e-02f, -8.00225735e-02f, -2.07462877e-01f,
  1.94089711e-01f, 3.56936865e-02f, -1.44609287e-01f, 1.24284603e-01f, -8.24980512e-02f, -6.94029778e-02f, -7.85034746e-02f, 4.59300615e-02f, 2.45107055e-01f, 7.98340887e-02f,
  1.19984196e-03f, 8.65244567e-02f, 2.10179597e-01f, -9.18226689e-02f, 3.33614312e-02f, -2.19377995e-01f, -6.54566064e-02f, -2.15909451e-01f, 4.79616262e-02f, 3.70597810e-01f,
  5.01672961e-02f, 2.42985427e-01f, 1.37652919e-01f, 2.25573912e-01f, -1.23449475e-01f, 2.33231023e-01f, -1.76683038e-01f, 3.56437504e-01f, 8.83873850e-02f, -1.11061540e-02f,
  -9.41217244e-02f, -1.39515726e-02f, -1.16701379e-01f, -2.84857959e-01f, 2.71426886e-02f, -1.50138987e-02f, 2.38982707e-01f, 2.37906590e-01f, -2.27916595e-02f, 2.59506777e-02f,
  -1.01681553e-01f, -1.50843650e-01f, -1.30485132e-01f, 3.58759344e-01f, -3.52280885e-01f, 1.90806296e-02f, 2.81859159e-01f, 3.35458457e-01f, 2.97224730e-01f, 1.65600609e-02f,
  -6.21082596e-02f, -2.64835477e-01f, 1.10875182e-01f, -1.87908769e-01f, 2.31486231e-01f, -2.28128746e-01f, -3.31979478e-04f, -2.78928369e-01f, -9.74705145e-02f, -4.29640710e-01f,
  -2.77681977e-01f, 7.24662170e-02f, 4.18497443e-01f, -6.82274103e-02f, 1.02639332e-01f, 3.12245578e-01f, 1.63760945e-01f, -3.98582637e-01f, 1.20959833e-01f, 4.17716086e-01f,
  -2.38202646e-01f, -1.51288509e-01f, -6.03439435e-02f, -1.91938337e-02f, -2.10729390e-01f, 2.39963219e-01f, -2.47109517e-01f, -1.08006678e-03f, 3.68822366e-02f, 1.92885295e-01f,
  -4.44054343e-02f, -3.89476418e-02f, 3.61430258e-01f, -2.43497312e-01f, -5.78166433e-02f, 1.93415135e-01f, 1.46514580e-01f, 3.19944441e-01f, 4.96629551e-02f, 2.14458093e-01f,
  -2.47185558e-01f, -2.88543910e-01f, -8.93138200e-02f, 1.79709475e-02f, 7.97560066e-02f, 3.17705840e-01f, 2.70418860e-02f, 1.98783100e-01f, -2.56726928e-02f, 1.01844862e-01f,
  -3.17456620e-03f, -3.67022268e-02f, 6.39293268e-02f, 3.20256948e-01f, -4.66745533e-03f, 1.67489246e-01f, -1.06386751e-01f, -4.09355946e-02f, 2.78259665e-01f, -2.91182846e-02f,
  2.41072327e-01f, 2.16750309e-01f, -2.93527037e-01f, -7.85011053e-03f, -1.87962070e-01f, 1.55685842e-02f, -3.13656889e-02f, -1.10287309e-01f, -1.52939670e-02f, -2.80599058e-01f,
  2.20736906e-01f, 8.03209692e-02f, 2.82933354e-01f, 8.55177045e-02f, -1.77153543e-01f, -9.72668156e-02f, -2.24505082e-01f, 7.62796998e-02f, -1.56880412e-02f, 1.03750728e-01f,
  -7.64667392e-02f, 2.57658005e-01f, -1.28970097e-03f, 2.30563119e-01f, -7.53413141e-02f, 1.59337327e-01f, 5.90721285e-03f, -3.46517831e-01f, 1.59458622e-01f, 4.04153485e-03f,
  -1.25478461e-01f, -5.34514152e-02f, -9.07484442e-02f, 4.66341199e-03f, -3.11460048e-01f, 1.76158771e-01f, 2.26593927e-01f, 9.28551108e-02f, -2.19791606e-01f, 2.64450788e-01f,
  2.05050766e-01f, 1.05088927e-01f, 1.54842809e-01f, 1.80171773e-01f, 9.61761996e-02f, -1.30327707e-02f, 2.48567492e-01f, -1.60287783e-01f, 1.21273689e-01f, 2.68579245e-01f,
  -2.07554512e-02f, -6.13227412e-02f, -2.28648875e-02f, -1.45955250e-01f, -1.16433442e-01f, 7.76572619e-03f, 5.38893342e-02f, 3.21962349e-02f, -3.37730050e-02f, 1.79978922e-01f,
  1.54997885e-01f, -1.45216256e-01f, 1.10050358e-01f, -3.86373848e-02f, -3.65593694e-02f, 1.05192520e-01f, 4.72426355e-01f, -2.04837784e-01f, -1.98676102e-02f, 9.63616520e-02f,
  5.09968540e-03f, -3.00765306e-01f, -4.02804092e-02f, -1.91851351e-02f, -2.61004448e-01f, -3.55815679e-01f, -2.79922962e-01f, 1.93999738e-01f, 1.13863803e-01f, 1.72428146e-01f,
  -8.72785673e-02f, -9.02261212e-02f, 1.35290325e-02f, -1.16018280e-01f, 4.32821400e-02f, 8.99242535e-02f, 7.95678943e-02f, 1.55254021e-01f, 1.89249292e-02f, -1.92625761e-01f,
  1.24219172e-01f, 1.58875957e-01f, -4.23876613e-01f, -1.25766635e-01f, -9.97360870e-02f, -2.13513061e-01f, 2.95250509e-02f, -2.90621191e-01f, 3.53891313e-01f, -3.29269052e-01f,
  -4.40953135e-01f, -4.07381169e-02f, 4.44633484e-01f, -3.47386211e-01f, -3.20430577e-01f, -1.39216051e-01f, -2.17102006e-01f, 1.27603114e-01f, -2.31805235e-01f, 4.02513221e-02f,
  -1.22066751e-01f, -1.16997853e-01f, -3.52436528e-02f, -2.32687637e-01f, 1.46819606e-01f, 1.04703583e-01f, 1.65452167e-01f, 5.09860590e-02f, -1.93168625e-01f, 5.42477407e-02f,
  -1.62000328e-01f, 9.98780690e-03f, 1.13069467e-01f, 8.69882014e-03f, 3.83770019e-02f, 1.03713550e-01f, -6.43355364e-04f, 1.25262082e-01f, 1.33462906e-01f, 5.10736704e-02f,
  -1.41884699e-01f, -1.53562173e-01f, -1.49119496e-01f, -1.29221275e-01f, 1.88388273e-01f, -1.24005549e-01f, -7.10505545e-02f, -3.20771962e-01f, -9.32001621e-02f, 1.40425622e-01f,
  1.73608109e-01f, 2.79765185e-02f, 1.35631606e-01f, -1.43927634e-01f, 1.68536529e-01f, 1.50196865e-01f, 6.85919747e-02f, 1.80070177e-01f, -1.73156023e-01f, -2.31941983e-01f,
  9.75137427e-02f, 2.98482001e-01f, 3.02114516e-01f, 5.13004027e-02f, 1.70578137e-01f, 2.79319465e-01f, 2.11876228e-01f, 7.36270323e-02f, 6.01472408e-02f, -2.67510451e-02f,
  1.17286429e-01f, 1.96587831e-01f, -3.08076710e-01f, 4.92083490e-01f, 9.67919547e-03f, 2.39461884e-01f, -3.14146653e-02f, -1.32557914e-01f, -1.47293672e-01f, 2.21913636e-01f,
  9.16393250e-02f, 1.24411121e-01f, -2.08009601e-01f, 4.74104658e-02f, 2.11726606e-01f, 1.03057131e-01f, -2.63010204e-01f, 2.68567707e-02f, -8.30367673e-03f, -7.94256330e-02f,
  3.93873081e-02f, 1.93741903e-01f, -1.97943121e-01f, -2.61420131e-01f, 5.19916527e-02f, 1.50357679e-01f, -3.24213862e-01f, 3.02837610e-01f, -1.23105526e-01f, -1.58923239e-01f,
  1.09659739e-01f, 2.63173580e-01f, -1.38970494e-01f, 4.12089638e-02f, -8.12710300e-02f, 2.93716401e-01f, -3.50317180e-01f, -2.44404942e-01f, 1.63195416e-01f, -2.79091805e-01f,
  -1.35538116e-01f, -1.56588644e-01f, -2.95916107e-02f, -9.70031023e-02f, 1.56135991e-01f, 1.34827733e-01f, -1.10198520e-02f, 3.57644856e-02f, -2.62608439e-01f, 8.16241056e-02f,
  2.43177429e-01f, -2.03064024e-01f, -3.65981366e-03f, -1.79584250e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.43107101e-01f, -3.82937610e-01f, 1.10433817e-01f, 2.26317257e-01f, -2.13295743e-01f, -1.20813563e-01f, 2.68648297e-01f, 2.74379373e-01f, -2.31534168e-02f, 2.80261368e-01f,
  1.93598852e-01f, 1.99194834e-01f, -4.92536277e-02f, 2.61313561e-02f, 1.17719352e-01f, -8.87491405e-02f, 7.21352175e-02f, 1.30505547e-01f, 2.11744532e-01f, -3.61199856e-01f,
  1.33274555e-01f, -4.93830107e-02f, 1.39352996e-04f, -2.33641088e-01f, -1.37298480e-02f, 1.30671933e-02f, 1.02667473e-01f, 2.60170192e-01f, 2.74955809e-01f, 1.50019988e-01f,
  -1.90131605e-01f, 3.14465612e-01f, 1.20081417e-01f, 4.20618236e-01f, 3.14500704e-02f, -9.76837277e-02f, 2.67993063e-01f, 9.53991041e-02f, -5.58314919e-02f, 2.43490472e-01f,
  -5.74548990e-02f, -7.77745843e-02f, 3.11739624e-01f, 3.76590699e-01f, 8.30054283e-02f, -1.77165583e-01f, 5.24057858e-02f, 1.43229831e-02f, -2.59904385e-01f, 1.16584189e-01f,
  1.45639345e-01f, 4.52014916e-02f, 2.82488257e-01f, -3.82467061e-02f, 1.50474548e-01f, -8.78190156e-03f, -4.71125171e-02f, -1.57435611e-02f, 2.86482304e-01f, -9.94219705e-02f,
  -3.27222841e-03f, 1.69837743e-01f, 2.97487900e-02f, -1.82099819e-01f, 4.96344678e-02f, -4.91868407e-02f, 2.48085231e-01f, -1.11924365e-01f, -8.69623758e-03f, 1.53131023e-01f,
  8.55759606e-02f, -1.22065723e-01f, 2.14504227e-01f, 1.83227703e-01f, 5.63706607e-02f, 2.09611759e-01f, -2.46227100e-01f, 3.33158672e-01f, -1.64795462e-02f, -8.08232501e-02f,
  -1.02955148e-01f, 1.34586334e-01f, -1.50512218e-01f, 1.52276903e-01f, -1.52642682e-01f, 9.39486101e-02f, 1.15049675e-01f, 2.43941396e-01f, 1.75280720e-01f, 9.81135517e-02f,
  -1.05647348e-01f, -1.49788365e-01f, 1.35569721e-01f, 1.28897838e-02f, 6.37505502e-02f, 3.61651093e-01f, 1.33387953e-01f, -2.33242870e-03f, 3.27707501e-03f, -1.36878639e-01f,
  1.36070058e-01f, -3.72129716e-02f, 8.71120840e-02f, -9.07404423e-02f, -8.79845470e-02f, 1.85300801e-02f, 1.27577111e-01f, 3.56139131e-02f, 1.03645541e-01f, -2.34952152e-01f,
  -6.57250881e-02f, -5.75808734e-02f, 1.89774752e-01f, 9.62638557e-02f, -1.32720307e-01f, 6.12046532e-02f, -1.20139495e-01f, 1.10416047e-01f, 5.32042384e-02f, 1.14036553e-01f,
  -1.41463429e-01f, 9.77337584e-02f, 3.62081230e-02f, 4.90936935e-02f, 1.17359854e-01f, -1.44339293e-01f, -1.55299664e-01f, 3.10007334e-01f, 1.78947225e-02f, -1.77430630e-01f,
  1.54256806e-01f, 1.18743561e-01f, -1.46427214e-01f, 2.51400024e-01f, -2.35047191e-02f, -8.26233774e-02f, -4.67008539e-02f, 2.16569439e-01f, 1.62335828e-01f, 2.38449782e-01f,
  -1.81323156e-01f, 2.00285539e-01f, -1.77861929e-01f, -1.22033581e-01f, 1.73142273e-02f, -6.40458092e-02f, -2.61837412e-02f, -1.91834077e-01f, 3.12132817e-02f, 1.37595087e-01f,
  2.30327994e-01f, 4.25174348e-02f, 1.13140993e-01f, 1.41364476e-02f, 2.34735534e-02f, -3.79713289e-02f, -1.65343713e-02f, -6.27451614e-02f, 1.54106393e-01f, -1.07932955e-01f,
  1.94227174e-01f, -8.41153041e-02f, 1.72109812e-01f, 2.01678365e-01f, -4.25056629e-02f, -1.84309959e-01f, -9.26003605e-02f, 1.39625967e-01f, 4.05400060e-02f, -1.10741302e-01f,
  1.39199570e-01f, -2.97372229e-02f, 7.18043074e-02f, -1.78413704e-01f, -1.57666013e-01f, -1.01061307e-01f, 1.05695948e-01f, -3.18580419e-02f, 2.05505759e-01f, -1.05008073e-01f,
  -1.37656763e-01f, -1.54996768e-01f, 4.64103781e-02f, -5.29332012e-02f, -1.56487092e-01f, -2.66610645e-03f, -1.27318472e-01f, -1.31686687e-01f, 2.07349434e-01f, -1.58875540e-03f,
  1.16905481e-01f, -1.89881220e-01f, 1.12994574e-01f, -2.66965300e-01f, 2.26085201e-01f, 1.86829954e-01f, 7.16698244e-02f, 2.18123868e-01f, 2.56237298e-01f, 1.53031081e-01f,
  9.65564847e-02f, 2.32629701e-01f, 1.18963636e-01f, 6.04791306e-02f, 3.77701372e-01f, -9.55398530e-02f, -1.27159610e-01f, -3.75270657e-02f, 2.86902249e-01f, -2.46882468e-01f,
  1.88441738e-03f, 3.63151357e-03f, 3.34832780e-02f, 5.27261905e-02f, -2.04571098e-01f, 1.80152636e-02f, 1.34178236e-01f, -5.76254092e-02f, -3.89970317e-02f, -2.44764552e-01f,
  1.71780765e-01f, 5.89567721e-02f, -1.12700120e-01f, -2.01891214e-02f, -8.03086236e-02f, 1.35750636e-01f, -1.17684565e-01f, 5.68709671e-02f, 2.29716320e-02f, 3.76732051e-02f,
  2.61232313e-02f, 1.56245619e-01f, 1.47838935e-01f, 1.56820238e-01f, -1.62542537e-01f, -7.42751285e-02f, 1.05640374e-01f, -1.33914471e-01f, 4.50208075e-02f, 1.17917964e-02f,
  1.26875177e-01f, -1.90630704e-01f, 1.41136989e-01f, 2.79734552e-01f, -4.51860689e-02f, -5.83449714e-02f, -1.18315525e-01f, -1.96092218e-01f, -4.12507094e-02f, -9.25461724e-02f,
  -8.34514797e-02f, -2.05226421e-01f, -2.95866393e-02f, 8.68421048e-02f, 1.02946110e-01f, 1.52640074e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.14392841e-01f, 1.42931059e-01f, 5.77532947e-02f, 2.66721155e-02f, 1.55415908e-01f, 2.79142708e-02f, 2.51001716e-01f, -8.92181247e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.61168844e-01f, 3.99433449e-02f, -2.09379867e-01f, -2.26173416e-01f, -1.42889723e-01f, 1.85557082e-01f, -2.99373120e-01f, -8.97154287e-02f, 4.99149859e-02f, 8.47778097e-02f,
  8.49377960e-02f, -1.17538676e-01f, -1.09178819e-01f, -4.39817831e-02f, 1.59833863e-01f, -5.96632771e-02f, 2.18894795e-01f, -1.70536906e-01f, 1.40387967e-01f, -6.75781583e-03f,
  -1.02106594e-01f, -8.77072588e-02f, -2.35431045e-02f, -4.44041044e-01f, -7.57214352e-02f, 4.39178571e-02f, -1.25829861e-01f, 7.15629682e-02f, -2.84176856e-01f, -5.57398610e-02f,
  -1.11520523e-02f, 9.41682234e-02f, -1.36278719e-01f, -9.63920876e-02f, -1.30092710e-01f, -1.70548007e-01f, -5.13428189e-02f, 1.85433514e-02f, 1.75684676e-01f, -4.45994921e-02f,
  2.68761843e-01f, -2.71437347e-01f, 1.34570241e-01f, -4.32071686e-02f, -9.36655030e-02f, 3.55724186e-01f, 9.04905051e-02f, -2.89525062e-01f, -2.24578828e-01f, -5.05248047e-02f,
  -4.73871946e-01f, 3.40583295e-01f, 3.99998099e-01f, -1.54500827e-02f, 6.35599997e-03f, 8.39337409e-02f, -2.52756298e-01f, -2.66664773e-01f, -1.73848048e-01f, 4.71633188e-02f,
  2.60486156e-02f, 4.98322397e-02f, 2.66513705e-01f, 1.88144043e-01f, 5.05682901e-02f, -1.01912528e-01f, 1.89530384e-02f, 3.64655182e-02f, -1.97008476e-01f, -4.83906195e-02f,
  4.54611517e-02f, -1.68411180e-01f, -1.41007960e-01f, -6.67088106e-02f, -2.95703888e-01f, -2.42814839e-01f, -7.10440576e-02f, -4.77614939e-01f, 1.55875981e-01f, -2.51322389e-01f,
  -7.15803122e-03f, 1.35281697e-01f, 2.23824456e-01f, -4.04009134e-01f, -2.64846236e-01f, -6.82787001e-02f, -3.21651436e-02f, 1.41528159e-01f, 8.40698555e-02f, 4.92082797e-02f,
  1.11335978e-01f, -9.17668045e-02f, 1.76790565e-01f, -2.31588855e-01f, -3.01261038e-01f, -1.53103977e-01f, -1.38279215e-01f, -1.83818862e-01f, -5.68502657e-02f, -3.46391112e-01f,
  1.74891815e-01f, -5.54324798e-02f, -3.55863363e-01f, 3.88211235e-02f, -1.88176259e-01f, -4.57596295e-02f, 8.01760927e-02f, 7.59241506e-02f, -4.38358039e-01f, -3.27304415e-02f,
  9.47039276e-02f, -4.60735559e-01f, -1.02181293e-01f, 2.40216747e-01f, -1.17775783e-01f, -8.60247388e-02f, -8.63649175e-02f, 1.07876085e-01f, -1.17452979e-01f, -7.83870518e-02f,
  3.46533984e-01f, 4.53454889e-02f, -1.70295328e-01f, 6.75642788e-02f, 1.05131045e-01f, 6.09481931e-02f, -7.42324442e-02f, -1.29076928e-01f, 1.18819304e-01f, 1.85306102e-01f,
  1.82302028e-01f, 9.77042466e-02f, -2.14594394e-01f, 1.22488355e-02f, 1.93779409e-01f, -2.43331268e-01f, 4.53287274e-01f, 1.20862149e-01f, -2.81052757e-02f, -8.42307582e-02f,
  4.33500469e-01f, -2.58461356e-01f, 1.66295961e-01f, 2.00022355e-01f, 4.35989618e-01f, -3.66044074e-01f, 3.39884274e-02f, 1.29332945e-01f, -3.29274803e-01f, -1.16721570e-01f,
  2.40719631e-01f, -4.72070932e-01f, -3.81209552e-01f, 2.87871808e-01f, 1.24652371e-01f, -1.71793297e-01f, -2.60395646e-01f, -9.17235613e-02f, -3.08803290e-01f, 1.23881407e-01f,
  9.72986817e-02f, 1.03980023e-02f, 2.71411002e-01f, -1.50024593e-01f, -1.47422940e-01f, -4.45980653e-02f, 2.21040070e-01f, 1.46493480e-01f, 2.05767170e-01f, 5.47593124e-02f,
  2.98045605e-01f, -1.07483834e-01f, 8.40447564e-03f, 1.37264743e-01f, -3.10635328e-01f, 4.99970019e-01f, 3.45433533e-01f, -1.31620571e-01f, 1.86916187e-01f, -5.38005419e-02f,
  -2.36592546e-01f, 3.01230848e-01f, -4.93922532e-01f, -4.20521088e-02f, 2.80644447e-01f, 3.15234482e-01f, -3.52066994e-01f, 2.08856408e-02f, -3.91952731e-02f, 1.36433810e-01f,
  -1.98761702e-01f, -1.31287217e-01f, -1.07544161e-01f, 1.68488696e-01f, -1.73208445e-01f, -3.38440128e-02f, -2.25074649e-01f, 5.77895194e-02f, 6.09377399e-02f, -4.79892455e-02f,
  -2.63484240e-01f, 1.49450302e-01f, 7.14610443e-02f, -2.18768835e-01f, 3.34403455e-01f, -3.79628658e-01f, -1.77322447e-01f, 3.39050218e-02f, 5.05132496e-01f, -7.61474594e-02f,
  1.82735234e-01f, -3.26305449e-01f, -2.76863754e-01f, 2.70750541e-02f, 1.45023838e-01f, -1.62533484e-02f, 2.89074123e-01f, -1.32062109e-02f, -1.63006917e-01f, 5.04263863e-02f,
  -2.02733636e-01f, -2.29428764e-02f, -3.08111869e-02f, 1.17370687e-01f, 1.74268916e-01f, 2.09716737e-01f, 7.44704530e-02f, -2.60508358e-01f, 8.74579102e-02f, -2.00592503e-02f,
  6.02948405e-02f, 1.50170596e-02f, 1.89816877e-01f, 7.39913285e-02f, 1.36954769e-01f, -1.92591071e-01f, 2.18199510e-02f, 4.09176014e-02f, 9.57003906e-02f, 2.17095971e-01f,
  4.16856743e-02f, 2.78327372e-02f, 3.18448752e-01f, -2.11147010e-01f, -3.71822059e-01f, 1.94245100e-01f, -4.41013098e-01f, -3.91509235e-01f, 8.76000598e-02f, 2.52705425e-01f,
  -1.89373612e-01f, -2.07234874e-01f, 1.56483632e-02f, 1.89700633e-01f, -1.56631097e-02f, -4.14722897e-02f, -2.19958559e-01f, -1.21077344e-01f, -8.91595408e-02f, -3.15272920e-02f,
  -1.28008887e-01f, 1.79155320e-01f, -2.52537876e-01f, 8.04725885e-02f, -1.19504310e-01f, 1.63565546e-01f, 2.19449133e-01f, -8.69653374e-02f, -4.28809933e-02f, -1.87852532e-01f,
  -2.58278870e-03f, -1.69512317e-01f, 2.95863986e-01f, -3.99733968e-02f, 2.97033906e-01f, -1.75839230e-01f, 2.44876295e-02f, -1.23983800e-01f, -3.17288674e-02f, -1.19164839e-01f,
  2.43800193e-01f, 1.40549187e-02f, -1.76615000e-01f, 3.30755375e-02f, -1.10881031e-01f, 2.30867583e-02f, -1.91017017e-01f, -5.25486059e-02f, 1.74660087e-01f, -1.63481608e-01f,
  3.26949745e-01f, 3.63547415e-01f, 1.49286866e-01f, -1.42656282e-01f, 6.61710426e-02f, 1.60823449e-01f, -1.39973551e-01f, -2.49300878e-02f, 1.04018703e-01f, 2.41550893e-01f,
  -1.26082286e-01f, 2.45695665e-01f, -1.94792449e-01f, -7.63394758e-02f, -1.24866411e-01f, 2.25557387e-01f, -3.69673967e-01f, 1.97699994e-01f, 3.58939677e-01f, -9.79720876e-02f,
  9.24876109e-02f, 1.67616442e-01f, 2.85519987e-01f, -1.88277587e-01f, 2.45499238e-01f, 2.55374551e-01f, 1.69420272e-01f, -1.38242722e-01f, 3.57553184e-01f, 7.39606619e-02f,
  1.57377087e-02f, 1.44047379e-01f, 6.35495931e-02f, -3.48001383e-02f, -1.13996610e-01f, -1.39509737e-01f, -7.55014569e-02f, -3.87595780e-02f, -4.85832617e-02f, 1.94028765e-01f,
  1.81105405e-01f, -3.87003347e-02f, -2.31389791e-01f, -9.99388397e-02f, -1.85805961e-01f, 5.37578501e-02f, 8.76776781e-03f, 2.85968751e-01f, 6.32174090e-02f, -3.42972279e-01f,
  -4.31218445e-01f, 1.72990039e-01f, -2.07117364e-01f, -1.86527640e-01f, 3.64952199e-02f, 2.95786917e-01f, -1.68319754e-02f, -1.96881548e-01f, 7.51972944e-02f, 5.06243147e-02f,
  -2.24538833e-01f, -6.12040572e-02f, 2.63575688e-02f, -2.30128914e-01f, -1.36319906e-01f, -1.60639033e-01f, -2.77741216e-02f, -1.18635863e-01f, -9.52487066e-02f, 1.62590239e-02f,
  -3.96782309e-02f, 3.80446389e-02f, 4.62251008e-02f, -2.10693968e-03f, -4.28282380e-01f, -2.87048191e-01f, 1.91108599e-01f, -4.70631510e-01f, -2.72689968e-01f, 1.53560966e-01f,
  1.23539023e-01f, -2.17887878e-01f, -1.87110245e-01f, 3.94593999e-02f, 1.81213215e-01f, 2.21075639e-01f, -2.99047232e-02f, 2.48555481e-01f, 2.98210233e-01f, 1.34055629e-01f,
  2.53473818e-01f, -1.01042986e-01f, -2.81543247e-02f, -1.79225057e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.65031366e-02f, -5.96726174e-03f, 3.04796785e-01f, 1.95802838e-01f, 2.09865451e-01f, 1.57739162e-01f, 1.19745187e-01f, 2.74938762e-01f, -1.31845564e-01f, 1.52365655e-01f,
  2.10325882e-01f, 1.94086581e-01f, 8.18490908e-02f, 9.85644832e-02f, -2.25454837e-01f, 2.32559830e-01f, -6.79362491e-02f, 1.46060497e-01f, -2.86066681e-01f, 1.90219358e-01f,
  2.11689815e-01f, 2.31643647e-01f, -1.97111890e-01f, -7.72438049e-02f, 4.43858534e-01f, -1.66024432e-01f, -6.69664284e-03f, 1.80321813e-01f, 1.52914882e-01f, 2.29142636e-01f,
  3.44225585e-01f, 1.57330006e-01f, 3.24734986e-01f, -2.86535583e-02f, 2.83163399e-01f, -1.51074387e-03f, 2.75410056e-01f, 6.45280001e-04f, 2.35474687e-02f, 4.22015600e-03f,
  3.08554798e-01f, -7.86273554e-02f, -1.80965252e-02f, 1.03996329e-01f, 2.47086007e-02f, 1.33517131e-01f, -9.25071388e-02f, 1.88320041e-01f, 1.59228936e-01f, 2.27678418e-01f,
  -6.52023405e-02f, -2.30165068e-02f, -3.62322718e-01f, -2.96442732e-02f, -1.87874481e-01f, -1.73728034e-01f, -1.20100416e-01f, 3.89202535e-01f, -9.30649713e-02f, 1.05199009e-01f,
  1.00624837e-01f, -5.18379807e-02f, -1.27038807e-01f, -1.41118899e-01f, 1.02078475e-01f, 1.86654702e-01f, 8.91953632e-02f, -9.47829038e-02f, 9.13000628e-02f, -1.32819459e-01f,
  -1.49142221e-01f, -1.19100204e-02f, -1.04770556e-01f, 9.03545693e-02f, -9.27620605e-02f, -1.99257165e-01f, 2.21423760e-01f, 2.07569683e-04f, 1.33920982e-01f, 5.23437187e-02f,
  -3.83621641e-02f, -3.82293649e-02f, -3.47679146e-02f, -9.30556431e-02f, -2.05548760e-02f, 1.66571587e-02f, 1.04258008e-01f, -3.09554070e-01f, 1.30148903e-01f, 2.24968880e-01f,
  1.59763753e-01f, 4.13599089e-02f, -6.02033213e-02f, -1.32980645e-01f, -4.91382629e-02f, 1.07531093e-01f, 2.60838538e-01f, 1.49541944e-01f, 3.49885017e-01f, -2.15904210e-02f,
  -1.61330670e-01f, 2.17806965e-01f, 3.38485599e-01f, 1.81031942e-01f, 3.75148088e-01f, 2.12721720e-01f, 2.92587638e-01f, 4.56632338e-02f, 4.01666999e-01f, 2.67290533e-01f,
  4.29844745e-02f, 5.88095903e-01f, 3.97781104e-01f, -2.05470160e-01f, -1.08442605e-01f, 1.39366552e-01f, -6.68707564e-02f, -6.75046071e-02f, -1.08379975e-01f, -2.94805735e-01f,
  1.47574637e-02f, 2.72451788e-01f, -2.97404587e-01f, 3.39656919e-02f, 6.65542632e-02f, -6.03814162e-02f, 9.46960002e-02f, 2.40942627e-01f, 2.01372206e-01f, -7.18497410e-02f,
  3.65632176e-02f, 2.14419395e-01f, 2.41005808e-01f, 1.97530910e-01f, 1.34826839e-01f, 1.51939005e-01f, -1.38259500e-01f, 1.05774768e-01f, 1.61834881e-01f, 2.12644950e-01f,
  1.91883847e-01f, 1.36623770e-01f, -5.51563799e-02f, -5.35025261e-02f, 8.04393142e-02f, 5.17831631e-02f, -9.82255861e-02f, -3.30017582e-02f, 5.82749620e-02f, -6.30496591e-02f,
  7.59814233e-02f, 1.68910056e-01f, 6.51851147e-02f, -1.59338236e-01f, -1.58969238e-01f, -6.76982030e-02f, -1.08524427e-01f, 6.56246841e-02f, 2.36874551e-01f, 5.57659380e-02f,
  2.01821014e-01f, 3.02816212e-01f, 1.06057040e-01f, 7.08980067e-03f, 2.53726602e-01f, -1.46868780e-01f, 1.56524420e-01f, 2.68867195e-01f, 2.85495102e-01f, -2.46194508e-02f,
  -8.81780535e-02f, -7.21492842e-02f, 1.46506110e-03f, -5.81404120e-02f, 4.24362756e-02f, 8.16783234e-02f, -7.62760639e-02f, 3.20332870e-02f, -7.48004317e-02f, -4.71802540e-02f,
  4.96540591e-02f, -3.49485464e-02f, 1.74625099e-01f, 2.13160947e-01f, -2.86754191e-01f, 2.05686659e-01f, 6.38848543e-02f, 7.97995850e-02f, -2.73784697e-02f, 9.62536782e-02f,
  1.14096791e-01f, 3.23901065e-02f, 2.30385229e-01f, 4.62632366e-02f, 2.30338424e-01f, 1.38048649e-01f, 4.09168154e-02f, 4.51751761e-02f, 2.72905529e-01f, -3.22629772e-02f,
  8.58915225e-03f, 1.84651241e-01f, -1.69796392e-01f, 2.80863374e-01f, -1.19954608e-01f, -2.51724999e-02f, -2.01748073e-01f, 1.52423665e-01f, -1.40482634e-01f, 1.02718687e-02f,
  2.88850088e-02f, -6.22559115e-02f, 1.95408821e-01f, 2.44646847e-01f, 2.08889276e-01f, 4.53597382e-02f, 2.73948759e-01f, -9.76349786e-02f, 1.14127964e-01f, -1.00712311e-02f,
  3.20310593e-01f, 6.20333813e-02f, -9.94849727e-02f, -1.21823587e-01f, 1.02197036e-01f, -5.20372614e-02f, -1.90342635e-01f, -8.10129717e-02f, 6.93905428e-02f, -5.54739945e-02f,
  -2.93113329e-02f, -7.67026320e-02f, 7.20778033e-02f, -6.69671446e-02f, 7.42614195e-02f, 1.02044195e-02f, 3.62417959e-02f, 2.67605055e-02f, 1.56242877e-01f, -7.16086477e-02f,
  4.28937003e-02f, -5.86634353e-02f, -1.57594562e-01f, 1.77075900e-02f, -1.83838978e-01f, -2.38982383e-02f, -2.40761980e-01f, 8.74122083e-02f, 1.04264110e-01f, 5.19226026e-03f,
  -1.24879144e-01f, -1.18814528e-01f, 1.81967691e-02f, 1.45243898e-01f, 1.03782564e-01f, 1.48590401e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  7.34115094e-02f, 7.60113075e-02f, -1.10417634e-01f, 6.45899475e-02f, 1.53517738e-01f, -6.55636191e-02f, 1.20663747e-01f, -2.40724552e-02f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.40107954e-01f, -2.51861155e-01f, 3.19416225e-02f, -1.23146094e-01f, 1.05583996e-01f, 3.27131361e-01f, -3.19822766e-02f, 7.45278597e-02f, 1.57904014e-01f, -3.28610957e-01f,
  -2.10847363e-01f, 4.65374663e-02f, -1.36849523e-01f, 3.40668857e-01f, 3.78839433e-01f, 2.20973015e-01f, -4.13195848e-01f, -3.43952864e-01f, 9.71141234e-02f, -3.42275530e-01f,
  -7.28775039e-02f, -1.21805094e-01f, -1.11746281e-01f, 1.79743752e-01f, 2.52949208e-01f, -1.27788782e-01f, -8.86247605e-02f, -2.53927231e-01f, 1.18767150e-01f, 2.92051788e-02f,
  2.39602923e-01f, 1.21051438e-01f, -2.66984016e-01f, 3.25429112e-01f, -7.73652270e-02f, 1.57907054e-01f, -1.39287144e-01f, -6.37151450e-02f, -1.04837045e-01f, 1.44491836e-01f,
  2.77081616e-02f, -5.00471778e-02f, 3.29740316e-01f, 1.82023317e-01f, -3.25437933e-01f, -4.29221243e-02f, -2.65043944e-01f, 3.14534485e-01f, -5.78808188e-01f, 6.75572380e-02f,
  -3.60837042e-01f, -9.90095660e-02f, -3.67474288e-01f, 2.80984312e-01f, 6.71902820e-02f, -6.03597835e-02f, 2.59830385e-01f, -1.73401402e-03f, -1.28636137e-01f, -3.66503507e-01f,
  -1.30763844e-01f, 1.78734764e-01f, 1.80022493e-01f, 1.02771651e-02f, -1.64453372e-01f, 2.18411982e-01f, 3.14759314e-01f, 1.92373544e-01f, 1.73118785e-01f, 1.56823233e-01f,
  -1.48490295e-01f, 4.24169265e-02f, -1.69513449e-01f, 2.08378546e-02f, 1.07125998e-01f, 3.11751485e-01f, -3.28989029e-01f, 1.70071989e-01f, -7.43747205e-02f, 2.14243084e-01f,
  -2.02139676e-01f, -3.09658110e-01f, -5.19912839e-01f, 4.25785072e-02f, -1.38641730e-01f, 2.60955900e-01f, -6.73414767e-02f, 4.33361351e-01f, -2.57466018e-01f, 1.51843444e-01f,
  -2.21569493e-01f, -4.03730482e-01f, 4.82709110e-02f, 2.14496017e-01f, -5.57219125e-02f, -1.38111770e-01f, -1.23262979e-01f, 2.63637781e-01f, 1.38062716e-01f, 2.27012351e-01f,
  2.54239649e-01f, 4.86588180e-01f, -1.32319797e-02f, 4.20339555e-01f, -1.31074190e-01f, -1.67282015e-01f, 7.25955367e-02f, -9.43685099e-02f, -6.58393353e-02f, -3.33116353e-02f,
  -5.03732823e-02f, -7.06918538e-02f, -5.53478189e-02f, -2.21267477e-01f, -1.23293707e-02f, -3.11640173e-01f, -3.23967248e-01f, 4.43987876e-01f, -3.39091897e-01f, 1.50231913e-01f,
  -1.75723240e-01f, -8.43874365e-03f, -1.24697819e-01f, -2.27745071e-01f, -1.62505719e-03f, 2.17535511e-01f, 2.08096117e-01f, -2.08352357e-01f, -6.23649620e-02f, -2.81632543e-01f,
  3.87521565e-01f, 2.33198196e-01f, -2.94116795e-01f, -1.74451619e-01f, -1.78740725e-01f, -1.90507889e-01f, 3.33154202e-02f, 2.57842332e-01f, 8.01065490e-02f, 2.48324186e-01f,
  2.03872636e-01f, -3.44157577e-01f, 2.38529712e-01f, 1.91534206e-01f, 5.20196930e-02f, -9.85487476e-02f, 2.48246029e-01f, 3.10333431e-01f, 9.28851143e-02f, -3.72220069e-01f,
  4.39975172e-01f, 2.78946936e-01f, -2.45431989e-01f, -1.69569254e-02f, 2.04027414e-01f, 1.63383588e-01f, -2.87148327e-01f, 5.54799698e-02f, -4.92535457e-02f, 4.74794134e-02f,
  1.00377567e-01f, -2.24805728e-01f, -4.58000749e-02f, -2.54734308e-01f, -1.76349413e-02f, -4.07418013e-01f, -7.89546520e-02f, -7.41055682e-02f, -4.30962183e-02f, 2.60345638e-01f,
  2.11897008e-02f, 1.65445358e-02f, 1.71672761e-01f, -1.56252295e-01f, -8.31232592e-02f, -2.30421409e-01f, 4.41633523e-01f, 1.64022967e-01f, 2.19451308e-01f, 2.16985330e-01f,
  3.96600068e-02f, -2.34643862e-01f, 3.42902392e-01f, -2.53252953e-01f, -1.89598516e-01f, 2.15509862e-01f, 1.07410222e-01f, 2.48768732e-01f, 8.02495033e-02f, 6.17022663e-02f,
  3.75102796e-02f, 1.40805081e-01f, -3.74258459e-02f, 3.71173352e-01f, -2.28487790e-01f, 6.61115944e-02f, 3.57280195e-01f, 3.53045970e-01f, 2.30095580e-01f, -1.81499854e-01f,
  1.27352417e-01f, -2.59155154e-01f, -1.36083961e-01f, -1.18608907e-01f, 1.68728486e-01f, 5.28068483e-01f, -7.13810325e-02f, 2.92435676e-01f, -4.88604568e-02f, -5.44399381e-01f,
  -3.01422238e-01f, -4.66418773e-01f, -1.93578869e-01f, -1.27194315e-01f, -4.28847700e-01f, 5.74391857e-02f, 8.53186622e-02f, -3.00914347e-01f, -1.91129044e-01f, 1.52968038e-02f,
  2.85821736e-01f, -3.05042099e-02f, -1.93872929e-01f, 2.10386738e-02f, 1.32450148e-01f, -3.49521160e-01f, 2.02889778e-02f, -1.06689730e-03f, -3.16972107e-01f, -1.30644694e-01f,
  1.76422834e-01f, -2.19706193e-01f, 1.24174515e-02f, 1.51345685e-01f, 2.83010881e-02f, 2.79585361e-01f, -7.10684434e-03f, -7.31934905e-02f, 3.46261710e-01f, 5.03346026e-01f,
  -3.65355939e-01f, -6.40717000e-02f, 2.72856444e-01f, 1.76472709e-01f, 2.09896132e-01f, -5.78389585e-01f, 1.11055516e-01f, 4.43272918e-01f, 8.16582441e-02f, -1.04821566e-02f,
  7.88197741e-02f, -2.71440297e-01f, 1.87511891e-01f, -2.02297792e-01f, -2.20710799e-01f, 3.21853091e-03f, -4.60040830e-02f, -2.34400168e-01f, 9.16717798e-02f, -8.36413875e-02f,
  2.68064499e-01f, 3.20014656e-02f, 7.40076452e-02f, -1.57234505e-01f, -9.43670496e-02f, 2.75766581e-01f, -1.20418198e-01f, 9.95925143e-02f, 1.70465663e-01f, -5.70861876e-01f,
  8.27754065e-02f, -1.64861709e-01f, 5.27946472e-01f, 3.67067426e-01f, 3.40393424e-01f, 5.35995185e-01f, 2.10711822e-01f, -3.72484624e-02f, 3.55082601e-01f, -1.17374532e-01f,
  -1.28709018e-01f, 3.75754058e-01f, -1.21654764e-01f, 2.43465140e-01f, -4.69869934e-02f, 3.86738032e-02f, -1.25366122e-01f, 1.08189851e-01f, -1.40725046e-01f, -1.44681046e-02f,
  3.06129724e-01f, -5.05695753e-02f, -7.46393427e-02f, -3.78785670e-01f, -2.66904294e-01f, -2.12206945e-01f, -1.84046015e-01f, 2.45647177e-01f, -8.97793546e-02f, 2.33406723e-01f,
  2.28156567e-01f, -3.83830100e-01f, 1.86884046e-01f, 3.40999305e-01f, -1.68140665e-01f, 5.48534188e-03f, 6.70112595e-02f, 3.92237157e-01f, 3.04869741e-01f, -3.11495990e-01f,
  4.71806288e-01f, 2.86536992e-01f, -1.13896228e-01f, 1.81662261e-01f, -1.01890951e-01f, -6.13120943e-02f, -1.63359761e-01f, -2.26778507e-01f, 1.05626471e-01f, -5.29391840e-02f,
  6.92630485e-02f, -2.38217533e-01f, 1.56152174e-01f, 2.03143388e-01f, -1.39753401e-01f, 3.86084169e-01f, -2.07691252e-01f, 2.14692894e-02f, -2.79167630e-02f, -2.40671307e-01f,
  1.30170941e-01f, 3.53694558e-01f, -1.33743867e-01f, 3.26862723e-01f, 2.75463521e-01f, 4.24892724e-01f, -4.74762917e-01f, -1.74796283e-01f, -1.53320402e-01f, -3.49202573e-01f,
  1.61315054e-01f, -3.00803095e-01f, -5.53965233e-02f, 5.12035549e-01f, 4.80646975e-02f, -2.31924683e-01f, 2.51064450e-02f, -4.34253961e-01f, 1.59809411e-01f, 9.07152370e-02f,
  1.61279827e-01f, -2.06566125e-01f, 7.34100342e-02f, -8.32605138e-02f, 1.55066803e-01f, -4.22352329e-02f, 1.83403179e-01f, 3.65392238e-01f, 2.55888496e-02f, 2.38578454e-01f,
  -1.10276699e-01f, 2.98897445e-01f, -2.81347595e-02f, -2.59842128e-01f, 2.84381866e-01f, -2.05313131e-01f, 2.08244830e-01f, -2.67079353e-01f, 3.40239197e-01f, 6.71586618e-02f,
  3.21561694e-02f, 1.74733236e-01f, 6.68254644e-02f, 1.62343606e-01f, 1.60092369e-01f, 1.28983468e-01f, -3.17001939e-01f, -2.04597823e-02f, 1.18513502e-01f, 8.91416073e-02f,
  -9.34128091e-02f, 1.35706171e-01f, -1.67505622e-01f, 2.79414691e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.00888270e-01f, -5.21969385e-02f, 8.22175816e-02f, 3.36957425e-01f, -1.61533132e-01f, -4.08942968e-01f, 9.19042900e-02f, -2.50527561e-01f, 2.75371164e-01f, 8.61580744e-02f,
  1.18193313e-01f, 1.30283594e-01f, 1.35841146e-01f, -3.72351445e-02f, -2.20976636e-01f, -2.69579031e-02f, -1.98252037e-01f, 9.03302208e-02f, -1.81684494e-01f, 3.20680380e-01f,
  1.05290851e-02f, -3.96097839e-01f, 3.24588604e-02f, -1.89169124e-02f, 3.38470638e-01f, 2.89227456e-01f, 1.01164930e-01f, 2.58913696e-01f, 1.90718606e-01f, 1.00521363e-01f,
  -1.23191975e-01f, 9.91767198e-02f, -5.95929362e-02f, 6.56705648e-02f, 3.31367552e-01f, 3.17761153e-02f, -9.63219926e-02f, 1.52435765e-01f, -8.57113115e-03f, 6.16713893e-03f,
  2.41953462e-01f, 6.87742382e-02f, 9.23295692e-02f, 1.76118493e-01f, -1.29593253e-01f, -5.00179306e-02f, -3.07546724e-02f, 1.63545772e-01f, -2.23212287e-01f, -2.40465328e-01f,
  -3.20094004e-02f, -1.34156778e-01f, 1.23607203e-01f, 2.36102670e-01f, 1.25084549e-01f, 3.42782795e-01f, 1.80199936e-01f, -2.24563062e-01f, -1.42848343e-01f, -2.66258687e-01f,
  -5.72139248e-02f, -1.77372813e-01f, 2.96347171e-01f, 9.46331173e-02f, 9.75770503e-02f, 2.00636879e-01f, 1.93355739e-01f, 2.27239296e-01f, 5.18473625e-01f, 4.98744965e-01f,
  2.56638527e-01f, 2.88862944e-01f, -5.30208200e-02f, 3.15366417e-01f, 2.62186795e-01f, 2.55879164e-01f, -6.91188350e-02f, -5.09849451e-02f, 2.69537479e-01f, 4.77700345e-02f,
  3.81472319e-01f, -1.82296395e-01f, -2.79031575e-01f, 1.16231129e-01f, -1.93334237e-01f, 2.07730323e-01f, 1.68160722e-01f, 4.38583285e-01f, -2.34212816e-01f, 2.68678397e-01f,
  8.19661096e-02f, -2.66818225e-01f, -8.13482925e-02f, 3.29151183e-01f, 2.90149212e-01f, -1.02047876e-01f, 1.32606551e-01f, -1.61475733e-01f, -7.07085952e-02f, 2.23735049e-01f,
  -1.20098665e-01f, -2.27730453e-01f, -1.29622027e-01f, -1.55034542e-01f, 7.28431642e-02f, -1.10551126e-01f, -1.50718629e-01f, 2.66889423e-01f, -2.00118914e-01f, -1.34958565e-01f,
  6.66230470e-02f, 1.87539488e-01f, -9.13415626e-02f, 3.01364630e-01f, 2.70408541e-01f, 1.72896340e-01f, 4.07912917e-02f, 1.05682686e-01f, 5.29171005e-02f, -1.66097563e-02f,
  2.18771949e-01f, -2.49759592e-02f, -1.32318288e-01f, 1.26777589e-01f, -5.84077612e-02f, 9.54088345e-02f, 2.84513831e-01f, -1.26119509e-01f, -4.73425165e-02f, -1.29378974e-01f,
  7.43968636e-02f, 1.91439893e-02f, 3.79938006e-01f, 1.79068059e-01f, 4.95522231e-01f, 2.79597789e-01f, 2.41594329e-01f, 3.44786346e-02f, -6.55453131e-02f, -4.86148410e-02f,
  -5.13231218e-01f, -2.08637401e-01f, 6.55204728e-02f, -4.62181568e-01f, 8.68562087e-02f, 4.67615783e-01f, -1.79186180e-01f, 4.64496203e-02f, -3.20017427e-01f, 6.73941493e-01f,
  4.26096357e-02f, -4.78751630e-01f, 1.62593752e-01f, 1.82809770e-01f, -2.09188163e-01f, 5.05723059e-01f, 3.23927224e-01f, -4.25764397e-02f, 2.25760698e-01f, -1.03520297e-01f,
  1.99490070e-01f, 2.14596346e-01f, 9.71704125e-02f, -1.70573890e-01f, -8.44274387e-02f, 1.24915235e-01f, -9.63216065e-04f, 2.65905410e-01f, 3.10522951e-02f, -1.32654816e-01f,
  3.01582545e-01f, -1.97242536e-02f, -3.09357438e-02f, 2.87593389e-03f, -8.55063926e-03f, -4.24933106e-01f, 3.70756716e-01f, 8.44355822e-02f, 1.96262464e-01f, -1.73151016e-01f,
  -1.34261474e-01f, 2.34019727e-01f, -1.18573852e-01f, 2.81171389e-02f, 1.54209346e-01f, -1.41281471e-01f, 1.22432426e-01f, 4.71171141e-01f, 1.63073435e-01f, 2.20308915e-01f,
  1.16159819e-01f, -1.90492809e-01f, 7.34943338e-03f, 3.27022463e-01f, -3.59389074e-02f, 3.00121516e-01f, -1.04316242e-01f, 8.04746430e-03f, -1.16059199e-01f, 2.47589916e-01f,
  -1.08739376e-01f, -2.16830775e-01f, 3.32503289e-01f, 1.42871633e-01f, -3.87283057e-01f, 1.33869871e-01f, -2.05376610e-01f, 5.88101409e-02f, -3.85607779e-01f, 5.29765151e-03f,
  -3.16656888e-01f, -1.50342092e-01f, -2.94587225e-01f, -5.29238693e-02f, -3.15701962e-01f, 1.54091921e-02f, 4.92005467e-01f, 3.09972223e-02f, -1.66023269e-01f, 9.65013504e-02f,
  1.63443834e-01f, 9.23683587e-03f, 1.15797527e-01f, -1.15270071e-01f, -9.12302732e-02f, -5.22215664e-02f, 2.49278396e-01f, 9.66828763e-02f, -3.35494652e-02f, 1.80145308e-01f,
  -7.66736716e-02f, 2.56484687e-01f, 1.38814375e-01f, 1.30721614e-01f, 1.89746127e-01f, -9.97649878e-02f, -1.80890277e-01f, -6.79820105e-02f, 2.32758462e-01f, 7.65909627e-03f,
  -1.59239247e-01f, -1.70661658e-02f, 4.80410159e-02f, -1.14276960e-01f, -2.30845407e-01f, 2.99553931e-01f, 1.70734957e-01f, 7.72808045e-02f, 1.40555084e-01f, -1.77320585e-01f,
  5.42651452e-02f, -1.70647591e-01f, 1.24693133e-01f, 1.80861607e-01f, 1.43799379e-01f, -1.08677499e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.60138541e-01f, 2.57780910e-01f, 3.77489537e-01f, 1.09380409e-01f, 2.07269222e-01f, -5.08558517e-03f, 1.89417243e-01f, 1.24964036e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  1.91034004e-01f, -5.07375360e-01f, -8.13414305e-02f, -3.70608896e-01f, -4.76383686e-01f, -3.77101451e-01f, -1.32410094e-01f, 1.64247900e-01f, -2.84609675e-01f, -5.83615541e-01f,
  4.04626429e-01f, 2.35929564e-01f, -3.24286878e-01f, -3.76703680e-01f, -4.43179637e-01f, -5.28831840e-01f, 3.52819026e-01f, 4.68548149e-01f, -5.58830976e-01f, 6.16008580e-01f,
  1.74246028e-01f, 5.40426970e-01f, -5.68810463e-01f, -3.01059559e-02f, 3.54021490e-01f, 3.11559923e-02f, -1.99201271e-01f, 4.23658013e-01f, -6.05225623e-01f, -2.76266307e-01f,
  -2.48671100e-01f, -1.68158427e-01f, -2.14913607e-01f, -4.24524173e-02f, 7.33966241e-03f, 2.14239970e-01f, 6.35847509e-01f, -9.36977789e-02f, 5.25636256e-01f, 4.92735893e-01f,
  5.94517827e-01f, 6.00581527e-01f, -5.94148412e-02f, 9.36809108e-02f, 3.71393919e-01f, 5.36328852e-01f, 9.61979032e-02f, 4.81844038e-01f, 7.59025812e-02f, -5.65416276e-01f,
  -1.99777409e-01f, 3.62810910e-01f, -4.24552649e-01f, -1.92644019e-02f, 4.71825749e-01f, -7.58901685e-02f, -3.33292186e-01f, 4.79987264e-01f, -7.49882385e-02f, 2.66252041e-01f,
  1.20378636e-01f, -2.59288609e-01f, -1.07351035e-01f, 4.96534705e-01f, 3.66838843e-01f, -6.28764853e-02f, 2.56575972e-01f, -1.20131969e-02f, 9.22952071e-02f, 2.41929650e-01f,
  5.39118826e-01f, -5.86584449e-01f, 4.66934562e-01f, -2.32754707e-01f, 3.25157046e-01f, 2.81651646e-01f, -5.99062800e-01f, 3.07746887e-01f, 4.30462152e-01f, 3.90155911e-01f,
  -7.65970170e-01f, -3.86318490e-02f, 1.15995921e-01f, -2.22865716e-01f, 1.72697559e-01f, -8.56505752e-01f, -7.49218941e-01f, -1.10789929e-02f, -1.64402738e-01f, -2.68161413e-03f,
  3.95463049e-01f, 1.70018002e-02f, 1.07865646e-01f, 1.30095541e-01f, 2.17128173e-01f, 4.72066849e-02f, -2.02567428e-01f, 3.79641354e-01f, 4.08174425e-01f, 1.21288776e-01f,
  4.97410625e-01f, -3.61488434e-03f, 2.77135760e-01f, 1.92630172e-01f, -7.52386302e-02f, 3.36162269e-01f, -4.92430598e-01f, 1.06503591e-02f, -4.57976103e-01f, 4.37971205e-01f,
  -7.35466108e-02f, -6.18109226e-01f, 1.72361523e-01f, 4.56397802e-01f, -5.20794511e-01f, -3.03898722e-01f, 5.21678030e-01f, 2.62944490e-01f, -4.77197140e-01f, -2.93101400e-01f,
  3.94780755e-01f, -2.19265535e-01f, -8.01233798e-02f, 9.69174206e-02f, 3.48351419e-01f, -4.65496242e-01f, -9.08279717e-02f, -1.12619914e-01f, -5.27140975e-01f, 2.31803712e-02f,
  -4.92805928e-01f, -3.71616304e-01f, -2.83712655e-01f, -5.75042903e-01f, -4.33017552e-01f, 3.11677068e-01f, -1.47110701e-01f, 4.56216991e-01f, -6.75696075e-01f, 1.09375536e-01f,
  -1.60809010e-02f, -6.00141227e-01f, -1.93622917e-01f, -5.26514173e-01f, 6.83928788e-01f, 2.92803235e-02f, -7.84191266e-02f, -1.09429313e-02f, 8.98302495e-02f, 3.86992484e-01f,
  -2.87867039e-02f, 5.05468138e-02f, 4.20373023e-01f, -1.32732078e-01f, -3.38468134e-01f, 6.36228248e-02f, 9.04086679e-02f, 2.91515648e-01f, -2.26597056e-01f, 5.39402254e-02f,
  3.02532971e-01f, 3.27199042e-01f, -1.37040969e-02f, 7.34759718e-02f, 5.83494663e-01f, 2.47024983e-01f, -1.87848762e-01f, 5.26126862e-01f, 4.86456156e-02f, 6.23117328e-01f,
  6.30975842e-01f, 2.95264181e-02f, 7.38105401e-02f, -2.56279223e-02f, 2.61705816e-01f, 8.10413584e-02f, 2.44838759e-01f, 1.85682833e-01f, -2.87532538e-01f, -2.76672900e-01f,
  3.92084450e-01f, -2.67640829e-01f, -8.58858004e-02f, 4.96210009e-01f, -3.88159782e-01f, -1.23035751e-01f, 5.48888803e-01f, 9.22700912e-02f, 5.22138357e-01f, -4.29802090e-02f,
  -4.90241528e-01f, 2.65463322e-01f, 2.18588486e-01f, 4.72384214e-01f, 1.66788787e-01f, -2.13990837e-01f, -3.90955269e-01f, 1.40340120e-01f, -7.52504110e-01f, -6.70887649e-01f,
  9.48516801e-02f, -3.35822016e-01f, 2.08586603e-01f, 2.16268659e-01f, 5.18095613e-01f, 2.25401521e-01f, -2.76602954e-01f, 1.81891501e-01f, 2.93261021e-01f, -3.49479437e-01f,
  2.74709404e-01f, -2.30937637e-02f, -5.93068659e-01f, 4.58576560e-01f, -3.57960224e-01f, -2.02502996e-01f, -3.63090038e-01f, -1.99568808e-01f, -6.27275258e-02f, -1.40575260e-01f,
  3.40940267e-01f, 3.45051169e-01f, 2.50440631e-02f, 1.39737327e-03f, -2.71778077e-01f, -2.36847594e-01f, 1.40666202e-01f, 4.09710020e-01f, -1.47389978e-01f, -1.85108781e-01f,
  -6.81727350e-01f, 3.86646867e-01f, -4.87171620e-01f, -1.43024698e-01f, -7.10077584e-01f, -4.47736263e-01f, 4.50421691e-01f, 1.52507797e-01f, 5.09635687e-01f, 2.64632493e-01f,
  -5.57270050e-01f, -4.20810163e-01f, 1.06582880e-01f, 4.87383008e-01f, -1.03986643e-01f, -2.56895691e-01f, 4.46918875e-01f, -7.70178959e-02f, 2.58483231e-01f, 1.87579632e-01f,
  -3.26933593e-01f, -6.23450466e-02f, -6.93855345e-01f, -2.23177731e-01f, 5.06294012e-01f, -1.01427428e-01f, 9.92728490e-03f, -4.39637154e-01f, -6.92276359e-01f, -4.99780029e-01f,
  2.78434843e-01f, -5.55702746e-01f, 6.78825304e-02f, 3.39464471e-02f, -6.84893131e-01f, 1.22484408e-01f, -4.17646617e-01f, 2.26425588e-01f, 3.38403672e-01f, -1.85818255e-01f,
  1.22477815e-01f, 8.06977376e-02f, -3.87834489e-01f, -3.33121568e-01f, 5.46228766e-01f, -3.18552196e-01f, -3.68719041e-01f, -4.73165274e-01f, 4.73746061e-01f, -1.99018195e-01f,
  -2.40752652e-01f, 3.21219027e-01f, 4.70232427e-01f, -1.04696624e-01f, -3.94749165e-01f, 2.41843343e-01f, 2.40980074e-01f, 3.58456790e-01f, -1.81489319e-01f, 4.96554732e-01f,
  -5.53508759e-01f, 4.36307549e-01f, -3.63749206e-01f, 1.69132292e-01f, 4.91926044e-01f, -4.75714862e-01f, 3.10653955e-01f, -6.19455755e-01f, -5.12032211e-01f, 1.83786139e-01f,
  -3.85333925e-01f, -1.84697464e-01f, -4.33159769e-01f, -1.88308030e-01f, -4.57951486e-01f, 3.17120850e-01f, 2.82835156e-01f, -1.48772404e-01f, 1.51161000e-01f, -2.43344486e-01f,
  -1.40631482e-01f, 7.77914226e-02f, -5.96050248e-02f, -2.70732462e-01f, -4.36013967e-01f, -5.94517440e-02f, 3.92022610e-01f, 4.13026690e-01f, -7.41508603e-02f, -6.69170767e-02f,
  1.98275045e-01f, 2.87845850e-01f, 2.40491226e-01f, 5.12660205e-01f, -6.51024356e-02f, 4.33973372e-01f, 4.71984029e-01f, -2.17762794e-02f, 5.05842827e-02f, 3.42133909e-01f,
  5.44392407e-01f, -2.87712961e-01f, -1.76895231e-01f, -7.59906173e-01f, -1.53058153e-02f, -4.69606072e-02f, 5.58661819e-01f, 1.21925250e-01f, -2.63969481e-01f, 4.54503447e-01f,
  3.29580933e-01f, 5.57754695e-01f, 1.84184670e-01f, 3.98224950e-01f, 8.67095590e-02f, 8.28582421e-02f, 6.88117266e-01f, -3.34327787e-01f, -7.34474003e-01f, -1.86335132e-01f,
  -5.47835588e-01f, -4.03977633e-02f, -7.91212991e-02f, -5.15657425e-01f, 3.53943914e-01f, 2.37529665e-01f, -6.07871711e-01f, 2.24855635e-02f, -4.46452536e-02f, -1.03887886e-01f,
  -1.06370687e-01f, -5.62126398e-01f, 5.67899048e-01f, -3.09878021e-01f, 3.53818148e-01f, 3.24377269e-02f, -1.14984095e-01f, 6.94607422e-02f, -1.88070625e-01f, -5.55513442e-01f,
  4.02977318e-01f, -5.63223541e-01f, -3.53065640e-01f, 8.61881301e-02f, 6.70094490e-01f, -1.71766922e-01f, 1.78589970e-01f, -3.05429339e-01f, -3.59893739e-01f, 2.32127309e-01f,
  5.94345741e-02f, -1.26521543e-01f, 4.50627744e-01f, 8.92616361e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  8.84765759e-02f, 2.07497075e-01f, -1.04836628e-01f, -2.02634424e-01f, 1.71518266e-01f, -1.00927077e-01f, -6.54813200e-02f, 1.53787777e-01f, -1.93243310e-01f, 7.85854012e-02f,
  2.05865741e-01f, -2.00706065e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    