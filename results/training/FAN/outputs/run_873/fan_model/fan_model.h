/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.56276202e-01f, -5.59030175e-02f, -9.09667835e-02f, 1.09919369e-01f, -2.44095460e-01f, -3.46780457e-02f, 4.00086725e-03f, 4.56242338e-02f, 2.59948662e-03f, -9.77606177e-02f,
  -2.12992772e-01f, -8.12043026e-02f, -2.31959999e-01f, -6.57599568e-02f, 6.62056282e-02f, -1.03765532e-01f, -1.20353602e-01f, 3.48697230e-02f, 1.90131769e-01f, 9.55824479e-02f,
  5.94544783e-02f, 2.90282398e-01f, 2.22495019e-01f, 1.97898462e-01f, -1.20636830e-02f, -3.09772100e-02f, -1.21534385e-01f, 3.45604569e-02f, -8.47097710e-02f, -6.72196969e-02f,
  -7.73592740e-02f, 1.99455619e-01f, -2.97721177e-02f, -6.81210533e-02f, -4.61785123e-02f, 1.57268897e-01f, -2.90186908e-02f, 6.18612207e-02f, -5.97063713e-02f, 3.93940285e-02f,
  -7.95389060e-03f, 7.23500326e-02f, -4.90233600e-02f, -8.45792610e-03f, 1.55588612e-01f, 4.91121262e-02f, 1.16741896e-01f, 1.02132946e-01f, -1.78750213e-02f, -1.27278194e-02f,
  -1.12872601e-01f, -4.11803313e-02f, -1.97032671e-02f, 1.92781892e-02f, 9.09597748e-06f, -1.00138195e-01f, -8.00993443e-02f, 4.65911962e-02f, -4.63289395e-02f, 1.93260908e-01f,
  2.36917529e-02f, -3.59843448e-02f, -1.25678554e-02f, 5.40890172e-02f, -4.06890400e-02f, -1.17926352e-01f, -2.02404847e-03f, -9.43678431e-03f, 2.01029126e-02f, 3.26345628e-03f,
  4.93460149e-02f, -1.00333363e-01f, -2.86477208e-02f, 4.77679484e-02f, -5.27083240e-02f, -2.55355630e-02f, 5.27994074e-02f, 8.07141047e-03f, -1.40365167e-02f, 1.88042037e-02f,
  -2.07894128e-02f, 2.05986463e-02f, -2.46884003e-02f, 5.13626775e-03f, -1.33554386e-02f, 3.31776850e-02f, 6.38083965e-02f, 2.46143825e-02f, -1.51679097e-02f, 4.49048877e-02f,
  6.51204214e-02f, -2.41799831e-01f, 5.07337600e-02f, 9.10230950e-02f, -3.92948836e-02f, -4.27754875e-03f, -7.45427981e-02f, 2.95574334e-03f, -5.50894439e-02f, 5.11375181e-02f,
  -2.54482590e-03f, 7.53060430e-02f, 2.73398366e-02f, 9.23114568e-02f, 4.23094966e-02f, 3.86980809e-02f, -5.74282855e-02f, -4.90432456e-02f, 2.30611512e-03f, 9.87754553e-04f,
  -2.54225396e-02f, -5.86306229e-02f, -7.99485818e-02f, -4.56336029e-02f, -2.66601928e-02f, -2.28868216e-01f, -1.26397535e-01f, 4.62335274e-02f, 3.09401215e-03f, 1.46598712e-01f,
  3.43910903e-01f, 2.14209482e-01f, -1.50080696e-01f, 2.14909717e-01f, 1.62624672e-01f, 9.92779657e-02f, 4.00600344e-01f, 1.51763290e-01f, 5.47470935e-02f, 2.51241237e-01f,
  9.62357894e-02f, -1.92652479e-01f, -1.91908523e-01f, -1.65571973e-01f, -1.29973680e-01f, 1.07905895e-01f, 7.59119242e-02f, -2.19235867e-01f, -2.59504855e-01f, -7.47377649e-02f,
  -4.58334163e-02f, -1.15240142e-02f, -1.11336388e-01f, -5.02878353e-02f, -8.51922631e-02f, -1.47802874e-01f, -2.78933253e-02f, -7.40428194e-02f, 2.63024191e-03f, -9.34592783e-02f,
  -2.55512089e-01f, -1.63186472e-02f, -1.03789687e-01f, -5.01907505e-02f, -1.00581504e-01f, 4.83177304e-02f, 8.47889483e-02f, 4.36062887e-02f, 1.39648858e-02f, 1.59693640e-02f,
  1.96516179e-02f, 1.63207985e-02f, 1.85450204e-02f, -5.34554012e-02f, -1.46913354e-03f, 1.16852240e-03f, 4.18085465e-03f, -6.67393729e-02f, -1.00083962e-01f, -1.08940192e-02f,
  7.34547824e-02f, -3.14439880e-03f, 3.54919471e-02f, -2.66541094e-02f, -9.67446901e-03f, -1.24705732e-01f, 1.07853832e-02f, -1.35300756e-01f, -1.67954843e-02f, 2.26441342e-02f,
  4.77007707e-04f, 1.27141969e-02f, -9.38825011e-02f, 2.60674693e-02f, 1.79174989e-02f, 3.33170928e-02f, -5.14778607e-02f, 3.52365002e-02f, -6.85845781e-03f, 3.76132950e-02f,
  1.56602524e-02f, -1.95577033e-02f, 8.62587430e-03f, 9.45476145e-02f, 1.76782452e-03f, -1.60580128e-02f, 3.18635255e-02f, 3.81135866e-02f, 5.20603778e-03f, 9.87374969e-03f,
  -9.64092761e-02f, -2.53997967e-02f, 5.13324142e-02f, -9.60606337e-02f, -1.65903363e-02f, -2.36716913e-03f, -2.23331749e-02f, -5.12090325e-02f, 7.53979683e-02f, -1.46391634e-02f,
  1.53771238e-02f, -2.99612023e-02f, -1.38143823e-02f, -7.01924115e-02f, 1.02505712e-02f, 4.23299940e-03f, -6.93343431e-02f, -5.39962389e-03f, -5.13070598e-02f, 3.87821682e-02f,
  -4.73131798e-02f, 2.54877172e-02f, 2.45930278e-03f, -3.06127220e-02f, 1.73140261e-02f, 5.29556461e-02f, 1.45479560e-01f, -7.87981451e-02f, 1.50611456e-02f, 6.23261370e-03f,
  9.41197723e-02f, 1.20068274e-01f, 8.28983728e-03f, 5.71670085e-02f, -5.34500927e-02f, 1.69331711e-02f, -4.26409282e-02f, 9.13111567e-02f, -2.47928686e-02f, 3.75141829e-01f,
  3.68908159e-02f, 1.28932260e-02f, 3.66799571e-02f, -3.84533592e-02f, 1.04181953e-01f, -4.99830507e-02f, 1.22477412e-02f, -1.43883109e-01f, -3.40400934e-02f, 1.02459788e-01f,
  -3.16162370e-02f, -2.16209888e-02f, -1.52951911e-01f, -1.59806654e-01f, -9.50527191e-02f, -8.01596269e-02f, 7.33062997e-02f, 3.63980583e-03f, -1.07096694e-01f, 1.42436013e-01f,
  1.71231568e-01f, 1.94423899e-01f, 6.20841384e-02f, 3.47549096e-02f, 1.65073812e-01f, 9.03719738e-02f, 1.23617113e-01f, 1.57227814e-01f, 1.84957385e-01f, 2.95095742e-01f,
  1.36212423e-01f, -6.58398643e-02f, -5.00357859e-02f, 1.00327797e-01f, 5.55062592e-02f, 3.05858292e-02f, -8.02908279e-03f, -3.19789387e-02f, -4.84701544e-02f, 3.73457633e-02f,
  3.30571234e-02f, 7.97609333e-03f, -1.05705317e-02f, 5.81051856e-02f, 4.99898801e-03f, 4.79809940e-02f, -9.13185179e-02f, -1.40393570e-01f, -1.28741890e-01f, -1.88812148e-02f,
  4.96495180e-02f, 3.50535363e-02f, 7.79960975e-02f, -6.64172620e-02f, -9.14772153e-02f, -7.23679140e-02f, 7.87091106e-02f, 5.99360615e-02f, 4.97335866e-02f, 3.30650240e-01f,
  1.35057747e-01f, 3.91468443e-02f, -7.59497359e-02f, -2.55134441e-02f, 2.66623087e-02f, 1.57728847e-02f, -4.61935811e-02f, 3.67240570e-02f, 1.79483034e-02f, 3.57979611e-02f,
  -4.48688716e-02f, -5.11867255e-02f, 6.77443370e-02f, -1.02575403e-02f, 4.65992466e-02f, 2.78673638e-02f, 3.80858257e-02f, 1.64666343e-02f, 3.00815701e-02f, 1.21178767e-02f,
  -7.38306120e-02f, 3.36996242e-02f, -1.18506392e-02f, 7.35691609e-03f, -1.28682656e-03f, -2.52695978e-02f, -7.84995779e-02f, -1.99283031e-03f, -3.19600627e-02f, 6.03160262e-02f,
  4.62529771e-02f, -2.23334685e-01f, 6.44083275e-03f, -1.51942428e-02f, 9.92333423e-03f, 1.95923373e-02f, 6.03592582e-02f, -1.12706929e-01f, -1.22184858e-01f, -1.50786433e-02f,
  -1.18283636e-03f, -7.88154751e-02f, 1.14626950e-02f, 3.40154022e-02f, -3.95926647e-02f, 5.52302413e-03f, 5.47049083e-02f, 1.35441460e-02f, -3.87967937e-02f, 8.64322931e-02f,
  6.47006258e-02f, 1.75958395e-01f, 1.69433057e-01f, 3.60263337e-04f, 3.97474729e-02f, 1.27800629e-02f, 5.41156642e-02f, 1.89254448e-01f, -4.87973653e-02f, 2.22083718e-01f,
  -4.19812113e-01f, 2.89987952e-01f, 1.23633109e-01f, -1.90022737e-01f, 8.94945562e-02f, 3.38537574e-01f, 3.47816050e-01f, 2.82512933e-01f, -6.09396398e-02f, 5.83772324e-02f,
  -7.31802061e-02f, -3.65274310e-01f, -2.39586532e-01f, -9.78063643e-02f, 6.81445673e-02f, 2.76518196e-01f, 1.50033072e-01f, -9.08026621e-02f, -2.08263546e-01f, -9.78938714e-02f,
  6.02381583e-03f, -4.41142097e-02f, -1.48642853e-01f, -8.58523697e-02f, 7.40432814e-02f, -1.06242523e-02f, 1.14267372e-01f, -4.81391139e-03f, 7.28346035e-02f, 4.11264151e-02f,
  -2.67236799e-01f, 5.91603890e-02f, -2.83627063e-02f, -1.36513993e-01f, -6.39149994e-02f, -2.91012530e-03f, -9.19773951e-02f, 4.91507277e-02f, 5.38595580e-03f, 3.97746824e-02f,
  -4.08350639e-02f, -1.28155649e-01f, -2.10848693e-02f, -6.41105101e-02f, 3.72577235e-02f, 4.69127782e-02f, 1.10791966e-01f, -2.69666854e-02f, 1.94785185e-02f, 5.93391843e-02f,
  6.28472194e-02f, -4.53274511e-02f, 2.30279136e-02f, 5.54212295e-02f, 4.59300503e-02f, -1.06115691e-01f, 4.10488099e-02f, 2.19633081e-03f, 1.65692659e-03f, 6.80920705e-02f,
  4.10161540e-02f, 8.12992547e-03f, -2.85916054e-03f, -6.89115934e-03f, -2.36892235e-02f, 6.81902841e-02f, 7.86061883e-02f, -4.81638834e-02f, 5.36944419e-02f, 2.09942553e-02f,
  3.50366607e-02f, -4.74003479e-02f, 7.97436573e-03f, 1.59220695e-02f, -3.11470274e-02f, 7.20431432e-02f, 2.22877041e-02f, 2.96576123e-04f, -5.16629480e-02f, 2.15885509e-02f,
  -1.14586890e-01f, 4.33889441e-02f, -4.85488847e-02f, -5.04517183e-02f, 5.30843250e-02f, 5.90537637e-02f, -1.76579058e-02f, 6.06718734e-02f, -9.49692726e-03f, 6.11591041e-02f,
  -1.81475610e-01f, -1.78902615e-02f, -8.04549903e-02f, -1.02676265e-01f, 5.61967008e-02f, 2.17450913e-02f, -9.07999203e-02f, -3.12506221e-02f, -4.14094003e-03f, 1.08757103e-02f,
  -3.95895205e-02f, -6.52775094e-02f, -7.42817596e-02f, 7.34113976e-02f, -6.25881851e-02f, -5.01384623e-02f, 1.72697082e-02f, -7.99011141e-02f, 2.36760974e-02f, 4.08859402e-02f,
  6.18197657e-02f, 8.16174448e-02f, -1.47477135e-01f, 6.04430288e-02f, -6.84201568e-02f, -1.66742027e-01f, 3.11842952e-02f, -6.00847453e-02f, -4.81291004e-02f, 5.50430780e-03f,
  4.54154685e-02f, 4.33772594e-01f, 7.35390633e-02f, 4.77801003e-02f, 2.08608702e-01f, 1.31629884e-01f, 1.68779552e-01f, -6.63297251e-02f, -5.75395748e-02f, 1.85447410e-01f,
  2.27373704e-01f, -4.47308086e-03f, -8.75039324e-02f, -1.89488709e-01f, -2.87023224e-02f, 8.66091717e-03f, 7.58486427e-03f, -1.21868074e-01f, -2.97195375e-01f, -6.16536662e-02f,
  8.25357903e-03f, -6.60931692e-02f, -9.26435664e-02f, -2.10212953e-02f, 9.95318517e-02f, -1.44694149e-01f, -1.06925480e-02f, 1.35839418e-01f, 1.16851896e-01f, 1.64593548e-01f,
  7.69518223e-03f, 2.27576435e-01f, -1.30191132e-01f, 4.84401621e-02f, 7.47508695e-03f, -4.50474164e-03f, -5.40592298e-02f, -4.99830805e-02f, 2.58544125e-02f, -2.51440313e-02f,
  1.28035083e-01f, 3.43150608e-02f, -5.76224588e-02f, -3.10916975e-02f, 6.43414333e-02f, 1.56036355e-02f, -5.40028214e-02f, -4.07594927e-02f, -5.93270808e-02f, 1.72781333e-01f,
  1.95503518e-01f, 2.70197302e-01f, 3.96813080e-02f, -1.83546357e-02f, -3.61510664e-02f, -8.37071091e-02f, 8.81597772e-02f, 9.51813757e-02f, -4.13084738e-02f, 9.22491699e-02f,
  7.79948337e-03f, -7.53099322e-02f, -5.16020053e-04f, -9.46680922e-03f, -4.18663882e-02f, -6.51169345e-02f, 2.74418034e-02f, -1.86776894e-03f, -7.86948800e-02f, -1.30283758e-02f,
  -8.90537165e-03f, 5.98087348e-02f, 3.42967398e-02f, -5.56849614e-02f, -1.50170329e-03f, 4.83713672e-02f, -3.87117229e-02f, 8.90354142e-02f, -3.84214185e-02f, -4.58021238e-02f,
  2.60835681e-02f, 2.79550496e-02f, -1.36862239e-02f, -3.06766219e-02f, 3.54472362e-02f, 7.83701837e-02f, 4.17029299e-02f, -8.44612420e-02f, -1.27534932e-02f, 3.17612290e-02f,
  -1.77005798e-01f, 4.19304855e-02f, -4.41019945e-02f, -6.23680241e-02f, 4.46079634e-02f, -4.07917649e-02f, 5.95593788e-02f, -3.24513726e-02f, 7.97350332e-02f, -6.77639022e-02f,
  2.33041346e-02f, 3.08028627e-02f, 9.60805863e-02f, -8.19805020e-04f, -2.62398329e-02f, 5.20738624e-02f, 6.92616850e-02f, -1.89272147e-02f, 4.38927636e-02f, 7.87976831e-02f,
  1.85066145e-02f, -6.41803667e-02f, -1.53768852e-01f, -1.25722528e-01f, 8.29758421e-02f, -3.93040217e-02f, -1.18648075e-01f, -4.03835028e-02f, -2.24839196e-01f, -1.23757243e-01f,
  -3.42724323e-02f, -9.80402604e-02f, -3.00326079e-01f, 9.62742642e-02f, -7.53384316e-03f, -2.28303954e-01f, -2.59767175e-01f, -5.78944273e-02f, 1.18720017e-01f, -3.82574908e-02f,
  -9.84764248e-02f, 4.80405390e-02f, -6.13086410e-02f, 1.28995804e-02f, -1.90160692e-01f, -1.79419160e-01f, -7.81210437e-02f, -1.37546852e-01f, -1.85042664e-01f, -3.39286029e-02f,
  2.21592456e-01f, 2.00560540e-01f, 7.27106482e-02f, 8.48167911e-02f, 2.66708136e-01f, 9.29571167e-02f, -2.38089506e-02f, 1.18703857e-01f, -1.08633995e-01f, 2.50251889e-01f,
  -8.40871260e-02f, -6.09603487e-02f, -5.96640855e-02f, 3.65730710e-02f, 1.11776963e-02f, -7.64339045e-02f, -3.77157219e-02f, 3.02581117e-02f, -1.05168149e-02f, 2.57024951e-02f,
  -2.37419792e-02f, -1.03212511e-02f, -1.94145497e-02f, 9.35409963e-02f, 9.10724774e-02f, -5.74853197e-02f, 8.52978751e-02f, 9.59422663e-02f, -6.80583045e-02f, 6.87181856e-03f,
  3.37674432e-02f, -1.22288950e-01f, -1.88520610e-01f, -2.08604219e-03f, -9.21835378e-02f, -2.39812061e-02f, -9.39831138e-02f, -2.88646221e-02f, -1.64380580e-01f, 2.20025212e-01f,
  -1.64142027e-02f, 1.39734074e-02f, -1.59859611e-03f, 1.19987736e-02f, 7.48633593e-02f, 1.28256679e-02f, -2.67146714e-02f, 3.34495082e-02f, -4.30880813e-03f, 6.69357255e-02f,
  -4.46944982e-02f, -5.09439856e-02f, 9.78945419e-02f, -7.69096911e-02f, 4.99421321e-02f, -1.06084757e-02f, -2.76648756e-02f, 1.03059998e-02f, -1.11781135e-02f, 9.96377766e-02f,
  8.49360675e-02f, -5.32471798e-02f, 7.53504932e-02f, 6.46731257e-02f, -3.73388045e-02f, -3.74453329e-02f, -1.56670697e-02f, 4.44939174e-02f, -3.58096212e-02f, -2.23468002e-02f,
  2.64638722e-01f, -3.11687380e-01f, -9.51392390e-03f, -1.10562565e-02f, -4.64474270e-03f, 7.83934668e-02f, -3.38351401e-03f, -2.92734569e-03f, 1.34512316e-02f, 4.08208929e-02f,
  -1.89555902e-02f, -2.30458584e-02f, 7.92862382e-03f, 7.82273039e-02f, -1.47038680e-02f, 5.15812337e-02f, 7.89902061e-02f, -4.25572358e-02f, -2.95507889e-02f, 1.84678826e-02f,
  1.97085161e-02f, -2.20995098e-02f, -1.40189216e-01f, -5.91968670e-02f, -1.07769892e-02f, -1.61915258e-01f, -7.59317130e-02f, -2.15139296e-02f, -2.28538230e-01f, -1.86683591e-02f,
  -3.71184975e-01f, 5.07617116e-01f, -9.05014127e-02f, -3.84057648e-02f, -1.25828618e-03f, 1.22658759e-01f, 1.77166998e-01f, 1.69321019e-02f, -1.45489648e-01f, 1.48031741e-01f,
  1.46105841e-01f, -7.69282430e-02f, -4.65574339e-02f, -4.84288596e-02f, -2.69823894e-02f, 8.96977335e-02f, 7.14486018e-02f, -2.73797840e-01f, -3.47349703e-01f, -1.17310494e-01f,
  -5.60268573e-02f, 1.08279437e-02f, -1.08527847e-01f, -3.39050964e-02f, 6.19869940e-02f, -5.81822433e-02f, 1.20589890e-01f, 1.17903806e-01f, 8.70359316e-02f, 1.67913154e-01f,
  -1.16612047e-01f, 1.48770735e-01f, -1.90917909e-01f, -2.70970296e-02f, 3.79965082e-02f, -6.90348372e-02f, -4.31184024e-02f, -4.22415435e-02f, 8.99731740e-02f, -5.01194336e-02f,
  -2.84907594e-02f, -3.38183418e-02f, 4.87322845e-02f, 4.26907688e-02f, -2.18800232e-02f, -2.70243967e-03f, 3.98025252e-02f, -8.12719464e-02f, -8.75543356e-02f, 5.20335287e-02f,
  9.33801457e-02f, 4.63248184e-03f, -1.03188809e-02f, -3.75714223e-03f, 4.98272143e-02f, -1.98759064e-02f, 1.35093600e-01f, 2.49468405e-02f, 2.24674214e-02f, 6.04377352e-02f,
  -4.81101079e-03f, 5.01854047e-02f, -2.40399484e-02f, -9.74360202e-03f, 8.96478072e-03f, -3.01403105e-02f, 5.73255261e-03f, -2.27898802e-03f, 5.60719185e-02f, -6.22156635e-03f,
  3.05610150e-03f, -5.09354398e-02f, -2.32963618e-02f, -5.31740114e-02f, -3.77651528e-02f, 3.57649326e-02f, -5.60404584e-02f, -1.96571276e-03f, 2.67111207e-03f, -5.03954068e-02f,
  -4.02896591e-02f, -6.93710744e-02f, 3.31618898e-02f, -3.27755138e-02f, 2.88011730e-02f, -3.17242034e-02f, 8.58911034e-03f, 7.47430772e-02f, 2.13813744e-02f, -1.55052720e-02f,
  -2.02630594e-01f, -1.34172840e-02f, -1.25762805e-01f, -7.87387714e-02f, 1.88792013e-02f, 8.55223089e-03f, 2.95246840e-02f, 1.88370645e-02f, -6.05133642e-03f, -2.72918958e-02f,
  -1.85726152e-03f, -3.16601880e-02f, 2.10688636e-02f, -2.25109272e-02f, -1.41215369e-01f, -1.00272357e-01f, 9.04353112e-02f, -7.10508078e-02f, -5.15869725e-03f, 4.98565752e-03f,
  7.23183900e-02f, -1.54534906e-01f, -2.93223411e-01f, -6.70002922e-02f, -1.25657395e-01f, -2.13892296e-01f, -1.35325775e-01f, -1.60522118e-01f, -2.24498004e-01f, -1.39732808e-01f,
  3.93488079e-01f, 6.66652340e-04f, -1.11021763e-02f, 1.45856187e-01f, -1.33198380e-01f, -2.42310725e-02f, -1.68668553e-01f, 1.29139915e-01f, 1.09262727e-01f, -1.16809629e-01f,
  3.12644653e-02f, -5.81369847e-02f, 1.90198465e-04f, 7.76278973e-02f, 6.35178611e-02f, -7.49687850e-02f, -4.35025850e-03f, 9.72812623e-03f, 7.52154663e-02f, -1.86885744e-01f,
  -1.20362595e-01f, 7.12849721e-02f, 2.32101157e-01f, 1.26689374e-02f, -1.56230912e-01f, -3.30627412e-02f, 4.89251390e-02f, 8.24313462e-02f, -5.86452074e-02f, -1.70700252e-01f,
  -2.81897008e-01f, 2.41411090e-01f, 1.59167051e-02f, 4.20116484e-02f, -6.64415443e-03f, 5.87730249e-03f, 1.00265965e-02f, 3.56063396e-02f, -6.63146079e-02f, -5.51120974e-02f,
  4.77196202e-02f, 5.18831834e-02f, 8.01547915e-02f, 2.23320629e-02f, -3.63170020e-02f, 2.92990878e-02f, 1.39044389e-01f, 7.66089708e-02f, 1.47732437e-01f, -2.36521265e-03f,
  -4.91073914e-02f, -1.48287381e-03f, 3.06143966e-02f, 2.94373371e-03f, -1.81771107e-02f, 3.18754427e-02f, -5.83911613e-02f, 7.25315064e-02f, 7.84164853e-03f, 1.17783407e-02f,
  1.26288272e-03f, -4.69322409e-03f, -3.51892114e-02f, -1.98578201e-02f, -4.32582609e-02f, 3.06394473e-02f, -1.49218841e-02f, 1.31292210e-04f, -3.07798386e-02f, -2.18072180e-02f,
  8.33189674e-03f, -2.87305359e-02f, 1.33893564e-02f, -3.69869694e-02f, 4.39644605e-03f, 5.10218479e-02f, -4.69424091e-02f, 7.18502328e-03f, 4.88191657e-02f, 7.49703720e-02f,
  4.94205542e-02f, -2.30838917e-02f, -1.60644613e-02f, -3.04073263e-02f, -1.79732032e-03f, 7.85545781e-02f, -1.02160347e-03f, -1.25432424e-02f, -1.27409445e-03f, -2.03731633e-03f,
  -2.84532961e-02f, 1.76771015e-01f, -1.45356923e-01f, -1.04729570e-02f, -3.91849093e-02f, 4.00804766e-02f, 4.16780375e-02f, -1.86049882e-02f, -3.64302285e-02f, -3.30016837e-02f,
  -5.42667694e-02f, -1.26801627e-02f, -4.72916290e-02f, -1.92122832e-02f, -2.82029156e-02f, -4.07076515e-02f, 1.95528176e-02f, 4.11776341e-02f, -4.30342294e-02f, -1.49567043e-02f,
  4.56170589e-02f, 1.12683829e-02f, -6.09187484e-02f, -7.99705163e-02f, 3.92308682e-02f, -5.32294624e-02f, -4.59649712e-02f, -2.49640979e-02f, 2.73197889e-02f, -1.19731583e-01f,
  3.02238204e-02f, 5.54492734e-02f, -3.13550442e-01f, 1.82488322e-01f, 8.37162882e-02f, -2.52169967e-01f, -1.85097322e-01f, -1.96873680e-01f, 1.11258425e-01f, 1.47806585e-01f,
  6.89901263e-02f, 5.79434596e-02f, 4.31560054e-02f, -3.93388793e-02f, -2.69147068e-01f, -1.76430941e-01f, -1.09391045e-02f, -1.50635004e-01f, -1.81341931e-01f, -1.16735287e-01f,
  1.94952905e-01f, 9.50402543e-02f, 5.79026416e-02f, -1.50109241e-02f, 2.54186004e-01f, 4.32444774e-02f, 6.84007704e-02f, 2.39844173e-02f, 6.33486807e-02f, 2.20119312e-01f,
  -1.13219880e-01f, -6.24704175e-02f, -1.91825166e-01f, 1.67680591e-01f, 2.44676955e-02f, -5.79699576e-02f, 1.79070067e-02f, -2.23147739e-02f, 3.51025425e-02f, 3.14405896e-02f,
  1.07810475e-01f, 9.37865153e-02f, -3.70299863e-03f, 8.72496814e-02f, -4.51535434e-02f, 3.47022861e-02f, 3.87078710e-02f, -5.68912365e-02f, -4.88668121e-02f, -9.16066542e-02f,
  1.69479132e-01f, 2.29034871e-02f, -3.83268856e-02f, -9.08408090e-02f, -4.75695357e-02f, 3.43369953e-02f, 4.08737846e-02f, -9.23928991e-02f, -1.91885173e-01f, 7.53826573e-02f,
  -4.91569601e-02f, -6.89722374e-02f, 3.90301598e-03f, -3.46771590e-02f, -2.05506720e-02f, 1.77605543e-02f, 2.10463218e-02f, -6.33722618e-02f, 4.70651966e-03f, -4.70886379e-02f,
  -1.00133419e-02f, -1.17292637e-02f, -1.74331143e-02f, 3.95747423e-02f, 1.39347687e-02f, 4.31424528e-02f, -1.76960544e-03f, 1.30202612e-02f, 4.36825790e-02f, 5.88021651e-02f,
  -3.94042442e-03f, -3.91503563e-03f, -2.50173770e-02f, -1.66575145e-02f, -1.92486551e-02f, 3.31225172e-02f, 4.49521877e-02f, 2.11589932e-02f, 2.81491391e-02f, -1.10563878e-02f,
  2.82697026e-02f, -1.01735301e-01f, 1.60937123e-02f, -5.41840494e-02f, 1.18271038e-01f, 4.58516032e-02f, 4.49706614e-02f, 6.70065805e-02f, -4.74397354e-02f, 1.34492032e-02f,
  -5.86513728e-02f, 1.91105977e-02f, 6.15195968e-05f, -5.96092409e-03f, 8.41362998e-02f, -4.11639027e-02f, 1.26008675e-01f, -6.63592219e-02f, -1.03080295e-01f, 1.01059228e-01f,
  1.22866452e-01f, -4.19575609e-02f, -1.99643582e-01f, -7.31088221e-02f, -5.06029725e-02f, -1.35012239e-01f, -8.74937549e-02f, -6.01169616e-02f, -8.95818770e-02f, 1.01287268e-01f,
  -7.83627212e-01f, -2.11893097e-01f, 6.80044964e-02f, -1.64743841e-01f, 9.96687189e-02f, -1.23018567e-02f, 8.79291538e-03f, -1.27646886e-02f, 2.62873024e-02f, -1.34012243e-02f,
  -1.32883459e-01f, 4.03587520e-02f, 1.41822889e-01f, 3.46758054e-03f, -3.13636027e-02f, 7.57672116e-02f, 1.24168426e-01f, -4.80640307e-02f, 7.89176747e-02f, 2.52893213e-02f,
  1.32025748e-01f, -1.81829426e-02f, -1.87237844e-01f, -2.97794547e-02f, 4.61786985e-02f, 4.20253314e-02f, -3.21451426e-02f, -7.00311437e-02f, -5.55786826e-02f, -9.73544121e-02f,
  4.86871526e-02f, -4.77402002e-01f, 2.07700178e-01f, 1.24497805e-02f, -4.60473895e-02f, -7.44882599e-02f, 2.76357252e-02f, -5.78714684e-02f, 1.26950620e-02f, -8.07738006e-02f,
  -7.01155290e-02f, 8.00794363e-03f, -2.11701840e-02f, 6.64331093e-02f, -7.37868845e-02f, -6.43460602e-02f, 4.82960930e-03f, 2.09508631e-02f, -2.41830125e-02f, -3.95093188e-02f,
  7.75925368e-02f, -1.73940822e-01f, -6.32086992e-02f, 1.14931792e-01f, -1.20285628e-02f, 2.81346384e-02f, 5.11708809e-03f, -6.83893412e-02f, -5.38853072e-02f, -5.90224788e-02f,
  -1.96910016e-02f, 2.34477129e-02f, -2.64188182e-02f, 1.98608190e-02f, 4.00629779e-03f, -8.02207086e-03f, 5.97149916e-02f, -2.60985829e-02f, 4.11668979e-02f, 1.23432614e-02f,
  5.38471155e-02f, -2.74336301e-02f, -2.72979308e-03f, 1.09070679e-03f, 1.11313062e-02f, 1.72632709e-02f, -2.78393216e-02f, 3.66957076e-02f, -4.47595939e-02f, -3.72241661e-02f,
  5.25723286e-02f, -3.65741514e-02f, 2.11464670e-02f, 2.37906408e-02f, 8.33268277e-03f, 3.83638069e-02f, 2.41679642e-02f, -1.82221867e-02f, -4.90369499e-02f, 1.28419967e-02f,
  1.46742523e-01f, 3.66623402e-02f, 7.90246855e-03f, -8.43437016e-02f, -4.07259613e-02f, 2.34035477e-02f, 9.83647443e-03f, 4.67123389e-02f, -2.41129585e-02f, -3.91556434e-02f,
  -1.99408047e-02f, -6.39760345e-02f, -2.35723928e-02f, 6.05642945e-02f, -1.12266615e-02f, 8.07184428e-02f, -5.07844351e-02f, -2.56711300e-02f, 1.78834945e-02f, -3.63064222e-02f,
  8.39505903e-03f, 3.12777348e-02f, -1.32369474e-01f, 1.09552972e-01f, -4.67590336e-03f, -2.99606305e-02f, 1.04330048e-01f, 1.14343822e-01f, 3.21293920e-02f, 1.11271583e-01f,
  1.76185057e-01f, -1.14796564e-01f, 4.30685505e-02f, 2.45066006e-02f, 8.54533166e-02f, 1.50841892e-01f, 2.61438370e-01f, 5.47712184e-02f, -7.79621527e-02f, 2.61270348e-02f,
  -2.22760811e-01f, -4.42197397e-02f, -7.24664610e-03f, 2.51170192e-02f, 1.76931366e-01f, 1.53386384e-01f, 2.67910540e-01f, 1.91699639e-01f, 2.11196005e-01f, 6.06631152e-02f,
  2.11472977e-02f, 6.04059882e-02f, -1.92677844e-02f, 3.51437554e-02f, -1.15584381e-01f, -2.58447528e-02f, -4.57068384e-02f, -2.25855727e-02f, -2.03289185e-02f, -2.05019325e-01f,
  -1.76726595e-01f, -2.57322520e-01f, 1.53584510e-01f, -4.05823179e-02f, -7.51934424e-02f, -6.34327754e-02f, -1.37063779e-03f, -4.61831354e-02f, -3.01053263e-02f, 6.71585202e-02f,
  -1.40084133e-01f, -2.08376050e-02f, -1.98684093e-02f, -3.78003009e-02f, -2.14481093e-02f, -8.81257802e-02f, -9.26951133e-03f, -9.34063923e-03f, 2.20637191e-02f, -2.15471759e-01f,
  -5.23876622e-02f, -1.30116805e-01f, -5.91749884e-02f, -4.66739386e-02f, -4.35963360e-04f, -8.59281700e-03f, -1.53100803e-01f, -5.22759482e-02f, 3.76600809e-02f, -1.04760639e-01f,
  1.49154365e-02f, -4.28346470e-02f, 6.39443938e-03f, 6.22605113e-03f, 5.04385568e-02f, 2.66692340e-02f, 2.65348051e-02f, 4.87098582e-02f, 2.56942213e-02f, 2.05789022e-02f,
  5.78657277e-02f, -3.76628079e-02f, 6.25331253e-02f, 4.40362506e-02f, -4.68646772e-02f, -3.15050147e-02f, 3.67755257e-02f, -1.88481994e-03f, 2.45187804e-02f, -3.40065174e-02f,
  3.71350832e-02f, 1.45064350e-02f, 1.55730462e-02f, -4.05982547e-02f, 2.13743150e-02f, -3.92674915e-02f, 4.85455990e-02f, -5.88485263e-02f, -6.89492971e-02f, -4.02601920e-02f,
  -9.29536596e-02f, 9.99535099e-02f, 9.39095020e-02f, -1.03269620e-02f, -6.54666871e-02f, -7.24150464e-02f, -4.76023741e-02f, 1.46765523e-02f, -5.92005476e-02f, -1.91851016e-02f,
  -7.69974738e-02f, 1.56293306e-02f, 5.47925197e-02f, -3.58477840e-03f, 9.30140838e-02f, 3.90972942e-02f, 5.71163148e-02f, 8.36297870e-02f, -4.00789157e-02f, -1.00403406e-01f,
  1.90955866e-02f, 1.50103211e-01f, 2.08746314e-01f, 1.84017614e-01f, 2.24913494e-03f, 2.18644843e-01f, 1.21895470e-01f, 4.57759723e-02f, 1.20002173e-01f, 2.22457275e-01f,
  -6.09115548e-02f, 4.17436734e-02f, 6.20576506e-03f, 1.88412517e-01f, 3.62457216e-01f, 2.70474464e-01f, 2.67006844e-01f, 4.62628119e-02f, 1.15215130e-01f, 8.92159641e-02f,
  1.70539975e-01f, 8.85764286e-02f, -8.29401836e-02f, -8.54001641e-02f, -1.36152878e-01f, -2.16291677e-02f, 3.02563515e-02f, -1.71045601e-01f, 8.07386357e-03f, 1.54678583e-01f,
  1.69764400e-01f, 1.66181654e-01f, -1.02905340e-01f, -3.30591872e-02f, 1.61621407e-01f, 1.76274791e-01f, 5.74537739e-02f, 1.04473822e-01f, 6.39526322e-02f, 2.26136193e-01f,
  3.99229955e-03f, 6.30933940e-02f, 8.15871637e-03f, -3.72983143e-03f, 2.22950801e-02f, -1.61927760e-01f, -8.73627514e-02f, -1.63293421e-01f, -5.64326474e-04f, -5.73386289e-02f,
  -2.24729646e-02f, -4.77262363e-02f, 1.22146465e-01f, 8.12481344e-02f, 7.37478882e-02f, 2.61816699e-02f, -5.28035220e-03f, -1.57504410e-01f, -5.63238747e-02f, -9.67545137e-02f,
  1.10828668e-01f, 7.86969289e-02f, -4.88842418e-03f, 1.24764759e-02f, -3.23848389e-02f, 9.06141624e-02f, -1.37819629e-02f, -2.83989515e-02f, -1.76645946e-02f, -9.32726711e-02f,
  6.72555044e-02f, -5.42755462e-02f, 2.77552716e-02f, -1.42550806e-03f, 8.01326036e-02f, -5.93737792e-03f, 4.04321589e-03f, -6.67622639e-03f, 4.40072343e-02f, 3.74041311e-03f,
  3.14918300e-03f, 1.12525877e-02f, -2.95148473e-02f, 2.25338675e-02f, 3.97879742e-02f, -4.03062291e-02f, 4.43109199e-02f, -3.44108306e-02f, -5.31606115e-02f, 6.95172548e-02f,
  -9.65780672e-03f, -3.31037231e-02f, -8.63046676e-04f, 4.29133810e-02f, 8.91393200e-02f, -1.19132129e-02f, -1.69427842e-02f, 6.85972050e-02f, 2.50827484e-02f, -3.76627408e-02f,
  -6.64926097e-02f, -2.48392299e-02f, -1.40665611e-02f, -7.87069425e-02f, -6.24900870e-02f, -6.66328445e-02f, 1.27253368e-01f, -8.56102332e-02f, 7.73764728e-03f, 5.33573367e-02f,
  -3.28571200e-02f, -3.01994532e-02f, -6.49551488e-03f, -5.93757704e-02f, 2.73348950e-02f, 8.94172676e-03f, 3.36584710e-02f, 4.00173590e-02f, -7.24554807e-02f, -9.69774127e-02f,
  -9.13317353e-02f, -3.35289277e-02f, -1.33188680e-01f, -1.00570343e-01f, -9.78588685e-02f, -2.03405060e-02f, -6.25663698e-02f, -1.11922570e-01f, -7.47085810e-02f, -9.76116136e-02f,
  1.85173795e-01f, -1.61490262e-01f, 2.78083906e-02f, -1.53428823e-01f, 1.33734718e-01f, 3.49828333e-01f, 3.49063724e-01f, 2.20526129e-01f, 1.26277050e-02f, -1.64065152e-01f,
  -4.24535759e-02f, -3.23694982e-02f, -8.65625516e-02f, 5.47257252e-02f, 2.24086955e-01f, -1.41178519e-01f, -2.39998192e-01f, 6.38841838e-02f, 1.96192443e-01f, 2.87419558e-01f,
  -2.92600524e-02f, -1.10140339e-01f, -6.24472909e-02f, -3.70706953e-02f, -2.58986920e-01f, -2.14760944e-01f, -2.83228368e-01f, -7.01279119e-02f, -8.01796466e-02f, -4.69281077e-01f,
  -5.42445667e-02f, 8.14175159e-02f, 1.12483099e-01f, 1.94291640e-02f, -7.82759413e-02f, -2.04099901e-02f, 1.27794303e-03f, -1.06172450e-01f, -1.40718482e-02f, -8.63583758e-02f,
  -8.90045390e-02f, 6.85409352e-04f, 1.07845599e-02f, -3.63445133e-02f, 2.36384030e-02f, 2.37312093e-02f, 1.60375461e-02f, 1.09003792e-02f, -9.54897050e-03f, 4.39523533e-02f,
  -9.26590189e-02f, -3.94147560e-02f, 1.49346471e-01f, 1.01010486e-01f, 6.03970438e-02f, 2.84835175e-02f, 9.79218408e-02f, -3.67643102e-03f, 1.83138892e-01f, -3.77495065e-02f,
  -2.83828285e-03f, -3.84213962e-02f, 4.68736142e-02f, -5.46304043e-03f, 3.35169549e-04f, -2.20264085e-02f, -1.68029137e-03f, -3.46916579e-02f, 7.90310726e-02f, -5.90345412e-02f,
  4.22642678e-02f, 5.17957211e-02f, 2.84338631e-02f, -6.84606656e-02f, -5.71761727e-02f, -7.66781950e-03f, -3.40684056e-02f, -3.54520120e-02f, -3.54972947e-03f, 1.66746527e-02f,
  7.28908256e-02f, 3.64412181e-02f, -4.93654981e-02f, -3.90373096e-02f, -3.12396064e-02f, 1.23824487e-02f, -1.67930895e-03f, -1.47257540e-02f, -2.92626359e-02f, 9.16457921e-03f,
  -1.22227684e-01f, 2.74034590e-01f, -1.18577570e-01f, 5.15829725e-03f, 2.35783290e-02f, -2.62413789e-02f, -1.00148164e-01f, 6.48202654e-03f, 3.15540582e-02f, 3.21186930e-02f,
  9.75523889e-02f, 3.72152291e-02f, -7.86155388e-02f, -4.30475175e-03f, 1.34698525e-01f, 2.07905564e-02f, -3.08564939e-02f, -7.98172057e-02f, 8.15011859e-02f, -1.87839828e-02f,
  -3.99979837e-02f, 3.64470929e-02f, 1.52723253e-01f, -6.00240156e-02f, 4.41250466e-02f, 1.46874338e-01f, 3.64855602e-02f, 3.65555286e-03f, 2.28644267e-01f, -3.16541344e-02f,
  -2.31415853e-01f, -2.23613858e-01f, -2.06966326e-01f, -1.26514450e-01f, 1.57461479e-01f, 2.42656544e-01f, 2.24425599e-01f, 2.81716436e-01f, 2.77814921e-02f, -6.38297051e-02f,
  2.99236383e-02f, -3.40920617e-03f, -4.90330532e-02f, -6.00210764e-02f, 5.51828817e-02f, -5.64341135e-02f, -2.38475259e-02f, -1.44440919e-01f, 4.93770391e-02f, 2.04777598e-01f,
  2.93404404e-02f, -1.32990137e-01f, -1.22488149e-01f, -1.95464082e-02f, -9.49460641e-02f, -2.43783668e-02f, -2.47675404e-01f, -2.21027091e-01f, -1.57200303e-02f, -3.99283081e-01f,
  -1.87152252e-01f, -5.08139767e-02f, 9.14850906e-02f, 5.77752152e-03f, -1.69794817e-04f, 3.51355702e-04f, 3.20078284e-02f, -1.02197126e-01f, 4.57807332e-02f, 4.56734002e-03f,
  -8.18520859e-02f, 7.56666586e-02f, -4.95617278e-02f, -5.37797920e-02f, 6.54713437e-02f, 1.17333315e-01f, -7.34027475e-02f, -1.69162881e-02f, -2.63559520e-02f, -4.64398153e-02f,
  1.02090987e-03f, 1.99633408e-02f, -2.26041395e-02f, 1.09230116e-01f, 8.81656334e-02f, -7.23208115e-02f, 4.53005508e-02f, 6.28227070e-02f, 8.72826427e-02f, -4.29737046e-02f,
  -2.21328065e-02f, -7.31981695e-02f, -6.73574023e-03f, -6.26168922e-02f, 4.83519584e-02f, -6.85059205e-02f, 5.21350931e-03f, 1.34588191e-02f, 3.46958153e-02f, -2.96518598e-02f,
  8.60644854e-04f, -1.32305128e-02f, -1.17763961e-02f, 3.28788930e-03f, -8.22888017e-02f, -5.86458184e-02f, -5.54311387e-02f, -5.48877101e-03f, 5.63180223e-02f, 2.35366710e-02f,
  1.91722736e-02f, 1.24130389e-02f, 1.49032744e-02f, 4.58686016e-02f, 5.62297888e-02f, -1.11130893e-03f, -6.63321093e-02f, 1.01634577e-01f, -2.85453629e-02f, -3.12338937e-02f,
  5.86613975e-02f, 6.00796714e-02f, -5.70320822e-02f, 7.52094537e-02f, -4.84684370e-02f, -4.00442164e-03f, -2.11230386e-02f, -5.18363267e-02f, -1.29382327e-01f, 2.46571135e-02f,
  9.25810859e-02f, -2.28124782e-02f, -9.65287071e-03f, 8.37143138e-02f, 1.35048464e-01f, 2.92202272e-02f, 5.04080206e-02f, -6.58698753e-02f, 8.45103040e-02f, 5.92446737e-02f,
  5.36260493e-02f, 1.50729790e-01f, 4.90288599e-04f, 1.02057472e-01f, 4.10572514e-02f, -1.41028157e-02f, 4.61851433e-02f, 1.08761676e-01f, 1.16644748e-01f, 1.39677957e-01f,
  2.82063454e-01f, 2.57324368e-01f, 4.30979967e-01f, 6.33795932e-02f, -1.90290540e-01f, -5.44799455e-02f, -8.72939453e-02f, -9.66759026e-02f, -1.43557504e-01f, 1.96105894e-02f,
  2.46800222e-02f, -2.07104787e-01f, 5.84595986e-02f, -1.13324277e-01f, 3.51841152e-02f, 7.57153481e-02f, 1.76855214e-02f, 1.09868854e-01f, 6.43990040e-02f, -1.37960523e-01f,
  -1.52375460e-01f, 6.76558465e-02f, 1.14107125e-01f, 4.88857888e-02f, -1.39760533e-02f, -1.35566190e-01f, 2.20136136e-01f, 3.19044441e-02f, 6.07064813e-02f, 1.51832700e-01f,
  1.73921704e-01f, 3.74072105e-01f, -1.03503183e-01f, -7.92647749e-02f, 4.34067845e-02f, 8.74970946e-03f, -8.90137032e-02f, 8.01968351e-02f, -4.27429713e-02f, 1.27170220e-01f,
  -5.59436455e-02f, -3.85292806e-02f, -1.45135121e-02f, 2.36028582e-02f, 5.95099665e-02f, 3.08745839e-02f, 5.89656308e-02f, 1.86242074e-01f, 5.28609529e-02f, -7.21084699e-02f,
  -1.50940046e-01f, 3.34066115e-02f, 2.80044675e-02f, -2.60581542e-02f, 2.87162531e-02f, -8.69141668e-02f, 1.23423450e-01f, -2.00928245e-02f, 1.50401980e-01f, 1.19686581e-01f,
  -8.61759186e-02f, 5.74589823e-04f, -7.46224746e-02f, 2.38761678e-02f, -1.50087941e-02f, 3.57964188e-02f, 5.57102561e-02f, -6.52765706e-02f, 3.03340098e-03f, -2.68145632e-02f,
  6.38794899e-02f, -9.46237519e-03f, 1.11415377e-02f, 7.58878514e-02f, -8.88080224e-02f, 3.17275636e-02f, -7.61783272e-02f, -4.42593694e-02f, 4.71706763e-02f, -1.90061629e-02f,
  9.07290801e-02f, -6.74817264e-02f, 5.83652221e-02f, -2.10395940e-02f, 1.40709458e-02f, 6.64926693e-02f, -8.56713951e-02f, -7.08151087e-02f, -6.60752952e-02f, -4.17153724e-02f,
  -5.25420085e-02f, 5.76092005e-02f, 1.40684694e-02f, -5.91244549e-02f, -8.65275133e-03f, -2.81382725e-02f, 2.23748572e-02f, 8.57896209e-02f, 3.97660211e-02f, 2.66951118e-02f,
  5.48322760e-02f, 8.45698640e-02f, 8.41525421e-02f, 1.79733634e-02f, 3.25813778e-02f, -5.69327101e-02f, -2.74145626e-04f, -8.70109815e-03f, -2.54318453e-02f, 2.19885074e-03f,
  -3.28203104e-02f, -3.65667953e-03f, -1.09647132e-01f, 5.90228811e-02f, -5.89615991e-03f, -1.44888833e-01f, 6.01036437e-02f, -7.07191974e-02f, -2.91179176e-02f, -6.70095906e-02f,
  5.06561816e-01f, -9.77844968e-02f, -2.83015668e-01f, 2.78970718e-01f, -7.89948702e-02f, -3.01504076e-01f, -2.97066331e-01f, -7.97899291e-02f, 1.31063804e-01f, 2.87989242e-04f,
  -2.61373054e-02f, 9.35468748e-02f, -5.75754941e-02f, -1.59922317e-01f, -2.75723338e-01f, -2.37630472e-01f, -7.46414810e-02f, -1.26760736e-01f, -3.17223817e-01f, -1.17420703e-01f,
  -7.98244551e-02f, 7.21281618e-02f, 2.41929051e-02f, 3.78123187e-02f, 1.11616306e-01f, 9.36420709e-02f, 5.41744381e-02f, 4.91718575e-02f, -9.56029221e-02f, -1.26956888e-02f,
  -1.20021068e-01f, -2.12615896e-02f, -7.64584243e-02f, 1.20002493e-01f, -4.65302356e-02f, 3.96494903e-02f, -1.00460602e-02f, 6.62811697e-02f, 4.80467379e-02f, 3.63014825e-02f,
  2.82442290e-02f, 8.53067357e-03f, -5.78776561e-03f, -6.54109567e-02f, 1.58434622e-02f, -1.19387871e-02f, -2.84604114e-02f, -1.28485024e-01f, -6.43339287e-03f, -5.75020313e-02f,
  -4.18843031e-02f, -8.80512744e-02f, 1.73073560e-02f, -6.08985126e-02f, -6.22975901e-02f, -7.42195025e-02f, -1.34609446e-01f, 2.76636332e-02f, -1.21588968e-01f, 7.90751949e-02f,
  -6.96572065e-02f, 2.00444106e-02f, -5.10449708e-03f, 5.16612083e-02f, 4.29227501e-02f, 1.23793066e-01f, -2.56009027e-02f, 1.27782440e-02f, -4.24368540e-03f, 2.93655172e-02f,
  1.65320877e-02f, -4.41814139e-02f, -3.86006869e-02f, -1.92757398e-02f, 6.92637404e-03f, -7.69118965e-02f, 1.90762561e-02f, -2.39693504e-02f, 1.22349840e-02f, 5.41460849e-02f,
  7.15179145e-02f, -1.54841896e-02f, 7.26728663e-02f, -1.60146237e-03f, -1.38154268e-01f, -3.95420985e-03f, -3.53415534e-02f, 2.50915363e-02f, 5.35140261e-02f, 2.41020508e-02f,
  3.28297615e-01f, -1.35381341e-01f, 1.63068056e-01f, 9.89039708e-03f, 2.13205423e-02f, 7.73312449e-02f, 4.60778922e-02f, 1.86224300e-02f, 1.01076789e-01f, -5.80885187e-02f,
  -6.12414777e-02f, 1.90565027e-02f, 1.28298474e-03f, 3.44636030e-02f, 1.08694872e-02f, -4.36217412e-02f, 8.95453244e-02f, 3.39518040e-02f, -2.95127090e-02f, 7.20396563e-02f,
  5.49125783e-02f, -9.48684104e-03f, 1.84443161e-01f, 8.33109319e-02f, -9.38852280e-02f, 8.49786922e-02f, 4.20135073e-02f, -2.36479156e-02f, -1.47055751e-02f, 2.19807029e-01f,
  -4.95359093e-01f, 6.10418171e-02f, 3.78085583e-01f, -1.75279766e-01f, 1.84141636e-01f, 1.14686035e-01f, 3.19619067e-02f, -1.14556998e-01f, -1.88064560e-01f, 7.18602464e-02f,
  -6.48223758e-02f, -1.12184301e-01f, -2.06379965e-01f, -5.19771315e-02f, -2.54570127e-01f, 1.17389955e-01f, 1.06275767e-01f, -3.81499790e-02f, -1.91363722e-01f, 3.64061594e-02f,
  1.29495356e-02f, 6.34244829e-03f, -2.46763811e-01f, -1.44647673e-01f, 1.34938017e-01f, 1.07085742e-01f, 1.64526582e-01f, 3.73929031e-02f, 8.39502215e-02f, 2.34113917e-01f,
  3.71662349e-01f, -1.41889960e-01f, -6.13851473e-03f, -1.56739086e-01f, 1.38815537e-01f, -7.62155056e-02f, -4.91392426e-03f, 5.58770560e-02f, -6.49303421e-02f, 9.10247862e-03f,
  1.24001622e-01f, -2.15561055e-02f, 7.66437128e-02f, -6.25578267e-03f, -1.48725640e-02f, -2.73418650e-02f, -3.99944559e-02f, -1.23357274e-01f, 1.05695669e-02f, 1.70497689e-02f,
  1.07080340e-01f, 1.44519340e-02f, 4.65275757e-02f, 7.50147877e-03f, 1.71957407e-02f, -3.20999436e-02f, 1.00243874e-01f, -1.80527177e-02f, -2.88140345e-02f, 7.28950426e-02f,
  8.07724614e-03f, 1.68670602e-02f, 4.89874966e-02f, -5.37378900e-02f, 4.03286656e-03f, -2.00657025e-02f, 6.08255863e-02f, -2.57547051e-02f, -3.64145599e-02f, 4.64034192e-02f,
  -9.76705626e-02f, 7.97317997e-02f, 1.59211531e-02f, -6.18024208e-02f, -1.31676327e-02f, -9.74831055e-05f, 1.11884112e-02f, -5.70226312e-02f, -1.93686392e-02f, 7.88757461e-04f,
  -7.32667148e-02f, 1.00392058e-01f, 1.18869580e-02f, 3.02174259e-02f, -2.11721063e-02f, -7.35516548e-02f, 3.52174900e-02f, -5.01370542e-02f, -2.87022162e-02f, 1.08624594e-02f,
  -9.50266570e-02f, -3.80476825e-02f, 7.60856196e-02f, -1.21626578e-01f, 4.23448198e-02f, 3.87683995e-02f, -2.26726830e-02f, 1.42342569e-02f, 1.01979040e-02f, 4.74321470e-02f,
  -4.29090150e-02f, -5.06338142e-02f, -5.51633127e-02f, 6.83731586e-02f, 2.33455002e-02f, 2.12708674e-02f, -4.34565470e-02f, -2.19286699e-02f, 1.76487323e-02f, 8.94727036e-02f,
  -6.63146824e-02f, 1.12876864e-02f, -7.81032667e-02f, -7.36660212e-02f, -4.91166301e-02f, -1.49300203e-01f, 6.40367270e-02f, 7.03377873e-02f, -6.42445758e-02f, -1.56508759e-02f,
  -3.12776774e-01f, -6.93644211e-02f, -3.92714173e-01f, -9.46943089e-02f, -3.40604596e-02f, -2.46965274e-01f, -1.27031624e-01f, -8.89918581e-02f, 1.93663742e-02f, 5.48521290e-04f,
  1.49833128e-01f, 2.43736178e-01f, 2.13271350e-01f, 1.65771142e-01f, 4.11609933e-02f, -1.90646902e-01f, -2.35975355e-01f, -1.90414712e-01f, -1.01144388e-01f, 1.07520558e-01f,
  1.02971166e-01f, -6.36757165e-02f, -7.88562745e-02f, -2.28781570e-02f, 4.53541614e-03f, 1.30771310e-03f, -1.27031684e-01f, -1.22870922e-01f, 5.38107939e-02f, -1.58735245e-01f,
  -1.21814162e-01f, -2.36328304e-01f, 7.30868876e-02f, 7.92672262e-02f, -2.88910121e-02f, -8.02003518e-02f, 2.65511568e-03f, -5.80849834e-02f, -2.99876016e-02f, -1.91140305e-02f,
  -2.49695648e-02f, 1.06881753e-01f, 6.63752928e-02f, 4.72965278e-02f, -2.70410385e-02f, -5.68361692e-02f, 9.42856595e-02f, -7.04675466e-02f, 1.23148533e-02f, 5.51630817e-02f,
  3.94177325e-02f, 3.68598141e-02f, -1.65428102e-01f, -1.23389550e-01f, -1.40622035e-01f, 3.20995110e-03f, -2.66221724e-02f, -2.05364488e-02f, -9.69786346e-02f, -2.14644387e-01f,
  4.39889841e-02f, -5.29307500e-02f, 5.22557013e-02f, -1.38928890e-02f, 1.06030358e-02f, 2.94679292e-02f, -7.07478598e-02f, -2.71561556e-02f, -8.94859619e-03f, -1.01881392e-01f,
  3.70311663e-02f, -2.76750680e-02f, -4.83836159e-02f, 5.67524321e-03f, 5.68353347e-02f, -4.16918881e-02f, 3.76430638e-02f, 4.65281261e-03f, 2.92530749e-02f, 3.17656696e-02f,
  -3.92947271e-02f, -4.20548990e-02f, -3.20212990e-02f, 6.88266382e-02f, -5.10804132e-02f, -4.64663953e-02f, 1.64480612e-03f, -8.71580280e-03f, -3.61570641e-02f, -3.48882750e-02f,
  2.22460963e-02f, 5.00782691e-02f, -8.93300027e-02f, 2.89830677e-02f, -8.50099400e-02f, 4.71433066e-02f, -6.12832233e-02f, 1.42598674e-02f, -2.05182973e-02f, -1.52390704e-01f,
  1.29529170e-03f, -2.48053782e-02f, -5.33246025e-02f, -1.66410524e-02f, -2.57324502e-02f, -8.82391930e-02f, 1.89413074e-02f, 1.33669032e-02f, 5.37903830e-02f, -2.35986486e-02f,
  6.70362860e-02f, -6.54165894e-02f, -8.85146633e-02f, -7.90527761e-02f, -8.08602348e-02f, 5.17006498e-03f, -1.88639879e-01f, -3.21528763e-02f, -9.73245427e-02f, -1.02412701e-01f,
  3.10083926e-02f, -2.02461213e-01f, -1.84773311e-01f, -1.33794278e-01f, 9.02535841e-02f, 9.72881988e-02f, -1.69528164e-02f, 8.64215121e-02f, 1.27173606e-02f, -1.18350901e-01f,
  5.53981997e-02f, 2.41146117e-01f, 9.94479433e-02f, 1.24831162e-02f, 3.02576981e-02f, -1.49735495e-01f, -1.35687470e-01f, -5.28677069e-02f, 1.69146106e-01f, 1.43309295e-01f,
  6.65441081e-02f, -3.44411731e-02f, -1.07999869e-01f, 2.55685877e-02f, -1.92063555e-01f, 5.18642087e-03f, -7.79513866e-02f, -2.07122356e-01f, -7.75084421e-02f, -4.33925152e-01f,
  -1.12053134e-01f, -1.75606340e-01f, 1.43078089e-01f, 1.24792010e-02f, -2.98938341e-02f, 2.82924417e-02f, 6.85183406e-02f, -1.58126019e-02f, 3.19192410e-02f, -8.52788389e-02f,
  -5.42288274e-03f, 4.80486043e-02f, -1.18561029e-01f, -6.71744421e-02f, -2.31238338e-03f, -7.05814064e-02f, -7.61222020e-02f, -1.87621415e-01f, 2.40248144e-02f, -3.98524739e-02f,
  -1.01734005e-01f, -2.53136344e-02f, 3.70873399e-02f, 4.37890328e-02f, 8.46192148e-03f, 7.56881982e-02f, -1.17738359e-01f, -2.06923410e-02f, -3.84991430e-02f, -1.35401487e-01f,
  -2.47057714e-02f, 4.88539524e-02f, 1.85285099e-02f, -6.27069697e-02f, 2.13965699e-02f, 3.58793116e-03f, -1.84342135e-02f, -3.27128768e-02f, 1.62730999e-02f, -5.93755580e-02f,
  -3.06897033e-02f, -2.45725941e-02f, -4.26724553e-02f, -3.62135731e-02f, -1.26028359e-02f, -3.11757531e-02f, 6.08027615e-02f, -3.63494530e-02f, 5.97111695e-02f, -3.87286283e-02f,
  -5.06381132e-02f, 5.22006340e-02f, -7.31843039e-02f, -7.50743002e-02f, -9.73535031e-02f, -2.57871151e-02f, 1.61396340e-02f, 3.82225439e-02f, -3.50455381e-02f, 3.91537398e-02f,
  2.92416781e-01f, 1.35842770e-01f, 3.97269288e-03f, 7.95624703e-02f, 2.34372821e-02f, -6.66827485e-02f, 1.63971949e-02f, -1.77262239e-02f, 1.74102876e-02f, 1.17168419e-01f,
  4.94109429e-02f, -3.20686772e-02f, 7.47161135e-02f, -5.18163433e-03f, 4.96853739e-02f, 9.90813747e-02f, 5.45484498e-02f, 2.35974845e-02f, -4.61756019e-03f, 3.91939618e-02f,
  -7.06166700e-02f, 1.64286837e-01f, 2.06164896e-01f, 6.88509196e-02f, 8.23498666e-02f, 2.97872335e-01f, 1.65079162e-01f, 1.66619286e-01f, 2.11030215e-01f, 1.75295502e-01f,
  8.88058543e-02f, -7.59582520e-02f, -2.63009280e-01f, -2.21041664e-01f, 2.62340927e-03f, 2.09071875e-01f, 1.71866193e-01f, 4.59893644e-02f, -1.99206956e-02f, -2.41259467e-02f,
  1.07732743e-01f, 1.40993267e-01f, -1.16335444e-01f, -1.28182128e-01f, -1.06810955e-02f, -2.45142683e-01f, -3.31006944e-01f, -1.53263018e-01f, -5.14409617e-02f, 4.49623130e-02f,
  5.14965169e-02f, -1.82845607e-01f, -1.79083928e-01f, -1.69739559e-01f, -1.82366088e-01f, 1.55747021e-02f, -1.96824506e-01f, -1.16888300e-01f, -6.04275428e-02f, -3.40155810e-01f,
  -2.34547883e-01f, 1.05896920e-01f, 1.24063650e-02f, 7.37744495e-02f, 2.26778667e-02f, -5.70945852e-02f, 7.56674558e-02f, -2.74912943e-03f, 8.42942372e-02f, -4.10021991e-02f,
  9.45072621e-02f, -2.23581046e-02f, -2.46744193e-02f, 5.41575141e-02f, 2.92769689e-02f, 7.08212107e-02f, -8.44292119e-02f, -2.99916267e-02f, -6.09433325e-03f, 4.29258123e-02f,
  -2.40698159e-02f, 7.33216926e-02f, 1.49516985e-01f, 4.67849411e-02f, 8.03612247e-02f, -5.01699932e-03f, 9.34596434e-02f, 4.78170849e-02f, 1.04496099e-01f, -4.70663197e-02f,
  -2.48846579e-02f, -3.72274704e-02f, 5.64205870e-02f, 4.96796891e-02f, 2.44982969e-02f, 4.60864268e-02f, -3.20219509e-02f, -3.40059196e-04f, -4.16318700e-03f, -1.35760214e-02f,
  1.51623785e-02f, -3.83495316e-02f, -5.23954211e-03f, -1.01779647e-01f, -6.13063350e-02f, 5.05811768e-03f, 8.80854577e-02f, -6.14215210e-02f, 4.09804843e-02f, -1.47763109e-02f,
  5.21573946e-02f, 4.68920730e-02f, -2.23280564e-02f, 2.03973707e-02f, 1.49858082e-02f, -2.33650412e-02f, -5.81375137e-02f, 1.44313704e-02f, 5.11338972e-02f, 2.26954855e-02f,
  -7.68837109e-02f, 1.44085586e-01f, -1.05871215e-01f, -1.43007785e-02f, -4.78344299e-02f, 5.79039566e-02f, 1.89478248e-02f, 1.82142644e-03f, 9.92730632e-02f, 5.74935088e-03f,
  3.95218618e-02f, -1.93766151e-02f, -4.77934740e-02f, 1.21477405e-02f, -4.09116074e-02f, 2.93095093e-02f, 4.04378027e-02f, -2.45489310e-02f, -1.17106382e-02f, -2.08882783e-02f,
  -4.76014540e-02f, 1.03120944e-02f, -9.14921425e-03f, -7.03659188e-03f, -3.27114724e-02f, -2.58273780e-02f, -7.46271089e-02f, 6.96135014e-02f, 8.92507657e-03f, -1.87726468e-01f,
  1.57850847e-01f, 4.11851369e-02f, -2.15821087e-01f, 1.13140792e-01f, 4.56632003e-02f, -4.95329872e-02f, -7.32842013e-02f, 5.59013430e-03f, 6.26548454e-02f, 2.40577711e-03f,
  2.07407221e-01f, 3.94406244e-02f, -2.79996004e-02f, -8.13612193e-02f, -1.07361674e-01f, -1.56743154e-01f, -1.90723345e-01f, -2.60330945e-01f, -2.63356585e-02f, -1.42447762e-02f,
  6.79096133e-02f, 9.00845509e-03f, -5.08427527e-03f, 2.34257746e-02f, 1.49718031e-01f, 6.62125871e-02f, -1.89108066e-02f, 3.15111950e-02f, -3.88178304e-02f, 1.04774989e-01f,
  3.85117620e-01f, 8.27820227e-02f, -1.64025143e-01f, 6.17808523e-03f, 9.84937139e-03f, -6.83171973e-02f, 9.39368329e-04f, -1.01243220e-01f, -8.17918405e-02f, -7.56150484e-02f,
  2.32318267e-02f, 1.22654699e-02f, 9.42154154e-02f, 3.09472089e-03f, 9.79963765e-02f, 6.60329536e-02f, -1.01655684e-01f, -1.24522500e-01f, -1.71021581e-01f, 3.63747887e-02f,
  1.02510050e-01f, 3.05952597e-02f, 4.10938868e-03f, -1.33467972e-01f, -7.39503205e-02f, -1.29118422e-02f, 3.27408426e-02f, -5.25836982e-02f, -6.04800768e-02f, 9.37056728e-03f,
  -1.51544064e-03f, -1.89832132e-02f, 5.92216775e-02f, -1.47670042e-02f, -5.32063432e-02f, -7.54400790e-02f, 5.00030480e-02f, 1.04090378e-01f, -2.48418581e-02f, 7.07573891e-02f,
  1.48477703e-02f, -1.04490735e-01f, 4.18866016e-02f, 7.92009383e-02f, -3.22111659e-02f, 5.22768013e-02f, -3.36130112e-02f, -6.15221038e-02f, -6.71137648e-04f, -6.18027635e-02f,
  4.66932431e-02f, 2.18132068e-03f, 4.19613943e-02f, -3.05822566e-02f, 2.02787761e-03f, -9.33731571e-02f, -1.27662411e-02f, 1.63195077e-02f, -4.91264043e-04f, 2.64527984e-02f,
  3.56885493e-02f, -2.99722821e-01f, 1.31037459e-01f, -5.69779612e-02f, 1.01920299e-01f, -7.39643574e-02f, 9.68660489e-02f, -3.30799408e-02f, 9.66690406e-02f, 2.01043524e-02f,
  1.28894210e-01f, 3.84098291e-02f, 6.45018518e-02f, 4.87350002e-02f, -2.74678785e-02f, 6.05402626e-02f, 7.41333142e-02f, -7.28251934e-02f, -2.84547228e-02f, -3.25948070e-03f,
  -3.23187746e-02f, 1.66222022e-03f, -4.02168669e-02f, -9.53937918e-02f, 1.16109841e-01f, 6.84267730e-02f, -4.43978282e-03f, 3.04820668e-02f, -5.54530732e-02f, -1.21104278e-01f,
  -2.39898160e-01f, 3.70682627e-02f, 2.66539723e-01f, -1.23405885e-02f, -2.62572686e-03f, -1.33346349e-01f, -1.63279176e-01f, -1.97846144e-01f, -1.19997405e-01f, -6.53958544e-02f,
  5.44259623e-02f, 1.37556940e-01f, 1.59556672e-01f, 9.69276950e-03f, -8.07510316e-02f, -3.45325246e-02f, -1.61585622e-02f, -9.64091942e-02f, -1.27626941e-01f, -1.23490579e-01f,
  -2.09391519e-01f, -8.58298913e-02f, -6.24585897e-02f, -9.59430784e-02f, 8.33016932e-02f, 7.37002632e-03f, 1.47571072e-01f, 1.21850133e-01f, 2.79888567e-02f, -3.46524566e-02f,
  2.31115744e-01f, 1.50591731e-01f, -1.12883233e-01f, 7.80729717e-03f, 2.10378766e-01f, -8.40926319e-02f, -2.76362579e-02f, 1.00488931e-01f, 4.44803722e-02f, -6.59633949e-02f,
  4.10829559e-02f, -3.74507681e-02f, 7.71922916e-02f, -4.49904986e-02f, -5.27701527e-02f, -9.17786583e-02f, -4.68850881e-02f, -5.25237322e-02f, 1.17720410e-01f, -3.34435888e-02f,
  6.07073605e-02f, 9.09871161e-02f, 2.03906387e-01f, 1.54331047e-02f, 1.63090210e-02f, 5.10949381e-02f, 5.35853356e-02f, 2.28886753e-02f, 1.78194508e-01f, -2.04217397e-02f,
  -1.22879036e-01f, 5.48233166e-02f, 5.88887446e-02f, -8.78541917e-02f, 1.99659402e-03f, -2.14029774e-02f, 8.18401948e-02f, -8.25260803e-02f, -1.77962463e-02f, -5.50153740e-02f,
  9.64839682e-02f, -3.07005756e-02f, -3.51138460e-03f, 1.44905935e-03f, -1.04167657e-02f, 3.33003737e-02f, 1.60833187e-02f, -3.50218117e-02f, 6.55692816e-02f, 6.52473196e-02f,
  -3.30523439e-02f, -1.75228901e-02f, 7.14713931e-02f, 2.19703410e-02f, 2.78322026e-02f, -4.59423428e-03f, -1.14439912e-02f, -3.53761278e-02f, 3.79990228e-02f, 2.14993525e-02f,
  5.82697988e-03f, 1.94641799e-01f, -9.53184161e-03f, -8.48676115e-02f, 5.40243201e-02f, -2.24865787e-02f, 5.02867922e-02f, 1.28955860e-02f, 1.42356530e-01f, -8.45383182e-02f,
  -7.65824039e-03f, -8.78018290e-02f, 1.08754806e-01f, -1.74221452e-02f, -1.93196572e-02f, -1.13595486e-01f, -4.77402918e-02f, -4.08436619e-02f, -4.69093882e-02f, -3.82640176e-02f,
  -7.82444403e-02f, -2.30687693e-01f, -1.48690730e-01f, 1.57756353e-04f, -4.63632010e-02f, -3.55117768e-02f, 7.76796937e-02f, -7.42286146e-02f, -7.73373768e-02f, -2.24475190e-01f,
  -1.18834920e-01f, 3.87041956e-01f, 1.20347731e-01f, 1.33643359e-01f, 1.41160712e-01f, 1.22245461e-01f, 3.65576923e-01f, 8.35605487e-02f, 1.66078676e-02f, 2.03993767e-01f,
  -1.11669920e-01f, -1.48359418e-01f, -1.43664554e-01f, -7.46510550e-02f, -1.27340853e-01f, 2.98340559e-01f, 2.69035429e-01f, -1.61424592e-01f, -2.62925029e-01f, -1.03458978e-01f,
  -5.33167981e-02f, 5.94609827e-02f, -2.41932526e-01f, -8.84961113e-02f, 2.04582602e-01f, 9.89343133e-03f, 9.49098170e-02f, -2.09579952e-02f, 1.37422994e-01f, 3.14633906e-01f,
  1.72716528e-01f, 9.33151022e-02f, -1.27534822e-01f, -1.97608825e-02f, 1.21379839e-02f, -2.78413575e-02f, 5.38034327e-02f, -6.90762177e-02f, -5.13157696e-02f, 6.93702772e-02f,
  -4.16187681e-02f, -5.81980869e-02f, -1.18307099e-02f, 4.15029153e-02f, 9.14652180e-03f, 3.55790704e-02f, 2.33430695e-03f, -5.99362096e-03f, 1.00039179e-02f, 1.23743741e-02f,
  -3.27795446e-02f, 7.28568900e-03f, -2.24365275e-02f, 1.12364992e-01f, 2.65085865e-02f, -4.92965318e-02f, 7.80932084e-02f, 1.26832724e-01f, 5.65661117e-02f, 2.08807632e-01f,
  1.77548937e-02f, -3.27956006e-02f, -2.35062297e-02f, 2.50667464e-02f, 4.99440869e-03f, 6.22221455e-03f, 1.58744063e-02f, 2.79360488e-02f, -1.37158521e-02f, -1.82610727e-03f,
  -5.89066446e-02f, 8.78414721e-04f, -1.09610595e-02f, -2.96434350e-02f, -1.50774373e-02f, 4.18585390e-02f, 2.74872016e-02f, 1.39587298e-02f, -3.25173475e-02f, -6.77161589e-02f,
  -3.03769466e-02f, -2.25964542e-02f, -2.66703591e-02f, 2.99959388e-02f, -7.29431957e-02f, 7.21507892e-02f, -2.13116407e-02f, -4.14949581e-02f, -3.21159139e-02f, 2.14025173e-02f,
  1.02488883e-01f, -3.29527944e-01f, 1.21862218e-01f, 4.93138582e-02f, -1.65440105e-02f, -1.89732704e-02f, 6.69070333e-02f, 2.61753481e-02f, -3.21735963e-02f, 6.47803172e-02f,
  -2.47396305e-02f, 2.75541563e-02f, 6.83043748e-02f, -1.09752975e-02f, 1.81276798e-02f, -3.52422632e-02f, 9.21270400e-02f, -2.74184849e-02f, -5.02945185e-02f, 8.04910213e-02f,
  9.05195922e-02f, 5.06010279e-02f, 6.65821508e-02f, 5.24783209e-02f, 2.97406688e-02f, -8.33451375e-02f, 1.58650503e-01f, 1.56883478e-01f, 4.65919301e-02f, 2.51315802e-01f,
  -2.70118475e-01f, -2.65218705e-01f, -1.08372504e-02f, 1.28511712e-01f, 1.41802818e-01f, 4.19502109e-02f, 2.09798776e-02f, 2.69039795e-02f, 2.12793406e-02f, -1.19085819e-01f,
  -2.46404648e-01f, -1.17759660e-01f, -8.53864998e-02f, -1.08305357e-01f, -4.95844781e-02f, -4.85319383e-02f, 1.18365571e-01f, 1.03274502e-01f, 1.18931063e-01f, 2.07017809e-01f,
  6.60351738e-02f, 2.06708163e-01f, 1.28347859e-01f, 1.59149364e-01f, 1.06391750e-01f, -4.03214619e-02f, -9.64702666e-02f, 2.89889295e-02f, -8.61727819e-03f, -5.66073060e-02f,
  -4.53703940e-01f, -9.30319428e-02f, 9.32215303e-02f, 1.60424896e-02f, -1.84667856e-02f, -9.20730457e-02f, -6.63742721e-02f, -2.72686649e-02f, -7.04599321e-02f, 4.11884896e-02f,
  -3.37280817e-02f, 3.02901138e-02f, 2.87607387e-02f, 5.09913191e-02f, -2.69221440e-02f, -9.60342865e-03f, 7.38706887e-02f, 7.85109624e-02f, 2.57989648e-03f, -4.45535518e-02f,
  1.12027921e-01f, 7.51839131e-02f, 7.98375532e-03f, 1.25544996e-03f, 7.03549758e-02f, 3.67603190e-02f, 1.34506552e-02f, -2.81991791e-02f, -3.97333018e-02f, -1.16992339e-01f,
  -1.93068590e-02f, -2.85794158e-02f, 2.54305210e-02f, 2.43405197e-02f, -3.71723832e-03f, -7.65959593e-03f, -3.38007743e-03f, 8.99113901e-03f, 2.84167118e-02f, 4.79609072e-02f,
  8.44572019e-03f, -2.25016866e-02f, -2.08786000e-02f, -3.43708470e-02f, -5.82613945e-02f, 2.35582590e-02f, 1.77496243e-02f, -1.20306322e-02f, -1.19891474e-02f, -6.02768082e-03f,
  -1.12489983e-02f, 3.43840756e-02f, 1.21501097e-02f, -3.54840886e-03f, 5.65198772e-02f, 5.56475716e-04f, -3.80326882e-02f, 3.57286036e-02f, -2.08573937e-02f, 1.34994034e-02f,
  -2.94709712e-01f, 1.37801185e-01f, -1.15007415e-01f, 7.00893849e-02f, 2.25857496e-02f, 1.72882602e-02f, -3.47900367e-03f, 4.00676057e-02f, 5.34401089e-02f, 1.55171787e-03f,
  5.83441928e-02f, -2.27259938e-02f, -4.67198975e-02f, 6.11225106e-02f, 6.62819156e-03f, 1.30059319e-02f, 1.63609330e-02f, -5.79020791e-02f, 7.50407055e-02f, -1.53064504e-02f,
  3.75154950e-02f, -6.28993735e-02f, -1.20093539e-01f, -8.92019123e-02f, 2.26985123e-02f, -1.29932255e-01f, -1.65784240e-01f, -1.49270315e-02f, -1.38130561e-01f, -2.34932482e-01f,
  -3.45805854e-01f, 1.61381885e-01f, 9.29748698e-04f, -1.11079134e-01f, 9.67959687e-02f, 1.06481552e-01f, 2.22056136e-01f, 9.01325643e-02f, -2.53314581e-02f, 1.16303168e-01f,
  3.82687330e-01f, 9.77552310e-02f, 9.45779309e-02f, 4.76059457e-03f, -5.56604005e-02f, -1.11013137e-01f, -2.06886843e-01f, -3.12887073e-01f, -2.06642628e-01f, -5.37388660e-02f,
  1.10267964e-03f, -1.73851684e-01f, -2.17466459e-01f, -1.13049977e-01f, -2.34039918e-01f, -4.88403812e-02f, -1.95448175e-01f, -1.40647963e-01f, -1.06054358e-01f, -3.84470940e-01f,
  1.12452149e-01f, 4.23910506e-02f, 2.74203531e-02f, 5.39470315e-02f, 1.12697162e-01f, -7.96529055e-02f, 2.49625500e-02f, -1.02888167e-01f, 5.98485358e-02f, 3.77347507e-02f,
  9.71316099e-02f, 5.46127893e-02f, 1.16739618e-02f, -1.22635381e-03f, 2.36427528e-03f, -6.53895549e-03f, 3.85708399e-02f, -1.20706588e-01f, 6.97419513e-03f, 5.87310642e-02f,
  5.67147061e-02f, -1.35570485e-03f, -4.21507210e-02f, 6.64894059e-02f, -2.75908988e-02f, -1.09374113e-01f, -1.91516876e-02f, -1.33802369e-01f, -1.81235105e-01f, -2.27790192e-01f,
  2.43219342e-02f, -4.21699360e-02f, -2.25535650e-02f, 2.94763409e-02f, 5.77639462e-03f, -1.29871769e-03f, -4.04127911e-02f, 1.89128350e-02f, 1.24503318e-02f, 2.26621665e-02f,
  6.44362997e-03f, 2.56087892e-02f, 8.31915298e-04f, -2.21319366e-02f, -3.99601087e-02f, -4.17541489e-02f, -9.17522907e-02f, 2.08695214e-02f, 2.25637741e-02f, -2.54447218e-02f,
  2.73273280e-03f, -8.18099082e-03f, -1.95414796e-02f, -6.59726793e-03f, -8.49073827e-02f, -1.79158244e-02f, 1.91244632e-02f, 4.19944860e-02f, 7.79976025e-02f, 8.94426629e-02f,
  5.25474660e-02f, 2.28516966e-01f, -3.28421034e-02f, -7.61331394e-02f, -5.73233999e-02f, 6.16212189e-02f, 1.16207384e-01f, 6.53804988e-02f, 6.48547038e-02f, 1.33034689e-02f,
  1.02077156e-01f, -8.09744895e-02f, 1.08945146e-01f, 7.76780620e-02f, 3.93800177e-02f, 4.80970107e-02f, 8.67152179e-04f, -4.70176451e-02f, -2.57634465e-02f, 4.85310741e-02f,
  6.98221326e-02f, -3.34850177e-02f, -4.67790253e-02f, 7.76660144e-02f, -8.24142173e-02f, -1.16465166e-01f, 2.06512008e-02f, -1.17749996e-01f, -8.22758302e-02f, -5.81436902e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.64305720e-02f, 3.24566782e-01f, 1.89272370e-02f, 2.28579238e-01f, 2.06262425e-01f, 2.65089005e-01f, 4.44952339e-01f, 3.38048577e-01f, 1.73995793e-01f, 1.13478914e-01f,
  2.81031467e-02f, 2.90527251e-02f, 1.74194619e-01f, 2.37484742e-02f, 2.03067645e-01f, 2.07583159e-01f, 1.37790889e-01f, -7.08602816e-02f, 1.68608632e-02f, 6.22925274e-02f,
  1.41787469e-01f, -7.20505253e-04f, -1.40764952e-01f, 1.04706697e-01f, 1.23231061e-01f, 1.10572904e-01f, 2.21992005e-02f, 7.48991407e-03f, 9.44779366e-02f, 4.54071388e-02f,
  -1.92159906e-01f, 7.08469972e-02f, -4.53084446e-02f, -1.31375507e-01f, -1.33209005e-01f, -9.62659642e-02f, 4.73226458e-02f, -1.55795902e-01f, -1.59490611e-02f, -6.60071597e-02f,
  9.25744697e-03f, 2.97608189e-02f, 2.62494087e-02f, -6.75381795e-02f, -4.06720638e-02f, -6.48887902e-02f, -1.01548471e-01f, 9.05310363e-02f, 6.37249127e-02f, 1.14420950e-02f,
  1.70311169e-03f, -3.39488313e-02f, 8.11716318e-02f, 1.38746426e-02f, 1.10566698e-01f, -6.28764257e-02f, -4.94909063e-02f, 4.22555171e-02f, -3.44683304e-02f, 7.39408880e-02f,
  1.49288569e-02f, 6.85714111e-02f, 6.63881600e-02f, -1.34850238e-02f, 7.53244432e-03f, 5.52553087e-02f, -1.96617469e-02f, 6.75439136e-03f, 3.73129845e-02f, 1.92122199e-02f,
  6.51563331e-03f, -2.31750514e-02f, 7.26151988e-02f, -4.55449559e-02f, -4.08669412e-02f, -4.00984958e-02f, -7.36791641e-02f, 7.60589987e-02f, -1.57177541e-02f, 8.46816227e-03f,
  -4.89530899e-02f, 5.89902289e-02f, -1.01447120e-01f, 5.71119674e-02f, -5.40454499e-02f, 2.07521264e-02f, -5.42028844e-02f, -9.67007205e-02f, -2.78407540e-02f, -4.58333232e-02f,
  -3.39402519e-02f, -7.29082152e-03f, -4.37711999e-02f, 7.77982846e-02f, 1.05919056e-02f, 1.31150393e-03f, 8.89410675e-02f, -1.15701236e-01f, -1.21468201e-01f, -1.83285736e-02f,
  -1.97675824e-02f, -2.88782883e-02f, -3.11068352e-02f, 3.04983705e-02f, -9.96935517e-02f, -7.42264390e-02f, -8.36391449e-02f, 1.11616954e-01f, -2.85648033e-02f, 3.91050540e-02f,
  3.49052297e-03f, -9.38061103e-02f, 3.58829498e-02f, -2.12142728e-02f, -6.05022162e-03f, -1.01588205e-01f, -3.12751792e-02f, -1.74287912e-02f, -8.82849284e-03f, -1.11364676e-02f,
  1.30322278e-01f, 1.14052698e-01f, -2.19360739e-01f, 4.49890718e-02f, -1.08542137e-01f, -2.39938438e-01f, -1.41328886e-01f, 8.92504826e-02f, 1.65454820e-01f, 3.67404940e-03f,
  6.70017302e-02f, 2.84765055e-03f, -1.82836309e-01f, -1.69885337e-01f, -1.46632135e-01f, -9.36569870e-02f, -1.95192829e-01f, -3.83221656e-01f, -3.20614010e-01f, -1.65500388e-01f,
  -9.75840315e-02f, -1.77177161e-01f, -6.43563047e-02f, -3.87135297e-02f, 6.92058429e-02f, -4.66527194e-02f, 2.54247878e-02f, -9.08073187e-02f, -2.20043987e-01f, -2.26820353e-02f,
  -4.84421812e-02f, -8.96522179e-02f, -3.62427309e-02f, -2.29616314e-02f, -2.28087846e-02f, 1.66653097e-02f, 1.93542168e-02f, -7.11591467e-02f, -5.51906005e-02f, 5.27351052e-02f,
  -9.54370871e-02f, -8.81016478e-02f, -1.07452728e-01f, -3.67587507e-02f, -9.08993632e-02f, -6.78320229e-02f, 2.87221782e-02f, -9.49445292e-02f, -1.33572211e-02f, -6.24960698e-02f,
  -7.85551369e-02f, -1.83896050e-01f, -1.58723250e-01f, -2.78962627e-02f, -6.38841391e-02f, -1.08249024e-01f, 6.62422851e-02f, 5.73572926e-02f, 1.86234731e-02f, 2.38078624e-01f,
  3.95936705e-02f, -8.33615102e-03f, 3.17658251e-03f, -1.36016104e-02f, 8.85634422e-02f, -2.33102706e-03f, -1.76995918e-02f, -3.58657911e-02f, 7.47922584e-02f, 6.09013662e-02f,
  5.13041727e-02f, 8.74298587e-02f, 3.17000342e-03f, 6.05975837e-02f, -5.04176542e-02f, -5.20605557e-02f, 4.48764637e-02f, -2.45025381e-02f, 1.36936465e-02f, -6.23300225e-02f,
  -1.49622385e-03f, 3.11488826e-02f, 6.86899126e-02f, 2.17158552e-02f, 3.93902659e-02f, 2.55394038e-02f, -7.76420161e-02f, -9.22259614e-02f, -1.98187865e-02f, -6.44902885e-02f,
  3.00748765e-01f, -2.01622322e-01f, 2.19122451e-02f, -3.88609022e-02f, 4.57204282e-02f, -4.13251668e-02f, 1.06548043e-02f, 1.84453069e-03f, 6.86104372e-02f, -9.64559019e-02f,
  3.94791178e-03f, 4.66859601e-02f, 3.06424703e-02f, -2.16600904e-03f, -6.95708543e-02f, 3.48602165e-03f, -6.57347497e-03f, 3.46859880e-02f, -1.39218807e-01f, 6.41706437e-02f,
  1.43499330e-01f, -2.33597830e-02f, 2.07848232e-02f, 9.29437857e-03f, 4.39569689e-02f, 5.96381444e-03f, -4.39986289e-02f, -4.32771146e-02f, 9.88019910e-03f, 2.58192003e-01f,
  4.85908806e-01f, 1.74694538e-01f, 2.07348540e-01f, 1.31033555e-01f, -6.14405517e-03f, -6.53040484e-02f, 6.95728436e-02f, -3.41477841e-02f, 6.41681999e-02f, 9.83265862e-02f,
  -2.95842979e-02f, -9.01728794e-02f, -3.83953676e-02f, -1.13013692e-01f, 1.99776590e-02f, -1.89072303e-02f, 4.59514782e-02f, 1.31540513e-02f, 1.27573414e-02f, 7.00758547e-02f,
  -1.21449038e-01f, -4.35812250e-02f, 1.61293536e-01f, 1.26890004e-01f, 6.05129898e-02f, -9.75377392e-03f, 8.97237957e-02f, 4.79747541e-02f, 3.15633230e-02f, 4.99037355e-02f,
  2.16658786e-01f, 2.90284783e-01f, -2.64974385e-01f, -5.83784096e-02f, -1.18603017e-02f, 9.64307636e-02f, -5.10969013e-02f, 9.22692120e-02f, 2.79851016e-02f, 1.53123336e-02f,
  9.26120114e-03f, 7.80770704e-02f, -2.30436958e-02f, 2.17478778e-02f, 7.49595910e-02f, 1.17161404e-02f, 1.60085142e-01f, 4.74667884e-02f, 8.70552957e-02f, 6.33113235e-02f,
  -1.68058667e-02f, 8.97643343e-02f, 3.68784443e-02f, -7.86443278e-02f, 1.70511063e-02f, -1.32003263e-01f, 9.54722287e-04f, 7.40973577e-02f, 1.10598393e-01f, 5.86437844e-02f,
  -1.09517738e-01f, 8.89043976e-03f, 1.98230073e-02f, 7.45704770e-02f, 1.48615530e-02f, 5.53450584e-02f, 3.78921181e-02f, -1.05610974e-01f, -3.29612717e-02f, -8.08138028e-03f,
  2.02938658e-03f, -1.55702652e-02f, -5.73782669e-03f, 2.52809376e-02f, -8.11792463e-02f, 5.83945140e-02f, 8.41225386e-02f, 2.61891074e-02f, 7.20164701e-02f, 9.08980146e-02f,
  1.26856461e-03f, 6.21380880e-02f, 5.23083135e-02f, 2.57110409e-03f, -5.59539907e-03f, 1.29794376e-02f, 8.96614715e-02f, 1.67459007e-02f, -1.49542941e-02f, 1.26918301e-01f,
  -1.45245060e-01f, -1.02249235e-01f, -8.76341313e-02f, -6.45429194e-02f, 6.43395409e-02f, 4.80051385e-03f, 4.50384393e-02f, 5.30643202e-02f, -3.95653434e-02f, 4.99705821e-02f,
  -1.15740234e-02f, -6.34548590e-02f, -6.65391749e-03f, 2.66385283e-02f, -1.21886075e-01f, -8.52271095e-02f, -1.27400197e-02f, -6.69676140e-02f, -6.79610819e-02f, 9.84621122e-02f,
  -1.29879758e-01f, -1.37447596e-01f, -2.14257035e-02f, -2.77409982e-02f, -5.32255732e-02f, -1.86532095e-01f, -9.38258544e-02f, -1.41526043e-01f, -1.76747859e-01f, -1.67162925e-01f,
  -1.22950666e-01f, -1.84813663e-01f, -1.91382021e-01f, -8.81916471e-03f, 3.34248841e-02f, -3.52630205e-02f, -2.13646829e-01f, -4.07446027e-02f, -5.16502466e-03f, -1.65647447e-01f,
  -3.42769995e-02f, -6.18485734e-02f, -4.11427394e-02f, -1.63623959e-01f, -1.31792620e-01f, -2.86696792e-01f, -2.52676696e-01f, -7.65052587e-02f, -7.39999488e-02f, -7.05466866e-02f,
  -4.92331088e-02f, -3.60910185e-02f, -2.07857043e-02f, -1.07730575e-01f, -5.80322137e-03f, -1.31189108e-01f, -9.37372223e-02f, -2.80719325e-02f, -1.90252826e-01f, -1.50340885e-01f,
  -1.28214940e-01f, 1.07716776e-01f, 9.43609029e-02f, -5.09068510e-03f, -9.23121721e-02f, 5.32653220e-02f, -8.73137563e-02f, 9.26469564e-02f, 2.24207249e-02f, -1.66447759e-02f,
  1.53248189e-02f, 7.45731890e-02f, -9.06897802e-03f, 5.86845577e-02f, 7.65435174e-02f, -3.88190746e-02f, -6.83732852e-02f, -5.75360358e-02f, -2.95328326e-03f, 8.25922191e-02f,
  -7.49362856e-02f, -5.92165031e-02f, -5.12428433e-02f, -7.19671696e-02f, 4.28880304e-02f, -7.89471865e-02f, -4.92488742e-02f, 7.53548667e-02f, -1.56826705e-01f, -1.26542732e-01f,
  -1.06665090e-01f, 8.64210445e-03f, -2.85738986e-02f, -3.45386341e-02f, -3.28367911e-02f, 4.64447327e-02f, -1.54720126e-02f, -7.13454187e-02f, 6.87614083e-02f, -7.27162808e-02f,
  5.64905629e-02f, -2.92535126e-02f, -3.22809629e-02f, 1.73228905e-02f, -9.11498740e-02f, 5.90356663e-02f, -8.47796947e-02f, -5.95786013e-02f, -7.28213415e-02f, -8.49794373e-02f,
  -9.62476525e-03f, -2.30704360e-02f, -2.60055438e-02f, 3.91613878e-02f, -8.83607939e-02f, 4.90817651e-02f, -2.74168458e-02f, 7.47930855e-02f, 6.23216946e-03f, 3.01891528e-02f,
  -4.04841118e-02f, -1.74064972e-02f, -2.02724524e-02f, 9.28275883e-02f, 1.21711148e-03f, 6.19009472e-02f, -5.06192185e-02f, -3.59768681e-02f, 6.46838546e-03f, -4.31661718e-02f,
  4.36768122e-02f, 4.21974137e-02f, -9.08389986e-02f, 6.20450545e-03f, 1.40153021e-02f, 6.51696399e-02f, -1.35808170e-01f, -8.51965509e-04f, -1.34303095e-02f, 6.96671605e-02f,
  -6.22597560e-02f, -2.04224527e-01f, -1.65964156e-01f, -2.47463230e-02f, -5.18066101e-02f, -4.12776656e-02f, -8.45305175e-02f, -1.14900604e-01f, -1.57286108e-01f, -2.32389271e-01f,
  6.77603558e-02f, 1.49525300e-01f, 2.88392305e-01f, -7.95953944e-02f, 1.76332965e-01f, 2.76379466e-01f, 3.13320190e-01f, 1.15321413e-01f, -1.45354196e-01f, 1.05946153e-01f,
  -1.76307485e-02f, -2.13190228e-01f, -5.70313744e-02f, -1.28232077e-01f, -2.94774137e-02f, 5.61590381e-02f, -4.19524359e-03f, -7.68693089e-02f, -6.84243292e-02f, -3.55743058e-02f,
  -1.64654136e-01f, -7.64790922e-02f, 1.75268166e-02f, -5.65929972e-02f, -1.78239681e-02f, -4.30326164e-02f, 5.64115942e-02f, 7.43841976e-02f, -1.15189310e-02f, -1.90881625e-01f,
  -2.47969143e-02f, 2.03890562e-01f, -1.93606138e-01f, -1.42692208e-01f, -6.35074032e-03f, -5.39530534e-03f, -5.72048128e-02f, -7.22499415e-02f, 5.52391708e-02f, -7.17873871e-02f,
  9.94992331e-02f, 5.34616634e-02f, -7.51082674e-02f, 1.62402056e-02f, 3.51260342e-02f, -2.78330538e-02f, 5.65007441e-02f, -9.58502516e-02f, -1.47172892e-02f, -5.99875860e-02f,
  -5.06690890e-02f, 5.28238490e-02f, 1.37259379e-01f, 9.88867059e-02f, 7.89166540e-02f, -1.30396513e-02f, 1.41129307e-02f, 1.78633276e-02f, -9.69211198e-03f, 7.43910810e-03f,
  -1.04367048e-01f, -5.50265936e-03f, -1.23980781e-02f, -5.11608534e-02f, -1.36918752e-02f, -4.58809249e-02f, -6.52286559e-02f, -1.91865657e-02f, -3.04696262e-02f, -1.36552956e-02f,
  -1.46910250e-02f, 1.05097435e-01f, 4.69920225e-02f, -5.93113154e-03f, 2.14539003e-02f, 9.22978297e-02f, 1.18541807e-01f, -3.76587100e-02f, 1.34632587e-01f, -2.65886337e-02f,
  -2.57963985e-02f, 4.91573140e-02f, 2.83230394e-02f, 6.05397895e-02f, 1.94395632e-02f, -2.44942475e-02f, -3.91115621e-02f, 4.99694459e-02f, 6.91775605e-02f, 6.74110418e-03f,
  -2.11966649e-01f, 1.97794124e-01f, -1.78486824e-01f, -1.21120341e-01f, 1.18676387e-01f, -5.15253581e-02f, 1.57673918e-02f, -2.26020161e-02f, -5.62869310e-02f, 6.67596757e-02f,
  5.93860485e-02f, 5.88440001e-02f, 1.21694647e-01f, -5.82578406e-02f, -1.27216522e-02f, 1.36775821e-02f, 3.65068428e-02f, -1.82475299e-02f, 3.27246413e-02f, 5.70908822e-02f,
  4.42298548e-03f, -5.68841249e-02f, 7.83412308e-02f, 3.06741358e-03f, 2.95034936e-03f, -1.19600728e-01f, -8.44966844e-02f, 4.54222932e-02f, 5.90790920e-02f, -5.26728109e-02f,
  -4.42102961e-02f, 9.99555886e-02f, -5.55795282e-02f, 1.14904352e-01f, 2.95914859e-02f, -7.31129274e-02f, -4.95748334e-02f, -3.40528134e-03f, -3.39588411e-02f, 1.25796750e-01f,
  -5.12196273e-02f, -1.38851348e-02f, -7.54315108e-02f, -8.18990916e-02f, -1.77181810e-01f, 3.60421673e-03f, 7.27728158e-02f, -7.62769729e-02f, -2.31448844e-01f, -8.37251320e-02f,
  1.89910904e-02f, -5.30772135e-02f, -1.85625121e-01f, 2.61943899e-02f, 9.11310408e-03f, 2.06406061e-02f, 7.72769600e-02f, 2.81476136e-02f, 6.45976588e-02f, 1.53671131e-01f,
  -4.47660126e-02f, -1.28303736e-01f, -2.24388596e-02f, 6.87730461e-02f, -1.89895928e-02f, -2.62494404e-02f, 6.00882024e-02f, 4.15886147e-03f, -9.31185409e-02f, -2.96696778e-02f,
  -2.97894329e-02f, 2.38756631e-02f, -1.10653348e-01f, 4.02986333e-02f, -4.58744317e-02f, -1.25539184e-01f, -2.91142873e-02f, -1.32965520e-01f, -8.75910670e-02f, -3.26761082e-02f,
  -5.42020015e-02f, 1.00066429e-02f, -8.24226439e-02f, 2.84979120e-02f, -1.38419140e-02f, 2.92992173e-03f, -6.05902076e-02f, 2.16443259e-02f, -3.19370292e-02f, 8.33882689e-02f,
  8.85776896e-03f, -4.33224514e-02f, 5.36680892e-02f, -2.33677756e-02f, 5.59929684e-02f, -3.13462950e-02f, -2.13123169e-02f, -1.62160341e-02f, -3.85899260e-03f, -7.11258426e-02f,
  -8.58417675e-02f, -5.10173701e-02f, -8.51539969e-02f, 4.12834361e-02f, 4.71042767e-02f, -6.33408874e-02f, 2.79514231e-02f, -5.04610203e-02f, 4.90311682e-02f, -4.45429496e-02f,
  -9.79411323e-03f, 4.00375538e-02f, 4.74274345e-03f, -3.04425694e-02f, 3.44844460e-02f, 1.70607660e-02f, 7.30519891e-02f, -6.58838600e-02f, 4.75898162e-02f, -1.14918901e-02f,
  -7.47234672e-02f, -6.69599650e-03f, -6.26452789e-02f, -1.68686919e-02f, 4.87643518e-02f, 2.52541695e-02f, -1.29781822e-02f, -8.79393518e-02f, 1.29073504e-02f, -7.69167542e-02f,
  -3.24349739e-02f, -8.60017464e-02f, -6.11938909e-02f, -4.13041115e-02f, -5.87105639e-02f, -2.13906970e-02f, 3.96501832e-02f, -7.84084871e-02f, 1.14513305e-03f, -7.85529539e-02f,
  4.10980321e-02f, 3.05860676e-02f, -1.52280584e-01f, -3.17962132e-02f, 1.96388848e-02f, 2.62817871e-02f, 3.47840507e-03f, -5.09817228e-02f, -7.94858262e-02f, -4.47817668e-02f,
  1.11737043e-01f, 9.37386453e-02f, 1.56909302e-01f, -7.79467076e-02f, -1.97823439e-02f, 6.15879595e-02f, 8.61962233e-03f, 1.02140725e-01f, 2.98576243e-02f, -1.07725718e-04f,
  3.32694389e-02f, -1.31835327e-01f, 3.41183618e-02f, 6.32703453e-02f, 1.80673182e-01f, 5.09846071e-03f, -2.18121111e-02f, 1.65208071e-01f, 4.00719643e-02f, -7.83732999e-03f,
  -6.28413111e-02f, 9.25314724e-02f, 1.26330256e-01f, 8.67960528e-02f, -5.13667539e-02f, -6.68636011e-03f, 7.31392354e-02f, 5.64499497e-02f, -2.44857999e-03f, -8.75143781e-02f,
  -1.12377420e-01f, -2.96520554e-02f, 5.16415387e-02f, -4.93713245e-02f, -2.73004603e-02f, 5.72664440e-02f, 5.46729006e-02f, -3.60645130e-02f, 7.12408274e-02f, 4.21180464e-02f,
  -1.08176053e-01f, -2.75345389e-02f, 5.34590594e-02f, -8.23118165e-02f, -2.17212867e-02f, 3.32695991e-02f, -1.67400073e-02f, 7.09938556e-02f, -1.56245641e-02f, -1.95088387e-02f,
  -1.16040625e-01f, -2.73280777e-02f, 7.41664767e-02f, 1.94708910e-02f, 1.25132516e-01f, -2.10080650e-02f, -4.88486625e-02f, -5.09380884e-02f, 7.60846585e-03f, 4.28094789e-02f,
  3.65717895e-02f, 6.06083423e-02f, -4.21338268e-02f, 3.84194078e-03f, 2.16670632e-02f, 3.04013342e-02f, -7.72999180e-03f, 7.82514457e-03f, 2.45351940e-02f, 1.97574869e-02f,
  5.67883812e-03f, -4.13695537e-03f, -5.05107492e-02f, 2.65097916e-02f, -9.70782191e-02f, -6.77564880e-03f, -3.52921188e-02f, -9.14227962e-02f, 2.43378449e-02f, 5.03382683e-02f,
  -5.90519570e-02f, 6.14289020e-04f, -1.59030464e-02f, -1.20050861e-02f, -9.02298838e-02f, -6.60069659e-02f, -3.79153155e-02f, 3.42683755e-02f, 3.69604528e-02f, 2.55713202e-02f,
  -8.58964473e-02f, -4.78643291e-02f, -1.02543637e-01f, 2.38540303e-02f, 4.48557362e-02f, -6.66555986e-02f, -1.91346444e-02f, 8.49991813e-02f, -5.88310547e-02f, 2.11289786e-02f,
  1.83814615e-02f, 5.44975139e-03f, -1.94885172e-02f, 2.47573014e-02f, -8.83451700e-02f, 7.33999396e-03f, -4.67424132e-02f, 6.63261712e-02f, -5.58810346e-02f, -1.54636726e-02f,
  -1.99096724e-02f, -3.84205356e-02f, -1.32781148e-01f, -8.98986235e-02f, -8.88037775e-03f, -7.68352970e-02f, -6.34716824e-03f, -5.36977239e-02f, -2.47195829e-02f, -4.54210788e-02f,
  -6.11609042e-01f, 4.16773632e-02f, -8.29136521e-02f, -4.34365869e-01f, -2.40768656e-01f, -1.91234201e-02f, 8.01191479e-02f, -1.22080825e-01f, -1.94023877e-01f, -8.98743495e-02f,
  -1.47655793e-02f, -8.55801255e-02f, -1.02616116e-01f, -5.51545694e-02f, -4.06938717e-02f, -8.69293883e-02f, -4.48241830e-02f, -1.14606991e-01f, -1.70319647e-01f, -7.78297633e-02f,
  -1.35674983e-01f, -3.21960509e-01f, -2.81317860e-01f, -1.18629709e-01f, -1.70619518e-01f, -7.25606084e-02f, 1.74004734e-02f, -1.35814846e-01f, 3.02561205e-02f, -8.59084725e-02f,
  2.98649162e-01f, -2.49765441e-02f, -4.00655828e-02f, 7.86770415e-03f, -2.46926378e-02f, -4.32247370e-02f, -2.27997154e-02f, 1.59955416e-02f, -7.96642452e-02f, 7.13586435e-02f,
  1.02374153e-02f, 5.40470853e-02f, -4.11012992e-02f, -1.63681824e-02f, -9.32270363e-02f, 4.54492606e-02f, -1.24462456e-01f, 7.02612428e-03f, -4.02394608e-02f, 9.89833921e-02f,
  3.46140452e-02f, 1.40562672e-02f, -3.16644721e-02f, 1.55917794e-01f, 6.49484023e-02f, 3.01580243e-02f, 1.46039069e-01f, 1.01348549e-01f, 8.07918385e-02f, -1.87852848e-02f,
  -1.65608358e-02f, -2.95739025e-02f, 2.84314938e-02f, -2.81591862e-02f, 6.49852008e-02f, 7.62651041e-02f, 5.38282245e-02f, -2.85967346e-03f, -9.53567326e-02f, 3.33516002e-02f,
  -2.36960407e-02f, 1.17683247e-01f, -2.04950869e-02f, -8.88790488e-02f, 2.07594316e-03f, -3.68787162e-02f, 6.48918077e-02f, -1.57021848e-03f, 1.75446607e-02f, -6.61441684e-02f,
  -3.78109924e-02f, 4.52985950e-02f, -1.03703095e-03f, 1.75492000e-02f, -3.91227193e-02f, -8.39321688e-03f, 2.92894803e-02f, -1.89185627e-02f, 4.65253517e-02f, -4.71920893e-03f,
  8.44034925e-02f, 9.51408967e-02f, -5.82322404e-02f, 1.62304360e-02f, -8.77147093e-02f, 1.07134305e-01f, -3.00923828e-02f, -1.86316185e-02f, -9.27468911e-02f, -5.82256615e-02f,
  1.64912958e-02f, 4.25373856e-03f, 2.65417080e-02f, 4.02454399e-02f, -7.88835660e-02f, 7.51793236e-02f, -1.59770045e-02f, -1.66072492e-02f, 3.89429294e-02f, 1.08981296e-01f,
  -2.72392072e-02f, 2.05476284e-02f, 5.25030494e-02f, 4.24076356e-02f, 7.69373542e-03f, -4.49041948e-02f, 5.92835657e-02f, 7.28304088e-02f, 2.11187843e-02f, 3.79028134e-02f,
  -2.18601301e-01f, -1.64615050e-01f, -1.00043677e-01f, 2.86369193e-02f, 1.26793787e-01f, -6.53723553e-02f, -1.36150718e-01f, -1.97725549e-01f, -4.73788679e-02f, -1.13765642e-01f,
  1.23147443e-01f, 7.68866837e-02f, -1.45929962e-01f, -1.66741218e-02f, -1.83222979e-01f, -2.50841111e-01f, -2.45995685e-01f, -8.32469612e-02f, -8.99318010e-02f, 1.07468523e-01f,
  -9.47262719e-03f, 7.97260404e-02f, 1.08954692e-02f, 4.44792435e-02f, 7.95813948e-02f, -6.06022216e-03f, -1.09279484e-01f, 2.50018798e-02f, 4.05776724e-02f, -8.22445005e-02f,
  -2.88168974e-02f, -4.83429283e-02f, 3.38633987e-03f, 9.09274966e-02f, 1.08455375e-01f, -9.26345810e-02f, -2.30254722e-04f, 1.29302805e-02f, -4.89481948e-02f, -1.37083735e-02f,
  3.46921757e-02f, 8.14111009e-02f, -8.62016678e-02f, 1.64861437e-02f, -3.21530141e-02f, -7.13672191e-02f, -5.52387983e-02f, -8.10591578e-02f, -1.09008223e-01f, -8.42774659e-02f,
  -4.78034876e-02f, 3.73725966e-02f, -6.91896379e-02f, -4.40834984e-02f, 1.39768713e-03f, -2.89137568e-02f, 4.50034589e-02f, -5.44345267e-02f, -1.77506953e-02f, -1.26927420e-01f,
  8.30503181e-02f, 3.51729766e-02f, -1.25540013e-03f, -1.73316933e-02f, -1.47636316e-03f, 6.66006133e-02f, 1.66046862e-02f, 3.56949084e-02f, 3.23328376e-02f, -1.64004900e-02f,
  -3.76697816e-02f, 1.05083548e-02f, -4.05606814e-02f, -9.07573625e-02f, 3.24596511e-03f, -7.08184317e-02f, -5.75748365e-03f, 1.83135066e-02f, -9.54433829e-02f, 3.92152667e-02f,
  -4.36871545e-03f, 1.88682340e-02f, 2.81437058e-02f, 3.34836841e-02f, -7.98560604e-02f, 4.24231887e-02f, 1.03953164e-02f, 7.83255398e-02f, -4.78326082e-02f, -5.90990670e-02f,
  -8.15660655e-02f, 6.36397069e-03f, -6.16350658e-02f, -1.26671702e-01f, 6.71302900e-02f, -2.34402623e-02f, 4.46377061e-02f, -1.30346958e-02f, -3.24435569e-02f, 2.69016754e-02f,
  2.44727693e-02f, -3.47054452e-02f, -5.85606880e-02f, 3.17627341e-02f, -5.20333126e-02f, -4.56405245e-02f, -1.46098867e-01f, -1.26643822e-01f, -1.03521012e-01f, -6.96960613e-02f,
  -9.36553031e-02f, -2.51395673e-01f, -2.45963588e-01f, -1.21877350e-01f, -5.65143004e-02f, -8.13747793e-02f, -2.24062443e-01f, -1.02002569e-01f, -3.15960944e-01f, -2.21984640e-01f,
  -1.84590578e-01f, -3.21894847e-02f, -1.46936283e-01f, 2.45852903e-01f, 3.20328504e-01f, 6.15146533e-02f, 7.57819563e-02f, -1.85373928e-02f, 2.04798207e-01f, 1.24557197e-01f,
  2.39521220e-01f, 3.12881321e-01f, 2.00630501e-01f, 1.76984668e-01f, -8.08857940e-03f, -1.71971526e-02f, 1.98603328e-02f, 3.38861905e-02f, 9.03961062e-03f, 7.12975636e-02f,
  2.73645550e-01f, 1.10811681e-01f, -9.66256484e-02f, 4.84320335e-02f, 2.05666021e-01f, 2.23786116e-01f, 1.12672113e-01f, 1.09718733e-01f, 8.36518258e-02f, 8.71264562e-02f,
  5.13663292e-02f, -1.47588387e-01f, 1.09327845e-01f, 9.64727029e-02f, 9.09454897e-02f, -3.53718288e-02f, -3.25045809e-02f, -1.34374604e-01f, -3.73940915e-02f, 4.01390009e-02f,
  -2.00698692e-02f, 5.19214256e-04f, 8.96113589e-02f, -7.52887428e-02f, -3.44971307e-02f, -1.22272670e-01f, -2.83883158e-02f, -4.74868752e-02f, -1.08748928e-01f, -8.23397785e-02f,
  1.65947109e-01f, -1.03469510e-02f, -1.43348634e-01f, -3.96405756e-02f, 2.24812962e-02f, 1.61760449e-02f, -1.58231005e-01f, 2.72534578e-03f, -5.04834540e-02f, -8.20625201e-02f,
  1.63475820e-03f, 5.34029640e-02f, -2.92082038e-02f, -3.81592032e-03f, 6.52393252e-02f, 5.62769994e-02f, 7.14690834e-02f, 8.40538815e-02f, 4.63061184e-02f, -1.27310921e-02f,
  -9.09298938e-03f, 2.30003428e-02f, 3.68928649e-02f, 6.65698349e-02f, 3.48833762e-02f, 1.52436215e-02f, -4.49221060e-02f, -6.53396919e-02f, -6.14534728e-02f, 2.19021607e-02f,
  1.68977976e-02f, -6.18029647e-02f, -8.54708627e-02f, 2.75406633e-02f, -3.39955427e-02f, -5.40515892e-02f, -4.81028743e-02f, -2.23006867e-02f, 9.09330882e-03f, 5.14253080e-02f,
  -5.60786650e-02f, -2.83643287e-02f, 9.15923268e-02f, 1.10522388e-02f, 3.93670090e-02f, -6.57103211e-02f, -1.71958879e-02f, -3.82916741e-02f, -3.82214896e-02f, -9.15481225e-02f,
  -6.52139215e-03f, -1.10385641e-01f, -8.62023979e-02f, -1.57376453e-02f, -8.89344066e-02f, -4.19644602e-02f, -4.80704866e-02f, 6.29174486e-02f, -2.68069711e-02f, -1.20342769e-01f,
  -1.03381230e-02f, -9.92742628e-02f, 2.56897006e-02f, 3.01686097e-02f, -3.16474885e-02f, 1.21689020e-02f, -1.31924137e-01f, -5.63545711e-03f, -1.20153308e-01f, -1.92959189e-01f,
  1.88277721e-01f, -9.11988243e-02f, 6.81139808e-03f, 1.49634287e-01f, 1.59018993e-01f, 2.31846452e-01f, 1.61489472e-01f, 8.21851753e-03f, -8.02101754e-03f, -2.59493403e-02f,
  -1.18656762e-01f, -1.93131924e-01f, -8.86800587e-02f, -1.72505647e-01f, -6.37489930e-02f, 2.37194262e-02f, -6.46897266e-03f, 8.97665322e-02f, -7.09088938e-03f, 1.12561785e-01f,
  -5.55159934e-02f, 1.48077264e-01f, 4.23287004e-02f, -2.03667842e-02f, -9.13442075e-02f, -6.84367642e-02f, 9.11062807e-02f, 6.93910420e-02f, -7.50977127e-03f, 1.77227650e-02f,
  3.17424312e-02f, -1.00014098e-01f, 5.65724038e-02f, -1.48343071e-01f, -5.86236529e-02f, 1.43577764e-03f, -8.39294344e-02f, -3.15463431e-02f, -1.40047953e-01f, -5.63851893e-02f,
  -4.25045863e-02f, 1.51666366e-02f, -1.41332835e-01f, -2.60901283e-02f, 1.93594955e-02f, 6.22435510e-02f, 3.02114468e-02f, 1.55099798e-02f, -7.30550289e-02f, -9.13431719e-02f,
  -3.76059487e-02f, 6.32920489e-02f, 9.54351425e-02f, -3.56709287e-02f, -1.80167377e-01f, -9.12415758e-02f, 2.85525918e-02f, -1.09891472e-02f, -8.42447057e-02f, 5.53909913e-02f,
  -6.43914640e-02f, -4.74912822e-02f, 1.97866485e-02f, 2.47796420e-02f, -4.62376028e-02f, 6.74806535e-02f, -3.32218148e-02f, 6.28846437e-02f, -6.74120858e-02f, -1.90161709e-02f,
  6.06128527e-03f, 2.61946656e-02f, -2.80635767e-02f, 9.26399603e-03f, -4.54544090e-02f, 8.78871232e-03f, -7.99807534e-02f, -8.31650272e-02f, 6.25668764e-02f, 1.73671450e-02f,
  -8.83145705e-02f, -7.78008848e-02f, -2.32030842e-02f, -5.83245121e-02f, -7.63560981e-02f, -3.99383530e-02f, -5.73647209e-02f, -6.25707433e-02f, -1.03793517e-02f, 4.28485759e-02f,
  7.32675642e-02f, -9.45508704e-02f, -2.71195360e-02f, -1.13836482e-01f, -1.94663629e-02f, -1.25503615e-01f, 6.35961257e-03f, -5.20863496e-02f, -1.32972956e-01f, -5.70967831e-02f,
  -1.42438039e-01f, -8.38140473e-02f, -8.00365582e-02f, 2.55521648e-02f, 1.17803328e-01f, 3.64840999e-02f, -5.50836585e-02f, 9.71160010e-02f, -9.62151811e-02f, -4.25476842e-02f,
  -5.04775532e-02f, 2.13579670e-01f, 1.27074569e-01f, 2.71804091e-02f, 1.04122028e-01f, 1.14830583e-01f, 4.55614366e-02f, 1.39895277e-02f, 1.99039415e-01f, 2.98037499e-01f,
  -4.28740978e-01f, -7.29054287e-02f, 3.67332436e-02f, -4.06817794e-02f, 1.54147506e-01f, 9.41282958e-02f, 7.81706721e-02f, 3.08626983e-02f, -1.28313184e-01f, -6.59876391e-02f,
  8.67019519e-02f, -1.18633501e-01f, -7.72551671e-02f, -2.61924993e-02f, 1.91607866e-02f, 1.35511309e-01f, 1.20270617e-01f, -8.65853950e-03f, 6.12611175e-02f, -4.03243378e-02f,
  1.15712881e-01f, 4.17075679e-02f, -7.59046674e-02f, 4.71227691e-02f, -9.18424204e-02f, -3.35159898e-02f, 7.90138617e-02f, 6.78947866e-02f, 4.66576815e-02f, -4.71864045e-02f,
  -6.80763274e-02f, -1.43400609e-01f, 5.69921285e-02f, -7.03385174e-02f, 1.32943923e-02f, -9.00746435e-02f, 1.82331204e-02f, -1.04633503e-01f, -1.22732542e-01f, -1.05317302e-01f,
  8.05981606e-02f, 5.58434613e-02f, -1.85424425e-02f, 6.51231930e-02f, -1.04250893e-01f, -1.10573210e-01f, -5.22363931e-02f, -4.15007807e-02f, -8.90082195e-02f, 2.88955737e-02f,
  1.16537161e-01f, 3.74824926e-02f, -4.97846417e-02f, -5.46136722e-02f, -9.23760012e-02f, 8.87519680e-03f, 2.15113326e-03f, -1.35495335e-01f, 5.60442172e-03f, -5.30858077e-02f,
  -2.29423624e-02f, 2.29432471e-02f, -7.31574232e-03f, 1.87550895e-02f, -1.87677331e-02f, 1.16637349e-02f, -2.69354079e-02f, 2.95073111e-02f, -2.53572445e-02f, 3.44865322e-02f,
  -6.14525527e-02f, -4.70659143e-06f, 5.89210689e-02f, -7.18277022e-02f, 2.45230235e-02f, 5.96739538e-02f, 8.84232074e-02f, -1.03630619e-02f, 8.26613978e-02f, 5.77382185e-02f,
  -2.58908607e-02f, -6.07926138e-02f, 5.20170517e-02f, -6.52176654e-03f, 7.01479837e-02f, 8.32300931e-02f, 5.39477635e-03f, -6.51987344e-02f, 3.25462818e-02f, -2.91644111e-02f,
  -1.42015949e-01f, 2.18080074e-01f, -1.61195412e-01f, -1.28264159e-01f, -8.93050153e-03f, -6.35766611e-02f, -5.74998856e-02f, -2.15643030e-02f, -6.06828295e-02f, -2.17966214e-02f,
  -4.57201451e-02f, -1.03967741e-01f, -5.79226613e-02f, -5.94110638e-02f, 1.28764668e-02f, -4.55080718e-02f, 1.72122102e-02f, -1.20020911e-01f, -6.10356294e-02f, -3.02168261e-02f,
  -7.57568628e-02f, -7.18718693e-02f, -2.04616383e-01f, -1.39073297e-01f, 6.64441055e-03f, -1.76568106e-01f, 6.25748560e-03f, -1.18459642e-01f, -7.66732767e-02f, -1.29418612e-01f,
  9.05272961e-02f, -1.62575826e-01f, 8.31057224e-03f, 1.97051376e-01f, 7.59704858e-02f, 4.82890122e-02f, 4.56063356e-03f, 3.23982127e-02f, 6.26640990e-02f, 1.66358496e-03f,
  8.12140182e-02f, 1.06140025e-01f, 1.25559896e-01f, 9.71398056e-02f, 6.33658469e-03f, 7.11105093e-02f, 8.73882696e-02f, 1.04633279e-01f, 1.18198685e-01f, 1.45775592e-03f,
  5.24252616e-02f, -5.71540780e-02f, 1.60791203e-02f, -1.72938276e-02f, 7.38742203e-02f, 8.35635290e-02f, 9.46757346e-02f, 2.62455307e-02f, -3.30395326e-02f, -1.98849570e-02f,
  1.22363670e-02f, -2.36226395e-02f, 5.08035868e-02f, 3.82450335e-02f, -3.29927206e-02f, 3.00320555e-02f, 1.86076537e-02f, -1.15011044e-01f, -1.07241124e-01f, -6.96515962e-02f,
  8.64451155e-02f, 3.72821186e-03f, 1.05059277e-02f, -1.68342069e-02f, -7.10377023e-02f, -6.67927489e-02f, -1.04341477e-01f, -8.04905817e-02f, -4.10190597e-02f, 4.28700596e-02f,
  4.62399200e-02f, 4.46734875e-02f, 4.09008563e-02f, 6.68121548e-03f, 3.43377404e-02f, 1.41803712e-01f, 2.49674581e-02f, -4.86971578e-03f, 5.65427206e-02f, -2.05830447e-02f,
  8.29937831e-02f, -8.31317715e-03f, 2.40727458e-02f, 4.39267196e-02f, -1.95402224e-02f, 7.30306283e-02f, 5.32626100e-02f, -1.29518583e-02f, 8.39607269e-02f, -1.53801795e-02f,
  8.57156068e-02f, -1.15610184e-02f, -7.50178378e-03f, -1.16716549e-02f, 1.16697162e-01f, 1.15808241e-01f, 2.76927017e-02f, 5.31180948e-02f, 5.83314151e-02f, 3.36779580e-02f,
  2.87266485e-02f, -4.37184266e-04f, -5.06334901e-02f, -6.97297081e-02f, 1.97344292e-02f, 1.22280277e-01f, 6.19795248e-02f, 9.63695571e-02f, 4.27713767e-02f, -1.75887085e-02f,
  -1.17600232e-01f, 7.79614896e-02f, 9.00412723e-02f, -4.28702757e-02f, -1.27273463e-02f, 5.87508678e-02f, 7.49931857e-02f, 1.14161670e-02f, -1.47847697e-01f, -6.57205954e-02f,
  3.05444095e-02f, 6.14755638e-02f, 3.12662795e-02f, -4.09974270e-02f, 2.01077107e-02f, 7.43693709e-02f, -2.68432721e-02f, 2.00115331e-02f, -6.74917251e-02f, 5.46507277e-02f,
  -3.72009538e-02f, -2.44052857e-02f, 2.92327087e-02f, 1.81660131e-02f, 6.98236004e-02f, 4.73929793e-02f, -5.82283698e-02f, 6.80854172e-02f, -5.79822212e-02f, 1.77765600e-02f,
  1.51156977e-01f, -3.57902378e-01f, -2.54358709e-01f, -6.75684661e-02f, -3.02283108e-01f, -4.27489012e-01f, -5.48593998e-01f, -1.35221273e-01f, 2.80237161e-02f, -3.02482247e-01f,
  -2.24958614e-01f, -3.51370536e-02f, 7.66159967e-02f, 9.72065255e-02f, 2.26566587e-02f, -3.31312299e-01f, -2.87129909e-01f, -3.05923522e-02f, 1.64016008e-01f, -1.62660673e-01f,
  -1.57199338e-01f, 6.16883151e-02f, 1.71921730e-01f, 1.45791113e-01f, -1.06730036e-01f, 5.59482612e-02f, -1.37463771e-03f, 1.01903267e-02f, -2.12549701e-01f, -1.89252391e-01f,
  -3.91764700e-01f, -4.81571890e-02f, 1.44504281e-02f, 1.45952523e-01f, -4.08470146e-02f, -8.68885890e-02f, -3.31663154e-02f, 1.02510944e-01f, -3.57445665e-02f, -1.39492840e-01f,
  -2.32343525e-02f, 5.39001524e-02f, 1.03763245e-01f, -8.66455026e-03f, -8.64445791e-02f, -2.76640225e-02f, 3.63900363e-02f, 4.73394431e-02f, 3.95940430e-03f, -5.01728021e-02f,
  -1.27078220e-01f, -1.12787709e-01f, -8.36525206e-03f, -2.06589745e-03f, 4.50537875e-02f, 1.21171951e-01f, 5.62694445e-02f, 5.76493517e-02f, 8.61042663e-02f, -1.23805255e-01f,
  -4.69398163e-02f, -2.51280386e-02f, -3.96655127e-02f, 5.15794978e-02f, 4.98553962e-02f, 6.64371178e-02f, -8.61713365e-02f, 1.02499081e-02f, 4.33940515e-02f, 6.06410280e-02f,
  -3.22412094e-03f, -7.70924706e-03f, 7.75512829e-02f, 5.11689819e-02f, -1.29056601e-02f, 3.83885689e-02f, 4.71028220e-03f, -5.11730909e-02f, -1.05794920e-02f, -2.68642902e-02f,
  -7.86290877e-03f, 1.08918473e-02f, 5.41641898e-02f, -1.31622981e-02f, 3.52971628e-03f, 6.04621461e-03f, -4.77687754e-02f, 1.96633730e-02f, 7.05356598e-02f, -5.37677892e-02f,
  2.16660082e-01f, 1.11278355e-01f, -1.04531206e-01f, -3.00706970e-03f, 1.27658360e-02f, 3.06733605e-02f, -1.06623538e-01f, 6.19520433e-02f, -2.93875970e-02f, -5.04094921e-02f,
  -3.95345688e-02f, 8.17842409e-02f, 2.22417004e-02f, -5.87047935e-02f, 3.65089513e-02f, 1.25516579e-02f, -4.70533036e-02f, -3.74605022e-02f, -4.07303683e-02f, -1.15699209e-01f,
  -6.61032880e-03f, 2.13646907e-02f, -5.72296418e-02f, 3.22262421e-02f, 5.37766553e-02f, 3.65127027e-02f, -1.19940467e-01f, -8.44851602e-03f, 1.65218115e-02f, -1.48385623e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.93193465e-01f, 1.69073254e-01f, 2.98881203e-01f, -1.47280153e-02f, 2.30237275e-01f, 1.33595780e-01f, 3.53856124e-02f, 3.21124464e-01f, 9.61453170e-02f, 5.52537851e-02f,
  2.04262018e-01f, 2.61509269e-01f, 6.28026277e-02f, 3.08339834e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.98219603e-02f, 1.39138764e-02f, -2.37508461e-01f, -6.36338666e-02f, -1.76796615e-01f, -3.23867053e-01f, 2.31850311e-01f, 5.33630662e-02f, -1.37819946e-01f, 7.83019215e-02f,
  -1.42121822e-01f, -8.03085789e-02f, -2.66180784e-01f, -3.07399094e-01f, -4.04199809e-01f, 5.44952303e-02f, 1.29956588e-01f, -3.37761372e-01f, -1.75147414e-01f, -5.65835536e-01f,
  -8.61173943e-02f, 1.28122166e-01f, -5.41057408e-01f, -2.11247224e-02f, -2.07259119e-01f, 4.97075588e-01f, -1.74489319e-01f, 1.82418302e-02f, -1.91173464e-01f, -2.90765643e-01f,
  2.67610908e-01f, -1.06386103e-01f, 1.01259969e-01f, 9.47775617e-02f, 9.56647322e-02f, -2.53009796e-01f, -1.11366242e-01f, 4.42990482e-01f, 4.04941380e-01f, -1.73030436e-01f,
  3.85235548e-02f, -5.03311396e-01f, 7.49736056e-02f, 3.73184174e-01f, 1.51334882e-01f, 2.04049662e-01f, -1.88413978e-01f, -4.30621132e-02f, 3.47552061e-01f, 1.53096542e-01f,
  -9.39174518e-02f, 1.48999602e-01f, -1.85628742e-01f, 6.14667118e-01f, -2.46331349e-01f, -1.97539270e-01f, 9.45053250e-03f, 8.17681253e-02f, 3.94804537e-01f, -7.38865659e-02f,
  -1.22205935e-01f, -7.65827149e-02f, -1.02290988e-01f, 6.34187043e-01f, 1.18528567e-01f, 1.81904897e-01f, 1.54759869e-01f, -2.19452024e-01f, -3.04896772e-01f, 3.94953676e-02f,
  -2.28181109e-01f, 1.15553029e-01f, 1.72896355e-01f, 2.32406303e-01f, -7.06445053e-02f, -4.00806308e-01f, -5.09131067e-02f, 2.22876206e-01f, 4.56033759e-02f, -1.33104905e-01f,
  -3.15968812e-01f, 2.03918472e-01f, -2.67355055e-01f, -1.88385174e-01f, 7.71622136e-02f, 1.27170738e-02f, -1.36742175e-01f, 1.01860777e-01f, 4.54940587e-01f, -1.62113592e-01f,
  -6.22695722e-02f, -4.42430705e-01f, -6.90242290e-01f, -1.47094712e-01f, -4.41700548e-01f, -5.88364005e-01f, 3.81657690e-01f, -4.49042827e-01f, -3.66047531e-01f, 3.22067738e-01f,
  -1.23846814e-01f, 5.33515096e-01f, 1.91836819e-01f, -1.12214580e-01f, 3.93977314e-02f, -7.06794500e-01f, 2.06387743e-01f, 4.10037756e-01f, 3.29320103e-01f, -9.53309759e-02f,
  3.55191855e-03f, -5.33312082e-01f, -4.88789350e-01f, 5.14977090e-02f, 3.75761032e-01f, -1.43441394e-01f, -1.87909769e-04f, 4.16787602e-02f, -7.57405162e-02f, -1.89940363e-01f,
  7.04168752e-02f, 1.44855669e-02f, -3.48730743e-01f, 3.94752175e-01f, -1.83690608e-01f, -4.16287273e-01f, 3.37004006e-01f, 5.97409070e-01f, 1.03240073e-01f, -2.40729451e-01f,
  1.10653199e-01f, -1.71201564e-02f, 1.63006317e-02f, 5.94537752e-03f, 2.85480320e-01f, -9.48754773e-02f, 6.56835660e-02f, 2.37789944e-01f, 2.32286140e-01f, 1.89743072e-01f,
  1.53911904e-01f, 1.29935453e-02f, 2.76933491e-01f, 3.66086274e-01f, 4.86809276e-02f, 1.88696668e-01f, 2.65486002e-01f, 2.99103677e-01f, -8.00149441e-02f, 9.82245430e-03f,
  -2.66553044e-01f, -2.31863540e-02f, 2.31984019e-01f, 9.75834019e-03f, -4.93158519e-01f, -2.26104692e-01f, -7.70689622e-02f, -3.63063306e-01f, -1.92092210e-02f, -1.38210326e-01f,
  3.33029687e-01f, -1.00916056e-02f, 2.07224488e-01f, 1.13495961e-01f, -2.09476575e-01f, -1.59623146e-01f, -3.60669672e-01f, 3.14713895e-01f, -2.73887962e-01f, -1.15597114e-01f,
  2.47969627e-01f, -2.50327468e-01f, -3.51163477e-01f, -5.53686857e-01f, 3.26737314e-01f, -5.91239870e-01f, 6.05758488e-01f, -3.13868701e-01f, -4.41362292e-01f, -3.28644276e-01f,
  -1.43134728e-01f, -8.68570879e-02f, -6.90882504e-02f, -8.87267515e-02f, 1.69188157e-01f, -2.04033121e-01f, 3.43108959e-02f, -2.19218090e-01f, -1.72413811e-01f, 2.26644278e-01f,
  1.67076699e-02f, 4.65816259e-01f, -2.13157088e-01f, -6.60841689e-02f, -1.62487105e-01f, -3.57452989e-01f, 2.60483623e-01f, 1.13817707e-01f, -2.64887601e-01f, 1.33572027e-01f,
  -6.06038123e-02f, 8.45742598e-03f, 2.01694667e-01f, 1.62632465e-01f, 1.11001194e-01f, -1.48940951e-01f, 5.40190525e-02f, 1.80257455e-01f, -4.06521708e-02f, -2.38639161e-01f,
  1.22764438e-01f, -2.10182756e-01f, 3.19944918e-02f, 9.47109908e-02f, -7.45375529e-02f, 1.45323753e-01f, -3.72552037e-01f, -4.00077373e-01f, 1.02562539e-01f, -2.74223477e-01f,
  7.74972558e-01f, 1.84394926e-01f, -2.74885327e-01f, 4.68169093e-01f, -2.67410010e-01f, -1.76808983e-01f, 4.05738473e-01f, -2.70897120e-01f, -4.03021164e-02f, 3.84590298e-01f,
  3.29245120e-01f, -4.09680992e-01f, -6.64866328e-01f, 3.94892037e-01f, 3.71381879e-01f, -4.23842967e-02f, 2.54978269e-01f, -2.12529451e-01f, 1.04680754e-01f, -1.97145075e-01f,
  -1.43197058e-02f, 3.18628247e-03f, -2.70304501e-01f, -1.27225727e-01f, -2.63886601e-01f, 1.26595452e-01f, 2.38185838e-01f, 1.49707228e-01f, -6.20502904e-02f, 7.04314232e-01f,
  1.89788550e-01f, -1.66365445e-01f, -1.53545126e-01f, 4.01560903e-01f, -9.33842361e-02f, -4.09464777e-01f, -2.39158124e-02f, 1.18956327e-01f, -2.93450952e-01f, -2.38990560e-02f,
  6.60607815e-02f, -1.93457484e-01f, -4.77315597e-02f, 1.05458520e-01f, 2.81042624e-02f, -4.23604883e-02f, -4.46212977e-01f, 9.36926678e-02f, -3.15594710e-02f, 2.27107182e-01f,
  1.31421000e-01f, -8.90851468e-02f, -1.39657944e-01f, -9.39237699e-03f, 2.88447708e-01f, 2.10894987e-01f, 1.19939605e-02f, -3.40937942e-01f, 1.17321715e-01f, 5.17521426e-02f,
  -4.28612143e-01f, -2.05097407e-01f, 4.08215187e-02f, -2.34458968e-01f, 1.99883789e-01f, 1.03559062e-01f, 3.27161789e-01f, 2.81376570e-01f, 5.06497547e-02f, 2.94149071e-01f,
  -1.99949607e-01f, -4.66866255e-01f, -2.40405351e-01f, -5.77575505e-01f, -1.91318661e-01f, 1.88425124e-01f, 5.09750724e-01f, 2.65930057e-01f, 3.24894220e-01f, -1.86522990e-01f,
  5.33447266e-01f, 2.51889884e-01f, 3.92680377e-01f, -2.23932356e-01f, -3.70861530e-01f, 5.75645149e-01f, 2.45266497e-01f, 4.73175287e-01f, 1.57703608e-01f, 3.71624589e-01f,
  4.50696014e-02f, 2.21070811e-01f, -2.06592336e-01f, 2.35518754e-01f, 1.96579754e-01f, -1.76226333e-01f, -1.11295044e-01f, -1.52198240e-01f, 4.44369763e-02f, 1.18057594e-01f,
  6.96974099e-02f, -2.72284359e-01f, 2.40585610e-01f, 3.27346385e-01f, 3.00329924e-01f, 7.42492527e-02f, 4.88333315e-01f, 4.11788821e-02f, 5.49548678e-02f, 2.74685889e-01f,
  2.50789762e-01f, -8.67386013e-02f, 2.41946593e-01f, 2.49182522e-01f, -4.95781712e-02f, -5.87942123e-01f, 1.10892184e-01f, 1.40390575e-01f, 3.34362447e-01f, 1.25321522e-01f,
  -3.09618097e-02f, -2.47464739e-02f, 5.04142225e-01f, 3.63250487e-02f, 3.14624667e-01f, 3.42372090e-01f, 7.54125476e-01f, 1.40840441e-01f, -1.80964414e-02f, -1.70559123e-01f,
  4.51158196e-01f, -1.15547255e-01f, 1.04982212e-01f, 3.81894886e-01f, -1.58191055e-01f, 2.46058911e-01f, -1.77629396e-01f, -1.90256104e-01f, 1.94618627e-01f, -8.35087225e-02f,
  5.59274852e-01f, -6.13958836e-01f, 1.37687430e-01f, 4.72386122e-01f, 1.32081404e-01f, 1.98280104e-02f, -4.35664803e-01f, 1.86862528e-01f, -4.29702550e-01f, 2.77766496e-01f,
  1.02891348e-01f, 6.56385660e-01f, -1.48634940e-01f, -1.58468813e-01f, -1.46469012e-01f, 1.46803647e-01f, -4.11257669e-02f, -1.40301660e-01f, -2.91650772e-01f, 9.61783901e-03f,
  2.52552181e-01f, -2.19955757e-01f, -1.40728667e-01f, 8.67633969e-02f, -3.41274053e-01f, 2.22111076e-01f, -3.83676216e-02f, 9.25457031e-02f, 6.89146370e-02f, 1.30859494e-01f,
  1.19870119e-01f, -1.79642811e-02f, 4.93671484e-02f, -1.79836184e-01f, 1.49138898e-01f, 4.03438807e-01f, -1.41790453e-02f, -4.10210580e-01f, -4.18331861e-01f, 2.88058996e-01f,
  8.28972384e-02f, 1.09685674e-01f, -5.95185399e-01f, -2.91754186e-01f, 2.38525450e-01f, 1.04713298e-01f, 2.31563702e-01f, 1.89102039e-01f, -5.88956892e-01f, 5.22659481e-01f,
  -3.13638985e-01f, 1.39267460e-01f, -3.22191305e-02f, 2.14896262e-01f, 2.09106073e-01f, 1.52130648e-01f, 1.74991056e-01f, 5.40469885e-02f, -4.30044115e-01f, -1.20200545e-01f,
  2.61360705e-01f, -6.04802072e-01f, -2.88049459e-01f, 4.89117622e-01f, -1.84366405e-01f, -1.21972807e-01f, -4.43223983e-01f, -2.48845398e-01f, -5.06994247e-01f, 3.88247110e-02f,
  -2.36886799e-01f, 1.58124179e-01f, 5.66675700e-02f, -4.58940595e-01f, 2.91962400e-02f, -2.12237969e-01f, 5.75195491e-01f, -1.49879456e-01f, -1.93492249e-01f, -7.38837868e-02f,
  1.85653418e-01f, -2.48439625e-01f, -3.34058315e-01f, -3.04173499e-01f, -1.17053211e-01f, -2.44699687e-01f, -1.75541118e-01f, -3.29783171e-01f, -1.81425869e-01f, 8.28120932e-02f,
  1.62077934e-01f, -2.25257382e-01f, 4.43880409e-02f, 1.10083021e-01f, -2.82000035e-01f, 6.27251938e-02f, -1.82696179e-01f, 5.79386158e-03f, -1.69778038e-02f, -4.33909982e-01f,
  -1.27466485e-01f, -3.15482169e-02f, 6.42648339e-02f, -3.93619806e-01f, 1.60298020e-01f, 5.14017232e-03f, -4.53594550e-02f, -1.76061139e-01f, 7.72417486e-02f, 3.05097122e-02f,
  -7.94895366e-02f, -5.20436406e-01f, 1.31972861e-02f, -3.87102872e-01f, -1.21937580e-01f, -1.81711927e-01f, 4.54612404e-01f, 2.56194711e-01f, 1.19069278e-01f, 3.86218548e-01f,
  -1.46180809e-01f, 1.14871658e-01f, 4.99428093e-01f, 2.87103295e-01f, -5.50766848e-03f, -2.49330997e-01f, 2.38093510e-02f, -2.19134122e-01f, -3.36530447e-01f, 1.07341837e-02f,
  1.84611127e-01f, -2.72341490e-01f, -2.17783600e-01f, -1.21000506e-01f, -1.35820687e-01f, 4.01436418e-01f, 2.22661838e-01f, -1.42495424e-01f, 4.53381717e-01f, -1.66418791e-01f,
  -4.19893682e-01f, -3.55392545e-02f, -1.40598476e-01f, 1.71078205e-01f, 1.93341989e-02f, -2.10366711e-01f, -6.35465491e-04f, 3.89765054e-01f, -1.76332504e-01f, 3.10369730e-01f,
  1.79698057e-02f, -2.52346635e-01f, 8.83356258e-02f, 1.26400962e-01f, -8.70491117e-02f, 1.27397463e-01f, -4.00698045e-03f, 1.35659315e-02f, -3.97234172e-01f, 1.30285561e-01f,
  1.80609245e-02f, 2.09798470e-01f, -4.49253619e-01f, 3.66378635e-01f, -9.98924896e-02f, 8.54919702e-02f, 1.20148696e-01f, 2.34492972e-01f, 2.51233250e-01f, -5.31097531e-01f,
  5.27870469e-02f, 2.03164771e-01f, -2.48928019e-03f, -5.46040423e-02f, 5.53569198e-02f, 1.13065436e-01f, -2.89712101e-02f, 1.40241832e-01f, 4.17255670e-01f, 2.89666414e-01f,
  1.29926160e-01f, -2.44008765e-01f, -2.81445861e-01f, -5.29878736e-01f, -1.49946705e-01f, -3.32035333e-01f, -3.87745239e-02f, 5.44563174e-01f, 1.25041500e-01f, 2.97106683e-01f,
  2.48779893e-01f, -6.58510476e-02f, 1.67999417e-01f, 1.94370762e-01f, -5.31285703e-01f, 4.00642663e-01f, -1.85102254e-01f, -6.87060058e-02f, -4.34188694e-01f, 3.22167069e-01f,
  1.17092326e-01f, -5.19008696e-01f, 2.92757582e-02f, -2.86399096e-01f, -2.98792589e-02f, -1.45465180e-01f, 2.16653660e-01f, 5.95578551e-03f, -6.98041916e-02f, -3.81487489e-01f,
  -1.52290478e-01f, -1.02839559e-01f, 5.97747684e-01f, 5.12782708e-02f, 1.51371554e-01f, -4.50414717e-01f, 2.73929328e-01f, 2.18178742e-02f, -3.96351740e-02f, 6.44041896e-02f,
  1.32618090e-02f, -1.95134208e-01f, 1.07194006e-01f, 1.70148805e-01f, -3.84418547e-01f, 2.44776562e-01f, -1.06594600e-01f, -1.75385222e-01f, -3.37431312e-01f, -3.51463526e-01f,
  3.74545515e-01f, 3.32876816e-02f, 1.29491374e-01f, 2.00699002e-01f, -6.85261143e-03f, 6.00977801e-02f, -5.98059520e-02f, 1.17487028e-01f, 2.33375490e-01f, 1.57732517e-01f,
  2.57616252e-01f, -7.24590570e-02f, -2.92851001e-01f, 4.60335553e-01f, -5.57705104e-01f, 5.06622374e-01f, 3.76405150e-01f, 1.63960040e-01f, -1.18425578e-01f, 5.54529667e-01f,
  -4.71565902e-01f, -3.66790831e-01f, 4.15087312e-01f, -5.39909124e-01f, -4.08944368e-01f, 9.90443528e-02f, 3.38881612e-01f, 2.07131237e-01f, 4.02212381e-01f, -3.25952142e-01f,
  2.53193378e-02f, 5.16156673e-01f, 1.89578936e-01f, -1.69956043e-01f, 1.73005193e-01f, -2.07455590e-01f, -3.61687601e-01f, -4.44861762e-02f, 1.03276312e-01f, 6.79255053e-02f,
  -1.67478636e-01f, 1.90034732e-01f, -2.30550483e-01f, -2.69145548e-01f, 3.97746861e-01f, 4.41952139e-01f, -1.61834046e-01f, 1.21523023e-01f, 1.39765456e-01f, -2.31297880e-01f,
  -6.15849495e-02f, 9.32152122e-02f, 1.89103961e-01f, -3.52086984e-02f, -1.93298459e-01f, 1.15905575e-01f, -4.40285504e-02f, -3.01509410e-01f, 7.15472922e-02f, -3.36597145e-01f,
  7.94880837e-02f, 9.83410552e-02f, 2.59993732e-01f, 1.84232831e-01f, 1.68382287e-01f, 3.13566625e-01f, -1.65975288e-01f, 3.15339833e-01f, -1.23076491e-01f, 1.48135021e-01f,
  -6.44016406e-03f, 1.28542468e-01f, 7.24797994e-02f, -5.14730275e-01f, 1.03587314e-01f, -2.46200800e-01f, -3.51181895e-01f, 2.64735639e-01f, -2.92836666e-01f, -3.73788059e-01f,
  -9.24653038e-02f, -3.05082709e-01f, -5.80314994e-01f, -2.50079155e-01f, 5.13597846e-01f, -6.10469375e-03f, -3.82109880e-01f, -8.22282583e-02f, 3.94069403e-02f, -2.15729959e-02f,
  -4.27713953e-02f, 5.01214206e-01f, -2.61026230e-02f, 3.49598080e-01f, -2.12225899e-01f, 2.55369842e-01f, 1.98982388e-01f, 2.91859001e-01f, -5.04976511e-01f, 3.86032939e-01f,
  -7.05363527e-02f, 8.18449929e-02f, -2.24071383e-01f, -2.87487119e-01f, -6.59639761e-02f, -2.40277156e-01f, -8.10306370e-02f, 5.67833304e-01f, -1.89626366e-01f, -1.91330627e-01f,
  8.26826915e-02f, -2.90003195e-02f, -1.60021514e-01f, -2.22190440e-01f, 1.06349602e-01f, 7.41016716e-02f, 1.29772767e-01f, -3.22711021e-02f, -4.10597384e-01f, -1.76844466e-02f,
  -7.27338940e-02f, -1.76254123e-01f, 1.92906871e-01f, -2.19779864e-01f, 1.96245849e-01f, 4.95252684e-02f, 1.45978436e-01f, 7.35201910e-02f, -2.67442942e-01f, -7.58881792e-02f,
  -1.16545804e-01f, -1.74676016e-01f, 1.27506584e-01f, 3.37995648e-01f, 1.19335741e-01f, 1.42610475e-01f, -2.50130557e-02f, 1.78196788e-01f, 2.18207538e-01f, 1.17621377e-01f,
  3.12145472e-01f, -9.30447876e-02f, 2.82002568e-01f, 5.52861929e-01f, -6.02960587e-01f, 4.20246124e-01f, 2.22104356e-01f, -1.03134759e-01f, -5.43157101e-01f, -2.63355244e-02f,
  2.98423260e-01f, 4.56085175e-01f, -8.17691758e-02f, 3.65841955e-01f, -3.09714884e-01f, -1.05715785e-02f, -2.92130738e-01f, -2.80202627e-01f, 2.71816492e-01f, 1.84259519e-01f,
  2.43939951e-01f, 6.10306486e-02f, 8.76280665e-03f, 1.72731966e-01f, 2.31955394e-01f, -1.59687474e-01f, 4.20581996e-01f, -1.54821888e-01f, 6.38080716e-01f, -1.18482701e-01f,
  2.18314499e-01f, -7.48004764e-02f, -5.41992560e-02f, -2.42363706e-01f, 3.67942452e-02f, 7.35763758e-02f, -1.57697409e-01f, -2.98380405e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.74446996e-02f, 2.45857164e-02f, -6.89365789e-02f, -7.98858553e-02f, -1.31946921e-01f, 4.45643812e-02f, -1.10575985e-02f, -1.65269136e-01f, -1.20640378e-02f, -9.19002220e-02f,
  -2.48434413e-02f, 1.71264298e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    