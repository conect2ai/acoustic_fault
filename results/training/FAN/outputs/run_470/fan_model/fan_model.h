/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.47752473e-01f, 7.99901900e-04f, 3.75020951e-02f, -3.16123180e-02f, -1.29839908e-02f, -1.68834731e-01f, -1.45092070e-01f, -9.70022082e-02f, -2.65128493e-01f, 1.11777419e-02f,
  -7.58232130e-03f, 1.28980279e-02f, -1.64243467e-02f, -8.22481364e-02f, -1.06872670e-01f, -1.96937006e-02f, -1.95801228e-01f, 6.13034554e-02f, 1.93740036e-02f, -3.54127549e-02f,
  -7.32103437e-02f, -1.66608974e-01f, 7.13760406e-02f, 8.40310231e-02f, -7.40629435e-03f, -3.28126661e-02f, 5.19628748e-02f, 2.18724638e-01f, 1.67802665e-02f, 8.73841420e-02f,
  -1.16105832e-01f, -1.93289276e-02f, 6.40618615e-03f, -4.46455844e-04f, 2.94769928e-03f, 2.81513967e-02f, 5.22019789e-02f, 1.04922041e-01f, 8.75950884e-03f, -7.86639843e-03f,
  -8.38538259e-03f, -6.48894534e-03f, 2.83577554e-02f, -1.20364903e-02f, -6.73379377e-02f, -2.58133877e-02f, -1.69851203e-02f, -5.87310158e-02f, 3.72320935e-02f, 2.32048258e-02f,
  -2.17198245e-02f, 2.80110482e-02f, 4.60341312e-02f, -1.87706202e-02f, 9.02635604e-02f, -4.56789359e-02f, -2.50666235e-02f, 5.83922900e-02f, -3.76687460e-02f, -1.74260996e-02f,
  1.80060025e-02f, 9.42830443e-02f, 7.72316232e-02f, 3.56371850e-02f, -2.51314440e-03f, 7.08025992e-02f, 4.80057672e-02f, 3.90117951e-02f, 8.36049691e-02f, 4.53086495e-02f,
  -4.44374196e-02f, 2.35039778e-02f, 3.70064639e-02f, -4.20928560e-02f, 1.42657934e-02f, -8.33646022e-03f, -1.67630259e-02f, 2.17497423e-02f, -3.81055148e-03f, -7.09467242e-03f,
  5.45000136e-02f, -2.21608020e-02f, 3.60645987e-02f, -4.51508611e-02f, 2.27733534e-02f, 4.16663103e-02f, 4.07008789e-02f, 3.07901222e-02f, -1.60966627e-02f, 4.78328317e-02f,
  -1.22439340e-01f, -5.51454304e-03f, -7.51306862e-02f, 2.18160041e-02f, 5.92183657e-02f, 4.88167927e-02f, -4.91029210e-03f, -2.55666231e-03f, -3.14402133e-02f, -2.44265944e-02f,
  5.04788160e-02f, -1.95224618e-03f, -4.14031409e-02f, 4.83660847e-02f, -1.67566687e-02f, 1.30075086e-02f, 1.31255528e-03f, 2.98214369e-02f, -2.99049113e-02f, 2.75678989e-02f,
  1.56468824e-02f, -3.29880789e-02f, 5.67920171e-02f, 1.94773711e-02f, -5.18207159e-03f, 2.60028914e-02f, 4.63366657e-02f, -2.01868564e-02f, 1.70543026e-02f, -1.75928343e-02f,
  2.35400841e-01f, -6.75543770e-02f, -8.16790909e-02f, 2.31325045e-01f, 1.14557697e-02f, -2.55038947e-01f, -9.19828638e-02f, 1.86983749e-01f, 8.33697058e-03f, -1.35377765e-01f,
  1.01273991e-01f, -1.22834168e-01f, -6.57167137e-02f, 5.71680330e-02f, 5.26746102e-02f, -8.31840634e-02f, 5.96682280e-02f, -9.99944881e-02f, 6.34126514e-02f, 9.66453329e-02f,
  2.32753046e-02f, 5.32412976e-02f, -1.53432935e-02f, 7.61727542e-02f, -6.35953713e-03f, 5.89313209e-02f, 1.14888296e-01f, -5.64488117e-03f, 4.53442559e-02f, -9.41516906e-02f,
  1.13508314e-01f, 1.45446256e-01f, -6.02991804e-02f, -4.60114889e-02f, 7.91261867e-02f, 1.10739106e-02f, -5.05372807e-02f, -3.82160284e-02f, -6.22708239e-02f, -4.96003963e-03f,
  -1.04549125e-01f, 3.18553410e-02f, 2.11281851e-02f, 1.74697917e-02f, -1.45065458e-02f, -4.56738211e-02f, -8.11352432e-02f, -4.80692238e-02f, -5.54837696e-02f, -2.20089443e-02f,
  -1.24897091e-02f, 1.29334508e-02f, -1.12078317e-01f, -5.21403626e-02f, 6.23994842e-02f, -4.79650870e-02f, -1.23465843e-01f, -1.57507118e-02f, -3.20639573e-02f, 1.04023553e-02f,
  -9.10409093e-02f, -6.59861416e-02f, 1.13580776e-02f, 6.45660087e-02f, 1.39583107e-02f, 8.49364996e-02f, -6.24531955e-02f, -3.29154208e-02f, 7.56455958e-02f, -4.42498252e-02f,
  1.03842169e-01f, 3.30855362e-02f, 3.60714495e-02f, -3.29547226e-02f, 7.02135041e-02f, -1.25426063e-02f, -2.34899651e-02f, 9.64950956e-03f, 3.46896180e-04f, 4.52401191e-02f,
  -2.93019973e-03f, 4.51640412e-03f, 6.80170730e-02f, -6.42675012e-02f, 8.79098941e-03f, -3.31067368e-02f, 1.15542486e-03f, -7.61471614e-02f, 3.45680118e-02f, 6.04999484e-03f,
  1.05854347e-02f, 1.62490219e-01f, -2.04948690e-02f, -1.80375874e-02f, -2.25331057e-02f, -4.03338298e-03f, -7.95652121e-02f, 2.62080021e-02f, -1.70625339e-03f, 6.39120638e-02f,
  -5.35176955e-02f, 3.05635296e-02f, 2.50148866e-02f, 3.42923924e-02f, -5.24542220e-02f, -1.33475671e-02f, 1.22254780e-02f, 6.35236921e-03f, 7.25895837e-02f, 8.44710544e-02f,
  1.75627775e-03f, -4.70924377e-02f, -4.37497571e-02f, 7.92286694e-02f, 4.41997824e-03f, 1.46574213e-03f, 4.26017977e-02f, -3.32823060e-02f, 5.07642850e-02f, -6.36983961e-02f,
  2.66824186e-01f, 9.08106491e-02f, -5.36123849e-02f, 1.73869953e-01f, 1.48749724e-01f, -1.03930838e-01f, -7.36520067e-02f, 1.81591898e-01f, 1.00535870e-01f, -8.29460323e-02f,
  -2.21745647e-03f, 4.37811576e-02f, -2.20750764e-01f, 3.53932455e-02f, 9.56097990e-02f, -2.45837823e-01f, 2.11497441e-01f, 2.66270782e-03f, 3.76745290e-03f, 1.64020449e-01f,
  1.05323151e-01f, 4.69944999e-02f, 2.86833979e-02f, 6.91952333e-02f, 4.42259461e-02f, 1.23446427e-01f, -4.39758934e-02f, -6.37770370e-02f, 7.58287162e-02f, -1.41423391e-02f,
  1.48258597e-01f, 1.33054435e-01f, 3.67202722e-02f, -2.39273459e-02f, 5.33630401e-02f, 1.22483997e-02f, 8.98877345e-03f, -1.01450130e-01f, 6.10463955e-02f, 1.20763704e-02f,
  -2.16842405e-02f, 2.66516265e-02f, -4.67210338e-02f, -9.51366276e-02f, -8.40012804e-02f, -1.58939306e-02f, -1.21718468e-02f, 2.64454987e-02f, 3.55276801e-02f, -5.81083857e-02f,
  2.66396292e-02f, -1.31054958e-02f, -4.82780151e-02f, 2.77706888e-02f, 6.23937696e-02f, 1.17801744e-02f, -4.09242474e-02f, -7.79994298e-03f, 1.01645850e-02f, 1.20664097e-01f,
  8.57830513e-03f, 2.27415189e-02f, -2.04378981e-02f, 6.09703641e-03f, 1.61746014e-02f, 4.78704050e-02f, -7.39242211e-02f, 7.03306347e-02f, -1.95169132e-02f, 3.42518762e-02f,
  7.61132240e-02f, 5.12008294e-02f, 4.31799330e-03f, 2.05103569e-02f, 9.45112295e-03f, 5.89658208e-02f, -3.31628695e-02f, -5.56912528e-05f, 6.49121311e-03f, -3.51367076e-03f,
  -2.32453011e-02f, -1.13018071e-02f, -7.89932627e-03f, -8.83738603e-03f, 2.48473673e-03f, -3.78575246e-03f, -7.89237469e-02f, 2.29727570e-02f, 2.00663656e-02f, -2.31015850e-02f,
  -2.03083958e-02f, 1.12833098e-01f, 2.43122298e-02f, -4.54200841e-02f, -3.39464284e-02f, -4.62383181e-02f, 2.03976948e-02f, 2.24373993e-02f, -4.64263037e-02f, -2.44222339e-02f,
  -5.23063718e-05f, 8.11425373e-02f, 4.62394506e-02f, 3.24502005e-04f, -7.19752256e-03f, 4.03413735e-02f, 2.50906534e-02f, 2.44174968e-03f, 7.67836794e-02f, 6.13761209e-02f,
  -5.63066714e-02f, 8.35556258e-03f, 2.56587453e-02f, 5.89917302e-02f, -1.66238821e-03f, 3.97463180e-02f, 2.23502181e-02f, 1.37393875e-02f, -3.25007029e-02f, -6.35399902e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.52691042e-01f, 2.92489737e-01f, -3.64435874e-02f, -8.44597518e-02f, -7.25359693e-02f, 1.31802753e-01f, 1.67113960e-01f, 1.46060869e-01f, 6.22541904e-02f, 2.62134761e-01f,
  5.48397712e-02f, -2.14001223e-01f, 1.54857159e-01f, 1.81968942e-01f, -1.99815333e-01f, 2.37050250e-01f, 5.03959022e-02f, -7.60715604e-02f, -1.44355493e-02f, -1.24448255e-01f,
  -1.64075747e-01f, 8.09300542e-02f, -1.96092203e-02f, 1.83976769e-01f, -2.21117303e-01f, -1.63706735e-01f, -2.11420849e-01f, 3.65262665e-02f, -1.48453191e-01f, -1.61645804e-02f,
  -2.78971642e-01f, -2.57221401e-01f, -2.66161263e-01f, -1.88044935e-01f, -2.08126962e-01f, -5.18016852e-02f, -1.70421358e-02f, -2.50541419e-02f, 3.16699296e-02f, -5.99018596e-02f,
  -3.98456790e-02f, -2.65173391e-02f, -2.96096895e-02f, 2.06435658e-03f, -2.98739877e-02f, -2.62673609e-02f, 6.49448633e-02f, -8.06599483e-02f, 1.64688081e-02f, 9.06483829e-02f,
  6.60382807e-02f, -7.34028779e-03f, -2.00640988e-02f, 9.72869992e-02f, -4.30760346e-02f, 3.79922986e-02f, 4.68887091e-02f, -8.90651625e-03f, -1.84997901e-01f, -4.85347360e-02f,
  6.33269176e-03f, -5.95542192e-02f, 7.32379258e-02f, -4.74475464e-03f, -9.17094480e-03f, -8.03802535e-02f, -8.17362405e-03f, -4.61368635e-02f, -2.39405059e-03f, 7.04672709e-02f,
  1.00407787e-02f, 4.16828413e-03f, -3.21367420e-02f, -4.36771289e-02f, -3.25305713e-03f, -4.18715440e-02f, 3.69740538e-02f, 2.00613979e-02f, 4.27492298e-02f, -7.53414631e-02f,
  7.93420151e-02f, 4.16692384e-02f, -6.98636174e-02f, 3.03511322e-02f, -2.91202255e-02f, -2.25068126e-02f, -1.85805261e-02f, 3.50116263e-03f, -5.12703508e-02f, -3.18767354e-02f,
  -1.78538084e-01f, -2.34647915e-01f, 1.08098832e-03f, -9.19787213e-02f, -1.21701114e-01f, -3.61008607e-02f, -7.87922516e-02f, -7.13583380e-02f, -1.20423667e-01f, -9.12273377e-02f,
  -1.01679442e-02f, 5.99728152e-02f, -3.58131006e-02f, -6.18327260e-02f, -5.14399596e-02f, 4.20153327e-02f, 7.32344091e-02f, -5.21694943e-02f, -1.17792480e-01f, -9.50007513e-02f,
  -8.97163078e-02f, -3.49733979e-02f, 5.85833415e-02f, -8.26382264e-02f, -4.43334393e-02f, -5.65233417e-02f, -1.00306809e-01f, 2.74971910e-02f, -1.41547387e-02f, 2.45842338e-02f,
  2.70333499e-01f, -3.77798408e-01f, -4.23936218e-01f, -5.03120339e-03f, 3.66422415e-01f, 1.82620615e-01f, 2.26109978e-02f, 1.95901692e-01f, -1.88507557e-01f, 5.90056293e-02f,
  1.55313909e-01f, -2.44670540e-01f, -1.94981128e-01f, 1.07829414e-01f, 2.04835355e-01f, -3.10978979e-01f, 2.43637353e-01f, 4.23970520e-02f, -1.55225605e-01f, -3.13894786e-02f,
  1.05127372e-01f, 2.80055225e-01f, 1.30572142e-02f, 3.09031814e-01f, 1.59282595e-01f, -5.66719547e-02f, 2.91715503e-01f, -9.59432647e-02f, 2.17282414e-01f, 2.35564932e-01f,
  -2.75188824e-03f, -1.58536863e-02f, -6.46071136e-02f, -9.86019373e-02f, 2.28550192e-02f, -3.53268832e-02f, -7.84852207e-02f, 9.84197035e-02f, -4.81284410e-02f, -1.18407778e-01f,
  -7.79820830e-02f, 5.22080846e-02f, 7.07980692e-02f, -3.40147652e-02f, 7.90053159e-02f, 1.40951484e-01f, -5.06252237e-02f, -6.00909553e-02f, -1.38975784e-01f, -1.53535351e-01f,
  -1.81536987e-01f, -5.12472950e-02f, 2.80016959e-02f, -4.21854369e-02f, -1.49708360e-01f, 1.60353293e-03f, 6.37936890e-02f, -2.66393814e-02f, 2.76324544e-02f, -4.87544807e-03f,
  7.49530122e-02f, 6.55753091e-02f, 5.77095859e-02f, 9.37403459e-03f, -2.71365792e-02f, -8.19915533e-02f, 5.98664060e-02f, -6.11478388e-02f, -4.76922244e-02f, -8.55372474e-02f,
  -3.19166668e-02f, 2.87780594e-02f, -3.16443034e-02f, 9.89836082e-02f, 1.11692660e-01f, 3.17611583e-02f, -3.36296782e-02f, 3.76878381e-02f, -6.38709068e-02f, -8.42769966e-02f,
  -1.29150124e-02f, 1.33253019e-02f, -5.04602715e-02f, 7.19559006e-03f, 1.54248895e-02f, -8.94247927e-03f, 8.49374011e-02f, -2.55182455e-03f, 1.83377527e-02f, 2.76982933e-02f,
  -6.76756650e-02f, -1.21642679e-01f, -7.26022720e-02f, 1.22536205e-01f, -1.02751844e-01f, 6.00548238e-02f, 5.90955652e-02f, -6.40211105e-02f, 1.66965351e-02f, -9.51303765e-02f,
  1.22331478e-01f, 8.46404284e-02f, 3.06526870e-02f, 6.51721433e-02f, 3.17416266e-02f, 3.39417420e-02f, 2.19022669e-02f, 7.53026381e-02f, 1.47687420e-01f, -1.54983969e-02f,
  9.16941911e-02f, 2.06624158e-02f, 4.20212932e-03f, 1.65080056e-02f, 6.89025000e-02f, -2.74437256e-02f, 1.01799086e-01f, 1.67153478e-02f, 1.11912014e-02f, -8.51158425e-02f,
  -2.79339224e-01f, 1.06961895e-02f, 3.30071300e-01f, 4.52412903e-01f, -1.04160115e-01f, -2.31548622e-01f, -3.78021419e-01f, 8.31719115e-02f, 2.03236148e-01f, -1.69310719e-01f,
  -5.12015074e-02f, -1.12347240e-02f, -1.73444256e-01f, 3.58054399e-01f, -7.05321655e-02f, 1.29028171e-01f, 9.90390778e-04f, 9.02807787e-02f, 5.48066571e-02f, 1.31252334e-01f,
  1.12926841e-01f, 1.14528060e-01f, 2.37006560e-01f, 6.14377074e-02f, 2.39931792e-02f, 1.05063871e-01f, 1.28417998e-03f, -9.60621834e-02f, 1.54070824e-01f, -9.99841988e-02f,
  -2.13170260e-01f, 2.14300990e-01f, 1.07932270e-01f, -1.05035640e-01f, -9.65447128e-02f, -1.37054667e-01f, -3.60661559e-02f, -4.02472392e-02f, 1.61735062e-02f, -5.97849339e-02f,
  1.00536920e-01f, 4.91828211e-02f, 9.02981684e-02f, -1.83834769e-02f, -1.21747172e-02f, 8.71533900e-02f, 6.10672683e-02f, 3.96663435e-02f, 1.89688522e-02f, -6.74425885e-02f,
  3.55471484e-02f, 2.93805432e-02f, 7.18047693e-02f, 1.88291203e-02f, 5.42944893e-02f, 3.80519740e-02f, 8.89667571e-02f, 8.79854411e-02f, 8.51101130e-02f, 3.90640907e-02f,
  8.73148534e-03f, 5.67860864e-02f, -5.57136089e-02f, -3.27135101e-02f, 8.09530634e-03f, -1.09211661e-01f, 3.07501145e-02f, -1.64695635e-01f, -8.04913417e-02f, -7.49482512e-02f,
  -4.97884527e-02f, 4.95533645e-02f, 1.02427155e-01f, -2.93276124e-02f, 6.67861402e-02f, -7.50188679e-02f, 5.65536954e-02f, -3.22648650e-03f, -2.85461824e-02f, -5.50234802e-02f,
  8.12357590e-02f, -9.07179527e-03f, -4.89356853e-02f, -7.00617805e-02f, -1.45940721e-01f, 2.93733808e-03f, 1.35815218e-01f, -3.23010376e-03f, -2.44341828e-02f, 1.97782740e-02f,
  -1.40461490e-01f, 2.96469599e-01f, 8.45747665e-02f, -8.69908109e-02f, 7.54463971e-02f, 3.27876233e-03f, 4.75015268e-02f, -5.17012961e-02f, -6.07937016e-02f, -2.41208095e-02f,
  -8.66992250e-02f, -5.42932563e-02f, -1.00983351e-01f, -9.05840695e-02f, 4.11074087e-02f, -5.68409376e-02f, -9.06430334e-02f, -5.13547682e-04f, -1.34725749e-01f, 1.95806380e-03f,
  -2.19712052e-02f, -7.57048428e-02f, -8.46033618e-02f, -4.73370170e-03f, 2.16248892e-02f, 3.85757498e-02f, -4.79954183e-02f, 8.20287913e-02f, 3.12687345e-02f, 8.67546871e-02f,
  -4.47367162e-01f, 1.37332201e-01f, -5.21550961e-02f, 2.79708982e-01f, -1.16949208e-01f, -9.60040018e-02f, -1.38157338e-01f, 1.57208756e-01f, -1.19847052e-01f, 1.13789923e-01f,
  1.09784842e-01f, -1.26531482e-01f, 8.52187574e-02f, 3.15779775e-01f, 1.31180167e-01f, 1.02288574e-01f, 9.35109183e-02f, -4.22625020e-02f, 6.38323650e-02f, 1.02158181e-01f,
  4.94752638e-02f, 2.70098686e-01f, 1.78915441e-01f, 7.74868205e-02f, -5.52014969e-02f, 6.44311607e-02f, 1.51251286e-01f, 4.16209325e-02f, 2.03704804e-01f, 1.63684580e-02f,
  -1.03642665e-01f, 3.75581644e-02f, -6.93498459e-03f, -6.88528642e-02f, 6.45949766e-02f, -8.09707567e-02f, -3.13819982e-02f, -6.24151006e-02f, -4.70844954e-02f, 1.09355841e-02f,
  -1.30093113e-01f, -1.03398934e-02f, -5.88359609e-02f, 7.98318237e-02f, -9.40461829e-03f, 5.96901774e-02f, 7.93790743e-02f, -8.66915882e-02f, -5.58175594e-02f, 8.42628181e-02f,
  1.60189357e-03f, 4.83075790e-02f, -6.28350377e-02f, 2.30652634e-02f, 9.98934060e-02f, 4.87484224e-02f, -1.19779773e-01f, -4.12849709e-02f, -5.87408012e-03f, 4.11670581e-02f,
  -4.50290553e-02f, -6.23416789e-02f, 4.24528979e-02f, 1.50172245e-02f, 8.61807168e-02f, 1.03565112e-01f, 5.48762083e-02f, 7.70884901e-02f, -7.23959878e-02f, 1.65793244e-02f,
  -5.26707321e-02f, -8.44691787e-03f, -2.13985518e-02f, 1.53920334e-02f, -5.10338731e-02f, -2.61209104e-02f, -8.84495825e-02f, 7.48020038e-02f, -1.03465356e-01f, 1.32444859e-01f,
  -3.53329740e-02f, -1.31280392e-01f, 1.00982848e-04f, -6.67103082e-02f, 8.02028254e-02f, 3.27492058e-02f, 9.75448713e-02f, -4.92693204e-03f, -4.01286148e-02f, -2.32257247e-02f,
  1.15409680e-01f, 7.37610981e-02f, 1.02193654e-01f, -3.38256434e-02f, 5.45330055e-04f, 2.37453617e-02f, -2.14686785e-02f, 7.90376067e-02f, 4.86332625e-02f, 1.07765667e-01f,
  -9.77928489e-02f, -7.68138049e-03f, -2.21542679e-02f, 8.36739764e-02f, 2.50863694e-02f, -2.49167327e-02f, -5.59975803e-02f, 2.88973972e-02f, -2.77568325e-02f, 2.61635799e-02f,
  5.39175533e-02f, 5.03629111e-02f, -2.93720067e-02f, -2.49352008e-02f, 2.20819470e-02f, -8.72442275e-02f, -4.55872975e-02f, -5.85578196e-02f, 6.53946772e-02f, -1.15305958e-02f,
  -1.38118193e-01f, -1.68548450e-01f, -4.01474476e-01f, -3.37591678e-01f, 8.57662633e-02f, -3.35839629e-01f, -3.82542521e-01f, -2.96756551e-02f, 2.29459126e-02f, 7.63774738e-02f,
  -4.41479683e-02f, -1.14677347e-01f, 1.18737124e-01f, -3.48903030e-01f, -4.25654382e-01f, -8.38848427e-02f, -4.53638911e-01f, -2.31427237e-01f, -6.23926260e-02f, -1.71359301e-01f,
  -9.46778506e-02f, -3.95452827e-02f, -2.95186251e-01f, 6.14211783e-02f, -1.30337521e-01f, 7.29827583e-02f, 2.32714266e-01f, 6.93089217e-02f, -2.23021686e-01f, -1.59474034e-02f,
  -9.95040238e-02f, 1.61064994e-02f, -1.21837407e-01f, -3.91911827e-02f, -1.64117634e-01f, -5.45944907e-02f, -4.84571755e-02f, -8.09332579e-02f, -2.86594201e-02f, -1.00917183e-01f,
  7.19241500e-02f, 5.94777539e-02f, -1.08619198e-01f, 7.69463405e-02f, -6.15421741e-04f, 2.75485311e-02f, 4.44012210e-02f, -9.03858244e-02f, -4.82722968e-02f, -8.94924179e-02f,
  -1.45804703e-01f, -2.42105611e-02f, -8.48020315e-02f, 6.35642279e-03f, -2.92507671e-02f, 4.61504050e-02f, -8.31476599e-02f, 7.69057451e-03f, -3.00229918e-02f, -7.59167001e-02f,
  1.07256949e-01f, 4.87608612e-02f, -3.20164487e-02f, -2.00136751e-02f, -1.74654275e-02f, -1.73347648e-02f, 2.02091988e-02f, -5.65960370e-02f, 6.49780631e-02f, 5.95493466e-02f,
  2.54313592e-02f, -6.40878454e-02f, 1.04330629e-01f, -5.55121005e-02f, -1.07411789e-02f, 2.62140762e-02f, -2.31328569e-02f, 2.40598191e-02f, -7.19804615e-02f, 1.13762366e-02f,
  3.66183110e-02f, -1.22536579e-02f, 4.19448502e-02f, 6.22197837e-02f, -3.20667848e-02f, 4.07768302e-02f, -6.69274852e-03f, -8.23818371e-02f, 5.94723858e-02f, -1.90120563e-02f,
  -6.08072467e-02f, 3.23360227e-02f, 6.58298209e-02f, -4.30793427e-02f, 8.67298767e-02f, -5.78924343e-02f, -2.09037047e-02f, -7.66000301e-02f, 1.29497033e-02f, 1.90855525e-02f,
  3.19739990e-02f, 1.14403386e-02f, 6.97983652e-02f, -2.40928009e-02f, 2.12864596e-02f, 6.30298480e-02f, 5.60416691e-02f, 5.16366661e-02f, 1.00391703e-02f, 6.65525720e-02f,
  1.00324214e-01f, 8.26632231e-02f, 1.14268407e-01f, 3.89764532e-02f, 1.14266779e-02f, 5.93149476e-02f, 1.82205141e-02f, -2.16399506e-02f, -1.43619776e-02f, 4.45964560e-02f,
  -2.46913880e-01f, 2.88943201e-01f, 2.44669601e-01f, -2.27079958e-01f, 1.72474310e-01f, 4.88699414e-02f, -1.10899977e-01f, 4.80148792e-01f, 1.17676951e-01f, -6.24503046e-02f,
  -1.62785739e-01f, 2.68921927e-02f, 9.63617787e-02f, -1.52600914e-01f, -1.42780766e-01f, -1.12286471e-02f, -1.12599388e-01f, -1.83118552e-01f, 2.65260667e-01f, -7.16975704e-02f,
  7.99050108e-02f, -1.40393421e-01f, -5.85199185e-02f, 2.05179974e-01f, 8.24012607e-02f, 1.62819885e-02f, -4.38090503e-01f, 1.99271023e-01f, -2.03012124e-01f, 3.09482329e-02f,
  -2.13806853e-01f, -6.72150552e-02f, -3.07373498e-02f, 2.46972200e-02f, 4.66156378e-02f, -3.71834636e-03f, -5.50099351e-02f, -3.83775122e-02f, 5.55143319e-02f, 1.53793216e-01f,
  -1.34346299e-02f, 9.89982113e-02f, 3.77428494e-02f, 1.06999382e-01f, 1.41793877e-01f, 1.14581972e-01f, 7.22930674e-03f, 7.60528259e-03f, -7.20155910e-02f, 9.76213813e-02f,
  1.16299897e-01f, 9.34106484e-02f, -4.17485088e-02f, -1.14977688e-01f, -6.32596910e-02f, -8.39667320e-02f, -7.30627924e-02f, -3.36586535e-02f, 4.64140400e-02f, -6.87801689e-02f,
  5.21710999e-02f, -6.23346977e-02f, -4.88977060e-02f, -6.99178607e-04f, 6.75594807e-02f, 2.97868773e-02f, -2.20381655e-02f, -1.17919147e-02f, 3.77365872e-02f, -4.61205989e-02f,
  -9.40128341e-02f, -7.04620332e-02f, 1.09108210e-01f, -1.94205698e-02f, 2.39304900e-02f, -9.41878855e-02f, -1.30073622e-01f, 2.23486312e-02f, 4.39462699e-02f, -3.63621749e-02f,
  -1.19310832e-02f, -1.14489794e-01f, 6.93117231e-02f, -6.27443418e-02f, 1.07167447e-02f, -1.41894352e-02f, -1.10880751e-02f, 1.08588636e-01f, -5.92307001e-02f, -1.30808810e-02f,
  -5.87426662e-01f, -4.31809664e-01f, -9.65018868e-02f, -4.14807051e-02f, -7.14825839e-02f, -1.49650842e-01f, -5.32949343e-02f, 4.89577129e-02f, -4.01609242e-02f, 5.26634930e-03f,
  -9.09476206e-02f, 5.71162812e-02f, -8.19999799e-02f, 6.96174204e-02f, -7.77107105e-03f, -2.94038169e-02f, -6.86344206e-02f, -2.39553135e-02f, -2.18583360e-01f, 9.51536447e-02f,
  6.27819374e-02f, -1.07737683e-01f, -9.01101306e-02f, -2.17728093e-02f, -5.62048182e-02f, -1.81905657e-01f, -2.75917184e-02f, 5.12803253e-03f, -3.98169532e-02f, -7.31106615e-04f,
  4.06226963e-01f, -3.27089936e-01f, -3.88983488e-02f, 3.18600118e-01f, 2.21410856e-01f, 1.51486725e-01f, 3.06221157e-01f, -4.61145770e-03f, 3.91795754e-01f, -2.83293486e-01f,
  4.66179699e-02f, -2.20132589e-01f, -1.66953400e-01f, 4.66533676e-02f, 2.62639910e-01f, -1.37323901e-01f, 2.62815386e-01f, 7.44749606e-02f, 7.49061108e-02f, 1.45800216e-02f,
  2.19633192e-01f, 1.26799047e-01f, -1.87030181e-01f, -1.48174644e-01f, 1.02672249e-01f, 2.40756832e-02f, -1.63828488e-02f, -1.39310071e-02f, -1.18369947e-03f, 5.75302467e-02f,
  8.14019963e-02f, 6.01006076e-02f, -8.25551059e-03f, -1.78115889e-02f, -1.12513952e-01f, 2.39764191e-02f, -1.17743902e-01f, -1.32867351e-01f, 8.54930058e-02f, -1.23675540e-02f,
  -1.09800957e-01f, 9.41682607e-03f, 5.01902513e-02f, 2.33536828e-02f, 6.72918931e-02f, 6.27673641e-02f, 7.16065466e-02f, 5.01041971e-02f, -8.30136985e-02f, 3.16491611e-02f,
  1.05135171e-02f, -1.96636952e-02f, 8.00596625e-02f, -1.14650242e-01f, 5.25069907e-02f, 1.87419318e-02f, -3.27288583e-02f, -1.27949389e-02f, -1.11254163e-01f, 4.84445458e-03f,
  -1.00156888e-01f, -1.20383617e-03f, -4.85404953e-02f, 5.22899581e-03f, 2.32031643e-02f, 5.36751598e-02f, 6.53533489e-02f, -4.72985059e-02f, 2.96559036e-02f, 3.51712033e-02f,
  1.38999093e-02f, 4.19925749e-02f, 1.21918716e-01f, 2.50949580e-02f, -3.89355645e-02f, -7.48824514e-03f, 5.26397489e-02f, 6.58949763e-02f, 3.68238688e-02f, -1.82360748e-03f,
  5.11975512e-02f, 4.77587208e-02f, 2.36117691e-02f, 2.10998338e-02f, -1.33937299e-01f, -1.60955600e-02f, 1.77231748e-02f, 9.81224254e-02f, -2.72327866e-02f, 2.50409860e-02f,
  4.41945307e-02f, -1.41124561e-01f, -5.07149398e-02f, -1.35294065e-01f, 6.23948686e-03f, 2.52172258e-02f, -4.80995476e-02f, 4.22510467e-02f, 7.81021267e-02f, -1.68339927e-02f,
  1.08196372e-02f, -6.33808412e-03f, -6.86182976e-02f, -6.46888465e-02f, -4.57818881e-02f, -1.45315761e-02f, -7.04095885e-02f, 2.63940040e-02f, -7.04346225e-02f, -8.65585282e-02f,
  -1.52769173e-03f, 9.62602813e-03f, 1.89202558e-02f, 5.82791679e-02f, 1.88957956e-02f, -7.34564215e-02f, -2.92878901e-03f, -4.69107032e-02f, -1.10072549e-02f, 1.09381370e-01f,
  -3.54131132e-01f, 1.37734264e-01f, -2.76679266e-02f, 2.67551839e-01f, -1.26245633e-01f, -2.76536912e-01f, -1.89636901e-01f, 4.61744145e-02f, 8.27880111e-03f, 3.18787470e-02f,
  2.90004094e-03f, 7.81462640e-02f, 8.77894387e-02f, 2.43387923e-01f, 1.14078857e-01f, 1.09708436e-01f, 6.67058825e-02f, -6.30400702e-02f, 1.32702412e-02f, 1.23017684e-01f,
  1.26470551e-01f, 1.41456693e-01f, 1.72354147e-01f, 1.51503876e-01f, 1.74946696e-01f, 1.44516766e-01f, 2.43530124e-01f, 1.22773767e-01f, 8.52557793e-02f, 5.35965413e-02f,
  -3.28632034e-02f, 9.62764956e-04f, 7.16877729e-02f, 5.64985648e-02f, -3.87844928e-02f, -6.81426153e-02f, -3.91736664e-02f, 1.29997209e-02f, 3.68560255e-02f, 4.88068238e-02f,
  2.95413714e-02f, 1.92767605e-02f, 1.53568611e-02f, 2.26540584e-02f, -7.67592043e-02f, 6.59039896e-03f, -6.33802265e-02f, -5.04360395e-03f, 3.97386961e-03f, 2.73462255e-02f,
  -1.02040097e-01f, -4.06169370e-02f, 1.11849019e-02f, -5.02829701e-02f, -4.18951139e-02f, 3.67330946e-02f, -2.82019330e-03f, 3.67694981e-02f, -6.97262213e-02f, 4.45232429e-02f,
  -5.16724959e-02f, 7.15364004e-03f, -5.48840798e-02f, 4.92112041e-02f, 9.27362368e-02f, 8.16225410e-02f, -5.40544791e-03f, 7.23963901e-02f, -1.51387798e-02f, 9.68185440e-02f,
  1.20713249e-01f, 7.36756176e-02f, 1.57301109e-02f, -1.97685417e-02f, 4.24695089e-02f, 3.44995931e-02f, -2.71115489e-02f, 9.32345092e-02f, 2.21118592e-02f, -2.34046346e-03f,
  1.24025747e-01f, 1.90968886e-02f, 2.55684685e-02f, -8.11758712e-02f, 8.42339471e-02f, 3.09076905e-03f, -1.47020118e-02f, -2.90785693e-02f, 8.99405554e-02f, -1.33093178e-01f,
  1.72509238e-01f, 1.47093028e-01f, -6.99054971e-02f, -8.45433697e-02f, 9.83720645e-02f, -7.55330324e-02f, -1.61152016e-02f, -2.60158032e-02f, -8.13000426e-02f, 1.46018332e-02f,
  5.81218638e-02f, 7.67788664e-02f, 2.32412163e-02f, -1.66770574e-02f, -5.55856014e-03f, -8.71288707e-04f, 1.10623054e-01f, 2.23235805e-02f, 1.19721629e-01f, 1.38438687e-01f,
  4.06016819e-02f, -1.07553072e-01f, 9.71758813e-02f, -7.67729580e-02f, 3.01583968e-02f, 2.62804385e-02f, -2.45586000e-02f, -1.89367291e-02f, -1.10093102e-01f, -6.49614492e-03f,
  -2.39425093e-01f, 1.62215322e-01f, -1.54686734e-01f, 6.93472996e-02f, 3.39010894e-01f, -6.95308819e-02f, -2.55738288e-01f, 1.27410978e-01f, -1.02291226e-01f, 2.49111913e-02f,
  1.78730309e-01f, 2.41540838e-02f, -2.78731376e-01f, 3.14556181e-01f, 1.62373018e-02f, -2.19208777e-01f, 3.49660754e-01f, 1.46758974e-01f, 4.91848476e-02f, 3.31978351e-02f,
  -3.78858000e-02f, 2.04423130e-01f, -8.49652141e-02f, 2.97174990e-01f, -1.64947324e-02f, -9.59722772e-02f, 5.15613854e-02f, -2.28951320e-01f, 1.83681220e-01f, 1.17685176e-01f,
  -1.40116066e-01f, -1.54392198e-01f, -3.84699851e-02f, -1.39789402e-01f, -1.29260466e-01f, -1.15108266e-01f, -1.85283020e-01f, 7.91938752e-02f, -3.67913321e-02f, 1.32817980e-02f,
  -1.11464955e-01f, 3.78887467e-02f, 5.18805571e-02f, 1.48078548e-02f, 5.38662001e-02f, -1.41526619e-02f, 6.78543672e-02f, -8.46180022e-02f, 6.79319948e-02f, -7.24906176e-02f,
  6.21178595e-04f, 7.77294487e-02f, -4.56343376e-04f, 5.44044189e-02f, -8.15359429e-02f, -9.14217718e-03f, -6.39668712e-03f, -6.79866178e-03f, 8.56925175e-02f, 3.37582156e-02f,
  9.24061239e-02f, -3.45558524e-02f, 1.31258108e-02f, -1.97804309e-02f, -5.87327741e-02f, -1.32405823e-02f, 5.00681512e-02f, 3.68958227e-02f, -1.37036905e-01f, 1.08825490e-02f,
  5.57845235e-02f, -5.72516285e-02f, 3.21394093e-02f, -1.26140518e-02f, -5.12234345e-02f, -1.11498060e-02f, 2.64339801e-02f, -4.22276445e-02f, 1.43721495e-02f, 3.20023075e-02f,
  -1.12171754e-01f, 3.48861516e-02f, -5.17888814e-02f, -4.06754948e-02f, 1.27516910e-01f, -8.78044814e-02f, 1.35386577e-02f, -1.41718954e-01f, -3.97637375e-02f, -9.57513880e-03f,
  -3.16078573e-01f, -2.23016545e-01f, -6.61913399e-03f, 1.69497263e-02f, -3.59106399e-02f, 3.06813363e-02f, -4.26461026e-02f, -5.75830825e-02f, -7.38016814e-02f, 4.93942481e-03f,
  2.08599772e-03f, 2.06308980e-02f, 9.35722142e-03f, -7.07415910e-03f, 8.76700133e-02f, -6.34880513e-02f, -1.16024017e-01f, -1.38753176e-01f, -3.41412760e-02f, 1.04667656e-02f,
  -6.31269887e-02f, -6.57080486e-02f, 6.63591400e-02f, 2.07457654e-02f, 2.08936054e-02f, -5.30082397e-02f, 6.47926820e-04f, -1.66813955e-02f, 4.40944284e-02f, 6.29816875e-02f,
  -2.15741340e-02f, 4.05450493e-01f, -5.33615276e-02f, 1.33576572e-01f, -1.14445098e-01f, 4.14029270e-01f, 3.87131602e-01f, -7.78690651e-02f, 2.34221086e-01f, 3.44722033e-01f,
  1.01059474e-01f, 8.23071003e-02f, 6.34919479e-02f, 1.76805764e-01f, 1.63735613e-01f, 1.13766372e-01f, 2.65908688e-01f, 2.20872268e-01f, -1.36810988e-02f, 1.29800946e-01f,
  -1.10270634e-01f, 2.36736238e-01f, -2.14997783e-01f, -9.81991813e-02f, -1.07702361e-02f, -1.45351335e-01f, -1.94864765e-01f, -2.76805997e-01f, -1.59284428e-01f, 4.15508170e-03f,
  4.73973118e-02f, -8.16322863e-02f, -1.09994590e-01f, 2.11491603e-02f, 1.68325640e-02f, -8.64105299e-02f, -1.37551269e-03f, -5.08657023e-02f, -1.90809622e-01f, -1.40018817e-02f,
  5.43314554e-02f, -5.33115864e-03f, 9.54200253e-02f, -1.32444939e-02f, -5.07185012e-02f, -9.60769653e-02f, 2.62160152e-02f, -7.13551044e-02f, 1.66950189e-02f, -4.80943322e-02f,
  3.60683203e-02f, 3.53996567e-02f, 3.47065181e-02f, 5.81220239e-02f, 1.91855233e-03f, -7.73200160e-03f, 2.82760020e-02f, -2.34320592e-02f, 9.01390612e-02f, 1.13680668e-01f,
  -5.67576056e-03f, 6.35243729e-02f, 5.60941435e-02f, 2.92057241e-03f, 9.06008575e-03f, 2.04269048e-02f, 2.17299797e-02f, -9.76908505e-02f, -4.21626158e-02f, 6.73797131e-02f,
  6.14355877e-02f, -4.14395742e-02f, 1.00696012e-01f, 4.94757369e-02f, 8.55041854e-03f, -9.62858200e-02f, -3.68678831e-02f, -4.57322448e-02f, -1.16032502e-02f, -6.85709864e-02f,
  -5.49558625e-02f, 3.91843766e-02f, 5.33134080e-02f, 1.11976056e-03f, -5.05596176e-02f, -9.26323682e-02f, -1.82626974e-02f, -1.04574729e-02f, -2.32422147e-02f, -6.13533240e-03f,
  1.71001107e-01f, 2.50945240e-01f, 1.04357943e-01f, 1.99112389e-02f, -4.69408296e-02f, 4.21848744e-02f, -3.61311026e-02f, -8.26223101e-03f, 1.14523962e-01f, 3.24664190e-02f,
  6.16259836e-02f, 1.11905113e-01f, 1.09286971e-01f, -6.29027933e-02f, 3.10020801e-02f, 1.47787362e-01f, 4.84154187e-02f, -4.29084562e-02f, 8.36746916e-02f, -2.67019048e-02f,
  -5.44843785e-02f, 1.04170516e-01f, 1.07114442e-01f, 9.66148674e-02f, 1.19345702e-01f, 1.15249723e-01f, 6.35525361e-02f, -9.29667242e-03f, 6.80649132e-02f, 1.32737190e-01f,
  3.11661482e-01f, 1.78480558e-02f, -2.87487388e-01f, 7.07500577e-02f, -1.73930582e-02f, 3.25015694e-01f, 3.14080864e-01f, 7.46480562e-03f, 5.54944836e-02f, 1.39012128e-01f,
  1.44177079e-01f, 2.69878432e-02f, 1.69085890e-01f, 2.34159514e-01f, 2.16545314e-01f, 8.23787600e-02f, 3.54754806e-01f, 1.30164981e-01f, -1.40734047e-01f, 8.91788229e-02f,
  9.14580747e-02f, 3.13127458e-01f, -2.64469296e-01f, -5.15226610e-02f, 1.45023197e-01f, -3.49096656e-01f, -1.12797596e-01f, -9.72017869e-02f, -1.27497643e-01f, -1.20708629e-01f,
  4.96585369e-02f, 5.84308244e-02f, -8.92718211e-02f, 4.20412123e-02f, 3.23088467e-02f, 1.16787225e-01f, -2.81785596e-02f, -5.85937425e-02f, -9.22770500e-02f, -2.48463620e-02f,
  9.41282362e-02f, -1.70282535e-02f, 6.16078125e-03f, -8.34808350e-02f, 1.04483761e-01f, -3.45104747e-02f, -1.59840658e-01f, -4.71909046e-02f, -4.18121926e-02f, -2.84315385e-02f,
  -1.19115792e-01f, 3.07342671e-02f, -3.68002430e-02f, -1.34815097e-01f, -5.44199422e-02f, -1.49623463e-02f, -6.00120910e-02f, -1.54722348e-01f, 2.93459315e-02f, 2.06898749e-02f,
  -2.46381573e-02f, 1.06515221e-01f, 6.45766109e-02f, 1.91238485e-02f, 2.65750494e-02f, -4.58471775e-02f, 9.07145068e-02f, -6.93175569e-02f, -6.03889264e-02f, -3.12590897e-02f,
  -4.06555347e-02f, 2.48636641e-02f, 2.86187720e-03f, 4.92564626e-02f, 2.92415246e-02f, 6.38755858e-02f, -5.19712940e-02f, -1.99349858e-02f, -7.97841400e-02f, 8.05541966e-03f,
  1.89383216e-02f, 1.18106827e-01f, -1.06556468e-01f, 6.22462556e-02f, -3.78202498e-02f, -3.56526449e-02f, 1.12352826e-01f, -4.29421812e-02f, -5.68333492e-02f, 7.08624944e-02f,
  8.17843080e-02f, 5.31136356e-02f, -7.66262636e-02f, 1.36402743e-02f, 1.76106056e-03f, 7.79506341e-02f, 2.50789035e-05f, 1.29347155e-02f, -8.39607976e-03f, 5.98584898e-02f,
  -4.96175364e-02f, -6.08056523e-02f, 1.41991973e-01f, -1.62307069e-01f, 1.09684244e-02f, 6.47033080e-02f, 1.56756453e-02f, -3.26832198e-02f, 7.81344995e-02f, 3.68476547e-02f,
  -3.37035283e-02f, 4.00845446e-02f, 4.65374589e-02f, -5.66195883e-02f, -2.39957850e-02f, -7.02781230e-02f, 4.91617993e-02f, 2.81628650e-02f, 1.64706763e-02f, -8.32432359e-02f,
  4.14383560e-01f, -2.24797741e-01f, 3.60726267e-02f, 1.88657135e-01f, 1.90295070e-01f, -1.25550017e-01f, 2.30753154e-01f, -2.30314627e-01f, 1.58636689e-01f, -2.99739122e-01f,
  -8.28220025e-02f, 1.16125889e-01f, 9.99098178e-03f, -1.37329698e-01f, 2.50808388e-01f, 1.23244955e-03f, -1.25997782e-01f, 6.59908950e-02f, -3.36756278e-03f, -1.09454483e-01f,
  1.37364790e-01f, -1.80693403e-01f, 6.87045306e-02f, -2.85791934e-01f, 5.47914803e-02f, 5.19561544e-02f, -2.59571914e-02f, 8.27961266e-02f, -2.81827867e-01f, -9.35504287e-02f,
  1.06209656e-02f, -4.79186140e-02f, -1.86288487e-02f, -6.24535866e-02f, 8.96384344e-02f, 6.20220229e-02f, 8.53380039e-02f, 4.34144661e-02f, 6.16039149e-02f, 3.16881761e-02f,
  -2.05695741e-02f, -5.64829744e-02f, -1.15666154e-03f, 3.52704003e-02f, -5.71116656e-02f, -4.28815521e-02f, 1.18198015e-01f, -1.20452568e-02f, -5.46442941e-02f, 2.42345277e-02f,
  1.02401450e-01f, 7.91575701e-04f, 6.30821288e-02f, 3.76011282e-02f, 9.50045288e-02f, 6.23745918e-02f, -1.01726659e-01f, 1.20510496e-01f, 2.39773076e-02f, 6.91609085e-03f,
  -4.79909182e-02f, 7.31907692e-03f, 2.42935717e-02f, -1.62047073e-02f, 4.57692891e-02f, -9.46359802e-03f, 1.64445490e-02f, -6.33082390e-02f, 5.02709905e-03f, -8.54188353e-02f,
  3.58898416e-02f, 5.21647125e-05f, -9.50406566e-02f, 8.47795457e-02f, -1.43752657e-02f, -2.35794242e-02f, -3.10859717e-02f, -4.39100266e-02f, 1.62210494e-01f, -4.32875678e-02f,
  4.00046222e-02f, -6.44202456e-02f, -4.32179086e-02f, -7.46027231e-02f, 1.00807644e-01f, 7.98186362e-02f, -1.28864720e-01f, 9.94221866e-03f, 3.16124633e-02f, -6.03977367e-02f,
  -1.10137939e-01f, -2.13723868e-01f, 5.74748740e-02f, -1.71800569e-01f, -7.04048807e-03f, -8.44273418e-02f, -5.08196168e-02f, -1.18969530e-01f, -6.44028485e-02f, -5.41897267e-02f,
  3.93438451e-02f, -1.08661065e-02f, 8.90525654e-02f, -6.46814704e-02f, 6.70480430e-02f, -1.21638253e-01f, -1.36787654e-03f, 2.69641541e-03f, 3.06760594e-02f, -1.24518521e-01f,
  -1.43531673e-02f, -5.45012057e-02f, 2.85518765e-02f, 1.71818957e-02f, -1.31459406e-03f, 1.26855820e-02f, -1.82169527e-02f, 4.51261550e-02f, -5.63524626e-02f, -9.05482918e-02f,
  -4.88611944e-02f, 2.56138742e-01f, -3.25966179e-02f, -1.85041562e-01f, 4.31046188e-02f, -3.64334613e-01f, -1.43572092e-01f, 9.34914201e-02f, 1.11994199e-01f, 2.33185932e-01f,
  -9.25477594e-02f, -2.00468046e-03f, -4.21225801e-02f, -2.78366894e-01f, -5.87578893e-01f, -2.09822118e-01f, -3.05626690e-01f, -1.45304143e-01f, -5.06247766e-02f, 2.58009378e-02f,
  -1.90880060e-01f, -1.19586319e-01f, -2.65925318e-01f, 1.04311235e-01f, -3.17146741e-02f, 2.91140020e-01f, 2.11268682e-02f, 2.03954563e-01f, -7.86081031e-02f, -1.12320818e-01f,
  -3.70542035e-02f, 1.17583290e-01f, 8.01110119e-02f, -1.32093355e-02f, -1.10769652e-01f, -2.48908009e-02f, -2.45581865e-02f, -2.78156176e-02f, 4.16832939e-02f, -2.57260874e-02f,
  4.15643826e-02f, 1.07691931e-02f, -3.31780389e-02f, 5.17173968e-02f, 1.21846206e-01f, -2.32254378e-02f, -4.07524481e-02f, 5.08130938e-02f, 2.54037697e-02f, 1.08207017e-03f,
  5.68155479e-03f, -7.17976764e-02f, -5.97565286e-02f, 2.03505013e-04f, 2.50653550e-02f, -7.05743656e-02f, -3.29885334e-02f, -7.67300725e-02f, -1.26824215e-01f, 1.19078662e-02f,
  -4.76960950e-02f, -3.00328247e-02f, -9.57512558e-02f, 6.05842695e-02f, -4.57208045e-02f, 3.32749709e-02f, 1.47168450e-02f, 6.05342118e-03f, 4.46721725e-02f, 1.92135796e-02f,
  -4.02734503e-02f, 4.39659283e-02f, 1.16456980e-02f, 3.79271731e-02f, -2.96680517e-02f, 1.93843022e-02f, 1.42124901e-02f, -1.39235174e-02f, -1.10476471e-01f, -6.26045018e-02f,
  7.28442147e-02f, -2.92124506e-02f, 5.10771647e-02f, -9.97882411e-02f, -1.33793861e-01f, -4.56306450e-02f, 8.13469887e-02f, 5.82438558e-02f, 4.33799438e-02f, 2.85972934e-02f,
  -2.44812807e-03f, 4.37008068e-02f, 9.35140997e-02f, 1.30672425e-01f, 7.24650621e-02f, -1.00695759e-01f, 5.98336086e-02f, -6.59762044e-03f, 4.42429259e-02f, -2.93744449e-02f,
  2.61544436e-02f, 1.95099358e-02f, 1.38074812e-02f, -1.39512224e-02f, 7.48401508e-02f, -8.67567733e-02f, -8.96621402e-03f, -1.04725193e-02f, 5.15365675e-02f, -1.06893137e-01f,
  4.78691943e-02f, 1.13539070e-01f, -4.59540151e-02f, 3.02595403e-02f, 2.02949867e-02f, 5.41694276e-03f, -3.45873348e-02f, 1.04678698e-01f, 7.41589516e-02f, -9.13945213e-02f,
  1.45668745e-01f, -2.91737765e-01f, -4.28881161e-02f, -1.31224450e-02f, 1.17970489e-01f, -2.37539355e-02f, 1.28774971e-01f, -1.54352769e-01f, 1.71757147e-01f, -2.14696765e-01f,
  -1.51642300e-02f, -8.49618614e-02f, 2.03722894e-01f, -3.20787221e-01f, 2.68871933e-01f, -1.49048101e-02f, -2.11195663e-01f, -1.11734979e-01f, 8.63012299e-02f, 1.81274414e-02f,
  1.38451293e-01f, -1.44569591e-01f, 4.80666645e-02f, -2.05625460e-01f, -1.85914814e-01f, -1.02611594e-01f, -1.56879678e-01f, -2.63115130e-02f, -2.97525972e-01f, 1.79355349e-02f,
  1.82803422e-02f, -4.86176722e-02f, -6.79295808e-02f, -1.61697015e-01f, -6.63036332e-02f, -7.48983473e-02f, -1.07349485e-01f, -1.58970971e-02f, 5.46941310e-02f, 9.52964574e-02f,
  9.45834070e-02f, 5.45380339e-02f, -2.83639506e-02f, 4.43889312e-02f, -1.84801966e-02f, -5.60578667e-02f, 6.10854328e-02f, -7.38603324e-02f, -4.89092879e-02f, -3.56021337e-02f,
  6.77508786e-02f, -4.42830212e-02f, -2.78181415e-02f, -1.01092517e-01f, -7.27846697e-02f, -1.09013438e-01f, 8.33645463e-02f, -8.86369124e-03f, -3.84719372e-02f, 4.38587321e-03f,
  -5.10583585e-03f, 3.17812525e-02f, 4.77969609e-02f, -1.02073520e-01f, -6.14029951e-02f, 8.22841376e-02f, -4.18216251e-02f, -6.81339800e-02f, 5.51778227e-02f, 7.04613402e-02f,
  1.74583383e-02f, -2.11296268e-02f, 4.52164486e-02f, -8.30683783e-02f, -3.94700393e-02f, -7.36453533e-02f, -6.79165199e-02f, 7.75110535e-03f, -3.88303236e-03f, 3.34157422e-02f,
  4.15088944e-02f, -3.49859241e-03f, -1.08651459e-01f, -5.62169366e-02f, 3.81710380e-02f, -5.42648025e-02f, 1.96302515e-02f, -4.35733236e-02f, 7.02343658e-02f, 1.55713081e-01f,
  -1.28915101e-01f, -1.42834172e-01f, -7.84396976e-02f, 4.89100553e-02f, -1.39889851e-01f, -1.66787624e-01f, -3.88139375e-02f, -4.57672263e-03f, -7.42390975e-02f, -4.16516475e-02f,
  5.22994995e-02f, -2.54498944e-02f, -9.60588455e-02f, 7.61872604e-02f, -3.95526402e-02f, -5.01483753e-02f, 8.06097463e-02f, 6.03534281e-02f, -5.99086992e-02f, 5.58296070e-02f,
  8.84779021e-02f, 9.75698978e-02f, 3.05492990e-02f, 6.33756667e-02f, 4.11063731e-02f, 2.94942688e-02f, 1.56602468e-02f, 1.37020992e-02f, -2.24562697e-02f, -6.04086835e-03f,
  9.61998329e-02f, -3.96147758e-01f, -3.02933216e-01f, -1.37862757e-01f, 5.65641373e-02f, -3.95271480e-01f, -3.97941291e-01f, -1.04587466e-01f, 7.37097627e-03f, -7.37210736e-02f,
  -6.37127012e-02f, -6.25151396e-02f, -1.57396182e-01f, -2.18951389e-01f, 9.10515524e-03f, -7.62617439e-02f, -1.33640602e-01f, 5.94845489e-02f, 6.15182482e-02f, -1.98345125e-01f,
  -6.44317940e-02f, -4.50206883e-02f, -1.81095093e-01f, 4.21627387e-02f, -1.55091956e-02f, -4.98282611e-02f, 2.86788404e-01f, -1.42842531e-01f, 5.97856194e-02f, -7.08863065e-02f,
  -7.56257251e-02f, -1.46238685e-01f, -2.53901072e-02f, -7.24856257e-02f, -9.25401673e-02f, 5.53538762e-02f, 1.14961229e-02f, 5.75886331e-02f, -1.68531127e-02f, 7.89367333e-02f,
  -4.95478585e-02f, -5.23237512e-02f, 6.04723543e-02f, -5.01982355e-03f, 4.64072004e-02f, -3.72233540e-02f, -5.29799573e-02f, 8.09266791e-02f, 2.49866713e-02f, -4.91105765e-02f,
  -2.16406897e-01f, 5.39608635e-02f, -5.24482615e-02f, 1.15608668e-03f, -9.24764052e-02f, -9.28788483e-02f, 1.67932343e-02f, -3.57368700e-02f, 8.82305801e-02f, -4.36287560e-03f,
  -6.05169535e-02f, 6.63540736e-02f, -9.12693702e-03f, -2.88063362e-02f, 2.20793043e-03f, -4.71563451e-02f, -9.04999599e-02f, 4.92683575e-02f, 6.35904819e-02f, -6.30959519e-04f,
  -7.54050538e-02f, -1.15090147e-01f, 7.37253800e-02f, -4.46904227e-02f, 3.19191366e-02f, 5.19005433e-02f, 2.13824492e-02f, -2.36515943e-02f, -1.40871421e-01f, 6.07128516e-02f,
  -1.34982998e-02f, 1.61795169e-01f, -9.07848701e-02f, 1.38886765e-01f, -2.41115950e-02f, -2.73681525e-02f, 6.37368560e-02f, 2.65902709e-02f, -1.21138535e-01f, -2.12223288e-02f,
  -7.19475895e-02f, -1.41903967e-01f, 2.83225486e-03f, 3.17146368e-02f, -1.03702120e-01f, 8.51084405e-05f, -8.99354219e-02f, -1.72880992e-01f, 1.74636021e-02f, 5.70018105e-02f,
  4.75375243e-02f, 1.66131817e-02f, 1.80370241e-01f, -6.06024042e-02f, 6.62176833e-02f, -1.73339084e-01f, -9.16683674e-03f, 9.33903530e-02f, 1.13091625e-01f, -3.44552696e-02f,
  -1.67014692e-02f, 4.62024063e-02f, 1.63759887e-02f, -9.32050943e-02f, 7.14969859e-02f, 3.93099487e-02f, -9.30481479e-02f, -2.28172038e-02f, 5.12547307e-02f, 1.11257747e-01f,
  5.05190268e-02f, -1.49113715e-01f, -6.23737983e-02f, -2.14204341e-01f, 1.11061059e-01f, -1.14713512e-01f, -8.17608610e-02f, -2.74757743e-01f, 1.04831578e-02f, -1.81100994e-01f,
  -1.51904568e-01f, 2.35595345e-01f, 2.71586657e-01f, -1.62584811e-01f, 2.89210945e-01f, 2.05543190e-01f, -3.39027494e-01f, -2.07648471e-01f, 3.77468467e-02f, -2.97086120e-01f,
  -1.43183172e-01f, -2.68378407e-01f, 1.29448220e-01f, -1.88904375e-01f, -1.66255921e-01f, -1.25764370e-01f, 1.26217932e-01f, 9.27960426e-02f, -3.18912297e-01f, 4.65028733e-02f,
  -2.94856410e-02f, 5.12283705e-02f, -1.26326725e-01f, 7.91891292e-02f, -9.17622522e-02f, -2.11392175e-02f, -3.88098471e-02f, 1.16042495e-01f, 3.87211971e-04f, 2.26553921e-02f,
  1.06692202e-02f, 5.22563346e-02f, -6.55290261e-02f, 5.24172299e-02f, -9.89104584e-02f, -2.27866378e-02f, -5.36657274e-02f, 3.80100426e-03f, 1.36791347e-02f, 3.38923093e-03f,
  4.58539836e-02f, -6.46775663e-02f, -1.54020727e-01f, 6.34074360e-02f, 7.17248991e-02f, -4.58708666e-02f, -1.09827369e-02f, 1.02356069e-01f, 5.36444895e-02f, 1.91614591e-02f,
  -1.55455747e-03f, 7.18841627e-02f, -1.54960416e-02f, -1.15264244e-02f, 1.58358850e-02f, -1.37354255e-01f, -6.61064163e-02f, 4.87936884e-02f, -2.04265285e-02f, -6.04908653e-02f,
  3.30140665e-02f, 5.41550778e-02f, -5.47314659e-02f, -8.94906223e-02f, 2.72769528e-03f, 2.73133907e-02f, 1.08516872e-01f, 2.98041236e-02f, -5.59259914e-02f, -5.25789931e-02f,
  -7.58194327e-02f, -8.61210525e-02f, 1.03312992e-01f, 5.07445028e-03f, 1.74193084e-02f, 3.87136303e-02f, 2.08279118e-02f, -4.02286015e-02f, 7.71169513e-02f, 3.17873918e-02f,
  1.13629727e-02f, 2.16250420e-02f, -1.81850959e-02f, 6.85726777e-02f, 5.59612513e-02f, -3.28281820e-02f, -7.54813701e-02f, -1.51857898e-01f, 3.20596769e-02f, 2.01830655e-04f,
  -2.38587931e-01f, 1.77719295e-01f, 2.82169003e-02f, -3.50142247e-03f, 2.78798994e-02f, -1.97629929e-02f, -4.68983799e-02f, 1.09724462e-01f, 5.87272756e-02f, 2.65232450e-03f,
  -1.18388213e-01f, 3.92509401e-02f, 2.80932710e-02f, 1.06114587e-02f, -4.15026676e-03f, -8.91080499e-02f, -5.64610697e-02f, -3.20647284e-02f, 1.83001440e-02f, -2.48503704e-02f,
  -3.62566501e-01f, 1.95844591e-01f, -1.71872810e-01f, -1.65493578e-01f, -1.89816117e-01f, -1.24980211e-01f, 1.22976499e-02f, -2.12579295e-01f, -9.94481728e-04f, -5.96517958e-02f,
  -2.09313348e-01f, -2.85888538e-02f, 2.63675209e-02f, -8.05435702e-02f, 8.11696500e-02f, 2.72718102e-01f, -8.49315971e-02f, 2.40136757e-02f, 1.43050462e-01f, -3.04273993e-01f,
  5.34328297e-02f, -1.59470677e-01f, 1.35761881e-02f, -1.54346138e-01f, -3.52277070e-01f, -9.43879709e-02f, 4.24924269e-02f, -9.11751315e-02f, -1.53616980e-01f, -1.08963609e-01f,
  -3.65914106e-01f, -4.08417314e-01f, -3.13653976e-01f, -9.97326002e-02f, -1.38883278e-01f, -1.52719200e-01f, -8.01283717e-02f, -2.39353813e-02f, -8.39915127e-02f, -2.11072974e-02f,
  -1.21285073e-01f, -5.86142391e-02f, 3.97298113e-02f, 8.08464587e-02f, -1.35677755e-02f, -1.20281070e-01f, 6.02373341e-03f, -1.66315570e-01f, 1.51606323e-02f, 3.77685986e-02f,
  -4.39401083e-02f, -8.59681889e-02f, -1.71526358e-01f, 2.64913514e-02f, -4.61016409e-02f, -1.07554890e-01f, -1.91124678e-02f, 3.20723243e-02f, -9.75246429e-02f, 1.38288345e-02f,
  -5.44849457e-03f, 2.17908010e-01f, -3.10559478e-02f, 2.53339726e-02f, -5.01617044e-02f, -8.97591338e-02f, -2.56345491e-03f, 3.00449282e-02f, -1.00493403e-02f, -5.74619882e-02f,
  -4.69256081e-02f, -4.75913025e-02f, 4.50258609e-03f, 8.66834000e-02f, -1.39401732e-02f, -7.63178021e-02f, -1.93283800e-02f, -1.15217470e-01f, -2.81821657e-02f, -8.06416646e-02f,
  -5.00180833e-02f, 4.68502194e-02f, 2.86381766e-02f, -8.72425437e-02f, -8.53539631e-02f, 8.03662017e-02f, -8.38381648e-02f, 1.05636232e-01f, 3.94125422e-03f, -4.67292182e-02f,
  -1.83298603e-01f, -7.03315064e-02f, -4.02354123e-03f, -1.56978235e-01f, -1.40546206e-02f, -7.92971328e-02f, 1.73412040e-01f, 2.56505739e-02f, -3.08888629e-02f, -3.33001092e-02f,
  -4.79838848e-02f, 1.41087016e-02f, -8.60378295e-02f, 1.13936299e-02f, 8.84460285e-02f, -3.69747728e-02f, -1.13004833e-01f, 9.02894011e-04f, -4.18946557e-02f, -8.56336802e-02f,
  3.07291802e-02f, 8.60875919e-02f, 1.53010383e-01f, -6.30561123e-03f, -2.68071108e-02f, -2.75443736e-02f, -5.38935736e-02f, -1.05393650e-02f, -5.65447733e-02f, 1.18288182e-01f,
  2.81649381e-01f, -3.77754010e-02f, 1.88443050e-01f, 1.74709424e-01f, 1.72023013e-01f, 2.57251859e-01f, 4.19536084e-01f, 1.04433276e-01f, 2.46318728e-01f, -7.23323226e-02f,
  -7.64876455e-02f, 2.05218066e-02f, 9.64068100e-02f, -6.85561225e-02f, 2.84739226e-01f, 1.49627224e-01f, 1.75376058e-01f, 8.53198394e-02f, 9.74608138e-02f, 4.36077490e-02f,
  6.10115565e-02f, -1.14141162e-02f, -2.94823740e-02f, -2.32172921e-01f, -5.93675673e-02f, -2.29680076e-01f, -1.99654356e-01f, 1.49929494e-01f, -1.89431071e-01f, 1.17529608e-01f,
  5.44575006e-02f, -3.73913860e-03f, -6.13203123e-02f, -7.07020834e-02f, 4.69092838e-02f, -7.93111399e-02f, 1.05356611e-01f, 1.60444260e-01f, 4.12919782e-02f, -2.72128675e-02f,
  -5.33591583e-02f, 1.83050316e-02f, -5.11975512e-02f, 7.39303976e-02f, 5.35189323e-02f, -8.54801089e-02f, 1.04665011e-02f, -1.59482941e-01f, 1.15492521e-02f, 2.55476423e-02f,
  -1.03375256e-01f, 5.36954543e-03f, 1.10909171e-01f, -5.02955765e-02f, -3.18437926e-02f, 4.40105423e-02f, 3.35217826e-02f, 1.10622868e-01f, 5.38605079e-02f, -1.20393035e-03f,
  -6.44590799e-03f, 8.50325450e-02f, -7.13592023e-02f, -6.44544885e-02f, 6.50218455e-03f, -1.40730038e-01f, 6.64198846e-02f, 8.25187489e-02f, 9.80411693e-02f, 3.40416864e-03f,
  -6.28743172e-02f, 6.20590039e-02f, 9.55364946e-03f, 3.92511860e-02f, 1.65283799e-01f, -1.27509027e-03f, 9.04716924e-03f, 2.40097307e-02f, -8.50757062e-02f, 3.18197906e-02f,
  6.66233227e-02f, 4.93687838e-02f, -3.01008150e-02f, 1.60156582e-02f, 5.78873418e-02f, 7.51489997e-02f, -7.31030703e-02f, -5.32507077e-02f, -3.70415561e-02f, 4.06545885e-02f,
  -7.87501130e-03f, 1.59271106e-01f, -6.94710389e-02f, -8.12111720e-02f, -7.28837177e-02f, -2.03458562e-01f, 7.13630989e-02f, 5.98337688e-03f, 4.06716106e-04f, 3.13682482e-02f,
  -7.85195678e-02f, -4.00344655e-02f, 2.24092864e-02f, 1.14124365e-01f, -9.10835993e-03f, 3.42004225e-02f, -3.58586758e-02f, -4.76653315e-02f, -9.73768979e-02f, -8.07504281e-02f,
  -9.02735218e-02f, -5.87671213e-02f, -3.19367759e-02f, -9.90598276e-02f, -8.00928622e-02f, 9.92148444e-02f, -7.29666054e-02f, 4.96166348e-02f, -8.81383941e-03f, 7.14596212e-02f,
  -2.64075309e-01f, 6.15948532e-03f, -5.84824849e-03f, 3.62042785e-01f, -4.23843116e-02f, -1.58180639e-01f, -1.51635602e-01f, 3.56211476e-02f, -8.21944848e-02f, 3.19458619e-02f,
  4.01942544e-02f, -2.89474558e-02f, -1.22841679e-01f, 2.71621943e-01f, 1.46005647e-02f, 1.32742986e-01f, 1.73746198e-01f, 5.26758209e-02f, -2.37772614e-02f, 2.26682164e-02f,
  1.37865648e-01f, 1.71089038e-01f, 1.85953602e-01f, -1.80449635e-02f, -6.00854866e-02f, 4.37873639e-02f, 7.41585344e-02f, -3.10161393e-02f, 1.08818151e-01f, -1.95288863e-02f,
  3.03338803e-02f, -7.26231486e-02f, -4.76395572e-03f, 7.19598010e-02f, -2.66720746e-02f, -1.01415947e-01f, 1.10055711e-02f, 4.16554417e-03f, -1.56886391e-02f, -2.86625549e-02f,
  -1.86733510e-02f, 1.97959343e-06f, -9.04791895e-03f, -4.35258932e-02f, -6.95944205e-02f, 6.26284257e-02f, -3.84672992e-02f, -2.58708838e-02f, 1.49973556e-02f, -1.26180515e-01f,
  -5.92794754e-02f, 9.04728547e-02f, 3.12558897e-02f, 9.28123891e-02f, -3.43982056e-02f, 5.97572401e-02f, -3.87470163e-02f, -3.38565372e-02f, -5.51233860e-03f, 2.24897731e-02f,
  -1.42805636e-01f, 3.86097655e-02f, -8.82674605e-02f, 3.01636988e-03f, 1.95780788e-02f, -1.31589426e-02f, 4.33705561e-02f, -4.34896676e-03f, -7.03312680e-02f, 6.01691287e-03f,
  3.10213566e-02f, -4.13006805e-02f, 5.55712245e-02f, -3.06544732e-02f, -2.04470512e-02f, -4.48212028e-02f, 9.33640450e-03f, -1.28296018e-02f, 2.03864351e-02f, -1.52335018e-02f,
  -7.28350785e-03f, -3.26125622e-02f, 2.77284943e-02f, 4.21376862e-02f, 2.27701925e-02f, -2.16262266e-02f, 5.40171675e-02f, -3.98246236e-02f, -5.79962414e-03f, -2.47115213e-02f,
  -2.11570561e-02f, 2.67928224e-02f, 2.57225875e-02f, 3.98647934e-02f, 4.40280698e-02f, -6.65975641e-03f, 7.73402974e-02f, -7.24779218e-02f, -7.11303786e-04f, -2.25466359e-02f,
  -6.94535822e-02f, -9.17748958e-02f, 1.63351297e-02f, 1.52268838e-02f, 9.82063040e-02f, -2.06540488e-02f, 1.10146627e-02f, 6.70539290e-02f, -4.09816466e-02f, 1.02272138e-01f,
  -3.47482450e-02f, -3.65854315e-02f, 6.97878748e-02f, -5.15229739e-02f, 2.52194051e-02f, 3.03709712e-02f, -7.18898028e-02f, -3.14710140e-02f, -3.96789163e-02f, 4.17278334e-02f,
  3.32894325e-01f, 2.34818578e-01f, 1.99075818e-01f, 8.45363960e-02f, 9.88711268e-02f, -6.41591027e-02f, -9.66183469e-02f, -5.96429408e-02f, 1.38428882e-01f, -1.60029903e-02f,
  -1.12683006e-01f, 2.65009433e-01f, -1.22732259e-01f, 2.77577862e-02f, -5.14143944e-01f, -1.88503221e-01f, -1.08081169e-01f, -5.58690876e-02f, 2.29506120e-02f, 6.88003302e-02f,
  -1.11969173e-01f, -1.31847396e-01f, -1.22396313e-01f, -7.40092844e-02f, 2.16884807e-01f, 2.37980202e-01f, -3.25154781e-01f, 3.86426714e-03f, -2.90473718e-02f, -1.02086291e-02f,
  -2.88404804e-02f, -3.11546158e-02f, -6.15582950e-02f, 1.62895638e-02f, -1.09328173e-01f, 1.16706090e-02f, -4.04917030e-03f, -1.01962313e-01f, 9.70619917e-03f, -2.25487119e-03f,
  8.60254616e-02f, -1.06257964e-02f, 2.00649220e-02f, 3.48487496e-02f, 2.75988691e-02f, 6.25307322e-04f, 9.02905390e-02f, 1.13259237e-02f, 1.20431826e-01f, 1.49929628e-01f,
  3.66211459e-02f, -2.69868266e-04f, 9.87630412e-02f, -7.89960176e-02f, 3.94982360e-02f, -1.01867998e-02f, 1.82987507e-02f, -1.04056010e-02f, 5.20658679e-02f, 1.36316985e-01f,
  -1.51486415e-02f, 8.47466011e-03f, 7.89754558e-03f, 9.00224969e-02f, 3.05142011e-02f, -6.94730727e-04f, 5.56039595e-05f, -4.66591455e-02f, -4.28302074e-03f, 1.19589968e-03f,
  -1.14849254e-01f, 1.99922547e-02f, -3.24165672e-02f, 5.41047417e-02f, 5.02884425e-02f, 4.10110392e-02f, -5.60077950e-02f, -1.17697127e-01f, -8.36536959e-02f, -3.43446694e-02f,
  -7.27043524e-02f, 1.89487692e-02f, -1.17076216e-02f, -2.10503861e-02f, -6.84681535e-02f, -3.70251834e-02f, 4.57934244e-03f, 2.74263639e-02f, 1.61286036e-03f, -1.70995086e-01f,
  -2.73793250e-01f, -2.05062211e-01f, -8.59299749e-02f, -3.80871184e-02f, 6.35892078e-02f, 3.13500017e-02f, 6.58026561e-02f, 9.82570127e-02f, -1.95622426e-02f, 5.44417910e-02f,
  -1.48480840e-03f, -6.61652461e-02f, 4.15008552e-02f, -2.33787969e-02f, -1.27386257e-01f, -3.25494185e-02f, -3.71762514e-02f, -4.30470593e-02f, -1.39011130e-01f, 1.28041804e-02f,
  9.40363947e-03f, 2.30877046e-02f, 1.13138273e-01f, 8.46138000e-02f, -5.12932278e-02f, -1.14057899e-01f, 2.33757589e-02f, -7.11043924e-02f, 1.38209173e-02f, 6.12940975e-02f,
  1.96797252e-01f, -1.55870214e-01f, 9.24050137e-02f, 1.75984263e-01f, 1.13795251e-02f, 5.39040081e-02f, -1.51811354e-02f, -2.15132192e-01f, -3.16517323e-01f, -6.59782067e-02f,
  3.35571468e-02f, -3.83131839e-02f, -1.01436809e-01f, -1.16573246e-02f, 1.98973380e-02f, -3.05614650e-01f, 2.55518313e-02f, -3.14277597e-02f, -1.87908262e-01f, 1.50255635e-01f,
  -1.58015992e-02f, -1.54422512e-02f, 2.25573525e-01f, 1.86707616e-01f, 1.38810933e-01f, 2.22344980e-01f, 3.25513512e-01f, 2.28269711e-01f, 3.68128777e-01f, 8.69721547e-02f,
  -1.38277132e-02f, -1.04468711e-01f, -1.24025233e-02f, -6.22574985e-02f, 1.64769277e-01f, 2.09532246e-01f, 1.60130024e-01f, -3.45087866e-03f, -3.75905968e-02f, -4.88129668e-02f,
  1.02877520e-01f, -3.19509432e-02f, -1.91199809e-01f, 1.26436248e-01f, 2.80789230e-02f, -3.63623165e-02f, -1.00443279e-02f, -1.14097893e-02f, -1.11970166e-02f, 5.95602058e-02f,
  -3.32021676e-02f, -3.74198295e-02f, 1.74194027e-03f, 1.70296859e-02f, 3.00512854e-02f, -3.81547734e-02f, 6.86987042e-02f, 9.94191021e-02f, -1.19895935e-01f, -1.09503716e-02f,
  1.19702434e-02f, -1.02680348e-01f, -1.65301815e-01f, -1.44990236e-01f, 2.59443000e-02f, -6.18230458e-03f, -1.19903281e-01f, -6.07222579e-02f, 5.20727299e-02f, 8.77303109e-02f,
  6.06872030e-02f, 8.74147415e-02f, 1.08005404e-01f, -9.38350707e-02f, -2.76464224e-02f, -1.35577828e-01f, 1.07551582e-01f, -2.08050665e-02f, 4.93540578e-02f, -1.12851277e-01f,
  -4.57299016e-02f, -2.55527887e-02f, 7.35821351e-02f, -3.45369354e-02f, -1.75680652e-01f, 1.22359246e-01f, -8.72459449e-03f, 1.02161914e-02f, 1.85101088e-02f, 4.49950397e-02f,
  -4.77078892e-02f, 1.48539245e-01f, 1.06059927e-02f, -4.71121892e-02f, 4.75751869e-02f, 8.25390890e-02f, -1.36827128e-02f, -4.59917858e-02f, 4.66659740e-02f, -3.84377949e-02f,
  2.84986615e-01f, 2.89633702e-02f, -4.23062146e-02f, 1.60968691e-01f, 8.58643875e-02f, 1.41368315e-01f, -2.04439424e-02f, 1.35059953e-01f, 1.01219535e-01f, 2.45559886e-01f,
  1.37142643e-01f, 3.14266980e-02f, -5.52272126e-02f, -1.06222339e-01f, 2.98534110e-02f, 1.69547170e-01f, -4.66650091e-02f, -1.84405632e-02f, 1.92548744e-02f, -1.85947921e-02f,
  2.05268383e-01f, -1.04859114e-01f, -2.21318200e-01f, 1.83619335e-01f, -1.27000809e-01f, -1.11675888e-01f, -9.15922299e-02f, -6.23795837e-02f, -1.55183434e-01f, -8.21714550e-02f,
  1.63591176e-01f, 3.38327810e-02f, 3.62120047e-02f, 1.30934611e-01f, 7.28615820e-02f, 1.83129199e-02f, 1.12484887e-01f, 3.60826775e-02f, -3.74361947e-02f, 1.85881764e-01f,
  1.57459229e-01f, 3.12459707e-01f, 7.01567754e-02f, 1.39317229e-01f, 1.68586299e-01f, 3.30060646e-02f, 2.16085941e-01f, -3.05897612e-02f, 2.58095890e-01f, 2.26065554e-02f,
  -1.44558521e-02f, 9.99854729e-02f, -5.93092106e-02f, -9.24308971e-02f, 1.42466351e-02f, 7.60093853e-02f, 3.86596732e-02f, 1.04823291e-01f, -7.37130195e-02f, 9.57697723e-03f,
  -8.88980925e-02f, 1.78731221e-03f, -2.39892676e-02f, 1.12432778e-01f, -8.29431415e-03f, -1.38872549e-01f, -8.84519741e-02f, 1.83560401e-02f, -1.04464158e-01f, 1.20124100e-02f,
  -7.50080198e-02f, -5.60286865e-02f, -2.38896180e-02f, -2.48648934e-02f, -4.01740372e-02f, 2.35683341e-02f, -1.19365804e-01f, 5.13051823e-02f, -9.20615271e-02f, -2.29222663e-02f,
  8.82267058e-02f, 7.75396079e-02f, -6.91081882e-02f, -4.90117557e-02f, 2.45337971e-02f, -4.93231714e-02f, 1.03061944e-01f, -5.96505180e-02f, -1.20541472e-02f, 5.86795770e-02f,
  -1.27605926e-02f, -1.21611312e-01f, 6.11747243e-02f, 4.19264808e-02f, 1.10878877e-01f, 3.72063629e-02f, 9.22269840e-03f, -1.60259213e-02f, -3.31699066e-02f, -2.62566656e-02f,
  2.90368069e-02f, -6.89622909e-02f, 7.21847937e-02f, -9.44123697e-03f, 3.57569642e-02f, -5.15428260e-02f, 5.43007143e-02f, -8.25949311e-02f, -1.15485616e-01f, -9.81617272e-02f,
  5.60977571e-02f, 1.00337856e-01f, -7.93774873e-02f, 3.71847264e-02f, -3.42267491e-02f, 1.02107301e-01f, 8.87921900e-02f, -5.83487228e-02f, 6.41368330e-02f, 9.83779207e-02f,
  2.36820672e-02f, 1.62203573e-02f, 5.09692021e-02f, -5.30962832e-02f, 6.64913431e-02f, -3.87524739e-02f, 8.64273459e-02f, -4.25351644e-03f, -2.11945549e-02f, 4.42937426e-02f,
  9.97223258e-02f, -6.26008585e-02f, 1.00109382e-02f, -1.71704497e-02f, 1.56400036e-02f, 1.01270370e-01f, -1.79728959e-02f, 2.55586393e-02f, 3.95303257e-02f, -7.20614269e-02f,
  -4.73023921e-01f, 3.10604930e-01f, 1.76189378e-01f, 2.89908886e-01f, -6.90932851e-03f, 1.20099937e-03f, 4.64929491e-02f, 1.39934734e-01f, 3.27833623e-01f, 1.52025655e-01f,
  -1.83972642e-02f, 9.83304456e-02f, -1.33414418e-02f, 7.96338394e-02f, 1.24681830e-01f, 4.76454534e-02f, 1.11181311e-01f, -2.81210020e-02f, 1.06877916e-01f, -2.11308133e-02f,
  1.31147653e-01f, 3.73970829e-02f, -5.96307181e-02f, -2.00829674e-02f, -9.60966498e-02f, 8.25862065e-02f, 1.79810107e-01f, 9.81338397e-02f, -3.16742286e-02f, 1.12661853e-01f,
  -1.40335143e-01f, 2.27082282e-01f, -6.78591132e-02f, 5.72752878e-02f, -8.97970796e-02f, -4.38124761e-02f, -8.60239416e-02f, -1.47788469e-02f, -7.35098124e-02f, 3.05411331e-02f,
  1.85572095e-02f, -9.05317217e-02f, 4.11900468e-02f, -1.50432559e-02f, 6.47408888e-02f, 3.78092229e-02f, -7.36941919e-02f, -9.73361954e-02f, -2.32424699e-02f, -9.37518775e-02f,
  4.54935059e-02f, 1.18775247e-02f, 4.07906994e-02f, -3.01206410e-02f, -7.48560997e-04f, 1.06966704e-01f, 8.39174092e-02f, -5.47712063e-03f, 1.72696225e-02f, 9.24445689e-02f,
  8.91472679e-03f, -4.81296852e-02f, 2.48990599e-02f, -2.25094873e-02f, 5.01866899e-02f, -4.84524183e-02f, 6.62684441e-02f, -2.14300696e-02f, 1.89932417e-02f, -9.35642794e-02f,
  -5.06393127e-02f, -2.77434103e-03f, -4.23450321e-02f, 1.52992038e-02f, 1.14675708e-01f, 1.15455836e-01f, -1.12797739e-02f, -4.48624156e-02f, -5.74890934e-02f, -5.08763343e-02f,
  1.47338435e-01f, -4.68081199e-02f, -2.69823913e-02f, -2.66073123e-02f, 4.58490625e-02f, 9.02576074e-02f, 1.01304136e-01f, 4.06709546e-03f, 9.08075795e-02f, 2.27354635e-02f,
  1.14746206e-01f, 3.22984099e-01f, 4.24375869e-02f, 1.07976813e-02f, 5.52757010e-02f, -1.70931630e-02f, 5.97566739e-03f, -3.95740159e-02f, 2.02666342e-01f, 1.10102087e-01f,
  -4.34859563e-03f, -5.46750575e-02f, -9.54398140e-02f, 6.65032566e-02f, -3.16640660e-02f, -1.70779868e-03f, 6.59805164e-02f, 1.21622480e-01f, 9.06720534e-02f, -1.40162438e-01f,
  -1.19311310e-01f, 1.90806703e-03f, -6.64143935e-02f, 3.28382030e-02f, -1.49269894e-01f, -5.41775227e-02f, -4.00226042e-02f, 2.18990557e-02f, 4.35382128e-02f, -3.72994542e-02f,
  -8.49304199e-02f, -1.91946357e-01f, -2.55027443e-01f, -3.93097937e-01f, 2.53851563e-01f, 3.97846222e-01f, 1.86110258e-01f, -1.31096661e-01f, -4.95957822e-01f, 1.17026359e-01f,
  2.79355645e-01f, -1.24611929e-01f, 2.25992784e-01f, -1.19015172e-01f, 1.01780035e-01f, 3.23080868e-02f, -1.08700082e-01f, 1.03797577e-01f, -1.75018445e-01f, 1.39476478e-01f,
  -5.48307179e-03f, 2.33603507e-01f, -1.57913551e-01f, -1.98298786e-02f, 2.12379187e-01f, -5.01226969e-02f, 2.22773001e-01f, 2.30574474e-01f, 9.13617611e-02f, 1.03364483e-01f,
  9.69452113e-02f, -3.41206230e-02f, -4.22073603e-02f, -1.33577988e-01f, 1.57258019e-01f, 1.89129427e-01f, 5.17681986e-02f, 7.91150779e-02f, -4.53912728e-02f, 3.56023908e-02f,
  7.83331916e-02f, 3.26597095e-02f, -1.34781629e-01f, -3.55412103e-02f, -7.37800002e-02f, -4.03790846e-02f, -9.78322923e-02f, -2.09820867e-02f, -1.45982087e-01f, 1.42123960e-02f,
  -1.82151031e-02f, 1.28709013e-02f, -1.12488426e-01f, -7.79071897e-02f, -5.33463433e-02f, -3.67403813e-02f, -1.57016795e-02f, 5.62125742e-02f, 1.28639881e-02f, -2.66364049e-02f,
  4.22383938e-03f, 9.14759561e-02f, 9.52159539e-02f, 4.25885012e-03f, 1.79949142e-02f, -2.28685364e-02f, -2.60989531e-03f, -1.84292570e-02f, -2.10519191e-02f, 1.74239576e-02f,
  -9.95892957e-02f, -1.11235127e-01f, 2.10626014e-02f, -2.77368203e-02f, 4.06461731e-02f, -4.44258004e-02f, 7.82735944e-02f, 7.67979324e-02f, -7.32527748e-02f, -9.49661527e-03f,
  -1.69564551e-03f, 6.65191934e-02f, -7.03817606e-03f, -2.67135352e-02f, -9.43645015e-02f, -1.13228068e-01f, -2.71878876e-02f, 3.66313523e-03f, 7.17544407e-02f, 7.41875395e-02f,
  5.87402619e-02f, 1.84302777e-01f, 1.18559571e-02f, -8.06327388e-02f, 5.78730414e-03f, 1.47055149e-01f, -7.56373778e-02f, -8.94274190e-03f, -7.57332295e-02f, 5.41989915e-02f,
  8.37579742e-02f, -7.45680258e-02f, 4.24178205e-02f, -1.43038675e-01f, -1.74064025e-01f, 4.39996198e-02f, 1.08011015e-01f, -8.93710777e-02f, -1.48401049e-03f, 5.42965019e-03f,
  5.00122737e-03f, 1.65755391e-01f, -9.18417871e-02f, -2.97813229e-02f, -6.30779862e-02f, -2.00057235e-02f, -7.54933581e-02f, 3.17740254e-02f, 5.59150837e-02f, -3.54796797e-02f,
  3.98507714e-03f, 3.00311744e-01f, -2.81533878e-03f, -9.09178331e-02f, -4.68807518e-02f, -8.50604549e-02f, -1.56226717e-02f, -6.91538602e-02f, -8.78977997e-04f, 1.76273555e-01f,
  -2.31521553e-03f, 2.96040803e-01f, 6.04904816e-02f, -2.01325819e-01f, -4.80138183e-01f, -3.14704061e-01f, -3.63107741e-01f, -4.15858738e-02f, -9.56524163e-02f, 2.67831031e-02f,
  -1.69756606e-01f, -2.70903975e-01f, -2.59920597e-01f, -5.19947186e-02f, 1.39142483e-01f, 2.76475877e-01f, -6.18866310e-02f, 1.59305215e-01f, 9.85973850e-02f, 7.03911064e-03f,
  3.11575923e-02f, -2.25113835e-02f, -9.39548202e-03f, 6.45689368e-02f, -8.25508162e-02f, 3.68079953e-02f, 3.92508581e-02f, -1.19823609e-02f, -4.56809253e-02f, 4.17020964e-03f,
  7.97690824e-02f, 6.72150776e-02f, -5.35978153e-02f, 6.35558590e-02f, 1.29807115e-01f, 7.89020956e-03f, 1.54017918e-02f, 7.45823048e-03f, 6.92261159e-02f, -5.71557097e-02f,
  -8.36892128e-02f, 1.35183170e-01f, 6.65465195e-04f, -9.91994049e-04f, -7.53066987e-02f, 1.26070857e-01f, -6.92748278e-02f, 1.25284240e-01f, 1.31964773e-01f, 2.97943726e-02f,
  -3.53448489e-03f, -6.93669915e-02f, -5.35069481e-02f, -1.64390169e-02f, 8.49451199e-02f, 1.65342093e-02f, -1.20464936e-02f, -2.16261391e-02f, 7.54933953e-02f, -2.05232995e-03f,
  6.42589554e-02f, 1.49259314e-01f, -1.43713728e-02f, -4.50328961e-02f, -2.37946846e-02f, 3.50033343e-02f, 2.35649832e-02f, 1.06989168e-01f, 1.56815425e-02f, 2.62732478e-03f,
  -9.67626087e-03f, -1.20997399e-01f, 1.07050031e-01f, 1.39933988e-01f, -1.59352180e-02f, 7.70931616e-02f, 5.21850884e-02f, 6.65623024e-02f, -3.56170535e-02f, 1.70176215e-02f,
  -1.61605567e-01f, -4.54440191e-02f, 7.50292614e-02f, 9.25855637e-02f, -9.52279940e-02f, 3.42393406e-02f, -1.19061843e-01f, -3.25514795e-03f, -7.22256154e-02f, -1.21292345e-01f,
  3.64288799e-02f, 2.67943437e-03f, -4.61403206e-02f, -2.02297363e-02f, -1.77162923e-02f, -1.53588783e-02f, 2.30066665e-02f, -3.49007212e-02f, -5.88397169e-03f, -1.22839669e-02f,
  4.77091782e-02f, -2.12785043e-02f, 6.66575432e-02f, -5.06351367e-02f, -2.19363533e-02f, 1.49732232e-01f, -4.09335904e-02f, 1.03490442e-01f, 3.59251513e-03f, 4.62827049e-02f,
  -4.23063606e-01f, 2.42065340e-01f, -1.37989417e-01f, 2.18129173e-01f, -2.75520273e-02f, 1.48267269e-01f, 1.62366644e-01f, 1.34573057e-02f, -8.76162574e-02f, 3.79206985e-01f,
  3.40726852e-01f, -1.08520091e-01f, 8.45770761e-02f, 3.23022604e-01f, -9.59651768e-02f, 1.77912772e-01f, 2.90712237e-01f, 2.26320550e-01f, -3.72919552e-02f, -7.27726892e-02f,
  -7.15465993e-02f, 2.30625331e-01f, 1.17804632e-01f, -6.22082725e-02f, 9.29707661e-02f, -1.26978487e-01f, 1.64622828e-01f, -1.19259492e-01f, 2.80527532e-01f, -6.30769059e-02f,
  -2.63669528e-04f, -1.07245207e-01f, -1.34703010e-01f, -1.11991994e-01f, -6.73879832e-02f, -1.17524035e-01f, 2.60497853e-02f, -1.07063614e-01f, -8.70851651e-02f, 4.29952564e-03f,
  -1.73459813e-01f, 9.54855885e-03f, 1.74921490e-02f, 1.58244584e-04f, -1.44012449e-02f, -6.97035566e-02f, 4.03147601e-02f, 1.20629452e-01f, 7.09388852e-02f, 1.43764056e-02f,
  -6.82385312e-03f, 5.36924414e-02f, 8.67221132e-02f, 4.63240035e-03f, 4.44927253e-03f, -4.49087508e-02f, 5.23240045e-02f, -8.19260702e-02f, 1.41119696e-02f, -8.09905380e-02f,
  -2.61288229e-02f, -7.30543816e-03f, 4.53573139e-03f, 7.47416988e-02f, 1.10068135e-02f, 8.81653428e-02f, 2.28972305e-02f, 3.81753445e-02f, -3.42312232e-02f, 6.21184222e-02f,
  -1.00504253e-02f, 1.33533120e-01f, -4.78009060e-02f, -2.02060044e-02f, -1.02300616e-02f, -1.70953607e-03f, -9.23663080e-02f, -5.19643761e-02f, 7.05733597e-02f, -1.70237012e-02f,
  -1.11011760e-02f, -7.09281787e-02f, 6.73467442e-02f, 1.93245299e-02f, 1.55820586e-02f, 9.55093931e-03f, -4.57793176e-02f, 9.84652340e-02f, 2.01286210e-04f, -3.08152009e-02f,
  1.26957476e-01f, 9.92704183e-02f, 9.62755978e-02f, -5.54806367e-02f, -1.99917648e-02f, -3.62111032e-02f, -3.00465021e-02f, -1.59403980e-02f, 4.37608063e-02f, -8.29470158e-02f,
  -5.58932647e-02f, -1.01998181e-03f, -7.11649209e-02f, -4.73173782e-02f, -9.40098614e-03f, -6.52648800e-04f, 4.64293994e-02f, -1.18684592e-02f, 8.66701826e-02f, 4.67077643e-02f,
  1.05285078e-01f, -8.14484805e-02f, 2.51336116e-02f, 7.43694007e-02f, -7.61959096e-03f, -5.24935424e-02f, -7.13382587e-02f, -1.08745188e-01f, -4.24210615e-02f, 4.94109802e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.25546187e-01f, 2.79954135e-01f, 2.55302668e-01f, 1.17015980e-01f, 1.71367824e-01f, 4.12889391e-01f, 3.27390432e-01f, 1.02217868e-01f, 3.03929418e-01f, 1.45591602e-01f,
  4.29308176e-01f, 4.07541841e-01f, 3.00140232e-01f, 3.29661101e-01f, 2.87773371e-01f, 1.66257486e-01f, 1.86764449e-01f, 2.76442647e-01f, -1.31055459e-01f, 3.79392952e-01f,
  3.76428336e-01f, 6.25518635e-02f, 8.57166871e-02f, 4.98479396e-01f, 2.28949383e-01f, 6.58219904e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.46781474e-01f, 1.35637268e-01f, 1.95333377e-01f, -2.19445243e-01f, -3.21402177e-02f, -1.32395804e-01f, -1.85327351e-01f, 2.39984035e-01f, -9.55659896e-02f, -8.08171332e-02f,
  2.46829763e-01f, 9.67552047e-03f, -9.87391770e-02f, -1.81959495e-01f, 8.25384706e-02f, 3.93605046e-02f, 1.67437717e-01f, 1.81377649e-01f, 1.00795649e-01f, 2.38787130e-01f,
  3.00953478e-01f, 1.64385512e-01f, 2.46147029e-02f, 1.07534446e-01f, -6.49215952e-02f, 4.75174785e-02f, 1.88495014e-02f, 2.62520649e-02f, -1.58084258e-01f, 1.63201243e-01f,
  1.33107364e-01f, 1.39360636e-01f, 6.78931251e-02f, 2.42040172e-01f, 8.07779282e-02f, -9.49059874e-02f, -2.40452647e-01f, 1.60351712e-02f, 1.66109875e-01f, -2.68093616e-01f,
  1.73988625e-01f, -1.55881226e-01f, 3.04017197e-02f, 8.33491609e-02f, -1.28637522e-01f, 1.11347109e-01f, -2.47540008e-02f, 1.24700014e-02f, -1.82746947e-01f, -5.18123172e-02f,
  2.38592759e-01f, -2.60056555e-01f, 7.65478835e-02f, 8.55057687e-02f, -6.61939476e-03f, -1.60442144e-01f, -9.96686965e-02f, 1.56252235e-01f, -1.11360982e-01f, -1.75708085e-01f,
  1.23917222e-01f, 6.12267368e-02f, 1.76395535e-01f, -8.57572109e-02f, -9.19948681e-04f, -2.58352607e-01f, -2.40178272e-01f, 2.78294176e-01f, -1.00120187e-01f, -2.32885435e-01f,
  1.31912529e-01f, -1.22358561e-01f, 7.40380734e-02f, 6.55152947e-02f, 3.03923368e-01f, -7.19097331e-02f, -1.41855493e-01f, 1.93110615e-01f, 7.29207173e-02f, -1.84055477e-01f,
  -8.87669474e-02f, 9.94866341e-02f, -2.09789574e-01f, -5.06817661e-02f, 1.80410460e-01f, -2.18256060e-02f, 5.55532910e-02f, -1.17175169e-01f, 2.75455266e-01f, -2.21236885e-01f,
  2.04979017e-01f, 1.03226267e-01f, -1.05279654e-01f, 6.48233742e-02f, -7.41029158e-02f, 2.20108524e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.43870753e-01f, 1.98933378e-01f, 1.22433670e-01f, -1.00943558e-01f, -3.19293529e-01f, 5.81144402e-03f, 3.16014349e-01f, -2.36020625e-01f, 2.99035162e-01f, 2.30903760e-01f,
  6.44069761e-02f, 1.38749495e-01f, -7.77607188e-02f, 2.59211719e-01f, -1.63737312e-01f, 2.89999694e-01f, 3.50404233e-01f, -9.47722495e-02f, -2.12203667e-01f, -1.13827206e-01f,
  -9.31882933e-02f, 1.99525759e-01f, 2.94994980e-01f, 1.92440793e-01f, 1.43784791e-01f, -5.50650805e-02f, 5.05291447e-02f, 3.03140759e-01f, 2.95706064e-01f, 2.16576323e-01f,
  -2.32309416e-01f, 3.70972097e-01f, 9.37181935e-02f, 3.03060293e-01f, 3.22558105e-01f, -3.82492036e-01f, 1.14310913e-01f, 5.28671503e-01f, -3.05655152e-01f, 3.00545305e-01f,
  2.80025363e-01f, 1.38198480e-01f, -3.15708339e-01f, 1.56064317e-01f, 3.98549974e-01f, 1.63654134e-01f, 3.62170488e-01f, 2.70045877e-01f, 3.27693552e-01f, 2.13467538e-01f,
  1.11312404e-01f, 1.72714114e-01f, 1.93654314e-01f, -2.15537727e-01f, -2.37868473e-01f, 2.73264855e-01f, 1.06934182e-01f, 2.97227710e-01f, 1.11215986e-01f, 1.91856340e-01f,
  -3.87182683e-02f, -1.65903121e-01f, 2.00244725e-01f, 5.80438077e-02f, 3.34980935e-01f, 3.33885938e-01f, 4.08427089e-01f, 3.53722960e-01f, -5.78420639e-01f, -3.22547734e-01f,
  2.16251105e-01f, -2.36038283e-01f, 2.62024313e-01f, 1.61714822e-01f, 8.56016204e-03f, 4.77245867e-01f, -1.04659922e-01f, -4.04524505e-02f, 2.42397621e-01f, -2.90237777e-02f,
  -7.85979629e-02f, -4.03605076e-03f, 1.53509483e-01f, -1.13637209e-01f, -2.64653474e-01f, 1.44149244e-01f, 2.98321903e-01f, 3.64673510e-02f, 4.38632444e-02f, 2.95138478e-01f,
  8.74948800e-02f, -5.26320674e-02f, 4.93648201e-02f, 4.86655116e-01f, 3.50548536e-01f, -3.42386328e-02f, 7.16291666e-02f, 2.91579086e-02f, 1.61532640e-01f, -2.16544300e-01f,
  -9.69423801e-02f, 7.96620771e-02f, 1.84853882e-01f, -5.65373711e-02f, 1.56399712e-01f, 2.80168235e-01f, -6.13987781e-02f, -2.85085708e-01f, -5.23219816e-02f, 3.51810545e-01f,
  7.37746432e-02f, 3.81614983e-01f, 7.94639513e-02f, -2.12429434e-01f, -1.35043621e-01f, -1.72968313e-01f, 2.05985248e-01f, -3.45904790e-02f, 2.55646735e-01f, 1.41435578e-01f,
  -4.17656451e-02f, -1.74393475e-01f, 3.45900118e-01f, 4.15039688e-01f, 3.13969791e-01f, 2.69559681e-01f, -9.56933200e-02f, 4.22496438e-01f, 1.32418856e-01f, 5.19844294e-01f,
  3.50513279e-01f, 3.46155584e-01f, -1.79830104e-01f, -3.19447219e-01f, -1.04741797e-01f, -1.25231165e-02f, -1.56487420e-01f, 1.35599226e-01f, 3.82239610e-01f, 2.13855892e-01f,
  -9.26264301e-02f, 4.73938845e-02f, -1.30007550e-01f, -2.44867608e-01f, -9.18534305e-03f, 5.93634993e-02f, 4.23156947e-01f, 2.39526674e-01f, 2.59794027e-01f, 2.37431660e-01f,
  2.83768058e-01f, 1.20312415e-01f, -2.27863751e-02f, -2.76123211e-02f, -4.37355489e-02f, 4.69591841e-02f, -3.96743417e-02f, 1.91174313e-01f, 2.62928665e-01f, -3.30542177e-02f,
  5.69581948e-02f, 1.52004510e-01f, 2.85951138e-01f, -7.83611462e-02f, 1.49459079e-01f, -9.21221972e-02f, -1.03189819e-01f, 5.30921638e-01f, -5.22223055e-01f, 1.05171904e-01f,
  2.12832674e-01f, -4.27285165e-01f, 3.02549541e-01f, -1.54921025e-01f, 3.55757087e-01f, 4.11164872e-02f, 1.25856131e-01f, 5.41984700e-02f, -5.06935008e-02f, 6.29428700e-02f,
  6.97399154e-02f, -8.18958804e-02f, -3.50395322e-01f, 2.53731191e-01f, -1.90429896e-01f, 9.84556377e-02f, 7.58143663e-02f, 1.08344324e-01f, -2.40527645e-01f, 3.53280306e-01f,
  5.17746881e-02f, 3.78612697e-01f, 2.16123164e-01f, -6.48151413e-02f, -1.68607831e-02f, 9.49420631e-02f, 2.16629222e-01f, 1.39576271e-01f, 4.18392792e-02f, 3.99230629e-01f,
  3.55032057e-01f, 4.30623353e-01f, 2.61359423e-01f, -1.49173960e-01f, -9.67883393e-02f, 2.37984776e-01f, 3.97597730e-01f, -1.08828224e-01f, 2.41106033e-01f, -9.52091515e-02f,
  3.04625392e-01f, -2.24361688e-01f, 2.61435986e-01f, -6.60404265e-02f, -7.09323138e-02f, 5.06358743e-02f, 1.97486475e-01f, 2.86894590e-02f, 2.78709352e-01f, 2.78902888e-01f,
  1.45883029e-02f, 2.19878107e-01f, -1.46709189e-01f, 2.94634312e-01f, 2.62939364e-01f, 4.05637234e-01f, 2.55755514e-01f, 2.69136310e-01f, -6.32038489e-02f, 2.36104548e-01f,
  -9.44867209e-02f, 1.16677769e-01f, 1.89504027e-01f, 1.53737277e-01f, 1.24637656e-01f, 3.53341609e-01f, 3.31577778e-01f, -1.71794713e-01f, 4.42385107e-01f, -2.12032437e-01f,
  1.20527789e-01f, 5.64165264e-02f, 4.25854146e-01f, 4.50407993e-03f, -1.65909678e-01f, -3.91574293e-01f, -2.08265990e-01f, -5.69836162e-02f, -1.11587361e-01f, 5.37318170e-01f,
  2.64974624e-01f, -2.24604651e-01f, -2.50581741e-01f, 8.55450183e-02f, 4.87084717e-01f, 6.25315607e-02f, 3.32275629e-01f, 1.86563522e-01f, 3.62533063e-01f, -2.63785958e-01f,
  -3.42797309e-01f, -1.54034466e-01f, -2.18090057e-01f, -8.48623589e-02f, -7.19936937e-02f, -3.54548752e-01f, -1.93849161e-01f, 1.02636822e-01f, 2.46791244e-01f, -4.05794121e-02f,
  -4.53236014e-01f, 1.22615241e-01f, 1.43049821e-01f, 5.24187803e-01f, -9.69040841e-02f, 4.06856805e-01f, -8.25900286e-02f, 3.94886345e-01f, 2.27934077e-01f, 4.60328221e-01f,
  -3.39772254e-01f, 2.11504444e-01f, 2.78766900e-01f, -5.37533052e-02f, -3.18427794e-02f, -1.91848278e-02f, 1.80325940e-01f, -2.60721117e-01f, 1.47769481e-01f, 3.14305156e-01f,
  3.05256754e-01f, 3.99833053e-01f, -4.66313541e-01f, -2.69191831e-01f, -2.73598194e-01f, -9.76601839e-02f, 5.93426451e-02f, -5.73661625e-02f, -4.48999286e-01f, 1.47467196e-01f,
  -2.12893590e-01f, -1.75463617e-01f, -1.40749425e-01f, 1.45497331e-02f, 4.43924628e-02f, 3.66300553e-01f, 1.17025301e-01f, -1.29494190e-01f, -7.92679638e-02f, 9.24757496e-02f,
  -9.26759169e-02f, 2.61077285e-01f, -2.92795986e-01f, 2.36094549e-01f, 1.90551490e-01f, -1.48723796e-01f, -4.37099069e-01f, 3.25595379e-01f, 2.90987492e-01f, -2.23466847e-02f,
  1.54405221e-01f, 2.33212143e-01f, 8.78374055e-02f, -3.33254784e-01f, 1.32538095e-01f, 4.61825699e-01f, 1.23825639e-01f, 2.36064553e-01f, 2.86957681e-01f, -8.58183950e-02f,
  -2.00436324e-01f, 4.08670098e-01f, 4.49355304e-01f, -1.83454141e-01f, 1.52157083e-01f, 1.41727000e-01f, 2.89247274e-01f, 1.73194140e-01f, 1.41519487e-01f, 3.19461346e-01f,
  4.61290404e-02f, 6.56936467e-02f, -1.77326590e-01f, 3.75670284e-01f, -1.37031719e-01f, 2.93258160e-01f, -3.27702537e-02f, -1.65460482e-02f, 9.24037322e-02f, -1.76538393e-01f,
  1.68083161e-01f, -1.75636992e-01f, 1.21855363e-01f, 2.55264461e-01f, 1.23071922e-02f, -1.69101786e-02f, -2.92717606e-01f, -2.13578850e-01f, 1.78042322e-01f, -9.75986421e-02f,
  -8.57938677e-02f, -1.14178240e-01f, 1.01504050e-01f, 2.81268746e-01f, 1.80989429e-01f, 2.12902874e-02f, -2.66516268e-01f, 1.41211614e-01f, 4.53496650e-02f, 3.57484013e-01f,
  -2.25443780e-01f, 1.27906501e-01f, 4.12981510e-01f, 4.94853288e-01f, 3.77432615e-01f, 2.96662837e-01f, 7.15370011e-03f, -2.27695704e-01f, -2.65056808e-02f, -4.44143079e-02f,
  2.19796956e-01f, -2.06852704e-01f, -1.87649682e-01f, 9.95938107e-02f, 9.10077244e-02f, 2.18752041e-01f, 3.31481308e-01f, -2.88344383e-01f, 5.19482680e-02f, 1.96378678e-01f,
  3.14998567e-01f, 3.97580653e-01f, 3.96953598e-02f, 3.94891769e-01f, 3.10721877e-03f, -1.77604645e-01f, 7.09758103e-02f, 4.87089343e-02f, 4.12582099e-01f, 2.12143272e-01f,
  2.91065246e-01f, -2.27196246e-01f, -7.54277781e-02f, -4.30889763e-02f, 9.29147750e-02f, -2.32843697e-01f, -1.82947947e-03f, -7.41400272e-02f, 8.25153440e-02f, -1.78443134e-01f,
  9.98021364e-02f, 1.49706095e-01f, 1.69994254e-02f, 1.81555271e-01f, 4.44770120e-02f, 4.49022651e-01f, 3.22326511e-01f, 3.03442568e-01f, 7.12999031e-02f, -3.21088731e-01f,
  -4.46563721e-01f, -2.89827883e-01f, 4.00693238e-01f, -2.87000626e-01f, 3.65839489e-02f, -2.64426647e-03f, -5.20869434e-01f, 2.75906831e-01f, -4.51039942e-03f, 5.95488474e-02f,
  -1.36008814e-01f, 2.17294991e-01f, 2.36556172e-01f, -2.98275024e-01f, -1.91639856e-01f, -5.35286330e-02f, -2.84315467e-01f, -1.11698527e-02f, 1.57137349e-01f, 3.18668038e-02f,
  2.56664287e-02f, -2.31676638e-01f, 1.40273526e-01f, 1.52903810e-01f, 1.23022586e-01f, 2.92125523e-01f, -1.58432037e-01f, 1.94084406e-01f, 3.19705188e-01f, 4.17996615e-01f,
  2.77636319e-01f, -9.22883153e-02f, 1.24342768e-02f, 1.66296020e-01f, -1.85462430e-01f, 4.83117074e-01f, -3.40860605e-01f, 1.22008473e-01f, -1.01217061e-01f, -1.42739251e-01f,
  3.77486467e-01f, -3.19884866e-02f, 1.20353885e-01f, 3.47330868e-02f, 1.06825918e-01f, 1.89622149e-01f, 3.16509753e-02f, 3.66332978e-01f, 4.87425514e-02f, -1.63769662e-01f,
  -3.73998344e-01f, 2.47231424e-01f, -2.03682467e-01f, 2.43590906e-01f, 3.29974949e-01f, 1.40368223e-01f, -3.96357268e-01f, 2.85508096e-01f, 3.26546252e-01f, 9.01294798e-02f,
  2.14168224e-02f, 1.89845916e-02f, 2.68633496e-02f, -3.20481211e-01f, 4.10213500e-01f, 4.96215791e-01f, -3.29929262e-01f, 2.57468343e-01f, 3.10458720e-01f, 3.79457064e-02f,
  -2.70436734e-01f, 2.23998249e-01f, 3.37423444e-01f, -7.78836161e-02f, 2.94929296e-01f, -1.84819520e-01f, -5.38103580e-02f, 2.74715662e-01f, 1.13344900e-01f, 5.39512634e-02f,
  1.61356166e-01f, -2.69102693e-01f, -3.82352442e-01f, 5.16510010e-02f, 2.04257295e-01f, 4.17968333e-01f, 2.96044648e-02f, 1.72424495e-01f, -1.58823326e-01f, -4.82750595e-01f,
  -8.73997733e-02f, -2.89184570e-01f, 9.55737457e-02f, -3.71476352e-01f, -3.55501711e-01f, 1.22495152e-01f, 2.85067499e-01f, 3.28347653e-01f, -1.96807131e-01f, 1.44297868e-01f,
  4.89913404e-01f, 3.54084879e-01f, -2.69645780e-01f, 5.25270328e-02f, -1.42292986e-02f, 3.61370444e-01f, 6.09176494e-02f, -3.86732876e-01f, -2.39533246e-01f, 2.02260628e-01f,
  1.38446301e-01f, 1.06545150e-01f, -2.33613625e-02f, -2.58903746e-02f, -3.00905794e-01f, -1.59661189e-01f, 9.49674472e-02f, -8.85269493e-02f, 3.53352100e-01f, 1.68629408e-01f,
  2.49300793e-01f, -2.87889123e-01f, -2.43980736e-01f, 6.27005175e-02f, 9.08549204e-02f, 2.92143356e-02f, 6.10751696e-02f, 2.42473170e-01f, -2.13194475e-01f, -1.72213987e-01f,
  4.32528287e-01f, -2.28270754e-01f, 1.93860129e-01f, 3.11266631e-01f, 4.66655135e-01f, 4.72937077e-01f, -3.44118685e-01f, 2.58451432e-01f, 2.93079764e-01f, -3.41868699e-01f,
  -4.38207835e-02f, -7.99421147e-02f, 4.29145843e-01f, 2.33982176e-01f, -2.28705332e-02f, 2.35402167e-01f, 2.52653807e-01f, -3.83449674e-01f, 9.89853814e-02f, 1.02245495e-01f,
  -3.90878975e-01f, -8.57755765e-02f, 2.60362655e-01f, 1.08527467e-01f, 1.68249831e-01f, 8.79000349e-04f, 2.71935582e-01f, 1.59500483e-02f, 1.73870131e-01f, -2.93091774e-01f,
  -2.11057216e-01f, 6.67176396e-02f, 4.69792157e-01f, -3.96459341e-01f, 2.24408954e-01f, 1.56986639e-01f, -5.36294162e-01f, 1.71743259e-01f, -1.96648568e-01f, 3.27485949e-01f,
  1.39900297e-01f, 5.34697652e-01f, 1.65888980e-01f, -2.17668414e-01f, -2.62179911e-01f, -2.98878133e-01f, -3.80465031e-01f, 6.68426976e-02f, 2.07874358e-01f, -7.12502077e-02f,
  1.20029390e-01f, 2.57077627e-02f, 1.29877970e-01f, 2.17370450e-01f, 3.69326442e-01f, 1.21435463e-01f, 3.94905098e-02f, 4.68836188e-01f, 1.17444597e-01f, 4.06891018e-01f,
  2.16112018e-01f, -1.10363446e-01f, -2.44592819e-02f, -2.32582450e-01f, 2.19558239e-01f, 2.66778350e-01f, -3.83532971e-01f, -5.05514294e-02f, 2.72537857e-01f, 2.48194084e-01f,
  1.70391396e-01f, 1.27438530e-01f, -1.59152076e-01f, 3.05597931e-01f, 2.11552516e-01f, 3.82204413e-01f, -6.93919137e-02f, 4.01227951e-01f, 3.32680017e-01f, 3.75170678e-01f,
  6.44461438e-02f, 3.45147729e-01f, -2.96693772e-01f, 1.04635675e-02f, -3.56130265e-02f, 2.28278652e-01f, 1.58841953e-01f, 2.55874991e-01f, 5.21746613e-02f, -2.72214431e-02f,
  1.50240079e-01f, 2.01674297e-01f, 3.29041511e-01f, -3.50805491e-01f, 5.48783094e-02f, 4.51931022e-02f, -1.43367112e-01f, -5.90175427e-02f, -1.86885029e-01f, -2.49192759e-01f,
  -2.32097343e-01f, 1.51922703e-01f, 4.05097872e-01f, -1.64932147e-01f, -1.56444788e-01f, 3.80140454e-01f, 3.22954267e-01f, 4.29165989e-01f, 1.29868299e-01f, 4.19006288e-01f,
  -1.09368950e-01f, 1.42930612e-01f, 1.08228303e-01f, 4.31579977e-01f, -9.93396435e-03f, 1.43028229e-01f, 7.28987157e-02f, -1.10598534e-01f, 2.47365922e-01f, -1.17075458e-01f,
  -1.09408259e-01f, -2.16232821e-01f, 1.53015733e-01f, 1.04939409e-01f, 3.27187836e-01f, 7.89562538e-02f, -1.49806261e-01f, 4.53379042e-02f, 2.22976074e-01f, -4.01092738e-01f,
  3.10735852e-01f, 5.56277074e-02f, -2.80604631e-01f, 4.24763232e-01f, -1.11878157e-01f, -1.22686967e-01f, 2.63350904e-01f, -2.46418178e-01f, -1.44295648e-01f, -5.72972409e-02f,
  2.51768947e-01f, -1.14449672e-01f, -3.20337236e-01f, -1.47750350e-02f, 7.08825663e-02f, -2.32612669e-01f, -1.64287522e-01f, 4.14265722e-01f, -1.89047083e-01f, -1.59063816e-01f,
  3.52133811e-01f, -1.92617685e-01f, 3.84314775e-01f, -1.18700504e-01f, 1.59419719e-02f, 1.89153522e-01f, -7.91976880e-03f, 1.36290237e-01f, 5.09864651e-02f, 1.38347045e-01f,
  -8.00923705e-02f, 2.56865948e-01f, 2.05322266e-01f, 7.89803118e-02f, -1.28465727e-01f, 1.67367637e-01f, 3.26507062e-01f, 1.35976642e-01f, 4.13315088e-01f, -2.23684788e-01f,
  -3.04921716e-02f, 2.08977669e-01f, 1.52013257e-01f, -7.13584796e-02f, 1.76770270e-01f, -1.55660376e-01f, -1.96886018e-01f, -1.06576160e-01f, 2.25093246e-01f, 5.43730080e-01f,
  -9.18936953e-02f, -1.61438361e-01f, 7.65731372e-03f, -2.96208471e-01f, 3.85785848e-01f, -8.71268809e-02f, 3.46465439e-01f, 4.15589660e-01f, 4.22501177e-01f, 4.01087105e-01f,
  -1.34130716e-01f, -1.79440528e-01f, -2.60676295e-01f, 2.08675072e-01f, -3.15499306e-01f, -2.11905748e-01f, 3.97948682e-01f, -2.08569854e-01f, 1.22687049e-01f, 6.23213910e-02f,
  3.34617356e-03f, -2.64011800e-01f, -3.50398310e-02f, 3.57844651e-01f, 3.42446685e-01f, 3.70829701e-01f, 3.16627711e-01f, 3.47944081e-01f, 2.33558580e-01f, -2.05872301e-02f,
  -2.07981914e-01f, 8.47261697e-02f, 2.45240495e-01f, 4.76479679e-02f, -3.84171993e-01f, 2.44896948e-01f, 3.16042930e-01f, -1.29650623e-01f, 1.27278060e-01f, 4.06047881e-01f,
  8.48964527e-02f, 1.05367921e-01f, -2.05674976e-01f, -2.25874200e-01f, 2.76089936e-01f, -2.27903336e-01f, 2.81908840e-01f, 2.03597456e-01f, 3.54788989e-01f, 3.47726405e-01f,
  -3.43608856e-01f, -7.68904760e-03f, 2.92894244e-01f, -3.81681621e-01f, -3.30942750e-01f, -2.32516199e-01f, 3.93967450e-01f, 1.56308323e-01f, -1.26835387e-02f, 2.27044314e-01f,
  3.31287682e-01f, -3.67528856e-01f, -5.65451570e-02f, 3.35424244e-01f, 4.69838362e-03f, -2.36146487e-02f, 8.06732997e-02f, 1.93975449e-01f, 2.62892038e-01f, -1.88796222e-01f,
  1.46089658e-01f, -7.16026723e-02f, 1.36601672e-01f, -6.05092430e-03f, 2.38252863e-01f, 3.33227515e-01f, 1.03610111e-02f, 3.08082908e-01f, -5.24018779e-02f, 1.46298468e-01f,
  -1.08590983e-01f, -1.50418922e-01f, -4.55517173e-02f, 2.79372722e-01f, 1.71417028e-01f, 2.44888574e-01f, 2.17170015e-01f, 8.53115618e-02f, 1.80681109e-01f, -9.00710374e-02f,
  1.99106947e-01f, -3.20643812e-01f, -2.01865584e-01f, -1.54793754e-01f, 1.06252275e-01f, 1.17222257e-01f, 3.12614739e-01f, 3.46460462e-01f, 1.41154438e-01f, 3.02678496e-01f,
  -7.95339644e-02f, 2.62318164e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.26551646e-01f, 1.10755339e-01f, 1.99228585e-01f, 2.99048722e-01f, 2.61959553e-01f, 6.90482650e-03f, 2.31353760e-01f, 3.50737810e-01f, 3.86090875e-01f, 2.12747246e-01f,
  1.20464131e-01f, 2.82453865e-01f, 3.34369302e-01f, 2.56956577e-01f, 3.66423666e-01f, 5.16187958e-02f, -1.03619561e-01f, -8.07197951e-03f, 1.18013397e-01f, 3.62720728e-01f,
  4.63984430e-01f, 8.88998508e-02f, 3.90343294e-02f, 1.15430228e-01f, 1.87385246e-01f, 1.97423697e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -5.36283292e-03f, -1.65759251e-01f, -3.75515670e-02f, 1.71726048e-02f, -1.09385148e-01f, 2.31714875e-01f, -1.49250492e-01f, 1.34099694e-02f, -4.45151217e-02f, -1.82967976e-01f,
  1.42841741e-01f, 1.02048583e-01f, -6.54843152e-02f, 4.22779918e-02f, 1.08760595e-01f, -9.47576165e-02f, 5.72095439e-02f, 6.63427338e-02f, -1.17916197e-01f, -2.51092464e-01f,
  1.62047014e-01f, 1.54485017e-01f, 1.43974200e-02f, -1.78783834e-01f, -3.36641781e-02f, 1.27356961e-01f, 1.24915075e-02f, 1.58087671e-01f, 2.13748783e-01f, 3.12634826e-01f,
  -7.84692168e-02f, -5.55523951e-03f, 1.74203113e-01f, -8.47820789e-02f, -2.50968039e-01f, 1.85380086e-01f, 1.41802549e-01f, -2.81965464e-01f, -8.99693966e-02f, -6.94422890e-03f,
  -2.32069910e-01f, 5.07592969e-02f, -1.33711979e-01f, 2.02297196e-02f, -2.10076898e-01f, -7.19367936e-02f, 1.97819397e-02f, -5.85411042e-02f, 2.33571231e-01f, -2.80357152e-02f,
  -1.01294488e-01f, 5.60489148e-02f, 1.72307808e-02f, 8.84926245e-02f, -4.75581884e-02f, -2.06356302e-01f, 7.85706490e-02f, 1.83712319e-01f, 2.22586647e-01f, 1.86663158e-02f,
  -2.58982390e-01f, 4.91933599e-02f, -1.59533545e-01f, -7.58306533e-02f, -1.75261293e-02f, -1.14245698e-01f, -7.28007406e-02f, -4.74332720e-02f, -1.17292903e-01f, -1.05546668e-01f,
  -4.34831833e-04f, 5.49431890e-02f, -3.57001200e-02f, -2.94699986e-02f, -1.40105754e-01f, 1.45934045e-01f, -4.74248873e-03f, -1.23984516e-01f, 1.54767394e-01f, 8.40108991e-02f,
  2.24863783e-01f, 8.64887908e-02f, 1.11080237e-01f, -1.94250103e-02f, 7.36306384e-02f, -6.59499615e-02f, 3.10993548e-02f, -2.57801086e-01f, -7.73810521e-02f, 2.37698898e-01f,
  1.58779815e-01f, -1.69100329e-01f, -2.07551524e-01f, -1.97951585e-01f, -1.91670954e-01f, -3.75135615e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.39485314e-01f, 8.03120434e-03f, -5.99870756e-02f, -2.55207002e-01f, -4.07627337e-02f, 2.06689432e-01f, -1.19107617e-02f, -1.81614459e-02f, 1.40139669e-01f, 2.94138402e-01f,
  2.90256053e-01f, -1.38929129e-01f, 1.54218897e-01f, 3.94744307e-01f, -3.59519631e-01f, 5.06811291e-02f, -2.02523112e-01f, -1.62181050e-01f, 2.55011744e-03f, -4.00494605e-01f,
  6.11648895e-02f, 3.20273012e-01f, 5.42666256e-01f, 2.76431769e-01f, -4.27665263e-02f, -1.71652198e-01f, -3.27289969e-01f, 4.08066027e-02f, 2.24481583e-01f, 1.20641626e-01f,
  1.93003282e-01f, 2.63942719e-01f, 3.98507565e-01f, 2.06586808e-01f, -5.51506467e-02f, 2.82050043e-01f, 1.41388565e-01f, -4.08039898e-01f, 1.92139804e-01f, 1.91295370e-01f,
  3.02988172e-01f, -2.34093308e-01f, 1.15508974e-01f, -2.23502338e-01f, -1.82344750e-01f, 2.96240091e-01f, 4.62697715e-01f, 2.91022718e-01f, 2.44082332e-01f, -7.78442100e-02f,
  -2.65399933e-01f, 2.23973572e-01f, 1.75543115e-01f, 2.71412302e-02f, -1.49115294e-01f, -1.06530696e-01f, -1.42986163e-01f, 6.95502087e-02f, 4.78334457e-01f, 4.84323561e-01f,
  2.85267860e-01f, -2.28065550e-01f, 1.35894433e-01f, -2.60486931e-01f, 1.40249878e-01f, 2.35338360e-01f, 4.06182051e-01f, 4.10568565e-02f, 1.45369127e-01f, 1.85083106e-01f,
  2.47552365e-01f, 1.94708467e-01f, 3.45421940e-01f, 2.01371491e-01f, -1.46763921e-02f, 3.42420608e-01f, 2.80988812e-01f, 2.55339891e-01f, 1.40039688e-02f, 3.08446348e-01f,
  -1.53469816e-01f, -2.13808343e-01f, 2.15598151e-01f, 2.55161345e-01f, 1.44234926e-01f, -3.08211058e-01f, 1.38433844e-01f, -6.66241422e-02f, 5.00775576e-01f, 1.40757069e-01f,
  -1.51850656e-01f, 1.45192191e-01f, -4.71664853e-02f, 3.79828587e-02f, 1.53627351e-01f, 4.58758265e-01f, 1.69772729e-01f, 2.73568872e-02f, 6.09499104e-02f, -2.90000349e-01f,
  -2.49711707e-01f, 5.62962033e-02f, 2.98886091e-01f, 2.05961689e-01f, -1.82993263e-01f, 4.45249975e-01f, -2.87291437e-01f, -1.40768886e-01f, 2.94714212e-01f, -2.20900908e-01f,
  -1.64376646e-01f, -4.13511693e-01f, 1.74379498e-01f, -1.09855263e-02f, 2.09619939e-01f, 2.22360715e-01f, 1.00432165e-01f, 3.72318476e-01f, 7.63381198e-02f, 4.75545786e-02f,
  1.96418837e-01f, 3.87312323e-02f, 7.17708468e-02f, -2.86652684e-01f, 5.50718494e-02f, -2.07622841e-01f, -2.00077128e-02f, 2.80919820e-01f, -2.14693695e-01f, -3.08353573e-01f,
  -1.57605246e-01f, 1.58750877e-01f, -1.38428003e-01f, 1.86626092e-01f, -1.10898368e-01f, -2.71262944e-01f, 1.25243396e-01f, 4.09870967e-03f, 2.93831825e-01f, -1.64380118e-01f,
  -1.37496619e-02f, -1.90853968e-01f, 2.19132796e-01f, -3.07896078e-01f, 1.10520318e-01f, 2.07464561e-01f, -2.87431687e-01f, -4.84898716e-01f, -2.02416286e-01f, -3.83436084e-01f,
  -1.86078295e-01f, 2.96844840e-01f, -2.05714732e-01f, 3.33324313e-01f, 1.33212820e-01f, 6.28739372e-02f, -5.81781305e-02f, 3.20884585e-01f, 7.70946443e-02f, -1.71478704e-01f,
  5.45069650e-02f, -3.01639020e-01f, 4.97457571e-02f, 4.46967542e-01f, 3.28111768e-01f, -1.44016534e-01f, -1.92654148e-01f, 2.88730294e-01f, 2.04374596e-01f, -5.06606661e-02f,
  1.12422697e-01f, -1.24811558e-02f, 2.49290884e-01f, 3.57374400e-01f, 4.90918495e-02f, 1.46109149e-01f, 1.18327916e-01f, -4.63974983e-01f, 1.39092822e-02f, -4.04040217e-01f,
  -3.53561305e-02f, 3.73295218e-01f, -2.47342922e-02f, 1.17094010e-01f, -1.04905300e-01f, -2.40550369e-01f, -3.90421525e-02f, 5.48856735e-01f, 3.46734554e-01f, 1.93697065e-02f,
  3.30160588e-01f, 1.32720664e-01f, 1.61734253e-01f, -1.47418920e-02f, -3.46712321e-02f, -2.20318064e-01f, -3.05517077e-01f, -4.81579229e-02f, -9.37902704e-02f, 2.49574065e-01f,
  -3.27416539e-01f, 1.47702262e-01f, -3.08733612e-01f, 1.93374813e-01f, 2.85345018e-01f, 2.44320586e-01f, -1.08772099e-01f, -3.83539915e-01f, 1.33924857e-01f, -2.55609136e-02f,
  1.58981115e-01f, -2.96247154e-01f, 2.53189802e-01f, 3.85828465e-01f, 5.17466068e-01f, -2.68030435e-01f, 3.53021435e-02f, 1.72804788e-01f, -7.02205822e-02f, -1.46430135e-01f,
  1.09800394e-03f, -1.53519109e-01f, -1.77440077e-01f, 1.40656173e-01f, 5.23352921e-01f, 3.43912184e-01f, 1.66852191e-01f, -1.23103932e-01f, 5.00335455e-01f, -7.67104253e-02f,
  2.13448867e-01f, 3.84303033e-02f, 3.42871994e-01f, 3.43390971e-01f, -3.62406522e-01f, -3.96458179e-01f, -2.60853052e-01f, 2.10559070e-01f, 2.91816443e-01f, 3.13124627e-01f,
  3.52921188e-01f, 3.27931911e-01f, 1.82278857e-01f, 4.93328303e-01f, -1.10125989e-01f, 8.96277186e-03f, -3.04167151e-01f, -1.16127282e-01f, 5.47969162e-01f, 3.45353298e-02f,
  2.86245614e-01f, 3.40220571e-01f, 9.55104828e-03f, -2.69773096e-01f, -2.11432427e-02f, 2.32211798e-02f, 2.44979300e-02f, 1.81851655e-01f, 4.00576770e-01f, 2.93814152e-01f,
  -1.77260488e-01f, 4.43306975e-02f, 2.40719289e-01f, -3.92090008e-02f, 1.58010066e-01f, 2.42418930e-01f, 3.26851070e-01f, 4.07421678e-01f, 2.60980189e-01f, -8.20418373e-02f,
  4.68038209e-02f, -9.17223766e-02f, 1.76235378e-01f, 2.33691320e-01f, 2.14866862e-01f, 2.18224406e-01f, 2.22869366e-01f, -4.50058401e-01f, -4.46114928e-01f, 1.39195800e-01f,
  4.51873392e-02f, 4.43322003e-01f, 1.87419742e-01f, -4.97958571e-01f, -1.87701210e-01f, 4.21568096e-01f, 2.27103099e-01f, 2.57689387e-01f, 2.69069880e-01f, 2.05879539e-01f,
  1.55075237e-01f, 3.96925420e-01f, 8.13002288e-02f, -3.98865014e-01f, 4.17053699e-02f, 4.56435114e-01f, -6.76878691e-02f, -1.24501027e-01f, 1.11645825e-01f, 1.38180673e-01f,
  -1.40099511e-01f, 4.37706649e-01f, 2.99311578e-01f, 2.42798418e-01f, 3.74690503e-01f, 1.39653040e-02f, 3.54004502e-02f, -2.41213828e-01f, 4.62521344e-01f, 4.45198715e-01f,
  -1.41042605e-01f, -2.50029117e-01f, -2.19272211e-01f, -3.14966924e-02f, 3.65191668e-01f, -2.32475176e-01f, 1.92325011e-01f, 1.35530472e-01f, -3.57843399e-01f, 2.15053968e-02f,
  -7.83830509e-02f, 1.44236639e-01f, 2.30083615e-01f, 1.22474082e-01f, -1.37515903e-01f, -3.32732022e-01f, -1.95480973e-01f, 2.69451827e-01f, -2.14024827e-01f, 9.23696160e-02f,
  -1.27987787e-01f, 3.75262618e-01f, 3.09984758e-02f, 2.33305678e-01f, 2.70949244e-01f, -7.11439997e-02f, 4.10805672e-01f, -8.55630115e-02f, 3.63591999e-01f, -7.09404051e-02f,
  2.40453303e-01f, 4.16664720e-01f, -2.11710945e-01f, -1.99755102e-01f, -1.55734777e-01f, -3.95876961e-03f, 1.47083491e-01f, 3.16697806e-02f, 2.45039523e-01f, 2.24492535e-01f,
  -5.60295470e-02f, 2.18787678e-02f, 1.00412615e-01f, -6.70011714e-03f, 4.22805667e-01f, 2.42295817e-01f, 2.83792853e-01f, 1.63684130e-01f, 3.27987522e-01f, -1.52426764e-01f,
  2.47140691e-01f, 3.91457677e-02f, 4.89013970e-01f, -7.15762526e-02f, 2.39443704e-01f, 7.00236186e-02f, -1.12423785e-01f, -3.20023715e-01f, 7.52652511e-02f, 1.34238586e-01f,
  6.64392710e-02f, -6.77135289e-02f, -1.76943354e-02f, -2.27001622e-01f, -7.80083388e-02f, 5.55617929e-01f, 5.06042987e-02f, 4.02495489e-02f, -2.86619931e-01f, 1.95080653e-01f,
  8.04351717e-02f, 3.52262884e-01f, 5.28626323e-01f, -1.64311811e-01f, -3.66519578e-02f, 1.92230955e-01f, -1.99854404e-01f, -3.98190618e-01f, -2.49808460e-01f, 7.09530637e-02f,
  7.19125047e-02f, 3.38919789e-01f, -3.09005260e-01f, 3.57272565e-01f, -8.99368227e-02f, 1.79681163e-02f, 3.37225884e-01f, 7.57049397e-02f, -2.75484193e-02f, -2.14869335e-01f,
  1.81204975e-01f, -2.90335640e-02f, 5.71936481e-02f, 1.10916354e-01f, 2.42705643e-01f, 9.23437476e-02f, 3.19609821e-01f, -1.94581300e-01f, 4.77868706e-01f, -4.31437641e-02f,
  1.82040468e-01f, -4.50501144e-02f, -3.47474329e-02f, -5.20257875e-02f, -2.30032429e-01f, 8.84536877e-02f, 3.76610309e-02f, 1.00582957e-01f, -1.61721826e-01f, -1.23271011e-01f,
  -1.50905445e-01f, 2.60428898e-02f, 4.00247604e-01f, 2.18952015e-01f, 5.58619611e-02f, 2.77197331e-01f, -6.11171536e-02f, 1.48900524e-01f, 3.35009992e-01f, -1.25648320e-01f,
  -2.95163486e-02f, -3.61574113e-01f, -2.33087689e-02f, -1.19840614e-01f, 4.08448070e-01f, 1.53345674e-01f, -7.26455748e-02f, -2.26186916e-01f, 1.74534559e-01f, -1.72602057e-01f,
  4.81744349e-01f, 1.69936135e-01f, 3.80152278e-02f, -2.43899167e-01f, -3.69779617e-01f, -1.45044476e-01f, -1.93928450e-01f, 2.86413461e-01f, 5.66529576e-03f, 2.32801184e-01f,
  3.20843786e-01f, 2.59154499e-01f, 1.82694241e-01f, -6.66324943e-02f, 1.08507432e-01f, -4.94444408e-02f, 4.50867862e-01f, 2.49392167e-01f, 4.02637243e-01f, 3.36236328e-01f,
  8.16407427e-02f, 9.75043401e-02f, 2.37486005e-01f, 3.06403667e-01f, -2.50411421e-01f, 1.45349205e-02f, 2.60203868e-01f, 4.99806821e-01f, 3.91008884e-01f, -4.78066862e-01f,
  -4.82424170e-01f, -1.87192425e-01f, 1.93823263e-01f, 2.50872344e-01f, 7.13185742e-02f, -3.64565849e-01f, -4.29433703e-01f, 3.26515764e-01f, -9.42654312e-02f, 2.13418063e-02f,
  4.46528077e-01f, 1.47016838e-01f, 1.88173726e-01f, 3.81233692e-01f, 3.17730069e-01f, -2.85671055e-01f, 3.45473997e-02f, 9.34611708e-02f, 4.00130212e-01f, -2.14431494e-01f,
  3.61170560e-01f, -1.42852604e-01f, -1.16271876e-01f, 5.27822316e-01f, 7.73376822e-02f, -7.11860061e-02f, 4.22676802e-01f, 1.10955641e-01f, 1.03807949e-01f, -1.88774206e-02f,
  -2.18326654e-02f, 1.72893330e-01f, -1.24656260e-01f, 4.92543191e-01f, -2.73355156e-01f, 3.71734917e-01f, 1.32618695e-01f, 3.63819748e-01f, 3.81664336e-01f, 1.25302989e-02f,
  3.06392640e-01f, -5.11587560e-02f, 2.08720103e-01f, 2.64539033e-01f, 2.55119819e-02f, -3.55407293e-03f, 1.87176660e-01f, -1.64995670e-01f, 2.45393395e-01f, 6.35249093e-02f,
  1.54763997e-01f, 2.71955729e-01f, 1.70548424e-01f, -1.38066739e-01f, -2.26944849e-01f, -1.23710498e-01f, 3.79793108e-01f, 1.21560441e-02f, 2.37524316e-01f, 3.64105403e-01f,
  -1.08351491e-01f, 3.92672062e-01f, -4.27484475e-02f, 1.08135216e-01f, -1.16990842e-01f, 1.47912661e-02f, 4.08632666e-01f, 4.12479669e-01f, 4.13341939e-01f, -1.13616124e-01f,
  -8.54292735e-02f, -1.01366669e-01f, -4.86824242e-03f, -1.57409385e-01f, 1.71847180e-01f, -1.13858975e-01f, 3.33384991e-01f, 1.75059289e-01f, 1.57807395e-01f, -9.50538516e-02f,
  4.69619893e-02f, -1.81928158e-01f, 4.53555644e-01f, -2.66161617e-02f, 2.36937329e-01f, 2.45252013e-01f, 2.01010197e-01f, 3.27319175e-01f, 9.46411267e-02f, 2.32319683e-01f,
  -1.65512726e-01f, -1.45605817e-01f, 1.05971411e-01f, -7.44384080e-02f, 1.04211926e-01f, -3.90282303e-01f, -2.96439230e-01f, 3.25923115e-01f, -3.39368433e-01f, 2.83598423e-01f,
  -5.32353483e-03f, -1.17468685e-02f, -3.25258374e-02f, 4.57505822e-01f, 4.41845298e-01f, -6.20360188e-02f, 2.80416399e-01f, 2.84560084e-01f, 6.56238617e-03f, -4.40732203e-02f,
  3.09400886e-01f, -2.25778803e-01f, 1.40936971e-01f, 2.24963222e-02f, 2.92018533e-01f, -6.95931241e-02f, -9.61051136e-02f, -4.58440602e-01f, 1.34018483e-02f, 1.38312681e-02f,
  2.45427281e-01f, -6.40577823e-02f, 2.73911655e-01f, 8.11145306e-02f, 6.91394657e-02f, 3.92500013e-01f, -2.28213295e-01f, 4.18387800e-01f, 1.06261402e-01f, 3.43458593e-01f,
  3.34895521e-01f, 6.83118105e-02f, 2.59844750e-01f, 4.08602595e-01f, 5.45728244e-02f, -2.76937097e-01f, 3.04907799e-01f, -1.59294158e-01f, 1.11853004e-01f, -3.85515094e-02f,
  -8.04126486e-02f, 2.66813427e-01f, -2.20069364e-01f, -7.42795318e-02f, -2.23235309e-01f, 1.80206791e-01f, -1.91975832e-01f, 4.28790078e-02f, 5.37519120e-02f, 2.89712846e-01f,
  3.65049392e-01f, 2.96856493e-01f, -2.95476079e-01f, -2.75093496e-01f, 2.67967075e-01f, -1.98998705e-01f, 1.76806301e-01f, -3.55305761e-01f, 3.24090302e-01f, 2.28076905e-01f,
  4.16688979e-01f, -3.89499366e-02f, -1.69837594e-01f, 1.15725271e-01f, 4.38878499e-02f, -3.18425387e-01f, 3.62924546e-01f, 2.50915110e-01f, 1.00365266e-01f, 1.97632417e-01f,
  -5.72943653e-04f, 1.69058084e-01f, -1.88342512e-01f, -1.65165633e-01f, -1.14458553e-01f, -2.38752201e-01f, 1.03714071e-01f, 1.42203480e-01f, -1.34515628e-01f, 2.44606689e-01f,
  1.50348648e-01f, 1.04295500e-01f, 1.34868681e-01f, -2.89501190e-01f, -1.21747050e-02f, -3.95066530e-01f, 1.72010943e-01f, 4.45984036e-01f, 7.70505741e-02f, 3.10848862e-01f,
  -8.11414421e-02f, 3.74846935e-01f, 6.73145056e-02f, 8.43174476e-03f, 4.14190769e-01f, 2.93173879e-01f, 1.49857357e-01f, -1.60228282e-01f, 6.90576285e-02f, -9.39369500e-02f,
  -7.66595230e-02f, 2.64508098e-01f, 1.39007747e-01f, -2.79884040e-03f, 1.94053426e-01f, 4.03380185e-01f, -2.36241877e-01f, -2.89693892e-01f, 2.62711085e-02f, 2.48976454e-01f,
  -1.25127658e-01f, -2.01908201e-01f, -1.85313553e-01f, 3.71417314e-01f, 4.16571461e-02f, 3.66584271e-01f, 4.27964509e-01f, 2.16901422e-01f, 4.32324678e-01f, 4.26137410e-02f,
  -7.11890310e-03f, -5.35629876e-02f, 3.73337895e-01f, 4.30445433e-01f, -5.23805991e-02f, -2.36356318e-01f, -2.42125332e-01f, 1.35153711e-01f, 2.45880023e-01f, -1.95597246e-01f,
  9.67308655e-02f, 1.15932353e-01f, -1.49644148e-02f, 6.28841370e-02f, 3.50355983e-01f, 3.19267899e-01f, 1.97364420e-01f, 3.35032493e-01f, 1.50975689e-01f, -4.46960360e-01f,
  2.54759043e-02f, 2.17311502e-01f, 3.62034254e-02f, -1.37750193e-01f, 1.64450735e-01f, 1.42087460e-01f, -2.27641791e-01f, 2.35386372e-01f, 4.50405687e-01f, 3.02893072e-01f,
  4.36160177e-01f, 1.84306979e-01f, 1.58370599e-01f, -1.15948627e-02f, 4.42773283e-01f, 3.37405056e-02f, -4.27207261e-01f, -2.43773028e-01f, 7.86249712e-02f, 1.96634188e-01f,
  3.61687243e-01f, -7.87494853e-02f, 1.23546802e-01f, 2.20806152e-01f, 7.05857873e-02f, 2.07344115e-01f, 1.46735623e-01f, 2.32319281e-01f, 1.33585900e-01f, 2.29490757e-01f,
  2.19935849e-01f, -6.73059979e-03f, 2.19231043e-02f, 3.24307829e-01f, -3.01662851e-02f, -2.05522612e-01f, 2.68451124e-01f, -7.38731772e-02f, 1.38304397e-01f, 1.34430036e-01f,
  2.58921504e-01f, 1.61144286e-01f, 3.74143958e-01f, -3.42382379e-02f, -1.09811544e-01f, -1.69390693e-01f, 6.66528642e-02f, 4.29402769e-01f, -3.48597541e-02f, -1.56524494e-01f,
  -2.50129968e-01f, 8.56592283e-02f, 2.84477621e-01f, -1.64096132e-01f, 2.89784670e-01f, 3.23010832e-01f, 2.41460443e-01f, -9.35636985e-04f, -9.70603898e-02f, 3.54382575e-01f,
  3.13938290e-01f, 6.94903210e-02f, 8.97689350e-03f, -1.34733468e-01f, 1.60368055e-01f, -1.29808396e-01f, -7.05000758e-03f, 2.57806897e-01f, 4.14908469e-01f, -4.87180874e-02f,
  2.70002894e-02f, -2.75066257e-01f, 4.34175670e-01f, -2.80986633e-02f, -1.35025471e-01f, 3.98048043e-01f, -1.48549959e-01f, 1.71313435e-01f, 5.32078147e-02f, -2.05505818e-01f,
  -3.57495189e-01f, -6.21941984e-02f, -1.44083977e-01f, 2.48301789e-01f, 2.29908645e-01f, -4.76606369e-01f, -2.43053928e-01f, 4.73883152e-01f, -3.91688524e-03f, -8.44866857e-02f,
  3.22839558e-01f, -1.06400624e-01f, 1.91665605e-01f, 1.78964466e-01f, 2.91797161e-01f, -8.02693963e-02f, -1.04512140e-01f, 2.28063211e-01f, 3.91753793e-01f, -2.25943257e-03f,
  9.92245525e-02f, -6.05905950e-02f, 1.26458883e-01f, 4.79931712e-01f, -1.89430982e-01f, 4.18060333e-01f, 9.36751366e-02f, -1.73531622e-01f, 2.06801891e-01f, -1.70983955e-01f,
  1.84415162e-01f, 2.71310925e-01f, -3.13012972e-02f, 5.43924123e-02f, -1.97060704e-01f, -3.05007756e-01f, 2.15541981e-02f, 2.75818288e-01f, 5.26405156e-01f, 9.23189595e-02f,
  1.45062923e-01f, -1.02838956e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  3.00761700e-01f, 7.70117044e-02f, 3.91572535e-01f, 3.36205095e-01f, -5.95550463e-02f, -2.90215071e-02f, 1.29836008e-01f, 1.66054040e-01f, 9.24184993e-02f, 1.97517112e-01f,
  -3.36173438e-02f, 6.62043989e-02f, 1.41806543e-01f, 2.12897286e-01f, 1.68297261e-01f, 3.18570375e-01f, 3.34667504e-01f, 2.03530133e-01f, 1.16526693e-01f, 6.11330122e-02f,
  4.60467748e-02f, -5.01565486e-02f, 2.96785980e-01f, -8.16896260e-02f, 2.46815205e-01f, 2.19835684e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.19836777e-01f, 3.02275605e-02f, 2.20457092e-01f, 9.82914716e-02f, -2.91404575e-01f, -1.35699719e-01f, 1.94812387e-01f, -4.34238277e-02f, -5.10675088e-02f, 1.55089557e-01f,
  -1.13672011e-01f, 9.89550501e-02f, 5.87223433e-02f, -5.56680607e-03f, 7.80073702e-02f, -3.16122547e-02f, -9.54535529e-02f, 1.55931413e-01f, -1.47519141e-01f, -1.61074951e-01f,
  -1.13660224e-01f, 1.57172941e-02f, 2.10839999e-03f, -1.28377557e-01f, 2.44327024e-01f, 1.10963494e-01f, 2.98288632e-02f, -4.47091050e-02f, -8.59437212e-02f, 2.95701653e-01f,
  -3.77719477e-02f, 1.26785845e-01f, 1.37515083e-01f, 1.93635866e-01f, 1.13106258e-01f, -1.58050090e-01f, 1.41794860e-01f, -8.37311223e-02f, -4.90970090e-02f, 7.80042773e-03f,
  1.55109301e-01f, 7.26064667e-02f, -1.31222263e-01f, -1.66490063e-01f, -1.22409537e-01f, 3.17354240e-02f, 1.86237171e-01f, 6.97794836e-03f, -1.74708426e-01f, 4.43955231e-03f,
  -2.03879345e-02f, 1.89105898e-01f, 1.71164557e-01f, -1.37065025e-02f, -1.14011317e-01f, 3.26387100e-02f, -1.10961147e-01f, -7.71566704e-02f, -8.07533786e-02f, -4.68787625e-02f,
  -1.06627820e-02f, 1.25456788e-02f, 2.90981442e-01f, -5.58277518e-02f, -7.94288218e-02f, 2.12529041e-02f, 2.25794986e-02f, -1.99564889e-01f, -2.59391040e-01f, 1.68304920e-01f,
  -1.45684138e-01f, -7.89915100e-02f, -5.59825636e-02f, 1.30670190e-01f, -1.23713642e-01f, 2.96427519e-03f, 1.16493717e-01f, 2.04039533e-02f, 8.80349278e-02f, -1.89626992e-01f,
  -1.14354794e-03f, -9.00809467e-02f, 3.73147801e-02f, 1.42116398e-01f, -1.82675198e-01f, -6.65521622e-02f, -8.92976448e-02f, -3.35821658e-02f, 2.18442708e-01f, 5.80820516e-02f,
  1.13306791e-01f, 6.82537109e-02f, -7.55548850e-03f, -1.48303896e-01f, 7.75130838e-02f, 1.11134186e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -1.06211834e-01f, 1.58022448e-01f, -1.21855726e-02f, -2.57525176e-01f, -7.41891786e-02f, -8.75432193e-02f, 3.53385597e-01f, -3.76320809e-01f, 1.82707474e-01f, 2.59479165e-01f,
  1.70248926e-01f, -6.20446801e-02f, 1.49984181e-01f, -6.29440919e-02f, 1.81539636e-02f, 2.14750916e-02f, 3.03237826e-01f, -1.71132267e-01f, 3.14570516e-01f, 2.43416548e-01f,
  -1.46856131e-02f, -2.60575950e-01f, -1.27272502e-01f, 5.37425801e-02f, -4.95388396e-02f, 2.53416270e-01f, 6.63088933e-02f, -2.83972733e-02f, -1.78030893e-01f, -1.87075347e-01f,
  -1.89684257e-01f, 1.32077839e-02f, -7.48369321e-02f, -2.57585436e-01f, 8.28880966e-02f, 8.77242070e-03f, 4.28825879e-04f, 3.04962844e-01f, 4.80265856e-01f, 8.56675655e-02f,
  6.86718896e-02f, 3.21594775e-01f, 2.14882314e-01f, 1.86615527e-01f, 2.11571470e-01f, -1.62495136e-01f, -3.08697999e-01f, 2.44081736e-01f, 7.70903602e-02f, 1.84423879e-01f,
  1.85742289e-01f, 6.87367693e-02f, -5.97589374e-01f, 2.44420186e-01f, -1.02295712e-01f, -6.79424405e-02f, 2.12610528e-01f, -4.41703992e-03f, 1.65915117e-01f, 1.47717774e-01f,
  -5.54618351e-02f, 3.50674570e-01f, -1.50152922e-01f, 2.63419807e-01f, -5.09497561e-02f, -2.21476451e-01f, 1.70000553e-01f, -1.01621099e-01f, -3.74386519e-01f, -2.81586051e-01f,
  1.00102596e-01f, -3.70127231e-01f, 1.74801305e-01f, 3.05555344e-01f, -1.35738906e-02f, -7.25920079e-03f, 3.42195123e-01f, 6.77925814e-03f, 1.17066450e-01f, 8.39545652e-02f,
  5.03317714e-02f, -2.43999455e-02f, 6.67514503e-02f, 2.60663331e-01f, 1.76705346e-01f, -1.60845548e-01f, -8.96657333e-02f, 4.16453695e-03f, -8.69357809e-02f, 3.20742190e-01f,
  1.45118520e-01f, 1.02925427e-01f, -9.52065140e-02f, 1.78984359e-01f, -1.34075694e-02f, 1.46655396e-01f, 1.82201505e-01f, 3.98871899e-02f, 4.60517049e-01f, -3.43897015e-01f,
  -4.77694124e-01f, -2.27698773e-01f, 1.97650060e-01f, 3.22907180e-01f, 1.52018592e-01f, 7.73141384e-02f, -2.20060080e-01f, 1.49091110e-01f, -3.58977839e-02f, 4.02388096e-01f,
  -1.46526262e-01f, 2.42253486e-02f, -2.89193481e-01f, 2.13171393e-01f, 2.32026696e-01f, 2.53052175e-01f, -1.52263403e-01f, 1.65588602e-01f, 2.31714606e-01f, 7.72392824e-02f,
  4.19471532e-01f, -1.01220377e-01f, 7.79044777e-02f, -2.57976472e-01f, 4.91783544e-02f, -1.05546147e-01f, -3.32280606e-01f, 1.25899762e-01f, -1.36313289e-01f, 4.71031927e-02f,
  -1.53889105e-01f, 1.65545911e-01f, 1.39691368e-01f, -7.38568828e-02f, -2.46259749e-01f, 2.71496862e-01f, 1.80399001e-01f, -1.31745636e-01f, -1.79901645e-01f, 6.34213388e-02f,
  -1.57932803e-01f, -8.02690014e-02f, 2.63966620e-01f, 2.10724607e-01f, 1.37459457e-01f, -1.67080775e-01f, -5.59842996e-02f, 9.90973637e-02f, 3.03036124e-01f, 8.57176110e-02f,
  -1.53045684e-01f, 9.76211727e-02f, -2.61582136e-01f, -1.60545763e-02f, 5.94442757e-03f, 2.12646872e-01f, 3.47886443e-01f, 3.05112511e-01f, 3.62264477e-02f, -1.01942264e-01f,
  -7.21430480e-02f, 2.49078318e-01f, -8.06303993e-02f, -2.58047581e-01f, -2.79785067e-01f, -6.46241456e-02f, 3.01406264e-01f, -1.70957461e-01f, 3.11684042e-01f, 1.52507797e-01f,
  -2.68345058e-01f, 2.59047955e-01f, 2.36772507e-01f, -1.15266152e-01f, 2.79211372e-01f, -1.45358235e-01f, -1.16531819e-01f, 2.41220728e-01f, 5.48252910e-02f, 3.22499901e-01f,
  2.62642235e-01f, 2.20853999e-01f, -2.09364608e-01f, 1.38708539e-02f, -6.17103912e-02f, 5.54105788e-02f, 7.74242356e-02f, -1.15673088e-01f, -1.10508919e-01f, -2.54859209e-01f,
  -3.09357882e-01f, 4.58632022e-01f, 2.26164743e-01f, -4.12416868e-02f, 7.59373605e-02f, -2.54068285e-01f, 1.65565878e-01f, -1.59872100e-01f, -1.24731377e-01f, 2.06964687e-01f,
  -9.00256187e-02f, 6.31773844e-02f, 2.96571046e-01f, -7.14913011e-02f, 1.08584084e-01f, 1.91069506e-02f, 2.32139692e-01f, -3.91489834e-01f, -3.14683020e-01f, 3.48587215e-01f,
  -8.21867213e-02f, 1.22107878e-01f, -1.47167325e-01f, 2.32133403e-01f, 2.73268193e-01f, 1.21864915e-01f, 2.37045974e-01f, -3.18336070e-01f, 2.62565166e-01f, -3.24900687e-01f,
  1.10241905e-01f, -1.70151994e-01f, -1.43623706e-02f, -2.82661077e-02f, 3.73342842e-01f, 8.22734535e-02f, 1.50668211e-02f, -5.82465887e-01f, -1.35659408e-02f, 2.86942631e-01f,
  -6.68746382e-02f, -1.70748942e-02f, 4.27082837e-01f, 3.53282541e-01f, -8.38163942e-02f, -4.31470603e-01f, 2.48999689e-02f, 4.92537826e-01f, 1.08041979e-01f, -3.04047704e-01f,
  2.03746259e-02f, 2.68594980e-01f, 2.42716491e-01f, 4.12339479e-01f, 2.37171814e-01f, 2.09549442e-01f, 2.63468057e-01f, 4.20251153e-02f, 2.39317775e-01f, -8.99203643e-02f,
  1.36711955e-01f, -3.50621194e-01f, 6.36506304e-02f, -3.46212000e-01f, 1.42280295e-01f, -2.61659116e-01f, -1.54322013e-01f, 1.70119911e-01f, 1.01239763e-01f, 1.96753889e-01f,
  -1.91610590e-01f, -3.10448676e-01f, -1.67043164e-01f, -2.43370887e-02f, 2.47329190e-01f, 8.17889124e-02f, 8.54175463e-02f, -2.04289705e-01f, -1.42654106e-01f, -1.99846074e-01f,
  2.39307195e-01f, 1.96153238e-01f, 2.72045523e-01f, 2.23390207e-01f, -2.22270697e-01f, -1.17354408e-01f, 3.44408125e-01f, 8.81570429e-02f, -1.36693165e-01f, 9.91326198e-02f,
  -4.53103244e-01f, 1.07325271e-01f, 3.30064595e-02f, 4.74990197e-02f, 2.61270553e-01f, 1.51557028e-01f, 2.16884673e-01f, 2.29915097e-01f, 6.43253103e-02f, 4.46071252e-02f,
  9.96762887e-02f, -6.84155570e-03f, -1.90227181e-01f, -2.37378195e-01f, 3.32379937e-01f, 5.94523139e-02f, 1.90887675e-01f, -3.51290479e-02f, 1.49530947e-01f, 4.76016939e-01f,
  2.72340506e-01f, -2.26157948e-01f, -4.43512797e-02f, 1.20449290e-01f, 2.55685776e-01f, 2.82655299e-01f, 6.83251992e-02f, -1.43118784e-01f, -7.08530694e-02f, 3.49780738e-01f,
  -8.66317302e-02f, 3.25532854e-01f, -1.32766306e-01f, 3.70066762e-01f, 7.23219886e-02f, 9.39733014e-02f, 1.12592034e-01f, 2.71527350e-01f, -2.55717784e-01f, 3.73070300e-01f,
  -1.43597471e-02f, -6.40655160e-02f, -1.46621302e-01f, 2.90234298e-01f, 3.95602323e-02f, 6.33587763e-02f, -9.12727714e-02f, 2.56350219e-01f, 3.46458964e-02f, -4.12870198e-02f,
  -3.83699894e-01f, 2.81615973e-01f, 6.79074377e-02f, 1.83932334e-01f, -1.12613641e-01f, 4.92829978e-01f, 4.18271482e-01f, -4.50407624e-01f, -4.02406007e-02f, -7.68602937e-02f,
  1.93448529e-01f, 2.52020299e-01f, 1.79573521e-01f, -1.35870829e-01f, 1.40400110e-02f, 2.71218181e-01f, 6.93343729e-02f, 5.95595181e-01f, 5.03563285e-01f, 2.92629927e-01f,
  -5.08476095e-03f, 3.64770651e-01f, -2.37817541e-01f, -1.41907841e-01f, -1.25617594e-01f, 3.66100192e-01f, -1.28908493e-02f, -1.80462912e-01f, 1.82731554e-01f, -3.00163239e-01f,
  -1.49175316e-01f, -5.93569614e-02f, 2.13092521e-01f, 1.27724230e-01f, 1.92509755e-01f, -6.01280987e-01f, -4.97766596e-04f, 1.38950735e-01f, 1.18090503e-01f, 2.70961493e-01f,
  -1.18849151e-01f, -1.27672225e-01f, 9.31251720e-02f, 2.82893687e-01f, -1.37118742e-01f, 2.11890250e-01f, -9.04736295e-02f, 3.76249492e-01f, -2.06583485e-01f, -8.47952887e-02f,
  3.88572663e-02f, 1.73952952e-01f, 2.24191770e-01f, 1.17240466e-01f, 4.49586548e-02f, 5.32887615e-02f, 1.00941531e-01f, 6.73902482e-02f, -4.49672729e-01f, -3.39787722e-01f,
  2.65717953e-01f, -2.14195356e-01f, 9.92959589e-02f, 1.53126493e-01f, 2.66576290e-01f, -2.05780089e-01f, 2.88564980e-01f, -2.48174399e-01f, 3.98486793e-01f, -2.04964250e-01f,
  -8.68415833e-02f, 3.59714150e-01f, 1.41455054e-01f, 4.53088160e-06f, 1.46079943e-01f, 1.98344186e-01f, 4.79649603e-02f, 2.54651338e-01f, -1.93959519e-01f, 4.29924846e-01f,
  -1.39692202e-01f, -8.54339600e-02f, -4.31636907e-02f, 1.06721796e-01f, 2.22232983e-01f, -1.93443894e-01f, 1.23831160e-01f, 1.35623500e-01f, 1.44376099e-01f, -1.90321922e-01f,
  -2.60062814e-01f, 3.34527157e-02f, -2.97254473e-01f, -3.22211608e-02f, 3.41206044e-01f, 1.08255565e-01f, -1.55465469e-01f, -2.20832899e-01f, -3.16964924e-01f, 5.30129373e-01f,
  1.57887071e-01f, -1.97218463e-01f, -3.53297591e-01f, 1.45075232e-01f, -2.25730538e-01f, -2.77607441e-02f, 3.11102360e-01f, 2.38765582e-01f, 2.72284061e-01f, 2.22169962e-02f,
  5.06492496e-01f, -4.32118863e-01f, -2.85416972e-02f, -3.39457929e-01f, 1.02794170e-02f, 3.39436531e-02f, 3.34361702e-01f, -9.30020809e-02f, -2.35779613e-01f, 2.52544105e-01f,
  -1.03778347e-01f, -1.78763479e-01f, 6.72365203e-02f, 4.43130791e-01f, -2.18616143e-01f, -3.15956205e-01f, 6.54124469e-02f, 4.63352114e-01f, -9.53566581e-02f, -3.91785353e-01f,
  1.20957777e-01f, 2.34174624e-01f, 2.39663631e-01f, 1.58442691e-01f, 3.41951013e-01f, -1.04387797e-01f, 3.20594877e-01f, 3.64586830e-01f, 2.71079779e-01f, -3.55024934e-02f,
  3.16833228e-01f, -9.55677554e-02f, -5.13184592e-02f, 2.32012402e-02f, 4.22143877e-01f, 1.17165297e-02f, 2.25162074e-01f, -1.49882317e-01f, 1.06504731e-01f, -1.65031284e-01f,
  -1.28346294e-01f, 2.35587075e-01f, 2.19038844e-01f, -2.74032623e-01f, -4.43675697e-01f, -2.48154894e-01f, 3.84343505e-01f, -3.19754742e-02f, 1.47718221e-01f, 2.71410227e-01f,
  -1.84738502e-01f, -1.05453664e-02f, 2.72711813e-02f, 3.46707731e-01f, -1.14194475e-01f, -3.78435284e-01f, -3.94753635e-01f, 4.34264362e-01f, 1.24399342e-01f, 5.31383269e-02f,
  -1.44217074e-01f, -4.07597087e-02f, -6.07379563e-02f, 2.27932613e-02f, 2.29015782e-01f, 1.95265234e-01f, 1.56095266e-01f, -3.40862840e-01f, -3.55684966e-01f, -8.15504566e-02f,
  2.46401697e-01f, 1.05431959e-01f, 1.62215903e-01f, 1.76131085e-01f, 2.37793192e-01f, 3.02654542e-02f, -3.86043876e-01f, -3.25493008e-01f, 3.24307591e-01f, 1.99422371e-02f,
  2.97373503e-01f, -1.08449608e-01f, -2.17305675e-01f, 3.46262157e-01f, 2.41000146e-01f, 1.27343656e-02f, 4.59167100e-02f, 3.52774449e-02f, 5.23318164e-02f, 2.41552085e-01f,
  -4.91481945e-02f, 3.98217104e-02f, 2.41747946e-01f, 8.60097352e-03f, -2.19609857e-01f, 2.93828696e-01f, -1.50373608e-01f, 1.12317741e-01f, -3.59161407e-01f, 5.63661419e-02f,
  -1.55105479e-02f, 1.52149826e-01f, -2.86948830e-01f, 4.60414201e-01f, 4.97770011e-02f, -1.44365221e-01f, 2.19304636e-01f, -4.72937264e-02f, -3.32225394e-03f, -2.86999822e-01f,
  -1.47810325e-01f, 3.72975618e-01f, -2.07058489e-01f, -3.02040547e-01f, -1.32681325e-01f, 1.57065198e-01f, 6.63580596e-02f, 2.10158423e-01f, -1.49247885e-01f, 1.02384642e-01f,
  2.96941511e-02f, 1.83493234e-02f, -1.93368830e-02f, -1.69178188e-01f, -5.52269146e-02f, 4.05167997e-01f, 6.44066259e-02f, -1.78416222e-02f, 3.47562909e-01f, 9.14633647e-02f,
  -1.47011653e-01f, -6.83769509e-02f, 1.03087805e-01f, -3.85247394e-02f, -2.85999566e-01f, 2.01449394e-01f, 1.10882752e-01f, 1.31736726e-01f, -1.92258693e-02f, 1.50214344e-01f,
  5.46332061e-01f, 3.55915517e-01f, -1.26535580e-01f, 1.55011714e-01f, -3.29672545e-01f, -9.54205245e-02f, 4.20581222e-01f, -5.68715436e-03f, 7.37319095e-03f, -1.30636290e-01f,
  3.22132885e-01f, 5.74639775e-02f, -1.69024244e-01f, 2.68402100e-01f, 1.05818130e-01f, -3.44797336e-02f, 1.70366943e-01f, 2.33753338e-01f, 1.99447259e-01f, 4.68415730e-02f,
  2.54870933e-02f, -1.32216543e-01f, 1.79033101e-01f, -7.64606986e-03f, 1.81292728e-01f, 2.33263046e-01f, 3.38792652e-01f, -2.78791368e-01f, 2.38894895e-01f, -4.80373669e-03f,
  -8.59614015e-02f, 3.22029054e-01f, -4.35822196e-02f, -1.72373012e-01f, 5.68557903e-03f, 1.38064906e-01f, 2.16742322e-01f, -5.13656139e-01f, 2.05717579e-01f, 1.17714340e-02f,
  -3.65691155e-01f, -2.74964035e-01f, 2.03337461e-01f, 5.74635416e-02f, -2.97891758e-02f, 4.50415820e-01f, -4.60298330e-01f, -3.37608188e-01f, 3.74526352e-01f, 3.94927472e-01f,
  -5.15921973e-02f, 5.46023071e-01f, -5.36621176e-02f, -2.08051503e-01f, -4.46229190e-01f, 6.24716952e-02f, 2.65044481e-01f, 8.55783150e-02f, 3.19239199e-01f, 7.45242536e-02f,
  5.16982339e-02f, -1.34884669e-02f, -2.65237316e-02f, 1.55839417e-02f, 2.52401888e-01f, 2.40163133e-01f, 2.41924580e-02f, 8.17547664e-02f, 1.40199217e-03f, 3.14699054e-01f,
  -1.40272066e-01f, -5.53092957e-02f, 4.13350314e-01f, 7.09820613e-02f, 9.98910293e-02f, 1.48627624e-01f, 3.08329612e-01f, -1.44092128e-01f, 3.44132900e-01f, 2.67726392e-01f,
  -3.60072941e-01f, 1.51238739e-01f, -1.17866985e-01f, -3.52839023e-01f, 7.76955038e-02f, 3.82951170e-01f, 3.51261385e-02f, 3.28860939e-01f, 1.57321304e-01f, 2.36967430e-01f,
  -1.71897739e-01f, -2.04295125e-02f, 1.62659243e-01f, -1.44213319e-01f, 3.04331779e-02f, 1.49657493e-02f, 2.25302324e-01f, 1.03136815e-01f, -2.40697622e-01f, -4.66760155e-03f,
  -1.33533016e-01f, 1.40192881e-01f, 3.96011807e-02f, -1.91610307e-01f, 2.21167296e-01f, -2.17511117e-01f, 2.33792081e-01f, 2.76425928e-01f, 4.36336607e-01f, -2.79733390e-01f,
  2.30438560e-02f, -5.79670593e-02f, -1.39351726e-01f, -1.87886227e-02f, 1.15212150e-01f, -2.85107404e-01f, 1.08097523e-01f, 1.88672811e-01f, 2.80633301e-01f, 1.57059744e-01f,
  1.20319486e-01f, 1.63807366e-02f, -2.61492711e-02f, 2.48927828e-02f, 2.55670041e-01f, -7.49148130e-02f, -5.18635549e-02f, 9.45833698e-02f, -9.38652176e-03f, -3.35450798e-01f,
  5.36346495e-01f, 2.06664782e-02f, 1.22984931e-01f, -1.11058511e-01f, -1.16611175e-01f, 1.33713350e-01f, 1.05730500e-02f, -4.26363885e-01f, 1.06708847e-01f, 4.37958278e-02f,
  7.34507712e-03f, 2.40055650e-01f, 1.31474733e-01f, -1.56220406e-01f, 1.48778781e-02f, 1.54963791e-01f, -4.54080403e-01f, 3.71863931e-01f, -3.26609015e-01f, 8.35299566e-02f,
  -4.23686504e-01f, 4.93805297e-02f, 3.63412164e-02f, -1.08980745e-01f, 3.55723500e-03f, 1.44861147e-01f, 1.79647982e-01f, 8.00980851e-02f, 2.61597693e-01f, 1.46129608e-01f,
  4.82891314e-02f, 1.29518330e-01f, -2.70879626e-01f, 4.46035504e-01f, -5.39636128e-02f, -2.29848221e-01f, -2.02448964e-01f, -5.70438914e-02f, -2.60250956e-01f, 5.09076774e-01f,
  1.62059024e-01f, 3.23410958e-01f, 6.54145926e-02f, -3.58209610e-02f, -1.71124607e-01f, -1.75091028e-01f, 1.66505337e-01f, 3.29705238e-01f, 4.29676354e-01f, -1.09771326e-01f,
  2.00660765e-01f, -2.91091025e-01f, 4.45556268e-02f, -5.22717498e-02f, 3.57487649e-01f, 2.27994546e-01f, 3.59310597e-01f, 3.24975938e-01f, -3.44636559e-01f, 2.18137607e-01f,
  3.20610851e-01f, 1.22838520e-01f, -1.95280269e-01f, -4.35362346e-02f, 2.36646384e-01f, -4.30817902e-01f, 1.80065840e-01f, 3.71181667e-01f, 2.85485059e-01f, -4.11889911e-01f,
  2.01978594e-01f, -6.40956610e-02f, 1.56730413e-01f, -4.21521813e-01f, -1.28824204e-01f, 2.70462215e-01f, 2.35330969e-01f, 3.33352685e-01f, 4.34915237e-02f, -1.63470238e-01f,
  9.89022292e-03f, 1.72534704e-01f, -4.21163142e-02f, -1.27567336e-01f, 2.55613834e-01f, -2.74362922e-01f, -1.73753619e-01f, -4.60311174e-02f, 3.36962402e-01f, -2.58298725e-01f,
  1.04580827e-01f, 3.15030403e-02f, -1.00743651e-01f, 5.57906143e-02f, -2.30741277e-02f, 1.69261485e-01f, -6.10476546e-02f, 1.84580117e-01f, 1.48248896e-01f, 2.09358528e-01f,
  -1.22564830e-01f, -4.04493958e-01f, 1.45197213e-01f, 1.94700867e-01f, 1.63646802e-01f, 2.49254152e-01f, -1.12066502e-02f, -2.25505725e-01f, 1.63074672e-01f, 2.96181917e-01f,
  4.12537515e-01f, -8.72468650e-02f, 2.76052386e-01f, 1.45678356e-01f, -9.93670747e-02f, 1.34072244e-01f, 2.19732285e-01f, 2.57227719e-01f, 3.76718938e-01f, -2.04691105e-03f,
  4.37522084e-01f, -1.79251045e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  6.57988042e-02f, -1.16378456e-01f, 1.45982265e-01f, 3.71051282e-01f, 6.10140599e-02f, 2.83598632e-01f, -9.19691399e-02f, 2.57048279e-01f, 1.74608186e-01f, -1.38267890e-01f,
  -7.82346725e-03f, -3.74034792e-02f, 9.27442908e-02f, 2.44951710e-01f, 2.34450951e-01f, 2.14222535e-01f, 1.61399335e-01f, 6.66913483e-03f, -1.32277712e-01f, -2.24450324e-02f,
  1.11606598e-01f, 7.10659102e-02f, -4.03000191e-02f, 2.86322445e-01f, 4.31485176e-02f, 2.40289137e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  5.46886250e-02f, 1.07388727e-01f, 7.59131908e-02f, 1.51249796e-01f, 7.26114511e-02f, 3.06083441e-01f, -8.69451091e-02f, -3.10911983e-01f, 1.00665584e-01f, 2.15392634e-01f,
  -2.35065341e-01f, 3.26180995e-01f, 8.65026042e-02f, 2.01897576e-01f, -7.13117281e-03f, -5.25064945e-01f, -4.16952312e-01f, -2.83691406e-01f, -6.62784204e-02f, 3.14285159e-01f,
  2.32918754e-01f, 2.57338732e-01f, -3.39061201e-01f, -3.21084350e-01f, -2.69604325e-01f, -3.53022873e-01f, -2.96662480e-01f, -3.79805535e-01f, -1.82141617e-01f, 2.14003064e-02f,
  4.03678358e-01f, -6.38260320e-02f, -3.73407640e-02f, -2.33256459e-01f, -2.66414192e-02f, -3.18728179e-01f, 5.42270066e-03f, 2.03404590e-01f, 2.11857259e-01f, -2.86959857e-01f,
  1.35863155e-01f, -1.58292189e-01f, 1.35637239e-01f, 2.92755693e-01f, -3.23278368e-01f, 1.77437887e-01f, 1.46108225e-01f, -1.07682988e-01f, 5.97034814e-03f, -2.33015507e-01f,
  1.41163468e-01f, -3.41652721e-01f, 2.18740225e-01f, -2.83766627e-01f, -1.86817851e-02f, -8.76041502e-02f, -1.04601294e-01f, -1.42479837e-01f, 1.12872966e-01f, 6.87750429e-02f,
  -3.62317830e-01f, -3.10594976e-01f, 2.29664762e-02f, 8.69035572e-02f, -1.25124618e-01f, 1.94681212e-01f, 3.32242846e-02f, 2.99393684e-01f, -1.79721519e-01f, 1.71382651e-01f,
  1.61096916e-01f, 2.86187619e-01f, 1.48800060e-01f, -2.33033553e-01f, -2.63274282e-01f, 1.02628149e-01f, -1.77892447e-01f, -4.40713882e-01f, 8.55884776e-02f, 1.68003783e-01f,
  9.92219597e-02f, 1.80846989e-01f, 7.75076030e-03f, -1.91577554e-01f, 1.56391449e-02f, -8.65798816e-02f, 2.44395867e-01f, -2.65943289e-01f, -2.60993987e-01f, -3.83589059e-01f,
  2.62937725e-01f, 2.85963267e-01f, -5.83744496e-02f, -3.96785229e-01f, -2.81445473e-01f, -1.02032050e-01f, 1.06354371e-01f, 1.01200581e-01f, -1.34327054e-01f, -1.27070054e-01f,
  -1.40828118e-01f, 1.38635129e-01f, 1.48735577e-02f, 3.08089137e-01f, -4.31055516e-01f, 1.04582042e-01f, -1.44730926e-01f, 2.11301565e-01f, 3.38175178e-01f, -7.85620436e-02f,
  -4.30472642e-02f, 1.68952972e-01f, -3.83332789e-01f, 1.27175897e-01f, 1.10017814e-01f, 9.18480475e-03f, -3.60121042e-01f, 2.32120436e-02f, 9.51510891e-02f, 1.34802520e-01f,
  1.89833462e-01f, 2.38507509e-01f, -3.28403562e-01f, 6.78084046e-02f, 2.27973893e-01f, -5.64001277e-02f, -2.23633349e-01f, -6.37373745e-01f, 1.50525108e-01f, 5.37071787e-02f,
  2.13939592e-01f, 2.04077899e-01f, 1.95654094e-01f, -3.16781998e-01f, -2.97888637e-01f, -2.76154846e-01f, -6.56970143e-02f, 2.99000621e-01f, -7.50687048e-02f, 6.23398200e-02f,
  1.76073655e-01f, 1.73012897e-01f, 6.08469993e-02f, -8.54432657e-02f, -1.33804679e-01f, -3.89152795e-01f, 1.51256293e-01f, 3.30688506e-01f, -3.47151250e-01f, 1.23919286e-01f,
  1.32518739e-01f, 2.49384373e-01f, -1.44535020e-01f, 1.96868882e-01f, -3.26291770e-01f, -8.56247917e-02f, -1.31943196e-01f, 2.22266227e-01f, -1.04600325e-01f, -5.59098572e-02f,
  1.87875435e-01f, -8.03894401e-02f, 2.96043366e-01f, -1.84927762e-01f, 2.11709961e-01f, 7.07579255e-02f, -2.79842913e-01f, 2.13218346e-01f, -7.71737397e-02f, 1.07956707e-01f,
  -1.08733296e-01f, -2.43243679e-01f, 1.16669901e-01f, 3.44694644e-01f, -2.40575537e-01f, -4.37860996e-01f, 1.39062464e-01f, -1.21233940e-01f, -4.63889360e-01f, 1.37097582e-01f,
  5.83899952e-02f, -3.05234373e-01f, -2.70273954e-01f, -1.50072917e-01f, 1.38064399e-01f, -3.97951126e-01f, -4.19224519e-03f, 7.73434192e-02f, -2.06897020e-01f, 2.42448285e-01f,
  -3.92862350e-01f, 2.46685177e-01f, 5.34268245e-02f, 1.20317504e-01f, -3.67949717e-02f, 5.20137362e-02f, -3.95935535e-01f, -3.19353849e-01f, -2.03797057e-01f, 3.13784391e-01f,
  -8.00285861e-02f, -1.97522715e-01f, 1.32700071e-01f, -4.05329585e-01f, 3.01989391e-02f, -4.65107679e-01f, -6.16119243e-02f, -4.10847412e-03f, 2.85116315e-01f, -7.45573565e-02f,
  -2.33075500e-01f, -3.85728151e-01f, -1.70349196e-01f, -1.28012419e-01f, -3.71443838e-01f, 2.49058425e-01f, -6.25793487e-02f, -2.08425984e-01f, 2.65878201e-01f, 3.25277954e-01f,
  -1.52335778e-01f, 1.71254754e-01f, -1.89273939e-01f, 7.46272355e-02f, -8.21242854e-02f, -1.42934144e-01f, -1.18620887e-01f, 1.66134804e-01f, -3.81596908e-02f, 2.49885954e-02f,
  2.59640124e-02f, 3.56012583e-02f, -4.63729724e-02f, -3.09786081e-01f, 1.21985199e-02f, -4.61313963e-01f, 2.10513130e-01f, -4.22562547e-02f, 2.18920842e-01f, -1.43659841e-02f,
  -3.42945248e-01f, 3.28610539e-01f, 2.83932507e-01f, 9.08412412e-02f, -1.53954536e-01f, -1.56473234e-01f, -3.27117443e-01f, -6.79458678e-02f, 3.11612010e-01f, 1.75297678e-01f,
  -3.06496043e-02f, 5.52935302e-02f, -1.17124982e-01f, 9.17346179e-02f, 3.79844904e-01f, -1.67210385e-01f, -1.23547222e-02f, -1.42116234e-01f, 1.15886450e-01f, 3.07948589e-01f,
  1.62901431e-01f, 6.94933832e-02f, 2.38319576e-01f, 4.27801460e-01f, 2.24137440e-01f, 2.06654429e-01f, -4.10763115e-01f, 2.69246161e-01f, -7.27175549e-02f, 1.02392316e-01f,
  -3.56655508e-01f, -4.43032384e-02f, -2.81213909e-01f, -6.23913705e-02f, 2.74142504e-01f, -3.43197852e-01f, -5.23835681e-02f, 3.60271364e-01f, 2.61036027e-02f, -7.64464512e-02f,
  -2.79388338e-01f, -9.47255269e-02f, 3.08861583e-02f, -1.95033297e-01f, 1.58755720e-01f, -4.11893696e-01f, 2.21764728e-01f, 8.23973790e-02f, 3.16810384e-02f, -1.40990704e-01f,
  -1.10863768e-01f, -3.60220999e-01f, 2.57994890e-01f, -2.51071811e-01f, -2.67539114e-01f, -4.20223624e-01f, -2.34469205e-01f, -5.71466267e-01f, 1.87777609e-01f, -3.23080391e-01f,
  -2.65144616e-01f, -2.48647287e-01f, 1.88287035e-01f, -2.37733275e-01f, 2.04082489e-01f, -1.22206971e-01f, -7.55658299e-02f, -1.02244020e-01f, -7.07143545e-02f, -4.50168625e-02f,
  -2.14402497e-01f, -1.92207798e-01f, 2.43630722e-01f, 3.38320374e-01f, -1.89254180e-01f, 5.06250076e-02f, -1.75778881e-01f, 2.14609608e-01f, -4.05798107e-02f, 2.69646674e-01f,
  -1.81477368e-01f, -1.90807208e-01f, -1.34663031e-01f, 1.18870117e-01f, 2.66115963e-01f, -6.20708913e-02f, -9.12940726e-02f, -3.34668458e-01f, 9.17823911e-02f, -2.67569691e-01f,
  1.84068158e-01f, 1.67480797e-01f, -1.51183695e-01f, -3.68751079e-01f, 2.29409724e-01f, 5.58405668e-02f, 1.03749987e-02f, 2.83441812e-01f, 2.72549599e-01f, -1.21233568e-01f,
  -4.12569165e-01f, -3.84844810e-01f, 2.55217254e-01f, -1.85985357e-01f, -1.41097978e-01f, 1.03747472e-01f, -2.63637453e-01f, 7.04222322e-02f, 3.96959424e-01f, 2.24646330e-02f,
  -2.86694258e-01f, 5.70651256e-02f, 9.59789008e-02f, 1.36691481e-01f, -2.39021897e-01f, 1.02766722e-01f, -2.11272687e-01f, -1.48351192e-01f, -6.48652986e-02f, 1.09519050e-01f,
  -2.25094303e-01f, 1.34608269e-01f, 1.58522248e-01f, -1.57445762e-02f, -1.03829131e-01f, -4.09776390e-01f, 1.79373056e-01f, 1.71214536e-01f, 2.73262471e-01f, -7.00058937e-02f,
  -4.75911438e-01f, -1.95230275e-01f, -5.74122965e-01f, -1.91944554e-01f, 2.51025110e-01f, 2.34135821e-01f, -1.49478301e-01f, 8.30599517e-02f, -1.19281031e-01f, -2.41861016e-01f,
  1.98210124e-02f, 2.36728564e-01f, -5.07959239e-02f, -3.75431448e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  7.44700357e-02f, 1.11598605e-02f, -4.47980389e-02f, 8.97848681e-02f, 2.23460987e-01f, 9.23317373e-02f, 8.85560364e-02f, -4.78828363e-02f, -1.70174003e-01f, -1.28773585e-01f,
  -9.89496484e-02f, -2.10115034e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    