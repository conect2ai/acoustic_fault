/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.24970575e-02f, 5.26028797e-02f, -1.42839655e-01f, 1.32782757e-01f, 3.38520519e-02f, -2.39779651e-01f, -2.22724482e-01f, -4.48518842e-02f, 1.93684418e-02f, 8.81434605e-02f,
  7.68599510e-02f, -7.69914612e-02f, 3.74638066e-02f, -1.59156382e-01f, -2.55870968e-01f, -4.11900915e-02f, 4.88065779e-02f, -2.14200243e-01f, -3.91056776e-01f, -9.96230692e-02f,
  6.03132099e-02f, 1.18774049e-01f, -4.96493839e-02f, 1.75498258e-02f, 1.71269283e-01f, 1.69231351e-02f, 1.39940515e-01f, 1.91495195e-01f, 3.75075154e-02f, 3.41563284e-01f,
  7.11777806e-02f, 6.39767423e-02f, -8.60367119e-02f, -2.06285976e-02f, 1.35692254e-01f, 1.67372413e-02f, 2.61910558e-02f, 9.05905366e-02f, 4.44524176e-02f, 8.51840451e-02f,
  2.47284435e-02f, 4.15128022e-02f, 6.18967637e-02f, 7.63851553e-02f, 9.72751379e-02f, -2.51678620e-02f, 5.28700463e-03f, -1.20717667e-01f, 1.46611976e-02f, -4.34175059e-02f,
  1.46681488e-01f, 1.16342396e-01f, 3.74868996e-02f, -8.78411233e-02f, -3.93838957e-02f, -2.55199559e-02f, 5.67045249e-02f, 1.70320068e-02f, -3.24201509e-02f, 7.04426020e-02f,
  1.06707839e-02f, -3.29563804e-02f, -1.08093888e-01f, -2.34481860e-02f, -6.54315501e-02f, 2.58577085e-04f, 3.81342950e-03f, 8.18316266e-02f, -3.84073630e-02f, 1.20544629e-02f,
  -2.65423767e-02f, -3.42733343e-04f, -1.78968012e-02f, 4.21989597e-02f, 4.34182212e-03f, 4.15641926e-02f, -6.77404851e-02f, 3.99102345e-02f, -3.40585820e-02f, 4.90816124e-02f,
  9.10395663e-03f, -2.01497618e-02f, 9.86637995e-02f, -4.68071252e-02f, -3.39568872e-03f, 4.24636388e-03f, 7.74457827e-02f, -4.28717621e-02f, -3.31358686e-02f, -5.74795417e-02f,
  1.73833013e-01f, -2.35698268e-01f, 7.38539472e-02f, -1.00465573e-01f, 3.27895954e-02f, 2.32141912e-02f, 8.28367025e-02f, -5.11335358e-02f, 4.19267155e-02f, -3.48522589e-02f,
  -7.62625784e-02f, -6.85100108e-02f, -4.31726780e-03f, -3.39295529e-02f, 2.05477681e-02f, -3.62515226e-02f, 1.04319133e-01f, 1.18328985e-02f, -9.89814103e-02f, 1.14499196e-01f,
  6.21952452e-02f, -3.71568091e-02f, -1.42583445e-01f, -2.98736449e-02f, -7.08215982e-02f, -1.56997412e-01f, 5.86843789e-02f, -7.78068304e-02f, -2.48361260e-01f, 4.17007431e-02f,
  -2.77263559e-02f, 1.09236173e-01f, 1.31594256e-01f, 4.26468588e-02f, -1.04432791e-01f, -2.12095425e-01f, -4.63668965e-02f, -9.23027545e-02f, 1.63165610e-02f, -1.29156392e-02f,
  -1.71730086e-01f, -1.00039110e-01f, -4.33612578e-02f, -5.78092597e-02f, 8.90826434e-02f, 1.29359260e-01f, 8.00875351e-02f, 5.09276614e-02f, -1.29137054e-01f, -1.13769300e-01f,
  -1.06038272e-01f, -3.69057059e-02f, 9.93284509e-02f, -1.76497586e-02f, 1.44910306e-01f, -1.44429892e-01f, 1.75649256e-01f, 4.75556999e-02f, 3.90856005e-02f, 2.41503030e-01f,
  -4.21111025e-02f, 2.22461805e-01f, -1.01260349e-01f, -3.06126252e-02f, -4.75908928e-02f, -4.93599325e-02f, 3.07735875e-02f, 1.13489561e-01f, 5.17586656e-02f, 1.76389758e-02f,
  -3.90378274e-02f, 4.29054275e-02f, 8.37314650e-02f, 7.56761357e-02f, 7.02111721e-02f, -4.10863087e-02f, 1.87585339e-01f, 1.08262710e-01f, 1.30224451e-01f, 5.85884508e-03f,
  1.18659705e-01f, 4.37062569e-02f, -3.50963771e-02f, 1.17238931e-01f, 1.55969113e-01f, -3.37456912e-02f, 4.59248992e-03f, 9.31012183e-02f, 2.24235095e-02f, 1.39125913e-01f,
  -4.44825552e-02f, 2.12332904e-02f, 2.55269296e-02f, 1.21507037e-03f, -8.27717781e-02f, 4.69967164e-02f, 1.75936671e-03f, -1.00937933e-02f, -4.44023199e-02f, -1.34610645e-02f,
  6.35688603e-02f, -7.87870362e-02f, 2.99572833e-02f, -2.40852274e-02f, 1.19729089e-02f, 4.92923148e-02f, -1.79930478e-02f, -4.21546474e-02f, 1.51899140e-02f, 4.34252247e-02f,
  -3.09932344e-02f, -2.03212816e-02f, 9.06945765e-02f, -1.24476086e-02f, 3.60142812e-02f, -2.25298549e-03f, -3.51946913e-02f, 4.12606038e-02f, -4.16847952e-02f, -6.29488677e-02f,
  -2.20993385e-01f, 4.89001796e-02f, -3.18531618e-02f, 1.11600794e-02f, 3.40785682e-02f, -3.50117148e-03f, 4.85875979e-02f, -9.25706029e-02f, 2.39549894e-02f, -1.95515342e-02f,
  -9.92059428e-03f, -5.31572364e-02f, -2.17625145e-02f, 3.46850418e-02f, -3.33496816e-02f, -7.26212412e-02f, -2.04571765e-02f, 3.28975394e-02f, -2.82808542e-02f, 2.12493706e-02f,
  5.61983176e-02f, -9.55961049e-02f, -2.03990459e-01f, -7.93241486e-02f, 2.76388023e-02f, -1.19725749e-01f, -1.30283281e-01f, -5.75179122e-02f, -1.96092159e-01f, -1.70176089e-01f,
  6.16871178e-01f, 2.15766594e-01f, 2.11601615e-01f, 7.73070008e-02f, -3.91283538e-03f, -1.54442862e-01f, -1.67952925e-01f, -8.55363309e-02f, 2.57049054e-02f, 4.35872115e-02f,
  -5.90141267e-02f, -6.27662335e-03f, -1.33622847e-02f, -7.58550642e-03f, -5.25842384e-02f, 5.40228887e-03f, -6.82557896e-02f, 5.45913726e-02f, -1.18028313e-01f, -1.99984625e-01f,
  -1.89453378e-01f, 3.38741168e-02f, 2.11473450e-01f, 7.79845342e-02f, -3.49788330e-02f, -1.77146658e-01f, 5.97579852e-02f, 2.78088078e-02f, -2.95167640e-02f, 6.14711568e-02f,
  1.73414648e-01f, 3.81274730e-01f, -1.99648663e-01f, -8.03817287e-02f, 1.27616689e-01f, 7.52741396e-02f, 9.90006793e-03f, 4.85758223e-02f, -3.78632285e-02f, 2.80569028e-03f,
  -1.37227820e-02f, 5.57100885e-02f, -2.63610613e-02f, -1.11512452e-01f, 3.47897969e-02f, 6.08260632e-02f, 2.20407601e-02f, 5.89512400e-02f, -4.24127281e-02f, -3.51762548e-02f,
  -1.51859537e-01f, 1.18578263e-02f, 1.26407042e-01f, 1.51562737e-02f, 4.82963733e-02f, -2.70545669e-02f, 1.08546451e-01f, 1.33349746e-01f, -1.15797075e-03f, 1.78287745e-01f,
  -5.55178747e-02f, -1.44719332e-02f, 6.38102889e-02f, -5.05425744e-02f, 2.44301669e-02f, -3.60328406e-02f, -1.58753153e-02f, -3.51786390e-02f, -3.63383256e-02f, 3.80001664e-02f,
  -1.26145184e-02f, 4.38101962e-02f, -5.14838286e-02f, 4.54864316e-02f, -5.63818887e-02f, 4.03627716e-02f, -3.72557119e-02f, 2.89082639e-02f, -4.01681513e-02f, 1.36987586e-02f,
  9.49595030e-03f, 5.49506880e-02f, 6.75782561e-02f, -1.94730554e-02f, 4.56016287e-02f, 1.41122947e-02f, 2.45259106e-02f, -3.08289714e-02f, 6.40380681e-02f, 7.16595650e-02f,
  -1.15571283e-01f, 5.82787907e-04f, 1.01346336e-01f, -1.84935387e-02f, -3.62426763e-05f, 5.54189645e-02f, 3.81910056e-02f, -1.22260563e-02f, -2.81424960e-03f, -3.98122333e-02f,
  -2.24191323e-02f, 4.80935127e-02f, 6.60194978e-02f, -5.74689964e-03f, 5.44177042e-03f, 8.68259638e-04f, -4.17652428e-02f, 5.81445582e-02f, -1.87675860e-02f, -1.86813697e-02f,
  -6.03843220e-02f, -1.17504798e-01f, -2.21887864e-02f, -6.19367091e-03f, 2.74243299e-03f, -1.66387916e-01f, -9.76323485e-02f, -6.00666963e-02f, -8.58997256e-02f, -8.22899938e-02f,
  2.14934605e-03f, 1.94042102e-01f, 2.38008693e-01f, -1.42612159e-01f, 6.48697615e-02f, 1.77591726e-01f, 3.05887878e-01f, 1.52642041e-01f, -4.38710377e-02f, 6.59527034e-02f,
  1.00082226e-01f, -1.90619528e-02f, -4.95125866e-03f, 2.47840080e-02f, 1.54411271e-01f, 2.43396640e-01f, -1.40629392e-02f, 5.91414645e-02f, 2.82066297e-02f, 5.26860245e-02f,
  -2.13430375e-02f, -7.60095492e-02f, -1.84080496e-01f, -5.00601120e-02f, -6.91482425e-02f, -3.04211993e-02f, -6.38546199e-02f, -9.91231352e-02f, 1.12887032e-01f, -1.19015969e-01f,
  2.69447207e-01f, 4.66746390e-02f, -7.77584093e-04f, -1.18357234e-01f, 3.27585381e-03f, 8.27574581e-02f, 7.62254223e-02f, -3.98412235e-02f, -5.54912165e-02f, -4.25329544e-02f,
  2.10763793e-02f, -5.30525390e-03f, -1.22111090e-01f, -3.17130201e-02f, -6.15924671e-02f, 4.45412807e-02f, -3.53794508e-02f, -1.13182120e-01f, 4.10354100e-02f, -2.22062971e-03f,
  4.27526832e-02f, -6.72345683e-02f, 1.22182056e-01f, 2.86522340e-02f, 3.53607908e-02f, -1.27980590e-01f, 2.40418129e-02f, -1.21487282e-01f, 3.67292538e-02f, -4.99787256e-02f,
  -5.91947557e-03f, -5.87322116e-02f, 1.46415201e-03f, 3.74473408e-02f, 3.06722838e-02f, 2.74305120e-02f, 2.82481872e-02f, -3.87796238e-02f, -3.77335474e-02f, 1.45843960e-02f,
  7.71313161e-02f, 1.01930387e-02f, 3.21395183e-03f, 4.11449047e-03f, 4.25856523e-02f, -6.32408112e-02f, -6.45864084e-02f, 2.30518635e-02f, 9.32496786e-03f, -1.22674452e-02f,
  -7.03849830e-03f, -1.29560120e-02f, -1.84955448e-02f, 7.01315515e-03f, -3.65734547e-02f, 4.07114439e-02f, -2.46019028e-02f, 6.13071397e-02f, -5.57541177e-02f, -9.48579088e-02f,
  -2.23271840e-04f, 5.44804707e-02f, 1.06486425e-01f, -2.77152564e-02f, -1.60145536e-02f, -1.89473834e-02f, 4.13546003e-02f, -2.80844653e-03f, -9.02624726e-02f, 6.94004297e-02f,
  -1.44451251e-02f, -2.36925893e-02f, 3.80705334e-02f, -6.08707666e-02f, 6.65804371e-02f, 6.83269203e-02f, -4.02328670e-02f, 7.17377849e-03f, -4.89677452e-02f, 1.50029399e-02f,
  2.83315349e-02f, 7.07814423e-03f, 7.40234852e-02f, 1.39705479e-01f, 3.68967168e-02f, 1.00179844e-01f, 7.07846135e-02f, 1.32640854e-01f, 1.17662445e-01f, 1.62551433e-01f,
  9.95634049e-02f, -2.03700796e-01f, -2.92568393e-02f, 1.47080511e-01f, 1.17261328e-01f, -4.83034924e-02f, -1.07520439e-01f, -1.00498788e-01f, -9.42567457e-03f, 1.03471540e-01f,
  -5.43621555e-02f, 1.25629798e-01f, 1.44662306e-01f, 5.10836579e-02f, -1.49406046e-01f, -4.21074070e-02f, 6.60651550e-03f, 3.93520966e-02f, 1.11155640e-02f, -1.44982329e-02f,
  7.39379153e-02f, 4.55066934e-02f, -4.26018648e-02f, -1.01289004e-01f, -5.50824357e-03f, 1.52253330e-01f, 5.91244623e-02f, 5.00091128e-02f, -1.02041133e-01f, 1.30530402e-01f,
  2.68031418e-01f, -1.06599435e-01f, 7.96776265e-02f, 2.21973239e-03f, -2.21930649e-02f, 1.69369411e-02f, 6.10586777e-02f, -3.48882712e-02f, 7.47826099e-02f, -1.93546880e-02f,
  1.96555033e-02f, -5.99586591e-02f, 7.10773394e-02f, -6.59322143e-02f, -3.30329426e-02f, 8.37742072e-03f, -1.47712663e-01f, -1.06888518e-01f, -1.80204622e-02f, -9.58747864e-02f,
  -6.30845726e-02f, -5.43386675e-03f, 1.16427176e-01f, 7.69756269e-03f, -9.64212939e-02f, -3.30200866e-02f, 3.58953699e-02f, -8.96329358e-02f, -6.48876950e-02f, 3.05615552e-03f,
  4.06585336e-02f, -1.69131383e-02f, -1.99571885e-02f, -4.43919934e-02f, -1.23502044e-02f, -1.67248975e-02f, 6.14962727e-02f, 3.75304073e-02f, -6.84673786e-02f, -3.94194499e-02f,
  4.17319834e-02f, -3.39370817e-02f, -1.68995317e-02f, 6.69194758e-03f, 3.48673388e-02f, 1.14381677e-02f, -6.30176067e-02f, -2.91274693e-02f, 6.28446229e-03f, -1.69182085e-02f,
  -3.05044297e-02f, 8.23581964e-02f, -4.43895422e-02f, -3.95952091e-02f, 2.65479591e-02f, -2.90148295e-02f, 4.61447164e-02f, -8.68587941e-02f, -4.27029701e-03f, 2.95736529e-02f,
  2.12938681e-01f, -1.45930648e-01f, 7.68288970e-02f, 2.66174339e-02f, 1.20561793e-01f, -2.83954423e-02f, 1.30177503e-02f, -3.61260176e-02f, 4.01253887e-02f, 6.51970878e-02f,
  2.47848071e-02f, 3.62971090e-02f, -2.87361406e-02f, -9.27364379e-02f, 6.76682070e-02f, 1.49189765e-02f, 2.90305354e-02f, 1.03610605e-01f, 1.54367667e-02f, -5.76799624e-02f,
  -2.34397016e-02f, 1.86750457e-01f, 1.81784257e-01f, 7.71244019e-02f, 9.23133269e-02f, 2.36961037e-01f, 1.97773919e-01f, 1.23127587e-01f, 1.93155825e-01f, 2.33195752e-01f,
  -1.40613288e-01f, -2.30772793e-01f, -4.33201417e-02f, -2.73259968e-01f, -1.50119215e-01f, 1.19057618e-01f, 1.64239842e-03f, 7.29214922e-02f, 1.72130167e-02f, -1.60294071e-01f,
  -1.65459752e-01f, 1.24146208e-01f, 3.32776122e-02f, 2.50408858e-01f, 1.90089941e-01f, -1.42931953e-01f, -1.41409889e-01f, 7.65968338e-02f, 4.20245707e-01f, 2.87498802e-01f,
  -5.91637269e-02f, -1.40534535e-01f, -3.20665129e-02f, -1.86545053e-03f, -2.23523200e-01f, 9.47701633e-02f, -1.19016178e-01f, -1.11750200e-01f, -2.91544874e-03f, -2.49326527e-01f,
  -2.24563126e-02f, -6.78445622e-02f, 1.50317624e-01f, -2.54650395e-02f, -1.03345059e-01f, 7.18119442e-02f, 8.50667432e-02f, -2.02354901e-02f, -2.30265153e-03f, -7.62333199e-02f,
  -6.34060502e-02f, -1.97792016e-02f, 5.68736680e-02f, -5.09606190e-02f, 4.23804931e-02f, 3.85748670e-02f, -2.88078040e-02f, 4.64828983e-02f, 6.74448162e-02f, 7.73005094e-03f,
  -1.70493983e-02f, -6.56686798e-02f, -6.27054498e-02f, 1.05593264e-01f, 4.96152677e-02f, 4.38107476e-02f, 4.02940847e-02f, 7.16377497e-02f, 2.82833837e-02f, -4.59957197e-02f,
  -6.12730570e-02f, -5.42473309e-02f, -5.93513139e-02f, -9.61151272e-02f, -5.36016747e-03f, -1.49710393e-02f, -2.58895643e-02f, -2.02398263e-02f, 9.72251520e-02f, -5.12089767e-02f,
  1.17354868e-02f, 1.75152086e-02f, -5.79871330e-03f, -2.30023209e-02f, -7.12408349e-02f, 3.55628505e-02f, -2.14674883e-02f, -3.57209297e-04f, -2.06932914e-03f, -2.63674911e-02f,
  7.67807662e-02f, 2.45670173e-02f, -6.12594932e-02f, -6.62194192e-03f, 6.06620014e-02f, -1.01320138e-02f, 2.32872255e-02f, -1.99012421e-02f, -3.21162827e-02f, -4.29041944e-02f,
  5.66134462e-03f, 1.54310822e-01f, -3.17395553e-02f, 5.26708439e-02f, -4.48380597e-02f, -1.26230819e-02f, -7.66688539e-03f, 6.31668344e-02f, -9.51719731e-02f, 5.29724471e-02f,
  4.98511605e-02f, 3.17592472e-02f, -8.04969519e-02f, -1.05256438e-02f, 1.32103130e-01f, -1.98890306e-02f, -1.05679020e-01f, 7.09612593e-02f, 5.13243340e-02f, -1.00204051e-01f,
  -1.50078943e-03f, 4.50862534e-02f, 1.29541665e-01f, 1.14675434e-02f, 5.77989370e-02f, 9.01543796e-02f, -3.24185453e-02f, 2.47053206e-02f, 1.39403895e-01f, -2.04384560e-03f,
  -1.51161805e-01f, -1.86278418e-01f, -2.51654774e-01f, -1.27897905e-02f, -1.63366362e-01f, -1.84314325e-01f, -3.16592455e-01f, -1.73951000e-01f, 6.56586513e-02f, -5.38177080e-02f,
  7.01946318e-02f, 4.20530945e-01f, 2.68542707e-01f, 2.29616225e-01f, 6.35679588e-02f, -1.47319376e-01f, -2.42204070e-01f, 9.20335390e-03f, 1.15209512e-01f, 6.92301393e-02f,
  2.18316227e-01f, -7.19350646e-05f, 8.38701651e-02f, 1.24807753e-01f, 3.44797224e-02f, 1.28610149e-01f, -5.77948876e-02f, -5.09743541e-02f, 9.41535830e-02f, 7.17528835e-02f,
  1.88992247e-01f, -2.34029248e-01f, 1.05010994e-01f, 3.87743562e-02f, 2.04054751e-02f, -3.24136801e-02f, 2.68390006e-03f, -7.11297393e-02f, 3.61957364e-02f, -5.58913238e-02f,
  -2.58590039e-02f, 7.85010159e-02f, -2.41690129e-02f, 2.06762422e-02f, 3.46314609e-02f, -1.27468994e-02f, -6.52821958e-02f, -4.49621025e-03f, -4.24230322e-02f, -7.20572770e-02f,
  1.08481020e-01f, -1.00559801e-01f, -4.18823510e-02f, -1.64257307e-02f, -4.50231731e-02f, 1.11451946e-01f, -2.18295027e-02f, -7.66009539e-02f, -6.42796904e-02f, -7.58751258e-02f,
  -1.94868930e-02f, -4.51898426e-02f, -2.13884022e-02f, -8.18995852e-03f, 4.59964126e-02f, -1.72419660e-02f, 3.73508818e-02f, 6.17439998e-03f, 9.39957649e-02f, -4.63916082e-03f,
  2.40486152e-02f, 1.60075705e-02f, -1.42828636e-02f, -7.79784890e-03f, 9.26110968e-02f, -7.73080140e-02f, -4.49649021e-02f, -3.04145422e-02f, 6.17403351e-02f, -6.16861954e-02f,
  6.93393573e-02f, 1.96504910e-02f, -2.70394236e-02f, 6.95286989e-02f, -1.60462584e-03f, -2.14989278e-02f, -3.15786712e-02f, 2.85896678e-02f, 7.97533838e-04f, -4.31038961e-02f,
  2.98261851e-01f, -4.99512181e-02f, 7.41390362e-02f, -1.25624174e-02f, -3.88258547e-02f, -2.78169438e-02f, 1.07223190e-01f, -2.24250332e-02f, 4.63090315e-02f, 1.43109709e-02f,
  -5.38874269e-02f, -4.92495447e-02f, -2.57861856e-02f, 4.39953655e-02f, 2.40201168e-02f, 4.13688868e-02f, -4.06557620e-02f, 3.01209046e-03f, 3.66914016e-03f, -1.10760508e-02f,
  -7.69070908e-02f, -6.77286610e-02f, 4.09025811e-02f, 3.17643732e-02f, 2.89201681e-02f, 1.35979220e-01f, -7.67839840e-03f, 7.80008212e-02f, 3.32592241e-02f, -6.53157756e-02f,
  -7.54058957e-01f, -1.15873538e-01f, 1.12633612e-02f, -2.56361842e-01f, 9.83786061e-02f, -4.79803747e-03f, 6.99552894e-03f, -1.76926956e-01f, -6.68427050e-02f, -8.61546025e-02f,
  1.40654474e-01f, 2.50150591e-01f, 3.97758521e-02f, 1.07194021e-01f, -8.39740038e-02f, -7.51971453e-02f, -3.85042024e-03f, -4.57913242e-03f, 3.94136505e-03f, 1.31452993e-01f,
  2.67728847e-02f, -4.98829819e-02f, -1.91929489e-01f, -5.11210784e-02f, -4.28157635e-02f, 2.14636445e-01f, -1.01522624e-01f, -8.36447924e-02f, 1.78692073e-01f, -3.56692225e-02f,
  1.05225861e-01f, -2.12640300e-01f, 8.21415633e-02f, 4.50518914e-02f, 9.80548486e-02f, -1.13275968e-01f, -2.63726711e-02f, -1.04025267e-01f, 2.12273430e-02f, -8.95829424e-02f,
  5.30586950e-02f, 4.22776826e-02f, 6.16135150e-02f, 5.89633994e-02f, -1.92312092e-01f, -4.77982163e-02f, -4.98581342e-02f, -8.37031603e-02f, -3.81223299e-02f, -5.09345867e-02f,
  1.08869486e-01f, 4.09460887e-02f, -3.20260413e-02f, 9.39874947e-02f, -4.55912650e-02f, 1.03753000e-01f, -8.91493750e-04f, 7.19755813e-02f, 1.20471884e-02f, -1.16381153e-01f,
  -2.90084798e-02f, 1.12226242e-02f, 3.82650318e-03f, -1.71852261e-02f, -2.24372149e-02f, -1.29871201e-02f, 2.95634493e-02f, 5.40536083e-02f, 5.23633510e-03f, -5.36800288e-02f,
  6.20883107e-02f, -2.80669220e-02f, -2.35000644e-02f, -4.81935441e-02f, 4.82810624e-02f, -3.37282754e-02f, -1.99209452e-02f, -7.66441301e-02f, -1.95816960e-02f, -3.91009971e-02f,
  -1.36079788e-02f, 2.71701477e-02f, -1.96678061e-02f, 4.28613946e-02f, 3.58522795e-02f, 4.23615910e-02f, 2.52046827e-02f, 5.80912046e-02f, 5.34066521e-02f, -8.42695124e-03f,
  -1.69139862e-01f, 1.42923862e-01f, -7.36171231e-02f, -2.29699798e-02f, -3.09206024e-02f, 4.85826731e-02f, -2.72684880e-02f, 2.66628917e-02f, 7.30416477e-02f, -3.82708684e-02f,
  6.12407513e-02f, -9.70230624e-02f, -2.84357052e-02f, 3.13038230e-02f, 6.59214631e-02f, -6.89731631e-03f, 5.98883815e-02f, 3.34823653e-02f, 6.08192980e-02f, -8.40595961e-02f,
  -4.39507142e-02f, -1.04179546e-01f, -7.84075782e-02f, 4.13985886e-02f, -1.05874017e-02f, -5.36283888e-02f, 1.85895637e-02f, -7.21122921e-02f, 6.25633448e-02f, -2.36525282e-01f,
  2.40202114e-01f, 3.06776851e-01f, -3.38131309e-01f, 1.98967755e-02f, -5.43969311e-02f, -2.37205047e-02f, 5.86194247e-02f, 5.39681688e-02f, 9.23025832e-02f, 1.66587472e-01f,
  2.48753250e-01f, 9.60980449e-03f, -9.68611538e-02f, -8.19933712e-02f, -1.08622223e-01f, -7.86348134e-02f, -2.49041378e-01f, -2.72703528e-01f, -1.80611685e-01f, -2.29406245e-02f,
  6.72236606e-02f, 1.24255130e-02f, 6.08543977e-02f, -8.98658633e-02f, 1.36924565e-01f, -7.58331828e-03f, 6.10111840e-03f, 3.85960788e-02f, 4.11128625e-02f, 5.50832823e-02f,
  8.30063075e-02f, 2.43703857e-01f, -8.28458965e-02f, -1.95849892e-02f, 1.21558802e-02f, 6.57857656e-02f, 3.35353985e-02f, 6.08609691e-02f, -7.05472901e-02f, -4.15422395e-02f,
  3.88891660e-02f, 4.28380594e-02f, -7.27617592e-02f, 2.87914816e-02f, 4.57190163e-03f, -3.01408395e-02f, 9.66089815e-02f, -6.10784963e-02f, -1.44632027e-01f, 2.17435919e-02f,
  1.01374406e-02f, 3.91059816e-02f, -1.09246589e-01f, -8.07687938e-02f, -8.52634385e-02f, -1.86042696e-01f, -8.31714552e-03f, -4.56794053e-02f, -5.65969124e-02f, 1.79729253e-01f,
  4.09201160e-02f, -5.27271293e-02f, 4.55547217e-03f, -1.37960876e-03f, 1.55718606e-02f, -3.32611576e-02f, 4.04963605e-02f, 3.92730050e-02f, 1.81592349e-02f, -2.26288829e-02f,
  -5.27286343e-02f, 3.50346155e-02f, -1.50849512e-02f, 1.05841504e-02f, 1.48136355e-02f, -7.40097761e-02f, -6.52270112e-03f, 1.60386749e-02f, 5.13942391e-02f, -5.24365231e-02f,
  2.77053621e-02f, -8.40947479e-02f, -2.95171011e-02f, 2.20179800e-02f, -5.08753164e-03f, -2.02939492e-02f, -9.72741768e-02f, 9.11954418e-02f, 3.11280433e-02f, -1.45402979e-02f,
  1.19139992e-01f, -8.49562660e-02f, 1.26753137e-01f, 2.49274597e-02f, -8.31647590e-02f, -9.96952504e-03f, 6.47411961e-03f, -3.30012827e-03f, 7.60611892e-03f, 7.74246827e-02f,
  -5.04679382e-02f, 7.25838989e-02f, -2.90920418e-02f, -9.24261734e-02f, 2.02121329e-03f, 1.87155791e-02f, 1.12340767e-02f, -9.76572856e-02f, 2.95855310e-02f, 5.63930608e-02f,
  -2.95572020e-02f, -7.35890418e-02f, -4.74904440e-02f, -2.43588910e-02f, -9.14235692e-03f, -9.28601846e-02f, 2.93533411e-02f, 7.14596547e-03f, -6.23549931e-02f, 9.32170823e-02f,
  1.37428045e-01f, -3.34662080e-01f, -1.54911429e-01f, 1.19075201e-01f, 1.11530930e-01f, -1.45178720e-01f, -4.48296547e-01f, -1.30471036e-01f, 1.40643671e-01f, -4.89568934e-02f,
  1.04677133e-01f, 2.92242020e-01f, 6.37839437e-02f, 1.67976275e-01f, -1.15142390e-01f, -3.16273659e-01f, -2.11138606e-01f, -5.27036525e-02f, 1.03272736e-01f, 4.19645496e-02f,
  -2.59698816e-02f, 5.57549559e-02f, 9.75728929e-02f, 4.57711630e-02f, -3.14595364e-02f, 1.52543887e-01f, -1.57138571e-01f, -5.89193814e-02f, -1.99008244e-03f, -2.29139440e-02f,
  -1.38884075e-02f, 9.01113171e-03f, 1.16574883e-01f, 1.19593754e-01f, 2.33496190e-03f, 1.69455484e-02f, 1.76287312e-02f, 5.85048459e-02f, 3.70438173e-02f, -7.85087273e-02f,
  1.29285082e-01f, 6.53291345e-02f, 2.37098895e-02f, 1.20930932e-01f, -9.28968862e-02f, 8.09906870e-02f, -3.40683721e-02f, -5.53163216e-02f, 2.69696787e-02f, 6.03564866e-02f,
  1.04718491e-01f, 1.74360983e-02f, -5.38205244e-02f, -9.36532859e-04f, 1.39148198e-02f, 7.14083165e-02f, -3.95324118e-02f, 2.50064023e-02f, 1.04132906e-01f, -8.11133757e-02f,
  1.97656266e-03f, -3.09852026e-02f, -4.61000949e-03f, -3.61492336e-02f, -5.40181845e-02f, 1.02644272e-01f, -1.38285039e-02f, 3.01486105e-02f, -6.44233897e-02f, -4.17719521e-02f,
  1.04460828e-01f, -1.57813504e-02f, 5.28375022e-02f, -5.86749315e-02f, 6.75426722e-02f, 2.52878368e-02f, -8.33834261e-02f, -1.94794647e-02f, 3.17490399e-02f, -6.21567182e-02f,
  -2.94336844e-02f, 9.85762849e-02f, 5.16219018e-03f, -9.17409509e-02f, -3.84476781e-02f, -2.11038459e-02f, -5.90366684e-02f, 8.10785070e-02f, 6.57243505e-02f, 7.38322968e-03f,
  -1.08293677e-02f, 9.09256414e-02f, -1.13668829e-01f, -6.81719482e-02f, 1.10325992e-01f, 1.92166734e-02f, 6.58270940e-02f, -1.55348051e-02f, 2.21360382e-02f, -3.27053145e-02f,
  3.24309468e-02f, 3.94564979e-02f, 4.44589462e-03f, -1.10654701e-02f, -7.95078054e-02f, 2.36868020e-02f, -8.88270438e-02f, -6.38217106e-03f, -6.03288561e-02f, -7.29170963e-02f,
  -8.44196677e-02f, -6.55688420e-02f, -2.74379496e-02f, -6.94004074e-02f, -6.28830940e-02f, 3.18016000e-02f, -5.44571839e-02f, -8.09515864e-02f, -1.23991910e-02f, -2.38052756e-01f,
  -1.10932551e-02f, -1.89305335e-01f, -1.79612502e-01f, 4.18901518e-02f, 8.21708441e-02f, -7.38443360e-02f, -1.47891849e-01f, -1.61889233e-02f, -6.74552247e-02f, -2.28966027e-02f,
  -1.23991229e-01f, -4.03502025e-03f, -2.38140002e-02f, -1.04851509e-02f, -2.28355005e-02f, -1.63320616e-01f, 5.30733019e-02f, 9.15383250e-02f, 1.69132724e-01f, 1.77212372e-01f,
  1.53073490e-01f, 1.31541744e-01f, 1.40282273e-01f, 7.35410675e-02f, 9.35872048e-02f, 5.83355092e-02f, 1.75857861e-02f, 2.43323781e-02f, 7.70691410e-02f, 3.09161264e-02f,
  -2.27205053e-01f, -1.99815035e-02f, -3.76608805e-03f, 7.49970078e-02f, -6.77795187e-02f, 3.31038758e-02f, -1.08815573e-01f, 8.19955692e-02f, -3.81812192e-02f, -1.27616441e-02f,
  2.00657392e-04f, 1.33052915e-01f, 4.58977036e-02f, -1.15619181e-02f, 9.70089510e-02f, -1.44195715e-02f, 2.32509822e-02f, -3.73044573e-02f, -7.96032995e-02f, -1.31571842e-02f,
  5.04541062e-02f, 8.54931679e-03f, -1.02693990e-01f, -1.37021095e-01f, 2.75754537e-02f, 9.40932930e-02f, -3.34703433e-03f, 9.97521728e-03f, -7.82427117e-02f, -1.38949126e-01f,
  -1.27852056e-02f, -5.81384040e-02f, 2.36911401e-02f, 6.78473487e-02f, -4.52159047e-02f, -2.73607858e-02f, 1.02825753e-01f, 3.93216200e-02f, 8.61340016e-02f, 1.06320810e-02f,
  -4.24748249e-02f, -9.46503282e-02f, 1.65534019e-02f, 2.89994162e-02f, -5.41395210e-02f, -3.22684124e-02f, 1.26362089e-02f, -9.10435989e-03f, -2.56398097e-02f, 1.17599238e-02f,
  -3.43574919e-02f, 2.50348616e-02f, -5.59600703e-02f, 7.56663904e-02f, 8.47256705e-02f, -2.02001724e-03f, 1.37354761e-01f, 2.67365985e-02f, -2.28333529e-02f, 5.22459857e-02f,
  -1.07551694e-01f, 5.57046309e-02f, -2.63840482e-02f, -2.41747890e-02f, 2.88297124e-02f, 3.19749601e-02f, 2.54548360e-02f, -5.36062606e-02f, 2.16028206e-02f, 4.67102192e-02f,
  2.57301070e-02f, 2.24220715e-02f, -6.15051538e-02f, 2.29466725e-02f, 9.54379365e-02f, -2.78649442e-02f, 3.37954517e-03f, 8.16317424e-02f, 9.81775373e-02f, -7.11219907e-02f,
  -2.31335182e-02f, -6.87123239e-02f, -6.43334612e-02f, -1.27085820e-01f, 3.99863236e-02f, -8.04603025e-02f, -7.45448619e-02f, -9.50021110e-03f, -1.49850085e-01f, -1.40946493e-01f,
  -6.35245919e-01f, 6.88773096e-02f, 1.29410416e-01f, -2.04263285e-01f, 1.76073730e-01f, 2.91702569e-01f, 2.14867920e-01f, 7.19122589e-03f, -9.61490944e-02f, -3.52873988e-02f,
  8.02968070e-02f, -1.93357065e-01f, -1.50629923e-01f, 2.71970797e-02f, -5.05168624e-02f, 1.38434753e-01f, 5.13386838e-02f, -1.08163826e-01f, 1.86368302e-02f, 4.98260781e-02f,
  5.51825278e-02f, -1.18611544e-01f, -1.66457683e-01f, -3.70452255e-02f, -7.66566694e-02f, -3.30029093e-02f, 1.92806602e-01f, -2.57291757e-02f, 1.44410312e-01f, -5.20851314e-02f,
  -8.70313123e-02f, 1.85969975e-02f, -4.50533926e-02f, -5.76731637e-02f, 7.17356950e-02f, -1.16878301e-01f, -1.29345641e-03f, -8.18788111e-02f, 4.87075374e-02f, 6.66562393e-02f,
  1.92697030e-02f, 2.19022227e-03f, -6.51746690e-02f, 3.68592925e-02f, 6.82467297e-02f, 3.52722965e-02f, -2.82199550e-02f, -8.28327611e-03f, 4.75773700e-02f, 5.45056425e-02f,
  5.58031611e-02f, 6.17157407e-02f, 1.22612892e-02f, 1.27530977e-01f, 8.33676681e-02f, -7.70295039e-02f, 1.48889154e-01f, 3.93982120e-02f, 1.49487928e-01f, -1.03313312e-01f,
  1.80356298e-03f, -1.10445702e-02f, 1.50857950e-02f, -3.02300323e-02f, 1.54308453e-02f, -1.85002945e-02f, -4.75347117e-02f, 2.38814782e-02f, 2.71760412e-02f, -6.97364956e-02f,
  1.53514696e-02f, 3.99462618e-02f, -1.26422737e-02f, -5.38342334e-02f, 1.36598330e-02f, 1.52780078e-02f, -6.76643103e-02f, 3.75673622e-02f, 1.66687183e-02f, -5.62404208e-02f,
  -1.91060069e-03f, 4.65467386e-02f, -2.38894243e-02f, 7.66196055e-03f, 4.30713082e-03f, 3.98625433e-02f, -6.74473494e-02f, 7.52038583e-02f, -5.69037981e-02f, 4.75321012e-03f,
  -2.15529054e-01f, 1.69575289e-01f, -1.64302960e-01f, 3.80556062e-02f, 1.99061185e-02f, -6.73753629e-03f, 3.65945026e-02f, -1.30155252e-03f, -4.72512357e-02f, -4.36008610e-02f,
  1.07795754e-02f, -5.29872924e-02f, -8.11409112e-03f, 3.96048762e-02f, -6.85656536e-03f, 4.54640947e-02f, -2.58797826e-03f, -4.20146883e-02f, -3.93272713e-02f, 5.13362400e-02f,
  -8.40065349e-03f, 2.03146916e-02f, -1.54126540e-01f, -7.61230290e-02f, 6.30188407e-03f, -1.02860756e-01f, 4.11456712e-02f, 3.61292921e-02f, -6.02356829e-02f, -6.71842843e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.22292727e-01f, -1.42477915e-01f, 1.27751544e-01f, -1.65676698e-02f, 2.45779343e-02f, -2.95719616e-02f, 7.32146576e-02f, 6.69222847e-02f, 7.44047761e-02f, -4.59228717e-02f,
  -2.65978370e-02f, -9.17223468e-02f, -9.80422720e-02f, 1.13579324e-02f, 4.76661213e-02f, -3.65556292e-02f, 1.30526140e-01f, 1.82615280e-01f, -3.29974643e-03f, 4.55578715e-02f,
  -5.60826585e-02f, 3.94019894e-02f, 3.79846357e-02f, 4.53842208e-02f, 6.37949631e-02f, -7.88176134e-02f, -4.60548513e-02f, -3.99036258e-02f, -1.25053346e-01f, 3.38217542e-02f,
  -1.25996634e-01f, -1.21147893e-01f, 1.28701940e-01f, -1.52245304e-02f, 1.77370980e-02f, 4.44600619e-02f, -2.68579759e-02f, 8.55335072e-02f, -5.30762039e-02f, 9.66571867e-02f,
  5.75473458e-02f, 3.62795442e-02f, 6.87929019e-02f, 2.31272262e-02f, -5.72741888e-02f, 1.59178805e-02f, -1.13114144e-03f, 6.43116683e-02f, -7.14413496e-03f, -5.44632711e-02f,
  -4.17524055e-02f, 5.59592433e-03f, 4.56801504e-02f, 8.05484655e-04f, 8.34036469e-02f, -4.46669683e-02f, -8.57163891e-02f, -9.55381840e-02f, 8.66863728e-02f, 8.10397118e-02f,
  -3.27274129e-02f, -3.37916128e-02f, 5.40560670e-02f, -4.36023325e-02f, 7.34352246e-02f, -5.48186898e-02f, 2.53729559e-02f, 6.29869476e-02f, 6.37070015e-02f, 4.70152907e-02f,
  2.23965775e-02f, -1.28644370e-02f, -1.05687194e-02f, -5.21348380e-02f, 2.46461090e-02f, 3.70521173e-02f, 7.50366822e-02f, -1.00729801e-01f, -3.54996696e-02f, -5.76890074e-02f,
  6.09952547e-02f, -1.08295023e-01f, -8.21050927e-02f, 1.27292220e-02f, -9.82740447e-02f, -1.26718879e-02f, 3.37794386e-02f, -9.31506827e-02f, -9.55843627e-02f, -7.81699792e-02f,
  1.02089839e-02f, -4.25652675e-02f, 3.65808196e-02f, 1.46440510e-02f, 6.55630156e-02f, -5.02661839e-02f, -6.37660474e-02f, -5.31534897e-03f, -4.27273586e-02f, 2.15773284e-02f,
  2.52566002e-02f, 7.69968107e-02f, -8.53064880e-02f, -7.04041496e-02f, 9.42671224e-02f, -1.55491484e-02f, -8.98657963e-02f, 9.09756199e-02f, 2.01649442e-02f, -3.01866792e-02f,
  2.19680611e-02f, 5.60674518e-02f, 3.50840539e-02f, 1.54855609e-01f, 5.18458746e-02f, 1.03933550e-01f, 3.78286839e-02f, 6.52033417e-03f, 1.99209321e-02f, 2.10975692e-01f,
  8.88555571e-02f, 4.31046747e-02f, 1.34973973e-01f, 1.56718850e-01f, -2.96775233e-02f, -7.43887722e-02f, -1.04699574e-01f, -1.57982886e-01f, -7.53962696e-02f, -5.33558279e-02f,
  5.84051572e-02f, -3.87401357e-02f, 3.62566896e-02f, -8.28419998e-02f, -8.68081450e-02f, 4.85709682e-02f, -2.22835820e-02f, -2.61569954e-02f, -4.01068665e-02f, -1.17521666e-01f,
  7.77012631e-02f, 1.11902423e-01f, 1.09441601e-01f, 1.43817998e-02f, 1.80559903e-02f, -2.34993380e-02f, 1.28807696e-02f, 7.61998221e-02f, -2.36947089e-02f, 1.03314042e-01f,
  1.89304024e-01f, 1.15024582e-01f, 1.11921306e-03f, 4.40305956e-02f, 6.95622414e-02f, 5.08840270e-02f, -8.29103887e-02f, -3.83294821e-02f, -1.66816898e-02f, -7.59754702e-02f,
  8.37521031e-02f, 4.01384309e-02f, -1.09018043e-01f, -4.21940573e-02f, -1.10905487e-02f, -6.22411817e-02f, 1.90041978e-02f, -9.63555947e-02f, -2.20894236e-02f, 6.76309019e-02f,
  7.37071335e-02f, 2.86136735e-02f, 7.55055016e-03f, -1.46223858e-01f, -8.81360099e-02f, -5.94814681e-02f, -9.33515877e-02f, -2.87509430e-02f, 1.23768868e-02f, 4.13338542e-02f,
  -7.35177845e-02f, 1.96054615e-02f, -8.42830911e-02f, -8.56778622e-02f, -7.57829100e-02f, 1.94855053e-02f, 3.66332754e-02f, -5.20254709e-02f, 5.14668413e-02f, 1.46877933e-02f,
  -7.58620724e-02f, 8.94237384e-02f, -2.34043710e-02f, -6.67554140e-02f, -7.27237538e-02f, -4.25527319e-02f, -8.13496411e-02f, 3.84530313e-02f, 5.20388708e-02f, 5.79888709e-02f,
  2.51406394e-02f, 4.61383946e-02f, 7.90786818e-02f, -8.24726447e-02f, 3.36421169e-02f, -7.69423991e-02f, 1.25581296e-02f, -1.70506109e-02f, 6.38822615e-02f, 7.14058653e-02f,
  -4.19593342e-02f, -3.12095489e-02f, -1.69404764e-02f, -1.02226339e-01f, 5.65881021e-02f, 4.45093773e-03f, -5.64778317e-03f, -1.01477271e-02f, 5.80378762e-03f, 4.59742956e-02f,
  -5.59233278e-02f, -3.29524316e-02f, -9.03651211e-03f, -6.54159635e-02f, -8.03822204e-02f, -6.74426556e-02f, -5.84459975e-02f, -9.07218158e-02f, -6.92744181e-02f, -9.02620479e-02f,
  -1.31440550e-01f, -1.41656324e-01f, 4.25190590e-02f, -7.74573758e-02f, 3.21860723e-02f, -9.47852060e-02f, -7.98087120e-02f, -1.22089423e-01f, -1.40198201e-01f, 1.06215291e-02f,
  -1.31327119e-02f, -2.40166694e-01f, -5.96005544e-02f, -1.97159812e-01f, -1.14338705e-02f, 2.30768844e-02f, -2.15417847e-01f, 1.38122113e-02f, -3.65140364e-02f, -2.47892261e-01f,
  -6.38920590e-02f, 1.15942337e-01f, -9.81326103e-02f, 5.30188577e-03f, -7.60053769e-02f, -2.82488585e-01f, -2.38062546e-01f, -7.41371512e-02f, 1.67760700e-01f, 8.61412194e-03f,
  -8.04658979e-02f, -9.15651470e-02f, 1.10887125e-01f, -2.22254544e-02f, 5.88095747e-02f, 2.07432136e-02f, -9.86152142e-03f, 2.69975029e-02f, 8.04814324e-02f, -1.62743539e-01f,
  -1.53497770e-01f, -1.10393940e-02f, 8.67190808e-02f, 6.26416504e-02f, 2.33212244e-02f, 4.39529158e-02f, -7.07792863e-02f, 9.34852511e-02f, 1.91690996e-02f, -1.78007002e-03f,
  4.12829258e-02f, -2.13054381e-02f, -1.76225305e-02f, -2.07016617e-03f, 5.78616466e-03f, -3.71666588e-02f, -7.78239174e-03f, 3.91206443e-02f, -4.84397933e-02f, -2.69735567e-02f,
  -1.01223432e-01f, -8.39817375e-02f, 8.55345428e-02f, 4.61625401e-03f, 8.20046887e-02f, 1.04821198e-01f, 1.02165539e-03f, 1.72559366e-01f, 9.18686539e-02f, 7.08649680e-02f,
  -1.14874365e-02f, 6.10529035e-02f, 9.44311693e-02f, 3.23302783e-02f, 4.81870869e-04f, 1.10128634e-02f, 8.66260752e-03f, -6.04803152e-02f, -1.22902086e-02f, 4.95977737e-02f,
  3.13576758e-02f, 1.62918642e-02f, -3.30379605e-02f, 4.46852185e-02f, 6.10212237e-02f, 2.35555787e-02f, 6.46207854e-03f, -6.46034703e-02f, 7.65378550e-02f, 9.65673402e-02f,
  8.73098150e-02f, -2.95489881e-04f, -1.34301782e-02f, 2.83910483e-02f, -7.76211992e-02f, -1.08107135e-01f, -5.02016358e-02f, 6.28764853e-02f, -4.08566184e-02f, 6.68636560e-02f,
  -4.22791876e-02f, 1.64404631e-01f, -1.31641164e-01f, 7.23296329e-02f, -8.69859830e-02f, -4.77277972e-02f, -6.96081221e-02f, -1.88830476e-02f, 5.80172986e-02f, 1.98813025e-02f,
  2.01757136e-03f, -1.19240237e-02f, -1.31846429e-03f, 8.52857064e-03f, -2.41436176e-02f, -3.85338590e-02f, -3.04746395e-03f, 5.84139675e-02f, -5.62518723e-02f, -1.79081894e-02f,
  1.85954329e-02f, -1.13774292e-01f, -4.78781648e-02f, 2.17963550e-02f, 5.85410222e-02f, -6.86329305e-02f, 8.17295630e-03f, -4.30066064e-02f, 7.32681155e-02f, -1.58684134e-01f,
  8.47167224e-02f, 4.05762577e-03f, -6.87276050e-02f, -9.24472213e-02f, -3.16990609e-03f, 8.29631239e-02f, -2.49419119e-02f, 5.84755512e-03f, -7.59640262e-02f, 2.79495139e-02f,
  9.56217274e-02f, 4.39428873e-02f, 4.92150150e-02f, -3.43822502e-02f, 1.09813914e-01f, 2.96940506e-02f, 1.44918039e-02f, 4.95242141e-02f, -3.76454033e-02f, 1.81059036e-02f,
  -4.82756011e-02f, -5.63431680e-02f, -7.48584792e-02f, 2.77771782e-02f, 2.35535521e-02f, -5.90068139e-02f, -1.43543333e-02f, -3.40551473e-02f, -1.95217356e-02f, -2.73178332e-02f,
  7.15269819e-02f, 7.40471482e-02f, 1.26964562e-02f, -3.14789526e-02f, -4.14551944e-02f, -6.84755370e-02f, 1.33878542e-02f, -2.54685599e-02f, -6.46708459e-02f, -3.16665578e-03f,
  -2.86436677e-02f, -8.71756598e-02f, 2.60424074e-02f, 4.83008884e-02f, -7.49601051e-03f, -7.94610903e-02f, 2.53931861e-02f, 4.65323292e-02f, -1.14517594e-02f, 5.57233915e-02f,
  3.51074487e-02f, 9.21348631e-02f, 3.31265032e-02f, 5.34249693e-02f, -3.79226767e-02f, 3.65352468e-03f, 1.90257803e-02f, -2.53287982e-02f, -3.17427702e-02f, 4.61986363e-02f,
  -5.17368540e-02f, 2.35834885e-02f, 7.02578202e-02f, 6.34491667e-02f, 8.14286098e-02f, 5.73027246e-02f, 7.17629955e-05f, -4.71911393e-02f, 6.41510263e-02f, 1.44659486e-02f,
  -6.62411004e-02f, 6.34014010e-02f, 2.25807410e-02f, 5.22767194e-02f, -2.70568691e-02f, 5.93083864e-03f, 3.68877500e-02f, -1.80006884e-02f, 6.41942769e-02f, -9.12884772e-02f,
  7.73063824e-02f, -1.96209624e-02f, 7.16107711e-02f, 6.87918589e-02f, 2.59517059e-02f, -5.97923584e-02f, -4.76817302e-02f, 5.74588850e-02f, 5.68147264e-02f, -6.12703189e-02f,
  1.94694251e-02f, 6.62110895e-02f, 8.65021795e-02f, 4.34529921e-03f, -2.27507502e-02f, -7.83804655e-02f, 1.59745943e-02f, -2.73152851e-02f, 3.96742560e-02f, -7.51045421e-02f,
  -3.67343910e-02f, -2.32347846e-02f, 5.53818010e-02f, 7.70758232e-03f, 7.94214159e-02f, 2.96160430e-02f, -9.22706425e-02f, 3.25422995e-02f, 4.46334630e-02f, 2.64518745e-02f,
  -4.64656614e-02f, 7.91479051e-02f, 1.87238567e-02f, 9.99197066e-02f, -6.01365939e-02f, 4.33610864e-02f, 9.90903601e-02f, 3.97718698e-02f, 5.88914100e-03f, 6.79341704e-02f,
  2.71026403e-01f, 1.63020581e-01f, 9.58691090e-02f, 5.57676442e-02f, 4.14055213e-03f, -8.26522261e-02f, -2.12518808e-05f, 1.23846069e-01f, 9.21976566e-02f, 2.73669381e-02f,
  7.58944601e-02f, 2.05178559e-02f, -1.61351338e-02f, 4.94271144e-02f, 1.64464995e-01f, 4.35024910e-02f, -4.40843217e-02f, -3.44919898e-02f, 6.53687939e-02f, -3.80195975e-02f,
  -1.29892593e-02f, 1.24056954e-02f, 1.37675405e-01f, 9.29099545e-02f, 6.40842691e-02f, 5.59822917e-02f, 9.96563509e-02f, -3.14245820e-02f, -4.32218425e-02f, 1.72032975e-02f,
  -9.15598348e-02f, -2.30025011e-03f, -3.56343277e-02f, -1.12227574e-01f, -5.28870896e-02f, 7.59107396e-02f, 8.25081989e-02f, 4.40188199e-02f, -5.00173122e-02f, 7.39377141e-02f,
  -8.43715370e-02f, 5.30651584e-03f, 1.18381288e-02f, 2.63513476e-02f, 8.15754011e-02f, -5.47656007e-02f, 3.60227041e-02f, 2.15088343e-03f, 7.90644437e-02f, -6.29746690e-02f,
  -8.96464884e-02f, -3.28555740e-02f, -5.87726235e-02f, 6.74202517e-02f, -3.09387408e-02f, -1.18486419e-01f, -4.28698165e-03f, -1.06724665e-01f, -2.95914728e-02f, -1.75084602e-02f,
  -7.12487474e-02f, 4.89912443e-02f, -1.61667657e-03f, 6.95378631e-02f, 5.17863641e-03f, 5.40808737e-02f, -3.50481682e-02f, 7.52749329e-04f, -5.37016690e-02f, -6.32830039e-02f,
  -6.41798899e-02f, 1.95939466e-02f, 3.69369984e-02f, 7.34323338e-02f, 3.73422951e-02f, 2.53322423e-02f, -1.13636024e-01f, -8.39187801e-02f, 5.33404686e-02f, 3.68054360e-02f,
  3.53322253e-02f, -2.59641428e-02f, -3.25430334e-02f, 2.28344705e-02f, 5.42770550e-02f, -4.86312946e-03f, -8.73141661e-02f, 5.24419732e-02f, 3.77808101e-02f, 4.52754274e-02f,
  2.07788497e-03f, -1.86705273e-02f, -2.50571277e-02f, 5.57412840e-02f, -4.84310091e-02f, -8.45511705e-02f, -1.15818279e-02f, 1.57430470e-02f, -3.71609330e-02f, -8.31825100e-03f,
  5.09610884e-02f, -3.15098278e-02f, -5.18469997e-02f, -5.24295792e-02f, -5.75420586e-03f, -9.26621184e-02f, -3.24500427e-02f, -1.40744429e-02f, -7.32909888e-02f, -8.97018537e-02f,
  -2.19583474e-02f, -4.37334590e-02f, -4.55898978e-02f, -6.48384392e-02f, 5.41640557e-02f, -1.63122863e-02f, 3.87246720e-02f, -2.84709334e-02f, 6.74230754e-02f, 1.15984984e-01f,
  1.35843297e-02f, -2.36192811e-02f, -4.51597571e-02f, -2.62109712e-02f, -1.82859472e-03f, 7.38568902e-02f, 1.09117799e-01f, 1.52427331e-01f, 1.49685621e-01f, 1.48729146e-01f,
  1.07088692e-01f, -2.40291152e-02f, -5.48359491e-02f, 5.33143207e-02f, 3.32028903e-02f, -6.38033226e-02f, -5.89812770e-02f, -4.81525697e-02f, -2.46598255e-02f, 3.77061660e-03f,
  1.82712972e-02f, 9.70206708e-02f, -1.38040045e-02f, -5.86284250e-02f, -2.11004796e-03f, 7.89693370e-02f, 1.03490977e-02f, 9.94492844e-02f, 1.06572494e-01f, -7.27491379e-02f,
  -1.10103764e-01f, 1.38109326e-01f, -9.36080739e-02f, 5.88305816e-02f, 5.62636927e-02f, -2.86152456e-02f, 6.38148934e-02f, 7.01078773e-02f, 8.67647603e-02f, -4.76190299e-02f,
  -5.80441169e-02f, -4.40068357e-02f, -3.99075337e-02f, -1.45329963e-02f, 1.10015966e-01f, -1.38742682e-02f, 9.73488465e-02f, -3.60353999e-02f, 8.06761086e-02f, 6.95155263e-02f,
  3.29946913e-02f, 1.28188565e-01f, 1.22769408e-01f, 5.73416725e-02f, 1.15345895e-01f, 6.46497309e-02f, 7.36943707e-02f, -2.12926976e-02f, 8.78491849e-02f, 1.79851670e-02f,
  6.56710565e-03f, 6.91322163e-02f, 4.97694723e-02f, -4.86317649e-02f, 8.49363133e-02f, 8.89506862e-02f, 1.90242622e-02f, 8.54023546e-02f, 9.88443196e-02f, 7.50590563e-02f,
  9.28361341e-02f, -1.49473101e-02f, -4.05267663e-02f, -6.45255744e-02f, 5.50513603e-02f, -1.07687963e-02f, -5.77545613e-02f, -3.75515632e-02f, -3.99395823e-02f, 9.98834223e-02f,
  5.85379675e-02f, -1.63811333e-02f, 8.92660394e-02f, 9.16382298e-02f, -9.16683022e-03f, 6.16731904e-02f, 1.68053210e-02f, 1.82636827e-02f, 1.01103857e-02f, -8.03097934e-02f,
  6.30725026e-02f, -2.05119606e-02f, 3.91876437e-02f, 5.29201422e-03f, -3.84640368e-03f, 7.40750059e-02f, 8.88962150e-02f, -5.46171926e-02f, -5.79703040e-02f, 1.03848591e-01f,
  3.64358760e-02f, 1.56753662e-03f, 7.72858039e-03f, 4.31735814e-02f, -5.42441104e-03f, -5.83438277e-02f, 9.49626118e-02f, -1.82513762e-02f, 1.79685466e-02f, 4.47701402e-02f,
  -7.35331252e-02f, 1.17844060e-01f, -2.17439374e-03f, 4.81588431e-02f, 7.43630752e-02f, -9.17707607e-02f, -7.50864595e-02f, -9.03792605e-02f, 4.09110822e-02f, -2.87640020e-02f,
  -2.35857531e-01f, -1.73918426e-03f, 3.18688340e-02f, 9.21396986e-02f, 5.21075428e-02f, -7.38924593e-02f, -1.64325252e-01f, -1.87588751e-01f, 1.42777311e-02f, -1.14716135e-01f,
  5.26650436e-02f, -3.36022526e-02f, -7.51122162e-02f, -7.33232945e-02f, -2.35254854e-01f, -2.01343954e-01f, -5.76380529e-02f, -6.22707326e-03f, -1.55576035e-01f, -3.85908410e-02f,
  -7.22080469e-02f, -1.07183114e-01f, -5.70816696e-02f, 6.38551861e-02f, 2.47859322e-02f, 5.78151159e-02f, 5.80230057e-02f, -5.69118978e-03f, -1.98176838e-02f, 9.03609768e-02f,
  -5.23469411e-02f, -1.28128469e-01f, -2.33699381e-03f, 9.75136235e-02f, 9.52573940e-02f, -9.64673981e-02f, 1.70465279e-02f, 9.24639553e-02f, 7.95145258e-02f, 2.85638217e-02f,
  1.06824830e-01f, 5.10952994e-02f, 4.97090220e-02f, -8.68493877e-03f, -5.23664095e-02f, -5.08124530e-02f, 3.37268296e-03f, -9.37385485e-02f, 6.59412035e-05f, -5.28101698e-02f,
  8.78350437e-02f, 4.46715057e-02f, -1.48172766e-01f, -2.29164474e-02f, -8.87447447e-02f, 3.01642399e-02f, 8.32653269e-02f, 1.74349938e-02f, 8.13905299e-02f, -7.26950914e-02f,
  -1.79389230e-04f, 1.07618555e-01f, -6.44663945e-02f, 2.98560709e-02f, -6.58634380e-02f, -1.10025881e-02f, 4.59444858e-02f, -8.63252804e-02f, 2.00699829e-02f, 9.22706723e-03f,
  1.84538700e-02f, 7.32993111e-02f, 4.24184129e-02f, -6.79897144e-02f, 7.70667195e-02f, -2.38385461e-02f, 5.25225326e-02f, 2.77778953e-02f, -4.42213416e-02f, 1.00883367e-02f,
  -1.78765226e-02f, -4.49751765e-02f, 1.02879204e-01f, -4.15420979e-02f, 1.33578125e-02f, 5.11719920e-02f, 8.23651254e-02f, -5.02019562e-02f, 8.41154605e-02f, 1.06169526e-02f,
  -5.62552735e-03f, 5.53692281e-02f, 2.77806129e-02f, -1.35738151e-02f, 6.53658062e-02f, 1.34173995e-02f, 2.77783610e-02f, 2.32038051e-02f, 4.84900773e-02f, -7.20173270e-02f,
  -1.04817241e-01f, -8.72481540e-02f, -7.87367076e-02f, -8.68811905e-02f, -8.83642286e-02f, -1.11059524e-01f, -8.81554112e-02f, -4.71749529e-02f, -1.14819974e-01f, 1.97614040e-02f,
  -2.92196628e-02f, -1.88296184e-01f, -2.04256237e-01f, -1.12090722e-01f, -1.04815282e-01f, -3.81840020e-02f, -1.55738473e-01f, 2.17540562e-02f, -9.26085711e-02f, -1.17211007e-01f,
  -4.33010727e-01f, -2.14692503e-02f, -4.35735546e-02f, -2.57131845e-01f, -1.77282736e-01f, -1.16114356e-02f, -1.23861492e-01f, -1.00987375e-01f, -1.03081696e-01f, 5.51411845e-02f,
  1.27458135e-02f, -2.59039626e-02f, -5.89404143e-02f, 5.07030636e-02f, -1.67943820e-01f, -1.49571851e-01f, -1.34978786e-01f, -2.85281718e-01f, -2.58742779e-01f, -1.43371254e-01f,
  -1.28640324e-01f, -1.45644143e-01f, -1.39690295e-01f, -9.30666849e-02f, 1.94967806e-01f, -9.19850729e-03f, 9.01171844e-03f, 8.71071145e-02f, 1.56419426e-01f, 2.64888220e-02f,
  3.36981922e-01f, -1.64603233e-01f, -4.58240360e-02f, -8.47377777e-02f, -2.59494013e-03f, -7.36363325e-03f, -4.29400019e-02f, 2.21060533e-02f, -1.04504347e-01f, -4.57020998e-02f,
  1.34196924e-02f, 2.33640112e-02f, 2.98559684e-02f, -5.78038208e-02f, -7.18665347e-02f, -1.46576678e-02f, -2.55988855e-02f, -2.27526184e-02f, -8.04511532e-02f, 1.24200702e-01f,
  7.80444816e-02f, -4.41114604e-03f, -8.61393958e-02f, 6.42617866e-02f, -3.82028408e-02f, -1.45624680e-02f, 4.25793119e-02f, 1.00854851e-01f, 2.09105182e-02f, 1.34275466e-01f,
  1.75679028e-02f, 2.05645505e-02f, 5.84813021e-03f, 2.46733874e-02f, -2.76894215e-02f, 1.55736611e-03f, -1.42124677e-02f, -4.93573844e-02f, 2.65317457e-03f, 4.61502597e-02f,
  4.49698940e-02f, 1.94620825e-02f, 6.45188913e-02f, 3.03487610e-02f, 2.11420059e-02f, -7.23895058e-02f, 4.73987684e-02f, 5.50907291e-03f, 1.20957457e-02f, -2.74060052e-02f,
  -1.60668567e-02f, 1.00256741e-01f, -7.49111408e-04f, 5.80305681e-02f, -5.15933484e-02f, -1.45153059e-02f, -4.78258133e-02f, -5.92654608e-02f, 4.84663434e-03f, -1.12830549e-01f,
  1.86049759e-01f, -2.62342066e-01f, -6.66038645e-03f, 4.03847247e-02f, 1.80987194e-02f, -3.09277214e-02f, 1.03719145e-01f, -5.91332316e-02f, -3.67731526e-02f, 7.35646412e-02f,
  -2.10585855e-02f, 7.62056038e-02f, -5.14857769e-02f, 7.70834386e-02f, -2.53693871e-02f, 5.57757802e-02f, 4.75745276e-02f, 1.82264391e-02f, -4.77227978e-02f, 1.02319919e-01f,
  9.12240148e-02f, -5.43718375e-02f, -4.70206663e-02f, 1.09327398e-01f, 5.41759543e-02f, -1.84234902e-02f, 9.26020071e-02f, 1.10217184e-01f, -2.04904657e-02f, 1.62814170e-01f,
  -2.17405066e-01f, -5.72730135e-03f, 8.61037225e-02f, -8.39843452e-02f, 1.86812077e-02f, 1.26891822e-01f, 1.44079089e-01f, 5.26884831e-02f, 2.93673296e-02f, 6.26717880e-02f,
  6.52412772e-02f, -4.18685414e-02f, -9.08131711e-03f, 3.98907810e-02f, -6.20157719e-02f, 7.67006278e-02f, -3.36969718e-02f, 8.18813071e-02f, 8.95338282e-02f, -8.62422436e-02f,
  -3.69093791e-02f, -4.69628945e-02f, 2.25775633e-02f, -1.01740155e-02f, 5.78166656e-02f, -1.38480738e-02f, -1.76340342e-02f, 9.29308385e-02f, -4.98215370e-02f, -9.44777131e-02f,
  2.03463271e-01f, 9.30746421e-02f, -1.08703122e-01f, -1.84545815e-02f, 3.73785906e-02f, -1.61833465e-02f, 9.20626074e-02f, -2.93022823e-02f, 6.81717992e-02f, 6.94971010e-02f,
  1.53934835e-02f, -1.25544779e-02f, -5.05693145e-02f, 8.82419348e-02f, 2.77500898e-02f, 1.70277841e-02f, 5.64338341e-02f, -2.18790621e-02f, 6.19909866e-03f, 2.92001907e-02f,
  -5.96892147e-04f, 4.92013358e-02f, 2.22864468e-02f, -2.55753510e-02f, 6.82557151e-02f, 3.99604626e-02f, 4.89017665e-02f, -2.37904470e-02f, -5.02198264e-02f, 1.82218552e-02f,
  -2.36197840e-02f, 4.05228361e-02f, -8.69752690e-02f, -6.47778139e-02f, 3.21651064e-02f, -1.03672653e-01f, 8.14614892e-02f, 5.31546772e-02f, 1.99930407e-02f, 1.00440765e-02f,
  -1.37153659e-02f, 5.79046039e-03f, 4.47172336e-02f, 1.65597424e-02f, 2.25668903e-02f, 7.45472088e-02f, -1.70275923e-02f, 6.40270114e-02f, -4.79603633e-02f, -2.61300728e-02f,
  -2.99968962e-02f, -8.05630684e-02f, -2.54676901e-02f, 3.17251123e-02f, -4.59691063e-02f, -3.07901353e-02f, 5.60747311e-02f, -6.63518086e-02f, -9.61494818e-03f, 2.35031936e-02f,
  1.65015101e-01f, 1.77299548e-02f, -2.78661828e-02f, 1.17677459e-02f, 1.93946809e-02f, 6.09151945e-02f, 4.03889976e-02f, -4.20644833e-03f, 4.05485108e-02f, 1.35616869e-01f,
  1.16538137e-01f, 9.61165056e-02f, 7.49010965e-03f, -4.32460606e-02f, 5.09324931e-02f, 7.00568110e-02f, -2.01965664e-02f, 7.30257109e-02f, 6.42986074e-02f, 3.08218990e-02f,
  7.50618055e-02f, -1.91588625e-02f, -5.50825261e-02f, -2.64900606e-02f, 1.50406510e-02f, 3.85082997e-02f, 1.39059834e-02f, -1.66602880e-02f, 4.95696366e-02f, 6.05866313e-02f,
  -3.25391181e-02f, 7.05304369e-02f, 4.75741224e-03f, 8.77198502e-02f, -5.41206859e-02f, -2.45073974e-01f, -1.57182753e-01f, -1.68064818e-01f, 2.84068976e-02f, -2.02324577e-02f,
  -9.10511911e-02f, 3.20121348e-02f, 2.92825401e-02f, 3.13403681e-02f, -4.69176285e-02f, 3.42161278e-03f, 1.99434832e-01f, 1.23137809e-01f, -3.46332118e-02f, 1.88468322e-02f,
  1.99386612e-01f, 3.21776345e-02f, 9.48359594e-02f, 1.10928550e-01f, 1.75352052e-01f, 1.12463780e-01f, -5.73064685e-02f, 1.18221819e-01f, 5.43520860e-02f, 3.67640615e-01f,
  1.56975552e-01f, -3.83766405e-02f, -2.84906700e-02f, 4.80117649e-02f, -6.32438138e-02f, 3.39952186e-02f, -2.80524474e-02f, -2.11245418e-02f, -6.51992485e-02f, 1.26885185e-02f,
  7.43089849e-03f, 1.85730848e-02f, 6.80984333e-02f, 2.47408692e-02f, -6.24512434e-02f, -7.28152785e-03f, 3.32517922e-03f, 6.05119057e-02f, -5.00228740e-02f, -3.48250717e-02f,
  1.26182884e-01f, 5.03624938e-02f, -5.92359602e-02f, -4.78192717e-02f, -1.29695848e-01f, -6.09395914e-02f, -1.33473426e-01f, -1.03017755e-01f, -2.16889247e-01f, -1.61032621e-02f,
  4.50011045e-02f, -4.01389897e-02f, -1.84530839e-02f, -1.36054847e-02f, 5.97036667e-02f, -3.29151307e-03f, 1.85163654e-02f, -5.69368750e-02f, 7.32106864e-02f, -2.61840280e-02f,
  -8.52958858e-02f, 4.02604304e-02f, 6.84512965e-03f, -1.15817497e-02f, -1.58237730e-04f, -4.18393761e-02f, -1.19913789e-02f, -2.61927266e-02f, -5.25506660e-02f, -1.99219286e-02f,
  7.54644498e-02f, -7.76226968e-02f, 4.63683195e-02f, -2.10251641e-02f, -7.42463619e-02f, 5.32698035e-02f, -3.50183807e-02f, -8.67310092e-02f, -3.66897136e-02f, 6.76566884e-02f,
  -1.74029350e-01f, -1.46886572e-01f, 6.16935007e-02f, 4.68485579e-02f, 5.40079810e-02f, -6.38395324e-02f, -3.29924718e-04f, 6.63683340e-02f, -2.06836443e-02f, -5.91243580e-02f,
  -4.95796539e-02f, -2.82273144e-02f, -2.99947076e-02f, -4.54832874e-02f, -8.25693682e-02f, 2.40956414e-02f, -1.35319188e-01f, 6.92813769e-02f, -6.43537715e-02f, -2.45656143e-03f,
  -4.27959040e-02f, -4.16451618e-02f, -1.75311297e-01f, -1.32732093e-01f, -1.52787538e-02f, -1.30425110e-01f, -5.62749058e-02f, -1.37631044e-01f, -1.76192716e-01f, -2.34417215e-01f,
  -2.83110261e-01f, -1.69086516e-01f, -1.25952601e-01f, -1.34810656e-01f, 5.48217371e-02f, 3.47267051e-04f, -6.26801550e-02f, -4.04545441e-02f, 5.42978346e-02f, -1.38562247e-01f,
  -2.26669423e-02f, -6.60245046e-02f, -1.45238355e-01f, 4.12245877e-02f, -8.93544033e-02f, -2.57373154e-01f, -9.75389630e-02f, -1.84958383e-01f, 7.27210566e-02f, 6.28925264e-02f,
  4.49958928e-02f, -1.63918361e-01f, -5.13117835e-02f, -6.80408105e-02f, -8.91643912e-02f, -1.17112510e-01f, -1.55907437e-01f, -9.05591622e-02f, -1.44029826e-01f, -2.50556827e-01f,
  -2.62791991e-01f, 1.58794448e-01f, 8.96421745e-02f, -9.92004946e-02f, -7.55144805e-02f, 6.03943393e-02f, -3.12910192e-02f, 9.00305361e-02f, -5.85934967e-02f, 8.05042610e-02f,
  -3.59584056e-02f, 1.00043960e-01f, 1.59920789e-02f, -2.10477207e-02f, 4.16920893e-02f, -6.17564432e-02f, -8.06741565e-02f, -7.20807984e-02f, 3.43393572e-02f, 8.27312395e-02f,
  -2.82135066e-02f, 2.05019377e-02f, -1.01096012e-01f, 2.29778327e-02f, 9.91412625e-02f, 7.51046911e-02f, -2.40551848e-02f, -6.07388429e-02f, -1.32242799e-01f, -2.62123317e-01f,
  -4.58293259e-02f, 2.34709121e-02f, 2.54922137e-02f, 9.60580446e-03f, 1.64192561e-02f, 2.76158713e-02f, -5.27193118e-03f, -1.00273222e-01f, -4.89152297e-02f, -1.03784509e-01f,
  -1.94763895e-02f, 5.21263033e-02f, -5.48839234e-02f, -1.47720248e-01f, -2.41397079e-02f, 3.61748878e-03f, -1.91081106e-03f, -7.42851347e-02f, -8.25840384e-02f, -1.07497466e-03f,
  -2.30527744e-02f, -4.14131247e-02f, -4.48701456e-02f, 5.62472008e-02f, -3.48167308e-02f, -5.41181043e-02f, 4.42843102e-02f, -8.80145561e-03f, -3.04383356e-02f, -4.04754514e-03f,
  -2.23067194e-01f, 8.74713585e-02f, -1.37649789e-01f, -2.20381934e-02f, -2.97061708e-02f, 2.73169689e-02f, 1.16768787e-02f, 7.94735700e-02f, 5.14443628e-02f, 2.37664562e-02f,
  1.61284336e-03f, -2.14795209e-02f, -1.47206500e-01f, -4.62264717e-02f, 5.49870776e-03f, -1.20273186e-02f, -1.01494171e-01f, -1.23701423e-01f, -2.47245468e-02f, 9.46073309e-02f,
  -7.35706463e-02f, -1.23905309e-01f, -7.80999288e-02f, -1.94375262e-01f, -7.85299018e-02f, -1.72612354e-01f, -9.67195332e-02f, -3.37334946e-02f, -2.20309481e-01f, -3.06087613e-01f,
  1.68306813e-01f, 3.18667442e-02f, -2.07203701e-02f, 2.27974746e-02f, 2.62432285e-02f, -5.50846942e-03f, -1.19726859e-01f, -4.20501493e-02f, 1.19679421e-01f, 5.43844402e-02f,
  -9.15072560e-02f, -4.09181304e-02f, 1.74159370e-02f, 9.88191739e-02f, 2.33203676e-02f, -5.07936515e-02f, 8.45719576e-02f, 8.80129188e-02f, 1.34424716e-01f, 3.48522887e-02f,
  8.87648314e-02f, 1.13314196e-01f, 5.96117191e-02f, -5.06978016e-03f, 8.04605111e-02f, 6.55302480e-02f, 1.51352491e-02f, 4.83371429e-02f, -2.28084363e-02f, 4.01199423e-02f,
  8.25560540e-02f, -7.52138793e-02f, -3.63193713e-02f, 4.14733179e-02f, -1.29236793e-02f, 9.21276286e-02f, 1.48185631e-02f, -5.10994829e-02f, -7.29684755e-02f, 1.99392810e-02f,
  -2.16387119e-02f, -6.99366108e-02f, -1.63816307e-02f, -1.60848629e-02f, 2.40358207e-02f, -7.71016404e-02f, 7.86890462e-03f, 8.59434251e-03f, -1.05856536e-02f, -5.67065328e-02f,
  -3.08635971e-03f, -4.02990282e-02f, 2.40425020e-02f, 2.74273697e-02f, -8.40904936e-02f, 8.32543448e-02f, 9.28975735e-03f, 5.55358417e-02f, 7.39213154e-02f, 2.49758903e-02f,
  2.41230112e-02f, -1.57227516e-02f, -9.35286866e-04f, 2.35517845e-02f, -1.11765405e-02f, 9.46762338e-02f, 5.64280897e-02f, 5.45429774e-02f, -1.69012751e-02f, -7.17396662e-02f,
  -5.74986488e-02f, 7.02065900e-02f, 3.46394069e-02f, -2.91307643e-02f, 5.92283010e-02f, 3.66750844e-02f, -3.79832052e-02f, 7.75017366e-02f, 5.18133417e-02f, -2.36204807e-02f,
  6.95788711e-02f, 3.95003967e-02f, 8.89127050e-03f, 2.23902632e-02f, 1.61813274e-02f, 3.19074355e-02f, 7.88170919e-02f, -6.58734515e-02f, -6.74138516e-02f, -4.82381508e-02f,
  -8.26760158e-02f, -1.37601748e-01f, -4.18510521e-03f, -1.08475434e-02f, -7.85109401e-02f, -5.40756946e-03f, 2.37831976e-02f, 8.05056766e-02f, -2.31926013e-02f, -5.83300926e-02f,
  -5.25559634e-02f, -4.77023982e-02f, 4.54128124e-02f, 4.39874940e-02f, -4.30606417e-02f, 2.84420699e-02f, -1.99684016e-02f, -1.95286862e-04f, 1.71531681e-02f, 3.28538977e-02f,
  4.82049072e-03f, 3.21553871e-02f, -3.23036909e-02f, -9.06689316e-02f, -6.90400526e-02f, -1.03558544e-02f, -5.47357015e-02f, 2.67297588e-03f, -8.78989846e-02f, 2.34159417e-02f,
  -2.38808513e-01f, 6.02317080e-02f, 1.30826563e-01f, -7.58270100e-02f, 7.21458942e-02f, 1.37560636e-01f, 6.45206422e-02f, -8.00155289e-03f, -4.39463332e-02f, 8.10906738e-02f,
  4.01763283e-02f, -1.30009979e-01f, -1.31479856e-02f, 5.84722571e-02f, -2.28007114e-03f, -4.18129079e-02f, 7.58814216e-02f, -8.89083222e-02f, 5.52519970e-02f, -2.48297267e-02f,
  -4.66261692e-02f, -8.34715143e-02f, -2.76523661e-02f, -7.59908138e-03f, -6.86587542e-02f, 5.76273771e-03f, -8.61376300e-02f, 1.52138639e-02f, -1.22625558e-02f, -9.29617435e-02f,
  -3.12505588e-02f, -1.47785880e-02f, -1.33436788e-02f, -1.72833819e-02f, 1.26336180e-02f, 7.67916813e-02f, 4.64986414e-02f, -1.04907006e-01f, 5.11474796e-02f, -8.22936967e-02f,
  -4.30634134e-02f, -9.59998816e-02f, -9.48603526e-02f, 7.21471608e-02f, -3.62363867e-02f, 7.73079842e-02f, -6.12964146e-02f, -9.82966647e-02f, 4.10277098e-02f, -4.58595976e-02f,
  1.46538753e-03f, 4.46893424e-02f, -4.43839654e-02f, 1.17771499e-01f, -1.92691851e-02f, 2.82565951e-02f, -1.70594547e-02f, 4.56214808e-02f, 2.66729258e-02f, -6.88208416e-02f,
  5.52203245e-02f, -3.04306690e-02f, -3.21822651e-02f, -6.16807751e-02f, 7.19615370e-02f, -6.47317246e-02f, -4.55596894e-02f, -1.52256712e-02f, -4.19234186e-02f, 6.87470511e-02f,
  1.05533646e-02f, 6.16107835e-03f, -7.24242404e-02f, 7.86030083e-04f, -3.47502083e-02f, -3.65842953e-02f, 4.33239900e-02f, 4.41960245e-03f, 3.71890031e-02f, -6.65061325e-02f,
  -8.84255767e-02f, 6.60070479e-02f, -7.40954056e-02f, -6.34932052e-03f, 6.71473816e-02f, 2.69836336e-02f, 9.84540358e-02f, -2.67565940e-02f, 1.14477418e-01f, 3.68060209e-02f,
  -1.34622216e-01f, 1.51928030e-02f, 3.15723866e-02f, -6.15429273e-03f, 8.03544745e-02f, 7.84332156e-02f, -6.20385483e-02f, 4.19257656e-02f, -4.42179069e-02f, 5.11080325e-02f,
  -3.88847664e-02f, -4.18045595e-02f, 5.26751168e-02f, -6.49715727e-03f, -5.58923930e-02f, -6.31674156e-02f, 7.66493455e-02f, 6.45790026e-02f, -2.56755054e-02f, -6.62450641e-02f,
  1.01033345e-01f, -9.34141874e-03f, -7.61292726e-02f, 7.63376877e-02f, 1.58116911e-02f, 5.81315309e-02f, 4.94871177e-02f, -2.25721076e-02f, -5.49784489e-02f, -5.85392751e-02f,
  -5.28218411e-02f, 5.19836284e-02f, 9.21525955e-02f, -8.51232037e-02f, -1.09850146e-01f, -2.93302611e-02f, 1.00139342e-01f, 5.86800501e-02f, -3.62507580e-03f, 1.12266941e-02f,
  -8.08012933e-02f, -3.17969956e-02f, 6.95578307e-02f, -3.71450931e-02f, 3.71005051e-02f, 1.18205063e-01f, 9.68145579e-03f, -1.29307434e-02f, 8.01688507e-02f, 5.23012914e-02f,
  -2.69423556e-02f, -1.24064498e-02f, 7.48955682e-02f, 1.19233996e-01f, 2.92666070e-02f, -2.30272836e-03f, -2.68798191e-02f, 8.33599716e-02f, 4.90466915e-02f, 4.75244969e-02f,
  3.57695273e-03f, 1.96777564e-02f, -5.69164800e-03f, -9.46510658e-02f, -1.06024176e-01f, -7.51656219e-02f, -7.37098083e-02f, 6.97994083e-02f, -6.29655598e-03f, -1.99994668e-02f,
  2.74145044e-02f, -2.89431196e-02f, 2.29398124e-02f, -3.47930193e-02f, -9.15189907e-02f, -4.13607992e-02f, 7.29939044e-02f, 8.08734223e-02f, 6.13103583e-02f, -7.64339566e-02f,
  2.96754520e-02f, -7.50149414e-03f, 4.27145213e-02f, -2.99551878e-02f, -6.40112236e-02f, -9.19479057e-02f, 1.67893153e-02f, 3.09178103e-02f, -1.28218504e-02f, 3.06535121e-02f,
  3.42131406e-02f, 6.62584614e-04f, 5.76685695e-03f, -3.23714092e-02f, -7.83688426e-02f, -6.28457218e-02f, 7.72579983e-02f, 8.28478262e-02f, 4.82995398e-02f, 2.56989039e-02f,
  5.31731285e-02f, 6.74610287e-02f, -2.15577204e-02f, -2.59665195e-02f, 7.85168074e-03f, -7.48331994e-02f, 5.22845574e-02f, -1.73617210e-02f, 7.36347288e-02f, 7.08750710e-02f,
  -4.28910293e-02f, 1.77336559e-02f, -6.74937218e-02f, 7.98049048e-02f, -2.94718184e-02f, 7.79232755e-02f, -7.99257457e-02f, -4.21875045e-02f, 3.74153559e-03f, -6.96629509e-02f,
  2.94371322e-02f, -9.31478739e-02f, 4.87126298e-02f, 7.95972198e-02f, -5.52055836e-02f, 7.05455691e-02f, 5.10105751e-02f, -2.91990209e-02f, -6.47215322e-02f, -2.09096894e-02f,
  -4.01846990e-02f, -6.39930964e-02f, 5.49368486e-02f, -6.84441328e-02f, -9.18862671e-02f, 3.13057564e-02f, -9.85020846e-02f, 6.97838590e-02f, 3.93488854e-02f, -8.66218731e-02f,
  2.11548395e-02f, -9.29165557e-02f, 1.24757085e-02f, -9.08692703e-02f, -8.69400501e-02f, -5.60040697e-02f, -2.16304101e-02f, 5.60048735e-03f, -1.06059104e-01f, -4.09772843e-02f,
  1.14849277e-01f, 1.13587618e-01f, -9.45544243e-02f, 6.54026791e-02f, 2.24145334e-02f, -7.58811459e-02f, 1.11055449e-01f, 3.00575106e-04f, 9.20714717e-03f, 1.32111400e-01f,
  2.41931360e-02f, -6.96700364e-02f, 4.96249013e-02f, -2.83168014e-02f, -2.76969392e-02f, 1.70896128e-02f, -9.87227187e-02f, -1.50760934e-01f, -1.47467237e-02f, -1.10667482e-01f,
  -2.97603346e-02f, -2.87582166e-02f, 2.91570779e-02f, -4.50737625e-02f, 2.35623643e-02f, -9.65442955e-02f, -1.15956897e-02f, -2.37473361e-02f, 7.37419701e-04f, -9.84707624e-02f,
  -9.74700525e-02f, 9.07174423e-02f, -1.30816981e-01f, -5.95187061e-02f, -4.52866629e-02f, 9.60803628e-02f, 7.63422698e-02f, 1.64116770e-02f, 1.35873109e-01f, 1.34182185e-01f,
  -3.92313562e-02f, 7.11566657e-02f, 6.28014952e-02f, 7.25108162e-02f, 1.76024027e-02f, 1.02198809e-01f, 6.30366476e-03f, -2.33020708e-02f, -1.39444685e-02f, 5.32223172e-02f,
  -3.33902761e-02f, 6.40493929e-02f, -6.53625429e-02f, 6.56420216e-02f, -2.75777709e-02f, -4.80949283e-02f, 5.26154041e-02f, 5.73738515e-02f, -1.24565676e-01f, 6.14574999e-02f,
  -2.47289892e-03f, 1.61659643e-02f, 4.01931517e-02f, 3.93625386e-02f, 1.75968243e-03f, 7.13318959e-02f, -7.39321695e-04f, -8.63400754e-03f, 7.56444931e-02f, 5.21840379e-02f,
  4.09908891e-02f, 4.50577103e-02f, -6.20602146e-02f, 5.54391369e-02f, -4.24070247e-02f, 1.19950837e-02f, 2.09883843e-02f, -5.33141047e-02f, -5.69251329e-02f, 1.04263417e-01f,
  9.38107353e-03f, -4.21540253e-02f, -4.27857004e-02f, -8.15835148e-02f, -8.31393227e-02f, 8.87933671e-02f, 3.12553793e-02f, 2.75540259e-03f, -2.08239630e-03f, 4.94101793e-02f,
  1.01842947e-01f, -1.36925235e-01f, -2.88433637e-02f, -1.21100284e-02f, -6.65018708e-02f, 1.14368498e-01f, -7.78626725e-02f, 3.98278236e-02f, 2.77602933e-02f, 7.58751184e-02f,
  3.19525935e-02f, -2.13946216e-02f, 3.04211732e-02f, 5.94680347e-02f, 1.01598680e-01f, -5.73952235e-02f, 5.47552742e-02f, -9.53285396e-02f, -6.86431676e-02f, 5.68604320e-02f,
  -5.27877547e-03f, 1.00003436e-01f, 3.39691974e-02f, -2.77792960e-02f, -5.27771004e-02f, -1.09557584e-01f, -2.73848139e-02f, 7.81579837e-02f, -9.62654427e-02f, 1.31731510e-01f,
  -2.59032845e-01f, -1.37658432e-01f, 2.03915909e-02f, 2.13950992e-01f, 2.27978200e-01f, 2.43450373e-01f, 2.14687631e-01f, 1.81670442e-01f, 2.00238913e-01f, 2.38271300e-02f,
  -2.09955007e-01f, -3.83202396e-02f, -2.59735435e-03f, 5.33032678e-02f, -2.07139123e-02f, 1.50602415e-01f, 2.60248035e-01f, 7.54791275e-02f, 4.65635508e-02f, -4.90141883e-02f,
  1.46165475e-01f, 6.09254465e-02f, -5.39141474e-03f, 2.04057600e-02f, 1.47807330e-01f, 1.17518224e-01f, 8.03085193e-02f, 1.12765038e-03f, -7.84622058e-02f, 1.27072617e-01f,
  -3.83219391e-01f, -1.82264015e-01f, 4.49299318e-04f, -7.08490610e-02f, -3.87800746e-02f, -8.12594965e-02f, 2.29066759e-02f, -4.55428623e-02f, -5.66744022e-02f, 2.84945946e-02f,
  -6.82748482e-02f, -1.19522125e-01f, 2.73684207e-02f, -7.74079189e-02f, -1.07386492e-01f, 7.59082288e-02f, -9.16784853e-02f, 5.11859432e-02f, -8.28827471e-02f, -4.70413677e-02f,
  -6.67831376e-02f, -1.00643106e-01f, 1.85054622e-03f, 9.10257921e-02f, -3.64862289e-03f, 3.22677381e-02f, -5.41870221e-02f, -4.42196093e-02f, -3.83241810e-02f, -1.26980081e-01f,
  8.32761601e-02f, -8.94476101e-02f, -2.36560330e-02f, -6.31549284e-02f, -5.27530611e-02f, 3.33889090e-02f, 5.17107435e-02f, 3.41615006e-02f, 7.15570599e-02f, -2.89237536e-02f,
  3.57894376e-02f, -5.94946668e-02f, 4.55487333e-02f, -1.29643036e-02f, -4.64529879e-02f, 2.60069333e-02f, 1.29944123e-02f, -4.64525633e-02f, -8.31772834e-02f, -3.11074406e-03f,
  7.94087499e-02f, -1.69476066e-02f, 1.84585415e-02f, 2.58484725e-02f, 5.52145466e-02f, -2.09641159e-02f, 1.00560553e-01f, -2.56990604e-02f, -1.31969983e-02f, 7.25988373e-02f,
  8.68011732e-03f, -8.61159638e-02f, 5.15554883e-02f, -4.45222482e-02f, 1.28682572e-02f, -1.12714373e-01f, 3.13973874e-02f, -9.90669131e-02f, -3.55999768e-02f, -4.62516621e-02f,
  -8.72343034e-02f, -6.39366210e-02f, -7.35144094e-02f, 3.36566344e-02f, 9.85242501e-02f, 1.16287291e-01f, 2.45846529e-02f, -1.12076825e-03f, 1.67035256e-02f, -8.94637778e-03f,
  -6.38467520e-02f, 8.52433294e-02f, 1.11819478e-03f, 7.81756490e-02f, 1.36853065e-02f, 5.28688990e-02f, 5.03097884e-02f, 7.95187131e-02f, -6.63878396e-02f, 1.05236128e-01f,
  1.42173931e-01f, 1.08969338e-01f, -8.84945225e-03f, 1.50111884e-01f, 3.88295092e-02f, 5.66676073e-02f, -4.05400619e-02f, -4.37961891e-02f, 3.76732647e-02f, 4.28568013e-03f,
  5.30926548e-02f, -3.56503502e-02f, 9.47373807e-02f, 9.57056731e-02f, 3.89562212e-02f, 1.00050136e-01f, 1.16280481e-01f, 8.31928924e-02f, 3.95197235e-02f, -2.52180770e-02f,
  4.78668250e-02f, -1.21819535e-02f, 4.76814695e-02f, -1.87403820e-02f, 8.07271600e-02f, 1.02356866e-01f, -1.48345518e-03f, 6.46359697e-02f, 1.14063613e-01f, 1.29734784e-01f,
  -9.25375223e-02f, 1.07341327e-01f, -5.97830750e-02f, -2.85997763e-02f, 7.16720894e-02f, 1.79007519e-02f, -6.39190376e-02f, -1.20208025e-01f, 6.20961040e-02f, -5.70620038e-02f,
  3.09769399e-02f, 2.71388944e-02f, 8.18214789e-02f, -4.22472507e-02f, 8.05180334e-03f, -4.98847570e-03f, -5.23640588e-02f, 5.97046502e-03f, 2.89808289e-04f, -7.30612874e-02f,
  -1.77376773e-02f, 6.14814274e-02f, 5.65830581e-02f, -1.05710849e-01f, 6.35439809e-03f, -9.36655328e-03f, 4.95208316e-02f, -4.36997712e-02f, -7.31947646e-02f, 2.30352525e-02f,
  -4.65206169e-02f, -6.20959699e-03f, 2.37309225e-02f, -5.97360656e-02f, 3.97202708e-02f, -1.59070194e-02f, 3.39354463e-02f, 7.65654221e-02f, -2.79638562e-02f, -6.16813153e-02f,
  -8.34635198e-02f, -4.23684567e-02f, -6.55171126e-02f, -8.83780494e-02f, 1.40570644e-02f, 3.07692261e-03f, 4.94641997e-02f, 2.29166076e-03f, -4.19383012e-02f, -3.42007279e-02f,
  -4.01800498e-02f, -2.26900121e-03f, -7.37831742e-02f, -4.94249277e-02f, 1.23386243e-02f, -2.42417641e-02f, 2.13236492e-02f, 4.94328626e-02f, 7.81181902e-02f, -5.19981012e-02f,
  -1.50594234e-01f, -1.20102577e-01f, -1.87699180e-02f, 4.45394590e-02f, -5.18128574e-02f, -8.08538571e-02f, -9.38980430e-02f, -7.37219155e-02f, -9.41056982e-02f, -4.16853838e-03f,
  8.97981524e-02f, -2.47212555e-02f, -2.68338267e-02f, -2.56785583e-02f, 6.30619377e-02f, 4.81746867e-02f, -7.56161334e-03f, 7.40181729e-02f, -1.07487269e-01f, -3.90967168e-02f,
  3.89283039e-02f, -1.09536007e-01f, -8.76198709e-02f, -5.30944169e-02f, -2.64524911e-02f, 4.12262976e-02f, 4.06806171e-02f, -8.75033513e-02f, -3.28571796e-02f, -4.29796241e-03f,
  -1.11774012e-01f, 7.47943148e-02f, 6.78243348e-03f, 1.02593713e-01f, 1.34040397e-02f, 1.73179805e-02f, -1.11927070e-01f, -1.41140893e-01f, 7.13516492e-04f, 4.14337069e-02f,
  8.48087892e-02f, -1.89534260e-03f, -3.11509725e-02f, 4.94584404e-02f, -2.19496768e-02f, 4.39413823e-02f, -8.05770159e-02f, -5.05789779e-02f, -1.49077177e-01f, -4.52447124e-02f,
  -4.88385260e-02f, 2.94993110e-02f, -6.18867762e-02f, 6.30262569e-02f, 8.51906687e-02f, 7.22280741e-02f, 1.61989611e-02f, -4.24155556e-02f, 8.12313631e-02f, 5.76464646e-02f,
  9.50196683e-02f, 1.21106897e-02f, -9.24250633e-02f, 1.00637022e-02f, 8.05014893e-02f, 4.20095325e-02f, -1.68774966e-02f, -3.56339738e-02f, -3.13595869e-02f, 2.36986461e-03f,
  -1.88532565e-02f, -2.00939607e-02f, -4.58978005e-02f, 3.45665850e-02f, 2.62143840e-05f, -7.53390342e-02f, 2.88016889e-02f, -1.25395849e-01f, -1.17493063e-01f, -2.72590369e-02f,
  -2.38776896e-02f, 8.21573064e-02f, -9.66593344e-03f, -1.07763000e-01f, -6.19360395e-02f, -2.13761274e-02f, -6.71887323e-02f, -5.51290512e-02f, 4.41109249e-03f, -8.66115559e-03f,
  -5.51130585e-02f, 5.59404977e-02f, 4.79573384e-02f, 2.61963177e-02f, 5.35141602e-02f, -3.87124196e-02f, 6.32485822e-02f, -4.00384739e-02f, -2.10057180e-02f, -2.78860983e-03f,
  -3.79736312e-02f, 3.49307470e-02f, -3.66519839e-02f, -8.88038725e-02f, 2.85349507e-02f, -1.76340924e-03f, 3.37265083e-03f, -5.58744222e-02f, -7.44913518e-02f, 2.89479401e-02f,
  2.07925625e-02f, -7.80690461e-02f, 7.24566355e-02f, 1.93046723e-02f, 1.29343905e-02f, -7.09173456e-02f, -3.81962359e-02f, 4.63671647e-02f, -8.38288814e-02f, -1.50713427e-02f,
  -2.06442326e-02f, -1.23139992e-01f, -1.21332863e-02f, -1.91625487e-02f, 7.69665167e-02f, -7.21081048e-02f, 1.20391540e-01f, -6.62841275e-03f, -5.05937785e-02f, -5.87945245e-02f,
  -4.11581509e-02f, -6.45373613e-02f, 7.53913447e-02f, 3.78455333e-02f, -4.41465527e-02f, -1.75522603e-02f, -1.35191381e-02f, -8.71695727e-02f, 5.72216548e-02f, 4.79143485e-02f,
  -1.05158024e-01f, 3.01134586e-03f, -1.30384797e-02f, -4.63132560e-02f, 5.20226583e-02f, -1.95668098e-02f, -2.10161484e-03f, -9.01017785e-02f, -1.49289206e-01f, -6.36466742e-02f,
  -1.42319486e-01f, 6.57629892e-02f, 1.04932323e-01f, -1.58953562e-01f, -1.11620156e-02f, 1.05988182e-01f, 1.59380034e-01f, 5.96403703e-02f, -1.67050138e-01f, -8.96113086e-03f,
  -5.07113226e-02f, -9.72394198e-02f, -9.33700502e-02f, -3.83208841e-02f, 2.95618493e-02f, 4.37935814e-02f, 2.34377310e-02f, -1.04416125e-01f, 2.53288019e-02f, -9.78435874e-02f,
  -3.05865537e-02f, -3.00509240e-02f, -1.75529540e-01f, -1.07134983e-01f, 1.29667372e-02f, 2.94978358e-02f, -7.08800703e-02f, 3.73830833e-02f, 4.92341891e-02f, -7.11562410e-02f,
  1.58393309e-01f, 3.68878804e-02f, 2.27250662e-02f, 5.37374802e-02f, 2.82885712e-02f, -6.85174912e-02f, 9.72663518e-03f, 1.59347616e-02f, 7.05082789e-02f, 6.84592053e-02f,
  -6.84202388e-02f, -4.10035737e-02f, -4.27078754e-02f, 6.54108301e-02f, -5.02317734e-02f, 1.14641767e-02f, 7.32537508e-02f, -4.81933504e-02f, -8.96953270e-02f, 2.82459799e-02f,
  9.12914276e-02f, 1.66609138e-02f, -1.42197218e-02f, -2.92758215e-02f, -1.50651354e-02f, 5.48444688e-03f, 3.49254832e-02f, 6.04435056e-02f, 9.08372179e-02f, -6.61434755e-02f,
  -3.01532187e-02f, -3.84821743e-02f, -4.96553862e-03f, 7.07940385e-02f, -3.84548120e-02f, -6.32810444e-02f, -2.69003566e-02f, 5.68716824e-02f, 5.39305881e-02f, -2.07926314e-02f,
  -3.55686061e-02f, -2.09291689e-02f, 1.03167027e-01f, -3.18985395e-02f, 7.40981475e-02f, 1.04985842e-02f, 6.23587184e-02f, 6.38448820e-02f, -6.25231043e-02f, -1.48649309e-02f,
  -1.26076099e-02f, 3.03994529e-02f, 6.74063265e-02f, -6.10471256e-02f, 7.08759129e-02f, -1.07378080e-04f, 7.82694761e-03f, 4.30621032e-04f, 6.66111112e-02f, 5.54085895e-02f,
  -1.05861299e-01f, 1.19949847e-01f, -7.51092657e-02f, -9.48016271e-02f, -3.72178778e-02f, -2.56968252e-02f, 4.99809459e-02f, -5.21380268e-02f, -6.54931217e-02f, -5.86785488e-02f,
  5.15687764e-02f, 2.67030415e-03f, 5.11548668e-02f, -2.75519490e-02f, -4.49864194e-02f, 7.68496245e-02f, -1.95841398e-02f, 1.15435077e-02f, -4.61646281e-02f, 5.79827353e-02f,
  -9.99576449e-02f, -1.12540498e-02f, -7.55049055e-03f, 4.63956315e-03f, -5.68387732e-02f, -9.41249281e-02f, 1.00599989e-01f, -8.87979046e-02f, 4.80935946e-02f, -1.84061136e-02f,
  1.26511186e-01f, 1.52976979e-02f, -2.80959830e-02f, -2.06782687e-02f, -3.41072753e-02f, -1.58112347e-01f, -4.25814576e-02f, -8.40537474e-02f, 2.12184358e-02f, 7.97218829e-02f,
  1.47083193e-01f, 1.41445905e-01f, 1.40761226e-01f, 9.71577093e-02f, -4.68281657e-03f, 1.90382972e-02f, 1.49505483e-02f, 2.95685027e-02f, 5.06518707e-02f, 4.74899337e-02f,
  4.81672995e-02f, -3.76942940e-02f, 1.03184618e-01f, -4.36957628e-02f, -3.21691595e-02f, -1.81727931e-02f, 8.53054896e-02f, 9.15384144e-02f, 6.07022420e-02f, 1.17365897e-01f,
  5.10378145e-02f, 7.70117715e-02f, 4.80796061e-02f, 1.45613208e-01f, 2.69129220e-02f, 8.45286176e-02f, 2.99498141e-02f, -2.81308815e-02f, 5.03086261e-02f, -1.05898296e-02f,
  7.75978640e-02f, 1.20431393e-01f, -6.65192232e-02f, -1.54412454e-02f, -8.35760608e-02f, 3.46315303e-03f, 9.15097594e-02f, 1.51192555e-02f, -4.85906824e-02f, 4.13516797e-02f,
  -8.86567053e-04f, 5.44667765e-02f, -2.02678679e-03f, -4.13566343e-02f, 2.11885502e-03f, 1.20468661e-01f, 2.71117631e-02f, -2.39746831e-02f, -7.37824813e-02f, 8.93151164e-02f,
  4.45281565e-02f, -3.61054726e-02f, -4.29205336e-02f, 4.94830497e-02f, 1.19872240e-03f, 3.03355213e-02f, -6.05859719e-02f, -9.19059664e-02f, 4.67123613e-02f, 5.54465242e-02f,
  -1.49318576e-02f, 6.18751496e-02f, -4.92570661e-02f, 2.53960378e-02f, 1.78188328e-02f, -7.38692358e-02f, -9.18403175e-03f, -7.87056386e-02f, -3.02860718e-02f, -7.25291222e-02f,
  -5.43504804e-02f, -2.55339555e-02f, 4.06949222e-02f, -4.30112109e-02f, -4.22301814e-02f, -5.24388812e-02f, 1.11603457e-02f, 6.40873089e-02f, -3.80756147e-02f, 4.53746878e-02f,
  -2.82882508e-02f, 9.46659967e-02f, 1.23833567e-01f, 1.01162516e-01f, 8.71761050e-03f, 1.29703647e-02f, -1.08116101e-02f, 8.73976946e-02f, 4.81460020e-02f, 5.36155067e-02f,
  -1.29280249e-02f, -1.69554465e-02f, -9.77522954e-02f, -3.77782770e-02f, -9.15420949e-02f, -1.09483218e-02f, 8.14186856e-02f, 5.15430234e-02f, 5.65468110e-02f, 7.68512860e-02f,
  -7.04062730e-02f, 1.40366610e-03f, -2.66961772e-02f, -6.19984493e-02f, 6.18192069e-02f, 8.37896317e-02f, 6.93674088e-02f, 2.01311782e-02f, 1.85598359e-02f, -4.91704084e-02f,
  1.25954479e-01f, 9.92867276e-02f, -1.08191527e-01f, 4.20923643e-02f, 4.17539999e-02f, -7.45215937e-02f, 1.11598931e-02f, 5.23786768e-02f, -6.06906824e-02f, 8.18255842e-02f,
  -9.02550370e-02f, -8.09988007e-02f, -2.75561176e-02f, 1.16023864e-03f, -3.01719066e-02f, -2.46189907e-02f, 4.02040184e-02f, -1.02668025e-01f, -2.15772390e-02f, -9.21143368e-02f,
  2.21817419e-02f, 3.57317813e-02f, 9.26132873e-02f, -3.58130187e-02f, -5.47326393e-02f, 4.76796776e-02f, -3.97227816e-02f, -6.86887577e-02f, 4.35660332e-02f, 1.03398943e-02f,
  -2.01740444e-01f, -1.17881067e-01f, -1.09044105e-01f, -4.09160554e-03f, -1.12310573e-02f, 3.13809142e-02f, -5.35155386e-02f, -4.81644422e-02f, -1.11429617e-01f, -7.84568191e-02f,
  -8.42631310e-02f, 1.20988348e-02f, -1.33393407e-01f, 1.06421309e-02f, -8.25574249e-02f, 3.37393694e-02f, 2.58345120e-02f, -2.12198980e-02f, 3.80304642e-02f, -4.32206318e-02f,
  4.88011986e-02f, -2.78665572e-02f, 2.98080891e-02f, 7.94084743e-02f, -1.30201116e-01f, -5.02933823e-02f, -7.84584600e-03f, -3.64745148e-02f, -1.19918972e-01f, 2.10806970e-02f,
  -5.82811274e-02f, -1.50911249e-02f, 3.05488072e-02f, 5.58539517e-02f, 2.62382813e-02f, 5.06304987e-02f, 2.64289882e-02f, -1.75365675e-02f, 2.17008144e-02f, -4.33381088e-02f,
  -1.61516629e-02f, -7.85318315e-02f, -2.66833324e-02f, 8.75428021e-02f, 3.50017510e-02f, 4.07350548e-02f, -2.44662706e-02f, 6.31610975e-02f, 7.64452517e-02f, -8.24931040e-02f,
  5.21150231e-02f, 2.45558447e-04f, -7.08588138e-02f, -5.47937118e-02f, 5.81437424e-02f, -2.31338535e-02f, 6.26510307e-02f, -3.47713903e-02f, -2.54108687e-03f, 6.17411286e-02f,
  1.29808366e-01f, -1.26685074e-03f, -4.54456210e-02f, -6.06091693e-03f, 6.14727661e-02f, -1.59142911e-02f, -7.88877904e-02f, -1.20800398e-02f, -1.05413400e-01f, -5.75003885e-02f,
  -9.33753178e-02f, -8.29901397e-02f, 5.26834726e-02f, 3.65639701e-02f, -7.60388151e-02f, -3.13355066e-02f, 5.78039102e-02f, 1.48322992e-02f, -7.96677172e-02f, 3.37884054e-02f,
  1.23795964e-01f, 3.39710936e-02f, 6.41017631e-02f, 1.02157533e-01f, -6.92512468e-02f, 3.91831435e-02f, -6.32030442e-02f, -4.36486602e-02f, 3.50183286e-02f, 1.84550375e-01f,
  -2.00502593e-02f, -5.40218987e-02f, -3.63905817e-01f, -1.39672766e-02f, -1.30813107e-01f, -1.28650799e-01f, -8.68261456e-02f, -4.90082335e-03f, -3.52371186e-02f, -1.46672696e-01f,
  4.55551222e-02f, -4.59620692e-02f, 1.64038017e-02f, 1.28305200e-02f, 7.61659145e-02f, -1.53948560e-01f, -2.24913046e-01f, -2.07913563e-01f, -2.23456491e-02f, -1.01728477e-01f,
  5.29563539e-02f, -4.20118086e-02f, -1.25624225e-01f, -8.24355409e-02f, 4.84292395e-02f, -3.58395837e-02f, -1.85975075e-01f, -1.33248240e-01f, -1.16101630e-01f, -1.79527298e-01f,
  -1.33532256e-01f, -1.87881589e-01f, -7.34376311e-02f, 7.58501738e-02f, -1.13726281e-01f, 1.16809998e-02f, -1.65011063e-02f, -6.99760988e-02f, 8.39022398e-02f, -5.69272265e-02f,
  -1.79822259e-02f, 5.50546125e-02f, 6.43265918e-02f, -3.32516283e-02f, 2.94650942e-02f, 1.93365924e-02f, 4.17328477e-02f, -4.17832173e-02f, 1.33208958e-02f, 5.51318191e-03f,
  -5.39846309e-02f, -8.00041929e-02f, -8.91822875e-02f, 5.54305166e-02f, -2.74711642e-02f, -8.42376426e-02f, -1.31647307e-02f, -6.24472834e-02f, 4.67559844e-02f, 1.89643148e-02f,
  3.16338092e-02f, 5.60443662e-02f, -6.66900426e-02f, -4.20809118e-03f, 3.55010852e-02f, 1.63895134e-02f, -8.51881355e-02f, 3.69020067e-02f, 1.60158817e-02f, 9.35508609e-02f,
  3.18301618e-02f, -6.58268332e-02f, 2.59486996e-02f, -4.41545062e-02f, -2.24933419e-02f, -5.36369160e-02f, 2.54914537e-02f, 3.19014117e-02f, -3.96899171e-02f, -5.41956238e-02f,
  1.67936421e-04f, 2.93384008e-02f, 3.27710547e-02f, 4.74036299e-02f, -1.25061363e-01f, 1.56644136e-02f, 5.72947506e-03f, 9.95998681e-02f, -2.12108698e-02f, 1.13951992e-02f,
  1.20069802e-01f, -1.69956639e-01f, -4.11843471e-02f, 6.58529159e-03f, -3.93428504e-02f, 1.52482120e-02f, -1.12222686e-01f, 3.46615948e-02f, -5.35295680e-02f, -2.30341628e-02f,
  -3.75161357e-02f, 5.59764989e-02f, 6.64121211e-02f, 2.14882232e-02f, -4.70394501e-03f, 3.11830058e-03f, 8.74996837e-03f, -6.70019761e-02f, 8.44146982e-02f, -2.69159023e-02f,
  -1.40023921e-02f, 1.36272073e-01f, 2.11742714e-01f, 3.16299917e-03f, 7.43018761e-02f, 2.60356404e-02f, 1.20177962e-01f, 9.71748829e-02f, 1.16259933e-01f, 1.54954255e-01f,
  2.53837764e-01f, 1.59517154e-01f, 1.11256413e-01f, -3.30503844e-02f, -1.31900787e-01f, -1.32856786e-01f, 3.28048915e-02f, 4.20230404e-02f, 1.16287291e-01f, 9.11533087e-02f,
  -6.64885156e-03f, 2.53476631e-02f, -6.65252283e-02f, -6.46944046e-02f, 8.22349861e-02f, 1.11704022e-01f, 3.53827924e-02f, 6.65919110e-02f, -2.00837245e-03f, 4.84779514e-02f,
  9.11697447e-02f, 1.51792571e-01f, 2.32404098e-01f, 1.47140563e-01f, 1.67881548e-02f, -3.07891965e-02f, -1.56015316e-02f, 9.28393379e-02f, 9.01635271e-03f, 1.53225392e-01f,
  6.66254610e-02f, 2.16968190e-02f, -3.06396373e-02f, 8.10602307e-02f, -6.60327673e-02f, 5.40985614e-02f, -2.05563139e-02f, 7.02264309e-02f, -3.52999717e-02f, 9.12603512e-02f,
  1.08441822e-02f, 1.04769051e-01f, -8.65751803e-02f, 1.81772327e-03f, -4.67295423e-02f, 3.29917334e-02f, -1.85714755e-02f, 4.06251065e-02f, 9.30001363e-02f, 1.53915510e-02f,
  -5.65437712e-02f, -1.55896479e-02f, 4.26483303e-02f, -9.17581692e-02f, -5.24979755e-02f, -6.03440367e-02f, -4.24669385e-02f, 8.14553648e-02f, -7.44751692e-02f, 6.36907816e-02f,
  -1.13164932e-02f, 6.06394894e-02f, -7.75818527e-02f, -8.57770965e-02f, -3.88025902e-02f, 5.17970137e-02f, -4.75627482e-02f, 1.97449606e-02f, -7.30654225e-02f, 8.94801393e-02f,
  -7.69131407e-02f, 1.74373034e-02f, -8.99796933e-03f, 4.06726040e-02f, -7.25121200e-02f, -5.22491410e-02f, -6.71037510e-02f, -4.59118746e-02f, -8.37998241e-02f, 9.29929968e-03f,
  3.22516486e-02f, -1.17886160e-03f, 2.87707411e-02f, -1.15455287e-02f, -1.95886176e-02f, 4.82089706e-02f, -4.90627624e-02f, -2.07770336e-02f, 9.61488113e-03f, 8.31860378e-02f,
  2.14815326e-02f, -1.74354017e-01f, 1.37218283e-02f, 8.51389542e-02f, 1.09843928e-02f, 6.89937621e-02f, 1.42187681e-02f, 4.98292185e-02f, -5.52553646e-02f, 8.40469599e-02f,
  2.83481684e-02f, 4.88917530e-02f, -9.64322761e-02f, 1.89278442e-02f, -2.46451348e-02f, -4.13496308e-02f, 7.45255500e-02f, -2.07650177e-02f, 5.87817058e-02f, 1.60663505e-03f,
  6.19416684e-02f, -7.50400275e-02f, 5.04815876e-02f, 1.04692830e-02f, -4.37295437e-02f, -1.30653188e-01f, -3.11753862e-02f, 2.93114427e-02f, -9.78392661e-02f, 6.32973388e-02f,
  -5.95178548e-03f, 8.36971849e-02f, 3.72399427e-02f, 2.30862588e-01f, 2.85203487e-01f, 6.00639023e-02f, 1.33097738e-01f, 7.65868872e-02f, 1.11384191e-01f, 1.71144933e-01f,
  2.35128954e-01f, 2.51946568e-01f, 1.45875707e-01f, 1.76457644e-01f, 9.71347615e-02f, 1.67114437e-02f, 9.44625959e-02f, -5.72072081e-02f, 4.46476489e-02f, 1.19435079e-01f,
  4.59980704e-02f, 3.39388698e-02f, -7.21585751e-02f, -7.52278268e-02f, 1.42705068e-01f, 7.85102695e-02f, 4.85988893e-02f, -6.42086938e-02f, 8.05499256e-02f, 1.52857840e-01f,
  6.11960702e-02f, 7.71283126e-03f, -1.17098372e-02f, -6.40295260e-03f, 7.85975009e-02f, -6.53865635e-02f, 2.71340329e-02f, -1.04834758e-01f, -9.29465704e-03f, -8.28334168e-02f,
  -5.57359494e-02f, -9.89061967e-02f, 1.46431513e-02f, -2.35207304e-02f, -1.77769605e-02f, -1.09439865e-01f, -1.00478254e-01f, -1.22137539e-01f, -1.15468509e-01f, 3.99439484e-02f,
  1.29646197e-01f, 4.50055674e-02f, -3.08850072e-02f, -1.96115840e-02f, -7.63259456e-02f, 4.02441248e-02f, 1.12692360e-02f, 2.01866161e-02f, -3.32908221e-02f, -6.14399053e-02f,
  2.03966610e-02f, 6.95087165e-02f, 1.11247808e-01f, -4.41218577e-02f, -1.22284489e-02f, 6.48261085e-02f, 2.43033050e-03f, -2.76985988e-02f, -1.25646349e-02f, -4.30019908e-02f,
  7.20488653e-02f, -1.38742905e-02f, 5.13205044e-02f, 8.52136761e-02f, 5.16543649e-02f, -6.96634687e-03f, 1.02611013e-01f, 8.09094459e-02f, 2.14405311e-03f, 4.54865722e-03f,
  -7.93722272e-02f, -7.60834664e-02f, 8.97344109e-03f, -3.72772701e-02f, 3.68278404e-03f, 4.65030670e-02f, -7.13549480e-02f, -2.95276660e-02f, 3.53021314e-03f, -2.21319888e-02f,
  -2.98564378e-02f, 3.09606027e-02f, -2.64476538e-02f, -6.02548532e-02f, 1.63128171e-02f, 5.16117290e-02f, 9.16734636e-02f, -1.36445807e-02f, -1.11540155e-02f, -5.35937306e-03f,
  3.11083887e-02f, -4.57301401e-02f, 8.84097517e-02f, -2.80873310e-02f, -9.52062532e-02f, -4.01418023e-02f, -6.71164617e-02f, -3.07772160e-02f, -3.70927714e-02f, -3.94527502e-02f,
  2.19076443e-02f, -1.04387224e-01f, -5.05330339e-02f, -2.13888194e-02f, -6.43739030e-02f, 6.71505183e-02f, -1.57769918e-01f, -1.56522632e-01f, -8.63848627e-02f, -9.30085704e-02f,
  -7.17588421e-03f, 5.52388653e-02f, 8.14340860e-02f, 9.07404274e-02f, -6.15873076e-02f, -1.65688023e-02f, 4.75542474e-04f, 1.56271290e-02f, 3.44887972e-02f, 2.65962593e-02f,
  -3.63800898e-02f, 6.54366612e-02f, 1.15405824e-02f, 7.88446590e-02f, -1.81533664e-03f, -5.69305979e-02f, 5.13833947e-04f, 2.32097749e-02f, -1.53869260e-02f, 9.29275379e-02f,
  4.20908481e-02f, 1.68427788e-02f, 8.99394751e-02f, 5.88507615e-02f, -9.87458006e-02f, -6.04205113e-03f, -3.08132246e-02f, 1.49908699e-02f, 6.99424744e-02f, 1.78689994e-02f,
  4.33362424e-02f, 2.24142354e-02f, 8.61919224e-02f, 3.67802102e-03f, 5.17446995e-02f, 7.72933811e-02f, -6.96798041e-02f, 5.33806086e-02f, -2.59533357e-02f, 6.70085773e-02f,
  -6.47408962e-02f, -9.64865088e-02f, 3.59769203e-02f, -5.51149659e-02f, -7.79819265e-02f, 7.24127889e-02f, -6.20159581e-02f, 8.08731467e-02f, -4.94803935e-02f, -1.94366556e-02f,
  1.68426894e-02f, 4.66089323e-02f, -8.49367604e-02f, -4.55073565e-02f, -9.49072391e-02f, 4.09297682e-02f, 4.17198241e-03f, -1.94180720e-02f, -8.05852339e-02f, 7.52276480e-02f,
  -5.13820462e-02f, -4.99605834e-02f, 7.61089399e-02f, 6.45445511e-02f, 8.00294578e-02f, -6.24407642e-02f, 3.44023295e-02f, 7.89465383e-02f, -1.46059990e-02f, -4.84976023e-02f,
  8.44187066e-02f, 8.84875935e-03f, 4.39934209e-02f, -3.69480625e-02f, 5.75472899e-02f, -6.03866577e-02f, 2.78881844e-02f, -8.13696682e-02f, -6.72427192e-02f, -7.11533800e-02f,
  1.05046906e-01f, 1.61223747e-02f, -2.37704441e-02f, 1.13059897e-02f, -4.06971723e-02f, 1.85401011e-02f, -3.17768119e-02f, 6.43360093e-02f, -7.11524161e-03f, -2.05614567e-02f,
  -1.63759978e-03f, -2.92769987e-02f, 1.05503187e-01f, 6.58438355e-02f, -7.37219825e-02f, 6.74906597e-02f, 1.57827372e-03f, -6.71473444e-02f, -9.08853933e-02f, -2.49389224e-02f,
  2.69808564e-02f, -4.31379862e-02f, -7.33423159e-02f, 3.58047225e-02f, 5.05651347e-02f, 2.48854887e-02f, -6.08914867e-02f, 3.01570091e-02f, 4.70210351e-02f, 5.63410036e-02f,
  -7.82191083e-02f, -6.00744411e-02f, 1.12686485e-01f, -6.79767579e-02f, 4.40022163e-02f, 1.11120986e-02f, -6.37185574e-02f, 2.94884425e-02f, 5.23634180e-02f, 1.35663897e-01f,
  2.02904597e-01f, 1.34384692e-01f, -1.17792681e-01f, 1.06923237e-01f, -7.45890215e-02f, -1.04766116e-01f, -1.54609665e-01f, 5.34164310e-02f, 6.20828792e-02f, -3.38197947e-02f,
  -1.20168896e-02f, -3.60776186e-02f, -7.69187883e-02f, -5.89659661e-02f, -6.11875243e-02f, -1.00700140e-01f, -1.41357452e-01f, -6.34913296e-02f, -1.16191216e-01f, -1.23813629e-01f,
  -7.00395182e-02f, 1.10937931e-01f, 1.03660047e-01f, -4.95801903e-02f, -3.07811387e-02f, -2.33217198e-02f, -1.11509264e-01f, -7.73185194e-02f, -3.92894708e-02f, -2.53833039e-03f,
  -1.86982945e-01f, -1.06561005e-01f, -3.76990624e-02f, 1.35099202e-01f, 5.45455441e-02f, 7.02119619e-03f, -1.20512741e-02f, 1.26994461e-01f, 6.27546012e-02f, 6.98999763e-02f,
  -4.88632061e-02f, -8.13870281e-02f, 5.15000559e-02f, 3.22557054e-02f, 3.75236385e-02f, -5.45523688e-02f, 1.07924573e-01f, 8.38211477e-02f, -2.37650797e-02f, -7.45700970e-02f,
  7.78139532e-02f, -2.49279849e-02f, -9.31699872e-02f, 7.42367096e-03f, -6.55364543e-02f, -5.75485565e-02f, -6.54881150e-02f, -9.50561091e-03f, -5.49283810e-02f, -2.39618309e-02f,
  -1.17575817e-01f, -7.02230781e-02f, -5.80674335e-02f, -1.69105195e-02f, 4.51868176e-02f, -2.48486586e-02f, 2.78984159e-02f, 4.81206886e-02f, -8.27224776e-02f, 7.37803355e-02f,
  6.95136264e-02f, -6.84148297e-02f, -8.82289559e-02f, -1.02594569e-02f, 6.93768263e-02f, 3.26064155e-02f, -2.55758893e-02f, -5.12429513e-02f, -6.20900057e-02f, -5.36419898e-02f,
  -2.26896610e-02f, -3.42998803e-02f, -1.01061827e-02f, 4.56117243e-02f, -4.67136540e-02f, -6.11447357e-02f, -9.95973796e-02f, 6.35782722e-03f, 1.93806961e-02f, 1.13860576e-03f,
  3.66056450e-02f, -2.20702350e-01f, 1.15814261e-01f, 7.40321055e-02f, 3.15476358e-02f, -4.11004806e-03f, 1.44948773e-02f, -3.24728824e-02f, 7.01702833e-02f, 2.65675262e-02f,
  6.20842576e-02f, -6.61851466e-02f, 7.20226020e-02f, 3.19217369e-02f, 8.39483272e-03f, -1.75039936e-02f, 3.21811251e-02f, -2.23555658e-02f, -3.12554762e-02f, 5.80694526e-02f,
  7.31419027e-02f, 3.99313346e-02f, 1.58340356e-03f, -3.60346101e-02f, 5.28465509e-02f, -4.56034020e-02f, -4.20721062e-02f, 8.63345787e-02f, -6.75860643e-02f, 2.28961810e-01f,
  1.30955920e-01f, -1.50054589e-01f, -4.84968096e-01f, -1.76207975e-01f, -2.01151088e-01f, -1.01843685e-01f, -1.32933736e-01f, 8.21415260e-02f, -1.79952886e-02f, -2.55395949e-01f,
  -3.34855840e-02f, -2.94440556e-02f, -1.38719976e-01f, -1.87047068e-02f, 5.80061339e-02f, -2.41281644e-01f, -3.13141704e-01f, -1.63021624e-01f, 3.46018141e-03f, 9.41254869e-02f,
  5.45322783e-02f, -4.93098572e-02f, 1.00103430e-01f, -2.77398955e-02f, -1.11449018e-01f, -4.29360308e-02f, -2.53745735e-01f, -2.27945119e-01f, -1.80440128e-01f, -3.49045187e-01f,
  -5.37265122e-01f, -4.72409017e-02f, -1.70349069e-02f, 1.17144309e-01f, -4.16430235e-02f, 2.82624792e-02f, 3.78774740e-02f, -9.35255457e-03f, 4.73940745e-02f, -1.04966722e-01f,
  -4.76583838e-03f, -1.46592138e-02f, -1.06242895e-02f, 6.02425188e-02f, -5.58764935e-02f, 7.17763454e-02f, -3.97122884e-03f, -5.54841645e-02f, -8.19158182e-02f, 1.05549581e-02f,
  2.82326173e-02f, -1.04751125e-01f, 5.43345995e-02f, 6.91925585e-02f, -4.83031534e-02f, -3.64219435e-02f, -1.27207264e-01f, 1.41136488e-02f, 2.06283424e-02f, -6.27505630e-02f,
  -2.51136348e-02f, -5.98038658e-02f, -6.45778477e-02f, 3.12318634e-02f, 9.95773301e-02f, -8.36458728e-02f, -5.87081118e-03f, -1.06475111e-02f, 7.90776834e-02f, -4.73818928e-02f,
  -3.55051784e-03f, -6.24211244e-02f, 6.65490776e-02f, -3.92283918e-03f, -7.04752579e-02f, 1.94181446e-02f, 2.84216721e-02f, -2.90243644e-02f, -5.06837759e-03f, 5.25179729e-02f,
  4.47293818e-02f, 1.52176078e-02f, -7.69364610e-02f, 3.07408590e-02f, -7.80454427e-02f, 1.57897398e-02f, 6.12388328e-02f, 1.23921126e-01f, -1.40866609e-02f, 5.66419661e-02f,
  -5.35076559e-02f, 3.53362039e-02f, -7.65072331e-02f, 1.04942039e-01f, -1.07245386e-01f, 1.05188154e-02f, -9.58892107e-02f, -3.88111137e-02f, -1.18673919e-02f, -5.19063249e-02f,
  -9.08942311e-04f, -1.81208607e-02f, -5.68781421e-02f, 8.55490342e-02f, 4.30084132e-02f, 2.56648716e-02f, 7.84436520e-03f, -4.69493791e-02f, -8.87472462e-03f, 1.27638891e-01f,
  3.96291353e-02f, 5.40632643e-02f, 3.35847475e-02f, -8.79562460e-03f, 2.06811423e-03f, -4.22327444e-02f, -1.49463369e-02f, -9.82700959e-02f, -3.86879742e-02f, 2.22578589e-02f,
  7.08175972e-02f, -1.48563892e-01f, 4.03028652e-02f, 8.20307955e-02f, 3.39033753e-02f, -1.03492569e-02f, 5.11222407e-02f, 9.02805552e-02f, 4.78035882e-02f, -4.34099726e-04f,
  -6.80297017e-02f, -1.93525583e-01f, -1.32269248e-01f, -3.30534689e-02f, -4.55057733e-02f, 2.47811321e-02f, 1.05106965e-01f, -3.22357863e-02f, 7.77024105e-02f, 8.33696499e-02f,
  -6.23308271e-02f, -4.10676375e-02f, 4.55513112e-02f, -1.92436632e-02f, 8.96139443e-03f, -6.42236248e-02f, 6.69491896e-03f, -1.89360902e-02f, -1.03926705e-02f, 1.43800806e-02f,
  -1.46397218e-01f, -8.74951109e-02f, 1.05458032e-02f, -2.54351851e-02f, -1.16432160e-01f, 2.66046412e-02f, -2.21724436e-02f, -2.84174830e-02f, -6.70524389e-02f, 4.89417203e-02f,
  -1.08512476e-01f, -1.01449646e-01f, 3.82877002e-03f, -1.19948819e-01f, 8.82697664e-03f, 1.37399789e-02f, 9.56636481e-03f, 9.95355323e-02f, 3.76905501e-02f, 2.00338103e-02f,
  -1.71964057e-02f, 3.97693701e-02f, 1.12898126e-02f, -9.70039517e-03f, -2.49039792e-02f, -2.70877779e-02f, -2.93082627e-03f, -8.45186636e-02f, -1.44695602e-02f, -3.21816169e-02f,
  1.04347892e-01f, -3.00302841e-02f, -8.95219296e-02f, -2.44803987e-02f, -5.53595014e-02f, 6.44895062e-02f, 6.92157224e-02f, 2.30131950e-02f, 6.98600430e-03f, -1.60903223e-02f,
  -2.37534773e-02f, 7.88603276e-02f, 3.07180565e-02f, 6.37496784e-02f, -1.10010266e-01f, -1.12683335e-02f, 7.38037378e-02f, 3.82739864e-02f, 5.89122158e-03f, -4.36628330e-03f,
  4.83474554e-03f, -4.52418663e-02f, 1.76800787e-02f, 1.80392116e-02f, -2.56837998e-02f, -5.55370599e-02f, -3.94892767e-02f, -5.21008782e-02f, 3.10137477e-02f, 2.81038154e-02f,
  -3.75807695e-02f, -8.53858516e-03f, 4.75187078e-02f, 8.97712037e-02f, 2.14545354e-02f, -1.88557729e-02f, -4.27178741e-02f, 4.60437238e-02f, 9.57390293e-03f, 1.78849641e-02f,
  -1.04637079e-01f, 4.73538861e-02f, -1.17972996e-02f, -1.97083764e-02f, 1.17613375e-03f, -5.98492548e-02f, -6.68567494e-02f, -2.47938409e-02f, -1.16516994e-02f, -1.68740340e-02f,
  1.10994287e-01f, 1.65395617e-01f, 1.56690583e-01f, 3.67356129e-02f, 4.12317663e-02f, 1.39203236e-01f, 9.63813663e-02f, 7.36484826e-02f, 7.80612826e-02f, 1.00227982e-01f,
  1.60093144e-01f, -4.32668701e-02f, -2.41279468e-01f, 3.97872515e-02f, 1.03877187e-02f, -7.73137435e-02f, -1.66948661e-01f, 1.82730127e-02f, 1.16009027e-01f, -1.27609791e-02f,
  7.59706274e-02f, 7.93421641e-02f, 1.40927315e-01f, 6.91256300e-02f, -4.54626698e-03f, -3.76309045e-02f, -2.02312455e-01f, -3.75170968e-02f, 8.28176290e-02f, -4.14269307e-04f,
  -2.07320340e-02f, -3.88665460e-02f, -2.58318055e-02f, -2.47489028e-02f, 3.83908004e-02f, -4.26721796e-02f, -8.61944184e-02f, -3.09055150e-02f, -3.27036232e-02f, -5.15452400e-02f,
  5.07115722e-02f, -1.27362758e-01f, -4.53979559e-02f, 6.81523755e-02f, -1.37719974e-01f, -1.22766711e-01f, 3.44886468e-03f, -5.57443574e-02f, 5.18665835e-02f, -1.92047264e-02f,
  2.31503695e-03f, -2.90039014e-02f, -3.01592667e-02f, -1.94043275e-02f, -2.30689254e-02f, 6.12955652e-02f, -2.28915224e-03f, -1.10564761e-01f, -1.46189462e-02f, -7.81738907e-02f,
  -7.00702369e-02f, -9.24173221e-02f, 2.82374471e-02f, -4.87887189e-02f, -9.35201999e-03f, 5.93037270e-02f, -6.92366362e-02f, -8.39040205e-02f, -1.21224247e-01f, -1.52110495e-02f,
  -3.00751626e-02f, -3.53073142e-03f, 5.08810356e-02f, 5.93535602e-02f, 1.00489847e-01f, 1.93745196e-02f, 7.49627054e-02f, -5.31226723e-03f, 6.28770143e-02f, -5.39760739e-02f,
  5.55392466e-02f, -8.17459300e-02f, 6.29917383e-02f, -6.77790269e-02f, -3.17725688e-02f, -1.10441156e-01f, 2.34176777e-02f, -4.22643311e-02f, -2.59904563e-02f, -1.73079558e-02f,
  8.68550763e-02f, -7.12545961e-02f, -2.72118021e-02f, -4.67653200e-02f, -7.54426047e-02f, -2.68941671e-02f, 3.18154991e-02f, -8.20499286e-02f, -7.66533520e-03f, -9.10285935e-02f,
  1.93160087e-01f, -1.03941642e-01f, 1.00562148e-01f, 8.08904320e-02f, -5.61347716e-02f, -1.49448505e-02f, 3.80167887e-02f, 3.87200229e-02f, -7.68159181e-02f, 7.27406070e-02f,
  -4.94201481e-02f, 1.59796495e-02f, -5.93961366e-02f, 1.17455833e-02f, -2.02334020e-02f, 1.04438243e-02f, 1.46527411e-04f, 3.56323719e-02f, -8.29296187e-02f, 4.37359465e-03f,
  -5.77661544e-02f, 5.91511913e-02f, 7.34581128e-02f, 4.01572250e-02f, 7.43792802e-02f, 1.46499962e-01f, 1.14162490e-01f, -3.90622430e-02f, 6.84889965e-03f, -1.85449759e-03f,
  8.37302282e-02f, -5.05074896e-02f, 1.29319847e-01f, 1.68289855e-01f, 2.05519050e-01f, 2.01985225e-01f, 1.28690273e-01f, 1.10597886e-01f, -4.09517325e-02f, 9.50954333e-02f,
  -3.05900592e-02f, -1.32365927e-01f, -1.12603277e-01f, 4.76158485e-02f, -2.08020844e-02f, -1.16832405e-02f, 4.88378070e-02f, 7.89788216e-02f, 1.07469529e-01f, 1.33127540e-01f,
  -5.20139188e-03f, 2.54644211e-02f, -3.40806432e-02f, -2.85777338e-02f, 9.84103233e-03f, 8.79633948e-02f, 3.72818895e-02f, 3.45625505e-02f, -1.43064500e-03f, -3.67819369e-02f,
  -8.28941092e-02f, 8.82496908e-02f, -4.85423245e-02f, -1.07619524e-01f, -3.16556804e-02f, -5.10123782e-02f, 7.09697232e-02f, -1.29406393e-01f, 6.87519982e-02f, 8.45221728e-02f,
  1.18990429e-02f, 5.21831326e-02f, -1.62901450e-02f, -4.71616797e-02f, -4.52170186e-02f, 2.47896761e-02f, -1.01761088e-01f, 2.37720478e-02f, -4.82457988e-02f, -4.92926575e-02f,
  -7.46358931e-02f, 4.58886661e-02f, -8.58127233e-03f, 7.49785155e-02f, -1.05433956e-01f, 2.51931269e-02f, -9.84510481e-02f, 3.05098109e-02f, -8.20330158e-02f, 3.11848707e-02f,
  -1.70788374e-02f, -5.26235364e-02f, -9.04582720e-03f, -4.32464927e-02f, 2.93486926e-04f, 6.42619953e-02f, 6.62330240e-02f, 2.26433761e-02f, -1.02723800e-02f, -8.23772028e-02f,
  -4.72515747e-02f, 6.71719983e-02f, -4.99238707e-02f, -6.48929626e-02f, 2.43836995e-02f, -5.86080598e-03f, -8.41819122e-02f, 1.69909894e-02f, 2.49610678e-03f, -5.23241460e-02f,
  -5.10617048e-02f, 1.01592660e-01f, 3.18269171e-02f, -8.85394812e-02f, -9.07013752e-03f, -1.23945577e-02f, -7.22832233e-02f, 7.13960081e-02f, -7.44838566e-02f, 2.32554674e-02f,
  -2.27899980e-02f, 8.33790824e-02f, -4.77265120e-02f, -2.87366435e-02f, -7.05750138e-02f, -4.52646799e-03f, -1.08120695e-01f, -3.12040243e-02f, 1.09302670e-01f, 9.62748602e-02f,
  1.72624383e-02f, 7.61159026e-05f, -7.78908953e-02f, -4.31073494e-02f, -2.64043305e-02f, -4.64171767e-02f, 4.01723608e-02f, -2.42784303e-02f, -1.45010715e-02f, 5.58360443e-02f,
  -6.48818687e-02f, 9.48387012e-02f, 1.22837111e-01f, 7.17850775e-02f, -8.75064582e-02f, 6.35060892e-02f, 2.38323919e-02f, -2.20381562e-02f, 1.46504894e-01f, -1.79882720e-02f,
  -4.34694104e-02f, 2.57673651e-01f, 1.18478075e-01f, 4.31058370e-02f, 1.24306880e-01f, 2.05394477e-01f, 2.35988557e-01f, 9.91075039e-02f, -1.08593166e-01f, 1.30605519e-01f,
  1.73827291e-01f, -3.03903390e-02f, -7.41667747e-02f, -5.84497228e-02f, -2.71369312e-02f, -7.54574835e-02f, 5.41665107e-02f, -1.23002969e-01f, -1.42789721e-01f, -1.68057173e-01f,
  -7.40896836e-02f, 1.11434991e-02f, -6.08871020e-02f, -7.47180879e-02f, -2.44754422e-02f, -1.48584262e-01f, -9.31112394e-02f, 4.15372774e-02f, 2.56002061e-02f, -1.28134117e-01f,
  -2.59959307e-02f, 1.82791367e-01f, -4.83128950e-02f, -8.22242349e-02f, 5.65478876e-02f, -9.05530341e-03f, 2.56390925e-02f, 1.81924626e-02f, 7.68347755e-02f, 5.26961312e-02f,
  2.83678174e-02f, 1.09646097e-01f, 4.10792492e-02f, -4.35675122e-02f, -1.07894912e-02f, -3.08677461e-03f, -5.30671095e-03f, -7.57613927e-02f, -1.35064512e-01f, 3.92639115e-02f,
  -7.34380111e-02f, 6.21622568e-03f, -4.34989929e-02f, 3.48693430e-02f, -3.34239751e-02f, -6.24663979e-02f, -1.71975084e-02f, -1.88712496e-02f, -5.08758202e-02f, -1.52027249e-01f,
  -6.63397834e-02f, -3.34811732e-02f, 9.70273763e-02f, -1.92671418e-02f, -1.21543203e-02f, 7.88806900e-02f, 2.91165952e-02f, -3.62791903e-02f, 4.37485278e-02f, 3.64760794e-02f,
  -3.85665409e-02f, -6.05123676e-02f, 8.83528516e-02f, 4.69557904e-02f, -2.76386086e-02f, -1.13055883e-02f, -7.87221268e-02f, 3.43638249e-02f, 2.32775491e-02f, 4.79906909e-02f,
  4.83180657e-02f, -4.26947065e-02f, -1.19827976e-02f, -7.95636848e-02f, 1.35018788e-02f, -6.63955808e-02f, 1.42335715e-02f, -7.09688291e-02f, 9.75456014e-02f, 5.67485243e-02f,
  -9.63576734e-02f, 9.60960984e-02f, -7.66038522e-02f, -2.42210329e-02f, -1.88702047e-02f, 4.51923683e-02f, -3.00727449e-02f, 1.03254532e-02f, 5.83398603e-02f, -7.69672617e-02f,
  1.33884028e-01f, -1.60763636e-02f, 4.27110381e-02f, -4.37304489e-02f, -9.75923613e-02f, -6.58554435e-02f, 1.28943836e-02f, -6.51677772e-02f, -2.64695510e-02f, -3.35738203e-03f,
  -4.33716038e-03f, -1.67302657e-02f, -5.56810647e-02f, -1.20679587e-01f, -6.74255844e-03f, -1.58152178e-01f, -3.47851515e-02f, -1.55127257e-01f, -1.41406402e-01f, -1.73412487e-01f,
  -1.58804104e-01f, 1.09463014e-01f, -1.76128168e-02f, 1.29370436e-01f, -6.35793433e-02f, -1.08277671e-01f, -1.86461091e-01f, -1.19029574e-01f, 4.77116145e-02f, 5.50595596e-02f,
  6.26340583e-02f, 9.66508016e-02f, 2.35607289e-02f, -2.64992807e-02f, -7.29253292e-02f, -6.90399855e-02f, 4.23606075e-02f, 4.36146520e-02f, -1.21027030e-01f, -1.46982493e-02f,
  2.24813223e-02f, 2.62500569e-02f, 1.39076207e-02f, -4.80231158e-02f, 1.24348000e-01f, -3.39920744e-02f, 9.57451388e-03f, -1.38252443e-02f, 1.07124727e-02f, 1.67595789e-01f,
  1.00350969e-01f, -2.28402819e-02f, -4.60615978e-02f, -5.61941825e-02f, 6.68659881e-02f, -1.94614697e-02f, 4.58850823e-02f, 4.47084494e-02f, 2.24431697e-02f, 7.60719925e-02f,
  1.01181217e-01f, -1.02136927e-02f, -2.55883653e-02f, 3.51538658e-02f, -8.41263980e-02f, -5.80944605e-02f, -1.08222492e-01f, -4.75776643e-02f, -1.11328520e-01f, -1.61571428e-03f,
  -2.01121643e-02f, -2.84251533e-02f, -3.51875797e-02f, -9.68699008e-02f, -3.66163775e-02f, 5.28444648e-02f, -9.58282277e-02f, -2.61101723e-02f, -7.13774860e-02f, 8.81678686e-02f,
  -9.52575542e-03f, -4.00873348e-02f, 4.63075489e-02f, -5.01057915e-02f, 7.85173699e-02f, -2.75142421e-03f, -2.80885603e-02f, 5.90668730e-02f, -4.43508811e-02f, 1.38014490e-02f,
  -6.58786716e-03f, -7.72373080e-02f, -1.86978988e-02f, 2.93526258e-02f, 2.01432109e-02f, 3.18184830e-02f, 7.26139545e-02f, -9.54430327e-02f, -3.30833457e-02f, -2.04362744e-03f,
  -3.81174237e-02f, -8.68964195e-02f, 4.52019535e-02f, 4.04297449e-02f, 5.84736392e-02f, -2.55960450e-02f, -2.37853173e-02f, 4.76397164e-02f, -4.88168485e-02f, 9.12294835e-02f,
  -7.34213814e-02f, -7.75010660e-02f, 3.21854949e-02f, -6.70954511e-02f, -5.91279753e-03f, -7.12776463e-03f, -4.32241000e-02f, 7.56944716e-02f, 5.02373129e-02f, -8.85821208e-02f,
  -5.47911227e-02f, -1.02220207e-01f, 8.49412009e-02f, -1.05589084e-01f, -1.45256445e-02f, -1.13695398e-01f, -1.24858595e-01f, 8.74670397e-04f, -9.74597409e-02f, 3.83621156e-02f,
  3.63327153e-02f, -1.09262072e-01f, -8.92852247e-02f, -1.32906884e-01f, 1.51119323e-03f, -7.90106282e-02f, -5.48885502e-02f, -6.09370274e-03f, -7.11167455e-02f, -1.47251189e-01f,
  1.15034960e-01f, -7.80025274e-02f, -1.21846169e-01f, -8.59590154e-03f, -1.14031509e-01f, -1.34015009e-01f, -1.63172737e-01f, -1.31258024e-02f, 7.94856548e-02f, -2.94026714e-02f,
  -8.04974809e-02f, 2.74458677e-02f, 1.57799065e-01f, 1.47891253e-01f, 1.27857506e-01f, -7.31971860e-02f, 2.86565665e-02f, 9.05602723e-02f, 1.25255927e-01f, 2.49461513e-02f,
  -9.85922143e-02f, -2.16810387e-02f, 9.00049955e-02f, -4.73356945e-03f, -1.64778441e-01f, -4.72215973e-02f, -1.33102937e-02f, -9.82538164e-02f, -1.00281529e-01f, -1.25795305e-01f,
  -2.47726977e-01f, -4.10010777e-02f, 1.05908327e-01f, 1.11901328e-01f, 2.29562316e-02f, 8.77091736e-02f, 1.05506275e-03f, -1.99506786e-02f, 1.07752252e-02f, -6.64220080e-02f,
  -5.28624281e-02f, 3.74540053e-02f, -4.76335734e-02f, -6.01276159e-02f, 7.60370772e-03f, -1.13339890e-02f, 6.62531108e-02f, 1.12209767e-01f, 4.84895147e-02f, -6.09185360e-02f,
  -1.04506090e-01f, 6.24349676e-02f, -5.81640303e-02f, 3.98344323e-02f, 7.38536045e-02f, 9.98055935e-02f, 2.58512702e-02f, -6.52286410e-02f, 7.95332342e-03f, 4.60355505e-02f,
  3.86060067e-02f, 4.60699089e-02f, 1.24623999e-02f, 2.28706934e-02f, 9.52838268e-03f, -7.75009813e-03f, -7.12089539e-02f, -9.11006406e-02f, -1.56274978e-02f, 5.50610758e-02f,
  3.01279896e-03f, 4.83752377e-02f, -1.39270574e-02f, 3.31502743e-02f, 1.39456950e-02f, -5.84928915e-02f, -9.35340449e-02f, 1.92263897e-03f, 2.54351739e-02f, 2.73733865e-02f,
  -5.35032339e-02f, 2.85610873e-02f, 2.13757511e-02f, 9.29877162e-03f, -2.40927413e-02f, 4.47663590e-02f, 8.18192959e-03f, -5.08684367e-02f, 2.53352318e-02f, -7.56928772e-02f,
  -6.16659485e-02f, 2.77880609e-01f, -1.74709894e-02f, -3.84999514e-02f, 4.39985730e-02f, 3.55843268e-02f, -5.00556901e-02f, 2.43647420e-03f, -6.83797374e-02f, -9.04868618e-02f,
  -6.12170920e-02f, 3.62704061e-02f, -1.05368614e-01f, -8.54371414e-02f, -8.56935699e-03f, 1.32686934e-02f, 5.19545227e-02f, 5.18113039e-02f, 2.14276072e-02f, -1.03685044e-01f,
  4.84020710e-02f, 1.38536617e-02f, 1.11252747e-01f, -1.05185658e-02f, -4.72778194e-02f, 1.24921933e-01f, 5.17661870e-02f, -7.25667402e-02f, 1.44670576e-01f, 5.01370952e-02f,
  2.00070620e-01f, -3.09669584e-01f, 1.05443537e-01f, 3.53127494e-02f, 6.91386983e-02f, 1.55140147e-01f, -2.87837293e-02f, -7.27108270e-02f, -4.87910695e-02f, -6.88086031e-03f,
  -2.18344808e-01f, -2.30500028e-01f, -1.97095722e-01f, -6.44167438e-02f, -1.54952621e-02f, 4.95312847e-02f, 8.21249858e-02f, 2.23716974e-01f, 1.52607054e-01f, 2.27524303e-02f,
  1.80312921e-03f, 6.91717789e-02f, 1.27659068e-01f, -3.11414953e-02f, 4.20396999e-02f, -6.77487701e-02f, -1.14386790e-02f, -1.71959959e-02f, -5.60698435e-02f, 7.28496164e-02f,
  1.62086841e-02f, 4.94207740e-02f, 1.20582178e-01f, 8.70834047e-05f, 8.66714958e-03f, -7.37847015e-02f, -1.05533637e-02f, -5.42532187e-03f, -1.10339284e-01f, 5.83903864e-02f,
  2.30806116e-02f, -2.40243357e-02f, -4.93114591e-02f, -4.08500154e-03f, 9.11940858e-02f, 3.27876657e-02f, 5.91179589e-03f, -8.80292207e-02f, -8.56752098e-02f, -3.29248048e-02f,
  -1.57678008e-01f, 1.58856697e-02f, 8.95987079e-02f, -1.44175990e-02f, -4.80648763e-02f, -3.24663222e-02f, 3.29205953e-02f, 1.04314778e-02f, -6.99118674e-02f, -7.95610473e-02f,
  -3.42988148e-02f, 6.64570406e-02f, -2.24831384e-02f, -2.17687301e-02f, 1.87705792e-02f, 5.70676625e-02f, 9.94388387e-02f, 1.32530546e-02f, 4.97864075e-02f, 2.53401306e-02f,
  -7.01065958e-02f, 4.34997566e-02f, 3.18829454e-02f, 6.41449839e-02f, -4.83237579e-02f, 1.33585306e-02f, -9.41412244e-03f, -4.21073698e-02f, -1.21040046e-01f, 3.68620381e-02f,
  -6.37153238e-02f, -1.64979519e-05f, 7.45623037e-02f, -2.03746427e-02f, -6.16338477e-02f, 5.65101542e-02f, 8.57919753e-02f, -1.12404160e-01f, 1.33453300e-02f, 5.85217513e-02f,
  -1.49109252e-02f, -5.53913694e-03f, 8.41928832e-03f, -1.00665810e-02f, 9.08604190e-02f, -6.79497868e-02f, -1.20013538e-04f, 3.71923447e-02f, 4.97109629e-02f, 5.46758715e-03f,
  -9.53787640e-02f, 3.35757546e-02f, -4.23697159e-02f, 3.55469398e-02f, 7.73535445e-02f, 7.49201979e-03f, 8.85931496e-03f, -2.06112247e-02f, 3.55716832e-02f, -6.53221458e-02f,
  2.18430012e-02f, 7.60207400e-02f, 1.84533283e-01f, -2.40184497e-02f, -2.52394546e-02f, 1.90154091e-01f, 1.19487509e-01f, 8.14342275e-02f, 1.76272020e-01f, 1.27131328e-01f,
  2.17611462e-01f, -6.38486370e-02f, -3.34323272e-02f, 6.42748326e-02f, -7.01570930e-03f, -1.07850932e-01f, -1.73802063e-01f, 4.13608411e-03f, 3.54866050e-02f, -1.28762186e-01f,
  5.05430251e-02f, 1.26667097e-02f, 9.05287787e-02f, 5.95935844e-02f, 9.22953635e-02f, -2.37845220e-02f, -7.83067867e-02f, 6.34737015e-02f, 7.89038986e-02f, -1.02129132e-01f,
  -3.46042924e-02f, 2.22196411e-02f, 4.88848053e-03f, -9.31997411e-03f, -1.26127079e-01f, -1.00417420e-01f, -4.39156704e-02f, -1.17194459e-01f, 3.84754268e-03f, -1.19258113e-01f,
  5.77665754e-02f, 7.86366835e-02f, 6.06650836e-04f, -5.08756340e-02f, 1.13715259e-02f, 1.07895203e-01f, 3.03875599e-02f, -8.89603049e-02f, 4.11833404e-03f, 3.14984955e-02f,
  -2.71724034e-02f, 4.77658063e-02f, 2.73014288e-02f, 5.83892874e-02f, -1.20941505e-01f, 1.10143861e-02f, -1.13714091e-01f, -6.90558031e-02f, -7.13459700e-02f, -7.77813867e-02f,
  -2.61866096e-02f, 3.70174274e-02f, 8.91908631e-02f, -9.61737484e-02f, 3.70783135e-02f, 1.15890101e-01f, 3.40445042e-02f, -3.25931422e-02f, 7.47805182e-03f, -9.19110924e-02f,
  -8.12433809e-02f, 8.12819749e-02f, 5.21129332e-02f, -3.46226171e-02f, -2.43401024e-02f, 5.33610359e-02f, 8.45689978e-03f, -7.91231096e-02f, -7.23776966e-02f, -7.47049153e-02f,
  1.93956476e-02f, -7.07433298e-02f, -5.21293655e-02f, -4.47677411e-02f, 2.29842998e-02f, 2.53755087e-03f, 7.03712925e-02f, -5.58012314e-02f, -7.26072490e-02f, 3.58302183e-02f,
  5.04444949e-02f, 4.13477421e-02f, -1.43108796e-03f, -3.15894671e-02f, -8.81085731e-03f, 3.52569707e-02f, -8.68381001e-03f, -4.67861742e-02f, 8.92922096e-03f, -4.42077927e-02f,
  4.14035581e-02f, 1.56742528e-01f, 1.53159022e-01f, 1.41822353e-01f, 3.07272002e-02f, -3.64184082e-02f, 8.07831436e-02f, 2.69737821e-02f, 3.78844216e-02f, 1.96998883e-02f,
  -6.21437952e-02f, 1.65305883e-02f, 2.05888003e-02f, -4.56232354e-02f, 3.67956124e-02f, 8.25532302e-02f, -5.21060377e-02f, 2.42144093e-02f, -9.79364216e-02f, 5.32585308e-02f,
  -1.45293161e-01f, 6.26746789e-02f, 1.62530184e-01f, 1.22369595e-01f, 1.21939957e-01f, 1.96358562e-01f, -5.92219597e-03f, 2.20622979e-02f, 1.27669945e-01f, 8.17233101e-02f,
  -3.24256241e-01f, -4.22609858e-02f, 8.72171894e-02f, 7.19526410e-02f, -1.04183629e-01f, -1.57459378e-01f, -4.46238331e-02f, 3.26317782e-03f, -2.66772751e-02f, -7.51256496e-02f,
  -7.80131444e-02f, 2.27498766e-02f, 5.04302792e-02f, 6.50407374e-02f, 8.75108317e-02f, 1.86301857e-01f, 2.49812603e-01f, 2.03716502e-01f, -3.92812267e-02f, -9.84594598e-03f,
  9.62881744e-02f, 6.33727610e-02f, -1.14058897e-01f, 8.35993439e-02f, 1.44845694e-01f, 5.85226063e-03f, 1.09608479e-01f, -1.04384581e-02f, 8.70139673e-02f, 2.03196257e-01f,
  -1.37773737e-01f, -2.33939141e-01f, -2.02005822e-02f, -4.64912355e-02f, -2.23723315e-02f, 8.39351267e-02f, -4.09095064e-02f, 4.70948145e-02f, -1.30066378e-02f, 8.11676867e-03f,
  6.82475220e-04f, -3.55947241e-02f, 5.72284823e-03f, -1.52012622e-02f, -6.57840744e-02f, -4.50527333e-02f, -1.51075376e-02f, 8.96154568e-02f, 8.68547559e-02f, -3.49550992e-02f,
  1.36626912e-02f, -1.14404529e-01f, -8.29520896e-02f, -5.74872568e-02f, -2.98502166e-02f, -7.14865476e-02f, -1.28963917e-01f, -1.29057821e-02f, -7.23303631e-02f, -1.15292661e-01f,
  -1.14473281e-02f, -4.78994846e-03f, 4.94105257e-02f, 4.26175110e-02f, 6.74639121e-02f, 4.26851911e-03f, 2.31289733e-02f, 4.79289815e-02f, -6.79750601e-03f, 1.86160505e-02f,
  6.14131652e-02f, 1.21762315e-02f, -1.96290128e-02f, -1.07018352e-01f, 4.21452038e-02f, -1.33675802e-02f, 7.51744583e-03f, 8.93668607e-02f, -4.81824912e-02f, 3.87499519e-02f,
  1.56941190e-02f, 7.60576203e-02f, -9.89699885e-02f, 7.94295743e-02f, 3.01044546e-02f, 1.40092075e-02f, -6.09493218e-02f, -4.28977609e-02f, -3.56700160e-02f, -1.23044802e-02f,
  -2.17554435e-01f, 4.31602728e-03f, 8.37064162e-03f, -3.46920565e-02f, 3.77594456e-02f, -4.45953496e-02f, -6.25047386e-02f, -5.94067201e-02f, 1.81997325e-02f, 3.52528244e-02f,
  -1.10624656e-01f, 8.49043392e-03f, -7.27501661e-02f, -3.27875614e-02f, -8.00509751e-02f, -7.31962919e-02f, -1.42259067e-02f, -2.57455204e-02f, -6.45447820e-02f, -6.38859943e-02f,
  1.85388662e-02f, -5.49899749e-02f, -1.56108454e-01f, -5.04840054e-02f, -7.51536489e-02f, -9.49999318e-02f, -8.30213279e-02f, -1.94788173e-01f, -1.41609445e-01f, -2.46071324e-01f,
  1.09569751e-01f, -2.21117333e-01f, -3.12688977e-01f, 1.63022224e-02f, -1.42494485e-01f, -4.66670394e-02f, -2.30271682e-01f, 2.51163375e-02f, 5.25915734e-02f, -1.60589442e-01f,
  -6.93070292e-02f, 8.60875845e-02f, 1.05485842e-01f, 1.67800877e-02f, -8.12932327e-02f, -1.32559046e-01f, -2.66315788e-01f, -7.38537870e-03f, 2.33161962e-03f, -4.38377075e-02f,
  -7.22068772e-02f, -2.04029586e-03f, 1.02227509e-01f, 1.70059614e-02f, -9.59354788e-02f, 9.91321448e-03f, -1.37766019e-01f, -3.58728156e-03f, -1.21953480e-01f, -2.37724200e-01f,
  -1.84474424e-01f, 4.49995399e-02f, 2.74779499e-02f, 1.04965232e-01f, 3.87457758e-02f, 7.14414865e-02f, -7.37547427e-02f, 4.42397147e-02f, 1.02043733e-01f, 6.76092282e-02f,
  4.79944460e-02f, -7.20991811e-04f, 2.52484884e-02f, -1.12009896e-02f, -1.67592578e-02f, 2.01365594e-02f, -2.91860513e-02f, 5.50636686e-02f, -1.66430492e-02f, 7.64040351e-02f,
  -6.18155859e-02f, 1.06727175e-01f, 1.01794332e-01f, 5.98370433e-02f, 2.90996656e-02f, 1.13921247e-01f, -4.17783447e-02f, 1.50588915e-01f, 2.19537299e-02f, 2.08901782e-02f,
  -1.93823334e-02f, 2.07795519e-02f, -1.39815686e-02f, 5.71389077e-03f, 3.56160756e-03f, 2.80167311e-02f, -8.25355127e-02f, 4.68532033e-02f, 6.02448508e-02f, -3.07751889e-03f,
  -8.48896429e-02f, 5.12972008e-03f, 1.42900394e-02f, 1.40987821e-02f, -6.55820146e-02f, -6.96149170e-02f, -2.34527942e-02f, 1.24561628e-02f, 1.42626429e-03f, 3.77685539e-02f,
  4.67830636e-02f, -1.40298409e-02f, 5.02924658e-02f, 2.87750959e-02f, 3.54425311e-02f, -7.24418759e-02f, 2.85491459e-02f, 2.35261060e-02f, 7.09988177e-02f, -5.63222356e-02f,
  -1.12390472e-02f, 3.33486609e-02f, -8.90599713e-02f, 2.23775525e-02f, 5.94621301e-02f, -2.65974924e-02f, -5.66809922e-02f, 1.29501000e-02f, 8.76035094e-02f, -5.54746613e-02f,
  3.07043511e-02f, 2.28976198e-02f, -5.80290668e-02f, -5.00225881e-03f, -1.59098636e-02f, 3.27129625e-02f, -1.53757697e-02f, 9.22772884e-02f, 1.05297610e-01f, 7.25127608e-02f,
  8.78651068e-02f, 5.49843982e-02f, -5.68964751e-03f, -2.36849003e-02f, 9.04992372e-02f, -1.88950039e-02f, 3.93366292e-02f, 6.29867315e-02f, 8.01351480e-03f, -1.45248815e-01f,
  -1.50892109e-01f, -1.39280781e-01f, -5.42264781e-04f, 1.83079094e-02f, 6.90312311e-02f, -1.81127805e-02f, -1.20390214e-01f, 2.69864053e-02f, -3.72285247e-02f, 5.19493669e-02f,
  1.19840726e-01f, 1.10591806e-01f, -3.40538993e-02f, -4.94337007e-02f, -8.66163820e-02f, -3.26192863e-02f, 1.85519848e-02f, -2.47346275e-02f, 4.72290963e-02f, 3.67860422e-02f,
  -6.09646253e-02f, 1.21863792e-02f, -7.45016560e-02f, -3.82332429e-02f, 3.25362906e-02f, -9.88904834e-02f, -1.14686944e-01f, -3.77189517e-02f, -1.61122307e-02f, -5.90814315e-02f,
  -2.88066408e-03f, -5.30361384e-02f, 1.17405042e-01f, -4.16702665e-02f, -6.26746891e-03f, 5.66587113e-02f, -4.25534025e-02f, -6.18846789e-02f, 7.00247288e-02f, -8.60141218e-02f,
  -2.80797351e-02f, -2.06298511e-02f, 3.16962376e-02f, 7.45170424e-03f, -6.19798638e-02f, 4.29347046e-02f, 4.99008968e-02f, -6.85100630e-02f, -9.82591584e-02f, -5.03575839e-02f,
  -3.95408534e-02f, 1.28964484e-02f, -4.64956649e-02f, -8.83301049e-02f, -8.81347060e-02f, -2.35267971e-02f, -7.97477886e-02f, -1.51235089e-01f, -1.08559698e-01f, -2.26002395e-01f,
  3.73215377e-02f, -2.23027472e-03f, -1.55701358e-02f, -2.89266799e-02f, 1.52248209e-02f, 2.62526819e-03f, 3.54852229e-02f, 8.05254802e-02f, -6.07718080e-02f, 5.03883772e-02f,
  1.09557733e-02f, -4.99034077e-02f, 8.28186050e-02f, -1.11170746e-01f, -8.53301808e-02f, 4.02834360e-03f, -2.77716108e-02f, -8.58879015e-02f, -2.75870459e-03f, 3.42173874e-02f,
  -3.21843810e-02f, -5.38851172e-02f, 3.31546552e-02f, -6.97700530e-02f, 7.45725110e-02f, 2.85125673e-02f, 3.71091627e-02f, 7.27254748e-02f, -3.10009271e-02f, 2.76637133e-02f,
  -3.84934060e-02f, 1.36925921e-01f, -1.23811178e-01f, -5.17440103e-02f, 2.64200475e-02f, -1.14361821e-02f, -7.69014508e-02f, -4.47644331e-02f, 6.07728064e-02f, 1.12505711e-03f,
  9.98806357e-02f, -6.05579205e-02f, 5.59376478e-02f, -3.73062566e-02f, -5.75936809e-02f, -9.24889967e-02f, -1.10557698e-01f, -7.20852613e-03f, -6.37631118e-02f, 4.77398448e-02f,
  5.88789210e-03f, -4.83790264e-02f, -1.85004160e-01f, -2.57857442e-02f, -3.16978917e-02f, -7.85323828e-02f, -1.56825542e-01f, -9.98896435e-02f, -1.92741513e-01f, -1.65753976e-01f,
  3.39723200e-01f, -3.21456306e-02f, -4.13609780e-02f, 1.34502858e-01f, -1.57643616e-01f, -2.04311818e-01f, -2.60690421e-01f, -1.21315420e-01f, 1.41795933e-01f, 7.06424424e-03f,
  1.20188951e-01f, 2.57956952e-01f, 1.17058165e-01f, 1.65752172e-01f, 3.70204225e-02f, 7.04970434e-02f, 2.71778600e-03f, 1.66040927e-01f, 9.77385119e-02f, -2.11793231e-03f,
  -6.73444150e-03f, -4.84553315e-02f, -1.58454012e-02f, 5.38881421e-02f, -1.94967701e-03f, 2.51085684e-02f, 2.44461652e-02f, 4.06129621e-02f, -5.41844172e-03f, 9.45209712e-02f,
  9.65950340e-02f, 1.10982366e-01f, 4.94748680e-03f, 6.29054382e-02f, -8.02018717e-02f, 4.50249985e-02f, 8.70333761e-02f, 1.14325369e-02f, -3.09208110e-02f, -7.38083869e-02f,
  -2.68418044e-02f, 4.21457402e-02f, 1.17368940e-02f, -1.52909476e-02f, -4.83130887e-02f, -4.00819369e-02f, -5.51878475e-02f, 3.03516481e-02f, 6.24943301e-02f, 8.93549994e-02f,
  -6.10538088e-02f, 3.80517170e-03f, -3.65643464e-02f, -4.96162511e-02f, -3.53191160e-02f, 5.09970039e-02f, 1.44419083e-02f, -2.03492697e-02f, 3.45874019e-02f, 1.09248661e-01f,
  8.62998664e-02f, 8.70175138e-02f, 6.34082556e-02f, 8.55278671e-02f, -1.48149570e-02f, -7.79946661e-03f, -3.42786312e-02f, -6.43142387e-02f, 4.08030562e-02f, -7.00459778e-02f,
  6.70587178e-03f, 7.12960437e-02f, 1.01775294e-02f, -4.02937233e-02f, 5.00721857e-02f, 1.80554911e-02f, 5.96136600e-02f, 8.22635293e-02f, -2.92672738e-02f, 5.69294505e-02f,
  -3.00425105e-02f, -5.65962046e-02f, -6.32065758e-02f, -4.47810926e-02f, -5.61477244e-02f, 9.86484140e-02f, -5.23997471e-04f, -1.13714451e-03f, 1.14953257e-02f, -2.50300299e-02f,
  -3.20248231e-02f, -2.27990858e-02f, 6.45973086e-02f, 3.99580076e-02f, -4.81616370e-02f, 8.31588283e-02f, 4.39229161e-02f, -6.42489940e-02f, -9.49205607e-02f, -7.00236559e-02f,
  6.20863512e-02f, 6.55670315e-02f, -4.56882268e-02f, -3.75899598e-02f, 3.47276516e-02f, 4.54731137e-02f, 6.92198500e-02f, -2.17400845e-02f, -4.63305041e-02f, -8.59976411e-02f,
  -7.92559702e-03f, 6.73717912e-03f, -3.63487750e-03f, 1.19311698e-02f, 2.05187942e-03f, 7.52358288e-02f, -9.11302790e-02f, 5.19216694e-02f, 2.46950444e-02f, -4.88436893e-02f,
  -1.13029435e-01f, 3.56840864e-02f, -5.48136327e-03f, 9.30491909e-02f, 2.33961076e-01f, 1.29016235e-01f, 1.94913149e-01f, 2.04030201e-01f, 1.99375540e-01f, 4.57692444e-02f,
  1.00374609e-01f, 1.20564252e-01f, 2.71888852e-01f, 1.54259875e-01f, 1.48838729e-01f, 1.36939913e-01f, 1.64925754e-01f, 1.99066270e-02f, 1.36426166e-01f, 8.55425149e-02f,
  8.35780874e-02f, -2.02174988e-02f, -1.00844219e-01f, -2.94831581e-02f, 1.71591565e-02f, 3.49005833e-02f, 7.33770356e-02f, 3.90295871e-02f, 4.43842262e-02f, 3.13119516e-02f,
  -1.57146193e-02f, -1.99897647e-01f, 2.89597623e-02f, -7.81496316e-02f, -3.54994945e-02f, -1.11078411e-01f, 5.70279174e-02f, -1.78181410e-01f, 2.83253528e-02f, 7.69435894e-03f,
  3.76736559e-02f, -7.61088589e-03f, 5.34124933e-02f, -6.56306297e-02f, -2.38572638e-02f, -6.33645728e-02f, -1.26144245e-01f, -2.88897101e-03f, 1.99348647e-02f, -1.29416417e-02f,
  1.82990190e-02f, -4.40207422e-02f, -6.97724372e-02f, 3.46921124e-02f, 1.68766989e-03f, 2.81736962e-02f, -3.21042463e-02f, -2.33185440e-02f, 2.29735766e-02f, -4.13193181e-02f,
  -2.21699439e-02f, 3.31925489e-02f, -6.95157722e-02f, 4.04188968e-02f, 1.13230059e-03f, 5.09006009e-02f, 6.52586967e-02f, 5.19700237e-02f, 5.52374013e-02f, -3.10021155e-02f,
  9.55082402e-02f, 1.26587246e-02f, 1.17025273e-02f, 1.14985839e-01f, -6.93033412e-02f, -2.27144081e-02f, -4.25189547e-02f, -3.35460156e-02f, -5.84914051e-02f, 3.26818042e-02f,
  -5.25375158e-02f, -3.74308787e-02f, -7.13149011e-02f, -6.64452910e-02f, -9.26821157e-02f, 8.37422386e-02f, 3.06212832e-03f, -4.57833745e-02f, 9.33041144e-03f, -2.62529701e-02f,
  2.56914198e-02f, 6.98462725e-02f, 9.69060287e-02f, 1.26058163e-04f, -5.63129485e-02f, -4.58514951e-02f, 9.57734361e-02f, -1.90006271e-02f, 6.20941166e-03f, 1.97305251e-02f,
  -7.98025206e-02f, 1.17420498e-02f, 2.73264889e-02f, -7.93069005e-02f, 1.94356050e-02f, -7.02859238e-02f, -4.37393896e-02f, -1.53130824e-02f, 5.77100255e-02f, -1.52255790e-02f,
  1.07939973e-01f, 4.71901596e-02f, 9.01443362e-02f, 8.85885730e-02f, 1.08222170e-02f, -3.34173697e-03f, 2.53544040e-02f, -8.14424753e-02f, 2.14624014e-02f, -8.94100890e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  9.10786316e-02f, 5.93175553e-02f, 1.22083440e-01f, 1.01336753e-02f, 7.89772570e-02f, 1.93052832e-02f, 1.54759303e-01f, 2.96420097e-01f, 3.53972167e-02f, 1.35065332e-01f,
  1.57991067e-01f, -6.43319711e-02f, 2.87155695e-02f, 2.92964987e-02f, 1.41189456e-01f, 1.35637075e-01f, 1.10041715e-01f, 1.24961825e-03f, 5.62004969e-02f, -9.47230309e-03f,
  1.52511224e-01f, 2.68435240e-01f, 1.27833346e-02f, 4.07280177e-02f, -5.01843281e-02f, 5.82779199e-02f, 2.99266964e-01f, 8.99797156e-02f, 2.62134224e-01f, 1.78333055e-02f,
  1.76119104e-01f, 8.32539722e-02f, 2.01504156e-01f, 9.78815109e-02f, 1.26033872e-01f, 1.17014892e-01f, 1.25261799e-01f, 1.54691055e-01f, 1.65078431e-01f, 1.58060670e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.28904814e-01f, -1.12566287e-02f, -1.05888173e-01f, 4.64546494e-02f, -6.55130148e-02f, 1.79307908e-01f, 5.35270683e-02f, -1.38264850e-01f, -4.70133908e-02f, -6.41134456e-02f,
  6.54065758e-02f, 3.69059126e-04f, -1.53436750e-01f, 5.64972237e-02f, -1.26542568e-01f, 1.24561302e-02f, -6.66220188e-02f, 1.14256360e-01f, -6.37421235e-02f, 9.45383683e-02f,
  -1.42041087e-01f, -2.28441983e-01f, 7.32422946e-03f, -4.40064631e-02f, 1.20648615e-01f, -1.32651553e-01f, -1.28579959e-02f, -4.08589616e-02f, 6.17947243e-02f, -1.11239351e-01f,
  -1.01181818e-02f, 1.55746236e-01f, 1.31200612e-01f, -5.94082363e-02f, -2.33819440e-01f, 2.65525877e-02f, -8.68149102e-02f, -2.47683711e-02f, 2.78765112e-02f, -4.36548814e-02f,
  -1.23627640e-01f, -6.66932538e-02f, 3.01078428e-02f, -9.19884294e-02f, -2.53673457e-02f, 8.74019265e-02f, 1.53015718e-01f, -9.23148319e-02f, 1.04873642e-01f, -9.39291567e-02f,
  -2.13049129e-02f, 7.24788308e-02f, 7.82136172e-02f, -5.26280701e-02f, -1.22355059e-01f, 8.27240795e-02f, -9.43061560e-02f, -6.78766295e-02f, -6.46956414e-02f, 4.41394933e-02f,
  4.37012687e-03f, -7.13120960e-03f, -2.63186637e-02f, 6.27703443e-02f, -3.88173945e-02f, 5.27049266e-02f, -7.47552514e-02f, 9.55484957e-02f, 1.68943766e-03f, 2.76200604e-02f,
  1.23895839e-01f, -1.64319649e-01f, -1.14751108e-01f, 8.74154940e-02f, 5.07274903e-02f, -2.02530652e-01f, -1.76504403e-01f, 2.25290179e-01f, -1.16088383e-01f, -4.47225980e-02f,
  -2.69637644e-01f, -1.10181212e-01f, -2.93119669e-01f, 3.68527544e-04f, -2.89169163e-01f, -2.94228107e-01f, -6.12353161e-02f, 2.68437743e-01f, 8.26094896e-02f, -8.91911983e-02f,
  -7.60924816e-02f, 5.08660451e-03f, -1.15935784e-02f, -9.45773050e-02f, -6.70842752e-02f, -1.98305130e-01f, -5.96259125e-02f, 1.78797022e-02f, 1.89677328e-02f, 2.05484238e-02f,
  1.03849769e-01f, -7.43150041e-02f, 3.38855758e-02f, 2.52368808e-01f, 1.18206991e-02f, -9.07911211e-02f, -8.48442502e-03f, -1.52981235e-02f, -1.09030288e-02f, -2.54240304e-01f,
  -4.82547283e-03f, -5.26004732e-02f, -7.75199160e-02f, -5.56964390e-02f, -8.09922740e-02f, 9.42098871e-02f, -1.99887335e-01f, 9.03397873e-02f, 1.56167626e-01f, -3.76057290e-02f,
  1.61905378e-01f, 1.40075564e-01f, -1.07116014e-01f, 2.18134239e-01f, -6.20410815e-02f, -5.31363375e-02f, -1.77992105e-01f, -1.66130960e-01f, -1.74830794e-01f, 1.71527222e-01f,
  1.64717242e-01f, -9.32804123e-02f, 3.21244150e-02f, -1.58115029e-01f, 2.88761314e-02f, 1.99991509e-01f, 9.87469479e-02f, -4.11066040e-02f, -8.57825279e-02f, 7.52208084e-02f,
  4.25946824e-02f, -5.24017960e-02f, -1.56092197e-01f, 4.64491285e-02f, 2.84473617e-02f, 1.63437054e-01f, 3.35712045e-01f, 4.33596075e-01f, 1.46877602e-01f, 9.80161056e-02f,
  5.90541922e-02f, 2.12345466e-01f, -2.21409965e-02f, -3.94042768e-02f, 1.70899153e-01f, 1.58191308e-01f, -1.68532327e-01f, 1.52645871e-01f, 1.67367905e-01f, 2.89458156e-01f,
  -4.96302620e-02f, 2.67169420e-02f, 1.49696738e-01f, -8.72185901e-02f, -1.50411511e-02f, 9.50450376e-02f, 1.50308972e-02f, -1.02378204e-01f, -8.81500244e-02f, 1.39833629e-01f,
  -1.71480253e-02f, -1.27902972e-02f, 1.09290434e-02f, 1.92691043e-01f, -1.22034453e-01f, 2.11293817e-01f, -1.03898175e-01f, -8.74872878e-02f, 2.29853421e-01f, -1.09766372e-01f,
  1.99890658e-01f, 8.83264001e-03f, 1.69076528e-02f, 2.50953063e-02f, -9.42544043e-02f, -2.68955439e-01f, 1.47710398e-01f, 6.33898079e-02f, 5.61677963e-02f, 1.71544313e-01f,
  1.84037182e-02f, 2.40087941e-01f, -1.84287667e-01f, 5.68004251e-02f, -1.08064622e-01f, -1.47338435e-01f, 1.49607509e-01f, -1.16742916e-01f, 1.11713566e-01f, -4.86172847e-02f,
  2.25359295e-02f, -2.26414248e-01f, -2.15311483e-01f, -8.25999454e-02f, 2.77883410e-01f, 1.14461295e-01f, -5.00890985e-02f, -2.02862248e-01f, -1.44229740e-01f, -4.19004783e-02f,
  1.28055230e-01f, -1.36073902e-01f, 5.32606654e-02f, -6.13945827e-04f, 2.72400677e-01f, -2.18592525e-01f, -1.42140538e-01f, -6.02999777e-02f, -4.36000042e-02f, -5.32771647e-02f,
  -5.35426438e-02f, -3.39847207e-02f, -7.19163120e-02f, -1.56307578e-01f, -1.66618824e-02f, 1.56928703e-01f, 1.55428395e-01f, 1.35492057e-01f, -1.34305403e-01f, -1.61460470e-02f,
  -1.77847706e-02f, 3.70680839e-02f, 1.30610287e-01f, 8.77856538e-02f, -8.40203315e-02f, 1.48158714e-01f, 1.63824990e-01f, -6.41667843e-02f, 1.60741135e-01f, 1.37577280e-01f,
  1.29048780e-01f, 1.38647363e-01f, 2.99360096e-01f, 1.01021947e-02f, -8.14733431e-02f, -1.49422795e-01f, 8.60706940e-02f, -4.75223176e-02f, 2.03309152e-02f, -1.94992885e-01f,
  -2.65177339e-02f, -1.83497882e-03f, 2.18543053e-01f, 1.78073756e-02f, 5.98816387e-02f, -7.79770911e-02f, 1.81184709e-02f, 3.31985876e-02f, -5.69326384e-03f, 7.77213424e-02f,
  -1.66881941e-02f, 1.01478890e-01f, 2.17528995e-02f, 1.20837204e-02f, 7.18633682e-02f, 5.88736013e-02f, 1.00445256e-01f, 7.70814642e-02f, 2.88266063e-01f, 9.60136503e-02f,
  4.63320076e-01f, -3.52518372e-02f, 4.80237864e-02f, -3.47923487e-01f, -1.54761404e-01f, -4.81115222e-01f, 2.84533590e-01f, 1.08762011e-02f, 6.37682006e-02f, -3.72143596e-01f,
  3.96780074e-02f, 1.86563045e-01f, -2.12095559e-01f, 2.76533235e-02f, 1.62896872e-01f, -2.74837557e-02f, -3.79794557e-03f, -1.26861557e-01f, -1.33132279e-01f, 1.22954465e-01f,
  -1.99855581e-01f, 1.01601116e-01f, -1.55296475e-01f, -1.04273759e-01f, 7.19822794e-02f, -1.12892576e-01f, 6.53938651e-02f, 4.69147898e-02f, -3.29794129e-03f, 1.21359281e-01f,
  2.81240176e-02f, -1.80171177e-01f, 6.28914088e-02f, -6.35451376e-02f, -2.81193927e-02f, 1.63912237e-01f, -7.33435005e-02f, 8.72701965e-03f, 7.87335336e-02f, -1.25566227e-02f,
  1.26125021e-02f, -3.32391113e-02f, -3.39585021e-02f, -2.82984804e-02f, 2.54556146e-02f, -1.57152489e-01f, -5.73509745e-02f, -1.26481935e-01f, 1.61724910e-01f, -2.31004402e-01f,
  -1.02170315e-02f, 1.64083511e-01f, -1.21025771e-01f, 5.09486906e-02f, 1.50741148e-03f, -3.32715586e-02f, -9.83665977e-03f, 1.21948689e-01f, -2.80092694e-02f, -5.75025566e-02f,
  8.77180845e-02f, 4.20798324e-02f, 2.31007546e-01f, 2.10152611e-01f, -6.61501065e-02f, -1.99684083e-01f, -8.81604776e-02f, -1.63416669e-01f, -2.78804395e-02f, 2.75199950e-01f,
  -1.25701740e-01f, 8.87469500e-02f, 8.14673975e-02f, 3.33200455e-01f, -3.46124321e-02f, 2.65487079e-02f, 1.86345115e-01f, -1.05585307e-01f, -1.47380799e-01f, 2.54506506e-02f,
  1.96936056e-01f, 9.13166106e-02f, 4.78054434e-02f, 1.42841607e-01f, 1.69635475e-01f, 3.67189385e-02f, 7.64137208e-02f, -1.08488714e-02f, -1.00699537e-01f, 1.23878300e-01f,
  -4.70415764e-02f, 1.42260998e-01f, 1.48613364e-01f, -5.65710142e-02f, -6.29688799e-02f, -1.63477391e-01f, -1.10449336e-01f, 9.19565260e-02f, -8.98739249e-02f, -3.11616324e-02f,
  -1.11299142e-01f, -1.62414432e-01f, -6.16204403e-02f, -1.07257828e-01f, 2.01316640e-01f, 9.27099884e-02f, -3.81757170e-02f, -4.33314927e-02f, -1.41612664e-01f, 1.91951901e-01f,
  1.27430722e-01f, 2.03116730e-01f, -1.57904536e-01f, 2.35743970e-02f, -6.56877980e-02f, 6.37211055e-02f, -1.02858447e-01f, -3.21538337e-02f, 1.14884615e-01f, -7.26055652e-02f,
  -1.04078189e-01f, 6.72036558e-02f, 1.54420203e-02f, -5.53996749e-02f, -2.19258945e-02f, -2.13939287e-02f, -1.55063108e-01f, -6.44282401e-02f, 2.43536085e-01f, -1.02772892e-01f,
  -1.51823804e-01f, 4.37066145e-02f, -1.19021915e-01f, -1.25491470e-01f, 9.66421217e-02f, 7.24744275e-02f, -1.00160666e-01f, -1.27875507e-01f, 4.05343883e-02f, 9.06041488e-02f,
  6.21008053e-02f, 2.45944448e-02f, 8.27974901e-02f, 8.00614879e-02f, -7.83804655e-02f, -2.44421676e-01f, 1.02147505e-01f, -1.23847008e-01f, 5.51798753e-02f, -1.09373145e-01f,
  -1.28217012e-01f, 2.10984759e-02f, 1.40654445e-02f, -1.68498203e-01f, -2.65952460e-02f, -1.31705537e-01f, -2.14203354e-02f, 4.68750075e-02f, -7.98302814e-02f, 7.86492899e-02f,
  8.45667645e-02f, 9.12788436e-02f, -7.18233213e-02f, -6.35744408e-02f, 6.38225377e-02f, 1.57979820e-02f, -4.74681184e-02f, 1.63082823e-01f, -6.35268018e-02f, -5.36527224e-02f,
  2.20049955e-02f, -4.40181307e-02f, 1.97292909e-01f, -2.30328903e-01f, 2.52042741e-01f, 1.13488264e-01f, 1.31720707e-01f, -3.85416597e-02f, 6.26544580e-02f, 6.47447035e-02f,
  6.84114173e-02f, -2.44089961e-02f, 1.20411195e-01f, 6.81752041e-02f, 2.47317571e-02f, -1.91864386e-01f, -1.24597885e-01f, 4.35393825e-02f, 6.33333325e-02f, -1.18262164e-01f,
  2.25129589e-01f, 1.41057894e-01f, 2.00255737e-01f, -2.19599277e-01f, -1.33246899e-01f, -2.95253899e-02f, -7.48005584e-02f, 1.10351071e-01f, 2.63160855e-01f, 1.49684593e-01f,
  -4.54974407e-03f, 5.97171821e-02f, -3.18296091e-03f, -6.20675609e-02f, -2.27520783e-02f, -7.90016502e-02f, -5.87961562e-02f, -1.63063101e-04f, 1.72836661e-01f, 1.43969342e-01f,
  -1.02625862e-01f, -5.04750274e-02f, 1.79352865e-01f, 3.24680917e-02f, -7.02480674e-02f, -1.28144920e-02f, -2.45529283e-02f, -2.59362906e-01f, -1.46109313e-01f, 1.31424636e-01f,
  5.67352138e-02f, 5.56438752e-02f, 6.66824430e-02f, -7.04553500e-02f, -5.26503734e-02f, -5.96384667e-02f, 1.16715498e-01f, -5.33722341e-02f, 1.11889936e-01f, -8.10700804e-02f,
  -8.95006582e-02f, -1.41794488e-01f, -1.29275635e-04f, 2.27402747e-02f, -6.04020804e-02f, -1.39302775e-01f, -1.97053447e-01f, 4.48708534e-02f, -1.36188582e-01f, 1.45422459e-01f,
  1.74578026e-01f, -1.07113712e-01f, -1.94957275e-02f, 6.29256740e-02f, -7.72440732e-02f, 8.97203907e-02f, 1.40379414e-01f, 2.04730686e-03f, 9.99501646e-02f, 9.06268284e-02f,
  -1.09172696e-02f, -1.60164852e-02f, 6.98394850e-02f, 9.69247222e-02f, 2.24291474e-01f, 2.98925877e-01f, 1.27374321e-01f, -3.48839879e-01f, -8.24454799e-02f, -1.43892139e-01f,
  -6.53363019e-02f, 2.56484330e-01f, 1.55552417e-01f, 1.16458811e-01f, 1.15299277e-01f, 1.58769917e-02f, -1.24789827e-01f, -7.15187863e-02f, 1.26348078e-01f, -6.35696650e-02f,
  -1.08982749e-01f, 1.50243551e-01f, 2.36749798e-01f, -4.94713113e-02f, -1.14319045e-02f, 1.30579248e-01f, 2.25550294e-01f, -5.63786700e-02f, -1.30096776e-02f, -6.45978823e-02f,
  6.72631664e-03f, 1.27704963e-01f, 2.98285037e-02f, 7.45846704e-02f, 4.45475653e-02f, -1.24139555e-01f, -5.22224084e-02f, -1.54281855e-01f, -7.88201857e-03f, 6.00375533e-02f,
  -1.24963515e-01f, 4.91945222e-02f, -2.18763761e-02f, -1.63487032e-01f, 6.07776791e-02f, -1.35385217e-02f, 7.79602602e-02f, 1.87540561e-01f, -7.51277953e-02f, -1.72527492e-01f,
  -1.38255760e-01f, 1.60041884e-01f, -7.56759048e-02f, 3.30251381e-02f, -3.67787816e-02f, -4.70737889e-02f, -9.53371376e-02f, -1.40823990e-01f, -1.40380368e-01f, -8.12704787e-02f,
  1.14289626e-01f, 5.11290543e-02f, 3.75228538e-03f, -1.42963082e-01f, -1.72899738e-02f, -6.47321716e-02f, 4.55882661e-02f, 2.14364082e-02f, 2.06595555e-01f, 3.12933236e-01f,
  2.57946730e-01f, -1.98848128e-01f, -2.32695013e-01f, -2.52265006e-01f, -1.83681414e-01f, -1.57858714e-01f, 3.18065137e-02f, -6.86815530e-02f, -1.62885915e-02f, 1.60582550e-02f,
  -2.53347754e-02f, -1.26526728e-02f, -1.65024176e-01f, 2.09605210e-02f, 8.48272741e-02f, 1.06283180e-01f, 1.05540738e-01f, -1.14750110e-01f, 5.47425784e-02f, 6.14127927e-02f,
  -2.25923762e-01f, -1.07596345e-01f, -1.19851321e-01f, 1.27655119e-01f, -1.10276341e-01f, -1.07962988e-01f, 4.09938768e-02f, -1.80949848e-02f, 1.05863318e-01f, 1.09539732e-01f,
  5.18947542e-02f, -2.43429929e-01f, 7.47024566e-02f, -1.19946618e-02f, 5.11535369e-02f, -5.40416837e-02f, -1.57167494e-01f, 9.63038504e-02f, -1.75609589e-01f, -3.85774486e-02f,
  2.48552859e-02f, 1.57691985e-01f, -1.03852540e-01f, 3.85646224e-02f, 3.20742354e-02f, 2.33314723e-01f, -1.65339381e-01f, 7.57202432e-02f, 1.46433324e-01f, 4.69911993e-02f,
  2.28593722e-01f, -3.96578610e-02f, 1.29128575e-01f, 2.38928095e-01f, 1.58905443e-02f, 2.17559800e-01f, -4.90630569e-04f, 3.92851159e-02f, -9.02367849e-03f, 2.23821536e-01f,
  1.77917019e-01f, -5.65356240e-02f, -1.54631302e-01f, 8.56459513e-02f, -6.14949912e-02f, 3.90999205e-02f, -1.30080670e-01f, -1.60184074e-02f, -1.78848967e-01f, -8.94398093e-02f,
  -2.53658086e-01f, -1.59507751e-01f, 5.27518569e-03f, 1.26385450e-01f, 1.08713247e-01f, -1.71832964e-02f, -3.26351002e-02f, -3.29765305e-02f, -1.02834292e-01f, 5.88240800e-04f,
  -1.11936949e-01f, -2.24842817e-01f, -2.28709616e-02f, -5.89010715e-02f, -9.43932682e-03f, -8.04687142e-02f, 1.02476038e-01f, 1.20282263e-01f, -1.46640956e-01f, 2.50831932e-01f,
  -3.44925560e-02f, -6.29066154e-02f, 8.18829089e-02f, -1.01023845e-01f, 1.36314422e-01f, -1.64001901e-03f, -6.77681416e-02f, 5.01937699e-03f, 9.86990631e-02f, 1.22843822e-02f,
  -8.84065479e-02f, 9.79047269e-02f, -1.04364298e-01f, 1.36963233e-01f, -2.27867905e-02f, -1.32565469e-01f, 8.94685835e-02f, 2.21548170e-01f, -5.56292608e-02f, 1.36781558e-01f,
  -1.15460120e-01f, 7.48172849e-02f, -1.36552617e-01f, 1.28820971e-01f, 9.62039456e-03f, -5.38050234e-02f, -1.46931246e-01f, -1.19263008e-01f, -1.55964240e-01f, -1.58309966e-01f,
  -2.85360634e-01f, 5.61601706e-02f, -1.22175574e-01f, -2.88873613e-02f, -5.61195612e-02f, -3.21802422e-02f, -1.52433917e-01f, -1.65566102e-01f, 9.58188251e-03f, 1.74372345e-01f,
  -1.03141345e-01f, 6.47911802e-02f, 1.11677818e-01f, 2.19951347e-01f, 1.75561458e-01f, 6.99231774e-02f, -1.86274320e-01f, 3.01856577e-01f, -1.87877953e-01f, -1.33039117e-01f,
  1.18876874e-01f, 1.34544253e-01f, -8.79413411e-02f, -1.44308861e-02f, -1.13616996e-01f, 1.73595175e-01f, 1.36676490e-01f, -2.17300713e-01f, 2.23585829e-01f, -5.92878945e-02f,
  9.27870050e-02f, 5.32128140e-02f, 9.68364850e-02f, 2.43629166e-03f, -1.48247764e-01f, -6.75433949e-02f, -1.94801353e-02f, -9.79326889e-02f, -1.75097540e-01f, 5.21760210e-02f,
  -1.83151305e-01f, -1.94549728e-02f, -1.86938681e-02f, -1.27129480e-01f, 8.72383639e-02f, -1.20484956e-01f, -4.12435494e-02f, -1.27220646e-01f, 1.56864583e-01f, -1.48186535e-01f,
  -1.14657700e-01f, -2.34865785e-01f, -1.48719072e-01f, -2.15252578e-01f, 1.15452304e-01f, 1.17679469e-01f, -1.82006359e-01f, 3.64915133e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -9.29471627e-02f, 7.13526681e-02f, -2.06448920e-02f, -4.63972166e-02f, 4.68019694e-02f, 8.00728053e-02f, 1.07965760e-01f, 4.30408046e-02f, 1.24670463e-02f, 1.03832655e-01f,
  6.69429973e-02f, -2.88960654e-02f, -4.06282097e-02f, 1.00937933e-01f, 3.30947079e-02f, -6.85892180e-02f, -9.15827155e-02f, 1.38275279e-02f, 1.48323536e-01f, -5.51833361e-02f,
  -1.49549007e-01f, 1.11546934e-01f, -1.07635818e-01f, 4.05958109e-02f, 1.49348944e-01f, -3.29911560e-02f, 8.69107842e-02f, -1.60538610e-02f, -7.11391196e-02f, 5.22538573e-02f,
  6.08852766e-02f, 2.08016429e-02f, 1.41214415e-01f, 6.11847714e-02f, 4.93803360e-02f, 9.76909399e-02f, 7.76850283e-02f, 7.40406103e-03f, -1.38260320e-01f, -1.71316806e-02f,
  8.41328055e-02f, -6.85327575e-02f, -1.29949888e-02f, 1.55804217e-01f, 3.23912352e-02f, -1.03337504e-01f, -8.60532522e-02f, -8.24956968e-02f, -5.22189774e-02f, -9.57197249e-02f,
  -1.30204512e-02f, 3.81937101e-02f, 6.35285974e-02f, -3.35528441e-02f, -7.53964260e-02f, -3.66553999e-02f, -4.21604291e-02f, 1.01374201e-01f, 1.28200978e-01f, 7.35480562e-02f,
  3.43063213e-02f, -4.13950570e-02f, 8.04138035e-02f, 9.10258591e-02f, 1.66313589e-01f, -9.87824947e-02f, -1.03335746e-01f, -4.54224348e-02f, -7.97488838e-02f, 1.34046063e-01f,
  -6.10382184e-02f, -5.04759625e-02f, 9.50344503e-02f, 1.33878514e-01f, 8.17794949e-02f, 1.72436103e-01f, 5.66313080e-02f, 2.19113037e-01f, 1.51098192e-01f, -4.57248837e-02f,
  -1.58909768e-01f, 4.31625172e-02f, -1.86065361e-01f, -2.03059077e-01f, -1.15545327e-02f, -1.32298470e-01f, 4.51908112e-02f, 4.03900333e-02f, -1.04984157e-01f, 3.89427580e-02f,
  -1.80339701e-02f, -9.58481282e-02f, 1.86119959e-01f, -1.60064851e-03f, 2.90763639e-02f, -8.41220245e-02f, 2.29104478e-02f, -1.16907805e-02f, -9.00414437e-02f, -3.15127186e-02f,
  5.74611500e-03f, 1.44583985e-01f, -1.74591821e-02f, 1.04259565e-01f, 8.26429650e-02f, -2.31760107e-02f, 9.99484360e-02f, -3.81079502e-02f, -4.19682413e-02f, -1.45617366e-01f,
  -6.60818368e-02f, 3.38240992e-03f, 3.04518137e-02f, -7.08702281e-02f, -1.05726205e-01f, 4.91583347e-02f, 7.73593262e-02f, -7.19371364e-02f, 6.92780167e-02f, -2.95093725e-03f,
  -4.03008461e-02f, -3.14221345e-02f, 3.20363492e-02f, 2.95156501e-02f, -5.92497885e-02f, -1.28874555e-01f, -5.51660769e-02f, 3.49873230e-02f, -5.96576976e-03f, -4.95364890e-02f,
  3.26849483e-02f, -9.43107381e-02f, 1.18400119e-01f, -6.97238743e-02f, 1.65545002e-01f, 8.38048980e-02f, 8.77015889e-02f, -7.80076012e-02f, 1.67835370e-01f, 1.42548466e-03f,
  1.31392792e-01f, -1.92593466e-02f, 7.49198273e-02f, -1.31038398e-01f, 7.05912784e-02f, -6.54809028e-02f, -6.31825477e-02f, -1.22420765e-01f, 2.23755419e-01f, -5.23451976e-02f,
  -5.50733991e-02f, -1.86074406e-01f, -3.04222088e-02f, -7.25082234e-02f, 7.04362169e-02f, 2.30147969e-02f, 3.59966867e-02f, 1.11611538e-01f, 1.22436352e-01f, 5.73695898e-02f,
  -1.69670761e-01f, -1.25209205e-02f, 2.21608445e-01f, -1.07918210e-01f, -4.82650921e-02f, -1.29221052e-01f, 1.61242008e-01f, 1.95289440e-02f, -2.19465755e-02f, -1.02922201e-01f,
  -1.75216958e-01f, -6.85153587e-04f, -3.53698134e-02f, 2.29758292e-01f, -9.61776227e-02f, -1.12734511e-01f, -1.10498436e-01f, 2.12872818e-01f, 4.21309531e-01f, 6.51905462e-02f,
  1.63694412e-01f, -9.77203324e-02f, 5.85487783e-02f, 3.75125761e-04f, -4.03176248e-02f, 5.55362105e-02f, 8.03677738e-02f, -7.85403326e-02f, 1.59127012e-01f, 6.43289536e-02f,
  1.69328274e-03f, -2.71835532e-02f, 6.69949055e-02f, -1.25607923e-01f, -1.13774300e-01f, -1.42573476e-01f, -1.06007703e-01f, 6.14685193e-02f, -5.16526960e-02f, 1.22156233e-01f,
  -6.75439835e-02f, -2.04434201e-01f, 1.22988090e-01f, -3.72456759e-03f, -9.56465863e-03f, -1.30170882e-01f, 9.23495665e-02f, 1.19221844e-01f, 6.24906383e-02f, 2.74685681e-01f,
  1.85778126e-01f, 6.13404997e-02f, 1.70476921e-02f, 1.79574907e-01f, 2.04764619e-01f, 5.28073981e-02f, -3.50250900e-02f, -1.42028987e-01f, 2.02774540e-01f, 1.31911695e-01f,
  -1.16815716e-01f, 1.23082317e-01f, -3.28850970e-02f, 5.03941104e-02f, -1.32143628e-02f, -5.78885376e-02f, 1.20287679e-01f, -4.75754775e-02f, -1.51283816e-01f, -6.63385615e-02f,
  -4.80055027e-02f, -5.93588687e-02f, 8.20355341e-02f, -4.83908467e-02f, -5.05088158e-02f, 3.19517516e-02f, -1.22490920e-01f, 1.72329955e-02f, 5.70725687e-02f, -2.13583186e-02f,
  5.37716411e-02f, 5.43588772e-02f, 2.94772238e-01f, -1.23651117e-01f, 1.13967590e-01f, -2.34436169e-02f, 2.65875477e-02f, -5.28226644e-02f, -9.53933969e-02f, -3.63382325e-02f,
  1.05272040e-01f, -1.07452916e-02f, 2.01165289e-01f, 9.10101011e-02f, -1.00972153e-01f, 2.27628853e-02f, 3.79927270e-02f, 7.67597929e-02f, 1.79355815e-02f, 2.26110965e-01f,
  1.35531779e-02f, 1.52978286e-01f, 1.45005256e-01f, -6.31435215e-02f, 1.98542207e-01f, 2.39067629e-01f, 9.53541771e-02f, -4.56921421e-02f, -1.42427506e-02f, 3.73851843e-02f,
  -3.54534313e-02f, 4.87443991e-02f, -3.38742137e-02f, 7.88081735e-02f, -1.00767829e-01f, 2.97560453e-01f, -3.72108445e-02f, -2.12058231e-01f, -1.05774820e-01f, 3.40204716e-01f,
  -8.31542537e-02f, 8.61974508e-02f, 1.83181427e-02f, -3.67904082e-02f, -4.10686024e-02f, -8.67564464e-04f, 1.54696107e-01f, 2.22067624e-01f, 8.18319693e-02f, -4.67703789e-02f,
  3.39823142e-02f, -2.99977157e-02f, 1.79935336e-01f, 1.29240170e-01f, -6.89683035e-02f, 1.17034949e-01f, 1.00200348e-01f, -5.33608459e-02f, 1.82416424e-01f, -1.01853572e-01f,
  7.03262389e-02f, -2.08518691e-02f, -3.06925178e-02f, -2.31173187e-02f, 9.43970121e-03f, -1.73562333e-01f, -1.04204223e-01f, 1.36873731e-02f, -4.98394594e-02f, -2.42964923e-02f,
  1.01839133e-01f, 1.03330180e-01f, 6.39479160e-02f, 3.54504772e-02f, -9.46445838e-02f, 2.33400568e-01f, -1.49944931e-01f, 1.21010982e-01f, -1.24901071e-01f, -1.19671397e-01f,
  -5.17452471e-02f, 1.03454806e-01f, 4.36307676e-02f, -9.49917883e-02f, -3.53841633e-02f, -2.34077871e-02f, -6.29167855e-02f, 6.11210354e-02f, 3.02451048e-02f, 1.07620373e-01f,
  2.36878674e-02f, -6.71154186e-02f, 3.78772169e-02f, 4.76455539e-02f, -1.78352192e-01f, 4.84580770e-02f, 9.27482694e-02f, -7.16613457e-02f, 3.15803252e-02f, 1.44134164e-01f,
  6.32352978e-02f, 8.38321745e-02f, 8.44635963e-02f, -1.00822844e-01f, 3.67743634e-02f, -4.35536355e-02f, -4.03909497e-02f, 1.18319513e-02f, 8.82367194e-02f, 7.16349110e-02f,
  8.22800696e-02f, 1.03750952e-01f, -1.05124727e-01f, 1.65599540e-01f, -1.71900824e-01f, -3.62716205e-02f, -6.55512214e-02f, 1.17450438e-01f, 3.72332260e-02f, 2.84083694e-01f,
  1.49777651e-01f, 1.18912205e-01f, 7.90909752e-02f, -2.32011452e-02f, -1.22952200e-01f, -7.70346746e-02f, -5.68827763e-02f, 3.11331362e-01f, 9.84134525e-02f, 7.51288608e-02f,
  -4.76750210e-02f, -1.06232122e-01f, 7.46225640e-02f, 1.33809522e-01f, -4.16795500e-02f, 5.73944487e-03f, -1.15572646e-01f, -1.54055312e-01f, -1.14461936e-01f, 7.88493529e-02f,
  -5.04249223e-02f, -2.53318623e-02f, 7.10254759e-02f, 2.85905927e-01f, 1.83007866e-01f, 1.13845833e-01f, -8.42064768e-02f, 1.02118477e-01f, 3.18969898e-02f, 1.22404166e-01f,
  1.86056688e-01f, -4.69022393e-02f, -4.37231250e-02f, 8.15616772e-02f, 3.63777317e-02f, -2.00572554e-02f, -3.27386975e-01f, -1.83332309e-01f, -2.58302212e-01f, -9.30789635e-02f,
  -9.73011404e-02f, 2.23969087e-01f, 9.83985215e-02f, 1.98392998e-02f, -2.90266369e-02f, 3.57597992e-02f, 1.76184863e-01f, -1.27280384e-01f, 1.73783422e-01f, -2.17721313e-01f,
  1.63302183e-01f, 4.24051238e-03f, 6.18047267e-02f, 1.44811049e-02f, -4.33488004e-02f, -2.56472051e-01f, -9.83477384e-02f, -5.74762933e-03f, -2.03762986e-02f, -7.41259521e-03f,
  3.07276053e-03f, -2.45329775e-02f, -9.63952541e-02f, 2.89265454e-01f, 2.12973002e-02f, 1.66026205e-02f, -1.53225601e-01f, 1.36765139e-02f, 1.45725131e-01f, 1.47810727e-01f,
  -1.90386876e-01f, 2.14670286e-01f, -9.40618962e-02f, -4.28353027e-02f, 4.34432507e-01f, -4.86454368e-03f, 1.37423351e-01f, -3.78140770e-02f, -1.14941344e-01f, -1.09527953e-01f,
  3.02308559e-01f, -8.50923732e-02f, 1.46279544e-01f, 1.69951215e-01f, 2.20021516e-01f, -3.62938158e-02f, -4.41389065e-03f, 1.78261831e-01f, -6.79507330e-02f, -9.30275694e-02f,
  1.58711597e-02f, -1.22262135e-01f, -4.57164124e-02f, 8.60299617e-02f, 4.05988470e-03f, -6.01559356e-02f, 1.27530843e-02f, -1.02297999e-01f, 3.32910451e-03f, 3.99709865e-02f,
  -1.14181787e-02f, 3.18834698e-03f, 3.52075212e-02f, -6.10504858e-02f, 2.91895121e-03f, 2.99464278e-02f, 5.03845327e-02f, -2.13439669e-02f, -7.01917037e-02f, -1.00056924e-01f,
  1.12253457e-01f, -3.71876769e-02f, 2.72648106e-03f, 7.29061384e-03f, 1.18756853e-01f, 5.00268023e-03f, -2.04459615e-02f, 5.96141517e-02f, 5.11202104e-02f, -1.00119546e-01f,
  -8.86535197e-02f, -1.04805835e-01f, -5.75771146e-02f, -5.62847927e-02f, 6.12948500e-02f, -1.17474340e-01f, 4.19660769e-02f, -7.56138861e-02f, -5.59290089e-02f, -1.27768358e-02f,
  -2.69856304e-02f, 7.42681250e-02f, -2.68016905e-02f, 4.22852635e-02f, 1.07563928e-01f, 4.92544547e-02f, 9.54808816e-02f, 1.02402121e-02f, -6.85639083e-02f, 3.38510685e-02f,
  4.26792130e-02f, 1.12910442e-01f, -1.02047168e-01f, 6.62355945e-02f, -8.48751962e-02f, -4.21635173e-02f, -6.92702159e-02f, -8.90942290e-02f, -1.09868668e-01f, -1.20800041e-01f,
  3.83728333e-02f, 9.14396569e-02f, 1.11043185e-01f, 1.13131016e-01f, -7.39498287e-02f, -2.56703030e-02f, -4.75110188e-02f, 5.85079677e-02f, 3.33992951e-02f, 1.70979276e-01f,
  2.69214809e-02f, 1.18357234e-01f, 6.89742044e-02f, 9.06831250e-02f, -2.18485575e-02f, 2.50830483e-02f, 5.79413101e-02f, -1.13793567e-01f, 8.36915001e-02f, 5.00205532e-03f,
  8.39839205e-02f, -1.27601162e-01f, 4.13696580e-02f, 1.78624596e-02f, 3.09111271e-02f, -1.89384073e-01f, -2.39864290e-02f, -9.22365710e-02f, 1.04254678e-01f, -1.05355926e-01f,
  1.28539801e-01f, 1.82506051e-02f, -1.73843075e-02f, -1.28124043e-01f, 3.10502257e-02f, -7.43759051e-02f, 3.66841480e-02f, -1.17166013e-01f, -7.35271424e-02f, 3.80278789e-02f,
  4.45955060e-02f, -1.76343713e-02f, 2.44981162e-02f, 2.81336308e-02f, 9.81209800e-02f, 5.69293881e-03f, 5.82242012e-02f, 1.75097704e-01f, 1.06199197e-01f, 7.90927038e-02f,
  2.75328476e-02f, 1.35358227e-02f, 1.36342078e-01f, -5.40069714e-02f, 1.55352309e-01f, -9.57578048e-02f, -2.28472687e-02f, -1.48426145e-01f, 1.62474409e-01f, -1.41048968e-01f,
  -5.68755977e-02f, -6.04131669e-02f, 1.42929971e-01f, -3.93003188e-02f, -8.49619657e-02f, 3.88794355e-02f, 7.26977782e-03f, 1.62842259e-01f, 8.41276646e-02f, -6.73200889e-03f,
  2.01405510e-01f, 9.62500572e-02f, 2.44079098e-01f, 1.29616514e-01f, 6.49137795e-02f, 6.43038377e-02f, -3.23685147e-02f, 1.88294291e-01f, 3.99474829e-01f, 1.88264057e-01f,
  1.49793267e-01f, -2.61676490e-01f, 7.10020438e-02f, -2.17008710e-01f, 2.37961218e-01f, 3.15913223e-02f, 7.51730204e-02f, 7.36422762e-02f, 3.34165581e-02f, -3.01470280e-01f,
  6.14865385e-02f, 1.40967458e-01f, -4.15286720e-02f, -1.30137324e-01f, -1.95392519e-02f, -3.91780473e-02f, 2.17295125e-01f, 1.12960204e-01f, -5.01467381e-03f, 3.36007953e-01f,
  -4.80350815e-02f, 5.87525927e-02f, -1.39277652e-01f, -1.37977898e-02f, 8.88550282e-02f, 5.76669490e-03f, 8.60170424e-02f, 1.96696147e-01f, -2.04592302e-01f, 7.21995085e-02f,
  9.22387317e-02f, -5.16812922e-03f, 6.80689216e-02f, -1.08434640e-01f, 7.19439387e-02f, 2.05210015e-01f, -2.06696577e-02f, -1.03017025e-01f, 6.29085989e-05f, 4.70542815e-03f,
  -7.96392262e-02f, 1.85560554e-01f, -1.24191329e-01f, -1.22609474e-02f, -9.51870382e-02f, 1.84038430e-01f, 8.38592276e-02f, 6.44677728e-02f, 1.50413796e-01f, -1.39076471e-01f,
  1.25075907e-01f, 2.34055236e-01f, 4.61873226e-02f, 1.11602403e-01f, -6.67584885e-04f, -1.30330324e-01f, 9.01005492e-02f, -1.39410809e-01f, 5.08518256e-02f, -2.89540160e-02f,
  5.92730083e-02f, -1.67801932e-01f, -7.27874786e-02f, 4.27710414e-02f, -1.42450064e-01f, -3.29648852e-02f, -1.94997549e-01f, -2.98981741e-02f, -3.08640540e-01f, 9.12710428e-02f,
  2.22464260e-02f, -2.01773703e-01f, 3.00387535e-02f, 3.74487936e-01f, -1.29197659e-02f, -2.90315336e-04f, -2.04087645e-02f, -2.26247907e-02f, 3.77467424e-02f, 1.80052727e-01f,
  7.63212889e-02f, 1.08373001e-01f, 1.42639473e-01f, 1.06254674e-01f, 1.66091353e-01f, -1.31002486e-01f, 7.71036595e-02f, -1.31072521e-01f, -5.22247003e-03f, 5.16655035e-02f,
  1.01948455e-01f, 5.86171001e-02f, 8.50057453e-02f, -4.51782253e-03f, -7.96499774e-02f, -3.56605127e-02f, -7.36623034e-02f, 2.02465877e-01f, -6.29736111e-02f, 2.02302653e-02f,
  1.20497227e-01f, 1.15231136e-02f, -2.04796612e-01f, 1.74408332e-01f, 2.08821103e-01f, 1.24761648e-02f, -7.48452693e-02f, -3.95067893e-02f, 4.72381972e-02f, 1.15443379e-01f,
  -1.34334996e-01f, 2.70007066e-02f, -8.12630802e-02f, 1.31017566e-01f, -9.31118652e-02f, 2.02222839e-02f, 2.01610908e-01f, 7.53988791e-03f, 1.77152127e-01f, -5.00980131e-02f,
  2.18287691e-01f, 1.57495126e-01f, -5.02338223e-02f, 8.55474919e-02f, 1.93037108e-01f, 1.19483629e-02f, -3.91453616e-02f, -1.02861181e-01f, 3.37294757e-01f, -1.91879705e-01f,
  2.12275192e-01f, -6.84988722e-02f, 2.99111664e-01f, -9.07845944e-02f, 2.00008765e-01f, 3.50500554e-01f, -1.36248782e-01f, -2.96751827e-01f, -6.99389875e-02f, 7.94902965e-02f,
  1.00269392e-01f, -6.61223605e-02f, 1.71045348e-01f, -1.66313276e-02f, 1.15426145e-01f, 1.12220896e-02f, -1.15813091e-01f, 6.06735498e-02f, 2.03266874e-01f, 7.98207521e-02f,
  -1.45041883e-01f, -1.08661586e-02f, 9.90125909e-02f, -8.34884346e-02f, 7.27788880e-02f, -5.85897565e-02f, -1.83369871e-02f, 7.27499127e-02f, -1.63056571e-02f, 2.40670040e-01f,
  -2.50330530e-02f, 9.45561975e-02f, 1.51800379e-01f, 1.32425591e-01f, 2.13401437e-01f, -1.00883685e-01f, 7.14770257e-02f, -4.67865095e-02f, -4.43091244e-02f, 5.13996743e-02f,
  1.88095018e-01f, -8.12633336e-02f, 1.43047795e-01f, 7.95890950e-03f, 1.19031362e-01f, 5.71188256e-02f, 2.56989926e-01f, 1.35469005e-01f, 1.29296198e-01f, 5.81183285e-02f,
  1.80374458e-02f, 1.77691832e-01f, 2.08167925e-01f, 1.08004436e-02f, 1.77275449e-01f, -1.88831557e-02f, 1.91629216e-01f, 2.03176901e-01f, 1.26834169e-01f, 2.71507837e-02f,
  3.51903230e-01f, 3.87778878e-01f, 2.08033085e-01f, -2.40791783e-01f, -2.04171032e-01f, -3.68676782e-01f, -1.84884205e-01f, -8.42765847e-04f, 1.42421469e-01f, 5.77297136e-02f,
  2.86450148e-01f, -8.44217986e-02f, -1.05126351e-01f, 2.63686150e-01f, -1.30839944e-01f, 6.15552329e-02f, 2.56846398e-02f, -7.36878142e-02f, -1.19897291e-01f, -1.79832682e-01f,
  -1.48208374e-02f, 3.95183206e-01f, -1.90413699e-01f, 8.40145126e-02f, -1.33358255e-01f, 1.42175823e-01f, -2.13717613e-02f, -8.75538588e-02f, 2.04701483e-01f, -1.30107114e-02f,
  2.44202325e-03f, -2.54831053e-02f, -7.80089498e-02f, -2.46978194e-01f, 2.42052749e-01f, 1.46794036e-01f, -1.04442477e-01f, 5.51252961e-02f, -2.25315154e-01f, -6.04847409e-02f,
  -8.23149756e-02f, -1.35258799e-02f, -5.44544458e-02f, 2.26988286e-01f, -8.04888085e-02f, -4.37439792e-02f, 4.27197628e-02f, 2.75817782e-01f, -6.62632287e-03f, -1.37479961e-01f,
  7.87387043e-02f, 1.26597146e-02f, 4.70932631e-04f, -1.35590509e-01f, -1.66118950e-01f, 9.58616361e-02f, 1.14494506e-02f, 1.26570627e-01f, 5.92749231e-02f, 3.15344408e-02f,
  9.71179754e-02f, 1.32558584e-01f, 5.12335524e-02f, 6.01024963e-02f, 9.56505537e-03f, 2.17272490e-01f, 1.37542382e-01f, -2.79665831e-02f, -1.50168791e-01f, -1.53975442e-01f,
  -3.74826156e-02f, -2.38850117e-01f, 1.18243225e-01f, -2.05898762e-01f, -1.12155274e-01f, -1.57368869e-01f, 3.03396117e-02f, -3.96721959e-02f, -1.54184431e-01f, 1.63158495e-02f,
  1.46276891e-01f, 1.01506516e-01f, -1.71066970e-02f, -4.15564887e-02f, -9.34491903e-02f, 1.61049545e-01f, -1.23371622e-02f, -6.55449182e-02f, 7.74569660e-02f, -1.33194085e-02f,
  9.66790468e-02f, -3.88699323e-02f, 1.72142938e-01f, 9.61545184e-02f, -1.29131833e-02f, -7.03844056e-02f, -8.29862729e-02f, -5.39041795e-02f, 1.36505485e-01f, -5.09380773e-02f,
  -8.48954543e-02f, 3.49002634e-03f, -1.15177231e-02f, 7.79698715e-02f, -1.15795299e-01f, -6.32659867e-02f, 7.65402056e-03f, 1.54662440e-02f, -1.39859870e-01f, -5.33112399e-02f,
  3.12055647e-02f, 1.24780163e-01f, -7.46643841e-02f, -1.81702286e-01f, 6.93419054e-02f, -9.21076313e-02f, -1.22991666e-01f, 2.16518313e-01f, 2.68057168e-01f, -7.42069706e-02f,
  2.28419080e-01f, 9.60994661e-02f, -1.77206695e-01f, 2.60839611e-01f, 6.48702905e-02f, 1.33788660e-01f, 1.61463290e-01f, 9.22095180e-02f, 2.30760425e-01f, 4.81475294e-02f,
  2.88626760e-01f, -5.98347653e-03f, 3.15948650e-02f, -3.11438411e-01f, -5.78723922e-02f, -8.46280009e-02f, 5.55981696e-02f, 1.63797215e-01f, -9.44347158e-02f, -3.01473454e-04f,
  -8.15813541e-02f, 2.03375995e-01f, 8.11252147e-02f, 8.77008513e-02f, 4.24762331e-02f, 1.76820025e-01f, 1.41768679e-01f, -2.26889085e-02f, 9.14707333e-02f, -8.43444988e-02f,
  7.28026554e-02f, -1.06918573e-01f, 5.03842123e-02f, -1.35475740e-01f, 1.11127414e-01f, -1.59525871e-01f, 1.76924229e-01f, 9.95165482e-02f, -1.00915425e-01f, 8.99574161e-02f,
  1.11484952e-01f, -9.62958634e-02f, -1.66790843e-01f, 2.77382493e-01f, -5.65763414e-02f, 1.31782979e-01f, -6.75503835e-02f, -1.34951293e-01f, 3.78856845e-02f, 7.39767328e-02f,
  2.75726050e-01f, 1.27326384e-01f, -1.51989320e-02f, -3.44169773e-02f, -1.81032047e-02f, -1.77603245e-01f, -3.87287070e-03f, 1.45229816e-01f, -1.52113084e-02f, 4.03500773e-04f,
  1.82098433e-01f, 2.18736961e-01f, 2.10158661e-01f, -2.36326829e-02f, 2.74324063e-02f, 1.68587476e-01f, 1.34972930e-01f, 2.85311844e-02f, -9.99673605e-02f, -3.73320729e-02f,
  2.27472305e-01f, -1.49170145e-01f, -2.01076061e-01f, -2.37353176e-01f, 5.40251248e-02f, -1.18941583e-01f, 7.24201798e-02f, 1.29608661e-01f, -9.80701149e-02f, -3.18770185e-02f,
  1.81589976e-01f, 1.00262247e-01f, 8.15425739e-02f, -1.32870317e-01f, 1.69859365e-01f, -1.06474729e-02f, 3.71929407e-02f, 7.62792081e-02f, 1.74699172e-01f, 1.05104253e-01f,
  -1.13992050e-01f, -1.93786636e-01f, -2.21017718e-01f, -1.76561058e-01f, 1.65018626e-02f, 1.97035936e-03f, -8.87632952e-04f, -6.77732006e-02f, 4.09586467e-02f, 4.39835228e-02f,
  9.09252651e-03f, -1.78071633e-01f, -1.45680115e-01f, -7.87227005e-02f, 5.21810390e-02f, 2.09186599e-01f, 8.84054452e-02f, 1.34112954e-01f, 1.24183614e-02f, 1.84618622e-01f,
  4.85883683e-01f, 1.94794565e-01f, 1.26308233e-01f, 2.19589882e-02f, -1.26103178e-01f, -1.77324310e-01f, 2.60149956e-01f, -4.95245904e-02f, 2.90614646e-02f, -7.17335939e-02f,
  1.41572446e-01f, -1.12325571e-01f, 6.06332272e-02f, 1.15143076e-01f, -8.44182670e-02f, -1.40571505e-01f, 1.24568185e-02f, -5.85033819e-02f, -2.23352257e-02f, 2.52969600e-02f,
  8.04317445e-02f, -1.26472667e-01f, 1.17329873e-01f, 6.87199906e-02f, -5.81126399e-02f, -1.85537729e-02f, 8.24420899e-02f, -4.96526212e-02f, 6.09584637e-02f, 4.65367325e-02f,
  -6.30632713e-02f, -1.10510178e-01f, -2.61485297e-03f, -1.48008659e-01f, 1.10178873e-01f, -1.09233148e-01f, -1.12337833e-02f, -1.42388223e-02f, 5.92804104e-02f, -2.27720644e-02f,
  7.30302930e-02f, -4.07849578e-03f, -3.71579342e-02f, -7.44806975e-02f, -1.38554215e-01f, -1.06468931e-01f, -2.36469917e-02f, 9.31217000e-02f, -8.91197026e-02f, 1.06425256e-01f,
  4.50571515e-02f, 8.15783739e-02f, 7.82362968e-02f, 1.21181738e-02f, -9.14715305e-02f, -2.06741747e-02f, -4.99165691e-02f, -7.15948641e-02f, 1.22781070e-02f, -6.54565170e-02f,
  1.57068104e-01f, 1.05746746e-01f, -1.01716213e-01f, 8.32333937e-02f, -7.54424930e-02f, -1.00342892e-02f, -6.35103583e-02f, -1.16755582e-01f, 4.95050550e-02f, 3.95024568e-02f,
  -1.10761620e-01f, -9.17581171e-02f, -4.92102467e-02f, -4.32737060e-02f, 5.85653335e-02f, -1.44013271e-01f, 2.08015461e-02f, -8.13915953e-02f, 1.89563856e-01f, 2.47878525e-02f,
  -1.76633701e-01f, -2.63858531e-02f, 8.14583376e-02f, 1.12587688e-02f, 6.31889999e-02f, 4.75896597e-02f, 4.49132584e-02f, 2.19428651e-02f, -8.21482157e-04f, 4.42754962e-02f,
  1.43717349e-01f, 2.36342207e-01f, 1.95403382e-01f, 1.06313348e-01f, -1.39011845e-01f, -1.85783654e-01f, -1.89300671e-01f, -1.55449405e-01f, 1.24064691e-01f, -8.55658427e-02f,
  5.63857369e-02f, -1.06685326e-01f, 1.49461031e-01f, 2.71041784e-02f, -1.03137039e-01f, -7.06516728e-02f, 6.72642961e-02f, 1.69013143e-01f, -9.93975177e-02f, -6.01591319e-02f,
  1.98248208e-01f, 1.06215566e-01f, 2.99458914e-02f, -1.11141406e-01f, 3.90744135e-02f, 1.25669748e-01f, 1.41083553e-01f, -1.01496903e-02f, 6.02929965e-02f, 1.00187659e-01f,
  -5.09929731e-02f, 2.08470806e-01f, 7.05337375e-02f, -5.83585985e-02f, 1.63281679e-01f, -1.56653777e-01f, -2.03158539e-02f, 1.45523563e-01f, -8.78747404e-02f, -8.25977027e-02f,
  5.64553179e-02f, 5.72787933e-02f, -2.13822834e-02f, -1.30131647e-01f, 1.63135231e-02f, -2.87184659e-02f, 4.71644141e-02f, 1.38023466e-01f, 3.01655103e-02f, 3.88357639e-02f,
  -4.23482768e-02f, 4.14086618e-02f, -3.38286906e-02f, 2.19386052e-02f, -1.28702715e-03f, 2.09723990e-02f, -7.52316639e-02f, -6.28402233e-02f, 1.37650874e-02f, 9.40144584e-02f,
  3.11973877e-02f, 7.88539648e-02f, 1.02265328e-01f, 1.61636755e-01f, -2.70198863e-02f, 1.48395123e-02f, 1.36715591e-01f, -2.11755820e-02f, 2.24556751e-03f, 8.42368230e-02f,
  -1.96182966e-01f, -9.70750600e-02f, -1.25533521e-01f, -1.10214189e-01f, 5.08799497e-03f, 5.63489832e-02f, -3.49052958e-02f, -6.68308046e-03f, 8.87462422e-02f, -1.07146636e-01f,
  -6.09068535e-02f, -6.89980388e-02f, -3.66155803e-02f, -1.24688961e-01f, -1.00552432e-01f, -9.86187384e-02f, -2.18357611e-02f, -4.88576703e-02f, 1.03416309e-01f, 1.06303975e-01f,
  -5.40846027e-02f, 7.17072412e-02f, 2.95737609e-02f, -2.14393362e-02f, 6.77137868e-03f, -4.67100628e-02f, 9.71952006e-02f, -6.42336253e-03f, 4.64688540e-02f, -2.58344207e-02f,
  8.46277550e-02f, -7.62097389e-02f, 9.23116207e-02f, -6.34830669e-02f, 5.42617263e-03f, 2.27216799e-02f, 1.27139598e-01f, -9.22769010e-02f, -9.57489908e-02f, 4.63456884e-02f,
  -4.72498536e-02f, -7.35946968e-02f, -6.06580265e-02f, -1.09233884e-02f, 5.42418770e-02f, 8.69478360e-02f, 2.15473417e-02f, 2.92972550e-02f, 5.08457720e-02f, -1.02532841e-01f,
  8.44789296e-02f, 1.22965232e-01f, 1.43146783e-01f, 2.10708201e-01f, 1.71745107e-01f, -6.24223277e-02f, -5.72268330e-02f, 9.81361195e-02f, 1.92542389e-01f, -6.97482303e-02f,
  1.91904306e-01f, -1.62451237e-01f, -7.48136938e-02f, -5.68053462e-02f, 2.00184017e-01f, -1.42560825e-01f, -4.28130962e-02f, 2.95419395e-01f, 2.43277282e-01f, -1.98580429e-01f,
  -1.04190648e-01f, 1.17190108e-01f, 1.43547580e-01f, -9.64258611e-02f, -1.03057757e-01f, -4.76911291e-02f, 1.70827165e-01f, 5.27404733e-02f, 4.01977859e-02f, 2.62123197e-01f,
  -1.63782306e-03f, 9.26878210e-03f, -3.80061567e-02f, 4.68333326e-02f, 1.00599691e-01f, 1.06033301e-02f, 1.14201978e-01f, -4.54812758e-02f, -1.07375588e-02f, 1.97197378e-01f,
  -8.52563232e-02f, -7.99880624e-02f, -2.72958167e-02f, 1.43721831e-04f, 5.55570759e-02f, 1.68714881e-01f, 1.57507107e-01f, -1.58060677e-02f, 5.83899431e-02f, -1.16512679e-01f,
  -1.40892923e-01f, 3.85027565e-02f, 2.50289589e-02f, 1.54786119e-02f, 1.62814911e-02f, -3.15278284e-02f, 1.32414445e-01f, 2.33448092e-02f, 1.35677800e-01f, -4.28956933e-02f,
  1.76302016e-01f, 1.45860657e-01f, -5.64116389e-02f, 2.82036047e-02f, 1.60703063e-01f, -2.67539602e-02f, 1.32708639e-01f, 2.28353459e-02f, -1.12193562e-01f, -5.72428666e-02f,
  -2.16963440e-02f, 1.47239819e-01f, -1.36687802e-02f, 1.72595337e-01f, -1.47240171e-02f, -1.87872276e-01f, -1.82648703e-01f, -5.25523312e-02f, -4.03494090e-02f, 2.22053111e-01f,
  -1.11015610e-01f, 1.25241593e-01f, 1.92667380e-01f, 2.88263321e-01f, -2.25229599e-02f, -1.26477525e-01f, 1.72770336e-01f, -1.19057931e-02f, 9.45077538e-02f, 6.78163469e-02f,
  1.27591357e-01f, 1.37026504e-01f, -7.87566528e-02f, -1.10379979e-01f, 2.95620501e-01f, -7.06294253e-02f, 9.41796303e-02f, 1.38087332e-01f, 8.11823830e-02f, 1.41433701e-01f,
  8.88380557e-02f, -3.95625457e-02f, -1.99017432e-02f, -3.59787755e-02f, -9.33656096e-02f, -4.33536470e-02f, -1.57283112e-01f, -9.69981700e-02f, -1.43374220e-01f, -1.25929967e-01f,
  1.55188367e-01f, -3.42583284e-02f, -8.37272108e-02f, -2.77174320e-02f, 1.57061964e-01f, 1.14080869e-01f, 4.08266336e-02f, 2.36398913e-02f, -1.49700180e-01f, 1.48727685e-01f,
  6.48232177e-02f, 1.83156535e-01f, -7.47368336e-02f, 9.27290618e-02f, 4.61569205e-02f, 7.99652264e-02f, -6.47836402e-02f, -1.32191023e-02f, -3.51977907e-02f, -1.34901449e-01f,
  -1.38329148e-01f, 1.20686933e-01f, -4.01777364e-02f, 6.91053271e-02f, 1.64483096e-02f, -1.00372523e-01f, -4.43128049e-02f, -3.75732109e-02f, -9.94661301e-02f, -6.56584576e-02f,
  -1.38353731e-03f, -1.34071738e-01f, 4.98310886e-02f, -7.94943199e-02f, -7.22867399e-02f, 3.56108472e-02f, 8.08530897e-02f, -1.21424375e-02f, -5.48340939e-02f, -1.01954993e-02f,
  6.85223341e-02f, 1.14725783e-01f, -9.45326313e-02f, 3.92039567e-02f, 1.21074140e-01f, -3.72858234e-02f, -8.10099393e-02f, 1.25760585e-01f, 4.33283225e-02f, -8.75724629e-02f,
  5.05246781e-03f, -4.67556827e-02f, 9.01128426e-02f, -1.33368269e-01f, 1.84674785e-02f, -6.79062605e-02f, -6.18605353e-02f, 5.87954894e-02f, 9.07025263e-02f, -4.04430516e-02f,
  -6.12919815e-02f, 9.51927081e-02f, -7.54247457e-02f, -1.62695721e-02f, 1.47431667e-04f, -3.68745327e-02f, 5.67778125e-02f, 6.92770928e-02f, -1.09074056e-01f, 1.27661794e-01f,
  -1.16376087e-01f, -7.08248168e-02f, 8.68224949e-02f, -4.45596799e-02f, -1.23459630e-01f, -1.08580127e-01f, 2.55768485e-02f, -1.31264087e-02f, 7.79433772e-02f, 1.24327578e-01f,
  -6.31258450e-03f, 1.62753373e-01f, 1.69982523e-01f, 2.54391253e-01f, -8.54384806e-03f, 1.54163793e-01f, 1.60536408e-01f, 1.11957915e-01f, 9.33267549e-02f, 2.24206433e-01f,
  2.95229018e-01f, 4.39605862e-02f, -1.43781260e-01f, 1.18868267e-02f, -1.07157700e-01f, -2.99089909e-01f, -2.77215093e-01f, -2.94935077e-01f, 4.12985772e-01f, -2.37783670e-01f,
  -3.16271126e-01f, 1.72253951e-01f, 6.15551136e-02f, -3.84968407e-02f, -9.62903276e-02f, 4.02253754e-02f, 1.85321033e-01f, 9.13232192e-02f, 9.73266587e-02f, 3.49082649e-01f,
  9.58626941e-02f, -2.80589879e-01f, 5.82829453e-02f, -7.89731964e-02f, 4.76969890e-02f, 3.69345350e-03f, 2.63875574e-01f, 9.18081328e-02f, 6.34100363e-02f, 5.91822378e-02f,
  -1.29767815e-02f, -7.20170885e-02f, 2.28441641e-01f, 2.57465273e-01f, 1.89785585e-01f, -4.29425538e-02f, -1.17314786e-01f, 1.93469867e-01f, 1.26090899e-01f, 1.38746142e-01f,
  -8.29188749e-02f, 1.58462971e-01f, 1.37511238e-01f, -5.54525200e-03f, -8.82680044e-02f, -1.77229270e-01f, -1.65583417e-01f, -1.81502283e-01f, -1.26257509e-01f, 2.73981248e-03f,
  -1.58315927e-01f, 4.64907959e-02f, 1.42405722e-02f, 1.21592633e-01f, 9.44456533e-02f, 4.88530546e-02f, 1.44218266e-01f, -3.08792945e-02f, 2.11654186e-01f, 2.26971194e-01f,
  1.34491727e-01f, -4.56703901e-02f, -4.83810157e-02f, 3.24308537e-02f, 1.79860413e-01f, 1.16748558e-02f, -4.64079157e-02f, -2.58104235e-01f, 1.12447105e-02f, -1.12395950e-01f,
  1.95729300e-01f, 5.80006279e-02f, 2.74345186e-02f, 2.50136524e-01f, 1.70508057e-01f, -6.00177199e-02f, 6.59878850e-02f, 6.40432537e-02f, 7.08342670e-03f, 3.64652500e-02f,
  2.62881033e-02f, 9.51363072e-02f, 1.52669847e-03f, 6.07165173e-02f, -4.12945077e-02f, 1.90123737e-01f, -5.36617674e-02f, -8.86633024e-02f, -2.43267231e-02f, 6.78314567e-02f,
  -1.04132839e-01f, 1.66212127e-01f, -8.82885754e-02f, 1.31316304e-01f, -1.98500231e-01f, 8.59233513e-02f, 4.86274660e-02f, 1.39685459e-02f, 8.93111080e-02f, 1.34236455e-01f,
  4.95245773e-03f, 2.03069672e-01f, 1.12141825e-01f, -1.15421772e-01f, 1.92062676e-01f, -1.51024431e-01f, -1.05972022e-01f, 1.29061952e-01f, 1.29259691e-01f, -1.13445073e-01f,
  1.23331890e-01f, 1.68500707e-01f, -4.08384204e-03f, 9.40593630e-02f, 1.38309911e-01f, 1.09539278e-01f, 5.54622188e-02f, 1.11769184e-01f, -1.61768533e-02f, -1.46233719e-02f,
  -2.48122914e-03f, 3.89498100e-02f, -3.43156531e-02f, 7.27159455e-02f, 3.44920047e-02f, 1.56291768e-01f, -2.43915617e-02f, -1.20674461e-01f, 4.69416119e-02f, -6.38844371e-02f,
  -2.18304202e-01f, 1.99953228e-01f, -1.21058933e-01f, 1.74267039e-01f, 6.90599978e-02f, 2.44002208e-01f, 4.03664820e-02f, -1.10292450e-01f, -8.30034986e-02f, 3.13049436e-01f,
  -2.17625056e-03f, -5.04317656e-02f, 5.70207499e-02f, 5.73898032e-02f, 1.73222292e-02f, -4.87550832e-02f, 5.38034625e-02f, 3.85334790e-01f, 1.15673259e-01f, -9.75627974e-02f,
  1.29945412e-01f, -3.10921110e-02f, -9.74055100e-03f, 1.20790005e-01f, -5.96674755e-02f, -1.11140117e-01f, -5.18543366e-03f, -1.64312031e-03f, 7.94464499e-02f, -1.24471329e-01f,
  4.93740030e-02f, 1.26802072e-01f, 3.16189975e-02f, 5.85183501e-02f, 1.97105538e-02f, 8.68764296e-02f, 4.84385528e-02f, 7.18068853e-02f, -1.22966617e-01f, -6.36951774e-02f,
  7.50688314e-02f, 2.47324239e-02f, -6.48373067e-02f, -1.11393459e-01f, 3.53786051e-02f, 4.86041792e-02f, 9.51173604e-02f, 8.18163380e-02f, 3.89083177e-02f, -1.10163398e-01f,
  1.36384368e-02f, -2.89499201e-02f, -3.32909264e-02f, 6.05382062e-02f, 1.15869120e-01f, -2.00862829e-02f, -8.65730196e-02f, -1.09497514e-02f, -1.11039400e-01f, -2.53076777e-02f,
  -3.45799886e-02f, -1.16411358e-01f, 8.34907442e-02f, 1.16661988e-01f, -9.77593586e-02f, 7.19492184e-03f, -1.37335196e-01f, -7.95407295e-02f, -4.96916473e-02f, 8.75398517e-02f,
  -5.75839393e-02f, -7.61525705e-02f, 7.43778497e-02f, -8.29768255e-02f, -4.93645407e-02f, -4.00913227e-03f, 1.93430353e-02f, -3.50562707e-02f, -3.81026715e-02f, -1.72095671e-02f,
  -2.19246503e-02f, -1.23292908e-01f, 4.78432178e-02f, 1.71843186e-01f, -2.75850799e-02f, -2.49748919e-02f, 8.25113505e-02f, -2.01951545e-02f, -6.85548736e-03f, 2.08945975e-01f,
  1.02743506e-01f, -5.67188598e-02f, -3.15656401e-02f, -1.59590706e-01f, 4.00919877e-02f, -8.92563984e-02f, -8.25703442e-02f, 1.43603414e-01f, -4.92374003e-02f, -6.44845739e-02f,
  -1.20674126e-01f, 1.68878995e-02f, 1.19717903e-01f, -1.18964082e-02f, -4.38576890e-03f, -2.93767732e-02f, 1.31516317e-02f, -7.20888376e-02f, -1.44944236e-01f, 2.32772499e-01f,
  4.11970466e-02f, 6.66689351e-02f, -9.75367278e-02f, 8.95239413e-02f, 5.90605326e-02f, -6.49698451e-02f, 5.50587773e-02f, 7.07950667e-02f, 7.28065297e-02f, -7.97586516e-02f,
  8.85392576e-02f, -1.82391275e-02f, -4.58197966e-02f, 1.55921564e-01f, 4.58570756e-02f, -9.86687932e-03f, -9.30710360e-02f, 1.58673197e-01f, 8.97054523e-02f, 1.64571539e-01f,
  -8.48605558e-02f, 5.89922778e-02f, -9.40307081e-02f, -1.04838654e-01f, -3.24958712e-02f, -1.00469753e-01f, -1.28815666e-01f, -4.59681489e-02f, -7.51304328e-02f, -1.47630842e-02f,
  -1.40777096e-01f, 7.26981238e-02f, 1.43227473e-01f, 1.13672361e-01f, -1.65069759e-01f, -1.30290493e-01f, 1.04650043e-01f, 7.57274255e-02f, 1.24621503e-02f, 1.22539461e-01f,
  -6.83704810e-03f, 9.52660069e-02f, -6.89938664e-02f, 1.68668106e-01f, 5.80881536e-02f, -8.72343034e-02f, -2.73895487e-02f, -6.45531416e-02f, 6.90731127e-03f, 2.11149771e-02f,
  4.93301190e-02f, 1.70964137e-01f, 7.39414543e-02f, -1.54797792e-01f, -1.46108508e-01f, 3.99234481e-02f, -4.17578220e-02f, 3.99632938e-02f, 7.41673857e-02f, 9.11236405e-02f,
  -3.62900160e-02f, -1.36975363e-01f, -2.24729721e-03f, -6.26880117e-03f, -1.48367405e-01f, -8.78589600e-02f, 1.48353875e-01f, 2.57028848e-01f, 9.00517032e-02f, 1.00661166e-01f,
  2.01507375e-01f, 1.80337634e-02f, -3.41537818e-02f, 5.59419394e-02f, 2.07478143e-02f, 1.50653452e-01f, -6.78793713e-02f, 9.32627246e-02f, 9.12185684e-02f, -9.22787040e-02f,
  -6.31763414e-02f, -5.29653579e-02f, 3.57196629e-02f, -1.16416544e-01f, 1.65566817e-01f, 7.65339136e-02f, 1.46112874e-01f, 6.23708963e-02f, 9.31945518e-02f, 1.62203953e-01f,
  -1.05502608e-03f, -1.23740427e-01f, -3.16776186e-02f, 8.74114037e-02f, 9.54535156e-02f, 5.33984378e-02f, -9.18519031e-03f, 7.54820406e-02f, 7.81626701e-02f, -1.28920645e-01f,
  2.30604541e-02f, 3.36570591e-02f, 1.59415677e-01f, 7.26092383e-02f, 1.89052727e-02f, -1.25812232e-01f, -1.12685837e-01f, -1.58162378e-02f, -3.36162047e-03f, 4.84171463e-03f,
  -3.45987901e-02f, 5.98814599e-02f, 5.61094098e-02f, 5.71265779e-02f, -5.32755405e-02f, 1.49849489e-01f, -2.11212914e-02f, -1.60163827e-02f, 2.25815311e-01f, -7.70384893e-02f,
  5.56634851e-02f, 1.25889063e-01f, 1.41634594e-03f, 6.89557716e-02f, 1.82559654e-01f, 5.65598123e-02f, 9.27969590e-02f, 3.24505232e-02f, 1.48409680e-01f, 9.72118303e-02f,
  1.97490137e-02f, 1.40346378e-01f, -1.01395503e-01f, 1.66564807e-02f, -7.95744285e-02f, 3.26956399e-02f, 7.93255642e-02f, -7.11726695e-02f, 1.44352645e-01f, -1.13841191e-01f,
  -1.04884297e-01f, -2.74683405e-02f, -1.06200054e-01f, -2.99111921e-02f, -6.63131401e-02f, -1.44799929e-02f, -8.57307911e-02f, 7.80977830e-02f, 7.01312125e-02f, -8.93907174e-02f,
  6.17293082e-02f, -7.91803449e-02f, 2.19384674e-02f, 1.04169242e-01f, 1.09343916e-01f, 1.17286958e-01f, 1.32905334e-01f, 9.32461768e-02f, 1.33008748e-01f, -7.40712136e-02f,
  -1.08864240e-01f, -1.29524143e-02f, 3.52344997e-02f, -1.18042327e-01f, 8.08466524e-02f, 1.19879693e-02f, 9.07958448e-02f, -7.16852322e-02f, -1.20938115e-01f, 1.14240400e-01f,
  -1.66564714e-02f, -8.36183056e-02f, -1.75407063e-02f, -1.10945381e-01f, -8.46107230e-02f, 3.31823006e-02f, -1.16222359e-01f, -1.03355266e-01f, -6.02835566e-02f, 9.33411419e-02f,
  -8.78670737e-02f, 1.15133822e-01f, -9.97520909e-02f, -8.83018151e-02f, -5.97966611e-02f, -2.31920797e-02f, 6.91856295e-02f, -6.81414530e-02f, 7.51436353e-02f, 2.94972807e-02f,
  5.66939563e-02f, 1.50112510e-01f, -5.37053719e-02f, -1.77758485e-02f, -2.24930067e-02f, 1.14020221e-01f, -7.33956397e-02f, 8.26842636e-02f, 3.24406587e-02f, 1.19048417e-01f,
  5.97738959e-02f, 6.90296218e-02f, 1.15456827e-01f, 2.41367724e-02f, 1.30711449e-02f, 1.42406538e-01f, -1.51113309e-02f, -1.21061290e-02f, -1.94141254e-01f, -2.41132509e-02f,
  2.91274078e-02f, -8.26972798e-02f, 1.11541107e-01f, 5.43680154e-02f, 4.71516103e-02f, -2.29792036e-02f, -2.29528397e-01f, -4.54823254e-03f, 1.08958587e-01f, -5.89384474e-02f,
  1.33156374e-01f, 5.25625162e-02f, 1.15652114e-01f, 2.57286038e-02f, 6.21212507e-03f, -9.79992300e-02f, 6.54230192e-02f, -2.17165455e-01f, 1.10035352e-01f, 8.54749158e-02f,
  3.38219069e-02f, 1.07919969e-01f, 3.16545703e-02f, -5.07096155e-03f, -1.25641689e-01f, 2.85114229e-01f, -4.83032223e-03f, 1.66118238e-02f, -7.65565112e-02f, -1.62805319e-02f,
  9.64351073e-02f, 7.91992545e-02f, -1.55160338e-01f, -1.14737265e-02f, 2.50987634e-02f, -3.79814766e-03f, 6.61928803e-02f, 1.12981752e-01f, 1.16645619e-01f, 1.05314218e-01f,
  5.04789725e-02f, -9.26580951e-02f, 6.05809726e-02f, 3.86277735e-02f, 1.76121503e-01f, 1.39034942e-01f, 3.54021937e-02f, 4.45798934e-02f, -4.85211797e-02f, 2.12698087e-01f,
  1.68104932e-01f, 1.54142991e-01f, 1.70509607e-01f, -2.47026682e-02f, -1.27933417e-02f, 2.24042773e-01f, 2.65114486e-01f, 1.75058424e-01f, 6.95913061e-02f, 1.24494262e-01f,
  1.63704772e-02f, 1.93443418e-01f, -2.15730101e-01f, 1.66693360e-01f, -2.06021518e-01f, -1.68340847e-01f, -1.90516829e-01f, 2.88637459e-01f, 1.55837670e-01f, 3.16075027e-01f,
  -3.27032477e-01f, 2.54460484e-01f, 3.35703462e-01f, 1.74883679e-01f, 4.99426574e-02f, -7.42959902e-02f, 1.99586660e-01f, -9.70465615e-02f, 7.42109567e-02f, -8.28075930e-02f,
  1.46437258e-01f, -2.28255734e-01f, -1.35111228e-01f, 7.02850521e-02f, 3.18982989e-01f, -1.92765351e-02f, 1.27693405e-02f, 8.22938159e-02f, -2.02506304e-01f, -7.30314711e-03f,
  -1.67893201e-01f, -1.18756443e-01f, -3.25488672e-02f, -3.56369466e-02f, 8.72664712e-03f, -1.27029553e-01f, 1.67122427e-02f, -1.74009979e-01f, -1.25163451e-01f, 3.00048608e-02f,
  2.16021404e-01f, 1.23053625e-01f, -2.28069425e-01f, -1.39222190e-01f, -7.84020275e-02f, -9.40079242e-02f, 2.60507792e-01f, -4.06970212e-04f, -7.84541741e-02f, 1.30727589e-01f,
  3.08213811e-02f, 2.18249261e-01f, -4.55079861e-02f, -1.41700029e-01f, 1.15184113e-01f, 1.86629564e-01f, -4.80720028e-02f, 1.02373190e-01f, -5.17576411e-02f, 5.28193153e-02f,
  -2.72323526e-02f, -5.20242797e-03f, 6.26995265e-02f, 4.26652096e-02f, -2.24410761e-02f, -3.64835449e-02f, 1.45617099e-02f, 9.73602012e-02f, 2.71407217e-02f, -7.35422000e-02f,
  -1.13845356e-01f, -7.22842962e-02f, -2.38938600e-01f, 1.10399369e-02f, 2.04290390e-01f, -8.97736661e-03f, 6.55695349e-02f, 2.27494225e-01f, -6.37553707e-02f, -1.94680300e-02f,
  -5.83205074e-02f, -7.54178464e-02f, 1.52203673e-02f, 1.78215206e-01f, 1.49857581e-01f, 2.24428982e-01f, -3.48563530e-02f, -5.02548292e-02f, 2.58124471e-01f, 2.64061708e-03f,
  -7.08959326e-02f, 4.72407490e-02f, 1.54487461e-01f, -3.39578232e-03f, -3.94223630e-02f, -1.52679160e-02f, -7.80191366e-03f, 5.60876820e-03f, -2.02124706e-03f, 1.71961844e-01f,
  5.52401431e-02f, -8.98425430e-02f, -1.28612518e-01f, 1.25324324e-01f, 1.40067816e-01f, -1.07235909e-01f, -7.35731199e-02f, -9.35316756e-02f, 1.86222360e-01f, -1.06514804e-01f,
  -8.12909603e-02f, -7.75263533e-02f, -7.11145177e-02f, -7.30797499e-02f, 1.09942101e-01f, 6.83943182e-02f, -8.06508288e-02f, -1.06184267e-01f, -1.26752391e-01f, 1.02175519e-01f,
  2.12845400e-01f, 7.18733892e-02f, 1.01984844e-01f, -7.02236686e-03f, 1.54246062e-01f, 1.44980913e-02f, 1.87110990e-01f, 1.05190627e-01f, 1.78372398e-01f, 1.04721479e-01f,
  -1.75712749e-01f, -5.85221276e-02f, 1.20393813e-01f, -4.18833531e-02f, 1.58434555e-01f, 2.36715555e-01f, 3.55843343e-02f, 1.21631265e-01f, -4.03226107e-01f, 1.58062756e-01f,
  -1.12769596e-01f, -6.74913600e-02f, 1.54838815e-01f, -9.63978395e-02f, 1.12856887e-01f, 3.18896770e-02f, -5.37047833e-02f, -4.72368998e-03f, -1.75950360e-02f, -2.14020789e-01f,
  -1.99806429e-02f, 1.09720588e-01f, -7.09473193e-02f, 4.61846553e-02f, -2.78572682e-02f, -8.03109109e-02f, -9.87615883e-02f, 2.37283006e-01f, 7.04017580e-02f, -9.72637683e-02f,
  4.05072346e-02f, -7.43396506e-02f, -1.12697542e-01f, -8.10087994e-02f, -5.48690036e-02f, 1.22874938e-01f, 1.22088403e-01f, -1.46392539e-01f, -5.52012725e-03f, 1.41101450e-01f,
  1.13117278e-01f, 1.05276212e-01f, -1.69610545e-01f, -6.71492815e-02f, 1.15219191e-01f, 2.61038393e-01f, 3.29457194e-01f, 7.88017884e-02f, 2.14767873e-01f, -9.14673209e-02f,
  1.81884661e-01f, 2.28376836e-02f, 1.24860704e-01f, 1.02782190e-01f, 6.31646588e-02f, 1.72154069e-01f, 2.62261927e-02f, 8.87054484e-03f, 3.17386985e-02f, 4.80335392e-02f,
  9.18196663e-02f, 7.67347068e-02f, 5.55111021e-02f, 1.20487094e-01f, -9.04982984e-02f, 1.00134894e-01f, 2.10572273e-01f, 1.16449647e-01f, -5.54232225e-02f, -2.23428514e-02f,
  -2.31503516e-01f, -2.77710527e-01f, 2.19040275e-01f, -1.40605018e-01f, -3.45750339e-02f, -1.28468916e-01f, 8.58796537e-02f, 1.48828492e-01f, -1.85430303e-01f, -8.73619691e-02f,
  1.43932536e-01f, 6.72565848e-02f, -1.78195953e-01f, -1.54532149e-01f, -1.04391621e-03f, 1.21530645e-01f, -1.32357359e-01f, 1.19441263e-01f, -3.13145593e-02f, 1.20730735e-01f,
  1.47891536e-01f, 1.24987230e-01f, 8.02796334e-02f, -1.17627561e-01f, 4.38824780e-02f, -1.04317278e-01f, 1.64129242e-01f, 1.47798404e-01f, 2.08641142e-01f, -1.05973110e-02f,
  -2.23375820e-02f, 1.68823719e-01f, -3.37811708e-02f, 1.57199934e-01f, -8.63241106e-02f, 4.06374261e-02f, 7.36581758e-02f, 3.62512693e-02f, -5.45202009e-02f, 1.08351812e-01f,
  -1.54262148e-02f, 1.74723305e-02f, -1.26440585e-01f, -4.67941761e-02f, 1.80240069e-02f, -3.61931622e-02f, 4.49578501e-02f, 4.61607538e-02f, 1.15554268e-02f, 1.76363692e-01f,
  2.84952242e-02f, -3.51951793e-02f, -7.71278590e-02f, -4.75467043e-03f, 8.71583447e-02f, 1.82064131e-01f, 1.92229390e-01f, -1.60963953e-01f, -1.83746859e-01f, -3.03510241e-02f,
  6.84752166e-02f, 1.57595828e-01f, 1.86122134e-02f, -4.11877558e-02f, -1.86243191e-01f, 1.55505553e-01f, 1.59079641e-01f, 3.83028053e-02f, 1.56098688e-02f, 2.59975493e-01f,
  -1.22832820e-01f, -6.19530417e-02f, 1.51240885e-01f, -3.44829597e-02f, -3.09617613e-02f, -3.10024545e-02f, 1.73669960e-02f, -7.53637105e-02f, -7.72330016e-02f, -1.34815365e-01f,
  3.46433133e-01f, -1.21058077e-01f, 6.90602213e-02f, 5.40245622e-02f, 3.71261500e-02f, 3.15678027e-03f, 5.50650991e-02f, 1.25856400e-01f, 1.88012362e-01f, 5.12634031e-02f,
  -4.34838459e-02f, -6.14843145e-02f, -2.35362500e-02f, 1.06980696e-01f, -3.58992964e-02f, -1.43922359e-01f, 1.35375217e-01f, 1.40240754e-03f, 5.12461513e-02f, 4.75618802e-02f,
  2.74187207e-01f, 5.56011945e-02f, -1.33508563e-01f, -1.09911166e-01f, -2.09712628e-02f, -7.58788586e-02f, 1.85693484e-02f, 1.31212026e-01f, -3.21424305e-02f, -6.55459519e-03f,
  3.58113088e-02f, 2.79530380e-02f, 8.00327137e-02f, 2.92405710e-02f, 1.57066911e-01f, -2.48712003e-02f, 2.77856328e-02f, 1.76531658e-01f, 5.69784269e-02f, -3.01840715e-02f,
  1.68420643e-01f, 1.25916868e-01f, 8.74433219e-02f, -4.82915789e-02f, -8.12254921e-02f, -6.74855411e-02f, 6.18700720e-02f, -5.98746166e-02f, 1.99115083e-01f, -9.76475999e-02f,
  2.39275128e-01f, 6.38948232e-02f, 8.70340131e-03f, -2.71662951e-01f, -5.35728633e-02f, -1.07990861e-01f, 4.52026129e-02f, -1.30196780e-01f, 1.48654774e-01f, 5.32606579e-02f,
  -1.18082963e-01f, -9.34918672e-02f, -9.08841714e-02f, -1.83805525e-02f, 6.64922595e-02f, 1.05817452e-01f, -1.09329008e-01f, 1.40205696e-01f, 1.25007123e-01f, -4.63724993e-02f,
  -4.64988686e-02f, -1.31517276e-01f, -1.70474976e-01f, 7.77967051e-02f, 1.75857350e-01f, 1.92184955e-01f, 1.55951664e-01f, -9.50214490e-02f, 2.79106963e-02f, 1.75979078e-01f,
  2.67050803e-01f, -3.94130386e-02f, 2.20912308e-01f, -1.00431725e-01f, -9.93893594e-02f, -3.81689593e-02f, 3.37641425e-02f, 6.92915767e-02f, 6.84138089e-02f, 8.53008330e-02f,
  -4.58457284e-02f, -9.50227827e-02f, 1.40353711e-02f, -2.72219721e-02f, 1.00181550e-01f, 8.97753090e-02f, 9.44804102e-02f, 8.57002810e-02f, -2.14132457e-03f, 3.43173407e-02f,
  8.55515152e-02f, -6.32504374e-02f, -6.78052334e-03f, 1.96867157e-03f, 1.82551831e-01f, 1.07683919e-01f, -7.45519698e-02f, -6.19198978e-02f, 1.53389141e-01f, 9.65558812e-02f,
  4.89009079e-03f, -1.27922118e-01f, -3.32852542e-01f, -3.46453488e-01f, -7.48615116e-02f, -2.49873251e-01f, 7.33451918e-03f, -9.46975276e-02f, 1.81893393e-01f, 1.17271803e-01f,
  2.08374057e-02f, 3.01722623e-02f, 5.94424903e-02f, 6.77026883e-02f, 2.20625754e-02f, -6.80630431e-02f, 7.85786957e-02f, -1.50627112e-02f, -1.48430914e-01f, 1.01457469e-01f,
  -1.71253067e-02f, 2.49788649e-02f, 6.91044107e-02f, 2.37983584e-01f, 9.53631997e-02f, -3.24814953e-02f, -8.26520473e-02f, -1.29973099e-01f, 6.41975626e-02f, 8.77916813e-02f,
  1.08410023e-01f, -6.38191923e-02f, 7.67734498e-02f, -6.76998054e-04f, -4.68827458e-03f, 9.21032131e-02f, 8.83286893e-02f, 1.88662991e-01f, 2.62519978e-02f, -4.41762619e-02f,
  -1.29951742e-02f, 2.39431038e-01f, -6.27743825e-02f, -2.53381357e-02f, -2.66798157e-02f, -4.09813188e-02f, -9.01080370e-02f, -5.25167491e-03f, 3.14127207e-01f, 7.80292675e-02f,
  3.18494178e-02f, 2.61087686e-01f, 8.99777263e-02f, 8.84529054e-02f, -1.09471820e-01f, 2.15955049e-01f, 2.00750381e-01f, 6.48243800e-02f, 1.65387124e-01f, 2.30892301e-01f,
  2.60320045e-02f, -2.56319106e-01f, -2.96372414e-01f, 2.66719013e-01f, 1.75371230e-01f, -1.48238197e-01f, -2.29018107e-01f, -1.28808469e-01f, -2.34975889e-02f, -4.42869365e-01f,
  4.06420641e-02f, 1.71325669e-01f, 1.28827915e-01f, 5.58982305e-02f, -1.84638813e-01f, -2.02037320e-02f, 2.26802309e-03f, 2.78155785e-02f, -1.12608433e-01f, 4.84818667e-02f,
  2.11033791e-01f, 9.53252837e-02f, -1.10929333e-01f, -1.14207968e-01f, -4.98108976e-02f, 2.64409874e-02f, 1.26630798e-01f, 3.59012872e-01f, 3.54882926e-02f, -2.16204673e-02f,
  1.69340253e-01f, -1.95072263e-01f, 2.00916588e-01f, 4.71196435e-02f, 6.08768454e-03f, -1.52301431e-01f, 1.47755118e-02f, 4.48653623e-02f, -9.43570286e-02f, 1.61400959e-01f,
  1.26288816e-01f, 1.03620127e-01f, 1.75270766e-01f, -7.51427561e-02f, -9.45596993e-02f, 3.18273544e-01f, 5.13101593e-02f, 9.31936800e-02f, -1.25507057e-01f, 4.28153165e-02f,
  -3.34512502e-01f, 1.12468012e-01f, -1.61665194e-02f, 2.45866552e-01f, 9.50448886e-02f, 1.11890532e-01f, 1.33716032e-01f, 2.82329265e-02f, 1.48212895e-01f, 1.03720374e-01f,
  1.10737965e-01f, 1.05773553e-01f, -2.97612939e-02f, -7.09190145e-02f, -6.12168433e-03f, -1.06375754e-01f, -1.48029804e-01f, -2.42106318e-02f, -1.58395872e-01f, 6.72636628e-02f,
  -9.81085375e-02f, 1.13406301e-01f, -1.10154971e-01f, 2.12150306e-01f, 5.95202073e-02f, 2.71710038e-01f, -2.37050392e-02f, -8.48790109e-02f, 1.81415200e-01f, -1.12673253e-01f,
  7.46799484e-02f, -7.16089318e-03f, 2.53568530e-01f, -1.32488357e-02f, -8.48926827e-02f, 5.86369075e-02f, 4.19827193e-01f, 8.00129920e-02f, 1.46928072e-01f, -7.78130144e-02f,
  7.66053498e-02f, 2.16245670e-02f, 3.45851220e-02f, -5.06346039e-02f, -6.47926051e-03f, 4.55323979e-02f, 6.02950379e-02f, 4.11759503e-02f, 2.20320118e-03f, -1.27349570e-01f,
  -8.21081772e-02f, -1.91366505e-02f, 3.23255569e-01f, 4.16456722e-02f, -5.48622869e-02f, -1.15738124e-01f, 1.38494879e-01f, 1.35565192e-01f, 1.12803504e-01f, -8.28109831e-02f,
  -7.46644288e-02f, 4.23508212e-02f, 2.35919446e-01f, 1.69228807e-01f, -9.87820998e-02f, 4.40433025e-02f, 5.12274168e-02f, 1.31209448e-01f, 1.70124963e-01f, -5.41659705e-02f,
  1.31155491e-01f, -4.90245000e-02f, -8.42913892e-03f, -2.88727619e-02f, 1.91359650e-02f, 9.66166779e-02f, -5.22503480e-02f, 4.00752500e-02f, -3.34343351e-02f, -1.48518533e-01f,
  -5.90254441e-02f, -4.14655991e-02f, 1.14548400e-01f, 1.00033306e-01f, 1.83547094e-01f, 3.88104469e-02f, 9.75478292e-02f, 1.85506679e-02f, -2.31317841e-02f, -7.34124184e-02f,
  -2.43512150e-02f, -6.11245185e-02f, -2.13877521e-02f, 1.39007410e-02f, -3.64866406e-02f, -1.06082730e-01f, -7.58620501e-02f, 1.53765827e-01f, -6.18657051e-03f, 5.80475740e-02f,
  2.69999895e-02f, 9.95166134e-03f, 1.79881249e-02f, -1.05435684e-01f, 4.04007584e-02f, -8.92845690e-02f, 1.03348799e-01f, 2.20389683e-02f, -1.39502525e-01f, 1.56709328e-01f,
  -9.53155831e-02f, 1.56142965e-01f, -7.67639652e-02f, 2.28865623e-01f, -9.47044715e-02f, 8.25335085e-02f, 5.06476825e-03f, -5.92587627e-02f, 2.04746366e-01f, -4.45759855e-02f,
  -1.29614502e-01f, 9.65127796e-02f, 1.28529981e-01f, -1.00606315e-01f, -5.63949682e-02f, 8.19964930e-02f, 4.19902690e-02f, -8.39682147e-02f, 6.14338294e-02f, 1.51341036e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.56077623e-01f, 4.46084477e-02f, -5.42349219e-02f, -2.02278439e-02f, 2.75884002e-01f, -1.42679866e-02f, 1.37403518e-01f, -1.24160543e-01f, -5.20860292e-02f, 2.07349911e-01f,
  1.55724734e-01f, 1.66980326e-01f, 1.20111838e-01f, 1.34569585e-01f, 1.40280887e-01f, 5.00083752e-02f, 3.48961912e-02f, -2.85052843e-02f, 1.58457626e-02f, 2.07342148e-01f,
  7.74078146e-02f, -8.37285891e-02f, 2.10903823e-01f, 1.60224676e-01f, 9.87354070e-02f, -1.72450710e-02f, 5.56865595e-02f, -4.90050167e-02f, 3.51500288e-02f, -3.56040560e-02f,
  4.89446186e-02f, 3.34478617e-02f, 2.14249901e-02f, 2.97234748e-02f, 6.85246438e-02f, -6.85829809e-03f, 1.14574172e-01f, 3.06965947e-01f, 9.88528058e-02f, 3.43470983e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.52041495e-01f, -4.05612379e-01f, 3.19404043e-02f, -3.23525280e-01f, -4.64443415e-01f, -3.82040776e-02f, -5.30659370e-02f, -5.89493737e-02f, -1.60775289e-01f, -4.02041584e-01f,
  -1.10699750e-01f, -3.04904997e-01f, -4.48871888e-02f, -9.59686413e-02f, -2.28739992e-01f, 2.51015753e-01f, -1.40124345e-02f, 1.50225058e-01f, 1.88510492e-01f, 1.92837149e-01f,
  1.47793770e-01f, 3.16968441e-01f, -2.82474428e-01f, 3.11846703e-01f, -1.24023408e-01f, 1.31113157e-01f, 3.51561219e-01f, 4.98798877e-01f, -4.31318283e-01f, -9.93086696e-02f,
  3.55322599e-01f, 3.04298103e-02f, 1.76998526e-01f, -2.22003564e-01f, -1.48365781e-01f, 4.38817032e-02f, -2.48799220e-01f, -2.67727487e-03f, -2.27270395e-01f, 3.51812601e-01f,
  2.05177087e-02f, 7.41217658e-02f, 5.32980934e-02f, 1.67631537e-01f, 3.06525141e-01f, 4.13318649e-02f, -1.68532550e-01f, 6.10876344e-02f, 6.39233515e-02f, -4.50626053e-02f,
  -9.39803496e-02f, 1.22866482e-01f, -6.15742318e-02f, -1.84591524e-02f, 3.80943447e-01f, 2.62362719e-01f, -7.33903274e-02f, 3.85632180e-02f, 1.25533476e-01f, 1.97684690e-01f,
  -4.07092720e-02f, -1.20263711e-01f, 2.36728817e-01f, 4.44490314e-02f, -7.02334046e-02f, -1.84291214e-01f, -1.08009048e-01f, 1.63206812e-02f, 1.53893769e-01f, 5.01702838e-02f,
  -1.45902053e-01f, 1.06472149e-01f, 2.54666537e-01f, -7.71626681e-02f, -5.43898763e-03f, 6.23038635e-02f, -1.88972145e-01f, -2.79673606e-01f, 3.02350730e-01f, -2.25541350e-02f,
  -1.63929045e-01f, -4.10020053e-01f, 3.90049309e-01f, -3.65860045e-01f, -4.29225177e-01f, 3.41992676e-02f, 3.17970105e-02f, -1.67676538e-01f, 4.13207449e-02f, 5.80500253e-02f,
  2.04305679e-01f, 3.72261368e-02f, -3.40609312e-01f, 2.67495036e-01f, 5.17188489e-01f, 2.25352738e-02f, 1.72037929e-01f, -2.97689915e-01f, -2.10098892e-01f, 6.44815445e-01f,
  -2.32015982e-01f, -1.77966937e-01f, -1.63318254e-02f, 5.59345901e-01f, 8.50793347e-02f, -2.64675289e-01f, -8.28507356e-03f, -1.16272382e-02f, -2.45960087e-01f, -1.03182264e-01f,
  -4.99924600e-01f, 8.17607120e-02f, -2.42702290e-01f, -8.42282549e-02f, 2.77590156e-01f, 3.96488994e-01f, 1.10726617e-02f, 2.66197890e-01f, -7.18401968e-02f, -2.19242707e-01f,
  5.45880854e-01f, -8.21473077e-02f, 7.03543499e-02f, 6.95991740e-02f, -1.78056404e-01f, -5.85491538e-01f, 4.58474047e-02f, 2.15409666e-01f, 9.18264687e-02f, 1.26031265e-01f,
  2.52405316e-01f, 2.90764809e-01f, 6.33622646e-01f, -6.93744645e-02f, 1.21763319e-01f, 2.17661202e-01f, -3.04701701e-02f, 3.43719482e-01f, 6.81412593e-02f, -7.17937574e-02f,
  2.44448930e-02f, 1.45568028e-01f, 2.09917337e-01f, 1.11965299e-01f, -9.22291279e-02f, 2.55285352e-01f, -9.89603847e-02f, 2.39809036e-01f, 2.28149176e-01f, 1.32449031e-01f,
  2.36608699e-01f, -3.61733466e-01f, 2.32996792e-01f, 7.05440864e-02f, -2.99030989e-01f, -1.21638201e-01f, 1.76294655e-01f, -2.76507258e-01f, 1.23933420e-01f, -6.30710274e-02f,
  3.96154821e-02f, 1.96481824e-01f, -1.27255365e-01f, 4.97255288e-03f, 6.67600185e-02f, -1.67475685e-01f, -2.12914869e-02f, -5.02498709e-02f, -3.56515013e-02f, 6.20099492e-02f,
  3.20488699e-02f, 2.41423741e-01f, 2.62711525e-01f, -1.26930118e-01f, -3.70604187e-01f, 1.97306931e-01f, -1.35511443e-01f, -1.31138504e-01f, -2.76553482e-01f, 5.75385951e-02f,
  8.69326815e-02f, 1.24198392e-01f, 8.40070188e-01f, -2.38301426e-01f, 2.80324817e-01f, -3.26141566e-01f, -2.01019794e-01f, -8.91503543e-02f, -2.07632691e-01f, -2.87058324e-01f,
  1.93869546e-01f, 6.51476672e-03f, -1.29180159e-02f, 4.84706700e-01f, -3.19590807e-01f, 1.69914216e-01f, -5.08940518e-01f, -1.06052876e-01f, 9.34869573e-02f, -2.41545856e-01f,
  -9.57620591e-02f, -1.35101438e-01f, 8.25318769e-02f, 1.11910552e-01f, 9.50738415e-02f, 2.35777721e-01f, 6.22040518e-02f, -1.59662172e-01f, -3.86595339e-01f, 1.21869825e-01f,
  -1.05391070e-01f, 2.70486653e-01f, 8.98446217e-02f, -1.14758991e-01f, 2.47444093e-01f, 2.59707361e-01f, 1.70148592e-02f, -3.47500555e-02f, -9.94553603e-03f, -1.97643757e-01f,
  4.43238765e-01f, -9.46467221e-02f, 9.73063782e-02f, -2.84540951e-02f, -2.25166470e-01f, -4.69409555e-01f, 4.72526699e-01f, -2.04475522e-01f, -2.30603948e-01f, -2.50036493e-02f,
  -2.42729917e-01f, 8.51036161e-02f, 2.53355131e-03f, -1.90221265e-01f, 1.10588560e-03f, -3.97781312e-01f, 2.30890915e-01f, -1.30018026e-01f, 1.45820886e-01f, -3.63807440e-01f,
  4.30924475e-01f, -8.08381662e-02f, 1.40169784e-02f, 4.82386462e-02f, -5.91386855e-02f, -5.97430654e-02f, 2.38918871e-01f, 2.79963106e-01f, -6.18922710e-02f, -1.01470113e-01f,
  5.02357125e-01f, -3.76355290e-01f, -1.01670526e-01f, -7.25326687e-02f, 4.21699464e-01f, -1.30543977e-01f, -8.20524171e-02f, -1.66414797e-01f, -2.02888668e-01f, 1.03466354e-01f,
  2.98035532e-01f, -2.57500350e-01f, -3.70032303e-02f, -3.09388697e-01f, -4.32215244e-01f, 1.72798455e-01f, 8.77548456e-02f, 4.29763675e-01f, -1.88567802e-01f, -1.82984114e-01f,
  7.16338605e-02f, 1.89796870e-03f, -1.61893234e-01f, 3.49611759e-01f, 6.50204495e-02f, 2.89359272e-01f, 2.30340809e-01f, -3.59430164e-01f, -2.71843523e-01f, 1.44083798e-01f,
  1.36813074e-01f, 1.48674855e-02f, 2.55709678e-01f, -1.37109518e-01f, -8.27681553e-03f, -1.19206674e-01f, -4.16861147e-01f, 1.00786574e-01f, -6.22530840e-02f, 3.73288900e-01f,
  -3.49036455e-02f, 3.63241017e-01f, -3.27077806e-01f, -1.38416970e-02f, 3.98202986e-01f, -1.76719800e-01f, 5.94177172e-02f, 1.32963713e-02f, 5.25161177e-02f, 4.21883799e-02f,
  3.13424826e-01f, -5.77006489e-02f, 5.11318684e-01f, 1.42743006e-01f, 1.24247104e-01f, -1.10160641e-01f, 8.18885192e-02f, 4.94382419e-02f, -1.18453607e-01f, -1.30943745e-01f,
  -1.34852231e-01f, 3.27512294e-01f, -5.28289117e-02f, -4.61934470e-02f, 1.00155100e-01f, -1.70003459e-01f, 2.46100761e-02f, -3.47513676e-01f, 2.03981757e-01f, -4.21030186e-02f,
  9.26983580e-02f, -1.15496628e-01f, 2.01001719e-01f, 2.59909660e-01f, 2.58784652e-01f, 1.76071405e-01f, 1.66859224e-01f, 1.73322573e-01f, 3.29150379e-01f, 1.14241458e-01f,
  8.01607966e-03f, -8.13318864e-02f, 9.90178660e-02f, -2.68210769e-01f, -7.71372989e-02f, 1.70170456e-01f, 3.54505628e-01f, -3.78867120e-01f, -1.35565670e-02f, 1.63113400e-01f,
  -1.00098262e-02f, -3.44887137e-01f, 1.36295438e-01f, -1.33597627e-01f, -2.38254726e-01f, -1.36986831e-02f, 3.95346284e-01f, -3.14075023e-01f, -2.67635912e-01f, 9.45177581e-03f,
  2.59400785e-01f, 5.26999123e-02f, 1.94842100e-01f, 1.70183152e-01f, -2.57705003e-01f, 2.28428826e-01f, -3.29594344e-01f, 5.07311709e-03f, -7.83186965e-03f, 5.38913548e-01f,
  9.88966525e-02f, -2.17707437e-02f, -8.71525630e-02f, 2.03671381e-02f, -2.11695641e-01f, -1.18567392e-01f, 6.78707063e-01f, 1.04216971e-01f, -1.84509650e-01f, -1.18149258e-03f,
  -1.54856861e-01f, 8.72530416e-02f, -5.17861769e-02f, 5.85948583e-03f, -2.94518709e-01f, -7.21253455e-03f, -3.80618423e-01f, 2.29448259e-01f, -1.82604209e-01f, 3.55531722e-01f,
  1.61728740e-01f, 1.55215383e-01f, -2.99593955e-02f, 9.99456868e-02f, -1.92320943e-02f, 1.20872132e-01f, 1.15968041e-01f, -4.20791917e-02f, -4.88965213e-01f, 2.17893839e-01f,
  8.55176300e-02f, 2.46604696e-01f, 1.58784434e-01f, -2.62879491e-01f, 2.53374167e-02f, -4.90266323e-01f, 1.30285129e-01f, 1.93024091e-02f, -5.92283845e-01f, 2.58288801e-01f,
  3.47580433e-01f, -1.58924744e-01f, 1.06284738e-01f, 1.34071305e-01f, 1.95766956e-01f, 4.04304802e-01f, -1.17783779e-02f, -1.46890664e-03f, 7.03570396e-02f, 2.52381414e-01f,
  -9.11694691e-02f, -1.02349654e-01f, -8.49658158e-03f, -1.45913109e-01f, -3.13192427e-01f, 3.93163897e-02f, 7.09944637e-03f, 3.10853213e-01f, -2.37097189e-01f, -1.70390327e-02f,
  7.30438888e-01f, 5.35453498e-01f, -3.18341881e-01f, -1.49186552e-01f, 2.20330656e-01f, 4.09458369e-01f, 1.16509538e-04f, 1.47338927e-01f, -1.59081236e-01f, -2.16513360e-03f,
  -1.88626289e-01f, -3.72686163e-02f, -5.60150808e-03f, -6.88290447e-02f, 1.98881447e-01f, -3.13376606e-01f, -6.07583206e-03f, -1.16775557e-01f, -2.63768286e-01f, -3.40374783e-02f,
  -8.01872984e-02f, 3.93164754e-01f, -2.08151326e-01f, 1.24983817e-01f, 1.40138939e-01f, -2.04521567e-01f, -4.53730404e-01f, -2.28268262e-02f, -1.22564793e-01f, -2.42939800e-01f,
  -4.25560065e-02f, -6.98142573e-02f, -2.07339711e-02f, -3.94972086e-01f, -1.82754204e-01f, -1.36688471e-01f, -2.19456285e-01f, -7.89303854e-02f, -3.29118460e-01f, -2.39609852e-01f,
  3.51711586e-02f, 4.04764146e-01f, 1.07799120e-01f, 2.60006279e-01f, -3.42297137e-01f, 1.74505487e-01f, -2.28018194e-01f, -2.32918590e-01f, 1.19903713e-01f, 3.12531680e-01f,
  1.42905250e-01f, -1.39114857e-01f, 1.37991667e-01f, 1.69379249e-01f, -1.97798535e-01f, -6.13530539e-02f, 2.16293201e-01f, 3.00369352e-01f, 3.28110129e-01f, 5.24843335e-02f,
  -1.19958948e-02f, 5.28110843e-03f, 2.95125932e-01f, -3.78224880e-01f, 1.72647685e-01f, 9.19210985e-02f, -3.16570461e-01f, -2.59432375e-01f, 5.89224920e-02f, 2.80136764e-02f,
  -8.98947939e-02f, -2.46265292e-01f, 2.73706049e-01f, -9.04423892e-02f, -1.98395669e-01f, 2.04061970e-01f, -3.37231420e-02f, 3.90959829e-01f, 2.10949689e-01f, -6.50126254e-03f,
  7.34226853e-02f, 3.10954332e-01f, -3.54614332e-02f, -1.48737445e-01f, 6.07064664e-02f, -1.52761430e-01f, 1.88285783e-02f, -1.95363790e-01f, 2.44877557e-03f, 2.81455159e-01f,
  5.82196098e-03f, 7.71044344e-02f, 9.38647464e-02f, 9.65912715e-02f, 2.34944150e-01f, -2.28452191e-01f, 2.40053728e-01f, 9.80086401e-02f, 6.28663413e-03f, -2.68244892e-01f,
  8.73006321e-03f, 1.11891307e-01f, -3.74317795e-01f, -2.15742648e-01f, -5.17214509e-03f, 2.87782639e-01f, -4.67203945e-01f, -3.76495808e-01f, 1.05773970e-01f, -3.31229448e-01f,
  -5.03892489e-02f, -3.41945887e-01f, -2.98533499e-01f, -2.15015128e-01f, 2.62311071e-01f, -1.94821835e-01f, 3.22949924e-02f, 5.45009859e-02f, -5.37880100e-02f, -1.79016352e-01f,
  1.12486910e-02f, -1.09731443e-02f, 1.87535323e-02f, -2.78001893e-02f, -1.69468507e-01f, -8.03708136e-02f, -1.54322699e-01f, -4.04928446e-01f, -2.35879496e-01f, -2.77079213e-02f,
  -7.51357898e-02f, 9.01027694e-02f, -4.19823229e-02f, -2.08924398e-01f, 2.08083093e-01f, -2.08977833e-01f, -2.28944644e-01f, -2.98322234e-02f, -2.80370787e-02f, -2.95445919e-01f,
  -1.71128646e-01f, -1.44920200e-01f, -4.75629204e-04f, -4.36179377e-02f, 4.57286574e-02f, 2.81114310e-01f, -1.32612273e-01f, -1.25006139e-01f, 5.36552787e-01f, 2.26859972e-01f,
  -3.29316035e-02f, -2.16725633e-01f, 4.95782524e-01f, 6.86681271e-01f, -1.77779227e-01f, -2.50322014e-01f, -1.89729899e-01f, -1.51483402e-01f, 8.53473470e-02f, -1.70255974e-01f,
  -1.21096246e-01f, -1.63770080e-01f, -5.30689992e-02f, -4.87817898e-02f, -3.17436099e-01f, 1.21292353e-01f, 2.37371564e-01f, -2.26097539e-01f, -3.66473675e-01f, -3.85022253e-01f,
  4.25184071e-01f, 4.33473110e-01f, 5.29457331e-01f, 2.90661663e-01f, -7.71030560e-02f, 1.43077508e-01f, 1.16783157e-01f, 2.36684278e-01f, -4.18977052e-01f, -2.02123791e-01f,
  -1.63882375e-02f, -2.93605417e-01f, 6.45913556e-02f, -1.20459162e-01f, -7.13204220e-02f, 2.06518218e-01f, -3.11187983e-01f, -9.86450016e-02f, -8.94174278e-02f, 5.60325801e-01f,
  -2.61178892e-02f, 2.91531980e-01f, 5.20838201e-01f, -5.96231036e-02f, 4.02783722e-01f, -2.66360790e-01f, -1.43303528e-01f, -1.86940357e-01f, -1.28165990e-01f, 3.94391507e-01f,
  -1.36380836e-01f, 1.12857707e-01f, -3.03734034e-01f, 2.98804462e-01f, -1.75486788e-01f, 1.04229562e-02f, -1.57240361e-01f, 1.23779431e-01f, -8.10857564e-02f, -1.09816991e-01f,
  -1.36431158e-01f, -6.74355924e-02f, -4.98539209e-03f, -9.71604288e-02f, -6.61384240e-02f, 4.69145691e-03f, -3.03540647e-01f, -2.00532347e-01f, -5.69174960e-02f, 2.01886058e-01f,
  1.49873778e-01f, -2.88086712e-01f, -4.41081345e-01f, -3.26410860e-01f, -7.29809180e-02f, 2.94357240e-01f, 8.01476091e-02f, 2.27001533e-01f, 1.69187441e-01f, -3.12783062e-01f,
  3.18353027e-01f, 3.89943242e-01f, 3.92596126e-01f, -4.87202972e-01f, 3.93152088e-01f, -4.73910779e-01f, -5.09374022e-01f, -3.10942054e-01f, -3.27073008e-01f, -3.77589017e-01f,
  -5.26153564e-01f, -4.34926599e-01f, -1.31302610e-01f, 4.64131892e-01f, -3.39947157e-02f, 2.28427723e-02f, -1.01808921e-01f, 4.95919585e-02f, 2.61383742e-01f, 1.17830932e-01f,
  -1.37534589e-01f, -1.23472333e-01f, 2.90667228e-02f, -5.30981161e-02f, -2.64726222e-01f, 3.28996987e-03f, -3.35252374e-01f, 4.80417535e-03f, -1.03589863e-01f, -2.57910758e-01f,
  -1.08958364e-01f, -1.68004513e-01f, -1.05088390e-01f, -1.22868367e-01f, -2.56039619e-01f, 8.42065886e-02f, 1.94361851e-01f, -5.68930171e-02f, 2.94239014e-01f, 1.52235199e-02f,
  3.27171683e-02f, -5.47725633e-02f, -1.29834026e-01f, -9.44697782e-02f, -2.73862988e-01f, -1.62094444e-01f, 6.36703148e-03f, -2.16558591e-01f, -4.34378572e-02f, 1.96180306e-02f,
  -1.51909798e-01f, 3.45492661e-01f, -2.91854978e-01f, 2.36134738e-01f, 2.04577059e-01f, 1.23520948e-01f, 2.70484328e-01f, 1.89260423e-01f, 5.54135107e-02f, 2.53229111e-01f,
  1.45556673e-01f, 1.79214463e-01f, 1.85570598e-01f, 2.11181954e-01f, -3.36915217e-02f, 3.95103365e-01f, -2.53779769e-01f, 1.34987757e-01f, -2.36148164e-01f, -7.79401436e-02f,
  5.26761472e-01f, 1.07728168e-01f, 3.06939036e-01f, -1.04433723e-01f, 1.27138123e-01f, 4.72435772e-01f, 1.02103285e-01f, -9.80923325e-02f, -1.63119212e-01f, 2.47117326e-01f,
  -1.67064831e-01f, -2.83300830e-03f, 8.44627097e-02f, -9.96568128e-02f, -3.32446843e-01f, 4.91048815e-03f, 1.06103092e-01f, -2.92196780e-01f, 3.08360219e-01f, -2.98432857e-01f,
  2.43430972e-01f, 2.18824834e-01f, 5.16997635e-01f, -1.56445965e-01f, -6.25602063e-03f, 2.23068625e-01f, 1.90183237e-01f, -2.80175745e-01f, 1.95925430e-04f, -1.81799736e-02f,
  3.99246871e-01f, -4.08006191e-01f, -1.44912854e-01f, -2.54928060e-02f, 1.73731923e-01f, -1.86315998e-01f, -4.66876291e-02f, -1.44595921e-01f, -3.72384548e-01f, 1.70792788e-01f,
  -2.22761735e-01f, 2.85650492e-01f, 2.63484895e-01f, -1.90004289e-01f, 2.07332700e-01f, 3.39560121e-01f, -2.16828242e-01f, -1.20420814e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.98758036e-01f, -9.08457786e-02f, 1.10112928e-01f, -3.09004681e-03f, -5.58020361e-02f, -3.59735750e-02f, 4.46170606e-02f, -7.75929764e-02f, 4.05553617e-02f, -1.29021481e-01f,
  1.92629457e-01f, -6.38149586e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    