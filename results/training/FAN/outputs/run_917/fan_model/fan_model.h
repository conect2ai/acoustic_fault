/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.73009396e-01f, 2.04396069e-01f, -2.83310190e-02f, -1.34074241e-02f, 2.38582306e-02f, -1.57779068e-01f, 6.31184950e-02f, -1.72273442e-02f, 9.51470509e-02f, 1.33630902e-01f,
  -1.21042192e-01f, -1.04043372e-01f, -1.88056767e-01f, -1.18887141e-01f, -1.09112121e-01f, 7.00372085e-02f, 1.63630880e-02f, -1.46683142e-01f, -2.82585919e-01f, -5.70451580e-02f,
  -5.04994467e-02f, -2.84546483e-02f, -1.70278668e-01f, 1.85094420e-02f, 1.85528845e-01f, 3.10879201e-02f, 3.27065401e-02f, 2.46097315e-02f, 3.54835540e-02f, 1.81922004e-01f,
  9.27829891e-02f, 1.99243296e-02f, -1.46269992e-01f, -7.60001987e-02f, -2.79333945e-02f, 6.03396259e-02f, 6.18649237e-02f, 5.41064814e-02f, -7.26619735e-02f, 1.49349514e-02f,
  6.37501758e-03f, -5.19318096e-02f, -1.45521052e-02f, 1.06402121e-01f, 1.10815994e-01f, -6.48306683e-02f, 1.27578229e-01f, -6.55375049e-02f, -7.83460215e-02f, 1.21807314e-01f,
  8.90070274e-02f, -4.25460748e-02f, -1.70168579e-01f, -2.00238544e-02f, 5.86618073e-02f, -1.35959640e-01f, -5.96615933e-02f, 5.71744442e-02f, -2.84126941e-02f, 2.75535762e-01f,
  -1.54039252e-03f, 4.32061777e-03f, 4.31506746e-02f, 4.40181121e-02f, -2.70630922e-02f, -5.32134622e-03f, 4.01140973e-02f, -2.58351862e-02f, 3.92094180e-02f, -4.50092339e-04f,
  -5.54462709e-02f, 9.50329751e-02f, -3.39528732e-02f, -2.84559745e-03f, 2.37864722e-02f, -2.07628426e-03f, -5.65384924e-02f, 5.85273616e-02f, -4.31204699e-02f, -9.49945860e-03f,
  4.08778340e-02f, -8.34307224e-02f, 3.72801651e-03f, 5.59072308e-02f, 6.57394603e-02f, -5.37506975e-02f, -2.53827614e-03f, 4.87002321e-02f, 9.39403102e-02f, -4.10379842e-02f,
  4.62786630e-02f, -2.83165097e-01f, 8.00130889e-02f, 4.42919210e-02f, -3.02899792e-03f, 2.08239327e-03f, -1.09177409e-02f, -5.45024015e-02f, -1.47593785e-02f, 9.61369351e-02f,
  -1.00954995e-01f, -1.29586803e-02f, 1.26707265e-02f, 1.42710414e-02f, 3.91745195e-02f, 9.85078067e-02f, 1.53987676e-01f, 2.54407637e-02f, -8.79129693e-02f, 7.91543201e-02f,
  8.10871199e-02f, -2.40210351e-02f, -1.55596167e-01f, -6.17586039e-02f, -3.07358913e-02f, -1.32262424e-01f, -4.19856124e-02f, -1.93159543e-02f, -1.81087360e-01f, 1.76672459e-01f,
  -3.26825470e-01f, -1.33767262e-01f, -2.07565978e-01f, -1.85919955e-01f, -2.31287163e-03f, 7.89694190e-02f, 1.34137541e-01f, 9.94496271e-02f, 1.00305170e-01f, 1.53175974e-02f,
  3.48118767e-02f, 6.84858188e-02f, 9.73315611e-02f, 5.53357527e-02f, -5.47553459e-03f, -9.44870040e-02f, -2.73266345e-01f, -2.22137496e-01f, -2.07418445e-02f, 1.26482293e-01f,
  6.50453717e-02f, -1.66442558e-01f, -1.96208417e-01f, -6.28806502e-02f, 1.77081898e-02f, -4.86700013e-02f, -1.41831301e-02f, -1.51463076e-01f, 6.82205753e-03f, -1.43699095e-01f,
  3.91310528e-02f, -2.29958266e-01f, 1.49193421e-01f, 2.94217076e-02f, -5.02880178e-02f, -1.16786370e-02f, 1.85463447e-02f, 8.92190635e-03f, -4.35749777e-02f, -6.36486560e-02f,
  -6.02785535e-02f, 1.04071155e-01f, -6.14934936e-02f, 3.83481421e-02f, 2.02455502e-02f, -6.04115725e-02f, -1.37037113e-01f, -1.24226533e-01f, -9.03280601e-02f, -8.96918867e-03f,
  1.17981978e-01f, -1.02890916e-01f, -6.26672655e-02f, 9.70713273e-02f, -4.01520077e-03f, -7.94172958e-02f, 3.06698936e-03f, -4.31779288e-02f, 2.96187610e-03f, -8.09138194e-02f,
  1.38055738e-02f, -8.21786409e-04f, 6.13945238e-02f, -2.83803884e-02f, -1.61844082e-02f, 6.97025657e-02f, -6.48679659e-02f, 3.97354290e-02f, -6.01233803e-02f, 9.94658185e-05f,
  4.80403043e-02f, -5.66259772e-02f, 1.91543233e-02f, 1.72923878e-02f, 3.81034357e-03f, -3.55091169e-02f, -4.56831492e-02f, 7.47943819e-02f, 1.25819258e-02f, 1.55949849e-03f,
  5.24882153e-02f, -3.99659611e-02f, 2.69925240e-02f, 5.83433453e-03f, -4.53238375e-02f, -2.97478959e-02f, -8.07233378e-02f, 1.05468243e-01f, 4.04107980e-02f, 2.68356055e-02f,
  1.22307040e-01f, 6.92426413e-02f, -3.01328171e-02f, 6.24007313e-03f, -5.61479330e-02f, 7.48880506e-02f, -7.73821725e-03f, -1.84394363e-02f, -4.02672961e-02f, 1.36365443e-02f,
  2.81592179e-02f, -7.70514505e-03f, -4.94044609e-02f, 5.23343943e-02f, 2.22767759e-02f, 1.14334486e-01f, 7.21224919e-02f, -7.08067045e-02f, -2.08828710e-02f, 6.65262416e-02f,
  6.93826471e-03f, -3.11761275e-02f, 1.19381271e-01f, 9.71473902e-02f, -3.28177586e-02f, 1.17484853e-01f, 1.43308258e-02f, 9.94486362e-02f, 5.03978096e-02f, 6.89790174e-02f,
  1.06904671e-01f, 6.25873432e-02f, -2.51486331e-01f, 7.44003877e-02f, -8.41895640e-02f, -2.38545716e-01f, -1.57155439e-01f, -7.36988038e-02f, 1.94800645e-01f, 3.75390723e-02f,
  8.78306478e-02f, 1.10578343e-01f, 1.73290655e-01f, 5.09167463e-02f, -1.72854736e-01f, -9.02034566e-02f, -2.36596912e-01f, -2.42366299e-01f, -1.23935774e-01f, 4.00533862e-02f,
  2.47350372e-02f, 1.16726108e-01f, -1.37656191e-02f, -8.25022757e-02f, 1.49372607e-01f, 9.98067334e-02f, -5.78178912e-02f, -3.76505740e-02f, 2.40564183e-03f, 6.20099120e-02f,
  6.13177009e-02f, -1.26090944e-01f, -2.24623252e-02f, 1.05302684e-01f, -9.08051245e-03f, -1.86724833e-03f, 5.00226542e-02f, 7.75282364e-03f, 7.56635964e-02f, 7.04917833e-02f,
  -1.80136394e-02f, -2.18143687e-02f, -7.87165761e-02f, 6.76828846e-02f, -2.89960094e-02f, -5.67102283e-02f, -1.33284792e-01f, -6.35590255e-02f, -4.46915254e-02f, -3.93328555e-02f,
  9.94878039e-02f, -1.24448180e-01f, -1.10901356e-01f, -7.64112771e-02f, -7.57345110e-02f, -3.26496437e-02f, -7.26757199e-02f, -5.69271781e-02f, -1.15183562e-01f, 1.69588402e-01f,
  1.96899008e-02f, 7.44979382e-02f, -8.43445659e-02f, -2.09357999e-02f, 8.25334340e-02f, -5.36391838e-03f, -6.01665489e-02f, 5.74343465e-02f, -6.27357662e-02f, -1.35916751e-02f,
  -6.01229146e-02f, -1.45189660e-02f, -3.20174396e-02f, 6.91803545e-02f, 7.54988417e-02f, -7.41163502e-03f, -4.96267043e-02f, 6.89915791e-02f, 2.31587961e-02f, 1.18997516e-02f,
  -3.82742239e-03f, -3.68638337e-02f, 7.08483532e-03f, -4.74795997e-02f, -8.25291574e-02f, 1.24984952e-02f, -6.05867542e-02f, 4.55624796e-02f, 5.47954105e-02f, 4.39389609e-03f,
  4.04972047e-01f, -1.90225467e-01f, 1.22965947e-01f, 7.36869574e-02f, -1.72253810e-02f, 1.67158935e-02f, 1.19166501e-01f, -3.19379009e-02f, -4.07429039e-02f, -3.42795961e-02f,
  -7.90546276e-03f, -6.92432746e-02f, 5.92332110e-02f, 2.51444206e-02f, -9.61724017e-03f, 4.42798138e-02f, -3.06712314e-02f, -2.85651311e-02f, 1.42974081e-02f, -3.52442004e-02f,
  1.04512885e-01f, -5.34776561e-02f, 3.49467732e-02f, 5.92532493e-02f, 8.00087154e-02f, 8.03450197e-02f, 3.84580493e-02f, 8.98711979e-02f, -6.67197779e-02f, 1.57303795e-01f,
  3.05149972e-01f, 3.54132116e-01f, 2.74422020e-01f, 2.56979972e-01f, 2.92379797e-01f, 1.79829746e-01f, 3.08821648e-01f, 1.44249976e-01f, 1.23122744e-01f, 1.74131602e-01f,
  1.50515646e-01f, -1.23350210e-01f, 4.60675657e-02f, -6.30570948e-02f, 9.22642499e-02f, 2.57534117e-01f, 1.81839183e-01f, -8.91499780e-03f, -9.65570379e-03f, 6.39166534e-02f,
  6.81598336e-02f, 1.88514769e-01f, -6.42593298e-03f, 2.08739238e-03f, 1.93664469e-02f, -5.16953841e-02f, 1.50356472e-01f, 1.63296267e-01f, 1.26281083e-01f, 2.01103643e-01f,
  1.79814592e-01f, 2.64227450e-01f, -1.36533484e-01f, -3.81367989e-02f, 1.07548840e-01f, -6.55245557e-02f, 6.60472214e-02f, -3.52859162e-02f, -3.06192357e-02f, 1.33048937e-01f,
  1.96213294e-02f, 4.52183709e-02f, 5.21816351e-02f, -3.73415314e-02f, -1.40493864e-03f, 2.63903802e-03f, -5.11779077e-02f, -4.09708871e-03f, 1.19516742e-03f, 1.15793310e-01f,
  2.36487612e-02f, 1.40202656e-01f, -5.96563295e-02f, -6.98181689e-02f, -1.16184182e-01f, -1.00126237e-01f, -1.62284896e-02f, -1.01882264e-01f, -1.35034844e-01f, 7.44214281e-02f,
  4.64840122e-02f, -3.88390198e-02f, -2.88827382e-02f, -1.83017347e-02f, 7.62236258e-03f, -8.79349858e-02f, -2.46992521e-02f, -4.82690819e-02f, -3.64257395e-02f, 2.58439244e-03f,
  -3.41242328e-02f, -2.91030365e-03f, 3.29634510e-02f, 2.48603970e-02f, -3.32185775e-02f, 5.51238209e-02f, -5.74087314e-02f, 7.67595395e-02f, -4.56292965e-02f, -5.49780428e-02f,
  -2.00974587e-02f, -3.09793372e-02f, 2.42593102e-02f, -6.70157000e-02f, 7.61005208e-02f, 5.61983744e-03f, 8.12394097e-02f, -2.78338557e-03f, -5.34773767e-02f, 4.19493020e-02f,
  -8.20373222e-02f, -6.78080916e-02f, 1.60356909e-01f, -3.76594812e-02f, -7.48167485e-02f, -3.17288674e-02f, -5.72924316e-03f, -1.12505779e-01f, -1.12704537e-03f, -4.04681414e-02f,
  1.84469875e-02f, 1.33689614e-02f, -1.76868588e-02f, 1.93239897e-02f, 1.20720537e-02f, -1.01939300e-02f, -4.03198674e-02f, 5.17152920e-02f, -7.29903206e-02f, -8.72257501e-02f,
  7.80619681e-03f, -4.93385196e-02f, -4.64753099e-02f, -9.05633271e-02f, -2.37263944e-02f, -1.32089287e-01f, -1.07242472e-01f, -2.22626757e-02f, -9.43717733e-02f, -4.87900479e-03f,
  5.70332743e-02f, -2.46366292e-01f, -4.46444124e-01f, -8.34225044e-02f, -9.33438390e-02f, -5.47685064e-02f, -8.76018330e-02f, 6.34089336e-02f, 1.56306222e-01f, -9.21288431e-02f,
  -7.46432021e-02f, 2.33910475e-02f, -3.51783521e-02f, -3.25980708e-02f, -3.42210568e-02f, -2.41893947e-01f, -2.33300492e-01f, -1.27297640e-01f, -1.92932207e-02f, 6.16601855e-02f,
  1.25553891e-01f, 1.70433372e-02f, 1.69147313e-01f, 6.56682923e-02f, 3.05518191e-02f, 6.29987614e-03f, -1.53987244e-01f, -8.74425918e-02f, -9.23859328e-02f, -1.96279541e-01f,
  -4.74193931e-01f, -1.34291828e-01f, 7.47592747e-02f, 1.06536280e-02f, -1.15778260e-02f, 2.29148399e-02f, -4.91971299e-02f, 7.57243559e-02f, -1.48745924e-02f, -1.57779653e-03f,
  -3.79179008e-02f, 7.60818943e-02f, 2.19379887e-02f, -3.99340037e-03f, -6.30020648e-02f, 1.06127486e-01f, 1.03367716e-02f, -7.58403167e-02f, 6.69236034e-02f, -1.15556326e-02f,
  5.43038473e-02f, -8.33308324e-02f, -1.58580378e-01f, -3.37122381e-03f, -3.72580402e-02f, -5.17691374e-02f, 1.86485250e-03f, -6.47999048e-02f, 1.93016063e-02f, -5.38662523e-02f,
  -3.99296284e-02f, 2.70424727e-02f, -2.40904815e-03f, 4.39329483e-02f, 9.21713859e-02f, -8.17764178e-02f, 1.58418473e-02f, -4.21355404e-02f, 4.49326001e-02f, -1.37450232e-03f,
  -3.08576766e-02f, -5.90335540e-02f, -3.22888978e-02f, -2.52119750e-02f, -4.46469663e-03f, 2.49360707e-02f, 4.78622690e-02f, -3.09824757e-03f, -3.12483348e-02f, -3.05768065e-02f,
  4.32243198e-02f, 4.67184782e-02f, 5.72436228e-02f, 4.10354473e-02f, 5.46240211e-02f, -1.13964841e-01f, 4.35219286e-03f, 6.65919185e-02f, 3.25985290e-02f, 4.31192368e-02f,
  1.45266531e-02f, 9.73294452e-02f, -1.60850316e-01f, 3.29139680e-02f, 3.89474793e-03f, 4.95242216e-02f, -4.98048924e-02f, -6.59162551e-02f, -3.38802673e-02f, -2.41632201e-02f,
  9.32181627e-03f, 3.54663022e-02f, -7.51157925e-02f, -5.04431352e-02f, 5.55847809e-02f, 6.03427738e-02f, 4.97727133e-02f, -6.45408928e-02f, 3.45566645e-02f, 1.09975524e-02f,
  5.59880137e-02f, 4.78728637e-02f, -3.59966420e-02f, -7.36901015e-02f, -1.00813787e-02f, -7.23978877e-02f, -1.37601085e-02f, 6.66052029e-02f, 1.62362736e-02f, 1.71722639e-02f,
  -6.51752949e-01f, -1.23854347e-01f, 6.20642379e-02f, -1.24220692e-01f, 8.54382440e-02f, 2.45111287e-01f, 1.55458212e-01f, 1.17214501e-01f, -7.22151622e-02f, -6.36063963e-02f,
  -5.20294979e-02f, 1.09094093e-02f, 1.48523860e-02f, 4.44689766e-02f, 4.26029088e-03f, 2.07642153e-01f, 9.69389454e-02f, 6.81356639e-02f, -1.73649024e-02f, -3.20613151e-03f,
  1.08343340e-01f, -7.03853071e-02f, -2.40725622e-01f, -7.09258243e-02f, 3.32570747e-02f, 1.60788244e-03f, 7.45310038e-02f, -1.20030686e-01f, -2.26528570e-02f, -3.14272777e-03f,
  1.25030903e-02f, -4.04897243e-01f, 1.19560368e-01f, -3.03042252e-02f, 3.44347507e-02f, -1.16666868e-01f, 1.73954610e-02f, -3.04386485e-02f, -2.11854782e-02f, -4.20155935e-02f,
  -1.33283734e-01f, -2.63990946e-02f, -6.15025349e-02f, -1.25211440e-02f, -6.69096783e-02f, -6.44203946e-02f, -8.35110918e-02f, -1.00888200e-01f, -8.92278478e-02f, -1.65993646e-02f,
  -1.87946716e-03f, -1.04707919e-01f, -1.00347228e-01f, 5.72122373e-02f, 4.95216101e-02f, -7.34637454e-02f, -3.20628397e-02f, -4.41117436e-02f, -4.56544086e-02f, -9.69740003e-02f,
  1.17493216e-02f, 1.68413073e-02f, -1.45486807e-02f, -5.60196787e-02f, 5.42797484e-02f, -2.39211246e-02f, 9.56619624e-03f, 2.66499482e-02f, 4.23199385e-02f, 3.78172249e-02f,
  -4.65643918e-03f, -3.92077938e-02f, 6.35515600e-02f, -9.99353733e-03f, -1.21803842e-02f, 1.55848693e-02f, -1.56438854e-02f, -1.80111872e-03f, 1.05095478e-02f, 8.77027959e-03f,
  -6.69042841e-02f, -4.60673310e-02f, 4.83148508e-02f, 7.56676644e-02f, 8.66391882e-03f, -6.89855367e-02f, -4.99499738e-02f, 5.53635089e-03f, -5.09135649e-02f, -5.31114303e-02f,
  1.25445783e-01f, 5.60604781e-02f, -4.20769751e-02f, -8.63428488e-02f, -8.51268619e-02f, 2.30199043e-02f, 1.00868242e-02f, -8.90405700e-02f, -2.32569072e-02f, -1.33601269e-02f,
  -2.98145935e-02f, 1.85695868e-02f, 4.53447364e-02f, 5.70035987e-02f, 2.16320176e-02f, 3.06892525e-02f, -2.09397674e-02f, 3.57272327e-02f, 3.83415334e-02f, 1.01670921e-02f,
  5.42962924e-02f, 2.88404757e-03f, 8.98959935e-02f, 1.19853564e-01f, 8.04196298e-02f, 8.05212557e-02f, 1.39065027e-01f, 5.53027615e-02f, 1.42768651e-01f, 2.05445424e-01f,
  -1.52937457e-01f, -2.72332188e-02f, 1.53928578e-01f, -1.32302806e-01f, -3.59994447e-04f, 2.32248157e-01f, 2.22478852e-01f, 1.45957202e-01f, -7.70967230e-02f, -1.69627592e-02f,
  2.25357115e-02f, -5.07413060e-04f, 2.03100573e-02f, 1.34754375e-01f, 1.82522193e-01f, 4.87062968e-02f, -1.50449602e-02f, 1.18455835e-01f, 8.87703076e-02f, 9.95008647e-02f,
  6.06136695e-02f, -1.61952436e-01f, -4.47061472e-02f, 7.35205784e-02f, -8.89645219e-02f, -7.14671314e-02f, 1.02216573e-02f, -9.13901851e-02f, 1.86850876e-02f, -1.05342001e-01f,
  7.48316583e-04f, 3.52619626e-02f, 8.72044563e-02f, -9.86902043e-02f, -1.33153731e-02f, 4.21890318e-02f, 1.15119435e-01f, 1.43288160e-02f, -5.70190586e-02f, -4.29852717e-02f,
  -4.89914529e-02f, -3.40512395e-03f, 1.21223340e-02f, 1.43211456e-02f, -3.21064927e-02f, 2.31715329e-02f, -7.53882108e-04f, 5.24765998e-02f, 8.84987414e-02f, 8.42456296e-02f,
  5.75625226e-02f, 9.84862968e-02f, 1.09094329e-01f, 3.54823954e-02f, 1.38361424e-01f, -2.59221196e-02f, -7.45475572e-03f, 7.00818608e-03f, 6.50196848e-03f, -2.05165699e-01f,
  -4.49058339e-02f, 1.02025736e-03f, 3.29439789e-02f, -7.00398609e-02f, -2.15332489e-02f, -7.07376674e-02f, -6.17866963e-02f, 3.22621725e-02f, 3.48432325e-02f, -1.24616120e-02f,
  4.17995155e-02f, -3.00823059e-02f, 9.49923974e-03f, -3.40154618e-02f, 3.79934274e-02f, 2.73641199e-02f, -4.23499681e-02f, -3.88004296e-02f, -8.04471038e-03f, 1.01495981e-02f,
  -6.02061450e-02f, -1.01239681e-02f, -3.88831249e-03f, -8.17314312e-02f, 1.04502484e-01f, -5.15799485e-02f, 1.60108991e-02f, 8.61137733e-02f, 2.46259756e-03f, -2.77301800e-02f,
  -2.43050843e-01f, 2.62837827e-01f, -1.60905588e-02f, -2.22055316e-02f, 1.65001322e-02f, -8.37140530e-02f, -4.66857180e-02f, -8.16090498e-03f, -7.23625049e-02f, -4.70343046e-02f,
  4.48352918e-02f, 6.13152981e-03f, -5.84550053e-02f, -8.72922763e-02f, -6.21914044e-02f, 1.64803900e-02f, -1.12265021e-01f, -4.45683626e-03f, -3.23228276e-04f, -9.07064900e-02f,
  -4.05899696e-02f, 2.27752212e-03f, 8.50256626e-03f, -9.70203057e-02f, 5.88773862e-02f, -4.78210524e-02f, -9.87654775e-02f, -7.03844205e-02f, 3.78119573e-02f, -2.49044985e-01f,
  1.37140065e-01f, 2.30265602e-01f, 6.94482103e-02f, 2.10084859e-02f, 2.73276925e-01f, 3.72814447e-01f, 4.03313577e-01f, 1.98813736e-01f, 1.37102883e-02f, 1.73027128e-01f,
  6.32559806e-02f, -1.49433821e-01f, -2.54633814e-01f, -1.82974949e-01f, -1.10745318e-01f, 1.54587343e-01f, 3.21315378e-02f, -1.52900994e-01f, -1.14014409e-01f, -9.52562019e-02f,
  -1.00124374e-01f, -1.63229793e-01f, -2.10368395e-01f, -5.33726327e-02f, 8.33455101e-02f, -4.60017659e-02f, 8.91910940e-02f, 9.83587727e-02f, 5.48690781e-02f, -3.73497047e-02f,
  -6.91097230e-02f, 2.25061238e-01f, -7.97364414e-02f, -1.30190909e-01f, -1.09655991e-01f, -4.54806648e-02f, 1.04340337e-01f, -9.27733555e-02f, -8.28028191e-03f, 1.11936063e-01f,
  -1.14269629e-02f, -9.26817581e-02f, -1.12576149e-02f, -1.09272115e-02f, 3.35744210e-02f, 9.60527211e-02f, -1.11794122e-01f, -7.82324970e-02f, -6.86529279e-02f, 9.56873894e-02f,
  -2.42919549e-02f, 1.98024899e-01f, 1.78068563e-01f, 3.49700898e-02f, 2.12173397e-03f, -2.91219857e-02f, 8.55155513e-02f, 4.41924632e-02f, 7.48344138e-02f, 9.45024118e-02f,
  2.62521654e-02f, -6.52416190e-03f, -4.01509255e-02f, 1.87481530e-02f, -1.18495366e-02f, 3.20274383e-02f, 1.73723716e-02f, 4.54416387e-02f, 1.44016966e-02f, 4.55079414e-02f,
  -2.80514825e-02f, 4.49196026e-02f, 2.17935238e-02f, -2.48148409e-03f, -7.03369230e-02f, 2.24986244e-02f, 1.20800808e-01f, -5.87558970e-02f, -1.54896490e-02f, 5.10943297e-04f,
  -2.56744139e-02f, 3.22746560e-02f, 2.15692166e-02f, -6.52225688e-02f, -4.40639891e-02f, -3.20346393e-02f, -4.87042628e-02f, 7.67869577e-02f, -3.07312496e-02f, 1.17695397e-02f,
  -1.89899966e-01f, -9.15465280e-02f, -4.48615812e-02f, -5.46077779e-03f, 1.07259221e-01f, -4.98197563e-02f, -7.98872411e-02f, -8.36853236e-02f, 2.38850471e-02f, -4.64172401e-02f,
  7.57930651e-02f, -3.94365862e-02f, 4.62354310e-02f, 3.52873281e-03f, 3.35464142e-02f, 3.40820663e-02f, -1.40071372e-02f, -2.54317243e-02f, -9.46443081e-02f, 4.91965823e-02f,
  4.79232930e-02f, 1.68691054e-01f, 5.57423942e-02f, 8.26666504e-03f, 6.69738352e-02f, 4.24826751e-03f, 3.39624621e-02f, 1.79078635e-02f, 1.22545987e-01f, 1.26366273e-01f,
  1.20002240e-01f, 9.33731627e-03f, -2.61638075e-01f, 1.17497869e-01f, 7.98957869e-02f, -1.13523647e-01f, -1.08243749e-01f, 3.85849997e-02f, 3.70945595e-03f, -2.63910908e-02f,
  1.04004323e-01f, 3.76390554e-02f, 1.06344871e-01f, -3.91523764e-02f, -1.23346403e-01f, -1.94428086e-01f, -9.48547423e-02f, -1.23355694e-01f, -1.11694686e-01f, -6.71088770e-02f,
  -7.57356221e-03f, 9.35922042e-02f, -1.09259248e-01f, 1.99601129e-02f, 7.06707872e-03f, -5.80293350e-02f, -1.58419006e-03f, 3.55649255e-02f, -1.05042972e-01f, -9.96992737e-02f,
  1.01279758e-01f, 8.54509398e-02f, -6.89170463e-03f, 8.34892318e-02f, 5.63175306e-02f, 1.77670922e-02f, 6.94125369e-02f, 9.83861182e-03f, 9.55270231e-02f, 7.79448226e-02f,
  5.82101084e-02f, 2.83703934e-02f, -6.94248546e-03f, 1.49221933e-02f, -1.27122346e-02f, 4.86760139e-02f, 6.83169067e-03f, -5.16460128e-02f, -5.64003773e-02f, 8.60958248e-02f,
  1.06422246e-01f, 7.68384710e-03f, -1.86255239e-02f, -5.65931275e-02f, -1.07064627e-01f, 2.64074355e-02f, -5.99855334e-02f, -8.10380802e-02f, -1.21614407e-03f, 2.57843304e-02f,
  -2.55565941e-02f, -1.07776523e-01f, -7.26311505e-02f, 6.17919583e-03f, 5.94047271e-02f, -5.16916588e-02f, 1.54538564e-02f, -5.73534779e-02f, -4.05069590e-02f, -7.97282383e-02f,
  2.31862850e-02f, 1.54871214e-02f, 8.64545926e-02f, 4.89271097e-02f, -4.72862273e-02f, 3.23889707e-03f, 4.69236597e-02f, -5.74261695e-02f, -1.21444184e-03f, -2.69581228e-02f,
  -3.17262784e-02f, -7.74288401e-02f, -6.21164516e-02f, -6.70547858e-02f, -3.26477587e-02f, -4.89664748e-02f, -6.44250289e-02f, -1.42316998e-03f, -1.03813242e-02f, 2.79923286e-02f,
  1.96919277e-01f, -5.97176813e-02f, 3.86210643e-02f, 9.86613408e-02f, 1.33147947e-02f, -5.89289106e-02f, -2.80523561e-02f, -7.32945465e-03f, 3.66349332e-02f, 6.71436191e-02f,
  5.51417135e-02f, -3.03269038e-03f, 2.25126408e-02f, 6.64740577e-02f, 3.54349613e-02f, 1.00510016e-01f, 5.22900708e-02f, 1.13946600e-02f, -7.26924762e-02f, 9.20702741e-02f,
  3.44234630e-02f, -6.15940280e-02f, 3.20433863e-02f, -3.80882695e-02f, 9.76440869e-03f, -1.16271339e-02f, -5.84592447e-02f, 3.54797021e-02f, -9.97227207e-02f, 2.24107150e-02f,
  3.61835547e-02f, 2.59825170e-01f, 1.90941870e-01f, -8.42026770e-02f, 6.17563874e-02f, 1.79451481e-01f, 1.70266554e-01f, -5.41197918e-02f, -1.33479610e-01f, 1.58958554e-01f,
  2.05308661e-01f, 1.20170368e-02f, -7.14319125e-02f, -1.19632430e-01f, -1.04604796e-01f, 7.87158087e-02f, -1.34529650e-01f, -7.34159574e-02f, -1.84611782e-01f, -3.28359492e-02f,
  -8.42722207e-02f, -1.65862575e-01f, -7.59665594e-02f, -1.43742502e-01f, -5.29550249e-03f, -1.55568644e-01f, 6.79595992e-02f, 1.48215909e-02f, 1.87070101e-01f, -1.84112079e-02f,
  2.85083234e-01f, 3.04008812e-01f, -1.41241983e-01f, 2.94355256e-03f, 6.40661344e-02f, -7.07467869e-02f, -5.05985282e-02f, 5.96735813e-02f, -4.77174781e-02f, 7.59581625e-02f,
  -1.96075402e-02f, 5.61910011e-02f, 1.23861816e-03f, 5.50505258e-02f, -1.94125231e-02f, 1.84089004e-03f, -1.12403864e-02f, -9.71534029e-02f, -8.75941440e-02f, 1.16407864e-01f,
  9.12355334e-02f, 8.33006352e-02f, 1.90768108e-01f, -1.36853280e-02f, 1.74153433e-03f, -4.66578975e-02f, 1.65957898e-01f, 1.53704301e-01f, 2.89087798e-02f, 1.07703269e-01f,
  1.48297921e-02f, 6.80909902e-02f, -1.29144387e-02f, -3.86323826e-03f, -3.22729768e-03f, 7.55082536e-03f, -7.02236453e-03f, 5.31051047e-02f, -7.59271234e-02f, -1.24711916e-02f,
  1.45269954e-03f, -4.58647795e-02f, -4.07710262e-02f, 3.97013016e-02f, -8.94466713e-02f, 1.74486823e-02f, 4.80368584e-02f, -4.37945835e-02f, 4.44395095e-02f, -7.47884391e-03f,
  4.97500934e-02f, -1.72925573e-02f, 3.64577360e-02f, 2.27104523e-03f, 2.29344908e-02f, 2.10476238e-02f, -3.09815407e-02f, -5.96005209e-02f, -7.26180431e-03f, 1.65061024e-03f,
  -9.49549153e-02f, -4.19789702e-02f, 3.68614160e-02f, -8.97035152e-02f, 6.44422248e-02f, 4.26657125e-02f, 7.63126090e-02f, -1.61104705e-02f, -4.31128033e-02f, 3.30133140e-02f,
  1.18406013e-01f, -3.99118960e-02f, 2.28969958e-02f, -5.52449301e-02f, -5.43788709e-02f, 2.65017748e-02f, 4.96530756e-02f, -3.94476429e-02f, 7.11845458e-02f, -4.22907015e-03f,
  -9.27307606e-02f, -4.32045013e-02f, 8.58961046e-03f, -5.25182560e-02f, 8.64891987e-03f, -1.23247057e-01f, 2.34887470e-02f, 7.01539516e-02f, 1.17391776e-02f, -1.29644245e-01f,
  6.82778060e-01f, -3.49063993e-01f, -2.55397081e-01f, 5.89301102e-02f, -1.19195074e-01f, -1.93704531e-01f, -2.41624892e-01f, 6.58490658e-02f, 2.30377287e-01f, -1.50337130e-01f,
  -1.51319757e-01f, 9.31212977e-02f, 1.42130628e-01f, 1.31288961e-01f, 1.48088500e-01f, -1.95756361e-01f, -1.81366906e-01f, 8.58536437e-02f, 2.78887719e-01f, 1.87397584e-01f,
  5.15907370e-02f, 3.80182378e-02f, 2.95493960e-01f, 1.43663287e-01f, -1.82067052e-01f, 2.49090772e-02f, -1.75638020e-01f, -1.84176907e-01f, -1.79170623e-01f, -2.41143450e-01f,
  -8.34503844e-02f, -2.34592315e-02f, 5.24112284e-02f, 1.02292307e-01f, -9.89405662e-02f, 5.36879562e-02f, 7.57915899e-02f, -1.84912346e-02f, -8.65912586e-02f, 2.24384069e-02f,
  -1.16058491e-01f, 2.48066708e-02f, -5.96480966e-02f, -7.86083564e-02f, 3.42627764e-02f, -4.15608622e-02f, -6.22569472e-02f, 9.86027494e-02f, 3.40235271e-02f, -8.58459435e-03f,
  -1.54136270e-01f, -9.66729596e-02f, -3.46392840e-02f, -7.00240359e-02f, 5.43410927e-02f, -2.99834274e-03f, -1.18698820e-01f, 1.76989418e-02f, -2.09900960e-02f, 8.84594619e-02f,
  3.65369916e-02f, 4.53889370e-03f, -4.05518636e-02f, 8.25303514e-03f, -4.18277690e-03f, -4.58166096e-03f, -1.00846924e-01f, -1.63308270e-02f, 1.77392606e-02f, -4.59427498e-02f,
  2.84333341e-02f, -2.12793481e-02f, 5.15779518e-02f, -2.01486107e-02f, -2.43160930e-02f, -2.21635718e-02f, -5.99656925e-02f, -6.45315647e-02f, -6.58210367e-02f, 3.47605906e-02f,
  1.44641735e-02f, 2.25624349e-02f, -6.54537752e-02f, 7.14639842e-04f, -2.79024187e-02f, -2.48844665e-03f, 2.07043551e-02f, 1.29898461e-02f, 2.98352838e-02f, -6.09716168e-03f,
  1.49742931e-01f, -8.93171877e-02f, 1.15315989e-01f, 1.49985537e-01f, -4.27044332e-02f, 4.55809534e-02f, -6.41054511e-02f, 4.34797965e-02f, -7.41946176e-02f, 4.83774543e-02f,
  -1.04343323e-02f, 9.18135121e-02f, 4.15085023e-03f, 2.89779939e-02f, 3.31250653e-02f, 6.41468689e-02f, -1.54729830e-02f, 6.42106831e-02f, 6.63148016e-02f, -2.27747601e-03f,
  6.15671452e-04f, 1.14126146e-01f, 2.14955062e-01f, 8.19681212e-02f, 2.63563134e-02f, 2.31143355e-01f, -2.55889166e-02f, 5.43912984e-02f, 1.05451167e-01f, 1.73086390e-01f,
  5.60315907e-01f, -1.34942338e-01f, -1.98898599e-01f, 2.69407243e-01f, -1.32974058e-01f, -4.31441925e-02f, -2.80543149e-01f, -1.45801883e-02f, 1.43360600e-01f, -1.03002295e-01f,
  -4.49178815e-02f, 9.88859334e-04f, -2.70055160e-02f, -7.36509264e-02f, -8.06969628e-02f, -1.50287792e-01f, -2.32876927e-01f, -9.03825313e-02f, -2.73898933e-02f, -1.10882655e-01f,
  -8.85189176e-02f, 2.79034730e-02f, 2.22440198e-01f, 1.27729580e-01f, -1.99509729e-02f, 5.68342656e-02f, 4.46112901e-02f, 5.29979728e-02f, -1.32509947e-01f, -1.65736273e-01f,
  -2.57881045e-01f, 2.21272096e-01f, -9.75415036e-02f, 2.91453283e-02f, -5.66111691e-02f, 3.35009508e-02f, -1.00119606e-01f, 1.00953177e-01f, 8.15741122e-02f, 3.42684276e-02f,
  1.04790837e-01f, 8.39863271e-02f, -2.82500591e-02f, 5.49467728e-02f, 3.81293632e-02f, 6.59801140e-02f, 6.01094104e-02f, 6.13754094e-02f, 6.72455579e-02f, -6.98219910e-02f,
  -1.02366410e-01f, 4.56132405e-02f, 6.99109733e-02f, 1.94497276e-02f, 8.37859660e-02f, 9.10708234e-02f, -7.38433003e-02f, -6.31996850e-03f, 1.20699219e-01f, -7.07677566e-03f,
  -1.99592337e-02f, -5.11868438e-03f, 1.71163529e-02f, 5.29764071e-02f, -3.39180534e-03f, -2.15746090e-02f, 1.40141677e-02f, -7.32117519e-02f, 2.36023981e-02f, -1.82577483e-02f,
  -2.14134082e-02f, 3.43438843e-03f, 1.99107756e-03f, 4.93187495e-02f, -2.05445159e-02f, 5.24044298e-02f, 1.22773563e-02f, -3.07285506e-02f, -1.00868400e-02f, 4.81929742e-02f,
  -2.82791909e-02f, -7.18038343e-03f, 8.47855359e-02f, -2.43362468e-02f, 1.68332029e-02f, 2.71550380e-03f, 3.73161235e-03f, 8.73213541e-03f, 5.81311733e-02f, 1.27258757e-02f,
  5.05546965e-02f, 3.48908901e-02f, -9.78109464e-02f, 2.57349443e-02f, 5.01511917e-02f, 2.12603025e-02f, 1.54913357e-02f, 3.27808689e-03f, 5.27071469e-02f, -2.80979797e-02f,
  -5.03251813e-02f, -1.08001465e-02f, 3.14634480e-02f, -5.71043380e-02f, -2.20555943e-02f, 9.36355721e-03f, -5.69848046e-02f, 2.71518566e-02f, -4.26372178e-02f, 5.54146320e-02f,
  -1.01671331e-01f, 4.27743010e-02f, -1.74054857e-02f, -8.64472240e-02f, 3.41914371e-02f, 1.92168113e-02f, -6.78382963e-02f, -8.47467184e-02f, 5.07686462e-04f, -5.47176488e-02f,
  3.98739249e-01f, 9.54651535e-02f, 1.57720238e-01f, 9.13620889e-02f, -1.20342672e-01f, 9.44533944e-02f, 1.53904930e-01f, -3.37811857e-02f, -3.29647548e-02f, -2.21597403e-03f,
  8.63576308e-02f, 2.51155440e-02f, 1.68197602e-02f, -8.25776830e-02f, -4.63736197e-03f, 1.03295200e-01f, 1.09457774e-02f, 1.47663020e-02f, -5.61060682e-02f, -1.30791023e-01f,
  -1.10970579e-01f, -6.23223968e-02f, 3.20541263e-02f, -1.15874574e-01f, -1.18750602e-01f, 7.38965813e-03f, -7.93659240e-02f, -6.20409325e-02f, 4.64940108e-02f, -5.40180951e-02f,
  2.06370234e-01f, 1.01084828e-01f, -5.77473603e-02f, -1.16053365e-01f, -1.59819871e-02f, 1.01400748e-01f, 5.02317250e-02f, -1.54021289e-02f, -8.14791247e-02f, -5.30039668e-02f,
  -2.48427819e-02f, -8.25365409e-02f, 9.25802626e-03f, -1.38733149e-01f, -2.52541862e-02f, 3.27323638e-02f, -2.19379246e-04f, -4.36488874e-02f, -6.48403540e-02f, 7.95750841e-02f,
  -4.21803109e-02f, 5.25507778e-02f, 1.37953058e-01f, 7.20200986e-02f, 7.81538039e-02f, 8.08469206e-02f, 1.37361363e-02f, 9.86324698e-02f, 1.37745962e-01f, 1.00347854e-01f,
  -7.09681734e-02f, 7.55876675e-02f, 3.85037400e-02f, 2.55054533e-02f, -7.80557469e-02f, 3.53892222e-02f, -4.95666750e-02f, -8.08303133e-02f, 5.78771085e-02f, -1.71681866e-02f,
  4.71829958e-02f, 5.87293655e-02f, -2.66690683e-02f, 3.20218392e-02f, 5.34324832e-02f, 4.01938483e-02f, 2.65049729e-02f, -3.58305238e-02f, -4.67163557e-03f, -2.07295641e-02f,
  9.48246103e-03f, -3.72923426e-02f, -4.25080024e-02f, -6.45529404e-02f, 7.16440231e-02f, 2.33362652e-02f, 7.73637593e-02f, 5.31555116e-02f, -3.17605259e-03f, 9.62377861e-02f,
  9.22302753e-02f, -4.57002632e-02f, 4.58841883e-02f, 6.81954250e-02f, -4.22715470e-02f, -5.63250259e-02f, 3.20955403e-02f, 1.21562090e-02f, 7.08824918e-02f, 1.57200135e-02f,
  1.22252516e-02f, -1.78493895e-02f, 4.43679616e-02f, -2.22654082e-03f, -6.08517155e-02f, 5.62596656e-02f, -1.39707327e-02f, 5.42882867e-02f, -3.74667086e-02f, 9.83868167e-02f,
  -6.73152357e-02f, 4.40568067e-02f, 2.76522279e-01f, 6.72858655e-02f, -1.79310329e-02f, 1.85920879e-01f, 1.22480728e-01f, 1.46830857e-01f, 2.22733364e-01f, 1.71812862e-01f,
  -1.79131359e-01f, 3.31125975e-01f, -9.05420035e-02f, 1.75929531e-01f, 1.03186451e-01f, -5.53409792e-02f, 6.24273233e-02f, -3.76358107e-02f, 1.15978725e-01f, 1.56284094e-01f,
  1.47718713e-01f, -5.12920767e-02f, -6.23223633e-02f, -1.81115568e-01f, -2.39923343e-01f, 6.73767850e-02f, 7.21340626e-02f, -1.05006427e-01f, -3.79355013e-01f, -9.46759731e-02f,
  1.09772071e-01f, 1.19756728e-01f, -1.04831934e-01f, 9.90738044e-04f, 2.63358831e-01f, 8.23038295e-02f, 8.18159878e-02f, 9.60065052e-02f, 1.06588095e-01f, 2.91329980e-01f,
  -1.70856297e-01f, 5.12722842e-02f, -1.76289350e-01f, 6.72911406e-02f, 2.24482622e-02f, -8.02457482e-02f, -1.02139823e-01f, -3.30635905e-02f, -5.06058112e-02f, 2.57252697e-02f,
  7.86424708e-03f, -8.44076276e-02f, 4.57475111e-02f, -5.82129648e-03f, -3.04481424e-02f, -9.96759720e-03f, -2.30477545e-02f, -5.72533384e-02f, -1.54538721e-01f, 4.21069190e-02f,
  8.92875046e-02f, 1.08154200e-01f, -2.40014009e-02f, -2.47854944e-02f, 3.02853491e-02f, -1.35427743e-01f, -1.72657203e-02f, -9.31355953e-02f, -8.06346014e-02f, 5.16700409e-02f,
  3.09236590e-02f, 8.08019098e-03f, 4.67847893e-03f, 3.88727188e-02f, 1.28293540e-02f, 8.85548443e-02f, 1.86434702e-03f, 1.16091222e-03f, 3.65792252e-02f, -4.02512178e-02f,
  8.19816627e-03f, -8.93276408e-02f, -3.82227218e-03f, -4.95394692e-02f, 5.25836460e-02f, 1.80382263e-02f, 5.99366892e-03f, -1.88279431e-02f, -4.57718000e-02f, -5.26037216e-02f,
  -2.22558845e-02f, -3.83847617e-02f, 5.91478497e-02f, -3.51948626e-02f, 6.76831901e-02f, 1.62269287e-02f, 1.30604114e-02f, 8.18199571e-03f, 1.37499152e-02f, 1.56027870e-02f,
  -4.81632203e-02f, -2.42377341e-01f, 6.71569854e-02f, -7.53078759e-02f, 4.39232290e-02f, 5.06741852e-02f, 1.20894127e-02f, 3.32933031e-02f, 2.99279373e-02f, 2.28903983e-02f,
  1.84353590e-02f, -6.09147921e-02f, -1.73514951e-02f, 2.33308263e-02f, -6.86911345e-02f, 4.16180491e-02f, 4.43001837e-02f, -1.87281091e-02f, -5.02864905e-02f, 3.29057351e-02f,
  8.70142505e-02f, -3.28369588e-02f, -4.34353799e-02f, -8.07091519e-02f, -3.39395180e-02f, -4.59502302e-02f, -7.48933852e-02f, 2.41365340e-02f, -1.80252835e-01f, -1.02554588e-02f,
  -1.18481539e-01f, -1.92650091e-02f, -4.30978984e-01f, 1.02412462e-01f, 9.83548611e-02f, -7.94020146e-02f, 2.22331844e-02f, 1.57028481e-01f, 1.41914055e-01f, 1.21485166e-01f,
  8.48155692e-02f, 2.59519696e-01f, 9.26599503e-02f, 3.70541699e-02f, -3.38097923e-02f, -1.14664078e-01f, -2.50880539e-01f, -3.01884890e-01f, -2.08424523e-01f, 5.45014180e-02f,
  1.09191716e-01f, 1.16452426e-01f, -6.34630993e-02f, 4.67413366e-02f, -1.69541221e-02f, 2.32446436e-02f, -1.25174761e-01f, 9.79088899e-03f, -1.29174322e-01f, -1.72062129e-01f,
  -1.07834980e-01f, -4.18444909e-03f, 1.91056132e-02f, 5.37707768e-02f, 7.56148994e-02f, -8.77297893e-02f, -3.30529176e-02f, -4.92625050e-02f, -2.90495884e-02f, -7.98531249e-02f,
  1.06346384e-01f, 1.08724996e-01f, 8.83172918e-03f, -7.51147605e-03f, -4.75784726e-02f, 5.25992997e-02f, -2.25663763e-02f, -1.93364516e-01f, -1.20245004e-02f, 3.51785496e-02f,
  1.20794505e-01f, -4.53192443e-02f, -7.13836104e-02f, -4.98531424e-02f, -5.29554449e-02f, 2.40284130e-02f, -8.28661621e-02f, -9.06127095e-02f, -1.44190446e-01f, -3.54019627e-02f,
  2.96487417e-02f, -1.51859103e-02f, 3.28758731e-02f, 7.62251541e-02f, 2.09120028e-02f, -4.52372506e-02f, -5.09486869e-02f, 5.04865907e-02f, 6.45134598e-02f, -6.17968924e-02f,
  7.37130269e-03f, 8.24041106e-03f, 3.55806053e-02f, 1.33979507e-02f, 3.03492248e-02f, -5.53257875e-02f, 1.12308764e-04f, -3.21123004e-02f, -9.19983163e-03f, 6.61275163e-02f,
  -4.75194678e-02f, -2.58599613e-02f, -2.98921019e-02f, 2.04878207e-02f, -4.25882861e-02f, -1.32140452e-02f, 4.46685515e-02f, 5.82267828e-02f, -2.95674428e-03f, -8.63574073e-03f,
  2.43909433e-01f, -1.27170026e-01f, 6.43883944e-02f, -8.46725702e-03f, -5.69869131e-02f, 4.40938585e-02f, 2.95904186e-02f, -1.65088789e-03f, -6.40257122e-03f, 7.01400451e-03f,
  9.12323222e-03f, -6.36846712e-03f, 1.33393295e-02f, 7.33159408e-02f, 2.74510682e-03f, 3.75232361e-02f, 1.12302959e-01f, 3.97754610e-02f, -6.72317445e-02f, -4.00687614e-03f,
  4.83199358e-02f, -5.29853143e-02f, 4.98412028e-02f, -9.29788128e-03f, 6.74278811e-02f, 4.58625592e-02f, -4.67142835e-02f, -7.32999891e-02f, -1.99419465e-02f, 1.58118531e-01f,
  3.04580301e-01f, -8.99599716e-02f, 9.73964781e-02f, -8.13934281e-02f, -2.77251247e-02f, 2.53629088e-01f, 3.87547344e-01f, 1.83743387e-01f, 7.92260692e-02f, 4.48047332e-02f,
  -1.35293990e-01f, -1.67677194e-01f, -9.61942002e-02f, 5.34506403e-02f, 1.94266304e-01f, 8.70854259e-02f, 2.17141248e-02f, 1.01415634e-01f, 2.88158029e-01f, 4.86324765e-02f,
  -9.36191827e-02f, -9.05807391e-02f, -2.65072044e-02f, 1.13650821e-02f, -2.10353270e-01f, -1.99876919e-01f, -1.11654580e-01f, -1.70869529e-01f, -1.78136285e-02f, -2.02755168e-01f,
  6.35573715e-02f, 1.18448928e-01f, 4.28245924e-02f, -1.47246331e-01f, -1.83197603e-01f, 5.58406860e-02f, 4.20489162e-02f, -1.01810433e-01f, -5.78333326e-02f, -9.23861749e-03f,
  2.97254580e-03f, -6.34837672e-02f, -5.76830506e-02f, -5.23349233e-02f, -4.05280180e-02f, 1.82224978e-02f, 4.37642038e-02f, 8.14080611e-02f, 1.93179809e-02f, -2.50345990e-02f,
  -2.06849933e-01f, -3.92047921e-03f, 8.50793198e-02f, 7.82909766e-02f, 9.38686505e-02f, 2.25109830e-02f, -4.79801297e-02f, -1.63493715e-02f, 1.23452917e-01f, -9.68799964e-02f,
  -1.60681736e-02f, -1.30059654e-02f, -1.76241621e-03f, -1.50381997e-02f, 7.01485500e-02f, -6.53401949e-03f, 5.41456342e-02f, -6.63422644e-02f, 5.18213026e-02f, -2.03255881e-02f,
  2.63418518e-02f, -1.66489594e-02f, -8.82493239e-03f, -2.21466757e-02f, -7.72733055e-03f, -5.30597568e-02f, 4.30818312e-02f, -7.15179220e-02f, 1.62418522e-02f, -3.53725739e-02f,
  1.33029493e-02f, 6.45852536e-02f, -8.97658616e-03f, -4.34638895e-02f, -2.00377870e-02f, -8.84134509e-03f, 2.24905461e-02f, -8.31389800e-02f, 4.88060452e-02f, -3.08599509e-02f,
  -6.87502027e-02f, -6.68125823e-02f, 9.22208503e-02f, 7.66315237e-02f, 5.39577417e-02f, -4.99684252e-02f, -4.74671759e-02f, -1.70622524e-02f, -3.35938367e-03f, 4.74816822e-02f,
  7.28852898e-02f, 1.04917750e-01f, -3.00055067e-03f, -1.67894475e-02f, 9.02601257e-02f, 9.09217075e-02f, -3.53481509e-02f, -1.93435978e-03f, 1.23039074e-02f, -6.17257506e-03f,
  -5.87019213e-02f, 1.47267580e-01f, 2.05717847e-01f, 1.17746577e-01f, 8.19244236e-02f, 9.69653130e-02f, 1.52221262e-01f, 1.27794504e-01f, 2.56031364e-01f, 2.16354072e-01f,
  -1.95159465e-01f, -1.23345919e-01f, -2.95911240e-03f, 4.34550978e-02f, 1.92060173e-01f, 5.00988588e-02f, -9.15973112e-02f, -3.49138975e-02f, -2.72285696e-02f, 4.17571813e-02f,
  2.48782769e-01f, 1.04507931e-01f, -2.22158954e-02f, -9.59078688e-03f, -1.49988398e-01f, -7.81474113e-02f, -1.37234509e-01f, -1.70110211e-01f, -1.13903314e-01f, 8.02072808e-02f,
  -2.24578921e-02f, -5.70498854e-02f, -6.08457960e-02f, -1.82123840e-01f, 2.69687641e-02f, -7.63260350e-02f, -5.14003681e-03f, -6.14213012e-02f, 2.84755952e-04f, -2.04499364e-01f,
  5.43159135e-02f, 2.05836013e-01f, -2.28966735e-02f, 8.58270824e-02f, 1.24842614e-01f, -1.18191771e-01f, 4.45346870e-02f, 4.20502499e-02f, 4.74019088e-02f, -4.99558933e-02f,
  7.73162097e-02f, 2.25518458e-02f, 1.02786981e-01f, -1.85467228e-02f, -1.21955927e-02f, -1.09473355e-01f, -1.06821552e-01f, -1.12852409e-01f, -7.68928006e-02f, -2.03819368e-02f,
  4.17739265e-02f, 9.04775187e-02f, 7.50374496e-02f, 2.51791105e-02f, 1.57944916e-04f, 1.22184522e-01f, 6.04024455e-02f, -1.34559169e-01f, -1.41630858e-01f, -3.00271958e-01f,
  -7.67756253e-02f, 5.24793975e-02f, 5.29156253e-02f, -8.01352710e-02f, -9.38454177e-03f, 1.71290282e-02f, 6.35445565e-02f, 1.15206689e-02f, -4.09153178e-02f, -8.24763328e-02f,
  2.98915729e-02f, 2.36256067e-02f, 4.57701012e-02f, -5.04353121e-02f, 4.32884246e-02f, 1.86085813e-02f, 2.22536009e-02f, -5.49790189e-02f, 7.49351308e-02f, 3.88030261e-02f,
  -1.34675705e-03f, 1.54650528e-02f, -1.54472422e-02f, -1.10607492e-02f, 2.68555135e-02f, -3.61539051e-02f, 2.49635205e-02f, 3.47881652e-02f, 2.41003167e-02f, 1.95245910e-02f,
  -1.38546199e-01f, 1.64350957e-01f, -7.82053098e-02f, 4.06866753e-03f, 1.93757266e-02f, 2.06875447e-02f, 1.77178271e-02f, 1.53403007e-03f, 1.60724297e-01f, -3.10602505e-02f,
  7.76601583e-02f, 2.09187828e-02f, 2.92600282e-02f, -2.21710000e-02f, 1.83381569e-02f, 6.34405389e-02f, 1.95952244e-02f, 2.14852411e-02f, -1.21977879e-02f, -6.57660291e-02f,
  -8.12338144e-02f, -1.60611659e-01f, -9.08064395e-02f, -3.81469056e-02f, -7.25571364e-02f, 1.83339827e-02f, -1.56486779e-01f, -5.85609749e-02f, -1.68756932e-01f, -4.09285635e-01f,
  -9.96025205e-02f, -8.44181627e-02f, 1.05923802e-01f, 2.49079708e-02f, 1.65861085e-01f, -6.67389333e-02f, -1.04283281e-01f, -2.67066695e-02f, 6.26079217e-02f, -8.44356716e-02f,
  -1.13981478e-01f, -6.69654235e-02f, -1.65076870e-02f, 2.50474531e-02f, -1.46392137e-01f, -1.08175322e-01f, 1.33242518e-01f, -2.59371158e-02f, -5.26550487e-02f, 6.86864778e-02f,
  1.46280140e-01f, 9.87934694e-02f, -3.17242444e-02f, 7.26941898e-02f, 1.99701309e-01f, 1.68070376e-01f, 5.09842746e-02f, 6.23250231e-02f, -9.08492506e-03f, 2.23663986e-01f,
  3.15903015e-02f, -1.52930850e-02f, 8.22078511e-02f, 3.67277209e-03f, 1.02937713e-01f, -3.75893787e-02f, 2.45758742e-02f, -6.13588281e-02f, -4.67926636e-02f, -4.08418551e-02f,
  9.52505693e-02f, -3.17829885e-02f, 4.61911187e-02f, 2.48261504e-02f, 4.44740243e-02f, -7.72920549e-02f, -4.26521339e-02f, -3.38437669e-02f, 1.93548538e-02f, -8.19049962e-03f,
  3.77283543e-02f, 1.09192714e-01f, -1.38628008e-02f, -8.17551091e-02f, -7.86696747e-02f, 3.73204313e-02f, 3.71018564e-03f, 8.94846022e-02f, -6.67421296e-02f, -1.14668282e-02f,
  -4.38045114e-02f, 5.15738688e-02f, 2.79334057e-02f, -2.59007048e-02f, 2.00480763e-02f, -2.81828735e-03f, -3.29667777e-02f, 3.89104299e-02f, -3.29038128e-02f, 1.60416495e-02f,
  -5.18386588e-02f, -4.13464382e-02f, 7.03476276e-03f, -5.71054071e-02f, 6.19160794e-02f, 5.75641170e-02f, 2.22916529e-02f, 1.95587128e-02f, -2.49716267e-02f, 5.17802015e-02f,
  1.51398592e-02f, 2.48732157e-02f, 4.90112267e-02f, 7.36645982e-02f, -8.93718079e-02f, -1.95657630e-02f, 6.91954140e-03f, -7.66340792e-02f, -1.96094122e-02f, 1.15540018e-02f,
  6.42526299e-02f, -1.05712950e-01f, 4.81856912e-02f, 1.19766938e-02f, 4.06181440e-03f, 6.95662349e-02f, 8.49804208e-02f, 3.95683572e-02f, 7.73214474e-02f, 6.56397045e-02f,
  -9.85857397e-02f, 2.20627487e-02f, 1.97597351e-02f, -8.21079966e-03f, -6.40071109e-02f, -6.78983983e-03f, -7.49079809e-02f, -2.87559293e-02f, -3.83833423e-02f, 2.50812974e-02f,
  1.14824250e-02f, -4.89066392e-02f, 1.69379245e-02f, -9.80953798e-02f, 4.35434580e-02f, -1.26384974e-01f, -1.00359522e-01f, -4.46328521e-02f, -2.46539749e-02f, -1.29021313e-02f,
  3.86541396e-01f, -4.36799452e-02f, -1.26794784e-03f, 8.99853110e-02f, -1.65683478e-01f, -1.79187298e-01f, -1.47285491e-01f, -3.75480913e-02f, 1.22171171e-01f, -8.61600861e-02f,
  -1.48492083e-01f, 4.29675588e-03f, -1.92387972e-03f, -1.73455719e-02f, 1.14992626e-01f, -3.64419334e-02f, 7.42541030e-02f, 3.00260261e-02f, 1.29361406e-01f, 5.73847555e-02f,
  -5.88092320e-02f, 6.73569143e-02f, 1.31114960e-01f, 2.63020787e-02f, 3.21751013e-02f, 4.36426401e-02f, 3.95802818e-02f, 3.74703519e-02f, -6.13387972e-02f, -2.78423019e-02f,
  4.67031375e-02f, 9.21840444e-02f, 9.28134322e-02f, -7.32161328e-02f, -1.23569831e-01f, -4.01053727e-02f, -5.40026315e-02f, 1.13049440e-01f, -4.73991334e-02f, 4.14894475e-03f,
  -2.77532991e-02f, -4.17886265e-02f, 4.42032330e-02f, -5.92781929e-03f, -6.13949858e-02f, 3.88060473e-02f, -1.16968960e-01f, 4.16486263e-02f, -2.18096133e-02f, -6.36669025e-02f,
  -7.79737681e-02f, -1.17668264e-01f, -1.17308060e-02f, -3.31178047e-02f, 3.06655746e-02f, 7.49636963e-02f, 2.93473005e-02f, -3.36239929e-03f, -3.19425226e-03f, 1.56339660e-01f,
  2.67737992e-02f, -1.64010026e-03f, -2.86847949e-02f, 6.68603703e-02f, 5.28224446e-02f, -2.27571279e-02f, -4.57696654e-02f, -1.75066758e-02f, -6.77080005e-02f, 5.66644035e-02f,
  -4.63458635e-02f, 1.26686050e-02f, 3.36851552e-02f, 1.06879314e-02f, 3.21219787e-02f, -1.01312660e-01f, 3.97017114e-02f, -5.55651262e-03f, -4.93850373e-02f, -5.81116937e-02f,
  5.71423508e-02f, 6.46660896e-03f, 6.80710748e-02f, 3.68829146e-02f, -4.18786108e-02f, -3.64570990e-02f, 2.49170070e-03f, -2.29091756e-02f, -6.18941635e-02f, -6.50981739e-02f,
  1.68080106e-01f, -6.35664016e-02f, 1.85592353e-01f, 1.03401497e-01f, 7.88387260e-04f, 4.67661694e-02f, 1.20792603e-02f, -4.44788523e-02f, -1.11178504e-02f, 6.42073229e-02f,
  -7.35706538e-02f, 1.72435101e-02f, 2.58876644e-02f, -3.10730133e-02f, 9.17934999e-03f, -6.28897222e-03f, -5.47512211e-02f, 6.04444742e-02f, -7.09953606e-02f, -1.04494952e-01f,
  -1.33475870e-01f, 2.10502855e-02f, 1.62615106e-01f, 6.65379316e-02f, 4.54288498e-02f, 9.95960981e-02f, 1.32264212e-01f, 1.04789808e-01f, 4.59751822e-02f, 9.68891829e-02f,
  5.02635598e-01f, 3.72519493e-01f, 1.90676317e-01f, 1.13439798e-01f, 7.38422852e-03f, 6.32040948e-02f, 1.80468023e-01f, -3.59670892e-02f, -3.87700908e-02f, 2.20786884e-01f,
  5.55723021e-03f, -4.49964851e-02f, -3.06841321e-02f, -1.06544271e-01f, 1.38179900e-03f, 1.00352541e-01f, -1.41844703e-02f, -4.34908532e-02f, -1.66449144e-01f, -9.70709026e-02f,
  -1.82534933e-01f, -2.04010494e-02f, 5.59887774e-02f, 1.08741866e-02f, -3.38909291e-02f, -1.35009781e-01f, 4.63170968e-02f, -2.29411367e-02f, -1.08308531e-01f, 3.38092558e-02f,
  1.55716106e-01f, 8.26202184e-02f, -1.01564944e-01f, -5.36168925e-03f, -3.44140343e-02f, -8.72987881e-03f, 7.18876347e-02f, -9.56198946e-03f, 3.17924470e-02f, -8.49003159e-03f,
  -6.81474283e-02f, 2.69937180e-02f, -4.25473750e-02f, -8.70791003e-02f, 8.66766423e-02f, -9.90094841e-02f, 8.30842182e-03f, 1.60908923e-02f, -2.26412974e-02f, -6.75212368e-02f,
  -9.34359804e-02f, 1.15807176e-01f, 9.19092968e-02f, -3.26099321e-02f, -1.15669616e-01f, -1.71989858e-01f, -6.54429272e-02f, -1.69443697e-01f, 1.90055314e-02f, 1.39074162e-01f,
  -6.74332827e-02f, 1.99415609e-02f, 2.52631940e-02f, -5.93822002e-02f, 1.93267073e-02f, -3.21996175e-02f, -3.53813618e-02f, -8.84679705e-03f, -1.23747690e-02f, 2.26924568e-02f,
  1.85632203e-02f, -4.98071797e-02f, 1.35085834e-02f, 8.20013732e-02f, -1.68697827e-03f, 8.18912685e-02f, -3.75725590e-02f, 5.90669736e-02f, 5.52324951e-02f, 2.86090616e-02f,
  -6.47127330e-02f, -5.69003038e-02f, 3.62739451e-02f, -3.33450250e-02f, -3.34557630e-02f, 3.78246158e-02f, 6.43855054e-03f, -9.03912857e-02f, -2.96945926e-02f, 8.26703086e-02f,
  1.97739184e-01f, 2.47728862e-02f, 8.91382340e-03f, -1.22179873e-01f, 1.01667203e-01f, 1.12921251e-02f, -2.70651262e-02f, -1.18536614e-02f, 3.75230275e-02f, 5.23591600e-02f,
  -3.58844288e-02f, 5.68740144e-02f, 1.13562435e-01f, -4.23291959e-02f, 1.76936034e-02f, -2.41174363e-02f, 4.41207886e-02f, -2.27924436e-02f, -2.62954328e-02f, 3.25971395e-02f,
  -2.85812393e-02f, 1.41624004e-01f, 1.84532076e-01f, 6.38540881e-03f, -1.08902352e-02f, 8.90280530e-02f, 7.96664134e-02f, 2.10888553e-02f, 1.70093477e-01f, 3.13560724e-01f,
  1.16217554e-01f, -4.29726988e-02f, 1.34223655e-01f, 9.78112519e-02f, -1.98462140e-02f, -1.04222268e-01f, -1.25347584e-01f, -1.31648898e-01f, 6.04344681e-02f, 1.26879051e-01f,
  3.89936157e-02f, 8.83436110e-03f, 1.15154786e-02f, -3.17947194e-02f, -5.71375107e-03f, 1.21155247e-01f, 1.40735328e-01f, -8.24807584e-03f, 2.83574685e-02f, 4.32578251e-02f,
  6.10519014e-02f, -6.80243736e-03f, 3.62677202e-02f, 7.64926821e-02f, 2.72114187e-01f, 1.79724261e-01f, 1.72460482e-01f, 2.70946715e-02f, 1.75623968e-01f, 3.76437247e-01f,
  3.42020452e-01f, -1.27815709e-01f, -5.22380695e-02f, -4.48370576e-02f, 4.55060191e-02f, 1.60083324e-02f, -4.20225896e-02f, 1.53375193e-02f, -3.00953630e-02f, 7.37102777e-02f,
  4.97280015e-03f, 1.34620257e-02f, 8.17855299e-02f, -5.72902299e-02f, 1.91876423e-02f, 2.87915468e-02f, -5.22700548e-02f, -6.56833500e-02f, 8.34286585e-03f, -7.30962381e-02f,
  1.49184642e-02f, -6.55855760e-02f, -3.37820128e-03f, 4.72202040e-02f, -3.32484804e-02f, 6.72080666e-02f, 5.15713869e-03f, 1.56759191e-02f, -9.27403048e-02f, 2.58504272e-01f,
  5.50707243e-02f, 7.62928426e-02f, -8.76597688e-02f, -5.93049824e-02f, 1.36117665e-02f, -3.98369022e-02f, 6.98732138e-02f, 2.26985365e-02f, 3.26383188e-02f, -1.43685052e-02f,
  4.34958525e-02f, -1.06465861e-01f, 1.30104460e-02f, 5.62958308e-02f, 7.27981105e-02f, 5.90133481e-03f, -3.79514210e-02f, 4.80824262e-02f, 2.72372067e-02f, 1.78350098e-02f,
  4.98160012e-02f, -3.16215791e-02f, 3.01879011e-02f, -2.62552965e-02f, 1.17104864e-02f, 7.76050463e-02f, 8.23675543e-02f, 1.25959460e-02f, -8.38731825e-02f, -8.25978816e-02f,
  1.72549516e-01f, -3.53492081e-01f, 8.37619379e-02f, -1.80030614e-02f, 5.70947081e-02f, -2.82412805e-02f, 1.69654600e-02f, -2.64896266e-02f, -9.78279039e-02f, 5.14185056e-02f,
  -6.60920888e-02f, 4.38657403e-02f, 7.70352408e-02f, 5.79303540e-02f, 4.69986163e-02f, 3.06319539e-03f, 4.73405533e-02f, 8.80269036e-02f, -8.03326294e-02f, -1.04471758e-01f,
  -3.87454405e-02f, 1.01482712e-01f, 5.43857813e-02f, 6.27674237e-02f, -5.09094782e-02f, -2.01034211e-02f, 5.65297082e-02f, 1.17729366e-01f, 3.19698267e-02f, 2.34675586e-01f,
  -4.71836999e-02f, -7.37288147e-02f, -3.16943705e-01f, -1.62664965e-01f, -1.29852787e-01f, -5.98070137e-02f, -2.07131788e-01f, -1.17884278e-01f, -8.05443600e-02f, -6.49268255e-02f,
  2.41155237e-01f, 1.42642722e-01f, 1.28206491e-01f, 8.15396942e-03f, -1.11466520e-01f, -2.60714352e-01f, -3.18316579e-01f, -2.53630221e-01f, -1.02082148e-01f, 8.73984490e-03f,
  -1.00297362e-01f, -5.72752431e-02f, -1.40095994e-01f, -4.35679369e-02f, 1.26617067e-02f, -1.93821993e-02f, -1.39884233e-01f, -6.86485693e-02f, 6.92254305e-02f, -1.51688978e-01f,
  2.36380592e-01f, 1.98154673e-02f, -6.92205131e-02f, -3.50545198e-02f, 7.36736879e-02f, 1.06402576e-01f, -3.81113705e-03f, -7.89943859e-02f, 9.32418276e-03f, 1.63780618e-02f,
  4.63860147e-02f, 8.70292485e-02f, 3.69827189e-02f, 7.06664771e-02f, 2.57697068e-02f, 9.95365232e-02f, -9.69688669e-02f, -7.92414472e-02f, -5.93356974e-02f, 1.07253104e-01f,
  9.17355791e-02f, -2.40632650e-02f, 2.01211553e-02f, -3.27951834e-02f, 1.00667896e-02f, 1.52960028e-02f, 7.44956285e-02f, 9.06409398e-02f, -1.22574819e-02f, -3.88172572e-03f,
  2.40517271e-04f, -3.82875465e-03f, -7.81219080e-02f, 8.59545171e-02f, -4.05925028e-02f, 1.61958300e-02f, 8.54213629e-03f, -6.45875856e-02f, 1.11600012e-02f, 7.78653547e-02f,
  -4.45470139e-02f, -3.52723859e-02f, 3.22280228e-02f, -5.27051948e-02f, -4.14285921e-02f, -3.75000089e-02f, -4.21952717e-02f, -5.26077710e-02f, -5.38233928e-02f, 7.34137222e-02f,
  -9.87019204e-03f, 3.47955488e-02f, 5.25135919e-02f, 2.13723704e-02f, 2.83513200e-02f, 2.50668954e-02f, 1.05740046e-02f, 4.65097371e-04f, 3.28784212e-02f, -1.22017868e-01f,
  1.20400213e-01f, -4.42686938e-02f, 6.20565638e-02f, -4.46700351e-03f, -6.09971881e-02f, 8.10445473e-02f, 1.00376993e-01f, -9.67838466e-02f, 3.65284272e-02f, -4.01693135e-02f,
  3.21728438e-02f, 6.49683625e-02f, -3.30145247e-02f, 9.58879665e-03f, -5.24439998e-02f, -4.72021922e-02f, -7.40610361e-02f, -3.72277386e-02f, -4.01763096e-02f, 4.05567437e-02f,
  -9.69425868e-03f, -1.26851425e-01f, -8.34927484e-02f, -6.53512925e-02f, 8.76393542e-02f, -1.80199668e-02f, -5.59074047e-04f, -4.51454520e-02f, -6.21584505e-02f, -1.95559844e-01f,
  1.00359112e-01f, -1.32482067e-01f, -9.70943645e-02f, 8.57602954e-02f, -7.74048939e-02f, -7.82690123e-02f, -7.47926533e-05f, 1.38829231e-01f, 9.25697535e-02f, -1.19040735e-01f,
  -5.54237179e-02f, -7.16462433e-02f, -3.86171741e-03f, -2.90722586e-02f, 2.37146281e-02f, 7.95618296e-02f, 3.46365683e-02f, 1.17045328e-01f, 1.58335865e-01f, 1.40372962e-01f,
  9.87086892e-02f, 1.07250065e-01f, 1.14734292e-01f, 3.25999185e-02f, 1.47136888e-02f, 4.79690470e-02f, -4.42812359e-03f, 3.14283632e-02f, -1.09794520e-01f, 3.77832130e-02f,
  -2.62357712e-01f, -4.64883111e-02f, 1.04120091e-01f, -1.49963852e-02f, -9.93832201e-02f, 4.93330285e-02f, 6.30471632e-02f, 2.84759998e-02f, -4.79258597e-02f, 6.79313093e-02f,
  -1.49455052e-02f, 4.61157179e-03f, -3.88025008e-02f, -2.53427103e-02f, 7.77195469e-02f, 7.45501090e-03f, 1.33261740e-01f, 3.77989113e-02f, 1.20886639e-01f, 7.87754264e-03f,
  5.61303040e-03f, -9.96119604e-02f, 1.92685053e-02f, 1.93988159e-02f, -2.29009949e-02f, -3.76910679e-02f, 5.00654913e-02f, -5.30793145e-02f, -8.99625767e-04f, 8.95470381e-02f,
  -6.98778313e-03f, 7.21592456e-02f, -3.02342717e-02f, -2.52753142e-02f, -2.55652685e-02f, 9.18574408e-02f, -1.83284108e-03f, -2.03811619e-02f, 1.46819819e-02f, 1.31790191e-02f,
  5.83388917e-02f, -6.85526431e-02f, -3.30228694e-02f, -6.96739480e-02f, -8.93726051e-02f, -4.35091965e-02f, -3.14710252e-02f, -3.21763121e-02f, 6.41749725e-02f, 7.50627322e-03f,
  -4.76406664e-02f, -5.75331375e-02f, 1.23366220e-02f, -7.07458854e-02f, 8.29971954e-02f, 1.91728037e-03f, -6.14486970e-02f, -2.40388345e-02f, -5.91159835e-02f, -1.01055734e-01f,
  -1.70239788e-02f, -7.83065110e-02f, -5.97235672e-02f, 4.17960584e-02f, -5.55021279e-02f, -3.52137163e-02f, -1.14127509e-01f, -5.16688973e-02f, -8.71653110e-02f, 5.18692769e-02f,
  -6.52126372e-02f, -4.59852256e-02f, -2.16774195e-02f, -1.46320346e-03f, -2.93667484e-02f, 3.46840620e-02f, -6.94219843e-02f, 1.04755175e-03f, 5.85554540e-03f, -3.58436629e-02f,
  -7.74557963e-02f, 3.69488411e-02f, -7.11693093e-02f, 6.12725019e-02f, 3.15009654e-02f, -1.11889720e-01f, 1.94457755e-03f, 7.35543147e-02f, 6.33000210e-02f, 7.27066323e-02f,
  -9.06287953e-02f, -1.83596030e-01f, -8.01464170e-02f, 2.50383634e-02f, 2.15977564e-01f, 2.69345284e-01f, 1.01065427e-01f, 1.17111817e-01f, 7.52952844e-02f, -7.97081813e-02f,
  3.11340131e-02f, 3.09216119e-02f, 9.96656045e-02f, -4.72779535e-02f, 6.98820800e-02f, -1.01304509e-01f, 1.58907678e-02f, -3.06627657e-02f, 4.89204936e-02f, 1.56209454e-01f,
  1.37098089e-01f, 1.24904728e-02f, -4.09555845e-02f, -7.82843530e-02f, -1.49432721e-03f, 1.22395299e-01f, -7.42100924e-02f, -6.95066601e-02f, -1.46795392e-01f, -2.37138167e-01f,
  -6.21001236e-02f, -2.16291219e-01f, 8.51572156e-02f, 1.40745228e-03f, -1.25887133e-02f, -1.15125611e-01f, 6.55192807e-02f, -6.14291020e-02f, -3.85158211e-02f, -6.21657558e-02f,
  -6.53504278e-04f, -1.03490822e-01f, -3.39902379e-02f, -9.90190264e-03f, 1.67586990e-02f, -6.12520725e-02f, -1.03910543e-01f, -1.61362067e-01f, -9.34976563e-02f, -1.25763476e-01f,
  1.05070069e-01f, 9.20811892e-02f, 4.52323742e-02f, -3.46204489e-02f, -1.93077959e-02f, 7.14302883e-02f, -9.04245526e-02f, -3.56226973e-02f, -8.86303261e-02f, -9.13529620e-02f,
  7.49212801e-02f, -4.55413684e-02f, -2.57537663e-02f, -3.49944946e-03f, 6.69529364e-02f, -1.47147682e-02f, 4.95475344e-02f, 7.10619017e-02f, 4.42185998e-02f, -1.50714936e-02f,
  -3.67529243e-02f, -1.51330903e-02f, 9.59843490e-03f, -5.86620420e-02f, 1.03876935e-02f, -2.61710933e-03f, -2.74463203e-02f, -4.08868454e-02f, 1.88803878e-02f, -1.10190839e-01f,
  -2.65368950e-02f, -1.86419848e-03f, 1.54263051e-02f, -5.66779114e-02f, 2.27451883e-02f, 3.17930058e-02f, 2.62002125e-02f, 6.94849417e-02f, -2.62160636e-02f, 4.39124592e-02f,
  1.54138058e-01f, 1.40764222e-01f, -4.51608971e-02f, 2.37513725e-02f, -5.16313761e-02f, -3.84493060e-02f, -2.74225633e-04f, 1.76457781e-02f, 5.45882434e-03f, -2.66509480e-03f,
  1.03451284e-02f, -5.87164611e-02f, 1.73952244e-02f, -5.31812720e-02f, 4.58765477e-02f, 9.22950581e-02f, 3.07366978e-02f, 6.69990554e-02f, 1.05081365e-01f, -2.96258070e-02f,
  5.47851175e-02f, 1.19142957e-01f, 1.73113540e-01f, 1.87670648e-01f, -4.33732197e-02f, 2.54067898e-01f, 1.31666154e-01f, 7.49245882e-02f, 1.24880940e-01f, 1.36064962e-01f,
  -1.20157875e-01f, -1.37706235e-01f, -2.61194795e-01f, -7.83806518e-02f, -1.03667431e-01f, -2.28195608e-01f, -2.14223042e-01f, -1.23333812e-01f, 2.49271514e-03f, -1.00815229e-01f,
  1.06462345e-01f, 2.24877432e-01f, -1.76018267e-03f, 5.65038696e-02f, -9.04507786e-02f, -3.42543334e-01f, -3.55717897e-01f, -2.37863526e-01f, -8.22924972e-02f, -1.34992907e-02f,
  4.19968087e-03f, -1.06362678e-01f, -1.63160264e-02f, -1.12244911e-01f, -3.32899503e-02f, -6.59671277e-02f, -1.07901514e-01f, -1.56523839e-01f, -2.00862676e-01f, -2.60190696e-01f,
  -1.63767904e-01f, -1.30381836e-02f, 4.85827364e-02f, 8.17029998e-02f, 3.46498899e-02f, 4.93116379e-02f, 6.74957410e-02f, -3.25455032e-02f, 5.19024171e-02f, -5.96931987e-02f,
  6.98422641e-02f, 1.16630279e-01f, 7.11795539e-02f, 1.00477058e-02f, 6.02660794e-03f, -1.93438437e-02f, -1.26652151e-01f, -1.39676124e-01f, -1.43161472e-02f, -5.13112657e-02f,
  -4.13702242e-03f, 2.10895613e-02f, -2.16400698e-02f, -5.08968011e-02f, 2.82761436e-02f, 1.07117616e-01f, 1.39017887e-02f, -8.81808922e-02f, -6.42685294e-02f, -1.71939880e-01f,
  -6.75234571e-02f, 4.67320234e-02f, 2.67222635e-02f, 1.16138691e-02f, 2.53684279e-02f, 2.58152504e-02f, -6.27198741e-02f, -9.02910996e-03f, -1.20000876e-02f, -8.51118471e-03f,
  2.69794594e-02f, -5.66611476e-02f, 4.84692082e-02f, -1.28542587e-01f, 3.26351523e-02f, -2.45020445e-02f, -2.59336513e-02f, -2.71075051e-02f, -1.10959951e-02f, -1.60144232e-02f,
  -2.68856939e-02f, 6.00678846e-02f, 8.07857700e-03f, 3.88709158e-02f, -4.13285904e-02f, -2.27265637e-02f, 3.36315371e-02f, -2.26868205e-02f, 6.88186288e-02f, -3.93862613e-02f,
  1.69083327e-01f, 1.27873674e-01f, -4.04142309e-03f, -7.97926933e-02f, -2.86769699e-02f, 4.18158360e-02f, 1.09771611e-02f, -1.95902046e-02f, 1.40225440e-01f, -4.71586287e-02f,
  6.20880686e-02f, -5.05375303e-02f, 2.42078751e-02f, -2.85782591e-02f, -2.20074807e-03f, -6.62354976e-02f, -4.78493832e-02f, 1.53428316e-02f, 5.66333421e-02f, 1.61592383e-02f,
  -9.36454311e-02f, 1.54344663e-02f, -6.28224909e-02f, 2.32971348e-02f, 2.68693808e-02f, 4.89544421e-02f, -2.26899777e-02f, 2.69846171e-02f, -2.50369981e-02f, -1.59333795e-01f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.81232566e-01f, -2.77572926e-02f, -4.80815656e-02f, -2.28051051e-01f, 2.27205399e-02f, 7.57456049e-02f, 1.78018704e-01f, 6.76762015e-02f, -1.46305442e-01f, -1.26009509e-01f,
  -8.08471814e-02f, -1.82724401e-01f, -1.83605701e-01f, -1.09385833e-01f, 4.00115065e-02f, 8.73891041e-02f, -2.02171523e-02f, -2.78913490e-02f, -1.33954167e-01f, -4.77758422e-02f,
  -6.58517890e-03f, -1.61649257e-01f, -9.52500701e-02f, -1.00071877e-01f, -1.94450021e-01f, -1.97268844e-01f, -9.33763757e-02f, -1.89469427e-01f, 1.96565446e-02f, -1.25087544e-01f,
  -1.06793426e-01f, 3.78084108e-02f, -3.35110016e-02f, -6.49750531e-02f, -9.28535163e-02f, -1.75598115e-02f, -3.80484872e-02f, -4.70803119e-02f, 3.10662761e-02f, 5.51946275e-03f,
  5.08258678e-02f, 4.25597355e-02f, -1.75520871e-02f, 1.92741845e-02f, -9.26044509e-02f, 1.04529299e-02f, -5.32340221e-02f, 2.79333256e-03f, 6.93954974e-02f, 1.25570610e-01f,
  7.49153793e-02f, 8.51351768e-02f, -3.63091864e-02f, 1.31294280e-01f, 7.14708567e-02f, -1.73970889e-02f, -7.28002936e-02f, 1.06923491e-01f, 7.70094618e-02f, 1.28014190e-02f,
  9.68595967e-02f, 6.89462200e-02f, -9.27075092e-03f, 4.39559035e-02f, -3.95972915e-02f, 3.21877301e-02f, 3.68357897e-02f, 4.46612984e-02f, 7.24609941e-02f, -4.45917808e-02f,
  7.07221851e-02f, 7.55275339e-02f, -5.51572032e-02f, -2.67431792e-02f, -7.88207501e-02f, -3.55051942e-02f, 6.73473105e-02f, 5.67859299e-02f, -3.19846794e-02f, -7.40611404e-02f,
  1.81951746e-02f, -8.21665525e-02f, -1.00773079e-02f, -2.84919068e-02f, -4.06389348e-02f, 1.39965657e-02f, 8.07608590e-02f, -1.25382571e-02f, -2.44328640e-02f, 1.47968680e-02f,
  -1.11940846e-01f, 2.11778477e-01f, -6.48240224e-02f, -9.93877053e-02f, -6.51256070e-02f, 1.01944849e-01f, -3.80195938e-02f, 7.71008357e-02f, 1.76926069e-02f, -4.91195135e-02f,
  5.46579808e-02f, -7.03338832e-02f, -9.04920474e-02f, -5.20490482e-02f, -1.04618490e-01f, -5.60941510e-02f, -6.74720332e-02f, -4.20544818e-02f, 2.53972728e-02f, -1.54507365e-02f,
  3.31585743e-02f, 1.24277785e-01f, 6.19717464e-02f, 6.20664060e-02f, 4.07903083e-02f, 6.00455478e-02f, 7.27178007e-02f, 7.19904825e-02f, -1.69292931e-02f, -9.81504470e-02f,
  -8.44626352e-02f, -1.02874301e-01f, 1.49068549e-01f, 4.65691313e-02f, 1.33321851e-01f, 4.23064679e-02f, 1.09023210e-02f, -7.32230544e-02f, -4.05043028e-02f, -9.36900824e-02f,
  3.59563008e-02f, -2.80716289e-02f, -5.19291274e-02f, -2.26312801e-02f, -6.29268661e-02f, 1.94701273e-02f, 3.63534242e-02f, 5.44199608e-02f, 1.92029383e-02f, -7.58606009e-03f,
  -5.59624471e-02f, -2.77927960e-03f, -6.71535730e-02f, -2.13139858e-02f, 2.33514048e-02f, -4.20558937e-02f, -4.40991372e-02f, -6.02672473e-02f, -1.11121014e-02f, -1.81701686e-02f,
  8.77656862e-02f, -1.03504188e-01f, -3.19040716e-02f, 2.64359023e-02f, -1.45303058e-02f, 1.76763460e-02f, 8.26823488e-02f, -9.28298756e-02f, -1.12471275e-01f, -6.98091602e-03f,
  -8.86702910e-02f, -1.51497833e-02f, 5.74982446e-03f, -7.15068132e-02f, -2.51842085e-02f, -2.66054664e-02f, -2.46032514e-02f, 8.03600177e-02f, -7.91914091e-02f, 6.82090130e-03f,
  -4.26744521e-02f, 6.20397069e-02f, 7.57290125e-02f, 9.75630246e-03f, -4.44251392e-03f, -6.17496930e-02f, -8.96330699e-02f, 7.23123774e-02f, 8.18794966e-02f, -9.89826303e-03f,
  8.00031349e-02f, -7.06373304e-02f, -6.21943586e-02f, 4.75656847e-03f, -2.23952923e-02f, 2.22031563e-03f, 2.43528169e-02f, 4.53691706e-02f, 1.30372914e-02f, 4.08344455e-02f,
  2.78492607e-02f, 6.64105788e-02f, 1.55264083e-02f, 1.74836593e-03f, -8.29273239e-02f, 1.39854839e-02f, -4.47375663e-02f, -3.85873183e-03f, 1.74241629e-03f, 6.40220195e-02f,
  -4.05419022e-02f, 3.15016061e-02f, -9.76237059e-02f, -4.42730561e-02f, -6.90007284e-02f, -7.30561614e-02f, -8.21732581e-02f, -2.78898589e-02f, 6.91121863e-03f, -1.44329499e-02f,
  -6.73995772e-03f, 1.07153304e-01f, 1.14703178e-02f, -1.06020093e-01f, 1.41911125e-02f, 6.54833531e-03f, 5.46304546e-02f, 6.54140115e-02f, -4.04624455e-02f, 2.03752946e-02f,
  -2.44367700e-02f, 2.89270524e-02f, 1.47482064e-02f, 3.73588167e-02f, 6.75317720e-02f, -3.99645939e-02f, -9.59396921e-03f, 9.74080041e-02f, -6.58225790e-02f, -3.43032219e-02f,
  -9.20250788e-02f, 2.02965643e-02f, 7.91192949e-02f, -7.04057887e-02f, 4.32467833e-02f, 1.05055548e-01f, 3.23094614e-02f, 7.29647651e-02f, 1.21918902e-01f, -6.36355504e-02f,
  -2.39486232e-01f, -1.35752201e-01f, -2.79943645e-01f, 2.02571601e-02f, 5.80529422e-02f, 3.65439663e-03f, 5.34529388e-02f, 1.10858887e-01f, -8.11634120e-03f, -8.50916200e-04f,
  -9.01748836e-02f, -7.86333403e-04f, -9.51205716e-02f, -9.98361260e-02f, -7.41762072e-02f, -1.31695703e-01f, -1.86358497e-01f, -2.36451268e-01f, -1.56843841e-01f, 2.30325181e-02f,
  -8.56183320e-02f, -7.65337944e-02f, -2.06557706e-01f, -2.08101980e-02f, 4.79316115e-02f, -3.89507636e-02f, -9.04355794e-02f, -1.33109003e-01f, -5.46271577e-02f, -1.10379860e-01f,
  -1.02427527e-01f, 1.98297529e-03f, 4.53418680e-02f, 1.51532907e-02f, 2.79800184e-02f, -1.00292161e-01f, 7.05472659e-03f, -7.84597769e-02f, -7.38359429e-03f, 4.25623097e-02f,
  4.02312949e-02f, -4.89535630e-02f, 2.91665662e-02f, 6.62375763e-02f, 1.97474491e-02f, 4.64033894e-02f, -3.03370804e-02f, -1.39394328e-01f, -7.37615004e-02f, -5.97583763e-02f,
  -5.62582389e-02f, -1.16329648e-01f, -1.22742161e-01f, -5.65632656e-02f, -2.90804468e-02f, -2.24864241e-02f, -3.75423059e-02f, -6.68322667e-02f, 2.58890130e-02f, -1.19850457e-01f,
  7.69286007e-02f, -4.72723320e-02f, 6.26971349e-02f, -1.49354013e-02f, 1.91743989e-02f, 5.89544252e-02f, 5.78089841e-02f, -5.09113446e-02f, 3.25990207e-02f, 1.78243816e-02f,
  3.31710689e-02f, -1.37663940e-02f, -2.92650908e-02f, -6.99060038e-02f, -8.44292492e-02f, -8.95028859e-02f, -8.28352571e-02f, 2.98923664e-02f, -1.01823688e-01f, -5.65420650e-02f,
  -7.20790550e-02f, -3.96545976e-02f, 9.26091895e-02f, -5.64660169e-02f, 1.14726797e-02f, -5.85474856e-02f, 5.28736785e-02f, 9.96726379e-02f, -5.21418452e-02f, 8.43184292e-02f,
  8.54612663e-02f, -1.47863939e-01f, -1.03262961e-01f, 3.03372145e-02f, -7.57322758e-02f, -1.22052059e-02f, -3.59887048e-03f, -1.12559097e-02f, -6.49563447e-02f, -7.88183287e-02f,
  9.13503841e-02f, -6.93022385e-02f, 5.42841246e-03f, -7.33830929e-02f, -1.94773806e-04f, -5.06256707e-02f, -5.21008372e-02f, -5.81428781e-02f, -9.79552865e-02f, -4.14697304e-02f,
  -1.25034809e-01f, -4.42042127e-02f, -1.49582416e-01f, -7.81658664e-02f, -1.37917800e-02f, -1.18208893e-01f, -1.63294807e-01f, 1.07951034e-02f, -1.63377166e-01f, -1.82659283e-01f,
  -8.15419555e-02f, -6.00795820e-02f, -4.48981486e-02f, 6.79024532e-02f, -7.83306174e-03f, 6.55406341e-02f, 8.10851976e-02f, 1.11307062e-01f, 1.42200142e-01f, 1.27221733e-01f,
  6.23093992e-02f, 1.17688850e-01f, 1.25472903e-01f, 2.31898338e-01f, 1.72418073e-01f, 1.76154271e-01f, 1.04160942e-01f, 7.89008513e-02f, 8.95470455e-02f, 2.63523329e-02f,
  1.23556145e-01f, 8.48358218e-03f, 1.27169760e-02f, 7.72411674e-02f, 1.00967169e-01f, 7.65339285e-02f, 7.09507838e-02f, -7.94139802e-02f, 1.69060193e-02f, 9.32342410e-02f,
  -5.83224408e-02f, -4.98394668e-02f, 3.47595625e-02f, 6.95483014e-02f, -3.82344536e-02f, -6.66832179e-02f, 3.74683402e-02f, -5.26587777e-02f, -6.77357242e-02f, 1.29018514e-03f,
  -1.51782325e-02f, 2.75188382e-03f, -2.50774119e-02f, 1.36997141e-02f, -1.37903050e-01f, -1.13576129e-01f, 5.02703153e-02f, 1.05187319e-01f, 1.30697787e-01f, -9.15966257e-02f,
  2.04051826e-02f, -1.12997718e-01f, -7.72748888e-02f, -2.11532284e-02f, 3.58344391e-02f, 8.54315311e-02f, 3.39671262e-02f, 6.14061207e-02f, 6.15741387e-02f, -1.19223803e-01f,
  1.19566567e-01f, 4.17106524e-02f, 1.90078225e-02f, 9.63737220e-02f, 6.67363182e-02f, 9.83865112e-02f, -2.12145504e-02f, 2.99201235e-02f, -1.08374599e-02f, -7.44243264e-02f,
  -4.56105322e-02f, 7.23816454e-02f, -1.34019237e-02f, 7.46710747e-02f, 4.26174141e-02f, 6.88258633e-02f, 5.96367195e-02f, 1.13957627e-02f, -5.60044274e-02f, -4.10600379e-02f,
  -1.96269900e-02f, -2.61559300e-02f, -3.56810503e-02f, 9.91491750e-02f, -4.43193689e-02f, -1.34859839e-02f, 7.01709911e-02f, -9.01038200e-02f, 3.45842801e-02f, -7.15685338e-02f,
  1.10081034e-02f, 1.33924529e-01f, -1.23700162e-03f, 7.62503371e-02f, 2.75986586e-02f, 6.63906112e-02f, 9.57793146e-02f, -6.66676834e-02f, -6.43430129e-02f, 9.12927184e-03f,
  -6.23932406e-02f, -7.05531314e-02f, -6.56085536e-02f, -2.63152756e-02f, -1.36793088e-02f, -3.24664488e-02f, -1.07461177e-02f, 6.30421005e-03f, 9.37799811e-02f, -6.79499432e-02f,
  1.03750639e-01f, -9.15228203e-03f, -8.63750353e-02f, -2.08724458e-02f, 2.43176576e-02f, 4.40135859e-02f, -7.85567835e-02f, -3.70765068e-02f, -4.06382345e-02f, -3.76405679e-02f,
  2.02376306e-01f, -9.68195796e-02f, -1.25417605e-01f, -3.33699547e-02f, 4.60113212e-02f, 2.74106637e-02f, 2.81391423e-02f, 4.72727455e-02f, 1.15946129e-01f, -3.09541021e-02f,
  3.57089937e-02f, 1.65266842e-01f, 1.07226677e-01f, 1.37245119e-01f, 7.03527480e-02f, 1.67990532e-02f, -4.65084091e-02f, 1.25520420e-03f, 1.54723987e-01f, 7.11955279e-02f,
  -1.86726470e-02f, -3.20216902e-02f, -3.98101099e-02f, -1.01146020e-01f, -1.51233017e-01f, -5.27472645e-02f, -9.58662480e-04f, 1.48920640e-02f, -1.20737761e-01f, 5.20782545e-03f,
  -1.03253841e-01f, -5.45709208e-02f, -5.56523586e-03f, -4.89970334e-02f, 2.22697742e-02f, 5.39418794e-02f, 4.47489470e-02f, -7.72766769e-02f, -5.46126254e-02f, -1.05228007e-01f,
  -2.36294214e-02f, -9.17153247e-03f, 8.28600526e-02f, 5.13145775e-02f, 1.03221694e-03f, 7.10668340e-02f, 1.86152011e-02f, 8.53927061e-02f, 1.66663490e-02f, -4.11234796e-02f,
  -1.06809214e-01f, -1.47867054e-02f, 4.29033749e-02f, 1.43085397e-03f, 3.30129974e-02f, 5.86174838e-02f, 3.82662518e-03f, 5.11721596e-02f, 1.04229659e-01f, 1.40577815e-02f,
  1.08102197e-02f, 4.92646033e-03f, 8.47351551e-02f, 3.16989385e-02f, -1.31417308e-02f, 5.26470551e-03f, 2.64245588e-02f, 1.13362595e-02f, 6.65844232e-02f, 3.48382853e-02f,
  -5.20023704e-02f, 2.79272627e-02f, -8.16581398e-02f, -7.78605789e-03f, -7.11700916e-02f, -1.99822690e-02f, 4.74475212e-02f, 2.75295116e-02f, 1.41843408e-02f, 3.25997174e-02f,
  5.03581250e-03f, -7.63359815e-02f, 1.38188964e-02f, 1.90470479e-02f, -4.85948334e-03f, 3.55003662e-02f, -6.94966093e-02f, 5.03223054e-02f, 1.41810738e-02f, 2.82078907e-02f,
  -8.74626413e-02f, -2.54420824e-02f, 6.42826557e-02f, -1.71967410e-02f, 3.72307524e-02f, -6.54702112e-02f, 5.44235967e-02f, 1.17043834e-02f, 3.60980518e-02f, -9.76132452e-02f,
  -1.30968615e-02f, -7.62092099e-02f, -6.99127465e-02f, 9.67670605e-03f, 4.64484468e-03f, 2.47851964e-02f, 6.39669374e-02f, -6.52256161e-02f, 4.50452380e-02f, -8.58529508e-02f,
  -8.53839591e-02f, 1.00081665e-02f, 1.32077187e-01f, 5.24181053e-02f, 6.83601499e-02f, 1.35036260e-01f, -1.60816498e-02f, -3.59249040e-02f, -5.92601299e-03f, -4.03532423e-02f,
  -1.10350661e-01f, -1.25581557e-02f, -1.43682793e-01f, -1.02597035e-01f, 7.55960643e-02f, -1.30402157e-02f, 7.04820603e-02f, 1.42413527e-01f, -1.08753880e-02f, 8.00474286e-02f,
  -1.14447288e-01f, -2.35226657e-02f, -8.42246488e-02f, -6.66372553e-02f, 1.08351268e-01f, 7.39457756e-02f, 5.48396781e-02f, -5.30291349e-04f, -7.56969536e-03f, 1.03953376e-01f,
  9.22541916e-02f, -1.06580267e-02f, -4.08778153e-02f, -5.79010993e-02f, -4.20990735e-02f, -6.44627139e-02f, -1.16851009e-01f, -7.00862408e-02f, 5.30956239e-02f, 2.71365903e-02f,
  3.00255567e-02f, -1.98181972e-01f, 1.06436461e-01f, -3.31642409e-03f, -8.31566751e-02f, -1.08109355e-01f, 3.04026138e-02f, 2.22897958e-02f, -8.05993378e-02f, -2.03537401e-02f,
  -5.64559959e-02f, -9.68388394e-02f, -9.19044018e-02f, 6.28780499e-02f, 1.68441497e-02f, -4.23755795e-02f, -6.77866042e-02f, 4.61565554e-02f, 7.57205300e-03f, 4.59996946e-02f,
  -5.33987246e-02f, -6.85856268e-02f, -7.50617683e-02f, 6.57218322e-02f, 6.59390092e-02f, -5.87331355e-02f, 8.55979994e-02f, 2.00396441e-02f, -1.40136033e-02f, 5.34358285e-02f,
  -3.42806503e-02f, 5.03401197e-02f, 1.96741931e-02f, 8.51900429e-02f, 1.99225508e-02f, -4.21872698e-02f, -1.91595536e-02f, -1.53209642e-02f, 4.79816683e-02f, 5.13266400e-02f,
  8.26355368e-02f, -2.89143976e-02f, 4.47444431e-02f, 4.67360988e-02f, 1.20341200e-02f, -2.00123992e-02f, -4.02585082e-02f, 6.94728643e-02f, 5.58546074e-02f, -1.00924343e-01f,
  -5.83546795e-02f, 6.38186932e-02f, -2.72299949e-04f, -6.59121498e-02f, -1.50734466e-02f, 4.43622284e-02f, -8.77451822e-02f, -3.08230743e-02f, -7.10548535e-02f, -1.38733222e-03f,
  2.11051881e-01f, 2.16101040e-03f, -5.09710750e-03f, 6.43069297e-02f, 3.56268510e-02f, -4.79887985e-02f, -5.78556284e-02f, -3.70606892e-02f, 5.46384975e-02f, 1.00575387e-01f,
  3.39171067e-02f, 8.91821012e-02f, -2.08604392e-02f, -3.69479284e-02f, 1.01413041e-01f, 5.81660168e-03f, 3.02876849e-02f, -3.20958570e-02f, 4.28115390e-02f, -3.44428495e-02f,
  -5.19189239e-03f, 1.11648431e-02f, 3.02891769e-02f, 1.47728845e-01f, 8.52495506e-02f, 3.46113025e-04f, 4.82399203e-02f, 1.97250750e-02f, 4.47722971e-02f, 6.29871488e-02f,
  -1.34398252e-01f, -9.69692096e-02f, -3.27280164e-02f, -5.46635650e-02f, 4.51024175e-02f, -5.15193753e-02f, 8.09587464e-02f, 7.02894405e-02f, -1.46529004e-01f, 1.00079803e-02f,
  -3.48185264e-02f, 7.10288063e-02f, -4.03530896e-02f, 5.97926229e-02f, 8.06975141e-02f, -1.01190582e-02f, 7.07281474e-03f, 3.28470431e-02f, 1.38946190e-01f, -6.41322061e-02f,
  -1.78510044e-02f, 7.05540553e-02f, 3.46795507e-02f, 3.22192982e-02f, 4.32901159e-02f, 1.40594982e-03f, -1.81526262e-02f, -1.41481459e-02f, -1.06350563e-01f, -4.16980758e-02f,
  2.07905367e-01f, -6.23026639e-02f, 1.00711673e-01f, -5.97904362e-02f, 9.40066669e-03f, -1.17863275e-01f, -3.01752414e-04f, -6.09083623e-02f, 1.90109443e-02f, 1.18984086e-02f,
  -6.93636611e-02f, -5.86846247e-02f, -6.75588567e-03f, -2.84890621e-03f, 6.67804619e-04f, -3.95559818e-02f, -1.01765193e-01f, -9.17092524e-03f, 8.37103501e-02f, 9.80112795e-03f,
  -9.14654508e-02f, 4.07515951e-02f, -1.27460798e-02f, 5.76350316e-02f, 1.54667506e-02f, -6.10945299e-02f, 2.94033960e-02f, -4.23353128e-02f, 6.59999624e-03f, -4.37245220e-02f,
  1.63171198e-02f, 6.30939528e-02f, 7.42896497e-02f, -3.51322666e-02f, -7.16083273e-02f, -2.03222577e-02f, 7.81782344e-02f, -1.05865989e-02f, 3.87354940e-02f, -3.71051468e-02f,
  -5.58545068e-02f, -2.86281966e-02f, 5.56040369e-02f, -6.75410926e-02f, -5.84052987e-02f, 6.65168613e-02f, 6.00279830e-02f, -3.50040831e-02f, -8.45095590e-02f, -5.40741794e-02f,
  -7.83899277e-02f, -5.06966040e-02f, -2.32983064e-02f, 7.89236277e-02f, 5.79615831e-02f, -3.23734619e-02f, -3.64373699e-02f, -7.12741166e-02f, 7.17485547e-02f, -6.88532591e-02f,
  4.16386463e-02f, -6.72131032e-02f, 2.79467683e-02f, 2.76095644e-02f, -9.78436321e-02f, 1.03457924e-02f, 5.17657660e-02f, -1.97013170e-02f, -6.93313330e-02f, -4.80724350e-02f,
  -5.54114245e-02f, -6.55668676e-02f, 8.20929278e-03f, 7.19227418e-02f, 1.00315886e-03f, -5.92198074e-02f, -9.94779095e-02f, 9.53527167e-02f, -6.99495450e-02f, 2.32231598e-02f,
  -5.62719209e-03f, 2.91982442e-02f, -3.15615498e-02f, -4.68700677e-02f, -6.44897446e-02f, 5.60356528e-02f, 1.46060422e-01f, 5.24297431e-02f, 9.42556858e-02f, 9.16702598e-02f,
  1.83994010e-01f, -3.82684022e-02f, -2.56315134e-02f, 2.24050079e-02f, -1.02293424e-01f, -1.19078413e-01f, -4.42233905e-02f, 6.02351502e-02f, -2.24426179e-03f, 1.41207259e-02f,
  -1.95013925e-01f, -2.96268128e-02f, -1.35390550e-01f, -7.90917501e-02f, 9.82321873e-02f, -8.54434669e-02f, 1.19985059e-01f, 1.26556158e-01f, 6.42798841e-02f, 9.45773646e-02f,
  -7.06026796e-03f, 6.12798519e-02f, 5.98647706e-02f, 1.19336449e-01f, -9.83080044e-02f, -5.12213679e-03f, 4.99723032e-02f, -1.20933019e-01f, -4.37513590e-02f, 4.40464467e-02f,
  -1.61021337e-01f, -2.45450567e-02f, 1.79407578e-02f, 3.89816202e-02f, -2.40932629e-02f, 1.11778177e-01f, 6.85245767e-02f, 5.72216213e-02f, -3.37706432e-02f, 8.41058195e-02f,
  -1.22997276e-01f, -9.05235484e-02f, -7.08519369e-02f, -1.01660416e-01f, -6.65558428e-02f, 1.74309202e-02f, -2.72003319e-02f, -2.94443388e-02f, -3.50377783e-02f, 1.04944939e-02f,
  -1.02053709e-01f, -2.27317438e-02f, -2.24617794e-02f, 3.65234539e-02f, 1.51902437e-02f, 2.59350371e-02f, -2.20830832e-02f, -9.35188830e-02f, 1.24701709e-02f, 3.78875025e-02f,
  3.83729003e-02f, -7.85068870e-02f, 4.84979860e-02f, -6.15307465e-02f, -6.57023191e-02f, -6.44594431e-02f, 8.67848471e-02f, -4.55940664e-02f, 1.49213085e-02f, 2.32216585e-02f,
  -4.17422652e-02f, -7.40093067e-02f, -3.51404250e-02f, 3.83479893e-02f, -4.54537421e-02f, -6.35926425e-02f, -5.75494096e-02f, -4.20446806e-02f, 4.69289124e-02f, 2.26039365e-02f,
  -5.62984496e-02f, -5.19384705e-02f, 5.80342999e-03f, 2.56393459e-02f, -1.65489912e-02f, 8.81624445e-02f, -6.59523904e-02f, -8.32402855e-02f, 3.88173983e-02f, 3.38575691e-02f,
  -5.37511632e-02f, 4.71318737e-02f, 6.85961917e-02f, 7.24754781e-02f, -1.55507578e-02f, 3.96813415e-02f, -1.05046302e-01f, -3.78170656e-03f, 1.81850139e-02f, 3.54775079e-02f,
  -3.41358446e-02f, -8.00164267e-02f, -3.07952706e-02f, 2.36016940e-02f, 6.66677579e-02f, 4.90036746e-03f, 8.39795247e-02f, 3.54549885e-02f, 1.43145705e-02f, -1.00575365e-01f,
  9.54287499e-02f, 1.36261687e-01f, 9.88073125e-02f, 1.42855188e-02f, -5.85653856e-02f, 1.19080693e-01f, -4.24089581e-02f, 1.63867865e-02f, 1.23935424e-01f, 6.05902262e-02f,
  -4.65620868e-02f, 2.24342067e-02f, -3.00220966e-01f, -3.00527774e-02f, -1.26479670e-01f, -1.32366598e-01f, 9.13942531e-02f, 9.38314572e-02f, 1.35193532e-02f, 3.52167152e-03f,
  -5.60522415e-02f, -6.39261231e-02f, -4.14548181e-02f, -1.52069833e-02f, -8.27355385e-02f, -1.30617078e-02f, -1.42974198e-01f, -1.47057608e-01f, -1.33699089e-01f, 1.07475311e-01f,
  5.49571142e-02f, -8.04013163e-02f, -2.42334269e-02f, 5.58214039e-02f, -1.49710989e-02f, -1.13667957e-01f, -1.95988536e-01f, -1.31849557e-01f, -1.53563783e-01f, -1.78458676e-01f,
  -1.71431243e-01f, -9.39236060e-02f, 8.64002737e-04f, 7.94426128e-02f, -1.28650889e-01f, 3.77663299e-02f, -2.11894587e-02f, 4.51422781e-02f, -1.08860306e-01f, -7.32855573e-02f,
  -5.30371815e-02f, -2.29640380e-02f, -7.66722560e-02f, -4.84670997e-02f, 6.99301288e-02f, -7.52878189e-02f, 4.55446355e-02f, 3.28584872e-02f, -1.02340966e-01f, 2.47010384e-02f,
  2.23818459e-02f, -8.46333355e-02f, -2.59404462e-02f, -5.94832795e-03f, 4.86647487e-02f, -1.15796134e-01f, -6.63020611e-02f, -1.40328295e-04f, -1.14057377e-01f, 5.50978770e-03f,
  2.97199432e-02f, -1.03992596e-02f, 4.36011143e-02f, -5.12002446e-02f, 3.93344872e-02f, -4.75595370e-02f, 1.08079379e-02f, 2.25303248e-02f, -3.38107049e-02f, 5.27965203e-02f,
  -5.11193164e-02f, 4.52833846e-02f, 7.58203045e-02f, -6.68937191e-02f, 2.69561820e-02f, -7.43278265e-02f, 6.12469204e-02f, 9.41086709e-02f, -5.40172169e-03f, 6.98106140e-02f,
  5.28772436e-02f, -8.19325447e-02f, 6.49721771e-02f, 2.01840233e-02f, -3.42413262e-02f, -7.48687238e-02f, 4.55644205e-02f, -3.32409367e-02f, 7.05238432e-02f, -6.01352677e-02f,
  -3.87112573e-02f, -1.01603456e-01f, -6.82117939e-02f, -4.71142046e-02f, -7.47468024e-02f, -5.75427935e-02f, -7.38681033e-02f, 1.26980152e-02f, 4.40747254e-02f, -6.30446002e-02f,
  -2.10060296e-03f, 3.17556337e-02f, 2.21389458e-02f, -3.74886952e-02f, 9.61216986e-02f, -6.52382299e-02f, 1.05270788e-01f, -4.28702608e-02f, 6.11748658e-02f, 3.89700532e-02f,
  6.86620474e-02f, 1.67534798e-02f, 5.70372902e-02f, -3.86491045e-02f, 2.37965118e-02f, -4.56547551e-02f, -7.81537145e-02f, 1.09939380e-02f, -8.61860216e-02f, 2.16578975e-01f,
  -2.47147933e-01f, 1.32985726e-01f, 2.27656551e-02f, -6.88591450e-02f, -1.17061898e-01f, -9.67446119e-02f, -1.14327870e-01f, -7.27196708e-02f, -4.60976288e-02f, 3.29587422e-02f,
  2.22719293e-02f, -1.39960125e-01f, -1.30078584e-01f, -1.80652827e-01f, -1.60801098e-01f, 3.48411426e-02f, -1.94711953e-01f, -2.39423543e-01f, -4.16344851e-01f, -3.49235833e-01f,
  -1.35643288e-01f, -2.29979023e-01f, -1.32927507e-01f, -1.68042749e-01f, 1.23946173e-02f, -9.65061039e-02f, 1.56398281e-01f, -4.26902398e-02f, -7.17439502e-02f, 8.46189260e-02f,
  2.38535360e-01f, -5.53967915e-02f, -8.18608105e-02f, -1.18944988e-01f, 7.51645789e-02f, -2.65313201e-02f, 6.34561479e-02f, 3.01029757e-02f, 7.28840455e-02f, 7.94276819e-02f,
  -4.59883688e-03f, -5.26989205e-03f, -4.09775116e-02f, -8.60913694e-02f, -8.09423104e-02f, -4.50190566e-02f, -4.21093702e-02f, 2.97855716e-02f, 8.33234340e-02f, 4.95903231e-02f,
  -6.71192585e-03f, -4.30214070e-02f, 1.00730611e-02f, 1.15588501e-01f, 5.65965436e-02f, -3.76473106e-02f, 5.16958944e-02f, 1.05693772e-01f, -4.81997468e-02f, 2.12591320e-01f,
  2.56232172e-02f, 3.20690535e-02f, -1.34124397e-03f, 2.17413474e-02f, -7.28841797e-02f, 9.37453937e-03f, -3.87829766e-02f, -6.01061396e-02f, 7.65376445e-03f, 7.68817589e-02f,
  5.91602847e-02f, 1.83808059e-02f, 9.16787833e-02f, 2.91883461e-02f, 5.32597257e-03f, -3.00747808e-02f, 2.05855891e-02f, 3.40254530e-02f, 6.60722479e-02f, -5.55805042e-02f,
  -9.03393999e-02f, 1.09632939e-01f, 4.35434468e-02f, 5.67715848e-03f, -1.28237689e-02f, 4.83301803e-02f, -5.84059879e-02f, -1.03139549e-01f, 3.13380472e-02f, -7.78608993e-02f,
  2.19130397e-01f, -2.01224968e-01f, 4.40353863e-02f, 1.65927969e-02f, -1.54657532e-02f, 5.31062745e-02f, 3.12317032e-02f, 3.31647620e-02f, 1.74727272e-02f, 3.75436968e-04f,
  -8.24764445e-02f, 2.02633464e-03f, 3.79563831e-02f, -5.70749193e-02f, -1.02110684e-01f, 4.82672220e-03f, -3.75043079e-02f, -7.55478740e-02f, 4.46025729e-02f, 1.67550385e-01f,
  7.62893781e-02f, 3.52810472e-02f, -3.64005230e-02f, 1.50593221e-01f, 5.19048199e-02f, -1.29597291e-01f, 9.16363448e-02f, 8.39240029e-02f, -2.94759572e-02f, 1.50449425e-01f,
  1.84944689e-01f, 9.75868925e-02f, -1.53966486e-01f, 6.99869618e-02f, -5.12527116e-02f, 1.80009343e-02f, 1.24146074e-01f, 8.02350268e-02f, 4.26707566e-02f, 6.73154965e-02f,
  1.31537709e-02f, -1.26359582e-01f, -9.69041362e-02f, 2.83162994e-03f, 1.17535396e-02f, 3.78701799e-02f, -9.86153260e-03f, -8.79120380e-02f, -1.60120159e-01f, -2.29810309e-02f,
  1.23711228e-01f, 7.07137063e-02f, -1.89230982e-02f, -3.06747891e-02f, -3.37385084e-03f, -5.42132854e-02f, 4.46491614e-02f, -4.88781072e-02f, -1.38926134e-01f, -3.18272784e-02f,
  -1.83178663e-01f, -1.24897204e-01f, -1.41924635e-01f, 3.15654427e-02f, -5.32690920e-02f, 1.03809945e-01f, 1.13812927e-02f, 6.98318258e-02f, -6.45079389e-02f, 5.13623729e-02f,
  -1.15014605e-01f, 4.23719622e-02f, -3.83250192e-02f, 4.74519506e-02f, -3.16921733e-02f, -4.62746434e-02f, 7.23890141e-02f, 5.50739020e-02f, 3.16880420e-02f, -1.25151332e-02f,
  -1.61070959e-03f, -1.11090265e-01f, 3.82185318e-02f, -8.90969336e-02f, -1.87391543e-03f, -1.39338702e-01f, -4.40847017e-02f, -2.48747263e-02f, 2.25287657e-02f, 1.09425128e-01f,
  -5.26185706e-02f, -2.69978447e-03f, -6.11721128e-02f, 7.63079822e-02f, 4.14354876e-02f, 1.20241838e-02f, -5.64015210e-02f, -5.44278324e-02f, 3.59510779e-02f, 9.05793458e-02f,
  6.81236163e-02f, 3.17594782e-02f, -7.38819987e-02f, -3.12060323e-02f, -1.63277350e-02f, -6.28271848e-02f, -6.20771460e-02f, 7.04720989e-02f, 7.29181245e-02f, 8.81786123e-02f,
  -8.01751614e-02f, -9.96250510e-02f, 6.30640686e-02f, 1.42287547e-02f, -8.35322961e-03f, 1.20229796e-02f, 4.96458896e-02f, -6.05560318e-02f, 1.09200245e-02f, 2.17361748e-02f,
  1.60872146e-01f, -9.08187628e-02f, -1.59435552e-02f, 8.59480202e-02f, -1.22067966e-02f, -6.29589111e-02f, 4.58897054e-02f, 6.45209253e-02f, -7.42298663e-02f, 2.91571151e-02f,
  7.32658058e-03f, 5.32510802e-02f, -2.55123507e-02f, 4.83755991e-02f, 5.81678376e-02f, -7.89192412e-03f, 7.86161199e-02f, -7.49021694e-02f, 4.89783213e-02f, -4.47538011e-02f,
  6.02073502e-03f, 9.08159614e-02f, 9.81805325e-02f, -5.26264422e-02f, -9.24216136e-02f, -2.78019328e-02f, -6.26594052e-02f, 4.46405485e-02f, -4.22288403e-02f, 2.51898050e-01f,
  4.97861467e-02f, 1.34833291e-01f, -1.24552153e-01f, 8.06507021e-02f, 2.74394043e-02f, -3.06555480e-02f, -9.60649550e-02f, 4.77480926e-02f, -6.24000020e-02f, 6.86574867e-03f,
  1.86185002e-01f, 1.90174803e-01f, 1.24800116e-01f, 1.23597970e-02f, 4.18466739e-02f, 4.27886583e-02f, -7.80420452e-02f, -1.79400407e-02f, 7.47401342e-02f, -6.69878423e-02f,
  1.03942387e-01f, -3.17327268e-02f, 9.42602381e-02f, -4.89181317e-02f, 6.16953187e-02f, 1.33978389e-03f, 2.70152651e-02f, -6.06003366e-02f, 3.34485918e-02f, 8.11576471e-02f,
  1.57297224e-01f, 6.38571978e-02f, -2.63633076e-02f, 1.15949392e-01f, 7.03524947e-02f, 8.04606825e-03f, 7.52245039e-02f, 2.93317083e-02f, 7.94168934e-02f, -9.02003050e-02f,
  -3.47654847e-03f, 1.30582266e-02f, 1.22037577e-02f, -2.78913807e-02f, -2.06186622e-02f, -2.86985189e-02f, 3.98108996e-02f, -2.45205611e-02f, -1.73187461e-02f, 1.48312561e-02f,
  -7.40858633e-03f, 4.80968654e-02f, 1.15157980e-02f, -4.81151119e-02f, -2.15359759e-02f, -2.80049839e-03f, 2.09610304e-03f, 2.22412869e-02f, -2.08525341e-02f, -4.09117900e-04f,
  -7.14387223e-02f, -6.39756918e-02f, -1.05586328e-01f, -4.59417179e-02f, 2.18079165e-02f, -8.38352367e-02f, 4.91822213e-02f, -6.35821596e-02f, 4.34577614e-02f, -9.02182981e-02f,
  -2.57257894e-02f, -6.70132935e-02f, -5.32056205e-02f, -5.88422939e-02f, -1.98778361e-02f, -4.25274670e-02f, -4.38309982e-02f, -7.61654344e-04f, -7.73908496e-02f, -5.12717552e-02f,
  8.42506140e-02f, -3.85259502e-02f, -9.77495909e-02f, -5.81233650e-02f, -6.30549043e-02f, -4.86995354e-02f, -1.02142468e-01f, -2.50483342e-02f, -2.62355749e-02f, -6.01230301e-02f,
  1.41106308e-01f, -2.83698877e-03f, 1.16745315e-01f, -3.42765339e-02f, -9.10192356e-02f, -8.59158486e-02f, -1.52877206e-02f, -3.73382159e-02f, -9.30604115e-02f, 7.68630803e-02f,
  -1.84423588e-02f, -5.53213246e-02f, 7.91967958e-02f, 3.16622347e-04f, -5.23787588e-02f, 6.15140982e-02f, -7.27473199e-02f, 9.83525664e-02f, 3.34541500e-02f, -2.88727675e-02f,
  5.77999987e-02f, 4.46474962e-02f, 2.57227402e-02f, -8.69843236e-04f, -2.51134653e-02f, -8.89145024e-03f, 1.28490315e-03f, 6.70975307e-03f, -1.35425860e-02f, 6.69599324e-02f,
  -7.32976496e-02f, 5.67368791e-02f, -1.96652282e-02f, -8.82668495e-02f, 7.09448010e-03f, 2.40042377e-02f, 1.85418781e-02f, 3.48181501e-02f, -2.44413801e-02f, 1.12383496e-02f,
  -3.22996639e-02f, -1.37004862e-02f, -9.28475335e-02f, -7.25406185e-02f, -8.17636177e-02f, 1.11583158e-01f, 7.80121163e-02f, -7.81523213e-02f, -4.47345600e-02f, 1.76622011e-02f,
  -6.52577430e-02f, 7.60945007e-02f, -6.30663708e-03f, -8.55130851e-02f, 5.03827631e-02f, 7.60197639e-02f, -6.48773238e-02f, -7.35536516e-02f, -2.59790067e-02f, -8.46735835e-02f,
  -3.65426578e-03f, -6.14757985e-02f, -3.66652943e-02f, -4.87839580e-02f, 8.14678743e-02f, -5.83497956e-02f, 1.94517002e-02f, 4.10307311e-02f, 4.25486006e-02f, 3.62153687e-02f,
  8.97891261e-03f, -6.52046055e-02f, 1.25885643e-02f, 8.66448805e-02f, 2.09703874e-02f, 6.31231815e-02f, 5.98866716e-02f, 1.53727259e-03f, -4.47063632e-02f, 6.61050379e-02f,
  5.27997210e-04f, 3.95733155e-02f, 3.96864638e-02f, 4.03636768e-02f, 1.42254820e-02f, -5.81916459e-02f, 3.21483575e-02f, 3.23869288e-02f, -9.52268094e-02f, -5.50359823e-02f,
  2.02322118e-02f, -2.25332733e-02f, 5.95270805e-02f, 8.57990310e-02f, 4.28134799e-02f, 2.86603440e-03f, -7.80342892e-02f, -3.38862427e-02f, 1.60755049e-02f, 5.61794564e-02f,
  -4.01025862e-02f, -3.51278298e-02f, 1.31790787e-02f, -1.02602143e-03f, 3.70408855e-02f, -9.39670671e-03f, 1.86194666e-03f, 4.04967591e-02f, 2.05698912e-03f, -9.29725692e-02f,
  -1.51962563e-02f, 8.58460069e-02f, 2.07773931e-02f, 3.08623128e-02f, -1.55097153e-02f, -2.68384330e-02f, 1.59131251e-02f, -7.45001137e-02f, 5.62147796e-02f, -7.40110353e-02f,
  2.66153682e-02f, 3.16739790e-02f, -7.33225420e-02f, -8.12143236e-02f, 1.08995279e-02f, -6.19585859e-03f, 5.85741028e-02f, -6.97513372e-02f, -7.91245997e-02f, 4.56593819e-02f,
  -7.76071623e-02f, -1.94141828e-03f, 3.50671671e-02f, 8.48338306e-02f, -1.24193849e-02f, -4.14849445e-02f, -6.77235350e-02f, 6.14839308e-02f, 1.20033650e-02f, -5.82301207e-02f,
  6.32737428e-02f, 8.53278637e-02f, 9.05796215e-02f, -1.26966145e-02f, -1.21992026e-02f, 7.22015277e-02f, 9.27233398e-02f, 8.16527978e-02f, 5.27049378e-02f, 5.19516356e-02f,
  -6.09562024e-02f, -6.24682233e-02f, 8.02914947e-02f, -8.19297209e-02f, -1.14269994e-01f, -2.99750175e-02f, -1.19206265e-01f, 2.96937097e-02f, -6.44799322e-02f, -4.13511284e-02f,
  -5.32232635e-02f, -1.64241329e-01f, -4.35405523e-02f, 1.05228290e-01f, 1.96529627e-02f, 2.15866161e-03f, 2.32729185e-02f, 1.36930812e-02f, 6.10358594e-03f, -6.95264786e-02f,
  7.93388765e-03f, -1.37965027e-02f, 1.56031745e-02f, 1.48978472e-01f, -5.42918891e-02f, -1.16241649e-02f, -2.75801048e-02f, 1.10672936e-01f, 3.21965031e-02f, 6.23784326e-02f,
  -6.52677119e-02f, -9.34510306e-03f, -4.15842980e-02f, -1.16588250e-02f, -9.16975737e-02f, 8.41064751e-02f, -6.91262633e-02f, 1.35766104e-01f, 6.66866526e-02f, -2.80785561e-03f,
  -4.30261828e-02f, 6.44463673e-02f, -7.44029656e-02f, 6.32860214e-02f, 2.79058665e-02f, 5.57894148e-02f, 9.09141675e-02f, 1.55061677e-01f, -2.00553499e-02f, 5.10475338e-02f,
  -9.14534330e-02f, -1.13901980e-01f, -5.54349683e-02f, 4.29588221e-02f, 1.05026647e-01f, 8.25670373e-04f, -8.88246763e-03f, 1.18367404e-01f, 1.19445898e-01f, 7.43491426e-02f,
  -6.29808083e-02f, 5.72715588e-02f, 6.15606382e-02f, -6.28011674e-03f, -6.96362630e-02f, 6.36717081e-02f, -2.49720011e-02f, -1.02504358e-01f, 4.63328809e-02f, -3.66857685e-02f,
  2.22815499e-02f, 6.44198731e-02f, 3.72798704e-02f, 5.88276386e-02f, 2.92112753e-02f, 5.56414835e-02f, -3.14074904e-02f, 3.07096150e-02f, -7.38465115e-02f, -1.96519624e-02f,
  -1.35962302e-02f, 3.34524759e-03f, 6.29740879e-02f, 6.86962306e-02f, -3.66534549e-03f, 2.07883008e-02f, 6.59923628e-02f, 1.91398766e-02f, -2.30328254e-02f, 3.53307389e-02f,
  -1.12673983e-01f, -1.47320880e-02f, -4.86452915e-02f, -8.72932896e-02f, -4.06242348e-02f, -5.98695055e-02f, -4.57201637e-02f, -2.55833566e-02f, -6.97678998e-02f, -2.99503207e-02f,
  -6.76986412e-04f, -7.55049661e-02f, -3.20252068e-02f, 6.53658286e-02f, -1.15177915e-01f, -3.03416960e-02f, -9.91960317e-02f, -3.12313996e-02f, -8.38019922e-02f, -9.19912234e-02f,
  -1.16399765e-01f, -1.32878050e-01f, -2.33969539e-01f, -1.12766795e-01f, 1.78470816e-02f, -2.02593714e-01f, -1.55023709e-01f, -1.17068186e-01f, -7.23240227e-02f, -1.68314591e-01f,
  -2.60594301e-02f, -9.92079377e-02f, 1.83687396e-02f, 9.00791660e-02f, 6.55925274e-02f, 5.99771701e-02f, -1.68367028e-01f, -8.08628127e-02f, 2.77123949e-03f, 4.86577153e-02f,
  8.71594697e-02f, 6.46337494e-02f, 7.42291063e-02f, 7.27089420e-02f, -9.69866365e-02f, 4.86458316e-02f, -3.47499251e-02f, 9.17674601e-02f, 2.12755501e-02f, 6.64210618e-02f,
  8.73472840e-02f, 1.21569829e-02f, 7.24616647e-02f, -7.90732652e-02f, 5.15221171e-02f, 6.41354173e-02f, -4.94452454e-02f, 6.32967427e-02f, 2.62704771e-02f, 9.38752964e-02f,
  1.40786767e-01f, -3.98629941e-02f, 1.13239445e-01f, -3.55541557e-02f, -1.95216574e-02f, 1.33823389e-02f, -7.61311054e-02f, -1.56645582e-03f, -1.01115249e-01f, 4.56857271e-02f,
  1.75697077e-02f, -2.03671325e-02f, 1.29215000e-02f, 1.02518371e-03f, 6.73411712e-02f, -1.62423849e-02f, -6.82575703e-02f, -1.19883921e-02f, 4.48456444e-02f, 6.90229759e-02f,
  -4.36892845e-02f, 6.93732128e-02f, 4.57101986e-02f, -1.67082846e-02f, -3.09300199e-02f, 3.49533334e-02f, 3.11172996e-02f, -4.12963144e-02f, 1.65964700e-02f, -8.05659965e-02f,
  3.58140171e-02f, 1.29631802e-01f, -3.40993479e-02f, 9.09681171e-02f, -3.84770297e-02f, -1.34647395e-02f, 3.28267068e-02f, 2.65487563e-02f, 2.39392426e-02f, -4.06606644e-02f,
  -2.67903730e-02f, -1.38830990e-02f, 5.68474382e-02f, 3.89884301e-02f, 1.16847590e-01f, -1.33104092e-02f, 3.20009105e-02f, 1.26266321e-02f, 9.13207084e-02f, 5.79811120e-03f,
  8.73849094e-02f, -2.84999814e-02f, 7.86177292e-02f, 3.91938053e-02f, -2.69497465e-02f, 9.28434208e-02f, 3.48509327e-02f, 4.57855761e-02f, 4.63329032e-02f, 6.85031265e-02f,
  -2.63775922e-02f, -1.29122451e-01f, 1.09418511e-01f, 4.78418916e-02f, 7.01337680e-02f, 2.09052693e-02f, -2.77787931e-02f, -1.76023096e-02f, -3.45927750e-04f, -9.62271914e-02f,
  -1.38056744e-02f, -1.10153593e-02f, -7.75742903e-02f, -6.84713423e-02f, -5.15985675e-02f, 5.83345331e-02f, -9.20007899e-02f, -1.17931282e-02f, 5.10540344e-02f, -3.39121111e-02f,
  -7.38090351e-02f, 3.42418393e-03f, 2.58372240e-02f, -6.85866689e-03f, -8.56865048e-02f, 3.65177654e-02f, 9.26203132e-02f, 9.18871015e-02f, 6.51209503e-02f, -4.01480049e-02f,
  -3.87688056e-02f, 1.88287392e-01f, 4.98498939e-02f, 1.64821625e-01f, -1.06773406e-01f, -1.66576847e-01f, -8.13536644e-02f, -7.99521804e-03f, 1.40050277e-01f, 5.56533150e-02f,
  -1.45379394e-01f, -3.93353738e-02f, -2.75339969e-02f, -1.44001752e-01f, -1.15376763e-01f, 7.69634992e-02f, -5.94771886e-03f, -5.55199012e-02f, -2.57802188e-01f, -1.76096529e-01f,
  -8.48698169e-02f, 3.83499474e-03f, -4.36083451e-02f, 5.36010154e-02f, 4.01463732e-03f, -1.14528406e-02f, 1.55360550e-01f, -3.46417241e-02f, -3.35552432e-02f, 4.33202013e-02f,
  -1.78546712e-01f, -3.85625325e-02f, -9.26813334e-02f, 1.70005136e-03f, 5.80581725e-02f, -6.24964423e-02f, -1.02153204e-01f, 7.53898174e-02f, 6.23577163e-02f, -6.04205169e-02f,
  -8.85956883e-02f, -9.67245400e-02f, 1.60120782e-02f, -8.03382322e-02f, -8.04429725e-02f, -1.11012861e-01f, 6.61774874e-02f, -1.53858196e-02f, 1.18954834e-02f, -5.62028401e-02f,
  -1.18064009e-01f, -1.94239691e-01f, -3.82319652e-02f, 8.00988525e-02f, 2.31764875e-02f, 4.56624338e-03f, 4.91497219e-02f, 5.91971129e-02f, 2.32015718e-02f, 3.71112861e-02f,
  3.34911905e-02f, -5.83152659e-02f, 5.31153269e-02f, 1.07356971e-02f, 6.24398701e-02f, 5.07558621e-02f, 5.22873774e-02f, 6.19527958e-02f, -5.33588082e-02f, 9.88723561e-02f,
  -6.74761012e-02f, 6.24997318e-02f, -1.68915736e-04f, -1.65069718e-02f, -4.61763293e-02f, 9.32961032e-02f, -8.09073821e-02f, -3.84249091e-02f, -5.31260185e-02f, 7.07340613e-02f,
  -1.41107768e-03f, -5.00158500e-03f, 4.43066992e-02f, -6.19254261e-02f, -2.77646892e-02f, 7.25086704e-02f, -9.98218879e-02f, -1.35378037e-02f, 9.16113108e-02f, -3.44751999e-02f,
  1.18275128e-01f, -1.73258290e-01f, -1.57423913e-02f, -8.59435797e-02f, -2.67085619e-02f, -1.78913027e-02f, -9.36405212e-02f, 2.12943573e-02f, -1.08092139e-02f, -1.13657624e-01f,
  -1.67916745e-01f, -4.83484007e-02f, 2.17695553e-02f, -1.22844234e-01f, -1.52515098e-01f, -1.27799496e-01f, -3.10718510e-02f, -9.38553140e-02f, 2.99102385e-02f, -2.28644721e-02f,
  -1.43479044e-02f, -5.70808761e-02f, -7.40292668e-02f, -3.91045734e-02f, 7.19331503e-02f, -1.31485611e-01f, -4.81192023e-02f, -5.41102886e-03f, 8.94360989e-03f, 1.07724339e-01f,
  4.68374789e-02f, 1.30582333e-01f, -1.24016721e-02f, -6.90224320e-02f, -1.03937201e-01f, 1.88850114e-04f, -1.20611265e-02f, -9.69968885e-02f, 5.08579984e-02f, -3.41041163e-02f,
  8.68465006e-02f, 7.13777319e-02f, 6.46241009e-02f, -6.89454898e-02f, -1.22462370e-01f, 3.37712541e-02f, -1.36666372e-01f, -2.10537259e-02f, -7.01139122e-02f, -1.16727076e-01f,
  -2.51852069e-02f, 5.24322838e-02f, -3.03751118e-02f, -4.42835409e-03f, 6.75441045e-03f, -9.45996344e-02f, -7.32362941e-02f, -1.41747147e-02f, -2.33264118e-02f, 5.84207177e-02f,
  6.01617359e-02f, 1.57318458e-01f, -6.79471418e-02f, 4.01937924e-02f, -6.54512122e-02f, 7.76997954e-03f, 5.20429723e-02f, 1.08955264e-01f, -7.18597919e-02f, 9.66606364e-02f,
  8.16369876e-02f, -5.06442413e-02f, 2.96455193e-02f, 3.60887349e-02f, -1.90617237e-02f, -7.48398528e-02f, -1.76125243e-02f, 3.32870297e-02f, -7.21391886e-02f, 2.39583366e-02f,
  1.23310937e-02f, 4.14022990e-02f, 6.13602698e-02f, -7.11390451e-02f, -1.08598517e-02f, -6.96206093e-02f, -6.07532635e-03f, 3.44745405e-02f, -6.74141496e-02f, 1.72159281e-02f,
  -5.54961059e-03f, 2.49419492e-02f, -7.99905956e-02f, 7.08071217e-02f, 1.03794917e-01f, -2.75699003e-03f, -2.00106781e-02f, 1.02762692e-01f, -1.46568315e-02f, 9.55209136e-02f,
  -8.26301873e-02f, 1.01174526e-01f, 1.37861576e-02f, 4.87197898e-02f, -2.17616223e-02f, 9.82763171e-02f, -4.37545180e-02f, 5.15229777e-02f, -4.79176007e-02f, 1.30455187e-02f,
  7.66353905e-02f, 2.04703994e-02f, -3.72178555e-02f, 7.28576332e-02f, 3.89184151e-03f, 2.95879077e-02f, -8.89946148e-03f, 9.07520354e-02f, -3.09898052e-02f, -4.37468588e-02f,
  1.44724935e-01f, -1.62344158e-01f, 1.01105087e-01f, -2.00435556e-02f, 2.47022230e-02f, -8.37650970e-02f, 3.10822129e-02f, 5.22296131e-02f, 5.31950705e-02f, 1.74293518e-02f,
  -2.60817371e-02f, 2.97517758e-02f, 8.30570608e-02f, -6.92026615e-02f, -4.67485078e-02f, -1.19355889e-02f, -2.26882659e-02f, 5.39476499e-02f, 6.91199973e-02f, -5.19123822e-02f,
  3.57066356e-02f, -1.12987282e-02f, -5.15463166e-02f, -8.09757262e-02f, -6.62005842e-02f, 4.36985213e-03f, -6.81867776e-03f, -2.61298381e-02f, 1.75821558e-02f, 1.28289312e-01f,
  7.56845027e-02f, 3.45650129e-02f, -2.48678565e-01f, -1.24510065e-01f, -4.25652899e-02f, -1.11098573e-01f, 1.83903202e-02f, -6.76931888e-02f, -1.69857428e-03f, -5.16221765e-03f,
  1.04166940e-01f, 4.69752587e-02f, -9.96368900e-02f, -1.10023534e-02f, -5.21775670e-02f, -1.15421496e-01f, -3.97358462e-02f, -2.64833838e-01f, -2.48237893e-01f, -2.25990769e-02f,
  -1.12685978e-01f, -1.90884084e-01f, -2.15083867e-01f, -1.74703419e-01f, -7.94016048e-02f, -8.16753432e-02f, -1.16323262e-01f, -2.59898212e-02f, -9.33280308e-03f, 1.83591172e-02f,
  -1.85068086e-01f, -6.59396267e-03f, -1.23680033e-01f, 1.02658339e-01f, -7.10796639e-02f, -7.64158601e-03f, 7.65460208e-02f, -1.23619087e-01f, 4.72614095e-02f, 5.47910715e-03f,
  6.55685216e-02f, -3.56765725e-02f, -1.15783408e-01f, -9.58061218e-02f, -5.07314876e-02f, -6.38363883e-02f, -1.13105401e-01f, -1.44131884e-01f, -8.74297842e-02f, -6.73773512e-02f,
  8.54450390e-02f, -7.02113509e-02f, -1.05070343e-04f, 2.78797001e-02f, -4.90282439e-02f, 4.24228562e-03f, -1.01870775e-01f, -3.69986892e-02f, -1.32065147e-01f, -1.16386011e-01f,
  -1.27343722e-02f, -4.28862981e-02f, 4.09297124e-02f, 1.84065495e-02f, -2.86840126e-02f, -4.63447124e-02f, -4.23539281e-02f, 8.50785431e-03f, -4.86437082e-02f, -2.48107053e-02f,
  -3.02649401e-02f, -5.93328364e-02f, 6.01591310e-03f, 7.65486360e-02f, -9.98027772e-02f, 5.90998940e-02f, 5.25419861e-02f, -9.45759341e-02f, 2.00926028e-02f, -4.67263721e-03f,
  2.07030047e-02f, -5.52401952e-02f, -2.79626306e-02f, -1.06696878e-02f, -3.51737030e-02f, -2.49116309e-02f, 3.22353952e-02f, 7.02328011e-02f, -3.87472175e-02f, 5.26075512e-02f,
  -6.98449910e-02f, -7.86451623e-02f, 6.00371882e-02f, -3.39542888e-02f, -3.55232544e-02f, -7.73666576e-02f, -4.31952290e-02f, 3.77314538e-02f, -9.71573498e-03f, -7.30695724e-02f,
  -9.22567248e-02f, -7.21850097e-02f, -5.03222197e-02f, -3.24019231e-02f, -1.14535697e-01f, -7.80347064e-02f, 3.54662389e-02f, 3.32416687e-03f, -9.72414464e-02f, -6.21799789e-02f,
  6.06424958e-02f, -4.13389094e-02f, -2.82630250e-02f, 3.24153751e-02f, -5.67486845e-02f, -1.00849867e-01f, -8.52123052e-02f, 9.12043639e-03f, -2.34913118e-02f, -2.58320142e-02f,
  2.20926311e-02f, -8.47826749e-02f, 1.26904175e-01f, -2.69491654e-02f, 9.30813402e-02f, -1.09591754e-04f, -1.36675805e-01f, -6.42637685e-02f, 5.20687662e-02f, -6.33513089e-03f,
  1.60199646e-02f, 2.28498504e-03f, 8.24725032e-02f, 1.30497009e-01f, 9.66121256e-02f, -9.90309343e-02f, 5.11024892e-02f, 1.19452178e-01f, 1.65618703e-01f, -4.78523783e-02f,
  -7.19328076e-02f, -5.63393570e-02f, 5.33327162e-02f, 2.37980448e-02f, -1.16343223e-01f, 7.26220757e-02f, 2.88698692e-02f, 7.86105320e-02f, -5.02712140e-03f, -1.01543292e-01f,
  1.34599935e-02f, -1.05165124e-01f, 1.29496768e-01f, 8.76685455e-02f, -2.54074894e-02f, -2.41402779e-02f, -3.94170545e-02f, -2.22402774e-02f, -2.11704131e-02f, -1.03900790e-01f,
  -7.36384615e-02f, -8.83557424e-02f, -2.16413988e-03f, -1.44095514e-02f, -3.69629869e-03f, -2.88138054e-02f, 1.05955070e-02f, 1.20330637e-03f, 2.00915858e-02f, 2.84197628e-02f,
  -1.90411415e-02f, -2.59390064e-02f, 8.78701434e-02f, 4.87765968e-02f, 1.36625264e-02f, -1.04195904e-02f, -5.85114174e-02f, -9.35018510e-02f, -3.36277224e-02f, -2.40324736e-02f,
  -5.91065455e-03f, 1.14548653e-01f, 5.56005910e-02f, 3.67565714e-02f, 4.51506004e-02f, -7.87138268e-02f, 3.39643918e-02f, -3.07496116e-02f, -7.04970658e-02f, -4.80156764e-02f,
  5.02183288e-03f, 8.92907288e-03f, 3.07006408e-02f, -8.61826017e-02f, 8.30896795e-02f, -9.15695168e-03f, 7.97005445e-02f, 1.00002217e-03f, 6.37129992e-02f, -6.81474805e-02f,
  -7.48159215e-02f, 2.93906350e-02f, 8.59488025e-02f, 7.75076970e-02f, -7.34228641e-02f, 1.21395953e-01f, 5.34686148e-02f, 6.00057654e-02f, 4.41266736e-03f, -5.90133741e-02f,
  -4.02084887e-02f, 4.27832156e-02f, -4.09295633e-02f, -2.07262044e-03f, -1.44989975e-02f, 1.32512692e-02f, -1.03525013e-01f, 3.56968045e-02f, 1.19111724e-02f, 3.58800106e-02f,
  -1.90187804e-02f, 3.18304636e-02f, -1.04947083e-01f, 6.62224516e-02f, -1.90685911e-04f, -7.85849616e-02f, -2.81839520e-02f, -4.04603295e-02f, 2.84788311e-02f, 2.82753408e-02f,
  8.68117344e-03f, -2.70567983e-02f, 2.91772168e-02f, -4.55302745e-03f, -4.08722945e-02f, 1.69135574e-02f, 6.02048412e-02f, 4.68113236e-02f, 4.58904430e-02f, -1.19939491e-01f,
  -3.61127704e-01f, 3.13138403e-02f, -9.23423190e-03f, -2.74629980e-01f, -1.41103389e-02f, 2.34512016e-01f, 3.39332670e-01f, 1.32435277e-01f, -1.20850183e-01f, 7.51776695e-02f,
  -3.46969143e-02f, -1.42035738e-01f, -1.73452556e-01f, -4.06135619e-02f, 9.53855887e-02f, 2.15739101e-01f, -2.44369321e-02f, -1.23246647e-02f, -1.02231301e-01f, 5.52587910e-03f,
  -2.35055410e-03f, -1.02972299e-01f, -1.90334812e-01f, -1.70311972e-01f, -1.87660411e-01f, -1.09086066e-01f, -5.44576272e-02f, -6.83549885e-03f, 6.89380467e-02f, 2.10851096e-02f,
  -2.38398835e-02f, -1.41017407e-01f, -5.42471483e-02f, -6.97948113e-02f, -4.85874414e-02f, -2.95933057e-02f, -3.34968902e-02f, -1.96292643e-02f, -3.18322591e-02f, 8.03558603e-02f,
  -1.32600397e-01f, -5.63075319e-02f, -6.31982014e-02f, 3.03315595e-02f, -2.35089175e-02f, -7.83866569e-02f, 3.86883249e-03f, -8.79958048e-02f, 2.28694789e-02f, -3.02783642e-02f,
  4.80344221e-02f, -6.19387105e-02f, -2.35938076e-02f, 8.96807108e-03f, 4.92302999e-02f, 8.03252682e-03f, 5.40229157e-02f, -5.88610806e-02f, 3.39069776e-02f, -7.71451928e-03f,
  4.77219783e-02f, -1.02939801e-02f, 5.53019717e-02f, -3.60463038e-02f, 5.93586862e-02f, -1.18680159e-02f, -6.72423169e-02f, 5.91638386e-02f, -7.41653219e-02f, -4.12763506e-02f,
  -9.41957638e-04f, 7.85490796e-02f, 3.12793888e-02f, 1.13139329e-02f, 3.91211621e-02f, 4.04411554e-03f, 8.60978365e-02f, -2.42480598e-02f, -1.06486296e-02f, -2.67259106e-02f,
  -9.37542133e-03f, 6.75211102e-02f, -7.51652196e-02f, -4.61487770e-02f, 9.70922485e-02f, 8.78443755e-03f, -2.13896018e-02f, 7.92894699e-03f, -1.87630230e-03f, 5.29907681e-02f,
  -1.68570161e-01f, 4.60815281e-02f, -9.14988294e-02f, -1.24030150e-01f, -1.00481883e-01f, 4.83422950e-02f, -6.97452202e-03f, -7.02731907e-02f, -1.04868360e-01f, 9.72180814e-02f,
  6.91152364e-03f, 2.45470311e-02f, -8.21105167e-02f, 7.99304917e-02f, -4.85162158e-03f, 9.45738256e-02f, 4.63566072e-02f, -8.76892209e-02f, -4.48790975e-02f, 7.13114664e-02f,
  3.52478586e-02f, 1.16969131e-01f, 3.41655947e-02f, 5.98347709e-02f, 4.25842963e-02f, -7.46330842e-02f, -3.67775671e-02f, -2.40557771e-02f, 9.50857252e-02f, 3.20968963e-02f,
  -8.12848657e-02f, -1.10023327e-01f, 5.50516844e-02f, -5.65014519e-02f, 3.74600291e-02f, 7.14333877e-02f, -1.05134279e-01f, -1.16719566e-01f, -2.77179144e-02f, 3.55374850e-02f,
  -5.90255596e-02f, -1.23351283e-01f, -5.06939329e-02f, 5.12747131e-02f, -6.66906983e-02f, -5.88952266e-02f, -8.78429413e-03f, 1.07611291e-01f, 1.33432284e-01f, -3.60095873e-02f,
  -1.74857229e-02f, 1.54069148e-03f, 1.10729955e-01f, 1.08864106e-01f, 1.07491620e-01f, 7.20506161e-02f, -4.44065928e-02f, 5.61062917e-02f, -6.29597977e-02f, -1.12258131e-03f,
  3.34505625e-02f, -9.62358415e-02f, 9.30686072e-02f, -8.57976526e-02f, 7.63883516e-02f, 4.47431169e-02f, 3.10909306e-03f, 4.27371003e-02f, 8.18055421e-02f, 3.52405719e-02f,
  2.47733518e-02f, -9.31731611e-03f, 6.47792891e-02f, 1.07279062e-01f, 7.47227445e-02f, -6.54253596e-03f, 1.33131361e-02f, -1.70123726e-02f, -2.08219253e-02f, -2.45577674e-02f,
  4.06513885e-02f, 4.64436859e-02f, -6.57163411e-02f, 4.12199609e-02f, 3.14783454e-02f, -5.48042729e-02f, -6.20278120e-02f, 1.71619728e-02f, 1.94568001e-02f, -2.77745817e-02f,
  1.30235963e-02f, -7.46945068e-02f, 1.63431838e-02f, -5.70615046e-02f, 2.45034862e-02f, -3.69673275e-04f, -1.71978567e-02f, 8.23186412e-02f, -7.07527399e-02f, 6.62995577e-02f,
  6.98967949e-02f, -6.93412423e-02f, -3.65200564e-02f, 8.08915049e-02f, 4.65726517e-02f, 2.52629281e-03f, -7.88607821e-03f, -1.19455485e-03f, 1.41253183e-02f, 7.29758963e-02f,
  -3.03581338e-02f, 6.86445013e-02f, 1.38571309e-02f, -2.88628899e-02f, -1.24642497e-03f, -2.43114792e-02f, -4.59694006e-02f, 6.46387115e-02f, 5.87721029e-03f, -6.10409379e-02f,
  8.92809704e-02f, 3.65425013e-02f, -3.57874855e-02f, 2.84120161e-02f, -6.45267591e-02f, 1.22397840e-02f, -7.24269301e-02f, 1.05271168e-01f, -6.47855690e-04f, 1.05436025e-02f,
  7.10088760e-02f, 6.71963692e-02f, -4.34733517e-02f, 9.01555941e-02f, -2.01825164e-02f, 9.52698067e-02f, 7.04737306e-02f, 1.77633725e-02f, -3.51492167e-02f, -1.96508057e-02f,
  3.15989889e-02f, 5.37030101e-02f, 1.46718873e-02f, 2.97292741e-03f, -5.90140708e-02f, -7.79161230e-02f, 4.40719984e-02f, -5.55707924e-02f, -6.71433732e-02f, 2.56764293e-02f,
  -1.04926117e-01f, -1.48436636e-01f, 6.78392593e-03f, -1.08150192e-01f, 5.38624637e-03f, -1.20662944e-02f, 5.91183864e-02f, -7.90264979e-02f, -4.28840183e-02f, -1.13393646e-02f,
  -1.23071864e-01f, -4.07326892e-02f, -5.93497977e-02f, 1.69975329e-02f, 1.17579931e-02f, -3.34282629e-02f, 1.39394840e-02f, 4.04962525e-02f, 7.25282654e-02f, 1.03989072e-01f,
  -1.04659572e-01f, -1.00280531e-01f, 4.00036722e-02f, 5.45487516e-02f, 5.85808232e-02f, -4.97344732e-02f, 3.23397778e-02f, -1.67876501e-02f, 1.84191633e-02f, -1.03473045e-01f,
  1.20903537e-01f, -1.10496558e-01f, 2.04397570e-02f, -8.00896138e-02f, -2.98804939e-02f, -7.51725286e-02f, 2.73709409e-02f, 1.49508817e-02f, -6.05618879e-02f, 5.74305886e-03f,
  -1.40273776e-02f, -1.71864051e-02f, -5.72519861e-02f, -7.17394203e-02f, 5.63520938e-02f, -5.66259958e-02f, -6.41966090e-02f, 4.59115542e-02f, 4.78598773e-02f, 5.96325323e-02f,
  -1.14027172e-01f, -3.47184427e-02f, 7.17099532e-02f, -2.59686187e-02f, -1.89566724e-02f, -2.07309462e-02f, 3.40371877e-02f, 7.34718367e-02f, 8.19244310e-02f, 5.21315783e-02f,
  -2.59204069e-03f, -6.56840904e-03f, -8.65350440e-02f, 7.49477744e-02f, -1.00623056e-01f, 4.22156230e-02f, -3.28376070e-02f, -4.73166257e-02f, 5.21181747e-02f, 8.07516202e-02f,
  7.35971183e-02f, 2.22245185e-03f, 1.86319184e-02f, 2.92229559e-02f, 5.84748425e-02f, 1.02063501e-02f, -4.12602350e-03f, 1.01252540e-03f, -5.94988391e-02f, 7.17492600e-04f,
  -3.71476710e-02f, 8.89220685e-02f, -1.86350029e-02f, -1.95264202e-02f, 7.31160790e-02f, -1.40650552e-02f, 5.82875684e-02f, 4.76941913e-02f, -4.34750058e-02f, -7.90972933e-02f,
  8.64569023e-02f, -5.65240011e-02f, -7.96693191e-02f, -4.87767421e-02f, -2.46625077e-02f, -7.12001994e-02f, -7.64957666e-02f, 5.13961986e-02f, -3.58481146e-02f, -2.70030182e-02f,
  -7.64340675e-03f, 8.41539651e-02f, -9.42167863e-02f, -6.47676811e-02f, 9.39314067e-02f, 9.27871838e-02f, -6.75178021e-02f, -7.04860240e-02f, -1.72656029e-02f, 7.23678991e-02f,
  -1.00990526e-01f, -4.10601422e-02f, -1.81607390e-03f, 3.03570777e-02f, -6.54805079e-02f, 8.29607099e-02f, 3.26531418e-02f, 2.58019343e-02f, 1.03929743e-01f, -5.46381809e-02f,
  -1.98622763e-01f, 3.40756425e-03f, 1.31741315e-01f, -2.75973901e-02f, -7.26114959e-02f, -1.09460622e-01f, -1.76167622e-01f, -1.01654328e-01f, -1.17118858e-01f, -5.78256510e-02f,
  1.32265002e-01f, 9.38904732e-02f, 6.25350326e-02f, -1.02536706e-02f, -1.29250273e-01f, -9.83665138e-02f, -7.37601817e-02f, 1.38280187e-02f, -1.19554050e-01f, -5.93752079e-02f,
  5.45663238e-02f, -2.69897953e-02f, -8.31240974e-03f, -1.05374686e-01f, 2.77907718e-02f, 3.85417007e-02f, 7.24346191e-02f, -5.05035222e-02f, 8.74611512e-02f, 8.98595527e-02f,
  3.83735925e-01f, -1.03955688e-02f, 1.69175789e-02f, -2.86731441e-02f, 1.26153201e-01f, -3.64376120e-02f, 5.74959777e-02f, -3.23522352e-02f, -4.60942090e-02f, 3.62583883e-02f,
  8.52914229e-02f, 8.59776661e-02f, -5.45624048e-02f, 3.03204786e-02f, -7.52562359e-02f, -6.52521551e-02f, 1.68535169e-02f, 3.56548056e-02f, 1.76304150e-02f, 1.08136982e-01f,
  -4.50448729e-02f, -2.66813003e-02f, -2.15045214e-02f, -3.94145260e-03f, 9.05402526e-02f, 7.27075264e-02f, -1.03902454e-02f, 6.51999097e-03f, -4.66011651e-02f, 3.94111685e-02f,
  1.29064173e-02f, 8.23632479e-02f, 4.88162860e-02f, 6.84851632e-02f, 6.66428283e-02f, -2.87331715e-02f, 1.26664154e-03f, -4.64168750e-02f, -1.64255947e-02f, 8.52584466e-02f,
  -7.97032937e-02f, 4.85872999e-02f, -6.10343106e-02f, -5.71276508e-02f, 2.82331109e-02f, -1.09931557e-02f, -3.34739685e-02f, 3.46134081e-02f, 6.41329307e-03f, -6.23061545e-02f,
  -4.03022915e-02f, -6.22447282e-02f, -5.70093468e-02f, 2.29117181e-02f, -7.91336671e-02f, 3.91350091e-02f, 2.81776208e-02f, 8.46390277e-02f, -2.41081510e-02f, 4.94199665e-03f,
  1.61482796e-01f, -9.05154794e-02f, 2.89838854e-02f, -9.09973755e-02f, -6.72862632e-03f, -4.60274629e-02f, 5.13673574e-02f, -9.32520032e-02f, 1.33720618e-02f, 3.73536088e-02f,
  3.76612768e-02f, -2.40106806e-02f, -2.09353445e-03f, 3.23028713e-02f, -4.99789417e-02f, -6.17908649e-02f, -1.45943454e-02f, -7.60793239e-02f, -1.07825831e-01f, 1.16032539e-02f,
  -4.48811576e-02f, -9.61122811e-02f, -4.51186225e-02f, 9.48885605e-02f, -5.14404029e-02f, 4.11340147e-02f, 1.27317995e-01f, 7.66704082e-02f, 5.94898202e-02f, -5.07203974e-02f,
  -1.16708323e-01f, 3.25385891e-02f, -4.48398627e-02f, 2.03030668e-02f, -3.15713212e-02f, 4.82016988e-02f, 9.62607749e-03f, -7.28419721e-02f, 1.15539934e-02f, -4.02539000e-02f,
  4.90275994e-02f, 1.11504890e-01f, 7.36509264e-02f, 8.39619897e-03f, 9.32424888e-02f, -1.16958162e-02f, -3.37629719e-03f, -6.42533898e-02f, -1.44692678e-02f, 1.36939004e-01f,
  8.10583457e-02f, 1.59901790e-02f, -5.49742021e-03f, -7.16367215e-02f, -4.71876003e-02f, -1.65035147e-02f, 1.63351595e-02f, 8.39996636e-02f, -6.07088357e-02f, -2.69502290e-02f,
  -1.43387262e-02f, -1.26992077e-01f, 4.76357974e-02f, -5.49813211e-02f, -3.73014733e-02f, -1.06687769e-01f, 1.68926604e-02f, -3.84111106e-02f, -5.77287422e-03f, -2.07792539e-02f,
  4.72358204e-02f, -4.48901914e-02f, -1.02753257e-02f, -5.66339083e-02f, 4.14579064e-02f, -7.99549967e-02f, -7.19342083e-02f, -9.45696458e-02f, -1.06576562e-01f, 3.50107886e-02f,
  -2.88560372e-02f, 5.53827509e-02f, -5.51537797e-02f, -2.45605758e-03f, -7.36094415e-02f, -1.92295853e-02f, -3.69025581e-02f, -4.72116806e-02f, -2.42254417e-02f, -5.19571081e-02f,
  -4.17056270e-02f, 5.85051738e-02f, 6.29274175e-02f, 3.66030447e-02f, 9.04375985e-02f, 4.71617281e-02f, -2.40935367e-02f, 2.30541285e-02f, -5.50778536e-03f, 6.72262162e-02f,
  4.18610349e-02f, 7.16947988e-02f, -7.89386630e-02f, 4.21261489e-02f, 6.09187409e-02f, 4.26982604e-02f, 3.27923372e-02f, -4.15213518e-02f, 2.81504039e-02f, 2.34408733e-02f,
  -1.71233881e-02f, -6.26797304e-02f, -9.87663046e-02f, -2.83749886e-02f, 8.08365792e-02f, -2.98824757e-02f, 5.99229261e-02f, 6.68684170e-02f, -6.64520115e-02f, 5.95353134e-02f,
  -9.14714187e-02f, -1.57361459e-02f, 1.66096259e-02f, -1.72245335e-02f, -9.46724713e-02f, -1.06296942e-01f, -7.47914240e-02f, -5.65972961e-02f, -9.69549641e-02f, 6.43442273e-02f,
  7.14662746e-02f, 3.33159640e-02f, 1.14527130e-02f, -1.24979718e-02f, -2.62752809e-02f, 2.32852511e-02f, -8.61714035e-02f, -6.91905916e-02f, 5.33600934e-02f, -9.54021588e-02f,
  -4.66386974e-02f, 1.42367054e-02f, -3.27245407e-02f, -2.29253508e-02f, 2.55915709e-02f, -3.20669226e-02f, -8.68386924e-02f, 4.20326442e-02f, -8.87748376e-02f, -6.25397041e-02f,
  1.34178847e-01f, 1.78819299e-02f, 9.11406800e-02f, -3.58235203e-02f, -7.06355646e-02f, 7.04847202e-02f, 9.46281776e-02f, -5.00317477e-02f, -8.26641098e-02f, 4.45745215e-02f,
  -3.41447070e-02f, 7.89889246e-02f, 7.71115944e-02f, 1.19804829e-01f, 1.18089594e-01f, 1.05478376e-01f, 7.59467185e-02f, 5.30831516e-02f, 1.47512197e-01f, 7.44770607e-03f,
  -1.47501146e-03f, -6.97676688e-02f, -3.24580111e-02f, 8.11198577e-02f, -7.99420401e-02f, -6.04907516e-03f, -8.29885080e-02f, -2.40974762e-02f, 6.00355305e-02f, -9.83002931e-02f,
  -4.60736491e-02f, 1.31995022e-01f, -4.59263511e-02f, -7.21593127e-02f, -6.22161813e-02f, 3.04516498e-02f, 8.81044567e-02f, 2.85543110e-02f, -1.06585011e-01f, 2.65455004e-02f,
  -4.47829179e-02f, 4.26707491e-02f, -4.22131903e-02f, -3.51570919e-03f, -7.73648098e-02f, -1.74460672e-02f, 6.40235618e-02f, 1.19354650e-02f, -9.29393992e-03f, -5.31736687e-02f,
  -9.96393636e-02f, -3.59170921e-02f, 5.67035079e-02f, 6.21013418e-02f, -2.38997061e-02f, 2.44120439e-03f, 6.39912710e-02f, 5.99058196e-02f, -1.72721012e-03f, 2.32760180e-02f,
  5.09880576e-03f, -5.04142325e-03f, 3.81335616e-02f, -2.65176464e-02f, 7.79431686e-02f, 1.72465593e-02f, 4.17800844e-02f, 4.48175371e-02f, -7.11266994e-02f, -1.78652145e-02f,
  -1.92255769e-02f, 8.22558030e-02f, 6.39616176e-02f, 6.02749810e-02f, 4.30852436e-02f, 3.49351913e-02f, 6.09024835e-04f, 4.14538309e-02f, 8.44518244e-02f, -8.67268071e-02f,
  5.68933897e-02f, -5.06204776e-02f, -9.55317616e-02f, -1.69021245e-02f, -3.33490670e-02f, -1.19369049e-02f, 6.06789514e-02f, 7.49843344e-02f, 8.03056508e-02f, -7.83213302e-02f,
  -1.18298732e-01f, 6.40111044e-02f, -6.61297590e-02f, 9.25751179e-02f, 1.51699074e-02f, 7.04008639e-02f, 5.73110534e-03f, 1.80120301e-02f, 3.28590684e-02f, 4.35008779e-02f,
  -1.36197945e-02f, -3.27695757e-02f, 5.87187782e-02f, 4.56244387e-02f, -2.66957674e-02f, -8.83165523e-02f, -5.25343381e-02f, 6.25756681e-02f, 1.72551218e-02f, 2.04913262e-02f,
  2.18451228e-02f, -1.06606513e-01f, -6.03276119e-02f, 8.49856660e-02f, 3.85278873e-02f, 8.55613723e-02f, -2.17770226e-02f, 2.85588391e-02f, 1.03754006e-01f, -1.43011197e-01f,
  9.58885178e-02f, -2.44170818e-02f, 1.01140365e-01f, -2.64295787e-02f, 1.21331714e-01f, 2.39445381e-02f, 9.88143608e-02f, 1.13017261e-02f, -2.55915727e-02f, 6.97766244e-02f,
  -6.35240972e-02f, -5.72022684e-02f, -9.46695209e-02f, 2.97766970e-03f, -7.24126920e-02f, -7.49848131e-03f, -3.72587554e-02f, -6.56878576e-02f, -7.46121556e-02f, -1.73217934e-02f,
  -5.11347838e-02f, -1.58179477e-02f, 1.09167106e-01f, 7.38189146e-02f, -3.85702617e-04f, -4.56946231e-02f, 6.86375201e-02f, 7.62134790e-02f, -7.54955262e-02f, -2.69662030e-03f,
  -1.38875335e-01f, -1.39891440e-02f, -5.30081848e-03f, -3.49557661e-02f, -2.93112099e-02f, -7.52669051e-02f, 6.62173107e-02f, 7.26922825e-02f, -6.98890090e-02f, 4.08405550e-02f,
  -5.02489544e-02f, -5.88369928e-02f, -7.98127279e-02f, -7.21499771e-02f, 3.66957532e-03f, 4.62026894e-02f, -5.59549127e-03f, -6.19624890e-02f, -1.89330075e-02f, -7.42244348e-02f,
  -1.08083799e-01f, 2.20113024e-02f, 1.50294676e-02f, 3.97719629e-02f, 2.20018644e-02f, -4.70346957e-02f, -9.94327441e-02f, 6.68076333e-03f, 1.37486383e-02f, 9.56882015e-02f,
  8.58023316e-02f, 6.58288300e-02f, 7.08773434e-02f, 5.43752052e-02f, 8.63196924e-02f, -8.68629217e-02f, 5.97482733e-02f, 2.44883988e-02f, 1.15686916e-02f, 3.27344798e-02f,
  -6.52838051e-02f, -3.42750549e-02f, 1.24258725e-02f, -7.08847493e-02f, 8.49157199e-02f, 8.51486176e-02f, 7.94523135e-02f, 9.14199203e-02f, -2.26819869e-02f, -1.68332402e-02f,
  -3.62446383e-02f, 1.01680510e-01f, 9.12109390e-02f, -2.42886115e-02f, -6.97444230e-02f, 9.11696777e-02f, -5.07933199e-02f, 1.02765346e-02f, 2.05279067e-02f, -3.26603726e-02f,
  5.61183169e-02f, 1.30859986e-01f, -7.07785264e-02f, 4.42898162e-02f, 2.00964455e-02f, 4.02537696e-02f, -1.53387832e-02f, -6.73186854e-02f, -2.04682667e-02f, 5.89452833e-02f,
  -8.88364017e-02f, -5.89339919e-02f, 4.33100127e-02f, 1.78842954e-02f, 4.07152437e-02f, -5.08396067e-02f, 6.53857365e-02f, 1.80195160e-02f, 2.72908229e-02f, -3.70215462e-03f,
  -3.58140431e-02f, 5.44446670e-02f, 7.80365318e-02f, 8.84785652e-02f, 1.79988728e-03f, -9.43564903e-03f, 3.81068587e-02f, -2.81156655e-02f, 6.98823929e-02f, 1.29113033e-01f,
  2.36948892e-01f, 6.09948896e-02f, -5.91838956e-02f, 2.68693976e-02f, -4.44238111e-02f, -1.92332044e-01f, -1.66351110e-01f, 1.49937151e-02f, 5.96360937e-02f, 1.07498094e-01f,
  7.02912733e-02f, 1.65274501e-01f, 1.73195079e-01f, 6.05050623e-02f, 5.43819629e-02f, -5.43202311e-02f, 4.68327850e-02f, 2.85306275e-02f, -5.49162216e-02f, -1.18065648e-01f,
  4.10884842e-02f, -3.18546109e-02f, 1.24996156e-01f, 2.12500654e-02f, 3.45898233e-02f, -5.70114926e-02f, -1.44454278e-02f, -2.83469744e-02f, -5.38438931e-02f, -3.00418567e-02f,
  -3.85032967e-02f, 3.52918804e-02f, -5.85142663e-03f, 1.37025774e-01f, -7.09477365e-02f, 9.51910540e-02f, -7.05148652e-02f, -3.10239699e-02f, 4.82691312e-03f, 6.27532527e-02f,
  5.78011423e-02f, 1.00692540e-01f, 1.38427122e-02f, -7.89989159e-02f, -4.33757268e-02f, 6.14867136e-02f, 7.29932263e-02f, 1.85121689e-02f, 1.71621051e-02f, -8.49651322e-02f,
  7.63578666e-03f, -7.87274614e-02f, 4.31091350e-04f, 6.91873953e-02f, 8.28730389e-02f, 1.04212701e-01f, -2.39314213e-02f, 7.10712001e-02f, 1.34047329e-01f, 8.02832916e-02f,
  -8.98362994e-02f, -7.30165616e-02f, -3.47739495e-02f, -5.30748330e-02f, -4.85957116e-02f, -2.59824824e-02f, -1.03235573e-01f, -2.35677082e-02f, 3.34997587e-02f, 3.47649083e-02f,
  -2.15268973e-02f, 4.27734703e-02f, 8.64311606e-02f, -2.70182062e-02f, 8.00701901e-02f, -5.57103083e-02f, -1.13158233e-01f, -1.37382289e-02f, -2.85954606e-02f, -2.82584392e-02f,
  -2.76203323e-02f, -6.95511047e-03f, -6.67473227e-02f, -7.23785162e-02f, 3.36576402e-02f, -5.25138937e-02f, -5.19946069e-02f, 4.86746952e-02f, -1.14392284e-02f, 7.39086047e-03f,
  -6.57823160e-02f, 9.16419923e-02f, 2.59964522e-02f, 1.48945097e-02f, -1.42055973e-02f, 8.98928344e-02f, -3.65596339e-02f, 9.49819982e-02f, -7.16602281e-02f, -1.03918239e-01f,
  -5.36982194e-02f, -1.45393913e-03f, 4.61404771e-02f, 3.34425550e-03f, 2.29530446e-02f, 5.13197742e-02f, -3.40334885e-02f, -1.91783831e-02f, -5.02634794e-02f, -2.70192814e-03f,
  7.63356984e-02f, 1.63648147e-02f, 2.90937955e-03f, -2.21991260e-02f, -6.39610440e-02f, 1.03514805e-01f, 3.18799540e-02f, -1.18230600e-02f, 1.48801338e-02f, 1.86206456e-02f,
  1.14308067e-01f, -1.64298534e-01f, -2.52073973e-01f, -5.35858124e-02f, -7.31639490e-02f, -1.43316641e-01f, -8.01212490e-02f, -5.00940830e-02f, -8.28766301e-02f, -1.29722223e-01f,
  -7.82225803e-02f, -7.65926670e-03f, -4.86892052e-02f, -2.90068369e-02f, 2.04174872e-02f, -5.78533970e-02f, -1.21305406e-01f, 1.43898800e-02f, 1.07436404e-01f, 1.54398650e-01f,
  -5.08164614e-02f, -6.00925274e-02f, 3.64558175e-02f, -2.68060490e-02f, -1.78701710e-02f, -1.25562266e-01f, -2.14739636e-01f, -3.43283117e-02f, -3.80017646e-02f, -1.96628362e-01f,
  -1.50668666e-01f, -1.98013838e-02f, 9.24158767e-02f, 8.19893330e-02f, -9.05941997e-04f, 5.28011657e-02f, -6.54020905e-02f, -2.80209221e-02f, 8.01960528e-02f, 5.49869910e-02f,
  -9.64471996e-02f, 6.40712082e-02f, 4.67926450e-02f, -3.03566940e-02f, 9.03295279e-02f, -5.11776842e-02f, 4.46936041e-02f, 7.59480819e-02f, -5.00114523e-02f, -3.80213447e-02f,
  -4.50539738e-02f, -2.10011769e-02f, 8.55392516e-02f, 5.80951609e-02f, 7.50602037e-02f, -8.40616003e-02f, -3.82135846e-02f, 2.98889987e-02f, 8.50052983e-02f, 2.00647656e-02f,
  2.62549967e-02f, -3.71717550e-02f, -1.51860192e-02f, 6.02431707e-02f, 7.97390267e-02f, -2.21139230e-02f, 3.61637063e-02f, 3.62879150e-02f, 6.79858848e-02f, 2.77659260e-02f,
  6.06047399e-02f, -1.31127210e-02f, -9.24692973e-02f, 8.68206546e-02f, -6.98788017e-02f, -5.93052097e-02f, -5.32259000e-04f, 7.29617104e-02f, -2.95604300e-02f, -3.94283002e-03f,
  7.97904842e-03f, 2.96204183e-02f, -7.71529898e-02f, 3.64826364e-03f, -1.21944889e-01f, -7.82921258e-03f, -9.67791025e-03f, -4.16270755e-02f, -7.83843920e-02f, 2.52237897e-02f,
  1.61480054e-01f, 3.13514657e-02f, -3.09470557e-02f, 5.61271310e-02f, -7.33332336e-02f, -2.64273081e-02f, -9.36748385e-02f, 4.92293611e-02f, 6.60749227e-02f, 5.95383868e-02f,
  -2.18008850e-02f, 1.12727515e-01f, 5.98993562e-02f, 6.83164075e-02f, 1.09576203e-01f, 4.25921492e-02f, 5.27761430e-02f, 5.77928405e-03f, -6.83911219e-02f, -9.12417471e-02f,
  4.86650690e-02f, -3.59339900e-02f, 1.33104578e-01f, -5.77387474e-02f, -2.10198220e-02f, 8.84843469e-02f, 1.80870425e-02f, 9.31970254e-02f, -4.25351696e-04f, 4.72426740e-03f,
  -1.22189455e-01f, -1.25465751e-01f, 8.10805187e-02f, -1.85153931e-02f, 3.81500088e-03f, 8.86212960e-02f, -1.37174819e-02f, -2.34006923e-02f, -8.17921162e-02f, 4.65850420e-02f,
  -7.19435290e-02f, 7.33172297e-02f, -6.86755553e-02f, 2.95086764e-02f, 2.23175455e-02f, -1.32973433e-01f, -1.25549272e-01f, -3.13774049e-02f, -3.31632234e-02f, -4.51780185e-02f,
  -4.60035317e-02f, -7.03485012e-02f, -3.83826233e-02f, -1.18349850e-01f, -2.35831309e-02f, -4.57732342e-02f, -3.43637466e-02f, 7.48823807e-02f, -3.72797363e-02f, -3.62695679e-02f,
  1.88324768e-02f, -2.34564077e-02f, -7.06559941e-02f, 4.18922193e-02f, -2.46232133e-02f, 1.37813035e-02f, 7.98576418e-03f, -1.34672457e-03f, 6.26688600e-02f, -3.25989947e-02f,
  -1.26992026e-02f, 8.82622823e-02f, 7.68895447e-02f, -6.62713572e-02f, 2.37659458e-02f, -1.06450766e-02f, -6.00349568e-02f, -4.33925427e-02f, 6.92797527e-02f, -3.84084973e-03f,
  -1.01505816e-02f, 4.54148166e-02f, -7.75892008e-03f, 2.77680941e-02f, 9.31411013e-02f, 8.52666497e-02f, -4.70659044e-03f, -3.04290429e-02f, -4.03442420e-02f, -3.41830365e-02f,
  2.64423564e-02f, 6.23363033e-02f, 2.56884024e-02f, -4.08684239e-02f, -1.72300637e-02f, 2.90455688e-02f, -4.49615493e-02f, 2.28793826e-04f, -7.62105733e-02f, -7.73460791e-02f,
  -5.16772345e-02f, -4.60556634e-02f, -2.48044357e-02f, -4.37151343e-02f, -5.81020117e-02f, -4.95786592e-02f, -8.52896459e-03f, -4.62349840e-02f, 6.98337972e-04f, 9.94919799e-03f,
  4.85256203e-02f, 3.12100928e-02f, -4.29797098e-02f, 3.34871374e-03f, -1.44246966e-02f, -3.60348523e-02f, -6.63184980e-03f, 8.94429684e-02f, 6.23740517e-02f, 8.14176649e-02f,
  3.05434354e-02f, 8.35572742e-03f, -4.51057218e-02f, -3.30200270e-02f, 1.04161210e-01f, 7.65291825e-02f, -4.88103107e-02f, 3.84002253e-02f, -4.20053899e-02f, 5.02358936e-02f,
  -4.25574444e-02f, -2.80407052e-02f, 1.90358534e-02f, -3.40942889e-02f, -9.50668473e-03f, 4.53452431e-02f, -1.19751349e-01f, 5.16383201e-02f, -8.03494826e-02f, 9.26688407e-03f,
  -9.21385363e-02f, -7.00759739e-02f, -4.00200672e-02f, -8.26470405e-02f, 3.30195837e-02f, 6.47353306e-02f, 7.55221397e-02f, 2.97455327e-03f, 8.33972767e-02f, -8.82460363e-03f,
  2.92243063e-02f, 6.53284416e-02f, -1.45874038e-01f, 4.38395031e-02f, -1.12889923e-01f, -1.34524867e-01f, -2.90749017e-02f, 5.99516882e-03f, 4.49946858e-02f, -2.42534112e-02f,
  8.92338902e-02f, 1.13776125e-01f, -6.66608522e-03f, 2.34701727e-02f, -5.88813657e-03f, -1.31158724e-01f, -9.69360247e-02f, -2.24138722e-02f, 7.57282227e-02f, -1.51619427e-02f,
  -4.41628415e-03f, -8.53268057e-02f, -4.82242964e-02f, -9.19786021e-02f, 5.59311211e-02f, -7.65280202e-02f, -5.79269044e-02f, -6.08102679e-02f, -2.41025575e-02f, 4.83677424e-02f,
  7.65748397e-02f, 7.75456661e-03f, 1.79184638e-02f, -3.25504430e-02f, -1.65390726e-02f, -6.44332841e-02f, -3.52747515e-02f, -8.80245715e-02f, 8.85128379e-02f, -8.89051855e-02f,
  -2.98078209e-02f, 4.44636866e-02f, -2.42927228e-03f, 8.63015130e-02f, 5.66251054e-02f, 5.16352393e-02f, -4.63418290e-03f, -9.43707675e-02f, 5.53704053e-02f, 3.37339118e-02f,
  8.84091929e-02f, -1.27811767e-02f, 5.06204106e-02f, -3.74443531e-02f, -2.62960009e-02f, 5.13955131e-02f, 7.49524236e-02f, 7.56412596e-02f, -7.39589392e-04f, 6.62534460e-02f,
  -1.18075488e-02f, 8.30543861e-02f, 9.96454656e-02f, -5.78288808e-02f, -7.70607498e-03f, 3.36026191e-03f, -4.57113124e-02f, 6.08647540e-02f, -3.77816185e-02f, 6.68236613e-02f,
  4.06119786e-02f, 7.74298087e-02f, -3.17941867e-02f, -4.84911278e-02f, 8.08771998e-02f, -2.17232900e-03f, 7.49698728e-02f, 9.81905833e-02f, 7.79144764e-02f, 3.04065067e-02f,
  -6.94602802e-02f, 3.23112346e-02f, -3.71770225e-02f, 4.43462934e-03f, -9.52388626e-03f, -4.30534184e-02f, 7.06971064e-02f, 5.13018072e-02f, 4.86360975e-02f, 3.26483138e-02f,
  1.27157167e-01f, -8.81993100e-02f, 8.50415081e-02f, 8.77438188e-02f, -1.17672399e-01f, -6.56378120e-02f, -7.81466812e-03f, -6.22068830e-02f, -3.64950523e-02f, -3.10025625e-02f,
  -5.16397990e-02f, -2.52800453e-02f, 7.94970095e-02f, -9.77393799e-03f, 3.88277955e-02f, -7.60741830e-02f, -2.79341694e-02f, 1.99430771e-02f, -2.76432205e-02f, 3.17986906e-02f,
  -7.54623674e-03f, -7.51399696e-02f, -4.60860133e-02f, -2.37505138e-03f, 1.83240455e-02f, -7.49641359e-02f, -3.90474349e-02f, 3.17849405e-02f, -3.90416384e-02f, 6.93928450e-03f,
  -6.71069697e-02f, -1.01399370e-01f, 1.23446316e-01f, -1.05807045e-02f, -1.22170396e-01f, -1.19227313e-01f, -1.75267994e-01f, -9.33583528e-02f, -1.01008505e-01f, -8.36524814e-02f,
  -4.41568233e-02f, 2.13648304e-02f, -2.80901752e-02f, 1.01242475e-02f, 6.84420466e-02f, -8.38361401e-03f, 1.30985141e-01f, 1.66924834e-01f, 2.29901280e-02f, 1.18085677e-02f,
  -9.95679125e-02f, -5.55327870e-02f, 1.18788317e-01f, 8.09627622e-02f, 1.20365135e-01f, -6.08207611e-03f, 9.58123580e-02f, 1.15479514e-01f, -2.73397309e-03f, 9.96060967e-02f,
  7.42904900e-04f, 7.71841258e-02f, -2.86953431e-02f, 1.92638880e-04f, -1.01865649e-01f, -1.08390497e-02f, -1.44105759e-02f, 2.40937993e-02f, -9.58839729e-02f, -3.44409384e-02f,
  -3.99780385e-02f, -8.80988166e-02f, -2.80162655e-02f, 1.73540041e-02f, 4.89028059e-02f, -3.17331925e-02f, -2.90983468e-02f, 9.65065286e-02f, -3.14512639e-03f, -7.78483897e-02f,
  -1.10610485e-01f, -1.16824940e-01f, -4.71573044e-03f, -9.06975046e-02f, 1.45299034e-02f, -4.89779115e-02f, 7.21454853e-04f, 8.38340148e-02f, -7.35769495e-02f, 4.41077389e-02f,
  2.01401319e-02f, -3.04395296e-02f, -9.17619318e-02f, 6.24746308e-02f, 5.74225374e-02f, -6.56056330e-02f, 1.73844639e-02f, -6.20093420e-02f, 3.90136167e-02f, 8.81201923e-02f,
  -4.86094356e-02f, -4.12947498e-02f, -3.84098738e-02f, 5.74148931e-02f, 9.71292704e-02f, 6.37094080e-02f, 5.95435873e-02f, 3.89113203e-02f, 4.51074503e-02f, -5.15717939e-02f,
  -3.81855555e-02f, -5.59998630e-03f, 4.90364023e-02f, 5.87820783e-02f, -4.23549078e-02f, 3.06321550e-02f, -7.08780214e-02f, -5.26286587e-02f, 5.03511243e-02f, 1.60788040e-05f,
  -1.06530160e-01f, -6.70955703e-02f, -1.67021081e-02f, -7.99767897e-02f, 2.75961719e-02f, -1.28283678e-03f, -3.53370979e-02f, 4.06093784e-02f, -1.24673340e-02f, 5.42560667e-02f,
  -1.04292221e-01f, -7.19554573e-02f, -5.69807887e-02f, -3.95462364e-02f, 1.53175564e-02f, 1.62793640e-02f, -8.15038085e-02f, -6.13810644e-02f, -1.54384617e-02f, -7.34870210e-02f,
  3.14657018e-02f, -1.39975220e-01f, -7.62331262e-02f, 4.53512068e-04f, -8.57467726e-02f, -1.53645784e-01f, -7.20592886e-02f, -1.14257544e-01f, -2.66635884e-02f, -1.69936717e-01f,
  -1.21953629e-01f, -6.54049516e-02f, 6.80570230e-02f, 3.44618745e-02f, -3.69314179e-02f, 6.22774214e-02f, 4.22779880e-02f, 9.85907093e-02f, -7.15110973e-02f, -1.51240882e-02f,
  -7.35046342e-02f, 3.91978472e-02f, 6.43068254e-02f, -7.88997710e-02f, 1.03204966e-01f, 5.34889586e-02f, 3.99101004e-02f, 5.29037826e-02f, 4.62032035e-02f, -1.64562762e-02f,
  -8.60681906e-02f, 2.86898110e-02f, 1.71854754e-03f, 2.38742307e-02f, 4.84589003e-02f, -4.25902680e-02f, -4.40985896e-02f, -5.63429035e-02f, -5.27155064e-02f, 2.61166245e-02f,
  5.28214313e-02f, -2.40774127e-03f, 6.57862499e-02f, 2.11600829e-02f, -9.55124665e-03f, 9.96407941e-02f, -3.94585729e-02f, 1.46880373e-02f, 9.90206525e-02f, -2.53322292e-02f,
  7.66650960e-02f, -6.07573688e-02f, 5.74928187e-02f, 2.17590723e-02f, -4.62664366e-02f, 9.85509828e-02f, 8.20301920e-02f, -3.51193398e-02f, 1.51429297e-02f, 8.01719725e-02f,
  4.64189909e-02f, 3.99144180e-02f, 9.02158022e-02f, -3.14303301e-03f, 2.64023189e-02f, -7.13401437e-02f, 5.73574156e-02f, 2.94597410e-02f, 3.92775238e-02f, 1.15714995e-02f,
  -1.37324343e-02f, -8.69544894e-02f, 3.82004865e-02f, -3.59511450e-02f, -7.40967989e-02f, -9.09981951e-02f, 1.76383350e-02f, -5.23762181e-02f, 4.29939702e-02f, 5.45494631e-02f,
  2.29514800e-02f, 5.25357015e-02f, 2.51837857e-02f, -3.87184471e-02f, -9.42108035e-02f, -3.63501832e-02f, -1.60606615e-02f, -2.66195796e-02f, -8.46454687e-03f, -3.55227701e-02f,
  4.47759591e-02f, 7.18727186e-02f, 3.99530306e-03f, -2.59970687e-02f, 1.02815796e-02f, 6.65823743e-02f, 7.36033618e-02f, -1.12276105e-02f, -5.83132021e-02f, 3.02590756e-03f,
  1.24230376e-02f, -5.34414090e-02f, 4.98616649e-03f, 1.69531833e-02f, 8.64477903e-02f, 5.72801568e-02f, 4.62248623e-02f, 6.71950877e-02f, 6.92963079e-02f, 5.53697161e-02f,
  8.92308205e-02f, 2.14308035e-02f, 5.64254075e-02f, 9.89710018e-02f, -1.84324756e-02f, 8.51443261e-02f, 9.00571942e-02f, -8.07905123e-02f, -5.35273105e-02f, 7.60009214e-02f,
  8.37219581e-02f, -1.53489346e-02f, -9.99794006e-02f, -1.09086763e-02f, -7.22595155e-02f, 1.89701910e-03f, 3.48984972e-02f, 4.65064719e-02f, -9.27620381e-02f, -6.14116713e-02f,
  1.60126816e-02f, 5.45179956e-02f, -1.10475793e-01f, 1.03485025e-01f, -1.05103869e-02f, 1.88142303e-02f, -1.16562650e-01f, 7.80471042e-02f, 7.32428133e-02f, -1.47035439e-02f,
  7.82544091e-02f, -7.28438944e-02f, 2.58394219e-02f, 9.26075561e-04f, -1.30823687e-01f, -8.77913982e-02f, -8.65364745e-02f, -1.03991866e-01f, -8.39397591e-03f, 7.11617172e-02f,
  8.68642479e-02f, 6.22903928e-02f, 5.36549129e-02f, -7.83493817e-02f, 7.54888803e-02f, -7.73660019e-02f, -6.27395213e-02f, -3.19782570e-02f, -5.64672844e-03f, 1.26674205e-01f,
  3.79626676e-02f, 8.69510695e-02f, -2.68718656e-02f, -3.97553779e-02f, 3.09843719e-02f, 8.58813226e-02f, 5.01442142e-02f, 3.06299385e-02f, 7.00442195e-02f, -4.26315218e-02f,
  -1.74120888e-02f, -6.60792738e-02f, 7.48633519e-02f, 4.29877527e-02f, 5.69344908e-02f, -3.75216664e-03f, -4.03289758e-02f, 5.99877089e-02f, -3.96339670e-02f, 1.16714172e-01f,
  1.12116439e-02f, 4.01056558e-02f, 6.35488555e-02f, -9.31490883e-02f, 4.76926453e-02f, -2.65275016e-02f, 7.61919830e-04f, -2.49221586e-02f, 3.09164021e-02f, 5.35930786e-03f,
  3.25022414e-02f, -1.23109696e-02f, 3.07729904e-04f, -9.84093919e-03f, -8.01258311e-02f, 5.81453107e-02f, 4.32843119e-02f, 1.25311047e-03f, -3.80156524e-02f, 7.11340532e-02f,
  -3.25340107e-02f, -2.75964141e-02f, 3.15758176e-02f, -3.95595729e-02f, -8.24032649e-02f, 3.99442501e-02f, -7.03641400e-02f, -5.01058958e-02f, -4.51975539e-02f, -5.07750921e-02f,
  1.50068644e-02f, 7.49998316e-02f, 6.76691756e-02f, -5.54177873e-02f, -4.54359874e-02f, -2.68997103e-02f, 6.71247616e-02f, -5.80637306e-02f, -9.77193862e-02f, -5.30899055e-02f,
  -2.37634964e-02f, -1.57975093e-01f, -4.94783781e-02f, -4.09829766e-02f, 7.50640780e-02f, 7.40108043e-02f, 2.00985167e-02f, 9.28895921e-02f, 3.59772220e-02f, 2.46493146e-03f,
  6.16629981e-02f, -3.52386199e-02f, -9.46740508e-02f, 2.16850974e-02f, -4.96844202e-02f, -4.09127995e-02f, 5.62975137e-03f, 8.54196176e-02f, 6.25613108e-02f, -9.87301115e-03f,
  -2.09023082e-03f, -4.62303013e-02f, -7.51311257e-02f, 4.53507453e-02f, 1.11888992e-02f, -4.19854410e-02f, -5.21154255e-02f, -6.43617138e-02f, -1.18752770e-01f, -9.16890875e-02f,
  1.18374474e-01f, 2.96100415e-02f, -4.61366475e-02f, 7.69620836e-02f, 5.22382371e-02f, -2.08731964e-02f, 4.83857431e-02f, -7.75142536e-02f, 6.12392798e-02f, 9.88827199e-02f,
  7.88747519e-02f, 1.29627466e-01f, 2.38240995e-02f, 9.65509936e-02f, 4.87054251e-02f, -8.53179917e-02f, -5.65135181e-02f, -4.71209781e-03f, -7.44829848e-02f, -3.14477161e-02f,
  1.10465951e-01f, 9.20891985e-02f, 7.55676255e-02f, -9.57794208e-03f, 4.89863046e-02f, 4.37505990e-02f, -1.43271042e-02f, 1.02895275e-02f, -3.32377455e-03f, 6.44504130e-02f,
  2.09074095e-02f, 7.27118924e-02f, 4.39076573e-02f, 6.61063865e-02f, 7.57372901e-02f, -1.03959315e-01f, 7.21145943e-02f, 2.43808068e-02f, -6.26563132e-02f, -3.06140780e-02f,
  -6.54025748e-02f, 2.45266370e-02f, -1.50209926e-02f, 3.47577892e-02f, 6.51573166e-02f, -2.56033465e-02f, -3.05251218e-02f, 2.08443627e-02f, -7.86735956e-03f, -2.06631757e-02f,
  -2.08237506e-02f, -3.89722101e-02f, -3.66861671e-02f, 5.45436740e-02f, -3.34353372e-02f, 5.07987440e-02f, -6.79942742e-02f, -5.14444150e-02f, -8.20410773e-02f, 6.14280477e-02f,
  -8.84480774e-03f, -4.35116254e-02f, 4.20918204e-02f, -5.14798574e-02f, 4.18837853e-02f, -7.04657957e-02f, 6.57097772e-02f, -9.59724560e-03f, -8.92725587e-03f, 6.05141707e-02f,
  -3.75317857e-02f, 1.35400137e-02f, -2.29473766e-02f, -5.00782840e-02f, 7.87864253e-02f, -1.05369091e-01f, 4.33792137e-02f, -4.40057833e-03f, -8.36428627e-02f, -5.58062866e-02f,
  2.85563711e-02f, -4.19281796e-02f, -6.08308092e-02f, -1.42474044e-02f, 1.96672548e-02f, -2.64529362e-02f, 7.30781257e-03f, 4.01940346e-02f, 3.79642062e-02f, 5.14232740e-02f,
  -1.72217172e-02f, 1.03222832e-01f, 6.59037903e-02f, 5.80829047e-02f, 7.54827112e-02f, -7.50887468e-02f, 4.05269526e-02f, 9.38757509e-02f, 9.89254862e-02f, -1.40729761e-02f,
  -6.46019876e-02f, -1.85097358e-03f, 5.36749996e-02f, 3.57344449e-02f, -3.48418206e-02f, 4.90301363e-02f, -2.06486176e-04f, -5.52347302e-02f, -1.41962655e-02f, 5.18067107e-02f,
  -1.00088656e-01f, -6.02539778e-02f, 3.48518007e-02f, -7.90855363e-02f, -1.69404522e-02f, 8.66665170e-02f, -5.75487465e-02f, -8.32818076e-02f, 2.21592225e-02f, -1.32402211e-01f,
  -1.06834313e-02f, 1.10133007e-01f, 2.60423739e-02f, 1.25891879e-01f, 1.47117302e-01f, 1.47799566e-01f, 1.12667784e-01f, -2.22170558e-02f, 7.50671551e-02f, 4.81584109e-02f,
  6.71666414e-02f, 3.72023433e-02f, -6.96453080e-02f, 1.62941702e-02f, 8.69316980e-03f, -7.34601170e-02f, -9.76499841e-02f, 4.89859022e-02f, -7.55083412e-02f, -5.06413840e-02f,
  1.17209926e-01f, 3.04794461e-02f, -6.78706728e-03f, 3.78256552e-02f, 9.94209349e-02f, -7.32300505e-02f, 5.93914539e-02f, 7.65754981e-03f, 9.48412195e-02f, -1.04084842e-01f,
  3.13857640e-03f, 5.15966117e-02f, 3.27666774e-02f, 5.29649891e-02f, -6.82711229e-02f, -2.19285041e-02f, 3.64489034e-02f, 7.65854912e-03f, 9.42487270e-03f, -7.19067901e-02f,
  1.27050355e-02f, -7.94030279e-02f, 3.59591059e-02f, 3.75400740e-03f, -4.66819666e-02f, 8.03653430e-03f, -6.72674999e-02f, -8.17608610e-02f, 2.25419514e-02f, -1.18691184e-01f,
  -5.94163649e-02f, 8.92687067e-02f, 7.99640641e-02f, -9.90417227e-02f, -1.18620813e-01f, -9.35757533e-02f, 4.06259671e-02f, 5.19742891e-02f, -7.70496354e-02f, -8.42745155e-02f,
  -6.19835556e-02f, -8.50008354e-02f, -6.44787177e-02f, -7.02783540e-02f, -5.22830430e-03f, -7.65686622e-03f, -6.10490851e-02f, -8.81667435e-03f, 1.73281413e-02f, 7.97813907e-02f,
  5.13920374e-02f, -2.94021107e-02f, -5.92778903e-03f, -1.74355414e-02f, 2.53267474e-02f, -1.91528890e-02f, -3.91763523e-02f, 1.84104443e-02f, -2.61901338e-02f, 6.20477833e-02f,
  -7.46494010e-02f, -6.94800839e-02f, 3.35073285e-02f, -3.10486276e-02f, -9.21881795e-02f, 2.71672811e-02f, 9.14780237e-03f, -1.39566176e-02f, -6.99957684e-02f, 5.03434753e-03f,
  -1.06795542e-02f, -6.86461702e-02f, -2.45046746e-02f, 4.02483977e-02f, 6.20930381e-02f, 6.50152266e-02f, -4.75608278e-03f, 4.88659814e-02f, 7.59430453e-02f, -4.70619500e-02f,
  8.41976926e-02f, 2.01481972e-02f, 4.09084707e-02f, 5.03341854e-02f, -1.10624013e-02f, 5.80897927e-02f, 5.44483662e-02f, 1.72165073e-02f, -1.71273816e-02f, -6.28419146e-02f,
  -7.78312460e-02f, -4.20725942e-02f, 4.50974964e-02f, -4.81987856e-02f, 1.35956239e-02f, -9.99528449e-03f, 1.01217322e-01f, -4.23890203e-02f, -1.34105282e-02f, 8.36052075e-02f,
  -1.91022262e-01f, -8.11293423e-02f, -4.90566716e-02f, 4.02220711e-02f, -1.64567083e-02f, 7.53227398e-02f, 9.08054486e-02f, -3.36026493e-03f, 1.46180568e-02f, -1.69462115e-02f,
  1.45504316e-02f, -6.87745512e-02f, 3.20591480e-02f, 9.34233982e-03f, -7.09935278e-03f, -5.71981259e-02f, -8.93901661e-02f, 1.63928941e-02f, 5.02960570e-02f, 2.00718511e-02f,
  -2.85309087e-02f, -1.06329218e-01f, -6.18626550e-02f, -7.43463412e-02f, 7.33185038e-02f, -9.42484662e-02f, -1.13497615e-01f, -3.64088267e-02f, 4.85799275e-02f, -9.08211619e-02f,
  1.36678591e-02f, -8.65266398e-02f, 7.71614760e-02f, 7.61042954e-03f, -8.21324065e-02f, -8.76033381e-02f, 3.36248390e-02f, 6.84300587e-02f, -1.62590947e-02f, -1.22198630e-02f,
  -6.48057461e-02f, 4.97575775e-02f, 6.84013888e-02f, 3.26443724e-02f, -8.90064538e-02f, -4.08483930e-02f, -8.55807066e-02f, 7.21403733e-02f, -5.07588647e-02f, 8.13900009e-02f,
  -9.75371599e-02f, -4.37130257e-02f, -6.68182224e-02f, -6.03935756e-02f, -7.01022800e-03f, -4.20612022e-02f, 8.02650303e-02f, 1.30648995e-02f, 4.52416204e-03f, -6.33184090e-02f,
  -9.42659900e-02f, -5.59598953e-02f, 5.81962913e-02f, 1.36380200e-03f, 3.28486450e-02f, -9.78541449e-02f, -1.05144251e-02f, 5.00049405e-02f, -2.35378724e-02f, 6.36397749e-02f,
  -2.23391471e-05f, 4.18571904e-02f, 2.00689975e-02f, -1.94794666e-02f, 6.19390607e-02f, 4.45637107e-02f, 6.81862608e-02f, 6.42355159e-02f, -5.22964224e-02f, 5.11151180e-02f,
  5.21886274e-02f, 1.22587737e-02f, -7.47818649e-02f, 4.64112777e-03f, -1.26599576e-02f, 2.64290124e-02f, 1.01292059e-02f, 1.92659646e-02f, 1.82842724e-02f, -7.98904374e-02f,
  6.82992861e-02f, -5.49555980e-02f, -2.59176567e-02f, 1.02740422e-01f, -6.78476915e-02f, 4.03971374e-02f, -7.61361793e-02f, -9.19998661e-02f, 3.15181352e-02f, 2.97570918e-02f,
  1.07113179e-02f, 5.51867336e-02f, -6.17995076e-02f, 3.61873433e-02f, -3.20971757e-03f, -1.30689191e-02f, -9.23066065e-02f, -8.97103921e-03f, -7.13197468e-03f, -8.05334598e-02f,
  -7.02255517e-02f, -6.96549639e-02f, 9.12005976e-02f, 7.36216530e-02f, 3.40932719e-02f, -5.46698831e-02f, -2.58576125e-02f, 4.49845232e-02f, 7.39556774e-02f, 7.87397921e-02f,
  -3.27604823e-02f, 6.08190857e-02f, -1.18446417e-01f, 8.63170028e-02f, 1.11760423e-01f, 3.71297747e-02f, -1.25632226e-01f, -2.74867341e-02f, 9.82241482e-02f, 4.68790941e-02f,
  2.47637741e-02f, 1.49366930e-01f, 1.10167712e-01f, 6.69121882e-03f, -1.42388552e-01f, -4.05140743e-02f, -3.18934172e-02f, -6.88499510e-02f, -9.92475376e-02f, -4.70619574e-02f,
  1.60182610e-01f, 1.23345323e-01f, -9.31262039e-03f, -3.91279198e-02f, 1.42929420e-01f, 3.45495492e-02f, -5.64736053e-02f, 6.00268133e-02f, -3.38415466e-02f, 4.53261621e-02f,
  -8.06897208e-02f, -7.59824514e-02f, -1.32982612e-01f, 1.15730509e-01f, -1.73583254e-02f, -2.67268089e-03f, -2.89829504e-02f, -6.02147281e-02f, -7.54177123e-02f, -4.28503640e-02f,
  -1.75736006e-02f, -7.78021142e-02f, -1.29066464e-02f, -6.98359758e-02f, 2.14106292e-02f, 1.58401132e-02f, -1.04112804e-01f, -1.32733379e-02f, -6.30814061e-02f, -1.23687007e-01f,
  1.17319062e-01f, 9.47221965e-02f, -1.46652132e-01f, -5.42218164e-02f, -1.61622003e-01f, 1.06281899e-04f, 1.76546257e-02f, -4.51922379e-02f, -1.63850784e-01f, -7.33180866e-02f,
  4.36356105e-02f, -9.16822776e-02f, -6.71247244e-02f, -8.80307108e-02f, -1.28695127e-02f, 1.03456415e-02f, -1.84338365e-03f, -7.56011233e-02f, -9.29181427e-02f, 2.78145680e-03f,
  2.09651552e-02f, 1.72323678e-02f, -5.21109030e-02f, -5.00720888e-02f, 4.15138230e-02f, -1.80884507e-02f, -4.00431082e-02f, -6.40138090e-02f, 3.52032110e-02f, -8.84757489e-02f,
  2.17346773e-02f, -9.03941691e-02f, 8.12108815e-02f, -1.67310964e-02f, -9.10628513e-02f, -9.29497927e-02f, 3.34962979e-02f, -4.72480617e-02f, -9.99534782e-03f, -2.04262827e-02f,
  6.82429746e-02f, -7.76963085e-02f, -2.38234904e-02f, -9.17552635e-02f, 5.81377000e-02f, 3.94969285e-02f, 5.70549779e-02f, -2.26790132e-03f, 2.20120624e-02f, -1.18463203e-01f,
  2.24282257e-02f, -2.70041078e-03f, 6.53394610e-02f, 1.96786947e-03f, 1.12948883e-02f, -9.05732140e-02f, -5.13511412e-02f, -4.36518677e-02f, -6.15900420e-02f, -6.51376098e-02f,
  -5.87644055e-02f, -9.04244464e-03f, -8.71702805e-02f, -3.48904617e-02f, -1.12055272e-01f, -4.66657095e-02f, -1.19661829e-02f, -1.52101189e-01f, -9.84139293e-02f, -9.62558985e-02f,
  -2.26918027e-01f, 2.51504667e-02f, 1.18221730e-01f, -1.74950033e-01f, -9.27827731e-02f, 3.31432745e-02f, -6.49536178e-02f, -7.69930184e-02f, -2.23379936e-02f, -6.85166866e-02f,
  -8.24710503e-02f, -6.24503614e-03f, 7.66081363e-02f, 1.27277598e-01f, -1.79638958e-03f, -2.14249920e-02f, -3.38679813e-02f, 9.99724939e-02f, 4.82324921e-02f, -1.07106715e-01f,
  -1.70902070e-02f, -1.37920931e-01f, -1.00369394e-01f, -1.21295735e-01f, -1.41867459e-01f, -7.61002377e-02f, 4.35119085e-02f, -4.03829776e-02f, -3.07353269e-02f, -1.53145194e-01f,
  1.16281152e-01f, -1.11348867e-01f, 9.27973073e-03f, 3.51968706e-02f, 2.05580909e-02f, 1.86379757e-02f, 2.75102463e-02f, -1.19484715e-01f, 4.29742225e-02f, 6.05936609e-02f,
  6.21832684e-02f, -8.94011259e-02f, -3.37647386e-02f, -8.49787667e-02f, -2.18646228e-02f, -7.00086430e-02f, -2.18798891e-02f, -4.61252183e-02f, -6.61029071e-02f, 3.32456492e-02f,
  4.43935581e-02f, -1.49860494e-02f, -1.49469115e-02f, 1.05708048e-01f, -2.87525672e-02f, 3.63594182e-02f, 9.51940790e-02f, 2.28959136e-02f, -4.91856365e-03f, -1.01197861e-01f,
  -2.78207138e-02f, 1.13768950e-02f, 7.86738237e-04f, 1.81110092e-02f, 4.06432301e-02f, 4.66460325e-02f, 4.19564582e-02f, -1.32866865e-02f, -7.92164952e-02f, -4.27366905e-02f,
  -4.86156195e-02f, -3.88026983e-02f, 2.05182880e-02f, -1.55114084e-02f, 2.37268005e-02f, -5.16015254e-02f, 4.35938388e-02f, 8.96771774e-02f, 7.34573007e-02f, -3.29850838e-02f,
  7.69313099e-03f, 6.49612173e-02f, 2.85469741e-02f, 3.42041962e-02f, -6.10895902e-02f, -4.76907082e-02f, 9.32671800e-02f, -2.29660012e-02f, -3.78382243e-02f, -1.76075455e-02f,
  4.42125387e-02f, 1.41782060e-01f, -5.72341233e-02f, -2.00488549e-02f, -2.97523551e-02f, -4.73779589e-02f, -5.82876466e-02f, -6.69819564e-02f, -1.89280473e-02f, -3.81468539e-03f,
  2.00166348e-02f, -6.84670061e-02f, 4.31904383e-02f, 3.56442295e-02f, 6.85043857e-02f, 2.27394216e-02f, -9.37808156e-02f, 6.47698194e-02f, 1.02778547e-01f, 9.75058228e-03f,
  5.46242557e-02f, -3.13937180e-02f, 4.74932715e-02f, -3.88063751e-02f, 3.51236872e-02f, 1.15225174e-01f, 1.29279166e-01f, -6.88528316e-03f, 1.36115447e-01f, -4.88266498e-02f,
  4.10885476e-02f, 5.35666160e-02f, 9.47398841e-02f, 2.83262040e-02f, 5.96031807e-02f, 3.85017470e-02f, 7.43722245e-02f, 5.57776354e-02f, -1.16305023e-01f, -9.77556929e-02f,
  3.55460197e-02f, -9.77824703e-02f, 3.33907828e-03f, 2.44859327e-02f, -3.11263353e-02f, -5.55558465e-02f, 2.17484515e-02f, -1.82265472e-02f, 7.43756145e-02f, 9.38194245e-02f,
  -4.09386456e-02f, -1.75153203e-02f, 5.74204214e-02f, 5.71542978e-02f, -1.22376839e-02f, -8.80518556e-02f, -5.75201474e-02f, -1.13778813e-02f, 3.63300852e-02f, -3.94102260e-02f,
  8.81253108e-02f, 9.96399745e-02f, -8.90128613e-02f, -2.84395348e-02f, 2.33095437e-02f, 6.33405708e-03f, -6.36108741e-02f, 1.14315145e-01f, -2.62013469e-02f, 1.04956232e-01f,
  3.14807370e-02f, 1.29812015e-02f, -2.91795228e-02f, 7.74451867e-02f, 1.05157122e-02f, 9.87750515e-02f, 4.76885661e-02f, 1.02697760e-01f, -3.35769635e-03f, -4.07924876e-02f,
  -9.44373980e-02f, 7.65181053e-03f, 2.87444219e-02f, -4.72207852e-02f, 7.46793523e-02f, 1.28859142e-02f, -1.09203365e-02f, -3.63725759e-02f, 5.08336723e-02f, -4.36853282e-02f,
  5.78381633e-03f, -3.80055234e-02f, -2.97121387e-02f, -5.89838810e-02f, -1.01169059e-02f, -8.62923339e-02f, 3.94691899e-02f, 2.00190358e-02f, -5.92629686e-02f, 4.00540195e-02f,
  5.88869266e-02f, 8.11558310e-03f, 7.12645352e-02f, 5.90270311e-02f, -2.20176782e-02f, -2.49188114e-02f, 1.04487659e-02f, 1.32038919e-02f, 5.57259247e-02f, -5.30161075e-02f,
  -6.56751618e-02f, 4.35055010e-02f, -5.81753924e-02f, -9.79116303e-04f, 7.37490132e-02f, 9.21381265e-02f, 2.41273083e-02f, -2.96397116e-02f, 7.55278841e-02f, -5.00952229e-02f,
  -8.04112256e-02f, 4.22257669e-02f, -1.51568070e-01f, -6.53777197e-02f, 6.39002472e-02f, 7.32802674e-02f, 5.01857959e-02f, -1.93178188e-02f, -3.48584317e-02f, 7.46176718e-03f,
  7.14643151e-02f, 7.20970482e-02f, -5.42081818e-02f, 4.95551974e-02f, 6.04880601e-02f, 5.17815202e-02f, 2.51407512e-02f, 6.69933185e-02f, -3.87153663e-02f, 8.28213692e-02f,
  5.96566722e-02f, -3.96278836e-02f, -1.76904351e-02f, 4.54264916e-02f, -1.69336926e-02f, -9.33723748e-02f, -4.04622406e-03f, -6.04597628e-02f, -8.27643499e-02f, -1.32420525e-01f,
  1.60174698e-01f, -6.06626756e-02f, 5.57156699e-03f, 1.53444439e-01f, 1.24835864e-01f, 1.77083388e-01f, 1.92902356e-01f, 1.20007180e-01f, -1.93076208e-02f, -1.16967689e-02f,
  5.92777096e-02f, -6.50391579e-02f, -1.24767087e-01f, -1.27248421e-01f, -4.58040982e-02f, 8.59275684e-02f, 1.17246330e-01f, -8.84042215e-03f, 4.02016379e-02f, 1.29519748e-02f,
  6.87913820e-02f, -1.80739295e-02f, 1.12912297e-01f, -7.12476522e-02f, -3.05424025e-03f, -5.30556254e-02f, 7.92614371e-02f, 1.10715643e-01f, 1.29452469e-02f, -2.50787158e-02f,
  -2.14305088e-01f, 1.22012116e-01f, -3.91354710e-02f, 5.65108582e-02f, -1.78450383e-02f, 2.72865891e-02f, -5.49531356e-02f, -1.23119988e-02f, -5.48569299e-02f, -5.22494316e-02f,
  4.34683487e-02f, 4.27531004e-02f, 4.91047613e-02f, 3.03231558e-04f, 1.68438181e-02f, 3.07195298e-02f, 5.62609099e-02f, -1.39291887e-03f, -2.13556122e-02f, 3.08046713e-02f,
  2.33758539e-02f, 1.13798968e-01f, -2.68950202e-02f, 7.53689185e-02f, 1.30973253e-02f, 7.56955445e-02f, 4.08511758e-02f, 3.49642113e-02f, -5.63102812e-02f, 7.20411912e-02f,
  1.46965710e-02f, -1.41515387e-02f, -8.69834423e-02f, 1.26387617e-02f, 7.32824057e-02f, -2.68685278e-02f, 1.43985935e-02f, -5.99642955e-02f, 6.02215119e-02f, 3.28842588e-02f,
  -2.33082455e-02f, 1.59000256e-03f, 8.03744197e-02f, 2.36139186e-02f, -1.31877204e-02f, -5.99777214e-02f, -5.82391880e-02f, -1.96629744e-02f, -3.31094787e-02f, 8.35652277e-02f,
  2.89732777e-02f, -5.16484343e-02f, 2.63882000e-02f, 7.89564773e-02f, -8.99129361e-02f, -3.08465213e-02f, 7.38911405e-02f, 4.89597768e-02f, 3.14614847e-02f, -2.65549291e-02f,
  7.71887377e-02f, 1.05008103e-01f, 7.65533594e-04f, -2.40473393e-02f, -3.06448117e-02f, 5.13864355e-03f, -6.66270107e-02f, -7.04704374e-02f, 1.80340204e-02f, 7.83752203e-02f,
  -7.38889426e-02f, -3.25916335e-02f, -9.70860794e-02f, -1.86959170e-02f, 9.29268599e-02f, 8.28313529e-02f, 2.36963537e-02f, 1.27321323e-02f, -7.31303394e-02f, -7.70064667e-02f,
  9.32701677e-02f, 1.30159721e-01f, 9.72510222e-03f, 4.88453358e-02f, -3.77730541e-02f, -2.76622809e-02f, 1.07417963e-01f, 4.81017530e-02f, 1.51515622e-02f, 1.40147507e-01f,
  1.20520212e-01f, -1.01687580e-01f, -1.18632354e-01f, -7.73912296e-03f, -7.18038296e-03f, 4.60027829e-02f, -1.59034893e-01f, 2.77471282e-02f, -2.03154571e-02f, 6.36150911e-02f,
  -3.97779010e-02f, 9.50192008e-03f, 2.17265747e-02f, -1.56318136e-02f, -1.45131022e-01f, -1.05903752e-01f, -6.07971400e-02f, -1.29471809e-01f, 5.42760231e-02f, -2.65943091e-02f,
  -1.22663220e-02f, 9.90970135e-02f, 2.51333863e-02f, -5.87266572e-02f, 1.42938003e-01f, -2.62756478e-02f, -1.13187470e-02f, -4.19455990e-02f, 8.65759626e-02f, 5.64806089e-02f,
  5.58991171e-02f, 3.98552865e-02f, -4.24482748e-02f, -3.05451192e-02f, -2.53280322e-03f, -6.88481927e-02f, 8.49647522e-02f, -2.01630946e-02f, 6.15820289e-02f, 4.33257893e-02f,
  8.16034973e-02f, -5.35960458e-02f, -5.04944548e-02f, -1.16922455e-02f, 7.23775476e-03f, -3.73823345e-02f, -1.02094427e-01f, -5.51047772e-02f, -1.19659677e-01f, 5.93088008e-02f,
  -6.02899566e-02f, 2.22980399e-02f, 5.51398173e-02f, -2.41079815e-02f, -3.33876424e-02f, -1.52742292e-03f, 2.00628545e-02f, 8.16205144e-02f, 3.12212985e-02f, 7.66917765e-02f,
  -8.17523301e-02f, 1.89669654e-02f, 8.34282860e-02f, 6.16459511e-02f, -9.87379532e-03f, -1.18070785e-02f, -8.16694871e-02f, 2.08255891e-02f, 1.89830875e-03f, -3.70639861e-02f,
  5.14306761e-02f, -4.19083200e-02f, -2.93584652e-02f, -9.92077589e-02f, -1.03605660e-02f, 4.62263450e-02f, -5.83120398e-02f, -8.58441368e-02f, -3.82632427e-02f, -8.78321156e-02f,
  1.67932548e-03f, 5.74124679e-02f, -4.34374064e-02f, -3.16168033e-02f, -1.68878473e-02f, 6.16640784e-02f, 1.74308550e-02f, 1.95255354e-02f, 2.51173787e-02f, -3.80511954e-02f,
  5.14514334e-02f, -2.98901536e-02f, -1.19147392e-03f, 2.00469773e-02f, 3.77866887e-02f, -3.85633647e-03f, -1.22179426e-02f, 1.95465665e-02f, -1.36292186e-02f, 7.60766044e-02f,
  -4.17261869e-02f, 1.03243869e-02f, 1.55287962e-02f, -5.96152842e-02f, 5.23741543e-02f, 5.09110987e-02f, -3.23695317e-02f, 2.44044536e-03f, -3.01800761e-02f, 1.30129408e-03f,
  -8.84787366e-02f, 2.61134002e-02f, -1.67756286e-02f, -3.18675302e-02f, 1.97840389e-02f, -6.55958802e-02f, 1.24874460e-02f, -4.19699959e-02f, -9.49163958e-02f, -9.47106779e-02f,
  -1.81780428e-01f, -4.11124267e-02f, 6.79454133e-02f, -1.80441827e-01f, -1.64045632e-01f, -7.88298398e-02f, -2.78657558e-03f, -7.80309439e-02f, 6.62368303e-03f, -3.03184073e-02f,
  -7.42079020e-02f, 8.98261517e-02f, -6.34524077e-02f, -2.41812449e-02f, -1.08004823e-01f, -1.14701308e-01f, -1.34930700e-01f, -1.32318093e-02f, 9.34184939e-02f, 4.42149043e-02f,
  -1.09409332e-01f, -8.77953097e-02f, -6.98328316e-02f, -4.78041656e-02f, -6.69731498e-02f, 3.82721610e-02f, 3.27076688e-02f, 1.00508491e-02f, -8.06793198e-02f, -5.00122197e-02f,
  1.87018871e-01f, 8.20356682e-02f, -5.64545430e-02f, -4.99283371e-04f, -2.53825579e-02f, -3.58152576e-02f, -1.05533199e-02f, 6.98032454e-02f, 8.38571489e-02f, -3.29517238e-02f,
  -6.09742589e-02f, -1.37012796e-02f, 1.18735600e-02f, -1.38062192e-02f, 4.80793118e-02f, 7.48421103e-02f, 4.90343869e-02f, -9.23182294e-02f, 4.96491604e-02f, 7.90711865e-02f,
  -3.56269032e-02f, 4.28526700e-02f, 1.12989694e-01f, 8.73761550e-02f, 5.54456823e-02f, -4.37119976e-02f, 6.94792196e-02f, -3.61661837e-02f, 9.50192139e-02f, -4.19801287e-02f,
  2.23154183e-02f, -7.41707627e-03f, -2.11745724e-02f, -5.61650656e-02f, -4.34755757e-02f, 4.54042703e-02f, -8.75637457e-02f, 6.68040738e-02f, -7.18311965e-02f, 1.60615426e-02f,
  -1.47224460e-02f, 8.83260146e-02f, -1.27477441e-02f, -2.01534871e-02f, -8.02789852e-02f, 5.77797852e-02f, 1.05177388e-02f, -3.16648036e-02f, 2.07633134e-02f, 1.82653219e-02f,
  -7.36628249e-02f, 3.33594643e-02f, 5.85093908e-02f, 6.37268275e-02f, 3.33573595e-02f, -4.38148379e-02f, 7.58982450e-02f, -6.55771121e-02f, 2.32277028e-02f, -3.91675830e-02f,
  5.29183485e-02f, 9.41766873e-02f, -5.18340766e-02f, 2.72032227e-02f, 3.59906554e-02f, -7.77839497e-02f, -5.38659655e-02f, -8.22465122e-02f, 1.81059819e-02f, 9.28687751e-02f,
  1.27405236e-02f, 4.79332134e-02f, -4.94960546e-02f, 5.26269190e-02f, 5.57052158e-02f, -8.20105076e-02f, -8.41569081e-02f, -3.30008082e-02f, 7.41665065e-02f, -6.19670376e-03f,
  -4.90144938e-02f, 3.13494503e-02f, 7.87843838e-02f, -8.11790000e-04f, -6.10609762e-02f, -6.49345368e-02f, -4.66856100e-02f, 1.03116140e-01f, 1.82703082e-02f, 1.66284072e-03f,
  5.25291413e-02f, 1.51154641e-02f, 1.29833132e-01f, -1.37132093e-01f, 6.31898493e-02f, 1.35913044e-01f, 1.11256009e-02f, -1.74916368e-02f, -1.17895037e-01f, -7.13693649e-02f,
  6.82217628e-02f, -4.24975343e-02f, -3.76078784e-02f, -8.66578519e-02f, -7.64528513e-02f, -1.10277951e-01f, -4.35082018e-02f, -8.23182538e-02f, -3.05896159e-02f, 9.49677825e-02f,
  -6.17967136e-02f, 1.29930526e-02f, -8.84874761e-02f, -1.10258050e-01f, -6.69688592e-03f, -1.38902768e-01f, 6.14840537e-02f, 3.21775079e-02f, 1.85939595e-02f, 1.43307913e-02f,
  1.39223645e-02f, 1.50524110e-01f, -5.04364781e-02f, -5.19647589e-03f, 1.15583055e-01f, 2.60784067e-02f, -7.99205676e-02f, -1.02648176e-01f, 2.54958589e-02f, 4.72350605e-02f,
  -1.29267517e-02f, -5.38282841e-02f, 6.03514649e-02f, -2.62681060e-02f, 3.92066538e-02f, -3.09169795e-02f, 1.58877671e-02f, -1.30424961e-01f, 5.57574555e-02f, 3.46986353e-02f,
  8.97881016e-02f, 1.09275848e-01f, -1.05632506e-02f, -3.05348299e-02f, -6.79178222e-04f, -4.82742786e-02f, 1.87466685e-02f, 7.56497309e-02f, 3.15134712e-02f, -1.30235419e-01f,
  1.83206759e-02f, -4.39276733e-02f, -5.20346873e-03f, -3.72539349e-02f, -1.09960496e-01f, -1.55129032e-02f, 2.30846349e-02f, 8.41515064e-02f, -1.91740859e-02f, -4.80980575e-02f,
  -8.26205313e-02f, -1.62448213e-02f, 6.42987192e-02f, -5.52692413e-02f, -9.76623297e-02f, 3.92791592e-02f, 7.99997803e-03f, 2.44005583e-02f, -9.31338686e-03f, -9.89035144e-03f,
  6.34863228e-02f, -4.78573609e-03f, -6.77243620e-02f, -7.27757141e-02f, -7.56350085e-02f, 8.20006877e-02f, -7.73971975e-02f, 1.10096652e-02f, 5.45233563e-02f, -7.07329214e-02f,
  -1.87435806e-01f, 1.54707998e-01f, -1.10884622e-01f, -1.40730903e-01f, -4.38245974e-04f, -9.83350947e-02f, -8.30829889e-02f, -5.45340143e-02f, 7.47424662e-02f, -4.18027639e-02f,
  -1.54608469e-02f, -4.30151112e-02f, 6.24312263e-04f, 1.02498243e-02f, -1.03286341e-01f, 3.53031121e-02f, -4.70774323e-02f, -1.03586674e-01f, 2.75528315e-03f, 5.23648448e-02f,
  1.08146025e-02f, -1.33751318e-01f, -1.54418781e-01f, -1.43381387e-01f, -2.82550640e-02f, -3.82413715e-02f, -1.22864768e-01f, -9.03062299e-02f, -8.58955607e-02f, -2.15057254e-01f,
  1.57092854e-01f, 7.91167319e-02f, 1.05188325e-01f, 1.19582616e-01f, 3.03364322e-02f, 4.82951850e-02f, 1.28432140e-02f, 3.62631213e-03f, -5.25969863e-02f, -5.21813817e-02f,
  -7.12033063e-02f, -1.39025316e-01f, -6.07925989e-02f, -7.35394657e-02f, -3.21311839e-02f, 7.09418058e-02f, 1.11607522e-01f, 1.00653894e-01f, 9.58580971e-02f, 3.69623229e-02f,
  7.22633749e-02f, -3.76996920e-02f, 5.56630865e-02f, 3.39188911e-02f, 9.90760997e-02f, 7.06223845e-02f, 1.20074293e-02f, -7.42509812e-02f, -1.07592838e-02f, 5.86888231e-02f,
  -1.00583643e-01f, 7.87853748e-02f, -4.58530895e-02f, 2.43100858e-05f, -1.05880953e-01f, -3.48204933e-02f, -7.58797675e-02f, -7.67529905e-02f, 1.55212972e-02f, -1.27382642e-02f,
  3.34766321e-02f, -1.67470891e-02f, 3.07529531e-02f, 8.26812908e-03f, -6.93047494e-02f, 1.83258615e-02f, -7.92790204e-02f, 1.24227755e-01f, 8.64002556e-02f, -3.04004308e-02f,
  4.30072844e-02f, -8.38767365e-02f, -5.15224598e-02f, 5.12608886e-02f, 5.94267063e-02f, 6.35795966e-02f, -1.03367530e-01f, 1.04585923e-01f, 5.15040196e-02f, 7.98454285e-02f,
  -1.36621296e-01f, 2.75735371e-02f, 3.53373587e-02f, -4.89919782e-02f, -3.38177904e-02f, -5.30167818e-02f, -8.45108554e-02f, -7.88380578e-02f, -4.25646156e-02f, 3.09117567e-02f,
  -5.08982129e-02f, 3.48189920e-02f, -5.85426837e-02f, 5.81575222e-02f, -9.62528065e-02f, -5.69274947e-02f, 3.10395509e-02f, 2.74461079e-02f, 7.84522519e-02f, 8.39186683e-02f,
  -2.84887641e-03f, 1.98081192e-02f, 2.10272539e-02f, -4.88147996e-02f, -6.32917285e-02f, 6.96746912e-03f, 5.60326725e-02f, -5.65492809e-02f, -8.00868869e-02f, 6.29447168e-03f,
  -2.13191286e-02f, 6.36156797e-02f, 5.48331402e-02f, 1.71694085e-02f, -7.20988512e-02f, 7.42036775e-02f, 3.52950543e-02f, -1.38416083e-03f, -6.30013421e-02f, 9.75489840e-02f,
  5.10359555e-02f, -3.48090045e-02f, -7.89868236e-02f, -2.07423214e-02f, -4.44741771e-02f, 6.25831783e-02f, 6.46063834e-02f, -3.65684889e-02f, -7.20993709e-03f, -7.42645934e-02f,
  -8.48226920e-02f, 8.67533311e-03f, -1.80289093e-02f, 8.83675814e-02f, 3.70468907e-02f, -1.79986935e-02f, -9.56629887e-02f, -8.40207338e-02f, -4.56428528e-03f, -5.55690452e-02f,
  -9.64809358e-02f, -1.05691440e-01f, 1.33612100e-03f, -1.64291084e-01f, -5.56378588e-02f, 4.38142680e-02f, 1.08463109e-01f, -5.71174808e-02f, -1.83739718e-02f, -6.83307499e-02f,
  2.19239984e-02f, -1.47616029e-01f, -1.40660927e-01f, -1.17537484e-01f, -3.66408043e-02f, -3.21502090e-02f, -1.13429293e-01f, -1.58731982e-01f, -5.85406646e-02f, -2.91546769e-02f,
  -1.35632098e-01f, -1.68659180e-01f, -2.46429704e-02f, -8.75139534e-02f, -5.13299704e-02f, -8.74044523e-02f, -9.71506834e-02f, -1.34302914e-01f, -3.02672796e-02f, -8.25766101e-02f,
  -3.13551947e-02f, 1.81843396e-02f, 8.63624886e-02f, -6.02096180e-03f, -3.25788185e-02f, -7.73129687e-02f, -1.90163311e-02f, 7.65054226e-02f, 9.07904506e-02f, -7.19383964e-03f,
  -4.19667661e-02f, -7.73577020e-02f, -3.61762717e-02f, -8.76103118e-02f, -2.81934235e-02f, 7.14498684e-02f, -1.19201588e-02f, -8.28547999e-02f, -1.67826135e-02f, -5.73189147e-02f,
  1.25186816e-02f, 2.55097076e-02f, 9.05835778e-02f, 5.11701591e-03f, 8.70848149e-02f, -4.93616462e-02f, 9.49188918e-02f, 3.44344378e-02f, 2.50515789e-02f, -8.44791159e-02f,
  2.80217174e-02f, -5.46012670e-02f, -1.17715960e-03f, 4.92706597e-02f, 3.57181882e-03f, 3.91108841e-02f, 6.96768761e-02f, -7.37968972e-03f, 1.09227234e-03f, -8.73423144e-02f,
  7.73389935e-02f, -3.24404836e-02f, 6.15389235e-02f, -5.33215478e-02f, -9.56190601e-02f, -9.90201253e-03f, -6.04686253e-02f, 7.55405501e-02f, 2.67430656e-02f, -7.81720206e-02f,
  -3.07062622e-02f, 5.72037771e-02f, -6.41811416e-02f, -1.85046997e-02f, 6.97170123e-02f, 9.17087793e-02f, -7.15952441e-02f, -5.63638285e-02f, -2.37042992e-03f, 8.45978409e-02f,
  -1.25987560e-01f, 1.40104473e-01f, 1.29628731e-02f, 4.48069461e-02f, -6.09909296e-02f, 7.38814324e-02f, -4.54510674e-02f, 5.77081703e-02f, -4.69410839e-03f, -7.44966716e-02f,
  -1.56026483e-02f, 1.38365757e-02f, 1.84178594e-02f, 5.89198358e-02f, -5.78276590e-02f, 7.38754049e-02f, 5.98556548e-03f, -6.94917217e-02f, 1.91229545e-02f, -1.97382625e-02f,
  2.46683955e-02f, 8.75035450e-02f, 5.11984993e-03f, -4.43588942e-02f, -3.03650480e-02f, -9.90310218e-03f, -5.81898279e-02f, 9.54998657e-02f, 2.30217334e-02f, 4.28730249e-02f,
  -5.17553836e-02f, -7.92152286e-02f, -3.49752046e-02f, 6.99128732e-02f, 1.40203342e-01f, 4.81366217e-02f, -1.52032316e-01f, -1.32042304e-01f, 4.50868644e-02f, 1.47670065e-03f,
  -5.89075275e-02f, 3.28979269e-02f, -7.42594060e-03f, -3.74020971e-02f, -1.48662478e-01f, -6.73935656e-03f, 8.35957229e-02f, 1.02125160e-01f, 6.58963546e-02f, -6.60132691e-02f,
  7.68576786e-02f, -3.55693661e-02f, 3.19714163e-04f, 8.82820040e-03f, 1.90039501e-01f, 1.45812228e-01f, -7.92166829e-05f, 1.60023179e-02f, 1.34564310e-01f, 1.34209603e-01f,
  1.52039051e-01f, -6.93924651e-02f, -6.37169853e-02f, -2.06417255e-02f, -3.70909809e-03f, 4.81505059e-02f, -4.51364145e-02f, -3.51561001e-03f, 3.08644790e-02f, 4.02004570e-02f,
  1.01856276e-01f, 9.73866954e-02f, 8.50256532e-02f, 4.12261672e-02f, 4.74218838e-02f, -3.75846364e-02f, -9.47871879e-02f, -9.96809900e-02f, 2.08963864e-02f, 9.22427624e-02f,
  1.01785675e-01f, 6.98447078e-02f, -5.56709059e-02f, -9.34535563e-02f, -8.63503814e-02f, -4.39032204e-02f, -4.36236709e-02f, 7.54873976e-02f, 3.11823823e-02f, 5.08539639e-02f,
  6.30737990e-02f, -3.34317908e-02f, 2.27098633e-03f, 1.48238521e-02f, -1.80439148e-02f, -2.02204566e-02f, -1.05291558e-02f, -5.81692047e-02f, -8.89902934e-02f, -2.61832196e-02f,
  1.82594564e-02f, -8.51525888e-02f, -2.94252206e-03f, -4.07003611e-02f, 9.57894996e-02f, 8.37075114e-02f, -1.12392781e-02f, -7.79365823e-02f, 3.16626802e-02f, -3.89509313e-02f,
  3.34735848e-02f, 7.67599940e-02f, 6.96174940e-03f, 6.29262328e-02f, 7.57697597e-02f, 1.75866596e-02f, 4.40360270e-02f, -1.60249434e-02f, 6.83929995e-02f, -4.43907976e-02f,
  -9.80416834e-02f, -9.84540060e-02f, 3.25661898e-02f, 4.53276969e-02f, 8.96371827e-02f, -2.98702680e-02f, 2.30696164e-02f, 1.11217014e-01f, 1.17667593e-01f, -7.75366463e-03f,
  -2.82588624e-03f, -2.79850904e-02f, 2.51112673e-02f, 4.88478169e-02f, 1.98412016e-02f, 1.02928057e-01f, 9.55505073e-02f, 1.10205933e-01f, 7.34612271e-02f, 1.20821841e-01f,
  8.69503394e-02f, -5.25384136e-02f, -1.06032573e-01f, -4.02566977e-02f, 2.82377983e-03f, 4.69277017e-02f, 1.65182143e-03f, -2.17915755e-02f, -4.55951132e-02f, -8.20034444e-02f,
  -1.12033047e-01f, -1.28109932e-01f, -1.46808639e-01f, 1.06852911e-01f, -2.62247939e-02f, 5.23012318e-02f, 4.92327148e-03f, 3.88280898e-02f, 1.51208490e-01f, 6.06010482e-02f,
  4.14727777e-02f, 2.94599328e-02f, -1.59332696e-02f, 1.32557288e-01f, -3.61559242e-02f, 6.78010359e-02f, 7.09567964e-02f, -4.09546420e-02f, 6.15998618e-02f, 5.48598096e-02f,
  1.20502837e-01f, 7.35032633e-02f, 4.09668759e-02f, 7.26766437e-02f, 1.13386229e-01f, 3.58829349e-02f, -8.62332210e-02f, 5.35373092e-02f, 7.58536756e-02f, 6.58802539e-02f,
  -2.94229761e-02f, -1.46746412e-01f, 5.55078387e-02f, 4.32736278e-02f, -7.03377277e-03f, -9.12736580e-02f, 3.34081389e-02f, -1.11580394e-01f, 3.60577255e-02f, 3.70010431e-03f,
  4.13243175e-02f, 4.35399748e-02f, -2.59013078e-03f, 7.21885962e-03f, -9.38078971e-04f, 2.92737968e-03f, -6.04133718e-02f, 1.16078267e-02f, -3.18727493e-02f, 4.15933281e-02f,
  7.76956752e-02f, -2.76914034e-02f, 2.48053437e-03f, 3.53003927e-02f, -1.01888195e-01f, -6.56935796e-02f, -1.65673848e-02f, -8.90341476e-02f, 2.86386423e-02f, -1.50775351e-03f,
  -5.76091968e-02f, 8.28285590e-02f, 4.74264175e-02f, -3.61852571e-02f, 8.59760940e-02f, 2.91731302e-02f, 1.01079650e-01f, 7.79632404e-02f, 1.74167398e-02f, -3.71926688e-02f,
  -5.98897561e-02f, 5.72520215e-03f, -8.39511901e-02f, 3.22097586e-03f, -1.01979002e-02f, -7.78712034e-02f, -6.51494274e-03f, 6.37941286e-02f, -1.52309382e-04f, -5.73131032e-02f,
  4.15646359e-02f, -3.35871018e-02f, 2.89323870e-02f, 4.21098061e-02f, -7.41387159e-02f, 9.71752859e-04f, 6.23029470e-02f, 6.52729571e-02f, -7.73990601e-02f, 7.13590011e-02f,
  1.01455204e-01f, 2.33070366e-02f, 6.94841892e-02f, -5.04969358e-02f, 5.63796377e-03f, -6.78958790e-03f, -1.24149537e-02f, 7.04976078e-03f, -5.24669653e-03f, -2.92325541e-02f,
  -2.59216353e-02f, -8.36676881e-02f, 1.20483031e-02f, 2.53831036e-02f, -7.56222755e-02f, -4.38178107e-02f, 1.31139308e-02f, 1.44883133e-02f, 8.09290111e-02f, 5.81589621e-03f,
  8.45399685e-03f, -9.07088444e-03f, 3.54526713e-02f, 9.25071072e-03f, 1.95592605e-02f, 1.00535192e-01f, 2.62161847e-02f, 4.21742760e-02f, 4.40739021e-02f, 1.04447052e-01f,
  2.35646725e-01f, 5.61599284e-02f, -2.17536576e-02f, 1.01176985e-01f, -7.20384121e-02f, -1.54117495e-01f, -3.46531719e-01f, -2.71049619e-01f, -3.32960412e-02f, 6.32367954e-02f,
  -7.06963241e-03f, 7.12203234e-02f, 7.88918957e-02f, 7.83620551e-02f, -6.54500946e-02f, 1.58279017e-02f, 6.73184022e-02f, 2.39548739e-02f, 1.06678255e-01f, 9.36804153e-03f,
  1.26414046e-01f, 1.46521121e-01f, 1.30898461e-01f, 1.18780740e-01f, 1.84075549e-01f, 1.11384310e-01f, 5.25106788e-02f, 1.82354540e-01f, 1.18402869e-01f, 3.44603628e-01f,
  1.30388126e-01f, 2.68960957e-05f, -1.40329793e-01f, 1.73450522e-02f, 5.89615218e-02f, 1.06390238e-01f, -4.76015965e-03f, -3.36525701e-02f, 7.91631080e-03f, -2.05483492e-02f,
  1.15135208e-01f, 1.00966483e-01f, -5.54150082e-02f, 5.44391125e-02f, 1.25336545e-02f, -6.71275556e-02f, 7.71877095e-02f, 8.01486000e-02f, -3.92691931e-03f, 3.01779807e-02f,
  4.01239619e-02f, 7.86658153e-02f, -1.30671471e-01f, -1.37274951e-01f, -7.56440461e-02f, 8.08579400e-02f, -3.51606160e-02f, -6.36498407e-02f, -7.56662115e-02f, 5.34902215e-02f,
  1.02689661e-01f, -6.49994910e-02f, 4.41448800e-02f, 9.56051946e-02f, -1.72967706e-02f, 1.63386650e-02f, 7.65515119e-02f, 7.11290240e-02f, -1.96430534e-02f, 5.64048067e-02f,
  -1.88060608e-02f, 7.66574442e-02f, 2.48999726e-02f, -1.52092986e-02f, -1.86335784e-03f, 4.59617823e-02f, -4.40398715e-02f, 6.25126511e-02f, 2.15294901e-02f, -5.32970242e-02f,
  -2.49938257e-02f, 4.57387120e-02f, 8.79129767e-02f, 6.00243639e-03f, 5.95522486e-02f, -5.76431118e-02f, -2.46478058e-02f, -5.33579141e-02f, -3.79480347e-02f, 2.19772514e-02f,
  -2.07260996e-01f, -1.25937462e-01f, -4.68250848e-02f, 1.34307817e-02f, -2.12285598e-03f, -9.33283418e-02f, 6.80970550e-02f, -7.76522160e-02f, 7.24675879e-02f, -6.90872148e-02f,
  -7.17232823e-02f, -4.07797359e-02f, 1.73612405e-02f, -9.15528238e-02f, -3.38027552e-02f, -1.25640839e-01f, -2.36436184e-02f, 3.23591009e-02f, -1.21406823e-01f, 3.05574220e-02f,
  -7.78439566e-02f, -1.06919199e-01f, -8.68017226e-02f, -1.63259491e-01f, -1.37181431e-01f, -1.36134312e-01f, -3.61863077e-02f, -9.73703116e-02f, -2.07448348e-01f, -1.12878136e-01f,
  -8.72528832e-03f, -5.41785993e-02f, -1.88810956e-02f, 1.17105246e-01f, 1.29198551e-01f, 1.61611736e-02f, -7.51875192e-02f, -2.28548758e-02f, 3.74124176e-03f, 1.14540875e-01f,
  1.43518284e-01f, 1.78134114e-01f, -2.30853818e-02f, 6.97776005e-02f, -5.59849739e-02f, -2.08843034e-03f, 2.25004982e-02f, 1.99179482e-02f, 5.73260076e-02f, 5.04773147e-02f,
  1.67830646e-01f, 1.03344992e-01f, -1.55210600e-03f, 5.89637198e-02f, 1.92023113e-01f, 1.18947737e-01f, 2.54549682e-02f, 1.03485629e-01f, 7.24210218e-02f, 5.54627329e-02f,
  1.16808027e-01f, -6.36690259e-02f, -7.73806125e-03f, -7.44099915e-03f, 7.71617284e-03f, 6.26892522e-02f, -8.33559856e-02f, -2.94413529e-02f, 4.57733795e-02f, 3.27586383e-02f,
  8.70550275e-02f, -1.60129871e-02f, 6.28292933e-02f, 1.62274484e-02f, -1.00679085e-01f, -6.45642951e-02f, -1.19650558e-01f, -1.21079281e-01f, -1.26140222e-01f, -1.92137193e-02f,
  1.08890623e-01f, 7.01338798e-02f, -4.70675081e-02f, -1.54545844e-01f, -1.14265956e-01f, 9.18971375e-03f, -6.56073466e-02f, 6.96348473e-02f, -7.80594535e-03f, -7.98299611e-02f,
  -8.47845059e-03f, -5.62832728e-02f, -1.66814551e-02f, -5.12775853e-02f, -1.39317708e-02f, 4.17772904e-02f, 2.31434479e-02f, -2.45396774e-02f, 8.42309222e-02f, 4.90281843e-02f,
  9.20318160e-03f, 2.39491127e-02f, -4.33120355e-02f, 2.30932627e-02f, 2.00762749e-02f, -7.14066550e-02f, -1.57170072e-02f, 4.23968956e-02f, -5.59712760e-02f, 5.02781831e-02f,
  3.80286612e-02f, -7.85299093e-02f, 1.16691710e-02f, -3.13679711e-03f, -6.42855838e-02f, 3.58209712e-03f, -2.86369282e-03f, 8.22105035e-02f, -1.36121837e-02f, -2.34296024e-02f,
  3.94715406e-02f, -1.73137069e-01f, 1.30356431e-01f, 7.03597590e-02f, -1.40922638e-02f, -4.61249463e-02f, -1.74345188e-02f, -6.62094653e-02f, 8.83891732e-02f, 1.05421720e-02f,
  -3.09669897e-02f, -4.04733047e-02f, -1.31247705e-02f, -7.32376277e-02f, -7.10784420e-02f, -4.19079475e-02f, -1.92395300e-02f, 3.05491295e-02f, -1.05174512e-01f, 1.57884061e-02f,
  -1.22373618e-01f, -5.63453026e-02f, -5.78775890e-02f, -7.39541203e-02f, -3.79479453e-02f, 3.63323316e-02f, 2.82590911e-02f, 5.78066595e-02f, -4.10061367e-02f, 4.50292323e-03f,
  2.88738459e-01f, 1.12910323e-01f, 4.33225110e-02f, 6.30386472e-02f, 8.24492704e-03f, 5.60705028e-02f, 2.06793740e-01f, 1.73532188e-01f, 1.28801182e-01f, 1.62234277e-01f,
  4.34987880e-02f, 1.05703883e-02f, -3.76600549e-02f, 2.04161704e-02f, -1.31313941e-02f, -3.80826853e-02f, 3.27122808e-02f, 3.36310193e-02f, -1.31027400e-02f, 9.77251455e-02f,
  1.33615270e-01f, 1.23840496e-01f, 1.11887231e-01f, 7.20860511e-02f, 9.32056010e-02f, 8.35982636e-02f, 3.63420546e-02f, 1.30687281e-01f, -1.56986192e-02f, -1.76873542e-02f,
  -8.76050740e-02f, 5.98620735e-02f, -1.27665475e-01f, -7.71044046e-02f, 2.01717764e-02f, 9.70995948e-02f, 1.00939497e-01f, -4.10444550e-02f, 1.01119034e-01f, -6.81434497e-02f,
  -2.50007082e-02f, 6.66688979e-02f, 2.52711326e-02f, 5.34728207e-02f, -5.94221465e-02f, 4.84430827e-02f, -1.96575932e-03f, 1.02291428e-01f, 4.08969671e-02f, 7.59313479e-02f,
  1.82859041e-02f, -5.26939481e-02f, 2.81615928e-02f, -3.54095437e-02f, -5.02642058e-02f, -9.61427391e-02f, -4.90641259e-02f, -6.60990849e-02f, 6.02058992e-02f, 6.78088963e-02f,
  6.98163034e-03f, 9.22454670e-02f, -2.70602154e-03f, -6.41190272e-04f, 2.24457309e-02f, -2.21232846e-02f, -2.28346847e-02f, 6.00932054e-02f, -7.95233324e-02f, -8.46575126e-02f,
  -7.73470551e-02f, -1.08831063e-01f, 4.55736220e-02f, 5.90586625e-02f, -9.72960740e-02f, -8.38099048e-02f, 2.68608495e-03f, -7.39906803e-02f, -9.84580349e-03f, 7.45520964e-02f,
  4.09680791e-02f, 2.23545898e-02f, 4.19951640e-02f, -7.72076249e-02f, -6.12486415e-02f, -8.08791369e-02f, -1.19349308e-01f, 4.20835093e-02f, -7.10130436e-04f, 7.75494352e-02f,
  -2.37116497e-02f, -1.22917123e-01f, -6.34875428e-03f, -4.17970791e-02f, -4.94849384e-02f, 3.69051248e-02f, 1.20803872e-02f, 2.42257360e-02f, 8.29844642e-03f, -5.43714240e-02f,
  -5.70427626e-03f, -6.56136399e-05f, 3.50152887e-02f, 7.58367926e-02f, -8.55364725e-02f, -9.93549153e-02f, 5.25911748e-02f, -5.24039678e-02f, -4.62732986e-02f, 6.22305460e-02f,
  -6.66304007e-02f, -6.50350377e-02f, 2.79519018e-02f, -8.27443376e-02f, 4.65752650e-03f, 1.75928641e-02f, -7.61663169e-02f, -8.56784359e-02f, -7.45109022e-02f, 8.07205588e-03f,
  -9.37049761e-02f, 1.87048435e-01f, -1.03298416e-02f, 2.22298559e-02f, 1.17081366e-01f, 1.55053586e-01f, 2.14536369e-01f, 6.66147545e-02f, 9.01312679e-02f, 3.09894439e-02f,
  9.89085734e-02f, 2.36204006e-02f, 1.06230564e-01f, 5.60954735e-02f, 8.21396112e-02f, 5.32441884e-02f, -4.54291850e-02f, -9.07811150e-02f, -1.10578433e-01f, -7.03941509e-02f,
  -2.60364991e-02f, -5.89924268e-02f, -1.36453688e-01f, 3.62363122e-02f, 4.33170907e-02f, 7.34094605e-02f, 6.87888786e-02f, -2.65381988e-02f, 7.29634762e-02f, 5.67277074e-02f,
  -9.26138535e-02f, -1.12370275e-01f, -8.17382112e-02f, 8.53816862e-04f, 3.47858518e-02f, -2.07576100e-02f, -4.09536473e-02f, -1.07888706e-01f, -2.83331722e-02f, 6.79014027e-02f,
  -3.66412359e-03f, -6.54627830e-02f, 8.20357352e-02f, 1.33016109e-02f, 6.86504915e-02f, -6.31622449e-02f, -2.54106317e-02f, -1.27170816e-01f, 1.40898610e-02f, -8.59731883e-02f,
  -2.65118876e-03f, 1.44670606e-02f, -9.70109776e-02f, 5.88307753e-02f, -1.42151892e-01f, -7.94302672e-02f, 3.29858400e-02f, -1.21439636e-01f, -5.59223667e-02f, -7.17718899e-02f,
  3.33157480e-02f, -8.66789967e-02f, -5.61287766e-03f, -5.18562309e-02f, 2.18111761e-02f, -6.88518956e-02f, -4.24914137e-02f, 8.83342400e-02f, -5.81899285e-02f, 3.02900635e-02f,
  5.58517240e-02f, -7.17360228e-02f, 3.89223322e-02f, -4.11962941e-02f, -4.03002501e-02f, 1.39038935e-02f, 4.36437018e-02f, 5.07942401e-02f, -7.27142915e-02f, -1.23953363e-02f,
  3.42619494e-02f, -3.60343643e-02f, -3.63728702e-02f, 8.19226354e-02f, -7.29585811e-02f, 6.60464615e-02f, -1.58449989e-02f, 7.36333132e-02f, 7.01203793e-02f, 5.98782748e-02f,
  1.01398788e-01f, 3.60194817e-02f, 1.43160736e-02f, -5.35759851e-02f, -9.55616236e-02f, -9.38502401e-02f, -5.05806580e-02f, -8.27993602e-02f, -3.09644956e-02f, -6.28959853e-03f,
  4.16383967e-02f, -1.94977690e-02f, 5.80189452e-02f, -3.65033261e-02f, 1.80328917e-02f, -4.12388705e-02f, 6.61313161e-02f, -7.78291672e-02f, -1.08792685e-01f, -1.13162994e-01f,
  -4.75102700e-02f, -7.77661279e-02f, 5.06870374e-02f, -4.59555946e-02f, 2.95989886e-02f, -6.48965314e-02f, -1.97905768e-02f, -5.92623316e-02f, 3.91256623e-02f, 9.85725597e-02f,
  1.51978955e-01f, 1.15408599e-01f, 1.03571057e-01f, 7.26752430e-02f, -1.14506364e-01f, -1.52679607e-01f, -7.07480833e-02f, -2.19740998e-03f, 2.62848120e-02f, 2.44204141e-02f,
  -1.04823768e-01f, -8.20786208e-02f, -2.18344405e-02f, -1.62069753e-01f, -1.23658143e-01f, 4.37039360e-02f, -9.74170193e-02f, 3.07108853e-02f, -1.45228535e-01f, -1.11314528e-01f,
  -5.49708530e-02f, 3.10305990e-02f, 1.09523870e-02f, -2.98304781e-02f, 1.44119605e-01f, 4.50366549e-02f, 1.64736975e-02f, 1.68456435e-01f, 6.39528707e-02f, 1.17837399e-01f,
  1.07169941e-01f, 1.49113864e-01f, -1.37228146e-01f, -7.95862451e-02f, -1.89040005e-02f, 6.95485547e-02f, 4.37258147e-02f, 1.16536453e-01f, -9.39410031e-02f, -5.21270335e-02f,
  1.45516004e-02f, 6.12489171e-02f, -6.10195622e-02f, -9.17249694e-02f, -8.78450722e-02f, 1.24820629e-02f, -2.75132600e-02f, -5.15500037e-03f, -1.55931516e-02f, 5.84891438e-02f,
  -3.39296833e-02f, 7.24945217e-02f, -7.45628253e-02f, 1.60362329e-02f, 2.48545576e-02f, -1.30280033e-01f, 6.67774901e-02f, 6.30435199e-02f, 4.47628573e-02f, -2.94298660e-02f,
  -6.21302426e-02f, 8.14856738e-02f, -1.44262584e-02f, -7.28945881e-02f, 2.48281751e-02f, -7.97924399e-02f, 6.62618876e-03f, 2.16167606e-02f, 3.64375710e-02f, -4.58639264e-02f,
  -5.29076904e-02f, 2.99631618e-02f, 2.71937698e-02f, -6.79856464e-02f, 6.06293939e-02f, -7.33291954e-02f, 6.42488450e-02f, -6.25308007e-02f, -8.60514194e-02f, -2.25274041e-02f,
  -4.67484742e-02f, 5.39281741e-02f, 2.91118603e-02f, 1.31587218e-02f, -7.22293854e-02f, 2.62162257e-02f, 4.81726713e-02f, 4.24352102e-02f, 5.16138263e-02f, 4.61142100e-02f,
  -1.57714903e-01f, -6.82636425e-02f, 7.12273689e-03f, -1.18096583e-01f, 6.82042837e-02f, -8.43097791e-02f, 1.64686819e-04f, -9.11640674e-02f, 5.05849123e-02f, -9.80511829e-02f,
  3.13551761e-02f, 3.25386450e-02f, 3.91067304e-02f, -3.52535211e-02f, -8.68111178e-02f, -1.01236857e-01f, -8.50894898e-02f, -9.60618407e-02f, -3.69589888e-02f, 6.27641603e-02f,
  -1.00812957e-01f, -1.66136846e-01f, -2.41229802e-01f, -1.66851759e-01f, -2.91345660e-02f, -1.61820784e-01f, -8.04655403e-02f, -9.43250731e-02f, -2.00480700e-01f, -9.70535800e-02f,
  5.76419421e-02f, -9.39511955e-02f, -1.36945218e-01f, -8.34290162e-02f, 6.62380680e-02f, 5.35506639e-04f, -4.75984253e-03f, -8.39529634e-02f, 1.56699922e-02f, -4.10824735e-03f,
  4.21482660e-02f, -3.42731248e-04f, -9.39543471e-02f, -5.61955050e-02f, -4.86211628e-02f, -1.24910057e-01f, -1.30184934e-01f, 4.27516215e-02f, 9.19793248e-02f, 9.06396732e-02f,
  3.80155779e-02f, 3.69327664e-02f, -4.83913049e-02f, 2.55567003e-02f, -6.93901330e-02f, -1.36122286e-01f, -1.26845971e-01f, -6.66755736e-02f, -9.58291963e-02f, -1.06224328e-01f,
  -1.80886403e-01f, 5.70171848e-02f, -5.78167960e-02f, 1.55941379e-04f, -7.39950463e-02f, -9.08212811e-02f, -3.00344154e-02f, -7.97606111e-02f, -2.89888401e-02f, 1.70440460e-03f,
  -7.82394409e-02f, 3.87082272e-03f, -2.98730955e-02f, 2.50096377e-02f, -1.03382505e-02f, 7.81989396e-02f, -6.56279176e-03f, 1.74042527e-02f, -6.16907328e-02f, 8.10804442e-02f,
  -3.15191597e-02f, 8.81635621e-02f, 1.95152070e-02f, 1.15134032e-03f, -5.06073013e-02f, -2.28591706e-03f, -1.45880114e-02f, -6.22361265e-02f, 4.78979610e-02f, -8.27819705e-02f,
  5.32540046e-02f, 1.94329210e-02f, 1.77551061e-02f, 2.15780810e-02f, 2.05887156e-03f, -8.94057453e-02f, -8.68649185e-02f, 8.35684408e-03f, 1.97632816e-02f, 7.79354200e-02f,
  -8.32829177e-02f, 7.06657814e-03f, -5.06215915e-03f, 4.27267551e-02f, 6.73467815e-02f, 5.09078875e-02f, 2.19006371e-02f, 2.34538093e-02f, 1.95538402e-02f, 1.64289959e-02f,
  3.98837440e-02f, 7.17415512e-02f, 1.30351400e-02f, -8.21616426e-02f, -1.67011600e-02f, 2.91875768e-02f, 3.43999267e-02f, -4.89835069e-02f, 3.74207981e-02f, -7.30654746e-02f,
  -1.40544802e-01f, -1.08870529e-02f, -2.77307210e-03f, -4.23666984e-02f, -5.55979041e-03f, -4.51113135e-02f, 3.33803743e-02f, -6.54570982e-02f, -3.82174440e-02f, -3.96862328e-02f,
  4.55734804e-02f, -9.28771719e-02f, -5.36863506e-02f, 1.40499361e-02f, 5.11077344e-02f, 8.08202326e-02f, -3.00816670e-02f, -5.32081500e-02f, -3.71058956e-02f, 1.18220979e-02f,
  1.19592706e-02f, -1.05396912e-01f, -5.30973300e-02f, -7.43156672e-02f, 3.49223875e-02f, 1.77987516e-02f, -1.21157967e-01f, -1.17630385e-01f, -8.27476159e-02f, -9.94904935e-02f,
  -2.50033557e-01f, 8.25973004e-02f, -1.08651958e-01f, -3.59138399e-02f, 8.02240968e-02f, 1.39713898e-01f, 1.80684954e-01f, 9.80793014e-02f, 2.78255753e-02f, 4.60636914e-02f,
  -8.14688504e-02f, 3.77018228e-02f, 1.08799919e-01f, 2.32393946e-02f, 1.33431047e-01f, 1.82442546e-01f, 9.83997807e-02f, -4.85682860e-02f, -8.29956830e-02f, 6.58599660e-02f,
  2.78083663e-02f, -1.73742860e-03f, -5.58151938e-02f, 6.62352424e-04f, -1.66327618e-02f, 1.22981602e-02f, -9.78157222e-02f, -8.07301104e-02f, -6.96647167e-02f, 3.61272022e-02f,
  -1.79093137e-01f, -2.61882633e-01f, 1.95411667e-02f, -4.00124229e-02f, -3.77404913e-02f, -6.75033927e-02f, -9.12821367e-02f, -1.25058338e-01f, -3.52065861e-02f, -6.24457151e-02f,
  4.63427454e-02f, -3.18518281e-02f, -6.64541945e-02f, 6.50563976e-03f, 1.60774924e-02f, -3.57914045e-02f, -1.85728259e-02f, -1.35831177e-01f, -4.26774658e-02f, 1.99730657e-02f,
  4.52590398e-02f, -1.11860953e-01f, -1.04815409e-01f, 1.40759745e-03f, 4.96487133e-02f, 1.57170501e-02f, -2.82141473e-02f, -7.47095048e-02f, -7.25425594e-03f, -1.91406921e-01f,
  1.66052822e-02f, -2.21592952e-02f, -4.88336757e-02f, -5.70135154e-02f, 2.62352787e-02f, -7.48542696e-02f, -1.66934393e-02f, 8.42501968e-02f, -6.62353039e-02f, 3.44747305e-02f,
  -1.57716237e-02f, 5.08577228e-02f, -8.79928842e-02f, -8.89268797e-03f, -3.48474756e-02f, -6.26750961e-02f, 2.31821500e-02f, 3.05114668e-02f, -5.51835969e-02f, 7.75584355e-02f,
  2.01629363e-02f, -4.42671143e-02f, -1.14591658e-01f, 7.51002133e-02f, 1.16108386e-02f, 2.78978329e-02f, 6.91053420e-02f, -6.70969412e-02f, 5.19807637e-02f, -4.30953279e-02f,
  -9.59566608e-02f, 4.40318920e-02f, -9.52233151e-02f, 5.62323779e-02f, -9.49379895e-03f, -1.55634724e-03f, 6.42857850e-02f, -8.69191885e-02f, -6.81167617e-02f, -4.99403067e-02f,
  -9.34093222e-02f, -1.18599057e-01f, 1.20501472e-02f, -1.60428546e-02f, -4.03597318e-02f, -6.35585636e-02f, 6.28765523e-02f, 5.88669106e-02f, 6.64087292e-03f, -6.99478611e-02f,
  -5.53862415e-02f, -1.16799317e-01f, -1.49717510e-01f, 4.73476052e-02f, -4.98201139e-02f, 2.45419294e-02f, -1.36154322e-02f, -8.89716297e-02f, -5.78217022e-02f, -7.20082000e-02f,
  6.30344599e-02f, -2.49972746e-01f, 3.07018869e-02f, 1.34882927e-01f, 1.40405536e-01f, 2.83375178e-02f, 1.62095912e-02f, 5.90728372e-02f, 8.93051773e-02f, 5.50728478e-02f,
  -1.08696990e-01f, 5.74965551e-02f, 2.49711405e-02f, -4.49390896e-02f, -5.08964360e-02f, 1.22872218e-01f, 1.55594870e-01f, 1.07248396e-01f, 8.86557475e-02f, 4.71120737e-02f,
  -5.50916083e-02f, -3.90640460e-02f, -1.01001620e-01f, -1.57415457e-02f, 4.69298214e-02f, 6.74773455e-02f, -5.37272058e-02f, -4.53971066e-02f, -4.57606204e-02f, 9.90479961e-02f,
  2.12526953e-04f, -1.01259194e-01f, 8.52737650e-02f, -1.14757478e-01f, 1.76170003e-02f, -4.10181247e-02f, 8.13720077e-02f, 1.78684406e-02f, -1.14808396e-01f, 3.40466797e-02f,
  4.66042943e-02f, -3.35045643e-02f, 8.01964477e-03f, -7.85600692e-02f, 2.57503372e-02f, -7.31030405e-02f, 2.13958994e-02f, -4.57206927e-02f, 8.39843997e-04f, -6.58594966e-02f,
  -1.19830810e-01f, -1.55292340e-02f, 6.68594167e-02f, -2.12838519e-02f, 5.92419272e-03f, 1.02077045e-01f, 1.40689174e-02f, 3.20467725e-02f, -7.75427325e-03f, 8.57864991e-02f,
  -4.97585870e-02f, -3.08628380e-03f, -8.26294906e-03f, -3.38072069e-02f, 5.83352856e-02f, 1.09440520e-01f, -1.04236426e-02f, 5.83086759e-02f, -5.77754192e-02f, -7.96951503e-02f,
  -6.50671870e-02f, 1.16589647e-02f, 5.20564355e-02f, -2.32087132e-02f, -4.81246263e-02f, 8.69469866e-02f, 4.52606454e-02f, -8.79968517e-03f, -5.74028231e-02f, 6.62301853e-02f,
  3.80597040e-02f, 7.35108554e-02f, -1.14137501e-01f, -8.75284523e-02f, -3.52008604e-02f, -5.86408749e-02f, 6.89654946e-02f, -1.06987104e-01f, -1.45868054e-02f, 7.19349906e-02f,
  8.15429017e-02f, -6.08762689e-02f, 1.22206032e-01f, -6.26318827e-02f, -7.84474518e-03f, -1.00003347e-01f, 6.89190775e-02f, 1.02770294e-03f, 3.52720134e-02f, 6.57766983e-02f,
  2.36514192e-02f, 4.68001924e-02f, -1.03890419e-01f, -4.81602438e-02f, 7.03902692e-02f, 1.16799260e-02f, -6.54649213e-02f, 1.43725097e-01f, 3.15522552e-02f, -1.22512646e-01f,
  -1.03825770e-01f, 1.13566935e-01f, 8.03381875e-02f, 1.14607081e-01f, -1.06679555e-02f, 1.64602563e-01f, 1.34620415e-02f, 3.57829034e-02f, 1.72581058e-02f, 1.98727921e-02f,
  -8.07412788e-02f, -4.15407158e-02f, 1.88296169e-01f, -1.41803082e-02f, 1.31633684e-01f, 2.64929622e-01f, 2.18758136e-01f, -2.90947631e-02f, 4.63479273e-02f, 6.27636984e-02f,
  -9.43170264e-02f, -5.74161001e-02f, -4.58368510e-02f, -1.00201569e-01f, -1.02028273e-01f, 8.65612924e-02f, 6.09327443e-02f, -4.68499362e-02f, 1.18839435e-01f, 7.95710161e-02f,
  5.40649928e-02f, -1.26835898e-01f, -1.29603356e-01f, -1.34025022e-01f, -5.48485853e-02f, -9.07831788e-02f, 7.25570172e-02f, -6.57452568e-02f, 4.51168455e-02f, -3.34149450e-02f,
  1.46998195e-02f, 7.30396435e-02f, -2.84335595e-02f, -1.53122395e-01f, 5.68778105e-02f, -3.86922695e-02f, 9.44759548e-02f, -6.04622066e-02f, -1.19419634e-01f, -6.90843165e-02f,
  -2.26606634e-02f, 4.58825082e-02f, -6.08469956e-02f, -2.06929911e-02f, -6.93213642e-02f, 1.64225623e-02f, -9.47194919e-02f, 1.02860341e-03f, -5.54357395e-02f, 6.79271519e-02f,
  -7.76148960e-02f, 3.98539416e-02f, 8.28704983e-02f, -4.08643335e-02f, -3.53018679e-02f, -2.78636534e-02f, 4.98456024e-02f, -4.70214002e-02f, 8.00055042e-02f, -8.03118348e-02f,
  -8.40964466e-02f, -2.67309370e-03f, 6.93050399e-02f, -1.06999185e-02f, 4.16592993e-02f, -9.70545337e-02f, 9.93322395e-03f, -8.26575682e-02f, 7.62663633e-02f, 2.16388796e-02f,
  8.73524919e-02f, 7.01268166e-02f, 3.52943912e-02f, 2.69455481e-02f, -3.25983763e-02f, 1.08253948e-01f, -4.10972275e-02f, -2.54593156e-02f, 3.19351442e-02f, -2.22047660e-02f,
  -1.48989959e-02f, 8.15183967e-02f, -9.59014893e-03f, 3.13208699e-02f, 9.31947827e-02f, 5.32992296e-02f, 1.89931109e-03f, 7.89598674e-02f, 3.46114039e-02f, 5.99902235e-02f,
  -7.88067803e-02f, 1.28641510e-02f, 3.68696004e-02f, -1.26632433e-02f, 9.52232853e-02f, -4.64993902e-03f, 2.09235903e-02f, -6.21947758e-02f, -1.26749892e-02f, 6.41721115e-02f,
  4.07010643e-03f, 2.19569281e-02f, -7.03323074e-03f, 8.10416639e-02f, 9.41481590e-02f, 1.08804986e-01f, -1.01157166e-01f, -6.63923398e-02f, 6.78063855e-02f, -4.14237939e-02f,
  4.22998630e-02f, 1.19378559e-01f, 1.01506285e-01f, 9.11990404e-02f, -7.44824708e-02f, 2.38603987e-02f, 1.10827699e-01f, 1.07040189e-01f, 5.61814904e-02f, -4.68725823e-02f,
  -2.77446389e-01f, 6.31118938e-02f, -2.26698518e-02f, 8.82276222e-02f, 1.96223974e-01f, 1.05034068e-01f, 1.91018581e-01f, 3.32968645e-02f, 5.39031960e-02f, -1.14856856e-02f,
  9.29077342e-02f, 5.73943220e-02f, 8.21940079e-02f, 3.81324552e-02f, -3.26594301e-02f, 1.35354802e-01f, 1.40681148e-01f, -2.39615068e-02f, -1.18228436e-01f, 3.44679877e-02f,
  1.16434768e-01f, 9.50987190e-02f, -9.93322730e-02f, -1.03773303e-01f, 1.96465850e-02f, 8.60026702e-02f, -7.96602368e-02f, -1.36192814e-02f, 9.55806673e-02f, 9.36427787e-02f,
  -9.59677398e-02f, -1.86375484e-01f, -1.87123548e-02f, 5.76539822e-02f, -1.68291181e-02f, -1.38830841e-01f, -3.14661525e-02f, -1.34548604e-01f, -9.10513625e-02f, -6.57901093e-02f,
  -6.79885224e-02f, -7.73112774e-02f, -9.23670549e-03f, -7.33068585e-02f, -9.91372243e-02f, -8.47581774e-02f, -8.96515092e-04f, -1.67663127e-01f, -1.67650208e-01f, -3.93884862e-03f,
  1.56211611e-02f, -3.63375284e-02f, -2.35549789e-02f, -1.26429513e-01f, -6.24104813e-02f, -1.40434243e-02f, -1.29411444e-01f, -2.00634524e-02f, -4.77846973e-02f, -3.38126607e-02f,
  6.47939444e-02f, -6.67180717e-02f, 5.23249917e-02f, -8.18675309e-02f, 1.45981135e-02f, 5.89124560e-02f, 7.07278103e-02f, 1.22193787e-02f, 3.74935626e-04f, -7.63480738e-02f,
  4.20460068e-02f, -6.64087432e-03f, -7.51883350e-03f, 2.58397553e-02f, -2.79403813e-02f, -7.28767691e-03f, -2.92925052e-02f, -2.18793582e-02f, 2.90366672e-02f, -3.05796806e-02f,
  -6.62950277e-02f, 1.40299611e-02f, 5.68802990e-02f, -1.10806413e-02f, -5.35332821e-02f, 5.49468547e-02f, 3.59299779e-02f, -8.18108618e-02f, 2.18600780e-02f, -9.68888476e-02f,
  -9.90815237e-02f, -1.71671942e-01f, -8.96963775e-02f, -2.99751125e-02f, 4.39442433e-02f, -7.56953564e-03f, -1.25108557e-02f, 3.55438739e-02f, -7.65314698e-02f, -7.09751174e-02f,
  2.43942272e-02f, 8.89688323e-04f, 4.44546342e-02f, -6.52205572e-02f, -5.82456142e-02f, 8.50073155e-03f, -2.10717251e-03f, 6.11569360e-02f, 1.30999060e-02f, -8.40836316e-02f,
  5.85023351e-02f, -3.57602499e-02f, -1.49613619e-01f, -4.55484763e-02f, 2.78292899e-03f, -1.24738358e-01f, -6.67383447e-02f, 2.62105446e-02f, -5.90630285e-02f, -9.87710208e-02f,
  2.50040423e-02f, -1.63424879e-01f, 1.59221366e-01f, 3.82372886e-02f, 1.85263112e-01f, 1.46112725e-01f, 9.54119191e-02f, 7.15513760e-03f, -8.07490014e-03f, -5.70080429e-03f,
  -2.92421319e-03f, -9.03877523e-03f, -6.20405003e-02f, -7.31412172e-02f, -3.41123231e-02f, -5.57223558e-02f, -2.73376075e-03f, 1.13873728e-01f, 2.63077412e-02f, 1.38762057e-01f,
  -9.83470585e-03f, 9.86080617e-02f, 5.83526865e-02f, -3.76092345e-02f, -6.63596541e-02f, 4.20152731e-02f, -3.73355448e-02f, 1.25246951e-02f, -1.02688976e-01f, 2.16187481e-02f,
  2.46156588e-01f, -8.51472542e-02f, -5.06423973e-02f, -1.09553397e-01f, -1.86400842e-02f, 2.77303830e-02f, -8.00589174e-02f, -1.73220653e-02f, -5.11485301e-02f, -8.25754330e-02f,
  -8.41910914e-02f, 4.71952967e-02f, -4.33424786e-02f, 2.61193374e-03f, -1.73961360e-03f, 7.63312876e-02f, -4.81646061e-02f, -1.64848804e-01f, -2.80525964e-02f, -3.24526988e-02f,
  -3.42922081e-04f, 3.73664610e-02f, 5.78613281e-02f, 4.88397703e-02f, -1.34600431e-01f, -2.79925466e-02f, 3.35762575e-02f, -3.12655680e-02f, -6.37394562e-02f, 4.96292673e-02f,
  -4.30802330e-02f, 4.46190871e-03f, -4.01948616e-02f, 7.76247703e-04f, -1.61645729e-02f, -2.48369426e-02f, 6.52253255e-02f, 1.85346138e-02f, -6.25649914e-02f, 5.93858678e-03f,
  -7.16465563e-02f, -3.94204110e-02f, -2.84944419e-02f, 5.19505814e-02f, 4.09180224e-02f, -6.26862571e-02f, -8.29330832e-02f, -9.28568766e-02f, -1.19024375e-03f, -1.96624193e-02f,
  2.14545783e-02f, -1.83663312e-02f, 1.59980860e-04f, -9.78997648e-02f, 2.44063735e-02f, -5.55822253e-02f, 2.48445626e-02f, 3.49457227e-02f, -8.88710096e-02f, 6.06049746e-02f,
  1.34113520e-01f, -1.28634796e-01f, 7.98808560e-02f, -1.15429372e-01f, 9.60232690e-02f, -1.10258274e-01f, -1.26569588e-02f, -1.01787008e-01f, -1.18137255e-01f, -4.89301234e-03f,
  5.63113466e-02f, -9.23747644e-02f, -1.52889285e-02f, -5.45706637e-02f, 4.99584116e-02f, -3.36282477e-02f, -1.03834979e-01f, 3.71822566e-02f, -5.55291586e-02f, 8.01048707e-03f,
  -1.02583900e-01f, 8.26943442e-02f, 1.81779385e-01f, 1.19675934e-01f, -6.83095818e-03f, 1.26260921e-01f, 1.96941465e-01f, 5.54775968e-02f, 3.86047028e-02f, 5.53350076e-02f,
  8.50074813e-02f, 5.61788827e-02f, 3.07737589e-02f, 1.20113455e-01f, 7.50330603e-03f, -1.79444373e-01f, -8.63263607e-02f, 2.76869396e-03f, 1.02791572e-02f, 7.70888776e-02f,
  9.54341739e-02f, 8.85893106e-02f, -5.38504049e-02f, -6.50207847e-02f, -1.20239995e-01f, -7.08591789e-02f, -1.08137570e-01f, -3.41360979e-02f, -1.67826727e-01f, -6.43275231e-02f,
  -1.38204098e-01f, 4.64615151e-02f, -1.84409367e-03f, -4.19516303e-02f, -2.09618229e-02f, -5.22556975e-02f, 5.49770407e-02f, -7.44502097e-02f, -4.03572842e-02f, -1.07043654e-01f,
  4.87240702e-02f, 1.42897964e-01f, -1.32904708e-01f, -6.37856200e-02f, -8.19054022e-02f, 4.70870994e-02f, 3.75702940e-02f, 1.13674132e-02f, -8.12099874e-02f, 1.08560454e-02f,
  -4.05408032e-02f, -8.04642290e-02f, -6.50128424e-02f, -1.00667730e-01f, -1.72427036e-02f, -8.71722996e-02f, -1.27635878e-02f, -9.02684107e-02f, -8.30330625e-02f, -9.03776288e-02f,
  -2.27635656e-03f, 2.30302662e-02f, -2.62926016e-02f, -4.62666303e-02f, 8.49741697e-02f, -8.00638422e-02f, 3.16570699e-02f, -2.44568158e-02f, 8.38851482e-02f, -2.49722712e-02f,
  -4.17346060e-02f, -4.72588763e-02f, 3.42483595e-02f, 2.22157929e-02f, -3.28250378e-02f, 4.12489846e-02f, -5.81275187e-02f, -1.94459874e-02f, -1.37800248e-02f, 3.84531580e-02f,
  6.13146462e-02f, 4.12817895e-02f, 4.06404026e-02f, 7.51721188e-02f, 7.80790746e-02f, 4.87957075e-02f, -4.42697220e-02f, -2.72488948e-02f, -4.65286821e-02f, -1.62448399e-02f,
  9.12776068e-02f, -6.78607747e-02f, 1.00639872e-01f, 3.92997339e-02f, 6.85843527e-02f, 2.22650506e-02f, -4.19462249e-02f, 5.71751744e-02f, 6.13101665e-03f, 4.66198847e-02f,
  9.31484029e-02f, -3.51818912e-02f, 7.04002604e-02f, -6.60414174e-02f, -3.73963974e-02f, -5.53339832e-02f, 8.67386088e-02f, -4.72705588e-02f, -4.93612364e-02f, -7.83048198e-02f,
  6.11485390e-04f, 4.75572869e-02f, 7.91377667e-03f, 5.48324324e-02f, 5.25396951e-02f, -5.71771525e-02f, -5.66266403e-02f, 1.25772823e-02f, 3.21924239e-02f, 3.09816971e-02f,
  3.10649276e-02f, -1.03126772e-01f, -1.05511826e-02f, -2.67284568e-02f, 9.65175703e-02f, -6.88885674e-02f, -4.57673669e-02f, 4.16714847e-02f, -1.16666690e-01f, 1.80325862e-02f,
  -1.02395311e-01f, -7.74430260e-02f, 4.12893631e-02f, 7.23987743e-02f, -4.44685631e-02f, 1.06428310e-01f, -6.23960160e-02f, -6.66141808e-02f, 6.27141446e-02f, -7.20252004e-03f,
  1.67264591e-03f, 4.96319681e-02f, 4.46114056e-02f, 6.38996363e-02f, -5.09142317e-02f, 7.28716999e-02f, -8.26531872e-02f, -5.53131886e-02f, -2.29924638e-02f, 7.23891929e-02f,
  -3.80641744e-02f, 2.00009793e-02f, -1.18483551e-01f, -3.40119712e-02f, -2.74229981e-02f, -3.96842211e-02f, 1.41068455e-02f, -5.67618161e-02f, -3.03505566e-02f, 3.92962210e-02f,
  8.98626149e-02f, -1.21100403e-01f, -5.60819812e-04f, 1.24653475e-02f, -3.22012268e-02f, 4.98224534e-02f, 2.02820133e-02f, 7.98018575e-02f, -1.25258025e-02f, -5.09237237e-02f,
  -2.76766755e-02f, -3.93763818e-02f, 5.05061857e-02f, -2.96949595e-02f, 2.94032358e-02f, 1.73306614e-02f, -2.12444495e-02f, -8.02842602e-02f, -2.48263739e-02f, 5.84939793e-02f,
  3.86458375e-02f, -2.75340471e-02f, 2.54685879e-02f, -8.10038671e-02f, -2.26002596e-02f, 3.58232320e-03f, -3.09433565e-02f, 6.06978871e-02f, 3.41165662e-02f, 1.14888281e-01f,
  -7.66387284e-02f, 3.06652160e-03f, -8.62319916e-02f, 4.04782742e-02f, -9.14347172e-02f, 1.91892497e-02f, -4.84397002e-02f, 2.27184612e-02f, -1.75460894e-02f, 6.78713322e-02f,
  -7.66370818e-02f, -9.81548280e-02f, -8.39120373e-02f, 1.90871523e-03f, -8.81499797e-03f, -4.76976968e-02f, -5.04327342e-02f, -6.12542927e-02f, -7.17904195e-02f, -1.58751365e-02f,
  -7.78612634e-03f, -4.86804135e-02f, -1.42599561e-03f, -1.91661399e-02f, 4.44370247e-02f, -9.18099061e-02f, 1.65223107e-02f, 1.93007737e-02f, 7.89235085e-02f, -2.36948710e-02f,
  9.30907726e-02f, -6.90467656e-02f, 1.17717437e-01f, -9.80040524e-04f, 7.27718621e-02f, -4.32801284e-02f, 2.45317514e-03f, 5.65000139e-02f, -7.13833347e-02f, 9.41386968e-02f,
  -5.94739392e-02f, 1.46318944e-02f, -5.38352020e-02f, 3.51982787e-02f, -2.07910221e-02f, -4.73291427e-02f, 3.34740034e-03f, -1.27141597e-02f, -2.96553448e-02f, 9.54682603e-02f,
  9.45940316e-02f, -5.32711446e-02f, 6.71571353e-03f, -4.84661981e-02f, -6.87630624e-02f, -9.38271265e-03f, 4.18482274e-02f, 1.02423735e-01f, -6.09316044e-02f, 1.00972496e-01f,
  -8.19966942e-02f, -6.66126385e-02f, 1.08760267e-01f, 1.48983710e-02f, -1.62456147e-02f, 3.80637497e-02f, -1.10816143e-01f, -2.08897572e-02f, -7.83730149e-02f, -3.80158313e-02f,
  5.87137640e-02f, -2.74175964e-02f, -7.33655393e-02f, -8.31179786e-03f, -5.93599379e-02f, 4.27434966e-02f, -8.52773413e-02f, 4.94599454e-02f, -2.45642327e-02f, -1.66837107e-02f,
  3.57794613e-02f, 1.79276913e-02f, 8.20946917e-02f, -4.13285717e-02f, -6.61484292e-03f, -4.44335565e-02f, 8.76413137e-02f, 7.67003074e-02f, -8.72895047e-02f, -5.62431142e-02f,
  1.47527024e-01f, 7.85916578e-03f, 3.35692540e-02f, -1.33868247e-01f, -1.58154638e-03f, 2.99110413e-02f, 8.66251439e-02f, 8.08467641e-02f, 4.88168821e-02f, -4.41288715e-03f,
  3.44909728e-03f, -1.00720681e-01f, -2.46611573e-02f, -5.65963015e-02f, 3.52768525e-02f, 5.93597128e-04f, -1.05563402e-01f, -5.87517582e-02f, -9.88555700e-02f, 3.86222303e-02f,
  -1.18976021e-02f, -6.26931638e-02f, 9.53747332e-02f, -4.23379503e-02f, -8.62785280e-02f, 6.13789447e-02f, 1.00163534e-01f, 7.77585879e-02f, -2.60944515e-02f, 9.34331715e-02f,
  -3.36166807e-02f, 4.70533036e-02f, 1.78122206e-03f, 2.83445623e-02f, 8.37536622e-03f, 8.26399475e-02f, -4.00028080e-02f, 4.98745916e-03f, -2.01422325e-03f, 6.15492463e-03f,
  -4.86637056e-02f, -7.99055919e-02f, 7.76220411e-02f, 7.81426132e-02f, -8.10524076e-03f, 7.19450638e-02f, -4.31370661e-02f, -5.93905933e-02f, -1.26803452e-02f, 4.38467860e-02f,
  -3.45236026e-02f, -4.25049756e-03f, -2.45587695e-02f, 7.12687969e-02f, 3.41141373e-02f, 3.82691473e-02f, 1.79990451e-03f, -9.53084752e-02f, -7.81660751e-02f, 5.28076179e-02f,
  1.00616693e-01f, -1.37541950e-01f, 1.08645305e-01f, -6.01974092e-02f, -2.53514908e-02f, 1.30265148e-03f, -9.10571814e-02f, -7.38411248e-02f, -6.85883835e-02f, -4.77133319e-02f,
  2.44833250e-02f, 5.72752617e-02f, 2.14026943e-02f, -8.14737868e-04f, -2.72063687e-02f, 6.71238229e-02f, -7.54099041e-02f, -4.32119183e-02f, 2.31406000e-03f, -8.20633993e-02f,
  -7.61949494e-02f, -1.38925004e-03f, -2.09484696e-02f, 2.98293699e-02f, 6.67136312e-02f, 1.03630997e-01f, 1.12483371e-02f, -5.17594293e-02f, 1.63362939e-02f, 7.67107457e-02f,
  9.48564187e-02f, 1.28745642e-02f, -1.59445316e-01f, 4.30289693e-02f, -1.52577627e-02f, 2.06447933e-02f, -7.42477328e-02f, 4.38032039e-02f, 2.71801166e-02f, 5.17536849e-02f,
  8.50344002e-02f, 1.13907374e-01f, 1.62278283e-02f, 4.70211022e-02f, -4.41058688e-02f, 3.34987342e-02f, -7.06998678e-03f, -6.49142824e-03f, 9.31884199e-02f, -1.88320838e-02f,
  4.09367569e-02f, -6.21334985e-02f, 4.96040918e-02f, 6.08386658e-03f, -1.00337744e-01f, -1.27352281e-02f, -3.05310711e-02f, -1.96542200e-02f, -1.16107948e-01f, -3.78491990e-02f,
  1.10367887e-01f, -3.96045074e-02f, 3.53888460e-02f, -6.34194762e-02f, -1.05152810e-02f, 3.44134085e-02f, -4.63579670e-02f, -1.02040350e-01f, 4.54835854e-02f, 6.28852174e-02f,
  4.65472080e-02f, -2.59196182e-04f, -8.68206918e-02f, -6.39163181e-02f, -9.44540277e-02f, 1.63983088e-02f, -9.65191796e-02f, -1.03661925e-01f, 4.18941927e-05f, -2.94097327e-02f,
  -1.01719804e-01f, -5.92811704e-02f, 7.00478703e-02f, -5.35562076e-02f, -1.36497943e-02f, 3.47297490e-02f, -1.89928953e-02f, -9.30705965e-02f, -1.08948402e-01f, 6.14822023e-02f,
  5.02222776e-02f, -3.59761678e-02f, -1.51811764e-02f, -1.32423639e-02f, 4.54565994e-02f, 7.47093782e-02f, -1.54804839e-02f, -4.47742583e-04f, 3.44486199e-02f, -2.41800901e-02f,
  3.41737606e-02f, -5.05021475e-02f, -6.29239231e-02f, 7.10279867e-03f, 2.97959223e-02f, 2.62810141e-02f, 5.24969073e-04f, 4.03511478e-03f, 5.17770238e-02f, -6.32508891e-04f,
  9.55235139e-02f, 3.21609043e-02f, -2.61880551e-02f, -9.32286233e-02f, -6.15106560e-02f, 5.73442578e-02f, -4.85090539e-02f, -4.51317206e-02f, 7.19247311e-02f, -3.05192303e-02f,
  1.73293665e-01f, -5.45694083e-02f, 1.34371936e-01f, 5.05184243e-03f, -1.88756312e-04f, -4.89590578e-02f, 2.53703687e-02f, 5.64261526e-02f, -3.02537382e-02f, 4.62255366e-02f,
  -7.02854618e-02f, 5.46570495e-02f, -2.27049496e-02f, -8.65332931e-02f, 5.66070117e-02f, 7.24107251e-02f, 8.60387832e-02f, 3.27852815e-02f, -1.04382738e-01f, 4.51428108e-02f,
  -4.07388322e-02f, 1.24980658e-02f, 1.94620743e-01f, 4.51463871e-02f, 9.44477469e-02f, 4.13788445e-02f, 1.25408992e-02f, -4.29650135e-02f, 6.56247512e-02f, 1.88410491e-01f,
  1.03226289e-01f, -4.86215353e-02f, 1.43440306e-01f, 3.43090817e-02f, 1.95843056e-02f, -1.19444109e-01f, -9.01948009e-03f, 7.13543147e-02f, 7.56148845e-02f, -7.57529587e-02f,
  8.67511630e-02f, -7.83584639e-03f, 6.36787638e-02f, 5.34498692e-02f, 9.35728326e-02f, -2.15236284e-03f, -7.74004683e-02f, -2.68986486e-02f, 1.35246012e-02f, -4.15850952e-02f,
  4.63803113e-02f, -2.79115848e-02f, 6.92931339e-02f, -5.99375926e-04f, 4.69540134e-02f, -1.30080513e-03f, -4.08393405e-02f, 4.81931120e-02f, -3.21213156e-02f, -1.06704690e-01f,
  -5.25165908e-02f, 9.00943503e-02f, 6.52112812e-02f, 3.24261226e-02f, 1.29271641e-01f, 7.57125691e-02f, 6.22965582e-02f, 9.01629329e-02f, 4.05844338e-02f, -5.47937378e-02f,
  2.33247988e-02f, 6.45151734e-02f, 7.44638965e-02f, 3.26777250e-02f, -8.66681337e-03f, 9.27316993e-02f, 8.86977315e-02f, 9.80897546e-02f, 9.48265493e-02f, -1.11413291e-02f,
  2.53916681e-02f, -5.86509146e-03f, -2.94297151e-02f, 9.39239338e-02f, 5.01020066e-02f, -5.90578429e-02f, 8.45695958e-02f, 1.56814940e-02f, 7.78581053e-02f, -3.31801623e-02f,
  4.52022180e-02f, -3.09677422e-02f, 1.51178660e-03f, -4.95472783e-03f, 8.28115940e-02f, -1.53548187e-02f, -7.39378482e-02f, 9.61414427e-02f, -6.91370368e-02f, 9.08921361e-02f,
  1.93100814e-02f, -3.40434238e-02f, -3.61038744e-02f, 1.80941317e-02f, 1.09080501e-01f, 6.54075518e-02f, -7.80425742e-02f, 8.95598531e-03f, -2.84262765e-02f, 6.50702119e-02f,
  1.28376782e-02f, 8.90397206e-02f, 8.29580799e-02f, 6.09294176e-02f, 9.66702849e-02f, 3.87108997e-02f, 8.51913616e-02f, -6.97519705e-02f, -3.93903181e-02f, -6.05136529e-02f,
  -9.69534293e-02f, -3.60860629e-03f, 3.37767079e-02f, -3.42292921e-03f, -1.53688444e-02f, 1.24269642e-01f, 9.76094753e-02f, -4.81374115e-02f, -6.71372190e-02f, -5.12069799e-02f,
  -4.02024761e-02f, -4.96030487e-02f, 6.56633750e-02f, 4.20488231e-02f, -8.72657299e-02f, -5.11934496e-02f, 6.56317845e-02f, 9.14852694e-02f, -3.45270941e-03f, 1.00664116e-01f,
  1.06038906e-01f, 4.22304198e-02f, -8.48752931e-02f, 1.63422450e-02f, -8.02144781e-02f, -7.40950927e-02f, -2.06711944e-02f, 1.05138794e-02f, 5.18491827e-02f, 5.17657353e-03f,
  -1.22918496e-02f, -1.40364096e-01f, -1.29357027e-02f, -5.47437482e-02f, 7.26174489e-02f, -9.85103920e-02f, -7.91198015e-02f, -9.93870646e-02f, -2.28075981e-02f, -4.97909300e-02f,
  1.82184484e-02f, -1.21377856e-01f, -5.74401096e-02f, 8.31244327e-03f, -9.10952091e-02f, -9.49863531e-03f, 2.55685132e-02f, -1.00427963e-01f, 3.02121812e-03f, -1.32113278e-01f,
  7.28302822e-03f, -7.99924806e-02f, 2.81466767e-02f, 8.02735612e-02f, -9.78163034e-02f, -1.28845870e-01f, -4.43757921e-02f, -3.79909910e-02f, -6.07439838e-02f, -1.43821090e-01f,
  -9.73407105e-02f, -1.58490613e-02f, 7.99979866e-02f, -1.12064771e-01f, 6.88514262e-02f, -2.41289474e-02f, -4.10984010e-02f, 9.69256461e-02f, 5.18950075e-03f, 2.93306187e-02f,
  -7.32740164e-02f, 3.57198976e-02f, 3.74999344e-02f, -5.50299250e-02f, -4.81137186e-02f, -2.55247671e-02f, -3.03101223e-02f, 9.56262089e-03f, 1.06629729e-01f, 2.38376036e-02f,
  -1.10202484e-01f, -9.96406302e-02f, -7.77927190e-02f, 7.25575835e-02f, -2.24745013e-02f, -7.74213299e-02f, -1.45597355e-02f, -2.63012946e-03f, 2.02166699e-02f, -1.63108766e-01f,
  -6.73030317e-02f, -7.27072135e-02f, -1.71372443e-02f, 2.30701622e-02f, -3.04042008e-02f, 1.27376830e-02f, 1.39637990e-02f, -9.24128368e-02f, -3.86142768e-02f, 1.89132504e-02f,
  2.58538332e-02f, -3.00752744e-02f, -5.30285798e-02f, 9.66733973e-03f, -1.48066944e-02f, -4.20274809e-02f, -5.73175326e-02f, -9.84140113e-02f, -2.44934577e-02f, -5.23325950e-02f,
  2.69620828e-02f, 5.05989082e-02f, 2.86228247e-02f, 4.49578874e-02f, 3.54534835e-02f, 2.85145976e-02f, 5.91944866e-02f, 5.98332211e-02f, 6.23690039e-02f, 5.19028381e-02f,
  3.58603485e-02f, 5.59037291e-02f, -4.81872857e-02f, -8.80797654e-02f, -4.38216701e-03f, 3.73444147e-02f, -5.48282824e-02f, -6.18646815e-02f, 3.30379456e-02f, 5.25705032e-02f,
  4.87460494e-02f, -3.65084447e-02f, -6.60521090e-02f, 3.79374474e-02f, 3.86969931e-02f, 4.71861102e-02f, 4.82719094e-02f, 2.30572019e-02f, -8.27798918e-02f, -6.80951104e-02f,
  -6.50262982e-02f, -5.79813085e-02f, -2.94303726e-02f, -9.71297622e-02f, 8.26875039e-04f, -7.30816349e-02f, -9.67635065e-02f, -7.83110261e-02f, -9.96560007e-02f, -1.95773050e-01f,
  -1.76875412e-01f, -1.46138281e-01f, -6.63588941e-02f, -3.03865839e-02f, 1.60832509e-01f, 1.60627365e-01f, 7.66128674e-02f, 5.64044863e-02f, -7.14292284e-04f, 5.66590317e-02f,
  9.83921159e-03f, -7.64109939e-02f, -2.55441889e-02f, 3.02754119e-02f, 2.92690992e-02f, 5.56703098e-02f, 1.15888916e-01f, 5.16726412e-02f, 5.40546551e-02f, 8.20500031e-02f,
  7.94054717e-02f, -6.83707446e-02f, 8.42057634e-03f, 4.27173227e-02f, 5.25792055e-02f, -4.90131155e-02f, 2.34267022e-02f, 2.95903906e-02f, 5.31991497e-02f, 4.75844443e-02f,
  1.00442216e-01f, -1.88441515e-01f, 1.02306463e-01f, -1.03698552e-01f, -7.92735666e-02f, 5.93602993e-02f, -3.57293747e-02f, -1.01229429e-01f, -4.89101261e-02f, -1.14247028e-03f,
  -4.74941032e-03f, -5.51786125e-02f, -3.35882194e-02f, -6.69563636e-02f, -2.46313252e-02f, -4.75101806e-02f, -1.06336437e-01f, -8.34147166e-03f, 2.85257716e-02f, -9.67062414e-02f,
  5.21802604e-02f, -1.21905869e-02f, -7.70207271e-02f, -1.48814144e-02f, 2.09899992e-02f, -1.11293364e-02f, -4.55801040e-02f, 7.12822564e-03f, -9.62062553e-02f, -7.13486820e-02f,
  -3.14280093e-02f, -2.22405940e-02f, 5.82428575e-02f, 4.98368628e-02f, 5.59028517e-03f, 5.70318811e-02f, 4.68413867e-02f, 4.61646952e-02f, 1.59215368e-03f, 4.21955250e-02f,
  5.37208654e-02f, 8.76215398e-02f, 6.57308772e-02f, 8.06065425e-02f, -4.02957760e-02f, -4.06884626e-02f, 8.08346719e-02f, -8.68658870e-02f, 4.68278453e-02f, -8.25495869e-02f,
  -2.26634531e-03f, -5.18023819e-02f, -4.24691141e-02f, -5.77957928e-02f, -9.08307731e-02f, -3.73440818e-03f, -6.82611838e-02f, -2.90805548e-02f, 1.59387514e-02f, -6.48477003e-02f,
  9.59728062e-02f, -8.60679224e-02f, 2.27601081e-02f, -6.31385744e-02f, 6.42505288e-02f, -2.18917821e-02f, -5.95629551e-02f, 2.48118341e-02f, 6.05070591e-02f, -5.26152700e-02f,
  -7.45219067e-02f, -6.49920478e-02f, 3.90870310e-02f, -4.93813418e-02f, 5.07330708e-02f, 8.72144252e-02f, -5.21769039e-02f, -5.45372516e-02f, 7.33793899e-02f, 8.41487944e-02f,
  7.05067068e-02f, 1.68711379e-01f, 1.15518004e-01f, 9.43454430e-02f, -3.52089084e-03f, 5.96675836e-02f, 1.30606428e-01f, 1.59764454e-01f, 8.29054937e-02f, 1.87220991e-01f,
  -1.30290970e-01f, -7.58651569e-02f, -1.65358204e-02f, -3.01983356e-02f, 3.47399935e-02f, -1.08585365e-01f, -1.80081781e-02f, -1.05822615e-01f, -8.37407261e-02f, -9.89524648e-02f,
  -1.25636822e-02f, -2.46809479e-02f, 2.61993706e-02f, -7.20979832e-03f, 5.03756432e-03f, -2.72084447e-03f, -6.24542981e-02f, -4.30031754e-02f, -7.64389115e-04f, -3.58830318e-02f,
  3.70877124e-02f, -1.21465378e-01f, -1.13422349e-01f, -4.36525047e-02f, 8.21383819e-02f, 1.26135498e-01f, -3.02149300e-02f, 8.09665769e-02f, 1.34914160e-01f, 1.34026706e-01f,
  4.20984663e-02f, -5.06209545e-02f, -5.05416319e-02f, -5.26180789e-02f, -2.85600498e-02f, 3.96579280e-02f, -5.78427874e-02f, -3.93260159e-02f, 4.05782349e-02f, -1.90304387e-02f,
  -6.47681486e-03f, 8.67077410e-02f, 6.86402153e-03f, 8.97349603e-03f, -1.21812709e-02f, -4.26105736e-03f, -1.11788884e-01f, -5.09796701e-02f, -2.30140612e-02f, -5.97770885e-02f,
  -6.64240867e-02f, 2.83371052e-03f, -7.24682733e-02f, -7.54934475e-02f, -6.33520931e-02f, 8.11032951e-02f, 9.23332497e-02f, 6.51522726e-02f, -2.66111549e-02f, 8.41211900e-02f,
  4.98832464e-02f, -2.26077083e-02f, 8.02455842e-02f, -3.01568825e-02f, -9.11796186e-03f, 7.90081024e-02f, -6.91191154e-03f, -8.93804953e-02f, -1.01203464e-01f, -8.55644569e-02f,
  6.05147406e-02f, 3.90031897e-02f, -7.97433481e-02f, -4.37174961e-02f, -5.20287156e-02f, 2.00354550e-02f, 3.90791744e-02f, -4.49436530e-02f, -8.65779221e-02f, -8.86064172e-02f,
  -5.34466095e-02f, 5.01020998e-02f, 4.51658964e-02f, 1.07761370e-02f, 7.24089071e-02f, -7.32337534e-02f, -5.59664443e-02f, 4.56834398e-02f, 4.83702607e-02f, -2.97971610e-02f,
  4.30685431e-02f, -6.12194948e-02f, 4.17008698e-02f, -1.00892326e-02f, -6.80575892e-02f, -1.12045277e-02f, 9.49213654e-02f, 2.90369391e-02f, -6.90726470e-03f, 7.60935694e-02f,
  -5.02014197e-02f, 7.49607533e-02f, -2.94801351e-02f, -5.34325764e-02f, -1.08641021e-01f, 3.37371528e-02f, -7.91014805e-02f, -5.37689105e-02f, -1.65310521e-02f, 2.19625086e-02f,
  -1.31620407e-01f, -1.44294888e-01f, -1.29717946e-01f, -2.93536391e-02f, -8.86344835e-02f, -3.21265906e-02f, 3.27317044e-02f, -2.61409879e-02f, -1.49663193e-02f, -1.30501062e-01f,
  -1.07583083e-01f, 1.53827965e-01f, 1.51396677e-01f, -6.73446506e-02f, 7.78548717e-02f, 1.56050771e-01f, 9.59661901e-02f, 2.28208322e-02f, -2.78005516e-03f, 4.75033820e-02f,
  1.59039535e-02f, -1.43019468e-01f, -1.15936752e-02f, 5.98602556e-02f, 1.43097445e-01f, 1.21633925e-01f, 1.41840190e-01f, 9.38778594e-02f, 9.95161086e-02f, 7.05020279e-02f,
  8.65975453e-04f, 7.95751996e-03f, 1.68420915e-02f, -7.86694407e-04f, 7.09132478e-02f, -9.84546691e-02f, -5.54026978e-04f, -2.11427771e-02f, -4.56600897e-02f, -5.02093649e-03f,
  4.08301130e-02f, 1.26049206e-01f, -9.48223006e-03f, -2.19441745e-02f, 3.71534377e-02f, -1.01267286e-01f, -3.52505594e-02f, 5.28866872e-02f, -7.63430521e-02f, -6.06860816e-02f,
  -5.46469949e-02f, 1.10395381e-03f, 1.60096325e-02f, 2.18981374e-02f, -7.86291435e-02f, -5.94413653e-02f, 1.39528895e-02f, -2.30753440e-02f, 6.40509874e-02f, 8.66075605e-02f,
  8.77993298e-04f, -1.05128415e-01f, -1.65194031e-02f, -6.15050979e-02f, 1.19476892e-01f, 6.79302588e-02f, -4.14014049e-02f, 4.88104939e-04f, -1.09818392e-02f, -3.75103429e-02f,
  -5.48256747e-02f, 7.95711800e-02f, 7.24647865e-02f, -8.29412118e-02f, -1.61227714e-02f, -3.59618813e-02f, -4.63640429e-02f, -6.08017407e-02f, 2.02397928e-02f, -2.02009231e-02f,
  1.08731035e-02f, -9.26693603e-02f, 1.75309069e-02f, -8.87350887e-02f, -7.78178126e-02f, 1.39023745e-02f, -5.07709235e-02f, 7.25421906e-02f, -9.41616856e-03f, -8.09659436e-02f,
  7.53765777e-02f, -4.11141291e-03f, -8.05055499e-02f, -3.80949564e-02f, -3.60397547e-02f, 8.54111090e-02f, -1.05163202e-01f, 3.66108678e-02f, -8.25973004e-02f, 8.21259245e-03f,
  -1.44119218e-01f, 2.50120591e-02f, -8.89919177e-02f, 7.11568668e-02f, -1.93997528e-02f, 3.96084711e-02f, -2.82224976e-02f, -1.67654473e-02f, 4.44766246e-02f, -1.61606316e-02f,
  -8.00841600e-02f, 8.54414478e-02f, -7.62502989e-03f, 7.75143355e-02f, 1.74149906e-03f, -8.50087255e-02f, -6.89621195e-02f, 5.27913049e-02f, 9.50150378e-03f, -2.00898387e-02f,
  -1.96703617e-02f, -7.57417036e-03f, -1.12637796e-01f, -3.96177508e-02f, -3.37917171e-02f, -9.08596814e-02f, 2.09572278e-02f, -6.85081258e-02f, -7.25708753e-02f, -3.37325968e-02f,
  -6.61121756e-02f, -3.45616899e-02f, 1.30614623e-01f, -8.41795504e-02f, -8.08906779e-02f, -4.74339165e-02f, 4.38516364e-02f, 2.17597969e-02f, 1.00896321e-02f, -1.11996278e-01f,
  -1.25889212e-01f, -1.29208744e-01f, -1.03937589e-01f, 4.40906100e-02f, 1.20025143e-01f, 9.05002058e-02f, 1.95967965e-02f, 8.22448805e-02f, -8.84339120e-03f, 6.58387737e-03f,
  2.48565394e-02f, 1.05211824e-01f, 5.04039526e-02f, -5.40614873e-02f, -4.57328670e-02f, 3.08023524e-02f, 4.09538075e-02f, 8.69238749e-03f, 5.97142763e-02f, -6.54311478e-02f,
  -3.06020747e-03f, -1.64037079e-01f, 7.65286162e-02f, 4.83857021e-02f, 8.38676393e-02f, -2.16932725e-02f, 6.24540783e-02f, 7.09620640e-02f, -2.70885583e-02f, 4.75520492e-02f,
  -5.62805459e-02f, -3.57850897e-03f, 6.82466999e-02f, -4.37515322e-03f, 6.49601966e-02f, 4.79863398e-02f, -3.51035446e-02f, 1.07119612e-01f, -7.15623200e-02f, 4.80073281e-02f,
  -1.09331392e-01f, -8.03812668e-02f, -9.88643989e-02f, 4.70328219e-02f, -6.93077873e-03f, -9.39994305e-02f, 7.54394084e-02f, 4.79831314e-03f, 5.61730899e-02f, -2.61907615e-02f,
  1.16220482e-01f, -5.22224465e-03f, -9.12516937e-02f, 5.26435971e-02f, -6.44573867e-02f, -8.48151967e-02f, -4.12009694e-02f, 3.69184949e-02f, -3.57201211e-02f, 4.82304841e-02f,
  -5.92082813e-02f, -2.06266791e-02f, 3.51063274e-02f, -1.29890246e-02f, 1.57242250e-02f, -5.41695626e-03f, -5.28260991e-02f, -4.10294831e-02f, -4.98381779e-02f, 6.94301054e-02f,
  -8.74563232e-02f, -4.50695343e-02f, 7.06190169e-02f, -5.61328419e-02f, 4.05652747e-02f, -3.37871350e-02f, -5.87947927e-02f, 3.75410207e-02f, 8.13501626e-02f, -1.02676407e-01f,
  -5.64534627e-02f, 6.14657216e-02f, 2.66334880e-02f, 1.12015270e-02f, -7.01007992e-02f, -2.48413105e-02f, -7.22688437e-02f, -8.00938085e-02f, 5.77629805e-02f, -1.42715441e-03f,
  -1.14366777e-01f, 9.15539935e-02f, -3.96656021e-02f, -3.52577120e-02f, 7.73250908e-02f, -1.89336706e-02f, -8.28659534e-02f, 3.23816650e-02f, 4.65357751e-02f, 4.21959460e-02f,
  5.13930246e-02f, -3.73274684e-02f, 7.65142664e-02f, 5.34879118e-02f, -1.13674384e-02f, -6.24405406e-02f, -7.53660053e-02f, 9.64249894e-02f, 6.18330576e-02f, -3.24277277e-03f,
  -6.24638908e-02f, -1.61766410e-01f, -3.71807180e-02f, 6.27413904e-03f, -3.58300358e-02f, 4.68896180e-02f, 6.26646504e-02f, 9.33964252e-02f, 4.69318517e-02f, 2.91668866e-02f,
  -1.20030575e-01f, -7.37122521e-02f, -9.26287174e-02f, -1.78232640e-02f, 6.78612366e-02f, -4.44996208e-02f, 5.89283854e-02f, -4.30001691e-03f, 1.15843870e-01f, 8.47384259e-02f,
  8.32201466e-02f, 1.08610682e-01f, -3.62618789e-02f, 9.29695368e-02f, -1.19978353e-01f, -8.79554227e-02f, 6.78319633e-02f, -2.37128790e-02f, 3.69840264e-02f, -7.18140230e-02f,
  -1.33300841e-01f, 2.40148678e-02f, 1.28053620e-01f, -5.12332134e-02f, 3.22378725e-02f, 6.36314750e-02f, -9.16994214e-02f, 6.83310907e-03f, 1.16223563e-02f, -8.94607008e-02f,
  -1.38504179e-02f, -1.39911603e-02f, 5.32691665e-02f, -2.49359161e-02f, -1.98187809e-02f, 6.67656213e-02f, -1.90526657e-02f, 3.42100933e-02f, 3.96634787e-02f, 6.28712550e-02f,
  -1.56309344e-02f, -3.04293837e-02f, 3.47408466e-02f, 8.03210288e-02f, -4.99712024e-03f, 1.52300531e-02f, 3.02581023e-02f, 6.42377138e-02f, 4.17635292e-02f, -7.10259518e-03f,
  3.29582840e-02f, 4.83630039e-02f, -1.39791481e-02f, -8.35113525e-02f, 4.02818397e-02f, -5.74182021e-03f, -6.48559704e-02f, 9.10742730e-02f, -5.20912372e-02f, -3.06861009e-02f,
  7.46145770e-02f, -6.78947475e-03f, 8.57457370e-02f, 2.72052567e-02f, -8.52861106e-02f, 5.55777214e-02f, -1.63687393e-02f, -2.19676588e-02f, -3.82325798e-02f, 4.94978949e-03f,
  -1.02496343e-02f, 1.26975803e-02f, -8.35135877e-02f, 6.87829033e-02f, 8.35439041e-02f, -1.61400493e-02f, 3.94592807e-02f, -6.07180260e-02f, 2.88576651e-02f, -6.23202249e-02f,
  -6.16757087e-02f, 1.64304838e-01f, -1.43730352e-02f, -3.08451476e-04f, 3.44057307e-02f, 5.03426343e-02f, -3.61348093e-02f, 1.49436668e-02f, 7.92274475e-02f, -6.26405329e-02f,
  -8.29321072e-02f, 1.68213919e-02f, 4.10534963e-02f, 6.74539134e-02f, -3.51842083e-02f, -4.18341309e-02f, -8.89828280e-02f, 7.39537254e-02f, 4.88265827e-02f, -4.58607301e-02f,
  -1.14302570e-02f, 3.79691869e-02f, -9.09293517e-02f, -4.19748574e-02f, 4.84847091e-02f, 6.87116235e-02f, 3.29454569e-03f, -6.32188842e-02f, 4.82266583e-02f, -3.66917662e-02f,
  -1.95313320e-01f, -8.40506181e-02f, -1.37364835e-01f, -2.11234212e-01f, -1.33303955e-01f, -1.23920210e-01f, -5.83499670e-02f, -1.42776489e-03f, -1.71426520e-01f, -9.77250561e-02f,
  9.62759648e-03f, 1.46124270e-02f, -1.12550461e-03f, 1.26835793e-01f, 1.38266340e-01f, -1.31609961e-01f, -1.76353455e-01f, -5.23216128e-02f, 1.65405586e-01f, 1.17962979e-01f,
  -4.80868816e-02f, -1.22221105e-01f, 5.48880100e-02f, -2.71966755e-02f, -1.66617036e-01f, -9.23240930e-02f, -1.10518612e-01f, -1.04465023e-01f, -3.23803313e-02f, -2.05923676e-01f,
  8.97566453e-02f, -1.28718644e-01f, 9.87941921e-02f, 8.60885084e-02f, 4.51261550e-02f, 6.85758516e-02f, -5.96286803e-02f, 1.45339016e-02f, 6.73603788e-02f, -6.23178482e-02f,
  4.63527031e-02f, 8.30067694e-02f, 8.33006054e-02f, 3.56530994e-02f, -6.29102811e-02f, -1.21010356e-02f, -1.91269498e-02f, -2.38376670e-02f, 1.29360445e-02f, -8.54165256e-02f,
  -9.30495374e-03f, 2.96800844e-02f, 2.28805002e-02f, 2.45399848e-02f, 5.92667609e-02f, 2.22875662e-02f, 4.73111942e-02f, -1.74216740e-02f, 8.95755589e-02f, -8.16464331e-03f,
  2.29349937e-02f, -5.07040992e-02f, 3.66631821e-02f, 8.50030407e-02f, -5.46958670e-03f, 4.95290719e-02f, -3.44628952e-02f, 2.89890207e-02f, 3.09255514e-02f, -5.36757661e-03f,
  3.16840261e-02f, -8.84359702e-02f, 3.07365879e-02f, -7.09280148e-02f, 7.61091290e-03f, 2.31285486e-02f, 4.42752391e-02f, -4.95668575e-02f, 6.19771853e-02f, 2.45225728e-02f,
  5.84974326e-02f, 6.57415763e-02f, -8.08921382e-02f, 2.18433458e-02f, -4.06558253e-03f, -1.03488266e-01f, 2.79652495e-02f, 3.68941128e-02f, -4.68720160e-02f, -6.23480901e-02f,
  7.32394457e-02f, 5.15319072e-02f, -3.14109214e-02f, 5.35973869e-02f, -1.21440873e-01f, -6.96715042e-02f, 5.96702332e-03f, 1.74498241e-02f, -5.62631451e-02f, -6.19465709e-02f,
  1.20517440e-01f, -4.35530841e-02f, 2.75970693e-03f, -4.55998778e-02f, 9.87753421e-02f, 4.03425433e-02f, -6.91638812e-02f, -1.69558097e-02f, 8.94418582e-02f, 2.92798947e-03f,
  3.28772962e-02f, 6.52109832e-02f, 1.32609857e-02f, 9.56811160e-02f, -3.56970355e-02f, -3.28098089e-02f, 1.00016683e-01f, 8.62101838e-02f, 9.73358005e-02f, 1.74111109e-02f,
  -8.06222409e-02f, -1.63733259e-01f, 5.19794635e-02f, -1.53795928e-01f, -2.38934252e-02f, -2.33703479e-02f, -1.78856105e-01f, -1.17010795e-01f, -1.52262328e-02f, -6.17319942e-02f,
  -1.01061072e-02f, 3.18671130e-02f, -2.16126926e-02f, 5.96916266e-02f, -3.97848152e-02f, -1.22767136e-01f, -7.82691594e-03f, 1.13245912e-01f, -1.86822563e-02f, 3.66756134e-02f,
  -1.13416493e-01f, -1.54755920e-01f, -2.92968545e-02f, 6.02013292e-03f, -1.07213721e-01f, 1.13083497e-02f, -9.80534032e-03f, -3.04328483e-02f, -1.18420683e-01f, -1.06832288e-01f,
  -3.56744565e-02f, 5.68617657e-02f, 9.14704725e-02f, 2.29914784e-02f, 3.32628116e-02f, 1.96785964e-02f, 3.24185267e-02f, 1.01162978e-01f, -7.08743036e-02f, -8.20387974e-02f,
  8.43300670e-03f, -4.99876477e-02f, -7.45503455e-02f, 4.50698286e-03f, -7.63837099e-02f, 1.94236822e-02f, -4.82273474e-02f, 4.50906157e-02f, 8.69877785e-02f, -1.08072102e-01f,
  1.83921084e-02f, -3.75904553e-02f, 8.06334093e-02f, -6.20393902e-02f, -6.05210438e-02f, 1.64550040e-02f, -5.67643940e-02f, -5.34336120e-02f, 8.98275301e-02f, 6.30547712e-03f,
  -2.88260523e-02f, 2.33722255e-02f, 9.64259077e-03f, -2.90624313e-02f, -7.12177232e-02f, 6.01387918e-02f, 4.63728085e-02f, -6.05612025e-02f, 5.31275831e-02f, -2.80854907e-02f,
  4.60714102e-02f, 5.45708742e-03f, -2.33977232e-02f, -3.79160680e-02f, 7.61662275e-02f, 5.00858354e-04f, -8.45353976e-02f, 5.78599945e-02f, 5.64920492e-02f, 5.06075211e-02f,
  1.58856588e-03f, 9.16485861e-02f, 5.53735159e-03f, 4.12042113e-03f, 1.10914465e-02f, -7.65874460e-02f, -5.89897074e-02f, 5.21607101e-02f, -3.87081578e-02f, -1.66319776e-02f,
  1.01989601e-02f, 2.34639436e-01f, -9.01574327e-04f, -4.92254458e-02f, -3.22559588e-02f, 6.28090501e-02f, 6.77656755e-03f, -3.60994302e-02f, 9.92553681e-02f, -5.81400916e-02f,
  -6.65732995e-02f, -4.98944055e-03f, 6.05553091e-02f, -9.45277289e-02f, 3.13130245e-02f, -9.38892066e-02f, 1.23421308e-02f, 8.13416988e-02f, 7.96097741e-02f, -1.16666071e-01f,
  -1.19953498e-01f, -1.20203152e-01f, 6.53555896e-03f, -1.97811089e-02f, -9.06109139e-02f, 1.37575358e-01f, 8.52330029e-02f, -2.62301583e-02f, 5.25624193e-02f, -1.48118272e-01f,
  -1.23709843e-01f, -2.54345238e-02f, 6.95279017e-02f, -8.03989395e-02f, -5.19303158e-02f, -3.52482572e-02f, -5.48102483e-02f, 4.96940687e-02f, 5.94924344e-03f, 7.87250847e-02f,
  4.37289290e-02f, -8.79294649e-02f, -4.47791256e-02f, -2.79655568e-02f, -8.10311586e-02f, 2.42099799e-02f, 7.56089156e-03f, -1.01493195e-01f, -1.21319868e-01f, -1.50070101e-01f,
  -7.55769620e-03f, -1.39452040e-01f, -1.25423804e-01f, -8.04622397e-02f, -3.50953862e-02f, -1.32197320e-01f, 1.49944443e-02f, -8.81754011e-02f, -1.10622771e-01f, -1.37377366e-01f,
  1.26561895e-01f, -6.06089272e-02f, -6.43423945e-02f, -1.60260364e-01f, 9.49545801e-02f, -2.69208979e-02f, 3.87325585e-02f, 2.91201919e-02f, 3.38622220e-02f, -2.80256588e-02f,
  -6.35014623e-02f, -2.87285075e-02f, 7.22299516e-02f, 7.82809407e-02f, -7.35402852e-02f, 6.49379194e-02f, -5.64813428e-03f, -4.67024073e-02f, 3.42642665e-02f, -1.78532396e-02f,
  -2.98984461e-02f, 3.70396823e-02f, -1.10776551e-01f, -2.86956038e-02f, 5.91194257e-02f, -1.31691068e-01f, -6.41264394e-02f, -9.18247178e-02f, -8.05785209e-02f, -3.26716378e-02f,
  7.74419531e-02f, -3.19607593e-02f, -7.61983171e-02f, -2.99610873e-03f, 6.42907992e-02f, 6.79213032e-02f, 6.56980202e-02f, -5.66815399e-02f, 2.36378815e-02f, -2.75149439e-02f,
  1.49040809e-02f, 1.41633991e-02f, -1.40056768e-02f, 1.91581436e-02f, -1.47095434e-02f, 1.17675411e-02f, -1.01584792e-01f, -2.28573605e-02f, 3.48385200e-02f, 2.45882142e-02f,
  -9.46238413e-02f, -3.30575444e-02f, 1.02302738e-01f, -1.21448645e-02f, -5.43948263e-02f, -2.21433695e-02f, 2.21408121e-02f, 1.52468067e-02f, 6.79026544e-02f, 3.57984304e-02f,
  1.29616886e-01f, -1.10721596e-01f, -4.68400382e-02f, -8.17430988e-02f, 1.73408929e-02f, 9.68573689e-02f, 7.11681694e-02f, -4.11021821e-02f, 6.52512461e-02f, -1.55399600e-02f,
  -4.65596514e-03f, -3.62866633e-02f, 1.93373989e-02f, 3.93655375e-02f, -2.11262982e-02f, -4.91878949e-02f, -2.75096986e-02f, -1.17719509e-01f, 3.19205225e-04f, 9.40860957e-02f,
  9.78068113e-02f, -1.21687567e-02f, -4.29082327e-02f, 3.80135439e-02f, -4.64384928e-02f, -2.67764721e-02f, 4.76746298e-02f, 7.66962534e-03f, -1.34407431e-01f, -8.22107568e-02f,
  -1.09613359e-01f, -1.36272326e-01f, -6.76691309e-02f, -1.89512610e-01f, -8.73976499e-02f, -5.26911542e-02f, 5.45573086e-02f, -8.01171828e-03f, -6.64814785e-02f, 1.32799102e-02f,
  -9.23738778e-02f, -1.00544997e-01f, -1.01876266e-01f, -7.24809095e-02f, 3.79493162e-02f, 2.96961404e-02f, -8.94078091e-02f, 1.51293818e-02f, 8.88665542e-02f, -4.29640990e-03f,
  7.40978643e-02f, -6.06937036e-02f, -4.46916521e-02f, -5.95843419e-02f, 2.44472711e-03f, -1.24199219e-01f, -1.16097589e-03f, -9.19269174e-02f, 8.01928341e-03f, 1.75533001e-03f,
  -4.13618013e-02f, -1.03260996e-02f, 1.81698631e-02f, 1.80539675e-02f, 1.79562569e-02f, 4.95094759e-03f, -3.42025682e-02f, -1.04653731e-01f, 3.89841087e-02f, 9.07065719e-03f,
  4.22792770e-02f, -1.42464051e-02f, -4.39896807e-02f, -3.30380909e-03f, 5.77268703e-03f, -2.86381394e-02f, -7.61011317e-02f, -8.05374533e-02f, 6.35561869e-02f, 7.12987408e-02f,
  9.44617763e-02f, -6.31930903e-02f, 2.90488545e-02f, -1.25105679e-02f, 4.85493019e-02f, 5.69006577e-02f, -9.41990241e-02f, -3.34666781e-02f, -3.00089512e-02f, 9.42985713e-03f,
  5.96417710e-02f, -8.20766613e-02f, -7.61366040e-02f, 5.79712167e-02f, 4.84368317e-02f, -1.24506811e-02f, -8.50423127e-02f, -9.22958478e-02f, 9.22651365e-02f, -7.03321770e-02f,
  1.47692626e-02f, -2.90837209e-03f, 4.38236147e-02f, -1.07862666e-01f, 2.10430231e-02f, -8.73284265e-02f, -2.69732419e-02f, -2.18767133e-02f, 8.03877190e-02f, 6.63889349e-02f,
  -6.51198551e-02f, 3.28699648e-02f, -1.06720425e-01f, 2.92902607e-02f, 7.72234723e-02f, 7.71829709e-02f, 2.01737378e-02f, 6.92373067e-02f, 4.11664024e-02f, 3.62425670e-02f,
  -1.54788911e-01f, 1.03273526e-01f, 2.79257186e-02f, 6.17258586e-02f, -4.32440341e-02f, 1.45966690e-02f, -8.98397639e-02f, 6.20855801e-02f, 3.86711918e-02f, 7.30256438e-02f,
  8.68953168e-02f, -9.54730138e-02f, -2.76277773e-02f, -7.46140406e-02f, 5.32068796e-02f, 3.66551317e-02f, 1.81882251e-02f, -2.56125350e-02f, 7.85368960e-03f, 8.87190774e-02f,
  1.68510079e-02f, -1.32642016e-01f, -1.46827310e-01f, -1.00336760e-01f, -6.62414283e-02f, -5.96199930e-02f, 3.01458873e-02f, 5.28252944e-02f, 5.13379127e-02f, -1.72737360e-01f,
  4.09815162e-01f, 1.21866815e-01f, -6.95966929e-02f, -8.92581418e-03f, -3.60837462e-03f, 2.92063840e-02f, -2.75815129e-02f, -5.59041053e-02f, -5.99228442e-02f, 1.08786397e-01f,
  2.21287683e-01f, 2.18568996e-01f, 1.12637602e-01f, 1.64901957e-01f, 1.09086946e-01f, 1.22596798e-02f, -1.48323476e-01f, 5.96559979e-02f, 1.33353308e-01f, 6.76393583e-02f,
  4.24951389e-02f, 8.17500576e-02f, 5.50646484e-02f, 1.36937108e-02f, 2.31337212e-02f, -3.86691317e-02f, -9.77659300e-02f, 6.30271062e-02f, -2.94386651e-02f, -5.02605103e-02f,
  8.03096816e-02f, 1.41233817e-01f, -8.09814408e-02f, 1.04479946e-01f, -8.52810312e-03f, 5.47079407e-02f, 1.70061775e-02f, -3.75284962e-02f, -1.64770577e-02f, -1.37174532e-01f,
  -9.40529909e-03f, 7.87559077e-02f, -3.82796302e-02f, 1.50504038e-02f, -3.53716202e-02f, -2.49418113e-02f, -8.12650099e-02f, -4.00452651e-02f, 6.26282319e-02f, -2.94389036e-02f,
  -4.73775007e-02f, 5.17878681e-02f, 5.84464781e-02f, -9.71296504e-02f, -2.49880590e-02f, 1.32887498e-01f, 6.60521984e-02f, -3.56232822e-02f, -6.90457523e-02f, -8.02834481e-02f,
  -1.75020043e-02f, 1.39476821e-01f, 5.21515571e-02f, 5.18639274e-02f, 7.92503655e-02f, -1.07154977e-02f, -2.69610202e-04f, 1.89560074e-02f, 4.60421667e-02f, 2.48240195e-02f,
  3.50519791e-02f, 5.09487465e-02f, 2.51539312e-02f, 7.51482276e-03f, 8.21645930e-02f, 1.53770568e-02f, 4.42204513e-02f, 1.51822781e-02f, 6.95246458e-02f, -4.26317416e-02f,
  7.33254552e-02f, -8.96184426e-03f, 2.82779206e-02f, 4.54990938e-02f, -4.20962907e-02f, 2.11211480e-02f, 7.71940723e-02f, 6.77659065e-02f, 1.07129551e-01f, -4.20890152e-02f,
  -8.30465108e-02f, 1.03425771e-01f, 5.84024042e-02f, 2.50367075e-02f, -6.56146556e-02f, -4.75697592e-02f, -5.24975806e-02f, -1.20734774e-01f, 4.11492325e-02f, -6.83317333e-02f,
  -3.02000623e-03f, 1.77097239e-03f, 4.04704772e-02f, -2.34240126e-02f, 1.18142115e-02f, 1.57885291e-02f, -6.61236271e-02f, -4.87569682e-02f, -9.71447006e-02f, -2.04226933e-02f,
  -8.41750652e-02f, 1.48206241e-02f, 1.14200987e-01f, -2.26193406e-02f, 3.31877843e-02f, 1.30525559e-01f, -7.30136856e-02f, -8.50726292e-02f, 3.20310853e-02f, -6.86329976e-02f,
  -3.15045238e-01f, 1.68122038e-01f, 1.47634581e-01f, -1.40969053e-01f, 5.11356778e-02f, 2.07896411e-01f, 2.03419432e-01f, 8.61008391e-02f, -4.29468155e-02f, 9.80627388e-02f,
  1.10842474e-01f, -1.26080900e-01f, -1.49428904e-01f, -8.32026005e-02f, -6.92035630e-02f, 4.75850888e-02f, 9.49181318e-02f, -1.01030357e-02f, -1.35551974e-01f, -3.14374454e-02f,
  -3.66113186e-02f, -1.98664650e-01f, -2.42506862e-01f, -5.03506288e-02f, -1.46027148e-01f, -1.16194129e-01f, -9.31918323e-02f, -6.14890456e-02f, -5.32411411e-02f, -1.52488267e-02f,
  9.17939246e-02f, 1.38185155e-02f, 4.22146078e-03f, -5.02730161e-02f, -8.37662537e-03f, 5.23224324e-02f, 3.51163447e-02f, -1.05521999e-01f, -2.10013166e-02f, -6.79319054e-02f,
  -7.55212680e-02f, 7.64498487e-04f, 2.12055328e-03f, 7.64171705e-02f, -2.34804042e-02f, 8.22330564e-02f, 2.37931963e-02f, 1.42186237e-02f, -2.86619645e-02f, 7.42519349e-02f,
  -2.74177808e-02f, 7.03600124e-02f, -1.93844326e-02f, -4.34953645e-02f, 1.62716638e-02f, 9.67725180e-03f, 5.62664494e-02f, 2.22781929e-03f, 9.27096084e-02f, -9.25278142e-02f,
  1.21399760e-01f, 6.71526715e-02f, -3.52035165e-02f, -1.92437898e-02f, 5.75723387e-02f, -8.90430734e-02f, -6.34043217e-02f, 1.37769245e-02f, -8.49827081e-02f, -7.83450529e-02f,
  -5.23609333e-02f, 7.80204237e-02f, -8.31212476e-02f, -8.45301598e-02f, 5.20580560e-02f, 5.24707921e-02f, -5.11155911e-02f, 2.59756912e-02f, 4.24305834e-02f, -8.68423134e-02f,
  -3.43265794e-02f, 2.36858781e-02f, -3.50562893e-02f, 9.36673861e-03f, 5.87227046e-02f, 7.03109577e-02f, -7.83436000e-02f, 3.09558283e-03f, -3.84268314e-02f, -2.58568525e-02f,
  -8.21724981e-02f, 1.47993684e-01f, -4.14387658e-02f, -1.24771312e-01f, 3.84529755e-02f, -4.55704816e-02f, -4.28533368e-03f, -6.00237167e-03f, -1.11192204e-01f, -2.07575280e-02f,
  -5.41323610e-03f, -5.06928824e-02f, -3.90913822e-02f, -1.70264933e-02f, -2.68318448e-02f, -4.64594066e-02f, 7.27680996e-02f, -3.36494409e-02f, -4.07673605e-03f, -4.50287126e-02f,
  7.10910782e-02f, 1.08084574e-01f, -3.98050658e-02f, -2.25126017e-02f, -7.98986852e-02f, 6.68738876e-03f, 7.80694485e-02f, 1.05846226e-01f, 3.10032163e-02f, 8.08054507e-02f,
  2.95635402e-01f, 3.13261926e-01f, 3.40926684e-02f, 1.49770349e-01f, -2.54247375e-02f, 7.54496679e-02f, 1.24156766e-01f, 2.15580389e-01f, 7.22493902e-02f, 7.45316669e-02f,
  4.08759266e-02f, 3.03140227e-02f, -3.54784466e-02f, 9.96015444e-02f, 5.60311377e-02f, 8.00219327e-02f, -2.57772021e-02f, -3.25865000e-02f, -5.62851876e-02f, 8.35783184e-02f,
  4.96715531e-02f, 1.45176873e-01f, 1.40272379e-01f, 3.20065022e-02f, -7.45027736e-02f, -1.10856071e-01f, -3.14208865e-02f, 1.33320943e-01f, -6.27682433e-02f, -8.97214562e-02f,
  -1.66186184e-01f, 2.29363337e-01f, -1.07608251e-01f, -1.00979872e-01f, 4.03524339e-02f, 1.64721278e-03f, 6.27395138e-02f, -1.01092316e-01f, -7.45449141e-02f, 2.36459412e-02f,
  -7.34192878e-02f, 4.71361689e-02f, 1.45689370e-02f, -9.20673981e-02f, 9.73395407e-02f, -2.81416662e-02f, 3.29164378e-02f, 8.55717808e-03f, -7.30242208e-02f, -4.79273386e-02f,
  -3.62334102e-02f, 8.03548694e-02f, 1.18037477e-01f, 4.97569293e-02f, -6.79926435e-03f, -2.78981160e-02f, 1.13502420e-01f, 5.15348688e-02f, -5.71877733e-02f, -2.00261083e-02f,
  -1.36069715e-01f, -2.50259656e-02f, 5.48789203e-02f, 2.29484332e-03f, -5.12503646e-02f, 7.34365135e-02f, -4.55238894e-02f, -5.89916296e-03f, -1.32734999e-02f, 1.03897385e-01f,
  -5.94349280e-02f, 8.26096907e-02f, -1.50895454e-02f, 3.77376601e-02f, 4.06062566e-02f, -6.19428158e-02f, 2.65911147e-02f, 3.13785374e-02f, 9.58001018e-02f, -1.11178821e-03f,
  5.71666611e-03f, -3.42968069e-02f, -4.55700932e-03f, -6.94558248e-02f, -6.19048327e-02f, 8.49123206e-03f, -7.45462701e-02f, 6.30864277e-02f, 8.82356837e-02f, -5.45089431e-02f,
  -1.22735882e-02f, 3.82646322e-02f, -5.05670123e-02f, -1.15634792e-01f, -2.54783519e-02f, -7.16159418e-02f, -3.22905704e-02f, 3.82673405e-02f, -6.34840690e-03f, -7.05175684e-04f,
  -1.90862976e-02f, 7.10399076e-02f, 5.04492037e-02f, -1.02819107e-01f, 6.76050223e-03f, -1.18599638e-01f, -6.34536371e-02f, -6.76978454e-02f, -9.58948359e-02f, -3.39034572e-02f,
  -7.12601691e-02f, -3.86314318e-02f, 2.22920291e-02f, 5.14074080e-02f, -1.12095840e-01f, -1.11578003e-01f, -7.53320903e-02f, -1.01059102e-01f, 9.73088294e-02f, 2.19428800e-02f,
  -1.15574216e-02f, 1.22262621e-02f, 3.31441760e-02f, -3.92479710e-02f, -4.48748469e-03f, -1.71064094e-01f, -1.28509998e-01f, -1.59105211e-01f, -6.54708669e-02f, -7.66125396e-02f,
  5.39452396e-02f, -6.30353093e-02f, 3.78530496e-03f, 1.56006645e-04f, -1.19148955e-01f, -4.47082333e-02f, -5.25242984e-02f, 9.05649066e-02f, -6.83573121e-03f, -1.01036675e-01f,
  -6.21788241e-02f, -7.90145248e-03f, 2.20667422e-02f, -3.84591962e-03f, -8.55501220e-02f, 5.09499758e-02f, 7.48921037e-02f, 6.63890271e-03f, 1.71461850e-02f, 6.91760927e-02f,
  1.08423881e-01f, -5.63947968e-02f, 4.18683998e-02f, -3.44348699e-02f, 8.57333690e-02f, 1.38692688e-02f, -4.54085208e-02f, -1.67011563e-02f, -1.91789959e-02f, -2.78713144e-02f,
  -1.86391715e-02f, 3.45043689e-02f, -2.42779292e-02f, -3.12488489e-02f, 4.50702086e-02f, 5.35332449e-02f, 7.38274911e-03f, 4.76023555e-02f, 3.14570665e-02f, -6.72448501e-02f,
  4.45870161e-02f, -2.01947754e-03f, 2.53181104e-02f, -1.40995230e-03f, -1.16494268e-01f, 1.74581762e-02f, -5.15996628e-02f, -9.01857913e-02f, -7.07630143e-02f, 8.02762061e-02f,
  -7.60726929e-02f, -9.58617926e-02f, 2.59176474e-02f, -6.78708181e-02f, -1.01705454e-01f, -9.45410505e-02f, -7.83889741e-02f, -9.17598419e-03f, 6.36936873e-02f, 3.82335298e-02f,
  -8.31297040e-02f, 1.12289349e-02f, -8.30617398e-02f, 2.75205616e-02f, -5.63443005e-02f, -1.03670090e-01f, 5.52991033e-02f, 3.37534100e-02f, 2.55336873e-02f, -1.03034712e-01f,
  1.79923300e-04f, -4.37833443e-02f, -7.10317791e-02f, -6.47121817e-02f, -4.52747382e-02f, 4.05170247e-02f, 4.47481163e-02f, -5.66815995e-02f, 4.69057821e-02f, -9.01330635e-02f,
  1.52564198e-01f, -4.58339304e-02f, -4.73548584e-02f, -5.75042330e-02f, 8.16620216e-02f, -5.44167273e-02f, -7.00566173e-02f, -2.12991089e-02f, -1.43337864e-02f, 2.81618889e-02f,
  -1.63666401e-02f, 7.99894631e-02f, 8.86627100e-03f, 6.59194291e-02f, -4.97343801e-02f, 2.47149300e-02f, 1.25289718e-02f, 4.07563709e-02f, -9.13910866e-02f, -1.05709784e-01f,
  -7.79709145e-02f, 4.56589907e-02f, 5.10113463e-02f, -3.66731435e-02f, -1.70046352e-02f, 1.11933723e-01f, -3.34652653e-03f, 7.45730251e-02f, -4.64904355e-03f, 1.22851759e-01f,
  -1.76913619e-01f, -1.06699474e-01f, 3.84961907e-03f, 1.44305438e-01f, -1.74557175e-02f, -1.52104020e-01f, -2.39092439e-01f, -5.29952645e-02f, -2.39532199e-02f, -1.05339028e-01f,
  5.05061122e-03f, 4.35534567e-02f, 1.04822300e-01f, -1.53911700e-02f, -7.62891173e-02f, 2.86592301e-02f, 1.38970658e-01f, -9.15016085e-02f, -2.86042932e-02f, -1.39744073e-01f,
  -9.35546402e-03f, 4.83990908e-02f, -3.52674648e-02f, 7.47322813e-02f, 1.61454037e-01f, -2.65849605e-02f, 1.57272905e-01f, 1.14547564e-02f, -7.17752203e-02f, 1.36063486e-01f,
  7.28916600e-02f, -7.80961011e-03f, -6.19250648e-02f, -1.84813775e-02f, 1.11469090e-01f, -8.78993645e-02f, 4.03419845e-02f, -7.20098242e-02f, -6.25112876e-02f, -5.17111458e-02f,
  7.13847652e-02f, 5.76778091e-02f, -4.05169167e-02f, -3.86009179e-02f, -7.93811865e-03f, -1.42202228e-01f, -2.43909638e-02f, -4.21039537e-02f, -1.78447533e-02f, -1.16345838e-01f,
  -3.15012336e-02f, -6.52350932e-02f, 8.43275990e-03f, -5.36723547e-02f, 1.20024290e-02f, 6.44606873e-02f, -9.18567255e-02f, -1.08036183e-01f, -9.63727478e-03f, -1.47077888e-01f,
  -4.06715572e-02f, 9.90022495e-02f, 3.02315261e-02f, -4.96258326e-02f, -4.59726229e-02f, 7.50536025e-02f, -2.18023583e-02f, 1.01218568e-02f, 4.60278429e-02f, 5.63262701e-02f,
  5.34716956e-02f, 5.95088489e-02f, 2.81562712e-02f, 4.00185920e-02f, 1.65692847e-02f, 5.07520214e-02f, -8.74080360e-02f, -5.82456701e-02f, -1.31764663e-02f, 1.92382447e-02f,
  -6.69170320e-02f, 2.08891071e-02f, -3.60644683e-02f, 3.40477712e-02f, 9.40038860e-02f, 5.70705533e-02f, -8.21980555e-03f, 2.67126169e-02f, -4.97133508e-02f, -6.72098622e-02f,
  -4.28541824e-02f, -5.05562723e-02f, 4.21583429e-02f, -7.10410699e-02f, -4.87574153e-02f, 5.38006537e-02f, -1.85654610e-02f, 3.44002098e-02f, 2.28749178e-02f, -8.23161099e-03f,
  -7.82377124e-02f, -1.22772641e-01f, -4.54066209e-02f, -5.83112128e-02f, -1.22335941e-01f, -9.81023684e-02f, -1.38505651e-02f, -8.70006830e-02f, -9.13032591e-02f, -2.62686145e-02f,
  -1.87049229e-02f, -1.74845397e-01f, -2.07812503e-01f, -4.35245298e-02f, -4.70687374e-02f, -5.74231031e-04f, -3.09139043e-02f, -3.60475928e-02f, -2.12546378e-01f, -2.40985006e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  5.76365441e-02f, 4.23236610e-03f, 1.63378879e-01f, 9.56502557e-02f, 8.19633380e-02f, 6.66587800e-02f, 2.78411582e-02f, 1.45293713e-01f, 3.31803448e-02f, 1.40868232e-01f,
  1.37562916e-01f, -1.44761410e-02f, 3.30399200e-02f, 1.41669556e-01f, 1.22278579e-01f, 1.71305552e-01f, 9.48913917e-02f, 2.04198301e-01f, 8.83188695e-02f, 1.19469784e-01f,
  -1.51689220e-02f, 1.94474235e-02f, 1.62058488e-01f, 1.42864408e-02f, 1.48112193e-01f, 1.34290438e-02f, 4.02963422e-02f, -4.57522878e-03f, 9.83792916e-02f, -3.52085419e-02f,
  -1.02928292e-03f, -5.69656910e-03f, 1.02103457e-01f, 9.37778130e-02f, 1.96762197e-02f, 2.82081719e-02f, 9.29596554e-03f, 9.68278199e-02f, 1.22764204e-02f, 5.68233132e-02f,
  1.28002346e-01f, -4.62899264e-03f, 1.02093041e-01f, 1.26702890e-01f, 6.21669590e-02f, 9.09987986e-02f, 6.43508062e-02f, 1.77437335e-01f, -2.18454618e-02f, 1.40716583e-01f,
  1.32227108e-01f, 5.63237481e-02f, 6.65268376e-02f, 4.12600078e-02f, 8.47375765e-02f, 1.41367063e-01f, 8.65461826e-02f, 1.25629321e-01f, 8.92166421e-02f, 1.34019200e-02f,
  -3.65744643e-02f, 6.67777061e-02f, -1.11396499e-02f, 2.09708866e-02f, 1.69325605e-01f, 6.24285266e-02f, 8.19830820e-02f, 2.43219212e-02f, 2.05978900e-02f, 6.32231981e-02f,
  6.36539310e-02f, 6.64521679e-02f, -1.46691483e-02f, 1.70180127e-01f, 1.82497561e-01f, 1.64401844e-01f, 1.19470708e-01f, 2.61318889e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.00809047e-02f, -2.43980989e-01f, -7.93257356e-02f, -3.65499407e-01f, -6.78487659e-01f, 6.61195591e-02f, 8.98537114e-02f, -1.04180820e-01f, -4.92352881e-02f, -6.81142807e-02f,
  6.46983311e-02f, -2.03356281e-01f, -1.72438532e-01f, 4.52427939e-03f, -2.58364975e-01f, -4.19945866e-02f, -8.83040577e-02f, 2.91659664e-02f, 5.62424324e-02f, -3.57635289e-01f,
  -3.77533138e-01f, -3.33153486e-01f, 1.04851589e-01f, -2.89415177e-02f, -1.79683685e-01f, -1.15520976e-01f, 1.29217803e-01f, 3.38505432e-02f, 1.35598527e-02f, 1.51849851e-01f,
  -4.88183424e-02f, 3.59369256e-02f, -1.73243955e-01f, 2.58262128e-01f, -2.43925363e-01f, 5.63233376e-01f, 3.02627027e-01f, -3.06240261e-01f, -1.97130606e-01f, 3.65382642e-01f,
  5.22356369e-02f, 2.42120251e-01f, -4.73653935e-02f, -5.19645959e-02f, -3.75693142e-01f, -5.66532537e-02f, 6.39396012e-02f, 2.31503844e-01f, 9.31243151e-02f, -1.60919711e-01f,
  1.48499355e-01f, -6.49925768e-02f, 4.79813248e-01f, -1.48324311e-01f, 5.34396134e-02f, 1.20496899e-01f, -9.50438436e-03f, 2.71012653e-02f, 3.39183956e-01f, -1.48571506e-01f,
  6.58901483e-02f, -3.57331969e-02f, 1.95537973e-03f, 1.18376091e-01f, -1.60192400e-02f, -2.12802574e-01f, -3.15071233e-02f, 1.33691758e-01f, -1.29011469e-02f, -4.78216298e-02f,
  1.18780762e-01f, 1.24326445e-01f, -8.28346089e-02f, 1.02505848e-01f, -6.26639426e-02f, -1.01848923e-01f, 1.53852981e-02f, 3.48865688e-01f, 8.30943659e-02f, 1.39421314e-01f,
  2.99510416e-02f, 7.13205412e-02f, 1.30432814e-01f, 3.60832177e-02f, -2.22676303e-02f, 1.73337549e-01f, 5.34420041e-03f, -8.31265002e-02f, 7.52516091e-02f, -1.23974979e-02f,
  1.46684527e-01f, 1.35319635e-01f, 9.79593322e-02f, -4.81606163e-02f, 1.49431214e-01f, -7.41091818e-02f, 3.28966416e-02f, -7.65129849e-02f, 5.17920218e-02f, -6.68898076e-02f,
  -1.20013595e-01f, -1.52708935e-02f, 3.50809634e-01f, -3.90685685e-02f, -1.24010123e-01f, -1.10813089e-01f, -2.07099728e-02f, -1.37538105e-01f, 9.38939769e-03f, 4.96404022e-02f,
  -7.26837516e-02f, 1.54908113e-02f, 6.50719553e-03f, 2.03352168e-01f, -6.00752197e-02f, 4.07823408e-03f, -1.69269413e-01f, -7.07524493e-02f, 1.09739155e-01f, 3.16118091e-01f,
  5.73956594e-02f, -1.30837841e-03f, 1.88998535e-01f, -3.93403172e-02f, -2.10691974e-01f, -7.29167312e-02f, -8.40491876e-02f, -1.25384927e-01f, -9.51629579e-02f, 1.13311008e-01f,
  2.34754473e-01f, -5.52267849e-01f, -8.70130286e-02f, 2.01930478e-01f, 5.73050193e-02f, 2.63913453e-01f, -2.29705870e-02f, 5.47768027e-02f, -4.29499298e-01f, -1.26953945e-01f,
  9.97673254e-03f, -7.65621066e-02f, 1.41335845e-01f, 5.49215823e-02f, 2.53559321e-01f, 2.06507603e-03f, 7.59581029e-02f, 2.20287070e-01f, -1.11198597e-01f, 2.20145613e-01f,
  1.24242313e-01f, 1.30675435e-01f, -2.54794389e-01f, -6.78045750e-01f, 8.91947001e-02f, 1.42848551e-01f, -2.02586893e-02f, 1.24211632e-01f, -1.86916813e-01f, 1.05141267e-01f,
  -3.23915839e-01f, 4.06090543e-02f, -1.93183258e-01f, 4.76749778e-01f, 3.21183026e-01f, 3.65990609e-01f, -5.05499780e-01f, 1.65302947e-01f, 5.02059937e-01f, -2.12532724e-03f,
  -3.34660441e-01f, 3.95771533e-01f, 1.23826966e-01f, -2.34460399e-01f, 3.12480271e-01f, -3.04637081e-03f, 3.59851301e-01f, 2.98311025e-01f, 1.00160427e-01f, 8.18370376e-03f,
  -1.83226511e-01f, 3.04451317e-01f, 3.92016679e-01f, -1.25568345e-01f, -6.17901161e-02f, 1.17115982e-01f, -1.41339198e-01f, -2.55119950e-01f, -1.40018553e-01f, 1.19354047e-01f,
  -1.17744677e-01f, -2.38943562e-01f, 9.65361893e-02f, -2.19127834e-01f, -5.54202236e-02f, 1.13081329e-01f, 1.94041759e-01f, -2.53250808e-01f, -1.75646186e-01f, -1.11036533e-02f,
  -1.29460976e-01f, -2.71934900e-03f, 2.39633262e-01f, -3.58763635e-02f, 3.10028732e-01f, 1.74396917e-01f, 1.23904739e-02f, 7.07650930e-02f, -1.47623941e-01f, -1.72055647e-01f,
  -6.46359622e-02f, 1.66383475e-01f, -5.16763330e-02f, -8.63853283e-03f, -1.23144023e-01f, 1.67343944e-01f, -1.41337678e-01f, -3.24515402e-02f, -4.95802313e-02f, 6.56354576e-02f,
  -1.86483771e-01f, 6.63005337e-02f, 7.90974498e-02f, -1.09897979e-01f, 1.06870988e-02f, -7.02239126e-02f, 6.42902851e-02f, 6.96316436e-02f, -5.30485436e-02f, -2.68017709e-01f,
  4.22071330e-02f, 1.27165820e-02f, 1.51668712e-01f, -8.62802789e-02f, -7.69911408e-02f, -5.93812801e-02f, 3.85416113e-02f, -8.90661702e-02f, -6.79224283e-02f, 2.14506924e-01f,
  5.24839722e-02f, 2.30136327e-03f, -3.29570360e-02f, -6.95765242e-02f, 3.31092663e-02f, -1.16910979e-01f, 3.36705288e-03f, 2.45731056e-01f, 2.62023419e-01f, -2.09196493e-01f,
  -5.67834787e-02f, 5.15464127e-01f, -1.95132226e-01f, 1.92686781e-01f, 9.96396169e-02f, -1.72780678e-01f, -1.53907211e-02f, 1.74122050e-01f, 1.04949055e-02f, 3.71670932e-01f,
  1.42901167e-01f, 2.15216354e-01f, 2.11227629e-02f, -3.39965850e-01f, 5.95984533e-02f, -1.20991446e-01f, 1.48182079e-01f, 1.49883568e-01f, -5.48511595e-02f, 1.67211220e-01f,
  1.28744822e-02f, 1.36652570e-02f, 1.49714679e-01f, 1.07978046e-01f, 7.94700235e-02f, 6.36058003e-02f, 2.78387278e-01f, 2.89305151e-01f, 7.35265464e-02f, 9.80458185e-02f,
  4.55411881e-01f, -3.80251765e-01f, -2.36439258e-01f, -2.74456620e-01f, -5.07152081e-01f, 1.39635012e-01f, 4.56312671e-02f, 1.02487981e-01f, -5.22653222e-01f, -2.97870547e-01f,
  -4.24619228e-01f, -5.49807660e-02f, 1.19201228e-01f, -3.43878090e-01f, -3.32482159e-01f, -3.50688696e-01f, -4.38715637e-01f, 3.44672538e-02f, 8.02306831e-02f, -3.85890976e-02f,
  -4.33321178e-01f, -2.41783440e-01f, -1.90611973e-01f, 1.20965332e-01f, -1.68195143e-01f, 1.53770849e-01f, -1.38787612e-01f, 7.25158751e-02f, -2.28714392e-01f, 9.63661000e-02f,
  -1.06266536e-01f, -1.12287477e-01f, 2.73369625e-02f, 1.33683607e-01f, -9.05061588e-02f, -2.45039105e-01f, -1.85401142e-01f, -1.37877852e-01f, -2.29525659e-02f, 2.43295774e-01f,
  -2.50088554e-02f, 1.10121354e-01f, -2.18464285e-01f, -3.42802674e-01f, 2.69143790e-01f, -1.65706620e-01f, 2.05438644e-01f, 1.05909996e-01f, 4.39456403e-02f, -4.98217829e-02f,
  6.28012046e-02f, 3.70138064e-02f, 1.28254846e-01f, -8.88845418e-03f, -4.74135168e-02f, -1.36183798e-01f, 2.88142174e-01f, 1.23385437e-01f, -1.42322838e-01f, -6.22404628e-02f,
  -1.14287809e-01f, -7.05035850e-02f, -7.78878853e-02f, 7.63396993e-02f, 9.86423492e-02f, -4.20491956e-02f, -1.59070000e-01f, -8.10740702e-03f, 5.50521724e-02f, -3.10608302e-03f,
  -1.05058953e-01f, -2.05193181e-02f, -7.00706020e-02f, 4.45452258e-02f, -2.49734581e-01f, -2.87807077e-01f, -1.68587163e-01f, -2.41429135e-02f, 2.38355082e-02f, 3.12119126e-02f,
  -1.29446954e-01f, -1.26416996e-01f, -1.71495944e-01f, -1.84419572e-01f, -1.22384012e-01f, -1.17089972e-01f, -2.51718834e-02f, -1.17745981e-01f, 1.48979977e-01f, 1.92966253e-01f,
  -4.96228449e-02f, -9.24582966e-03f, 5.15189394e-02f, 1.96565598e-01f, 1.41348302e-01f, 1.08083256e-01f, 2.48339966e-01f, -5.40044382e-02f, 9.17711928e-02f, -1.34799480e-01f,
  -1.24661319e-01f, -1.50923729e-01f, 1.55829638e-01f, 2.24046350e-01f, -9.21141431e-02f, -1.33082584e-01f, 1.59780219e-01f, 1.55636743e-01f, 1.16260193e-01f, -7.70728886e-02f,
  -3.74884605e-02f, 5.25524877e-02f, 7.78211504e-02f, -1.13083422e-01f, -1.77744538e-01f, 1.40775114e-01f, -8.10188577e-02f, 8.84840041e-02f, 1.13972850e-01f, 8.12673494e-02f,
  -2.12689310e-01f, -1.46240830e-01f, -3.16559434e-01f, 5.67159094e-02f, -2.47084260e-01f, 1.30854130e-01f, -6.57803938e-02f, -7.49146566e-02f, 2.14953795e-01f, 1.04602538e-01f,
  3.16897511e-01f, -3.72960359e-01f, -1.82270676e-01f, 1.65162176e-01f, 4.45340186e-01f, 3.90521169e-01f, 2.04953641e-01f, -2.08123386e-01f, 2.50589490e-01f, -4.69498962e-01f,
  -6.35749757e-01f, -1.30506277e-01f, 1.27226673e-02f, -1.19337223e-01f, -2.20941436e-02f, 1.53010264e-01f, -1.65902600e-01f, -3.52030039e-01f, -3.21349323e-01f, -1.96610972e-01f,
  2.64759719e-01f, -1.22590818e-01f, -6.34641573e-02f, 2.87684530e-01f, 5.68963528e-01f, 9.18937325e-02f, 1.28812179e-01f, -5.41536361e-02f, 2.45272536e-02f, 7.69886747e-03f,
  -9.01666954e-02f, -3.04615665e-02f, 1.69770587e-02f, 9.66348946e-02f, -1.01555228e-01f, -9.40125510e-02f, 9.57308486e-02f, 1.15856603e-01f, -1.01276793e-01f, -2.22826391e-01f,
  -1.33203506e-01f, 1.98264718e-01f, -4.48639579e-02f, 5.96428573e-01f, -2.92984918e-02f, 8.56651291e-02f, -5.70146963e-02f, 3.45383547e-02f, 5.78913689e-02f, -1.73406638e-02f,
  -1.03504546e-01f, -2.09273532e-01f, 4.98089455e-02f, -6.17545024e-02f, -5.03267441e-03f, -4.03643027e-03f, -4.12323251e-02f, -9.98378769e-02f, -7.29163438e-02f, 4.22962606e-02f,
  -1.30958200e-01f, 2.51605213e-01f, -6.82887295e-03f, -2.57680919e-02f, -1.48245633e-01f, 7.88668841e-02f, 1.92536339e-01f, -2.82234401e-02f, 2.83790767e-01f, 5.90010220e-03f,
  2.44199578e-03f, -1.42858312e-01f, -8.37063342e-02f, -1.62593201e-01f, 3.53769623e-02f, -4.45757154e-03f, 5.29684722e-02f, 2.56070405e-01f, -1.36542141e-01f, 2.42253989e-01f,
  5.72081245e-02f, -1.59053743e-01f, -2.13048264e-01f, 1.47148613e-02f, -1.29111618e-01f, -1.91064477e-01f, -5.53917736e-02f, 2.87009478e-02f, 1.32419407e-01f, 8.97651687e-02f,
  8.70572999e-02f, 5.43096773e-02f, -1.83652025e-02f, 1.54289708e-01f, 5.42879514e-02f, 1.05642825e-01f, 2.98614979e-01f, -7.45872483e-02f, 5.32872200e-01f, -1.81742385e-01f,
  -1.24901541e-01f, -7.18219280e-02f, -1.77114949e-01f, 1.94344670e-01f, -8.53276774e-02f, 8.21734592e-02f, 2.46355474e-01f, 4.43408377e-02f, -7.28424713e-02f, -6.83028437e-03f,
  -1.36283770e-01f, -1.05504170e-02f, 2.58733124e-01f, -1.73357874e-02f, 5.35728596e-02f, 1.19671226e-02f, -1.77520551e-02f, -1.86352104e-01f, -3.32492381e-01f, 7.10944533e-02f,
  -3.60953361e-02f, 1.76405668e-01f, -9.60671343e-03f, -2.61409074e-01f, -1.14103958e-01f, -8.51517096e-02f, -3.42885345e-01f, 4.19458896e-01f, 2.46678814e-01f, 1.82076454e-01f,
  -4.18728650e-01f, 2.36912817e-01f, -8.75902623e-02f, -1.98248684e-01f, 1.32691577e-01f, 8.70478079e-02f, 2.77962267e-01f, -4.44390118e-01f, 2.34301940e-01f, -2.39324588e-02f,
  3.17034572e-01f, 1.23705633e-01f, -3.49370509e-01f, 1.98511988e-01f, 5.38073964e-02f, -6.68155849e-02f, -1.01613827e-01f, -2.95990348e-01f, 2.41815969e-01f, -1.15701176e-01f,
  -2.84145981e-01f, 1.58483729e-01f, -4.14924845e-02f, -5.14115468e-02f, 2.66678661e-01f, -2.92350296e-02f, -1.30823702e-01f, -1.87191859e-01f, -1.19091548e-01f, -1.72512457e-01f,
  -1.74730152e-01f, 6.53478742e-01f, -3.91042642e-02f, 1.66818742e-02f, -2.68677548e-02f, 1.31314680e-01f, 3.86700593e-02f, 4.08858091e-01f, 1.07056588e-01f, 1.64374143e-01f,
  -9.84123424e-02f, -3.01819265e-01f, 4.13435735e-02f, 1.03579089e-02f, 2.07771063e-01f, -1.49372593e-01f, 1.85955229e-04f, 1.46328155e-02f, 1.10152051e-01f, -2.54533619e-01f,
  8.01213980e-02f, 3.71241495e-02f, 1.42875507e-01f, 8.83289948e-02f, 1.52170017e-01f, -7.48328939e-02f, -6.80830628e-02f, -3.55371460e-02f, 1.14792988e-01f, -3.55026801e-03f,
  1.07561972e-03f, -9.10467654e-03f, 6.51506931e-02f, 1.13371640e-01f, 2.07575932e-02f, -1.23386653e-02f, 3.24512944e-02f, 1.64904520e-01f, -1.81698482e-02f, -1.14088356e-01f,
  -5.56391589e-02f, -7.10071996e-02f, -4.92608920e-02f, 3.38628948e-01f, -1.14880830e-01f, -1.53411448e-01f, 4.75486703e-02f, -9.73143950e-02f, -7.85199702e-02f, -1.25452191e-01f,
  2.71327227e-01f, 8.57402906e-02f, 6.24495447e-02f, -4.57410030e-02f, 1.84432313e-01f, 2.17355058e-01f, -1.73122939e-02f, 1.59642845e-01f, -1.11233748e-01f, -8.54657665e-02f,
  -1.41485929e-01f, -2.22888649e-01f, 1.06294788e-01f, 3.15867931e-01f, -1.04621090e-01f, -2.08257496e-01f, -7.66791776e-02f, -3.67963314e-02f, 9.16233659e-02f, 3.05053711e-01f,
  7.70304948e-02f, 1.57036632e-01f, -1.00707538e-01f, 2.00746477e-01f, -1.80225167e-02f, 2.58958966e-01f, -2.38819003e-01f, 1.30613565e-01f, 4.70202304e-02f, 3.85327600e-02f,
  1.87975824e-01f, 1.89749926e-01f, 2.63383508e-01f, 3.43919992e-01f, 1.96623802e-02f, 3.34004670e-01f, 1.66940823e-01f, 7.04194680e-02f, 1.66942358e-01f, -7.05494136e-02f,
  2.87998259e-01f, 9.02965590e-02f, -9.62447226e-02f, 1.33895233e-01f, 2.84398437e-01f, 3.07872266e-01f, 1.81559220e-01f, 4.66898710e-01f, -2.27700695e-01f, 4.18776393e-01f,
  4.64498475e-02f, -4.88269418e-01f, 8.41796473e-02f, 1.18311353e-01f, -2.40363911e-01f, 5.50824344e-01f, 2.31789812e-01f, 1.57008007e-01f, 2.79440224e-01f, 4.86232847e-01f,
  4.17554565e-02f, -4.24044937e-01f, -2.04287603e-01f, 1.49480790e-01f, 4.33091551e-01f, -1.17769554e-01f, -2.30179206e-01f, 1.07944086e-01f, 1.04297653e-01f, 2.26557955e-01f,
  7.15678465e-03f, -1.73323467e-01f, 2.27447110e-03f, -1.35235246e-02f, -4.70910631e-02f, 7.02219009e-02f, -1.33093163e-01f, 1.77886218e-01f, 4.13432539e-01f, 3.26637834e-01f,
  4.65369195e-01f, 1.44036397e-01f, 1.07473232e-01f, -2.06146523e-01f, -1.69651076e-01f, 2.97236413e-01f, 1.11324348e-01f, 2.37512469e-01f, -1.60814792e-01f, 3.62079814e-02f,
  -5.48530035e-02f, -9.71911773e-02f, -2.14394733e-01f, -1.18684717e-01f, -1.76101938e-01f, 2.00189903e-01f, 1.32440537e-01f, 1.13844953e-01f, -2.22670093e-01f, 7.67014399e-02f,
  -1.61875397e-01f, -5.79299815e-02f, 2.16257330e-02f, 5.69056999e-03f, 1.28402576e-01f, -8.07650685e-02f, 9.53989774e-02f, -1.71607390e-01f, -1.14023976e-01f, 1.82493925e-01f,
  -7.28164911e-02f, -2.42262319e-01f, -2.51543939e-01f, -5.72907999e-02f, 1.21776434e-02f, -1.92636237e-01f, 9.30932164e-02f, -2.07404763e-01f, 5.97182009e-03f, 2.28059664e-01f,
  2.04929218e-01f, -2.10910127e-01f, -4.04985324e-02f, 6.01627827e-02f, -1.55919075e-01f, -1.61123499e-01f, -3.97016741e-02f, -6.01754449e-02f, 9.48785618e-02f, 2.69486941e-02f,
  -7.96976909e-02f, 1.98799625e-01f, -1.03569347e-02f, -1.07857287e-01f, 8.19317326e-02f, -2.20779300e-01f, -2.00508848e-01f, 3.16672660e-02f, -1.09723367e-01f, -1.11227274e-01f,
  -2.76223958e-01f, 8.98204297e-02f, -1.42846391e-01f, 2.04471909e-02f, -2.58697732e-03f, 2.44056746e-01f, 9.55133215e-02f, -1.92983896e-01f, 1.09192938e-01f, -4.09016997e-01f,
  6.93082018e-03f, -7.15144798e-02f, -9.18885842e-02f, -2.69521952e-01f, 1.74324736e-01f, 3.38866502e-01f, 2.73075327e-02f, 8.41433406e-02f, 1.92810535e-01f, 1.14683829e-01f,
  6.75758868e-02f, 1.29841551e-01f, -2.40119129e-01f, 2.56165773e-01f, -1.25577658e-01f, 5.37534105e-03f, -1.40327662e-01f, 1.20587923e-01f, -2.65590549e-02f, 5.89339361e-02f,
  -1.11141399e-01f, -3.41830164e-01f, -2.85291940e-01f, 2.70276815e-01f, -3.32371652e-01f, -1.53832510e-01f, 4.72114652e-01f, -2.91904896e-01f, -4.15727139e-01f, -5.42467386e-02f,
  -1.48179039e-01f, -1.71697915e-01f, 8.65124539e-02f, 1.85189903e-01f, 1.59871057e-01f, 8.28639641e-02f, 1.09870143e-01f, -3.78239393e-01f, -5.73325194e-02f, -4.70230073e-01f,
  1.82385519e-02f, 3.08689952e-01f, 8.83119479e-02f, 3.77645552e-01f, -2.03392565e-01f, 2.19972596e-01f, -5.06598771e-01f, -4.42738026e-01f, -2.15846032e-01f, -7.75357857e-02f,
  -2.25140274e-01f, -2.51715519e-02f, -2.84286356e-03f, -1.33629188e-01f, -6.83496967e-02f, 1.96883187e-01f, -8.36863071e-02f, -1.65195644e-01f, 6.73147365e-02f, 1.46457022e-02f,
  -1.47440791e-01f, 2.89456397e-01f, -2.32843813e-02f, 1.10501744e-01f, 7.24319220e-02f, -2.07558468e-01f, -5.64485751e-02f, -4.24071774e-02f, -3.05872690e-03f, 5.10783494e-03f,
  -9.63090286e-02f, -1.03843950e-01f, 8.01570565e-02f, -1.08559892e-01f, 1.32126600e-01f, -2.85650231e-02f, -1.42338380e-01f, 3.34217735e-02f, 3.26831102e-01f, 5.64128570e-02f,
  1.35922208e-01f, 5.12196391e-04f, -1.22683801e-01f, -7.81829283e-02f, -2.48328686e-01f, -1.12291634e-01f, 1.02833144e-01f, -1.48714140e-01f, 1.11590540e-02f, -5.96320964e-02f,
  -9.21670124e-02f, 2.27179557e-01f, -2.21508592e-01f, 7.19865859e-02f, -1.52794152e-01f, 4.59272414e-01f, -9.14616659e-02f, 1.53903529e-01f, -2.43949264e-01f, 3.60274166e-01f,
  -5.99601073e-03f, -2.08952993e-01f, -6.08938225e-02f, -1.54720694e-01f, -2.12369233e-01f, -1.74640238e-01f, 3.15845385e-03f, 5.19927740e-02f, 4.84298281e-02f, -1.48208246e-01f,
  -2.37522069e-02f, -8.32770169e-02f, -2.27867454e-01f, 3.17599415e-03f, 1.38608173e-01f, 2.63539851e-02f, -4.60193902e-02f, -1.36035964e-01f, -1.90821320e-01f, -1.51983798e-01f,
  3.02160741e-04f, 5.93215637e-02f, -2.41517022e-01f, 1.22783460e-01f, 1.34367812e-02f, -6.60593882e-02f, -8.05557817e-02f, 1.11654721e-01f, -5.69428578e-02f, -1.70789674e-01f,
  1.39167663e-02f, -1.23139463e-01f, -4.24249209e-02f, 1.08545884e-01f, -5.02798557e-02f, -1.52312785e-01f, -3.45688999e-01f, -2.10003480e-01f, -3.25122833e-01f, -3.77080828e-01f,
  -4.65074554e-02f, -2.46777721e-02f, -4.50895652e-02f, -1.44533649e-01f, -7.62078864e-03f, -1.78807482e-01f, 3.35337855e-02f, -2.68525779e-01f, -9.81802586e-03f, -9.54990238e-02f,
  -1.10829398e-01f, 4.45698090e-02f, -1.69547901e-01f, -6.64245784e-02f, 2.49275640e-01f, -3.86973731e-02f, 3.44744563e-01f, 2.44900316e-01f, 1.65026963e-01f, -1.20810390e-01f,
  -2.37279549e-01f, -3.39923561e-01f, -3.23950440e-01f, -3.17563206e-01f, 2.57193416e-01f, 1.55984670e-01f, -1.25365451e-01f, -3.48869078e-02f, 1.88310057e-01f, -2.16839388e-01f,
  -3.54877442e-01f, 1.32507846e-01f, -2.04707742e-01f, 1.57217294e-01f, 1.48075178e-01f, -1.48574129e-01f, -8.12167078e-02f, -8.76074471e-03f, 9.08127874e-02f, 3.64161521e-01f,
  -3.86917703e-02f, 1.54744953e-01f, 4.32043858e-02f, -5.10526486e-02f, -1.76997893e-02f, -1.73098385e-01f, 3.31923105e-02f, -5.27245626e-02f, -1.87952127e-02f, -2.64507309e-02f,
  -3.72757241e-02f, 1.63016737e-01f, -1.28781095e-01f, 2.22044736e-02f, -3.40985171e-02f, 1.11019157e-01f, -6.80549443e-02f, -1.35775641e-01f, -1.26087680e-01f, 1.63125440e-01f,
  -4.51896079e-02f, -1.00345440e-01f, -1.50126055e-01f, -1.20776944e-01f, -3.66047025e-02f, -1.07329555e-01f, 3.37978266e-02f, 8.96548033e-02f, -3.64428805e-03f, 1.99751668e-02f,
  3.88669185e-02f, 8.68125483e-02f, 1.88368142e-01f, -3.29471901e-02f, -3.15347165e-02f, 7.14593679e-02f, -1.35811344e-01f, -1.48097783e-01f, -1.01211801e-01f, 6.88449442e-02f,
  -1.71673819e-01f, 1.20706156e-01f, 2.16795757e-01f, -3.80730964e-02f, 5.74549809e-02f, -5.98207265e-02f, 2.73021191e-01f, -8.97365063e-02f, 1.80681348e-02f, 4.65741068e-01f,
  1.51292697e-01f, -2.18132455e-02f, 5.34957886e-01f, -1.15373559e-01f, -1.43125474e-01f, 6.51558340e-02f, -1.32224500e-01f, -9.47404769e-04f, -1.39530525e-01f, -3.37567180e-02f,
  2.24409565e-01f, 3.06814201e-02f, 1.87972367e-01f, -3.96797284e-02f, 1.28560245e-01f, -1.54766083e-01f, -1.24812543e-01f, -8.20280761e-02f, -6.62153214e-02f, -2.40974531e-01f,
  -3.01358979e-02f, -5.60030639e-02f, -1.81777984e-01f, 1.69978723e-01f, 8.18224438e-03f, 2.42656842e-01f, -4.39915061e-03f, 2.72963166e-01f, 3.82607132e-02f, 1.42022729e-01f,
  5.70378453e-02f, -1.80355564e-01f, 8.23462158e-02f, 1.06358774e-01f, 6.09958619e-02f, 1.67005569e-01f, -5.15430458e-02f, 2.05650944e-02f, 5.00718364e-03f, -4.45457339e-01f,
  2.02754140e-02f, 6.84013292e-02f, 1.91461761e-02f, 4.78019100e-03f, 5.01362234e-02f, -2.16658950e-01f, -8.87832567e-02f, -8.73158872e-02f, -2.67254915e-02f, -1.12493001e-01f,
  -7.56850392e-02f, -2.61964113e-01f, 1.59993276e-01f, -1.48507267e-01f, 3.07520300e-01f, -4.68091480e-02f, 5.49657345e-01f, -2.78572321e-01f, -1.36304602e-01f, 2.54534304e-01f,
  -1.37617644e-02f, 2.69986451e-01f, -1.40025035e-01f, -3.37807059e-01f, 4.56823945e-01f, -3.49057138e-01f, 8.30092356e-02f, 2.18666524e-01f, 1.74540177e-01f, 2.72018939e-01f,
  -4.82954890e-01f, 1.43621683e-01f, 4.12025928e-01f, -4.63916361e-01f, 2.60111559e-02f, 2.20857009e-01f, -2.28339002e-01f, -1.75871700e-01f, 8.36151391e-02f, 7.43172988e-02f,
  9.04344544e-02f, 2.52943188e-01f, -1.54100180e-01f, -2.75676101e-01f, 2.37897132e-02f, -2.39114746e-01f, 4.60155085e-02f, -1.33911714e-01f, 1.27508968e-01f, -6.88011795e-02f,
  -1.62557513e-01f, -2.29536176e-01f, 7.37686902e-02f, 1.07185945e-01f, 1.14174359e-01f, 1.12147726e-01f, -2.07750037e-01f, -8.78228694e-02f, -4.42145504e-02f, 2.27084324e-01f,
  -2.51938283e-01f, 3.92227061e-03f, 3.14756818e-02f, -2.36935094e-01f, -9.49028600e-03f, -6.75098598e-02f, -2.28450596e-02f, -1.48355871e-01f, 4.88327406e-02f, 4.52507325e-02f,
  -1.60588741e-01f, -3.92959565e-02f, 3.12380306e-02f, 2.56752998e-01f, 2.90374663e-02f, -7.88231641e-02f, -1.51699722e-01f, 1.60631239e-01f, 9.84923542e-03f, 6.17437549e-02f,
  1.48774339e-02f, -1.06180996e-01f, -5.89333475e-02f, -1.29632160e-01f, -8.19956735e-02f, -9.29738060e-02f, -1.84008591e-02f, -6.96619600e-02f, 3.70084435e-01f, 3.84739518e-01f,
  -1.68311261e-02f, 4.34088737e-01f, -1.59369677e-01f, 5.67282476e-02f, 1.26756459e-01f, 1.13934666e-01f, -1.56861231e-01f, 8.08036979e-03f, 3.19201261e-01f, -1.57902807e-01f,
  1.28139276e-02f, 1.12596840e-01f, 8.36400092e-02f, -1.38263047e-01f, -8.63431394e-03f, -6.09372668e-02f, -1.17929965e-01f, -1.32570177e-01f, 7.39492998e-02f, -7.88212568e-03f,
  7.44551793e-02f, -1.09117687e-01f, -2.66593900e-02f, 1.44827381e-01f, 6.06859997e-02f, 3.20799142e-01f, -7.13915974e-02f, -1.99031580e-04f, -9.49638933e-02f, 1.38423756e-01f,
  4.94435132e-02f, 7.74908438e-02f, 1.04486026e-01f, 4.08551320e-02f, -6.12402745e-02f, -1.47775933e-01f, 1.28667295e-01f, -4.82204854e-01f, 3.98500971e-02f, -1.63518086e-01f,
  9.35238972e-03f, 9.74393860e-02f, -1.53532494e-02f, 1.68808326e-01f, -4.72101904e-02f, 1.42277226e-01f, 3.53092104e-01f, 1.14412522e-02f, -2.75669903e-01f, 3.28145355e-01f,
  2.65515953e-01f, -6.04216829e-02f, -4.25884783e-01f, -2.82554924e-01f, -3.04636836e-01f, 1.76105320e-01f, 1.18835486e-01f, -2.21957371e-01f, 1.50229707e-02f, -2.70560771e-01f,
  4.66557086e-01f, 1.53969660e-01f, -5.33839762e-01f, 3.75608265e-01f, 2.75311828e-01f, -1.09951586e-01f, -2.01295525e-01f, 2.04605743e-01f, 3.38779360e-01f, -1.81607842e-01f,
  -1.98626414e-01f, 1.79997578e-01f, -2.65348703e-01f, 1.28963590e-02f, -5.30855432e-02f, -3.80846597e-02f, -5.83776794e-02f, -1.96973339e-01f, -1.07008062e-01f, -1.27988547e-01f,
  -1.10196821e-01f, -1.34069920e-01f, -1.36772498e-01f, 1.82578370e-01f, -3.95795479e-02f, -1.71515793e-01f, 2.73432940e-01f, -1.47522926e-01f, 3.73454913e-02f, 1.37419656e-01f,
  -3.93108577e-02f, -2.29277089e-01f, 5.32073006e-02f, -1.30876154e-01f, 1.68176413e-01f, 7.52370805e-02f, -2.06213742e-01f, -1.12674959e-01f, 4.88252193e-02f, -1.69277579e-01f,
  1.45212356e-02f, 9.60865095e-02f, 3.35802957e-02f, -8.93182307e-02f, 1.81638062e-01f, 1.94682166e-01f, 9.98718441e-02f, -1.92035124e-01f, 3.38562518e-01f, -1.95973098e-01f,
  -1.02565147e-01f, -7.94605091e-02f, 1.93708658e-01f, -1.19754799e-01f, 1.28828004e-01f, -7.91999847e-02f, -2.13539198e-01f, 3.78330618e-01f, 3.76275666e-02f, 6.33635461e-01f,
  3.49589795e-01f, -9.14622620e-02f, -8.55612382e-02f, 2.11771339e-01f, 8.77175704e-02f, -1.08817190e-01f, -1.01296222e-02f, -1.20095596e-01f, 1.28847227e-01f, 6.83319569e-02f,
  1.96105782e-02f, 9.48265120e-02f, 6.41485630e-03f, 7.03366920e-02f, -7.17821643e-02f, -1.11437783e-01f, -4.82743885e-03f, 1.74149305e-01f, -1.69387624e-01f, -2.58088768e-01f,
  -2.29582071e-01f, -1.39041558e-01f, -1.56244561e-01f, -1.17316902e-01f, 2.10781619e-02f, 2.18539461e-01f, -1.91493183e-01f, -2.15632901e-01f, 1.50158599e-01f, 2.42165387e-01f,
  3.64746675e-02f, -1.51376650e-01f, -5.85222021e-02f, 1.23225570e-01f, 1.06477194e-01f, -4.05871749e-01f, 4.99436073e-03f, 1.75583497e-01f, -7.37130351e-04f, 8.30339044e-02f,
  2.09813863e-01f, -2.11703494e-01f, 8.46525133e-02f, -3.40216719e-02f, -5.58403209e-02f, 1.33795619e-01f, 2.29624864e-02f, -1.69894472e-03f, -1.33743072e-02f, 1.32318556e-01f,
  1.91717260e-02f, 2.75774412e-02f, -6.18563704e-02f, 1.30819017e-02f, 1.53360918e-01f, 5.81628941e-02f, 3.69835496e-01f, 3.28237116e-01f, -2.60181546e-01f, -3.98525983e-01f,
  4.37817842e-01f, -1.22251146e-01f, -9.84664708e-02f, 2.91182883e-02f, 9.66211408e-02f, -9.29909572e-02f, -6.24932110e-01f, 2.67251313e-01f, -1.39346495e-01f, 1.40954301e-01f,
  2.14708701e-01f, -2.36755952e-01f, -4.46573040e-03f, 7.98771903e-02f, 9.82067138e-02f, 3.73904526e-01f, 3.12271208e-01f, -1.52433261e-01f, 2.60384142e-01f, 1.26914755e-01f,
  -1.51812896e-01f, 8.96812230e-02f, -6.50108382e-02f, -5.48690744e-02f, -5.72235063e-02f, 2.04171285e-01f, 2.71726340e-01f, -2.40025267e-01f, -9.01479423e-02f, 3.09643596e-01f,
  -8.24059844e-02f, 1.25118434e-01f, 1.03807256e-01f, -1.40772045e-01f, 1.13582060e-01f, -1.01493299e-01f, 1.29115492e-01f, -2.79462278e-01f, -2.35230587e-02f, 4.89869602e-02f,
  7.67446682e-02f, 1.78864330e-01f, 3.86769682e-01f, 5.62492087e-02f, -2.38885283e-02f, -1.06200255e-01f, -2.00267777e-01f, 1.80781214e-03f, 4.79994565e-02f, 1.27259746e-01f,
  -1.16957977e-01f, -1.10926190e-02f, -6.02438264e-02f, -6.17425032e-02f, 5.33328317e-02f, 1.51746690e-01f, -8.51556882e-02f, 2.61927783e-01f, 6.23620627e-03f, -2.44447216e-01f,
  2.48512672e-03f, 2.12488875e-01f, -1.83407173e-01f, -2.07887486e-01f, -1.00314952e-01f, -1.08795702e-01f, 3.56720202e-02f, -1.76273867e-01f, -9.77926888e-03f, -2.06001490e-01f,
  1.13977008e-01f, -1.01592191e-01f, -2.29453921e-01f, -1.01568080e-01f, 2.18306668e-02f, 4.92694452e-02f, 3.08586862e-02f, 2.86463052e-01f, 3.04996707e-02f, 1.70823693e-01f,
  2.16440797e-01f, 1.75362438e-01f, -1.81834251e-01f, -1.88144118e-01f, 2.63549298e-01f, 7.57925436e-02f, 1.26469731e-02f, 3.43572721e-02f, -1.56619728e-01f, 2.76169688e-01f,
  5.74559458e-02f, 1.33831948e-01f, -6.39684349e-02f, -6.68130349e-03f, 9.71501842e-02f, -8.62890631e-02f, 2.18322754e-01f, -1.44999877e-01f, 2.87568104e-03f, -4.25967686e-02f,
  -1.56703308e-01f, -2.67032206e-01f, -8.34877864e-02f, -4.03482765e-02f, -7.71059170e-02f, -3.35952163e-01f, 1.32634297e-01f, -2.71653354e-01f, -8.01799595e-02f, 1.37196705e-01f,
  1.39174610e-01f, 9.72315371e-02f, 2.89607849e-02f, 9.65077505e-02f, 8.93815458e-02f, 1.24428697e-01f, 8.19717571e-02f, -7.40205124e-02f, 1.76853955e-01f, 1.44186303e-01f,
  4.96531315e-02f, 2.36596882e-01f, 1.93085689e-02f, -1.86155036e-01f, -2.78817475e-01f, -4.36881781e-01f, 3.25513214e-01f, -2.24949658e-01f, -2.53421813e-01f, 3.03706914e-01f,
  5.65027714e-01f, -6.04925193e-02f, 5.63533187e-01f, -4.56922650e-01f, 1.76751032e-01f, 3.67054254e-01f, 1.75273180e-01f, -1.96002930e-01f, 3.18734258e-01f, 2.99906135e-01f,
  -1.01779170e-01f, -1.98816821e-01f, 4.40709680e-01f, -3.15729618e-01f, -1.54291540e-01f, -1.78725675e-01f, -1.26826286e-01f, -1.09527767e-01f, 7.02098757e-02f, -2.08483301e-02f,
  -1.43479541e-01f, -1.93662867e-01f, 1.02206664e-02f, -1.86156318e-01f, -4.39800285e-02f, -1.76110879e-01f, -7.05235153e-02f, -2.49888431e-02f, 3.37369442e-02f, -7.41741359e-02f,
  1.82265732e-02f, -4.06051390e-02f, -1.25960648e-01f, -4.36759740e-02f, 7.53124207e-02f, -5.23768179e-02f, -6.39939681e-02f, 7.26467371e-02f, -4.54314910e-02f, -1.10477172e-01f,
  -8.52805823e-02f, -3.42232212e-02f, 1.51823848e-01f, 8.09221342e-02f, -7.94339254e-02f, -1.19754784e-01f, 2.92149577e-02f, 2.25722305e-02f, -1.55720204e-01f, 5.07776663e-02f,
  6.46993443e-02f, 7.80784935e-02f, 2.20599532e-01f, -1.20841354e-01f, -7.30896890e-02f, -4.65716459e-02f, 2.39766061e-01f, 2.05770090e-01f, 3.20364162e-03f, 3.58179286e-02f,
  3.29131544e-01f, 1.09127343e-01f, 4.41142991e-02f, -1.27640665e-01f, -2.59532273e-01f, -1.41371295e-01f, -1.50193200e-01f, 2.24815980e-01f, 1.13887876e-01f, 2.12448850e-01f,
  1.11464567e-01f, -9.54585373e-02f, -2.32150570e-01f, 1.83804855e-01f, 2.37348080e-02f, 3.86183560e-02f, 1.00422777e-01f, -1.58121601e-01f, -3.03923730e-02f, -1.56801835e-01f,
  6.53871521e-02f, -7.42505863e-03f, -1.98046520e-01f, -1.01313792e-01f, 2.54955977e-01f, -1.53239325e-01f, 1.10231182e-02f, -1.25977173e-01f, 2.34168246e-02f, -2.74592265e-02f,
  -9.89767835e-02f, 2.27573738e-01f, 1.33894086e-01f, 5.04058242e-01f, -7.87815005e-02f, -2.00223625e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.99171242e-02f, 9.36909318e-02f, 5.79158142e-02f, 4.09768559e-02f, 4.32273634e-02f, 1.20326534e-01f, -3.54200490e-02f, -5.83491884e-02f, 4.97944616e-02f, -2.30417829e-02f,
  -1.32616952e-01f, 9.51688066e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    