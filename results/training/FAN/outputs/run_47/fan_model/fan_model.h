/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.25124344e-01f, 6.47708923e-02f, 5.14513403e-02f, -2.28114128e-01f, 1.73554391e-01f, 1.28182443e-02f, -1.97344676e-01f, 1.58945039e-01f, -5.45936190e-02f, -7.41269514e-02f,
  -2.24690601e-01f, 5.20052128e-02f, -1.03975594e-01f, -2.19140798e-01f, -4.25779969e-01f, -1.41930923e-01f, -4.14716423e-01f, -1.73954532e-01f, 5.40242232e-02f, -3.64333838e-02f,
  -5.93054593e-02f, -1.88598752e-01f, -1.22836523e-01f, 1.54951960e-01f, 5.52147068e-02f, 1.98021993e-01f, -1.60689905e-01f, 1.94861263e-01f, -3.00591104e-02f, 3.60348299e-02f,
  -1.58129081e-01f, 3.63217629e-02f, 1.78864487e-02f, 8.94574001e-02f, -5.18718027e-02f, 1.20683676e-02f, 8.72788113e-03f, -9.52162035e-03f, -2.48900540e-02f, -3.86560746e-02f,
  -3.49916983e-03f, 1.07833352e-02f, 2.70911511e-02f, 4.82663959e-02f, 4.90530021e-02f, 1.53919756e-02f, 6.98270053e-02f, 3.65210883e-02f, 9.02199969e-02f, 4.33436874e-03f,
  6.09165505e-02f, -3.20590474e-02f, -7.28166988e-03f, -3.57045420e-02f, 1.40548646e-02f, 3.64906591e-04f, -2.56729182e-02f, 7.33790128e-03f, 1.63196977e-02f, -4.78247888e-02f,
  -1.94227807e-02f, 1.11977253e-02f, -5.40054515e-02f, 1.04794372e-02f, -2.99432110e-02f, -1.87849347e-02f, -4.76971343e-02f, -2.78422460e-02f, -7.88131170e-03f, -2.39895862e-02f,
  -3.44665237e-02f, 1.40693495e-02f, 3.19077284e-03f, 4.83249240e-02f, -5.52402586e-02f, 9.34098847e-03f, -2.37105116e-02f, 9.12461989e-03f, -4.39809449e-02f, -1.02473218e-02f,
  -5.62060364e-02f, 3.30723003e-02f, -1.61469094e-02f, -4.90059964e-02f, 1.34355025e-02f, 6.64045736e-02f, -7.49993743e-03f, 4.34378460e-02f, -5.53344004e-03f, -5.85297830e-02f,
  -5.29851466e-02f, -3.32276598e-02f, 5.51926531e-02f, -1.69513025e-03f, -1.61973797e-02f, -4.19201255e-02f, -1.82670839e-02f, 4.67915572e-02f, 2.97477879e-02f, -5.13030104e-02f,
  4.02370840e-02f, 1.60659873e-03f, -2.74822228e-02f, -4.27263491e-02f, -6.05183318e-02f, -6.07943535e-02f, -5.40655069e-02f, -2.91795861e-02f, -7.53712878e-02f, -2.13347524e-02f,
  2.09736563e-02f, 5.33204973e-02f, 2.23019905e-02f, 2.25998089e-02f, -4.76867631e-02f, -3.30570899e-02f, 3.77099328e-02f, 5.12622893e-02f, 8.16942286e-03f, -3.39969620e-02f,
  -5.26299104e-02f, 2.43152350e-01f, 6.00703852e-03f, -3.68900180e-01f, -2.78495066e-02f, 2.81601399e-01f, -3.05822402e-01f, 3.82179692e-02f, 8.42421278e-02f, 1.37804285e-01f,
  -1.86681017e-01f, -3.44205461e-02f, -6.89380094e-02f, -8.15155581e-02f, -6.76508620e-02f, 7.07087740e-02f, 1.30593807e-01f, 7.03056976e-02f, 9.36987922e-02f, 2.50000264e-02f,
  1.18105439e-02f, -2.29475200e-02f, -1.31427646e-01f, -9.48982371e-04f, -1.50339052e-01f, -1.21100746e-01f, -2.43331239e-01f, -1.36561871e-01f, -6.04808405e-02f, 4.65485118e-02f,
  -5.68761230e-02f, -1.12936638e-01f, -5.11844866e-02f, 2.92695444e-02f, 3.77530456e-02f, -5.08969324e-03f, 5.16607054e-02f, -8.56114179e-02f, -3.05010434e-02f, 5.18478639e-02f,
  1.78802200e-02f, -5.68297282e-02f, -2.13895142e-02f, 2.87265573e-02f, 1.26411989e-01f, -4.74775247e-02f, 1.66469868e-02f, -5.13820387e-02f, 1.49456821e-02f, -3.51868793e-02f,
  7.67168701e-02f, 5.83130196e-02f, -1.80271559e-03f, 2.72012595e-02f, -4.50815707e-02f, -3.61412689e-02f, 5.78900706e-03f, 4.62191086e-03f, 4.93014418e-02f, 7.26742670e-02f,
  3.87372114e-02f, 1.28791565e-02f, 1.40496409e-02f, -8.59387293e-02f, 7.56135359e-02f, -4.96427454e-02f, -2.22996878e-03f, -3.18149738e-02f, -3.29867192e-02f, -5.47791868e-02f,
  -5.39021902e-02f, 4.86423708e-02f, 2.36150734e-02f, -4.80497908e-03f, -7.16392696e-03f, -1.91748664e-02f, -3.78828496e-02f, 1.19031984e-02f, 3.89232300e-03f, -3.24713364e-02f,
  2.18315087e-02f, -6.80062314e-03f, 1.69758461e-02f, -3.72338668e-02f, -1.45703321e-02f, -9.96169075e-03f, -3.33208703e-02f, 3.75023894e-02f, -1.47360256e-02f, 1.46054719e-02f,
  2.50694394e-01f, 3.46842259e-01f, -5.96495792e-02f, -6.97913244e-02f, 6.24707155e-02f, 8.41425136e-02f, -5.50812343e-04f, 8.02788138e-02f, 9.73548889e-02f, -7.99081177e-02f,
  1.37967104e-02f, -3.99291962e-02f, 3.50072086e-02f, -5.92942797e-02f, -3.54257599e-02f, 9.15511400e-02f, -8.24224204e-02f, 4.04729657e-02f, -1.53043289e-02f, -8.63806345e-03f,
  -5.75955249e-02f, -2.46945154e-02f, -4.57881279e-02f, -1.09229833e-02f, 4.90703993e-02f, -9.68784746e-03f, -5.60107594e-03f, -1.95081241e-03f, 2.50660907e-02f, -2.74181925e-02f,
  -9.32476640e-01f, 1.98902503e-01f, -2.18598589e-01f, -2.79107660e-01f, -1.53094083e-01f, 1.14214383e-01f, -1.61217079e-01f, -7.43649229e-02f, -2.94367582e-01f, 2.17913911e-01f,
  -1.10405758e-01f, -6.25946820e-02f, -4.68810759e-02f, 1.06224818e-02f, -2.01368123e-01f, 1.62939712e-01f, -9.73356143e-02f, -1.34940799e-02f, 8.43284950e-02f, -1.04215346e-01f,
  -1.18741408e-01f, 3.12340558e-02f, -1.19685814e-01f, 1.88261986e-01f, -2.07491606e-01f, -6.23923466e-02f, -5.54460734e-02f, -5.27988933e-03f, 2.16469690e-02f, 8.66749883e-02f,
  -1.00547578e-02f, -3.87872681e-02f, 7.20826443e-03f, -2.25348826e-02f, -5.33390194e-02f, -5.14180139e-02f, -4.28908318e-02f, 7.17513338e-02f, -5.50621897e-02f, 3.18654589e-02f,
  -1.60595812e-02f, -1.28223849e-02f, -2.27953633e-03f, 1.93082709e-02f, -3.57754119e-02f, -2.79932693e-02f, -3.11189122e-03f, -2.31687771e-03f, -2.78793052e-02f, -4.47601639e-02f,
  5.10076880e-02f, -3.82723995e-02f, -5.02303466e-02f, -1.93198323e-02f, -2.31891107e-02f, 4.06262539e-02f, 3.27769294e-03f, -9.88834258e-03f, 7.14558084e-03f, 8.28961655e-03f,
  1.16891635e-03f, -7.46984333e-02f, 2.27798689e-02f, -4.56709526e-02f, 6.34322166e-02f, -3.70125212e-02f, 4.53402698e-02f, -1.75180994e-02f, -4.70677838e-02f, -1.49137983e-02f,
  -1.50483765e-03f, -1.98001880e-02f, -2.36329027e-02f, -5.56147136e-02f, 1.49822524e-02f, -2.30032094e-02f, -2.05396232e-03f, 3.01964791e-03f, -7.66317695e-02f, 7.46590924e-03f,
  1.12330392e-02f, -9.25905164e-03f, 3.43589969e-02f, -2.22279057e-02f, 5.14386222e-03f, -4.99674678e-02f, -3.33021879e-02f, 2.64709350e-02f, 2.98286974e-03f, -4.68504354e-02f,
  -5.70773631e-02f, -1.50425941e-01f, 1.64710861e-02f, -4.28651506e-03f, 5.07656112e-02f, 6.66500255e-02f, 2.06150096e-02f, -4.76737693e-02f, 5.62952310e-02f, -9.06086266e-02f,
  3.87093332e-03f, -2.25000363e-02f, -2.93730944e-02f, 2.01601274e-02f, 6.92076385e-02f, 1.12611493e-02f, -8.38519447e-03f, -2.82385666e-02f, -1.99275650e-02f, -1.38495825e-02f,
  -5.92120253e-02f, 4.21187580e-02f, 2.40690894e-02f, 1.09648462e-02f, -5.43446746e-03f, 2.46368907e-03f, -2.67453082e-02f, -2.56413221e-02f, 5.63584594e-03f, -1.93104837e-02f,
  -1.77788928e-01f, -3.16141769e-02f, -3.13015610e-01f, -3.21914762e-01f, 3.54236178e-02f, 2.19411775e-01f, 1.13413788e-01f, -4.24645394e-02f, -3.89873385e-01f, 1.78303242e-01f,
  1.11246176e-01f, -1.58444688e-01f, -1.34371698e-01f, 1.80783689e-01f, -2.58762687e-01f, -3.06716323e-01f, 1.83768079e-01f, 1.35571092e-01f, -1.46904349e-01f, 1.94686148e-02f,
  -1.03808634e-01f, 6.54167831e-02f, -1.55289829e-01f, 3.41929793e-02f, 9.15655196e-02f, 2.45046392e-02f, 7.04484358e-02f, -1.36527732e-01f, 2.77952135e-01f, 2.12615682e-03f,
  1.35645226e-01f, -1.12753041e-01f, 2.71000732e-02f, -1.98063869e-02f, 1.43340111e-01f, 8.31031576e-02f, -3.12810726e-02f, -8.22174326e-02f, 2.74174660e-02f, 7.58891404e-02f,
  6.66831061e-02f, -1.24731250e-01f, 6.83183596e-02f, -6.33132234e-02f, -2.92922575e-02f, 3.60733494e-02f, 1.06577672e-01f, 7.16991201e-02f, -4.59621251e-02f, 9.30469949e-03f,
  4.84986380e-02f, 5.89969532e-05f, 4.20679934e-02f, -5.34414537e-02f, -2.96617616e-02f, 5.59681766e-02f, -1.06001176e-01f, 2.38668872e-04f, 1.02980591e-01f, 7.95927793e-02f,
  -4.72405180e-02f, -2.32404079e-02f, -2.87850630e-02f, 2.09925082e-02f, 4.35963869e-02f, 3.47298384e-02f, 2.50815377e-02f, 3.72874439e-02f, 4.90582436e-02f, -3.73184425e-03f,
  1.19444691e-01f, 1.55408094e-02f, 7.37560466e-02f, 6.71006292e-02f, -5.41446507e-02f, 2.02533472e-02f, 6.25925213e-02f, 1.08015493e-01f, 3.95852327e-03f, 8.69684070e-02f,
  -1.61054075e-01f, -4.06514294e-02f, 3.70903127e-02f, 4.20153849e-02f, -2.26359107e-02f, -7.94546381e-02f, -7.35280886e-02f, -9.18532163e-02f, 5.76891005e-02f, 1.58218648e-02f,
  2.41673917e-01f, -1.65428311e-01f, 1.17345728e-01f, 3.44997309e-02f, 1.74135584e-02f, 1.82535015e-02f, -2.73898244e-02f, 3.99539806e-02f, -6.03449233e-02f, -4.01888341e-02f,
  7.00995177e-02f, 1.11671753e-01f, 3.78711261e-02f, -7.93966092e-03f, -8.87812525e-02f, -3.14805098e-02f, -5.45609817e-02f, 1.58753153e-02f, 1.58294573e-01f, -5.73889073e-03f,
  1.01483881e-01f, -2.26540640e-02f, 9.79811326e-02f, 5.90230860e-02f, 6.86545819e-02f, 4.66191880e-02f, 2.88827009e-02f, -8.85077938e-03f, 6.49861619e-02f, -8.65680650e-02f,
  3.54181260e-01f, -1.68084249e-01f, 1.37997001e-01f, -1.51730120e-01f, 1.50699601e-01f, 2.86448151e-01f, 2.82568187e-01f, -1.36171058e-01f, 1.05327792e-01f, -1.28611341e-01f,
  -8.22904333e-02f, 1.16604716e-01f, -1.04305577e-02f, -1.40819460e-01f, 1.73322618e-01f, -6.05944209e-02f, 7.27365725e-03f, 3.56392399e-03f, 1.47275731e-01f, -1.02213383e-01f,
  1.48970028e-02f, -1.23097569e-01f, 4.99474853e-02f, -1.32963270e-01f, -8.32931027e-02f, -4.67267931e-02f, -2.19522759e-01f, 5.91057241e-02f, -1.57392666e-01f, 7.53699020e-02f,
  9.52628031e-02f, -6.54256865e-02f, -2.71294378e-02f, -5.82671948e-02f, -2.62293848e-03f, 1.10863158e-02f, -1.85281355e-02f, 4.16056439e-02f, 5.10649979e-02f, 5.08520170e-04f,
  3.01380232e-02f, 1.53588513e-02f, -1.73216015e-02f, -1.36284260e-02f, 7.80506581e-02f, -9.48101003e-03f, 4.70653586e-02f, 6.82374761e-02f, 3.72709371e-02f, 1.20313177e-02f,
  2.02111322e-02f, -2.70529464e-02f, 4.31413203e-02f, -1.61572266e-02f, 1.83188561e-02f, 4.27601263e-02f, 9.91384033e-03f, 2.31146403e-02f, 6.84428168e-03f, 2.35098153e-02f,
  -5.96910082e-02f, 3.91661189e-02f, -5.03407307e-02f, 1.45155843e-02f, 2.11959053e-03f, -1.22347372e-02f, 2.36197840e-02f, -4.25474532e-03f, 9.78245214e-03f, -1.60766561e-02f,
  -1.64167378e-02f, 3.41159478e-02f, -3.33393295e-03f, 2.75739748e-03f, -2.80343071e-02f, -4.01678160e-02f, 5.06152324e-02f, -2.00132485e-02f, -1.93570890e-02f, -1.27661787e-02f,
  -7.98977092e-02f, 4.42713089e-02f, -8.36304948e-03f, 8.07831530e-03f, 7.46065890e-03f, 1.27244359e-02f, -7.70364106e-02f, -7.17844116e-03f, 5.53742535e-02f, -1.44373141e-02f,
  -4.15011682e-02f, -2.13098124e-01f, -1.53501192e-03f, 4.05793749e-02f, -3.95077690e-02f, 5.34966541e-03f, 2.10586525e-02f, -6.51321709e-02f, -3.04462686e-02f, -4.35280725e-02f,
  -3.11964434e-02f, -2.77294330e-02f, 5.56868501e-02f, 2.28538569e-02f, -3.44820730e-02f, -1.77125763e-02f, -1.46664912e-02f, -1.55090624e-02f, -8.22478458e-02f, -1.22217303e-02f,
  -4.83579710e-02f, 2.27185804e-02f, 2.01956537e-02f, -6.79367483e-02f, -5.53899817e-02f, -3.93027030e-02f, 4.88152541e-03f, 5.70350401e-02f, -2.31560152e-02f, -3.96306701e-02f,
  3.75878602e-01f, 3.00665259e-01f, 5.24880707e-01f, 2.18427449e-01f, 1.59488067e-01f, -3.96887869e-01f, -1.01684526e-01f, 1.74619824e-01f, 5.50687127e-02f, -1.68504640e-01f,
  -8.85589421e-02f, 6.62073269e-02f, -4.84384457e-03f, -8.76350701e-02f, 9.83693674e-02f, 3.00113065e-03f, 2.66796984e-02f, 3.51438746e-02f, 1.57928411e-02f, 2.10494325e-01f,
  2.86605477e-01f, -8.52854252e-02f, 3.65312576e-01f, 3.30481082e-02f, 1.95677221e-01f, 8.52864087e-02f, 8.79219547e-02f, -5.14435917e-02f, -7.84762353e-02f, -1.83899805e-01f,
  -1.32452250e-01f, -2.49443594e-02f, 1.47539318e-01f, 6.00591935e-02f, 4.22822637e-03f, -6.33451790e-02f, -8.32172111e-02f, -7.30136633e-02f, 1.04324088e-01f, 4.03601825e-02f,
  -3.42347436e-02f, -1.29857361e-01f, 1.99840423e-02f, -5.76851666e-02f, 5.56284469e-03f, 4.07084934e-02f, 8.56107697e-02f, -1.91766080e-02f, -5.61131397e-03f, 2.67574210e-02f,
  5.43118268e-02f, -1.61751416e-02f, -2.29379460e-02f, -1.28535544e-02f, 6.30306173e-03f, -8.82656351e-02f, -3.89835611e-02f, -4.43828031e-02f, 4.14985791e-02f, 1.97695512e-02f,
  -7.46379271e-02f, 2.19183080e-02f, 2.12212544e-04f, 2.33325772e-02f, 1.36918284e-03f, -1.41896429e-02f, 5.47748851e-03f, 1.58524700e-02f, 1.85662229e-02f, 2.28791963e-03f,
  -9.60161071e-03f, 5.13448045e-02f, -7.36155361e-02f, -5.33174025e-03f, 6.25270931e-03f, -5.07000051e-02f, 3.17924693e-02f, -2.98998225e-02f, 9.62551534e-02f, 3.64643298e-02f,
  5.02455933e-03f, -1.06389910e-01f, 5.83172254e-02f, 9.56169795e-03f, -5.54507934e-02f, 1.66009758e-02f, -2.43346281e-02f, -8.29487108e-03f, 1.90718733e-02f, 5.70218526e-02f,
  -5.37972786e-02f, 1.24906274e-02f, -8.49418063e-03f, -5.49737513e-02f, 7.41728954e-03f, -2.84885187e-02f, 1.59514751e-02f, -5.27785392e-03f, -5.55919893e-02f, -2.38693729e-02f,
  7.57395849e-02f, 7.29119703e-02f, -5.91245331e-02f, -6.43820316e-02f, 6.08299710e-02f, -3.62090915e-02f, -2.94328108e-02f, 6.56725280e-03f, 1.32111937e-01f, -3.06464601e-02f,
  8.20780545e-03f, -1.51992647e-03f, 6.86174557e-02f, 8.85345638e-02f, 3.91429998e-02f, 3.03836670e-02f, 2.22617220e-02f, -2.18796544e-02f, 2.55749784e-02f, 1.73393320e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.17566216e-01f, 9.86002684e-02f, 1.63073279e-02f, 1.88510641e-01f, -3.48785728e-01f, -2.04019532e-01f, -3.50180656e-01f, -1.08475700e-01f, 1.06449239e-01f, 9.91518516e-03f,
  -3.65183026e-01f, 5.85002065e-01f, -3.02395195e-01f, 1.09504133e-01f, -3.13901097e-01f, -9.98042673e-02f, -2.28433296e-01f, -7.44532561e-03f, 4.15364280e-03f, -2.17925206e-01f,
  -9.79761407e-02f, -3.82913500e-01f, -1.61669493e-01f, -3.51607472e-01f, 8.09898693e-03f, 1.17943026e-01f, -1.83568731e-01f, -1.78133562e-01f, 2.06314195e-02f, 8.20625108e-03f,
  5.76852113e-02f, 2.56732088e-02f, 1.90210175e-02f, 2.77866442e-02f, -1.86279163e-01f, -5.02609536e-02f, -1.50212292e-02f, 3.94374840e-02f, -5.22743426e-02f, 6.29634187e-02f,
  4.48320881e-02f, 2.38657948e-02f, 5.27524389e-04f, -2.30903681e-02f, 3.41421254e-02f, 6.89957216e-02f, 4.92462702e-02f, 7.85627440e-02f, 5.83770052e-02f, 4.00897749e-02f,
  8.85771215e-02f, 1.24913096e-01f, -5.70576265e-03f, 2.27097645e-02f, 5.23826368e-02f, 8.10071360e-04f, 4.24850658e-02f, -1.80196203e-02f, 1.37320133e-02f, 1.22536518e-01f,
  -7.55817816e-02f, -1.70493677e-01f, -1.05406661e-02f, 8.38751867e-02f, -2.06007604e-02f, -5.85287027e-02f, 1.92086194e-02f, -1.03901938e-01f, 4.45755720e-02f, -1.31745934e-02f,
  -1.01962583e-02f, 8.14393908e-02f, 7.92862754e-03f, -5.57362325e-02f, -3.01527251e-02f, 7.60514662e-02f, 5.46071269e-02f, -1.58170667e-02f, 1.52358925e-02f, -5.46189994e-02f,
  -7.95611218e-02f, -4.41526435e-02f, 7.90635776e-03f, 5.46602197e-02f, -1.80608630e-02f, -3.73224355e-03f, -8.79411818e-04f, 2.88030822e-02f, 5.23184836e-02f, -1.88505769e-01f,
  -1.93533510e-01f, -3.58718097e-01f, -5.01329713e-02f, 2.11466178e-02f, 5.54282637e-03f, 5.63373752e-02f, -1.19964946e-02f, -5.43814488e-02f, -1.22497946e-01f, -3.99132520e-02f,
  -8.69415626e-02f, -4.68306467e-02f, 4.13617343e-02f, 4.56185127e-03f, -1.10575566e-02f, -7.12899566e-02f, -5.27080894e-02f, -8.07431061e-03f, -1.45231232e-01f, 1.61011256e-02f,
  -3.08232605e-02f, 1.90804023e-02f, -8.57338309e-04f, 1.88395628e-04f, -5.87525479e-02f, 2.57332884e-02f, 3.22487280e-02f, 1.00778334e-01f, -3.91797423e-02f, -2.57669371e-02f,
  1.32504046e-01f, -5.19084156e-01f, -4.09116030e-01f, 8.25216994e-02f, 1.34214312e-01f, 9.94965062e-02f, -3.62389714e-01f, -4.33498658e-02f, -3.60918581e-01f, -3.02875657e-02f,
  -2.83766724e-02f, -5.27780177e-03f, -4.93861884e-01f, 2.33598620e-01f, 1.95960462e-01f, -3.24797988e-01f, 1.71060011e-01f, -9.49264020e-02f, -1.76713422e-01f, -1.21794427e-02f,
  -3.39064673e-02f, 3.09576750e-01f, -1.80198357e-01f, 2.97831714e-01f, -1.82726309e-02f, -2.88929138e-03f, 1.45280480e-01f, -6.30091652e-02f, 4.69374776e-01f, 2.09607393e-01f,
  1.69907168e-01f, -1.31155819e-01f, -6.24760017e-02f, 2.70404611e-02f, -7.49504045e-02f, 6.90676868e-02f, 8.84596407e-02f, 1.34651661e-01f, 3.46860178e-02f, -1.28193930e-01f,
  -5.98326065e-02f, 5.05121499e-02f, 8.32450017e-02f, -1.32363429e-02f, 5.89306094e-02f, -2.78729293e-02f, -1.85938794e-02f, -5.53226061e-02f, -6.38124049e-02f, 2.12263758e-03f,
  -9.11593512e-02f, -7.70376101e-02f, -5.76680563e-02f, -1.31854098e-02f, -9.26857144e-02f, -3.92427705e-02f, -1.70572530e-02f, -6.30264431e-02f, 1.22096837e-02f, 6.42654374e-02f,
  -1.14838928e-02f, -2.94472426e-02f, -3.82006839e-02f, 8.07856694e-02f, -3.76654081e-02f, 3.28308791e-02f, 1.08819443e-03f, 4.57648672e-02f, -1.18979692e-01f, 1.55984564e-02f,
  -1.53032830e-02f, 2.72179078e-02f, -2.07090583e-02f, 4.25147898e-02f, 7.96587244e-02f, -4.49956954e-03f, -3.06753144e-02f, -1.80779658e-02f, -8.79312977e-02f, -2.83420365e-02f,
  5.30825043e-03f, 2.44900305e-02f, -1.39711769e-02f, -1.30206430e-02f, 1.78189501e-02f, -3.26726288e-02f, 6.05622642e-02f, -2.13208683e-02f, -2.74543222e-02f, -6.84276447e-02f,
  -1.11593507e-01f, -1.90466672e-01f, -4.39549722e-02f, 6.88084215e-02f, 6.82092179e-03f, 6.24815226e-02f, -4.74151224e-02f, -1.02294981e-02f, -1.04835881e-02f, -1.06406240e-02f,
  1.08197287e-01f, 3.78741999e-03f, -7.33364141e-03f, 1.00145414e-01f, 4.22712341e-02f, 6.68976968e-03f, 4.79128025e-02f, 9.23331454e-02f, -3.23931091e-02f, 3.30991298e-02f,
  2.68519614e-02f, 2.70223971e-02f, -3.75001989e-02f, -1.72870550e-02f, 7.74717554e-02f, -7.73400441e-02f, -2.95833740e-02f, 5.15194722e-02f, 5.63796386e-02f, -9.77405831e-02f,
  -1.73033595e-01f, 4.95128408e-02f, -2.22141501e-02f, -2.95539320e-01f, -7.46523589e-02f, -3.31811965e-01f, -1.40285879e-01f, -1.67580023e-02f, -1.82769150e-01f, 1.06560498e-01f,
  -1.80515155e-01f, 1.03877172e-01f, -1.40697472e-02f, -4.17994201e-01f, -7.23553956e-01f, -2.82323033e-01f, -3.51626843e-01f, -1.29714698e-01f, -2.10476413e-01f, 9.12829116e-02f,
  -1.53349727e-01f, -2.54706353e-01f, -1.18020423e-01f, 1.98989641e-02f, 2.13384584e-01f, 2.73685902e-01f, 2.11225688e-01f, 1.08093910e-01f, 1.31500915e-01f, -1.07377835e-01f,
  -1.31147653e-01f, 1.15430906e-01f, 9.55115929e-02f, 6.46828189e-02f, -2.19232775e-02f, 6.38384521e-02f, 1.28739640e-01f, -6.64124191e-02f, -4.43598023e-03f, -3.53659280e-02f,
  7.98286796e-02f, -4.38751988e-02f, -1.20509818e-01f, 7.52127077e-03f, 8.30527917e-02f, 5.75125143e-02f, 1.16320252e-02f, -7.01816473e-03f, -3.19447108e-02f, -2.16185451e-02f,
  -5.27764112e-02f, -7.14043677e-02f, 3.34836021e-02f, -3.91033553e-02f, -7.69432113e-02f, 3.76814492e-02f, -3.86936925e-02f, 1.01754673e-01f, 3.43307108e-02f, 1.63573939e-02f,
  4.16429900e-02f, 6.71902075e-02f, -3.45052853e-02f, 5.45197651e-02f, -4.84929048e-02f, 6.72286972e-02f, -1.08647095e-02f, 3.07248794e-02f, 5.64792082e-02f, -7.75848851e-02f,
  -9.05625056e-03f, -7.70210102e-03f, -2.62043551e-02f, 5.43903783e-02f, -5.61525263e-02f, -6.02862565e-03f, -2.99037937e-02f, 3.89736146e-02f, -1.06305987e-01f, -5.70025817e-02f,
  -1.23638688e-02f, 4.49305139e-02f, 1.25514262e-03f, 3.67766134e-02f, -5.75155318e-02f, -1.01119503e-02f, 6.60367608e-02f, 4.44303788e-02f, 1.04215946e-02f, -2.74525099e-02f,
  -5.25605008e-02f, 1.51158884e-01f, -5.99990450e-02f, -2.01427639e-02f, 9.93505120e-02f, 2.87024155e-02f, -1.38073310e-01f, -2.01857090e-02f, 3.65283713e-02f, -1.85566470e-02f,
  5.56220077e-02f, 7.87636116e-02f, 9.45355818e-02f, -2.03964394e-02f, -4.86511365e-02f, -1.30099267e-01f, 3.70554030e-02f, 7.76014775e-02f, 2.56248638e-02f, -6.57664659e-03f,
  1.24011122e-01f, 4.06651152e-03f, -5.77327833e-02f, 2.82702874e-03f, 3.36091481e-02f, 2.11621206e-02f, 1.04174893e-02f, -6.80627972e-02f, 3.45222726e-02f, -1.78385302e-02f,
  3.57121050e-01f, -4.60338444e-01f, -1.64136916e-01f, -4.22890961e-01f, -2.12672383e-01f, -2.32390210e-01f, 3.91872153e-02f, -3.80302191e-01f, -2.11360365e-01f, -2.61787593e-01f,
  -7.68909510e-03f, 2.34335348e-01f, 2.24075675e-01f, -5.38417637e-01f, 7.87516177e-01f, 1.10451080e-01f, -3.29184890e-01f, -4.44378965e-02f, -1.40774161e-01f, -2.84131646e-01f,
  -1.10741965e-01f, -2.70541310e-01f, -1.93790998e-02f, -3.15930277e-01f, -2.92545021e-01f, -1.21686973e-01f, 1.96790040e-01f, -1.21402312e-02f, -1.35639548e-01f, 2.55992860e-02f,
  -4.47361358e-02f, -2.01128796e-01f, -2.95146592e-02f, 9.26124081e-02f, 8.34682137e-02f, 7.75597245e-02f, -2.65432289e-03f, 1.56526074e-01f, -5.65468892e-02f, -8.03496689e-03f,
  2.29950249e-02f, 2.87280511e-02f, -4.55330983e-02f, 6.39810637e-02f, -5.26985303e-02f, -2.25052591e-02f, -3.63720767e-02f, -4.10567522e-02f, -9.77678448e-02f, -3.55860777e-02f,
  -4.47060876e-02f, -8.13988745e-02f, -1.33989751e-01f, -3.12547684e-02f, -6.07756898e-03f, -1.18320540e-01f, -6.02002367e-02f, 3.35022621e-02f, -7.41363019e-02f, 1.51947588e-02f,
  -3.18061560e-02f, -3.07373814e-02f, 8.64358172e-02f, -5.37947193e-02f, -4.73008491e-02f, -4.63791452e-02f, 1.50333392e-02f, -3.61277983e-02f, 4.85684872e-02f, -6.26500323e-02f,
  1.87786222e-02f, -8.16951022e-02f, 3.63125280e-03f, -5.28369211e-02f, -1.85251713e-03f, 1.15964804e-02f, 7.19177425e-02f, -8.45185947e-03f, -7.44316056e-02f, 7.69484788e-02f,
  -3.68039720e-02f, 1.31699918e-02f, -9.79683995e-02f, -2.13889196e-03f, -5.99640571e-02f, -1.00090802e-02f, -7.06246793e-02f, 1.60488095e-02f, -1.85773838e-02f, -1.65660195e-02f,
  -1.03722468e-01f, 8.64852220e-02f, -3.60389948e-02f, -1.03946207e-02f, 3.57107334e-02f, -3.93457748e-02f, 1.10989448e-03f, -9.50680822e-02f, 1.49110993e-02f, -1.91307478e-02f,
  -5.10234293e-03f, 2.70345341e-02f, 5.01759462e-02f, -4.18182760e-02f, -1.86930317e-02f, -7.33616948e-02f, 5.54397181e-02f, 3.13840173e-02f, 2.16122959e-02f, -2.82105943e-03f,
  5.09338938e-02f, 1.21786386e-01f, 6.68421090e-02f, -2.25019213e-02f, -5.01623116e-02f, 2.10394621e-01f, 9.56969187e-02f, -2.72623729e-02f, 5.90052493e-02f, -2.23314688e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -2.52911560e-02f, -2.15008646e-01f, 1.70172438e-01f, 9.15272757e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.62074998e-01f, -1.13487773e-01f, 5.95092811e-02f, -7.10043460e-02f, 7.26654768e-01f, 4.02536541e-01f, 8.65282044e-02f, 6.20363414e-01f, 5.84549427e-01f, 1.37503222e-01f,
  -8.94049928e-02f, -2.78616875e-01f, 4.63008016e-01f, 2.36277968e-01f, 6.87796846e-02f, -1.59669235e-01f, 1.77705526e-01f, 3.30923676e-01f, -6.50250074e-03f, 3.14198597e-03f,
  -8.57692063e-02f, -1.68998435e-01f, -3.80875799e-03f, -3.04114342e-01f, -1.69555053e-01f, -3.24016646e-03f, -4.76599425e-01f, 2.23660678e-01f, 1.89880177e-01f, 1.76122412e-01f,
  4.57750529e-01f, -2.82110840e-01f, 1.70900762e-01f, -1.08016521e-01f, 5.99130154e-01f, -2.79650092e-01f, 2.08981708e-01f, 1.69773065e-02f, -3.54656905e-01f, 3.83917779e-01f,
  -2.14191213e-01f, 1.62362874e-01f, -2.30829492e-01f, -5.06652832e-01f, -1.96694642e-01f, 3.19461703e-01f, -4.61711772e-02f, 3.28416765e-01f, -1.36962861e-01f, -6.69024885e-02f,
  -1.85158834e-01f, 2.47506544e-01f, -1.83254421e-01f, -6.94160089e-02f, -3.94861817e-01f, -2.63236910e-01f, 2.65017539e-01f, -2.68474698e-01f, -1.02110561e-02f, -3.01300943e-01f,
  -4.04993117e-01f, 1.03080042e-01f, -2.43797660e-01f, -1.37438595e-01f, 1.54119268e-01f, -3.02240103e-01f, 3.83526206e-01f, -8.98804814e-02f, -2.81833351e-01f, -1.72930002e-01f,
  -4.98841643e-01f, -3.07658352e-02f, -6.10966563e-01f, -1.75958619e-01f, -2.31341243e-01f, 4.58804965e-02f, -1.82874173e-01f, 2.09499836e-01f, -1.47861749e-01f, 3.18686098e-01f,
  4.34418827e-01f, 7.86185544e-03f, 6.92144409e-02f, -2.94701345e-02f, -2.08485141e-01f, 2.93970585e-01f, 1.28077656e-01f, -5.58293648e-02f, -3.09947401e-01f, -1.42777666e-01f,
  7.95203388e-01f, 1.29759878e-01f, -1.68240815e-01f, -1.89361945e-01f, -1.44077003e-01f, 5.36174357e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.52615908e-02f, -2.35322043e-01f, 5.43327451e-01f, 9.77571383e-02f, 3.92786950e-01f, 5.38408637e-01f, -8.28184038e-02f, 3.86571065e-02f, -8.72837603e-02f, 4.15552944e-01f,
  6.20582774e-02f, -8.03580731e-02f, -3.43089700e-01f, 8.14671159e-01f, -1.84421167e-01f, 2.36417696e-01f, 6.14374757e-01f, -9.62098315e-02f, 2.94509917e-01f, 3.11988562e-01f,
  6.54677272e-01f, -1.83748640e-02f, 4.26158398e-01f, 5.71149409e-01f, -1.89574495e-01f, -3.03622514e-01f, 6.90871656e-01f, 4.48177040e-01f, 5.20532310e-01f, -5.09529829e-01f,
  -1.26876116e-01f, 4.01854455e-01f, 4.96721238e-01f, -1.06400184e-01f, 4.10076469e-01f, 2.93627352e-01f, 1.45536616e-01f, 4.72647905e-01f, 3.53353083e-01f, 4.68886286e-01f,
  4.64176713e-03f, -4.63807732e-01f, 2.92398274e-01f, 4.56727669e-02f, 3.19406204e-02f, -5.70285618e-01f, -4.20908362e-01f, 3.70645165e-01f, 2.25751981e-01f, 2.82231361e-01f,
  4.24269319e-01f, -3.72609168e-01f, 5.32963216e-01f, 1.63662180e-01f, 2.57345885e-01f, 7.28812039e-01f, 3.79235208e-01f, 4.59983319e-01f, -5.06224990e-01f, -3.61395061e-01f,
  -9.04130340e-02f, 2.12402359e-01f, 3.43934864e-01f, 4.89343405e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.61277905e-01f, 1.61337510e-01f, 1.01738267e-01f, 2.29875609e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.04984957e-01f, -3.55379820e-01f, -1.20295752e-02f, 7.80765772e-01f, -5.09563208e-01f, -3.04672629e-01f, -8.62430692e-01f, 2.89560258e-01f, -5.74038804e-01f, -5.63690603e-01f,
  6.75079644e-01f, 3.04992408e-01f, -5.58277369e-01f, -2.16452390e-01f, 1.97494909e-01f, -9.79070291e-02f, 1.48286968e-01f, -2.73097336e-01f, -1.74906492e-01f, -2.72243559e-01f,
  2.63847589e-01f, 3.72529209e-01f, 2.32926250e-01f, -8.87468383e-02f, 5.42269409e-01f, -1.37329161e-01f, -4.76829946e-01f, -9.32640061e-02f, 2.36895800e-01f, -3.19233328e-01f,
  -4.38021123e-01f, -2.33199507e-01f, 3.00144911e-01f, -1.64222643e-01f, -1.61021575e-01f, -8.61700416e-01f, -1.40974566e-01f, -2.96920955e-01f, 2.40487397e-01f, 4.37541604e-02f,
  -2.38378555e-01f, -1.16456479e-01f, -4.35371906e-01f, -1.16405040e-01f, -2.49146983e-01f, 1.01996191e-01f, -1.26926273e-01f, 4.50584322e-01f, 2.69271910e-01f, 6.88544691e-01f,
  -1.43541470e-02f, 8.05088639e-01f, -2.30704784e-01f, -5.17210245e-01f, -3.60958844e-01f, -4.42572951e-01f, 2.67165285e-02f, 1.27058864e-01f, 3.89052123e-01f, 1.84256688e-01f,
  -2.70703554e-01f, 1.05725691e-01f, 7.44258463e-02f, 8.52548331e-02f, 9.42287296e-02f, -1.90494195e-01f, -2.78606832e-01f, -1.72577098e-01f, 3.40167135e-02f, -3.11408967e-01f,
  -3.34721804e-02f, -5.43537140e-01f, 1.05644077e-01f, -2.54103631e-01f, 2.21676305e-01f, 5.26189804e-01f, 6.00040078e-01f, 3.33157927e-01f, 1.01364709e-01f, -7.13540763e-02f,
  -8.63665864e-02f, 4.48844045e-01f, 3.15570742e-01f, 4.80239570e-01f, 5.71887083e-02f, -1.54958025e-01f, -4.44628447e-01f, -4.46222693e-01f, 2.36588746e-01f, 7.78508857e-02f,
  5.20241499e-01f, 5.23805693e-02f, 4.44946110e-01f, -8.77763331e-02f, -5.14936401e-03f, -4.08153594e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.96321735e-02f, 5.11952877e-01f, 2.87531048e-01f, 3.75096500e-01f, 3.03214431e-01f, 5.01973391e-01f, 6.41037881e-01f, 5.49991369e-01f, 6.39955878e-01f, 4.62439597e-01f,
  -6.73054233e-02f, -7.97726095e-01f, 6.60184145e-01f, -1.03955007e+00f, -9.95946407e-01f, 6.64459825e-01f, -1.80893123e-01f, 1.08128354e-01f, -9.14341658e-02f, -2.50175953e-01f,
  3.14698040e-01f, 6.79235905e-02f, 4.20756221e-01f, -3.01893413e-01f, 9.37484026e-01f, 2.80031804e-02f, 6.30792618e-01f, 1.16983084e-02f, 7.59530246e-01f, 4.04950231e-01f,
  3.45449477e-01f, 4.09096479e-01f, 2.08459929e-01f, 6.58525050e-01f, 4.73312676e-01f, 8.08451772e-02f, 3.42439741e-01f, 1.37664124e-01f, 9.91201341e-01f, 1.80083305e-01f,
  -7.37349629e-01f, 1.26512080e-01f, -1.16982281e+00f, -1.79335009e-02f, -3.48161519e-01f, 6.66460395e-01f, 5.73958397e-01f, 5.13705432e-01f, 1.89224765e-01f, -6.42608618e-03f,
  -2.99031306e-02f, -2.94656992e-01f, 5.55866957e-01f, 6.36334538e-01f, 1.04736590e+00f, -5.39296269e-01f, 4.82956380e-01f, 1.99750558e-01f, -1.85455624e-02f, 7.65086338e-02f,
  2.00291593e-02f, 4.67337430e-01f, 4.67982650e-01f, 6.04697645e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.25545898e-01f, 1.71434153e-02f, 8.76824200e-01f, 1.60281733e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.80887812e-01f, 3.09378922e-01f, -6.60180151e-02f, 2.13537216e-02f, 4.35327172e-01f, 1.33895250e-02f, -2.81000901e-02f, -4.60439652e-01f, 3.09208065e-01f, 2.11785004e-01f,
  2.99005564e-02f, -2.59773940e-01f, -5.68577766e-01f, -1.45365030e-01f, 4.26149040e-01f, 3.44263464e-02f, 3.04789692e-01f, 5.12525737e-01f, 3.49686109e-02f, 6.31754398e-01f,
  4.02793944e-01f, 2.70501465e-01f, 3.84048492e-01f, -5.63008010e-01f, -3.92713159e-01f, 1.55098528e-01f, -3.99550289e-01f, 1.14390559e-01f, -1.71141952e-01f, -3.79538625e-01f,
  4.64168429e-01f, -7.92559385e-02f, 9.23389867e-02f, 2.23259509e-01f, -5.49349822e-02f, -7.37413168e-02f, 6.36086226e-01f, 2.90808856e-01f, -1.19451523e-01f, -3.28019828e-01f,
  7.50087053e-02f, 3.36886972e-01f, 1.48827404e-01f, 2.94263273e-01f, -4.61137950e-01f, 1.44516677e-02f, 2.61029691e-01f, 3.09035897e-01f, 1.06185272e-01f, 4.81433749e-01f,
  2.34079003e-01f, -1.50775358e-01f, 7.00853691e-02f, 2.63430744e-01f, 1.80512264e-01f, -1.84979752e-01f, -1.00060558e+00f, 5.41998446e-01f, 3.56057853e-01f, 8.41318607e-01f,
  -4.26658094e-02f, -5.07385060e-02f, -3.87910903e-02f, 1.41963571e-01f, 9.91942212e-02f, 1.87824324e-01f, 2.04932496e-01f, 2.03018531e-01f, -5.38070738e-01f, 3.83078992e-01f,
  2.95440733e-01f, -1.89564880e-02f, 2.00405046e-01f, -1.69322044e-01f, -6.97666645e-01f, 1.85607597e-01f, 2.52679914e-01f, -3.72506857e-01f, -3.41951102e-02f, -2.11517975e-01f,
  1.17632441e-01f, 2.34196872e-01f, -1.66485414e-01f, 1.07897237e-01f, 2.80467361e-01f, 1.79207176e-02f, 3.57286245e-01f, -4.22792643e-01f, -9.62614417e-01f, 6.82777047e-01f,
  3.01409125e-01f, 5.44753492e-01f, -3.62719923e-01f, 7.89599642e-02f, -8.53018761e-02f, 1.20947964e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  6.14999712e-01f, 8.48414719e-01f, 1.04455471e+00f, 1.02136493e+00f, 7.00539052e-01f, 1.78913987e+00f, 9.07969713e-01f, -1.06046522e+00f, -9.34419870e-01f, 1.45048559e+00f,
  -1.33692205e+00f, 1.21321177e+00f, 3.78046751e-01f, -4.08716828e-01f, 5.41175485e-01f, -4.54965457e-02f, -6.13546491e-01f, -5.74893914e-02f, 2.26415485e-01f, 8.26619029e-01f,
  5.72759032e-01f, 1.02373874e+00f, -1.54759157e+00f, 1.72741205e-01f, 1.13126850e+00f, 5.38159609e-01f, -1.12825632e-01f, -6.69795811e-01f, -9.14253853e-03f, 3.23596001e-01f,
  9.84103262e-01f, 8.88448715e-01f, 3.02603304e-01f, 8.40777934e-01f, 3.80489737e-01f, 1.07031748e-01f, 6.35111272e-01f, -9.37957466e-02f, -8.37932229e-01f, -1.17359988e-01f,
  1.11605620e+00f, -8.30778122e-01f, -9.98502195e-01f, -1.32707608e+00f, 4.11878169e-01f, -1.02297437e+00f, 1.19063008e+00f, -1.96453586e-01f, -1.73386312e+00f, 5.41411817e-01f,
  -9.32971854e-03f, 9.69843447e-01f, 6.98289931e-01f, 5.64279377e-01f, 1.62241608e-02f, 7.95499861e-01f, -9.83637571e-01f, -6.10630035e-01f, -6.92889631e-01f, 1.02038264e+00f,
  1.54066312e+00f, 4.93492931e-01f, -6.58488989e-01f, 4.39940989e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  7.84166694e-01f, -2.06079066e-01f, 3.00680310e-01f, 4.50721562e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.33943450e-01f, -6.40449449e-02f, 4.47223514e-01f, 4.67811644e-01f, 1.41346246e-01f, 2.96697557e-01f, -1.21238589e+00f, 5.76517165e-01f, 2.55917888e-02f, -3.97753306e-02f,
  1.17936277e+00f, -1.30955672e+00f, 3.17395210e-01f, -1.71510473e-01f, -1.93601344e-02f, 3.58473472e-02f, -1.04000950e+00f, 7.51677334e-01f, 9.27285194e-01f, 2.58946836e-01f,
  2.11353600e-01f, 6.75206721e-01f, -1.33108618e-02f, -1.35808134e+00f, -7.36352623e-01f, -2.96192139e-01f, -1.04529917e-01f, -7.63184428e-01f, 1.35970891e-01f, -5.13868779e-03f,
  -1.66312158e+00f, 4.34994578e-01f, 1.64077207e-01f, -8.14873517e-01f, -8.04381192e-01f, 2.70639807e-01f, 1.16800040e-01f, 7.79550755e-03f, -3.64803642e-01f, 4.12313119e-02f,
  -2.74571478e-01f, 4.00924295e-01f, -3.49049836e-01f, -5.42708218e-01f, -1.58250737e+00f, -9.47024584e-01f, -4.46825564e-01f, 8.06313217e-01f, 4.30571675e-01f, -5.95058203e-01f,
  1.06797695e+00f, 1.43297285e-01f, -9.55613777e-02f, -5.44802308e-01f, 1.05192471e+00f, 2.06291363e-01f, 1.53005168e-01f, -1.21252966e+00f, 1.46949148e+00f, -8.25471520e-01f,
  2.09814310e-01f, -3.29600453e-01f, 7.37890422e-01f, -1.26154542e+00f, -2.97836810e-01f, -6.33871078e-01f, -7.89444029e-01f, 9.18728948e-01f, -2.16552019e-02f, 1.14927530e+00f,
  -5.20259328e-02f, -5.92105389e-01f, 1.71516582e-01f, 1.09392667e+00f, -6.73357248e-01f, 4.49972272e-01f, 7.09333122e-02f, 4.30189371e-01f, 5.74478544e-02f, -8.62286627e-01f,
  -2.02475220e-01f, 6.79572463e-01f, -1.22269332e+00f, -1.15960777e+00f, -1.12788177e+00f, -1.10619235e+00f, 7.01993167e-01f, 1.11550689e+00f, -6.37059391e-01f, -2.67036576e-02f,
  2.05182806e-02f, 5.14892697e-01f, 1.50492899e-02f, 4.05929953e-01f, -1.19320905e+00f, -5.50043583e-02f, -3.69532824e-01f, -6.50587261e-01f, -8.36904109e-01f, -6.49780273e-01f,
  7.87583411e-01f, -6.02714121e-01f, 9.44294333e-01f, 6.21438563e-01f, 4.90826339e-01f, 1.55636445e-01f, -4.78490174e-01f, 3.24210286e-01f, 1.30941570e+00f, -1.13946950e+00f,
  -3.05093139e-01f, -1.44631267e+00f, -6.95758700e-01f, 4.11131412e-01f, -8.84255096e-02f, 3.06509256e-01f, -1.30824402e-01f, 5.58758259e-01f, -1.25397444e-01f, -1.29196227e-01f,
  -3.21501791e-01f, -1.35561550e+00f, 6.65740669e-01f, -1.23417892e-01f, -1.74643695e+00f, 9.47561562e-01f, -7.24023938e-01f, -5.43935359e-01f, 4.68907684e-01f, -5.53049922e-01f,
  7.56115973e-01f, 4.52589810e-01f, 1.89139098e-01f, 3.20146173e-01f, -6.59172118e-01f, 4.91689116e-01f, -1.04067288e-01f, 3.28752309e-01f, 1.23600042e+00f, 7.64809072e-01f,
  9.12152767e-01f, -1.70855296e+00f, -8.58992338e-01f, 3.41693699e-01f, 1.46519256e+00f, 1.05508435e+00f, 1.30551970e+00f, -2.09882155e-01f, -1.02850211e+00f, -1.08982718e+00f,
  -3.88899669e-02f, -1.28358090e+00f, 1.14959908e+00f, 1.34914327e+00f, -1.20945346e+00f, 1.46788561e+00f, -4.91247803e-01f, -8.47498119e-01f, -7.65119910e-01f, -7.20413744e-01f,
  2.22616225e-01f, 7.04185545e-01f, 2.89290905e-01f, -4.43377346e-01f, 4.95963573e-01f, -6.07874155e-01f, -5.59828937e-01f, 9.23774987e-02f, -7.03489482e-01f, -7.80873060e-01f,
  2.97594398e-01f, 3.11254829e-01f, -1.44530737e+00f, 4.00128178e-02f, 5.49121618e-01f, 3.62860054e-01f, -8.03283453e-01f, -2.95729995e-01f, -9.65446174e-01f, -3.76553833e-02f,
  -1.74771577e-01f, 4.60185446e-02f, -5.63758016e-01f, -8.12386423e-02f, 3.42646718e-01f, -9.38335776e-01f, -9.83009577e-01f, -9.76893127e-01f, -1.42427826e+00f, 2.57167727e-01f,
  8.38826120e-01f, -1.03819299e+00f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.15198988e-01f, -1.86322048e-01f, 2.06006736e-01f, 1.85322270e-01f, -5.85332513e-02f, 1.28528118e-01f, 3.73046726e-01f, -3.82800460e-01f, -3.36752534e-01f, 1.10608685e+00f,
  -2.95214504e-01f, 1.07182652e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    