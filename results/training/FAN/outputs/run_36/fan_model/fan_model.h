/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.42994642e-01f, 1.72991268e-02f, 1.61304120e-02f, 2.01733410e-01f, 1.42134815e-01f, 4.61325169e-01f, 2.54377335e-01f, 4.19871993e-02f, 1.05405226e-01f, -5.98042347e-02f,
  7.37923533e-02f, -1.84533462e-01f, -2.41861895e-01f, 2.06853867e-01f, 1.41656071e-01f, -1.20929949e-01f, 3.47450703e-01f, 5.17484061e-02f, -1.09788448e-01f, -1.14302626e-02f,
  -7.15464652e-02f, 1.51171446e-01f, -1.03454612e-01f, -3.86675894e-02f, 3.57471360e-03f, -8.26577544e-02f, -7.51238763e-02f, -7.74449259e-02f, 8.88036788e-02f, 1.02565937e-01f,
  -1.04929768e-02f, -1.08404055e-01f, 6.83872253e-02f, -8.40431228e-02f, 4.23633531e-02f, 1.51296370e-02f, 6.92979619e-02f, -3.50837037e-02f, 4.37012874e-02f, -1.70045607e-02f,
  4.99608107e-02f, 2.74473671e-02f, 3.94477881e-02f, 3.03668100e-02f, -6.04964457e-02f, -3.30309346e-02f, -5.79455681e-02f, -1.71676837e-02f, -5.25702797e-02f, 1.39248138e-02f,
  -5.39758280e-02f, -7.56464228e-02f, 1.37151014e-02f, 2.17141937e-02f, 1.50689902e-02f, 3.72284651e-02f, 1.41590938e-01f, 2.79596145e-03f, 3.96147445e-02f, 6.91660047e-02f,
  2.05794778e-02f, 4.52803522e-02f, 3.49831283e-02f, -6.59273118e-02f, 1.13137193e-01f, -2.73242733e-03f, -3.34338769e-02f, -4.09725169e-03f, 8.71411785e-02f, -2.49148570e-02f,
  4.13659103e-02f, 6.83411956e-02f, -5.75402826e-02f, -5.83045259e-02f, -1.97963044e-02f, 8.47902615e-03f, -3.78145874e-02f, -6.75876066e-02f, -1.77580230e-02f, 8.56654160e-03f,
  -4.03234139e-02f, 7.70011768e-02f, -7.83091858e-02f, -6.19789213e-02f, 2.88289562e-02f, 7.93719944e-03f, 1.48590729e-02f, -6.11959472e-02f, -3.34333256e-02f, -6.86319033e-03f,
  1.40319273e-01f, 9.75354314e-02f, -6.38038293e-02f, 2.49599013e-02f, 4.10607420e-02f, 3.93132977e-02f, 3.74868661e-02f, 8.00687447e-02f, 4.46039699e-02f, 5.86301507e-03f,
  1.50891170e-02f, 1.94377303e-02f, -2.00026501e-02f, -2.03631036e-02f, 2.42246930e-02f, 4.82677743e-02f, -1.05998619e-02f, 1.31437570e-01f, 7.03275800e-02f, -9.96026322e-02f,
  4.41896394e-02f, -1.33133410e-02f, -8.54090750e-02f, 1.43967578e-02f, 1.13118254e-01f, -6.53973520e-02f, 9.20066759e-02f, -2.39864979e-02f, -7.16112554e-02f, -4.65376563e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.60806133e-03f, -8.44749957e-02f, -2.24421456e-01f, 2.34331205e-01f, 2.33334526e-01f, 1.80173501e-01f, -2.50945359e-01f, 2.44804814e-01f, -1.47800162e-01f, 2.24199221e-01f,
  3.26111108e-01f, 1.88023411e-02f, -2.19598964e-01f, 9.71248448e-02f, 1.36032447e-01f, -2.41456434e-01f, 2.04465970e-01f, 1.16398856e-01f, -4.01275009e-02f, 1.70189962e-01f,
  1.73590422e-01f, 3.20946902e-01f, 1.23384676e-03f, 4.26108360e-01f, 3.29663008e-01f, 1.83173895e-01f, 2.41198331e-01f, -1.66689530e-01f, 4.14781213e-01f, -1.85739412e-03f,
  2.47004777e-02f, -4.74321097e-02f, -4.26633731e-02f, -2.22759753e-01f, 4.22412455e-02f, -1.91631857e-02f, 3.48579250e-02f, -1.24981254e-01f, 1.06663018e-01f, 1.73346270e-02f,
  4.52277400e-02f, 8.14677551e-02f, -5.41583300e-02f, -3.03490646e-02f, 5.37486654e-03f, -3.67068835e-02f, 3.69629562e-02f, 3.65801230e-02f, -5.71041256e-02f, -1.99354902e-01f,
  -1.72159240e-01f, -7.62008429e-02f, -5.84004971e-04f, 3.10870502e-02f, 8.24842900e-02f, 1.35098591e-01f, -4.15103473e-02f, 1.55694172e-01f, -4.15912047e-02f, 1.69004738e-01f,
  4.41042800e-03f, 4.72442284e-02f, 1.58667281e-01f, 6.71042427e-02f, -1.16497308e-01f, -8.08017552e-02f, 1.08591817e-01f, 1.37148770e-02f, -5.82534969e-02f, 8.86096507e-02f,
  8.79390910e-02f, 1.55508533e-01f, -1.45519927e-01f, -8.03747624e-02f, 3.76079381e-02f, -9.23535824e-02f, 1.23037137e-01f, 8.49773213e-02f, 1.52942196e-01f, 1.41998321e-01f,
  1.76324043e-02f, -1.13134734e-01f, 1.51728407e-01f, 7.62386322e-02f, -2.76391450e-02f, 1.32789850e-01f, 1.79055631e-01f, 7.92021379e-02f, 5.79575151e-02f, 3.79024670e-02f,
  2.03124285e-01f, 2.54821301e-01f, 9.54855466e-04f, -2.37928610e-02f, -2.09741876e-01f, -2.20559612e-02f, 4.41108793e-02f, -1.38108199e-02f, 7.09735900e-02f, 4.58685271e-02f,
  6.33070916e-02f, 4.97052595e-02f, 1.05228625e-01f, -4.23817001e-02f, -8.51522088e-02f, 1.75221205e-01f, 1.41688576e-02f, 2.13751644e-01f, 2.02041596e-01f, 1.31271452e-01f,
  7.50181973e-02f, 5.77695817e-02f, 2.24373583e-02f, 4.02018465e-02f, 1.58633322e-01f, 2.44644675e-02f, 2.40148325e-02f, -2.30592061e-02f, 1.42313559e-02f, -1.46011636e-02f,
  1.30814062e-02f, 3.85358810e-01f, 4.57326742e-03f, 5.24310112e-01f, 2.47458257e-02f, -2.77721822e-01f, -3.98592919e-01f, 2.00751126e-01f, 1.86556969e-02f, 1.84781864e-01f,
  -1.50356200e-02f, 1.12621650e-01f, 1.23893411e-03f, 3.70558910e-02f, 3.50438535e-01f, -2.24927813e-01f, 2.08533302e-01f, -1.04459308e-01f, 2.26934496e-02f, 2.51025945e-01f,
  1.57773308e-02f, 2.10710973e-01f, -3.01450863e-02f, 2.58124061e-02f, 1.11153409e-01f, 1.11433484e-01f, 3.78323048e-01f, -8.91488567e-02f, 1.01110019e-01f, -1.99631602e-02f,
  -8.28632340e-02f, 2.89351463e-01f, -1.12110816e-01f, 3.32906023e-02f, 6.02534600e-02f, -1.21006638e-01f, -1.54328331e-01f, 7.98689667e-03f, -1.04431264e-01f, 1.19352929e-01f,
  -3.00639383e-02f, 6.89792857e-02f, -1.06619865e-01f, 4.10695598e-02f, -3.00452653e-02f, 8.96040499e-02f, -6.16151132e-02f, 4.60014446e-03f, 4.20481712e-02f, -9.56868902e-02f,
  -3.84273231e-02f, 4.68788706e-02f, 2.95983031e-02f, -5.88228814e-02f, 2.25874316e-02f, 1.21579561e-02f, 5.34564303e-03f, 5.80682838e-03f, 1.95616409e-01f, 1.12925939e-01f,
  5.39685637e-02f, 4.81793210e-02f, -5.81255890e-02f, -1.67103231e-01f, 1.07724622e-01f, 7.48107582e-02f, -7.37421736e-02f, -8.11694041e-02f, -2.13010684e-01f, 4.29911837e-02f,
  -9.21432450e-02f, 3.67557374e-03f, -7.78455362e-02f, 2.74152048e-02f, -5.11500007e-03f, -1.27499728e-02f, -5.35215698e-02f, 5.88183925e-02f, -8.37905798e-03f, -5.55810742e-02f,
  4.21556346e-02f, 1.02577493e-01f, -1.06948987e-01f, 4.21177112e-02f, 6.63589314e-02f, 5.05495220e-02f, 1.78012311e-01f, 3.68902609e-02f, -3.26422006e-02f, 1.41823813e-01f,
  1.96292102e-01f, 6.53002620e-01f, 2.35516652e-02f, 7.30629936e-02f, -1.28316224e-01f, -3.62139456e-02f, 1.11982174e-01f, 1.29518405e-01f, 7.59758055e-02f, 6.53654486e-02f,
  1.20137028e-01f, -1.04398824e-01f, 1.08515844e-01f, 9.82410647e-03f, 9.41985846e-02f, 8.25188607e-02f, 2.55260114e-02f, 8.59239474e-02f, 1.30131558e-01f, 1.08126558e-01f,
  6.17795177e-02f, 1.07757203e-01f, 1.13662072e-02f, -1.70684859e-01f, 9.12814140e-02f, -5.68928793e-02f, -1.36420831e-01f, -6.38231114e-02f, 1.62635595e-01f, -1.88134927e-02f,
  -1.79748163e-01f, -4.54124540e-01f, -1.48629144e-01f, 2.89380610e-01f, 2.93896466e-01f, 2.49777809e-02f, 1.77274972e-01f, -5.65643124e-02f, -3.02756220e-01f, -1.03999294e-01f,
  2.04473555e-01f, 1.13582231e-01f, -2.64609084e-02f, 1.64675593e-01f, 1.80937946e-01f, -3.64038944e-01f, 4.62823324e-02f, 1.19665451e-01f, -2.33386099e-01f, -1.19362146e-01f,
  7.00153559e-02f, -4.62053716e-02f, 8.51405561e-02f, -1.96334288e-01f, 2.71566153e-01f, -9.79673713e-02f, 3.49115133e-01f, 1.00160018e-01f, 1.27863258e-01f, 1.27368823e-01f,
  4.88721244e-02f, -1.48810670e-01f, 3.31374519e-02f, -5.58207333e-02f, -9.09581184e-02f, 2.89072376e-02f, 8.91405344e-02f, 6.57218993e-02f, 2.73111742e-02f, -4.56609949e-02f,
  7.67605603e-02f, -6.34748489e-03f, -7.19462149e-03f, -8.54563266e-02f, -3.27234194e-02f, 8.26172344e-03f, 5.65092675e-02f, 1.48503214e-01f, -2.84339059e-02f, 3.64678279e-02f,
  -7.87394345e-02f, 1.18818410e-01f, 1.70428291e-01f, -6.05418021e-03f, 4.21520956e-02f, -5.47469594e-02f, -5.09837791e-02f, 1.51104468e-04f, 6.12741224e-02f, -1.75244078e-01f,
  -1.24874569e-01f, 8.12533349e-02f, 7.87213594e-02f, 1.21336274e-01f, -6.03824668e-02f, 4.78428556e-03f, -4.67790887e-02f, 3.42690013e-02f, -8.21451098e-03f, -1.59135789e-01f,
  -3.88991125e-02f, -9.79951397e-02f, 5.17603941e-02f, -4.39941026e-02f, -1.00295804e-02f, 3.09233740e-02f, 6.44667000e-02f, 1.38501570e-01f, -1.10840365e-01f, 9.41362157e-02f,
  1.04965465e-02f, 8.19140114e-03f, -1.10080540e-01f, 9.77920741e-03f, -5.29064909e-02f, -2.85687178e-01f, -6.61603883e-02f, -1.11198381e-01f, 1.04412250e-01f, -4.83596362e-02f,
  1.20941103e-01f, -9.74062830e-02f, -8.33808444e-04f, 1.57216161e-01f, -7.05346614e-02f, -6.40970618e-02f, -1.09249324e-01f, -5.62568381e-02f, -7.85455033e-02f, -8.74401852e-02f,
  1.19937733e-01f, -6.38283566e-02f, 9.01247337e-02f, -1.66524857e-01f, 1.46765456e-01f, -1.43123999e-01f, 6.84054568e-02f, -5.40099218e-02f, 1.37181908e-01f, -7.06591457e-02f,
  6.16169423e-02f, 1.05446339e-01f, 9.56832096e-02f, -1.68949012e-02f, -1.51609108e-01f, 8.36008191e-02f, 4.73571718e-02f, -1.50633782e-01f, 1.72601640e-01f, 1.11291125e-01f,
  3.50118220e-01f, -5.30712426e-01f, -6.20722510e-02f, 4.27913308e-01f, 1.76699683e-01f, -1.34711355e-01f, -4.57731038e-02f, 1.40351737e-02f, 3.25434119e-01f, -5.16766906e-01f,
  -1.02256715e-01f, -3.49091262e-01f, -4.19723421e-01f, 3.99193875e-02f, 4.12057102e-01f, -2.61365920e-01f, 1.79369181e-01f, -5.99517711e-02f, 8.40822235e-02f, -1.19491637e-01f,
  1.85447797e-01f, 2.34054536e-01f, -1.56457677e-01f, -2.89693978e-02f, 1.09201014e-01f, 1.17082663e-01f, 7.03269839e-02f, -1.65806249e-01f, -3.26310880e-02f, 5.79075962e-02f,
  1.01316229e-01f, -8.06932822e-02f, 1.25260308e-01f, 6.12602979e-02f, -3.79685275e-02f, -4.30030748e-02f, -9.22588632e-02f, -6.40353784e-02f, 9.51412022e-02f, -2.71558855e-02f,
  -1.36541352e-01f, 4.96725738e-02f, 3.66459936e-02f, 3.08538247e-02f, 7.37858042e-02f, 3.47071141e-02f, 3.84077542e-02f, -5.33526205e-02f, -1.51299210e-02f, -8.55474696e-02f,
  -2.87257526e-02f, 3.46671045e-02f, 4.05081213e-02f, -1.17308050e-01f, 1.15383200e-01f, 4.55827974e-02f, -8.05679709e-02f, -8.50917846e-02f, 2.96266098e-02f, 7.49091282e-02f,
  -2.70936638e-02f, 1.54720023e-02f, -3.40980515e-02f, 6.62215576e-02f, -1.96938757e-02f, 1.58992022e-01f, -4.20039445e-02f, -5.87181114e-02f, -6.01180531e-02f, 1.14139328e-02f,
  4.93514277e-02f, 3.49653396e-03f, -3.48400213e-02f, -6.31440617e-03f, 1.46060511e-02f, 2.20750514e-02f, 1.93297211e-02f, -4.45104390e-02f, 5.95163070e-02f, 1.58476420e-02f,
  -4.59736846e-02f, 2.51773931e-02f, -2.00637355e-02f, 2.41586622e-02f, 1.74244940e-02f, 3.48778777e-02f, -3.24289463e-02f, -5.17485365e-02f, 1.38399191e-02f, 3.91169786e-02f,
  -1.55038998e-01f, -2.03425229e-01f, -2.74939928e-02f, -1.34326266e-02f, -6.12419508e-02f, 1.07458103e-02f, -2.38543414e-02f, 3.60706188e-02f, 7.69814774e-02f, 8.39223489e-02f,
  -3.45861241e-02f, 2.93535143e-02f, -8.08717161e-02f, 5.90283945e-02f, 1.26401531e-02f, -7.72012174e-02f, -7.72514343e-02f, 1.74353272e-02f, 5.85089922e-02f, 2.23482940e-02f,
  -6.38950840e-02f, -3.70164216e-02f, -1.69769558e-03f, 3.04989982e-02f, -6.21497259e-02f, -8.70351121e-02f, -6.87092543e-02f, 3.37857604e-02f, -1.44212227e-02f, 7.53450394e-03f,
  3.23961169e-01f, -3.98598835e-02f, 2.94341207e-01f, 4.15964633e-01f, 1.80350970e-02f, -3.60257745e-01f, -1.47191003e-01f, 1.90577246e-02f, -2.62080789e-01f, -6.20552115e-02f,
  -5.61259054e-02f, 1.25210449e-01f, -3.91424775e-01f, -1.83278561e-01f, -2.39977419e-01f, -6.86018407e-01f, -1.85714826e-01f, -7.06530139e-02f, -4.06255484e-01f, 2.59195387e-01f,
  1.58135042e-01f, -1.90825760e-01f, 4.23962176e-02f, 1.25540584e-01f, 8.12115446e-02f, 6.28490865e-01f, 2.61878490e-01f, 4.56634946e-02f, 2.90631920e-01f, -2.11091146e-01f,
  -3.06021720e-01f, -1.42800927e-01f, 7.69346431e-02f, -5.45325391e-02f, 1.90677747e-01f, 1.70307174e-01f, 2.03458115e-01f, 2.88506038e-02f, -4.78070863e-02f, -1.58920567e-02f,
  1.49707422e-02f, -3.71398367e-02f, 5.85629418e-03f, -7.96530917e-02f, -3.09115537e-02f, 2.07743533e-02f, 1.07164912e-01f, -5.34034194e-03f, -6.06023483e-02f, 4.03245054e-02f,
  1.25708319e-02f, 8.30536708e-02f, 2.34309718e-01f, 8.31017867e-02f, 1.42340437e-01f, -9.09692142e-03f, 6.39790371e-02f, 2.53855497e-01f, 8.69689044e-03f, -2.88213901e-02f,
  1.02130778e-01f, -7.33760446e-02f, -1.59172326e-01f, -1.81021884e-01f, -1.33816734e-01f, 6.27998859e-02f, -1.03751794e-01f, 3.31082307e-02f, -7.83470795e-02f, 4.88448478e-02f,
  -7.44985268e-02f, -3.52345109e-02f, -1.53893322e-01f, 8.44958276e-02f, 1.14807874e-01f, 2.83326972e-02f, 4.96399403e-02f, -6.69150427e-02f, 4.61258255e-02f, -8.78186598e-02f,
  -2.17769936e-01f, 1.22560911e-01f, 6.22335039e-02f, 1.89859960e-02f, -1.25930369e-01f, 6.44064918e-02f, 1.02887206e-01f, 3.79321724e-02f, 3.50822061e-02f, 7.72727355e-02f,
  4.94937077e-02f, 3.38234067e-01f, 9.23448727e-02f, -4.91360389e-02f, 8.11602324e-02f, -3.45330574e-02f, -7.94539228e-02f, -5.27387634e-02f, 8.77374709e-02f, -1.32117629e-01f,
  1.60443068e-01f, 6.73306957e-02f, -8.98376759e-03f, 2.57278532e-02f, -4.79362682e-02f, 4.03852426e-02f, 9.09059346e-02f, 1.57458074e-02f, 2.25738764e-01f, 2.47490749e-01f,
  2.33533368e-01f, -3.27263437e-02f, -2.82873921e-02f, 4.83741798e-02f, 4.42083143e-02f, 7.80356228e-02f, 1.01442508e-01f, 9.71795321e-02f, 3.55358720e-02f, -5.53861819e-02f,
  -3.55560809e-01f, -9.96091068e-02f, -5.21802068e-01f, -4.10597146e-01f, 1.75786912e-01f, -4.55469668e-01f, -3.37221473e-01f, 8.46946519e-03f, 5.18347360e-02f, 2.08973899e-01f,
  1.15465447e-01f, -1.01335600e-01f, 4.63353507e-02f, -5.48037648e-01f, -3.95683616e-01f, -1.33037329e-01f, -5.76189160e-01f, -3.14197332e-01f, -8.44661519e-02f, -2.66279936e-01f,
  -2.54581600e-01f, -2.11421341e-01f, -5.17968953e-01f, 1.75169289e-01f, -3.57481271e-01f, 3.83601375e-02f, 1.79907933e-01f, 1.37063742e-01f, -8.24357271e-02f, 7.67478570e-02f,
  -1.87177300e-01f, 1.53519541e-01f, -5.87367080e-02f, -7.83358812e-02f, -1.73791155e-01f, 5.88597357e-02f, -1.38982981e-01f, -7.87859224e-03f, 5.28871007e-02f, -9.86635536e-02f,
  2.27716099e-02f, -7.98920617e-02f, -4.57671881e-02f, 1.36645943e-01f, -4.66473177e-02f, -1.57328937e-02f, -7.68576562e-02f, -7.18453526e-02f, -6.65826872e-02f, -1.21906295e-01f,
  -1.31963685e-01f, -6.32025078e-02f, 2.06523179e-03f, 9.18085575e-02f, -6.68728724e-02f, 5.68682421e-03f, 1.12983165e-02f, 3.59516032e-02f, -2.04273332e-02f, -5.86024672e-02f,
  1.34779401e-02f, -2.47974824e-02f, -3.82703505e-02f, -1.37513671e-02f, 3.75693552e-02f, 7.11709261e-02f, -4.06212173e-02f, 1.02399655e-01f, 6.05303943e-02f, 2.00041328e-02f,
  4.97413054e-02f, 4.40795831e-02f, 4.34708558e-02f, -1.53659612e-01f, -6.27723485e-02f, -4.16168757e-02f, -8.18315595e-02f, 8.65084454e-02f, -1.25977933e-01f, 3.73725928e-02f,
  1.11422673e-01f, -2.19755411e-01f, 4.40096334e-02f, -1.33427396e-01f, -3.30917388e-02f, -1.14372717e-02f, 4.81468538e-04f, -5.94163463e-02f, -6.68336004e-02f, -3.59865203e-02f,
  -3.34274815e-03f, 2.77936962e-02f, 4.05779369e-02f, 5.13087362e-02f, 1.12327591e-01f, -1.51735432e-02f, -1.21416897e-01f, -2.79690400e-02f, -4.51785512e-02f, -7.63319507e-02f,
  -3.16888802e-02f, 2.80596614e-02f, 4.20095623e-02f, -5.53950146e-02f, 2.01404709e-02f, -4.23482321e-02f, 7.54919350e-02f, 1.02988034e-01f, 8.61126110e-02f, 3.76323760e-02f,
  1.07058480e-01f, 1.45697728e-01f, 4.14995998e-02f, -1.01160416e-02f, 3.70780751e-02f, -3.90585661e-02f, 1.21339187e-01f, 1.30537972e-02f, 1.00959819e-02f, -4.65920195e-02f,
  3.65020424e-01f, -3.45843285e-01f, -2.08105892e-01f, -3.10542714e-02f, -8.25469792e-02f, -5.04564524e-01f, -2.69737184e-01f, -1.18639648e-01f, -1.06616013e-01f, -1.63481981e-01f,
  -6.37936145e-02f, 9.61562097e-02f, 1.26906127e-01f, -1.21579997e-01f, 3.22631627e-01f, 2.35431030e-01f, -5.94586246e-02f, -9.91469771e-02f, 2.16954365e-01f, 1.79440185e-01f,
  2.89682567e-01f, -3.50750722e-02f, 2.91517049e-01f, 1.13669716e-01f, 8.98030121e-03f, 4.26412493e-01f, 5.65553606e-01f, 2.55145341e-01f, 1.67916790e-01f, 1.16056859e-01f,
  1.32017471e-02f, 3.58555540e-02f, -3.97910997e-02f, 2.31961571e-02f, 1.87427383e-02f, 3.69058214e-02f, 1.13691157e-03f, 7.07020164e-02f, 4.81487736e-02f, -1.13506718e-02f,
  6.34043664e-02f, 6.61058128e-02f, -1.76183786e-02f, 1.12259492e-01f, 9.53397229e-02f, -6.71693012e-02f, 6.28684834e-02f, -4.76519912e-02f, -7.30574504e-02f, 3.69371870e-03f,
  -1.01919724e-02f, -7.79879242e-02f, -5.44678234e-02f, 5.98630272e-02f, 2.29320806e-02f, -6.82533681e-02f, 8.80230665e-02f, 6.04698770e-02f, -1.20658696e-01f, -7.31337816e-02f,
  9.43409428e-02f, -1.52220475e-02f, -7.12941065e-02f, -5.73451146e-02f, -3.07710040e-02f, 8.91221985e-02f, -1.00408264e-01f, -1.52670562e-01f, 1.73677281e-02f, 2.61201002e-02f,
  -1.07025973e-01f, -6.93590790e-02f, 1.28973290e-01f, 5.18309921e-02f, 1.03811212e-01f, -3.12330239e-02f, 3.45975570e-02f, 1.10703558e-01f, -1.03311151e-01f, -1.45031273e-01f,
  7.96735883e-02f, 1.82286963e-01f, 3.42985708e-03f, -1.94967333e-02f, 3.03490963e-02f, -4.66853613e-03f, 5.26998639e-02f, -1.64393168e-02f, -1.86968390e-02f, -9.30298194e-02f,
  -3.98059422e-03f, 1.92407653e-01f, -6.71884918e-04f, -2.72839945e-02f, -1.11285569e-02f, -5.00194840e-02f, 2.72475798e-02f, -1.81408226e-01f, 1.29860818e-01f, -1.12159200e-01f,
  -1.73524786e-02f, -1.09848738e-01f, 6.67491332e-02f, 3.37905437e-02f, 1.07021466e-01f, -1.14018008e-01f, 1.44809291e-01f, -9.01968870e-03f, -1.28672957e-01f, 3.46778682e-03f,
  3.07003651e-02f, -6.06621020e-02f, 1.38429999e-01f, -8.81702080e-02f, -7.91958869e-02f, -5.64991981e-02f, 2.40016524e-02f, -2.10413858e-02f, 7.27640241e-02f, -7.54425004e-02f,
  -4.62380022e-01f, 3.05864185e-01f, -4.29584175e-01f, 2.62981385e-01f, -1.96397036e-01f, 5.05996764e-01f, 2.93328971e-01f, 3.46942954e-02f, 2.63303638e-01f, 5.46707511e-01f,
  2.84509361e-01f, 1.52236775e-01f, 1.25988349e-01f, 5.16907930e-01f, 1.82563722e-01f, 4.10122365e-01f, 4.47158456e-01f, 3.43264252e-01f, -1.46093041e-01f, 6.16329908e-02f,
  -1.52319148e-01f, 3.19423020e-01f, -6.40114993e-02f, -9.40327793e-02f, -3.43584836e-01f, -3.19943100e-01f, 2.36237254e-02f, -3.60610873e-01f, 3.58304046e-02f, 3.39606404e-02f,
  -1.68409348e-02f, -1.28461346e-01f, -6.97598159e-02f, -5.32495193e-02f, -6.36363849e-02f, -5.59565797e-02f, -1.36514023e-01f, -1.18015751e-01f, -1.30452767e-01f, -6.22302517e-02f,
  -2.13094763e-02f, -8.62162188e-02f, 9.10105482e-02f, -6.07358366e-02f, -2.57129259e-02f, -7.60272071e-02f, -8.84330422e-02f, 1.99047588e-02f, 5.05544767e-02f, -1.09874547e-01f,
  -1.80296563e-02f, 1.24336287e-01f, 8.92487839e-02f, 3.60295139e-02f, -4.78102826e-02f, 1.47196157e-02f, 1.17215380e-01f, -5.46427108e-02f, 1.31126689e-02f, 7.43218660e-02f,
  5.76809049e-02f, -9.07063670e-03f, 5.29303774e-02f, -1.09978057e-01f, 9.24382359e-02f, -1.04029819e-01f, 1.74097553e-01f, -3.86664877e-03f, -5.31403348e-02f, 8.85635335e-03f,
  6.80791810e-02f, -9.45946723e-02f, 8.38081613e-02f, 7.26576848e-03f, 2.10721865e-02f, 1.11724049e-01f, 2.08287835e-02f, 6.94072526e-03f, 1.67024024e-02f, -2.37080343e-02f,
  -1.70010328e-02f, -7.02964962e-02f, -1.78137142e-02f, -1.42415026e-02f, 1.04435101e-01f, -1.11911550e-01f, 1.29352286e-02f, -3.88838835e-02f, -6.44132048e-02f, -8.44834372e-02f,
  1.84005871e-01f, 1.28722295e-01f, 6.42016977e-02f, 3.82147287e-03f, 6.20628521e-03f, 4.31414088e-03f, 6.75800294e-02f, -8.36029202e-02f, 6.56586587e-02f, -6.98369145e-02f,
  -3.62193352e-03f, 8.04329216e-02f, -3.44007872e-02f, 2.06928924e-02f, 6.58399835e-02f, 3.60554084e-02f, -2.69819852e-02f, 1.66471265e-02f, 1.07397087e-01f, -2.76152324e-02f,
  -4.24304418e-03f, 7.43371472e-02f, 4.26865891e-02f, -1.11745268e-01f, 1.72567572e-02f, 5.70084937e-02f, -6.60441769e-03f, -1.15142204e-01f, -1.16373543e-02f, 2.29552686e-02f,
  -3.09471309e-01f, -2.96466976e-01f, -8.34612250e-02f, -2.55712390e-01f, -1.41595706e-01f, -3.41003686e-01f, 1.03311434e-01f, -4.45026338e-01f, 2.26163208e-01f, -6.41412959e-02f,
  7.66555369e-02f, 2.50423960e-02f, 3.43309253e-01f, -4.44942191e-02f, 3.21517020e-01f, 4.01382148e-01f, 7.73699954e-02f, 1.04610458e-01f, -2.62671430e-02f, -2.28377268e-01f,
  4.86866832e-02f, -2.29673594e-01f, 1.31494433e-01f, -4.91524100e-01f, -1.10932797e-01f, -2.01480940e-01f, 6.49571642e-02f, -1.72479019e-01f, -2.99186915e-01f, 3.88002098e-02f,
  -1.23606861e-01f, -2.57890791e-01f, -1.52004525e-01f, -6.44900203e-02f, -2.59082690e-02f, 3.95212136e-03f, 2.49918234e-02f, 5.57408342e-03f, -2.45560892e-02f, 2.29640584e-02f,
  2.42353138e-02f, -1.42828643e-01f, -1.63464189e-01f, -3.55923502e-03f, -7.38635734e-02f, -2.40802504e-02f, 1.65796187e-02f, 3.76899540e-02f, -1.33018658e-01f, -8.24671313e-02f,
  -8.42083171e-02f, -5.53282052e-02f, 8.05622712e-02f, 6.47101775e-02f, 1.04894802e-01f, 2.01683622e-02f, 5.98056354e-02f, 1.02795854e-01f, -5.59462383e-02f, -1.76221654e-02f,
  3.49334851e-02f, -3.16605829e-02f, 6.75649894e-03f, -8.89355391e-02f, -3.23493890e-02f, 1.17141977e-02f, -5.57993986e-02f, 1.53229862e-01f, -6.87486827e-02f, -5.63415606e-03f,
  -3.59141864e-02f, 1.62062049e-02f, -9.65296626e-02f, -3.96033339e-02f, 1.44399898e-02f, 3.78937349e-02f, -2.88206618e-02f, -4.49231379e-02f, 1.25344336e-01f, 7.27756275e-03f,
  -6.81444332e-02f, 5.20488843e-02f, 7.63869882e-02f, -2.18715649e-02f, 7.23355114e-02f, 4.88278940e-02f, -6.83124736e-03f, 1.59792125e-01f, 8.86735246e-02f, 1.06161200e-01f,
  -4.65086669e-01f, -3.67335945e-01f, -7.02641085e-02f, -8.43849927e-02f, -2.64300145e-02f, -7.17797056e-02f, 4.49051969e-02f, -6.23355173e-02f, -5.87485246e-02f, 4.16757073e-03f,
  -3.12663168e-02f, 4.87766974e-02f, -7.10483268e-02f, -9.40680318e-03f, 4.23735231e-02f, 3.81381512e-02f, -1.67543571e-02f, 5.22954985e-02f, 4.76236902e-02f, -1.01310626e-01f,
  -2.65942141e-02f, -6.58918098e-02f, 1.03043340e-01f, -6.95124418e-02f, 2.32129991e-02f, 1.36987567e-02f, -2.04181001e-01f, -5.58727980e-02f, -1.97193474e-02f, -8.43979698e-03f,
  4.98202831e-01f, 4.00554389e-01f, 8.78720805e-02f, 7.05999792e-01f, 2.42286012e-01f, 2.54694283e-01f, 2.84813792e-01f, 2.51374424e-01f, 6.63096547e-01f, 6.32396787e-02f,
  -1.21665232e-01f, 3.98086727e-01f, -3.44615430e-01f, 2.30919063e-01f, -3.76867242e-02f, -6.57079890e-02f, 3.49930316e-01f, 2.89688468e-01f, 2.27290660e-01f, 1.30594268e-01f,
  2.02083379e-01f, -1.30392209e-01f, -3.88246298e-01f, -2.40294516e-01f, 1.00720398e-01f, 1.84396476e-01f, -4.17617053e-01f, -3.43744457e-01f, -1.18225664e-01f, -1.57291479e-02f,
  4.15616110e-02f, 2.58607805e-01f, -5.18472726e-03f, -2.83034537e-02f, -6.86831847e-02f, -1.04634993e-01f, 5.83021576e-03f, -1.16884232e-01f, -2.75709890e-02f, 5.83956987e-02f,
  6.49781972e-02f, -1.40337229e-01f, 4.49894406e-02f, -9.47140008e-02f, 1.21025868e-01f, -2.90016253e-02f, -9.95700061e-02f, 5.07158563e-02f, 7.60522252e-03f, -7.48826638e-02f,
  1.42942257e-02f, -6.24302775e-02f, -9.66454204e-03f, -2.31199265e-02f, 7.45870993e-02f, 1.76802985e-02f, -2.28915233e-02f, 5.79935201e-02f, 1.62926093e-02f, 1.14372753e-01f,
  3.79623361e-02f, 5.10716327e-02f, -7.56597370e-02f, -8.73151645e-02f, 1.20965522e-02f, -6.82165027e-02f, -5.83471656e-02f, -4.38718647e-02f, 7.92215206e-03f, -2.71860994e-02f,
  8.67779553e-02f, 8.70567560e-03f, 2.94079687e-02f, -2.00659800e-02f, 8.42207521e-02f, 3.45795974e-02f, 2.36201622e-02f, -3.88429649e-02f, 1.09336488e-01f, -2.99574453e-02f,
  1.69143062e-02f, 3.29689942e-02f, -1.39103934e-01f, -8.89530927e-02f, -2.27149799e-02f, 7.72918866e-04f, 7.61592165e-02f, 8.45530853e-02f, -7.46959681e-03f, -1.37408171e-02f,
  2.13755056e-01f, 4.83324021e-01f, 7.25890249e-02f, 4.27509956e-02f, 9.90154892e-02f, 8.19821097e-03f, -8.24116357e-03f, 1.03119619e-01f, 1.27909616e-01f, 2.90772859e-02f,
  -3.14247794e-02f, 8.96220794e-04f, 5.49467243e-02f, -1.25279158e-01f, -4.47010286e-02f, -1.69306211e-02f, 7.04975873e-02f, 1.32577449e-01f, 1.20917715e-01f, -1.45566091e-01f,
  -5.88017814e-02f, 9.49840471e-02f, 6.52167201e-02f, 6.89009801e-02f, 4.13300283e-03f, 5.08185886e-02f, 1.56075805e-01f, 3.75117399e-02f, -1.56039493e-02f, 6.40540645e-02f,
  4.31907773e-01f, 3.90877575e-02f, -1.39712572e-01f, -2.00683877e-01f, -1.03839420e-01f, 2.45659113e-01f, 2.87527561e-01f, -1.52083024e-01f, -3.47549826e-01f, -1.63542200e-02f,
  7.24198595e-02f, -4.10908498e-02f, 6.19645044e-02f, -3.23578604e-02f, 2.53898978e-01f, 3.42021622e-02f, 2.17057586e-01f, 1.00732990e-01f, -1.04977071e-01f, 1.78166747e-01f,
  5.32055125e-02f, 4.47474211e-01f, -1.42664060e-01f, -6.80000782e-02f, 2.74109900e-01f, -3.34254950e-01f, -1.53113142e-01f, -1.01091027e-01f, -1.10513128e-01f, 3.79188098e-02f,
  5.59801608e-02f, 8.84090215e-02f, -5.00432439e-02f, 8.12050626e-02f, -6.56023547e-02f, 3.43708843e-02f, 6.39593825e-02f, 1.91738516e-01f, -1.23176143e-01f, -9.49658155e-02f,
  2.23476235e-02f, -3.83447565e-04f, 4.07746956e-02f, -1.67421028e-02f, 5.44973239e-02f, -1.32438943e-01f, -7.74063841e-02f, 1.68268736e-02f, -5.69863282e-02f, 1.31645530e-01f,
  -1.48172816e-02f, 9.28355455e-02f, 1.23391524e-02f, -1.32098600e-01f, -7.18580261e-02f, 6.93829432e-02f, 1.77749398e-03f, 6.46708384e-02f, -1.74416937e-02f, 1.07520388e-03f,
  7.90275335e-02f, 7.16564879e-02f, 1.51031300e-01f, 1.99868437e-02f, 4.78406399e-02f, 1.08919308e-01f, 1.28123730e-01f, -5.38474508e-02f, -1.07287792e-02f, -7.88385514e-03f,
  -2.15229794e-01f, -1.02733940e-01f, 7.80642778e-02f, 3.65529582e-02f, 6.39982074e-02f, 1.56983957e-01f, 7.38948956e-02f, 1.41210840e-04f, -1.46011963e-01f, -1.61965653e-01f,
  -5.87657280e-02f, 5.09858094e-02f, 1.08208312e-02f, 2.46203248e-03f, -8.16942938e-03f, -1.12528771e-01f, -7.88206533e-02f, -2.71386188e-02f, 7.32520502e-03f, 9.08723623e-02f,
  -2.26661786e-02f, 5.13018668e-02f, -9.52956006e-02f, 3.71798649e-02f, -1.04214683e-01f, 1.19481748e-03f, -1.97577402e-02f, 1.39843877e-02f, -1.93635393e-02f, 1.17458954e-01f,
  2.90076658e-02f, 2.02213284e-02f, 1.38919279e-02f, 2.33307742e-02f, -1.04239412e-01f, 3.65751609e-02f, -2.80984472e-02f, -1.36697009e-01f, -5.53435683e-02f, 5.99608980e-02f,
  -8.21800157e-02f, 2.00932357e-03f, 1.11268222e-01f, -8.47435445e-02f, 1.12312427e-02f, 7.58495331e-02f, -1.10608071e-01f, 8.20776506e-04f, 1.03042625e-01f, -5.82568422e-02f,
  -2.80502111e-01f, -3.71947229e-01f, 2.13965654e-01f, -4.53565866e-01f, 2.01267019e-01f, 4.82794374e-01f, 1.62895933e-01f, -1.46098107e-01f, -2.67572820e-01f, -2.75815398e-01f,
  -1.43836945e-01f, -1.76978111e-01f, 4.28674556e-02f, -4.85973209e-01f, 2.75778860e-01f, 6.72588497e-03f, -2.61528134e-01f, -1.17710285e-01f, -9.45321694e-02f, -3.12672138e-01f,
  -1.86366543e-01f, -2.79546320e-01f, -4.27923761e-02f, -2.57545978e-01f, -2.07698107e-01f, -1.70648530e-01f, -3.48790595e-03f, 2.40304112e-01f, -2.13609427e-01f, -1.71392132e-02f,
  2.29372922e-02f, -2.43025377e-01f, -9.55511555e-02f, 4.40138318e-02f, 1.74911186e-01f, 8.69177431e-02f, 1.01703443e-01f, 1.71005473e-01f, -1.23555912e-02f, 2.68243030e-02f,
  1.53588271e-02f, -1.07642278e-01f, -7.45056942e-02f, -2.91013028e-02f, -1.03099667e-01f, -4.74802107e-02f, -1.12303190e-01f, -3.26709785e-02f, 1.14511490e-01f, 8.61198455e-02f,
  1.24714384e-02f, -4.77953590e-02f, -1.22968666e-01f, -8.99053141e-02f, 5.49736358e-02f, -2.55131964e-02f, 4.32212651e-02f, 1.06923640e-01f, 4.02304269e-02f, -3.10318824e-02f,
  5.06651700e-02f, 9.95071530e-02f, 4.99076284e-02f, -1.27483577e-01f, 1.79539889e-03f, -4.73455600e-02f, -4.07546349e-02f, -1.70135517e-02f, 2.10892241e-02f, 1.23367868e-02f,
  -1.02793626e-01f, -4.64838371e-02f, -5.71981668e-02f, -3.73486616e-02f, -4.39675190e-02f, -4.12808880e-02f, -6.45859763e-02f, -5.55196702e-02f, -1.61983222e-02f, 8.65762532e-02f,
  -1.83102414e-02f, 4.13166173e-03f, -6.49387091e-02f, -1.93461571e-02f, 1.16503090e-01f, 6.23437539e-02f, -1.62010416e-02f, -6.94004372e-02f, 3.77632007e-02f, 1.09804556e-01f,
  9.98116881e-02f, 2.73617983e-01f, 7.77482567e-03f, 1.66702494e-02f, -7.46579608e-03f, 8.31631124e-02f, -2.16054842e-02f, 6.34735776e-03f, 1.18374161e-01f, -3.34585048e-02f,
  -3.26375514e-02f, -7.98466876e-02f, 7.73869678e-02f, -3.24874669e-02f, -2.68172100e-02f, -8.84820968e-02f, 4.05762605e-02f, -5.92691265e-02f, -1.16522657e-02f, -2.81618014e-02f,
  4.51025851e-02f, -2.95256618e-02f, -9.39658377e-03f, 9.55581665e-02f, -8.70333686e-02f, -2.61881668e-02f, 1.76422194e-01f, 5.28681697e-03f, -5.55690704e-03f, 1.45027200e-02f,
  -7.31392875e-02f, 4.60625201e-01f, -1.85404167e-01f, 3.75595242e-01f, 7.37759098e-02f, 6.33819774e-02f, -1.05532862e-01f, 2.93033838e-01f, 5.58946878e-02f, 2.48301759e-01f,
  3.57052445e-01f, -3.28581259e-02f, -9.83302817e-02f, 4.70458418e-01f, 1.03665948e-01f, -3.20358649e-02f, 2.44585797e-01f, 1.52668670e-01f, -4.96755727e-02f, 1.54788405e-01f,
  -1.27242934e-02f, 4.23967689e-01f, -2.50586309e-02f, 2.13724345e-01f, 5.69455698e-02f, 6.53258488e-02f, 1.51349649e-01f, -1.76144302e-01f, 3.77738833e-01f, 5.69182225e-02f,
  -7.50336573e-02f, -1.13480970e-01f, -6.30833209e-02f, -8.27168524e-02f, 1.74747765e-01f, -1.05645753e-01f, -1.97285131e-01f, -7.08739460e-02f, 5.25945984e-02f, 5.73798083e-04f,
  -6.19865656e-02f, -9.20277089e-02f, 4.45511229e-02f, -1.37249663e-01f, -3.78563479e-02f, -4.01322469e-02f, 3.19786300e-03f, -1.16242550e-01f, -5.86699955e-02f, 2.88222935e-02f,
  2.10254220e-04f, 3.97737436e-02f, -1.46901375e-02f, 1.36602402e-01f, -9.35696997e-03f, -8.42878446e-02f, -5.73617034e-03f, -2.12729797e-01f, 4.98574600e-02f, -9.64741164e-04f,
  7.47736469e-02f, -2.22728811e-02f, -2.45644346e-01f, -2.25591566e-02f, 3.89884636e-02f, 1.85787957e-02f, -1.28133506e-01f, 2.09132992e-02f, -8.25145766e-02f, 1.12920284e-01f,
  1.31425979e-02f, 9.64457318e-02f, -1.46879151e-03f, 4.30022255e-02f, -7.58634880e-02f, -8.74859542e-02f, -9.25842449e-02f, -8.47192388e-03f, 1.37500595e-02f, 2.17815838e-03f,
  -3.33239138e-02f, -6.82331175e-02f, 2.72742449e-03f, 2.29324512e-02f, -4.49377634e-02f, 6.79538399e-02f, 6.06748722e-02f, -8.98796692e-02f, -2.52560768e-02f, -1.43974826e-01f,
  1.39028937e-01f, 2.58197457e-01f, -8.71994272e-02f, -2.06096806e-02f, 7.38046318e-02f, 4.13209535e-02f, -3.42394300e-02f, 1.32211417e-01f, -4.90167066e-02f, -7.73562863e-02f,
  -1.20496519e-01f, -6.43815994e-02f, 2.22771298e-02f, 6.80370331e-02f, -2.03506071e-02f, 6.91958284e-03f, -7.95698315e-02f, -1.04792513e-01f, 1.40754566e-01f, 1.09455764e-01f,
  4.05074134e-02f, 1.33156090e-03f, -6.77671209e-02f, -2.50960104e-02f, 1.21026963e-01f, 7.34806731e-02f, -4.35155332e-02f, -4.09993678e-02f, -2.26845387e-02f, -4.67279181e-02f,
  1.77065209e-01f, -5.49713552e-01f, 2.48823762e-01f, 3.81031096e-01f, 1.67758092e-01f, -2.12227672e-01f, 2.90279150e-01f, -1.38348684e-01f, -2.30239287e-01f, -3.48411113e-01f,
  2.77601421e-01f, 2.45555535e-01f, -1.11215390e-01f, 9.24051087e-03f, 4.55546230e-01f, -1.14662126e-01f, -2.58654412e-02f, 1.23181395e-01f, 6.85774237e-02f, 8.43839347e-03f,
  1.00226603e-01f, 2.68407948e-02f, 1.95055604e-01f, -1.93511650e-01f, 3.62646878e-02f, 4.69399504e-02f, 1.21809645e-02f, 1.52583987e-01f, 6.54667690e-02f, 9.13698226e-02f,
  2.20555626e-02f, -1.51304007e-02f, -1.11392587e-02f, 5.16781118e-03f, -2.61139069e-02f, -4.85860882e-03f, 1.64169192e-01f, 1.14409164e-01f, 6.21038340e-02f, -4.35014963e-02f,
  4.64000087e-03f, -2.18126196e-02f, -1.59181356e-02f, -2.67475611e-03f, -2.63073053e-02f, -2.26368234e-02f, -1.70734122e-01f, -6.40302449e-02f, -3.29367630e-02f, -1.14853129e-01f,
  -1.20668486e-01f, -1.03446342e-01f, -1.53804626e-02f, -4.93404781e-03f, 2.80659995e-03f, -4.91645560e-02f, -1.75741799e-02f, 8.81302357e-02f, 1.16534261e-02f, -2.30882363e-03f,
  9.81784835e-02f, -1.05065936e-02f, -6.51470423e-02f, -8.91193748e-02f, 1.03454143e-01f, 5.53058200e-02f, 5.18677430e-03f, 5.63260727e-03f, 6.74322620e-02f, -4.29568719e-03f,
  9.68408585e-02f, 1.23895757e-01f, -7.24029243e-02f, -5.12162149e-02f, 3.40452529e-02f, -2.02809751e-01f, 6.76632673e-02f, -4.87982780e-02f, -4.27334346e-02f, -1.81796867e-02f,
  2.67497655e-02f, 2.65267165e-03f, -7.57400319e-03f, 1.14926860e-01f, 1.33886831e-02f, 1.39458865e-01f, 6.15895540e-02f, -7.42651820e-02f, -4.28852551e-02f, 1.95249617e-01f,
  2.70783696e-02f, -2.77237743e-02f, 5.19442260e-02f, -6.63335770e-02f, 2.19105668e-02f, -7.42744505e-02f, 1.43163409e-02f, 2.84735486e-02f, -8.14727992e-02f, 5.54662347e-02f,
  5.25874179e-03f, 1.20999537e-01f, -7.29610175e-02f, 1.86302774e-02f, 7.13511556e-02f, -1.27484649e-02f, 4.82858643e-02f, 7.07232505e-02f, -1.75703749e-01f, -1.02867313e-01f,
  -1.24945268e-02f, -5.76653667e-02f, 2.77035628e-02f, 9.00756195e-03f, 8.61156657e-02f, 2.56167263e-01f, 3.14920172e-02f, 2.08974201e-02f, -6.78055361e-02f, 3.85519564e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.20247640e-01f, 1.19741239e-01f, 3.91399115e-01f, -6.31293133e-02f, 5.64062357e-01f, 2.81172395e-01f, 1.33731484e-01f, 6.07711636e-02f, 2.24203900e-01f, 1.41130805e-01f,
  -1.36469882e-02f, 5.06821454e-01f, 9.97919887e-02f, 1.20628387e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.92964131e-01f, -1.94241419e-01f, -1.65436283e-01f, -1.85478538e-01f, -2.08496556e-01f, -1.07962370e-01f, 1.26807973e-01f, 1.61740154e-01f, -2.92641997e-01f, -1.77790612e-01f,
  -3.66446495e-01f, 4.53729212e-01f, -1.65494401e-02f, -2.26032641e-02f, -4.41052824e-01f, -1.90505832e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.30991220e-01f, -6.86027184e-02f, 4.67009880e-02f, -1.63842991e-01f, 2.41871759e-01f, -4.10386741e-01f, -1.64524555e-01f, 7.21598208e-01f, -2.21889131e-02f, -4.26149011e-01f,
  2.01805264e-01f, -2.81853646e-01f, 9.90091264e-03f, 2.69776076e-01f, -5.03675118e-02f, 1.56248137e-01f, -3.39942515e-01f, 8.44609067e-02f, 1.74992457e-01f, 3.83024871e-01f,
  3.98818731e-01f, -4.79599163e-02f, -7.21788360e-03f, -1.92048214e-02f, 3.74464303e-01f, 4.16014008e-02f, -4.75019097e-01f, -1.50549233e-01f, 4.29984301e-01f, 1.04756229e-01f,
  3.86175066e-01f, 2.80456662e-01f, 1.08602196e-01f, -2.57139117e-01f, -4.05116677e-01f, 2.37415023e-02f, -4.45926450e-02f, -4.22503687e-02f, 3.21153611e-01f, 1.26429424e-01f,
  -2.63706893e-01f, -1.59493223e-01f, -9.75738093e-02f, 5.12500167e-01f, 1.24579772e-01f, -1.51419744e-01f, 3.89300734e-02f, 4.65412848e-02f, 2.16540053e-01f, 3.88851225e-01f,
  -1.37081340e-01f, -6.33787394e-01f, 5.88750243e-01f, 6.41623855e-01f, 5.86250238e-02f, -1.55801460e-01f, -1.23594433e-01f, 2.34880179e-01f, 7.26246417e-01f, -7.19914794e-01f,
  2.02361226e-01f, 2.87607938e-01f, 4.08265024e-01f, 5.30640066e-01f, 8.82630646e-02f, -2.25961599e-02f, 4.37881827e-01f, 6.63491428e-01f, -1.53990045e-01f, -6.79872036e-01f,
  -4.10589874e-02f, 3.43570113e-01f, 5.87091625e-01f, 9.00733769e-01f, 1.09194383e-01f, 3.15806180e-01f, 2.52993912e-01f, 5.48001707e-01f, 4.80157197e-01f, -3.39901179e-01f,
  1.60777941e-01f, 3.01932484e-01f, 2.03589886e-01f, 5.30666173e-01f, 3.47940484e-03f, 4.19566244e-01f, 6.85793042e-01f, 4.04928476e-01f, 3.04524720e-01f, -6.76024705e-02f,
  -4.58399981e-01f, -3.78482878e-01f, -4.38244492e-01f, -3.24272752e-01f, 6.66535348e-02f, 2.14818895e-01f, 2.45470732e-01f, -5.73633969e-01f, 1.06743135e-01f, 1.64175034e-01f,
  9.25293639e-02f, -6.53221369e-01f, 3.27992976e-01f, 5.03496230e-01f, 5.72364926e-02f, -3.91022235e-01f, -9.34151933e-02f, 1.63738623e-01f, -1.23153076e-01f, -2.32638568e-01f,
  2.74568647e-01f, -1.45960972e-01f, 3.88282955e-01f, -4.61367041e-01f, 1.03569418e-01f, 3.77066046e-01f, 4.27017540e-01f, 3.99579734e-01f, 5.96665561e-01f, 5.70623457e-01f,
  1.80621240e-02f, -2.50978947e-01f, -1.74133703e-01f, 2.44164780e-01f, -4.53542441e-01f, 1.25709414e-01f, 4.65355348e-03f, -2.43728422e-02f, 8.34393352e-02f, -5.06513752e-02f,
  -2.46456206e-01f, 6.35160729e-02f, -2.19115335e-02f, -2.63499051e-01f, 2.59627006e-04f, 6.20423675e-01f, 3.93810481e-01f, -4.81789917e-01f, 3.83354992e-01f, -4.80408400e-01f,
  4.31359321e-01f, 3.70384872e-01f, -7.18105286e-02f, 2.33500704e-01f, -6.89361274e-01f, -1.54384792e-01f, 4.47594255e-01f, 2.18750238e-01f, -7.24932402e-02f, -2.17483610e-01f,
  3.38475555e-02f, -4.98072863e-01f, 2.43268117e-01f, 1.74110066e-02f, -6.44683301e-01f, 3.01275045e-01f, 4.60696727e-01f, -4.87903357e-02f, 4.17270005e-01f, -3.99304181e-03f,
  -5.19566655e-01f, -5.02489150e-01f, -3.40178549e-01f, 1.70365363e-01f, -4.12015229e-01f, 5.14051914e-02f, -4.95281309e-01f, 7.37545133e-01f, 5.77229820e-02f, -1.62659243e-01f,
  3.43915194e-01f, 4.13097814e-02f, -1.49728790e-01f, -2.69561261e-01f, -8.78483653e-02f, -2.23254710e-01f, 2.83704072e-01f, 2.61192888e-01f, 4.14199859e-01f, 7.81381950e-02f,
  1.89800054e-01f, 5.28279901e-01f, 5.94876587e-01f, -1.38811246e-01f, 6.49179667e-02f, 5.78348756e-01f, 1.33856758e-01f, 4.34223413e-01f, 3.19409311e-01f, 4.08571362e-01f,
  1.87436223e-01f, 4.60829705e-01f, 7.85302997e-01f, -1.14557244e-01f, 1.40845835e-01f, -7.66866654e-02f, 1.76061735e-01f, -4.47276711e-01f, 5.71408011e-02f, 6.51139915e-01f,
  7.48699903e-02f, -4.14502680e-01f, 3.38155299e-01f, -2.56416053e-01f, -1.14398897e-01f, 5.45217276e-01f, -2.82767475e-01f, 7.95525983e-02f, 8.53262991e-02f, -4.21341479e-01f,
  -1.95244506e-01f, 3.60456437e-01f, 2.29463980e-01f, -4.42919552e-01f, 1.72448650e-01f, 5.35405338e-01f, -6.16048812e-04f, -3.88284862e-01f, 2.55881697e-01f, -7.73510784e-02f,
  -1.75140917e-01f, 9.88308415e-02f, 3.12752068e-01f, 2.49670699e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.87494856e-01f, -5.10720015e-02f, 4.90992576e-01f, 1.63127258e-01f, 5.28300226e-01f, 1.63368836e-01f, 2.85291165e-01f, 3.00141275e-01f, 1.90345898e-01f, -3.19382071e-01f,
  -1.67865187e-01f, 6.44524753e-01f, 2.61541039e-01f, 3.26515585e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  4.34613138e-01f, 2.73532480e-01f, -1.28004178e-01f, -9.64251459e-02f, 7.37766782e-03f, 1.90947592e-01f, -2.80219167e-01f, 2.36224100e-01f, -1.87604710e-01f, 4.90948781e-02f,
  8.26350003e-02f, -5.24772465e-01f, -4.44924504e-01f, 2.89043725e-01f, 1.76302195e-01f, -1.65642589e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.76975918e-01f, -7.50668406e-01f, 5.17739892e-01f, 2.08074197e-01f, -8.16861212e-01f, 6.89113259e-01f, 5.99396050e-01f, -1.38151556e-01f, 1.11011967e-01f, 2.52600282e-01f,
  4.78029996e-01f, -3.71581651e-02f, -7.17650890e-01f, 4.60928082e-01f, 5.62635779e-01f, 2.36449152e-01f, 8.60429481e-02f, 3.13083790e-02f, -7.02518523e-01f, 4.82148468e-01f,
  4.62455638e-02f, -1.53849825e-01f, 6.24987125e-01f, 2.07771540e-01f, -6.03082597e-01f, -2.20018774e-01f, 5.34167811e-02f, 4.50405747e-01f, -9.79237258e-02f, 3.06197673e-01f,
  -6.40672326e-01f, -4.78004932e-01f, -5.82085013e-01f, -1.82877153e-01f, -2.94617098e-02f, 4.51088727e-01f, -2.91694831e-02f, 4.28929269e-01f, -3.27339590e-01f, 8.09952080e-01f,
  -5.85347936e-02f, 3.48688483e-01f, 2.44614497e-01f, 1.00626498e-01f, 9.49003175e-02f, 4.54392135e-01f, -5.69073521e-02f, 2.39281496e-03f, 7.48266459e-01f, 2.49006957e-01f,
  -4.06944901e-02f, -1.72367617e-01f, 3.06982458e-01f, -4.96645987e-01f, 4.34955537e-01f, 1.66378677e-01f, -4.75894123e-01f, 2.15892881e-01f, 1.89326722e-02f, -8.71192142e-02f,
  -7.27609873e-01f, 5.74980438e-01f, -1.83498546e-01f, -1.70896441e-01f, -7.31094480e-01f, -1.35833845e-01f, -4.20368075e-01f, 2.86384672e-01f, -1.61015853e-01f, -1.42245695e-01f,
  3.41146529e-01f, 6.64532065e-01f, 5.32957576e-02f, 2.57670492e-01f, 2.06558347e-01f, 2.56853700e-01f, 2.14783356e-01f, 1.14456154e-01f, -7.70514235e-02f, 4.27691847e-01f,
  -9.64013040e-02f, 1.83325022e-01f, -5.89828134e-01f, -4.67094958e-01f, 1.70730576e-01f, 5.70793271e-01f, -8.74661803e-02f, 2.53971994e-01f, -1.00180715e-01f, 1.20518334e-01f,
  -5.44836760e-01f, -7.81328857e-01f, -2.86126751e-02f, 3.66288096e-01f, -4.89276320e-01f, -3.34788352e-01f, 1.03940122e-01f, -9.91637558e-02f, -5.60259163e-01f, -2.88506091e-01f,
  -1.39355093e-01f, 5.10489523e-01f, 1.06888935e-02f, 1.40902504e-01f, -8.64552855e-01f, 1.32607684e-01f, -5.95422328e-01f, -8.40466440e-01f, -2.92946786e-01f, 4.29823428e-01f,
  -8.47451150e-01f, -4.51954186e-01f, -7.65611902e-02f, -3.32425274e-02f, 5.13811886e-01f, -2.97605187e-01f, 1.31575420e-01f, -4.75019589e-02f, 3.94495964e-01f, 1.01237319e-01f,
  5.82627892e-01f, 4.86545265e-01f, 6.03643060e-01f, -1.50021940e-01f, 1.06503296e+00f, -2.31209546e-01f, 5.52236557e-01f, 4.27429587e-01f, -6.93092942e-01f, -4.57668394e-01f,
  2.05127865e-01f, 4.51993793e-01f, -5.10472834e-01f, -5.00638485e-02f, 3.13226551e-01f, 1.87950760e-01f, 3.02745420e-02f, -2.72076935e-01f, 5.61820567e-01f, 3.54512304e-01f,
  4.94089097e-01f, 3.24221522e-01f, 2.75931597e-01f, 4.41955060e-01f, 6.29720509e-01f, -3.54827464e-01f, 2.29176208e-01f, 1.38987839e-01f, -3.88444394e-01f, -2.21814528e-01f,
  7.35330105e-01f, -1.60145670e-01f, -3.49129528e-01f, -3.00217211e-01f, 4.81201380e-01f, 3.92263889e-01f, -8.04259002e-01f, 3.41580838e-01f, 4.05424029e-01f, 1.26836095e-02f,
  -1.55368790e-01f, -9.20454115e-02f, -5.99360824e-01f, 2.15047210e-01f, -1.54474214e-01f, -3.58865485e-02f, 6.38709068e-02f, 5.04120409e-01f, -3.42348635e-01f, 2.63861805e-01f,
  -4.53807235e-01f, 1.50169387e-01f, -2.20657527e-01f, 4.13929164e-01f, -3.03358227e-01f, 8.67856368e-02f, 7.51349747e-01f, 4.66218710e-01f, 2.13207960e-01f, -3.86422634e-01f,
  7.04589665e-01f, -4.68964636e-01f, 2.41286978e-01f, 1.74217924e-01f, 3.60114604e-01f, 5.70547104e-01f, -3.72240186e-01f, -3.31837505e-01f, -7.12294579e-01f, 3.13253164e-01f,
  2.92658627e-01f, -1.00561291e-01f, 1.01135880e-01f, 7.54423559e-01f, 2.92693198e-01f, -2.51081795e-01f, 9.19633567e-01f, -4.01971221e-01f, 2.22632825e-01f, 5.59397936e-01f,
  1.03698027e+00f, 8.92297685e-01f, 1.32368386e-01f, -2.58488804e-01f, 5.71415722e-01f, 8.68852511e-02f, 9.99255925e-02f, 6.44844651e-01f, -5.17460942e-01f, -2.68650949e-01f,
  4.04974520e-02f, 3.21714550e-01f, -1.46190494e-01f, 8.74868274e-01f, 5.31342328e-02f, 4.96061742e-01f, 1.35727197e-01f, 1.71211466e-01f, 7.25455284e-02f, -3.67832631e-01f,
  -4.37988281e-01f, 1.92026079e-01f, 2.34111324e-01f, -5.37602156e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.61817348e-01f, 2.15755463e-01f, -4.17865396e-01f, 4.15892750e-01f, -2.17786297e-01f, 5.04658639e-01f, 2.36601397e-01f, 1.84419110e-01f, -5.27730174e-02f, 1.92501590e-01f,
  1.21473586e-02f, 6.06127858e-01f, 3.52788955e-01f, 1.72614932e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.56549379e-01f, -9.63147283e-02f, 1.54295757e-01f, 6.10725917e-02f, 3.20995718e-01f, -1.78524807e-01f, -6.84234202e-02f, -2.16728076e-01f, -4.75236297e-01f, -2.44007349e-01f,
  4.94930148e-02f, -1.62133098e-01f, 1.21478386e-01f, -3.11261058e-01f, 2.29674820e-02f, 1.73315749e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -4.77890112e-02f, 1.63086817e-01f, 3.49242464e-02f, 6.15174174e-02f, 3.20312530e-01f, -2.70890683e-01f, 4.80275184e-01f, 6.59282327e-01f, 6.57433867e-01f, -3.14678609e-01f,
  1.52878463e-01f, -4.00377601e-01f, 3.53837669e-01f, -5.48543513e-01f, -2.09788963e-01f, 2.02758327e-01f, -1.07874736e-01f, -4.00029927e-01f, 4.71386641e-01f, -4.47831720e-01f,
  -8.17985088e-02f, -2.18954280e-01f, -7.51773268e-02f, -2.21011102e-01f, -6.17086589e-01f, 5.85586607e-01f, 2.53774136e-01f, -2.05928206e-01f, -2.38354012e-01f, 1.96095765e-01f,
  8.14366341e-01f, -2.16814607e-01f, 8.08963776e-01f, 6.60733759e-01f, 9.15294215e-02f, 8.70176852e-02f, -6.33235633e-01f, 5.31562567e-01f, -3.46352756e-01f, 7.31692374e-01f,
  5.28051913e-01f, 1.38123296e-02f, -3.51940691e-01f, 1.60009637e-01f, -2.97375411e-01f, 1.04924405e+00f, 6.68660283e-01f, 1.48321956e-03f, -7.57065594e-01f, 6.16691649e-01f,
  -6.63560256e-02f, -2.79552519e-01f, 1.04165769e+00f, 1.07111983e-01f, 4.06679779e-01f, 2.98928559e-01f, 2.84372340e-03f, -1.40287459e-01f, 2.62361288e-01f, -3.63587499e-01f,
  5.00735879e-01f, -7.28261247e-02f, 4.42292184e-01f, 4.91619885e-01f, -3.76734406e-01f, -6.44927442e-01f, 2.56778389e-01f, 2.17035636e-01f, 7.74878040e-02f, -2.98255354e-01f,
  1.69110447e-01f, -1.30326197e-01f, -9.25191119e-03f, 6.85112029e-02f, 4.47205365e-01f, 1.82938039e-01f, -9.61870030e-02f, -9.03423071e-01f, -6.20461740e-02f, 2.36989185e-01f,
  -2.14154080e-01f, 3.83470319e-02f, 5.39056182e-01f, -4.18091387e-01f, 2.48726711e-01f, -3.58099461e-01f, -2.19645314e-02f, -9.50849280e-02f, -9.93645042e-02f, 4.85812962e-01f,
  2.78930485e-01f, 3.32693160e-01f, -3.81612837e-01f, -5.63726366e-01f, -9.46811885e-02f, 4.29818541e-01f, 1.17667533e-01f, -6.30169213e-01f, 4.90008682e-01f, 1.62536234e-01f,
  -3.86010557e-01f, -1.05170496e-01f, 3.67645234e-01f, -1.76542580e-01f, -1.13945633e-01f, 4.27043170e-01f, 5.37416220e-01f, 4.07448679e-01f, 3.83627228e-02f, -5.03113329e-01f,
  2.92236861e-02f, 1.14318222e-01f, -1.30545441e-02f, -6.09445810e-01f, 1.39002159e-01f, 6.26699269e-01f, -1.20592989e-01f, 4.65214163e-01f, 3.60598683e-01f, -7.66807973e-01f,
  -4.56635565e-01f, 4.82103080e-01f, 4.58610713e-01f, 5.84790707e-01f, 1.61429211e-01f, -8.52771997e-02f, 2.19692979e-02f, -1.26405552e-01f, 3.88741255e-01f, 5.48785806e-01f,
  6.78532183e-01f, 3.29982936e-01f, 2.17074573e-01f, 1.02319598e-01f, -2.56575197e-01f, -5.55917203e-01f, -1.66093707e-01f, -1.88615635e-01f, 3.96800607e-01f, 4.11894739e-01f,
  -1.57842934e-01f, 8.26968551e-02f, -3.48792940e-01f, 4.22869027e-01f, 3.95551890e-01f, 3.68436486e-01f, 4.18373317e-01f, 5.33100426e-01f, 2.75282651e-01f, 5.83275795e-01f,
  5.68659723e-01f, -7.78031826e-01f, -3.83469462e-01f, -3.79661351e-01f, 2.22976550e-01f, 4.75713074e-01f, 2.24806815e-01f, 2.93095082e-01f, -1.10922933e-01f, 2.70345174e-02f,
  5.24826229e-01f, 7.61737645e-01f, 4.63480234e-01f, -4.08157796e-01f, 2.46262148e-01f, -1.08096190e-01f, -9.16210487e-02f, -3.81807297e-01f, -3.50333512e-01f, 2.86182091e-02f,
  2.99132653e-02f, 5.11100829e-01f, -1.36304289e-01f, 2.39745319e-01f, -3.76152068e-01f, 3.21104974e-01f, -4.22088429e-02f, -2.02417135e-01f, -2.78806001e-01f, 4.07733805e-02f,
  2.94215411e-01f, -1.43670872e-01f, 5.97581029e-01f, 3.63339990e-01f, 3.42483789e-01f, 4.59011316e-01f, -2.47739106e-02f, -3.34483057e-01f, 5.06989539e-01f, 5.12000620e-02f,
  7.49508023e-01f, 2.78492391e-01f, 3.89306009e-01f, 3.11516613e-01f, 5.74767709e-01f, -3.34420502e-01f, -4.68628585e-01f, 2.92226881e-01f, -7.79973805e-01f, 1.26881853e-01f,
  3.75570267e-01f, 2.68052340e-01f, -2.81960845e-01f, 6.31112158e-02f, -1.86418951e-01f, 3.18666875e-01f, 4.28835601e-01f, 1.84559777e-01f, -1.36844628e-02f, 4.99000624e-02f,
  5.62411174e-02f, 6.97349966e-01f, -3.65661941e-02f, 5.38051426e-01f, 8.42172652e-02f, 8.49720716e-01f, 1.01029921e+00f, -5.98833442e-01f, -8.55419636e-02f, 1.70685068e-01f,
  5.98617017e-01f, 2.59520769e-01f, -5.56368589e-01f, 2.44347155e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -1.87375993e-01f, 4.41176109e-02f, 6.87289596e-01f, -1.60372883e-01f, -6.13145716e-02f, 1.56375214e-01f, 1.45954676e-02f, 3.11301053e-02f, 2.14012280e-01f, -1.48228705e-01f,
  2.82599270e-01f, 1.05748460e-01f, 6.54230535e-01f, 1.32140815e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.99124974e-01f, -5.51582277e-01f, 4.10872489e-01f, 1.71284918e-02f, 2.04655193e-02f, -5.15894771e-01f, 2.26918757e-01f, -6.41673654e-02f, 3.12993020e-01f, -6.66561350e-02f,
  3.77010740e-02f, 6.61721900e-02f, -6.79393560e-02f, 1.00412648e-02f, -2.31372207e-01f, 4.55818146e-01f, 4.44410518e-02f, 3.24033797e-01f, -1.49901286e-01f, -6.81022048e-01f,
  -7.21097171e-01f, -2.97387540e-01f, 2.30134487e-01f, -1.57192916e-01f, 1.87763333e-01f, 3.79091531e-01f, 3.57147366e-01f, 3.57940257e-01f, 1.64124757e-01f, -6.34161532e-01f,
  -7.66290367e-01f, 4.20872830e-02f, -2.11914062e-01f, 3.59219342e-01f, 4.84153032e-01f, -3.91653538e-01f, -7.05759645e-01f, 1.47436053e-01f, 1.13165453e-01f, -2.61524826e-01f,
  -4.20386702e-01f, -3.30898643e-01f, 1.94665045e-01f, 1.74134344e-01f, -8.78838822e-02f, 4.17287916e-01f, -8.86261344e-01f, 2.79568315e-01f, -3.71990085e-01f, -1.01159126e-01f,
  9.00749955e-03f, 5.08325040e-01f, -1.05966993e-01f, -2.94154942e-01f, -2.54622698e-01f, -6.08218126e-02f, 1.38381630e-01f, 1.90304875e-01f, -9.67844844e-01f, -8.09443593e-01f,
  -9.56237078e-01f, 3.52764040e-01f, 9.60981026e-02f, -2.37569243e-01f, 7.23341405e-01f, -3.54037285e-01f, -3.12973112e-01f, 4.00988944e-02f, 4.08738405e-01f, -1.20715773e+00f,
  -5.99875897e-02f, 9.90492925e-02f, 5.39544709e-02f, -1.23269148e-01f, 2.45315537e-01f, 5.52829206e-02f, 5.12478173e-01f, -6.21371448e-01f, 4.82133090e-01f, -4.21167165e-01f,
  -3.71095866e-01f, 3.09947908e-01f, -3.57618481e-01f, -5.26807547e-01f, 3.69584858e-01f, -5.68906546e-01f, -6.55349910e-01f, -7.81944931e-01f, -3.03977370e-01f, 3.48012567e-01f,
  4.71890271e-02f, 3.76276225e-01f, -2.78642634e-03f, -2.51641810e-01f, 7.70701244e-02f, 3.56010109e-01f, 2.04613417e-01f, -3.43241006e-01f, 1.45099670e-01f, -5.26836693e-01f,
  3.43496919e-01f, 3.08090627e-01f, -3.76133978e-01f, -3.79991084e-01f, -8.71553361e-01f, -7.13850379e-01f, -1.85001358e-01f, -4.95123714e-02f, 6.72904775e-02f, 6.64686039e-02f,
  7.50168785e-02f, 5.71414471e-01f, -5.13417460e-03f, -2.91841358e-01f, -3.41544181e-01f, 2.79854387e-01f, -6.12597227e-01f, -5.90954758e-02f, 5.72579563e-01f, 4.19967920e-01f,
  2.82275259e-01f, 8.37312564e-02f, -3.78685981e-01f, -2.98865974e-01f, -4.02539790e-01f, -1.33027643e-01f, -1.93412583e-02f, -1.97103947e-01f, -3.73367548e-01f, 2.68107533e-01f,
  7.61290044e-02f, -2.37587541e-02f, -3.99805665e-01f, 1.91036999e-01f, 6.68531209e-02f, -3.82007390e-01f, -6.68312684e-02f, 1.98831096e-01f, -1.05271876e-01f, 2.29324251e-01f,
  -3.85812260e-02f, 2.24184170e-01f, -6.34357810e-01f, -1.92825481e-01f, -1.34969838e-02f, 7.21776247e-01f, -5.39281480e-02f, -7.62452632e-02f, -6.79155469e-01f, 2.25393772e-01f,
  1.16724990e-01f, 2.80582428e-01f, 1.33918121e-01f, -2.75855750e-01f, 3.18519205e-01f, -6.13943860e-02f, 4.85843867e-01f, -6.59488082e-01f, 5.37187345e-02f, -4.32519108e-01f,
  -1.26862317e-01f, 2.33028799e-01f, -2.63844222e-01f, 2.17515603e-01f, 1.96541950e-01f, 6.40179068e-02f, -6.01516664e-01f, 6.84235469e-02f, -6.37750030e-02f, -2.75984973e-01f,
  -2.83791393e-01f, 1.67317137e-01f, 2.68259943e-01f, 5.49342372e-02f, 1.89250886e-01f, -4.83968437e-01f, 5.93997985e-02f, -4.86141324e-01f, -2.31019437e-01f, 2.72857279e-01f,
  7.32330680e-01f, -8.13090336e-03f, -2.18062133e-01f, -8.03930938e-01f, -9.75917876e-01f, -6.82591736e-01f, -8.01795423e-01f, -2.34681010e-01f, -6.41883969e-01f, 3.14258039e-01f,
  2.23224729e-01f, -7.36847222e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.53375506e-01f, -2.62814760e-01f, -1.98771179e-01f, 1.52908474e-01f, 1.23718977e-01f, -1.37987927e-01f, 3.25034529e-01f, -9.40070748e-02f, -4.61549938e-01f, -1.86235189e-01f,
  -3.14171106e-01f, 3.22588176e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    