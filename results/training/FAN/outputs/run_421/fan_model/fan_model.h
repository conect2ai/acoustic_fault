/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.12685835e-01f, 3.54986414e-02f, 2.16735676e-02f, -1.82813883e-01f, -8.08598548e-02f, -6.59050420e-02f, 7.28334934e-02f, -2.71250814e-01f, -9.35584307e-02f, 3.19600031e-02f,
  -2.60693245e-02f, 5.75899109e-02f, 2.21923701e-02f, -4.52760719e-02f, -1.32287547e-01f, 6.50128052e-02f, -1.03204519e-01f, -2.67633107e-02f, 4.81064543e-02f, -7.20622241e-02f,
  -1.49810743e-02f, -1.69956684e-01f, 8.14834759e-02f, -4.60622944e-02f, -4.38918620e-02f, 3.37977223e-02f, 7.19582289e-02f, 1.59289777e-01f, -1.74652971e-03f, 1.00216188e-01f,
  -1.38974190e-01f, -1.00620188e-01f, 5.67508191e-02f, 7.13937804e-02f, -5.91934435e-02f, 1.01902127e-01f, -4.88063768e-02f, 4.66651330e-03f, 2.95321085e-02f, 3.21425609e-02f,
  5.57724722e-02f, -7.11179376e-02f, 3.39374617e-02f, -1.79180391e-02f, -8.54540337e-03f, 1.07585140e-01f, 2.95741186e-02f, -3.20342137e-03f, -8.67039114e-02f, 1.87968323e-03f,
  8.67535472e-02f, 1.03145791e-02f, 7.11742938e-02f, -2.07405481e-02f, -2.34212242e-02f, -4.19217488e-03f, -1.01697110e-02f, -5.69589473e-02f, 1.24663617e-02f, -6.77754954e-02f,
  -3.75988483e-02f, 3.89622040e-02f, 8.92266855e-02f, -4.06702869e-02f, -2.40771510e-02f, -5.06386906e-02f, 5.86774386e-02f, -4.21109498e-02f, 5.19857556e-02f, -7.28497356e-02f,
  -1.12483881e-01f, -5.38837537e-02f, -2.67167613e-02f, -1.80276204e-02f, -7.65924826e-02f, -4.57895212e-02f, -2.69253403e-02f, -2.33140439e-02f, -2.96218898e-02f, 4.41990793e-03f,
  -4.70118970e-02f, 5.62959053e-02f, -1.19669354e-02f, -2.74169054e-02f, -1.82640348e-02f, -4.18482758e-02f, 3.70895453e-02f, 5.80567643e-02f, 1.76222716e-02f, -3.27735841e-02f,
  -2.66008340e-02f, -1.33258000e-01f, 4.14284877e-02f, -9.29957777e-02f, 4.47509028e-02f, 2.96625681e-02f, -1.57216918e-02f, 2.33143624e-02f, 9.03228372e-02f, -3.35611925e-02f,
  -2.97802351e-02f, 6.36433437e-02f, -8.19206834e-02f, -5.01895472e-02f, -6.69159517e-02f, -5.59165236e-03f, 7.98879249e-04f, -8.06485862e-02f, -7.94680044e-03f, -9.92510468e-03f,
  -7.03650191e-02f, 4.70613176e-03f, -5.62276132e-02f, -1.36370167e-01f, -6.06459267e-02f, 2.26150863e-02f, 9.63679422e-03f, 6.76510036e-02f, 3.48407626e-02f, -2.35066228e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.28754809e-01f, 6.01492643e-01f, -6.33830950e-02f, 4.33355302e-01f, -2.02573180e-01f, 2.19399855e-01f, 2.35085905e-01f, 1.59671113e-01f, 9.56118628e-02f, 5.07267356e-01f,
  7.53293112e-02f, 1.14462212e-01f, 1.11748725e-01f, 2.98902422e-01f, 6.34729639e-02f, 2.65633464e-01f, 2.13124901e-01f, 1.11668833e-01f, -3.80156487e-02f, 1.09453507e-01f,
  1.15214614e-02f, 3.62883955e-01f, -6.45307079e-02f, 2.23634392e-02f, -1.10721268e-01f, 9.82963480e-03f, 1.60376336e-02f, -2.12153226e-01f, 7.87453949e-02f, 7.99273048e-03f,
  9.31452960e-03f, 1.22292735e-01f, -7.51197860e-02f, -1.30533591e-01f, -7.21004531e-02f, -1.00259654e-01f, -8.63640308e-02f, -2.24923231e-02f, -2.57220138e-02f, -2.31236499e-03f,
  2.83007440e-03f, 1.89012550e-02f, 8.18676651e-02f, 2.60835793e-02f, 3.44700005e-04f, -5.85579872e-02f, -8.80605206e-02f, -1.02654286e-01f, -6.00486062e-02f, 3.11386157e-02f,
  -2.79857200e-02f, -2.63466244e-03f, -2.56949198e-02f, -2.38651726e-02f, -1.57030284e-01f, 7.19322935e-02f, 9.48754326e-02f, -1.26740217e-01f, -3.92286815e-02f, 8.32306296e-02f,
  -8.95533897e-03f, 1.00446917e-01f, -5.62272817e-02f, -5.95399402e-02f, -6.30398244e-02f, 5.90474643e-02f, 2.23949421e-02f, -7.42439851e-02f, -1.63747445e-02f, 2.80177314e-02f,
  2.29992568e-02f, 8.35650414e-02f, 1.73229817e-02f, 3.20872776e-02f, -3.16722086e-03f, 1.00154117e-01f, 2.28221621e-02f, 2.25702021e-02f, 1.77501759e-03f, -1.07510099e-02f,
  6.54938295e-02f, -5.13438089e-03f, 5.91896549e-02f, 5.81174418e-02f, 6.82180598e-02f, 2.17142012e-02f, 4.52546142e-02f, 5.68569526e-02f, -5.86528815e-02f, -6.27520084e-02f,
  2.46233881e-01f, 3.62613797e-01f, -2.82204300e-02f, -9.61063057e-02f, 5.72838746e-02f, -6.68648779e-02f, -2.74262931e-02f, 3.78116220e-02f, 2.66114082e-02f, -4.89755906e-02f,
  4.72322628e-02f, 3.11308801e-02f, -6.89573064e-02f, -1.19257243e-02f, -1.66384839e-02f, 1.19604953e-01f, -6.42687967e-03f, 4.20148410e-02f, 5.50838932e-02f, 1.74239688e-02f,
  8.42616633e-02f, 2.18947995e-02f, -4.39992640e-03f, -1.07052490e-01f, 7.61133851e-03f, 9.32645574e-02f, -8.90845954e-02f, 4.77876980e-04f, -7.54734427e-02f, 9.39330012e-02f,
  2.24149212e-01f, 2.95924544e-01f, 3.25339049e-01f, 4.78011161e-01f, -2.16527790e-01f, -2.52850235e-01f, -2.58690625e-01f, 2.54154075e-02f, -8.21222961e-02f, 1.20264038e-01f,
  -1.00263484e-01f, 2.83415824e-01f, -1.57816216e-01f, 1.32091790e-01f, -1.21058665e-01f, -2.95571297e-01f, -6.52824342e-02f, -1.05465308e-01f, -1.23176530e-01f, 2.50495195e-01f,
  9.17298123e-02f, -9.04011130e-02f, 2.53998488e-01f, 1.22344159e-02f, 2.17512652e-01f, 3.21520776e-01f, 2.72000372e-01f, 2.07587122e-03f, 3.22454065e-01f, -1.31990567e-01f,
  -6.60676658e-02f, -4.21709307e-02f, 1.60669133e-01f, -1.27224633e-02f, -3.45653109e-02f, 1.18729770e-01f, 6.34335577e-02f, -1.24668770e-01f, -1.19501539e-01f, 6.26081228e-02f,
  4.50358279e-02f, -7.18820021e-02f, -4.89504412e-02f, 3.06986682e-02f, -1.00467317e-01f, 2.70698927e-02f, 9.14209262e-02f, 8.36758018e-02f, 9.44309980e-02f, 1.75774395e-02f,
  1.73899114e-01f, 4.83618006e-02f, 2.28591617e-02f, 3.56983803e-02f, 9.46301743e-02f, -8.81199446e-03f, 1.71223376e-02f, 7.17798248e-02f, 5.10462783e-02f, -5.59524186e-02f,
  -6.61352500e-02f, -1.06859542e-01f, 2.29462842e-03f, -4.45928760e-02f, 4.80443500e-02f, -4.99047861e-02f, 5.37548251e-02f, -6.39337748e-02f, -4.85566631e-02f, 4.73875515e-02f,
  8.36043712e-03f, 4.09612022e-02f, -7.06871301e-02f, -3.19867656e-02f, -2.97814365e-02f, -3.23608629e-02f, 2.52970736e-02f, -7.13076591e-02f, 6.70284033e-02f, 7.49435872e-02f,
  -8.47999305e-02f, 6.67380914e-03f, 2.25843769e-02f, -8.06791261e-02f, -4.79840338e-02f, 4.33917567e-02f, -7.01253340e-02f, 6.68458864e-02f, 1.51226409e-02f, 2.93489844e-02f,
  -1.19543709e-01f, 6.50282502e-02f, 6.27702698e-02f, -9.78044197e-02f, -7.42999688e-02f, -3.57855521e-02f, 2.85394746e-03f, 1.01024561e-01f, 1.11716539e-01f, -1.01268388e-01f,
  9.40296426e-03f, -4.23461534e-02f, -3.17783095e-02f, 5.72241433e-02f, -5.92045039e-02f, 3.29139382e-02f, -2.86410544e-02f, 6.71187118e-02f, 3.42008360e-02f, 3.81846651e-02f,
  8.21170583e-02f, -1.00630343e-01f, -4.11060788e-02f, 2.15068739e-02f, -4.46183160e-02f, 7.24677071e-02f, -1.58779267e-02f, 1.37310531e-02f, -9.34821833e-03f, -6.58327267e-02f,
  1.03261583e-01f, -4.42000926e-01f, 5.88250011e-02f, -1.76682889e-01f, 1.60754189e-01f, -3.09067428e-01f, 1.08170986e-01f, -2.78029650e-01f, 5.74720651e-02f, -4.46004510e-01f,
  -3.40956450e-01f, 9.71217304e-02f, 8.23611096e-02f, -5.87594092e-01f, 4.40671176e-01f, 8.23870674e-02f, -4.17498708e-01f, -2.02718914e-01f, 2.38258481e-01f, -2.33355805e-01f,
  -3.21267210e-02f, -1.97441638e-01f, 1.23940594e-03f, -2.24982649e-02f, -7.30206072e-02f, 2.86724344e-02f, 1.14237722e-02f, 2.19237670e-01f, -3.72282118e-01f, 5.39578944e-02f,
  -3.69567759e-02f, -8.47478118e-03f, -1.66543424e-02f, -2.11505350e-02f, -7.88122416e-02f, 4.82304804e-02f, -3.90890874e-02f, 2.51015872e-01f, 7.02362210e-02f, 7.69152790e-02f,
  -2.29839366e-02f, 7.75364563e-02f, 1.72533821e-02f, 4.25824113e-02f, -1.50251873e-02f, 7.74604641e-03f, 3.96775454e-02f, 5.31668402e-02f, 4.42234799e-02f, 5.94751947e-02f,
  5.01118973e-03f, -2.93077566e-02f, -1.34153515e-01f, -1.24418966e-01f, -3.45757529e-02f, -3.10559142e-02f, 9.86810997e-02f, 1.06175095e-01f, -3.68312486e-02f, -3.88768874e-02f,
  -8.22464675e-02f, 3.43140997e-02f, -9.41943973e-02f, -1.30749077e-01f, -3.87866125e-02f, -1.17080629e-01f, -6.42283782e-02f, 2.06948817e-02f, 9.99899879e-02f, -2.10264195e-02f,
  -6.58171475e-02f, -1.91961124e-03f, 3.48025523e-02f, -2.37047840e-02f, -2.18285229e-02f, -5.33004552e-02f, -5.16742505e-02f, -7.54029006e-02f, 9.23810154e-03f, 5.56877209e-03f,
  4.77225743e-02f, -2.84920875e-02f, -7.73638785e-02f, -1.60484910e-02f, 6.68464601e-02f, 5.06395251e-02f, -3.97161394e-02f, -3.74486148e-02f, -1.68505237e-02f, 1.56246513e-01f,
  -1.85564429e-01f, -2.13952363e-01f, 1.01665482e-02f, -6.63539544e-02f, -3.56538477e-03f, -1.16996273e-01f, 5.00246650e-03f, -6.80619180e-02f, 6.02231845e-02f, -4.44926322e-02f,
  -4.93254140e-02f, -3.66445561e-03f, -6.61429986e-02f, 3.88020501e-02f, -6.40163710e-03f, -1.29687548e-01f, -5.21008335e-02f, -2.42936462e-02f, -4.22320813e-02f, -9.89525616e-02f,
  -1.03075117e-01f, -5.30926660e-02f, 1.46861345e-01f, 2.65740938e-02f, -2.66262628e-02f, -3.25198062e-02f, 1.24024547e-04f, -3.74688171e-02f, 1.38868347e-01f, -9.45847109e-02f,
  -6.21377051e-01f, 1.21989354e-01f, -1.70984954e-01f, -5.43121994e-01f, 2.09090896e-02f, -1.31360024e-01f, -2.31517673e-01f, 1.11520499e-01f, -5.44579588e-02f, 3.64577651e-01f,
  1.46177813e-01f, -2.69651353e-01f, 3.10188949e-01f, -4.56431150e-01f, -5.89825153e-01f, -2.30478212e-01f, -4.97721016e-01f, -3.14246297e-01f, -1.38474077e-01f, -1.07935764e-01f,
  -3.79449576e-01f, -7.73029327e-02f, -2.92417496e-01f, 3.24144363e-01f, -7.05842525e-02f, 6.02407381e-02f, 1.52061239e-01f, 2.90075034e-01f, -5.69804646e-02f, -2.70949099e-02f,
  -1.77812353e-02f, -8.15218082e-04f, -3.21682915e-02f, -1.89060196e-02f, -5.59277227e-03f, 1.27935246e-01f, -8.98841117e-03f, 8.87260959e-02f, -4.03957292e-02f, -6.54532528e-03f,
  -6.52271602e-03f, 3.24828289e-02f, -1.31616443e-01f, 5.80085516e-02f, -3.30274887e-02f, 6.21242216e-03f, -1.28342479e-01f, 3.01414486e-02f, 9.90645960e-02f, -2.74621192e-02f,
  -4.60343696e-02f, -1.04226479e-02f, -9.87437963e-02f, -1.01345614e-01f, -1.98507030e-02f, 4.03635763e-02f, -1.07962027e-01f, 3.63692865e-02f, 1.92948582e-03f, 4.27746885e-02f,
  1.01751070e-02f, -5.26262857e-02f, -1.40424315e-02f, -5.73014878e-02f, 2.02094242e-02f, 6.62645549e-02f, -5.03347963e-02f, -3.76150683e-02f, -8.35707784e-02f, 5.27859069e-02f,
  -4.65906449e-02f, -8.89030844e-02f, -2.01103948e-02f, -6.97723776e-02f, -7.26374835e-02f, -5.65073863e-02f, -4.49313745e-02f, 4.11684960e-02f, -6.88094199e-02f, -6.08905926e-02f,
  1.26952663e-01f, -8.65247250e-02f, 5.72160259e-02f, -6.90593710e-03f, 9.53617394e-02f, -1.35288937e-02f, 2.79745199e-02f, 9.51725896e-03f, -1.03998095e-01f, -1.24325184e-02f,
  1.53106719e-01f, 1.81005627e-01f, 5.05774021e-02f, 1.11584783e-01f, -7.72862113e-04f, -5.19357324e-02f, -1.03933021e-01f, -4.63939682e-02f, -1.46282092e-02f, -4.10048552e-02f,
  -1.22266011e-02f, -1.11003667e-01f, 6.31619543e-02f, -6.09906837e-02f, 2.96020377e-02f, 1.12318359e-02f, 2.83774175e-02f, 4.28664796e-02f, 3.86420190e-02f, 3.14691514e-02f,
  -8.53194448e-04f, 1.38140041e-02f, -4.01558094e-02f, 2.30091065e-02f, -7.69013017e-02f, 6.36735559e-02f, 6.04423769e-02f, -6.04087766e-03f, -2.34439895e-02f, 5.74127398e-02f,
  -2.61514664e-01f, 1.21435737e-02f, 4.27790582e-02f, -1.30854890e-01f, -1.90830007e-01f, 3.18408728e-01f, 2.03300372e-01f, -1.17070563e-01f, -2.34112605e-01f, -6.71083555e-02f,
  -1.63462222e-01f, -1.05395168e-02f, 2.64323473e-01f, -2.55023539e-01f, 3.31206322e-01f, 4.85782504e-01f, 5.13260141e-02f, 8.84291306e-02f, -1.00979723e-01f, -9.11312923e-02f,
  -4.45625633e-02f, -4.66904342e-02f, 2.76251435e-01f, -1.65997967e-01f, -1.51918679e-01f, -2.59466588e-01f, -1.04464181e-01f, -9.02861431e-02f, -2.39689484e-01f, -9.92856473e-02f,
  7.88728967e-02f, 4.67250980e-02f, 1.65169165e-01f, 2.38109916e-01f, 9.92530882e-02f, 1.03961572e-01f, 9.65673253e-02f, 1.18098415e-01f, -1.38742715e-01f, -2.62290775e-03f,
  -3.86227816e-02f, 1.31482899e-04f, -7.78875276e-02f, -4.93956022e-02f, -1.04258023e-01f, 1.85963474e-02f, -1.51257478e-02f, -2.91109495e-02f, 8.55801702e-02f, 5.53559624e-02f,
  -9.39870439e-03f, 7.93934390e-02f, -6.67192042e-02f, 1.87327396e-02f, -6.07552491e-02f, -5.19511104e-03f, 1.56026017e-02f, 1.53939456e-01f, 6.23314492e-02f, -3.20460759e-02f,
  -2.39626132e-02f, -7.04752430e-02f, 9.71378908e-02f, -7.97112510e-02f, -8.68022516e-02f, -6.37499020e-02f, 2.86474358e-03f, -1.98406130e-02f, -2.11225808e-01f, 1.50083546e-02f,
  -3.44112958e-03f, -3.43585014e-02f, 8.55465531e-02f, 8.42473004e-03f, -1.67237714e-01f, -9.91413370e-02f, 1.85712185e-02f, -3.09297480e-02f, -1.22363716e-01f, -5.07716760e-02f,
  4.28844728e-02f, -8.21751207e-02f, -6.28037453e-02f, 5.67333121e-03f, 4.99789044e-02f, 4.71426407e-03f, -8.34012255e-02f, 1.03665471e-01f, -1.34621114e-02f, 5.92926517e-03f,
  5.12286089e-02f, 1.15257584e-01f, 1.21919073e-01f, 1.81278989e-01f, 1.15755640e-01f, 8.90673883e-03f, 3.35062519e-02f, -7.30569661e-02f, -1.53744370e-01f, 3.68518941e-02f,
  -9.44259241e-02f, 3.87534574e-02f, -5.70517145e-02f, -8.48470330e-02f, -1.71777114e-01f, 1.90434344e-02f, 6.29248768e-02f, 1.18799945e-02f, -1.70778716e-03f, -1.28064618e-01f,
  4.22072411e-02f, -2.49796715e-02f, 3.29125784e-02f, 7.32399151e-03f, -1.01971440e-01f, -4.37879972e-02f, -6.69182763e-02f, 6.62586540e-02f, -6.04838133e-02f, 1.24311633e-01f,
  4.26034898e-01f, 5.25118530e-01f, 1.00475259e-01f, 2.36159071e-01f, -2.54718691e-01f, 1.11881532e-01f, 6.05421327e-02f, 8.74897242e-02f, -1.55262887e-01f, 1.29611641e-01f,
  -3.77125442e-02f, 3.21880490e-01f, 3.42618711e-02f, 2.37011880e-01f, 1.11994915e-01f, -8.40226710e-02f, 6.27706796e-02f, -8.48431364e-02f, -8.71801227e-02f, 4.08860296e-01f,
  8.39647800e-02f, 2.22026646e-01f, -4.40397672e-02f, 1.55235142e-01f, 2.90694028e-01f, 3.04252535e-01f, -1.66214649e-02f, -4.49870303e-02f, 2.12738961e-01f, 9.14255083e-02f,
  -9.16898903e-03f, 1.45730330e-02f, 6.16465546e-02f, 6.45445585e-02f, 8.81550238e-02f, -4.70608249e-02f, -1.71164870e-02f, 1.25985771e-01f, -8.92668292e-02f, -1.77318193e-02f,
  6.74603656e-02f, 5.87869547e-02f, 2.27850266e-02f, -1.19720042e-01f, -2.47337762e-02f, -9.04600993e-02f, -6.72967061e-02f, 7.77989551e-02f, -3.93359438e-02f, 1.12282820e-01f,
  -1.79441292e-02f, 6.62921509e-03f, -1.39921214e-02f, -1.77329674e-03f, 5.95921138e-03f, -8.46311226e-02f, -3.37900664e-03f, -1.49256596e-02f, -2.54764110e-02f, 1.85734749e-01f,
  7.17644617e-02f, -5.55346869e-02f, 5.30432537e-02f, -5.86350784e-02f, 1.39756843e-01f, -5.00656711e-03f, 6.77781180e-02f, -1.04970470e-01f, -6.82603493e-02f, -9.68413353e-02f,
  -7.67453760e-02f, -1.28077894e-01f, -6.12645745e-02f, -7.58741572e-02f, 4.34548371e-02f, 5.62316105e-02f, -2.43777819e-02f, -3.93075757e-02f, 3.22699770e-02f, -4.95333597e-02f,
  -1.23062372e-01f, 7.20173717e-02f, -1.79987587e-02f, 3.25990655e-02f, -6.28672838e-02f, -1.04225539e-01f, 5.75629920e-02f, 7.06019402e-02f, -8.28462988e-02f, 5.04415482e-02f,
  1.18760586e-01f, 3.25052828e-01f, 7.41469637e-02f, -1.60483662e-02f, 3.51786949e-02f, 1.30035460e-01f, -8.07026252e-02f, 2.21260965e-01f, 3.16911899e-02f, 7.75218606e-02f,
  -1.44443531e-02f, -6.02460057e-02f, 4.61828262e-02f, -2.96438225e-02f, -1.15306452e-01f, 1.28292874e-01f, 3.37281488e-02f, -2.42064521e-02f, 6.37690127e-02f, -1.44891245e-02f,
  -4.10742089e-02f, -8.26031119e-02f, 2.56911423e-02f, -5.81711605e-02f, 1.58710703e-02f, 6.68535158e-02f, 5.39283231e-02f, -7.93412700e-03f, -6.82878569e-02f, -6.69172779e-02f,
  6.43644869e-01f, -4.93048310e-01f, -4.83695954e-01f, 4.28357981e-02f, 4.71341819e-01f, 1.72451198e-01f, 9.29190442e-02f, -9.19919312e-02f, -5.84050752e-02f, -3.37949097e-02f,
  1.74906239e-01f, -5.33445664e-02f, -2.60016739e-01f, 3.99082333e-01f, 4.29288238e-01f, -1.26412496e-01f, 2.35258341e-01f, 8.69754255e-02f, -7.30223209e-02f, -7.01659694e-02f,
  2.00562522e-01f, 5.21669865e-01f, -3.21514569e-02f, 1.28860204e-02f, 2.34280586e-01f, -3.22140306e-01f, 3.97883616e-02f, -3.08366537e-01f, 2.31590897e-01f, 7.54711479e-02f,
  7.89723694e-02f, 1.02070011e-01f, 9.77403205e-03f, -1.11868642e-01f, -5.36397323e-02f, -2.83310656e-02f, -9.94624943e-02f, -5.15329950e-02f, -6.58191592e-02f, 3.72556932e-02f,
  -8.09181407e-02f, 8.14162120e-02f, 4.23587635e-02f, 7.76167139e-02f, 6.36200830e-02f, 1.84789170e-02f, 8.36479962e-02f, -5.11250272e-03f, -3.91822197e-02f, 4.17732969e-02f,
  -8.73511017e-05f, -2.28474867e-02f, 2.23302692e-02f, -1.13542609e-01f, -5.90994060e-02f, 7.28819966e-02f, -5.97403385e-02f, -9.82543677e-02f, 4.66268100e-02f, 8.93700570e-02f,
  4.57626060e-02f, -2.31512431e-02f, 1.26564922e-02f, 1.58547878e-01f, 2.63853353e-02f, 3.91644575e-02f, 8.77253115e-02f, -2.57816650e-02f, -5.09725809e-02f, 1.35737155e-02f,
  -6.01715362e-03f, 1.52978068e-02f, 2.35857572e-02f, 4.53779064e-02f, 9.03519690e-02f, -9.85703245e-03f, 7.77754635e-02f, 7.10694073e-03f, -6.98877722e-02f, 4.85276915e-02f,
  6.70596678e-03f, -8.53617117e-03f, 2.40383893e-02f, -8.16860050e-02f, 2.87241042e-02f, -5.76323904e-02f, 6.10801019e-02f, 1.64960232e-02f, -8.57083425e-02f, -5.93070909e-02f,
  -7.83179849e-02f, -2.74429679e-01f, -6.07401393e-02f, -9.38735809e-03f, -1.21158622e-01f, 1.03564598e-01f, -8.27352256e-02f, 2.44249813e-02f, -6.66296184e-02f, -2.62766145e-02f,
  4.19913046e-03f, -4.92746830e-02f, -1.06589802e-01f, -2.36004740e-02f, -1.09080292e-01f, 2.96186041e-02f, -4.54670712e-02f, -1.01125129e-01f, -4.73489277e-02f, 1.17347836e-01f,
  -2.23165918e-02f, -3.35631669e-02f, -1.37046993e-01f, -2.32788157e-02f, -1.90139655e-02f, -6.24151900e-02f, -3.15860100e-02f, -3.26973610e-02f, 3.39138657e-02f, 8.70665722e-03f,
  -6.83944821e-01f, 2.99351215e-01f, 5.83465509e-02f, 1.73950478e-01f, -1.05755240e-01f, 6.40620768e-01f, 5.88291466e-01f, 1.34642228e-01f, 4.43970263e-02f, 2.84546435e-01f,
  1.25347655e-02f, -1.78789601e-01f, 1.61215991e-01f, 2.29697287e-01f, 1.94008216e-01f, 2.85980642e-01f, 3.01365018e-01f, 2.74705172e-01f, -3.79144922e-02f, 1.67064033e-02f,
  -6.02190122e-02f, 2.45950863e-01f, 1.64242491e-01f, 4.38106852e-03f, 2.53371354e-02f, -3.18201631e-01f, 1.64870359e-02f, 7.60598183e-02f, 1.98810548e-02f, 1.00207515e-01f,
  -2.44456783e-01f, -1.43575758e-01f, -2.72703379e-01f, -3.10691874e-02f, -8.45296755e-02f, -4.17362293e-03f, -2.66095484e-03f, -2.95283110e-03f, -1.12760896e-02f, 4.40665781e-02f,
  -7.38037527e-02f, -1.00811400e-01f, -4.28581350e-02f, -6.18407018e-02f, 8.20235312e-02f, 3.81300342e-03f, -2.25103125e-02f, 5.15138870e-03f, 3.29987854e-02f, -9.62129831e-02f,
  3.50303128e-02f, -3.22984941e-02f, -5.00905029e-02f, 1.14253096e-01f, -9.96225514e-03f, 5.59412651e-02f, 7.18264878e-02f, -4.66638021e-02f, -7.29898922e-03f, -1.32536553e-02f,
  4.42981198e-02f, 1.07245602e-01f, 2.09761155e-03f, 7.07980618e-02f, 4.01680246e-02f, -5.32320254e-02f, 2.33653877e-02f, -8.19389671e-02f, -1.90497190e-02f, 1.92372373e-03f,
  -7.81581551e-03f, -2.27292161e-02f, -1.36903822e-01f, 4.65528928e-02f, 1.06214378e-02f, -6.51363209e-02f, 6.05365112e-02f, -1.66370126e-03f, 2.02287529e-02f, -8.00543800e-02f,
  4.99157049e-02f, -4.61679064e-02f, 3.95759381e-02f, -6.37941882e-02f, -4.83577996e-02f, 9.84167606e-02f, -1.73761155e-02f, -5.15540987e-02f, 5.09671420e-02f, -2.91336253e-02f,
  3.38440031e-01f, 2.57047266e-01f, -3.38627473e-02f, -1.09309673e-01f, -7.13413069e-03f, 3.91816720e-02f, 4.63877991e-02f, -1.01108819e-01f, 1.97973117e-01f, 1.18796192e-02f,
  6.52580485e-02f, 2.04145741e-02f, 6.70966879e-02f, 5.71966246e-02f, -3.01768985e-02f, -1.87373944e-02f, 9.41919759e-02f, 1.09124146e-01f, 3.80260050e-02f, -7.00322585e-03f,
  -1.37090415e-01f, 1.99715309e-02f, -6.12865575e-02f, -3.65614891e-02f, 1.30413575e-02f, -1.43851966e-01f, -1.42947445e-03f, -2.16076449e-02f, -5.07491790e-02f, -6.53285086e-02f,
  -7.09026456e-01f, 1.29130259e-01f, -2.46455610e-01f, -3.16006154e-01f, -1.18061952e-01f, -4.01058763e-01f, -4.28191781e-01f, -3.13479220e-03f, -1.32308099e-02f, 1.46341994e-01f,
  -4.63511832e-02f, -1.90321952e-02f, 2.93026417e-01f, 1.93119962e-02f, -1.53225020e-01f, 3.40292931e-01f, -1.16914362e-01f, -1.42883241e-01f, 1.27364874e-01f, -2.87094086e-01f,
  -3.65901515e-02f, -1.19091459e-01f, 2.61127446e-02f, 1.57921880e-01f, -4.01167661e-01f, -1.63904950e-01f, -4.05561104e-02f, -8.42637643e-02f, -1.51938543e-01f, -6.85077831e-02f,
  -4.40363824e-01f, -2.63205737e-01f, -2.73564577e-01f, -7.77063072e-02f, -1.70599490e-01f, -1.45269439e-01f, -2.46344969e-01f, -9.50003974e-03f, -1.35117739e-01f, 6.22035526e-02f,
  -9.33041573e-02f, 5.41779958e-02f, -7.31430650e-02f, 2.02613305e-02f, -7.45638013e-02f, -3.76587473e-02f, 3.05072647e-02f, -7.34743327e-02f, 6.50497526e-02f, 1.27625152e-01f,
  6.27927333e-02f, 5.88733405e-02f, -1.51481047e-01f, 1.45748541e-01f, -3.92250083e-02f, -4.74068560e-02f, 2.29566135e-02f, -4.46254797e-02f, -1.03319928e-01f, -1.30792171e-01f,
  6.25349507e-02f, -8.78092498e-02f, 5.42892255e-02f, 1.56454314e-02f, -1.99262034e-02f, 7.23095669e-04f, -4.41904627e-02f, 4.83113676e-02f, -2.25829668e-02f, 3.17493901e-02f,
  6.63921535e-02f, 8.12575147e-02f, 1.90795045e-02f, -8.70283619e-02f, 1.03773184e-01f, 1.45028960e-02f, 8.06914642e-03f, -3.59142683e-02f, 8.12191367e-02f, -8.50012749e-02f,
  -5.89020252e-02f, -4.23720628e-02f, 1.23893179e-01f, 3.84475701e-02f, -2.82658562e-02f, 6.93059191e-02f, -3.71471792e-02f, 6.15482265e-03f, -4.34250720e-02f, -8.59147236e-02f,
  -5.47089458e-01f, -3.96606177e-01f, -3.93540636e-02f, -1.39507791e-02f, -5.04521988e-02f, -1.42009571e-01f, 1.94022637e-02f, 3.25006098e-02f, -5.60456887e-02f, -1.09012492e-01f,
  -1.87965501e-02f, 3.13161116e-04f, -1.05057523e-01f, 5.43938689e-02f, 1.28853545e-01f, -1.20214717e-02f, -9.10301656e-02f, 3.26668359e-02f, -9.26373079e-02f, -4.73625697e-02f,
  -6.00742884e-02f, -4.38428745e-02f, 5.17743900e-02f, 8.60413760e-02f, -5.50233340e-03f, -4.93961535e-02f, -1.26619220e-01f, 3.82638350e-02f, -7.22419322e-02f, 3.03329900e-02f,
  -1.55749545e-01f, 1.84668660e-01f, 7.57213295e-01f, 6.21266328e-02f, 2.45365500e-01f, 6.01717651e-01f, 3.11465085e-01f, 1.92721054e-01f, 2.25319073e-01f, -3.08257997e-01f,
  -4.16190296e-01f, 1.69993594e-01f, -8.69769976e-02f, -3.73765416e-02f, 6.34884164e-02f, 1.36058539e-01f, 6.88646287e-02f, -2.37877965e-02f, 1.66529521e-01f, -3.49047072e-02f,
  1.33174405e-01f, -1.66279972e-01f, 3.40047151e-01f, -1.65510505e-01f, 1.56214207e-01f, -4.92292158e-02f, -4.95680213e-01f, 2.41382137e-01f, -2.96276689e-01f, 5.56345806e-02f,
  -3.79509091e-01f, -1.62565693e-01f, -4.49105501e-02f, -1.39978305e-02f, 2.66432893e-02f, -5.30070625e-02f, -4.90475781e-02f, -2.87256986e-02f, -1.02384202e-01f, -7.99382851e-03f,
  6.29605502e-02f, 1.66262984e-01f, 3.91006619e-02f, 1.04961850e-01f, 8.21505114e-02f, 1.54443920e-01f, 2.46750385e-01f, 1.11816698e-04f, 9.60828513e-02f, 2.65767068e-01f,
  1.39146790e-01f, 6.51521757e-02f, 1.52846634e-01f, -1.25223503e-01f, -3.43157910e-02f, -6.66106194e-02f, 1.03794485e-01f, 1.42086605e-02f, -2.69011501e-02f, -4.89937402e-02f,
  -7.91933388e-02f, 1.14331886e-01f, 3.86560895e-02f, 3.01375929e-02f, 4.93945815e-02f, -6.89098015e-02f, -2.72546262e-02f, -8.70375559e-02f, 2.32608691e-02f, -1.22491466e-02f,
  6.21949807e-02f, 6.13242909e-02f, -6.88955933e-02f, 7.02283382e-02f, 5.43292761e-02f, -2.64728954e-03f, -4.86011617e-02f, -4.38433811e-02f, -1.43880649e-02f, -2.05954034e-02f,
  -1.49099100e-02f, -8.45088884e-02f, 4.58033197e-02f, -1.22481715e-02f, -1.72612574e-02f, 4.54500653e-02f, -4.58985269e-02f, 1.23046562e-01f, 1.88147614e-03f, -8.07522535e-02f,
  -2.75007069e-01f, -3.45673680e-01f, -1.04357339e-01f, -7.92781636e-02f, -9.56880152e-02f, -5.03640100e-02f, -5.02755605e-02f, 4.27828059e-02f, 1.13065168e-02f, -7.57751986e-02f,
  1.56164439e-02f, -6.22010753e-02f, -1.24091238e-01f, -2.40947735e-02f, -2.07008217e-02f, 1.37087265e-02f, -7.63072520e-02f, -7.08357543e-02f, -7.09325001e-02f, -9.90949348e-02f,
  -3.50325368e-02f, -8.68502110e-02f, -1.46702677e-02f, -1.80678871e-02f, -4.24999148e-02f, -2.87502185e-02f, -6.82008341e-02f, -2.89990138e-02f, -8.74105915e-02f, -3.68466973e-02f,
  -1.41242653e-01f, -2.80001044e-01f, -1.30627096e-01f, -1.34833843e-01f, -2.71185696e-01f, -2.47294396e-01f, 1.96528047e-01f, -3.42217863e-01f, -2.41964087e-01f, 1.42622739e-01f,
  2.74728328e-01f, 9.73579139e-02f, 4.38816100e-01f, 1.77692994e-02f, 2.20642969e-01f, 2.01750562e-01f, -9.93823633e-02f, 9.18031782e-02f, -2.41764575e-01f, -2.81260341e-01f,
  -9.83654633e-02f, -1.06588446e-01f, 2.18198806e-01f, -3.78277600e-01f, -5.37533723e-02f, -1.43758476e-01f, 2.21574530e-01f, -4.48852107e-02f, -4.84423805e-03f, 1.02575883e-01f,
  -2.43969768e-01f, -3.11610252e-01f, -5.95682897e-02f, -2.99087595e-02f, -3.56734022e-02f, 1.56010743e-02f, 8.33235681e-02f, 1.41470522e-01f, -6.45759627e-02f, -9.75771472e-02f,
  1.58332244e-01f, -3.04630380e-02f, -1.03518099e-01f, -6.47265138e-03f, -3.88529710e-02f, -5.12562171e-02f, 1.72507372e-02f, -6.45244643e-02f, -1.34177163e-01f, 3.40710320e-02f,
  7.70309120e-02f, -8.25416744e-02f, 6.47320226e-02f, -3.88969630e-02f, 1.06408961e-01f, -5.87038919e-02f, -2.98823114e-03f, 4.92585562e-02f, -9.43992883e-02f, -1.73830822e-01f,
  8.87617469e-02f, -3.84934321e-02f, 4.50040139e-02f, 5.55093912e-03f, 3.02826501e-02f, 6.92595541e-02f, 6.93845376e-02f, 1.34353757e-01f, -6.61999434e-02f, 7.08041787e-02f,
  -2.87854094e-02f, -3.51292524e-03f, 1.62775666e-02f, 3.08463015e-02f, 4.11312468e-02f, 9.41589996e-02f, 7.85228014e-02f, -4.85467762e-02f, 6.28544688e-02f, -1.17749497e-02f,
  -3.01069543e-02f, 5.86654916e-02f, 1.20016083e-01f, 8.29593912e-02f, -6.22513285e-03f, 3.77688520e-02f, -6.21124730e-02f, 1.57949468e-03f, -5.45863137e-02f, 4.44208644e-02f,
  -4.80535775e-01f, -3.59920859e-01f, -5.92952631e-02f, 4.06709779e-03f, -2.13119853e-02f, -1.16558243e-02f, -5.58161661e-02f, -1.24836512e-01f, -9.46798548e-02f, -7.45290518e-02f,
  -2.65005268e-02f, 8.20569247e-02f, 3.54363658e-02f, 3.21042426e-02f, 8.07899460e-02f, 6.54456988e-02f, -5.35375215e-02f, 7.58758979e-03f, -5.91270141e-02f, 3.13412547e-02f,
  5.93890846e-02f, 1.00655086e-01f, 6.74897060e-02f, -6.42914772e-02f, 3.64854448e-02f, 7.12923780e-02f, -1.40407354e-01f, 5.20609878e-02f, -2.33087260e-02f, 5.95528670e-02f,
  -1.43443391e-01f, -1.13842197e-01f, -3.69794369e-01f, -1.04714617e-01f, 3.29450160e-01f, 9.68232676e-02f, -1.05806604e-01f, 1.21090405e-01f, -4.60044116e-01f, 1.42488256e-01f,
  1.05057351e-01f, -2.73981333e-01f, -2.74962872e-01f, -1.19041517e-01f, -1.91556662e-02f, -4.31579441e-01f, 1.79056287e-01f, 2.56225765e-02f, -2.59114623e-01f, 1.46739170e-01f,
  -5.37333488e-02f, 3.42192829e-01f, -2.18328927e-03f, 4.15039599e-01f, 6.94961995e-02f, 1.29533276e-01f, 4.89137113e-01f, 3.87701876e-02f, 2.38481537e-01f, 1.74346074e-01f,
  -5.79881258e-02f, -2.55803853e-01f, -3.84224802e-02f, 4.47094515e-02f, 1.04461253e-01f, 2.10449219e-01f, 9.61709246e-02f, 7.66178742e-02f, 2.36550961e-02f, -8.26567933e-02f,
  8.84165838e-02f, 2.16308590e-02f, -5.74992970e-03f, 1.32517777e-02f, 7.04976171e-02f, 3.58379749e-03f, -1.89243704e-01f, -5.86218983e-02f, -1.28526255e-01f, -2.21372798e-01f,
  -1.45658195e-01f, 9.37529549e-04f, 4.11505960e-02f, 8.17079842e-02f, -1.86202064e-01f, -6.87579289e-02f, -3.10937222e-03f, -8.48405734e-02f, -2.38014315e-03f, -4.29060385e-02f,
  1.16657548e-01f, 8.28449056e-03f, -2.20640860e-02f, -1.26941100e-01f, -3.15111727e-02f, -6.47308230e-02f, -1.21134087e-01f, 7.89606012e-03f, -3.46318707e-02f, -2.59777121e-02f,
  8.48926008e-02f, 1.00489989e-01f, -6.45344704e-02f, 7.86498562e-02f, 5.80411032e-02f, -4.32083644e-02f, 2.84916554e-02f, 6.87213195e-03f, 7.90881962e-02f, -1.15486182e-01f,
  2.51777098e-02f, 5.03670275e-02f, 5.91262951e-02f, 8.51066709e-02f, -4.11532894e-02f, 5.46353795e-02f, -2.25054263e-03f, -8.89589936e-02f, -3.15364450e-02f, 2.36283187e-02f,
  5.98804392e-02f, 1.00518458e-01f, 8.88656173e-03f, -2.79306620e-02f, -4.13541086e-02f, 1.63019244e-02f, -5.99970594e-02f, 2.46391091e-02f, 1.38042703e-01f, -7.35855103e-02f,
  2.08187312e-01f, 1.62171409e-01f, 6.90765157e-02f, -1.21304309e-02f, 9.17500928e-02f, 2.28033625e-02f, -9.76964831e-03f, 1.05300926e-01f, 1.75777987e-01f, 4.29594703e-03f,
  1.58579096e-01f, 5.88439107e-02f, 1.84689425e-02f, -8.31496418e-02f, 1.49393871e-01f, 1.19692460e-02f, 3.66061591e-02f, 1.30959213e-01f, -7.48339593e-02f, -1.43808141e-01f,
  1.66964039e-01f, 4.13398743e-01f, 3.07509065e-01f, 7.94989988e-02f, -1.34052679e-01f, 2.54389971e-01f, 9.91898328e-02f, 3.19389030e-02f, 2.69796878e-01f, 1.57681838e-01f,
  -2.66521245e-01f, 3.27222615e-01f, 2.46601515e-02f, -1.48812503e-01f, -1.37796640e-01f, -5.95766567e-02f, 1.14939325e-01f, 9.85696986e-02f, 3.97162214e-02f, -1.75603867e-01f,
  -1.57562464e-01f, -2.71213323e-01f, -3.42854619e-01f, -2.83428222e-01f, -1.33969918e-01f, 5.07819280e-03f, -4.22752738e-01f, -1.96891680e-01f, -1.20518818e-01f, 6.36547133e-02f,
  -1.45327985e-01f, -3.02620512e-02f, -3.38658057e-02f, 1.81696862e-01f, 1.40496390e-02f, 9.00634974e-02f, 1.13053189e-03f, -1.23043424e-02f, 6.56049177e-02f, 1.33798327e-02f,
  8.11125562e-02f, 1.31267989e-02f, 7.81131014e-02f, 3.41931335e-03f, 2.81862002e-02f, 1.17853964e-02f, 7.23170713e-02f, 6.01958334e-02f, 4.38573286e-02f, 1.30238142e-02f,
  2.67546978e-02f, 2.14349404e-02f, -2.73280889e-02f, 4.31151018e-02f, -4.79627252e-02f, 2.70469543e-02f, 9.87476036e-02f, 3.02684903e-02f, 1.25865221e-01f, 8.25105608e-02f,
  1.71258405e-01f, -5.72132552e-03f, -2.92374417e-02f, -9.12070274e-02f, -8.47812891e-02f, -2.91465353e-02f, 1.66682247e-02f, -9.58567858e-02f, 1.33348405e-01f, -1.29696667e-01f,
  -2.88621173e-03f, -1.06262043e-02f, 6.67690560e-02f, 4.53928635e-02f, -3.74836358e-03f, -7.85558224e-02f, 5.64894341e-02f, -3.22879888e-02f, 8.36048275e-02f, -4.53990102e-02f,
  4.95838933e-02f, 6.97655901e-02f, -1.07153729e-01f, 1.37292722e-03f, 1.63210884e-01f, -5.22769243e-02f, -2.33677216e-02f, 4.99160960e-02f, -1.11372694e-01f, 1.02690443e-01f,
  1.44854352e-01f, 1.81192100e-01f, 5.36058992e-02f, 4.36157174e-02f, -2.63985805e-02f, 7.55100548e-02f, 8.21696371e-02f, 7.26641715e-02f, 2.86841523e-02f, 3.45102847e-02f,
  1.16961189e-01f, -5.01293782e-03f, -4.44115438e-02f, -7.64427260e-02f, 5.72345145e-02f, -5.03867120e-02f, -7.59707764e-04f, 4.59176078e-02f, 2.58022454e-02f, -3.26234438e-02f,
  -9.17593539e-02f, -6.80907071e-03f, 8.81225616e-03f, -6.86229244e-02f, -9.19405837e-03f, -5.05650192e-02f, -1.99249536e-02f, 9.70237255e-02f, 1.03283554e-01f, 2.75911530e-04f,
  -4.25996721e-01f, -4.71644178e-02f, 1.51506856e-01f, 4.58276272e-01f, -8.10026526e-02f, -4.81032938e-01f, -4.89832759e-01f, 5.07610254e-02f, -1.83544815e-01f, -3.25258315e-01f,
  -2.65694335e-02f, -2.15220824e-02f, -3.70151311e-01f, 3.41965050e-01f, 4.70970452e-01f, 6.37630224e-02f, 4.71367270e-01f, 6.22914769e-02f, 1.66474760e-01f, 1.29591435e-01f,
  4.50127900e-01f, 4.25984144e-01f, 4.73949432e-01f, 4.66863155e-01f, 2.33893041e-02f, 1.45813286e-01f, 3.95367175e-01f, -9.07430425e-02f, 4.35779363e-01f, 1.95233196e-01f,
  -1.13616541e-01f, 4.31311578e-02f, 2.70602833e-02f, -3.42287570e-02f, -6.65532425e-02f, -1.50417969e-01f, -9.57584679e-02f, -8.33934080e-03f, 2.43255105e-02f, 3.38435322e-02f,
  -1.64583057e-01f, 9.75667387e-02f, 1.50948346e-01f, -1.87822077e-02f, -1.53857470e-01f, 7.24915639e-02f, 7.70913586e-02f, -7.14293271e-02f, -6.61631301e-03f, -7.82709271e-02f,
  -3.86580005e-02f, -7.43162856e-02f, -1.41625460e-02f, -6.53515980e-02f, 9.65146124e-02f, 9.69645679e-02f, -1.80724468e-02f, -5.83642609e-02f, 1.35283386e-02f, -3.12453834e-03f,
  -5.63953221e-02f, -2.09449232e-02f, -7.76123852e-02f, -3.44061926e-02f, 4.37005945e-02f, 1.71889979e-02f, 3.98165658e-02f, -3.98189835e-02f, 4.72570099e-02f, 4.56885621e-02f,
  -6.27971813e-02f, -7.75043145e-02f, 3.99489328e-02f, -3.93634699e-02f, 6.82443529e-02f, -1.21604756e-01f, -1.14591112e-02f, -1.09018143e-02f, 1.57792289e-02f, 2.92359237e-02f,
  -1.02920935e-03f, 9.22196209e-02f, -2.66969427e-02f, 4.46551666e-02f, 8.07583705e-02f, 9.55699664e-03f, 8.46348330e-02f, -2.85907481e-02f, -3.69812585e-02f, 8.13679844e-02f,
  -3.13377567e-02f, 2.60706574e-01f, -1.93749983e-02f, -2.74433810e-02f, 1.18410334e-01f, -1.09010898e-02f, 8.90358165e-02f, 2.91952444e-03f, 1.23028718e-01f, -9.30837393e-02f,
  4.95366938e-02f, -9.86419320e-02f, -6.63248776e-03f, 5.52147999e-02f, 1.54009104e-01f, 3.53496196e-03f, 4.14047167e-02f, 2.44990084e-03f, 8.36664587e-02f, 1.45728528e-01f,
  -8.13800618e-02f, -1.76209494e-01f, 1.37102010e-03f, -2.22770702e-02f, 1.22745475e-02f, -1.41324148e-01f, 3.59717384e-02f, 1.68142766e-02f, 1.45443678e-01f, 1.28140878e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.78176337e-01f, 2.47080519e-04f, 3.83375943e-01f, 1.78367645e-01f, 4.25327331e-01f, 2.26883560e-01f, 5.30182481e-01f, 4.19380009e-01f, 2.60244429e-01f, 8.21128845e-01f,
  1.09085560e-01f, 3.40582252e-01f, 1.07117265e-01f, -1.53293216e-03f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.21057890e-01f, -1.74462438e-01f, -5.71458161e-01f, 1.39744475e-01f, -1.21921383e-01f, 1.77662358e-01f, -1.77533194e-01f, -2.63574421e-01f, -2.47584522e-01f, -2.98973590e-01f,
  -2.40707144e-01f, 1.16211800e-02f, -1.18533254e-03f, 1.88816816e-01f, -1.83028668e-01f, 4.43520367e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.60849965e-01f, -6.63693011e-01f, 8.04839469e-03f, 4.55060661e-01f, 1.80780232e-01f, 3.38212401e-01f, 1.47471443e-01f, 2.47960418e-01f, 4.41392213e-01f, -3.74393463e-02f,
  -3.33103418e-01f, 5.26744783e-01f, -1.99276611e-01f, 4.88121361e-01f, 2.34707087e-01f, -2.87685301e-02f, -5.79119399e-02f, 6.10984087e-01f, 2.11703733e-01f, -2.59615272e-01f,
  1.88703537e-01f, 8.99036705e-01f, 3.43418568e-01f, -8.35292712e-02f, 1.31668895e-01f, 4.44286674e-01f, 6.45448327e-01f, 3.82027440e-02f, 2.56809175e-01f, 1.20389804e-01f,
  -2.17381030e-01f, 7.05998302e-01f, 4.94982332e-01f, 3.48398685e-01f, 2.58892745e-01f, 2.44071677e-01f, 6.77357391e-02f, -1.24543317e-01f, 5.55419445e-01f, 2.47750640e-01f,
  -4.59571838e-01f, 4.01932538e-01f, 3.73254120e-01f, 6.19351327e-01f, 1.73306867e-01f, -2.86153853e-01f, 5.87294757e-01f, 1.47733778e-01f, 4.31139693e-02f, 6.26537204e-01f,
  2.67643392e-01f, -2.82113999e-01f, 3.62780720e-01f, 6.68736160e-01f, 4.92767572e-01f, 3.16090249e-02f, -4.50066477e-02f, 6.58259988e-01f, 7.33130991e-01f, 3.08103561e-02f,
  5.81139565e-01f, 4.57946301e-01f, -2.58652210e-01f, 7.65209615e-01f, 6.00885786e-02f, -1.57912448e-01f, 6.74343348e-01f, 3.02096784e-01f, -5.26059508e-01f, -4.57325011e-01f,
  1.65837482e-01f, 3.03905010e-01f, -6.76313117e-02f, 3.82059455e-01f, 2.81360239e-01f, -9.51969624e-02f, 4.79712673e-02f, 1.30019918e-01f, 3.99116784e-01f, 5.36433339e-01f,
  -2.15555981e-01f, -6.23733178e-02f, -3.84363197e-02f, 9.32979211e-02f, 5.26117742e-01f, 3.02474380e-01f, 1.54262796e-01f, -1.81398153e-01f, 2.26395965e-01f, -3.79694432e-01f,
  4.08342570e-01f, -5.02544403e-01f, -1.56930555e-02f, -3.87745857e-01f, 5.26556484e-02f, -4.30517830e-02f, 4.66052353e-01f, 2.97577769e-01f, 3.40095103e-01f, -6.56595975e-02f,
  5.82383454e-01f, -3.12895596e-01f, 4.75559980e-01f, 4.06097651e-01f, -2.43609279e-01f, 6.77553535e-01f, 1.43565729e-01f, 3.12645257e-01f, 7.80214131e-01f, -1.94389194e-01f,
  2.01465130e-01f, -1.69674382e-01f, 1.05493888e-01f, 5.08198082e-01f, -2.45888963e-01f, 5.66043496e-01f, -1.33208737e-01f, 5.67623436e-01f, -1.52113438e-01f, 1.22196920e-01f,
  -4.23831075e-01f, -3.46793890e-01f, 1.00936219e-01f, 3.07550937e-01f, -2.10209310e-01f, 6.77991152e-01f, 2.90534586e-01f, -2.93291628e-01f, 1.71920255e-01f, -5.99276543e-01f,
  2.92306960e-01f, 2.97981381e-01f, -8.51472318e-02f, -2.66067415e-01f, -4.44841484e-04f, 5.28616965e-01f, 7.02602804e-01f, 1.69942960e-01f, -2.08496794e-01f, -9.74063948e-02f,
  -4.40349340e-01f, 9.95770335e-01f, 2.81443596e-01f, 4.36173081e-01f, 1.23023771e-01f, 5.80586679e-02f, 6.22547269e-01f, 6.15220785e-01f, -5.53538799e-01f, -8.74455497e-02f,
  3.73258680e-01f, 5.03118038e-01f, -2.81704962e-01f, 3.02572221e-01f, 3.72120023e-01f, 2.92072799e-02f, -2.06427082e-01f, 4.36666816e-01f, 3.00724894e-01f, 6.44700170e-01f,
  2.47325554e-01f, -3.51614416e-01f, -2.90242314e-01f, -2.81644672e-01f, 5.71994066e-01f, 4.28830236e-01f, 2.09799454e-01f, -3.32471669e-01f, 9.02070880e-01f, -4.89861369e-02f,
  3.54994148e-01f, 1.50284559e-01f, 1.57202810e-01f, 4.60965425e-01f, -3.08668286e-01f, 7.49254748e-02f, 3.28302234e-01f, -4.05444026e-01f, 1.79769978e-01f, 6.99445486e-01f,
  -8.96549076e-02f, -3.86161625e-01f, 2.56349623e-01f, 3.02017331e-01f, 1.68407112e-02f, 4.16963369e-01f, 1.30700603e-01f, 8.32619667e-01f, -3.03701311e-01f, -3.44024211e-01f,
  5.97439468e-01f, 5.95522046e-01f, -3.65330577e-01f, 4.12680477e-01f, -2.05607861e-01f, -8.06082189e-01f, -2.94759452e-01f, 1.89629838e-01f, -1.77011490e-01f, 1.70635819e-01f,
  -2.17329919e-01f, -1.17336735e-01f, 3.20409447e-01f, 4.70209122e-01f, -1.85685098e-01f, -1.38349488e-01f, -1.48700133e-01f, 2.22970694e-01f, -1.37743140e-02f, -2.44646832e-01f,
  2.11785749e-01f, -4.69491333e-01f, 3.69351268e-01f, -5.92393816e-01f, -3.31098251e-02f, 4.23448086e-01f, 4.81412232e-01f, 2.64207900e-01f, -3.87683243e-01f, 3.58307697e-02f,
  3.89787018e-01f, 2.78528214e-01f, 1.02709785e-01f, -2.55544543e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  6.88589036e-01f, 1.88220531e-01f, 3.31506580e-01f, 1.92068070e-01f, -5.00190333e-02f, -2.73708582e-01f, 6.82819039e-02f, 5.17997444e-01f, 3.70616525e-01f, 2.54657269e-01f,
  5.93375444e-01f, 5.29485822e-01f, -8.94341469e-02f, 2.71853477e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.59875816e-02f, 3.99836928e-01f, 1.48252860e-01f, 8.45208243e-02f, -1.44451901e-01f, -1.49426788e-01f, 1.77472960e-02f, -5.07728517e-01f, -2.67717421e-01f, 3.53181571e-01f,
  -5.00968620e-02f, -9.96887684e-02f, 2.36562967e-01f, 3.97281080e-01f, 6.36082411e-01f, -6.04460835e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.60259724e-01f, -6.17355946e-03f, -2.62033790e-01f, -2.30041280e-01f, 1.39815629e-01f, 2.19755590e-01f, -2.17251122e-01f, 1.38896868e-01f, -2.56848246e-01f, -1.09280884e-01f,
  1.09630980e-01f, -2.02695832e-01f, -1.79878876e-01f, 1.75277948e-01f, -4.79079895e-02f, -1.47161618e-01f, -4.31530327e-01f, -1.10128537e-01f, -1.03242882e-01f, 5.89639843e-01f,
  4.21951301e-02f, 5.26585400e-01f, 2.29033515e-01f, 3.97597134e-01f, 5.99579334e-01f, -3.41347575e-01f, -3.79733622e-01f, 1.19663477e-01f, 1.49054587e-01f, -7.33840987e-02f,
  -1.06322996e-01f, 2.10467786e-01f, -1.67074487e-01f, 2.88243946e-02f, 1.01441927e-01f, 1.61284044e-01f, -2.37952083e-01f, -1.61499530e-01f, 2.42961377e-01f, 8.91962349e-02f,
  1.36509567e-01f, -1.59049898e-01f, -1.87781319e-01f, -1.95733696e-01f, -2.03994334e-01f, -1.93433136e-01f, 8.26532543e-02f, -1.13231838e-02f, -3.00133526e-01f, 7.08732665e-01f,
  9.58937630e-02f, 3.62723917e-02f, -1.85036436e-01f, 1.85007960e-01f, 5.29241323e-01f, -1.32547200e-01f, -2.10436553e-01f, -6.15515888e-01f, 8.54929864e-01f, 9.16609243e-02f,
  7.54081011e-01f, 4.88022044e-02f, -1.09951138e+00f, 5.25192201e-01f, 8.64271462e-01f, 2.91596025e-01f, 6.59384429e-01f, 2.73238197e-02f, 1.94063723e-01f, 3.76184508e-02f,
  -4.85722601e-01f, -6.57167315e-01f, -1.68220818e-01f, 9.85316753e-01f, -1.79916710e-01f, -1.07620187e-01f, 3.65697920e-01f, 4.19148952e-01f, 1.22128499e+00f, -3.51982296e-01f,
  1.65101469e-01f, 4.99750637e-02f, 3.32499713e-01f, 7.12644756e-01f, -1.42543599e-01f, 4.64302301e-01f, -3.10248405e-01f, 6.12813830e-01f, 3.38179655e-02f, 2.46477827e-01f,
  1.30476549e-01f, -2.93385535e-01f, 9.21459258e-01f, -3.61136764e-01f, 5.03922880e-01f, 4.50152636e-01f, -2.94087738e-01f, -2.19026320e-02f, 2.57303417e-01f, -6.83058500e-02f,
  5.44675052e-01f, 1.83475798e-03f, 7.51585245e-01f, -5.15057862e-01f, 1.47850707e-01f, 7.93641284e-02f, 6.68842733e-01f, 7.61083126e-01f, -6.07307911e-01f, 6.79160416e-01f,
  -3.75777304e-01f, 1.66627411e-02f, 1.14113823e-01f, 7.81163812e-01f, 3.43173295e-01f, 5.96342087e-01f, -1.53113976e-01f, 5.26227176e-01f, -1.67679284e-02f, -4.89418328e-01f,
  -5.48178017e-01f, 7.34896481e-01f, 4.75019097e-01f, 4.06754494e-01f, -4.40597124e-02f, 3.83774601e-02f, 4.59478617e-01f, -4.81582016e-01f, 1.43010390e-03f, -7.45181620e-01f,
  -1.72905967e-01f, 3.66045982e-01f, 3.20920199e-01f, 4.16580200e-01f, -2.18124632e-02f, 6.32338285e-01f, 7.34413266e-01f, -4.16594028e-01f, -8.40481371e-02f, -3.75175849e-02f,
  1.04601420e-01f, 4.09473240e-01f, 1.49729684e-01f, 1.97399884e-01f, 2.87701011e-01f, 6.60445355e-03f, 6.71438694e-01f, 2.84799725e-01f, -5.71658611e-02f, 1.67214170e-01f,
  7.17459992e-02f, -8.55159597e-04f, -2.42929354e-01f, 4.09438103e-01f, 4.92602289e-01f, 3.54253560e-01f, 6.78661048e-01f, 5.55589795e-01f, 1.19343472e+00f, 9.62034166e-02f,
  2.21565709e-01f, -8.58655930e-01f, 3.51563781e-01f, -1.64212868e-01f, 8.29449236e-01f, -1.36734203e-01f, 3.93210620e-01f, -6.82256401e-01f, 6.68845773e-01f, 5.47877997e-02f,
  1.06704623e-01f, 3.97552043e-01f, -4.00187284e-01f, 7.18939543e-01f, 3.07611704e-01f, 3.04403484e-01f, -4.78801966e-01f, 1.84369057e-01f, -2.01901421e-01f, 3.67720872e-01f,
  4.11095798e-01f, 5.20421743e-01f, 5.60039580e-01f, 7.12007165e-01f, 1.54579163e-01f, -1.31504714e-01f, 1.36490286e-04f, 6.96240127e-01f, -1.55993119e-01f, -1.03780385e-02f,
  -1.63202494e-01f, -2.61278421e-01f, 1.84024423e-01f, -6.84317768e-01f, 6.50515258e-01f, -3.26635957e-01f, 1.77884027e-01f, -6.24222867e-02f, -2.10269704e-01f, -3.14349798e-03f,
  6.36322200e-01f, -3.66491407e-01f, 3.79699379e-01f, -3.32249761e-01f, 1.02920309e-01f, 1.19713411e-01f, 7.53357485e-02f, 1.03023243e+00f, 3.70381594e-01f, -5.83315790e-01f,
  -3.62716407e-01f, 7.80790806e-01f, 5.06733358e-01f, 8.01022410e-01f, -3.03314894e-01f, 5.15727699e-01f, 5.53645492e-01f, 5.57747073e-02f, -5.97455800e-01f, -1.10634722e-01f,
  2.96254128e-01f, 3.35597545e-02f, 1.21095085e+00f, -4.43601340e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -2.68635988e-01f, -1.51680008e-01f, 6.74188137e-02f, 1.03250414e-01f, 2.98417747e-01f, 2.91276842e-01f, 1.61992222e-01f, 3.16986144e-01f, -3.84914950e-02f, 2.10489139e-01f,
  3.61355782e-01f, 2.87544783e-02f, 4.66633081e-01f, 3.01867902e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -4.77716029e-02f, 1.33527756e-01f, -1.41365141e-01f, -2.03196540e-01f, -7.59696513e-02f, -2.59462059e-01f, -3.68466624e-03f, 5.45569742e-03f, 2.20073760e-01f, -5.49833328e-02f,
  3.99718247e-02f, -1.39777079e-01f, 1.28012538e-01f, 1.89655036e-01f, -1.23759657e-01f, 5.97234629e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -4.71744463e-02f, -4.10825670e-01f, -5.42584294e-03f, 3.55934769e-01f, 2.42917329e-01f, -4.39355522e-01f, -4.55131941e-02f, -7.13019848e-01f, 5.65100968e-01f, -1.23425402e-01f,
  5.19067824e-01f, -1.78670466e-01f, 6.53938949e-01f, 6.87837064e-01f, 3.01692426e-01f, 2.16348305e-01f, -3.53997976e-01f, -5.83232760e-01f, 6.83244169e-02f, 2.21931577e-01f,
  2.47840613e-01f, 5.24408221e-01f, -2.36571327e-01f, 1.16217308e-01f, -1.78916603e-01f, -3.87233168e-01f, 1.32510453e-01f, 2.84458220e-01f, 6.99192137e-02f, -2.22431675e-01f,
  5.36850393e-01f, 2.10150450e-01f, -6.32915378e-01f, -2.41234638e-02f, -1.20619833e-02f, -3.59299104e-03f, 7.41624534e-02f, 8.69556427e-01f, -9.15802922e-03f, 3.00893635e-01f,
  1.38133481e-01f, 6.46472692e-01f, -1.96060926e-01f, 4.12150204e-01f, -5.08516490e-01f, 1.46321759e-01f, -2.63701081e-01f, -5.34128547e-02f, 1.69311851e-01f, 6.69407845e-02f,
  9.22960341e-02f, -2.20354199e-01f, 8.85472745e-02f, 6.82515800e-01f, 1.83372930e-01f, 3.48940969e-01f, 1.98065102e-01f, 4.96552169e-01f, -1.29108891e-01f, 5.42920291e-01f,
  6.88396022e-02f, -2.42394075e-01f, 1.11447446e-01f, -4.15616781e-01f, 2.96804130e-01f, 2.02165514e-01f, -1.52678952e-01f, 1.03236005e-01f, -1.69336200e-02f, 1.64795235e-01f,
  -3.34837213e-02f, -4.37843949e-01f, 7.08359540e-01f, -2.52625272e-02f, 7.52111599e-02f, 1.16623133e-01f, 4.30234313e-01f, 1.23376817e-01f, -1.49409890e-01f, 5.84399216e-02f,
  9.54173580e-02f, -7.83874243e-02f, -1.45997638e-02f, 5.30277342e-02f, -1.84102997e-01f, -8.70651603e-02f, -1.47339329e-01f, -3.78604352e-01f, 7.21487403e-01f, 7.53397286e-01f,
  -1.13533102e-01f, 2.91931242e-01f, 1.94201082e-01f, 7.31093645e-01f, -5.85464418e-01f, 1.17116019e-01f, 2.68786609e-01f, 9.22142267e-02f, 2.11193919e-01f, 3.66323978e-01f,
  -7.51152635e-03f, -4.01936978e-01f, 2.43898869e-01f, 5.69926500e-01f, -5.00045121e-01f, 3.00402850e-01f, 1.86598480e-01f, 1.70881435e-01f, -1.98949978e-01f, 4.10286278e-01f,
  -5.56446970e-01f, 4.13647115e-01f, -8.08286726e-01f, -6.74849689e-01f, -2.34700546e-01f, 3.14007223e-01f, 3.56894135e-02f, 4.76083457e-01f, -2.08173379e-01f, 3.19045305e-01f,
  8.36764425e-02f, 9.43613201e-02f, 6.05277978e-02f, -2.62116864e-02f, -8.12479854e-02f, -8.51342008e-02f, 4.36002702e-01f, -2.89814919e-01f, 2.74139643e-01f, -5.94272554e-01f,
  -1.99663967e-01f, -2.27075905e-01f, -2.45682672e-01f, 1.59936607e-01f, 1.68855011e-01f, -1.26817338e-02f, 2.17526436e-01f, -4.23330098e-01f, 2.79013008e-01f, 1.91041321e-01f,
  6.48157120e-01f, -4.82027709e-01f, 8.62984419e-01f, -1.90357342e-02f, 1.67026266e-01f, -7.87988544e-01f, 2.25518301e-01f, 7.58484304e-01f, -2.30189443e-01f, 4.21200730e-02f,
  -5.40948153e-01f, 4.51692432e-01f, -1.13651186e-01f, -5.82011342e-01f, 6.07374549e-01f, 9.66885909e-02f, 1.63087875e-01f, 4.03209478e-01f, 1.94024161e-01f, 6.51900709e-01f,
  4.14397299e-01f, 7.71190107e-01f, -1.37319908e-01f, -3.28572422e-01f, 2.35105734e-02f, 6.20474637e-01f, 3.42536867e-01f, -6.98120892e-02f, 4.55209911e-01f, 4.98667538e-01f,
  6.03219084e-02f, 3.89758676e-01f, 2.00140253e-01f, 2.57971555e-01f, -1.83822140e-01f, -3.83331090e-01f, 6.54115498e-01f, 9.31734741e-01f, 2.12074414e-01f, -1.26673430e-01f,
  1.91675425e-01f, -2.49954462e-01f, 1.10042584e+00f, 3.34541380e-01f, -1.34657726e-01f, 3.46935570e-01f, -6.03733473e-02f, 5.37821889e-01f, -2.99652144e-02f, -5.88080347e-01f,
  1.86303616e-01f, 3.19319934e-01f, 6.11233294e-01f, 5.53180397e-01f, -2.16065291e-02f, -2.66169786e-01f, 7.81235695e-02f, -3.40287030e-01f, 6.19732857e-01f, -1.82795040e-02f,
  8.48935321e-02f, -2.35474348e-01f, 1.15719214e-01f, 3.61358047e-01f, 4.81073201e-01f, -3.90954226e-01f, 1.69132993e-01f, 1.13660000e-01f, -1.86106134e-02f, -1.06424876e-01f,
  1.68632939e-02f, 6.63643897e-01f, 3.32009494e-02f, 3.59342657e-02f, 4.37522501e-01f, 3.46307069e-01f, -4.90556717e-01f, 4.09379423e-01f, 3.43144596e-01f, -9.02770683e-02f,
  2.98973564e-02f, 3.06163430e-01f, -2.78144002e-01f, 8.24918330e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  5.80177866e-02f, -9.24229696e-02f, -6.95860013e-02f, 1.23465262e-01f, -1.09595917e-02f, -3.24054696e-02f, -5.52778058e-02f, -2.68811703e-01f, 1.81601301e-01f, -6.84760287e-02f,
  -9.38556269e-02f, 1.66422084e-01f, 2.71178693e-01f, 3.89902443e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -5.89569956e-02f, 2.10809946e-01f, 3.12112063e-01f, -2.36359447e-01f, 8.02128091e-02f, -5.73864579e-01f, -8.69845450e-02f, 1.26301140e-01f, -4.34317708e-01f, 4.06902805e-02f,
  -2.46279612e-01f, 3.94322902e-01f, -2.39709750e-01f, -8.54656875e-01f, -5.09866714e-01f, 1.66234538e-01f, 3.52831423e-01f, -2.85890788e-01f, -1.01756610e-01f, 2.01894239e-01f,
  1.36449441e-01f, 2.85526246e-01f, -6.93620890e-02f, 2.85060816e-02f, -4.16690260e-01f, 4.03341889e-01f, 1.97419479e-01f, -4.06856462e-02f, 4.33474453e-03f, -5.29297590e-01f,
  -3.08116525e-01f, -6.00618660e-01f, -1.17676988e-01f, -1.17293082e-01f, -8.35339189e-01f, -4.08591479e-01f, 3.87453079e-01f, 3.06354344e-01f, 5.35173230e-02f, -3.88290780e-03f,
  -6.31600976e-01f, 8.74795467e-02f, -5.07056057e-01f, -2.93909013e-01f, 3.99938136e-01f, 6.87313527e-02f, -2.62502402e-01f, -1.14803791e-01f, 1.55239031e-01f, -2.18593046e-01f,
  -6.07708573e-01f, -7.31916428e-01f, -2.01388046e-01f, 5.32724783e-02f, -5.54275215e-01f, -5.56946583e-02f, 4.53100532e-01f, -7.03002572e-01f, -8.23646307e-01f, 3.77007648e-02f,
  -2.17496067e-01f, 1.80640921e-01f, -5.10244295e-02f, 4.20241416e-01f, 5.56233265e-02f, 3.46955955e-01f, -3.15774307e-02f, -2.22209975e-01f, -3.04663956e-01f, -3.50311875e-01f,
  -6.17281869e-02f, 1.51607394e-01f, -4.11676392e-02f, -6.76554799e-01f, -3.99410054e-02f, 1.41887665e-01f, -1.12671144e-01f, 2.81262428e-01f, 1.33954927e-01f, 1.90570056e-01f,
  -2.34195158e-01f, 5.54417372e-01f, 3.51746470e-01f, -4.43845689e-01f, -7.36093700e-01f, -6.65596053e-02f, 3.20663869e-01f, 6.83923885e-02f, -1.46034706e+00f, -1.58473372e-01f,
  1.52532682e-01f, 2.09118694e-01f, 6.14885688e-02f, -5.41756749e-01f, 4.23397077e-03f, -2.81243593e-01f, 5.01840055e-01f, -2.94826537e-01f, -3.83611739e-01f, 1.98160689e-02f,
  -1.71764866e-01f, 4.21381854e-02f, -1.49928972e-01f, -4.99248356e-01f, -9.04985130e-01f, -3.35241199e-01f, 1.94391400e-01f, -2.38537312e-01f, 3.64407569e-01f, 6.02460027e-01f,
  5.17975092e-01f, -2.89791405e-01f, 1.08623527e-01f, -3.61851245e-01f, -9.61703807e-03f, 8.55877921e-02f, -9.65999886e-02f, -5.47587633e-01f, -8.41562569e-01f, -5.67139387e-01f,
  1.72979146e-01f, 8.99953842e-02f, -4.27003384e-01f, 4.29887354e-01f, -4.18635130e-01f, -1.26710147e-01f, -4.94321883e-01f, 3.25779974e-01f, 1.21851929e-01f, 3.54338229e-01f,
  4.23557460e-02f, -5.88437617e-01f, 1.48569524e-01f, 5.93828075e-02f, 3.06683123e-01f, 3.67830873e-01f, -1.72973037e-01f, -2.73488373e-01f, -4.88127738e-01f, -3.71851176e-01f,
  3.61546546e-01f, -3.27021480e-01f, -2.17719570e-01f, -4.85731095e-01f, -1.00365272e-02f, -7.50474352e-03f, 1.50844023e-01f, 2.92561442e-01f, -6.21918380e-01f, -2.68224359e-01f,
  -3.43916148e-01f, -7.27085650e-01f, -5.18423915e-01f, 2.73133665e-01f, 3.45079213e-01f, 3.10436517e-01f, -7.79702723e-01f, 3.01740114e-02f, 6.75262362e-02f, 2.23375648e-01f,
  1.58723891e-01f, -4.07992572e-01f, 3.41266999e-03f, -1.18381989e+00f, 3.43332380e-01f, 1.51014209e-01f, -4.31618661e-01f, -1.03527587e-03f, 7.11277276e-02f, 1.19947053e-01f,
  -7.18630970e-01f, -1.00057733e+00f, 2.22397268e-01f, 5.48554659e-01f, -8.19487423e-02f, 1.06510095e-01f, -3.51518810e-01f, 3.94685060e-01f, 1.78461879e-01f, -9.28377271e-01f,
  -5.14177442e-01f, -3.46027836e-02f, 2.07395852e-01f, 2.34129682e-01f, -6.23829067e-01f, -8.85627985e-01f, 2.45494410e-01f, -5.83290398e-01f, 6.83855936e-02f, 3.00491810e-01f,
  4.65070516e-01f, -7.26254940e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.71678409e-01f, -4.15560491e-02f, 8.93043280e-02f, 2.22832918e-01f, 2.03336552e-01f, -1.75362602e-01f, 1.73286840e-01f, 2.66683847e-02f, -4.80445176e-02f, 8.45741034e-02f,
  2.04059854e-01f, 2.73580015e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    