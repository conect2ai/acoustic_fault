/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.67119676e-02f, -3.00025433e-01f, 5.10567546e-01f, -7.55129894e-03f, 3.45518552e-02f, -3.55672017e-02f, -2.89771736e-01f, -7.89816976e-02f, -6.82250485e-02f, 8.95005688e-02f,
  1.60716593e-01f, 1.50369704e-01f, 3.14749449e-01f, 2.54318714e-01f, 9.93952155e-02f, 2.30558887e-02f, 1.34343710e-02f, 3.69764745e-01f, 3.42250019e-01f, -1.88812204e-02f,
  -1.06040880e-01f, -5.49388118e-02f, 2.06474736e-02f, 1.30106077e-01f, 4.00046594e-02f, 2.70992428e-01f, 1.87712073e-01f, 1.25876978e-01f, 2.12721199e-01f, 2.32373565e-01f,
  4.68987435e-01f, -2.49442994e-03f, 3.19796115e-01f, 1.26228392e-01f, 3.26009244e-01f, 2.20195219e-01f, 1.62357986e-01f, 1.96355507e-01f, 1.71238720e-01f, 1.96848258e-01f,
  2.65486836e-01f, 1.37019128e-01f, 2.71067649e-01f, 2.12242916e-01f, 1.94176242e-01f, 2.34899864e-01f, 7.75403604e-02f, 1.82907507e-01f, 2.31706798e-01f, 1.18540294e-01f,
  6.59159273e-02f, 1.21300109e-01f, 2.46236622e-01f, 9.64993238e-02f, 2.24727258e-01f, 2.50034392e-01f, 2.60877937e-01f, 2.65873462e-01f, 2.76651651e-01f, 7.87499622e-02f,
  -3.36662456e-02f, -1.38604566e-01f, -1.37141168e-01f, -1.51370302e-01f, -1.67137727e-01f, -1.01164423e-01f, -1.12084463e-01f, -9.33418274e-02f, -1.69829845e-01f, -2.17935503e-01f,
  -1.32424012e-01f, -1.35053679e-01f, -1.26802683e-01f, -1.83330894e-01f, -1.19023979e-01f, -1.91047549e-01f, -1.18077822e-01f, -9.22479033e-02f, -3.86537649e-02f, -1.28340214e-01f,
  -2.00054571e-02f, -7.49129876e-02f, -9.11036283e-02f, -1.39582008e-01f, -1.62334099e-01f, -1.33393437e-01f, -1.50239483e-01f, -2.32791707e-01f, -2.23164141e-01f, -2.25141436e-01f,
  1.45658180e-01f, 3.99914861e-01f, 2.76406199e-01f, 9.85550433e-02f, 1.76390454e-01f, 1.97241962e-01f, 2.42134020e-01f, 1.35240912e-01f, 2.42806807e-01f, 2.24735767e-01f,
  1.83451697e-01f, 1.66859359e-01f, 2.40011558e-01f, 1.21774502e-01f, 1.78021520e-01f, 2.02526703e-01f, 6.64186478e-02f, 2.55166769e-01f, 1.69995815e-01f, 1.38974473e-01f,
  1.40015155e-01f, 8.94488171e-02f, 2.68724769e-01f, 2.13337272e-01f, 2.53901273e-01f, 3.23755771e-01f, 2.53930539e-01f, 2.72750735e-01f, 3.25500935e-01f, 7.39224628e-03f,
  -7.82399327e-02f, -4.87100482e-01f, 4.97422785e-01f, 1.12880051e-01f, -1.84705690e-01f, -1.91567391e-01f, -2.04049110e-01f, 2.17537489e-02f, 1.27366066e-01f, -2.84250733e-03f,
  -1.42640814e-01f, 3.96597981e-02f, 3.03316206e-01f, 1.07020400e-01f, 1.59640923e-01f, 1.30854562e-01f, 1.10939823e-01f, 2.58857697e-01f, 2.43272871e-01f, -2.36337110e-01f,
  -2.53887296e-01f, -1.05439410e-01f, -5.26965642e-03f, 1.17782019e-01f, -6.53201565e-02f, 4.91447151e-02f, 2.55124599e-01f, 2.32990608e-02f, -4.07477431e-02f, 6.74458593e-02f,
  2.70898581e-01f, -1.72183156e-01f, 9.80168357e-02f, -1.88834965e-01f, -4.19953242e-02f, 3.73888090e-02f, -2.67030206e-02f, 4.41153459e-02f, -5.56741916e-02f, 5.99783771e-02f,
  -3.56491022e-02f, -5.04145995e-02f, -5.72721325e-02f, -1.48306772e-01f, -4.33471613e-02f, -3.47232707e-02f, -7.77264237e-02f, 1.23616442e-01f, 1.95359122e-02f, -1.34677425e-01f,
  -2.08923534e-01f, -2.37273335e-01f, 5.76715507e-02f, -1.17697164e-01f, 4.18735784e-04f, 8.85831714e-02f, -6.93494901e-02f, 1.85377058e-02f, 1.37565613e-01f, 1.55639015e-02f,
  1.54001370e-01f, 6.60387054e-02f, 1.71202589e-02f, 3.79494540e-02f, 1.21361203e-01f, 1.37768209e-01f, 7.81784505e-02f, 7.63315186e-02f, 2.22330708e-02f, 5.15436344e-02f,
  1.49045959e-01f, 8.81136954e-02f, 5.04700616e-02f, 4.98861670e-02f, 5.16893677e-02f, 4.05385867e-02f, 6.55802041e-02f, -2.15773862e-02f, 5.13786413e-02f, 8.72567594e-02f,
  1.41617702e-02f, 8.67799073e-02f, 7.89786205e-02f, -1.18149947e-02f, 5.07302694e-02f, 8.36373940e-02f, 1.31852436e-03f, 1.65081900e-02f, 8.41764063e-02f, 1.48218460e-02f,
  1.64673701e-01f, 4.32739174e-03f, 6.95183799e-02f, 4.57802154e-02f, -5.00153527e-02f, -6.20697476e-02f, -7.47170486e-03f, 1.66397914e-02f, -4.59581017e-02f, -4.20391224e-02f,
  -1.23285964e-01f, 2.95504089e-02f, 9.63231362e-03f, -4.95785177e-02f, -4.54218546e-03f, -8.09645578e-02f, -1.05837144e-01f, 3.82005535e-02f, -6.48738220e-02f, -9.31021497e-02f,
  -7.77783319e-02f, -3.97862587e-03f, 1.66077852e-01f, 1.48661762e-01f, -6.16364777e-02f, 9.12178531e-02f, 6.59037009e-02f, 1.88427977e-02f, 1.51756808e-01f, 8.05897787e-02f,
  -4.52393830e-01f, 4.34375644e-01f, -1.37496116e-02f, -1.56181365e-01f, -2.80685067e-01f, -2.80418128e-01f, -6.63396940e-02f, -2.46495634e-01f, -1.32947296e-01f, 1.43165454e-01f,
  2.62802362e-01f, 3.63973200e-01f, 3.24115485e-01f, 2.81117857e-01f, 1.95114449e-01f, 1.20345488e-01f, -2.60556806e-02f, -9.08662081e-02f, -1.35262057e-01f, -1.39345363e-01f,
  6.15083091e-02f, -3.44992429e-01f, -2.90706545e-01f, -7.10572228e-02f, 6.36427030e-02f, 1.83813065e-01f, -4.01190408e-02f, -4.63296287e-02f, 2.35497952e-01f, 4.12110955e-01f,
  2.46907130e-01f, 8.05901960e-02f, -1.35679230e-01f, 4.14632820e-02f, -1.38562461e-02f, 2.65703015e-02f, -1.35518173e-02f, -1.14708459e-02f, -4.47096583e-03f, -7.18177557e-02f,
  2.11785585e-02f, -1.92342399e-04f, 2.59630773e-02f, 6.10561036e-02f, -9.35985744e-02f, 7.05184713e-02f, -9.82847884e-02f, 7.91208968e-02f, 6.11147955e-02f, 1.81809276e-01f,
  1.16469570e-01f, 6.41039982e-02f, 6.12780116e-02f, -6.41669482e-02f, 3.00091151e-02f, -1.26677481e-02f, 5.32448143e-02f, 1.13976523e-01f, 1.50214925e-01f, 4.50615436e-02f,
  -1.87722862e-01f, -9.03605372e-02f, -7.94541687e-02f, -1.59609932e-02f, 1.41389295e-02f, -1.06394455e-01f, -3.42954956e-02f, -3.40605229e-02f, -5.44849485e-02f, -9.76353139e-02f,
  2.70118769e-02f, 1.04449116e-01f, 1.35590532e-03f, -5.53905847e-04f, 3.51725556e-02f, -4.61295024e-02f, -7.36944028e-04f, 1.05544351e-01f, 9.39751416e-02f, 3.81338075e-02f,
  2.35740300e-02f, 5.86182950e-03f, 1.62700820e-03f, -9.49049089e-03f, 5.87527454e-02f, 5.25972135e-02f, 1.36408433e-02f, 2.40251478e-02f, -2.72379331e-02f, -6.99864626e-02f,
  -7.95333087e-02f, -4.37330715e-02f, 1.61032438e-01f, 1.20290421e-01f, -1.01107974e-02f, 8.17488581e-02f, 8.49747062e-02f, 7.75970593e-02f, 7.44171022e-03f, 8.81515145e-02f,
  2.98126806e-02f, 4.03797114e-03f, 7.34093934e-02f, -1.53325545e-02f, -1.18454866e-01f, 2.07966603e-02f, 6.96101710e-02f, 6.34353757e-02f, 6.99060634e-02f, 8.32649320e-02f,
  4.40245830e-02f, -5.36046773e-02f, -5.70164733e-02f, 1.03094727e-01f, 5.43861166e-02f, 6.10630726e-03f, 1.88261904e-02f, -6.33949786e-02f, -5.37354872e-02f, -1.33171082e-01f,
  -5.09733558e-02f, -4.10257369e-01f, -2.92588055e-01f, -2.94160843e-01f, -1.94121808e-01f, -1.21891253e-01f, -2.85960555e-01f, 7.45026814e-03f, -6.77188626e-04f, -2.15997890e-01f,
  1.30034342e-01f, 3.90996754e-01f, 3.15566212e-01f, 3.16756248e-01f, 2.75584638e-01f, -2.14993596e-01f, -1.97227135e-01f, 1.04351521e-01f, 3.34770679e-01f, 1.80437207e-01f,
  7.41290972e-02f, -4.79921736e-02f, -3.65240164e-02f, 9.55688581e-02f, -1.87237829e-01f, 2.82369144e-02f, -2.23071977e-01f, -2.00233132e-01f, -6.64180443e-02f, -2.30761230e-01f,
  -6.03107139e-02f, -1.65246800e-01f, 2.17930123e-01f, 1.25195846e-01f, -1.35102533e-02f, 3.75162661e-02f, -6.46859109e-02f, -1.22053370e-01f, -1.93903968e-02f, -2.51732618e-02f,
  -9.47562456e-02f, 6.51613027e-02f, -8.94993916e-03f, -4.71066758e-02f, 2.61636842e-02f, -2.37638932e-02f, -6.77933358e-03f, -1.77261177e-02f, -1.02654649e-02f, -1.12775102e-01f,
  -7.97264352e-02f, -1.84827253e-01f, -1.48470536e-01f, 8.93819034e-02f, 5.32223331e-03f, 8.68757144e-02f, -6.73073381e-02f, 2.03904118e-02f, -1.44669451e-02f, -2.67453417e-02f,
  3.89120765e-02f, -2.90319249e-02f, 3.89138721e-02f, 8.89158696e-02f, 9.08159688e-02f, 7.29868710e-02f, 3.19657177e-02f, 9.98895466e-02f, 1.04937114e-01f, -1.11424411e-02f,
  1.45012006e-01f, 1.34614278e-02f, 3.45986113e-02f, -5.54411905e-03f, 4.18183915e-02f, -8.79952535e-02f, 2.67906804e-02f, 4.06034291e-02f, 1.21829927e-01f, -2.81003080e-02f,
  3.66407521e-02f, 2.40547787e-02f, 1.13220811e-02f, 6.99363798e-02f, 7.33328760e-02f, 2.68790927e-02f, 4.71563684e-03f, 2.92315912e-02f, 1.95614360e-02f, -5.14231138e-02f,
  9.95645449e-02f, 1.17775679e-01f, -2.61208741e-03f, -1.14121027e-02f, -1.99289382e-01f, -5.39851896e-02f, -3.32703441e-02f, -8.19157511e-02f, -5.64299698e-05f, -4.05335277e-02f,
  3.93672884e-02f, -7.48859569e-02f, -7.51768351e-02f, -2.74820719e-02f, 1.49462149e-02f, -1.58969201e-02f, -2.06053518e-02f, 1.04437722e-02f, 2.47751661e-02f, -5.19674607e-02f,
  -1.11068584e-01f, -2.31107920e-02f, 3.98083255e-02f, 2.21102517e-02f, -4.12083277e-03f, 8.39287564e-02f, 2.27926429e-02f, -2.19808836e-02f, 9.03820917e-02f, -7.02236444e-02f,
  -5.69847882e-01f, -1.47755101e-01f, -2.05614015e-01f, -1.54760122e-01f, 4.17185575e-01f, 3.74985009e-01f, 4.94159073e-01f, 2.49747589e-01f, 1.09373786e-01f, 3.37111205e-02f,
  -2.79128272e-02f, -6.58661425e-02f, -2.20290255e-02f, 8.19498615e-04f, 3.29511203e-02f, 2.21139312e-01f, 9.91834849e-02f, 1.01714451e-02f, 1.28319636e-01f, 3.82880181e-01f,
  3.05330336e-01f, 2.00142357e-02f, -2.28719294e-01f, -5.28770089e-02f, 7.87354913e-03f, 9.88806486e-02f, -7.04827383e-02f, -1.51017055e-01f, 9.68047827e-02f, -1.24746993e-01f,
  -1.09523833e-01f, -2.32261583e-01f, 2.26946607e-01f, -4.98858131e-02f, -1.11119710e-01f, -3.63612659e-02f, 1.00787118e-01f, -1.50350779e-01f, -5.79218306e-02f, 3.30474898e-02f,
  -6.84061497e-02f, 1.49826249e-02f, -8.37022346e-03f, -3.69874239e-02f, -5.31890318e-02f, 9.19641368e-03f, -1.03106670e-01f, -1.53002650e-01f, -7.15076998e-02f, 6.56659752e-02f,
  1.27084032e-01f, -5.02466341e-04f, -5.07123992e-02f, 1.17798872e-01f, 3.06484904e-02f, -1.07647283e-02f, -8.41676295e-02f, -4.69203889e-02f, -5.29582985e-02f, 1.94134861e-02f,
  7.87561312e-02f, -8.80092233e-02f, -3.71495335e-05f, 9.69307031e-03f, -4.95552570e-02f, -3.29799950e-02f, -3.00115179e-02f, -3.46316360e-02f, -2.86369994e-02f, -7.48692155e-02f,
  -2.97207739e-02f, -1.96281052e-03f, -2.18350869e-02f, 3.90839530e-03f, -5.60770184e-02f, -7.21983686e-02f, -4.76274043e-02f, -6.60125837e-02f, -7.11331218e-02f, 1.94622017e-03f,
  -1.14063419e-01f, -1.01185188e-01f, -1.50707707e-01f, -4.03585136e-02f, -4.47246209e-02f, -1.47575930e-01f, -6.17231764e-02f, 2.13095662e-03f, 2.34791096e-02f, -5.08086756e-02f,
  2.37441272e-01f, 4.84295748e-02f, 8.18433836e-02f, 5.37057333e-02f, 3.42836492e-02f, -3.02571128e-03f, -1.16308527e-02f, 1.06037624e-01f, -2.23776279e-03f, 5.46296127e-02f,
  3.67462412e-02f, 7.09004744e-05f, -1.78126451e-02f, 9.29412320e-02f, 1.10608079e-01f, 8.91332403e-02f, 1.02324829e-01f, 2.49290429e-02f, 1.19196586e-01f, 8.83857980e-02f,
  3.67937498e-02f, 1.33883983e-01f, 1.97406590e-01f, 1.57397509e-01f, 9.83619392e-02f, 1.61149934e-01f, 2.31181487e-01f, 1.57804430e-01f, 1.39722466e-01f, 2.90690780e-01f,
  1.48179084e-01f, 2.13307261e-01f, 2.18885452e-01f, 6.84747994e-02f, 3.30772344e-03f, 5.79953417e-02f, 8.30759332e-02f, 7.03478009e-02f, -6.86005354e-02f, -2.42735539e-02f,
  -3.18294577e-02f, -4.09721166e-01f, -2.13530287e-01f, -2.11555183e-01f, -3.11074674e-01f, -5.02302796e-02f, -9.69634429e-02f, -3.02959651e-01f, -3.22047263e-01f, -3.17170560e-01f,
  -3.44212621e-01f, -1.53876364e-01f, -1.31774858e-01f, -1.09351240e-01f, 1.25388011e-01f, -1.14645682e-01f, 1.10247381e-01f, 7.03209639e-02f, -7.18527436e-02f, -1.01536900e-01f,
  -8.28441828e-02f, 2.21035212e-01f, -2.21211493e-01f, -1.37754470e-01f, -2.34799627e-02f, -4.59122285e-02f, -1.14682734e-01f, 6.90430552e-02f, -9.07724649e-02f, 5.03649861e-02f,
  -7.30879754e-02f, -1.16937153e-01f, 1.69286802e-02f, -1.41638340e-02f, -4.40620482e-02f, -4.86589130e-03f, -3.10048983e-02f, -7.66188800e-02f, -9.02957469e-03f, -5.34259416e-02f,
  -5.60320988e-02f, 7.77646201e-03f, 1.50186554e-01f, -4.50922437e-02f, 1.89893954e-02f, -2.72491630e-02f, 1.73721015e-02f, -1.86230615e-02f, 4.39627767e-02f, 4.44081575e-02f,
  3.72973122e-02f, 1.24436051e-01f, 1.28374472e-01f, 1.40408650e-01f, -1.11362627e-02f, 1.07084803e-01f, 5.61363716e-03f, -2.53650360e-03f, 1.75393932e-02f, 1.15245678e-01f,
  8.83945823e-03f, -3.30092423e-02f, 6.14551343e-02f, 4.86923829e-02f, 1.70914773e-02f, 2.04296082e-01f, 7.10532535e-03f, 1.23490719e-02f, 1.18844464e-01f, 1.40369326e-01f,
  5.16030639e-02f, 6.02469556e-02f, 4.65421565e-02f, 9.85622257e-02f, 2.45863316e-03f, 1.71153992e-01f, 2.15049181e-02f, 9.67489108e-02f, 2.82641556e-02f, 1.75773337e-01f,
  -1.10754659e-02f, -2.23914608e-01f, -1.33131951e-01f, -1.88212752e-01f, -3.03092487e-02f, -1.34783611e-01f, -1.30550787e-01f, -9.78105292e-02f, 2.45431922e-02f, -1.47236243e-01f,
  -5.66076040e-02f, -1.68792546e-01f, -4.14585769e-02f, -1.08820930e-01f, -8.12893659e-02f, -1.16367951e-01f, -1.67631116e-02f, -7.12738633e-02f, -1.17747076e-01f, 5.80253452e-02f,
  -5.80376834e-02f, -3.17833424e-02f, -2.26231456e-01f, -1.09430991e-01f, -1.18243828e-01f, -1.99663758e-01f, -1.00309476e-01f, -6.56846836e-02f, -1.42472014e-01f, -1.90361738e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.44448090e-01f, 6.98765337e-01f, 1.16768575e+00f, -7.50589192e-01f, 3.93512070e-01f, 5.88471889e-01f, 5.92062354e-01f, 1.89858268e-03f, -5.73378980e-01f, -8.20349727e-04f,
  4.82022882e-01f, -3.87327015e-01f, -1.22048214e-01f, -2.14209601e-01f, -1.05466485e-01f, 3.86795513e-02f, -2.03110814e-01f, -3.15716505e-01f, -1.72627360e-01f, -1.67570546e-01f,
  -3.58991832e-01f, -3.23466986e-01f, -3.51690233e-01f, -2.68698782e-01f, -5.95938563e-01f, -5.01226008e-01f, 2.11637020e-01f, -8.83024111e-02f, 2.40388468e-01f, -6.53244078e-01f,
  -1.09139957e-01f, 1.60462916e-01f, -6.78438917e-02f, -2.68009633e-01f, 3.51305395e-01f, -3.76512021e-01f, -1.17276378e-01f, -3.87412086e-02f, -1.81385547e-01f, 3.03228945e-02f,
  4.30777334e-02f, -1.38480356e-02f, -2.28965431e-02f, -2.31308132e-01f, -2.11298615e-01f, -2.48342559e-01f, -1.70919597e-02f, -1.90737396e-01f, -8.66344050e-02f, 4.65948492e-01f,
  1.15602612e-01f, -5.59489802e-02f, 3.36498350e-01f, 2.70354629e-01f, 2.54946858e-01f, 6.17470592e-02f, 2.28916824e-01f, -2.64334142e-01f, 3.61107737e-01f, -5.05664289e-01f,
  -1.67567596e-01f, 9.01597440e-02f, 1.71874940e-01f, 8.43104571e-02f, -1.47243381e-01f, -2.35151779e-02f, -1.27959490e-01f, 2.80985255e-02f, -2.94050779e-02f, -1.68422133e-01f,
  1.34403199e-01f, 3.25715899e-01f, 1.01878822e-01f, -1.47634998e-01f, -4.22740914e-03f, 1.30712584e-01f, -1.21706001e-01f, 5.98536581e-02f, -5.68084093e-03f, -3.67038324e-02f,
  -2.10134864e-01f, 1.16396070e-01f, -7.66179934e-02f, -1.90275922e-01f, 1.95530757e-01f, 2.71120714e-03f, -1.23842634e-01f, 9.25689042e-02f, -7.87374191e-03f, 1.34404540e-01f,
  -4.97533947e-01f, 5.05596161e-01f, -6.35568500e-01f, -2.87362039e-01f, -1.74174085e-02f, -1.49539309e-02f, 1.15474574e-01f, 1.10719554e-01f, -9.19339992e-03f, -1.45305887e-01f,
  2.43467480e-01f, -2.44026189e-03f, -5.17329350e-02f, 3.12262736e-02f, -1.55047923e-01f, 1.17777251e-02f, -1.76038891e-01f, -8.13123584e-02f, 1.31523356e-01f, 2.33705938e-01f,
  2.37389896e-02f, -3.04551095e-01f, -6.55404627e-01f, -3.95777881e-01f, -1.63575158e-01f, -3.20435554e-01f, -2.30326682e-01f, -3.35720539e-01f, -1.30879328e-01f, -8.24987113e-01f,
  8.15671563e-01f, -1.93358451e-01f, 1.57063872e-01f, 3.83288532e-01f, -3.30578178e-01f, -7.01874197e-01f, -1.01668966e+00f, -4.24916565e-01f, 8.15774202e-02f, -5.62392734e-02f,
  -3.36971432e-01f, -3.51927280e-01f, -1.51794329e-01f, -2.30147094e-01f, -4.33367580e-01f, -2.12135106e-01f, -9.07096192e-02f, 1.76069021e-01f, -2.58092076e-01f, -2.88124979e-01f,
  -1.99541569e-01f, 3.73037964e-01f, 5.62979400e-01f, 2.09846333e-01f, 5.47637820e-01f, 1.59620598e-01f, 6.16356194e-01f, 5.40584683e-01f, 3.13622318e-03f, 6.58833325e-01f,
  2.72479504e-01f, 5.27897775e-01f, -4.87205118e-01f, 8.09521377e-02f, 9.86575894e-03f, 2.59947777e-01f, 1.90808845e-03f, 3.78477037e-01f, -3.98680061e-01f, -5.71810491e-02f,
  -7.82059282e-02f, 9.24075581e-03f, -1.88905969e-01f, 2.10770667e-02f, 4.09419760e-02f, 5.57855591e-02f, 2.27434948e-01f, -7.12220930e-03f, 9.21972468e-02f, -5.09069301e-03f,
  -4.39681083e-01f, 7.19297081e-02f, -3.48258823e-01f, -3.41150433e-01f, -1.33401304e-01f, -6.39564246e-02f, -9.64611769e-02f, 1.96376726e-01f, 1.02110729e-01f, 6.81848228e-01f,
  4.71221842e-02f, -7.25068292e-03f, -5.63448295e-02f, 3.57409827e-02f, -1.24396063e-01f, -1.07875258e-01f, -6.60914406e-02f, -1.02669001e-01f, 5.92719652e-02f, -2.49383021e-02f,
  -2.70970225e-01f, -1.10954650e-01f, 2.03139603e-01f, 1.47611111e-01f, -2.43922174e-01f, 1.68296561e-01f, -1.46523342e-01f, -5.22025954e-03f, 1.29481912e-01f, -9.42344293e-02f,
  -1.07819788e-01f, 3.09902756e-03f, 1.40723497e-01f, -2.99287550e-02f, 2.91891433e-02f, 1.31960437e-01f, 2.59937286e-01f, -2.76824515e-02f, 2.27858692e-01f, 1.76463068e-01f,
  -2.63518747e-02f, -5.04416525e-01f, -1.58793330e-02f, 8.70650038e-02f, 9.22244787e-02f, 9.26544368e-02f, -1.09219044e-01f, -1.19322807e-01f, -6.40823171e-02f, -1.88544527e-01f,
  -2.17586413e-01f, -1.63917542e-01f, 1.30299568e-01f, -1.92374662e-01f, -3.61066848e-01f, -1.21199213e-01f, -1.30968481e-01f, -4.91164565e-01f, -1.00896455e-01f, -2.09121630e-01f,
  -3.99351269e-01f, -3.70846152e-01f, -4.99275357e-01f, -5.57335973e-01f, -1.69569328e-01f, -4.16685671e-01f, -1.82124406e-01f, -3.27288002e-01f, -5.50361753e-01f, -4.15926635e-01f,
  8.66506040e-01f, 6.22828364e-01f, -2.97254771e-01f, 4.07821298e-01f, 1.36960849e-01f, -7.01175928e-02f, 4.88964230e-01f, 2.27268457e-01f, 6.49884567e-02f, 1.81977004e-01f,
  6.71109091e-03f, -3.41120988e-01f, -4.52168852e-01f, -5.31007648e-01f, -3.46061081e-01f, -1.22097582e-01f, -2.83641011e-01f, -4.22380924e-01f, -5.81658185e-01f, -2.12409213e-01f,
  8.50530341e-03f, 5.84386706e-01f, 3.52540463e-01f, -2.28795782e-02f, 1.41283393e-01f, -2.73574442e-01f, 2.13467315e-01f, 4.19332206e-01f, -1.18297234e-01f, -1.99882805e-01f,
  -3.08602601e-01f, 5.09412348e-01f, -5.44229090e-01f, -9.80749726e-02f, 1.61462799e-02f, -1.90982241e-02f, 5.29264137e-02f, -1.60202906e-02f, 1.41220286e-01f, 5.46181612e-02f,
  6.05944060e-02f, -6.00976404e-04f, 6.98005259e-02f, 1.10988587e-01f, 2.41488263e-01f, 4.82669398e-02f, 1.61886647e-01f, -6.24659332e-03f, -1.09248474e-01f, -2.24218797e-02f,
  -1.42596096e-01f, 1.14561625e-01f, 1.06473744e-01f, -4.22863513e-02f, -2.16179729e-01f, -2.28840172e-01f, -9.91278142e-02f, -1.84003696e-01f, -1.88647032e-01f, 2.75916494e-02f,
  -1.43747047e-01f, -6.67673647e-02f, 9.77574736e-02f, 1.96943283e-01f, 2.68372923e-01f, 2.13321615e-02f, 9.07161236e-02f, 1.65805772e-01f, 3.97632904e-02f, 1.56466201e-01f,
  6.75666481e-02f, 2.94760186e-02f, 1.43183544e-01f, 3.01237941e-01f, -1.57792810e-02f, 7.38492087e-02f, 1.21101022e-01f, 1.36057526e-01f, 1.13888055e-01f, 1.68269068e-01f,
  -8.47250149e-02f, 1.86049547e-02f, 7.19360337e-02f, 1.37423584e-02f, 1.13509288e-02f, -5.36636710e-02f, -1.37927309e-02f, 9.54494402e-02f, 8.11367556e-02f, 5.36290891e-02f,
  4.76906776e-01f, -8.65153074e-02f, -1.33326530e-01f, -1.21128812e-01f, 9.81245711e-02f, 1.50160668e-02f, 2.59796456e-02f, 6.22716779e-03f, 1.37833089e-01f, 1.24788843e-01f,
  -9.16019902e-02f, 9.16761532e-02f, 8.42488855e-02f, 5.08342497e-03f, -5.51003031e-02f, -6.10061781e-03f, 1.36065617e-01f, -7.88580999e-02f, -1.74601883e-01f, -1.36266071e-02f,
  4.22661789e-02f, 8.36790651e-02f, 5.55156730e-02f, -6.70701265e-02f, -4.13016677e-02f, -2.04020411e-01f, -8.36052895e-02f, -1.64923549e-01f, -1.48445010e-01f, 3.19869488e-01f,
  -1.52259541e+00f, 2.10456938e-01f, -2.65366852e-01f, -6.73048735e-01f, -6.81190491e-01f, -7.41895497e-01f, -2.13805094e-01f, -4.69267704e-02f, -2.96599448e-01f, 4.39409256e-01f,
  2.77467012e-01f, -1.84712186e-01f, 7.28170946e-02f, -3.54951248e-02f, -3.82980436e-01f, 6.64822608e-02f, -3.10008436e-01f, -7.13337183e-01f, -8.73060048e-01f, -5.53177416e-01f,
  -3.07090104e-01f, -7.55345941e-01f, -7.20770478e-01f, -4.04418409e-01f, 1.61579639e-01f, -1.45472541e-01f, 1.09335013e-01f, -4.12791103e-01f, -1.76521048e-01f, -1.91246733e-01f,
  5.46135843e-01f, -6.08250678e-01f, -1.20971322e-01f, -2.39225969e-01f, 2.51806229e-02f, -9.68417525e-03f, -1.02129444e-01f, 1.03005379e-01f, 1.12975545e-01f, 1.44286558e-01f,
  -2.28633285e-01f, -7.27344826e-02f, -2.11166471e-01f, -1.15147363e-02f, -1.63967729e-01f, -8.92385542e-02f, 4.29434627e-02f, -6.85252249e-02f, 2.78213155e-02f, 3.39140832e-01f,
  2.32635900e-01f, -2.33836770e-01f, 6.23098901e-03f, 1.72843337e-01f, -8.58205780e-02f, -2.73371577e-01f, 2.25176305e-01f, -2.73222644e-02f, -3.27436142e-02f, 4.41518724e-01f,
  -1.08603761e-01f, 2.14078367e-01f, 5.23512103e-02f, -4.47073765e-02f, 8.05676430e-02f, 1.29426420e-01f, 9.76064801e-02f, 1.75200403e-01f, -4.66094762e-02f, 7.06614405e-02f,
  1.74706966e-01f, 6.90463036e-02f, -4.09708545e-02f, -2.98891887e-02f, 5.60365580e-02f, -4.08370085e-02f, -1.35776168e-02f, 1.87723771e-01f, 5.08286916e-02f, -8.29687268e-02f,
  -1.23038143e-01f, -8.05412699e-03f, 6.09508492e-02f, -1.66249238e-02f, -3.28459102e-03f, 1.71876438e-02f, -6.16721250e-02f, -2.80166380e-02f, 6.46505058e-02f, -1.07582390e-01f,
  4.65576291e-01f, -5.90989351e-01f, 1.62096485e-01f, 3.60554643e-02f, 2.54783221e-02f, 1.95409387e-01f, 1.00743897e-01f, -2.47280039e-02f, -1.23675779e-01f, -3.49891596e-02f,
  -1.64035872e-01f, 1.00759223e-01f, 2.54448932e-02f, 1.51651189e-01f, -1.20179988e-01f, -9.40187648e-02f, 1.33550972e-01f, -3.46110202e-02f, 1.40675278e-02f, 2.79390752e-01f,
  2.94358194e-01f, 1.65997863e-01f, 1.64997101e-01f, 3.33648831e-01f, 9.30681080e-02f, -2.38831371e-01f, 2.13616133e-01f, 1.59112841e-01f, 6.48731440e-02f, 4.31934744e-01f,
  -5.13820648e-01f, 6.00118577e-01f, 7.48207092e-01f, -4.24392298e-02f, 2.08652079e-01f, -7.71998754e-03f, 3.17213014e-02f, -3.12689960e-01f, 8.82102456e-03f, 3.99230748e-01f,
  2.91900128e-01f, -3.17728847e-01f, 1.18264750e-01f, -1.94970652e-01f, -4.64419812e-01f, 5.15349746e-01f, 4.59011912e-01f, -3.04626316e-01f, -8.68678808e-01f, -7.29154825e-01f,
  -2.66941994e-01f, -3.91553044e-01f, -5.74504912e-01f, -2.66668171e-01f, 3.68412107e-01f, -1.89929619e-01f, 5.77437818e-01f, 2.62680650e-01f, 3.66773099e-01f, 8.02058101e-01f,
  5.69384634e-01f, 5.89408994e-01f, -3.17355454e-01f, -7.21703246e-02f, 2.50933647e-01f, 7.60660991e-02f, 2.40330771e-02f, 2.41179302e-01f, 9.69178602e-02f, 1.70842379e-01f,
  2.29781732e-01f, 4.41465378e-02f, 3.19221467e-01f, 1.12229310e-01f, -1.16316393e-01f, -3.73903930e-01f, -5.37020676e-02f, -1.73760653e-01f, -8.36681947e-02f, 1.80531800e-01f,
  2.09761605e-01f, -9.81166661e-02f, -1.07072525e-01f, -1.56973347e-01f, 1.20730042e-01f, -4.17559236e-01f, -3.11890002e-02f, -3.02073300e-01f, -2.72889584e-01f, -2.18199603e-02f,
  5.95672429e-02f, 9.97216105e-02f, 6.21562190e-02f, 6.66615739e-02f, -1.50608525e-01f, 2.04187870e-01f, 2.14023262e-01f, -1.59864221e-02f, -2.46031880e-02f, -5.91956675e-02f,
  1.08393477e-02f, -1.03357323e-01f, -3.73454355e-02f, 2.38910362e-01f, 1.54872835e-02f, -4.91768345e-02f, -8.86098817e-02f, -1.19470507e-01f, 8.99197534e-02f, -6.97038695e-02f,
  -7.94676319e-02f, -6.44181594e-02f, 8.12849551e-02f, -1.84977710e-01f, 1.80086255e-01f, 2.05361042e-02f, 7.81065300e-02f, -1.27162248e-01f, -1.69152096e-01f, 1.99668497e-01f,
  -4.37663823e-01f, -4.89303246e-02f, 5.76577596e-02f, -1.28814816e-01f, 9.44193900e-02f, 9.23793465e-02f, 1.04958430e-01f, -7.21997172e-02f, 1.56457976e-01f, -2.74669111e-01f,
  -7.98312351e-02f, -3.92019041e-02f, 2.69988447e-01f, 1.08100086e-01f, -2.18415529e-01f, -2.04989091e-01f, -1.18227713e-01f, -1.66603193e-01f, -1.70675710e-01f, -4.40473333e-02f,
  -2.52603125e-02f, -8.06508660e-01f, -6.78405344e-01f, -3.21651936e-01f, -2.48478115e-01f, -7.43225336e-01f, -2.72621751e-01f, -4.81178790e-01f, -5.33730865e-01f, -5.62213719e-01f,
  -5.48111856e-01f, -9.99040604e-01f, -8.57113838e-01f, -9.13876414e-01f, -6.20632231e-01f, -1.92862451e-01f, -4.80224162e-01f, 5.53401327e-03f, -1.96111962e-01f, -7.87892163e-01f,
  -2.13400766e-01f, 3.43565285e-01f, -9.45922732e-02f, 2.00284585e-01f, 1.41485736e-01f, -8.31217647e-01f, -8.05225134e-01f, -4.57582951e-01f, 2.99600452e-01f, 3.30303274e-02f,
  -2.75295526e-01f, -6.40855134e-01f, -2.92962879e-01f, -1.25680611e-01f, -5.32773614e-01f, -2.42070943e-01f, -8.02281022e-01f, -4.76024419e-01f, -2.00933471e-01f, -7.72637188e-01f,
  -3.18036854e-01f, 1.66268289e-01f, 1.86321050e-01f, 2.46362507e-01f, -3.54175717e-01f, 2.45248750e-01f, -5.28905690e-02f, -4.38765511e-02f, 2.39367694e-01f, -1.50991246e-01f,
  1.63959842e-02f, 2.60428637e-01f, 2.09724501e-01f, 6.38680011e-02f, -1.55728251e-01f, 2.61602495e-02f, -1.15892693e-01f, -1.10374667e-01f, -1.27645791e-01f, -2.17708126e-02f,
  5.42264283e-02f, 1.49609357e-01f, 2.53530890e-01f, -4.64210548e-02f, 2.72523165e-01f, 1.02310516e-01f, -1.08488739e-01f, 3.34027469e-01f, 1.88427091e-01f, -6.60419226e-01f,
  -8.25609714e-02f, -1.51989818e-01f, -5.31947315e-02f, 1.02629913e-02f, 8.50388706e-02f, -1.64382942e-02f, -3.16275358e-02f, 1.61403775e-01f, -1.01023624e-02f, 7.46119246e-02f,
  -1.07095852e-01f, -7.30987713e-02f, 1.08389951e-01f, -1.89159419e-02f, -3.53100784e-02f, -5.00563979e-02f, 2.69446764e-02f, -8.62237141e-02f, 8.97304490e-02f, -1.67483948e-02f,
  5.47821335e-02f, 4.85641435e-02f, -6.40535320e-04f, 7.89579526e-02f, -3.16740200e-02f, -6.87848330e-02f, 5.17746732e-02f, 1.32858336e-01f, 7.04050511e-02f, 1.08367294e-01f,
  -1.61778897e-01f, 3.60057205e-01f, -2.43260145e-01f, 2.56763518e-01f, -2.18208015e-01f, -6.42395094e-02f, -6.36291504e-02f, -2.13492699e-02f, 1.50452271e-01f, -1.25384510e-01f,
  1.76136538e-01f, -6.49039373e-02f, -8.56958255e-02f, 7.69015029e-02f, -1.09319957e-02f, 1.15971975e-01f, -1.23875998e-01f, -2.13792071e-01f, 1.83523804e-01f, 1.25509957e-02f,
  -1.45562872e-01f, -8.56038823e-04f, 9.02642123e-03f, -3.13405618e-02f, 2.38257051e-01f, 1.92647383e-01f, -1.12885930e-01f, 1.25635520e-01f, 2.25486428e-01f, -6.53800786e-01f,
  1.30276382e-01f, -6.01561069e-01f, 4.69890088e-01f, -1.56147301e-01f, -2.17984676e-01f, -1.85416192e-01f, -2.49350399e-01f, -2.95843780e-01f, -1.95898563e-01f, -1.48642987e-01f,
  -1.73352137e-01f, 2.53711373e-01f, 2.20349848e-01f, 1.04015879e-01f, 6.79857582e-02f, 5.56845069e-02f, 1.84851900e-01f, 4.57544535e-01f, 5.06377339e-01f, 1.29269257e-01f,
  -5.73970750e-02f, -1.31711274e-01f, -2.36618817e-02f, -5.35324104e-02f, -1.40904739e-01f, 8.92528594e-02f, -3.59196519e-03f, -1.25957504e-01f, -1.32281423e-01f, 1.18673809e-01f,
  1.10902584e+00f, -3.38397205e-01f, 7.30564073e-02f, -1.96713492e-01f, -7.63935000e-02f, -1.05245844e-01f, 1.58627033e-01f, -1.25270570e-04f, -2.43097782e-01f, -9.74913016e-02f,
  -1.74197301e-01f, -3.03755850e-02f, 9.39162076e-02f, -1.35602402e-02f, -4.20192555e-02f, -1.20623438e-02f, -6.57311156e-02f, 8.38970859e-03f, -1.12045556e-01f, 2.91442778e-03f,
  -1.42750576e-01f, -6.71305060e-02f, -1.45887770e-02f, -9.63014215e-02f, -1.22040555e-01f, 1.26061395e-01f, -1.06259830e-01f, -9.63326395e-02f, -1.28028765e-01f, -6.37834370e-02f,
  -1.54914081e-01f, 1.32448310e-02f, -1.65836420e-02f, 8.62462595e-02f, 6.05842425e-03f, 5.09328507e-02f, 1.12215765e-01f, -8.73946175e-02f, -3.43185244e-03f, 3.56900208e-02f,
  6.32554591e-02f, 1.02188000e-02f, 4.84371521e-02f, -1.58505235e-02f, -7.28571191e-02f, 5.96063621e-02f, 6.96000084e-02f, -1.04150333e-01f, -9.97664407e-02f, -1.34261891e-01f,
  1.03536792e-01f, 6.45877048e-02f, -2.80894875e-03f, -4.14879806e-02f, -1.73115060e-01f, -3.29766721e-02f, 6.89557716e-02f, -3.23470086e-02f, -3.71960327e-02f, -1.12669773e-01f,
  4.72401857e-01f, -2.83708513e-01f, 4.06591982e-01f, 5.86053543e-02f, -4.18712065e-04f, -2.58760422e-01f, 7.84625560e-02f, -6.95523899e-03f, -8.39115456e-02f, 3.51353996e-02f,
  -5.50574362e-02f, 8.93242210e-02f, 2.92884279e-02f, -5.89294769e-02f, 1.79263934e-01f, -6.57475367e-02f, -1.91082656e-01f, 6.90638646e-02f, -1.85727969e-01f, -1.61169827e-01f,
  -2.36219913e-01f, -1.20305764e-02f, 3.93468231e-01f, 2.10177273e-01f, -6.25029430e-02f, 2.91631639e-01f, 3.19308579e-01f, 1.60261318e-01f, 1.85014695e-01f, 2.21946836e-03f,
  -6.52803838e-01f, -5.56431115e-01f, 4.84606445e-01f, 3.36033255e-01f, 7.49082789e-02f, -5.29544473e-01f, -8.39704096e-01f, -7.29758143e-01f, -1.55916497e-01f, -2.27422163e-01f,
  -4.05163109e-01f, -1.13274202e-01f, -5.82459606e-02f, 5.25862351e-02f, -1.58376545e-01f, 7.05053359e-02f, 6.38447106e-01f, 5.33339560e-01f, 1.23941779e-01f, -7.10607246e-02f,
  1.56288326e-01f, 2.67209828e-01f, 1.55720651e-01f, 2.67544627e-01f, 3.64980042e-01f, 2.45162845e-01f, 1.24106400e-01f, 1.77309290e-01f, 7.86251854e-03f, 8.28464091e-01f,
  -2.46686950e-01f, -4.39273953e-01f, 1.88176721e-01f, 5.42687289e-02f, 1.42157242e-01f, -2.15238389e-02f, -1.05257146e-01f, 6.28432184e-02f, 8.75907168e-02f, 2.02260137e-01f,
  2.32269883e-01f, 4.94960956e-02f, -1.04137279e-01f, 1.94270045e-01f, 4.02245522e-02f, 4.10910957e-02f, 2.57678866e-01f, 3.66031080e-02f, -2.63274107e-02f, -1.02352314e-01f,
  3.17511439e-01f, 7.07662990e-03f, -2.25300133e-01f, -9.34667513e-02f, -1.62625834e-01f, 1.50082916e-01f, -2.58922279e-01f, -3.35416608e-02f, -4.28780794e-01f, -1.97116271e-01f,
  -1.70579121e-01f, 1.07190609e-01f, 7.57727250e-02f, 2.19262335e-02f, 1.29559566e-03f, -1.53753813e-02f, 2.91768342e-01f, 3.51475962e-02f, 3.38947698e-02f, 1.42635688e-01f,
  5.95820427e-04f, 3.41830254e-02f, 1.08760614e-04f, -7.99589530e-02f, 5.21799289e-02f, 1.18319549e-01f, 9.80682075e-02f, 3.19860540e-02f, 2.73914505e-02f, 4.13144976e-02f,
  1.74417291e-02f, -5.70838414e-02f, 2.14632928e-01f, 2.10334972e-01f, 6.74251541e-02f, 2.82924891e-01f, 1.78470939e-01f, 3.85240093e-03f, -2.20320988e-02f, -7.23142847e-02f,
  -4.96172398e-01f, 2.22666562e-01f, 9.52500775e-02f, 1.12191193e-01f, 7.17207640e-02f, 9.59262848e-02f, 1.29099205e-01f, 1.13585219e-01f, 2.22235978e-01f, 5.91159314e-02f,
  -1.52496397e-01f, -2.09090814e-01f, -2.91294634e-01f, 1.69715375e-01f, -1.73955932e-02f, -2.84758639e-02f, 6.58671409e-02f, 1.20508507e-01f, -6.13656789e-02f, 2.23568939e-02f,
  1.05051443e-01f, -2.27358058e-01f, -5.37285089e-01f, -4.23040122e-01f, -2.62192935e-01f, -2.81059116e-01f, -1.66416451e-01f, -3.39183003e-01f, -5.31363547e-01f, -6.70584381e-01f,
  7.22089708e-01f, 1.95942044e-01f, -3.45249683e-01f, 5.11413515e-01f, 2.40321741e-01f, -4.93789583e-01f, -7.98008740e-01f, -5.97840190e-01f, 2.38616467e-01f, 5.74612431e-02f,
  2.70660520e-01f, 1.33544967e-01f, 7.45169669e-02f, -4.04482663e-01f, -9.51999426e-01f, -5.92100620e-01f, -5.03722012e-01f, -6.53975368e-01f, -9.98567164e-01f, -8.30218256e-01f,
  -2.49618590e-01f, -1.51848748e-01f, -3.14804435e-01f, -3.82860392e-01f, 5.13695955e-01f, 2.96689332e-01f, 2.73819268e-01f, 2.07975149e-01f, -1.37009531e-01f, 5.39982796e-01f,
  -7.70729110e-02f, 3.14494595e-02f, -2.11116955e-01f, 8.48681331e-02f, 2.27378637e-01f, -8.19853619e-02f, -2.88831681e-01f, -3.55753526e-02f, 1.04621097e-01f, -1.33082435e-01f,
  3.26151252e-01f, -1.59388661e-01f, -3.44348289e-02f, -7.35873953e-02f, -2.09458813e-01f, -3.30670327e-01f, -3.25020134e-01f, -5.07780433e-01f, -2.93197334e-01f, -2.53115892e-01f,
  5.71217686e-02f, -9.24627334e-02f, -1.55051649e-01f, -2.22201496e-01f, -2.85043120e-01f, 1.40745491e-01f, -1.01019591e-01f, -2.53926050e-02f, -2.30451912e-01f, 2.76620477e-01f,
  -8.22016150e-02f, 1.67498812e-01f, 5.52104861e-02f, -1.23600297e-01f, -3.11468095e-02f, 2.45403856e-01f, 1.12192571e-01f, -8.55570808e-02f, -1.33028194e-01f, 6.65292293e-02f,
  -1.54199123e-01f, 5.90850785e-03f, -1.37248755e-01f, -1.11769080e-01f, -1.46478554e-02f, -1.30078316e-01f, 1.00867473e-01f, -1.43684477e-01f, -2.00532153e-01f, 9.05022621e-02f,
  7.07877614e-03f, -9.10862535e-02f, 1.89623147e-01f, -1.91395476e-01f, -1.54032558e-01f, -2.76913866e-03f, -2.07103919e-02f, -3.94116491e-02f, -1.66631475e-01f, -8.65029022e-02f,
  2.95247704e-01f, -3.03442836e-01f, 3.00250679e-01f, -4.04214412e-01f, -3.70978378e-02f, 1.33707598e-01f, 1.54881120e-01f, -2.42131859e-01f, 2.20659658e-01f, -6.34955242e-02f,
  -1.69139504e-01f, 7.97761530e-02f, 1.02568813e-01f, 1.64398085e-02f, -2.02736348e-01f, 1.64655149e-02f, -5.08006662e-02f, 1.30033363e-02f, -3.57109040e-01f, 1.35574043e-02f,
  -7.00549548e-03f, -3.66316766e-01f, 1.48044601e-01f, 1.35680705e-01f, 3.20645608e-02f, 1.99933290e-01f, 1.71762913e-01f, 2.31945425e-01f, -1.84278637e-01f, 1.67045891e-01f,
  -2.36971587e-01f, -7.33070016e-01f, 7.80470490e-01f, -2.49287069e-01f, 4.31057334e-01f, 6.66173398e-01f, 8.82076323e-01f, 4.98876069e-03f, -3.02762896e-01f, 1.55030936e-01f,
  -3.94555777e-01f, -8.79328728e-01f, -6.91052735e-01f, -3.51820081e-01f, -6.59398958e-02f, 6.31121337e-01f, 6.71443224e-01f, 2.99755514e-01f, 3.45696449e-01f, 2.59639204e-01f,
  -7.29214326e-02f, -2.53852963e-01f, -2.57605165e-01f, -3.27370435e-01f, -2.93619007e-01f, -2.23849192e-01f, -8.62392709e-02f, -2.71298319e-01f, 1.01340925e-02f, -2.06417069e-01f,
  1.98380351e-01f, -4.83502537e-01f, 1.58999369e-01f, -2.37853378e-01f, -2.39042923e-01f, -1.63179591e-01f, -4.76517864e-02f, -3.56544465e-01f, -3.30168419e-02f, 9.86168440e-03f,
  -1.07462093e-01f, -2.35882491e-01f, -1.62635520e-01f, -2.26838857e-01f, -8.32290351e-02f, 5.56580536e-03f, -2.18629271e-01f, -2.51712620e-01f, -2.86093473e-01f, -5.78423850e-02f,
  -1.84420079e-01f, 1.83967799e-01f, 1.79823115e-01f, 1.86594084e-01f, -2.18395934e-01f, 7.63138011e-02f, -1.11301444e-01f, -1.71614662e-01f, -5.21618538e-02f, -4.91202921e-02f,
  2.45170534e-01f, 3.04531609e-03f, -5.86610138e-02f, -1.47349373e-01f, -2.47854199e-02f, 1.48463026e-01f, -8.92250463e-02f, -1.08313881e-01f, -1.34923728e-03f, -4.30700481e-02f,
  -2.74452828e-02f, -1.25807375e-02f, 1.28512811e-02f, 6.57545123e-03f, -9.15499702e-02f, -1.18587673e-01f, 1.86571673e-01f, -1.57124713e-01f, -6.87672645e-02f, -1.11142516e-01f,
  -2.52618253e-01f, 6.39835447e-02f, 4.56165001e-02f, -7.62553811e-02f, 1.77219044e-02f, -1.54851705e-01f, -9.02192593e-02f, -1.25159264e-01f, -5.24062850e-02f, 2.42867172e-02f,
  -3.93293083e-01f, 6.15769662e-02f, 6.21552579e-02f, -3.12313050e-01f, -4.13184948e-02f, -2.17758223e-01f, -2.81526446e-01f, -1.86034679e-01f, -9.85586420e-02f, 4.24584076e-02f,
  -7.38311484e-02f, -6.46273792e-02f, -1.44207969e-01f, 1.26477536e-02f, 2.31353879e-01f, 2.40487561e-01f, -3.81039776e-04f, -2.15625875e-02f, -4.05751318e-02f, 1.64703710e-03f,
  1.07936569e-01f, 2.19891757e-01f, 3.30782950e-01f, 3.16284657e-01f, 3.87082919e-02f, 3.71494651e-01f, 2.58060366e-01f, 2.73908824e-01f, 3.87649715e-01f, 4.01537627e-01f,
  1.47960556e+00f, -1.97208837e-01f, -9.83663082e-01f, 1.62327103e-02f, -5.96947074e-01f, -5.89886606e-01f, -6.21596098e-01f, 5.55283278e-02f, 2.65839845e-01f, -1.21138893e-01f,
  -1.10869633e-03f, 5.90958595e-01f, 4.30420220e-01f, 2.42113203e-01f, 6.29052579e-01f, -5.73926330e-01f, -4.05283570e-01f, 1.13012478e-01f, 1.24324873e-01f, -3.70733701e-02f,
  -1.00095659e-01f, 1.43317789e-01f, 6.51514292e-01f, 2.72669166e-01f, -6.94989860e-01f, -2.18833745e-01f, -6.98576152e-01f, -4.99994099e-01f, -4.45890039e-01f, -9.86380637e-01f,
  -6.50639236e-01f, -4.26698089e-01f, 2.41689503e-01f, 5.25380492e-01f, -1.32815123e-01f, 2.65223563e-01f, 4.96337339e-02f, -6.15946092e-02f, 2.82432288e-01f, -1.03451110e-01f,
  -1.15786076e-01f, 2.59072185e-01f, -9.41962656e-03f, -1.08396739e-01f, -1.66748211e-01f, 4.52341279e-03f, 2.51329560e-02f, 7.91900307e-02f, 1.79307058e-01f, -2.86125187e-02f,
  -2.44336665e-01f, -3.90242338e-01f, -3.59006017e-01f, -2.67796695e-01f, -3.33408952e-01f, 1.95540115e-02f, -7.04596698e-01f, -4.33138072e-01f, -5.66165633e-02f, -7.02421486e-01f,
  5.78647591e-02f, -4.32248600e-02f, -1.91714130e-02f, -1.35394931e-01f, 2.37912629e-02f, -2.61694100e-02f, -1.80498697e-02f, -5.79867251e-02f, -8.17189515e-02f, -1.25974312e-01f,
  -1.19302969e-03f, -2.10222993e-02f, -1.29803317e-02f, 6.57881796e-02f, -9.60887894e-02f, -6.04267791e-02f, 6.18322603e-02f, 9.52315778e-02f, -5.86484410e-02f, 1.16211578e-01f,
  -2.11779829e-02f, -7.08192885e-02f, -2.52514370e-02f, 1.16396837e-01f, -8.43518153e-02f, 3.61922458e-02f, -8.55805501e-02f, 1.19554766e-01f, -1.65574588e-02f, 1.03781916e-01f,
  4.41560686e-01f, 4.77746189e-01f, -2.88085602e-02f, 1.74122438e-01f, 1.74669921e-02f, 1.02601334e-01f, -7.15377703e-02f, 8.32627788e-02f, -8.69261846e-02f, 6.55119643e-02f,
  -4.08928655e-02f, 1.88338086e-01f, 7.13026598e-02f, 5.65472466e-04f, -4.67051342e-02f, 1.64287779e-02f, 3.27059090e-01f, -1.25199839e-01f, -5.86473010e-02f, -1.66294500e-01f,
  9.82235447e-02f, 2.03881174e-01f, 9.75575596e-02f, -9.57357287e-02f, -3.54816139e-01f, 1.55281916e-01f, -3.08461994e-01f, -3.22927415e-01f, 3.78204882e-01f, 2.57694632e-01f,
  -3.65089774e-01f, 5.30818403e-01f, -4.40179497e-01f, 6.38592005e-01f, -5.44055086e-03f, -2.56242216e-01f, -5.78768924e-02f, 2.22191557e-01f, 4.61097389e-01f, 3.62544954e-01f,
  -1.33225471e-01f, -3.93642969e-02f, 2.61652410e-01f, -2.82618757e-02f, -3.00860494e-01f, 2.96850532e-01f, 3.68240923e-01f, -4.13074940e-01f, -7.84616411e-01f, -5.04475415e-01f,
  2.03885868e-01f, 3.74636739e-01f, -8.31968337e-02f, -1.72998503e-01f, 3.94535184e-01f, 1.98366612e-01f, 3.29676419e-01f, 9.60431397e-02f, -1.88663319e-01f, 3.41061831e-01f,
  -1.52340785e-01f, -4.04664576e-01f, -1.46472588e-01f, -7.64028803e-02f, -4.51169685e-02f, -9.67878252e-02f, -3.01942140e-01f, 4.50484864e-02f, -1.36264265e-01f, 2.17474587e-02f,
  -1.96779639e-01f, -2.34628499e-01f, -1.94843978e-01f, -1.65552065e-01f, -1.27108023e-01f, -2.32163370e-01f, 3.62203866e-02f, -1.82214096e-01f, -7.94732422e-02f, -2.93085814e-01f,
  1.50270562e-03f, -4.25434411e-01f, -3.39719206e-01f, -4.13794778e-02f, -3.32002044e-01f, -3.50205809e-01f, -2.59344429e-01f, -5.46068788e-01f, -6.20447099e-01f, 2.71590382e-01f,
  3.40579152e-02f, 6.69470504e-02f, -3.02366801e-02f, 9.28191468e-02f, 1.47485927e-01f, 3.13748941e-02f, 4.37537357e-02f, -3.45182419e-02f, 3.27727268e-03f, 8.42222944e-02f,
  -1.84858277e-01f, 3.36328074e-02f, 7.81122148e-02f, -1.29725765e-02f, 1.95142739e-02f, 1.36551494e-02f, -4.65361625e-02f, 1.97819099e-01f, -1.29380673e-01f, 6.16700873e-02f,
  -6.14751093e-02f, -6.54357448e-02f, 5.47968671e-02f, 1.44731700e-02f, -1.35283202e-01f, -6.70152381e-02f, 8.33605509e-03f, -1.88794285e-01f, 8.39296877e-02f, -3.57999541e-02f,
  7.56749153e-01f, -3.84588152e-01f, 4.18407649e-01f, 7.02481717e-02f, 6.37457520e-02f, -1.19024180e-01f, 1.50632605e-01f, -7.11976783e-03f, -4.54131700e-02f, -1.15707241e-01f,
  -2.57707983e-01f, -2.01448858e-01f, 7.22012967e-02f, 5.45697194e-03f, -7.63029680e-02f, -6.72286749e-02f, 2.42074415e-01f, 1.78373292e-01f, 1.97129056e-01f, 1.53543934e-01f,
  4.15805876e-01f, 1.51806608e-01f, 1.98739499e-01f, 4.16404098e-01f, 2.47078761e-01f, 2.15818211e-02f, 2.27002323e-01f, 9.63519141e-02f, -2.86699105e-02f, 7.61347950e-01f,
  -6.99775875e-01f, -7.15929866e-01f, -6.13629103e-01f, 2.83325225e-01f, 7.80849934e-01f, -3.76530178e-02f, -8.22677433e-01f, -4.94059205e-01f, 2.15239555e-01f, -4.35995191e-01f,
  3.33352149e-01f, 6.49971187e-01f, 2.38692284e-01f, 1.58185706e-01f, -4.03984278e-01f, -6.25475347e-01f, -2.29011372e-01f, -1.73131824e-01f, 2.29016766e-01f, 5.08970559e-01f,
  6.00226879e-01f, 2.14283243e-01f, -1.16104111e-02f, -2.42111888e-02f, 2.15673268e-01f, 3.13710362e-01f, -7.99207017e-02f, 2.84945369e-01f, -8.15108269e-02f, 3.88407223e-02f,
  -3.14575613e-01f, -5.21785796e-01f, -8.11763853e-03f, 4.79315132e-01f, 3.21798742e-01f, -5.85733116e-01f, -2.60468483e-01f, -2.44853795e-01f, 1.15458205e-01f, -3.34797084e-01f,
  2.45865598e-01f, -5.15405796e-02f, 3.38426739e-01f, -4.43979986e-02f, -9.20367893e-03f, -3.58573407e-01f, -1.38847634e-01f, -4.23623532e-01f, -4.80217367e-01f, -6.07010201e-02f,
  5.72987914e-01f, 4.59080070e-01f, -2.14680359e-01f, -1.91931501e-01f, -4.85602915e-01f, 3.00801061e-02f, -3.81758183e-01f, -3.06677699e-01f, -7.45245516e-01f, -7.08646178e-01f,
  6.13675937e-02f, 1.84087694e-01f, 6.66330904e-02f, -6.30817190e-02f, 7.77223632e-02f, 1.72012329e-01f, -5.77039160e-02f, 1.08040810e-01f, 1.43949226e-01f, -7.67339692e-02f,
  3.42490822e-02f, -1.12630129e-01f, 4.56086285e-02f, -2.04822034e-01f, -1.54055674e-02f, -9.03234780e-02f, 1.66978016e-02f, -1.25166520e-01f, 8.62798467e-02f, -1.64584354e-01f,
  6.60426915e-02f, 2.67611090e-02f, 1.32235289e-01f, -1.23837009e-01f, -9.53579098e-02f, -1.27172738e-01f, -1.18735187e-01f, 5.24039119e-02f, 4.02086861e-02f, -4.41210009e-02f,
  -1.62296835e-02f, -6.73312098e-02f, -2.33883277e-01f, -1.37802139e-01f, 2.13094167e-02f, 1.74896404e-01f, 2.72695012e-02f, -6.47334615e-03f, -6.14645630e-02f, -2.00374052e-01f,
  -2.33747542e-01f, -3.02146047e-01f, -2.18869448e-01f, -3.54740806e-02f, 6.00421391e-02f, -8.87440518e-02f, -3.36300172e-02f, 7.70819709e-02f, -7.01038018e-02f, 1.76770672e-01f,
  -1.81315199e-01f, -2.67233223e-01f, -3.89591783e-01f, -4.30326194e-01f, -5.06048612e-02f, -1.99707672e-01f, -3.39055896e-01f, -3.23694348e-01f, -5.01500189e-01f, -9.51562524e-01f,
  6.56680822e-01f, -3.96717489e-01f, 1.58944905e-01f, 5.11854827e-01f, 4.58495110e-01f, 4.44389910e-01f, 2.76167244e-01f, 2.29037747e-01f, 3.09056073e-01f, 2.29750693e-01f,
  1.95985615e-01f, 2.98225254e-01f, 1.63077608e-01f, -7.98239838e-03f, 1.74438521e-01f, 4.68152836e-02f, 2.17555076e-01f, 2.12125912e-01f, 1.30621240e-01f, -8.42913333e-03f,
  -1.30430996e-01f, 1.08035289e-01f, 7.67191872e-02f, -8.15027580e-02f, -2.28441507e-01f, 1.12126999e-01f, 8.20468441e-02f, 1.38734421e-02f, -1.63077474e-01f, -4.61923271e-01f,
  -5.17320454e-01f, -2.13266388e-02f, -2.74772607e-02f, -2.78824810e-02f, -2.42621318e-01f, -1.54875964e-01f, -1.38157262e-02f, -1.60233483e-01f, -1.80527121e-01f, -1.01856187e-01f,
  -1.79717094e-01f, -7.96953812e-02f, -1.75844951e-04f, -4.47314270e-02f, -4.08318415e-02f, -8.65107849e-02f, -5.69024868e-03f, 5.19548692e-02f, 2.44560596e-02f, -1.22267596e-01f,
  -1.18771568e-01f, 8.59922692e-02f, 1.05525859e-01f, 1.35897115e-01f, 4.21075821e-02f, 1.06435165e-01f, -1.04648367e-01f, -8.22434798e-02f, 8.28283560e-03f, 1.64552722e-02f,
  9.72488299e-02f, 1.48807690e-01f, 1.04249246e-01f, 2.56962687e-01f, 8.52451101e-02f, 1.99350357e-01f, 1.75062284e-01f, 1.34513289e-01f, 2.47336000e-01f, 4.10499647e-02f,
  2.20788810e-02f, 2.31951877e-01f, 1.74859494e-01f, 7.14130551e-02f, 1.62029669e-01f, 7.28194639e-02f, -4.84281518e-02f, -9.71073210e-02f, 9.63165835e-02f, 1.73477177e-03f,
  1.25624239e-01f, -1.29314557e-01f, -1.61478430e-01f, -2.33261064e-01f, -1.91753566e-01f, 6.51359856e-02f, 1.52193056e-02f, -7.28072226e-02f, -4.42228243e-02f, -1.61401525e-01f,
  1.71885807e-02f, 5.52790761e-01f, -2.32224204e-02f, -4.81580459e-02f, -7.63276815e-02f, -1.16410419e-01f, 7.26836622e-02f, -1.20759845e-01f, -3.48823518e-01f, -1.12389438e-01f,
  -1.05873115e-01f, -8.59152526e-02f, -3.22520696e-02f, -3.32461521e-02f, 2.19279349e-01f, 1.11720905e-01f, -3.38419415e-02f, 6.96936622e-02f, 1.78392231e-02f, -1.09208442e-01f,
  -1.57370254e-01f, 2.43154615e-01f, 3.42433095e-01f, 3.15973580e-01f, 1.72614425e-01f, 3.64154339e-01f, 3.98265459e-02f, -5.77329844e-02f, 1.75701186e-01f, 1.19484365e-01f,
  2.38465354e-01f, -5.60175121e-01f, -1.28794417e-01f, 4.71455812e-01f, -5.31974733e-01f, -6.41904354e-01f, -7.81453371e-01f, 3.13049257e-01f, 3.15968186e-01f, -6.03224218e-01f,
  -7.56285965e-01f, -2.30573565e-01f, -1.32292211e-01f, -2.87562963e-02f, 2.19057888e-01f, -5.40951014e-01f, -1.58545509e-01f, 4.63839173e-01f, 5.95363081e-01f, -4.94573414e-02f,
  -3.26254725e-01f, 3.19741994e-01f, 7.45857775e-01f, 4.77058619e-01f, -1.51255995e-01f, -5.53862415e-02f, -1.05976790e-01f, -9.21024382e-02f, -5.63511968e-01f, -6.72574520e-01f,
  -3.87875527e-01f, 7.73240998e-02f, 1.02115080e-01f, -1.38521254e-01f, -2.18294352e-01f, -5.71887568e-02f, 3.55722988e-03f, 2.78081447e-01f, -1.73465148e-01f, -1.42709225e-01f,
  -2.28474393e-01f, -8.47405717e-02f, -1.73630595e-01f, 5.33087663e-02f, 6.78563267e-02f, -9.84014049e-02f, 4.14959192e-01f, 3.99228215e-01f, 5.96333854e-02f, -1.65952504e-01f,
  -5.17676353e-01f, -5.48179984e-01f, -2.14181542e-01f, 7.06120506e-02f, 2.10490406e-01f, 1.35224890e-02f, 1.50475502e-01f, 1.46305300e-02f, 1.89959109e-01f, -2.87497431e-01f,
  -8.10458511e-02f, -6.11339808e-02f, 4.10798155e-02f, 1.50935590e-01f, 6.69637024e-02f, -5.27914194e-03f, 1.28870368e-01f, -2.36784428e-01f, -9.12216380e-02f, -3.27760391e-02f,
  -7.61614740e-02f, -1.23782389e-01f, -3.39960009e-02f, -1.02355450e-01f, -4.16726507e-02f, -1.75948590e-01f, -1.64047673e-01f, 1.43112853e-01f, -1.06197596e-01f, -4.80185449e-02f,
  2.65843999e-02f, 4.68848981e-02f, 6.06895946e-02f, -2.66607497e-02f, -9.65752974e-02f, 9.88637358e-02f, -1.16675295e-01f, -3.31077576e-02f, 9.70304012e-02f, -2.08437696e-01f,
  1.74454153e-01f, 1.43944412e-01f, -4.29023087e-01f, 5.11173233e-02f, -1.15213662e-01f, -4.67491634e-02f, -2.71428257e-01f, 2.23723892e-02f, -1.21232823e-01f, -1.35463744e-01f,
  -1.08150639e-01f, -2.40451470e-02f, 2.22620945e-02f, 1.95686847e-01f, 3.46750999e-03f, -2.54290372e-01f, -1.59182534e-01f, -3.23294610e-01f, -1.80959255e-02f, -8.63492563e-02f,
  2.54160076e-01f, -2.52302945e-01f, -3.26667696e-01f, -2.66524255e-01f, -1.49888799e-01f, -1.77783817e-01f, -1.39273822e-01f, -3.83492559e-01f, -2.69731820e-01f, -3.90444517e-01f,
  -1.51801214e-01f, 3.50691259e-01f, 3.80143821e-01f, -7.10635334e-02f, 2.44300053e-01f, 5.02690732e-01f, 7.97278106e-01f, 4.28876936e-01f, -9.50573012e-02f, -1.75543074e-02f,
  -3.73657852e-01f, -5.45561314e-01f, -3.75942200e-01f, -2.95143843e-01f, 1.06553376e-01f, 3.53845507e-01f, 3.56130779e-01f, -9.77499131e-03f, -9.62027460e-02f, -1.36928737e-01f,
  -1.93675831e-01f, -2.50143278e-03f, -2.25702405e-01f, 1.04088224e-01f, 3.36743206e-01f, -7.02126771e-02f, 1.20221764e-01f, 2.23319560e-01f, 9.51852724e-02f, 5.75907864e-02f,
  -4.27035064e-01f, 3.06908101e-01f, -4.65781450e-01f, -3.07678163e-01f, -6.63995072e-02f, -1.71450272e-01f, -1.93588421e-01f, -1.73843071e-01f, -1.43703213e-02f, -5.47414720e-02f,
  -8.41317549e-02f, -7.17522278e-02f, 1.08662158e-01f, 4.94421162e-02f, 2.61148751e-01f, 1.41713142e-01f, 9.31302607e-02f, 1.14923857e-01f, -1.47935450e-01f, -2.43299603e-01f,
  -3.40124905e-01f, -1.03902519e-01f, 1.56261146e-01f, 2.53947854e-01f, 1.51994452e-01f, -2.91395545e-01f, 3.24095696e-01f, 9.62670818e-02f, 9.29467380e-02f, 1.20148636e-01f,
  -4.22785878e-01f, 1.47674248e-01f, 1.80081278e-01f, -1.06431708e-01f, -1.03302926e-01f, -1.11135907e-01f, 1.19573670e-02f, -9.74122062e-03f, 8.13193172e-02f, 1.51008397e-01f,
  -2.34866980e-02f, -2.62712330e-01f, -5.20205460e-02f, -1.78752869e-01f, -3.56968194e-01f, -1.08073123e-01f, 2.26585791e-01f, -7.18496665e-02f, -1.45582289e-01f, 6.55401545e-03f,
  -3.98024991e-02f, 1.70311555e-01f, 4.22570482e-02f, 7.87716582e-02f, -1.56319439e-01f, -1.74758825e-02f, -1.51216805e-01f, -7.71460831e-02f, -1.47584090e-02f, -4.85605709e-02f,
  -3.73587400e-01f, -2.53005475e-01f, -3.46791238e-01f, 1.98295057e-01f, 2.47871831e-01f, 4.51023839e-02f, -2.53790319e-01f, -1.01491854e-01f, 2.06232831e-01f, -9.19506848e-02f,
  4.68274727e-02f, -2.88827509e-01f, -1.25368208e-01f, 2.99600847e-02f, -7.26012513e-02f, 1.40090135e-03f, -2.49783263e-01f, -2.68967506e-02f, -2.49974370e-01f, -7.12967217e-02f,
  -3.56421433e-02f, -6.07028091e-03f, -2.58544683e-01f, 1.05652456e-04f, -3.51123840e-01f, -5.96292078e-01f, -7.03822449e-02f, 4.43460867e-02f, -3.35228182e-02f, -2.84303515e-03f,
  -6.20306790e-01f, 1.54227048e-01f, -8.24741542e-01f, -2.82515675e-01f, -8.23708698e-02f, -1.26563400e-01f, 3.29119891e-01f, 3.41971695e-01f, 2.54234433e-01f, 3.12443346e-01f,
  2.07293078e-01f, -1.44774631e-01f, -6.00319862e-01f, -5.53981185e-01f, -7.85065651e-01f, -2.63348460e-01f, -5.81223667e-01f, -8.88030648e-01f, -4.30902272e-01f, 3.18866581e-01f,
  2.97588468e-01f, -2.02931762e-01f, -3.86635929e-01f, -1.15992866e-01f, 4.16479766e-01f, -3.18915337e-01f, -2.24690601e-01f, -4.12009656e-01f, -4.27610308e-01f, -3.41744304e-01f,
  -6.99433535e-02f, -9.03117657e-02f, -1.32629946e-01f, -3.24551314e-01f, -1.85039937e-01f, -8.32058564e-02f, 3.07816327e-01f, -1.82229221e-01f, -1.19400084e-01f, 4.94257361e-02f,
  -1.81338653e-01f, 3.64591256e-02f, 6.58810586e-02f, 7.46071264e-02f, 1.17312953e-01f, 2.66531482e-02f, -3.25993389e-01f, -2.33503640e-01f, -4.58062649e-01f, 1.51099458e-01f,
  -9.59217325e-02f, -4.12874758e-01f, -7.30182290e-01f, -2.90753096e-01f, -6.38395846e-02f, -5.26490450e-01f, 9.02984738e-02f, -8.51429105e-02f, -6.46631122e-01f, 1.13177478e-01f,
  1.61199078e-01f, 8.71671364e-03f, -3.75489937e-03f, 1.68272719e-01f, 2.67093062e-01f, 8.52326751e-02f, 6.68131709e-02f, 8.13142732e-02f, 6.17758185e-02f, -1.61550656e-01f,
  5.07919155e-02f, 1.97597668e-01f, 1.61307305e-01f, 6.66615963e-02f, -9.30012167e-02f, -9.67121199e-02f, -4.58779670e-02f, 1.26632228e-01f, -2.47903571e-01f, -1.43669099e-02f,
  -1.19913436e-01f, 3.14006321e-02f, -3.99593599e-02f, 3.16881947e-02f, -2.55156517e-01f, -1.39603347e-01f, 1.12825736e-01f, 3.19801480e-01f, 1.31210685e-01f, 6.04007281e-02f,
  1.40146106e-01f, -2.90490240e-01f, -4.05586092e-03f, -4.21967767e-02f, -1.06613599e-01f, -1.04195597e-02f, -1.40402853e-01f, -1.28510699e-01f, 3.87140512e-02f, 2.62158394e-01f,
  3.46446335e-01f, 2.07314998e-01f, 4.98098172e-02f, 2.56421059e-01f, 3.27552438e-01f, -9.08662528e-02f, -2.27440104e-01f, -2.06476331e-01f, -3.26392442e-01f, 3.33661973e-01f,
  -5.59605584e-02f, -1.37654230e-01f, -4.32423681e-01f, -1.85776800e-01f, -3.86255905e-02f, -4.74478513e-01f, 1.54359415e-02f, 2.30358124e-01f, -5.32001853e-01f, 4.62718874e-01f,
  -6.12524629e-01f, 6.49968207e-01f, -1.65885985e-01f, -5.01345575e-01f, -1.60422370e-01f, 3.01165134e-01f, 8.56437922e-01f, 4.48977724e-02f, -5.52032113e-01f, 1.46703959e-01f,
  -7.16431858e-03f, -3.40412527e-01f, -2.92489976e-01f, 8.74848664e-02f, 4.62894976e-01f, 5.43350339e-01f, 3.73025298e-01f, 1.34402588e-01f, -9.56319496e-02f, 1.57102525e-01f,
  3.66690904e-01f, -3.74917127e-02f, -1.78136811e-01f, -8.62452853e-03f, -1.81552976e-01f, -1.85346231e-01f, -1.27631903e-01f, -1.27087876e-01f, 4.16544437e-01f, 4.79244858e-01f,
  -4.36671823e-03f, -2.54753828e-01f, -1.70796305e-01f, -2.67367125e-01f, -1.04338430e-01f, 1.54622823e-01f, 9.38349888e-02f, -1.61835983e-01f, -1.08422130e-01f, -1.07655801e-01f,
  -1.40481517e-01f, -2.01222533e-03f, -1.03028603e-01f, 4.47075069e-02f, -2.40892962e-01f, -4.01855856e-02f, -4.33647372e-02f, 5.47173470e-02f, -1.01394035e-01f, -6.76432177e-02f,
  4.05390650e-01f, -3.09699088e-01f, -6.03275657e-01f, -2.11608842e-01f, -7.85995349e-02f, -4.81274635e-01f, -8.28741491e-02f, 3.59897166e-02f, -1.84313595e-01f, -4.76015396e-02f,
  -1.31284326e-01f, -5.27262837e-02f, 6.90875128e-02f, 1.57664567e-01f, 2.18074068e-01f, -6.46144710e-03f, 1.10753365e-01f, 2.82130003e-01f, 1.48236051e-01f, 4.24842499e-02f,
  -8.05803984e-02f, -1.44095704e-01f, -1.21693619e-01f, -5.62522262e-02f, -1.38240337e-01f, -1.30558893e-01f, 1.51261821e-01f, 2.09580660e-01f, 9.38068628e-02f, 4.12886143e-02f,
  -2.96210940e-03f, -9.97615978e-03f, -5.01516759e-01f, 4.34562676e-02f, 1.49639010e-01f, 2.74178945e-02f, -6.61273599e-02f, 4.49451897e-03f, -2.54975080e-01f, -2.10319739e-02f,
  -4.74403173e-01f, 1.85219780e-01f, -9.73071232e-02f, 8.48075598e-02f, -2.08382914e-03f, -7.02583641e-02f, -1.13401547e-01f, 3.29706608e-03f, -1.91120297e-01f, -3.92357782e-02f,
  5.88070899e-02f, -8.63765657e-04f, -3.51665504e-02f, 9.26886648e-02f, -1.97706670e-01f, -2.63770938e-01f, 1.71452060e-01f, -6.75993636e-02f, 4.52781580e-02f, -2.57494420e-01f,
  9.22864601e-02f, -1.18183747e-01f, -6.16843641e-01f, -3.80232513e-01f, -2.87790984e-01f, -5.76244414e-01f, -3.06176573e-01f, -2.02870771e-01f, -2.44677782e-01f, -8.75232816e-02f,
  6.65572882e-02f, 3.97785097e-01f, -1.79427966e-01f, 3.60254377e-01f, 2.06539363e-01f, 1.87466279e-01f, 2.04688385e-01f, 8.94874930e-02f, 2.86620766e-01f, 3.24714452e-01f,
  3.84385645e-01f, 4.10037011e-01f, 2.41023377e-01f, 2.73226798e-01f, 2.65926301e-01f, 2.27046341e-01f, 1.85554519e-01f, 2.54445150e-02f, -2.39431430e-02f, 2.08225280e-01f,
  4.11742926e-01f, 2.49684900e-01f, 2.44467467e-01f, 1.71800166e-01f, 3.47993940e-01f, 3.63002211e-01f, 2.62536675e-01f, 2.73338288e-01f, 3.26236665e-01f, 5.54963768e-01f,
  1.16105683e-01f, 8.78405347e-02f, -1.54776737e-01f, 7.29357004e-02f, -1.29727751e-01f, -2.08306968e-01f, -1.06934614e-01f, -2.74988234e-01f, -8.75990018e-02f, -3.81280445e-02f,
  -7.65849575e-02f, -1.88232869e-01f, -6.85838331e-03f, -2.70554423e-01f, -1.54131487e-01f, -1.99693561e-01f, -1.34318143e-01f, -8.36584195e-02f, -1.51869636e-02f, 9.51797795e-03f,
  6.93092123e-02f, -1.47128375e-02f, -1.34712607e-02f, -5.80257140e-02f, -8.85625556e-03f, -7.15965256e-02f, -1.23867810e-01f, -1.77129041e-02f, -1.77542061e-01f, -1.34907663e-01f,
  -8.12510774e-02f, 7.27883652e-02f, -4.43724766e-02f, -1.16283566e-01f, -1.68811738e-01f, -1.94497496e-01f, -8.34561735e-02f, 2.92107351e-02f, -1.98134691e-01f, -1.76938027e-01f,
  -4.18378748e-02f, -4.03808877e-02f, -7.38748759e-02f, -1.58496592e-02f, -4.69890423e-02f, -1.26533002e-01f, -8.99024382e-02f, 1.77276507e-02f, -1.73737273e-01f, -1.77180707e-01f,
  -1.46848366e-01f, -1.62661169e-02f, -1.35704681e-01f, 8.86933040e-03f, 3.23476493e-02f, -1.00913696e-01f, -5.36491089e-02f, -7.74791539e-02f, 9.85471159e-02f, 1.56154901e-01f,
  2.55305201e-01f, -1.08233385e-01f, 2.05083102e-01f, 1.75777167e-01f, 7.39370584e-02f, -1.03389196e-01f, 5.58689050e-02f, -3.61533128e-02f, -5.50176725e-02f, 7.78244585e-02f,
  -2.50278786e-02f, -1.05576031e-01f, -2.98335832e-02f, -8.41111541e-02f, -1.95500642e-01f, -8.07949454e-02f, 4.99345623e-02f, 1.73949048e-01f, 1.43399909e-01f, 2.39718147e-02f,
  1.81778334e-02f, -1.85245171e-01f, -1.72922999e-01f, -1.56647712e-01f, 3.41696925e-02f, 1.95901375e-02f, -2.49115095e-01f, -6.52931817e-03f, -1.54259041e-01f, -2.87821561e-01f,
  1.26053357e+00f, -1.73751175e-01f, 2.88675219e-01f, 2.29179904e-01f, -1.57114699e-01f, 4.35885675e-02f, 2.92674988e-03f, 1.88594148e-01f, 1.75650746e-01f, 1.94438726e-01f,
  -1.77682657e-02f, -7.18600489e-03f, 1.40076488e-01f, 5.41862398e-02f, 1.45079479e-01f, 6.09669536e-02f, 3.38319167e-02f, 4.44102377e-01f, 3.42414111e-01f, 1.66323707e-01f,
  4.55458201e-02f, 1.30930454e-01f, 3.01739186e-01f, 2.03817800e-01f, -6.12652637e-02f, 1.27728984e-01f, 9.76984575e-02f, 1.68579482e-02f, 4.19035479e-02f, -3.25809978e-02f,
  3.01441755e-02f, 4.19875234e-01f, 1.09032683e-01f, -7.05534965e-02f, -1.85087740e-01f, -7.61929229e-02f, -1.98815558e-02f, -1.62029192e-01f, -1.78264111e-01f, 2.31574895e-03f,
  -2.15572029e-01f, 9.06164292e-03f, 9.05228127e-03f, -6.03332035e-02f, -1.03908300e-01f, -1.00646988e-01f, 1.29768237e-01f, 1.43160075e-01f, 1.60453841e-01f, -7.65651539e-02f,
  -1.82662576e-01f, -2.18483105e-01f, -1.88500062e-02f, -9.18041021e-02f, 1.49606932e-02f, -4.01146971e-02f, -6.98786899e-02f, -9.99739543e-02f, 1.01312250e-01f, 9.25737247e-02f,
  2.65917391e-01f, 2.70318568e-01f, 2.37054408e-01f, 1.23288468e-01f, 2.10140347e-01f, 1.42436296e-01f, 3.24226171e-03f, -6.73366413e-02f, 2.44498789e-01f, 1.22303292e-01f,
  3.29977013e-02f, 1.57515839e-01f, 2.02417493e-01f, -8.23466573e-03f, -1.98807567e-01f, -1.54675469e-01f, -3.20714206e-01f, -1.90185264e-01f, 1.47130743e-01f, -2.18926873e-02f,
  1.50326580e-01f, 1.04408681e-01f, 2.25837454e-02f, -6.58742860e-02f, -4.06308956e-02f, 3.32351625e-02f, 4.21072543e-02f, -5.57709932e-02f, -5.00038266e-02f, 7.81211245e-04f,
  -6.46761477e-01f, 1.87426567e-01f, 2.26712957e-01f, 9.84605961e-03f, -5.80057912e-02f, -2.23351680e-02f, 1.06381238e-01f, -1.32167593e-01f, -2.31537923e-01f, -6.75285831e-02f,
  -2.29032159e-01f, -2.20253039e-02f, -1.07341474e-02f, 6.30273595e-02f, 1.05625473e-01f, -1.49411142e-01f, -1.68096632e-01f, -3.58288884e-02f, -5.55351414e-02f, -1.57733217e-01f,
  -2.50631690e-01f, -5.98637909e-02f, -7.03861639e-02f, -4.88087907e-02f, -2.93557327e-02f, 6.03497215e-02f, -1.62276775e-02f, -8.16949084e-02f, 1.38160333e-01f, 1.47856936e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  7.94630289e-01f, 1.00076497e+00f, 1.16994095e+00f, 1.02808404e+00f, 5.97126067e-01f, -7.93996751e-02f, 1.43673790e+00f, 8.50479305e-01f, 4.00653630e-01f, 1.29390264e+00f,
  1.09692216e+00f, 8.10357630e-01f, 2.44490832e-01f, 7.17592478e-01f, 6.94868624e-01f, 8.39737296e-01f, 8.44329894e-01f, 5.64752102e-01f, 4.66614604e-01f, 9.45819616e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -5.25686204e-01f, -2.23347060e-02f, 3.91693146e-04f, -4.75479186e-01f, -1.53560907e-01f, -3.23317945e-01f, -2.73526788e-01f, -4.89184529e-01f, -4.14936751e-01f, 2.80985415e-01f,
  3.04757029e-01f, -3.47338706e-01f, -5.73813096e-02f, -1.61406159e-01f, -5.41973054e-01f, -2.62667418e-01f, -1.64793754e+00f, 5.34324169e-01f, -8.97381485e-01f, -3.17212552e-01f,
  -2.44506717e-01f, -7.92517066e-01f, 2.30621278e-01f, -9.22045946e-01f, 7.14960992e-01f, -8.58927444e-02f, 5.76162219e-01f, -4.88075167e-01f, 5.15201151e-01f, -5.94107568e-01f,
  -9.16752934e-01f, -3.80206168e-01f, 1.43908247e-01f, 1.30291671e-01f, 3.76467973e-01f, -2.23266244e-01f, 2.53990352e-01f, -9.10977349e-02f, 1.96090356e-01f, 1.22464783e-01f,
  -2.01939404e-01f, 2.35718802e-01f, -4.39648598e-01f, -2.19909713e-01f, -7.04787254e-01f, -9.79475439e-01f, -7.27147698e-01f, -6.04490101e-01f, -2.80425157e-02f, 9.59977090e-01f,
  7.86683336e-02f, -9.71539497e-01f, 3.00648272e-01f, -3.25821489e-01f, 8.94429266e-01f, -6.62615299e-01f, -2.20928013e-01f, 3.51683497e-01f, 1.21257916e-01f, -4.82797414e-01f,
  -1.35806429e+00f, -2.73807019e-01f, -1.96266323e-01f, 1.00206029e+00f, 1.45772770e-01f, -6.82735592e-02f, 2.14094877e-01f, 9.78778626e-05f, 2.08573401e-01f, 6.32012784e-02f,
  5.57718992e-01f, 4.14044589e-01f, -2.31233925e-01f, 4.27771360e-01f, -3.60891074e-01f, -2.91497529e-01f, 4.83345062e-01f, 4.81435597e-01f, -1.10675514e+00f, -5.84405899e-01f,
  -4.35240537e-01f, -5.44195712e-01f, -1.84566662e-01f, 7.37789929e-01f, -7.70642757e-01f, 8.39442015e-02f, 3.44944447e-01f, -6.06631935e-01f, 2.41610840e-01f, 2.70256817e-01f,
  1.20028007e+00f, -3.83369058e-01f, -9.85270262e-01f, -3.22980165e-01f, -1.16386557e+00f, -2.70933479e-01f, 1.15712816e-02f, 4.92492691e-02f, -3.25126648e-01f, 1.59165055e-01f,
  -1.75445557e-01f, 1.38512224e-01f, -5.93438558e-02f, -1.04231864e-01f, 5.45122981e-01f, 6.20664954e-02f, 5.53848982e-01f, -1.43590778e-01f, 7.40002692e-01f, -7.92014778e-01f,
  -1.01202381e+00f, 1.73811972e-01f, 4.82201993e-01f, 2.17793420e-01f, -9.69425142e-01f, -2.83915192e-01f, -6.38820887e-01f, 5.84827125e-01f, -1.33199885e-01f, -9.99743104e-01f,
  -3.85510504e-01f, -4.17649686e-01f, -6.87820852e-01f, -2.77301501e-02f, 2.53256232e-01f, 9.00058210e-01f, -7.28874445e-01f, -2.80873239e-01f, -1.07740201e-01f, 2.05222219e-02f,
  -2.18116239e-01f, 1.69357695e-02f, 1.42899137e-02f, -2.21857980e-01f, 1.54207632e-01f, 1.64553553e-01f, 2.08036616e-01f, -1.49546891e-01f, -2.10280061e-01f, 2.45495349e-01f,
  2.03084350e-01f, 3.87169957e-01f, -2.73957223e-01f, 5.83450615e-01f, 6.76144958e-01f, -2.33296350e-01f, -6.46792650e-01f, 4.87948135e-02f, 6.47940278e-01f, -1.15422142e+00f,
  -4.76333320e-01f, 5.69316410e-02f, -7.69807100e-02f, 2.25125834e-01f, -1.01226093e-02f, 8.32851008e-02f, 2.11244076e-01f, -1.16935492e+00f, -4.44193967e-02f, -4.24045712e-01f,
  5.10560833e-02f, 2.29660049e-01f, 9.97802764e-02f, 5.21744967e-01f, 2.26748794e-01f, 1.62158489e-01f, -4.97540534e-01f, -7.73360133e-02f, -4.60811436e-01f, -4.11039703e-02f,
  1.79777130e-01f, -8.89396816e-02f, -1.34492946e+00f, 9.15361419e-02f, 6.16842210e-01f, 4.69091892e-01f, -1.18789780e+00f, -7.72564948e-01f, -1.04006517e+00f, -7.91436315e-01f,
  4.31197524e-01f, -1.44614756e-01f, 6.80808485e-01f, 9.23829794e-01f, -2.75209427e-01f, -1.90858081e-01f, 4.31050248e-02f, -6.08184040e-01f, 4.12119329e-01f, 1.84324626e-02f,
  1.81369022e-01f, -2.49316692e-01f, 6.06188811e-02f, 2.35151097e-01f, 1.17429607e-01f, 1.07275695e-01f, -3.92136335e-01f, 1.73655123e-01f, -1.82456985e-01f, 8.24343935e-02f,
  3.53825033e-01f, -4.14816022e-01f, -3.20486784e-01f, 1.88318700e-01f, -9.93358254e-01f, 9.83182132e-01f, 1.31804258e-01f, -8.59878242e-01f, 5.80368102e-01f, -3.89375091e-01f,
  3.21053416e-01f, 1.94957927e-01f, -7.15076864e-01f, -8.99137616e-01f, -1.17398143e+00f, -8.82629156e-01f, -1.66912913e+00f, -8.31785381e-01f, 3.29498500e-01f, -1.54900834e-01f,
  -4.47185040e-01f, 2.54613459e-01f, 3.08185935e-01f, 3.35749835e-01f, -1.15519904e-01f, -6.45145997e-02f, -5.31362221e-02f, -8.91402736e-02f, -6.66711330e-02f, 4.93443012e-03f,
  -1.28559187e-01f, 7.16087967e-02f, 1.72490805e-01f, -1.69999469e-02f, 3.19046408e-01f, -1.58029437e-01f, -5.90243712e-02f, -1.15724909e+00f, -4.33587998e-01f, -7.09553123e-01f,
  3.64279121e-01f, -5.36543667e-01f, 8.99639949e-02f, 3.41810793e-01f, -8.61859843e-02f, -3.37652355e-01f, -7.30211437e-01f, 1.06729794e+00f, 5.31275272e-01f, 1.28988817e-01f,
  -3.88469219e-01f, 2.46384472e-01f, -4.86447923e-02f, 5.40492952e-01f, 1.06988154e-01f, -1.17153597e+00f, 1.60495117e-01f, 1.97723106e-01f, -5.80983758e-01f, 3.14772069e-01f,
  -7.23337606e-02f, 1.99425623e-01f, 5.03239967e-02f, 3.98846358e-01f, -5.49920499e-01f, -2.56299108e-01f, 4.10005510e-01f, -9.39102396e-02f, -7.44444788e-01f, -2.48935238e-01f,
  2.68010139e-01f, -9.01584208e-01f, -4.18198675e-01f, -7.67297506e-01f, 6.74743235e-01f, -1.25609040e-01f, -8.27454925e-01f, 9.32413876e-01f, -7.30962634e-01f, -6.35212734e-02f,
  -1.77253217e-01f, 3.04525554e-01f, -4.75745201e-01f, 4.96426731e-01f, -7.16499984e-01f, -3.49393934e-01f, -8.64364266e-01f, 3.17211896e-01f, 4.45741154e-02f, -1.19602263e-01f,
  -2.30893970e-01f, 8.71974416e-03f, 1.70556143e-01f, -6.59217089e-02f, -3.47447116e-03f, -2.56088793e-01f, 4.68390137e-01f, -2.27076516e-01f, -3.84992212e-01f, -1.85971726e-02f,
  -7.75926709e-01f, 4.89939243e-01f, 3.54004920e-01f, -1.14888060e+00f, 3.65615249e-01f, -9.03994858e-01f, 2.79721618e-01f, 6.55034244e-01f, 1.25589645e+00f, -6.26782000e-01f,
  -4.39500928e-01f, -2.99212575e-01f, 1.18512738e+00f, -9.34629083e-01f, -9.15728807e-01f, -1.08986235e+00f, 1.16953224e-01f, -3.80761266e-01f, 1.08755507e-01f, -5.08766472e-01f,
  -4.79624681e-02f, -5.04772700e-02f, -2.13122860e-01f, 1.25120491e-01f, 3.79675962e-02f, 1.76592648e-01f, 1.48684368e-01f, 4.10982668e-01f, 4.46466267e-01f, 2.48524219e-01f,
  3.50044340e-01f, -3.67198169e-01f, -4.61382449e-01f, -6.56713724e-01f, -6.10749006e-01f, 2.61816949e-01f, -4.73485708e-01f, -4.16047066e-01f, 1.15214694e+00f, -6.08905852e-01f,
  -6.93659559e-02f, -5.84131926e-02f, -1.08063555e+00f, 7.87035644e-01f, -6.29535854e-01f, -7.32191026e-01f, -9.08458352e-01f, -2.55978078e-01f, 6.08586490e-01f, -6.66991919e-02f,
  -5.19548714e-01f, -7.15360463e-01f, -3.70039977e-02f, 7.97890425e-02f, 1.23405956e-01f, -2.20639437e-01f, 1.66657194e-01f, -1.67370051e-01f, -1.52374133e-01f, -2.19804287e-01f,
  -2.77592719e-01f, -1.55853093e-01f, -4.25005049e-01f, 3.95576805e-01f, 1.01573622e+00f, -1.65136948e-01f, 1.08592331e+00f, -7.25711167e-01f, 3.78882229e-01f, -2.86871642e-01f,
  -3.60561073e-01f, -1.32557368e+00f, -1.17908791e-01f, -1.73155874e-01f, -9.46221411e-01f, -9.51659322e-01f, -3.99619818e-01f, -3.13589305e-01f, -5.93952477e-01f, 1.15653408e+00f,
  -6.75979257e-01f, -3.94548327e-02f, -8.79596174e-02f, 1.41578257e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  7.36648500e-01f, 3.94472599e-01f, 8.15086007e-01f, -9.45748806e-01f, -3.06905091e-01f, 5.92128560e-02f, 3.02604958e-02f, -6.95606232e-01f, -5.73212147e-01f, -7.18840584e-03f,
  -7.05462754e-01f, -5.40391028e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    