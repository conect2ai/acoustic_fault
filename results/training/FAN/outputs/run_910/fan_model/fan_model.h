/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.30909163e-02f, 1.89653873e-01f, -7.62926787e-02f, -4.37352844e-02f, 8.37264291e-04f, -1.67021602e-01f, -2.36126110e-02f, -1.61647983e-02f, -7.63120577e-02f, 1.21715248e-01f,
  8.46041888e-02f, -4.26388606e-02f, 3.52470018e-02f, 7.93869868e-02f, -8.47043321e-02f, 5.51251918e-02f, 1.17864348e-01f, 1.40332133e-02f, -2.06365898e-01f, -2.26037383e-01f,
  -1.20620355e-02f, -4.00100350e-02f, -1.22835941e-03f, -2.61250008e-02f, 1.61473274e-01f, -1.22151963e-01f, 1.72277331e-01f, 1.84907928e-01f, 8.08214173e-02f, 3.46909881e-01f,
  7.73320347e-02f, 1.76002532e-01f, -8.86743069e-02f, -3.76801342e-02f, 2.67205089e-02f, -3.59094627e-02f, 3.24031860e-02f, 8.48393440e-02f, -3.50024104e-02f, 4.79415432e-02f,
  4.22760136e-02f, -2.06838138e-02f, 7.50102326e-02f, -5.07448725e-02f, 9.23418552e-02f, 6.29915716e-03f, 1.06448969e-02f, 1.60208549e-02f, -1.14781819e-02f, -1.05613274e-02f,
  3.03657316e-02f, -2.74154954e-02f, -4.03669812e-02f, 1.15392136e-03f, 9.06268656e-02f, -7.78752267e-02f, 4.89359498e-02f, 3.23133618e-02f, 7.68224150e-02f, 3.96856368e-02f,
  -5.94793521e-02f, -5.09938225e-02f, 1.55998552e-02f, -2.80260779e-02f, -5.27353259e-03f, 7.45488470e-03f, 1.04399594e-02f, -1.29092783e-02f, -6.70852885e-02f, 6.96281865e-02f,
  -3.21046822e-02f, -3.81593555e-02f, 5.97091578e-02f, 2.18218174e-02f, -1.75694451e-02f, 1.06313892e-01f, -9.53986309e-03f, -3.00790966e-02f, -9.95519236e-02f, 6.61711991e-02f,
  -5.83662800e-02f, -5.10239229e-02f, 4.19896096e-02f, 9.91518050e-02f, 2.61872578e-02f, -5.12238685e-03f, -2.83774771e-02f, -3.17941643e-02f, 4.53745201e-02f, 9.51536894e-02f,
  1.00558504e-01f, -2.02517323e-02f, -1.43347559e-02f, -1.36828059e-02f, 4.54174988e-02f, -2.86234636e-02f, -3.84855233e-02f, -2.03336850e-02f, 9.76839811e-02f, -7.22781196e-02f,
  8.40470344e-02f, 1.14384396e-02f, -1.52785350e-02f, -8.98319483e-02f, -1.86793115e-02f, -2.02810597e-02f, -1.02741733e-01f, -1.00695744e-01f, 2.07445286e-02f, 9.81604122e-03f,
  -3.82262878e-02f, -5.83267175e-02f, -2.06370100e-01f, 4.59368899e-03f, -1.26084115e-03f, -7.83645660e-02f, -1.12592474e-01f, 2.37220638e-02f, -1.32479161e-01f, -7.61246458e-02f,
  5.47856390e-02f, 1.03738187e-02f, -5.61786741e-02f, 1.34122059e-01f, -1.81503035e-02f, 6.49913773e-02f, -9.55077410e-02f, -5.84187582e-02f, 3.87422778e-02f, -4.61845919e-02f,
  -1.04947491e-02f, -3.04148514e-02f, 3.39346752e-02f, -1.09356791e-01f, -3.79030593e-02f, -5.87852225e-02f, 5.24141379e-02f, -4.82015014e-02f, -1.01474233e-01f, 1.29742417e-02f,
  -8.73483494e-02f, -5.90815693e-02f, 8.32230300e-02f, -8.20664912e-02f, 1.70767158e-02f, -6.39669970e-02f, 1.04979418e-01f, 7.75306970e-02f, -5.34547605e-02f, 1.87801942e-01f,
  1.16805837e-01f, 4.14927490e-02f, -1.40883535e-01f, -4.79122214e-02f, -1.75159276e-02f, 2.98286807e-02f, 3.60770077e-02f, 1.33837890e-02f, 5.27881272e-03f, -2.93738965e-04f,
  1.93522889e-02f, -2.69187000e-02f, 8.41573998e-02f, 5.59158251e-02f, 4.79174629e-02f, -2.57455409e-02f, 5.44675291e-02f, 1.37567297e-02f, 2.62565967e-02f, 1.30249513e-02f,
  -4.51246053e-02f, 7.98779577e-02f, -4.80607823e-02f, -6.68874756e-02f, 3.37339193e-02f, -3.91287319e-02f, -1.83414621e-03f, -5.07443026e-02f, -6.42649680e-02f, -6.03580214e-02f,
  -4.30854000e-02f, 1.13780774e-01f, -1.13545833e-02f, -1.83850769e-02f, 1.58290882e-02f, -4.97246236e-02f, 2.55775265e-02f, -9.42822488e-04f, -1.17413044e-01f, 2.02332269e-02f,
  -5.43133579e-02f, 5.78189194e-02f, 1.72035838e-03f, 9.76634677e-03f, -3.67787480e-02f, 1.03434242e-01f, -8.90455693e-02f, -4.73871902e-02f, -1.89905651e-02f, -1.99315790e-02f,
  2.61303615e-02f, 2.84966058e-03f, 1.16984479e-01f, 1.05200462e-01f, 2.99613439e-02f, -7.60284737e-02f, -5.08171059e-02f, -1.34358793e-01f, -1.66458660e-03f, -7.47994184e-02f,
  -5.72839342e-02f, -1.49026632e-01f, 1.85450520e-02f, -1.95557885e-02f, 1.35357510e-02f, 9.40195993e-02f, -3.15762125e-02f, -1.53526952e-02f, 1.92687698e-02f, -3.04121953e-02f,
  -5.36867902e-02f, 3.47360000e-02f, 3.91318724e-02f, 1.11229392e-02f, -5.24251303e-03f, -7.72257075e-02f, -9.41355601e-02f, -1.21728092e-01f, 1.95976533e-02f, -5.62998466e-02f,
  -4.77858383e-04f, -8.44523981e-02f, -1.02345534e-01f, 4.03072536e-02f, -4.31697496e-04f, -9.40053836e-02f, 5.69343986e-03f, -6.69668689e-02f, -1.36745766e-01f, -1.67042688e-01f,
  2.27670416e-01f, 1.79608449e-01f, -1.75395061e-03f, 1.19738646e-01f, -1.04451157e-01f, -2.10015252e-01f, -1.39269695e-01f, -5.51212542e-02f, 1.38277009e-01f, 5.96681908e-02f,
  -5.03705889e-02f, 7.60518834e-02f, -3.70603316e-02f, -2.60743927e-02f, 2.02793647e-02f, 2.79553584e-03f, -8.21007118e-02f, -1.03706360e-01f, -1.07136451e-01f, -1.21823251e-01f,
  2.81029083e-02f, 1.14885695e-01f, 1.91332892e-01f, -3.51782739e-02f, 3.05339210e-02f, 2.78627058e-03f, 5.25338799e-02f, -9.49807279e-03f, 2.11069658e-02f, 1.47974834e-01f,
  -8.55378360e-02f, 7.41684064e-02f, -1.44990757e-01f, 5.36372848e-02f, 8.61419588e-02f, -3.15639973e-02f, 5.32378890e-02f, 1.17290452e-01f, -8.98947380e-03f, 4.31653038e-02f,
  -3.53068635e-02f, -2.22850051e-02f, -6.20492026e-02f, -1.37752229e-02f, 3.65370559e-03f, -5.82238883e-02f, 1.02069974e-01f, 7.37928525e-02f, -2.50791032e-02f, 5.13459966e-02f,
  6.34033382e-02f, -1.76250692e-02f, -6.44549057e-02f, -7.63018951e-02f, -1.11706950e-01f, -1.19195245e-02f, 4.71644849e-02f, -3.31269577e-02f, -5.39503060e-02f, 2.42167674e-02f,
  -2.26269532e-02f, -6.92412630e-02f, -5.96399754e-02f, 1.33830430e-02f, -4.69362503e-03f, -7.87265673e-02f, 1.34508433e-02f, -3.35141830e-02f, -8.03535655e-02f, 3.44423763e-02f,
  -3.73808928e-02f, -6.50916621e-02f, 2.02349778e-02f, 1.73604656e-02f, -5.14871404e-02f, 1.07489536e-02f, -2.60425489e-02f, -2.87210215e-02f, 1.86375249e-02f, 1.74354818e-02f,
  -5.15655540e-02f, 3.82706188e-02f, 5.46480604e-02f, -1.20438114e-02f, 8.36959034e-02f, -7.17203170e-02f, -1.06540918e-02f, 6.52661324e-02f, -2.45468058e-02f, -1.47815039e-02f,
  -8.14878866e-02f, -1.17609404e-01f, -2.80927569e-02f, 2.97408476e-02f, 1.88838486e-02f, 3.43272253e-03f, -5.44798188e-02f, 1.02101378e-01f, -3.13185975e-02f, 3.89735103e-02f,
  1.92007031e-02f, -8.56643245e-02f, 3.11709326e-02f, -2.56184805e-02f, 3.48324962e-02f, 7.26429597e-02f, -8.09502900e-02f, 2.62319818e-02f, -5.31202108e-02f, -5.50566390e-02f,
  6.30609319e-02f, -3.19698974e-02f, 3.94059978e-02f, -1.74244940e-02f, -7.81261027e-02f, -1.13212697e-01f, -5.96871860e-02f, -5.27906008e-02f, -8.81179199e-02f, 7.85722136e-02f,
  6.10068560e-01f, -1.55968601e-02f, -8.08499455e-02f, 9.82279629e-02f, -7.17526004e-02f, -1.52082071e-01f, -1.45610958e-01f, -4.81179915e-02f, 4.22900654e-02f, -1.26059875e-02f,
  -1.21124722e-02f, -5.88046536e-02f, -6.56927004e-02f, -7.45342225e-02f, -1.17769964e-01f, 3.84084545e-02f, -1.86359882e-01f, -6.97443336e-02f, 1.32005066e-01f, 6.52140975e-02f,
  -1.05543293e-01f, 3.82859670e-02f, 2.47664064e-01f, 7.47136539e-03f, -2.13628020e-02f, 2.68245637e-02f, 4.15521748e-02f, 1.98126361e-02f, 5.55073880e-02f, -1.46860391e-01f,
  1.61773071e-01f, 7.63570145e-02f, -2.90414896e-02f, 5.34356236e-02f, -1.86133943e-02f, 6.23280779e-02f, 4.20706607e-02f, 9.45044979e-02f, 2.92962734e-02f, -1.41036895e-03f,
  -1.98475774e-02f, 3.81961092e-02f, 5.63932583e-02f, -4.79160808e-02f, 8.21997523e-02f, -8.90716910e-03f, 1.83743350e-02f, 9.58721191e-02f, 4.34936620e-02f, 9.41999350e-03f,
  -1.17609248e-01f, 4.37203720e-02f, 1.13566406e-01f, -3.95374745e-02f, -5.18009439e-02f, -9.85770151e-02f, 3.86144221e-02f, -9.62716565e-02f, 2.78926101e-02f, 6.74645454e-02f,
  -2.74630953e-02f, 2.91319508e-02f, 1.43833049e-02f, -2.48976927e-02f, -5.46949208e-02f, 9.65292845e-03f, -1.67062711e-02f, -4.00507338e-02f, 4.19205502e-02f, 5.28198257e-02f,
  -7.45108947e-02f, 5.47304749e-02f, -2.15121824e-02f, 4.92046475e-02f, -3.63528505e-02f, 4.70039099e-02f, -2.60234419e-02f, -6.97954893e-02f, -3.19747627e-02f, 6.97571412e-02f,
  -1.04231583e-02f, -6.18658476e-02f, 1.97784975e-02f, 1.25158690e-02f, -1.12895621e-02f, -1.20298536e-02f, 5.02542146e-02f, -3.11118942e-02f, -5.92794176e-03f, 3.56576382e-03f,
  1.81260169e-01f, -1.54210985e-01f, 1.23994969e-01f, -1.49893044e-02f, 7.00310059e-03f, -5.67743145e-02f, 1.85885876e-02f, -5.51723465e-02f, 2.35343650e-02f, 2.97174770e-02f,
  -8.14867765e-02f, -1.18546989e-02f, -4.37409431e-03f, -6.00545807e-03f, 5.33781126e-02f, -8.47448874e-03f, -2.50723604e-02f, 2.82232631e-02f, -7.61227459e-02f, 9.79290009e-02f,
  -1.03101626e-01f, 8.94590467e-02f, 1.15003705e-01f, -1.05479553e-01f, 3.65142561e-02f, 3.85269076e-02f, 4.49575484e-02f, 8.45151693e-02f, 4.54211719e-02f, 6.82290941e-02f,
  -1.69512615e-01f, -1.46592185e-01f, -8.04217812e-03f, -2.98879226e-03f, 6.19614087e-02f, 1.40342325e-01f, -9.33269933e-02f, 3.18609551e-02f, -7.35593960e-02f, -1.52926857e-03f,
  -6.10121293e-03f, 6.42555133e-02f, -2.91459984e-03f, 5.64757884e-02f, 6.78699911e-02f, 4.07817699e-02f, -2.40812153e-02f, 4.99594063e-02f, 1.42491698e-01f, 9.37112793e-02f,
  -4.65837680e-02f, -4.90459753e-03f, 1.01129524e-01f, -5.41690178e-03f, -5.62480316e-02f, -2.81407256e-02f, -2.39588823e-02f, -2.37659421e-02f, 1.02151647e-01f, -1.88788414e-01f,
  -6.39764443e-02f, -1.06991388e-01f, 1.25531554e-01f, -4.59433831e-02f, -2.10985299e-02f, -5.17210849e-02f, -1.01053156e-01f, 2.66207326e-02f, -1.81193016e-02f, -8.87625217e-02f,
  6.86910525e-02f, 1.21862581e-02f, 2.95155235e-02f, 1.69234388e-02f, 7.01275617e-02f, -4.95543852e-02f, -6.18992932e-02f, 9.90658849e-02f, 5.87422997e-02f, 3.18667181e-02f,
  3.82946618e-02f, -1.09964274e-01f, -1.23880222e-01f, -5.10121360e-02f, 2.36368198e-02f, 4.53456640e-02f, 3.79978269e-02f, -6.42431006e-02f, 1.02873720e-01f, -1.81822777e-01f,
  -5.64838760e-02f, -8.67359415e-02f, 4.48503755e-02f, -8.90967026e-02f, -5.25540148e-04f, -4.40119840e-02f, -7.02138841e-02f, -1.92642212e-02f, -3.07527985e-02f, 7.07927123e-02f,
  -4.79348823e-02f, -4.77111302e-02f, 4.98206578e-02f, -7.10397139e-02f, 4.65474464e-02f, 4.75934036e-02f, 4.89389189e-02f, -5.80743328e-02f, -5.00405617e-02f, -1.08460095e-02f,
  -6.27873912e-02f, -4.13798681e-03f, -1.17956698e-01f, 6.58344999e-02f, -7.47850910e-02f, -4.25043190e-03f, 1.48892924e-02f, -9.26504508e-02f, 7.83242658e-02f, 5.59189133e-02f,
  -9.89210233e-02f, 2.10654378e-01f, -3.64126228e-02f, -5.00363074e-02f, -2.59978021e-03f, 4.27203774e-02f, -6.11279123e-02f, 4.20597717e-02f, 2.13158689e-02f, 4.29969095e-02f,
  -4.85755764e-02f, 2.01713865e-05f, -8.50180537e-02f, -8.47767666e-02f, 3.51626729e-03f, 4.84025077e-04f, -1.75699051e-02f, -2.93707401e-02f, 6.23022765e-02f, 6.44738898e-02f,
  -9.54420939e-02f, -1.27592072e-01f, -1.11394808e-01f, -3.13513428e-02f, -7.01400563e-02f, -7.92181715e-02f, -2.49794498e-02f, -3.98388691e-02f, -9.10229683e-02f, -2.02177227e-01f,
  -2.21045390e-01f, -4.39440608e-02f, 8.38472843e-02f, -1.21299066e-01f, 4.70759310e-02f, 1.33664787e-01f, 7.88686331e-03f, 8.99647325e-02f, 5.75050302e-02f, -8.74784365e-02f,
  3.62962373e-02f, -8.42921808e-02f, 8.40348192e-03f, -3.60847451e-02f, -1.28100395e-01f, -1.39852196e-01f, -1.18603230e-01f, -2.47004293e-02f, -1.07126117e-01f, -3.91258374e-02f,
  3.69208120e-02f, -1.77147821e-01f, -8.82221088e-02f, 2.27489825e-02f, -1.17934518e-01f, 8.57315958e-02f, -9.88952965e-02f, -9.54525620e-02f, 4.63940576e-03f, -1.74451679e-01f,
  2.33480502e-02f, 4.84584160e-02f, -7.52182901e-02f, -1.02853440e-01f, 4.03609648e-02f, 4.36833873e-02f, 2.48405095e-02f, 1.44412881e-02f, 4.10130359e-02f, 4.26852936e-03f,
  -5.35614155e-02f, 8.17285478e-02f, 1.84521207e-03f, 5.63819595e-02f, 1.93315819e-02f, -7.91866779e-02f, 1.15349693e-02f, -7.23566413e-02f, -1.16079852e-01f, 1.09336767e-02f,
  1.29390033e-02f, -2.13914178e-02f, -7.21456930e-02f, 5.14502935e-02f, 2.43058391e-02f, -1.86857593e-03f, -7.95058999e-03f, 5.62125333e-02f, -8.88081938e-02f, -1.26967102e-01f,
  -5.99513575e-02f, 9.87562723e-03f, -1.14067066e-02f, 3.82292345e-02f, -6.97613955e-02f, -5.20303324e-02f, 5.41884303e-02f, 6.47660941e-02f, 4.01035361e-02f, -8.00143704e-02f,
  7.35624284e-02f, -6.70566484e-02f, -4.34323773e-02f, -1.23802297e-01f, -2.92866733e-02f, -3.39569338e-02f, 4.16097138e-03f, -3.96654755e-02f, -2.66684107e-02f, -4.26411107e-02f,
  -2.52774023e-02f, -3.60043198e-02f, 1.72767211e-02f, 1.43645396e-02f, 1.28383413e-02f, -4.16857302e-02f, -2.99460888e-02f, 2.76982173e-04f, 4.07447293e-02f, -6.38802499e-02f,
  -4.82519642e-02f, 8.67622495e-02f, -3.17140669e-02f, -7.90227503e-02f, 6.85447007e-02f, 1.64892413e-02f, 4.41352539e-02f, 7.48932511e-02f, 6.20545074e-02f, 1.29381930e-02f,
  5.29088490e-02f, -4.70532253e-02f, 3.79601605e-02f, -5.57877980e-02f, -6.34078681e-02f, -5.45993000e-02f, -8.24527219e-02f, -2.90392693e-02f, -4.54557054e-02f, 1.19101033e-01f,
  -4.05280031e-02f, -8.06744546e-02f, -7.65761361e-02f, -6.51571080e-02f, 1.59037169e-02f, -1.21436231e-01f, 6.09078445e-02f, 1.00411847e-01f, -6.77607208e-02f, -2.76679508e-02f,
  -2.32357487e-01f, -2.56208271e-01f, -2.45250408e-02f, -5.96376844e-02f, -4.16461863e-02f, 1.05183549e-01f, 1.37651032e-02f, -2.33687330e-02f, 8.73873755e-02f, -2.23271683e-01f,
  6.99360594e-02f, 1.89215109e-01f, 3.91125195e-02f, 1.08489409e-01f, 1.15913406e-01f, -7.87213147e-02f, -1.48053363e-01f, 5.04759373e-03f, 3.27187479e-01f, 1.61742568e-01f,
  6.70000762e-02f, -4.29081321e-02f, -4.85213958e-02f, 9.66405421e-02f, -1.15617372e-01f, 1.13695242e-01f, -2.32042111e-02f, -1.31046712e-01f, 1.61693513e-01f, -1.80409729e-01f,
  1.90705702e-01f, -1.03378028e-01f, 4.46704477e-02f, 6.01423681e-02f, -8.54869559e-02f, -1.09459236e-01f, -1.02126051e-03f, -3.77113707e-02f, -4.58081216e-02f, 2.21967995e-02f,
  -8.13314766e-02f, -8.39941427e-02f, -5.74421212e-02f, 1.42096942e-02f, -9.00739431e-02f, 3.35285664e-02f, -8.94276723e-02f, 7.93155283e-02f, 1.91916805e-02f, 8.96755904e-02f,
  3.26974131e-02f, 1.69829428e-02f, -4.19338755e-02f, 7.98242539e-02f, 6.41457736e-02f, 4.15942632e-02f, 8.93765092e-02f, -9.73219424e-03f, 8.34093094e-02f, -1.79446682e-01f,
  -8.69901199e-03f, 1.92655250e-02f, -2.91020353e-03f, 6.98496848e-02f, -7.71312714e-02f, 4.83353715e-03f, 6.38906062e-02f, 4.79681678e-02f, 6.72061089e-03f, -1.52334282e-02f,
  -3.58615741e-02f, -1.12378877e-02f, 5.23279747e-03f, -9.22728777e-02f, -2.12341212e-02f, 5.73854074e-02f, -1.70286316e-02f, -6.16233563e-03f, -3.86237092e-02f, 2.84836646e-02f,
  2.69452040e-03f, 3.16448212e-02f, 1.51913865e-02f, 1.66571997e-02f, 3.29199769e-02f, -6.35048375e-03f, -5.58498651e-02f, 1.51599757e-02f, -1.91082042e-02f, 1.74130388e-02f,
  8.11770707e-02f, 1.18695073e-01f, -6.54271096e-02f, 3.01424302e-02f, 4.25052680e-02f, -3.30633819e-02f, -6.66363165e-02f, 2.40769591e-02f, -6.80165291e-02f, -5.99460416e-02f,
  2.70614699e-02f, -7.70514533e-02f, -7.13741872e-04f, 4.44164826e-03f, 9.13999602e-02f, 4.17529233e-02f, -5.68291731e-02f, -8.79113795e-04f, 4.72225472e-02f, -1.03818346e-02f,
  -1.55801997e-02f, 2.65805237e-02f, 9.91902128e-02f, 9.52689126e-02f, -2.84074135e-02f, 7.90117532e-02f, 1.34918746e-02f, 3.89399119e-02f, 5.15446104e-02f, -9.53698233e-02f,
  1.35232247e-02f, -1.21460907e-01f, 3.10759377e-02f, 3.38974744e-02f, -3.33027914e-02f, -1.39118239e-01f, -1.95289209e-01f, -1.17873609e-01f, 1.49130240e-01f, 3.93471010e-02f,
  -3.58362161e-02f, 9.26061049e-02f, 2.14343946e-02f, 1.20503329e-01f, -1.09127544e-01f, -1.67520776e-01f, -9.90273152e-03f, 1.14204228e-01f, 2.17336752e-02f, 1.02015764e-01f,
  -1.99179593e-02f, -4.68240194e-02f, 5.07752188e-02f, 1.07266426e-01f, 1.62457805e-02f, 6.87024221e-02f, 9.15901437e-02f, 1.37258455e-01f, 9.02542844e-02f, 8.14408138e-02f,
  -3.72146145e-02f, 1.03382491e-01f, 2.51781382e-02f, 8.10267627e-02f, 8.79314691e-02f, -5.98801039e-02f, 8.36766511e-02f, -6.05166219e-02f, 4.55935160e-03f, -1.07375812e-02f,
  -5.24034549e-04f, 1.04443140e-01f, -7.13827610e-02f, 6.90323114e-02f, -2.36888174e-02f, -5.78713343e-02f, -6.04374707e-02f, 1.25311501e-02f, 5.13074398e-02f, -4.49209809e-02f,
  -3.60803753e-02f, 4.17430997e-02f, -1.63520157e-01f, -1.20023377e-01f, -8.51337798e-04f, 2.99979467e-02f, 8.99667665e-03f, 5.00316806e-02f, 5.90529069e-02f, 6.68703467e-02f,
  1.02034993e-01f, 1.04476415e-01f, -5.80313988e-02f, 7.23765651e-03f, -3.82474922e-02f, -1.67806055e-02f, 6.10328168e-02f, 4.21005115e-02f, 5.03608622e-02f, 1.93050206e-02f,
  -2.73089111e-02f, 5.03445901e-02f, -6.80911094e-02f, -4.94307689e-02f, -5.29077686e-02f, 6.38926998e-02f, 5.73968887e-02f, 2.63811965e-02f, -5.46992645e-02f, 8.21774229e-02f,
  -3.20375785e-02f, -4.26611751e-02f, 4.05224748e-02f, -9.49152466e-03f, 7.76479079e-04f, 8.08272231e-03f, 4.58877496e-02f, 4.28278698e-03f, -3.06752650e-03f, 5.48119135e-02f,
  9.92986001e-03f, -5.07151000e-02f, -1.10413060e-02f, 3.06407418e-02f, -2.46806070e-02f, 3.43470797e-02f, 6.91578239e-02f, -5.62307276e-02f, 9.79687050e-02f, -5.64841218e-02f,
  -6.97000027e-02f, -7.24980608e-02f, 2.54122596e-02f, -2.03560833e-02f, 2.04293784e-02f, -4.02105078e-02f, -4.29581739e-02f, 2.61102319e-02f, 2.84984033e-03f, -1.29786193e-01f,
  -7.57157281e-02f, -1.05669573e-01f, -1.41877905e-01f, -1.81656033e-01f, -4.45507728e-02f, -3.95288765e-02f, -4.32991758e-02f, -7.69063905e-02f, 3.80232371e-02f, -2.18759850e-01f,
  -3.05226982e-01f, -3.51403132e-02f, -1.24311075e-01f, -2.00890765e-01f, -1.83755085e-01f, -9.66048092e-02f, -2.24362649e-02f, -7.89779648e-02f, -8.18583667e-02f, 2.42555910e-03f,
  1.24263503e-01f, 6.61047641e-03f, 6.84476867e-02f, -1.20370248e-02f, -6.93505555e-02f, -3.21252830e-03f, -1.04403563e-01f, -9.55738351e-02f, -2.50743926e-01f, -1.71003446e-01f,
  8.45968816e-03f, -1.54443726e-01f, -1.93093523e-01f, -5.34072891e-02f, -1.28595054e-01f, 5.10662794e-02f, 1.20857000e-01f, 1.70902237e-02f, 1.66393816e-02f, -7.01717213e-02f,
  7.62360319e-02f, -2.57121891e-01f, 8.06243066e-03f, -2.65409984e-02f, 6.85242936e-02f, 5.16596250e-02f, 7.01331999e-03f, -4.72621173e-02f, 2.89327949e-02f, -3.24564017e-02f,
  4.82511222e-02f, 8.55311658e-03f, -2.68230867e-02f, -1.99822616e-02f, -7.78289661e-02f, -2.24579195e-03f, -4.31346893e-02f, -1.09784216e-01f, -9.73555893e-02f, -4.59164046e-02f,
  4.68221493e-03f, -3.62245291e-02f, -1.44958556e-01f, -5.57069592e-02f, 1.85468886e-02f, -1.20044224e-01f, -1.36224136e-01f, -1.20352060e-01f, -1.09200984e-01f, -6.77689016e-02f,
  4.56413515e-02f, 4.64910865e-02f, 3.91904488e-02f, -2.94691566e-02f, 7.39337737e-03f, 2.26754369e-03f, -1.36031862e-03f, 1.64170116e-02f, -2.47764448e-03f, 3.67877446e-02f,
  -4.53925654e-02f, 5.19026779e-02f, -2.65385248e-02f, -1.33021865e-02f, 3.20190452e-02f, -3.42145525e-02f, 8.68512169e-02f, -1.34920543e-02f, -1.24479467e-02f, -2.61013000e-03f,
  -3.32193747e-02f, 3.52954827e-02f, -3.84651730e-03f, -5.00821648e-03f, -3.30192409e-02f, 5.45392893e-02f, 5.01053445e-02f, -5.49136288e-02f, -2.05223206e-02f, -3.50146601e-03f,
  1.10159695e-01f, 5.01781795e-03f, 7.56770894e-02f, 1.16859479e-02f, -3.72100361e-02f, 4.69026677e-02f, 6.60305619e-02f, -8.32459237e-03f, 3.04765124e-02f, 9.52896923e-02f,
  -4.37861457e-02f, 5.74970134e-02f, 7.05202892e-02f, 1.89374723e-02f, 9.94849950e-03f, -5.06427474e-02f, 1.03418201e-01f, 1.47722876e-02f, 2.49293465e-02f, 1.12594217e-01f,
  1.08536541e-01f, -1.65495230e-03f, 3.19249928e-02f, 1.01796119e-02f, 6.19333284e-03f, -2.93425955e-02f, 3.23023135e-03f, 3.80400289e-03f, -4.27500159e-02f, 2.20027477e-01f,
  -2.67666399e-01f, -2.00253442e-01f, 1.98725864e-01f, 3.76438312e-02f, -1.84392370e-02f, -2.42825031e-01f, -4.50616479e-01f, -2.36023456e-01f, 1.98274273e-02f, -1.06350459e-01f,
  -2.26656809e-01f, 1.18433069e-02f, 1.36567160e-01f, 1.16928160e-01f, -2.40150057e-02f, -9.27524790e-02f, 2.53152162e-01f, 1.22676618e-01f, 4.84042615e-02f, -1.23184741e-01f,
  8.68150666e-02f, 1.35404781e-01f, 6.86487928e-02f, 1.27674580e-01f, 8.26761499e-02f, 2.31054146e-02f, 1.37259766e-01f, 1.86094865e-01f, 3.13092880e-02f, 3.30877751e-01f,
  9.97093394e-02f, -6.27045855e-02f, -1.54695921e-02f, -6.07305616e-02f, 6.49662241e-02f, -6.18963018e-02f, -4.13913280e-02f, 1.90656036e-01f, -5.93182109e-02f, 9.85902548e-03f,
  1.03221625e-01f, 2.50168368e-02f, 7.55563527e-02f, 1.21756956e-01f, -5.61996400e-02f, -7.07904100e-02f, 1.00080065e-01f, 8.74913707e-02f, 1.07610151e-01f, -4.97989841e-02f,
  1.20658325e-02f, -6.64265603e-02f, 3.92333977e-03f, -2.51623448e-02f, -3.66467610e-02f, 6.55234559e-03f, -3.01017780e-02f, 7.43892640e-02f, 6.68977499e-02f, 8.23705122e-02f,
  -2.84947790e-02f, 5.56372330e-02f, -5.82677834e-02f, 5.97790889e-02f, 9.44567192e-03f, -2.26464719e-02f, 7.07836971e-02f, -3.28989141e-02f, 5.08559570e-02f, -6.71496019e-02f,
  -8.22475180e-03f, 2.63245706e-03f, 2.49546785e-02f, 9.55415145e-03f, 2.02059783e-02f, 3.89057770e-02f, -5.96115515e-02f, -3.74057926e-02f, 8.08297992e-02f, 4.70871478e-02f,
  4.85677943e-02f, 1.80501509e-02f, -5.28871082e-02f, 5.10963015e-02f, -4.91572060e-02f, 1.87420025e-01f, 2.32300963e-02f, -2.68167984e-02f, -8.60229358e-02f, 1.07496127e-03f,
  -1.64586097e-01f, 1.00536026e-01f, -4.88195149e-03f, 8.60427506e-03f, 2.41461787e-02f, -1.89408027e-02f, 4.53747138e-02f, -2.75392998e-02f, -4.85684257e-03f, -6.74346834e-02f,
  -1.06819116e-01f, -4.41803075e-02f, -4.47124131e-02f, 4.67915162e-02f, -5.17407805e-02f, -4.06460799e-02f, -5.39286993e-02f, -2.25860886e-02f, -2.74102744e-02f, 8.73714238e-02f,
  -9.48620662e-02f, -1.19850479e-01f, -2.21257538e-01f, -1.00204527e-01f, 1.92941306e-03f, -9.17595848e-02f, -1.35496855e-01f, -1.57932654e-01f, -1.84000298e-01f, -3.99730861e-01f,
  -1.97053313e-01f, 9.27308127e-02f, 1.05180077e-01f, -1.05595507e-01f, -1.19952746e-01f, 3.35730836e-02f, 2.85457633e-02f, 7.93766379e-02f, -8.59052408e-03f, -1.81192923e-02f,
  -4.11645211e-02f, 9.65627506e-02f, -4.94349115e-02f, 3.03292200e-02f, 6.06338754e-02f, 7.67964944e-02f, 2.28177402e-02f, 2.79276818e-02f, -2.38174759e-02f, 4.14889306e-02f,
  -2.18135789e-02f, 6.42303079e-02f, 7.43539929e-02f, -5.71862981e-02f, 4.33831550e-02f, -3.36859152e-02f, 1.96043216e-02f, 2.78281271e-02f, 4.89569716e-02f, 1.70025751e-01f,
  1.70121074e-01f, -2.14819182e-02f, 6.19208440e-02f, -3.16906385e-02f, 6.87136874e-02f, 3.76853198e-02f, 3.37256049e-03f, -3.22665110e-05f, 5.52803725e-02f, -5.94185255e-02f,
  -6.42502382e-02f, 1.04004387e-02f, -4.84972075e-02f, -4.77751344e-02f, -4.24443418e-03f, -5.01990765e-02f, 1.24522271e-02f, 5.23082912e-02f, -3.41035426e-02f, 5.20482734e-02f,
  3.87227871e-02f, -5.71548939e-02f, 5.04202619e-02f, 2.43908330e-03f, -2.36189030e-02f, 5.45280278e-02f, 5.57649992e-02f, 5.44416122e-02f, 3.75404581e-02f, 1.31804701e-02f,
  2.72868071e-02f, 8.60640258e-02f, 1.78161066e-03f, -5.04270457e-02f, 4.96980175e-02f, -3.82844912e-04f, 7.01458678e-02f, 9.43451524e-02f, -4.03022692e-02f, 3.14576994e-03f,
  3.40159386e-02f, 2.63495632e-02f, 1.98124889e-02f, -2.21356899e-02f, -5.91418892e-02f, -2.64415238e-02f, -2.73545198e-02f, -8.92479997e-03f, -1.76990051e-02f, -2.61126589e-02f,
  -6.60450161e-02f, 6.86464980e-02f, 4.44931090e-02f, 1.96599737e-02f, -5.61878234e-02f, -8.42330158e-02f, -3.59354950e-02f, 6.26092181e-02f, 4.06761467e-02f, 7.44838093e-04f,
  1.86752304e-01f, -7.74275884e-02f, 1.14736646e-01f, -5.95338233e-02f, 8.85819457e-03f, 6.38033971e-02f, -6.38805330e-02f, 5.05110398e-02f, -7.13017210e-02f, 7.78957233e-02f,
  -5.28757349e-02f, -4.55754343e-03f, 7.53664076e-02f, -1.67860347e-03f, 1.49352569e-02f, 7.72404391e-03f, 5.88916093e-02f, -4.34293151e-02f, 4.47561741e-02f, -2.23045181e-02f,
  -7.48786144e-03f, 3.79114831e-03f, 5.63488677e-02f, -6.14835992e-02f, -1.84135232e-02f, -1.15500420e-01f, 6.79752305e-02f, 4.80915457e-02f, -5.37247956e-02f, 4.06164527e-02f,
  -1.98211387e-01f, -5.16119562e-02f, -6.40538558e-02f, -9.03035328e-02f, -1.36494553e-02f, -2.99866330e-02f, 9.14255157e-02f, 6.53726682e-02f, -1.10447463e-02f, -9.09498632e-02f,
  -1.05576888e-01f, -3.48499394e-03f, 4.42077778e-02f, 7.21125081e-02f, 1.38032272e-01f, -1.27405273e-02f, 4.21257643e-03f, 7.27689359e-03f, 4.54071425e-02f, 6.28428608e-02f,
  -8.70524533e-03f, -7.48296008e-02f, 3.67388874e-03f, -2.28535812e-02f, -4.19987589e-02f, -6.63095340e-02f, 5.02714142e-03f, 4.17744629e-02f, -5.03934324e-02f, 2.72054747e-02f,
  -2.39471108e-01f, -5.49712107e-02f, 2.21663658e-02f, -6.87124627e-03f, 7.44569525e-02f, -3.77934016e-02f, -6.12692647e-02f, 9.08816233e-03f, -9.85536142e-04f, -7.03818351e-02f,
  -4.36675251e-02f, -1.70384403e-02f, 2.90123783e-02f, -5.79172336e-02f, 1.81188099e-02f, -2.06213240e-02f, 2.77398676e-02f, -2.92024333e-02f, 7.20550027e-03f, 4.83675264e-02f,
  6.43655062e-02f, -6.83288835e-03f, -1.33720413e-03f, 4.16973680e-02f, 7.14500621e-02f, 6.87078238e-02f, 3.84950228e-02f, 3.79019566e-02f, 4.61004078e-02f, -9.06020924e-02f,
  1.55188292e-02f, -1.41287269e-02f, 6.84491619e-02f, -7.68159935e-03f, -3.04651354e-02f, 1.40476199e-02f, -6.87173009e-02f, -6.05691671e-02f, 3.53037715e-02f, -2.38279365e-02f,
  7.51668364e-02f, -9.04599205e-03f, -5.46072200e-02f, 3.69086675e-02f, -5.44464700e-02f, 1.60831548e-02f, -4.52610441e-02f, -2.84654312e-02f, 2.95477198e-03f, 3.31494473e-02f,
  2.13325415e-02f, -2.87949704e-02f, -2.60227062e-02f, 3.81706469e-02f, 5.14855832e-02f, 5.45284003e-02f, -4.09330279e-02f, 6.03121705e-02f, -2.47733630e-02f, -4.29899208e-02f,
  -3.04500610e-01f, 1.44779295e-01f, -8.29254016e-02f, -5.35111353e-02f, -5.29099889e-02f, -1.21491831e-02f, 5.65484315e-02f, 3.33361886e-02f, 1.54568981e-02f, -5.11335209e-02f,
  1.01837311e-02f, 4.40748706e-02f, -4.87042293e-02f, 5.98085970e-02f, 2.80087385e-02f, -7.82648772e-02f, 2.70820260e-02f, -6.42800704e-03f, 1.58530883e-02f, -6.86813444e-02f,
  1.73082203e-02f, 7.41176493e-03f, -9.12495703e-02f, -2.68901754e-02f, -1.96274417e-03f, -2.28196979e-02f, -7.86798820e-02f, -7.13370144e-02f, -3.41987759e-02f, -1.50341019e-01f,
  2.55753726e-01f, -2.23377138e-01f, -5.56080155e-02f, 1.36682361e-01f, -7.55949914e-02f, 4.09372114e-02f, 1.10917483e-02f, -1.87539700e-02f, 9.02505592e-02f, -6.34649545e-02f,
  -1.11576356e-02f, 1.44644696e-02f, 1.00838408e-01f, 2.93426048e-02f, 1.54026464e-01f, 6.55309260e-02f, 5.62384315e-02f, 1.14793979e-01f, 1.75325856e-01f, 4.36713211e-02f,
  5.07114176e-03f, 1.91906840e-02f, 5.69128692e-02f, 7.02936873e-02f, -1.87025279e-01f, -7.98882842e-02f, -1.53598949e-01f, -8.65005478e-02f, -1.58423156e-01f, -2.84660727e-01f,
  -2.56045997e-01f, 2.57976213e-03f, 2.70707104e-02f, 1.22681618e-01f, -1.11383036e-01f, -9.92352795e-03f, -6.65300637e-02f, -3.51867005e-02f, -7.51699926e-03f, -6.06380664e-02f,
  -1.91443730e-02f, 1.83809698e-02f, 6.39283806e-02f, -7.82630779e-03f, -2.95405369e-02f, -1.48931360e-02f, -8.18168931e-03f, 2.07937174e-02f, 3.81858125e-02f, -8.09459537e-02f,
  -2.24628616e-02f, -1.23669542e-01f, -1.26766771e-01f, -8.40344429e-02f, -7.80663639e-02f, 2.32918058e-02f, -9.27187502e-02f, -7.03727156e-02f, -1.06740713e-01f, -1.73001975e-01f,
  -7.54069686e-02f, 1.52841676e-02f, -7.46906400e-02f, -2.75085233e-02f, -1.88395232e-02f, -1.17487563e-02f, -3.69192846e-02f, 7.12250965e-03f, 8.14673379e-02f, 6.83431339e-04f,
  6.45380691e-02f, 3.82482521e-02f, 3.18012461e-02f, 7.26837292e-02f, -3.54157910e-02f, -4.25497890e-02f, 3.22538540e-02f, -1.04266159e-01f, 6.90396875e-02f, -2.10660473e-02f,
  -1.23515697e-02f, -7.01091886e-02f, 6.08915128e-02f, 5.85959405e-02f, 5.72399721e-02f, -5.66379130e-02f, 2.01119334e-02f, 5.57263307e-02f, -3.88930016e-03f, 3.33755538e-02f,
  3.46156582e-02f, 1.26861766e-01f, 1.10108450e-01f, 7.03166127e-02f, 5.74097969e-03f, 2.84991041e-02f, -1.02247328e-01f, 7.33523518e-02f, 7.84499273e-02f, 1.70352198e-02f,
  7.31672645e-02f, 6.34856522e-02f, 2.02542711e-02f, 1.44429142e-02f, 7.30889570e-03f, 5.13837822e-02f, -4.24567144e-03f, 9.39952501e-04f, 1.38852634e-02f, -7.39743412e-02f,
  6.25772998e-02f, 6.70459121e-02f, 6.94932118e-02f, -1.11322608e-02f, 8.07140172e-02f, 9.07141343e-02f, -2.51080468e-02f, -8.79053473e-02f, -1.95611548e-02f, 5.59926033e-02f,
  3.95620883e-01f, 1.53322965e-01f, 5.37306331e-02f, -4.08979021e-02f, 1.30951945e-02f, 4.58582304e-02f, 2.08821371e-01f, 2.24023927e-02f, -7.94555843e-02f, 7.67030790e-02f,
  1.16851874e-01f, 1.25170439e-01f, 1.78461909e-01f, 6.36841282e-02f, 1.42723426e-01f, 1.65235385e-01f, 5.98576036e-04f, -2.86821909e-02f, -6.00891449e-02f, -1.00379750e-01f,
  -3.89532298e-02f, -9.78340283e-02f, -2.05723587e-02f, -1.75178021e-01f, 1.14410564e-01f, 1.73907623e-01f, 1.08092334e-02f, 1.12069085e-01f, 1.08225688e-01f, 1.15148239e-01f,
  2.46998519e-01f, 1.28386363e-01f, 3.91667709e-02f, 2.10335776e-02f, 8.43450874e-02f, 8.29537585e-02f, 4.08553556e-02f, 5.49551174e-02f, 7.28989765e-02f, -1.69914234e-02f,
  7.60981664e-02f, -3.78200151e-02f, 4.51887473e-02f, -8.06045979e-02f, -5.35133965e-02f, -2.57962756e-02f, -8.82659256e-02f, -1.42609784e-02f, 9.45498869e-02f, -8.90316814e-02f,
  -9.81527641e-02f, -2.75246669e-02f, -2.20753942e-02f, -3.03897597e-02f, -9.63599142e-03f, 1.51181184e-02f, 6.07528873e-02f, 3.79659757e-02f, 7.65940025e-02f, 2.62615383e-01f,
  -1.20785860e-02f, -2.29009744e-02f, 6.01684190e-02f, -7.87138846e-03f, -4.12980542e-02f, -5.51398098e-03f, -1.00667059e-01f, 4.25998606e-02f, -2.53578816e-02f, 4.28306945e-02f,
  1.46142803e-02f, -5.44058196e-02f, -2.29371972e-02f, -4.76440005e-02f, -3.21638957e-02f, -1.17805474e-01f, -1.28881428e-02f, 4.19063643e-02f, 5.21837687e-03f, 3.20765153e-02f,
  1.98167525e-02f, 2.70316079e-02f, -9.55068693e-02f, 2.86853053e-02f, 2.29690364e-03f, -9.74782631e-02f, -3.75099331e-02f, 3.11357882e-02f, 4.14977260e-02f, 9.91537143e-03f,
  1.18701361e-01f, 2.45964862e-02f, 1.41143590e-01f, 3.53371054e-02f, -1.18664131e-02f, -9.44504142e-02f, 4.33572568e-02f, -6.23500757e-02f, -1.68299687e-03f, 5.61594702e-02f,
  -9.94812101e-02f, -2.47542057e-02f, -3.58098565e-04f, -2.84515172e-02f, -2.34027375e-02f, 2.85702967e-03f, 7.86022767e-02f, 1.83695890e-02f, -2.98347808e-02f, -1.62412360e-01f,
  -6.92273751e-02f, 4.69512977e-02f, 2.07403190e-02f, 3.34361121e-02f, 4.60369736e-02f, 1.31192887e-02f, 7.48914331e-02f, 7.01304302e-02f, 7.19840378e-02f, 2.26918623e-01f,
  7.12482352e-03f, 1.68287620e-01f, -6.91012219e-02f, -6.18102029e-02f, -3.13171484e-02f, 9.10848603e-02f, -8.01445730e-03f, 4.45979498e-02f, -2.43504271e-02f, -6.52902275e-02f,
  5.40258102e-02f, -3.42153711e-03f, -3.66804413e-02f, 1.98219959e-02f, -6.96439669e-03f, -6.23325035e-02f, -1.26822684e-02f, -1.36407480e-01f, -1.40289158e-01f, 4.41954061e-02f,
  5.14111891e-02f, 4.56501730e-02f, -4.11034934e-03f, -1.04696990e-03f, -4.26707864e-02f, -1.28463477e-01f, -7.87473023e-02f, 1.58117302e-02f, -8.00823644e-02f, -5.34222126e-02f,
  1.18815884e-01f, 1.77845389e-01f, -1.52575793e-02f, -3.86536866e-02f, 9.31753293e-02f, 5.53004481e-02f, 2.31525097e-02f, 5.01476824e-02f, 5.82743622e-02f, 2.59221476e-02f,
  -1.75800789e-02f, -9.54655372e-03f, 6.63559660e-02f, 9.64001790e-02f, 7.58449584e-02f, -1.14792744e-02f, -3.18729952e-02f, 2.71284487e-02f, 3.98558453e-02f, 1.15216672e-01f,
  5.30938879e-02f, -1.33965379e-02f, 3.36675607e-02f, -1.31386239e-02f, 1.84284095e-02f, -9.95258521e-03f, -1.72549449e-02f, -3.17193456e-02f, -9.12362188e-02f, -4.76518534e-02f,
  -4.22418788e-02f, -6.35415986e-02f, 2.21585054e-02f, 2.33864901e-03f, -7.15790130e-03f, 1.21234832e-02f, -3.62557285e-02f, -3.59973311e-02f, -6.52204901e-02f, -7.08924001e-03f,
  -5.73919248e-03f, -3.44049372e-02f, 4.03783582e-02f, -7.35492855e-02f, -2.91841291e-02f, -9.47906673e-02f, -5.26333712e-02f, 2.30906252e-02f, 1.98478028e-02f, -2.82175951e-02f,
  8.44746232e-02f, -4.32019979e-02f, -4.70518209e-02f, 2.23926622e-02f, 2.90803965e-02f, -6.71521528e-03f, 9.07165334e-02f, 8.86094496e-02f, -2.83165611e-02f, 7.03184828e-02f,
  -1.05585761e-01f, -7.79533610e-02f, -4.27895151e-02f, -6.79622814e-02f, 6.85305670e-02f, 8.75323415e-02f, 1.71168311e-03f, -3.73477675e-02f, -3.69203440e-03f, 3.56202051e-02f,
  -5.81193306e-02f, -5.06571159e-02f, -4.40647686e-03f, -3.67750712e-02f, -2.12204643e-02f, -7.37304389e-02f, 4.23220024e-02f, -1.21935263e-01f, -3.58329192e-02f, 8.01223442e-02f,
  4.66313772e-02f, -7.19747767e-02f, -1.55712873e-01f, 5.68820164e-03f, 6.18469715e-02f, -1.66823436e-02f, -7.76188672e-02f, -9.91750211e-02f, -5.29353420e-05f, -1.07871078e-01f,
  -5.74089363e-02f, 8.72933418e-02f, -5.16656153e-02f, -7.96219856e-02f, 3.42321470e-02f, 1.71030417e-01f, 2.40983441e-01f, 1.44831585e-02f, -5.22317998e-02f, -8.10300484e-02f,
  -4.88720089e-02f, -1.25868693e-01f, -1.26951739e-01f, -3.44965793e-02f, 1.02790222e-01f, 1.74913615e-01f, 3.12313903e-02f, 6.77636638e-02f, 1.47315348e-03f, -6.40174448e-02f,
  -9.99225751e-02f, -7.13864714e-02f, -1.39709804e-02f, 1.08553190e-02f, 8.76549333e-02f, -1.78107843e-02f, -1.67699102e-02f, 4.56987433e-02f, 1.31364092e-01f, 5.04293777e-02f,
  -4.65493463e-02f, -5.92427999e-02f, 1.17944516e-02f, -6.44331500e-02f, -1.91437658e-02f, 5.79343438e-02f, 2.91147307e-02f, -6.37023672e-02f, 1.70003634e-03f, -4.30915058e-02f,
  7.38594830e-02f, 2.58342121e-02f, 8.56559277e-02f, -2.56704371e-02f, 1.55915143e-02f, 7.30222464e-02f, -2.34925095e-02f, 1.04948552e-02f, 4.43755696e-03f, 9.83096138e-02f,
  7.64656961e-02f, -1.48832594e-04f, 4.80173565e-02f, 7.25678653e-02f, 7.11500198e-02f, -7.18505085e-02f, 7.63275251e-02f, 8.71856287e-02f, 1.42933711e-01f, -2.45533194e-02f,
  -3.59449722e-02f, 6.93876073e-02f, 3.46694440e-02f, -2.38743145e-02f, 4.99102063e-02f, 3.83423753e-02f, 2.15544812e-02f, -3.13552357e-02f, 1.13315862e-02f, -5.94128519e-02f,
  1.14712007e-02f, 1.36932433e-02f, 3.71580268e-03f, -6.41991058e-03f, -7.81426057e-02f, 7.64100626e-02f, 1.13114946e-01f, 9.40054841e-03f, -2.52878126e-02f, 1.50371324e-02f,
  1.35802524e-02f, 3.75985950e-02f, -2.85107885e-02f, -2.99048182e-02f, 5.03866710e-02f, 4.52337153e-02f, 7.63282180e-02f, 1.25535235e-01f, 4.15029749e-02f, 9.06638950e-02f,
  -1.23533547e-01f, -2.77621523e-02f, -1.14065886e-01f, 5.34898564e-02f, -1.30240237e-02f, 1.26061188e-02f, 3.22891846e-02f, 4.79065105e-02f, -2.25152094e-02f, -3.12997326e-02f,
  -3.20588984e-02f, -5.64465439e-03f, 4.75744158e-02f, 5.99004775e-02f, -5.41057363e-02f, -8.66872966e-02f, -1.93237979e-02f, 2.32398766e-03f, -2.60405242e-02f, -4.43727560e-02f,
  -2.67333090e-02f, 2.39927657e-02f, -5.66281416e-02f, 8.42917264e-02f, 2.99719200e-02f, 3.91025282e-02f, 2.55697854e-02f, -8.30417685e-03f, 1.52393915e-02f, 1.28844410e-01f,
  -7.33604953e-02f, 9.96279120e-02f, -4.35943119e-02f, -1.58638462e-01f, -5.89749850e-02f, 8.54499191e-02f, 2.89413393e-01f, -6.12741224e-02f, -1.97613537e-02f, 7.55311549e-02f,
  -1.04082994e-01f, -2.87605058e-02f, -9.48862806e-02f, 2.76151448e-02f, 1.62310041e-02f, 1.91259772e-01f, 1.50705546e-01f, 7.61983097e-02f, 3.11965998e-02f, 7.50624090e-02f,
  -8.28024894e-02f, -1.27414288e-02f, -8.29376951e-02f, -6.15556201e-04f, -2.20518447e-02f, -1.61051556e-01f, 4.44834307e-02f, -3.37995589e-02f, -7.13674575e-02f, 5.44444621e-02f,
  -3.86838093e-02f, 2.94751842e-02f, 5.99047355e-02f, 3.63002829e-02f, -1.05663151e-01f, -3.13993953e-02f, 7.37980008e-02f, -8.73899609e-02f, -4.80083451e-02f, -5.81470830e-03f,
  -7.53155444e-03f, -2.35616677e-02f, -5.91543876e-02f, 7.88028911e-03f, 5.85039472e-03f, -9.46571454e-02f, -1.57284401e-02f, 2.30832770e-02f, 1.18027218e-02f, -4.67224084e-02f,
  -1.74439661e-02f, 3.30356620e-02f, 9.15632322e-02f, -2.02315412e-02f, 3.64575200e-02f, -1.23009030e-02f, -5.25497459e-02f, -6.82968795e-02f, -4.50365357e-02f, -8.31916705e-02f,
  2.07840325e-03f, -1.03349220e-02f, -6.16005249e-02f, 6.40271306e-02f, 4.44164127e-03f, -9.36369076e-02f, 2.35280022e-02f, 7.93764219e-02f, -4.67140079e-02f, 7.86330104e-02f,
  -1.74640156e-02f, -2.76961736e-02f, -6.19755052e-02f, -8.52518752e-02f, 2.34451015e-02f, 6.22488856e-02f, -4.20978889e-02f, 8.13771784e-02f, -5.71312644e-02f, 2.61551831e-02f,
  -4.26753275e-02f, -1.98028274e-02f, -4.95661423e-02f, -9.25965756e-02f, 7.08188787e-02f, 4.40638028e-02f, -3.27986665e-02f, -1.42348977e-02f, -5.53814061e-02f, -4.31325547e-02f,
  -1.31044388e-01f, 1.83312029e-01f, -4.60322164e-02f, 2.54794527e-02f, 6.09529531e-03f, 7.93560073e-02f, 2.70496425e-03f, -7.40677193e-02f, -3.48529704e-02f, 1.95822287e-02f,
  -4.46575955e-02f, -4.76498157e-02f, -4.28676456e-02f, 3.98605466e-02f, -3.14389318e-02f, -3.79744358e-02f, 2.97074467e-02f, -5.44542521e-02f, 2.27151811e-02f, 5.45051321e-02f,
  1.85376592e-02f, 1.00686274e-01f, 4.68032695e-02f, 9.23210531e-02f, -4.12405878e-02f, 1.52062625e-02f, 9.51404870e-02f, 3.95057863e-03f, 9.92411375e-02f, 1.64853316e-02f,
  -6.46617949e-01f, 1.02070488e-01f, -1.54563025e-01f, -5.07437229e-01f, -2.77591199e-01f, -4.41819243e-02f, -1.23996519e-01f, 4.24455144e-02f, -8.94616917e-02f, -1.02517031e-01f,
  4.97591421e-02f, -1.49286753e-02f, 1.71209835e-02f, 1.02928266e-01f, 1.92996655e-02f, 7.92205799e-03f, -9.99555588e-02f, -5.51845990e-02f, -1.64209291e-01f, -1.21670052e-01f,
  -1.15709670e-01f, -2.85805285e-01f, -2.01911107e-01f, 1.24543637e-01f, -4.73636240e-02f, -2.39155348e-02f, -3.49337012e-02f, -1.66948199e-01f, 1.91363573e-01f, -2.57947236e-01f,
  2.34725457e-02f, -9.48953852e-02f, -6.81456327e-02f, 4.88789156e-02f, -1.09054737e-01f, 8.02924708e-02f, 5.22807464e-02f, 3.25732231e-02f, 8.14747363e-02f, 4.69103195e-02f,
  -3.73524465e-02f, 2.25402284e-02f, 3.17046903e-02f, -2.80143656e-02f, 5.94051480e-02f, 5.18594161e-02f, 7.24248216e-02f, 8.49138945e-03f, 7.10322484e-02f, -1.49728674e-02f,
  -7.90949166e-02f, -6.93975613e-02f, 3.95100750e-02f, 5.61921671e-02f, 4.77072895e-02f, -1.01556452e-02f, 4.57525477e-02f, 1.00631893e-01f, 9.04884562e-02f, 9.72611904e-02f,
  -6.87639266e-02f, 6.29698485e-02f, 2.79464643e-03f, -2.12931111e-02f, 3.24918237e-03f, 1.14251506e-02f, -1.90088972e-02f, -6.41304180e-02f, -5.09847887e-02f, 2.21297909e-02f,
  -1.47522306e-02f, -2.49046851e-02f, 6.80949464e-02f, -6.78829253e-02f, 3.42006683e-02f, -9.78110433e-02f, 6.35013953e-02f, -2.13884544e-02f, 3.21811251e-02f, 2.34001856e-02f,
  2.69959383e-02f, 2.68709194e-02f, 1.13970656e-02f, 1.12754710e-01f, 3.30860838e-02f, -8.20685402e-02f, -3.91179360e-02f, 5.53774945e-02f, -5.66974506e-02f, 3.33351344e-02f,
  -2.49976646e-02f, -6.33946806e-02f, 3.40261906e-02f, 4.58899364e-02f, -4.25439514e-02f, 2.25924179e-02f, -4.09201309e-02f, 4.75779129e-03f, -8.03920720e-03f, 5.45652434e-02f,
  -3.71652469e-02f, 1.36074051e-02f, -1.92040801e-02f, 1.44941825e-02f, -2.90151034e-02f, -2.79662963e-02f, -1.88885070e-02f, -8.69488493e-02f, 2.68474631e-02f, 3.19670253e-02f,
  5.81484698e-02f, 1.23206386e-02f, 3.00053302e-02f, 8.43383074e-02f, 1.08135014e-03f, -6.37119710e-02f, 8.40979740e-02f, -6.00114278e-03f, 1.22798301e-01f, 1.20231569e-01f,
  1.03655085e-01f, -7.86201190e-03f, -1.14556462e-01f, 6.63444176e-02f, -1.37803853e-01f, -1.92470327e-01f, -4.24937367e-01f, -8.92655924e-02f, 1.76018998e-01f, -9.71128196e-02f,
  -1.33615583e-01f, 1.43987700e-01f, 1.25754386e-01f, 1.13989323e-01f, -5.27179763e-02f, -1.58276632e-01f, -9.59597379e-02f, -2.00132616e-02f, 7.82590359e-02f, 2.94890217e-02f,
  -3.87567617e-02f, 3.78390476e-02f, 1.92737609e-01f, 1.18173145e-01f, 9.43291560e-02f, 3.10935490e-02f, 9.48522892e-03f, -3.38044725e-02f, -5.92531040e-02f, 6.63852692e-02f,
  -1.08275175e-01f, -1.96301509e-02f, 3.05888448e-02f, 3.48633416e-02f, -9.68531221e-02f, -3.78967205e-04f, -8.12536180e-02f, 3.42185311e-02f, -5.27306274e-02f, -5.74849062e-02f,
  -2.58159824e-02f, 2.93037239e-02f, -5.02236672e-02f, -6.38074949e-02f, -5.56396507e-02f, 3.88670862e-02f, 8.32731798e-02f, 8.48567933e-02f, 7.41815045e-02f, -1.20884649e-01f,
  -8.36480632e-02f, 4.59385514e-02f, -8.84481966e-02f, 1.13575840e-02f, 2.51445803e-03f, 6.29028538e-03f, -1.16374925e-01f, -3.67213003e-02f, -1.96685903e-02f, 4.22494709e-02f,
  -9.56714246e-03f, -3.82898301e-02f, 2.83908821e-03f, 6.48177564e-02f, -4.62922677e-02f, 6.54029548e-02f, 1.83484741e-02f, -8.99377763e-02f, 1.85018368e-02f, -2.89873630e-02f,
  2.03500055e-02f, -2.47555804e-02f, -6.36493340e-02f, 8.77129566e-03f, -3.51087414e-02f, -4.51133065e-02f, -3.07161221e-03f, -2.21187365e-03f, -9.72815044e-03f, 9.76810530e-02f,
  6.81057945e-02f, 5.69832027e-02f, -2.89897081e-02f, -2.61945743e-02f, 2.42711809e-02f, 1.35302758e-02f, -1.30655728e-02f, 5.10579161e-02f, -2.11198293e-02f, -6.73207454e-03f,
  1.12651147e-01f, -7.63116078e-03f, 8.38263035e-02f, 7.91870877e-02f, 2.75686942e-03f, 8.33683163e-02f, -5.62704634e-03f, 4.70815646e-03f, 9.12184548e-03f, -5.28811440e-02f,
  -1.17141791e-01f, 3.49582136e-02f, -2.98515446e-02f, 2.28577387e-02f, -3.57154920e-03f, 5.54530770e-02f, 2.45599449e-02f, -3.93146500e-02f, -2.79893056e-02f, 1.69161009e-03f,
  -5.29343896e-02f, 1.50650153e-02f, 1.24928243e-02f, -3.30905318e-02f, -6.64510531e-03f, 1.11397346e-02f, -8.11400265e-02f, -1.99710466e-02f, -2.19650120e-02f, 6.77330792e-02f,
  1.21327206e-01f, 6.42376021e-02f, -6.37411997e-02f, 8.98376629e-02f, 3.72820944e-02f, -1.63960636e-01f, -1.38618246e-01f, -1.26325056e-01f, -4.96052504e-02f, 8.46126210e-03f,
  -1.30244642e-02f, 1.81897897e-02f, 9.37569961e-02f, 6.89858943e-02f, -1.17559709e-01f, 4.60728817e-02f, 2.25037336e-02f, 1.19961530e-01f, -1.91165060e-02f, -1.26124531e-01f,
  8.60031843e-02f, 1.75405636e-01f, 1.84800297e-01f, 1.06515475e-02f, 4.10052948e-02f, 8.36195648e-02f, 6.35555089e-02f, 1.52216956e-01f, 6.16446920e-02f, 2.66654134e-01f,
  8.03179760e-03f, -3.22055146e-02f, 1.75712928e-02f, 1.16896920e-01f, -7.29564503e-02f, -9.44369882e-02f, -1.15401797e-01f, 1.35813225e-02f, -1.94962248e-02f, 4.59022895e-02f,
  4.62077521e-02f, 5.09772077e-02f, 1.95626654e-02f, 2.36252118e-02f, -1.79479888e-03f, -4.36190702e-02f, 1.47372652e-02f, 4.42814939e-02f, -7.09732994e-02f, -1.10559493e-01f,
  4.21349183e-02f, -1.89296734e-02f, -1.22506708e-01f, -1.16970748e-01f, -9.00509879e-02f, -6.75912648e-02f, 3.54602374e-02f, -3.27144703e-03f, -8.22085813e-02f, 1.23031244e-01f,
  -4.57051210e-03f, 5.28834015e-02f, -8.90172739e-03f, -2.12258715e-02f, -1.23969130e-02f, -3.01950201e-02f, 7.92945772e-02f, 3.47167999e-02f, 6.25869557e-02f, 9.86508280e-03f,
  3.64803597e-02f, -4.89502810e-02f, -2.43062042e-02f, -8.22845623e-02f, 7.67076835e-02f, 5.76738417e-02f, -4.45791520e-02f, -2.34850962e-02f, -2.23310124e-02f, -8.89313221e-03f,
  -6.80347979e-02f, -1.63309481e-02f, 4.01347913e-02f, 5.64739807e-03f, -6.23723976e-02f, 2.18591467e-02f, -4.71816398e-02f, 6.22040592e-02f, 1.83959422e-03f, -4.55742255e-02f,
  1.06596813e-01f, -4.26165573e-02f, 4.66410592e-02f, 9.86823160e-03f, 3.11365221e-02f, 2.73674261e-02f, 2.53887498e-03f, 9.97611359e-02f, 2.53615137e-02f, 4.65370417e-02f,
  -7.33158365e-02f, 8.42625871e-02f, -1.19859753e-02f, -5.71575537e-02f, 2.79580560e-02f, -5.61091490e-02f, -2.15201057e-03f, 3.72845307e-02f, -5.57719618e-02f, 2.16318108e-02f,
  -2.99777631e-02f, -7.61788711e-02f, -3.21472832e-03f, 5.32821119e-02f, -7.48284981e-02f, 7.38211125e-02f, 2.03292053e-02f, -1.83859169e-02f, 8.21803987e-04f, 1.70819178e-01f,
  -4.87573706e-02f, -3.59046072e-01f, -8.10615644e-02f, 3.50756049e-02f, -1.11529343e-02f, 1.51258603e-01f, -1.67475995e-02f, 2.04883534e-02f, -1.05428994e-02f, -1.26811594e-01f,
  -8.54734033e-02f, 1.32561117e-01f, 1.03902243e-01f, 1.04118116e-01f, -6.37336969e-02f, -9.76396650e-02f, -1.99763894e-01f, -4.62419651e-02f, 2.33428448e-01f, 2.33494207e-01f,
  6.09458424e-03f, -3.18419784e-02f, 8.15229118e-02f, 1.09610289e-01f, -8.66318122e-03f, 2.76315898e-01f, -1.40906706e-01f, 5.63436281e-03f, 1.08082868e-01f, -2.15593532e-01f,
  8.61106515e-02f, -2.25945547e-01f, 1.42715648e-01f, -1.27548188e-01f, -6.42753690e-02f, -2.18498208e-05f, 8.63195024e-03f, -1.03801563e-01f, 1.84932277e-02f, -7.21535906e-02f,
  1.31455502e-02f, 6.59823464e-03f, 1.05225638e-01f, -2.96434481e-02f, 4.13015336e-02f, 3.12453080e-02f, -2.85028629e-02f, -1.17700495e-01f, -1.23036332e-01f, -2.45858822e-02f,
  -7.04489574e-02f, -4.69149426e-02f, -1.72415171e-02f, -8.23523849e-03f, -6.57633245e-02f, -4.95413691e-02f, -5.27407005e-02f, -6.12694654e-04f, -3.90218198e-02f, 5.43023795e-02f,
  3.39240432e-02f, -9.39314626e-03f, 1.21605713e-02f, -3.09591740e-02f, 8.41851830e-02f, 5.98854094e-04f, -1.90796033e-02f, 1.81577969e-02f, -8.30435008e-02f, 5.94740622e-02f,
  2.75301952e-02f, -6.63855597e-02f, 7.27396682e-02f, 4.46965881e-02f, -2.44689323e-02f, 5.89520857e-03f, -3.00931502e-02f, 6.13806164e-03f, -2.10706629e-02f, 1.88856367e-02f,
  -6.84063733e-02f, -3.68484184e-02f, 1.71647221e-02f, 3.97310741e-02f, -9.75949839e-02f, 1.82794109e-02f, -2.45149974e-02f, -2.32166089e-02f, 8.78455043e-02f, -1.28346249e-01f,
  1.19025603e-01f, -1.46964744e-01f, 2.46433783e-02f, 7.41215199e-02f, 1.38239162e-02f, 3.17371599e-02f, -3.43403444e-02f, 5.93314096e-02f, -7.67629221e-02f, 3.04264687e-02f,
  -1.99391395e-02f, 6.40261769e-02f, -7.40328431e-02f, 2.12804433e-02f, 2.82430686e-02f, -7.01604737e-03f, -4.37617376e-02f, 4.85318825e-02f, -4.41672057e-02f, -2.01912690e-02f,
  3.20099778e-02f, 4.13427316e-02f, 1.88527301e-01f, 9.53306630e-02f, 1.34191036e-01f, 8.95205289e-02f, 1.10533006e-01f, 9.63069275e-02f, 6.47654012e-02f, 1.05666123e-01f,
  -8.24551731e-02f, -9.89048257e-02f, 1.01868317e-01f, -1.47114128e-01f, -7.45307356e-02f, 1.38366073e-01f, 2.06670061e-01f, -1.17847370e-02f, -1.06722720e-01f, 1.05756976e-01f,
  -1.73946679e-01f, -8.50334838e-02f, -3.07882857e-03f, -5.36313131e-02f, 4.79298905e-02f, 1.23645179e-01f, 1.61821485e-01f, -7.23746838e-03f, 1.01224892e-01f, 4.38337587e-02f,
  9.41922702e-03f, 6.25024289e-02f, -1.68881148e-01f, -7.25140348e-02f, 7.48092756e-02f, -4.40538749e-02f, -3.22091952e-02f, -4.33438495e-02f, -7.18609095e-02f, 1.49957746e-01f,
  7.15453103e-02f, -1.61842495e-01f, 6.72726482e-02f, -8.59916657e-02f, 1.10348184e-02f, 2.13306006e-02f, -4.07121256e-02f, -7.32183233e-02f, -9.67412889e-02f, -5.95012009e-02f,
  -1.18427396e-01f, -4.67771702e-02f, -7.52502531e-02f, 7.68303580e-05f, -3.63739096e-02f, 9.50589851e-02f, 1.84502248e-02f, -5.00443466e-02f, 1.08239204e-01f, -5.75869605e-02f,
  -5.94376922e-02f, -1.05316892e-01f, -1.20181218e-01f, -8.90797973e-02f, 9.19083320e-03f, -4.70635146e-02f, -1.69029698e-01f, -6.91686058e-03f, -1.11597955e-01f, 4.92504537e-02f,
  2.40091048e-02f, -5.51384576e-02f, 2.56865788e-02f, -1.89192127e-03f, -2.78915241e-02f, -5.08355573e-02f, -4.04530624e-03f, -3.72661427e-02f, -5.83212217e-03f, 8.42738077e-02f,
  -1.97010934e-02f, -2.44472791e-02f, 5.25171384e-02f, 4.83604148e-02f, 3.15256342e-02f, 5.23919724e-02f, 1.18199261e-02f, -1.72334723e-02f, -3.31338681e-02f, 1.40876686e-02f,
  -2.46873312e-03f, -3.71208452e-02f, 7.91899711e-02f, 3.34775038e-02f, -5.42211644e-02f, -1.26051605e-01f, 6.20378032e-02f, -1.37102112e-01f, -9.76974843e-04f, -3.13669182e-02f,
  8.16254094e-02f, -1.06093548e-01f, -2.06010207e-03f, 3.29556433e-03f, 1.27997734e-02f, -4.79961447e-02f, -2.28041392e-02f, 4.82879300e-03f, -9.37826838e-03f, 4.89423126e-02f,
  1.45747475e-02f, -5.41631877e-03f, 5.47691770e-02f, -1.45519627e-02f, 1.53410926e-01f, 1.60661098e-02f, -1.22520262e-02f, -8.00690427e-03f, -2.12898050e-02f, 8.34840313e-02f,
  2.11547986e-02f, 5.49833328e-02f, 6.47362471e-02f, 3.03826737e-03f, 6.19044676e-02f, 4.70222048e-02f, 1.23186119e-01f, -2.63097640e-02f, 4.77150492e-02f, 1.40646860e-01f,
  5.24935573e-02f, 1.58008356e-02f, -5.57853952e-02f, -1.04499921e-01f, -7.65548125e-02f, -6.49413317e-02f, 4.37442511e-02f, -1.31406173e-01f, -4.42156419e-02f, 3.66567820e-02f,
  1.09751504e-02f, -2.75541078e-02f, 2.84152254e-02f, 8.29606354e-02f, -4.34524789e-02f, 7.85219222e-02f, 5.65641038e-02f, 1.08153298e-01f, 6.31699264e-02f, 3.21027972e-02f,
  -9.80708189e-03f, 5.07095503e-03f, 6.94002360e-02f, -2.85251737e-02f, 1.36476010e-02f, 2.78831217e-02f, -2.35897154e-02f, -7.42122978e-02f, -3.82852145e-02f, 8.82712379e-02f,
  -1.40530497e-01f, -1.25596106e-01f, 5.36509091e-03f, 3.70011255e-02f, 4.95037902e-03f, 1.88168101e-02f, -8.87972936e-02f, 2.60898564e-02f, 8.74941610e-03f, -9.28982794e-02f,
  -8.74992609e-02f, -1.04408190e-01f, 6.23793900e-02f, 1.33043376e-03f, 3.59787196e-02f, 5.02949506e-02f, -5.18152229e-02f, 8.78344700e-02f, 5.69520667e-02f, 3.28831151e-02f,
  -2.99094748e-02f, -1.37812600e-01f, 3.15372758e-02f, 7.80404452e-03f, -6.95026740e-02f, 8.41272175e-02f, -4.30067182e-02f, -8.15895945e-02f, -6.34028614e-02f, -6.53459430e-02f,
  6.02956079e-02f, -3.69209647e-02f, 5.03328629e-02f, 8.47614631e-02f, -2.28722338e-02f, 8.20729509e-02f, 8.10904354e-02f, -6.47142064e-03f, 2.69460622e-02f, -9.77262035e-02f,
  -6.72443435e-02f, -3.33944857e-02f, -5.93193322e-02f, -6.67410865e-02f, -4.57908809e-02f, -5.35289720e-02f, -1.47050004e-02f, 3.07583213e-02f, -5.99150471e-02f, 2.66464334e-02f,
  2.84911692e-02f, 4.92215380e-02f, -5.99710010e-02f, -2.39914451e-02f, -2.98242103e-02f, 1.45253018e-02f, -1.92863289e-02f, -7.03460127e-02f, -1.58748496e-02f, -3.75335217e-02f,
  -5.07831238e-02f, -3.89088392e-02f, 3.22075970e-02f, 7.86130875e-02f, 6.91986308e-02f, -2.38864962e-02f, -4.46334928e-02f, -2.76767407e-02f, 3.79315577e-02f, -5.00683486e-02f,
  -8.56929831e-03f, 6.06113523e-02f, -1.29496846e-02f, -7.07977340e-02f, -5.66462092e-02f, 9.14653242e-02f, 9.30283032e-03f, -2.30843890e-02f, 8.53147656e-02f, -8.92216042e-02f,
  8.41324851e-02f, 1.16168987e-04f, -5.13613112e-02f, -6.74645975e-03f, 7.00689852e-02f, 4.67506163e-02f, 6.55262247e-02f, 5.21230511e-02f, 1.03757828e-01f, 8.91831983e-03f,
  1.39265209e-01f, -4.79034968e-02f, -5.36703393e-02f, 5.95083125e-02f, -4.84998897e-02f, 7.92149380e-02f, 2.14139875e-02f, -3.76030728e-02f, 1.08754952e-02f, -6.17075972e-02f,
  -7.40521296e-04f, 2.00299989e-03f, -2.30940972e-02f, 5.09206727e-02f, 7.05885366e-02f, -4.88617271e-02f, 1.10158145e-01f, 1.38337240e-01f, 7.07133412e-02f, -9.02618188e-03f,
  7.40902945e-02f, -2.90148202e-02f, 9.09739882e-02f, 6.24781363e-02f, -1.09068580e-01f, 3.83822322e-02f, 1.35590732e-02f, 5.39798625e-02f, 2.19951682e-02f, -5.74499629e-02f,
  -2.11037934e-01f, -7.44534060e-02f, 3.95042822e-03f, -1.27304196e-02f, 1.32286549e-02f, 1.16638482e-01f, 1.21010393e-01f, 5.43768182e-02f, -3.01472936e-02f, 4.33104374e-02f,
  -4.23794687e-02f, 8.28133747e-02f, -5.53160300e-03f, -2.41765492e-02f, 8.63135532e-02f, 3.84291820e-02f, 4.76297177e-02f, -4.32761051e-02f, 2.97569633e-02f, -8.13219622e-02f,
  -7.41992146e-02f, 6.40347302e-02f, 2.31343438e-03f, 6.40638322e-02f, -4.39331159e-02f, -4.64824811e-02f, -9.26708453e-04f, 1.38632283e-02f, -4.10795733e-02f, -3.35938819e-02f,
  2.08808165e-02f, -2.01083181e-04f, -1.90708674e-02f, -5.41135520e-02f, 4.28983569e-02f, 2.58764755e-02f, 1.21869510e-02f, -1.95531081e-03f, 2.21394263e-02f, -7.60603920e-02f,
  -7.56294727e-02f, 3.59233990e-02f, -6.04894497e-02f, 1.60005782e-02f, -1.16798375e-02f, 8.05813540e-03f, -2.44609918e-02f, 2.50879359e-02f, -3.20057608e-02f, 1.61483213e-02f,
  4.45794798e-02f, -4.11095507e-02f, -4.57889400e-03f, 3.66937369e-02f, 7.59817809e-02f, -3.57560590e-02f, 3.15623917e-02f, 3.58637311e-02f, -5.95931038e-02f, -1.38931982e-02f,
  -1.77392393e-01f, 1.26289472e-01f, -9.24111232e-02f, 5.99930137e-02f, -1.09576471e-02f, -1.32714957e-02f, -9.99140292e-02f, 1.14871763e-01f, -2.02691760e-02f, -3.18406671e-02f,
  3.52984779e-02f, 3.53090763e-02f, 2.10744832e-02f, -5.17368838e-02f, -7.25618973e-02f, 1.39126498e-02f, -3.10422033e-02f, 2.00330615e-02f, 3.66305262e-02f, -8.77407119e-02f,
  -1.35640521e-02f, -2.91134361e-02f, -9.76817980e-02f, -3.87549549e-02f, -6.21733777e-02f, 7.21143484e-02f, -8.75595063e-02f, -1.11549661e-01f, -2.12582741e-02f, 9.21278540e-03f,
  4.31166708e-01f, -9.69280824e-02f, -3.61528397e-02f, 1.12776030e-02f, -1.41891330e-01f, -6.72141463e-02f, -2.13405833e-01f, -1.35912612e-01f, -5.24774082e-02f, -6.89578354e-02f,
  -1.02347456e-01f, 5.15805259e-02f, 6.82225078e-02f, 2.15508882e-03f, -1.72878355e-02f, -6.16104677e-02f, -1.19235940e-01f, 6.83011934e-02f, 2.46710360e-01f, 4.16638143e-02f,
  -5.55988364e-02f, -2.26925798e-02f, 8.06629658e-02f, 1.16978526e-01f, -6.74053729e-02f, 1.35759907e-02f, -8.48103762e-02f, -5.56057729e-02f, 8.21665600e-02f, -2.29432717e-01f,
  5.75128905e-02f, 3.76047678e-02f, 1.98166799e-02f, 7.09180981e-02f, -2.27581207e-02f, 1.36698157e-01f, 1.02712708e-02f, 7.20272958e-02f, 2.66965609e-02f, -4.44827154e-02f,
  1.03916693e-02f, 1.30891288e-02f, 7.46653304e-02f, 9.31629818e-03f, -4.93529346e-03f, 9.15707275e-02f, -1.04818478e-01f, 1.05159171e-01f, -3.32049131e-02f, -8.38708878e-02f,
  -1.97087377e-02f, 2.77377805e-03f, 2.32589189e-02f, -2.31784694e-02f, -3.45481895e-02f, -2.62635928e-02f, -5.71064763e-02f, -9.45999566e-03f, 7.76745081e-02f, 4.40166816e-02f,
  -2.43541226e-02f, -3.45604424e-03f, 3.79029177e-02f, -3.33960541e-03f, 5.42232245e-02f, -4.51415293e-02f, -2.51799505e-02f, -3.79185332e-03f, -1.26813236e-03f, 3.38928832e-04f,
  -5.51564945e-03f, -1.99339315e-02f, -8.08750559e-03f, 2.41420381e-02f, -3.63829583e-02f, 3.32078189e-02f, 7.76200835e-03f, -1.53710349e-02f, 2.92449202e-02f, -6.23006187e-03f,
  -2.09953375e-02f, 1.87841933e-02f, 5.73504250e-03f, 1.68948565e-02f, -4.19367850e-02f, 5.06327935e-02f, -2.31911670e-02f, -8.57472513e-03f, -2.53639114e-03f, 5.37445396e-02f,
  1.49945309e-02f, 1.78121626e-02f, -1.41448125e-01f, -6.74136877e-02f, 6.11181855e-02f, 6.16733730e-02f, -7.28240758e-02f, -5.06178942e-04f, -5.88921234e-02f, 3.95409912e-02f,
  1.00907022e-02f, 7.85104632e-02f, -7.61036202e-02f, -9.83291641e-02f, 5.53356223e-02f, -3.39608714e-02f, -2.88089225e-03f, 4.74200994e-02f, -8.05962905e-02f, 8.07580277e-02f,
  -7.21216481e-03f, 9.08915401e-02f, 4.05697264e-02f, -2.23506149e-02f, -2.49375962e-02f, 1.17075004e-01f, -6.68729795e-03f, -7.87785947e-02f, 8.54419246e-02f, -1.77799668e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.33011192e-02f, 6.63196482e-03f, 4.53064078e-03f, 2.90787476e-03f, 6.28553331e-02f, 1.17457196e-01f, 4.89047915e-02f, 5.56413159e-02f, -1.15884682e-02f, -2.96158530e-02f,
  -9.14378539e-02f, 1.01909168e-01f, -4.47196476e-02f, 1.24264471e-01f, 7.87012652e-02f, 1.21013738e-01f, -1.75398607e-02f, 8.16761404e-02f, -5.30859903e-02f, -6.29871786e-02f,
  1.18455790e-01f, -3.82440761e-02f, 1.06753461e-01f, 7.96742514e-02f, 1.00470483e-01f, -1.23830447e-02f, -2.69065928e-02f, -1.25237815e-02f, 9.84496623e-02f, 1.49608925e-01f,
  -4.11128663e-02f, -5.34072286e-03f, -1.51066959e-01f, -6.48426041e-02f, 5.52739613e-02f, 1.35307118e-01f, 1.97628457e-02f, -3.61194573e-02f, -8.63286704e-02f, -5.26127703e-02f,
  8.79586209e-03f, -4.30162996e-03f, 3.60515714e-02f, 8.40830579e-02f, 7.17413351e-02f, 3.29583324e-02f, -6.19079992e-02f, 1.11598507e-01f, 1.03547990e-01f, -1.14648342e-02f,
  -4.51117381e-02f, -1.01529919e-01f, -4.16901931e-02f, -1.00100063e-01f, 8.48340094e-02f, 1.29266456e-02f, -2.46040318e-02f, 7.73020387e-02f, -8.87846947e-02f, 6.75362572e-02f,
  5.45284823e-02f, 8.31305161e-02f, -2.25603916e-02f, 3.45406234e-02f, 4.87881266e-02f, -6.10875115e-02f, -3.53759266e-02f, 8.38224217e-02f, 6.78899139e-02f, 8.29027519e-02f,
  -3.03063262e-02f, 3.70203927e-02f, -6.07975051e-02f, -5.30977026e-02f, -5.49339801e-02f, -8.35624635e-02f, 7.65955523e-02f, 6.58463314e-02f, -6.14110567e-02f, -7.18883472e-03f,
  5.19263977e-03f, -4.74079400e-02f, 2.88357921e-02f, 8.74427781e-02f, 7.34046623e-02f, -1.31826941e-03f, 3.26243825e-02f, -6.22703955e-02f, 4.60900888e-02f, -2.70734150e-02f,
  4.37558891e-04f, -7.72787333e-02f, -7.29812831e-02f, 2.78747473e-02f, -3.44550274e-02f, 7.94457868e-02f, -1.65615715e-02f, -3.20571922e-02f, -5.38768359e-02f, 4.94049378e-02f,
  4.34372015e-02f, 7.24865869e-02f, 4.80193906e-02f, 5.35163991e-02f, -6.73232153e-02f, 2.47518104e-02f, -3.81823890e-02f, 9.75714549e-02f, -1.58815961e-02f, 3.26136090e-02f,
  -1.20983832e-02f, -7.88805261e-02f, 4.59754504e-02f, -6.89766407e-02f, 6.81488737e-02f, -6.09048717e-02f, -1.13791816e-01f, 5.11909742e-03f, 5.76619767e-02f, -9.91973281e-02f,
  2.03778788e-01f, -1.28490329e-01f, 2.03235626e-01f, 2.09745184e-01f, 1.62551090e-01f, 1.63625628e-01f, 1.90575212e-01f, 1.58607334e-01f, 7.31500387e-02f, -1.03258202e-02f,
  -3.52953188e-02f, 2.00811587e-02f, 8.28321502e-02f, 7.63697326e-02f, 2.16323342e-02f, 3.14507820e-02f, 1.39511690e-01f, 2.87695136e-02f, 7.88148120e-02f, 1.00229837e-01f,
  3.54579724e-02f, -8.72123912e-02f, -7.18262047e-02f, -5.88993262e-03f, -5.35252653e-02f, 1.24719441e-01f, -1.06568523e-01f, 5.17071635e-02f, -1.30486628e-02f, -7.85755962e-02f,
  -1.12613186e-01f, 5.83966784e-02f, 1.90360844e-01f, -6.25714287e-02f, -1.99308507e-02f, -3.49934660e-02f, 5.01140058e-02f, -9.26713347e-02f, 6.18835762e-02f, -3.29313651e-02f,
  -2.65645050e-02f, -5.01611568e-02f, 2.94057839e-03f, 5.84226437e-02f, 5.19334152e-03f, -8.65885839e-02f, -5.14509007e-02f, 4.71264310e-02f, -5.81820961e-03f, 7.43910810e-03f,
  -6.38382137e-02f, 3.98560911e-02f, -4.44522388e-02f, 9.59820375e-02f, 3.03500295e-02f, 1.03150986e-01f, -8.13110992e-02f, 1.01056136e-02f, -8.89784284e-03f, 2.11795811e-02f,
  3.81205752e-02f, 6.09503947e-02f, 9.83614475e-03f, -4.29251604e-02f, 5.63325882e-02f, 1.17361108e-02f, 4.67763841e-02f, -1.08770661e-01f, -5.55326678e-02f, 1.82037633e-02f,
  -5.67276515e-02f, 7.21128434e-02f, -1.43169211e-02f, 3.90647724e-02f, 3.04602962e-02f, -4.09506857e-02f, 8.28594118e-02f, -9.20391455e-02f, -6.18834347e-02f, -1.26256302e-01f,
  -5.61789051e-02f, 4.02195044e-02f, 5.48284384e-04f, 6.02595471e-02f, 1.54182501e-02f, 9.01831463e-02f, 3.41608897e-02f, 2.43077315e-02f, 7.37896888e-04f, 1.55319348e-02f,
  -4.89573665e-02f, 4.83220220e-02f, 3.36335488e-02f, -3.77027541e-02f, -1.45806288e-02f, 1.42541314e-02f, 8.91736522e-02f, -1.56911202e-02f, -2.43076403e-02f, 5.46381669e-03f,
  -9.17521864e-02f, 2.65009254e-02f, -4.64336835e-02f, -1.41809702e-01f, 1.07647814e-01f, 3.68955284e-02f, -1.07255325e-01f, 2.67436206e-02f, -7.63397291e-02f, 2.69501414e-02f,
  -3.23563851e-02f, 5.18804304e-02f, 1.04618981e-01f, 1.05530314e-01f, 6.12801686e-02f, 5.22328317e-02f, 1.48939583e-02f, -1.02797514e-02f, 8.17002952e-02f, -3.41801308e-02f,
  -1.47971585e-01f, -1.29537627e-01f, 7.26464540e-02f, 8.12585130e-02f, 1.53389752e-01f, 7.13968799e-02f, 1.28725722e-01f, 8.17464069e-02f, 9.01312679e-02f, -8.35116208e-03f,
  -9.51705053e-02f, -6.33062944e-02f, -4.48956676e-02f, 1.75706893e-02f, -3.46346684e-02f, 5.28529398e-02f, -6.11920515e-03f, 7.90689781e-04f, 5.94834127e-02f, 6.30606040e-02f,
  7.56353810e-02f, 2.79775374e-02f, 3.25171761e-02f, -2.41763368e-02f, 4.26285081e-02f, -1.95226923e-03f, 6.97724000e-02f, -7.64208063e-02f, -1.01983748e-01f, 1.53839942e-02f,
  -5.61669171e-02f, -1.27138808e-01f, 1.02209657e-01f, -3.99599895e-02f, 3.46011259e-02f, -6.54446194e-03f, -4.10896614e-02f, -3.31462324e-02f, -2.56631281e-02f, -4.48135436e-02f,
  3.76062170e-02f, -9.60437208e-02f, -5.76002076e-02f, -1.82326827e-02f, 3.05139795e-02f, -4.68917824e-02f, -4.26853113e-02f, -6.69893026e-02f, -7.88846239e-02f, -9.01190937e-02f,
  5.54555617e-02f, -9.20530260e-02f, -2.07053348e-02f, 9.44741536e-03f, 1.10780401e-02f, -3.84666212e-02f, -8.03102553e-02f, 4.94966395e-02f, 5.56017563e-04f, -1.00486256e-01f,
  -1.52436327e-02f, -8.68465900e-02f, 7.24447966e-02f, 3.99074592e-02f, 2.08218377e-02f, -3.72992232e-02f, 2.44476162e-02f, -5.17321564e-02f, -1.26213999e-02f, -1.41529897e-02f,
  2.71711480e-02f, 5.06063066e-02f, 5.72945327e-02f, -4.64890804e-03f, -1.12826098e-02f, 6.87901070e-03f, -4.65285480e-02f, -6.33472577e-02f, 2.21991222e-02f, 6.78143203e-02f,
  2.18955688e-02f, 1.23279691e-02f, -1.10524828e-02f, -1.12169655e-02f, -3.76439281e-02f, 2.65308674e-02f, -6.82736337e-02f, 2.48991977e-02f, 2.47419085e-02f, -1.25536211e-02f,
  3.72122265e-02f, -1.76536443e-03f, -1.49102109e-02f, 5.86060993e-02f, 7.19058663e-02f, 1.55331092e-02f, 6.28116727e-02f, 2.25986112e-02f, 1.89902764e-02f, 5.68530895e-02f,
  8.71041697e-03f, -5.83084449e-02f, -3.86366919e-02f, 7.76268765e-02f, -5.37550412e-02f, 4.76136729e-02f, -6.47929013e-02f, 7.71101490e-02f, -3.53633761e-02f, 4.01273295e-02f,
  7.09853321e-02f, -2.13499367e-02f, -5.12900651e-02f, 5.64291514e-02f, -1.78820156e-02f, 9.26156044e-02f, -5.85597306e-02f, 1.97453424e-02f, 1.71476044e-02f, 4.31232825e-02f,
  -1.40479982e-01f, -3.39249671e-02f, 1.31082505e-01f, -1.43318236e-01f, 5.52060343e-02f, 1.37438908e-01f, 6.01442046e-02f, -7.70040229e-02f, -5.88350967e-02f, -2.82005612e-02f,
  -3.14428434e-02f, 1.15015730e-02f, -9.86925140e-02f, 3.99631076e-02f, 2.63265963e-03f, -1.09439846e-02f, 7.47015998e-02f, 6.91036358e-02f, 1.81507140e-01f, 7.35327154e-02f,
  8.48943135e-04f, -9.47819576e-02f, -4.33197580e-02f, -2.49257442e-02f, -6.05090186e-02f, -5.41860238e-02f, 2.36401986e-02f, -1.13763370e-01f, 2.54992228e-02f, -1.29763544e-01f,
  2.50648826e-01f, 2.51885857e-02f, -8.13373849e-02f, -1.00231402e-01f, 3.55373360e-02f, -5.53870276e-02f, -5.66445701e-02f, -3.42446216e-03f, 3.21737267e-02f, -9.06391963e-02f,
  -3.75743676e-03f, 5.08894622e-02f, -1.05905840e-02f, -1.33489175e-02f, -5.11842072e-02f, -4.25802032e-03f, 1.72714368e-02f, -6.88589662e-02f, 3.91208343e-02f, -3.48171778e-02f,
  2.85493843e-02f, -5.28629199e-02f, 4.90381010e-02f, -7.47290300e-03f, -5.20827249e-02f, 4.35827672e-02f, -5.11541963e-02f, -7.29308799e-02f, -5.29327570e-03f, -8.44227672e-02f,
  4.67225094e-04f, 3.20003144e-02f, -3.00101116e-02f, 4.39770147e-02f, -8.46903250e-02f, 5.60811274e-02f, 1.09885767e-01f, 5.93666695e-02f, -8.69880095e-02f, -7.04006627e-02f,
  -2.93019786e-02f, 5.64613156e-02f, -3.51988710e-02f, -2.83648837e-02f, -6.43791333e-02f, -6.23710155e-02f, -1.87511966e-02f, -8.65144684e-05f, -7.68985972e-02f, -4.89015989e-02f,
  -2.60404628e-02f, 1.85068734e-02f, -3.25228311e-02f, 5.53860217e-02f, -6.67216554e-02f, 7.16308923e-03f, -2.05679201e-02f, 1.05070069e-01f, -7.25410283e-02f, 7.11303651e-02f,
  -4.77524847e-02f, -3.01059950e-02f, 3.70761380e-02f, -8.37029144e-02f, 5.98774105e-02f, -5.22408485e-02f, 6.17505424e-02f, -6.27119169e-02f, 2.82626785e-02f, -1.82376169e-02f,
  8.27502534e-02f, -1.05751853e-03f, 1.73734408e-02f, -2.62388103e-02f, 1.07336305e-01f, -6.99983984e-02f, -4.08483483e-02f, 8.50501359e-02f, 3.33226658e-02f, -1.42045334e-01f,
  8.76211468e-03f, 9.15338844e-02f, 7.77804181e-02f, 4.98519316e-02f, -9.10448506e-02f, 7.07566738e-04f, 6.30224571e-02f, 1.16996318e-01f, 1.10261776e-01f, -4.52366211e-02f,
  2.19645863e-03f, 7.90601522e-02f, 1.27188284e-02f, 5.52785210e-02f, -2.79108039e-03f, -6.84215873e-02f, -3.39277349e-02f, 5.98180946e-03f, -2.22463030e-02f, 2.30930094e-02f,
  -2.54501402e-02f, -4.36724462e-02f, 3.60752568e-02f, -4.53107245e-02f, 2.16960497e-02f, -1.01857437e-02f, 3.24061662e-02f, 1.00806236e-01f, 7.06639439e-02f, 6.00976422e-02f,
  -3.29374149e-02f, -5.65322007e-05f, 7.69834295e-02f, -6.65582940e-02f, 8.44100043e-02f, 6.10037893e-03f, -3.27298269e-02f, 9.55362320e-02f, -1.07165035e-02f, 1.03692576e-01f,
  1.37096690e-02f, -3.36599462e-02f, 4.89974860e-04f, 1.89678092e-02f, -7.08794817e-02f, -5.38810156e-03f, -3.46334688e-02f, 7.79606448e-03f, 3.08186840e-02f, -4.17429470e-02f,
  -5.98201416e-02f, 5.43539822e-02f, 3.16219218e-02f, -2.91449837e-02f, -3.93235125e-02f, 1.02352025e-02f, 6.14815168e-02f, 1.31217940e-02f, -8.19702521e-02f, 6.36848854e-03f,
  8.00381452e-02f, -2.14507524e-02f, 3.17434520e-02f, 4.84005213e-02f, -1.73260346e-02f, 4.49296497e-02f, 3.05148829e-02f, -2.08832677e-02f, -9.72491968e-03f, 8.91982839e-02f,
  -2.13828273e-02f, 2.49717664e-02f, 2.90034004e-02f, -2.58783493e-02f, -1.31200217e-02f, 6.10167719e-02f, 6.33455487e-03f, 6.19130917e-02f, 8.79833251e-02f, 5.66069670e-02f,
  -5.87872826e-02f, -1.91881731e-02f, -5.71803860e-02f, -7.39481673e-02f, -6.56004623e-02f, 3.05681862e-02f, 9.63168510e-04f, -3.88552137e-02f, 4.97671701e-02f, -7.41199926e-02f,
  7.87999853e-02f, 4.84214909e-02f, -5.42790331e-02f, 6.59938231e-02f, 3.51528861e-02f, 2.25917380e-02f, -2.57011317e-02f, 3.80522013e-02f, -6.41371757e-02f, 8.28535706e-02f,
  -4.66827415e-02f, -3.56274508e-02f, 9.13692862e-02f, 2.39279866e-02f, 4.81453687e-02f, -7.38987476e-02f, 3.87338512e-02f, 7.21461996e-02f, -7.65434131e-02f, -6.59897551e-03f,
  -6.90744966e-02f, 2.87010279e-02f, -1.05058877e-02f, 1.02153949e-01f, -5.98146506e-02f, -3.97287235e-02f, -3.10807936e-02f, 4.99961376e-02f, 8.39377791e-02f, -5.94037920e-02f,
  -1.70235280e-02f, -3.64963599e-02f, -3.11105140e-02f, -8.24515000e-02f, 4.69197109e-02f, 1.75296646e-02f, 4.29465733e-02f, -4.66860011e-02f, -8.31829831e-02f, -4.83417325e-03f,
  2.25331873e-01f, -1.29966080e-01f, -7.94290528e-02f, 2.16429532e-02f, -5.94458431e-02f, -4.31838073e-02f, -9.74093843e-03f, -1.09180413e-01f, 6.72582304e-03f, -2.46103704e-02f,
  -4.29874472e-02f, -1.01065256e-01f, -8.03864524e-02f, -7.33484924e-02f, -7.26388544e-02f, 1.92771051e-02f, 8.94106403e-02f, 1.17255136e-01f, 1.11698650e-01f, -7.80236945e-02f,
  -6.03293069e-02f, -9.90361441e-03f, -3.28901373e-02f, -5.54988813e-03f, -6.46045059e-02f, 1.07843960e-02f, 6.01981468e-02f, 2.08253181e-03f, -1.21716317e-02f, 3.17889825e-02f,
  3.53979059e-02f, -3.69316116e-02f, -6.00151308e-02f, -9.71360430e-02f, -1.15985140e-01f, 1.96730737e-02f, 9.91998985e-02f, -7.71207437e-02f, -5.36011532e-02f, -1.30462032e-02f,
  -1.16725832e-01f, -2.85377190e-03f, -4.93982024e-02f, -7.51547813e-02f, 1.27523048e-02f, 7.29210377e-02f, 8.21049418e-03f, -3.48526314e-02f, 4.03715037e-02f, -2.65631068e-04f,
  2.71669216e-02f, 6.04921719e-03f, -3.13944221e-02f, -1.67306571e-03f, 2.23727245e-02f, -2.10041180e-02f, -1.30089357e-01f, 1.76191460e-02f, 1.48332203e-02f, 2.68283579e-02f,
  4.62865420e-02f, 7.33178854e-02f, -5.75222485e-02f, 5.97103424e-02f, 1.02463737e-02f, 1.28789535e-02f, 7.27161691e-02f, -7.86538119e-04f, 6.24151528e-02f, 6.02567345e-02f,
  -9.86344293e-02f, 8.33839029e-02f, -2.02310048e-02f, -8.55259970e-02f, -1.60935298e-02f, -5.37433028e-02f, -4.87883948e-03f, 1.45102385e-03f, 2.48029586e-02f, -8.52630734e-02f,
  3.65324020e-02f, 3.21591012e-02f, -7.16913166e-03f, 4.17687111e-02f, 2.86378711e-02f, 3.26229073e-02f, -9.46273804e-02f, 3.48651111e-02f, 2.70518358e-03f, 3.57992649e-02f,
  -9.87900570e-02f, -2.39451360e-02f, 7.73799047e-02f, -8.74423459e-02f, -5.97756170e-02f, -1.91388477e-03f, -5.46373390e-02f, 8.74541029e-02f, 4.00342904e-02f, -5.73341325e-02f,
  -9.75431353e-02f, -5.57207987e-02f, 1.15672061e-02f, -6.35536388e-03f, -4.62531894e-02f, -1.46331196e-03f, 6.60801604e-02f, -2.70824018e-03f, -8.02138541e-03f, 5.28947785e-02f,
  -4.23544943e-02f, -3.88103053e-02f, 1.35786101e-01f, 9.33138281e-02f, -6.46019215e-03f, 1.60662949e-01f, 8.75673592e-02f, -2.79069208e-02f, 8.70525464e-02f, -9.14266682e-04f,
  2.36645881e-02f, -1.48806535e-03f, -1.52548682e-02f, 2.25189719e-02f, 5.24482131e-02f, 4.75802645e-02f, -7.58939832e-02f, 6.51361644e-02f, 2.46566571e-02f, 6.11832850e-02f,
  2.87187770e-02f, 1.63502991e-02f, -2.54456829e-02f, -1.66738741e-02f, 9.54703614e-02f, -3.38765141e-03f, -3.46461572e-02f, 1.59471016e-02f, 9.40297022e-02f, -2.80541945e-02f,
  5.41025549e-02f, 4.58521098e-02f, -1.72295198e-02f, 8.06077048e-02f, 4.11612876e-02f, -3.83046120e-02f, 6.85119554e-02f, -1.40556323e-04f, -2.33956929e-02f, -4.34401035e-02f,
  3.40519175e-02f, 1.66188441e-02f, -5.29876389e-02f, -7.77633637e-02f, -2.98769046e-02f, 3.68559696e-02f, 8.89547765e-02f, -3.75821488e-03f, 8.01137537e-02f, -4.56785448e-02f,
  6.00317270e-02f, -4.70377207e-02f, -8.19437206e-02f, -6.65258765e-02f, 5.88792982e-03f, -6.73988089e-02f, 4.59046252e-02f, 6.76023439e-02f, -5.99758998e-02f, -1.03501743e-02f,
  5.10065667e-02f, 4.44429964e-02f, -4.05396074e-02f, 6.62931576e-02f, -1.12804743e-02f, -2.62697488e-02f, -1.34201525e-02f, 3.64033207e-02f, 2.44405828e-02f, -1.44545268e-02f,
  -3.42931561e-02f, 4.95863706e-02f, -3.04606743e-02f, -9.52613447e-03f, 5.95549643e-02f, 3.76253924e-03f, -3.67398970e-02f, -2.81344336e-02f, 8.88661146e-02f, -6.42736703e-02f,
  5.05859442e-02f, 2.32458748e-02f, -2.39108074e-02f, 5.57438396e-02f, -4.11177613e-02f, -7.01677203e-02f, -6.15049861e-02f, -2.90779695e-02f, -2.31313165e-02f, 7.45767206e-02f,
  -2.37403680e-02f, -7.87162483e-02f, 6.44371286e-02f, 2.48792232e-03f, -1.77712447e-03f, 3.40211461e-03f, 9.51693952e-02f, -3.22373733e-02f, 1.89691540e-02f, -9.17204395e-02f,
  -3.78516689e-03f, 8.22098628e-02f, 5.92162162e-02f, -4.91054133e-02f, -1.76236238e-02f, 9.90726240e-03f, 2.98600905e-02f, -6.28009960e-02f, 7.17920735e-02f, 1.39979599e-02f,
  2.65920479e-02f, -1.66010968e-02f, 3.49194114e-03f, 5.60871586e-02f, -7.04381913e-02f, 3.41281109e-02f, 7.31467903e-02f, 4.04822007e-02f, -2.73884591e-02f, -5.16216597e-03f,
  3.79469693e-02f, 1.26927290e-02f, 5.74286655e-02f, 4.15923633e-02f, 5.53058498e-02f, -5.81119135e-02f, 5.24700768e-02f, -2.34143399e-02f, 2.14437339e-02f, 6.84951022e-02f,
  -8.57536569e-02f, 3.51033323e-02f, -3.46781462e-02f, -3.36705521e-02f, -5.72022162e-02f, -5.64864278e-02f, 2.66409498e-02f, -1.80646889e-02f, 5.16503006e-02f, 5.75839728e-02f,
  -1.06348291e-01f, -2.88115423e-02f, -6.47152290e-02f, -4.31202240e-02f, 5.08427853e-03f, 4.29140702e-02f, 4.26192582e-02f, 8.27480927e-02f, -6.93317205e-02f, 6.21219724e-02f,
  7.25821927e-02f, 9.65883136e-02f, 1.24619121e-03f, 4.62801382e-02f, -2.75906343e-02f, -9.60212052e-02f, 1.49195977e-02f, -1.29451770e-02f, 3.23079303e-02f, 2.42918096e-02f,
  -2.41600047e-03f, 1.51118748e-02f, 1.02258451e-01f, 1.70884263e-02f, 6.44038171e-02f, 4.91752885e-02f, -9.64838788e-02f, 6.92264223e-03f, 6.26150817e-02f, 8.12723041e-02f,
  9.88230407e-02f, 4.31242324e-02f, -4.84471768e-02f, -4.53370512e-02f, -5.50398342e-02f, 3.73697318e-02f, -3.41502242e-02f, 9.40879881e-02f, 1.44996801e-02f, 4.86288741e-02f,
  -4.87299077e-02f, 6.53479770e-02f, -6.51806220e-02f, 1.09593190e-01f, -4.85093258e-02f, 5.43312803e-02f, -7.31331781e-02f, -4.43228222e-02f, 3.32406955e-03f, -3.18371840e-02f,
  -1.29867390e-01f, -1.67679004e-02f, -3.11104916e-02f, -1.10249169e-01f, -9.83285829e-02f, -7.66856670e-02f, 4.21412662e-02f, 3.45612951e-02f, 7.16314390e-02f, -6.69932887e-02f,
  8.41460228e-02f, 2.56964993e-02f, -7.00169429e-02f, -9.68238190e-02f, -8.52982998e-02f, -1.21185007e-02f, -3.99062061e-04f, 4.77823652e-02f, 7.12951347e-02f, 2.55609956e-02f,
  3.62070687e-02f, -2.93020103e-02f, 3.68881458e-03f, -5.60059622e-02f, -2.82158479e-02f, 3.60680148e-02f, 4.79862615e-02f, 2.97361910e-02f, -6.74269721e-02f, 4.09219880e-03f,
  8.27004947e-03f, 4.86807749e-02f, -2.50801630e-02f, 6.51097764e-07f, 9.81107429e-02f, -1.25263762e-02f, -7.38231838e-02f, -3.33715566e-02f, 5.04568405e-02f, 1.85896624e-02f,
  -2.18374226e-02f, 8.09968039e-02f, -9.54604000e-02f, -8.36204365e-03f, 2.00937316e-02f, 3.37908939e-02f, 8.97607952e-02f, 7.40488917e-02f, 1.05534978e-01f, 6.74343435e-03f,
  -1.12386525e-03f, 3.74931321e-02f, 9.16007832e-02f, 2.97766551e-02f, -3.29821482e-02f, -4.32982668e-02f, 4.93253022e-03f, 6.55681342e-02f, -2.38630380e-02f, -3.57301757e-02f,
  -1.07483089e-01f, 2.67418493e-02f, 8.79102794e-04f, 1.84130579e-01f, 2.10447773e-01f, 2.31111795e-01f, 2.76755512e-01f, 1.50103047e-01f, 1.18492045e-01f, 9.62830731e-04f,
  4.97974493e-02f, -2.95939203e-02f, -4.29148041e-02f, 8.45885724e-02f, 6.57344609e-02f, 7.90268332e-02f, 9.24766883e-02f, -9.10900440e-03f, 7.11083561e-02f, 9.78816152e-02f,
  2.88077164e-02f, -1.51714375e-02f, -1.19785845e-01f, -5.97431734e-02f, 5.88923097e-02f, 9.99857262e-02f, -3.94030251e-02f, -2.39033811e-02f, 6.96556196e-02f, 5.55261821e-02f,
  -1.07233562e-01f, 4.35183197e-02f, -3.12072169e-02f, -1.23426467e-01f, -3.41777541e-02f, -1.68483153e-01f, 2.95661930e-02f, -3.99691127e-02f, 9.31611955e-02f, 8.79509151e-02f,
  9.50314030e-02f, 2.16758903e-02f, -4.85305069e-03f, -3.84101756e-02f, -9.32327881e-02f, -4.35332470e-02f, 2.82558091e-02f, -2.94431578e-02f, -7.88431466e-02f, -3.30970213e-02f,
  2.71092895e-02f, -5.70418760e-02f, -3.75683084e-02f, 9.68752243e-03f, 1.05372779e-01f, -8.91339555e-02f, 1.65327324e-03f, 7.35842660e-02f, -2.99939942e-02f, -1.21923853e-02f,
  -2.94090137e-02f, 5.04227495e-03f, -2.08694190e-02f, -9.09796581e-02f, -1.21698521e-01f, 2.99870335e-02f, -5.47682345e-02f, 4.73764651e-02f, 4.55452614e-02f, -4.79002446e-02f,
  -7.59757031e-03f, 3.22698131e-02f, -7.65547855e-03f, 5.78316525e-02f, 5.40552521e-03f, -9.92470514e-03f, -3.73096718e-03f, 7.66979754e-02f, 1.76948663e-02f, 6.87506422e-02f,
  -2.23092046e-02f, 6.52384162e-02f, -3.12464144e-02f, 3.64568308e-02f, -4.40811515e-02f, 6.45195181e-03f, -4.57151234e-02f, -3.59906740e-02f, -5.93614355e-02f, 1.70367397e-02f,
  6.59065098e-02f, 8.61962438e-02f, -1.21751890e-01f, -1.00134745e-01f, 8.16158485e-03f, -9.93893966e-02f, -6.58669993e-02f, 5.86356297e-02f, 5.95835671e-02f, 2.54197735e-02f,
  3.51626687e-02f, 1.20284401e-01f, -1.73916686e-02f, -6.19212650e-02f, -1.84734873e-02f, 3.87037322e-02f, -4.66725901e-02f, 8.03068876e-02f, 6.58613369e-02f, 1.78037751e-02f,
  6.86048940e-02f, 6.26472477e-03f, -2.48731598e-02f, 7.89078549e-02f, -3.49382646e-02f, -7.93577060e-02f, 2.53046025e-02f, -7.05643464e-03f, 9.24216136e-02f, -7.74647668e-02f,
  4.79175933e-02f, 4.61744033e-02f, 3.46125918e-03f, -8.39157775e-02f, 9.55077186e-02f, 2.87613794e-02f, 3.21291350e-02f, -2.85092052e-02f, -2.23776102e-02f, 7.32704327e-02f,
  2.80338731e-02f, 2.72200443e-02f, -2.08591092e-02f, -1.48253124e-02f, -3.35062556e-02f, -2.02687830e-02f, 1.00758327e-02f, 8.75603035e-02f, 5.76855103e-03f, 9.17468667e-02f,
  -6.50346577e-02f, 3.86486799e-02f, -8.99030343e-02f, -2.91271601e-02f, 2.12732460e-02f, 9.04747620e-02f, -1.28888292e-02f, -3.23254280e-02f, 3.50850374e-02f, -5.87745868e-02f,
  -7.43109360e-02f, 8.97911936e-02f, -3.00055966e-02f, 3.02305166e-02f, 8.97489935e-02f, 2.00585816e-02f, 9.94661637e-03f, 7.14256465e-02f, 8.02507252e-02f, -1.77472737e-02f,
  -2.59598736e-02f, 1.03017382e-01f, 6.71828538e-02f, -5.59200719e-03f, -2.68546562e-03f, 8.17147717e-02f, 7.03103319e-02f, -3.98205564e-04f, 7.98545703e-02f, 8.11579227e-02f,
  1.00217216e-01f, 8.08676630e-02f, 8.55683163e-02f, 3.44766192e-02f, -6.77218959e-02f, -8.77361894e-02f, 1.83194187e-02f, 8.28256980e-02f, -2.35368051e-02f, 1.18857929e-02f,
  7.95054734e-02f, -7.78709203e-02f, -8.57728049e-02f, 3.36875282e-02f, -4.31389809e-02f, -2.54635271e-02f, 5.07272072e-02f, -5.51355071e-03f, 7.28279948e-02f, 2.29002740e-02f,
  -1.90069042e-02f, -1.60025377e-02f, 2.49796249e-02f, 6.08142093e-02f, 5.72937392e-02f, 4.40605842e-02f, 2.78517120e-02f, 8.40401873e-02f, 4.81392555e-02f, 5.44299260e-02f,
  2.01884918e-02f, 5.20181879e-02f, 5.37729748e-02f, -4.10523228e-02f, 5.90001531e-02f, -7.24391220e-03f, 5.25274687e-02f, 6.35175481e-02f, 2.94763092e-02f, -3.08740903e-02f,
  7.57888034e-02f, 3.17278504e-02f, -7.74449632e-02f, -7.69888088e-02f, -2.16929447e-02f, 4.74325791e-02f, -4.25260477e-02f, -1.28367729e-02f, 4.15799543e-02f, 4.69834469e-02f,
  -4.93229739e-02f, 1.28837405e-02f, 7.06640631e-02f, 5.40055381e-03f, 8.05261880e-02f, -1.61338635e-02f, 7.51728863e-02f, -3.24075408e-02f, -5.08340541e-03f, 4.35437374e-02f,
  3.87454331e-02f, -6.52490780e-02f, -7.01094493e-02f, -4.57041077e-02f, 1.80626549e-02f, 1.88501868e-02f, 7.29307085e-02f, -2.17084102e-02f, -1.02094270e-03f, 3.50103602e-02f,
  2.49215707e-01f, -4.36551459e-02f, -1.39237210e-01f, 3.84879485e-02f, -7.32308254e-02f, -1.42887786e-01f, -7.13831250e-05f, -1.45566463e-02f, -1.40493140e-02f, -9.71603096e-02f,
  -9.82258841e-02f, 2.87282690e-02f, 7.76472762e-02f, -1.12630296e-02f, -3.99384014e-02f, -1.07759804e-01f, -1.01821475e-01f, 1.07056268e-01f, 1.19774967e-01f, 1.13352109e-02f,
  -4.25410867e-02f, -1.32441474e-02f, 1.15158997e-01f, 6.75221458e-02f, -1.10383891e-01f, 4.62032333e-02f, -3.61851677e-02f, -6.60111830e-02f, -1.18817039e-01f, -1.12964876e-01f,
  -5.93195409e-02f, -2.37850547e-02f, -1.84166990e-02f, 1.15811370e-01f, 9.75786522e-03f, 6.66173026e-02f, 9.25379321e-02f, -1.75700989e-02f, 4.06408235e-02f, 1.86717510e-02f,
  -4.18917276e-02f, -4.81868871e-02f, -7.65986741e-02f, -1.07740229e-02f, -1.50957480e-02f, -5.48290722e-02f, -8.61518681e-02f, -8.21495578e-02f, 8.77263919e-02f, -4.60269414e-02f,
  -7.04331249e-02f, -5.69035262e-02f, -3.28740701e-02f, -9.45331454e-02f, 5.51298931e-02f, 5.28060868e-02f, -8.23756158e-02f, -1.00344300e-01f, -8.74039531e-02f, 2.22306629e-03f,
  -3.10305580e-02f, -5.40070273e-02f, 7.90614337e-02f, -2.68645063e-02f, 5.33867534e-03f, 6.20185807e-02f, -4.63209450e-02f, -7.84424469e-02f, -2.19516698e-02f, 3.39575037e-02f,
  -8.68485644e-02f, -6.02128692e-02f, 9.06110555e-02f, 4.65483079e-03f, -1.15697412e-02f, -2.13757697e-02f, 6.78593293e-02f, -7.14161545e-02f, -9.54229385e-03f, 1.25144543e-02f,
  -3.37195322e-02f, 6.30018637e-02f, 8.87390983e-04f, 8.78306478e-02f, -4.00053374e-02f, -1.51275722e-02f, 3.98212746e-02f, -4.53947298e-02f, 1.68763883e-02f, 3.70167419e-02f,
  2.66246758e-02f, 6.23506121e-03f, 6.10216148e-02f, 3.59576941e-02f, 2.79895831e-02f, -2.05423031e-02f, 3.07146870e-02f, -5.21859527e-02f, 2.45461725e-02f, -3.92357744e-02f,
  8.63594860e-02f, 8.65184739e-02f, 2.96184793e-02f, -3.72141153e-02f, -2.21924037e-02f, 5.51623628e-02f, 4.81420979e-02f, 7.78576359e-02f, 9.80277359e-02f, -8.23596492e-02f,
  -7.26106316e-02f, -1.43788569e-02f, 6.14591949e-02f, 3.61954197e-02f, 3.98167931e-02f, 4.39164378e-02f, -6.19849004e-02f, 6.23707585e-02f, 9.90656018e-02f, 8.38817284e-02f,
  1.92821845e-01f, -8.57135355e-02f, -9.77956355e-02f, 9.69390105e-03f, 1.28656682e-02f, -4.02941033e-02f, -3.78173613e-03f, 4.86429185e-02f, 1.28602594e-01f, 9.14820358e-02f,
  1.57130137e-01f, 1.02642708e-01f, 1.71541512e-01f, 8.26205462e-02f, 1.08637556e-01f, -1.24476850e-02f, -5.61394095e-02f, 4.53042723e-02f, 1.34153113e-01f, 8.12338814e-02f,
  -5.45817651e-02f, -1.25747724e-02f, 3.15672904e-02f, 6.85005933e-02f, -9.82906595e-02f, -3.86257805e-02f, 5.18448912e-02f, -2.81949881e-02f, -3.37998793e-02f, -5.18634403e-03f,
  -7.24275559e-02f, 2.36204602e-02f, 3.44089163e-03f, 1.22245528e-01f, -1.31771088e-01f, -1.08178623e-01f, -6.14448509e-04f, -3.14887948e-02f, 6.36248589e-02f, 1.95934903e-02f,
  7.69009516e-02f, 4.08310592e-02f, -9.97359380e-02f, 2.05008890e-02f, -3.36912163e-02f, -4.75149341e-02f, -6.88686669e-02f, 6.81414902e-02f, 8.03233776e-03f, 7.68769458e-02f,
  -7.47335181e-02f, 7.54903406e-02f, 3.18594575e-02f, 4.58055921e-02f, 7.10040703e-02f, 3.31049599e-02f, 8.69898424e-02f, -5.05751036e-02f, 9.11762714e-02f, -1.21171679e-02f,
  2.93347891e-02f, 3.24239917e-02f, -2.72399653e-02f, 8.55765713e-04f, 2.30346192e-02f, 7.50633404e-02f, 3.55161689e-02f, 1.81557536e-02f, -4.56079952e-02f, 2.16142711e-04f,
  -1.09903002e-02f, -4.58498634e-02f, 3.88338752e-02f, 1.09716304e-01f, -1.72783788e-02f, -1.69619024e-02f, 1.42289046e-03f, 6.69037402e-02f, 4.99559976e-02f, 2.20869016e-02f,
  -4.63314727e-02f, -5.38824871e-02f, -5.27648069e-02f, 5.16912490e-02f, -6.35954440e-02f, 8.06545541e-02f, -4.61144000e-02f, 7.83884004e-02f, -5.86479045e-02f, -7.12372586e-02f,
  -3.52816731e-02f, 7.83821344e-02f, -3.47261652e-02f, -1.01398662e-01f, 4.20637839e-02f, -4.91855666e-02f, 7.88046345e-02f, -5.14459088e-02f, 1.03479903e-02f, -3.34235542e-02f,
  3.98563035e-02f, 4.27500494e-02f, 3.29978727e-02f, -2.59270929e-02f, -5.06670214e-02f, 5.69834411e-02f, -6.98270425e-02f, 5.18065132e-02f, 8.38441551e-02f, 7.63992295e-02f,
  -5.08930981e-02f, 1.10833393e-02f, 7.90455118e-02f, 7.52529204e-02f, 1.24721825e-02f, 3.58006395e-02f, 2.20358185e-02f, -6.64828112e-03f, 1.11132920e-01f, 1.19175464e-01f,
  -4.47483547e-02f, -1.43901393e-01f, -7.36380294e-02f, -1.56438187e-01f, -1.20744957e-02f, -8.12919214e-02f, -1.23220354e-01f, -6.46934584e-02f, -1.18330032e-01f, -1.19089134e-01f,
  -1.74817443e-01f, -5.49828447e-02f, -5.00873569e-03f, -3.71118495e-03f, -4.85698394e-02f, -2.42884476e-02f, -1.10742696e-01f, -1.31735327e-02f, -6.94318935e-02f, -6.27103448e-02f,
  -1.76568143e-02f, 5.40153356e-03f, -4.75026853e-03f, 5.50008528e-02f, -1.03067420e-01f, 4.67134938e-02f, -3.55971754e-02f, -9.10639539e-02f, -2.82238657e-03f, -5.22802621e-02f,
  -1.39151454e-01f, -1.03825694e-02f, 4.13371548e-02f, 4.11233455e-02f, -9.81746241e-02f, 7.00423867e-02f, -1.89823890e-03f, 5.02653159e-02f, -8.34340602e-02f, -2.95490846e-02f,
  -1.02405265e-01f, -1.66775994e-02f, 5.49646728e-02f, -6.04437925e-02f, -7.16905817e-02f, 4.99649830e-02f, 1.03303328e-01f, 8.34809244e-03f, 4.62274887e-02f, 4.64430712e-02f,
  -3.55404355e-02f, -1.20293256e-02f, 1.62444729e-02f, 8.96237884e-03f, 4.61992659e-02f, -2.46358085e-02f, -5.39773367e-02f, 8.24059919e-02f, 1.22311912e-01f, -1.13585405e-03f,
  3.57314087e-02f, -2.89717177e-03f, 6.31437078e-02f, 4.02610712e-02f, 5.84306456e-02f, 2.45960392e-02f, 4.75490727e-02f, -4.21526805e-02f, -2.03773770e-02f, -4.37834271e-04f,
  5.24090827e-02f, -7.24507496e-02f, -5.48637919e-02f, -5.90703897e-02f, -4.79585454e-02f, 1.84050743e-02f, -1.80506855e-02f, 8.17824304e-02f, -6.86612949e-02f, 1.45820295e-02f,
  7.16325417e-02f, 6.44134954e-02f, 1.04886238e-02f, -2.65147109e-02f, -6.59045279e-02f, -3.48197632e-02f, 9.36824363e-03f, 5.47498949e-02f, 9.24803596e-03f, 8.16360563e-02f,
  -3.79170515e-02f, 1.47338420e-01f, -9.60276052e-02f, -3.84319536e-02f, -1.89879641e-03f, 1.13649173e-02f, -3.80978361e-02f, -3.15737203e-02f, 2.59828884e-02f, -2.09329762e-02f,
  6.89765662e-02f, -2.28513908e-02f, -5.70807569e-02f, 6.39988184e-02f, 4.92581166e-02f, -2.10620719e-03f, 2.18370673e-03f, 3.90680209e-02f, 9.96376276e-02f, 3.06362472e-02f,
  -5.96211441e-02f, 1.37867425e-02f, 5.73680997e-02f, -1.61761697e-02f, 5.70186926e-03f, -6.01224154e-02f, -2.99195051e-02f, 7.83061981e-02f, 1.13568068e-01f, -5.81487864e-02f,
  5.80582023e-02f, 5.05956374e-02f, -5.84690608e-02f, 1.08542174e-01f, 5.96804619e-02f, 2.08879192e-03f, -3.55271846e-02f, -7.54681136e-03f, 6.56977072e-02f, -2.99317110e-03f,
  5.47116101e-02f, 8.45094100e-02f, 1.19862640e-02f, 5.20126075e-02f, -8.12881514e-02f, 1.43759213e-02f, -9.97233689e-02f, -2.46049557e-02f, 1.37846485e-01f, 4.61845361e-02f,
  -5.92337474e-02f, 6.70031160e-02f, -4.47248816e-02f, -6.95617720e-02f, -5.91694750e-02f, 6.30749017e-02f, -7.50190914e-02f, -1.93473250e-02f, -2.17769090e-02f, -1.49757013e-01f,
  -4.04538885e-02f, 2.55121738e-02f, -2.71323416e-02f, -9.26708430e-02f, 7.74229243e-02f, -3.44397686e-03f, 1.13718687e-02f, -7.15397373e-02f, -4.38260883e-02f, -2.66352277e-02f,
  -6.60948083e-02f, -2.45307200e-02f, -7.79660568e-02f, 3.07794418e-02f, 3.47211473e-02f, 1.22006536e-02f, 5.72220013e-02f, -5.58849759e-02f, 4.01118398e-02f, 6.00258866e-03f,
  -6.71331659e-02f, -5.00125438e-02f, -6.16436154e-02f, 5.37703373e-02f, -3.20481285e-02f, 5.55406278e-03f, -4.54769507e-02f, 4.49520499e-02f, -8.23155269e-02f, -1.42747924e-01f,
  -3.26154046e-02f, 5.14131319e-03f, -6.55567870e-02f, 5.52752614e-02f, -8.24573934e-02f, -1.33413766e-02f, -3.68275754e-02f, 1.24781681e-02f, 3.46345380e-02f, 6.51840791e-02f,
  -3.48866880e-02f, 1.29800439e-01f, 7.86338281e-03f, -1.74135342e-02f, 7.95619711e-02f, 1.34135538e-03f, -1.08032957e-01f, -1.26602473e-02f, -6.98583797e-02f, -5.21333851e-02f,
  1.15397476e-01f, 3.93108688e-02f, -9.33589879e-03f, -6.03882857e-02f, -5.63962050e-02f, -3.33250985e-02f, 4.90515195e-02f, -3.47885340e-02f, 1.69378407e-02f, 9.00729969e-02f,
  9.90841463e-02f, -8.76321793e-02f, -4.94366512e-02f, 2.36992333e-02f, -2.01377477e-02f, -6.00370998e-03f, 6.98251501e-02f, -6.92028478e-02f, 9.77132749e-03f, -1.43271347e-03f,
  8.71442072e-03f, -5.40199354e-02f, 1.24556869e-02f, 3.06068943e-03f, 6.00081012e-02f, -7.24358484e-02f, 5.73366322e-02f, -2.21216809e-02f, 3.92147042e-02f, 3.83447157e-03f,
  -4.16793227e-02f, -1.02553949e-01f, 2.25697309e-04f, -8.13836232e-02f, 3.56312282e-02f, -4.18630317e-02f, 1.00361340e-01f, -4.17380072e-02f, 8.86905342e-02f, -5.78187406e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.00930132e-01f, 2.31049191e-02f, 4.14488874e-02f, 1.32699877e-01f, -5.84019721e-02f, -2.64551509e-02f, -3.08297481e-02f, 6.27274662e-02f, -2.62191184e-02f, -7.10200295e-02f,
  5.49398847e-02f, -2.45350245e-02f, 1.15021514e-02f, 6.25223517e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.71229262e-02f, -1.24078669e-01f, 4.77902330e-02f, 1.84125647e-01f, -3.16905901e-02f, -9.39594880e-02f, 1.36095762e-01f, -1.65762931e-01f, -6.26752824e-02f, -3.91886476e-03f,
  -6.76914006e-02f, -5.14878659e-03f, -6.35085031e-02f, 7.50028715e-02f, -1.07924685e-01f, -3.50761004e-02f, 5.38359862e-03f, 1.41910970e-01f, 5.48320897e-02f, 1.93730146e-02f,
  1.70257241e-01f, -6.06587157e-02f, -7.10775033e-02f, 1.32356897e-01f, 2.23428801e-01f, 1.47565693e-01f, 4.64854427e-02f, 1.67080000e-01f, 1.76185146e-01f, -1.43023729e-01f,
  5.89435287e-02f, -1.88658889e-02f, 8.32640976e-02f, 9.45806503e-02f, 1.10512510e-01f, -8.32147375e-02f, -7.78417662e-02f, -1.24300323e-01f, 7.56709510e-03f, -1.30954176e-01f,
  -1.36769786e-01f, -2.17074245e-01f, 1.37606531e-01f, 2.08002463e-01f, 1.44028261e-01f, 8.35736021e-02f, 1.28642342e-03f, -5.43696322e-02f, -1.60517633e-01f, -1.04426309e-01f,
  -8.10630172e-02f, -1.74543768e-01f, -2.55707745e-02f, -1.86299577e-01f, -3.41597423e-02f, 1.02970943e-01f, -7.83309713e-02f, 1.05596960e-01f, -1.43015817e-01f, -6.94418652e-03f,
  -1.52856156e-01f, 7.04179034e-02f, -1.06005138e-02f, -6.67959685e-03f, -1.19990371e-01f, -1.25820190e-01f, 1.02219447e-01f, -1.21605918e-02f, -1.10317849e-01f, -1.19405523e-01f,
  7.23994747e-02f, -1.33327603e-01f, 4.33245935e-02f, -1.32527053e-01f, -6.66039959e-02f, -4.03001942e-02f, 1.45493448e-01f, 1.86428316e-02f, -6.97942823e-02f, -1.08197898e-01f,
  -1.35992572e-01f, 2.47786403e-01f, 1.07440367e-01f, -7.77826533e-02f, 1.07288085e-01f, -3.05725411e-02f, 4.52975072e-02f, 8.94226413e-03f, -5.03452197e-02f, 9.57237482e-02f,
  -6.02657609e-02f, 1.36366174e-01f, -6.80694282e-02f, -1.32093251e-01f, -1.07942916e-01f, -1.64837465e-01f, 1.02129422e-01f, 2.12104861e-02f, 1.14291430e-01f, 1.36361569e-01f,
  1.09173376e-02f, 5.98065779e-02f, 4.31254180e-03f, -1.63056761e-01f, -1.73312739e-01f, -1.47868112e-01f, -6.64421543e-02f, 2.28372708e-01f, 1.28862366e-01f, 3.00426446e-02f,
  -1.89335214e-03f, -4.39409725e-02f, 7.69718438e-02f, -2.63171587e-02f, 5.44333905e-02f, -1.39025822e-01f, -7.03727528e-02f, -1.47862092e-01f, -4.55353782e-02f, 1.16940044e-01f,
  1.62359625e-02f, 1.09552005e-02f, -8.50019231e-03f, -1.08439883e-03f, 1.13526620e-01f, -9.25261080e-02f, 4.81652729e-02f, -9.60177779e-02f, -5.61018009e-03f, -6.20606132e-02f,
  1.19087622e-01f, -7.67807215e-02f, -4.91303504e-02f, -1.03328861e-01f, 2.41427589e-02f, -1.13391817e-01f, 1.98925063e-01f, -2.02160776e-01f, 2.32526958e-02f, -5.04286811e-02f,
  -1.39702275e-01f, -1.16239473e-01f, 1.13393493e-01f, 4.18202132e-02f, -9.27136093e-02f, 5.41427396e-02f, -2.71153729e-02f, -8.69877040e-02f, 2.00182814e-02f, -3.22148651e-02f,
  4.10484560e-02f, -9.17803794e-02f, -4.82040681e-02f, -6.47773892e-02f, -1.17852371e-02f, -1.09509669e-01f, 4.05380949e-02f, 1.08353272e-01f, -3.93715594e-03f, 2.10710227e-01f,
  1.19089544e-01f, -7.81288594e-02f, 5.29349037e-02f, -6.38649538e-02f, 1.04019679e-01f, 2.17221633e-01f, -1.35681048e-01f, -7.91016221e-02f, -1.27479061e-01f, -1.46385655e-01f,
  -8.72953422e-03f, 2.02125087e-01f, 4.24005203e-02f, 9.25864130e-02f, -9.58040729e-02f, 9.34139416e-02f, 3.72010432e-02f, 2.05857664e-01f, -2.26964280e-02f, 5.63484356e-02f,
  7.44202584e-02f, -1.39154673e-01f, 8.63904804e-02f, 9.82241109e-02f, 8.68985429e-02f, -1.14653662e-01f, 9.24165845e-02f, -5.21580279e-02f, 1.36054933e-01f, 6.93523139e-02f,
  5.86888343e-02f, -4.44513969e-02f, -1.79052949e-02f, 6.41281810e-03f, 5.26570007e-02f, -7.88669288e-02f, -1.41421556e-01f, 1.21568553e-02f, 9.79402289e-02f, -1.67717051e-03f,
  2.62438416e-01f, -5.94851375e-02f, 8.06442369e-03f, 7.57228658e-02f, -2.31413946e-01f, -1.66371346e-01f, 1.53972034e-03f, 4.29210998e-03f, 7.34813511e-02f, -1.38989687e-01f,
  -1.36249855e-01f, 4.23975624e-02f, -5.45557514e-02f, -1.41012575e-02f, -1.24543840e-02f, 8.23079273e-02f, -1.93795294e-01f, -2.19691604e-01f, 4.34363596e-02f, -6.14377037e-02f,
  -9.81117189e-02f, 2.53994107e-01f, -6.47100946e-03f, 2.51887321e-01f, 1.28215402e-01f, 3.91100459e-02f, -1.04401678e-01f, -1.15045659e-01f, 1.00926712e-01f, 1.96494475e-01f,
  2.66190656e-02f, -6.34871498e-02f, -1.66084573e-01f, -4.85386327e-03f, 1.79024916e-02f, 7.06982519e-03f, -9.15564001e-02f, 1.61395241e-02f, -1.57840773e-01f, 7.04532564e-02f,
  1.84950605e-01f, 1.20393030e-01f, -1.64109439e-01f, 1.13594800e-01f, 4.57798988e-02f, -8.03522170e-02f, 3.05297859e-02f, -6.55324832e-02f, -1.09129883e-01f, -1.35272950e-01f,
  -6.66456521e-02f, -2.19948050e-02f, 1.38585363e-02f, 1.57522887e-01f, 1.72946900e-01f, 1.60062894e-01f, -9.38197225e-02f, -1.10916704e-01f, 1.26588523e-01f, -1.07562564e-01f,
  -1.02758087e-01f, -5.88871017e-02f, -6.20979220e-02f, 9.36336517e-02f, 7.54543319e-02f, 1.40695199e-01f, 9.42500010e-02f, 4.79502976e-02f, -7.59112090e-02f, -1.08703390e-01f,
  2.24384293e-03f, -5.23809083e-02f, 6.81546032e-02f, 2.67302394e-02f, -1.12359941e-01f, 4.26134728e-02f, -1.95687801e-01f, 3.89866158e-02f, -2.05799099e-02f, 1.02901727e-01f,
  -1.65854275e-01f, -4.67260778e-02f, 6.47309050e-02f, -8.41780156e-02f, 1.06217541e-01f, 2.81886384e-02f, 8.44404846e-02f, 2.36104038e-02f, -5.55416755e-02f, -7.09877675e-03f,
  -1.45352378e-01f, -1.11607589e-01f, -9.64957569e-03f, 1.11514188e-01f, 1.51691988e-01f, 7.95900822e-02f, 3.68381739e-02f, -8.60072151e-02f, 5.89029416e-02f, -6.56094477e-02f,
  -1.63112611e-01f, 1.48147091e-01f, -1.02427490e-01f, -9.87179205e-02f, 1.31964684e-01f, 1.02883875e-01f, -1.20902568e-01f, 1.01690307e-01f, 7.59362616e-03f, 6.30131550e-03f,
  -2.03849766e-02f, 2.69339569e-02f, -5.53443506e-02f, 7.00875092e-03f, 8.81297663e-02f, -1.22482173e-01f, 1.41604751e-01f, 1.05759546e-01f, 6.73397556e-02f, 1.47794381e-01f,
  5.06840348e-02f, 1.15094081e-01f, 2.78434120e-02f, 1.14392206e-01f, -4.56791595e-02f, -1.65268078e-01f, -3.48366098e-03f, 8.29801783e-02f, 1.09543189e-01f, 1.44014820e-01f,
  1.09248005e-01f, -9.85522121e-02f, 3.60481963e-02f, -7.80679062e-02f, -6.51626363e-02f, 8.22288636e-03f, -5.06427735e-02f, -2.73570985e-01f, 3.86085324e-02f, 2.68550101e-03f,
  -1.93141505e-01f, 8.89349654e-02f, 5.90862930e-02f, -5.41139282e-02f, 8.67120102e-02f, 1.30469412e-01f, 6.48154393e-02f, -1.54128715e-01f, -1.92648098e-01f, 6.42074868e-02f,
  2.63038427e-02f, 1.82519600e-01f, 1.62309140e-01f, 1.27765322e-02f, -1.22587584e-01f, -7.22000897e-02f, 7.25513473e-02f, -1.19216725e-01f, 1.50952980e-01f, 1.76510841e-01f,
  -2.05114465e-02f, -1.43622551e-02f, 1.26646295e-01f, -5.04358150e-02f, -1.39308155e-01f, 7.50403628e-02f, -1.64459839e-01f, -1.47010699e-01f, -5.47702238e-03f, -3.60124595e-02f,
  -6.29901141e-02f, -1.84859127e-01f, -4.41806503e-02f, 1.04372144e-01f, -1.15479119e-01f, -1.45875514e-01f, -4.00369465e-02f, -1.11230217e-01f, -8.24650750e-02f, 5.28478846e-02f,
  -1.89691961e-01f, -1.00379527e-01f, 5.15668839e-02f, 2.22722311e-02f, 6.80383220e-02f, -1.04844026e-01f, 1.10075213e-01f, 1.96456581e-01f, 9.92653593e-02f, 1.27724200e-01f,
  -7.23026767e-02f, 3.27986740e-02f, 1.09180734e-01f, 7.95716718e-02f, -1.02189276e-02f, -5.22472747e-02f, -8.74269754e-02f, -6.21420331e-02f, -7.18266144e-02f, -9.68349129e-02f,
  -1.02313850e-02f, -1.15924649e-01f, 3.09422743e-02f, 5.08593842e-02f, -1.55650526e-01f, 2.73725595e-02f, 9.63257849e-02f, 6.55015633e-02f, -4.02511433e-02f, -6.56716004e-02f,
  -4.38145213e-02f, 2.17045873e-01f, 2.16608375e-01f, -1.68156344e-02f, 9.21555702e-03f, -5.75537514e-03f, -1.75524671e-02f, 1.23243354e-01f, 2.07085796e-02f, 1.16233297e-01f,
  -1.88447580e-01f, 3.21795903e-02f, 1.17780328e-01f, 2.75175460e-02f, -1.93338409e-01f, -7.92268738e-02f, 1.93824843e-01f, 1.11578509e-01f, 9.34749097e-02f, -4.10826989e-02f,
  -2.17688411e-01f, -6.00114912e-02f, 1.29025340e-01f, 1.75743252e-01f, 2.29065213e-02f, 5.71482517e-02f, -2.21115097e-01f, -5.15855215e-02f, 3.97133417e-02f, -1.40003055e-01f,
  -7.81182274e-02f, -9.07209814e-02f, -1.89266562e-01f, 1.16713971e-01f, -2.79029943e-02f, 9.10681039e-02f, -1.03474725e-02f, 3.10562886e-02f, 3.70546691e-02f, -2.90716831e-02f,
  1.08980186e-01f, 1.21766083e-01f, 6.60595447e-02f, -1.11093335e-02f, -2.29330244e-03f, 4.35087346e-02f, -3.21497284e-02f, 1.89080536e-01f, 1.08334832e-01f, 1.08094789e-01f,
  -6.53555021e-02f, -1.27873734e-01f, 1.04354322e-01f, 7.72550851e-02f, -5.06470390e-02f, -1.58643156e-01f, -4.38821968e-03f, -2.53232028e-02f, -9.93417054e-02f, -1.21207707e-01f,
  -7.13001937e-02f, 7.41375610e-02f, 1.54243708e-02f, -1.75282493e-01f, -6.47881478e-02f, -5.18163741e-02f, -2.63053365e-02f, -1.53248729e-02f, 1.93377212e-01f, 2.17286542e-01f,
  -1.80922598e-02f, 3.44164558e-02f, -2.01332137e-01f, -1.16703428e-01f, 1.66527480e-01f, 1.36586726e-01f, 1.31460920e-01f, 2.80159116e-02f, 1.44881591e-01f, -1.27299562e-01f,
  2.87771933e-02f, -1.75383210e-01f, -2.04451129e-01f, 6.63902238e-02f, -1.56483054e-01f, -1.08545713e-01f, -1.43837212e-02f, 7.51714036e-02f, 8.28175154e-03f, 3.25192325e-02f,
  -9.82246175e-02f, 8.66094902e-02f, -7.45585114e-02f, -3.70375626e-02f, -4.48985286e-02f, 2.63390560e-02f, 1.00042470e-01f, -5.69338724e-02f, 6.29757643e-02f, -3.00039654e-03f,
  -2.23411955e-02f, 1.18324801e-01f, 9.64424238e-02f, -6.14726916e-02f, -7.45390356e-02f, -4.84620742e-02f, -5.30279502e-02f, -2.07650643e-02f, 4.31981981e-02f, -1.11959502e-01f,
  -1.50935119e-02f, 1.66409705e-02f, 4.42492589e-02f, -1.12177998e-01f, -8.90442505e-02f, 9.09750722e-03f, 1.48077030e-02f, -8.72393772e-02f, 8.82184952e-02f, 1.02297187e-01f,
  -4.29028906e-02f, -4.66365144e-02f, -2.33408790e-02f, 2.63859611e-02f, 4.02344614e-02f, 3.16113383e-02f, -1.11418687e-01f, 1.79356739e-01f, 9.39733014e-02f, 6.49915859e-02f,
  -9.76118445e-02f, -4.92702276e-02f, 3.38798156e-03f, -8.96581039e-02f, -1.45425558e-01f, 7.80731067e-02f, 4.55868617e-02f, -4.61778454e-02f, -1.16537046e-02f, -7.80030265e-02f,
  3.96762416e-02f, 6.94031566e-02f, -6.92067146e-02f, -8.18856210e-02f, 5.96664846e-02f, -1.06293760e-01f, -7.50101805e-02f, -2.13918477e-01f, 1.19274057e-01f, 1.06101744e-01f,
  -8.37563798e-02f, -1.12702072e-01f, 9.19042081e-02f, 1.43004045e-01f, 8.28663856e-02f, -3.90062034e-02f, -5.32252602e-02f, -8.07271898e-02f, 1.18157484e-01f, 4.02868800e-02f,
  9.68965292e-02f, -5.16713597e-02f, -5.19019365e-02f, 1.53654158e-01f, -1.44592047e-01f, -1.39688253e-01f, 5.33171408e-02f, 8.90601277e-02f, 6.37425706e-02f, 2.92546418e-03f,
  7.73342624e-02f, 7.40769729e-02f, 1.14729226e-01f, 3.85617539e-02f, 3.92954284e-03f, 7.03123808e-02f, 8.39745700e-02f, 3.94479558e-02f, -2.59809941e-02f, 1.32523058e-03f,
  -8.55700951e-03f, 1.50463089e-01f, 4.05338518e-02f, 4.03015763e-02f, 1.31128192e-01f, 1.19630784e-01f, -8.95452723e-02f, -3.75737511e-02f, -5.96207492e-02f, 8.16635564e-02f,
  -1.27523199e-01f, 1.12032443e-01f, 4.90640067e-02f, 2.59226393e-02f, 2.39117946e-02f, -1.90599382e-01f, -1.32100508e-01f, -6.90285042e-02f, -1.92475706e-01f, 4.56853174e-02f,
  -2.78889202e-02f, -6.97249500e-03f, 6.28932714e-02f, -1.22923702e-01f, 6.89890459e-02f, -1.16292782e-01f, -1.07242512e-02f, 3.08898743e-02f, -1.70337036e-01f, -1.67642087e-01f,
  1.04873292e-01f, -6.19171411e-02f, 1.54663071e-01f, 1.54389560e-01f, -1.27681985e-01f, -6.83361292e-02f, -8.15626606e-02f, -5.54053001e-02f, 4.32608984e-02f, 1.09445214e-01f,
  6.35819808e-02f, 1.78930163e-01f, -8.60301107e-02f, 1.17458642e-01f, -8.39028507e-02f, -8.75347015e-03f, -3.79565433e-02f, -1.53766990e-01f, -2.58539394e-02f, -3.70726064e-02f,
  -3.31321061e-02f, 2.75798067e-02f, -1.22606464e-01f, -3.50075923e-02f, 6.86367899e-02f, 7.23741502e-02f, -4.69592176e-02f, 6.99352399e-02f, -1.05361685e-01f, 1.80308327e-01f,
  -1.54843614e-01f, -1.66283816e-01f, 4.10211720e-02f, 1.20940059e-01f, -1.03537880e-01f, 6.64642379e-02f, 3.42886858e-02f, -4.66123223e-02f, -1.06840976e-01f, 1.52375966e-01f,
  1.05463099e-02f, -6.37289658e-02f, -4.82097780e-03f, -7.55793601e-02f, -1.08617902e-01f, 1.27610520e-01f, -8.31180289e-02f, -1.06880702e-01f, 1.82127267e-01f, -1.72699600e-01f,
  -1.39124930e-01f, -1.80115886e-02f, -7.05787316e-02f, -1.01477616e-01f, 4.34958711e-02f, 2.82139480e-02f, -6.92231432e-02f, 9.53805000e-02f, 1.33033097e-01f, -8.17173719e-02f,
  3.55989821e-02f, 4.86221202e-02f, -1.06315449e-01f, -1.42200008e-01f, -9.90413353e-02f, -5.42026386e-02f, 1.82259291e-01f, 7.95755833e-02f, 2.05679685e-02f, -2.20548622e-02f,
  6.23857751e-02f, 3.07308193e-02f, 1.79619938e-01f, 1.29474670e-01f, 2.34658159e-02f, 1.45743906e-01f, -7.70529956e-02f, -5.88343330e-02f, 3.85401025e-02f, -7.93306902e-02f,
  1.02160759e-01f, -1.29183158e-01f, -2.41585784e-02f, -9.83942896e-02f, 3.13205980e-02f, -8.62194821e-02f, 9.73283201e-02f, 1.01594992e-01f, -2.65299063e-02f, -1.92235827e-01f,
  -1.23443343e-01f, 7.20778182e-02f, 2.53220480e-02f, 2.31179923e-01f, -1.34739593e-01f, -8.56589824e-02f, -1.61273792e-01f, -1.07727557e-01f, -2.80122329e-02f, -1.06954575e-01f,
  3.67279463e-02f, -1.92928568e-01f, 3.15613896e-02f, 7.45896250e-02f, -1.91400498e-01f, -7.55821764e-02f, 8.94142389e-02f, -8.56457427e-02f, -1.14219368e-01f, -2.19982490e-01f,
  -7.40573332e-02f, -1.37301415e-01f, -3.80049497e-02f, 9.46745127e-02f, 1.48281738e-01f, 2.56116539e-01f, 4.79248874e-02f, 1.31677672e-01f, -1.08139701e-01f, -5.55872805e-02f,
  -2.05137488e-02f, -4.00203057e-02f, 1.95512146e-01f, -3.95874977e-02f, 2.44419798e-02f, -1.35366425e-01f, 2.63122022e-01f, 8.04412812e-02f, -1.35020465e-01f, 1.14966936e-01f,
  9.32625085e-02f, 4.14764807e-02f, 2.16537490e-02f, 1.21593431e-01f, -8.68389010e-02f, 6.17468506e-02f, -2.89724935e-02f, 1.21189885e-01f, 5.02458811e-02f, -2.08513848e-02f,
  8.60673487e-02f, -1.15134671e-01f, 3.84865291e-02f, -2.01869868e-02f, -7.44147003e-02f, -7.34107122e-02f, 1.63068846e-02f, 5.24668545e-02f, 9.26440656e-02f, -8.21491331e-02f,
  2.19495982e-01f, 2.83304304e-01f, -5.78175038e-02f, 6.21935986e-02f, 1.03552327e-01f, -1.51532572e-02f, -1.19921444e-02f, 3.42586935e-02f, 1.39569253e-01f, 2.35647544e-01f,
  -1.62429273e-01f, -3.85905541e-02f, -5.68104498e-02f, -6.48758858e-02f, 5.05533069e-02f, -4.88211326e-02f, 1.01391368e-01f, 1.11420229e-02f, -8.81871879e-02f, 1.20891489e-01f,
  1.86468050e-01f, -2.64550131e-02f, 1.30058676e-01f, -3.04312706e-01f, -8.62888992e-02f, -1.02069646e-01f, -1.38499960e-01f, 3.56851369e-02f, 1.16773352e-01f, 2.99502071e-02f,
  -8.72073993e-02f, 2.43056774e-01f, -2.39232540e-01f, -1.03115015e-01f, 3.88794616e-02f, 1.56212449e-01f, -7.01716840e-02f, -4.58653755e-02f, -1.07278414e-01f, 6.30392209e-02f,
  2.17719957e-01f, -6.74347728e-02f, -5.16216867e-02f, 1.66769370e-01f, 4.59002480e-02f, 6.59744292e-02f, 9.67802182e-02f, 7.45628253e-02f, -4.34294529e-02f, -1.14299573e-01f,
  -1.17050245e-01f, 6.19818941e-02f, -1.20111154e-02f, 6.77358806e-02f, -2.96167340e-02f, 3.05735652e-04f, -2.04447672e-01f, 1.21603571e-01f, -9.60088521e-02f, 5.66846877e-02f,
  9.17452723e-02f, 2.41525304e-02f, 8.43292326e-02f, -1.29462406e-02f, -1.10435344e-01f, -5.13202650e-03f, 5.12946658e-02f, 6.78049102e-02f, -1.24723203e-01f, 3.22899073e-02f,
  -1.40518934e-01f, 4.83932383e-02f, 3.42895538e-02f, 2.34795604e-02f, -1.16840981e-01f, 1.27549380e-01f, 5.92000149e-02f, -9.20931175e-02f, 4.65090293e-03f, -8.77890289e-02f,
  5.49631603e-02f, -9.88247469e-02f, -1.26286775e-01f, 4.73092310e-02f, 1.93335414e-02f, 8.45396295e-02f, -9.38875899e-02f, 4.18978110e-02f, 8.22599009e-02f, -1.21204086e-01f,
  -7.22224712e-02f, -2.29041912e-02f, -5.00568189e-02f, 7.03314915e-02f, -2.12010499e-02f, -1.30445613e-02f, -1.05093628e-01f, 6.74787462e-02f, 1.40505388e-01f, -5.38551509e-02f,
  6.20535277e-02f, 6.56182468e-02f, 8.87470022e-02f, 1.33241281e-01f, -6.91923052e-02f, -1.19942166e-01f, -1.77416176e-01f, 2.12744605e-02f, 6.61928505e-02f, 1.50456615e-02f,
  -6.22405037e-02f, -4.46617454e-02f, 3.08924671e-02f, 9.01502147e-02f, 3.66216116e-02f, 5.18327467e-02f, -9.87342326e-04f, 1.34091318e-01f, 2.77158394e-02f, 7.41151422e-02f,
  5.99518679e-02f, -1.47233531e-01f, -1.28070330e-02f, 3.92969837e-03f, -3.75251137e-02f, -8.86558816e-02f, -3.16156968e-02f, 3.86137851e-02f, -1.21455677e-02f, 1.83240399e-01f,
  5.95540702e-02f, 2.40455549e-02f, -7.93834869e-03f, -1.87018812e-02f, 4.80049513e-02f, -3.85498963e-02f, 1.30919844e-01f, -4.96093929e-03f, -1.37992218e-01f, -3.10524870e-02f,
  -6.30915388e-02f, 4.44392383e-04f, -1.44135535e-01f, -9.58695188e-02f, 1.18022084e-01f, -7.84979910e-02f, 3.32160927e-02f, 6.91223517e-02f, -9.07940120e-02f, 8.72142799e-03f,
  8.25361833e-02f, -1.30819023e-01f, 6.93791509e-02f, 9.24731642e-02f, 1.69626176e-02f, -1.20368013e-02f, 9.94194672e-02f, -5.72852790e-02f, -3.70126031e-02f, 1.83316886e-01f,
  -2.14226469e-01f, -7.92260617e-02f, -1.33773670e-01f, 1.55271575e-01f, -4.90790270e-02f, -3.72933522e-02f, -1.48163512e-01f, -1.40212089e-01f, 2.29616612e-01f, 3.29113565e-02f,
  -1.35970712e-01f, 1.12088405e-01f, -1.47862405e-01f, -2.06202209e-01f, -9.78391171e-02f, -1.45072713e-01f, -1.74191609e-01f, -9.50175896e-02f, -5.65790478e-03f, 4.11644801e-02f,
  -5.67594208e-02f, -2.72171889e-02f, 1.82544775e-02f, 6.42310083e-02f, -1.59170888e-02f, 7.33396485e-02f, -1.61488667e-01f, -2.50305105e-02f, -1.08464152e-01f, 1.74058288e-01f,
  -1.55164804e-02f, -3.54235657e-02f, -9.28138942e-02f, 1.67757854e-01f, -3.05583291e-02f, -1.12522706e-01f, 1.02535665e-01f, 6.74847811e-02f, 1.55773982e-01f, -4.06477833e-03f,
  4.33943793e-03f, 6.04958087e-02f, -9.85953286e-02f, -6.52142838e-02f, 3.62604950e-03f, 8.51577297e-02f, -6.94307080e-03f, -4.10307311e-02f, 2.56184209e-02f, -1.60442188e-01f,
  -6.58252537e-02f, 5.86480685e-02f, 1.21235967e-01f, 6.29440844e-02f, 4.04575244e-02f, 1.63807895e-03f, -3.29376198e-02f, 2.60519795e-02f, -1.29739158e-02f, 1.14703504e-02f,
  9.79177356e-02f, -1.88717283e-02f, 5.94783612e-02f, 8.13471973e-02f, -1.98007710e-02f, -8.88033137e-02f, -2.18478404e-02f, 1.03455335e-01f, -2.57080141e-02f, -7.31538981e-02f,
  -7.11788535e-02f, -1.53507397e-01f, 1.20408460e-01f, 1.88559875e-01f, 1.33235310e-03f, -2.52476986e-02f, -1.08944945e-01f, 3.46307494e-02f, 2.81707365e-02f, -1.09251067e-02f,
  1.01666860e-01f, -2.30334684e-01f, 6.42040968e-02f, 1.63620580e-02f, 8.37391149e-03f, -1.05210342e-01f, -1.02126502e-01f, -1.84458084e-02f, -1.35490432e-01f, -9.05417874e-02f,
  1.23323172e-01f, -7.32810125e-02f, 4.76559848e-02f, 1.58485606e-01f, -1.62697345e-01f, 7.64791593e-02f, -7.96042010e-02f, 3.96738313e-02f, 5.47486953e-02f, 4.56015095e-02f,
  2.86390223e-02f, 2.88246553e-02f, -4.57122251e-02f, 8.23961571e-02f, -1.51339397e-01f, 1.91384126e-02f, -8.20124075e-02f, 5.88659868e-02f, -1.66398346e-01f, -3.35550830e-02f,
  4.73604798e-02f, 8.39053392e-02f, 8.25984776e-03f, 1.19457006e-01f, -7.19290599e-02f, -9.57571995e-03f, -1.27221122e-01f, -1.04539186e-01f, -3.76877515e-03f, -1.38969511e-01f,
  -1.91579372e-01f, -2.31447387e-02f, 2.02092886e-01f, -1.47261500e-01f, -8.89154151e-02f, 2.22682938e-01f, -1.02129050e-01f, 1.35124847e-01f, -2.60427266e-01f, 4.93049622e-02f,
  -2.20088258e-01f, 2.57362723e-01f, 2.71520525e-01f, -1.79062679e-01f, -8.46593082e-02f, -1.54418215e-01f, 1.63886890e-01f, 1.40341103e-01f, 1.27911652e-02f, 1.86341032e-01f,
  1.04448400e-01f, -1.53635135e-02f, -8.76594037e-02f, 2.85852969e-01f, 6.96873516e-02f, 2.06568852e-01f, 1.19633622e-01f, 1.13933213e-01f, -1.13642715e-01f, 1.83093343e-02f,
  -1.06070124e-01f, -1.67428311e-02f, -1.19706683e-01f, -3.53636220e-02f, 1.92321539e-01f, 4.35918942e-02f, 7.09068328e-02f, -8.00862536e-03f, 4.59367670e-02f, 1.72870353e-01f,
  8.48207176e-02f, -1.11571193e-01f, -2.09748093e-02f, -3.83822061e-02f, -3.63615341e-02f, 1.66136056e-01f, -1.07086994e-01f, 4.93062213e-02f, 7.95237422e-02f, -8.74790177e-02f,
  1.20548151e-01f, 1.34266481e-01f, 3.17746848e-02f, 7.90096167e-03f, -3.36821042e-02f, 4.33169194e-02f, 6.94239289e-02f, 2.05565467e-01f, 1.53501481e-01f, 5.77599630e-02f,
  -1.09751984e-01f, 3.89172439e-03f, -1.37123436e-01f, -9.33235437e-02f, -1.00160897e-01f, 2.14399826e-02f, 1.11505995e-02f, -4.90582101e-02f, -2.02253327e-01f, 5.32518439e-02f,
  -6.86347298e-03f, -1.88829169e-01f, -1.31325603e-01f, -1.37297854e-01f, 7.01252297e-02f, 7.71637559e-02f, 9.71376002e-02f, 8.51368345e-03f, -2.06184038e-03f, 1.83645830e-01f,
  -1.59439281e-01f, -2.32260954e-02f, 1.03094548e-01f, -1.68828756e-01f, 1.34070843e-01f, -4.29488569e-02f, 8.07354897e-02f, 1.67052507e-01f, 5.16339159e-03f, 1.69802576e-01f,
  8.70397240e-02f, 9.39462408e-02f, 9.05775875e-02f, 6.39316440e-03f, 9.45521221e-02f, -4.22595404e-02f, 7.54975528e-02f, 9.78440195e-02f, 1.81927502e-01f, 3.06338836e-02f,
  6.49503618e-03f, 3.07484996e-02f, -3.68163586e-02f, 9.92273837e-02f, 1.01713099e-01f, 3.76903526e-02f, 1.73376892e-02f, 5.10468483e-02f, 4.09364849e-02f, 9.48414430e-02f,
  2.97421422e-02f, 1.04905196e-01f, -6.55371249e-02f, -3.24243382e-02f, -2.59007644e-02f, -9.02627707e-02f, 9.37064290e-02f, -3.35618621e-03f, 2.73116324e-02f, -1.05377950e-01f,
  -6.25578761e-02f, 1.24853484e-01f, 5.57166478e-03f, -8.73567387e-02f, -2.33787876e-02f, 1.15846448e-01f, -7.91882426e-02f, -1.17894337e-01f, 1.18284477e-02f, 8.44319016e-02f,
  1.11639975e-02f, -4.80758101e-02f, -1.20120980e-01f, 6.13174327e-02f, -4.89695519e-02f, -1.13750566e-02f, -1.06644481e-01f, -2.05308348e-01f, -1.16944261e-01f, 9.60965380e-02f,
  1.10155143e-01f, -1.16816245e-01f, -7.97357783e-02f, -8.84509161e-02f, -3.86294723e-02f, 1.78819388e-01f, -5.07636257e-02f, 9.60213989e-02f, -6.11129962e-02f, 9.54984501e-02f,
  -5.21050394e-02f, 1.22705385e-01f, -8.93174559e-02f, 1.93011165e-01f, 9.53413472e-02f, -7.25000128e-02f, 1.25039658e-02f, -4.26649749e-02f, 3.18449400e-02f, 1.85381174e-02f,
  6.99560419e-02f, -9.89480019e-02f, 1.68807790e-01f, 1.04367368e-01f, 3.68765593e-02f, -5.39406464e-02f, -4.93570492e-02f, -1.04382291e-01f, 1.01563884e-02f, -9.63109732e-02f,
  1.30439624e-01f, -8.81308913e-02f, -8.92557278e-02f, -1.30986199e-01f, 3.47161517e-02f, -2.70998031e-02f, -2.88647991e-02f, 7.00398535e-02f, -3.20329182e-02f, 1.27022684e-01f,
  7.33894482e-02f, -1.45060241e-01f, -1.24653421e-01f, 7.91611671e-02f, -1.60008132e-01f, -1.39289275e-01f, -1.23218056e-02f, 1.05941631e-01f, 4.95491475e-02f, 1.07005849e-01f,
  -6.15866743e-02f, 6.89949319e-02f, 7.37151429e-02f, 1.09960616e-01f, -6.91533014e-02f, -1.45932406e-01f, -2.10849926e-01f, -2.26318568e-01f, 6.13721982e-02f, -1.73401356e-01f,
  1.12195171e-01f, -5.83257601e-02f, 8.48911256e-02f, 3.78168710e-02f, -2.60597672e-02f, 5.04542813e-02f, -9.65447128e-02f, -1.32218376e-02f, -2.45336816e-01f, 8.89386982e-02f,
  3.21105532e-02f, -5.98432757e-02f, -1.08682759e-01f, 6.37285188e-02f, 2.09820922e-02f, 1.14559472e-01f, 1.17668033e-01f, 1.09136634e-01f, -8.87582898e-02f, -1.71279579e-01f,
  1.36064321e-01f, 1.42217383e-01f, 4.91292588e-02f, 9.96421874e-02f, 3.30261961e-02f, -3.27333845e-02f, -4.84301932e-02f, -9.54576358e-02f, -1.03160806e-01f, -1.00837059e-01f,
  1.63746551e-02f, -9.31558013e-03f, -2.42844168e-02f, -1.74697861e-01f, 8.87463689e-02f, 1.57307997e-01f, -1.32048041e-01f, 1.31104857e-01f, -2.28903055e-01f, 1.69274494e-01f,
  -2.95919669e-03f, -1.10133560e-02f, 1.38384104e-01f, 1.40184790e-01f, 6.46748617e-02f, 1.12566054e-01f, -4.14127260e-02f, 2.75905966e-03f, -1.46902218e-01f, -5.41526303e-02f,
  -4.68061529e-02f, -3.26485373e-02f, -1.05751052e-01f, -4.99608810e-04f, -2.96409745e-02f, -7.26444051e-02f, -1.24749936e-01f, 5.53307161e-02f, 1.48996577e-01f, 4.59691808e-02f,
  2.30138265e-02f, -7.37666935e-02f, -1.21412784e-01f, -1.72640607e-01f, -1.14735804e-01f, -7.26200417e-02f, -1.07555389e-01f, 2.80731581e-02f, 4.17435877e-02f, -6.11346252e-02f,
  -5.24370335e-02f, 8.07132199e-03f, -2.43476465e-01f, -2.22073406e-01f, 9.38938558e-02f, -1.96012244e-01f, 1.57121569e-01f, 2.13943589e-02f, 8.92678425e-02f, -3.00558619e-02f,
  1.49859205e-01f, 1.74733639e-01f, 5.88727556e-02f, 1.02006972e-01f, -8.58459398e-02f, -1.12542138e-02f, -5.90856262e-02f, -1.56317607e-01f, 2.40174949e-01f, 1.91409308e-02f,
  7.32264295e-02f, -5.10352552e-02f, 5.32077532e-03f, -8.59150812e-02f, 1.28795937e-01f, -4.93206941e-02f, -9.03317407e-02f, -1.34845162e-02f, 7.95973688e-02f, -7.19646141e-02f,
  -5.82719818e-02f, 5.28929569e-03f, 7.22634494e-02f, 1.27444804e-01f, 3.78838405e-02f, -6.75773695e-02f, 5.56635708e-02f, 1.31668225e-01f, -6.45502135e-02f, 5.24330437e-02f,
  3.34656686e-02f, 7.56662712e-02f, -7.27482066e-02f, 3.75340017e-03f, 7.29552358e-02f, -1.05922483e-01f, -6.43296912e-02f, 8.04918408e-02f, -2.01068953e-01f, 3.93174663e-02f,
  -5.88692687e-02f, -7.59083182e-02f, 1.65975332e-01f, 2.12869747e-03f, -2.41687298e-02f, 8.21907446e-02f, -1.01676382e-01f, -6.83436766e-02f, -7.22915307e-02f, -1.13834664e-01f,
  9.65244249e-02f, 6.96813464e-02f, 3.69248018e-02f, 1.20106991e-02f, 2.26211566e-02f, 1.36729583e-01f, -6.68637231e-02f, 5.53283542e-02f, 1.06893189e-01f, -5.38347475e-02f,
  -6.64577484e-02f, 5.81934378e-02f, 4.51674126e-02f, 1.85499161e-01f, -1.67968702e-02f, 1.78720832e-01f, 8.74628574e-02f, 1.50154680e-01f, -3.67509276e-02f, 1.60930157e-01f,
  -2.07258780e-02f, 4.45399508e-02f, 2.03738779e-01f, -4.99919429e-02f, 1.17037416e-01f, 4.20495309e-02f, 6.96612448e-02f, -9.00012553e-02f, -1.11672997e-01f, 8.89654309e-02f,
  2.15388536e-02f, -8.95217657e-02f, 4.20549363e-02f, -8.10462683e-02f, -1.60575397e-02f, 8.83771852e-02f, 1.20033391e-01f, -1.07462741e-02f, 1.25844508e-01f, 1.61766708e-02f,
  -9.43236649e-02f, -9.80883315e-02f, 9.16154459e-02f, -3.26247178e-02f, -2.12349873e-02f, 1.12857290e-01f, 8.58413652e-02f, -8.46730620e-02f, -2.34534661e-03f, 1.45801948e-02f,
  5.55042513e-02f, 7.04331091e-04f, -7.28294998e-02f, -2.01811060e-01f, -6.04445487e-02f, 4.00833301e-02f, -1.51869565e-01f, 1.48495570e-01f, 2.19439436e-02f, 2.91007161e-02f,
  1.37366220e-01f, -9.95733142e-02f, 6.12365268e-02f, -1.53401062e-01f, 1.31806031e-01f, 1.44433260e-01f, -1.17277764e-01f, -1.03401333e-01f, -8.79818480e-03f, 1.22931518e-01f,
  9.90665480e-02f, 1.32794213e-02f, -1.25378579e-01f, 4.63186838e-02f, 6.14507124e-03f, 3.88459000e-03f, 1.38157696e-01f, -4.60215472e-02f, -5.83858751e-02f, 1.32417202e-01f,
  6.88550919e-02f, 6.27169535e-02f, -1.50405243e-01f, -6.34452999e-02f, 1.20634891e-01f, 1.21093690e-01f, -4.36452813e-02f, -1.05769590e-01f, 2.18683835e-02f, 6.42574206e-02f,
  2.55559962e-02f, -4.13221382e-02f, -6.07234500e-02f, -6.37333319e-02f, -1.26742832e-02f, -4.63529341e-02f, -5.90382405e-02f, 3.10693756e-02f, 9.84090045e-02f, 1.25378072e-01f,
  1.19321952e-02f, -8.49158503e-03f, 1.95224793e-03f, 5.07780015e-02f, 1.04901962e-01f, 1.03357352e-01f, -1.20647132e-01f, -5.31950733e-03f, -7.53019974e-02f, 1.95536271e-01f,
  1.94260553e-02f, 1.70868516e-01f, 7.25499764e-02f, -7.50196725e-02f, -1.86464260e-03f, -1.21762857e-01f, -9.07679200e-02f, -8.46267268e-02f, 1.25862025e-02f, 2.55824830e-02f,
  1.87716857e-01f, 7.51888659e-03f, -1.33880734e-01f, -1.54451534e-01f, 5.14186881e-02f, -4.26097177e-02f, -8.92702565e-02f, -2.64651366e-02f, -8.00079107e-02f, 7.85217714e-03f,
  5.74461222e-02f, -5.53295650e-02f, 3.53084430e-02f, 1.27209827e-01f, 3.02422866e-02f, 1.64802358e-01f, 1.74300864e-01f, 3.51409353e-02f, 1.89519763e-01f, 1.90512419e-01f,
  1.11831881e-01f, -5.23899719e-02f, -7.84128606e-02f, 2.10996680e-02f, 1.10477060e-01f, 4.66472730e-02f, 3.59159516e-04f, 1.67435154e-01f, 6.48710504e-02f, 1.16377816e-01f,
  1.16171418e-02f, -1.42663538e-01f, 2.43081711e-02f, -7.49605075e-02f, 1.87485255e-02f, 5.23672067e-02f, -4.09512110e-02f, 4.68708016e-02f, -1.15809314e-01f, -1.51448041e-01f,
  1.33854384e-02f, -6.01157434e-02f, -1.05538644e-01f, -7.44023994e-02f, -1.25582561e-01f, 1.91715315e-01f, -4.57871519e-02f, -6.50378168e-02f, -2.65939459e-02f, 2.35334951e-02f,
  -1.65424291e-02f, -4.11629267e-02f, 3.54276262e-02f, 6.58684820e-02f, -2.29260512e-02f, 1.54911667e-01f, -1.90675214e-01f, -6.72467127e-02f, -1.19568437e-01f, -6.79095834e-02f,
  -1.40821055e-01f, -1.18797824e-01f, -1.47927940e-01f, -1.41798943e-01f, -8.47661346e-02f, 8.67515877e-02f, 2.91583836e-02f, 2.28619099e-01f, -1.19094692e-01f, 1.62024871e-01f,
  -9.38986912e-02f, 5.48108928e-02f, -9.56794694e-02f, -1.03011660e-01f, 1.16948128e-01f, -1.18974514e-01f, 1.14618696e-01f, 2.80828290e-02f, -7.12585822e-02f, -2.11543396e-01f,
  3.74134779e-02f, 8.34379047e-02f, 3.01624894e-01f, -9.26243365e-02f, 5.86539581e-02f, -4.66420427e-02f, -1.56188026e-01f, -1.24594629e-01f, 1.40203387e-01f, 1.59150064e-01f,
  -1.37234375e-01f, -4.10641246e-02f, 2.62137642e-03f, -5.16442470e-02f, 6.19235300e-02f, 7.19915703e-02f, -1.03095904e-01f, -1.93612918e-01f, -2.24747002e-01f, -5.87224849e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.63035410e-03f, 6.96056709e-02f, 1.44357175e-01f, 1.22254930e-01f, 7.98276812e-02f, 7.27283442e-03f, -9.37840343e-02f, -9.16166008e-02f, 1.90836892e-01f, 1.70023903e-01f,
  8.05684179e-02f, 1.64474219e-01f, -1.73461691e-01f, -1.14276476e-01f, 1.24393096e-02f, -6.70532733e-02f, 1.54290527e-01f, -1.76850423e-01f, 1.68740794e-01f, 1.44933879e-01f,
  -1.09762423e-01f, 1.28080649e-02f, 1.58991128e-01f, 1.47959828e-01f, 2.89961174e-02f, -1.91983998e-01f, -1.13355815e-01f, -6.23024106e-02f, 8.98380503e-02f, -5.35981283e-02f,
  3.08647901e-02f, 2.23404199e-01f, 1.47328109e-01f, 1.87648356e-01f, -5.06357814e-04f, -1.29993912e-02f, 8.78776461e-02f, 1.69029176e-01f, 9.09078419e-02f, -7.89124966e-02f,
  -1.06417887e-01f, -1.35264263e-01f, -2.14933660e-02f, 6.68455064e-02f, -2.73571666e-02f, 1.55029893e-01f, -1.26722813e-01f, -5.63940071e-02f, 8.41156691e-02f, 7.30650201e-02f,
  -1.50978342e-01f, 9.54993963e-02f, 2.57571954e-02f, -8.39026198e-02f, -5.32640740e-02f, -1.25681385e-01f, 9.09836497e-03f, -6.12957329e-02f, 1.60236247e-02f, 1.23286225e-01f,
  1.12447061e-01f, 1.23539425e-01f, 7.38862529e-02f, -2.23286338e-02f, 3.71952131e-02f, 2.13239223e-01f, 8.35738517e-03f, -3.07519048e-01f, 1.34836182e-01f, 1.48483040e-02f,
  5.02450764e-02f, 4.95034084e-02f, -7.72429854e-02f, 4.17913543e-03f, 2.24581119e-02f, -3.40234898e-02f, 8.10306594e-02f, 6.21966943e-02f, 5.66459708e-02f, -7.24722072e-02f,
  1.84667617e-01f, 3.04744300e-03f, -3.75410244e-02f, 1.00374362e-02f, 3.51451449e-02f, 2.13060901e-02f, 9.33386609e-02f, 1.21156178e-01f, -1.44314408e-01f, 1.09537274e-01f,
  5.17064855e-02f, -1.11486927e-01f, -2.89431870e-01f, 9.53286737e-02f, -1.26364157e-01f, 1.01880282e-01f, -6.71331137e-02f, -1.69769913e-01f, 2.85898805e-01f, 1.14163958e-01f,
  2.62431413e-01f, -1.02580272e-01f, -2.18511876e-02f, -2.05581784e-02f, -5.05858250e-02f, 6.50861338e-02f, -1.05040714e-01f, -5.77653609e-02f, -7.77452663e-02f, -1.74976110e-01f,
  -1.70076098e-02f, -2.52450518e-02f, 3.57309245e-02f, -2.04969779e-01f, 1.76044509e-01f, -1.22356035e-01f, 7.86528438e-02f, 2.41085654e-03f, 6.04891069e-02f, 7.35224411e-02f,
  -9.24926549e-02f, 1.37463838e-01f, 2.68316120e-01f, -2.68513504e-02f, -8.21400881e-02f, -1.42652810e-01f, 8.16627666e-02f, -1.30587339e-01f, 1.29348993e-01f, 1.35355666e-01f,
  2.11941320e-02f, 2.41433591e-01f, -3.43248583e-02f, 3.18281762e-02f, -5.26092714e-04f, 1.69435851e-02f, 6.00157259e-03f, 2.77400762e-01f, -7.66549781e-02f, -1.41951563e-02f,
  -5.16297892e-02f, 1.84828475e-01f, 4.05379049e-02f, 1.91615507e-01f, 1.51125327e-01f, -2.38283370e-02f, 8.89503509e-02f, 3.18316847e-01f, -2.53100306e-01f, -9.98068228e-02f,
  3.12539153e-02f, -1.22827351e-01f, -1.17966831e-02f, -2.81072315e-02f, -1.22636028e-01f, 1.14729799e-01f, 2.41936073e-01f, -1.72229663e-01f, 8.87781084e-02f, -4.48699594e-02f,
  -4.27983627e-02f, 1.79762356e-02f, -1.97917283e-01f, 8.89283940e-02f, -2.65543222e-01f, -7.78400674e-02f, 2.53900468e-01f, -2.87461765e-02f, 2.73994468e-02f, 6.64589787e-03f,
  1.30012259e-01f, -1.95229307e-01f, 1.17557883e-01f, 1.13420933e-01f, 9.71077830e-02f, 7.80050457e-02f, -9.32504609e-02f, 1.12813272e-01f, -4.97890189e-02f, 8.93201120e-03f,
  -4.17148843e-02f, 1.51234984e-01f, 1.02456436e-01f, 5.76621667e-02f, 7.91301727e-02f, -3.26331295e-02f, 1.93829034e-02f, 1.38441790e-02f, -1.08210355e-01f, -1.30211571e-02f,
  -2.40924135e-01f, 4.43289429e-02f, 6.61897473e-03f, 1.46289006e-01f, -2.35476643e-02f, 1.02144346e-01f, 4.50361036e-02f, -1.44259155e-01f, -1.12769142e-01f, -1.85260568e-02f,
  1.88956242e-02f, 2.10206166e-01f, 1.51813626e-02f, -3.26481499e-02f, 1.03242606e-01f, 9.21801031e-02f, -8.96384642e-02f, -1.23581681e-02f, 2.94777751e-02f, -9.22174901e-02f,
  1.19371749e-01f, -3.64465080e-02f, -1.37440767e-02f, 9.29105952e-02f, -6.06197603e-02f, 8.47402662e-02f, 2.10891347e-02f, -2.18514055e-01f, -2.93617081e-02f, -1.75248042e-01f,
  -1.81817152e-02f, 2.16047298e-02f, 1.39229685e-01f, 6.33050352e-02f, -5.48605360e-02f, 1.43509880e-01f, -8.21604207e-02f, 9.16451290e-02f, 1.58407278e-02f, -1.64168533e-02f,
  6.13521738e-03f, -5.58584221e-02f, -6.03076816e-02f, -1.40903553e-03f, 2.89421268e-02f, 4.92605753e-02f, -1.30844995e-01f, 1.09143771e-01f, 3.03767566e-02f, 2.57951189e-02f,
  -9.85419452e-02f, -7.04811811e-02f, 8.88067409e-02f, 9.30982009e-02f, -9.30516347e-02f, 6.90493137e-02f, 1.15518101e-01f, -9.62355733e-02f, 8.21730867e-02f, -7.65179098e-03f,
  -6.99578896e-02f, -7.48129934e-02f, 6.25189170e-02f, -7.00964779e-02f, -1.26910433e-02f, 1.01444907e-01f, 1.04684941e-01f, 9.22683999e-02f, -7.71138147e-02f, 5.76174185e-02f,
  -8.50077122e-02f, 9.06405002e-02f, 3.26875746e-02f, 1.34390786e-01f, 6.67473003e-02f, -3.78442705e-02f, 1.45025402e-02f, 3.26402932e-02f, 1.04830280e-01f, 7.87230283e-02f,
  3.78099903e-02f, -3.87508236e-02f, -4.44092602e-02f, -8.22904259e-02f, 3.17309946e-02f, -4.94814180e-02f, 4.25591506e-03f, 1.56103894e-01f, 5.27837276e-02f, 1.71962678e-02f,
  -2.97103040e-02f, -2.98853926e-02f, -1.01040274e-01f, 8.49771276e-02f, -1.18473828e-01f, 1.20882884e-01f, 5.13934754e-02f, 1.66428775e-01f, -1.07260518e-01f, 2.94172745e-02f,
  -6.41166717e-02f, -3.27402204e-02f, 1.24338046e-01f, 1.34864524e-01f, 8.25304762e-02f, 1.12116732e-01f, -5.53046688e-02f, -1.10296540e-01f, 2.37635877e-02f, -3.39630544e-02f,
  5.97443916e-02f, 5.37692988e-03f, 1.32018458e-02f, -5.38572222e-02f, 3.46922725e-02f, -7.86170736e-02f, 8.02767947e-02f, -8.57252926e-02f, -8.91746208e-02f, 7.07197264e-02f,
  -1.04340993e-01f, -3.40725109e-02f, 5.23985215e-02f, -4.56545651e-02f, 1.01839744e-01f, -6.67327195e-02f, -4.83620055e-02f, 2.38247123e-02f, 2.33908053e-02f, 3.16218734e-02f,
  -6.68017119e-02f, -6.20408580e-02f, 1.02035508e-01f, 1.20228156e-01f, 9.74780414e-03f, 9.69965607e-02f, -3.73660699e-02f, -6.08634017e-02f, 4.67985831e-02f, -6.26282021e-02f,
  -2.35520713e-02f, -1.03172369e-01f, 7.10125938e-02f, 1.05676986e-01f, -8.26591700e-02f, 7.05602393e-02f, -1.02668650e-01f, 5.21340854e-02f, 3.97171490e-02f, -8.43245313e-02f,
  6.25658780e-02f, -8.90713837e-03f, -7.29046986e-02f, 1.32660493e-01f, -1.10463634e-01f, 1.25561327e-01f, -1.01868463e-04f, -1.15581088e-01f, -1.36370569e-01f, -2.77837515e-02f,
  1.11818023e-01f, 1.05970278e-01f, 1.11162953e-01f, -6.99432939e-02f, -5.45593128e-02f, -3.70764360e-03f, -8.26899558e-02f, 6.41568080e-02f, 9.75774899e-02f, 9.54287872e-02f,
  1.02567710e-02f, -8.93902928e-02f, -1.17171690e-01f, -2.43711248e-02f, 1.25731155e-01f, -9.68530029e-02f, -9.30176005e-02f, 2.34616697e-02f, -3.91415022e-02f, -8.94452259e-02f,
  -8.72197747e-02f, 1.34924665e-01f, 6.24040589e-02f, -3.78982052e-02f, -8.23599696e-02f, -1.03644915e-01f, -6.51307683e-03f, 9.22739953e-02f, -4.60619368e-02f, 1.08856246e-01f,
  7.77743161e-02f, 1.67721063e-01f, -1.68479215e-02f, -4.04423513e-02f, 6.39332831e-02f, 1.02025546e-01f, 2.07255092e-02f, -7.85587057e-02f, -6.68685585e-02f, -1.96499545e-02f,
  1.09563708e-01f, 1.04772607e-02f, 1.64124325e-01f, 1.78332895e-01f, 2.80400068e-02f, 1.00495167e-01f, -1.42112188e-02f, 1.51230708e-01f, 9.87789780e-02f, 1.30233273e-01f,
  -3.51100899e-02f, 4.62809354e-02f, -6.15118295e-02f, 6.74645603e-02f, -3.04694679e-02f, -5.07090688e-02f, 4.40783650e-02f, 7.38376081e-02f, 2.37249509e-02f, -2.30421066e-01f,
  -1.41517818e-01f, 3.04905493e-02f, 8.31243843e-02f, 5.69272712e-02f, 8.61105993e-02f, -3.37658487e-02f, 7.41337761e-02f, -9.96182263e-02f, -9.36140716e-02f, -1.61122024e-01f,
  8.53604302e-02f, 2.13032201e-01f, -1.32644370e-01f, -2.17305087e-02f, 1.26711980e-01f, 1.64355878e-02f, -6.91925287e-02f, -8.52991641e-02f, -1.30383829e-02f, 1.02386661e-01f,
  9.22108516e-02f, -1.44613953e-03f, 1.36787534e-01f, 5.66016026e-02f, -3.81512567e-02f, 1.57437176e-01f, 1.52099490e-01f, 1.38672784e-01f, -1.14725146e-03f, 9.65819582e-02f,
  -7.05032796e-02f, 3.06720193e-02f, 7.83512369e-03f, -1.11854143e-01f, 7.39830658e-02f, -3.88290398e-02f, -3.56381051e-02f, -2.32437979e-02f, -4.01960798e-02f, 1.73186153e-01f,
  -1.73454937e-02f, -3.95325311e-02f, 6.85297251e-02f, 1.81640059e-01f, -2.02228706e-02f, 1.48746029e-01f, 1.44136921e-01f, 1.89466476e-01f, 5.54298386e-02f, 6.03650659e-02f,
  -9.20077637e-02f, 1.01168297e-01f, 1.19598024e-01f, 2.55496483e-02f, 2.73016561e-02f, 9.34565812e-02f, -1.04221411e-01f, 4.65302132e-02f, -8.41605440e-02f, 4.71030958e-02f,
  9.52073634e-02f, -1.22444332e-02f, -9.34496745e-02f, -1.61180198e-01f, -1.55728459e-01f, 7.46083111e-02f, -5.44640347e-02f, 7.77625665e-02f, 1.32614747e-01f, 2.94986516e-02f,
  -1.26160756e-01f, -9.17146131e-02f, -1.41157568e-01f, -7.44667277e-02f, -4.77231033e-02f, 1.09008849e-01f, 7.28076557e-03f, -1.86381638e-01f, 1.20929778e-01f, 1.36333168e-01f,
  7.47362599e-02f, 3.49471457e-02f, -7.50951767e-02f, 1.91952154e-01f, 7.31963068e-02f, 1.59744307e-01f, 7.55789652e-02f, 7.66527131e-02f, -5.12843067e-03f, 2.14971870e-01f,
  1.51464626e-01f, 5.05531430e-02f, -1.15336485e-01f, -1.02223149e-02f, -9.32414085e-03f, 3.65065485e-02f, 1.15543857e-01f, 7.06320181e-02f, 2.03539059e-02f, 1.39883608e-01f,
  1.16473407e-01f, 1.23228185e-01f, -7.01193437e-02f, 1.80455387e-01f, 1.50522858e-01f, -6.60914928e-02f, 5.68960235e-02f, 9.52377915e-02f, -1.85164530e-02f, 1.38231754e-01f,
  6.43177480e-02f, 6.97100163e-02f, -4.44217622e-02f, -1.23815648e-01f, 2.00197965e-01f, 1.04191124e-01f, 1.16795599e-01f, 1.10186100e-01f, 2.51193214e-02f, 1.01666987e-01f,
  1.36138946e-01f, 1.52545460e-02f, -6.28085658e-02f, -1.18213408e-01f, 7.64078125e-02f, 1.57120615e-01f, -3.86371873e-02f, -1.73444003e-01f, 7.81912729e-02f, -2.38415715e-03f,
  4.78591882e-02f, 4.09600437e-02f, 4.53640270e-04f, 2.40560435e-02f, -4.63844948e-02f, -1.59841791e-01f, -8.38858038e-02f, 2.16977485e-02f, 1.44037992e-01f, 2.14259401e-01f,
  5.63859940e-02f, -1.28811806e-01f, 1.37835771e-01f, 1.03427693e-01f, -1.77309752e-01f, 1.41543662e-02f, 6.81665493e-03f, 2.35168263e-03f, 1.05225153e-01f, 3.41267139e-02f,
  1.22756407e-01f, 1.13497943e-01f, 6.84505776e-02f, 1.08117141e-01f, 7.11211413e-02f, 1.82351723e-01f, -1.10891037e-01f, 8.35363045e-02f, 7.28374869e-02f, 8.94026831e-02f,
  1.45020962e-01f, 8.60594884e-02f, 2.12662555e-02f, 1.62730828e-01f, 5.03247790e-02f, 7.07622170e-02f, 4.14052494e-02f, -9.24636945e-02f, 1.07188575e-01f, -7.14367582e-03f,
  -1.22100554e-01f, -8.18653703e-02f, 8.99668112e-02f, 3.40162069e-02f, 2.04495966e-01f, -1.04789861e-01f, 8.44877735e-02f, -4.53933328e-02f, 3.90818575e-03f, -5.80838509e-02f,
  -7.88334459e-02f, 4.89710867e-02f, 7.48154372e-02f, 8.76654312e-02f, 1.02170736e-01f, -8.63834769e-02f, 1.95309505e-01f, 1.63444087e-01f, 1.35715768e-01f, 1.20116942e-01f,
  9.51855779e-02f, -4.75469939e-02f, -1.04729392e-01f, -4.26582955e-02f, -9.05749425e-02f, 2.41947964e-01f, 1.92956567e-01f, 2.50921488e-01f, 8.44912082e-02f, 5.68516850e-02f,
  1.33388877e-01f, 1.78745575e-02f, 1.44905001e-01f, -2.24576667e-02f, -1.38530865e-01f, 1.16279554e-02f, -1.99741587e-01f, -1.45254076e-01f, 1.51441678e-01f, 6.29975349e-02f,
  7.36840293e-02f, 1.70109212e-01f, -1.18024029e-01f, 7.54969716e-02f, 7.22470209e-02f, -8.57651457e-02f, -1.57461733e-01f, -6.27725720e-02f, 7.70137310e-02f, -6.25227317e-02f,
  -3.16877514e-02f, -9.77663323e-02f, 1.23519942e-01f, 7.52005428e-02f, -1.53920382e-01f, 3.60312164e-02f, -5.95193282e-02f, 1.85066566e-01f, 1.59548640e-01f, 2.00527329e-02f,
  8.68291855e-02f, -9.74979550e-02f, -2.87109483e-02f, 8.71541873e-02f, -1.22588426e-01f, 1.26611711e-02f, -1.70692499e-03f, 9.25996825e-02f, 1.19880788e-01f, -2.22999081e-02f,
  -1.15201259e-02f, -1.68468468e-02f, -8.30644369e-02f, 8.65370408e-03f, -6.07721545e-02f, -3.38574895e-03f, -4.02947105e-02f, 1.40388543e-02f, -9.09829959e-02f, 7.86434766e-03f,
  -4.93536852e-02f, -1.02642082e-01f, -1.08458884e-01f, 5.97825274e-02f, -1.57142542e-02f, 2.92590093e-02f, -1.23236082e-01f, 1.20858349e-01f, 3.67897190e-02f, 8.01470503e-02f,
  -7.00095342e-03f, 7.04395398e-02f, 4.75534797e-02f, 3.79658490e-02f, 1.07075371e-01f, 9.37363654e-02f, -7.07383901e-02f, 4.42024246e-02f, -1.19462982e-01f, -1.20191574e-01f,
  6.51577935e-02f, -2.04225779e-02f, -3.32231596e-02f, -6.76280633e-02f, 1.10656738e-01f, 4.80129011e-02f, -6.81286827e-02f, -3.25068412e-03f, 1.48727549e-02f, -2.22626459e-02f,
  -7.18819350e-02f, 4.78768721e-02f, -6.62020519e-02f, 3.19459219e-03f, 1.22216865e-01f, 3.30847688e-02f, 1.77363399e-02f, -2.92814318e-02f, 1.17153928e-01f, -9.12402198e-02f,
  -9.90727022e-02f, -3.44318263e-02f, -5.98102733e-02f, -1.68269556e-02f, -6.81277597e-04f, 9.25841033e-02f, 1.16311908e-01f, -1.53245777e-01f, -8.81148502e-03f, 1.56419177e-03f,
  1.19375028e-01f, 9.86543745e-02f, 9.72782969e-02f, 6.09048009e-02f, 8.71161595e-02f, 2.83456631e-02f, 6.87808245e-02f, 6.86555430e-02f, -1.05338553e-02f, -7.07491636e-02f,
  -6.62006885e-02f, -4.77044657e-02f, -1.30345963e-03f, -4.27347934e-03f, 1.58979446e-01f, -1.17911905e-01f, 2.09856965e-02f, 1.06409259e-01f, -1.11294203e-01f, -5.01279011e-02f,
  -8.57611895e-02f, -1.55503318e-01f, -2.15140656e-01f, 1.83069170e-01f, -8.01816396e-03f, 9.14659649e-02f, 7.11694956e-02f, -2.64657233e-02f, 1.93458155e-01f, 4.28894907e-02f,
  2.07235530e-01f, 5.37366979e-02f, -8.91756266e-02f, -1.26418561e-01f, 1.27153918e-02f, 1.78070012e-02f, 7.59914219e-02f, -5.53379860e-03f, -1.00282788e-01f, 1.83202907e-01f,
  1.22023135e-01f, 1.31006628e-01f, 5.15396334e-02f, 1.13330156e-01f, 9.12901461e-02f, 9.30114985e-02f, 8.70496929e-02f, 7.11608231e-02f, 3.85675319e-02f, -4.72360998e-02f,
  -4.45436547e-03f, 9.01032835e-02f, 3.55752297e-02f, -6.37331307e-02f, 4.33826121e-03f, 3.91908996e-02f, 1.91569552e-01f, -9.46316198e-02f, 3.91587168e-02f, 5.67124039e-02f,
  -2.54774623e-05f, -2.25299019e-02f, -4.86329347e-02f, -7.28260204e-02f, 1.68875411e-01f, 1.04962662e-01f, 2.84762923e-02f, -7.80914575e-02f, 5.42393550e-02f, -7.53256539e-03f,
  6.18791915e-02f, -1.17735945e-01f, 1.42129242e-01f, -1.11247808e-01f, 8.77607763e-02f, -5.60353184e-03f, 8.71591195e-02f, -1.64890680e-02f, -1.61614437e-02f, 2.84043550e-02f,
  1.36630610e-01f, -3.68723238e-04f, 4.48642559e-02f, 1.01237163e-01f, -7.36884102e-02f, -1.23733513e-01f, -1.64914712e-01f, -2.64857858e-02f, 2.37410478e-02f, 5.74169233e-02f,
  1.09525971e-01f, -3.93395685e-03f, 1.30746514e-01f, 1.00397028e-01f, -2.91046668e-02f, -5.88838123e-02f, -1.24126300e-01f, 9.58438963e-02f, -3.99871729e-03f, -8.13485906e-02f,
  9.31208581e-02f, 1.15719087e-01f, -1.35970667e-01f, -8.90719295e-02f, -1.39188468e-01f, -7.61419162e-02f, 2.04549301e-02f, -1.30681559e-01f, -1.01445451e-01f, -4.55247723e-02f,
  1.41231315e-02f, 6.12382516e-02f, -3.64906490e-02f, 1.22503653e-01f, -2.73330119e-02f, 7.63720274e-02f, -4.87800092e-02f, -6.13095909e-02f, -1.39760017e-01f, 1.72794223e-01f,
  9.23607349e-02f, -5.25711738e-02f, -2.86409818e-02f, -7.16669112e-02f, -8.84189978e-02f, 7.96907619e-02f, -1.11592598e-02f, 6.60856962e-02f, -2.28784373e-03f, -8.41354281e-02f,
  -1.00315019e-01f, -2.25281660e-02f, -3.16378325e-02f, -2.05160230e-02f, 1.59653649e-02f, 1.12269215e-01f, -1.15089461e-01f, 7.29039460e-02f, -2.98863966e-02f, -9.76482853e-02f,
  -3.15742828e-02f, -4.84185033e-02f, 1.60957780e-02f, 1.16490737e-01f, -1.04439870e-01f, -9.68101472e-02f, 1.27160147e-01f, -7.16597885e-02f, 1.82038769e-02f, 1.12959810e-01f,
  -6.71770051e-02f, -2.40695644e-02f, -8.88372436e-02f, 1.22785762e-01f, 1.10802151e-01f, 5.49383909e-02f, -6.01359047e-02f, -7.07733631e-02f, -1.71339065e-02f, -9.02298093e-02f,
  1.64431408e-02f, 9.56978649e-02f, -1.04807325e-01f, -4.90023717e-02f, -9.39814448e-02f, -8.40430334e-02f, 8.48736763e-02f, 4.42386195e-02f, -6.47803321e-02f, 6.15951791e-02f,
  1.02745183e-01f, -1.17466852e-01f, 1.83800571e-02f, 1.14191035e-02f, -7.12267905e-02f, -4.56722714e-02f, -5.97621724e-02f, -7.05120489e-02f, 2.37466320e-02f, 5.60591780e-02f,
  1.40795574e-01f, -1.06293790e-01f, -1.82171781e-02f, -3.67960483e-02f, -5.85293174e-02f, -7.48443902e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.11466832e-01f, 1.83322683e-01f, 9.78008062e-02f, -5.84456977e-03f, -6.94172382e-02f, 8.73158313e-03f, 2.57522557e-02f, 1.05799437e-01f, 1.02318883e-01f, 7.27100745e-02f,
  -1.20947972e-01f, 6.47673905e-02f, -9.27517377e-03f, 4.68122959e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -9.21213031e-02f, 9.29595083e-02f, -7.24638328e-02f, -3.52408923e-02f, -6.61432371e-02f, -6.66969791e-02f, 1.07152507e-01f, -4.15500402e-02f, 1.82184711e-01f, -3.15212645e-02f,
  9.91330966e-02f, -5.96331321e-02f, -3.49362232e-02f, 2.78273579e-02f, -2.87506394e-02f, 1.31795064e-01f, 4.55068983e-02f, 1.09743461e-01f, 1.59519345e-01f, -8.31836388e-02f,
  1.34356618e-01f, 1.15907930e-01f, 1.09136179e-01f, 4.36095521e-02f, -1.47909537e-01f, 2.56006926e-01f, 1.07715726e-01f, -4.85120304e-02f, -1.90597311e-01f, -8.28998759e-02f,
  -1.34797886e-01f, 1.57105058e-01f, -1.35472193e-01f, 4.83995304e-02f, 1.50985003e-01f, -5.77912591e-02f, -1.71064630e-01f, -3.18498421e-03f, -1.52123064e-01f, -2.02813484e-02f,
  1.03961349e-01f, -1.19955525e-01f, -1.55125543e-01f, 4.74581495e-02f, 7.35709518e-02f, -1.59165725e-01f, -4.86482829e-02f, -1.24772593e-01f, 3.31846997e-02f, 6.38530105e-02f,
  -1.69873476e-01f, -1.23888597e-01f, 9.51022357e-02f, 7.05789551e-02f, 1.64183956e-02f, -1.43035486e-01f, -1.84446812e-01f, -1.87892914e-01f, -2.89042182e-02f, 4.10597548e-02f,
  2.22633919e-03f, -1.86847225e-01f, 1.22664034e-01f, 8.58838260e-02f, 5.98920044e-03f, -1.81623474e-02f, -2.42508389e-02f, -7.69223571e-02f, -1.22059770e-01f, 2.84399223e-02f,
  1.34639725e-01f, -2.00589914e-02f, -8.88525993e-02f, 1.42095372e-01f, -1.07871480e-01f, 1.75465286e-01f, 9.74499509e-02f, -6.66106269e-02f, 8.26882794e-02f, 7.41031859e-03f,
  4.42710891e-02f, 5.19655719e-02f, -2.78845318e-02f, -7.08987266e-02f, 1.00107238e-01f, -1.06775820e-01f, -8.06474909e-02f, 4.51060906e-02f, 3.34515586e-03f, -7.02424943e-02f,
  -1.20294809e-01f, 3.90467830e-02f, 2.07654744e-01f, 2.94174552e-02f, 2.28100792e-01f, 9.35702696e-02f, 1.84275627e-01f, -1.16979584e-01f, -5.18894531e-02f, -1.82600424e-01f,
  1.26002938e-01f, 2.11426735e-01f, 9.72653106e-02f, 4.29417826e-02f, 1.46442533e-01f, -4.79293764e-02f, 3.64013985e-02f, -1.40684545e-01f, -1.31408200e-01f, -2.33607851e-02f,
  -5.85713685e-02f, -1.67304520e-02f, -1.87337801e-01f, -1.13740206e-01f, 7.77662247e-02f, -6.54474199e-02f, 4.07414958e-02f, -4.10091430e-02f, 1.12216942e-01f, 1.16180301e-01f,
  -5.64695485e-02f, 1.93406403e-01f, -4.11409959e-02f, 1.85947061e-01f, -6.06724992e-02f, 1.47035331e-01f, 9.23476964e-02f, -5.86402901e-02f, 9.02258232e-02f, 2.86895707e-02f,
  3.30183422e-03f, 1.32456580e-02f, -1.25272393e-01f, -3.54885347e-02f, 2.36936919e-02f, -4.87207882e-02f, -4.29656394e-02f, 1.37313873e-01f, 3.55302133e-02f, 5.45728020e-02f,
  9.21246931e-02f, -1.02558859e-01f, -9.61306621e-04f, -6.86756074e-02f, -1.59020811e-01f, 9.47538856e-03f, -4.69248071e-02f, -8.85808542e-02f, 1.13506801e-03f, 6.38071969e-02f,
  1.35185402e-02f, -1.54665960e-02f, 1.50558308e-01f, -4.89208587e-02f, 4.96077202e-02f, 1.73576146e-01f, 2.66196966e-01f, -4.74196188e-02f, 1.98589355e-01f, -4.71934564e-02f,
  2.38858506e-01f, -1.05611868e-01f, 1.93810109e-02f, -1.62671916e-02f, 2.64705390e-01f, 3.39218289e-01f, -1.08815372e-01f, -1.55140385e-02f, 1.04452848e-01f, -3.48840728e-02f,
  -1.18876770e-01f, -5.40929399e-02f, -2.37745851e-01f, -2.42383122e-01f, 4.52704588e-03f, 1.10428132e-01f, 1.25075737e-03f, 7.80549049e-02f, 1.66258126e-01f, 7.27386028e-02f,
  1.50307892e-02f, 1.97661445e-01f, 1.49840102e-01f, 1.59659255e-02f, 1.23648010e-01f, -9.79184210e-02f, -1.03420034e-01f, 1.82844713e-01f, 6.14947118e-02f, 1.99170083e-01f,
  -9.32577532e-03f, 7.71754384e-02f, 1.72591284e-02f, 1.43106252e-01f, -4.33509871e-02f, 3.07734851e-02f, 1.01937123e-01f, 7.96326399e-02f, 3.50497924e-02f, 9.32703614e-02f,
  9.07119364e-02f, 1.25927627e-01f, 1.52756527e-01f, -6.37598261e-02f, 1.53736070e-01f, 8.27778280e-02f, 1.33018553e-01f, -4.44802865e-02f, -8.42469409e-02f, 6.67645559e-02f,
  9.21150967e-02f, 1.00043803e-01f, 9.72527638e-02f, 1.22102477e-01f, 1.09036453e-02f, 1.02683261e-01f, 3.76737490e-02f, 9.01380852e-02f, -9.85257700e-02f, -1.79115027e-01f,
  -2.02749353e-02f, -1.03975676e-01f, 7.15561211e-02f, -1.04141524e-02f, 3.09841353e-02f, -2.19326094e-02f, 1.93320647e-01f, 6.21638373e-02f, -1.24066144e-01f, 1.33589227e-02f,
  7.31108070e-04f, -9.68480110e-02f, -3.33916359e-02f, -5.66575490e-02f, 7.51208067e-02f, -8.78792629e-02f, -7.70334620e-03f, -1.29519805e-01f, -2.24028826e-02f, 4.40237336e-02f,
  5.21065779e-02f, 1.48167342e-01f, -1.72587708e-02f, -1.21208273e-01f, 1.94110304e-01f, -7.17596635e-02f, -9.51735228e-02f, 7.46173337e-02f, -6.61943555e-02f, 4.58539054e-02f,
  -1.56934157e-01f, 7.81975035e-03f, -8.52387398e-02f, -1.18778318e-01f, 1.69150792e-02f, 4.21168990e-02f, 8.33668932e-02f, -7.54089728e-02f, 4.03327718e-02f, -2.97593642e-02f,
  4.33248840e-02f, 1.22164853e-01f, 8.72118175e-02f, 1.06767640e-01f, -5.50565757e-02f, -9.25061852e-03f, -3.86094116e-02f, -1.32696524e-01f, -1.32765591e-01f, 9.53169540e-02f,
  3.94372754e-02f, 1.39360577e-01f, 1.64834056e-02f, -5.70181804e-03f, 5.03933616e-02f, 9.24063548e-02f, -3.24112587e-02f, -4.89977151e-02f, 7.37492740e-02f, 1.20659113e-01f,
  -2.01666467e-02f, -2.20634509e-02f, -8.38933662e-02f, 4.98987846e-02f, -2.08084378e-02f, -1.53712019e-01f, 7.72178769e-02f, -1.93535104e-01f, -3.86723876e-02f, 3.30970883e-02f,
  -1.73988834e-03f, -3.75728309e-02f, -2.28594378e-01f, -3.00010085e-01f, 2.00838260e-02f, -1.76419154e-01f, -1.20726153e-01f, -2.70655155e-01f, 1.02581613e-01f, 5.04651777e-02f,
  2.06153736e-01f, 1.19474843e-01f, 4.70824242e-02f, -3.90542559e-02f, -3.43680009e-02f, -1.41842514e-01f, -1.24918923e-01f, 2.71828473e-01f, -1.91733107e-01f, -1.41427010e-01f,
  -7.57857226e-03f, 1.26010433e-01f, -5.84786870e-02f, -1.68646380e-01f, -3.67215239e-02f, -9.47778001e-02f, -7.87835643e-02f, -6.57582581e-02f, 1.13176800e-01f, 2.99574714e-02f,
  1.08417168e-01f, 3.01752947e-02f, 8.61628577e-02f, -1.13546193e-01f, -7.78551698e-02f, -6.89393729e-02f, -1.46707028e-01f, -7.21339360e-02f, -7.04402402e-02f, -9.72715840e-02f,
  1.07073598e-01f, 5.48392311e-02f, 7.64512569e-02f, 7.45048970e-02f, -1.56387761e-02f, -1.18073538e-01f, -1.23276278e-01f, -7.14008659e-02f, 4.55220714e-02f, 5.32812811e-02f,
  -1.42302990e-01f, -7.47770593e-02f, -1.10998146e-01f, -5.41962609e-02f, 5.92481121e-02f, 3.08949258e-02f, -5.96954003e-02f, 1.22828931e-01f, 1.09498091e-01f, 8.24853405e-02f,
  4.34556007e-02f, 4.30596285e-02f, 1.81449819e-02f, 4.08326164e-02f, -6.97566047e-02f, 8.21785852e-02f, 1.08060107e-01f, -1.69980869e-01f, -6.74711391e-02f, -1.77970901e-01f,
  -1.04129896e-01f, -6.37828186e-02f, 4.86688800e-02f, 5.46801165e-02f, 5.77275967e-03f, 1.26239315e-01f, 1.17839701e-01f, 7.32372627e-02f, 1.81830898e-02f, -9.92601085e-03f,
  -8.33228417e-03f, 1.92194656e-01f, 2.86892131e-02f, -7.18367994e-02f, -1.01704085e-02f, 1.16000764e-01f, 1.15541324e-01f, -1.26152083e-01f, -1.00377783e-01f, -9.71098021e-02f,
  6.16697781e-02f, 1.82749704e-02f, 3.25597897e-02f, -9.43531469e-02f, 8.92526004e-03f, 1.59645393e-01f, 1.37307495e-01f, 3.19357887e-02f, -9.90523249e-02f, 9.39976573e-02f,
  -4.58099693e-02f, 1.63264319e-01f, -2.03570463e-02f, -3.81860249e-02f, 1.83409482e-01f, 6.12775721e-02f, -5.94928116e-02f, 2.75705960e-02f, -4.44060825e-02f, 1.19716756e-01f,
  -1.09418057e-01f, 1.44165829e-01f, 9.02666822e-02f, -1.92177005e-03f, 1.16406858e-01f, 1.09355882e-01f, 1.16907530e-01f, -9.09719393e-02f, -8.18051696e-02f, 1.40772954e-01f,
  1.29557326e-01f, -4.97329049e-02f, -1.36808470e-01f, -8.33140835e-02f, -1.55009210e-01f, 2.33004931e-02f, -2.16284528e-01f, -3.06664128e-02f, 1.04644462e-01f, 1.58271149e-01f,
  -1.94636211e-01f, -4.87203151e-02f, -6.66821226e-02f, -1.61777377e-01f, 1.39618488e-02f, 1.71605006e-01f, 1.74775839e-01f, 1.45185813e-01f, 1.16531752e-01f, 9.47038233e-02f,
  9.05518159e-02f, 4.82114181e-02f, 2.23297849e-01f, -4.98699071e-03f, -8.02558139e-02f, -1.17098324e-01f, 1.63929179e-01f, -7.15514645e-02f, -7.20228329e-02f, 8.68318528e-02f,
  -6.47554845e-02f, 1.00616328e-01f, 6.21376634e-02f, -1.24502771e-01f, -5.84539697e-02f, -1.59299105e-01f, -1.81619242e-01f, 1.18913673e-01f, 7.11714774e-02f, 1.51594520e-01f,
  5.07260785e-02f, 7.68964887e-02f, 1.30724227e-02f, -8.88400674e-02f, -2.05071806e-03f, -2.49563921e-02f, -6.85993209e-02f, -6.46009147e-02f, 3.24125141e-02f, -6.49491474e-02f,
  1.36450864e-02f, -4.54503521e-02f, 1.30857497e-01f, 8.29596668e-02f, -4.37558442e-02f, 1.52554199e-01f, 3.37963663e-02f, 1.59740657e-01f, 4.11623493e-02f, -2.31950711e-02f,
  -2.09915894e-03f, 1.39465546e-02f, 5.36141247e-02f, 7.29258955e-02f, 3.65060084e-02f, 5.43288626e-02f, 1.72593549e-01f, -3.94759104e-02f, 5.88215441e-02f, 1.32054701e-01f,
  1.41743600e-01f, -6.89490587e-02f, -1.32581234e-01f, -1.72808737e-01f, -1.29399031e-01f, 1.42809525e-01f, -1.21971913e-01f, 1.08163476e-01f, 9.76363719e-02f, 4.55273874e-02f,
  -1.24043755e-01f, 7.57108554e-02f, -7.23211616e-02f, -1.92062050e-01f, -7.54659027e-02f, -6.11802042e-02f, 8.94306600e-02f, -1.69715524e-01f, 2.05490857e-01f, -1.29883125e-01f,
  -1.52001247e-01f, -2.96995901e-02f, 9.18268040e-02f, -6.78083003e-02f, 3.51509340e-02f, -9.51149594e-03f, -1.02741115e-01f, 2.13431701e-01f, -9.24139004e-03f, -7.97165036e-02f,
  -6.02089055e-02f, -2.18776446e-02f, -4.08342443e-02f, -6.76150620e-03f, -3.99219543e-02f, -1.52044818e-01f, 3.89546007e-02f, -6.86342642e-02f, -1.28085643e-01f, 6.40182272e-02f,
  -3.98336463e-02f, -8.87105167e-02f, -8.92496333e-02f, 2.95862593e-02f, -1.33136854e-01f, 4.42599356e-02f, -9.38276108e-03f, -9.27880183e-02f, -1.29614398e-02f, -4.85639498e-02f,
  9.44531336e-03f, -6.10212050e-02f, -4.24151197e-02f, -7.61650056e-02f, -1.48749858e-01f, 3.29583585e-02f, -4.56239209e-02f, -1.70561209e-01f, 1.34657864e-02f, 1.35276079e-01f,
  1.94115818e-01f, 5.63015416e-02f, 2.54741814e-02f, -9.02853385e-02f, 4.17714193e-02f, 6.37290180e-02f, -1.06281310e-01f, -7.97130540e-02f, -1.39122874e-01f, -1.18281245e-01f,
  1.19628394e-02f, -7.62436762e-02f, -8.74555185e-02f, -1.27699971e-01f, 1.29431887e-02f, -6.13104776e-02f, 1.53794393e-01f, 8.27384815e-02f, 8.56026933e-02f, -5.21017835e-02f,
  -1.35464206e-01f, -9.69502255e-02f, 2.35633664e-02f, 1.52143091e-01f, -1.67655900e-01f, -8.61099809e-02f, -3.51297408e-02f, -9.35366675e-02f, -1.12739736e-02f, -3.19786146e-02f,
  9.20812637e-02f, 1.05274685e-01f, 3.07909027e-02f, -5.29435650e-02f, 1.21680148e-01f, -5.34854978e-02f, 3.73031124e-02f, 4.74738963e-02f, -6.70933677e-03f, -6.30805418e-02f,
  6.23988770e-02f, 8.10774490e-02f, 3.93665582e-02f, 5.46509912e-03f, 6.79556578e-02f, 7.30765760e-02f, -2.47527082e-02f, -7.94822201e-02f, 2.45233402e-02f, -7.54810721e-02f,
  -5.38515337e-02f, 2.69958824e-02f, -7.43505685e-03f, -4.14257161e-02f, -7.17929155e-02f, -9.85310748e-02f, -9.17396217e-04f, 7.91413411e-02f, -7.38771558e-02f, -4.83176149e-02f,
  -8.37250501e-02f, -1.17368408e-01f, 1.28032699e-01f, -1.16306925e-02f, -7.87585303e-02f, -1.33501187e-01f, 4.51378040e-02f, -1.90137196e-02f, -9.14570242e-02f, 1.33325875e-01f,
  -5.69096580e-02f, -1.02219224e-01f, -1.53298542e-01f, -2.29473919e-01f, 4.08270992e-02f, -3.61799859e-02f, 6.13436699e-02f, -1.76234752e-01f, 9.01680738e-02f, 2.03931034e-02f,
  6.90217689e-02f, -4.06983234e-02f, 1.01168476e-01f, 4.77626547e-02f, -1.34260535e-01f, -1.82817847e-01f, -1.87269360e-01f, 2.09931776e-01f, -2.03502476e-01f, -6.90573677e-02f,
  2.76598632e-02f, -5.57112359e-02f, -1.57804281e-01f, -4.68844473e-02f, -6.96178451e-02f, -2.87527237e-02f, -2.46925261e-02f, 9.01194140e-02f, 1.00792006e-01f, -6.16649985e-02f,
  2.65658442e-02f, -2.55593173e-02f, 1.24428138e-01f, -1.70592621e-01f, -5.41363992e-02f, -8.73615816e-02f, 7.46475607e-02f, -7.92461559e-02f, -4.77263406e-02f, 4.93423380e-02f,
  -3.31186429e-02f, 5.75600788e-02f, -9.35941413e-02f, -7.61278272e-02f, 1.57769263e-01f, 1.51661672e-02f, -6.40880540e-02f, 5.37905330e-03f, -2.36216243e-02f, 1.10331893e-01f,
  -8.64432082e-02f, -5.32982461e-02f, 2.11634450e-02f, 1.28275668e-02f, -4.34643216e-03f, -1.69998810e-01f, 2.80155651e-02f, 2.12847322e-01f, 1.75524846e-01f, 1.30186174e-02f,
  -1.62273217e-02f, 5.20824194e-02f, 1.77627981e-01f, -1.50271341e-01f, 2.98821498e-02f, -2.24886313e-02f, 1.53023168e-01f, 8.67109746e-02f, -3.28094163e-03f, 8.75085534e-04f,
  1.48501042e-02f, 9.91313681e-02f, 3.09997629e-02f, 3.27913463e-02f, -4.62546684e-02f, 8.24173354e-03f, -7.72285089e-02f, 1.15299508e-01f, -2.31114458e-02f, -7.66924322e-02f,
  2.31472239e-01f, -1.06449336e-01f, -5.13632447e-02f, 1.33686155e-01f, -8.98195244e-03f, -2.25372855e-02f, -3.45945098e-02f, 2.36677855e-01f, 1.90344438e-01f, 6.45443946e-02f,
  -1.53570371e-02f, 1.46580741e-01f, -3.17635424e-02f, -1.96962189e-02f, -3.16437446e-02f, -1.46757424e-01f, 6.57572225e-02f, -5.44059016e-02f, -4.03659232e-02f, -8.92391335e-03f,
  -1.76523975e-03f, 2.26094238e-02f, 3.10022384e-02f, -1.02364056e-01f, -2.88339593e-02f, 3.60767208e-02f, -2.91521177e-02f, -5.90094104e-02f, 1.22001953e-01f, -8.84449016e-03f,
  -7.25417063e-02f, 9.92302820e-02f, 1.48392394e-02f, 1.45008162e-01f, 8.18871707e-02f, -1.27923325e-01f, 4.19891346e-03f, -3.20742056e-02f, 5.53371310e-02f, -1.49031311e-01f,
  -9.31120515e-02f, 2.30105802e-01f, 2.56395966e-01f, 1.42992184e-01f, 6.73712716e-02f, -4.80546169e-02f, 1.27993166e-01f, -9.48581379e-03f, -1.92802221e-01f, -1.85792640e-01f,
  -3.26415524e-02f, 6.10224903e-02f, 6.62158802e-02f, 1.20538892e-02f, -2.64786594e-02f, -1.05483606e-01f, -6.40826449e-02f, -6.60065934e-02f, -1.52857795e-01f, -3.12097315e-02f,
  3.69889885e-02f, 2.16278099e-02f, -6.07660674e-02f, -1.04616553e-01f, 1.24703571e-01f, -7.70562980e-03f, -1.65348664e-01f, 1.38002485e-01f, -7.47749135e-02f, 8.31975415e-02f,
  1.29253836e-02f, 2.20824964e-02f, 1.16318233e-01f, 1.81367636e-01f, 8.55238438e-02f, -5.94005175e-03f, 1.22929528e-01f, -1.16240688e-01f, -6.92785829e-02f, 1.39064416e-01f,
  5.33819292e-03f, 4.19070721e-02f, -9.53914970e-02f, -2.54164147e-03f, -4.31509763e-02f, -4.46554013e-02f, -1.79900788e-02f, 1.06255077e-01f, -3.08496393e-02f, 2.39649042e-03f,
  -6.85656592e-02f, 2.57745273e-02f, -1.00829341e-01f, -1.18918963e-01f, 6.48035407e-02f, -1.15088366e-01f, 1.25770971e-01f, 9.96603891e-02f, 8.33896771e-02f, -8.57539847e-02f,
  9.09515917e-02f, -3.48697207e-03f, 4.11262922e-02f, 8.57179910e-02f, 5.53836524e-02f, 9.84612927e-02f, 3.48820090e-02f, -2.12986693e-02f, -1.55884800e-02f, -1.36461571e-01f,
  -1.36404559e-01f, 2.26601288e-02f, -1.67797476e-01f, -1.49041235e-01f, -1.08523492e-03f, 6.88835010e-02f, 9.62795243e-02f, -4.80527580e-02f, 8.00227597e-02f, -2.12490380e-01f,
  -1.51613161e-01f, 3.56509462e-02f, 9.08920728e-03f, -1.80761889e-01f, -1.37956485e-01f, 1.31493479e-01f, -7.85750374e-02f, -2.30010182e-01f, 8.30650851e-02f, 1.82095692e-01f,
  -3.15199405e-01f, 4.15581577e-02f, 6.43619001e-02f, 1.32901281e-01f, 4.11042646e-02f, -1.27049789e-01f, -1.44256324e-01f, 1.19638659e-01f, 4.64555584e-02f, 1.40354291e-01f,
  1.42852962e-01f, 9.00653303e-02f, -3.45732346e-02f, -1.48961702e-02f, -3.30820419e-02f, 4.12940159e-02f, -1.03331720e-02f, -8.81023407e-02f, -8.30955897e-03f, -2.85291318e-02f,
  2.87280860e-03f, 8.37517157e-02f, 8.29840079e-02f, 4.34043705e-02f, 3.05432137e-02f, 3.75778377e-02f, 7.37492740e-02f, 9.40060914e-02f, -1.08458236e-01f, -9.69469547e-02f,
  -3.31957862e-02f, -7.60070011e-02f, -1.02325752e-01f, -2.84781624e-02f, -1.04125999e-02f, 3.63706388e-02f, 1.18499026e-01f, -1.61933258e-01f, -1.53043151e-01f, -1.45862922e-01f,
  4.76182029e-02f, 6.25016615e-02f, 2.58899331e-01f, 6.43514320e-02f, 5.30841425e-02f, -4.22207005e-02f, 5.75668775e-02f, -1.10034700e-02f, 9.31327268e-02f, 2.00271100e-01f,
  -7.48879910e-02f, 2.09324405e-01f, -7.46529270e-03f, 2.30282228e-02f, -1.78894266e-01f, -1.43345997e-01f, -4.88465372e-03f, -1.06402293e-01f, -1.52255192e-01f, 6.99920580e-02f,
  -1.08156949e-01f, -1.24830296e-02f, 1.41792625e-01f, -4.21105176e-02f, 9.12918821e-02f, 1.33873463e-01f, -1.29840849e-02f, -1.35712937e-01f, 6.22030348e-02f, 2.77428031e-02f,
  -1.18349962e-01f, 1.25094205e-01f, -5.86482808e-02f, -5.98599799e-02f, 7.40921795e-02f, -1.08557440e-01f, -1.13029927e-01f, -6.10586181e-02f, 1.03229843e-01f, 9.81658474e-02f,
  -8.64607468e-02f, 3.99149656e-02f, 1.74039334e-01f, 8.63934830e-02f, 4.21232097e-02f, 1.45299479e-01f, 1.01282798e-01f, -7.24213198e-02f, 1.83536902e-01f, 1.17925908e-02f,
  -4.45675552e-02f, 4.30628620e-02f, 6.33497164e-02f, -6.25033826e-02f, -1.09482504e-01f, 1.03574730e-02f, 6.76518073e-03f, 1.20407604e-01f, 1.35058627e-01f, -5.73307984e-02f,
  -1.44364476e-01f, 1.38276979e-01f, -1.07719168e-01f, 8.08554217e-02f, 5.67346178e-02f, 2.61495244e-02f, 1.65739596e-01f, 2.48231053e-01f, 1.43371802e-02f, 6.88590631e-02f,
  -1.57808557e-01f, -4.73132171e-02f, 6.33297041e-02f, 1.94562331e-01f, 2.92137116e-02f, 8.12180862e-02f, 2.64753662e-02f, 9.36269835e-02f, -2.11643487e-01f, 1.16225608e-01f,
  -7.32181966e-02f, 6.33969307e-02f, -1.12240635e-01f, 3.46850641e-02f, -1.88566417e-01f, -1.23116687e-01f, 1.30985856e-01f, -1.65692240e-01f, 2.50973791e-01f, -5.51451333e-02f,
  8.62668976e-02f, 1.36591226e-01f, -8.17733109e-02f, 3.57648507e-02f, -1.28971130e-01f, -6.08059131e-02f, 2.98705325e-02f, -1.88819870e-01f, -7.17215762e-02f, 4.69034538e-02f,
  3.41636091e-02f, 4.49322397e-03f, -3.68640870e-02f, 2.72266730e-03f, 4.15982492e-02f, -9.42520984e-03f, 1.67550519e-01f, 1.00453779e-01f, 1.44360527e-01f, 9.94625464e-02f,
  1.01931468e-01f, 7.39892060e-03f, -2.17969976e-02f, -3.71511877e-02f, -1.02272660e-01f, 1.07981965e-01f, 2.21762389e-01f, -1.71690725e-03f, 1.47477359e-01f, -4.07459363e-02f,
  -5.38353138e-02f, 1.54891228e-02f, 4.82166708e-02f, 8.17197040e-02f, -7.00774118e-02f, 1.20660268e-01f, 1.91952914e-01f, 3.05763967e-02f, -1.29927948e-01f, -1.03542261e-01f,
  4.40376885e-02f, 1.30872309e-01f, -1.92511410e-01f, -6.54907227e-02f, -3.81108783e-02f, -1.59131661e-01f, -2.30482295e-01f, -1.51315942e-01f, 4.03445773e-02f, -4.21083272e-02f,
  1.38384268e-01f, -1.20233618e-01f, 4.48429324e-02f, -5.96928522e-02f, 4.75884276e-03f, -1.53104737e-01f, -1.60720870e-02f, -1.12528346e-01f, 7.71709979e-02f, -1.40154451e-01f,
  -6.00104630e-02f, -7.86013678e-02f, -5.81557723e-03f, -1.83415022e-02f, -1.83031745e-02f, -8.08661357e-02f, -1.43667430e-01f, -2.28814706e-01f, -1.08836882e-01f, -4.13325652e-02f,
  -7.01480359e-02f, -6.78260252e-02f, 9.19132307e-02f, 9.63246264e-03f, -1.13178352e-02f, 1.03243627e-01f, 8.12428221e-02f, 1.37126192e-01f, 4.66996208e-02f, 4.71460372e-02f,
  1.05780587e-01f, -1.50168035e-02f, 1.62764832e-01f, -2.54073832e-02f, 6.25031348e-03f, -6.64079636e-02f, 9.50690582e-02f, 1.44156337e-01f, -1.14070952e-01f, 2.14201369e-04f,
  1.45496979e-01f, 1.55548621e-02f, 1.14842594e-01f, -6.73820674e-02f, 7.39736781e-02f, 1.13016039e-01f, -6.03907444e-02f, 4.95570004e-02f, 2.16518901e-02f, -5.17474599e-02f,
  2.73164129e-04f, -1.97455138e-01f, -2.92121500e-01f, -1.01305120e-01f, -1.48096398e-01f, 1.47277683e-01f, -1.50487632e-01f, -3.92519310e-02f, 1.05629703e-02f, 1.78016290e-01f,
  -1.42633721e-01f, -1.03123344e-01f, 2.55699456e-02f, -1.15950286e-04f, 6.82444796e-02f, 4.30545136e-02f, -4.82713431e-02f, -5.88719593e-03f, -5.14465645e-02f, 1.36050329e-01f,
  8.38154331e-02f, -1.92875296e-01f, 1.95479095e-02f, 5.73402047e-02f, 3.02289636e-03f, -1.54629678e-01f, 2.71930218e-01f, 7.14406297e-02f, -6.09216392e-02f, 2.61312909e-03f,
  -6.37418255e-02f, 8.68422836e-02f, 4.42448668e-02f, -2.12372169e-01f, 1.19920880e-01f, -5.75356260e-02f, -1.37379214e-01f, 2.37616282e-02f, 6.75322786e-02f, -3.08672320e-02f,
  -1.09673798e-01f, 8.25774297e-02f, 1.12623170e-01f, 5.79526499e-02f, -9.49853286e-02f, -3.82653065e-02f, -5.18918559e-02f, -9.47042480e-02f, 1.04214713e-01f, 9.40071046e-03f,
  -1.68107450e-01f, 5.73191606e-02f, -3.63560580e-02f, -9.38249007e-02f, -3.47567983e-02f, 5.80163440e-03f, -5.50145246e-02f, -9.80196819e-02f, -1.15580462e-01f, 8.68516788e-02f,
  9.41417515e-02f, 2.58441307e-02f, 1.36075690e-02f, -1.74755514e-01f, -1.04761966e-01f, -2.43366808e-02f, 1.42468229e-01f, 2.14666933e-01f, -4.27984931e-02f, 2.06100289e-03f,
  1.46970958e-01f, -4.15231586e-02f, 1.44497409e-01f, 2.22270235e-01f, 1.05461255e-01f, 1.11856088e-01f, 1.19540781e-01f, -7.14695156e-02f, -1.32111639e-01f, 5.97743168e-02f,
  1.81919515e-01f, 1.49254456e-01f, -1.28431141e-01f, 2.42333323e-01f, 1.45768985e-01f, 2.59475615e-02f, 1.07345484e-01f, 1.60042256e-01f, 8.68063420e-02f, -2.08076127e-02f,
  1.59750730e-01f, 7.79218674e-02f, 1.02055378e-01f, -8.35285187e-02f, 8.13854113e-02f, 1.61975324e-01f, -2.11210977e-02f, -2.72506863e-01f, -1.38657885e-02f, -1.46515056e-01f,
  -1.35877416e-01f, 5.19935787e-02f, -9.62585658e-02f, 9.97086912e-02f, 4.58851568e-02f, -2.52323989e-02f, -1.75658707e-02f, 3.13635096e-02f, -3.71357799e-02f, -1.05128743e-01f,
  7.12078437e-02f, 5.09149097e-02f, -7.54143670e-02f, -1.39421582e-01f, 1.32837281e-01f, 5.36658056e-02f, 1.02520473e-01f, 1.07000798e-01f, 1.73579499e-01f, 9.69392359e-02f,
  1.09344453e-01f, -2.82027442e-02f, -5.94696738e-02f, 8.20401609e-02f, -2.87704170e-02f, 1.16931118e-01f, -1.37289226e-01f, 9.62754041e-02f, -1.01837022e-02f, -1.45266533e-01f,
  -7.19361752e-02f, -1.36550963e-01f, 1.14385359e-01f, -5.61071374e-02f, -7.85528217e-03f, 1.52866334e-01f, -2.78442297e-02f, -2.19851043e-02f, 5.58446348e-02f, -1.02258205e-01f,
  -2.99931765e-02f, 1.07011482e-01f, -6.20140135e-02f, -1.29897103e-01f, 4.01036367e-02f, -1.64645761e-01f, 7.28996694e-02f, 6.17781393e-02f, -1.50839999e-01f, -1.50020227e-01f,
  -1.84529275e-01f, -1.19494088e-01f, 7.79463630e-03f, 7.13620782e-02f, -1.58632994e-01f, -9.05008838e-02f, -3.75876874e-02f, -4.75332290e-02f, -1.92403629e-01f, -7.15233386e-02f,
  -4.04053554e-02f, -3.36343050e-02f, -1.20141275e-01f, -1.17950171e-01f, 6.81536570e-02f, -7.35361055e-02f, 5.06039970e-02f, -1.05652288e-01f, -5.74860983e-02f, 8.50122571e-02f,
  -2.55117211e-02f, -1.45187229e-01f, -1.21091202e-01f, -1.04479492e-01f, 4.03887369e-02f, -1.21381670e-01f, -1.21885017e-01f, -6.48726597e-02f, -1.00240856e-01f, -3.53256539e-02f,
  7.76375309e-02f, -6.84165657e-02f, -1.03022277e-01f, -1.24839567e-01f, -3.67109589e-02f, 4.08056229e-02f, -1.18347127e-02f, 3.51901725e-02f, -1.16184950e-01f, -5.39921783e-02f,
  -1.07877359e-01f, 2.78779920e-02f, 1.28430977e-01f, 2.10033953e-01f, 2.27899104e-01f, 3.72132473e-02f, -8.49432647e-02f, -6.98404610e-02f, 6.59292471e-03f, -4.76579135e-03f,
  -1.48585230e-01f, 4.37693521e-02f, 2.29665288e-03f, 1.01099953e-01f, -5.01124747e-02f, 2.14500329e-03f, 4.61672954e-02f, 1.57614306e-01f, -8.61346871e-02f, 1.15820251e-01f,
  -4.53440882e-02f, 6.51142076e-02f, 8.45976546e-02f, 1.61403105e-01f, -7.22611472e-02f, -2.18092371e-02f, 4.80584763e-02f, -1.56623989e-01f, -1.02328949e-01f, 2.44959611e-02f,
  -1.20690390e-02f, 5.00135124e-04f, 1.75786212e-01f, 4.39564623e-02f, 1.02002323e-01f, 3.13365720e-02f, -7.04149529e-02f, -7.18314480e-03f, -9.21756402e-02f, 5.59568554e-02f,
  -9.47866142e-02f, 9.43376049e-02f, 1.15074582e-01f, -6.39253855e-02f, 1.02233477e-01f, 2.95142829e-02f, 1.31429404e-01f, 3.07231955e-02f, 5.64247444e-02f, 1.34829089e-01f,
  5.24821430e-02f, -8.56394172e-02f, -2.23552510e-02f, 8.78943354e-02f, 5.89284040e-02f, 8.83582085e-02f, 2.09491149e-01f, 1.32165939e-01f, 8.73543173e-02f, 7.26815909e-02f,
  2.16138493e-02f, 6.80420473e-02f, -4.46932241e-02f, -3.84146385e-02f, -1.27094164e-01f, 2.07507491e-01f, 1.78319737e-01f, 1.22729592e-01f, 3.58281806e-02f, -1.74736202e-01f,
  3.87245230e-02f, 8.69482681e-02f, -4.94639352e-02f, -1.34380192e-01f, 2.78685279e-02f, -2.16832951e-01f, -2.30285674e-01f, -2.99945306e-02f, -1.75116107e-01f, 1.37635008e-01f,
  -3.13263908e-02f, -8.50554928e-02f, -1.51007146e-01f, -9.98510644e-02f, -6.77515417e-02f, -1.64062023e-01f, -1.55452028e-01f, 1.26929671e-01f, 4.00640555e-02f, -4.95254844e-02f,
  -1.05125956e-01f, 3.66124362e-02f, -2.28779241e-01f, -7.86649734e-02f, -4.39705476e-02f, -1.20337628e-01f, -1.29023135e-01f, -1.37331232e-01f, -1.91715121e-01f, -8.54858756e-03f,
  -1.01771049e-01f, -6.87639266e-02f, 4.86928001e-02f, 2.92607285e-02f, -3.68319973e-02f, 1.15092639e-02f, -8.68601352e-02f, -2.86100823e-02f, 1.14613280e-01f, -3.26453671e-02f,
  1.75189838e-01f, -9.74962115e-02f, -7.58518130e-02f, 1.56251080e-02f, 4.51054201e-02f, 1.30513180e-02f, 8.34190696e-02f, -9.06638056e-02f, 1.31782964e-02f, 7.41304383e-02f,
  1.56639293e-01f, 1.26885444e-01f, -7.34954402e-02f, 1.20328560e-01f, -1.18728772e-01f, 5.94020933e-02f, 9.78868306e-02f, 2.87213922e-02f, -1.37475461e-01f, 1.14964694e-01f,
  -5.06337471e-02f, 5.60164042e-02f, 6.58216104e-02f, -9.43976641e-02f, -4.98725884e-02f, 1.14499874e-01f, 1.14807904e-01f, 3.27548273e-02f, -1.78375676e-01f, -2.51720548e-01f,
  8.91807601e-02f, 1.34127468e-01f, -3.66565473e-02f, 1.43011793e-01f, 1.00090228e-01f, 3.85444835e-02f, -5.15631549e-02f, -8.79688784e-02f, -5.41194938e-02f, -2.17235550e-01f,
  3.61874402e-02f, 1.52136877e-01f, -1.08252436e-01f, -2.22188786e-01f, 9.26580429e-02f, 4.10552137e-02f, -9.32436511e-02f, 9.14725140e-02f, -6.19757921e-03f, 5.13109341e-02f,
  1.24595165e-02f, -6.19132863e-03f, -8.90108347e-02f, 2.41890207e-01f, 3.71430442e-02f, -8.81613940e-02f, 1.10532634e-01f, 5.34089319e-02f, -6.41840335e-04f, 1.24677256e-01f,
  6.78652003e-02f, -8.40077829e-03f, -1.07087471e-01f, 9.54310000e-02f, -1.18934348e-01f, 9.71185043e-02f, -1.24618858e-01f, 9.17921891e-04f, -4.45681810e-02f, 8.57592672e-02f,
  -1.45861143e-02f, 8.94281343e-02f, 3.26567590e-02f, -1.33062944e-01f, 1.48536367e-02f, -2.86055822e-02f, -1.76205769e-01f, 2.20794216e-01f, 4.78886068e-02f, -1.05546542e-01f,
  -1.51478961e-01f, -4.57170904e-02f, 2.22258475e-02f, 4.75308578e-03f, -1.39814410e-02f, 1.75543129e-01f, 3.21293712e-01f, 1.80182651e-01f, -1.54884845e-01f, 1.17582269e-01f,
  1.29593939e-01f, -1.02766864e-02f, -6.13021553e-02f, 5.45030870e-02f, -3.46273966e-02f, 9.10598487e-02f, -1.52909175e-01f, 9.18068513e-02f, 8.79770964e-02f, 1.65659741e-01f,
  1.11944757e-01f, 4.47932854e-02f, -8.12651590e-02f, 7.10769072e-02f, 1.71738237e-01f, 1.42919332e-01f, 6.13779156e-03f, -2.15068847e-01f, 4.84070815e-02f, -9.12803784e-03f,
  -1.99573144e-01f, -1.20293640e-01f, -4.95925695e-02f, 1.24918222e-01f, -1.04208766e-02f, 2.29538426e-01f, 1.27519771e-01f, 5.54850586e-02f, -1.98722202e-02f, 1.13010921e-01f,
  -3.35938483e-02f, -9.59909856e-02f, -4.77089360e-02f, -7.37252459e-02f, -1.11948505e-01f, -1.19657807e-01f, 7.66193122e-03f, 7.10878745e-02f, -2.43342388e-02f, 9.52638015e-02f,
  1.18169725e-01f, -4.43707919e-03f, -9.10913479e-03f, -1.29529759e-01f, 4.65748869e-02f, -7.25837275e-02f, 1.00655951e-01f, 1.18969195e-01f, 9.14274007e-02f, 8.35771933e-02f,
  7.42072761e-02f, -1.53911933e-01f, 6.39182255e-02f, 9.48820487e-02f, 2.81584561e-02f, -5.23174368e-02f, 3.58098075e-02f, -1.42022058e-01f, -1.44873515e-01f, -2.13225603e-01f,
  -1.63387671e-01f, -1.00080296e-01f, 3.29894200e-02f, -1.26646534e-01f, 1.00595728e-01f, 4.24124710e-02f, 1.73211381e-01f, 1.06339483e-02f, 1.07174024e-01f, -1.27672479e-01f,
  6.96633533e-02f, 1.74588375e-02f, -1.21371083e-01f, -1.09158047e-01f, 1.00153252e-01f, -1.40661031e-01f, 3.84423658e-02f, 1.09018654e-01f, 2.20902953e-02f, -1.62166134e-01f,
  -1.22662149e-01f, 1.57809407e-01f, -2.20228985e-01f, 2.06618384e-02f, -3.09782829e-02f, 1.02416471e-01f, -1.12523921e-02f, 3.19915712e-02f, -1.21515477e-02f, -3.23591605e-02f,
  -4.30503152e-02f, -1.57857448e-01f, -6.44719377e-02f, -4.27927636e-02f, 8.80426168e-03f, -1.26286715e-01f, -4.84496690e-02f, -1.67499006e-01f, -1.74066499e-01f, -1.61265939e-01f,
  8.10076818e-02f, -1.30931154e-01f, 1.58300959e-02f, -1.42141894e-01f, -4.36069742e-02f, -8.43211934e-02f, -3.34322057e-03f, 9.72954585e-05f, 9.87288877e-02f, 3.68985720e-02f,
  -1.05757071e-02f, -1.43211996e-02f, -1.80913061e-01f, -7.08884671e-02f, -8.33273530e-02f, -1.45181522e-01f, 9.22739804e-02f, -9.07935202e-02f, -8.48470777e-02f, -1.06020436e-01f,
  1.04856327e-01f, -8.14572945e-02f, -2.26947904e-01f, -6.44716099e-02f, 2.01349258e-01f, 1.53234705e-01f, 7.32802898e-02f, -6.07847758e-02f, 1.99542359e-01f, -8.40473548e-02f,
  -9.04036760e-02f, 1.14870794e-01f, 1.52055934e-01f, 2.98859384e-02f, 3.16920690e-02f, 1.20304517e-01f, -1.16463594e-01f, -1.50310723e-02f, 6.46540448e-02f, -4.67235968e-02f,
  -2.05039475e-02f, 8.76296218e-03f, 7.05546513e-02f, -3.36135626e-02f, -9.94680002e-02f, -2.86055170e-03f, 8.12337771e-02f, -1.96322739e-01f, 2.12646767e-01f, 1.17997511e-03f,
  -6.62603825e-02f, -8.58234055e-03f, 1.89987510e-01f, 1.37083173e-01f, 1.56847998e-01f, -7.80012608e-02f, 7.41022676e-02f, -8.68715271e-02f, -5.58379367e-02f, -1.18221350e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.23356062e-02f, 8.71069282e-02f, 1.90726042e-01f, 1.74477510e-03f, 2.48580761e-02f, 4.74146232e-02f, 2.44072929e-01f, 2.61005200e-03f, 4.86783348e-02f, 3.44038643e-02f,
  9.59329084e-02f, 2.41740659e-01f, 2.03075752e-01f, 2.09374756e-01f, 2.48662949e-01f, 6.09758087e-02f, 8.25234130e-02f, 9.87294130e-03f, -2.66386364e-02f, 8.68439153e-02f,
  3.78548913e-03f, 1.92761406e-01f, 1.89921185e-01f, 1.70694977e-01f, -8.34972505e-03f, 1.85072914e-01f, -3.05011607e-04f, -3.98298241e-02f, 2.20487267e-01f, 7.93655589e-02f,
  2.00405821e-01f, 2.89650708e-01f, 2.34540120e-01f, -1.88234895e-01f, -9.96812340e-03f, -2.11515948e-02f, 2.36945540e-01f, 2.72397757e-01f, -1.55029282e-01f, 2.34270826e-01f,
  2.19815210e-01f, 3.18337739e-01f, -1.11099124e-01f, 1.00674622e-01f, -1.02188691e-01f, -2.18472272e-01f, -3.88692804e-02f, 4.69155610e-02f, 7.87555575e-02f, -8.96238089e-02f,
  3.72306287e-01f, -2.95036554e-01f, 2.36076131e-01f, 2.29126900e-01f, 4.11282778e-02f, -2.34446228e-02f, 1.66678399e-01f, 1.20842911e-01f, -5.54381264e-03f, 1.29047083e-02f,
  7.78809860e-02f, 1.67125687e-02f, 6.80588260e-02f, 1.39067415e-02f, 8.96026045e-02f, 1.33801559e-02f, 5.60445376e-02f, 1.39681056e-01f, -1.50132934e-02f, 2.47430317e-02f,
  -3.51504348e-02f, -3.51958759e-02f, 2.14431100e-02f, 1.73975062e-02f, 8.51819441e-02f, -1.03662811e-01f, -7.67071396e-02f, 1.29356340e-01f, -1.47629939e-02f, 1.40392363e-01f,
  -3.16894390e-02f, 1.49513096e-01f, 1.04741842e-01f, -1.19322777e-01f, 6.50410131e-02f, 1.41786695e-01f, 8.13713148e-02f, 4.00657430e-02f, 1.49104238e-01f, 5.18536605e-02f,
  5.50719276e-02f, -2.04217702e-01f, -6.47754148e-02f, -3.42881233e-02f, 8.16425588e-03f, 9.91436765e-02f, -1.10527381e-01f, 1.22285403e-01f, 1.21626623e-01f, 1.07425870e-02f,
  -1.05776899e-01f, -1.00849636e-01f, -5.02831191e-02f, 9.72664133e-02f, -7.09958747e-02f, -1.38813287e-01f, 6.39507249e-02f, -3.41269188e-02f, -5.15840091e-02f, -8.60055387e-02f,
  6.93665296e-02f, -5.23366593e-02f, 1.15791475e-03f, 4.91252989e-02f, 1.04603395e-02f, 1.44160241e-01f, -7.28585199e-02f, -7.58771691e-03f, -5.69375679e-02f, 9.06649698e-03f,
  1.36668123e-02f, -1.00032844e-01f, -2.85970215e-02f, -4.32527205e-03f, -8.68442357e-02f, -9.55341160e-02f, -6.34438246e-02f, 1.15833193e-01f, 2.29130331e-02f, 2.26638183e-01f,
  1.32848784e-01f, 8.85891095e-02f, 4.58304547e-02f, 1.70668513e-01f, 1.20903797e-01f, -8.02234933e-03f, 5.91018163e-02f, 1.45703517e-02f, -8.72257818e-03f, 1.31939709e-01f,
  7.36237466e-02f, 1.49759904e-01f, -2.25670952e-02f, 1.89395875e-01f, 1.43867359e-01f, -4.61241193e-02f, 3.80003676e-02f, 1.07976072e-01f, 2.15496734e-01f, -1.67108960e-02f,
  1.68877155e-01f, 1.43931553e-01f, -7.24386126e-02f, 4.56060246e-02f, 1.69219300e-01f, 5.11948243e-02f, -1.36693895e-01f, -3.16043720e-02f, -1.62093475e-01f, -8.64655152e-02f,
  -2.10903361e-01f, 5.37758544e-02f, 1.00970693e-01f, 1.35485336e-01f, -3.18946451e-01f, -2.10378185e-01f, -8.67877752e-02f, -2.09458083e-01f, -8.81728530e-02f, 9.79600027e-02f,
  1.09725870e-01f, 2.02420488e-01f, 1.71769202e-01f, 7.06621706e-02f, -4.17734534e-02f, -6.70065433e-02f, 2.22920150e-01f, -1.29601419e-01f, 1.87559891e-02f, -2.28417739e-02f,
  1.03328809e-01f, -1.26522407e-01f, -2.62446459e-02f, 5.71190417e-02f, 1.16445176e-01f, 5.20044640e-02f, 1.81525499e-01f, -1.01553470e-01f, -3.61836590e-02f, -9.09905881e-02f,
  -1.77299678e-02f, -1.09754868e-01f, -3.01393550e-02f, 7.31013343e-02f, 1.11583911e-01f, -9.43152085e-02f, -1.27291456e-01f, 3.64665352e-02f, -5.66284359e-02f, 7.69971833e-02f,
  -1.12393878e-01f, -1.03389233e-01f, 3.97172682e-02f, 3.88363078e-02f, -1.75522733e-02f, -6.29453287e-02f, 3.59958261e-02f, -3.34419757e-02f, 1.16580069e-01f, 1.33051891e-02f,
  -9.08007473e-02f, -1.77753977e-02f, -3.99400592e-02f, -6.88375086e-02f, -8.03150535e-02f, -6.37051649e-03f, -7.41664693e-02f, 1.30931422e-01f, -6.77619278e-02f, 2.88918111e-02f,
  -1.64494459e-02f, 1.91557799e-02f, 1.19017504e-01f, -5.57681825e-03f, 1.05753846e-01f, -5.71242571e-02f, 3.03213987e-02f, 4.75410484e-02f, 3.87706645e-02f, 5.61870225e-02f,
  6.74786344e-02f, -3.25120129e-02f, -3.69692035e-02f, 1.09891675e-01f, -9.63762328e-02f, 6.42029047e-02f, 4.80581596e-02f, 5.65793812e-02f, -6.64562546e-03f, -4.91601266e-02f,
  -8.45136791e-02f, 6.22304752e-02f, -3.70023623e-02f, 5.71278716e-03f, -3.00066695e-02f, -7.53461123e-02f, 5.68260066e-02f, 1.13036800e-02f, 6.42903596e-02f, 6.65201172e-02f,
  -1.41791269e-01f, 3.03705540e-02f, -7.95801505e-02f, 5.62871359e-02f, 5.47110289e-02f, -5.73065281e-02f, -3.55032808e-03f, 1.99265614e-01f, 1.06525362e-01f, -3.16955782e-02f,
  -2.62934826e-02f, -3.87117527e-02f, 3.57299149e-02f, 1.48797050e-01f, 8.77142847e-02f, -2.60761734e-02f, 1.78246781e-01f, 6.19363040e-03f, -4.82566766e-02f, 1.54143736e-01f,
  -1.32351637e-01f, 1.86155409e-01f, 1.94519609e-01f, -4.53602672e-02f, -5.87127823e-03f, 2.07537055e-01f, 1.42268822e-01f, 3.74652781e-02f, 1.63858294e-01f, 3.48115265e-02f,
  1.87900752e-01f, -7.33497590e-02f, 1.01936467e-01f, 8.32751617e-02f, -1.75343573e-01f, -2.30107620e-01f, -2.51537949e-01f, -3.07856739e-01f, -8.66907388e-02f, 6.78162277e-02f,
  1.66508481e-01f, 1.55191019e-01f, -2.98985004e-01f, -1.19330876e-01f, 6.90685958e-02f, -2.90890872e-01f, -2.03389414e-02f, -2.10179552e-01f, 2.76771575e-01f, -6.15548193e-02f,
  1.41101107e-01f, 1.54261217e-01f, 1.02991171e-01f, 1.05459698e-01f, 1.42951116e-01f, -5.08163087e-02f, -1.43586919e-01f, 3.80583942e-01f, -2.43116051e-01f, -9.20702815e-02f,
  9.87934545e-02f, 1.26595879e-02f, 1.31966993e-01f, 1.01543367e-01f, 2.35389143e-01f, 3.16796795e-04f, -5.68053983e-02f, 2.53533363e-01f, 1.25648901e-01f, -1.12143345e-01f,
  2.23148555e-01f, -2.86958572e-02f, 7.64205307e-02f, 1.79241285e-01f, 1.03054345e-01f, 4.51523252e-02f, -1.00185245e-01f, 1.10424431e-02f, 1.38256643e-02f, 8.40841457e-02f,
  1.34229392e-01f, 3.45270708e-02f, -1.42528251e-01f, 1.81235895e-01f, 3.39674726e-02f, 2.51689255e-01f, 1.75368693e-02f, 1.65540293e-01f, 2.11250961e-01f, 4.42384370e-02f,
  8.57943222e-02f, 2.11649925e-01f, 8.59650448e-02f, 6.92919567e-02f, 2.77129769e-01f, -6.16851263e-02f, -7.09157810e-02f, -1.37034222e-01f, -2.14234710e-01f, -6.42493218e-02f,
  -1.53219536e-01f, -2.72172123e-01f, -1.88831598e-01f, 1.45257255e-02f, 2.41505429e-01f, 2.51803309e-01f, -1.81044847e-01f, -2.25595042e-01f, 1.17196567e-01f, -2.88683414e-01f,
  -1.67409062e-01f, 1.17881626e-01f, 2.57704496e-01f, 2.70719844e-04f, -6.72294497e-02f, 2.87217468e-01f, 1.86612591e-01f, 1.64928019e-01f, 2.30381429e-01f, 2.84725726e-02f,
  -9.60162580e-02f, 1.96438983e-01f, 5.16705103e-02f, 8.94424915e-02f, -5.71314096e-02f, -1.15937874e-01f, 1.65331781e-01f, 1.08091965e-01f, 2.17420027e-01f, -1.57373041e-01f,
  4.93708253e-02f, 1.45180017e-01f, 2.43014619e-02f, -1.26052335e-01f, -1.02326259e-01f, 5.14078848e-02f, -5.46066351e-02f, -1.02373876e-01f, -1.07103325e-01f, 3.17877717e-02f,
  5.97869605e-02f, -6.91455454e-02f, -8.45238641e-02f, -6.50935546e-02f, -9.14878547e-02f, -7.97846839e-02f, 6.78833127e-02f, 1.32508175e-02f, -8.22596997e-03f, -1.21898144e-01f,
  -1.08949967e-01f, -7.42550567e-02f, 4.27845381e-02f, 1.10557511e-01f, -6.11764751e-02f, -8.51168633e-02f, 1.21374525e-01f, -1.23202585e-01f, 5.65018691e-02f, 9.69038606e-02f,
  8.06304738e-02f, -4.85403351e-02f, 3.22634168e-02f, -5.55073237e-03f, 6.35191128e-02f, 3.56286578e-02f, -1.14866793e-01f, -3.06177568e-02f, 5.14598452e-02f, -5.56226633e-02f,
  1.06038660e-01f, 8.84021148e-02f, -1.09414987e-01f, 6.18553720e-02f, -9.63429213e-02f, 1.17753752e-01f, 4.08862606e-02f, -8.46170560e-02f, 1.15534766e-02f, 6.69372976e-02f,
  4.78258356e-02f, -7.70066530e-02f, -4.91938628e-02f, -8.01513493e-02f, -3.98509651e-02f, 2.01119017e-03f, 4.86866198e-03f, -4.69304956e-02f, 8.78509358e-02f, 7.18648918e-03f,
  1.97923426e-02f, 1.23581506e-01f, 7.27721751e-02f, 2.70055998e-02f, 8.45345110e-02f, -3.99323441e-02f, -9.25467163e-02f, 3.23332381e-03f, 3.03317625e-02f, 2.05135141e-02f,
  2.14666829e-01f, 2.55091228e-02f, 1.20595142e-01f, 1.15295731e-01f, 1.29701063e-01f, -4.50312905e-02f, -9.24826786e-02f, 2.11314484e-01f, 4.12223898e-02f, -1.05972663e-02f,
  5.41330054e-02f, 1.26686752e-01f, 1.36369690e-01f, 5.93256690e-02f, 2.08253771e-01f, -7.11081475e-02f, 6.58209920e-02f, 1.35577589e-01f, 7.69873112e-02f, 1.13980718e-01f,
  1.77433476e-01f, 6.08627498e-02f, 7.04214573e-02f, 1.51279882e-01f, 1.72900572e-01f, 2.64677763e-01f, 1.54044822e-01f, 6.58342838e-02f, -1.38409287e-01f, -5.95449731e-02f,
  -1.52883649e-01f, -3.36542241e-02f, -1.21142671e-01f, -2.10509941e-01f, -1.90328732e-01f, -6.55603185e-02f, -1.74583524e-01f, 5.16011268e-02f, 1.54288903e-01f, -1.96077168e-01f,
  2.65433472e-02f, 5.57124726e-02f, 9.99278501e-02f, -1.02360278e-01f, -1.26475021e-01f, 1.94381952e-01f, -4.84874398e-02f, -3.58663321e-01f, 1.26219854e-01f, -4.61185686e-02f,
  -2.14778751e-01f, -5.76508455e-02f, 1.03744291e-01f, 4.78834696e-02f, -7.78586268e-02f, -2.94641703e-02f, -1.22522779e-01f, 3.36825848e-01f, 1.23220645e-01f, 7.55066648e-02f,
  1.61455229e-01f, -2.15398669e-02f, 6.04980476e-02f, 4.05256338e-02f, 2.91623287e-02f, -7.38699138e-02f, 3.28172706e-02f, 1.10329986e-01f, 7.05313087e-02f, -5.71340648e-03f,
  -2.61663757e-02f, -5.29695256e-03f, -5.35750166e-02f, 1.12813868e-01f, 1.00989372e-01f, -7.80735016e-02f, -9.52027962e-02f, -9.48703736e-02f, 2.77165864e-02f, 6.93638325e-02f,
  1.11686312e-01f, 1.74828414e-02f, 2.41472013e-02f, 6.70822933e-02f, -6.77363994e-03f, 1.08227901e-01f, -9.58400443e-02f, 1.90346479e-01f, 1.53434217e-01f, 1.01428390e-01f,
  -1.49921373e-01f, -1.48422748e-01f, -8.94396752e-02f, 9.36131924e-02f, -6.90344870e-02f, -7.51772821e-02f, 2.29378529e-02f, -4.68692631e-02f, -1.08032301e-01f, 6.59613982e-02f,
  -9.48148817e-02f, 4.65139234e-03f, 4.27931063e-02f, -5.04732840e-02f, -7.39473328e-02f, -5.26790954e-02f, -8.59920010e-02f, -1.18867792e-01f, -9.90267657e-03f, -8.55207369e-02f,
  -7.59519115e-02f, -1.12297632e-01f, -9.61500481e-02f, 5.30740954e-02f, -5.00940438e-03f, -2.55456045e-02f, -1.27136009e-02f, 8.05521011e-02f, -2.33630352e-02f, -9.16489065e-02f,
  -6.37500361e-02f, 2.33940613e-02f, -9.21747386e-02f, -2.05881651e-02f, 8.55816454e-02f, 3.19534168e-02f, 1.47544965e-01f, 1.21955566e-01f, -4.11015637e-02f, 4.78830151e-02f,
  -1.39381196e-02f, -8.87651742e-02f, -4.85194400e-02f, 1.62852690e-01f, 4.90018800e-02f, 6.80631474e-02f, 8.44818428e-02f, 1.44338552e-02f, 4.49642763e-02f, -2.86407303e-02f,
  7.81366229e-03f, 1.52546436e-01f, 2.95161046e-02f, -1.30100131e-01f, -1.59014001e-01f, 1.84323967e-01f, 2.26547830e-02f, 1.18090082e-02f, 1.02430359e-01f, -2.13087797e-02f,
  8.57760161e-02f, -1.83665752e-01f, -4.32355404e-02f, 1.80923983e-01f, 1.22789830e-01f, 1.65727362e-01f, -1.91482797e-01f, -4.73818183e-03f, 1.25625595e-01f, -9.48828012e-02f,
  1.34743899e-01f, 4.34723161e-02f, -7.83686563e-02f, -1.74794182e-01f, 7.38567412e-02f, -1.63180903e-02f, -9.23312679e-02f, 1.44067228e-01f, 1.59933537e-01f, 9.39994752e-02f,
  -8.76193866e-02f, 1.38923883e-01f, 2.42641419e-01f, 2.28508368e-01f, 1.49590284e-01f, -1.04654498e-01f, 1.87523607e-02f, 2.16521397e-01f, -1.47564813e-01f, 3.25107127e-02f,
  7.25816488e-02f, 1.93525460e-02f, 2.38086060e-01f, 1.30173922e-01f, 2.39693403e-01f, -1.45149333e-02f, 5.32396324e-02f, 2.29672447e-01f, -2.51543596e-02f, -5.06117987e-03f,
  3.47844372e-03f, -1.40943974e-01f, 4.21032012e-02f, 5.29152900e-02f, 1.57265738e-01f, -3.29675190e-02f, -2.43925750e-02f, 7.63020068e-02f, 2.13083699e-02f, 4.95953187e-02f,
  3.90237197e-02f, -8.31169412e-02f, 1.06669506e-02f, 8.25215951e-02f, 1.17223866e-01f, 5.97363859e-02f, 8.89378227e-03f, 6.74419403e-02f, -7.80987740e-02f, -4.50608917e-02f,
  5.69909811e-03f, 1.33883923e-01f, 2.56744698e-02f, 4.00641374e-02f, 1.80053320e-02f, -2.46202555e-02f, -1.40348524e-01f, -1.57517493e-01f, 8.50370675e-02f, 1.28843307e-01f,
  2.17340767e-01f, 1.97259057e-02f, 2.54003793e-01f, -5.30854836e-02f, 6.16709962e-02f, -1.35463197e-02f, 2.27505416e-01f, 2.61013154e-02f, 8.51263106e-02f, 3.07660419e-02f,
  -9.46115032e-02f, 5.40510379e-02f, 4.26104926e-02f, -7.64439031e-02f, -2.93835141e-02f, 9.39640775e-02f, 1.27206678e-02f, -2.48613749e-02f, -1.82696104e-01f, 5.18418141e-02f,
  1.99397877e-01f, 9.86626595e-02f, 2.37845168e-01f, 6.88483119e-02f, 1.24594487e-01f, 1.76056121e-02f, -7.99571574e-02f, -8.64177663e-03f, 6.45069480e-02f, 9.83044282e-02f,
  1.25475764e-01f, 4.22436334e-02f, 5.85029423e-02f, 1.08757615e-01f, 8.71172845e-02f, 1.11997992e-01f, -5.09131104e-02f, 1.26417717e-02f, 1.49011454e-02f, -3.22812721e-02f,
  -4.69237901e-02f, 2.20674966e-02f, 3.43072377e-02f, -1.49253374e-02f, -2.33591367e-02f, -5.33506647e-02f, -1.56911284e-01f, 8.74192491e-02f, 2.72747204e-02f, 1.40845180e-01f,
  -1.11613639e-01f, -6.67357147e-02f, 5.66494688e-02f, -9.09749418e-02f, -7.93762226e-03f, 1.49990901e-01f, 9.47041661e-02f, 6.37452751e-02f, 3.15408073e-02f, -1.18759714e-01f,
  -8.48196968e-02f, -1.29974887e-01f, 1.79675538e-02f, -1.28702283e-01f, 8.21507201e-02f, -1.03948027e-01f, -1.02608413e-01f, 1.25673890e-01f, 2.00995672e-02f, 1.62924781e-01f,
  5.12105711e-02f, -2.40034703e-02f, 4.77326959e-02f, 2.80406531e-02f, 1.78574659e-02f, 5.18990979e-02f, 2.78813485e-02f, 9.45798159e-02f, -1.21708550e-02f, 1.61102816e-01f,
  -7.12888315e-02f, 2.53474098e-02f, 1.91946104e-02f, -2.50224490e-02f, -1.48753747e-01f, 2.21800476e-01f, -2.80666631e-02f, 4.97464761e-02f, 1.22505739e-01f, -1.14077646e-02f,
  -3.08388975e-02f, 1.54814079e-01f, -9.90006141e-04f, -3.57697047e-02f, -4.03884426e-02f, 1.13409027e-01f, 6.42305538e-02f, 3.75758223e-02f, -1.58366393e-02f, -7.65321031e-02f,
  1.06643863e-01f, 1.34385303e-02f, -9.11146551e-02f, 3.53753543e-03f, -8.32008272e-02f, -8.17870572e-02f, 3.37542966e-02f, -8.96159858e-02f, 9.16222334e-02f, 7.98649713e-02f,
  -7.90370852e-02f, -4.27466705e-02f, -6.02008738e-02f, -7.71338046e-02f, -1.21268541e-01f, 5.46416529e-02f, -7.95083195e-02f, -1.17830388e-01f, 5.61277866e-02f, 6.35966137e-02f,
  -3.17698233e-02f, 2.05672579e-03f, -4.58138548e-02f, -9.11786258e-02f, 1.06825046e-01f, 2.49435809e-02f, -1.03587694e-01f, -4.16364819e-02f, -8.29185639e-03f, -8.33986625e-02f,
  1.10561363e-01f, -4.59324308e-02f, 7.65347183e-02f, -4.41290326e-02f, 5.92535399e-02f, -1.49636082e-02f, 6.41212985e-02f, 2.12448835e-02f, -4.11614627e-02f, -5.94942272e-02f,
  -5.97453862e-03f, -1.21184476e-01f, -5.39997295e-02f, 7.48041719e-02f, 3.24975559e-03f, -6.81845620e-02f, 1.84368230e-02f, 2.42048874e-02f, 5.66241667e-02f, 9.83893871e-02f,
  8.24903995e-02f, 2.06770543e-02f, 3.14691700e-02f, -2.05110498e-02f, 8.41123462e-02f, -1.02393866e-01f, -9.62155834e-02f, -3.33998948e-02f, 5.52888177e-02f, -1.25319839e-01f,
  1.14637264e-03f, 7.87819326e-02f, -9.66235474e-02f, 1.15310643e-02f, 9.34369117e-02f, 8.27278048e-02f, 4.70185205e-02f, 4.66849729e-02f, 1.70540184e-01f, 5.88181242e-02f,
  1.17186897e-01f, 5.63929342e-02f, 1.24453567e-01f, 1.20476909e-01f, -1.85720772e-02f, 1.14395589e-01f, -8.93792510e-02f, -1.72044635e-02f, 2.37482876e-01f, 3.01912092e-02f,
  3.68694961e-02f, 1.66121215e-01f, 1.31934285e-01f, 1.26611620e-01f, 8.44693482e-02f, 6.25219718e-02f, -6.27536178e-02f, 5.15789054e-02f, -5.75300157e-02f, -1.44327000e-01f,
  -1.57120973e-01f, 1.05420137e-02f, 7.65552521e-02f, 1.55310892e-02f, -3.01121492e-02f, 5.40825166e-02f, 6.25406951e-02f, -1.45525753e-01f, -1.79160446e-01f, 6.07055463e-02f,
  -1.23102598e-01f, 1.27912566e-01f, 1.17646530e-01f, -1.58343032e-01f, -1.23353601e-01f, 6.29031807e-02f, 1.05090961e-01f, 6.58005774e-02f, -5.07193878e-02f, 2.64107455e-02f,
  -1.21218786e-01f, -9.92784500e-02f, -1.20699458e-01f, 4.19074949e-03f, -5.41312546e-02f, -4.58268747e-02f, 1.07959881e-01f, 1.04720354e-01f, -1.27309188e-01f, -6.79402128e-02f,
  -6.40428998e-03f, 2.58354172e-02f, -1.26016438e-01f, -9.18894485e-02f, 1.14799537e-01f, -4.16001379e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.23231509e-01f, 7.93091506e-02f, 4.87473458e-02f, -1.20112211e-01f, 5.71006685e-02f, 2.82994136e-02f, 7.20523894e-02f, 1.61932901e-01f, -1.10469409e-03f, 6.21044599e-02f,
  6.90473318e-02f, 6.74368367e-02f, 8.26098993e-02f, -2.67146043e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -2.63472609e-02f, 1.53233603e-04f, -4.90980111e-02f, -2.46033221e-02f, -4.86019701e-02f, -2.70953914e-03f, 1.80991203e-01f, -7.75476024e-02f, 2.71652006e-02f, 1.07248589e-01f,
  -1.19620487e-01f, 1.10502392e-01f, 1.27639323e-01f, 1.20525651e-01f, 4.08760943e-02f, 1.25043780e-01f, 1.82882741e-01f, 1.10316858e-01f, -9.21191573e-02f, 3.54329348e-02f,
  8.13855454e-02f, -7.90716894e-03f, 9.02392492e-02f, 6.39309958e-02f, -1.12608679e-01f, -6.31519184e-02f, 9.60168391e-02f, 9.97700021e-02f, 2.46174950e-02f, 7.06475452e-02f,
  1.38880461e-01f, 6.66142851e-02f, 3.63065563e-02f, 2.35744435e-02f, 2.95386985e-02f, 1.38584971e-01f, 1.11816078e-01f, 1.20699733e-01f, 4.00761738e-02f, 1.36396408e-01f,
  1.58636365e-02f, -6.15401566e-02f, -1.19124450e-01f, 1.40864864e-01f, -6.73698261e-03f, 2.75055077e-02f, 2.56339252e-01f, 1.95151940e-01f, -1.71353161e-01f, 2.60509923e-02f,
  7.78552815e-02f, -5.71394414e-02f, -1.14199504e-01f, -2.98183523e-02f, -5.87072261e-02f, -2.95109689e-01f, -1.26070589e-01f, 2.99107730e-01f, 6.33304417e-02f, -9.46174115e-02f,
  -1.50433062e-02f, -6.68491647e-02f, -8.55166763e-02f, -3.85624133e-02f, -2.79131327e-02f, 3.02775204e-02f, -6.92131966e-02f, -7.23575652e-02f, 1.83955599e-02f, 1.26823574e-01f,
  -9.87968966e-02f, 7.27670267e-02f, -1.16355948e-01f, 6.14441894e-02f, -4.23422679e-02f, -2.38725115e-02f, 5.80869392e-02f, 5.60464859e-02f, 1.36795007e-02f, -9.12409574e-02f,
  -7.72192925e-02f, -7.93140307e-02f, -5.06178476e-02f, 7.60153830e-02f, -1.65023282e-01f, 9.18636620e-02f, -5.19177020e-02f, -5.60900420e-02f, -2.46579070e-02f, 1.53313011e-01f,
  -1.28922418e-01f, -1.22916795e-01f, 1.31129632e-02f, -1.48493871e-01f, -1.26178145e-01f, -1.00041023e-02f, 4.68873233e-02f, 4.18661349e-02f, -1.89666897e-01f, -4.85572331e-02f,
  -1.63130641e-01f, -4.00386825e-02f, 7.82295987e-02f, 2.24971384e-01f, 5.16343908e-03f, 1.44524351e-01f, -9.70545933e-02f, -1.27290189e-02f, 3.93738635e-02f, -1.18322842e-01f,
  2.16581882e-03f, -5.75027280e-02f, -5.81682213e-02f, 5.75235337e-02f, 2.30678335e-01f, -8.68759379e-02f, 1.06159829e-01f, 9.43806246e-02f, -1.99979022e-01f, -1.30860552e-01f,
  4.92984205e-02f, -1.35293275e-01f, 3.89043838e-02f, -8.35836753e-02f, 2.28291843e-02f, -8.20847973e-02f, -5.28038740e-02f, 9.34119076e-02f, -9.42451805e-02f, 7.04740509e-02f,
  -2.20377833e-01f, -3.85285658e-03f, -2.12198660e-01f, 8.42661113e-02f, -2.37024333e-02f, 1.77872032e-02f, 9.14689079e-02f, -7.43865669e-02f, -2.10649550e-01f, -7.53290728e-02f,
  1.34179398e-01f, 7.64464363e-02f, -5.65872230e-02f, 6.92390651e-02f, 4.03390862e-02f, 4.47017774e-02f, 4.30695042e-02f, -6.17550462e-02f, -4.28921804e-02f, 2.08461378e-02f,
  -3.65194269e-02f, 2.58558765e-02f, 9.94950011e-02f, -2.63821065e-01f, -1.43550739e-01f, -1.98382944e-01f, -1.02305502e-01f, 9.66809541e-02f, 1.58831224e-01f, 1.61683097e-01f,
  -2.39645913e-01f, 3.32984477e-02f, 9.55190659e-02f, -9.98533368e-02f, -1.33222729e-01f, -1.82822466e-01f, -6.42468361e-03f, -5.70064858e-02f, -1.65786177e-01f, 6.63426369e-02f,
  1.50648698e-01f, -1.29141182e-01f, 1.24245845e-01f, -1.53758645e-01f, -1.91953480e-01f, 3.75312157e-02f, -5.00957035e-02f, 2.20435902e-01f, -1.82733163e-02f, 7.47479126e-02f,
  1.94130003e-01f, 1.10727534e-01f, 7.00870156e-02f, 1.22855298e-01f, 1.61240231e-02f, -1.42183274e-01f, -1.01567671e-01f, 2.75493354e-01f, 3.23843323e-02f, 6.73846826e-02f,
  9.38126817e-03f, -1.75864443e-01f, 4.67046015e-02f, -4.98591214e-02f, -3.54078785e-02f, 1.08549990e-01f, -1.72664151e-01f, -7.44915232e-02f, -6.02473095e-02f, 4.17710803e-02f,
  -9.79121700e-02f, 1.42931007e-02f, -8.10204893e-02f, 8.71062949e-02f, -1.07952654e-01f, 3.00296326e-03f, -5.22816880e-03f, 3.83064933e-02f, -9.80506614e-02f, 7.99963325e-02f,
  3.39024328e-02f, -4.13967893e-02f, -9.41384807e-02f, 1.32568274e-02f, 4.85746637e-02f, 9.46661271e-03f, -1.23769179e-01f, -5.91315851e-02f, -1.45618975e-01f, -1.32352766e-02f,
  3.99939194e-02f, 1.54760927e-02f, 1.44005403e-01f, 2.84021534e-02f, -2.26100132e-01f, -5.14885858e-02f, 6.76462129e-02f, -6.93936646e-02f, -1.85830057e-01f, -3.07087712e-02f,
  -4.71311957e-02f, -1.78160384e-01f, -1.36268780e-01f, 1.29346892e-01f, 8.36121514e-02f, -1.30007993e-02f, -4.71410751e-02f, -2.25121319e-01f, -2.06262589e-01f, -1.06588259e-01f,
  1.57545879e-01f, 9.06726941e-02f, -2.42932960e-01f, 2.93553285e-02f, 1.59454614e-01f, 3.07171959e-02f, 2.13369727e-01f, 2.63429552e-01f, -1.03138737e-01f, -1.41029149e-01f,
  5.30007072e-02f, 1.58230200e-01f, 7.94762596e-02f, 1.36584282e-01f, 8.15351456e-02f, -2.63955630e-02f, -1.10790618e-02f, -1.41718447e-01f, -4.84606018e-04f, 1.32458553e-01f,
  1.45242540e-02f, -1.07370250e-01f, 1.16084285e-01f, -8.73370320e-02f, 1.28940880e-01f, -1.42264113e-01f, -1.77194387e-01f, -1.62374854e-01f, -6.10410385e-02f, 2.99014337e-02f,
  -1.27895236e-01f, 2.10748496e-03f, -1.35515733e-02f, 9.08809006e-02f, 8.43357444e-02f, 1.37070790e-01f, 9.71845463e-02f, 8.89310613e-02f, -6.95914999e-02f, -1.72141969e-01f,
  1.89829856e-01f, -1.59454376e-01f, 2.50353217e-01f, 2.89154053e-01f, -9.91780013e-02f, -2.81645626e-01f, 1.68157071e-02f, -2.08765566e-01f, 2.31500700e-01f, -5.99104352e-02f,
  -3.03304475e-02f, 1.40762538e-01f, 3.03930845e-02f, -2.70779431e-02f, 2.36357629e-01f, 1.67244777e-01f, -1.49941772e-01f, -2.36940220e-01f, 1.66356668e-01f, -8.22978094e-02f,
  1.24271512e-01f, 7.32210800e-02f, 1.24470264e-01f, 1.36392593e-01f, -1.32167175e-01f, 1.38171285e-01f, 2.65956342e-01f, -3.59667465e-02f, -3.13880175e-01f, -3.11993081e-02f,
  -1.38712808e-01f, -1.39325783e-01f, 2.86560934e-02f, -7.34550878e-02f, -1.14642367e-01f, -3.20196711e-02f, -3.11656464e-02f, 8.02598819e-02f, -2.85529252e-02f, -9.43414122e-02f,
  -1.62983611e-02f, 3.09943175e-03f, -7.84614012e-02f, -4.39444147e-02f, 1.24620400e-01f, -9.35046449e-02f, -5.32898940e-02f, -1.07524991e-01f, 1.56475548e-02f, 4.42371741e-02f,
  -5.55324182e-03f, 4.20415811e-02f, -7.53694773e-02f, 3.39511260e-02f, 3.63088883e-02f, -3.79468836e-02f, 1.26990244e-01f, -5.08262217e-02f, 2.37634014e-02f, -9.97327864e-02f,
  -1.32561103e-02f, -7.41098598e-02f, 1.37472540e-01f, 7.36117829e-03f, 4.34908643e-02f, 1.89752936e-01f, 9.99196246e-02f, 9.01123732e-02f, 1.83349866e-02f, 5.42441979e-02f,
  1.36347031e-02f, 2.03453773e-03f, 2.02781767e-01f, -6.07606731e-02f, 8.42370167e-02f, 4.33192328e-02f, 3.37429084e-02f, 2.42874548e-01f, 1.60776973e-02f, 2.37750620e-01f,
  2.33980119e-01f, 2.04957817e-02f, -1.73418745e-01f, 1.74650371e-01f, -9.00179073e-02f, 2.30334610e-01f, 1.74208596e-01f, 7.37765506e-02f, -1.72476292e-01f, -1.40738368e-01f,
  6.01626784e-02f, -1.15912423e-01f, 7.58567918e-03f, 6.65778667e-02f, -1.91077128e-01f, -2.76707947e-01f, 7.21535161e-02f, 2.66653866e-01f, 4.31541689e-02f, -1.37982965e-01f,
  7.14373440e-02f, -7.72944614e-02f, 1.54165179e-02f, 4.44935970e-02f, -2.79086307e-02f, -2.30892748e-02f, 8.22491944e-02f, -9.43848565e-02f, 1.59529328e-01f, 1.25676349e-01f,
  1.01644054e-01f, -2.80480515e-02f, 5.12417704e-02f, 1.33943960e-01f, 8.74842331e-03f, -1.04527891e-01f, 7.57132918e-02f, 6.24462515e-02f, -2.77627930e-02f, 9.75394621e-03f,
  9.03604478e-02f, -7.16338977e-02f, -7.90309161e-02f, 6.61536306e-02f, 8.96408930e-02f, 3.59762944e-02f, -1.46602408e-03f, 5.97361140e-02f, 7.14024808e-03f, -8.90248269e-03f,
  -8.78770426e-02f, -1.82064101e-01f, -1.20380409e-02f, 2.13351414e-01f, 7.69611150e-02f, -1.68249104e-02f, -1.87208876e-01f, 5.14327660e-02f, 2.20584393e-01f, 3.26390304e-02f,
  -7.56966174e-02f, 5.31677343e-02f, -1.56328574e-01f, -2.25886256e-01f, -1.06906421e-01f, -9.06088129e-02f, -3.02287489e-02f, -2.25152541e-02f, 3.11514508e-04f, 4.92681488e-02f,
  2.29628216e-02f, 1.60087064e-01f, -5.92488311e-02f, 5.03983609e-02f, -3.66596460e-01f, -1.09758209e-02f, 2.24684417e-01f, 2.85936799e-03f, 2.96501726e-01f, 2.01770708e-01f,
  -3.77877951e-02f, 1.12857908e-01f, 7.48763308e-02f, 1.09987207e-01f, -3.93850431e-02f, -9.12225097e-02f, -6.18371293e-02f, -7.69833848e-02f, -4.16963696e-02f, 1.61221370e-01f,
  8.99039060e-02f, -1.30961657e-01f, -1.94312856e-02f, 5.02216630e-02f, -9.30975378e-02f, 7.71770552e-02f, -1.41151249e-01f, -1.35466814e-01f, 1.87814265e-01f, -5.90229314e-03f,
  8.24832544e-02f, 5.79032525e-02f, 3.86772789e-02f, 5.95301688e-02f, -1.20936327e-01f, -3.40182654e-04f, 5.39942123e-02f, 3.59398909e-02f, 1.82091087e-01f, -7.55550638e-02f,
  1.75138667e-01f, 8.81253034e-02f, 4.64971997e-02f, 3.33779790e-02f, -4.10605893e-02f, -2.35586315e-01f, 9.19676274e-02f, 6.76739262e-03f, -1.06091634e-03f, 2.87788451e-01f,
  -3.35412063e-02f, 6.54263124e-02f, 9.59966928e-02f, -6.36040345e-02f, -2.05654770e-01f, -1.26750648e-01f, -5.45185134e-02f, -2.10359052e-01f, 3.48890908e-02f, 1.90664843e-01f,
  9.36076045e-02f, 4.62349467e-02f, -1.08052462e-01f, -3.49944644e-02f, -1.84588432e-01f, -2.77383272e-02f, 1.25071183e-01f, -2.10538447e-01f, -2.01056346e-01f, 1.70385048e-01f,
  2.71920502e-01f, -5.92604221e-04f, 1.75607845e-01f, 2.71315038e-01f, -8.70805085e-02f, -1.32576495e-01f, -1.11771505e-02f, -4.28467579e-02f, -6.35646880e-02f, 1.65679127e-01f,
  -4.67734858e-02f, -7.44036341e-04f, 1.59455672e-01f, -1.21287696e-01f, 9.00752470e-03f, -1.14124261e-01f, -3.71551663e-02f, 3.52142774e-03f, 9.38832611e-02f, 1.05008259e-01f,
  1.89437009e-02f, -5.28140925e-02f, -1.06006980e-01f, -9.20897350e-02f, -1.58744678e-02f, 2.08506919e-02f, 2.14836616e-02f, 2.95061339e-02f, 7.25713372e-02f, -5.43051101e-02f,
  8.55588913e-02f, -8.16158857e-03f, 2.93928068e-02f, 8.64504203e-02f, -1.41764149e-01f, -2.88351420e-02f, 8.94898549e-02f, -1.33067295e-01f, 1.06065378e-01f, 1.00656725e-01f,
  -6.96504712e-02f, -1.94975898e-01f, 8.35369080e-02f, -3.37766074e-02f, -3.56206261e-02f, -1.07567832e-01f, -2.17288524e-01f, 1.34788841e-01f, -1.04674280e-01f, -2.45042637e-01f,
  3.39320228e-02f, -2.34157755e-03f, -2.39076883e-01f, 1.73607856e-04f, 2.66977459e-01f, -1.89278662e-01f, 1.33111313e-01f, -2.20562264e-01f, 3.91891152e-02f, -1.14778308e-02f,
  -1.20391279e-01f, 2.12717757e-01f, 1.48857191e-01f, -8.78539607e-02f, -1.27797723e-01f, 1.53303100e-03f, -6.35927618e-02f, -7.14429244e-02f, -5.13280788e-03f, -2.53551424e-01f,
  -1.43995598e-01f, 2.20612556e-01f, 2.84581572e-01f, 1.41544014e-01f, -1.16963528e-01f, -2.56706387e-01f, 3.41631100e-02f, -1.15526449e-02f, -8.25334638e-02f, -5.21716587e-02f,
  1.51888892e-01f, 1.27808690e-01f, 2.26503327e-01f, 3.08976658e-02f, -1.05567016e-01f, -1.00865047e-02f, -1.24673747e-01f, -7.55941048e-02f, -8.26384798e-02f, -3.39482725e-02f,
  1.89302079e-02f, 1.55368093e-02f, 8.98978263e-02f, 9.65108797e-02f, -7.38034695e-02f, 5.84435128e-02f, 7.17285499e-02f, 1.87626351e-02f, -1.37461042e-02f, -9.55282301e-02f,
  1.17357984e-01f, 3.66786458e-02f, 2.55824238e-01f, 2.88677961e-01f, 1.11282520e-01f, -2.77829081e-01f, -4.74922433e-02f, -4.18981053e-02f, 1.21629275e-01f, -1.81493102e-04f,
  -1.95376575e-01f, 1.62798434e-01f, 1.52242973e-01f, -1.29925758e-01f, 2.12347716e-01f, 2.44565353e-01f, -1.65403128e-01f, -1.23041175e-01f, 1.24752499e-01f, -1.29452333e-01f,
  8.96157399e-02f, -9.44971368e-02f, 1.29915625e-01f, 8.89851712e-03f, -2.01072946e-01f, 1.99546978e-01f, 3.37203681e-01f, -4.58404161e-02f, -8.51804093e-02f, -6.06559850e-02f,
  -2.59655297e-01f, -2.58050352e-01f, -2.59772725e-02f, -7.30010495e-02f, 2.55132560e-02f, 5.16003929e-02f, 1.48879290e-01f, -1.39808923e-01f, -7.04371259e-02f, -1.42544731e-01f,
  1.69309065e-01f, -9.34567079e-02f, -2.50466503e-02f, -4.88217473e-02f, 9.22986940e-02f, 1.13293022e-01f, 4.32805531e-02f, -3.63384075e-02f, 1.86554808e-02f, -1.15167489e-03f,
  -1.56098492e-02f, -7.25531876e-02f, -1.90166924e-02f, -8.87037721e-03f, 3.76055017e-02f, 1.41713172e-01f, 1.50859598e-02f, -2.88857389e-02f, -4.42867987e-02f, -1.27624825e-03f,
  3.30240303e-03f, -2.49892063e-02f, 9.73632708e-02f, 2.34718397e-02f, -5.02901450e-02f, -1.43101607e-02f, 8.84485915e-02f, 2.37413406e-01f, 1.36137143e-01f, -2.50169337e-01f,
  -6.34807572e-02f, -2.52946109e-01f, 3.93655822e-02f, -1.08600758e-01f, -1.94650874e-01f, 1.61674052e-01f, -5.54002076e-02f, 9.66303516e-03f, 1.13994978e-01f, 1.70585200e-01f,
  6.61332207e-03f, -8.68979171e-02f, -1.31494358e-01f, -3.18280309e-02f, 2.60989461e-02f, -6.62624985e-02f, 1.12147182e-01f, -1.61710262e-01f, 1.00899927e-01f, 1.91857927e-02f,
  2.62204647e-01f, -6.28684163e-02f, -1.62541404e-01f, -6.75618229e-03f, -3.27772915e-01f, -1.97709844e-01f, -2.32742005e-03f, 4.34436388e-02f, -7.48428851e-02f, -1.44326493e-01f,
  7.47291744e-02f, 9.97303352e-02f, -7.86412805e-02f, -2.56890580e-02f, -1.25878707e-01f, 1.41381219e-01f, 9.78947729e-02f, -1.02248825e-01f, -8.04616734e-02f, -1.15121521e-01f,
  -8.57503042e-02f, 9.81355011e-02f, -2.18887568e-01f, -1.72627702e-01f, -3.90605591e-02f, -5.92819788e-02f, -9.49513018e-02f, -4.85964082e-02f, -1.03608459e-01f, 7.35115036e-02f,
  -1.53972208e-01f, -8.51725489e-02f, -1.05069697e-01f, 1.07883058e-01f, 6.95576370e-02f, 4.40836931e-03f, 4.01546992e-02f, 4.53150906e-02f, 1.45620868e-01f, -1.93805639e-02f,
  -3.91268395e-02f, 6.43215328e-02f, -7.85769299e-02f, -1.91774264e-01f, 4.72356305e-02f, 2.30148807e-01f, -1.52313426e-01f, -9.25439131e-03f, -1.83638752e-01f, 5.19960746e-02f,
  -7.15141371e-03f, -2.85747349e-01f, -3.92569862e-02f, -5.27864434e-02f, -1.15859210e-01f, 2.16067255e-01f, 2.71272987e-01f, -1.48644432e-01f, -1.16075911e-01f, -2.40800112e-01f,
  -6.84021935e-02f, -3.23083848e-02f, -7.82281011e-02f, 1.84777066e-01f, 1.29240319e-01f, 3.24564688e-02f, 9.72942449e-04f, -1.00021400e-01f, -1.25820860e-01f, 1.63254306e-01f,
  5.66812418e-02f, -3.81748199e-01f, -3.60418446e-02f, -2.45547034e-02f, 1.20611978e-03f, 5.38851991e-02f, 3.34086604e-02f, -1.74805567e-01f, -1.71230137e-01f, 6.19399585e-02f,
  -1.36882365e-01f, 4.55282293e-02f, -6.64472505e-02f, 9.15432945e-02f, -1.03018209e-01f, -4.65278368e-04f, 3.39625217e-02f, 7.73036182e-02f, -3.14523838e-02f, -1.05345353e-01f,
  3.79041657e-02f, -1.31092206e-01f, -5.41819520e-02f, -1.24827467e-01f, -1.50904104e-01f, 5.66553557e-03f, 6.25783950e-02f, -1.13044135e-01f, -1.64690111e-02f, 1.14318892e-01f,
  -3.65107767e-02f, -6.64905384e-02f, -1.68535888e-01f, 1.76870413e-02f, -1.82068735e-01f, -2.70651788e-01f, -1.19608931e-01f, 1.86584890e-01f, 1.61976144e-01f, 4.95540574e-02f,
  -1.02425843e-01f, 8.97661597e-02f, 1.68107525e-01f, -8.38906541e-02f, -1.38081565e-01f, 1.34459212e-01f, -2.27351606e-01f, -8.35450646e-03f, 4.03798148e-02f, -2.18776911e-02f,
  9.63300001e-04f, 5.62042408e-02f, -8.53931978e-02f, 3.58057022e-02f, 1.49329985e-02f, 4.52182963e-02f, 5.38401045e-02f, 4.85126264e-02f, -4.23647642e-01f, 1.82958156e-01f,
  1.27504364e-01f, -9.33304578e-02f, 2.86425114e-01f, -6.61385879e-02f, 1.26851261e-01f, 1.26770556e-01f, -2.75912099e-02f, -4.69785407e-02f, 7.32733123e-03f, 1.01834029e-01f,
  -1.06148332e-01f, 5.70603125e-02f, -2.52518896e-02f, -9.76231247e-02f, -9.90951359e-02f, 1.54116377e-01f, 1.27850950e-01f, 1.27990052e-01f, 9.28123295e-02f, -1.59857526e-01f,
  -1.78491566e-02f, 9.76620167e-02f, -1.07834205e-01f, -1.12837866e-01f, -3.55550051e-02f, -2.78921332e-02f, 8.90150070e-02f, -2.36945804e-02f, 1.48017868e-01f, -6.22980334e-02f,
  8.57146084e-02f, 1.07483797e-01f, 4.41754535e-02f, 3.64467874e-02f, -1.43784001e-01f, -5.03966510e-02f, -9.15247127e-02f, -2.43195653e-01f, -8.37750882e-02f, 1.52168393e-01f,
  -5.34154698e-02f, -6.36265054e-02f, -1.95568465e-02f, 5.78619773e-03f, 1.27567843e-01f, 1.51285946e-01f, -1.44053595e-02f, 1.43785626e-01f, 1.17047347e-01f, 1.30199596e-01f,
  -9.96301472e-02f, -1.43766344e-01f, -1.03624955e-01f, -1.68458879e-01f, -4.39723171e-02f, -4.85937335e-02f, 1.23357691e-01f, 3.57800871e-02f, -1.89242661e-02f, 2.50704944e-01f,
  -1.41116306e-01f, -2.55811606e-02f, -1.33562684e-02f, -1.83670402e-01f, -4.84096557e-02f, -2.91721001e-02f, 1.23981759e-01f, 8.92756358e-02f, 4.82248105e-02f, 7.71089792e-02f,
  8.00377056e-02f, 1.05382249e-01f, -5.06505668e-02f, 3.42988819e-02f, 4.91240919e-02f, -6.02458976e-02f, -1.32864788e-01f, -1.61809400e-01f, -1.53763026e-01f, 2.49022450e-02f,
  -2.21999735e-01f, -6.82200268e-02f, -6.93419352e-02f, -1.48606405e-01f, -1.50142265e-02f, 7.83117115e-02f, -1.91957057e-01f, -1.07987896e-01f, 3.94032560e-02f, -5.20845503e-02f,
  -8.02518651e-02f, -3.48627791e-02f, 1.04387864e-01f, -3.25359218e-02f, -9.92001221e-02f, 1.29617658e-03f, -2.37188246e-02f, -1.94732528e-02f, -1.85464583e-02f, -2.94751078e-02f,
  -6.54358938e-02f, -1.85981706e-01f, -1.53450266e-01f, -1.63182780e-01f, -9.21368748e-02f, 1.76811919e-01f, 9.83656719e-02f, -3.94469760e-02f, -1.78063512e-01f, 5.23031950e-02f,
  -4.32521664e-02f, -8.23595226e-02f, -9.84460637e-02f, -1.53711453e-01f, -4.56301123e-02f, -4.09020483e-02f, -5.23843095e-02f, 1.37483347e-02f, 6.46392033e-02f, -7.41884112e-02f,
  2.51671532e-03f, -2.60567427e-01f, -8.35019425e-02f, 4.57253866e-02f, -3.51293311e-02f, -5.27517078e-03f, -1.22101031e-01f, -3.73777784e-02f, 9.07070711e-02f, -2.51610354e-02f,
  1.32408097e-01f, 6.87844008e-02f, -5.05560152e-02f, -1.40145481e-01f, -1.51061537e-02f, 1.45672306e-01f, 1.04077131e-01f, -1.64871048e-02f, -9.16815624e-02f, -1.84215933e-01f,
  1.23189297e-02f, -2.04125836e-01f, -1.25143379e-01f, 4.90011312e-02f, -7.69734830e-02f, 9.96646732e-02f, 1.32368347e-02f, -1.31203026e-01f, 1.95950106e-01f, 1.61766380e-01f,
  -1.56425815e-02f, -1.40157670e-01f, 1.62869215e-01f, -1.48966730e-01f, 1.78519543e-02f, -1.80683564e-02f, -4.59012687e-02f, 6.97362199e-02f, -3.95586416e-02f, 1.15130208e-01f,
  -6.88630566e-02f, -1.99502453e-01f, 8.24687853e-02f, 3.37064196e-03f, -1.72109529e-02f, -1.08369417e-01f, 7.98882023e-02f, 1.82585180e-01f, -2.14846507e-02f, 1.58770546e-01f,
  1.21780217e-01f, -2.72593737e-01f, -1.12088695e-01f, -1.08887507e-02f, 1.28778204e-01f, 1.42149717e-01f, 1.57463282e-01f, 1.48250088e-01f, 7.46240690e-02f, -2.48295963e-01f,
  -6.26417622e-02f, -1.51635274e-01f, -1.00612700e-01f, -3.61644775e-02f, -8.06498900e-02f, 8.27885494e-02f, 1.14071228e-01f, 2.15846580e-02f, -1.17229737e-01f, -1.41261309e-01f,
  -2.19765857e-01f, 4.15604413e-02f, -1.30811647e-01f, 3.43947113e-02f, 1.00791447e-01f, 9.06000659e-03f, -5.15337922e-02f, 2.55162776e-01f, -1.61270332e-02f, 1.70197919e-01f,
  -1.82651542e-02f, 8.14026520e-02f, -3.90475430e-02f, -9.86889079e-02f, -7.81020001e-02f, 1.36915535e-01f, 1.45126078e-02f, -4.31814650e-03f, 7.37904906e-02f, 4.15491052e-02f,
  1.36319950e-01f, 8.54174886e-03f, -1.03380777e-01f, -6.54621497e-02f, 1.37840912e-01f, 1.06068157e-01f, -5.93305603e-02f, 9.15560648e-02f, -8.21103752e-02f, -1.44386858e-01f,
  -2.49109287e-02f, -4.49563339e-02f, -7.81727806e-02f, -2.11255671e-03f, 4.16005813e-02f, -8.22915360e-02f, -1.87643059e-02f, 1.59878226e-04f, -1.05066979e-02f, 2.14461088e-01f,
  -1.96050368e-02f, 2.81822477e-02f, -3.63729075e-02f, -6.45142002e-03f, 6.79277852e-02f, -7.40724131e-02f, 1.58412471e-01f, -9.27737504e-02f, 1.19925432e-01f, -4.33702394e-02f,
  -9.51914564e-02f, -1.67534258e-02f, -3.72378342e-02f, 1.69119626e-01f, 6.52712286e-02f, -5.59924915e-02f, -2.09092319e-01f, 2.22509548e-01f, 3.86101333e-03f, 1.82500109e-01f,
  9.49450359e-02f, -2.22187296e-01f, -9.63588879e-02f, -2.12003514e-01f, -4.12784182e-02f, 1.28070280e-01f, 2.00547390e-02f, -5.89576289e-02f, -2.13884730e-02f, -2.18785450e-01f,
  -8.09565932e-03f, 2.50638485e-01f, 1.25797212e-01f, -2.45677173e-01f, -7.81882256e-02f, 3.34786177e-02f, -2.21222509e-02f, 1.12775154e-01f, -1.52699187e-01f, -8.43100548e-02f,
  -1.48171321e-01f, -8.57901648e-02f, 6.36326969e-02f, -6.68640509e-02f, 4.59136181e-02f, 4.34732623e-02f, 1.50654525e-01f, -4.78697009e-02f, -4.75562140e-02f, -6.59838617e-02f,
  9.39159840e-03f, -1.01912871e-01f, 1.37521237e-01f, -6.05502911e-02f, -1.16979145e-01f, 3.58508639e-02f, -4.05922672e-03f, -1.42656803e-01f, 8.63530263e-02f, 6.33918215e-03f,
  -7.42838234e-02f, 1.05458386e-01f, -2.20101014e-01f, -2.57182848e-02f, -7.85120577e-02f, -6.11119196e-02f, 8.11235011e-02f, 1.60126969e-01f, -8.29712600e-02f, -3.03778518e-02f,
  -6.35052770e-02f, 9.25131515e-02f, 1.51798338e-01f, -1.56371489e-01f, -2.01901402e-02f, 1.55126318e-01f, -8.64370838e-02f, -6.84689358e-02f, 7.51571357e-02f, -5.77581525e-02f,
  -2.73462266e-01f, 1.70919850e-01f, 3.09508312e-02f, 2.11275905e-01f, 9.65064764e-02f, -1.98742703e-01f, -5.49542494e-02f, -3.52244265e-02f, -3.50010782e-01f, 4.43449197e-03f,
  7.67700821e-02f, -8.56973901e-02f, 9.86363590e-02f, 9.42581370e-02f, -1.09902032e-01f, 4.00330015e-02f, 8.92029051e-03f, -6.79965969e-03f, -2.05512628e-01f, 7.24747358e-03f,
  -1.26566589e-01f, 1.84931874e-01f, -1.62578881e-01f, -2.62701623e-02f, -7.16460049e-02f, 1.34566486e-01f, -2.28995793e-02f, -3.15888375e-02f, -6.78663030e-02f, -1.27060845e-01f,
  6.20140992e-02f, 5.22140302e-02f, -1.32579222e-01f, -1.44694746e-01f, 4.99914363e-02f, -1.36369467e-01f, 4.31956537e-02f, 6.74469024e-02f, 8.84675309e-02f, 8.51347148e-02f,
  -4.43341248e-02f, -1.12202822e-03f, -1.04892083e-01f, -9.81430523e-03f, -1.11643903e-01f, 6.18694313e-02f, 2.17413213e-02f, 1.86646059e-01f, 1.44862816e-01f, 1.47753600e-02f,
  -1.24622742e-03f, 7.06671327e-02f, 2.66615562e-02f, -2.21672013e-01f, 2.00349659e-01f, 8.15787259e-03f, 1.20944254e-01f, 1.17853675e-02f, 4.12468389e-02f, 2.10592374e-01f,
  7.95505419e-02f, -7.46707395e-02f, 2.15386450e-01f, 1.22274430e-02f, -1.97462231e-01f, 9.88412201e-02f, 1.22014754e-01f, 8.73708874e-02f, 1.43565506e-01f, 3.38117927e-02f,
  2.04251278e-02f, -3.22782658e-02f, 1.13882571e-01f, 4.96414229e-02f, -5.73854288e-03f, 7.99396560e-02f, -3.72692905e-02f, -2.81291425e-01f, 5.73671982e-02f, 2.79478878e-01f,
  -1.12593882e-02f, -9.85552371e-02f, -1.99865639e-01f, -6.18874691e-02f, 1.12855241e-01f, 1.96895406e-01f, 4.92313206e-02f, -8.57597440e-02f, -1.75385103e-01f, -5.87882102e-03f,
  -1.63967133e-01f, -6.28131554e-02f, 2.55561676e-02f, -1.02326814e-02f, 1.52374012e-03f, -7.51753449e-02f, 5.44421971e-02f, -1.20033972e-01f, -9.81393456e-02f, -2.31511742e-01f,
  3.39976177e-02f, 1.16412342e-01f, -4.38069180e-02f, -3.74636427e-02f, -4.66374792e-02f, -1.38029844e-01f, 2.86538191e-02f, -7.40640536e-02f, 1.16920993e-01f, 6.96200281e-02f,
  -3.97538953e-02f, 2.36583836e-02f, -1.49892718e-01f, -1.76618576e-01f, -3.79603170e-02f, 2.40669116e-01f, 1.72915190e-01f, -2.62594689e-02f, -1.52633637e-01f, -4.16688155e-03f,
  1.20887391e-01f, 3.47025543e-02f, 2.85703931e-02f, -9.36421752e-02f, 3.76312435e-02f, -2.45766059e-01f, -6.65090233e-02f, -9.46311355e-02f, 7.86994621e-02f, 1.21873908e-01f,
  2.32362486e-02f, -9.99267492e-03f, -1.28280461e-01f, -1.71156198e-01f, 9.65097249e-02f, 9.51737463e-02f, -4.49409753e-01f, 2.63458472e-02f, 6.25785366e-02f, 8.41360018e-02f,
  2.68945426e-01f, 2.99897820e-01f, -2.04842538e-02f, -4.21368182e-02f, -3.51030007e-02f, -2.34928471e-03f, -4.82353009e-02f, 1.22563884e-01f, -8.87399614e-02f, -1.21637277e-01f,
  2.46120915e-02f, 7.88007602e-02f, 8.39583799e-02f, -3.45425420e-02f, 3.70433591e-02f, -9.18914452e-02f, 1.46674722e-01f, 8.28655288e-02f, -5.45504615e-02f, -5.98593280e-02f,
  1.28232494e-01f, 1.56243546e-02f, 1.48351580e-01f, 3.28095779e-02f, -8.44487995e-02f, 6.03158288e-02f, 9.76397917e-02f, -1.58961117e-02f, 3.05238366e-02f, -2.80972496e-02f,
  -1.36489924e-02f, -9.77821201e-02f, 7.05506131e-02f, -4.74946126e-02f, 1.19700633e-01f, -5.93082756e-02f, 1.48734283e-02f, 1.19185701e-01f, 8.26718211e-02f, -1.02191783e-01f,
  -5.06877117e-02f, -2.23463044e-01f, 8.15081820e-02f, 4.28279750e-02f, -1.47392005e-01f, 2.39202864e-02f, 7.10720569e-02f, 1.61738470e-01f, 1.97772756e-01f, 2.22280890e-01f,
  -1.12897232e-01f, -6.38813749e-02f, 1.15039006e-01f, 3.03561166e-02f, -1.37039945e-01f, 2.41953116e-02f, 2.28928372e-01f, 8.97851437e-02f, 2.34691761e-02f, -3.16377319e-02f,
  1.12667546e-01f, 5.11493012e-02f, -2.40655810e-01f, 1.10247657e-01f, -1.78899899e-01f, -2.62634426e-01f, 1.17517285e-01f, -3.22482316e-03f, -8.67550671e-02f, -6.57095984e-02f,
  1.35497093e-01f, -5.32708764e-02f, 4.45245095e-02f, 4.80206311e-02f, 4.59785387e-02f, -1.56448465e-02f, 9.91103649e-02f, -9.63042676e-02f, 4.03924063e-02f, -1.18881360e-01f,
  -1.98711485e-01f, 5.31540588e-02f, 4.92198206e-02f, 1.45806102e-02f, -1.33614764e-02f, -1.29406443e-02f, 1.10950962e-01f, -4.48087119e-02f, 1.07941613e-01f, -1.88126117e-01f,
  3.10035748e-03f, 8.60879198e-02f, -1.15988597e-01f, 9.07530729e-03f, -1.07350461e-01f, -2.62015108e-02f, -6.26108050e-02f, -4.00920212e-02f, -1.04404286e-01f, 2.65622810e-02f,
  -1.95883140e-01f, -1.99769765e-01f, 7.87935629e-02f, 1.02317132e-01f, -1.04030408e-01f, 1.32502079e-01f, -1.33335426e-01f, 9.42452028e-02f, -5.64476065e-02f, 1.59196625e-03f,
  -1.70682460e-01f, -7.19501674e-02f, -1.61364347e-01f, -1.41491011e-01f, 7.92348832e-02f, 8.11768249e-02f, -8.57871994e-02f, -4.34392430e-02f, 2.94656046e-02f, 1.32209286e-01f,
  -5.48078120e-03f, -4.24221270e-02f, -7.30483606e-02f, 6.44337684e-02f, -1.17737770e-01f, 3.86606604e-02f, 2.61893541e-01f, -1.09776199e-01f, 9.62859467e-02f, 1.10879801e-01f,
  3.57811362e-03f, 6.71983957e-02f, 3.63319963e-02f, 7.14853313e-03f, -1.17789730e-01f, -2.66262926e-02f, 3.65619548e-02f, 3.66826542e-02f, -3.65049243e-02f, -1.37595490e-01f,
  -2.91354537e-01f, 1.77589625e-01f, 2.66578756e-02f, 1.38807938e-01f, -1.08387046e-01f, 5.66852540e-02f, -3.01980767e-02f, 1.03017278e-01f, 2.02253647e-02f, -1.23779759e-01f,
  7.48588368e-02f, 3.32187936e-02f, 1.00611329e-01f, -8.57902393e-02f, 2.96109635e-02f, 1.38335735e-01f, -5.91588132e-02f, 8.44175220e-02f, 1.30714536e-01f, 2.49023717e-02f,
  9.80073512e-02f, -6.87031373e-02f, 1.06942490e-01f, 3.28523032e-02f, -1.72363028e-01f, -5.12327179e-02f, -4.45852503e-02f, 1.23471558e-01f, 4.74837273e-02f, -2.31800437e-01f,
  -4.39690147e-03f, 1.31240770e-01f, 1.63291067e-01f, -2.10976191e-02f, 3.20173353e-02f, 1.60505995e-01f, 1.05621763e-01f, -2.16872975e-01f, 1.19486995e-01f, -1.73309445e-01f,
  -1.25813365e-01f, 1.52738765e-01f, 6.90761060e-02f, -4.93769767e-03f, -1.12464607e-01f, -1.64335314e-02f, 2.10090101e-01f, 5.17472848e-02f, -8.98247734e-02f, -9.63013545e-02f,
  -1.47581846e-01f, 2.84722317e-02f, 1.76760703e-01f, 2.77541280e-02f, 3.74289975e-02f, -8.55652243e-02f, -6.99247271e-02f, 1.07723862e-01f, 4.39277738e-02f, 7.03554153e-02f,
  -5.53958975e-02f, 4.17556334e-03f, -1.03747971e-01f, 2.83619226e-03f, -9.80624184e-02f, 4.16014381e-02f, -1.13718830e-01f, 5.28524406e-02f, -8.26296508e-02f, 5.27955703e-02f,
  -1.82834640e-02f, -5.08767292e-02f, 4.49661389e-02f, 1.67403683e-01f, -9.96999592e-02f, -5.57640009e-02f, -2.12709401e-02f, 2.87648179e-02f, -8.77489895e-02f, -7.53915682e-02f,
  3.22260298e-02f, -2.42890697e-02f, -1.04339570e-01f, 1.82036653e-01f, 1.36504069e-01f, 1.49082035e-01f, -1.06656097e-01f, -5.65885380e-02f, -1.34475410e-01f, -1.47858083e-01f,
  4.73152474e-02f, 2.01605797e-01f, -7.48987347e-02f, 6.55566156e-03f, -1.04566831e-02f, 6.00357689e-02f, 1.51454613e-01f, -2.28501968e-02f, -1.89609095e-01f, 5.73051115e-03f,
  -1.35485366e-01f, -1.80903345e-01f, -4.89322916e-02f, 5.62289916e-02f, 1.06118463e-01f, 8.95480514e-02f, -1.11354470e-01f, -1.96829930e-01f, -1.79820091e-01f, -2.13874638e-01f,
  1.14805497e-01f, -5.92749938e-02f, -1.96106538e-01f, -1.00639239e-02f, 3.02307401e-03f, 4.46452349e-02f, 1.31829327e-03f, 2.81366915e-01f, -1.06502883e-01f, -1.54204294e-01f,
  -3.09225656e-02f, -7.56861269e-02f, -4.51231189e-02f, -7.06409989e-03f, -7.01515470e-04f, 1.06522724e-01f, 9.19731185e-02f, 3.27145047e-02f, 2.21476611e-02f, 8.61328766e-02f,
  -3.84267196e-02f, 1.34542540e-01f, 9.51347277e-02f, 9.44796856e-03f, 1.27770498e-01f, -4.13276032e-02f, -1.26727447e-01f, -3.26233543e-02f, 6.40834868e-02f, 9.80256572e-02f,
  1.07001014e-01f, 1.03854433e-01f, 2.20939890e-02f, -7.35565126e-02f, 1.30507573e-01f, 2.03633811e-02f, -2.45800782e-02f, -3.77408229e-02f, -8.22046623e-02f, -1.59628391e-02f,
  1.15111887e-01f, -5.81542552e-02f, 3.61184292e-02f, -4.61065322e-02f, -5.98018542e-02f, -2.09217176e-01f, 6.33566976e-02f, 1.24739751e-01f, 7.95089081e-02f, -1.42801628e-01f,
  -1.52880345e-02f, 3.61230187e-02f, 1.41620878e-02f, -2.01329082e-01f, 3.95156033e-02f, 2.03139603e-01f, -1.94492966e-01f, -6.32536113e-02f, 2.31741086e-01f, 7.07238019e-02f,
  1.18301652e-01f, -1.90783575e-01f, -1.34047959e-02f, 2.36496523e-01f, -2.36564432e-03f, 9.10714120e-02f, 2.25235105e-01f, -8.42449293e-02f, 1.13903038e-01f, -6.95628896e-02f,
  -2.71793574e-01f, -1.13231078e-01f, 9.38977823e-02f, -2.30708607e-02f, 7.34016299e-02f, 4.33852710e-02f, 1.44830897e-01f, -1.56907335e-01f, 4.16804813e-02f, 9.90478322e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  6.50902092e-02f, 1.14757754e-01f, -5.95128834e-02f, -1.02156796e-01f, -4.32072133e-02f, -2.67401598e-02f, 7.43384883e-02f, -5.06552085e-02f, -3.67724560e-02f, -8.55799466e-02f,
  -4.98813950e-02f, -1.18587323e-01f, -1.13906220e-01f, -1.08803384e-01f, -1.08392291e-01f, 3.25164758e-02f, 1.19298160e-01f, 1.19550452e-01f, -5.88974170e-02f, -6.68498650e-02f,
  -1.57811865e-02f, -1.01457126e-01f, 9.30560101e-03f, 6.76181400e-03f, 2.88092736e-02f, 3.87555771e-02f, -8.82606804e-02f, 3.74488980e-02f, -4.67918925e-02f, -3.79977860e-02f,
  -3.34444977e-02f, -3.65616046e-02f, -4.62925360e-02f, 5.92153445e-02f, 1.16520233e-01f, 1.19158879e-01f, -8.09140056e-02f, 5.68932034e-02f, -6.82071075e-02f, -1.02969564e-01f,
  8.42524245e-02f, -1.02442406e-01f, 8.76390655e-03f, -8.54390189e-02f, -1.09709740e-01f, -4.49389964e-02f, 6.68487176e-02f, 8.20835903e-02f, -9.67933238e-02f, 1.14357814e-01f,
  -6.25672936e-02f, 1.02811574e-03f, -1.16915867e-01f, 2.97327898e-02f, -1.47531675e-02f, -9.21795070e-02f, 6.90223575e-02f, -6.96987510e-02f, -5.58563843e-02f, -4.74391878e-02f,
  1.07694760e-01f, -1.05930276e-01f, 5.93412556e-02f, 1.57813281e-02f, 3.56929377e-02f, -3.98387164e-02f, -4.76696566e-02f, -4.92959917e-02f, -8.86403918e-02f, 1.15851760e-01f,
  8.17834288e-02f, 6.11552075e-02f, 6.96637928e-02f, 8.20294172e-02f, 5.58905639e-02f, 1.54393092e-01f, 4.43462953e-02f, 5.63673042e-02f, 1.58178121e-01f, 4.27140594e-02f,
  -1.32287174e-01f, 1.09261889e-02f, -7.28768855e-02f, -7.53370672e-02f, 1.57046050e-01f, 9.95810255e-02f, -5.30316159e-02f, 1.06175229e-01f, 2.02289317e-02f, 1.00774849e-02f,
  -9.97979417e-02f, -2.23541737e-01f, -9.27413628e-02f, 1.82409495e-01f, 7.51732290e-02f, 1.01132676e-01f, -3.42894462e-03f, 1.52091794e-02f, 5.02454191e-02f, -6.89245835e-02f,
  -5.24312258e-02f, -1.59200743e-01f, -1.14198625e-01f, 7.34160766e-02f, 1.67542443e-01f, 1.21362761e-01f, -3.34277898e-02f, 1.60307810e-01f, -1.29751459e-01f, 8.81190524e-02f,
  6.58511966e-02f, -1.85567498e-01f, 7.28364363e-02f, 6.19984008e-02f, -5.81205003e-02f, 6.39073476e-02f, 6.14391416e-02f, 8.28399584e-02f, 7.30286762e-02f, 8.06439370e-02f,
  1.80040835e-03f, -7.01885149e-02f, 2.47132760e-02f, -2.99601164e-02f, -3.87661792e-02f, 6.67578503e-02f, 7.19552040e-02f, -8.14153627e-03f, -5.81972487e-02f, -1.19007938e-01f,
  -1.56282887e-01f, 1.41939357e-01f, 1.24764994e-01f, -7.10805878e-02f, 1.80781186e-01f, 4.89009283e-02f, 1.97598130e-01f, 1.36059240e-01f, -2.08687875e-02f, 3.78773957e-02f,
  -3.82442516e-03f, 6.06530607e-02f, 9.68458429e-02f, 2.07663029e-01f, 1.37729079e-01f, 5.79953799e-03f, -1.31260939e-02f, 1.38181031e-01f, 9.11259949e-02f, -1.10365056e-01f,
  -1.39967829e-01f, 5.99782914e-02f, 1.02307416e-01f, -7.81641901e-02f, 7.73370042e-02f, -4.33347709e-02f, 3.10669839e-02f, 1.34956673e-01f, -5.18861488e-02f, -7.63966367e-02f,
  1.78366721e-01f, 2.13768538e-02f, 1.30914554e-01f, 1.37976766e-01f, 1.61317065e-01f, 8.99222866e-02f, -7.10521638e-02f, 1.47091821e-01f, -5.24273179e-02f, -1.42893374e-01f,
  9.54991654e-02f, -1.06321767e-01f, 7.90569857e-02f, -3.93631943e-02f, 1.39867052e-01f, 2.08887026e-01f, -5.92303462e-02f, 4.15562559e-03f, 7.08600283e-02f, -5.74964844e-02f,
  -8.28531384e-02f, -3.74853574e-02f, 7.71400556e-02f, -1.08343057e-01f, 5.37862116e-03f, 3.28487307e-01f, -1.32920086e-01f, 1.92674547e-01f, -2.42228024e-02f, -1.63565185e-02f,
  -3.88580710e-02f, 1.01336434e-01f, 1.63665339e-01f, -9.81570855e-02f, 2.29485910e-02f, 1.46656990e-01f, -2.68059000e-02f, 1.34197846e-01f, 1.08293239e-02f, -6.59961849e-02f,
  1.56656504e-01f, -6.63087070e-02f, -1.53588811e-02f, 5.77767231e-02f, 1.42861605e-01f, 1.07594341e-01f, 6.11419827e-02f, 5.19086234e-02f, 3.50648090e-02f, -1.04812630e-01f,
  -7.01521114e-02f, 2.19341516e-01f, 1.04390629e-01f, -8.41489509e-02f, -7.14107826e-02f, -3.59705649e-03f, 2.43081123e-01f, -3.29736173e-01f, 1.23765409e-01f, 1.30162001e-01f,
  -8.98614177e-04f, 6.57624304e-02f, 5.62778153e-02f, 1.42516673e-01f, 3.41554880e-02f, -8.35064724e-02f, -7.64121339e-02f, 1.24070644e-01f, 5.63344061e-02f, -5.02847768e-02f,
  8.32860470e-02f, -8.03239942e-02f, -1.33679226e-01f, 6.43176138e-02f, 3.64910513e-01f, -1.69860646e-01f, 1.77875962e-02f, -3.48185807e-01f, -7.94118270e-02f, 3.67158741e-01f,
  -7.04927146e-02f, 1.44546747e-01f, 4.50331457e-02f, -7.48661608e-02f, 1.58825934e-01f, -4.53078039e-02f, 9.28303823e-02f, 2.54937619e-01f, -3.00107598e-02f, -1.90887414e-03f,
  -5.29755875e-02f, 3.38170141e-01f, -5.40744849e-02f, 1.55143902e-01f, 1.45100327e-02f, -1.15453035e-01f, -3.26136500e-02f, -5.76711260e-02f, 8.27404931e-02f, -1.25304028e-01f,
  -4.93452735e-02f, 1.61587782e-02f, -4.16151397e-02f, 8.44093785e-02f, -5.20901382e-02f, -3.78910676e-02f, 1.77687667e-02f, 3.93649340e-02f, -8.86001736e-02f, -5.56611232e-02f,
  -2.77508460e-02f, 1.06428035e-01f, 3.40251066e-02f, 9.56786945e-02f, 3.11835017e-02f, 9.20531750e-02f, 6.34416640e-02f, -6.64467439e-02f, -4.87853363e-02f, -3.47411893e-02f,
  -1.11946836e-02f, 8.52009431e-02f, -8.26864764e-02f, 1.11307219e-01f, 1.15709208e-01f, -6.59764037e-02f, 5.57237975e-02f, -1.05487570e-01f, -5.86234741e-02f, 9.59797055e-02f,
  -7.09970146e-02f, -7.95877203e-02f, -6.15445413e-02f, -8.51986408e-02f, 2.29063984e-02f, -9.19467658e-02f, -1.11660495e-01f, 7.99178183e-02f, 5.04053980e-02f, -8.84700343e-02f,
  -3.85437720e-02f, 7.79515952e-02f, -9.12457183e-02f, 1.11160941e-01f, 1.30652085e-01f, 1.22538336e-01f, -1.21902041e-02f, 9.74273309e-02f, -1.15869954e-01f, -9.41312611e-02f,
  1.15190856e-01f, 1.30116597e-01f, 4.39606719e-02f, -6.60838857e-02f, -3.26202065e-02f, 1.88430976e-02f, -2.09059902e-02f, 9.86082479e-02f, 9.92434919e-02f, 4.76992764e-02f,
  8.86943564e-02f, -3.54375057e-02f, 2.57126093e-02f, 6.25475794e-02f, -3.81104723e-02f, -4.09596078e-02f, -9.46830362e-02f, 4.34940755e-02f, -1.22374289e-01f, -5.62136248e-02f,
  -1.45886308e-02f, -8.83458629e-02f, -3.46291102e-02f, 5.20604737e-02f, -7.15574324e-02f, -4.68404405e-03f, -6.56831563e-02f, 8.14750642e-02f, -1.22341588e-01f, 1.03305914e-01f,
  2.06052661e-02f, 7.85857514e-02f, -7.34614804e-02f, -5.12040183e-02f, 1.95450131e-02f, 2.55678594e-02f, -5.73810674e-02f, -9.55483466e-02f, -9.31573212e-02f, -6.24839291e-02f,
  3.80426496e-02f, -9.97287929e-02f, -7.87321627e-02f, 6.32289946e-02f, -3.00625674e-02f, 1.07915767e-01f, 7.76701793e-02f, 1.70080438e-02f, 6.63351151e-04f, 3.93885560e-02f,
  9.24960077e-02f, -2.77775377e-02f, 3.35309766e-02f, 6.01226911e-02f, 1.71006061e-02f, -1.24374330e-02f, -5.73107824e-02f, -1.08445406e-01f, 7.89939240e-02f, -8.79628733e-02f,
  6.00325316e-02f, -4.01731730e-02f, -3.06880102e-02f, 9.94988307e-02f, -2.12789569e-02f, -4.87296320e-02f, 1.23746328e-01f, -7.34596178e-02f, 5.03345877e-02f, 8.16962868e-02f,
  -2.14258805e-02f, 7.91428313e-02f, -1.17820479e-01f, -8.70067179e-02f, -3.78087126e-02f, 1.09124556e-01f, 6.67926073e-02f, 8.92781019e-02f, 1.75208658e-01f, 1.45919368e-01f,
  1.42814025e-01f, -8.59670192e-02f, 5.15936501e-02f, 9.57805067e-02f, -1.58183455e-01f, 4.85676117e-02f, 2.26431694e-02f, 7.45090693e-02f, -8.28143954e-02f, 1.16964139e-01f,
  1.75556183e-01f, -7.38434494e-02f, 5.23513788e-03f, -3.80222825e-03f, 9.51740742e-02f, 1.04120158e-01f, -1.64358452e-01f, 1.17864639e-01f, -3.57484035e-02f, -1.66739300e-01f,
  5.85330352e-02f, 1.38329402e-01f, 3.93665545e-02f, 1.15044126e-02f, 5.84772835e-03f, 1.31530225e-01f, -9.97143164e-02f, 9.16371500e-05f, 1.00076742e-01f, 2.02057827e-02f,
  9.01967585e-02f, 9.73335281e-02f, -1.09303094e-01f, -8.06408450e-02f, -2.29019433e-01f, 8.89954045e-02f, 1.05527602e-01f, -1.77497804e-01f, 3.31056602e-02f, -5.74721843e-02f,
  -5.61858527e-02f, 3.11330378e-01f, -1.08804539e-01f, -6.97150603e-02f, -2.69752424e-02f, -1.28709733e-01f, 9.21614468e-02f, 5.63470013e-02f, 2.43822724e-01f, 8.90691131e-02f,
  4.32400778e-02f, -5.33740558e-02f, -8.15904438e-02f, 3.46998900e-01f, -8.16102698e-02f, 8.86112750e-02f, 2.31437217e-02f, -6.50890172e-02f, -5.59552349e-02f, -1.52030036e-01f,
  1.91610667e-03f, 1.19357659e-02f, -4.77777310e-02f, -8.26310460e-03f, -1.20207049e-01f, -8.47527478e-03f, 8.51442516e-02f, -6.79139644e-02f, -2.13427152e-02f, -9.06912610e-02f,
  -5.38152419e-02f, -1.09275162e-01f, 5.17088510e-02f, -2.21552351e-03f, 1.18481010e-01f, 1.17943503e-01f, 7.44947791e-02f, 6.85324594e-02f, 5.40934391e-02f, 4.77100983e-02f,
  -4.33943272e-02f, -6.56842440e-02f, -4.91183288e-02f, 7.88650438e-02f, -1.10671505e-01f, 6.85421228e-02f, -7.80136138e-02f, -6.93666190e-02f, 3.81655395e-02f, 5.94017804e-02f,
  -6.15094006e-02f, -9.80737358e-02f, 1.18975766e-01f, 2.41406932e-02f, -1.14513047e-01f, 5.44312634e-02f, -7.72799626e-02f, -1.31367877e-01f, 6.89437762e-02f, -3.85212228e-02f,
  1.12192323e-02f, -2.61530355e-02f, -1.23551518e-01f, 3.21447216e-02f, -1.23333499e-01f, -7.63959438e-02f, 2.10904069e-02f, -6.86164871e-02f, 4.53735217e-02f, 9.20026749e-02f,
  -5.56881889e-04f, -3.78160141e-02f, 1.44312521e-02f, 1.75254837e-01f, -9.04170610e-03f, -8.28446597e-02f, 6.43080920e-02f, -4.11624499e-02f, -1.12880088e-01f, -8.45481642e-03f,
  -3.93479168e-02f, 5.46291731e-02f, -1.15591943e-01f, 1.15724746e-03f, -1.12835415e-01f, -2.99190953e-02f, 1.22722924e-01f, 1.70008406e-01f, 1.32763788e-01f, -2.65540443e-02f,
  3.47460695e-02f, -8.85008276e-02f, -1.48293555e-01f, -1.20874248e-01f, -9.69635416e-03f, -2.69711856e-02f, -1.08074352e-01f, -3.83462347e-02f, 1.63980365e-01f, -1.09964482e-01f,
  7.30983689e-02f, 7.02525526e-02f, -1.84472695e-01f, -1.21454708e-01f, -7.80631676e-02f, 3.09458226e-02f, -1.23996781e-02f, -8.30313936e-02f, -8.07848051e-02f, -8.39804932e-02f,
  -5.44241979e-04f, -9.90010351e-02f, 6.16145246e-02f, -5.30094318e-02f, -3.32081281e-02f, 5.76792695e-02f, -1.32964045e-01f, 9.86830965e-02f, 1.08096607e-01f, 6.67663291e-02f,
  -1.04076758e-01f, 3.54410126e-03f, -1.07758515e-01f, -4.85264249e-02f, -1.11278698e-01f, -1.79698274e-01f, 6.71441555e-02f, -8.80454034e-02f, -1.83176864e-02f, -1.75167471e-02f,
  -1.82003230e-01f, 7.78245926e-02f, 1.02536067e-01f, -5.35916500e-02f, -6.67781532e-02f, -4.83733006e-02f, 1.25501633e-01f, 3.28327790e-02f, -7.03128204e-02f, 2.01349497e-01f,
  2.30242610e-02f, 2.63515055e-01f, -3.23925875e-02f, 5.45191355e-02f, -9.53126177e-02f, -4.52357344e-02f, 3.94796394e-02f, -1.21116200e-02f, -1.95988283e-01f, 3.17406356e-02f,
  -6.63997978e-02f, -4.03181016e-02f, -3.21754180e-02f, -1.20136134e-01f, 1.25012517e-01f, 6.17061183e-02f, 6.91088885e-02f, -3.07405484e-03f, -1.16686344e-01f, -4.04120870e-02f,
  8.97558331e-02f, 1.37470305e-01f, -1.03636719e-02f, -1.15605220e-02f, -8.07884708e-02f, 1.20706163e-01f, -7.78430775e-02f, 6.46696314e-02f, 3.75618190e-02f, 6.41914681e-02f,
  8.66199434e-02f, -2.08894700e-01f, 3.72590646e-02f, 3.97955030e-02f, -2.03431193e-02f, 3.49206477e-02f, -5.40580750e-02f, -9.83236358e-02f, 3.85786183e-02f, 9.57462192e-02f,
  -9.67245847e-02f, 1.32113501e-01f, 8.19054842e-02f, 4.62513939e-02f, -5.21018989e-02f, 1.16237700e-02f, -1.03738897e-01f, -1.05917066e-01f, 6.23505469e-03f, 1.87603831e-02f,
  4.65253694e-03f, -1.82520568e-01f, -3.25698145e-02f, 6.37882203e-02f, -7.03607798e-02f, 1.36367306e-01f, 6.69996068e-02f, -3.49050276e-02f, -1.32762283e-01f, 6.69517815e-02f,
  -5.82154728e-02f, -1.80033445e-02f, -1.10707425e-01f, 1.33897752e-01f, -9.84120741e-02f, -2.38260124e-02f, 1.66092858e-01f, 1.01453967e-01f, 1.06328472e-01f, 2.64761746e-02f,
  1.44273862e-01f, 5.20380288e-02f, 8.68482608e-03f, 6.40184656e-02f, -4.46445234e-02f, -7.86520019e-02f, 9.26449224e-02f, -5.65071404e-02f, 1.91738397e-01f, 8.99513289e-02f,
  2.77697295e-02f, -1.90290846e-02f, -5.49544878e-02f, -9.98040363e-02f, -5.57899401e-02f, 1.01016521e-01f, 1.53559104e-01f, 1.57500148e-01f, 1.59022897e-01f, 1.98106244e-02f,
  1.71491787e-01f, -3.79827842e-02f, 2.88894735e-02f, 1.32886484e-01f, 3.59747596e-02f, -1.39866294e-02f, 1.04964107e-01f, -1.01113051e-01f, -8.49664360e-02f, 1.64128318e-01f,
  3.75729962e-03f, -3.01097799e-02f, -1.48758575e-01f, 1.50393575e-01f, 7.24358559e-02f, -2.17875559e-02f, -1.71080697e-02f, 1.13486543e-01f, -6.98657930e-02f, -1.66883916e-01f,
  2.97405850e-03f, 4.28253785e-02f, 1.05727753e-02f, 1.64359897e-01f, -1.20920144e-01f, -3.16448212e-02f, 1.03279471e-01f, -1.40305743e-01f, 1.56605005e-01f, -1.60585210e-01f,
  -1.97617725e-01f, 4.79154810e-02f, -3.53310853e-02f, -1.16881490e-01f, 3.23819250e-01f, 7.19545633e-02f, -1.09883115e-01f, 3.96888144e-02f, -9.73400697e-02f, 7.94823468e-02f,
  1.67281106e-01f, 1.69386119e-01f, -7.60415047e-02f, 8.79411623e-02f, 4.45838012e-02f, -7.07733855e-02f, -1.81106806e-01f, -1.27250761e-01f, -1.17845617e-01f, 9.13780779e-02f,
  8.68664533e-02f, 1.86278731e-01f, -2.68126447e-02f, 1.60176978e-01f, 2.06055671e-01f, 4.84430455e-02f, 1.05365224e-01f, -6.48521706e-02f, 1.47927001e-01f, 5.62744588e-02f,
  -4.84662317e-02f, 2.00911686e-01f, 2.01492250e-01f, -5.05251400e-02f, 2.31571704e-01f, 2.35650867e-01f, 2.22116008e-01f, 2.32819170e-01f, 1.12300709e-01f, 1.07714787e-01f,
  -7.71458969e-02f, -1.18320405e-01f, 1.87977850e-01f, 1.35878861e-01f, -9.04844403e-02f, -4.98507097e-02f, -5.78466505e-02f, 3.21898535e-02f, 5.72337434e-02f, 4.54611890e-02f,
  3.58393118e-02f, -1.08438514e-01f, 5.81511855e-02f, 5.18490225e-02f, -7.40553290e-02f, 1.59031630e-01f, 5.31518906e-02f, -4.27718014e-02f, -1.02527909e-01f, -1.52661309e-01f,
  -1.79766342e-01f, -1.68952465e-01f, 3.07726055e-01f, 9.53302979e-02f, -9.89823788e-02f, 1.78079084e-01f, 1.09852985e-01f, -9.70300511e-02f, 2.27076054e-01f, 4.04347360e-01f,
  5.35171740e-02f, -2.39879489e-01f, -1.71265304e-01f, -7.54393311e-03f, 2.07772046e-01f, 1.01416692e-01f, -7.75676072e-02f, 1.36875197e-01f, -3.32050584e-02f, 1.43065810e-01f,
  2.95956641e-01f, -6.43611550e-02f, 8.57028216e-02f, -8.36904347e-02f, -1.51359424e-01f, 5.01985401e-02f, 9.38588604e-02f, 1.24437928e-01f, 1.96328282e-01f, 1.30611956e-02f,
  1.69123784e-01f, 1.04721807e-01f, 2.02016205e-01f, -4.27299328e-02f, 7.71236345e-02f, 2.92597222e-03f, -1.23984572e-02f, 1.79809660e-01f, 2.00294051e-02f, 1.38420269e-01f,
  5.14542423e-02f, 4.67706211e-02f, -1.25821948e-01f, 2.05030739e-01f, -2.09855482e-01f, -1.96694940e-01f, -1.31574851e-02f, 2.12249458e-02f, -1.65772721e-01f, 1.54329732e-01f,
  1.34945348e-01f, -1.84889540e-01f, 1.39521407e-02f, 7.67297372e-02f, -1.06652848e-01f, -6.10638596e-02f, -2.24948347e-01f, -1.70272812e-01f, 1.37823701e-01f, 2.00918257e-01f,
  -1.75492525e-01f, -9.66536999e-02f, 6.49543479e-02f, 2.37668213e-03f, -1.75266601e-02f, 1.79041892e-01f, -2.06872642e-01f, -6.21463098e-02f, -5.38457371e-02f, -8.26610252e-03f,
  4.49211627e-01f, -8.93971995e-02f, 4.52579498e-01f, 2.19344467e-01f, -9.13854614e-02f, 2.44066551e-01f, 1.77896276e-01f, 2.52680123e-01f, -2.97711790e-01f, 2.51696426e-02f,
  -1.14755530e-03f, 4.79564145e-02f, 1.24315128e-01f, 3.77897844e-02f, 1.89812914e-01f, 1.08136877e-01f, 9.48623940e-02f, 8.51232838e-03f, 1.45179674e-01f, 9.85088944e-02f,
  2.57466771e-02f, 1.36513412e-01f, 2.03143954e-01f, 1.48019969e-01f, 1.02540970e-01f, 5.00584729e-02f, 9.57990363e-02f, 2.17449233e-01f, -7.61500699e-03f, 2.12179154e-01f,
  1.97672784e-01f, 4.37029116e-02f, 1.47477284e-01f, -1.54587850e-02f, 1.11152917e-01f, 4.94588576e-02f, 1.01261690e-01f, 1.81764260e-01f, 6.38740733e-02f, 2.44162738e-01f,
  1.00870163e-03f, -1.65931284e-01f, -2.11569458e-01f, -1.70312911e-01f, 1.45435721e-01f, -1.26054108e-01f, -4.89065982e-02f, 1.03910416e-01f, 2.01420233e-01f, 1.40277952e-01f,
  1.42512515e-01f, 2.87825316e-01f, 9.47831273e-02f, 8.40217341e-04f, -2.20964309e-02f, -6.31830692e-02f, -7.18010440e-02f, 2.39424050e-01f, 2.13423610e-01f, 1.17376603e-01f,
  -1.23685002e-01f, -1.92537699e-02f, 3.25371742e-01f, 5.82095645e-02f, -3.06702778e-02f, -1.60122160e-02f, -2.12530568e-01f, -2.26478070e-01f, 4.15197089e-02f, 1.82512939e-01f,
  -3.34980525e-02f, -9.09293294e-02f, 2.04222336e-01f, 4.69561331e-02f, -3.99119630e-02f, 2.48250678e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -2.46138647e-02f, -9.42491218e-02f, 4.57734056e-02f, 1.71139708e-03f, -6.17709793e-02f, 7.61468261e-02f, -5.43553531e-02f, 1.63640361e-02f, 9.05472487e-02f, 1.30467758e-01f,
  4.16052192e-02f, 1.72497928e-01f, -4.72807772e-02f, -3.07212658e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.07567590e-02f, 6.63499832e-02f, -3.82372551e-02f, -3.33475471e-01f, -4.97542381e-01f, -1.48213908e-01f, -2.38504380e-01f, -2.68501908e-01f, 1.74073383e-01f, -2.86778331e-01f,
  -3.23316127e-01f, -8.87116343e-02f, -1.95780218e-01f, -4.96714301e-02f, 1.54988840e-02f, -6.56413287e-02f, 1.21605590e-01f, -1.98321044e-01f, -8.52288306e-02f, -1.01838872e-01f,
  -1.53794559e-02f, -1.73032224e-01f, 1.18921146e-01f, -2.33710781e-01f, -3.00206214e-01f, 1.99719042e-01f, 2.27876440e-01f, -3.32706094e-01f, -2.06313953e-01f, 2.25762308e-01f,
  2.96384454e-01f, -2.41687030e-01f, -2.25475132e-01f, 1.80097744e-01f, -4.13367897e-03f, 1.32928550e-01f, -2.25817293e-01f, -6.82606399e-02f, 2.59072453e-01f, -8.55949223e-02f,
  1.74044997e-01f, -1.10449428e-02f, -9.99717414e-03f, 3.29347998e-01f, 4.33173254e-02f, 1.22903697e-01f, -2.01472059e-01f, 2.78546005e-01f, 1.95974577e-02f, 1.68212965e-01f,
  1.13888159e-01f, -7.22987652e-02f, 3.36262822e-01f, 6.11601025e-03f, 3.43300514e-02f, 2.14254446e-02f, -5.08829728e-02f, 4.86131199e-02f, 2.25473151e-01f, 3.17924798e-01f,
  -1.15220420e-01f, -4.94490862e-01f, -6.62515700e-01f, 3.55330765e-01f, -1.77065339e-02f, 7.67564699e-02f, -6.65416047e-02f, 1.47044942e-01f, -1.47835776e-01f, 1.55368999e-01f,
  1.98789444e-02f, 2.62686968e-01f, -2.30167225e-01f, -3.34714800e-01f, 7.07170181e-03f, 3.39050561e-01f, 1.07479356e-01f, -1.24858499e-01f, 2.44173050e-01f, 2.64042646e-01f,
  -7.78280050e-02f, -2.45723531e-01f, 7.19565749e-02f, -1.68434024e-01f, 1.88575953e-01f, 1.36681953e-02f, 1.72944330e-02f, -4.68064807e-02f, -4.20391530e-01f, 3.09697300e-01f,
  -1.10828201e-03f, 3.31770927e-01f, -7.27222338e-02f, 2.26260945e-01f, -1.89971119e-01f, 1.64091587e-01f, -3.74631941e-01f, 3.18113744e-01f, -1.08766288e-01f, -6.40581474e-02f,
  2.93725014e-01f, 1.67659312e-01f, 2.08434016e-01f, 1.52884111e-01f, -9.72985551e-02f, -3.10499579e-01f, 3.07580382e-02f, -2.23249570e-01f, 7.59436563e-03f, 1.13718696e-01f,
  -2.04389960e-01f, -2.75692910e-01f, -2.92912237e-02f, 6.71464251e-03f, -4.14720401e-02f, -7.19046667e-02f, 3.00204515e-01f, 5.10890543e-01f, -1.31897315e-01f, 1.50577985e-02f,
  3.36381942e-01f, 7.48408437e-02f, 1.64696723e-01f, 1.39020056e-01f, -2.08898529e-01f, -2.93801516e-01f, -1.74091101e-01f, -1.09489612e-01f, -1.22153878e-01f, -1.12693742e-01f,
  1.01595782e-02f, 2.26874009e-01f, 7.76976645e-02f, 2.80130487e-02f, 6.99889958e-02f, 2.07840085e-01f, -1.26748547e-01f, 5.52690923e-01f, 2.77498364e-01f, -2.33693108e-01f,
  2.82655388e-01f, -1.58285543e-01f, -1.96117043e-01f, -5.96498922e-02f, 1.31035939e-01f, 2.28922471e-01f, 1.08146138e-01f, 5.87944947e-02f, 1.16075069e-01f, 2.19877154e-01f,
  1.56161532e-01f, -6.83834106e-02f, 1.71712264e-01f, 2.78471231e-01f, -5.91363907e-02f, -2.91400939e-01f, -2.45504379e-01f, -7.30388463e-01f, 3.27661008e-01f, 3.31510752e-01f,
  2.46067643e-01f, -4.91481960e-01f, -4.45007533e-01f, -1.53664842e-01f, -6.04838552e-03f, -1.06422201e-01f, 2.38032147e-01f, -6.51606619e-02f, 2.39584401e-01f, 2.61713147e-01f,
  3.43957320e-02f, 1.68478668e-01f, -2.18215048e-01f, -2.95292020e-01f, 8.94804597e-02f, -1.16969854e-01f, -3.65770698e-01f, -1.84643298e-01f, -1.46788638e-02f, -2.32242972e-01f,
  2.53535807e-01f, -1.17714010e-01f, -3.49570885e-02f, -1.06714435e-01f, 1.22968905e-01f, -9.10336673e-02f, 1.99563727e-01f, -7.35153332e-02f, -3.85842696e-02f, -2.84232944e-01f,
  2.90457517e-01f, 4.11085077e-02f, 9.63031314e-03f, -1.71791449e-01f, 9.57736969e-02f, 1.56909719e-01f, 3.61385375e-01f, 2.95654535e-01f, 3.22825730e-01f, 4.25950259e-01f,
  4.90635395e-01f, 3.27944785e-01f, 1.25965923e-01f, -1.01993643e-01f, -3.84095088e-02f, 3.79182305e-03f, -1.68841541e-01f, -1.24724068e-01f, 1.38257772e-01f, 2.95408905e-01f,
  2.12169498e-01f, 3.50879163e-01f, 1.21136628e-01f, 9.20940340e-02f, 2.14098051e-01f, 1.32869855e-01f, 1.72016487e-01f, 5.02292737e-02f, -3.64201844e-01f, -4.34904963e-01f,
  -2.09073216e-01f, 2.96847224e-01f, 6.17803559e-02f, 7.54613951e-02f, -3.95731330e-02f, 3.42543572e-02f, 2.81480193e-01f, 3.04064512e-01f, -3.32524598e-01f, -2.52696633e-01f,
  1.54962286e-01f, -1.33871496e-01f, 3.35022449e-01f, -9.85737592e-02f, -2.73701362e-02f, 5.82696460e-02f, -2.79318422e-01f, 2.12922812e-01f, -3.19427878e-01f, 2.81430990e-01f,
  -1.79022744e-01f, -5.53386845e-02f, -4.25536782e-02f, 7.33493418e-02f, 1.39140084e-01f, -5.01247421e-02f, -3.16103771e-02f, -1.07774928e-01f, -3.20793353e-02f, 7.19836429e-02f,
  -1.29660815e-01f, 1.42559707e-01f, 1.87626228e-01f, 3.03998321e-01f, -2.72649109e-01f, 9.33142304e-02f, -1.50315925e-01f, 1.93340763e-01f, -4.59562033e-01f, -1.25780091e-01f,
  4.33579355e-01f, -1.39213637e-01f, 1.76615685e-01f, 3.22711259e-01f, -8.70263726e-02f, 1.30541965e-01f, -1.07528664e-01f, -9.91801396e-02f, -1.05422057e-01f, 2.14301392e-01f,
  -3.07782561e-01f, 2.85145223e-01f, -1.22370884e-01f, 2.71992773e-01f, -6.40113354e-02f, -2.73197383e-01f, -4.57482859e-02f, 5.14959581e-02f, 1.33404657e-01f, -5.89243807e-02f,
  7.20697939e-02f, 1.33219123e-01f, 2.58574694e-01f, -1.08401023e-01f, -3.11444134e-01f, 3.85819465e-01f, 4.62673977e-02f, -3.97461861e-01f, -3.84685248e-01f, -3.60169977e-01f,
  4.10153449e-01f, 2.99873441e-01f, -1.60478950e-01f, -7.64738470e-02f, -1.03586622e-01f, 5.01660444e-02f, -1.16849497e-01f, 3.75761926e-01f, -1.50591999e-01f, 2.94905305e-01f,
  -1.16534315e-01f, 3.52898717e-01f, -7.61448517e-02f, -5.12669347e-02f, -2.92255759e-01f, 1.41388595e-01f, -1.78259034e-02f, -5.32879680e-03f, -8.46239403e-02f, -4.93052423e-01f,
  6.45565391e-02f, 3.31965201e-02f, -3.09855342e-01f, 9.41533446e-02f, -3.58071066e-02f, -1.78796679e-01f, -8.49553421e-02f, -3.63410443e-01f, -7.17139244e-02f, 5.83236873e-01f,
  2.25029066e-01f, 1.09994216e-02f, 3.77177268e-01f, 1.10698789e-01f, 4.09573764e-01f, 1.21648215e-01f, 3.89039725e-01f, -1.33171916e-01f, 5.30756176e-01f, 3.16379845e-01f,
  1.90546855e-01f, 5.10644376e-01f, -1.45013139e-01f, 1.77490041e-01f, -1.13128662e-01f, -6.84817508e-02f, 2.30821341e-01f, -9.11830515e-02f, 2.08453298e-01f, -1.44310057e-01f,
  5.59424423e-02f, 2.52299793e-02f, -3.64194959e-02f, -1.30560985e-02f, -1.22273125e-01f, -2.36792900e-02f, 1.87998768e-02f, -2.97289807e-02f, -1.65233582e-01f, -5.16885370e-02f,
  -2.65461858e-02f, 1.52669207e-03f, 4.31107223e-01f, 4.36913997e-01f, 3.89005870e-01f, 2.56547611e-03f, 3.23761731e-01f, -2.19969988e-01f, -1.38767296e-02f, -4.30858470e-02f,
  -4.25262958e-01f, -2.15657666e-01f, -1.68804094e-01f, -3.18010300e-01f, -6.27084002e-02f, -4.57335673e-02f, 1.71423748e-01f, -2.96468496e-01f, -2.32290924e-01f, 2.73053855e-01f,
  -8.83601680e-02f, -1.02075219e-01f, -2.71079363e-03f, 6.44393489e-02f, -1.08318917e-01f, 1.54280793e-02f, 1.92477945e-02f, 5.73804118e-02f, -2.36283571e-01f, -2.35913083e-01f,
  -2.33624637e-01f, -1.13970332e-01f, 4.37807560e-01f, 2.19682351e-01f, 3.74618545e-02f, -5.14267720e-02f, 2.35978827e-01f, -2.61661619e-01f, -1.26000270e-01f, 2.16165692e-01f,
  -1.75698757e-01f, -2.72511899e-01f, -4.39925790e-01f, -1.88861996e-01f, -1.20918237e-01f, -1.59161594e-02f, -1.56416968e-01f, -5.52982651e-02f, 2.94572711e-01f, -8.39672759e-02f,
  1.96258157e-01f, -1.43779710e-01f, 1.88704342e-01f, -1.55876251e-02f, -4.23397660e-01f, -1.19584233e-01f, -3.18622328e-02f, -1.45779297e-01f, -8.48518088e-02f, -3.01528215e-01f,
  5.57659119e-02f, 3.03582639e-01f, 3.95729721e-01f, 9.29385722e-02f, -1.15734175e-01f, 1.03611788e-02f, -1.79631859e-01f, -9.53663290e-02f, 2.52733856e-01f, 2.36204127e-04f,
  -3.37864608e-01f, 2.07022622e-01f, -2.11183056e-01f, 1.56920943e-02f, -1.84726473e-02f, 9.31846872e-02f, 3.19057763e-01f, 1.14192627e-02f, 4.41394001e-01f, -6.19722307e-02f,
  1.23508312e-01f, 3.19674850e-01f, 1.34463727e-01f, -3.57103646e-01f, 1.09314427e-01f, 3.29677612e-01f, -2.79694766e-01f, -3.61324817e-01f, -9.10919905e-02f, 1.38500305e-02f,
  -8.97670835e-02f, 9.47489366e-02f, 1.53070286e-01f, 2.27231048e-02f, 2.95419339e-02f, 3.02646607e-01f, 2.31326565e-01f, -4.03838933e-01f, -3.30118509e-03f, -4.52889085e-01f,
  -2.84560919e-01f, -1.97673813e-01f, -3.14690843e-02f, -3.04990977e-01f, -2.84387231e-01f, 6.04655780e-02f, 4.05724458e-02f, 1.38692399e-02f, -1.62794098e-01f, 8.19853768e-02f,
  -1.09711587e-01f, -2.59422213e-01f, -2.42403205e-02f, -2.30361789e-01f, -4.05226573e-02f, 9.89664420e-02f, -2.18872800e-01f, -4.27316517e-01f, -1.98400483e-01f, -4.83475300e-03f,
  -1.48291945e-01f, -7.45117217e-02f, 3.91077995e-02f, -7.48668015e-02f, -1.38263792e-01f, 1.58308744e-01f, -1.74106807e-01f, 6.64280206e-02f, 2.11870689e-02f, -2.66425818e-01f,
  -2.68219262e-01f, -2.18210086e-01f, 1.67360753e-01f, 1.54579848e-01f, -1.86881855e-01f, 2.01291278e-01f, 1.99196875e-01f, 4.77955282e-01f, 4.23747003e-01f, -1.74816161e-01f,
  3.04621253e-02f, -6.36689514e-02f, 9.39270407e-02f, 3.41703221e-02f, 1.35712773e-01f, 2.41640791e-01f, 2.68519789e-01f, -3.42211306e-01f, -7.16709420e-02f, -3.37554328e-02f,
  4.03362239e-04f, 3.03084284e-01f, 1.00409031e-01f, 2.37387465e-03f, 3.69344145e-01f, 1.72078341e-01f, 1.24025978e-01f, -8.64520967e-02f, 3.16275001e-01f, 5.06458469e-02f,
  6.28406703e-02f, -2.36517325e-01f, -1.83457404e-01f, 2.08166111e-02f, -2.87409097e-01f, -1.85232237e-01f, -4.27243449e-02f, -3.96445423e-01f, 4.91041839e-02f, -2.16716394e-01f,
  -1.24006301e-01f, 4.51787204e-01f, -6.47139996e-02f, -3.20039779e-01f, -4.54082377e-02f, 9.63327009e-03f, 2.11741313e-01f, -3.34059261e-02f, -2.94797271e-01f, -1.66351274e-01f,
  -4.41692859e-01f, 2.19773144e-01f, -1.16797298e-01f, -5.91107737e-03f, -6.50950223e-02f, 3.24331671e-02f, -8.68088827e-02f, -3.07560444e-01f, 1.14711538e-01f, 2.27727219e-01f,
  1.65401876e-01f, -3.37755412e-01f, 3.40962075e-02f, 3.11392576e-01f, 5.35217710e-02f, 3.76791447e-01f, -8.48135427e-02f, -4.71353717e-02f, 4.04319763e-01f, -2.36486390e-01f,
  1.36473596e-01f, 2.50311136e-01f, -2.74756640e-01f, -9.27581191e-02f, -1.99621871e-01f, -5.69885857e-02f, 1.04552053e-01f, -2.07837090e-01f, 1.41429380e-01f, -1.01108169e-02f,
  1.79144874e-01f, 6.32367358e-02f, 1.03731370e-02f, -1.23707816e-01f, -2.56842405e-01f, 3.12790602e-01f, 4.01354507e-02f, -9.91830155e-02f, 3.44553053e-01f, -6.53701201e-02f,
  2.24589229e-01f, 2.52234209e-02f, -4.35375065e-01f, -5.92636839e-02f, 2.84741282e-01f, -4.91832256e-01f, 1.25355855e-01f, 1.41279653e-01f, 3.05201620e-01f, 3.70816827e-01f,
  -4.84472811e-01f, 5.93676753e-02f, 1.02436125e-01f, -3.41763318e-01f, -1.55922636e-01f, -3.49932104e-01f, 6.72763363e-02f, -2.93010831e-01f, 2.16317952e-01f, 5.78341559e-02f,
  3.03524267e-02f, 2.09160671e-01f, -1.85847983e-01f, 1.63969815e-01f, 1.17960945e-01f, 1.87612891e-01f, 5.29274791e-02f, 1.70951877e-02f, 1.00586757e-01f, 1.97221041e-01f,
  2.30706036e-01f, 1.67312890e-01f, 2.23564431e-02f, -3.22120428e-01f, 2.84216516e-02f, 1.33322095e-02f, 3.87643993e-01f, 1.22216672e-01f, 4.57132459e-01f, -7.71331117e-02f,
  -4.00982648e-01f, -2.27244943e-01f, -2.77348489e-01f, 3.81170601e-01f, -1.43472165e-01f, -2.26418629e-01f, -1.50712430e-01f, 3.32420737e-01f, 4.19588000e-01f, 1.04340516e-01f,
  -6.42392924e-03f, -4.35017675e-01f, 2.98539400e-01f, -1.47661790e-01f, 8.69913250e-02f, -1.92975178e-01f, -9.19775069e-02f, 1.80462942e-01f, -6.93923831e-02f, -3.96883786e-01f,
  -2.70450413e-02f, -2.05307622e-02f, -1.28564611e-01f, -3.06915585e-02f, -6.93570524e-02f, 6.92565814e-02f, -2.32782196e-02f, 4.47712513e-03f, 3.69975299e-01f, -9.77457091e-02f,
  6.63391575e-02f, 9.77975801e-02f, 3.40783030e-01f, 1.04040422e-01f, 2.06146225e-01f, 5.61023839e-02f, -2.02781409e-01f, 1.53514117e-01f, -2.76252329e-01f, -2.62803972e-01f,
  -1.25159770e-01f, -3.73771995e-01f, -2.48643309e-01f, 1.58386886e-01f, -1.35877449e-02f, -3.50568444e-01f, 1.37072325e-01f, -3.41172904e-01f, -2.13540941e-01f, -2.50910148e-02f,
  2.00249210e-01f, -9.03373677e-03f, -9.15061459e-02f, 3.04603279e-01f, -1.00336686e-01f, -1.69336930e-01f, 3.21122825e-01f, 2.03356352e-02f, 1.31144091e-01f, 7.38837346e-02f,
  -1.52014300e-01f, -3.81764829e-01f, 1.78047180e-01f, 3.54640633e-01f, 3.33108395e-01f, 3.52764636e-01f, 3.95062476e-01f, -3.07637714e-02f, -4.15520161e-01f, -1.32245496e-01f,
  -3.52788270e-01f, -1.13635518e-01f, 3.47011536e-02f, -3.71312052e-01f, -1.90326616e-01f, 1.30481973e-01f, -2.72969902e-01f, -2.16395184e-01f, -2.06413083e-02f, 2.64417946e-01f,
  -9.09115151e-02f, -7.18378946e-02f, -3.59760642e-01f, -1.87223777e-02f, 1.48401901e-01f, 7.27720335e-02f, -2.56779969e-01f, -4.86654676e-02f, -1.96173191e-01f, 5.07264622e-02f,
  -2.14985281e-01f, 3.20949584e-01f, -3.98140877e-01f, 1.84475392e-01f, 4.58255820e-02f, 4.97374646e-02f, -1.10255212e-01f, -1.79635450e-01f, -3.74374270e-01f, -1.41235471e-01f,
  -1.56390771e-01f, -3.33441406e-01f, 4.02468711e-01f, -2.27023393e-01f, 5.29261306e-04f, 3.98214221e-01f, 3.47834289e-01f, -7.42555968e-03f, 2.17316002e-01f, -2.79065762e-02f,
  1.77907914e-01f, 3.22623014e-01f, -2.52613097e-01f, 1.85126364e-01f, -1.14666549e-02f, 1.94439545e-01f, -2.20951457e-02f, 9.33590680e-02f, 6.93932399e-02f, -2.44142115e-01f,
  -1.09667167e-01f, 2.77460963e-01f, 3.47212255e-01f, -2.60494966e-02f, -2.43136123e-01f, 2.51810819e-01f, -1.41525920e-02f, -1.64573431e-01f, -5.61958790e-01f, -2.88659304e-01f,
  -5.02107926e-02f, 1.21192865e-01f, -2.98584312e-01f, 9.46466103e-02f, -8.13232511e-02f, -3.35169137e-01f, -2.43610635e-01f, -1.79137707e-01f, 3.23291481e-01f, -9.48798358e-02f,
  1.32788897e-01f, 1.08309582e-01f, 2.74010032e-01f, 1.09347291e-01f, -7.82895610e-02f, 2.79458135e-01f, -2.77031939e-02f, 1.16362624e-01f, 5.15987724e-02f, -3.90145369e-02f,
  -2.08465792e-02f, -1.39896557e-01f, -2.05527067e-01f, 8.53111595e-02f, 1.02498688e-01f, 4.94892538e-01f, -8.62349868e-02f, -1.41306132e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.43198130e-02f, 1.09088384e-01f, -5.48896119e-02f, -1.25749454e-01f, 1.89001322e-01f, -1.23686031e-01f, 4.06440534e-02f, -9.25445780e-02f, -1.50092551e-03f, -1.21113211e-02f,
  6.98013455e-02f, -7.70944655e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    