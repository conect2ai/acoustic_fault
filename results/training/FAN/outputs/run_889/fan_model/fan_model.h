/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.93256348e-01f, 3.17922145e-01f, 2.13911589e-02f, 9.20366645e-02f, 3.21819521e-02f, -1.11060388e-01f, -1.54051417e-03f, 1.24013424e-02f, 4.45009023e-02f, 1.00143567e-01f,
  -7.02823326e-02f, -1.36729017e-01f, -5.47717176e-02f, -1.48165539e-01f, -8.07209685e-02f, -3.40043567e-02f, 6.39189258e-02f, -8.85306820e-02f, -2.29033217e-01f, -8.06700289e-02f,
  3.57221439e-02f, -1.09415576e-02f, 4.87301759e-02f, 7.19670765e-03f, 1.12062387e-01f, -8.42144787e-02f, -8.17941409e-03f, 1.17010944e-01f, -5.22469915e-02f, 4.81025167e-02f,
  -2.39999622e-01f, 2.16046691e-01f, -9.44326669e-02f, 4.16212901e-02f, -6.06057420e-02f, -2.22336669e-02f, -3.95364538e-02f, 1.59104485e-02f, 3.48578915e-02f, -2.15468439e-03f,
  3.88581567e-02f, -3.23081464e-02f, -8.60207900e-02f, 6.22789226e-02f, 7.29108527e-02f, -1.44302575e-02f, 8.18663165e-02f, 9.07887593e-02f, 2.35872995e-02f, -2.76975650e-02f,
  -2.47544162e-02f, 1.09428421e-01f, 8.97095632e-03f, 4.77232039e-02f, 7.05270842e-02f, -5.27186096e-02f, 2.25904416e-02f, 6.77957013e-02f, -5.88542148e-02f, 1.85191393e-01f,
  5.74983582e-02f, 7.85885528e-02f, -4.59976271e-02f, 4.77038398e-02f, 3.26631702e-02f, 4.40512449e-02f, 3.77085316e-03f, -4.72046249e-02f, -4.26101647e-02f, 1.12178259e-01f,
  -5.34989126e-02f, -1.68219116e-02f, 3.91734205e-02f, -4.39801812e-03f, 5.08531146e-02f, -1.48544190e-02f, -7.68431872e-02f, 5.01314551e-02f, 1.03508616e-02f, -9.96244792e-03f,
  -4.04524133e-02f, 3.16247046e-02f, 3.13007981e-02f, -8.16801637e-02f, 2.10683979e-02f, 3.33849043e-02f, -6.65777503e-03f, -4.51596528e-02f, 9.77207720e-03f, 9.52805281e-02f,
  -2.22239152e-01f, -1.10715367e-01f, -4.21448462e-02f, 6.56532273e-02f, -5.65321557e-02f, 4.73909639e-02f, 3.52936015e-02f, -1.28529472e-02f, 4.14259732e-02f, -5.28341644e-02f,
  2.05195714e-02f, 4.43597399e-02f, -5.36739342e-02f, -4.77773100e-02f, -8.28702077e-02f, 1.11357523e-02f, 4.51146066e-02f, -4.76510413e-02f, -3.10822949e-02f, 2.08454840e-02f,
  8.52641370e-03f, -6.07293285e-03f, -1.35402411e-01f, -7.77113587e-02f, 4.54465114e-03f, -1.45657778e-01f, -1.00652464e-01f, -5.28472289e-02f, -1.56154886e-01f, -4.41877730e-02f,
  -1.52185872e-01f, 1.32364601e-01f, 2.82829255e-01f, -2.16235429e-01f, 2.38243863e-02f, 3.18727016e-01f, 4.88182873e-01f, 7.78669864e-02f, -1.71748668e-01f, -2.61587836e-03f,
  -1.25285447e-01f, -2.06511110e-01f, -6.22544847e-02f, -8.70136991e-02f, 1.42749324e-01f, 2.40196854e-01f, 1.91281989e-01f, 1.15465172e-01f, 8.56670178e-03f, 2.41442155e-02f,
  -6.52184784e-02f, 5.11179864e-03f, -1.90525338e-01f, 3.05901933e-02f, -6.75772652e-02f, -1.63504750e-01f, -3.68777737e-02f, -1.00848876e-01f, 9.83760431e-02f, -8.40212852e-02f,
  1.60109419e-02f, 7.68415555e-02f, 2.25792322e-02f, -4.82317396e-02f, -3.26780342e-02f, 5.58343455e-02f, 6.74906373e-02f, -5.97394854e-02f, 5.66478074e-02f, 7.25655034e-02f,
  -1.13939568e-01f, -8.65168646e-02f, 8.82506520e-02f, -1.14076003e-01f, -2.08589677e-02f, 2.16366680e-04f, -1.10713907e-01f, 7.82194212e-02f, 2.92067602e-02f, 1.00843702e-02f,
  -4.98108976e-02f, 1.23510353e-01f, 1.15487173e-01f, 7.90727735e-02f, 7.17223436e-02f, -4.08550948e-02f, 8.58262479e-02f, -4.99934554e-02f, 3.93914385e-03f, -1.03941923e-02f,
  8.87575746e-03f, -3.65582407e-02f, -4.66660224e-02f, 7.30810314e-02f, 1.09673562e-02f, -6.08214289e-02f, -3.25570330e-02f, -3.21618691e-02f, -1.71663996e-03f, -2.35858113e-02f,
  -4.17697094e-02f, 1.41803250e-02f, -1.20037803e-02f, -2.57561505e-02f, -5.43937497e-02f, 1.99632421e-02f, 1.25595136e-02f, 1.07842321e-02f, -2.14080829e-02f, 2.21792851e-02f,
  -7.87771344e-02f, 5.48632583e-03f, -3.53477895e-02f, -2.28342833e-03f, 8.32894742e-02f, 1.69873983e-02f, 1.58400945e-02f, -1.77187915e-03f, -9.54893231e-02f, -2.91730911e-02f,
  -2.20562175e-01f, 2.11204529e-01f, -4.18030843e-02f, 7.01148063e-02f, -9.06886011e-02f, 1.39712049e-02f, -5.44438045e-03f, 3.45976688e-02f, -5.66674396e-02f, 6.70623183e-02f,
  5.68462536e-03f, 4.15887274e-02f, 2.06947569e-02f, 4.91313972e-02f, 2.60837860e-02f, 3.01527902e-02f, -3.07400767e-02f, 2.55444255e-02f, -1.76781379e-02f, -2.79484340e-03f,
  3.73197272e-02f, 4.69030291e-02f, -5.13616651e-02f, 5.16285859e-02f, -9.47582349e-03f, 5.24691604e-02f, 1.66200288e-02f, 5.26475497e-02f, 1.33401081e-01f, 2.66880114e-02f,
  -1.11509100e-01f, 3.15553807e-02f, 1.57588139e-01f, 2.53285263e-02f, 7.07494766e-02f, 3.88231874e-02f, 2.46255338e-01f, 5.31267263e-02f, 3.46422493e-02f, 1.48972228e-01f,
  3.21263783e-02f, -4.06294204e-02f, -2.15772968e-02f, -7.77646527e-02f, 4.14804509e-03f, 5.84832616e-02f, 4.27886890e-03f, -9.97293293e-02f, 7.00217560e-02f, -2.37399023e-02f,
  -8.06727335e-02f, -1.40973348e-02f, -1.43795246e-02f, 3.96175273e-02f, -5.26314117e-02f, -4.20348346e-02f, 1.22938275e-01f, 5.91636561e-02f, 6.93161860e-02f, 5.56516275e-02f,
  6.95574358e-02f, -3.06664743e-02f, -7.87961297e-03f, -4.12998982e-02f, -3.26435380e-02f, -4.13857810e-02f, 1.32304728e-02f, 8.31358060e-02f, 7.36837760e-02f, 2.44179312e-02f,
  -4.65187356e-02f, 1.99952144e-02f, -9.15882960e-02f, -5.21727949e-02f, 9.35381092e-03f, -1.97320059e-02f, 1.37949819e-02f, 1.98812298e-02f, 1.01373605e-01f, 1.87664269e-03f,
  3.34275253e-02f, -2.88562365e-02f, -4.58672680e-02f, 4.98107374e-02f, 3.03042377e-03f, 8.51351861e-03f, -1.95379574e-02f, 5.80246188e-02f, 2.41079107e-02f, -1.93298273e-02f,
  3.41532007e-02f, -2.60452125e-02f, -2.42357347e-02f, -1.63033381e-02f, 4.29569371e-02f, 5.81793711e-02f, -9.87211019e-02f, 7.22691864e-02f, 2.96741370e-02f, 3.05783283e-02f,
  -3.97670418e-02f, 7.87032545e-02f, 3.27264071e-02f, 4.77515943e-02f, -3.26634683e-02f, 7.95576945e-02f, 3.01833805e-02f, -4.14105169e-02f, -6.10046126e-02f, -6.81968182e-02f,
  -4.20104004e-02f, 4.43231910e-02f, 1.65719576e-02f, -7.54615441e-02f, -5.27330376e-02f, 3.27563807e-02f, 5.05629443e-02f, -5.97431660e-02f, -1.41544612e-02f, 8.46058801e-02f,
  -4.54512984e-02f, -5.70314117e-02f, -1.75310168e-02f, -3.78704071e-02f, 6.09984323e-02f, -1.74645185e-02f, 7.44946599e-02f, 5.92369260e-03f, 3.48608382e-03f, 1.12482626e-02f,
  5.09455279e-02f, -2.01295018e-02f, -4.81739827e-02f, -4.61448096e-02f, 2.59784721e-02f, -1.04207620e-02f, 2.61806361e-02f, -5.63788749e-02f, -1.89756304e-02f, 7.27064684e-02f,
  5.04939817e-04f, 4.55380827e-02f, 2.73736585e-02f, 6.28712848e-02f, 3.16128917e-02f, -1.80525277e-02f, 1.26721933e-01f, 9.37675387e-02f, 3.30454148e-02f, 1.68890789e-01f,
  -2.63256252e-01f, 2.79554784e-01f, 1.70403756e-02f, -4.36619855e-02f, 1.27714336e-01f, 1.72862131e-02f, 5.15138432e-02f, -2.32457146e-02f, 4.26297933e-02f, 1.04968295e-01f,
  1.03846140e-01f, -8.60004425e-02f, -1.59500428e-02f, -8.10647309e-02f, -2.64870137e-01f, 3.21027599e-02f, -4.24256101e-02f, -2.89779097e-01f, -3.35772991e-01f, -1.17362723e-01f,
  9.41561666e-05f, -9.60307270e-02f, -1.36941299e-01f, -1.19553722e-01f, 7.75914043e-02f, 9.14484560e-02f, 1.49441838e-01f, -6.50886795e-04f, 9.09429267e-02f, 1.21005841e-01f,
  1.39649391e-01f, -1.11606913e-02f, -1.41978115e-01f, -2.02951431e-02f, 5.44715822e-02f, -7.34227970e-02f, -4.85820249e-02f, -4.03019972e-02f, 3.64130945e-03f, 7.07677379e-02f,
  5.85446283e-02f, 9.47018340e-03f, -8.65844116e-02f, 7.16976672e-02f, 2.64940206e-02f, -1.27495360e-02f, -3.54910046e-02f, -7.69995824e-02f, -1.05934471e-01f, 6.12594336e-02f,
  6.55933022e-02f, -5.98713346e-02f, -7.96681568e-02f, 4.46804389e-02f, -1.50647238e-01f, -1.67443171e-01f, 2.84887869e-02f, -8.07813033e-02f, -1.01645626e-01f, 2.85134818e-02f,
  7.21267643e-05f, 5.08665666e-03f, 5.49919121e-02f, 5.90243787e-02f, 3.69905457e-02f, -1.60676744e-02f, -6.67982036e-04f, 7.19759837e-02f, 6.04619570e-02f, -8.39980878e-03f,
  -3.21717672e-02f, -5.82256652e-02f, -8.68855324e-03f, 1.47022866e-03f, 2.73859948e-02f, 2.01643333e-02f, -4.46866751e-02f, 6.03103079e-02f, 1.09848417e-02f, -7.82227144e-02f,
  4.76804897e-02f, -1.51905054e-02f, 8.42606798e-02f, 4.57221568e-02f, 4.05258425e-02f, -1.07990138e-01f, 7.16880411e-02f, 1.57217272e-02f, -1.52164232e-02f, 2.26141699e-02f,
  1.84048831e-01f, -1.33136302e-01f, -2.70242821e-02f, -3.49673815e-02f, 2.17889845e-02f, 3.31245959e-02f, 1.10053927e-01f, -2.38104742e-02f, 4.75198552e-02f, -4.34113592e-02f,
  -5.77590801e-02f, 4.66764383e-02f, 1.40935466e-01f, -1.20822936e-02f, -5.20200916e-02f, 7.89874792e-03f, 5.47755435e-02f, 3.17513533e-02f, -5.59804076e-03f, 1.69014513e-01f,
  8.03843886e-02f, -1.52017400e-02f, 1.97001570e-03f, -2.26833615e-02f, 1.40468997e-03f, -7.41100013e-02f, 1.12017222e-01f, 4.50569615e-02f, -7.44208321e-02f, 1.87912971e-01f,
  -2.55890399e-01f, 1.21092610e-01f, -4.66444455e-02f, -2.73303855e-02f, 3.01223677e-02f, -8.93654749e-02f, 2.23502424e-02f, -4.98093143e-02f, -8.32978189e-02f, 6.77836835e-02f,
  6.75148666e-02f, -1.20105647e-01f, -4.35652323e-02f, 1.38737122e-02f, -1.57382935e-01f, 1.80344075e-01f, 1.01796202e-01f, 7.55298557e-03f, -1.38691276e-01f, -5.06584793e-02f,
  7.76902735e-02f, 1.01211816e-01f, -1.03435844e-01f, 5.64104617e-02f, 1.87172562e-01f, 8.85841027e-02f, 1.03710473e-01f, 2.38748882e-02f, 9.43510607e-02f, 4.07828152e-01f,
  1.28339410e-01f, 3.42242830e-02f, -1.02449201e-01f, 3.17521989e-02f, 5.09313308e-03f, 2.01475434e-02f, 3.99264805e-02f, 2.16625631e-02f, 3.60013805e-02f, 1.91977546e-02f,
  -3.85982729e-02f, 4.86334078e-02f, 1.28314737e-02f, -1.55046731e-02f, 6.29057586e-02f, -1.13537337e-03f, 3.74260210e-02f, -5.47136031e-02f, -1.13600194e-02f, 4.77924310e-02f,
  9.98524651e-02f, -8.90452322e-03f, 4.72050384e-02f, 7.12377131e-02f, -8.56025070e-02f, -2.65244246e-02f, -2.17194650e-02f, 6.06798306e-02f, 5.79524152e-02f, 2.22630471e-01f,
  -1.07942736e-02f, -2.36342289e-02f, -1.50089851e-02f, 3.04310806e-02f, -1.82714667e-02f, -4.39628661e-02f, 8.56928676e-02f, -1.79172661e-02f, -1.52402800e-02f, 5.98528311e-02f,
  -1.01145543e-02f, -2.35463455e-02f, 8.23882818e-02f, 2.84149963e-02f, 3.40029746e-02f, 5.27945161e-02f, -4.94665541e-02f, -1.66750439e-02f, 2.75269691e-02f, 5.94079085e-02f,
  -1.30234420e-01f, -2.31420249e-02f, 6.83255494e-02f, 1.06229531e-02f, 9.92937386e-03f, 6.70225173e-02f, 6.23508207e-02f, -1.09651230e-01f, -4.44753468e-02f, -9.80378389e-02f,
  2.91144736e-02f, -1.73884183e-01f, 7.66149461e-02f, 3.66142183e-03f, 8.70562065e-03f, 2.63682455e-02f, -5.02378643e-02f, 4.37234044e-02f, -9.69628766e-02f, -3.70836295e-02f,
  -1.59650873e-02f, -1.12766027e-01f, -2.19413335e-03f, 2.24408507e-02f, 6.23684265e-02f, 6.74420521e-02f, -5.60629880e-03f, -2.68645696e-02f, 5.63090108e-03f, -1.92629211e-02f,
  9.83378384e-03f, 5.30505888e-02f, -1.07147023e-01f, 2.02291086e-02f, 9.85354930e-03f, -5.44122905e-02f, 8.14475939e-02f, -6.74962103e-02f, -1.10059746e-01f, 1.76005519e-03f,
  -3.16658199e-01f, -1.70804244e-02f, 1.20882943e-01f, -1.10239558e-01f, -5.47561832e-02f, -1.23584956e-01f, -2.37082973e-01f, -7.77132958e-02f, -5.36650680e-02f, -1.10499319e-02f,
  1.91008486e-02f, -1.04162050e-03f, 1.02701679e-01f, 1.53211519e-01f, 2.23736968e-02f, -5.50136901e-02f, 3.62104662e-02f, 7.58110080e-03f, -5.43274544e-02f, -9.57175419e-02f,
  4.18374725e-02f, -8.67907889e-03f, -2.86422968e-02f, -1.41147733e-01f, 7.49142915e-02f, -6.23054095e-02f, 8.93030241e-02f, 2.03427877e-02f, 1.89166695e-01f, 2.06413269e-01f,
  3.53306383e-01f, 1.30260035e-01f, -3.78493369e-02f, -3.01045123e-02f, 1.19784512e-01f, -6.43866360e-02f, 3.10853720e-02f, 2.42523625e-02f, -3.12638171e-02f, 4.24254239e-02f,
  3.68393920e-02f, 1.39824646e-02f, -6.76647294e-04f, 5.91989374e-03f, -5.50635792e-02f, 2.51423363e-02f, 1.06260534e-02f, 5.32914102e-02f, 2.37371866e-02f, 7.96224177e-02f,
  1.45279542e-01f, 1.43398389e-01f, 1.02363974e-02f, 6.77299798e-02f, 9.74127129e-02f, 4.80072647e-02f, 1.28116142e-02f, 1.35756180e-01f, 2.33300738e-02f, -1.55716790e-02f,
  6.36365730e-04f, 2.79806107e-02f, 6.10348135e-02f, -9.15547311e-02f, -9.14164484e-02f, -1.04462966e-01f, 5.77014987e-04f, 4.88864165e-03f, -3.44753824e-02f, -3.47119123e-02f,
  -7.11138360e-03f, -1.96920317e-02f, 1.91267507e-04f, -6.79311529e-03f, -3.12749222e-02f, 4.71291915e-02f, -3.86365540e-02f, 7.07027223e-03f, 1.40341846e-02f, -1.81602128e-02f,
  1.67358536e-02f, -1.32374745e-02f, 1.02347985e-01f, 7.59480521e-03f, 1.27324358e-01f, -1.87013261e-02f, 7.98097532e-03f, -2.95001287e-02f, -2.01963801e-02f, 3.54453959e-02f,
  -1.73426151e-01f, 9.46749225e-02f, -7.99105167e-02f, 1.73218437e-02f, 4.12025750e-02f, 1.84394009e-02f, 5.04790768e-02f, 7.43731335e-02f, 8.37187767e-02f, -8.61136541e-02f,
  -4.17903550e-02f, -6.92980513e-02f, -2.42676884e-02f, -4.07727510e-02f, -1.11597851e-01f, -4.35042381e-02f, -8.92917626e-03f, -1.82282235e-02f, -4.42263158e-03f, 4.53710258e-02f,
  -5.14025092e-02f, -1.60539627e-01f, -1.55540824e-01f, -3.93442363e-02f, 8.11979473e-02f, -1.13677174e-01f, -3.01640164e-02f, 1.30573362e-02f, -5.91756701e-02f, -3.06843787e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.24471799e-01f, -6.59178197e-02f, -1.16513111e-01f, 1.85865939e-01f, 1.02001309e-01f, 2.53469218e-02f, -3.49446610e-02f, -4.30132560e-02f, 1.26161024e-01f, 1.42819747e-01f,
  1.15389682e-01f, 1.96869418e-01f, 1.41639620e-01f, 9.77959186e-02f, 5.08997291e-02f, 1.27067074e-01f, 3.15236896e-02f, 9.53365937e-02f, 5.02033951e-03f, 2.18126178e-02f,
  1.12477697e-01f, 4.60328758e-02f, -1.12857483e-01f, -7.48938918e-02f, 1.49826095e-01f, 1.58930138e-01f, 9.11466405e-03f, -3.79590578e-02f, 4.42949720e-02f, 7.24900812e-02f,
  -1.01642450e-02f, -4.71793674e-03f, 9.40706283e-02f, 7.45760603e-03f, -2.71541346e-03f, 2.22884137e-02f, 4.35397811e-02f, -2.69143786e-02f, -2.13496573e-02f, 6.55384511e-02f,
  -9.40879621e-03f, 4.16886155e-03f, -7.98050035e-03f, -3.61784399e-02f, -5.28102778e-02f, -3.25606167e-02f, 4.68027666e-02f, 1.16213188e-02f, -5.88714331e-02f, -1.10195600e-03f,
  2.72122305e-03f, -1.74774099e-02f, -1.22318126e-01f, -1.15603037e-01f, 3.50602604e-02f, 7.56042525e-02f, -7.68361762e-02f, -2.79114954e-02f, -5.21548800e-02f, 1.14609217e-02f,
  -3.18253040e-02f, 7.74342120e-02f, 1.36431241e-02f, -2.60867905e-02f, 2.03713123e-02f, 1.09267473e-01f, 1.14361189e-01f, 8.59769136e-02f, 6.88630491e-02f, -9.94445756e-02f,
  8.43619406e-02f, -3.51417512e-02f, 2.49589048e-02f, -3.67890820e-02f, 3.46792303e-02f, -1.05435938e-01f, -5.05950935e-02f, -2.41059661e-02f, 1.40056182e-02f, -4.69436385e-02f,
  1.56956129e-02f, 9.23146121e-03f, 6.21274151e-02f, -4.78350036e-02f, 1.90310646e-02f, 5.44928946e-02f, 5.16128205e-02f, -4.11474518e-02f, 3.12480237e-02f, 7.63934152e-03f,
  5.90553097e-02f, -9.76472124e-02f, 9.03967023e-02f, -5.54117225e-02f, -4.80589308e-02f, 5.26240394e-02f, 1.66683868e-02f, -2.04174239e-02f, -5.44348881e-02f, 6.27740426e-03f,
  -4.35633771e-02f, -7.31412545e-02f, 2.87786480e-02f, -2.96961777e-02f, -5.41308261e-02f, 8.83427914e-03f, 6.53954968e-02f, -3.79477702e-02f, 1.69907305e-02f, -1.21135637e-01f,
  4.38023061e-02f, -6.59201369e-02f, 9.27781686e-03f, -7.34223202e-02f, -3.15968655e-02f, 6.26475830e-03f, -4.63049747e-02f, -1.48320794e-01f, -3.94692598e-03f, -1.42915204e-01f,
  3.56980503e-01f, -1.25516132e-01f, -2.19404548e-01f, 3.96906771e-02f, -5.25139458e-02f, -8.87534916e-02f, -2.80360971e-03f, 1.14064336e-01f, 1.76389236e-02f, -1.28305167e-01f,
  -1.44862175e-01f, 6.14850484e-02f, -8.62848908e-02f, 3.79986055e-02f, 1.22501448e-01f, 8.68408754e-03f, -4.03720178e-02f, 8.25936720e-02f, -5.41885151e-03f, -5.64796440e-02f,
  5.38706370e-02f, -4.99921478e-02f, 1.27843261e-01f, -3.74318473e-02f, -9.45879295e-02f, -7.72887021e-02f, -1.36407197e-01f, -1.01714870e-02f, -1.09533951e-01f, -9.43246707e-02f,
  -2.14720398e-01f, -1.28182411e-01f, -6.20929748e-02f, 1.00895777e-01f, 2.23971857e-03f, 2.60499977e-02f, 5.26161939e-02f, 3.99796255e-02f, -1.24184340e-02f, -5.52011058e-02f,
  -6.53804988e-02f, -7.39935338e-02f, -6.08723015e-02f, 6.45905063e-02f, 3.85788307e-02f, 5.97777404e-03f, -8.52886811e-02f, -7.16990530e-02f, -1.78953186e-02f, -9.40900892e-02f,
  -8.55939686e-02f, -3.85670997e-02f, -4.56213094e-02f, 5.29998839e-02f, -6.91341162e-02f, -3.37343737e-02f, -1.12366252e-01f, -1.32816806e-01f, -6.71585510e-03f, 3.52808051e-02f,
  4.90284264e-02f, 5.44381700e-02f, -3.11727393e-02f, -4.60294299e-02f, 8.96798670e-02f, -4.54958379e-02f, -1.79912895e-02f, 1.38322096e-02f, 4.05602716e-03f, 1.08256206e-01f,
  5.20022064e-02f, -7.62735456e-02f, -4.65671904e-02f, -2.10896377e-02f, -2.95072962e-02f, -7.76519207e-03f, 6.01740256e-02f, 3.77817750e-02f, 1.25920540e-02f, -6.99207047e-03f,
  -4.04394530e-02f, 3.86036187e-02f, -6.75805956e-02f, -7.72146210e-02f, -4.75709662e-02f, 2.60396488e-02f, -1.90750547e-02f, 7.88274631e-02f, 3.97715196e-02f, -6.45645931e-02f,
  1.69657364e-01f, -9.99988094e-02f, -1.88268013e-02f, 7.10136667e-02f, -2.67189462e-02f, 2.63395384e-02f, 4.66886051e-02f, 2.74120853e-03f, -8.59908089e-02f, -1.15223564e-02f,
  -3.43553536e-02f, -4.09024321e-02f, -5.87832108e-02f, -6.07179850e-02f, -5.71230128e-02f, 1.08147040e-02f, -7.69389048e-03f, 8.23328868e-02f, -6.36273101e-02f, -7.21567273e-02f,
  -1.34006729e-02f, 1.23776816e-01f, 1.59949630e-01f, 1.02215737e-01f, 6.20481372e-02f, 1.26248464e-01f, -2.64102165e-02f, 3.61655429e-02f, 8.26715678e-02f, 2.19572410e-01f,
  8.77471119e-02f, -1.08175054e-01f, 8.32642987e-02f, 1.34836242e-01f, 4.61881272e-02f, 4.09713462e-02f, -9.93764121e-03f, 7.04170242e-02f, 8.64978880e-02f, 7.59704933e-02f,
  -1.20746344e-02f, 4.52077389e-02f, 9.69699249e-02f, 2.82605737e-02f, 4.66952100e-02f, -3.24877538e-02f, -5.65640144e-02f, 1.19505888e-02f, -3.65381874e-02f, 3.76873389e-02f,
  6.62391167e-03f, -6.89111464e-03f, 5.42210415e-02f, 6.65795356e-02f, 6.29623830e-02f, 1.13622159e-01f, 2.87070405e-02f, 4.07096632e-02f, -6.99796230e-02f, 1.04362227e-01f,
  1.06569350e-01f, -5.38157932e-02f, 1.08530186e-01f, 6.73302710e-02f, 2.55931523e-02f, -2.87085283e-03f, 8.31601024e-02f, 2.68694535e-02f, -1.94595810e-02f, -4.53589968e-02f,
  -3.33954096e-02f, -6.24295175e-02f, 6.00957163e-02f, -1.52893108e-03f, 3.92368585e-02f, 6.57320023e-03f, -1.07647128e-01f, -3.66429389e-02f, 7.18655735e-02f, -4.09900211e-02f,
  -8.16583261e-02f, -3.66048440e-02f, -4.05660048e-02f, 4.41090390e-02f, 9.08697546e-02f, -3.92817073e-02f, 5.01812063e-02f, 8.37899372e-02f, 2.37221066e-02f, 2.63072420e-02f,
  -4.21307981e-02f, 3.03336754e-02f, -1.27508026e-02f, -8.92253071e-02f, -1.00705020e-01f, 2.07186881e-02f, 1.12059619e-02f, -8.37996304e-02f, -6.89741746e-02f, -8.10693193e-04f,
  -1.14177698e-02f, 3.14859226e-02f, 4.49464619e-02f, -1.22588007e-02f, 5.81493676e-02f, -1.90701168e-02f, -8.53243098e-02f, 7.96844158e-03f, 5.16141020e-02f, -5.69335856e-02f,
  -6.64548874e-02f, 6.68485239e-02f, -3.48384008e-02f, -5.21120057e-02f, -7.24867955e-02f, 1.98080838e-02f, 2.77637783e-02f, 1.23475231e-02f, -1.16457129e-02f, 2.72238385e-02f,
  3.97471972e-02f, 7.65478751e-03f, 2.30824295e-02f, 5.25179207e-02f, -3.40879709e-02f, 6.69248402e-02f, 7.81979319e-03f, 4.21338119e-02f, -5.59957065e-02f, 8.73748735e-02f,
  2.65597552e-02f, 3.58261466e-02f, 7.24319890e-02f, -4.29767556e-02f, -5.57821617e-02f, 5.40920906e-02f, 1.60499904e-02f, -2.12732572e-02f, -6.92452043e-02f, -6.58943430e-02f,
  -9.67671499e-02f, 4.33547646e-02f, 2.40738336e-02f, -4.79237847e-02f, -2.91946391e-03f, -1.65922306e-02f, -1.10220890e-02f, -4.21054550e-02f, 5.24972565e-02f, 2.45999880e-02f,
  -1.45959795e-01f, -9.10909995e-02f, -1.40672937e-01f, 9.04755443e-02f, 4.36026528e-02f, 2.96893977e-02f, -1.85842022e-01f, -1.03699535e-01f, 8.35631937e-02f, 7.90659979e-04f,
  3.35085057e-02f, 1.42843708e-01f, -3.29878256e-02f, 1.21518318e-02f, -8.87940153e-02f, 1.75815653e-02f, -3.39716114e-02f, -1.66515097e-01f, -1.41289979e-01f, -5.90911228e-03f,
  1.15482613e-01f, 7.68999830e-02f, 2.66098101e-02f, 3.30403373e-02f, 1.36161268e-01f, 1.19108610e-01f, 1.13893799e-01f, 7.44645298e-02f, -1.86529942e-02f, 1.15645356e-01f,
  6.28720224e-02f, -9.91803315e-03f, -9.22974050e-02f, 1.36326417e-01f, 8.53974186e-03f, -6.82415590e-02f, -5.33427857e-02f, 2.85561811e-02f, -4.81176376e-02f, -4.25581075e-02f,
  2.39106361e-02f, -1.90829262e-02f, 8.89659375e-02f, -5.52291572e-02f, -3.07672620e-02f, -9.57616195e-02f, -2.55005937e-02f, -9.80968550e-02f, -1.07445739e-01f, 1.07717309e-02f,
  8.50503147e-02f, 1.36197228e-02f, -9.56280977e-02f, -5.62751293e-02f, -2.87128128e-02f, -4.23834883e-02f, -9.27574337e-02f, -9.07920115e-03f, -7.29997531e-02f, -5.40629849e-02f,
  4.47004735e-02f, 4.10380587e-02f, 3.57235186e-02f, 2.92244535e-02f, 6.24948293e-02f, 9.26840007e-02f, 1.20363273e-02f, 2.03396790e-02f, -3.37138139e-02f, -5.95608726e-02f,
  -1.75030585e-02f, 4.99573722e-02f, -1.63076464e-02f, -2.98820101e-02f, 8.26279894e-02f, 5.84691018e-02f, 6.49278983e-02f, -5.54568805e-02f, -2.04568636e-03f, 1.65566411e-02f,
  -6.48203418e-02f, -9.12536588e-03f, 3.03519350e-02f, 1.18731791e-02f, -4.20169085e-02f, -3.77655178e-02f, -5.01913056e-02f, -2.56901756e-02f, -9.05215889e-02f, -1.78606715e-02f,
  -1.80300567e-02f, -1.91191339e-03f, 2.80171540e-02f, -3.03211007e-02f, 6.60731364e-03f, 2.84964088e-02f, 5.99418543e-02f, 6.53893799e-02f, 7.48548284e-02f, 3.54723893e-02f,
  6.45584092e-02f, -4.26156856e-02f, -3.06083616e-02f, -3.83570381e-02f, -3.45402490e-03f, 5.83936945e-02f, -2.51732916e-02f, -9.43041779e-03f, -5.61899953e-02f, -6.75707906e-02f,
  -2.31436733e-02f, 3.88783514e-02f, -1.27762362e-01f, -7.06730187e-02f, 9.31633264e-02f, 6.57868758e-02f, -1.63743217e-02f, 3.85109782e-02f, -1.72251388e-02f, -1.10829122e-01f,
  -1.84877515e-01f, -5.99927939e-02f, -1.30291909e-01f, -1.66024834e-01f, -7.36079067e-02f, -5.48950918e-02f, -1.04246281e-01f, -1.30248265e-02f, 2.78418250e-02f, -1.35740042e-01f,
  -2.33169366e-02f, -6.61617070e-02f, 1.23248193e-02f, -8.83216858e-02f, 5.36105223e-03f, -1.37425467e-01f, -1.32681772e-01f, -1.66454121e-01f, -4.73397598e-02f, -8.63266885e-02f,
  -6.35749772e-02f, -1.08531401e-01f, -1.82103753e-01f, 1.46911629e-02f, -7.42134154e-02f, -1.14317589e-01f, -9.81158242e-02f, -5.24913296e-02f, -1.04297161e-01f, -5.38775362e-02f,
  3.37361135e-02f, -1.28152460e-01f, -3.98184210e-02f, -3.97847220e-02f, -1.94239039e-02f, 4.26274054e-02f, 4.98618409e-02f, -9.55261365e-02f, -5.73961763e-03f, -2.36016680e-02f,
  -1.17265016e-01f, -2.41046119e-02f, 5.64617068e-02f, -6.67426139e-02f, -5.28853573e-02f, -4.93303202e-02f, -8.63774940e-02f, -1.26609012e-01f, -7.22451136e-02f, -7.01711699e-02f,
  -7.84993842e-02f, -6.93509951e-02f, -2.49036923e-02f, -5.02404533e-02f, 5.87679595e-02f, 2.69172098e-02f, 5.60567304e-02f, -4.39937954e-04f, 2.74961088e-02f, -4.58171889e-02f,
  -2.03338824e-02f, -3.52348574e-02f, -7.79021755e-02f, -7.51333684e-02f, -1.99371949e-02f, -7.09606409e-02f, -2.19815951e-02f, 2.19999477e-02f, 7.80535489e-02f, -6.49233237e-02f,
  -2.84595639e-02f, -4.28958982e-02f, 1.57251600e-02f, 2.75253076e-02f, 5.62495366e-02f, 1.92009117e-02f, 1.49565926e-02f, 8.92203953e-03f, 3.94591056e-02f, -1.58973306e-03f,
  8.73725489e-02f, 1.22397430e-01f, 2.73606628e-02f, -2.19023507e-02f, -1.01810932e-01f, 1.48715228e-02f, 1.15332901e-02f, 4.90589328e-02f, 7.21722320e-02f, 6.84082434e-02f,
  1.60762206e-01f, -1.57029003e-01f, -4.48513813e-02f, -3.47762518e-02f, -1.91440228e-02f, -6.72058389e-02f, 8.02459940e-03f, -6.52273446e-02f, 6.41901121e-02f, 5.23574837e-02f,
  -7.80000910e-02f, 5.40877786e-03f, -6.55496493e-02f, 7.61127323e-02f, 2.87434831e-02f, -1.39915086e-02f, 6.15912024e-03f, -7.11152107e-02f, 8.50301385e-02f, 7.63894990e-02f,
  3.48231569e-02f, 4.43370752e-02f, 9.61307958e-02f, -1.35704270e-02f, 1.25760049e-01f, -4.86022495e-02f, 8.35341588e-02f, -3.94530687e-03f, -6.03800900e-02f, 9.03041735e-02f,
  5.59071340e-02f, -5.33129424e-02f, 5.98212518e-03f, -2.84000896e-02f, 3.12524363e-02f, 1.09068759e-01f, 6.29580021e-02f, -3.93702649e-02f, 6.79637045e-02f, 1.23221219e-01f,
  9.05234888e-02f, 1.36292484e-02f, -4.51863818e-02f, -3.53566706e-02f, 4.58656065e-02f, 2.97040995e-02f, 4.38878685e-02f, -6.12911023e-02f, -6.03876822e-02f, -6.37176782e-02f,
  3.50832217e-03f, 1.75859295e-02f, -1.20308369e-01f, -1.15516327e-01f, -3.87775488e-02f, 2.51306277e-02f, -1.84405390e-02f, 1.31206494e-02f, -8.57347175e-02f, -5.82305714e-02f,
  -8.67188945e-02f, -9.69778672e-02f, -2.88075283e-02f, -8.95487741e-02f, 5.61146904e-03f, 2.56950781e-03f, -4.53712158e-02f, 8.39632377e-02f, 4.32750918e-02f, -9.49456245e-02f,
  -2.97567975e-02f, 3.03262267e-02f, -8.64329711e-02f, -6.10104688e-02f, -8.27511214e-03f, -2.00326759e-02f, 6.08422905e-02f, -6.48088753e-02f, -7.76855648e-02f, -2.00805385e-02f,
  -7.43648633e-02f, -9.19835120e-02f, 6.65994957e-02f, -7.96023011e-02f, 1.07639348e-02f, -1.02563556e-02f, 5.26912659e-02f, -5.74540570e-02f, -6.71729892e-02f, -1.07400566e-01f,
  4.31236252e-02f, -9.87943038e-02f, -3.53188291e-02f, 2.59794202e-02f, -5.28521240e-02f, -4.95753773e-02f, -9.88113433e-02f, -1.83804389e-02f, -2.21921764e-02f, 1.82881427e-03f,
  1.33563420e-02f, 1.28424354e-02f, -5.69965728e-02f, 1.50618069e-02f, -2.17072642e-03f, -1.31089594e-02f, 6.40163347e-02f, 1.85244232e-02f, 6.55769855e-02f, -1.63373165e-02f,
  -2.42670476e-02f, 5.48964776e-02f, -2.00964650e-03f, -2.84177717e-03f, 5.47118373e-02f, 4.37513590e-02f, -2.78862100e-02f, -5.78172784e-03f, 2.31884401e-02f, 9.92868915e-02f,
  -1.43103793e-01f, 9.76347923e-02f, 1.37686478e-02f, -3.19128600e-03f, -7.87594393e-02f, 2.62809973e-02f, 5.19413762e-02f, -2.07500849e-02f, -1.05626218e-01f, 1.09456936e-02f,
  -1.11368094e-02f, 3.30792069e-02f, -3.63463238e-02f, 1.42919889e-03f, -2.07973272e-02f, -6.10499503e-03f, 7.29444250e-02f, -8.93201679e-02f, 6.00392558e-02f, -8.37972313e-02f,
  8.62553790e-02f, 8.43341127e-02f, 5.34190275e-02f, 1.17076039e-02f, 4.46914919e-02f, 3.11414879e-02f, -6.42107949e-02f, -1.81402750e-02f, 4.51323874e-02f, 8.02614465e-02f,
  -1.49863750e-01f, 9.85572934e-02f, -6.40770346e-02f, -2.64204387e-03f, -1.42585533e-02f, -4.16606478e-02f, -1.09864846e-01f, -7.20786722e-03f, -7.58532733e-02f, 3.58352661e-02f,
  -7.18506277e-02f, -9.20194536e-02f, 1.66028123e-02f, -9.83668640e-02f, -1.62967503e-01f, 1.57481944e-03f, -1.47268167e-02f, -1.13884673e-01f, -2.53516912e-01f, -4.72531132e-02f,
  -1.19231634e-01f, -1.34627178e-01f, -1.55895412e-01f, -4.87287901e-02f, 8.66592824e-02f, -4.64095967e-03f, 9.73443091e-02f, -9.13601965e-02f, 4.03438956e-02f, -3.79005596e-02f,
  -2.56831162e-02f, 8.35423023e-02f, -6.90477267e-02f, 1.55096538e-02f, -2.46983813e-03f, -6.02712072e-02f, 4.57586572e-02f, -4.39800508e-02f, -1.38255674e-02f, -7.52483606e-02f,
  6.45929947e-02f, -5.82106411e-02f, -2.30859891e-02f, -8.62586871e-02f, -9.02638286e-02f, -9.19387788e-02f, 5.58263436e-02f, -6.07700832e-02f, -9.38524902e-02f, 1.60551886e-03f,
  -7.10161775e-02f, -1.58179268e-01f, 2.91466676e-02f, -8.69468525e-02f, -1.08576067e-01f, -5.41076846e-02f, 2.53154449e-02f, 1.60160046e-02f, -1.01762593e-01f, 1.60768077e-01f,
  1.23218067e-01f, 1.20568678e-01f, -1.09154880e-01f, -7.57592693e-02f, -5.87927818e-04f, -3.57053764e-02f, 3.52731645e-02f, -4.28625308e-02f, 7.48717412e-02f, -4.04969156e-02f,
  -2.04068311e-02f, 4.02818508e-02f, -2.38315556e-02f, -1.30823329e-02f, 4.65609655e-02f, 4.37841238e-03f, 5.25755174e-02f, -1.47289317e-02f, 4.65284064e-02f, 2.88870968e-02f,
  2.38263328e-02f, -5.28536364e-02f, 5.00182947e-03f, -2.82103028e-02f, 3.29460911e-02f, -5.60119078e-02f, -1.48083866e-02f, -6.18769899e-02f, -5.79183400e-02f, -1.06546484e-01f,
  1.36991203e-01f, -1.83422327e-01f, 7.49050900e-02f, 8.28299613e-04f, 8.79867375e-02f, 3.31162103e-02f, 5.44163361e-02f, -4.94958684e-02f, 9.75171402e-02f, -3.00507806e-02f,
  -5.36258146e-02f, 5.55093517e-04f, 1.17197827e-01f, 3.30564752e-02f, -8.06129910e-03f, -1.13163330e-01f, -2.02886434e-03f, -5.68366498e-02f, 2.71299295e-03f, -5.48158437e-02f,
  -4.71561924e-02f, -5.57949804e-02f, 5.21575511e-02f, 4.48823273e-02f, -1.93733182e-02f, -1.09948501e-01f, -3.21026705e-02f, 5.98674268e-02f, -5.00704236e-02f, 1.87914759e-01f,
  3.00029606e-01f, -1.79429144e-01f, -6.04242049e-02f, 1.44270390e-01f, -2.21473677e-03f, -8.48958455e-03f, -9.09205079e-02f, 4.42254879e-02f, 5.80588952e-02f, 3.20901275e-02f,
  4.30677930e-04f, 7.66552389e-02f, 1.53062955e-01f, 9.00595710e-02f, 5.37158139e-02f, -9.03932750e-02f, -1.87605303e-02f, 1.26990348e-01f, 1.96263134e-01f, 7.54011571e-02f,
  1.67024676e-02f, 2.65423004e-02f, -2.36179885e-02f, -6.69814134e-03f, 1.14552472e-02f, -4.95809987e-02f, -4.02198508e-02f, -4.34415974e-02f, -8.10592398e-02f, -1.20455571e-01f,
  2.91880080e-03f, -1.10377282e-01f, 1.60830483e-01f, 5.26440144e-02f, -1.11739971e-01f, -2.86933985e-02f, 9.84541625e-02f, -9.43076089e-02f, 8.77584144e-02f, 2.97881700e-02f,
  6.82252049e-02f, 8.26947112e-03f, -4.75661159e-02f, -1.06075376e-01f, -2.67617051e-02f, -6.62588626e-02f, 4.22239350e-03f, 8.02917685e-03f, 8.52570385e-02f, 2.77836658e-02f,
  -1.38412386e-01f, -1.25322733e-02f, -2.15781126e-02f, 4.80041653e-02f, 1.72493439e-02f, 9.62601006e-02f, -1.96716022e-02f, -6.41782656e-02f, -8.74282513e-03f, -8.94637108e-02f,
  9.18721259e-02f, 4.68955822e-02f, 8.57079625e-02f, 7.23969890e-03f, 1.96382143e-02f, 7.87857771e-02f, 8.24522153e-02f, -7.01076910e-02f, -1.04370080e-02f, -1.01647273e-01f,
  7.02577010e-02f, -1.06717153e-02f, 4.04111445e-02f, 7.06218705e-02f, 2.86108945e-02f, 1.63334850e-02f, -2.81151873e-03f, -5.25793526e-04f, 1.23204440e-02f, 5.36536936e-05f,
  -8.76257420e-02f, 1.56446397e-02f, -7.57110864e-02f, -4.80966792e-02f, 3.13465600e-03f, -2.86417566e-02f, 6.33923262e-02f, -8.40948597e-02f, -5.62589876e-02f, -2.44092476e-02f,
  1.22506864e-01f, 2.85027716e-02f, 7.31792301e-02f, 6.32308470e-03f, 2.28127763e-02f, 1.51539072e-02f, 1.97199993e-02f, -2.29055760e-03f, -1.32787198e-01f, 2.71512903e-02f,
  -1.15289278e-01f, -8.69433656e-02f, -9.13112238e-03f, -6.50325865e-02f, -2.26417389e-02f, 4.93910648e-02f, -1.31109864e-01f, 9.04368311e-02f, 2.47529522e-03f, -7.49545768e-02f,
  -5.13265990e-02f, 1.26583844e-01f, 1.68804705e-01f, 9.86969844e-02f, -2.97788233e-02f, 1.79816172e-01f, 6.44166246e-02f, 1.01343550e-01f, 4.88763303e-02f, 1.86663643e-02f,
  1.66813694e-02f, -7.20387250e-02f, 7.32145831e-03f, 6.96919113e-02f, -9.81051102e-02f, -5.88254146e-02f, 6.51802048e-02f, -6.29242957e-02f, 3.58923264e-02f, -2.76352968e-02f,
  -8.84895697e-02f, -5.67214787e-02f, -1.06914997e-01f, 1.09038623e-02f, 6.86629191e-02f, -4.17506360e-02f, -5.06903939e-02f, -1.60608124e-02f, -7.69398436e-02f, -4.62746881e-02f,
  -8.00802261e-02f, -6.20671315e-03f, -6.41337410e-02f, 1.18301129e-02f, -7.97347873e-02f, -6.46606982e-02f, -5.36529645e-02f, -8.18744823e-02f, 9.43245552e-03f, -3.22278356e-03f,
  5.79257086e-02f, -1.22808851e-01f, 1.90701485e-02f, -5.93069121e-02f, 7.66734183e-02f, 3.81929204e-02f, 5.40317819e-02f, 2.39712447e-02f, 3.17958444e-02f, 4.71060500e-02f,
  -3.41334119e-02f, -4.87553142e-02f, -1.58548970e-02f, 7.26476461e-02f, -1.83689464e-02f, 2.84283608e-02f, 8.02985355e-02f, 6.48290589e-02f, -9.68553051e-02f, -5.19073568e-02f,
  3.81947346e-02f, 3.24327522e-03f, -5.73873855e-02f, -3.49877477e-02f, -6.02003932e-02f, -4.51915823e-02f, -5.82676940e-02f, -4.39240262e-02f, -5.84094822e-02f, 1.36755556e-01f,
  1.50262807e-02f, -2.79303882e-02f, 7.12012872e-02f, -2.60092821e-02f, 1.00274421e-01f, 1.09113092e-02f, -8.11247006e-02f, -2.23284606e-02f, 2.32815966e-02f, -1.66512914e-02f,
  9.34387892e-02f, 1.16601391e-02f, -2.14117058e-02f, 2.38187667e-02f, -3.92015688e-02f, -8.72513950e-02f, 6.48319796e-02f, -9.15662292e-03f, 3.96281369e-02f, -3.66455130e-02f,
  -7.73772672e-02f, -1.25765622e-01f, 2.61685122e-02f, -5.31612560e-02f, -7.95694590e-02f, -2.28827652e-02f, 2.84080431e-02f, -1.13700345e-01f, -5.55095673e-02f, -4.78100590e-02f,
  7.34379813e-02f, -7.48112947e-02f, 5.25328331e-02f, 6.56294748e-02f, 1.98162929e-03f, -1.45775601e-02f, -4.32444252e-02f, 3.10581159e-02f, -7.88734853e-02f, -1.51364394e-02f,
  -1.12661652e-01f, -7.75268674e-02f, -1.03454590e-02f, -2.74290610e-02f, -5.36014028e-02f, 3.19036357e-02f, 3.40294205e-02f, -5.74814752e-02f, 5.77726886e-02f, -6.67440742e-02f,
  -5.84946480e-03f, -3.92125081e-03f, 9.29127559e-02f, 1.19665945e-02f, -7.68683404e-02f, -7.25862663e-03f, -1.81700122e-02f, 1.31525043e-02f, 7.03722164e-02f, 2.06030339e-01f,
  -1.08307764e-01f, -1.41254753e-01f, 1.73621535e-01f, -5.03350608e-02f, 3.80333364e-02f, 5.97036406e-02f, -3.39999907e-02f, -1.22983240e-01f, -7.08041294e-03f, -1.29323676e-01f,
  -2.81042214e-02f, -1.64403498e-01f, -3.37822922e-02f, 4.70168330e-03f, 6.37490526e-02f, -4.52384129e-02f, 2.16312204e-02f, -6.77227648e-03f, 1.36546016e-01f, 4.52607833e-02f,
  3.74448933e-02f, 6.05585240e-02f, -2.09013689e-02f, 1.39832438e-04f, -9.67431366e-02f, -5.56900427e-02f, 7.34062940e-02f, -4.84351628e-02f, 2.59298682e-02f, -8.86186585e-02f,
  3.68002951e-02f, -9.04339254e-02f, -4.69281711e-03f, -3.59927118e-02f, 7.85271749e-02f, 1.86919495e-02f, 4.24304465e-03f, -7.27312863e-02f, -4.84870151e-02f, 7.42404163e-02f,
  -3.17512825e-02f, -9.64656323e-02f, 7.47268498e-02f, 3.08807995e-02f, -6.66432306e-02f, -2.63118576e-02f, -3.44715565e-02f, 6.49034008e-02f, -9.94425565e-02f, -8.89841318e-02f,
  -8.94748420e-02f, 3.25228125e-02f, 5.54280467e-02f, 2.37472951e-02f, 3.70856673e-02f, -3.10425293e-02f, 5.51138781e-02f, -4.92702276e-02f, -8.20455421e-03f, -8.90478268e-02f,
  -7.06977770e-02f, -2.48719454e-02f, -2.22042594e-02f, 2.52579208e-02f, 7.26661533e-02f, 6.45296723e-02f, 7.81348795e-02f, -2.96100304e-02f, 3.29584419e-03f, -3.98359224e-02f,
  8.47767889e-02f, -2.65608802e-02f, 5.29659055e-02f, 3.80860828e-02f, -3.23118009e-02f, 7.93602243e-02f, 4.53952625e-02f, 2.92952098e-02f, -4.62179258e-02f, -7.38860748e-04f,
  8.42616931e-02f, -2.82598156e-02f, -3.78969051e-02f, 1.00665092e-01f, -1.67267732e-02f, 1.70561764e-02f, 6.99123293e-02f, 6.15884550e-02f, -1.76654439e-02f, -2.58890521e-02f,
  7.55214170e-02f, 1.15675749e-02f, -7.52419746e-03f, 6.12525605e-02f, -5.13822660e-02f, -3.26062809e-03f, -3.30014974e-02f, -1.95361692e-02f, 1.70019455e-02f, -5.60741872e-02f,
  -8.45621377e-02f, -3.09185013e-02f, 8.47489685e-02f, -2.60884520e-02f, 1.32022221e-02f, 4.23099622e-02f, 2.15368345e-02f, -3.79761606e-02f, 1.41288596e-03f, 1.06571261e-02f,
  -2.90398318e-02f, 9.79745016e-02f, 9.00970623e-02f, 1.18233129e-01f, 3.01676299e-02f, 1.18067823e-01f, -2.36617681e-02f, 9.27985162e-02f, 9.09729078e-02f, 1.47620365e-01f,
  2.46262059e-01f, -5.98567128e-02f, 9.77644697e-04f, 7.29075633e-03f, -2.20802911e-02f, -2.15620324e-02f, -1.60075873e-01f, -4.11080495e-02f, -5.25066108e-02f, -4.00411226e-02f,
  5.17624021e-02f, -2.20685937e-02f, 1.11471880e-02f, 5.61750531e-02f, -2.40547508e-02f, -6.93566278e-02f, -9.13364366e-02f, -4.49508391e-02f, -1.05146617e-02f, 4.11577821e-02f,
  4.36522402e-02f, 6.03181943e-02f, 1.02653421e-01f, 1.96084324e-02f, -9.74202901e-02f, -5.05545475e-02f, -9.81466323e-02f, 5.67278417e-04f, -5.59673905e-02f, -7.01874420e-02f,
  8.95212665e-02f, -3.10892817e-02f, 9.02235061e-02f, -2.32310984e-02f, -9.28384289e-02f, 5.91377281e-02f, -8.31976011e-02f, -2.64553744e-02f, 7.95344338e-02f, -9.10143554e-02f,
  2.60733739e-02f, 1.85326412e-02f, 1.86757017e-02f, -6.07890226e-02f, 3.15816961e-02f, -1.43794836e-02f, -1.12772875e-01f, 5.66897616e-02f, 8.18639714e-03f, -9.57428664e-02f,
  5.75391110e-03f, -1.05499633e-01f, 6.02562428e-02f, -9.74943787e-02f, 1.36876358e-02f, 5.36644086e-02f, -3.34532186e-02f, -3.62626053e-02f, 8.68256390e-02f, -5.29339500e-02f,
  7.16264546e-02f, 6.18390255e-02f, 7.89551660e-02f, -2.72656251e-02f, -9.59479585e-02f, 6.01464920e-02f, 1.34810992e-02f, -7.42069781e-02f, 1.80085246e-02f, 4.90676686e-02f,
  -3.15886214e-02f, -5.82601130e-02f, 9.50807426e-03f, -5.85284666e-04f, 7.64727667e-02f, -3.71081755e-02f, 1.15074404e-01f, 5.47015183e-02f, 2.49051582e-02f, -7.42636807e-03f,
  2.22888049e-02f, 6.83881566e-02f, 8.84458199e-02f, -2.91981250e-02f, -7.32541159e-02f, 2.19970699e-02f, 5.95141165e-02f, -5.51792532e-02f, 3.64080397e-03f, 4.76795994e-02f,
  4.20461744e-02f, 3.26035842e-02f, 4.80562262e-02f, 9.54042226e-02f, 7.67647773e-02f, 5.89925349e-02f, 5.66120297e-02f, 2.93233488e-02f, -9.67230275e-02f, -3.74436267e-02f,
  7.45859277e-03f, 5.81041258e-03f, -7.73728043e-02f, -1.76707972e-02f, 4.63099964e-03f, 7.87759852e-03f, 3.68022025e-02f, 2.21334072e-03f, -4.90012914e-02f, -9.82045289e-03f,
  4.96404767e-02f, 2.36354172e-02f, -4.47923206e-02f, 4.71058860e-02f, 6.65367534e-03f, 1.17675550e-01f, -6.01034872e-02f, 1.08551629e-01f, 6.57766834e-02f, -7.57145369e-03f,
  -7.67033100e-02f, -5.38191870e-02f, 4.10993211e-02f, -9.74584147e-02f, -5.29250130e-02f, -4.98501100e-02f, -1.62841920e-02f, 6.02311008e-02f, 3.02220732e-02f, -1.16221994e-01f,
  -4.14329693e-02f, -1.93330217e-02f, 2.82426886e-02f, -6.77502528e-02f, 5.52822389e-02f, -8.79944488e-02f, -7.94525295e-02f, -4.34571803e-02f, 2.91646080e-04f, -2.41425950e-02f,
  6.92506284e-02f, 6.59351647e-02f, 3.86117306e-03f, -6.59238696e-02f, -1.21576749e-01f, -7.79340193e-02f, -1.05944246e-01f, 4.95683029e-02f, -1.13610029e-01f, -6.49053007e-02f,
  -6.96163177e-02f, 5.92804216e-02f, 1.12481695e-02f, 8.16136673e-02f, 5.71135730e-02f, -3.43921892e-02f, 5.74812815e-02f, 6.14625029e-02f, 6.44511133e-02f, 1.23217674e-02f,
  -4.84833270e-02f, -6.21610619e-02f, 7.87284151e-02f, 3.63218114e-02f, -5.21048531e-02f, -8.98429975e-02f, 4.70942957e-03f, -1.32209407e-02f, 1.26739582e-02f, 1.41360229e-02f,
  -3.14255357e-02f, 2.84632184e-02f, 1.60144251e-02f, -6.74234331e-02f, 6.90147355e-02f, 2.37703510e-02f, -2.62126443e-03f, -3.74477915e-02f, -1.13508560e-01f, -1.76178545e-01f,
  -3.69572751e-02f, -2.87076011e-02f, 1.04880959e-01f, -3.95517796e-02f, 3.04017798e-03f, -4.93477955e-02f, -5.59312776e-02f, -2.76465379e-02f, 2.45069410e-03f, 1.80546083e-02f,
  8.89499336e-02f, -6.95628971e-02f, 1.05900019e-02f, -8.86985362e-02f, 3.17891277e-02f, -2.26244014e-02f, -4.84996326e-02f, -5.55924289e-02f, -1.80265475e-02f, 6.58291951e-02f,
  4.38351221e-02f, 4.00597416e-02f, 2.50591692e-02f, 4.32508886e-02f, -1.46641396e-02f, -5.91795109e-02f, 6.15549535e-02f, -4.14634012e-02f, 5.24927154e-02f, 3.99064794e-02f,
  -4.11633737e-02f, 5.63285537e-02f, -8.45311582e-02f, -1.35776699e-02f, 8.90557989e-02f, -5.71864955e-02f, -3.58211957e-02f, -3.55406776e-02f, -3.59542221e-02f, 2.47133672e-02f,
  4.78949025e-02f, -4.16150205e-02f, 2.11012084e-02f, 5.59743345e-02f, 1.24701038e-02f, -1.86146442e-02f, 3.94285517e-03f, -4.00380753e-02f, -7.60427639e-02f, -2.72463039e-02f,
  -4.73617874e-02f, 2.77832188e-02f, -6.38612285e-02f, -1.04007751e-01f, -1.11714020e-01f, -2.69016251e-02f, -1.29788578e-01f, -1.03016227e-01f, -3.98473404e-02f, -2.28926480e-01f,
  8.56650621e-02f, 2.89127797e-01f, 8.98429006e-02f, 8.62531066e-02f, 4.57760431e-02f, -4.79441509e-02f, 3.13138962e-02f, -1.10445209e-01f, -8.00954551e-02f, -6.82880282e-02f,
  -1.15991026e-01f, -7.18542710e-02f, -6.85353205e-03f, -7.82030299e-02f, 6.94875494e-02f, 8.71964172e-02f, 2.19017431e-01f, 1.34944588e-01f, -8.78970623e-02f, 2.68385112e-02f,
  4.15348001e-02f, 1.82845637e-01f, 1.25524893e-01f, 1.25952676e-01f, 1.40336797e-01f, 1.37942601e-02f, -9.80813801e-02f, 1.49043843e-01f, 9.24754441e-02f, 4.29932535e-01f,
  4.77274843e-02f, 6.92245737e-02f, -1.61334261e-01f, -4.81289551e-02f, 1.46013265e-02f, -1.64763965e-02f, -2.67074369e-02f, 5.66097070e-03f, -9.07058083e-03f, 3.85198854e-02f,
  8.19434747e-02f, 9.55257043e-02f, 2.53405254e-02f, 1.07552363e-02f, -6.47487268e-02f, -7.51932990e-03f, -4.86011356e-02f, 3.75510380e-02f, -1.10144503e-01f, -4.21407595e-02f,
  9.09417793e-02f, 6.47358596e-02f, -2.70273592e-02f, -4.74096127e-02f, -8.32493678e-02f, -5.34288920e-02f, 3.74234803e-02f, -3.85120213e-02f, -1.65207908e-01f, 6.23249374e-02f,
  3.98010612e-02f, -3.01211029e-02f, -6.87160194e-02f, 6.55809343e-02f, 9.74749774e-02f, 1.22894235e-02f, 5.82153127e-02f, -9.07426625e-02f, 1.02755554e-01f, -6.87416047e-02f,
  -2.16711536e-02f, -1.95718519e-02f, -7.97073469e-02f, 7.75358230e-02f, -7.72870556e-02f, 5.62412851e-02f, 5.51918000e-02f, 1.65104065e-02f, -1.11625521e-02f, -8.72456506e-02f,
  5.58357984e-02f, -4.01685536e-02f, -3.81649174e-02f, -2.07992131e-03f, -6.48921952e-02f, -5.64118475e-02f, -1.82617866e-02f, -6.28936216e-02f, -4.15221266e-02f, 3.12030893e-02f,
  -2.06758276e-01f, -2.58444756e-01f, -1.46398330e-02f, 1.20567465e-02f, 6.46919832e-02f, -1.00574166e-01f, -9.14657582e-03f, 2.08439231e-02f, -3.75783257e-02f, 7.25129768e-02f,
  -7.50418454e-02f, 3.98898013e-02f, -7.06622899e-02f, -4.77265753e-02f, -1.62890460e-02f, -2.32082717e-02f, -9.04804189e-03f, -5.57188466e-02f, -5.66944554e-02f, -4.04048115e-02f,
  -3.23685855e-02f, -1.72968432e-01f, -7.09256455e-02f, -1.40230387e-01f, -1.11842461e-01f, -2.49212086e-01f, -1.42328456e-01f, -6.40314966e-02f, -2.10986793e-01f, -1.36216164e-01f,
  1.96123347e-01f, -1.74843729e-01f, 2.33676106e-01f, 3.39539498e-02f, 2.80585408e-01f, 1.91200197e-01f, 2.96908349e-01f, -2.32952964e-02f, -9.41652060e-02f, 6.02660663e-02f,
  -1.12638801e-01f, -1.27487630e-01f, -2.05028027e-01f, -1.06810004e-01f, -5.91020063e-02f, 1.25602752e-01f, 5.83697408e-02f, 6.31282702e-02f, 6.03483692e-02f, 5.13532059e-03f,
  -1.00847632e-01f, 7.10206330e-02f, 6.51314855e-02f, 7.82454759e-03f, -7.77665749e-02f, -1.03028789e-01f, 7.38998502e-03f, 1.03731968e-01f, -1.13954864e-01f, -1.28384158e-01f,
  3.19670103e-02f, 1.63175493e-01f, 1.73108149e-02f, -1.04971848e-01f, 4.33698595e-02f, -1.09538324e-01f, 1.17354635e-02f, -7.50062168e-02f, -1.27190888e-01f, -7.24079013e-02f,
  -4.64041755e-02f, -3.93785164e-02f, -7.71263167e-02f, 5.06546609e-02f, 2.14375611e-02f, -2.39232648e-02f, -3.95827405e-02f, 2.01073731e-03f, -7.35111237e-02f, 3.53737213e-02f,
  -9.58020836e-02f, 2.83717085e-02f, 1.47565171e-01f, 2.34150048e-02f, 2.11642608e-02f, -5.38252480e-03f, -5.45945391e-03f, -1.12714067e-01f, 3.62269469e-02f, -1.22544542e-01f,
  2.26053037e-02f, -2.53899060e-02f, 3.98225943e-03f, 2.21995935e-02f, 8.38501751e-03f, -3.44455079e-03f, -3.23114246e-02f, -9.01876315e-02f, -4.54916134e-02f, -2.97383685e-02f,
  6.73048645e-02f, -3.30979116e-02f, -2.56572012e-02f, 6.02544211e-02f, -1.08631782e-01f, 7.90489763e-02f, 1.37183061e-02f, -5.08313030e-02f, -8.06334615e-03f, 4.05983701e-02f,
  1.01710698e-02f, 1.15423277e-01f, 1.80405900e-02f, 3.54010239e-02f, -1.09624257e-02f, 6.93063065e-02f, -8.05408582e-02f, -7.90539011e-02f, 5.02896421e-02f, 1.09958552e-01f,
  -1.79132938e-01f, 1.67540088e-01f, -1.41078144e-01f, -8.62266794e-02f, 1.04032718e-01f, -1.09802499e-01f, -1.99368764e-02f, -2.67996136e-02f, 3.96182314e-02f, 6.15887269e-02f,
  5.85636161e-02f, 3.13481949e-02f, -3.65406508e-03f, 3.51369157e-02f, 1.65958390e-01f, 9.24289343e-04f, -1.52321503e-01f, 6.71501234e-02f, 1.15211876e-02f, -2.86593717e-02f,
  -3.39715369e-02f, 5.53485118e-02f, 7.62079582e-02f, 7.46313930e-02f, -3.69031131e-02f, 3.91047299e-02f, 4.46161628e-02f, 6.52248338e-02f, 1.41817287e-01f, -4.41577584e-02f,
  -4.11773950e-01f, 2.84815561e-02f, 8.96957740e-02f, -5.70789911e-02f, 1.49673708e-02f, 1.18873619e-01f, -1.40460180e-02f, 4.03513983e-02f, 3.64018083e-02f, 6.46745488e-02f,
  6.13893270e-02f, 3.60864922e-02f, 6.31205663e-02f, -1.03327483e-01f, -1.77187659e-02f, 9.29410458e-02f, 8.87722746e-02f, -5.35660498e-02f, -2.16598630e-01f, -1.09424718e-01f,
  -3.74048501e-02f, -1.85761407e-01f, -1.48604721e-01f, -9.35207456e-02f, -5.61123481e-03f, -6.86176568e-02f, 3.95161025e-02f, -6.77779242e-02f, -6.24656826e-02f, 8.58906880e-02f,
  1.11882761e-01f, -4.31726575e-02f, -6.87012151e-02f, -2.93523800e-02f, 9.12028402e-02f, -7.41492677e-03f, -3.81974243e-02f, -8.64921808e-02f, -5.22485934e-02f, 5.39257713e-02f,
  -2.14926433e-02f, -2.18698662e-02f, -1.43157076e-02f, 3.76900621e-02f, -1.05388522e-01f, 6.46791654e-03f, -1.42562658e-01f, -2.75735650e-02f, -1.00701995e-01f, -5.29032461e-02f,
  5.10091521e-02f, -2.89191213e-02f, -1.02191180e-01f, -1.89430993e-02f, 8.82556941e-03f, -1.71180051e-02f, -4.32981877e-03f, -1.07019087e-02f, 1.23247167e-03f, -6.61228551e-04f,
  -4.68377806e-02f, 8.60857069e-02f, 3.63402106e-02f, -9.12729930e-03f, -2.92741065e-03f, -6.02440769e-03f, 1.03970885e-01f, -4.52395901e-02f, 4.90388193e-04f, 5.96258417e-03f,
  -1.14629976e-03f, 1.48819080e-02f, 1.10414308e-02f, 4.19241898e-02f, -7.14441529e-03f, -1.05826836e-02f, -7.98572879e-03f, 2.27748640e-02f, -5.34178168e-02f, -1.77794099e-02f,
  4.19161879e-02f, -7.08966106e-02f, -6.92299306e-02f, -8.58350694e-02f, 9.20018628e-02f, 8.81889760e-02f, -6.11848570e-02f, 1.55851329e-02f, -3.09802163e-02f, 1.17891118e-01f,
  3.78257111e-02f, 4.94802557e-02f, -4.53329124e-02f, -4.14136723e-02f, -8.22867174e-03f, -6.86424747e-02f, 6.58617318e-02f, -6.13198541e-02f, 5.26893809e-02f, 2.29231883e-02f,
  8.00009966e-02f, 5.92045626e-03f, -4.59566899e-02f, -1.80717856e-02f, -4.32180874e-02f, -1.10559978e-01f, -5.09677827e-02f, -6.85917586e-02f, -9.19107273e-02f, 3.06468811e-02f,
  -7.77303278e-02f, -7.02671930e-02f, -1.01416357e-01f, 6.68985443e-03f, -5.72029278e-02f, 1.84326433e-02f, 3.40958536e-02f, -4.30697426e-02f, -5.94453141e-02f, -1.74398590e-02f,
  2.40211576e-01f, 8.42763111e-03f, -1.98609859e-01f, 1.85735792e-01f, -2.88585201e-03f, -1.05484024e-01f, -1.14750050e-01f, -6.82697594e-02f, 1.30943805e-01f, -2.81841494e-02f,
  -1.17769778e-01f, -9.22777783e-03f, -5.17605804e-03f, -1.35854129e-02f, -1.37309045e-01f, -1.84806615e-01f, -1.50774464e-01f, -5.89140952e-02f, 2.32776441e-02f, -1.38441548e-01f,
  -7.77314454e-02f, -3.02087609e-02f, 1.18878223e-01f, -6.35996461e-02f, 2.42011845e-02f, -6.88975975e-02f, -2.70670988e-02f, -8.87260139e-02f, -1.49457365e-01f, -8.21250603e-02f,
  -7.44566321e-02f, -7.41059482e-02f, -9.45425499e-03f, -1.82694178e-02f, 6.17259145e-02f, -5.56096286e-02f, 6.09160922e-02f, 2.93212365e-02f, 9.84734520e-02f, 3.84123735e-02f,
  -7.80835748e-02f, -7.75910839e-02f, 2.71323659e-02f, -6.30744472e-02f, -4.93826531e-02f, -2.93196812e-02f, 6.64275065e-02f, -1.04711421e-01f, 4.78466637e-02f, -6.97601661e-02f,
  -7.24866763e-02f, -5.43501265e-02f, -1.04556225e-01f, 2.91809123e-02f, -3.04590017e-02f, -1.10102724e-02f, -7.66593516e-02f, -2.25007646e-02f, 3.56765315e-02f, 8.68767425e-02f,
  -6.44548088e-02f, -8.30764025e-02f, -3.90048102e-02f, 1.09236233e-01f, 5.10389768e-02f, -2.21165381e-02f, -2.37716289e-04f, -1.82263441e-02f, -6.45143911e-02f, -7.64835998e-03f,
  3.83325554e-02f, -3.67898755e-02f, 5.71841076e-02f, 4.85019423e-02f, 3.12099676e-03f, 8.77271742e-02f, -2.92473491e-02f, -8.01635012e-02f, -2.16643140e-02f, 7.46377781e-02f,
  6.77718222e-02f, -8.33904445e-02f, -2.89178919e-02f, 2.31064782e-02f, 8.54478870e-03f, -3.80880721e-02f, -3.59983034e-02f, -2.86052432e-02f, 6.05109669e-02f, 8.47066939e-02f,
  2.32452810e-01f, -1.78874493e-01f, 9.89251733e-02f, -6.46052435e-02f, -3.59025858e-02f, -1.09158121e-02f, -2.44451929e-02f, -2.97449064e-02f, 2.95626391e-02f, -3.93346995e-02f,
  -4.22279201e-02f, 8.00209939e-02f, 9.30475518e-02f, -9.15878043e-02f, -6.46567196e-02f, -7.20177367e-02f, 5.65913282e-02f, -4.52615432e-02f, 2.47034188e-02f, -2.86418721e-02f,
  -6.16209283e-02f, 5.87011464e-02f, 1.10263705e-01f, 3.00359819e-03f, -3.58101614e-02f, 1.11275963e-01f, -9.70182344e-02f, -1.80802550e-02f, -1.16869174e-02f, -2.76772911e-03f,
  6.23317324e-02f, 5.99809736e-02f, -1.13704219e-01f, -2.43477933e-02f, -5.06380852e-03f, -3.34269479e-02f, 4.23586294e-02f, 5.50300814e-02f, -9.17649921e-03f, -1.04132676e-02f,
  1.97181460e-02f, -2.72500757e-02f, 2.47729048e-02f, -9.22315046e-02f, -3.58901359e-02f, -5.40723018e-02f, -9.90348309e-02f, 2.98454836e-02f, 7.20489696e-02f, -2.49083620e-02f,
  -5.65264225e-02f, -6.64469600e-02f, 7.04388469e-02f, -1.56373587e-02f, -1.21350452e-01f, -8.96385983e-02f, -7.04886839e-02f, 1.03803882e-02f, -1.06335856e-01f, -7.61259422e-02f,
  -1.56768456e-01f, -1.18967049e-01f, -5.16467206e-02f, 5.74130155e-02f, -7.78777003e-02f, 2.21321899e-02f, -4.92699854e-02f, -2.43247878e-02f, 5.57657480e-02f, -4.48044129e-02f,
  -1.03701063e-01f, 7.06365407e-02f, -1.16633572e-01f, 1.24372086e-02f, -6.98373392e-02f, 4.48570289e-02f, 5.19521162e-02f, -4.94701006e-02f, -3.12649868e-02f, -3.81894708e-02f,
  -4.74731252e-02f, 3.40115055e-02f, -8.95201862e-02f, 1.45155555e-02f, -2.56135575e-02f, -4.86983481e-04f, -1.01617850e-01f, -1.02645546e-01f, 2.00234316e-02f, 4.89815697e-02f,
  -6.76646084e-02f, 1.72681790e-02f, -1.80047564e-02f, -3.53118442e-02f, -4.42993864e-02f, 3.59194875e-02f, -9.81828477e-03f, -5.70810474e-02f, 1.69723276e-02f, -1.94758736e-02f,
  -3.81643027e-02f, 4.57559936e-02f, -4.53024507e-02f, 5.32813966e-02f, 7.64220506e-02f, 5.08688902e-03f, 1.30061414e-02f, 5.66954911e-02f, 3.42440642e-02f, -2.89359689e-02f,
  5.63175902e-02f, -1.79287177e-02f, 1.35401255e-02f, 4.11885828e-02f, 3.87291387e-02f, -7.92293549e-02f, 6.41991422e-02f, -4.35084105e-02f, 2.13366002e-02f, -3.51727828e-02f,
  2.98794284e-02f, 5.94626507e-03f, 2.35249475e-02f, 8.27892572e-02f, -1.74088217e-03f, 6.55439449e-03f, -9.01403651e-02f, 6.02394305e-02f, -1.24479989e-02f, 1.51531147e-02f,
  6.48599118e-02f, -6.46909475e-02f, 2.66958568e-02f, 3.89081761e-02f, -7.37570450e-02f, 9.00219306e-02f, 6.71926662e-02f, -4.45002271e-03f, 6.11798430e-04f, 5.34950234e-02f,
  7.87841082e-02f, 1.05876759e-01f, 2.49724947e-02f, -8.37994646e-03f, -1.94157306e-02f, 1.22928852e-02f, 1.36492345e-02f, 2.90152989e-03f, 8.45641345e-02f, 5.86993732e-02f,
  -2.78100073e-02f, 2.78590135e-02f, -2.73170751e-02f, -8.22523609e-02f, -6.39295280e-02f, 9.40883532e-03f, 1.10048115e-01f, -7.16269240e-02f, -4.18864153e-02f, 1.61487125e-02f,
  -7.97498226e-02f, -6.59345165e-02f, 5.33157494e-03f, -6.96400255e-02f, 9.39612687e-02f, 1.64254513e-02f, 2.74507571e-02f, 4.87324186e-02f, -5.86782675e-03f, -5.85541911e-02f,
  7.44367465e-02f, -2.38303356e-02f, -1.63219534e-02f, -4.02493123e-03f, 4.64732237e-02f, -6.29459098e-02f, -2.12088730e-02f, 3.32872346e-02f, -3.08885649e-02f, -1.59818511e-02f,
  -7.35307634e-02f, -8.00109282e-02f, 1.37547897e-02f, 1.94926448e-02f, 8.82185251e-03f, -2.25777887e-02f, 5.43021113e-02f, -8.20158944e-02f, -3.84322703e-02f, -9.27788466e-02f,
  -7.47848451e-02f, -8.40665624e-02f, 7.29644150e-02f, 1.54147241e-02f, 5.72340041e-02f, 8.89247879e-02f, 2.69644465e-02f, -6.57659993e-02f, 6.79707080e-02f, -2.13935077e-02f,
  -4.56476286e-02f, 1.98847149e-03f, 5.09750135e-02f, -6.76094554e-03f, 1.04986792e-02f, -3.86320986e-02f, 5.48185557e-02f, -3.24719287e-02f, -7.98450559e-02f, -1.17210113e-02f,
  5.16403615e-02f, 4.78360802e-02f, -5.52073047e-02f, -4.61934395e-02f, 9.06988308e-02f, -1.04844337e-02f, -5.48140779e-02f, -6.83348849e-02f, -7.35639334e-02f, 7.28124473e-03f,
  1.07153896e-02f, -6.22796789e-02f, -1.47403786e-02f, 1.60775986e-02f, 3.26252654e-02f, -2.32333187e-02f, 8.66073444e-02f, 4.33685258e-02f, -3.26944366e-02f, 4.86804955e-02f,
  -2.88165119e-02f, -9.09266472e-02f, -5.97745143e-02f, 3.37185487e-02f, -3.20843570e-02f, -8.55596513e-02f, -1.68856867e-02f, 6.19462356e-02f, -2.97999978e-02f, -5.11016548e-02f,
  7.07535297e-02f, 7.67895998e-03f, -7.24393353e-02f, -3.39458846e-02f, 4.82132621e-02f, 5.02393171e-02f, -1.09774787e-02f, 2.42673326e-02f, 2.84823515e-02f, 6.81230202e-02f,
  -3.81569974e-02f, -6.63188174e-02f, 3.53548340e-02f, -3.15816957e-03f, -1.80412419e-02f, -2.27286872e-02f, 4.17648256e-02f, -3.05480175e-02f, 9.78560448e-02f, -7.14728385e-02f,
  -9.15850997e-02f, 4.12542261e-02f, 1.70632526e-02f, -8.89871344e-02f, 5.08068539e-02f, -1.80479251e-02f, -1.82904098e-02f, -8.08466151e-02f, -4.43737991e-02f, 6.08617738e-02f,
  -1.58085749e-01f, -9.61849317e-02f, -1.82860017e-01f, -1.73892125e-01f, -3.40395756e-02f, -4.97710519e-02f, 1.98031198e-02f, 8.51290971e-02f, -1.64684523e-02f, -1.46925997e-03f,
  2.17503700e-02f, -6.98579326e-02f, -3.98046970e-02f, -1.24065392e-01f, 3.37669924e-02f, -8.85525718e-02f, -1.37100250e-01f, -1.27676725e-01f, -1.11783586e-01f, -3.31809372e-02f,
  -1.36293605e-01f, -7.09077492e-02f, -1.81436464e-01f, -6.20907508e-02f, -1.36803791e-01f, 1.62329748e-02f, -5.97717240e-02f, -1.67847484e-01f, -1.58212092e-02f, -7.01270550e-02f,
  -6.59044236e-02f, 2.87928358e-02f, -3.79380099e-02f, -1.08319290e-01f, -9.89781469e-02f, -4.41390090e-02f, -3.04814931e-02f, 7.46523887e-02f, -8.22711065e-02f, 4.26660180e-02f,
  9.87387262e-03f, 3.71116735e-02f, -5.11520989e-02f, -3.59037220e-02f, -2.04559956e-02f, -8.11043661e-03f, 4.76371422e-02f, -1.10323936e-01f, -8.78455117e-02f, 2.98980670e-03f,
  2.86681503e-02f, -1.22365758e-01f, -1.23853326e-01f, 2.53259297e-02f, -3.73696685e-02f, -1.08780049e-01f, 1.24026751e-02f, -3.04611512e-02f, -2.34326459e-02f, 4.52702343e-02f,
  7.91760609e-02f, -4.64386903e-02f, -5.31105436e-02f, 6.44627064e-02f, 5.47155552e-02f, 6.57034889e-02f, -4.88398075e-02f, 3.16768847e-02f, -8.46256837e-02f, -3.75754237e-02f,
  -4.72085811e-02f, 8.27423334e-02f, 6.72615916e-02f, 5.71255907e-02f, -1.60910748e-02f, -2.31831451e-03f, 6.20689169e-02f, 7.79292881e-02f, 4.69233990e-02f, 8.16343352e-02f,
  -3.46777439e-02f, 4.26161438e-02f, 7.83579797e-02f, -1.64894201e-02f, 1.84244495e-02f, 2.65799835e-02f, 2.66724527e-02f, 2.93745734e-02f, -2.43415907e-02f, 1.74551271e-02f,
  -2.37176232e-02f, 6.38223216e-02f, -2.68475413e-02f, 3.96223217e-02f, 1.94582734e-02f, 1.67908929e-02f, -4.38420400e-02f, -2.90065147e-02f, 1.83628574e-02f, -9.68172699e-02f,
  -1.07636452e-01f, 6.42074049e-02f, 4.41092141e-02f, 1.80823856e-03f, 6.00803681e-02f, 1.05011284e-01f, -2.10231133e-02f, -1.15160003e-01f, -2.07068156e-02f, 1.30837010e-02f,
  1.23937994e-01f, -1.07742116e-01f, -1.27740830e-01f, -4.29185405e-02f, -6.36144876e-02f, -2.52772328e-02f, -3.30828386e-03f, 3.72152962e-02f, 4.05159369e-02f, 9.21680704e-02f,
  1.73511952e-01f, -1.77219465e-01f, -3.52914393e-01f, 6.48313686e-02f, -1.49925590e-01f, -3.50004120e-04f, -1.98720232e-01f, -3.45609635e-02f, -1.72501255e-03f, -1.08519994e-01f,
  -8.43079314e-02f, 1.18159212e-01f, 8.39541703e-02f, -2.46320642e-03f, -3.90432999e-02f, -2.49168366e-01f, -2.17904642e-01f, -2.59433910e-02f, 8.64223167e-02f, 6.93658292e-02f,
  -1.62854604e-02f, -1.14615478e-01f, 6.55988753e-02f, 6.16704859e-02f, -1.29479557e-01f, -7.01532885e-02f, -2.00018525e-01f, -1.19611919e-02f, -4.85984571e-02f, -2.51321256e-01f,
  -8.26997012e-02f, 1.73403663e-04f, 7.92321377e-03f, 1.10924235e-02f, -6.43759221e-02f, 2.69694515e-02f, 3.21258791e-02f, -1.14182033e-01f, 8.03006291e-02f, 6.97608152e-03f,
  -1.04415901e-01f, 1.12663686e-01f, -3.46129015e-03f, -2.38367226e-02f, -1.48406634e-02f, -4.50607613e-02f, -6.26146942e-02f, 8.11725706e-02f, -8.72024447e-02f, -7.65769035e-02f,
  -8.99776742e-02f, -6.15461655e-02f, -6.53256327e-02f, 7.04992861e-02f, 6.80322051e-02f, -1.93827935e-02f, 2.19664853e-02f, -3.17168124e-02f, -1.23763373e-02f, -2.44867187e-02f,
  -1.70857441e-02f, 2.08749678e-02f, 5.67021780e-02f, 1.53324511e-02f, 3.62473428e-02f, -1.07700258e-01f, 3.96667644e-02f, -2.76791770e-02f, 5.93445078e-02f, 4.12213653e-02f,
  -3.26417480e-03f, 8.72458564e-04f, -3.42204422e-02f, 3.05315237e-02f, -1.34175494e-01f, -1.41680613e-02f, 1.04492018e-02f, 8.76103155e-03f, -2.23139618e-02f, -6.95128441e-02f,
  3.37848328e-02f, -1.07645663e-02f, -2.13257642e-03f, 3.14863436e-02f, -3.78954560e-02f, 2.96220332e-02f, 4.35938686e-02f, 3.16314176e-02f, 6.81582093e-02f, 7.98230022e-02f,
  4.41784374e-02f, 8.39197859e-02f, 8.44872836e-03f, 2.21679099e-02f, -9.68777388e-02f, -6.15179911e-02f, -1.57769732e-02f, 7.91557878e-02f, 5.96858822e-02f, -1.44235685e-03f,
  -7.46732345e-03f, 9.72305238e-02f, 5.02080619e-02f, -5.92281856e-02f, -1.78102348e-02f, 7.10068569e-02f, -1.35413319e-01f, -2.25939844e-02f, 1.16520599e-01f, 5.14328666e-02f,
  -1.18909115e-02f, 6.31791428e-02f, 5.54590859e-03f, 3.66519019e-02f, 1.09554790e-01f, 1.09840088e-01f, 4.06305455e-02f, 5.28141372e-02f, 1.53489172e-01f, -5.89863136e-02f,
  1.76794916e-01f, 1.37933850e-01f, 1.52326599e-01f, -5.68399429e-02f, -8.66255816e-03f, 1.33767780e-02f, 1.56603649e-01f, 1.34046942e-01f, 2.58350223e-02f, 1.79510307e-03f,
  6.90925419e-02f, -3.36646736e-02f, -1.41440453e-02f, -5.48752584e-02f, 1.49429381e-01f, 9.66476277e-02f, -6.87177628e-02f, 4.63614762e-02f, 1.30097374e-01f, 3.22335996e-02f,
  -6.36129677e-02f, -7.66975060e-02f, 1.48791626e-01f, 9.97613966e-02f, -8.50282330e-03f, -4.51733544e-02f, 8.27321336e-02f, 1.07440062e-01f, -3.48233469e-02f, -1.12835877e-01f,
  9.89606827e-02f, 1.45400658e-01f, -4.93221171e-02f, -3.73755880e-02f, 5.98773845e-02f, 1.30601535e-02f, -5.74075207e-02f, 5.63068548e-03f, 4.50098701e-02f, 1.77938752e-02f,
  -1.99075248e-02f, -9.46589839e-03f, -8.92565250e-02f, -1.11314487e-02f, 7.50978068e-02f, -3.61495167e-02f, 3.25071290e-02f, 1.03639267e-01f, 2.20312085e-02f, 9.85323638e-02f,
  3.16387340e-02f, -3.39218192e-02f, 8.69654119e-02f, 3.05332467e-02f, -1.68060232e-02f, -6.41629696e-02f, -1.13530001e-02f, -5.91984540e-02f, 2.49034204e-02f, -1.12123403e-03f,
  -1.22032732e-01f, 3.37567218e-02f, 1.23318598e-01f, -7.90150389e-02f, 4.45035733e-02f, -1.00595271e-02f, 4.06503975e-02f, -4.09307517e-02f, 5.02395295e-02f, -2.75843702e-02f,
  3.66823599e-02f, 4.93588820e-02f, 5.08977696e-02f, 5.17108627e-02f, 5.14987223e-02f, 2.72038896e-02f, 2.74495557e-02f, 3.55022959e-02f, 1.02598235e-01f, 1.37487790e-02f,
  7.11940750e-02f, -3.55869010e-02f, -6.66613951e-02f, -3.88224958e-04f, 1.42466975e-02f, -5.97792044e-02f, 3.23912352e-02f, -1.00664392e-01f, -4.51956689e-02f, 7.07692429e-02f,
  -1.61123618e-01f, -6.88768225e-03f, -3.72902788e-02f, -8.16006400e-03f, -1.06640533e-01f, -2.70267818e-02f, 4.41077575e-02f, 1.10823440e-03f, -9.78199169e-02f, -9.43989456e-02f,
  5.60218059e-02f, -1.34038948e-03f, -2.03544963e-02f, 4.35597934e-02f, -1.92693416e-02f, 3.77523154e-03f, -1.16221711e-01f, -8.92450586e-02f, -1.27591759e-01f, -9.48894247e-02f,
  -1.99209224e-03f, 8.39536358e-03f, -1.18568525e-01f, 2.89928596e-02f, 3.35080065e-02f, -2.83029454e-04f, -9.52082425e-02f, -1.67008135e-02f, -7.11005777e-02f, -2.73863096e-02f,
  1.52104601e-01f, -1.09679356e-01f, -5.42543791e-02f, -8.79153013e-02f, -1.48677945e-01f, -1.04309604e-01f, -1.24783613e-01f, 4.11796756e-02f, 5.63629866e-02f, -6.53992817e-02f,
  1.04914919e-01f, 9.01431665e-02f, 1.77383840e-01f, 1.32008746e-01f, 1.40212908e-01f, 1.55150732e-02f, -4.86393608e-02f, 3.90039049e-02f, 6.36062324e-02f, -7.58737847e-02f,
  -6.88960701e-02f, -1.89674720e-02f, 1.15637388e-02f, 3.74685042e-02f, -1.42810822e-01f, -4.50191973e-03f, -3.29597630e-02f, -1.49856322e-02f, 1.50678288e-02f, -2.28035469e-02f,
  1.43503785e-01f, -5.89647144e-02f, -5.01611717e-02f, 7.34735951e-02f, -3.75306979e-02f, 5.04380502e-02f, -1.42611284e-02f, 2.41274275e-02f, -4.35486548e-02f, -5.60003482e-02f,
  3.25152427e-02f, 7.24716112e-02f, -3.76467519e-02f, -3.80713195e-02f, -8.71206447e-02f, 4.93439734e-02f, -9.30461958e-02f, 2.47041248e-02f, -6.97218999e-02f, 2.17833631e-02f,
  -5.24582937e-02f, -2.39439588e-02f, -8.00306126e-02f, -3.34586315e-02f, 2.42509414e-03f, -2.87524797e-02f, -2.55143084e-02f, -2.23010946e-02f, 6.42925873e-03f, 4.42977250e-02f,
  6.59802258e-02f, -2.62073576e-02f, -1.47149395e-02f, 6.38239235e-02f, -6.00561127e-02f, -5.47467545e-02f, 2.85097584e-02f, 1.41627053e-02f, 6.72875494e-02f, -4.58932184e-02f,
  -6.13094121e-02f, -1.50702579e-03f, -7.17745796e-02f, -2.38945633e-02f, 7.73592293e-02f, -8.06116611e-02f, -1.59056280e-02f, 5.63412085e-02f, 2.15537716e-02f, -6.13483787e-02f,
  -6.25797501e-03f, 6.50942624e-02f, -3.58504392e-02f, -1.76802073e-02f, 3.41835916e-02f, -2.05388255e-02f, 2.58807279e-02f, 2.33835839e-02f, -4.76725474e-02f, 4.28832276e-03f,
  1.23801135e-01f, 9.24724787e-02f, 4.80374843e-02f, 5.51533401e-02f, -1.65163528e-03f, 3.45485322e-02f, 9.31092799e-02f, -6.72430620e-02f, -5.28699271e-02f, -7.09082782e-02f,
  2.25009210e-02f, 1.11763224e-01f, -2.10322179e-02f, -4.56558764e-02f, 1.72019135e-02f, -1.63767617e-02f, -2.95774825e-02f, 8.92829746e-02f, -4.17486876e-02f, -4.20286916e-02f,
  1.57200061e-02f, -1.96192879e-02f, 1.07768066e-01f, 8.31496343e-02f, -6.73186406e-03f, 2.07522213e-01f, 5.42817675e-02f, 7.15318993e-02f, 1.41311884e-01f, -2.58089807e-02f,
  -3.95163931e-02f, -3.37765142e-02f, 4.11015600e-02f, 3.06766815e-02f, 1.31932899e-01f, 2.41556298e-02f, 9.44850594e-02f, 5.94766177e-02f, -9.32839289e-02f, -8.46384689e-02f,
  4.52231169e-02f, -1.12549499e-01f, -1.29283756e-01f, -9.91691872e-02f, 4.19641957e-02f, 5.60611114e-02f, -6.08019754e-02f, -6.88679367e-02f, 9.13411938e-03f, 7.16380551e-02f,
  -1.01011589e-01f, -1.54873058e-02f, -9.54784751e-02f, -2.21239794e-02f, -1.13670267e-01f, -7.87101611e-02f, 2.77791694e-02f, 8.46376084e-03f, 7.65430331e-02f, -7.85086080e-02f,
  -1.09502316e-01f, 6.94504520e-03f, -5.01972623e-02f, -3.90535360e-03f, -8.03000107e-03f, -5.61383925e-02f, 4.73214127e-02f, -8.63971561e-02f, 3.52666676e-02f, -1.27361435e-02f,
  -2.53632218e-02f, -7.25695491e-02f, -6.77183690e-03f, 6.03697561e-02f, 1.40663758e-02f, -2.87427884e-02f, -4.42543998e-02f, 1.05122395e-01f, 8.54245052e-02f, -4.38080542e-02f,
  9.27141160e-02f, 2.18356568e-02f, -1.25293732e-02f, -3.28648537e-02f, 6.52761683e-02f, 7.44614676e-02f, -6.00360595e-02f, 9.46821272e-03f, 9.86187756e-02f, -1.06574511e-02f,
  -4.81195077e-02f, 6.77618757e-02f, 7.57746175e-02f, 2.86148489e-02f, -4.11796048e-02f, 7.63047785e-02f, 6.47477154e-03f, 3.40544879e-02f, 9.23648849e-02f, 4.47251461e-02f,
  2.02678982e-02f, 1.90492477e-02f, 9.24390629e-02f, 6.82622790e-02f, 3.49840447e-02f, 8.45831111e-02f, -8.39076936e-03f, -6.39255121e-02f, 5.33116758e-02f, -7.86208734e-02f,
  2.09560785e-02f, 7.53298402e-02f, 1.95278414e-02f, 8.14038739e-02f, -2.21516229e-02f, -1.71255507e-02f, -9.87790711e-03f, 9.24684182e-02f, 3.31332684e-02f, 8.50803927e-02f,
  -9.00798887e-02f, 6.38849586e-02f, -6.48243353e-02f, -6.39066622e-02f, 3.60328034e-02f, 4.34432253e-02f, 3.02505028e-02f, 4.80728969e-02f, 5.96662126e-02f, -4.54108557e-03f,
  -4.31584865e-02f, -7.44832233e-02f, 4.83170860e-02f, 2.66269166e-02f, -5.35676181e-02f, 5.33433035e-02f, 7.13435411e-02f, 1.63086026e-03f, 3.24752852e-02f, -2.55787261e-02f,
  -2.19149701e-02f, 8.01952332e-02f, -7.65803177e-03f, 3.15319076e-02f, 8.86412617e-03f, 9.71392319e-02f, 5.75744957e-02f, -7.78663382e-02f, 1.02206230e-01f, -2.72036903e-03f,
  -2.03373834e-01f, -1.70551896e-01f, 3.30224112e-02f, -3.21585797e-02f, -4.38774452e-02f, -1.63167700e-01f, -2.97616184e-01f, -7.85481706e-02f, 3.30347591e-03f, -9.58479792e-02f,
  -1.13088652e-01f, 1.53130582e-02f, -7.49529479e-03f, -1.92262847e-02f, -6.09943308e-02f, -2.30182245e-01f, -1.44810796e-01f, -6.66834861e-02f, 5.43779752e-04f, 3.30647975e-02f,
  -1.46658355e-02f, 4.97341491e-02f, 1.42333969e-01f, 6.53327331e-02f, 2.97775050e-03f, 1.62000936e-02f, 8.44992772e-02f, -5.98374754e-02f, 3.38696353e-02f, -1.53472111e-01f,
  -8.47163647e-02f, -1.46340430e-01f, 1.11827970e-01f, 7.91391656e-02f, 2.44689360e-02f, -6.45989850e-02f, -4.07702401e-02f, -8.81889611e-02f, 7.11226836e-02f, 4.09027888e-03f,
  1.93327405e-02f, 5.48949204e-02f, -1.44690517e-02f, 1.63768381e-02f, -1.25767393e-02f, -7.45427003e-03f, -6.91792220e-02f, 6.28798604e-02f, 6.03505075e-02f, -4.30723839e-02f,
  -7.53372014e-02f, -7.23423809e-02f, -5.07117547e-02f, -6.76613450e-02f, -8.89779329e-02f, -3.97781543e-02f, 2.90806592e-02f, -7.61872903e-02f, -9.44107622e-02f, -1.35737181e-01f,
  2.80505214e-02f, 2.48292424e-02f, 1.30060967e-02f, 9.16276593e-03f, -4.12543416e-02f, 6.57905936e-02f, 4.27405583e-03f, -8.32607821e-02f, 8.56833011e-02f, 1.12241376e-02f,
  -4.25545452e-03f, 4.05709147e-02f, -3.04675158e-02f, -4.81415018e-02f, -1.11599714e-02f, -6.43140003e-02f, -1.85967907e-02f, -5.38113788e-02f, 2.77831755e-03f, -5.38592786e-02f,
  -8.20175335e-02f, 6.05100393e-03f, 7.48628154e-02f, 6.01732507e-02f, 5.50022256e-03f, 1.43483719e-02f, 1.15543306e-02f, -8.06405097e-02f, -8.91217813e-02f, -1.18190579e-01f,
  -1.14045694e-01f, 8.54176283e-02f, -1.18627898e-01f, -9.38095618e-03f, -7.76453093e-02f, 5.85081130e-02f, -3.73080261e-02f, 8.17239061e-02f, 8.63114314e-04f, -8.87923986e-02f,
  -2.85246354e-02f, -6.26374781e-02f, -3.53423581e-02f, 4.36782762e-02f, -7.13645369e-02f, -6.95887059e-02f, -7.52047747e-02f, 2.92112324e-02f, -3.25712701e-03f, 3.03500239e-02f,
  -2.11911593e-02f, -4.02357839e-02f, -8.37873071e-02f, -1.23977270e-02f, 6.11003814e-03f, -7.14381337e-02f, -3.08957174e-02f, -1.97353140e-02f, -9.46971327e-02f, -2.42879465e-01f,
  -2.93559164e-01f, -2.19790369e-01f, 1.51102841e-01f, -9.09610316e-02f, 7.49846771e-02f, 2.93130092e-02f, 1.32560551e-01f, -5.44768497e-02f, 2.40973849e-02f, 9.74493399e-02f,
  -3.45393792e-02f, -5.16547225e-02f, 4.45814952e-02f, -4.54008132e-02f, -9.20049399e-02f, 1.94063596e-02f, 3.91251594e-02f, 5.61588816e-02f, -1.45369610e-02f, 4.20126840e-02f,
  -6.46968782e-02f, -7.83510357e-02f, -1.28923580e-01f, 5.03921323e-02f, -1.81398820e-02f, 1.07623599e-02f, 8.60014409e-02f, 4.11287844e-02f, -7.80190229e-02f, -4.71952430e-04f,
  3.07374775e-01f, -2.33325124e-01f, -2.08294746e-02f, -1.70035124e-01f, -4.19785604e-02f, 3.17396000e-02f, -2.75292285e-02f, -4.83133551e-03f, -5.38421832e-02f, 4.71535996e-02f,
  -5.26180938e-02f, 3.47665548e-02f, -1.15003891e-01f, -1.99947935e-02f, 2.46768035e-02f, 5.64775020e-02f, -1.08315557e-01f, -1.07737228e-01f, -2.05031298e-02f, -1.19230719e-02f,
  -3.21490169e-02f, -1.07882582e-01f, -2.58565973e-02f, 1.53328050e-02f, -4.82705124e-02f, -9.11970064e-02f, 3.97927389e-02f, -3.18342224e-02f, -7.72045106e-02f, -5.09639643e-02f,
  2.10817270e-02f, 1.26130983e-01f, 9.77246612e-02f, -5.78377917e-02f, -4.57923859e-02f, 9.22136847e-03f, 3.08192484e-02f, -8.60373862e-03f, 6.89640343e-02f, 5.60263284e-02f,
  -2.02600081e-02f, 4.45830747e-02f, 2.12747902e-02f, 3.85077670e-03f, -1.40390238e-02f, -9.74989589e-03f, -7.95032978e-02f, -1.35994963e-02f, -3.49373110e-02f, -1.03430469e-02f,
  1.83521193e-02f, -8.92342068e-03f, 2.44048256e-02f, -1.73322093e-02f, -5.25613502e-02f, 3.49711248e-04f, -4.74191383e-02f, -1.06452279e-01f, -7.96926096e-02f, 1.37692783e-02f,
  1.25008240e-01f, -8.32580328e-02f, 5.78416884e-02f, -4.57741991e-02f, 6.02227524e-02f, -4.23118770e-02f, -6.66392222e-02f, 2.02898253e-02f, 8.14857483e-02f, -5.12739364e-03f,
  -4.07348089e-02f, -4.52973433e-02f, -4.47888114e-02f, 4.03125733e-02f, -7.74992350e-03f, 6.24956079e-02f, 5.20377569e-02f, 5.42980172e-02f, 4.41200212e-02f, -9.29512903e-02f,
  -5.27561866e-02f, 1.05060577e-01f, 1.46352068e-01f, 9.05792192e-02f, -1.14002237e-02f, -2.70172459e-04f, 1.65432885e-01f, 1.11934043e-01f, 4.44048643e-02f, 2.54034370e-01f,
  1.26512721e-01f, 3.43726599e-03f, -4.49829772e-02f, 8.83245319e-02f, -1.30058704e-02f, 1.12216156e-02f, -1.15009010e-01f, -3.93821672e-02f, 9.11915824e-02f, 3.53798009e-02f,
  3.74827757e-02f, 9.46481302e-02f, 1.47609100e-01f, 5.22702970e-02f, 4.73675244e-02f, -1.14724673e-01f, 1.38200670e-02f, 1.82872952e-03f, -1.94791686e-02f, 6.67145029e-02f,
  1.10739350e-01f, 7.61201680e-02f, 1.57228276e-01f, -1.67331602e-02f, -1.59973577e-02f, 8.16746354e-02f, 5.70457764e-02f, 1.31253302e-01f, 1.31602883e-01f, 9.66092870e-02f,
  6.75180778e-02f, 3.63806495e-03f, -5.36689237e-02f, 1.26703173e-01f, 1.02545448e-01f, 1.26486889e-03f, 9.60488096e-02f, -7.11817443e-02f, 1.20528545e-02f, -1.11550480e-01f,
  2.46822066e-03f, 6.31024241e-02f, -8.83333907e-02f, 4.56513092e-03f, 4.72341366e-02f, 3.34891453e-02f, -1.31617021e-02f, -5.61759621e-02f, -3.39843296e-02f, 2.24961005e-02f,
  2.47704890e-02f, 4.55194078e-02f, -1.11425422e-01f, -8.30535293e-02f, 6.81071589e-03f, 1.10027932e-01f, 1.42026311e-02f, -1.88728292e-02f, -6.46435469e-02f, -6.30547851e-02f,
  -6.98616430e-02f, -1.23138927e-01f, -4.88871969e-02f, 3.20854294e-03f, 6.70354292e-02f, -1.00278586e-01f, 1.63447578e-02f, 4.09912206e-02f, -8.48499909e-02f, 6.07316159e-02f,
  -5.58304191e-02f, 2.99747232e-02f, -8.93545803e-03f, -4.22751345e-02f, -8.21401104e-02f, 7.74016157e-02f, -8.79611634e-03f, -6.69007003e-02f, -7.90139511e-02f, -9.83257219e-02f,
  5.76074608e-03f, -5.63344546e-02f, -3.39387776e-03f, -8.14751834e-02f, -9.15413424e-02f, -1.48849236e-02f, -7.96329305e-02f, -5.55977002e-02f, 3.35733383e-03f, -2.59235278e-02f,
  2.02965876e-03f, 1.75830051e-02f, -3.91864851e-02f, 8.96920450e-03f, -1.24102626e-02f, -4.58308775e-03f, 1.51067115e-02f, -7.35326856e-02f, 5.64094484e-02f, 4.56480347e-02f,
  1.86873917e-02f, 4.18334268e-02f, 7.40749612e-02f, 3.37717757e-02f, 1.22294845e-02f, -1.73721381e-03f, -5.62701300e-02f, -2.10632477e-02f, 4.49790573e-03f, -8.97725448e-02f,
  -9.86091867e-02f, 5.19808680e-02f, -5.15529215e-02f, -1.32360831e-01f, 2.25651711e-02f, -2.44034622e-02f, 6.68837652e-02f, 2.50578448e-02f, -3.25834006e-02f, 4.62250933e-02f,
  -2.90351152e-01f, -1.89896300e-02f, -1.20367475e-01f, -1.38215259e-01f, 9.05561745e-02f, 1.69359874e-02f, -3.72505784e-02f, -4.70981076e-02f, 2.11166330e-02f, 1.96214337e-02f,
  -1.77466944e-02f, -1.10708207e-01f, -1.61437348e-01f, -1.40700594e-01f, -1.52674377e-01f, -1.11686274e-01f, -1.83100611e-01f, -1.07839257e-01f, -1.25949427e-01f, 4.63765953e-03f,
  -1.24314494e-01f, -2.09053054e-01f, -1.24056049e-01f, -8.09569359e-02f, 5.21803908e-02f, 2.83259936e-02f, -2.40258649e-02f, -3.57712321e-02f, 1.75116323e-02f, 1.43097555e-02f,
  -1.62259310e-01f, 3.06960456e-02f, 3.56398039e-02f, -3.56147476e-02f, 1.08190533e-02f, -4.08930369e-02f, 5.78190312e-02f, 3.69325429e-02f, 7.96739012e-02f, -5.49826846e-02f,
  -4.10713479e-02f, -6.99732676e-02f, -8.23169500e-02f, -6.02335446e-02f, 3.88615509e-03f, 3.69936340e-02f, 1.95310172e-02f, -7.08054565e-03f, 5.07696085e-02f, 2.48626377e-02f,
  -6.36228034e-03f, 1.03521608e-01f, -1.77659222e-03f, -2.27714283e-03f, 1.39733285e-01f, 2.77295783e-02f, 8.26970786e-02f, 9.88955349e-02f, -1.88933313e-02f, -7.39676654e-02f,
  -7.39639550e-02f, 1.83539521e-02f, 2.00558677e-02f, -9.75280777e-02f, -6.52361289e-02f, 6.04385547e-02f, 1.98666267e-02f, -1.04410507e-01f, 1.21063227e-02f, -3.03715784e-02f,
  8.21111649e-02f, 1.71264205e-02f, -1.18047491e-01f, -6.03703558e-02f, -1.14732638e-01f, -5.36973104e-02f, -2.53960360e-02f, 3.07678245e-02f, -8.88575688e-02f, 4.33083810e-02f,
  -9.32035670e-02f, 5.14731407e-02f, 9.38885752e-03f, -9.15433764e-02f, -2.87097227e-02f, -1.24501631e-01f, -1.97681785e-02f, 8.73500481e-02f, -2.76216418e-02f, 2.88798064e-02f,
  -1.62523285e-01f, -4.81383270e-03f, 1.27332993e-02f, -9.50680748e-02f, -4.77649691e-03f, -1.76391832e-03f, 1.21894646e-02f, -1.59722287e-02f, -8.72593448e-02f, 4.95753884e-02f,
  3.05583160e-02f, -9.32915583e-02f, -9.65915024e-02f, 2.91446806e-03f, 2.33277399e-02f, 8.36606789e-03f, -2.17024032e-02f, -1.71429724e-01f, 4.30472828e-02f, 1.10012971e-01f,
  -4.09950465e-02f, -4.23497520e-02f, -7.12487921e-02f, -5.91581911e-02f, 1.41457375e-02f, -5.68596944e-02f, -1.10826172e-01f, 8.03542361e-02f, -9.96478051e-02f, -2.37218991e-01f,
  -1.64652810e-01f, 8.58652219e-02f, -4.55653146e-02f, -3.83533426e-02f, 8.02166238e-02f, -1.28425388e-02f, -1.19323730e-01f, 4.31166999e-02f, -8.89817923e-02f, -6.38843924e-02f,
  -5.34916259e-02f, -4.27978747e-02f, -3.66396606e-02f, 1.55782644e-02f, -1.19511925e-01f, -9.17851180e-02f, 3.63029912e-03f, -1.54443726e-01f, -1.00011509e-02f, -9.11816955e-02f,
  -9.90984403e-03f, 7.09921354e-03f, -1.56245530e-01f, -5.49182706e-02f, 1.40985936e-01f, 1.13830427e-02f, 1.20558031e-01f, -4.12775502e-02f, -6.11133091e-02f, 6.88686445e-02f,
  2.06034318e-01f, -8.42005759e-02f, -4.81393700e-03f, 3.71335298e-02f, 7.95944780e-02f, -8.63961354e-02f, -3.31124961e-02f, 8.75699148e-02f, 1.61931869e-02f, 9.43152979e-02f,
  -3.74032483e-02f, -1.09425476e-02f, -1.10664163e-02f, 6.53992593e-02f, 3.83403301e-02f, 1.48874521e-02f, 8.38687867e-02f, 9.19037759e-02f, 1.08544342e-01f, 1.40970215e-01f,
  6.17165267e-02f, 1.01061217e-01f, 4.30816039e-02f, -1.21176075e-02f, 1.51653700e-02f, 5.02873734e-02f, 1.65370494e-01f, 1.41637787e-01f, 1.09058335e-01f, 1.14569061e-01f,
  -8.42829421e-02f, 8.11329260e-02f, -6.41566738e-02f, 2.96575949e-02f, 8.06094706e-02f, -2.09542774e-02f, -3.91601212e-02f, 2.69829743e-02f, -4.91115823e-02f, 5.18277138e-02f,
  4.52808710e-03f, -5.97769544e-02f, -5.76347597e-02f, -6.58017173e-02f, 7.85903707e-02f, 6.76204711e-02f, 6.47386983e-02f, 2.16483567e-02f, 9.58868265e-02f, -3.51627134e-02f,
  -3.80481444e-02f, 7.96926767e-03f, -1.97248254e-02f, 4.45061252e-02f, -4.68498133e-02f, -3.38584781e-02f, -5.73127791e-02f, 3.70108820e-02f, 6.53200597e-02f, -8.68948996e-02f,
  1.42252773e-01f, -1.12016872e-01f, -8.78465101e-02f, -2.15214510e-02f, -5.25134318e-02f, 8.11939538e-02f, 3.20416118e-04f, -6.25526682e-02f, -3.57841067e-02f, 3.54183391e-02f,
  7.83626363e-02f, 5.75022176e-02f, -5.07646352e-02f, 4.61205430e-02f, 2.98339054e-02f, -4.72630821e-02f, -3.30412947e-02f, 1.01294704e-01f, -1.36584481e-02f, 1.75318830e-02f,
  -6.64950581e-03f, 4.71668951e-02f, 3.64436358e-02f, 8.69823545e-02f, -1.12867355e-02f, 4.38112505e-02f, 4.38369811e-02f, -1.37248717e-03f, -3.63965444e-02f, -2.04809643e-02f,
  -2.77255565e-01f, -1.20386723e-02f, -1.74172074e-01f, 2.03241810e-01f, 1.89045265e-01f, 2.50572383e-01f, 2.28200331e-01f, 2.04332978e-01f, 1.76859185e-01f, 1.54352427e-01f,
  -8.82222578e-02f, 4.66275290e-02f, -6.47875965e-02f, 5.71701266e-02f, 4.40868810e-02f, 2.49355376e-01f, 1.36776641e-01f, -1.77735779e-02f, -7.35649914e-02f, 3.02904360e-02f,
  1.49659514e-01f, -4.52693552e-02f, -2.51819581e-01f, 4.94676121e-02f, 1.51222676e-01f, 8.09153840e-02f, -3.00263823e-03f, 7.17138872e-02f, -1.94340684e-02f, 1.39706090e-01f,
  -3.77391338e-01f, -1.38893813e-01f, 1.83703769e-02f, -6.16650395e-02f, -4.29133959e-02f, -2.88986508e-02f, -3.87295187e-02f, -1.40138313e-01f, -2.62294114e-02f, 2.16075778e-02f,
  -4.54953983e-02f, -5.98361157e-02f, -7.81501934e-04f, -4.51325774e-02f, -1.09075584e-01f, 4.79160808e-02f, -1.09172747e-01f, -1.36119023e-01f, -1.15998171e-01f, -8.02841708e-02f,
  9.63021964e-02f, 2.31251270e-02f, -3.77909541e-02f, 1.91765483e-02f, -4.15109918e-02f, -1.48258194e-01f, -1.09666497e-01f, -1.10357352e-01f, -1.09257296e-01f, -1.06848538e-01f,
  -5.41060865e-02f, -6.28071744e-03f, 5.83342500e-02f, -5.87662980e-02f, 2.93947160e-02f, -9.79894772e-03f, -7.85470102e-03f, 2.91610360e-02f, -2.04283316e-02f, -4.02965099e-02f,
  -1.47634353e-02f, -8.63615125e-02f, -5.74777126e-02f, -6.94480240e-02f, 1.25640929e-02f, 1.30047398e-02f, -1.12484419e-03f, -1.10477488e-03f, -5.83106689e-02f, -1.27958611e-01f,
  -2.73945611e-02f, -6.20885678e-02f, -6.41609877e-02f, -2.50460114e-02f, 1.02567345e-01f, -9.23128203e-02f, -5.34684770e-03f, 1.40276216e-02f, -2.80249249e-02f, -6.41062632e-02f,
  -9.64014605e-03f, -1.45267531e-01f, -2.77487058e-02f, 1.40493934e-03f, 2.60992218e-02f, -1.08435966e-01f, -4.94626053e-02f, -1.19566076e-01f, -1.18521042e-02f, -2.49420982e-02f,
  1.03269506e-03f, -1.05689123e-01f, -4.65439595e-02f, -1.75103750e-02f, 9.10025910e-02f, 5.79733364e-02f, -2.94169635e-02f, 8.45148042e-02f, 2.45273784e-02f, -1.02438204e-01f,
  -1.14725651e-02f, 1.04278453e-01f, -1.66815892e-02f, -8.55332166e-02f, 4.36469093e-02f, -9.02582407e-02f, -1.10323258e-01f, 7.50366598e-02f, -1.13213509e-01f, -2.17391532e-02f,
  2.89511438e-02f, -1.29098997e-01f, 3.15439180e-02f, 1.64746329e-01f, 5.12243621e-02f, -9.53354966e-03f, 1.42587781e-01f, 8.16549733e-02f, -6.88224752e-03f, -7.93730021e-02f,
  -5.73364608e-02f, -9.52210426e-02f, -5.49529605e-02f, 2.38348125e-03f, 1.75064951e-02f, 1.01702824e-01f, 1.44840255e-01f, 3.47245596e-02f, 9.15102474e-03f, -6.65543228e-02f,
  5.80442734e-02f, 4.68154326e-02f, -1.06388398e-01f, -8.93014595e-02f, -7.48969987e-02f, 2.00595446e-02f, 1.27328420e-02f, -1.39370030e-02f, 8.30706675e-03f, 1.68286953e-02f,
  -1.95961028e-01f, -2.30221730e-02f, 2.99285874e-02f, 3.38815339e-02f, -6.04492240e-03f, -1.60454735e-02f, -8.03069696e-02f, -3.97052839e-02f, 1.65940318e-02f, -1.40883615e-02f,
  -6.74522445e-02f, -1.88320782e-02f, -9.82296914e-02f, -1.12850733e-01f, -1.68286022e-02f, -2.21085530e-02f, 4.43368852e-02f, 2.42330674e-02f, -2.65565682e-02f, 1.42703680e-02f,
  -2.35099695e-03f, 4.42462452e-02f, -1.44401472e-02f, -2.87103299e-02f, 2.08967291e-02f, 1.24491556e-02f, -9.43563785e-03f, -4.92017493e-02f, -6.58239573e-02f, 4.38035652e-02f,
  4.67149839e-02f, 3.71436179e-02f, -9.62905139e-02f, -1.18607298e-01f, -3.58147584e-02f, -3.77894961e-03f, 1.08166069e-01f, 8.55107009e-02f, 7.14565143e-02f, -9.14840028e-03f,
  -5.92292435e-02f, -1.98120065e-02f, 2.13171653e-02f, -1.81051828e-02f, -1.17424205e-01f, -5.61759062e-02f, 6.18587248e-02f, -9.95763987e-02f, -5.74066602e-02f, 3.59715745e-02f,
  1.46491798e-02f, -1.53255323e-02f, 1.84638947e-02f, -9.41332206e-02f, -4.35619317e-02f, -2.94542518e-02f, 4.41946797e-02f, -1.12767994e-01f, -5.31710163e-02f, -7.24950805e-02f,
  5.58776930e-02f, -7.15939105e-02f, 1.14447288e-01f, 9.18142870e-02f, 7.57891387e-02f, -9.59853157e-02f, -3.02465875e-02f, -4.05476652e-02f, 6.14032522e-02f, -8.43887590e-03f,
  -1.06931962e-01f, -6.18977286e-03f, 2.71875151e-02f, -2.06038859e-02f, 1.62392836e-02f, -4.31359187e-03f, -8.00118670e-02f, 1.64927412e-02f, -4.17922214e-02f, 2.23823506e-02f,
  -2.12012674e-03f, 5.95740341e-02f, 1.70525089e-01f, -1.95123721e-02f, 5.84097840e-02f, 1.05769455e-01f, 2.75158249e-02f, 1.66755412e-02f, 2.68838368e-02f, 1.11229919e-01f,
  -5.28178131e-03f, -1.33836269e-03f, -1.30071059e-01f, -1.11635039e-02f, 5.22341989e-02f, 6.27298504e-02f, -6.77041635e-02f, -7.69492751e-03f, 1.35999799e-01f, 3.33249420e-02f,
  1.53803617e-01f, 3.29802111e-02f, -6.61524944e-03f, -1.34553462e-01f, -1.80554315e-01f, -1.20943390e-01f, -8.51085708e-02f, -1.96861103e-01f, -1.66729212e-01f, -2.40031742e-02f,
  8.08348134e-02f, -1.19084820e-01f, -1.71686798e-01f, -1.09410420e-01f, 8.91855881e-02f, 7.13788345e-02f, -3.58425006e-02f, 6.23940751e-02f, 4.53290567e-02f, -5.44534577e-03f,
  -7.97365457e-02f, -2.63041295e-02f, 2.35883184e-02f, 1.52579544e-03f, 3.18159685e-02f, -8.86086747e-02f, -7.10525364e-02f, -8.37286338e-02f, 4.39261049e-02f, -2.74466425e-02f,
  6.90033883e-02f, 4.77949567e-02f, 6.20353669e-02f, 4.68597934e-02f, -5.43369949e-02f, -7.23480433e-02f, -8.88092667e-02f, -1.86883137e-01f, -9.90748852e-02f, -6.12808727e-02f,
  -6.24076230e-03f, 1.96857397e-02f, -1.38222635e-01f, -3.47378999e-02f, -1.16785988e-01f, -2.83753611e-02f, 4.54315394e-02f, 2.32112389e-02f, -1.42250732e-02f, -8.23610574e-02f,
  9.38301086e-02f, 4.27476615e-02f, 3.17364512e-03f, -2.64231954e-02f, -5.20438291e-02f, 2.07060501e-02f, -6.47109821e-02f, 5.96775971e-02f, -8.47207233e-02f, 6.08177297e-02f,
  2.45613419e-02f, -4.59032208e-02f, 3.87426047e-03f, -5.97101599e-02f, 2.14500502e-02f, 3.41152623e-02f, 1.04617983e-01f, 9.95027740e-03f, -1.50912367e-02f, -1.81859434e-02f,
  -3.96660157e-02f, 2.80718599e-02f, -8.98587853e-02f, 4.72952165e-02f, 5.75772300e-02f, 7.95660838e-02f, 8.83630440e-02f, 1.99067630e-02f, 8.41691792e-02f, 8.47389996e-02f,
  -8.73052776e-02f, 7.71257877e-02f, 7.13619683e-03f, -4.14547976e-03f, 9.92153734e-02f, 3.73896584e-02f, 8.96519888e-03f, 2.10699812e-02f, 2.17013564e-02f, 4.62392978e-02f,
  -5.91589585e-02f, -1.13156689e-02f, -7.25989938e-02f, 4.94376458e-02f, -1.04240090e-01f, -1.68772899e-02f, -5.25575094e-02f, -2.20327266e-02f, -1.67809315e-02f, -8.41689259e-02f,
  2.75676139e-02f, -1.31528422e-01f, -1.90518916e-01f, -3.49767767e-02f, -3.45174521e-02f, -3.83940414e-02f, -1.27305031e-01f, -5.49789444e-02f, -9.44558680e-02f, -5.15600108e-02f,
  1.35996953e-01f, -1.53131727e-02f, 1.32672444e-01f, 1.29214808e-01f, 1.11151569e-01f, 7.68375322e-02f, 2.73633394e-02f, 7.97478482e-02f, 4.97329645e-02f, 1.18192673e-01f,
  -2.13925517e-03f, -2.49706581e-02f, 3.83788981e-02f, 1.14156187e-01f, 1.15684442e-01f, 2.97219884e-02f, -4.20497032e-03f, -4.19199318e-02f, 1.46670774e-01f, 4.57051508e-02f,
  4.58786637e-02f, 4.87037227e-02f, -5.90208694e-02f, -1.52998222e-02f, -1.36392713e-01f, 4.05559428e-02f, -6.74805939e-02f, -5.16250096e-02f, 1.35597074e-02f, -1.55344918e-01f,
  3.26470025e-02f, -2.08022352e-02f, 1.41699553e-01f, -6.26558140e-02f, 7.88276084e-03f, 6.05041496e-02f, -2.79497504e-02f, -2.19943710e-02f, -8.59596580e-02f, -2.82975901e-02f,
  -5.34842163e-02f, 5.20984270e-03f, -9.58666280e-02f, -6.95564598e-02f, -8.49479996e-03f, 3.03662755e-02f, -2.62142606e-02f, -4.42042612e-02f, 7.92299286e-02f, -5.28177097e-02f,
  -9.67426598e-02f, -3.41409892e-02f, 5.68616278e-02f, -8.16680267e-02f, 2.40219198e-03f, 2.61922944e-02f, 1.92414224e-02f, -7.76739232e-03f, 7.94720650e-02f, -7.04403641e-03f,
  6.75601140e-02f, 2.38506515e-02f, -4.25114632e-02f, -8.68945792e-02f, -6.90674782e-02f, -4.69782278e-02f, 7.11601460e-03f, 2.05750088e-03f, -4.80954498e-02f, 6.20254278e-02f,
  9.50668082e-02f, 6.88254908e-02f, -3.23409997e-02f, 9.66840908e-02f, 1.04556819e-02f, -4.47617620e-02f, -7.66469911e-02f, -2.66822632e-02f, 4.41632830e-02f, -9.51241478e-02f,
  3.10754701e-02f, -3.55711244e-02f, -2.62980051e-02f, 2.20767651e-02f, -4.27108370e-02f, -2.12864131e-02f, -2.64541507e-02f, -2.91948561e-02f, -4.29212302e-02f, -1.82282254e-02f,
  -9.51562524e-02f, 1.67833969e-01f, 3.10996771e-02f, -8.49312767e-02f, 5.33857569e-03f, 2.47300193e-02f, -4.34313118e-02f, -2.35604402e-02f, -6.19789995e-02f, 1.62986089e-02f,
  4.71844450e-02f, -6.82725385e-02f, -1.25023611e-02f, 4.01304737e-02f, 5.23092784e-02f, 1.76782394e-03f, -7.11546242e-02f, -9.17567238e-02f, 1.39578162e-02f, 4.37936820e-02f,
  -3.93759087e-02f, 5.97712621e-02f, 9.75349247e-02f, -1.46923633e-03f, 5.70932403e-02f, 1.33828804e-01f, -5.87977469e-02f, 9.90194976e-02f, 1.78756528e-02f, 4.05375436e-02f,
  2.62148052e-01f, 2.12771952e-01f, 3.34315635e-02f, 4.45499122e-02f, -7.31536150e-02f, -1.33295327e-01f, -7.94420615e-02f, -7.37355500e-02f, -6.84586167e-02f, 6.50179461e-02f,
  -5.87055273e-02f, -6.04471974e-02f, -9.96873528e-02f, -1.75040979e-02f, 5.04973643e-02f, 1.31274732e-02f, 5.56975119e-02f, 2.66301483e-02f, -3.08204722e-02f, 2.89326124e-02f,
  1.24841221e-01f, 1.39998361e-01f, 1.46970972e-01f, 2.06733495e-02f, 2.55971439e-02f, 1.97975542e-02f, -3.70017663e-02f, -4.78793234e-02f, 8.13209638e-02f, 2.98150361e-01f,
  1.32201314e-01f, -2.65426021e-02f, -1.62956901e-02f, -1.03964666e-02f, -8.12749863e-02f, 1.10924728e-01f, 7.25954995e-02f, 5.21445796e-02f, 1.13747306e-02f, -3.33527625e-02f,
  6.80176616e-02f, 4.35756929e-02f, 3.45429070e-02f, 7.14857057e-02f, 9.29054022e-02f, -3.09469495e-02f, -1.47819063e-02f, -7.74962408e-03f, -3.86985322e-03f, -4.88054156e-02f,
  -1.68978646e-02f, 7.49956518e-02f, 2.84878369e-02f, -1.15844689e-01f, 4.43069711e-02f, 4.92026173e-02f, 2.56479345e-02f, 9.94710252e-02f, -8.75484198e-02f, 1.09672122e-01f,
  -4.84012626e-02f, 1.15239188e-01f, -6.74607325e-03f, -3.32789086e-02f, 6.08744919e-02f, -1.00702308e-01f, -6.71104193e-02f, 1.75962541e-02f, -6.23304471e-02f, 5.78538887e-02f,
  5.23788435e-03f, 4.27068844e-02f, -6.47768676e-02f, 3.47437598e-02f, 4.27877083e-02f, -3.43094356e-02f, 6.77128658e-02f, -3.45986001e-02f, -4.97805029e-02f, 9.06702280e-02f,
  -3.78979743e-02f, -9.33744200e-03f, -8.21482092e-02f, 8.17785412e-03f, 3.91511060e-02f, 5.20912632e-02f, 1.48690073e-02f, 6.29914328e-02f, -5.23251630e-02f, 5.91841228e-02f,
  -9.25293341e-02f, -2.27167398e-01f, 8.85626152e-02f, 7.96618909e-02f, -1.52564347e-02f, -3.78747918e-02f, -9.90452990e-03f, -7.38816559e-02f, 3.38017642e-02f, -6.82095706e-04f,
  -1.33496094e-02f, -1.29854144e-03f, -3.72959650e-04f, -8.26423392e-02f, -8.73760357e-02f, -9.96536389e-03f, -1.05428830e-01f, -1.05248587e-02f, -6.58885464e-02f, 2.90223453e-02f,
  -1.75620876e-02f, -6.06993912e-03f, -4.80094291e-02f, -1.09603144e-01f, 9.39197559e-03f, -3.45971398e-02f, -5.08131534e-02f, -3.58052589e-02f, -1.63586378e-01f, 2.59268675e-02f,
  -1.54896349e-01f, -2.41251905e-02f, -7.90106654e-02f, 2.69189209e-01f, 3.27058941e-01f, 2.27239132e-01f, 1.45013362e-01f, 2.13874370e-01f, 2.01391473e-01f, 5.62549848e-03f,
  1.11565337e-01f, 4.78758551e-02f, 2.77827606e-02f, 1.35058656e-01f, 5.00369705e-02f, 4.45617400e-02f, 1.67947263e-01f, 6.69363663e-02f, -1.99145693e-02f, 1.52465403e-01f,
  1.42057404e-01f, -8.70138220e-03f, -6.42457157e-02f, 6.51434958e-02f, 1.03246562e-01f, 5.82802221e-02f, 7.91231245e-02f, 5.81560917e-02f, -5.51024601e-02f, -9.20032337e-02f,
  -3.48342247e-02f, -1.66946262e-01f, 3.68540175e-02f, 5.18021658e-02f, -1.47842079e-01f, -6.42040297e-02f, -4.70851874e-03f, -1.46972388e-01f, -6.59654811e-02f, -8.77718180e-02f,
  2.14158185e-02f, -1.03822164e-01f, -5.86047918e-02f, -5.64839579e-02f, -3.55231762e-02f, -3.59323137e-02f, -3.28462198e-02f, 1.07010184e-02f, 1.17872665e-02f, 5.37785366e-02f,
  9.61714014e-02f, 7.98408762e-02f, -4.34814952e-02f, 5.14514484e-02f, 6.20771907e-02f, 1.49005819e-02f, -3.47314216e-02f, -8.11984241e-02f, 2.62784176e-02f, -1.99562293e-02f,
  4.46771551e-03f, 3.32511254e-02f, 6.32974505e-02f, -8.52752924e-02f, 2.82259472e-02f, 3.07029951e-03f, 1.10018346e-02f, 1.05634397e-02f, 1.21568799e-01f, -3.85899059e-02f,
  -3.76103371e-02f, 7.82145038e-02f, -2.83681657e-02f, 1.89355167e-03f, -4.02032621e-02f, 2.26811990e-02f, 3.37161566e-03f, -4.73536178e-02f, -8.51170123e-02f, -5.98357953e-02f,
  -1.66563690e-02f, -4.75529023e-02f, 1.15302373e-02f, 3.12195625e-02f, 5.70968054e-02f, -6.41753674e-02f, 5.06692342e-02f, -2.01618038e-02f, -8.22494105e-02f, 1.17404712e-02f,
  -2.45291032e-02f, -3.10426708e-02f, 3.28109562e-02f, -4.06185947e-02f, -1.08740769e-01f, -1.39337569e-01f, 6.04104847e-02f, -6.09077513e-02f, -5.33631556e-02f, -1.30266987e-03f,
  -2.18310449e-02f, 1.31453304e-02f, -3.37742195e-02f, -7.14251250e-02f, 3.56974341e-02f, 1.20904867e-03f, -8.52966607e-02f, 1.31535344e-02f, 5.02955504e-02f, 3.72462869e-02f,
  7.99114108e-02f, -1.64480042e-02f, -2.70309187e-02f, 8.36668983e-02f, 8.84317309e-02f, 4.89029959e-02f, -6.81745335e-02f, 5.76235987e-02f, 4.24309596e-02f, 1.77337844e-02f,
  -4.14795019e-02f, 1.35953099e-01f, 6.31063506e-02f, 3.40597406e-02f, 1.09385423e-01f, -4.79287915e-02f, -3.44404881e-03f, -4.99276668e-02f, -1.28915787e-01f, 5.91834858e-02f,
  5.04981950e-02f, 2.87132207e-02f, -2.91903354e-02f, -1.22028731e-01f, -1.21146671e-01f, 1.77047197e-02f, 1.47096872e-01f, -5.67510836e-02f, -2.44118169e-01f, -1.85976550e-01f,
  -6.80119693e-02f, -8.47173184e-02f, -4.57828864e-02f, -1.67860895e-01f, 4.49207760e-02f, -8.70520025e-02f, 7.01152980e-02f, -2.21238919e-02f, 5.23442887e-02f, 1.36568353e-01f,
  -8.68638530e-02f, 9.17305499e-02f, -9.71419662e-02f, -6.43638894e-02f, 3.48400623e-02f, 4.22641523e-02f, -1.74622855e-03f, 2.89259870e-02f, -6.22318648e-02f, 6.65362030e-02f,
  8.92485864e-03f, 1.63043067e-02f, 6.59976038e-04f, -3.64257321e-02f, -1.48203343e-01f, -9.49633047e-02f, -1.49362525e-02f, -7.81736970e-02f, -3.23518813e-02f, -7.83318728e-02f,
  3.21043022e-02f, 6.64237663e-02f, -8.99106562e-02f, 3.86776775e-02f, -5.10076396e-02f, 5.71443811e-02f, -9.82413627e-03f, -9.56249051e-03f, -3.18966876e-03f, -1.11298166e-01f,
  -7.96144828e-02f, -6.29836228e-03f, 8.50004777e-02f, 6.89783841e-02f, -4.21191491e-02f, -5.96317416e-03f, 3.84762101e-02f, 8.04122761e-02f, -7.80879855e-02f, 3.84480059e-02f,
  1.84291434e-02f, 1.94777199e-03f, 8.37639496e-02f, 8.64161924e-02f, -4.93872389e-02f, -4.21792679e-02f, 1.42845027e-02f, 8.14470872e-02f, -5.07460497e-02f, 2.57638138e-04f,
  -3.03213894e-02f, -6.50569797e-02f, 4.60346416e-02f, -1.11080473e-02f, -1.45535544e-02f, 2.93991109e-03f, 4.58522253e-02f, 4.16382365e-02f, 6.70606643e-02f, -1.22680608e-03f,
  -1.23077266e-01f, 7.49389529e-02f, 4.07907479e-02f, -1.13517486e-01f, 1.39537482e-02f, -4.78594303e-02f, -5.22696935e-02f, -3.96429151e-02f, 1.19584808e-02f, -4.05122526e-02f,
  -7.03936890e-02f, -6.26301765e-02f, 5.95086031e-02f, -7.17780814e-02f, -1.45826578e-01f, -5.86469956e-02f, 8.07768703e-02f, 3.09168864e-02f, -1.31085292e-01f, 3.33760306e-02f,
  2.37971991e-02f, -6.34082481e-02f, -1.11762546e-01f, -1.16298221e-01f, -2.21881885e-02f, -8.22218508e-02f, -1.41605511e-01f, -1.94901809e-01f, -1.79987878e-01f, -1.28680736e-01f,
  1.85860321e-01f, -6.59849644e-02f, 1.35804519e-01f, 2.79529728e-02f, 1.15466088e-01f, 1.51582837e-01f, 4.54463586e-02f, 1.34479225e-01f, 9.46403071e-02f, 6.17666878e-02f,
  -1.24966837e-02f, 1.04607537e-01f, 9.00623724e-02f, 1.87812038e-02f, 1.82857420e-02f, -4.88851517e-02f, 8.13270435e-02f, 1.23261645e-01f, 3.86800095e-02f, -2.75894441e-02f,
  8.28671157e-02f, 7.69246370e-02f, 9.64497551e-02f, -5.21003688e-03f, 7.36417074e-04f, 1.76197272e-02f, 1.68864802e-02f, -1.46752995e-04f, -2.09473167e-02f, 4.84392382e-02f,
  -2.04428080e-02f, 3.56379971e-02f, 1.76650248e-02f, 1.28202494e-02f, -3.56031545e-02f, 1.31906457e-02f, 5.43156639e-02f, -7.87253752e-02f, 2.25796159e-02f, 2.48871424e-04f,
  -6.21811673e-02f, 4.04160097e-02f, -3.66856460e-03f, -5.84185719e-02f, -8.10760353e-03f, 3.19952816e-02f, 6.89586177e-02f, 1.30503997e-02f, 5.75929992e-02f, -4.61570509e-02f,
  -7.13859946e-02f, -5.70369838e-03f, 1.68872755e-02f, -6.80106552e-03f, 7.89065808e-02f, 7.70386085e-02f, -3.31107937e-02f, 2.68407236e-03f, 6.73642159e-02f, 3.95994484e-02f,
  5.15770242e-02f, -1.97274107e-02f, 2.24608704e-02f, 7.04875514e-02f, -6.44796491e-02f, -7.98935518e-02f, 7.47660622e-02f, -2.36146823e-02f, 6.21985160e-02f, -1.80099849e-02f,
  -4.98689190e-02f, 7.93473199e-02f, 1.02003112e-01f, -2.90450864e-02f, -7.20685124e-02f, 1.88168790e-02f, -8.18703249e-02f, -6.37738481e-02f, 4.08418141e-02f, -1.11336811e-02f,
  -3.63738164e-02f, 5.60120381e-02f, -1.55855734e-02f, 3.88061330e-02f, 7.24432543e-02f, -1.93336494e-02f, 1.25899157e-02f, 1.23403026e-02f, 5.41314967e-02f, -2.84333564e-02f,
  -1.45922005e-02f, 7.86605775e-02f, 1.63584352e-02f, -8.77276585e-02f, 6.11179732e-02f, 1.93380453e-02f, 6.27989471e-02f, -1.23599455e-01f, -1.33083090e-01f, -5.18934615e-02f,
  -8.15100744e-02f, -5.83128445e-02f, 8.56002718e-02f, -3.52561362e-02f, 2.40959339e-02f, -5.27986176e-02f, 7.91956186e-02f, -3.84698175e-02f, 1.80056766e-02f, 2.40628477e-02f,
  -6.78642765e-02f, -6.24427982e-02f, 7.63034597e-02f, -6.03139028e-02f, 9.69275981e-02f, 1.17379710e-01f, -1.10147567e-02f, -8.43534097e-02f, 4.77552377e-02f, -8.35323483e-02f,
  -1.80811524e-01f, 9.72804129e-02f, -1.69872075e-01f, 1.20347567e-01f, 4.83077988e-02f, -5.90739809e-02f, -7.68718123e-02f, -4.42657880e-02f, 2.78868806e-02f, 5.00694960e-02f,
  -2.22748816e-02f, 1.68151990e-01f, 9.13738757e-02f, -7.30976760e-02f, -6.85254857e-02f, 3.91733013e-02f, 7.79810455e-03f, 3.74925174e-02f, -5.47669381e-02f, 6.90031350e-02f,
  1.80406064e-01f, 1.43444231e-02f, -9.93353501e-02f, -7.88302273e-02f, 1.45175114e-01f, 2.79505663e-02f, 2.67649572e-02f, 1.11892030e-01f, -1.73224621e-02f, 2.20062509e-01f,
  5.26245125e-02f, -6.25388101e-02f, 4.90466394e-02f, -8.66561010e-03f, 2.45771129e-02f, 4.82000075e-02f, 4.57890108e-02f, -1.17291912e-01f, -7.28733614e-02f, -5.02423085e-02f,
  -2.27565430e-02f, -4.52399887e-02f, -4.86397184e-02f, -1.78454886e-03f, -2.92225592e-02f, -1.05483860e-01f, -1.18376926e-01f, -1.19307965e-01f, -4.79195900e-02f, -1.37875572e-01f,
  2.91593373e-02f, -2.49040890e-02f, -1.22798771e-01f, -1.86356567e-02f, -9.38104689e-02f, 2.78863888e-02f, -4.79712225e-02f, -1.25026241e-01f, -7.23328034e-04f, -6.58896044e-02f,
  7.93594345e-02f, -7.30303228e-02f, -1.02378599e-01f, 6.13690615e-02f, 3.99099141e-02f, -2.52825078e-02f, -1.22977225e-02f, -3.16098332e-02f, -1.24119129e-02f, -7.95597285e-02f,
  4.98295575e-02f, -2.19209213e-02f, 4.98645343e-02f, 9.23950747e-02f, 7.03514069e-02f, -3.94233852e-04f, 5.27539141e-02f, -5.67293018e-02f, 2.45094988e-02f, 7.18386471e-02f,
  9.22874920e-03f, -6.52688369e-02f, 3.72771062e-02f, -4.23369333e-02f, -3.52012701e-02f, -1.51220215e-02f, -3.76288518e-02f, 4.10787351e-02f, -6.28646389e-02f, 1.47105772e-02f,
  7.15810210e-02f, -7.45069757e-02f, 1.42237544e-01f, 4.88541275e-02f, -2.95930207e-02f, -3.77159193e-02f, 2.45822780e-03f, -6.75917193e-02f, 1.36529412e-02f, -5.48316427e-02f,
  -8.28458741e-03f, 6.38757050e-02f, 4.56306525e-02f, 2.01399578e-03f, -9.60680693e-02f, -1.55870197e-02f, -4.15502451e-02f, 1.89131107e-02f, -7.02113137e-02f, -1.04263492e-01f,
  6.94080442e-02f, 1.37642063e-02f, -8.62626079e-03f, -8.44879523e-02f, 3.81075442e-02f, 7.83351362e-02f, -5.47408573e-02f, 6.41007274e-02f, -8.79201367e-02f, 5.19059040e-02f,
  -1.74934953e-01f, -7.18433857e-02f, 1.13369957e-01f, -1.12056313e-02f, -1.87042821e-02f, 1.19868688e-01f, 5.54270931e-02f, 6.14544339e-02f, 6.86635375e-02f, -1.82827376e-02f,
  2.55912598e-02f, 3.21891047e-02f, -7.13092610e-02f, 6.10879622e-02f, -3.63922603e-02f, 2.61466466e-02f, -1.49754854e-02f, 8.68410543e-02f, 8.95577297e-02f, 7.62611777e-02f,
  6.15986027e-02f, -4.99800593e-02f, -4.84066783e-04f, -2.51301471e-02f, 5.44590428e-02f, 3.43763940e-02f, 4.43761088e-02f, -2.17941124e-02f, -1.27562089e-02f, 6.99786544e-02f,
  1.26212211e-02f, -1.87622476e-02f, -2.00689561e-03f, -3.08792554e-02f, 6.56468328e-03f, -7.07459822e-02f, 3.24285193e-03f, -1.09836020e-01f, 1.80594474e-02f, 3.84092964e-02f,
  -7.04398975e-02f, -1.03715761e-02f, 4.30265926e-02f, -3.24540213e-02f, -4.76959124e-02f, -6.11731671e-02f, -1.25603899e-01f, 4.00720686e-02f, 3.36947851e-02f, -4.84915823e-03f,
  -1.51119968e-02f, 6.24430962e-02f, -5.51960431e-02f, 1.44950021e-02f, -1.33767286e-02f, -2.45838854e-02f, 3.10551710e-02f, -6.88177273e-02f, 2.89822295e-02f, -3.91892008e-02f,
  7.34805465e-02f, 5.92862405e-02f, -8.03958401e-02f, 5.74312322e-02f, -4.87373397e-02f, 9.25319344e-02f, 3.51289101e-02f, -1.61488988e-02f, 2.40483345e-03f, 8.31342191e-02f,
  -7.12099820e-02f, 1.40184667e-02f, 1.06751300e-01f, -2.98846457e-02f, 1.80971867e-03f, 2.23583020e-02f, -5.50531112e-02f, 4.35716892e-03f, -7.74415722e-03f, -7.61667565e-02f,
  5.51158264e-02f, -6.69780150e-02f, 6.64700419e-02f, -3.69678400e-02f, -2.31486093e-03f, -5.49251027e-02f, 6.75572976e-02f, -5.43432049e-02f, 9.89596359e-04f, -5.56130372e-02f,
  1.51771247e-01f, -1.26481161e-01f, -2.00811569e-02f, -3.34381536e-02f, -6.28510714e-02f, -2.78185420e-02f, -4.06121090e-02f, 7.96631537e-03f, 6.78576082e-02f, 1.00662626e-01f,
  -4.26449515e-02f, -3.82543877e-02f, -2.81593911e-02f, 2.00440623e-02f, -4.36269678e-03f, 3.25536579e-02f, -7.28879310e-03f, 8.95565376e-02f, 7.10802153e-02f, 5.50914891e-02f,
  -1.05563834e-01f, 1.22839592e-01f, -3.02023217e-02f, 7.33845234e-02f, -8.54156315e-02f, 1.93305947e-02f, 9.85026583e-02f, 8.02400187e-02f, 9.44382176e-02f, 9.82317775e-02f,
  8.62858966e-02f, -1.25418633e-01f, -6.70828670e-02f, -1.32458568e-01f, -1.63367227e-01f, -1.00192437e-02f, -5.51489443e-02f, -8.90410244e-02f, -1.15502320e-01f, -1.19953374e-05f,
  -9.21147317e-02f, 8.23528245e-02f, 1.10321783e-01f, 1.14137217e-01f, 7.60973543e-02f, -4.49238643e-02f, 2.72056684e-02f, 4.20059003e-02f, 6.61611035e-02f, -8.93101692e-02f,
  5.40860072e-02f, -5.93936369e-02f, 8.11484307e-02f, -1.62662901e-02f, -1.27828702e-01f, 1.38893984e-02f, -1.41340449e-01f, -3.53857595e-03f, -1.70134772e-02f, -1.11745924e-01f,
  -5.30306846e-02f, 7.15598166e-02f, 3.52446698e-02f, -3.15968804e-02f, -5.80677763e-02f, -1.04981824e-03f, 3.83122899e-02f, 5.97338974e-02f, 5.65076321e-02f, 5.55885844e-02f,
  8.63089710e-02f, 2.46838480e-02f, -1.13159642e-02f, -6.32661022e-03f, 6.00069910e-02f, 1.98317203e-03f, 4.07909267e-02f, 7.02636242e-02f, 9.38979536e-03f, -8.13860074e-02f,
  -5.32614775e-02f, 5.03376015e-02f, -2.25593187e-02f, -9.78290848e-03f, -1.52034229e-02f, 9.05086547e-02f, -6.01495476e-03f, -4.42993492e-02f, 8.97972845e-03f, -2.92888302e-02f,
  2.08467841e-02f, -4.46425751e-03f, -5.73507883e-02f, 1.25419777e-02f, -9.37308650e-03f, -8.45826939e-02f, -6.87750876e-02f, 1.01230510e-01f, 4.02738750e-02f, -7.89493769e-02f,
  -3.66965099e-03f, -1.78260952e-02f, -8.01936910e-03f, -1.74889416e-02f, 5.69729470e-02f, -4.73596752e-02f, -5.13405912e-03f, 4.37909029e-02f, 6.62267506e-02f, 2.43633967e-02f,
  -9.20301396e-03f, 2.54615825e-02f, 4.32081670e-02f, -4.55737561e-02f, 6.17586970e-02f, -7.33706309e-03f, 5.85833713e-02f, -6.87642246e-02f, -7.80790970e-02f, -6.12131394e-02f,
  -6.71185851e-02f, 1.64019108e-01f, -4.49846312e-02f, 1.34266717e-02f, 7.27204978e-02f, -1.18538644e-02f, 1.70664154e-02f, -5.76716550e-02f, -9.39956773e-03f, 5.99878505e-02f,
  -6.29371172e-03f, -6.97876364e-02f, 1.10420026e-02f, -2.28661858e-02f, -8.96424800e-02f, 9.12702680e-02f, -6.46817386e-02f, 9.25962552e-02f, 8.72977450e-02f, -9.92136225e-02f,
  -1.33742362e-01f, 3.11208740e-02f, -2.36889441e-02f, -2.31015198e-02f, 7.06868172e-02f, 7.74276331e-02f, 2.11392138e-02f, -6.30202815e-02f, 3.84358875e-02f, -4.81304377e-02f,
  -1.17680497e-01f, -1.81715041e-01f, -2.22792789e-01f, -7.14517459e-02f, -1.10144332e-01f, 1.25293164e-02f, -6.86698481e-02f, -1.15704834e-02f, 3.84136774e-02f, -1.38176277e-01f,
  -9.75509081e-03f, 1.93806738e-02f, -9.11698118e-02f, 6.77707791e-02f, -5.45326360e-02f, -8.72502774e-02f, -1.98556975e-01f, -5.03591597e-02f, -4.36883606e-02f, 7.23372325e-02f,
  -1.03751801e-01f, -3.83682996e-02f, 8.98697004e-02f, 2.09931508e-02f, -4.00300249e-02f, -3.56259546e-03f, -3.22166160e-02f, -8.47395509e-02f, 4.89592850e-02f, -1.50292501e-01f,
  -9.63975415e-02f, 3.75975072e-02f, 1.10310957e-01f, -2.39072205e-03f, -3.05050947e-02f, -5.68127558e-02f, -4.88540754e-02f, 6.16618432e-02f, -2.87564397e-02f, 5.89542240e-02f,
  -4.80674719e-03f, -2.83859912e-02f, -4.72755469e-02f, -1.32275757e-03f, 7.16474699e-03f, 9.47878137e-02f, -5.94472922e-02f, 3.15882899e-02f, 2.99431160e-02f, -8.23060274e-02f,
  2.39004716e-02f, 5.83935454e-02f, -2.00960878e-03f, 4.57782531e-03f, 9.06792060e-02f, 4.80966792e-02f, -7.92299211e-03f, 4.99375835e-02f, 1.09675258e-01f, 7.75037035e-02f,
  -1.04674567e-02f, -1.18234223e-02f, -4.79354486e-02f, 1.37502225e-02f, 5.97206615e-02f, -4.03754897e-02f, 2.00680215e-02f, 5.90677783e-02f, -2.01881267e-02f, 3.30359116e-02f,
  -2.96964915e-03f, -3.03189512e-02f, 2.89634541e-02f, -7.10338429e-02f, 7.18079433e-02f, -2.11123191e-02f, 7.24924579e-02f, -1.31355030e-02f, -5.18635958e-02f, -2.30780914e-02f,
  3.91311496e-02f, -3.01779639e-02f, -4.73078527e-02f, 3.34179439e-02f, 6.50461838e-02f, -8.53315517e-02f, 6.82190433e-02f, -2.09718198e-02f, 8.36406182e-03f, 1.50521481e-02f,
  -1.23076700e-01f, 1.41068865e-02f, -7.75190666e-02f, 7.37432111e-03f, -1.72636490e-02f, -3.23168151e-02f, -4.66208607e-02f, -6.89331219e-02f, 4.77108173e-02f, -7.89921656e-02f,
  1.75040513e-02f, -5.72653338e-02f, -2.19622739e-02f, 1.78332999e-02f, 7.01382086e-02f, 3.61626083e-03f, -4.37326729e-02f, -2.71885544e-02f, 2.64515597e-02f, -6.57012733e-03f,
  -7.91456401e-02f, -9.00974870e-02f, 2.40718015e-02f, 9.88701880e-02f, -1.69052556e-02f, -5.61921299e-02f, 1.14332726e-02f, 6.67315871e-02f, 5.82270809e-02f, -2.99069821e-03f,
  7.81764612e-02f, -2.20614254e-01f, -1.97139919e-01f, 1.36033008e-02f, -2.90964637e-02f, -5.64603768e-02f, -2.28919029e-01f, -2.89167073e-02f, 9.52496529e-02f, -1.07647255e-01f,
  -5.07013835e-02f, 6.87347203e-02f, 4.58150208e-02f, -7.46987686e-02f, -5.34242801e-02f, -1.68601111e-01f, -1.53655663e-01f, -3.83744650e-02f, 2.32227053e-02f, 1.08437113e-01f,
  -3.16520780e-02f, -5.03624193e-02f, 6.37669340e-02f, 1.06412927e-02f, -2.77988147e-02f, -2.25093067e-02f, -1.67737678e-01f, -7.50819370e-02f, -1.56660587e-01f, -5.77452593e-02f,
  -1.53651893e-01f, 5.59675768e-02f, -7.17549548e-02f, 3.85626443e-02f, -2.44833492e-02f, 8.68354142e-02f, 6.74580187e-02f, -8.00752342e-02f, 1.91087890e-02f, 5.96896969e-02f,
  -4.71372791e-02f, -2.70300508e-02f, 5.97075336e-02f, -4.64087650e-02f, 4.30087782e-02f, 1.77367788e-03f, -6.40798807e-02f, 1.86378360e-02f, -6.82532638e-02f, 2.34285872e-02f,
  -7.33894110e-02f, 3.18683535e-02f, -5.36622219e-02f, -1.63527858e-02f, 1.28825223e-02f, -2.88662389e-02f, -5.95070608e-02f, -9.36836526e-02f, -8.55034217e-02f, -4.95610945e-02f,
  -3.35728824e-02f, 2.31365561e-02f, -3.54394913e-02f, 2.43041050e-02f, 8.72462541e-02f, -1.78547706e-02f, -6.30195364e-02f, -3.02412957e-02f, 5.47200851e-02f, -1.01702809e-02f,
  -3.53867710e-02f, 5.94136938e-02f, 1.02438800e-01f, -9.93958786e-02f, -1.06135644e-02f, 3.46415527e-02f, -6.40797690e-02f, -9.10625979e-02f, -1.08041905e-01f, -3.79587449e-02f,
  -2.90768333e-02f, 1.13753088e-01f, -6.27494277e-03f, 1.10062817e-02f, -1.09991409e-01f, -3.86542790e-02f, -8.81688073e-02f, 2.85420790e-02f, 7.22720427e-03f, 1.15599344e-02f,
  6.27987608e-02f, -3.70864794e-02f, -9.75051522e-02f, 3.03138755e-02f, 1.98986866e-02f, -8.19596946e-02f, 2.33239066e-02f, -6.37928490e-03f, 8.01124703e-03f, 7.05366430e-04f,
  6.24702722e-02f, 4.06537317e-02f, 2.36130692e-02f, 4.17012088e-02f, -3.68038728e-03f, 8.27779099e-02f, -8.68177880e-03f, -2.31280923e-03f, -6.70178682e-02f, -5.19142337e-02f,
  3.20356265e-02f, 1.25976978e-02f, -1.61404461e-02f, -6.32727593e-02f, -7.06808567e-02f, -5.94696067e-02f, -2.15911097e-03f, -9.29771811e-02f, -1.06998548e-01f, -1.64351612e-01f,
  -2.04065606e-01f, -1.74873501e-01f, -1.28803357e-01f, -1.83843195e-01f, 5.55457249e-02f, 1.20594457e-01f, 6.03633039e-02f, -5.16186096e-02f, -8.53596553e-02f, -5.81182539e-02f,
  -1.39085250e-03f, 3.18964981e-02f, -2.21656635e-02f, 1.63323253e-01f, 6.22022003e-02f, 5.10613918e-02f, -4.45922390e-02f, 8.83110613e-02f, 1.53144613e-01f, 1.27628088e-01f,
  7.68539160e-02f, 3.47487070e-02f, -8.09248909e-02f, -5.19191846e-02f, -1.11928932e-01f, -4.21404727e-02f, -1.28961697e-01f, -4.42172475e-02f, -3.97681817e-02f, -9.72392559e-02f,
  -1.48120716e-01f, -1.14873298e-01f, 4.91469204e-02f, 1.90431643e-02f, 5.59367016e-02f, -4.63330434e-05f, -1.58908665e-02f, -6.10420778e-02f, 3.76043618e-02f, -5.20104021e-02f,
  2.61531267e-02f, 8.56292099e-02f, -5.22998944e-02f, -6.36946708e-02f, -6.35403022e-02f, -3.25575471e-02f, -3.78727466e-02f, 1.14069683e-02f, -5.06915972e-02f, 5.41670173e-02f,
  6.52663186e-02f, 4.10114154e-02f, -4.73499708e-02f, -7.68417865e-02f, -1.42437249e-01f, 7.45699480e-02f, -5.19114584e-02f, -1.12571560e-01f, -5.14903292e-02f, -2.66842395e-01f,
  1.11624435e-01f, 1.32472571e-02f, 1.52375055e-02f, 1.84852127e-02f, 5.89005798e-02f, 3.91442403e-02f, -3.73796970e-02f, 1.05410509e-01f, 7.83040375e-02f, -6.84021562e-02f,
  2.75920536e-02f, -3.10707465e-02f, 9.23789665e-02f, 1.61195602e-02f, 5.86755164e-02f, 5.82761168e-02f, 6.90198243e-02f, -4.32120711e-02f, 9.95840058e-02f, 2.16112919e-02f,
  -9.55913961e-03f, -6.82139769e-02f, -1.11424960e-01f, -1.00866593e-02f, -5.29640401e-03f, -5.07414453e-02f, -6.94098175e-02f, -6.25724643e-02f, -1.15758091e-01f, 3.16081829e-02f,
  -1.03037663e-01f, 1.94564179e-01f, -3.91002521e-02f, 6.64586872e-02f, -4.16486859e-02f, 5.87838590e-02f, -9.96149406e-02f, 4.18391936e-02f, -4.62740548e-02f, -6.47094697e-02f,
  -3.66806090e-02f, -6.01990372e-02f, -1.01452909e-01f, 3.80706675e-02f, 7.64776990e-02f, -8.40854719e-02f, -8.09713006e-02f, 2.23418269e-02f, -2.70979526e-03f, -8.97153616e-02f,
  -7.08183870e-02f, -1.15973316e-01f, -3.42495628e-02f, -2.80908123e-02f, -1.18342608e-01f, 7.10025523e-03f, -1.13207117e-01f, -1.96538225e-01f, -1.77492067e-01f, -2.99802631e-01f,
  1.44776091e-01f, 1.02156818e-01f, 1.01260744e-01f, 1.34163871e-01f, -8.24723989e-02f, -6.56526834e-02f, -5.36429025e-02f, 7.08265379e-02f, 4.44220491e-02f, 2.72404421e-02f,
  8.99335742e-03f, 6.10565618e-02f, 1.25338763e-01f, 1.01032853e-01f, 4.45131958e-02f, 8.58423337e-02f, 3.91124934e-02f, 1.41867250e-01f, 1.07689179e-01f, 9.47326142e-03f,
  -5.96167929e-02f, 2.94271205e-02f, 5.93030155e-02f, 6.71501160e-02f, 8.26907679e-02f, -8.69153738e-02f, -8.08286220e-02f, 4.68824282e-02f, 2.87147593e-02f, 1.11678973e-01f,
  -4.82815988e-02f, 1.04975760e-01f, -7.94670954e-02f, -5.71342073e-02f, -5.87042607e-03f, -6.19827844e-02f, -1.17410086e-02f, -2.46553551e-02f, -8.36799368e-02f, -8.00782144e-02f,
  -1.08433440e-01f, 4.30657081e-02f, 2.05452647e-02f, -5.57123423e-02f, 4.63335253e-02f, -6.40667155e-02f, 1.78711936e-02f, 8.25161710e-02f, 1.79046653e-02f, 6.80044293e-02f,
  8.09150003e-03f, 2.89393235e-02f, -6.50539175e-02f, -2.12863693e-03f, 6.59163222e-02f, 2.56939270e-02f, 7.22832454e-04f, 1.76350679e-02f, -1.88047625e-03f, -4.30752188e-02f,
  -7.79693853e-03f, 4.82942350e-03f, -1.74979512e-02f, -5.90443332e-03f, 5.49527295e-02f, -1.35055585e-02f, 1.67809147e-02f, 4.18424904e-02f, 9.20811370e-02f, 6.65862262e-02f,
  -5.93756735e-02f, -4.09901328e-02f, -3.51284444e-02f, 6.70068115e-02f, -6.29694667e-03f, 3.03728506e-02f, -5.05903885e-02f, 7.75903538e-02f, -2.15243381e-02f, -6.07561171e-02f,
  2.70402357e-02f, -3.98793779e-02f, 5.98194189e-02f, -3.51866186e-02f, 1.02527149e-01f, 4.72347215e-02f, -5.29762432e-02f, 4.64894809e-02f, 5.80564374e-03f, -8.33086073e-02f,
  3.33849862e-02f, 1.14822760e-01f, -5.07073812e-02f, 3.19301896e-02f, 5.73950820e-02f, -9.81536880e-02f, -6.13760483e-03f, 9.41839907e-03f, -5.54267224e-03f, -8.86149704e-02f,
  -4.90072556e-03f, 5.24821803e-02f, -3.10126469e-02f, 1.55973537e-02f, -5.88839874e-02f, -1.42357528e-01f, 6.43782085e-03f, -1.96213815e-02f, 9.84887313e-03f, 3.57587822e-02f,
  -2.42478959e-02f, -1.18996911e-01f, 8.42326414e-03f, -7.14163035e-02f, -1.09630138e-01f, 1.56392101e-02f, -6.31264746e-02f, -9.72690135e-02f, -6.19490109e-02f, 4.00049053e-02f,
  -2.48107314e-01f, 3.00791650e-03f, -1.07624044e-03f, -1.50350243e-01f, 4.79329675e-02f, 1.66168481e-01f, 1.87347502e-01f, 8.72807726e-02f, -1.21122748e-01f, 1.30625769e-01f,
  7.08790570e-02f, -1.30816400e-01f, -3.56880501e-02f, 8.86990279e-02f, 5.60789220e-02f, 1.37980059e-01f, 3.14994506e-03f, 3.31476294e-02f, 1.65003147e-02f, -3.59509513e-02f,
  -1.08988006e-02f, -7.99474642e-02f, -1.22596800e-01f, -1.21396028e-01f, -1.21275321e-01f, -1.32134661e-01f, 1.23689324e-03f, 5.70629314e-02f, 9.28081647e-02f, 1.08253732e-01f,
  5.04578762e-02f, 4.78064939e-02f, 6.10335730e-02f, -6.52043127e-06f, 8.60531814e-03f, -2.06808969e-02f, 7.21700583e-03f, -6.52230391e-03f, -7.61260092e-02f, -2.10133623e-02f,
  4.84458879e-02f, 2.07680222e-02f, -7.64242113e-02f, 5.19154705e-02f, -8.20095390e-02f, -6.09307140e-02f, 6.32624105e-02f, 3.64152784e-03f, 1.42768549e-03f, 2.80026533e-02f,
  4.83656935e-02f, 2.86553092e-02f, -6.96612895e-02f, -3.25141102e-02f, 9.22854692e-02f, 4.53882627e-02f, -7.19029531e-02f, -3.44098546e-02f, 8.65224004e-02f, -2.85284147e-02f,
  -2.45108902e-02f, -6.82511833e-04f, -2.24532820e-02f, -4.54773828e-02f, -4.02774885e-02f, -3.59224435e-03f, -6.94106147e-02f, -2.19214074e-02f, -1.73359644e-02f, 4.90859151e-02f,
  1.71752498e-02f, 4.98034880e-02f, -1.04313351e-01f, -8.54214877e-02f, -6.00519329e-02f, -6.64002402e-03f, 3.36529277e-02f, 6.79767877e-02f, 3.21780890e-02f, -6.23314418e-02f,
  -9.07191541e-03f, 6.07089102e-02f, -4.67804559e-02f, 5.58175221e-02f, -3.60355675e-02f, 4.72281734e-03f, -6.68973252e-02f, 3.20141613e-02f, 3.40449549e-02f, -6.67507946e-02f,
  -2.12940380e-01f, 9.44202170e-02f, -7.68398345e-02f, -8.04993287e-02f, 3.45075689e-03f, -1.05327189e-01f, 3.14758122e-02f, 8.16585205e-04f, -3.59495953e-02f, -7.49979243e-02f,
  -1.90770179e-02f, -7.33022094e-02f, 3.14123780e-02f, 6.30198792e-02f, -8.38252530e-02f, 3.54765207e-02f, -6.73995391e-02f, -1.36975482e-01f, -1.19392509e-02f, -5.81833087e-02f,
  8.38536862e-03f, -4.25448231e-02f, -5.50836995e-02f, -1.04113311e-01f, -8.45086649e-02f, -1.64749756e-01f, -3.82374623e-03f, 3.16197611e-02f, -2.07256824e-02f, -8.51359963e-02f,
  -8.18815753e-02f, -1.58218667e-01f, 1.22733846e-01f, -1.03418164e-01f, -1.51130453e-01f, -1.43452371e-02f, -1.36993051e-01f, -2.17765179e-02f, -1.69752970e-01f, -1.61034867e-01f,
  -1.75516009e-01f, -5.71787991e-02f, -4.40794267e-02f, -7.38346428e-02f, 9.49907601e-02f, -5.39842620e-02f, 7.79423341e-02f, 7.70568773e-02f, 9.89002138e-02f, 3.88637893e-02f,
  -1.18470356e-01f, -4.58890945e-02f, 1.28605500e-01f, 2.59779878e-02f, -1.66223839e-01f, -1.75884236e-02f, 4.63401265e-02f, -1.03287145e-01f, -4.93623391e-02f, -1.20512716e-01f,
  2.65236720e-02f, -2.17971355e-01f, 4.84074280e-02f, 4.70293202e-02f, 4.99673150e-02f, -6.47709593e-02f, 6.84310123e-03f, -3.92802805e-02f, -1.08818069e-01f, -2.75045428e-02f,
  -1.31071240e-01f, 8.67874175e-03f, -1.42250992e-02f, -6.10165149e-02f, -1.10200092e-01f, -1.09650068e-01f, 2.98836268e-02f, 1.14086039e-01f, 7.79902786e-02f, -4.64977548e-02f,
  1.55938156e-02f, -1.11508250e-01f, 3.67297381e-02f, -1.84265748e-02f, -2.33412255e-02f, 1.92558654e-02f, 4.82873395e-02f, 1.73623171e-02f, 4.44694199e-02f, 6.62130257e-03f,
  9.15707424e-02f, 7.39110708e-02f, 9.30090249e-02f, -6.76840246e-02f, 9.19436067e-02f, 7.03071505e-02f, 7.36032575e-02f, -4.79722396e-02f, -6.05021045e-02f, 6.91428855e-02f,
  5.38903512e-02f, 3.53873000e-02f, 3.10414210e-02f, -2.53635040e-03f, 8.73982981e-02f, 7.69078033e-04f, -6.40568975e-03f, -4.95881774e-02f, -5.12246005e-02f, 7.01975450e-02f,
  -7.59569034e-02f, 1.06824134e-02f, -5.09093795e-03f, 3.14350128e-02f, -1.62868667e-02f, 2.49786675e-02f, -3.04588433e-02f, 2.17410084e-02f, -8.71659443e-02f, -3.94484699e-02f,
  6.91914978e-03f, 7.24456757e-02f, -2.17793919e-02f, 3.81977037e-02f, 4.06342112e-02f, 6.43038601e-02f, -1.25119850e-01f, 1.93316415e-02f, -7.47488160e-03f, -4.47979756e-02f,
  5.96183771e-03f, -4.90411781e-02f, -4.43598479e-02f, 2.47898381e-02f, -8.94929841e-02f, -2.71249656e-02f, -1.61231346e-02f, 6.41149729e-02f, -2.22862512e-02f, 2.17734892e-02f,
  2.41295304e-02f, 2.55193822e-02f, 2.37016845e-02f, -1.99686475e-02f, -7.20919594e-02f, -3.61017622e-02f, 9.00909454e-02f, -5.04091978e-02f, 2.79846434e-02f, 4.04665135e-02f,
  6.47626072e-02f, 2.64654793e-02f, 7.81648606e-02f, 8.92621726e-02f, -7.14539215e-02f, -1.02032825e-01f, -8.68652388e-03f, -2.18547378e-02f, 3.40941846e-02f, 1.12351375e-02f,
  -1.14010789e-01f, -5.73537685e-02f, 2.72466876e-02f, -5.44974357e-02f, -8.98697041e-03f, 9.58836600e-02f, 2.84988564e-02f, -9.79411416e-03f, -2.73135994e-02f, 5.25936671e-02f,
  -7.24235699e-02f, -5.75084761e-02f, -3.95414606e-03f, -1.93365980e-02f, 9.61192101e-02f, -7.59003982e-02f, -4.12698090e-02f, -2.69087609e-02f, -7.90329129e-02f, 3.94118279e-02f,
  4.17891704e-02f, 4.21710983e-02f, -8.74464214e-02f, -1.02131136e-01f, 4.54048850e-02f, 1.70644447e-02f, -5.09854928e-02f, 1.06500551e-01f, 9.60282423e-03f, 6.67031109e-03f,
  4.71815020e-02f, 4.08502892e-02f, 2.41909232e-02f, -2.10956428e-02f, 9.34885535e-03f, 5.67015521e-02f, -6.05053306e-02f, 2.06260439e-02f, -7.65926838e-02f, 2.43390668e-02f,
  -8.25795680e-02f, -6.67134747e-02f, 6.35626838e-02f, 2.58177109e-02f, -7.30080083e-02f, 4.41461019e-02f, -8.83448645e-02f, -4.34187800e-02f, -1.01857677e-01f, -3.69782490e-03f,
  -5.22909872e-02f, 6.43015429e-02f, 5.48809022e-02f, 5.87788038e-02f, -8.05451274e-02f, -4.51557152e-02f, -1.91705935e-02f, 2.35433672e-02f, -3.35008986e-02f, 1.54564409e-02f,
  -2.44277753e-02f, -1.12304151e-01f, 1.90262869e-02f, 3.30719054e-02f, 1.94213015e-03f, -6.41846582e-02f, 5.34718111e-02f, 1.96685176e-02f, -4.64452468e-02f, -8.62464756e-02f,
  -6.14047684e-02f, 8.28224048e-02f, 7.85179213e-02f, 1.67181031e-04f, -9.91766825e-02f, -2.30856594e-02f, -5.06712645e-02f, 1.13829877e-02f, -3.38167362e-02f, -4.94685397e-02f,
  -4.75858338e-03f, -1.30568862e-01f, -5.33634275e-02f, 8.40670317e-02f, 1.03986137e-01f, 2.02524494e-02f, -2.81198900e-02f, 7.18993694e-02f, 2.03033164e-02f, 4.70274594e-03f,
  -7.97958076e-02f, -2.66500656e-02f, -2.20901389e-02f, -1.86729468e-02f, -2.91796904e-02f, -3.91940586e-03f, -5.57349324e-02f, 7.60021582e-02f, 4.97839078e-02f, 2.53017130e-03f,
  1.03531234e-01f, 8.97225167e-04f, 4.16625477e-02f, 1.86439585e-02f, -6.10253448e-03f, -2.68766358e-02f, 5.20269945e-03f, -4.88860048e-02f, 8.05151686e-02f, 1.56188056e-01f,
  -1.79402918e-01f, 1.14499442e-01f, -5.87731041e-02f, -8.13586861e-02f, -1.39830217e-01f, -4.78010438e-02f, 7.00791106e-02f, -1.07772626e-01f, 2.69349143e-02f, -2.25486755e-02f,
  -4.86890413e-02f, 9.27759707e-03f, 5.28559685e-02f, 4.64628870e-03f, -1.10968780e-02f, -7.02031795e-03f, -2.68833749e-02f, -7.60727972e-02f, -1.83192164e-01f, -8.23403820e-02f,
  -1.28611743e-01f, -4.30522189e-02f, -1.62802786e-02f, -4.55962718e-02f, -1.81025304e-02f, -2.83159819e-02f, 4.87565435e-02f, 8.25216155e-03f, 1.89220663e-02f, -1.00710802e-01f,
  1.64172143e-01f, -1.48145422e-01f, 3.13363969e-02f, -1.44306589e-02f, -3.05172261e-02f, 4.69699949e-02f, 1.19902641e-02f, 1.75768174e-02f, -5.82429953e-02f, 1.41782360e-03f,
  -1.04203939e-01f, -9.12580416e-02f, -4.79487963e-02f, 1.71688087e-02f, -6.67357026e-03f, -5.63522950e-02f, 2.49380339e-02f, -4.83211428e-02f, 6.68741837e-02f, -3.42175215e-02f,
  4.70722094e-02f, -3.64231244e-02f, -9.15267617e-02f, -4.32154275e-02f, 2.00482756e-02f, -4.70825247e-02f, -3.94990146e-02f, -6.18892051e-02f, -7.78591186e-02f, 1.14212930e-01f,
  1.47692244e-02f, -4.02105227e-02f, 1.76016632e-02f, -2.59920862e-02f, 7.77842999e-02f, 1.91491749e-02f, 6.60101920e-02f, -2.79655820e-03f, -2.98816096e-02f, 3.56195658e-03f,
  7.47908428e-02f, 5.22165969e-02f, 2.82441825e-02f, 6.36993051e-02f, 9.95378243e-04f, -8.35713670e-02f, -4.25237417e-02f, 4.40686308e-02f, -3.47203598e-03f, -9.82253924e-02f,
  -5.29211313e-02f, 4.96215671e-02f, -1.27290078e-02f, -1.06210122e-02f, -6.88926950e-02f, -1.26568917e-02f, -7.94731230e-02f, 5.15512843e-03f, 7.25656375e-02f, -5.94622716e-02f,
  1.10346198e-01f, -9.34252441e-02f, 1.20951369e-01f, 4.75119539e-02f, -1.04308212e-02f, 3.09803355e-02f, -6.53638542e-02f, -3.49451602e-02f, -9.28203985e-02f, -2.01090835e-02f,
  3.11184302e-02f, -5.96417226e-02f, -4.18680273e-02f, 8.76367539e-02f, 4.95298952e-02f, -5.81529997e-02f, -1.30746085e-02f, 3.68253626e-02f, -3.58276218e-02f, -3.67783345e-02f,
  -4.64465003e-03f, 4.01890464e-02f, 1.78668424e-02f, -7.66632101e-03f, 6.67322353e-02f, 8.78360569e-02f, 4.36036997e-02f, 8.02230614e-04f, 3.63788009e-02f, 1.69505253e-01f,
  1.16616011e-01f, -1.52312055e-01f, -2.20802650e-02f, 6.28765440e-03f, -5.52856065e-02f, 9.66371968e-03f, 3.42353880e-02f, -6.53648973e-02f, 3.74779813e-02f, 5.66452481e-02f,
  -1.10020779e-01f, 5.20735271e-02f, -4.60124575e-02f, 4.70557027e-02f, 7.25843087e-02f, -3.31024118e-02f, -2.98745036e-02f, 9.74290073e-02f, 1.02223419e-01f, -7.55062327e-03f,
  4.34186757e-02f, -4.59970022e-03f, -5.15214391e-02f, -3.64658050e-02f, -8.52489248e-02f, -4.09319215e-02f, 4.55243699e-02f, 4.06972133e-03f, -8.03205594e-02f, 1.93718877e-02f,
  1.19826086e-01f, -1.28352612e-01f, 1.15533084e-01f, -5.44917546e-02f, -6.25271648e-02f, -1.38076562e-02f, 5.27398884e-02f, 3.66456471e-02f, -8.30055326e-02f, -5.21857291e-02f,
  -1.44178688e-03f, -9.10718367e-02f, -5.80001213e-02f, -7.30500221e-02f, -4.68240166e-03f, -7.46474927e-03f, -2.61978735e-03f, -1.10324085e-01f, -1.41873032e-01f, -1.94923766e-02f,
  -5.53453416e-02f, -2.11197473e-02f, 3.82660329e-02f, -7.49335587e-02f, -9.50078070e-02f, -1.45250997e-02f, -7.78543130e-02f, -1.31349042e-01f, -1.35939687e-01f, 1.42502226e-02f,
  -6.36612475e-02f, -1.06234488e-03f, -3.20462720e-03f, -5.20550907e-02f, 5.56549281e-02f, 1.46579547e-02f, 2.90864315e-02f, 1.39766531e-02f, 4.13603671e-02f, -1.41080497e-02f,
  2.63235699e-02f, 2.49222368e-02f, -2.98979711e-02f, 8.24580863e-02f, 1.50564406e-03f, 5.04096225e-02f, -7.92284589e-03f, -2.08313484e-02f, -1.78009402e-02f, -1.75398253e-02f,
  4.92955819e-02f, 9.40623879e-02f, -3.83067653e-02f, 4.51149344e-02f, -7.68707618e-02f, 6.80568162e-03f, 2.73817703e-02f, 1.01997077e-01f, -2.17764564e-02f, 2.55166423e-02f,
  1.06446862e-01f, 1.74287483e-02f, 1.36736542e-01f, 5.53438626e-02f, 6.29837587e-02f, -4.24035415e-02f, 5.04386835e-02f, -4.16155495e-02f, -6.72528744e-02f, 9.22382250e-03f,
  -5.36336303e-02f, 4.59113419e-02f, -9.31963846e-02f, 1.62035041e-02f, 5.58930859e-02f, 5.76618314e-02f, 5.91341115e-04f, 3.65597643e-02f, -6.75396249e-02f, 1.58632398e-02f,
  -4.16678423e-03f, 1.20412655e-01f, 4.32291664e-02f, 1.41590565e-01f, 5.30917272e-02f, -1.44996261e-02f, 9.42351893e-02f, 7.79055711e-03f, 1.20910913e-01f, 2.04206765e-01f,
  9.32797492e-02f, 1.21240921e-01f, 4.96899243e-03f, 4.54001911e-02f, 2.86164265e-02f, -1.90345924e-02f, -1.38195023e-01f, -6.24560453e-02f, -5.03108278e-02f, 9.93559044e-03f,
  -4.30113710e-02f, 6.15034178e-02f, 6.18195683e-02f, -2.15368699e-02f, -5.73970452e-02f, -7.16010556e-02f, 3.96560729e-02f, -9.83057842e-02f, -8.78705904e-02f, -1.17113799e-01f,
  6.42414093e-02f, -1.14186369e-02f, -3.52415517e-02f, -4.96813320e-02f, 1.82406828e-02f, 7.52440467e-02f, 7.88706839e-02f, -8.94870162e-02f, -7.21846707e-03f, -2.21051276e-02f,
  1.93203501e-02f, 7.93943107e-02f, -4.65808250e-02f, 2.30192915e-02f, 3.56192961e-02f, -6.05944246e-02f, -2.29729395e-02f, 5.43409400e-03f, -5.55810370e-02f, 3.21054040e-03f,
  6.35270178e-02f, -1.57097299e-02f, 1.25094214e-02f, -2.06545796e-02f, -4.13492136e-02f, -2.18985509e-02f, -3.61250266e-02f, -3.80276106e-02f, 2.37618759e-02f, -4.49899323e-02f,
  -7.15739429e-02f, 7.24604949e-02f, -1.10585682e-01f, -4.42852974e-02f, -6.07672445e-02f, 2.08273847e-02f, -7.49496296e-02f, -3.50357145e-02f, -1.23634182e-01f, -6.27105758e-02f,
  -4.02226523e-02f, -1.03688985e-02f, 1.15106236e-02f, -1.32218739e-02f, -3.55871990e-02f, 3.16458158e-02f, -5.84077761e-02f, -6.67933077e-02f, -5.04084714e-02f, 4.20939410e-03f,
  8.31544921e-02f, 8.65518078e-02f, -6.82416335e-02f, 3.60428207e-02f, -5.34154885e-02f, -7.08044395e-02f, 3.91576588e-02f, 4.27302904e-02f, -1.34869022e-02f, 4.01484780e-02f,
  4.36705388e-02f, -1.50809493e-02f, 5.83429746e-02f, 5.02030402e-02f, 5.90190515e-02f, -3.49547565e-02f, -7.64972437e-03f, -8.72262102e-03f, -2.13703397e-03f, -7.01899081e-02f,
  3.44889313e-02f, -1.86523031e-02f, 1.95747474e-03f, -3.47573683e-02f, 3.48558985e-02f, 6.15955964e-02f, -7.77443871e-02f, 3.20349820e-02f, 6.02826364e-02f, -8.53908658e-02f,
  6.08493239e-02f, -3.05582620e-02f, 8.47287923e-02f, 1.32037560e-02f, 6.35743514e-02f, -8.82265344e-02f, 1.99283827e-02f, 8.75937007e-03f, 2.41926294e-02f, -1.34021713e-04f,
  7.29407817e-02f, -5.04076332e-02f, 9.71563458e-02f, -2.11306009e-02f, -9.05833542e-02f, -4.98040058e-02f, 3.14821489e-02f, 2.35436913e-02f, 3.32128294e-02f, 1.40425920e-01f,
  1.42239392e-01f, 5.61261028e-02f, 2.64405638e-01f, 7.21834078e-02f, 6.01565316e-02f, 1.49484560e-01f, 1.25319406e-01f, 1.11422524e-01f, 3.95464823e-02f, 1.92255080e-02f,
  2.43502893e-02f, -1.29459068e-01f, -1.26325220e-01f, -1.10644363e-01f, -5.25508896e-02f, -4.99812327e-02f, 1.39002409e-02f, 4.82582077e-02f, 1.48296162e-01f, -2.37283539e-02f,
  -1.17297396e-01f, 1.04062922e-01f, 1.05382420e-01f, 7.18269646e-02f, -6.41310886e-02f, -1.01981252e-01f, 5.94362617e-02f, 1.32104173e-01f, 6.68290183e-02f, -1.42085269e-01f,
  -3.11099272e-02f, 1.49769962e-01f, -1.29128113e-01f, 3.57593596e-02f, -8.00307188e-03f, -3.46120186e-02f, 9.51032266e-02f, -7.57978037e-02f, -3.95913459e-02f, 6.22812919e-02f,
  9.31631252e-02f, 9.30735692e-02f, -3.81013565e-02f, -7.74406344e-02f, 5.62152788e-02f, 3.18936142e-03f, 3.33007537e-02f, 3.56475171e-03f, -6.37888163e-02f, -1.08652171e-02f,
  -1.06677033e-01f, 2.92670075e-02f, 1.39059260e-01f, 3.58702093e-02f, 9.47942436e-02f, 4.43463027e-02f, 8.79055783e-02f, -4.56617437e-02f, 6.82221055e-02f, -3.98272425e-02f,
  1.16108339e-02f, 4.56357449e-02f, -6.82524368e-02f, 1.46070076e-02f, -6.87579289e-02f, -8.46144110e-02f, 4.84005734e-02f, 7.71780834e-02f, 3.22241709e-02f, 6.13752976e-02f,
  3.06805642e-03f, -5.87481372e-02f, 3.60034779e-02f, -4.01122086e-02f, -1.08399242e-02f, -3.97327542e-02f, -2.51731146e-02f, -7.37079754e-02f, -6.84471652e-02f, 3.63963917e-02f,
  -2.46345419e-02f, -3.77446860e-02f, 8.41963813e-02f, -1.91447921e-02f, -2.38139890e-02f, -4.20480222e-02f, 3.81962247e-02f, 1.44556928e-02f, 1.63864698e-02f, -5.85743189e-02f,
  -4.53851297e-02f, 1.69168413e-01f, -1.79443389e-01f, 3.25250253e-02f, 8.01021457e-02f, 5.68046197e-02f, -8.87780413e-02f, 1.84774548e-02f, 6.29324839e-02f, 1.96742751e-02f,
  9.62660313e-02f, -4.28271182e-02f, 3.16138119e-02f, -2.53861025e-02f, -1.30755901e-02f, 3.09550483e-03f, 2.86335777e-02f, -9.93015692e-02f, -2.26313554e-04f, -5.85323386e-02f,
  -7.67828971e-02f, 7.09867179e-02f, 9.42265615e-03f, 9.05254576e-03f, -4.05641310e-02f, 9.23073292e-02f, 1.42877195e-02f, 5.41038141e-02f, 1.35617509e-01f, -8.51744488e-02f,
  2.60618955e-01f, -1.07013248e-01f, -3.66347313e-01f, 7.66023993e-02f, -4.09013778e-02f, -1.39362752e-01f, -2.81057715e-01f, 5.25650196e-02f, 1.85475066e-01f, -1.98143438e-01f,
  5.43393157e-02f, 2.01654539e-01f, 7.07814172e-02f, -8.50418583e-02f, -7.32885078e-02f, -2.97830343e-01f, -2.58195490e-01f, -1.67024642e-01f, 1.77597329e-02f, 7.82886595e-02f,
  1.22313043e-02f, 1.05971538e-01f, 6.82400689e-02f, 3.80897941e-03f, -5.46029545e-02f, -4.94141988e-02f, -2.16017202e-01f, -7.36949742e-02f, -1.91713750e-01f, -1.33380547e-01f,
  -1.83492750e-01f, 1.08303659e-01f, -5.90611026e-02f, 2.17634328e-02f, -6.35403246e-02f, 6.49242178e-02f, -5.15646078e-02f, 1.70421433e-02f, 1.64689720e-01f, -3.60426307e-02f,
  6.45555332e-02f, 5.17944880e-02f, -3.18173096e-02f, 8.14078078e-02f, 1.61450766e-02f, -3.79395904e-03f, -1.80735104e-02f, 3.19901318e-03f, 1.47284605e-02f, 3.16254445e-03f,
  6.66638315e-02f, -3.08767799e-02f, 6.53087394e-03f, 2.12080572e-02f, 6.53893203e-02f, 7.38910912e-03f, 6.85444623e-02f, 1.57674141e-02f, -4.49184962e-02f, 1.48319423e-01f,
  -6.94774091e-02f, -7.39098638e-02f, -3.16715054e-02f, 1.38760097e-02f, 5.35018407e-02f, 1.22231536e-01f, 2.63153631e-02f, -5.50389811e-02f, 9.56266671e-02f, -1.11287562e-02f,
  5.77510074e-02f, -6.78373128e-02f, 1.06004670e-01f, 2.58558113e-02f, -2.74209771e-02f, -5.38582653e-02f, -4.41060625e-02f, -2.28854194e-02f, 5.43398410e-02f, 8.21816828e-03f,
  4.26653139e-02f, -7.19924122e-02f, 4.51188870e-02f, 1.04358383e-02f, -9.07599255e-02f, 2.85913125e-02f, 4.34421323e-04f, 1.64657906e-02f, -6.55700862e-02f, 2.15582848e-02f,
  9.45093185e-02f, -1.28278106e-01f, -6.22556135e-02f, 2.98907179e-02f, 5.89716770e-02f, 2.96143685e-02f, -3.78492400e-02f, 7.75487795e-02f, 1.03930242e-01f, 2.90836841e-02f,
  -2.39918306e-02f, -2.09399755e-03f, -2.33430322e-02f, 5.78758009e-02f, 7.02541918e-02f, 3.89178246e-02f, -9.57058556e-03f, 1.44991800e-02f, -8.96558613e-02f, 3.73643339e-02f,
  1.06745260e-02f, -2.12953668e-02f, 1.53511062e-01f, 3.80632728e-02f, 1.07811205e-02f, 2.20807991e-03f, 1.82409342e-02f, 8.58258829e-02f, -4.93678041e-02f, 6.30424842e-02f,
  -1.19303830e-01f, -2.18560938e-02f, 8.48867595e-02f, -1.22871757e-01f, -5.67645989e-02f, -6.45801127e-02f, -8.70082080e-02f, 4.28381562e-02f, 5.48836850e-02f, 5.59553802e-02f,
  -5.64342737e-02f, 3.17764543e-02f, 9.79929119e-02f, 9.45375785e-02f, 9.06622708e-02f, -1.98342986e-02f, -2.34692954e-02f, 7.64097199e-02f, 4.52532656e-02f, 9.28982645e-02f,
  6.68105707e-02f, -8.25553164e-02f, -1.05501987e-01f, -3.29963639e-02f, 8.15002471e-02f, 2.87775248e-02f, -5.62350005e-02f, -7.12509602e-02f, 1.29397251e-02f, 1.28624048e-02f,
  1.53871015e-01f, 5.39380200e-02f, 6.85931966e-02f, -5.33968508e-02f, -6.13076948e-02f, -6.59195706e-02f, 4.38301265e-02f, -7.06574619e-02f, -3.47714908e-02f, -2.81076059e-02f,
  6.90821633e-02f, -2.67857369e-02f, -1.68547519e-02f, 1.18069490e-03f, -1.08068481e-01f, -4.04238375e-03f, -3.93695123e-02f, 3.76604833e-02f, 8.73384848e-02f, 1.12167999e-01f,
  -7.14297220e-02f, 2.49561034e-02f, 3.72299217e-02f, 1.44701246e-02f, -3.15887257e-02f, 1.05896875e-01f, -3.11478712e-02f, 7.31168166e-02f, -5.85810607e-03f, -6.47110790e-02f,
  1.29110711e-02f, 8.07017647e-03f, -7.17247231e-03f, 1.81089919e-02f, -2.14528274e-02f, -4.18755189e-02f, 4.13029790e-02f, -2.80755777e-02f, 7.34234974e-03f, -1.30892545e-01f,
  -8.01956207e-02f, 6.92288131e-02f, 4.88275476e-02f, 2.35954602e-03f, 2.63875630e-02f, -9.64619517e-02f, 4.25625257e-02f, -1.67191755e-02f, 2.71957107e-02f, -8.77182931e-02f,
  -3.12543735e-02f, 5.02262590e-03f, 1.29246321e-02f, -7.41526559e-02f, -4.33726236e-03f, 6.42816126e-02f, 8.63816887e-02f, -8.85992199e-02f, 5.73214106e-02f, -8.34375396e-02f,
  2.10390344e-01f, 4.12538201e-02f, 1.04469836e-01f, 1.19200028e-01f, 6.09896854e-02f, 1.94862429e-02f, 4.78423350e-02f, 3.39423567e-02f, 7.71401972e-02f, 6.50625005e-02f,
  4.07000594e-02f, 1.10471353e-01f, 5.28382100e-02f, -3.34264562e-02f, 2.60615163e-02f, 2.40428392e-02f, -7.00914189e-02f, 2.75113564e-02f, -1.42537616e-03f, 1.06949136e-01f,
  9.81058087e-03f, 5.91247715e-03f, 7.28336051e-02f, 1.75311863e-02f, 1.22181371e-01f, 7.81998411e-02f, 2.72452869e-02f, 7.70484358e-02f, 1.83817605e-03f, 7.88233802e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.21128596e-01f, 1.64086014e-01f, 8.06905106e-02f, 8.52397922e-03f, 2.48391122e-01f, 9.73635167e-02f, 1.64123196e-02f, 1.64420709e-01f, -1.68742351e-02f, 1.81268886e-01f,
  1.03680097e-01f, 1.12708993e-01f, 1.12420395e-01f, 2.21113339e-01f, 1.56647265e-01f, -4.17790562e-03f, -3.83528918e-02f, -2.78849248e-02f, 2.07763538e-01f, 3.29145044e-02f,
  4.28125486e-02f, 1.26682714e-01f, -2.85800193e-02f, 1.67923868e-01f, 1.35762662e-01f, 1.41854540e-01f, 8.31726566e-02f, -6.43918943e-03f, 1.26260102e-01f, 7.08133504e-02f,
  1.75741822e-01f, 1.25649199e-01f, 1.35146186e-01f, 4.08342220e-02f, 1.21925056e-01f, -3.23453769e-02f, 1.90627977e-01f, -1.01830373e-02f, -3.15926410e-02f, 1.15852825e-01f,
  3.41731198e-02f, 2.45418206e-01f, 1.06396392e-01f, 4.46469598e-02f, 2.34825060e-01f, 5.21215647e-02f, 7.38565475e-02f, 8.26571062e-02f, 1.37462839e-01f, 9.01330486e-02f,
  1.97019503e-01f, 4.32727160e-03f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.46724619e-02f, 1.37089938e-01f, 2.43040454e-02f, 1.04246184e-01f, -4.28126706e-03f, -1.32881880e-01f, 2.70237178e-01f, 2.58308351e-02f, -8.45449418e-02f, 2.13141248e-01f,
  2.57253408e-01f, 1.56692043e-01f, 1.14133708e-01f, 1.07106669e-02f, -2.39030924e-02f, -7.49409124e-02f, -2.02391133e-01f, 2.70181131e-02f, 5.71821295e-02f, -1.57522663e-01f,
  9.37252641e-02f, 3.57085536e-03f, -1.10462680e-01f, -1.50171846e-01f, 6.86452314e-02f, -1.39384225e-01f, 1.03739247e-01f, -8.88602734e-02f, 1.04505606e-01f, -1.96202155e-02f,
  7.62858167e-02f, -2.34380096e-01f, -1.00274652e-01f, -2.35271469e-01f, 3.91114391e-02f, -1.41081139e-01f, -1.44462541e-01f, -1.75384432e-02f, -2.40117460e-02f, 7.58707747e-02f,
  1.65470153e-01f, 1.24809425e-02f, 1.14900991e-01f, -2.48069406e-01f, 1.87644929e-01f, -1.07532464e-01f, 1.80607691e-01f, -1.41036466e-01f, 1.62607953e-01f, -5.93658760e-02f,
  -1.37123540e-01f, -2.81492132e-03f, -1.79179519e-01f, 4.83231023e-02f, 8.29790160e-02f, 6.55812323e-02f, 4.11486737e-02f, -9.27972570e-02f, 1.01996638e-01f, -1.90750599e-01f,
  8.22860226e-02f, -3.17562255e-03f, -5.60767651e-02f, -1.35014236e-01f, -8.81804898e-02f, 1.20381825e-01f, 1.28320098e-01f, 7.35618994e-02f, -5.28281778e-02f, -4.07051183e-02f,
  -2.02344373e-01f, 2.36405373e-01f, 1.77265853e-01f, -6.63732886e-02f, 8.85774270e-02f, -9.71966758e-02f, -1.02859654e-01f, 9.82463360e-02f, -6.67471364e-02f, -1.73698850e-02f,
  -1.39717460e-01f, 4.49679064e-04f, -4.95946668e-02f, 7.07697496e-02f, 1.99622232e-02f, -7.54514523e-03f, 6.01108931e-02f, -8.80159438e-02f, 1.53276742e-01f, 1.11617282e-01f,
  1.50998414e-01f, 4.51480933e-02f, -7.57017508e-02f, 1.40005320e-01f, -4.38529104e-02f, -3.85650434e-02f, -7.73152038e-02f, 1.04041025e-01f, -1.12711072e-01f, -6.91957399e-02f,
  1.77418321e-01f, -1.67325422e-01f, -2.16605172e-01f, 7.11029246e-02f, 8.03286657e-02f, 1.17178544e-01f, -1.72601640e-01f, -1.30343482e-01f, 1.17299855e-01f, -1.55955702e-02f,
  1.71845444e-02f, 4.46238276e-03f, 2.14947239e-02f, 6.09110706e-02f, 1.37199596e-01f, -9.71714482e-02f, -1.37246415e-01f, 1.68068465e-02f, -5.17625064e-02f, 9.74969193e-02f,
  -1.35866962e-02f, -6.03927225e-02f, 4.91185151e-02f, 1.76996425e-01f, -2.29702350e-02f, 7.65476823e-02f, -5.51650040e-02f, 1.30117804e-01f, 1.24233164e-01f, 1.50500223e-01f,
  2.04836037e-02f, -1.04284659e-01f, 1.58235073e-01f, 1.18897781e-01f, -2.85942871e-02f, 1.64547324e-01f, 2.03219671e-02f, 2.69270837e-02f, 1.60534963e-01f, 1.89277202e-01f,
  1.14789374e-01f, -1.26059756e-01f, 9.27234739e-02f, 1.14163337e-02f, -8.85818973e-02f, 4.28077318e-02f, 6.92624971e-02f, 4.38249335e-02f, 3.75145264e-02f, 3.80862020e-02f,
  4.00985777e-02f, -1.22287340e-01f, 1.59086213e-01f, 1.75855458e-01f, 1.26875594e-01f, -6.98625147e-02f, -6.48219213e-02f, -1.07628591e-02f, -1.40387788e-01f, -1.32315844e-01f,
  -1.32844104e-02f, -7.20985755e-02f, 2.42596641e-02f, -1.36926934e-01f, 4.28501610e-03f, 1.51563808e-01f, -1.21299602e-01f, -2.46942937e-02f, 2.49906853e-01f, -3.29951718e-02f,
  4.19768766e-02f, 1.25694618e-01f, 2.01983839e-01f, 2.70988464e-01f, 1.18223086e-01f, 2.15634480e-01f, 9.85817388e-02f, 1.48261681e-01f, 6.59883395e-02f, -1.05432346e-01f,
  -1.60276994e-01f, -5.76074384e-02f, 1.76184967e-01f, 2.19468605e-02f, -7.08620474e-02f, -7.30104148e-02f, -1.16714146e-02f, 1.66751314e-02f, 2.33050473e-02f, 1.54700622e-01f,
  -3.03383797e-01f, -1.19820893e-01f, 4.68419343e-02f, 5.90226315e-02f, 1.71412416e-02f, -7.16720074e-02f, 1.11792535e-01f, 2.60191015e-03f, -2.60891058e-02f, -2.17897147e-01f,
  -4.69312854e-02f, -9.55041219e-03f, 3.57449017e-02f, -7.81855639e-03f, 1.06631294e-01f, -7.17626959e-02f, -1.79153197e-02f, 9.33660343e-02f, -6.21060282e-02f, 3.37803178e-02f,
  1.10683702e-01f, 2.13822171e-01f, 6.62553683e-02f, 7.42792785e-02f, -5.17723858e-02f, -9.10552219e-02f, -1.05227558e-02f, -9.77583826e-02f, -1.09462701e-01f, 2.80352496e-02f,
  8.57198536e-02f, 6.64411187e-02f, -1.18705504e-01f, 9.04355496e-02f, -7.18812048e-02f, 1.17698312e-01f, 5.31113520e-02f, -1.32221347e-02f, 1.10660926e-01f, 3.28570828e-02f,
  1.53449122e-02f, 2.08290741e-01f, -5.90207465e-02f, -2.53427569e-02f, 4.09284271e-02f, -1.93045419e-02f, 6.67878464e-02f, -4.13663015e-02f, -1.20330364e-01f, 7.48803988e-02f,
  1.36943683e-01f, 9.66946110e-02f, -1.33177057e-01f, 8.16527903e-02f, 8.94807503e-02f, 3.35949734e-02f, -1.41419828e-01f, -2.62769982e-02f, -7.55815133e-02f, 1.32692069e-01f,
  -4.85993326e-02f, 1.21128224e-01f, 1.01248629e-01f, 4.82390560e-02f, 1.20263286e-01f, 2.02839032e-01f, 1.41786903e-01f, -1.02707490e-01f, 2.44274251e-02f, 1.20738141e-01f,
  5.37395850e-02f, -1.39129966e-01f, 3.99609238e-01f, -7.01812133e-02f, -3.42694223e-02f, 2.09394753e-01f, 2.17714146e-01f, 1.20640248e-01f, -8.40470940e-02f, 3.32940854e-02f,
  -1.18857048e-01f, -1.16659828e-01f, -1.25938937e-01f, -1.15170114e-01f, 5.83065040e-02f, -1.00676455e-01f, 6.87416177e-03f, -1.71512082e-01f, 2.65718102e-02f, -1.58829525e-01f,
  2.72683233e-01f, -1.62256822e-01f, -6.23231418e-02f, -8.89519006e-02f, -9.89231244e-02f, -5.70564643e-02f, -6.38897642e-02f, -2.13131651e-01f, -1.09512940e-01f, -1.31805703e-01f,
  7.91713446e-02f, 3.31474133e-02f, -1.03820667e-01f, 6.30244762e-02f, 4.47694473e-02f, -1.89926952e-01f, 1.02335438e-01f, -3.02861333e-02f, 5.33250570e-02f, -1.67129874e-01f,
  2.53081858e-01f, -2.43671034e-02f, 2.53634602e-01f, 5.61231785e-02f, -8.62972662e-02f, -2.32532620e-02f, -1.16713420e-01f, -1.54237285e-01f, -4.82731797e-02f, -2.61826515e-02f,
  5.71524315e-02f, 1.01588920e-01f, -1.61001429e-01f, 3.78606059e-02f, -3.02021634e-02f, -6.97200522e-02f, -2.09653638e-02f, -7.61399269e-02f, -7.05114231e-02f, -1.88705325e-01f,
  8.60288665e-02f, 8.11751117e-04f, -1.00020036e-01f, -1.00446910e-01f, 1.08445793e-01f, 1.20628793e-02f, 7.27126375e-02f, 3.99258494e-01f, 1.65599942e-01f, 9.62153599e-02f,
  7.15737045e-02f, -5.66079319e-02f, 3.26299407e-02f, -1.46367848e-01f, -7.88107701e-03f, -1.46443471e-01f, -3.37490775e-02f, 5.70473447e-02f, -7.15274438e-02f, -1.48729250e-01f,
  4.06907909e-02f, 1.99830662e-02f, -6.35791123e-02f, 4.86236177e-02f, 1.33209219e-02f, 2.16158405e-01f, 1.74042597e-01f, -2.43866637e-01f, 2.54739728e-02f, 4.54164967e-02f,
  7.65815601e-02f, -2.26883635e-01f, 2.45452989e-02f, -1.78431541e-01f, 1.37245864e-01f, -1.80615678e-01f, 1.05342150e-01f, -1.70781851e-01f, 1.08615123e-01f, -1.28587866e-02f,
  1.65276349e-01f, 2.10104764e-01f, 1.22702077e-01f, 5.60972914e-02f, 3.67766581e-02f, 1.33728325e-01f, 1.24639928e-01f, -1.17758289e-01f, -1.67498663e-02f, 6.58246204e-02f,
  -1.05576873e-01f, -1.08506769e-01f, -1.58739954e-01f, 2.00982615e-01f, -4.29678559e-02f, 1.22207932e-01f, -2.37729177e-02f, 3.39369439e-02f, 1.19000524e-02f, -9.98110548e-02f,
  -5.73194660e-02f, -7.98377395e-03f, -2.56551862e-01f, 1.23042569e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.96790919e-01f, 2.23207086e-01f, -1.98460054e-02f, 1.46853581e-01f, -3.02580018e-02f, 1.16877146e-01f, -1.14185877e-01f, 1.76471829e-01f, -4.35852185e-02f, -1.14505745e-01f,
  -3.24773788e-01f, -5.92801511e-01f, 6.32582232e-02f, 4.67801392e-01f, 2.95043811e-02f, -1.39796138e-01f, 2.32894465e-01f, 1.85223103e-01f, -2.59046331e-02f, 3.48932952e-01f,
  1.77790150e-01f, 1.38944477e-01f, 1.94209918e-01f, -4.71810289e-02f, -1.73602924e-01f, 2.95355678e-01f, -1.24373980e-01f, 1.03691623e-01f, 1.48924172e-01f, 5.14002927e-02f,
  1.81323126e-01f, 2.83362538e-01f, 5.71344569e-02f, 1.98104307e-01f, 9.72993523e-02f, -1.33020520e-01f, 2.73481701e-02f, -4.88032512e-02f, 1.48550598e-02f, -1.53721035e-01f,
  3.12026978e-01f, 1.87177762e-01f, 1.57957166e-01f, 2.01137900e-01f, -6.55027926e-02f, 3.40526074e-01f, -2.32090935e-01f, 1.31362587e-01f, 3.61949615e-02f, 3.98457646e-02f,
  1.71108887e-01f, 4.53460775e-02f, 1.51062995e-01f, 1.59519330e-01f, 9.69421770e-03f, -9.81752127e-02f, 9.78298783e-02f, -4.45930101e-02f, 4.55572978e-02f, 2.00771973e-01f,
  5.75314984e-02f, 5.88681772e-02f, 3.01892966e-01f, -8.64731818e-02f, 3.52888614e-01f, -6.34494647e-02f, 2.09838882e-01f, 2.15000704e-01f, 1.27220407e-01f, 1.27614975e-01f,
  2.92677879e-02f, -2.81647801e-01f, -7.30036125e-02f, -8.40627179e-02f, -2.35271439e-01f, 2.42013391e-02f, 1.63076207e-01f, 1.18251272e-01f, 7.80276880e-02f, -3.76133062e-02f,
  1.30752057e-01f, -5.07356487e-02f, -2.24422347e-02f, -5.14296144e-02f, -9.74530727e-03f, -5.60984202e-02f, 9.43109989e-02f, 8.05007368e-02f, 7.94059038e-02f, -1.12419702e-01f,
  -3.95840779e-02f, 1.23272039e-01f, 1.46345586e-01f, 1.19919457e-01f, 1.37667224e-01f, 2.75332063e-01f, -1.02923632e-01f, -4.16176654e-02f, -5.99575900e-02f, 2.81213969e-01f,
  -2.46315897e-01f, 1.86512545e-01f, 1.22152165e-01f, -2.55067721e-02f, -1.47427604e-01f, -1.01434924e-01f, 1.47910997e-01f, -7.52592552e-03f, -1.32510468e-01f, -1.04599893e-01f,
  -1.16195433e-01f, 3.64489034e-02f, -3.68562229e-02f, -8.02318007e-02f, 1.08204298e-01f, 1.30245969e-01f, 3.19695592e-01f, 3.29831809e-01f, 6.95937127e-02f, -3.10180709e-03f,
  6.37830794e-02f, -1.26335964e-01f, -5.70903793e-02f, -1.28866538e-01f, -7.18169585e-02f, 6.73332959e-02f, 2.43718326e-01f, -5.02198227e-02f, 2.24984530e-02f, 2.28042543e-01f,
  9.05979723e-02f, 4.73464781e-04f, 2.16852143e-01f, -5.19718565e-02f, -1.28527649e-03f, -9.65114608e-02f, 9.08152014e-02f, -2.32767668e-02f, -7.90965110e-02f, -2.94195622e-01f,
  1.12812921e-01f, 8.31932351e-02f, 1.07373409e-01f, -8.99333134e-02f, 6.08203970e-02f, 9.53604206e-02f, 2.18525797e-01f, 5.50081991e-02f, 1.80670053e-01f, 4.08108113e-03f,
  7.32659101e-02f, 1.42067308e-02f, -7.77386203e-02f, 1.13228060e-01f, 1.17256224e-01f, 2.36520097e-01f, 1.69038460e-01f, -5.16898371e-02f, 7.83382803e-02f, -1.86139643e-02f,
  -4.58904728e-02f, 1.22408204e-01f, -1.18614724e-02f, 8.85308087e-02f, 9.77760851e-02f, 6.28437549e-02f, -9.98977348e-02f, -1.36565417e-02f, 2.36116081e-01f, 1.68819427e-01f,
  5.09204641e-02f, -2.58905664e-02f, -9.04116780e-02f, 3.95830907e-02f, 1.31796181e-01f, -8.73320922e-02f, 1.40731230e-01f, 1.35738820e-01f, -5.02138287e-02f, -1.14380486e-01f,
  -5.83023503e-02f, -1.53620243e-01f, 1.00957341e-01f, -1.49887383e-01f, 1.15712211e-02f, 1.64527923e-01f, 1.19021624e-01f, 5.92125058e-02f, 7.05931112e-02f, -6.82030246e-02f,
  2.31133893e-01f, -1.01724461e-01f, 1.09433517e-01f, -9.62952618e-03f, 6.89854920e-02f, 1.95871502e-01f, -9.97359604e-02f, 1.28013253e-01f, -2.05188543e-02f, -2.14804113e-01f,
  2.98610167e-03f, -3.66543867e-02f, -1.00105748e-01f, 3.11586224e-02f, 9.27751288e-02f, -1.83417276e-02f, 9.19379592e-02f, 2.31485870e-02f, 1.86834019e-02f, -8.82415622e-02f,
  -6.74505681e-02f, 3.51937860e-02f, 5.35075553e-03f, -5.95179126e-02f, 1.46476284e-01f, 1.12290323e-01f, 1.16577692e-01f, -5.47020584e-02f, -3.87273878e-02f, -7.19386041e-02f,
  8.17451254e-02f, -6.41414374e-02f, 9.56224129e-02f, 1.45652473e-01f, -1.25037983e-01f, -1.17177166e-01f, -9.46196243e-02f, 1.96599171e-01f, -1.81371525e-01f, 5.70007637e-02f,
  2.31503591e-01f, 1.22296222e-01f, 6.55350089e-02f, 6.53522462e-02f, 1.40868619e-01f, 3.54864215e-03f, 8.59442353e-02f, 1.37897983e-01f, -1.61630549e-02f, 1.29101068e-01f,
  1.44976094e-01f, -8.02865177e-02f, -3.04758772e-02f, 2.50982821e-01f, 1.15176506e-01f, 2.62181163e-01f, 5.46087027e-02f, -4.20373827e-02f, -7.59262890e-02f, -1.09442234e-01f,
  -4.96587195e-02f, -1.52941078e-01f, -9.28446352e-02f, -5.90014942e-02f, 3.07061315e-01f, 1.00487858e-01f, 1.47709370e-01f, 1.03145771e-01f, 1.69324189e-01f, 1.37488037e-01f,
  8.86671618e-02f, 1.22307599e-01f, 2.66711116e-01f, -7.56891519e-02f, -1.66858390e-01f, 9.00897086e-02f, 1.29072994e-01f, 4.64782938e-02f, 8.73097181e-02f, 1.05118845e-02f,
  -7.07304999e-02f, 8.98637697e-02f, -3.05679385e-02f, -1.06879838e-01f, 1.01301419e-02f, -1.51221499e-01f, -7.48022869e-02f, 7.63364881e-02f, -1.44104548e-02f, -9.34243649e-02f,
  4.21111852e-01f, -1.64666548e-01f, 1.33570045e-01f, -7.25201666e-02f, 3.47601809e-02f, 7.54167885e-02f, -6.08137660e-02f, 5.24421746e-04f, -1.06369458e-01f, -8.33230466e-02f,
  -1.67347938e-02f, -2.30524801e-02f, -1.47384122e-01f, 9.28035229e-02f, 3.60446349e-02f, 1.19106583e-01f, 1.66960478e-01f, 6.35784939e-02f, 1.99910672e-03f, -1.64714053e-01f,
  2.35731378e-01f, 4.37035859e-02f, 1.68640554e-01f, -1.49543405e-01f, 1.66573167e-01f, -4.32761461e-02f, -1.10603683e-01f, 1.91005357e-02f, 5.05335489e-03f, 1.37284353e-01f,
  -1.83307566e-02f, 2.13990167e-01f, -1.26909047e-01f, 7.64460042e-02f, -1.12606943e-01f, -1.10763296e-01f, 1.29789516e-01f, -8.11816379e-03f, 2.87126508e-02f, -4.73653041e-02f,
  9.13506150e-02f, 1.69165447e-01f, 5.35893366e-02f, 1.34067442e-02f, 1.55120537e-01f, 1.07382342e-01f, 3.16442586e-02f, -1.38960034e-01f, -7.38600940e-02f, 6.06315136e-02f,
  3.97103839e-02f, -1.94803867e-02f, -5.53667322e-02f, 8.81180912e-02f, -1.15898937e-01f, 9.45102498e-02f, 4.93030995e-02f, -8.91721547e-02f, 1.13930047e-01f, 1.10835299e-01f,
  6.27312213e-02f, 1.52524829e-01f, 1.01880506e-01f, 8.74540880e-02f, -1.33197799e-01f, -7.55009353e-02f, 9.22828168e-02f, 1.94198862e-01f, -8.71095061e-02f, -4.69772257e-02f,
  3.44873890e-02f, 4.64784466e-02f, -1.34320423e-01f, -1.00750081e-01f, 9.35200974e-02f, 1.47549570e-01f, 3.60047072e-02f, 6.10333905e-02f, -2.02194210e-02f, 1.65547073e-01f,
  -1.17265396e-01f, 4.42983843e-02f, -4.99866828e-02f, 1.14585310e-01f, -1.28489390e-01f, -1.69829535e-03f, 9.42085087e-02f, -9.33401883e-02f, -2.30501872e-02f, 8.90088305e-02f,
  -1.00769557e-01f, -8.93276483e-02f, -1.05142683e-01f, -1.17133826e-01f, 2.42906902e-02f, -8.49727094e-02f, 1.57651439e-01f, 1.07391551e-01f, 3.99249420e-02f, 2.78280582e-02f,
  -4.65874001e-02f, 5.13596535e-02f, 9.86760855e-02f, -4.05212119e-02f, -1.52187445e-03f, 4.16929051e-02f, 1.87738314e-01f, 2.20780253e-01f, 5.61092887e-03f, 3.84176672e-02f,
  5.95117100e-02f, -4.20246065e-01f, 3.15656289e-02f, 6.11009300e-02f, 2.77827475e-02f, 1.16682395e-01f, 9.45401862e-02f, 1.01122580e-01f, -3.31335738e-02f, 1.45627990e-01f,
  1.97713479e-01f, -1.30809486e-01f, 1.91619620e-02f, 6.38693795e-02f, 1.06365621e-01f, 1.37152243e-02f, 1.76213309e-01f, 1.57974456e-02f, 2.15561494e-01f, -1.73861876e-01f,
  7.09135085e-02f, 2.57850081e-01f, -3.55255529e-02f, 2.11651735e-02f, -1.14050694e-03f, -1.62254628e-02f, -7.75039429e-03f, 1.18307434e-01f, -2.01733541e-02f, 1.03851072e-02f,
  -3.13068070e-02f, 3.99991125e-02f, -1.32895246e-01f, -3.04271132e-02f, 1.30738392e-01f, -2.60204002e-02f, -1.15648014e-02f, 3.76997292e-02f, 2.40399182e-01f, -8.74428600e-02f,
  -1.56285167e-02f, -9.20008421e-02f, 1.72795534e-01f, 9.70947444e-02f, -3.36961672e-02f, -9.62394550e-02f, 1.88039616e-01f, -1.75951183e-01f, -2.69191135e-02f, -1.97531044e-01f,
  -1.15161240e-01f, 8.60688388e-02f, 3.79675403e-02f, 1.43491820e-01f, 9.19041038e-02f, -1.86525106e-01f, 2.27771148e-01f, 2.28276420e-02f, 7.12918341e-02f, 4.61762734e-02f,
  9.52135175e-02f, 1.83497444e-01f, 6.01115115e-02f, 1.05860360e-01f, 1.97631314e-01f, 2.41829321e-01f, -5.72156336e-04f, -1.09538272e-01f, 7.06509082e-03f, -1.68457866e-01f,
  1.12150274e-01f, 6.45965561e-02f, 1.66744888e-02f, -5.39506674e-02f, -7.57384524e-02f, 5.81718460e-02f, 3.02718906e-03f, 2.41849925e-02f, 1.81254465e-02f, 1.07989395e-02f,
  3.73564921e-02f, -6.31475523e-02f, 2.73815006e-01f, 2.28739083e-01f, -1.00308256e-02f, 1.19583994e-01f, 1.41716316e-01f, 7.95220435e-02f, 6.96330070e-02f, 8.92515853e-02f,
  4.32213806e-02f, -6.08427078e-02f, 1.30531907e-01f, -1.71933353e-01f, -3.33450399e-02f, 3.02453768e-02f, -2.06501456e-04f, -4.03762683e-02f, 3.21469307e-01f, 1.08454354e-01f,
  2.07754746e-02f, -9.84731540e-02f, -2.61999480e-02f, 3.21174227e-02f, -4.64002788e-02f, -2.12187991e-02f, 3.95054147e-02f, 1.05069943e-01f, 9.98952687e-02f, -5.62863424e-02f,
  2.50848643e-02f, 1.03820734e-01f, 1.14703506e-01f, 5.66517711e-02f, -6.66673258e-02f, 6.46469966e-02f, -1.28129467e-01f, 1.32156849e-01f, -4.94297631e-02f, 1.08713984e-01f,
  7.75150070e-03f, -1.03861377e-01f, -1.18448436e-01f, -5.57628162e-02f, 2.59403605e-02f, 1.23125106e-01f, -7.16827530e-03f, 2.07938254e-02f, -5.77598764e-03f, 3.93188819e-02f,
  8.67027789e-02f, 7.20502734e-02f, 1.13353074e-01f, 7.67982677e-02f, 4.88819480e-02f, 1.49514265e-02f, 3.21889259e-02f, -1.09330202e-02f, 4.86941300e-02f, 1.23359367e-01f,
  -6.71211332e-02f, 1.65615916e-01f, -7.47061074e-02f, 2.96255313e-02f, 1.66184455e-02f, 3.32012288e-02f, 5.79898730e-02f, 8.05084184e-02f, -8.44163075e-02f, -7.85111487e-02f,
  -4.06807475e-02f, -6.72448426e-02f, -4.14346233e-02f, -1.14777841e-01f, 4.84471805e-02f, 7.31354058e-02f, -1.17649972e-01f, -9.73969623e-02f, -1.09063976e-01f, 1.11124493e-01f,
  -4.75869589e-02f, -5.37132695e-02f, -1.05456688e-01f, 3.13746929e-02f, 1.04087129e-01f, 7.53004476e-02f, -1.19125731e-01f, 1.36530414e-01f, -4.52044308e-02f, 4.50197374e-03f,
  -5.45438044e-02f, -3.47595736e-02f, 1.26657873e-01f, -1.11950338e-01f, 7.68357217e-02f, 2.43371893e-02f, 5.39283678e-02f, 1.10691458e-01f, 9.85000134e-02f, -1.70122515e-02f,
  4.63357903e-02f, -2.68877503e-02f, -1.16686426e-01f, -3.27757647e-04f, 9.51033160e-02f, 5.97125441e-02f, 1.54399527e-02f, 7.81873837e-02f, 3.55663784e-02f, 1.15705505e-01f,
  -3.04488856e-02f, -8.64153132e-02f, 1.48883656e-01f, 2.40836039e-01f, 6.58130124e-02f, 5.65925576e-02f, -7.08580613e-02f, -1.80799276e-01f, -1.18590958e-01f, 7.04442039e-02f,
  -1.74318976e-03f, 1.01595186e-01f, -9.71693546e-02f, 4.22308221e-02f, 7.01546595e-02f, 9.97816846e-02f, -1.14749178e-01f, -3.54561135e-02f, -5.37342317e-02f, 7.66759887e-02f,
  1.04514413e-01f, 2.27756783e-01f, 6.06940351e-02f, -7.44119287e-02f, -5.85846119e-02f, 7.07010552e-02f, 1.45826004e-02f, -6.32449090e-02f, -4.37466353e-02f, -8.12503994e-02f,
  -2.17470974e-02f, -8.94319043e-02f, 3.58331390e-02f, 3.89732495e-02f, -4.03154902e-02f, -2.01698765e-03f, 2.63487339e-01f, 2.30938382e-02f, 1.34512842e-01f, -5.86802401e-02f,
  -7.34032243e-02f, 1.36030495e-01f, 1.45249397e-01f, -1.07969277e-01f, -8.07891190e-02f, -5.92163280e-02f, -9.41345915e-02f, -5.34711145e-02f, 4.78430185e-03f, -6.91226646e-02f,
  -1.13513090e-01f, 1.56150356e-01f, 8.52243826e-02f, 3.88724543e-02f, 1.60255581e-02f, 3.96484919e-02f, -2.48769186e-02f, 1.11882314e-01f, 2.65532080e-03f, -1.34800732e-01f,
  1.30610019e-01f, 6.41278774e-02f, 1.23950854e-01f, 1.77687835e-02f, 2.85470835e-03f, -5.61006973e-03f, -1.66563600e-01f, -1.37927592e-01f, 6.76409230e-02f, 1.45050008e-02f,
  1.38882622e-01f, 1.64217636e-01f, 1.58509582e-01f, 1.95901524e-02f, -1.49546042e-02f, 7.05429614e-02f, 2.23219752e-01f, 3.98031957e-02f, 6.69944510e-02f, -4.26197723e-02f,
  -1.04354464e-01f, -4.54037972e-02f, -1.43947452e-01f, 1.12191603e-01f, -3.69993150e-02f, -8.75527561e-02f, 2.18785882e-01f, -7.57063255e-02f, -2.65393704e-02f, -7.82574266e-02f,
  4.77388948e-02f, 2.83988938e-02f, -1.40917853e-01f, -9.59331542e-02f, 2.54579615e-02f, 1.33270949e-01f, 1.38333857e-01f, -1.06180422e-01f, 1.49764404e-01f, 1.83963940e-01f,
  8.37402418e-02f, -7.46216476e-02f, 8.11596140e-02f, -2.35164873e-02f, -6.39334694e-02f, 9.31805000e-02f, 1.15944594e-01f, -1.00819252e-01f, 9.71811786e-02f, 9.44584757e-02f,
  -4.49188985e-02f, -7.93661326e-02f, 7.34416470e-02f, 2.36469954e-01f, -1.15295604e-01f, 1.03554077e-01f, 4.44470719e-03f, 7.61979744e-02f, 4.08983938e-02f, 3.96736600e-02f,
  -9.44892243e-02f, -8.02947134e-02f, 1.40556112e-01f, -3.01044919e-02f, -2.34748200e-02f, 1.70783892e-01f, 1.84774488e-01f, -7.85360206e-03f, -4.06655185e-02f, 1.20010115e-01f,
  -1.72948942e-01f, 1.98263019e-01f, 5.03077991e-02f, 1.11129517e-02f, 1.27614915e-01f, -5.02285920e-02f, 1.44742295e-01f, -1.98311396e-02f, 1.86388493e-02f, -8.44382569e-02f,
  1.44379497e-01f, -3.02518681e-02f, -6.21792339e-02f, -2.37288084e-02f, -5.41127250e-02f, -4.38119806e-02f, -6.43484965e-02f, -1.09354846e-01f, 1.13952644e-01f, -8.90970454e-02f,
  8.39439854e-02f, 4.60333452e-02f, 8.18074569e-02f, 2.88197324e-02f, -3.81104238e-02f, 1.69299647e-01f, 5.95102608e-02f, 1.54445261e-01f, -6.54783621e-02f, 5.51376306e-02f,
  -2.36596130e-02f, -1.30039483e-01f, 1.01689786e-01f, -5.32467440e-02f, 1.84769407e-01f, 7.58440718e-02f, -2.84528546e-03f, 4.12935503e-02f, -1.14825163e-02f, 6.00617863e-02f,
  -1.18873455e-01f, 8.76885727e-02f, 4.25729789e-02f, 1.51524603e-01f, 8.24689791e-02f, -6.14815345e-03f, -7.11417645e-02f, 6.48839101e-02f, -3.36756483e-02f, 1.13491798e-02f,
  4.46109846e-02f, 3.02538294e-02f, 1.43260270e-01f, -5.45175895e-02f, -1.50372565e-01f, -1.11897543e-01f, 6.47477657e-02f, 1.40463993e-01f, 1.94421764e-02f, -4.11874242e-02f,
  8.83730054e-02f, -3.01742274e-02f, -1.06179602e-01f, -6.95142476e-03f, 2.85513103e-02f, 1.19634837e-01f, -5.73680969e-03f, 1.13785729e-01f, 7.26288781e-02f, -4.67272960e-02f,
  -7.27558285e-02f, -9.29548293e-02f, 3.21068801e-02f, -1.22110434e-01f, 1.27285779e-01f, -1.90826058e-02f, -8.76769349e-02f, 1.52212596e-02f, 4.09978405e-02f, -1.10871002e-01f,
  1.21477142e-01f, 1.29607422e-02f, 1.18334331e-01f, -9.81451944e-02f, 5.02509177e-02f, -5.69214337e-02f, 4.30814326e-02f, -1.18714064e-01f, -7.35083083e-03f, 1.08601097e-02f,
  4.28077914e-02f, -9.01718810e-03f, 8.86434093e-02f, 7.63956234e-02f, -3.50790583e-02f, -1.06684707e-01f, -9.79645103e-02f, 9.52951014e-02f, 2.10382659e-02f, -3.03150471e-02f,
  -1.77709777e-02f, -1.03282712e-01f, -1.16264142e-01f, -1.23397693e-01f, 1.50498590e-02f, -6.97483718e-02f, -8.60442668e-02f, -1.91693418e-02f, 1.21256344e-01f, 7.13008866e-02f,
  1.21344842e-01f, 7.59687945e-02f, -2.21494008e-02f, 1.20712429e-01f, -2.39837617e-02f, 9.57996026e-03f, -1.05142966e-01f, -2.49703899e-02f, -2.03402638e-02f, 1.10438593e-01f,
  -2.57179346e-02f, 5.48157515e-03f, -6.11133166e-02f, -1.76316202e-01f, -1.09464042e-01f, 1.44704372e-01f, 1.78791545e-02f, 7.11447224e-02f, 1.50293037e-01f, -7.46541619e-02f,
  3.83909494e-02f, 8.79714638e-02f, -4.58131321e-02f, 3.28349397e-02f, 2.60637719e-02f, -2.85224244e-02f, 3.88993062e-02f, 1.63694218e-01f, -6.71037585e-02f, -2.66973325e-03f,
  4.42116745e-02f, 1.28939345e-01f, 2.14030519e-02f, 1.05612129e-01f, -9.04565603e-02f, 1.13444619e-01f, 6.66574389e-02f, 1.46074414e-01f, -5.31445444e-02f, 1.39624372e-01f,
  -1.86723247e-02f, -8.07379037e-02f, 1.54927880e-01f, 7.20626265e-02f, -1.38844654e-01f, -1.43288940e-01f, -6.64415210e-02f, 1.13637596e-01f, 7.47311711e-02f, -3.37284394e-02f,
  1.72365740e-01f, 1.44511238e-01f, -3.49423173e-03f, 1.02036968e-02f, 1.80132702e-01f, 1.05075195e-01f, -7.56672472e-02f, 9.83102433e-03f, 1.59754515e-01f, 5.98466732e-02f,
  -6.09853826e-02f, 1.35173589e-01f, -5.35325184e-02f, 1.44177929e-01f, 4.45886217e-02f, -4.73291166e-02f, -8.08786675e-02f, -8.86206031e-02f, -1.23287976e-01f, -4.69486304e-02f,
  -1.28625363e-01f, -9.86573193e-03f, -5.63730448e-02f, 1.04271419e-01f, 6.61676154e-02f, -8.99518840e-03f, 1.76060513e-01f, 1.96339369e-01f, 1.21155344e-01f, 4.39432524e-02f,
  8.82478580e-02f, 2.30785891e-01f, 1.01362027e-01f, -1.27878012e-02f, -1.54091477e-01f, -2.26424873e-01f, 1.69517323e-02f, 2.40114741e-02f, 8.45152438e-02f, -5.27645610e-02f,
  -5.68055958e-02f, -7.41681037e-03f, -6.76392438e-03f, 7.62125179e-02f, 4.08585668e-02f, -4.27127928e-02f, 8.78047124e-02f, -7.20145255e-02f, -2.07102336e-02f, 1.71608090e-01f,
  1.43209413e-01f, 3.06902099e-02f, 7.87908360e-02f, -1.43122047e-01f, 3.49414721e-02f, -4.81982008e-02f, -5.34056760e-02f, 1.38536274e-01f, 1.80415258e-01f, -6.60575032e-02f,
  -3.23196128e-02f, 2.30875760e-01f, -1.08996466e-01f, 2.23629782e-03f, -6.71213940e-02f, 1.55578954e-02f, -1.66734174e-01f, -5.01000360e-02f, 3.83704081e-02f, -5.22274822e-02f,
  3.69167998e-02f, 1.27292201e-02f, 1.54673100e-01f, 1.54764950e-01f, -1.21797532e-01f, -3.88901532e-02f, 1.00669861e-01f, 5.38296998e-02f, 3.70698012e-02f, 2.08063066e-01f,
  -1.23289330e-02f, 9.07959566e-02f, 1.75909862e-01f, -7.52325431e-02f, -6.25038892e-02f, -1.54964328e-01f, 8.95333663e-02f, 1.47503257e-01f, -6.16875663e-02f, -1.28386229e-01f,
  1.38009146e-01f, 2.19910413e-01f, 4.89480942e-02f, 2.72510219e-02f, 1.51049405e-01f, 1.85906231e-01f, -7.72059932e-02f, 1.98504880e-01f, 1.48433680e-02f, -9.62413698e-02f,
  -6.91887289e-02f, 2.17847511e-01f, -6.71161637e-02f, -9.69072431e-02f, -8.72951224e-02f, -1.95425469e-02f, 1.29594309e-02f, 1.13074847e-01f, -4.36543860e-02f, -2.72343997e-02f,
  1.05361372e-01f, 2.45592043e-01f, 7.32976049e-02f, -6.28084317e-02f, 1.75809726e-01f, 2.33964086e-01f, 1.92676678e-01f, -1.41432911e-01f, -7.33164623e-02f, 1.24004893e-01f,
  -9.69516113e-03f, -1.54521525e-01f, 7.94590916e-03f, -3.84043306e-02f, -4.83150082e-03f, 2.12424070e-01f, 1.86358586e-01f, -1.11626804e-01f, 3.54675464e-02f, -8.52831677e-02f,
  -7.64936432e-02f, -7.63707384e-02f, -1.28507717e-02f, -2.04927716e-02f, -1.98382698e-02f, -9.61084142e-02f, 4.50729579e-02f, 7.11120218e-02f, -1.24144636e-01f, 1.34513825e-01f,
  6.91299066e-02f, -5.95396683e-02f, -1.96095351e-02f, 2.34483540e-01f, 4.48209941e-02f, 2.19151333e-01f, 1.33949101e-01f, -6.71173036e-02f, 5.11245951e-02f, -5.40876128e-02f,
  -2.21856460e-02f, 1.66750759e-01f, -2.38563314e-01f, 8.06130245e-02f, 2.77602882e-03f, -1.04910910e-01f, 1.20865114e-01f, 1.18255869e-01f, 4.70061693e-03f, 1.28295019e-01f,
  1.99319478e-02f, -1.21205375e-01f, 5.25028519e-02f, -1.34484274e-02f, 1.26685500e-01f, 7.62878582e-02f, 1.02533713e-01f, -5.76480590e-02f, 1.05247363e-01f, -6.53875396e-02f,
  -4.38288320e-03f, -1.28955916e-01f, -1.12339020e-01f, 5.81148565e-02f, 6.50344118e-02f, -1.30143063e-02f, -9.66966003e-02f, 3.47175486e-02f, 1.36462793e-01f, 9.05747265e-02f,
  -1.41823187e-01f, 5.49826138e-02f, -1.21460326e-01f, -8.76227021e-02f, -2.52229497e-02f, -1.18753061e-01f, 1.25573635e-01f, 4.27562334e-02f, -6.73993155e-02f, 1.30898625e-01f,
  -1.03903458e-01f, 1.65311933e-01f, -7.74327815e-02f, -7.54684061e-02f, -1.10705189e-01f, -8.79818648e-02f, 5.01137674e-02f, 5.65851294e-03f, 1.46989107e-01f, -4.11304384e-02f,
  1.30081519e-01f, 1.16249949e-01f, -3.71542759e-02f, -1.42039908e-02f, 1.36605967e-02f, -1.20457277e-01f, -5.09017073e-02f, 2.47362629e-02f, 9.84033477e-03f, 5.05103990e-02f,
  -4.47890311e-02f, -5.69989458e-02f, -7.67134950e-02f, -1.39968574e-01f, -6.36761039e-02f, 1.76157698e-01f, 8.71858746e-02f, -1.52339814e-02f, -7.25026242e-03f, 2.99410168e-02f,
  -8.11871514e-02f, -3.48065831e-02f, 7.62629211e-02f, -9.68946069e-02f, 8.47609714e-02f, -6.09073937e-02f, 1.63773581e-01f, 9.20975655e-02f, -3.13934870e-02f, 1.85289577e-01f,
  -1.64923389e-02f, -1.66141957e-01f, 1.27643049e-01f, 4.65781754e-03f, 9.13977474e-02f, -1.25516862e-01f, -2.58477665e-02f, -3.34008336e-02f, -6.96481094e-02f, 1.30305961e-01f,
  -4.24005613e-02f, -1.11078240e-01f, 9.82288197e-02f, 1.08361125e-01f, 1.50046036e-01f, -3.02731711e-02f, 4.54644635e-02f, -1.79445560e-04f, 1.15771756e-01f, -5.82206063e-02f,
  5.17027415e-02f, 1.33565500e-01f, -7.88472407e-03f, -7.23365024e-02f, 1.86188623e-01f, 7.06016123e-02f, -9.03677847e-03f, 5.70008308e-02f, -6.47670636e-03f, -1.05567008e-01f,
  1.07165486e-01f, 8.14855173e-02f, 1.36547208e-01f, -9.03970078e-02f, 1.28730163e-01f, -1.05257280e-01f, 8.88212398e-02f, 1.44490585e-01f, -2.02706046e-02f, 1.24697685e-02f,
  8.28894153e-02f, -1.20005950e-01f, -9.99586061e-02f, 9.97133180e-02f, 1.14649862e-01f, 1.28280506e-01f, 1.25240803e-01f, -1.91330619e-03f, 8.22015628e-02f, 9.77170244e-02f,
  -1.76996782e-01f, 1.04405053e-01f, 4.38913554e-02f, -1.01342469e-01f, -1.18141271e-01f, -6.83482513e-02f, -4.03734297e-02f, 9.46271718e-02f, 1.81750469e-02f, 1.24776416e-01f,
  -1.00241408e-01f, -5.30629382e-02f, -2.13649198e-02f, 5.82803180e-03f, -2.87877638e-02f, 3.24632153e-02f, -4.11277777e-03f, -4.14292706e-04f, -1.53637482e-02f, 1.98789127e-02f,
  5.42479567e-02f, -9.15646628e-02f, 6.66079437e-03f, -8.99972394e-02f, -8.91371593e-02f, 8.61868635e-02f, 8.30437616e-02f, 9.41728875e-02f, 7.63370395e-02f, 3.03560365e-02f,
  7.90826678e-02f, -8.25906247e-02f, -6.30305558e-02f, -2.22391710e-02f, 6.35043755e-02f, -9.86698940e-02f, -9.91265178e-02f, -1.41245037e-01f, -1.14137763e-02f, -4.06329967e-02f,
  -8.65468085e-02f, 3.72851342e-02f, 3.47042233e-02f, 5.22682145e-02f, 1.14604153e-01f, 6.76512569e-02f, -1.00274250e-01f, 1.40046149e-01f, 1.35432675e-01f, 7.53577352e-02f,
  -1.74767207e-02f, -3.91842052e-02f, -1.20015785e-01f, 9.29197744e-02f, -1.33000270e-01f, 1.15212895e-01f, -5.14302626e-02f, 7.59112760e-02f, 4.00929376e-02f, -3.13379541e-02f,
  5.65435551e-02f, -7.01212734e-02f, 2.91943084e-02f, -1.09780259e-01f, -8.52181837e-02f, 1.02054581e-01f, 4.33314173e-03f, -7.27704763e-02f, -2.73853354e-02f, 3.87181640e-02f,
  1.99533910e-01f, -6.94599599e-02f, 1.07953124e-01f, 1.59972712e-01f, 1.00824200e-01f, 7.48590380e-02f, -6.55489191e-02f, -2.07210835e-02f, -1.06540993e-01f, -1.11731244e-02f,
  -1.54845929e-03f, -7.05238199e-03f, 1.71938121e-01f, 1.24710485e-01f, 6.58159927e-02f, 5.36733605e-02f, -8.85997489e-02f, 5.53229228e-02f, -9.01942477e-02f, -5.25710769e-02f,
  -1.87058635e-02f, 2.11086750e-01f, 3.55975367e-02f, 1.07334077e-01f, -5.72894774e-02f, 7.79861212e-02f, -5.54278754e-02f, -4.68198396e-02f, 1.35027438e-01f, 8.58683735e-02f,
  6.22693636e-02f, -4.55454066e-02f, -4.46718000e-02f, 5.16040735e-02f, -5.01486249e-02f, -8.20705071e-02f, 1.14125162e-01f, -3.05748340e-02f, -1.63190514e-02f, 1.83476657e-02f,
  2.30005402e-02f, -6.38738871e-02f, 1.65463269e-01f, 1.77445747e-02f, 6.06159307e-02f, 3.22681363e-03f, -1.26559690e-01f, 1.75630804e-02f, -5.28872088e-02f, -6.50978088e-02f,
  -1.01423562e-01f, 1.51849389e-01f, 4.91990484e-02f, 9.67836380e-02f, 2.15322021e-02f, -4.66009267e-02f, 6.25774562e-02f, 1.15970604e-01f, 3.00184619e-02f, -4.46638465e-02f,
  -8.35717618e-02f, 1.21435605e-01f, 9.37958434e-02f, 1.74759105e-01f, 9.67616662e-02f, 4.60950695e-02f, 1.40477255e-01f, 8.51558298e-02f, -5.22603840e-02f, -1.07310654e-03f,
  2.37775475e-01f, -1.61768333e-03f, 1.00468628e-01f, -9.28196087e-02f, -6.24121167e-02f, 1.15209430e-01f, 2.49796808e-02f, -1.32833542e-02f, -1.01492023e-02f, -1.32805958e-01f,
  6.95617571e-02f, -1.36345491e-01f, -2.43848637e-02f, 1.81535836e-02f, 2.61601478e-01f, -9.28986296e-02f, 3.05265840e-02f, 5.24724498e-02f, -9.94414277e-03f, -3.11836060e-02f,
  -1.67197317e-01f, -6.67118430e-02f, -5.45166694e-02f, -1.03151679e-01f, 1.38730407e-01f, -1.70359552e-01f, -3.74621898e-02f, -8.20375904e-02f, -1.06777795e-01f, -1.60275667e-03f,
  2.21714959e-01f, -7.95029700e-02f, 2.69434415e-02f, -1.21307008e-01f, 6.24241270e-02f, 1.24554813e-01f, 1.90126613e-01f, 8.93350095e-02f, 1.64503902e-01f, 6.12078793e-02f,
  4.52108048e-02f, -5.73696904e-02f, -1.23628944e-01f, -7.44935945e-02f, 1.12572126e-01f, 4.52592932e-02f, -1.67898282e-01f, 4.56305891e-02f, -8.22112989e-03f, -2.27476191e-02f,
  6.69143200e-02f, -5.09318523e-02f, 1.28556462e-02f, -8.50287601e-02f, 1.46626448e-02f, 1.14281625e-02f, 5.80563806e-02f, -8.99981186e-02f, -4.35131006e-02f, -8.93044695e-02f,
  3.65400501e-02f, 6.24173321e-03f, 1.16641643e-02f, 8.57875645e-02f, -3.94781306e-02f, -2.87469719e-02f, -5.07976534e-03f, 1.14100173e-01f, -9.43701267e-02f, 2.27694679e-02f,
  -3.11914980e-02f, -1.06578074e-01f, -1.15311511e-01f, -1.66144073e-02f, 1.04525939e-01f, -5.27148061e-02f, -6.36208802e-02f, -8.20840597e-02f, 1.19760066e-01f, -8.89182240e-02f,
  1.14503250e-01f, -9.13492218e-02f, -8.81004427e-03f, -1.18740879e-01f, 4.15054671e-02f, -9.81369615e-02f, -9.05291364e-02f, 9.67116281e-02f, -3.23978178e-02f, -1.12442106e-01f,
  -1.86700886e-03f, 7.63790496e-03f, -6.77774707e-03f, 7.27345198e-02f, -2.93277465e-02f, -4.79106419e-02f, 3.01135369e-02f, 7.23775402e-02f, -1.07577272e-01f, -1.23337559e-01f,
  6.96240515e-02f, -8.61685798e-02f, 8.16210173e-03f, 3.55604594e-03f, -7.09366947e-02f, -8.65708198e-03f, 4.83006313e-02f, 1.42007153e-02f, -8.54493529e-02f, -4.79706153e-02f,
  -1.07960030e-01f, -7.68973753e-02f, 1.05784103e-01f, -6.72738850e-02f, -7.03494297e-03f, 1.15224406e-01f, 9.02829543e-02f, -3.44378538e-02f, 8.83903354e-02f, 1.37917951e-01f,
  -4.04944457e-03f, -5.35336249e-02f, -4.16209958e-02f, -6.02969751e-02f, 8.24293271e-02f, -8.90972912e-02f, -1.47781959e-02f, 1.23636499e-01f, -5.84968850e-02f, -7.45707229e-02f,
  2.59009823e-02f, 1.70725971e-01f, 2.02579927e-02f, 6.97132871e-02f, 1.33197948e-01f, 2.83059925e-02f, -3.00802477e-02f, 7.18196249e-03f, -4.63249758e-02f, 6.93855807e-02f,
  -4.53788862e-02f, -5.14339432e-02f, 9.77027044e-02f, -1.23260818e-01f, 3.95297557e-02f, 2.47274097e-02f, 1.27365187e-01f, -3.69365886e-02f, 7.73543045e-02f, -6.91052303e-02f,
  1.15552232e-01f, -1.02351889e-01f, -2.19822321e-02f, 9.85626727e-02f, -3.91246043e-02f, 1.63270235e-01f, -1.16272569e-01f, 1.12639636e-01f, 8.70875791e-02f, -4.13783900e-02f,
  -1.05471335e-01f, 3.10650393e-02f, 1.66674122e-01f, 3.96298468e-02f, -6.89304918e-02f, -8.85540843e-02f, -2.08349172e-02f, -1.10897340e-01f, 9.26229581e-02f, 2.47579534e-02f,
  8.28743502e-02f, -1.15119867e-01f, -8.79163519e-02f, -1.29388124e-01f, 9.82239917e-02f, 1.05098821e-02f, 5.46899550e-02f, 4.07740958e-02f, 6.72912225e-02f, -8.12416002e-02f,
  1.07914537e-01f, 2.56492645e-02f, 4.86221202e-02f, -5.91747835e-02f, -1.61806971e-03f, -1.58622563e-02f, -1.14182439e-02f, 7.10663795e-02f, -3.27349231e-02f, -2.54133493e-02f,
  1.22090630e-01f, 8.10633600e-02f, 3.59871760e-02f, 1.51735812e-01f, -7.19512925e-02f, -3.81807722e-02f, 1.69242658e-02f, 6.02384098e-02f, 9.59462598e-02f, -3.41225304e-02f,
  -7.68002868e-02f, 7.75806606e-02f, -4.20619138e-02f, 2.14935541e-02f, 9.25160274e-02f, -8.02830234e-03f, -9.51148942e-02f, 1.04379438e-01f, -4.31697257e-02f, -2.84578302e-03f,
  3.12067028e-02f, 1.26128629e-01f, -1.15566459e-02f, -8.28888193e-02f, -3.14540863e-02f, 4.93743084e-02f, 8.79504010e-02f, -9.04869586e-02f, 7.30381832e-02f, 7.79366642e-02f,
  8.58596936e-02f, 1.38987318e-01f, -9.81784388e-02f, 1.29016042e-01f, -6.50662109e-02f, -5.72192557e-02f, -6.94259405e-02f, 1.08769029e-01f, 9.17250197e-03f, -2.98029594e-02f,
  1.39477715e-01f, -4.62333933e-02f, 1.29969267e-03f, -2.91570369e-03f, -1.23855345e-01f, -4.19149883e-02f, 2.86663845e-02f, 1.34628475e-01f, -6.69475719e-02f, -6.76255599e-02f,
  8.29375237e-02f, 1.21174697e-02f, 4.83212210e-02f, 1.20268494e-01f, -1.35418102e-01f, 1.17781423e-01f, 1.42793164e-01f, 8.96038637e-02f, 7.32512102e-02f, -4.74841818e-02f,
  6.41542673e-02f, 7.76782706e-02f, -1.16151206e-01f, 2.01875120e-01f, -2.53712460e-02f, -1.67333081e-01f, -2.34864485e-02f, -5.27394190e-02f, -2.83732899e-02f, 4.86590154e-02f,
  6.58776332e-03f, -1.80312265e-02f, 1.57480970e-01f, -4.63677458e-02f, -1.28904417e-01f, -4.53795940e-02f, -1.03283972e-01f, 3.76543701e-02f, 1.36711858e-02f, 1.48977339e-01f,
  4.39541191e-02f, 1.74727067e-01f, 5.01020364e-02f, -9.92661864e-02f, -8.29785839e-02f, 1.07851941e-02f, 3.54128592e-02f, 3.27747837e-02f, -8.14623535e-02f, -4.63819830e-03f,
  6.69932887e-02f, 7.94525146e-02f, 1.31762907e-01f, -4.35962453e-02f, 3.02695925e-03f, -6.43848106e-02f, 1.45223722e-01f, 2.94396859e-02f, -5.19553982e-02f, -7.24142268e-02f,
  -8.65601003e-02f, -8.17606375e-02f, 8.17246363e-02f, -8.01047683e-03f, 5.04945293e-02f, -3.93966213e-03f, -2.31735054e-02f, -1.68637540e-02f, -1.66172236e-02f, 9.30245742e-02f,
  3.52609158e-02f, 1.94315478e-01f, 1.25094160e-01f, -2.22966000e-02f, -3.67930271e-02f, -2.16241851e-02f, -1.27433643e-01f, 9.74612497e-03f, -1.47840664e-01f, 1.26759438e-02f,
  6.17242381e-02f, 1.80749655e-01f, 4.48975572e-03f, -1.11446260e-02f, 7.63443708e-02f, 8.71429816e-02f, 7.67471716e-02f, 1.11855432e-01f, -1.07443154e-01f, -1.18097238e-01f,
  1.68651491e-01f, 1.57379687e-01f, 2.36969218e-02f, -7.40608796e-02f, -4.79286574e-02f, 4.20051850e-02f, 1.55223794e-02f, -1.10545292e-01f, -5.97974136e-02f, 9.59335938e-02f,
  -5.41615076e-02f, 6.34487495e-02f, 1.55605108e-01f, 1.98391471e-02f, 1.68802828e-01f, 1.23062670e-01f, -1.62640139e-02f, 9.58962739e-02f, -6.34809583e-02f, -9.98235419e-02f,
  -8.90669450e-02f, -5.91374524e-02f, 1.04495391e-01f, -2.46012751e-02f, 1.63626354e-02f, 4.91044782e-02f, 7.58238509e-02f, -3.57958153e-02f, -9.92619470e-02f, 2.79619060e-02f,
  -9.42968670e-03f, -4.28717071e-03f, 3.05353180e-02f, 1.15003251e-01f, 2.16371074e-01f, 1.14856809e-01f, 1.06187686e-01f, 6.70147538e-02f, -1.13261200e-01f, 3.95165160e-02f,
  -9.68399197e-02f, -5.80669455e-02f, -7.26715177e-02f, -2.65570413e-02f, 5.67034893e-02f, -3.95838916e-02f, -4.76123765e-02f, 9.96012539e-02f, 8.20701495e-02f, 3.81779745e-02f,
  -7.18412623e-02f, 1.22464076e-01f, -1.29664123e-01f, 1.86466560e-01f, 7.05353245e-02f, 6.87147379e-02f, 8.80408287e-02f, 1.14516526e-01f, 6.13528527e-02f, 2.68812180e-02f,
  -7.29592964e-02f, 2.21015066e-01f, 1.10481389e-01f, 1.31892815e-01f, 1.17359042e-01f, 1.08234636e-01f, 4.16259393e-02f, -1.82778865e-01f, -1.25774339e-01f, 1.65812209e-01f,
  2.38499403e-01f, 1.30997717e-01f, 2.34380037e-01f, -1.64569676e-01f, -5.70916720e-02f, -3.13499477e-03f, -1.11846812e-01f, 9.92923528e-02f, -4.24735853e-03f, -4.34390940e-02f,
  3.08450162e-01f, -1.07453391e-01f, 1.24574818e-01f, 6.11516386e-02f, 2.60591924e-01f, -7.37275183e-02f, 5.74021153e-02f, -8.80364031e-02f, 8.18483010e-02f, 3.49643305e-02f,
  1.37864603e-02f, 8.98655131e-02f, 2.64837414e-01f, 1.91335112e-01f, 2.89829731e-01f, -9.51754600e-02f, 2.72378594e-01f, -5.73320948e-02f, -1.79986462e-01f, 1.79456994e-01f,
  1.70012310e-01f, -3.38494331e-02f, 1.07397102e-01f, -1.20966369e-02f, -5.03868796e-02f, -7.97799509e-03f, -8.42784811e-03f, 2.55413145e-01f, -1.49455652e-01f, 1.95608586e-01f,
  -1.03026621e-01f, -1.18859157e-01f, 1.55532628e-01f, -1.43261522e-01f, 9.66941863e-02f, -3.74401361e-02f, -2.46765148e-02f, 3.01859435e-02f, 1.38529554e-01f, 1.39312118e-01f,
  -6.33632019e-02f, -9.54598188e-03f, 7.83438981e-02f, 1.75096124e-01f, 1.22800665e-02f, -6.93025142e-02f, -1.63719565e-01f, -1.42208800e-01f, -9.49292928e-02f, -6.41236678e-02f,
  -2.47410964e-04f, 5.14614955e-02f, 1.05281230e-02f, 7.53202066e-02f, -1.18021369e-01f, 7.42426217e-02f, -1.18478738e-01f, 2.64069717e-03f, 7.37069249e-02f, -6.91339746e-03f,
  -6.57133982e-02f, 1.42164946e-01f, -8.36986527e-02f, -7.10393637e-02f, -6.64690956e-02f, 2.16922704e-02f, 1.20171309e-01f, -1.71402954e-02f, 1.25455871e-01f, 4.52188700e-02f,
  -6.28340691e-02f, 1.43972963e-01f, 7.65803531e-02f, 2.00088412e-01f, -9.07796696e-02f, 1.09277353e-01f, -3.99560630e-02f, -4.02380638e-02f, 1.14076054e-02f, 1.42139718e-02f,
  -4.08406742e-02f, 7.19873756e-02f, -7.45710284e-02f, 1.79380812e-02f, 1.18813001e-01f, -6.48945048e-02f, 7.61839822e-02f, -6.41868412e-02f, -5.81707507e-02f, 9.16159078e-02f,
  -1.04635343e-01f, 2.28920728e-01f, 1.45788463e-02f, 3.82278897e-02f, 1.51644573e-01f, 9.06272829e-02f, -6.98776171e-02f, 8.15084279e-02f, 5.71702942e-02f, 1.81715135e-02f,
  3.10560502e-02f, -3.00821997e-02f, 1.51505649e-01f, 8.82758126e-02f, 1.19817205e-01f, 8.61184821e-02f, 1.24376155e-01f, 1.05872981e-01f, -6.21095533e-03f, 2.21634209e-01f,
  1.02235608e-01f, -1.14113227e-01f, -1.81951672e-02f, -1.14201285e-01f, -1.49278164e-01f, 8.16481188e-02f, 2.47697346e-02f, -1.68715343e-01f, 1.34458438e-01f, 7.25705549e-02f,
  -8.57696962e-03f, -4.02261019e-02f, 1.27757624e-01f, 2.15535611e-01f, -5.33439405e-02f, 2.64026355e-02f, 2.82556470e-02f, 1.30916700e-01f, -4.40264493e-02f, -2.52886713e-02f,
  -1.96214598e-02f, 3.35088745e-02f, 1.02492496e-01f, -9.95758399e-02f, 8.10881034e-02f, 1.61000088e-01f, 1.55173391e-01f, -2.48854216e-02f, 2.39648178e-01f, -7.23216906e-02f,
  7.75417918e-03f, -8.54684785e-03f, 3.41714770e-02f, 1.02671005e-01f, -1.12710074e-01f, 1.40602402e-02f, -4.18718085e-02f, 3.19819823e-02f, 4.63530719e-02f, 5.19283079e-02f,
  8.23996663e-02f, 6.97980896e-02f, -2.81856395e-02f, 9.33184028e-02f, -1.73131913e-01f, 8.71293172e-02f, 3.65017477e-04f, 5.14087714e-02f, 2.10472509e-01f, -9.19063985e-02f,
  3.75072323e-02f, 6.65692240e-02f, 6.02992624e-03f, 1.91881657e-01f, -1.79264680e-01f, 6.82458431e-02f, 4.75352667e-02f, 2.20955610e-02f, -9.02168527e-02f, 8.66058767e-02f,
  1.39269352e-01f, 1.07473001e-01f, 9.02951360e-02f, -2.35303417e-02f, 1.50453551e-02f, 2.52744108e-01f, -1.83543079e-02f, 1.05968729e-01f, 3.72358263e-02f, -1.41978189e-01f,
  1.21463113e-01f, 1.78001761e-01f, 1.94573432e-01f, -1.32760210e-02f, 1.41639352e-01f, 3.77480425e-02f, -7.62621239e-02f, -2.32592761e-03f, 3.14772576e-02f, 1.43237159e-01f,
  -4.03201878e-02f, -3.69435214e-02f, 3.13629024e-02f, -6.67988881e-02f, -1.32708594e-01f, -8.47867876e-03f, 1.84592173e-01f, 3.69211584e-02f, 8.52432940e-03f, 8.37751478e-02f,
  -8.99804160e-02f, 1.81346253e-01f, 1.36427328e-01f, -6.22134358e-02f, 2.50304490e-01f, 1.85887009e-01f, -4.90804166e-02f, -6.06057830e-02f, 1.95416063e-01f, 1.12088770e-01f,
  5.24123898e-03f, 1.45829648e-01f, -3.84658985e-02f, 1.10497601e-01f, -1.90965459e-02f, 6.97541758e-02f, -8.76784995e-02f, -2.27144621e-02f, 1.62416101e-02f, 5.26396893e-02f,
  -1.53132841e-01f, -8.45042393e-02f, -1.27177397e-02f, 7.68771619e-02f, -2.60914620e-02f, 9.49037373e-02f, 8.17012712e-02f, -4.24236879e-02f, -2.17831116e-02f, -5.87403327e-02f,
  1.00453228e-01f, 2.77857818e-02f, -4.97556999e-02f, -3.13405395e-02f, -1.09593056e-01f, -1.55187072e-02f, -4.41196598e-02f, -1.29000917e-01f, -1.07172258e-01f, 1.21078780e-03f,
  5.17836213e-02f, -1.40993759e-01f, 1.71336368e-01f, 4.29332480e-02f, -1.02178872e-01f, 3.18464153e-02f, 6.63769841e-02f, -1.15495078e-01f, 9.63396132e-02f, -1.21698971e-03f,
  -1.17061630e-01f, -1.33925349e-01f, 7.38207325e-02f, 8.60161558e-02f, 1.08488448e-01f, -9.72514674e-02f, 5.22797816e-02f, 1.69462487e-01f, -7.99981430e-02f, 1.17140055e-01f,
  -7.56469741e-02f, 4.22588587e-02f, -4.50993963e-02f, -6.61340654e-02f, -9.33844894e-02f, -1.82274226e-02f, -2.43662614e-02f, 5.44159040e-02f, -3.07573173e-02f, 1.02466293e-01f,
  1.94655254e-01f, 1.53429314e-01f, 4.63897251e-02f, 1.04838558e-01f, -2.10103840e-02f, 2.33375534e-01f, 1.60532035e-02f, 1.39943987e-01f, 1.70941859e-01f, 1.30467132e-01f,
  -2.80142501e-02f, -8.50178599e-02f, 8.63416567e-02f, 1.26594141e-01f, 3.16027552e-02f, -7.64718279e-02f, -1.58585802e-01f, -1.01708293e-01f, -1.11247890e-01f, 1.08245112e-01f,
  1.69683263e-01f, -1.11805432e-01f, 1.43660322e-01f, -9.88236964e-02f, -4.21995334e-02f, 7.61292800e-02f, -2.01555970e-03f, 1.73234803e-04f, -9.74082425e-02f, 7.30213746e-02f,
  8.59765261e-02f, -1.33121356e-01f, -2.66078636e-02f, 6.58789054e-02f, 7.53026158e-02f, 3.19550782e-02f, -4.24086936e-02f, 1.08349353e-01f, 4.60569337e-02f, 1.11786835e-01f,
  -1.28841192e-01f, -5.50746080e-03f, -7.76382461e-02f, -2.52363421e-02f, -8.48015100e-02f, 1.54723087e-02f, -8.88779312e-02f, 2.01987326e-02f, -8.39939807e-03f, 1.08414985e-01f,
  7.95880556e-02f, -9.97213945e-02f, -4.46416810e-02f, 3.78451161e-02f, -5.66779301e-02f, -6.16764575e-02f, -1.13023311e-01f, 7.96887502e-02f, -3.72223184e-02f, 9.34719369e-02f,
  1.40678540e-01f, 8.14556256e-02f, 8.82924534e-03f, 3.92280258e-02f, 1.20803304e-01f, -2.91423071e-02f, 5.05645908e-02f, -9.09365267e-02f, 1.58459976e-01f, -4.20101136e-02f,
  -8.74110684e-02f, 5.90455085e-02f, 1.16887145e-01f, -4.64558639e-02f, -3.55708599e-02f, 1.68600772e-02f, -1.17204795e-02f, 6.05349168e-02f, -9.86734033e-02f, -4.78545539e-02f,
  -9.67826694e-02f, 9.38264784e-05f, 1.21295258e-01f, -9.02212262e-02f, 5.38529605e-02f, -6.06441125e-02f, -8.37151632e-02f, 1.22017518e-01f, 2.09102646e-01f, -1.27764717e-01f,
  7.31293694e-05f, -4.38119024e-02f, 2.79119313e-02f, 1.12510271e-01f, -1.18723966e-01f, -1.24588320e-02f, -6.33296818e-02f, 7.55830258e-02f, -1.84638023e-01f, 1.63500592e-01f,
  1.01411417e-01f, 2.41749678e-02f, 1.72117259e-02f, 1.62294552e-01f, -1.94950530e-03f, -5.64509928e-02f, -2.69803554e-02f, 8.16569030e-02f, -5.57049699e-02f, 5.69925010e-02f,
  7.94792622e-02f, 2.04829931e-01f, -5.03078178e-02f, -7.10665435e-02f, 9.63586494e-02f, 8.12645033e-02f, -1.14567347e-01f, 5.20944297e-02f, 4.07375880e-02f, 2.09429890e-01f,
  7.42334174e-03f, -4.05285833e-03f, 1.06606923e-01f, 1.37525797e-01f, 3.10033071e-03f, -8.45847130e-02f, 2.79444844e-01f, -3.17686722e-02f, 1.58808455e-01f, -1.12931833e-01f,
  1.61417082e-01f, 1.76474124e-01f, 5.16318083e-02f, 1.25533789e-01f, 4.85536978e-02f, 9.78852883e-02f, 1.11289673e-01f, 7.36486586e-03f, 1.94465481e-02f, 1.47372633e-01f,
  1.22807704e-01f, 1.51940688e-01f, -5.50819524e-02f, -2.58737914e-02f, -1.17370620e-01f, -1.14782125e-01f, -2.77363081e-02f, -1.58366889e-01f, -4.13242122e-03f, -4.17318046e-02f,
  1.77103013e-01f, -2.96496265e-02f, -8.98885652e-02f, -1.02218345e-01f, -1.23873604e-02f, -7.34362975e-02f, -9.19017419e-02f, 6.66533783e-02f, -6.50651827e-02f, 2.35894341e-02f,
  -2.40795705e-02f, -1.10054918e-01f, -1.16028339e-01f, 7.27631897e-02f, 1.22107275e-01f, 8.66700038e-02f, -3.78056476e-03f, -1.24063686e-01f, 3.27956192e-02f, -4.32411879e-02f,
  1.08571827e-01f, -1.02982365e-01f, 9.48739648e-02f, 6.80697411e-02f, -5.65644950e-02f, -1.15642890e-01f, 3.33005078e-02f, -2.66071633e-02f, 8.86527449e-02f, -8.52887854e-02f,
  2.26736479e-02f, -3.56991328e-02f, 6.80119917e-02f, -6.02243356e-02f, -3.26047689e-02f, -1.03281774e-01f, 7.40812942e-02f, 4.44455631e-02f, -7.65011311e-02f, -6.26463145e-02f,
  9.73982736e-02f, 8.28565750e-03f, -9.25509185e-02f, 1.18361369e-01f, -5.45163080e-02f, -4.39168736e-02f, 4.20240574e-02f, -6.73245415e-02f, -7.18458695e-03f, -5.32093160e-02f,
  1.00860789e-01f, -1.12240545e-01f, 2.51829103e-02f, -1.03244446e-01f, -1.26991063e-01f, 2.08380707e-02f, -2.74191052e-02f, -7.90155306e-03f, -9.07772034e-02f, 1.77004449e-02f,
  -1.17717706e-01f, 5.44288419e-02f, 1.62075367e-02f, 1.08781330e-01f, 1.52087593e-02f, -1.18932307e-01f, 9.89502948e-03f, -8.36158171e-02f, -3.49567793e-02f, -1.78519636e-03f,
  -7.02804998e-02f, 6.59977421e-02f, -3.25107500e-02f, 1.55328035e-01f, -6.03720956e-02f, 5.10033071e-02f, 1.06992219e-02f, 6.57980144e-02f, 1.00525759e-01f, 9.41760540e-02f,
  6.10827878e-02f, 6.18299134e-02f, -2.64863037e-02f, 1.25172466e-01f, -3.26061249e-02f, 1.50196806e-01f, -2.21380088e-02f, 1.52173176e-01f, 1.10009462e-01f, 9.84423980e-02f,
  3.55000980e-02f, 1.05738938e-02f, -1.00670226e-01f, 9.86413136e-02f, -6.18321635e-02f, 6.36472851e-02f, -2.92125270e-02f, 1.52483404e-01f, 1.32454082e-01f, 4.31502610e-02f,
  1.38432935e-01f, -8.90535265e-02f, -1.23235144e-01f, -3.82047184e-02f, 1.29023612e-01f, 7.70796612e-02f, -1.69702210e-02f, -7.71061098e-03f, -8.31221715e-02f, 1.49601743e-01f,
  1.28852710e-01f, 1.38216749e-01f, -5.75882345e-02f, 6.72359914e-02f, -5.62012307e-02f, 9.52586997e-03f, 1.27346084e-01f, 1.41295463e-01f, 6.86905831e-02f, -7.42408335e-02f,
  -2.37235483e-02f, -9.38477442e-02f, 4.96602543e-02f, -7.50818849e-03f, -1.24687860e-02f, -2.12372653e-02f, 1.32647287e-02f, 1.70399904e-01f, -1.16266524e-02f, 7.24977581e-03f,
  4.69183698e-02f, -1.28467038e-01f, -1.50009152e-02f, -1.87197700e-02f, -9.74794943e-03f, -3.10544167e-02f, -7.52344131e-02f, 1.01937145e-01f, -9.41518992e-02f, -1.76226228e-01f,
  7.69672766e-02f, -3.61491069e-02f, 1.58119142e-01f, 1.96811602e-01f, -1.07856855e-01f, 9.08430591e-02f, 3.03206276e-02f, -4.96104099e-02f, -3.98991778e-02f, 1.47741184e-01f,
  1.86040644e-02f, -1.14045747e-01f, 8.61265734e-02f, -4.80267406e-02f, -1.30891874e-01f, -5.82638150e-03f, -7.00856149e-02f, 1.16216920e-01f, 5.03005460e-03f, 1.35479067e-02f,
  -3.42589170e-02f, 1.62499696e-01f, -9.00725946e-02f, 1.13239083e-02f, 6.46348065e-03f, 4.85879509e-03f, -7.04969615e-02f, -1.06787190e-01f, 4.03095260e-02f, -8.52095038e-02f,
  2.73848385e-01f, 1.15293883e-01f, 1.42456621e-01f, -7.29385316e-02f, -6.12272471e-02f, 1.76838115e-01f, -9.11307782e-02f, 3.70371751e-02f, 6.39135242e-02f, -9.03163925e-02f,
  -5.06635495e-02f, 1.85358280e-03f, 1.04045026e-01f, 7.08450004e-02f, 9.40425918e-02f, -7.70353675e-02f, 2.48476341e-02f, -9.65281874e-02f, 6.17254227e-02f, 1.07421413e-01f,
  -3.19080986e-03f, 9.95505080e-02f, 1.43190756e-01f, 5.19655831e-02f, 3.76565784e-01f, 8.17192495e-02f, -2.57864334e-02f, 1.64351881e-01f, -6.32391945e-02f, 2.39054397e-01f,
  -1.92489818e-01f, -1.12056039e-01f, -2.84667283e-01f, -3.76512885e-01f, -1.24330550e-01f, 2.74754256e-01f, 2.09254369e-01f, -3.67917605e-02f, 1.04052527e-02f, 5.95498309e-02f,
  1.33895203e-01f, 2.65835281e-02f, -2.52504885e-01f, 1.54184490e-01f, -1.33547723e-01f, -1.44565781e-03f, 6.71108887e-02f, 2.13899110e-02f, 7.97347501e-02f, -9.37094018e-02f,
  -2.99585462e-02f, -1.58194602e-01f, 3.36149298e-02f, -5.67786694e-02f, 1.32765383e-01f, 1.76381513e-01f, 1.28181711e-01f, 2.31240705e-01f, 9.24518257e-02f, 2.54222125e-01f,
  -2.26160049e-01f, 1.34032831e-01f, 1.75978437e-01f, -2.19752211e-02f, -1.42761961e-01f, -1.67733222e-01f, 1.37656331e-01f, 7.50742033e-02f, 5.85503392e-02f, -2.71454286e-02f,
  -6.29614368e-02f, 3.35679650e-02f, 4.81179096e-02f, -4.08317661e-03f, 1.81879938e-01f, 2.69928783e-01f, 2.60445863e-01f, 3.53331298e-01f, 2.03919500e-01f, 1.18953675e-01f,
  1.89755306e-01f, -9.42404196e-02f, -1.51670665e-01f, -1.49137184e-01f, 7.49302702e-03f, 4.99770194e-02f, 1.72666341e-01f, -3.52028199e-02f, -1.62576267e-03f, 4.29884307e-02f,
  -8.96772593e-02f, -1.17157465e-02f, -1.24423407e-01f, -1.20338209e-01f, -1.06673747e-01f, 3.38624120e-02f, 1.26387283e-01f, 4.31313105e-02f, 5.58301769e-02f, 1.08622663e-01f,
  -3.65267210e-02f, -7.54042119e-02f, 6.46887645e-02f, 8.74506533e-02f, 8.13575089e-02f, 1.15376577e-01f, 8.62239972e-02f, -4.90155146e-02f, 6.01319559e-02f, -1.07332699e-01f,
  5.10475077e-02f, 5.16183078e-02f, -2.72106398e-02f, -9.05256420e-02f, -3.23169641e-02f, -7.47588575e-02f, -8.05055425e-02f, 9.02472362e-02f, 1.51334731e-02f, -7.24046528e-02f,
  3.97940390e-02f, -6.63741231e-02f, 8.22918937e-02f, -2.47948673e-02f, -1.83438528e-02f, -3.34596559e-02f, -2.60759890e-02f, 4.25578766e-02f, 7.97262415e-03f, 1.90703897e-03f,
  -6.39073700e-02f, -2.07242444e-02f, -2.89312359e-02f, -5.48524968e-02f, 9.01593789e-02f, 8.05774108e-02f, 1.11729860e-01f, 5.83269037e-02f, -1.05117537e-01f, 7.93983638e-02f,
  3.77421789e-02f, 6.51455149e-02f, -6.52066395e-02f, 5.17132655e-02f, -5.84276617e-02f, 1.86330685e-03f, -6.62930086e-02f, -5.43398820e-02f, 9.91174132e-02f, -1.38242384e-02f,
  5.05897216e-02f, -8.78147483e-02f, 2.31913343e-01f, 1.50802322e-02f, -1.61894932e-02f, -7.94163905e-03f, -2.97137303e-03f, 1.98904708e-01f, 3.39414775e-02f, -1.20327517e-01f,
  -1.29660651e-01f, -2.78171629e-01f, -1.42702416e-01f, -7.43511394e-02f, 2.74704322e-02f, 5.81743270e-02f, 1.85054079e-01f, -9.64976698e-02f, 3.26144807e-02f, 8.00274611e-02f,
  -7.93838948e-02f, 4.93188389e-02f, 8.90161991e-02f, -8.51087123e-02f, 8.38066190e-02f, 4.23844308e-02f, 1.15616664e-01f, 1.44695312e-01f, -1.87905163e-01f, 5.32459430e-02f,
  5.21094389e-02f, 3.55698653e-02f, 2.67762076e-02f, 1.87044844e-01f, 1.69105917e-01f, 2.75653303e-02f, -3.45966406e-02f, -1.49995964e-02f, -1.78651974e-01f, 1.35361880e-01f,
  -1.26553282e-01f, -2.05833539e-02f, 1.67725738e-02f, 1.85978245e-02f, -1.21259443e-01f, 3.18997800e-02f, 1.02636673e-01f, 1.10282362e-01f, -1.76524222e-01f, 1.04615286e-01f,
  3.74221727e-02f, -1.40595466e-01f, 1.30137473e-01f, 1.37178926e-03f, 5.22790551e-02f, 2.64959279e-02f, 2.04507366e-01f, -8.96045789e-02f, 1.30217999e-01f, -2.72433534e-02f,
  7.26760253e-02f, 9.58012864e-02f, 9.76074785e-02f, -3.75069603e-02f, 9.41841602e-02f, 6.33798614e-02f, -9.66795254e-03f, -2.83087604e-02f, 1.00538582e-01f, -7.13989586e-02f,
  2.36613542e-01f, 1.17380351e-01f, 4.06754240e-02f, 1.58855557e-01f, 1.60061046e-01f, 1.92416087e-01f, 2.98004970e-02f, 7.47616068e-02f, -1.29790381e-01f, 3.07110976e-02f,
  1.43188789e-01f, -1.13979787e-01f, -6.17323034e-02f, 1.77754506e-01f, -5.18223234e-02f, -4.85080108e-02f, 4.91492674e-02f, 1.10464811e-01f, -4.52014320e-02f, -2.02422068e-02f,
  7.10947812e-02f, 2.14543477e-01f, 2.63044778e-02f, -1.07784338e-01f, 1.34708300e-01f, 1.34686291e-01f, 1.13401115e-01f, -1.30833745e-01f, -2.19656285e-02f, -6.27455637e-02f,
  -4.15472500e-02f, 3.55333127e-02f, 8.28403160e-02f, 6.84250295e-02f, 6.89564347e-02f, -2.33437512e-02f, -6.76576048e-02f, 1.35108292e-01f, 2.86088940e-02f, 1.18295312e-01f,
  -3.50915380e-02f, 1.52475415e-02f, 1.84758604e-01f, -6.68576278e-04f, 9.46883932e-02f, 5.05065173e-02f, 3.47108915e-02f, -3.19986679e-02f, 4.12947452e-03f, -5.55095971e-02f,
  -5.40248379e-02f, -2.09102556e-02f, 1.43527180e-01f, 1.67678937e-01f, 1.57188073e-01f, 3.82123031e-02f, 1.09111026e-01f, 7.58830011e-02f, -6.85916990e-02f, 8.84188432e-03f,
  7.14718481e-04f, 3.62577699e-02f, 8.85838419e-02f, 1.12799898e-01f, -1.00626476e-01f, -1.06202811e-01f, -1.03697358e-02f, -1.38748541e-01f, -9.47618634e-02f, -8.85340571e-02f,
  2.51059741e-01f, 6.49004802e-02f, 2.60465145e-01f, 9.61000472e-02f, 1.13927566e-01f, 2.11863279e-01f, -1.42417133e-01f, -6.28452003e-02f, 7.65357688e-02f, -1.27431806e-02f,
  1.12395108e-04f, -2.28357483e-02f, 1.29140496e-01f, -5.75033501e-02f, 1.84347600e-01f, -1.39391452e-01f, 7.67082945e-02f, -8.49653706e-02f, 8.60494226e-02f, 3.39571051e-02f,
  -8.13405737e-02f, 8.41153190e-02f, -1.57761261e-01f, 1.33073598e-01f, -9.57212672e-02f, -1.19381271e-01f, 4.73874919e-02f, 4.18322310e-02f, -5.64788431e-02f, -4.80632707e-02f,
  3.05805236e-01f, 1.48600578e-01f, 1.26971260e-01f, -7.16886371e-02f, 1.13019869e-01f, 2.69657433e-01f, 1.50001228e-01f, -3.58146541e-02f, 2.07766905e-01f, 5.91203533e-02f,
  5.13378680e-02f, -1.17090948e-01f, -1.55458013e-02f, -6.17766455e-02f, -1.06198810e-01f, 7.77626261e-02f, -1.85605466e-01f, -1.32412270e-01f, -1.21724695e-01f, 2.80008018e-02f,
  -2.14152206e-02f, -2.12449208e-01f, -1.17566086e-01f, 1.82795987e-01f, -2.35878583e-02f, -9.05150622e-02f, 1.01028763e-01f, 9.52191874e-02f, -1.35716796e-01f, 7.17375726e-02f,
  8.63132328e-02f, -7.77138025e-02f, -1.04514718e-01f, 9.22558755e-02f, 1.55435383e-01f, 9.78076607e-02f, 1.59379274e-01f, -6.54597431e-02f, 8.30087811e-02f, 1.05462082e-01f,
  1.07450359e-01f, 1.04828879e-01f, -7.37794116e-02f, -9.17181596e-02f, -1.65676773e-02f, 1.92167901e-03f, 4.04235013e-02f, 8.74511525e-02f, 1.54420972e-01f, -3.35653834e-02f,
  2.14230623e-02f, -9.27407220e-02f, -1.26449428e-02f, 5.47277406e-02f, 3.81861851e-02f, -9.93389986e-04f, 8.75329133e-03f, 6.45332187e-02f, -7.78005198e-02f, 7.78278708e-02f,
  -7.50700161e-02f, -6.27722591e-02f, -1.53227430e-02f, 1.07921921e-01f, 5.93820103e-02f, -4.47605178e-02f, -8.25290680e-02f, -1.21166140e-01f, 1.04057617e-01f, -8.54694620e-02f,
  -9.49361920e-02f, 8.71683955e-02f, 5.54100499e-02f, -3.72139998e-02f, 4.19310741e-02f, -4.93801720e-02f, 7.37823471e-02f, -1.31015688e-01f, 6.16563410e-02f, 3.26278172e-02f,
  -6.63173273e-02f, -3.54321077e-02f, -1.00511029e-01f, 8.34811404e-02f, -1.26132369e-01f, -5.53977042e-02f, -1.12064227e-01f, -8.58029127e-02f, 2.11742207e-01f, -3.21802907e-02f,
  -9.77081154e-03f, 5.61556071e-02f, 1.91008657e-01f, 2.65233405e-02f, 1.36155501e-01f, -1.95995927e-01f, -2.68879421e-02f, 3.08406055e-01f, 4.49776538e-02f, 1.26961201e-01f,
  2.48385072e-02f, 7.00971931e-02f, -6.76620752e-03f, 2.22169697e-01f, 1.58449620e-01f, 1.63667232e-01f, 1.46063194e-01f, -7.39708096e-02f, 8.68226662e-02f, -1.56206176e-01f,
  -6.53085560e-02f, 4.20889221e-02f, -1.10990480e-01f, -1.39161244e-01f, 1.43210009e-01f, 1.22325793e-01f, -5.85385300e-02f, -4.36723093e-03f, 7.70295262e-02f, -7.34313130e-02f,
  -1.65241137e-01f, -1.24440724e-02f, 1.34583011e-01f, 1.32868543e-01f, -4.05375473e-02f, 3.96891832e-02f, 2.87204444e-01f, -1.10848797e-02f, 1.95806801e-01f, 1.06176101e-01f,
  3.02919358e-01f, -3.82070281e-02f, -9.55917165e-02f, 1.13811538e-01f, 2.53021687e-01f, 2.25866120e-02f, 2.16115385e-01f, 1.47325128e-01f, -1.92916512e-01f, 7.36647621e-02f,
  1.26740843e-01f, 7.64101073e-02f, -6.37718663e-02f, -7.78591409e-02f, -1.71058670e-01f, -2.96354946e-02f, 1.56185329e-01f, -4.13161628e-02f, 6.93982840e-02f, 3.93177234e-02f,
  -2.81661768e-02f, -3.29642855e-02f, 1.48114234e-01f, 1.14523090e-01f, 5.02538010e-02f, -1.28448475e-02f, 1.44523472e-01f, 1.77872460e-02f, 1.10118061e-01f, 3.11799288e-01f,
  -2.12821341e-03f, 3.04084811e-02f, -6.38245568e-02f, 7.02525675e-02f, 4.32616360e-02f, 1.26031831e-01f, -1.38165325e-01f, -1.59577169e-02f, 2.16124449e-02f, 2.63519641e-02f,
  2.20032204e-02f, -1.37907863e-01f, 1.29570857e-01f, 1.00197040e-01f, -1.27011210e-01f, 1.47643462e-01f, 2.40385756e-02f, 1.92186058e-01f, -2.94196457e-02f, -1.46967947e-01f,
  3.47006954e-02f, -3.09372470e-02f, 7.16991723e-02f, -1.17874943e-01f, 2.04117093e-02f, 3.32759582e-02f, 5.95069528e-02f, -3.20321657e-02f, 6.92254603e-02f, 2.60021631e-02f,
  1.21677808e-01f, 3.88606377e-02f, -4.32139263e-02f, 3.24532650e-02f, -5.16333729e-02f, 9.38226506e-02f, -1.30021181e-02f, -1.00431643e-01f, 9.58249867e-02f, -9.03783366e-03f,
  -7.78476372e-02f, -6.77852556e-02f, -1.39813218e-03f, -2.08945759e-02f, -8.29822496e-02f, 1.83577418e-01f, 7.92760178e-02f, 1.12591341e-01f, 7.70159513e-02f, -1.12928003e-01f,
  5.84742874e-02f, -1.02104051e-02f, -1.08260207e-01f, 2.30297118e-01f, -9.85824764e-02f, 7.05405399e-02f, 2.40182914e-02f, 8.86121914e-02f, 1.86867431e-01f, -8.59262720e-02f,
  2.83740878e-01f, 1.57541856e-01f, 4.72248495e-02f, -9.46978405e-02f, 7.39840716e-02f, 3.39953691e-01f, 1.12901025e-01f, 2.05044031e-01f, 7.17227459e-02f, -1.65761352e-01f,
  3.25720794e-02f, 8.64964873e-02f, 2.25908130e-01f, 8.63942802e-02f, 3.11980009e-01f, 5.26530556e-02f, 1.55356765e-01f, 8.57656077e-02f, -1.57918409e-01f, 3.97285372e-02f,
  -1.19943395e-01f, -1.08934194e-01f, 2.01652586e-01f, -7.93759227e-02f, -4.71309163e-02f, -2.05248781e-02f, 2.92657048e-01f, -5.05099632e-02f, -1.82660714e-01f, -4.18157279e-02f,
  -9.88101810e-02f, 8.41720626e-02f, 2.38197625e-01f, 2.12359661e-03f, 1.53947070e-01f, 1.83286354e-01f, -9.83533189e-02f, -8.12571868e-02f, 2.05505356e-01f, 1.82873220e-03f,
  -1.37443185e-01f, 8.26805159e-02f, -2.07788851e-02f, -9.59037319e-02f, 1.78687140e-01f, 5.57226278e-02f, -7.15711117e-02f, 2.79402584e-02f, 2.28430592e-02f, -5.19338883e-02f,
  -1.45938158e-01f, 2.80075129e-02f, 1.34671405e-01f, -6.85539246e-02f, 2.27926016e-01f, 8.62405002e-02f, 5.26825488e-02f, -1.08730949e-01f, -6.24345988e-03f, 1.14964753e-01f,
  -2.70425379e-02f, -1.49595842e-01f, -7.30645061e-02f, -1.11140404e-03f, -7.19266236e-02f, 1.18307970e-01f, -1.36753693e-01f, -1.80918738e-01f, -1.30091101e-01f, -2.01110449e-02f,
  -3.64618190e-02f, -7.14774132e-02f, -5.87598160e-02f, -3.83923948e-02f, 5.08858375e-02f, 8.85976925e-02f, 1.02287354e-02f, -3.41094546e-02f, 3.13012372e-03f, 1.29874930e-01f,
  -1.13229148e-01f, 9.39026773e-02f, 1.24322698e-01f, 1.07623726e-01f, 6.46736845e-02f, 1.17942989e-02f, 4.97647151e-02f, 1.35762632e-01f, 4.24462445e-02f, 2.14238856e-02f,
  -9.91294533e-02f, 7.00381994e-02f, -9.42845345e-02f, -3.14600281e-02f, -5.95778599e-02f, -5.17376438e-02f, -1.13272883e-01f, 9.53460485e-02f, 7.97113106e-02f, -5.22695221e-02f,
  2.49809586e-02f, 1.74652319e-02f, 1.21219270e-01f, -1.77976582e-02f, 6.35547861e-02f, 1.22687846e-01f, 8.81989822e-02f, -7.29201213e-02f, 3.28817815e-02f, -1.22660644e-01f,
  -1.85216591e-02f, 1.14422813e-01f, 7.38463849e-02f, 1.04487881e-01f, 1.34574488e-01f, 4.73004058e-02f, 8.38699937e-02f, 9.70181376e-02f, 2.64296997e-02f, 8.57308283e-02f,
  8.84918422e-02f, 5.42135425e-02f, 2.45205928e-02f, -1.17922015e-01f, 1.27458051e-01f, 4.91761416e-02f, 1.23523943e-01f, 2.70945579e-02f, 1.28711775e-01f, -2.79918723e-02f,
  6.45086989e-02f, 2.16273263e-01f, 5.79809323e-02f, -5.56857958e-02f, -1.52086675e-01f, -9.66401696e-02f, -3.92911397e-02f, -1.09194636e-01f, 6.45476505e-02f, -3.95874828e-02f,
  3.52431508e-03f, 1.20269597e-01f, -1.96760297e-02f, -1.57836005e-01f, 8.41371045e-02f, 1.27986059e-01f, -2.35262401e-02f, 7.50078410e-02f, 3.79939452e-02f, 2.09363773e-01f,
  6.68795407e-02f, -1.43176287e-01f, 7.33061209e-02f, -7.39218816e-02f, 9.65808183e-02f, -7.41514787e-02f, 1.80856243e-01f, -8.46178830e-02f, 1.74579129e-01f, -2.61402503e-02f,
  6.07076287e-02f, -4.80447859e-02f, -5.62292635e-02f, -4.69343178e-02f, 1.38276577e-01f, -1.88754834e-02f, 2.06398387e-02f, -2.39858422e-02f, -3.93575095e-02f, -5.19734211e-02f,
  -7.73121428e-04f, 1.10825337e-01f, -9.86242220e-02f, 9.88266245e-02f, 9.44453198e-03f, -6.55219657e-03f, -3.77899930e-02f, 1.11798652e-01f, -1.33383339e-02f, 6.79702535e-02f,
  1.70820042e-01f, 4.01404202e-02f, -2.39757542e-02f, -3.75004373e-02f, 5.73332701e-03f, 2.05736130e-01f, -9.49523747e-02f, -1.00906432e-01f, -3.21784988e-02f, -2.39477511e-02f,
  1.73461258e-01f, 2.27588028e-01f, 1.82134420e-01f, 1.26138821e-01f, 1.48489207e-01f, 1.99756250e-01f, 1.59805119e-02f, -1.77465454e-02f, -5.17469309e-02f, -4.47489955e-02f,
  -1.24585830e-01f, -1.52387209e-02f, 6.88989181e-03f, -1.65837601e-01f, -1.30062029e-02f, 1.49556279e-01f, -9.76438001e-02f, -1.18088804e-01f, -3.72535805e-03f, 1.07912600e-01f,
  1.03674671e-02f, 2.59103812e-02f, 2.80470014e-01f, 2.22710922e-01f, 1.00972123e-01f, -1.33889839e-01f, 1.43579692e-01f, 4.03837711e-02f, -3.12314685e-02f, 2.92574000e-02f,
  2.06847981e-01f, -1.49926558e-01f, 1.21077098e-01f, -6.38608038e-02f, -7.08305836e-02f, -1.00202449e-01f, 1.05714761e-01f, 1.47201754e-02f, 7.88185596e-02f, -2.95715239e-02f,
  -6.73889294e-02f, 3.01845819e-02f, 1.85242936e-01f, -6.71745092e-02f, -2.59486884e-02f, 8.94881692e-03f, -5.13307340e-02f, 8.31398591e-02f, 8.30771029e-02f, -1.66695081e-02f,
  -3.14210616e-02f, -6.13615550e-02f, 1.20681711e-02f, 1.95737481e-01f, 5.23610450e-02f, 1.20079234e-01f, 9.18995216e-02f, -1.17159635e-02f, -1.08295463e-01f, 2.07673565e-01f,
  -3.38125452e-02f, -1.09554067e-01f, 1.67034835e-01f, 1.72295928e-01f, 1.46451890e-01f, 2.14978397e-01f, 8.05424228e-02f, 1.21025093e-01f, 4.70606163e-02f, 2.37938948e-02f,
  -9.20749232e-02f, -8.43395665e-02f, -8.99962243e-03f, -9.06099975e-02f, 1.20828092e-01f, 1.03309050e-01f, 1.40117809e-01f, -7.44178146e-02f, -7.48001412e-02f, -6.42304420e-02f,
  -1.18117616e-01f, 1.88163355e-01f, 5.26952045e-03f, -4.33191992e-02f, -5.44806197e-02f, -1.27045199e-01f, 3.22195888e-01f, 6.89825043e-02f, -7.00889155e-02f, 3.35721783e-02f,
  -3.74523401e-02f, 6.65645525e-02f, -3.13507207e-02f, -7.32395649e-02f, -1.20107457e-02f, 6.71716928e-02f, 6.56332523e-02f, -1.29246831e-01f, -7.05016032e-02f, 2.12645248e-01f,
  -2.36795824e-02f, -7.01594129e-02f, -1.67875420e-02f, 1.46371111e-01f, 7.69680589e-02f, -5.80004752e-02f, 1.64488882e-01f, 4.05905247e-02f, 1.40845850e-01f, 8.08311403e-02f,
  6.37076050e-02f, 1.07996576e-01f, -8.90401229e-02f, 1.18132716e-03f, 1.88289769e-02f, -1.43887484e-02f, 9.65433642e-02f, -7.43633583e-02f, 6.00840747e-02f, 1.22466467e-01f,
  -1.07045509e-01f, -7.80046731e-02f, -5.32588139e-02f, 4.31233868e-02f, 2.19805725e-02f, -6.99997172e-02f, 1.47876590e-01f, 9.93121043e-02f, 6.64956644e-02f, 6.48810565e-02f,
  4.31216694e-02f, 5.04245162e-02f, 9.29791422e-05f, 2.44122185e-02f, 3.06310225e-02f, 2.68485636e-01f, -3.65329310e-02f, -3.76012564e-01f, 3.41621749e-02f, 2.89462119e-01f,
  -4.66583297e-02f, 1.04491860e-01f, 2.11494252e-01f, 6.28186613e-02f, 2.57118046e-01f, 1.36936292e-01f, 2.01651543e-01f, -5.10722436e-02f, -7.32607022e-02f, -1.19237535e-01f,
  -1.51804760e-01f, 2.08319247e-01f, 2.66432040e-03f, 1.44446209e-01f, 6.69224933e-02f, -3.17586213e-02f, 1.98996559e-01f, 5.81072792e-02f, 2.35291813e-02f, -9.16550085e-02f,
  -5.40905818e-02f, -5.20644933e-02f, 2.66564846e-01f, -1.14364885e-02f, -1.92975774e-02f, 8.31455290e-02f, 2.60233700e-01f, 6.15536161e-02f, 1.83007613e-01f, 1.19978316e-01f,
  -6.36900961e-02f, 1.67078212e-01f, 1.72927566e-02f, -3.96185135e-03f, 5.78029118e-02f, 1.61314145e-01f, -1.51901633e-01f, 9.78026018e-02f, 4.11944985e-02f, -1.99038982e-02f,
  -1.07794115e-02f, -2.17370540e-02f, 1.70349658e-01f, 9.33795124e-02f, 2.38750920e-01f, 1.45526916e-01f, 9.04967040e-02f, 1.51930839e-01f, 1.75706416e-01f, -1.34347081e-01f,
  -5.57091162e-02f, 1.02616973e-01f, -5.71504757e-02f, 1.00213706e-01f, 5.98876737e-02f, 9.78795439e-02f, 9.44982544e-02f, 5.87472655e-02f, 5.07080369e-03f, -3.05465758e-02f,
  -4.07247655e-02f, 8.47314447e-02f, -5.85716255e-02f, 3.02969068e-02f, -3.54252979e-02f, -9.42661315e-02f, -6.85419887e-02f, -2.69040391e-02f, 1.63252391e-02f, -1.27642751e-01f,
  -1.25747457e-01f, 1.00013494e-01f, -9.41682905e-02f, 2.27812845e-02f, -3.23717929e-02f, 1.45257488e-01f, 1.02253206e-01f, -1.09599316e-02f, 9.34788883e-02f, 9.75920334e-02f,
  2.09501982e-01f, 1.25806987e-01f, 1.65728778e-01f, -6.44308999e-02f, 9.42019373e-02f, -4.88628894e-02f, -4.65338081e-02f, 6.47370666e-02f, 1.75910071e-01f, 7.49138817e-02f,
  -4.51064669e-03f, -1.18859686e-01f, 1.13552846e-01f, -4.10162583e-02f, -4.68824841e-02f, 7.91131780e-02f, -9.23944563e-02f, 3.51329595e-02f, -1.74151465e-01f, 7.93485343e-02f,
  1.48756185e-03f, 1.56103671e-01f, 5.33382185e-02f, 2.54554898e-02f, 9.13956016e-02f, 1.40479043e-01f, 2.62051467e-02f, -3.80508192e-02f, -3.79760340e-02f, -5.16911000e-02f,
  -3.03551145e-02f, 1.77241266e-01f, 1.05093405e-01f, -4.74089794e-02f, -1.17478125e-01f, 1.18088998e-01f, -3.72971073e-02f, -1.16224058e-01f, -9.76061672e-02f, -9.71273333e-02f,
  -1.83750149e-02f, 4.06206585e-02f, -2.71418667e-03f, 1.70759764e-02f, 7.78084099e-02f, -9.37737375e-02f, 7.06064627e-02f, 8.38048607e-02f, -6.56470284e-02f, -4.35233526e-02f,
  -7.26235360e-02f, 2.78004296e-02f, -7.07276314e-02f, 6.69529662e-02f, -9.46688801e-02f, 2.26315539e-02f, 8.90727788e-02f, 5.44386730e-02f, 8.55865777e-02f, 5.88944778e-02f,
  -8.38042051e-02f, -9.27495882e-02f, -5.41062765e-02f, -3.16898269e-03f, -7.49661699e-02f, -1.55106653e-02f, -7.17062727e-02f, -4.24246602e-02f, -6.96946904e-02f, -2.95716505e-02f,
  1.03833549e-01f, 1.17218651e-01f, 9.54648554e-02f, 5.50108962e-02f, 8.44492391e-03f, 1.26245603e-01f, 6.17835075e-02f, -5.72832376e-02f, -6.04553968e-02f, 7.39976615e-02f,
  1.61532070e-02f, -2.55423412e-02f, -9.35683325e-02f, -8.68082047e-03f, -4.44178246e-02f, 2.76000146e-02f, 6.40817583e-02f, -7.82886371e-02f, -1.06237575e-01f, -1.22477330e-01f,
  3.99265476e-02f, 1.03977643e-01f, 5.77316470e-02f, -1.01889215e-01f, 2.42760386e-02f, 7.01718852e-02f, -6.04910925e-02f, -1.27522051e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  9.73433182e-02f, 2.21502811e-01f, 2.06396892e-03f, 5.45540005e-02f, 2.78940201e-01f, 1.77267082e-02f, 7.99056292e-02f, 1.76054552e-01f, -1.67780668e-02f, 8.54907110e-02f,
  6.12150468e-02f, 1.95291135e-02f, -2.69476827e-02f, 3.45627256e-02f, 2.06368625e-01f, 7.01381564e-02f, 1.85788155e-01f, 1.55640841e-01f, 7.57091418e-02f, 1.86130807e-01f,
  8.88147131e-02f, -9.32943821e-02f, -1.30763846e-02f, 4.87506166e-02f, 1.19815975e-01f, 2.04448327e-01f, 7.75557831e-02f, 1.92236781e-01f, 2.09372014e-01f, -5.54236434e-02f,
  7.38092363e-02f, 6.96957558e-02f, -3.73722240e-02f, -1.04381241e-01f, -7.34406188e-02f, 1.13914177e-01f, 1.36717588e-01f, 1.35823404e-02f, 1.38905451e-01f, 1.74615830e-02f,
  8.94970298e-02f, -6.16836250e-02f, 8.38078558e-02f, -8.72840639e-03f, 2.30573282e-01f, -3.88147794e-02f, 1.26000658e-01f, 9.10430253e-02f, 1.31176695e-01f, 1.80371255e-01f,
  -3.64687294e-02f, -8.73929262e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  8.94228742e-03f, -5.79729751e-02f, 7.60465935e-02f, 4.85826693e-02f, 5.73475994e-02f, 8.27088133e-02f, -1.51792318e-01f, -2.56792847e-02f, 3.41634229e-02f, 1.41844168e-01f,
  -1.44047245e-01f, -3.85244489e-02f, -1.39765769e-01f, -1.05481468e-01f, 8.86948928e-02f, 4.86882776e-02f, -1.52985573e-01f, -4.92242612e-02f, -7.49514401e-02f, -1.68174863e-01f,
  -1.03180677e-01f, 3.46360146e-03f, 1.06342018e-01f, 9.42268595e-03f, -6.63919598e-02f, -7.51822889e-02f, 8.23614597e-02f, -5.62031474e-03f, -3.30771320e-02f, 1.32929027e-01f,
  -7.06597092e-03f, 9.87583026e-02f, 1.30948620e-02f, 7.06976801e-02f, -1.16911724e-01f, -8.80645812e-02f, 1.12583824e-01f, -3.93204466e-02f, 1.23809762e-01f, -9.55948308e-02f,
  -1.46795642e-02f, 1.86265018e-02f, -1.55761883e-01f, 1.03554070e-01f, 1.38871968e-01f, -1.46557847e-02f, 7.44865686e-02f, -1.71215296e-01f, -3.45613225e-03f, 8.41892064e-02f,
  -4.39154766e-02f, 1.38332648e-03f, -6.90561309e-02f, 1.14041910e-01f, 8.72544795e-02f, 3.74933630e-02f, 2.96950966e-01f, -4.09744009e-02f, -1.15765892e-01f, 9.32208449e-02f,
  -6.41003624e-03f, -3.88575755e-02f, 2.64934748e-02f, 1.03782810e-01f, -9.44545045e-02f, -1.11142151e-01f, 1.13688461e-01f, -1.00133970e-01f, -2.03891136e-02f, -1.23788632e-01f,
  -6.56590164e-02f, 2.17526451e-01f, 1.54784769e-01f, -9.00885239e-02f, -6.58986792e-02f, 1.03161275e-01f, 1.77912265e-01f, -7.37254769e-02f, -1.90681801e-03f, -1.21296823e-01f,
  -1.74752295e-01f, 1.23792306e-01f, -1.02405570e-01f, 1.43743902e-01f, 1.63013220e-01f, 1.57470442e-02f, -1.43525109e-01f, -1.11290805e-01f, 7.01942444e-02f, 1.60630926e-01f,
  -9.42482948e-02f, 8.05547908e-02f, 3.24750878e-02f, 3.25766169e-02f, -1.16387121e-01f, 9.25830007e-02f, -4.79321852e-02f, 4.31012735e-02f, 1.19944043e-01f, 7.21636266e-02f,
  3.52166332e-02f, 1.61167264e-01f, -2.25449920e-01f, -1.12153940e-01f, 8.94505680e-02f, 8.36733542e-03f, 4.46879864e-03f, 4.61127684e-02f, -4.96073253e-03f, 6.65639415e-02f,
  1.84549585e-01f, 4.36575115e-02f, -2.56282330e-01f, 3.07379663e-02f, -6.75803721e-02f, 1.43115774e-01f, -1.46554559e-01f, -2.89905183e-02f, -1.13812886e-01f, -8.17779526e-02f,
  2.89412513e-02f, -9.50240642e-02f, 7.12120458e-02f, -3.40385176e-02f, -6.16956949e-02f, 1.18722178e-01f, -1.34527206e-01f, 1.14008583e-01f, 1.52334437e-01f, 3.01265027e-02f,
  1.71722725e-01f, 1.53510228e-01f, 4.39455435e-02f, 6.82192808e-03f, 1.10580869e-01f, 1.58949777e-01f, 1.33601487e-01f, -3.10209431e-02f, 7.76046067e-02f, 6.18776819e-03f,
  -8.78029987e-02f, -5.23603521e-03f, 6.10045381e-02f, -9.67051312e-02f, -6.94463402e-02f, 9.83100105e-03f, -6.49924343e-03f, -1.20770693e-01f, -5.55561855e-02f, -7.26490691e-02f,
  -9.69068483e-02f, 4.74101193e-02f, -1.91415232e-02f, -9.46665406e-02f, 8.34092032e-03f, 1.52986944e-01f, 1.08127363e-01f, 1.19447023e-01f, -3.74881364e-02f, 1.13540024e-01f,
  -1.00202665e-01f, 4.82692895e-03f, 6.54614866e-02f, -1.10683538e-01f, 3.36558037e-02f, 1.22969961e-02f, 8.12280774e-02f, 6.14858419e-02f, 8.90894681e-02f, -9.67583805e-02f,
  -1.04495808e-01f, 7.17195272e-02f, -1.91126063e-01f, 8.93920437e-02f, 6.93660602e-02f, -1.92931950e-01f, -1.35881841e-01f, -8.21361095e-02f, -5.55383749e-02f, 3.71226147e-02f,
  -2.04893380e-01f, -1.09274827e-01f, -1.47498757e-01f, 1.31604940e-01f, 2.10090056e-02f, -5.21325916e-02f, 1.17498040e-01f, -1.56606082e-02f, -8.37787241e-02f, 7.53320679e-02f,
  4.99633849e-02f, 4.77657318e-02f, 1.78317636e-01f, 1.36464745e-01f, 1.27824083e-01f, -5.45368455e-02f, -5.73761277e-02f, -2.98483688e-02f, -4.59372438e-02f, -1.52007863e-02f,
  -6.09791279e-02f, -2.41745193e-03f, -1.33363932e-01f, -1.13269225e-01f, 3.13382894e-01f, -1.80341646e-01f, 1.89103231e-01f, -2.60734856e-01f, -1.91629082e-01f, 9.43054929e-02f,
  -1.94736989e-03f, 8.67369920e-02f, 4.45898548e-02f, 2.90632173e-02f, -9.57773626e-02f, 7.92813599e-02f, 5.18012606e-02f, 3.21450420e-02f, -3.83263305e-02f, 2.02925298e-02f,
  -2.80041862e-02f, 2.64448095e-02f, 1.32020898e-02f, 1.41244590e-01f, -9.78583843e-02f, 1.49108926e-02f, -4.42689657e-02f, -5.67845181e-02f, -5.84714822e-02f, -7.94218183e-02f,
  -1.31183758e-01f, 8.47461745e-02f, 6.88097775e-02f, -2.37252656e-02f, -7.75681734e-02f, -7.63182193e-02f, -9.03582573e-02f, -3.89422625e-02f, 6.87650740e-02f, -1.48066372e-01f,
  -1.56850204e-01f, -1.09361015e-01f, -2.30215825e-02f, 1.45472258e-01f, -1.62276432e-01f, 1.26553234e-02f, -1.86553165e-01f, -1.01722196e-01f, -6.08255863e-02f, 9.95701086e-03f,
  -6.63455427e-02f, 7.86662400e-02f, 6.26883730e-02f, 2.23318309e-01f, -5.66258691e-02f, 5.33840023e-02f, 3.60533260e-02f, 7.87602067e-02f, 6.56464510e-03f, 5.09220734e-02f,
  3.37928757e-02f, -6.51851147e-02f, -1.34844463e-02f, -6.85803825e-03f, -2.21821927e-02f, -1.39748290e-01f, -2.15383619e-01f, 5.03300242e-02f, 3.89822900e-01f, 4.35473658e-02f,
  -8.94582644e-02f, 7.54971430e-03f, -2.75696158e-01f, -3.01899631e-02f, -1.54951334e-01f, -9.88562629e-02f, 7.52893314e-02f, -9.52874683e-03f, -2.89029471e-04f, 1.36952266e-01f,
  4.84408066e-02f, 5.03047816e-02f, 4.23172154e-02f, -1.24716386e-01f, 8.89626220e-02f, 7.21633956e-02f, 2.20174920e-02f, 8.75139758e-02f, -1.09238550e-01f, 6.46430328e-02f,
  -5.73015474e-02f, 3.34101589e-03f, 4.09833379e-02f, 6.57482967e-02f, -1.17124416e-01f, -1.12693608e-01f, 1.89214468e-01f, 1.54819429e-01f, -1.62485301e-01f, -1.29806846e-01f,
  -3.68309207e-02f, 1.18914783e-01f, 1.16898224e-01f, -7.17499405e-02f, -6.55113196e-04f, -9.07896832e-02f, 1.35559604e-01f, 4.49155644e-02f, -1.53704643e-01f, -1.35969417e-02f,
  -4.97935824e-02f, -3.83800245e-03f, -3.77495922e-02f, -7.83555806e-02f, 9.18780938e-02f, -2.34027300e-02f, -8.62062424e-02f, 1.70105979e-01f, 8.54306519e-02f, -5.33572882e-02f,
  9.05690268e-02f, 2.46499106e-02f, -4.67600226e-02f, -1.12151094e-02f, 6.90812096e-02f, 2.74351239e-02f, -3.57237235e-02f, -1.76561624e-01f, 1.64868921e-01f, -3.51938829e-02f,
  1.11100048e-01f, -1.36188760e-01f, -1.80674896e-01f, 2.73699939e-01f, -5.95277511e-02f, 1.72970027e-01f, -3.70383151e-02f, 4.33733687e-02f, 1.29124925e-01f, -8.55385214e-02f,
  -3.46665122e-02f, -1.53402537e-01f, 1.84394605e-02f, -6.10798597e-02f, 1.21921748e-01f, 9.16416645e-02f, 2.00602695e-01f, -6.40420541e-02f, 1.38377175e-01f, -8.97644833e-02f,
  -1.52375355e-01f, -7.21623003e-02f, -1.50520727e-01f, -7.99383819e-02f, 1.25710964e-01f, -7.34275877e-02f, 4.62981164e-02f, 2.09530126e-02f, -2.33895689e-01f, 3.16157192e-03f,
  -7.99800828e-03f, 5.11417985e-02f, -9.06013176e-02f, 5.20141870e-02f, 5.02829365e-02f, -7.93467015e-02f, -1.15015768e-01f, 1.70300659e-02f, 1.87253684e-01f, -5.92982136e-02f,
  2.00065300e-01f, -9.52884257e-02f, -1.58363283e-01f, -3.85914557e-02f, -1.07020751e-01f, 5.18450439e-02f, -1.73188105e-01f, -1.16962545e-01f, 4.87840589e-04f, -4.88319136e-02f,
  9.09993704e-03f, -7.74381533e-02f, 1.10494882e-01f, -1.19261965e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.46340698e-01f, 8.96042679e-03f, -1.15518726e-01f, -6.85417950e-02f, -1.29741848e-01f, -4.19628359e-02f, 1.06897607e-01f, 3.29043791e-02f, -6.11549728e-02f, 1.42238304e-01f,
  1.33360580e-01f, 3.62536833e-02f, -1.17479429e-01f, -3.95314731e-02f, 2.86600795e-02f, 5.73167652e-02f, 1.07541583e-01f, 6.13137968e-02f, 1.30192876e-01f, 9.41893235e-02f,
  5.33007272e-02f, -1.98790543e-02f, 8.55135992e-02f, 5.84582984e-02f, 3.11951265e-02f, 1.00741796e-01f, 2.16185916e-02f, -3.17802913e-02f, 4.01417650e-02f, -2.86136679e-02f,
  -1.24704510e-01f, 4.45345752e-02f, 1.91741198e-01f, -4.76883203e-02f, -1.80192590e-02f, 2.48449128e-02f, 7.04276040e-02f, 1.20871857e-01f, -9.10035446e-02f, -3.65398712e-02f,
  -9.04260203e-02f, 4.94777672e-02f, -2.51673516e-02f, 1.42122582e-01f, 3.59939113e-02f, 4.45702113e-02f, -5.69346063e-02f, -5.28363883e-03f, 4.63350676e-02f, 7.25514367e-02f,
  -2.94637885e-02f, -1.29437670e-01f, 2.26054057e-01f, -7.35305175e-02f, 1.07709542e-01f, -1.30760595e-01f, -7.69230127e-02f, 1.33843590e-02f, -9.69548970e-02f, -2.75401641e-02f,
  1.67261451e-01f, -6.41099215e-02f, -1.24256939e-01f, -3.58977430e-02f, 4.35443074e-02f, 7.05952793e-02f, 5.68611622e-02f, -1.61638469e-01f, -8.99449438e-02f, 5.05042858e-02f,
  -9.87368077e-02f, 7.78294131e-02f, -1.06727302e-01f, 4.18789759e-02f, 9.76012200e-02f, -9.84700304e-03f, -1.34757027e-01f, -9.17349383e-02f, 6.18184805e-02f, 1.03837267e-01f,
  7.52651915e-02f, -1.17452569e-01f, 1.60001870e-02f, 4.55281697e-02f, 6.30753860e-02f, -1.13772206e-01f, 6.14230223e-02f, -5.78816235e-02f, -2.78965458e-02f, -2.50377990e-02f,
  6.06833622e-02f, 4.26066928e-02f, 1.01427972e-01f, 5.98016009e-03f, 4.11882587e-02f, 9.50152576e-02f, -1.07246511e-01f, -1.08827174e-01f, -1.96030941e-02f, -1.14651658e-01f,
  -1.00141153e-01f, -1.25500113e-01f, -3.47553305e-02f, 9.79054943e-02f, -3.94319221e-02f, 6.51265979e-02f, -9.08030048e-02f, -6.92238808e-02f, -8.58783163e-03f, -6.62546009e-02f,
  -1.15583777e-01f, -7.72291794e-02f, -1.39878169e-01f, 3.89223695e-02f, -8.05822909e-02f, -3.80951017e-02f, 9.05116946e-02f, -1.87585913e-02f, 9.69358757e-02f, -6.85752332e-02f,
  7.75169283e-02f, 1.16043709e-01f, 1.45426346e-02f, -9.26868021e-02f, -8.43939111e-02f, -6.50708228e-02f, 8.50994959e-02f, -8.91378224e-02f, 2.16584206e-01f, 1.68097168e-01f,
  2.41646484e-01f, 1.44501612e-01f, 8.84028450e-02f, 2.11930051e-01f, 8.30587223e-02f, 2.23270446e-01f, 1.29538655e-01f, -3.61142308e-02f, -2.28065383e-02f, 3.11940253e-01f,
  1.79122165e-01f, -2.27134019e-01f, 1.57524690e-01f, -9.82170030e-02f, 1.14325635e-01f, -9.91443396e-02f, -1.81536421e-01f, 1.49959832e-01f, 3.06681897e-02f, 1.54013902e-01f,
  -5.78601621e-02f, 4.80636805e-02f, -2.40562446e-02f, -5.46744131e-02f, 1.47324890e-01f, 2.56258547e-01f, -6.94102570e-02f, -5.18241376e-02f, -2.90803704e-02f, 1.54065520e-01f,
  8.17502290e-02f, 6.10082112e-02f, 4.63169347e-03f, 1.20482169e-01f, 5.96728288e-02f, 7.82047585e-02f, 2.81802565e-01f, -2.50116666e-03f, 3.22555244e-01f, 2.52725687e-02f,
  5.36292158e-02f, 8.46595764e-02f, -8.27909485e-02f, 7.77771920e-02f, -3.19494009e-02f, -1.03312500e-01f, -1.35365143e-01f, -2.54045371e-02f, 5.32096485e-03f, 2.57338524e-01f,
  1.12505779e-02f, -3.36702093e-02f, 1.09566078e-01f, 1.86427608e-01f, 1.63463280e-01f, -7.34681860e-02f, 7.42601156e-02f, 2.74892479e-01f, 4.85906117e-02f, 8.99898037e-02f,
  7.55063863e-03f, 9.04474929e-02f, -2.59667635e-03f, 1.19061776e-01f, -1.65147372e-02f, 3.99626158e-02f, -1.26417279e-01f, -7.88086280e-02f, -1.64048765e-02f, -8.42524227e-03f,
  -1.22856587e-01f, -3.63963470e-02f, -1.85624622e-02f, -6.66122288e-02f, 2.73270905e-01f, -1.08004548e-01f, 1.04360647e-01f, -2.22969986e-02f, -1.12563334e-01f, -2.07550097e-02f,
  -4.81866784e-02f, 1.26109511e-01f, -9.87838283e-02f, 7.52476826e-02f, 6.77750334e-02f, -1.79250259e-03f, -6.36278167e-02f, -6.50257990e-02f, 3.47360149e-02f, -9.95197520e-02f,
  6.16286397e-02f, -8.85299072e-02f, 7.93047249e-02f, 7.38411099e-02f, -2.61267591e-02f, 2.10832786e-02f, 1.49833616e-02f, -7.29433894e-02f, 9.62283164e-02f, -3.98162613e-03f,
  -5.10483682e-02f, 3.28243524e-03f, 1.73807126e-02f, -9.31015536e-02f, 1.07816406e-01f, -4.99969982e-02f, -1.99018754e-02f, -8.21325257e-02f, 1.28754318e-01f, 3.24427597e-02f,
  1.25531703e-01f, 6.95729703e-02f, 1.36741415e-01f, -1.02815526e-02f, -2.39631794e-02f, -8.30941051e-02f, -5.41276066e-03f, -6.80225939e-02f, -1.53473780e-01f, -1.47068473e-02f,
  -7.83904865e-02f, -1.14757447e-02f, 7.46978670e-02f, 6.52604699e-02f, 7.20851347e-02f, 2.24052798e-02f, -8.38789269e-02f, -1.21560350e-01f, 8.68288502e-02f, -8.23722407e-02f,
  -4.25937660e-02f, -1.22593887e-01f, -9.09098908e-02f, 1.43547341e-01f, 1.13351621e-01f, -1.21212423e-01f, 6.63405880e-02f, 9.50480551e-02f, 9.97057632e-02f, -5.14215976e-02f,
  -9.22568962e-02f, -1.53668731e-01f, -1.48649309e-02f, 1.12155192e-01f, -1.31794810e-01f, -2.69094370e-02f, 4.19095112e-03f, 1.22898415e-01f, -4.52626757e-02f, -7.41354674e-02f,
  6.54866323e-02f, 3.21289385e-03f, 9.24994349e-02f, 7.98838586e-02f, -9.33945403e-02f, 1.54715776e-02f, -3.25674005e-02f, 4.81291600e-02f, -4.24284637e-02f, -1.17563538e-01f,
  -8.40982944e-02f, -4.76229936e-03f, -1.19287502e-02f, 1.18932702e-01f, 8.77386481e-02f, -9.40518454e-02f, 1.24020629e-01f, -3.79789360e-02f, -2.97015496e-02f, -5.62881120e-02f,
  -3.43549401e-02f, -2.55635194e-02f, -2.86198035e-02f, -8.97687301e-02f, -8.58152583e-02f, 8.16446356e-03f, 9.85800102e-02f, -1.72632132e-02f, 3.93868685e-02f, 4.46339995e-02f,
  -1.24001233e-02f, 1.40689999e-01f, 2.63001602e-02f, -5.07187843e-02f, 6.00866489e-02f, 1.86622769e-01f, 9.51837152e-02f, 8.98820683e-02f, 5.79466298e-02f, 5.32339774e-02f,
  -1.21842034e-01f, 2.40883082e-02f, 4.10566926e-02f, -9.70546156e-02f, -1.11007355e-01f, -7.24886507e-02f, 2.38931980e-02f, -6.14049882e-02f, 1.10741928e-01f, -1.15693584e-01f,
  -9.50942487e-02f, -7.80029520e-02f, -1.26258373e-01f, 4.18996327e-02f, -4.30096686e-02f, 1.50042800e-02f, 3.06220055e-02f, 1.70517582e-02f, -3.36605161e-02f, 8.75341520e-02f,
  1.13852367e-01f, -1.75698474e-02f, -8.18595961e-02f, -3.22795566e-03f, 2.70537194e-02f, -1.12310693e-01f, 9.49567836e-03f, 5.94142266e-02f, 6.99256826e-03f, -3.39062735e-02f,
  -1.28098419e-02f, 4.80192937e-02f, 2.54953513e-03f, 1.03685871e-01f, -1.19479865e-01f, 5.02264984e-02f, -5.39240576e-02f, -6.67189732e-02f, 1.56284854e-01f, -4.65993546e-02f,
  -5.47312424e-02f, 1.43351048e-01f, -1.06193446e-01f, 1.11417055e-01f, 1.29978195e-01f, 8.08989555e-02f, -6.79808110e-02f, -1.23228632e-01f, -3.81454676e-02f, -1.21089049e-01f,
  9.83217061e-02f, 6.24321401e-03f, -1.09365724e-01f, -9.00778025e-02f, 1.09833375e-01f, 9.69890580e-02f, 1.30105376e-01f, 2.65109586e-03f, -1.16912887e-01f, -4.25805524e-02f,
  2.58698743e-02f, 1.27014354e-01f, 1.85922006e-04f, -3.96516807e-02f, 2.48015802e-02f, 1.61400869e-01f, 3.48864943e-02f, 1.74983725e-01f, 1.89312082e-02f, 2.51253664e-01f,
  6.98866844e-02f, -8.89122337e-02f, -7.86321163e-02f, 6.67948127e-02f, 9.58687905e-03f, -2.66539037e-01f, 3.87668572e-02f, 9.82039720e-02f, 1.00137061e-02f, 1.21812951e-02f,
  2.32638195e-02f, 5.98024838e-02f, 2.78117239e-01f, -1.16071880e-01f, 1.04358166e-01f, -1.94521412e-01f, 9.22270268e-02f, -5.85155860e-02f, -1.13925979e-01f, 6.06188700e-02f,
  6.59515932e-02f, -6.00071475e-02f, 1.05026625e-01f, 1.14405580e-01f, -4.17143777e-02f, -5.97142354e-02f, -1.28270835e-02f, -5.38780577e-02f, -3.74794044e-02f, 1.31059557e-01f,
  -1.39388189e-01f, 8.82176310e-02f, 1.62529573e-02f, 1.16064958e-01f, -1.66820243e-01f, 1.87083781e-01f, 1.99601248e-01f, 3.07416432e-02f, 1.87675744e-01f, -5.42815141e-02f,
  2.75309253e-02f, 1.95977073e-02f, 2.54426092e-01f, -1.10420868e-01f, 1.57699078e-01f, 8.11827108e-02f, 2.32318819e-01f, 4.64208312e-02f, 3.88596281e-02f, -1.85421094e-01f,
  1.23900082e-02f, -6.14680164e-02f, -2.32598349e-01f, -5.58456220e-02f, 6.59916177e-02f, -3.64616178e-02f, -2.26370338e-02f, -8.87045823e-03f, 2.41282821e-01f, 2.22740307e-01f,
  1.15125008e-01f, 2.02774733e-01f, 3.18061352e-01f, 1.40839368e-01f, -2.02230010e-02f, 9.99905467e-02f, -1.12765424e-01f, -1.37662524e-02f, -2.11129457e-01f, 2.17407495e-02f,
  1.91828474e-01f, 3.28182499e-03f, 2.53184289e-01f, -2.02809766e-01f, -2.14443281e-02f, 2.49323938e-02f, 9.54064205e-02f, 9.75235030e-02f, -4.01385166e-02f, 1.31690785e-01f,
  -1.90258503e-01f, -1.50149807e-01f, -1.85887683e-02f, 1.44778460e-01f, 1.27159476e-01f, 1.08177088e-01f, 1.97186377e-02f, 1.08451918e-01f, -8.17347765e-02f, 2.30745658e-01f,
  5.48728276e-03f, -8.02035481e-02f, 1.32962137e-01f, -6.09482825e-02f, -5.47460094e-02f, 7.51807019e-02f, -1.32561579e-01f, -9.55169052e-02f, 5.66582941e-02f, 5.23851626e-02f,
  -1.24276735e-01f, 8.18219110e-02f, -7.57899657e-02f, -8.97103921e-02f, 1.06973865e-03f, -1.62697852e-01f, -2.39390075e-01f, -2.48387754e-02f, 7.58562014e-02f, 2.20252052e-01f,
  -2.10675791e-01f, 1.22844446e-02f, 1.51280928e-02f, 9.28528309e-02f, -1.27175236e-02f, 7.98539221e-02f, 1.53761342e-01f, 1.72027797e-01f, 1.73099279e-01f, 2.36253828e-01f,
  2.72294432e-02f, 1.00815054e-02f, 1.57095879e-01f, -1.07593387e-01f, -6.60227239e-02f, 1.17674887e-01f, 1.61997214e-01f, 1.37742385e-01f, 8.34158584e-02f, -1.24129139e-01f,
  -1.56999856e-01f, 4.01792005e-02f, -2.50634421e-02f, 1.28963798e-01f, 9.85954180e-02f, -8.80509987e-02f, 1.84943862e-02f, 8.28009322e-02f, 7.79987499e-02f, 9.51821283e-02f,
  -1.39364094e-01f, 5.20752817e-02f, 1.23817757e-01f, 6.90042228e-02f, 3.75244655e-02f, 8.43689740e-02f, 8.93038660e-02f, 1.99684650e-01f, -9.19111371e-02f, -1.14218108e-01f,
  -1.27132624e-01f, -2.89695673e-02f, -8.34949091e-02f, 7.35533834e-02f, -1.26579925e-01f, 9.40304622e-02f, -1.03763200e-01f, 1.18666654e-02f, 4.17014100e-02f, 4.43306938e-03f,
  1.53972119e-01f, -1.01791479e-01f, -1.49141764e-02f, 1.96442574e-01f, 1.36503680e-02f, 7.38513051e-03f, -1.19630760e-02f, 4.70579090e-03f, 1.91333797e-02f, 1.14124596e-01f,
  -1.39624178e-01f, -1.09408639e-01f, -1.11376017e-01f, 1.65594190e-01f, 5.03047444e-02f, -1.10239878e-01f, 1.05812415e-01f, 5.92207499e-02f, 1.89476863e-01f, -9.54018831e-02f,
  1.10188469e-01f, 5.97159285e-03f, -9.86780375e-02f, 1.96649089e-01f, -1.85336005e-02f, -1.76927652e-02f, -2.07752377e-01f, 9.42733213e-02f, 6.53199032e-02f, 1.17491484e-01f,
  -1.24210984e-01f, -5.52409738e-02f, -1.35608166e-01f, 2.37792972e-02f, 1.16145276e-01f, 1.63355201e-01f, -2.13543773e-01f, -1.81541681e-01f, 4.35626924e-01f, 1.45617023e-01f,
  9.55993831e-02f, -3.28415409e-02f, -1.96290895e-01f, 1.52697623e-01f, 1.18413121e-01f, 5.08247092e-02f, -3.30144726e-02f, -4.62419316e-02f, -1.23217732e-01f, 1.85347989e-01f,
  5.09061031e-02f, -1.51380792e-01f, 4.12838086e-02f, -4.28420715e-02f, -1.12921730e-01f, -1.15095071e-01f, -9.86378267e-02f, -1.54531598e-01f, -1.05906069e-01f, 9.13152844e-02f,
  7.96817318e-02f, -1.40042707e-01f, 1.62027121e-01f, 1.71792936e-02f, -2.20339358e-01f, 1.00098088e-01f, 1.82392329e-01f, -4.01903763e-02f, 1.51880130e-01f, 4.01948616e-02f,
  1.08250707e-01f, 1.06738575e-01f, 4.01278846e-02f, 2.15825766e-01f, 2.38962173e-01f, 2.05467977e-02f, 2.66099334e-01f, 5.19336499e-02f, 1.35718673e-01f, -1.27986795e-03f,
  -1.24458469e-01f, -5.64231314e-02f, -1.32101446e-01f, -8.67325626e-03f, -3.92597914e-02f, 2.41753552e-02f, 1.54101860e-03f, 1.17999529e-02f, -1.13669172e-01f, -1.03181973e-01f,
  1.51596144e-01f, -6.39310433e-03f, -4.98974621e-02f, -2.91147884e-02f, 2.59674698e-01f, 1.04895763e-01f, 2.12710984e-02f, -1.49142668e-01f, -1.84112012e-01f, -1.14541918e-01f,
  4.81969193e-02f, -2.64788792e-02f, -8.52436200e-02f, 2.26995170e-01f, -4.66501787e-02f, 1.34617269e-01f, -4.63284329e-02f, 1.35667175e-01f, -1.25736922e-01f, 1.20817780e-01f,
  -2.88242511e-02f, 1.90341920e-02f, 8.63969773e-02f, -1.03847697e-01f, 3.15574706e-02f, 2.14708924e-01f, 1.19371802e-01f, 3.60510759e-02f, 7.47630373e-02f, -4.89035808e-02f,
  7.12374132e-03f, -9.80510726e-04f, -5.90726398e-02f, -4.76756543e-02f, 5.75926751e-02f, 1.72039829e-02f, -6.42421171e-02f, -1.13449275e-01f, 2.09182546e-01f, 1.15275182e-01f,
  9.27093402e-02f, -3.76679446e-03f, 1.09607376e-01f, 3.71034220e-02f, 9.85382199e-02f, -9.70370471e-02f, 5.43768145e-02f, 5.35512306e-02f, 2.43308142e-01f, -3.43706124e-02f,
  -8.37736875e-02f, -4.44628932e-02f, 8.48442987e-02f, -1.12716228e-01f, 2.15892479e-01f, 2.77001411e-02f, 5.74655347e-02f, 7.29263127e-02f, 7.06742480e-02f, -5.50177805e-02f,
  -6.38220161e-02f, 5.45309531e-03f, 7.38544092e-02f, 7.09528774e-02f, -1.06170774e-01f, -8.20996463e-02f, 1.58218946e-02f, -8.94509032e-02f, 3.13918144e-02f, 1.16023030e-02f,
  8.52428451e-02f, 1.19797699e-01f, -6.50342479e-02f, -1.08756563e-02f, 1.28262341e-02f, -2.08746493e-02f, -5.75915091e-02f, 5.63179590e-02f, 1.01299891e-02f, 7.72146508e-02f,
  -1.04432732e-01f, 1.03907600e-01f, 2.02065930e-02f, -5.53984232e-02f, -4.02799211e-02f, -7.88089409e-02f, -8.34524538e-03f, -8.22361326e-04f, -7.89141506e-02f, -7.88684934e-02f,
  -2.89103743e-02f, -6.20755292e-02f, 5.77838207e-03f, -7.11331367e-02f, 7.44207278e-02f, 6.07015677e-02f, 4.48670052e-02f, -6.99292347e-02f, 6.71402812e-02f, 5.30332737e-02f,
  -4.82408442e-02f, 3.44187357e-02f, 4.77138944e-02f, 1.08939946e-01f, 1.93406418e-02f, -7.21951574e-02f, 3.43720056e-02f, -1.35832345e-02f, 2.79703122e-02f, -5.73779978e-02f,
  -1.05782814e-01f, 8.30411538e-02f, -2.45627351e-02f, 1.01540983e-01f, 9.15085003e-02f, 1.14603832e-01f, -9.77748539e-03f, -1.24750018e-01f, -6.91400021e-02f, -9.46934298e-02f,
  -3.19307745e-02f, -7.52951354e-02f, -3.63387242e-02f, -1.05353840e-01f, -3.51644717e-02f, 8.44755843e-02f, 2.19043568e-02f, -6.90927356e-02f, -3.82289328e-02f, 5.92293125e-03f,
  -6.90042302e-02f, -9.65146441e-03f, 3.48974555e-03f, -5.88266328e-02f, 2.28079502e-02f, 1.07385330e-01f, -1.44305709e-03f, -2.98273489e-02f, 3.56424004e-02f, -2.13877186e-02f,
  -7.26755857e-02f, -6.57093106e-03f, -8.67242813e-02f, -4.68687303e-02f, -1.22892678e-01f, -3.27778980e-02f, -5.80482148e-02f, 9.98190418e-03f, 1.00794770e-01f, 7.74653330e-02f,
  1.00164995e-01f, -4.36402224e-02f, -1.06370531e-01f, 1.17469631e-01f, -5.02529368e-02f, 1.12548426e-01f, 9.35647078e-03f, 9.83661041e-02f, -1.17439918e-01f, -9.11189094e-02f,
  -2.58738846e-02f, -1.18188284e-01f, -6.86232969e-02f, 2.57597473e-02f, 1.72657203e-02f, -4.76066694e-02f, -7.65943304e-02f, 1.21192664e-01f, 8.52096826e-02f, -7.48793781e-02f,
  -7.44555965e-02f, 6.52544573e-02f, -9.40448865e-02f, -6.31612912e-02f, -1.17013164e-01f, -1.69664901e-02f, -8.51475894e-02f, 9.42182243e-02f, 1.14874192e-01f, -4.80472967e-02f,
  1.01409398e-01f, -1.08355768e-01f, 9.63544920e-02f, -2.67401785e-02f, -8.83590132e-02f, -1.19407699e-01f, 5.91639504e-02f, -1.08510628e-01f, 4.56876867e-02f, -9.32350606e-02f,
  5.86577365e-03f, -1.04213156e-01f, 7.78826792e-03f, 9.40408707e-02f, 1.35182634e-01f, 1.12042710e-01f, -1.35177085e-02f, 2.22022682e-01f, 1.97670713e-01f, 5.21301366e-02f,
  1.67304918e-01f, 7.04121143e-02f, 2.37529010e-01f, 1.57702044e-02f, -2.37445876e-01f, 8.59457329e-02f, -1.39906690e-01f, 8.15571025e-02f, 3.96625996e-01f, -1.13029517e-02f,
  2.40325883e-01f, 1.04010567e-01f, -2.98155956e-02f, -1.07048102e-01f, -3.76240513e-03f, 4.67585623e-02f, -6.31576926e-02f, -8.77524838e-02f, 1.49843186e-01f, 6.45516962e-02f,
  1.75409660e-01f, 8.44160542e-02f, -9.02144238e-02f, -6.17210940e-02f, 1.89926058e-01f, 6.74781650e-02f, -1.17056584e-03f, -5.59378080e-02f, 1.16932213e-01f, 1.88810155e-01f,
  5.73889129e-02f, 4.02720273e-02f, 2.68514804e-03f, 1.36136878e-04f, -8.99156108e-02f, 5.87315373e-02f, -4.15729806e-02f, -4.76637445e-02f, -3.64419408e-02f, -1.31237000e-01f,
  2.33135715e-01f, 6.57283142e-03f, 6.49434999e-02f, 3.52682807e-02f, 1.21001959e-01f, 4.76990603e-02f, 7.80244474e-04f, 4.65872288e-02f, 1.67243600e-01f, -3.41854943e-03f,
  -1.43697605e-01f, 9.37439799e-02f, 1.47457466e-01f, -2.42312163e-01f, -1.24850944e-01f, 8.88958052e-02f, 3.39114554e-02f, 4.54866178e-02f, -8.69672075e-02f, 4.78882045e-02f,
  -1.39436841e-01f, -3.12706595e-03f, 1.17522284e-01f, 9.22737420e-02f, 1.19841643e-01f, -6.72055557e-02f, -6.09966218e-02f, 1.55944556e-01f, -3.04554179e-02f, 6.27018809e-02f,
  -9.97202396e-02f, 1.43599600e-01f, -1.28070945e-02f, -1.94451977e-02f, -7.49939457e-02f, -1.53080365e-02f, -2.35165134e-02f, 3.82898897e-02f, -3.22906388e-04f, 1.77477106e-01f,
  7.11108893e-02f, -4.99765724e-02f, 9.02222022e-02f, 9.00361612e-02f, 6.71560839e-02f, 1.09380417e-01f, 6.44244924e-02f, 3.33034992e-02f, 1.76910371e-01f, -1.09844819e-01f,
  4.61299494e-02f, 1.19730094e-02f, -1.42288720e-02f, 1.29098311e-01f, -5.78060150e-02f, -5.87946326e-02f, -3.90584879e-02f, -2.99151223e-02f, 9.19445977e-02f, -1.23994946e-01f,
  -9.73512903e-02f, -9.07978788e-02f, 1.67840123e-02f, 8.54982156e-03f, 2.01258719e-01f, 3.08290273e-02f, 6.26143143e-02f, -1.76240541e-02f, 5.17205559e-02f, -2.08851714e-02f,
  1.59605108e-02f, 1.37253746e-01f, -3.92241143e-02f, -4.60549584e-03f, 9.14901868e-02f, 2.02433899e-01f, -4.28000651e-03f, -2.52618659e-02f, -5.25812618e-02f, -1.24967754e-01f,
  8.20454881e-02f, 9.90390554e-02f, 6.26713708e-02f, -7.04365671e-02f, 1.13166414e-01f, 1.59378126e-02f, -6.88188672e-02f, -3.04410253e-02f, -1.68327272e-01f, 1.02929674e-01f,
  -1.66053250e-01f, -1.10253677e-01f, 3.36535513e-01f, 1.28263518e-01f, 1.33050159e-01f, -9.68054533e-02f, -1.13770075e-01f, 5.71123660e-02f, 4.96347584e-02f, 1.08756237e-01f,
  6.00129887e-02f, 7.88291171e-02f, -6.13929816e-02f, 1.40236005e-01f, -1.02747343e-01f, -1.24291562e-01f, -3.80399115e-02f, -7.55524710e-02f, -1.64408952e-01f, -5.31338826e-02f,
  -8.81789997e-02f, 1.12685177e-03f, -3.10553645e-04f, -7.24127889e-02f, 5.52838147e-02f, -1.34678736e-01f, 8.76699463e-02f, -7.15939999e-02f, -8.59322473e-02f, 3.05288993e-02f,
  -3.12675685e-02f, -5.60050681e-02f, 1.41042650e-01f, -5.29751815e-02f, 2.21239403e-03f, -1.30949374e-02f, 5.25037237e-02f, 8.58023018e-02f, -8.14617723e-02f, -1.15978997e-02f,
  -1.04374148e-01f, -1.13179334e-01f, 6.94328696e-02f, 4.08281833e-02f, 2.88212467e-02f, -9.54027474e-02f, 9.86647457e-02f, -1.11091979e-01f, 1.01805896e-01f, -3.93509306e-02f,
  -7.86090121e-02f, 3.23732257e-01f, -3.65963653e-02f, 1.16465516e-01f, 2.45466471e-01f, 9.15277377e-02f, 1.11753762e-01f, 1.98996887e-01f, 2.64732033e-01f, 2.59132743e-01f,
  3.91106345e-02f, -1.59540877e-01f, -8.84551629e-02f, -1.53044984e-01f, -1.50939813e-04f, 2.82392800e-02f, -3.34819913e-01f, 1.68763131e-01f, -9.14659426e-02f, 5.84080741e-02f,
  1.47843003e-01f, 2.38883924e-02f, -9.13975909e-02f, 1.87766645e-02f, -3.35259661e-02f, -1.59555361e-01f, -6.63182959e-02f, 7.13537335e-02f, 1.48988422e-02f, -1.15598347e-02f,
  1.71041265e-01f, 2.38475189e-01f, -6.13076463e-02f, 3.29706185e-02f, -3.69362459e-02f, 3.82250524e-03f, -1.14700183e-01f, 9.03194305e-03f, -5.00319619e-03f, -4.73214202e-02f,
  1.42196938e-01f, 3.07391174e-02f, 2.71848105e-02f, 8.59274417e-02f, 1.01787366e-01f, -5.26184738e-02f, -2.12682322e-01f, -1.20287389e-01f, 3.88743803e-02f, -3.62427011e-02f,
  8.43462795e-02f, -9.36657563e-02f, 1.99149013e-01f, 6.56610802e-02f, 7.64404088e-02f, 1.63347527e-01f, -1.31281510e-01f, 1.20098315e-01f, 9.53024626e-02f, 9.16845575e-02f,
  -7.75711436e-04f, 4.20872271e-02f, 6.10596314e-02f, 1.79561317e-01f, 1.09327905e-01f, -1.55565888e-01f, 1.42483667e-01f, 5.06903529e-02f, 2.40444586e-01f, 2.60207236e-01f,
  8.44478831e-02f, 2.08747447e-01f, 1.92409605e-01f, 5.86308613e-02f, 8.72518569e-02f, -1.03810571e-01f, -8.45477656e-02f, 5.52893756e-03f, -7.41966963e-02f, 3.09548993e-02f,
  -6.07352071e-02f, 4.36733663e-01f, -1.45641059e-01f, 2.77832687e-01f, -2.51750182e-02f, -9.28681791e-02f, -6.19766256e-03f, -6.51528016e-02f, -1.33294230e-02f, -1.16998568e-01f,
  1.73413940e-02f, -1.42851785e-01f, 1.05638832e-01f, 7.22537786e-02f, 3.48353565e-01f, 2.59624004e-01f, 8.62706378e-02f, -1.25007778e-01f, -7.72446990e-02f, -5.44808730e-02f,
  -1.70154452e-01f, 4.60441448e-02f, -1.20959133e-01f, -2.21094284e-02f, -1.67906415e-02f, -1.11988531e-02f, -4.40224223e-02f, 2.13201061e-01f, -1.26887724e-01f, 1.05440550e-01f,
  -9.78137106e-02f, -1.45491064e-02f, 1.72699302e-01f, 1.11331277e-01f, -1.61066360e-03f, 3.93992066e-02f, 4.76749301e-01f, -1.24781564e-01f, 1.88012287e-01f, -7.27430135e-02f,
  -2.24384174e-01f, -1.13739215e-01f, 2.96162479e-02f, 8.73392224e-02f, 1.52339563e-01f, 1.60224870e-01f, -1.31079033e-02f, 5.14265662e-03f, -9.76474117e-03f, -9.01194066e-02f,
  5.86873554e-02f, -1.00737875e-02f, -1.89615935e-02f, 3.14212218e-02f, -2.32826974e-02f, 4.54224795e-02f, -4.49187309e-02f, 3.99286263e-02f, -3.92378010e-02f, 6.60372451e-02f,
  5.52992262e-02f, 8.10738504e-02f, 5.51957712e-02f, 2.99328081e-02f, 6.23781048e-02f, 2.51592323e-03f, -1.00903012e-01f, -3.65675613e-02f, -3.43020335e-02f, -4.77356231e-03f,
  -1.00896806e-01f, 2.32839994e-02f, -5.82484193e-02f, 1.27569541e-01f, -1.03656434e-01f, 1.79850888e-02f, 3.49271707e-02f, 1.39371734e-02f, 7.99504369e-02f, 1.77612584e-02f,
  -1.02595545e-01f, 1.29090520e-02f, -1.11699499e-01f, 1.10827923e-01f, -1.15499854e-01f, -9.25119743e-02f, -1.24941625e-01f, 1.19045250e-01f, -5.84931532e-03f, 4.88658510e-02f,
  -3.45238782e-02f, -6.02386519e-02f, 1.35378614e-02f, -9.80885029e-02f, -9.00197476e-02f, -1.01588905e-01f, 1.76467211e-03f, -2.44803894e-02f, 9.40056518e-02f, -6.85378388e-02f,
  -7.43400827e-02f, -7.60897323e-02f, 1.07403323e-01f, -9.35505852e-02f, 5.25562018e-02f, -5.84478937e-02f, 1.34099737e-01f, 1.11781396e-01f, -6.50619268e-02f, 8.86291713e-02f,
  3.87307778e-02f, 6.74318820e-02f, 1.34623069e-02f, 5.65823214e-03f, 1.07471794e-01f, 2.41773911e-02f, -1.51821524e-01f, -1.06213666e-01f, -3.15942019e-02f, 6.41102418e-02f,
  8.57494399e-02f, -4.82631363e-02f, 4.20412458e-02f, -1.45367756e-01f, -1.47988647e-01f, 1.60867855e-01f, -8.84446651e-02f, -1.65911138e-01f, 5.59122339e-02f, 1.83901981e-01f,
  1.27441809e-01f, 2.07678288e-01f, 2.57256143e-02f, 2.98846373e-03f, 2.15598628e-01f, -7.54276440e-02f, -2.84829438e-02f, -4.00423519e-02f, -1.04404474e-02f, 4.53460664e-02f,
  -3.68970186e-02f, 1.93546548e-01f, 4.40597720e-02f, -3.30590419e-02f, 6.72016367e-02f, -3.23368721e-02f, -6.31772727e-02f, 8.16367716e-02f, 3.22816223e-02f, 5.57884350e-02f,
  -7.40121007e-02f, -2.36852504e-02f, 4.57574055e-02f, -7.41020171e-03f, -4.38519008e-02f, -4.22342457e-02f, -1.19967185e-01f, 2.02935547e-01f, -4.86972928e-02f, 8.39285180e-02f,
  6.99303150e-02f, -6.98134080e-02f, 1.35340169e-01f, 1.58029139e-01f, 1.02396784e-02f, 1.59987714e-02f, 1.28989413e-01f, -1.82165354e-02f, -4.86124121e-02f, 6.06628647e-03f,
  1.87187374e-01f, -1.69762507e-01f, 1.48547828e-01f, 1.56151950e-01f, -1.46344468e-01f, -1.41912177e-01f, 8.79317895e-02f, -1.43335387e-02f, -5.96365370e-02f, -1.21115565e-01f,
  2.44227946e-01f, 5.22147156e-02f, 2.30403662e-01f, 1.99899152e-01f, 1.96413934e-01f, 1.79779947e-01f, -5.13392873e-02f, -1.62314147e-01f, -5.88571727e-02f, -1.60894215e-01f,
  -9.99829546e-02f, 1.95814013e-01f, -5.79833314e-02f, 1.63309380e-01f, -1.88883960e-01f, 1.44575849e-01f, 1.00408226e-01f, 3.41616897e-03f, -2.57055670e-01f, -6.36734739e-02f,
  3.62797901e-02f, 6.11732788e-02f, 1.06737465e-01f, -5.26494049e-02f, -2.92260796e-02f, 7.88246468e-02f, 1.07901424e-01f, 9.73616168e-02f, -8.53881463e-02f, 7.59622529e-02f,
  -7.80408457e-02f, 1.26915872e-01f, -5.50485738e-02f, -1.56934448e-02f, -5.98457418e-02f, -5.72603866e-02f, 1.46656319e-01f, -1.53039861e-02f, 2.77335376e-01f, 7.06292689e-02f,
  -6.62433058e-02f, 1.35123655e-01f, -1.33154377e-01f, -1.13060594e-01f, 1.74682483e-01f, -8.39338079e-02f, 1.07911415e-01f, -1.68798715e-01f, 1.88566506e-01f, 9.00926441e-02f,
  -5.19832633e-02f, 9.99551415e-02f, -2.35650778e-01f, -1.10059880e-01f, 8.86500850e-02f, 1.88980386e-01f, 1.12760194e-01f, -7.42547512e-02f, 1.72716245e-01f, 4.95198667e-02f,
  -1.28541544e-01f, -9.39425081e-02f, 1.55684188e-01f, 8.83993208e-02f, 1.46988645e-01f, 1.96466774e-01f, -2.60694567e-02f, 6.53944835e-02f, 1.54394269e-01f, 1.13180690e-01f,
  -6.66935965e-02f, 2.59772558e-02f, 2.60113001e-01f, -9.04135779e-02f, 2.23385304e-01f, 1.34441823e-01f, 1.20520517e-01f, 1.60265729e-01f, 1.01979963e-01f, -4.86828722e-02f,
  2.81768769e-01f, -7.74433985e-02f, -1.01087140e-02f, 2.59375840e-01f, 3.82174067e-02f, -4.20273840e-02f, 3.59874815e-02f, 1.09185008e-02f, -3.03124543e-02f, -7.53003955e-02f,
  2.32463524e-01f, 2.46759057e-02f, 2.21489638e-01f, -1.97317917e-02f, 8.27570260e-02f, 3.14039402e-02f, 1.36641964e-01f, 1.15618862e-01f, 6.39618114e-02f, -9.67222080e-02f,
  3.61842141e-02f, 1.05223820e-01f, 7.33234584e-02f, 1.72481701e-01f, 5.27151749e-02f, -1.76636875e-01f, 6.30757585e-02f, -7.43006468e-02f, -6.72788322e-02f, -1.11768775e-01f,
  -6.95013627e-02f, 1.01723537e-01f, 1.46343037e-01f, -1.51211275e-02f, 2.34510884e-01f, 1.13847181e-01f, 2.25225054e-02f, 1.34377345e-01f, -1.66151077e-01f, 8.53661597e-02f,
  -2.22512856e-01f, 7.43004605e-02f, -3.61023210e-02f, 2.73680001e-01f, 3.01802218e-01f, -8.28818679e-02f, 1.25032529e-01f, -1.36723695e-02f, -1.01592608e-01f, 8.24089199e-02f,
  -1.20937034e-01f, -1.25911742e-01f, -7.63188526e-02f, 4.73091826e-02f, -8.49036127e-03f, -2.42535789e-02f, -8.55674073e-02f, -7.16595277e-02f, -7.41046146e-02f, -5.20197339e-02f,
  8.48045200e-02f, 1.08921453e-01f, -1.18052311e-01f, 3.13038193e-02f, -3.32557671e-02f, 6.13469034e-02f, -1.22921281e-01f, -7.15442747e-02f, -8.64829421e-02f, 7.93627426e-02f,
  -7.59194642e-02f, -1.18436009e-01f, -1.17579348e-01f, 1.20194823e-01f, 2.39815675e-02f, 2.89800260e-02f, 1.20923452e-01f, 9.36228633e-02f, -6.68223500e-02f, -4.28540707e-02f,
  -2.54049394e-02f, -2.44059768e-02f, -9.84296277e-02f, 4.39048782e-02f, 5.31278700e-02f, -5.98834828e-03f, -5.73180467e-02f, 9.60523635e-02f, -5.74614331e-02f, -5.78515306e-02f,
  4.20190208e-03f, -3.89131531e-03f, 7.14643151e-02f, 8.34760740e-02f, -2.72643715e-02f, -2.19640415e-03f, -7.61031285e-02f, -7.58342296e-02f, -3.88583331e-03f, 8.04922804e-02f,
  -7.37626553e-02f, -5.03285751e-02f, -7.45849013e-02f, 2.64271852e-02f, -6.80204183e-02f, 8.97514913e-03f, -3.56242992e-02f, 3.40435319e-02f, 8.16411003e-02f, -1.03310600e-01f,
  -8.22221935e-02f, -9.08319056e-02f, 2.79603694e-02f, 1.24639101e-01f, -1.12913907e-01f, 1.94852173e-01f, 4.78135347e-02f, -8.07601884e-02f, -1.88904747e-01f, 1.16027266e-01f,
  7.59210587e-02f, -1.38577715e-01f, -6.02878816e-02f, 1.60953283e-01f, 3.36502135e-01f, -7.26793259e-02f, 5.26819825e-02f, 9.27030444e-02f, -9.95964333e-02f, 1.26434527e-02f,
  -1.83353201e-01f, 1.80747703e-01f, 2.58026342e-03f, 1.34529978e-01f, -1.02975748e-01f, 3.91901918e-02f, 1.05907328e-01f, 2.13847086e-02f, 1.60255488e-02f, -4.00314964e-02f,
  -5.34148403e-02f, -1.47322446e-01f, 1.60291702e-01f, 1.87350318e-01f, 8.83467793e-02f, 6.51575401e-02f, 3.56046930e-02f, 3.95845734e-02f, 1.40402183e-01f, 5.87639734e-02f,
  7.77182030e-03f, 1.41261011e-01f, 1.67348132e-01f, -1.04641385e-01f, 8.13555345e-02f, -1.24444954e-01f, 1.46643698e-01f, -1.20506659e-01f, 9.94468480e-02f, 8.49166289e-02f,
  8.03649705e-03f, 1.01943262e-01f, 7.49723287e-03f, 9.27165523e-02f, -6.43096715e-02f, -7.71079361e-02f, -7.43758529e-02f, 1.78636461e-01f, -6.62959218e-02f, -1.06154615e-02f,
  2.34528735e-01f, 6.64298013e-02f, 2.98368875e-02f, 8.96405876e-02f, 1.90441176e-01f, -7.06738606e-02f, -4.15426940e-02f, -6.82695657e-02f, -8.38356987e-02f, -7.93166980e-02f,
  8.30171704e-02f, 1.31864652e-01f, 5.51775359e-02f, 8.11180919e-02f, 1.51260793e-01f, 6.49032230e-03f, 1.64853245e-01f, -1.07950419e-01f, -9.98035371e-02f, 1.08337373e-01f,
  1.02453314e-01f, -1.52883055e-02f, 8.34498405e-02f, -5.72490273e-03f, -2.17709597e-02f, -8.69999379e-02f, 4.92046447e-03f, -7.61897042e-02f, 3.32048186e-03f, -1.34121142e-02f,
  -3.76399420e-02f, -1.25130415e-01f, 1.24473475e-01f, 3.33545469e-02f, 5.06568924e-02f, -6.03869045e-03f, 9.23292637e-02f, -1.37039125e-01f, 1.43037122e-02f, -2.88227592e-02f,
  -3.46782207e-02f, 1.17674060e-02f, 7.35449567e-02f, 1.05214819e-01f, -1.07087187e-01f, 4.87251915e-02f, 7.44988173e-02f, 4.85286936e-02f, 8.66685808e-02f, 1.69445463e-02f,
  -2.04551406e-03f, 7.54646771e-03f, 2.25380939e-02f, 3.02042291e-02f, 1.34146109e-01f, 2.29512677e-02f, -3.83218825e-02f, -2.59602088e-02f, -1.16804847e-02f, 3.51785086e-02f,
  -1.03900596e-01f, -8.04925039e-02f, 4.79045063e-02f, -1.14311449e-01f, -2.72473693e-02f, -4.66404930e-02f, 7.49287382e-02f, 4.62050103e-02f, -9.17668790e-02f, -1.02372520e-01f,
  1.30770639e-01f, 8.73315986e-03f, 8.04757699e-02f, -8.12893435e-02f, 1.64323300e-01f, 1.97957799e-01f, 5.36457039e-02f, -1.50404006e-01f, -2.56387681e-01f, -1.58906952e-02f,
  -1.65891107e-02f, -5.03572561e-02f, 9.58884805e-02f, 2.14996383e-01f, 1.41643494e-01f, 5.30522428e-02f, 1.49384856e-01f, 8.38554204e-02f, 1.48100741e-02f, -7.84573331e-02f,
  1.10547364e-01f, -7.33073102e-03f, 2.63206989e-01f, 2.13015266e-02f, -2.44423188e-02f, 1.67532209e-02f, 8.20821151e-02f, 3.29616144e-02f, -5.25609143e-02f, 1.06939264e-01f,
  -3.08287912e-03f, -3.09925829e-03f, 5.14349453e-02f, -1.14347287e-01f, 8.07283968e-02f, 1.28723949e-01f, -9.91222039e-02f, -7.05584735e-02f, 2.68180609e-01f, 9.66067240e-02f,
  -1.17345825e-01f, 1.48025721e-01f, 1.69109747e-01f, -3.31772566e-02f, 2.94495821e-02f, 8.13630521e-02f, 1.24209737e-02f, 7.72880465e-02f, -5.26535176e-02f, -1.95750948e-02f,
  -1.07879370e-01f, 4.36977595e-02f, -9.90453511e-02f, 6.81584999e-02f, 1.92428008e-01f, -4.73626405e-02f, 2.67992824e-01f, -5.58534712e-02f, -5.84754124e-02f, -7.32534230e-02f,
  -1.96580231e-01f, 1.64449681e-02f, 1.22418121e-01f, -1.00627720e-01f, 1.03733398e-01f, -4.81296293e-02f, -9.65187252e-02f, 1.31290033e-02f, 1.09024636e-01f, -5.85423969e-02f,
  -1.16753541e-01f, -1.10945553e-01f, 1.16215132e-01f, -4.57973545e-03f, -1.19321011e-01f, -7.78530464e-02f, -1.24160819e-01f, 5.39653338e-02f, 2.20551193e-02f, 3.89412940e-02f,
  2.79544406e-02f, 9.18476805e-02f, 7.02089071e-02f, -1.17286839e-01f, 9.00337398e-02f, -5.28005138e-02f, -9.94019657e-02f, -5.50658107e-02f, 8.08762908e-02f, -1.44192521e-02f,
  3.37766372e-02f, -3.96212190e-02f, -1.01470895e-01f, -1.12644427e-01f, -1.06637821e-01f, 2.21366845e-02f, -1.22560494e-01f, 1.19695902e-01f, 1.16795018e-01f, 2.77896356e-02f,
  -1.69157907e-02f, -3.57007533e-02f, 5.53055517e-02f, -9.07809511e-02f, -6.29609600e-02f, -1.04021028e-01f, 5.00936992e-02f, -1.12565108e-01f, 5.75928427e-02f, 5.51896580e-02f,
  1.03996940e-01f, -1.14950404e-01f, 3.34804505e-02f, -5.30618913e-02f, -2.50235796e-02f, -4.55888361e-02f, 1.36446552e-02f, 8.37559700e-02f, 9.35354531e-02f, 1.07797839e-01f,
  8.66127461e-02f, 1.10863417e-01f, 1.06394574e-01f, -8.24595466e-02f, -3.21154781e-02f, -1.04411952e-01f, -2.90748198e-03f, -3.96375731e-02f, 3.35467756e-01f, 1.56852186e-01f,
  3.06634873e-01f, 1.63692996e-01f, 2.96044320e-01f, 2.09851876e-01f, -1.45842314e-01f, 6.49635345e-02f, 7.96829239e-02f, 8.92959833e-02f, -6.55283183e-02f, -2.46783227e-01f,
  -7.51800612e-02f, 3.73823307e-02f, 3.08424652e-01f, -1.09883316e-01f, 1.55468673e-01f, 1.35895118e-01f, 1.94205284e-01f, -2.96737589e-02f, -1.22650750e-01f, -9.31098834e-02f,
  3.98540683e-02f, 3.89231928e-02f, -1.27716750e-01f, -5.57419360e-02f, 6.87350705e-02f, 9.05028880e-02f, 1.11207999e-01f, 9.91891548e-02f, 5.22550941e-03f, 7.51239508e-02f,
  -3.73221491e-03f, -1.33013725e-02f, 7.27627873e-02f, -1.10431850e-01f, -8.20251852e-02f, 1.61187291e-01f, -1.74832761e-01f, 3.71413007e-02f, 1.17668062e-01f, 1.86055358e-02f,
  -3.25977094e-02f, 1.38429537e-01f, -1.87367380e-01f, 6.77570002e-03f, -7.29591027e-02f, -1.67664826e-01f, -2.10679203e-01f, -7.27727041e-02f, 8.27819481e-03f, 1.60015434e-01f,
  -2.67438758e-02f, 1.24122366e-01f, 2.08924949e-01f, -1.44995198e-01f, 1.41093582e-01f, -3.09778843e-02f, 1.60862524e-02f, -1.25799164e-01f, 7.00260773e-02f, 1.48756251e-01f,
  -1.83058366e-01f, -3.00236195e-02f, 3.79779339e-02f, -9.79529992e-02f, -2.47206062e-01f, -1.19917318e-01f, 1.01150842e-02f, -1.65580019e-01f, 5.84010631e-02f, 1.58402711e-01f,
  -2.12511625e-02f, 2.55129766e-02f, -4.30554897e-02f, 5.54872975e-02f, 7.76005089e-02f, 3.94222103e-02f, 1.10937893e-01f, 1.80680126e-01f, 1.31802753e-01f, 4.34613004e-02f,
  8.95556882e-02f, 1.34195060e-01f, 6.37593940e-02f, 2.79393848e-02f, 1.77605763e-01f, 2.22089469e-01f, -9.87221450e-02f, 7.03922510e-02f, -1.01686217e-01f, -2.38453015e-03f,
  -8.33033621e-02f, -1.36674240e-01f, -1.08437818e-02f, 6.44301102e-02f, 5.13512343e-02f, 5.83314188e-02f, 1.28210455e-01f, 6.58519045e-02f, 1.14507623e-01f, -6.38250113e-02f,
  9.48403329e-02f, -1.01912685e-01f, -1.19025476e-01f, 2.34753396e-02f, 2.19717950e-01f, -1.03586793e-01f, -3.13000567e-02f, 5.26244938e-02f, -3.60113499e-03f, 9.30216610e-02f,
  1.80435777e-02f, 3.04844528e-02f, 4.10494544e-02f, 5.99000230e-02f, 2.77815700e-01f, 8.51772875e-02f, 4.06642295e-02f, -1.30613238e-01f, 3.65312733e-02f, 1.06436245e-01f,
  -9.52636078e-02f, -1.37729213e-01f, 1.50366157e-01f, 9.20392051e-02f, -1.17726266e-01f, 3.13532203e-02f, 2.70475090e-01f, 4.31296602e-02f, 2.84617931e-01f, 1.33754909e-01f,
  3.17644417e-01f, 3.36976349e-01f, 8.66835862e-02f, -1.62260965e-01f, -3.13274860e-01f, -3.51526146e-03f, -1.64294407e-01f, -8.03033188e-02f, -2.41232533e-02f, 3.48084807e-01f,
  7.89902583e-02f, 1.39663205e-01f, -1.57299861e-02f, 2.10423872e-01f, 2.86297966e-02f, -1.65372670e-01f, -1.21081784e-01f, -1.46725804e-01f, 1.90649226e-01f, -1.48180842e-01f,
  8.90655518e-02f, 6.98502734e-02f, 1.26944423e-01f, -1.23895891e-01f, 7.53024220e-02f, -6.46440908e-02f, -8.12238082e-02f, 2.80262548e-02f, -1.49926275e-01f, -1.06533878e-01f,
  -9.98356193e-02f, 2.99429540e-02f, 8.46306607e-02f, -1.06751427e-01f, 1.30871728e-01f, 1.44041851e-01f, -1.22977369e-01f, 1.45323932e-01f, 6.69553727e-02f, 5.20760613e-03f,
  2.18314469e-01f, -2.43105534e-02f, -7.81196058e-02f, -1.00677922e-01f, 1.70792952e-01f, -1.10750593e-01f, -1.32762969e-01f, -2.66814735e-02f, -6.78875856e-03f, 8.69429410e-02f,
  3.96805972e-01f, 5.09428829e-02f, 2.95783252e-01f, 1.47355184e-01f, -8.29920024e-02f, -1.93822429e-01f, 1.31984819e-02f, 1.49457410e-01f, -9.96275172e-02f, -1.14384279e-01f,
  1.45678818e-02f, -4.59711009e-05f, -3.53685506e-02f, 9.04005989e-02f, 1.06828648e-03f, -1.47348419e-01f, 3.20434645e-02f, 2.08619721e-02f, 1.05471760e-01f, -9.99054238e-02f,
  -1.22610889e-01f, 1.96851596e-01f, 2.89202154e-01f, -4.54928838e-02f, 1.07389681e-01f, 9.19609666e-02f, 1.30897284e-01f, 5.11579365e-02f, 3.19325039e-03f, 2.77443469e-01f,
  -7.56084919e-02f, 5.22469580e-02f, 9.85134766e-03f, -2.60343961e-02f, 1.14953905e-01f, 7.04545453e-02f, 4.68957797e-02f, 1.49027199e-01f, 2.88756676e-02f, -1.72431767e-01f,
  9.38092265e-03f, 6.04936108e-02f, 8.88731629e-02f, 5.55330217e-02f, -1.68288276e-02f, -8.62156451e-02f, 1.83698922e-01f, -3.19065154e-02f, -1.76314227e-02f, 6.56438991e-02f,
  1.41385764e-01f, 5.83051564e-03f, -6.41124994e-02f, -5.20136091e-04f, -1.56345591e-02f, -4.76034991e-02f, 7.25819170e-02f, 1.46486714e-01f, 1.81010850e-02f, -9.81238037e-02f,
  9.35261548e-02f, 6.74357265e-02f, 1.67447794e-02f, 1.11808382e-01f, -8.46030787e-02f, 1.45278648e-01f, -1.95727512e-01f, -9.77147464e-03f, 1.12405069e-01f, 1.97929725e-01f,
  1.07931502e-01f, 4.65534851e-02f, 4.32175724e-03f, -9.84275043e-02f, 2.74883300e-01f, 2.33079359e-01f, 2.15806328e-02f, 2.17059091e-01f, 1.31036714e-01f, 1.59933716e-01f,
  -2.31328532e-01f, 1.85855497e-02f, -2.66171366e-01f, 6.52098423e-03f, -3.61052215e-01f, -2.07323894e-01f, 3.22869092e-01f, -6.55689538e-02f, 3.52840453e-01f, 5.93630411e-02f,
  -1.86108485e-01f, 1.39723033e-01f, 2.47009665e-01f, -4.33969311e-02f, -8.12365487e-02f, -5.48760295e-02f, 8.48727599e-02f, 8.52135196e-02f, -1.01637445e-01f, -9.10494290e-03f,
  -1.41469136e-01f, -2.20107049e-01f, -1.50527954e-01f, -6.64877668e-02f, 5.55174872e-02f, 7.62395784e-02f, -1.31661206e-01f, -3.59315388e-02f, 1.71846390e-01f, -5.72726876e-02f,
  -1.18152604e-01f, -7.74023384e-02f, 6.85386658e-02f, -1.08202882e-01f, -3.66055705e-02f, 1.25555143e-01f, -1.67896356e-02f, 9.96599942e-02f, -8.11274443e-03f, 3.81051376e-02f,
  -1.01571769e-01f, 1.43653557e-01f, -2.62996733e-01f, -2.61611249e-02f, -2.32281815e-03f, -7.85007998e-02f, -3.97633538e-02f, -7.27724982e-03f, 1.73789516e-01f, 1.84951955e-03f,
  3.57997209e-01f, -6.12348206e-02f, -1.03590183e-01f, -1.58426300e-01f, -1.30324751e-01f, 5.01036346e-01f, -6.27075955e-02f, 3.97240818e-02f, 1.09397985e-01f, 1.88454881e-01f,
  -4.27110754e-02f, 1.96658283e-01f, 1.48563674e-02f, -1.70266465e-03f, -2.78623309e-03f, 1.76017404e-01f, 1.66323423e-01f, 1.14938550e-01f, -1.56208098e-01f, -8.64590183e-02f,
  2.19868973e-01f, 1.23795748e-01f, 1.35292664e-01f, 5.46235368e-02f, -1.21676408e-01f, 4.70837094e-02f, 9.11176428e-02f, -8.29273090e-02f, -5.62659241e-02f, -2.80262642e-02f,
  -7.58173130e-03f, 1.57878473e-02f, 1.85527783e-02f, -1.59968153e-01f, 2.09280491e-01f, 2.27306843e-01f, 1.21701509e-01f, -5.54362833e-02f, -1.25821620e-01f, -5.62884398e-02f,
  1.38643235e-02f, -6.08147793e-02f, -3.85338254e-02f, -5.53714745e-02f, 2.82915756e-02f, -4.00664099e-02f, -8.11190605e-02f, 1.87821567e-01f, 1.29681274e-01f, -1.26823559e-01f,
  -1.44696653e-01f, -5.67879453e-02f, -1.42231748e-01f, -3.73248868e-02f, -5.38749918e-02f, -7.99653456e-02f, 7.61208683e-02f, -2.62153279e-02f, 1.51360199e-01f, 6.18857443e-02f,
  -1.21559024e-01f, 5.49998018e-04f, -2.30870962e-01f, 1.06500953e-01f, 1.31749824e-01f, 7.89837539e-03f, 1.08466171e-01f, -9.67189893e-02f, 6.26919419e-02f, -5.41476384e-02f,
  5.29720262e-02f, -1.24538653e-01f, 1.32771134e-01f, 1.25506133e-01f, 6.14949241e-02f, -6.10436909e-02f, -1.09832771e-01f, -4.42963187e-03f, 1.37538224e-01f, 2.99594980e-02f,
  4.91974205e-02f, 1.04383267e-01f, 1.11713469e-01f, 5.34533290e-03f, -4.13576886e-02f, 9.95727107e-02f, -1.24537088e-01f, 1.67428348e-02f, 1.56107336e-01f, -1.06328711e-01f,
  1.18009664e-01f, -1.04766198e-01f, -1.04606971e-01f, -4.54795882e-02f, 2.76616998e-02f, 4.41619791e-02f, -7.51006901e-02f, 4.60314490e-02f, 1.19003445e-01f, 8.97788480e-02f,
  -1.07043348e-01f, -5.95624931e-02f, 5.56060523e-02f, 3.69765796e-03f, -2.60268338e-02f, -1.13286011e-01f, -6.67944252e-02f, 3.13874185e-02f, 2.62994785e-02f, 5.75711066e-03f,
  3.49683091e-02f, 8.81133974e-02f, -2.05287877e-02f, 4.94515523e-02f, 8.97872895e-02f, 4.45197597e-02f, -6.76501542e-02f, 2.02882960e-02f, -4.77424217e-03f, 6.94295093e-02f,
  1.39273897e-01f, 5.82086146e-02f, -9.77639109e-02f, -5.22427969e-02f, -1.41327381e-02f, 9.79140550e-02f, 1.64313525e-01f, 6.33237651e-03f, 9.62603614e-02f, -9.40017030e-02f,
  -2.82182768e-02f, 5.91310896e-02f, -5.91306910e-02f, -2.37071402e-02f, 8.04340467e-02f, 4.71007973e-02f, 1.38214231e-01f, 2.03189164e-01f, 1.24248691e-01f, 1.57705516e-01f,
  1.40662298e-01f, 9.02540311e-02f, -6.77263439e-02f, -2.02734228e-02f, -5.22719845e-02f, -5.79600185e-02f, -2.14661509e-02f, 1.87797695e-01f, -2.21853554e-02f, -5.83196729e-02f,
  3.47564518e-02f, -1.81284308e-01f, -5.47994487e-02f, 5.40945381e-02f, -2.55368114e-01f, 7.89180547e-02f, -1.13486148e-01f, 1.48194835e-01f, 2.01848105e-01f, 6.50866982e-03f,
  8.65270793e-02f, -1.17233008e-01f, 6.13695495e-02f, 3.14316988e-01f, 8.74208286e-02f, 7.34179467e-02f, 2.77484339e-02f, 1.45964608e-01f, -1.62283584e-01f, 1.15608431e-01f,
  -4.94493656e-02f, 6.07213825e-02f, 2.26356313e-01f, 6.81231245e-02f, 3.37719709e-01f, 5.52703924e-02f, 2.70861566e-01f, 1.20089613e-01f, -1.88918158e-01f, -1.46494666e-02f,
  -2.63271201e-02f, -8.06435272e-02f, 3.91914286e-02f, 8.09891447e-02f, -7.66657740e-02f, 8.59422907e-02f, -2.03449398e-01f, 7.35289231e-02f, -1.56909406e-01f, -1.16690636e-01f,
  1.21127658e-01f, 2.05152646e-01f, 1.74388438e-01f, -1.51853919e-01f, 2.36706451e-01f, 1.28608271e-01f, -1.36113986e-01f, 1.82274073e-01f, -1.37796635e-02f, 6.35142326e-02f,
  -8.05798844e-02f, -1.24487847e-01f, -9.80208162e-03f, -1.19401209e-01f, 5.74104562e-02f, 2.68960837e-02f, -1.24403767e-01f, -8.68209898e-02f, 3.93831395e-02f, 6.36006743e-02f,
  7.37130716e-02f, 5.99163063e-02f, -5.19093871e-02f, 2.72246394e-02f, -1.10975891e-01f, -5.22808991e-02f, 2.58819368e-02f, -1.97237227e-02f, -2.00547185e-02f, 1.13153011e-02f,
  -6.14246167e-02f, -9.04629156e-02f, 8.78784359e-02f, 7.97733888e-02f, 1.21030703e-01f, -9.40409377e-02f, 2.30627265e-02f, 2.07131170e-02f, -9.88162830e-02f, -2.26849131e-02f,
  -1.21552795e-01f, -1.16237231e-01f, -2.76360270e-02f, -8.49714950e-02f, 9.00209844e-02f, -9.03457105e-02f, 1.14028998e-01f, 6.89816028e-02f, 2.42815465e-02f, 9.11748707e-02f,
  -6.91026226e-02f, 4.05669846e-02f, -8.45809355e-02f, -1.23258658e-01f, -3.09331212e-02f, -8.93188044e-02f, -9.01089162e-02f, -6.55325502e-02f, -1.89336650e-02f, -4.62151840e-02f,
  5.49602062e-02f, -4.74153161e-02f, 4.77996543e-02f, 7.90870413e-02f, 1.53894946e-02f, 5.98627664e-02f, -9.98080298e-02f, -1.01363055e-01f, -4.76003774e-02f, 1.15678087e-02f,
  -3.62899005e-02f, 7.17221498e-02f, 6.46962747e-02f, 2.89971828e-02f, 2.22378019e-02f, -6.88397586e-02f, 3.19315493e-02f, -6.72229528e-02f, -2.58846786e-02f, -4.02778126e-02f,
  -7.67475292e-02f, 5.58031090e-02f, -8.92442912e-02f, -6.58667609e-02f, -4.65859659e-02f, 5.15272506e-02f, -9.93378162e-02f, -8.04631636e-02f, 4.64585163e-02f, -5.75727411e-02f,
  1.14747159e-01f, 1.67637784e-02f, -7.39611760e-02f, -6.47891685e-02f, 4.68621701e-02f, -3.27020995e-02f, -1.01866484e-01f, -6.70083761e-02f, 1.11974902e-01f, -7.74137750e-02f,
  4.18506004e-02f, 5.26194721e-02f, 3.96751836e-02f, 8.04260895e-02f, 1.14401504e-01f, -1.02516972e-01f, 8.44465569e-02f, -1.15153044e-02f, -1.21254325e-01f, 1.00609995e-01f,
  -7.58241117e-02f, 1.84668954e-02f, -2.16202475e-02f, 5.53515255e-02f, 1.08285710e-01f, -1.78400576e-02f, -4.93416339e-02f, 3.46923918e-02f, -3.17325443e-02f, 2.30790451e-02f,
  -6.33563995e-02f, -8.38373080e-02f, -2.65441779e-02f, -1.14710048e-01f, -8.70555490e-02f, -1.09823443e-01f, 1.77722611e-02f, -1.06337266e-02f, -1.24626055e-01f, -9.47116390e-02f,
  -7.06707835e-02f, -8.41395855e-02f, -4.10334654e-02f, -5.74514531e-02f, -4.00663801e-02f, -2.89512165e-02f, 1.97331030e-02f, -1.52851958e-02f, -2.28231490e-01f, -6.20610528e-02f,
  -1.84324250e-01f, 1.84228849e-02f, -2.41350949e-01f, -1.96466625e-01f, -8.22541192e-02f, -1.21033965e-02f, -1.83374975e-02f, -4.53454144e-02f, -1.00974143e-01f, 3.61689739e-02f,
  2.34912530e-01f, 7.51295360e-03f, 9.22360197e-02f, 1.87767804e-01f, 2.26035733e-02f, -7.31225312e-02f, 3.49391848e-02f, 1.30773664e-01f, -3.08006071e-02f, 1.18780628e-01f,
  5.43948114e-02f, 1.21295631e-01f, -3.49474885e-02f, 1.10251516e-01f, -3.76313999e-02f, -2.19359286e-02f, -6.90515786e-02f, -5.97630739e-02f, 8.05472359e-02f, -1.02479599e-01f,
  1.61123037e-01f, -3.05216834e-02f, -6.63042068e-02f, -6.12813607e-02f, 1.52538031e-01f, 1.12262160e-01f, 6.35422766e-02f, 1.20946996e-01f, -5.83945848e-02f, 4.64247428e-02f,
  3.85862701e-02f, 1.20397516e-01f, 2.54406035e-01f, -8.10741261e-02f, 1.04647450e-01f, 1.39750019e-01f, 2.73721993e-01f, -5.08417450e-02f, 1.33752406e-01f, -1.66897580e-01f,
  2.52842844e-01f, 6.69710264e-02f, 1.13799341e-01f, 5.38969412e-03f, -1.02711454e-01f, 1.87054917e-01f, -4.63687107e-02f, -1.44000918e-01f, -8.47651809e-02f, -4.57237698e-02f,
  7.55520016e-02f, 1.66304093e-02f, 7.79706538e-02f, -1.17014453e-01f, -3.05106863e-02f, 7.02430680e-02f, 1.97206549e-02f, -7.11751655e-02f, 3.13139148e-02f, -7.07335398e-02f,
  -6.62688538e-02f, -8.09491053e-03f, -2.08350122e-02f, -4.19185497e-02f, -3.28316838e-02f, -1.19249687e-01f, -2.95417830e-02f, -1.23437434e-01f, 6.79783076e-02f, -9.58912298e-02f,
  -5.04580326e-03f, 8.36696774e-02f, 1.17434405e-01f, 1.12286925e-01f, -1.15961544e-02f, 6.33919090e-02f, 4.94732261e-02f, 1.14658259e-01f, -1.00768201e-01f, -6.39128536e-02f,
  9.55540016e-02f, -3.97608802e-02f, 7.85955042e-02f, -6.66585788e-02f, 5.73546812e-02f, -3.83712016e-02f, 1.18145064e-01f, -6.50969073e-02f, -4.03179750e-02f, -1.19163012e-02f,
  4.79344353e-02f, -1.24359550e-02f, 1.73888430e-02f, -9.34543926e-03f, -1.26245067e-01f, 1.02328286e-01f, 4.24065068e-02f, -2.96749342e-02f, -8.68415926e-03f, -5.90284429e-02f,
  3.87240574e-02f, 7.88114741e-02f, -1.15488358e-01f, 8.53208750e-02f, -1.06224127e-03f, -5.03650345e-02f, -4.40156460e-02f, 1.68039072e-02f, -4.02476527e-02f, 3.13098840e-02f,
  1.13348020e-02f, -5.34141064e-02f, -6.18931055e-02f, -7.38686100e-02f, 1.22037768e-01f, -5.68685075e-03f, 2.37557590e-01f, 5.79591841e-02f, 1.70207918e-01f, 3.90450284e-02f,
  4.56774086e-02f, 2.75284469e-01f, -3.35037261e-02f, -1.69162452e-01f, -1.54942021e-01f, 1.77666754e-01f, -1.35408774e-01f, -2.22399712e-01f, -1.54258475e-01f, 3.10216788e-02f,
  1.47371203e-01f, 1.16506889e-01f, 1.78152859e-01f, 2.24871695e-01f, 2.24933192e-01f, 6.04903921e-02f, -1.24910124e-01f, 6.58149645e-03f, 1.53090522e-01f, -3.40850689e-02f,
  -3.39466855e-02f, 1.85697407e-01f, -7.10882246e-02f, -2.18563080e-01f, -5.40217059e-03f, 2.99071111e-02f, 8.25765431e-02f, -2.64914837e-02f, 6.12428077e-02f, 8.06779787e-02f,
  1.29429087e-01f, 1.27802551e-01f, -1.22931294e-01f, -1.57866374e-01f, 2.10204244e-01f, -5.20171747e-02f, -1.10044666e-01f, 2.19474822e-01f, 1.53760225e-01f, -7.99861643e-03f,
  5.08070439e-02f, 8.76757577e-02f, -1.70065224e-01f, 2.44703256e-02f, -2.31232509e-01f, -1.07638285e-01f, -9.55820009e-02f, 5.70701659e-02f, -5.50346412e-02f, 1.01838689e-02f,
  4.00761038e-01f, 1.58592742e-02f, 3.06592077e-01f, 4.42133434e-02f, -1.14187196e-01f, -2.03258619e-02f, -2.36130022e-02f, 2.50722826e-01f, 6.89234287e-02f, -2.01928485e-02f,
  -1.39086634e-01f, -3.90490144e-02f, 1.22944675e-01f, -8.91893134e-02f, -9.49457437e-02f, -5.59501462e-02f, 6.35359213e-02f, 5.32977283e-02f, -3.50614935e-02f, -1.24078177e-01f,
  -5.93799800e-02f, -1.34976581e-02f, 1.10166468e-01f, 9.40421224e-02f, -9.39718410e-02f, -9.90460590e-02f, 8.83792192e-02f, -2.53188629e-02f, -8.07846412e-02f, 5.51666059e-02f,
  -4.94933017e-02f, 3.74084935e-02f, 7.80614018e-02f, 1.64199337e-01f, 2.65525170e-02f, -3.52422521e-02f, -3.37323099e-02f, 1.83496401e-01f, -6.27852529e-02f, -5.45790093e-03f,
  -3.19121107e-02f, 5.39550111e-02f, 6.24755546e-02f, -5.65878972e-02f, -2.79764887e-02f, 8.86781141e-02f, 1.64716005e-01f, -1.42194061e-02f, 1.34628609e-01f, 1.08743042e-01f,
  5.79415597e-02f, -1.17788287e-02f, -1.37623727e-01f, -1.19121753e-01f, 1.00488074e-01f, -8.45332816e-02f, 1.19807363e-01f, 5.70002422e-02f, 2.24354386e-01f, -4.02093083e-02f,
  -9.68968496e-03f, -8.22954178e-02f, -8.37405995e-02f, 1.00876488e-01f, -9.14442390e-02f, 2.16403808e-02f, -5.71383946e-02f, 3.96104194e-02f, 1.27379507e-01f, -5.95659427e-02f,
  -5.96912503e-02f, 6.30376041e-02f, 2.59817410e-02f, 5.76549321e-02f, -3.43228946e-03f, -3.39839645e-02f, -2.19439361e-02f, -5.59906065e-02f, -1.31419916e-02f, 8.28459263e-02f,
  -1.32019579e-01f, 7.42513314e-02f, -1.30694956e-02f, 1.22536652e-01f, 9.01418030e-02f, 7.53310993e-02f, 2.00950354e-02f, 3.65465358e-02f, -6.94087520e-02f, 6.01116456e-02f,
  -1.11981206e-01f, -3.82360928e-02f, 1.46751493e-01f, -1.08264834e-01f, -6.15267828e-02f, -3.59345749e-02f, 1.78989604e-01f, -4.33966480e-02f, -5.10390326e-02f, 1.36902750e-01f,
  -1.29002169e-01f, 1.89997896e-03f, -6.49049059e-02f, 1.53560951e-01f, -1.41494721e-03f, -3.79622243e-02f, -8.82410631e-02f, -5.20272218e-02f, -4.78255674e-02f, 9.96121094e-02f,
  -8.02164748e-02f, 1.08856663e-01f, 1.24278560e-01f, -4.98851575e-02f, 1.24531090e-01f, 1.76438779e-01f, -3.07346527e-02f, 7.97372311e-02f, 1.26317412e-01f, -2.87833475e-02f,
  -2.34900713e-02f, -3.36085483e-02f, -1.58010256e-02f, -3.34553644e-02f, 2.16670185e-02f, -9.12319049e-02f, 1.11840621e-01f, -6.88028261e-02f, -1.25787882e-02f, 5.10171019e-02f,
  2.58597106e-01f, 1.13872960e-01f, -9.18281749e-02f, -5.16280197e-02f, 9.57526043e-02f, 1.08011313e-01f, 4.92639989e-02f, 1.10302337e-01f, -4.80036512e-02f, 1.82912171e-01f,
  -1.72194272e-01f, 8.84816796e-02f, 7.27989972e-02f, -7.62867257e-02f, -2.01824069e-01f, -1.11063138e-01f, -1.00898385e-01f, 1.15288459e-01f, -5.04491143e-02f, -2.64021784e-01f,
  5.40278494e-01f, 3.56082141e-01f, 1.28490806e-01f, 2.22660094e-01f, -8.90207887e-02f, 1.06174551e-01f, 3.50606330e-02f, 1.52239680e-01f, -1.96089428e-02f, 1.87104307e-02f,
  -2.58627117e-01f, -1.15111088e-02f, 3.85022606e-03f, -1.43542051e-01f, 1.12185925e-01f, -2.07870096e-01f, 1.57942712e-01f, -2.80665338e-01f, -3.63711193e-02f, -7.17291161e-02f,
  8.59217048e-02f, 4.87825051e-02f, 4.80121821e-02f, -4.55349609e-02f, -1.02946006e-01f, 7.97219295e-03f, -3.24787527e-01f, 1.87927082e-01f, -2.57085450e-02f, -2.06821039e-01f,
  7.86333606e-02f, -6.16535656e-02f, 1.07320193e-02f, 1.02109559e-01f, 1.81841180e-01f, 1.96574628e-01f, 3.19583863e-01f, -1.20174184e-01f, 3.54050785e-01f, -2.51404911e-01f,
  -1.28981665e-01f, 5.88896908e-02f, -9.70602483e-02f, -3.96848731e-02f, -2.36056685e-01f, 1.32461652e-01f, 5.43280877e-02f, 1.72088698e-01f, 2.02960938e-01f, 1.50917649e-01f,
  7.15145394e-02f, 8.08391944e-02f, 7.04551861e-02f, -8.36275518e-02f, -3.84458564e-02f, -8.11470747e-02f, -1.42123356e-01f, -8.03901628e-02f, -1.15943387e-01f, -1.01532422e-01f,
  -1.16446137e-01f, -2.45267376e-02f, -1.91510674e-02f, 1.49249546e-02f, 6.14281297e-02f, 3.80087309e-02f, -7.58608282e-02f, 1.17227109e-02f, 2.91411020e-02f, -1.17952161e-01f,
  -9.10023227e-03f, 1.18969612e-01f, 1.38602838e-01f, -5.01026809e-02f, 9.13798995e-03f, 7.34664798e-02f, -4.38362435e-02f, -3.43846083e-02f, 6.08926117e-02f, 2.91729514e-02f,
  -2.14381777e-02f, -2.70791911e-02f, 2.96605043e-02f, 8.49932581e-02f, -3.50019410e-02f, -1.56849828e-02f, 2.25659274e-02f, -9.74827930e-02f, -1.00733759e-02f, 1.44208223e-01f,
  7.58198127e-02f, -1.65818166e-02f, 2.84378398e-02f, 8.21601152e-02f, 3.47646102e-02f, 2.00803466e-02f, 1.59900382e-01f, -1.06640086e-01f, 8.70191902e-02f, 1.87850893e-02f,
  -4.21614461e-02f, 1.26744313e-02f, 3.04086190e-02f, -7.81724826e-02f, -1.26181971e-02f, -9.46954861e-02f, 2.52229255e-03f, -6.98239431e-02f, -4.36302312e-02f, -8.57093111e-02f,
  9.89410058e-02f, 8.92515779e-02f, -3.26450355e-02f, 1.06790334e-01f, 1.18597388e-01f, 8.04805160e-02f, -7.81551376e-02f, -9.36262608e-02f, 1.23016767e-01f, 3.72570865e-02f,
  -1.49688184e-01f, 7.66508356e-02f, -1.83585703e-01f, -1.68060660e-02f, -4.58371602e-02f, -1.96215883e-02f, -1.26705855e-01f, 4.49493229e-02f, 1.06433697e-01f, 2.74214834e-01f,
  1.55983958e-02f, 1.69163942e-01f, -1.24163002e-01f, 1.69793829e-01f, 9.35638398e-02f, -8.99315029e-02f, 9.41224862e-03f, -1.48058400e-01f, 2.39532128e-01f, 1.65089265e-01f,
  -9.48635712e-02f, -4.89687920e-02f, 1.26014292e-01f, 1.61704063e-01f, -1.11309744e-01f, 6.44799992e-02f, 2.82363929e-02f, -2.96481065e-02f, -1.39656022e-01f, 4.06780243e-02f,
  -1.48694878e-02f, 8.41049477e-02f, 1.33608833e-01f, 3.93814854e-02f, 1.25454649e-01f, -9.59347561e-03f, 1.81934945e-02f, 1.29508600e-01f, 9.49465558e-02f, -9.13149491e-02f,
  1.25316396e-01f, 7.75571615e-02f, -1.96282379e-02f, -6.68577850e-02f, 3.48871589e-01f, -9.49439779e-02f, 3.65255773e-02f, -1.42853633e-01f, -1.75511166e-01f, -3.23302150e-02f,
  -3.91315296e-02f, -7.72757977e-02f, 2.58613557e-01f, -9.57261026e-03f, -1.84661429e-02f, -9.54894498e-02f, -1.38035297e-01f, 5.81556037e-02f, 1.46959737e-01f, 5.47574349e-02f,
  -8.72790590e-02f, 7.38371015e-02f, -9.97810811e-02f, 9.86289233e-02f, -4.41081375e-02f, -8.37955847e-02f, -9.29101277e-03f, -6.85503259e-02f, 1.59837934e-03f, 5.03851362e-02f,
  -5.42964712e-02f, -7.58854859e-03f, -3.48694175e-02f, -4.08223532e-02f, -1.17515698e-01f, 1.09116845e-01f, -4.87280777e-03f, -2.91977562e-02f, 8.67661908e-02f, -2.97886841e-02f,
  -1.03100412e-01f, -6.52954951e-02f, -1.10958569e-01f, -7.75605142e-02f, -9.09551382e-02f, 2.43479591e-02f, -1.17890187e-01f, 9.71331149e-02f, 3.38673554e-02f, 1.07984915e-02f,
  -1.69917345e-02f, -1.01044290e-01f, -1.58579089e-02f, -8.84994492e-02f, -5.67897782e-02f, 1.36221843e-02f, -2.48014443e-02f, -3.73191051e-02f, -5.38541488e-02f, -1.05938584e-01f,
  -6.38717189e-02f, -8.18747953e-02f, -3.83245572e-02f, -7.64622465e-02f, 5.59789091e-02f, 1.28992712e-02f, 8.10487270e-02f, 6.57171533e-02f, 1.05103336e-01f, -2.98849698e-02f,
  1.01898715e-01f, -5.09890318e-02f, -3.37496325e-02f, 6.03675395e-02f, -4.33743931e-02f, 3.69048230e-02f, -3.64720859e-02f, 3.02387178e-02f, 3.53619754e-02f, 4.52859364e-02f,
  -1.01023540e-01f, 2.03849189e-02f, 8.40109140e-02f, -2.66719311e-02f, 5.99802323e-02f, -1.17457822e-01f, -1.23775462e-02f, 4.86529097e-02f, 1.43882230e-01f, 1.60692409e-01f,
  4.19321880e-02f, 4.17204946e-02f, -1.88682452e-02f, -1.06804408e-02f, 2.74917427e-02f, -1.25834972e-01f, -8.55734795e-02f, 1.16030034e-02f, 3.10196187e-02f, 1.40419230e-01f,
  5.10211568e-03f, -8.15406069e-02f, 9.99450237e-02f, -3.45507227e-02f, 4.32198271e-02f, 1.41281128e-01f, 7.94287175e-02f, -1.42711356e-01f, -4.40418860e-03f, -9.55101289e-03f,
  -1.05586596e-01f, -8.22146982e-02f, 1.13136418e-01f, -3.24706063e-02f, 4.17199433e-02f, 6.99525401e-02f, -4.69599711e-03f, 9.90925133e-02f, 1.00888498e-01f, 2.30777282e-02f,
  -1.14013419e-01f, -1.15876786e-01f, 1.70766190e-01f, 1.75760835e-02f, -2.82879472e-02f, 8.33439976e-02f, 4.87370417e-02f, -8.63345489e-02f, -2.08241567e-02f, 5.84427305e-02f,
  1.18366927e-02f, 1.14153318e-01f, -3.74952108e-02f, 5.60470857e-02f, -1.06756259e-02f, 3.22279856e-02f, 6.96929991e-02f, 1.22306593e-01f, 1.09686300e-01f, 8.51611793e-02f,
  1.23973608e-01f, 1.00577585e-01f, 6.46924153e-02f, 9.97410938e-02f, -6.22883141e-02f, 4.71541286e-02f, 1.42007381e-01f, 6.77763298e-02f, 4.46301624e-02f, -1.60000399e-01f,
  -1.32710278e-01f, -7.38982558e-02f, -4.02298719e-02f, -6.95934659e-03f, 8.17117654e-03f, -2.34880447e-02f, -7.53903687e-02f, 3.30100246e-02f, 3.95784006e-02f, 4.46090288e-02f,
  1.69292092e-01f, 2.50735223e-01f, 1.15469351e-01f, 2.24626616e-01f, 1.86779901e-01f, -6.82650283e-02f, 2.25238189e-01f, 8.03369135e-02f, -1.71527043e-02f, 9.32870656e-02f,
  5.69809750e-02f, -9.65898857e-02f, 1.08794466e-01f, 1.75812066e-01f, -4.93783988e-02f, -2.90243477e-01f, -1.53011754e-02f, -9.94901955e-02f, -3.70815843e-02f, 9.10398960e-02f,
  1.56311944e-01f, 6.05716705e-02f, -3.25170383e-02f, -1.26525491e-01f, -1.66897118e-01f, -4.42504883e-02f, 1.93061113e-01f, 8.29135180e-02f, -2.11591363e-01f, -3.48329730e-02f,
  2.03064948e-01f, 9.05957744e-02f, 1.27543226e-01f, -5.49100749e-02f, 4.07052748e-02f, 4.40715626e-02f, 4.75773327e-02f, -4.82272170e-02f, -2.25095022e-02f, -1.56070888e-01f,
  2.60116637e-01f, 8.45707804e-02f, 2.66411513e-01f, -2.07275361e-01f, -7.64295980e-02f, 3.75855453e-02f, -1.63091421e-01f, -1.27374947e-01f, 2.94016208e-02f, 1.67813241e-01f,
  -9.58362594e-02f, 2.65910327e-02f, 1.38906449e-01f, 6.43201396e-02f, 7.26282448e-02f, 1.17425613e-01f, 5.08157350e-02f, -3.86809371e-02f, 9.47446302e-02f, 2.06429493e-02f,
  2.78601144e-02f, 6.28136098e-02f, -1.01887956e-01f, 1.71591312e-01f, 1.54506460e-01f, -4.21344303e-02f, 6.06987663e-02f, 3.48901674e-02f, 9.71887559e-02f, 4.98390719e-02f,
  1.46963429e-02f, 2.41450854e-02f, 6.65765721e-03f, 1.64106876e-01f, 6.98309690e-02f, 4.26889546e-02f, -9.33165178e-02f, 1.00709582e-02f, -1.73358187e-01f, 6.84735849e-02f,
  -1.66973889e-01f, 8.03277344e-02f, 1.31185234e-01f, 3.31109799e-02f, 6.19946383e-02f, 2.06781924e-02f, -6.14098832e-02f, 5.09159155e-02f, 9.96971205e-02f, -9.40393284e-02f,
  1.31098434e-01f, -3.44665423e-02f, 1.63215980e-01f, 7.69093484e-02f, 1.03502795e-01f, -1.53035177e-02f, -2.85787098e-02f, 1.47509603e-02f, -1.44666970e-01f, 1.27433121e-01f,
  -2.96792090e-01f, -7.33516812e-02f, -8.17555410e-04f, 1.62345424e-01f, 1.35036349e-01f, -1.08966865e-01f, 7.07102986e-03f, 6.18418083e-02f, 8.45502168e-02f, -8.36996436e-02f,
  8.53663683e-02f, 6.74242005e-02f, 2.45063147e-03f, 2.66848654e-01f, 6.54940456e-02f, -4.96105589e-02f, 1.97077915e-01f, 1.66767761e-01f, -1.20354496e-01f, 6.42324686e-02f,
  6.66061714e-02f, 1.95803598e-01f, 1.77118182e-01f, 8.94188508e-03f, 3.70873779e-01f, -8.76033232e-02f, 3.26728046e-01f, 1.05858982e-01f, -3.35555524e-01f, -3.08009926e-02f,
  -1.45296305e-02f, 8.96558613e-02f, 3.55371743e-01f, -6.45160228e-02f, 1.28309041e-01f, 2.88181186e-01f, 1.06793037e-02f, 1.28302798e-01f, -1.86688527e-01f, 4.44194712e-02f,
  7.24714398e-02f, -7.07833022e-02f, 1.95914775e-01f, 4.18553986e-02f, 1.69705525e-01f, 1.89976126e-01f, 7.63207600e-02f, 1.30646586e-01f, 3.44446182e-01f, -1.11895464e-01f,
  1.35542154e-01f, 1.25852153e-01f, -7.79565284e-03f, 2.72216171e-01f, -4.01953496e-02f, -1.37616232e-01f, 4.80100214e-02f, -5.14276549e-02f, 7.84550086e-02f, -1.91320423e-02f,
  -1.73230633e-01f, 1.95020102e-02f, 1.33740008e-01f, -2.09775958e-02f, 8.68444815e-02f, -4.32582423e-02f, 1.20182119e-01f, -3.23871486e-02f, 1.40163675e-01f, 5.77792488e-02f,
  6.36940449e-02f, 2.32111737e-02f, -1.85254782e-01f, -1.04979403e-01f, 2.09284183e-02f, 2.91513354e-01f, 2.94356257e-01f, -1.89647734e-01f, 1.19532712e-01f, -2.63366401e-02f,
  -1.41674438e-02f, 4.19460051e-02f, -1.90339342e-01f, -5.80674484e-02f, 1.03593640e-01f, -6.83770701e-02f, -5.59669286e-02f, -2.19394431e-01f, -2.58221298e-01f, -1.33012816e-01f,
  -1.78506285e-01f, 1.78434625e-01f, 3.56961489e-01f, 2.93656021e-01f, 7.91055113e-02f, 3.75758074e-02f, -2.14112327e-02f, -1.35455146e-01f, -1.37834758e-01f, 1.10289849e-01f,
  -4.91592102e-02f, 8.54657143e-02f, 1.30657732e-01f, 1.48607656e-01f, -9.99491140e-02f, 7.01808184e-02f, 1.86574478e-02f, -1.00963891e-01f, -4.06934833e-03f, -6.42443672e-02f,
  8.76336396e-02f, -7.87488893e-02f, 4.76413518e-02f, -1.04141004e-01f, 2.42974074e-03f, -5.61551787e-02f, 8.62862468e-02f, -1.41545162e-01f, 2.76260346e-01f, 3.24568246e-03f,
  -9.01432186e-02f, 3.07076313e-02f, 5.54643124e-02f, -7.86090046e-02f, 2.66770512e-01f, -8.27731565e-02f, 5.99466339e-02f, 1.89294502e-01f, 1.27221614e-01f, -1.01465121e-01f,
  2.82590725e-02f, 3.32843475e-02f, -8.51696953e-02f, 1.08186267e-02f, 2.02747330e-01f, -2.54665385e-03f, -9.32525247e-02f, -4.64717075e-02f, 1.06004149e-01f, -1.17011890e-02f,
  -4.65069972e-02f, 1.41726300e-01f, 2.29021728e-01f, -2.12894753e-02f, 2.53101476e-02f, -8.39124992e-02f, -7.44753852e-02f, 1.17449485e-01f, 9.70493034e-02f, -3.77845541e-02f,
  -1.15173824e-01f, 3.01414847e-01f, 2.05264345e-01f, 8.22593868e-02f, -5.23107639e-03f, 1.66374221e-01f, 1.16205916e-01f, -2.47699633e-01f, 1.02533892e-01f, -1.20961882e-01f,
  1.18740305e-01f, 1.56520933e-01f, -1.08562492e-01f, 1.59293786e-01f, 3.00248545e-02f, 5.31124212e-02f, 7.28936046e-02f, 1.20842516e-01f, 1.38402795e-02f, 1.13621935e-01f,
  -2.84531061e-02f, 2.47990116e-01f, -6.81570247e-02f, 1.50735587e-01f, -2.05961280e-02f, -4.50756289e-02f, 1.60450101e-01f, 5.15592955e-02f, -1.29328623e-01f, 6.84642568e-02f,
  1.91038549e-01f, 2.17634141e-01f, 8.29805583e-02f, 5.98570220e-02f, 1.72696203e-01f, -6.35244418e-03f, -1.17571183e-01f, 8.77964869e-02f, -1.45434335e-01f, -8.34853575e-02f,
  5.90235740e-02f, 8.20651129e-02f, -2.31641233e-01f, 1.47561291e-02f, -1.68681473e-01f, 1.08181365e-01f, -4.54223007e-02f, 8.52417424e-02f, -1.18599467e-01f, 1.42495230e-01f,
  1.42117321e-01f, -1.48600414e-01f, 7.90268257e-02f, 1.04041472e-01f, 1.30830243e-01f, 1.60964802e-01f, 5.71780056e-02f, 5.79107851e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  6.96227998e-02f, -1.17229737e-01f, 2.18508646e-01f, -1.03832588e-01f, -1.00819543e-01f, -4.85585779e-02f, 1.02827303e-01f, 1.45263717e-01f, 5.72109334e-02f, 1.50270030e-01f,
  -2.02656649e-02f, 2.36027241e-02f, 6.84127733e-02f, 1.83585986e-01f, 1.08805642e-01f, 1.16385989e-01f, 1.96257651e-01f, 1.42424107e-01f, -2.97496691e-02f, -2.75258031e-02f,
  1.40197098e-01f, 1.99505851e-01f, 4.39735092e-02f, 7.42947310e-02f, -9.00487006e-02f, -5.62323555e-02f, -9.72590819e-02f, 2.13263839e-01f, -3.31482179e-02f, 1.21134281e-01f,
  -1.42970961e-02f, 1.39061794e-01f, 6.72615319e-02f, -7.83834085e-02f, 1.42022550e-01f, 3.69455945e-03f, 9.44406241e-02f, 8.24261457e-03f, 1.73231401e-02f, 9.75622535e-02f,
  -1.15006194e-01f, 9.81869102e-02f, 2.02741940e-02f, -9.66435820e-02f, -2.69448292e-02f, -9.02161300e-02f, 4.55007888e-02f, 8.94308314e-02f, -1.04095921e-01f, 1.13307253e-01f,
  -5.56172878e-02f, 1.23630110e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.66839471e-02f, -1.86950386e-01f, -3.22871268e-01f, -2.17196167e-01f, -3.02107006e-01f, -2.53206789e-01f, 1.02135234e-01f, -4.73256409e-03f, 4.03328501e-02f, -2.38404498e-01f,
  9.21009704e-02f, 2.53329277e-01f, -7.55865797e-02f, 6.45158067e-02f, -6.16302609e-01f, -1.14031389e-01f, -1.01023816e-01f, 3.95928361e-02f, -6.54926598e-02f, -4.37443018e-01f,
  1.04221128e-01f, 7.36141354e-02f, 1.97553888e-01f, -8.32980424e-02f, -4.02085222e-02f, -1.22968726e-01f, 1.09514548e-02f, 3.58624868e-02f, -2.47174263e-01f, 2.97954947e-01f,
  -6.65042922e-02f, 3.14451456e-01f, 7.45676830e-02f, -3.32386285e-01f, 6.10423507e-03f, -3.79266478e-02f, -1.16333507e-01f, 1.94468424e-01f, -5.62188476e-02f, -5.55954516e-01f,
  1.58182204e-01f, 4.27149907e-02f, -6.45082816e-02f, 7.76168853e-02f, -2.67333491e-03f, 1.92697681e-02f, -2.99717844e-01f, 8.28973502e-02f, -1.16949908e-01f, 2.12353915e-01f,
  -6.50733709e-02f, 4.20044065e-02f, 6.66488754e-03f, 8.61562341e-02f, 3.35992038e-01f, 1.01165995e-01f, 3.02161872e-01f, -8.16010088e-02f, 8.46085995e-02f, 3.31593692e-01f,
  -9.67119932e-02f, -2.27576479e-01f, 4.14328158e-01f, -3.57882455e-02f, 1.60274077e-02f, 3.31469983e-01f, -1.63349256e-01f, 7.05813840e-02f, -4.08452779e-01f, -4.32181694e-02f,
  -6.96947873e-02f, 7.95932338e-02f, -2.46337086e-01f, 3.68203133e-01f, 1.85507312e-01f, 2.11398806e-02f, -4.66493517e-02f, -3.44838314e-02f, -3.54695350e-01f, 3.35974187e-01f,
  -1.43746838e-01f, -1.05334237e-01f, 1.65934265e-01f, -1.86473846e-01f, -1.83712065e-01f, 5.50232947e-01f, -1.65867284e-01f, 6.04738146e-02f, 4.81167175e-02f, -3.33838642e-01f,
  3.35325859e-02f, 1.53988093e-01f, -3.53126615e-01f, 2.48920228e-02f, -5.24150990e-02f, 8.90019089e-02f, -2.71033317e-01f, -2.73878444e-02f, 1.09234370e-01f, 1.77288681e-01f,
  3.09248585e-02f, -2.41436094e-01f, 3.66357639e-02f, -2.99266219e-01f, 9.99501795e-02f, -1.96614027e-01f, 3.00122444e-02f, 1.27194166e-01f, 1.44240558e-01f, -1.27397299e-01f,
  -3.27711672e-01f, 1.14209652e-01f, -5.24548814e-02f, 4.51691240e-01f, 6.35459498e-02f, -3.45408440e-01f, 7.75616020e-02f, 1.24544268e-02f, 7.46117890e-01f, 1.41056299e-01f,
  2.10118443e-01f, -1.36308856e-02f, -2.19607547e-01f, 8.58904719e-02f, -2.52307206e-01f, -1.71596408e-01f, 2.62444198e-01f, -2.81112641e-01f, 2.09784940e-01f, -3.36805098e-02f,
  2.23161489e-01f, 1.10024206e-01f, 2.77032226e-01f, 1.38057279e-03f, -2.34764721e-02f, -1.09569579e-01f, 8.58047977e-02f, -9.48929489e-02f, 5.32980170e-03f, 4.42124367e-01f,
  -2.69915074e-01f, 7.71469176e-02f, -6.47028238e-02f, 8.74012634e-02f, -1.07496925e-01f, -4.51322608e-02f, 1.84742078e-01f, -5.04446728e-03f, -2.43367314e-01f, 2.08123386e-01f,
  2.68227011e-01f, 8.08396563e-03f, 3.91156636e-02f, 6.88722134e-02f, 2.82338336e-02f, -1.25911966e-01f, 4.07063872e-01f, 6.26492620e-01f, 6.61636516e-02f, -8.55301023e-02f,
  2.75332749e-01f, 8.61867890e-02f, 8.55167508e-02f, -1.31071344e-01f, 8.70760977e-02f, 3.81326899e-02f, 7.15543749e-04f, 1.79210842e-01f, -2.25470632e-01f, 2.91085094e-01f,
  -3.40197422e-02f, -3.79876584e-01f, 3.73120755e-01f, 3.43361832e-02f, 2.07737938e-01f, -5.18695675e-02f, -3.31613421e-03f, -9.59538743e-02f, 5.60444593e-03f, -2.35809714e-01f,
  1.50940210e-01f, -4.66921292e-02f, 1.84437066e-01f, -1.13810867e-01f, 2.41390765e-01f, -3.68273444e-02f, -1.96054205e-01f, -3.73179048e-01f, -1.94887772e-01f, -2.06274822e-01f,
  -2.42130101e-01f, -1.16286620e-01f, -2.02275142e-01f, -1.77256837e-01f, 6.13055751e-02f, -3.22926827e-02f, -1.37365311e-01f, 9.60906819e-02f, 8.60861018e-02f, -4.51099984e-02f,
  6.18975721e-02f, 9.19619109e-03f, 1.58003002e-01f, -2.49996006e-01f, -1.49930000e-01f, -5.20841107e-02f, 3.61596227e-01f, -6.95374375e-03f, -3.16069275e-02f, 5.54473922e-02f,
  -1.33714348e-01f, -1.46877140e-01f, 2.98047066e-01f, -2.57184714e-01f, 1.38397500e-01f, -2.13370863e-02f, 4.40545417e-02f, -6.23782240e-02f, 2.37872172e-02f, -1.22406501e-02f,
  2.86345273e-01f, 2.41086975e-01f, 3.84635553e-02f, -2.67310143e-01f, 5.61346710e-01f, -1.40939713e-01f, 1.18260570e-01f, -6.38193125e-03f, -1.37467742e-01f, 1.89945310e-01f,
  -1.69345513e-01f, -3.19717169e-01f, -1.50810510e-01f, 1.58979833e-01f, -8.13743621e-02f, -5.34559004e-02f, -4.37306985e-02f, 8.70374888e-02f, 5.56755185e-01f, 6.55519590e-02f,
  -3.02292444e-02f, -9.72786769e-02f, 1.21868327e-01f, -7.68176019e-02f, 2.31806859e-01f, 5.62167168e-02f, -4.13079381e-01f, 5.38601726e-02f, 1.96862713e-01f, -5.20411432e-02f,
  1.02733979e-02f, -1.69196784e-01f, 9.00697112e-02f, -3.76146913e-01f, 3.29113275e-01f, 1.51863070e-02f, -1.15976989e-01f, -9.69752595e-02f, -1.84491679e-01f, 1.37624323e-01f,
  2.50859112e-01f, -3.78019437e-02f, 8.17527026e-02f, -1.42785862e-01f, -9.82932672e-02f, -2.53900856e-01f, -5.12609370e-02f, -3.01280990e-02f, -9.88733023e-02f, -4.35991436e-02f,
  -2.37619981e-01f, -7.88517445e-02f, 2.26128101e-02f, 5.27042896e-02f, 3.37654561e-01f, 8.75176340e-02f, 3.25586706e-01f, -3.56167257e-01f, 2.20363960e-01f, -6.25911504e-02f,
  3.24828289e-02f, -1.34086713e-01f, -2.52571732e-01f, -4.80960496e-02f, 6.36798963e-02f, 1.44490646e-02f, 1.24506660e-01f, 3.32226634e-01f, 1.54709622e-01f, -4.02977586e-01f,
  -3.28023247e-02f, -2.82825232e-01f, -1.16398446e-01f, 3.65621269e-01f, 4.96675633e-03f, 1.95334598e-01f, -1.51673928e-02f, 4.77086097e-01f, -3.49451333e-01f, 2.28847906e-01f,
  -3.16599280e-01f, -3.70118506e-02f, -5.22910655e-02f, -2.57421974e-02f, -3.51728424e-02f, -1.05446555e-01f, 2.26093978e-02f, 4.97580558e-01f, -2.40626946e-01f, 1.81550369e-01f,
  -3.67062002e-01f, 4.71225157e-02f, 7.54967481e-02f, -5.74969314e-02f, 1.69703066e-01f, 7.99083859e-02f, -1.09127991e-01f, -5.43499403e-02f, 8.38377625e-02f, -1.31945342e-01f,
  1.46925032e-01f, 1.66159570e-01f, 5.40136211e-02f, -2.25021373e-02f, -7.31687900e-03f, 5.48745804e-02f, -1.68269381e-01f, -8.92464146e-02f, 2.50197779e-02f, 3.16856772e-01f,
  2.26305425e-02f, -6.28924444e-02f, 9.13032237e-03f, -3.26985568e-02f, -5.70145622e-02f, 4.94636483e-02f, -1.08812131e-01f, -1.28411949e-01f, 9.56121236e-02f, 3.51071835e-01f,
  1.24265470e-01f, 3.64528894e-02f, 1.65721495e-02f, 5.21369353e-02f, -1.04049407e-01f, -2.50891834e-01f, -1.48633555e-01f, 4.20329511e-01f, -1.90830186e-01f, -1.30656794e-01f,
  4.11423631e-02f, -3.68359722e-02f, -1.44624889e-01f, 2.67434726e-03f, 5.39728962e-02f, -5.59288710e-02f, 8.23829174e-02f, 1.74957454e-01f, -1.04475424e-01f, 2.97286421e-01f,
  1.19689122e-01f, 2.54356712e-01f, -1.27356395e-03f, 5.92356563e-01f, 3.25085670e-02f, -9.40540507e-02f, -6.91436455e-02f, -5.72672337e-02f, -1.11131392e-01f, -2.47076079e-01f,
  3.97298001e-02f, 2.89624453e-01f, -2.34010413e-01f, -2.08014801e-01f, 4.61219311e-01f, -9.25774425e-02f, -3.09681952e-01f, -5.64680323e-02f, 1.25284657e-01f, 2.67403156e-01f,
  1.49875045e-01f, -2.02735618e-01f, 2.34861672e-01f, -3.32021892e-01f, 1.34791017e-01f, 5.92942536e-02f, 3.13358307e-01f, 2.59268373e-01f, 2.17905521e-01f, 2.63716787e-01f,
  -9.65813175e-02f, -2.79527664e-01f, 3.18326131e-02f, -3.25379282e-01f, -3.27464968e-01f, 3.63323450e-01f, 1.36942655e-01f, -1.24812722e-02f, 1.14494778e-01f, -1.65050402e-01f,
  -1.48786545e-01f, 1.99333914e-02f, 1.46983445e-01f, -1.46451863e-02f, -4.43663821e-02f, 1.45373377e-03f, -2.84964263e-01f, 5.47122732e-02f, -2.50563156e-02f, 5.54284036e-01f,
  2.62643605e-01f, -2.14512482e-01f, 1.87276885e-01f, -7.30231702e-02f, -1.11648589e-01f, -8.38430449e-02f, -2.37900406e-01f, 4.05548126e-01f, 8.54530632e-02f, -2.38204345e-01f,
  1.29969269e-01f, -3.65434617e-01f, -2.91862283e-02f, 1.36199877e-01f, -3.70794535e-02f, -6.34802818e-01f, -9.88290925e-03f, -2.84388751e-01f, 1.10071220e-01f, -6.89621223e-03f,
  -3.82140994e-01f, -4.00520824e-02f, -8.56045783e-02f, -1.97570831e-01f, 1.74113885e-02f, -4.41057593e-01f, -2.82038376e-02f, -1.37249857e-01f, 1.06150150e-01f, -1.39905125e-01f,
  -3.13414305e-01f, -7.94345364e-02f, -6.27027974e-02f, -1.71067566e-01f, -2.27626160e-01f, 7.76059508e-01f, -4.08458591e-01f, 1.14836380e-01f, -1.09633140e-01f, -1.49161890e-01f,
  -2.60706812e-01f, -1.26042604e-01f, -3.07728369e-02f, -3.25336158e-01f, -1.61926389e-01f, -3.14245895e-02f, -5.93801364e-02f, -3.16407412e-01f, -3.48060697e-01f, -2.16422319e-01f,
  7.61685446e-02f, -5.45627736e-02f, 1.79469988e-01f, 7.61930570e-02f, 5.84277660e-02f, 8.48612860e-02f, -7.90901203e-03f, -3.18559021e-01f, 9.81280804e-02f, -3.71230990e-02f,
  1.36561990e-01f, -4.01894934e-03f, -5.70662022e-02f, 8.66837651e-02f, 1.49785936e-01f, 3.45630161e-02f, -2.79171020e-01f, -4.70082462e-01f, 4.42560855e-03f, -4.06406447e-02f,
  -3.99366081e-01f, 8.12974870e-02f, 1.26902774e-01f, 5.84784001e-02f, -6.75758868e-02f, 9.75490883e-02f, -3.70593593e-02f, -2.42578104e-01f, 4.96109515e-01f, -3.37081611e-01f,
  2.55844772e-01f, -1.56487480e-01f, -2.95956433e-01f, -2.29835305e-02f, 2.35865433e-02f, -5.20321913e-02f, -1.21034101e-01f, 4.25368130e-01f, -5.44122197e-02f, -1.79494649e-01f,
  3.60792950e-02f, 1.19392887e-01f, -2.56768882e-01f, 8.64617229e-02f, -1.56915620e-01f, 3.75989564e-02f, -4.96611521e-02f, 2.89906681e-01f, 1.99983314e-01f, 2.12771371e-01f,
  1.15058124e-01f, 3.04445684e-01f, 1.00401312e-01f, -2.15296999e-01f, 2.30144620e-01f, -2.32456058e-01f, -1.18046120e-01f, -6.03528619e-02f, 1.02608437e-02f, 3.86648893e-01f,
  -2.86542065e-02f, 2.97881871e-01f, 2.00177059e-01f, -1.80432335e-01f, 2.80944109e-02f, 1.73414778e-02f, 3.21890533e-01f, 1.64776698e-01f, 1.96486428e-01f, 1.03664570e-01f,
  -3.94560903e-01f, 4.20086145e-01f, 1.71942726e-01f, 1.91611111e-01f, -2.43246078e-01f, 1.22611895e-01f, 6.92879874e-03f, -2.65789062e-01f, -9.79797915e-02f, 1.95223466e-01f,
  -3.00997198e-01f, -4.20788854e-01f, 1.27904400e-01f, -2.16729596e-01f, -1.72072664e-01f, 6.03836849e-02f, -6.24697320e-02f, 2.67712116e-01f, 5.39517812e-02f, -2.70278811e-01f,
  -7.54193291e-02f, 7.12366179e-02f, -2.72919238e-02f, -3.60710084e-01f, 2.73284316e-01f, -4.73114708e-03f, 2.54475400e-02f, -9.73323286e-02f, 8.18061680e-02f, -1.14451610e-01f,
  8.66392478e-02f, 2.53636744e-02f, 9.81378928e-02f, -1.78669155e-01f, 8.97781625e-02f, 2.64519826e-02f, 1.54479027e-01f, 2.04108097e-02f, -2.40079418e-01f, -1.14753321e-01f,
  -8.88416097e-02f, -1.20110862e-01f, 2.85316080e-01f, -1.78620279e-01f, -1.08270757e-01f, 4.41482574e-01f, 1.04642501e-02f, -5.23447096e-02f, -1.94645654e-02f, -1.84712678e-01f,
  2.87956502e-02f, 1.95820734e-01f, 1.46852145e-02f, -9.91697982e-02f, -1.46966845e-01f, -2.21204549e-01f, -3.56618732e-01f, 8.64762366e-02f, 2.48845562e-01f, -1.18806273e-01f,
  -1.79490909e-01f, -1.04356848e-03f, 3.42585292e-04f, -2.46323887e-02f, 4.32260960e-01f, -2.52037704e-01f, -2.03907922e-01f, -2.55474806e-01f, 7.78232440e-02f, -1.12638250e-02f,
  -9.90003645e-02f, 5.15437722e-01f, -3.34703475e-02f, -1.53190404e-01f, 3.99202332e-02f, 2.44500011e-01f, 4.44928929e-02f, 8.49618465e-02f, -1.01238191e-01f, 1.48569822e-01f,
  -5.73506802e-02f, -4.54277068e-01f, 1.15751900e-01f, 1.31915480e-01f, -1.44662289e-02f, 8.41398165e-02f, 3.27956602e-02f, 2.63866633e-01f, -2.58575022e-01f, -3.70690078e-01f,
  -2.36850798e-01f, 1.92533970e-01f, -3.01156104e-01f, 1.21118777e-01f, 3.57927978e-02f, 1.06734678e-01f, 1.21497303e-01f, 3.05893421e-01f, -3.49098668e-02f, 9.06147510e-02f,
  -9.67104733e-02f, -1.17516816e-01f, -1.17422983e-01f, 8.74720812e-02f, 1.26897708e-01f, 4.55625862e-01f, -8.87459368e-02f, 2.64667332e-01f, -2.66157687e-01f, -3.61841857e-01f,
  -1.11855999e-01f, 1.30714893e-01f, 2.44033471e-01f, -1.44759631e-02f, 3.65981944e-02f, -1.02213591e-01f, 2.70263851e-01f, 2.88956255e-01f, 3.25936705e-01f, 3.47645253e-01f,
  1.58237040e-01f, -3.30055684e-01f, 9.90616456e-02f, -1.14780575e-01f, 1.55636370e-01f, -2.01601833e-01f, -5.15610259e-03f, 9.13120285e-02f, -3.76884192e-02f, 1.52410060e-01f,
  6.29990622e-02f, 6.41744435e-02f, -3.18413824e-01f, -1.23044372e-01f, 5.03586940e-02f, 3.37904599e-03f, -8.64280388e-02f, 1.85452566e-01f, -2.27378055e-01f, -3.66174459e-01f,
  -8.57383013e-02f, -3.33431847e-02f, -1.07554391e-01f, -5.11812091e-01f, -1.02974087e-01f, -1.22779064e-01f, -6.38450161e-02f, 1.35775611e-01f, -1.25958800e-01f, 4.42124099e-01f,
  5.86514212e-02f, 7.69840330e-02f, -2.81843364e-01f, 6.80096447e-01f, 1.86150014e-01f, 4.40455377e-02f, 2.98280627e-01f, -1.23735979e-01f, -1.16287649e-03f, -2.88182169e-01f,
  6.75914958e-02f, 4.09258097e-01f, -3.48758176e-02f, 2.42777735e-01f, -4.89585876e-01f, 1.29582686e-02f, 2.39256695e-01f, 8.32900032e-02f, -1.35892937e-02f, -2.82597512e-01f,
  1.86614886e-01f, -3.39180410e-01f, -3.05117846e-01f, 2.52744794e-01f, 4.87084351e-02f, 2.15678856e-01f, 2.18393043e-01f, 3.19254816e-01f, 1.67488083e-01f, 3.04443836e-01f,
  -1.02071844e-01f, 2.04553589e-01f, 1.46093428e-01f, 5.19057624e-02f, 8.67995396e-02f, -4.27954309e-02f, -2.09707066e-01f, 5.82547598e-02f, 3.82863522e-01f, -1.64898727e-02f,
  2.24782944e-01f, 1.08538466e-02f, -3.35579962e-01f, 3.88963759e-01f, -9.70675983e-03f, -4.13536787e-01f, 6.19434342e-02f, -3.29941101e-02f, -1.03435442e-01f, -5.09602763e-02f,
  1.83833733e-01f, -3.12832505e-01f, 1.69576496e-01f, 6.24857098e-02f, 1.47301555e-01f, -2.37850547e-01f, 2.23069787e-01f, 2.91200787e-01f, 5.77534214e-02f, 3.34235787e-01f,
  -1.50739729e-01f, -1.59216970e-01f, 6.59092218e-02f, -1.13017671e-01f, -2.37317726e-01f, -3.36033255e-01f, 1.93326935e-01f, -4.13652182e-01f, -6.33345917e-02f, -1.45053774e-01f,
  3.26393485e-01f, -4.16145325e-02f, 1.14774182e-01f, -1.89949110e-01f, 1.16446547e-01f, -1.55026361e-01f, -5.08984886e-02f, -1.77002326e-01f, 1.00540938e-02f, 7.41413683e-02f,
  -2.77918696e-01f, 1.17322639e-01f, 2.44482923e-02f, -2.20341057e-01f, 2.42277663e-02f, 4.34749156e-01f, -9.62963700e-03f, 1.38933524e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.47023126e-01f, -1.15390709e-02f, 1.86383314e-02f, 2.95525528e-02f, -6.89278543e-02f, -5.51202856e-02f, 2.23685633e-02f, -1.38177291e-01f, 3.52984779e-02f, 1.25400409e-01f,
  1.19408511e-01f, -2.27047596e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    