/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.64929342e-01f, 2.06109812e-03f, 2.56810300e-02f, -8.74707941e-03f, -3.19269866e-01f, -1.55245081e-01f, 1.35202199e-01f, -1.04675535e-02f, -1.37167633e-01f, -1.68362595e-02f,
  1.45983174e-02f, 3.35918814e-02f, 1.48192883e-01f, 2.85747927e-02f, 3.76670152e-01f, -7.55881425e-03f, 4.13039848e-02f, 4.22652245e-01f, 1.85243219e-01f, -1.56234369e-01f,
  -3.00016224e-01f, 1.23766564e-01f, 2.15227559e-01f, 1.32244051e-01f, -1.59768820e-01f, -4.57083210e-02f, -1.04999477e-02f, -3.94389257e-02f, -7.08518550e-02f, -1.98685005e-01f,
  1.22408919e-01f, 1.63657255e-02f, 3.02502960e-02f, 4.32198457e-02f, -2.68440414e-02f, 3.27445120e-02f, -3.35587049e-03f, -2.72607654e-02f, -3.89966555e-02f, -6.56765848e-02f,
  -6.17081150e-02f, -1.41044825e-01f, -3.53989825e-02f, -1.07477084e-01f, -1.80528872e-02f, -3.31591554e-02f, -8.04806724e-02f, 8.02179575e-02f, 1.56885773e-01f, 1.00846365e-02f,
  -1.22964092e-01f, -9.19211507e-02f, 8.07948112e-02f, -9.14162695e-02f, -2.34078132e-02f, -5.01623712e-02f, 1.41277639e-02f, -7.91007653e-03f, 1.33315012e-01f, 1.54254988e-01f,
  -7.87688326e-03f, 6.27549365e-02f, -2.21997332e-02f, 6.92681782e-03f, 6.28964230e-03f, 2.45457310e-02f, -1.79739564e-03f, 1.81542654e-02f, -1.08760551e-01f, 1.33105159e-01f,
  -1.17496751e-01f, 1.93196051e-02f, -9.99393389e-02f, 1.09244823e-01f, 1.18694520e-02f, 1.37924692e-02f, 1.59385484e-02f, 7.62750432e-02f, 4.56105061e-02f, 4.73424979e-02f,
  4.28440683e-02f, -5.52887768e-02f, -6.28843606e-02f, -1.28842946e-02f, 1.85445212e-02f, 7.41178617e-02f, -2.18132455e-02f, 3.95629369e-02f, -7.40032774e-05f, -8.50660875e-02f,
  1.86405852e-01f, -3.47016081e-02f, 1.35745749e-01f, 6.51256740e-02f, -9.85110365e-03f, -2.81244125e-02f, 7.14207366e-02f, -6.48038015e-02f, 5.83217777e-02f, 1.17975429e-01f,
  3.87203209e-02f, 1.52784482e-01f, -9.22141969e-03f, -1.70376413e-02f, 5.76017760e-02f, -2.76033534e-04f, 1.15278987e-02f, 8.19997936e-02f, -4.03020941e-02f, -5.41697927e-02f,
  1.22762891e-02f, 2.60389209e-01f, 2.33546853e-01f, 1.04147546e-01f, -7.28497398e-04f, 2.40892500e-01f, 9.09224227e-02f, 2.11302508e-02f, 1.79833889e-01f, 2.53273487e-01f,
  2.54122347e-01f, 9.16453674e-02f, 5.25650620e-01f, 3.74717891e-01f, 3.48526746e-01f, 3.12100589e-01f, 3.51151854e-01f, 3.50294024e-01f, 1.25207290e-01f, 1.89350083e-01f,
  -3.03462408e-02f, -2.70050645e-01f, -2.57391214e-01f, -2.19546825e-01f, -8.43794867e-02f, 1.12369537e-01f, 2.19492763e-01f, 6.02956638e-02f, 1.68727115e-01f, 3.24794859e-01f,
  1.20696828e-01f, 1.45478666e-01f, 2.87281461e-02f, 1.09400459e-01f, 1.18980423e-01f, -3.55382375e-02f, -4.55847196e-02f, 6.48284554e-02f, -9.10492018e-02f, 1.45248711e-01f,
  1.37656450e-01f, 1.54655308e-01f, 7.43838251e-02f, -8.88027027e-02f, -3.67310382e-02f, -3.71700265e-02f, 1.19279400e-02f, 1.04146861e-01f, -5.58557250e-02f, 1.04406297e-01f,
  8.09235796e-02f, -9.00312234e-03f, 5.12468964e-02f, -3.49948555e-02f, 1.62399821e-02f, 2.76779756e-02f, 1.48911238e-01f, 1.57273844e-01f, -1.13396898e-01f, 1.17534455e-02f,
  2.88835280e-02f, 1.69486761e-01f, 8.19132701e-02f, 6.85831234e-02f, 7.73436949e-02f, -6.88616633e-02f, 3.05697415e-02f, 8.21500272e-02f, 9.33568776e-02f, -6.32364489e-03f,
  3.94940749e-02f, -1.71759412e-01f, 9.00969803e-02f, 9.99416783e-02f, -1.99800208e-02f, 5.26451655e-02f, -3.59056029e-03f, -5.70902675e-02f, 7.45202079e-02f, -6.73915818e-02f,
  -8.44697580e-02f, -7.73651004e-02f, -7.90822208e-02f, 1.07437454e-01f, 9.97695373e-04f, -1.93227958e-02f, -7.42184892e-02f, -6.86435867e-03f, -1.67084523e-02f, -4.66175973e-02f,
  -5.79590164e-02f, 6.49009347e-02f, -2.10648309e-02f, -1.27408942e-02f, 6.82231560e-02f, 2.72144489e-02f, 1.03331618e-01f, 2.65542530e-02f, 3.34976614e-02f, -7.28970394e-02f,
  -2.17709303e-01f, -7.91072398e-02f, -5.62282652e-02f, 2.16821358e-02f, 5.50131872e-02f, -1.36013612e-01f, -1.89827144e-01f, -1.47588504e-02f, -2.00250417e-01f, -2.25335639e-02f,
  -4.58215028e-02f, -4.30361815e-02f, -1.06225207e-01f, -6.03892133e-02f, -1.52494973e-02f, 5.09459786e-02f, 3.72877531e-02f, -1.41782816e-02f, 4.57193004e-03f, -1.64513990e-01f,
  -5.90223558e-02f, -2.28325967e-02f, -5.40255494e-02f, -8.03255439e-02f, -1.27556041e-01f, -3.52842547e-02f, -5.45357727e-02f, -6.83381632e-02f, -4.59542274e-02f, -1.20404400e-01f,
  3.44165951e-01f, 9.35890079e-02f, -2.00789571e-01f, -3.89396138e-02f, -1.56547502e-01f, -9.72671956e-02f, 4.54633057e-01f, 1.44204021e-01f, -5.78038506e-02f, 2.30988026e-01f,
  -1.98249191e-01f, -2.72023022e-01f, -1.50576264e-01f, -1.61301449e-01f, -2.57107969e-02f, 2.81083941e-01f, 1.16212271e-01f, -5.21839969e-02f, -2.41640545e-02f, 7.39289680e-03f,
  -1.03824392e-01f, 1.62036680e-02f, -1.23262353e-01f, -8.44152346e-02f, 3.67540866e-02f, 6.64517954e-02f, 4.48182188e-02f, -2.28372842e-01f, -3.19130085e-02f, -7.93194547e-02f,
  -6.56735599e-02f, 3.80770932e-03f, 1.43420756e-01f, -2.74481662e-02f, -1.18079439e-01f, 1.11571513e-01f, -2.02977993e-02f, -2.30538640e-02f, -1.20648313e-02f, 2.77143009e-02f,
  -1.31490529e-01f, -6.57434687e-02f, -1.10305987e-01f, -1.79056749e-01f, -4.90571894e-02f, -5.20086624e-02f, -7.72402659e-02f, 3.87907289e-02f, -3.44250798e-02f, 1.39982507e-01f,
  1.22907385e-02f, -1.00321986e-01f, -9.13251191e-02f, 5.11825383e-02f, -1.29904956e-01f, -1.82438552e-01f, -1.34285942e-01f, -7.57350102e-02f, -1.24737859e-01f, 3.51979993e-02f,
  5.61370403e-02f, 4.44330685e-02f, -3.59404907e-02f, -3.60147655e-02f, 2.87899394e-02f, -7.11601079e-02f, -1.29988501e-02f, 3.38827893e-02f, -9.91161726e-03f, 9.12863240e-02f,
  -7.71974623e-02f, 1.66107956e-02f, 5.65804401e-03f, 1.96630582e-02f, 3.06214616e-02f, -6.19991235e-02f, 4.07418348e-02f, 5.19668907e-02f, -8.92821774e-02f, 5.95090771e-03f,
  -3.46400030e-02f, -1.26134539e-02f, -4.64371145e-02f, 4.74057198e-02f, 2.96054152e-03f, -3.65519151e-02f, -5.12338467e-02f, 1.71331055e-02f, 7.04861507e-02f, -2.25392487e-02f,
  1.80359900e-01f, -1.83442950e-01f, 8.35634395e-02f, 9.32776034e-02f, -5.58104087e-03f, -6.05198927e-02f, -2.10139970e-03f, -2.88429763e-02f, -3.08639631e-02f, -2.19493005e-02f,
  3.78562883e-02f, 6.98897168e-02f, 3.68641131e-02f, 5.49490638e-02f, 1.87138747e-02f, 5.54728284e-02f, 4.65371236e-02f, 5.81478924e-02f, 1.14182280e-02f, -2.43461020e-02f,
  5.52070960e-02f, 1.18129499e-01f, 2.25351304e-01f, 1.19113371e-01f, -1.63627472e-02f, 1.42044365e-01f, 1.51482821e-01f, 1.58244222e-01f, 1.43375263e-01f, 4.93507564e-01f,
  3.92985493e-01f, 3.58157009e-01f, -3.62613350e-01f, 3.65369111e-01f, -4.02920187e-01f, -4.84241605e-01f, -4.31312799e-01f, -1.20581789e-02f, 2.05313012e-01f, -3.87173109e-02f,
  -1.29390061e-01f, 8.98881163e-03f, 8.85962322e-02f, 1.23703137e-01f, 1.39735997e-01f, 6.43409938e-02f, 1.60087466e-01f, -4.41204309e-02f, -4.84731913e-01f, -3.42977047e-01f,
  4.19960432e-02f, 1.50181338e-01f, 2.47936204e-01f, 1.12286374e-01f, 4.62258793e-02f, -1.17809540e-02f, -5.07497229e-02f, 1.31863192e-01f, 9.12133530e-02f, 2.71278501e-01f,
  4.18403465e-03f, 9.33520347e-02f, 3.77398171e-02f, 7.73554817e-02f, -4.35923822e-02f, 7.38424733e-02f, -2.60039903e-02f, 8.08792114e-02f, -7.30324015e-02f, -2.51821578e-02f,
  -5.45284003e-02f, 2.36138571e-02f, -4.93192710e-02f, 2.58560944e-02f, 2.39910092e-02f, -4.44052517e-02f, 6.34148344e-02f, 1.56063810e-01f, 6.80155903e-02f, -6.74153641e-02f,
  1.73480790e-02f, -3.81345712e-02f, -9.06924754e-02f, -1.49306720e-02f, -8.28498229e-03f, 5.19141438e-04f, -3.36614884e-02f, 1.05982199e-01f, -7.37855735e-04f, 1.67072505e-01f,
  3.91709208e-02f, 6.35836050e-02f, -4.41410840e-02f, 9.96605679e-03f, -6.65663090e-03f, -9.06670615e-02f, 6.89000040e-02f, 3.39294644e-03f, 1.41418977e-02f, -5.49047813e-02f,
  -6.42593205e-02f, 7.24499002e-02f, 1.32876239e-03f, -8.09974372e-02f, -3.49717289e-02f, 2.26319227e-02f, -1.13620818e-01f, 5.64376339e-02f, 9.83781666e-02f, -2.61124298e-02f,
  1.93245970e-02f, -1.14254619e-03f, -6.78008869e-02f, -2.02044118e-02f, 6.12527393e-02f, 4.94823977e-03f, 2.48851627e-02f, -6.18654676e-02f, -4.55556549e-02f, 4.45654839e-02f,
  2.38050111e-02f, 4.59708041e-03f, 9.74267945e-02f, 4.53672335e-02f, 1.20318048e-01f, 6.88493624e-02f, 7.51875564e-02f, 1.19168594e-01f, 9.19990912e-02f, 4.65525873e-02f,
  -8.58140960e-02f, 8.52088723e-03f, 7.63360225e-03f, 8.20768848e-02f, -7.18385279e-02f, -7.46484846e-02f, 7.79510885e-02f, -1.48350835e-01f, 3.67240347e-02f, 9.70514938e-02f,
  3.16840149e-02f, -3.50243263e-02f, -7.56223947e-02f, -2.86573395e-02f, 4.77902889e-02f, -5.89687899e-02f, -1.02271050e-01f, -8.70925859e-02f, -8.68022665e-02f, -1.49882928e-01f,
  4.24186856e-01f, 7.06311017e-02f, 8.21842924e-02f, 7.44383335e-02f, -1.07116021e-01f, -2.42889803e-02f, 1.80920586e-02f, -1.14870317e-01f, -6.14107959e-02f, 1.54921576e-01f,
  7.22098500e-02f, -3.16366196e-01f, -1.52045920e-01f, -3.18699777e-01f, -1.07114494e-01f, 1.13036960e-01f, -2.48119924e-02f, -4.46530059e-02f, -1.34539962e-01f, 4.96653132e-02f,
  1.07862390e-04f, 2.38839477e-01f, 1.76909730e-01f, -1.05358399e-01f, 1.48742586e-01f, -2.32518822e-01f, 7.32404664e-02f, 1.42805144e-01f, 2.89739203e-03f, 1.48466185e-01f,
  2.05329403e-01f, 2.27924734e-01f, -1.76518589e-01f, -9.68861058e-02f, 1.13818698e-01f, 1.68581963e-01f, 7.62884542e-02f, 1.24856710e-01f, -3.23642716e-02f, 1.43903121e-01f,
  6.77118916e-03f, -7.44490772e-02f, -2.12970059e-02f, 4.94140340e-03f, 1.37357607e-01f, 2.83916909e-02f, 1.00898026e-02f, -4.59567346e-02f, -4.17565294e-02f, 4.60951254e-02f,
  1.40776346e-02f, 6.79827929e-02f, 1.37258336e-01f, -1.53726548e-01f, -7.02914372e-02f, -1.45348161e-01f, -7.42810429e-04f, 1.23816486e-02f, -1.38274297e-01f, 1.00432545e-01f,
  -4.87701409e-02f, 2.46147066e-02f, -3.72384372e-03f, 1.28231356e-02f, -2.23848447e-02f, -2.85191904e-03f, -1.67821664e-02f, -3.57002541e-02f, -6.20721094e-02f, 9.20255184e-02f,
  -4.60576043e-02f, 6.94617955e-03f, -7.14082911e-04f, 4.34684716e-02f, -4.27201800e-02f, 2.89748907e-02f, -2.10207496e-02f, -5.87530481e-03f, -1.50775202e-02f, 4.92479128e-04f,
  1.42496768e-02f, -7.78908581e-02f, 6.94172382e-02f, 7.62864156e-03f, -3.06276381e-02f, -7.28477836e-02f, 1.52577823e-02f, -5.55211194e-02f, -5.90666942e-03f, 6.72724247e-02f,
  5.46497405e-02f, -3.47308725e-01f, 3.40861529e-02f, -1.41263092e-02f, 3.39826457e-02f, -7.09591433e-02f, -2.17073187e-02f, -3.95395420e-02f, 1.90813448e-02f, -1.93297751e-02f,
  2.77397316e-02f, 7.87371711e-04f, 2.09313426e-02f, -7.22705154e-03f, -4.69106715e-03f, -8.65262747e-03f, 3.52208540e-02f, 1.76154636e-03f, -5.84004521e-02f, 7.34243765e-02f,
  -3.78655866e-02f, 2.81313788e-02f, 5.95978759e-02f, -1.45956054e-02f, -1.92260407e-02f, -7.17522018e-03f, 2.57700421e-02f, 1.63397063e-02f, -1.88817047e-02f, 1.26873165e-01f,
  3.59071404e-01f, 1.37352690e-01f, 8.08231160e-02f, 3.29950303e-01f, 7.45728437e-04f, -1.54293194e-01f, -1.25811130e-01f, -1.20223545e-01f, -2.44515911e-02f, 2.44653702e-01f,
  1.29807368e-01f, 4.61804420e-02f, 1.94426924e-01f, 2.94108223e-02f, -3.34037542e-02f, 1.95427448e-01f, 1.98630705e-01f, 5.46613783e-02f, -3.49346638e-01f, -3.82321686e-01f,
  -9.33331624e-02f, 1.01059318e-01f, -5.08771203e-02f, -2.62864113e-01f, 5.67115545e-02f, 1.39240041e-01f, 4.27600473e-01f, 1.49818420e-01f, -5.19011803e-02f, 6.24184787e-01f,
  2.26654500e-01f, -7.80261680e-02f, -5.39941527e-02f, 2.16422863e-02f, 6.81481287e-02f, -6.11627214e-02f, -8.77200514e-02f, -7.08746840e-04f, 1.71167962e-02f, -2.54549999e-02f,
  9.16634426e-02f, -4.96707335e-02f, -9.99784023e-02f, 2.76065338e-02f, -5.01611643e-02f, -7.27104023e-02f, -3.63993980e-02f, -3.46370041e-02f, 8.90757702e-03f, -3.25365504e-03f,
  5.97420819e-02f, 1.41926883e-02f, -5.36057279e-02f, -4.38548625e-02f, -1.48600176e-01f, -7.28562176e-02f, -5.22198603e-02f, -8.27308893e-02f, -3.07648722e-02f, 1.66014686e-01f,
  3.42438626e-03f, 3.38183679e-02f, 2.59708501e-02f, -6.36476129e-02f, 1.84496287e-02f, 3.06527852e-03f, 4.51330692e-02f, 5.69062792e-02f, 2.70381048e-02f, -2.79389285e-02f,
  -4.07476500e-02f, 4.82822284e-02f, -8.71464461e-02f, -3.51159014e-02f, 7.68582225e-02f, -7.42824096e-03f, 4.37622257e-02f, -3.39722005e-03f, 6.51972964e-02f, -3.50720920e-02f,
  -4.62989211e-02f, 9.60936995e-06f, -3.62674221e-02f, -5.33343889e-02f, 5.95854409e-02f, -9.34405066e-03f, -4.69917245e-03f, -2.15130355e-02f, -5.26865013e-02f, -1.98063962e-02f,
  1.55070290e-01f, 5.16347289e-02f, 1.23050056e-01f, 1.17149099e-03f, 9.29056294e-03f, -9.69323143e-03f, 1.29895359e-01f, -2.35806815e-02f, 4.97535206e-02f, 8.49341974e-02f,
  -1.34499362e-02f, 2.09966190e-02f, 7.22896755e-02f, 1.70755349e-02f, -3.28298435e-02f, 5.05787097e-02f, 1.56769436e-02f, 5.91757745e-02f, -2.41595525e-02f, -2.15817224e-02f,
  7.12859584e-03f, 7.71884769e-02f, 1.44417174e-02f, 5.48747703e-02f, 3.46808285e-02f, 7.70360753e-02f, 1.29608348e-01f, 4.50073136e-03f, -4.40680683e-02f, 1.26876682e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.58102364e-03f, 1.49189577e-01f, -6.18766665e-01f, 4.38517630e-01f, 1.52217835e-01f, -2.31513325e-02f, -2.11161107e-01f, 2.07374826e-01f, 3.70624334e-01f, -8.17175210e-02f,
  2.45719731e-01f, 2.14243561e-01f, -3.30535769e-01f, -1.04233429e-01f, -6.80678904e-01f, -5.50875604e-01f, -5.40859044e-01f, -8.11115980e-01f, -5.74884951e-01f, 1.38755832e-02f,
  6.98048025e-02f, -1.18958153e-01f, -2.14465946e-01f, -2.76484378e-02f, 4.28891093e-01f, 6.05313070e-02f, -2.29653135e-01f, 3.55895655e-03f, -3.44386809e-02f, -5.89864589e-02f,
  -2.44060650e-01f, 6.93315268e-03f, -6.15075491e-02f, 2.68856108e-01f, 9.55752879e-02f, -1.44086275e-02f, -1.09156638e-01f, -1.50607660e-01f, 1.97409913e-02f, -1.59585536e-01f,
  6.57514557e-02f, 1.88176215e-01f, -2.32256114e-01f, 4.35259640e-02f, -8.75200033e-02f, 3.03562302e-02f, -7.24153370e-02f, -1.54834449e-01f, -1.45010307e-01f, 5.86107224e-02f,
  1.90159827e-01f, -1.50108129e-01f, -2.26131931e-01f, 1.76933691e-01f, -7.03650117e-02f, -1.67529657e-02f, 1.05884701e-01f, 3.01364601e-01f, -1.69860706e-01f, 1.84787467e-01f,
  4.23854478e-02f, -1.06727267e-02f, -3.95493553e-04f, 8.43471810e-02f, -1.83593854e-02f, -8.44071433e-02f, 1.15833590e-02f, 2.69392021e-02f, -5.35217300e-02f, 7.06522241e-02f,
  3.23612662e-03f, -4.50786054e-02f, -1.27449706e-02f, -7.50072077e-02f, -3.33824530e-02f, 5.74895889e-02f, 5.67067116e-02f, -3.57735641e-02f, -1.51096985e-01f, 5.25460616e-02f,
  4.48825508e-02f, -3.83252874e-02f, -1.32277841e-02f, -1.74417190e-04f, -5.45032881e-03f, 6.00265376e-02f, -4.83427383e-03f, 9.84916538e-02f, 8.40981081e-02f, 1.18978936e-02f,
  2.27221265e-01f, -2.09235176e-01f, -1.25116467e-01f, -4.49793637e-02f, -1.16750464e-01f, 9.83092114e-02f, 2.10891843e-01f, 3.16921771e-02f, 5.22774868e-02f, 8.09303224e-02f,
  8.07596967e-02f, -1.18737318e-01f, -3.61308977e-02f, 6.32515252e-02f, -1.24056451e-01f, -4.83576953e-03f, 1.09782696e-01f, -5.08757755e-02f, 1.76844113e-02f, 3.63972157e-01f,
  1.17438495e-01f, 1.02883242e-01f, -7.39754215e-02f, -8.20110589e-02f, 3.69275510e-02f, -2.24182710e-01f, -2.50386238e-01f, 5.20911068e-02f, -2.27105334e-01f, -1.02854870e-01f,
  -9.63271797e-01f, 2.35924780e-01f, -1.74067095e-01f, -7.45064497e-01f, -2.71119505e-01f, 1.02342330e-01f, -5.14211878e-02f, 6.03922643e-02f, -6.39913827e-02f, -1.79172531e-01f,
  1.37122005e-01f, 1.36743365e-02f, -1.14103958e-01f, 5.53936213e-02f, 1.42002463e-01f, -7.62606561e-02f, -2.88784206e-01f, -2.49807790e-01f, -2.94835940e-02f, 2.19010010e-01f,
  1.30545616e-01f, -4.47613209e-01f, -4.38783675e-01f, 3.97669524e-02f, -5.19412719e-02f, -2.10087392e-02f, -3.36060315e-01f, -1.37194142e-01f, 3.38357627e-01f, -3.72906238e-01f,
  1.18157871e-01f, 1.01962969e-01f, -6.99420124e-02f, -1.59700915e-01f, 2.31833383e-02f, 1.47701353e-01f, 1.27360243e-02f, -1.64267689e-01f, 8.85478929e-02f, 1.11952750e-03f,
  -2.26365015e-01f, 2.60669850e-02f, -2.37873733e-01f, 2.88955700e-02f, -3.17222513e-02f, -6.66199997e-02f, -4.48796600e-02f, -9.13472921e-02f, -1.10454209e-01f, 1.14592820e-01f,
  1.19948156e-01f, 2.82233208e-02f, -1.46132987e-02f, 1.18319891e-01f, 2.35448807e-01f, -2.84487195e-02f, 1.52516559e-01f, 1.62463546e-01f, 1.13232009e-01f, 4.44748290e-02f,
  -3.66511904e-02f, 1.55556396e-01f, 2.70871315e-02f, 5.32632358e-02f, -6.75450936e-02f, -5.43870293e-02f, -3.12743671e-02f, 3.89936427e-03f, -1.92250479e-02f, -3.26430537e-02f,
  -5.87755851e-02f, 2.62484215e-02f, 1.99365057e-02f, -5.86636364e-02f, -3.15723792e-02f, -2.56432425e-02f, -2.03596167e-02f, -3.44974324e-02f, 1.05388515e-01f, -1.39421821e-01f,
  -5.08333417e-03f, 7.48379081e-02f, -3.79244685e-02f, 7.16595352e-02f, 1.24578392e-02f, -2.59271413e-02f, -3.76683138e-02f, 1.33890659e-01f, -2.13848986e-02f, 8.37787986e-03f,
  -1.55671299e-01f, 1.09432288e-01f, -8.11689422e-02f, 1.55772522e-01f, 8.52038246e-03f, 1.54766040e-02f, 1.38859532e-03f, 1.93084314e-01f, -5.37130870e-02f, 4.76914681e-02f,
  1.21302173e-01f, 3.23547013e-02f, -2.08806582e-02f, 8.91114697e-02f, -5.68328910e-02f, 1.91593301e-02f, 1.61822531e-02f, -1.35976136e-01f, 1.29249334e-01f, 9.37918127e-02f,
  4.93236668e-02f, 4.51934859e-02f, -1.15658581e-01f, -1.48106530e-01f, 3.48983891e-02f, -4.65138815e-02f, 9.47457626e-02f, 2.23093033e-02f, -1.20994728e-02f, -9.72130820e-02f,
  -5.81107177e-02f, -1.16476096e-01f, 4.28514123e-01f, -1.19752124e-01f, 2.72262216e-01f, 3.01813602e-01f, 2.91074008e-01f, 3.80578116e-02f, -1.94254983e-02f, 8.62299204e-02f,
  -1.13925617e-02f, -1.68595295e-02f, 2.32278779e-02f, 1.18811235e-01f, 6.74317777e-02f, 1.26278862e-01f, 3.34618464e-02f, -4.71386909e-02f, 1.24340557e-01f, 2.78257906e-01f,
  -1.51728496e-01f, -2.94225693e-01f, -3.87727857e-01f, -6.67899698e-02f, 1.23183914e-01f, 1.71561524e-01f, 1.57141939e-01f, -1.28324702e-01f, 1.02100335e-01f, -2.45535836e-01f,
  5.55133224e-01f, -1.57838443e-03f, 3.37806523e-01f, -2.67072935e-02f, 6.80315867e-02f, 1.97808757e-01f, -6.78391242e-03f, 1.34764403e-01f, 8.70917365e-02f, -1.33173048e-01f,
  -4.94347624e-02f, -1.84472695e-01f, -5.15008569e-02f, -1.70630679e-01f, -1.12802908e-01f, 3.91129218e-03f, -1.28362566e-01f, -1.14095703e-01f, 6.90758824e-02f, 2.75842667e-01f,
  9.60122198e-02f, 8.82002339e-03f, 1.55447856e-01f, 1.01870328e-01f, 1.05503559e-01f, -6.55688811e-03f, 6.27259687e-02f, -1.11036696e-01f, -2.54171807e-02f, -1.03246719e-01f,
  8.54113474e-02f, -5.07829413e-02f, 1.40642136e-01f, 2.99431421e-02f, 8.55517015e-02f, -2.49040965e-02f, 3.59375477e-02f, 1.55480476e-02f, -2.40908973e-02f, -1.35730401e-01f,
  -1.06414326e-01f, 1.33151293e-01f, 4.68477756e-02f, -8.01171064e-02f, 4.76284288e-02f, -1.47472009e-01f, -1.05175912e-01f, 2.98391562e-02f, -2.97039729e-02f, -4.85636517e-02f,
  -4.43260185e-02f, 4.18851636e-02f, -5.24113998e-02f, -3.36255655e-02f, -8.32246467e-02f, 3.02362386e-02f, 4.29792814e-02f, 3.75685096e-02f, -6.66239560e-02f, -1.54960379e-02f,
  4.65397984e-02f, 6.42406940e-02f, 5.01322038e-02f, -1.74558431e-01f, -3.07515692e-02f, 7.52773136e-02f, 9.96065065e-02f, 1.69565715e-02f, -4.91838157e-02f, 3.26789767e-02f,
  3.98505107e-03f, 8.28130767e-02f, -3.73388119e-02f, -2.40869466e-02f, -6.66818097e-02f, -1.28709033e-01f, -1.75541580e-01f, 2.44763680e-02f, 4.60242033e-02f, 7.96174556e-02f,
  1.53332889e-01f, 1.74611762e-01f, 2.08439946e-01f, -2.68606227e-02f, 2.25197989e-02f, 4.30117957e-02f, 2.61317670e-01f, 1.25636443e-01f, 1.06267333e-01f, 1.85899138e-01f,
  -4.14136708e-01f, 6.78727925e-01f, 1.58201814e-01f, -5.22540510e-02f, 3.63185436e-01f, 2.27205858e-01f, 7.13589787e-01f, 1.63394153e-01f, -2.04394996e-01f, 2.03677461e-01f,
  3.13608378e-01f, -2.52377450e-01f, -1.44914031e-01f, -1.64604291e-01f, 1.12062849e-01f, 1.52823120e-01f, 1.51792333e-01f, -1.10056691e-01f, -4.77356583e-01f, -1.81392759e-01f,
  -7.06118420e-02f, 5.63655943e-02f, -2.02673227e-01f, -1.37743548e-01f, 5.48143610e-02f, -3.89997035e-01f, 1.63409740e-01f, 3.57844710e-01f, 6.33863732e-02f, 6.26737624e-02f,
  -1.59155384e-01f, 2.71999627e-01f, -1.71344772e-01f, -4.04466391e-02f, 1.40696779e-01f, -1.73175618e-01f, -1.38881922e-01f, 3.46877649e-02f, 2.59012886e-04f, -5.12511209e-02f,
  8.91313106e-02f, -7.86851943e-02f, 5.95776401e-02f, 5.60015850e-02f, 4.52330569e-03f, 1.08180903e-02f, 8.10928643e-02f, 1.97527073e-02f, 4.07357281e-03f, 1.47934305e-03f,
  3.07407767e-01f, 2.20936552e-01f, 2.18087777e-01f, 3.14703703e-01f, 1.69076234e-01f, -6.70846850e-02f, 2.26384059e-01f, 7.38270134e-02f, 1.75861046e-01f, -2.00615406e-01f,
  -9.41782817e-02f, -5.29795960e-02f, 9.42732915e-02f, 6.32220507e-02f, 1.49599360e-02f, 1.85864195e-02f, 4.82320525e-02f, -3.69361341e-02f, -4.84522395e-02f, -5.89516088e-02f,
  9.20465142e-02f, -2.66607990e-03f, 6.33797422e-02f, 3.98277044e-02f, -8.16963166e-02f, 1.13690846e-01f, 3.00824381e-02f, 4.56658341e-02f, 7.57171167e-03f, 2.99677551e-02f,
  5.01035154e-03f, 9.65696871e-02f, -1.92610454e-02f, 8.38408321e-02f, 4.73923348e-02f, 5.24637327e-02f, -1.62442215e-02f, 1.85623709e-02f, -1.56633444e-02f, -2.05680411e-02f,
  -4.00956631e-01f, 1.86386868e-01f, -1.33555457e-01f, -5.95002621e-02f, 2.70994958e-02f, 3.73656787e-02f, -4.51044627e-02f, -4.28695418e-03f, 4.76157814e-02f, 4.63264249e-02f,
  1.20778516e-01f, -5.13759293e-02f, 9.27124545e-02f, -5.13448380e-02f, -1.66396827e-01f, -1.03552930e-01f, 2.77088154e-02f, 9.92472842e-03f, -1.14641692e-02f, 3.44429873e-02f,
  3.97632234e-02f, -6.62529022e-02f, -3.59399408e-01f, -4.48225662e-02f, -1.21731699e-01f, -3.12677205e-01f, -1.98494583e-01f, -2.24492863e-01f, -2.71000355e-01f, -3.06026280e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  3.10193807e-01f, 2.40026727e-01f, -1.43832624e-01f, 3.26800019e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.90599942e-01f, -3.88621837e-02f, -6.96485192e-02f, -3.75668943e-01f, 6.15402013e-02f, -1.47270188e-01f, 9.84105933e-03f, 1.30691871e-01f, 3.68062854e-01f, -1.98955521e-01f,
  5.17530382e-01f, 1.70376688e-01f, 3.14502567e-01f, 4.75349799e-02f, 3.54789913e-01f, -8.76639485e-02f, 1.56083182e-01f, 3.23054552e-01f, -1.89268783e-01f, 8.62666517e-02f,
  -3.29003066e-01f, -2.95527101e-01f, -2.18461052e-01f, -2.94218063e-01f, 4.92510945e-01f, -2.23107174e-01f, -3.87114972e-01f, -2.67434597e-01f, 4.18400951e-02f, 2.77445972e-01f,
  2.04785854e-01f, -2.55161941e-01f, 3.58572185e-01f, 5.55615313e-02f, -1.23758584e-01f, -8.15353170e-03f, 1.27523258e-01f, 1.52876452e-01f, 5.48249960e-01f, -4.61028330e-02f,
  3.60600650e-01f, -4.99876030e-02f, 1.74958333e-01f, 1.85524166e-01f, -1.52189672e-01f, -1.07283749e-01f, 1.43965483e-01f, -2.45421138e-02f, 1.87851638e-02f, -3.28080095e-02f,
  -4.10880186e-02f, 2.96116583e-02f, -2.48787791e-01f, 7.05465078e-02f, 5.83892725e-02f, 1.42649323e-01f, 2.16209188e-01f, -2.53031969e-01f, -3.69785726e-02f, -1.96379483e-01f,
  -3.63744467e-01f, -4.48736161e-01f, 2.36065343e-01f, 4.51412410e-01f, -1.33058220e-01f, -8.27488080e-02f, -1.16297984e-02f, 1.46788478e-01f, 7.76777342e-02f, 4.82775778e-01f,
  2.74190545e-01f, 3.99211682e-02f, 2.90749192e-01f, 3.50880504e-01f, 5.05235732e-01f, 1.36462867e-01f, 1.94642767e-01f, -4.11442608e-01f, -3.54133546e-02f, 1.75834432e-01f,
  1.51879445e-01f, 1.48182362e-01f, 5.03524691e-02f, -2.20152885e-01f, -2.78444558e-01f, -5.25433235e-02f, -1.38814837e-01f, 2.15033039e-01f, 6.19967207e-02f, -1.29611567e-01f,
  4.27027524e-01f, 8.48370418e-03f, 2.76884492e-02f, -4.30721074e-01f, 1.09161191e-01f, 1.67734295e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -8.42919171e-01f, -1.42524287e-01f, 9.75800037e-01f, 4.25525188e-01f, 4.52819049e-01f, -1.05962440e-01f, -2.18761057e-01f, 6.19116724e-02f, 3.05031277e-02f, -9.90299955e-02f,
  -3.74690115e-01f, -4.38863337e-01f, 2.59636730e-01f, 8.18744123e-01f, 4.35009688e-01f, 4.42425400e-01f, 2.07140326e-01f, -1.49836451e-01f, 1.00289233e-01f, -6.38046861e-02f,
  3.35133612e-01f, 6.01706803e-01f, 5.15025109e-02f, 2.70683952e-02f, 4.29289103e-01f, -4.18529600e-01f, 1.75108369e-02f, 2.42673412e-01f, -2.45107263e-02f, 2.72753894e-01f,
  2.28646234e-01f, -7.20292628e-01f, 2.50980765e-01f, 1.18539393e-01f, -1.74454406e-01f, 1.58844069e-01f, 2.20623240e-01f, -6.28532946e-01f, -3.69874686e-01f, 2.94021517e-03f,
  -5.31690419e-01f, 4.75421697e-01f, 1.81573853e-01f, 6.61400259e-01f, 5.36783099e-01f, -4.41760989e-03f, -4.94704962e-01f, -5.25618792e-01f, 5.50907552e-02f, 4.27012235e-01f,
  3.26913819e-02f, 5.07047713e-01f, 6.76404163e-02f, -6.20109260e-01f, -4.83894259e-01f, -1.06055796e-01f, -2.04086870e-01f, -7.24426210e-02f, -4.05204818e-02f, 2.79902220e-01f,
  3.57799977e-01f, 1.95311606e-01f, -2.62363702e-01f, -2.81241208e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  5.03188908e-01f, 4.64404911e-01f, 3.94447505e-01f, 4.21726853e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.33997846e-01f, 7.01421380e-01f, 1.00242887e-02f, -9.22197923e-02f, 3.82438570e-01f, -1.86326385e-01f, 6.65422156e-02f, -2.99760878e-01f, -9.67739336e-03f, 2.63126701e-01f,
  7.70378947e-01f, 3.79799575e-01f, -4.98109832e-02f, 1.35642104e-03f, 4.80785035e-02f, -3.22770000e-01f, -2.73972051e-03f, 3.84718813e-02f, 2.67544776e-01f, 2.45463908e-01f,
  1.44737944e-01f, 2.09341154e-01f, -1.29126191e-01f, -3.76828253e-01f, 5.17980382e-02f, 2.90755451e-01f, -1.46059036e-01f, -2.32840627e-01f, 3.64620000e-01f, 3.23714614e-02f,
  -7.12729335e-01f, -5.89714229e-01f, -2.13303283e-01f, -5.16900837e-01f, 3.80341977e-01f, 1.42920434e-01f, -6.46155000e-01f, -1.75266251e-01f, -8.37674737e-02f, 7.22020194e-02f,
  -2.66439915e-01f, -4.71191645e-01f, -3.83642167e-01f, 4.84759882e-02f, 1.16831072e-01f, -4.89954591e-01f, 3.52367997e-01f, 2.66335994e-01f, 2.51770228e-01f, 1.19271949e-01f,
  -1.34404734e-01f, 6.35188282e-01f, 4.87289317e-02f, -1.43352181e-01f, -1.05335407e-01f, 2.92901576e-01f, -1.34070978e-01f, -5.94809949e-01f, -3.25837135e-01f, -1.00571728e+00f,
  3.19202691e-01f, 1.95722610e-01f, -2.32912958e-01f, 3.27637523e-01f, 1.20505862e-01f, 5.52447081e-01f, 2.31716722e-01f, 7.68238962e-01f, 2.12696955e-01f, 1.62933961e-01f,
  3.07024986e-01f, 2.94567049e-01f, 1.67877197e-01f, -5.24606884e-01f, 9.66875479e-02f, -1.69109315e-01f, -1.82042345e-01f, 1.26935855e-01f, -7.73993731e-02f, -8.12847316e-02f,
  4.06242698e-01f, -5.04130185e-01f, -2.45946988e-01f, -6.53876066e-02f, -6.93074316e-02f, 3.20321731e-02f, 8.38988781e-01f, 1.30253211e-01f, 2.54578590e-01f, 2.17997178e-01f,
  2.53404099e-02f, 5.48918188e-01f, -1.94082260e-01f, 3.49894851e-01f, 5.94081402e-01f, -1.63574070e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  7.92120337e-01f, -2.66504914e-01f, 1.71336487e-01f, -3.62878770e-01f, -1.96245350e-02f, 4.18233080e-03f, 1.74515367e-01f, -7.39270091e-01f, 1.14595406e-01f, 7.29134632e-03f,
  7.25059748e-01f, 6.74513578e-01f, -1.39559343e-01f, -1.05498803e+00f, 3.19524676e-01f, 1.98238865e-01f, 6.55963004e-01f, 4.02602777e-02f, 2.70124733e-01f, -3.66965383e-01f,
  3.74871016e-01f, -1.38519987e-01f, -3.47597331e-01f, -3.48723441e-01f, 5.36052063e-02f, 7.84967422e-01f, 4.38552886e-01f, 8.36864293e-01f, 7.52634108e-01f, -4.29358054e-03f,
  -7.30609953e-01f, -6.56463683e-01f, 2.41112024e-01f, 1.06177437e+00f, 1.46836132e-01f, -6.60692379e-02f, 9.36233997e-01f, 5.97611368e-01f, -1.19022286e+00f, -5.00244975e-01f,
  -1.01976967e+00f, 4.39470887e-01f, -4.61663216e-01f, -4.94825840e-01f, -2.69515384e-02f, -6.74356163e-01f, 8.46490443e-01f, 6.99628949e-01f, 3.49015325e-01f, 5.71000092e-02f,
  -3.58120650e-01f, -2.33261868e-01f, -1.74147248e-01f, -2.09104642e-01f, -8.32383782e-02f, 3.17968041e-01f, -3.74657422e-01f, -2.93492943e-01f, -1.16966031e-01f, -4.32525992e-01f,
  5.93107581e-01f, 9.58534144e-03f, 5.39264143e-01f, 4.96841162e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  1.13660872e-01f, 3.67532820e-01f, 5.32399058e-01f, -1.18822530e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  5.33918679e-01f, -1.77830327e-02f, 5.16493380e-01f, -1.98825225e-01f, 1.24895774e-01f, -3.00494373e-01f, 2.17193529e-01f, 2.62715071e-01f, -3.78442794e-01f, 5.65057039e-01f,
  -5.86546287e-02f, -7.96460927e-01f, -2.55347729e-01f, 1.67245865e-01f, 1.48794129e-01f, -2.01448590e-01f, -3.47071469e-01f, -3.15643638e-01f, -5.28788686e-01f, -1.77532673e-01f,
  -4.62839901e-01f, 3.86135519e-01f, -3.62262249e-01f, 2.60199815e-01f, 1.55720264e-01f, 1.40495896e-01f, -7.83687085e-02f, 5.68090379e-01f, -4.16495204e-01f, -1.26833320e-01f,
  -4.14904952e-01f, 4.23186839e-01f, -2.34646037e-01f, -1.81500390e-01f, -3.43106031e-01f, -1.98422149e-01f, -1.57069474e-01f, 1.88238502e-01f, 2.51615234e-02f, -2.32814655e-01f,
  -2.99443584e-02f, 2.94763029e-01f, -3.39369406e-03f, 3.93568212e-03f, -2.31461018e-01f, -5.63975811e-01f, -2.92684764e-01f, 6.35007679e-01f, -3.99729639e-01f, -2.21573442e-01f,
  -7.61688128e-02f, 3.18548143e-01f, -1.83245599e-01f, 2.35125065e-01f, 1.54124647e-01f, 4.67696905e-01f, -7.82855377e-02f, -1.73311964e-01f, 3.45837802e-01f, -7.41329268e-02f,
  -7.79386833e-02f, 5.85359216e-01f, -1.05897397e-01f, -4.57995743e-01f, 3.29640508e-01f, 5.80184996e-01f, 3.25343490e-01f, 8.63993466e-01f, -1.49664218e-02f, -7.03146979e-02f,
  5.26334882e-01f, 5.29744446e-01f, -1.99505776e-01f, -2.35537678e-01f, 9.63251770e-01f, 6.04498804e-01f, -3.13026160e-01f, -8.44888855e-03f, -7.55378306e-02f, -2.21280217e-01f,
  -5.05572259e-01f, -3.22123736e-01f, -4.21369642e-01f, -2.00807840e-01f, -6.95453823e-01f, -4.18748498e-01f, -8.59468505e-02f, 4.52949703e-01f, 5.90137899e-01f, 1.91442564e-01f,
  8.10195208e-01f, -1.23893060e-01f, -4.86379266e-01f, 1.04401045e-01f, -2.88218968e-02f, 3.75747122e-02f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.64761949e+00f, -1.01374924e-01f, -6.74710810e-01f, -5.95524490e-01f, -6.20472431e-01f, 5.94625831e-01f, -4.21790481e-01f, -8.71602058e-01f, 5.07470071e-01f, -2.12043822e-02f,
  -4.73958194e-01f, -2.18717560e-01f, -1.37692094e-01f, -1.78388000e+00f, 5.28303441e-03f, 2.99786061e-01f, -4.93465275e-01f, -5.79412043e-01f, -1.61027089e-01f, 2.40914654e-02f,
  7.61192679e-01f, 1.21185752e-02f, -8.59159768e-01f, -6.10864818e-01f, 1.39046311e+00f, -9.00011480e-01f, -4.35517430e-01f, -4.96833473e-01f, 8.26583624e-01f, -6.39373720e-01f,
  1.08052349e+00f, 7.31442273e-01f, 8.71878564e-02f, -3.15311939e-01f, 4.82524931e-01f, -6.81529462e-01f, 3.67568880e-01f, -5.82841992e-01f, -4.34868969e-02f, 6.26443863e-01f,
  -2.82848924e-02f, 1.15218222e+00f, -5.06427169e-01f, -1.18437099e+00f, -1.22756422e+00f, 2.04442039e-01f, 1.14523029e+00f, 3.87589216e-01f, 6.66273773e-01f, 1.32622850e+00f,
  4.43544835e-01f, 7.96586871e-02f, -1.40409380e-01f, 3.27361405e-01f, -1.01363674e-01f, -1.09781265e+00f, 4.50700730e-01f, 1.00755286e+00f, 5.26127338e-01f, -5.79359829e-01f,
  -7.34254837e-01f, -1.54906642e+00f, 9.60033059e-01f, 4.90384012e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  1.77547321e-01f, 1.49638861e-01f, 3.59543413e-01f, 4.69304770e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -4.57603931e-01f, 1.86642148e-02f, 2.44275928e-01f, 4.39095229e-01f, -2.96712033e-02f, 1.08281143e-01f, -4.67905253e-01f, 2.23237932e-01f, -4.03975427e-01f, 9.76970140e-03f,
  -5.61504006e-01f, 5.84109463e-02f, 1.39575052e+00f, 2.03911722e-01f, 7.31726438e-02f, 2.78163880e-01f, -1.27685785e+00f, 3.55554402e-01f, 1.88594669e-01f, 3.71079057e-01f,
  5.22435486e-01f, 5.49865246e-01f, 7.59794235e-01f, -1.35060167e+00f, -1.25060332e+00f, 7.82659709e-01f, 3.02274734e-01f, 1.05385315e+00f, 1.32235989e-01f, -8.54320645e-01f,
  7.03270674e-01f, -1.16155982e+00f, -1.02135849e+00f, -1.22207117e+00f, 1.64925441e-01f, 1.31902084e-01f, -1.81670561e-01f, 5.89291751e-01f, -5.63282371e-01f, 8.64766359e-01f,
  -6.40125871e-01f, -4.62688446e-01f, -2.89214879e-01f, 6.72594965e-01f, -1.68330029e-01f, -7.25163341e-01f, 2.73918092e-01f, 1.04464316e+00f, -4.66247827e-01f, 1.02728300e-01f,
  -3.06921750e-01f, 7.32067525e-01f, -4.62109715e-01f, 1.10118398e-02f, -1.41142023e+00f, 3.64433706e-01f, 1.08719194e+00f, -1.44501436e+00f, -1.26721179e+00f, 1.91675806e+00f,
  -2.19330609e-01f, 8.22135508e-01f, 1.48023203e-01f, -1.14558232e+00f, 6.19977057e-01f, 8.46255362e-01f, 1.46676123e-01f, -8.97665262e-01f, -8.25662136e-01f, -1.99543893e-01f,
  3.70796412e-01f, -8.61219704e-01f, 5.54842591e-01f, -1.23326175e-01f, -7.89450347e-01f, -6.92782640e-01f, -3.26513022e-01f, 3.53991300e-01f, 2.50954747e-01f, 2.66657948e-01f,
  5.12971699e-01f, 1.21411192e+00f, 1.25552988e+00f, 6.18029833e-01f, -7.53799021e-01f, 6.11784577e-01f, 1.04773879e+00f, -1.11912584e+00f, 2.03583494e-01f, -7.27111340e-01f,
  5.88149965e-01f, -1.50642836e+00f, -9.52677727e-01f, -8.31739962e-01f, -3.43817711e-01f, 9.53072846e-01f, 9.63487267e-01f, -1.30410635e+00f, -1.45241368e+00f, 1.83734047e+00f,
  -1.62425292e+00f, -1.20021093e+00f, -1.39027582e-02f, -9.28634048e-01f, -1.10615754e+00f, 1.17841804e+00f, 6.36659026e-01f, -1.05788720e+00f, -3.36276412e-01f, -1.83928415e-01f,
  -9.93948221e-01f, -1.14237332e+00f, -1.09320080e+00f, -9.38373208e-01f, -1.05560791e+00f, -2.75156140e-01f, 5.70691049e-01f, -4.33621518e-02f, -2.28481010e-01f, 1.26193285e+00f,
  1.13126945e+00f, 4.35699791e-01f, -2.71401200e-02f, -1.11318004e+00f, 3.43033850e-01f, 3.99026684e-02f, 6.65342867e-01f, -9.07446146e-01f, 6.09256566e-01f, 1.43485177e+00f,
  1.59104198e-01f, -1.37388825e+00f, -1.63421106e+00f, -4.41873431e-01f, -6.59515858e-01f, 7.13205576e-01f, -1.11504889e+00f, 5.04029691e-01f, -1.43219367e-01f, 1.62648261e+00f,
  5.43927327e-02f, -3.96537960e-01f, -9.64782715e-01f, -1.04749656e+00f, 2.54259497e-01f, -1.82788476e-01f, -6.29116297e-01f, -1.55547559e-01f, 1.02492225e+00f, -3.35504711e-01f,
  2.27696329e-01f, 7.06973255e-01f, -1.32621968e+00f, -8.35404992e-01f, 6.97536469e-01f, -5.87086439e-01f, -1.33774769e+00f, 8.58512998e-01f, -9.22728062e-01f, 3.85954678e-01f,
  1.08243918e+00f, 1.07050873e-01f, 1.25775409e+00f, 2.11965251e+00f, 1.94516623e+00f, 7.67805457e-01f, -1.91198867e-02f, 1.62702143e+00f, 1.80208719e+00f, 3.61813247e-01f,
  7.74718940e-01f, 1.76948953e+00f, -1.49696314e+00f, -5.05503774e-01f, -1.14267302e+00f, -1.44812131e+00f, 7.46682286e-01f, -1.09227788e+00f, -4.70296144e-01f, -1.71224761e+00f,
  2.03354383e+00f, -1.32931781e+00f, 4.55754787e-01f, -1.11691558e+00f, 2.01378894e+00f, -1.52627319e-01f, 5.61258905e-02f, -8.78306210e-01f, 9.70868915e-02f, -9.58229244e-01f,
  -1.09228981e+00f, -3.97855043e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.04599395e-01f, 2.45039165e-02f, -6.79559886e-01f, -6.03802562e-01f, -7.33444870e-01f, 5.04991353e-01f, 5.35594642e-01f, -5.51969647e-01f, 5.15603006e-01f, 3.10694147e-02f,
  1.95446759e-01f, 5.49027443e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    