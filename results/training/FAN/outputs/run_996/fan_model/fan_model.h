/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.42913955e-01f, 3.13134879e-01f, -4.46721204e-02f, 2.70690411e-01f, -1.36542007e-01f, -2.20579043e-01f, -4.76438291e-02f, -5.59220500e-02f, 5.96083440e-02f, 1.24238379e-01f,
  8.80906507e-02f, 4.21759151e-02f, -5.61164431e-02f, -4.54194732e-02f, -1.31144390e-01f, 3.50000337e-02f, -1.44382671e-01f, -1.63206533e-01f, -3.07964772e-01f, -1.15277663e-01f,
  -2.73619033e-02f, 1.01954244e-01f, 5.94065599e-02f, -2.62382239e-01f, 2.28767782e-01f, 6.10490739e-02f, 1.01341709e-01f, 7.89155141e-02f, -4.77937311e-02f, 2.04711661e-01f,
  3.09245199e-01f, 1.92187026e-01f, -2.24063605e-01f, -7.52774253e-02f, 8.90215263e-02f, 7.73764998e-02f, 1.06656916e-01f, 6.64981455e-02f, -1.15964048e-01f, 7.70004583e-04f,
  1.33859031e-02f, -1.11319751e-01f, -6.88108280e-02f, 8.61260593e-02f, -1.85660331e-03f, -2.36442778e-03f, -1.13922171e-02f, -1.01433443e-02f, -7.48853683e-02f, 1.32840484e-01f,
  7.94239715e-02f, -7.24536702e-02f, -1.86796244e-02f, -1.33539304e-01f, -3.78419529e-03f, -2.00210065e-01f, 4.03607776e-03f, -4.45083641e-02f, -2.65659750e-01f, 2.22089410e-01f,
  -5.80394231e-02f, 8.09195489e-02f, 1.38332248e-02f, 4.43582051e-02f, 3.94752473e-02f, 5.16139753e-02f, 3.79281491e-02f, -4.48059328e-02f, -4.50839028e-02f, 6.52208403e-02f,
  -8.59145969e-02f, 5.84418960e-02f, 2.94843949e-02f, 7.63666257e-02f, 3.09464969e-02f, -2.00423300e-02f, -4.79696430e-02f, 4.34584031e-03f, -2.64729522e-02f, 1.66882928e-02f,
  -3.71495150e-02f, -3.78307030e-02f, -2.87651792e-02f, -5.19038178e-02f, -5.50442040e-02f, 5.15155680e-03f, 1.42431473e-02f, 2.46763602e-03f, -1.52966951e-03f, -3.25674936e-02f,
  2.83863455e-01f, -3.65186960e-01f, 3.41047823e-01f, -5.90407364e-02f, 1.43671762e-02f, -4.18827347e-02f, 1.75145008e-02f, -6.35463372e-02f, 4.18007895e-02f, 4.58719879e-02f,
  -3.50143686e-02f, 5.92577569e-02f, 5.26260361e-02f, -6.11576065e-02f, -6.58866540e-02f, -8.81673768e-02f, 3.16960067e-02f, 1.87542923e-02f, -4.67821583e-02f, 2.73473677e-03f,
  -5.24707250e-02f, -2.65076179e-02f, 4.62417230e-02f, 5.14784642e-02f, -3.12872604e-02f, 1.96845527e-03f, 1.03206113e-01f, 1.49920940e-01f, -9.73356888e-02f, 2.18161896e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.33846927e-01f, -4.23557311e-01f, -4.05678034e-01f, 3.28132570e-01f, 9.82794762e-02f, 6.56959563e-02f, -2.96382848e-02f, 2.57838339e-01f, 3.93246561e-01f, -2.22024322e-02f,
  -3.22167069e-01f, -2.15678722e-01f, -2.64367104e-01f, -2.43837297e-01f, -1.47141561e-01f, -1.53387815e-01f, -2.21599892e-01f, -1.10280797e-01f, 1.37832031e-01f, 3.00277084e-01f,
  1.07002519e-01f, 3.43563616e-01f, 2.31774896e-01f, 2.42023598e-02f, 1.48011064e-02f, -5.73807210e-02f, -1.79044619e-01f, -4.75222245e-02f, -2.67521828e-01f, -4.66159970e-01f,
  -5.66941738e-01f, -4.93944138e-02f, 1.07035875e-01f, 1.21781282e-01f, -1.60574809e-01f, 7.52226338e-02f, 8.64137709e-03f, -1.92529634e-01f, -1.20602138e-01f, -1.41117588e-01f,
  -5.83159588e-02f, -3.70616131e-02f, -7.67883360e-02f, -1.03765979e-01f, -1.08689398e-01f, 1.21888639e-02f, -2.33578011e-02f, -2.49685720e-02f, -1.44403383e-01f, -1.65444598e-01f,
  -8.09242353e-02f, -1.58949122e-01f, -2.46965304e-01f, -1.82422921e-01f, -1.54503167e-01f, -8.22089463e-02f, -2.47496903e-01f, -2.37913609e-01f, -3.38894278e-01f, -7.53738806e-02f,
  -8.81360006e-03f, -1.76104717e-02f, 2.63859630e-02f, -3.87986973e-02f, 6.87044263e-02f, -9.09913853e-02f, -6.19534738e-02f, 8.54053628e-03f, 1.93257537e-02f, 1.17173798e-01f,
  -1.20087899e-01f, 3.30609968e-03f, -4.98493128e-02f, 1.68809071e-02f, -2.51575024e-03f, 4.65797856e-02f, -2.34070942e-02f, 9.21847001e-02f, -1.03381664e-01f, 1.10464513e-01f,
  6.17686100e-02f, -9.56814289e-02f, 5.21704294e-02f, 3.58756669e-02f, 3.81470062e-02f, -1.37986407e-01f, 1.35482416e-01f, -6.25771061e-02f, 4.66006473e-02f, 3.13211791e-02f,
  2.06296623e-01f, -3.04385684e-02f, 7.46986717e-02f, 1.40555859e-01f, 1.11768253e-01f, -1.01516195e-01f, -6.07042275e-02f, 6.26482815e-02f, -1.84636652e-01f, -1.01240247e-01f,
  -5.15994355e-02f, -5.93430698e-02f, -3.86707820e-02f, -8.78139436e-02f, 8.99125487e-02f, 5.43651916e-02f, 6.81571737e-02f, 2.12477297e-01f, 1.25235125e-01f, 9.55384523e-02f,
  1.14197776e-01f, 1.79026365e-01f, 1.91533685e-01f, 6.92293793e-02f, 1.40145972e-01f, 2.25243330e-01f, -3.07593346e-02f, 1.92580327e-01f, 2.00358614e-01f, 4.74097282e-01f,
  1.11375117e+00f, 1.74752280e-01f, 1.73934251e-01f, 4.22135144e-02f, -6.43516958e-01f, -2.42995039e-01f, -2.58570641e-01f, 1.17669396e-01f, 1.91798523e-01f, 3.07987425e-02f,
  -3.19783203e-03f, 2.58998930e-01f, 3.82755339e-01f, 3.77054483e-01f, 4.64179456e-01f, -7.62709677e-02f, 8.74205977e-02f, 5.24766862e-01f, 2.37265348e-01f, -9.56790298e-02f,
  -2.68885285e-01f, 1.25087816e-02f, 2.93413132e-01f, 1.82527944e-01f, -2.82908022e-01f, -4.66685668e-02f, 4.97335494e-02f, -2.18905985e-01f, -1.02265783e-01f, -1.12356767e-01f,
  4.44589891e-02f, 4.02242392e-01f, 9.44547355e-02f, 3.48309502e-02f, 3.08708157e-02f, 1.65885165e-01f, 2.25093067e-02f, -3.01220473e-02f, -1.17450282e-01f, -2.75462940e-02f,
  -2.34004036e-01f, -3.46209966e-02f, -6.87438101e-02f, -1.17929973e-01f, -1.85277507e-01f, -1.05714716e-01f, 1.02718987e-01f, 3.01352620e-01f, 1.48438871e-01f, 7.22783953e-02f,
  -1.98369011e-01f, -1.04927182e-01f, -2.39042994e-02f, -1.49715990e-02f, 1.64206117e-01f, 9.97983888e-02f, 2.16576108e-03f, 1.01866320e-01f, 2.84472674e-01f, 1.46931052e-01f,
  1.80244930e-02f, 1.75573260e-01f, 2.35900134e-02f, -2.89752036e-02f, 8.67419690e-03f, -5.96915334e-02f, -9.88187417e-02f, 3.06835771e-02f, 3.49277332e-02f, -7.54683241e-02f,
  -3.70440260e-02f, 1.03836935e-02f, 8.35336298e-02f, 4.88235652e-02f, 1.34750698e-02f, 9.45277289e-02f, -1.12968005e-01f, 5.33620119e-02f, 6.69932142e-02f, -6.48332462e-02f,
  -7.97133707e-03f, -6.85018580e-03f, -2.14805547e-02f, -6.41004145e-02f, -6.41344041e-02f, 7.98660964e-02f, -1.10067353e-01f, 1.18628312e-02f, 3.77951749e-02f, -7.86419492e-03f,
  -3.55889387e-02f, 4.06754434e-01f, 6.13604821e-02f, 1.01968281e-01f, 6.59938306e-02f, -1.08815104e-01f, 1.04286589e-01f, -5.93678132e-02f, -1.29603565e-01f, -6.27232343e-02f,
  -3.33471075e-02f, 6.23819360e-04f, 4.17426154e-02f, -4.74397559e-03f, -8.35973769e-02f, -1.32289141e-01f, 5.15286289e-02f, -9.85165592e-03f, -7.19966888e-02f, -1.22350670e-01f,
  -2.29644448e-01f, -1.26197487e-01f, 8.99122134e-02f, -4.37579714e-02f, -9.85998660e-02f, -3.66160795e-02f, -1.77525520e-01f, -1.44116938e-01f, 5.45834117e-02f, -1.59704953e-01f,
  -8.24167788e-01f, -5.84887385e-01f, 2.97507904e-02f, -6.25341773e-01f, -1.77630976e-01f, -1.56061903e-01f, -6.14181757e-01f, -5.55108711e-02f, -2.14056641e-01f, -5.85254371e-01f,
  -2.73136318e-01f, -2.43741516e-02f, -8.34418312e-02f, -2.90936232e-02f, -2.22495005e-01f, -6.67112768e-01f, -3.30398023e-01f, -9.33226570e-02f, 2.38484561e-01f, -1.39215076e-02f,
  -3.22477162e-01f, -4.86068845e-01f, -2.24437088e-01f, 1.46024421e-01f, -1.52375534e-01f, 1.19209826e-01f, -1.49401397e-01f, -4.50640135e-02f, 2.88267937e-02f, -4.22317266e-01f,
  -7.41087794e-02f, -1.83951318e-01f, 1.61638081e-01f, -9.41689014e-02f, -2.32348666e-01f, -4.75871302e-02f, -1.59903169e-01f, -1.68781504e-01f, 2.12646902e-01f, -1.81514382e-01f,
  -1.70112908e-01f, -4.03693505e-03f, -1.75270870e-01f, 1.28914505e-01f, -1.70708105e-01f, 4.97064628e-02f, -1.23521760e-01f, -9.58715826e-02f, -5.38728982e-02f, 1.27422273e-01f,
  -2.43208800e-02f, -7.93493092e-02f, 1.19656175e-01f, 2.37185568e-01f, 2.85119623e-01f, 2.05102354e-01f, 2.06780657e-01f, 3.28698814e-01f, 3.87661636e-01f, -2.30740011e-01f,
  -1.38771847e-01f, 1.24881892e-02f, -1.11516744e-01f, -1.12151830e-02f, 5.52216135e-02f, -3.96891497e-02f, 2.95429770e-02f, -1.03317574e-01f, -3.17910202e-02f, 5.74908182e-02f,
  -3.53446580e-03f, -1.71471909e-02f, -3.71787213e-02f, -4.54700887e-02f, -7.79471779e-03f, -8.62611309e-02f, -6.69375286e-02f, -6.16629943e-02f, 1.00227438e-01f, -8.69521797e-02f,
  5.82285970e-02f, 6.40820898e-03f, 9.21674296e-02f, 1.36529192e-01f, -2.52311751e-02f, -5.65394089e-02f, 5.78948818e-02f, 8.13738480e-02f, 4.42034043e-02f, -2.59626340e-02f,
  -1.05994858e-01f, 3.25373769e-01f, -2.31981695e-01f, 8.77026543e-02f, -7.75295421e-02f, -2.53275111e-02f, -6.46901727e-02f, 4.96010706e-02f, -6.50628582e-02f, -1.39789060e-01f,
  7.12621957e-02f, -2.90656149e-01f, -1.07936420e-01f, 3.06483433e-02f, -2.13862076e-01f, -1.02526762e-01f, -1.08039588e-01f, -1.73847735e-01f, 8.19060430e-02f, 1.13497358e-02f,
  8.01889673e-02f, 2.02664454e-02f, -1.10619441e-01f, 3.27830873e-02f, 1.48316190e-01f, 1.12243146e-01f, 1.26319826e-01f, 1.96468145e-01f, 9.91878361e-02f, -2.97073364e-01f,
  -1.29141197e-01f, 1.92850292e-01f, 9.20923948e-02f, 2.77364910e-01f, 7.27971569e-02f, -2.64203936e-01f, -3.71754378e-01f, -2.64511645e-01f, -2.42320951e-02f, 1.79902967e-02f,
  -1.53910011e-01f, 8.70554820e-02f, -1.04600415e-02f, -5.26839122e-02f, -2.29959875e-01f, 4.17699404e-02f, 3.26937586e-01f, 1.96398631e-01f, -7.54481107e-02f, -1.48065507e-01f,
  1.60761967e-01f, 2.17632532e-01f, 1.08934455e-01f, -1.22579567e-01f, 9.78655890e-02f, -8.68050382e-02f, 1.19309045e-01f, 2.79127151e-01f, 1.60899788e-01f, 5.07710636e-01f,
  -2.75387745e-02f, 1.80139512e-01f, -1.45591661e-01f, 2.39873022e-01f, 6.89382479e-02f, 9.29289386e-02f, -1.80789694e-01f, 1.91449955e-01f, 1.78339723e-02f, 4.48891558e-02f,
  1.58447787e-01f, -1.39575779e-01f, -2.96497941e-02f, -3.41341868e-02f, -1.13070160e-01f, -8.81111249e-02f, -6.77551404e-02f, 7.65534490e-02f, -1.60316393e-01f, -1.17715545e-01f,
  3.58569115e-01f, 2.53936946e-01f, -1.42234519e-01f, -1.84695661e-01f, -1.64573908e-01f, 1.72361180e-01f, -1.87262863e-01f, -3.59349735e-02f, -3.25473100e-01f, -1.32320449e-01f,
  -1.96331106e-02f, -2.00863004e-01f, -3.66426595e-02f, 1.04084253e-01f, -4.78753448e-02f, 2.71189194e-02f, -4.69952859e-02f, -1.24021657e-01f, -8.65776464e-03f, 1.31688446e-01f,
  -6.90342262e-02f, -7.90668428e-02f, -5.32980785e-02f, 4.32470404e-02f, -2.92899758e-02f, -1.05457030e-01f, -1.79635078e-01f, 2.31014639e-02f, 1.96896475e-02f, -7.47931823e-02f,
  7.05141127e-02f, -1.78047761e-01f, 1.10124024e-02f, -1.50482580e-01f, 1.04917906e-01f, -1.09067401e-02f, -9.12446156e-02f, 3.05724274e-02f, 1.72495302e-02f, 1.89077184e-01f,
  -3.31295878e-01f, 1.35077149e-01f, -2.81370312e-01f, -5.73094636e-02f, 1.00164838e-01f, 7.57063553e-02f, 1.23210639e-01f, 3.24425921e-02f, -8.47269520e-02f, -1.68839946e-01f,
  -1.94777608e-01f, -1.66224226e-01f, -1.06200315e-01f, -9.55480486e-02f, -1.16990522e-01f, 1.74617134e-02f, -4.03088406e-02f, 5.83823887e-04f, -6.69750199e-02f, -1.60396487e-01f,
  -1.00441553e-01f, -5.05021289e-02f, -2.38582373e-01f, -2.55752206e-01f, -1.29707813e-01f, -1.81569532e-01f, -3.32485259e-01f, -2.27236703e-01f, -3.04856926e-01f, -5.39316714e-01f,
  -3.11304092e-01f, -6.84289634e-01f, -4.02919352e-01f, -8.55702236e-02f, -2.23300859e-01f, -2.00970292e-01f, -5.68342805e-01f, 2.04787195e-01f, 2.41829351e-01f, -5.06262600e-01f,
  -2.68447418e-02f, 1.96012586e-01f, -4.22993898e-02f, 1.60846468e-02f, 1.00586385e-01f, -5.99584758e-01f, -5.04291177e-01f, -1.47522986e-01f, 4.67507750e-01f, 3.49857330e-01f,
  -2.86615416e-02f, -1.37430072e-01f, 5.86910956e-02f, 1.67561173e-01f, -3.81101310e-01f, -1.29834056e-01f, -4.83544767e-01f, -3.89975250e-01f, -2.63091594e-01f, -7.53744900e-01f,
  -5.08521795e-01f, -1.79280788e-02f, 1.56556651e-01f, 8.02206546e-02f, -2.67360508e-01f, 1.48157515e-02f, -1.38404295e-01f, 3.27525437e-02f, 5.57903722e-02f, -1.16947152e-01f,
  1.01343006e-01f, 1.02392994e-01f, 6.87722638e-02f, 8.01487193e-02f, -1.32700801e-01f, 5.16840145e-02f, 3.13547924e-02f, 1.42762139e-02f, -9.73466933e-02f, 2.61042360e-03f,
  -2.68205423e-02f, 9.73984450e-02f, -3.54625843e-02f, -5.94609417e-02f, 1.82734296e-01f, 6.53552189e-02f, -1.50188044e-01f, 4.15649526e-02f, 4.75775935e-02f, -6.90220118e-01f,
  -3.57159670e-03f, -2.25434259e-01f, 4.72666025e-02f, -9.43889376e-03f, 3.40533666e-02f, 1.96243510e-01f, -5.92628270e-02f, -3.21751945e-02f, 2.61948095e-03f, 3.75188328e-02f,
  -1.31859826e-02f, -1.48109356e-02f, 2.51347721e-02f, 1.65434685e-02f, -4.93281428e-03f, -1.70411374e-02f, -8.84688422e-02f, -6.79384917e-02f, 4.71039712e-02f, -1.05532512e-01f,
  3.76381688e-02f, 6.54390901e-02f, -6.20576611e-04f, -6.71855658e-02f, -1.03415363e-01f, -1.08381756e-01f, 6.97191805e-02f, 1.02532044e-01f, 4.93226899e-03f, -4.27101552e-02f,
  -8.36322829e-02f, 9.89006981e-02f, -2.13826418e-01f, 2.50151195e-02f, 2.08610464e-02f, -1.05091631e-02f, 9.78928804e-02f, 4.52387296e-02f, -4.31158245e-02f, -1.21563599e-01f,
  9.26316157e-03f, 3.07068210e-02f, -1.03962347e-01f, -8.58961940e-02f, -7.70378439e-03f, 6.01489246e-02f, 1.13945037e-01f, -1.16347186e-01f, 2.03164183e-02f, -2.71835197e-02f,
  1.53496116e-02f, 1.50941163e-01f, 7.08527043e-02f, -9.79166944e-03f, -3.02869286e-02f, 2.90420204e-02f, -2.20766693e-01f, -1.20881498e-01f, -6.22835644e-02f, -4.52810735e-01f,
  4.19096947e-01f, -6.20102227e-01f, 1.51908174e-01f, 3.94146472e-01f, 6.19961262e-01f, 6.26755059e-01f, 4.20241296e-01f, 2.87178159e-01f, 1.88761309e-01f, -4.42226045e-02f,
  -2.33427659e-01f, -1.52332604e-01f, -1.09360358e-02f, -3.33398697e-03f, 2.26608329e-02f, 2.90402800e-01f, 3.66032094e-01f, 1.33775666e-01f, 1.80153817e-01f, 1.86814457e-01f,
  5.74473143e-02f, -7.91020095e-02f, -3.09390306e-01f, 6.17555194e-02f, 9.71728489e-02f, 1.80845410e-01f, -5.64683527e-02f, -2.08937109e-01f, -1.54902935e-01f, -1.66007057e-01f,
  -1.65417150e-01f, -3.11316788e-01f, 1.63416862e-01f, -2.62711849e-02f, -1.45069599e-01f, -8.97856206e-02f, 8.91272072e-03f, -1.31414980e-01f, -8.24642926e-02f, -5.10995723e-02f,
  -2.00369552e-01f, -1.15487389e-01f, 8.12052414e-02f, -3.39386128e-02f, -3.36916968e-02f, -4.54279408e-02f, -1.63604572e-01f, -2.64571756e-02f, 8.21373835e-02f, 3.41836289e-02f,
  -4.52800803e-02f, 8.18405207e-03f, 1.33603951e-02f, 1.23553403e-01f, 1.98998004e-01f, 1.68423027e-01f, -1.81202218e-01f, 3.16060036e-02f, -8.01722407e-02f, -6.62477463e-02f,
  1.74654007e-01f, 8.42727646e-02f, 7.56653175e-02f, -1.82778817e-02f, 8.85579064e-02f, 7.17971921e-02f, 5.90873286e-02f, -1.34256361e-02f, 1.37000993e-01f, 4.33311332e-03f,
  1.45388078e-02f, 1.57010317e-01f, 6.11373559e-02f, -6.91789612e-02f, -1.12656746e-02f, -7.68851191e-02f, -8.19248632e-02f, -1.18447892e-01f, -1.01735152e-01f, 9.45911556e-02f,
  -3.30423079e-02f, 4.57356572e-02f, -3.27513181e-02f, 4.82725464e-02f, -1.05569605e-02f, 1.43528599e-02f, 2.77749952e-02f, -2.19496459e-01f, 1.07965358e-02f, 2.24970095e-02f,
  1.67470872e-02f, 7.77532011e-02f, 1.60957128e-01f, -1.01419777e-01f, -1.43187836e-01f, -1.25205368e-01f, 9.95368212e-02f, -1.76939622e-01f, -2.23506000e-02f, 5.30959442e-02f,
  -1.70536235e-01f, -2.02163775e-02f, -6.49089143e-02f, -2.36916050e-01f, -3.24928970e-03f, -6.07118979e-02f, -2.06236839e-01f, 3.56924571e-02f, -1.00362152e-01f, -9.54706073e-02f,
  -7.96175152e-02f, 9.60944295e-02f, 6.22195750e-02f, 4.10945006e-02f, 1.60343177e-03f, 3.15740645e-01f, -4.45927791e-02f, -1.37683153e-01f, 1.43224701e-01f, 8.08106884e-02f,
  -7.59382129e-01f, -4.04879861e-02f, 2.95201927e-01f, -5.88422688e-03f, 2.02997878e-01f, -5.28401509e-03f, 2.94043839e-01f, -8.55259001e-02f, -3.50692362e-01f, -7.12561309e-02f,
  1.36355907e-01f, 1.35882780e-01f, 2.06946671e-01f, 1.64593190e-01f, 2.41943762e-01f, 3.37914914e-01f, 6.90340772e-02f, 1.71295777e-01f, 5.16672194e-01f, 3.25494945e-01f,
  2.37303972e-01f, 5.35706729e-02f, -1.46064624e-01f, -1.57138288e-01f, 4.29819077e-02f, 2.12572172e-01f, -9.66488011e-03f, -7.56595954e-02f, -4.23747022e-03f, 1.08872615e-01f,
  7.75035083e-01f, 6.28147740e-03f, 1.87051013e-01f, -1.11293763e-01f, -2.19703708e-02f, -1.98699981e-01f, 1.33106738e-01f, -6.31362647e-02f, -1.49220034e-01f, -8.01048800e-03f,
  -5.92585057e-02f, -5.16829938e-02f, 5.70404045e-02f, 4.63900529e-02f, 1.48402378e-01f, -6.85162768e-02f, -1.75611839e-01f, 1.72478154e-01f, 2.06998959e-02f, 4.42372225e-02f,
  -2.00215145e-04f, 5.48383892e-02f, 2.20638588e-01f, -6.14137063e-03f, 6.06388971e-02f, 9.01061296e-02f, 2.76469998e-02f, 7.36913905e-02f, -4.37030718e-02f, 1.19986851e-03f,
  2.47593354e-02f, 5.88661544e-02f, 6.83371276e-02f, 8.23537782e-02f, -6.90904483e-02f, -1.16204344e-01f, -1.29926819e-02f, 1.99032918e-01f, 7.46337548e-02f, 1.04447808e-02f,
  1.10539705e-01f, 6.53084517e-02f, 1.78432763e-02f, 1.01804130e-01f, 3.27481925e-02f, 9.78348255e-02f, 4.92222011e-02f, 1.14851758e-01f, -1.06520630e-01f, -1.04061238e-01f,
  2.13210341e-02f, 7.54130036e-02f, -1.29822224e-01f, 1.13324828e-01f, -8.72692913e-02f, 3.92473340e-02f, -9.87612177e-03f, -3.18269641e-03f, -4.70066890e-02f, -1.53627321e-01f,
  4.19508129e-01f, -1.85734659e-01f, 2.37003818e-01f, 2.43074428e-02f, -9.66082364e-02f, -3.70123208e-01f, -5.17970361e-02f, -8.69836435e-02f, -7.29337111e-02f, -3.86949293e-02f,
  -2.03783289e-01f, -6.52140155e-02f, -8.54473487e-02f, 1.23070637e-02f, 1.23458430e-01f, 1.46962479e-02f, -1.08287014e-01f, 1.42104521e-01f, -3.91870961e-02f, 2.14659255e-02f,
  -2.78910220e-01f, -1.85713824e-02f, 3.08574945e-01f, 3.31625976e-02f, -5.76598532e-02f, 6.64706305e-02f, 2.45705292e-01f, 4.35391162e-03f, 1.36077121e-01f, -6.12726770e-02f,
  3.09446067e-01f, -8.09368014e-01f, 2.19010964e-01f, 3.61688063e-02f, 4.01006378e-02f, 1.84948474e-01f, -2.02218704e-02f, -9.98141840e-02f, 4.92839925e-02f, -1.48395017e-01f,
  -1.70729175e-01f, 9.79788229e-02f, 1.09112635e-02f, -9.85684395e-02f, -2.54820883e-02f, 1.25610098e-01f, 1.68732628e-02f, 2.73311853e-01f, 4.09205139e-01f, 2.42739365e-01f,
  -1.00308031e-01f, -1.60489962e-01f, -8.23128968e-02f, -8.30619037e-02f, -2.04455301e-01f, 7.34403655e-02f, -2.39169911e-01f, -3.06943119e-01f, -3.31343383e-01f, -2.87717760e-01f,
  2.93303013e-01f, -4.17265892e-01f, 2.14505643e-01f, -2.07694128e-01f, -1.77648678e-01f, -1.04653919e-02f, 1.33799583e-01f, -7.03279525e-02f, -1.80194601e-01f, 9.23346914e-03f,
  3.74348927e-03f, -5.06086163e-02f, -1.31724421e-02f, -9.65850800e-02f, -8.80853236e-02f, -2.94847228e-02f, -2.40634724e-01f, -1.66520372e-01f, -5.59100360e-02f, -1.49082869e-01f,
  -1.45130828e-01f, -1.62397861e-01f, 1.31207898e-01f, -9.30842385e-03f, -6.89385086e-02f, 3.62331197e-02f, -2.22467437e-01f, -2.28849798e-01f, -1.61254734e-01f, -6.05788417e-02f,
  -2.04100572e-02f, 3.78117673e-02f, 7.18624294e-02f, -5.86042218e-02f, 7.52576068e-02f, 1.30796850e-01f, 4.20366637e-02f, 3.93990204e-02f, 2.14412878e-03f, -3.81453745e-02f,
  -5.53007349e-02f, 5.41247055e-02f, 4.54539843e-02f, -6.05746321e-02f, -3.67191136e-02f, -5.81689067e-02f, -2.26802453e-02f, -7.33927637e-02f, -5.15350290e-02f, -1.90987717e-02f,
  -7.88326263e-02f, 5.96068092e-02f, 6.14013225e-02f, -9.10272822e-02f, -2.16551527e-01f, -7.38534285e-03f, -4.03165706e-02f, -1.35493040e-01f, 2.17303429e-02f, -4.71044183e-02f,
  2.08463103e-01f, -5.19314222e-02f, 2.53977507e-01f, 9.27858576e-02f, 1.36706993e-01f, -1.35592148e-01f, -4.62798104e-02f, -3.13606225e-02f, 6.21026792e-02f, 1.34184688e-01f,
  -1.11179255e-01f, 1.36850893e-01f, -9.61583182e-02f, -1.80101588e-01f, 9.70292389e-02f, -8.85747075e-02f, -1.69996172e-01f, 5.66578284e-02f, 2.65135765e-02f, -4.10273299e-02f,
  -1.32059112e-01f, 1.26256511e-01f, 3.54687482e-01f, 1.98558971e-01f, -3.59165785e-03f, 3.31933945e-01f, 1.93081558e-01f, 2.02967703e-01f, 3.16907942e-01f, 3.37543666e-01f,
  6.02310061e-01f, 1.78664804e-01f, 3.12704444e-01f, 1.68102637e-01f, 3.86127263e-01f, 4.23561603e-01f, 5.94271839e-01f, 3.25928092e-01f, 2.52649561e-02f, 3.41371968e-02f,
  2.41061404e-01f, -8.65966529e-02f, -1.17491320e-01f, -2.87156314e-01f, 8.10278505e-02f, 4.42211889e-02f, -6.64243028e-02f, -7.21525177e-02f, 9.47044417e-02f, 2.36891121e-01f,
  2.47219075e-02f, 1.70260116e-01f, 1.67940348e-01f, -6.80266544e-02f, -1.65893704e-01f, -1.47548780e-01f, 8.19555894e-02f, 8.88315812e-02f, 2.86529120e-02f, -4.75350142e-01f,
  -2.39496067e-01f, 4.58392978e-01f, -1.31227404e-01f, -1.93893999e-01f, 6.14249818e-02f, -1.97318733e-01f, -2.83688810e-02f, -4.85907272e-02f, 8.00611302e-02f, -1.48327589e-01f,
  1.25142070e-03f, -4.58476171e-02f, 7.96217546e-02f, 3.04394290e-02f, 1.26898676e-01f, 1.01961516e-01f, 2.64406670e-02f, 2.05595251e-02f, -1.43237486e-02f, 4.79843188e-03f,
  -1.53974876e-01f, 1.62230656e-01f, 3.24866802e-01f, 6.62203282e-02f, 5.83224883e-03f, 5.03334496e-03f, 5.64120114e-02f, -4.77333507e-03f, 1.17446445e-01f, -1.96571425e-01f,
  -1.03581287e-01f, -4.88670915e-02f, 4.44485843e-02f, 8.57195817e-03f, 5.80127090e-02f, -1.37290284e-01f, -1.11652292e-01f, 5.71316481e-03f, 4.56470475e-02f, 2.22174153e-01f,
  -1.12053208e-01f, 3.43498570e-04f, -1.16958298e-01f, 1.60947204e-01f, -5.32305166e-02f, -1.08110700e-02f, -2.41077635e-02f, -2.25938838e-02f, -1.92743838e-02f, 2.56569274e-02f,
  9.59762335e-02f, 4.02802788e-02f, -2.55787820e-02f, -4.93970811e-02f, 7.55542517e-02f, 7.55087510e-02f, 3.80178653e-02f, 4.14864831e-02f, 5.09369224e-02f, 1.74624417e-02f,
  -3.55760276e-01f, 3.72505337e-01f, -1.98190570e-01f, -1.72457591e-01f, 6.13867305e-03f, -7.53149763e-02f, -6.51041493e-02f, -1.48535118e-01f, -3.35404538e-02f, -6.30548075e-02f,
  1.24487774e-02f, -1.04131855e-01f, -7.44044734e-03f, 8.95625874e-02f, 1.25942126e-01f, -1.38662374e-02f, -1.27376229e-01f, 2.45476775e-02f, -1.23130657e-01f, -1.77417099e-01f,
  -2.27633625e-01f, 7.86361769e-02f, 9.52030197e-02f, -1.48551941e-01f, -6.74712658e-02f, -1.18013114e-01f, -3.66062112e-02f, -3.82090881e-02f, 2.35029906e-01f, 4.73200157e-02f,
  5.48785985e-01f, -2.77130574e-01f, -2.25629330e-01f, 1.56776264e-01f, -6.81952015e-02f, -5.56407161e-02f, -2.51111001e-01f, 1.91325992e-01f, 2.69602388e-01f, -6.22355491e-02f,
  2.79310644e-01f, 3.58757526e-01f, 3.27739060e-01f, 3.88351619e-01f, 2.82590240e-01f, -1.75496966e-01f, -2.65748829e-01f, 8.59009102e-02f, 1.93409368e-01f, -1.04820989e-01f,
  -1.57918707e-01f, -2.04548284e-01f, 4.83428128e-02f, 3.63817140e-02f, -2.51308501e-01f, 4.73682489e-03f, -1.39232427e-01f, -2.10195899e-01f, -2.13053018e-01f, -3.69868696e-01f,
  -1.24231547e-01f, 1.00259200e-01f, 1.16036683e-01f, 2.56643385e-01f, -7.67119750e-02f, -5.11387028e-02f, -5.19989207e-02f, 6.63770884e-02f, -8.84289518e-02f, -1.12739116e-01f,
  5.03113270e-02f, -3.93960364e-02f, 1.62748678e-03f, -9.65755284e-02f, -1.04929678e-01f, -1.49829030e-01f, -4.78210412e-02f, -3.90692689e-02f, -1.67578440e-02f, -8.01696181e-02f,
  -6.27315566e-02f, 1.15901172e-01f, 1.51314273e-01f, 4.64464016e-02f, 1.42990559e-01f, 1.96419269e-01f, -4.25101146e-02f, 1.26339057e-02f, 5.78545704e-02f, 5.96699677e-02f,
  1.96238294e-01f, -9.28455964e-02f, -1.52892426e-01f, -5.31532764e-02f, 2.64993124e-02f, -1.28611354e-02f, -2.00300831e-02f, -6.11188598e-02f, 2.58479510e-02f, -6.02955632e-02f,
  1.90417923e-03f, 1.04120687e-01f, 1.16092078e-01f, -5.55130690e-02f, -7.71732777e-02f, -1.21063046e-01f, -2.06487402e-02f, 2.37063430e-02f, 1.07625932e-01f, -4.68947664e-02f,
  7.89053515e-02f, 9.25269499e-02f, -8.46603587e-02f, -6.45031407e-02f, -3.94718423e-02f, 4.31347676e-02f, 2.02795547e-02f, 1.52717590e-01f, -9.95375365e-02f, 1.00409165e-02f,
  6.37194365e-02f, 3.43417466e-01f, 7.85790086e-02f, 8.40885658e-03f, -1.76267043e-01f, -2.09316984e-02f, 5.38508184e-02f, 3.45929118e-04f, -6.69474080e-02f, 5.50063550e-02f,
  2.41362173e-02f, 5.55001721e-02f, 7.15250149e-02f, -1.81522131e-01f, -8.31581727e-02f, -9.10976008e-02f, -2.07701419e-02f, -1.01284888e-02f, 6.09625392e-02f, -1.47108606e-03f,
  6.89072758e-02f, 1.36978328e-01f, 2.89725035e-01f, 1.36018306e-01f, 2.04382807e-01f, 3.31844538e-01f, -7.01341256e-02f, 2.35887412e-02f, 1.46034107e-01f, -1.17885038e-01f,
  -6.65880442e-01f, -2.50276271e-02f, -8.51553008e-02f, -3.45747173e-01f, 1.89974084e-01f, 3.85712653e-01f, 3.72717708e-01f, 2.29560852e-01f, 8.53038579e-02f, -3.65766622e-02f,
  9.02843773e-02f, -8.99022669e-02f, -3.84813100e-01f, 6.11862866e-04f, 4.49768603e-02f, 1.56271264e-01f, 9.19062495e-02f, -1.43497005e-01f, -4.72997390e-02f, 2.30904549e-01f,
  1.49425417e-01f, -2.22314358e-01f, -3.50139737e-01f, -8.83993581e-02f, -2.48948544e-01f, -1.63217172e-01f, -3.27685952e-01f, -3.53172153e-01f, -4.49318215e-02f, -3.17076653e-01f,
  -3.08203995e-02f, 9.48223025e-02f, 1.42601728e-01f, -3.35134789e-02f, -2.92866528e-02f, -1.96368709e-01f, -4.95885238e-02f, -2.06762090e-01f, -2.91343927e-02f, 2.79620457e-02f,
  -1.89972863e-01f, 1.33763114e-02f, -1.45791233e-01f, -3.46840397e-02f, -1.64280355e-01f, 4.20655962e-03f, 8.21270514e-03f, -1.33772612e-01f, -3.16135259e-03f, 1.58109084e-01f,
  1.51665866e-01f, -1.01099677e-01f, -3.06371123e-01f, 1.58991009e-01f, -1.09660067e-02f, -2.59661078e-01f, -3.26743126e-01f, -1.89013153e-01f, -1.59132242e-01f, -3.86532813e-01f,
  6.45966679e-02f, 1.14269689e-01f, 2.44750571e-03f, -1.99282840e-02f, 4.93223928e-02f, 3.67138050e-02f, 3.27462964e-02f, 4.05118838e-02f, -1.94532182e-02f, -1.27486974e-01f,
  1.02064937e-01f, -1.09984167e-01f, 8.93893987e-02f, -2.63454597e-02f, -1.22419611e-01f, -1.62931811e-02f, 2.79599223e-02f, 1.14825077e-01f, -3.83277796e-02f, -4.46784943e-02f,
  -6.17791265e-02f, -6.96622506e-02f, -1.18324466e-01f, 1.16884708e-01f, -5.44345565e-02f, 3.55853252e-02f, -7.54178166e-02f, 4.63281423e-02f, -1.64373532e-01f, -1.40586913e-01f,
  -9.03196856e-02f, 1.11900680e-01f, -1.44377813e-01f, -3.57761756e-02f, -1.21156580e-03f, -1.62840575e-01f, -4.19837981e-02f, -3.58730555e-02f, -1.46311253e-01f, 1.36829004e-01f,
  3.99497198e-03f, -1.79785371e-01f, -1.65805861e-01f, 1.59397230e-01f, -9.01104361e-02f, 3.85391340e-02f, -7.50080720e-02f, 9.55499187e-02f, 1.21329971e-01f, -3.01400889e-02f,
  5.00462949e-02f, -1.04365639e-01f, -4.17757958e-01f, -9.68933925e-02f, -1.20470934e-01f, -3.28936577e-01f, -3.47092658e-01f, -3.25537443e-01f, -4.00217056e-01f, -3.77216905e-01f,
  -8.18035603e-01f, 3.84717494e-01f, 1.82787299e-01f, -4.53525931e-02f, 5.15626013e-01f, 1.93954840e-01f, 2.43206277e-01f, -2.73859650e-01f, -1.79306611e-01f, 2.11384580e-01f,
  4.36553329e-01f, 9.40400884e-02f, 7.66366199e-02f, -3.52449752e-02f, -2.64220387e-01f, 3.65179747e-01f, 2.73864210e-01f, -2.69036978e-01f, -5.24333656e-01f, -3.77812058e-01f,
  1.80895761e-01f, -2.20419675e-01f, -5.38120270e-01f, -2.11936831e-01f, 8.63488540e-02f, 2.47482937e-02f, 1.50461450e-01f, 2.44435832e-01f, 2.06565633e-01f, 3.77399743e-01f,
  8.62477794e-02f, -1.07569240e-01f, 8.63293558e-02f, 1.34814769e-01f, 3.04704934e-01f, -2.54715621e-01f, 2.41448786e-02f, -4.79130931e-02f, -1.46963760e-01f, -1.85639206e-02f,
  2.79484153e-01f, -2.28585273e-01f, 2.18238488e-01f, -1.65722352e-02f, -2.51701057e-01f, -2.36009061e-01f, -1.83621615e-01f, -2.04718396e-01f, -3.86338174e-01f, -2.22865298e-01f,
  3.72819662e-01f, 2.87552148e-01f, -3.49237807e-02f, -1.02924585e-01f, -3.82169694e-01f, 1.46265358e-01f, -7.72669688e-02f, -8.44985992e-02f, -3.45951080e-01f, -6.03039682e-01f,
  2.16381568e-02f, 1.79274395e-01f, 1.07540898e-02f, -3.81484330e-02f, -5.99402152e-02f, 9.31993276e-02f, 5.94783984e-02f, -4.68572564e-02f, -5.90806967e-03f, -5.75240776e-02f,
  4.66007292e-02f, 3.94039899e-02f, -8.59637558e-03f, -2.42296439e-02f, -5.92045709e-02f, 1.39393330e-01f, 1.80890299e-02f, -1.24296479e-01f, 6.29670620e-02f, -5.14158979e-02f,
  -4.14191233e-03f, -1.80290807e-02f, 1.73358154e-02f, -1.88307136e-01f, 3.06101181e-02f, 5.25177876e-03f, -3.34468577e-03f, 1.87471248e-02f, -9.15375799e-02f, 6.20962195e-02f,
  -3.26134533e-01f, 2.09013477e-01f, 1.57702580e-01f, -6.40387982e-02f, 5.45206144e-02f, -1.24141164e-01f, 4.54764478e-02f, -2.09033087e-01f, -1.65946409e-01f, -2.25202456e-01f,
  -9.59767848e-02f, 3.79016250e-02f, -8.00758321e-03f, 1.30526340e-02f, -1.40471771e-01f, -7.46788159e-02f, 1.60770223e-01f, 2.85815112e-02f, -2.85634119e-02f, 2.54797190e-02f,
  -5.88341206e-02f, -1.83717161e-01f, -2.02934340e-01f, -1.45381549e-02f, 3.90416756e-03f, -1.80712014e-01f, -1.56194955e-01f, -2.32084572e-01f, -3.47086698e-01f, -3.88894171e-01f,
  3.76189530e-01f, -5.10052368e-02f, -4.41687882e-01f, 3.70323777e-01f, -9.40340757e-02f, -4.64259088e-01f, -3.12960893e-01f, -2.81114459e-01f, 3.53457123e-01f, 1.36268824e-01f,
  6.69690743e-02f, 1.06194772e-01f, 4.78959717e-02f, -2.31966987e-01f, -5.51529646e-01f, -1.66011706e-01f, -2.64470965e-01f, -3.72947276e-01f, -5.22079766e-01f, -4.18278873e-01f,
  2.52304059e-02f, 1.17840037e-01f, -7.91605338e-02f, -2.61683404e-01f, 2.81666368e-01f, -8.72792229e-02f, 9.67258122e-03f, -7.51451328e-02f, -3.48438680e-01f, 6.37810454e-02f,
  -7.60605885e-03f, -3.44780460e-02f, -1.44007847e-01f, -9.34619009e-02f, 1.05456142e-02f, -4.16674800e-02f, -2.14244321e-01f, 1.11014647e-02f, 3.09528783e-03f, 2.41380278e-02f,
  5.25838742e-03f, -1.67089105e-02f, -9.48518738e-02f, -1.15839794e-01f, -1.55010864e-01f, -9.43634808e-02f, -1.59571879e-02f, -1.99528039e-01f, 2.11854167e-02f, -7.22316653e-02f,
  1.48349091e-01f, -1.86334737e-03f, -2.71838337e-01f, -1.52610675e-01f, -2.60184318e-01f, -1.98012725e-01f, -1.57679081e-01f, -3.23969334e-01f, -5.06735206e-01f, -6.68403320e-03f,
  8.25169533e-02f, 2.41290312e-02f, -1.77037083e-02f, -8.39196593e-02f, 8.22022036e-02f, 6.00267611e-02f, -4.70132343e-02f, 2.26029987e-03f, 2.52345228e-04f, 2.89867651e-02f,
  -2.41151750e-02f, 7.77991638e-02f, 7.03873695e-04f, -6.04157969e-02f, 1.36117758e-02f, -3.79687804e-03f, 2.94762608e-02f, 9.93488170e-03f, -1.45391542e-02f, -1.55910058e-02f,
  -2.99336445e-02f, -5.44189475e-03f, 6.73566088e-02f, -9.21359882e-02f, -5.10174315e-03f, -5.95390499e-02f, -9.35644656e-02f, -6.82911202e-02f, 1.83945354e-02f, -2.01234426e-02f,
  2.76663959e-01f, -1.57944560e-01f, 2.68901289e-01f, -6.07509539e-02f, -5.84449396e-02f, 3.02188043e-02f, 9.60754231e-02f, -3.53572741e-02f, 1.56395659e-01f, 3.62792686e-02f,
  -1.76758036e-01f, 5.98958693e-02f, 8.09703581e-03f, -6.15646876e-02f, -1.88931879e-02f, -1.26724124e-01f, -4.46950346e-02f, -8.64159241e-02f, -6.63906708e-02f, 2.36506090e-01f,
  4.89396192e-02f, -1.36771634e-01f, 7.61799216e-02f, 8.11254233e-02f, 9.21022743e-02f, -3.55528318e-03f, 9.65408050e-03f, 3.18350531e-02f, -2.56550699e-01f, 3.16224307e-01f,
  4.04130518e-02f, -4.28479910e-01f, 3.77712250e-01f, 3.92432123e-01f, -1.04040682e-01f, -1.52222261e-01f, -3.28813583e-01f, -1.60819784e-01f, 1.12754352e-01f, -8.53130966e-03f,
  -4.62868333e-01f, -9.00753960e-03f, -1.75090635e-03f, 1.27987102e-01f, 1.54703423e-01f, 2.30715662e-01f, 4.90191162e-01f, 5.94418526e-01f, 2.63999194e-01f, -1.25534058e-01f,
  1.32510811e-01f, 2.85228461e-01f, 1.56477258e-01f, 2.35114694e-01f, 4.82099466e-02f, 1.77989215e-01f, 1.63950562e-01f, -5.12663685e-02f, -4.02677571e-03f, 5.15839934e-01f,
  1.20757304e-01f, -1.67674899e-01f, 1.15733463e-02f, -2.91031122e-01f, -7.87456557e-02f, -8.95753503e-02f, -1.41483888e-01f, 7.43076112e-03f, -7.28562027e-02f, 3.62550355e-02f,
  -1.02196328e-01f, 9.46044028e-02f, -1.00905955e-01f, 9.35202315e-02f, -1.27142400e-01f, -1.36641994e-01f, 6.22195899e-02f, 1.84849069e-01f, 1.54517993e-01f, -1.72111988e-02f,
  7.38737732e-02f, -2.43538797e-01f, -2.67600328e-01f, -6.06873259e-02f, 1.05407551e-01f, 9.13205817e-02f, -3.71428788e-01f, -1.79495662e-01f, -9.18949842e-02f, 1.26242384e-01f,
  2.79315170e-02f, -1.16257057e-01f, -5.91785349e-02f, 7.85904601e-02f, 6.11145683e-02f, 1.61494948e-02f, 1.33531749e-01f, -6.09269775e-02f, 6.75362051e-02f, -1.52251904e-03f,
  7.94060528e-03f, -3.02651711e-02f, -6.85432926e-02f, -8.93534347e-03f, -2.87837386e-02f, 1.11221284e-01f, 1.54701695e-01f, 4.59433757e-02f, -3.91027927e-02f, 5.41715547e-02f,
  3.70288119e-02f, 1.57677025e-01f, 8.59643817e-02f, 1.40837967e-01f, 1.01568945e-01f, 7.89985433e-02f, 6.59560636e-02f, -8.18634406e-02f, -8.44702497e-02f, -6.88173920e-02f,
  -2.48506531e-01f, -9.69517976e-02f, 2.08722055e-01f, -7.91289285e-02f, -6.22459874e-02f, -1.88189179e-01f, -1.47585362e-01f, 3.12531479e-02f, -1.26814306e-01f, -7.23925605e-02f,
  -2.24394530e-01f, -1.74451381e-01f, -4.09748368e-02f, 3.87159269e-03f, 9.42334160e-02f, -1.14394605e-01f, -1.88051298e-01f, 1.90243110e-01f, -3.72584537e-02f, -6.13241047e-02f,
  7.58701712e-02f, -2.99022824e-01f, -2.08738148e-01f, 1.39192259e-02f, -2.35802054e-01f, -2.22463220e-01f, -1.88241109e-01f, -1.56966925e-01f, -1.61069587e-01f, -1.37102425e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.12877148e-01f, 4.75607872e-01f, 5.56601405e-01f, 2.85295516e-01f, -6.58283606e-02f, 5.11094272e-01f, 8.19393396e-02f, 4.77288336e-01f, 1.25252858e-01f, -3.28184158e-01f,
  -1.02630578e-01f, 4.31338221e-01f, 2.00384125e-01f, 4.77698326e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.17018783e-01f, 1.72128454e-01f, -1.32456273e-01f, 1.27213627e-01f, -5.98360114e-02f, 1.08882807e-01f, -3.81039917e-01f, -3.24563622e-01f, 2.55844891e-01f, -3.49556595e-01f,
  1.78856581e-01f, -1.35037690e-01f, -3.08361053e-01f, 2.58622319e-01f, 4.40530241e-01f, -3.55163336e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.34172717e-01f, 3.28683525e-01f, 1.93728119e-01f, 3.76678556e-01f, 2.43661255e-01f, 6.34620428e-01f, -1.00518383e-01f, 4.17771310e-01f, 1.20180406e-01f, 6.07436061e-01f,
  -1.75935522e-01f, -4.60231125e-01f, -2.51002580e-01f, 3.98861408e-01f, 7.30059072e-02f, 7.32311130e-01f, 5.35396457e-01f, 2.86413074e-01f, 8.38129461e-01f, -2.62352496e-01f,
  -8.37307274e-01f, 1.48016319e-01f, -5.81806481e-01f, 4.90629047e-01f, -1.09003820e-01f, 4.14024919e-01f, 2.25704849e-01f, -5.14677644e-01f, -1.39756843e-01f, 2.94823050e-01f,
  5.40144324e-01f, 1.58285256e-02f, 2.51133204e-01f, -4.59270805e-01f, -8.53610039e-02f, 3.21479321e-01f, 3.39251399e-01f, -1.19173877e-01f, 3.34681869e-01f, 3.20267260e-01f,
  1.77218497e-03f, 1.50332615e-01f, -3.18575621e-01f, 2.43348652e-03f, 4.50325072e-01f, 3.98191154e-01f, -3.53603333e-01f, 1.48122549e-01f, 4.76939917e-01f, 2.93299437e-01f,
  7.75143087e-01f, -4.92270321e-01f, 3.06005239e-01f, -1.07728854e-01f, 4.93632168e-01f, 2.64535159e-01f, 1.16394632e-01f, 1.37144849e-01f, 3.49259824e-01f, -1.34719118e-01f,
  2.02851549e-01f, -4.81329203e-01f, 6.00322843e-01f, -4.31081384e-01f, 1.69430733e-01f, -8.28666210e-01f, -2.20106572e-01f, -4.32694793e-01f, 4.94381279e-01f, 3.19825947e-01f,
  1.79610133e-01f, 1.96409956e-01f, -1.65081054e-01f, -4.16148365e-01f, -4.93377715e-01f, -2.58060116e-02f, 5.42360246e-01f, 5.59995949e-01f, -2.91367531e-01f, 3.41178119e-01f,
  3.94364864e-01f, -1.20406538e-01f, 7.07346976e-01f, 4.10819799e-01f, -1.14079431e-01f, -2.59080529e-01f, 5.47792614e-01f, 4.50565308e-01f, -5.87764196e-02f, 1.13853075e-01f,
  4.51931238e-01f, -4.05697823e-02f, -3.33969325e-01f, -1.27183255e-02f, -1.21265464e-01f, 1.56145943e-02f, 2.84192383e-01f, -1.22234978e-01f, -1.75301824e-02f, -1.57767013e-01f,
  -3.88155803e-02f, 1.53902248e-01f, -5.54389894e-01f, 2.30362535e-01f, -1.57322526e-01f, -6.60315454e-02f, 6.94075108e-01f, -6.50618553e-01f, 1.36377618e-01f, 8.91485751e-01f,
  -3.26066554e-01f, -3.51912290e-01f, -7.48845860e-02f, 8.32492393e-03f, -4.70640123e-01f, 2.08287284e-01f, 3.49780917e-02f, 5.46637952e-01f, -1.35244742e-01f, -2.05878034e-01f,
  1.27388924e-01f, -3.39291215e-01f, -5.08895993e-01f, -2.83711046e-01f, -3.28716457e-01f, 3.11635345e-01f, 6.57200515e-01f, 4.12587643e-01f, 3.40055257e-01f, 6.03701532e-01f,
  6.59632325e-01f, -1.71409935e-01f, 1.60781294e-01f, 2.95191318e-01f, 1.05573617e-01f, -5.89765869e-02f, 2.14684919e-01f, 4.01783347e-01f, -1.03047848e-01f, -7.12945223e-01f,
  -2.99679458e-01f, 4.43534106e-02f, 6.74026251e-01f, 3.00891865e-02f, 3.64923924e-02f, -1.15546174e-02f, -2.04814728e-02f, 4.39051002e-01f, 3.30387264e-01f, -3.44562978e-01f,
  3.58308345e-01f, 2.04408363e-01f, 4.13256377e-01f, 6.61971688e-01f, -1.90792561e-01f, 1.75946251e-01f, -2.46714562e-01f, -5.30494869e-01f, -1.55386120e-01f, 1.43569168e-02f,
  4.44115460e-01f, -3.67221892e-01f, -3.28678302e-02f, -6.05096579e-01f, 5.33854738e-02f, 2.88176298e-01f, -6.64789796e-01f, 2.24400491e-01f, 4.19457734e-01f, 5.94540477e-01f,
  3.12534869e-02f, -2.02566057e-01f, -3.89643341e-01f, 6.16201162e-01f, -1.80892929e-01f, -6.78169483e-04f, 3.69351879e-02f, 4.72248644e-01f, -8.23579878e-02f, 5.04202008e-01f,
  -1.03922427e+00f, 4.71824646e-01f, -1.16781211e+00f, 2.44758204e-01f, -3.51619065e-01f, -4.08152074e-01f, 2.36378700e-01f, -7.65490308e-02f, -5.52774429e-01f, -1.51443884e-01f,
  -1.84403375e-01f, 4.29204494e-01f, 2.62013227e-01f, 1.07645970e-02f, -5.98324299e-01f, 2.31304750e-01f, 4.89948660e-01f, -6.86564073e-02f, 4.69647110e-01f, -1.32079631e-01f,
  -7.28284001e-01f, -5.19384086e-01f, -3.99204642e-01f, -7.86843121e-01f, 7.85400867e-01f, -1.31255582e-01f, -4.77817878e-02f, 2.26852849e-01f, 3.25811177e-01f, 7.93031752e-02f,
  5.14396906e-01f, 1.10252254e-01f, 1.71585977e-01f, -9.32302624e-02f, 4.03376490e-01f, 6.00041866e-01f, -3.76320928e-01f, 1.32581368e-01f, 7.60930538e-01f, 1.23217300e-01f,
  3.75362299e-02f, -2.14901105e-01f, -4.46410440e-02f, 6.35644794e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.72581947e-01f, 4.70612705e-01f, 1.21770926e-01f, 7.05113828e-01f, 7.64485598e-02f, -2.87642889e-02f, 3.30124915e-01f, 4.54991549e-01f, 1.76186264e-01f, -4.58268434e-01f,
  -1.18698128e-01f, 3.09157997e-01f, 2.99344003e-01f, 5.05593777e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  6.27685010e-01f, 4.27521169e-01f, -6.45411611e-02f, 4.97035235e-02f, 4.22675919e-04f, -1.78745136e-01f, -1.57313511e-01f, -1.71474874e-01f, -3.42734843e-01f, 1.88101873e-01f,
  4.12484705e-01f, 5.35661355e-02f, -3.04833263e-01f, 2.31325418e-01f, -5.39931394e-02f, -5.30821122e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.17229313e-01f, -7.71849930e-01f, 4.00909990e-01f, -3.50505896e-02f, 2.87631243e-01f, 2.78342754e-01f, -3.22131962e-01f, 4.86897022e-01f, -3.65009278e-01f, -4.37306106e-01f,
  5.42775631e-01f, 5.80757439e-01f, 2.10248753e-01f, -9.11538079e-02f, -1.55971661e-01f, 4.31918234e-01f, 1.76950753e-01f, -7.68882871e-01f, 4.40153867e-01f, -3.57752234e-01f,
  2.05967352e-01f, -1.53768398e-02f, -2.63445854e-01f, 5.63667826e-02f, -6.09779894e-01f, -1.25334695e-01f, -1.20754063e-01f, -1.77409157e-01f, -7.78482437e-01f, 3.90315413e-01f,
  4.97192115e-01f, 4.14599061e-01f, 7.99985409e-01f, 4.19122070e-01f, 1.37377858e-01f, 9.09535587e-01f, -2.95253128e-01f, 5.17589569e-01f, -2.09273785e-01f, -8.60205144e-02f,
  -4.56911445e-01f, -1.88890293e-01f, 4.01299685e-01f, -4.39052582e-01f, 1.22585952e-01f, -4.16628391e-01f, 3.36128324e-01f, -9.01882350e-02f, -4.51139987e-01f, -1.17469513e+00f,
  3.33547294e-01f, 6.67485297e-02f, 3.70868862e-01f, 3.94113392e-01f, 6.10240877e-01f, -1.59872286e-02f, -2.13565007e-01f, 5.56032121e-01f, 3.34517330e-01f, 3.22035253e-01f,
  5.27683854e-01f, -3.29337716e-01f, -1.91548973e-01f, 1.49021789e-01f, -2.51018722e-02f, 5.84241807e-01f, -5.57179809e-01f, 3.57980341e-01f, 2.96516418e-01f, 4.61638331e-01f,
  5.32938540e-01f, -3.23599935e-01f, 5.52181005e-01f, -3.25404376e-01f, 2.07453500e-02f, 2.16008410e-01f, -3.15510631e-01f, 5.46219409e-01f, 4.55391496e-01f, -2.07760055e-02f,
  5.86525261e-01f, -6.18589520e-01f, -3.49537991e-02f, -2.44094938e-01f, 3.41051906e-01f, 2.78892964e-01f, 2.97794014e-01f, 8.29225313e-03f, -5.64332485e-01f, -3.50856669e-02f,
  2.02274650e-01f, -3.95377189e-01f, -9.10072744e-01f, 1.05387636e-01f, 7.49979317e-01f, 3.63721639e-01f, 1.12306464e+00f, 7.20803678e-01f, 4.47484165e-01f, 1.96068764e-01f,
  -2.08905995e-01f, 1.06303088e-01f, 1.05595300e-02f, -3.11678529e-01f, -7.96540201e-01f, 7.17621028e-01f, 4.77845430e-01f, -2.76153684e-01f, 4.90010194e-02f, 4.49483365e-01f,
  -1.34184420e-01f, -2.60001570e-01f, 6.64341211e-01f, -4.24658358e-01f, -1.63303301e-01f, 5.10795772e-01f, 2.03625500e-01f, 3.96229416e-01f, 6.60398960e-01f, 3.02076131e-01f,
  -5.96091114e-02f, -3.81978542e-01f, -1.02303870e-01f, -4.09843832e-01f, -3.23128819e-01f, 4.56658341e-02f, 5.82682073e-01f, 5.64603746e-01f, 3.37059528e-01f, -2.76363641e-01f,
  3.55644733e-01f, 1.76696032e-02f, 2.74134070e-01f, -8.96629468e-02f, 4.38819498e-01f, -4.08841670e-01f, -2.31828466e-01f, 4.57151264e-01f, -2.09986612e-01f, -4.18971360e-01f,
  -2.20952883e-01f, 3.85428220e-01f, 2.66624808e-01f, -2.45145589e-01f, 3.19172233e-01f, -6.04487717e-01f, 2.66780734e-01f, -4.16952342e-01f, 3.63677859e-01f, -1.98252097e-01f,
  1.58084050e-01f, 3.64346206e-01f, -5.93078732e-01f, 5.74278235e-01f, -4.30876296e-03f, 2.14630723e-01f, -4.16609734e-01f, 3.72343749e-01f, 3.56161952e-01f, 1.42542392e-01f,
  -1.65719107e-01f, 4.14115310e-01f, 1.39304977e-02f, 8.85731816e-01f, 4.66310792e-02f, 3.53037834e-01f, 1.71465635e-01f, 6.26296520e-01f, 1.12369978e+00f, -2.19600186e-01f,
  1.92265660e-01f, -4.11053121e-01f, 6.15721762e-01f, 4.99318033e-01f, -2.37539470e-01f, 5.17822504e-01f, 2.71251708e-01f, -6.03537381e-01f, 3.75558406e-01f, -2.33127968e-03f,
  4.51909900e-01f, -1.48050308e-01f, 4.80697751e-01f, -3.08147788e-01f, -3.74766737e-01f, 7.30950177e-01f, -2.34677251e-02f, -5.94710052e-01f, 2.12614033e-02f, -5.31081297e-03f,
  2.00676277e-01f, -1.31739542e-01f, 3.85810763e-01f, 2.15597034e-01f, 3.04700464e-01f, 7.92794943e-01f, -3.55722398e-01f, 6.61210954e-01f, -3.93429965e-01f, 1.46915346e-01f,
  -1.25313431e-01f, -1.49525523e-01f, 5.63710034e-01f, -2.10895553e-01f, 2.75868084e-03f, 2.06854329e-01f, 1.35746256e-01f, 1.50323927e-01f, 9.07719970e-01f, 2.21691489e-01f,
  4.28941846e-01f, -1.14934042e-01f, 2.93261886e-01f, 1.56937569e-01f, 5.25982440e-01f, -3.61379057e-01f, 6.03349805e-01f, 1.73309118e-01f, -1.08032078e-01f, -4.80218202e-01f,
  -1.32194147e-01f, 8.90338942e-02f, 1.81315780e-01f, 9.17869955e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.08697900e-01f, 8.97854418e-02f, 3.07552993e-01f, 2.15884689e-02f, 3.20656419e-01f, 2.19530180e-01f, 6.47724390e-01f, 4.45910573e-01f, 1.69992521e-01f, 1.84214219e-01f,
  1.76359490e-01f, 2.11609125e-01f, 3.65730792e-01f, 3.46907705e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.10522398e-01f, -3.50385070e-01f, 1.62580073e-01f, -4.08647418e-01f, 8.50663483e-02f, 4.27435458e-01f, -5.42276278e-02f, -3.00004482e-01f, 1.49169445e-01f, 7.89437369e-02f,
  -1.38772622e-01f, 2.04147041e-01f, 1.05627738e-01f, -1.70413956e-01f, -1.27438217e-01f, -3.08584720e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  6.38584077e-01f, -6.91814363e-01f, 3.41318190e-01f, 6.18662760e-02f, 5.54005504e-01f, -3.47998857e-01f, 2.44649425e-01f, 1.41627446e-01f, 1.65064901e-01f, 4.48829561e-01f,
  -5.26581287e-01f, -3.96686673e-01f, 5.90125263e-01f, -3.06705773e-01f, 5.82876563e-01f, 3.21022272e-01f, 8.47077429e-01f, 9.48602736e-01f, -1.66924238e-01f, -2.62001902e-01f,
  8.44474137e-01f, -1.05893068e-01f, 1.79636016e-01f, 1.80451989e-01f, 8.44265282e-01f, 5.03579266e-02f, -2.71804839e-01f, -2.00857177e-01f, -3.60696942e-01f, 1.52499214e-01f,
  5.19364536e-01f, 4.88438345e-02f, -3.70798826e-01f, 2.05574781e-01f, 5.07274449e-01f, 3.09286356e-01f, 1.37010708e-01f, 6.50937185e-02f, -3.80717307e-01f, -6.62087277e-02f,
  5.19251287e-01f, 6.23539500e-02f, 1.47320107e-01f, -7.48425256e-03f, 7.13619232e-01f, -2.63013870e-01f, 7.46077776e-01f, -4.59707707e-01f, 3.27040732e-01f, 5.08699000e-01f,
  1.04389377e-01f, -5.76461792e-01f, 2.51026452e-01f, 5.06481528e-01f, -5.86603999e-01f, -5.70369303e-01f, 5.87824658e-02f, -1.82692543e-01f, 1.57177001e-01f, 2.28322804e-01f,
  3.72467749e-02f, 5.97578645e-01f, -1.06527805e-01f, 8.33662227e-02f, 8.00419152e-01f, 5.13070881e-01f, 2.14739949e-01f, 3.32290471e-01f, -1.32318050e-01f, 1.67043656e-01f,
  -5.45954108e-01f, 1.12709124e-02f, 1.27512133e+00f, -4.55587536e-01f, 6.63215399e-01f, 5.27360320e-01f, -6.70839027e-02f, 4.53748405e-01f, -9.22659338e-02f, 4.92868572e-01f,
  -4.16898668e-01f, 3.44536215e-01f, -8.08720440e-02f, 9.71678644e-02f, -3.75767946e-01f, 2.92936474e-01f, 3.17967176e-01f, 2.24732786e-01f, -4.91349459e-01f, 9.48221609e-02f,
  8.83329213e-02f, 1.54845268e-02f, 9.04488117e-02f, 2.45834351e-01f, -3.81640017e-01f, 7.20804930e-02f, 2.56489545e-01f, 4.89292383e-01f, 6.87758997e-02f, 9.38259244e-01f,
  4.69246179e-01f, -2.01206133e-01f, 3.92440885e-01f, 8.89687896e-01f, -6.27851579e-03f, 4.09512222e-01f, 3.48088294e-01f, 7.54666507e-01f, -4.09814924e-01f, 2.15137094e-01f,
  7.25862682e-02f, 5.94704561e-02f, -2.83039778e-01f, -5.48823237e-01f, 2.45478839e-01f, 3.22674632e-01f, 3.69495183e-01f, 4.12644953e-01f, -2.13834316e-01f, 5.08264542e-01f,
  -4.14999068e-01f, 3.93075556e-01f, 2.73356050e-01f, 1.84497416e-01f, -1.63684845e-01f, 4.71500456e-01f, 2.97491327e-02f, -1.10758143e-02f, -1.83185622e-01f, 1.29298374e-01f,
  1.53073311e-01f, 9.21609282e-01f, -6.71257734e-01f, -1.17660016e-01f, 2.23558098e-01f, 5.33266425e-01f, -2.71762937e-01f, 3.59699309e-01f, 3.11113358e-01f, 6.39665008e-01f,
  -6.95842579e-02f, 3.11858565e-01f, -1.30632758e-01f, -6.17146268e-02f, -7.26838827e-01f, 3.72860372e-01f, -2.94370413e-01f, 1.40617579e-01f, 7.71526873e-01f, -2.61458665e-01f,
  4.79681224e-01f, 2.40380868e-01f, 6.61833286e-02f, 4.28611845e-01f, -8.09717737e-03f, -2.57712036e-01f, 1.77006036e-01f, 3.22418846e-02f, 3.18937093e-01f, 1.72931448e-01f,
  4.87039983e-01f, -1.04123783e+00f, -1.92760024e-02f, -1.02862291e-01f, -3.85180533e-01f, 2.98650920e-01f, -2.01361120e-01f, 3.44137438e-02f, -2.27641582e-01f, 2.70683676e-01f,
  3.45960945e-01f, 1.01007149e-01f, -1.13795146e-01f, 4.50643122e-01f, -4.63786304e-01f, 4.13800567e-01f, -1.18182287e-01f, 8.35867405e-01f, 9.28547680e-02f, 1.89773604e-01f,
  3.15895587e-01f, 4.49484944e-01f, -1.13634324e+00f, -4.71221954e-01f, 5.03999829e-01f, -2.67508656e-01f, -7.09431246e-02f, -2.66651124e-01f, 3.15600378e-03f, 8.57048854e-02f,
  7.72653401e-01f, -1.62124962e-01f, -6.41871035e-01f, -8.76060948e-02f, 3.91804159e-01f, -3.12570333e-01f, 4.23628874e-02f, 5.56167006e-01f, 5.74748158e-01f, 1.13670498e-01f,
  -4.75756943e-01f, 3.79602194e-01f, -2.07104981e-01f, -2.32612088e-01f, 4.39749330e-01f, -1.36666030e-01f, 2.73410022e-01f, 7.01284483e-02f, -1.90501317e-01f, 5.47662199e-01f,
  -5.94987631e-01f, -1.24627292e-01f, 9.43009648e-03f, 1.93540659e-02f, 7.43961871e-01f, 1.23549543e-01f, 2.55317718e-01f, 2.86598057e-01f, 4.96980339e-01f, 2.70965137e-02f,
  1.90840721e-01f, 4.25352514e-01f, 1.67757064e-01f, 6.54023588e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  7.09946752e-01f, 5.87650895e-01f, -2.04479054e-01f, 1.93591624e-01f, -2.03304775e-02f, 3.38656083e-02f, 4.34512973e-01f, -4.70096260e-01f, 1.52303815e-01f, -6.12483859e-01f,
  6.64292872e-02f, -1.67372718e-01f, -2.00766146e-01f, 2.39851460e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.92752987e-01f, 2.15287700e-01f, -1.40842915e-01f, -6.83200508e-02f, -4.13666904e-01f, 6.54735565e-02f, -7.29939401e-01f, 2.52204895e-01f, 1.66165650e-01f, -1.29280007e-02f,
  2.00031176e-01f, 3.93107891e-01f, -7.08189607e-01f, -4.08883154e-01f, 3.56646746e-01f, 6.18605390e-02f, -4.53815371e-01f, -1.37534842e-01f, -2.79659424e-02f, -5.46482205e-01f,
  3.04142088e-01f, -7.24734187e-01f, -2.19623093e-02f, -9.03677121e-02f, -3.99642698e-02f, 3.44272465e-01f, 3.15469921e-01f, -7.00729132e-01f, -5.75769842e-01f, -5.00609353e-02f,
  1.58084780e-01f, -9.45809722e-01f, -8.16394165e-02f, 1.50134861e-01f, -5.72593927e-01f, -5.50374866e-01f, -6.63281977e-01f, 1.94157168e-01f, 2.74922937e-01f, 1.07677497e-01f,
  3.00664127e-01f, 2.96349883e-01f, 3.98935169e-01f, -9.14443851e-01f, 4.45219100e-01f, -3.80659759e-01f, -6.92602098e-01f, -2.61709601e-01f, -4.36488867e-01f, -2.22264200e-01f,
  -3.19018692e-01f, -6.33522928e-01f, -1.08439159e+00f, -7.19560683e-01f, -5.13422668e-01f, 3.10859025e-01f, -1.45143364e-03f, 1.76492453e-01f, 2.60647595e-01f, 9.63682383e-02f,
  7.14411616e-01f, 7.55213127e-02f, -3.84043865e-02f, 2.93525577e-01f, 3.40965658e-01f, -1.22375512e+00f, 1.15100003e-03f, 2.91200489e-01f, -3.40793580e-01f, -3.41756344e-02f,
  2.63268918e-01f, -3.39901328e-01f, 1.41088858e-01f, 3.50517243e-01f, -1.11936375e-01f, 1.91917613e-01f, 5.73513284e-02f, -6.24079823e-01f, -1.00476980e-01f, 4.53460440e-02f,
  -9.74879339e-02f, 3.02358687e-01f, 3.98882478e-01f, 5.48431456e-01f, 8.24148878e-02f, -3.55104476e-01f, -2.35051185e-01f, 2.23044559e-01f, -3.70493121e-02f, -3.32340747e-01f,
  -4.39830720e-02f, 2.79974848e-01f, -3.44164446e-02f, -1.41200408e-01f, -1.20564491e-01f, -4.20143187e-01f, -3.07773501e-01f, -2.86100924e-01f, -8.22816670e-01f, -1.34234563e-01f,
  1.43382207e-01f, -1.48039937e-01f, 4.24776584e-01f, -9.68600586e-02f, 3.71613532e-01f, -5.96975029e-01f, 4.88533497e-01f, 3.83819938e-02f, -8.23720396e-01f, -1.18480157e-02f,
  -7.44773328e-01f, 9.04318616e-02f, -1.35436535e-01f, 1.94628444e-02f, -4.78417665e-01f, -9.08008635e-01f, 1.51439101e-01f, 5.55331826e-01f, 5.63694537e-02f, 2.15971008e-01f,
  -6.96154296e-01f, -3.87622528e-02f, 1.79724232e-03f, 9.20047425e-03f, 1.90043136e-01f, -3.82024646e-01f, 2.70312428e-01f, 3.83000523e-01f, -4.94622700e-02f, -1.90928653e-02f,
  -1.25406794e-02f, -5.06885767e-01f, 3.44772428e-01f, 1.44057453e-01f, -6.83096468e-01f, 5.89308143e-02f, -1.26899540e+00f, 3.60468924e-01f, -7.75724649e-01f, 4.95018303e-01f,
  4.64097500e-01f, 1.66719392e-01f, 1.04962744e-01f, -4.84425813e-01f, 9.63547111e-01f, 3.58549237e-01f, -4.88469720e-01f, 3.41700017e-01f, -4.57520485e-02f, 4.97641236e-01f,
  4.22652841e-01f, -5.74953496e-01f, -3.50273222e-01f, -4.71118748e-01f, -6.85724854e-01f, -2.49471366e-02f, -6.47578249e-03f, 1.73347846e-01f, -5.99610329e-01f, 4.33947831e-01f,
  -2.43816823e-01f, 5.19124866e-01f, -1.93938669e-02f, 2.97432452e-01f, 1.85559750e-01f, 3.10268342e-01f, 5.09338498e-01f, -5.27671814e-01f, -8.20546746e-01f, -2.91357100e-01f,
  -1.18729854e+00f, -1.15374863e+00f, -3.56866390e-01f, 6.45997107e-01f, -2.20762044e-01f, -9.16742802e-01f, 3.55687231e-01f, 1.04687917e+00f, 5.87683141e-01f, -3.81158620e-01f,
  1.36780098e-01f, -8.86070132e-01f, -1.35444045e-01f, -5.92523158e-01f, -1.04504371e+00f, -8.23408246e-01f, -4.59667087e-01f, -1.59902722e-01f, -6.10745907e-01f, -1.14757192e+00f,
  2.56140709e-01f, 2.08257765e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.16007417e-01f, -1.16604462e-01f, 1.12787209e-01f, -1.10390387e-01f, -9.63235870e-02f, 3.44895810e-01f, -9.69106797e-03f, -1.11405261e-01f, -1.24795381e-02f, 1.47891581e-01f,
  -2.15440750e-01f, 7.10868657e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    