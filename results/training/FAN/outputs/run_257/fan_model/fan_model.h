/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.11600156e-02f, 1.23523310e-01f, -2.79034078e-01f, 1.48435421e-02f, -8.92992541e-02f, -8.06910098e-02f, -2.32142117e-02f, -2.01056860e-02f, 7.06297010e-02f, 2.14919567e-01f,
  -7.54672568e-03f, 1.78313069e-02f, 1.45403534e-01f, -1.27637936e-02f, 2.56534576e-01f, 1.28102913e-01f, 1.96414590e-02f, 6.40289783e-02f, -3.24996226e-02f, 2.52807811e-02f,
  -1.07030712e-01f, 1.34641975e-01f, -2.05297425e-01f, 7.33213592e-03f, -1.91347390e-01f, -2.03015968e-01f, 1.17551424e-01f, -9.63053256e-02f, 5.30755566e-03f, 4.12842259e-02f,
  -6.21836819e-02f, -8.36911574e-02f, -1.45292923e-01f, -3.58557552e-02f, -5.65538667e-02f, -6.53493404e-02f, -1.01560242e-02f, -3.69962007e-02f, -1.25025108e-01f, -1.17818005e-02f,
  -3.02642491e-02f, 5.17042493e-03f, 2.68452484e-02f, 2.24204753e-02f, -4.45612194e-03f, -7.30977356e-02f, -1.09921180e-01f, -1.07736118e-01f, -2.19305456e-02f, -1.16019301e-01f,
  -1.08766451e-01f, -5.64413741e-02f, -6.89833388e-02f, 4.45237495e-02f, -1.26579821e-01f, -3.99567708e-02f, -5.73949255e-02f, 8.91037867e-04f, 4.15587090e-02f, -4.70615327e-02f,
  9.89881381e-02f, -9.31516523e-04f, -2.93920785e-02f, 7.70514905e-02f, 2.91715320e-02f, 2.23384015e-02f, 2.58401167e-02f, 2.72876956e-02f, -2.32634600e-02f, 4.69189398e-02f,
  2.72455602e-03f, 4.35089925e-03f, 8.56542028e-03f, -6.32030815e-02f, 2.83662453e-02f, 7.27203488e-03f, -3.56023014e-02f, 3.16081219e-03f, -1.57781374e-02f, -8.66071600e-03f,
  6.14762641e-02f, 4.69410978e-02f, 1.29012307e-02f, -6.38118684e-02f, 4.47406992e-02f, -3.44569981e-03f, -5.12122251e-02f, -2.86535779e-03f, -4.44103144e-02f, 5.37318215e-02f,
  2.16610178e-01f, 4.05037880e-01f, 5.12744999e-03f, 3.01605556e-02f, 1.02651983e-01f, 6.42774180e-02f, 3.21727879e-02f, 3.30589451e-02f, 1.00820944e-01f, 8.16867873e-02f,
  -4.16240543e-02f, -4.35962752e-02f, 5.99979199e-02f, -3.56915146e-02f, 8.65636207e-03f, 3.37953144e-03f, 1.05187766e-01f, 8.73443931e-02f, 2.57183071e-02f, -3.33939539e-03f,
  4.55991775e-02f, 9.05473828e-02f, 1.02582611e-02f, -2.38333247e-03f, 3.85773443e-02f, 2.22309530e-02f, 4.66734730e-02f, 7.85141820e-05f, -2.62426343e-02f, 8.19337890e-02f,
  3.15994769e-01f, -3.89673978e-01f, -1.89776450e-01f, -1.13805167e-01f, 1.41114458e-01f, 1.52072847e-01f, 1.42755792e-01f, -5.87437786e-02f, -5.11605069e-02f, -2.18842775e-01f,
  4.98754792e-02f, -8.59822035e-02f, -1.23870991e-01f, -6.62751719e-02f, 3.39325368e-01f, -8.58756825e-02f, 2.78517883e-02f, -1.19242601e-01f, -1.64753813e-02f, -8.51622745e-02f,
  6.77347556e-02f, 1.15093738e-01f, -4.56606448e-02f, -9.44960043e-02f, -6.48600534e-02f, -1.42766312e-01f, 3.60736139e-02f, -3.61519344e-02f, -6.51665404e-02f, 9.10318196e-02f,
  1.46641240e-01f, -7.62353539e-02f, 9.27302055e-03f, -5.75996861e-02f, 3.11396900e-03f, -9.80780050e-02f, -7.50467414e-04f, -5.13090705e-03f, 4.67803963e-02f, -9.57976002e-03f,
  -2.60987636e-02f, 2.53660586e-02f, 6.84566125e-02f, 1.96249057e-02f, 1.54508231e-02f, 3.45541053e-02f, -3.09628844e-02f, -1.68769211e-02f, -6.75501395e-03f, 2.90544424e-02f,
  -6.78717941e-02f, -1.52776046e-02f, -5.86784296e-02f, -1.18008092e-01f, -2.37422176e-02f, 6.61986992e-02f, -2.64025219e-02f, -5.73302247e-02f, 2.61923671e-02f, -4.40265313e-02f,
  5.41745238e-02f, -7.68281594e-02f, 1.35603314e-02f, 2.49106288e-02f, -3.55235394e-03f, 8.24991316e-02f, 2.27870364e-02f, -2.34809006e-03f, -3.29510719e-02f, -4.39735129e-02f,
  1.75206158e-02f, -3.64722079e-03f, -5.11927903e-03f, -2.29446013e-02f, 3.65903974e-02f, 4.66271788e-02f, -3.48723419e-02f, -7.62805389e-03f, -6.30009845e-02f, 4.71633077e-02f,
  -2.75592282e-02f, 3.52756418e-02f, -5.66032194e-02f, 4.72283893e-04f, 1.22098979e-02f, 4.55802632e-03f, -3.04045696e-02f, -4.74090800e-02f, 2.96095503e-03f, 3.10606509e-02f,
  -3.42455693e-02f, -1.42486170e-01f, -1.88515894e-02f, 4.65650447e-02f, -1.23163141e-01f, -5.21686450e-02f, 2.21354440e-02f, 5.70360525e-03f, -3.03496066e-02f, 6.74930960e-02f,
  -2.12115794e-02f, -4.01074700e-02f, -4.30121692e-03f, 2.97355582e-03f, 5.03859445e-02f, -4.25041951e-02f, -2.83912811e-02f, 5.62447356e-03f, -1.16477227e-02f, -2.18603667e-03f,
  1.49807369e-03f, 2.05427725e-02f, 3.55434902e-02f, 3.51140536e-02f, -2.98106782e-02f, -3.85584347e-02f, 1.72379632e-02f, 1.30185261e-02f, 3.71200703e-02f, -7.70607889e-02f,
  9.80625823e-02f, 1.08477868e-01f, -1.90357059e-01f, 4.19375300e-03f, 1.82220548e-01f, 1.32268995e-01f, 8.04684535e-02f, -2.58549545e-02f, -8.13630596e-02f, 1.43532500e-01f,
  3.60910594e-02f, -3.51736844e-02f, 2.71832775e-02f, 1.96455836e-01f, -2.25937851e-02f, -1.97961815e-02f, 1.53442189e-01f, 6.30295277e-02f, -5.67934290e-02f, 1.00504212e-01f,
  -9.43404436e-02f, 2.19295204e-01f, -9.59758833e-02f, 8.55429918e-02f, 1.24580041e-01f, -7.97773600e-02f, 1.01104639e-01f, -1.94453057e-02f, 1.73481122e-01f, -1.55916335e-02f,
  1.70802213e-02f, -1.59233227e-01f, -5.27478121e-02f, 3.04758660e-02f, 8.04692283e-02f, -5.81742357e-03f, 4.58330363e-02f, -2.72117369e-02f, -2.51653381e-02f, 1.90004343e-04f,
  1.32507924e-02f, -2.28909706e-03f, 1.98953655e-02f, -1.68461204e-02f, -1.48340752e-02f, -5.60403131e-02f, -4.43511941e-02f, 2.61001941e-02f, -5.55421226e-04f, -3.13021243e-02f,
  -5.87697029e-02f, -6.22474886e-02f, -1.02286888e-02f, 8.83065443e-03f, -1.08857080e-01f, 9.76092275e-03f, -2.37002037e-02f, -6.64512888e-02f, -1.13883968e-02f, -8.74160230e-03f,
  3.45052779e-03f, 7.16776913e-03f, -2.47422270e-02f, 1.48837352e-02f, 3.20949219e-02f, -2.68875650e-04f, 7.09691048e-02f, 2.72840389e-05f, -1.67701077e-02f, 3.15080471e-02f,
  1.57688353e-02f, -2.44767144e-02f, 5.95149957e-03f, 2.00994182e-02f, 5.24170510e-03f, -1.44046172e-02f, 3.10125742e-02f, 4.45979610e-02f, -9.42274462e-03f, -2.85197459e-02f,
  -9.65423603e-03f, -1.54399490e-02f, 6.88374229e-03f, -1.96931958e-02f, -3.00166812e-02f, -2.77174562e-02f, 6.00232221e-02f, -5.76565391e-04f, 2.73948945e-02f, -5.76790273e-02f,
  5.02689719e-01f, 2.08989292e-01f, 6.49977848e-02f, 4.83161546e-02f, 2.29770225e-02f, -1.30992467e-02f, -5.92115968e-02f, 2.09645438e-03f, 2.41491292e-02f, -3.99631262e-02f,
  3.76202613e-02f, 7.38215074e-02f, 1.98302660e-02f, -1.17813749e-02f, 2.62047760e-02f, 2.54098941e-02f, 3.76837403e-02f, 1.11185014e-02f, 8.10970888e-02f, 8.93345848e-02f,
  7.64571130e-02f, 5.88845871e-02f, -1.70446001e-02f, -2.43621506e-02f, 4.54866551e-02f, -3.77937444e-02f, -6.09349413e-03f, -7.70628974e-02f, 1.69854965e-02f, 3.37045640e-02f,
  2.95829415e-01f, -2.66251475e-01f, -4.33990836e-01f, 7.60838762e-02f, 2.57601231e-01f, -7.17127845e-02f, -1.08529076e-01f, 1.78814575e-01f, 5.11071198e-02f, -9.70638171e-03f,
  1.09978117e-01f, -2.27608293e-01f, -1.50366008e-01f, -6.37773573e-02f, 1.15874574e-01f, -1.41200125e-01f, 1.74714327e-01f, 4.65972908e-02f, -1.19289517e-01f, 1.80342391e-01f,
  8.88237655e-02f, 1.50952011e-01f, -1.45954907e-01f, 3.46287489e-02f, 2.55029444e-02f, -3.45185138e-02f, 1.01369955e-01f, -1.14536755e-01f, -1.12212509e-01f, -6.48439974e-02f,
  -1.43463332e-02f, 9.73739997e-02f, -8.26434791e-02f, -6.46134466e-02f, 4.50007133e-02f, 5.22474051e-02f, -1.95873827e-02f, -9.04910415e-02f, -6.86362609e-02f, -1.14149442e-02f,
  -7.44853988e-02f, 1.08199000e-01f, -3.42926458e-02f, -4.93955798e-02f, 7.10192311e-04f, -7.40665421e-02f, -3.62832943e-04f, -6.04085773e-02f, -2.29684915e-02f, 4.82390411e-02f,
  -7.30731413e-02f, -4.55166176e-02f, 5.96987791e-02f, 2.54602525e-02f, -1.15965381e-02f, -2.14493815e-02f, -2.07529925e-02f, -5.41547574e-02f, 1.22139193e-02f, 3.93861532e-02f,
  1.47088319e-02f, 5.36387451e-02f, -1.96162518e-02f, 4.79501225e-02f, -3.86650185e-03f, 5.99665381e-03f, -6.22844249e-02f, 1.31905014e-02f, -5.96168526e-02f, 7.78321922e-02f,
  1.20357625e-01f, -1.19713775e-03f, 7.74708167e-02f, -3.50423902e-02f, -1.32835209e-02f, 3.55119370e-02f, -1.94655657e-02f, -1.11834472e-02f, 1.28335506e-01f, 2.88751815e-02f,
  -4.89150733e-03f, 1.47822993e-02f, 1.82335940e-03f, 7.62830004e-02f, -7.40166893e-03f, -2.80718300e-02f, 5.64129977e-03f, -6.35838090e-03f, 2.84478609e-02f, -2.55528167e-02f,
  1.75010711e-01f, 2.07570389e-01f, 4.40245345e-02f, -4.57799323e-02f, -2.99736783e-02f, -3.80220450e-02f, -3.11283749e-02f, 2.93044467e-02f, -1.03728093e-01f, 1.84925739e-02f,
  -3.09062507e-02f, 1.96386799e-02f, 4.64824922e-02f, 4.61745225e-02f, -6.20283969e-02f, -1.61281358e-02f, 1.25502460e-02f, -1.94266867e-02f, 1.00336872e-01f, 4.20202799e-02f,
  3.44851762e-02f, 4.35405585e-04f, -4.00029831e-02f, 7.91799128e-02f, 6.32257909e-02f, 3.38426069e-03f, 7.73178563e-02f, -3.83331478e-02f, -3.37865725e-02f, -3.81237641e-02f,
  -1.79083049e-01f, -2.68657595e-01f, 1.01343602e-01f, -3.17173377e-02f, 1.84346974e-01f, 3.70097131e-01f, 2.37367511e-01f, 6.17163666e-02f, 9.91684124e-02f, -4.72581349e-02f,
  1.35746196e-01f, -3.56505252e-02f, -6.86789155e-02f, 1.04945228e-01f, 3.06820005e-01f, 5.16390689e-02f, 1.01045288e-01f, -4.17728759e-02f, -8.01086053e-02f, -6.17056480e-03f,
  -1.70205198e-02f, 3.99402492e-02f, 1.69840246e-01f, -2.60617379e-02f, 1.20995142e-01f, -1.65710837e-01f, -4.44123521e-02f, 7.13394256e-03f, 5.89946955e-02f, 1.37295753e-01f,
  1.80375576e-02f, -2.22717673e-01f, 6.77915514e-02f, 3.43681723e-02f, 4.40194719e-02f, 2.86274608e-02f, 7.29127601e-03f, 7.34932497e-02f, -3.65796015e-02f, 4.56300378e-02f,
  -6.40038028e-02f, -5.10006137e-02f, -3.37553583e-02f, 5.22740111e-02f, -8.84353667e-02f, -1.62569247e-03f, -3.24216411e-02f, 1.17647007e-01f, 2.96750478e-02f, 8.67024213e-02f,
  1.00441957e-02f, 5.10625653e-02f, -2.47390289e-02f, 2.52006073e-02f, 4.21302579e-02f, 4.33303154e-04f, 3.95351686e-02f, 4.82386798e-02f, -1.80914029e-02f, 1.92409568e-02f,
  4.74165864e-02f, -4.39999439e-02f, -2.66959779e-02f, -2.52963342e-02f, 3.43217561e-03f, -1.16047570e-02f, -3.14707030e-03f, 6.61237687e-02f, -4.10935618e-02f, 4.90586124e-02f,
  5.66375405e-02f, 2.32235100e-02f, -2.56099924e-02f, 3.17675397e-02f, -4.51863892e-02f, -2.96431892e-02f, -4.99188192e-02f, -9.70953726e-04f, -7.01214597e-02f, 3.56201082e-02f,
  -3.89433131e-02f, -3.69086936e-02f, -3.24900411e-02f, -2.35851631e-02f, 2.22969353e-02f, 8.70379359e-02f, -1.98842399e-02f, -8.17581778e-04f, 4.64275628e-02f, 3.01543269e-02f,
  -2.44067088e-01f, -1.99780211e-01f, 1.28794052e-02f, -1.48707349e-02f, -1.76945841e-03f, 3.59224975e-02f, -9.65209305e-03f, 2.17247847e-02f, -3.05596963e-02f, 3.70459445e-02f,
  1.51275126e-02f, 7.50050554e-03f, -2.26196181e-02f, -6.49145097e-02f, 1.25409933e-02f, 5.00060469e-02f, -4.16474715e-02f, -4.29688506e-02f, 6.40044510e-02f, -1.65504906e-02f,
  -4.41980250e-02f, -3.11533213e-02f, 1.08716890e-01f, -8.54325294e-02f, -3.44613381e-02f, 2.45618261e-02f, -2.94112712e-02f, 2.21610386e-02f, 3.16324830e-02f, 3.59267667e-02f,
  -1.28802629e-02f, 3.41150686e-02f, -7.87752792e-02f, 7.18559176e-02f, 1.32815942e-01f, -1.14791207e-01f, -1.31283477e-01f, 1.47944346e-01f, 7.64149651e-02f, 3.80570702e-02f,
  1.36068881e-01f, -1.67560458e-01f, -1.00692727e-01f, 1.32849261e-01f, -3.21773887e-01f, -1.99697986e-01f, -2.77231447e-02f, -3.15726027e-02f, 8.89666453e-02f, -1.20329950e-03f,
  1.22833364e-02f, 6.39688149e-02f, -1.04193695e-01f, 1.58249184e-01f, 9.95693058e-02f, 1.15193896e-01f, -1.97940506e-02f, -7.39175677e-02f, 7.63527751e-02f, -9.78008844e-04f,
  8.51528198e-02f, 4.74011302e-02f, 3.92719209e-02f, 1.48666715e-02f, 3.91282625e-02f, -3.19108069e-02f, -3.42314765e-02f, -9.20480490e-02f, 2.50342153e-02f, -6.75808042e-02f,
  -4.51949947e-02f, -9.44235362e-03f, 5.87619506e-02f, 2.81468723e-02f, 6.64656684e-02f, 6.63573965e-02f, 5.34334928e-02f, 7.60162696e-02f, 4.78813834e-02f, 1.05593717e-02f,
  -1.61291640e-02f, -1.13342293e-02f, 4.23751175e-02f, -4.18519462e-03f, 4.37381910e-03f, 2.33759638e-02f, -6.38879538e-02f, -3.77156660e-02f, 3.20218056e-02f, 4.29319916e-03f,
  -4.75049689e-02f, -3.90151292e-02f, 2.28823945e-02f, 6.54835999e-02f, 9.85656679e-03f, 6.94697797e-02f, 3.13638374e-02f, -4.61778045e-02f, -1.90219842e-02f, 1.13389716e-02f,
  5.05632423e-02f, -2.51836237e-02f, 8.02850816e-03f, 3.59880738e-02f, -1.66859124e-02f, 1.61006190e-02f, 8.79658200e-03f, -3.13367471e-02f, 6.95805624e-02f, 4.06539999e-02f,
  -3.87750231e-02f, -3.64951529e-02f, -4.25477559e-03f, 2.58991383e-02f, 1.20005822e-02f, -5.13121821e-02f, 1.01051079e-02f, 6.09209277e-02f, 3.92870541e-04f, -7.57382810e-02f,
  -9.35042202e-02f, -2.45963141e-01f, 6.63506016e-02f, 2.46787108e-02f, -6.71033701e-03f, -2.20687576e-02f, -4.40726690e-02f, 7.16220513e-02f, -3.65790576e-02f, -6.04224727e-02f,
  5.63895777e-02f, 1.63079854e-02f, 7.66051700e-03f, 9.79727134e-03f, 7.89316930e-03f, -3.56129669e-02f, -3.62823606e-02f, -9.54881236e-02f, -5.09269647e-02f, 7.03394227e-03f,
  3.06191333e-02f, -3.31718475e-02f, -3.40643637e-02f, 1.58891734e-02f, -4.58442606e-02f, -9.66938678e-03f, -7.21729593e-03f, -2.45115757e-02f, -8.20493102e-02f, 3.75242196e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.89396876e-01f, 1.41592637e-01f, 1.24131255e-02f, -2.10695360e-02f, -3.05903256e-01f, 1.23246707e-01f, 4.08504277e-01f, -2.62581825e-01f, -2.04371676e-01f, 4.14739996e-01f,
  3.86571914e-01f, -2.89030131e-02f, 3.77267271e-01f, 2.93863267e-01f, -1.81202129e-01f, 2.83446014e-01f, 1.84976563e-01f, 1.47096276e-01f, -9.37032178e-02f, -1.96516782e-01f,
  -1.03429727e-01f, 2.36346468e-01f, 1.33051604e-01f, -5.24303243e-02f, 1.77473053e-02f, -1.09411359e-01f, 1.31186411e-01f, 8.68723989e-02f, -3.71946506e-02f, -5.64954011e-03f,
  9.28402022e-02f, -1.55042466e-02f, -6.98526576e-02f, 3.88552919e-02f, -1.22095853e-01f, -3.04791257e-02f, 3.60605903e-02f, 6.27380684e-02f, -3.92277129e-02f, -1.15584224e-01f,
  -4.31348279e-04f, -2.86341030e-02f, -9.05984715e-02f, 1.26121165e-02f, -7.40521848e-02f, -6.50374889e-02f, 2.51396541e-02f, 8.23052824e-02f, -4.34003659e-02f, 9.32369207e-04f,
  7.63995480e-03f, -6.30183220e-02f, 5.63666783e-02f, 4.52288613e-02f, -2.09366418e-02f, 1.42998388e-02f, 1.15026096e-02f, 1.05851032e-02f, -6.91817701e-02f, -1.16282441e-01f,
  -1.26162186e-01f, -2.12024953e-02f, -2.28450596e-02f, 6.90250546e-02f, -7.01347291e-02f, 3.70759144e-02f, 5.87686785e-02f, -1.27542084e-02f, 8.99766851e-03f, 4.65346277e-02f,
  -1.98040344e-02f, 2.79579423e-02f, 9.78048891e-04f, 1.18878350e-01f, 2.67564449e-02f, 9.68459100e-02f, 8.30141455e-02f, 3.67564596e-02f, 1.48428176e-02f, -9.58622340e-03f,
  6.60252869e-02f, -8.06733891e-02f, 6.51538223e-02f, 1.18774377e-01f, 2.31977776e-02f, 1.47920372e-02f, 1.24039445e-02f, -4.51818779e-02f, 1.25404269e-01f, -4.82088514e-02f,
  -5.22090979e-02f, -1.84968844e-01f, 6.41577831e-03f, 7.47837946e-02f, 9.28537454e-03f, -6.16868176e-02f, -1.16283469e-01f, -9.49208736e-02f, -7.04679340e-02f, -1.27513096e-01f,
  -1.56228602e-01f, 5.59164621e-02f, -5.40498570e-02f, -4.19064099e-03f, 3.71203497e-02f, 3.52494493e-02f, 3.45203243e-02f, -6.29345998e-02f, -3.74942534e-02f, -5.92665002e-02f,
  3.54580805e-02f, -9.24603418e-02f, 8.57245550e-03f, -3.57560664e-02f, 5.22530116e-02f, 1.04446009e-01f, -8.03258419e-02f, -5.61783873e-02f, -1.62598733e-02f, 1.10440357e-02f,
  1.70706227e-01f, 4.44809794e-02f, -5.14303856e-02f, 1.29893184e-01f, -5.94264939e-02f, -1.98321207e-03f, 2.22502965e-02f, 9.26441178e-02f, 2.82539856e-02f, 3.88061069e-02f,
  1.48740023e-01f, -6.51576594e-02f, -5.93761392e-02f, 2.27291524e-01f, 2.38412514e-01f, 1.21297240e-01f, 8.50630924e-02f, 7.89407864e-02f, 1.74707770e-02f, -4.03427631e-02f,
  1.25606686e-01f, 5.16000763e-02f, 4.59258594e-02f, -8.82192254e-02f, -1.53201476e-01f, -1.37677461e-01f, 2.06345338e-02f, -5.49448207e-02f, -4.90786545e-02f, -1.10908531e-01f,
  -1.83831677e-02f, 1.06307946e-01f, 4.54805791e-02f, -7.63983130e-02f, -1.28565393e-02f, -2.55592726e-02f, -2.39517353e-02f, -3.31398547e-02f, -3.57485674e-02f, 1.02448285e-01f,
  2.73678452e-02f, -5.33739105e-02f, 1.25038683e-01f, -5.62706701e-02f, -3.58633511e-02f, 6.97082430e-02f, 2.69592516e-02f, -9.60610211e-02f, 7.77755380e-02f, -8.67868364e-02f,
  -8.60809758e-02f, -1.55753335e-02f, -9.61240157e-02f, -5.39087802e-02f, -6.65230528e-02f, 3.15487273e-02f, 9.79496166e-03f, 4.21441346e-03f, -1.40357809e-02f, 1.00083500e-01f,
  5.66940755e-02f, 1.71926711e-02f, -2.98503079e-02f, -5.88152464e-03f, 2.28779158e-03f, -7.61639699e-02f, 9.50514674e-02f, 8.19816291e-02f, 8.50732923e-02f, 2.37098411e-02f,
  -9.21622068e-02f, 5.90784587e-02f, -4.11563516e-02f, -1.43419961e-02f, 9.83808562e-02f, -1.11409396e-01f, 6.00656681e-02f, 7.23212510e-02f, -7.04798549e-02f, 5.30382134e-02f,
  2.38512701e-04f, 4.58105505e-02f, -4.24906984e-02f, 9.54971164e-02f, 5.10073006e-02f, 5.29264510e-02f, 4.52949144e-02f, -5.26708327e-02f, 2.78828554e-02f, 5.30865826e-02f,
  5.05475737e-02f, 6.44883513e-02f, 1.65546350e-02f, 4.01518047e-02f, -8.16312507e-02f, -4.82884645e-02f, -3.20030227e-02f, 1.33385688e-01f, -1.29407803e-02f, 1.33698285e-01f,
  6.81159692e-03f, -4.09752177e-03f, -7.86823481e-02f, 5.26035316e-02f, 1.27277717e-01f, 3.68182585e-02f, 3.73688713e-02f, -8.56092647e-02f, -9.41824093e-02f, -7.13213757e-02f,
  -4.14699130e-02f, -9.09285173e-02f, 9.53417271e-02f, -9.94911492e-02f, -5.08412048e-02f, -3.77342850e-02f, 5.86272329e-02f, 1.41534777e-02f, -2.20937189e-02f, 4.66275848e-02f,
  2.21833155e-01f, 3.23653147e-02f, 3.14904153e-01f, 4.62958217e-01f, -5.65182194e-02f, -1.59208104e-01f, -1.22596912e-01f, 1.52055221e-02f, 9.46420431e-02f, -1.12411998e-01f,
  -1.71910807e-01f, 2.88627118e-01f, -2.58254230e-01f, 5.91818281e-02f, -1.77757844e-01f, -2.13492513e-01f, 1.00641385e-01f, 8.84139240e-02f, 6.49111420e-02f, 1.63148567e-01f,
  1.09429032e-01f, -1.76340118e-01f, 2.37916242e-02f, -1.54870093e-01f, 2.29321614e-01f, 2.11747989e-01f, -1.55608431e-01f, -8.95254090e-02f, 9.57001820e-02f, -1.24884747e-01f,
  1.21464143e-02f, 1.00152552e-01f, 4.54764813e-02f, 8.89351964e-02f, 4.72904108e-02f, -4.72285151e-02f, -5.21480590e-02f, -1.35423109e-01f, -5.70645742e-02f, 3.98073047e-02f,
  4.25407104e-02f, -1.16460621e-02f, -6.79781009e-03f, -9.25912485e-02f, 3.24422717e-02f, -2.11421810e-02f, 6.02650717e-02f, 1.12695925e-01f, 5.45538813e-02f, 1.27573907e-01f,
  1.44465014e-01f, 5.76396435e-02f, 1.23321168e-01f, 6.57944977e-02f, 3.56981605e-02f, 6.29870072e-02f, -4.82675880e-02f, 9.39093605e-02f, -1.87589112e-03f, 1.01018563e-01f,
  1.21181063e-01f, -9.23704803e-02f, -5.04173636e-02f, -1.00076333e-01f, -5.49731255e-02f, -2.95783263e-02f, -6.73825340e-03f, 1.87770613e-02f, -2.51392256e-02f, -9.13212001e-02f,
  -2.72177421e-02f, 2.77938582e-02f, -9.47871432e-02f, 3.03701404e-02f, -2.01515593e-02f, -2.00544186e-02f, -3.68206948e-02f, 1.50939375e-02f, 2.19022539e-02f, 3.53292190e-02f,
  -2.26740353e-02f, -3.82417929e-03f, -3.02225985e-02f, -2.70568077e-02f, -1.11354329e-01f, 1.85655616e-02f, 2.45544389e-02f, 2.57972814e-02f, -3.12975310e-02f, -5.78354392e-03f,
  -4.21060622e-02f, -1.29527792e-01f, 1.64614394e-02f, -7.95114711e-02f, -6.68222681e-02f, -4.10547182e-02f, 1.94686139e-03f, 9.52658653e-02f, 2.71016546e-02f, -1.05578400e-01f,
  2.08064378e-03f, 2.48116348e-02f, -3.41541730e-02f, -7.18152970e-02f, -7.13143796e-02f, 3.06844525e-03f, -2.63548568e-02f, 2.48368457e-02f, 1.73178930e-02f, 2.11929530e-03f,
  2.36613750e-02f, -2.17588264e-02f, -4.94125076e-02f, 7.79429525e-02f, 2.53593121e-02f, -3.58757339e-02f, -1.37670012e-02f, -9.42219514e-03f, -2.09347773e-02f, 1.23538626e-02f,
  1.55361533e-01f, -3.39823700e-02f, -9.60171446e-02f, 1.82729125e-01f, -1.62592307e-01f, -8.65567029e-02f, -1.91443205e-01f, 7.49545246e-02f, -2.86752045e-01f, 7.58371726e-02f,
  1.55237854e-01f, -6.36579692e-02f, -3.50105092e-02f, 1.30930468e-01f, 6.95025027e-02f, -1.13846019e-01f, 2.04143301e-01f, -6.68664575e-02f, -5.18659987e-02f, 1.68902159e-01f,
  1.61798239e-01f, 3.03294599e-01f, 2.67079353e-01f, 2.85178602e-01f, 1.88880801e-01f, 2.86878079e-01f, 4.28209752e-01f, 8.24659169e-02f, 3.73576194e-01f, 1.49561673e-01f,
  -6.58003017e-02f, -2.82139294e-02f, 1.81489978e-02f, -5.55301756e-02f, -1.91826676e-03f, 1.01856939e-01f, -2.74049658e-02f, 3.31639238e-02f, 1.24494219e-02f, -8.16138908e-02f,
  -2.98318081e-02f, 2.23361272e-02f, -1.73212904e-02f, -8.72582868e-02f, -1.95971858e-02f, -2.85821371e-02f, -6.54112324e-02f, 6.68701380e-02f, -1.11772262e-01f, 4.66673076e-02f,
  -1.02748740e-02f, -4.14815918e-02f, 4.06014994e-02f, -1.03313159e-02f, -5.25386678e-03f, -1.79784559e-02f, -5.14084287e-02f, 7.83825070e-02f, -2.36406904e-02f, 1.42597975e-02f,
  1.09804645e-01f, -2.67584864e-02f, 1.42172910e-02f, -5.05335256e-02f, -8.30011517e-02f, 1.07026449e-03f, 2.80226879e-02f, 4.38765250e-03f, 2.04783827e-02f, 2.59129666e-02f,
  -3.37458774e-02f, 6.04329705e-02f, 1.30853709e-02f, -2.99816160e-03f, 3.67071293e-02f, 6.08949806e-04f, 3.76028419e-02f, 2.55546607e-02f, -2.86091603e-02f, -6.19964153e-02f,
  -3.93788405e-02f, 7.80953765e-02f, 1.39096892e-02f, 1.62965134e-02f, 2.34169438e-02f, -3.94638255e-03f, 5.00141531e-02f, -2.22537834e-02f, -4.63351905e-02f, -7.77126625e-02f,
  1.48195624e-01f, 2.08167404e-01f, -9.26084965e-02f, -7.34014809e-02f, -1.94262527e-02f, -6.03783093e-02f, -4.58114669e-02f, 6.91128746e-02f, 1.70595162e-02f, -5.70103619e-03f,
  1.37203276e-01f, 1.21263415e-02f, -4.54628952e-02f, 3.10463700e-02f, 5.26154600e-03f, 7.18682632e-02f, 6.32775649e-02f, 6.07299767e-02f, 5.07235266e-02f, 4.90512140e-02f,
  6.96378574e-02f, 2.20091399e-02f, -3.02004460e-02f, -8.32995549e-02f, 3.77275199e-02f, -4.40493040e-02f, 2.16931868e-02f, 8.34797276e-04f, 7.49936551e-02f, -6.74423948e-02f,
  -2.37958491e-01f, 1.85209200e-01f, -1.57285288e-01f, -2.21125245e-01f, 3.55279185e-02f, -3.43776643e-01f, -3.95402431e-01f, -6.24414645e-02f, 2.13880166e-02f, -9.06131566e-02f,
  -3.88118848e-02f, -7.65813217e-02f, 1.08569659e-01f, -2.61251152e-01f, -1.87258348e-01f, 1.23258837e-01f, -3.55302423e-01f, -1.95002735e-01f, 1.64507285e-01f, -1.75188094e-01f,
  -2.43668742e-02f, -1.02155417e-01f, -6.67641982e-02f, 2.11673200e-01f, -1.60018489e-01f, 3.99288759e-02f, -6.71294779e-02f, 1.97718218e-01f, -1.76853895e-01f, 6.56864643e-02f,
  -1.80592030e-01f, -7.96179920e-02f, -2.57678796e-02f, -1.59980673e-02f, -1.01834983e-01f, -3.73647958e-02f, -7.59158358e-02f, -2.39332207e-03f, -1.02406748e-01f, 1.05485246e-02f,
  -3.04061677e-02f, 2.52366271e-02f, -5.69534451e-02f, 1.58934936e-01f, 2.39156652e-02f, -2.22060308e-02f, -2.89015993e-02f, -7.75806755e-02f, -3.81544605e-02f, 9.32202712e-02f,
  -1.13972684e-03f, 2.02977397e-02f, -9.76291746e-02f, -6.73887134e-02f, -1.27450395e-02f, -3.47415954e-02f, -9.64116827e-02f, -5.43316156e-02f, -3.45336832e-02f, -5.69905080e-02f,
  -2.25535929e-02f, 1.02856169e-02f, -2.90515106e-02f, 7.24838525e-02f, -9.61478353e-02f, 1.76662952e-02f, -1.03679104e-02f, -1.57996770e-02f, -8.88645742e-03f, -3.42498720e-03f,
  -3.04028466e-02f, -1.91599503e-02f, 7.64021231e-03f, -4.62619103e-02f, -4.71023805e-02f, 4.91657667e-03f, -1.85621865e-02f, 9.02665630e-02f, -5.04016764e-02f, 9.02950019e-03f,
  7.24965613e-03f, -8.04793835e-02f, 6.26276806e-02f, 5.80852143e-02f, -2.15040054e-02f, 2.38614213e-02f, 8.93626362e-02f, 3.67311984e-02f, 4.05210368e-02f, -3.08446418e-02f,
  -1.77249745e-01f, -2.29160741e-01f, 2.99643073e-02f, 1.86734069e-02f, -4.41918969e-02f, 1.27593679e-02f, -6.68864977e-03f, 5.05886860e-02f, -3.23422104e-02f, -3.64363901e-02f,
  9.86390561e-03f, 1.14349332e-02f, -1.17276989e-01f, -2.75645703e-02f, -6.06686547e-02f, -5.17068207e-02f, -4.59218882e-02f, -1.37519315e-01f, -1.04186341e-01f, 2.39825938e-02f,
  -1.48669295e-02f, -1.80643853e-02f, 2.86931209e-02f, -4.41086013e-03f, 1.94195844e-02f, -1.34184182e-01f, 3.67506258e-02f, 1.30953128e-02f, 8.78429227e-03f, -9.48744789e-02f,
  1.20959938e-01f, 3.01289886e-01f, 3.55950475e-01f, 3.02717328e-01f, -1.83193445e-01f, -3.55034739e-01f, -1.45635322e-01f, 5.65254800e-02f, -9.54666063e-02f, 5.09297960e-02f,
  -9.90775675e-02f, 2.75271177e-01f, -1.49495840e-01f, 2.13832110e-01f, -2.14832693e-01f, -2.56542176e-01f, 2.96083223e-02f, 1.04389966e-01f, -4.73720990e-02f, 1.87989324e-01f,
  1.26214996e-01f, -8.20634067e-02f, 1.90934673e-01f, 9.55115333e-02f, 1.18500285e-01f, 3.17575157e-01f, 1.20837905e-01f, -1.59235764e-02f, 3.41529340e-01f, 5.05441912e-02f,
  -1.06785886e-01f, 1.88255962e-02f, 1.40630513e-01f, -2.47888314e-03f, 5.16121797e-02f, 3.35283601e-03f, 2.41401475e-02f, -4.72597294e-02f, -2.84578055e-02f, 8.07947069e-02f,
  -5.54265305e-02f, 1.83158799e-03f, 9.69548970e-02f, -4.17850055e-02f, -4.05500038e-03f, 1.20692909e-01f, 6.27065599e-02f, 5.61729632e-02f, 3.71744782e-02f, 1.28193721e-01f,
  9.23559144e-02f, 1.06700107e-01f, 3.11376080e-02f, 4.76499982e-02f, 9.30915996e-02f, -3.15255523e-02f, 6.73382804e-02f, -1.29615162e-02f, 6.51072944e-03f, 3.74935120e-02f,
  -1.32251456e-01f, -4.36223149e-02f, -1.45906741e-02f, 8.29525664e-02f, 8.04217383e-02f, 3.85960340e-02f, 4.75864001e-02f, -4.21816371e-02f, 1.84060484e-02f, -2.76410636e-02f,
  -4.24068607e-02f, 1.11536443e-01f, -6.80174027e-03f, 1.39842229e-02f, -1.12423161e-02f, 4.32108343e-02f, 1.31299030e-02f, -6.16580471e-02f, 2.15007085e-02f, -1.85943507e-02f,
  2.68569104e-02f, 3.97270992e-02f, 9.97773036e-02f, -5.60258143e-03f, 9.29897744e-03f, -3.28235212e-03f, 2.39326302e-02f, -4.26390627e-03f, 2.45713699e-03f, -5.04553057e-02f,
  -1.37076557e-01f, 9.89980400e-02f, 3.29575092e-02f, -2.49085911e-02f, 1.27090774e-02f, -8.28588083e-02f, -1.35255163e-03f, 2.45089941e-02f, 3.63323912e-02f, -5.92654459e-02f,
  -2.55455542e-02f, 4.96511953e-03f, -6.18802458e-02f, 6.27824813e-02f, -3.11403461e-02f, -2.53940262e-02f, -4.61785309e-02f, -2.26650573e-02f, 3.53238061e-02f, 9.75710079e-02f,
  5.61181568e-02f, -8.60199630e-02f, 6.16546301e-03f, -1.94646548e-02f, -8.35949928e-03f, -4.09533195e-02f, 3.37177701e-02f, 9.11487937e-02f, 6.74085915e-02f, -2.00356916e-02f,
  -4.84048486e-01f, 5.70146590e-02f, 1.02109537e-01f, -4.91563112e-01f, -1.06490955e-01f, 1.49860725e-01f, 9.92149338e-02f, -1.22150719e-01f, -2.68128425e-01f, -1.19409963e-01f,
  -1.45795539e-01f, -1.99783295e-01f, 4.22125131e-01f, -4.43914672e-04f, 2.31726840e-01f, 4.54001933e-01f, 1.97307505e-02f, -5.87858893e-02f, -6.36502355e-02f, -1.45891458e-01f,
  -3.48185450e-02f, -1.27196863e-01f, 2.88110405e-01f, 7.46947080e-02f, -6.75426424e-02f, -1.59539491e-01f, -1.09026782e-01f, 1.23262972e-01f, -7.89062306e-02f, 1.26319937e-02f,
  -1.84901431e-01f, -3.49404275e-01f, -1.14255445e-02f, -3.91675681e-02f, -2.84040044e-03f, 1.15826586e-02f, 6.65822811e-03f, 5.32333553e-02f, -1.01772748e-01f, -1.62236281e-02f,
  6.08292855e-02f, 2.93033086e-02f, -5.54467514e-02f, -2.35591792e-02f, -7.39353225e-02f, -7.61508942e-02f, 2.20610518e-02f, -8.73296559e-02f, -1.18966494e-02f, 8.52832422e-02f,
  8.23294818e-02f, -3.50277871e-02f, -4.42395769e-02f, 2.84867156e-02f, -1.67437680e-02f, -7.50687122e-02f, 4.36484702e-02f, 6.94847032e-02f, -4.82896343e-03f, -7.60237351e-02f,
  -1.99729893e-02f, 1.09675355e-01f, 6.42205924e-02f, -1.26383565e-02f, 7.59797543e-02f, -9.92835034e-03f, 5.82289509e-03f, 3.84670794e-02f, -6.55984432e-02f, 7.23585337e-02f,
  1.67837534e-02f, -1.19207002e-01f, -1.19680660e-02f, 2.84060445e-02f, -2.16515288e-02f, -7.39428699e-02f, 3.60071622e-02f, -4.11988720e-02f, 3.10071129e-02f, 2.90756002e-02f,
  5.51823042e-02f, 1.52113661e-02f, -2.03866116e-03f, -2.07098667e-02f, 1.08716497e-02f, -7.08821742e-03f, -4.23905849e-02f, 5.12309596e-02f, -7.20719621e-02f, -4.77936193e-02f,
  -1.54250041e-01f, -4.07989889e-01f, -3.12006921e-02f, -1.66892484e-01f, -7.15881288e-02f, -1.00736573e-01f, -3.12026013e-02f, -1.61091983e-02f, -7.91625082e-02f, -5.48224077e-02f,
  -8.59605595e-02f, 1.85141396e-02f, -5.44743836e-02f, 1.66628398e-02f, 1.51836481e-02f, -7.52974376e-02f, -5.02679460e-02f, 1.17871668e-02f, -8.55030417e-02f, -3.19889411e-02f,
  2.55904836e-03f, 1.11153992e-02f, 8.51012487e-03f, 2.65646651e-02f, -6.05105199e-02f, -1.25748038e-01f, -1.07932314e-01f, -3.62975635e-02f, -4.32571992e-02f, -1.97346173e-02f,
  3.84276867e-01f, -4.87123966e-01f, -8.53067636e-02f, 3.30638856e-01f, 2.66552746e-01f, 9.34610367e-02f, 2.61319190e-01f, -1.27214268e-01f, -1.26935482e-01f, -3.47095430e-01f,
  3.10889743e-02f, -1.44369662e-01f, -1.55977532e-01f, 1.81398958e-01f, 3.20051819e-01f, -2.37186357e-01f, 1.45662263e-01f, 8.99703726e-02f, -2.73757372e-02f, -7.91909546e-02f,
  8.73519555e-02f, 2.07000390e-01f, 1.17519945e-01f, -2.69698910e-02f, 1.80312946e-01f, -7.41066188e-02f, 1.40884640e-02f, -4.05848548e-02f, 1.56366095e-01f, 4.39155176e-02f,
  6.96615502e-02f, -1.54669136e-02f, 6.56267107e-02f, 2.03508101e-02f, -4.07672860e-02f, 9.24239401e-03f, 3.48656848e-02f, 9.21518058e-02f, 7.60420039e-02f, -8.92997831e-02f,
  -3.50564835e-03f, 2.46289559e-02f, 9.66402292e-02f, 1.22234181e-01f, 8.55024979e-02f, -5.15278988e-02f, -4.02877964e-02f, -2.54803561e-02f, -1.24950610e-01f, -8.11997503e-02f,
  -4.28329557e-02f, -3.08673736e-02f, 1.07339695e-02f, -3.22040729e-02f, 4.16237954e-03f, -4.89194691e-03f, -4.22713198e-02f, -5.20710759e-02f, -1.78291183e-02f, -7.14582205e-02f,
  -2.81182136e-02f, -4.94192075e-03f, -1.48508744e-02f, 4.72497940e-02f, 2.78497599e-02f, 7.88596496e-02f, 4.53096116e-03f, -4.01983783e-02f, -2.02326383e-02f, 3.65319215e-02f,
  -5.23445234e-02f, 3.68586779e-02f, 2.48350017e-03f, -3.41043770e-02f, -3.88762821e-03f, 3.19367871e-02f, 1.13256425e-01f, -6.20532706e-02f, -1.76357925e-02f, 3.00727505e-02f,
  5.78795373e-02f, -1.38774142e-02f, -6.97257891e-02f, -2.98036616e-02f, 2.95593385e-02f, -2.71476731e-02f, 4.46701981e-03f, -3.01050246e-02f, 6.71568811e-02f, 2.07123663e-02f,
  -6.29521012e-02f, -3.21179330e-01f, -6.23344705e-02f, 3.97512317e-02f, -2.77392343e-02f, 3.46935652e-02f, -5.14659844e-02f, -1.90236941e-02f, -7.23768175e-02f, -3.87461670e-02f,
  -2.99295895e-02f, -1.47146201e-02f, 1.30319148e-02f, -1.14982494e-03f, 3.57863642e-02f, 6.97026588e-03f, -5.75142018e-02f, -2.62089726e-02f, -4.57251035e-02f, -1.09144323e-01f,
  2.65323017e-02f, -3.84706333e-02f, -6.97027799e-03f, -3.49808391e-03f, -4.06289585e-02f, 4.94753979e-02f, 4.17900301e-04f, -9.39557552e-02f, -6.92075342e-02f, -1.26593679e-01f,
  4.96471487e-02f, -3.26715559e-02f, -2.15949833e-01f, -8.80579650e-02f, 1.34978779e-02f, -1.42522410e-01f, -3.12035203e-01f, -2.02083111e-01f, 6.59003272e-04f, -7.21247718e-02f,
  -1.90290600e-01f, 1.24067729e-02f, -1.05815783e-01f, -1.99645936e-01f, 1.65462255e-01f, 1.21456407e-01f, -2.45957240e-01f, -9.00607780e-02f, -6.95430934e-02f, -2.70998955e-01f,
  -4.12451550e-02f, -2.46888306e-02f, -3.73388492e-02f, 3.16844843e-02f, -1.07168481e-01f, -6.86727986e-02f, 1.08497620e-01f, -1.22814626e-02f, -6.35727774e-03f, 8.09957981e-02f,
  -1.30232111e-01f, -9.73016098e-02f, -1.49647430e-01f, -2.36402284e-02f, -1.56945959e-01f, -1.13795809e-01f, 1.13689303e-02f, 1.06932715e-01f, -8.42668936e-02f, -1.47833368e-02f,
  -1.77257638e-02f, 6.72288612e-02f, -6.28896803e-02f, 9.50388312e-02f, -2.49227509e-02f, 8.22469518e-02f, 1.12989312e-02f, 2.57093254e-02f, -1.05501629e-01f, -2.71881893e-02f,
  -1.11652315e-01f, 2.00641714e-02f, -9.63286089e-04f, 5.30235805e-02f, -1.86472386e-02f, -8.80914629e-02f, -3.79540119e-03f, 3.65710817e-02f, 5.71010932e-02f, -6.20810203e-02f,
  1.58852972e-02f, 2.53763217e-02f, -8.66676271e-02f, -6.14623679e-03f, -7.19141960e-02f, -5.97924329e-02f, -1.97342671e-02f, -1.16123380e-02f, 6.13330267e-02f, -3.86119224e-02f,
  -6.94073588e-02f, 1.25624314e-02f, -9.00074095e-03f, 4.01824936e-02f, -6.99175894e-02f, 3.35006975e-02f, -7.05268607e-02f, 8.85179713e-02f, 2.38558650e-02f, 1.13931519e-03f,
  1.68853831e-02f, -4.08844724e-02f, 8.40797648e-02f, 1.39221624e-02f, -9.88831595e-02f, 4.72545475e-02f, 1.58620700e-02f, -5.90279624e-02f, 6.53618500e-02f, 4.43249904e-02f,
  -1.80461735e-01f, -1.11208245e-01f, -9.19817388e-02f, 3.68806235e-02f, -4.39345054e-02f, -4.03664112e-02f, 2.62253303e-02f, 2.92988587e-03f, -8.90415348e-03f, -6.91806525e-02f,
  1.13278916e-02f, 1.77942812e-02f, 1.10146878e-02f, 6.90538138e-02f, -5.29607013e-02f, 5.16780391e-02f, -1.28073961e-01f, 8.81097093e-02f, -8.13947916e-02f, -4.76470552e-02f,
  2.49982141e-02f, 4.27315272e-02f, -7.88647756e-02f, -8.69595632e-02f, -8.59614760e-02f, 4.42890674e-02f, -4.23874035e-02f, 2.50860900e-02f, -4.18629684e-03f, 5.38759306e-02f,
  -3.18219274e-01f, -1.79786067e-02f, -1.42325699e-01f, -2.99180180e-01f, 2.45711774e-01f, 9.43622738e-02f, -2.39397474e-02f, 1.23364963e-01f, -2.60019928e-01f, 1.45398214e-01f,
  5.57970963e-02f, -2.54786044e-01f, -5.44221699e-02f, -1.72288403e-01f, -3.80461276e-01f, -3.23068023e-01f, -5.81287444e-02f, -1.40986219e-01f, -1.14102028e-01f, 1.70727558e-02f,
  -9.16047022e-02f, 2.83924136e-02f, -2.81773321e-02f, 4.11789566e-01f, 1.05960123e-01f, 1.36923775e-01f, 6.72643408e-02f, 2.63401359e-01f, 8.40625837e-02f, 5.93180805e-02f,
  4.94930111e-02f, -1.14604339e-01f, -1.63173508e-02f, 1.49492649e-02f, 1.18857637e-01f, 1.90156534e-01f, 1.19636275e-01f, -5.43544181e-02f, -6.29318208e-02f, -9.71248224e-02f,
  -5.10732234e-02f, 9.82914641e-02f, 3.95610146e-02f, -9.57591459e-02f, 2.27428917e-02f, 4.98645976e-02f, -4.65498045e-02f, -3.43271345e-02f, -2.37383768e-02f, -1.86736070e-04f,
  2.38143131e-02f, 8.55774507e-02f, -9.51116905e-03f, -3.74494009e-02f, -1.00740209e-01f, -1.39662400e-02f, 2.56370194e-02f, 5.15684299e-02f, 4.95215692e-02f, -6.59422427e-02f,
  3.36252972e-02f, 8.11802745e-02f, -3.69408280e-02f, -4.21214588e-02f, -1.56308580e-02f, -3.26484777e-02f, -7.59080201e-02f, 1.18309362e-02f, -3.31975929e-02f, -1.10573806e-02f,
  -1.23498794e-02f, -2.60556769e-02f, -8.42516795e-02f, 4.17380370e-02f, 1.52036939e-02f, -1.98019184e-02f, 1.53727494e-02f, -4.03876975e-02f, 3.20340954e-02f, -9.45392177e-02f,
  -1.21321343e-02f, 7.72053301e-02f, 4.39662933e-02f, 1.26159210e-02f, -1.94310024e-02f, -6.07339665e-02f, -6.11888692e-02f, -7.50279706e-03f, -5.21980561e-02f, 4.85322736e-02f,
  5.30649088e-02f, -9.56092328e-02f, -6.17730373e-04f, -1.09390095e-02f, 5.38702905e-02f, 2.53615510e-02f, -6.93490207e-02f, -4.68038470e-02f, 3.67586613e-02f, 2.33828034e-02f,
  1.10144302e-01f, -4.72516706e-03f, 1.29480353e-02f, -2.83013619e-02f, -6.78039417e-02f, -2.30363701e-02f, -1.03601199e-02f, 1.70075819e-02f, -2.57631186e-02f, 3.23500186e-02f,
  7.30260164e-02f, 5.09136282e-02f, -7.08108349e-03f, 6.39740825e-02f, 8.57599974e-02f, 8.72527286e-02f, 9.63595510e-03f, -5.99800702e-03f, 5.15101999e-02f, 7.26120721e-04f,
  -1.66724801e-01f, -1.62889525e-01f, 1.21854283e-01f, -1.47729546e-01f, 2.68935591e-01f, 9.99851078e-02f, -3.94359268e-02f, 8.26201215e-02f, 8.60496759e-02f, -6.37415797e-02f,
  -4.67466265e-02f, -1.79932743e-01f, -2.54745595e-02f, -2.51216024e-01f, -1.29836798e-01f, 2.65111662e-02f, -5.44173755e-02f, -1.99385554e-01f, 1.87461138e-01f, -6.57382458e-02f,
  8.69865157e-03f, -1.14911491e-05f, 5.00192717e-02f, 1.62951127e-01f, -1.70379914e-02f, -6.18782677e-02f, -3.22841033e-02f, 1.71130165e-01f, -1.04443975e-01f, 9.08947065e-02f,
  -3.75211239e-02f, 1.77882180e-01f, -1.04947716e-01f, -5.16386814e-02f, -9.94601995e-02f, 9.08913463e-02f, -7.71491751e-02f, 2.13433504e-02f, -6.58918545e-02f, 8.37423205e-02f,
  -1.02281801e-01f, 4.23141085e-02f, 3.75451371e-02f, -9.08965897e-03f, 7.50880092e-02f, 3.78032364e-02f, 7.94448256e-02f, -3.46142948e-02f, 2.80237608e-02f, 5.77276051e-02f,
  -2.21087411e-02f, -6.68749362e-02f, 4.08997685e-02f, -2.14485731e-02f, -1.16806268e-03f, 5.06826751e-02f, -1.87619366e-02f, -1.27251282e-01f, -6.56263083e-02f, -2.99373623e-02f,
  6.96712211e-02f, 4.95618992e-02f, 5.09538278e-02f, 4.79644351e-02f, 5.45198247e-02f, 3.17059197e-02f, -2.95014717e-02f, -1.80796981e-02f, 1.40577164e-02f, -6.08647577e-02f,
  -6.54771030e-02f, 1.60159487e-02f, 7.40114748e-02f, -7.02272169e-03f, -1.57598294e-02f, 4.53904346e-02f, 3.04203480e-02f, -3.83988470e-02f, -9.75833312e-02f, 1.74951088e-02f,
  5.44973556e-03f, 7.70774577e-03f, -1.03335874e-03f, -7.47804577e-03f, 6.92647621e-02f, 4.97657619e-02f, 4.29729698e-03f, 3.00742947e-02f, 1.73379073e-03f, -5.52092940e-02f,
  -1.62454680e-01f, -6.87032414e-04f, -1.06230937e-01f, 7.28918910e-02f, -7.46597275e-02f, -6.42718747e-02f, 1.18187368e-02f, -1.10638388e-01f, 2.97074076e-02f, 6.37173876e-02f,
  2.86494251e-02f, -1.08736726e-02f, 2.27407156e-03f, -5.17396852e-02f, 3.66794728e-02f, -4.41396609e-02f, 2.96393838e-02f, -5.85006773e-02f, -8.22587460e-02f, 2.99547222e-02f,
  1.03434008e-02f, -4.25946899e-02f, -6.22476004e-02f, -1.48735819e-02f, 3.42709795e-02f, -2.13185586e-02f, -7.06971576e-03f, 3.66132036e-02f, 6.17662147e-02f, 8.09150338e-02f,
  1.11293033e-01f, -1.71993040e-02f, 1.25354797e-01f, 2.82657564e-01f, -7.86954090e-02f, -1.61478102e-01f, -1.20817259e-01f, -4.24677059e-02f, -2.63715029e-01f, -1.75755069e-01f,
  1.02589071e-01f, 1.75622329e-01f, -1.27421588e-01f, 1.95074707e-01f, 2.84826159e-01f, -2.03209698e-01f, 7.09167272e-02f, 8.15125275e-03f, -5.87870888e-02f, 2.91119087e-02f,
  2.05578670e-01f, 2.36872673e-01f, 2.94975966e-01f, 2.79456764e-01f, 1.92954749e-01f, 2.20557958e-01f, 3.54082912e-01f, 6.61705807e-02f, 3.75743181e-01f, 2.81407833e-01f,
  -3.67871597e-02f, -1.26454994e-01f, 2.14249417e-02f, 1.83321312e-02f, -4.80172671e-02f, 3.51138301e-02f, 2.85575856e-02f, 4.21793200e-02f, 1.15230031e-01f, -3.32960743e-03f,
  -7.53107145e-02f, 3.37425806e-02f, 1.17268540e-01f, 1.17628248e-02f, -4.54913415e-02f, 1.12749897e-01f, 5.65665439e-02f, -1.76978502e-02f, 3.06448247e-02f, 2.85607763e-03f,
  -6.27178475e-02f, -2.79766582e-02f, 5.14308270e-03f, 5.76382242e-02f, 4.34805006e-02f, -2.16774438e-02f, -5.14655598e-02f, 2.93738134e-02f, 7.72741511e-02f, 3.27577442e-02f,
  -5.11516631e-02f, -8.49695876e-03f, -2.16064677e-02f, 1.19941607e-01f, 4.67589647e-02f, -1.05158752e-02f, -1.62721833e-03f, -6.78615794e-02f, -3.94077189e-02f, -5.83843999e-02f,
  7.31910765e-02f, 1.18503431e-02f, -1.86727243e-03f, 1.50983222e-02f, -4.17978503e-02f, 3.44319828e-03f, -8.68006959e-04f, -9.11285914e-03f, -1.41332403e-01f, 5.35350963e-02f,
  -5.67829236e-02f, -3.62808742e-02f, -1.40556926e-02f, 6.44045547e-02f, 1.02957012e-02f, -2.65791789e-02f, -2.63978168e-03f, -2.19669915e-03f, -2.64444817e-02f, 9.43440385e-03f,
  -8.53149295e-02f, 2.05052365e-02f, -3.66401412e-02f, 8.46709609e-02f, -6.23616390e-02f, 1.46745825e-02f, -3.50701101e-02f, -9.16711334e-03f, -3.69325727e-02f, -3.92876714e-02f,
  2.12989226e-02f, 5.69810197e-02f, -2.16396507e-02f, 5.27982898e-02f, 1.47216484e-01f, -5.66889234e-02f, 2.08617412e-02f, -3.49529758e-02f, 6.55496959e-03f, 5.24833659e-03f,
  4.81232852e-02f, -7.06945285e-02f, 3.25260088e-02f, -2.01796112e-03f, 5.43063134e-02f, 2.14523058e-02f, 5.05439863e-02f, -9.43627134e-02f, -3.60091180e-02f, -3.76013443e-02f,
  3.17509621e-02f, 1.62701346e-02f, -5.03348112e-01f, -1.15574315e-01f, -1.11381717e-01f, 2.55056024e-01f, 2.10418507e-01f, -1.51011914e-01f, -2.91690707e-01f, 3.15002322e-01f,
  3.43235135e-01f, -1.72852501e-01f, 9.43021923e-02f, 3.03749412e-01f, -1.66178897e-01f, 8.61480311e-02f, 3.47097218e-01f, 2.03881025e-01f, -1.01269282e-01f, 3.57945859e-02f,
  -3.94053236e-02f, 3.07201535e-01f, -6.51802942e-02f, 6.30548447e-02f, 1.03771739e-01f, -7.93310553e-02f, 1.06223263e-01f, -1.59727231e-01f, 2.24179178e-01f, -7.29726776e-02f,
  7.28804767e-02f, -1.10569991e-01f, -1.23787364e-02f, -1.07409224e-01f, 6.34983629e-02f, 1.44859612e-01f, -5.91686629e-02f, -2.17721500e-02f, -1.10833459e-01f, 6.94927434e-03f,
  2.85273921e-02f, -5.67122363e-02f, -9.34288744e-03f, -2.24015359e-02f, -2.40303762e-02f, -2.76518501e-02f, -2.89237257e-02f, -2.57759169e-02f, -4.44086790e-02f, 4.67106625e-02f,
  -1.93664413e-02f, 3.01666688e-02f, -4.21848223e-02f, 9.75910109e-03f, -8.82727727e-02f, -8.10940862e-02f, -2.45952625e-02f, -4.90196161e-02f, 5.63513599e-02f, -2.49356627e-02f,
  1.23247588e-02f, -2.53245346e-02f, 1.23866059e-01f, 3.12925428e-02f, 4.59274575e-02f, 4.16847542e-02f, 2.11955588e-02f, 1.35896150e-02f, -8.67679417e-02f, 4.69102412e-02f,
  2.05538962e-02f, -2.49920990e-02f, 2.62450967e-02f, 5.86947543e-04f, 3.29130217e-02f, 3.29876728e-02f, -7.34043717e-02f, -3.30518261e-02f, -2.99642072e-03f, 4.85904589e-02f,
  6.51392946e-03f, -1.03870314e-02f, 3.39733809e-02f, 3.21493410e-02f, 4.43128981e-02f, -1.41197816e-02f, 5.84971085e-02f, 4.08646874e-02f, -6.67158216e-02f, 7.51189515e-02f,
  1.02992512e-01f, 8.17675963e-02f, -1.71496551e-02f, 3.06004025e-02f, 5.26489643e-03f, 8.81945267e-02f, 6.79380819e-02f, -1.90358162e-02f, 2.87008332e-03f, 1.08308764e-02f,
  1.53274402e-01f, -5.73176630e-02f, 7.64603689e-02f, -5.05812764e-02f, -1.02289177e-01f, 5.30141369e-02f, 1.11606494e-02f, -4.11765501e-02f, -7.39072077e-03f, -4.18306105e-02f,
  1.50486780e-02f, 4.82834429e-02f, -1.25556663e-01f, -3.36530320e-02f, 1.37766227e-02f, 4.12142165e-02f, -6.47525117e-02f, -2.48904172e-02f, 4.33231331e-02f, -3.50557677e-02f,
  1.11569710e-01f, 6.37179613e-02f, 1.12234160e-01f, 9.01587680e-02f, -1.09648228e-01f, -6.96886182e-02f, -2.17983518e-02f, -9.62187126e-02f, 1.52292684e-01f, -2.97031179e-02f,
  -2.15150312e-01f, 3.17708194e-01f, 1.51453584e-01f, -1.72337532e-01f, 1.28226206e-01f, 8.70098770e-02f, -1.37609571e-01f, 7.63695389e-02f, 5.61711639e-02f, -1.34794503e-01f,
  -1.14161566e-01f, -2.38784418e-01f, 5.80800027e-02f, -2.72271693e-01f, -2.77257469e-02f, -1.57514773e-02f, -1.20956860e-01f, -1.40350601e-02f, -2.31040046e-01f, -3.13090719e-02f,
  2.36150287e-02f, 4.84761223e-02f, 1.32864326e-01f, 1.08955935e-01f, 5.31161278e-02f, 8.25333036e-03f, -4.83678747e-03f, 8.88781715e-03f, 4.92245053e-05f, 2.61718538e-02f,
  1.06878504e-01f, 9.10770148e-04f, 1.47130545e-02f, -4.49941196e-02f, -1.30392155e-02f, 2.35780831e-02f, 2.15382632e-02f, 6.39708862e-02f, 3.20306197e-02f, 1.09058293e-02f,
  1.57086831e-02f, 1.23390041e-01f, 8.05840716e-02f, 2.93772407e-02f, -4.16113138e-02f, 1.00971255e-02f, 4.13975865e-02f, 9.81853232e-02f, 1.74393337e-02f, 2.88447812e-02f,
  -2.33921390e-02f, -1.20147085e-02f, -6.48385212e-02f, 1.72592271e-02f, 6.96619973e-02f, -5.80092296e-02f, 5.38964996e-05f, -7.98808560e-02f, -8.27445537e-02f, 4.91522439e-02f,
  2.71550287e-02f, -2.67991759e-02f, 8.35579038e-02f, -4.47596163e-02f, 5.81034124e-02f, -5.29420283e-03f, -1.26374057e-02f, -9.93457064e-03f, 1.01502530e-01f, 6.07712083e-02f,
  -9.53842700e-02f, 1.85861364e-02f, 1.04843508e-02f, -7.64832497e-02f, 3.54149975e-02f, 2.36355700e-02f, -6.76732836e-03f, -1.02793379e-02f, 8.93202610e-03f, -5.37660234e-02f,
  -1.63051337e-02f, 5.66251241e-02f, 4.47292514e-02f, 1.31696090e-01f, -8.92911281e-04f, -4.42259349e-02f, -1.83742978e-02f, -9.51220561e-03f, -3.48582007e-02f, -4.56995890e-02f,
  3.22395936e-02f, 8.61752182e-02f, 1.05309375e-01f, -4.15898673e-02f, 7.45010674e-02f, -1.12415925e-01f, 2.19561923e-02f, 5.03116734e-02f, 2.74753869e-02f, 3.51269804e-02f,
  1.70633197e-02f, -1.99374016e-02f, -8.25026352e-03f, -1.35214068e-02f, -7.59194139e-03f, -4.81861532e-02f, -4.62922407e-03f, 1.62907951e-02f, 1.16196610e-02f, 7.16459900e-02f,
  -2.74217308e-01f, 3.16246122e-01f, -3.22815627e-02f, -2.70469189e-01f, -8.06637667e-03f, -2.65680790e-01f, -1.47491142e-01f, 1.70787368e-02f, -3.77800986e-02f, 2.73109287e-01f,
  2.34062225e-02f, 7.65765011e-02f, 1.79805644e-02f, -2.99559217e-02f, -6.50746226e-01f, -1.60623595e-01f, -2.90970564e-01f, -1.31876037e-01f, -1.05635189e-01f, -3.08022127e-02f,
  -2.08668455e-01f, 2.73794997e-02f, -1.34890065e-01f, 2.72802562e-01f, -2.56551569e-03f, 7.42096677e-02f, -7.15208501e-02f, 2.12521210e-01f, -2.72760093e-02f, -6.41466677e-03f,
  5.50918207e-02f, 1.12402119e-01f, 2.33394671e-02f, 1.16546892e-01f, -1.35651663e-01f, -1.18395284e-01f, -1.47671346e-02f, 2.25050934e-02f, -7.37737417e-02f, 3.31975743e-02f,
  -5.88603988e-02f, 3.62703800e-02f, -3.07631446e-04f, 2.38074753e-02f, -2.58045401e-02f, 1.26592204e-01f, -3.08923777e-02f, -1.45975943e-03f, 1.28819257e-01f, 1.44748148e-02f,
  9.85281765e-02f, -4.85097580e-02f, -2.12377161e-02f, -1.91815142e-02f, -9.56641734e-02f, 4.30825874e-02f, -8.26532096e-02f, -4.76596877e-02f, -6.76829964e-02f, -3.16844089e-04f,
  6.43083826e-03f, -1.55050263e-01f, -8.32413090e-04f, 1.08452022e-01f, 4.91991192e-02f, 3.09784543e-02f, 7.90662393e-02f, 3.64946462e-02f, -7.03812111e-03f, 9.85111762e-03f,
  3.24599482e-02f, 8.94357041e-02f, 5.92904277e-02f, -1.29311055e-01f, -4.99424571e-03f, 7.26017803e-02f, -7.05703497e-02f, -2.20580399e-02f, -6.87845945e-02f, 1.12468945e-02f,
  -1.23991901e-02f, -9.77911055e-03f, 1.43469404e-03f, -9.83235333e-03f, 3.33177447e-02f, 1.43679949e-02f, 6.07563462e-03f, -3.67197990e-02f, -2.06224993e-02f, -9.19286385e-02f,
  -6.82771429e-02f, -2.10582595e-02f, 1.00920759e-01f, 3.35696042e-02f, 4.17788103e-02f, -5.98959997e-02f, -2.45530717e-02f, 9.23450291e-03f, -1.04766957e-01f, -1.77827049e-02f,
  -5.09601086e-03f, -7.79790513e-04f, -3.53108793e-02f, 3.24543305e-02f, 3.95613052e-02f, -1.38114065e-01f, -3.38816717e-02f, 1.23570515e-02f, -2.74101496e-02f, -6.44811019e-02f,
  -3.56429368e-02f, 7.16488510e-02f, 8.52515921e-03f, -2.83003282e-02f, -6.62941337e-02f, 4.57683131e-02f, 3.61275375e-02f, 1.19323768e-02f, -7.45569840e-02f, -5.57737099e-03f,
  6.25501201e-02f, -1.72430515e-01f, -1.34118065e-01f, 1.73118785e-01f, 1.45461902e-01f, 6.51742667e-02f, 4.70986078e-03f, 5.96131757e-02f, -3.30207832e-02f, -1.47508399e-03f,
  -9.71746224e-04f, -7.00445846e-02f, -2.25294173e-01f, -1.12118348e-01f, -1.96269006e-01f, -2.64932722e-01f, 1.14871897e-02f, 2.28292868e-02f, -1.61963657e-01f, -5.29888794e-02f,
  -2.37097940e-03f, 1.08083650e-01f, -1.28024276e-02f, 1.11637428e-01f, 1.00486659e-01f, 1.06279224e-01f, 1.81639165e-01f, 1.11147448e-01f, 2.18229905e-01f, 1.45918187e-02f,
  -6.06319010e-02f, -7.04345386e-03f, 4.49939556e-02f, 1.84366461e-02f, 1.52568622e-02f, 8.43871608e-02f, 2.97096539e-02f, 6.79809647e-03f, 2.47333273e-02f, 1.42925307e-02f,
  3.89123261e-02f, -3.96790765e-02f, -4.71468363e-03f, 3.85319404e-02f, 1.07425243e-01f, -6.72225282e-02f, 6.71612518e-03f, 4.98916917e-02f, 6.53603822e-02f, -3.28781381e-02f,
  -8.36746916e-02f, 2.57304367e-02f, 3.16869318e-02f, -3.88952866e-02f, -6.30064011e-02f, -1.61085669e-02f, -8.25026333e-02f, -7.79241882e-03f, 1.42838648e-02f, -5.80068259e-03f,
  -7.40676969e-02f, 7.46997818e-02f, -7.02174529e-02f, -3.23504284e-02f, 2.97445357e-02f, 3.24551878e-03f, 2.15015840e-02f, 5.70853911e-02f, 3.52951512e-02f, -7.03487732e-03f,
  7.98387900e-02f, 1.01960853e-01f, 2.65645795e-02f, -1.69210415e-02f, 3.96625362e-02f, -3.61200124e-02f, 9.52551588e-02f, -8.84438753e-02f, 1.41325258e-02f, 5.63281626e-02f,
  7.54547939e-02f, -3.03919781e-02f, -1.91503707e-02f, 5.10316193e-02f, -5.32768480e-03f, 6.58598393e-02f, -2.89001707e-02f, 5.75657710e-02f, 5.25540933e-02f, -6.63396670e-03f,
  6.16606139e-02f, -1.77397236e-01f, -4.83908616e-02f, 4.31238255e-03f, 2.80035217e-03f, 9.22522694e-02f, -6.66552037e-03f, -1.82930995e-02f, -3.68208066e-02f, -3.89328506e-03f,
  1.47974506e-01f, 5.25996238e-02f, 2.29259729e-02f, -5.73690375e-03f, 9.50252414e-02f, -1.34561909e-02f, -4.79960814e-02f, 9.68209803e-02f, -1.34505583e-02f, -2.45862622e-02f,
  7.90087879e-02f, 7.28018489e-03f, 9.71072093e-02f, -5.30286692e-02f, 2.22163610e-02f, 1.27855716e-02f, 5.85725605e-02f, 9.12247151e-02f, 3.99830714e-02f, 3.28367205e-05f,
  -3.20589612e-03f, -3.20520252e-02f, 1.44563898e-01f, -7.59943873e-02f, 1.31174192e-01f, 9.28470120e-02f, 1.59415737e-01f, -1.62342861e-01f, -1.94009677e-01f, -2.35429347e-01f,
  -2.44842358e-02f, 7.03422725e-02f, 1.20132744e-01f, -6.05897792e-02f, 1.33011445e-01f, -3.21120061e-02f, -1.64215967e-01f, -1.39872059e-01f, -3.86225916e-02f, -1.06651867e-02f,
  -1.10946670e-01f, -1.76747590e-01f, 9.20386687e-02f, -1.52378857e-01f, 3.74681242e-02f, 8.03457946e-02f, -4.08457704e-02f, 6.41912520e-02f, -1.58414990e-01f, 6.56563640e-02f,
  3.92667316e-02f, 2.12044362e-02f, 1.60540268e-01f, 8.92227963e-02f, 4.68901061e-02f, 3.01847029e-02f, 1.62556954e-03f, 1.71712846e-01f, 1.35783523e-01f, -6.33484963e-03f,
  -7.58782998e-02f, -4.49811667e-02f, 1.62736364e-02f, -1.11754127e-02f, -8.83293003e-02f, -5.83302267e-02f, 6.29628301e-02f, 1.00129023e-01f, 6.08753525e-02f, 3.00888419e-02f,
  8.36645812e-02f, 1.18191559e-02f, -1.65318940e-02f, -1.11389413e-01f, -7.79466853e-02f, -9.08156261e-02f, 1.05639398e-02f, -9.82862059e-03f, 5.02752773e-02f, 3.53990383e-02f,
  -8.64013622e-04f, -7.44405538e-02f, 9.28040501e-03f, -2.24261265e-03f, 3.36925057e-03f, -9.27860886e-02f, 6.45313784e-02f, -8.24027732e-02f, 2.64389608e-02f, 8.05219337e-02f,
  -2.31663398e-02f, -2.12255511e-02f, -7.31050819e-02f, -2.94556729e-02f, -9.72427353e-02f, 1.38612520e-02f, -3.90057117e-02f, 4.79438007e-02f, -1.99617594e-02f, 5.44294566e-02f,
  4.55689579e-02f, -1.11297466e-01f, -2.63469410e-03f, 7.54821301e-02f, 3.31146270e-02f, 4.22025323e-02f, -3.92148308e-02f, 8.01207721e-02f, 6.79378659e-02f, -2.74247397e-02f,
  8.68503004e-02f, -1.05662338e-01f, 8.50415453e-02f, 6.64658770e-02f, 8.01164284e-02f, -3.38291153e-02f, -7.91378021e-02f, -6.08648174e-02f, 5.33664748e-02f, -5.66209434e-04f,
  -1.52155990e-02f, -2.90634334e-02f, -1.05721638e-01f, -5.41361906e-02f, -4.68327627e-02f, -6.79539815e-02f, -1.00687668e-02f, -1.00503661e-01f, 3.28039341e-02f, -7.63864815e-02f,
  5.00270203e-02f, -2.05095056e-02f, -5.43954875e-03f, -2.65717432e-02f, -6.66441247e-02f, -7.61397332e-02f, -6.80401772e-02f, -5.93630858e-02f, -2.08830722e-02f, -1.05038889e-01f,
  -7.10050613e-02f, -7.75137171e-02f, -1.94590002e-01f, -3.18132877e-01f, 2.67026722e-02f, -1.53799251e-01f, -2.84816414e-01f, -6.25321940e-02f, -1.48143247e-01f, 9.80004817e-02f,
  -8.75621736e-02f, -1.88595504e-01f, 6.84724152e-02f, -5.08083165e-01f, -2.76772350e-01f, -7.67392293e-02f, -2.83011734e-01f, -2.23474637e-01f, -6.04228713e-02f, -1.37434602e-01f,
  -3.04899551e-02f, -2.08312437e-01f, -4.84651849e-02f, 9.82157812e-02f, -5.38287647e-02f, 1.72502637e-01f, 2.83167452e-01f, 7.63414204e-02f, -3.10423728e-02f, -1.33023307e-01f,
  -1.25379160e-01f, 7.20244506e-03f, -1.32111283e-02f, -3.84793058e-02f, 5.98381609e-02f, 1.21560931e-01f, 2.13466678e-02f, -1.10088542e-01f, 3.37414965e-02f, -3.00009418e-02f,
  7.00859493e-03f, -1.46684516e-02f, -1.27311662e-01f, 1.62705183e-02f, 5.90863228e-02f, -7.08393008e-02f, 2.15702299e-02f, 6.78584650e-02f, -9.81101468e-02f, -7.50349164e-02f,
  -9.26986337e-02f, -9.13203359e-02f, 8.47022887e-03f, 2.09287070e-02f, -7.05374926e-02f, -3.96792591e-02f, -2.33582873e-02f, -2.23452654e-02f, -1.72901973e-02f, 5.19708991e-02f,
  6.83376417e-02f, 8.12156796e-02f, -5.40171377e-03f, -1.65738594e-02f, -1.60239637e-02f, -5.07582985e-02f, 5.02374209e-02f, 1.32774478e-02f, 7.80992955e-02f, 5.61554544e-02f,
  3.10854744e-02f, 1.74435191e-02f, -5.36137372e-02f, 3.31762843e-02f, 2.41672713e-02f, 1.48045607e-02f, 6.81609437e-02f, -1.87355485e-02f, -6.86027575e-04f, -2.83394121e-02f,
  -7.00780051e-03f, -1.63975190e-02f, 5.25034011e-05f, 6.57455847e-02f, -6.09014295e-02f, 6.02090582e-02f, -5.21199517e-02f, 2.53988188e-02f, 6.27569333e-02f, 2.61685811e-02f,
  1.03852497e-02f, 1.28314391e-01f, -1.24617349e-02f, 1.66920740e-02f, -3.53739923e-03f, -5.52222971e-03f, -1.08555831e-01f, -1.09359622e-01f, 2.91384086e-02f, -2.52491739e-02f,
  5.20675220e-02f, 3.59073542e-02f, 8.28091353e-02f, 1.50790857e-02f, 5.73580228e-02f, -3.25589278e-03f, -4.07071225e-02f, 1.23415757e-02f, 3.28396633e-02f, -1.13558993e-02f,
  2.39201821e-02f, 5.80866933e-02f, -2.47776639e-02f, 7.75451660e-02f, 2.42592189e-02f, 8.68752152e-02f, 4.18113805e-02f, 5.49656972e-02f, -2.83621661e-02f, -2.81505901e-02f,
  2.24106456e-03f, -3.04073483e-01f, 8.28501359e-02f, 1.49074448e-02f, 3.44836377e-02f, 4.52893320e-03f, 8.16581994e-02f, -1.80061802e-01f, -3.83650720e-01f, -2.29331851e-01f,
  -9.56811979e-02f, -4.50467691e-03f, 5.89812845e-02f, -3.98165770e-02f, 3.68942827e-01f, -5.39702177e-02f, -9.52481404e-02f, 4.83439974e-02f, -2.15149671e-02f, -7.27465823e-02f,
  -4.31962200e-02f, -1.07155768e-02f, 1.37957364e-01f, -1.43637052e-02f, 5.91480248e-02f, 3.94474044e-02f, 4.11669314e-02f, 5.45098856e-02f, 5.21092070e-03f, 7.87031651e-02f,
  -9.01653711e-03f, -1.56625062e-01f, -6.78507313e-02f, -7.18176812e-02f, -4.82477844e-02f, 1.00036271e-01f, 1.53088316e-01f, 1.30975798e-01f, -3.78423519e-02f, -6.22402430e-02f,
  7.38714263e-02f, 6.92971870e-02f, -5.18876389e-02f, -2.22747810e-02f, -1.20225921e-02f, -6.81409612e-02f, -3.05000823e-02f, -6.39071763e-02f, -8.66570994e-02f, 7.09550604e-02f,
  -6.41301391e-04f, 9.51672420e-02f, -3.44352424e-02f, 5.16870338e-03f, 2.27291267e-02f, 6.26496896e-02f, -6.69074655e-02f, 4.55229431e-02f, 5.15249893e-02f, -8.49046335e-02f,
  -2.43921448e-02f, 6.82875589e-02f, 6.38387725e-02f, 1.39533635e-02f, -2.26052776e-02f, 3.86607344e-03f, 1.65940970e-02f, 8.64002109e-02f, 7.72394687e-02f, -7.32829869e-02f,
  2.67758090e-02f, 6.89915568e-02f, -5.48274182e-02f, -4.88622524e-02f, -3.32014151e-02f, -8.71175975e-02f, -1.84345692e-02f, -4.69430722e-03f, -3.62746157e-02f, -4.00925912e-02f,
  9.05405432e-02f, 8.86664689e-02f, 9.17570479e-03f, -2.74916906e-02f, -1.21031599e-02f, 7.32352659e-02f, -1.92231983e-02f, -2.73731928e-02f, -3.55964489e-02f, 1.24481387e-01f,
  -1.17553435e-01f, -2.90345669e-01f, -3.27823237e-02f, 1.35170128e-02f, 2.83117723e-02f, -8.37488547e-02f, -5.12560792e-02f, -2.77172383e-02f, -8.85889772e-03f, -6.31695315e-02f,
  5.49193891e-03f, 6.42251000e-02f, 2.78371442e-02f, -4.12372164e-02f, 3.84121463e-02f, -9.96513739e-02f, -1.64392386e-02f, -5.44999391e-02f, 4.43634763e-02f, 6.81416020e-02f,
  -8.47386718e-02f, 2.82895342e-02f, -8.84775014e-04f, 6.07625395e-02f, 2.15007681e-02f, -1.05016297e-02f, -4.63756062e-02f, 1.20361365e-01f, 2.30539721e-02f, 6.95233718e-02f,
  2.18893364e-01f, -4.34754938e-01f, 4.79746163e-02f, 1.91307366e-01f, 1.05283000e-01f, 1.29010649e-02f, 2.28296503e-01f, -1.44965410e-01f, -1.22389778e-01f, -1.71884790e-01f,
  8.07734877e-02f, 1.65024307e-02f, 1.64711773e-02f, 1.37572717e-02f, 2.99037367e-01f, -1.59684509e-01f, 5.59341572e-02f, -1.07230665e-02f, -4.26250733e-02f, -3.42043000e-03f,
  1.02527596e-01f, 1.05714306e-01f, 7.53542632e-02f, -1.18529610e-01f, 2.38637514e-02f, -7.03018233e-02f, -7.84676429e-03f, 3.89024094e-02f, 3.15610021e-02f, 1.07380077e-01f,
  -3.38006541e-02f, -1.04734063e-01f, -1.77945495e-02f, 1.73856672e-02f, -5.36376536e-02f, 4.07245476e-03f, 2.62402706e-02f, 7.08497986e-02f, 4.01957240e-03f, 5.64218685e-03f,
  3.10058501e-02f, 4.48091067e-02f, -7.54497275e-02f, 8.04805234e-02f, -7.99996480e-02f, -1.22182406e-02f, 3.56172882e-02f, 6.29593953e-02f, 1.01539614e-02f, 5.92269860e-02f,
  -1.65296346e-02f, -1.67693887e-02f, 3.59478071e-02f, 3.84757407e-02f, 3.82609367e-02f, -2.67387815e-02f, 9.85064283e-02f, 7.36742616e-02f, -8.38934705e-02f, 5.61731383e-02f,
  -1.72139145e-02f, 4.05885391e-02f, -1.10099167e-01f, -4.51896861e-02f, 6.47911876e-02f, -7.72946104e-02f, 5.39723784e-03f, -3.63889933e-02f, 4.15361151e-02f, -3.50664631e-02f,
  8.21444765e-02f, -4.45630513e-02f, -4.84414957e-03f, 5.49107939e-02f, 8.50242600e-02f, 2.87516695e-03f, 4.72975746e-02f, -2.44394690e-02f, 5.46035245e-02f, -4.67598699e-02f,
  -4.72437106e-02f, 2.54889224e-02f, 2.66446397e-02f, 9.18124169e-02f, -5.04452921e-02f, -1.80453826e-02f, 2.54802145e-02f, -9.66563001e-02f, -5.59330434e-02f, 4.91837561e-02f,
  -5.56770898e-02f, -2.39064768e-01f, -2.30843332e-02f, -2.29792614e-02f, -2.66870968e-02f, -2.28676535e-02f, -4.08422463e-02f, -6.72637373e-02f, -1.03687443e-01f, 3.01944315e-02f,
  5.12647675e-03f, -8.55916366e-03f, -1.29116967e-01f, 5.70359007e-02f, -1.93295255e-02f, -1.16983861e-01f, -1.65476017e-02f, 6.12575598e-02f, 8.38967040e-02f, -3.59600522e-02f,
  1.38429813e-02f, -4.25698757e-02f, -6.72986638e-03f, 3.80021073e-02f, 7.34032542e-02f, -4.18178476e-02f, 3.94556075e-02f, -5.45559935e-02f, -8.50996003e-02f, 6.49347231e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.97144717e-01f, 1.31102264e-01f, 1.21743046e-01f, 7.71680325e-02f, 1.89290851e-01f, 1.96198076e-01f, 4.25191730e-01f, 2.43685991e-01f, 8.15545097e-02f, 4.50593561e-01f,
  1.80846736e-01f, 1.26495034e-01f, 2.14077741e-01f, 2.62153357e-01f, 3.98040563e-01f, 3.36905457e-02f, 7.27668777e-02f, 1.33193478e-01f, 6.00536354e-02f, 1.23023860e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.90012991e-01f, 5.04955351e-02f, 4.21311110e-02f, 1.98843807e-01f, 1.91188380e-02f, -1.02515779e-02f, 1.06696963e-01f, 1.81792617e-01f, 9.32451412e-02f, -1.84695631e-01f,
  5.88231683e-01f, -7.95018077e-02f, 3.23764682e-01f, 1.62708119e-01f, -2.20538139e-01f, -6.09305836e-02f, -2.91376978e-01f, -3.83092135e-01f, 5.87000772e-02f, 1.53086279e-02f,
  -2.28686690e-01f, -1.05284145e-02f, -2.81030163e-02f, -3.12965035e-01f, 3.35112244e-01f, -3.03052086e-02f, -1.92354724e-01f, -1.40305474e-01f, 7.37092178e-03f, -2.28414550e-01f,
  -8.77075046e-02f, 2.02193961e-01f, 7.24277087e-03f, -2.98387647e-01f, -2.45373651e-01f, -7.88843408e-02f, -1.76542386e-01f, -1.49584517e-01f, 3.30118597e-01f, -5.52518219e-02f,
  3.55431587e-01f, 6.90518841e-02f, 1.45629048e-01f, -1.41787026e-02f, 3.25142860e-01f, 1.99138165e-01f, -1.57096952e-01f, 3.24669957e-01f, -4.07214224e-01f, 2.14186728e-01f,
  3.75878364e-02f, 7.95982778e-02f, 1.29802942e-01f, -2.91939110e-01f, -2.78536916e-01f, 2.92862445e-01f, 1.32297814e-01f, -1.05585448e-01f, -2.17625320e-01f, 1.00883223e-01f,
  -7.51613006e-02f, -3.27834994e-01f, 3.13036323e-01f, 1.30947232e-01f, 2.24251440e-03f, -8.64651799e-02f, 2.87975460e-01f, -2.08462656e-01f, 2.20676854e-01f, 1.11787459e-02f,
  -4.78875130e-01f, -4.24519554e-03f, -4.42304999e-01f, -3.55232835e-01f, 4.48766470e-01f, 6.17315024e-02f, 1.58471122e-01f, -1.52561009e-01f, -5.57640800e-03f, -3.06862056e-01f,
  -2.22012997e-01f, 8.48154351e-02f, 2.29789257e-01f, 2.18966126e-01f, 5.20386361e-02f, 9.16588604e-02f, 2.87824750e-01f, -1.05766982e-01f, 3.81245017e-02f, -1.04487769e-01f,
  3.30805145e-02f, 2.99040154e-02f, 1.32961512e-01f, -2.50684887e-01f, 1.60395294e-01f, 2.61291981e-01f, 2.14701727e-01f, 1.33953452e-01f, 1.87352091e-01f, -4.55964878e-02f,
  1.50891840e-01f, -1.06844634e-01f, -3.64183336e-02f, -1.43358216e-01f, -1.12716615e-01f, -5.56822419e-01f, -7.53938109e-02f, -7.28292242e-02f, 4.34071481e-01f, -6.23451918e-02f,
  -1.08126290e-01f, -2.62634635e-01f, 1.61002517e-01f, 4.80607487e-02f, 2.07774356e-01f, -1.72841609e-01f, 7.88598359e-02f, 9.68234465e-02f, 4.81535681e-02f, -3.23365182e-01f,
  7.50969797e-02f, 9.98251140e-02f, 9.66266394e-02f, -1.30064651e-01f, 2.38929033e-01f, -8.51553380e-02f, 1.03082336e-01f, -1.65129006e-01f, 6.08077422e-02f, -1.19578496e-01f,
  -8.91046897e-02f, -3.17645743e-02f, -8.61932263e-02f, -1.91814557e-01f, -1.75643548e-01f, 2.64128357e-01f, -9.13369358e-02f, -4.75701511e-01f, 3.87639880e-01f, -9.70306173e-02f,
  4.05820251e-01f, -1.30903423e-01f, -3.20425123e-01f, -7.97750726e-02f, -2.20822394e-01f, -1.76641405e-01f, 2.72089481e-01f, 8.55973288e-02f, -2.46632881e-02f, -3.97804379e-02f,
  -2.82391403e-02f, -1.02782957e-01f, 3.97421978e-02f, -6.80344701e-02f, 1.40884876e-01f, 4.64189053e-02f, 2.11764142e-01f, -3.59390855e-01f, 1.04406364e-01f, 1.07415631e-01f,
  -3.72814983e-02f, 1.18619896e-01f, -3.30759436e-01f, -7.70312920e-02f, 9.01175737e-02f, 2.20835090e-01f, 2.99505353e-01f, 1.68485567e-01f, 9.54653174e-02f, -9.53778848e-02f,
  1.61848351e-01f, -3.50445747e-01f, 5.54934889e-02f, 1.01620488e-01f, -3.27599086e-02f, 2.74239093e-01f, -1.42667100e-01f, 1.53614208e-01f, 2.21248984e-01f, 1.05232410e-01f,
  4.61873859e-02f, -2.58199990e-01f, -1.77156076e-01f, 2.22352847e-01f, 2.53936619e-01f, 1.53652981e-01f, -3.16733122e-01f, -2.07096070e-01f, -7.93656185e-02f, 1.32570535e-01f,
  2.33848661e-01f, 1.72184378e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -3.18567678e-02f, -9.43155810e-02f, 3.27427462e-02f, -1.51836708e-01f, 2.77151354e-02f, 1.16388723e-01f, 2.21648619e-01f, 1.95866935e-02f, 3.35193984e-02f, 1.25000685e-01f,
  2.23045617e-01f, 1.89111635e-01f, 4.38894928e-01f, 2.22884580e-01f, -1.93630353e-01f, 3.20234209e-01f, -1.00673981e-01f, -6.74446672e-02f, 1.91517308e-01f, 3.19891363e-01f,
  8.45493656e-03f, 2.78155267e-01f, -1.42638460e-01f, 5.33382222e-02f, 5.38638294e-01f, -3.14483792e-01f, 1.40263110e-01f, 1.23471848e-03f, -1.35290056e-01f, -6.67366162e-02f,
  2.66080439e-01f, -2.74237227e-02f, 1.09591745e-02f, 1.54256225e-01f, 2.50690371e-01f, 2.35385150e-01f, 2.63705224e-01f, 2.45073617e-01f, 1.84423059e-01f, -1.53833702e-01f,
  1.86001554e-01f, 1.09072298e-01f, -4.64339890e-02f, -1.14865154e-01f, -1.86546281e-01f, 2.34908298e-01f, 2.07663342e-01f, 2.70006865e-01f, -2.64050066e-01f, 2.67421693e-01f,
  1.77802779e-02f, -1.53394714e-01f, -2.41387397e-01f, -3.24848443e-01f, -1.35138854e-01f, 1.39504001e-01f, -8.11398625e-02f, 5.39122522e-02f, -2.96941608e-01f, -8.64938796e-02f,
  -1.35796413e-01f, -1.94160074e-01f, -2.36049339e-01f, -1.21373840e-01f, 1.38350517e-01f, 2.17582360e-01f, 3.62680852e-01f, 3.54194671e-01f, 3.70421223e-02f, 1.25695184e-01f,
  -4.02277559e-01f, 6.68649733e-01f, -4.20141518e-01f, 1.12995736e-01f, 6.07779264e-01f, -1.68299630e-01f, -2.23902985e-01f, 1.29285023e-01f, -4.23635133e-02f, -2.43507951e-01f,
  1.54910862e-01f, -2.20609799e-01f, 4.97081012e-01f, 5.44481516e-01f, 3.45615059e-01f, 1.19761631e-01f, 2.18585834e-01f, 3.40537220e-01f, -3.71109366e-01f, 1.79100215e-01f,
  -2.62009084e-01f, -8.63111392e-03f, 3.73463750e-01f, -1.14569589e-01f, 4.92739171e-01f, 4.32921141e-01f, -3.44706550e-02f, -1.11443102e-01f, -1.20935537e-01f, 1.58413813e-01f,
  -8.60767215e-02f, -1.22368932e-01f, -1.32349059e-01f, -1.35712758e-01f, 6.53524175e-02f, 1.60937682e-01f, 1.36810943e-01f, -6.20676205e-02f, 6.87183216e-02f, 1.82685256e-02f,
  1.18683770e-01f, 8.31638724e-02f, -5.03493622e-02f, -2.62757372e-02f, -2.00859278e-01f, 7.20937178e-02f, -4.45960388e-02f, 2.18121141e-01f, 4.71281894e-02f, -6.21153191e-02f,
  6.13917410e-02f, -1.59710437e-01f, -5.59965102e-03f, 2.16709435e-01f, 1.11813713e-02f, 1.38472319e-01f, -1.23869237e-02f, -1.30929202e-01f, 7.24785998e-02f, 4.34721299e-02f,
  4.61282730e-02f, 2.91673213e-01f, 4.80149947e-02f, 3.91270727e-01f, -1.26224354e-01f, 4.25843626e-01f, -2.09519446e-01f, 7.17958510e-01f, 9.01772827e-02f, 3.15539211e-01f,
  -3.12044859e-01f, 8.93487632e-02f, 5.16255051e-02f, -1.03167027e-01f, 5.23429438e-02f, -2.36987084e-01f, -4.26050335e-01f, 4.91850257e-01f, 1.08054876e-01f, 2.22292259e-01f,
  -4.63606156e-02f, -3.74491140e-02f, 1.69838555e-02f, -1.07151277e-01f, -5.84690496e-02f, 4.02458102e-01f, -1.41248912e-01f, 3.36724728e-01f, -1.38501272e-01f, 2.22521260e-01f,
  2.56411523e-01f, 3.40213299e-01f, 3.92832905e-01f, 2.20270172e-01f, 4.40041542e-01f, 3.51006299e-01f, -2.67216444e-01f, -5.47112942e-01f, 2.01993017e-03f, -3.68442714e-01f,
  -1.00311354e-01f, 2.94769913e-01f, 4.73363876e-01f, -1.33354381e-01f, 2.57822610e-02f, -3.89195606e-02f, -6.81990981e-02f, 1.05747700e-01f, 2.54009217e-01f, -3.31925452e-01f,
  -2.89945036e-01f, 4.65873271e-01f, -5.46990037e-02f, -2.26340532e-01f, 2.14218736e-01f, -9.10934352e-04f, 5.08666873e-01f, 1.42476529e-01f, -8.77669007e-02f, -1.34117827e-02f,
  -2.21379474e-01f, -2.86310297e-02f, 3.56955640e-02f, 8.43300521e-02f, -1.74478710e-01f, -5.83570730e-03f, -7.97827914e-02f, -4.03890051e-02f, -1.27503261e-01f, -2.85284854e-02f,
  -6.45525455e-02f, 7.67780244e-02f, 6.38095587e-02f, 1.56073362e-01f, 3.16889398e-02f, -1.27160028e-01f, -1.25987545e-01f, 2.38460243e-01f, -1.31091058e-01f, -1.61500454e-01f,
  2.62188409e-02f, 1.06572598e-01f, 3.62482551e-03f, 3.70991617e-01f, -7.70573094e-02f, 7.56903365e-02f, 3.47977340e-01f, -2.46442407e-01f, 1.20300569e-01f, 4.65335995e-02f,
  -7.39708543e-02f, 1.40539184e-02f, 1.11382425e-01f, -1.81936637e-01f, 7.59821711e-03f, 1.46001846e-01f, 6.84027374e-02f, 1.66567519e-01f, 2.13137046e-02f, -6.54460937e-02f,
  2.47687206e-01f, -2.33772531e-01f, -4.06296225e-03f, -2.15354756e-01f, -1.24875724e-01f, 1.16603427e-01f, 3.53906536e-03f, 8.41123238e-02f, -2.94514030e-01f, -6.86643785e-03f,
  2.18297318e-01f, -1.79167278e-02f, 4.17658597e-01f, -1.93923086e-01f, 1.62277564e-01f, 1.36050671e-01f, 3.12038183e-01f, -6.59652129e-02f, 9.56578646e-03f, -1.67737752e-01f,
  2.49500692e-01f, -9.90336239e-02f, 8.42734873e-02f, 2.21134663e-01f, -1.40026376e-01f, -2.23659024e-01f, 8.07971880e-02f, -5.10672256e-02f, 2.55946815e-01f, 5.17330952e-02f,
  9.09759253e-02f, 5.79978228e-02f, -3.01754504e-01f, -3.70516777e-01f, -2.52004266e-01f, -4.14303362e-01f, -9.29860398e-02f, 1.18131720e-01f, 3.43446672e-01f, 1.17087118e-01f,
  1.90469444e-01f, -1.44248784e-01f, 2.01443166e-01f, 4.41151947e-01f, 3.53373230e-01f, -1.40460599e-02f, 1.02762409e-01f, 1.09103650e-01f, 1.42403720e-02f, -1.59865558e-01f,
  -1.18894801e-02f, -4.08391245e-02f, 5.03529191e-01f, -2.17218921e-01f, 6.71822205e-02f, -2.18648911e-01f, -1.85051709e-01f, -2.32208654e-01f, 4.54356149e-02f, 2.29299992e-01f,
  1.44421339e-01f, 1.19360141e-01f, -2.92456103e-03f, 9.45362821e-02f, -3.50653976e-01f, 2.20840201e-01f, -1.94537014e-01f, 3.59415673e-02f, 2.70711988e-01f, 1.53712898e-01f,
  7.31526762e-02f, 9.93390568e-03f, 3.74797322e-02f, -1.23463288e-01f, -9.18487012e-02f, -5.78478239e-02f, 2.94857591e-01f, 1.63184136e-01f, -2.16378644e-01f, 2.64218356e-02f,
  1.70244977e-01f, -2.70930737e-01f, 9.28765312e-02f, 1.52688557e-02f, -1.69232666e-01f, -3.05488352e-02f, -7.59148970e-03f, 1.27156600e-01f, 2.52054464e-02f, 6.91596568e-02f,
  -3.37746665e-02f, -1.33652434e-01f, -1.40894428e-02f, -9.72868800e-02f, 1.45038456e-01f, 1.43067285e-01f, -3.41101497e-01f, -8.00813809e-02f, 1.19697727e-01f, 6.38973759e-03f,
  -1.80700183e-01f, 3.36348452e-02f, -2.29484096e-01f, 1.26838684e-01f, 3.66383195e-01f, 1.84043616e-01f, -1.75127178e-01f, 2.80711800e-01f, -9.31234658e-02f, 1.00257446e-03f,
  1.67852908e-01f, 2.50981510e-01f, -2.15682849e-01f, 4.24465269e-01f, -6.35925606e-02f, 1.66073903e-01f, 1.51501834e-01f, 7.03926980e-02f, 6.11647628e-02f, 1.52829036e-01f,
  9.35684070e-02f, 9.01495069e-02f, -1.33302202e-02f, 1.79266572e-01f, 7.05131441e-02f, -9.00016725e-02f, 9.91536453e-02f, 2.02603698e-01f, -2.03058943e-02f, 2.22315818e-01f,
  8.63632932e-03f, -1.23224713e-01f, 1.79836020e-01f, -1.33417835e-02f, 7.49769732e-02f, -1.62251517e-01f, -1.10554405e-01f, 5.28298691e-02f, -1.87665090e-01f, -1.48743287e-01f,
  5.26869893e-02f, 4.23731618e-02f, 6.27164766e-02f, 1.66789457e-01f, 4.63545918e-02f, 1.38469547e-01f, -1.54816777e-01f, 6.22953102e-02f, 1.15711823e-01f, -2.05330610e-01f,
  -6.34039789e-02f, -2.04096511e-01f, -3.20859998e-02f, -1.21827938e-01f, 4.18004155e-01f, 2.70922482e-01f, 3.09084594e-01f, 2.34884977e-01f, 2.25015819e-01f, 4.12536353e-01f,
  5.76709807e-01f, -1.72588065e-01f, 6.99838579e-01f, 4.87628549e-01f, -8.36096331e-02f, 3.65758874e-02f, 2.64802724e-01f, 1.75833240e-01f, -2.42192164e-01f, 2.43642285e-01f,
  -1.65071204e-01f, 3.80317047e-02f, -2.31048599e-01f, 8.87364149e-02f, 1.34392187e-01f, 5.40481567e-01f, 9.31311473e-02f, -4.56677675e-02f, 4.71444458e-01f, -4.11274642e-01f,
  1.54358372e-01f, 1.08953074e-01f, -2.41412833e-01f, 1.53242528e-01f, -1.96093753e-01f, -2.46703420e-02f, 2.06504375e-01f, 6.81561530e-02f, 3.93039465e-01f, 3.59358221e-01f,
  5.11733815e-02f, 6.55264854e-02f, -1.26452088e-01f, -1.05765490e-02f, -1.24269962e-01f, -2.74373800e-01f, 2.31806957e-03f, -3.22834820e-01f, 2.65117764e-01f, -5.91263361e-02f,
  5.22602089e-02f, -2.12028861e-01f, -1.38715938e-01f, -9.02800709e-02f, 9.53024346e-03f, 2.39870071e-01f, -6.95035011e-02f, -1.90849125e-01f, -1.07058220e-01f, -1.81538075e-01f,
  -5.83479106e-02f, 2.76582688e-01f, 1.85089543e-01f, 2.85776425e-02f, 1.56343788e-01f, -3.20078850e-01f, -7.70053715e-02f, 1.10402610e-02f, 2.26353724e-02f, -3.85344215e-02f,
  8.46105367e-02f, 8.27792659e-02f, -2.37557897e-03f, 1.62830457e-01f, -2.92276412e-01f, -2.38110110e-01f, -1.63727447e-01f, -2.27212608e-01f, -1.80432960e-01f, 3.04452360e-01f,
  -7.21408799e-02f, -5.90217300e-02f, -9.87533629e-02f, 3.47843394e-02f, 3.91929746e-01f, -8.30017999e-02f, 6.54157028e-02f, -8.03857744e-02f, 7.40457401e-02f, 1.46073416e-01f,
  2.93333530e-01f, -6.06831275e-02f, -3.69714946e-02f, 9.78646576e-02f, 5.51428854e-01f, -4.15708162e-02f, 2.57664859e-01f, 3.92253429e-01f, 3.39527018e-02f, 8.22843891e-03f,
  1.19824000e-01f, 1.14645422e-01f, 3.73577088e-01f, 3.33640456e-01f, 3.40151757e-01f, 3.67605060e-01f, -3.49156916e-01f, 6.28280044e-02f, -2.41383120e-01f, 3.98759067e-01f,
  -1.10326894e-02f, 2.29925677e-01f, -3.50827545e-01f, 2.19653383e-01f, 4.52427834e-01f, 1.43120125e-01f, -1.64166436e-01f, 3.32458645e-01f, -3.67824316e-01f, 1.66327164e-01f,
  -1.86291724e-01f, 1.52846396e-01f, 1.48587748e-01f, 8.62767771e-02f, -2.62315363e-01f, -1.55512132e-02f, 2.41721302e-01f, 9.65558812e-02f, -8.56695250e-02f, 6.63291867e-05f,
  -1.81977868e-01f, 7.34255090e-02f, -5.86872883e-02f, 5.31396449e-01f, 2.16690764e-01f, 3.58227611e-01f, 3.35339457e-01f, 1.75035208e-01f, 6.11006439e-01f, -1.74819216e-01f,
  -1.78716764e-01f, -3.45599324e-01f, -9.68274251e-02f, -3.87718797e-01f, -1.73492245e-02f, 2.23555923e-01f, -2.79811412e-01f, -2.12213919e-01f, 5.18782258e-01f, -1.15731724e-01f,
  5.33588290e-01f, -3.58490556e-01f, 4.61905509e-01f, -1.75482094e-01f, 8.43587071e-02f, -2.20050573e-01f, -7.86442459e-02f, 3.18235725e-01f, 2.71883249e-01f, -4.08649296e-01f,
  -4.52443771e-02f, 2.02846020e-01f, -2.37154126e-01f, -3.05539727e-01f, 1.43704638e-01f, 3.20302248e-02f, -1.94922332e-02f, -2.31664651e-03f, -6.46111965e-02f, 2.63647288e-01f,
  3.34501982e-01f, 6.44438863e-02f, 4.48918551e-01f, 1.95064500e-01f, 7.68217370e-02f, -2.62493551e-01f, -5.97677194e-02f, -8.58738720e-02f, 3.98930684e-02f, 4.54656631e-01f,
  -2.31019128e-02f, 1.13108996e-02f, 1.29421458e-01f, 1.55429795e-01f, -1.56714544e-01f, 1.46763489e-01f, -1.43186644e-01f, 2.19968334e-01f, 1.76367804e-01f, -1.57376796e-01f,
  8.59215632e-02f, 1.20790675e-01f, -5.57362549e-02f, 2.66679563e-03f, 5.11557460e-02f, 1.40932202e-01f, 2.06307366e-01f, -2.21429653e-02f, 2.86715239e-01f, 1.62383839e-01f,
  5.85711598e-02f, -5.44525534e-02f, -7.82453939e-02f, 1.55709777e-02f, 9.59987640e-02f, 8.06145445e-02f, -5.00437571e-03f, 2.70782853e-04f, 5.09477369e-02f, 1.92547441e-01f,
  3.65087211e-01f, 2.37629816e-01f, -1.21866010e-01f, 6.27773166e-01f, -1.85721427e-01f, 3.39225262e-01f, -4.69843708e-02f, -5.44731393e-02f, -1.29962787e-01f, 6.28472805e-01f,
  -1.81534931e-01f, 2.36790031e-01f, 6.11269027e-02f, 1.12421453e-01f, 1.67536028e-02f, -2.21100584e-01f, -7.66894873e-03f, 2.04987466e-01f, -6.92544430e-02f, 1.35048211e-01f,
  -3.52692381e-02f, 1.98126987e-01f, 8.70421603e-02f, 1.06584564e-01f, 1.88765943e-01f, 2.12908894e-01f, 3.18889827e-01f, -4.04966846e-02f, 1.62358657e-01f, -3.10303122e-01f,
  3.20200413e-01f, 2.50525415e-01f, -1.58825636e-01f, 2.17499193e-02f, -2.77021617e-01f, -1.94238186e-01f, 2.16890290e-01f, 1.30739123e-01f, -1.14237472e-01f, -8.09593424e-02f,
  -1.37901440e-01f, -2.46202517e-02f, 4.22475755e-01f, 1.39153674e-01f, 6.72154501e-03f, -1.35076970e-01f, 3.30241583e-02f, -1.13403149e-01f, -1.69504195e-01f, 1.12602808e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.93125100e-02f, 2.51325905e-01f, 4.97934729e-01f, 6.06957749e-02f, 3.48158985e-01f, 4.27945107e-01f, 8.43663365e-02f, 3.29590023e-01f, 3.18296030e-02f, 2.90602982e-01f,
  1.12278171e-01f, -9.12619978e-02f, 3.37001592e-01f, 1.65715367e-01f, 2.81194210e-01f, 2.63854921e-01f, 4.48017389e-01f, 8.21567252e-02f, 1.54838696e-01f, 3.41147155e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -5.62289357e-01f, 1.93361878e-01f, -9.34908688e-02f, -3.41482401e-01f, -2.35470623e-01f, -9.54257175e-02f, 3.27287287e-01f, 5.62353313e-01f, 3.60932887e-01f, 3.38485837e-01f,
  4.80961114e-01f, 2.87265897e-01f, 5.22453129e-01f, -5.65687232e-02f, -5.63658953e-01f, -4.27786261e-02f, -3.76847774e-01f, 5.73968470e-01f, 1.01505360e-02f, 1.50719181e-01f,
  2.77861446e-01f, 2.15171605e-01f, -2.24908218e-01f, -7.09264576e-02f, 1.75612167e-01f, 1.08966544e-01f, -2.82919794e-01f, -4.82898712e-01f, 1.56376567e-02f, 3.37545685e-02f,
  -1.92551404e-01f, 4.02835757e-01f, -1.04389973e-01f, -5.86774871e-02f, 4.88827415e-02f, 4.33998883e-01f, 4.90631253e-01f, -2.68553555e-01f, 6.15221739e-01f, 8.01112771e-01f,
  -5.04432321e-01f, -3.07159454e-01f, -5.30502871e-02f, 3.41191590e-01f, 5.00136733e-01f, 9.65333730e-02f, -3.50246876e-01f, 6.78175176e-03f, 1.97872907e-01f, -3.74502003e-01f,
  2.69329995e-01f, -1.72684371e-01f, -3.65180910e-01f, -1.40753109e-02f, -1.79520860e-01f, -6.53125718e-02f, 7.63621032e-01f, -2.77400702e-01f, -2.75302023e-01f, -3.94388884e-01f,
  -4.73782450e-01f, 4.04144406e-01f, -2.14807361e-01f, 5.23475289e-01f, 5.56937084e-02f, -4.88278866e-01f, 5.48767447e-02f, -4.09536898e-01f, 1.90234333e-01f, 6.65128529e-02f,
  -1.28222495e-01f, 7.15947092e-01f, 4.23215538e-01f, -3.11710954e-01f, 3.50937732e-02f, -4.20436561e-02f, 3.78342688e-01f, -1.79269284e-01f, 4.57974285e-01f, 1.16646498e-01f,
  3.91512126e-01f, -5.42184830e-01f, 5.70692271e-02f, -2.91088045e-01f, -2.00990617e-01f, -6.57671243e-02f, 2.11113244e-01f, -1.00638168e-02f, 5.13821952e-02f, -3.27277899e-01f,
  -3.70951146e-01f, 1.87561154e-01f, -4.10255343e-01f, 1.51154876e-01f, 4.79420573e-01f, -1.52633905e-01f, -2.70637181e-02f, -2.04327151e-01f, 1.07351176e-01f, -2.19897494e-01f,
  2.18140095e-01f, -6.59548461e-01f, -4.45358962e-01f, -2.85958618e-01f, -1.81718934e-02f, 5.39567992e-02f, 1.09413080e-01f, -5.56028783e-01f, 2.97834259e-02f, -3.65401916e-02f,
  -5.03040135e-01f, 2.13073287e-02f, -2.83497691e-01f, 3.06781620e-01f, 2.66751042e-03f, 4.47972089e-01f, 4.57505018e-01f, -2.14361325e-01f, -3.29180032e-01f, -1.73481122e-01f,
  8.71135592e-02f, 2.41437834e-02f, 6.23331487e-01f, -1.50622055e-01f, 3.36255491e-01f, -1.94729596e-01f, -2.62697279e-01f, -2.81161427e-01f, 6.79233968e-01f, -7.59762824e-02f,
  -4.05152112e-01f, -1.26661077e-01f, 1.87169984e-01f, 3.98757964e-01f, 3.76066595e-01f, -9.14878249e-01f, 7.45072067e-01f, 3.26685846e-01f, 7.87051320e-01f, -1.79372758e-01f,
  8.24196115e-02f, -2.74766326e-01f, 4.09556508e-01f, -1.39433205e-01f, -4.03759092e-01f, 4.06390846e-01f, 8.21359456e-02f, 3.19062471e-01f, 3.48278224e-01f, 3.73666227e-01f,
  -1.13470539e-01f, 2.03881502e-01f, -4.39409494e-01f, -1.36325046e-01f, 2.48290688e-01f, -1.61927089e-01f, 2.49142647e-01f, 6.08502480e-04f, -5.01898408e-01f, -1.26379833e-01f,
  3.36436987e-01f, 7.33931601e-01f, 6.50933444e-01f, 3.45987290e-01f, 3.28262240e-01f, 4.95206684e-01f, 7.93740034e-01f, -1.61473721e-01f, -3.42051499e-02f, 2.35729799e-01f,
  -2.21304353e-02f, 1.93385288e-01f, -4.77221072e-01f, 6.16616368e-01f, -3.48399691e-02f, -9.56535488e-02f, -3.36328089e-01f, 1.28446311e-01f, -4.05207604e-01f, 6.65659027e-04f,
  -3.20896178e-01f, 2.45764181e-02f, -3.36279690e-01f, 1.11593172e-01f, 3.20847899e-01f, 3.87838811e-01f, -4.60806012e-01f, 6.70096725e-02f, 6.26360416e-01f, 7.24412575e-02f,
  -6.58715318e-04f, 2.72736758e-01f, 1.35582194e-01f, 3.39769185e-01f, -1.62810236e-01f, 2.80451477e-01f, 3.03969830e-01f, 3.30618411e-01f, 2.67204463e-01f, -5.32095373e-01f,
  5.73350132e-01f, -6.12475991e-01f, 1.16411850e-01f, -3.64347845e-01f, -2.15788886e-01f, 5.99672124e-02f, 5.71721971e-01f, -6.76473789e-03f, 8.33315134e-01f, -2.26589054e-01f,
  -7.13682473e-02f, -1.69714376e-01f, -9.67367142e-02f, 4.94192809e-01f, -1.58995599e-01f, -1.04493178e-01f, -4.84367192e-01f, -5.04084583e-03f, 6.76927567e-02f, 6.68038130e-01f,
  -5.91192901e-01f, -4.65323955e-01f, -6.35817870e-02f, -8.98335800e-02f, -3.17585766e-01f, -2.62786616e-02f, 1.14231128e-02f, -7.25530460e-02f, -7.69773573e-02f, 6.22010864e-02f,
  -5.61957657e-01f, -4.46240664e-01f, -6.15885377e-01f, -7.05197528e-02f, -2.73278803e-01f, 3.83223772e-01f, 1.79504920e-02f, -1.70137256e-01f, 2.79321432e-01f, -2.32872441e-01f,
  1.19140744e-01f, -7.34483957e-01f, 1.92636102e-02f, 2.38780096e-01f, 6.79966121e-04f, -1.20378293e-01f, -1.29517540e-01f, -1.76544249e-01f, -3.68038386e-01f, -2.50510246e-01f,
  2.53321141e-01f, -3.87286305e-01f, 9.24804568e-01f, -1.43002555e-01f, -2.87043452e-01f, -1.24639280e-01f, -3.24717492e-01f, -4.40439045e-01f, -4.36108887e-01f, 3.77292633e-02f,
  -5.70008636e-01f, -2.82591611e-01f, -2.96465814e-01f, 5.76028466e-01f, -6.30609989e-01f, -4.13216531e-01f, -3.70072097e-01f, 4.44086373e-01f, 6.58030575e-03f, 5.56216061e-01f,
  -4.17785138e-01f, 1.24239914e-01f, -3.40704739e-01f, -1.30685374e-01f, -1.41568109e-01f, -2.51431204e-02f, 3.31063867e-02f, -1.39607459e-01f, 2.62529492e-01f, -1.45231828e-01f,
  1.33090928e-01f, -1.74697623e-01f, -5.77745065e-02f, 3.14303368e-01f, -1.41488969e-01f, 3.05955887e-01f, 5.85033178e-01f, -2.18088344e-01f, -4.53311019e-02f, 3.07922900e-01f,
  -3.30383122e-01f, 4.16642763e-02f, -3.75366747e-01f, -1.54330447e-01f, 6.79626405e-01f, 4.39574510e-01f, 4.10056949e-01f, 2.61698037e-01f, 7.20061719e-01f, 3.17716718e-01f,
  -1.47462517e-01f, -2.28891715e-01f, 1.08460903e+00f, -1.16652166e-02f, -3.57927799e-01f, -2.84094363e-01f, -2.31725276e-01f, -3.38696390e-01f, -2.45569259e-01f, 2.72566289e-01f,
  -2.06610441e-01f, 2.31560357e-02f, -4.73528266e-01f, 4.31915015e-01f, -7.04944413e-03f, -5.12164056e-01f, -4.53542084e-01f, -1.54200464e-01f, 9.50853303e-02f, 1.58294380e-01f,
  1.50994271e-01f, 1.30643606e-01f, 1.46620378e-01f, 1.10096455e-01f, -3.59940022e-01f, 2.53429383e-01f, -4.30731744e-01f, -2.42199183e-01f, -5.08500755e-01f, -1.06436133e-01f,
  -3.29006284e-01f, -7.75501430e-01f, -1.00471899e-02f, -3.17835450e-01f, -4.98837203e-01f, 1.66115746e-01f, 3.30288559e-01f, 5.06581008e-01f, 2.79402673e-01f, 7.23283812e-02f,
  -4.22943473e-01f, 9.83872414e-02f, 3.58574167e-02f, -1.72509298e-01f, 8.10804009e-01f, -2.82284349e-01f, 2.01242104e-01f, 1.85665354e-01f, -4.41040516e-01f, 6.53242841e-02f,
  -3.19845617e-01f, -2.77688503e-01f, -3.33035678e-01f, 1.26694724e-01f, 7.20181391e-02f, 1.96490213e-01f, 1.88324675e-01f, 2.52129853e-01f, -6.50386691e-01f, -5.19677579e-01f,
  2.16928512e-01f, 3.26660544e-01f, -3.10692877e-01f, -5.66126525e-01f, -1.38932437e-01f, 2.70760078e-02f, -3.63203645e-01f, -1.14525199e-01f, -2.93957889e-01f, 4.62911069e-01f,
  -6.83551952e-02f, -3.30056667e-01f, 5.77774048e-01f, -8.75571743e-02f, 4.02404934e-01f, -2.21790195e-01f, -5.59902668e-01f, 2.47502863e-01f, 1.94716886e-01f, 3.42827469e-01f,
  -4.14375037e-01f, -3.29646021e-01f, 4.00669128e-01f, -2.78181076e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.21023051e-01f, 7.56138116e-02f, -1.59819469e-01f, -2.59290367e-01f, 1.83885157e-01f, 3.29421431e-01f, 7.99204558e-02f, 6.51766546e-03f, 3.08348741e-02f, 1.38994619e-01f,
  -1.58943385e-01f, 2.12620527e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    