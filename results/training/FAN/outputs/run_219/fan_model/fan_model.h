/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.98798758e-02f, -1.26266778e-01f, 6.01069592e-02f, -1.11809716e-01f, -1.23214245e-01f, 1.31787196e-01f, -2.99050193e-03f, -1.25713810e-01f, -7.07306564e-02f, -1.94975793e-01f,
  4.88155112e-02f, -5.18539250e-02f, 7.52033070e-02f, -2.18970198e-02f, 5.31563342e-01f, 2.98945397e-01f, 1.07796244e-01f, -2.41056886e-02f, -8.73307809e-02f, -9.86093059e-02f,
  8.69101658e-02f, -2.92614009e-02f, 1.57414377e-01f, -7.34475031e-02f, -5.96411005e-02f, -1.35775492e-01f, -5.54413684e-02f, 7.09494343e-03f, -9.53941345e-02f, 8.61061513e-02f,
  1.90738887e-01f, -3.56079526e-02f, -9.96189266e-02f, 1.50128698e-03f, -2.44900025e-02f, -3.61583196e-02f, 2.91856509e-02f, 9.26821232e-02f, 2.39904914e-02f, -5.58068529e-02f,
  6.99851885e-02f, 1.53429639e-02f, 7.53144873e-03f, -3.47237960e-02f, -3.33094746e-02f, -6.03685016e-03f, -3.81674953e-02f, -8.90531614e-02f, -1.06093869e-01f, -2.76758261e-02f,
  4.59872000e-02f, 1.75108318e-03f, -4.17648330e-02f, -5.14856875e-02f, 1.18229026e-02f, 1.32974572e-02f, 1.45394902e-03f, -1.21419625e-02f, 3.03873979e-02f, -7.62015507e-02f,
  -4.16869521e-02f, 3.72489318e-02f, 8.05066451e-02f, 1.33451279e-02f, 4.97650839e-02f, -3.80546935e-02f, 2.25856230e-02f, -1.30235367e-02f, -3.23778465e-02f, -5.72412908e-02f,
  -1.92994568e-02f, -3.96843478e-02f, -4.32909802e-02f, -6.38197130e-03f, -4.54765670e-02f, -8.03944096e-02f, 4.84938025e-02f, 1.08513953e-02f, 2.04836857e-02f, -2.56980006e-02f,
  -5.16059250e-02f, 8.23895186e-02f, -1.45986890e-02f, -5.36840186e-02f, 7.40229487e-02f, 3.16179469e-02f, -2.27340758e-02f, -6.84289914e-03f, 9.30363871e-03f, 2.71325521e-02f,
  -2.56775264e-02f, -5.83408922e-02f, -2.87810601e-02f, -3.79921868e-02f, 3.70039530e-02f, 8.42162594e-02f, 6.37537288e-03f, -7.42906928e-02f, 9.99633074e-02f, 5.09451181e-02f,
  -7.46557787e-02f, 3.28300446e-02f, 4.39734608e-02f, 6.55470043e-02f, 6.30220491e-03f, 1.17872665e-02f, 2.61677057e-02f, 5.52198142e-02f, -1.13639038e-03f, -9.05194357e-02f,
  -7.32521787e-02f, 3.69357429e-02f, 2.72913314e-02f, -7.96150267e-02f, -2.11678389e-02f, 1.54754892e-02f, -3.60473767e-02f, -2.07780525e-02f, -1.39082335e-02f, 4.97909151e-02f,
  -7.06901431e-01f, 2.46875197e-01f, -2.24785820e-01f, 1.12959251e-01f, -1.95203975e-01f, 1.67850778e-01f, 1.54717416e-01f, 1.89629439e-02f, 2.79777441e-02f, 1.18333817e-01f,
  -2.22427603e-02f, 3.30428071e-02f, 5.82764000e-02f, 1.33874580e-01f, 5.10878488e-02f, 1.63629830e-01f, 1.32009163e-02f, -1.00678563e-01f, 6.67311028e-02f, -2.23283675e-02f,
  -4.67308424e-02f, 7.54078403e-02f, -9.15739462e-02f, -5.12099192e-02f, -1.57952026e-01f, -6.88120201e-02f, -6.24748543e-02f, 8.04266408e-02f, -3.65831777e-02f, -1.40785156e-02f,
  -9.47903935e-03f, -1.79187924e-01f, -1.68337107e-01f, -5.63805737e-02f, -7.34134018e-02f, -6.90535679e-02f, 1.16320457e-02f, -4.32675481e-02f, -1.46342842e-02f, 1.03467599e-01f,
  5.91724701e-02f, -4.19194996e-02f, -2.28291638e-02f, 3.05905975e-02f, 1.63023416e-02f, -1.91525090e-02f, 1.01198815e-02f, -5.24025410e-02f, 7.89570156e-03f, 4.15440761e-02f,
  5.46183437e-03f, -3.97246741e-02f, -3.71474773e-02f, 3.03770532e-04f, -3.70912291e-02f, -3.56924385e-02f, 4.63611388e-04f, 3.91862402e-03f, -4.26665954e-02f, -6.91091642e-02f,
  -4.67961729e-02f, 1.35822715e-02f, 1.27762640e-02f, 3.02185095e-03f, -1.04257017e-02f, -1.35464752e-02f, -7.36705074e-03f, -1.19193019e-02f, 8.34844541e-03f, 3.92397009e-02f,
  3.14997174e-02f, -2.15147883e-02f, 1.58288553e-02f, 5.09253852e-02f, 1.53272375e-02f, 9.23073571e-03f, -9.82051529e-03f, 1.48077812e-02f, 2.95241531e-02f, -3.27460580e-02f,
  3.92867737e-02f, 9.65837389e-03f, -4.72665988e-02f, 2.91810352e-02f, 3.67250480e-02f, -5.86861931e-02f, 3.67897600e-02f, 8.87165591e-03f, 1.74207631e-02f, -1.63692480e-03f,
  9.55154970e-02f, -8.33816454e-02f, 1.09312408e-01f, -2.39316234e-03f, 3.58293504e-02f, -1.05242748e-02f, 8.18173774e-03f, 4.69856150e-02f, 1.38758630e-01f, 5.32114133e-03f,
  -1.83440167e-02f, -8.99235830e-02f, -2.23499793e-03f, -2.07448471e-03f, 4.44096327e-02f, 3.63993905e-02f, 8.06103200e-02f, 3.61917750e-03f, -3.51628214e-02f, 1.53513532e-02f,
  -7.00095855e-03f, -5.54942945e-03f, -2.02326846e-04f, -7.38137886e-02f, -4.30717133e-02f, -3.22030969e-02f, -8.30003694e-02f, 2.57336963e-02f, 4.58342955e-02f, 3.05573754e-02f,
  1.09273322e-01f, -1.65132254e-01f, -1.47459328e-01f, 9.86838862e-02f, 2.11087033e-01f, 4.82439518e-01f, 4.51866716e-01f, 9.74784419e-02f, 3.22550952e-01f, 3.51391248e-02f,
  1.93679839e-01f, -1.18378110e-01f, 4.34461199e-02f, 2.02104181e-01f, 3.48514169e-01f, 1.76659986e-01f, 1.81356251e-01f, 6.10518130e-03f, 4.79232408e-02f, 2.34032087e-02f,
  3.28450464e-02f, 6.91310540e-02f, -1.08102739e-01f, -1.02851383e-01f, 8.17373488e-03f, -1.89400852e-01f, -2.41513476e-01f, -1.06879197e-01f, -6.00687005e-02f, -2.62207035e-02f,
  2.09012717e-01f, 1.58601373e-01f, -7.59270489e-02f, -6.76307604e-02f, -4.27957438e-02f, -6.29259273e-02f, -1.20438255e-01f, -4.10484150e-02f, 7.74722844e-02f, -1.79160349e-02f,
  3.11230719e-02f, 7.38339406e-03f, 1.71174353e-03f, 4.68548350e-02f, -2.42679962e-03f, -1.12373009e-02f, -1.64805111e-02f, 2.29467116e-02f, -3.48869897e-02f, 2.01585665e-02f,
  2.63365060e-02f, -1.21749034e-02f, -3.07833552e-02f, -5.47174551e-02f, 7.53289983e-02f, 9.56086442e-02f, -3.08913067e-02f, 6.99135300e-04f, 1.60418674e-02f, 7.82223120e-02f,
  1.35127595e-02f, -2.44689137e-02f, -4.54708375e-02f, -3.93309519e-02f, -3.99837969e-03f, -4.77102138e-02f, 4.07933854e-02f, -3.39469388e-02f, -3.90648730e-02f, 2.28169244e-02f,
  -2.10165326e-02f, -1.78276114e-02f, 3.94446962e-02f, -1.28925929e-03f, 2.48305947e-02f, -2.62502488e-03f, -4.76258323e-02f, -8.18601474e-02f, 3.64198312e-02f, 5.31033725e-02f,
  -5.10242283e-02f, 1.26077486e-02f, -3.03309709e-02f, -8.72270912e-02f, 4.75301258e-02f, -4.54172641e-02f, -3.82414497e-02f, -4.39144857e-03f, -2.93464325e-02f, -2.20553353e-02f,
  -5.58999591e-02f, -1.83018103e-01f, 1.27111420e-01f, -1.07152732e-02f, -5.47044212e-03f, 6.70123398e-02f, 2.24793945e-02f, 8.13042559e-03f, -7.09796771e-02f, 2.26083733e-02f,
  2.98313960e-03f, 3.12798307e-03f, -5.09961396e-02f, -2.56307013e-02f, -6.04033982e-03f, 6.10734932e-02f, 1.76367778e-02f, -1.80052575e-02f, 4.47559357e-02f, -3.63026746e-02f,
  -8.73804241e-02f, 2.49553230e-02f, 2.85035726e-02f, 1.21744107e-02f, -3.19751650e-02f, -1.43170655e-02f, 7.86526576e-02f, -5.36503866e-02f, -3.20593826e-02f, 3.66296954e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.77159888e-01f, -8.00693128e-03f, -3.52356315e-01f, 2.15550020e-01f, -1.73866838e-01f, 2.45097309e-01f, 1.26658618e-01f, -3.03604528e-02f, -2.11376771e-01f, 4.42280024e-01f,
  2.69017339e-01f, -8.61401781e-02f, -6.62319288e-02f, 5.08286715e-01f, -2.15017915e-01f, -7.56894471e-04f, 3.26030225e-01f, 2.36730546e-01f, -1.99259445e-01f, 1.57800573e-03f,
  -9.23527181e-02f, 4.34560478e-01f, 1.64404482e-01f, 2.07393289e-01f, 7.20497221e-02f, -1.58454236e-02f, 2.05255136e-01f, -1.57617196e-01f, 3.24533492e-01f, 4.43549491e-02f,
  5.49969403e-03f, -1.63405716e-01f, -4.17359732e-02f, -3.68339792e-02f, -2.41331570e-02f, 9.33674071e-03f, 9.10675898e-03f, 5.44773694e-03f, -9.71188694e-02f, -8.62995982e-02f,
  -1.02784991e-01f, -5.55930799e-03f, 8.50306675e-02f, -1.19254543e-02f, -7.47559294e-02f, -2.23260131e-02f, -7.13264523e-03f, 1.25560602e-02f, 2.49860827e-02f, -1.11480996e-01f,
  1.19922068e-02f, -2.15034019e-02f, 2.13373527e-02f, 6.76724017e-02f, -5.26691675e-02f, 6.89953864e-02f, 7.63568580e-02f, -7.28035867e-02f, -1.16864769e-02f, 3.72089632e-02f,
  5.54532111e-02f, -9.27946046e-02f, 1.82037372e-02f, -1.16871856e-02f, 4.23554797e-03f, -6.32855482e-03f, 6.55534938e-02f, -3.85205857e-02f, -6.35779351e-02f, 5.08045442e-02f,
  3.63321342e-02f, -3.08375806e-02f, -3.49114649e-02f, 7.08274841e-02f, -3.15159708e-02f, 2.03997511e-02f, -4.09959853e-02f, 2.86353007e-03f, -9.14975181e-02f, -5.52792735e-02f,
  7.66530866e-03f, -5.34714200e-02f, 1.14921764e-01f, -6.14926312e-03f, 2.01382060e-02f, -1.60112195e-02f, 4.12653796e-02f, -6.98126620e-03f, 3.58618796e-02f, -7.73914903e-02f,
  -5.48042245e-02f, -1.27645954e-01f, 7.83894062e-02f, 3.74974310e-02f, -8.83833878e-03f, 3.53200138e-02f, -4.04531956e-02f, -4.82591055e-02f, -4.52093072e-02f, -1.01157993e-01f,
  6.28369004e-02f, 2.31911819e-02f, -1.11954734e-02f, 1.95123104e-03f, 1.25985667e-02f, 1.66206211e-02f, -5.06937206e-02f, 7.97333568e-02f, 1.02390394e-01f, -2.91068982e-02f,
  6.57964051e-02f, -3.44494060e-02f, -1.81150995e-02f, -4.71963435e-02f, 7.08699077e-02f, 5.67870401e-02f, -3.52629088e-02f, -2.24775393e-02f, -2.94618141e-02f, -3.02027650e-02f,
  5.28897643e-02f, -2.03879669e-01f, -2.94011325e-01f, -2.93092489e-01f, -2.21038833e-01f, -3.54377687e-01f, -5.69148123e-01f, -1.58342212e-01f, -1.62041590e-01f, -1.16934709e-01f,
  -1.39657184e-01f, 1.26066163e-01f, 3.42070699e-01f, -2.72106111e-01f, 2.67397016e-01f, 3.57150376e-01f, -3.34049940e-01f, -8.80626775e-03f, 3.65647562e-02f, -2.00735386e-02f,
  -2.27065086e-02f, -1.91421196e-01f, 1.45723820e-01f, -1.08353920e-01f, -1.50515780e-01f, -6.49563223e-02f, 1.94251731e-01f, -2.03655466e-01f, -1.57950625e-01f, -1.12301238e-01f,
  4.93759960e-02f, 2.22085118e-01f, -5.48482724e-02f, 6.34461194e-02f, 2.77779326e-02f, -1.60181429e-02f, -1.25159681e-01f, -1.44915469e-02f, -6.22252421e-03f, -5.89431152e-02f,
  2.69731693e-02f, -1.16150202e-02f, -5.07724285e-02f, -5.79573698e-02f, -5.93307540e-02f, -8.41986388e-02f, 5.46902493e-02f, -4.46613394e-02f, 1.66322328e-02f, -2.00164821e-02f,
  -8.91569629e-02f, -5.82857616e-02f, -1.08363241e-01f, -1.98813546e-02f, 5.64935431e-02f, -1.33622304e-01f, 9.06606019e-02f, 9.03625041e-02f, 6.55336007e-02f, -4.85022068e-02f,
  1.02199037e-02f, -2.91960146e-02f, -5.17465547e-03f, 1.45953810e-02f, -3.09742130e-02f, 3.97156645e-03f, 5.20987902e-03f, 8.38870257e-02f, -1.41851470e-01f, 4.29829136e-02f,
  -6.04206547e-02f, 7.03086406e-02f, 7.13202432e-02f, 5.84614975e-03f, -1.27697974e-01f, 4.78871576e-02f, 1.03164203e-02f, 2.25526895e-02f, -7.77823403e-02f, -3.29254381e-02f,
  7.55780041e-02f, -4.24819961e-02f, -4.40946594e-02f, 6.68748142e-03f, -4.26292010e-02f, 6.98189363e-02f, -2.78186556e-02f, 3.82707827e-02f, 5.37920445e-02f, 2.78372765e-02f,
  -5.73135391e-02f, 1.05412975e-01f, -7.65997544e-03f, -5.36342338e-02f, 9.91979148e-03f, -4.86052707e-02f, -4.53874543e-02f, -7.05206096e-02f, -1.25056431e-01f, -5.64663112e-03f,
  -6.01923615e-02f, 4.37235553e-03f, 2.09294166e-02f, 1.74396671e-02f, -1.04891621e-02f, -8.91759396e-02f, -1.42306238e-02f, 2.14120355e-02f, -1.00877896e-01f, -7.50027597e-02f,
  4.98229340e-02f, 2.92238593e-02f, 6.32704794e-02f, 7.74317309e-02f, -2.48961393e-02f, -4.76986244e-02f, 3.62584963e-02f, 1.31248683e-02f, -1.84753984e-02f, -3.68772671e-02f,
  5.40309966e-01f, -9.53399017e-02f, -3.66785556e-01f, 1.00571685e-01f, 2.25341529e-01f, 2.60119718e-02f, -2.17832610e-01f, 1.38685614e-01f, -8.22578967e-02f, -6.69317916e-02f,
  1.91463515e-01f, -8.93109962e-02f, -1.42827109e-01f, 3.23056012e-01f, 2.26647317e-01f, -1.63321957e-01f, 3.12772900e-01f, 8.69114548e-02f, -1.63116993e-03f, 1.08154170e-01f,
  1.27377629e-01f, 5.57521820e-01f, -1.31605580e-01f, 1.86446398e-01f, 9.54762846e-02f, -4.72449884e-02f, 1.50807530e-01f, -1.28284603e-01f, 1.66765332e-01f, 1.78644612e-01f,
  1.68373942e-01f, 1.28170609e-01f, 8.06856342e-03f, -8.09404999e-02f, 4.94850874e-02f, -1.03899278e-02f, -2.15902291e-02f, -6.67796582e-02f, -3.03020421e-02f, 4.54231240e-02f,
  -3.04969307e-02f, 1.28445804e-01f, 6.29569143e-02f, 2.08057538e-02f, -4.06939164e-03f, -8.19934905e-02f, 1.05949668e-02f, -1.01884894e-01f, -7.39397332e-02f, -7.39094103e-03f,
  -1.41326487e-01f, 2.60157418e-02f, 3.14819366e-02f, 2.64190435e-02f, -7.73424655e-03f, 8.05305410e-03f, 8.88758863e-04f, -1.33169502e-01f, 3.36077102e-02f, -3.68414051e-03f,
  8.58811960e-02f, -5.96518405e-02f, 3.52981985e-02f, 9.96001065e-03f, 7.88786933e-02f, 4.64691520e-02f, -2.55331956e-02f, 6.52805492e-02f, -6.29302114e-02f, 2.76573971e-02f,
  3.22801284e-02f, -7.15706050e-02f, -2.46826764e-02f, 4.07610573e-02f, -1.94495637e-02f, -5.23143671e-02f, 4.07314673e-02f, 6.54980466e-02f, 1.88644591e-03f, -3.75406630e-02f,
  -3.95584963e-02f, 5.44199012e-02f, -4.10078354e-02f, 3.62281539e-02f, 2.31687948e-02f, 4.20449786e-02f, 3.16630602e-02f, -4.17139083e-02f, -1.36953354e-01f, 7.78586371e-03f,
  -3.03582456e-02f, -4.21774946e-02f, -1.36600181e-01f, 2.85373311e-02f, -2.20480300e-02f, 6.18847050e-02f, -1.60102174e-02f, 2.76110359e-02f, -7.27047771e-03f, 4.40020300e-02f,
  -8.45655892e-03f, -6.24346994e-02f, -2.29707872e-03f, 8.87281895e-02f, 5.83937950e-02f, 7.87795931e-02f, -4.28587198e-02f, 9.74646118e-03f, 4.54917364e-02f, 6.79570287e-02f,
  -1.06661133e-01f, 4.09543253e-02f, 4.93205991e-03f, -4.21801321e-02f, -1.52652955e-03f, -1.25737771e-01f, -8.42524413e-03f, 2.65246630e-02f, -4.08910662e-02f, 1.77691784e-02f,
  -3.65705132e-01f, 4.87883091e-02f, -1.91360712e-01f, -9.51759610e-03f, 3.92258205e-02f, -7.27068633e-03f, -1.51379108e-01f, -1.33713320e-01f, -1.51238784e-01f, -1.16483621e-01f,
  -7.19371885e-02f, -4.01212461e-02f, -1.77779645e-01f, 6.91659525e-02f, -1.20998174e-01f, 5.74048497e-02f, 3.34981121e-02f, -6.82328418e-02f, 1.55711666e-01f, -3.29014510e-02f,
  1.09015025e-01f, 1.65511489e-01f, 1.53107926e-01f, 1.82952970e-01f, 9.98154283e-02f, 8.87571424e-02f, 1.57604232e-01f, -3.44563858e-03f, 4.12843116e-02f, 1.71357974e-01f,
  -4.88170758e-02f, 3.16673592e-02f, 1.45589719e-02f, 6.31604418e-02f, 1.98710803e-02f, -1.40248865e-01f, -1.60607826e-02f, -1.81303751e-02f, -1.26266643e-01f, -7.55356029e-02f,
  -5.32903597e-02f, 1.10511906e-01f, -5.08496016e-02f, -2.61007622e-02f, -7.49762729e-02f, 4.54971641e-02f, 7.83228278e-02f, 6.69733126e-05f, 7.39934435e-03f, 6.82392418e-02f,
  -2.64289696e-02f, 2.94756386e-02f, -5.23020029e-02f, 1.10074960e-01f, 3.60695682e-02f, 2.85215303e-02f, -3.23404856e-02f, 6.61771894e-02f, 1.13310784e-01f, 4.10998575e-02f,
  -9.39104985e-03f, -8.82498324e-02f, 4.25601564e-02f, 1.09927086e-02f, 5.29620051e-02f, 1.21087655e-01f, -6.45939186e-02f, 9.20224041e-02f, 3.69884782e-02f, -6.37495592e-02f,
  8.38635117e-02f, 2.22642906e-02f, -6.24275990e-02f, 3.26413661e-02f, 5.25882952e-02f, -1.08760847e-02f, -4.56189401e-02f, 1.49340574e-02f, 1.69457961e-02f, 5.97308725e-02f,
  9.07704234e-02f, -4.42439280e-02f, -2.49786563e-02f, -3.37879211e-02f, 3.23374234e-02f, -9.84820500e-02f, 5.51332980e-02f, 2.18876265e-02f, -1.90237407e-02f, -1.56505350e-02f,
  -4.34007868e-02f, 4.22313884e-02f, -1.53443804e-02f, 6.31493479e-02f, 3.59193049e-02f, -3.74534316e-02f, -2.04643719e-02f, -7.54673555e-02f, -9.71510485e-02f, -3.90979722e-02f,
  -9.88301705e-04f, 2.37287395e-02f, -3.13290283e-02f, -2.21154746e-02f, 7.16106268e-03f, 9.29479524e-02f, 3.75281759e-02f, -7.03902319e-02f, -4.37868293e-03f, 1.57214209e-01f,
  3.31193209e-03f, 8.32827240e-02f, -1.30948033e-02f, 5.34954295e-02f, 4.01062779e-02f, -9.82158910e-03f, 3.88313644e-02f, 2.35375147e-02f, -2.27481127e-02f, 1.01100959e-01f,
  -6.98734447e-02f, 7.55934343e-02f, -1.10666536e-01f, 5.95933944e-02f, 1.06339335e-01f, 1.71149269e-01f, 2.51131684e-01f, 1.24961056e-01f, 2.80472487e-01f, 1.41559049e-01f,
  5.00111282e-02f, 1.08781889e-01f, -6.66959584e-03f, 6.02853717e-03f, 2.82894149e-02f, -3.57692875e-02f, 1.85769618e-01f, 1.53035983e-01f, 2.84278020e-02f, 7.21127465e-02f,
  -1.06112491e-02f, -1.66692752e-02f, -2.85255194e-01f, -3.86550166e-02f, 2.63637416e-02f, -5.26810717e-03f, -9.06767920e-02f, -9.55715552e-02f, -6.85400004e-03f, 2.51951758e-02f,
  -5.57866693e-03f, 1.93744272e-01f, -3.40773724e-02f, -7.22605065e-02f, -2.85212025e-02f, -5.67195714e-02f, 1.72827840e-02f, -4.56783436e-02f, 2.32750773e-02f, 7.23549575e-02f,
  -4.55275085e-03f, -3.18092667e-02f, 5.79184406e-02f, -8.00541416e-03f, -3.00419684e-02f, -4.59942929e-02f, -4.79121357e-02f, 4.79705893e-02f, 1.56630352e-02f, 1.84907299e-02f,
  -9.55673009e-02f, 1.94021631e-02f, 7.73629025e-02f, -3.96145135e-02f, -1.20250218e-01f, 6.41110688e-02f, 3.82166579e-02f, 5.13413409e-03f, 9.20275301e-02f, 6.26865998e-02f,
  -1.24671333e-03f, -5.37851406e-03f, 3.86554599e-02f, -5.27085550e-02f, 4.45531681e-02f, -6.48284853e-02f, 1.28589384e-02f, -1.04572652e-02f, 3.34988274e-02f, -3.80282179e-02f,
  6.32483363e-02f, 1.97128467e-02f, 3.00681815e-02f, 5.76632619e-02f, 5.85844554e-02f, 1.04268588e-01f, 4.04814221e-02f, 1.01240501e-02f, 1.34397037e-02f, 2.82904394e-02f,
  1.00711854e-02f, -3.77409756e-02f, -4.50392738e-02f, -2.63839047e-02f, -2.33109780e-02f, 1.72694288e-02f, 5.39983660e-02f, 4.59268130e-02f, -5.20682745e-02f, 3.56550328e-02f,
  4.75979447e-02f, 3.18233073e-01f, -1.00279383e-01f, 2.46189069e-02f, -4.52580713e-02f, 5.35575487e-02f, -5.13587631e-02f, 2.49445625e-02f, 5.16669117e-02f, 1.19298726e-01f,
  1.00437924e-01f, 2.86066905e-02f, 2.74180043e-02f, -4.12600823e-02f, -2.29081837e-03f, 1.52974755e-01f, 4.81863180e-03f, -5.46161830e-02f, 7.70266131e-02f, -7.76271895e-02f,
  -9.69814323e-03f, 1.46737680e-01f, 1.49389552e-02f, 4.44551297e-02f, 2.80442145e-02f, -1.32513382e-02f, 6.59290031e-02f, -8.30047056e-02f, 3.21589857e-02f, 8.72644335e-02f,
  3.17517340e-01f, 4.05393124e-01f, 1.53955922e-01f, 1.98149338e-01f, -1.68086484e-01f, -3.02781165e-01f, -2.72742599e-01f, 9.66667086e-02f, -2.38041624e-01f, 8.22013244e-02f,
  -6.20253675e-04f, -3.66794430e-02f, 1.34924576e-01f, -2.54080407e-02f, -5.10987714e-02f, -1.25665188e-01f, -1.20491236e-02f, -1.59181565e-01f, -1.61199227e-01f, 3.39640290e-01f,
  1.04106449e-01f, 7.16010258e-02f, 1.62439764e-01f, 8.21063146e-02f, 8.56670737e-02f, 2.36956164e-01f, 3.65479261e-01f, 2.52474677e-02f, 2.89992779e-01f, -1.09133780e-01f,
  -2.06338480e-01f, 5.85020008e-03f, -4.39070947e-02f, 6.11344073e-03f, -3.40461992e-02f, 7.86317736e-02f, 5.74662630e-03f, -1.25265270e-01f, -3.20760086e-02f, 2.45458130e-02f,
  7.29536787e-02f, 7.41570443e-02f, -8.01761821e-02f, -1.10473536e-01f, 3.05845924e-02f, -3.00640780e-02f, 1.54859051e-02f, -3.05337273e-02f, 2.58738990e-03f, 4.37003225e-02f,
  5.55880144e-02f, 1.59519538e-02f, 8.34407285e-02f, -1.29665583e-01f, 2.38022916e-02f, -7.09392084e-03f, -7.34308455e-03f, 4.90689613e-02f, 7.99408779e-02f, -1.14450641e-01f,
  1.61961943e-01f, 3.90891656e-02f, 6.35059550e-02f, -8.07475895e-02f, 6.58914149e-02f, -6.72549009e-02f, -1.94729064e-02f, -5.32368086e-02f, -8.18007886e-02f, 1.39534444e-01f,
  -3.19827572e-02f, -2.33944389e-03f, -9.61294994e-02f, 4.98744175e-02f, 4.50456142e-02f, -7.21626356e-02f, 9.84277949e-02f, -4.32584360e-02f, 1.12841958e-02f, 1.38158957e-02f,
  -1.02067858e-01f, 4.76883445e-03f, -7.35673355e-04f, -6.26068935e-02f, -6.58131465e-02f, -1.92788448e-02f, 1.09077595e-01f, 1.94470435e-02f, -3.64251342e-03f, -3.25655416e-02f,
  1.04199834e-01f, 3.61695677e-01f, -4.06345800e-02f, -8.18769038e-02f, -4.53057103e-02f, -4.41996269e-02f, -1.27523050e-01f, -2.20010728e-02f, 1.56342402e-01f, -1.08066127e-01f,
  9.33396667e-02f, 3.26968096e-02f, -6.58973381e-02f, 1.02332197e-01f, -1.15299616e-02f, 5.39327078e-02f, 1.91669837e-01f, -2.79795937e-02f, 7.86352456e-02f, 1.20493196e-01f,
  1.86298698e-01f, 1.49433371e-02f, -7.96855912e-02f, -1.08157560e-01f, -1.58260167e-02f, 3.36669059e-03f, 6.81835115e-02f, 4.11147326e-02f, 6.80443794e-02f, 2.76417308e-03f,
  -7.55541682e-01f, -9.06066820e-02f, -3.02334100e-01f, -5.40548146e-01f, 1.17435463e-01f, -3.14484447e-01f, -3.77723902e-01f, -4.01068106e-03f, -6.41405657e-02f, 1.77279934e-01f,
  1.66581094e-01f, -2.92433321e-01f, 2.65370548e-01f, -4.68972713e-01f, -3.93898785e-01f, -1.99583977e-01f, -4.19748247e-01f, -2.79810131e-01f, -4.32148241e-02f, -1.62442878e-01f,
  -2.31159762e-01f, -1.75558284e-01f, -3.78348112e-01f, 1.87696218e-01f, -1.89782351e-01f, 1.01361349e-01f, 1.55133232e-01f, 2.38979071e-01f, -4.07933667e-02f, 8.16046447e-02f,
  -1.35755420e-01f, 2.82904860e-02f, -9.83013213e-03f, 5.51673323e-02f, -1.16128124e-01f, 5.74037712e-03f, -6.28575310e-02f, 3.66148241e-02f, 5.41969240e-02f, -2.02829894e-02f,
  -6.53409213e-02f, 2.71601062e-02f, -8.58747736e-02f, 1.62271813e-01f, -1.19370716e-02f, 8.40570331e-02f, -4.73674312e-02f, -3.96482535e-02f, -3.12692448e-02f, -1.05276279e-01f,
  -6.87005147e-02f, -2.40212437e-02f, -5.10098189e-02f, -3.70592847e-02f, 5.36903460e-03f, 2.50633843e-02f, -9.35118198e-02f, -7.06904614e-03f, -1.53855877e-02f, -2.15318017e-02f,
  -2.69947201e-02f, 1.00827236e-02f, -8.70466232e-03f, 5.80961481e-02f, -9.77146253e-03f, 4.73468117e-02f, -4.98993769e-02f, -8.03794339e-02f, 1.13921065e-03f, -1.59077137e-03f,
  -1.61746629e-02f, -3.07957940e-02f, -3.56418341e-02f, -5.02795056e-02f, -6.35876730e-02f, -3.99325378e-02f, -2.32102275e-02f, -3.91720720e-02f, -7.34924749e-02f, -1.86177790e-02f,
  -3.76339704e-02f, -1.53658185e-02f, 4.08170633e-02f, -5.33941984e-02f, 2.32808311e-02f, -2.46874662e-03f, 1.77938491e-02f, 1.50757516e-02f, -3.38210687e-02f, -6.95487857e-03f,
  -5.65836057e-02f, 2.53284629e-02f, 3.08487453e-02f, 3.16094756e-02f, 9.40468814e-03f, 4.76428419e-02f, -6.02275208e-02f, -4.77318577e-02f, -1.59052741e-02f, 2.67718323e-02f,
  3.05679571e-02f, -9.05692205e-02f, -1.73308644e-02f, -1.41702536e-02f, 2.40597744e-02f, 2.48706751e-02f, -4.65478897e-02f, 4.59680753e-03f, -2.02872008e-02f, 3.25657353e-02f,
  7.39261732e-02f, 8.18224847e-02f, -1.49106083e-03f, -8.13280120e-02f, -8.76551196e-02f, -3.32125686e-02f, -1.71575062e-02f, -4.05769944e-02f, -1.28619811e-02f, 6.54373784e-03f,
  -6.04034364e-01f, 1.17570423e-01f, -8.84489194e-02f, -1.69360593e-01f, -7.32631516e-03f, -1.22089654e-01f, -1.89588428e-01f, -1.59081966e-01f, -1.98534384e-01f, -2.57243812e-01f,
  -6.96389899e-02f, -1.47807136e-01f, 1.96769893e-01f, 3.00643202e-02f, 3.20714451e-02f, 1.90280944e-01f, -1.54713064e-01f, -1.42455384e-01f, 1.73260480e-01f, -1.33965760e-01f,
  -7.53930882e-02f, -2.85785850e-02f, 1.11479931e-01f, 1.58421248e-01f, -7.80784935e-02f, -1.65578332e-02f, -1.45867839e-01f, 1.67442441e-01f, -9.36182737e-02f, 4.87264954e-02f,
  -1.40320450e-01f, -1.73345417e-01f, -4.81814370e-02f, -1.03248052e-01f, -8.97846892e-02f, -6.02799505e-02f, -3.66729405e-03f, 5.43995909e-02f, -4.19244617e-02f, -6.63858093e-03f,
  -6.60105944e-02f, 1.11111691e-02f, -2.95470729e-02f, -1.42354723e-02f, -2.27529109e-02f, 3.42423655e-02f, 3.63274962e-02f, 7.11676851e-02f, 5.99577948e-02f, 9.25549716e-02f,
  1.39104486e-01f, -9.53014288e-03f, -9.87823009e-02f, -3.72589082e-02f, 6.30973000e-03f, -1.20315030e-02f, -2.61635315e-02f, -5.15986979e-02f, -8.10880363e-02f, -8.29140767e-02f,
  1.19463235e-01f, 3.67345400e-02f, -1.18578348e-04f, 5.94609827e-02f, -3.29647996e-02f, -2.26612557e-02f, -1.73390415e-02f, 6.73147365e-02f, -4.30521332e-02f, 6.43007010e-02f,
  -6.26091585e-02f, -8.22295696e-02f, -4.67771851e-02f, -5.40964417e-02f, -9.62109417e-02f, -5.10882474e-02f, -1.72870550e-02f, -8.24445765e-03f, 2.54600290e-02f, -1.26564018e-02f,
  -3.07980366e-02f, 5.01813702e-02f, 1.51565373e-02f, 7.12906346e-02f, -6.10174090e-02f, 6.17090128e-02f, 3.54423337e-02f, 3.95496637e-02f, 9.01014730e-03f, 2.01211367e-02f,
  -2.08608508e-01f, -3.72948706e-01f, -4.51091826e-02f, -4.35722470e-02f, -4.63658897e-03f, -8.13993961e-02f, 5.88235632e-03f, -2.75444500e-02f, -4.31413315e-02f, -8.75394605e-03f,
  -9.39615592e-02f, -1.88957695e-02f, -6.47468418e-02f, 8.52233693e-02f, 4.73449863e-02f, 8.92590452e-03f, -5.06280288e-02f, -9.30077434e-02f, -3.72260958e-02f, -5.18931858e-02f,
  -3.61380377e-03f, -9.90928523e-03f, 8.81752446e-02f, 1.29013984e-02f, -2.91942675e-02f, -7.42458403e-02f, -4.94159721e-02f, 8.95602349e-03f, -4.89357933e-02f, -3.38148810e-02f,
  4.22767729e-01f, -3.35630685e-01f, -9.92477387e-02f, 3.39055866e-01f, 5.66815734e-02f, -8.67883116e-02f, -2.59666979e-01f, 2.30776712e-01f, 8.76082256e-02f, -2.11135238e-01f,
  1.43194824e-01f, -1.21075422e-01f, -2.69135118e-01f, 1.53000131e-01f, 2.91178823e-01f, -5.41543737e-02f, 2.18806714e-01f, -2.94106212e-02f, 1.04954571e-01f, 3.39465141e-02f,
  2.18917847e-01f, 2.24369213e-01f, 1.94442093e-01f, 2.06456035e-01f, 6.13660365e-02f, 1.88568786e-01f, 1.22090787e-01f, -9.37151015e-02f, 8.02162439e-02f, 2.20300816e-02f,
  3.15222852e-02f, 3.79157513e-02f, -2.31513046e-02f, 6.93798438e-02f, -1.51045145e-02f, -5.12661599e-02f, -6.19816035e-02f, -1.54547468e-02f, -1.11688375e-02f, -9.94951464e-03f,
  -2.65854355e-02f, -2.58418042e-02f, 2.44496763e-02f, 3.21217217e-02f, 1.33199068e-02f, 7.48624206e-02f, -3.63045260e-02f, 5.49058616e-02f, -6.66126981e-02f, -6.02927469e-02f,
  -9.35515668e-03f, -1.58451544e-03f, 1.09475548e-03f, -7.79971406e-02f, 3.73252598e-03f, 8.79996717e-02f, -8.47722068e-02f, 1.06958877e-02f, -3.71799469e-02f, 3.81936580e-02f,
  -1.17944730e-02f, 4.95076329e-02f, -6.63566217e-03f, 8.83787572e-02f, -3.59202810e-02f, -7.02150771e-03f, 1.07438318e-01f, 9.74931405e-04f, 8.98962282e-03f, -4.23054136e-02f,
  7.82269612e-02f, 3.57415155e-02f, 1.18214153e-01f, -9.27731097e-02f, 9.54923406e-03f, 2.57528517e-02f, 9.83929168e-03f, -1.12689901e-02f, 1.23079773e-02f, 4.06238884e-02f,
  3.56788598e-02f, 3.84401195e-02f, -3.70072084e-03f, -1.01039577e-02f, 7.86987226e-03f, -9.34489742e-02f, 8.98736045e-02f, -2.10805926e-02f, 2.07230262e-02f, -3.99472862e-02f,
  -9.61790830e-02f, -8.62549096e-02f, -7.36228451e-02f, -7.04381019e-02f, -3.94156612e-02f, -2.45250203e-02f, 3.04749869e-02f, 3.91622745e-02f, 5.73212467e-02f, 1.67881362e-02f,
  -8.94918740e-02f, -4.34242114e-02f, 6.82073981e-02f, -5.12997620e-02f, -4.12072353e-02f, 2.95793195e-03f, 7.53541961e-02f, -1.99077912e-02f, -1.04479573e-03f, 2.31057480e-02f,
  -7.19865970e-03f, -9.79688615e-02f, -4.46837246e-02f, 3.53296734e-02f, -2.93166246e-02f, -1.80513076e-02f, -7.75230229e-02f, -2.98500117e-02f, 2.88184751e-02f, 2.24230643e-02f,
  2.63217241e-01f, -5.73296428e-01f, 1.92417711e-01f, 1.75687924e-01f, 2.89661556e-01f, 1.48138985e-01f, 3.80045205e-01f, -1.37977913e-01f, 2.41507962e-02f, -3.45587313e-01f,
  -4.66755368e-02f, -6.31217146e-03f, -6.31050617e-02f, -2.72450019e-02f, 3.12368155e-01f, -1.01452380e-01f, -4.82158773e-02f, -6.08947501e-02f, 2.77859513e-02f, -4.73598689e-02f,
  1.97901517e-01f, 3.27747837e-02f, 1.92785695e-01f, -5.41171655e-02f, 4.93096747e-02f, 1.03564691e-02f, 1.16286036e-02f, 1.20924816e-01f, 6.68638572e-02f, 8.83533731e-02f,
  -6.15257435e-02f, -9.72628966e-02f, -4.63741757e-02f, -8.90490264e-02f, -1.06177241e-01f, -4.96500619e-02f, 5.16987629e-02f, 7.36960992e-02f, 4.71122712e-02f, 5.37503026e-02f,
  -5.40710986e-02f, 3.35119888e-02f, 2.43362598e-03f, 4.71671484e-02f, 4.13180478e-02f, 7.49623477e-02f, 8.71883929e-02f, -5.76356389e-02f, 2.05867216e-02f, -2.21521314e-02f,
  3.05308234e-02f, -4.11423780e-02f, -3.36163752e-02f, -6.93406090e-02f, -5.22486307e-02f, -3.49001251e-02f, 7.48210028e-03f, 2.54425723e-02f, 3.33771259e-02f, -6.37474209e-02f,
  -1.44370180e-02f, -2.85784099e-02f, 7.09389746e-02f, -9.01619624e-03f, 4.12333645e-02f, 4.09075767e-02f, 3.13802324e-02f, 5.66503033e-02f, -7.33173313e-03f, 2.81555057e-02f,
  2.83377375e-02f, 1.11872694e-02f, 2.74143517e-02f, 1.02502897e-01f, -3.13229524e-02f, 1.35714170e-02f, 1.18695637e-02f, -8.09208769e-03f, 6.82836212e-03f, 2.23507099e-02f,
  1.47706931e-02f, 4.35644202e-02f, -3.87799293e-02f, 9.41676944e-02f, -3.54596041e-02f, 1.74294822e-02f, -2.36561093e-02f, -1.09635868e-04f, -8.54164828e-03f, 6.20273836e-02f,
  -2.34096140e-01f, -5.63110292e-01f, -6.71362206e-02f, 2.12160777e-02f, -1.84320398e-02f, -5.56840375e-02f, -3.89630049e-02f, -3.26024070e-02f, -5.45445457e-02f, -1.36754634e-02f,
  -1.86775438e-02f, 5.30813187e-02f, -6.88248798e-02f, 1.02003872e-01f, -4.34550308e-02f, -2.49951147e-02f, -4.49023955e-02f, -6.42557219e-02f, -5.96062616e-02f, 4.12736135e-03f,
  2.69173570e-02f, -4.38544974e-02f, 3.79582904e-02f, -6.87352382e-03f, -6.09241612e-03f, -1.92445405e-02f, -1.25785852e-02f, -8.09863582e-03f, -1.76708680e-02f, 3.31463385e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.70737997e-01f, 1.52718455e-01f, 1.88290924e-01f, 3.51947039e-01f, 2.21575633e-01f, 2.52524644e-01f, 3.59659880e-01f, 2.36001551e-01f, 2.95127761e-02f, 3.08110833e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.39610821e-01f, 1.69149086e-01f, -1.60050422e-01f, -3.93746465e-01f, -1.14306465e-01f, -3.34549516e-01f, -2.17324883e-01f, -4.15598750e-01f, -2.42497966e-01f, -1.56727523e-01f,
  2.17774346e-01f, 3.23752671e-01f, 2.42109925e-01f, -9.57380012e-02f, 4.25155200e-02f, -3.48487288e-01f, 1.04335686e-02f, 5.91672175e-02f, -2.66296528e-02f, 7.11750612e-02f,
  -4.37030524e-01f, 2.88856298e-01f, -2.83988744e-01f, 4.07687604e-01f, -2.76759595e-01f, -2.31518537e-01f, -1.42053014e-03f, -2.40865722e-01f, 2.05568001e-01f, -3.40005085e-02f,
  -1.95323750e-01f, 3.05975109e-01f, 1.27004951e-01f, 2.96640217e-01f, -2.86263406e-01f, -3.16209465e-01f, -2.97614038e-01f, 5.41364625e-02f, -3.19228500e-01f, -1.46630749e-01f,
  4.24077481e-01f, -1.56166637e-02f, 4.73074801e-02f, 2.58025020e-01f, -3.39828640e-01f, -3.81028354e-01f, 4.08792645e-01f, 6.92767203e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.74536663e-01f, -9.09268484e-02f, -2.04083502e-01f, -1.06383525e-02f, 5.62364697e-01f, 3.74499470e-01f, 5.88245332e-01f, 1.57242090e-01f, 3.52652222e-01f, -8.91610309e-02f,
  9.80686322e-02f, 1.76913708e-01f, -3.09541792e-01f, -1.89538315e-01f, -8.67073387e-02f, -3.56878042e-01f, 6.57070935e-01f, 1.00308761e-03f, -6.17700687e-04f, 5.35380065e-01f,
  7.65855551e-01f, 2.51503199e-01f, 3.52993876e-01f, 9.52773392e-01f, 1.27446964e-01f, 3.22520971e-01f, 6.03958607e-01f, 3.49590927e-01f, 7.06590712e-01f, 2.21097097e-01f,
  -1.14824228e-01f, -8.19870591e-01f, 3.88229936e-01f, 3.01866412e-01f, -2.99660265e-01f, -4.76220399e-01f, -3.78961951e-01f, -5.57133973e-01f, 5.12975156e-01f, -1.59418777e-01f,
  9.16983783e-01f, 1.99053332e-01f, -3.49925160e-02f, 8.10541689e-01f, 1.33146182e-01f, -1.60780951e-01f, 7.90552914e-01f, 6.27472401e-02f, 2.59977490e-01f, -9.63589177e-02f,
  3.77591848e-01f, -1.14828616e-01f, 3.68146926e-01f, -3.06871295e-01f, 3.34300667e-01f, 2.38580540e-01f, -2.86925405e-01f, 4.02806699e-01f, -1.78641915e-01f, 1.47669390e-01f,
  1.09771860e+00f, 7.52025187e-01f, -1.66302234e-01f, -4.42391858e-02f, -1.46760464e-01f, 1.81994632e-01f, 4.08012390e-01f, 3.96065742e-01f, 1.06430441e-01f, 6.43415675e-02f,
  1.24889098e-01f, 2.92667955e-01f, 2.43009284e-01f, 2.72480220e-01f, -3.37679952e-01f, -8.67883340e-02f, -7.97850452e-03f, 2.07990289e-01f, 1.71287060e-01f, 1.29676645e-03f,
  4.17150147e-02f, 3.12246144e-01f, 2.23402187e-01f, -2.84460008e-01f, -8.37380439e-02f, -3.65966499e-01f, 6.93589076e-02f, 4.34134901e-01f, -1.83494270e-01f, 3.43783528e-01f,
  -1.51817292e-01f, -1.11694969e-01f, 6.38673902e-01f, 5.55668771e-02f, -2.05780759e-01f, -2.81461120e-01f, 3.81878465e-01f, -2.68692702e-01f, 4.24301624e-01f, 1.82914972e-01f,
  4.33958858e-01f, 3.77004087e-01f, 8.27892005e-01f, -8.29392746e-02f, 2.77414918e-01f, 3.11088324e-01f, 1.74817309e-01f, -2.07337499e-01f, -1.75997123e-01f, 7.98990056e-02f,
  9.81832370e-02f, 1.01873279e-01f, 1.85074508e-01f, 3.09624434e-01f, -1.55623471e-02f, -3.93698931e-01f, -1.71915740e-01f, -4.53655750e-01f, 4.18437645e-02f, -2.90676337e-02f,
  -7.13848248e-02f, 6.48193732e-02f, 2.68987983e-01f, 1.67641819e-01f, 3.25542808e-01f, -2.31080681e-01f, 1.66012868e-01f, 1.29560143e-01f, 1.25593722e-01f, 3.64896655e-01f,
  1.18104786e-01f, 3.57225358e-01f, -2.10099034e-02f, 3.97851110e-01f, -4.02709842e-01f, 3.45539123e-01f, -1.21553309e-01f, 2.11733282e-01f, 1.96201339e-01f, -1.82207868e-01f,
  3.23007226e-01f, 3.40394050e-01f, -1.06232487e-01f, 6.92161858e-01f, 8.49074051e-02f, 4.27873224e-01f, 2.26258755e-01f, -5.44656634e-01f, -3.24788600e-01f, -5.31174242e-01f,
  -4.25717160e-02f, -8.39744955e-02f, -2.79759783e-02f, -5.12048006e-02f, 2.40824386e-01f, 6.79559529e-01f, 1.60558537e-01f, -1.80668309e-01f, -3.80181044e-01f, -2.07869500e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.24247986e-01f, 5.65159261e-01f, 4.15788054e-01f, 4.59566206e-01f, 3.45544875e-01f, 1.17306978e-01f, 5.50001085e-01f, 1.73445404e-01f, 2.77974784e-01f, 4.55262542e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.64409178e-01f, 2.54351735e-01f, 4.90548283e-01f, 1.23049393e-01f, 6.24779761e-01f, 2.27655366e-01f, -1.07910641e-01f, -7.08274469e-02f, -1.33950666e-01f, -1.68283388e-01f,
  -1.47137269e-01f, 3.28083515e-01f, -8.63438845e-02f, 8.94526206e-03f, 3.99238229e-01f, 2.80556768e-01f, -2.76790977e-01f, 6.16674013e-02f, -3.30922365e-01f, -1.05403900e-01f,
  -4.41337526e-01f, -4.04040933e-01f, 1.13520063e-01f, 2.24360377e-01f, -2.83971906e-01f, 2.75695235e-01f, -1.92770556e-01f, 2.92351451e-02f, 2.68423110e-01f, -6.21749386e-02f,
  -8.74184817e-02f, -3.84157985e-01f, -1.98615715e-01f, -3.30162227e-01f, -2.91891634e-01f, 5.25887430e-01f, -4.81136769e-01f, -2.10397691e-01f, -3.96995366e-01f, 8.41472819e-02f,
  2.26427913e-01f, 1.84414610e-01f, 2.85946995e-01f, 1.68932140e-01f, -5.49818099e-01f, -1.02653980e-01f, 7.27145420e-03f, -1.97025508e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.17589289e-01f, 1.81045815e-01f, -2.54005134e-01f, -3.01833451e-01f, -4.57279742e-01f, 8.33451867e-01f, 9.18588877e-01f, 5.71654141e-01f, 1.35745287e+00f, -4.52002943e-01f,
  -2.24152766e-02f, -4.98836964e-01f, 6.26446009e-01f, 2.29016930e-01f, -4.07136321e-01f, 3.31753567e-02f, 4.82281953e-01f, 6.14962459e-01f, 1.56766012e-01f, 4.34382319e-01f,
  9.15055908e-03f, 2.08137155e-01f, -2.09535673e-01f, -4.41161305e-01f, 4.74851280e-01f, 4.24814254e-01f, -3.16733330e-01f, 2.18232855e-01f, 6.42634034e-02f, 2.28146300e-01f,
  3.24725866e-01f, 3.66448641e-01f, -2.72288889e-01f, 2.43169293e-01f, -4.93928224e-01f, 1.08036011e-01f, 6.56849518e-02f, -5.24638355e-01f, 1.55680180e-01f, 3.52830499e-01f,
  -2.97322292e-02f, 8.71664822e-01f, 2.53555000e-01f, 1.91069454e-01f, 8.43719468e-02f, -1.50141999e-01f, -1.42067134e-01f, -7.12858960e-02f, -2.37738431e-01f, -2.90479243e-01f,
  -2.83987522e-01f, -1.98029667e-01f, -3.13796192e-01f, -2.33336136e-01f, 7.05327988e-02f, 1.61534026e-01f, 2.16268644e-01f, 3.06097597e-01f, -5.58301434e-02f, 2.05911174e-01f,
  4.19595122e-01f, -9.53333005e-02f, -3.00398737e-01f, -1.60728723e-01f, -3.79592657e-01f, 1.17260121e-01f, 3.20938230e-01f, -2.69909948e-01f, 1.14615247e-01f, 1.80718243e-01f,
  -1.97748363e-01f, -3.64101410e-01f, 2.43123844e-01f, -2.67484903e-01f, 4.55596358e-01f, 1.18137628e-01f, 1.79050744e-01f, 2.14659929e-01f, 1.86381832e-01f, -2.73850709e-01f,
  1.09610986e-03f, 1.79251656e-01f, -1.12220280e-01f, 2.87746996e-01f, 1.78428710e-01f, 3.50253992e-02f, -1.77376553e-01f, -1.31157547e-01f, 2.20871463e-01f, -1.00867435e-01f,
  1.70620963e-01f, -2.14601129e-01f, -5.30107729e-02f, -1.63164079e-01f, -1.12406410e-01f, 2.39272624e-01f, 1.33390754e-01f, 4.98874635e-01f, 2.81697989e-01f, 7.98189700e-01f,
  -2.93775588e-01f, 3.44362706e-02f, -7.39118978e-02f, -5.50264359e-01f, 4.93424833e-01f, 5.65396786e-01f, 6.76250011e-02f, 3.09299558e-01f, 1.60531595e-01f, 4.99142349e-01f,
  -3.20864528e-01f, 6.98660374e-01f, 2.98085697e-02f, 5.03808796e-01f, 4.16275620e-01f, -6.11457109e-01f, 1.14538455e-02f, -8.48616123e-01f, 3.93480122e-01f, 1.57646132e+00f,
  -6.85192704e-01f, 8.71968925e-01f, 3.96904498e-01f, 2.30087951e-01f, 3.64046544e-01f, -1.53393060e-01f, 4.98297215e-01f, -4.71306033e-02f, 5.74201643e-02f, 1.49348110e-01f,
  4.30175453e-01f, 8.00882339e-01f, -3.50293308e-01f, -1.84525535e-01f, 1.18008107e-01f, 5.84837496e-01f, 5.68642557e-01f, 3.08149189e-01f, -3.73376071e-01f, 4.14385051e-01f,
  -6.60569310e-01f, 4.53923523e-01f, -2.75440693e-01f, 8.83292139e-01f, -2.81437546e-01f, -2.96335936e-01f, -4.04745907e-01f, -2.21548885e-01f, 4.87927526e-01f, -8.13029557e-02f,
  -2.62555748e-01f, 4.52197045e-01f, 2.60817200e-01f, 5.64244986e-01f, 1.56773597e-01f, 5.88236511e-01f, -6.00848734e-01f, 1.27926812e-01f, 6.83668971e-01f, -1.45633131e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  4.04539645e-01f, 5.53584695e-01f, 6.10594228e-02f, -4.11951356e-02f, 2.61044711e-01f, -1.43683493e-01f, 1.41175851e-01f, 2.84246951e-01f, 1.14905447e-01f, -6.82464913e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.95049578e-01f, -9.69150305e-01f, -1.65390775e-01f, -6.13950789e-01f, -1.08352929e-01f, -1.76525056e-01f, 2.66496271e-01f, -4.48212475e-01f, 5.74419200e-01f, 3.77964228e-01f,
  4.17467244e-02f, 1.67861208e-01f, -2.17392713e-01f, 4.29441303e-01f, -4.09654856e-01f, -3.51437360e-01f, -2.97645088e-02f, 1.09681129e-01f, -7.89028928e-02f, -5.59278011e-01f,
  6.78725779e-01f, -1.36553779e-01f, 1.00927150e+00f, -5.23610771e-01f, -7.83900097e-02f, 1.89988956e-01f, -1.19851083e-01f, -1.21358179e-01f, -4.75676686e-01f, -2.77845442e-01f,
  2.03696579e-01f, -2.44093031e-01f, 1.27705142e-01f, 2.23881274e-01f, 2.28169531e-01f, -8.10598314e-01f, 4.88321446e-02f, -2.06252307e-01f, 9.16056812e-01f, -1.58385992e-01f,
  -2.77952850e-01f, 1.27392426e-01f, 4.97069389e-01f, 1.48611516e-02f, 5.59607804e-01f, -1.07158959e+00f, -6.62365258e-01f, -1.75911590e-01f, -1.22854665e-01f, -4.14906919e-01f,
  -4.10108596e-01f, -8.83184895e-02f, 6.88992977e-01f, 4.71408069e-01f, -8.04559112e-01f, 5.64297251e-02f, 4.83252019e-01f, 7.20455721e-02f, 1.95978567e-01f, 1.69245750e-01f,
  1.03016771e-01f, 1.97850764e-02f, 4.25688386e-01f, 5.55041194e-01f, 4.90675539e-01f, -1.54354006e-01f, 8.61230671e-01f, -2.92279333e-01f, 9.05401647e-01f, 3.69019330e-01f,
  -7.19157875e-01f, 2.76092559e-01f, 5.69550693e-01f, -1.02495782e-01f, -3.36302489e-01f, -1.69874296e-01f, -2.25823179e-01f, 8.01510036e-01f, -4.42242056e-01f, -2.65746355e-01f,
  4.18376327e-01f, 6.55539632e-01f, -7.83215184e-03f, 3.04243207e-01f, 8.35911870e-01f, -5.86488903e-01f, 2.27561846e-01f, -2.19192430e-01f, -3.64300460e-01f, -5.48997164e-01f,
  -4.64438617e-01f, 8.68498385e-02f, -1.72405437e-01f, 8.31785262e-01f, -1.15865096e-01f, -8.21974814e-01f, 3.72284412e-01f, 4.01474833e-01f, 2.64411569e-01f, 9.11771119e-01f,
  -1.13977218e+00f, -9.84950781e-01f, 6.82561457e-01f, 5.27170181e-01f, -3.10912728e-01f, -2.50053585e-01f, 1.43680230e-01f, 6.63836449e-02f, -2.44549111e-01f, -1.03873444e+00f,
  -4.11698997e-01f, 1.09479837e-01f, -3.43215503e-02f, -2.69612521e-01f, -6.02792799e-01f, -5.39978109e-02f, -3.02753299e-01f, 5.49799621e-01f, -5.09008527e-01f, -7.23633647e-01f,
  8.41455907e-02f, 2.15184223e-02f, -1.14238143e-01f, -1.81132346e-01f, -7.28188157e-01f, 3.81888181e-01f, 1.48621783e-01f, 8.82839799e-01f, -2.46238321e-01f, -7.92560756e-01f,
  -2.22257137e-01f, -6.03056610e-01f, -4.29593623e-01f, 7.79239416e-01f, 6.56755209e-01f, 2.26949826e-01f, -1.85615849e-02f, -1.30155608e-01f, -3.95233780e-01f, 3.39451730e-01f,
  3.43224853e-02f, -7.09256709e-01f, 5.66563249e-01f, 2.12634340e-01f, -3.26464176e-02f, 1.10152042e+00f, 1.91481397e-01f, 1.11137748e+00f, -7.22388029e-01f, -8.39970171e-01f,
  -7.91061580e-01f, -1.06052347e-01f, -2.87149042e-01f, -1.28332272e-01f, 4.38147217e-01f, -4.05539125e-02f, -2.65659451e-01f, 4.73268569e-01f, -5.38426280e-01f, 3.79299670e-01f,
  -2.68362552e-01f, 5.10036647e-01f, -1.08592406e-01f, 2.38420606e-01f, -3.54837447e-01f, 6.55272305e-01f, -4.93115842e-01f, 2.07674101e-01f, 5.08369841e-02f, -1.52679339e-01f,
  -3.21043357e-02f, 1.15601324e-01f, 6.50943995e-01f, -3.00864518e-01f, 1.01450586e+00f, 1.22589283e-02f, -1.60363428e-02f, 2.16112986e-01f, 4.71350014e-01f, 4.71865743e-01f,
  -4.09258783e-01f, 6.21070862e-02f, -2.43091404e-01f, 6.89594269e-01f, -5.61775625e-01f, -2.23351553e-01f, 4.50488478e-02f, 1.34301037e-01f, 1.06595492e+00f, -1.12018406e+00f,
  8.34199786e-01f, -4.70349789e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.62243977e-01f, -2.51569927e-01f, -2.07162544e-01f, -2.52703071e-01f, -4.12910320e-02f, 3.47466677e-01f, 8.67185712e-01f, -5.06184042e-01f, -2.74305046e-01f, 7.98946619e-01f,
  -2.73123056e-01f, -1.11891359e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    