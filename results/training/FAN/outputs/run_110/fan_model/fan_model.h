/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.76362668e-02f, -1.67100042e-01f, -2.71861762e-01f, -2.43237689e-01f, 1.37040332e-01f, 3.15785825e-01f, -1.82669789e-01f, 1.58128321e-01f, -1.33454889e-01f, 2.07427684e-02f,
  -3.92145030e-02f, -2.79419810e-01f, -4.40191999e-02f, 1.91324905e-01f, -1.79989059e-02f, -1.98340719e-03f, 1.79293469e-01f, -1.74602613e-01f, 9.81522948e-02f, -2.06028167e-02f,
  2.56001223e-02f, 2.34992236e-01f, -9.01626702e-03f, 1.92297056e-01f, 4.71116789e-02f, 4.10971679e-02f, -5.28824404e-02f, -1.49627224e-01f, 1.86540727e-02f, -1.32111520e-01f,
  2.02986076e-02f, 3.24695073e-02f, 1.62933767e-01f, -2.71714982e-02f, 1.40915751e-01f, 8.47393200e-02f, -3.90052199e-02f, 2.96080429e-02f, 9.19102039e-03f, -9.21803713e-02f,
  -7.20969215e-02f, -2.75832023e-02f, -1.16596177e-01f, 4.47365269e-02f, -4.24424335e-02f, 5.45393191e-02f, 5.37063219e-02f, 1.17254868e-01f, -4.02595662e-02f, -7.30968341e-02f,
  -8.97196755e-02f, -6.22405298e-02f, -6.59965575e-02f, -9.09484848e-02f, -2.17801593e-02f, -1.75865162e-02f, 5.91447391e-02f, -7.10984915e-02f, -2.04633288e-02f, 3.65531109e-02f,
  -7.62370182e-03f, 5.92576340e-02f, 5.94698228e-02f, 7.60765001e-02f, 8.33300501e-03f, -5.99893602e-03f, -4.18899022e-02f, 8.48438963e-02f, 2.71386579e-02f, -3.28267738e-02f,
  3.75334057e-03f, -8.07197243e-02f, 5.17716855e-02f, 2.81287413e-02f, 1.04824454e-01f, 7.07288906e-02f, -2.08841041e-02f, -1.83600616e-02f, 4.80872951e-03f, 9.55138952e-02f,
  -5.53039163e-02f, -6.83119372e-02f, -5.09916060e-02f, -7.40560815e-02f, 2.73490641e-02f, -6.68372633e-03f, 1.11032948e-01f, 4.16349098e-02f, -6.69782329e-03f, -9.95107666e-02f,
  -4.06060144e-02f, -1.31974727e-01f, 2.71858089e-02f, -2.71692239e-02f, -2.96103712e-02f, 9.30519775e-02f, 1.17705449e-01f, 6.48281872e-02f, -3.62746939e-02f, 8.83920193e-02f,
  9.07865316e-02f, 1.43424030e-02f, -7.90253133e-02f, 1.61260448e-03f, -5.80053637e-03f, 1.49246790e-02f, -7.13864490e-02f, -3.58443968e-02f, -9.04607698e-02f, -3.53699476e-02f,
  -6.98670894e-02f, -6.79801852e-02f, -8.91198143e-02f, 2.75745913e-02f, -1.87563635e-02f, -1.62594333e-01f, 3.47723626e-02f, -4.18662727e-02f, -9.39702243e-02f, -1.96513738e-02f,
  2.43551791e-01f, 1.97421461e-01f, -3.99318039e-02f, 1.93467289e-01f, 1.39504224e-01f, -1.44010976e-01f, -1.30573958e-02f, 1.74100757e-01f, 1.30336687e-01f, -8.45343620e-03f,
  -3.42629403e-02f, 9.05881152e-02f, -1.99054062e-01f, 1.02799628e-02f, 1.33934438e-01f, -3.16534251e-01f, 1.52782246e-01f, 5.28167225e-02f, -1.73201591e-01f, 1.80724517e-01f,
  3.00353188e-02f, 6.72295317e-02f, 2.03124091e-01f, 3.63015234e-02f, 1.37505695e-01f, 3.18646245e-02f, 3.47133726e-02f, -9.06739235e-02f, -7.99699035e-03f, -1.32793421e-02f,
  1.46195486e-01f, 1.50999203e-01f, -2.20008902e-02f, -5.55810072e-02f, 3.65400761e-02f, -6.18966110e-02f, -6.73391595e-02f, -1.88708693e-01f, -6.21199459e-02f, -9.05405283e-02f,
  -1.90401673e-01f, -3.60443629e-02f, -1.09870188e-01f, -1.32158339e-01f, 1.89797506e-02f, -5.59239462e-02f, -8.67914185e-02f, -5.31204939e-02f, -1.86636597e-02f, -2.55643968e-02f,
  9.10988823e-02f, -9.76844355e-02f, 2.15077959e-02f, 3.81398364e-03f, -7.35273510e-02f, 1.56207131e-02f, -8.68160799e-02f, -4.26082425e-02f, -2.15174723e-02f, 1.74919851e-02f,
  -5.75518943e-02f, 5.10163717e-02f, -3.16894352e-02f, -1.76690593e-02f, -5.68867363e-02f, -1.67631712e-02f, -2.40049586e-02f, -5.75565323e-02f, 2.35316008e-02f, 5.59511362e-03f,
  8.91321748e-02f, 1.08054735e-01f, -3.22375610e-03f, -4.70249839e-02f, -6.06946796e-02f, 8.32012966e-02f, -1.83385462e-02f, 8.49307701e-02f, -1.17580229e-02f, -3.14188264e-02f,
  1.71431415e-02f, 3.08431499e-02f, 8.29349160e-02f, 3.49980257e-02f, -1.78417005e-03f, -2.56823245e-02f, -1.11086935e-01f, 4.39933082e-03f, 3.58355716e-02f, -4.22383137e-02f,
  1.17503934e-01f, 2.42114544e-01f, 7.24379718e-03f, 5.29376455e-02f, -2.19424739e-02f, -1.91178676e-02f, -3.64462249e-02f, -1.30442142e-01f, -5.75865991e-02f, -2.52451561e-02f,
  -7.68903084e-03f, 1.76977348e-02f, 9.06241983e-02f, -8.42566788e-03f, 3.42571475e-02f, -6.95084780e-02f, 7.60193616e-02f, 1.11523420e-02f, 1.08859196e-01f, 4.67659608e-02f,
  2.99477503e-02f, 2.78325565e-02f, -2.72583812e-02f, 7.05719292e-02f, 4.96102720e-02f, 2.66500153e-02f, 5.85872419e-02f, 2.17284285e-03f, -8.20531473e-02f, -6.70503527e-02f,
  1.57231897e-01f, -6.04842566e-02f, 8.01455323e-03f, -5.09795062e-02f, 1.87890381e-01f, 4.92568724e-02f, -3.30909379e-02f, 5.67375235e-02f, -5.97841926e-02f, 3.77937444e-02f,
  1.66504979e-01f, -1.14465982e-01f, -1.23106450e-01f, 8.20495263e-02f, -1.62479833e-01f, -1.82443962e-01f, 7.47029530e-03f, 3.13452706e-02f, -9.48473513e-02f, 1.31141603e-01f,
  5.91552071e-02f, 9.50690061e-02f, -9.19479579e-02f, 7.77084008e-02f, 2.25960419e-01f, -9.69870854e-03f, 8.29524621e-02f, 9.38420892e-02f, 1.37782335e-01f, -9.78829991e-03f,
  -5.10245562e-02f, -4.18696702e-02f, 5.71054369e-02f, -3.01664453e-02f, 1.20446667e-01f, 4.82603796e-02f, 2.39447225e-02f, -6.57517463e-02f, 3.78402993e-02f, 1.00458995e-01f,
  7.64301699e-03f, 2.90203784e-02f, 4.45949612e-03f, -2.23389789e-02f, -3.28174606e-03f, 4.37693894e-02f, -4.21776017e-03f, 8.70654061e-02f, -4.64790780e-03f, -3.66355688e-03f,
  1.66868251e-02f, 4.77275662e-02f, 4.04299125e-02f, -4.41604443e-02f, -3.52015421e-02f, 1.42055014e-02f, -5.78934923e-02f, -4.09783944e-02f, 3.76614630e-02f, 8.66546407e-02f,
  2.64030714e-02f, 6.31604940e-02f, 7.71472752e-02f, 2.45653838e-02f, -2.88254023e-02f, 7.75014162e-02f, 3.42167020e-02f, 3.97193357e-02f, -1.14407562e-01f, 6.49621412e-02f,
  1.29669588e-02f, 6.19228706e-02f, -2.31109858e-02f, 5.15838712e-02f, 4.94095571e-02f, 4.74552214e-02f, 8.34940970e-02f, -9.57626402e-02f, 8.65636989e-02f, 3.89718153e-02f,
  9.50960219e-02f, 5.18991835e-02f, 7.37752169e-02f, 2.43598083e-03f, 7.47215971e-02f, 7.53041208e-02f, -2.19082758e-02f, 6.13466874e-02f, -3.53755504e-02f, 2.95395926e-02f,
  -1.43976733e-01f, -1.79572821e-01f, -2.77965870e-02f, -4.35635261e-02f, 1.07254777e-02f, 4.26046290e-02f, -1.11423824e-02f, 6.34159148e-02f, -9.51546952e-02f, 3.49199548e-02f,
  -1.84991546e-02f, 1.19633593e-01f, 5.31708524e-02f, 3.49783786e-02f, -6.48072362e-02f, 6.74985768e-03f, 3.82066593e-02f, 1.78009958e-03f, 1.46877253e-02f, 4.89772484e-02f,
  2.73797959e-02f, 1.02599636e-01f, -1.20152123e-02f, 1.15230158e-01f, -1.37853939e-02f, -1.83303133e-02f, 2.68487986e-02f, 2.68083364e-02f, -3.75729911e-02f, 6.09594882e-02f,
  2.71998376e-01f, -1.12738395e-02f, 3.66976410e-01f, 5.87846823e-02f, -8.64937678e-02f, -2.26883307e-01f, -1.59655377e-01f, 5.63136488e-02f, 1.67766199e-01f, -7.95534700e-02f,
  -1.10991776e-01f, -3.63080064e-03f, -1.15948759e-01f, -2.83718079e-01f, 3.22693586e-02f, -8.21854919e-02f, -7.62465447e-02f, -9.58999433e-03f, 7.58022666e-02f, 4.20092866e-02f,
  6.31939992e-02f, -3.20111364e-01f, 8.27488005e-02f, -1.36214614e-01f, -1.91272851e-02f, 9.24637020e-02f, -1.25793666e-01f, 5.25612431e-03f, -1.69854477e-01f, -1.08792439e-01f,
  1.21268757e-01f, 2.91100413e-01f, 4.55814227e-03f, 8.89016166e-02f, 6.58898577e-02f, -2.27854662e-02f, 1.21024521e-02f, -3.03784711e-03f, 4.70419452e-02f, -8.30534175e-02f,
  -2.57517826e-02f, -8.99930671e-02f, -1.22990191e-01f, -5.56105897e-02f, -3.27391662e-02f, 6.34798110e-02f, -3.39099765e-03f, -1.04086455e-02f, 8.07213131e-03f, 7.52436668e-02f,
  2.65430771e-02f, -7.02868775e-02f, -6.04710868e-03f, -2.21529715e-02f, 6.36324286e-02f, 1.47737481e-03f, 8.32439363e-02f, -5.16899750e-02f, -1.13225222e-01f, 1.04785107e-01f,
  -5.15426733e-02f, 2.09741332e-02f, -2.78931689e-02f, -5.91855915e-03f, 1.61033459e-02f, -6.36224896e-02f, 2.77991612e-02f, -1.85658559e-02f, 1.35302484e-01f, -3.03109847e-02f,
  -3.54511216e-02f, 1.10535719e-01f, 2.78660320e-02f, -4.79343534e-02f, 8.17192197e-02f, 3.31408121e-02f, 9.07856375e-02f, -3.22443806e-02f, -4.26317379e-03f, -1.75190363e-02f,
  -1.55128269e-02f, 1.56706311e-02f, 2.33187526e-02f, -4.23129648e-02f, -6.82907999e-02f, -2.12642481e-03f, -6.47806451e-02f, 4.75037284e-02f, 3.05449832e-02f, 8.31606686e-02f,
  3.87609638e-02f, 7.66190812e-02f, 3.56227811e-03f, -1.25057371e-02f, 2.85940636e-02f, -2.72341203e-02f, 6.13119937e-02f, -5.06660994e-03f, 5.30424528e-02f, 1.52196093e-02f,
  4.49164659e-02f, -6.02559447e-02f, -9.32660103e-02f, -1.77372545e-02f, -7.02460408e-02f, -1.07884541e-01f, -4.23036292e-02f, -4.37995093e-03f, -9.77468938e-02f, -1.99716655e-03f,
  -6.75967261e-02f, -3.57137732e-02f, 6.18477128e-02f, 1.87487472e-02f, 2.28112824e-02f, -1.01186952e-03f, 1.56956650e-02f, 7.82956555e-03f, -1.43029215e-02f, -1.37179857e-02f,
  3.72161955e-01f, -2.18264237e-01f, -2.64364313e-02f, 3.29016775e-01f, 7.00917467e-02f, 1.25013173e-01f, 2.79068053e-01f, -3.52074392e-02f, 1.90744042e-01f, -5.51377460e-02f,
  1.44250944e-01f, 2.04007588e-02f, 5.88310026e-02f, 3.98338549e-02f, 6.98124394e-02f, -5.86517435e-03f, 4.27031070e-02f, 1.12408750e-01f, 1.28924111e-02f, -2.96298116e-02f,
  2.27193013e-01f, -8.32995623e-02f, -3.14694196e-02f, -4.42754254e-02f, 1.35002196e-01f, 1.36298081e-02f, -3.61731579e-03f, 1.09396931e-02f, -3.52547737e-03f, 4.36016880e-02f,
  -2.20816396e-02f, -1.38455853e-01f, -3.28664742e-02f, -1.71906561e-01f, -7.17185736e-02f, 1.65554658e-02f, 5.38095869e-02f, 3.61151737e-03f, -6.66601881e-02f, -9.17027984e-03f,
  6.10524565e-02f, 8.76266044e-03f, -4.96393023e-03f, 1.86893661e-02f, 1.45833999e-01f, -2.40167975e-02f, -1.20498734e-02f, 1.20081164e-01f, 4.49568518e-02f, 3.84523347e-02f,
  6.09066486e-02f, 7.59409219e-02f, 5.10153659e-02f, -2.01140977e-02f, 3.70027497e-02f, 6.51626736e-02f, 3.64265107e-02f, 1.55674545e-02f, 4.63412032e-02f, -2.26711854e-02f,
  2.33035870e-02f, 5.79997897e-02f, 1.11971363e-01f, 1.93139892e-02f, -1.30157694e-01f, 4.37641591e-02f, -2.82797329e-02f, -6.34662956e-02f, -5.86578287e-02f, -2.45155822e-02f,
  -3.33294123e-02f, 3.92777957e-02f, -3.16071324e-02f, 9.84392222e-03f, 1.13275098e-02f, 1.79708637e-02f, 3.41744386e-02f, -6.89751804e-02f, 8.68534967e-02f, 5.26238494e-02f,
  1.24612264e-02f, -1.50644425e-02f, -3.00994497e-02f, 8.08897763e-02f, 1.05621800e-01f, 1.34021528e-02f, 2.65181717e-02f, -6.43578693e-02f, 2.50680987e-02f, 3.75696048e-02f,
  -2.30703861e-01f, -3.79188478e-01f, -1.04097597e-01f, -1.13517202e-01f, -9.34766755e-02f, 7.13449728e-04f, -4.01490703e-02f, -1.83967259e-02f, -1.82002887e-01f, -4.97074798e-02f,
  2.10606065e-02f, 1.32775931e-02f, 4.73808907e-02f, 5.78983799e-02f, -7.84864370e-03f, 3.25207296e-03f, 1.27500325e-01f, -1.65362507e-02f, -4.43051290e-03f, -2.70411465e-02f,
  1.97698399e-02f, 6.91186637e-02f, -3.74670140e-02f, 8.98197740e-02f, -1.28931990e-02f, 4.85101249e-03f, -5.46541847e-02f, 1.00006372e-01f, 1.95205361e-02f, -6.20111153e-02f,
  -1.06683641e-03f, 2.01961324e-01f, -1.99504822e-01f, 6.77434877e-02f, -1.24799497e-01f, -2.12996289e-01f, -9.69249755e-02f, 7.06904903e-02f, 8.10854807e-02f, 1.30063385e-01f,
  4.62737717e-02f, -7.06838518e-02f, 5.76739870e-02f, 7.40389600e-02f, -3.56698662e-01f, -4.70172018e-02f, 4.68552019e-03f, 1.56199485e-01f, -4.20485735e-02f, -2.14101728e-02f,
  -1.20194368e-01f, 3.83401811e-02f, -1.07750259e-01f, 5.24301501e-03f, -7.44855311e-03f, 1.05609298e-01f, 5.43281063e-02f, -1.65647238e-01f, 1.08415544e-01f, -1.14729054e-01f,
  8.71629491e-02f, 1.14883929e-01f, -9.26352385e-03f, 1.42807579e-02f, -2.16100652e-05f, -6.96026236e-02f, -3.10159065e-02f, -1.37556881e-01f, -5.26780672e-02f, -7.27551430e-02f,
  -6.21719211e-02f, -6.79188222e-02f, 2.40321215e-02f, 8.08584411e-03f, 3.50626446e-02f, -4.68971059e-02f, -4.89298590e-02f, 4.36233729e-02f, 3.54137225e-03f, -1.17931431e-02f,
  -3.97232622e-02f, -4.42820080e-02f, -9.04171728e-03f, 4.69099358e-02f, -5.20360135e-02f, -7.76932761e-02f, -1.37391612e-01f, -5.61217777e-02f, 5.00342213e-02f, -2.99242442e-03f,
  -7.24540055e-02f, -3.14326808e-02f, -1.22755645e-02f, 5.18895723e-02f, 2.09572315e-02f, -2.57521588e-02f, -6.50916481e-03f, -7.37056974e-03f, 6.05718270e-02f, -2.10345015e-02f,
  2.65208501e-02f, 7.70842135e-02f, -3.47428732e-02f, -1.29991561e-01f, -2.81432867e-02f, 1.64337344e-02f, -3.77414897e-02f, 5.63028082e-02f, 6.08455986e-02f, 6.72408044e-02f,
  -1.38062984e-01f, -7.65608698e-02f, 1.48192704e-01f, 3.84551212e-02f, -6.23386689e-02f, -1.22849941e-01f, -7.91996196e-02f, -2.35803109e-02f, -6.98575079e-02f, -4.49149534e-02f,
  2.18214035e-01f, 9.83426869e-02f, -1.97011582e-03f, 2.94186007e-02f, 3.39759625e-02f, 1.05124256e-02f, -1.17371060e-01f, -1.36699639e-02f, 2.22201068e-02f, -3.57490107e-02f,
  1.36111826e-02f, 5.72843403e-02f, -5.81098385e-02f, 7.16648698e-02f, -8.49856343e-03f, -5.17374091e-02f, -6.11084923e-02f, 6.05000369e-03f, 1.42562799e-02f, 2.47532893e-02f,
  -1.08408257e-02f, -7.26654977e-02f, -4.73283231e-02f, 3.24872765e-03f, 2.50312705e-02f, -3.97736318e-02f, 3.63747813e-02f, -8.56717750e-02f, -6.59255534e-02f, -6.67604059e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.54878759e-01f, -4.03982759e-01f, 8.69181529e-02f, 2.71932423e-01f, 2.99441159e-01f, 3.83418947e-02f, 1.23623580e-01f, 8.22642595e-02f, 2.55255878e-01f, -4.47752863e-01f,
  1.74936745e-02f, -2.20562696e-01f, -1.56198755e-01f, -1.04873858e-01f, 3.26693624e-01f, -8.11330006e-02f, -1.10790413e-02f, -2.01823071e-01f, 1.70402974e-01f, 8.74608010e-02f,
  8.92527327e-02f, -6.85264245e-02f, 1.19394861e-01f, -1.06598884e-01f, -1.36722540e-02f, -9.16211903e-02f, -1.78653345e-01f, -8.22219178e-02f, -1.63600951e-01f, -2.57379301e-02f,
  1.07673891e-01f, 4.27018851e-02f, 1.55059367e-01f, -2.97479369e-02f, 1.13248145e-02f, 3.59824970e-02f, -9.73295197e-02f, -6.28364533e-02f, 2.01283082e-01f, -1.34242371e-01f,
  -4.80183102e-02f, -1.28365040e-01f, -6.73210844e-02f, 1.59222819e-02f, 1.05150878e-01f, 4.28675301e-02f, 4.68997248e-02f, 4.04874049e-02f, -4.72178832e-02f, -2.69816108e-02f,
  5.83766960e-02f, -9.02162343e-02f, 9.75046232e-02f, -1.77464798e-01f, -4.96173874e-02f, 1.17430232e-01f, -8.15811381e-02f, -1.48173138e-01f, -9.56522003e-02f, -3.08181401e-02f,
  -1.58431470e-01f, -1.19694434e-02f, -6.42525405e-03f, 4.16342169e-02f, 9.21914354e-02f, 2.47968268e-02f, 7.73212463e-02f, -1.22605518e-01f, 3.56728141e-03f, 3.03763598e-02f,
  2.69247331e-02f, 9.98274386e-02f, 7.85929784e-02f, 3.89140472e-02f, -4.40777428e-02f, 7.58734494e-02f, 2.76327617e-02f, -1.50130123e-01f, -9.12194140e-03f, 1.35074884e-01f,
  3.62517722e-02f, 4.83360924e-02f, 6.13936596e-02f, -1.65443365e-02f, 5.61986640e-02f, 8.03087205e-02f, -1.50262907e-01f, -7.55141815e-03f, 4.81179692e-02f, -6.59835413e-02f,
  -2.16244962e-02f, -4.86277580e-01f, 1.14370557e-02f, -3.18049528e-02f, -7.77238682e-02f, 2.61218306e-02f, -5.44912778e-02f, -7.00844526e-02f, -1.29645437e-01f, 4.57086191e-02f,
  -9.80557948e-02f, -1.01142488e-01f, -2.53206417e-02f, 6.93348348e-02f, 8.11644420e-02f, -4.37860973e-02f, -7.16688111e-02f, -4.68097813e-02f, -6.21224530e-02f, -9.83689725e-02f,
  -1.28946960e-01f, -6.99868202e-02f, -4.25141566e-02f, 7.37160668e-02f, -7.57778287e-02f, -1.10285133e-01f, -2.85020545e-02f, -8.19701180e-02f, -1.42656639e-01f, -4.22808267e-02f,
  -6.99773580e-02f, -1.30879521e-01f, -2.15455443e-01f, -2.00104877e-01f, 1.39505416e-01f, 1.06892221e-01f, -8.05378780e-02f, 5.54264747e-02f, -1.81457326e-01f, 3.17552656e-01f,
  1.07459664e-01f, -2.39541128e-01f, 1.70103628e-02f, -1.90107137e-01f, -4.21964854e-01f, -2.67094910e-01f, -1.54957458e-01f, -2.72169523e-02f, -2.04713330e-01f, -1.85708441e-02f,
  -1.35857865e-01f, 1.34612799e-01f, -2.71625936e-01f, 2.24230945e-01f, 1.88085929e-01f, 4.60551493e-02f, 2.73765653e-01f, 2.28606075e-01f, 5.47161847e-02f, 4.15573567e-02f,
  -9.26207155e-02f, -9.76500958e-02f, -1.00601606e-01f, -3.92202847e-02f, 8.15830529e-02f, 1.02482572e-01f, 1.62943795e-01f, -2.98627396e-03f, -8.22842121e-02f, -6.91955015e-02f,
  6.68543950e-02f, -3.53774838e-02f, 2.26106700e-02f, -2.77228989e-02f, 6.95106909e-02f, 4.86733066e-03f, -7.99234062e-02f, -9.89255235e-02f, -4.43502069e-02f, -5.16400188e-02f,
  -6.83687851e-02f, -5.64511083e-02f, 1.46880567e-01f, -5.51728308e-02f, 2.61773970e-02f, -3.87872048e-02f, 6.17668740e-02f, 6.06936514e-02f, 6.85163811e-02f, -5.82592599e-02f,
  4.95880805e-02f, 5.42842373e-02f, -1.85551979e-02f, -1.42089903e-01f, -7.16740116e-02f, 1.30813150e-03f, -1.75734311e-02f, 1.92759559e-02f, -8.07994008e-02f, -5.16741769e-03f,
  2.79647447e-02f, -1.02806322e-01f, 6.53044228e-03f, 7.15275183e-02f, 4.15453725e-02f, -2.46710982e-02f, 2.96860542e-02f, 2.38562226e-02f, -7.90685490e-02f, -4.83740345e-02f,
  6.49064779e-02f, 6.79117665e-02f, -4.26570140e-02f, 6.35458753e-02f, 7.40483180e-02f, 4.76838946e-02f, 6.60681203e-02f, -1.39221922e-01f, -5.06779850e-02f, 1.08119443e-01f,
  -3.44890803e-02f, 1.29879460e-01f, -6.14939593e-02f, -5.23923486e-02f, -1.08009148e-02f, 4.67176214e-02f, -5.72920479e-02f, -3.04056481e-02f, -1.16497995e-02f, -2.92543545e-02f,
  8.22912529e-02f, 4.03146967e-02f, 1.60381943e-01f, -1.41440153e-01f, -4.07764316e-02f, 3.20133939e-02f, 2.09357310e-02f, 9.13430005e-02f, 4.90533486e-02f, 7.21691772e-02f,
  1.37889072e-01f, 1.06421903e-01f, 4.90632840e-02f, 1.11173414e-01f, 7.57908970e-02f, 1.59453809e-01f, 2.05135699e-02f, 4.81501669e-02f, 8.47571716e-02f, -6.34977501e-03f,
  4.54353303e-01f, 3.89978111e-01f, 1.86499432e-01f, 3.36890131e-01f, -1.40600622e-01f, -1.03007331e-01f, 2.63433665e-01f, 9.82151031e-02f, 3.56144875e-01f, 1.20562859e-01f,
  -1.24659777e-01f, 4.35319453e-01f, -1.95262462e-01f, 1.58949181e-01f, -2.27582216e-01f, -1.87445626e-01f, 8.56356546e-02f, 1.77823216e-01f, 1.29258707e-01f, 1.19618289e-01f,
  1.20479148e-02f, -1.43982366e-01f, -2.31156535e-02f, -3.14015262e-02f, 1.70768514e-01f, 1.61821529e-01f, -1.39338732e-01f, 6.22776486e-02f, 6.68354705e-02f, -2.34043617e-02f,
  -2.12419312e-02f, -2.74880370e-03f, 1.13036431e-01f, -2.51061544e-02f, 6.63180184e-03f, 1.48565462e-02f, -6.75469711e-02f, -7.80599117e-02f, -1.44777656e-01f, 5.76531924e-02f,
  2.90854722e-02f, 6.43711761e-02f, 4.54464704e-02f, -3.45116202e-03f, 1.86715990e-01f, 3.74925546e-02f, 3.84795777e-02f, 9.55366194e-02f, 1.95149541e-01f, 5.36196306e-02f,
  2.62288958e-01f, 4.07217443e-02f, 3.84379961e-02f, 4.35719127e-03f, 6.40740097e-02f, 1.68320201e-02f, 8.19953084e-02f, 4.47192155e-02f, 8.53696838e-02f, 1.51940584e-01f,
  -7.91468695e-02f, 3.16416845e-02f, 1.24904383e-02f, 9.39151943e-02f, -1.18722869e-02f, -2.67223902e-02f, 5.09974882e-02f, -9.36590880e-02f, 6.70126602e-02f, -8.38921126e-03f,
  -7.75547000e-03f, 1.12159653e-02f, 1.77968472e-01f, 4.69708852e-02f, -5.16337827e-02f, 3.04509550e-02f, 1.59393772e-02f, -1.41989112e-01f, 3.10775880e-02f, -7.96272233e-03f,
  -2.92814523e-02f, 7.30793178e-02f, 1.18517270e-02f, -3.23959403e-02f, 1.00272752e-01f, -3.72670365e-05f, 1.11061953e-01f, 8.54532495e-02f, 3.33920494e-02f, -8.53010789e-02f,
  -2.11412773e-01f, -2.05364138e-01f, 2.24842522e-02f, -7.10411509e-03f, -7.81282410e-02f, 1.51028130e-02f, 5.49254287e-03f, -4.15634960e-02f, -1.44601837e-01f, 6.00141985e-03f,
  2.19160272e-03f, 7.57770315e-02f, 6.85217383e-05f, -5.36918528e-02f, -1.71807557e-02f, -2.54401043e-02f, -4.04436281e-03f, 3.72343957e-02f, -9.07272622e-02f, 3.27086337e-02f,
  9.48877260e-02f, 1.14617974e-03f, -2.85751149e-02f, 4.17770632e-02f, 1.46127967e-02f, -3.55203412e-02f, -3.13159153e-02f, 1.17307797e-01f, -1.44603297e-01f, -7.48238787e-02f,
  2.21552104e-01f, -1.49874076e-01f, -2.20636204e-01f, 2.82643199e-01f, 9.82793719e-02f, 3.14446181e-01f, 2.35526308e-01f, 9.50368196e-02f, 2.88513958e-01f, -1.92908861e-03f,
  1.28784910e-01f, -1.03922442e-01f, -4.73861396e-02f, 4.09642547e-01f, 1.12803787e-01f, 3.57730426e-02f, 3.83953959e-01f, 1.84513330e-01f, 2.60931700e-02f, 1.79699942e-01f,
  1.24661565e-01f, 3.03691149e-01f, -2.81449944e-01f, -6.39595240e-02f, 6.19663484e-02f, -3.10290128e-01f, -2.25028425e-01f, -3.27000260e-01f, -1.67684570e-01f, -1.06337450e-01f,
  1.76397301e-02f, 4.95223552e-02f, -1.44887626e-01f, -4.64458838e-02f, 8.32019970e-02f, -8.54418501e-02f, 2.02088011e-03f, -1.11877806e-01f, -5.82732074e-02f, 7.89616555e-02f,
  1.52668208e-02f, -8.08564648e-02f, 5.85425608e-02f, -9.11334455e-02f, 1.71563819e-01f, -1.37978550e-02f, 1.64800920e-02f, -1.42777130e-01f, -1.47087470e-01f, -1.66468713e-02f,
  -4.52626906e-02f, 3.17517556e-02f, 1.68835372e-01f, -8.62160325e-02f, 4.04235162e-03f, -1.81331728e-02f, -8.61522183e-02f, -2.39891876e-02f, 2.52671000e-02f, 3.07164993e-02f,
  -1.88518986e-02f, 1.03756778e-01f, -1.10077411e-02f, 2.04168316e-02f, 1.23598285e-01f, -3.62104736e-02f, 5.13115339e-02f, -1.21971564e-02f, -3.02603206e-04f, 9.26163197e-02f,
  -1.97775196e-02f, -6.30028322e-02f, 1.43295610e-02f, 5.66944480e-02f, 7.17428178e-02f, -4.38506044e-02f, -9.95632857e-02f, 5.10127954e-02f, -2.12267581e-02f, -9.00983587e-02f,
  -1.36171728e-01f, -3.79857211e-03f, -1.38714746e-01f, -1.56427428e-01f, 5.24177067e-02f, -8.38175640e-02f, 1.44511878e-01f, 9.25238878e-02f, 6.77184388e-02f, -1.12092175e-01f,
  8.17482099e-02f, 6.92312494e-02f, 1.04767345e-02f, -6.06923997e-02f, -3.85313574e-03f, 5.87396249e-02f, -5.89074101e-03f, 5.55766262e-02f, -9.21483114e-02f, 1.01192936e-01f,
  -4.21067998e-02f, 4.22582030e-02f, 2.20348388e-02f, -1.22777447e-01f, 1.01505846e-01f, 1.06735133e-01f, 4.07539196e-02f, -1.47103565e-02f, -5.26653305e-02f, 4.06602258e-03f,
  8.05221498e-02f, -6.10789098e-03f, 9.23686996e-02f, 8.51343796e-02f, 1.57279968e-01f, -1.06198668e-01f, -8.98457393e-02f, -7.44013255e-03f, -2.03565054e-04f, 3.06395274e-02f,
  1.76836595e-01f, 1.42102435e-01f, -1.99195713e-01f, -2.43819192e-01f, 3.65808904e-02f, 3.85805011e-01f, 1.40367106e-01f, 1.08838409e-01f, -2.00241297e-01f, 2.18506008e-01f,
  1.98693603e-01f, -1.83338866e-01f, 1.62465349e-01f, 2.39642829e-01f, 1.26812667e-01f, 2.32017055e-01f, 2.33356729e-01f, 1.43915005e-02f, 1.15870357e-01f, 5.89983091e-02f,
  8.48403107e-03f, 2.88519412e-01f, -9.04092751e-03f, 2.10474387e-01f, 1.62319049e-01f, -1.15638755e-01f, -7.37394616e-02f, -1.84843972e-01f, -7.95229599e-02f, 4.85225357e-02f,
  6.73963651e-02f, 6.06636815e-02f, 5.69520555e-02f, 4.01099510e-02f, 1.37072697e-01f, 7.63761401e-02f, -4.67582010e-02f, 5.88556267e-02f, -1.57628015e-01f, 3.89063917e-02f,
  -2.07783878e-02f, 8.77269451e-03f, 1.78872664e-02f, -2.17837859e-02f, 1.72495972e-02f, -3.64490747e-02f, 1.04190171e-01f, -1.03381621e-02f, -1.98917696e-04f, 1.13401160e-01f,
  -1.33410897e-02f, -7.51245841e-02f, -1.90968961e-02f, -1.12244762e-01f, -7.78355002e-02f, 7.91769754e-03f, 1.73098836e-02f, -9.16155949e-02f, 6.30316958e-02f, -9.64280963e-02f,
  4.27275002e-02f, 1.13645330e-01f, 1.86397806e-01f, 6.72013536e-02f, 9.74788293e-02f, 6.19759299e-02f, 1.06211275e-01f, 1.01106517e-01f, -1.16254248e-01f, 6.56891912e-02f,
  -3.70390378e-02f, 8.62293877e-04f, 1.60047710e-01f, 1.15768120e-01f, 3.74336503e-02f, 6.96915090e-02f, 2.19682995e-02f, -3.33799273e-02f, -1.00350708e-01f, 9.05098021e-02f,
  4.87049036e-02f, 9.30582266e-03f, -2.55813710e-02f, -5.99654652e-02f, 2.30543405e-01f, 1.56566445e-02f, 1.30880773e-01f, 8.44349861e-02f, 5.74391112e-02f, -2.19531022e-02f,
  -1.26566701e-02f, -8.74814112e-03f, 5.49278036e-02f, -1.19275056e-01f, -4.33739126e-02f, 1.62459984e-01f, 1.16946340e-01f, 9.84163284e-02f, -8.46714601e-02f, 4.08530012e-02f,
  1.78658199e-02f, -8.45190212e-02f, 7.04994574e-02f, -5.59640974e-02f, -1.35302857e-01f, 1.89209476e-01f, 8.75670165e-02f, -5.81673253e-03f, -1.59129441e-01f, 9.55948234e-03f,
  1.25395162e-02f, 1.01877406e-01f, -6.92628622e-02f, -4.38465364e-02f, -7.92225972e-02f, -6.92371726e-02f, 1.85013451e-02f, 2.56211776e-02f, 2.93692835e-02f, -1.34224430e-01f,
  -1.29892856e-01f, -1.95948392e-01f, 2.21229494e-01f, 7.47649819e-02f, -1.64864641e-02f, -2.05035090e-01f, -9.87015292e-02f, -8.93906876e-02f, -2.19267040e-01f, -3.27903718e-01f,
  -6.42054528e-02f, 1.38912544e-01f, -2.03806162e-01f, 2.36443609e-01f, 4.23357576e-01f, -5.72131760e-02f, 1.50158510e-01f, 1.12302817e-01f, 9.66984080e-04f, 8.98028761e-02f,
  2.60101050e-01f, 1.62045017e-01f, 3.72059911e-01f, 1.58491626e-01f, 1.89828247e-01f, 1.08026542e-01f, 3.76219153e-01f, 2.90008754e-01f, 3.02959323e-01f, 9.95964333e-02f,
  -1.53384835e-01f, -5.90700209e-02f, 1.66145377e-02f, -7.13216364e-02f, -7.26660565e-02f, -4.37610336e-02f, 2.00024024e-02f, 1.55600220e-01f, -6.60569817e-02f, 1.18101195e-01f,
  -2.19740961e-02f, 2.36638322e-01f, 1.30558521e-01f, 6.13788553e-02f, -1.11525066e-01f, 3.36437151e-02f, -3.16261239e-02f, -2.16972679e-01f, 3.43763158e-02f, -1.10797258e-02f,
  -5.50972857e-03f, 4.17657867e-02f, -3.72231118e-02f, 8.21184460e-03f, 1.46430925e-01f, -1.50550246e-01f, -1.46271673e-03f, 2.09876642e-01f, 3.00710350e-02f, -4.31884527e-02f,
  -2.72833109e-02f, 3.36974971e-02f, 8.69437829e-02f, 4.50544991e-02f, 6.74144551e-02f, 1.20514967e-01f, 4.22291160e-02f, -1.34383747e-02f, 3.29366997e-02f, -1.74706094e-02f,
  -1.22724846e-01f, -4.89598475e-02f, 2.84691714e-02f, -1.29218698e-02f, 6.78943051e-03f, -1.06413394e-01f, 5.90812527e-02f, -1.80730652e-02f, -1.30263641e-01f, 5.64033771e-03f,
  -3.16367373e-02f, 6.39512297e-03f, -2.51818020e-02f, 8.55247751e-02f, -3.59825306e-02f, 4.24080938e-02f, 1.00738578e-01f, 1.24309380e-02f, 5.40643074e-02f, 1.33629441e-01f,
  -1.36059761e-01f, 8.77143741e-02f, 3.46692950e-02f, -1.22506075e-01f, 8.31837803e-02f, 3.59582379e-02f, 1.00826643e-01f, 2.67666951e-02f, 1.10690454e-02f, 2.78589241e-02f,
  -6.65524229e-03f, 1.45325199e-01f, -1.33682922e-01f, -1.05148420e-01f, 7.47225434e-02f, 1.49577120e-02f, 1.79874841e-02f, -8.61083344e-02f, 7.21089542e-03f, 2.95963716e-02f,
  -2.55984757e-02f, 3.29813026e-02f, 1.41284779e-01f, 1.66544229e-01f, -3.30249667e-02f, -5.82194291e-02f, 4.68035974e-03f, -6.67672530e-02f, 1.27960697e-01f, 9.60679650e-02f,
  3.38716209e-02f, -1.85554057e-01f, -1.02058232e-01f, -5.83370216e-03f, -1.64809093e-01f, 7.90822431e-02f, 2.44034939e-02f, -2.12547421e-01f, -1.18328162e-01f, -1.19207231e-02f,
  -1.27826646e-01f, 6.57379478e-02f, -1.10666558e-01f, 1.00751154e-01f, 2.88751841e-01f, 5.86467572e-02f, 1.87386706e-01f, 1.84818327e-01f, -5.10484390e-02f, -1.45964980e-01f,
  8.09030309e-02f, 2.58484006e-01f, -1.36385202e-01f, 2.99366447e-03f, -7.35312849e-02f, -5.17711304e-02f, 3.88147570e-02f, -1.81691930e-01f, 1.87820598e-01f, 1.47596955e-01f,
  -1.72593091e-02f, -9.08476934e-02f, -8.20712075e-02f, 1.28640264e-01f, -4.76251915e-03f, -6.55506626e-02f, -7.14414753e-03f, 1.75957799e-01f, -4.91394438e-02f, -1.52939130e-02f,
  8.52495655e-02f, 1.08699568e-01f, 1.56697854e-01f, -6.31839857e-02f, -1.89187117e-02f, -3.32281343e-03f, -2.29581930e-02f, -1.80616602e-02f, -8.79629627e-02f, -9.53978375e-02f,
  -1.03669629e-01f, 3.80066074e-02f, 2.55052978e-03f, 9.73900780e-02f, -2.47082370e-03f, 3.71816345e-02f, 1.75614953e-02f, -8.42418745e-02f, 1.61481336e-01f, 1.77646019e-02f,
  7.23805502e-02f, 9.50068422e-03f, 5.66218123e-02f, -9.97847095e-02f, 1.07842304e-01f, 1.15498118e-02f, -9.92081761e-02f, -6.77695032e-03f, -2.30084565e-02f, -7.08994195e-02f,
  -3.47403809e-02f, -1.94241822e-01f, -1.10846035e-01f, -2.87373886e-02f, -1.18102981e-02f, 1.08423280e-02f, -3.60573158e-02f, 7.25260517e-03f, -8.33907127e-02f, -5.59865758e-02f,
  2.08984334e-02f, 7.85942897e-02f, 1.44285643e-02f, 4.73261438e-03f, -3.36311907e-02f, -5.41951396e-02f, 3.44159640e-02f, -6.39585033e-02f, -8.63792151e-02f, -6.32607490e-02f,
  3.07391142e-03f, 7.76414499e-02f, -1.34397706e-03f, 1.08735390e-01f, 4.07974944e-02f, -7.95635879e-02f, 2.44939309e-02f, 7.73106962e-02f, 1.29129231e-01f, -3.88104171e-02f,
  3.71500030e-02f, 5.68081625e-02f, 2.42950246e-02f, -1.33046165e-01f, 1.21937972e-02f, -5.65060675e-02f, 9.76504982e-02f, 5.90129755e-02f, 6.03585541e-02f, -9.05096382e-02f,
  -5.35247885e-02f, -8.98291823e-03f, 4.92145270e-02f, -4.00350662e-03f, 1.11152440e-01f, 4.03565839e-02f, -2.50918996e-02f, -3.69405001e-02f, 6.58675283e-02f, 9.68693644e-02f,
  2.24785909e-01f, -2.21841678e-01f, 2.63139736e-02f, 6.73009753e-02f, 1.38586164e-01f, -1.45655721e-01f, -7.96886310e-02f, 3.43097448e-02f, -1.71095744e-01f, -2.40904644e-01f,
  1.01266049e-01f, 8.54693949e-02f, -2.21214116e-01f, 1.99916393e-01f, 2.51989871e-01f, -7.95164481e-02f, 1.24294102e-01f, 1.80174321e-01f, 1.78453792e-02f, 8.59467909e-02f,
  1.14650220e-01f, 1.15421109e-01f, 1.21383339e-01f, 2.77992785e-02f, 2.00120956e-01f, 2.16341540e-02f, 8.44722837e-02f, 8.72357860e-02f, 1.53713375e-01f, 1.31872326e-01f,
  -1.55705884e-01f, -3.59178917e-03f, -6.85877576e-02f, -1.14014916e-01f, -1.43824339e-01f, -1.03790574e-02f, -9.28579494e-02f, 1.49305403e-01f, -9.75175481e-03f, 2.03741230e-02f,
  -2.33663078e-02f, 1.35684043e-01f, 8.55029225e-02f, 1.98220257e-02f, -1.84844416e-02f, -1.90053340e-02f, 4.25325967e-02f, -4.28652465e-02f, -1.06894132e-02f, 1.31133243e-01f,
  2.88495868e-02f, 1.04146898e-01f, -2.84245238e-03f, 2.84719188e-02f, 1.54864520e-01f, 2.83533484e-02f, 5.41608036e-02f, 5.97168542e-02f, 1.48422373e-02f, -9.67568308e-02f,
  4.36071754e-02f, -2.43893582e-02f, 7.56164268e-02f, 6.81475848e-02f, 4.28503845e-03f, 1.33044690e-01f, 1.03775196e-01f, 1.00624911e-01f, 2.55941618e-02f, -1.28394468e-02f,
  -7.90541768e-02f, -8.22924078e-03f, 3.12951952e-03f, -3.00836358e-02f, 1.34854356e-03f, 8.89803171e-02f, 4.37060837e-03f, 2.21428499e-02f, -1.87619492e-01f, 2.00352259e-02f,
  2.46932590e-03f, -3.25291157e-02f, -2.92437095e-02f, 1.86563149e-01f, 2.25978624e-02f, 4.92030717e-02f, -5.74294142e-02f, -1.79523751e-02f, -8.63364786e-02f, -6.24186499e-03f,
  -3.04648191e-01f, -2.28433430e-01f, -4.94804047e-02f, -2.28411481e-02f, -9.83424634e-02f, -3.79937561e-03f, -9.15314332e-02f, 8.81119370e-02f, -6.93638548e-02f, -9.30766575e-03f,
  -6.92244917e-02f, 1.06604196e-01f, -7.63109773e-02f, -4.79963645e-02f, 1.15807622e-03f, -4.10453863e-02f, 2.88164876e-02f, -7.86342919e-02f, -4.58978452e-02f, 1.16038606e-01f,
  -9.69911460e-03f, 1.15452774e-01f, 7.91425258e-02f, 1.06192753e-01f, 8.22769329e-02f, 3.19171473e-02f, 9.70626026e-02f, -1.14952601e-01f, 1.35041162e-01f, -1.19878892e-02f,
  -1.08410485e-01f, 1.44271487e-02f, -1.28634959e-01f, -1.88920185e-01f, 2.63059177e-02f, -2.56633848e-01f, -1.70472354e-01f, 7.84264207e-02f, 8.66135806e-02f, 1.73416033e-01f,
  -2.72006094e-02f, 8.23840201e-02f, 2.09238678e-01f, -2.44220838e-01f, -2.55000710e-01f, 8.38383511e-02f, -3.26612830e-01f, -5.33924475e-02f, 7.31464550e-02f, -2.10394636e-01f,
  -2.11941838e-01f, -2.02414587e-01f, -8.30995813e-02f, -9.79282856e-02f, -2.13199750e-01f, 6.48066103e-02f, -9.82470140e-02f, -7.79735520e-02f, -1.99757501e-01f, 4.27555963e-02f,
  -5.14115542e-02f, 1.59157112e-01f, 2.60155890e-02f, 4.15619761e-02f, -1.24929309e-01f, -7.66482949e-02f, -1.43392354e-01f, -3.72777805e-02f, 7.45624378e-02f, 2.29734927e-03f,
  -1.05912043e-02f, 4.22058813e-02f, 2.70032771e-02f, -6.03056103e-02f, -6.31363615e-02f, -3.68620940e-02f, 7.79561400e-02f, 3.26315165e-02f, 5.52154407e-02f, -2.68712156e-02f,
  -3.39543782e-02f, 5.87532334e-02f, -6.10360689e-02f, 1.08498693e-01f, 9.56698041e-03f, 5.40325828e-02f, -3.73085849e-02f, -3.32800150e-02f, 5.75618297e-02f, -3.35067958e-02f,
  -1.36431575e-01f, -6.63817823e-02f, -6.82834983e-02f, -2.51221918e-02f, -4.63746898e-02f, -5.43318279e-02f, -5.42746000e-02f, 1.38592264e-02f, -2.04556752e-02f, 8.89435131e-03f,
  1.55146420e-01f, 9.52826962e-02f, 9.77810752e-03f, -7.08691850e-02f, -1.54899508e-01f, 5.73563874e-02f, 3.24914195e-02f, 5.18950224e-02f, -7.85219967e-02f, -1.77321713e-02f,
  1.83064580e-01f, 3.96302193e-02f, 1.35890588e-01f, -4.76192385e-02f, -3.45736407e-02f, -5.24261501e-03f, -3.43098231e-02f, -6.23655170e-02f, 2.96342224e-02f, -7.48513266e-02f,
  -3.86885554e-03f, -2.09175181e-02f, 9.85718444e-02f, 1.15715563e-01f, -1.51584214e-02f, -1.15361782e-02f, -5.85641526e-02f, -1.53869420e-01f, -1.18243799e-01f, -5.91437705e-02f,
  -9.00004953e-02f, -5.03878072e-02f, -1.44219715e-02f, 4.70297365e-03f, -3.14148329e-02f, -1.11496918e-01f, 1.98426750e-02f, 7.19812959e-02f, -3.49888057e-02f, 1.17770035e-03f,
  2.39821095e-02f, 6.08090758e-02f, 5.85530438e-02f, 5.87494336e-02f, 7.08224066e-03f, 8.11913013e-02f, 1.39347250e-02f, -2.33681239e-02f, -3.87766808e-02f, 2.29013283e-02f,
  2.14313850e-01f, 2.73128301e-01f, 2.53732443e-01f, 2.04043210e-01f, -1.62593246e-01f, -1.66498676e-01f, -1.01417050e-01f, -6.02568053e-02f, 1.75102964e-01f, 9.77369919e-02f,
  -2.20565632e-01f, 4.08129066e-01f, -1.13767967e-01f, -7.06462115e-02f, -1.12720951e-01f, -1.98961064e-01f, 1.08264171e-01f, 1.09305970e-01f, 6.38439730e-02f, 1.13841169e-01f,
  1.03841082e-03f, -1.28787145e-01f, -8.73803794e-02f, 2.52312869e-02f, 4.18039709e-02f, 1.37659311e-01f, -1.03556208e-01f, -1.99358627e-01f, 5.45630082e-02f, -5.65963946e-02f,
  -1.61102861e-01f, 1.30378246e-01f, 5.59601709e-02f, -3.70433331e-02f, 5.05999178e-02f, -5.05611412e-02f, -2.72506773e-02f, -1.70311302e-01f, -6.73577609e-03f, -4.86967303e-02f,
  1.66046485e-01f, -6.13691751e-03f, -4.14449722e-02f, -1.78467501e-02f, -1.44299502e-02f, -2.65872627e-02f, 3.31836082e-02f, 1.05297707e-01f, -1.56348031e-02f, -5.39160743e-02f,
  8.35068151e-02f, 4.58314046e-02f, -2.27720495e-02f, -6.20778687e-02f, 3.25512737e-02f, -5.72645292e-03f, 6.72959760e-02f, -9.50676650e-02f, 3.46949920e-02f, 1.27953067e-01f,
  1.21585190e-01f, -9.25284177e-02f, -1.25701606e-01f, -1.11407034e-01f, -6.92434385e-02f, -1.35964751e-02f, 5.70695177e-02f, -7.87659883e-02f, 1.60740808e-01f, -3.29221636e-02f,
  -8.65360200e-02f, -4.25759144e-03f, -1.09577633e-01f, -3.67169008e-02f, 9.67477337e-02f, 6.42656460e-02f, -4.24634330e-02f, 1.31634474e-01f, 1.21216051e-01f, 1.88108794e-02f,
  3.57106738e-02f, -9.91643593e-02f, -4.41085063e-02f, -1.30956724e-01f, -1.44291580e-01f, -2.95104869e-02f, 2.31426284e-02f, 2.92071756e-02f, -5.89466132e-02f, -3.48827913e-02f,
  1.01507761e-01f, 2.14976758e-01f, 3.67973484e-02f, -5.67639582e-02f, 4.40741107e-02f, -8.56187269e-02f, -7.91159943e-02f, -3.48638073e-02f, 1.26521021e-01f, -1.98384412e-02f,
  6.25381172e-02f, 1.35927964e-02f, 3.00795976e-02f, -6.82572946e-02f, 2.19375771e-02f, -9.87443328e-03f, 2.50570830e-02f, 7.15462267e-02f, 9.67678577e-02f, -5.53834289e-02f,
  -1.04490640e-02f, -7.06674671e-03f, 3.23229693e-02f, 2.10576039e-02f, 3.49700041e-02f, 2.72977129e-02f, 8.21407139e-02f, -4.57534976e-02f, -2.71477029e-02f, -1.77324489e-02f,
  2.85374612e-01f, -2.48452947e-01f, -2.57754117e-01f, 9.42986086e-02f, 6.18950948e-02f, 1.03962593e-01f, -1.32962257e-01f, -5.70885427e-02f, -8.01685452e-02f, -3.82697023e-02f,
  9.10541117e-02f, -3.00749075e-02f, -2.02025428e-01f, 3.19404542e-01f, 2.81700432e-01f, -2.42156371e-01f, 3.13651264e-01f, 1.23568639e-01f, -1.75735816e-01f, 1.13413863e-01f,
  1.14479572e-01f, 3.36845547e-01f, -6.75351843e-02f, 1.28264025e-01f, 1.48766980e-01f, -1.18319556e-01f, 1.01316966e-01f, -1.22308940e-01f, 2.02916935e-01f, 2.63322473e-01f,
  -2.48290207e-02f, -1.80873405e-02f, 1.40617527e-02f, 2.19843257e-02f, 9.26819630e-03f, 1.85580514e-02f, -3.23142376e-05f, 4.86836880e-02f, -6.71480447e-02f, -4.41064239e-02f,
  -3.58995534e-02f, 1.08982518e-01f, 7.88460299e-02f, 1.15865164e-01f, 1.24830060e-01f, 2.33450276e-03f, -6.26952201e-02f, -1.39905632e-01f, -6.64670914e-02f, 6.18731743e-03f,
  -1.54572800e-01f, -6.31835237e-02f, 7.17634484e-02f, 5.37695689e-03f, -1.11295328e-01f, -4.01449911e-02f, 1.12736260e-03f, -7.50376880e-02f, -5.25046512e-03f, 3.39872651e-02f,
  5.95622770e-02f, -1.21199163e-02f, 8.55244398e-02f, -1.21841980e-02f, -1.43295294e-02f, 4.09918390e-02f, 3.02514527e-02f, 1.17611233e-02f, -6.76929653e-02f, 4.21616845e-02f,
  -8.19415003e-02f, 1.53539488e-02f, 3.09480634e-02f, -1.23982858e-02f, 1.07261889e-01f, -9.00311582e-03f, 2.55449186e-03f, 3.08010764e-02f, -2.63472255e-02f, -5.41043803e-02f,
  -1.60644797e-03f, 4.53596227e-02f, -1.10167012e-01f, -1.00056035e-02f, -8.44102539e-03f, -3.50699713e-03f, 1.57163247e-01f, 6.88473955e-02f, -4.81632017e-02f, 6.07855096e-02f,
  6.83547184e-02f, -1.07810974e-01f, -2.88902987e-02f, 1.07008591e-02f, -5.35706393e-02f, 6.13034107e-02f, 5.80760911e-02f, 8.32391307e-02f, -4.83986177e-02f, -7.21017793e-02f,
  5.34188598e-02f, -4.98763248e-02f, 4.13167290e-02f, 3.74273546e-02f, 1.03785731e-01f, -3.79862487e-02f, -3.06580998e-02f, -8.03990737e-02f, -2.73278281e-02f, 3.20550874e-02f,
  -5.02198637e-02f, -1.35967702e-01f, 6.88912719e-02f, -1.12550318e-01f, -4.91567776e-02f, -4.92835008e-02f, -2.18643039e-03f, 6.86476007e-02f, 2.63985526e-02f, -4.99117896e-02f,
  -1.70847386e-01f, -5.26747815e-02f, -5.36829606e-02f, -1.26673713e-01f, -4.62129116e-01f, 9.25282612e-02f, 1.14719041e-01f, 2.16171239e-02f, 1.20344251e-01f, 2.93343067e-01f,
  -1.15465932e-01f, 3.26811969e-02f, 3.41248959e-01f, -1.81625560e-01f, 2.71011472e-01f, 2.41826788e-01f, 1.15587674e-02f, 1.37354270e-01f, -1.22705854e-01f, -6.82723224e-02f,
  -6.12173602e-02f, -1.41787842e-01f, 3.13310954e-03f, -5.54379374e-02f, -1.77198708e-01f, -2.46006966e-01f, -1.43814921e-01f, -1.53617680e-01f, -3.40257019e-01f, -1.79701403e-01f,
  -1.22451209e-01f, -8.04693475e-02f, -1.83387607e-01f, -1.87027100e-02f, -6.14662655e-02f, 2.06268802e-02f, -1.26559865e-02f, -5.35319336e-02f, -9.14233699e-02f, -3.17225838e-03f,
  2.98896655e-02f, -1.71110798e-02f, 1.44915434e-03f, 7.60074556e-02f, 9.88907292e-02f, -9.58339795e-02f, -8.11439455e-02f, -1.21227458e-01f, -3.36572044e-02f, -9.66939330e-02f,
  6.16440028e-02f, -8.42092857e-02f, -9.26907063e-02f, 4.85304557e-02f, -2.37278417e-01f, -3.45032290e-02f, 1.19903246e-02f, -2.04680748e-02f, -1.54759958e-01f, -1.03447363e-01f,
  -3.98116224e-02f, 4.88688760e-02f, 8.46183971e-02f, 4.31823768e-02f, -8.11972991e-02f, -8.57856125e-02f, -3.41635384e-02f, -6.97285384e-02f, -8.52716044e-02f, -5.53479344e-02f,
  -7.12726116e-02f, -4.33446132e-02f, 8.61871690e-02f, 2.85332054e-02f, 6.33956417e-02f, 2.12997779e-01f, 3.26982923e-02f, -1.05785504e-01f, -2.11663228e-02f, 4.80955280e-02f,
  1.21089116e-01f, 5.75984120e-02f, -1.71142787e-01f, -1.79355636e-01f, 4.85963821e-02f, -1.04853921e-02f, 4.14547734e-02f, 2.45684125e-02f, 1.11600026e-01f, -1.54559370e-02f,
  -1.41943783e-01f, 1.89796109e-02f, -1.03671402e-01f, -1.82165229e-03f, 9.32157859e-02f, -2.06964742e-02f, 9.71290097e-02f, -5.30722328e-02f, -4.99057695e-02f, 1.26231775e-01f,
  1.08045213e-01f, 1.07223988e-02f, -6.37960583e-02f, -1.80646610e-02f, 8.99958760e-02f, -5.93190594e-03f, 8.98862928e-02f, -2.19566468e-02f, -2.95608658e-02f, -1.08098030e-01f,
  -4.45371158e-02f, -1.35542937e-02f, -1.22368895e-02f, -1.32873148e-01f, -1.09075479e-01f, -1.71476826e-02f, 2.27188747e-02f, 5.56509979e-02f, -1.28173426e-01f, 9.17507187e-02f,
  3.44694890e-02f, -7.45213330e-02f, 3.11884522e-01f, 1.32653089e-02f, 1.79403022e-01f, 3.18965256e-01f, 2.93983132e-01f, -5.32536060e-02f, -8.54903134e-04f, -3.28623325e-01f,
  -1.57369450e-01f, 8.70287791e-02f, 2.68561617e-02f, -1.24035344e-01f, 3.47726554e-01f, 1.09161779e-01f, 1.06704146e-01f, 1.29343301e-01f, 1.17726572e-01f, -2.33747368e-03f,
  -7.35307410e-02f, -2.22769633e-01f, 2.81654410e-02f, -2.26819232e-01f, -5.14652394e-02f, -7.52711296e-02f, -2.26851746e-01f, 1.55972928e-01f, -9.28685069e-02f, 1.11130834e-01f,
  -1.10517144e-02f, -9.32491496e-02f, 9.59848017e-02f, 1.61478147e-02f, -4.26514857e-02f, -1.11790247e-01f, 8.27267915e-02f, 7.01408908e-02f, 1.23338364e-01f, -1.70942396e-01f,
  -3.55988257e-02f, -7.74422735e-02f, -1.02045029e-01f, 1.02838064e-02f, -4.68095532e-03f, -7.51419961e-02f, 8.61404911e-02f, 5.42464964e-02f, -2.27364413e-02f, -2.23447680e-02f,
  -5.19286143e-03f, 2.94099338e-02f, -3.46461311e-03f, -1.34690702e-01f, 9.43183228e-02f, 3.05878762e-02f, 6.61042705e-02f, 6.29453585e-02f, -1.45443901e-03f, -8.77006352e-02f,
  -1.02488078e-01f, 1.09044738e-01f, -1.06667802e-01f, -1.24312177e-01f, 4.84802667e-03f, -6.45940751e-02f, -4.09836359e-02f, -9.25225168e-02f, 5.04305512e-02f, 4.13257293e-02f,
  4.07327525e-02f, 7.89227411e-02f, 8.76715481e-02f, -1.13094179e-02f, -1.84797525e-01f, -1.99641466e-01f, 5.00354096e-02f, 9.33590382e-02f, -9.05533955e-02f, 7.70904347e-02f,
  -2.62615215e-02f, 8.69760737e-02f, 1.18509673e-01f, -1.29958764e-01f, -5.70467338e-02f, -2.63433866e-02f, -1.83895484e-01f, -6.99113384e-02f, -2.17432603e-02f, 8.38233083e-02f,
  6.55492395e-02f, -5.10093123e-02f, 7.18794093e-02f, 3.41761746e-02f, 6.07351027e-02f, -6.15853369e-02f, 8.42589885e-02f, -1.11252740e-02f, -1.18313609e-02f, -7.72527680e-02f,
  -1.35972485e-01f, -4.91301296e-03f, -6.77201375e-02f, -5.88199943e-02f, -4.23411764e-02f, -6.98309904e-03f, 7.89377838e-02f, 2.47859419e-03f, 9.14196000e-02f, 2.37088278e-02f,
  7.07360730e-02f, -3.65528725e-02f, 1.16606778e-03f, -8.16020966e-02f, -7.83049092e-02f, -2.80571524e-02f, -1.98965743e-02f, -1.96160283e-02f, -1.09053859e-02f, -2.43451204e-02f,
  2.89688587e-01f, 1.11021265e-01f, 1.04150884e-02f, 1.97043121e-01f, -1.71248913e-01f, -2.11490169e-01f, -2.12805066e-02f, -4.40127775e-02f, 1.29211828e-01f, -1.74783662e-01f,
  -5.37710525e-02f, 1.09733418e-02f, 1.66412205e-01f, -1.46544904e-01f, 2.98855573e-01f, 5.11353500e-02f, 1.80872545e-01f, -1.00414604e-01f, 2.84871031e-02f, 1.35689184e-01f,
  1.74270734e-01f, 1.52517147e-02f, 1.39368564e-01f, -1.03890903e-01f, -6.82836920e-02f, 5.16738258e-02f, 2.60157846e-02f, -8.02763849e-02f, -1.92324504e-01f, 3.64426896e-02f,
  -8.75184089e-02f, 9.93695483e-02f, -1.28216883e-02f, 3.56478281e-02f, 1.24382921e-01f, 1.06084989e-02f, -1.92323461e-01f, 3.63348313e-02f, 2.45913845e-02f, 6.44573942e-02f,
  1.02143496e-01f, 8.77170637e-02f, 4.69737649e-02f, -4.25309204e-02f, -3.98379192e-02f, -5.14546707e-02f, -1.90796219e-02f, 4.56357524e-02f, -4.60985066e-05f, 4.24654186e-02f,
  5.64313978e-02f, -2.41981000e-02f, 8.31556544e-02f, 2.29136888e-02f, 1.22574590e-01f, 9.09826681e-02f, -4.09852825e-02f, 1.21358018e-02f, -3.59127484e-02f, 8.04798380e-02f,
  9.80098620e-02f, -2.69598383e-02f, -8.10549185e-02f, -1.24411084e-01f, 2.93781012e-02f, 3.96644231e-03f, 4.76037115e-02f, 1.71908159e-02f, 8.67318586e-02f, -3.33574489e-02f,
  -8.77517462e-02f, 5.02206851e-03f, -7.13561922e-02f, -5.03851883e-02f, 4.74763364e-02f, 1.34560943e-01f, 4.02291119e-02f, -2.12968111e-01f, 3.13398242e-02f, -2.71635465e-02f,
  6.58935159e-02f, 1.72541179e-02f, 3.14735509e-02f, 6.95984438e-02f, -1.02000929e-01f, 4.99881059e-02f, 8.98138732e-02f, -3.74543779e-02f, -6.98628500e-02f, 1.28394663e-01f,
  6.72402009e-02f, 2.67546147e-01f, 6.77301139e-02f, -7.00296909e-02f, 7.77208507e-02f, 8.46031494e-03f, -3.81830968e-02f, -1.11680301e-02f, 2.38066792e-01f, 1.99343234e-01f,
  1.69638377e-02f, 3.35496068e-02f, -1.85093936e-02f, -2.85913516e-02f, -5.93122356e-02f, 5.41002005e-02f, 6.29407093e-02f, 1.32224662e-02f, 1.91108495e-01f, 5.62457740e-02f,
  4.73984852e-02f, 4.99964692e-02f, 1.61378741e-01f, -2.24774834e-02f, -2.52660234e-02f, 6.34703711e-02f, -5.49054705e-02f, -1.65219083e-01f, 8.11105072e-02f, 1.28479570e-01f,
  -3.81899029e-01f, 2.19248131e-01f, -1.00717321e-01f, 7.05009326e-02f, 7.29407519e-02f, -4.15848166e-01f, -1.06065594e-01f, 1.59142762e-01f, 1.32912934e-01f, 2.31624290e-01f,
  3.15418899e-01f, 3.91153097e-02f, 2.30040804e-01f, 2.89595872e-01f, -3.05981219e-01f, 9.16837156e-02f, -1.88263670e-01f, -6.53916746e-02f, -9.50226095e-03f, -3.26258466e-02f,
  -9.60214734e-02f, 2.48805150e-01f, -7.13404119e-02f, 1.81610346e-01f, 9.98523366e-03f, -1.51516881e-03f, 2.02194661e-01f, 2.31655091e-01f, -5.20167165e-02f, -1.18330255e-01f,
  -3.26880217e-02f, 2.75862902e-01f, -2.04298347e-02f, -6.65241852e-02f, -1.37297750e-01f, -1.42569751e-01f, -1.51680455e-01f, 5.55773592e-03f, 3.26463096e-02f, 3.61852050e-02f,
  -5.92402257e-02f, 4.75798175e-02f, 3.31132971e-02f, 9.53476280e-02f, 6.54758886e-02f, 7.04304427e-02f, -1.12667345e-01f, -1.43478483e-01f, -6.33298419e-03f, 2.20876206e-02f,
  5.92439948e-03f, -1.08125899e-02f, -1.42552689e-01f, 1.85670592e-02f, -1.15403151e-02f, -9.43259336e-03f, -6.97689354e-02f, 2.50832960e-02f, 7.11974055e-02f, 3.16263270e-03f,
  -3.36095430e-02f, -3.05670612e-02f, -1.84416492e-02f, 1.12575807e-01f, 1.60200730e-01f, 5.37254177e-02f, -3.19393277e-02f, -3.72027396e-03f, -9.19259638e-02f, 6.79685473e-02f,
  -1.36837168e-02f, -3.24568897e-02f, 1.41548336e-01f, -6.08673058e-02f, -3.15149762e-02f, -1.19961761e-02f, -1.50219858e-01f, -4.37296666e-02f, -6.88871592e-02f, -1.53191730e-01f,
  1.14670381e-01f, -1.84742492e-02f, -4.26227972e-02f, -2.68061776e-02f, 3.02401767e-03f, 4.27048840e-02f, 8.19995776e-02f, -2.14234199e-02f, -4.37113605e-02f, -9.07909870e-02f,
  -6.75102025e-02f, 2.16304213e-01f, 4.33190018e-02f, -1.61784589e-02f, 3.14867347e-02f, -1.60983086e-01f, -1.29286256e-02f, -9.89222154e-02f, -5.15457988e-02f, 5.72493579e-03f,
  -4.90173548e-02f, -5.72978985e-03f, -7.32511654e-02f, 2.80815773e-02f, 1.81906540e-02f, 2.89469622e-02f, 3.66010107e-02f, -8.56718794e-02f, -1.32197216e-02f, -1.12610310e-01f,
  6.94031045e-02f, 8.15368667e-02f, -1.29356027e-01f, -9.90789849e-03f, -4.36986797e-02f, -3.49704437e-02f, 4.56743874e-02f, -6.55847415e-02f, 3.14212516e-02f, 5.33408336e-02f,
  -2.37640277e-01f, 1.37919918e-01f, 1.69193938e-01f, -1.42828807e-01f, -1.98270157e-02f, -5.41376434e-02f, -5.94740845e-02f, 2.11497739e-01f, 2.00570419e-01f, 2.61687696e-01f,
  3.56098115e-02f, 4.02748436e-02f, 4.62770276e-02f, -3.52996327e-02f, -2.06335649e-01f, -1.66254133e-01f, -2.55001843e-01f, -4.49558385e-02f, -1.19147331e-01f, -9.92779583e-02f,
  -1.95643172e-01f, -2.64907897e-01f, -7.20371902e-02f, -1.18568458e-01f, 5.07179997e-04f, 1.66374221e-01f, -1.06964171e-01f, 2.46085525e-02f, -1.69702375e-03f, 3.22324708e-02f,
  7.86657631e-02f, 1.75811738e-01f, 1.53737709e-01f, 1.37720004e-01f, 5.41109480e-02f, -5.98791279e-02f, -1.62330344e-02f, -3.66608538e-02f, 8.04910157e-03f, 8.57604742e-02f,
  -3.47327441e-02f, 1.88190136e-02f, -1.56611893e-02f, -4.61312383e-02f, 1.88183840e-02f, 3.59947830e-02f, 1.07364133e-01f, -1.27624618e-04f, 1.93585426e-01f, 4.11003046e-02f,
  4.72863764e-02f, 1.13249421e-01f, 7.05591366e-02f, 1.62065253e-01f, 3.93762998e-02f, 9.68839601e-02f, -2.28285696e-02f, -2.69634612e-02f, 4.09140512e-02f, 3.12763304e-02f,
  -1.16444588e-01f, 4.11524624e-02f, 2.71148887e-03f, 2.65073385e-02f, -4.26818244e-03f, -2.25899182e-02f, -1.31647522e-03f, -3.29140574e-02f, -3.16169672e-02f, -6.34129765e-03f,
  9.24267024e-02f, 1.24934696e-01f, -1.74022336e-02f, -9.53290239e-02f, -1.40325129e-01f, 4.50272784e-02f, -3.43795270e-02f, 9.64048877e-02f, -1.51710957e-01f, -4.86371927e-02f,
  1.02459580e-01f, -2.32945457e-02f, 9.31930616e-02f, -1.12409621e-01f, -7.36127049e-02f, 1.84313580e-02f, -6.68647215e-02f, 6.20666659e-03f, 3.38078402e-02f, -1.06891192e-01f,
  6.57934276e-03f, 1.29235342e-01f, 1.04653090e-01f, 1.69457346e-01f, 8.93613100e-02f, -7.01921731e-02f, -9.77562889e-02f, -6.75368169e-03f, -5.82404919e-02f, -6.56080991e-02f,
  -8.60037208e-02f, 6.75403001e-03f, -1.46955639e-01f, -6.71838177e-03f, -9.58243459e-02f, -2.93469485e-02f, 6.53285533e-02f, 4.03794013e-02f, 8.04713592e-02f, 3.89803462e-02f,
  -5.17912917e-02f, -2.83050220e-02f, 7.97365010e-02f, -2.57095229e-02f, 1.99789065e-03f, 3.98787409e-02f, -7.32028931e-02f, 2.87809204e-02f, 1.28543898e-02f, -1.60218365e-02f,
  -2.48997182e-01f, -3.17267746e-01f, -1.76060826e-01f, -1.64772168e-01f, 1.36306465e-01f, 3.12163442e-01f, 3.68140012e-01f, -2.38051414e-01f, -4.39141423e-01f, -1.55211007e-02f,
  2.04918936e-01f, 2.43680850e-02f, 2.47507751e-01f, 1.45361319e-01f, 3.31626475e-01f, 2.26730444e-02f, -4.39018123e-02f, 1.07245877e-01f, -1.24942929e-01f, -1.04880996e-01f,
  -1.44262671e-01f, 1.29927471e-01f, 2.54549652e-01f, -1.11672118e-01f, 9.10999551e-02f, -2.10978806e-01f, 1.73177272e-01f, 1.96766689e-01f, 1.89761594e-01f, 2.50270575e-01f,
  6.38586283e-02f, -1.78705454e-01f, -7.75518864e-02f, 3.31088826e-02f, 8.84058252e-02f, 1.48147773e-02f, 2.28822425e-01f, 2.76340812e-01f, -9.16939974e-02f, 1.92444585e-02f,
  2.01873705e-01f, -4.50662412e-02f, -9.10827368e-02f, -2.87428545e-03f, -1.35763496e-01f, -8.64117593e-02f, -1.32338732e-01f, -7.56201819e-02f, -1.56943113e-01f, 1.53008644e-02f,
  -7.82647729e-02f, -3.92553210e-02f, -2.94708442e-02f, -1.15841944e-02f, -8.96729976e-02f, -1.20223351e-01f, -1.06092691e-01f, 2.65814140e-02f, 4.51158412e-04f, -1.18225299e-01f,
  -3.31432670e-02f, -8.67472962e-03f, -1.21621914e-01f, -2.64068190e-02f, -9.05264392e-02f, 7.53057599e-02f, 7.84261301e-02f, 7.41726086e-02f, -7.24355727e-02f, -1.65087450e-02f,
  -8.63591954e-02f, -6.15237243e-02f, -1.04097068e-01f, -4.73650545e-02f, -3.88487149e-03f, -4.21488062e-02f, 7.99896196e-02f, 9.44999382e-02f, -1.06509425e-01f, 1.57543086e-02f,
  1.29458234e-01f, -3.07178888e-02f, 8.28364640e-02f, 9.89031941e-02f, -5.44816069e-02f, -2.56579891e-02f, -8.92117023e-02f, -2.47147847e-02f, -1.16621666e-01f, 1.21014491e-01f,
  1.53283775e-01f, -1.91331118e-01f, -6.16091155e-02f, 9.32192132e-02f, -1.80307161e-02f, -1.26029132e-02f, 7.63114840e-02f, -8.03863928e-02f, -1.76148384e-03f, -8.39834288e-02f,
  4.33118157e-02f, -7.10987002e-02f, -1.98313054e-02f, -1.31755859e-01f, 6.30447119e-02f, -5.73915057e-02f, 5.59246540e-02f, -3.54099609e-02f, -9.79010537e-02f, -6.84067756e-02f,
  -7.84058422e-02f, 2.31978521e-02f, 2.89541390e-02f, -1.31493742e-02f, -7.55968457e-03f, -1.22107705e-02f, -8.07311013e-02f, 1.91490389e-02f, -1.15051039e-03f, 9.40367654e-02f,
  -1.42924160e-01f, 2.64604390e-01f, 2.05561981e-01f, 2.16243789e-01f, -7.33826309e-02f, -3.08222175e-01f, -1.57147795e-01f, -5.28433919e-02f, 4.80845571e-02f, 1.77210137e-01f,
  -7.23689273e-02f, 2.64924347e-01f, -1.35762379e-01f, 9.06460211e-02f, -3.04727197e-01f, -5.96445948e-02f, 2.38907747e-02f, 1.96116790e-01f, -1.18591608e-02f, 7.97554702e-02f,
  1.54538164e-02f, -2.18607150e-02f, -2.48631760e-02f, 8.60600695e-02f, 1.53543046e-02f, 2.03229859e-01f, 1.35223627e-01f, 4.89369966e-02f, 2.45668024e-01f, -7.65691623e-02f,
  -1.63363442e-01f, -1.09180184e-02f, 1.03786647e-01f, 5.16615529e-03f, -9.33603644e-02f, -2.36299876e-02f, -8.19064900e-02f, 4.75776494e-02f, -6.17458001e-02f, 2.40091775e-02f,
  1.51165873e-01f, -1.56569984e-02f, 7.84039199e-02f, 1.61495864e-01f, 8.57499763e-02f, 2.85938252e-02f, 6.33431450e-02f, -5.32823466e-02f, 1.49131000e-01f, 8.25207457e-02f,
  1.70613378e-01f, 1.03442848e-01f, 1.22819468e-01f, -2.91056931e-02f, 2.44553387e-03f, -2.04055291e-02f, 1.09126149e-02f, 8.41364264e-02f, 1.41389873e-02f, 4.12622355e-02f,
  -1.37124613e-01f, 1.61388114e-01f, 5.68585061e-02f, 5.29524200e-02f, 1.06710836e-01f, 3.16949710e-02f, -6.73122983e-03f, -7.96830878e-02f, 6.35225847e-02f, 3.36809717e-02f,
  -7.76293799e-02f, 2.79094782e-02f, 6.24489561e-02f, 1.23171076e-01f, 2.23211944e-02f, -7.42134079e-02f, 2.40807030e-02f, -5.19757122e-02f, -1.28266186e-01f, -4.02588658e-02f,
  -1.97639372e-02f, 5.87012693e-02f, 1.11923032e-02f, -1.00782039e-02f, -1.12314053e-01f, 5.09125479e-02f, 4.83157486e-02f, 1.03111342e-02f, 7.04111345e-03f, 1.77325252e-02f,
  -3.97128016e-02f, 1.06394783e-01f, 1.78531781e-02f, -3.61378603e-02f, -3.55679877e-02f, -3.21395956e-02f, -3.13528962e-02f, 8.99372473e-02f, 5.21113351e-02f, -5.43363094e-02f,
  6.77384734e-02f, 2.10172124e-02f, -7.47840572e-03f, 2.96538770e-02f, -2.52623130e-02f, 8.37064907e-02f, 2.53171101e-02f, 6.90752789e-02f, 1.21661983e-01f, 1.01014366e-02f,
  1.43020749e-01f, 7.18983188e-02f, 6.91707730e-02f, -4.53664623e-02f, 8.05329010e-02f, -4.75861393e-02f, -1.69737916e-02f, 5.12152612e-02f, 9.29632038e-02f, -5.77900857e-02f,
  -3.20351630e-01f, 3.31023216e-01f, -1.10194385e-01f, -1.05931915e-01f, 1.31582424e-01f, -2.77424008e-01f, 4.33832593e-02f, 6.95877448e-02f, 6.58646375e-02f, 8.42121616e-02f,
  5.33235893e-02f, 1.34460792e-01f, 2.70021886e-01f, -2.27067806e-02f, -3.65908772e-01f, -1.43822983e-01f, -2.49742746e-01f, -1.43643394e-01f, 7.85844773e-02f, -6.97947592e-02f,
  -3.65375169e-02f, 7.84600526e-02f, -2.34654531e-01f, 2.90806264e-01f, 2.77242102e-02f, -1.22750096e-03f, -1.58507317e-01f, 2.13565454e-01f, -1.99233055e-01f, 1.13189086e-01f,
  -1.57051012e-01f, 2.68928166e-02f, 3.28001869e-03f, -1.02787383e-01f, -8.46636817e-02f, -1.30615339e-01f, -1.83894962e-01f, 5.38513996e-02f, 1.95011105e-02f, 2.66528539e-02f,
  3.29900347e-02f, 3.08025517e-02f, 7.82125220e-02f, 8.85406435e-02f, 4.03747335e-02f, -1.48532512e-02f, -3.74229699e-02f, 1.65950060e-02f, 9.07760859e-02f, -4.45259064e-02f,
  1.10571496e-01f, -6.40293658e-02f, -1.47207499e-01f, -5.57137392e-02f, -2.55462676e-02f, 1.27003998e-01f, -2.22167060e-01f, -7.33867958e-02f, -1.16124243e-01f, -4.63227630e-02f,
  5.22688664e-02f, 1.27354577e-01f, 5.45279682e-02f, 8.16140324e-02f, 4.81528938e-02f, 5.19719496e-02f, 1.03620403e-01f, -4.64891503e-03f, -3.01671755e-02f, 1.00738672e-03f,
  -1.52491182e-01f, 1.28295980e-02f, 8.10880139e-02f, 4.66161594e-03f, -2.54844949e-02f, 2.42319126e-02f, -2.97746039e-03f, -1.22036748e-01f, -1.35196194e-01f, -1.03604183e-01f,
  1.36698440e-01f, -1.06772244e-01f, -6.02026545e-02f, -1.15374051e-01f, 5.26907891e-02f, -1.64682027e-02f, 1.15411598e-02f, -9.83598977e-02f, -3.45839411e-02f, -1.73439294e-01f,
  -4.12770808e-01f, -2.96836019e-01f, 3.82269733e-02f, 4.77373637e-02f, 5.28258495e-02f, -9.29750130e-02f, -2.52070464e-02f, 5.73138036e-02f, -2.38349140e-02f, 7.78927952e-02f,
  -2.14886796e-02f, -2.35525835e-02f, -2.19101220e-01f, 5.99686131e-02f, -7.07021207e-02f, -1.29749611e-01f, -1.30469371e-02f, 8.52034315e-02f, -3.20912004e-02f, -1.00731000e-01f,
  5.01033589e-02f, -6.83959061e-03f, 4.66777980e-02f, -1.02797173e-01f, -1.82176039e-01f, -4.87998798e-02f, -4.31872755e-02f, -5.17439991e-02f, -5.45604378e-02f, 3.34873274e-02f,
  1.43380746e-01f, -3.04220170e-01f, -1.96850881e-01f, 9.99751985e-02f, 1.63002342e-01f, 1.99994862e-01f, 9.48970988e-02f, 1.33194238e-01f, 2.31724582e-03f, 1.89171806e-02f,
  -6.80721402e-02f, -4.20489043e-01f, -2.52747625e-01f, -2.54488438e-01f, -2.15395123e-01f, -3.45292032e-01f, -1.95105858e-02f, -1.87928751e-01f, -1.42661348e-01f, -5.54439006e-03f,
  8.00258890e-02f, 1.70169920e-01f, -2.00102940e-01f, 3.53377879e-01f, 2.76380032e-01f, 2.15778098e-01f, 2.90132463e-01f, 1.80785552e-01f, 1.64455980e-01f, 4.43249755e-02f,
  -5.42489812e-02f, -5.79515882e-02f, -1.11661227e-02f, 2.79787146e-02f, 1.57675683e-01f, 1.96031630e-01f, 4.66412492e-02f, -1.04406975e-01f, -1.13827176e-01f, -6.04978465e-02f,
  -2.45127175e-03f, -2.67235772e-03f, -4.82629277e-02f, 2.16125119e-02f, 1.68882385e-01f, 6.99676573e-02f, -9.83193517e-02f, -1.11550903e-02f, -1.22006116e-02f, -1.31426647e-01f,
  -9.16492492e-02f, -3.96968685e-02f, 3.91387343e-02f, -3.68690975e-02f, -1.45115182e-01f, -9.11443233e-02f, 8.63064453e-03f, -6.31506965e-02f, 2.11739931e-02f, 1.07869385e-02f,
  1.49471700e-01f, 7.88502023e-02f, -8.42813496e-03f, -1.26108453e-01f, -1.02730848e-01f, 9.94520560e-02f, -6.93495795e-02f, 3.35394554e-02f, -7.26002129e-03f, -3.86526324e-02f,
  1.00188814e-01f, 4.38417532e-02f, 1.03540858e-03f, 1.23673134e-01f, 8.36051032e-02f, 8.63600895e-02f, 3.35546583e-02f, -1.10260412e-01f, 1.11338936e-01f, 2.32910868e-02f,
  9.48876515e-02f, 1.15494812e-02f, -1.03111245e-01f, 1.24624111e-02f, -7.20883813e-03f, 6.43207952e-02f, 7.05931261e-02f, -2.45151273e-03f, -6.37390241e-02f, 7.24737644e-02f,
  -1.04139872e-01f, -9.23393890e-02f, -9.75863710e-02f, 1.98106021e-02f, -1.18792064e-01f, 9.84247178e-02f, 2.50982139e-02f, 3.88058126e-02f, -3.42944302e-02f, -9.01884586e-02f,
  1.73824757e-01f, 1.19587213e-01f, 9.98884663e-02f, -7.57037625e-02f, 3.14482637e-02f, 4.91154045e-02f, -7.12329745e-02f, 6.84899837e-02f, 1.51576966e-01f, 6.20844215e-02f,
  8.02150890e-02f, 1.05304740e-01f, 6.21392094e-02f, 3.14712562e-02f, 2.47045569e-02f, 2.30257977e-02f, -1.10710226e-02f, 7.32206926e-02f, -1.25347730e-02f, 3.53328064e-02f,
  -1.49729878e-01f, -2.20061690e-01f, 1.41756549e-01f, -9.78731737e-03f, -2.86069870e-01f, 1.90379962e-01f, 3.42401654e-01f, -2.19024897e-01f, 1.00160904e-01f, 1.47376776e-01f,
  7.39657208e-02f, 9.08081383e-02f, 2.21660361e-01f, -7.86669925e-03f, 3.15059155e-01f, 2.17073470e-01f, 6.11242987e-02f, 2.16992185e-01f, -4.65064421e-02f, -1.75655976e-01f,
  -2.00712815e-01f, -2.00752914e-01f, 9.73583981e-02f, -4.23587620e-01f, -2.62932599e-01f, -3.15904438e-01f, -5.47223724e-03f, 3.31027992e-02f, -7.71358088e-02f, 2.56788228e-02f,
  -1.29348591e-01f, -6.80091009e-02f, -1.07475847e-01f, -1.56745650e-02f, -1.53358534e-01f, -1.67174451e-02f, 1.04199521e-01f, 1.64450511e-01f, -2.67114453e-02f, 2.15160344e-02f,
  1.28427491e-01f, -1.32394023e-02f, -6.69067353e-02f, 5.83321229e-03f, -1.20478272e-01f, -1.79561332e-01f, 7.03552645e-03f, -1.30002853e-03f, -6.78349733e-02f, 2.43067984e-02f,
  1.15260459e-01f, -5.09494171e-02f, -1.72811449e-02f, 8.00108910e-02f, -2.68264059e-02f, -9.79189426e-02f, 1.41928107e-01f, 1.01826131e-01f, -1.95950121e-01f, -6.33439273e-02f,
  2.12159064e-02f, 8.29238892e-02f, -5.73201329e-02f, -5.03184758e-02f, -2.80072577e-02f, -2.76183449e-02f, -9.88020469e-03f, 1.00411534e-01f, 7.47467801e-02f, -6.84181228e-02f,
  -1.58146061e-02f, -5.24220578e-02f, -6.17242530e-02f, -3.65699381e-02f, 7.42749721e-02f, -4.79319468e-02f, 4.33420613e-02f, -1.54482469e-01f, 8.97361711e-02f, -1.06464364e-02f,
  3.60292308e-02f, 3.83190103e-02f, -4.87158559e-02f, -8.20873491e-03f, -6.79470748e-02f, 2.50910711e-03f, -9.21026617e-02f, 3.46048437e-02f, 7.66828805e-02f, 3.69339548e-02f,
  -1.11478977e-01f, -1.68770522e-01f, -4.62232716e-02f, -1.63817599e-01f, -2.86305565e-02f, -1.54948644e-02f, 7.86493272e-02f, -1.32688165e-01f, -1.98791146e-01f, 2.01803492e-03f,
  1.57864671e-02f, 3.15824780e-03f, -1.77659094e-01f, -4.85932268e-02f, -6.73792977e-03f, -6.76870644e-02f, 6.87085390e-02f, -1.19076483e-01f, 9.50795636e-02f, -1.34126753e-01f,
  4.03611250e-02f, 6.35706037e-02f, 6.84743896e-02f, -8.93157199e-02f, -1.67003786e-03f, 3.06623578e-02f, -4.07867543e-02f, 8.74148391e-04f, -1.01941839e-01f, 9.59637538e-02f,
  1.40482828e-01f, -7.81831816e-02f, -1.75221533e-01f, -1.37886211e-01f, -2.86062211e-01f, -2.09271282e-01f, -1.57140881e-01f, -1.34217158e-01f, 5.43185584e-02f, 2.62345783e-02f,
  -2.55524576e-01f, 1.45843863e-01f, 1.29105985e-01f, -2.68431395e-01f, 1.76962733e-01f, 2.52691984e-01f, -3.45238894e-02f, 3.33945602e-02f, -3.51723395e-02f, -1.57113180e-01f,
  -7.24787042e-02f, -2.34084055e-01f, -1.02229774e-01f, -1.42809927e-01f, -3.00847828e-01f, -3.88356224e-02f, -7.45699778e-02f, -2.88041234e-01f, -1.96233794e-01f, -7.82485604e-02f,
  -5.74289709e-02f, 6.58884421e-02f, -5.40613569e-02f, 1.73728112e-02f, -1.26415370e-02f, 1.25734909e-02f, -1.33980542e-01f, -4.19156775e-02f, 2.06267890e-02f, 9.45161059e-02f,
  6.77648485e-02f, 1.72619522e-01f, 5.15987985e-02f, -5.64363934e-02f, -9.42531824e-02f, -1.02958009e-01f, 4.57200743e-02f, -5.79363257e-02f, -1.47182215e-02f, -1.61682330e-02f,
  -7.56684914e-02f, -5.42865060e-02f, -6.89381510e-02f, 1.63812503e-01f, 3.23956981e-02f, 1.21841840e-01f, 3.87717411e-02f, -5.14343865e-02f, 3.54248770e-02f, 6.72759162e-03f,
  -2.93428227e-02f, 8.84730965e-02f, -6.33782893e-02f, -1.57648504e-01f, -3.98188904e-02f, -6.62447885e-02f, 7.60894082e-03f, -4.90234978e-02f, -1.29164215e-02f, -1.25613576e-02f,
  1.67471599e-02f, -2.71592475e-02f, -6.19153194e-02f, 4.84786928e-02f, -5.53204305e-03f, 6.96652234e-02f, 2.09206622e-02f, -1.30641181e-02f, -1.35610048e-02f, -8.10777545e-02f,
  5.09401150e-02f, -1.11058140e-02f, 7.29504302e-02f, -1.72355454e-02f, -1.07093520e-01f, 4.14874107e-02f, -7.29006901e-02f, -3.06438860e-02f, -9.91779268e-02f, -8.86943787e-02f,
  -2.82997619e-02f, 2.85394508e-02f, 7.62713477e-02f, -8.42941343e-04f, -3.79748782e-03f, -4.01496738e-02f, -1.17694780e-01f, -1.07114087e-03f, 1.84649453e-02f, 1.02707474e-02f,
  -3.29092368e-02f, 9.61517096e-02f, 5.11288308e-02f, -3.15722115e-02f, 3.51225175e-02f, -6.94712400e-02f, 6.40275031e-02f, -3.38138617e-03f, 4.28741053e-02f, 2.05857828e-02f,
  -2.75907526e-03f, 6.91598281e-02f, 2.09390700e-01f, 5.28325662e-02f, 1.37833759e-01f, 7.74925500e-02f, -1.73397548e-02f, -2.68669650e-02f, 2.20337324e-02f, 3.91744263e-02f,
  -4.86511141e-01f, 2.02628106e-01f, -1.04608759e-01f, -2.61057615e-01f, -6.19515963e-03f, -5.90207912e-02f, -2.11970378e-02f, 1.90835312e-01f, 1.46322697e-01f, 1.27686694e-01f,
  -3.03561613e-02f, -2.96874214e-02f, 3.10355514e-01f, -6.27726018e-02f, -1.80741876e-01f, 1.73362687e-01f, -2.05024704e-01f, -1.74416929e-01f, 2.31001586e-01f, -1.48450792e-01f,
  -5.93652539e-02f, -1.31525815e-01f, -4.56403568e-02f, 1.23560064e-01f, -4.85546626e-02f, -5.06507494e-02f, -2.57109702e-01f, 1.75218865e-01f, -2.44685769e-01f, 2.51978394e-02f,
  -9.43831131e-02f, 6.18056767e-02f, -4.70020063e-02f, 3.78496908e-02f, -1.80823699e-01f, 6.52995333e-03f, -6.28610104e-02f, 4.59487699e-02f, 6.53520301e-02f, 1.15640916e-01f,
  -9.49791595e-02f, 9.41612497e-02f, 1.57334562e-02f, 7.51910955e-02f, 1.43142745e-01f, -4.01304625e-02f, -1.74913824e-01f, -1.31122604e-01f, 1.42945930e-01f, 3.19216922e-02f,
  2.96481401e-02f, 3.11225411e-02f, -1.29433230e-01f, -3.35523486e-03f, -1.17751062e-01f, 1.08921446e-01f, -2.52631642e-02f, -1.30142123e-01f, -1.39396727e-01f, -5.03659509e-02f,
  6.07037283e-02f, -5.94053864e-02f, 8.53870250e-03f, 1.07675530e-01f, 3.90640646e-02f, -8.84309877e-03f, -1.16699804e-02f, -1.43868689e-04f, -1.35461325e-02f, -8.21064711e-02f,
  -9.91204083e-02f, -3.14384475e-02f, 7.36294240e-02f, -5.46190962e-02f, -3.87297347e-02f, 1.54083094e-03f, -6.69146627e-02f, -7.46956542e-02f, 4.05237218e-03f, -1.53464139e-01f,
  4.58035665e-03f, -1.20019116e-01f, -1.13171570e-01f, -5.75644188e-02f, 1.23297147e-01f, -7.87198544e-03f, 9.18959901e-02f, -5.74369216e-04f, -8.32816400e-03f, -4.60362621e-02f,
  -2.16625050e-01f, -2.20515013e-01f, 6.29706457e-02f, 5.54435775e-02f, -8.12720731e-02f, -2.02566199e-02f, 8.28929022e-02f, 1.44808264e-02f, -8.40902999e-02f, 6.06605597e-02f,
  -1.97845362e-02f, -9.05056223e-02f, -1.25340521e-01f, 8.05334523e-02f, 1.26030713e-01f, -3.32228281e-02f, -7.03870207e-02f, -9.34864581e-02f, -1.26383021e-01f, -9.50829461e-02f,
  9.76143219e-03f, 2.93016294e-03f, 3.13112587e-02f, -3.07462569e-02f, -2.34062225e-02f, -4.90802824e-02f, -3.93628180e-02f, 2.29334105e-02f, -9.65175629e-02f, -1.18516888e-02f,
  8.76981393e-03f, 3.04012951e-02f, -4.79260534e-02f, -2.72554249e-01f, 1.22862093e-01f, 5.35872057e-02f, -1.17515653e-01f, 8.83383006e-02f, -2.37993225e-01f, 2.57873803e-01f,
  -5.08836620e-02f, -1.10437281e-01f, -1.07413262e-01f, -2.42231280e-01f, -3.39584738e-01f, -3.46496105e-01f, -1.28829122e-01f, -1.13111503e-01f, -1.15811072e-01f, 1.17498122e-01f,
  -9.38673392e-02f, 5.23372646e-03f, -2.98338920e-01f, 1.26359731e-01f, 5.58139719e-02f, 1.06126472e-01f, 3.27672213e-01f, 1.56876206e-01f, 8.26057568e-02f, -4.76899669e-02f,
  -3.46855493e-03f, -1.01200409e-01f, -5.12885749e-02f, -1.15602883e-02f, -3.98223195e-03f, 7.57374540e-02f, 5.10741249e-02f, -1.10131137e-01f, -1.09047584e-01f, -5.35261184e-02f,
  1.02862149e-01f, -7.47861788e-02f, -8.67026206e-03f, -3.80934365e-02f, 4.09988593e-03f, 7.23131746e-02f, -4.04652581e-02f, 8.53967518e-02f, -6.88201115e-02f, -5.70667461e-02f,
  -6.40797764e-02f, 5.64411767e-02f, 2.57994533e-02f, -2.26248577e-02f, 2.74740737e-02f, 2.45928974e-03f, 1.06181942e-01f, 1.31216273e-01f, 4.41017142e-03f, 1.02789022e-01f,
  1.48168594e-01f, 8.81461129e-02f, 1.35536315e-02f, -1.12985730e-01f, -1.87377799e-02f, 2.54437998e-02f, -2.48687640e-02f, 4.54502041e-03f, 6.81881513e-03f, -1.43673606e-02f,
  3.80847827e-02f, -7.47220218e-02f, -9.95879918e-02f, 3.30975046e-03f, 5.32981604e-02f, -8.27663988e-02f, 4.68133427e-02f, -3.81380506e-02f, 9.64114517e-02f, 1.21597759e-02f,
  -1.47405371e-01f, 1.14469238e-01f, 1.42783262e-02f, 1.16818897e-01f, -8.35986733e-02f, 7.19399750e-02f, 4.10833061e-02f, -4.47297692e-02f, -5.52595593e-02f, 8.41608495e-02f,
  -4.78302501e-02f, 1.48022369e-01f, -3.34558226e-02f, -1.23200685e-01f, 2.73109972e-02f, -2.87598595e-02f, -5.41396961e-02f, 3.39228548e-02f, -3.39947976e-02f, -1.90205034e-02f,
  2.46262074e-01f, 1.11218598e-02f, 1.49559677e-01f, -5.46426959e-02f, -2.46836245e-03f, 5.67153059e-02f, -1.93055421e-02f, 2.20057461e-02f, 6.28656149e-02f, 7.56257251e-02f,
  1.51174545e-01f, 9.56699774e-02f, 1.39960682e-03f, 1.85105857e-02f, 7.39549771e-02f, 6.67152703e-02f, 1.38211563e-01f, -2.40120087e-02f, 8.46439749e-02f, -2.90718768e-03f,
  3.35398704e-01f, -1.12569384e-01f, 1.95853412e-01f, 4.12904918e-01f, 1.13087028e-01f, -3.07184279e-01f, -1.63602054e-01f, 1.54636264e-01f, 1.50371566e-01f, -2.41058737e-01f,
  5.07092029e-02f, 5.71560487e-02f, -3.88878882e-01f, 1.79524496e-01f, 3.19483019e-02f, -1.83490306e-01f, 1.94645554e-01f, 7.89887533e-02f, 6.90244287e-02f, 1.86687693e-01f,
  2.48653904e-01f, 2.66076848e-02f, 6.81841001e-02f, 4.72006686e-02f, 6.00633807e-02f, 1.56307876e-01f, 7.73079395e-02f, -2.64420528e-02f, 1.62829414e-01f, -1.70397982e-02f,
  -6.07604831e-02f, 8.35472569e-02f, 3.49396057e-02f, -9.62306783e-02f, 7.79463872e-02f, 3.38154919e-02f, -6.82620406e-02f, -1.11189134e-01f, -2.25913581e-02f, -8.69314000e-02f,
  -1.31770492e-01f, -1.62658971e-02f, 7.73798488e-03f, -6.65960237e-02f, 5.19347237e-03f, 9.68088433e-02f, 1.57525688e-01f, 9.94167104e-03f, 3.99147235e-02f, 1.08132675e-01f,
  9.92902890e-02f, 6.81971088e-02f, -4.49780859e-02f, -4.02503721e-02f, 5.41590899e-02f, 1.05054960e-01f, 4.20476981e-02f, 2.09451932e-02f, 3.96211222e-02f, 1.34994283e-01f,
  -9.96754020e-02f, -3.13255638e-02f, 4.13439684e-02f, 1.16976462e-01f, 9.47566703e-02f, 1.23745337e-01f, -1.05848886e-01f, -5.11777550e-02f, -9.66627821e-02f, 2.92712171e-02f,
  6.50002807e-02f, 9.96144861e-02f, 5.60709238e-02f, 1.03357155e-02f, 5.31697534e-02f, 1.14610858e-01f, -6.26524463e-02f, -5.23422733e-02f, -5.25875688e-02f, 9.53832269e-02f,
  7.03558773e-02f, 2.80512478e-02f, -7.59356618e-02f, 7.23562017e-03f, -3.32000591e-02f, 1.29266139e-02f, -3.92464548e-02f, 4.59968410e-02f, 1.37492225e-01f, -3.60206701e-02f,
  -2.44758770e-01f, -5.64918369e-02f, -3.62834930e-02f, -1.20154068e-01f, -1.46449311e-02f, 2.98543982e-02f, 6.50616065e-02f, -4.17191871e-02f, -3.96365188e-02f, 1.89145729e-02f,
  -4.20132652e-02f, 3.37319672e-02f, -4.03760299e-02f, -8.60657617e-02f, -1.02199763e-01f, -4.87386174e-02f, 4.94164862e-02f, 4.74926271e-02f, 1.91398077e-02f, 8.35558772e-02f,
  5.04149012e-02f, -4.56034355e-02f, 7.13202432e-02f, 5.20275570e-02f, -2.74137091e-02f, 2.72801854e-02f, 3.10664456e-02f, 8.69522691e-02f, 2.35983059e-02f, 2.39705835e-02f,
  -7.11065829e-02f, 3.38964462e-01f, 1.76556811e-01f, -1.65850982e-01f, 3.77196148e-02f, -7.18813911e-02f, -1.31446153e-01f, 1.01746246e-01f, -1.75360311e-02f, 2.20671877e-01f,
  -9.60915461e-02f, 2.45409146e-01f, -7.73681179e-02f, -7.34157115e-02f, -3.80360156e-01f, -2.82991439e-01f, -1.91367626e-01f, 1.25584174e-02f, -6.14501610e-02f, -6.34361804e-02f,
  -1.41867384e-01f, -3.61626238e-01f, -1.89844817e-01f, -8.74592215e-02f, -1.88270900e-02f, 2.44981378e-01f, -1.39036983e-01f, 2.36113978e-04f, 1.00367457e-01f, -1.34815015e-02f,
  4.60098358e-03f, 2.29690298e-02f, 1.21746145e-01f, -9.02423449e-03f, -4.28747162e-02f, 7.54403770e-02f, 2.09002625e-02f, -7.87127763e-02f, -7.01056048e-02f, 1.12768523e-02f,
  1.95086859e-02f, -1.13930434e-01f, -2.02617571e-02f, 8.37829616e-03f, 1.09764300e-02f, -3.98568623e-02f, 2.72955038e-02f, 8.40871111e-02f, 8.63963366e-02f, 5.53778000e-03f,
  8.25585946e-02f, 3.02319787e-02f, -3.61021981e-02f, -3.42841782e-02f, 4.18647937e-02f, 2.01104507e-02f, 3.61313000e-02f, 2.39627771e-02f, 9.52514075e-03f, -7.70304911e-03f,
  1.78787727e-02f, -9.86199081e-02f, -1.21891946e-01f, 2.37275120e-02f, -7.90638402e-02f, 1.79160498e-02f, -2.59573422e-02f, -2.82999920e-03f, 1.15873739e-01f, -2.92593539e-02f,
  4.50997235e-04f, 5.66234551e-02f, -6.78361999e-03f, -2.50686221e-02f, 5.48352785e-02f, -3.46602388e-02f, 3.68150473e-02f, 1.47443004e-02f, 2.45851371e-03f, 4.57126983e-02f,
  -1.05335876e-01f, -1.38505818e-02f, 3.99904586e-02f, -4.61298600e-02f, -1.39005050e-01f, -4.95309010e-02f, -8.47575720e-03f, 2.07047239e-02f, -2.37815380e-02f, 5.74419228e-03f,
  -2.55911853e-02f, -1.42743111e-01f, 4.75215763e-02f, -2.19641160e-02f, 3.43405157e-02f, 2.95304414e-02f, -8.34143236e-02f, 1.89420395e-02f, -9.13783982e-02f, -5.99809512e-02f,
  5.72930016e-02f, -3.33842076e-02f, -2.14358978e-02f, -1.17345829e-03f, -7.05205128e-02f, -9.96873081e-02f, -4.24482636e-02f, 1.08506763e-02f, 3.07524838e-02f, 2.55307052e-02f,
  7.12157935e-02f, -6.26729131e-02f, -1.23738684e-02f, -1.75830424e-02f, -9.37318429e-03f, 6.79555014e-02f, 4.19060467e-03f, 5.76753095e-02f, -7.13412687e-02f, 2.76054069e-02f,
  1.49697274e-01f, -3.74261498e-01f, -6.61715791e-02f, 3.57941628e-01f, 4.56068590e-02f, -3.27028722e-01f, -2.93045193e-01f, 1.94246788e-03f, 1.55410483e-01f, -3.38362575e-01f,
  6.31647781e-02f, -1.37511373e-01f, -2.91900098e-01f, 1.45181894e-01f, 2.34100446e-01f, -5.95925637e-02f, 3.01425848e-02f, -8.94031953e-03f, -9.57372412e-03f, -5.13224714e-02f,
  2.68355340e-01f, 1.09299146e-01f, -5.33897057e-02f, 2.60452013e-02f, -1.60157427e-01f, 7.20408978e-04f, 3.15496363e-02f, -1.39548063e-01f, 1.24604575e-01f, 4.84917965e-03f,
  9.07192379e-02f, 1.19589865e-01f, -3.08227092e-02f, 8.02408606e-02f, -2.71741375e-02f, -7.26018623e-02f, -5.26042879e-02f, -5.16919903e-02f, 8.35682228e-02f, 1.20673887e-02f,
  -8.13019052e-02f, 9.94042456e-02f, 8.05093944e-02f, 2.35960018e-02f, 4.10294980e-02f, 5.01678139e-02f, 4.09948193e-02f, 2.28937925e-03f, -2.92508472e-02f, -3.73150967e-02f,
  -1.97862331e-02f, 5.01476787e-02f, 2.77172104e-02f, 8.83900300e-02f, 7.24668950e-02f, 6.21512011e-02f, -1.02712333e-01f, -1.00707613e-01f, 1.50144612e-02f, 6.20266497e-02f,
  3.98579985e-02f, -9.96153578e-02f, -9.51654315e-02f, -2.32004225e-02f, -7.12074712e-02f, 1.29172757e-01f, 3.22656217e-03f, -1.47396438e-02f, -5.91413006e-02f, -1.72528699e-02f,
  -5.03082238e-02f, -4.29271394e-03f, 2.13385299e-02f, 2.20571384e-02f, 9.20501649e-02f, 6.62935153e-02f, -1.82799120e-02f, -8.23090300e-02f, 5.44693843e-02f, -5.32180741e-02f,
  9.13546830e-02f, 4.33427021e-02f, -6.75761923e-02f, 5.29373884e-02f, 2.75248736e-02f, -1.53664919e-03f, 1.16798535e-01f, -8.71322602e-02f, -1.01997973e-02f, -1.80233657e-01f,
  4.01072167e-02f, -7.01674521e-02f, -1.12449363e-01f, 8.59696567e-02f, -2.68404726e-02f, -5.82769215e-02f, -4.25894000e-02f, 9.65330750e-02f, 1.57971065e-02f, 1.96574368e-02f,
  3.15673463e-02f, -1.86289847e-02f, 1.70090094e-01f, 1.61473840e-01f, 1.03124194e-01f, -1.52512521e-01f, 1.07176639e-02f, 2.25592218e-02f, 9.04874653e-02f, 5.65865962e-03f,
  1.85785943e-03f, 6.21041283e-03f, 1.36640277e-02f, -4.92628291e-02f, 8.55974779e-02f, 2.02453267e-02f, -6.91443458e-02f, 8.69383067e-02f, 9.20862854e-02f, 4.74213995e-02f,
  3.42906207e-01f, -1.64188415e-01f, -1.67515147e-02f, 1.21761039e-01f, 1.47320136e-01f, -5.43330051e-02f, -3.61095294e-02f, 1.41392261e-01f, -7.93494806e-02f, -2.22270504e-01f,
  1.26182169e-01f, -1.99351490e-01f, -8.42300951e-02f, 1.99362740e-01f, 1.95935488e-01f, -1.38841316e-01f, 1.79548025e-01f, -8.66499990e-02f, 5.26015721e-02f, 2.49606207e-01f,
  2.10803792e-01f, 3.49916995e-01f, 1.35375321e-01f, 1.56308725e-01f, 1.97347954e-01f, 1.13513321e-01f, 1.89907506e-01f, -4.09750938e-02f, 1.31067604e-01f, -7.96643719e-02f,
  -4.53769304e-02f, 1.23348929e-01f, 5.06909611e-03f, -8.47096667e-02f, 9.39016715e-02f, -4.79257070e-02f, -6.25013113e-02f, -1.43956849e-02f, -4.20583449e-02f, 7.01097166e-03f,
  2.18077619e-02f, 1.27487242e-01f, 1.07679553e-01f, 8.46604556e-02f, -2.41483320e-02f, 6.87857643e-02f, 1.03882551e-01f, -2.62181144e-02f, -1.21249624e-01f, 1.03029333e-01f,
  2.03504208e-02f, -4.88269702e-03f, -4.76919115e-02f, 2.32327078e-02f, 7.64407516e-02f, 6.98270872e-02f, -1.48087472e-01f, 9.05448198e-03f, -5.09887040e-02f, 2.29832549e-02f,
  2.54235983e-01f, -1.07196078e-01f, 2.63519660e-02f, 5.08865155e-02f, -8.74173716e-02f, 5.10498099e-02f, -1.76777735e-01f, -2.86434386e-02f, -1.10202298e-01f, -7.17054233e-02f,
  -1.67722702e-01f, -1.05568711e-02f, -1.52650885e-02f, -9.65483487e-02f, 6.91167042e-02f, 1.22983307e-02f, -1.51361495e-01f, -5.49254119e-02f, 1.17877156e-01f, -3.90175804e-02f,
  -6.46278113e-02f, 5.78001253e-02f, -7.15154707e-02f, -3.96236107e-02f, -6.57896399e-02f, 1.25545725e-01f, 1.69245359e-02f, 7.64771700e-02f, 9.24973376e-03f, -1.30674586e-01f,
  -1.27875522e-01f, 3.90950888e-02f, -2.99797487e-02f, -1.23788193e-02f, -1.49596557e-01f, -5.38989194e-02f, -1.22669160e-01f, 9.38212276e-02f, -9.46958642e-03f, 7.21927881e-02f,
  9.51798782e-02f, -6.04417622e-02f, -9.76229906e-02f, 4.99596703e-04f, -9.04127806e-02f, 4.29176688e-02f, 1.67083573e-02f, -1.14744522e-01f, -4.08193655e-02f, 8.96561369e-02f,
  4.97113429e-02f, 1.08199023e-01f, -1.09654143e-01f, 3.54849659e-02f, 7.42060915e-02f, -6.30359575e-02f, 4.86069582e-02f, 6.19879412e-03f, 5.57192601e-02f, -1.88565925e-02f,
  4.14171308e-01f, -2.56184548e-01f, -2.44236723e-01f, -1.76825210e-01f, -8.13085139e-02f, -1.62652209e-01f, -1.01775579e-01f, -3.04713607e-01f, -1.54008210e-01f, -2.69274116e-01f,
  -1.44851908e-01f, 9.81359035e-02f, 2.24164590e-01f, -2.78462052e-01f, 4.53919381e-01f, 1.78201094e-01f, -1.49693742e-01f, -7.28257224e-02f, -6.31132573e-02f, -5.75214298e-03f,
  3.34270000e-02f, -1.50978789e-01f, -1.26538232e-01f, -2.34867364e-01f, -1.97581962e-01f, -2.65083551e-01f, 3.96365076e-02f, -2.19767038e-02f, -3.15354019e-01f, -1.33076590e-02f,
  -7.41895139e-02f, -3.48957698e-03f, -6.16283156e-02f, -1.60496011e-02f, -1.16623538e-02f, 9.56202894e-02f, -5.61809465e-02f, 1.79410085e-01f, -4.61390894e-03f, 2.01637223e-02f,
  8.79382342e-02f, 6.25257716e-02f, -1.51827987e-02f, 1.79584101e-02f, 6.70397729e-02f, -6.40797466e-02f, -5.61405309e-02f, -2.78149471e-02f, -6.82168007e-02f, 1.14961907e-01f,
  -3.45414206e-02f, 4.23728228e-02f, 2.25845724e-03f, 1.18225785e-02f, -5.94583787e-02f, 3.49144693e-06f, 6.85061375e-03f, 9.41735208e-02f, 6.72304928e-02f, 4.98184562e-02f,
  3.71836610e-02f, 1.48116574e-01f, 1.23270594e-01f, 1.35293361e-02f, 2.24819835e-02f, -9.61517449e-03f, 2.95460541e-02f, -4.53726240e-02f, -6.02830425e-02f, -7.20530078e-02f,
  -4.18947972e-02f, -1.04979895e-01f, 6.74458593e-02f, 1.71185341e-02f, 4.14484516e-02f, 1.30022958e-01f, 7.64469579e-02f, -6.13536499e-02f, -1.29831851e-01f, -1.03276543e-01f,
  4.36270908e-02f, 8.44470486e-02f, -2.77921446e-02f, 1.66119970e-02f, -4.99213859e-02f, 3.89030986e-02f, -1.98468324e-02f, 1.84690896e-02f, -1.06489070e-01f, -4.43836637e-02f,
  -1.56199828e-01f, -3.69394384e-02f, -1.69081792e-01f, -7.84620047e-02f, -3.81784514e-02f, 1.40899094e-02f, -5.34125380e-02f, -6.40336648e-02f, -4.22919765e-02f, 5.64674847e-02f,
  -3.16430628e-02f, 6.53516278e-02f, 5.63182160e-02f, -7.90596157e-02f, -3.21153663e-02f, -1.24770314e-01f, 1.03948891e-01f, 1.13902548e-02f, 1.43254325e-02f, 2.22703349e-03f,
  3.16407569e-02f, 1.10675901e-01f, 5.37548214e-02f, -7.08204731e-02f, -1.17261469e-01f, 8.47632959e-02f, 2.50679161e-02f, 8.79233517e-03f, 1.76418558e-01f, 2.08511855e-02f,
  4.92271572e-01f, 2.89183736e-01f, 2.47499526e-01f, 7.02277124e-02f, -2.13266715e-01f, -1.91308856e-02f, 7.51311332e-02f, -7.16362372e-02f, -7.80132562e-02f, 5.12852985e-03f,
  -1.03836365e-01f, 3.30616683e-01f, -1.08526245e-01f, 1.35575294e-01f, -2.41482705e-01f, -9.76108015e-02f, 1.70057397e-02f, 1.08847968e-01f, -1.18428379e-01f, 1.12318426e-01f,
  -2.47064084e-02f, -2.10791498e-01f, -5.56537881e-03f, -1.23318560e-01f, 1.72737017e-01f, 1.91585302e-01f, -1.75573289e-01f, 9.44307894e-02f, 8.91424939e-02f, -8.83464143e-02f,
  2.32264237e-03f, -3.67671140e-02f, 1.14863940e-01f, 4.59372513e-02f, -3.40242358e-03f, 7.38311782e-02f, 4.43723127e-02f, 5.07139079e-02f, -1.02224812e-01f, 3.94639447e-02f,
  5.64571768e-02f, 4.44658659e-02f, 6.39590025e-02f, -4.43803612e-03f, 8.33851844e-02f, 7.40283430e-02f, 2.59108823e-02f, 1.11687839e-01f, 7.66068995e-02f, 1.42302424e-01f,
  1.53118595e-01f, 1.46583229e-01f, 8.13451037e-02f, -5.49822599e-02f, 1.74304899e-02f, -3.76792885e-02f, 1.65655520e-02f, 1.04639217e-01f, 6.26915023e-02f, -8.05580802e-03f,
  -4.22546128e-03f, -2.01340728e-02f, 9.76167321e-02f, 4.40202914e-02f, -8.98327213e-03f, -3.92150953e-02f, -2.12502340e-03f, 5.38497865e-02f, 5.23726456e-03f, 3.46900756e-03f,
  -4.69189845e-02f, 2.09935638e-03f, 4.71600033e-02f, 4.77205077e-03f, 1.09389108e-02f, -7.20614614e-03f, 1.16829045e-01f, 3.29440311e-02f, -1.45886719e-01f, -5.34600206e-02f,
  -5.08137532e-02f, -2.85024885e-02f, -5.06485663e-02f, 4.63006534e-02f, -4.36554104e-02f, -1.14730597e-02f, 3.91832627e-02f, 1.35680690e-01f, -2.65496857e-02f, -1.35182321e-01f,
  -1.32364333e-01f, -2.41500273e-01f, -7.58935809e-02f, 1.33268256e-02f, -2.11287774e-02f, 5.33714294e-02f, 1.24889985e-03f, 1.53333098e-01f, -1.41627580e-01f, -8.56355485e-03f,
  -9.21005290e-03f, 1.66157097e-01f, -2.08787415e-02f, 7.33446702e-02f, -4.71722893e-02f, -3.62699106e-02f, 2.95742806e-02f, -5.29767759e-02f, -8.59587714e-02f, 8.76631811e-02f,
  6.55931011e-02f, 1.78350080e-02f, 7.83514306e-02f, 2.04632687e-03f, 6.34401217e-02f, 5.42713292e-02f, 4.17980254e-02f, 9.11969095e-02f, 1.23170568e-02f, -8.41451138e-02f,
  2.48163845e-02f, -1.06592134e-01f, -2.12169647e-01f, 4.94604334e-02f, -1.40258849e-01f, -4.04136568e-01f, -2.23702222e-01f, -7.03291595e-02f, 2.83970773e-01f, 9.14185792e-02f,
  6.54765964e-02f, 1.65692702e-01f, 1.28318459e-01f, -1.70989800e-02f, -3.03584561e-02f, 2.92610973e-01f, -3.27101111e-01f, -2.66698399e-03f, 6.81614131e-02f, -2.83742517e-01f,
  -2.39592772e-02f, -2.80471414e-01f, -6.88408092e-02f, -1.37361750e-01f, -2.26496980e-01f, 3.94106880e-02f, 1.06378458e-01f, 7.18109682e-02f, -1.05382614e-01f, 1.35559831e-02f,
  -2.50825763e-01f, 7.51355104e-03f, -1.87563859e-02f, -4.07175682e-02f, -1.21564165e-01f, -3.22023928e-02f, -4.26231232e-03f, 1.54118285e-01f, 9.94009152e-02f, 7.44351791e-03f,
  5.74622303e-02f, 1.07047826e-01f, 3.80924251e-03f, 1.22871026e-01f, 8.43247306e-03f, 1.06805395e-02f, 9.66812372e-02f, -1.16066173e-01f, -1.84278227e-02f, 1.56432703e-01f,
  1.99590735e-02f, -4.90309671e-02f, -5.40206023e-03f, 4.21847031e-02f, 1.05880857e-01f, 3.76139320e-02f, -1.22179113e-01f, -3.55302170e-02f, -4.57164571e-02f, -1.06665328e-01f,
  -3.10328212e-02f, 8.22836906e-03f, 3.65507640e-02f, 1.36321727e-02f, 3.14158015e-02f, 8.38276073e-02f, 1.55337960e-01f, -3.28454785e-02f, 5.55945262e-02f, 4.09045406e-02f,
  -1.79538161e-01f, -7.55989784e-03f, 6.55521452e-02f, -5.57054579e-02f, 4.49116854e-03f, 9.09062997e-02f, -4.19047661e-03f, 1.94337443e-02f, -3.27655897e-02f, -5.11923470e-02f,
  9.55946073e-02f, -6.97764158e-02f, 3.30213681e-02f, 7.00861961e-02f, -6.57717139e-02f, 3.56077403e-02f, 6.85944036e-02f, 1.03608249e-02f, 2.94684786e-02f, -1.43411577e-01f,
  -2.59409934e-01f, -2.82955050e-01f, 4.36107442e-02f, 2.63680574e-02f, -5.10379001e-02f, -1.31413927e-02f, 5.19707315e-02f, 3.03416494e-02f, -1.18685916e-01f, 6.59641856e-03f,
  -1.05466790e-01f, 7.54587278e-02f, -2.01378718e-01f, 5.27895428e-02f, -3.31777520e-02f, -2.73100082e-02f, 8.60049129e-02f, -7.06801191e-02f, -1.12461448e-01f, -7.94267282e-03f,
  -5.26732542e-02f, 1.16724521e-01f, 1.39574066e-01f, 3.45239528e-02f, 1.20300665e-01f, 3.79371494e-02f, -7.06207901e-02f, 7.67590255e-02f, 1.21186756e-01f, -1.53013347e-02f,
  -1.47154137e-01f, 3.52267474e-01f, 2.18776003e-01f, 7.99162462e-02f, 1.24810703e-01f, 2.40048200e-01f, 2.13365033e-01f, 1.69767767e-01f, 3.49783927e-01f, -4.10201494e-03f,
  -1.42330140e-01f, 1.50289237e-01f, -1.53011546e-01f, 7.10406154e-03f, -2.99266905e-01f, 6.38105720e-02f, 1.94472522e-01f, 1.43297985e-01f, 1.43021598e-01f, -4.96379249e-02f,
  -3.39038894e-02f, -2.07765609e-01f, -2.35970214e-01f, -1.74572408e-01f, 5.04569858e-02f, 2.01007217e-01f, -3.76194805e-01f, -1.07358053e-01f, 1.05138533e-02f, 8.52162391e-02f,
  -2.02277042e-02f, -8.31852481e-03f, 3.03975213e-02f, 5.39759770e-02f, 5.16670719e-02f, 3.47417011e-03f, 5.57659715e-02f, 1.82458982e-02f, -2.93151047e-02f, 3.46651599e-02f,
  -8.50326568e-03f, 1.07720643e-01f, 8.46864060e-02f, -6.89766631e-02f, 3.83688584e-02f, -1.27323493e-02f, -5.97209157e-03f, 1.13893345e-01f, 1.03125265e-02f, -1.21333361e-01f,
  -3.69077511e-02f, -1.43383527e-02f, 9.69307944e-02f, 1.71617851e-01f, -2.21518762e-02f, 1.66802794e-01f, 1.39198780e-01f, -7.02199563e-02f, 1.12931751e-01f, 5.32434620e-02f,
  7.97258392e-02f, 6.34526387e-02f, -2.77324803e-02f, -1.21059371e-02f, 1.55570321e-02f, -6.16679899e-02f, -8.71641859e-02f, -3.00802011e-02f, 1.93648357e-02f, -5.77025004e-02f,
  -2.22034156e-02f, 2.76453923e-02f, -9.80608836e-02f, -6.07150495e-02f, 2.90862303e-02f, 5.97697496e-02f, -4.08405177e-02f, -3.79436091e-02f, 7.58440346e-02f, -8.88792649e-02f,
  1.30878594e-02f, 3.03746331e-02f, 9.07525886e-03f, 4.31572972e-03f, 2.59392988e-03f, 6.38721860e-04f, 9.71116684e-03f, -4.65620831e-02f, -2.05187649e-02f, -6.63261786e-02f,
  2.10535154e-01f, 2.49914855e-01f, 2.15529464e-03f, 6.06012382e-02f, -7.19702989e-02f, -8.98174196e-02f, 5.60826138e-02f, -1.31832063e-02f, 1.20147400e-01f, -2.04777392e-03f,
  7.30574597e-03f, 3.21714953e-02f, -8.42046291e-02f, -3.21951136e-02f, -9.64979529e-02f, 1.44742141e-02f, -3.23242247e-02f, -3.85943800e-02f, 3.44033614e-02f, -1.42369002e-01f,
  -4.98653799e-02f, -4.47941087e-02f, -5.25871217e-02f, -4.80071157e-02f, -3.21754590e-02f, 4.33152989e-02f, 5.64433560e-02f, -5.69936121e-04f, 2.34825779e-02f, -4.74745296e-02f,
  5.10232709e-02f, 3.22602540e-01f, 2.98926592e-01f, 9.78853405e-02f, -1.42547771e-01f, -3.27799529e-01f, -2.43089095e-01f, 2.36714836e-02f, -5.79965562e-02f, 3.53756063e-02f,
  -1.22862160e-01f, 2.82283843e-01f, -4.71565127e-02f, 1.43727437e-01f, -1.77957013e-01f, -1.90708652e-01f, 1.06502034e-01f, 6.20453395e-02f, 6.25082804e-03f, 7.72184283e-02f,
  8.16927403e-02f, -1.12546749e-01f, 1.75650179e-01f, -1.09686114e-01f, 1.29395977e-01f, 1.13801986e-01f, 1.39163494e-01f, 3.07907239e-02f, 1.78645700e-01f, -7.60163181e-03f,
  -1.06485739e-01f, 6.21921644e-02f, 8.27529654e-02f, 6.41046464e-02f, -1.68377105e-02f, 4.41680811e-02f, 1.49679080e-01f, 1.25169260e-02f, -1.38837084e-01f, -1.09006185e-02f,
  4.97757122e-02f, 6.69471771e-02f, 8.79235119e-02f, -1.16179204e-02f, 5.61677217e-02f, 8.50348622e-02f, 3.63586992e-02f, 1.06432047e-02f, 4.03532945e-02f, 1.67993963e-01f,
  3.57856334e-04f, 9.69964638e-02f, 9.84153301e-02f, 8.08425322e-02f, 1.70718789e-01f, -1.58387929e-01f, -3.82722616e-02f, 1.87204823e-01f, -3.67645435e-02f, 1.20484151e-01f,
  6.12163171e-02f, -4.19097096e-02f, -1.10554248e-01f, -3.58993523e-02f, -1.30452842e-01f, -2.87296064e-02f, 1.75583772e-02f, 3.35419402e-02f, -7.99387470e-02f, -8.82608891e-02f,
  -9.08840224e-02f, 1.31878614e-01f, -5.40453754e-02f, -7.40980506e-02f, -4.76222523e-02f, -3.34259719e-02f, -2.25385502e-02f, -4.32760902e-02f, 7.35453740e-02f, 3.12820449e-03f,
  4.00821790e-02f, -4.73788977e-02f, -4.06017415e-02f, 1.64604373e-02f, -2.12110683e-01f, 2.04045475e-02f, 1.73492849e-01f, -5.35178483e-02f, 5.46281636e-02f, 6.58146068e-02f,
  -3.33779380e-02f, 6.88422471e-02f, 5.51459081e-02f, -2.07960606e-02f, -1.74440388e-02f, -3.28348093e-02f, 4.05113585e-02f, 4.14181203e-02f, -2.23551150e-02f, -3.17140222e-02f,
  1.64207697e-01f, 7.04241395e-02f, -6.19694032e-02f, -1.07580043e-01f, 4.35097981e-03f, -2.07153913e-02f, -3.16607356e-02f, -9.97412056e-02f, 1.39407218e-01f, 9.84711051e-02f,
  -1.51539082e-03f, -1.09013328e-02f, 8.92658457e-02f, -9.06969160e-02f, 1.03863627e-01f, 1.18033521e-01f, -9.31044575e-03f, 1.25253260e-01f, 8.02229196e-02f, 1.69353396e-01f,
  -4.99563664e-01f, -1.95348030e-03f, -1.46488741e-01f, 2.01358899e-01f, -1.18154339e-01f, -3.00536416e-02f, 1.28457770e-01f, -1.34526998e-01f, 4.53739241e-02f, 3.02331448e-01f,
  2.48359084e-01f, -4.41112071e-02f, 1.13836661e-01f, 3.47456098e-01f, -2.36755118e-01f, 2.31253654e-01f, 2.06215113e-01f, 1.80578500e-01f, -8.58874917e-02f, -2.53173560e-01f,
  -1.49424762e-01f, 2.10485339e-01f, 7.12868646e-02f, -1.68661997e-01f, -1.10738538e-01f, 2.06537545e-04f, 2.69622654e-02f, -2.51679689e-01f, 1.60803005e-01f, 5.52743897e-02f,
  -2.43182495e-01f, -2.01856047e-01f, -1.13899462e-01f, -1.37940049e-01f, -1.77296937e-01f, -7.69184902e-02f, 1.05252834e-02f, -2.95671318e-02f, 3.96839231e-02f, 7.36147258e-03f,
  -2.53013261e-02f, -7.84025788e-02f, 2.95775551e-02f, 2.13589743e-02f, -3.52296084e-02f, -1.26434192e-02f, 1.34863153e-01f, 5.19754179e-02f, 1.93274412e-02f, -4.26903926e-02f,
  6.77733943e-02f, -2.52809119e-03f, 7.03936741e-02f, 1.45471632e-01f, 2.17398554e-02f, -5.28642796e-02f, 7.26079494e-02f, -2.50667352e-02f, -8.45364779e-02f, -1.57223735e-02f,
  -3.23417932e-02f, 4.29390706e-02f, 5.38555495e-02f, -3.36489044e-02f, -4.04870808e-02f, 1.01642106e-02f, 5.32879829e-02f, 8.34362116e-03f, 7.65763000e-02f, -8.64043236e-02f,
  -5.22786379e-02f, -3.45595152e-04f, -2.02909838e-02f, -3.90050597e-02f, 3.50022726e-02f, -3.40789370e-03f, -3.33019942e-02f, -7.32984692e-02f, 3.30287144e-02f, 3.76089029e-02f,
  -3.40204313e-03f, -4.93463986e-02f, 1.52613014e-01f, 3.11876629e-02f, -6.71009049e-02f, -5.01967333e-02f, -4.63983864e-02f, -2.58761030e-02f, 6.24693260e-02f, -5.69768213e-02f,
  -3.11564803e-01f, -3.40173662e-01f, 3.00744292e-03f, -1.84543654e-01f, -3.04578375e-02f, -9.64242592e-02f, -1.13768809e-01f, 1.39302500e-02f, -6.74845055e-02f, -1.39686227e-01f,
  2.34303251e-02f, 3.40602025e-02f, -9.66309011e-02f, 1.98204163e-02f, -2.31652558e-02f, -1.16935764e-02f, 5.95407113e-02f, -3.40151414e-02f, 3.30682695e-02f, -1.02022536e-01f,
  5.76969795e-03f, -1.12446971e-01f, 5.33883497e-02f, 5.58679476e-02f, 1.28404632e-01f, 8.00572336e-02f, -4.62389104e-02f, -1.11585960e-03f, -2.74201273e-03f, 6.23222999e-02f,
  -3.47118199e-01f, 2.68472463e-01f, -1.96760044e-01f, -3.75616670e-01f, 2.50478685e-01f, 1.52920440e-01f, -1.41947404e-01f, 1.03312336e-01f, -3.41274738e-01f, 1.19586578e-02f,
  -8.32606182e-02f, -1.39531747e-01f, -2.06466038e-02f, -2.79550523e-01f, -4.32092249e-01f, -1.78761110e-01f, -3.22586060e-01f, -1.91184267e-01f, -4.25099581e-02f, -6.00974299e-02f,
  -1.49116218e-01f, 4.12432291e-03f, -1.55666381e-01f, 1.89282566e-01f, 2.56116153e-03f, 1.13835797e-01f, 5.99708520e-02f, 1.87710688e-01f, -6.10074289e-02f, 1.11001227e-02f,
  -4.96147536e-02f, -4.42142971e-02f, 3.71701382e-02f, 3.32857631e-02f, -5.47166169e-03f, 3.98203032e-03f, 1.33981984e-02f, -1.27120875e-03f, -7.13966191e-02f, -1.23754308e-01f,
  8.37786347e-02f, -2.35839002e-02f, -1.23756625e-01f, 2.12348253e-02f, 2.23660711e-02f, -5.29313758e-02f, 2.06280872e-01f, 4.46158499e-02f, -2.92347302e-03f, 2.27113049e-02f,
  -6.99966550e-02f, 4.32646833e-02f, 1.10378861e-01f, -1.01728238e-01f, -1.67281169e-03f, 1.96191799e-02f, 1.15361530e-02f, 1.27548547e-02f, -6.43767230e-03f, -9.95029584e-02f,
  -3.12031247e-03f, 2.20236387e-02f, 5.04640527e-02f, -9.52834040e-02f, 1.33125447e-02f, 6.70726746e-02f, 7.07207620e-02f, 3.44783366e-02f, 4.34700064e-02f, 1.00597441e-01f,
  -2.08879355e-02f, -1.95503030e-02f, -1.30459350e-02f, -2.48555094e-02f, -2.97955684e-02f, 3.13597433e-02f, 2.00170130e-01f, 3.95089500e-02f, -8.99059772e-02f, -1.50246555e-02f,
  4.64416333e-02f, 1.37196541e-01f, -6.55705631e-02f, 9.47839916e-02f, -2.68053375e-02f, 1.14479706e-01f, 7.57630095e-02f, -1.90806352e-02f, -9.33794305e-03f, 5.31622954e-03f,
  1.14131935e-01f, -3.15738958e-03f, 3.53763774e-02f, 7.55265057e-02f, 1.14631113e-02f, 1.47952795e-01f, -6.76254649e-03f, 1.00928314e-01f, -5.51184416e-02f, -8.28622952e-02f,
  2.37859879e-02f, 1.39220497e-02f, 1.78498298e-01f, -9.21777822e-03f, -5.32808229e-02f, 8.52127094e-03f, 1.17809258e-01f, 1.57390479e-02f, 1.24925012e-02f, 5.92839085e-02f,
  3.11386213e-02f, -7.37080304e-03f, -8.22044015e-02f, 4.37558219e-02f, 7.86827207e-02f, 1.17844597e-01f, 1.03864290e-01f, -1.22751333e-02f, 6.57519177e-02f, -7.88843632e-02f,
  4.72507596e-01f, 2.15460539e-01f, 2.10210428e-01f, 2.75110543e-01f, -4.20508981e-02f, 4.34240047e-03f, 1.77289516e-01f, 1.50363490e-01f, 4.09523457e-01f, -6.44286126e-02f,
  -1.66445509e-01f, 1.78024694e-01f, -2.96966791e-01f, 3.29025462e-03f, -2.64892787e-01f, -1.29728049e-01f, 1.24323973e-02f, 1.62110180e-01f, 2.83259694e-02f, 1.12981185e-01f,
  9.95826647e-02f, -3.12941283e-01f, -2.16235384e-01f, -2.85640627e-01f, 1.14776090e-01f, 2.78601378e-01f, -4.13837016e-01f, -5.25078252e-02f, -6.26608804e-02f, -1.80218533e-01f,
  -4.70567048e-02f, 3.19120958e-02f, 1.45223439e-02f, 1.43407602e-02f, 1.21620633e-01f, 3.31968293e-02f, 2.03202143e-02f, -4.84778062e-02f, 9.06834379e-02f, 9.62002054e-02f,
  5.81343286e-02f, 6.37315437e-02f, -2.63895579e-02f, -7.63369054e-02f, 1.04310416e-01f, 1.00800887e-01f, 1.14183165e-01f, 4.08526212e-02f, -1.03825025e-01f, 5.15006036e-02f,
  3.68197681e-03f, 1.35802299e-01f, 1.28473133e-01f, 4.90031615e-02f, 8.99618585e-03f, 8.60545710e-02f, 6.15548044e-02f, -4.42735963e-02f, 3.30742039e-02f, 6.36620894e-02f,
  -1.49161890e-01f, 1.11697018e-02f, 1.29462862e-02f, 7.97702298e-02f, 1.87925920e-02f, 3.81199457e-02f, -9.50066373e-03f, -3.95040326e-02f, 1.40228599e-01f, -3.62796038e-02f,
  6.66948706e-02f, 2.23044995e-02f, 2.86730267e-02f, 1.35043815e-01f, 7.47640282e-02f, 5.89715466e-02f, -5.51839806e-02f, 7.24227428e-02f, 7.69057348e-02f, -4.57023568e-02f,
  -6.69620782e-02f, 6.64725574e-03f, -2.17677951e-02f, 4.29120064e-02f, 1.83692779e-02f, 8.67129266e-02f, -8.24087113e-03f, 3.70203778e-02f, -2.26469450e-02f, -1.21098101e-01f,
  -4.48809154e-02f, -3.38301770e-02f, -5.34610488e-02f, -5.29758483e-02f, -6.50614053e-02f, -4.73909676e-02f, 2.43735742e-02f, 2.59105433e-02f, -2.24419367e-02f, 4.61289324e-02f,
  -3.46492827e-02f, 5.63527718e-02f, -3.42309941e-03f, 2.14411542e-02f, -1.09218709e-01f, -5.87975271e-02f, 1.93469506e-02f, -6.25748187e-02f, -1.17188945e-01f, -1.37471661e-01f,
  -4.73445281e-02f, -8.86305142e-03f, 4.37641367e-02f, 1.03449404e-01f, -2.55466793e-02f, 3.50069106e-02f, 4.48526777e-02f, -5.99000491e-02f, -6.37743920e-02f, -2.61937897e-03f,
  -2.34639794e-01f, 1.78132534e-01f, -1.93515524e-01f, -1.77479312e-01f, -2.04021111e-02f, -2.48472318e-01f, -1.78668946e-01f, -1.63211793e-01f, -1.28951117e-01f, -1.56694800e-02f,
  -1.52593777e-01f, 4.76848260e-02f, 2.09410682e-01f, 3.04606277e-02f, -2.41468579e-01f, 2.87054181e-01f, -8.37047771e-02f, -5.88462949e-02f, 2.03604013e-01f, -1.11349590e-01f,
  6.69142529e-02f, -9.59895831e-03f, 2.61493344e-02f, 1.27901629e-01f, -1.96033582e-01f, -7.27419779e-02f, -1.73613802e-02f, 7.81018883e-02f, -1.90133959e-01f, -7.85813630e-02f,
  -2.17374250e-01f, -2.38040388e-01f, 1.52016226e-02f, -9.57465842e-02f, -1.06095217e-01f, -8.21622368e-03f, -3.24271955e-02f, 1.58262521e-01f, 6.31330349e-03f, -1.97694637e-02f,
  8.68017972e-02f, -3.67369838e-02f, 7.17190430e-02f, 2.23520231e-02f, 4.53069024e-02f, -2.44320855e-02f, 5.42912111e-02f, -1.07788242e-01f, 4.76321764e-02f, 5.42068630e-02f,
  -2.43386142e-02f, 2.79559288e-02f, -5.84607348e-02f, -1.41286589e-02f, 3.93566117e-02f, -7.11970925e-02f, -3.92865390e-02f, 7.74971321e-02f, -7.54412189e-02f, -1.60784975e-01f,
  6.07918985e-02f, 7.04036877e-02f, -3.96820642e-02f, -1.46814203e-02f, 5.18086702e-02f, -2.18612365e-02f, 1.03568388e-02f, -2.86346413e-02f, -5.93480393e-02f, -2.33069416e-02f,
  -7.20048994e-02f, -9.37325731e-02f, 5.19846566e-02f, 1.57379247e-02f, -1.84243396e-02f, -3.21308523e-02f, 8.55622590e-02f, -1.42784327e-01f, -1.17675439e-01f, -4.62974831e-02f,
  -2.34200489e-02f, -8.84728655e-02f, -7.09807426e-02f, 5.21919727e-02f, -3.07348538e-02f, 6.68272525e-02f, 4.60925326e-02f, 3.99339609e-02f, -7.84294009e-02f, -2.79817134e-02f,
  -3.63480717e-01f, -4.48840827e-01f, 9.09407809e-03f, -1.53528750e-01f, -4.52489667e-02f, 6.28773272e-02f, 1.06166415e-01f, 5.14802039e-02f, -1.08219862e-01f, -2.25959551e-02f,
  -1.81165412e-02f, -2.89719310e-02f, -4.39321548e-02f, -2.30662227e-02f, 2.19899695e-02f, 3.40667143e-02f, -2.78704334e-02f, 2.52694841e-02f, -1.87497616e-01f, -2.74550170e-02f,
  4.77147698e-02f, 2.20006760e-02f, -1.08152386e-02f, 4.44558822e-02f, 2.66352724e-02f, -1.34392798e-01f, -9.19623300e-02f, 1.00437507e-01f, 2.12891842e-03f, -1.04524912e-02f,
  -2.97698323e-02f, -1.69974774e-01f, -6.88087642e-02f, 3.06804292e-02f, -3.68715413e-02f, -1.82317913e-01f, -2.97806859e-01f, 1.25519335e-01f, -2.52517313e-01f, -1.51611388e-01f,
  -1.81627609e-02f, -1.35367632e-01f, -2.95408398e-01f, 5.38008846e-02f, 1.31077871e-01f, -2.76412278e-01f, 2.42386863e-01f, 3.00216787e-02f, -8.39490741e-02f, 1.07669130e-01f,
  1.81822866e-01f, 2.34010488e-01f, 9.36983898e-02f, 3.09743494e-01f, 6.49915487e-02f, 2.33918071e-01f, 3.03286403e-01f, 6.64928705e-02f, 3.06431293e-01f, 2.19547570e-01f,
  -1.17695875e-01f, -1.03689894e-01f, 5.29808551e-02f, -6.21030182e-02f, 7.23017156e-02f, 8.09917822e-02f, -2.29672305e-02f, 4.12374400e-02f, -1.52126759e-01f, 6.22704253e-02f,
  3.02816443e-02f, 5.59691414e-02f, 8.38517249e-02f, 2.47913208e-02f, 7.64598325e-02f, 5.31112216e-02f, -2.23335847e-02f, -5.87410182e-02f, -1.07255898e-01f, -7.03723431e-02f,
  -1.18972071e-01f, -1.11626461e-01f, 8.90390873e-02f, 1.10230893e-01f, -7.64986649e-02f, 9.67264734e-03f, -4.03741039e-02f, 8.15729573e-02f, -4.62197373e-03f, 6.60319179e-02f,
  3.67011316e-02f, -2.06918642e-02f, 3.31552885e-02f, -7.07048625e-02f, -6.50613848e-03f, 3.57414968e-02f, -1.31382108e-01f, 1.15940847e-01f, -2.51503997e-02f, -1.01902500e-01f,
  -6.07185215e-02f, -4.76177633e-02f, -9.22122300e-02f, -6.28405809e-02f, 5.24776503e-02f, -4.49873880e-02f, 4.84987125e-02f, 4.66878079e-02f, 5.66134974e-02f, -1.96886882e-02f,
  -1.76606670e-01f, 2.26384308e-02f, -1.03619203e-01f, 1.44795123e-02f, -1.17213637e-01f, -8.14946815e-02f, 1.31785395e-02f, -4.27213311e-03f, 6.60355985e-02f, -6.54775128e-02f,
  3.72040225e-03f, 1.05504595e-01f, -5.61852828e-02f, 1.30356392e-02f, 5.69395982e-02f, -1.92282777e-02f, -1.49374139e-02f, 8.14782009e-02f, -9.66663752e-03f, 2.14129407e-02f,
  9.11786929e-02f, 5.91614395e-02f, -3.07863131e-02f, -4.79135476e-02f, 1.65308863e-01f, -1.21194907e-02f, -1.88006535e-02f, -1.87648479e-02f, 1.21664204e-01f, 9.46503133e-03f,
  -6.35898784e-02f, -6.87203035e-02f, 1.07104056e-01f, -3.59504856e-02f, 2.01855730e-02f, -3.37965810e-03f, 6.53774887e-02f, 9.23218206e-02f, 6.70218319e-02f, -2.25701593e-02f,
  -3.83661598e-01f, 6.44802749e-02f, 5.32016754e-01f, -4.22447145e-01f, 1.65032316e-02f, 3.80497724e-01f, -1.06698321e-02f, 2.42895246e-01f, -7.62487054e-02f, -1.05109945e-01f,
  -9.78176594e-02f, -9.42802131e-02f, 2.44115457e-01f, -2.24052921e-01f, 3.99218678e-01f, 2.08542362e-01f, -1.71781793e-01f, -1.29190072e-01f, -3.48104574e-02f, -2.17452571e-01f,
  -1.55968204e-01f, -3.00940901e-01f, -2.29035281e-02f, -7.37812370e-02f, -1.39893845e-01f, -2.19831452e-01f, -2.89374381e-01f, 2.39917114e-02f, -3.90625559e-02f, 1.66049510e-01f,
  -1.94734186e-01f, -2.19889343e-01f, -2.25907609e-01f, 1.85153082e-01f, 1.16656460e-02f, -5.79956509e-02f, -1.19855724e-01f, -5.13694882e-02f, -1.38722748e-01f, 5.24337962e-02f,
  -7.08114952e-02f, 1.72161028e-01f, -7.85570145e-02f, -2.48429589e-02f, 3.05761397e-02f, -3.81597243e-02f, 9.16897506e-02f, 4.74774279e-02f, 9.61107537e-02f, 2.19355330e-01f,
  1.37408197e-01f, -4.15043347e-02f, 1.47282466e-01f, 4.84954240e-03f, 2.27330595e-01f, -2.75120307e-02f, -1.23180775e-03f, 6.59239218e-02f, -6.57122061e-02f, -2.22870708e-02f,
  5.32463863e-02f, 2.58707814e-02f, 5.61527833e-02f, -1.26782671e-01f, 1.37772681e-02f, 1.58323705e-01f, -1.34423077e-02f, 3.52879055e-02f, 8.81710500e-02f, -3.66130769e-02f,
  -6.40126020e-02f, -7.66927227e-02f, -1.49560615e-01f, 1.88848786e-02f, 9.58502814e-02f, 2.48024380e-03f, -7.83729553e-02f, -3.54548320e-02f, 1.07382230e-01f, 2.38148980e-02f,
  -7.77700096e-02f, 7.78025091e-02f, 7.72366747e-02f, -9.49693099e-02f, 6.82733804e-02f, -4.93012667e-02f, -1.36602595e-02f, 9.09494385e-02f, -1.04671642e-01f, -5.27647138e-02f,
  -2.87117481e-01f, -2.65122950e-01f, -1.84530586e-01f, -7.95704946e-02f, -1.24940783e-01f, -9.66655165e-02f, -1.01992406e-01f, -5.25533669e-02f, -1.17538862e-01f, 1.14935003e-02f,
  2.04144567e-02f, 1.30394488e-04f, -1.66173093e-02f, -2.93347407e-02f, 9.80899781e-02f, -3.94137315e-02f, -1.82967857e-01f, -1.09758794e-01f, -1.45892680e-01f, -1.18422629e-02f,
  -3.04509364e-02f, -1.03483461e-01f, 2.28267998e-01f, -1.60002336e-01f, 6.58119321e-02f, -4.10018489e-02f, 4.42947354e-03f, 6.37462065e-02f, 7.12195486e-02f, 1.04183190e-01f,
  -3.35793316e-01f, 2.27191865e-01f, 1.64369181e-01f, -9.10551846e-03f, -7.20270723e-02f, 4.78231870e-02f, -9.32552293e-02f, 7.96523318e-02f, -2.74545938e-01f, -1.67771392e-02f,
  6.77087009e-02f, -8.30562934e-02f, 1.74479321e-01f, 7.04541802e-02f, 1.98412701e-01f, 2.09232405e-01f, 7.63364956e-02f, 7.00464323e-02f, 2.52060294e-01f, 3.01296115e-01f,
  1.62709564e-01f, -2.58014649e-02f, 4.71427679e-01f, 2.25948960e-01f, 2.03334793e-01f, 1.38689220e-01f, 1.01054780e-01f, 8.62613842e-02f, 1.48983449e-01f, -7.38818944e-02f,
  3.79654169e-02f, -4.46878076e-02f, 1.21308096e-01f, -6.61846921e-02f, 1.27941296e-01f, -9.16152894e-02f, -2.43665259e-02f, -2.69125588e-02f, -1.04162805e-01f, 2.39839032e-03f,
  -6.18297830e-02f, -2.27440279e-02f, -1.03578130e-02f, -6.97462559e-02f, -1.70144260e-01f, -1.10679388e-01f, 1.04595892e-01f, 7.26653077e-03f, 4.55481037e-02f, -1.34078376e-02f,
  7.07236379e-02f, -4.11520600e-02f, -3.24637555e-02f, -4.52262871e-02f, -2.61299834e-02f, -3.96337137e-02f, 3.06041725e-02f, 7.13993311e-02f, -3.43643203e-02f, -5.19013926e-02f,
  -5.82566187e-02f, -1.01617463e-02f, -4.86936308e-02f, 3.69421840e-02f, -3.45642418e-02f, -4.14965264e-02f, -2.50269547e-02f, -2.89397710e-03f, 2.53838170e-02f, 9.75687616e-03f,
  6.39353469e-02f, 1.14483953e-01f, -4.01081890e-02f, -8.06503817e-02f, -4.42085229e-02f, -5.30115478e-02f, 7.25375190e-02f, 5.20006344e-02f, -2.71626795e-03f, 5.14875762e-02f,
  -7.86050782e-02f, -5.04137203e-02f, 7.86434300e-03f, 2.55396813e-02f, 5.52856456e-03f, 2.09088009e-02f, -3.20694447e-02f, 2.55056587e-03f, 1.73779607e-01f, 6.15178384e-02f,
  1.52430013e-01f, 2.58844197e-01f, 5.23875989e-02f, -1.05214484e-01f, 7.59590268e-02f, 1.01979800e-01f, 1.30605875e-02f, 2.71145590e-02f, 1.07393889e-02f, -1.21429609e-02f,
  -7.88203627e-02f, -1.04559094e-01f, 3.12348846e-02f, -1.38658471e-02f, -1.34459049e-01f, 1.15751326e-01f, 4.76535186e-02f, 1.81524437e-02f, 1.00211650e-02f, 6.58882633e-02f,
  2.72330660e-02f, -6.50373623e-02f, -1.44265905e-01f, -4.34978344e-02f, -1.26014441e-01f, -4.86701392e-02f, -2.01861076e-02f, -3.78968753e-02f, 2.10999083e-02f, -5.77753372e-02f,
  1.25465274e-01f, 7.84758627e-02f, -2.25680530e-01f, 1.29637256e-01f, 1.99308187e-01f, 3.79279733e-01f, 1.23449855e-01f, 1.89090893e-01f, 2.64759183e-01f, 5.90017512e-02f,
  1.04214037e-02f, 5.06385416e-02f, -2.54198700e-01f, 3.62795949e-01f, 4.11226273e-01f, -1.43250125e-02f, 4.97362763e-01f, 1.83441788e-01f, 4.79894020e-02f, 1.12875894e-01f,
  4.68158685e-02f, 2.39123359e-01f, -2.58725643e-01f, -2.15174969e-05f, 1.08004911e-02f, -1.91143662e-01f, -2.39747465e-01f, -2.35059410e-01f, 4.05613557e-02f, 2.63014197e-01f,
  2.44775843e-02f, 2.33891401e-02f, -4.90792766e-02f, -1.18197039e-01f, -6.46263361e-02f, -1.64989889e-01f, -1.01097815e-01f, -1.72320176e-02f, -1.63763426e-02f, 1.51808029e-02f,
  -7.30808526e-02f, 5.95007418e-03f, -3.93111892e-02f, 1.69560278e-03f, 1.43518284e-01f, 5.45399711e-02f, -1.38687238e-01f, -1.20570548e-02f, -3.37059633e-03f, -9.67728198e-02f,
  -1.22179985e-01f, -1.52030513e-01f, 7.35994950e-02f, -2.08641104e-02f, -1.13923803e-01f, 1.10636391e-01f, 2.11577695e-02f, 7.30557665e-02f, 3.89186200e-03f, 1.43408149e-01f,
  6.03944883e-02f, 7.97525495e-02f, -6.43586321e-03f, -2.43496988e-02f, 1.01463735e-01f, -2.70998944e-02f, 1.42584890e-01f, 5.43332808e-02f, 7.91947097e-02f, 4.22919877e-02f,
  3.76393460e-02f, 2.70098392e-02f, 1.70929745e-01f, 2.65756436e-02f, 6.60149530e-02f, 1.20716142e-02f, -5.47022140e-03f, -3.51487957e-02f, -7.65450299e-02f, -8.77129138e-02f,
  6.21957108e-02f, 3.87327597e-02f, -2.06135303e-01f, -1.31819144e-01f, 1.42565146e-01f, -1.21969938e-01f, 5.79205118e-02f, 6.85783178e-02f, -2.75818687e-02f, 1.27957752e-02f,
  1.87803641e-01f, 1.80034950e-01f, -9.92077813e-02f, -7.71155581e-02f, -2.31356490e-02f, 8.12972244e-03f, 9.34793577e-02f, 9.77273807e-02f, 3.31727117e-02f, -1.41823608e-02f,
  -1.42078111e-02f, -2.81227604e-02f, -2.93916836e-02f, -8.78699571e-02f, 6.45778105e-02f, 2.13721674e-03f, -5.17655797e-02f, -5.62441908e-03f, 1.02996022e-01f, 1.35694360e-02f,
  -1.26686051e-01f, -3.67848612e-02f, 1.20198861e-01f, 8.85214135e-02f, 5.96659584e-03f, -5.20194955e-02f, 3.03479023e-02f, -1.27444677e-02f, -2.21027136e-02f, 1.33401737e-01f,
  -3.06240201e-01f, 1.62580311e-01f, 1.09764151e-01f, -2.86729693e-01f, 2.25783020e-01f, 1.63869217e-01f, -4.77972142e-02f, 1.29330620e-01f, 1.96644753e-01f, -2.46057585e-01f,
  -2.66080141e-01f, -1.24060549e-01f, 1.99789166e-01f, -1.78278312e-01f, 1.37978405e-01f, 2.67060548e-01f, 4.21406180e-02f, -1.48357049e-01f, 1.28441021e-01f, -1.75934136e-02f,
  1.43088371e-01f, -6.20001666e-02f, -1.97189339e-02f, -1.08075114e-02f, -1.36690736e-01f, -1.46375373e-01f, -1.99053735e-01f, 1.67160675e-01f, -3.13016385e-01f, 9.51792393e-03f,
  -6.63874969e-02f, -3.24930176e-02f, -1.14091836e-01f, 2.18793284e-02f, -1.25331655e-01f, -1.92822553e-02f, 5.69844879e-02f, 3.51052135e-02f, 3.21313590e-02f, -1.67653672e-02f,
  -7.99487531e-02f, 8.36575776e-02f, 9.10672173e-03f, 9.41881463e-02f, 1.02171883e-01f, 6.10652240e-03f, -3.15970294e-02f, -6.51631802e-02f, 2.24722587e-02f, 4.43216227e-02f,
  -7.55727291e-02f, -6.78677261e-02f, -7.78532773e-02f, 5.94348535e-02f, 9.11123827e-02f, -2.79530548e-02f, 4.68860790e-02f, 4.87089455e-02f, 1.55275073e-02f, -3.58997546e-02f,
  1.10323206e-01f, 1.68001175e-01f, 6.19161688e-02f, 2.94843521e-02f, -2.54108626e-02f, -6.65670335e-02f, -1.04159899e-01f, 5.16786333e-03f, -1.94302555e-02f, -1.02621496e-01f,
  -8.93438086e-02f, -3.19658071e-02f, 2.20802173e-01f, 6.53739646e-02f, -1.24551998e-02f, -6.79389434e-03f, 4.40047272e-02f, -7.73360804e-02f, -1.11034453e-01f, -6.38265982e-02f,
  4.15237211e-02f, -4.39142510e-02f, -1.65619120e-01f, 6.69137621e-03f, 1.18632149e-02f, 9.13045108e-02f, 7.01387376e-02f, 9.74706039e-02f, -1.60158295e-02f, 5.41198291e-02f,
  -1.51078748e-02f, 6.20546238e-03f, -3.11861709e-02f, -1.50888681e-01f, 5.50813153e-02f, 4.88256291e-02f, 1.72670528e-01f, 2.28973087e-02f, 1.86456181e-02f, 5.25757000e-02f,
  3.70937400e-02f, -9.20829326e-02f, -7.38176480e-02f, 5.54958545e-02f, 9.45429355e-02f, 9.07815471e-02f, -8.22025314e-02f, -6.78634718e-02f, -7.44632334e-02f, -2.29697730e-02f,
  -7.36852288e-02f, 3.49345095e-02f, 1.47273643e-02f, -1.56878516e-01f, -4.11280245e-03f, -9.50454101e-02f, 5.83746359e-02f, -6.65241526e-03f, -3.94124724e-02f, 7.22169131e-02f,
  -1.79651126e-01f, -6.34302292e-03f, -6.93745539e-02f, -1.94495507e-02f, -1.29968449e-01f, 1.65828332e-01f, 2.70451277e-01f, -1.45522594e-01f, -3.66931170e-01f, 1.30999729e-01f,
  3.32526445e-01f, -1.76331535e-01f, 3.43105167e-01f, 2.98356861e-01f, 6.35250658e-02f, 2.62804776e-01f, 2.16201752e-01f, 2.16370896e-01f, -1.25671914e-02f, 2.59237643e-02f,
  8.45964998e-02f, 2.53064215e-01f, 2.74636716e-01f, 1.87251996e-02f, 5.77177070e-02f, -1.89163059e-01f, 2.02208012e-02f, -4.81019281e-02f, 2.18395423e-02f, 7.06319930e-03f,
  1.62185878e-01f, -2.31716130e-02f, 4.27949764e-02f, -9.57181081e-02f, 5.88982441e-02f, -1.63432807e-02f, 2.38776542e-02f, 2.31586806e-02f, -1.54485211e-01f, -2.26034671e-02f,
  -4.88766916e-02f, -3.97305898e-02f, -4.92774397e-02f, 2.96699870e-02f, -1.21433914e-01f, -4.48301695e-02f, -3.28588933e-02f, 1.26675636e-01f, 3.62309776e-02f, 3.60605717e-02f,
  6.68983385e-02f, 1.60303563e-02f, 9.39077884e-03f, 5.03573455e-02f, -7.86466151e-02f, -6.29317537e-02f, -5.02474159e-02f, -6.17112890e-02f, 8.23238492e-02f, -2.95548346e-02f,
  -8.60701501e-02f, 1.59400210e-01f, 1.11356974e-01f, 6.06209300e-02f, 9.71768498e-02f, 1.35750115e-01f, 1.37648344e-01f, -2.14041490e-02f, -1.67275503e-01f, 1.54760301e-01f,
  -6.03253618e-02f, -8.94323960e-02f, 7.97836483e-02f, -1.42519213e-02f, -7.05099758e-03f, 8.10524970e-02f, 1.06127784e-01f, 1.87414978e-02f, 1.36365751e-02f, -8.18053782e-02f,
  -1.31933028e-02f, -4.66153324e-02f, -2.00828584e-03f, 9.68344361e-02f, 1.23250552e-01f, 6.81787431e-02f, 1.05077773e-02f, -2.32258160e-02f, -2.98544355e-02f, 6.98497295e-02f,
  5.84795289e-02f, -2.58282989e-01f, -8.55377987e-02f, -1.17692262e-01f, 6.00605868e-02f, 6.65447190e-02f, -8.72438960e-03f, -1.17000632e-01f, -9.79274362e-02f, -9.02096331e-02f,
  -7.03468695e-02f, 5.75261656e-03f, 6.23169765e-02f, 2.68537197e-02f, -1.36343598e-01f, 2.45589875e-02f, 7.33243227e-02f, -6.52939023e-04f, -3.87436189e-02f, -5.44450385e-03f,
  2.81176008e-02f, 6.81814030e-02f, -2.62802839e-02f, 4.68147360e-02f, -6.38472661e-02f, 1.25231324e-02f, -1.33331239e-01f, -4.07388769e-02f, 2.08539749e-03f, -7.20139295e-02f,
  1.35286018e-01f, -5.80359623e-02f, -1.90287471e-01f, 4.60774638e-02f, 1.95790995e-02f, -4.24969234e-02f, -1.87189981e-01f, 5.53948358e-02f, -2.54956216e-01f, 4.43483852e-02f,
  9.96146947e-02f, -9.65183135e-03f, -1.52197316e-01f, 2.27334961e-01f, 1.99731842e-01f, -2.84291327e-01f, 2.24471197e-01f, -4.80540423e-03f, -1.73828155e-01f, 1.55788660e-01f,
  4.64272909e-02f, 3.34389329e-01f, -2.85098515e-02f, 2.33168349e-01f, 1.39845461e-01f, 3.71256620e-02f, 3.48423868e-01f, -7.40879551e-02f, 3.15462410e-01f, 9.41294357e-02f,
  -3.24996859e-02f, 3.52983139e-02f, -3.06332540e-02f, -1.19352989e-01f, 7.49436170e-02f, 9.40342471e-02f, 4.53539900e-02f, 8.19700360e-02f, -9.04299468e-02f, -2.60432847e-02f,
  4.36952002e-02f, 5.79547100e-02f, 3.36463526e-02f, 8.43423232e-02f, 4.53460477e-02f, 5.58339879e-02f, -5.39201908e-02f, -2.62036058e-03f, -1.03576094e-01f, 7.81300589e-02f,
  -1.09871410e-01f, -3.43615524e-02f, 6.51359409e-02f, 5.53391203e-02f, -2.91400533e-02f, -2.55340543e-02f, 3.67796272e-02f, 1.61732212e-01f, -7.28576034e-02f, 8.96200910e-02f,
  9.91862938e-02f, 4.16291915e-02f, -7.63201416e-02f, -1.56862944e-01f, -5.64772915e-03f, -5.21631315e-02f, 2.41236594e-02f, -1.05208522e-02f, -4.79357392e-02f, -3.51182483e-02f,
  -5.03311418e-02f, -3.92187474e-04f, 1.54883135e-03f, 8.48032758e-02f, 9.55645442e-02f, -5.67816310e-02f, -4.62289043e-02f, -1.13147199e-02f, 5.55310585e-02f, -6.39606118e-02f,
  -3.15071195e-02f, 6.22161403e-02f, -5.44887148e-02f, 6.59438744e-02f, -5.81873544e-02f, 1.38887927e-01f, 4.90647778e-02f, 9.15335417e-02f, -3.50800641e-02f, -4.94782738e-02f,
  7.89868906e-02f, 7.92236701e-02f, -2.76975110e-02f, -3.50153074e-02f, 2.56470405e-02f, 5.71819879e-02f, -4.00583521e-02f, 1.09587302e-02f, 6.49468601e-02f, 1.44326789e-02f,
  2.52883136e-01f, 1.07691642e-02f, -3.92688811e-02f, 9.36811939e-02f, 1.64276063e-02f, 6.33878857e-02f, -1.24164419e-02f, 8.39974135e-02f, 1.85470153e-02f, 8.91759917e-02f,
  7.57012218e-02f, 6.10207506e-02f, 5.69106871e-03f, -1.04255274e-01f, 5.70068061e-02f, 8.40155110e-02f, 1.42903179e-01f, 5.05731516e-02f, -5.06107584e-02f, -4.46852902e-03f,
  4.28324528e-02f, -1.07711367e-02f, -3.06502640e-01f, -1.66130558e-01f, -6.61444813e-02f, 2.26282120e-01f, 9.69070569e-02f, 3.72001231e-02f, -1.24622636e-01f, 3.30821186e-01f,
  1.70864657e-01f, -5.69584519e-02f, 1.49341762e-01f, 2.57265270e-01f, -5.81301041e-02f, 1.26549989e-01f, 2.03637838e-01f, 1.29831836e-01f, -3.94485518e-02f, 1.13498122e-01f,
  -1.19302772e-01f, 2.78725952e-01f, -1.94521710e-01f, 2.55031705e-01f, 8.20526332e-02f, -1.32980168e-01f, 1.56133756e-01f, -6.19507059e-02f, 9.37610716e-02f, 1.02719944e-02f,
  6.29927665e-02f, 2.67356597e-02f, -3.38191912e-02f, -2.40813904e-02f, -3.68549451e-02f, 5.41742854e-02f, 1.65154096e-02f, -9.97869521e-02f, -1.24678597e-01f, -4.36758855e-03f,
  4.08045985e-02f, 5.80659544e-04f, 3.66239138e-02f, 1.72111914e-02f, 3.04189976e-02f, -5.07464334e-02f, -1.40048265e-01f, -1.29197150e-01f, -1.46696717e-02f, 2.75099240e-02f,
  -5.34987338e-02f, 7.72962254e-03f, -3.35122421e-02f, -1.25597239e-01f, -9.98833328e-02f, -5.52803911e-02f, -4.94005829e-02f, -2.44117044e-02f, 8.31895620e-02f, -4.93575446e-03f,
  1.56344727e-01f, 7.58755133e-02f, 1.35417342e-01f, 5.48837334e-02f, 1.60525776e-02f, -2.43761903e-03f, -7.32035330e-03f, 1.63235702e-02f, -1.43552661e-01f, 6.20235205e-02f,
  -8.26364607e-02f, -6.52917251e-02f, 3.38494219e-02f, 6.32465258e-02f, 5.92922531e-02f, 6.85807690e-02f, -2.26463061e-02f, -2.78179650e-03f, -5.04796356e-02f, -9.53769311e-02f,
  -4.92284037e-02f, 2.83687860e-02f, -4.82889526e-02f, -7.81479776e-02f, 6.15253150e-02f, -8.23273361e-02f, 1.39229819e-01f, 8.77047796e-03f, -9.51403975e-02f, 4.80746068e-02f,
  6.09092452e-02f, 7.53811970e-02f, -5.27358539e-02f, 1.20951198e-02f, -1.17317192e-01f, 1.00660995e-01f, 7.39814416e-02f, 4.73819859e-02f, -7.66990110e-02f, 4.35568281e-02f,
  7.06429854e-02f, -1.07398421e-01f, 7.98862875e-02f, -6.28571436e-02f, -4.30846214e-02f, 1.46306291e-01f, 1.03920668e-01f, -1.37157470e-01f, -2.64912918e-02f, 3.25498246e-02f,
  -3.09535824e-02f, 1.71007797e-01f, -5.43825037e-04f, -5.48838228e-02f, 4.15261043e-03f, 1.19916061e-02f, -9.77464393e-03f, -6.63005630e-04f, -6.29278738e-03f, -6.32457510e-02f,
  -3.51439714e-01f, 3.20933878e-01f, -1.37570769e-01f, -3.06374967e-01f, -2.22517829e-02f, -1.11008614e-01f, -2.69250512e-01f, 9.57084894e-02f, -2.41792407e-02f, -1.19383782e-01f,
  -3.61223854e-02f, -1.59569234e-02f, 2.66741216e-01f, -1.14655003e-01f, -1.18486434e-01f, 1.96274742e-01f, -9.58593264e-02f, -1.34013876e-01f, 1.51625305e-01f, -5.88546433e-02f,
  3.34050953e-02f, -2.01902501e-02f, -1.44643970e-02f, 1.96676880e-01f, -1.85081386e-03f, -1.09768182e-01f, -1.56295031e-01f, 1.59738362e-01f, -1.36680201e-01f, 7.37877563e-02f,
  -2.56767213e-01f, -1.65006950e-01f, -2.04749733e-01f, -5.56462742e-02f, -1.37352988e-01f, -3.00928503e-02f, -6.96075112e-02f, 1.12769706e-02f, -3.99244204e-02f, 7.70471543e-02f,
  1.42458705e-02f, 6.13474958e-02f, 7.83825368e-02f, 1.02500387e-01f, -3.47128697e-02f, -4.11018133e-02f, -3.20165791e-02f, -2.44987067e-02f, 1.50287515e-02f, 4.62217368e-02f,
  8.38899985e-02f, -7.83170946e-03f, -1.46577895e-01f, -1.30756199e-01f, -2.98749525e-02f, -6.09620363e-02f, -1.75013363e-01f, -6.28050193e-02f, -2.30899155e-02f, -3.40325683e-02f,
  7.63754919e-02f, 2.18630210e-02f, 1.26983840e-02f, -4.09031883e-02f, -2.61207819e-02f, 2.86493059e-02f, -3.36316973e-02f, -2.25012153e-02f, -6.34807944e-02f, -7.92785920e-03f,
  -8.16914290e-02f, -8.48322362e-02f, 1.83841251e-02f, -2.21383534e-02f, -1.14481905e-02f, -1.24802161e-02f, -9.46009308e-02f, -1.54063001e-01f, 3.38974185e-02f, 7.45453387e-02f,
  -1.89043209e-02f, 2.83008255e-02f, -4.91224788e-02f, -5.22230715e-02f, 1.16932206e-01f, 3.86976115e-02f, 7.55793452e-02f, 2.17118878e-02f, 1.68246515e-02f, -6.77408800e-02f,
  -3.43652666e-01f, -4.05203342e-01f, -7.93490931e-02f, -2.07398925e-02f, 2.79843323e-02f, 3.51538062e-02f, 8.14249832e-03f, 4.07910608e-02f, -9.36059505e-02f, -6.66556135e-02f,
  9.12790447e-02f, -6.43802211e-02f, 4.13950086e-02f, 3.96574661e-02f, -1.75771546e-02f, -4.52083200e-02f, -8.55018198e-02f, -5.52867539e-02f, -1.44562274e-01f, -1.29019916e-02f,
  -7.79461721e-03f, -2.91138645e-02f, -5.84241711e-02f, 2.42621917e-02f, -9.83458087e-02f, -9.81720984e-02f, -8.49997476e-02f, 6.81536421e-02f, -8.81210640e-02f, 5.90025559e-02f,
  1.47854969e-01f, 3.15526962e-01f, 8.14914256e-02f, 2.55854100e-01f, -2.00300571e-02f, 2.75737762e-01f, 2.51509726e-01f, 3.90713736e-02f, 3.52337271e-01f, 6.08511865e-02f,
  -2.73341294e-02f, 8.47890675e-02f, 1.13079734e-02f, 2.01247856e-01f, -4.40156683e-02f, 1.26857951e-01f, 3.54568690e-01f, 2.46411905e-01f, 1.57252192e-01f, -1.38847521e-02f,
  1.76777691e-01f, 3.30826901e-02f, -2.42791593e-01f, -1.09790683e-01f, 6.23893626e-02f, 2.57227309e-02f, -2.92230397e-01f, -2.09899515e-01f, -6.98600560e-02f, -3.51966657e-02f,
  1.63850822e-02f, 8.61600712e-02f, 2.05289591e-02f, -5.53538557e-03f, 3.12343761e-02f, -1.59066826e-01f, -5.92851937e-02f, -6.70005940e-03f, -6.84385598e-02f, 9.73728523e-02f,
  3.66684720e-02f, -8.97326618e-02f, 1.29532680e-01f, -7.45276585e-02f, 1.21534932e-02f, 6.66584587e-03f, 9.28040668e-02f, -4.60113175e-02f, 1.63959060e-02f, 1.96585767e-02f,
  3.87071702e-03f, 4.12751064e-02f, 7.05477670e-02f, 6.19787946e-02f, 4.18919995e-02f, 6.07677959e-02f, 6.06493615e-02f, -2.42818501e-02f, 5.63309081e-02f, 1.21689856e-01f,
  2.04509497e-02f, 1.72928497e-01f, -1.83052756e-02f, -8.76434594e-02f, 3.80832329e-02f, 3.57011557e-02f, -7.85926953e-02f, -7.34849051e-02f, -2.51018791e-03f, -2.40908861e-02f,
  -8.39373618e-02f, -6.14190772e-02f, 9.44786817e-02f, 5.90151455e-03f, 1.03066139e-01f, -6.24158941e-02f, -5.95858768e-02f, -6.75891265e-02f, 4.41274680e-02f, -1.66925922e-01f,
  -5.57940640e-02f, 3.65537107e-02f, -2.96657044e-03f, -3.77783366e-02f, -5.60322516e-02f, 1.86375547e-02f, 1.55585572e-01f, 1.04962029e-02f, -3.67711708e-02f, -8.68149549e-02f,
  1.26497835e-01f, 2.21031249e-01f, 5.12506161e-03f, -2.69811992e-02f, -4.73573022e-02f, -7.01024011e-02f, 2.76946351e-02f, 1.64471880e-01f, 1.34072945e-01f, -2.41530929e-02f,
  2.54500788e-02f, -5.55368233e-03f, -5.10042720e-02f, -1.59571663e-01f, 1.41234780e-02f, 5.03888950e-02f, -9.43425039e-05f, -4.48433794e-02f, -6.65015653e-02f, -4.05901223e-02f,
  -2.80296858e-02f, 1.07968859e-02f, 7.52832964e-02f, 9.48792696e-02f, 1.07476398e-01f, -2.05126423e-02f, -3.98759060e-02f, 1.89300533e-02f, 4.56739888e-02f, 3.70407440e-02f,
  1.70297951e-01f, 2.03374475e-01f, -3.69575471e-02f, 1.21699125e-01f, -1.78733453e-01f, -1.51769519e-01f, -1.10495895e-01f, 2.73080394e-02f, -2.01690719e-01f, 1.47062734e-01f,
  2.09009960e-01f, -6.09884486e-02f, 2.50211298e-01f, 3.77460241e-01f, 6.32874891e-02f, 1.47922575e-01f, 2.58029580e-01f, 2.37927753e-02f, -8.01573694e-02f, 2.35261559e-01f,
  1.21597067e-01f, 3.19381684e-01f, 1.26149967e-01f, 5.76741248e-02f, 1.84668660e-01f, 1.47945015e-02f, 2.10747480e-01f, 2.77899969e-02f, 1.16065674e-01f, -8.47031642e-03f,
  2.06616912e-02f, 1.19359486e-01f, 6.88381912e-03f, -4.97064851e-02f, 1.06752425e-01f, -7.09791332e-02f, -1.05092516e-02f, 1.55961718e-02f, -8.37217122e-02f, -2.59438939e-02f,
  -3.09512354e-02f, -3.51716392e-02f, 6.50224090e-02f, -6.20599464e-02f, 1.12373196e-02f, -1.41719980e-02f, -1.32287887e-03f, -1.22239001e-01f, -1.87614642e-03f, 1.39932752e-01f,
  7.64285624e-02f, -2.15133857e-02f, 9.84569788e-02f, 1.40176304e-02f, 1.59149598e-02f, -8.62884447e-02f, -5.41874655e-02f, 5.49515672e-02f, 6.25857478e-03f, -7.33115450e-02f,
  6.52873442e-02f, -7.61535391e-02f, 4.95900884e-02f, -1.51974708e-02f, -7.43107498e-02f, 7.24745020e-02f, -2.75118928e-02f, 4.84520495e-02f, -1.30250126e-01f, 1.34863913e-01f,
  -2.90048700e-02f, -5.55867478e-02f, -4.62589366e-03f, 1.52189154e-02f, 1.99259184e-02f, -2.59498712e-02f, -2.57026982e-02f, -1.20694526e-02f, -9.48471541e-04f, -4.76334095e-02f,
  -2.94480622e-02f, 2.30872203e-02f, -9.67720449e-02f, 9.81775578e-03f, -8.15600306e-02f, -2.77040415e-02f, 1.35611489e-01f, 8.86787195e-03f, 2.27601337e-03f, -7.37492964e-02f,
  1.94389578e-02f, 2.14347064e-01f, -8.55825618e-02f, -1.26435012e-01f, 2.46633869e-02f, -4.28794883e-02f, -6.41735494e-02f, 2.61386478e-04f, -4.01597917e-02f, -2.41084844e-02f,
  1.05219983e-01f, -8.85452777e-02f, -2.94466540e-02f, 1.57905538e-02f, -5.19175120e-02f, 4.97515015e-02f, 4.35115322e-02f, -1.07096873e-01f, 8.17668587e-02f, 5.77047691e-02f,
  -8.00443813e-03f, -3.06744669e-02f, -2.49278708e-03f, -1.38587058e-01f, -4.47717048e-02f, 7.67832901e-03f, -6.90079182e-02f, 6.13162713e-03f, 1.15463950e-01f, -1.79238468e-02f,
  2.30341733e-01f, 9.73140672e-02f, -1.93908960e-01f, 7.84702525e-02f, -5.61032444e-02f, 3.86594236e-01f, 2.99945235e-01f, 8.03155825e-02f, 2.81242937e-01f, 2.30407849e-01f,
  9.11528170e-02f, 8.75509903e-02f, -2.37071607e-02f, 3.17887157e-01f, 2.20071658e-01f, 2.33784378e-01f, 4.07429397e-01f, 2.28330642e-01f, 1.95315346e-01f, 4.05126326e-02f,
  1.61975190e-01f, 2.54639804e-01f, -2.86494166e-01f, -1.98148191e-03f, -6.47522584e-02f, -2.14760467e-01f, -2.11466104e-01f, -1.88063309e-01f, -5.32227382e-02f, 5.51323080e-03f,
  2.96072126e-03f, -1.09919216e-02f, -7.26043060e-02f, 1.28597161e-02f, -6.22584336e-02f, -1.52115479e-01f, -5.20062596e-02f, -4.30941768e-02f, -1.30318981e-02f, 3.40141021e-02f,
  -1.79249216e-02f, 7.14693293e-02f, 5.84507957e-02f, -1.88371819e-02f, -1.67200509e-02f, 3.01541314e-02f, -1.62418187e-02f, -7.88542032e-02f, -9.06912833e-02f, -6.34642988e-02f,
  -4.07353193e-02f, 1.98529568e-03f, 4.35762741e-02f, 5.78255206e-02f, -2.44668592e-02f, 9.49757099e-02f, 9.78986174e-02f, 1.06341271e-02f, 4.88530025e-02f, -2.65969653e-02f,
  -3.59455943e-02f, 6.32598102e-02f, -2.56978739e-02f, -3.50027941e-02f, 8.82281363e-03f, -1.21501729e-01f, 8.79258513e-02f, -9.38002989e-02f, -6.11109808e-02f, 1.75787061e-02f,
  -5.32187410e-02f, -8.98737684e-02f, 5.82368188e-02f, 7.71893412e-02f, 1.20915115e-01f, 2.61204150e-02f, -8.90124682e-03f, 9.35725942e-02f, -3.34484950e-02f, 1.20214019e-02f,
  -2.46559158e-02f, 7.94338062e-02f, -2.74979584e-02f, -5.95759749e-02f, 4.69362177e-02f, -1.62661195e-01f, 4.97864559e-02f, -1.91327222e-02f, -7.10699856e-02f, -5.32865934e-02f,
  1.18007436e-01f, 2.20525429e-01f, 2.99913399e-02f, -2.91981194e-02f, -1.60403043e-01f, -6.52460232e-02f, 6.54956996e-02f, 5.52657545e-02f, 1.39826685e-01f, 1.00311503e-01f,
  -1.60583481e-02f, 9.28652957e-02f, -1.06362198e-02f, -3.84683274e-02f, 1.08247630e-01f, 1.06233694e-01f, -3.53527325e-03f, -8.57156962e-02f, -4.39385623e-02f, -6.80361837e-02f,
  -5.10721803e-02f, 5.36062606e-02f, 8.34483001e-03f, 1.05887675e-03f, -2.90092453e-03f, -3.48733515e-02f, 1.04931379e-02f, -6.65403605e-02f, -1.77980643e-02f, 2.79328190e-02f,
  -4.18150753e-01f, 2.59730458e-01f, -2.33417571e-01f, -9.41871777e-02f, 2.41478272e-02f, -1.07030757e-01f, 2.51523722e-02f, 8.19935352e-02f, -1.92000847e-02f, 1.65014356e-01f,
  1.69391409e-02f, -7.42767453e-02f, 2.10361674e-01f, 1.49732009e-01f, -1.94939345e-01f, 9.84987319e-02f, -9.39215273e-02f, -1.12882048e-01f, 1.32709937e-02f, -7.41966888e-02f,
  -7.59133101e-02f, 1.17726997e-01f, -4.78485487e-02f, 1.22614816e-01f, -8.51373225e-02f, -1.39319047e-01f, 1.45128563e-01f, 5.83245791e-02f, -6.17348701e-02f, 1.45652313e-02f,
  -1.58252530e-02f, 1.15252711e-01f, -1.05073646e-01f, -6.42521754e-02f, -1.29945546e-01f, -1.00330956e-01f, -3.24797770e-03f, -2.15280186e-02f, -3.25526185e-02f, -2.14891471e-02f,
  -7.21391514e-02f, 8.10888559e-02f, -1.17467940e-01f, 8.32913965e-02f, -2.08796170e-02f, -3.78534310e-02f, -4.38395143e-02f, -7.22641051e-02f, -4.35242467e-02f, 8.79262313e-02f,
  -1.27248978e-02f, 2.74522899e-04f, -5.26088588e-02f, 1.16358818e-02f, -3.87806334e-02f, -3.44723724e-02f, -3.51195224e-02f, 8.46716911e-02f, 1.49756419e-02f, -7.29727522e-02f,
  -4.61049452e-02f, -7.55523816e-02f, -2.49496140e-02f, 6.20083809e-02f, 4.74411286e-02f, 9.71786603e-02f, -1.60114449e-02f, -5.12339000e-04f, -6.27057031e-02f, -6.02645054e-02f,
  -6.60583675e-02f, -8.26271772e-02f, -8.25313386e-03f, -1.13468608e-02f, -8.87233317e-02f, 2.23877449e-02f, -1.62064612e-01f, -1.31990891e-02f, 1.55010922e-02f, -9.80371162e-02f,
  1.29893094e-01f, -2.24430878e-02f, -1.08176671e-01f, 5.46233431e-02f, 2.32631397e-02f, -1.44758999e-01f, -8.42981786e-02f, 3.06903161e-02f, 5.64277172e-02f, -8.45516622e-02f,
  1.12735711e-01f, 7.65260234e-02f, 6.15315400e-02f, 1.37150288e-02f, -7.61427684e-04f, -9.67686027e-02f, 5.89675345e-02f, -4.30337414e-02f, 2.26375479e-02f, -1.72353778e-02f,
  3.16295744e-04f, -1.75600611e-02f, -7.43893981e-02f, 2.40846784e-05f, -5.21922000e-02f, -1.71793886e-02f, 5.43226898e-02f, -5.46200275e-02f, -4.48885448e-02f, 6.86687231e-02f,
  -6.06347024e-02f, -2.60375906e-02f, -6.75616860e-02f, 1.16863372e-02f, 6.07037991e-02f, -2.25948580e-02f, 2.69359704e-02f, 6.02640249e-02f, -2.05751564e-02f, 2.20267493e-02f,
  3.83549213e-01f, -2.92117596e-01f, 2.56637305e-01f, 2.38292113e-01f, 2.73637116e-01f, 5.35295196e-02f, 3.56264383e-01f, -1.55126408e-01f, 7.69113079e-02f, -2.69435108e-01f,
  -6.01337068e-02f, 4.96767536e-02f, 2.94258334e-02f, -6.10498386e-03f, 1.87576309e-01f, -4.28726673e-02f, -1.54245663e-02f, -1.71211679e-02f, 2.73772012e-02f, 5.07744439e-02f,
  1.49990112e-01f, -2.00032756e-01f, 1.79268390e-01f, -2.91840464e-01f, 1.44962057e-01f, -5.60233602e-03f, -1.09980918e-01f, 1.63951412e-01f, -2.64308810e-01f, 1.64832585e-02f,
  -8.31513405e-02f, -3.63300666e-02f, 1.53213710e-01f, -5.52010052e-02f, -6.60827160e-02f, 5.01623154e-02f, 8.93466547e-02f, 2.26079017e-01f, 4.49638963e-02f, -1.69389825e-02f,
  3.67807224e-02f, 8.49377513e-02f, 2.00202223e-02f, 3.01314946e-02f, 8.90848190e-02f, -6.88523473e-03f, 3.59106064e-02f, -7.78235495e-02f, 3.03849485e-02f, 1.08789705e-01f,
  8.35821405e-02f, 1.25028342e-01f, 1.38531830e-02f, -6.07762150e-02f, 1.15352511e-01f, 5.98054267e-02f, 8.86599422e-02f, 1.48021296e-01f, 2.27878559e-02f, -9.70182568e-03f,
  -2.84257773e-02f, -8.83584768e-02f, 1.01050682e-01f, -9.41147655e-03f, -4.92307842e-02f, 4.52418253e-02f, -5.89830503e-02f, 4.17399071e-02f, -2.73459293e-02f, -7.58368373e-02f,
  -4.87925261e-02f, 1.45866899e-02f, 8.74062628e-02f, 8.51549283e-02f, 3.80478911e-02f, -2.15915311e-02f, -5.63772814e-03f, -5.36631867e-02f, -6.00350462e-02f, 8.89980122e-02f,
  3.15475999e-03f, -7.40952278e-03f, -7.78689012e-02f, 1.43397927e-01f, 2.58472748e-03f, 1.13673501e-01f, 3.64601612e-02f, 4.41904962e-02f, 2.32024230e-02f, 2.02700775e-02f,
  -2.91393816e-01f, -4.03960586e-01f, -6.42075017e-02f, -1.11042321e-01f, -1.84632808e-01f, -1.25092156e-02f, -2.89361272e-02f, 8.09129328e-02f, -1.98039517e-01f, 1.94773097e-02f,
  -3.77688482e-02f, 5.54661192e-02f, -7.24030957e-02f, -1.24173542e-03f, -6.13406375e-02f, 4.71763453e-03f, 6.79310635e-02f, -8.00093189e-02f, -1.61510874e-02f, -3.89234582e-03f,
  2.04607937e-02f, 7.64734764e-03f, 3.88917476e-02f, 8.71345699e-02f, -7.54828975e-02f, 7.39712715e-02f, 5.59369102e-02f, 5.97507805e-02f, -1.71902366e-02f, -2.80546416e-02f,
  -7.59611607e-01f, 3.23284477e-01f, 4.22305204e-02f, 6.07851718e-04f, -2.70894855e-01f, 3.42606664e-01f, 2.39711285e-01f, 4.08974178e-02f, 1.47021055e-01f, 3.32648396e-01f,
  7.07791820e-02f, -1.59806103e-01f, 1.70666561e-01f, 3.55688989e-01f, -1.70647025e-01f, 2.74111927e-01f, 2.28065103e-01f, 1.36743084e-01f, 3.13724838e-02f, -1.85137942e-01f,
  -1.47447318e-01f, 5.65747172e-02f, 1.24085665e-01f, -3.92558873e-02f, -1.98076010e-01f, -1.17982142e-01f, -5.53297140e-02f, -1.75112709e-01f, 5.67349941e-02f, -2.21656580e-02f,
  -2.23468870e-01f, -1.86789185e-01f, -1.69168115e-01f, 6.19469618e-04f, -1.41147017e-01f, -5.88134900e-02f, 1.96926389e-02f, -2.95934081e-02f, -1.15215436e-01f, -6.37182500e-03f,
  -9.81573761e-02f, -6.44492507e-02f, 1.87818557e-02f, -3.41809094e-02f, -8.18053074e-03f, 3.96653861e-02f, -3.04878992e-03f, 1.35437816e-01f, 6.65168315e-02f, 1.95379853e-02f,
  7.82386288e-02f, 4.95395400e-02f, 1.24836989e-01f, 1.83395699e-01f, 9.71502587e-02f, -1.56733231e-03f, 1.00305796e-01f, 3.50034423e-02f, 7.02659264e-02f, 1.38340756e-01f,
  -3.77964862e-02f, 3.89336981e-02f, -8.17372836e-03f, 1.20274303e-02f, 6.24122135e-02f, -1.06743658e-02f, 6.64997101e-02f, -7.74082914e-02f, 5.52103221e-02f, -4.98650372e-02f,
  9.56206422e-05f, -3.25067937e-02f, -1.07526138e-01f, 4.42622118e-02f, 4.13540937e-02f, 1.13754282e-02f, -1.43825457e-01f, -1.06122769e-01f, 3.88952903e-02f, -4.44638683e-03f,
  -4.85945456e-02f, -5.33862971e-03f, 8.25102404e-02f, -6.18343800e-02f, -1.90537181e-02f, -4.26482856e-02f, 9.83519387e-03f, 6.83315024e-02f, 4.08996269e-02f, -6.92805797e-02f,
  -1.64591059e-01f, -8.64426941e-02f, 2.38311291e-02f, -9.01669115e-02f, -3.54247764e-02f, -4.51048240e-02f, -1.09162144e-01f, -1.80833042e-01f, -1.79067273e-02f, 2.35772077e-02f,
  -4.30437811e-02f, -2.73724040e-03f, -1.14504769e-01f, -7.15623945e-02f, 9.96198505e-02f, 6.16710484e-02f, -3.15280408e-02f, -7.58608878e-02f, 5.60457371e-02f, -9.41887647e-02f,
  8.68198741e-03f, -5.23067228e-02f, 1.74800735e-02f, 1.29643157e-02f, 6.83008358e-02f, 4.71190438e-02f, -4.65795398e-02f, -2.95152364e-04f, -6.71816543e-02f, 1.56000346e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.62643597e-01f, 2.76609838e-01f, 2.09985405e-01f, 2.57864386e-01f, 1.70559347e-01f, 2.70199955e-01f, 2.25665674e-01f, 2.65425116e-01f, 1.45655930e-01f, 2.59576440e-01f,
  1.26592755e-01f, 2.14740425e-01f, 2.69297868e-01f, 3.35758507e-01f, 1.64135367e-01f, 1.46055356e-01f, 3.41810912e-01f, 2.76145905e-01f, 9.47374031e-02f, 2.84898281e-01f,
  3.56192917e-01f, 8.14206339e-03f, 2.99449027e-01f, 2.11090654e-01f, 3.30771238e-01f, 2.45531663e-01f, 1.87993556e-01f, 2.25728065e-01f, 2.55521655e-01f, 2.86230445e-01f,
  8.13723132e-02f, 3.83764774e-01f, 1.65552095e-01f, 1.11993980e-02f, 4.74301308e-01f, 2.61050403e-01f, 2.40275815e-01f, 9.47043523e-02f, 2.57805645e-01f, 3.01317900e-01f,
  2.16494113e-01f, 4.37770337e-01f, 1.41131163e-01f, 1.75216138e-01f, 1.71128526e-01f, 2.18843162e-01f, 2.63615936e-01f, 1.53618753e-01f, 2.56408244e-01f, 3.51636797e-01f,
  3.47960174e-01f, 2.81073213e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.00041679e-02f, 2.47433241e-02f, -3.42756137e-02f, -5.46534136e-02f, 8.43405798e-02f, 1.86112151e-02f, -4.68522906e-02f, -1.26021326e-01f, 4.76530716e-02f, -2.40715295e-02f,
  -3.77475172e-02f, -1.35395341e-02f, -1.75045073e-01f, 1.51419029e-01f, 6.11816533e-02f, -1.51316762e-01f, 2.93610115e-02f, -2.67414767e-02f, -1.40953526e-01f, -8.96444544e-02f,
  1.04449943e-01f, -3.10317222e-02f, -1.54284686e-01f, 7.24175721e-02f, -1.35409236e-01f, -2.28177294e-01f, 8.23709369e-02f, 7.72158429e-02f, 1.42719867e-02f, 3.72015908e-02f,
  1.92308724e-01f, 8.04447848e-03f, -7.21514747e-02f, -1.02450870e-01f, 1.19560800e-01f, 1.42689245e-02f, -5.40948771e-02f, 1.43187091e-01f, -1.39763609e-01f, -1.37229159e-01f,
  -1.37439176e-01f, 8.94430503e-02f, -7.39610046e-02f, 7.08503798e-02f, 1.30314808e-02f, 2.21671835e-01f, 1.94719985e-01f, 2.66421121e-02f, 1.30130887e-01f, -1.20356396e-01f,
  4.35038581e-02f, 2.63372939e-02f, -9.46354493e-02f, -2.00711563e-02f, 1.22904114e-03f, -8.61348063e-02f, 7.01741204e-02f, 8.57597888e-02f, -1.02297083e-01f, -6.01435527e-02f,
  -1.39738023e-01f, 8.80270451e-02f, -1.37356343e-02f, 1.32993370e-01f, -1.58445612e-02f, 5.09338081e-02f, 1.08373381e-01f, 2.16969058e-01f, 5.76451980e-02f, 7.95898028e-03f,
  4.73650265e-03f, 1.50650427e-01f, 9.31289196e-02f, 4.92037944e-02f, 1.78238854e-01f, -9.28640366e-02f, 1.85582399e-01f, -1.29198343e-01f, 1.22722186e-01f, 1.89421922e-02f,
  -1.18187770e-01f, 6.24220520e-02f, -8.49468708e-02f, 6.79869875e-02f, -1.86776996e-01f, 1.52616305e-02f, 4.52091396e-02f, 7.08619803e-02f, 1.02773942e-01f, -3.36061567e-02f,
  -1.45020813e-01f, -1.63853243e-01f, -1.04126245e-01f, 7.94759020e-03f, -1.56905502e-02f, 4.90478761e-02f, 1.16454228e-03f, -9.90980417e-02f, -1.71456076e-02f, -9.50059369e-02f,
  1.39223456e-01f, 8.81744456e-03f, 4.99568470e-02f, 8.05239305e-02f, -7.45747834e-02f, 1.04246818e-01f, -2.71527525e-02f, -9.53521058e-02f, 2.90957429e-02f, -1.22408099e-01f,
  -1.91063702e-01f, 7.65531734e-02f, -2.04257712e-01f, 1.48215353e-01f, -9.10424255e-03f, -7.19107017e-02f, 6.16206191e-02f, 5.77889755e-03f, -4.33764234e-02f, 4.00501266e-02f,
  -2.26434931e-01f, -3.83615308e-02f, 5.81963081e-03f, -6.40183389e-02f, -7.51110390e-02f, -1.89951107e-01f, 1.70867905e-01f, -2.29983125e-02f, 1.68206338e-02f, -1.14870705e-01f,
  -3.47241201e-02f, 3.78070287e-02f, -2.51070913e-02f, -2.30922066e-02f, -2.15044096e-01f, -4.45951819e-02f, -7.03363344e-02f, 2.24389508e-01f, -9.17136371e-02f, 3.19220796e-02f,
  -2.24284619e-01f, -7.47642219e-02f, 2.09319443e-01f, -8.37054551e-02f, -1.29432961e-01f, 5.62667027e-02f, -1.10340670e-01f, -3.65661792e-02f, 7.21237585e-02f, 4.84268032e-02f,
  -1.18807964e-01f, 2.78746784e-01f, -7.40590021e-02f, 1.10936919e-02f, 4.27291542e-02f, 1.28450289e-01f, -4.17039022e-02f, 1.40447810e-01f, 1.05682947e-01f, -1.63635015e-01f,
  5.05569875e-02f, 1.72821134e-02f, 1.36989281e-01f, -7.14419335e-02f, 5.39564863e-02f, 1.42697260e-01f, -2.24452522e-02f, -1.27360314e-01f, -1.40490547e-01f, 8.42949748e-02f,
  2.57146303e-02f, 1.37288168e-01f, 1.65655196e-01f, 9.53243375e-02f, -5.26278429e-02f, 9.99091491e-02f, 1.38205737e-01f, -1.03767380e-01f, 5.86593933e-02f, 1.00319818e-01f,
  -4.41667326e-02f, 5.81955956e-03f, 2.18015593e-02f, -2.50441972e-02f, -8.85680243e-02f, 1.32139906e-01f, 1.38522014e-01f, 1.10875465e-01f, -4.04482186e-02f, 6.02545813e-02f,
  -7.83734843e-02f, 1.40894085e-01f, 2.45788060e-02f, -6.53171446e-03f, 3.85941379e-02f, 3.23608471e-03f, 1.11319549e-01f, -2.45519113e-02f, -1.07087441e-01f, 4.69805151e-02f,
  -2.59838738e-02f, 1.28666058e-01f, -8.63228366e-02f, 1.19695932e-01f, -1.54873624e-01f, 1.23844311e-01f, 7.42103904e-02f, -1.87207982e-02f, -1.76837519e-01f, 7.33696530e-03f,
  6.77771540e-03f, 2.19620410e-02f, 6.22956939e-02f, 9.41702574e-02f, 3.07350140e-03f, -1.00226272e-02f, -1.09981775e-01f, -2.86693331e-02f, 1.51644245e-01f, 1.41213223e-01f,
  -1.83876663e-01f, 2.19792709e-01f, 1.02676362e-01f, 5.19006560e-03f, -5.52460514e-02f, 9.27041844e-02f, -8.63823667e-03f, 1.05223119e-01f, 1.03478730e-01f, 6.32530749e-02f,
  9.37706605e-03f, -1.15103677e-01f, -3.63906519e-03f, -5.12197949e-02f, 1.11181391e-02f, -6.66080741e-03f, 5.11977300e-02f, -3.78899509e-03f, 1.49519652e-01f, -1.77336819e-02f,
  4.94483560e-02f, -2.96456460e-02f, -1.59261972e-01f, -4.69170883e-02f, -1.25851175e-02f, -1.07881734e-02f, -1.57193124e-01f, 5.02830818e-02f, 2.27757972e-02f, 7.19589666e-02f,
  9.81737394e-03f, -7.39298835e-02f, 4.68880078e-03f, 5.59061356e-02f, -1.05309702e-01f, -1.76028863e-01f, 3.94739024e-02f, -4.01897989e-02f, 4.24528047e-02f, 2.55597662e-02f,
  -7.25643262e-02f, -3.83052640e-02f, 8.59540850e-02f, 1.00105427e-01f, 1.76842555e-01f, 1.85942993e-01f, 4.16218713e-02f, 5.24446703e-02f, 1.73866674e-02f, 8.57156143e-02f,
  1.70716688e-01f, -6.20998479e-02f, -1.82718009e-01f, 5.85039221e-02f, -9.15888548e-02f, 8.84647295e-02f, 8.56392533e-02f, 8.98346677e-02f, 3.76746915e-02f, -6.21749125e-02f,
  -8.05984885e-02f, 6.72756787e-03f, 6.10938333e-02f, 8.54629874e-02f, -1.10844694e-01f, 9.34685692e-02f, 2.00445861e-01f, 1.06610455e-01f, -1.39054611e-01f, -9.70094949e-02f,
  -4.34966162e-02f, 1.06962249e-01f, 2.29903385e-01f, 1.60661340e-01f, 5.47374710e-02f, 1.62781477e-01f, -1.47766113e-01f, 4.46312968e-03f, -5.86128905e-02f, -8.95856246e-02f,
  1.00451455e-01f, -7.41686821e-02f, 1.03695042e-01f, 7.07214847e-02f, 2.83416361e-02f, 1.10207424e-01f, 5.66632533e-03f, -7.53437504e-02f, -7.23432526e-02f, -1.23424781e-02f,
  -1.30239114e-01f, 8.18075240e-02f, -9.36873853e-02f, 1.03539892e-01f, -3.34286503e-02f, 3.71369161e-02f, -2.50775903e-01f, -7.41942227e-02f, 1.30552933e-01f, -2.41679624e-01f,
  -7.23200664e-02f, -1.25666022e-01f, -5.06821200e-02f, -1.44147381e-01f, -8.31023306e-02f, -4.24592085e-02f, 4.26894464e-02f, -8.35127831e-02f, 1.17957518e-02f, -3.10177132e-02f,
  4.38165069e-02f, 2.82981284e-02f, 2.11659953e-01f, 2.73313224e-02f, -1.06222741e-01f, 1.32275313e-01f, 2.10249662e-01f, -5.51059283e-02f, -1.31571904e-01f, -9.55508500e-02f,
  1.02485806e-01f, -8.77117142e-02f, -1.47271842e-01f, 4.22924981e-02f, -6.43522367e-02f, 9.66215506e-02f, 1.61765024e-01f, 6.79347888e-02f, -1.30626410e-01f, -1.45765424e-01f,
  1.47221953e-01f, 7.83538073e-02f, 2.54795533e-02f, -4.67683524e-02f, 1.92243904e-01f, -6.10012971e-02f, -8.25996026e-02f, -9.18191373e-02f, 1.92352515e-02f, 6.10659309e-02f,
  7.12421685e-02f, -1.52218357e-01f, 2.66908817e-02f, -6.92781806e-02f, -1.00224607e-01f, 1.16496511e-01f, -2.74475925e-02f, -3.30096036e-02f, 1.70753345e-01f, -1.80927813e-01f,
  -2.81524863e-02f, -1.48576554e-02f, -1.04783401e-01f, 1.87052459e-01f, 3.70379463e-02f, -1.46678835e-01f, 1.05995268e-01f, 1.21621788e-01f, 2.92769875e-02f, 2.58892998e-02f,
  1.23253413e-01f, 8.33841711e-02f, 3.93115394e-02f, 1.09353051e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.42557174e-02f, -5.28826974e-02f, -1.46501958e-02f, 1.19945250e-01f, 1.37301221e-01f, 1.53735559e-02f, -1.19692959e-01f, -1.99265689e-01f, -1.87682852e-01f, 1.93000454e-02f,
  -1.26804471e-01f, -3.24606001e-02f, -8.04352313e-02f, -7.78362006e-02f, -2.62450352e-02f, -2.28737071e-02f, 7.51493350e-02f, 1.37359262e-01f, 1.59995228e-01f, -1.25566810e-01f,
  1.64557338e-01f, -2.35873181e-02f, -1.93523809e-01f, 2.97448426e-01f, 5.45022972e-02f, 1.55482799e-01f, 3.17070454e-01f, 1.76551968e-01f, -4.91563231e-02f, 7.34462664e-02f,
  2.70122141e-01f, -1.88844025e-01f, 2.40013823e-01f, 1.64966345e-01f, 3.84913415e-01f, -1.43161505e-01f, -1.14620207e-02f, -7.94008598e-02f, 1.45876944e-01f, -2.34106451e-01f,
  -3.75407375e-02f, -1.69088423e-01f, 1.59018356e-02f, 1.26341462e-01f, -7.41624460e-02f, 1.96716353e-01f, 1.18810467e-01f, -3.87214571e-02f, 2.07789034e-01f, -1.21801183e-01f,
  1.23155184e-01f, 5.01573831e-02f, -1.01210654e-01f, 2.38750577e-01f, 8.35996941e-02f, -1.49157941e-01f, 1.66901071e-02f, 2.51563728e-01f, 3.00292075e-02f, -1.68707892e-02f,
  1.29334241e-01f, 1.39775157e-01f, -1.87675983e-01f, 3.14571917e-01f, -1.11521303e-03f, 3.43823396e-02f, 1.41325012e-01f, -1.84916202e-02f, 2.31618345e-01f, 4.62238267e-02f,
  2.01654255e-01f, -1.08420156e-01f, 2.18942724e-02f, -2.31102273e-01f, -1.16982490e-01f, -1.55653236e-02f, 4.73337695e-02f, 1.09091040e-03f, -7.78513476e-02f, 8.58282670e-02f,
  3.12527150e-01f, -3.20554636e-02f, -1.43206164e-01f, -3.29453200e-02f, -2.87446752e-02f, -1.90448567e-01f, -7.54680857e-02f, -8.18931162e-02f, -3.94712351e-02f, 2.26630573e-03f,
  8.23739767e-02f, 1.09427221e-01f, 7.50202462e-02f, -6.28476366e-02f, 2.23496556e-01f, -1.03039533e-01f, -4.65629809e-02f, -1.97697356e-01f, 2.69069254e-01f, -6.40555769e-02f,
  -1.54235482e-01f, -1.57748908e-02f, -1.86399460e-01f, 9.76033732e-02f, -1.71955168e-01f, 9.19954106e-03f, -8.37154835e-02f, 2.43990362e-01f, -1.10033035e-01f, 1.75689489e-01f,
  1.64271623e-01f, -8.13302621e-02f, 9.85238329e-02f, -8.46630186e-02f, 2.03262538e-01f, 2.21663952e-01f, 1.98988050e-01f, 1.90918773e-01f, 3.27237427e-01f, -1.47906601e-01f,
  9.58391875e-02f, 2.26986527e-01f, 1.48771867e-01f, 1.14512786e-01f, 5.82600124e-02f, 1.78054214e-01f, -2.49698311e-01f, 2.73440570e-01f, -5.06107211e-02f, 9.40111056e-02f,
  4.87012155e-02f, 2.31584564e-01f, 1.40123693e-02f, 1.55241802e-01f, 1.62085429e-01f, 1.09471492e-01f, 1.43240288e-01f, -1.15198987e-02f, 2.13416860e-01f, -1.58931181e-01f,
  1.63642973e-01f, -1.34458229e-01f, 2.82412589e-01f, 8.35932940e-02f, -8.57732147e-02f, 1.40441909e-01f, -4.68168445e-02f, 1.98766738e-01f, -8.59521106e-02f, 2.66769081e-02f,
  8.07982981e-02f, -9.24264640e-02f, -1.92622934e-02f, -1.07136354e-01f, -7.48022497e-02f, 1.00029081e-01f, -3.03898156e-01f, 8.80184025e-02f, 2.66190231e-01f, 2.65024573e-01f,
  -5.14825396e-02f, -1.77862093e-01f, 2.36990601e-01f, -1.04682535e-01f, 2.47997046e-01f, 9.66526642e-02f, 2.26039350e-01f, 2.08244383e-01f, -3.24707001e-01f, 3.38991016e-01f,
  -3.66629623e-02f, 2.11029053e-01f, 8.00415948e-02f, -5.31420968e-02f, 3.03259175e-02f, 3.67862999e-01f, 3.90981771e-02f, 2.10407659e-01f, 2.88300037e-01f, -4.36987393e-02f,
  4.38378006e-02f, 1.44556090e-01f, -1.46093383e-01f, -1.53624490e-01f, -1.95434704e-01f, 2.25271255e-01f, 1.07374482e-01f, -1.26125023e-01f, 3.10958326e-02f, 6.50296547e-03f,
  2.21833289e-01f, 9.16397423e-02f, -1.01972692e-01f, 2.61790361e-02f, 6.98101148e-02f, 2.84297410e-02f, 2.64333785e-02f, 1.57094393e-02f, -1.01196242e-03f, -1.57043695e-01f,
  -6.57416061e-02f, 9.57899261e-03f, 5.69935255e-02f, -1.87381059e-01f, 1.59642667e-01f, -7.85093233e-02f, -1.59683391e-01f, -2.24288866e-01f, -1.54752344e-01f, 4.20339763e-01f,
  2.21947357e-01f, 4.00329560e-01f, 1.58082783e-01f, -1.36861160e-01f, 1.81892022e-01f, 7.44412988e-02f, 1.04062840e-01f, -4.08842303e-02f, -1.30297616e-01f, -4.37561050e-02f,
  2.65645027e-01f, 2.25408711e-02f, 9.50204805e-02f, 9.08804685e-03f, 1.01053245e-01f, 3.37902792e-02f, 1.33590579e-01f, -7.63226897e-02f, 8.55678022e-02f, 3.74710979e-03f,
  2.32463151e-01f, 1.63449049e-02f, 1.16255939e-01f, -1.17889777e-01f, 1.66863903e-01f, -2.35235706e-01f, 6.90041035e-02f, 7.54071474e-02f, 8.53800848e-02f, -2.35618904e-01f,
  1.61520690e-01f, 1.91028625e-01f, 3.00189525e-01f, -4.81582060e-03f, 6.41557574e-02f, 2.23054558e-01f, 1.56589132e-02f, 1.82100400e-01f, -1.41957060e-01f, 2.12418824e-01f,
  -2.94068307e-01f, -1.69740453e-01f, -8.27837512e-02f, -8.90902057e-02f, 9.72434357e-02f, -1.00475013e-01f, 1.45586342e-01f, 5.70498221e-02f, 2.13362530e-01f, 1.34457290e-01f,
  5.34188077e-02f, 8.88184309e-02f, -2.37132329e-02f, 2.65830830e-02f, 8.04657564e-02f, 2.86897629e-01f, -1.32811472e-01f, 7.53471553e-02f, 9.62062851e-02f, 6.96191043e-02f,
  1.50915489e-01f, -3.59087400e-02f, -8.86369124e-02f, 1.60928190e-01f, -2.27454722e-01f, 1.39263587e-03f, -5.53195886e-02f, 1.94096401e-01f, -1.59080699e-01f, -1.58991963e-02f,
  -9.71175879e-02f, 1.95487827e-01f, 2.19802156e-01f, 1.66738659e-01f, -6.33984208e-02f, 1.86487451e-01f, 1.47912920e-01f, 7.45608360e-02f, -1.20049573e-01f, -1.97439134e-01f,
  1.37651980e-01f, 1.58799320e-01f, 1.52934596e-01f, 1.69882178e-01f, -8.64966437e-02f, 1.11483932e-01f, -2.17342094e-01f, 1.07789651e-01f, -7.08337724e-02f, 4.36593480e-02f,
  2.78616995e-01f, -7.15574548e-02f, 1.16230465e-01f, 1.56916544e-01f, 2.11256053e-02f, -2.42758133e-02f, 1.82754070e-01f, 2.21710816e-01f, -7.19888210e-02f, 1.22483291e-01f,
  -7.04525784e-02f, 5.66449277e-02f, -9.84173864e-02f, 2.05423579e-01f, 8.39706063e-02f, 1.80926070e-01f, -1.64254725e-01f, 5.31328693e-02f, 1.54311806e-01f, -6.82222471e-02f,
  1.41319439e-01f, 2.08485067e-01f, 2.71107137e-01f, 2.60802269e-01f, 1.61732554e-01f, 1.88845932e-01f, 8.17339271e-02f, -5.24672903e-02f, 9.53397825e-02f, -1.05189376e-01f,
  -1.84898034e-01f, -2.17923913e-02f, -6.93615228e-02f, 1.71023011e-01f, -1.39781207e-01f, -2.68496331e-02f, 2.53577411e-01f, -7.77656958e-03f, -5.51395789e-02f, 6.84770271e-02f,
  -6.44250438e-02f, -8.95334706e-02f, -9.32056904e-02f, -1.32614762e-01f, 8.29638839e-02f, 4.60552685e-02f, -1.06370240e-01f, 7.06746653e-02f, 1.77781895e-01f, -8.23968649e-02f,
  -7.09525272e-02f, 4.04093973e-02f, -5.14626950e-02f, -9.04562622e-02f, 4.43953350e-02f, 2.01723158e-01f, -1.82761535e-01f, 8.70367978e-03f, -2.08739206e-01f, 3.71159203e-02f,
  1.15688697e-01f, 1.09452181e-01f, -1.56719640e-01f, 2.01582804e-01f, -5.50721027e-02f, -9.23600271e-02f, 3.17837805e-01f, 4.62661609e-02f, 4.44192179e-02f, 1.73598584e-02f,
  2.49982864e-01f, 2.62545764e-01f, 4.14301902e-02f, 1.06283814e-01f, 1.67085081e-01f, -3.72388847e-02f, 1.42625019e-01f, 1.98191516e-02f, -2.90175956e-02f, -1.50998142e-02f,
  1.86470877e-02f, 1.41671405e-03f, 1.07356030e-02f, 1.62245110e-01f, 9.23513994e-02f, 1.51128620e-01f, -1.58423167e-02f, 1.46959886e-01f, 8.89058486e-02f, 1.79903820e-01f,
  -1.94194708e-02f, -1.91327723e-04f, 1.20985527e-02f, 2.94511318e-01f, 1.87673882e-01f, -2.28660107e-01f, 2.84770995e-01f, -1.92009211e-01f, 7.79256299e-02f, 1.99070945e-01f,
  1.02246009e-01f, -1.48146774e-03f, -5.22398464e-02f, -4.10259590e-02f, 1.61226362e-01f, 4.30868119e-02f, -1.62231490e-01f, 2.69577175e-01f, 1.49436623e-01f, 3.16432655e-01f,
  -1.20495453e-01f, 8.32350925e-02f, -2.13578686e-01f, -1.47893563e-01f, -2.77884156e-02f, 3.39542925e-02f, 2.30040997e-01f, 1.81950405e-01f, 2.14341700e-01f, -1.24669775e-01f,
  1.55319721e-01f, -1.16033815e-01f, 1.47347093e-01f, -9.35526472e-03f, 2.17437491e-01f, -1.26603752e-01f, 8.28536898e-02f, 4.38488051e-02f, -4.88326475e-02f, -1.54304266e-01f,
  -8.99392739e-02f, 1.64238319e-01f, 1.55974939e-01f, -1.06023498e-01f, 3.04363668e-01f, -6.51988313e-02f, 5.87502196e-02f, 3.37163240e-01f, -2.00332224e-01f, -1.48212805e-01f,
  -1.54862225e-01f, 2.22730145e-01f, 1.44707412e-01f, -1.10557139e-01f, 5.09515256e-02f, -1.01361893e-01f, 2.53170192e-01f, -4.27170843e-02f, -3.09162028e-03f, -4.06458266e-02f,
  -1.37453645e-01f, -7.41188899e-02f, -1.77197859e-01f, -8.24957490e-02f, 6.39728978e-02f, -3.84235522e-03f, 2.20723990e-02f, 5.73390163e-02f, 2.60380298e-01f, 1.10331958e-03f,
  2.03361943e-01f, 3.98609862e-02f, 6.58909827e-02f, 2.54733652e-01f, 3.49017009e-02f, -2.31314063e-01f, 4.74613085e-02f, -7.44170025e-02f, 2.36197174e-01f, 1.84107572e-02f,
  -4.22652066e-02f, 1.49556190e-01f, -4.36570458e-02f, 8.90357345e-02f, 3.32576394e-01f, 1.46625370e-01f, -2.71118313e-01f, -1.54657727e-02f, 2.80624002e-01f, 1.73527122e-01f,
  1.72975510e-01f, 1.06884554e-01f, 2.60086983e-01f, -8.44052508e-02f, 2.03732073e-01f, -1.77343073e-03f, 3.28211457e-01f, 1.00346357e-01f, 3.46368104e-02f, -9.23094749e-02f,
  2.78905690e-01f, -2.80781370e-02f, -6.41999766e-02f, 2.20291644e-01f, -1.23803662e-02f, 1.55249700e-01f, 1.66459292e-01f, -1.62480205e-01f, -2.06064984e-01f, -7.57523328e-02f,
  -3.73072140e-02f, 8.31971318e-02f, 7.69991577e-02f, -1.91345856e-01f, 4.34731282e-02f, 1.88885182e-01f, 6.50047436e-02f, 6.48327321e-02f, 1.25907108e-01f, 1.53539315e-01f,
  5.82350828e-02f, 6.34134337e-02f, 6.29902035e-02f, 1.05548576e-01f, 1.01295725e-01f, 1.40113607e-01f, -4.88928966e-02f, -4.55729179e-02f, 1.58547815e-02f, 8.69655833e-02f,
  8.75712559e-02f, 4.44217436e-02f, 3.16608965e-01f, -1.34568572e-01f, 3.58353972e-01f, -6.36701882e-02f, 8.94243792e-02f, 1.22569352e-01f, -2.34457657e-01f, 9.20265839e-02f,
  -4.11612689e-02f, 2.00312912e-01f, -1.47849143e-01f, -1.43574983e-01f, 9.37779695e-02f, 2.39394680e-02f, 2.97357917e-01f, 2.24764384e-02f, -5.54384105e-02f, -1.59279227e-01f,
  1.58934489e-01f, -5.77815734e-02f, 2.36307029e-02f, 1.63174912e-01f, 1.75138429e-01f, -1.23758562e-01f, 4.23559779e-03f, -1.15322873e-01f, 2.38567635e-01f, -1.16969533e-01f,
  1.50115743e-01f, 1.06326029e-01f, 6.33017048e-02f, 4.01329771e-02f, 1.21169453e-02f, -1.88937247e-01f, -8.08370411e-02f, -4.83716046e-03f, -1.36363357e-01f, 1.05881602e-01f,
  -1.72877386e-01f, 1.01038568e-01f, 2.13239901e-02f, -2.57831365e-01f, 2.77591757e-02f, -3.06616519e-02f, 3.92035954e-03f, -6.88914582e-02f, -2.28886127e-01f, -9.06336755e-02f,
  -9.51852053e-02f, -2.19608769e-01f, -5.41816242e-02f, -1.54109746e-01f, 4.44778800e-01f, -1.24318935e-01f, 1.73302829e-01f, 1.48502067e-01f, 1.61915809e-01f, -4.80666533e-02f,
  1.15390316e-01f, 1.01539440e-01f, 2.16333002e-01f, 1.74520940e-01f, -2.15693545e-02f, -5.54280169e-02f, -2.45787740e-01f, 1.75124437e-01f, -5.17373830e-02f, 2.56330132e-01f,
  -1.69485375e-01f, 1.30416468e-01f, 3.77246551e-03f, 3.36940773e-02f, 1.60212561e-01f, 4.80961315e-02f, 8.25758502e-02f, 4.66329791e-02f, 2.51790702e-01f, -1.16077721e-01f,
  -3.56944278e-02f, -9.72218346e-03f, 1.20110877e-01f, -2.56206095e-02f, 1.05568700e-01f, 8.14036429e-02f, 7.77126849e-02f, 2.58426338e-01f, -1.37089252e-01f, 1.11067919e-02f,
  -3.04672457e-02f, 2.86765873e-01f, 1.23923294e-01f, 8.75200052e-03f, 1.86076447e-01f, 1.48363784e-01f, -8.42139870e-03f, -2.99069047e-01f, -7.68790916e-02f, -7.28842542e-02f,
  -2.01314129e-02f, 8.01341608e-02f, 1.79675519e-01f, -1.91937372e-01f, 3.80927371e-03f, 3.02650779e-01f, -1.20631300e-01f, 1.35099500e-01f, 1.49598852e-01f, -1.76079094e-01f,
  4.21036892e-02f, 2.53458798e-01f, 2.14149714e-01f, -2.21192241e-02f, -4.83003743e-02f, 2.14688629e-02f, 9.54955220e-02f, 1.88051194e-01f, -1.84082299e-01f, 2.28462406e-02f,
  9.84241664e-02f, 6.49547130e-02f, 1.79927960e-01f, 4.34407108e-02f, 6.19648509e-02f, -8.89599696e-02f, -1.37629420e-01f, -2.20568746e-01f, -6.98942617e-02f, 1.68949485e-01f,
  1.65651008e-01f, -5.69774173e-02f, 1.66230102e-03f, 3.18259224e-02f, -1.61220387e-01f, -9.03990716e-02f, 1.19117461e-03f, 7.74150640e-02f, 3.14257890e-02f, 1.21345438e-01f,
  1.38723046e-01f, -1.48925215e-01f, -1.83536224e-02f, 1.84171930e-01f, 1.12117745e-01f, 2.06877097e-01f, 3.06268316e-02f, 2.83363704e-02f, 3.79754841e-01f, -8.02816302e-02f,
  -5.33869937e-02f, -2.12962121e-01f, 3.49172413e-01f, 1.08901076e-01f, -4.12589945e-02f, -5.45915589e-02f, -1.23363763e-01f, -1.69850010e-02f, 1.40643958e-02f, -8.74944925e-02f,
  3.31935167e-01f, -1.71666648e-02f, 2.32903644e-01f, -2.15809330e-01f, 6.42935336e-02f, 2.06392452e-01f, -1.05379827e-01f, -2.71422833e-01f, 1.04084142e-01f, -1.40022278e-01f,
  6.91943467e-02f, 1.04175180e-01f, -2.74743259e-01f, 9.78762060e-02f, 2.50645429e-01f, 9.96545479e-02f, -3.72421704e-02f, -7.26283565e-02f, -2.06396893e-01f, 8.99173021e-02f,
  -1.68312609e-01f, 1.68078602e-03f, 2.04802200e-01f, 9.93325934e-02f, 9.19661596e-02f, 2.13790417e-01f, 1.08019777e-01f, 3.10957972e-02f, 1.05034836e-01f, 1.87731549e-01f,
  -1.30657926e-01f, 1.37861231e-02f, 5.57700917e-02f, 1.52708799e-01f, -3.91788296e-02f, 1.69753041e-02f, -6.00178279e-02f, 1.49859801e-01f, 2.41489872e-01f, 1.05668843e-01f,
  -9.41695273e-02f, -1.11547597e-01f, 1.82968732e-02f, -6.77216649e-02f, 1.74999908e-01f, 1.85418501e-01f, -1.07931450e-01f, 1.71922401e-01f, 4.96977614e-03f, -1.50458207e-02f,
  1.11506656e-01f, 1.97141752e-01f, -1.41787842e-01f, 1.13402590e-01f, 1.92025155e-01f, 9.78012457e-02f, -9.63913277e-02f, 1.21813349e-01f, 6.15436630e-03f, 1.92471772e-01f,
  1.22671254e-01f, 2.27398515e-01f, 4.51326445e-02f, -1.17424577e-01f, 4.78312857e-02f, 2.49598324e-02f, 1.22927912e-01f, 1.26101568e-01f, 1.92390278e-01f, -1.28584906e-01f,
  1.78336367e-01f, 1.69320762e-01f, 2.23944351e-01f, -4.34121266e-02f, -1.40340552e-01f, -1.36783600e-01f, 5.39724380e-02f, 5.85704111e-02f, -2.28835791e-01f, 1.67104751e-02f,
  8.70735049e-02f, 7.97357112e-02f, 1.16393946e-01f, -1.12425551e-01f, 5.22927903e-02f, 1.11297503e-01f, 9.38351266e-03f, -2.48086393e-01f, 7.66532356e-03f, 5.78322746e-02f,
  9.93357524e-02f, 1.34157613e-01f, 1.66954517e-01f, 6.51425421e-02f, 6.66115507e-02f, -2.29514167e-01f, -1.51145020e-02f, -7.48143345e-02f, -1.99085176e-01f, -5.85339544e-03f,
  -8.55752453e-02f, 2.79220700e-01f, -1.94931701e-01f, -6.82390332e-02f, 2.73285005e-02f, 4.22076583e-02f, -6.11406900e-02f, -2.21299157e-02f, 1.52514070e-01f, -1.16845883e-01f,
  -2.34949723e-01f, 1.59772977e-01f, -2.70780474e-02f, -1.38786852e-01f, 1.58795208e-01f, 1.99126780e-01f, 1.22575037e-01f, 2.43306477e-02f, 1.86630085e-01f, 1.27920151e-01f,
  1.50148019e-01f, -1.99914604e-01f, 1.79461181e-01f, 1.26959413e-01f, -1.30463719e-01f, 9.30918828e-02f, 3.58696817e-03f, -1.02092624e-01f, -2.13035837e-01f, -1.59189194e-01f,
  -3.19986083e-02f, 3.13956514e-02f, -1.46447076e-02f, 2.06432432e-01f, 3.24739069e-01f, -1.23409599e-01f, 1.26286551e-01f, -8.03232938e-02f, 2.04352036e-01f, 1.47655442e-01f,
  -1.82438314e-01f, 1.04289204e-01f, 1.45221338e-01f, -1.05807573e-01f, 1.78834513e-01f, 7.22104236e-02f, -3.86258513e-02f, -3.30102332e-02f, -1.07788369e-01f, 1.88108802e-01f,
  -1.10481553e-01f, 3.17222476e-01f, 4.94102091e-02f, 1.64823264e-01f, 1.74745470e-01f, 2.43207633e-01f, 8.98920372e-02f, 2.38210842e-01f, 1.70695335e-01f, -8.60759467e-02f,
  1.52079120e-01f, 6.60646260e-02f, -1.49925828e-01f, -3.72840315e-02f, 7.48229325e-02f, 1.63212299e-01f, 5.85190430e-02f, -1.88676596e-01f, 4.41201255e-02f, 9.48945880e-02f,
  -1.51988566e-01f, 1.97850987e-02f, 3.15766484e-02f, 6.63395897e-02f, -8.29837993e-02f, -1.00231513e-01f, -1.00947499e-01f, -2.48026013e-01f, -1.25102416e-01f, 1.18907854e-01f,
  2.04544868e-02f, 1.38494521e-01f, 9.08474028e-02f, 2.67760456e-01f, -2.32276231e-01f, -1.25458449e-01f, 6.79414943e-02f, 2.56902307e-01f, 7.60835782e-02f, 2.59348422e-01f,
  -1.16892219e-01f, 4.24787924e-02f, -1.72454029e-01f, 2.42735356e-01f, -1.30337715e-01f, 1.17006309e-01f, 1.64354116e-01f, -1.10564426e-01f, 3.98779839e-01f, 1.88716561e-01f,
  1.12443991e-01f, 8.12181085e-02f, 3.11807543e-01f, 7.34979734e-02f, -1.42224178e-01f, 1.20354608e-01f, -5.77825792e-02f, -5.04019596e-02f, 1.47361858e-02f, 1.22259781e-01f,
  -3.55005711e-02f, -1.04814060e-01f, -1.95487946e-01f, 1.53257838e-02f, 2.38047708e-02f, 1.30317854e-02f, 3.21552008e-02f, -1.41767800e-01f, 3.10091767e-02f, -1.17427401e-01f,
  -2.51506239e-01f, -3.07478998e-02f, 1.59368515e-01f, 1.75937176e-01f, 5.32286279e-02f, 2.63680160e-01f, 2.16802582e-01f, -9.65272263e-03f, 3.80812466e-01f, -2.38860995e-02f,
  6.44510537e-02f, 3.18147928e-01f, -3.06483973e-02f, 1.99697465e-02f, -6.89719170e-02f, 2.19726428e-01f, -7.56889582e-02f, 5.63524105e-02f, 1.04020156e-01f, -1.04150183e-01f,
  -9.22860578e-03f, 1.15069054e-01f, 7.34263435e-02f, 2.25108527e-02f, -1.94490805e-01f, 2.18079872e-02f, 2.35627815e-02f, 2.31516942e-01f, 8.51729289e-02f, -1.11902289e-01f,
  -4.79979031e-02f, -8.04621652e-02f, 3.60429794e-01f, -7.42466524e-02f, 3.72754157e-01f, 3.27333093e-01f, -9.19222087e-02f, -1.50944695e-01f, 8.20052028e-02f, -1.31219193e-01f,
  2.39460170e-02f, 1.99462101e-02f, -1.82491481e-01f, 1.83890715e-01f, -1.71184286e-01f, 2.46261075e-01f, -5.03514111e-02f, 5.51954731e-02f, 1.82449430e-01f, -1.18593551e-01f,
  3.49641517e-02f, 1.02168404e-01f, -8.93675312e-02f, -6.68098684e-03f, 2.05149651e-02f, 8.23213831e-02f, -6.21344410e-02f, -8.06563795e-02f, 1.82557374e-01f, -8.88683349e-02f,
  -8.47093645e-04f, -1.09251309e-02f, 1.52804971e-01f, 9.22002643e-02f, 2.57476848e-02f, 3.08162365e-02f, 1.10391751e-02f, -2.16189981e-01f, -6.76930696e-02f, 1.89990804e-01f,
  -3.39407846e-03f, -1.21386424e-01f, 2.45527998e-01f, -4.44375612e-02f, 9.46140513e-02f, -3.69287908e-01f, -5.84799818e-05f, 2.10547626e-01f, -1.69159248e-01f, 1.85483307e-01f,
  1.67667210e-01f, -5.46475826e-03f, -1.89749673e-02f, -7.75524825e-02f, 1.04046471e-01f, 3.58789042e-02f, 1.32001564e-02f, 1.46726727e-01f, -1.79966372e-02f, 2.01318357e-02f,
  2.88488418e-01f, -1.63879707e-01f, -3.35598434e-03f, 1.27282903e-01f, 2.58504361e-01f, 1.59224421e-02f, 5.24378009e-02f, 1.82096884e-01f, 4.56147492e-02f, 8.93788785e-02f,
  3.17469925e-01f, 2.25822479e-01f, 2.27652714e-01f, 7.43107647e-02f, 2.08455622e-01f, 2.54110489e-02f, 1.47175863e-01f, 8.52061063e-02f, 2.60031164e-01f, -2.18734667e-02f,
  5.02598405e-01f, 6.61120489e-02f, -2.19622314e-01f, 3.07563126e-01f, 8.18397254e-02f, -1.38582289e-01f, -1.01961024e-01f, 3.66552830e-01f, -1.66685194e-01f, 1.82102546e-02f,
  -3.36604297e-01f, -3.71307433e-02f, 1.46322146e-01f, 3.74406725e-02f, 1.04727715e-01f, 1.20320074e-01f, 1.28443033e-01f, 3.91947143e-02f, -7.86002800e-02f, -1.68521553e-02f,
  6.68529868e-02f, -3.55033316e-02f, 5.33096008e-02f, -2.42571142e-02f, 3.25486302e-01f, -1.59245655e-01f, 3.62282127e-01f, -1.35908520e-03f, -7.60153010e-02f, 7.74365887e-02f,
  -1.69976160e-01f, 7.92180225e-02f, 1.12919249e-01f, 1.94657251e-01f, -8.27386901e-02f, -2.05100209e-01f, 2.18659177e-01f, -1.93558000e-02f, 2.75367200e-01f, -5.07489219e-02f,
  -1.81084841e-01f, -1.65280640e-01f, 2.33906016e-01f, -1.46283790e-01f, -1.81699786e-02f, 1.59680560e-01f, 3.00837755e-01f, -7.03158826e-02f, -3.00526898e-02f, -8.57154727e-02f,
  2.04669461e-01f, -5.97723648e-02f, 2.22642645e-01f, 1.00704663e-01f, 1.82878658e-01f, -1.64536219e-02f, 7.15947896e-02f, -1.96184069e-01f, -1.54750496e-01f, 1.11591695e-02f,
  -1.31917700e-01f, 7.37816235e-03f, -2.03060061e-01f, 6.05996512e-02f, -1.90393142e-02f, -2.26255968e-01f, 1.16689719e-01f, -1.83681864e-02f, 3.52471471e-02f, -3.50034274e-02f,
  -1.58789814e-01f, -1.57808781e-01f, -1.70500293e-01f, -2.78448224e-01f, -4.22580279e-02f, -1.77706659e-01f, 4.00251269e-01f, -1.42709434e-01f, 1.11808419e-01f, 1.15180865e-01f,
  1.34531423e-01f, 1.14676416e-01f, 1.48456722e-01f, 2.78827995e-01f, 8.12653825e-02f, 2.44381204e-01f, -2.56793592e-02f, -1.46514326e-02f, -1.07630149e-01f, 4.67910618e-02f,
  2.29165424e-04f, -1.89714879e-01f, 1.25579953e-01f, 1.81710035e-01f, 1.39080435e-01f, 1.60025969e-01f, -8.76855943e-03f, 6.62020519e-02f, -1.21314794e-01f, 1.34881720e-01f,
  1.30397215e-01f, 9.50073078e-02f, 1.30180521e-02f, 1.71836436e-01f, 1.91358719e-02f, -4.44859304e-02f, -2.77730703e-01f, 9.84262079e-02f, 4.79993224e-02f, 9.89600942e-02f,
  -5.02542965e-02f, -3.75011116e-02f, 2.10357890e-01f, 1.53206149e-03f, 2.25261867e-01f, -8.70670453e-02f, 5.39551787e-02f, 1.74556524e-01f, -1.53035760e-01f, -4.94614914e-02f,
  -1.68829039e-01f, 1.35525554e-01f, -6.97579384e-02f, -1.22164384e-01f, -1.30700320e-01f, 1.20606460e-01f, -1.06190696e-01f, 2.38990724e-01f, 1.14721783e-01f, 1.59263790e-01f,
  3.36091608e-01f, 2.09505349e-01f, -1.63050741e-01f, 2.06160545e-02f, 1.77315939e-02f, 1.49303436e-01f, 1.35051593e-01f, 7.94771761e-02f, 2.07126826e-01f, -2.16778833e-02f,
  -4.13466208e-02f, 7.40518942e-02f, 1.21623687e-02f, -9.41818058e-02f, 1.15839668e-01f, -1.10289343e-01f, 6.43837005e-02f, -4.37815525e-02f, -1.11115806e-01f, -4.10140827e-02f,
  -1.90016069e-02f, -4.83248681e-02f, 3.03498283e-02f, 1.02096312e-01f, -7.91335255e-02f, -6.32728729e-03f, 3.05344850e-01f, -1.02097563e-01f, 5.18933684e-02f, 4.76814760e-03f,
  -4.69427630e-02f, 1.08214192e-01f, -4.56807055e-02f, -8.73864070e-02f, -1.31795229e-02f, 4.57381010e-02f, -3.97671387e-02f, -1.99014097e-01f, 2.12130293e-01f, 1.73987910e-01f,
  1.55459628e-01f, 1.18747316e-01f, 1.63134456e-01f, -1.94572031e-01f, 8.07817131e-02f, -2.30291635e-01f, 5.83375730e-02f, -1.02662981e-01f, 1.10832930e-01f, 1.19570374e-01f,
  -8.50709751e-02f, -8.81541893e-02f, -1.99919492e-01f, 3.24583948e-01f, 1.60053119e-01f, 2.44737417e-01f, 2.21625522e-01f, 3.29326361e-01f, 9.74095464e-02f, 1.97946936e-01f,
  1.31150454e-01f, -1.96425840e-01f, 1.25761986e-01f, 1.17754400e-01f, -5.99178076e-02f, -1.32843658e-01f, 2.98126131e-01f, -7.74962232e-02f, 1.44513890e-01f, 7.84461722e-02f,
  1.17057808e-01f, 2.27312207e-01f, -9.11521986e-02f, 1.07493401e-01f, -3.66846770e-02f, 3.10250074e-01f, -8.78468098e-04f, 2.87846737e-02f, 1.17601771e-02f, 1.37144938e-01f,
  9.09127668e-02f, 2.60010250e-02f, -1.56178981e-01f, -1.46750063e-01f, -1.18675329e-01f, 3.88447680e-02f, 6.52648788e-03f, -3.71242575e-02f, -1.16502538e-01f, -2.09324181e-01f,
  -3.34110036e-02f, -4.44320552e-02f, 1.26545159e-02f, 1.46795690e-01f, 1.57205150e-01f, -7.81596676e-02f, 1.89349324e-01f, 9.51246768e-02f, -1.97929829e-01f, 3.44271481e-01f,
  4.07224894e-03f, 6.72898889e-02f, 5.52869309e-03f, 1.93579152e-01f, -9.61441845e-02f, 6.30314052e-02f, 6.73561543e-02f, -2.27603182e-01f, 3.27732772e-01f, 1.93706632e-01f,
  2.55004615e-01f, -9.93473753e-02f, -7.62290182e-03f, -7.65449628e-02f, 4.00339477e-02f, -2.72517174e-01f, 1.12072408e-01f, -9.85096842e-02f, 6.60748854e-02f, 1.59175217e-01f,
  -1.65922251e-02f, 2.52740264e-01f, -1.07372478e-01f, -2.13163625e-03f, 2.17799783e-01f, -1.20497141e-02f, 1.52638674e-01f, 8.36435780e-02f, -3.75558250e-03f, 2.13874117e-01f,
  -1.68112684e-02f, -8.08720663e-02f, 5.55684557e-03f, 1.21985331e-01f, 1.37314111e-01f, -2.41247769e-02f, 6.48252741e-02f, 9.20742378e-02f, -1.28325522e-01f, 3.32151055e-01f,
  2.51953572e-01f, 1.58700421e-01f, 1.73618257e-01f, 8.75223354e-02f, 2.37434968e-01f, 2.43303388e-01f, 5.63207902e-02f, 3.10858488e-01f, 1.11605264e-01f, -3.62513363e-02f,
  -6.03165366e-02f, 1.65856540e-01f, 2.83627808e-02f, 2.13205606e-01f, 1.83427349e-01f, 2.28476807e-01f, 1.09337918e-01f, -2.93052763e-01f, 5.31194955e-02f, -5.66444509e-02f,
  -5.73503934e-02f, 1.62509233e-01f, 1.11845225e-01f, -1.63533480e-03f, 8.93855095e-02f, 1.23218916e-01f, -1.25679657e-01f, -1.44414604e-01f, -1.64578333e-01f, 2.42875926e-02f,
  -2.10284621e-01f, 2.48938948e-01f, -1.62060589e-01f, 7.91115165e-02f, -1.51202440e-01f, 2.08115011e-01f, 1.12842694e-01f, 5.03975339e-02f, -5.18861115e-02f, 2.46809572e-01f,
  6.81714155e-03f, 1.31136253e-01f, -8.85234103e-02f, 2.01369509e-01f, -9.03381854e-02f, -1.80034220e-01f, 1.11168055e-02f, 2.58571088e-01f, -2.48621017e-01f, 4.05068062e-02f,
  -9.89350677e-02f, -3.38819847e-02f, 3.89842272e-01f, -3.57868485e-02f, -1.33192306e-02f, 6.37532696e-02f, 1.11990824e-01f, -1.39440060e-01f, 2.41996959e-01f, -2.74120588e-02f,
  2.61675656e-01f, 1.51783098e-02f, 1.01359682e-02f, -6.45941645e-02f, 5.22763887e-03f, 2.16122866e-01f, 8.73626098e-02f, 3.35949749e-01f, 2.57578731e-01f, 1.03034958e-01f,
  -2.37912565e-01f, -1.83601886e-01f, -5.92403598e-02f, 6.60029575e-02f, 1.59856796e-01f, -2.20768869e-01f, 1.04288571e-01f, -9.86104459e-02f, 2.93521844e-02f, 5.28298318e-02f,
  -1.03671439e-01f, 1.91271901e-01f, -2.97198594e-02f, -6.48494344e-03f, 5.39183468e-02f, 1.09992372e-02f, -1.36256129e-01f, 3.32820773e-01f, 2.14247331e-01f, 2.33342513e-01f,
  -1.89906564e-02f, -2.20264904e-02f, 1.65772602e-01f, 2.90880091e-02f, -8.84626061e-02f, -1.41020566e-01f, 3.62389833e-01f, 1.01892762e-01f, 1.36397958e-01f, -9.18561816e-02f,
  -1.80345345e-02f, -7.92232826e-02f, -1.37258321e-01f, -1.48822069e-01f, 2.03541175e-01f, 5.17981984e-02f, 4.37172204e-02f, 1.16706878e-01f, 5.18830419e-02f, -5.84580824e-02f,
  -3.55776660e-02f, 3.41976546e-02f, 6.98124617e-02f, -1.73936129e-01f, 2.17615530e-01f, -7.62324966e-03f, -3.67684923e-02f, 2.53914565e-01f, 3.03146821e-02f, -6.86544031e-02f,
  -1.46127090e-01f, 1.69593859e-02f, 1.30941421e-02f, -1.21875547e-01f, -1.15622161e-02f, -1.35756791e-01f, 2.51023561e-01f, -1.79478507e-02f, 7.99641162e-02f, 2.49759853e-02f,
  2.01826721e-01f, 1.31970271e-01f, 1.83105558e-01f, 1.49340525e-01f, -1.52036145e-01f, -1.43089527e-02f, 3.32991257e-02f, 1.52861148e-01f, -9.31112170e-02f, -2.37359591e-02f,
  -4.99906950e-02f, 3.07041742e-02f, -2.06606416e-03f, -1.31357670e-01f, -1.67800575e-01f, 3.02284002e-01f, -7.33796209e-02f, 1.19441576e-01f, -1.28238261e-01f, 1.46137223e-01f,
  5.10261282e-02f, 5.63496258e-03f, -4.78250645e-02f, 6.28172010e-02f, 2.08879206e-02f, 1.14230536e-01f, 2.09913984e-01f, 1.34469703e-01f, -2.63022743e-02f, -7.64166862e-02f,
  -6.96024764e-03f, -1.57241747e-01f, -7.87892658e-03f, 1.29065752e-01f, 1.73565328e-01f, 1.77853867e-01f, -9.02365670e-02f, 1.28943399e-01f, -1.23935886e-01f, 1.37644410e-01f,
  -1.06897250e-01f, 1.91743113e-02f, 2.68722743e-01f, -4.35084589e-02f, 1.15526266e-01f, 3.03038023e-03f, -2.67546978e-02f, 1.24955341e-01f, 3.06488931e-01f, 2.69814372e-01f,
  -4.42034900e-02f, 9.62586775e-02f, -1.58510450e-02f, 1.82934210e-01f, -1.74435228e-01f, 1.00062691e-01f, -9.32793170e-02f, 1.25007927e-01f, -2.00219393e-01f, -1.68443304e-02f,
  8.74355957e-02f, 2.82300320e-02f, 4.42569293e-02f, 2.21738920e-01f, 4.97219674e-02f, 3.54538381e-01f, 2.37584367e-01f, 1.50870502e-01f, 1.22289900e-02f, -7.19331950e-02f,
  -4.04490083e-02f, -4.26369570e-02f, -2.68844187e-01f, -2.55585387e-02f, -1.62814647e-01f, 1.07078344e-01f, 1.00441858e-01f, -1.52871192e-01f, 8.04925859e-02f, 1.75603390e-01f,
  -2.93687172e-02f, -5.81760444e-02f, 1.25232443e-01f, 1.16316900e-01f, -1.47454381e-01f, 1.49258032e-01f, 9.45437774e-02f, -1.31859630e-01f, -7.84655958e-02f, 1.77380487e-01f,
  -2.45670415e-02f, 1.84609801e-01f, -4.29590903e-02f, 3.35359797e-02f, -1.09106034e-01f, 7.02733314e-03f, 4.82765511e-02f, 1.38894767e-01f, -5.97374029e-02f, 1.59392804e-01f,
  -2.14361116e-01f, -1.12043783e-01f, -9.69407856e-02f, 1.09549977e-01f, -1.79164350e-01f, 3.40466410e-01f, 1.55227333e-01f, -1.09869219e-01f, 3.12659979e-01f, 1.09722972e-01f,
  1.37480825e-01f, 2.06275731e-02f, 3.12078416e-01f, 1.48882851e-01f, -3.38769443e-02f, 2.82552481e-01f, -7.79800937e-02f, -3.36641930e-02f, 2.04747822e-02f, 8.97893310e-02f,
  7.61040971e-02f, -9.80973765e-02f, -6.62986413e-02f, 5.64839412e-03f, -1.09835140e-01f, 1.35275453e-01f, 1.10269129e-01f, 8.96717515e-03f, 2.46930998e-02f, 8.04101005e-02f,
  3.61775048e-03f, 1.31826792e-02f, 6.87522590e-02f, -2.41694725e-04f, 5.47486469e-02f, 4.26175483e-02f, -1.02670006e-01f, 7.00403899e-02f, -1.48604795e-01f, 3.41249555e-01f,
  2.82839313e-02f, -5.47125563e-02f, -3.05733740e-01f, 2.20845848e-01f, 1.05733082e-01f, 1.39387876e-01f, 1.08490206e-01f, 1.38176754e-01f, 1.45136327e-01f, -7.43486434e-02f,
  -8.73682424e-02f, -6.19400553e-02f, 2.97093004e-01f, 2.58772194e-01f, 6.95297644e-02f, 3.64738613e-01f, 2.34459087e-01f, 2.71441042e-01f, -1.71966642e-01f, -1.31583691e-01f,
  -7.73245818e-04f, 3.50347996e-01f, 2.43011400e-01f, 2.57111937e-01f, 1.99523106e-01f, 1.01588294e-01f, -2.83776194e-01f, -1.54766068e-01f, -2.23837066e-02f, -1.78039074e-02f,
  1.15076073e-01f, 8.59749503e-03f, 3.17033470e-01f, -9.39579606e-02f, 1.03297532e-01f, 2.21234575e-01f, -1.58909068e-01f, -4.45800684e-02f, -8.34942795e-03f, -1.25139236e-01f,
  -1.47648007e-01f, 2.25453094e-01f, 2.75064725e-02f, 5.77683151e-02f, -6.60114363e-02f, -3.07379328e-02f, -1.02877654e-01f, 1.42747745e-01f, -1.04732208e-01f, -2.12630942e-01f,
  2.74654403e-02f, 1.17946863e-01f, 1.35187387e-01f, 8.99799541e-02f, 1.54681846e-01f, 1.53750340e-02f, 4.74957004e-02f, -2.45879173e-01f, -5.16307428e-02f, -4.91087209e-04f,
  -6.94582015e-02f, -1.61034912e-01f, 2.72939354e-02f, 6.45800829e-02f, -2.13334754e-01f, -1.50233805e-01f, 4.86699082e-02f, 2.53903717e-01f, -4.06484492e-02f, 1.20960839e-01f,
  1.04190432e-01f, -1.39759436e-01f, -1.65237933e-01f, 1.06742144e-01f, 1.04225986e-01f, -8.42360556e-02f, 4.48884778e-02f, 1.51767746e-01f, 2.70724952e-01f, 2.37068351e-04f,
  7.18212053e-02f, -8.54206383e-02f, 2.36063391e-01f, -4.34878655e-02f, 1.82657868e-01f, 1.71327367e-02f, -1.21158428e-01f, 4.07404117e-02f, -2.28481274e-02f, -1.04430839e-01f,
  -4.67476770e-02f, -8.81897658e-02f, 1.79251935e-02f, 2.27826834e-02f, -1.69515591e-02f, 3.00115645e-01f, 2.50722826e-01f, -1.51108176e-01f, 2.25467563e-01f, -3.76932346e-03f,
  4.14335221e-01f, 2.46254340e-01f, -2.23566204e-01f, 2.43628189e-01f, 2.00349823e-01f, -1.23032242e-01f, 3.06767859e-02f, 1.69531628e-01f, -1.59009933e-01f, -7.76237249e-02f,
  -1.57772541e-01f, 1.42484576e-01f, 5.22387698e-02f, 3.11503440e-01f, -1.62160862e-02f, 1.47001758e-01f, 1.41500071e-01f, 2.17325523e-01f, 2.48276249e-01f, 2.65401214e-01f,
  -2.32895747e-01f, 6.47299662e-02f, -1.27915861e-02f, -8.25773031e-02f, -1.67250276e-01f, 7.89121985e-02f, -3.79895717e-01f, -1.30027877e-02f, 2.29284614e-01f, -1.32671401e-01f,
  -1.00742400e-01f, 1.37879521e-01f, 1.10905059e-01f, -5.41504808e-02f, -3.51112187e-02f, 2.53145903e-01f, -1.00622112e-02f, 1.87257692e-01f, 3.31641734e-02f, -5.35122992e-04f,
  -2.76989229e-02f, 1.76826596e-01f, -9.55806300e-02f, 2.18856946e-01f, -4.24817093e-02f, -1.42281160e-01f, -1.13430314e-01f, 8.64236206e-02f, 3.83004583e-02f, 6.42911568e-02f,
  1.40047401e-01f, 1.82267278e-01f, -1.15614161e-01f, -1.78023398e-01f, -1.64912745e-01f, 2.23183975e-01f, -1.83602601e-01f, 2.98902720e-01f, 2.30714202e-01f, -1.13362610e-01f,
  7.05241188e-02f, 1.97620884e-01f, -4.27821763e-02f, 5.90959452e-02f, 6.20616227e-03f, 1.50224060e-01f, 1.80993363e-01f, 1.45369023e-01f, -2.25459278e-01f, 4.34490405e-02f,
  5.52146062e-02f, 4.42483509e-03f, 1.97666079e-01f, 6.11975836e-03f, 7.48233050e-02f, -3.02613359e-02f, -1.35686606e-01f, 5.81538230e-02f, 4.15398329e-02f, 2.48475522e-01f,
  5.42276949e-02f, 3.29021186e-01f, 3.63897800e-01f, 2.75153786e-01f, -9.27199647e-02f, -4.15827669e-02f, -4.83278707e-02f, -1.29595205e-01f, -1.59538016e-02f, -6.88984022e-02f,
  -1.12312727e-01f, 5.39750904e-02f, -1.18927643e-01f, 1.54175282e-01f, 1.09614268e-01f, 8.57321918e-02f, 3.22364941e-02f, -9.71937478e-02f, -8.87148008e-02f, -8.01249072e-02f,
  -2.12423906e-01f, 3.16813022e-01f, 2.01814950e-01f, 1.34346798e-01f, -5.68804294e-02f, -2.07745703e-03f, 2.74473637e-01f, -7.23031489e-03f, -1.68517068e-01f, -1.18076447e-02f,
  3.94421220e-01f, -9.42762103e-03f, 5.39738648e-02f, -1.62067920e-01f, -2.02437833e-01f, -1.83702111e-01f, -2.26820976e-01f, -1.64517879e-01f, -5.49384542e-02f, -2.10131910e-02f,
  -1.98517472e-01f, 2.86176443e-01f, -1.57591552e-01f, 1.34690195e-01f, -3.33044939e-02f, 8.18158220e-03f, 1.29349474e-02f, -1.24371573e-01f, 2.18734205e-01f, 2.44847536e-01f,
  8.32124725e-02f, 2.24896431e-01f, 1.86007455e-01f, -1.41228706e-01f, -8.99807783e-04f, -5.48645370e-02f, 1.72432542e-01f, 9.94965527e-03f, 1.44791260e-01f, 6.69738948e-02f,
  1.35399342e-01f, 3.35798383e-01f, 1.87055513e-01f, 2.35312432e-01f, 3.08458179e-01f, 1.20291421e-02f, 2.08492726e-01f, 1.27224386e-01f, 5.33033088e-02f, -7.36204684e-02f,
  1.02077357e-01f, -1.05614968e-01f, 2.01798864e-02f, 2.70506758e-02f, -1.78367607e-02f, 2.67735988e-01f, -1.73256546e-01f, 9.34395194e-02f, 2.18781844e-01f, -1.40634120e-01f,
  7.53721371e-02f, -3.60028706e-02f, -4.37295325e-02f, -1.75115526e-01f, 5.56785651e-02f, -8.93157944e-02f, 1.07504539e-01f, -6.27987832e-03f, -9.80953798e-02f, -1.76239878e-01f,
  4.27250534e-01f, -1.48052111e-01f, -2.41852343e-01f, 2.34954536e-01f, 2.00906962e-01f, -7.44843856e-02f, -2.35778719e-01f, 1.85325027e-01f, -2.29447961e-01f, -3.46081369e-02f,
  -1.88275307e-01f, 1.42749455e-02f, 2.46943861e-01f, 1.31527990e-01f, 3.68503225e-03f, 5.91119491e-02f, -5.71099669e-02f, 8.33343416e-02f, 2.56053716e-01f, -1.54036537e-01f,
  -4.24384512e-02f, -5.31665348e-02f, -6.27486557e-02f, 1.82548851e-01f, -6.29506819e-03f, -2.01117232e-01f, 2.18399525e-01f, 1.46381569e-03f, 1.20077059e-01f, -2.42468297e-01f,
  2.02359669e-02f, 2.51831720e-03f, 3.45811434e-02f, 1.24753363e-01f, 1.61642000e-01f, 5.56740463e-02f, 1.88130885e-01f, 4.31638435e-02f, -4.75601875e-04f, -5.00324331e-02f,
  1.74635500e-01f, 1.37526378e-01f, -2.10767258e-02f, 1.51594594e-01f, -1.25137746e-01f, -1.02380984e-01f, -1.12721130e-01f, 1.34224802e-01f, -2.27448955e-01f, -1.63174450e-01f,
  -4.58256155e-02f, -1.02177458e-02f, 2.05932438e-01f, 1.46183565e-01f, 2.02600852e-01f, 3.00114080e-02f, 7.33008608e-02f, 1.65742278e-01f, 1.29130200e-01f, 2.06719160e-01f,
  5.66767603e-02f, 2.84718484e-01f, 2.91969255e-02f, -1.95142105e-02f, -8.95237476e-02f, -2.19157941e-04f, -9.62418988e-02f, -1.17442362e-01f, 3.17682512e-02f, 1.99801266e-01f,
  1.29117981e-01f, -1.48738977e-02f, 5.87544218e-02f, -1.68390855e-01f, 1.16956644e-01f, 1.51144654e-01f, 2.34659106e-01f, -1.37749821e-01f, 2.02753674e-02f, 2.67578773e-02f,
  -7.10056722e-02f, 8.96498654e-03f, -2.05448627e-01f, -1.27859533e-01f, 9.21495110e-02f, 2.09843278e-01f, 9.12493020e-02f, 2.52766728e-01f, 1.51011378e-01f, 1.17281169e-01f,
  2.93701738e-02f, 1.44630969e-01f, 5.80792129e-02f, 1.35725096e-01f, 8.58453065e-02f, 1.94968253e-01f, 1.37712270e-01f, 5.15776984e-02f, -3.23116899e-01f, 2.16639683e-01f,
  7.34046251e-02f, -4.16308194e-02f, 8.06799307e-02f, -2.07046941e-01f, -1.15266107e-01f, -3.31542455e-02f, 1.57896042e-01f, 2.19935969e-01f, 7.64763653e-02f, -3.97893647e-03f,
  1.14779092e-01f, 1.17180064e-01f, 2.09369808e-01f, 1.61093194e-02f, 1.79800451e-01f, 2.29033366e-01f, 2.41100490e-01f, -2.15503156e-01f, -8.02424699e-02f, 2.31418293e-02f,
  -1.04722701e-01f, -3.79693694e-02f, 1.45619407e-01f, -1.40683100e-01f, -3.15787122e-02f, 1.15062959e-01f, -4.09376211e-02f, -9.22968388e-02f, -2.49395743e-02f, -1.01259962e-01f,
  -8.36175773e-03f, 1.28053814e-01f, 1.56009449e-02f, 1.61257689e-03f, -9.25744846e-02f, 1.57761555e-02f, 1.51534647e-01f, 1.47605138e-02f, 1.18616916e-01f, 2.96603382e-01f,
  9.30945203e-02f, 2.15218976e-01f, 9.34752598e-02f, 2.73975637e-02f, 1.14583606e-02f, 1.30459607e-01f, -1.38095051e-01f, 1.60807699e-01f, -1.12100810e-01f, 7.50974286e-03f,
  -1.01451099e-01f, 3.02046575e-02f, 7.67058581e-02f, -2.50870436e-01f, 1.99043840e-01f, 1.23284832e-01f, 1.87592924e-01f, -3.35709006e-02f, 1.71025813e-01f, 2.40886688e-01f,
  1.59908175e-01f, 2.39073392e-02f, 1.53698027e-01f, 1.45739943e-01f, 1.34544641e-01f, 1.99785233e-01f, 1.77986220e-01f, -7.92372003e-02f, 1.89123631e-01f, 2.32698753e-01f,
  -5.88829033e-02f, 2.17894852e-01f, -1.50409853e-03f, -3.13048720e-01f, 6.87261522e-02f, 1.82793230e-01f, -1.86115339e-01f, 2.34731629e-01f, 2.44151995e-01f, 1.14634223e-01f,
  1.52384952e-01f, -2.14040548e-01f, 6.62288219e-02f, -4.18932214e-02f, 6.89661056e-02f, 1.68645650e-01f, 1.77992165e-01f, -4.90176640e-02f, -3.09364144e-02f, -1.11810140e-01f,
  1.41234100e-01f, 4.76198271e-02f, -1.31543688e-02f, 6.44201785e-02f, 1.83104396e-01f, 7.19304755e-02f, -6.33530170e-02f, -4.78588566e-02f, 1.03907818e-02f, 1.12573422e-01f,
  -5.69912530e-02f, 8.57263803e-02f, 9.13018547e-03f, -5.07608876e-02f, 5.19707128e-02f, 1.89957961e-01f, 1.47201717e-02f, 2.99985349e-01f, -3.90276499e-02f, 5.42315468e-02f,
  1.41615137e-01f, 1.03786491e-01f, 7.64919966e-02f, -7.66978040e-02f, -3.19867700e-01f, -6.38338104e-02f, 1.91236004e-01f, -1.39672637e-01f, 4.79299873e-02f, 8.16021115e-02f,
  2.36519217e-01f, -1.01270765e-01f, 1.83321461e-01f, 2.53316876e-03f, 1.66226089e-01f, 1.10306226e-01f, -1.14382051e-01f, 1.07596494e-01f, -4.05140780e-03f, -8.60746577e-02f,
  2.18594726e-02f, -1.44732282e-01f, -7.68387243e-02f, -6.05829284e-02f, -1.39307424e-01f, -1.63089231e-01f, 7.71872583e-04f, 5.03062457e-02f, 1.70396287e-02f, 6.18896335e-02f,
  -1.13720007e-01f, 6.24321997e-02f, 1.85223043e-01f, -1.32980300e-02f, -9.46888849e-02f, -8.97578597e-02f, 7.61435032e-02f, -5.82725555e-02f, 2.25337952e-01f, 5.20463511e-02f,
  -1.39763832e-01f, 1.37468159e-01f, -1.36387274e-01f, -9.47389603e-02f, 2.60454863e-01f, 1.23845033e-01f, -1.81535892e-02f, 1.38556316e-01f, 2.29399964e-01f, -1.25261292e-01f,
  1.86247468e-01f, 7.99601972e-02f, 1.37587041e-01f, 3.13018041e-04f, 3.06195561e-02f, 1.46670058e-01f, 1.09812766e-01f, -1.77002653e-01f, -6.41231835e-02f, 1.06400177e-01f,
  2.06273437e-01f, 7.92380646e-02f, 9.90005881e-02f, 3.64889532e-01f, 2.00738713e-01f, 8.10227618e-02f, 2.77184606e-01f, -1.89170197e-01f, -1.52134091e-01f, -3.08478195e-02f,
  -1.43493697e-01f, -2.89439894e-02f, 1.51285112e-01f, -1.25257775e-01f, 1.33742481e-01f, 1.28215507e-01f, 8.78443010e-03f, 5.31352423e-02f, 2.74175182e-02f, 2.03431904e-01f,
  -4.70023379e-02f, 1.57226890e-01f, -4.75605903e-03f, 1.54224962e-01f, 3.76688018e-02f, 5.90031631e-02f, 2.34707996e-01f, 1.82555526e-01f, -2.41744876e-01f, -6.79516345e-02f,
  -9.21186358e-02f, -2.82795336e-02f, -1.11037605e-02f, 8.04462582e-02f, -3.06707382e-01f, -5.10242432e-02f, 2.12771386e-01f, -1.02102309e-01f, -5.02587669e-02f, 1.82161934e-03f,
  2.03707188e-01f, -2.08666682e-01f, 1.33909315e-01f, 2.29328781e-01f, -1.16176516e-01f, 3.64405572e-01f, -4.03996371e-02f, 1.37824446e-01f, 5.15780859e-02f, 2.36784831e-01f,
  -6.26499504e-02f, 2.32510760e-01f, 4.59910966e-02f, -1.66343331e-01f, 1.33122146e-01f, 2.54855692e-01f, 3.42673846e-02f, -1.76830918e-01f, 7.50687346e-02f, 1.30984202e-01f,
  4.56133746e-02f, -3.01728457e-01f, -1.04639933e-01f, 1.18594609e-01f, -1.62622500e-02f, 2.84106135e-01f, 1.04738042e-01f, 1.92339733e-01f, -5.68144284e-02f, 1.67378545e-01f,
  6.07744642e-02f, -9.00725871e-02f, -1.19933732e-01f, 2.96101533e-02f, 1.72962446e-03f, 5.86897209e-02f, -1.71886943e-02f, -1.33753181e-01f, 7.94938058e-02f, -2.98193786e-02f,
  2.02728763e-01f, 2.08694395e-02f, 1.04936197e-01f, 8.77571851e-03f, -1.25348210e-01f, 2.74550378e-01f, -2.35125292e-02f, -1.17650125e-02f, 7.89403245e-02f, 1.44814476e-01f,
  1.19447902e-01f, 1.11398168e-01f, -7.16533288e-02f, 9.17151850e-03f, 2.36392524e-02f, 3.09113413e-01f, 3.47558223e-03f, -2.12473702e-02f, -4.07166546e-03f, -2.15502188e-01f,
  1.33971989e-01f, -1.17614150e-01f, -2.96727046e-02f, 2.46583089e-01f, -6.17053993e-02f, 1.10354967e-01f, -1.65944025e-02f, 1.80697143e-01f, -8.94426331e-02f, 1.46310732e-01f,
  8.28070045e-02f, 1.07944079e-01f, -1.02030516e-01f, 9.37522277e-02f, -1.05732657e-01f, 1.56802326e-01f, -4.32040542e-02f, -2.19779179e-01f, 5.66402972e-02f, -2.74237096e-02f,
  6.52925074e-02f, -4.06587347e-02f, 1.46439314e-01f, 1.82962149e-01f, 4.19739960e-03f, 2.34604124e-02f, 2.04660185e-03f, 1.80507123e-01f, 2.48871017e-02f, 9.28298756e-02f,
  2.51035154e-01f, -6.37501106e-02f, -6.85391873e-02f, 1.58542812e-01f, 5.68123013e-02f, 1.45210519e-01f, 4.24416274e-01f, 3.31543118e-01f, -4.87345085e-02f, 1.93941489e-01f,
  -6.92939162e-02f, 5.62121533e-02f, -1.09874062e-01f, 2.37621784e-01f, 8.93161595e-02f, 9.21751410e-02f, -1.84421495e-01f, -9.47920829e-02f, 3.91448550e-02f, 1.41719267e-01f,
  2.34599963e-01f, 3.07593830e-02f, 1.14557825e-01f, -1.54048264e-01f, 9.58542600e-02f, 1.02329962e-01f, -4.22026590e-02f, 1.75353348e-01f, -3.82067785e-02f, -1.63083851e-01f,
  -1.33950278e-01f, 2.47968599e-01f, -2.53494084e-01f, 1.21588171e-01f, 8.70176852e-02f, 1.49991095e-01f, 1.24832757e-01f, -1.38529882e-01f, 2.34871786e-02f, -1.00106835e-01f,
  1.25568854e-02f, 1.28351882e-01f, 5.12519777e-02f, 2.10817382e-02f, -9.76442993e-02f, 2.12812051e-01f, 2.31706768e-01f, 2.94901747e-02f, 7.16273338e-02f, 1.27911448e-01f,
  1.01166330e-01f, 8.50707013e-03f, 5.07903695e-02f, 4.97213304e-02f, -7.14331167e-03f, -1.82334625e-03f, -3.88141535e-02f, 2.93275267e-02f, -1.23939915e-02f, 1.46302938e-01f,
  -2.21704282e-02f, 7.48725012e-02f, 3.68348658e-02f, 2.21716136e-01f, 9.77232587e-03f, 8.52707252e-02f, -1.85560826e-02f, -4.03004549e-02f, -7.51279294e-02f, 1.48711242e-02f,
  -2.31166780e-01f, 8.23627859e-02f, 2.30389148e-01f, -9.19776559e-02f, 1.16661407e-01f, 1.63305148e-01f, 2.19336137e-01f, -7.31962472e-02f, 1.57093823e-01f, 3.15297782e-01f,
  1.71989739e-01f, 1.54648080e-01f, -1.35183543e-01f, 1.92361623e-01f, 2.28187576e-01f, 2.99999446e-01f, 9.78442058e-02f, 2.61174589e-01f, 1.78651318e-01f, 1.29892543e-01f,
  -1.39374912e-01f, 1.69149086e-01f, -6.48153424e-02f, -2.11905949e-02f, -2.04879865e-02f, 2.67160069e-02f, -1.90022931e-01f, 1.97361559e-01f, 1.18356876e-01f, 1.73934847e-01f,
  -8.58393833e-02f, -1.87722132e-01f, 9.72154066e-02f, -1.92101479e-01f, 1.27692565e-01f, 3.09477389e-01f, -3.56136076e-02f, 1.92757234e-01f, 6.61593899e-02f, 1.41199082e-01f,
  1.10353418e-01f, 2.65881270e-02f, -7.71903619e-02f, 6.92037493e-02f, 5.80280535e-02f, 1.63655445e-01f, -2.03646272e-02f, 1.75885171e-01f, 9.45280492e-02f, 1.18327908e-01f,
  -1.92066431e-02f, 1.07930876e-01f, -7.92071596e-02f, -7.50906253e-03f, 1.47668943e-01f, 5.83737716e-02f, -5.84192090e-02f, 1.20123819e-01f, -3.35770696e-02f, -1.98033497e-01f,
  5.82216084e-02f, 1.21970326e-01f, -5.01353815e-02f, -3.46025340e-02f, -1.07271783e-01f, -1.13588318e-01f, 2.04229236e-01f, 1.21045575e-01f, -1.32465899e-01f, -1.98338926e-02f,
  1.14160217e-01f, -8.44273567e-02f, 1.63544446e-01f, -2.10553203e-02f, 1.67001337e-01f, 1.09395117e-01f, 5.16553558e-02f, -2.44214877e-01f, -6.96668923e-02f, 1.11811042e-01f,
  1.65841535e-01f, 1.39223814e-01f, 8.74385908e-02f, 8.45470130e-02f, -6.89963847e-02f, -2.23638207e-01f, -5.20884618e-02f, 2.62402277e-02f, 1.16649251e-02f, -1.60790488e-01f,
  5.17513715e-02f, -7.74896666e-02f, 3.27753983e-02f, -3.43834460e-01f, -3.54505400e-03f, 2.77733386e-01f, -1.03148893e-01f, 2.04314008e-01f, 9.32106152e-02f, -4.80168452e-03f,
  -1.18598782e-01f, -6.16863705e-02f, 2.42339656e-01f, -4.37313989e-02f, 1.17189981e-01f, 5.70569597e-02f, 1.96863636e-01f, 1.14376932e-01f, 3.25505972e-01f, -2.85483479e-01f,
  6.64081126e-02f, -8.63054246e-02f, 2.79276341e-01f, -7.37255141e-02f, -4.18085717e-02f, 1.61146313e-01f, -1.70050427e-01f, -9.98702422e-02f, 1.24929219e-01f, 2.29933932e-01f,
  1.86301380e-01f, 3.14647220e-02f, 2.06415683e-01f, -3.03003881e-02f, 1.32270932e-01f, -1.76111478e-02f, 2.33993575e-01f, -1.77170232e-01f, 4.05552953e-01f, 1.81164041e-01f,
  -1.55273989e-01f, 2.90660322e-01f, 1.28655732e-01f, -1.76322982e-01f, -4.63655107e-02f, 2.31851369e-01f, -1.65360346e-01f, -2.48637572e-02f, -2.39689633e-01f, -3.30748335e-02f,
  1.73501030e-01f, 4.55414541e-02f, 1.52902901e-01f, -6.94763735e-02f, 1.30781680e-01f, -2.35826105e-01f, 1.37379616e-01f, -3.21725756e-02f, 2.53104180e-01f, 1.80473164e-01f,
  2.75303740e-02f, -1.51746362e-01f, -1.16452605e-01f, 1.01538725e-01f, -8.25574547e-02f, 1.19919971e-01f, -1.17786169e-01f, 7.01523274e-02f, 2.69058555e-01f, 1.32494718e-01f,
  1.71654597e-01f, 2.11636588e-01f, -1.63562030e-01f, -7.87126124e-02f, 2.23251119e-01f, -2.40034804e-01f, -1.03544682e-01f, 3.64271067e-02f, 2.38336972e-03f, -2.09633559e-01f,
  2.45603532e-01f, -9.73013043e-02f, -5.21356016e-02f, 1.26439005e-01f, 3.02256867e-02f, -1.52395526e-02f, -1.49369344e-01f, 8.36905092e-02f, 1.03937507e-01f, -5.40877506e-02f,
  1.39618888e-01f, 2.86087364e-01f, 1.48390159e-02f, -5.56624308e-02f, 1.41873267e-02f, -1.31344795e-01f, 9.26543679e-03f, 2.53231198e-01f, 1.09732114e-02f, -2.81482905e-01f,
  -3.74971586e-03f, 2.78295815e-01f, -3.56421955e-02f, 2.70418882e-01f, 2.66070068e-01f, -2.74512172e-01f, 3.19448292e-01f, 2.16793045e-01f, 2.43644312e-01f, 5.69639765e-02f,
  -3.27741168e-02f, 2.15998739e-01f, 8.82789567e-02f, 4.64892574e-02f, -1.88321233e-01f, 2.72405028e-01f, 1.19896792e-01f, 8.13962743e-02f, 1.31281704e-01f, 1.76193550e-01f,
  1.31861970e-01f, 1.91382036e-01f, 6.61683129e-03f, 1.54423103e-01f, 7.85897374e-02f, 1.75508380e-01f, -6.21174648e-02f, 6.85129464e-02f, 6.41319081e-02f, -1.50584616e-03f,
  2.46582285e-01f, 1.57358274e-02f, 4.74769101e-02f, 4.90978993e-02f, -1.05177395e-01f, 8.96060169e-02f, -1.14577815e-01f, 1.65088743e-01f, 2.76629012e-02f, -9.98087134e-03f,
  -8.04398861e-03f, 6.00830205e-02f, -7.89528638e-02f, -7.39829391e-02f, -6.26191199e-02f, 1.31056115e-01f, -6.44993484e-02f, 2.16212720e-02f, -9.72270072e-02f, -7.14953169e-02f,
  7.06501817e-03f, 1.17435955e-01f, 6.95631132e-02f, 1.24952972e-01f, -1.06220171e-01f, 1.73492908e-01f, 1.06123695e-02f, 2.95345217e-01f, -4.85939980e-02f, 9.24639106e-02f,
  2.17971832e-01f, -1.00986950e-01f, -1.34957954e-02f, 1.96862042e-01f, -1.28936216e-01f, 1.25345364e-01f, 2.42912441e-01f, 1.85983434e-01f, 3.23999859e-02f, 4.38851900e-02f,
  1.10016456e-02f, 7.52601177e-02f, 6.77155182e-02f, 3.48731913e-02f, 2.06850879e-02f, 1.80888534e-01f, -2.18919460e-02f, -1.10364817e-01f, 1.15109771e-01f, 1.70890614e-02f,
  6.84681674e-03f, 8.08827486e-03f, 9.99424458e-02f, 1.89384311e-01f, 8.84967744e-02f, 7.72093311e-02f, -1.58447027e-02f, -1.02109499e-01f, 5.43191796e-03f, 2.85296496e-02f,
  1.19331844e-01f, -1.74486816e-01f, 2.54008263e-01f, -9.39055756e-02f, -1.04108334e-01f, 4.93180342e-02f, -1.52405780e-02f, 3.77559721e-01f, 3.57351601e-02f, 2.43038177e-01f,
  -7.56046548e-02f, -1.24198161e-01f, -4.15921248e-02f, 1.62978023e-01f, 2.06008628e-01f, 1.99278891e-01f, -1.31080011e-02f, 1.49765434e-02f, 2.74167210e-01f, 1.67414639e-02f,
  2.86308452e-02f, 4.30662706e-02f, 2.39492789e-01f, -6.50061145e-02f, 1.22754894e-01f, -1.13839500e-01f, 1.39923915e-01f, -7.68157169e-02f, 1.46935597e-01f, 1.05527557e-01f,
  -7.18701854e-02f, -7.22030625e-02f, -4.51532677e-02f, -3.90615836e-02f, 3.89294140e-02f, 1.38165310e-01f, -2.71121003e-02f, -1.56910233e-02f, 2.45331265e-02f, 1.45419806e-01f,
  3.03719819e-01f, 2.10513756e-01f, -7.36232996e-02f, 1.86800674e-01f, 2.02870563e-01f, 7.92638771e-03f, -1.95279524e-01f, 6.94494322e-02f, 1.50091741e-02f, 2.18282975e-02f,
  -4.60378528e-02f, -6.11310340e-02f, 2.89077878e-01f, 2.45063916e-01f, 4.55882400e-02f, -7.60275051e-02f, 2.52596643e-02f, -1.57539383e-01f, -8.82114172e-02f, -5.39353415e-02f,
  -7.19207749e-02f, 5.25019504e-02f, -7.55105838e-02f, 2.96386063e-01f, -1.14739701e-01f, 1.15084015e-01f, -1.04024090e-01f, 5.84231094e-02f, -3.90942441e-03f, -9.55423340e-02f,
  -2.21399620e-01f, 9.02364403e-02f, 3.42157632e-02f, 1.00114662e-02f, 2.56965190e-01f, 2.25317836e-01f, 3.43313403e-02f, 2.88200304e-02f, -1.70928359e-01f, 1.83924347e-01f,
  2.76296645e-01f, 1.75314516e-01f, -2.10717604e-01f, 1.77451581e-01f, 1.96611568e-01f, -1.42640814e-01f, -9.24602002e-02f, 1.20281816e-01f, 1.42016843e-01f, 5.39506078e-02f,
  1.96714669e-01f, 1.88469633e-01f, 2.15533018e-01f, 1.26814306e-01f, 3.93487215e-02f, -1.59245461e-01f, 1.94676846e-01f, -1.49806410e-01f, 1.55988291e-01f, -9.50993598e-03f,
  1.20950723e-02f, -1.25011802e-01f, 2.27860406e-01f, 1.78510800e-01f, -7.20804557e-02f, 1.12180747e-01f, -8.58510956e-02f, -1.21731116e-02f, -4.52611931e-02f, 1.07861020e-01f,
  -5.50222769e-02f, 2.22693026e-01f, -5.57733662e-02f, 2.08938733e-01f, -2.01603383e-01f, 1.72075629e-01f, -1.16576895e-01f, -1.90657765e-01f, 1.11676447e-01f, 1.67260975e-01f,
  2.12328315e-01f, 2.01466620e-01f, 1.87322825e-01f, 8.10372382e-02f, -2.26887077e-01f, -5.69514334e-02f, -8.19098651e-02f, 1.55109882e-01f, 1.06966503e-01f, -1.36354342e-01f,
  -4.71095406e-02f, -1.71976551e-01f, 9.42261666e-02f, -7.84527808e-02f, -8.63590986e-02f, 2.73441434e-01f, 1.80459902e-01f, 1.27151266e-01f, 1.09452538e-01f, 1.10812254e-01f,
  6.71822131e-02f, 2.45763808e-01f, 2.48202085e-01f, 3.13342869e-01f, -1.08021140e-01f, -1.07337115e-02f, 1.46288887e-01f, 8.92826691e-02f, -1.08238906e-01f, -1.88653678e-01f,
  2.43542969e-01f, 2.91023046e-01f, 6.26406223e-02f, -5.73515370e-02f, 9.81132612e-02f, 9.38348845e-02f, 9.53128561e-02f, -6.23679720e-02f, 2.76624382e-01f, 1.99753746e-01f,
  1.07318893e-01f, -5.15838377e-02f, 1.34503022e-01f, 4.15701456e-02f, -2.24205226e-01f, -1.80457868e-02f, 5.00978492e-02f, 9.58813280e-02f, 1.95748702e-01f, 1.37795016e-01f,
  -5.27614467e-02f, 1.06745288e-01f, 8.98258761e-03f, 2.07253918e-01f, -1.41693028e-02f, 4.22786772e-02f, 5.45014925e-02f, 6.53569773e-02f, 2.22324245e-02f, -1.14286967e-01f,
  1.26442164e-01f, 2.94235516e-02f, 2.20968381e-01f, 1.46685496e-01f, 2.19270930e-01f, 3.44223753e-02f, 1.99675232e-01f, 2.20358208e-01f, 1.60735808e-02f, 2.67661273e-01f,
  5.67780994e-02f, -1.65453508e-01f, 2.73765236e-01f, -8.95050094e-02f, 2.10845515e-01f, -7.85996765e-02f, 1.15662679e-01f, 3.11745614e-01f, 6.40861839e-02f, 2.55427863e-02f,
  1.63536891e-01f, 1.06106885e-01f, -1.27153978e-01f, 8.55152234e-02f, 2.70653069e-01f, 4.75228541e-02f, 2.94059873e-01f, 1.95691228e-01f, -1.30667627e-01f, -1.64036721e-01f,
  6.28208742e-02f, -9.80662480e-02f, -5.16210645e-02f, 1.73261374e-01f, 2.56411910e-01f, 9.39007550e-02f, 1.85949670e-03f, -1.12298369e-01f, 1.63049996e-01f, -1.76084280e-01f,
  1.74573541e-01f, 2.20356449e-01f, 2.16624469e-01f, 3.67808901e-02f, -5.17333932e-02f, 1.03054494e-01f, -2.12281913e-01f, -1.87187865e-01f, -3.17258269e-01f, 1.14152595e-01f,
  -2.80547827e-01f, 9.10181478e-02f, -1.27007306e-01f, -1.36529654e-01f, 2.96088398e-01f, 8.82525370e-02f, -3.73269059e-02f, 7.53712207e-02f, -7.23463669e-02f, -1.70007750e-01f,
  1.85468167e-01f, -2.80569363e-02f, 3.34901989e-01f, -7.04162568e-02f, 2.43792012e-01f, -9.93997827e-02f, 1.17813744e-01f, 1.91122547e-01f, 3.18920948e-02f, 3.06591213e-01f,
  1.92810580e-01f, 2.17619240e-01f, -1.58582434e-01f, 7.63489008e-02f, -4.81092408e-02f, 1.75405830e-01f, 2.27274030e-01f, -2.14152813e-01f, 2.01681644e-01f, -1.80506900e-01f,
  3.78539294e-01f, 9.00428221e-02f, -5.86446933e-02f, -9.81986709e-03f, -1.16344638e-01f, -1.54676726e-02f, 8.41826051e-02f, 1.84302971e-01f, -1.29782289e-01f, 2.31599450e-01f,
  2.84494221e-01f, 2.10598111e-01f, -9.63253826e-02f, 4.41402197e-02f, -2.42557287e-01f, -1.16834359e-03f, 1.11252032e-01f, 4.39755358e-02f, 1.79339319e-01f, 1.30968779e-01f,
  2.05227807e-01f, -1.28830150e-01f, 2.01456279e-01f, 6.66891634e-02f, -4.56122719e-02f, -3.39619294e-02f, 1.36447981e-01f, 2.63831764e-01f, -1.27325524e-02f, 2.46854603e-01f,
  1.03728503e-01f, -2.00897142e-01f, -1.50465682e-01f, 3.83580595e-01f, 4.89448644e-02f, -1.78628251e-01f, 1.31458446e-01f, -1.21513188e-01f, 1.85543951e-02f, 3.17559570e-01f,
  -2.19781175e-01f, -2.47307122e-01f, -1.34498641e-01f, 8.21218491e-02f, 2.47799486e-01f, -1.26577020e-01f, 1.17173277e-01f, -1.43322065e-01f, 3.00879300e-01f, -5.84113300e-02f,
  6.11356609e-02f, 7.81641975e-02f, 7.33288974e-02f, -1.38373394e-02f, -7.10533336e-02f, 4.68522273e-02f, 4.28372584e-02f, 4.96343151e-03f, -1.43273668e-02f, -5.75250806e-03f,
  -1.44314870e-01f, 1.92803472e-01f, -4.73112985e-02f, 3.20522249e-01f, -1.24867164e-01f, -1.11895084e-01f, -1.15454965e-03f, -1.87877983e-01f, 4.39165197e-02f, -1.00210033e-01f,
  3.01639676e-01f, 9.76131186e-02f, -1.77803151e-02f, -3.84229608e-02f, -1.78523153e-01f, 2.19114069e-02f, 2.36037254e-01f, 1.36805251e-01f, -1.06943719e-01f, 4.97841947e-02f,
  1.70784801e-01f, 1.34478688e-01f, -1.31184757e-01f, 6.93710074e-02f, 5.12499996e-02f, 2.06845894e-01f, -1.37007892e-01f, 1.32905856e-01f, 1.31639957e-01f, 3.71506661e-02f,
  2.68020302e-01f, -2.18083829e-01f, 2.17058480e-01f, -1.21184677e-01f, -3.93121354e-02f, -7.31656179e-02f, 2.04821303e-01f, -1.81303561e-01f, 1.52314767e-01f, -2.81781107e-02f,
  -1.27127454e-01f, -1.45185724e-01f, -1.59429669e-01f, 1.12182826e-01f, -1.03478484e-01f, 7.78318103e-03f, 1.16787195e-01f, 5.51171005e-02f, -1.94666892e-01f, -1.56786107e-02f,
  -5.81942424e-02f, 2.18348056e-01f, -1.75327420e-01f, -2.32722297e-01f, 1.34770691e-01f, 1.37075027e-02f, -2.68225390e-02f, -1.40065908e-01f, 1.36500031e-01f, 4.39400747e-02f,
  3.77333239e-02f, 1.19811639e-01f, -4.87714782e-02f, -1.16965011e-01f, 9.05609578e-02f, 1.41859427e-01f, -1.42867863e-01f, -5.39321303e-02f, 1.90207381e-02f, 2.46934056e-01f,
  2.08851159e-01f, -2.46958002e-01f, 2.39920795e-01f, -1.30894884e-01f, 1.06616080e-01f, 4.44188863e-02f, 6.74291849e-02f, 1.73403740e-01f, -3.09405047e-02f, 7.08359033e-02f,
  -1.09126501e-01f, -2.10518148e-02f, -2.08022948e-02f, -1.79308683e-01f, -1.55913636e-01f, -6.44205138e-02f, 2.05809489e-01f, 2.97988027e-01f, -4.58542071e-02f, -2.46917568e-02f,
  -6.20993115e-02f, -8.03229883e-02f, 1.47235051e-01f, -4.47643325e-02f, 2.12545305e-01f, 1.59270316e-02f, 2.15912014e-01f, 9.92768854e-02f, -2.04369977e-01f, 1.75076842e-01f,
  -2.39751041e-01f, -7.24210683e-03f, 7.79166222e-02f, -5.93669973e-02f, -1.86615765e-01f, -4.45698947e-03f, 2.39728376e-01f, -4.26682234e-02f, 2.27071568e-01f, 5.38923293e-02f,
  1.42513216e-01f, -7.09853927e-03f, 2.08520859e-01f, 1.25617817e-01f, 2.72620261e-01f, 1.12510636e-01f, -1.98998541e-01f, 2.75365144e-01f, -5.49334325e-02f, 1.72704265e-01f,
  1.14201091e-01f, 2.34186724e-01f, 1.32928371e-01f, 1.41754851e-01f, 1.74764514e-01f, -1.25186831e-01f, 6.34478852e-02f, -1.39888823e-01f, -8.50888863e-02f, -1.43430740e-01f,
  7.94314295e-02f, 1.38394773e-01f, -1.22148722e-01f, -5.70718348e-02f, 5.28547801e-02f, 2.20436916e-01f, 3.71931978e-02f, 2.01309666e-01f, 2.57235952e-02f, -1.67828098e-01f,
  1.65152147e-01f, -1.76907137e-01f, 8.05666819e-02f, -1.62293300e-01f, -4.64648269e-02f, 5.04709706e-02f, 2.09154844e-01f, -1.90014746e-02f, 1.57369211e-01f, 2.39945233e-01f,
  -7.14270249e-02f, -1.90109387e-01f, 1.61291227e-01f, 1.25512719e-01f, 4.17321324e-02f, 7.36290738e-02f, 9.49495882e-02f, 6.36131689e-02f, -1.62996382e-01f, -9.58892331e-02f,
  -1.48569107e-01f, -4.87711355e-02f, -1.29653409e-01f, -2.06168368e-02f, 3.78836870e-01f, -9.88291204e-03f, 1.18740663e-01f, 1.16588779e-01f, 1.75061315e-01f, -3.43740806e-02f,
  1.19866237e-01f, 2.20122039e-01f, -2.42383424e-02f, 2.77314484e-02f, 1.84160471e-02f, 1.66261226e-01f, -1.31317049e-01f, -2.59705842e-01f, -7.50966519e-02f, 8.60640556e-02f,
  -7.16792941e-02f, 6.14186153e-02f, 2.50669152e-01f, 2.50922590e-01f, 2.08048537e-01f, 6.80556670e-02f, 2.15669408e-01f, 2.96141565e-01f, 2.13040382e-01f, 2.54970700e-01f,
  1.25934049e-01f, -1.43372983e-01f, 6.05008751e-02f, 7.73113593e-02f, 6.80565089e-02f, 2.90648729e-01f, -7.74464309e-02f, 2.60790914e-01f, 1.02772377e-01f, -1.14553899e-01f,
  1.44373864e-01f, 5.22787310e-02f, 1.28094340e-03f, 3.65875028e-02f, 1.45621419e-01f, -1.43295839e-01f, -4.19424176e-02f, -1.13819137e-01f, -9.73000079e-02f, -6.67816848e-02f,
  7.43812025e-02f, -1.03866138e-01f, -9.46604460e-02f, 4.41267103e-01f, -1.94391653e-01f, -6.37694821e-02f, -1.97222635e-01f, 1.73632652e-01f, 1.28564104e-01f, 3.87575515e-02f,
  6.21294901e-02f, 2.17193604e-01f, 6.81423396e-02f, -3.25400941e-02f, -1.91920817e-01f, 4.88009378e-02f, -1.83783934e-01f, -2.20200673e-01f, 1.70069411e-01f, 5.90414070e-02f,
  -2.46712506e-01f, 2.15579286e-01f, -2.06900656e-01f, -1.53270334e-01f, 3.66835862e-01f, -2.43667047e-02f, -9.23151970e-02f, 2.56422371e-01f, 1.28662646e-01f, -1.79602072e-01f,
  2.91278139e-02f, -7.92443007e-02f, 2.38929927e-01f, -2.09111981e-02f, 1.05897106e-01f, -1.70453116e-01f, 2.20124945e-01f, 5.18288575e-02f, 1.28270119e-01f, -1.97253570e-01f,
  7.19970018e-02f, 4.25207838e-02f, 9.02155042e-02f, 1.70753434e-01f, 7.05792159e-02f, -1.78599462e-01f, -1.85450166e-02f, 1.74176976e-01f, -1.94256399e-02f, 1.28286958e-01f,
  -9.71594676e-02f, 2.60386497e-01f, 1.83667004e-01f, -1.05769634e-01f, 1.06326975e-01f, 2.68974155e-02f, -7.62645528e-02f, -5.19179180e-02f, 2.00549677e-01f, -2.84835696e-02f,
  -1.20504029e-01f, -2.50887796e-02f, -1.25220735e-02f, -2.37760097e-02f, 1.90840691e-01f, -7.60600492e-02f, -1.02481313e-01f, 2.46316940e-01f, 1.37883335e-01f, -3.03169806e-02f,
  -1.55770600e-01f, 9.97564197e-02f, 2.87079252e-02f, -6.05092496e-02f, 6.33319765e-02f, 1.47121966e-01f, 4.68814149e-02f, -8.51323456e-02f, -4.65766713e-02f, -1.87547924e-03f,
  -1.23759925e-01f, 1.40005127e-01f, 5.42440154e-02f, -8.59221369e-02f, -1.62547514e-01f, 2.04801425e-01f, -1.88377425e-01f, 1.14391245e-01f, 1.81855261e-01f, -2.56942868e-01f,
  2.04730645e-01f, 1.94849938e-01f, 1.46447644e-01f, -1.53740242e-01f, 5.06528541e-02f, 1.83063671e-01f, 1.34097204e-01f, 7.75877461e-02f, -1.51317358e-01f, 2.77168751e-01f,
  4.25414704e-02f, 1.10626481e-02f, -7.89393932e-02f, -1.44033581e-01f, -5.57033941e-02f, -3.84655334e-02f, 4.08448316e-02f, -1.49048120e-01f, -4.45882864e-02f, -1.95999771e-01f,
  -2.63680182e-02f, 5.41478954e-02f, -1.22815467e-01f, 1.43473186e-02f, -1.76980048e-02f, 1.39306122e-02f, 1.21930979e-01f, -1.35311529e-01f, 2.68225651e-02f, -7.55725875e-02f,
  6.85983300e-02f, -1.45548880e-01f, -3.51563878e-02f, 4.01599370e-02f, -1.26309007e-01f, -5.06287515e-02f, 3.48561645e-01f, 1.57300696e-01f, 1.44530132e-01f, 4.65860479e-02f,
  2.64993012e-01f, -1.54022336e-01f, 2.23692223e-01f, -2.35472307e-01f, 2.17451856e-01f, -1.41374201e-01f, -4.83226702e-02f, -3.38866562e-02f, 6.69200020e-03f, -4.08102982e-02f,
  -2.47489586e-01f, -8.31057802e-02f, 1.30075514e-01f, 9.16589573e-02f, -2.07509398e-02f, 2.63200879e-01f, 9.96857285e-02f, -1.01514772e-01f, 1.49733439e-01f, -2.38155648e-01f,
  -9.79193822e-02f, 2.73732077e-02f, 7.00267032e-02f, -1.16252959e-01f, 2.93274373e-01f, -1.07333586e-01f, 1.63329527e-01f, 9.87615213e-02f, 1.30201846e-01f, 2.25681469e-01f,
  3.33460458e-02f, 2.29943559e-01f, -6.06932305e-02f, 3.34144801e-01f, 1.74883544e-01f, -4.58155833e-02f, 1.05484322e-01f, -1.22604422e-01f, -1.06598087e-01f, 5.08538932e-02f,
  1.35558452e-02f, 3.71119715e-02f, -5.26260734e-02f, 1.56741172e-01f, 1.19459949e-01f, 1.31998405e-01f, 1.14768051e-01f, 7.73286521e-02f, 2.52171278e-01f, -3.99605334e-02f,
  -5.05622067e-02f, -1.53126791e-01f, -3.97370867e-02f, 1.54963089e-03f, 2.14439675e-01f, 2.18117520e-01f, 7.50193894e-02f, -9.24204364e-02f, -1.01714052e-01f, 1.27198145e-01f,
  1.60954401e-01f, 1.03516154e-01f, -2.55970061e-01f, 1.44080386e-01f, 1.28671542e-01f, 9.22709629e-02f, -2.04609200e-01f, 1.92419469e-01f, 8.80144835e-02f, 1.81251317e-01f,
  1.36379972e-01f, 2.73574561e-01f, 1.11631408e-01f, 1.68486103e-01f, 2.82712549e-01f, 2.26627082e-01f, 3.25500250e-01f, 2.50713937e-02f, 2.42930561e-01f, -5.80631979e-02f,
  5.29128313e-02f, 1.98593900e-01f, 1.33535653e-01f, -6.09872565e-02f, -6.06316626e-02f, -9.21993628e-02f, -1.67344645e-01f, 4.73049395e-02f, -3.79211567e-02f, 3.41330208e-02f,
  6.50365651e-02f, 1.04297362e-01f, 3.39854765e-03f, 1.25834987e-01f, -1.19898617e-01f, 8.24169964e-02f, 1.04345858e-01f, -2.27034196e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.35657683e-01f, 1.35280833e-01f, 1.57282818e-02f, 4.09225971e-02f, 1.79922208e-01f, 1.30975559e-01f, 4.58198451e-02f, 3.93281952e-02f, 3.15373875e-02f, 3.97136472e-02f,
  5.82250096e-02f, 3.55092548e-02f, 8.62118229e-02f, 1.61782086e-01f, 2.45379452e-02f, 3.66110429e-02f, 5.88645935e-02f, 9.43247676e-02f, 4.89072278e-02f, 2.54725013e-02f,
  1.40260294e-01f, 1.57701522e-01f, 1.28416464e-01f, 1.82458267e-01f, 1.22424066e-01f, 7.33720958e-02f, 1.59835711e-01f, 1.11749776e-01f, 2.01551527e-01f, 6.95928559e-02f,
  3.61852683e-02f, 5.60875535e-02f, 2.82571036e-02f, 7.83343017e-02f, 9.73305181e-02f, 9.73637179e-02f, 1.25466675e-01f, 1.60595685e-01f, 6.87354803e-02f, 4.85202149e-02f,
  1.66318923e-01f, -2.76314877e-02f, 1.16580524e-01f, 1.07402973e-01f, 5.03162406e-02f, -9.91281308e-03f, 1.59749940e-01f, 1.35457307e-01f, 1.74795240e-01f, 1.11462548e-01f,
  -3.08084562e-02f, 5.90040162e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -5.36547266e-02f, -6.84583038e-02f, -5.43938689e-02f, 5.52959889e-02f, -1.52519792e-02f, -6.65465817e-02f, 1.08763717e-01f, -1.28620625e-01f, 2.01659098e-01f, -1.21273808e-01f,
  5.07228449e-03f, 1.70601279e-01f, 2.11441934e-01f, 2.12002307e-01f, -3.51408660e-01f, -3.12699199e-01f, -2.90323228e-01f, -7.49654323e-02f, -3.86424154e-01f, 2.59953469e-01f,
  -1.03822201e-01f, 2.40721460e-03f, 2.25248054e-01f, -3.15351069e-01f, 3.26433808e-01f, -3.67887676e-01f, -6.53725713e-02f, -4.48918879e-01f, -1.63338795e-01f, -3.37183923e-01f,
  3.86444926e-01f, 2.40976647e-01f, -2.75083542e-01f, -1.45814210e-01f, -2.71919042e-01f, -2.38325670e-01f, -1.27017751e-01f, 1.51513159e-01f, -2.58620530e-01f, 2.74572402e-01f,
  2.72854149e-01f, -2.25877576e-02f, 1.31202042e-01f, 5.84666766e-02f, 3.63646090e-01f, 3.13544601e-01f, -2.12998807e-01f, 1.98922217e-01f, -3.54049534e-01f, -2.85533935e-01f,
  1.90425724e-01f, -2.77982205e-01f, 1.18138082e-01f, -1.38524443e-01f, -7.17689991e-02f, -3.55901539e-01f, -4.32274729e-01f, -1.99075937e-01f, 3.09427857e-01f, -2.85055727e-01f,
  -4.45415527e-01f, 2.37295672e-01f, 4.21484143e-01f, -2.51254648e-01f, 5.66328652e-02f, 1.93832070e-01f, -1.02269098e-01f, 1.05335459e-01f, 6.63164183e-02f, 1.24387115e-01f,
  -2.15207607e-01f, -2.19302908e-01f, -1.96875155e-01f, -1.61758915e-01f, -2.55009621e-01f, 1.56881973e-01f, -4.59518611e-01f, 3.25154126e-01f, -4.29212719e-01f, -1.94382802e-01f,
  -2.44593427e-01f, 1.94850817e-01f, -3.22630376e-01f, -1.68335021e-01f, -2.21551850e-01f, 2.03389362e-01f, -9.69536304e-02f, -2.09613457e-01f, -2.40714356e-01f, -1.43758267e-01f,
  -1.84090748e-01f, 5.51571511e-02f, -8.93208683e-02f, 8.91784132e-02f, 7.15930983e-02f, -4.21400040e-01f, 3.23532641e-01f, -3.13199967e-01f, -2.46076256e-01f, -2.87300587e-01f,
  -4.53232169e-01f, -3.79561514e-01f, -1.47377908e-01f, 3.08486223e-02f, 3.29663932e-01f, 1.47552669e-01f, 3.36191416e-01f, 2.70806670e-01f, -3.10250998e-01f, -2.99955249e-01f,
  -3.47576201e-01f, 3.28110784e-01f, 7.11853337e-03f, -2.43039310e-01f, 3.58069152e-01f, 7.96098784e-02f, -1.30583227e-01f, -2.22923860e-01f, -9.73799452e-02f, 1.36484295e-01f,
  -2.87776530e-01f, 8.15094262e-02f, 2.78079003e-01f, -5.23827896e-02f, 2.96780348e-01f, 3.07940245e-01f, 1.02685362e-01f, 1.22657806e-01f, -9.82888490e-02f, -1.67171627e-01f,
  -2.51037747e-01f, 5.23317903e-02f, -9.75070447e-02f, -2.46985242e-01f, 2.42013615e-02f, 1.60784945e-01f, -1.46534473e-01f, -8.53394791e-02f, 2.39685513e-02f, -1.33420169e-01f,
  -9.92202107e-03f, -3.16993952e-01f, 2.09047690e-01f, 5.01400948e-01f, -4.33115304e-01f, -4.70666558e-01f, -4.45750087e-01f, -1.16230659e-01f, 3.10861856e-01f, 3.01700532e-01f,
  -2.46586576e-01f, -1.85873106e-01f, -1.14270598e-01f, -1.85157470e-02f, 2.28829086e-01f, -3.86381805e-01f, 4.46481168e-01f, 2.18007881e-02f, -2.22225204e-01f, -8.35912451e-02f,
  -6.44665137e-02f, -3.42858046e-01f, -4.23631035e-02f, -2.36504227e-01f, 3.51980776e-01f, -1.90302894e-01f, -1.69367194e-01f, -4.17602807e-01f, -1.36676610e-01f, -1.26944125e-01f,
  -1.49338478e-02f, -5.51755875e-02f, 3.11751626e-02f, -8.99991777e-04f, -2.73720175e-01f, -2.32968241e-01f, -3.93986106e-01f, -3.50532889e-01f, 2.58918911e-01f, -2.19995826e-01f,
  2.25601435e-01f, -2.11743116e-01f, 2.30030175e-02f, 2.25019693e-01f, -4.90817755e-01f, -2.36532807e-01f, -5.65143339e-02f, 3.78212512e-01f, 2.94513464e-01f, 1.77341059e-01f,
  -1.24137267e-01f, -4.48035240e-01f, 3.31597291e-02f, -2.29642361e-01f, -1.18332438e-01f, -2.29211107e-01f, -5.68319075e-02f, -1.31024748e-01f, -1.89658821e-01f, 3.63851432e-03f,
  9.51775461e-02f, 1.32269546e-01f, 1.99679837e-01f, 2.98280418e-01f, 2.54810363e-01f, 1.61848798e-01f, -6.48924336e-02f, -4.38785739e-02f, 1.66220024e-01f, -1.16309293e-01f,
  -2.97144234e-01f, 3.74777079e-01f, -6.19318243e-03f, 6.37648702e-02f, -1.03192173e-01f, 1.98212743e-01f, 2.65873134e-01f, -8.55285972e-02f, 1.27809495e-01f, 2.08131745e-01f,
  4.97657955e-02f, -1.12463564e-01f, 2.11826250e-01f, -9.71617401e-02f, -4.57765371e-01f, -3.51413935e-01f, -7.86938891e-02f, -3.49900872e-02f, 2.57081062e-01f, 8.28367248e-02f,
  -3.44354808e-02f, -4.38568652e-01f, -3.95469278e-01f, -1.06728904e-01f, -1.53182652e-02f, 1.58614129e-01f, 3.37409317e-01f, -1.13128610e-02f, -2.91231543e-01f, 1.39780656e-01f,
  4.25783023e-02f, 2.27878451e-01f, -2.25765541e-01f, -2.83357620e-01f, -3.65329713e-01f, 2.58706927e-01f, -4.19282675e-01f, -1.84601098e-01f, -2.11363733e-01f, 2.97974765e-01f,
  -3.48703951e-01f, 1.06173210e-01f, -4.69668806e-01f, -2.38214329e-01f, 3.34502786e-01f, 2.20255226e-01f, -8.32253788e-03f, 1.60278738e-01f, 1.06703311e-01f, 1.70782611e-01f,
  2.06448734e-01f, 1.55309662e-01f, 4.24535014e-02f, -2.14538231e-01f, -8.66334140e-03f, -3.13888252e-01f, -2.46146172e-01f, 1.91661939e-01f, 8.45859051e-02f, 3.22533935e-01f,
  2.00991556e-01f, 6.33616149e-02f, 5.39095253e-02f, 2.89092153e-01f, 8.11067149e-02f, -1.96426436e-01f, -2.50202596e-01f, -1.15172490e-01f, -9.62056294e-02f, -2.41384313e-01f,
  2.06960708e-01f, 2.13541299e-01f, -1.87462032e-01f, 3.47278625e-01f, -3.65812540e-01f, 2.46114768e-02f, 5.36291264e-02f, 8.23202580e-02f, -2.00609103e-01f, -1.54461013e-03f,
  1.09890498e-01f, 2.49066859e-01f, -4.53179777e-01f, 2.93174475e-01f, -3.75128351e-02f, 1.44938752e-01f, -2.61176527e-02f, 1.64938654e-04f, -1.97452202e-01f, -3.59744012e-01f,
  -1.62968710e-01f, -1.99953556e-01f, 2.39923298e-01f, -4.36850905e-01f, -3.35369527e-01f, 2.44036540e-01f, 9.11889672e-02f, 5.23587205e-02f, 1.92501843e-01f, -3.76449019e-01f,
  -8.05573910e-02f, -5.29542685e-01f, -4.82019931e-02f, -3.02963883e-01f, -2.57656425e-01f, 2.65365213e-01f, -2.85772413e-01f, -2.53791958e-01f, -8.56769457e-03f, -3.43515635e-01f,
  2.03512132e-01f, 7.80447349e-02f, 2.06313729e-01f, 7.45977387e-02f, -1.36304693e-02f, 4.12831008e-02f, -2.82509685e-01f, 5.12754768e-02f, 2.82812446e-01f, 1.17605463e-01f,
  -2.10640296e-01f, -7.73380995e-02f, 2.30399817e-01f, -4.66378070e-02f, -1.14915036e-01f, -2.23280177e-01f, -1.12847097e-01f, -8.49293172e-02f, 1.79496124e-01f, 2.60819085e-02f,
  -2.21474603e-01f, -1.36970252e-01f, -1.29991263e-01f, 1.08087301e-01f, -1.27013728e-01f, -3.67892534e-01f, -3.95860761e-01f, -4.92725849e-01f, -3.20012420e-01f, 2.73839444e-01f,
  -2.43763223e-01f, 2.84455150e-01f, 1.86827734e-01f, 1.43302396e-01f, -2.40118757e-01f, 3.07524111e-02f, -2.61691779e-01f, -2.16672868e-01f, 3.79710853e-01f, 3.04979682e-01f,
  -2.08291769e-01f, 2.61213988e-01f, -2.10800633e-01f, 1.09226964e-01f, -1.54344723e-01f, 4.12862837e-01f, -5.82833998e-02f, 1.43111870e-01f, 3.83990854e-01f, -1.85065165e-01f,
  -4.03123677e-01f, -1.17039355e-02f, -5.91305532e-02f, -2.71360964e-01f, 1.97246656e-01f, 1.85939819e-01f, 2.90534288e-01f, -1.36299327e-01f, 1.92048624e-01f, -1.90435469e-01f,
  -1.24923019e-02f, -1.54062286e-01f, -1.47063553e-01f, -2.94104218e-01f, -3.32195014e-02f, -1.82222933e-01f, 1.51420936e-01f, 7.08853006e-02f, -2.78481022e-02f, 1.74638927e-01f,
  -9.95319039e-02f, 1.45050779e-01f, -1.85738564e-01f, -2.12244585e-01f, 2.44295299e-01f, 1.91782296e-01f, -2.91646183e-01f, -2.52309680e-01f, 3.90170217e-01f, -2.95707107e-01f,
  1.72863647e-01f, -3.18903327e-01f, 3.85128886e-01f, 4.58925128e-01f, 3.10330391e-01f, -1.69621482e-01f, -4.31080341e-01f, 2.25719996e-02f, -2.02326104e-01f, 2.81696543e-02f,
  5.37835717e-01f, -6.62629381e-02f, 1.97542816e-01f, 1.33194879e-01f, -2.78753728e-01f, -2.09760040e-01f, 2.07635760e-01f, -6.26229681e-03f, -1.96806759e-01f, -4.06942099e-01f,
  -1.49593040e-01f, -4.73153561e-01f, -4.75165784e-01f, -9.31548104e-02f, -1.71607703e-01f, -4.66415495e-01f, 3.45255256e-01f, -2.63693482e-01f, -2.01800466e-01f, -4.53872204e-01f,
  -1.46208676e-02f, -2.82678664e-01f, 5.05144261e-02f, -3.47119629e-01f, -4.37076032e-01f, 9.14773121e-02f, 1.47034541e-01f, -1.37603745e-01f, -1.04245834e-01f, 2.16837093e-01f,
  3.63301396e-01f, -1.55434370e-01f, -3.51366550e-02f, -4.85628396e-02f, 1.36889115e-01f, -1.25670761e-01f, -1.45110831e-01f, 1.59985602e-01f, 1.62966885e-02f, -1.72684956e-02f,
  -1.16483673e-01f, -1.49305627e-01f, 5.13488166e-02f, -1.59452364e-01f, -4.95797992e-02f, -1.23677365e-01f, 1.11256644e-01f, 4.49191034e-02f, -5.30194305e-02f, 1.37620524e-01f,
  1.31870717e-01f, -3.19510430e-01f, -2.70398915e-01f, 3.03701907e-01f, -2.19513029e-01f, -3.03341717e-01f, 3.23324978e-01f, 2.59918928e-01f, -2.11704001e-01f, 5.89841865e-02f,
  2.11218283e-01f, 1.98460519e-01f, -9.95764732e-02f, -2.41552860e-01f, 7.66148511e-03f, 3.37195039e-01f, -1.36869505e-01f, -2.13454649e-01f, -4.34552252e-01f, 2.79146820e-01f,
  -2.12908596e-01f, 8.86936039e-02f, -2.33480528e-01f, -9.90108252e-02f, -1.78174064e-01f, 2.89117377e-02f, -2.63944417e-01f, -3.23835909e-01f, -2.72726178e-01f, 2.12744191e-01f,
  2.56061391e-03f, -3.20292592e-01f, 1.89053252e-01f, 1.93907544e-02f, 1.64624557e-01f, -2.73662686e-01f, -2.12877244e-02f, 5.44444285e-02f, -6.43763617e-02f, -2.52663583e-01f,
  -1.55538291e-01f, 3.43112916e-01f, 2.13589102e-01f, -2.35782772e-01f, 9.43686441e-02f, 1.99419945e-01f, 2.12197825e-01f, -2.27351949e-01f, -1.88788474e-01f, -2.33824536e-01f,
  -2.37787634e-01f, 2.64483780e-01f, -9.97837409e-02f, -1.64845400e-02f, -1.08482717e-02f, 8.04520920e-02f, -2.03684032e-01f, -4.28575911e-02f, -9.86874327e-02f, 7.82844871e-02f,
  1.94780469e-01f, 1.42918617e-01f, 1.36780262e-01f, -1.32874608e-01f, -1.17837265e-01f, -8.74779075e-02f, -1.69128403e-01f, 7.27515016e-03f, 3.16558838e-01f, -1.61740318e-01f,
  -1.44079864e-01f, -1.76682040e-01f, -1.31830230e-01f, 1.85053989e-01f, -1.26505597e-02f, -2.03333601e-01f, -2.23670214e-01f, -1.66111037e-01f, 2.65418947e-01f, 4.18321565e-02f,
  -3.32251459e-01f, 2.37644255e-01f, 8.65345448e-02f, -1.06223188e-01f, -3.13924998e-02f, -1.99161589e-01f, 3.26359987e-01f, -1.59013540e-01f, 1.54061183e-01f, -8.77858847e-02f,
  1.10024869e-01f, -2.77435660e-01f, -3.92659575e-01f, 2.26795956e-01f, 1.31545499e-01f, -3.17821652e-01f, -1.58811599e-01f, -5.39936274e-02f, 3.70684892e-01f, 2.75290042e-01f,
  -1.97723269e-01f, -9.48093235e-02f, 2.56211996e-01f, 2.30467305e-01f, 1.41587526e-01f, 3.75736922e-01f, 2.12341815e-01f, -1.04455858e-01f, -1.95736676e-01f, -1.94481894e-01f,
  -2.22310960e-01f, -3.18134308e-01f, -1.59905627e-01f, 6.97392151e-02f, -1.97308883e-01f, 5.30213788e-02f, 3.63375992e-03f, 2.83332020e-02f, 2.35376209e-02f, -1.08923547e-01f,
  2.26896361e-01f, 6.42551109e-02f, -1.02238685e-01f, 3.02930772e-01f, -1.47626340e-01f, -1.44210890e-01f, -2.46747479e-01f, -1.71880618e-01f, -2.05860838e-01f, -4.28652912e-01f,
  -2.62343705e-01f, 2.22333699e-01f, -1.52474791e-01f, 5.91209531e-03f, 8.32267255e-02f, -2.87096113e-01f, 3.24934691e-01f, -2.71462351e-01f, 4.53496009e-01f, -2.78857082e-01f,
  -2.53533334e-01f, -3.54671240e-01f, -3.03051144e-01f, 1.41217202e-01f, 3.77442628e-01f, -4.67805982e-01f, -8.54175761e-02f, -8.16615373e-02f, -4.05990869e-01f, 4.06411380e-01f,
  8.52837414e-02f, -2.84035504e-01f, -1.92522272e-01f, 2.67955493e-02f, -2.06631333e-01f, 2.38591909e-01f, 3.68306726e-01f, -3.39713871e-01f, -1.89701438e-01f, -3.39310378e-01f,
  -2.62814730e-01f, -2.34660104e-01f, -2.33568121e-02f, -1.68364853e-01f, -2.59649642e-02f, 2.87786156e-01f, -2.20193088e-01f, -8.47930089e-02f, 3.05018097e-01f, -2.30449021e-01f,
  3.62996936e-01f, 1.40999436e-01f, 1.14796981e-01f, -1.78777441e-01f, -1.97745979e-01f, -9.90669355e-02f, -1.77002922e-01f, -2.00736359e-01f, -1.03489555e-01f, -2.22223386e-01f,
  -1.19592980e-01f, 1.88380685e-02f, 1.80824742e-01f, -1.33225963e-01f, 6.39561415e-02f, 1.19244471e-01f, 3.09416890e-01f, -2.58768827e-01f, -2.25451551e-02f, 2.64698923e-01f,
  2.27841929e-01f, -1.61923900e-01f, -3.15613002e-01f, -1.61908969e-01f, -3.56042236e-01f, -2.16385797e-01f, 2.03077406e-01f, 2.43878901e-01f, -2.59019166e-01f, -3.94008428e-01f,
  -3.15487355e-01f, 3.33382726e-01f, -2.41678834e-01f, 2.28673175e-01f, 2.93377846e-01f, 2.52472311e-01f, -3.04190904e-01f, -3.64077806e-01f, -1.91184551e-01f, -3.31815071e-02f,
  -2.73217916e-01f, -3.02323461e-01f, 1.87183812e-01f, -1.44713730e-01f, 2.05974162e-01f, 2.35387042e-01f, 3.31556797e-01f, -2.31946446e-02f, 2.22305924e-01f, 3.94787081e-02f,
  2.44111642e-01f, -2.41123453e-01f, -3.44784290e-01f, 8.03072527e-02f, -1.03274524e-01f, -1.51453130e-02f, -2.00277671e-01f, 5.91031313e-02f, 2.48527944e-01f, -3.12633485e-01f,
  -1.04314379e-01f, -1.66864414e-02f, -2.49171600e-01f, -5.50268665e-02f, -3.17151725e-01f, -3.34687412e-01f, -2.72377700e-01f, 2.04447791e-01f, -2.62375146e-01f, 2.23530903e-01f,
  3.66161942e-01f, 5.66650815e-02f, -3.55282605e-01f, -5.63904084e-02f, -3.71898413e-02f, 6.20667674e-02f, -1.82285786e-01f, -7.50200003e-02f, -9.00421813e-02f, -2.06704140e-01f,
  3.03239107e-01f, 2.29596168e-01f, 1.91841871e-01f, 1.65351897e-01f, 1.43665269e-01f, -2.22356930e-01f, -3.67362767e-01f, -3.68672788e-01f, 2.94005066e-01f, -3.19015056e-01f,
  1.64571717e-01f, -1.25703946e-01f, -3.45167518e-01f, -1.36243880e-01f, -1.16400190e-01f, -4.12410259e-01f, -2.80392051e-01f, 2.42616802e-01f, -3.35933387e-01f, 2.07078829e-01f,
  -2.23211005e-01f, 1.09108523e-01f, -2.60852158e-01f, -1.24709666e-01f, 3.62341344e-01f, -1.46631658e-01f, 5.80504835e-02f, -9.18688327e-02f, 1.37292072e-01f, 1.61161274e-01f,
  -5.38289063e-02f, -3.46723586e-01f, 3.42219025e-01f, -3.48700464e-01f, -1.17922544e-01f, -3.70375425e-01f, 8.79444033e-02f, 1.93088651e-01f, 1.35826737e-01f, 2.36909598e-01f,
  2.38986835e-01f, -2.04583909e-02f, 8.77721980e-02f, 1.44723758e-01f, -2.51410097e-01f, 2.20199063e-01f, -4.23688173e-01f, -1.04073495e-01f, 7.00986236e-02f, -2.29464546e-01f,
  2.75804698e-01f, -2.81880677e-01f, -1.50792286e-01f, -2.94574529e-01f, -1.67004690e-01f, -2.92809367e-01f, -2.45235562e-01f, 2.91054040e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.89062597e-02f, -8.62393156e-03f, -2.52203811e-02f, -1.72862023e-01f, 1.76195819e-02f, -3.22753787e-02f, -4.99136187e-02f, 1.79373045e-02f, -1.23693161e-01f, 6.41392767e-02f,
  -5.43745197e-02f, -6.05840497e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    