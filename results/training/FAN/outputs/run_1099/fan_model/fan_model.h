/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.58623987e-01f, 5.04645288e-01f, -1.09306686e-01f, -2.14511305e-02f, 2.10871905e-01f, 2.01654304e-02f, 3.34251463e-01f, 6.67617545e-02f, -2.70615686e-02f, 1.12371556e-01f,
  1.25684336e-01f, -1.56128526e-01f, -6.24951273e-02f, -2.03493506e-01f, -8.39946941e-02f, 7.18923798e-03f, 2.12789029e-02f, -2.85630405e-01f, -2.44606122e-01f, -1.01365939e-01f,
  2.10908413e-01f, -7.49880541e-03f, -7.72031173e-02f, -8.05915594e-02f, 7.97641575e-02f, -2.39323094e-01f, -2.51663737e-02f, 3.91590707e-02f, 1.75198652e-02f, -3.69925126e-02f,
  -1.95172042e-01f, 1.27286360e-01f, -3.38012874e-02f, -7.10516563e-03f, -9.49869081e-02f, -1.60041407e-01f, -1.64268108e-03f, -1.54592572e-02f, -1.44528951e-02f, -3.74297127e-02f,
  2.47384291e-02f, -1.01885073e-01f, -8.36026669e-02f, -1.84672268e-03f, -4.73571039e-04f, -2.62145493e-02f, -4.02904935e-02f, -5.70042990e-02f, -2.83280984e-02f, 2.10628323e-02f,
  1.50353238e-01f, 9.34767127e-02f, 9.74857509e-02f, 1.17323317e-01f, -8.31876993e-02f, -6.74262196e-02f, 8.95962194e-02f, -4.17399257e-02f, -1.00377768e-01f, -1.48298085e-01f,
  5.01294099e-02f, 3.13017219e-02f, 9.69981551e-02f, -1.36524802e-02f, -6.80785775e-02f, 4.65961173e-02f, 6.70745084e-03f, -3.15389782e-02f, 1.57093070e-02f, -8.71903729e-03f,
  -1.12391720e-02f, 1.78191985e-03f, -1.09461270e-01f, -9.35285818e-03f, -7.06109628e-02f, 6.46459013e-02f, -4.54560742e-02f, 7.82836005e-02f, -4.84223999e-02f, -8.28932412e-03f,
  1.43983020e-02f, -4.52808663e-02f, -9.62719619e-02f, 2.91425157e-02f, -1.94025990e-02f, -1.30107207e-02f, 1.86052006e-02f, 6.00507148e-02f, -8.34703539e-03f, 4.26820852e-02f,
  -1.82803527e-01f, 1.12779267e-01f, -1.03028476e-01f, -5.00699989e-02f, 2.14389544e-02f, -6.39186725e-02f, 3.15896645e-02f, -6.72313850e-04f, -7.62654468e-02f, -6.53383806e-02f,
  -8.61178711e-02f, -1.96183890e-01f, -4.16583866e-02f, -1.08963259e-01f, -7.34372288e-02f, -8.72228071e-02f, 7.91478008e-02f, -1.85949832e-01f, -1.61158927e-02f, 1.12987310e-02f,
  2.03309581e-03f, 3.25585976e-02f, -3.93396281e-02f, -5.63589521e-02f, -2.30397619e-02f, -5.65671586e-02f, -1.42139539e-01f, 1.49195519e-04f, -1.34532049e-01f, -4.12693396e-02f,
  5.55752553e-02f, 9.00465548e-02f, -3.63490939e-01f, 4.40090597e-02f, 4.83851992e-02f, -1.02020979e-01f, 5.99864013e-02f, -3.17200124e-02f, 3.32531966e-02f, 1.50221810e-01f,
  4.81399111e-02f, -1.80193852e-03f, -9.75911133e-03f, -7.97667727e-02f, -3.42912339e-02f, 1.32420540e-01f, -8.96102563e-02f, -2.81623423e-01f, -2.57102996e-01f, 2.60716807e-02f,
  1.15349062e-01f, -1.60684824e-01f, -2.40201905e-01f, -2.26515085e-01f, -1.30147561e-01f, -1.92479044e-01f, -2.89339244e-01f, -1.79735377e-01f, -1.46422043e-01f, -8.11483786e-02f,
  4.52486202e-02f, 2.18723286e-02f, -1.13889977e-01f, -2.84268633e-02f, -6.79443255e-02f, -6.79663420e-02f, -7.59728700e-02f, -1.74758881e-01f, -1.49491103e-02f, 2.61860285e-02f,
  -2.53059771e-02f, -8.61302093e-02f, -2.70352922e-02f, -1.15119651e-01f, -1.70510616e-02f, 9.61134501e-04f, -1.44944310e-01f, -1.05554342e-01f, -2.07616657e-01f, -7.24035054e-02f,
  -2.69990861e-02f, -7.64858127e-02f, -9.16258544e-02f, -1.59285098e-01f, 1.00681937e-04f, -1.41396016e-01f, -1.39565423e-01f, -2.30318680e-01f, -2.25008324e-01f, -1.53323054e-01f,
  -3.36478651e-02f, 3.42578813e-02f, 9.55553576e-02f, 7.38853440e-02f, 3.75476740e-02f, 2.69248821e-02f, 9.59559307e-02f, 8.92150700e-02f, 4.12687175e-02f, -6.68600723e-02f,
  1.35006204e-01f, -3.28088030e-02f, 8.34572539e-02f, 1.50790857e-03f, -1.01614095e-01f, 9.24327597e-03f, 2.85302084e-02f, -1.08247608e-01f, -1.34125426e-01f, -5.47089614e-02f,
  -1.76881794e-02f, -9.53100622e-02f, 2.45052408e-02f, 6.53616786e-02f, 6.04665559e-03f, 4.34708670e-02f, 2.98723001e-02f, 2.83637438e-02f, 7.99125209e-02f, 1.00327469e-02f,
  2.73899864e-02f, -2.29892030e-01f, 1.00440063e-01f, -7.14913011e-02f, -6.87075453e-03f, -1.36608034e-01f, -9.48077962e-02f, -8.80969539e-02f, -1.69733897e-01f, 3.86020616e-02f,
  -5.80463894e-02f, -1.24124475e-02f, -8.07230324e-02f, -9.08351541e-02f, -1.10022008e-01f, 3.07445675e-02f, 3.68115641e-02f, -7.53993541e-02f, -1.55859441e-01f, -1.25589326e-01f,
  -1.48703516e-01f, 3.85275036e-02f, 6.30633831e-02f, -1.15299806e-01f, -9.58658457e-02f, -1.07517928e-01f, -7.78928325e-02f, -1.61825418e-01f, -1.10822909e-01f, -8.53307396e-02f,
  2.59295434e-01f, 1.69880822e-01f, 1.39734283e-01f, 1.41621798e-01f, -1.52800575e-01f, -6.38412833e-02f, -1.06435873e-01f, 2.76610430e-04f, -1.56799391e-01f, -1.17339514e-01f,
  -9.49340537e-02f, 5.45202270e-02f, -1.05873242e-01f, 1.27596661e-01f, 1.44137084e-01f, -1.42458066e-01f, -3.09238695e-02f, 1.39474660e-01f, 2.31855571e-01f, 1.71367064e-01f,
  6.32856935e-02f, 2.01707020e-01f, 3.05453897e-01f, 1.09466016e-01f, 9.90616456e-02f, -1.01869792e-01f, -6.18737713e-02f, 4.17919531e-02f, 1.35154828e-01f, 2.30239585e-01f,
  4.94529381e-02f, 2.99148411e-01f, -9.02393013e-02f, 4.70007285e-02f, 4.81252186e-03f, 1.10177342e-02f, -3.67768705e-02f, 1.60649866e-02f, -4.31614257e-02f, -6.87928647e-02f,
  9.68300998e-02f, -1.66554861e-02f, 3.98102729e-03f, -1.63077004e-02f, 7.27977976e-02f, -2.37255655e-02f, 3.54736447e-02f, 1.15619607e-01f, 1.17792547e-01f, 1.07371151e-01f,
  -8.27836897e-03f, 6.04456924e-02f, 2.15520173e-01f, -1.13631085e-01f, 1.30256191e-01f, -3.19017284e-02f, 7.23944679e-02f, 1.97230965e-01f, 1.01362325e-01f, 1.02246098e-01f,
  -7.78158680e-02f, -7.60007054e-02f, 4.53160964e-02f, -1.27466451e-02f, 5.06672673e-02f, -6.66603595e-02f, 1.27276117e-02f, 1.25320004e-02f, -2.06493773e-02f, -5.45532349e-03f,
  7.64116878e-03f, -3.76519449e-02f, 2.29117479e-02f, 1.52858710e-02f, 1.86598592e-03f, 1.23858221e-01f, 1.09359156e-02f, 1.15326385e-03f, 9.96503234e-02f, 8.15457553e-02f,
  1.13570383e-02f, -1.80422459e-02f, -2.13395413e-02f, 6.15226384e-03f, 2.02938393e-02f, 6.46568909e-02f, -6.74899295e-02f, -3.16854864e-02f, -5.96205145e-02f, 6.08906411e-02f,
  -1.78036928e-01f, 1.95416864e-02f, -1.74685583e-01f, 1.00303061e-01f, 4.40406054e-02f, 1.92396473e-02f, 3.95093821e-02f, -4.55198698e-02f, -2.14106813e-02f, 5.15860580e-02f,
  6.72507435e-02f, -3.23002525e-02f, 3.33092846e-02f, -4.03499678e-02f, -1.22823149e-01f, -8.15755278e-02f, -1.24716446e-01f, -5.26811257e-02f, -5.02509512e-02f, -1.11048836e-02f,
  -2.14848101e-01f, -1.77742928e-01f, -1.43581986e-01f, -3.89727205e-02f, -6.79070726e-02f, -1.64334878e-01f, -1.47073492e-01f, -1.23924725e-01f, 8.33705813e-03f, -2.85459012e-01f,
  -4.46723774e-02f, -2.06916690e-01f, -3.82425301e-02f, -3.68836499e-03f, -1.35755092e-01f, -1.18543960e-01f, -4.16014880e-01f, -1.02596842e-01f, 8.67983177e-02f, -1.79873496e-01f,
  -3.95562239e-02f, 3.25165391e-01f, 1.94525167e-01f, 7.66471624e-02f, -5.30179404e-03f, -2.63575554e-01f, -1.83041632e-01f, 2.32974775e-02f, 7.30840564e-02f, -1.22032380e-02f,
  1.20984457e-01f, 6.58090711e-02f, 1.18928969e-01f, 4.72112745e-02f, -1.24826441e-02f, 2.93847144e-01f, 3.28653492e-02f, -3.63231488e-02f, 3.15822498e-03f, 2.01814398e-02f,
  1.21529829e-02f, -1.20307803e-01f, -1.04916506e-02f, 4.57589468e-03f, -2.40120217e-02f, -1.55497223e-01f, -1.09657995e-01f, -4.50574383e-02f, -5.49154766e-02f, -6.70312066e-03f,
  3.65411267e-02f, -8.34504589e-02f, -8.00218433e-02f, -6.91623464e-02f, -1.21445455e-01f, -2.83161476e-02f, -1.42110273e-01f, -1.32680401e-01f, -5.21930158e-02f, -1.27305627e-01f,
  -4.92167473e-02f, 1.13067310e-02f, -1.35076433e-01f, -1.24272764e-01f, -1.22320592e-01f, 2.60809698e-04f, -1.35502204e-01f, -1.04491368e-01f, 1.26225138e-02f, -6.64640963e-02f,
  -1.83077846e-02f, -2.25953013e-02f, 3.61180417e-02f, -5.22546284e-02f, 6.42648116e-02f, 1.76837534e-01f, 2.43310854e-02f, 1.43706545e-01f, 8.39914009e-02f, -2.45486423e-02f,
  1.08268261e-01f, 1.40859395e-01f, 9.28315073e-02f, -2.72731879e-03f, 9.30890143e-02f, -3.79290618e-02f, 1.72044206e-02f, 3.89182530e-02f, 7.16401190e-02f, -2.47748829e-02f,
  2.16602549e-01f, 4.48272005e-02f, 1.49880201e-01f, 6.75462410e-02f, -2.36243475e-02f, 9.63101387e-02f, 1.13141108e-02f, 6.99269399e-02f, 1.23201929e-01f, 2.02319250e-02f,
  1.94298789e-01f, -1.42796502e-01f, -2.18247861e-01f, -8.82572532e-02f, 1.70086510e-02f, -9.62027460e-02f, 7.74475336e-02f, -1.04562230e-01f, 3.70468609e-02f, -4.25110310e-02f,
  -1.12745710e-01f, -1.04248047e-01f, -4.00678553e-02f, -1.02964483e-01f, -5.21266498e-02f, -6.08837679e-02f, -3.82370725e-02f, -1.00736037e-01f, -7.48390257e-02f, -1.39545918e-01f,
  -1.79952130e-01f, -9.60403904e-02f, -1.11411400e-01f, -6.24236912e-02f, -1.64077505e-02f, -5.05468510e-02f, -9.90514234e-02f, -7.11600482e-02f, -7.74099901e-02f, -2.47386500e-01f,
  1.79067980e-02f, 2.74434090e-01f, 1.21182695e-01f, -2.27826372e-01f, 4.10080738e-02f, 6.56838641e-02f, 3.17105085e-01f, 5.40816076e-02f, 2.43250895e-02f, 1.53458089e-01f,
  -4.18419838e-02f, -3.78952980e-01f, -1.92623973e-01f, -1.85006455e-01f, -9.11174268e-02f, 1.09612264e-01f, -4.36714664e-02f, -2.61664111e-02f, -8.60750303e-02f, 9.87646133e-02f,
  -4.78694178e-02f, 1.44800206e-03f, -1.88889429e-02f, 4.72623743e-02f, 1.03400603e-01f, -1.52398422e-02f, 2.42474571e-01f, 6.17358573e-02f, 1.38917565e-01f, 2.12955713e-01f,
  1.45571873e-01f, 1.87238023e-01f, -7.66809955e-02f, -7.22142532e-02f, -4.30846699e-02f, 1.20563768e-01f, 7.15345368e-02f, 2.84108259e-02f, 6.78443525e-04f, 3.53707820e-02f,
  -7.92319924e-02f, 2.32402049e-02f, -1.07047923e-01f, 1.15502484e-01f, 6.68011606e-03f, 1.18415624e-01f, -1.29156131e-02f, -4.50225025e-02f, -1.13020405e-01f, 1.05295435e-01f,
  -6.50984496e-02f, -1.35099053e-01f, 4.19872403e-02f, -2.10508965e-02f, -1.13363780e-01f, -4.92392965e-02f, 1.01594970e-01f, 1.25111476e-01f, 7.96476901e-02f, 2.73333937e-01f,
  7.95475170e-02f, -5.71702272e-02f, -5.70705794e-02f, 5.98918982e-02f, -1.00182798e-02f, -7.51917288e-02f, -5.38949855e-02f, 1.66648300e-03f, 3.11290678e-02f, 7.39877820e-02f,
  -4.54336852e-02f, -3.64992544e-02f, -5.82424141e-02f, 6.22502621e-03f, 3.54933813e-02f, -3.71823870e-02f, -7.29302391e-02f, 5.21679781e-02f, -5.78024052e-03f, -3.74931842e-02f,
  -6.12440007e-03f, 4.85560037e-02f, -3.45659517e-02f, 1.53294438e-02f, 1.05521586e-02f, -5.20289764e-02f, 1.87869426e-02f, -1.34262163e-02f, 8.38493332e-02f, 1.15018852e-01f,
  6.68233186e-02f, -1.25310048e-01f, 3.21393870e-02f, 1.29090985e-02f, 1.02207310e-01f, -1.69960298e-02f, -4.62770015e-02f, 5.15726320e-02f, 4.36586998e-02f, 8.57871622e-02f,
  -1.75416272e-03f, -6.20720871e-02f, -6.55571595e-02f, 5.85010536e-02f, 2.35135425e-02f, 7.54092038e-02f, 2.23631971e-02f, 3.65303382e-02f, 2.07940419e-03f, 1.28342018e-01f,
  -7.06079751e-02f, 8.02009851e-02f, -2.68718647e-03f, -8.71098414e-02f, -1.58158559e-02f, -7.13894144e-02f, 9.80263203e-02f, 5.61747327e-02f, -7.08349273e-02f, 2.90603191e-01f,
  4.01753008e-01f, 1.13654636e-01f, 2.25394920e-01f, 1.76962554e-01f, 1.26054123e-01f, 1.66486874e-01f, 2.74709016e-01f, 6.95659146e-02f, -1.36702195e-01f, 1.69705421e-01f,
  2.38375422e-02f, -2.66003460e-01f, -2.00247869e-01f, -2.13727042e-01f, 1.92841925e-02f, 1.94239557e-01f, 2.05723584e-01f, 1.95692718e-01f, 4.85847481e-02f, 1.53925180e-01f,
  -1.20713869e-02f, 9.88279134e-02f, 1.31597713e-01f, -4.08586375e-02f, 5.44631965e-02f, -1.46278948e-01f, 1.10529192e-01f, 9.30805281e-02f, 6.66785170e-04f, 2.79097766e-01f,
  -2.15585474e-02f, 2.56285816e-01f, 8.80177766e-02f, 5.58750629e-02f, 1.01668991e-01f, 5.05615100e-02f, 1.79144237e-02f, 7.58700892e-02f, -3.54980975e-02f, 7.36414567e-02f,
  8.16222876e-02f, 8.33068117e-02f, 6.79529980e-02f, 8.75683352e-02f, -5.40676415e-02f, 3.21211107e-02f, -1.13375857e-02f, 9.14267898e-02f, -5.68190310e-03f, 3.70478369e-02f,
  8.26561823e-03f, 1.05780654e-01f, 2.17426002e-01f, -3.81942503e-02f, 1.31319702e-01f, 4.04552855e-02f, 1.34643093e-01f, 4.28382903e-02f, 6.65396154e-02f, 5.63545786e-02f,
  1.14458852e-01f, 6.41281009e-02f, -4.15032990e-02f, 5.09404764e-02f, 3.59745994e-02f, -5.43739907e-02f, -2.35118680e-02f, 2.09982749e-02f, 4.84177051e-03f, 1.95164848e-02f,
  3.87178324e-02f, 6.24400452e-02f, -6.16328642e-02f, 9.56437886e-02f, 1.97509248e-02f, 1.30471393e-01f, 5.66261336e-02f, 3.65070477e-02f, -8.33723694e-02f, 2.10946277e-02f,
  -5.15706912e-02f, 5.04256636e-02f, -9.53501612e-02f, -5.19871823e-02f, 5.29548340e-02f, 4.50648740e-02f, 8.51867720e-02f, 6.39821440e-02f, 8.30009803e-02f, 1.30499795e-01f,
  -3.57425570e-01f, -1.69891909e-01f, 6.60582185e-02f, 8.84690508e-02f, -4.01108935e-02f, -1.28419250e-01f, 2.75801886e-02f, -2.45212559e-02f, 4.08840887e-02f, -3.35392915e-02f,
  7.02289212e-03f, -5.60503751e-02f, -3.49406414e-02f, 5.09349182e-02f, -9.21737179e-02f, 1.01116240e-01f, -2.99324915e-02f, 4.62489799e-02f, -4.17778306e-02f, 1.00555941e-02f,
  2.94465795e-02f, 8.19406733e-02f, 5.66458330e-02f, 3.10150478e-02f, -2.33849813e-03f, 4.13601175e-02f, 2.55333260e-02f, -2.41689533e-02f, -5.47298901e-02f, -2.16857661e-02f,
  4.52925004e-02f, 6.65628305e-03f, -6.08437538e-01f, 1.83387354e-01f, -2.16722414e-01f, -2.10200131e-01f, -2.78701723e-01f, -4.31913212e-02f, 1.26716092e-01f, -8.12966377e-02f,
  8.20528418e-02f, 2.39945561e-01f, 6.71917871e-02f, -3.29525280e-03f, -3.04381978e-02f, -2.60123253e-01f, -2.62260288e-01f, -2.92363405e-01f, -3.48556638e-01f, -2.35229746e-01f,
  -3.01932432e-02f, 1.11301042e-01f, 1.11076748e-02f, 7.78199965e-03f, -4.77065928e-02f, 1.52518870e-02f, -4.96710278e-02f, -3.78261730e-02f, -9.56440270e-02f, -2.25196123e-01f,
  -4.13130403e-01f, -1.97201535e-01f, -5.07787755e-03f, 1.01886079e-01f, 5.64983208e-03f, 7.32517913e-02f, -5.78651838e-02f, -9.28979460e-03f, 1.32601425e-01f, 4.83882502e-02f,
  3.22586559e-02f, 2.18477938e-02f, 1.48349088e-02f, -4.79574490e-04f, -8.06855112e-02f, -9.17404369e-02f, -2.75875274e-02f, -3.68371829e-02f, 4.45355177e-02f, -2.92946715e-02f,
  3.39381024e-02f, -2.52369302e-03f, -4.79895994e-02f, -3.01205125e-02f, -1.02490306e-01f, -2.60963812e-02f, -7.98233673e-02f, -1.00336835e-01f, -6.29040301e-02f, 4.81662638e-02f,
  -6.41773343e-02f, 4.55907099e-02f, -2.99090948e-02f, 1.29015539e-02f, 1.56513732e-02f, 2.50694472e-02f, -5.04449289e-03f, -4.36563082e-02f, 5.47727849e-03f, 8.61888379e-02f,
  3.26313190e-02f, -1.02769114e-01f, 1.32021829e-02f, 2.55014710e-02f, -7.75149539e-02f, 1.60844028e-02f, 3.53735313e-02f, -1.14207957e-02f, 1.83339238e-01f, 8.77361894e-02f,
  9.59352627e-02f, -6.90992326e-02f, 2.34030318e-02f, 4.79961336e-02f, -6.82412833e-02f, -3.36620361e-02f, -3.11889574e-02f, 5.64329326e-02f, 6.65866807e-02f, 7.70100430e-02f,
  1.65913999e-01f, 1.17104733e-03f, -1.03316858e-01f, -1.27284341e-02f, -8.41364861e-02f, 6.86914921e-02f, -6.53314516e-02f, 6.88599125e-02f, 2.43280139e-02f, -2.86302548e-02f,
  -8.94279405e-02f, -9.91138369e-02f, 7.50167528e-03f, -7.39971027e-02f, 5.40930927e-02f, 1.60887949e-02f, 8.08963031e-02f, -1.24977544e-01f, -2.59448737e-02f, -1.92277913e-03f,
  2.11962741e-02f, -5.75364865e-02f, -5.32848239e-02f, 3.46298739e-02f, 5.98406419e-02f, -5.10375537e-02f, -6.20814674e-02f, -9.76235121e-02f, 8.44217371e-03f, 1.58715770e-01f,
  4.23447669e-01f, 1.86159223e-01f, -1.51745109e-02f, -8.82731453e-02f, -7.74698034e-02f, 1.03552397e-02f, 2.02166036e-01f, 7.50807896e-02f, -1.46028083e-02f, -4.34025489e-02f,
  1.34769171e-01f, -1.01448089e-01f, -7.73722157e-02f, 2.70866454e-02f, 1.69022098e-01f, -7.03828707e-02f, -3.36715668e-01f, -1.92421198e-01f, 6.42838255e-02f, 1.15030006e-01f,
  -2.19493970e-01f, -1.64143384e-01f, 4.08423282e-02f, 1.02090044e-02f, -1.00488558e-01f, 1.48698676e-03f, -5.82871325e-02f, -1.48791939e-01f, -4.95421626e-02f, -2.59161204e-01f,
  -1.95681397e-02f, 3.24544370e-01f, -3.31833307e-03f, 6.16411380e-02f, 8.95523056e-02f, 1.18547417e-01f, 4.46636900e-02f, 6.92386776e-02f, 5.46261817e-02f, -7.35168830e-02f,
  2.23565437e-02f, -6.24234462e-03f, -2.77860519e-02f, -7.57686645e-02f, -8.34720880e-02f, 2.14481950e-02f, 2.60803737e-02f, -2.17623059e-02f, -7.73353055e-02f, 4.14744802e-02f,
  -1.33655101e-01f, -7.92649463e-02f, 6.16041850e-03f, 4.59627435e-02f, 9.33266878e-02f, 6.56267107e-02f, 1.64429486e-01f, 8.00530240e-02f, 7.51471743e-02f, 8.57504308e-02f,
  1.10498376e-01f, 8.82126316e-02f, -1.05842359e-04f, 6.54007718e-02f, 4.95188385e-02f, 7.72893801e-02f, -7.91544318e-02f, -4.55028564e-02f, 2.62838998e-03f, 7.59760216e-02f,
  3.31292637e-02f, 1.13509275e-01f, 1.00337066e-01f, 9.42305848e-02f, -1.10758087e-02f, -5.58956526e-02f, 5.39780371e-02f, 3.08159962e-02f, -7.00675026e-02f, -1.39566865e-02f,
  5.55841848e-02f, -3.34965400e-02f, -5.25824465e-02f, 2.51393132e-02f, 3.33729759e-02f, -4.49360795e-02f, -4.41931561e-02f, 6.58112243e-02f, 8.54524449e-02f, 2.99762264e-02f,
  -3.74072306e-02f, 6.22314075e-03f, 2.88803726e-02f, -9.87911671e-02f, -4.73048836e-02f, -8.27065855e-02f, 3.05651389e-02f, -8.69918391e-02f, -1.93675812e-02f, -2.10029688e-02f,
  3.04787755e-02f, 9.41215754e-02f, 6.30576583e-03f, 8.67218673e-02f, 4.97339070e-02f, -7.27320015e-02f, -3.55219059e-02f, -4.21461500e-02f, -5.81692643e-02f, -1.01143390e-01f,
  -5.40034845e-02f, 2.07984727e-02f, 7.89742097e-02f, -5.25305681e-02f, 7.43384585e-02f, -1.43079273e-02f, 2.20315391e-03f, 6.82770275e-03f, 1.82519570e-01f, 1.97827265e-01f,
  5.05082130e-01f, -1.73099209e-02f, 1.11264929e-01f, 2.98884869e-01f, -2.87126321e-02f, -2.88070768e-01f, -2.53323764e-01f, -1.27933651e-01f, 6.88026287e-03f, -6.43503591e-02f,
  -1.60990417e-01f, -1.21630616e-01f, -3.38080712e-02f, -1.78065263e-02f, -3.18548903e-02f, 4.04805690e-02f, 1.27788618e-01f, 1.02990545e-01f, -1.54319197e-01f, -2.19019726e-01f,
  -7.07449019e-02f, 9.20547172e-02f, 3.68860997e-02f, -4.30456325e-02f, 1.34350345e-01f, -1.50865793e-01f, 4.98984056e-03f, 4.70210202e-02f, -1.94509536e-01f, 2.99924284e-01f,
  1.11181214e-01f, 8.17892477e-02f, -1.07020743e-01f, -1.17874686e-02f, -1.13658354e-01f, -1.46657050e-01f, -4.42335866e-02f, 3.33420676e-03f, -3.53789441e-02f, 4.37400602e-02f,
  -7.86809325e-02f, -1.26838341e-01f, -2.65692323e-02f, -1.61795765e-01f, -1.29922435e-01f, -1.48898751e-01f, -8.03307593e-02f, -8.71525630e-02f, -1.19262166e-01f, -5.34898899e-02f,
  -9.72712785e-02f, -7.34494925e-02f, 4.44177240e-02f, -1.59753636e-01f, -1.57464594e-01f, 1.30522647e-04f, -1.56182051e-01f, -5.78833185e-02f, -1.47344649e-01f, 9.46867222e-04f,
  1.69702116e-02f, 4.74439152e-02f, 1.25366375e-01f, 1.30108446e-01f, 3.82958502e-02f, 3.88956591e-02f, 1.20716561e-02f, -4.78605554e-03f, -3.15406062e-02f, 2.97965948e-02f,
  7.95954689e-02f, -1.83106530e-02f, 6.25006855e-02f, 2.53935829e-02f, 6.73851669e-02f, 5.82363605e-02f, -3.69058922e-02f, 8.66138339e-02f, 6.28658533e-02f, 6.56480342e-02f,
  5.41022904e-02f, 3.30757909e-02f, 7.89323077e-03f, -5.05557396e-02f, 2.61512753e-02f, 1.46009158e-02f, -6.99989423e-02f, 3.85795906e-02f, 1.10372409e-01f, 1.06752589e-01f,
  4.40499373e-02f, -1.91723153e-01f, -4.94384319e-02f, -1.48472562e-01f, -1.16642430e-01f, 9.19488911e-03f, -4.69020642e-02f, -1.35604247e-01f, -1.63917262e-02f, -5.87873198e-02f,
  1.80544506e-03f, -2.91928109e-02f, 1.16948336e-02f, 2.67524198e-02f, -1.58818960e-01f, -5.81422970e-02f, -1.42633453e-01f, -1.74924478e-01f, -1.41839281e-01f, -2.99173426e-02f,
  -6.39489740e-02f, -5.41610755e-02f, -4.76405810e-04f, 4.06323783e-02f, -9.04900506e-02f, -4.18950170e-02f, -4.92156558e-02f, -1.02660827e-01f, -1.22348264e-01f, -1.79632008e-02f,
  -8.40183869e-02f, 3.48235786e-01f, 8.04629177e-02f, -1.07933007e-01f, 1.02136850e-01f, -7.86416307e-02f, 8.64326730e-02f, 1.04379524e-02f, -9.76800397e-02f, 1.95599616e-01f,
  1.52594000e-01f, -1.30894452e-01f, -2.46579975e-01f, -3.00553262e-01f, -3.44372958e-01f, 1.23404339e-01f, 8.33595991e-02f, -2.36590356e-01f, -4.92607713e-01f, -2.78686881e-01f,
  5.02220634e-03f, -1.27194136e-01f, -1.81900099e-01f, -2.05598295e-01f, 2.67324001e-01f, -1.24307543e-01f, 1.59901865e-02f, 1.59414709e-02f, 1.07353255e-01f, 3.28380048e-01f,
  -3.99298333e-02f, 1.14221886e-01f, -1.91319838e-01f, -8.53815954e-03f, 1.34813786e-01f, 6.13258667e-02f, 6.35522753e-02f, 1.70525052e-02f, -5.82576133e-02f, -4.40835729e-02f,
  -7.62246475e-02f, 1.33157456e-02f, -6.75787330e-02f, -1.05285188e-02f, -5.38306609e-02f, -6.86316341e-02f, 3.58768888e-02f, -1.15134278e-02f, -9.05752257e-02f, 9.12546064e-04f,
  1.21483579e-01f, 1.13412127e-01f, 1.45813338e-02f, 6.12501614e-02f, 7.10228225e-03f, -8.45570210e-03f, -5.54227196e-02f, 1.18797738e-02f, -1.68576709e-03f, 3.05155702e-02f,
  1.05023891e-01f, -2.46195961e-02f, 2.80567110e-02f, -7.20200837e-02f, -5.35274334e-02f, 1.46903172e-02f, -4.04596776e-02f, 5.77449240e-02f, -3.96669768e-02f, -4.89552841e-02f,
  7.18291551e-02f, 6.78385198e-02f, 3.11794262e-02f, 5.33825867e-02f, 4.69415188e-02f, -2.03054696e-02f, -1.27439639e-02f, -5.26692532e-02f, 3.60514745e-02f, 3.52172628e-02f,
  -1.59701034e-02f, -4.63430472e-02f, 5.09341173e-02f, 1.93636212e-02f, -3.21271010e-02f, -7.46243596e-02f, 7.11925142e-03f, -4.96383421e-02f, -4.39693406e-02f, -1.19884091e-03f,
  -2.98206300e-01f, -3.13671499e-01f, -5.98763376e-02f, -8.47063959e-02f, -5.12573421e-02f, -1.82725880e-02f, 2.95985211e-03f, 2.28573680e-02f, 2.02116594e-02f, -7.49434531e-02f,
  -6.36417344e-02f, -9.96284783e-02f, -9.67273489e-02f, 5.50187528e-02f, 3.36375758e-02f, -5.34519926e-02f, 1.55273989e-01f, -1.47777505e-03f, -1.59170367e-02f, 8.94696489e-02f,
  2.94602923e-02f, 4.93927533e-03f, -1.20763645e-01f, -1.64362099e-02f, -1.04405150e-01f, -8.82354826e-02f, -1.49571076e-01f, 4.75042015e-02f, -1.37807786e-01f, -3.69689837e-02f,
  -3.27091008e-01f, 3.22960228e-01f, 2.25560442e-01f, -1.71297923e-01f, 1.33614600e-01f, 3.54753458e-03f, 9.88067836e-02f, -1.67830493e-02f, -1.52593240e-01f, 5.28831482e-02f,
  -2.38752775e-02f, -1.69138953e-01f, -1.11841947e-01f, -5.68254963e-02f, -3.55800912e-02f, 2.33542472e-01f, 2.48559847e-01f, 1.14909224e-02f, -1.34126335e-01f, -2.11119592e-01f,
  -4.94775437e-02f, 6.32109717e-02f, -8.44829623e-03f, 1.30461724e-02f, 2.32386917e-01f, 3.66595425e-02f, 3.38102400e-01f, 1.62883610e-01f, 1.07079819e-01f, 3.57885838e-01f,
  -6.40569106e-02f, 6.15161285e-02f, -1.97928324e-02f, 3.57614947e-03f, 1.21505007e-01f, 2.23225597e-02f, 8.27249736e-02f, 1.00950733e-01f, 8.25653672e-02f, 6.31470010e-02f,
  1.16449464e-02f, -7.87554216e-03f, 1.92438997e-02f, 1.00232042e-01f, 1.38137594e-01f, 4.57103103e-02f, 9.93609875e-02f, 1.36263013e-01f, 8.16982314e-02f, 1.02766335e-01f,
  9.94429663e-02f, 1.92220479e-01f, 6.35925457e-02f, 1.45839363e-01f, 5.90624698e-02f, -1.96074415e-03f, 2.29970083e-01f, 6.64498582e-02f, 1.64814621e-01f, 2.18915552e-01f,
  -6.14840463e-02f, -1.67735189e-01f, -9.38117802e-02f, -3.06608789e-02f, -3.34668308e-02f, -1.91414505e-02f, 4.03055102e-02f, -2.67828908e-02f, -2.19402183e-02f, 1.90679617e-02f,
  -3.29670273e-02f, -7.94621010e-04f, 2.31687329e-03f, 3.36208083e-02f, -1.47160757e-02f, 5.15809990e-02f, 1.51517568e-02f, 8.47906545e-02f, 3.38788740e-02f, -2.33340841e-02f,
  -6.28889212e-03f, -9.50688720e-02f, 4.57079150e-02f, 2.74936035e-02f, -2.45171823e-02f, -5.66159822e-02f, 1.26068564e-02f, 1.78627092e-02f, -6.22387640e-02f, 3.72986943e-02f,
  -4.36347201e-02f, 6.94995672e-02f, -2.44308300e-02f, -4.69803177e-02f, -3.12604122e-02f, 1.52400723e-02f, 4.81595173e-02f, 3.01620364e-02f, -1.42526738e-02f, 9.95377675e-02f,
  9.88761336e-03f, -3.38938497e-02f, 9.94392559e-02f, -1.04565965e-02f, 2.64678095e-02f, 5.41085899e-02f, 6.55268729e-02f, 9.90551412e-02f, 1.78795159e-02f, 3.83392945e-02f,
  3.59871127e-02f, -7.05460086e-02f, -1.03171609e-01f, 2.03474388e-02f, 2.44795568e-02f, -1.03223801e-01f, -8.79584998e-02f, 1.95172559e-02f, -1.13537915e-01f, 2.49233227e-02f,
  4.12574977e-01f, 3.05890977e-01f, -1.46121442e-01f, 1.54765472e-01f, 5.87492846e-02f, 3.69339995e-02f, 2.85005927e-01f, 3.00388187e-02f, -2.07679011e-02f, 7.49598145e-02f,
  -5.76339550e-02f, -2.10199550e-01f, -1.27330527e-01f, -2.41424859e-01f, -1.16230272e-01f, 3.86677012e-02f, 9.75432023e-02f, -1.51211023e-01f, -1.97733015e-01f, 5.70869260e-02f,
  -2.65020262e-02f, 2.19643354e-01f, 1.29684284e-01f, -7.39689618e-02f, 5.32719679e-02f, -1.16272777e-01f, -6.34652302e-02f, 1.33157402e-01f, 1.77706834e-02f, 3.67020294e-02f,
  -8.25945362e-02f, 2.45433107e-01f, -2.87989266e-02f, 5.58524877e-02f, 7.33602270e-02f, -2.16841712e-04f, -4.00089324e-02f, -4.91530634e-02f, 1.34668723e-02f, 1.07215628e-01f,
  -4.24712710e-02f, 1.10971220e-01f, -2.11138241e-02f, -1.57886259e-02f, 1.41679674e-01f, 1.31479383e-01f, 8.64338130e-02f, 8.64703730e-02f, 6.72058985e-02f, 9.04448051e-03f,
  -3.85327302e-02f, 6.64899945e-02f, 3.09833549e-02f, 2.22114064e-02f, -9.43279341e-02f, 1.41213816e-02f, 7.71795660e-02f, 9.43611376e-03f, -2.49708258e-02f, 4.92440797e-02f,
  6.04401976e-02f, -5.28890938e-02f, 3.65977995e-02f, -2.48580379e-03f, 3.73642705e-02f, -3.33439166e-05f, 6.34299591e-02f, -5.42823598e-02f, 7.36880004e-02f, 5.93946315e-02f,
  -1.17339604e-02f, -3.22206281e-02f, -2.60597058e-02f, 9.68615059e-03f, -1.60729572e-01f, 2.24087145e-02f, -1.24737332e-02f, -6.32183999e-02f, -2.89350450e-02f, 4.08585221e-02f,
  -1.11727873e-02f, 2.86143720e-02f, -8.20763037e-02f, -2.01134607e-02f, -1.05004862e-01f, -7.52655342e-02f, -3.33985761e-02f, 1.25615075e-02f, -5.31720147e-02f, 2.38784403e-02f,
  -1.37757927e-01f, -1.67629793e-01f, 9.29476228e-03f, -2.55868100e-02f, 9.42907557e-02f, 4.24384698e-02f, 1.47861987e-02f, 5.39893247e-02f, 9.58013162e-02f, -2.05692239e-02f,
  1.31313398e-01f, 4.05519009e-02f, 2.86863670e-02f, 1.01202086e-01f, 6.70989454e-02f, -4.16150056e-02f, 3.11374422e-02f, -2.38575041e-02f, -1.47695988e-02f, 8.74664783e-02f,
  5.53386100e-02f, 5.28599583e-02f, 8.55174810e-02f, -2.70775035e-02f, 4.68308665e-02f, 8.02170932e-02f, 7.68533498e-02f, 3.72294034e-03f, 7.35579384e-03f, 1.53069377e-01f,
  -9.63941962e-03f, -9.91220847e-02f, -1.23980306e-01f, -1.29791290e-01f, -8.88123959e-02f, -2.31139705e-01f, -3.94592553e-01f, -7.85030723e-02f, -4.59104627e-02f, -8.80819634e-02f,
  -3.79578993e-02f, 2.32376650e-01f, 1.87177405e-01f, 1.11947693e-01f, -4.01371531e-02f, -2.40675330e-01f, -2.65394241e-01f, 8.60045403e-02f, 8.43569711e-02f, -5.13491072e-02f,
  -1.05764158e-03f, 5.75504713e-02f, 1.41255632e-01f, 5.25913686e-02f, -1.19863227e-01f, 3.16474624e-02f, -7.92546868e-02f, -8.47686976e-02f, -1.36097744e-02f, -1.59313381e-01f,
  -9.35220569e-02f, -1.48886189e-01f, 6.73240870e-02f, 1.66593026e-02f, -7.24266693e-02f, -9.62482765e-02f, -4.31784764e-02f, 5.52628487e-02f, 7.65685141e-02f, -6.73514083e-02f,
  -5.80150895e-02f, -2.26815790e-03f, -4.48639272e-04f, -3.21602635e-02f, -5.02123758e-02f, -1.69423580e-01f, -1.10699452e-01f, -8.53688046e-02f, -9.81020108e-02f, -8.75988305e-02f,
  -1.79250851e-01f, 5.93599156e-02f, -1.58880632e-02f, 1.49973352e-02f, -4.01428388e-03f, 8.39867145e-02f, -1.75948367e-02f, -3.46415751e-02f, 8.86024609e-02f, -1.25228599e-01f,
  -4.95260432e-02f, -9.45968181e-02f, -1.33189142e-01f, -2.10801882e-04f, -1.21866323e-01f, -2.99242651e-03f, -2.11791042e-02f, -1.05654649e-01f, 2.48392187e-02f, 8.35196227e-02f,
  -2.27221213e-02f, -1.04980782e-01f, -1.19837718e-02f, -9.73599851e-02f, -4.61628214e-02f, -5.69773354e-02f, -6.95337430e-02f, -4.67015207e-02f, 3.01764496e-02f, 4.39591380e-03f,
  -9.87234712e-03f, -6.95913434e-02f, 3.27087305e-02f, -5.35046458e-02f, -1.34095803e-01f, -7.53849670e-02f, -1.22851305e-01f, 3.41860540e-02f, 3.08261365e-02f, 8.22420567e-02f,
  9.40293521e-02f, 1.35206103e-01f, -5.67546524e-02f, -4.78803692e-03f, -7.46545196e-02f, -1.31676043e-03f, -6.40765950e-02f, 3.17702256e-02f, 3.84825505e-02f, 5.53090870e-02f,
  1.58800166e-02f, 1.77936424e-02f, -1.09830841e-01f, -5.74708059e-02f, 1.57493576e-02f, 4.86074276e-02f, -8.17098394e-02f, 2.04082243e-02f, -2.91117909e-03f, -9.00513604e-02f,
  -6.51317388e-02f, -1.25203699e-01f, -2.12378837e-02f, -4.96091284e-02f, -1.33685753e-01f, 4.32645567e-02f, 1.12648338e-01f, -1.19397648e-01f, 8.86540208e-03f, -5.67804277e-02f,
  1.52174681e-01f, -3.45750660e-01f, 2.60196149e-01f, -2.04295173e-01f, -2.40795404e-01f, 1.10841498e-01f, 3.71613018e-02f, -1.59696452e-02f, -1.12905532e-01f, -1.64834335e-01f,
  -2.07030207e-01f, -6.82204366e-02f, -2.14366447e-02f, 5.56716174e-02f, 1.57923847e-01f, 2.34566070e-02f, 5.58097921e-02f, 2.49967277e-01f, 3.25125277e-01f, 8.64085555e-02f,
  -1.24334224e-01f, 6.09807018e-03f, -1.00612827e-03f, 6.01530410e-02f, -2.04582419e-02f, -7.76372897e-03f, -2.09399145e-02f, -8.64466354e-02f, 1.96478944e-02f, -1.58023819e-01f,
  3.01929146e-01f, -1.42135501e-01f, 3.89401205e-02f, -1.12009816e-01f, -1.15099058e-01f, -8.30041617e-03f, -3.24791437e-03f, -2.58294046e-02f, -5.64123057e-02f, -2.57581361e-02f,
  -2.31127053e-01f, -1.07293464e-01f, -1.83136016e-03f, -4.43352200e-02f, -7.01796217e-03f, -1.32608861e-02f, -2.33054776e-02f, 5.72516248e-02f, -6.14501312e-02f, 1.35181621e-02f,
  -1.52243912e-01f, -2.07336739e-01f, -5.56759685e-02f, 1.09742666e-02f, -5.18304482e-03f, -1.60695598e-01f, 2.84170522e-03f, 3.00459024e-02f, -1.18277490e-01f, -3.27066891e-02f,
  1.20739769e-02f, -9.09622014e-02f, -1.93723869e-02f, -1.37620941e-01f, -1.08129531e-01f, -8.78320038e-02f, -7.30559230e-02f, -9.33698416e-02f, 2.40598004e-02f, 2.02422198e-02f,
  1.13816494e-02f, -2.86595933e-02f, -1.44236311e-01f, -4.80366573e-02f, -1.82041351e-03f, -1.04447514e-01f, 1.44844281e-03f, -4.96935956e-02f, -8.85667875e-02f, 2.57529076e-02f,
  -1.60314798e-01f, -7.95623437e-02f, -1.10795945e-01f, 3.62878926e-02f, 3.06217931e-02f, -4.65921722e-02f, -2.96429116e-02f, -1.03917316e-01f, -5.87385371e-02f, 2.47832574e-02f,
  -1.11140721e-02f, -1.00175776e-01f, 9.61845964e-02f, 2.01785546e-02f, 1.16306869e-03f, 3.26793492e-02f, -1.12102062e-01f, -1.22354202e-01f, -7.86731243e-02f, -4.33279127e-02f,
  7.63203502e-02f, 6.96806833e-02f, -9.14420411e-02f, -1.12292906e-02f, -3.76632903e-03f, 2.59853378e-02f, 7.24471267e-03f, -4.05925699e-02f, -7.40488991e-02f, -4.91909450e-04f,
  -1.00447610e-01f, 2.58204881e-02f, 3.40294279e-02f, 1.73381884e-02f, -2.68770624e-02f, -8.77314210e-02f, 2.00261883e-02f, 9.89514366e-02f, 2.70662364e-02f, 1.66025564e-01f,
  -1.38207063e-01f, -1.22717962e-01f, -1.69484466e-01f, 1.13428652e-01f, 1.37053803e-01f, 1.80815594e-04f, -3.34228426e-01f, 9.61094454e-04f, 1.46813989e-01f, -5.59872277e-02f,
  3.25469859e-02f, 1.17882632e-01f, 2.01781690e-01f, 7.76866972e-02f, -1.19059205e-01f, -2.65979171e-01f, -1.16782188e-01f, 2.11047772e-02f, 8.44674185e-02f, -4.97408677e-03f,
  9.69416276e-02f, 1.07689142e-01f, -3.45380306e-02f, 7.74566755e-02f, -1.65127907e-02f, 2.64597833e-01f, 1.06895544e-01f, -4.42267917e-02f, 1.28448680e-01f, -1.00888014e-02f,
  -1.60898045e-01f, 4.72070096e-04f, -4.06257287e-02f, -5.51131964e-02f, 1.26508428e-04f, 6.19272590e-02f, -4.33734655e-02f, -2.73038410e-02f, -1.16376560e-02f, -1.40873328e-01f,
  -3.51547264e-02f, 2.19045542e-02f, 9.35506523e-02f, 6.78549185e-02f, -5.76664321e-02f, -5.52274995e-02f, -5.68403192e-02f, -2.58490201e-02f, -1.12440266e-01f, -1.49788529e-01f,
  -3.40650491e-02f, -6.85723051e-02f, -4.90259044e-02f, 1.40704783e-02f, -3.67049016e-02f, -6.00678325e-02f, 2.05057617e-02f, -5.07364608e-02f, 8.43308568e-02f, -1.65684327e-01f,
  1.27355412e-01f, 1.28685078e-02f, -2.15461496e-02f, -3.49335149e-02f, -1.04152419e-01f, -7.51491040e-02f, 2.11651493e-02f, -3.58081385e-02f, -6.01159558e-02f, -7.89282620e-02f,
  -2.34406609e-02f, -3.24816778e-02f, -1.52679617e-02f, -1.48525406e-02f, -5.40684201e-02f, -1.00183688e-01f, 3.66058014e-02f, -9.76596549e-02f, -8.42572376e-02f, -4.94836494e-02f,
  -1.18276663e-01f, -4.07364704e-02f, -7.34678358e-02f, -7.68670961e-02f, -2.85643842e-02f, -1.65179878e-01f, -1.51298031e-01f, -9.44674201e-03f, -2.09438242e-02f, -8.73065069e-02f,
  1.67697236e-01f, 7.64703080e-02f, -9.44476277e-02f, -7.68644512e-02f, -1.15358233e-01f, 5.53354919e-02f, -4.08633798e-02f, -1.47604551e-02f, 2.76311394e-03f, -1.84945017e-02f,
  -7.75387436e-02f, 5.80488108e-02f, 5.85318543e-02f, 9.66667160e-02f, 1.05623975e-01f, 5.94138280e-02f, -4.96591516e-02f, -2.31867153e-02f, -4.94436733e-03f, -4.59524468e-02f,
  -2.37906966e-02f, -1.39320105e-01f, -2.10775062e-01f, -1.46036437e-02f, -1.85914747e-02f, 1.57986432e-02f, -7.44188800e-02f, 6.55797636e-03f, -7.31817335e-02f, -1.34958059e-01f,
  -4.23412234e-01f, 4.66835173e-03f, 2.71941982e-02f, -1.24369405e-01f, 9.62959602e-02f, 1.69670843e-02f, -7.19223395e-02f, -7.04394355e-02f, -2.97996379e-03f, -6.13637194e-02f,
  6.99819848e-02f, 7.90747181e-02f, 1.25987694e-01f, 8.99612010e-02f, -1.33686289e-02f, -1.13945995e-02f, 3.25917825e-02f, -8.24485943e-02f, 1.07734039e-01f, 1.32849976e-01f,
  6.38662577e-02f, -1.52718887e-01f, -4.38737907e-02f, 7.33148679e-02f, -7.95502812e-02f, 5.27942665e-02f, -2.17700452e-02f, -5.28643169e-02f, 9.59501341e-02f, -2.11561788e-02f,
  -9.57441777e-02f, -1.00798003e-01f, 1.51473552e-03f, -3.61456834e-02f, 1.63006503e-02f, -4.61465418e-02f, -3.36724296e-02f, -6.34167269e-02f, 1.82057023e-02f, 1.26384581e-02f,
  1.19918428e-01f, 6.61931187e-02f, -7.56794661e-02f, -4.79822941e-02f, -1.50963105e-02f, 3.92392240e-02f, 7.03380108e-02f, -1.82002818e-03f, 2.37927269e-02f, -4.77167107e-02f,
  -3.27714607e-02f, 1.47242043e-02f, -9.41612199e-02f, 3.08408570e-02f, 4.36431989e-02f, 6.30428344e-02f, 8.07413310e-02f, -4.25178073e-02f, -3.48210707e-02f, -2.08060429e-01f,
  -7.64674097e-02f, -6.37893826e-02f, -1.50701404e-02f, -1.18086606e-01f, 8.79919156e-03f, 5.66706359e-02f, 9.33869109e-02f, -1.86279211e-02f, 1.76322963e-02f, -3.78345661e-02f,
  1.86403878e-02f, -1.02355197e-01f, -5.40361963e-02f, -2.25684345e-02f, 1.57701343e-01f, 4.74058427e-02f, 6.21156804e-02f, 8.26337934e-02f, 6.78306744e-02f, -7.74630532e-02f,
  1.15410246e-01f, 3.75616481e-03f, 1.26185328e-01f, -1.29158497e-02f, 1.91717409e-02f, 1.33208275e-01f, -1.36857992e-02f, 1.38408661e-01f, -2.11479757e-02f, 4.00350504e-02f,
  1.32571841e-02f, 1.72721952e-01f, -9.79341567e-02f, -9.94655862e-02f, 4.27948162e-02f, -4.95340861e-02f, -3.58745977e-02f, -1.07422970e-01f, 8.45203549e-02f, -7.22166672e-02f,
  1.02635445e-02f, 1.64988171e-02f, -3.32148038e-02f, 3.42793241e-02f, -1.18337095e-01f, 4.27095965e-02f, 2.30929870e-02f, -6.86929747e-02f, -1.04014248e-01f, -9.26643312e-02f,
  -2.34101377e-02f, -1.04044408e-01f, -5.49861640e-02f, -1.44387096e-01f, -1.13019951e-01f, -1.63043961e-01f, -9.70414504e-02f, -8.15554857e-02f, -1.11080058e-01f, -2.05703020e-01f,
  1.13544434e-01f, -2.58024782e-01f, 4.53423010e-03f, -1.73014998e-02f, -2.52646238e-01f, -3.69317144e-01f, -6.04498565e-01f, -2.56501079e-01f, 4.50817756e-02f, -2.22457528e-01f,
  -4.10565473e-02f, 2.51920521e-01f, 3.14641118e-01f, 1.51206896e-01f, 1.01777306e-02f, -1.83885396e-01f, -1.25984281e-01f, 8.47256109e-02f, 1.60865020e-02f, -2.30044156e-01f,
  -7.66667426e-02f, -6.23004548e-02f, 1.57340780e-01f, 1.38175581e-02f, -4.45322134e-02f, 3.13061476e-02f, -3.81751359e-02f, -1.09107226e-01f, -1.62535056e-01f, 1.27438039e-01f,
  1.24590203e-01f, 7.74376690e-02f, 8.79516006e-02f, -2.61448324e-02f, 6.62395358e-02f, -2.57131495e-02f, -5.35346530e-02f, 4.20251600e-02f, 3.76013368e-02f, -5.72895966e-02f,
  1.32992994e-02f, 6.34693652e-02f, -1.94685999e-02f, 3.99746671e-02f, -6.25782013e-02f, -1.23602241e-01f, -2.31932476e-02f, 1.02755371e-02f, 9.66398269e-02f, -2.82356869e-02f,
  -8.73376727e-02f, -4.15602745e-03f, -1.31229252e-01f, -9.33425203e-02f, 2.03703362e-02f, 7.13842362e-02f, 3.52286082e-03f, 3.73847298e-02f, -9.20829847e-02f, 3.10662296e-03f,
  2.85072103e-02f, 7.06663653e-02f, -1.87101513e-02f, -1.09393131e-02f, 4.95651178e-03f, -1.37805264e-03f, 1.09084301e-01f, -2.33202986e-02f, 6.85437769e-02f, 3.17925699e-02f,
  2.95226611e-02f, 5.79913855e-02f, -1.98465418e-02f, -3.54035683e-02f, -7.94689581e-02f, -5.09552211e-02f, 3.03615648e-02f, 1.06185516e-02f, 2.61376780e-02f, 3.32819298e-02f,
  1.84578840e-02f, 3.73349315e-03f, 1.72546413e-02f, 7.86595047e-03f, -1.17397234e-02f, -4.29109931e-02f, 2.48407163e-02f, -4.07457091e-02f, -3.17100971e-03f, -5.31888902e-02f,
  1.72806293e-01f, -3.32675539e-02f, -3.73589098e-02f, -2.04233304e-02f, -2.06484944e-02f, 3.04342695e-02f, 1.90963468e-03f, -7.68982619e-02f, -5.08971326e-02f, -8.26018751e-02f,
  -6.24304526e-02f, -6.01665638e-02f, -7.87523948e-03f, -3.97400334e-02f, 9.47853550e-03f, -2.29799096e-03f, -1.60203099e-01f, -4.05131700e-03f, 1.27844838e-02f, -9.36502814e-02f,
  -1.64886653e-01f, -1.43467173e-01f, -8.02255236e-04f, -7.39086866e-02f, -9.88782290e-03f, -3.86538245e-02f, -1.28389239e-01f, -1.38842195e-01f, -1.01552121e-01f, -1.37156323e-01f,
  -2.85024971e-01f, 3.20763588e-01f, -1.05170161e-01f, 1.47043616e-02f, 5.44028282e-02f, -7.44153410e-02f, -1.71265081e-02f, -1.21732794e-01f, -1.23269685e-01f, -2.34473497e-02f,
  1.74773380e-01f, -5.21245264e-02f, -7.01465309e-02f, -1.42517909e-01f, -1.49981856e-01f, 6.85197413e-02f, 9.96962190e-02f, -1.78306043e-01f, -4.60500270e-01f, -2.19042554e-01f,
  -8.42344090e-02f, -1.41892269e-01f, -1.26355380e-01f, -2.52051145e-01f, 3.56766284e-02f, -2.59551376e-01f, 2.40723370e-03f, 6.42989203e-02f, 2.39709974e-03f, 5.49467728e-02f,
  -1.80959582e-01f, 1.08415782e-02f, -2.56380051e-01f, -1.47822693e-01f, -7.58994222e-02f, -1.75537243e-01f, -8.04046616e-02f, -2.12732494e-01f, -1.25607207e-01f, -2.97895279e-02f,
  -1.76062927e-01f, -7.82632753e-02f, -1.99213848e-02f, -1.23998605e-01f, -1.92272156e-01f, -1.86205909e-01f, -6.49159923e-02f, -1.70523882e-01f, -2.48501673e-01f, -8.16150978e-02f,
  -1.01417884e-01f, -1.07263871e-01f, -1.36994302e-01f, -1.26876920e-01f, -1.51986361e-01f, -2.16123983e-01f, -3.46072875e-02f, -2.06629068e-01f, -1.11017078e-01f, -2.91498024e-02f,
  6.89864978e-02f, 1.59268439e-01f, 7.07455799e-02f, 1.91309661e-01f, 1.18414082e-01f, 1.36026278e-01f, 1.94713533e-01f, 9.55159217e-02f, 1.03038989e-01f, 9.59487259e-02f,
  4.96137515e-02f, 7.08939135e-02f, 1.85255811e-01f, 9.93493348e-02f, 5.81931174e-02f, 1.62125155e-01f, 6.63864464e-02f, 7.60885328e-02f, 9.66244265e-02f, 4.27768268e-02f,
  9.04714093e-02f, 4.11699042e-02f, 2.44020279e-02f, 1.36264116e-01f, 1.45205498e-01f, 1.64795488e-01f, 5.92739135e-02f, 9.66270044e-02f, -1.19030494e-02f, 1.67796791e-01f,
  -2.28937104e-01f, -6.99353665e-02f, -1.50515079e-01f, -2.35958070e-01f, -2.39852160e-01f, -2.44373053e-01f, -1.09633908e-01f, -1.01789936e-01f, -9.75203887e-02f, -5.37182987e-02f,
  -1.78991750e-01f, -1.65048957e-01f, -3.33944261e-02f, -1.18182346e-01f, -1.45860806e-01f, -1.39309049e-01f, -1.42684162e-01f, -1.88319162e-01f, -2.45317131e-01f, -1.44592673e-01f,
  -1.81651577e-01f, -2.66070634e-01f, -3.63263249e-01f, -1.94192469e-01f, -7.12916553e-02f, -2.97098488e-01f, -2.00296104e-01f, -2.13144287e-01f, -2.20599696e-01f, -1.17975742e-01f,
  -7.86791220e-02f, 2.60725170e-01f, 2.91249275e-01f, 1.90955341e-01f, 1.48661643e-01f, 2.05434561e-01f, 1.76718831e-01f, -1.82886273e-02f, -2.37359703e-02f, 2.62726516e-01f,
  8.53409152e-03f, 6.31011650e-02f, 5.98798245e-02f, 6.23345859e-02f, 1.24313660e-01f, 2.86270499e-01f, 1.85509250e-01f, -6.93708099e-03f, -1.65176541e-02f, 1.19194046e-01f,
  1.16125554e-01f, 2.59685400e-03f, -8.85409340e-02f, -5.22686616e-02f, 1.02913849e-01f, 1.11043341e-01f, 6.62311912e-02f, 6.74336255e-02f, 4.63953614e-02f, 1.32635057e-01f,
  2.02471241e-01f, -1.59762144e-01f, 3.47262174e-02f, -4.55412604e-02f, 1.36288047e-01f, 2.00001355e-02f, 1.35314047e-01f, -1.26260966e-01f, -8.31620917e-02f, 6.95941299e-02f,
  -1.11340322e-02f, -6.20180517e-02f, -3.17278244e-02f, -9.27829966e-02f, 6.89083198e-03f, 4.35714349e-02f, -1.23551272e-01f, 4.39210534e-02f, 1.08609777e-02f, 9.94492546e-02f,
  9.18985158e-03f, -9.12420079e-02f, -2.98794564e-02f, 1.80344936e-02f, 7.90470839e-02f, 5.78602254e-02f, 3.87086794e-02f, -9.63828117e-02f, -4.44829576e-02f, -2.91290656e-02f,
  5.39495647e-02f, -4.49948944e-02f, -1.96079891e-02f, -4.86612394e-02f, -4.08175625e-02f, -1.09344363e-01f, -1.08830266e-01f, 4.91434000e-02f, -1.07404083e-01f, -2.07535148e-01f,
  -1.14251867e-01f, 9.48294159e-03f, -5.22648990e-02f, -2.74526235e-02f, -2.20746752e-02f, -1.14594586e-01f, -1.49991393e-01f, 3.69080417e-02f, -1.33818507e-01f, -9.25508216e-02f,
  -2.37565711e-02f, -1.47995785e-01f, -5.69250388e-03f, 2.15059556e-02f, -1.04065999e-01f, 4.92797196e-02f, -4.19190200e-03f, -7.68866464e-02f, -6.57480443e-03f, -1.30927280e-01f,
  8.96544978e-02f, -3.55822891e-02f, 1.53023422e-01f, 2.15940252e-02f, -9.54147503e-02f, -4.25827317e-02f, -1.32216021e-01f, -1.44483358e-01f, 4.78875563e-02f, -8.73234030e-03f,
  -3.65078971e-02f, -1.44761458e-01f, -1.44581631e-01f, -1.17172763e-01f, -7.23519623e-02f, 1.90136917e-02f, -8.28447491e-02f, -9.97846667e-03f, 2.40637884e-02f, -1.34812877e-01f,
  -1.42159939e-01f, -6.79916292e-02f, -5.35474867e-02f, -4.53870744e-02f, 1.27193220e-02f, -2.59671155e-02f, -5.40478230e-02f, -4.27017882e-02f, -1.26697704e-01f, -1.24298874e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.25347534e-01f, 2.03536168e-01f, 2.73500443e-01f, 2.52291769e-01f, 2.94837803e-01f, 5.15564203e-01f, 5.82461417e-01f, 3.06879789e-01f, 5.26498966e-02f, 8.59043822e-02f,
  1.73600223e-02f, -1.35874286e-01f, -2.82897074e-02f, -7.94154126e-03f, 1.62504777e-01f, 2.13035360e-01f, 1.55105576e-01f, -2.22229213e-02f, -7.79453665e-02f, 8.15535486e-02f,
  4.01025228e-02f, -3.33652571e-02f, -2.29528606e-01f, -1.66802496e-01f, 6.55811131e-02f, -2.00521991e-01f, 1.54024228e-01f, 9.45861861e-02f, 8.22291300e-02f, -1.47701219e-01f,
  -3.95376198e-02f, 2.56187022e-01f, -1.29090235e-01f, -1.54666886e-01f, -9.75280181e-02f, -2.21049771e-01f, -2.40053441e-02f, -6.43119588e-02f, -4.80802096e-02f, -7.00021684e-02f,
  -1.29310638e-01f, -2.09479108e-01f, -2.22883746e-02f, 2.63530412e-03f, 6.66835811e-03f, -1.42137527e-01f, -5.92722520e-02f, 1.51238933e-01f, 1.74927592e-01f, 7.36828372e-02f,
  1.03638750e-02f, 1.25867292e-01f, 3.38394165e-01f, 1.91129014e-01f, 1.02612443e-01f, -3.44243795e-02f, 1.02899261e-01f, -4.80383784e-02f, 1.39175504e-01f, -7.18204975e-02f,
  3.49777751e-02f, -6.01237593e-03f, -5.24917105e-03f, -1.74307246e-02f, -2.31649354e-02f, -4.70623747e-02f, -9.50191021e-02f, -1.57658719e-02f, 1.50473475e-01f, -5.61670922e-02f,
  -4.66012210e-02f, 1.77268863e-01f, 2.16137636e-02f, 1.49583025e-02f, -1.03624195e-01f, 8.98294598e-02f, 2.20068656e-02f, -2.20069084e-02f, -2.54166946e-02f, -3.90543789e-02f,
  1.01545192e-01f, 1.21424466e-01f, 1.09306583e-02f, 6.60289032e-03f, -2.52911597e-02f, -1.00052513e-01f, 7.29110884e-03f, -4.67892028e-02f, -5.32293022e-02f, -1.39151430e-02f,
  2.14547962e-01f, 3.64394844e-01f, -1.75411895e-01f, -5.11112101e-02f, -9.54322424e-03f, -1.33481741e-01f, 2.29649041e-02f, -5.60505427e-02f, -5.34605421e-02f, -5.32587804e-02f,
  3.63943190e-03f, -1.64122194e-01f, -5.86912706e-02f, -4.47239814e-04f, -2.38189608e-01f, -1.10657528e-01f, -5.27508697e-03f, 1.46151125e-01f, 5.98026924e-02f, -7.36818537e-02f,
  -7.11980388e-02f, 1.09668761e-01f, 7.48511925e-02f, 6.74650893e-02f, 1.16922349e-01f, -6.08976148e-02f, -6.90568611e-02f, -1.52496854e-02f, 7.47676790e-02f, -1.48199886e-01f,
  -1.61497638e-01f, -4.81260449e-01f, 2.37080604e-01f, 1.04551539e-01f, 1.40708178e-01f, 3.47529531e-01f, 2.14209184e-01f, -1.14792623e-02f, 2.57208478e-02f, -7.21306652e-02f,
  -7.23440945e-02f, 5.75237721e-02f, -7.79269859e-02f, 1.58098806e-02f, -3.23851071e-02f, 1.25937477e-01f, 1.19339757e-01f, 1.49598882e-01f, 2.85588831e-01f, 1.54358864e-01f,
  -3.05226091e-02f, -1.34139970e-01f, -2.86395729e-01f, -1.27541035e-01f, -2.22237661e-01f, -2.05190908e-02f, -4.49408703e-02f, -1.08832233e-01f, -6.18102923e-02f, -1.83265507e-01f,
  4.88160461e-01f, 7.27649033e-02f, 1.22373119e-01f, -1.15597233e-01f, 2.12884676e-02f, 4.84017283e-02f, 3.09883282e-02f, -1.29298528e-03f, -7.51618594e-02f, 6.56225458e-02f,
  -1.32840425e-01f, 3.22661810e-02f, 3.09375748e-02f, -3.18835536e-03f, 1.00710414e-01f, 3.79985496e-02f, -8.55638087e-02f, 5.73779782e-03f, -1.74121261e-02f, 1.16591476e-01f,
  9.20410920e-03f, 2.90164035e-02f, 1.43852264e-01f, 3.71514931e-02f, -2.00122911e-02f, 5.69133200e-02f, -5.39369583e-02f, -5.50312847e-02f, 6.08648323e-02f, -1.34342670e-01f,
  1.08467415e-01f, 1.64315272e-02f, 5.73250316e-02f, 8.55867565e-02f, 1.22298732e-01f, 1.77530304e-01f, 6.87881783e-02f, -5.41134663e-02f, -6.20565079e-02f, -1.29550248e-01f,
  -3.10074855e-02f, 1.67531759e-01f, 9.27740112e-02f, -8.42173677e-03f, 7.55823925e-02f, -1.89724583e-02f, 6.50094599e-02f, -7.60537237e-02f, -4.60756086e-02f, -1.24206375e-02f,
  2.23442093e-02f, -4.93307561e-02f, 1.48612596e-02f, -8.75618830e-02f, 4.33151238e-03f, -2.08968651e-02f, 5.48677035e-02f, -1.11459926e-01f, -2.00365588e-01f, -5.95760942e-02f,
  4.58742917e-01f, 1.91169858e-01f, 9.45736989e-02f, -1.04887925e-01f, 4.56078723e-02f, -1.76864237e-01f, 1.00574300e-01f, -1.61481593e-02f, 1.63031965e-01f, 1.65713757e-01f,
  5.20491414e-02f, -6.52203634e-02f, -5.21423072e-02f, -5.31175248e-02f, 1.09543353e-02f, 2.84947501e-03f, 2.17792876e-02f, 3.05906031e-02f, -5.40379295e-03f, 4.34506163e-02f,
  -3.03779207e-02f, 9.11040977e-02f, 2.64063716e-01f, 1.11742303e-01f, 3.95955965e-02f, 1.59803972e-01f, 1.17876299e-01f, 1.51259959e-01f, 1.39925063e-01f, 1.26179904e-02f,
  1.01707011e-01f, 1.83488175e-01f, 1.49386361e-01f, 4.04242933e-01f, 2.34201372e-01f, 1.18295319e-01f, 1.55257639e-02f, 1.22291729e-01f, 4.50847000e-02f, 8.32695737e-02f,
  2.94444799e-01f, 3.22646350e-01f, 2.31265381e-01f, 2.60744929e-01f, 1.68230936e-01f, 1.37756243e-01f, 5.61152361e-02f, -1.62886567e-02f, 9.90984738e-02f, 2.13010833e-02f,
  1.64895475e-01f, 3.50241084e-03f, -1.26410380e-01f, 7.27891251e-02f, 2.27749780e-01f, 2.41723388e-01f, 1.67970374e-01f, 8.19852352e-02f, 1.58046752e-01f, 4.94239330e-02f,
  4.75833043e-02f, 1.05922952e-01f, -5.13748899e-02f, -3.88075225e-02f, -1.23541772e-01f, -1.30748853e-01f, -4.09582518e-02f, -7.10146576e-02f, -4.90544476e-02f, -2.77432855e-02f,
  1.37408022e-02f, 1.69423372e-02f, -1.20243736e-01f, -1.29692912e-01f, -6.20171428e-02f, -1.43496230e-01f, -8.26817080e-02f, 1.17503494e-01f, 1.48482114e-01f, 1.01600043e-01f,
  1.55975774e-01f, 4.38429117e-02f, -6.57181740e-02f, -3.23262922e-02f, 4.80284505e-02f, 4.35003564e-02f, 8.97692889e-03f, 4.22256142e-02f, 6.94345590e-03f, -8.45702644e-03f,
  1.09130763e-01f, 2.72213039e-03f, 1.25267878e-01f, -1.52351960e-04f, -9.37666930e-03f, -1.63702220e-01f, -2.28754710e-02f, 9.21609700e-02f, 1.16967715e-01f, -3.22301872e-02f,
  -9.68861878e-02f, 1.53691292e-01f, 1.02351755e-01f, -7.69120753e-02f, 1.13101728e-01f, -2.14521196e-02f, -2.88739204e-02f, 1.96527932e-02f, -3.93855572e-02f, -2.60741226e-02f,
  8.50608572e-02f, -3.75982039e-02f, -4.54442278e-02f, 2.52947751e-02f, -3.27195339e-02f, 1.36522517e-01f, 6.51437938e-02f, 1.33382916e-01f, -2.23275460e-02f, -1.00896493e-01f,
  1.74081221e-01f, 1.72086358e-01f, -2.61057653e-02f, 6.55059367e-02f, -4.05100584e-02f, -2.30230987e-02f, 1.53385952e-01f, 2.42790617e-02f, 1.16684966e-01f, 2.56952327e-02f,
  -1.62764918e-02f, 7.82998130e-02f, -3.92937623e-02f, 1.17718693e-04f, -8.80014803e-03f, 1.13521196e-01f, 6.58653304e-02f, 1.75674826e-01f, 1.62831724e-01f, 9.82146636e-02f,
  -2.52726395e-02f, -1.86856743e-02f, 3.26803885e-02f, 3.81928757e-02f, 5.30209392e-02f, 8.75356495e-02f, -5.12960404e-02f, 4.70784158e-02f, 1.20112812e-02f, -5.77068478e-02f,
  3.44565213e-01f, 1.80165097e-01f, -2.31308758e-01f, 3.53839815e-01f, -4.27979492e-02f, -2.07207561e-01f, -1.95727453e-01f, -1.74802780e-01f, 2.26861537e-01f, 1.83576226e-01f,
  2.04067022e-01f, -1.26301602e-01f, -9.28012207e-02f, -2.90204197e-01f, -4.05325532e-01f, -1.43342495e-01f, -1.96848977e-02f, -3.59831959e-01f, -5.42341173e-01f, -4.04402167e-01f,
  -1.59954816e-01f, -2.63162889e-02f, -1.21973261e-01f, -2.17970774e-01f, 3.17867517e-01f, 1.29711982e-02f, 6.85124099e-02f, 1.10095507e-02f, -1.28028318e-01f, 2.97244877e-01f,
  -1.97823457e-02f, 4.82398011e-02f, -1.81751385e-01f, -8.44064504e-02f, 1.04850911e-01f, 8.84928927e-03f, -9.22920555e-02f, -3.05572879e-02f, -6.48722872e-02f, -6.04102015e-02f,
  6.27636611e-02f, -1.35569036e-01f, -6.90733641e-02f, -8.08757544e-03f, 5.67578012e-03f, -2.05196038e-01f, -5.88404499e-02f, -2.68145621e-01f, 1.78270191e-02f, -7.59817362e-02f,
  -6.87139481e-03f, -1.47530675e-01f, -1.60660878e-01f, -1.67052999e-01f, -1.09820664e-02f, -5.70642352e-02f, -1.29609793e-01f, -2.23075505e-02f, -2.97262371e-01f, 2.70446092e-01f,
  2.36467794e-02f, -6.36899546e-02f, -2.44923346e-02f, 5.69139645e-02f, 1.77708685e-01f, 8.84647965e-02f, 4.09746356e-02f, 3.42001691e-02f, -1.38142379e-02f, -1.16133474e-01f,
  8.42275680e-04f, 5.71912713e-02f, -9.51512083e-02f, 9.41361953e-03f, 8.99464786e-02f, -1.28743365e-01f, -5.08232750e-02f, -2.00819876e-02f, 1.32364351e-02f, -5.80662116e-02f,
  -1.13174155e-01f, -3.43655199e-02f, 1.62511989e-01f, -3.62424515e-02f, -2.95152329e-02f, 1.40958652e-02f, -3.88709605e-02f, -5.29626533e-02f, 3.44277248e-02f, 4.86336760e-02f,
  2.88529038e-01f, -3.53704184e-01f, 2.33954042e-01f, -1.90851957e-01f, -9.17322934e-02f, 1.15296058e-01f, 1.60717189e-01f, -1.51685774e-01f, 8.51467345e-03f, -9.47236493e-02f,
  -2.03624800e-01f, -1.09044559e-01f, 1.68432817e-01f, 8.11651647e-02f, 1.13571072e-02f, -1.31559461e-01f, -1.01851799e-01f, -1.84386432e-01f, -1.97079405e-01f, 2.01264769e-01f,
  -4.06976677e-02f, -8.21334347e-02f, -8.91468450e-02f, -1.80031732e-02f, 3.98253724e-02f, -1.56567976e-01f, -7.67916664e-02f, 1.69698372e-02f, -2.79265314e-01f, 6.04092106e-02f,
  5.27241111e-01f, -1.08173080e-01f, 4.66667712e-01f, 1.13965981e-01f, 7.04109520e-02f, 2.73875296e-01f, 3.43622267e-01f, 9.81330350e-02f, -2.93174386e-02f, 7.75661096e-02f,
  -1.17104575e-01f, -3.18577945e-01f, -2.50720084e-01f, -1.44054696e-01f, 1.37454644e-01f, 1.17899522e-01f, 1.01395950e-01f, 3.46109688e-01f, 3.35027516e-01f, 1.16482243e-01f,
  -2.34300524e-01f, 3.31482142e-02f, 2.65760899e-01f, 9.50715225e-03f, -8.94848779e-02f, -8.06556195e-02f, 1.20339869e-02f, 9.82396826e-02f, -9.45016742e-02f, 5.84429875e-02f,
  -8.92458931e-02f, 2.41218403e-01f, -8.09439197e-02f, -2.58814126e-01f, -7.64328316e-02f, -8.32228884e-02f, -3.58233601e-02f, 1.24541973e-03f, -4.98549491e-02f, -1.48251224e-02f,
  -1.31640315e-01f, 2.85471305e-02f, -8.28003138e-02f, -1.79892089e-02f, -3.85752656e-02f, 2.11364310e-02f, -1.56677403e-02f, 7.56343901e-02f, 6.14130907e-02f, -3.55687253e-02f,
  -2.16996983e-01f, -7.44213238e-02f, 8.05555061e-02f, 1.83930583e-02f, 1.20471761e-01f, -7.01269507e-02f, 5.32148033e-02f, 1.36104792e-01f, 2.43117344e-02f, 2.05416512e-02f,
  -5.98124079e-02f, 1.40982971e-01f, 3.41890417e-02f, -2.80095432e-02f, 1.24756517e-02f, 2.45891940e-02f, 2.61216294e-02f, 1.89405959e-02f, 7.77572906e-03f, -5.57831712e-02f,
  -1.02014698e-01f, 1.23461172e-01f, -3.38546969e-02f, 7.38484263e-02f, -9.10331681e-02f, 6.87115043e-02f, 5.12623638e-02f, -5.16693294e-02f, -4.54206727e-02f, 3.59936506e-02f,
  -2.83973683e-02f, 1.03132151e-01f, 6.47367835e-02f, -1.01042492e-02f, -1.43379986e-01f, 7.70386830e-02f, -8.36266577e-02f, -1.13991499e-01f, -4.82302420e-02f, -5.69617674e-02f,
  -6.05032802e-01f, -9.46090668e-02f, -7.83500075e-02f, -1.54690400e-01f, 1.39252916e-01f, -5.77154793e-02f, -1.23918071e-01f, -5.71638644e-02f, -7.84802884e-02f, -4.56386171e-02f,
  -2.14489512e-02f, 1.34844676e-01f, -1.14512645e-01f, -5.33612520e-02f, 9.37488955e-03f, 3.14081162e-02f, -8.47090483e-02f, -1.06838737e-02f, 3.36284749e-02f, -9.62708518e-02f,
  -9.75584835e-02f, 6.40219301e-02f, 1.02990821e-01f, -1.37565564e-02f, -4.35028188e-02f, -1.05512269e-01f, -1.12207860e-01f, 6.80789500e-02f, 6.97000325e-02f, 7.91065618e-02f,
  -6.00016788e-02f, -1.54412046e-01f, 2.65736043e-01f, 1.16279565e-01f, -1.56455755e-01f, -3.13702345e-01f, -5.79487264e-01f, -4.65945780e-01f, -2.49351170e-02f, -9.81804505e-02f,
  -9.40643623e-03f, 1.84792385e-01f, 1.40514389e-01f, 8.53792280e-02f, -1.94756791e-01f, -1.50011599e-01f, 7.25766867e-02f, 1.58577010e-01f, 4.69697127e-03f, -1.78300783e-01f,
  1.22438237e-01f, 1.19520880e-01f, 2.43596688e-01f, -5.78517914e-02f, 1.71133339e-01f, 1.04233339e-01f, 1.53325737e-01f, 1.53610572e-01f, 8.48697424e-02f, 5.67955077e-01f,
  3.96805286e-01f, -1.73097163e-01f, 7.26869851e-02f, 8.34045932e-02f, 1.22542098e-01f, -1.91851389e-02f, 6.87330142e-02f, 7.44518191e-02f, 6.77577779e-02f, -2.33957451e-02f,
  1.53017029e-01f, 3.31966244e-02f, -2.51489766e-02f, 1.16360582e-01f, 6.52859434e-02f, -3.97049487e-02f, 3.86178419e-02f, 3.28696109e-02f, 1.34765923e-01f, -4.77985851e-02f,
  -1.23119075e-02f, 5.65238521e-02f, -2.33386412e-01f, -2.64466614e-01f, 3.01823430e-02f, 1.25163168e-01f, 1.51253389e-02f, 5.29546961e-02f, -7.62284771e-02f, 6.28407598e-02f,
  -1.50362393e-02f, -2.89827120e-02f, 1.36792630e-01f, 5.83725050e-02f, 2.44143270e-02f, 5.81373535e-02f, 1.95428636e-02f, -3.20159607e-02f, 1.62544753e-02f, 3.47173549e-02f,
  -3.71479876e-02f, 3.14416154e-03f, -4.89434320e-03f, 2.76501849e-03f, -1.67398471e-02f, 5.98132536e-02f, 2.83695515e-02f, 9.67970192e-02f, -1.26170525e-02f, 5.34852631e-02f,
  8.02130550e-02f, 2.07394827e-02f, -2.28704996e-02f, -4.53511393e-03f, -3.65546681e-02f, 7.02720359e-02f, 7.21606016e-02f, 4.19474877e-02f, -2.16697361e-02f, 1.11237675e-01f,
  3.54949236e-02f, 5.01771457e-02f, 1.17133148e-01f, 4.30150935e-03f, -1.10788608e-03f, -1.01907225e-02f, 1.22295268e-01f, 4.79837470e-02f, 2.15774253e-02f, -6.37530014e-02f,
  -1.40780658e-01f, -1.16696686e-01f, -8.58849660e-02f, 9.01123881e-02f, -6.89523518e-02f, -1.25484550e-02f, -1.81145538e-02f, 2.43577699e-04f, -5.57508394e-02f, -5.75493053e-02f,
  -1.58026308e-01f, -2.58746952e-01f, -3.42623562e-01f, -2.82086939e-01f, -1.34543240e-01f, -1.74035624e-01f, -6.67462870e-02f, -6.61863238e-02f, -1.41688854e-01f, -3.52734476e-01f,
  -5.22105932e-01f, 1.05120577e-02f, -6.26296103e-02f, -1.61417678e-01f, 2.73036301e-01f, 1.93493366e-01f, 6.49289265e-02f, -8.04287419e-02f, 5.04085608e-02f, 1.30030140e-01f,
  1.43036455e-01f, 1.90036520e-02f, 3.54699306e-02f, 6.33803383e-02f, -4.34287488e-02f, 1.62339211e-01f, 1.98660702e-01f, -4.80096750e-02f, -1.55474305e-01f, -9.16515384e-03f,
  1.65395647e-01f, -2.10909396e-01f, -3.29690993e-01f, -3.06332298e-02f, -5.89176528e-02f, 3.10245045e-02f, 6.64167777e-02f, -6.64346144e-02f, 1.43606782e-01f, 1.21868968e-01f,
  -1.01851001e-01f, -2.38604337e-01f, -5.98704629e-02f, -9.60752890e-02f, 8.00933167e-02f, -5.84601313e-02f, -4.07605134e-02f, -1.38243347e-01f, -4.08283137e-02f, -7.19745979e-02f,
  9.76976082e-02f, -5.34388144e-03f, -2.42645815e-02f, -8.58365968e-02f, -5.84186763e-02f, -1.29123762e-01f, -1.06976330e-01f, -2.25662217e-01f, -2.15774447e-01f, 3.74317877e-02f,
  2.03458250e-01f, 1.40320018e-01f, -7.86547586e-02f, -3.19987349e-02f, -1.53855249e-01f, -4.59931325e-03f, -2.04799965e-01f, -1.72178581e-01f, -4.26979028e-02f, -2.34969229e-01f,
  -1.35057807e-01f, -5.65533862e-02f, -4.96420301e-02f, 3.04656327e-02f, 1.39740231e-02f, -6.64698705e-03f, -4.76436177e-03f, 1.43344223e-01f, 1.10807419e-01f, -5.37620559e-02f,
  7.76347667e-02f, 7.34448433e-02f, -5.26525937e-02f, -1.36203691e-01f, -1.56288773e-01f, 4.25570868e-02f, 1.10273436e-02f, 9.66200605e-05f, -7.24231973e-02f, -1.09219868e-02f,
  6.77916259e-02f, -3.25285606e-02f, 3.18262242e-02f, 2.23973431e-02f, -3.78740020e-02f, -1.79166570e-02f, 4.34837379e-02f, -1.61674712e-02f, -5.67642525e-02f, 9.88904238e-02f,
  -7.76303336e-02f, 1.64045971e-02f, -1.76657096e-01f, -1.13019049e-01f, -2.24554986e-02f, 3.14987451e-02f, 5.46347909e-02f, -6.45857155e-02f, 1.34694904e-01f, -9.17932689e-02f,
  -4.70913202e-02f, -1.03586875e-01f, 7.78640881e-02f, 7.15599880e-02f, 2.56679300e-02f, 1.15881309e-01f, -1.65149663e-02f, 8.94948244e-02f, 7.63361305e-02f, -9.55707673e-03f,
  3.00927041e-03f, -2.54908483e-02f, -1.98429182e-01f, 2.93783415e-02f, -4.79157455e-02f, -1.29680276e-01f, -1.49916902e-01f, -1.13122843e-01f, -1.06734872e-01f, -2.46989548e-01f,
  -4.59617704e-01f, 2.11088538e-01f, -5.59775680e-02f, -1.87400967e-01f, 1.16463117e-01f, 2.36867726e-01f, 5.36304593e-01f, 6.82540908e-02f, -3.99863012e-02f, 1.32135808e-01f,
  1.52857140e-01f, -5.08318134e-02f, 5.57562374e-02f, 1.81821268e-02f, 2.30108760e-02f, 2.42468894e-01f, 3.42831880e-01f, 2.61599227e-04f, -1.87977120e-01f, 7.98203647e-02f,
  2.01455534e-01f, -1.39525160e-01f, -4.15253967e-01f, -8.07111636e-02f, -8.43374729e-02f, -1.33762985e-01f, -8.78838599e-02f, -5.64259291e-02f, 1.82936907e-01f, -1.04292169e-01f,
  -3.07740837e-01f, -1.43951043e-01f, 1.53047457e-01f, -1.34849906e-01f, -7.57946223e-02f, -1.59780368e-01f, 7.35689560e-03f, -3.14115524e-01f, -9.91507024e-02f, -8.49948153e-02f,
  -1.78593978e-01f, 3.73961814e-02f, 1.25897080e-01f, 8.03402364e-02f, -1.98081112e-03f, -8.03119561e-04f, -2.69334260e-02f, -5.71826883e-02f, -1.43065244e-01f, -1.30270094e-01f,
  3.15026700e-01f, 9.55146402e-02f, -1.46404117e-01f, 1.89729169e-01f, -7.16945156e-02f, -6.13299124e-02f, -4.64198701e-02f, -1.20467231e-01f, 5.86226303e-03f, -1.50349513e-01f,
  6.31266683e-02f, 3.09030022e-02f, -2.92243995e-02f, 2.26427265e-03f, 3.80585603e-02f, 6.65821061e-02f, 3.18397880e-02f, 5.53675331e-02f, 5.84033243e-02f, 3.84053178e-02f,
  1.34237647e-01f, -1.05780989e-01f, 7.60722384e-02f, 1.87856127e-02f, 2.41892459e-03f, 2.38925628e-02f, 9.33504552e-02f, -1.37137938e-02f, -7.83494860e-02f, 2.17019450e-02f,
  3.98771539e-02f, -2.40216237e-02f, -3.86963561e-02f, -1.15440868e-01f, -1.47058780e-03f, 3.06236427e-02f, -6.25316724e-02f, 5.00912662e-04f, 5.19563630e-02f, 8.23283494e-02f,
  -3.46683599e-02f, 3.43979895e-02f, -1.02183998e-01f, -3.57377678e-02f, -2.45045573e-02f, 4.92976308e-02f, 1.21664278e-01f, -4.62665595e-02f, 6.28532097e-03f, 1.36705726e-01f,
  -6.72747865e-02f, -3.48405503e-02f, 3.67490128e-02f, -8.63264799e-02f, 2.34113727e-02f, 8.17913413e-02f, -8.95683770e-04f, -6.43026829e-02f, -4.54175547e-02f, -1.76033452e-01f,
  -3.11153214e-02f, 5.03106304e-02f, -2.96234071e-01f, 7.50510320e-02f, -1.47271514e-01f, -4.59307693e-02f, -1.23166516e-01f, -9.29305032e-02f, -1.21999858e-02f, -1.40602291e-01f,
  -6.51058793e-01f, -2.20065743e-01f, 1.30126020e-02f, 6.36680424e-02f, 1.85615540e-01f, -7.10797310e-02f, -1.44411534e-01f, -2.88882941e-01f, -1.21556662e-01f, -1.35750830e-01f,
  2.25535799e-02f, 1.90797582e-01f, -7.18297204e-04f, -2.07082331e-02f, -2.56687999e-01f, -8.63144845e-02f, 2.00849935e-01f, 1.23218084e-02f, -9.20897126e-02f, -8.53642747e-02f,
  2.45105773e-01f, -3.93109843e-02f, -9.78825986e-02f, -1.01030618e-02f, -5.49125078e-04f, 1.18820898e-01f, 1.75729781e-01f, -2.29068659e-03f, -1.94676127e-02f, 3.22347097e-02f,
  -1.76353186e-01f, -1.70060322e-01f, 2.08462402e-01f, -1.30099848e-01f, 7.81401172e-02f, -1.64182544e-01f, -1.48438245e-01f, 1.28364593e-01f, -3.32680568e-02f, 1.28429204e-01f,
  2.14673534e-01f, 8.59845355e-02f, 1.47413298e-01f, 1.31912574e-01f, -3.46296541e-02f, -1.37928026e-02f, 4.79052849e-02f, -9.79954675e-02f, -4.63138148e-02f, -1.05959259e-01f,
  1.73524067e-01f, 4.00679372e-02f, -6.61084950e-02f, -4.68100682e-02f, -2.47809842e-01f, 4.68972176e-02f, -1.59106627e-01f, -1.61621913e-01f, -5.63085191e-02f, -2.51322806e-01f,
  1.37732491e-01f, 7.65617415e-02f, 1.18800215e-01f, 4.04547006e-02f, -3.38991755e-03f, 4.23239497e-03f, 7.62175396e-02f, 1.26019984e-01f, -1.07581466e-02f, -1.87943399e-01f,
  -1.38877565e-02f, -2.58810911e-03f, 1.90471765e-02f, -6.17906898e-02f, 1.95597690e-02f, 6.34290576e-02f, 2.25009900e-02f, -4.27328832e-02f, 1.08581223e-02f, 1.16580399e-02f,
  -5.69686554e-02f, 5.69574051e-02f, 5.89681678e-02f, 8.87242029e-04f, -1.32804736e-01f, -2.23347694e-02f, -1.78409051e-02f, -3.09707243e-02f, -9.79597718e-02f, -3.45724374e-02f,
  -1.16194114e-02f, 6.77522570e-02f, -7.44763687e-02f, -7.12691024e-02f, 1.72294572e-01f, 3.57015664e-03f, 1.02502793e-01f, 9.95264873e-02f, 9.05604959e-02f, -5.14829531e-02f,
  -3.15362364e-02f, 6.20690323e-02f, -7.63692856e-02f, 5.89960739e-02f, 4.03866637e-03f, -6.22124709e-02f, -3.92183177e-02f, 6.61738440e-02f, 1.81836784e-02f, 1.23652168e-01f,
  -1.56523764e-01f, -1.09865971e-01f, -1.88213170e-01f, -1.01679355e-01f, -2.31920779e-01f, -2.04074502e-01f, -1.48068085e-01f, 4.72307531e-03f, -1.89575881e-01f, -2.67349303e-01f,
  -5.42870879e-01f, 1.29701942e-01f, 2.15734378e-01f, -2.15956137e-01f, 9.97090712e-02f, -1.22672394e-01f, -8.36295858e-02f, -2.31811211e-01f, -2.30505094e-01f, -5.61168790e-03f,
  -1.48231983e-01f, -3.34773421e-01f, -2.51645207e-01f, -9.98758301e-02f, -2.85473377e-01f, -1.13194533e-01f, 5.55254854e-02f, -2.63216764e-01f, -4.48634386e-01f, -2.60400057e-01f,
  -9.22799930e-02f, -2.79451847e-01f, -2.36683995e-01f, -1.34043008e-01f, 1.70213893e-01f, -1.12494761e-02f, 1.74065113e-01f, 1.76034998e-02f, 1.34502038e-01f, 2.28805527e-01f,
  7.99689442e-02f, 3.91354598e-02f, -6.22898974e-02f, 1.57882329e-02f, 7.11025447e-02f, -3.61920707e-02f, -1.07552834e-01f, -4.41499464e-02f, -8.78602713e-02f, 3.98191670e-03f,
  2.08465215e-02f, -5.41928522e-02f, -7.18682334e-02f, 6.08611070e-02f, -1.44526348e-01f, -3.93948071e-02f, 8.91156197e-02f, -6.25734553e-02f, 6.72962591e-02f, 8.77731442e-02f,
  1.84157491e-01f, -1.73738282e-02f, 3.51995928e-03f, 2.35008840e-02f, 8.58984739e-02f, -2.48131007e-02f, 1.57478318e-01f, 4.40541245e-02f, 2.55972713e-01f, -2.77376287e-02f,
  -6.67932332e-02f, 4.32557836e-02f, 1.72185022e-02f, 6.32947870e-03f, -1.14084937e-01f, 4.49338043e-03f, -9.80656669e-02f, -1.33410454e-01f, -4.35951129e-02f, -1.47646666e-01f,
  2.57439055e-02f, 4.21142951e-03f, 5.34322262e-02f, 8.54821652e-02f, 8.56208652e-02f, 1.47909150e-01f, -6.71524107e-02f, 1.04146801e-01f, 4.17506695e-02f, 6.85232878e-02f,
  -6.71589002e-02f, 1.67883396e-01f, 1.20660454e-01f, 1.75737552e-02f, 1.64821581e-03f, 3.12667899e-02f, -7.87836267e-04f, -8.43400434e-02f, -4.07127663e-02f, 2.02564709e-02f,
  -2.89194465e-01f, -3.71892042e-02f, -7.55008385e-02f, 2.34771091e-02f, 1.02341160e-01f, 2.35518545e-01f, 1.63721159e-01f, 6.48636296e-02f, 1.02483071e-02f, -8.19716509e-03f,
  2.68094782e-02f, 3.85807492e-02f, 4.81158197e-02f, -1.26008387e-03f, -1.55452892e-01f, 6.78712726e-02f, -2.63260957e-02f, -9.41104963e-02f, 1.44208446e-01f, 2.30295569e-01f,
  2.18884930e-01f, -3.94479930e-02f, -2.05383569e-01f, -2.31590066e-02f, -6.33334368e-02f, -3.61710936e-02f, -3.44483890e-02f, 1.72043025e-01f, 1.03543386e-01f, 4.82841954e-02f,
  -7.43595302e-01f, -7.97158852e-02f, -1.43579394e-01f, -5.55504739e-01f, -1.68875784e-01f, 1.32520631e-01f, 2.33504742e-01f, 2.72739176e-02f, -3.32723200e-01f, -1.86963782e-01f,
  7.79358344e-03f, 1.04348682e-01f, -2.77571846e-02f, 6.77392408e-02f, 2.21584719e-02f, -1.22984201e-01f, -2.48652667e-01f, -2.40624145e-01f, 9.58221965e-03f, 2.50788897e-01f,
  1.28291875e-01f, -2.33468458e-01f, -4.20707762e-01f, -1.57271221e-01f, 5.68949766e-02f, -4.96303849e-02f, -2.11550727e-01f, -1.93341568e-01f, -4.24688011e-02f, -3.85489285e-01f,
  4.46075082e-01f, -2.07607657e-01f, -1.78358387e-02f, -1.18759004e-02f, 9.35665220e-02f, 3.01281810e-02f, 5.72368354e-02f, 1.02784056e-02f, 9.13066790e-02f, 1.07438922e-01f,
  -6.91358894e-02f, 4.50636111e-02f, -1.52262971e-02f, 1.64924890e-01f, 2.64717396e-02f, 7.92851225e-02f, 1.03767909e-01f, -8.57967243e-04f, 1.21350691e-01f, 1.84875488e-01f,
  6.99301064e-02f, 1.74574107e-01f, 1.44194067e-01f, 8.05042461e-02f, 1.61547258e-01f, 8.57343674e-02f, 1.37503043e-01f, 6.92668781e-02f, 1.27177268e-01f, 1.37169555e-01f,
  1.77858427e-01f, 2.03933090e-01f, 1.26117766e-01f, 7.37676695e-02f, 8.03976506e-02f, 1.04045026e-01f, 2.25352924e-02f, 9.39053372e-02f, 2.83982791e-03f, -2.16552503e-02f,
  6.31979331e-02f, -6.04061522e-02f, 1.80180818e-02f, -1.72398128e-02f, 5.05912453e-02f, -5.17698564e-02f, -4.79736365e-02f, -4.69642207e-02f, -4.96600010e-02f, -6.18721135e-02f,
  -4.96791415e-02f, -7.61362761e-02f, -8.67377147e-02f, 4.82222661e-02f, -5.09831272e-02f, -4.90288474e-02f, -9.50930826e-03f, -1.55482665e-02f, -5.03239371e-02f, -1.76036745e-01f,
  2.40446731e-01f, -5.33245131e-02f, -1.38910273e-02f, -4.66419570e-02f, -3.99711765e-02f, -7.15118423e-02f, -1.36899352e-01f, -1.46994099e-01f, -1.03302754e-01f, -3.64247225e-02f,
  6.09909222e-02f, -6.32195454e-03f, -6.35006651e-02f, 1.32920012e-01f, 2.65036784e-02f, -4.17326316e-02f, -3.13430242e-02f, -8.25890228e-02f, -3.27580161e-02f, 9.19513479e-02f,
  3.47271487e-02f, -6.00828603e-02f, 3.55983190e-02f, 7.11673871e-02f, -2.69783065e-02f, -4.63490598e-02f, 5.55262901e-02f, 7.27643445e-02f, -6.45439252e-02f, -2.32928693e-02f,
  -6.15856707e-01f, 1.36278301e-01f, 8.03779066e-02f, -2.96084136e-01f, 1.02178119e-01f, 3.03755641e-01f, 1.99611589e-01f, 1.15790650e-01f, 9.08772647e-03f, -7.45719895e-02f,
  9.35802460e-02f, 3.81277464e-02f, -1.12953082e-01f, 5.73620684e-02f, -5.01162037e-02f, 6.53085038e-02f, -1.73421353e-02f, -7.62012228e-02f, 7.44190160e-03f, 3.13081294e-01f,
  2.05909550e-01f, -9.54624340e-02f, -2.71352559e-01f, -1.13485858e-01f, -1.45916194e-01f, -1.80207789e-01f, -1.81409225e-01f, -1.92635000e-01f, 9.12387446e-02f, -2.25931644e-01f,
  -2.69613713e-01f, -8.67918357e-02f, 3.03486228e-01f, -1.76505139e-03f, -2.82371826e-02f, -2.95870285e-02f, 3.06785069e-02f, 1.08884908e-01f, 4.02639546e-02f, 1.08258344e-01f,
  -6.91509545e-02f, 1.07100412e-01f, -6.58143759e-02f, 9.42255110e-02f, 2.17902064e-02f, 1.14874266e-01f, -3.10140494e-02f, 5.75112589e-02f, 1.02211228e-02f, 8.00524652e-02f,
  1.17996037e-01f, -4.98100333e-02f, -3.02777272e-02f, 2.15694427e-01f, 2.49947533e-02f, -3.07449903e-02f, -5.78306355e-02f, -6.52918369e-02f, 2.34224666e-02f, -2.22460791e-01f,
  1.21464796e-01f, -5.19002602e-02f, -4.79247980e-02f, -1.86029624e-03f, -3.70692685e-02f, -8.77863728e-03f, 8.99193212e-02f, -2.27186549e-02f, -7.78116360e-02f, -2.71966569e-02f,
  -1.16237290e-02f, -4.01816182e-02f, 7.84722567e-02f, -5.96819445e-02f, -2.32180785e-02f, 5.63521087e-02f, -3.63815874e-02f, -7.76507631e-02f, 4.07412276e-02f, -3.06398273e-02f,
  -4.28325422e-02f, 5.24175465e-02f, 6.20334335e-02f, 1.39723858e-02f, 1.37210935e-02f, -2.38988902e-02f, -3.15133445e-02f, 8.76235217e-03f, -2.30465271e-03f, 1.16838604e-01f,
  -5.29811263e-01f, 2.07000654e-02f, -1.31288186e-01f, 1.09844334e-01f, -1.83844134e-01f, -4.54861345e-03f, -1.99655682e-01f, 1.58555098e-02f, -2.20081750e-02f, 1.78143606e-02f,
  1.26602560e-01f, 3.35852196e-03f, -1.08910300e-01f, 6.06872514e-02f, 4.86187339e-02f, 8.44702870e-03f, -4.30103391e-02f, 2.37745605e-02f, -5.57466894e-02f, -9.21701193e-02f,
  -1.59506947e-01f, -6.94208220e-02f, -1.43787265e-01f, 1.32801849e-02f, -8.08922350e-02f, -9.92790982e-02f, -2.05447793e-01f, -1.04894601e-01f, -1.07530877e-01f, -1.69458687e-01f,
  4.74206693e-02f, -3.26539665e-01f, -2.67797768e-01f, -2.06968188e-02f, -2.61368662e-01f, -1.62262231e-01f, -4.71915424e-01f, 1.55703081e-02f, 2.45931987e-02f, -3.27940106e-01f,
  -6.38040006e-02f, 1.52011335e-01f, 1.22992992e-02f, -1.64844409e-01f, -1.17302120e-01f, -4.45244253e-01f, -2.93156326e-01f, -4.67922017e-02f, 4.69993353e-02f, -2.65301182e-03f,
  -1.37012914e-01f, -1.84121862e-01f, 3.19508649e-02f, -9.93265677e-03f, -3.64388496e-01f, -2.54787505e-01f, -3.66268665e-01f, -1.17907472e-01f, -2.33348891e-01f, -5.57247758e-01f,
  -4.25668240e-01f, -3.35230529e-02f, 9.78592783e-02f, 7.46382996e-02f, -9.38291997e-02f, 1.69238761e-01f, -4.32115272e-02f, 1.06425367e-01f, 1.85767829e-01f, 1.93253905e-02f,
  1.57708496e-01f, 4.49387953e-02f, -3.08884792e-02f, -2.02178713e-02f, 1.48573192e-02f, 1.64260976e-02f, 6.48415089e-02f, 1.40419111e-01f, 2.44265907e-02f, 9.01764035e-02f,
  9.21604596e-03f, 4.22722176e-02f, 6.70435354e-02f, 1.50859475e-01f, 6.14258386e-02f, 9.99559686e-02f, -1.63309593e-02f, 1.39907256e-01f, 1.76167369e-01f, -9.22710150e-02f,
  -9.26864594e-02f, -8.67709741e-02f, -4.81892712e-02f, -5.28338477e-02f, 6.37408271e-02f, 9.85792279e-02f, -4.69256155e-02f, 4.22367686e-03f, 6.08682968e-02f, -5.43396994e-02f,
  7.70748109e-02f, -3.06797004e-03f, -5.77787161e-02f, -9.85699371e-02f, -1.27792150e-01f, 2.33455878e-02f, -2.59774290e-02f, -1.22193053e-01f, 4.78885043e-03f, 1.37481719e-01f,
  5.61092384e-02f, 9.55474749e-02f, -8.60903487e-02f, -9.06404927e-02f, -2.53024343e-02f, -6.75466657e-02f, -1.92412250e-02f, -5.59991524e-02f, -3.59635875e-02f, 4.51097861e-02f,
  -1.93256825e-01f, -3.37042697e-02f, -1.63928509e-01f, 4.39264029e-02f, 8.79458115e-02f, 1.86259567e-03f, -2.50889957e-02f, 9.41375494e-02f, -3.33933271e-02f, -6.07994646e-02f,
  7.76050463e-02f, -8.58320743e-02f, -8.99139717e-02f, -1.89061987e-03f, -6.22968413e-02f, 6.30120421e-03f, 3.15522850e-02f, -5.52722365e-02f, 1.84526164e-02f, 3.37790214e-02f,
  4.96622883e-02f, 1.22303776e-01f, -5.13933972e-03f, -3.85641009e-02f, -7.03712786e-03f, -3.96588370e-02f, -7.87862018e-02f, -1.84517466e-02f, -1.00554883e-01f, -1.88095391e-01f,
  -6.15516081e-02f, -2.42189974e-01f, -1.89096034e-01f, -6.09720610e-02f, -5.01237027e-02f, -6.40619993e-02f, 1.59004644e-01f, -6.40774667e-02f, -1.43017665e-01f, -1.81956500e-01f,
  -1.30878508e-01f, -3.45125869e-02f, -1.16771817e-01f, -3.56562398e-02f, -6.14303388e-02f, -1.23527639e-01f, -1.94099724e-01f, -1.95854045e-02f, 1.33015543e-01f, 2.54937500e-01f,
  2.04737842e-01f, 2.71284908e-01f, 4.55092080e-02f, 2.23029867e-01f, 5.27567342e-02f, 1.02790050e-01f, -6.73026368e-02f, -1.64257690e-01f, -1.07142270e-01f, -3.39075953e-01f,
  7.70409703e-02f, -3.50783318e-01f, 9.30816159e-02f, -6.81250021e-02f, -4.83846441e-02f, 2.79273372e-04f, -7.80115500e-02f, -1.35456353e-01f, -7.51046911e-02f, -1.08469747e-01f,
  -2.77559191e-01f, -1.79726973e-01f, -1.49520874e-01f, -2.07189983e-03f, 2.22931039e-02f, -2.40250211e-02f, 1.73959229e-02f, -3.13232876e-02f, -8.71639401e-02f, -4.67300117e-02f,
  3.65885086e-02f, -8.23265314e-02f, -1.11059457e-01f, 9.99816414e-03f, -2.23094020e-02f, -4.91420403e-02f, -7.82252997e-02f, -9.60716903e-02f, -5.76143935e-02f, -1.93147380e-02f,
  -6.88714758e-02f, -5.11480542e-03f, 1.24860024e-02f, -4.01516147e-02f, 6.28273934e-02f, 2.15620305e-02f, 1.09875605e-01f, 5.02757952e-02f, -5.26687615e-02f, 1.18445508e-01f,
  1.69484550e-03f, -8.75997022e-02f, -3.15793417e-02f, -3.33261304e-02f, -7.09772632e-02f, 9.76303127e-03f, -1.01320811e-01f, 9.53357518e-02f, -1.18189603e-01f, 5.70886210e-03f,
  -2.35948451e-02f, -1.68207675e-01f, -1.27881452e-01f, 1.52537161e-02f, -2.03697577e-01f, -9.18037817e-02f, -1.78159297e-01f, 2.97623482e-02f, 1.63830984e-02f, -2.04304844e-01f,
  4.14002866e-01f, -3.88267815e-01f, 7.54857883e-02f, -1.67873412e-01f, -2.95674801e-02f, -1.39980733e-01f, -2.36868598e-02f, -9.42386761e-02f, -6.39961064e-02f, -3.07561290e-02f,
  -1.54675975e-01f, -4.49563656e-03f, -3.61813828e-02f, 6.10924475e-02f, 2.55828220e-02f, 3.29346582e-02f, 6.12317771e-02f, 3.07574845e-03f, -9.57387388e-02f, 3.34411152e-02f,
  7.11115748e-02f, 3.03925782e-01f, 1.46921650e-01f, 4.24521714e-02f, 1.93553045e-02f, 1.49094045e-01f, 1.88785791e-01f, 2.51767904e-01f, 3.62423360e-02f, 3.97698671e-01f,
  -8.27661216e-01f, 8.55032578e-02f, 4.06904928e-02f, -6.90150976e-01f, -1.36305451e-01f, 1.78771555e-01f, 2.73490489e-01f, 5.58343530e-02f, -2.91405022e-01f, 3.81132960e-02f,
  4.83618043e-02f, -1.23026863e-01f, -1.87812969e-01f, 1.55537918e-01f, -2.57261358e-02f, -1.15161672e-01f, -1.97414294e-01f, -1.45688713e-01f, -6.27268106e-02f, 2.26570889e-01f,
  -5.12213372e-02f, -4.60404634e-01f, -3.34065288e-01f, -2.18104213e-01f, -4.85457890e-02f, -1.81285292e-01f, -2.18198463e-01f, -8.31472650e-02f, 2.32438490e-01f, -2.83673853e-01f,
  9.98273268e-02f, -7.10437968e-02f, 1.18991792e-01f, -6.91136420e-02f, -1.68955680e-02f, -9.03791487e-02f, 3.05085611e-02f, -1.38834476e-01f, -6.77969977e-02f, -4.65101860e-02f,
  -2.19612405e-01f, 6.78523779e-02f, -5.24402708e-02f, -8.07299688e-02f, -8.03279802e-02f, -4.70729880e-02f, -1.56053212e-02f, -1.23741448e-01f, -5.53512052e-02f, 9.44723189e-02f,
  1.10682480e-01f, 7.85345361e-02f, 1.21960707e-01f, 8.36200789e-02f, 1.35399431e-01f, -1.03869196e-02f, 1.36574462e-01f, -7.81360734e-03f, 1.98443308e-01f, -9.14198980e-02f,
  -4.34992053e-02f, 1.21583246e-01f, 7.46128894e-03f, 4.62122858e-02f, 2.56821457e-02f, 1.04300948e-02f, 3.37953456e-02f, -1.14419639e-01f, -8.08776822e-03f, 5.18387817e-02f,
  -2.93326993e-02f, -4.15887386e-02f, -4.74229157e-02f, -4.88694645e-02f, -1.97091848e-02f, 2.58617401e-02f, 8.86329636e-02f, -4.59488295e-03f, 5.36941737e-02f, -7.35169351e-02f,
  2.41769683e-02f, 4.16142382e-02f, -1.18709020e-01f, 7.38511086e-02f, 3.01213302e-02f, -6.65262491e-02f, 7.21746609e-02f, 4.88876365e-02f, -8.97622202e-04f, 5.72656691e-02f,
  -2.08919525e-01f, 1.17976896e-01f, -1.30410060e-01f, 6.98672310e-02f, -6.26546219e-02f, 5.15454784e-02f, 5.57852536e-02f, -1.35389529e-02f, -1.29226679e-02f, 8.10585469e-02f,
  3.62762474e-02f, -4.52143587e-02f, 5.61104380e-02f, -6.46089464e-02f, -4.26182747e-02f, -3.67831113e-03f, -6.68405497e-04f, -1.89615935e-02f, 6.75882623e-02f, 1.62730347e-02f,
  4.67049703e-02f, -2.32052561e-02f, -9.54515189e-02f, 1.09575406e-01f, -7.75500247e-03f, -1.19030841e-01f, 1.24697089e-01f, 1.00623325e-01f, 1.44366443e-01f, 8.95280950e-03f,
  7.44274184e-02f, -2.89243996e-01f, -2.13445663e-01f, -1.63626581e-01f, -1.94969922e-01f, -1.93260852e-02f, -2.96836883e-01f, -5.83630390e-02f, 7.17270793e-03f, -3.42543125e-01f,
  -1.53783530e-01f, 2.96276957e-01f, -2.01361477e-02f, 1.19715162e-01f, 3.27391103e-02f, -2.82033831e-01f, -2.86175936e-01f, 1.85317338e-01f, 4.38777417e-01f, 7.50230486e-03f,
  -1.49359480e-01f, -8.38998482e-02f, 1.26175895e-01f, 1.64364740e-01f, -2.61087179e-01f, -9.06065851e-02f, -3.71445358e-01f, -1.31215021e-01f, -1.55575246e-01f, -3.78600001e-01f,
  -2.07679480e-01f, 1.07557043e-01f, 1.02792978e-01f, 2.14100614e-01f, -8.96749273e-02f, 3.36277820e-02f, 1.12066843e-01f, 4.21399716e-03f, -2.41406113e-02f, 4.40340489e-02f,
  -1.01967920e-02f, -3.05033866e-02f, 4.76707555e-02f, -2.33057607e-02f, -4.39087525e-02f, -4.95513380e-02f, 8.88504684e-02f, 1.04448639e-01f, 1.08370803e-01f, -7.72648007e-02f,
  -1.74457341e-01f, -8.17211494e-02f, 9.52866673e-02f, 7.43164867e-02f, 2.24647164e-01f, 4.03035991e-02f, -4.85472269e-02f, 1.91141441e-02f, 1.78825021e-01f, -3.39249402e-01f,
  -1.56369701e-01f, 2.37980299e-03f, 4.67372611e-02f, -3.37651074e-02f, -3.68215255e-02f, 7.65832700e-03f, 1.72226410e-02f, -1.44380862e-02f, 1.60012916e-02f, -1.30940616e-01f,
  6.78767338e-02f, 1.99307222e-02f, -4.78000287e-03f, -1.09718926e-01f, -8.64056200e-02f, -1.19772747e-01f, -1.23571947e-01f, -9.10588950e-02f, -3.66491340e-02f, -3.49357575e-02f,
  7.23656043e-02f, 2.73545999e-02f, -5.00983447e-02f, -8.90924037e-03f, -9.75584164e-02f, -1.02174301e-02f, 3.19556855e-02f, 2.60621849e-02f, -1.06641300e-01f, 1.14681851e-02f,
  -3.20261307e-02f, 1.94745079e-01f, -1.16082482e-01f, -4.74183746e-02f, -8.65240097e-02f, 6.58658370e-02f, 2.71378122e-02f, -1.16270763e-04f, 2.22143352e-01f, 3.82840559e-02f,
  7.32277483e-02f, -5.98837547e-02f, -4.46586572e-02f, 2.90726740e-02f, 3.08157951e-02f, -3.69263887e-02f, -1.35456711e-01f, -4.27764207e-02f, -4.11315784e-02f, 2.98762042e-02f,
  -5.30724600e-02f, -5.43979593e-02f, -6.14370918e-03f, -5.56761660e-02f, 3.80210727e-02f, 9.20528322e-02f, -1.09132186e-01f, -3.89690809e-02f, 3.18510160e-02f, -2.28035435e-01f,
  -2.02054232e-01f, -1.67170674e-01f, 2.73788664e-02f, -1.45430535e-01f, -2.03472838e-01f, -2.83601247e-02f, 7.31353357e-04f, 1.33991495e-01f, 9.83118936e-02f, -1.20603861e-02f,
  2.96907239e-02f, 3.22525799e-02f, 9.36001912e-02f, 8.91840905e-02f, 9.78921056e-02f, -4.75406870e-02f, -2.95631468e-01f, -3.69672962e-02f, 1.69750139e-01f, 1.08571544e-01f,
  1.06243491e-02f, 1.75359473e-02f, -1.26726544e-02f, 1.09316945e-01f, -8.56331214e-02f, -3.59797431e-03f, -3.33030559e-02f, -9.78423730e-02f, -8.71945322e-02f, -4.08521235e-01f,
  8.75687674e-02f, -7.82145187e-02f, -2.09178701e-01f, -9.45759844e-03f, -5.74493185e-02f, 7.60080442e-02f, -3.57779637e-02f, -1.22720815e-01f, 7.29158148e-03f, 1.84481710e-01f,
  -3.32984656e-01f, 1.42008811e-01f, -2.11616773e-02f, 1.50763327e-02f, -6.86269775e-02f, 1.82286073e-02f, -8.23828056e-02f, -3.54609676e-02f, -7.10342079e-02f, 6.83439523e-02f,
  -2.58869857e-01f, -1.82782292e-01f, -3.61010700e-01f, -1.64043173e-01f, 1.13244556e-01f, -5.96533976e-02f, 9.43077579e-02f, 2.38371715e-01f, 4.85128909e-02f, -1.02231555e-01f,
  -5.68176946e-03f, -3.76313590e-02f, -8.37062225e-02f, 2.34581772e-02f, -2.83611417e-02f, 4.70352955e-02f, -9.63578299e-02f, -7.71651641e-02f, 8.67424160e-02f, 1.08930551e-01f,
  -6.08602725e-02f, 3.40393819e-02f, 1.04246037e-02f, -1.15981679e-02f, 1.92179263e-01f, -4.93703447e-02f, 7.06749335e-02f, 2.02325056e-03f, 4.26990800e-02f, 2.97555719e-02f,
  3.25766392e-02f, -1.00029297e-01f, -5.44302054e-02f, 1.05702668e-01f, 1.60103459e-02f, -3.63039114e-02f, 8.79660025e-02f, 1.75668728e-02f, 5.13801500e-02f, 6.76231235e-02f,
  1.36209428e-01f, -1.39900550e-01f, 7.46230111e-02f, -1.27866700e-01f, 1.00723714e-01f, -6.00963011e-02f, -3.72946076e-02f, -6.80537075e-02f, 1.00202121e-01f, 9.45009515e-02f,
  1.16718106e-01f, 2.37671807e-02f, 7.37502947e-02f, 7.80790001e-02f, -8.67149159e-02f, 8.78159702e-02f, -8.70708600e-02f, -1.56470574e-02f, -4.59892601e-02f, 7.16575980e-02f,
  -2.67162118e-02f, -1.68054789e-01f, -2.22191125e-01f, -7.92148802e-03f, 2.08216310e-01f, 1.36822730e-01f, 3.28465626e-02f, 6.96170703e-02f, -7.20877647e-02f, 4.30842191e-02f,
  -7.38253593e-01f, -1.88288406e-01f, 6.05057776e-02f, -2.74727881e-01f, 1.50592193e-01f, 9.83993858e-02f, -1.65731594e-01f, -1.67462781e-01f, -1.18681073e-01f, -1.11466013e-01f,
  6.05133250e-02f, 8.78980532e-02f, 1.32833600e-01f, 1.18783131e-01f, -1.56037211e-02f, 2.83482969e-02f, 3.90751004e-01f, 8.38090405e-02f, 3.69583629e-02f, -4.50791679e-02f,
  4.74669412e-02f, -1.28016993e-01f, 1.99083518e-02f, 3.49288993e-02f, -4.66136895e-02f, -9.36935423e-04f, 2.39567235e-01f, -4.22049686e-02f, 5.75053431e-02f, 1.31988361e-01f,
  -2.51802474e-01f, -5.02175331e-01f, 2.06116259e-01f, 1.01560727e-01f, 2.29173666e-03f, -1.46665245e-01f, -2.56631672e-01f, 6.35454580e-02f, 1.01613505e-02f, -5.78759611e-02f,
  1.85264386e-02f, -5.53100370e-02f, -6.71821907e-02f, -1.28090614e-02f, -1.78102218e-03f, -8.28251243e-02f, 5.25893178e-03f, -9.36819240e-02f, 4.97590974e-02f, -1.98314339e-02f,
  8.18364695e-02f, 1.75585300e-01f, 6.10424504e-02f, 2.70846069e-01f, 4.13021892e-02f, 3.06888167e-02f, 1.61770284e-02f, -7.97469839e-02f, 6.34690002e-02f, -2.44834036e-01f,
  1.18533552e-01f, 1.23285167e-02f, 9.82116908e-02f, -8.74066055e-02f, -3.18912603e-02f, -2.62568109e-02f, 5.48729151e-02f, 4.33260389e-02f, 1.70410529e-01f, -1.37882546e-01f,
  5.10046482e-02f, -5.03982604e-02f, 9.46527496e-02f, -1.73555373e-03f, 2.63421405e-02f, 7.34215230e-02f, -8.45364761e-04f, 2.87465621e-02f, 9.25999135e-02f, 7.15759024e-02f,
  3.96209285e-02f, -2.42317431e-02f, -2.49902103e-02f, -4.26190346e-02f, 1.71606421e-01f, -8.17942470e-02f, -4.48311754e-02f, -1.45215737e-02f, -8.95184577e-02f, 9.06175468e-03f,
  -4.05612826e-01f, 3.06211889e-01f, -1.96001515e-01f, -1.05476923e-01f, 4.93288636e-02f, 5.92757724e-02f, -1.74771726e-01f, -1.75778791e-02f, 2.09651273e-02f, -6.66056424e-02f,
  4.00705030e-03f, -1.84540063e-01f, 2.00941321e-02f, 6.40898198e-02f, -1.43390452e-03f, 2.19690464e-02f, 3.23505816e-03f, -5.09328675e-04f, 1.59331799e-01f, 2.03353949e-02f,
  5.02768112e-03f, -5.55554107e-02f, 2.11220905e-02f, -4.74570096e-02f, -9.41643938e-02f, 1.23650348e-02f, -1.13479666e-01f, -1.75002798e-01f, -9.66777429e-02f, -4.01231855e-01f,
  4.35985252e-02f, -3.71836662e-01f, -3.01570743e-01f, -4.68201675e-02f, 4.29055840e-02f, 1.21438146e-01f, 6.04826324e-02f, 1.74142197e-01f, 1.32800549e-01f, -9.12158340e-02f,
  -1.48451747e-02f, 2.88455874e-01f, -6.75348341e-02f, 4.77323458e-02f, 1.13470040e-01f, -2.02075228e-01f, -1.27109841e-01f, -1.43085578e-02f, 3.96733135e-01f, 4.12824750e-01f,
  2.09177494e-01f, 2.79485229e-02f, 2.45022699e-01f, 1.31224588e-01f, -1.55160114e-01f, 6.26285970e-02f, -1.65853038e-01f, -9.97636989e-02f, -1.32309637e-04f, -5.32942832e-01f,
  -2.58355349e-01f, -9.79522392e-02f, 5.54840900e-02f, 1.38804018e-01f, -1.76280379e-01f, 6.75783902e-02f, 1.06784077e-02f, -2.03120574e-01f, -9.60109085e-02f, 3.02511919e-02f,
  1.21527743e-02f, -8.65059420e-02f, -3.51680219e-02f, 8.20646621e-03f, -3.67724076e-02f, 1.41910106e-01f, 8.49202126e-02f, 1.49037102e-02f, -8.78019780e-02f, 2.82935891e-02f,
  1.20997705e-01f, 4.08247150e-02f, -1.59509540e-01f, -4.65623289e-02f, -7.96489939e-02f, -4.68321368e-02f, -8.64552259e-02f, -1.49438649e-01f, 6.46372214e-02f, -4.55365479e-01f,
  9.07613859e-02f, -3.75600308e-02f, -6.91880509e-02f, 1.06193610e-01f, 1.14189520e-01f, -3.68190482e-02f, 1.90617442e-02f, -4.51211035e-02f, 1.91089902e-02f, -5.06880321e-02f,
  9.04426575e-02f, 2.36022752e-02f, 1.30939439e-01f, -1.80418380e-02f, 1.37788840e-02f, -2.68174312e-03f, -2.48270240e-02f, -9.69676375e-02f, 1.05124805e-02f, 2.35463604e-02f,
  1.06620351e-02f, -8.21686909e-02f, 2.45945118e-02f, 9.16422904e-02f, -5.34164533e-03f, -3.20272855e-02f, -3.49727608e-02f, 1.16862148e-01f, -7.86404833e-02f, 5.65034710e-02f,
  9.82060209e-02f, 8.60884115e-02f, -2.59952694e-01f, 1.04068905e-01f, -1.20335363e-01f, -1.05420262e-01f, -1.95914637e-02f, -4.24187742e-02f, -1.41645521e-02f, -1.92266479e-02f,
  -1.24019254e-02f, -8.16813558e-02f, -1.87267959e-01f, -2.70568505e-02f, 8.12959671e-02f, 1.84682831e-01f, -9.93260443e-02f, -9.78710409e-03f, 3.54028083e-02f, 2.65111625e-02f,
  -1.46574438e-01f, 3.63363102e-02f, -4.89053491e-04f, -1.93539783e-01f, -2.58072615e-02f, 1.42366467e-02f, -5.43525368e-02f, -6.80285878e-03f, -1.39235437e-01f, -1.85660049e-01f,
  8.65330517e-01f, -2.28987426e-01f, -3.65030468e-02f, 2.01224431e-01f, -9.73960459e-02f, -6.64512962e-02f, -3.72105837e-01f, -6.15696236e-02f, -2.85920016e-02f, -1.15199894e-01f,
  1.05073236e-01f, 2.87940353e-01f, 3.14757079e-01f, 1.10015363e-01f, 1.39060855e-01f, -1.16280422e-01f, -1.11048236e-01f, 1.55573174e-01f, 1.32459536e-01f, -1.04856119e-01f,
  -1.12241358e-01f, -2.17681587e-01f, 8.41213912e-02f, -7.69594982e-02f, -1.67960882e-01f, 1.38496980e-01f, -1.93155259e-01f, -2.71511793e-01f, -1.31268576e-01f, -1.42989308e-01f,
  1.50812715e-01f, 3.43606099e-02f, 1.34318471e-01f, 1.43172115e-01f, 1.90650448e-02f, 1.34104177e-01f, 1.36551842e-01f, -6.17054477e-02f, 1.06523186e-01f, 2.74687912e-03f,
  5.03304265e-02f, -7.78592303e-02f, -3.87417190e-02f, -3.22656371e-02f, -1.16907634e-01f, -3.76470089e-02f, -1.56359822e-01f, -9.53331217e-02f, -7.62517378e-02f, 1.12762451e-02f,
  4.37374711e-02f, -2.68925689e-02f, -7.60710165e-02f, -1.21676149e-02f, -1.20685138e-02f, 3.50884609e-02f, -4.90160584e-02f, 4.63045314e-02f, -4.04864773e-02f, -6.08180612e-02f,
  -6.99934885e-02f, 2.45530941e-02f, -3.24579701e-02f, -2.38321610e-02f, -8.87665525e-02f, 8.68908837e-02f, -1.34985112e-02f, -2.18301341e-02f, -3.30974907e-02f, 9.98050673e-04f,
  -1.43724978e-01f, -5.89503273e-02f, -5.02673397e-03f, 2.18923092e-02f, 1.14525199e-01f, -7.16148764e-02f, -6.55095279e-02f, 3.97983342e-02f, 2.41296496e-02f, -1.29814312e-01f,
  -6.04868196e-02f, -3.12967151e-02f, 4.51026596e-02f, -2.34213799e-01f, -1.31059751e-01f, -7.10389167e-02f, -2.93827318e-02f, -2.38260673e-03f, 3.37351188e-02f, -5.85408695e-02f,
  -1.33551508e-01f, 2.46700615e-01f, 1.76686287e-01f, 2.08718646e-02f, 1.16866425e-01f, -3.11134197e-02f, 9.97847542e-02f, 6.13706484e-02f, 1.66592412e-02f, 1.83582045e-02f,
  5.83176576e-02f, 1.90642640e-01f, -5.01320213e-02f, -7.60289580e-02f, 1.25844464e-01f, 1.10210136e-01f, 1.09208420e-01f, 2.15975180e-01f, 3.10822334e-02f, -5.56745902e-02f,
  -1.20423429e-01f, 8.54798704e-02f, 8.51457641e-02f, 1.88898623e-01f, 2.91607268e-02f, 1.39981255e-01f, 8.19716975e-02f, -6.61797151e-02f, 1.70314103e-01f, 2.47368519e-03f,
  1.97357386e-01f, -2.49305233e-01f, 4.51450888e-03f, -4.35104361e-03f, -2.14490891e-01f, 3.11612841e-02f, -1.48850709e-01f, -8.46441835e-02f, -1.93693507e-02f, -2.45113969e-02f,
  1.28299847e-01f, 3.41482013e-01f, 2.04828590e-01f, 2.46314466e-01f, 1.50203750e-01f, -3.41039114e-02f, 1.42455113e-03f, 1.81018449e-02f, 2.43384019e-01f, 1.43470213e-01f,
  4.54079062e-02f, -2.33298197e-01f, 4.84978706e-02f, 8.71648937e-02f, -1.09105609e-01f, 7.24728256e-02f, 4.92603378e-03f, -7.39775375e-02f, -3.24455788e-03f, -3.02772075e-02f,
  4.18611281e-02f, -1.41459897e-01f, 3.36256549e-02f, -8.85582156e-03f, -3.18884142e-02f, -1.95586652e-01f, -3.49106677e-02f, -1.28188357e-01f, -1.38500303e-01f, -2.37142622e-01f,
  -3.94750498e-02f, -6.74259737e-02f, 1.68253873e-02f, -1.17519014e-02f, -1.92983821e-01f, 3.82790826e-02f, 1.43477006e-03f, 1.17364995e-01f, -6.50104880e-02f, -4.83217537e-02f,
  1.04250953e-01f, 1.07516699e-01f, 1.07759804e-01f, 1.56422257e-01f, 6.57961741e-02f, 7.22369403e-02f, -3.49203199e-02f, 1.01150982e-01f, 1.72826380e-01f, 1.14841275e-01f,
  7.56856129e-02f, 3.00511211e-01f, 1.79454267e-01f, -6.31355047e-02f, -3.85780307e-03f, 2.51962943e-03f, 8.14018864e-03f, 9.78850424e-02f, -3.66369076e-02f, 8.06438625e-02f,
  1.49728209e-01f, -3.98495467e-03f, -6.83554113e-02f, 1.03683494e-01f, 1.77367777e-01f, 1.08101122e-01f, -6.73356429e-02f, -4.69277650e-02f, 6.01491593e-02f, -1.06871493e-01f,
  1.20914772e-01f, -3.43476981e-02f, -2.95018665e-02f, 1.01118095e-01f, 5.38985655e-02f, 1.52667612e-01f, 7.37323388e-02f, 8.00214708e-02f, 5.94020709e-02f, 7.11290464e-02f,
  -1.11476511e-01f, 1.55873269e-01f, 3.54450494e-02f, 4.74614762e-02f, -1.06387638e-01f, 2.83823516e-02f, 6.32788315e-02f, -1.86490819e-01f, -4.76388693e-01f, -2.55448282e-01f,
  -7.69193843e-02f, 1.15100637e-01f, 1.79509282e-01f, -8.14544130e-03f, 9.83588770e-02f, -3.48418094e-02f, -2.02525780e-02f, 3.08335312e-02f, -1.00258365e-01f, -1.55031145e-01f,
  9.94397774e-02f, 7.64842480e-02f, 2.11660102e-01f, 1.45938098e-01f, 9.18261781e-02f, 9.84850749e-02f, 2.87632067e-02f, -5.99956363e-02f, 9.17228386e-02f, -5.16416058e-02f,
  -2.17353776e-01f, 2.76609957e-01f, -1.68105558e-01f, 4.80621271e-02f, 2.66859174e-01f, 1.78483613e-02f, 1.46290511e-01f, -2.84380689e-02f, -7.30985478e-02f, 1.25253931e-01f,
  2.24816680e-01f, 1.95435300e-01f, 1.16180569e-01f, 7.73352310e-02f, 1.99610516e-02f, 9.76685435e-02f, 1.72866121e-01f, -1.58047304e-01f, -1.41262710e-01f, 3.03834919e-02f,
  2.98026949e-01f, -8.81752074e-02f, -2.66809613e-01f, -2.54166991e-01f, 2.43184045e-01f, 7.40819424e-02f, 2.01210845e-03f, 1.21117570e-02f, 3.38474177e-02f, 2.94804722e-01f,
  3.11101824e-02f, -7.56555423e-02f, -1.80485435e-02f, -4.54186536e-02f, 6.48967028e-02f, -1.78158343e-01f, -9.30851474e-02f, -9.90614519e-02f, -3.66623104e-02f, -2.89552286e-02f,
  2.32519135e-01f, -9.39588342e-03f, 1.87399969e-01f, -1.24793820e-01f, -1.32439017e-01f, -1.47090659e-01f, -3.03856015e-01f, -1.72043025e-01f, -3.66495550e-01f, -9.08167884e-02f,
  2.61452854e-01f, 1.80034116e-01f, 3.65383402e-02f, 2.88390461e-02f, -1.15155093e-01f, 3.07649318e-02f, 9.19532999e-02f, -1.01976797e-01f, -9.48849320e-02f, -2.02339813e-01f,
  -2.15027221e-02f, 5.63806333e-02f, 9.32915285e-02f, 1.96333434e-02f, 8.03357661e-02f, 4.61659953e-02f, 1.41618252e-01f, 3.13084871e-02f, -6.61953762e-02f, 1.10085160e-02f,
  -8.93764570e-02f, -5.66730164e-02f, -7.38898739e-02f, -3.37150618e-02f, 6.24941699e-02f, 9.08276662e-02f, 3.89848016e-02f, 4.99427132e-03f, 1.36687355e-02f, -5.22489883e-02f,
  1.02208629e-01f, -4.26981412e-02f, -1.80852842e-02f, -3.79260145e-02f, 5.58657497e-02f, -3.97559674e-03f, -8.91599134e-02f, 5.71073219e-03f, -5.74353486e-02f, 1.31093143e-02f,
  -1.32399499e-01f, 1.49522570e-03f, -4.85454425e-02f, -3.85754332e-02f, 7.59414658e-02f, -8.18457976e-02f, 2.44409149e-03f, -3.44568156e-02f, 8.73987600e-02f, -5.19893542e-02f,
  7.00497851e-02f, 1.52704874e-02f, 9.49326809e-03f, -2.17919350e-01f, -7.10021257e-02f, 9.69881266e-02f, -7.85916522e-02f, -1.02450326e-01f, -1.86099172e-01f, -9.23664197e-02f,
  -1.08236121e-02f, -1.40148681e-02f, -1.48789957e-01f, -1.32040158e-01f, -8.92608315e-02f, -4.56646271e-02f, -7.67781660e-02f, -7.98809975e-02f, -6.38593435e-02f, -2.27010667e-01f,
  -3.54302526e-01f, 1.09746434e-01f, 1.97858825e-01f, -3.02264512e-01f, 9.69017446e-02f, 1.68587983e-01f, 1.15919225e-01f, -3.47629227e-02f, -8.61927867e-02f, 8.76362771e-02f,
  1.03882484e-01f, -7.68731013e-02f, -2.22300217e-01f, -5.80557808e-02f, -2.83904999e-01f, -1.05350919e-01f, -1.39098138e-01f, -2.46437132e-01f, -2.03881279e-01f, 1.74890831e-02f,
  -1.64621979e-01f, -2.28762716e-01f, -3.16733479e-01f, -1.05874538e-01f, -6.93840161e-02f, 1.35804135e-02f, -1.39372461e-02f, -3.76807936e-02f, 1.92216471e-01f, -6.11791611e-02f,
  9.13605466e-02f, 3.39370221e-01f, 1.13989711e-02f, -9.45532471e-02f, 7.02361241e-02f, -4.82953619e-03f, 7.23134773e-03f, 4.46239971e-02f, 1.23178244e-01f, -5.66011369e-02f,
  -4.13330607e-02f, 5.53961769e-02f, -1.82306722e-01f, 7.00875446e-02f, -1.93637386e-02f, 5.46034146e-03f, -8.17121118e-02f, -4.01026495e-02f, -1.46382779e-01f, 6.10049926e-02f,
  -2.32510731e-01f, 1.33728459e-01f, -3.32046673e-02f, 1.12666041e-01f, 1.62044734e-01f, 1.13358749e-02f, 1.54152691e-01f, -2.75057554e-03f, 2.04758286e-01f, 1.39635578e-01f,
  6.03080019e-02f, 1.34888962e-01f, 6.05609901e-02f, -1.83760989e-02f, 1.00282552e-02f, 6.35400936e-02f, 6.75323382e-02f, 9.75477323e-02f, -4.15226445e-02f, -4.67242226e-02f,
  1.22298136e-01f, -1.12339400e-01f, -2.26887246e-03f, 7.61475414e-02f, 2.38541011e-02f, 1.39953708e-02f, -5.95654920e-02f, 1.09533221e-02f, 1.38894886e-01f, 1.59940403e-02f,
  -3.67318094e-02f, -1.06408512e-02f, -5.41237704e-02f, -5.54501154e-02f, 6.39388561e-02f, 8.18066522e-02f, 5.14473729e-02f, 1.61512699e-02f, -2.66387612e-02f, 1.42005324e-01f,
  -3.35166276e-01f, 1.43814951e-01f, -7.94332996e-02f, -3.02229729e-02f, 3.83112840e-02f, 1.49660096e-01f, -8.78078192e-02f, -5.71803600e-02f, 1.40974475e-02f, -1.21570274e-01f,
  1.15253381e-01f, -1.81119204e-01f, -5.22853807e-02f, 2.09181616e-03f, -1.09373294e-01f, 1.13021500e-01f, -2.43850462e-02f, -4.21652831e-02f, -9.17855650e-02f, -9.56422314e-02f,
  -2.41380379e-01f, -7.49829486e-02f, -2.89842665e-01f, -1.47398695e-01f, 1.90644208e-02f, -2.16897205e-01f, -7.57027939e-02f, -8.22916776e-02f, 6.14277050e-02f, -2.49238610e-01f,
  5.18056452e-01f, -2.63691902e-01f, -5.31345546e-01f, 1.26620576e-01f, -2.75318064e-02f, 7.68795684e-02f, -1.88264698e-01f, 1.01886429e-01f, 1.20382145e-01f, -1.27312407e-01f,
  -2.50942260e-01f, 2.20589712e-01f, -5.34819588e-02f, -1.33295581e-01f, -1.49584394e-02f, -3.04816544e-01f, -2.97023118e-01f, 3.80835459e-02f, 2.07433045e-01f, 2.34819248e-01f,
  1.96105218e-03f, 1.30500928e-01f, 9.76577401e-02f, 1.13007471e-01f, -1.28438488e-01f, -2.79286299e-02f, -2.45350301e-01f, -1.73819393e-01f, -1.55353323e-01f, -3.61728370e-01f,
  -2.65693963e-01f, -1.85184032e-01f, -3.57052498e-02f, 7.21137375e-02f, -1.06654234e-01f, 1.41551360e-01f, -1.29474662e-02f, -1.02520555e-01f, -5.37496544e-02f, -7.99079016e-02f,
  -4.37869318e-02f, 7.84466565e-02f, 1.28261015e-01f, -7.43967295e-02f, -1.41923148e-02f, -2.22832989e-02f, -8.84310678e-02f, 1.42940413e-02f, -4.28153761e-02f, -2.58875582e-02f,
  -1.58133656e-02f, 2.75808834e-02f, -3.73417209e-03f, -1.49395883e-01f, -1.16448857e-01f, -6.30514175e-02f, -2.82957584e-01f, -6.74873143e-02f, -6.86289817e-02f, -1.71454147e-01f,
  -8.98042321e-03f, 9.39424485e-02f, -8.22653994e-03f, 2.58233026e-02f, 5.22255078e-02f, -4.37655039e-02f, -7.08580688e-02f, 9.28289741e-02f, 8.34291149e-03f, 7.24796206e-02f,
  -5.45817129e-02f, -1.21377207e-01f, -4.41666804e-02f, -9.34387818e-02f, 1.66479964e-02f, 5.32821082e-02f, 2.99170502e-02f, -2.39664540e-02f, 1.93121228e-02f, 1.37295097e-01f,
  1.21676989e-01f, 4.89824973e-02f, 1.20133013e-02f, 1.54529110e-01f, -5.94855770e-02f, -6.87533319e-02f, -2.59868130e-02f, -3.38010788e-02f, 1.64613813e-01f, 4.84520532e-02f,
  2.06328616e-01f, 3.87128666e-02f, 9.06433240e-02f, 7.53460824e-02f, 3.48867364e-02f, -8.02028179e-02f, -6.11324683e-02f, -4.28226255e-02f, 2.53238734e-02f, 7.68591911e-02f,
  -7.37553835e-02f, -2.73154192e-02f, -9.29735154e-02f, -1.52314246e-01f, 7.73826241e-02f, -4.26243991e-02f, 2.24995930e-02f, 1.18087560e-01f, 8.52011666e-02f, 4.07253578e-02f,
  -2.24487111e-02f, 1.89101100e-01f, 1.87474072e-01f, -4.07594182e-02f, 4.47761528e-02f, 2.14299485e-01f, 6.42485693e-02f, 1.22912891e-01f, 1.30762592e-01f, 1.93810701e-01f,
  -1.84213340e-01f, 5.34421682e-01f, -1.51691288e-01f, 2.07906775e-02f, 2.41059810e-01f, -2.41332185e-02f, 1.46441134e-02f, -4.72703902e-03f, 1.59781575e-02f, 1.31424055e-01f,
  9.43383276e-02f, 2.22786650e-01f, -1.62466075e-02f, 7.76103586e-02f, -7.08757341e-02f, 1.01344071e-01f, 6.31201938e-02f, -1.26963869e-01f, -2.45194256e-01f, -2.40649674e-02f,
  2.08310753e-01f, 1.58228233e-01f, -5.42034768e-02f, 1.69234052e-02f, 2.05741003e-01f, 9.26255956e-02f, 4.00103033e-02f, 1.40912145e-01f, 1.12997785e-01f, 4.64304060e-01f,
  -2.16031596e-01f, -1.25948101e-01f, -1.25816479e-01f, 1.71023533e-01f, -2.05898173e-02f, -1.42296970e-01f, -5.24735637e-02f, 3.88648026e-02f, 4.49830145e-02f, -6.59770817e-02f,
  1.18665949e-01f, 7.99386203e-02f, 1.66857332e-01f, 8.91742334e-02f, -5.97681180e-02f, 4.86258455e-02f, -1.13521859e-01f, -8.87022093e-02f, -1.01590283e-01f, -7.19184428e-02f,
  1.25038370e-01f, 9.11329761e-02f, -1.45181892e-02f, -1.17874347e-01f, -2.41886407e-01f, -5.59114404e-02f, -1.08672380e-01f, -1.43140048e-01f, -1.44604906e-01f, -7.96739827e-04f,
  -7.61549622e-02f, 4.06746566e-02f, 7.89586827e-03f, -1.25301883e-01f, -9.12509561e-02f, 2.31349608e-03f, -2.86746453e-02f, 7.04418076e-03f, 7.70723820e-02f, 6.30437657e-02f,
  -1.03739493e-01f, -1.09401725e-01f, -1.24370374e-01f, -2.65060067e-01f, -2.74362061e-02f, -4.72280122e-02f, -1.14770368e-01f, -1.13130786e-01f, -1.58641294e-01f, -1.08809210e-01f,
  -4.32801098e-02f, 9.69904810e-02f, 5.89378811e-02f, 8.97996053e-02f, -7.47982413e-02f, -1.49232984e-01f, 2.95477696e-02f, -1.10471755e-01f, -7.10871890e-02f, 8.42907205e-02f,
  -2.26875208e-02f, -3.48769516e-01f, -1.11532368e-01f, 9.76111889e-02f, 1.63789481e-01f, 1.36340052e-01f, 8.59912932e-02f, -5.65924076e-03f, 2.17644989e-01f, -5.01099527e-02f,
  7.78113678e-02f, -6.26444742e-02f, 2.59757489e-02f, -6.49276450e-02f, -1.20724358e-01f, 4.99999262e-02f, 1.01332910e-01f, 2.31517442e-02f, 5.26139997e-02f, -3.70095596e-02f,
  2.32742429e-02f, -6.30284175e-02f, -1.25761569e-01f, 8.14190805e-02f, -1.36473000e-01f, -7.65457749e-02f, -4.80194762e-02f, -8.20284057e-03f, -1.30408153e-01f, -1.34892493e-01f,
  5.83219647e-01f, -2.52589673e-01f, 2.84147143e-01f, 3.02351266e-01f, 1.30112171e-01f, 1.16491064e-01f, -1.46527700e-02f, 5.90165518e-02f, 1.72470406e-01f, 2.37025976e-01f,
  1.23065390e-01f, 2.35778838e-01f, 3.31006169e-01f, 1.99907929e-01f, 1.94551632e-01f, 5.56924846e-03f, 1.03157520e-01f, 2.31371224e-01f, 2.10976914e-01f, 2.24483952e-01f,
  2.47224346e-02f, -4.59477007e-02f, 2.65973117e-02f, 1.44611120e-01f, -7.56440312e-02f, 2.28390917e-01f, -8.28650035e-03f, -2.61740565e-01f, -1.55365184e-01f, -7.92446153e-05f,
  -2.11521968e-01f, -1.44948244e-01f, 1.58454627e-01f, -1.95516217e-02f, 6.07342012e-02f, 1.31400640e-03f, 5.30016087e-02f, 1.00292331e-02f, -2.84218211e-02f, -5.03403414e-03f,
  -1.20675802e-01f, -7.10343570e-02f, -1.48878708e-01f, -4.17940356e-02f, -1.43788368e-01f, -2.04339162e-01f, 6.84451498e-03f, 3.06117237e-02f, 1.10835016e-01f, -3.37525830e-03f,
  6.53655976e-02f, -1.81372896e-01f, -1.31656393e-01f, -8.13902169e-02f, 8.57825875e-02f, -4.41491194e-02f, -8.48477632e-02f, -5.46889007e-02f, -4.20620516e-02f, 8.80554095e-02f,
  9.27729439e-03f, -1.28879786e-01f, -5.64260148e-02f, 5.91993108e-02f, 1.44692987e-01f, 1.93787776e-02f, -5.04150428e-02f, -7.76201785e-02f, 6.45977929e-02f, -2.44660396e-03f,
  -4.85238694e-02f, 2.97092218e-02f, 7.24764401e-03f, 2.01789126e-01f, 1.22169301e-01f, -6.04490973e-02f, -7.75330961e-02f, -1.04616269e-01f, -2.82459930e-02f, -1.23596629e-02f,
  -1.07498050e-01f, -7.08426954e-03f, -5.35883009e-02f, -1.50497174e-02f, 1.85749363e-02f, 1.19552366e-01f, 8.62210765e-02f, 4.18690033e-02f, 4.60415184e-02f, 1.24862932e-01f,
  -1.82827085e-01f, 1.56831950e-01f, 2.98413843e-01f, -1.83047593e-01f, -1.20984808e-01f, 2.00834200e-02f, 2.12162361e-02f, -1.73021853e-01f, -1.31942466e-01f, -4.40009944e-02f,
  -1.33575544e-01f, 4.70632762e-02f, -1.28244117e-01f, -1.18246682e-01f, 4.26772311e-02f, 5.57702817e-02f, -3.38497460e-02f, 4.85808328e-02f, -6.93998337e-02f, -9.99188721e-02f,
  1.46791814e-02f, 8.11531395e-03f, 7.16918036e-02f, 1.53884962e-01f, -8.43917802e-02f, -3.75703648e-02f, -1.24780916e-01f, -2.39295602e-01f, -1.38724521e-01f, 1.62495852e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.97391236e-01f, -7.33117238e-02f, -1.44504562e-01f, -2.81522032e-02f, 1.34209305e-01f, 1.20342068e-01f, 1.02741253e-02f, -4.71621901e-02f, 1.30906273e-02f, 5.50730228e-02f,
  -2.91524045e-02f, 1.06209097e-03f, 1.24910921e-01f, 9.29861441e-02f, -1.29517848e-02f, 5.59019931e-02f, -1.50143489e-01f, 7.50224218e-02f, -4.08151522e-02f, 4.53986973e-02f,
  3.49006653e-02f, 6.06740415e-02f, 6.96610846e-03f, 7.23003894e-02f, -4.38196398e-02f, -2.61284411e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.29634999e-02f, -3.63746732e-02f, -2.42751867e-01f, -3.88549380e-02f, 1.07985251e-01f, -3.00378889e-01f, -1.17715321e-01f, 1.52261853e-01f, 5.89225329e-02f, 8.36098567e-02f,
  -1.19634988e-02f, 1.27582243e-02f, -1.17388606e-01f, -1.55664057e-01f, -1.15666777e-01f, 8.86441544e-02f, -1.30596712e-01f, 5.46374768e-02f, -2.58708652e-03f, 2.53861304e-02f,
  -3.26839127e-02f, 5.50227277e-02f, 6.92732781e-02f, 1.29623890e-01f, 1.98324725e-01f, -2.29834348e-01f, 6.66496977e-02f, -8.05847272e-02f, -6.70403093e-02f, 1.93338022e-02f,
  1.64851129e-01f, -1.86106846e-01f, -7.72661045e-02f, 9.14635658e-02f, -9.15592611e-02f, -2.77173460e-01f, 4.07369807e-02f, 1.39057100e-01f, -1.41012177e-01f, 1.51995802e-02f,
  -2.05398709e-01f, 1.26132473e-01f, 1.88261971e-01f, -9.87656265e-02f, -1.34747639e-01f, -1.38280362e-01f, -1.89133123e-01f, -2.23154157e-01f, 6.44517094e-02f, -4.47682571e-03f,
  -6.36808574e-02f, 3.60049188e-01f, 1.14325909e-02f, 2.06389390e-02f, 1.03118077e-01f, -1.93603322e-01f, 2.38773927e-01f, 3.35515998e-02f, -2.08164766e-01f, -1.24248564e-01f,
  1.10777050e-01f, 2.09418252e-01f, -9.86920521e-02f, 8.83841813e-02f, 2.24448681e-01f, 9.18276906e-02f, -2.46719867e-01f, 1.10248543e-01f, -4.22236733e-02f, 3.94123010e-02f,
  -6.25684634e-02f, 7.28089139e-02f, -1.77068487e-02f, 1.95739150e-01f, -2.28942987e-02f, 1.55896291e-01f, 9.17260051e-02f, 3.55130285e-02f, 1.46278786e-02f, -1.02584772e-01f,
  4.44258973e-02f, 6.59741908e-02f, -9.88837406e-02f, -1.80641070e-01f, -2.00090274e-01f, 6.40172586e-02f, 8.29647481e-02f, -1.08546525e-01f, 3.57530974e-02f, -1.07196219e-01f,
  -1.45843372e-01f, 1.77659556e-01f, -1.34407073e-01f, 1.54418617e-01f, 8.52027237e-02f, 7.74081722e-02f, 3.47926505e-02f, -3.23122777e-02f, -2.06739262e-01f, 8.91695246e-02f,
  -1.11914046e-01f, 1.67830199e-01f, -1.95749849e-03f, 4.27863002e-02f, -6.33860901e-02f, -2.12723136e-01f, 8.22364166e-02f, 4.35166210e-01f, -5.00872247e-02f, -1.34049103e-01f,
  2.01338455e-02f, -1.12824686e-01f, -3.35548669e-01f, -1.98562697e-01f, -3.87637764e-02f, -3.78143527e-02f, -5.12484983e-02f, -9.65318233e-02f, -2.12581366e-01f, 1.36259928e-01f,
  -3.06088161e-02f, -1.27360135e-01f, -5.93837164e-02f, -1.91805631e-01f, -5.76766014e-01f, 1.44132912e-01f, -5.92194460e-02f, 2.94663399e-01f, 4.11921069e-02f, 2.15537976e-02f,
  1.71273634e-01f, -1.31573394e-01f, -1.57237828e-01f, -4.51381281e-02f, 8.25239047e-02f, -1.30183116e-01f, -7.64582381e-02f, -1.20970123e-01f, -7.35428780e-02f, 8.73448923e-02f,
  -3.36638987e-02f, 1.45647014e-02f, -5.60905747e-02f, 8.26750249e-02f, 3.39749805e-03f, 8.37135501e-03f, -8.61241892e-02f, -4.17632386e-02f, 3.59954610e-02f, 1.63598210e-01f,
  -7.66134355e-03f, -2.18887910e-01f, -8.41714665e-02f, 2.49386743e-01f, -7.92284589e-03f, 1.27014846e-01f, -1.61767125e-01f, -4.66766022e-02f, -1.77893013e-01f, 9.92000178e-02f,
  -9.07357335e-02f, 1.00242138e-01f, 1.63488552e-01f, 1.68867067e-01f, 1.07607506e-01f, -1.68029398e-01f, -1.17167398e-01f, 8.76899660e-02f, 1.37176573e-01f, 3.00964550e-03f,
  -4.10392821e-01f, 2.08854154e-01f, 6.85644448e-02f, -2.93323286e-02f, 2.56170034e-01f, 1.56412408e-01f, -1.23176321e-01f, 2.14647263e-01f, 1.54974446e-01f, -2.91091591e-01f,
  -1.76178738e-01f, 1.23196684e-01f, -1.41649783e-01f, 3.25833678e-01f, -7.36052310e-03f, 3.38458687e-01f, 7.12562799e-02f, 1.43780649e-01f, 1.35439277e-01f, -1.31590828e-01f,
  1.07307665e-01f, 1.51288554e-01f, -3.09555070e-03f, -3.52372155e-02f, 4.24996354e-02f, -7.43628060e-03f, 2.19688088e-01f, 1.04007870e-02f, -2.00195819e-01f, 8.66925269e-02f,
  2.34309323e-02f, 6.02974072e-02f, -3.00154742e-03f, -8.95143196e-04f, -9.80579853e-02f, -1.39157735e-02f, -9.31844041e-02f, 2.77234125e-03f, -7.09012672e-02f, -8.43658671e-02f,
  1.08301066e-01f, 3.81773822e-02f, 4.37482782e-02f, 1.45035401e-01f, -1.23146422e-01f, 7.98967257e-02f, 1.49592355e-01f, -4.10898551e-02f, -4.95596118e-02f, 1.49473503e-01f,
  1.39754042e-01f, 6.01661503e-02f, 1.92215949e-01f, -9.43241790e-02f, -1.41258210e-01f, 8.05286542e-02f, -5.88644631e-02f, -1.24161050e-01f, 3.99713665e-02f, -5.98891340e-02f,
  6.44687936e-02f, 1.47646517e-01f, 1.80343971e-01f, 2.01776013e-01f, 7.26397382e-04f, -8.33654311e-03f, -3.08758188e-02f, -5.99134676e-02f, 7.59239569e-02f, -6.78221658e-02f,
  -1.85098603e-01f, -1.22644790e-01f, -1.40251843e-02f, -1.05920568e-01f, -3.75065535e-01f, -1.40947521e-01f, -9.63518173e-02f, -2.67046064e-01f, -1.29121974e-01f, 7.03138486e-02f,
  -8.43638778e-02f, 1.62976459e-01f, 4.27350961e-02f, -1.88187435e-01f, 7.27439225e-02f, -7.38472044e-02f, 1.43093199e-01f, 3.48618627e-02f, -1.37934476e-01f, 3.32160108e-02f,
  1.53938131e-02f, 1.25910014e-01f, 4.69115861e-02f, 1.26290068e-01f, 9.59028900e-02f, -2.03668159e-02f, -3.25369760e-02f, 8.08115117e-03f, -5.44817327e-03f, 1.06756799e-01f,
  1.86669365e-01f, 1.21668145e-01f, -1.94832770e-04f, 8.83144289e-02f, -7.52858073e-02f, -2.97061503e-01f, -3.69790732e-03f, -2.74461438e-03f, -8.51840824e-02f, -1.15949079e-01f,
  -8.75254348e-02f, -2.14924365e-02f, 1.59900784e-01f, 4.45466675e-02f, -2.15445116e-01f, -1.87535882e-01f, 1.23649210e-01f, 6.47443980e-02f, 8.23474750e-02f, 1.40310675e-01f,
  -4.78209965e-02f, 2.64808759e-02f, -9.61860344e-02f, 1.35456294e-01f, -2.45078057e-01f, 1.08208358e-02f, -4.85018641e-02f, -2.20161602e-01f, -6.83736429e-02f, 2.21503936e-02f,
  -1.37978986e-01f, -1.31711960e-01f, -8.40886310e-02f, -1.18289538e-01f, 1.31998107e-01f, -1.95601180e-01f, 1.90474048e-01f, 6.05886355e-02f, 1.62918195e-02f, 1.87322021e-01f,
  1.60204709e-01f, -1.44289613e-01f, 3.26831698e-01f, 1.02134526e-01f, 9.45742354e-02f, -1.00509182e-01f, -2.22417802e-01f, 1.90092236e-01f, -2.07148090e-01f, 2.12999880e-01f,
  -8.38259086e-02f, 5.82718253e-02f, 1.05353333e-01f, -4.21449449e-03f, -6.17156457e-03f, -1.70333812e-03f, 6.42473251e-02f, -1.91817281e-03f, -6.40675277e-02f, -6.63055703e-02f,
  -8.66796523e-02f, -9.39467251e-02f, -8.12109485e-02f, -1.11531347e-01f, -8.35034102e-02f, -8.27135965e-02f, 7.53933284e-03f, -5.40692732e-02f, -9.14982930e-02f, -7.10851327e-02f,
  -2.16586277e-01f, -2.35063210e-03f, 2.71790754e-02f, -4.03657444e-02f, -5.72414659e-02f, 1.00957096e-01f, 8.63792822e-02f, -1.49402255e-03f, -1.07554920e-01f, -8.90932686e-04f,
  4.61201780e-02f, -5.48699964e-03f, 1.05676502e-01f, 2.74674390e-02f, -8.26338958e-03f, 1.31765962e-01f, -6.42636120e-02f, -4.82028015e-02f, 3.12553570e-02f, -1.18887968e-01f,
  -8.84503350e-02f, -2.17732266e-01f, -1.74311861e-01f, 1.35112673e-01f, -1.02774709e-01f, -1.29088864e-01f, 2.25241661e-01f, 4.64252606e-02f, -1.19048581e-01f, 7.31361732e-02f,
  1.54736221e-01f, -1.15556970e-01f, 1.10068068e-01f, 2.46753886e-01f, -6.73860461e-02f, 2.85205781e-01f, 3.15075845e-01f, -3.01952269e-02f, 4.32223491e-02f, -1.10634312e-01f,
  1.39192775e-01f, -1.96970049e-02f, -9.54388976e-02f, -2.45073840e-01f, 1.30915418e-02f, -1.73237532e-01f, 2.06882849e-01f, -1.20856920e-02f, -3.99654210e-02f, 1.23393744e-01f,
  1.97105825e-01f, 4.31980863e-02f, 1.89673074e-03f, -1.17176689e-01f, 2.85996627e-02f, -1.03819231e-02f, -2.89023258e-02f, 1.32100992e-02f, -6.87962621e-02f, -7.82182589e-02f,
  1.30036697e-02f, -7.53171369e-02f, 8.07023719e-02f, -1.80919588e-01f, -1.96476579e-01f, -2.16732100e-02f, -6.91145808e-02f, -2.45691761e-02f, -1.22666426e-01f, 8.05485249e-02f,
  -5.69600277e-02f, -9.10308957e-02f, -9.49736312e-02f, -7.50502795e-02f, -1.84710883e-02f, -2.41740653e-03f, -1.77916642e-02f, -5.28821833e-02f, -4.37253434e-03f, 1.50726184e-01f,
  -9.24340263e-02f, -2.54422706e-02f, 1.02963718e-02f, -7.57503211e-02f, -2.20458321e-02f, -1.14410944e-01f, -1.21837603e-02f, -1.26935571e-01f, 1.04312211e-01f, 3.78463790e-02f,
  1.51110590e-01f, 4.37190235e-02f, -1.14688836e-01f, 1.10092245e-01f, 2.23558620e-01f, -1.06249951e-01f, 2.43289083e-01f, 1.76700488e-01f, 3.47223803e-02f, 2.42771223e-01f,
  2.17072025e-01f, 1.35728925e-01f, 1.09282948e-01f, -1.34948298e-01f, 9.51132402e-02f, -4.75739725e-02f, -2.52308875e-01f, 2.36002803e-01f, 3.45502719e-02f, -1.10586010e-01f,
  -5.77325672e-02f, 1.61565766e-01f, 4.18714955e-02f, -1.33485571e-01f, 5.14487103e-02f, -3.05032283e-02f, 7.82662481e-02f, 9.53318328e-02f, -1.79784507e-01f, 1.84155740e-02f,
  9.21334140e-03f, -1.16911270e-01f, -2.50232313e-02f, 2.68705841e-02f, -7.03441119e-03f, -2.72629913e-02f, -1.31673306e-01f, 4.23304029e-02f, 3.87535952e-02f, -7.74166407e-03f,
  1.78469997e-02f, 3.44469561e-03f, 7.33332634e-02f, -1.66471988e-01f, -1.03128009e-01f, 1.17064320e-01f, 2.83275694e-02f, -9.76708084e-02f, 3.51890065e-02f, 1.03607826e-01f,
  -9.57273915e-02f, 3.25431041e-02f, -3.97661850e-02f, -1.47466004e-01f, -1.22567266e-02f, -2.98583116e-02f, 2.03505844e-01f, 7.12637827e-02f, 1.19420595e-01f, -7.92265236e-02f,
  2.48291433e-01f, -1.73784092e-01f, -1.23586662e-01f, -1.43074766e-01f, -1.06746860e-01f, -9.03647095e-02f, 8.97034779e-02f, -1.95224017e-01f, -1.18736759e-01f, -5.95426336e-02f,
  -1.11159556e-01f, -1.21702895e-01f, -5.32210916e-02f, -2.65425086e-01f, -2.28949204e-01f, -8.78345687e-03f, 1.19752303e-01f, 2.05269977e-01f, -1.54547662e-01f, 7.82319531e-02f,
  1.06219025e-02f, 1.48502484e-01f, 1.26279175e-01f, 7.62782060e-03f, 1.79847315e-01f, 4.11837781e-03f, -1.52996057e-04f, 3.58603522e-02f, -1.07368343e-01f, -1.50676832e-01f,
  -9.22962092e-03f, -5.95196560e-02f, -2.17122436e-02f, 1.50748879e-01f, -8.55828598e-02f, 5.44799939e-02f, 7.79749919e-03f, -3.98863619e-03f, 3.02735474e-02f, -1.68468669e-01f,
  -1.36888176e-01f, -9.64325015e-03f, 4.21676598e-02f, 1.33308575e-01f, -6.03151396e-02f, -2.74519980e-01f, -6.90216273e-02f, -7.17711523e-02f, -4.35639657e-02f, 1.54320419e-01f,
  -2.41389751e-01f, 3.72599475e-02f, -6.05524220e-02f, 7.90360942e-02f, 5.42169362e-02f, -8.56336802e-02f, -4.41281796e-02f, 1.41909763e-01f, -1.03977941e-01f, -1.61873549e-01f,
  2.11391434e-01f, -1.64350703e-01f, 6.19654842e-02f, -2.56855130e-01f, 1.95424587e-01f, -9.69600976e-02f, -1.47111304e-02f, -2.23267227e-02f, 6.75349534e-02f, -2.23589629e-01f,
  -1.85593098e-01f, -9.96919945e-02f, 7.14912340e-02f, 1.59474388e-02f, -8.32105055e-02f, 1.94866449e-01f, -4.41036262e-02f, 3.07811469e-01f, 2.99456775e-01f, -2.34497599e-02f,
  4.90094051e-02f, 1.67154476e-01f, -1.89150453e-01f, 2.32074544e-01f, -1.19765796e-01f, 1.28234819e-01f, 1.77268431e-01f, -1.08590029e-01f, 1.61025912e-01f, -9.56009626e-02f,
  -9.40965563e-02f, 1.20718740e-01f, -1.29797861e-01f, -6.06725290e-02f, 9.22469273e-02f, -7.80740455e-02f, -2.27036417e-01f, 1.05352275e-01f, 4.17129695e-02f, -2.00625844e-02f,
  -1.19145319e-01f, -2.13067792e-02f, -6.28593862e-02f, -3.07872356e-03f, -1.48446783e-01f, 1.08994253e-01f, 1.98668777e-03f, 1.92044273e-01f, -9.41281766e-03f, -1.36730790e-01f,
  -1.45070776e-01f, 2.26780459e-01f, -5.52978851e-02f, 1.22434780e-01f, 1.19259711e-02f, -1.27941117e-01f, 8.68785605e-02f, 5.44738770e-02f, -9.37730893e-02f, 4.04183902e-02f,
  -1.33251892e-02f, 1.20988965e-01f, 1.83299487e-03f, -1.25274226e-01f, 1.23475485e-01f, -1.46467745e-01f, 1.49166688e-01f, 7.88673237e-02f, -3.25027317e-01f, 4.68576290e-02f,
  9.49192196e-02f, -5.83655387e-02f, 2.17935741e-01f, 2.76844442e-01f, -1.13041528e-01f, 2.07266003e-01f, 1.66173995e-01f, -1.42165497e-01f, -1.56001821e-01f, 1.08098783e-01f,
  -7.96268582e-02f, 1.24744602e-01f, 2.76353747e-01f, 6.02050424e-02f, -1.93205714e-01f, 6.57216087e-02f, -5.93572669e-02f, 1.62457764e-01f, 2.76881866e-02f, -2.26653084e-01f,
  -2.70487065e-03f, 7.59517774e-02f, 1.22032529e-02f, -1.30831808e-01f, -2.36094743e-02f, -8.40643942e-02f, -1.88264787e-01f, -1.36183307e-01f, -6.99229017e-02f, 8.17620456e-02f,
  7.72819221e-02f, -1.67708546e-02f, 1.57259300e-01f, 7.95283541e-03f, -1.21090457e-01f, -9.17574093e-02f, -2.91128852e-03f, -4.33301777e-02f, -5.57614788e-02f, 1.55868217e-01f,
  1.36015847e-01f, -8.18230659e-02f, -1.21822655e-01f, 1.09416910e-01f, 1.10045699e-02f, 1.81816235e-01f, 1.42820761e-01f, 1.44854352e-01f, 2.19746456e-01f, -7.59420618e-02f,
  2.20984578e-01f, -1.59341544e-01f, -1.89148977e-01f, -2.91989036e-02f, -1.88849419e-01f, 1.83464810e-02f, 4.24968032e-03f, -1.16087623e-01f, 4.95808981e-02f, -1.32556126e-01f,
  1.87436976e-02f, 7.81802982e-02f, 6.69222698e-02f, 6.60406277e-02f, -5.85505329e-02f, 6.16461076e-02f, -1.51376948e-01f, -2.03504249e-01f, -3.37606370e-02f, -2.31595904e-01f,
  1.64512515e-01f, -5.39252646e-02f, -3.18272382e-01f, -1.76453277e-01f, -1.21006265e-01f, -3.15555185e-01f, -1.21522672e-01f, 2.65136622e-02f, 1.41305868e-02f, 2.54455954e-01f,
  -1.05818331e-01f, -8.73870775e-03f, 2.26653531e-01f, 5.91325648e-02f, -1.04319956e-03f, -1.60242766e-02f, 1.10947676e-01f, -5.11096269e-02f, -4.41016406e-02f, 2.47078072e-02f,
  -1.33389784e-02f, -1.34401649e-01f, 7.81002864e-02f, -2.56481198e-05f, -5.64625836e-04f, -1.44633710e-01f, -9.54196230e-02f, 3.63037828e-03f, -1.94856171e-02f, -1.32313473e-02f,
  -3.00893709e-02f, -7.04331324e-02f, 1.07113749e-01f, 2.28231270e-02f, -7.45681077e-02f, 1.90527126e-01f, -3.69320586e-02f, 2.64733713e-02f, 1.32567480e-01f, -3.86909731e-02f,
  -1.91531107e-01f, 2.12004222e-02f, 2.19000012e-01f, 1.32038280e-01f, -1.26100052e-02f, -6.29194230e-02f, -4.53177467e-02f, 1.33947521e-01f, -1.24742258e-02f, 7.42650731e-03f,
  6.10947944e-02f, 1.39724035e-02f, -6.01186566e-02f, -2.38120660e-01f, -6.27036169e-02f, 9.74215269e-02f, -8.02644342e-03f, 2.21899733e-01f, 2.27218494e-01f, -1.42446786e-01f,
  3.19321483e-01f, 6.14019856e-02f, -6.75760731e-02f, 3.12206358e-01f, 2.36828044e-01f, -6.30928800e-02f, 8.46094266e-02f, -9.52301174e-03f, 9.38183591e-02f, 5.12657762e-01f,
  9.12726000e-02f, 5.67970518e-03f, 3.32007743e-02f, -2.85449228e-03f, 1.55832320e-01f, -7.93376490e-02f, 1.39982447e-01f, 7.04910606e-02f, 6.30725622e-02f, 4.31742929e-02f,
  1.72870472e-01f, -1.06531054e-01f, 2.55490132e-02f, -9.64358598e-02f, -4.43654717e-04f, -9.81242359e-02f, -6.68264413e-03f, -4.51892987e-02f, -5.73241711e-02f, -9.53042507e-02f,
  -1.36352703e-01f, -2.05465611e-02f, -1.35380551e-01f, -2.49410234e-02f, 1.36029199e-01f, 2.92126574e-02f, -1.03144377e-01f, -1.09344512e-01f, 1.11865662e-02f, 1.34633601e-01f,
  5.10207452e-02f, -5.90543970e-02f, -1.08750232e-01f, 9.55869332e-02f, 1.08840458e-01f, -2.24614576e-01f, -1.95101783e-01f, -1.11490428e-01f, -1.40673909e-02f, 8.31735283e-02f,
  -3.52220349e-02f, 1.15816602e-02f, -4.20112386e-02f, 2.24682197e-01f, -7.51549900e-02f, -1.08259439e-01f, 9.28636044e-02f, -7.73174837e-02f, -3.07250209e-02f, -5.76758608e-02f,
  1.67807676e-02f, -1.15318276e-01f, 6.62168488e-02f, -2.29653679e-02f, -7.53111541e-02f, -6.48118332e-02f, -1.55189008e-01f, 8.06170925e-02f, 1.44875184e-01f, -1.05756573e-01f,
  4.78552803e-02f, 1.26226887e-01f, 4.91911322e-02f, 4.03620768e-03f, 3.25887173e-01f, -2.31023263e-02f, 1.79088116e-01f, -1.22168668e-01f, 2.16993973e-01f, 1.03340887e-01f,
  -1.57760754e-01f, 1.92434028e-01f, 5.66302389e-02f, 2.81407572e-02f, -5.62575087e-03f, 2.59812474e-02f, -1.63161363e-02f, 7.46379122e-02f, -2.42941789e-02f, 5.33734001e-02f,
  -2.42291372e-02f, -2.88962014e-02f, 6.55317605e-02f, 1.92269292e-02f, 1.25572188e-02f, -8.92412383e-03f, 4.57522012e-02f, 9.19835046e-02f, -1.63131412e-02f, 4.07779329e-02f,
  9.40826386e-02f, -2.16034371e-02f, -4.41726632e-02f, -6.04878180e-02f, -6.66111484e-02f, -2.25250479e-02f, 6.14181906e-02f, -1.45586506e-01f, 9.42732692e-02f, 2.87729576e-02f,
  1.87051259e-02f, 8.92891958e-02f, 4.07450721e-02f, 2.73343064e-02f, -1.44432951e-02f, 3.99343222e-02f, -1.57587454e-01f, 1.36640400e-01f, -2.93977279e-02f, -8.42603371e-02f,
  8.40359405e-02f, 1.39110669e-01f, 5.75700030e-02f, 2.32204929e-01f, 2.15583071e-01f, 1.90064237e-01f, -2.45167688e-01f, -2.02613652e-01f, -2.36867741e-01f, -1.59139976e-01f,
  -6.17891066e-02f, -1.50961399e-01f, -1.59181535e-01f, -6.62473440e-02f, -1.09044574e-01f, 1.87626123e-01f, -1.66861132e-01f, -2.82109350e-01f, -2.09080532e-01f, 9.30264518e-02f,
  -1.59624100e-01f, -7.60098174e-02f, 5.95085416e-03f, 2.37375170e-01f, 6.25175312e-02f, -9.60998908e-02f, -1.63258985e-01f, 1.15588561e-01f, -3.61008584e-01f, -1.82809718e-02f,
  1.69767782e-01f, -1.98163465e-01f, 2.69241966e-02f, 1.50495665e-02f, -9.71122906e-02f, 4.11455780e-02f, 8.45158845e-03f, 6.46886230e-02f, 8.84661227e-02f, -9.53853503e-02f,
  1.09187402e-01f, -5.27170002e-02f, -2.15051010e-01f, -7.01897442e-02f, -3.39460820e-02f, -2.41666287e-01f, -6.61836565e-02f, -7.19183385e-02f, 1.63588859e-02f, 3.11387360e-01f,
  2.99891770e-01f, -3.99645835e-01f, 3.67678255e-02f, 7.63143739e-03f, 1.40837327e-01f, 3.73091139e-02f, 7.10009709e-02f, -4.37309518e-02f, 2.30027243e-01f, -8.71576928e-03f,
  9.52128321e-02f, -8.03167524e-04f, 5.97044220e-03f, 2.15454474e-01f, 1.57719940e-01f, 2.42928445e-01f, 1.01667017e-01f, -2.87224919e-01f, 2.32517838e-01f, -1.44488320e-01f,
  -1.11131184e-01f, -9.04101953e-02f, -1.90956190e-01f, 1.36622369e-01f, 2.37910882e-01f, 1.66591287e-01f, -4.70851094e-01f, -1.92773249e-02f, 3.07408988e-01f, -2.82661915e-01f,
  9.47094560e-02f, -2.63526112e-01f, -3.15862536e-01f, 1.60716891e-01f, -7.03522712e-02f, -1.63909256e-01f, 3.91004086e-02f, -2.79206991e-01f, 2.50781719e-02f, 1.06567405e-01f,
  -1.39473438e-01f, -1.93492770e-01f, 7.22010732e-02f, -3.05292942e-02f, -1.22806564e-01f, 5.85854873e-02f, 1.24996610e-01f, -5.95170632e-02f, 4.15007509e-02f, -6.03616349e-02f,
  9.59808677e-02f, -9.07837898e-02f, -3.79676670e-02f, -8.61004274e-03f, -7.84402713e-02f, 2.14987667e-03f, -9.36829597e-02f, -6.43351227e-02f, 3.23425800e-01f, 1.42082693e-02f,
  -6.65271729e-02f, 1.86220273e-01f, -2.29791645e-02f, -1.56681642e-01f, -5.53193912e-02f, -3.49185392e-02f, -1.69607058e-01f, 8.23782533e-02f, -1.30561898e-02f, 3.14698398e-01f,
  -1.13165632e-01f, 9.78221893e-02f, -5.50840609e-02f, 5.03539704e-02f, 7.50157982e-02f, 1.73919752e-01f, 9.99846607e-02f, -3.85718867e-02f, -1.47409186e-01f, -1.51662707e-01f,
  -6.10406660e-02f, 1.89306319e-01f, 8.31888691e-02f, 3.79811466e-01f, 7.64008239e-02f, 8.73902962e-02f, 3.31667900e-01f, 1.03010945e-01f, -6.05263412e-02f, 1.10362135e-01f,
  -3.65751050e-02f, -2.51256436e-01f, 2.59722397e-02f, 3.95806283e-02f, -7.85689577e-02f, 4.00887609e-01f, -2.77006060e-01f, -1.11725189e-01f, 2.67124683e-01f, 1.13225579e-02f,
  1.25634655e-01f, -4.11308050e-01f, 1.29487842e-01f, -5.05229533e-02f, 7.07130730e-02f, 4.16559801e-02f, -3.10996473e-01f, -7.93128833e-02f, 1.76090434e-01f, -1.11869514e-01f,
  8.36501271e-02f, 1.49522290e-01f, -9.06824842e-02f, -6.46767095e-02f, 2.43278429e-01f, -1.35430530e-01f, 1.50522277e-01f, 1.49466936e-02f, -6.29975721e-02f, -2.29026124e-01f,
  1.61244169e-01f, -9.88905504e-02f, 2.25221813e-01f, 5.01902252e-02f, -1.63786355e-02f, -1.75611153e-01f, -1.49873406e-01f, 2.39677012e-01f, 5.58045581e-02f, -2.26648375e-01f,
  1.02775790e-01f, -6.80915415e-02f, 2.41238862e-01f, 7.57657960e-02f, 1.46894678e-01f, 5.95934354e-02f, 4.56729196e-02f, -1.34453490e-01f, -9.77835953e-02f, -1.30839258e-01f,
  -1.23145588e-01f, -2.37981807e-02f, 3.32198255e-02f, 9.83928517e-03f, -4.11695316e-02f, 2.12233990e-01f, 1.83467388e-01f, 3.56776118e-02f, 1.13270059e-01f, 8.50931704e-02f,
  -1.19820639e-01f, 7.30838403e-02f, 1.42273203e-01f, 7.61276111e-02f, -1.53215528e-01f, 1.23856992e-01f, 9.68736783e-02f, -1.68714017e-01f, -3.81215438e-02f, -1.80133194e-01f,
  -2.93271929e-01f, -2.32368663e-01f, -2.56998669e-02f, -4.48639941e-04f, 2.29933023e-01f, -1.37835681e-01f, 3.73570696e-02f, -3.13788354e-01f, 4.48966175e-02f, -8.19711313e-02f,
  -7.85801709e-02f, -6.01900145e-02f, 1.01607786e-02f, -7.77118281e-03f, 4.03943509e-02f, 3.27606685e-02f, 3.39957029e-02f, -7.29225017e-03f, 7.03788102e-02f, 4.32156324e-02f,
  1.03596352e-01f, 7.04677328e-02f, -9.35619045e-03f, 5.89053407e-02f, 1.06510473e-03f, 1.41151905e-01f, 1.74858049e-01f, -1.94891728e-03f, 3.13888863e-02f, -3.43176983e-02f,
  -8.40771291e-03f, 3.22496176e-01f, -3.16304378e-02f, -6.71152398e-02f, 1.15192667e-01f, 1.31176814e-01f, 2.80371219e-01f, 1.28412992e-01f, 2.54730642e-01f, -8.50662440e-02f,
  -7.13048130e-02f, -6.13179952e-02f, -1.37961194e-01f, -6.24716617e-02f, 8.67092833e-02f, -2.83436244e-03f, -1.72142964e-02f, 2.19832473e-02f, -1.61282390e-01f, 4.07160610e-01f,
  2.95654312e-02f, 1.89689294e-01f, -9.90824327e-02f, -1.07073270e-01f, -9.47334766e-02f, 2.26814859e-02f, 9.67733935e-02f, -6.47812858e-02f, -1.89481869e-01f, 1.66436613e-01f,
  -8.34762231e-02f, -1.94621369e-01f, 9.16491598e-02f, -1.47849619e-01f, -1.14875592e-01f, -9.48027521e-02f, -1.73525691e-01f, -1.90234538e-02f, 8.18728283e-02f, -3.70740406e-02f,
  2.31065273e-01f, -4.55508418e-02f, -3.73483784e-02f, 5.84741235e-02f, -8.81305039e-02f, -7.71891102e-02f, -3.91741991e-02f, 5.75343473e-03f, 4.78297174e-02f, -8.41076449e-02f,
  8.34585056e-02f, -2.91298889e-02f, 3.53091992e-02f, -1.34018555e-01f, 3.07058508e-04f, 8.57296064e-02f, -9.44941938e-02f, -4.42977063e-02f, 5.29008657e-02f, -8.85781869e-02f,
  5.50671704e-02f, 4.43747528e-02f, 5.07220672e-03f, 1.12138748e-01f, -5.79873435e-02f, 1.86960071e-01f, -5.23562320e-02f, 1.43991247e-01f, -6.56396970e-02f, 2.52207220e-01f,
  1.37557358e-01f, 1.42109752e-01f, 5.05790710e-02f, 7.81609043e-02f, -2.64319475e-03f, 7.84539282e-02f, 1.12444319e-01f, 1.66762069e-01f, 2.14431092e-01f, 6.54515848e-02f,
  1.99957967e-01f, -9.43717360e-02f, 2.38874108e-01f, 2.19846174e-01f, 9.24089644e-03f, 1.69258937e-01f, 5.57767041e-02f, -6.76528662e-02f, 9.13001746e-02f, -5.00784218e-02f,
  -1.86838970e-01f, 2.96377111e-03f, -5.87745570e-02f, -2.49980390e-01f, -2.00424746e-01f, -1.18203789e-01f, 1.49668036e-02f, 9.31343436e-02f, -3.19808185e-01f, -6.46852106e-02f,
  1.62665860e-03f, -2.46111099e-02f, -7.88824633e-03f, -3.18035036e-01f, 1.09285273e-01f, -2.98696780e-03f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.80772677e-01f, -1.04587220e-01f, -1.86907649e-01f, 2.14986667e-01f, 2.02979267e-01f, 2.98986514e-03f, 1.38856187e-01f, 9.38738808e-02f, 5.88221811e-02f, 1.78245977e-01f,
  2.68925220e-01f, 3.32443044e-02f, 1.17456518e-01f, 1.21973187e-01f, 9.07615721e-02f, 9.00778323e-02f, -1.25469770e-02f, 1.17658101e-01f, 1.81269959e-01f, -1.84169099e-01f,
  -1.79193139e-01f, 6.41187206e-02f, 2.22073793e-02f, 1.19480239e-02f, -8.56127068e-02f, 1.48043603e-01f, -2.31622070e-01f, 2.62711316e-01f, -1.29095629e-01f, 2.22645342e-01f,
  -6.66554347e-02f, 2.00637862e-01f, 1.68880269e-01f, 1.81346744e-01f, -1.01815723e-01f, 4.73106325e-01f, -8.15848410e-02f, -5.49678616e-02f, -3.69280428e-01f, -3.71235907e-01f,
  -9.68924351e-03f, 1.73392490e-01f, -5.16796932e-02f, 4.04262036e-01f, -6.57564551e-02f, -3.19311917e-01f, 1.55071095e-01f, 8.54217336e-02f, -1.45513147e-01f, -1.94957495e-01f,
  1.50913997e-02f, 1.10712843e-02f, -5.87463900e-02f, 2.49078013e-02f, 3.30426805e-02f, 1.41197011e-01f, -2.50097692e-01f, -1.22714460e-01f, 1.29240528e-01f, -2.19783187e-01f,
  9.23122466e-02f, -1.89418256e-01f, 1.49492383e-01f, 4.29892875e-02f, -5.29619604e-02f, -8.29914361e-02f, 1.24049233e-02f, -7.54639646e-03f, -7.85499960e-02f, 3.52404863e-02f,
  1.13408685e-01f, -8.41337442e-02f, 3.64511199e-02f, -3.10231373e-02f, -7.92099014e-02f, -6.15669116e-02f, 1.68783486e-01f, 3.74851450e-02f, 6.56505674e-02f, 9.64317322e-02f,
  1.04126103e-01f, 1.82348173e-02f, -2.65592081e-03f, 3.82522643e-02f, -9.70586948e-03f, -4.50871745e-03f, -1.94927473e-02f, 8.16043690e-02f, 3.92203704e-02f, 1.72253430e-01f,
  -3.23428959e-02f, -5.32850698e-02f, 4.26304415e-02f, 6.64519444e-02f, 6.24961162e-04f, 1.22169033e-01f, -1.18804097e-01f, -5.13930134e-02f, 5.15093133e-02f, -9.78048742e-02f,
  1.98886208e-02f, -2.71672755e-03f, 5.40769137e-02f, 6.34619873e-03f, -2.16048863e-02f, -6.50486946e-02f, -3.99298102e-01f, 5.95879182e-03f, 2.49752089e-01f, 3.17128420e-01f,
  1.09969653e-01f, 2.95538843e-01f, 3.40035439e-01f, 3.13977391e-01f, 9.74375680e-02f, -9.37064178e-03f, 4.14569795e-01f, -9.53077599e-02f, 2.46349841e-01f, 1.55683771e-01f,
  2.63970107e-01f, -1.96440116e-01f, 4.49915342e-02f, 1.12650812e-01f, 2.09934071e-01f, -1.65536314e-01f, 7.82998577e-02f, 5.32362126e-02f, -1.58227324e-01f, -8.72520581e-02f,
  1.03156351e-01f, -7.87684843e-02f, 2.60525532e-02f, 1.36945441e-01f, 9.91423875e-02f, -2.48678979e-02f, -3.88955250e-02f, -1.09307885e-01f, -5.13867736e-02f, -5.12252860e-02f,
  2.79272231e-03f, 1.16959460e-01f, 1.02425896e-01f, -5.30229462e-03f, 8.35817382e-02f, -9.31428149e-02f, -3.54198664e-02f, 2.27529779e-01f, 4.21579406e-02f, -1.78039691e-03f,
  -2.45067820e-01f, -2.12096926e-02f, 6.09109439e-02f, -7.38818496e-02f, 2.81572323e-02f, -1.18508041e-01f, -2.39295010e-02f, -3.24977599e-02f, 3.24749984e-02f, -4.08294201e-02f,
  2.64181737e-02f, 1.10851675e-02f, 3.59917954e-02f, -2.04012215e-01f, -1.75031945e-02f, 2.67973896e-02f, 3.84790868e-01f, 2.80861277e-02f, -2.77057718e-02f, -3.57666731e-01f,
  1.45455196e-01f, -3.23313296e-01f, 2.01601669e-01f, 3.59672010e-01f, 1.47619009e-01f, 5.04551549e-03f, 7.61736035e-02f, 2.21189484e-01f, 1.21138245e-02f, -1.33470953e-01f,
  2.89627582e-01f, -9.49450955e-02f, -1.47586480e-01f, 4.63519245e-02f, -1.16691448e-01f, -1.87832743e-01f, 3.45073611e-01f, 2.36406133e-01f, 2.70332117e-02f, -1.85605422e-01f,
  -4.40889895e-02f, 6.52234405e-02f, -7.55450726e-02f, -4.09875587e-02f, 3.47833693e-01f, 7.87327811e-02f, 1.78978562e-01f, 5.33908159e-02f, -1.10393448e-03f, 9.32560563e-02f,
  4.29406799e-02f, -6.80542514e-02f, 9.53603312e-02f, 1.00983888e-01f, 7.32893348e-02f, -1.21174783e-01f, 9.17575061e-02f, 1.49721513e-02f, 2.47689486e-02f, 1.35241181e-01f,
  6.47330955e-02f, -2.16143563e-01f, -8.92019197e-02f, -4.17176895e-02f, 4.65529263e-02f, 4.30436544e-02f, -3.94922793e-02f, -9.68679860e-02f, 7.54840523e-02f, -1.35866314e-01f,
  -1.70151338e-01f, -9.65967551e-02f, -3.14419419e-02f, 7.21875206e-02f, -6.84923083e-02f, -4.12458517e-02f, 1.57714021e-04f, 6.61489218e-02f, -1.49575770e-01f, 1.31028499e-02f,
  -3.35816504e-03f, -1.17248960e-01f, 4.22625504e-02f, 1.11008098e-03f, -6.07155450e-02f, -2.91960567e-01f, -9.21898484e-02f, 8.35505351e-02f, 7.48051107e-02f, -2.86583006e-01f,
  3.27443220e-02f, -9.37646478e-02f, 1.35862559e-01f, 4.45623659e-02f, 4.54045832e-02f, 1.03231922e-01f, 1.40139207e-01f, 2.60919128e-02f, 3.84784728e-01f, 7.82322362e-02f,
  3.35622340e-01f, 3.79523523e-02f, 6.17883541e-02f, 1.92924619e-01f, -4.88759458e-01f, 7.96172470e-02f, 7.49112368e-02f, 8.53504017e-02f, -1.62069336e-01f, 1.09350793e-01f,
  5.47398403e-02f, 1.14740944e-02f, -1.21738389e-01f, 1.44551799e-01f, 6.06007092e-02f, -7.21591860e-02f, 1.24581628e-01f, -7.32045434e-03f, 1.22221984e-01f, 1.12744905e-01f,
  -1.32008851e-01f, -7.40372986e-02f, 1.98304936e-01f, 1.26905097e-02f, 5.80374012e-03f, 2.71046497e-02f, 1.03853062e-01f, 1.76294416e-01f, -3.34039629e-02f, 8.09639767e-02f,
  1.19011402e-01f, 6.95140585e-02f, 1.50315493e-01f, 1.71973094e-01f, 2.31059968e-01f, 8.63201320e-02f, 3.36386502e-01f, 6.29957020e-02f, -9.72286090e-02f, -1.15354598e-01f,
  -8.01791772e-02f, -1.33299798e-01f, 8.76744837e-02f, -6.58776313e-02f, 1.68747336e-01f, 1.02302590e-02f, 1.31261855e-01f, 1.48066714e-01f, 1.28409728e-01f, -7.56558822e-03f,
  -1.28871039e-01f, -2.61931252e-02f, -4.20178287e-02f, 1.04809530e-01f, -3.17213759e-02f, -1.32607639e-01f, 8.96211639e-02f, 7.45997801e-02f, -1.24146812e-01f, -5.91441914e-02f,
  -7.06600025e-02f, -1.36875451e-01f, -2.20303372e-01f, -2.77087748e-01f, 8.71990919e-02f, -3.27151269e-02f, -5.50260544e-02f, -4.83350940e-02f, 7.61784464e-02f, -3.26621622e-01f,
  2.71094572e-02f, 5.66179566e-02f, 2.03556135e-01f, -3.78762521e-02f, 3.52293588e-02f, -3.17324251e-02f, -1.33100018e-01f, -8.37575644e-02f, 1.07698165e-01f, 2.22971067e-02f,
  -1.54352039e-01f, 1.18143544e-01f, 1.22076161e-01f, -1.22856252e-01f, 1.16317878e-02f, 8.96579549e-02f, 1.32546172e-01f, -2.62255389e-02f, -8.38781744e-02f, 5.78623312e-03f,
  4.17439044e-02f, -1.63781792e-01f, 1.50010154e-01f, 1.19706422e-01f, -3.27284522e-02f, 2.07323879e-01f, 1.62043110e-01f, -6.39402270e-02f, 1.11534849e-01f, -1.53779462e-01f,
  3.39656584e-02f, 2.02178266e-02f, -1.13217436e-01f, -8.83410797e-02f, -8.84255543e-02f, 8.61641392e-02f, 1.13372825e-01f, -1.18967123e-01f, 4.70906086e-02f, 9.68074426e-03f,
  1.27631411e-01f, 1.18479848e-01f, 1.15236817e-02f, -2.38313138e-01f, -6.08002618e-02f, -1.72006473e-01f, -1.14853373e-02f, -2.66116053e-01f, 1.77134350e-01f, 6.44607618e-02f,
  2.43120193e-01f, 1.79109514e-01f, -1.63003191e-01f, 1.03319146e-01f, 7.57384300e-02f, -3.58730048e-01f, 2.40338042e-01f, 1.04306191e-01f, 2.16901198e-01f, -1.42592385e-01f,
  -1.24471724e-01f, 3.13533366e-01f, -1.84725881e-01f, 1.95257992e-01f, 9.13560390e-02f, 8.12572539e-02f, -3.87336686e-02f, 1.69300148e-03f, 2.71018475e-01f, 1.30515635e-01f,
  -1.04803473e-01f, 2.26875931e-01f, 1.55134341e-02f, 1.17335841e-01f, 7.15141371e-02f, 7.91649744e-02f, 1.03832997e-01f, 3.67766581e-02f, -6.96302727e-02f, 3.49203199e-02f,
  1.64234892e-01f, 8.28631688e-04f, 3.97507213e-02f, 6.12866580e-02f, 1.62556209e-02f, 3.53243761e-02f, 1.39458522e-01f, 9.17648003e-02f, 1.12369545e-01f, 1.76071823e-01f,
  -5.56411827e-03f, 2.67836630e-01f, 7.39049464e-02f, -1.97990268e-01f, 2.17651725e-01f, 7.91365355e-02f, -7.88086802e-02f, -1.29801273e-01f, -6.78163245e-02f, 5.95389418e-02f,
  -7.21976385e-02f, -1.30101129e-01f, -7.33074695e-02f, -1.63351521e-01f, 3.89550766e-03f, 2.36062169e-01f, 1.63596839e-01f, 2.94091493e-01f, -4.57391478e-02f, -2.58628935e-01f,
  6.91754594e-02f, -1.03360288e-01f, -3.20194870e-01f, -1.04037113e-01f, 2.02633783e-01f, -1.11386523e-01f, -1.62331283e-01f, 3.13064009e-01f, 6.94309026e-02f, -5.49315438e-02f,
  -1.01354875e-01f, 2.35624641e-01f, 2.15047687e-01f, 7.71941319e-02f, -1.67248055e-01f, 3.66955489e-01f, 1.49385780e-01f, 2.07202196e-01f, 1.14665382e-01f, 2.93946378e-02f,
  2.52724111e-01f, 9.16653275e-02f, 6.66210651e-02f, -4.62590344e-02f, -1.05661586e-01f, 2.04152748e-01f, 2.26696238e-01f, 3.29678170e-02f, -1.31386802e-01f, 2.06109196e-01f,
  -6.91412687e-02f, -6.04821853e-02f, 1.02715418e-01f, 1.64678469e-01f, 1.55739382e-01f, 1.64503261e-01f, 2.75544692e-02f, -1.55230850e-01f, -6.96883202e-02f, -1.21981017e-01f,
  1.26176670e-01f, -5.64280786e-02f, -2.13548496e-01f, -2.67402697e-02f, 9.75735858e-03f, -1.67192504e-01f, -2.25698546e-01f, -9.20820609e-02f, -1.32353023e-01f, -6.69386387e-02f,
  -1.72847603e-02f, 6.97687268e-02f, -7.30277821e-02f, -3.16761173e-02f, -5.07505573e-02f, 4.12189662e-02f, -8.75293836e-02f, -4.35327552e-02f, 6.08540103e-02f, 2.78503299e-02f,
  3.03649553e-03f, -1.43809780e-01f, -9.16820765e-02f, -1.25610441e-01f, -7.14444444e-02f, -1.67783856e-01f, -2.23633833e-02f, -1.99394807e-01f, 1.52051359e-01f, 1.06706887e-01f,
  -4.97923829e-02f, 1.58545241e-01f, -6.08516447e-02f, -5.25518693e-02f, 3.70066434e-01f, -1.23414569e-01f, 2.35348810e-02f, -1.97139218e-01f, -6.98446706e-02f, 3.62406790e-01f,
  -2.56437868e-01f, 2.18119621e-01f, -7.32019693e-02f, 2.98319254e-02f, 3.22150648e-01f, -5.62081579e-03f, -3.87283973e-02f, 7.71306157e-02f, 9.43051726e-02f, -1.70132980e-01f,
  1.88387409e-02f, 3.82731296e-02f, -1.65347561e-01f, 1.92096844e-01f, -4.10485603e-02f, 9.32519808e-02f, 7.90276974e-02f, -1.97433047e-02f, -8.52155238e-02f, -1.26862690e-01f,
  -1.52162865e-01f, -1.76772192e-01f, 3.73285189e-02f, 1.57488361e-01f, 1.38553128e-01f, -1.67347953e-01f, -2.12301519e-02f, -3.22028957e-02f, -9.81859416e-02f, -2.01970153e-02f,
  -1.27669603e-01f, -9.32805464e-02f, -1.21185370e-01f, -8.25331211e-02f, -1.56652816e-02f, 6.33706301e-02f, 4.80663925e-02f, 1.35909781e-01f, -1.22446597e-01f, 2.04138104e-02f,
  9.09802839e-02f, 1.43382654e-01f, 1.91249266e-01f, -2.50353515e-01f, -1.73941046e-01f, -1.08231522e-01f, 2.23057166e-01f, 1.55838460e-01f, 7.06093162e-02f, -3.06297630e-01f,
  -2.13335305e-02f, 3.03789172e-02f, 3.43715996e-02f, -1.96742326e-01f, 4.96874191e-02f, 1.93635538e-01f, 3.92281497e-03f, 1.20944701e-01f, 2.95549065e-01f, 5.52630285e-03f,
  -2.18402911e-02f, 1.88211411e-01f, -2.12928265e-01f, 9.67851728e-02f, 1.06848449e-01f, 6.33028448e-02f, 8.96320418e-02f, -4.12303321e-02f, -3.77293862e-03f, 1.16797104e-01f,
  -8.68845731e-02f, 2.05710515e-01f, 2.22130656e-01f, 1.40797004e-01f, -9.60780904e-02f, -4.39182334e-02f, 1.57449067e-01f, 7.44646564e-02f, 3.55390459e-03f, 1.24264829e-01f,
  1.91379726e-01f, 7.87165761e-02f, -3.65075991e-02f, 9.61350556e-03f, 2.79969513e-01f, -2.22918205e-02f, -8.19963664e-02f, -3.13028805e-02f, 8.35913420e-02f, 5.13844080e-02f,
  8.46539158e-03f, 2.00999469e-01f, -2.14180946e-01f, 3.18348765e-01f, 1.73865303e-01f, -6.53105676e-02f, -2.49930874e-01f, 1.93882331e-01f, -6.16871677e-02f, 5.07825166e-02f,
  -9.48706642e-02f, 1.82964817e-01f, 1.01893149e-01f, 1.15489222e-01f, -4.43426609e-01f, -1.68692097e-01f, 9.56301838e-02f, 8.95893127e-02f, -1.05071254e-01f, 3.79775226e-01f,
  1.78755447e-01f, 2.52342480e-03f, 5.63774891e-02f, 2.52965569e-01f, -1.51689932e-01f, -1.07614629e-01f, -8.18036795e-02f, -3.01565707e-01f, 2.01972529e-01f, -8.56925771e-02f,
  7.06042945e-02f, 2.25856900e-01f, -3.49156260e-01f, 1.15138009e-01f, -1.66824237e-01f, 1.29228547e-01f, 2.55342990e-01f, -2.51762420e-01f, 1.55586645e-01f, -8.78959224e-02f,
  -1.97273605e-02f, 4.16403748e-02f, 3.62969041e-02f, 2.14978799e-01f, 2.06152454e-01f, 1.28355678e-02f, 1.12473741e-01f, 2.69495826e-02f, 3.13326046e-02f, 2.81056464e-01f,
  1.52483925e-01f, 1.72354981e-01f, -4.30354811e-02f, 4.06739935e-02f, 7.87924305e-02f, 6.89842999e-02f, 1.39521390e-01f, -3.14633064e-02f, 1.19384915e-01f, -1.60421625e-01f,
  -1.70480460e-01f, -2.08903015e-01f, 7.77591811e-03f, 1.15388520e-01f, 2.35382374e-03f, -2.33370394e-01f, 1.43581375e-01f, 1.70736890e-02f, -2.57571697e-01f, 6.23289570e-02f,
  -9.45891961e-02f, 7.60302767e-02f, 9.24542919e-02f, -2.63584554e-01f, -1.52579919e-01f, -6.60587996e-02f, -1.46323562e-01f, 8.14051926e-02f, 4.29629255e-03f, 1.58536717e-01f,
  -2.77798891e-01f, -6.93582371e-02f, 2.41026327e-01f, 7.03615025e-02f, 3.05932034e-02f, 3.22919004e-02f, -1.81137651e-01f, 5.45884632e-02f, -4.38437089e-02f, -1.87361360e-01f,
  -2.53849119e-01f, 8.62932205e-02f, -2.22039241e-02f, 5.64555228e-02f, 1.81169495e-01f, -9.21185538e-02f, -2.07377136e-01f, -7.43639171e-02f, 1.24883540e-02f, -1.24910630e-01f,
  -1.72403112e-01f, 4.47259843e-02f, -7.27144331e-02f, -5.57152517e-02f, 2.34302357e-02f, 1.44141451e-01f, 4.65789922e-02f, 3.36098275e-03f, 9.82395783e-02f, 3.36874984e-02f,
  2.24710926e-01f, 4.15910669e-02f, 3.47577929e-02f, 7.81540424e-02f, -1.88308265e-02f, 5.07299788e-02f, -2.14931872e-02f, 1.43759146e-01f, 9.29685235e-02f, -2.64628883e-02f,
  -1.28766194e-01f, -2.02694517e-02f, 2.86909170e-04f, -2.80986447e-02f, -1.83548272e-01f, 1.67402640e-01f, -2.20833197e-02f, 3.51193473e-02f, 4.16840278e-02f, -3.65913007e-03f,
  -1.36456192e-01f, -1.50103331e-01f, -5.24446256e-02f, 6.08568676e-02f, -3.03803999e-02f, 1.34732693e-01f, -4.53438051e-02f, 8.05336162e-02f, 2.62495037e-02f, -6.70481026e-02f,
  -3.02523244e-02f, -7.09441602e-02f, 1.86276570e-01f, 9.52643454e-02f, -4.15913500e-02f, -2.08387107e-01f, -2.91949749e-01f, -1.04627959e-01f, 2.63335735e-01f, 2.55021125e-01f,
  2.02620029e-01f, 8.92590508e-02f, 6.37989268e-02f, 2.65697509e-01f, 5.83867133e-02f, -1.88904554e-01f, 2.47166127e-01f, 1.83705017e-02f, -1.49364257e-02f, 3.71596515e-01f,
  6.77056611e-02f, -1.45015508e-01f, -1.71924427e-01f, 1.60605609e-01f, 2.47783333e-01f, -3.04536909e-01f, 9.93156806e-02f, -1.29221484e-01f, 1.84140757e-01f, 1.19693696e-01f,
  -2.03652352e-01f, -1.79283507e-02f, 1.74448058e-01f, 8.85638446e-02f, -4.61332910e-02f, -1.36388524e-03f, 1.30533025e-01f, -4.55752164e-02f, 2.49822140e-01f, 9.56484377e-02f,
  2.78221667e-01f, 2.20406890e-01f, 9.70438644e-02f, -1.42564610e-01f, 2.08345592e-01f, 8.97016078e-02f, 1.69611439e-01f, 2.35894412e-01f, 1.72976494e-01f, 1.13486096e-01f,
  -2.47259393e-01f, 2.76246160e-01f, 5.62079623e-02f, 1.84720770e-01f, 6.87277243e-02f, 8.76950622e-02f, 1.68734074e-01f, 7.64575079e-02f, 3.47583175e-01f, -1.05511397e-01f,
  -2.40352377e-01f, -1.48888417e-02f, -2.98688114e-01f, -2.98133016e-01f, 9.31235254e-02f, 5.18353730e-02f, 1.08697796e-02f, -2.03251868e-01f, -4.42699390e-03f, 1.06544256e-01f,
  -4.72165830e-02f, 1.69897869e-01f, 4.90211248e-02f, 6.66607022e-02f, 1.41176447e-01f, 1.30902708e-01f, -1.83997124e-01f, -1.01487763e-01f, -1.62930191e-01f, 1.69206247e-01f,
  -1.92316651e-01f, -5.71832992e-02f, 6.18730672e-02f, -1.08632579e-01f, -1.43213749e-01f, -6.86037093e-02f, -6.96595311e-02f, 3.72359216e-01f, -9.22353938e-02f, 1.98537856e-02f,
  3.68584841e-01f, -1.55340403e-01f, 1.84113741e-01f, -6.04479276e-02f, 7.51159862e-02f, 4.10385579e-02f, -1.06950346e-02f, 5.92441708e-02f, -2.10300848e-01f, -1.60348877e-01f,
  1.22462608e-01f, 1.28900453e-01f, 4.69181426e-02f, -2.06560716e-02f, 1.01239607e-01f, 1.02963261e-01f, -1.56852901e-01f, -4.18189093e-02f, 3.76303867e-02f, 8.04632995e-03f,
  4.85668890e-02f, -6.93306029e-02f, 7.63597190e-02f, -8.48140940e-02f, -1.22670248e-01f, 1.50246248e-01f, 1.59926444e-01f, 1.83865145e-01f, -2.05432713e-01f, 9.14570540e-02f,
  5.84890060e-02f, -1.24670669e-01f, 2.56684393e-01f, -8.16269666e-02f, -7.99731351e-03f, -9.92551446e-03f, -8.24415907e-02f, -5.40396348e-02f, -7.46622309e-02f, -8.96444321e-02f,
  -7.85194039e-02f, 1.04274370e-01f, -9.84324366e-02f, 4.04476702e-01f, -1.92222863e-01f, 1.90669373e-01f, 3.71607430e-02f, -6.10745884e-02f, 6.77715391e-02f, 2.43857056e-01f,
  2.17400402e-01f, 5.77170178e-02f, 1.53718725e-01f, 2.43948773e-01f, 1.82717144e-01f, -1.19300850e-01f, 2.71897703e-01f, -1.50808230e-01f, 1.84681743e-01f, -6.70482665e-02f,
  -2.90662855e-01f, -5.53850736e-03f, 1.99093655e-01f, 2.41677329e-01f, -8.43944028e-02f, 2.75886595e-01f, 9.06815100e-03f, -1.43256159e-02f, 5.49923889e-02f, -9.78850797e-02f,
  -3.42963040e-02f, 4.04242985e-02f, 1.55223981e-01f, 4.37281132e-02f, 8.24444368e-02f, -1.87077392e-02f, 2.34124009e-02f, 9.68873315e-03f, 1.15273885e-01f, -5.50090857e-02f,
  1.29172489e-01f, 4.78093065e-02f, -1.95616502e-02f, -1.06968433e-01f, 1.27492892e-03f, 1.10394523e-01f, 2.42408291e-02f, 1.94714978e-01f, -9.92921889e-02f, 3.80937606e-02f,
  5.11621498e-02f, 2.91211624e-02f, 8.03750157e-02f, 6.29960448e-02f, -1.68043338e-02f, 1.76485315e-01f, 1.61587358e-01f, -7.45638832e-02f, -7.83506855e-02f, 3.67680229e-02f,
  -2.78187990e-02f, -7.09612295e-02f, -3.25145759e-02f, 8.29925463e-02f, 2.92041004e-01f, -2.78989524e-02f, 1.20053038e-01f, 8.39365181e-03f, -9.43572149e-02f, -3.39655280e-02f,
  1.71659291e-01f, 3.73347193e-01f, 1.04941733e-01f, 5.67057058e-02f, 2.12585591e-02f, 1.50625303e-01f, -4.33215871e-03f, -1.73160642e-01f, 4.07392234e-02f, -1.34792835e-01f,
  -8.46060142e-02f, 6.24813922e-02f, -4.69779298e-02f, -2.24337339e-01f, 5.15025333e-02f, 1.69923812e-01f, -4.38515693e-02f, -1.48139969e-01f, 1.14423946e-01f, -2.32020870e-01f,
  8.57570767e-03f, 1.28698051e-01f, 6.42008036e-02f, 1.11005761e-01f, -1.92402687e-03f, -5.18749282e-02f, -1.88143905e-02f, 5.97857498e-02f, 6.47076815e-02f, 5.86654507e-02f,
  -2.17582528e-02f, -5.27751148e-02f, -1.98596511e-02f, -6.30636290e-02f, 7.71383122e-02f, -1.35207891e-01f, 1.13010503e-01f, 3.40185240e-02f, 2.57277369e-01f, -2.88936850e-02f,
  -2.45376870e-01f, 1.87163413e-01f, -1.27125252e-02f, 6.76265508e-02f, 1.43138736e-01f, -4.38711345e-01f, -1.18831299e-01f, -4.68560085e-02f, 1.40678868e-01f, 2.60619760e-01f,
  1.61419973e-01f, -1.82493731e-01f, 9.44011509e-02f, -1.63358569e-01f, -2.37006918e-02f, -3.13592097e-03f, 2.84686834e-01f, 1.49862126e-01f, 2.73575604e-01f, -4.75960001e-02f,
  -7.15101957e-02f, -2.42516026e-01f, 4.44084793e-01f, 5.01886150e-03f, -9.62335169e-02f, -9.94336829e-02f, 9.75146368e-02f, -1.17257185e-01f, -2.81257570e-01f, -6.09332398e-02f,
  1.74117181e-02f, 1.55111417e-01f, -1.28000543e-01f, -4.38982025e-02f, -2.15412527e-02f, 2.65338302e-01f, -1.05423875e-01f, -1.82954550e-01f, 1.00172898e-02f, 1.54794510e-02f,
  1.39593720e-01f, -1.36024728e-01f, -1.57984085e-02f, 2.25181252e-01f, 1.13393329e-01f, 1.06728233e-01f, 3.34899612e-02f, 5.17811812e-03f, 1.23352893e-01f, -5.69456257e-02f,
  1.35112450e-01f, -6.96065724e-02f, -7.41390958e-02f, -3.26721221e-02f, 6.09380640e-02f, -1.06075518e-01f, 1.02830179e-01f, -1.91922355e-02f, -1.83094703e-02f, 3.94812878e-03f,
  -3.42276096e-02f, 4.17374037e-02f, 1.54781386e-01f, 2.32208237e-01f, -1.17564112e-01f, -1.21787190e-02f, -1.46473087e-02f, -7.58704692e-02f, -4.34934162e-03f, -3.04091424e-02f,
  2.00057268e-01f, -2.47793511e-01f, -8.69121850e-02f, 6.77693859e-02f, 4.10175771e-02f, -9.93687063e-02f, -1.00029893e-01f, -7.08727464e-02f, -1.37131274e-01f, -1.42527699e-01f,
  -4.60228622e-02f, -1.68942716e-02f, 2.03466490e-01f, 9.28617492e-02f, -1.67815909e-01f, -1.56126410e-01f, 1.10232025e-01f, -3.45464140e-01f, 2.13907316e-01f, 3.71395141e-01f,
  -2.91444436e-02f, -8.81576096e-04f, 2.26093367e-01f, 2.58148998e-01f, 3.00710469e-01f, 4.05641496e-02f, 1.31476313e-01f, 1.95009828e-01f, 9.06560943e-03f, 2.50403062e-02f,
  2.91083872e-01f, -1.42732002e-02f, -9.76238921e-02f, -8.44426267e-03f, 2.29939207e-01f, 7.09388480e-02f, -4.39888351e-02f, 4.41546366e-02f, 3.23337130e-02f, 4.66279127e-02f,
  3.03512692e-01f, 2.18945481e-02f, 1.28619373e-01f, 1.24542527e-01f, -9.27432999e-02f, 4.34398502e-02f, 1.58557773e-01f, -1.48848435e-02f, -1.09116860e-01f, 2.11034149e-01f,
  2.13704947e-02f, -3.36424857e-02f, -2.47506257e-02f, 1.28012314e-01f, 5.11059798e-02f, -6.02500886e-02f, -1.57989323e-01f, -2.33080670e-01f, -4.62670960e-02f, -2.19884932e-01f,
  1.55787736e-01f, -2.12049678e-01f, -1.60453424e-01f, -2.66982973e-01f, 1.31263714e-02f, -3.77258301e-01f, -4.38557774e-01f, -1.53291911e-01f, -1.59434184e-01f, 8.37036408e-03f,
  6.25601560e-02f, -9.22951698e-02f, -1.53432768e-02f, 1.18803851e-01f, -1.46348327e-01f, 1.26771912e-01f, 2.05055363e-02f, -6.48132116e-02f, -1.66386738e-01f, -1.26283109e-01f,
  1.71817854e-01f, -3.88248451e-02f, -9.86064076e-02f, -5.02102897e-02f, 1.98796373e-02f, -1.92058384e-01f, 3.80089283e-02f, -1.06477268e-01f, -4.96440381e-02f, 2.40044624e-01f,
  1.16169229e-01f, 1.85381860e-01f, 1.39853284e-01f, -1.86359450e-01f, 2.68247157e-01f, 6.67404085e-02f, 2.13260770e-01f, -1.64962128e-01f, -6.23686314e-02f, 2.53260314e-01f,
  -3.95556271e-01f, 9.88338515e-02f, -2.69075893e-02f, -3.30323726e-02f, 3.64647567e-01f, -1.27877027e-01f, -2.44771868e-01f, 4.51775640e-02f, 3.32202986e-02f, 5.78021780e-02f,
  -5.85947409e-02f, -1.92057624e-01f, -1.61138117e-01f, -1.27919689e-01f, -1.58849582e-01f, -8.05109516e-02f, -4.80113737e-02f, -1.55455887e-01f, 5.00230193e-02f, -2.00144500e-01f,
  -2.20455248e-02f, -1.34229258e-01f, -3.39568332e-02f, 2.45536659e-02f, 1.56896710e-01f, 2.41957545e-01f, 9.54448357e-02f, 2.25411858e-02f, 5.52682206e-02f, 2.87380636e-01f,
  4.58804443e-02f, -3.47233973e-02f, 9.03990194e-02f, -2.09228665e-01f, -1.10999644e-01f, 8.45941827e-02f, -1.67725548e-01f, 1.08428359e-01f, 1.51854247e-01f, -2.87806205e-02f,
  -1.96530417e-01f, -1.33891165e-01f, -6.77555650e-02f, 2.01116338e-01f, -1.41246483e-01f, 2.58767828e-02f, -6.39867708e-02f, -1.25843987e-01f, 1.66950673e-01f, 2.81480253e-01f,
  8.27266648e-02f, -1.10238947e-01f, 4.66966778e-02f, -9.89074484e-02f, -2.23359000e-02f, 9.59030837e-02f, 6.13419935e-02f, -1.62490532e-01f, -2.14904815e-01f, -1.18822522e-01f,
  -1.74842805e-01f, 9.33076814e-03f, 2.07354814e-01f, -1.05319835e-01f, 6.45166216e-03f, -1.33365527e-01f, -1.10436402e-01f, 1.58493984e-02f, -9.31717455e-02f, -5.05856723e-02f,
  8.72964337e-02f, 2.95024761e-03f, 7.54980519e-02f, -1.81149438e-01f, -1.76139493e-02f, -1.00874361e-02f, 2.07896456e-01f, -5.14452569e-02f, 6.08667284e-02f, -5.17682023e-02f,
  3.65307629e-02f, -1.23933312e-02f, -8.51155666e-04f, 1.94759108e-02f, -1.90238021e-02f, 2.06641465e-01f, 2.23462239e-01f, 2.28521526e-01f, -8.16034302e-02f, 1.48045838e-01f,
  1.00858927e-01f, -4.23155427e-02f, 4.78761755e-02f, -2.28142217e-02f, 2.86311835e-01f, 1.29541844e-01f, 1.28771260e-01f, 1.15049854e-01f, -1.47143215e-01f, -7.83571601e-02f,
  -8.31493959e-02f, -1.61529303e-01f, 1.91985607e-01f, 4.70771790e-02f, 2.35536635e-01f, -3.29044819e-01f, -4.31948341e-02f, -7.29559502e-03f, -6.86268732e-02f, -3.51197481e-01f,
  1.17690124e-01f, 4.28979158e-01f, 1.62304580e-01f, 1.61916744e-02f, 1.19275644e-01f, 2.07714126e-01f, -2.04138830e-01f, -3.08580458e-01f, 2.07005948e-01f, 1.76202860e-02f,
  -1.09324954e-01f, 8.88877213e-02f, -5.18793873e-02f, -1.94968939e-01f, -1.83914602e-01f, 2.20843047e-01f, 1.12603106e-01f, -3.61301988e-01f, 7.24729076e-02f, -1.58208624e-01f,
  6.35051429e-02f, -1.32714748e-01f, 3.11377853e-01f, 3.27051468e-02f, 1.34663150e-01f, 1.26975164e-01f, 1.06324784e-01f, 6.49103941e-03f, 2.84249783e-01f, 1.54544279e-01f,
  -5.92162274e-02f, -5.13857454e-02f, 8.68442357e-02f, -3.07453256e-02f, -1.41716570e-01f, -1.41451448e-01f, 1.66851223e-01f, 1.54480413e-01f, 1.70732871e-01f, 7.20002223e-03f,
  1.32435858e-01f, -1.29075795e-01f, -8.71232674e-02f, 6.95839077e-02f, -2.89975375e-01f, 5.06736279e-01f, 3.08223128e-01f, 1.42168216e-02f, -9.53112394e-02f, -2.58444816e-01f,
  3.47716808e-01f, -6.22677105e-03f, -2.03989208e-01f, 2.70716429e-01f, -2.29033560e-01f, -3.62843871e-02f, 5.60724214e-02f, -1.41507402e-01f, -2.24167094e-01f, -5.02958000e-01f,
  -4.80958410e-02f, 4.20484781e-01f, -2.85405785e-01f, -3.60348225e-02f, -4.94204424e-02f, 9.82343033e-02f, 2.32535794e-01f, 1.04733042e-01f, -2.13704452e-01f, -5.88029735e-02f,
  7.01114014e-02f, 3.29823256e-01f, -2.04668894e-01f, 7.16436803e-02f, 1.75437570e-01f, -1.89306572e-01f, 3.50505620e-01f, -1.21336907e-01f, -3.33172590e-01f, -1.46080613e-01f,
  5.72466776e-02f, 2.80126214e-01f, 1.09583326e-01f, 1.70385048e-01f, 4.51021641e-02f, 1.10504232e-01f, 1.52162686e-01f, 5.46690635e-02f, 1.85445130e-01f, 1.47467449e-01f,
  8.36335421e-02f, 1.04806148e-01f, 1.05536409e-01f, 7.64312893e-02f, 2.03154609e-02f, 1.29999220e-01f, 1.34804994e-01f, 2.56487932e-02f, 1.47660390e-01f, 9.14411917e-02f,
  1.11912496e-01f, -1.34159878e-01f, -3.15179154e-02f, -6.65922314e-02f, 1.62163854e-01f, 2.84586132e-01f, 8.02698731e-02f, -2.67012298e-01f, 9.78914127e-02f, -3.36478442e-01f,
  -1.13869429e-01f, -1.52659774e-01f, -1.31960362e-01f, 9.31503326e-02f, 1.83846071e-01f, -1.03624552e-01f, 1.22669622e-01f, 7.73881301e-02f, -7.69752041e-02f, 1.06381752e-01f,
  -8.07518885e-02f, 3.25883508e-01f, 4.19604629e-02f, 4.13964912e-02f, 2.23257970e-02f, -8.27910453e-02f, -1.83210775e-01f, 2.59780467e-01f, 2.38132011e-02f, -3.96033600e-02f,
  2.33877361e-01f, -1.97749808e-02f, -2.86541402e-01f, -5.28610386e-02f, -2.81390309e-01f, -2.41254792e-01f, -3.36253196e-01f, -2.61317223e-01f, -1.66537821e-01f, 1.32388487e-01f,
  3.53365280e-02f, -3.24277766e-02f, -8.24015215e-03f, 2.10933506e-01f, -2.33148739e-01f, -4.40559983e-02f, 1.74757138e-01f, -1.32513717e-01f, 1.38997044e-02f, -3.07930000e-02f,
  -1.57061100e-01f, 9.24843103e-02f, 4.58677448e-02f, -6.35137558e-02f, 7.85084143e-02f, 1.30185798e-01f, -1.55034875e-02f, -6.21470511e-02f, -9.54477340e-02f, 3.62995118e-02f,
  1.36197776e-01f, 1.84177533e-02f, 6.58452362e-02f, 1.29857540e-01f, 1.18020177e-01f, 2.28628460e-02f, 5.02851084e-02f, -1.21608436e-01f, 5.61277103e-03f, 5.56229390e-02f,
  1.04682997e-01f, -1.40747592e-01f, -8.18752274e-02f, -8.47586393e-02f, 5.89371249e-02f, 3.86437289e-02f, -1.64624810e-01f, -4.47582863e-02f, -1.19718954e-01f, 3.43149379e-02f,
  1.44740373e-01f, 6.24824315e-02f, -1.20089076e-01f, 1.21120356e-01f, -5.37087657e-02f, 9.17518064e-02f, -1.66402370e-01f, 1.94332525e-01f, 2.21254796e-01f, -3.31945866e-01f,
  -1.72250643e-01f, -1.88488051e-01f, -1.46034854e-02f, -8.70891884e-02f, -2.69154817e-01f, 1.68131888e-01f, -8.99600238e-02f, -2.87761509e-01f, 9.15936604e-02f, -2.67270833e-01f,
  -1.16137430e-01f, 4.13209438e-01f, -1.34828284e-01f, -8.61862525e-02f, 3.98156121e-02f, 1.64180368e-01f, 4.64771315e-02f, -6.35214150e-02f, 8.46030787e-02f, -3.74490991e-02f,
  -8.20920542e-02f, 3.42175388e-03f, -5.65844625e-02f, -4.02161144e-02f, -5.83492577e-01f, 2.24985883e-01f, 7.90060386e-02f, -5.28556556e-02f, 1.06759161e-01f, 1.42679095e-01f,
  1.76421367e-02f, 4.29882249e-03f, 1.67342544e-01f, 1.99303254e-02f, 7.67530724e-02f, -7.25807399e-02f, 1.54871434e-01f, 1.39255151e-01f, 1.75975144e-01f, 1.01360790e-01f,
  2.75158703e-01f, -4.37228382e-02f, -3.81228514e-02f, 1.08659483e-01f, -1.10713325e-01f, 1.71998605e-01f, 4.94501293e-02f, -2.95482695e-01f, 1.21043459e-01f, -2.01590881e-01f,
  4.64708842e-02f, 1.11489631e-01f, -1.17655002e-01f, 1.80406824e-01f, 1.15327902e-01f, -2.43712261e-01f, 5.92929823e-03f, 9.55787748e-02f, 5.84480911e-03f, 4.43297960e-02f,
  -5.20921266e-03f, -2.23198369e-01f, 1.26933381e-02f, -1.83842704e-01f, 9.62427408e-02f, 8.72070789e-02f, 3.18095274e-03f, -9.72695574e-02f, -5.74532077e-02f, 5.51575683e-02f,
  1.96805015e-01f, 1.92411363e-01f, -1.03665985e-01f, 1.03750005e-01f, 3.31136376e-01f, 4.20980901e-02f, 1.07218437e-01f, 1.08304590e-01f, 2.17346717e-02f, -3.83908629e-01f,
  2.48932056e-02f, 3.40152462e-03f, 1.89037561e-01f, -1.35921434e-01f, -1.05348691e-01f, -1.65960670e-01f, -4.12969366e-02f, -1.37829125e-01f, 4.06667683e-03f, -9.57547203e-02f,
  1.08328789e-01f, -2.09678262e-02f, 2.18295559e-01f, 1.50342090e-02f, 1.89456165e-01f, -5.67755885e-02f, 1.20103717e-01f, 6.01352379e-02f, 7.49463588e-02f, 9.90479905e-03f,
  -5.51982895e-02f, 5.83649352e-02f, 1.05480537e-01f, 1.45266339e-01f, 2.28417620e-01f, 7.99774134e-04f, -1.54100150e-01f, -1.47326559e-01f, 8.35730359e-02f, -3.08868475e-02f,
  -3.73904914e-01f, 2.92388767e-01f, 6.86878115e-02f, -1.59327015e-01f, -1.02028109e-01f, 3.37766148e-02f, -2.38057658e-01f, 7.99409077e-02f, 1.71802431e-01f, 2.18921646e-01f,
  7.86061808e-02f, 9.93745551e-02f, -8.03180411e-02f, -1.05846688e-01f, -7.88662024e-03f, -2.79670298e-01f, -1.21805079e-01f, -4.16795872e-02f, -1.96394309e-01f, -1.39212329e-02f,
  -1.03202321e-01f, -1.19754933e-02f, -1.62677150e-02f, 6.37443736e-02f, 1.19320616e-01f, 2.88489699e-01f, -1.14392310e-01f, 3.10286671e-01f, 2.35955626e-01f, 2.26039216e-01f,
  3.10887069e-01f, 1.35931998e-01f, 3.27023655e-01f, -1.92155108e-01f, -5.58021739e-02f, -3.33379239e-01f, 1.31130442e-01f, -2.68797837e-02f, -2.73129642e-01f, 8.82606432e-02f,
  6.79874793e-02f, 8.79323408e-02f, -1.34710729e-01f, -7.58641437e-02f, 1.28339618e-01f, 3.26923728e-02f, -1.56660438e-01f, -7.86668286e-02f, 2.25907430e-01f, 1.11794375e-01f,
  6.62604496e-02f, 4.38241288e-02f, 2.43958801e-01f, 7.67475367e-02f, 4.16862918e-03f, 6.35437854e-03f, 1.76150933e-01f, 1.33077025e-01f, -1.74016729e-01f, 4.48869526e-01f,
  1.08147413e-01f, -2.43320428e-02f, -1.97848737e-01f, 7.69915655e-02f, 1.06554352e-01f, 1.39619678e-01f, 4.52702269e-02f, -2.24199876e-01f, 5.69018200e-02f, -1.19273864e-01f,
  1.51387572e-01f, -1.49529770e-01f, -1.16689518e-01f, -1.68613583e-01f, -3.43109481e-02f, -3.76563549e-01f, 7.26409554e-02f, -9.92125124e-02f, 3.15551937e-01f, 3.20138894e-02f,
  -4.29524528e-03f, 4.67916131e-02f, 2.07729451e-02f, -4.43274409e-01f, 6.54606223e-02f, 4.01760072e-01f, -1.58172268e-02f, -1.63892016e-01f, 5.35113923e-02f, 3.25004250e-01f,
  1.64949849e-01f, 1.95564590e-02f, 1.31554872e-01f, 3.33911404e-02f, 7.35786483e-02f, -3.31402337e-03f, 3.02789003e-01f, -2.66058296e-01f, -3.73937875e-01f, 1.64531544e-02f,
  1.88992277e-01f, 1.70119956e-01f, -1.75846785e-01f, -9.55508277e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.90525763e-02f, 1.36418164e-01f, -6.05729111e-02f, -3.75886671e-02f, 8.02263841e-02f, -4.12871875e-02f, 1.91294700e-01f, 1.61589414e-04f, 3.89826484e-03f, -5.41669410e-03f,
  1.40733927e-01f, -4.63859141e-02f, 2.56649911e-01f, 1.22985795e-01f, 1.76615402e-01f, 6.98502660e-02f, -1.01867868e-02f, -5.33080511e-02f, -9.50013008e-03f, 1.01749599e-01f,
  -2.19864883e-02f, 1.12527646e-02f, 7.38354027e-02f, 1.43034652e-01f, 5.54107577e-02f, 5.00788204e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.95334349e-02f, -1.28735542e-01f, -5.12356032e-03f, -2.11981833e-02f, 9.22115743e-02f, 8.53382703e-03f, 4.35231999e-02f, 8.45756605e-02f, -2.04602420e-01f, -1.50268897e-01f,
  -1.89478725e-01f, -2.36788511e-01f, 5.03535420e-02f, 4.97064628e-02f, -4.08290252e-02f, -9.40162912e-02f, -2.45355628e-02f, -6.10326864e-02f, 5.00679389e-03f, 2.49323882e-02f,
  -1.67884845e-02f, -2.23403737e-01f, -1.88344017e-01f, 6.76657557e-02f, 3.42165790e-02f, 6.38167933e-02f, 2.38894835e-01f, -1.15370132e-01f, -2.50953555e-01f, -2.81675935e-01f,
  -1.04745962e-01f, -1.48751929e-01f, 1.56914443e-01f, 2.00403988e-01f, 4.23568068e-03f, 6.67940974e-02f, 2.83617061e-03f, -1.69294462e-01f, 9.33184177e-02f, -5.16553372e-02f,
  -5.65876961e-02f, 6.66847304e-02f, -8.13735947e-02f, -1.83156118e-01f, 6.19038679e-02f, 4.22272310e-02f, -1.20779417e-01f, 2.80679375e-01f, 3.05089772e-01f, 2.44409200e-02f,
  -1.48901954e-01f, -1.20355666e-01f, -1.78914696e-01f, 1.93034589e-01f, -1.26819789e-01f, 1.46913230e-01f, -5.19872531e-02f, -3.10325414e-01f, -3.76133770e-01f, 2.61918060e-03f,
  8.22564587e-02f, 8.13906044e-02f, -6.92745438e-03f, -1.93211868e-01f, 6.92804949e-03f, 7.92021155e-02f, -3.48932669e-02f, -1.06762573e-01f, 1.70037001e-01f, -1.40060872e-01f,
  3.19475532e-02f, -8.30445662e-02f, 2.74383482e-02f, -1.88077278e-02f, 4.56345417e-02f, 8.83733667e-03f, 1.96180031e-01f, -2.41964594e-01f, -2.92354599e-02f, -8.65722895e-02f,
  -1.73359737e-02f, -8.96201581e-02f, 2.61052251e-01f, 1.78455282e-02f, 1.40806764e-01f, -2.39515960e-01f, 2.27148999e-02f, -1.23260520e-01f, -2.58139312e-01f, 1.07042499e-01f,
  -3.40518658e-04f, -1.09422944e-01f, 3.28572579e-02f, 8.52427185e-02f, -1.14632472e-02f, -3.28944921e-01f, 4.27791297e-01f, 6.63846433e-02f, 2.61027068e-01f, 1.90212682e-01f,
  9.73190442e-02f, 2.18422562e-01f, -3.89956571e-02f, 7.85762072e-03f, 2.91868061e-01f, -1.67917490e-01f, 1.76476419e-01f, -1.01625338e-01f, -8.01013187e-02f, -1.35484338e-01f,
  3.14096808e-02f, 4.17843163e-02f, -6.73764125e-02f, -1.55178504e-03f, 2.75843292e-01f, -2.56341454e-02f, 1.03129938e-01f, -5.83816059e-02f, -2.09565997e-01f, -1.91253081e-01f,
  2.97192810e-03f, 3.24339867e-02f, -1.64931044e-02f, 1.07856192e-01f, -7.93020129e-02f, 7.83269480e-02f, -1.65948048e-01f, -1.50254164e-02f, -7.42301047e-02f, 2.20670514e-02f,
  -1.82761461e-01f, 5.75308204e-02f, -9.64996368e-02f, -1.05462953e-01f, 1.45077035e-01f, -1.92584656e-02f, 1.16017535e-01f, 3.77800092e-02f, 1.64793953e-01f, 7.32866451e-02f,
  1.29337013e-01f, -1.22031026e-01f, -1.57614350e-01f, 6.67537674e-02f, 5.64396344e-02f, 1.00465566e-01f, -6.67430088e-02f, 7.14666396e-02f, 3.37022245e-02f, 4.02919650e-02f,
  2.59711236e-01f, 2.93391664e-02f, -1.54706538e-01f, -3.87816764e-02f, 2.36826465e-01f, 2.07607940e-01f, -2.14089155e-01f, 1.13029875e-01f, -3.96764800e-02f, -1.47292167e-01f,
  7.17538372e-02f, 2.07266629e-01f, -4.28878814e-02f, -1.27965882e-02f, -1.99359190e-02f, 1.19595058e-01f, 3.36202793e-02f, -1.38207883e-01f, -4.55995463e-03f, -9.53314826e-02f,
  1.10164471e-01f, -8.44841376e-02f, 1.09595314e-01f, 6.38802052e-02f, 1.69268951e-01f, 2.63875127e-02f, 9.74628329e-02f, -4.68658358e-02f, 1.65580183e-01f, 2.90397555e-02f,
  9.47036445e-02f, 6.02888726e-02f, 5.48211075e-02f, 1.23718970e-01f, -7.00057000e-02f, 9.71675441e-02f, -1.24732554e-01f, 1.32215187e-01f, 6.21165633e-02f, -2.43877634e-01f,
  -2.73319453e-01f, -1.35293761e-02f, 1.23015873e-01f, -9.01616737e-02f, 2.40927443e-01f, -1.67642295e-01f, -6.66554421e-02f, 1.25862435e-01f, 1.57856792e-01f, 3.05526406e-01f,
  6.10528290e-02f, 3.65204886e-02f, 2.69124173e-02f, 2.20680013e-01f, 9.86972526e-02f, 7.93195441e-02f, -8.41745175e-03f, 2.38609239e-01f, 1.36980861e-01f, -1.90045573e-02f,
  -2.74282247e-01f, 2.91932315e-01f, -2.90695369e-01f, -4.54497367e-01f, 2.57203472e-03f, 2.07203794e-02f, -3.73761594e-01f, 3.93493809e-02f, 1.42012939e-01f, -1.93958119e-01f,
  -3.14206362e-01f, 2.51884252e-01f, -1.67317644e-01f, -1.34976789e-01f, 1.78417370e-01f, 4.19459939e-01f, -3.34480196e-01f, 1.30360782e-01f, 3.37233007e-01f, 1.36008441e-01f,
  -9.12762526e-03f, -6.07301928e-02f, -1.24840759e-01f, -3.83444317e-02f, 1.38472989e-02f, 2.81809028e-02f, 1.05974237e-02f, -1.41975790e-01f, -1.40952975e-01f, -4.28915434e-02f,
  2.29709759e-01f, -2.27113858e-01f, -1.40420943e-02f, -1.12366296e-01f, -9.10336152e-02f, 1.17935212e-02f, 7.39837363e-02f, 7.95190185e-02f, -8.46538842e-02f, 1.07222073e-01f,
  -1.02669641e-01f, -1.19968727e-01f, -5.56045547e-02f, 6.09710515e-02f, -3.68885770e-02f, -1.32120490e-01f, 7.51887215e-03f, -1.15636934e-03f, 1.33515239e-01f, -2.97631621e-01f,
  -1.27852693e-01f, -2.05352277e-01f, 1.05101123e-01f, 7.31167123e-02f, -3.01931202e-01f, 2.64170796e-01f, -1.99083596e-01f, -1.82052895e-01f, 1.26750633e-01f, -1.15406789e-01f,
  1.87113777e-01f, 1.66441267e-03f, -2.48227820e-01f, 9.83190909e-02f, 1.41456679e-01f, -3.77964646e-01f, -1.20726481e-01f, 1.15092769e-01f, 1.88254312e-01f, -1.45335123e-01f,
  -1.20334543e-01f, -1.15791336e-01f, 1.37910798e-01f, -2.83773810e-01f, -5.74398413e-02f, -2.06964538e-02f, -1.13876257e-02f, 7.72054493e-02f, 1.69299617e-01f, -1.81814685e-01f,
  -1.94754787e-02f, 2.45773718e-01f, -6.23349547e-02f, 2.41934553e-01f, -1.21494025e-01f, 8.07479694e-02f, 1.56478226e-01f, -3.86713296e-02f, 4.71803769e-02f, -2.90048629e-01f,
  -2.48280074e-02f, -2.55121082e-01f, -1.99381620e-01f, 3.83990295e-02f, -1.07677333e-01f, 1.04779974e-01f, -3.40217687e-02f, -1.75800860e-01f, 4.52756770e-02f, 2.21828550e-01f,
  1.18072785e-01f, -2.56426364e-01f, -1.70078009e-01f, 3.69760871e-01f, -2.39261657e-01f, -6.55767173e-02f, -3.90596688e-02f, 2.42626563e-01f, -1.25184193e-01f, 9.63160023e-02f,
  -2.62448192e-02f, -1.31805474e-02f, -1.10335276e-01f, 1.48810446e-01f, 6.73892573e-02f, -1.67945847e-01f, -4.25638780e-02f, -3.18324044e-02f, -3.40258218e-02f, -4.54301350e-02f,
  -1.89374298e-01f, -8.58069062e-02f, -7.81956017e-02f, 1.68473363e-01f, 3.77212055e-02f, -7.10774362e-02f, -3.11359148e-02f, 2.13466249e-02f, 9.98638421e-02f, -1.03482520e-02f,
  4.50841188e-01f, 1.37913138e-01f, 1.11946359e-01f, 1.27122045e-01f, 1.47363544e-01f, 6.48469403e-02f, -1.06176026e-01f, 6.09901212e-02f, 1.70014247e-01f, 2.38156199e-01f,
  1.98187172e-01f, 1.11073792e-01f, -3.03058587e-02f, -2.60765553e-01f, 2.70846069e-01f, 9.38070640e-02f, 1.74768120e-01f, 3.88508430e-03f, -1.05970949e-02f, 2.06148878e-01f,
  -2.74076730e-01f, 4.21961099e-02f, -5.27550280e-02f, -1.44968614e-01f, 2.38096938e-02f, -2.12170422e-01f, -1.39758423e-01f, 2.97291696e-01f, -1.73402384e-01f, -8.85658525e-03f,
  1.66163489e-01f, 1.99992001e-01f, -1.21235214e-01f, -2.80550122e-01f, -2.45589148e-02f, -8.44843313e-02f, 9.45680588e-02f, -1.35913894e-01f, 2.17607275e-01f, -3.21081653e-02f,
  4.46145721e-02f, 8.47476255e-03f, 2.32178327e-02f, 4.37371917e-02f, -3.95853966e-02f, 1.60857767e-01f, 1.50958390e-03f, 2.92612500e-02f, -2.03590274e-01f, -1.43622130e-01f,
  1.22691237e-03f, -1.42572355e-02f, 1.07986942e-01f, 2.51585077e-02f, 2.27400176e-02f, -1.19449876e-01f, -2.70439476e-01f, -1.69521533e-02f, -1.56778395e-01f, -2.53774762e-01f,
  -1.71358809e-01f, -8.59607011e-02f, 2.30758339e-02f, -1.41332641e-01f, 1.89679563e-01f, 2.06097350e-01f, 1.04308538e-02f, 1.14706717e-01f, 2.30895296e-01f, 2.61815526e-02f,
  -1.07444219e-01f, 2.44267762e-01f, 3.19705069e-01f, -1.75313056e-01f, 4.01295722e-02f, -5.71338311e-02f, -2.49904357e-02f, -3.47813606e-01f, 5.35440072e-02f, -3.30432534e-01f,
  -1.50921091e-01f, 2.34947890e-01f, 1.77303791e-01f, -1.08806320e-01f, -1.10663667e-01f, 1.00917995e-01f, 2.52446309e-02f, -7.74490684e-02f, 2.42351919e-01f, 5.35039790e-02f,
  1.01593152e-01f, -9.87130217e-03f, -1.97667107e-01f, 9.55763906e-02f, -3.79659235e-02f, -1.17955312e-01f, 6.67990278e-03f, -8.93459544e-02f, -4.11894545e-02f, -9.70866624e-03f,
  -1.57259881e-01f, -7.77114257e-02f, 1.02582190e-03f, 2.04417765e-01f, 1.83797285e-01f, 2.57777292e-02f, -7.76544735e-02f, 2.61672344e-02f, -1.10603653e-01f, 2.49907568e-01f,
  -9.40258130e-02f, -2.95022845e-01f, -3.01299930e-01f, -4.49606143e-02f, -5.73284626e-02f, 2.71142889e-02f, 2.51777563e-02f, -2.24217027e-02f, -5.39406668e-03f, -2.69673109e-01f,
  -1.28946185e-01f, 1.34007648e-01f, -5.50834574e-02f, -1.35705546e-01f, -4.26859334e-02f, -2.09339913e-02f, -7.30094127e-03f, -3.04010302e-01f, 1.91861227e-01f, 3.69593590e-01f,
  7.40959346e-02f, -7.93384537e-02f, 1.59396008e-01f, 7.75686875e-02f, -3.33565399e-02f, 2.64885992e-01f, 7.14310706e-02f, -1.01208881e-01f, 6.00299090e-02f, 1.62663683e-01f,
  -1.00091219e-01f, -2.27876008e-01f, 9.65124071e-02f, -1.74343899e-01f, -2.03164071e-01f, 7.81433955e-02f, 8.59877244e-02f, -1.44382179e-01f, 2.28667865e-03f, -1.66383564e-01f,
  -8.17888826e-02f, -7.21707195e-02f, 5.85268885e-02f, -6.40085936e-02f, 2.25541681e-01f, 1.26019269e-01f, -1.77045725e-02f, 6.22719936e-02f, -9.66578200e-02f, -1.14164278e-01f,
  1.32941410e-01f, 1.22046713e-02f, -2.88370252e-02f, 1.77835643e-01f, -1.64548829e-01f, 4.61407565e-03f, -5.36350422e-02f, 2.16991633e-01f, 1.96454123e-01f, -2.29762360e-01f,
  -2.21683025e-01f, -1.92896813e-01f, -6.01112135e-02f, 2.98341215e-02f, -2.39958301e-01f, -3.68121751e-02f, 8.33411142e-02f, 1.39608487e-01f, -9.50160548e-02f, -2.23534048e-01f,
  -2.53735930e-01f, 1.03647269e-01f, -3.08433939e-02f, -1.82824224e-01f, 1.80670694e-02f, 2.69292504e-01f, 1.08668499e-01f, 2.43609119e-02f, 1.44482404e-01f, -9.39364880e-02f,
  5.98875098e-02f, -2.28364944e-01f, -5.54329380e-02f, 2.96253175e-01f, -2.50468068e-02f, 5.85951172e-02f, 3.46098065e-01f, 2.81160716e-02f, -2.89614499e-01f, -1.28007337e-01f,
  3.81648317e-02f, -1.00592203e-01f, -9.90410373e-02f, 1.35387436e-01f, -2.51362145e-01f, -1.95077613e-01f, 1.08527720e-01f, -6.24554418e-02f, -1.11710005e-01f, -2.74901316e-02f,
  1.41766265e-01f, 2.50783145e-01f, -1.01853069e-02f, 8.24462399e-02f, -1.35444328e-01f, 1.83116511e-01f, 4.50502113e-02f, -9.71453711e-02f, 1.69337362e-01f, 2.42574960e-01f,
  -1.97150838e-03f, 1.13722302e-01f, -6.53870031e-02f, 1.47037745e-01f, 5.19141778e-02f, -1.09686479e-01f, -3.05576287e-02f, -6.95601255e-02f, 2.65976340e-01f, -1.66099926e-04f,
  5.83394468e-02f, -2.08331458e-02f, 2.43347988e-01f, 3.03358920e-02f, 1.07318699e-01f, -2.79044490e-02f, -7.59198368e-02f, -2.52367079e-01f, 6.17812872e-02f, 1.61425680e-01f,
  7.94193521e-02f, 3.90851386e-02f, 1.73049957e-01f, -3.40779461e-02f, -2.18982503e-01f, 9.79909301e-02f, 2.15567395e-01f, -8.54333397e-03f, 1.29745975e-01f, 4.81770858e-02f,
  -1.29249059e-02f, -4.35374416e-02f, 1.12317517e-01f, 2.66400352e-02f, 1.87925234e-01f, 7.20777502e-03f, -1.23510942e-01f, 2.46422719e-02f, 2.41830438e-01f, -9.79727358e-02f,
  -1.38080239e-01f, -2.73343343e-02f, 1.48452520e-01f, -3.30890030e-01f, 2.37094447e-01f, -1.76993441e-02f, 5.86399548e-02f, -2.27222770e-01f, 8.71462151e-02f, -5.84264379e-03f,
  2.99706638e-01f, 2.84973413e-01f, -3.80214080e-02f, 1.12448722e-01f, 1.87991112e-02f, 3.71541781e-03f, -9.08874199e-02f, -1.58976823e-01f, 3.40824798e-02f, -2.04939082e-01f,
  -1.29599804e-02f, -2.19704017e-01f, -5.32625429e-03f, 1.15672708e-01f, -7.02940375e-02f, -4.68606651e-02f, 3.57205570e-01f, 1.23083152e-01f, 8.27816948e-02f, -6.30510300e-02f,
  7.17201754e-02f, -7.74814636e-02f, 4.17255461e-02f, 2.40565836e-01f, -4.71644513e-02f, 7.21422583e-02f, -4.34355028e-02f, -4.18683365e-02f, -2.05128372e-01f, 7.06972405e-02f,
  5.79777546e-02f, -3.51543464e-02f, -1.08825147e-01f, 3.25515062e-01f, 1.94711566e-01f, 2.16495469e-01f, 1.81458622e-01f, 2.72340000e-01f, 8.77709240e-02f, 7.69536123e-02f,
  7.25983828e-02f, 2.00744912e-01f, 2.52933085e-01f, 2.03125611e-01f, -7.15509057e-02f, 2.74671540e-02f, 8.24137107e-02f, 1.49367079e-01f, 1.69951677e-01f, 6.53819591e-02f,
  5.46640903e-02f, -3.89044762e-01f, 1.18300430e-02f, 3.25687453e-02f, -1.86921015e-01f, 5.77514172e-02f, 8.96818787e-02f, -2.46627405e-01f, 8.90970156e-02f, -1.26084201e-02f,
  1.78655908e-01f, 3.09420582e-02f, -2.01962173e-01f, -9.70066860e-02f, -4.22368273e-02f, 9.21541452e-02f, 2.70836949e-01f, 3.22956145e-02f, 2.08825290e-01f, -3.83726992e-02f,
  -1.28115326e-01f, -2.45808586e-01f, 1.64928854e-01f, -6.93689957e-02f, 5.93974181e-02f, -1.73578858e-01f, -1.99032679e-01f, 1.53541565e-01f, -1.31350026e-01f, -3.47161405e-02f,
  2.41152614e-01f, 9.36696902e-02f, 8.44364092e-02f, -7.20782951e-02f, -6.97652549e-02f, -1.62904352e-01f, 5.37379943e-02f, -6.76680505e-02f, 2.38150060e-01f, -8.09387490e-02f,
  -5.14489003e-02f, -2.04821244e-01f, -6.18458763e-02f, 1.00229688e-01f, -1.33972213e-01f, 1.69935077e-01f, 8.63050595e-02f, -9.65463445e-02f, -2.14481950e-01f, 3.17777991e-02f,
  4.57527116e-03f, -8.08233395e-02f, -8.66739973e-02f, 3.35730612e-02f, 1.58725102e-02f, 1.80713341e-01f, -4.51703481e-02f, 2.38305435e-01f, -1.27320901e-01f, 2.71710664e-01f,
  9.76127833e-02f, -1.34561397e-02f, 6.43311962e-02f, -9.50257629e-02f, 3.78373861e-02f, 1.98073834e-01f, 3.49865824e-01f, -2.39398092e-01f, 6.66764602e-02f, -2.12443769e-01f,
  7.97320455e-02f, 5.96105829e-02f, 1.46584094e-01f, 1.13253690e-01f, 1.72100842e-01f, 1.58609793e-01f, 2.04802286e-02f, -5.46681648e-03f, 7.75784478e-02f, 5.69283031e-02f,
  1.53831393e-01f, 2.90463626e-01f, -1.33033246e-01f, -1.19075686e-01f, -3.66271921e-02f, -1.97763041e-01f, -6.16016574e-02f, 2.45476468e-03f, 3.38652432e-02f, -3.38785490e-03f,
  2.15219080e-01f, -2.79601719e-02f, -1.20249420e-01f, 1.39548346e-01f, 8.20843801e-02f, -1.52977005e-01f, -4.53541009e-03f, -9.66813862e-02f, -9.10021365e-02f, 1.20721877e-01f,
  -1.73371673e-01f, 1.21875092e-01f, -1.46714702e-01f, 2.68339425e-01f, 2.25844204e-01f, -9.82799679e-02f, -2.54583538e-01f, -1.31088600e-01f, 2.17972826e-02f, -1.20968353e-02f,
  -1.49129674e-01f, 9.73897874e-02f, -1.46288425e-01f, 2.05581635e-01f, 6.69621164e-03f, 1.14830591e-01f, -2.76920170e-01f, -4.17976379e-02f, -1.91495910e-01f, 6.98279515e-02f,
  -8.26084688e-02f, 1.83501035e-01f, 2.03729793e-01f, -3.70214810e-03f, -9.73174125e-02f, -1.06112599e-01f, 2.46839494e-01f, -2.68060654e-01f, -9.66771394e-02f, 3.50091338e-01f,
  8.15159008e-02f, -2.30445579e-01f, 6.51313504e-03f, -3.75156812e-02f, 4.07036580e-03f, -1.38342798e-01f, 1.46024331e-01f, 6.08331971e-02f, 2.11362571e-01f, 4.31522503e-02f,
  -2.18573332e-01f, -2.21028998e-01f, 1.92105189e-01f, -8.51361360e-03f, -4.36929129e-02f, -1.17293056e-02f, -1.20980524e-01f, 2.23246530e-01f, 8.80445987e-02f, -6.37449995e-02f,
  -1.08130723e-01f, 1.17508024e-02f, -1.77328408e-01f, -2.76948023e-03f, 1.80830419e-01f, 7.68447369e-02f, -1.68855444e-01f, 1.05459042e-01f, -1.26708567e-01f, -9.92909372e-02f,
  -1.92191228e-02f, -1.12366654e-01f, 7.04936087e-02f, -1.53874204e-01f, 3.18769515e-01f, -8.55684802e-02f, 6.22230433e-02f, -9.23769921e-02f, 2.09006384e-01f, -1.50490105e-01f,
  1.41970236e-02f, -4.32345085e-02f, -3.35881971e-02f, 7.70310462e-02f, 1.64921820e-01f, -2.55293280e-01f, 1.81301817e-01f, 5.72368577e-02f, 8.25220048e-02f, -2.18962133e-01f,
  1.51975024e-02f, -1.31710591e-02f, -2.96473116e-01f, -1.08998209e-01f, -1.55128509e-01f, -1.25460848e-01f, -3.83791476e-02f, 1.82080731e-01f, -1.38802469e-01f, -1.17538534e-01f,
  -2.32274801e-01f, 1.37470514e-01f, -1.95842400e-01f, -2.86915869e-01f, -9.82415676e-02f, -2.26658627e-01f, 2.43754294e-02f, -7.68138766e-02f, -1.91774115e-01f, 5.28791063e-02f,
  -3.16469334e-02f, -2.79054105e-01f, -4.20318879e-02f, 1.14130817e-01f, 9.29523781e-02f, 1.70094982e-01f, -4.98004481e-02f, 8.25593621e-02f, -2.71848023e-01f, -1.44331306e-01f,
  -9.87860113e-02f, -9.83775780e-02f, 9.69652906e-02f, -8.95035714e-02f, -1.41918749e-01f, -1.80165112e-01f, -3.45640838e-01f, -4.69962768e-02f, -7.43187964e-02f, -5.80336601e-02f,
  8.03333521e-02f, 1.33397475e-01f, -1.88615352e-01f, -4.18800041e-02f, 2.90560629e-02f, 2.44319811e-01f, 1.07635230e-01f, 2.10733131e-01f, -1.69353843e-01f, 1.55192986e-01f,
  -1.22072704e-01f, -4.30130325e-02f, -5.61257154e-02f, 7.35536888e-02f, 1.00829542e-01f, 1.93059862e-01f, 1.18967988e-01f, -5.90644032e-02f, 1.34395212e-01f, -1.39322847e-01f,
  -5.83008640e-02f, -2.44880632e-01f, -1.62109256e-01f, 1.04261167e-01f, -3.04242782e-02f, 6.90294132e-02f, 1.61344916e-01f, -2.79985368e-03f, -1.80015519e-01f, -1.45808030e-02f,
  -1.60720721e-01f, -7.02071413e-02f, -2.21192732e-01f, -3.61198969e-02f, -2.04347178e-01f, 1.69601381e-01f, 8.41543302e-02f, -1.29441544e-01f, 6.95686862e-02f, 1.38409242e-01f,
  -1.67444989e-01f, 8.92608389e-02f, 1.63501352e-01f, 1.65129066e-01f, 4.98499162e-02f, 1.11357525e-01f, -1.86249301e-01f, -1.37412950e-01f, 2.69507200e-01f, -9.37643647e-02f,
  -9.52916667e-02f, -8.39165673e-02f, -4.58626561e-02f, -4.64946032e-02f, 3.71219218e-02f, -2.49606460e-01f, -8.63721743e-02f, -4.77055982e-02f, 2.56559830e-02f, -1.36594117e-01f,
  1.62701160e-01f, -7.16609731e-02f, -1.29373550e-01f, 1.32582814e-01f, 1.25854656e-01f, -7.71366134e-02f, -5.49205840e-02f, -5.74859977e-02f, -1.89452738e-01f, 1.25228390e-01f,
  1.26733705e-02f, 1.03176594e-01f, -2.81597942e-01f, -7.61444569e-02f, -2.37285420e-01f, 9.09086466e-02f, -6.01668358e-02f, -4.68722656e-02f, 1.33115008e-01f, -9.33961645e-02f,
  -7.49134086e-03f, 2.69730330e-01f, 2.85518877e-02f, 1.29167482e-01f, -2.45154873e-01f, 7.83231556e-02f, 1.42837882e-01f, 7.64948130e-02f, 1.54713988e-01f, 1.20235547e-01f,
  1.17793456e-01f, 1.26007855e-01f, 1.92630753e-01f, 1.47261754e-01f, 1.53703287e-01f, -1.27632111e-01f, -1.81439683e-01f, 8.40679556e-02f, -2.09161937e-02f, 1.16275279e-02f,
  -2.70644993e-01f, 4.81017940e-02f, 2.32045740e-01f, 2.21653394e-02f, -1.36459008e-01f, -7.95994326e-02f, 7.24445805e-02f, 6.53938577e-02f, 2.14470282e-01f, 5.02800383e-02f,
  -1.38739869e-01f, -1.11883201e-01f, 8.01930726e-02f, -2.65491515e-01f, -5.19901887e-02f, -1.07160442e-01f, 2.62528937e-02f, 1.31877542e-01f, -1.61700591e-01f, -1.43795505e-01f,
  5.00185899e-02f, -3.96843329e-02f, 1.45235762e-01f, 5.49650453e-02f, 2.25859463e-01f, -7.03616366e-02f, 7.70907179e-02f, -6.63333237e-02f, -4.84060086e-02f, -1.57155752e-01f,
  6.44521713e-02f, -1.44729018e-01f, 2.56183892e-01f, -3.97643745e-02f, -8.64161626e-02f, 7.16712698e-03f, -1.21614657e-01f, 2.03237608e-01f, 1.15024976e-01f, 1.89724296e-01f,
  2.05547344e-02f, -1.37115866e-01f, -2.92071730e-01f, 7.90228248e-02f, 7.68996105e-02f, -1.20549731e-01f, -6.75431788e-02f, -7.54491193e-03f, -2.25418061e-01f, 1.24090537e-01f,
  -5.06376773e-02f, -1.11972719e-01f, -7.38216890e-03f, -2.38503903e-01f, -1.72391072e-01f, -2.83396896e-02f, 1.97503846e-02f, 1.64262667e-01f, 2.22998247e-01f, -3.85016017e-02f,
  -1.74522012e-01f, -1.14885993e-01f, 5.75613342e-02f, -5.54744042e-02f, -1.77234471e-01f, 2.05394015e-01f, 2.67624348e-01f, -2.46449947e-01f, 9.55281109e-02f, 9.23436508e-02f,
  -1.84719548e-01f, -1.25152662e-01f, 1.51323274e-01f, 5.86176254e-02f, 9.31041241e-02f, 1.11520588e-01f, -2.53157049e-01f, -8.95468667e-02f, -2.26943549e-02f, -2.14775935e-01f,
  -2.69825011e-01f, -5.18069118e-02f, -2.28785008e-01f, 6.48198873e-02f, -3.74931679e-03f, 7.80188292e-02f, -1.11945786e-01f, -8.53731856e-02f, -6.67601600e-02f, -3.76451947e-02f,
  2.73452461e-01f, -2.02092439e-01f, -2.43167356e-01f, 1.00841761e-01f, -1.89975411e-01f, -2.32151151e-02f, -1.07653864e-01f, -6.09783381e-02f, -7.91031048e-02f, -1.06097922e-01f,
  -5.06979562e-02f, 4.91506159e-02f, -2.39833724e-03f, -2.18697246e-02f, 4.65221554e-02f, 1.04721151e-01f, -4.91581447e-02f, 9.28502232e-02f, -1.32000446e-01f, -5.84617145e-02f,
  -2.54735164e-02f, 9.39085484e-02f, 1.82128325e-01f, 2.16341093e-01f, 7.82549083e-02f, 1.35976300e-02f, -8.10903907e-02f, -4.82630804e-02f, 4.66757752e-02f, -1.92138746e-01f,
  5.36202341e-02f, 5.34543321e-02f, -4.94713709e-02f, -9.68913808e-02f, 2.04160854e-01f, 5.38737811e-02f, 8.77860114e-02f, -8.30510929e-02f, -1.40084907e-01f, -1.00113936e-01f,
  6.77581802e-02f, -7.41295815e-02f, -1.81016997e-01f, -1.93892103e-02f, -9.31458082e-03f, -2.11982623e-01f, 1.47283405e-01f, 1.02840953e-01f, 1.05373964e-01f, -1.92655902e-02f,
  -5.72927594e-02f, 7.35664368e-02f, 1.43967822e-01f, 1.49990618e-01f, -7.62779638e-02f, 1.71474777e-02f, 1.25028551e-01f, -1.07508600e-01f, 2.78867912e-02f, -2.02900052e-01f,
  -1.37141213e-01f, -1.21893652e-01f, -1.16617084e-02f, -1.34650573e-01f, -6.58509582e-02f, 1.64952800e-01f, 4.12986614e-02f, 4.04409170e-02f, 2.13914469e-01f, 8.07407051e-02f,
  -1.39668658e-01f, -4.87035029e-02f, -2.07984030e-01f, -1.54614344e-01f, 3.95469321e-03f, 1.18645430e-01f, -1.57786086e-01f, 7.61617795e-02f, -1.63874358e-01f, 6.41501769e-02f,
  -6.74227327e-02f, -5.11897020e-02f, 4.76919971e-02f, -3.10178678e-02f, -2.49013782e-01f, 1.87359750e-01f, -4.47862111e-02f, -9.38015282e-02f, -1.21571012e-01f, 3.83622348e-02f,
  -5.19099087e-02f, -9.74800158e-03f, 7.80622810e-02f, 4.74137329e-02f, -1.11040756e-01f, 9.69059616e-02f, -8.69890153e-02f, -4.25721034e-02f, 8.55269190e-03f, -2.65212208e-02f,
  2.87633687e-01f, -4.59658913e-03f, 3.09537321e-01f, -1.78565662e-02f, -3.47314514e-02f, 1.02440588e-01f, -4.89720106e-02f, -5.84884398e-02f, 1.87583953e-01f, 9.49095562e-02f,
  1.79961726e-01f, 2.66803116e-01f, 1.99546777e-02f, 7.38269091e-02f, 1.86976597e-01f, -1.05988264e-01f, -1.16902865e-01f, -2.65187800e-01f, -1.65275723e-01f, -1.62753910e-02f,
  6.95497766e-02f, -1.75962850e-01f, -3.06168109e-01f, -9.25184116e-02f, -3.58882323e-02f, 1.35128200e-01f, 1.32317618e-01f, -1.13418192e-01f, -1.08557045e-01f, 8.56382400e-02f,
  3.53232175e-02f, -9.84269828e-02f, 8.06351900e-02f, -9.67472326e-03f, -1.29183158e-01f, 8.45076591e-02f, -2.06812099e-01f, 1.59744639e-02f, -2.04917192e-01f, -2.36940458e-01f,
  3.52270268e-02f, 7.89289027e-02f, 1.24071799e-02f, -8.19655284e-02f, -1.28703654e-01f, -1.81453958e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -4.21172455e-02f, 6.45708218e-02f, -6.62838593e-02f, 3.90711911e-02f, 1.08647473e-01f, -1.60554245e-01f, 8.11667368e-02f, 1.14287831e-01f, 1.14718586e-01f, 3.57884467e-02f,
  -1.64457545e-01f, -2.10034847e-01f, 1.98810250e-02f, 1.78262055e-01f, -3.20116505e-02f, 8.59755948e-02f, 1.66303422e-02f, 5.64140119e-02f, -8.63007531e-02f, -4.08675633e-02f,
  -3.74617577e-02f, 2.54580528e-01f, -1.86902717e-01f, 1.47832319e-01f, 3.38395506e-01f, 2.37960309e-01f, -2.65051872e-01f, 2.73240767e-02f, 3.33873034e-02f, -2.33273327e-01f,
  2.30985165e-01f, -1.13168597e-01f, -1.93166286e-01f, -3.44619602e-02f, 1.43690765e-01f, -1.57273084e-01f, -9.45708528e-02f, -2.04913616e-02f, 5.02119996e-02f, 1.41528219e-01f,
  -1.24929510e-02f, -1.35110885e-01f, -1.43460020e-01f, 4.81353998e-02f, -3.08873393e-02f, 7.79665485e-02f, 5.26265763e-02f, -7.45201260e-02f, -2.79830583e-05f, 1.74334824e-01f,
  4.28441651e-02f, 7.25607425e-02f, -4.78543155e-02f, 8.41375291e-02f, 1.07208110e-01f, -1.00177051e-02f, 2.01501265e-01f, 1.86762989e-01f, 1.14940144e-01f, -6.61857352e-02f,
  -1.50837496e-01f, -6.58241063e-02f, 2.25979328e-01f, -1.56102525e-02f, -5.38671985e-02f, -1.32604674e-01f, -4.00710963e-02f, -4.59296405e-02f, 6.70893192e-02f, 1.19207904e-01f,
  1.74751312e-01f, 2.91465446e-02f, 1.12674601e-01f, 5.54844663e-02f, -7.12625831e-02f, 9.74161178e-02f, 5.30609563e-02f, -2.40037367e-01f, 1.15374133e-01f, 1.37311175e-01f,
  1.39945239e-01f, 1.27118468e-01f, -2.72959739e-01f, 4.01717834e-02f, -4.55788404e-01f, -2.89983422e-01f, 3.50380003e-01f, -2.55168468e-01f, -1.77116528e-01f, -2.03054801e-01f,
  2.99679190e-01f, 5.45186875e-03f, -7.01486366e-03f, 2.39572278e-03f, 7.44861662e-02f, -3.18483055e-01f, -3.57041024e-02f, 2.89671302e-01f, -1.50818303e-02f, 4.18628603e-01f,
  1.68911710e-01f, 6.45510107e-02f, -9.34742913e-02f, -2.92213466e-02f, 4.05822933e-01f, 1.93455890e-01f, 3.16985190e-01f, 3.20680887e-02f, -2.50440776e-01f, -5.67335226e-02f,
  -5.99050894e-02f, 5.25345607e-03f, -2.76528602e-03f, 1.15186483e-01f, 1.31577909e-01f, -2.10964233e-02f, 2.60357201e-01f, -6.06191643e-02f, 1.67176843e-01f, 3.81347574e-02f,
  1.76474191e-02f, 3.41301113e-01f, -1.67164385e-01f, 3.09279300e-02f, 1.28007960e-02f, 3.44964117e-01f, -6.03368282e-02f, 2.00003758e-01f, 1.24574810e-01f, -4.73809913e-02f,
  1.69512302e-01f, -3.07039302e-02f, 1.62894934e-01f, -7.85856098e-02f, -1.83104444e-02f, 3.85285877e-02f, 4.19357568e-02f, -4.65418920e-02f, 5.44775091e-02f, 3.14046055e-01f,
  2.48864591e-01f, 7.54041970e-02f, 1.15655906e-01f, 5.46456464e-02f, 8.54307562e-02f, -1.21244699e-01f, -1.15086094e-01f, 2.47431219e-01f, -2.09643655e-02f, -1.40722662e-01f,
  1.21982008e-01f, 8.24022889e-02f, -3.47347617e-01f, 4.06098217e-02f, -2.94442810e-02f, -1.21681824e-01f, -2.96547771e-01f, 1.07492290e-01f, -1.22580469e-01f, 1.42605864e-02f,
  4.57340032e-01f, 2.76926249e-01f, -3.42613399e-01f, 2.37391293e-01f, 1.35358293e-02f, -4.82229218e-02f, -2.30983701e-02f, -6.79436997e-02f, 8.06053206e-02f, 9.96737555e-02f,
  1.92984670e-01f, 7.93643817e-02f, 1.82907373e-01f, 1.50631502e-01f, -1.14305079e-01f, -1.43441215e-01f, 1.37514815e-01f, -7.71699771e-02f, -1.15377001e-01f, -1.12913407e-01f,
  1.05630107e-01f, 2.93395221e-01f, 2.12660357e-01f, 3.74188125e-01f, -5.29927900e-04f, -4.27761674e-02f, -1.05070151e-01f, -9.16807577e-02f, -1.22566232e-02f, 6.76747737e-03f,
  -2.92592756e-02f, 3.31361406e-02f, -8.51213485e-02f, 1.29822776e-01f, -1.02037519e-01f, 2.99757123e-01f, 5.72675243e-02f, 3.14256817e-01f, 1.07068352e-01f, 9.81343612e-02f,
  2.05714013e-02f, 3.53150666e-01f, 2.67149746e-01f, -6.15549795e-02f, 3.71834785e-02f, 7.16969073e-02f, 1.28126144e-01f, -1.56378895e-02f, 8.42122734e-02f, 1.38295367e-01f,
  2.23460555e-01f, -8.09975564e-02f, 1.79696139e-02f, 1.83823228e-01f, 4.62374873e-02f, -2.36428574e-01f, 1.52278662e-01f, 1.07576914e-01f, -1.44555464e-01f, -8.53631422e-02f,
  3.14214140e-01f, 1.19134612e-01f, 5.40133938e-02f, -5.80658503e-02f, -1.99090570e-01f, -3.71423781e-01f, 1.98043332e-01f, 1.54853910e-01f, 2.12764796e-02f, 3.01783770e-01f,
  1.26714453e-01f, 2.26622477e-01f, 1.91863209e-01f, -1.80672020e-01f, 2.63580412e-01f, -8.11514556e-02f, 3.92937008e-03f, -1.56672597e-01f, -1.05110509e-02f, 2.00134069e-01f,
  -1.30920708e-01f, 1.15346067e-01f, 2.56918937e-01f, 2.86106896e-02f, 1.82487100e-01f, 6.19812608e-02f, -3.11868247e-02f, -4.18941915e-01f, -8.54176357e-02f, 2.59147912e-01f,
  1.92791969e-01f, 9.03829932e-02f, -6.89266101e-02f, 4.10003439e-02f, -4.33248021e-02f, 2.33935997e-01f, 2.22802721e-02f, 8.31824094e-02f, 1.16951644e-01f, -3.81972432e-01f,
  4.46390696e-02f, -2.69137949e-01f, -1.86747909e-01f, -4.76854324e-01f, 3.16801578e-01f, -7.77399242e-02f, -4.48798984e-01f, -1.70926020e-01f, -3.16040516e-01f, -6.05657876e-01f,
  1.49221137e-01f, 1.44185200e-01f, -2.30854198e-01f, -1.74183518e-01f, -1.38873756e-01f, 6.94614276e-02f, 6.01357839e-04f, 5.34423962e-02f, 9.37031433e-02f, 3.05857688e-01f,
  2.21799076e-01f, -1.36616573e-01f, -1.09596848e-01f, 2.03610942e-01f, 5.79136377e-03f, 7.34513402e-02f, -3.73958759e-02f, 1.93233863e-01f, -7.21233571e-03f, -1.32659197e-01f,
  -6.99132606e-02f, -1.63518831e-01f, -2.71795928e-01f, -3.94767910e-01f, -1.42713726e-01f, 4.25132290e-02f, -7.90466443e-02f, 1.32991791e-01f, -1.61621630e-01f, 1.10921212e-01f,
  -9.59158689e-02f, 1.29799500e-01f, 8.00673757e-03f, -1.30323812e-01f, -9.20345411e-02f, 8.88909474e-02f, -2.74891973e-01f, 8.37066993e-02f, -1.42260730e-01f, 1.26192942e-01f,
  1.51289210e-01f, 1.42394722e-01f, -2.23848093e-02f, 1.41387284e-01f, -1.81906894e-02f, -1.97934002e-01f, 1.72845289e-01f, 1.44329071e-01f, 1.21331871e-01f, 1.46480963e-01f,
  1.60052627e-01f, 1.39778972e-01f, 2.73156464e-01f, 1.67642683e-01f, 1.03474334e-01f, 2.02133298e-01f, 1.17238224e-01f, -9.87892896e-02f, 1.87770635e-01f, 8.31258148e-02f,
  6.09989055e-02f, 4.13343370e-01f, 1.47014305e-01f, 6.04473539e-02f, 2.66431332e-01f, 2.03586012e-01f, 5.87932803e-02f, 8.22790414e-02f, 5.91922691e-03f, 9.44166631e-02f,
  -8.77153501e-02f, -1.55385375e-01f, 2.30354488e-01f, 3.52982618e-02f, -3.96617502e-01f, -2.48541012e-01f, 1.44730449e-01f, -1.66790970e-02f, 3.24489288e-02f, 2.42525041e-01f,
  9.12030861e-02f, 1.05522655e-01f, 2.35248551e-01f, 1.27346143e-02f, -7.83051085e-03f, 3.37532192e-01f, 3.99282612e-02f, -4.60978076e-02f, 2.22067609e-02f, 6.18452206e-02f,
  6.17986098e-02f, -4.42730673e-02f, 2.00475857e-01f, -1.78952187e-01f, 1.56508267e-01f, 6.34842440e-02f, -1.01216726e-01f, 1.06473893e-01f, 7.46661499e-02f, -5.56088053e-02f,
  1.88973621e-01f, 1.84569452e-02f, 1.25698492e-01f, 8.61699656e-02f, -2.78844666e-02f, -9.65158790e-02f, -2.04098746e-01f, 2.91026145e-01f, -8.74888431e-03f, 8.98731649e-02f,
  -1.59326196e-01f, 2.31057391e-01f, -4.06908281e-02f, 1.96359202e-01f, 1.55668348e-01f, 2.35557199e-01f, 1.32615119e-01f, 1.66294083e-01f, 1.61025047e-01f, -1.21220097e-01f,
  2.73390383e-01f, 1.60035402e-01f, 2.64851034e-01f, -1.46052599e-01f, 1.89082608e-01f, 3.07789892e-01f, 1.16788715e-01f, 1.98793501e-01f, 7.36392587e-02f, -7.58439824e-02f,
  -4.64040861e-02f, -2.09662709e-02f, -7.80180767e-02f, 3.90123457e-01f, -3.64618748e-01f, -2.77260303e-01f, -2.32937783e-01f, 3.49729359e-01f, -1.61962077e-01f, 7.53533542e-02f,
  1.63117215e-01f, -4.70218342e-03f, -2.65758276e-01f, 1.54096829e-02f, -1.47176132e-01f, 9.24924612e-02f, -1.43912464e-01f, 8.00851658e-02f, -4.71607506e-01f, -2.60436356e-01f,
  -2.73696007e-03f, -2.55864352e-01f, -1.83816805e-01f, 3.85695659e-02f, -6.95759133e-02f, 1.87763706e-01f, -1.39551580e-01f, 2.41091833e-01f, -5.25015034e-02f, 2.05042899e-01f,
  -3.68428268e-02f, -4.34981138e-01f, 1.19787790e-01f, -2.80665495e-02f, 1.19018793e-01f, 1.68743521e-01f, -2.14284495e-01f, -2.01881126e-01f, 2.56269332e-02f, 2.33384535e-01f,
  -9.52592492e-02f, -1.84813321e-01f, 3.68527293e-01f, -1.04687534e-01f, -3.03685069e-01f, -4.80460711e-02f, 1.07839651e-01f, 2.18797073e-01f, -1.18312284e-01f, 2.25581035e-01f,
  9.18755233e-02f, 6.05187118e-02f, -2.31570080e-01f, 4.75139357e-02f, -3.11939836e-01f, 4.17421073e-01f, -1.89732194e-01f, 1.89444944e-01f, 2.89117128e-01f, 2.53486812e-01f,
  1.22883692e-01f, -4.09677140e-02f, 7.34401271e-02f, -7.35085532e-02f, -1.75391227e-01f, -1.42938331e-01f, -3.82321030e-02f, 2.51152385e-02f, 1.37458414e-01f, 5.34045584e-02f,
  5.54948635e-02f, 4.61246185e-02f, 3.05624562e-03f, 1.41636848e-01f, -1.19693153e-01f, 3.13057959e-01f, 1.29172262e-02f, 2.69955676e-03f, -2.27900267e-01f, 2.22520351e-01f,
  3.55369747e-01f, -1.49533048e-01f, -3.84406686e-01f, -8.92958641e-02f, 1.16823278e-02f, -3.59754749e-02f, -1.34139314e-01f, -1.26625866e-01f, 3.25844824e-01f, 1.75859243e-01f,
  1.46581292e-01f, 2.67627776e-01f, 2.71157622e-01f, 1.29274458e-01f, 2.08531454e-01f, -2.59098053e-01f, 5.94031438e-02f, -3.64405550e-02f, -1.56189978e-01f, 1.66882008e-01f,
  9.26701427e-02f, 2.10043743e-01f, 1.85347706e-01f, -3.33511904e-02f, -8.84680450e-02f, -1.84496567e-01f, 2.33898684e-02f, -1.72336064e-02f, 9.05321073e-03f, -3.84362072e-01f,
  -9.72457454e-02f, 1.41273916e-01f, 1.19125903e-01f, -2.40821078e-01f, 3.64252031e-02f, 3.37679774e-01f, 3.17945749e-01f, 1.54011622e-01f, -7.51575232e-02f, -2.32701991e-02f,
  1.40105039e-01f, 3.17236483e-02f, -7.89028313e-03f, -9.79401767e-02f, -1.37812253e-02f, 1.75206736e-01f, -2.38056600e-01f, -1.56172728e-02f, 2.26119205e-01f, 1.36604784e-02f,
  3.02448153e-01f, -1.89241663e-01f, 1.09716862e-01f, 1.21992543e-01f, -1.73222512e-01f, -5.74586273e-04f, 1.31620884e-01f, 1.95396826e-01f, -1.35485917e-01f, -1.16164535e-01f,
  1.30879000e-01f, 4.89476025e-02f, 2.28193149e-01f, 1.80906802e-02f, -6.57780170e-02f, 3.65262069e-02f, 3.00436646e-01f, -2.88942493e-02f, 1.78951964e-01f, 1.06111340e-01f,
  2.54714221e-01f, -1.99782491e-01f, -4.11316335e-01f, 2.82113142e-02f, 1.16195753e-01f, -2.13767946e-01f, 1.00853235e-01f, 6.53999597e-02f, -5.84845208e-02f, 3.28216404e-01f,
  6.17300831e-02f, -6.90375045e-02f, 3.77018228e-02f, 7.93626159e-02f, -1.31886154e-01f, 8.97943974e-02f, -2.03865826e-01f, -2.43939027e-01f, 2.85845459e-01f, -3.03620160e-01f,
  1.77453175e-01f, 1.78787977e-01f, -5.84321618e-02f, 3.39002609e-02f, 6.62527829e-02f, -9.61721465e-02f, 6.41322583e-02f, -6.51302487e-02f, 1.07380658e-01f, 4.50693555e-02f,
  -9.45873335e-02f, 4.42089587e-02f, 8.01272392e-02f, 9.13052708e-02f, -3.93205024e-02f, 9.89052802e-02f, 2.02508625e-02f, 3.77751626e-02f, 3.71722542e-02f, -7.08671287e-02f,
  -9.79942232e-02f, -1.18345790e-01f, 7.62804747e-02f, -5.37469834e-02f, -3.57245170e-02f, 2.18848437e-02f, -1.27771506e-02f, -4.66993004e-02f, 4.18241061e-02f, -9.66426730e-02f,
  1.00550845e-01f, 8.38189721e-02f, -1.54922111e-02f, 6.12532943e-02f, 8.08413252e-02f, 7.30861677e-03f, -3.31541747e-02f, 1.06409676e-01f, 2.19306108e-02f, 2.09553838e-02f,
  9.67954099e-02f, 6.61569014e-02f, -9.42662060e-02f, -3.41447704e-02f, -1.11482143e-01f, -1.10162422e-01f, -6.43221289e-02f, -3.56803685e-02f, -1.09698258e-01f, -1.38575390e-01f,
  -1.49333879e-01f, 6.37471452e-02f, -7.22906366e-02f, -1.20227173e-01f, -4.34649251e-02f, -1.29758671e-01f, -8.89974739e-03f, -3.39753716e-03f, 3.10243983e-02f, -2.52703074e-02f,
  5.87377138e-02f, -1.11728646e-01f, 7.96811208e-02f, -1.06573321e-01f, -8.05079646e-04f, -4.90212142e-02f, 1.14776995e-02f, 1.12318486e-01f, 3.66834141e-02f, 4.81593162e-02f,
  2.16942534e-01f, -3.22771259e-02f, 1.37394488e-01f, 2.97272205e-02f, -2.84420792e-02f, 5.94689734e-02f, -4.81303334e-02f, -6.59118593e-02f, 2.13503055e-02f, -3.75377983e-02f,
  -3.38129923e-02f, 1.14107117e-01f, 4.61382270e-02f, -1.03183970e-01f, 7.85377845e-02f, 2.89817333e-01f, 8.51910934e-02f, 1.82802230e-01f, -8.71396973e-04f, 8.12443346e-02f,
  -3.09546024e-01f, 3.80704403e-02f, -1.40966207e-01f, 9.42048877e-02f, 8.51684362e-02f, 4.23193350e-02f, -1.94385156e-01f, -1.14777684e-01f, -6.48909137e-02f, 2.16330305e-01f,
  3.02160680e-01f, 2.19841033e-01f, -2.56073892e-01f, 5.88289239e-02f, -2.04743594e-01f, 7.51207843e-02f, -2.63296515e-02f, -7.92784840e-02f, -6.88035833e-03f, 2.23060012e-01f,
  -1.54893607e-01f, -7.16741383e-02f, -4.28116173e-02f, 7.00600967e-02f, -1.89723328e-01f, 5.82174212e-03f, -3.13715376e-02f, 1.91269703e-02f, -5.44950515e-02f, 8.20704177e-02f,
  3.16203921e-03f, 1.96223691e-01f, -2.35616609e-01f, -2.54027963e-01f, 1.65189534e-01f, 8.38117823e-02f, 3.15373331e-01f, -1.31260723e-01f, 2.39364475e-01f, -4.42025632e-01f,
  -8.63798484e-02f, 1.79966807e-01f, 3.22324991e-01f, 1.64227441e-01f, -2.97977835e-01f, 6.31611347e-02f, -4.37163025e-01f, -1.45755410e-01f, -2.34940872e-01f, -1.03478387e-01f,
  2.95039713e-01f, -1.57396793e-01f, 8.43339637e-02f, 1.07582413e-01f, 8.01204145e-02f, -2.27063134e-01f, -7.55953044e-02f, -3.47610056e-01f, 3.01512685e-02f, -3.61889631e-01f,
  3.37064087e-01f, -1.38051063e-01f, -5.11156488e-03f, 1.27550259e-01f, -3.48493129e-01f, 1.28829554e-01f, -1.63029477e-01f, -6.96220770e-02f, -2.52356976e-01f, 8.03158358e-02f,
  -5.99844716e-02f, 2.02866912e-01f, 1.89941049e-01f, 1.71412472e-02f, -1.11972593e-01f, -3.25744659e-01f, 4.16039266e-02f, -2.39075556e-01f, 3.14394385e-02f, 5.89047745e-02f,
  -6.58508241e-02f, 2.15349212e-01f, -1.22743703e-01f, -3.94231116e-04f, 1.23717092e-01f, -2.07668290e-01f, -7.89635628e-02f, -1.02035619e-01f, -1.17625691e-01f, 1.70962699e-02f,
  6.09336346e-02f, -2.83052120e-02f, 4.01208736e-02f, 1.45083725e-01f, 1.01912573e-01f, -9.73950848e-02f, 1.67741343e-01f, 2.93299109e-01f, 5.93764707e-02f, -4.66026694e-01f,
  2.37479731e-02f, 2.26144671e-01f, -1.29350916e-01f, 2.06448331e-01f, -2.45722771e-01f, -4.59902622e-02f, -4.25060064e-01f, 8.79920125e-02f, 1.95288271e-01f, 6.38784245e-02f,
  4.15181607e-01f, 5.85829429e-02f, 2.31966943e-01f, -9.50659439e-02f, 2.74845243e-01f, 1.08599268e-01f, 1.75849631e-01f, -1.70528367e-01f, 1.30818570e-02f, 1.33615628e-01f,
  7.66180158e-02f, -4.75419089e-02f, 1.11672133e-01f, 2.56220639e-01f, 4.80120406e-02f, 2.18239382e-01f, -1.25119939e-01f, 2.30662823e-01f, 4.08401266e-02f, -4.86161351e-01f,
  -7.92627186e-02f, 2.88149923e-01f, -2.36872137e-01f, 6.00413494e-02f, 2.79065639e-01f, -4.29725796e-02f, -4.31432515e-01f, -1.16713129e-01f, 6.37108739e-03f, -1.26695661e-02f,
  -1.14719264e-01f, 4.71188068e-01f, -2.72761822e-01f, 3.06149006e-01f, 9.07472894e-02f, -2.35380903e-01f, 9.57545638e-02f, 4.94252406e-02f, -4.06500101e-02f, 9.91532654e-02f,
  -3.86596583e-02f, -1.54606849e-01f, 3.18679921e-02f, 1.02127269e-01f, -2.30599239e-01f, -2.12991089e-01f, 3.00825059e-01f, -2.06308141e-02f, 5.88503517e-02f, 8.80672708e-02f,
  -4.89108637e-02f, 1.67913854e-01f, 1.00352630e-01f, 3.13842863e-01f, -1.73171401e-01f, -1.42676324e-01f, -7.59819150e-02f, 1.87450405e-02f, -2.41184339e-01f, 3.08620214e-01f,
  1.99080825e-01f, 2.51230240e-01f, -2.82989740e-01f, 1.09014690e-01f, 1.60810784e-01f, -8.09548274e-02f, -2.69694328e-01f, 2.47578248e-01f, 5.31782135e-02f, -2.47795247e-02f,
  -8.33755452e-03f, 3.81129563e-01f, 8.96500610e-03f, 3.66378538e-02f, 8.70839804e-02f, -2.51165986e-01f, 2.44730517e-01f, 8.32339823e-02f, -1.64082751e-01f, -4.12154496e-02f,
  -1.80207580e-01f, 2.68661324e-02f, -2.01880470e-01f, 4.71828245e-02f, 1.98921636e-01f, -2.09946126e-01f, -1.27447873e-01f, -4.90616262e-03f, 1.20595843e-01f, 1.59447998e-01f,
  1.89036027e-01f, -6.30288869e-02f, 1.23824859e-02f, -1.74246058e-01f, -2.26878300e-01f, -1.77581131e-01f, 1.72930717e-01f, 3.52169909e-02f, -1.02919430e-01f, -7.05829402e-03f,
  -2.48194546e-01f, 1.81020707e-01f, 2.08996952e-01f, -1.34851262e-01f, 1.35914549e-01f, -1.85073242e-01f, -4.33209598e-01f, -1.54705837e-01f, 1.76693544e-01f, -6.87442627e-03f,
  -4.25633305e-04f, 1.55954733e-01f, 1.99758679e-01f, -1.41947478e-01f, 2.11465538e-01f, 8.74380860e-03f, 1.34194270e-01f, -1.48104146e-01f, -4.40576188e-02f, 4.89719778e-01f,
  -1.42576665e-01f, 7.36054331e-02f, -1.95106998e-01f, 5.90281710e-02f, 3.65416259e-02f, 1.55349433e-01f, -2.52427272e-02f, 1.50855869e-01f, 3.59739549e-02f, -1.34022787e-01f,
  7.52558038e-02f, 2.22751454e-01f, -8.89048576e-02f, 9.79600623e-02f, -6.33430332e-02f, 1.57643080e-01f, -1.33230463e-01f, -9.44261625e-02f, 1.01018727e-01f, -1.44801319e-01f,
  5.27803898e-02f, 2.00940207e-01f, -1.31872641e-02f, 7.82988295e-02f, 9.42754000e-02f, -1.77086398e-01f, 4.02489960e-01f, -2.08577029e-02f, -1.45285293e-01f, -3.83905396e-02f,
  2.23071575e-01f, 5.83153740e-02f, -3.13426226e-01f, 1.30362511e-01f, 1.27667755e-01f, 3.19901407e-02f, 3.06953967e-01f, 7.52898753e-02f, 1.07387520e-01f, -1.25646323e-01f,
  3.93817991e-01f, 1.10386260e-01f, -6.64498508e-02f, 1.47941485e-01f, 3.83931845e-01f, 1.76726550e-01f, 7.69533813e-02f, 2.99507491e-02f, -1.69883315e-02f, -4.03690726e-01f,
  -1.55665696e-01f, -1.90939322e-01f, -1.41730830e-01f, 2.57281125e-01f, 2.14019656e-01f, 1.49385273e-01f, 1.30163908e-01f, -9.99353379e-02f, 2.25125849e-02f, 1.49212331e-01f,
  9.60272923e-03f, -3.23515013e-02f, -2.03277677e-01f, 1.84947044e-01f, -1.63206324e-01f, 2.31876194e-01f, -2.42186919e-01f, 4.05900180e-01f, 2.05031171e-01f, -1.24485895e-01f,
  3.72982472e-02f, 7.09269196e-02f, 4.15203497e-02f, -3.55472445e-01f, -2.28807583e-01f, -3.40130121e-01f, -4.47093368e-01f, -2.91809887e-01f, 1.22126713e-01f, -1.88773870e-01f,
  -7.24689215e-02f, -3.01784128e-02f, -1.58960819e-01f, -9.36070457e-02f, 3.40805389e-02f, 2.09551409e-01f, -3.55122447e-01f, -1.91680968e-01f, -1.56303436e-01f, -8.36747587e-02f,
  -1.08611308e-01f, 2.23551124e-01f, -9.51098055e-02f, 8.90351981e-02f, 2.43570760e-01f, -9.56764221e-02f, 1.24914525e-02f, 3.54045600e-01f, -2.58579068e-02f, 1.31220609e-01f,
  -1.03627495e-01f, 3.45580250e-01f, 3.30067843e-01f, -1.34828806e-01f, -2.29512498e-01f, -1.07971422e-01f, -2.67812699e-01f, 2.58713346e-02f, -1.50289834e-01f, 1.35734811e-01f,
  1.57491043e-01f, -5.12900203e-02f, -1.70438513e-01f, 5.07758632e-02f, 2.41389453e-01f, 3.13385464e-02f, 1.03726618e-01f, -4.10106301e-01f, -1.72543585e-01f, -5.50075062e-02f,
  -1.59414783e-01f, 1.16190150e-01f, -7.85165131e-02f, 3.57817292e-01f, 1.65185332e-01f, 1.89801857e-01f, -1.55350799e-02f, -2.85195798e-01f, 7.38380402e-02f, -1.35139808e-01f,
  1.95248760e-02f, -3.94895263e-02f, -3.50664519e-02f, 7.29380324e-02f, -5.67891672e-02f, 3.02773356e-01f, -8.10842142e-02f, 4.19394523e-02f, -1.12190254e-01f, -2.40888342e-01f,
  -1.40242428e-02f, -1.34240597e-01f, 3.70670035e-02f, -3.47450413e-02f, 6.96754456e-02f, 6.71346113e-02f, 2.10164294e-01f, 1.02170467e-01f, 5.54261431e-02f, 1.21508047e-01f,
  -1.16470739e-01f, 5.23773916e-02f, -1.25542015e-01f, 1.13456398e-01f, -4.66787606e-01f, -7.25843757e-02f, 1.42966092e-01f, -3.79035324e-02f, -2.17060328e-01f, 1.20136611e-01f,
  1.15833692e-01f, 3.65508199e-01f, -1.88107252e-01f, 1.04833595e-01f, -8.68421495e-02f, 1.42377391e-01f, 2.36537427e-01f, 1.93274230e-01f, -2.92614311e-01f, -4.71208729e-02f,
  -1.37798131e-01f, 6.27213642e-02f, -2.36748278e-01f, 8.89966264e-02f, 2.46138006e-01f, 1.92798108e-01f, 7.86787421e-02f, -1.34553269e-01f, -7.77682364e-02f, 1.38622940e-01f,
  -7.91694783e-03f, -3.28723073e-01f, 1.62675917e-01f, -1.11573502e-01f, 1.11468069e-01f, -6.51193112e-02f, 5.76565750e-02f, 1.83898509e-01f, 1.05279818e-01f, 4.08605039e-01f,
  1.79869831e-02f, 8.26413780e-02f, -1.02903940e-01f, 8.65387693e-02f, -1.87046185e-01f, -3.04367393e-01f, -2.26676553e-01f, 8.25396180e-02f, 1.91508859e-01f, -9.67929896e-04f,
  2.21580282e-01f, 2.77100205e-01f, 2.95768440e-01f, 1.21104039e-01f, 3.37929100e-01f, 2.15948701e-01f, 2.57300407e-01f, -6.73536286e-02f, 4.31383029e-02f, 3.50860447e-01f,
  1.94750540e-03f, 2.04901531e-01f, 2.30194345e-01f, 2.12348744e-01f, 6.25949726e-02f, 1.05724387e-01f, 2.23973885e-01f, 2.52790600e-01f, -1.00285150e-01f, -1.88083991e-01f,
  2.01548696e-01f, 2.21700996e-01f, -4.16951686e-01f, -9.73897353e-02f, 1.31699473e-01f, -2.32029721e-01f, -1.39911711e-01f, 3.79298955e-01f, -7.69944862e-02f, -1.85141802e-01f,
  -3.65771912e-02f, 2.19119236e-01f, -1.35912001e-01f, 2.32415676e-01f, 2.42885366e-01f, -1.10195547e-01f, 1.40832169e-02f, -3.14414175e-03f, -1.62149996e-01f, -1.40462493e-04f,
  8.41081664e-02f, 1.60329770e-02f, 2.05786731e-02f, 2.60546543e-02f, -5.03501892e-02f, -4.75789569e-02f, -6.21199012e-02f, -1.94460377e-01f, 2.30777100e-01f, 5.76301664e-02f,
  -1.12403437e-01f, -4.17451784e-02f, -7.60816336e-02f, 7.46544451e-02f, -1.31600797e-01f, -5.37285991e-02f, 1.03976399e-01f, 9.56957266e-02f, -5.31815551e-02f, 2.06228435e-01f,
  4.74219210e-02f, -3.39752249e-02f, -9.32314545e-02f, -9.26719233e-02f, -2.90300280e-01f, 3.25659454e-01f, 1.51991341e-02f, 3.07634830e-01f, -2.03519501e-02f, 1.76183681e-03f,
  8.32956731e-02f, -1.32802755e-01f, 3.12040359e-01f, 2.46513829e-01f, 1.56802490e-01f, -2.79012788e-02f, -1.75098091e-01f, -1.89874917e-01f, 2.36641094e-01f, 9.23483819e-02f,
  2.08857805e-01f, 7.61252269e-02f, -6.23349696e-02f, -2.71182030e-01f, 9.34606344e-02f, 2.47938670e-02f, -3.44888508e-01f, 4.80260774e-02f, 2.10083753e-01f, -2.70740062e-01f,
  6.62491098e-02f, -1.61689054e-02f, -3.03784639e-01f, -3.15112360e-02f, 1.55295044e-01f, 9.00364369e-02f, -1.48566872e-01f, 9.01123434e-02f, 2.68890616e-02f, 1.01367474e-01f,
  -3.29034701e-02f, -1.88834473e-01f, -8.62861425e-02f, 1.51462287e-01f, 2.31802389e-01f, 1.11104809e-01f, 2.43400946e-01f, 2.41922662e-02f, -2.92376857e-02f, 4.76027057e-02f,
  1.00516543e-01f, -9.59084705e-02f, 1.73198506e-01f, 4.64435034e-02f, 2.06662819e-01f, -6.11725040e-02f, 1.65455844e-02f, -1.23339221e-01f, 2.65968759e-02f, 8.24224278e-02f,
  -5.50576709e-02f, 2.34457374e-01f, -4.37919796e-03f, -1.79723315e-02f, -9.37218964e-02f, 1.05564043e-01f, -3.65696251e-02f, 3.16092402e-01f, 2.85404265e-01f, 4.67392132e-02f,
  5.60908113e-03f, 4.11802270e-02f, -6.33223578e-02f, 2.43600622e-01f, 1.30578540e-02f, 1.55558884e-01f, 2.31615171e-01f, 1.70265958e-02f, -6.18987158e-02f, 2.02075824e-01f,
  9.56046134e-02f, -1.29266351e-01f, 6.39912635e-02f, 1.99129388e-01f, 6.89200824e-04f, -1.44382983e-01f, 3.39009881e-01f, 2.09819764e-01f, -1.38143927e-01f, 2.15136275e-01f,
  1.64784744e-01f, 1.17855832e-01f, -3.36408317e-01f, 6.72002956e-02f, 5.20442799e-02f, -5.58404513e-02f, 3.89386714e-02f, 1.48908928e-01f, -8.49260092e-02f, -2.62746394e-01f,
  -1.18812807e-01f, -1.39389932e-01f, 5.44784665e-02f, 4.62226644e-02f, 7.35522658e-02f, 6.50864542e-02f, 1.28155053e-01f, 1.21393919e-01f, -4.61195298e-02f, 1.36565208e-01f,
  -1.04012201e-02f, 3.04392446e-02f, 9.26719457e-02f, -1.74365848e-01f, -7.07662925e-02f, 1.95856705e-01f, 5.75928986e-02f, 1.01289615e-01f, -4.90745157e-02f, 4.27205302e-02f,
  2.29492024e-01f, -2.57711381e-01f, -2.26490527e-01f, -1.25525847e-01f, 2.39738718e-01f, -1.77796140e-01f, -2.21783221e-02f, -1.36036456e-01f, 1.59540311e-01f, 1.27032265e-01f,
  -6.15026169e-02f, -1.05022110e-01f, 1.14641309e-01f, -4.02994975e-02f, 1.25495335e-02f, 2.52722595e-02f, 1.76155679e-02f, 2.89008003e-02f, -3.78224906e-03f, -6.23974726e-02f,
  -5.79158999e-02f, 4.04335698e-03f, -5.27494140e-02f, -8.51165578e-02f, -8.61944333e-02f, -4.58610542e-02f, -1.27862811e-01f, -1.41211227e-01f, -1.37012362e-01f, 8.96225125e-03f,
  -1.41536985e-02f, -6.18988052e-02f, -8.92210379e-02f, 3.15939486e-02f, 2.28768643e-02f, -1.04710065e-01f, 3.73166241e-02f, 4.96020019e-02f, 4.73096743e-02f, 5.60225882e-02f,
  -6.56303763e-02f, -2.22702865e-02f, 1.11839049e-01f, -2.10010447e-02f, 1.22006729e-01f, -2.26128493e-02f, -3.19952853e-02f, 1.16878925e-02f, 3.80202830e-02f, -1.04518458e-01f,
  -1.87863074e-02f, -2.59856377e-02f, 3.63473073e-02f, -1.95190579e-01f, 1.41122071e-02f, -4.62478288e-02f, -1.08021945e-01f, -1.65745407e-01f, -2.02548862e-01f, -1.62605906e-03f,
  -7.04214498e-02f, -1.87216140e-02f, -1.23917744e-01f, -4.57108840e-02f, -1.86958149e-01f, -1.90587670e-01f, 5.48849776e-02f, -5.86219542e-02f, -8.17348436e-02f, -7.93362688e-03f,
  -7.32312649e-02f, 1.76965054e-02f, -1.63334519e-01f, 6.58347458e-02f, 1.00424960e-01f, -2.22458821e-02f, -5.99888563e-02f, 2.63037771e-01f, 1.59281176e-02f, 2.69909501e-01f,
  -3.46404351e-02f, 1.53566539e-01f, -1.86235607e-01f, 4.88153398e-02f, 8.95639956e-02f, -5.89228570e-02f, 8.51975903e-02f, 2.06820846e-01f, -9.76304859e-02f, -2.43546382e-01f,
  6.89627528e-02f, 1.60868749e-01f, 1.02234095e-01f, -3.32031734e-02f, -5.18504046e-02f, 3.07480454e-01f, -5.87244481e-02f, 1.31011710e-01f, 2.21473515e-01f, 1.88626856e-01f,
  -3.41982722e-01f, -1.49598911e-01f, 3.72416168e-01f, 6.34739175e-02f, 1.14856824e-01f, 4.58417386e-02f, -1.79364249e-01f, -4.41500247e-01f, -8.86969268e-02f, -3.96176800e-02f,
  1.69245619e-02f, -6.17690757e-02f, 2.23342478e-01f, 1.21475980e-01f, 3.14776264e-02f, -1.44446433e-01f, 2.12325096e-01f, -1.59500554e-01f, 1.26232281e-01f, -2.02051457e-03f,
  -2.36760542e-01f, 1.71517968e-01f, -1.36570275e-01f, 9.40899551e-02f, 2.66179383e-01f, 2.99024791e-01f, -4.91839014e-02f, 9.18939486e-02f, 1.31650627e-01f, -2.79430747e-01f,
  2.82908440e-01f, 8.69775191e-02f, 4.01102990e-01f, -2.36597601e-02f, -1.95990488e-01f, -4.48508076e-02f, 1.78209201e-01f, 2.80604674e-03f, 1.98747739e-01f, 2.86475927e-01f,
  -1.64514616e-01f, 4.47772682e-01f, -6.31307811e-03f, 3.30762677e-02f, 2.27202833e-01f, -5.66813983e-02f, 1.29503623e-01f, 4.14925292e-02f, 3.85525316e-01f, 1.91220939e-01f,
  1.13551192e-01f, 2.87074804e-01f, 5.02365874e-03f, -9.94434655e-02f, 5.85771352e-02f, 2.63574887e-02f, 2.81106960e-02f, 9.82693583e-02f, -2.02379912e-01f, -1.33489862e-01f,
  5.43699935e-02f, -9.41300839e-02f, -4.07801867e-01f, -2.57079415e-02f, 1.76286343e-02f, 8.36476311e-02f, 5.71005344e-02f, 3.01313251e-01f, -1.95832789e-01f, 4.25000153e-02f,
  2.61424541e-01f, -6.64539337e-02f, -3.56066555e-01f, -6.61100149e-02f, 5.52788861e-02f, 1.82908714e-01f, -1.37526721e-01f, 4.28645872e-02f, 1.14062749e-01f, 1.08265482e-01f,
  1.91540033e-01f, 8.72289762e-02f, 1.51231393e-01f, -1.39163164e-02f, -1.01592094e-01f, -1.21146746e-01f, -2.41098907e-02f, -2.92803124e-02f, 1.36152819e-01f, -3.24747302e-02f,
  2.00902477e-01f, 7.29940385e-02f, 9.11298618e-02f, 3.99274053e-03f, -2.75507063e-01f, 6.96418658e-02f, 1.85560640e-02f, -3.11870873e-03f, -1.74995795e-01f, -1.96440607e-01f,
  -6.77121356e-02f, 2.27432996e-01f, 8.13256130e-02f, 2.41073251e-01f, 7.75478128e-03f, 4.02122661e-02f, -5.37591465e-02f, 1.19990997e-01f, 2.17123679e-03f, 1.70353264e-01f,
  1.92216918e-01f, 7.94582069e-02f, -1.31849051e-02f, 1.33346975e-01f, -4.93904129e-02f, 1.60642549e-01f, -8.60220268e-02f, 1.13996044e-01f, 2.19170451e-01f, 2.80178636e-01f,
  3.21051553e-02f, -1.90275349e-02f, 6.21588491e-02f, 1.66578814e-01f, -1.43081859e-01f, -3.18815932e-02f, 1.94309726e-01f, 2.79931221e-02f, -3.09511364e-01f, -1.26700774e-01f,
  -3.04405317e-02f, 3.48541476e-02f, 3.72248292e-01f, 6.90526962e-02f, -4.41276610e-01f, -3.41114104e-01f, 1.07576817e-01f, -2.29589149e-01f, 9.63026434e-02f, -2.31746361e-02f,
  -3.84663381e-02f, 2.44897440e-01f, 3.44995260e-02f, -9.96394530e-02f, 3.02502932e-03f, 1.81340188e-01f, -2.00964004e-01f, 4.69712839e-02f, 9.58058238e-02f, -7.00171739e-02f,
  4.40922529e-02f, 1.35090977e-01f, 1.00071475e-01f, 2.72053927e-01f, 1.04812376e-01f, -1.21291757e-01f, 2.75774658e-01f, -4.22953889e-02f, 1.43100932e-01f, -1.54330269e-01f,
  5.29113829e-01f, 2.37124022e-02f, -6.39116988e-02f, 1.05322301e-01f, 3.14401656e-01f, 1.83901474e-01f, -1.79044306e-01f, 1.77617252e-01f, 1.83184028e-01f, -2.50924110e-01f,
  -1.90776009e-02f, -3.08031682e-02f, 3.85502055e-02f, 2.47802466e-01f, 5.26057035e-02f, 2.03184441e-01f, 1.07792139e-01f, 1.07718520e-01f, 2.32660636e-01f, 1.67813718e-01f,
  -1.15928948e-01f, -1.73740417e-01f, -1.62692651e-01f, -2.95668244e-01f, 2.86769927e-01f, -2.13450968e-01f, 1.08088523e-01f, 1.71010405e-01f, -3.16475481e-01f, 5.11675514e-02f,
  -2.98386551e-02f, 2.48699337e-01f, -1.83107525e-01f, -7.39060044e-02f, -4.66633681e-03f, -2.13227630e-01f, -3.02835137e-01f, 2.06067283e-02f, 3.66615683e-01f, -7.84939975e-02f,
  -9.86043587e-02f, -3.43686253e-01f, -5.78730963e-02f, 2.10426345e-01f, 1.43660486e-01f, -7.90126249e-02f, 1.33550510e-01f, 1.92928106e-01f, -8.30920190e-02f, 1.44646928e-01f,
  1.50878340e-01f, 1.77094340e-01f, 7.51072615e-02f, 7.60699362e-02f, 2.32975096e-01f, 6.05543740e-02f, -1.17720395e-01f, -5.43312635e-04f, -1.02054268e-01f, 4.08009201e-01f,
  -8.86345059e-02f, 4.45117742e-01f, -2.91435599e-01f, -8.90297517e-02f, -7.34005645e-02f, 3.10713202e-01f, -1.19793636e-03f, -9.35354177e-03f, 4.98328358e-02f, -1.61197126e-01f,
  -1.04243465e-01f, 5.52678518e-02f, 4.71728109e-02f, 2.07057133e-01f, -2.88753640e-02f, 1.49837628e-01f, 2.05680519e-01f, 6.10457174e-03f, 2.55005628e-01f, 1.09623849e-01f,
  2.49767914e-01f, 7.79453218e-02f, 1.74877301e-01f, 2.19211459e-01f, -1.48632467e-01f, 1.65034384e-01f, -2.49593779e-02f, 5.00623994e-02f, 1.83790326e-01f, 2.67644804e-02f,
  -2.89620180e-02f, -2.42641613e-01f, 2.30670974e-01f, -2.27959067e-01f, -2.21462280e-01f, -5.18560074e-02f, 1.41991451e-01f, -1.41894490e-01f, 2.25654989e-01f, 2.15075418e-01f,
  4.96688448e-02f, -9.07893702e-02f, 1.43146470e-01f, -1.23636998e-01f, -5.64941913e-02f, -1.04780480e-01f, 3.13519617e-03f, 8.85999724e-02f, -1.86754111e-02f, 2.23668069e-02f,
  2.17066277e-02f, -1.68802798e-01f, 2.06560493e-01f, 8.40080082e-02f, 1.59426674e-01f, 7.87529796e-02f, -2.44525690e-02f, -5.90921426e-03f, -2.19335165e-02f, -1.06856748e-01f,
  2.41151661e-01f, -2.00033844e-01f, 1.86090872e-01f, -1.03949733e-01f, -4.76955250e-02f, -1.70058712e-01f, -6.60757497e-02f, 1.55211106e-01f, 4.75788955e-03f, 5.78598939e-02f,
  -5.26040308e-02f, -8.37424695e-02f, -3.31649445e-02f, 1.77999601e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.04712628e-01f, 1.19881831e-01f, 1.75728407e-02f, 8.43943357e-02f, -1.47597760e-01f, 7.03853369e-02f, 7.26799518e-02f, -5.57896197e-02f, 1.86138991e-02f, -1.38634861e-01f,
  1.07103296e-01f, 2.09686067e-02f, -5.50360866e-02f, 6.27860501e-02f, 5.88108450e-02f, -1.35730162e-01f, -2.98739746e-02f, 2.73401979e-02f, 7.10654035e-02f, 4.87903785e-03f,
  2.23028120e-02f, 6.81515038e-02f, -6.89724414e-03f, -8.01819339e-02f, 6.53454810e-02f, 1.13981970e-01f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.14272967e-01f, -1.21997036e-01f, 2.54418105e-01f, 8.23636577e-02f, 1.06519602e-01f, 4.80679758e-02f, 9.59895253e-02f, 1.64344162e-02f, -1.11759320e-01f, -8.43090639e-02f,
  7.02407584e-02f, 7.31916055e-02f, 1.21287458e-01f, 2.56419331e-01f, 6.87871352e-02f, 2.71729212e-02f, 1.02834016e-01f, 3.59390117e-02f, -4.25654240e-02f, 2.99345046e-01f,
  1.68829262e-01f, 1.21048637e-01f, 1.10590294e-01f, 1.60313714e-02f, -2.48984471e-01f, -2.03236297e-01f, -9.50358529e-03f, 7.59395063e-02f, -4.72227111e-02f, -1.14414766e-01f,
  1.43899232e-01f, 1.05340369e-01f, 1.35108709e-01f, -1.40241876e-01f, -1.22678168e-01f, 6.36614412e-02f, 1.25627583e-02f, -2.16545612e-01f, -9.18720365e-02f, 1.56209722e-01f,
  1.74624160e-01f, -1.82364091e-01f, 1.15932994e-01f, -5.83221652e-02f, 1.00547582e-01f, 9.11561176e-02f, -1.79166809e-01f, -1.45681761e-02f, -1.19382359e-01f, 1.83604985e-01f,
  4.91159372e-02f, 1.19040787e-01f, -4.46233265e-02f, -3.34696546e-02f, -4.99793068e-02f, 5.31880707e-02f, 1.24952726e-01f, -1.28667563e-01f, 9.40872878e-02f, -1.29012644e-01f,
  2.20595729e-02f, -1.21419095e-01f, -5.76810911e-02f, 4.63159680e-02f, 1.43291444e-01f, -2.43358374e-01f, 8.98690370e-04f, 1.94439255e-02f, 5.08639701e-02f, 9.40965489e-02f,
  1.16763264e-01f, -5.41842133e-02f, 2.26836964e-01f, 1.22123167e-01f, 1.26116470e-01f, -3.85511555e-02f, -1.12851895e-01f, -1.89138770e-01f, 1.56793565e-01f, 8.14396739e-02f,
  -1.46333431e-03f, -3.42748612e-02f, 8.37406591e-02f, 1.72581092e-01f, 9.65579376e-02f, -1.63494080e-01f, -4.44832854e-02f, -2.73102289e-03f, 2.63622075e-01f, 6.83011040e-02f,
  -1.17850170e-01f, 9.03472230e-02f, 6.29644915e-02f, 3.27643782e-01f, -3.19218636e-01f, 7.49408314e-03f, -1.06592923e-01f, 7.24518076e-02f, -2.42812648e-01f, -1.80122435e-01f,
  8.81731287e-02f, 1.53642952e-01f, 2.53542159e-02f, -1.35562867e-01f, -1.64587766e-01f, 3.90824899e-02f, -3.19448054e-01f, -1.13593914e-01f, 9.60726738e-02f, -3.41194420e-04f,
  1.12318464e-01f, 2.75073126e-02f, 1.47595108e-01f, -1.44491524e-01f, 1.81317762e-01f, -7.91996494e-02f, 5.24056107e-02f, -6.61101788e-02f, -1.05640121e-01f, 3.79597535e-03f,
  9.16032270e-02f, 5.46337701e-02f, 2.86380202e-02f, 1.15060739e-01f, -8.61083716e-02f, 1.33525148e-01f, 6.70246109e-02f, -3.39970067e-02f, 5.19190207e-02f, 2.04412788e-02f,
  -8.10411572e-03f, -7.19383359e-02f, -2.15775311e-01f, -1.18895054e-01f, 1.25221968e-01f, 5.05621880e-02f, -2.15490490e-01f, -1.54487014e-01f, -1.80460244e-01f, 2.76106112e-02f,
  1.30962297e-01f, 1.18211105e-01f, -1.79201499e-01f, -3.01980436e-01f, -4.28369641e-02f, -1.33999720e-01f, -1.29769435e-02f, -6.58617765e-02f, 2.64799029e-01f, 1.24126464e-01f,
  -9.74307582e-02f, 1.36940733e-01f, -3.90712857e-01f, 8.64014437e-04f, 6.37205318e-02f, -1.50374055e-01f, 1.02279007e-01f, -1.34362996e-01f, 2.72858828e-01f, 2.58197576e-01f,
  8.44332650e-02f, -2.22668305e-01f, 3.24289501e-02f, 1.52678490e-01f, -4.60577831e-02f, -4.72225323e-02f, 3.80187854e-02f, 2.10955471e-01f, 7.81223774e-02f, 5.03595844e-02f,
  6.29610270e-02f, 6.27777576e-02f, -2.41959825e-01f, -2.48480752e-01f, -1.95854828e-01f, 1.94775313e-02f, 6.43411875e-02f, 1.62585285e-02f, -6.80448413e-02f, 2.09581897e-01f,
  -4.51637022e-02f, 6.17504269e-02f, 1.25185713e-01f, 7.43342703e-03f, -1.60545483e-01f, -1.55775949e-01f, -1.66366994e-01f, -9.06091928e-02f, 3.10982838e-02f, 5.40997684e-02f,
  -1.53973624e-01f, -3.18663046e-02f, 2.28545368e-02f, -7.41496235e-02f, -5.78152165e-02f, 2.19577208e-01f, -3.85239609e-02f, -2.17690706e-01f, 6.79357210e-03f, 4.57323305e-02f,
  -1.43673733e-01f, 5.32358587e-02f, -1.02798175e-02f, 1.25286832e-01f, -3.74825671e-02f, -6.81705102e-02f, -1.04097957e-02f, -2.25615293e-01f, 1.03249624e-01f, 1.00205012e-01f,
  1.62866220e-01f, -3.85171205e-01f, 9.56168249e-02f, 1.98913708e-01f, 1.76596463e-01f, -2.49489229e-02f, -2.44027600e-02f, 9.40191373e-02f, -2.26563439e-01f, -1.66591600e-01f,
  -4.31639403e-02f, -5.37014268e-02f, 2.48274878e-01f, -4.15209532e-02f, -1.50830999e-01f, -3.00255597e-01f, 2.91768223e-01f, 1.73572209e-02f, -3.53716337e-03f, -1.65944070e-01f,
  -1.24565274e-01f, -4.50333469e-02f, 1.37286738e-01f, 1.54867589e-01f, -2.60393679e-01f, 3.29144746e-02f, -8.71816725e-02f, 8.20846930e-02f, -1.15626939e-01f, 1.01929881e-01f,
  -1.14026368e-01f, 4.98010926e-02f, -1.61339819e-01f, -1.35289446e-01f, -1.16393149e-01f, 4.75674272e-02f, 1.07872896e-01f, 8.97550583e-02f, 2.17695564e-01f, -1.13967784e-01f,
  1.59821827e-02f, 1.66393127e-02f, 6.67598769e-02f, -1.18523970e-01f, 1.54485209e-02f, 2.44748741e-01f, -7.71422535e-02f, -7.83517808e-02f, 1.03904352e-01f, 3.07864156e-02f,
  -8.36206600e-02f, 1.70587599e-01f, 5.25770038e-02f, 8.72283652e-02f, -7.00874552e-02f, 2.47297451e-01f, 6.63209483e-02f, -6.21966459e-03f, 7.05695078e-02f, -1.42127410e-01f,
  -1.70779914e-01f, -1.11845760e-02f, 1.32501321e-02f, 6.81124330e-02f, 9.82401296e-02f, -1.37920961e-01f, -1.98684692e-01f, -1.16230525e-01f, -4.09468971e-02f, 2.40511551e-01f,
  -1.02023012e-03f, -6.86402665e-03f, 3.17326970e-02f, -4.15733084e-02f, 1.05961613e-01f, 3.60806078e-01f, -2.80993015e-01f, 2.25670993e-01f, -2.31523409e-01f, -2.66536415e-01f,
  -1.04868021e-02f, 2.41174493e-02f, -5.90794757e-02f, -1.05128944e-01f, 5.65113947e-02f, 4.51484416e-03f, 4.23268415e-03f, 1.46595329e-01f, -1.66558206e-01f, 9.40846503e-02f,
  -7.94579834e-02f, -1.50993690e-01f, 2.40406364e-01f, -8.26930553e-02f, -1.80599652e-02f, 6.11284040e-02f, -5.70282340e-02f, 1.89867511e-01f, 7.16772974e-02f, -1.34443969e-01f,
  6.67635426e-02f, 9.88598540e-03f, -8.30179304e-02f, 4.09827605e-02f, 3.20176631e-02f, 2.20336020e-01f, 1.32332921e-01f, -7.66070262e-02f, -6.77273422e-02f, 1.36391774e-01f,
  7.17540011e-02f, 4.72186645e-03f, 2.28065103e-01f, -7.91152120e-02f, -1.02353148e-01f, -5.59322210e-03f, -1.60191655e-01f, -1.33751050e-01f, -6.12541549e-02f, 2.54382432e-01f,
  1.09451242e-01f, 8.26686844e-02f, 4.15455364e-02f, -1.39989797e-02f, 1.04040399e-01f, 2.50403100e-04f, -1.03250127e-02f, 9.42617655e-02f, 1.24096476e-01f, -1.41607344e-01f,
  -9.14641768e-02f, 2.74411052e-01f, -8.40520859e-02f, 9.81255621e-02f, -1.39406189e-01f, 1.22140003e-02f, 3.29163671e-01f, 6.74024969e-02f, 9.41355303e-02f, 2.22667884e-02f,
  3.89137894e-01f, -4.14717868e-02f, -1.17996722e-01f, 1.34581570e-02f, 2.25035980e-01f, -2.47974694e-02f, -1.67589530e-01f, 3.27630676e-02f, -1.03720345e-01f, 1.33916093e-02f,
  -1.08341031e-01f, 6.51074350e-02f, 1.10900059e-01f, 1.33648282e-02f, -2.19738916e-01f, -1.55866921e-01f, -1.09167159e-01f, -9.17114466e-02f, -1.15616880e-01f, 2.50290841e-01f,
  -2.01513395e-01f, 2.12706625e-03f, 7.14068562e-02f, -1.05328292e-01f, 1.37912914e-01f, -1.09646153e-02f, -4.63266596e-02f, 4.17269506e-02f, 1.05284289e-01f, 2.77152658e-03f,
  6.36266321e-02f, -2.25740839e-02f, 7.38052875e-02f, 4.28868756e-02f, 1.94896292e-02f, -7.33154714e-02f, -9.91426408e-02f, -4.55037132e-02f, -1.93271413e-01f, 8.15709531e-02f,
  -9.06727985e-02f, -1.40127480e-01f, -5.83200902e-03f, -3.46595086e-02f, -1.04076244e-01f, 1.10068202e-01f, 2.24700626e-02f, -2.82745987e-01f, -3.32704820e-02f, -9.84707624e-02f,
  -7.29146525e-02f, -4.07956876e-02f, 2.60726273e-01f, -2.13604346e-01f, -2.55873464e-02f, 9.56228673e-02f, -3.50095183e-02f, 1.26140565e-01f, 1.80403292e-01f, 4.42190655e-02f,
  1.65824503e-01f, 1.37758953e-02f, 1.66976959e-01f, -1.13192059e-01f, 4.26239789e-01f, 8.82846192e-02f, 2.23831326e-01f, -1.65084541e-01f, 3.21901739e-01f, -3.68787721e-02f,
  -5.32622039e-02f, 3.73313248e-01f, -5.72553165e-02f, -5.44670746e-02f, -2.08516091e-01f, 1.16101049e-01f, 1.19102880e-01f, 1.53073847e-01f, -2.57071555e-01f, -2.54644781e-01f,
  4.88117114e-02f, 5.84190153e-02f, -1.24830119e-01f, 1.63582459e-01f, 7.49329850e-02f, 5.00450060e-02f, 2.35272199e-01f, 4.14444357e-02f, 9.10316873e-03f, -4.38568145e-02f,
  -1.50466144e-01f, -1.81115195e-01f, 4.35991734e-02f, -1.44521475e-01f, 3.53686437e-02f, -1.34300679e-01f, -9.89323929e-02f, -8.56612399e-02f, 2.21511930e-01f, 1.07553974e-01f,
  1.90906674e-01f, -1.50628179e-01f, -1.87159523e-01f, -7.63242468e-02f, -1.46463916e-01f, -2.00993735e-02f, -8.56116638e-02f, -1.91727262e-02f, 1.57347560e-01f, 6.51699528e-02f,
  1.55076534e-01f, -3.00551429e-02f, 4.18571010e-02f, 2.34770477e-02f, 1.06578015e-01f, -2.62337681e-02f, 3.55809228e-03f, 5.17646894e-02f, 8.27647820e-02f, 1.86005548e-01f,
  -1.70082524e-02f, 1.72908530e-01f, -1.97670877e-01f, 5.09110540e-02f, 3.71448249e-01f, 3.28030437e-01f, 8.21352005e-02f, -3.21228147e-01f, 2.57117122e-01f, -1.10138334e-01f,
  1.00230575e-01f, -9.90498215e-02f, -3.30287255e-02f, -1.73155501e-01f, -6.56064525e-02f, -1.04920693e-01f, 1.02512859e-01f, -2.42012646e-03f, -7.20009208e-02f, 7.26701766e-02f,
  1.69469953e-01f, 5.94635531e-02f, -2.30115235e-01f, -1.07607149e-01f, -1.21485837e-01f, 6.34349436e-02f, -1.03001492e-02f, 1.34053200e-01f, -6.23897128e-02f, 1.22966729e-01f,
  3.02416295e-01f, -3.54632437e-02f, -3.71942669e-03f, -3.02769970e-02f, -1.59967363e-01f, -1.44968554e-01f, -6.16931319e-02f, 5.58269061e-02f, -1.90076858e-01f, -1.23676851e-01f,
  1.59731984e-01f, -4.69992161e-02f, 1.29957944e-01f, 1.08103409e-01f, 9.39386040e-02f, -1.54461697e-01f, 1.77412927e-01f, 2.94232201e-02f, 1.07190274e-01f, 2.34970242e-01f,
  1.70454383e-01f, 7.07046315e-02f, 5.22281975e-02f, -1.69769842e-02f, -2.80093029e-02f, 3.05184036e-01f, -8.42533708e-02f, -1.87515050e-01f, 1.22234449e-01f, 2.03802347e-01f,
  4.57235724e-02f, 9.35812369e-02f, -8.81092101e-02f, -1.38614167e-04f, -2.47041628e-01f, -2.74795629e-02f, 2.07971394e-01f, -1.23525359e-01f, 1.24422133e-01f, 8.59446973e-02f,
  2.21403874e-02f, 1.55750409e-01f, -2.45489459e-02f, 2.87015170e-01f, 4.60275933e-02f, -1.47050604e-01f, -2.88467705e-01f, 5.76425679e-02f, -3.81427966e-02f, -8.85743424e-02f,
  1.02659270e-01f, -5.84486499e-03f, -1.18108399e-01f, 8.44393969e-02f, -8.01771358e-02f, -1.11550897e-01f, 1.24470312e-02f, -2.84865499e-01f, 1.81547299e-01f, -6.96236864e-02f,
  1.32652884e-02f, 1.94920182e-01f, 6.27221093e-02f, -1.54403865e-01f, 1.63318068e-01f, -2.67699417e-02f, -1.17052644e-01f, 4.90840338e-03f, 9.83339921e-03f, -1.03788599e-01f,
  -1.11928277e-01f, 1.34521261e-01f, -1.18287586e-01f, 5.06892353e-02f, -5.07405959e-02f, -1.21938817e-01f, 1.07427035e-02f, -2.27297202e-01f, 1.83842275e-02f, -3.43995616e-02f,
  -1.75164957e-02f, -1.89035103e-01f, 4.48089186e-03f, 4.80389707e-02f, 1.52552605e-01f, 8.41081887e-02f, 1.20444611e-01f, 1.86472073e-01f, -4.71791737e-02f, 2.71486968e-01f,
  7.45993108e-02f, -1.34996369e-01f, 1.49585888e-01f, 9.14578363e-02f, -1.53633401e-01f, 1.97451010e-01f, -3.73192653e-02f, 1.21535547e-01f, -9.68218967e-03f, 1.11581251e-01f,
  -1.25598088e-01f, -3.83982211e-02f, -4.20091040e-02f, -1.81027561e-01f, -6.85773045e-02f, 5.75350486e-02f, 8.05294290e-02f, -1.66344509e-01f, 2.32923880e-01f, 8.72564018e-02f,
  -7.30827376e-02f, -2.28415042e-01f, 9.10385102e-02f, -1.77399427e-01f, -1.35102078e-01f, 1.93828106e-01f, 9.77802649e-03f, -4.33092304e-02f, -8.59828368e-02f, 1.02871753e-01f,
  -1.37973294e-01f, 2.64638383e-02f, 1.01432800e-02f, 1.08072005e-01f, 3.29334401e-02f, 2.54544973e-01f, 1.85229816e-02f, -6.16547130e-02f, 1.26266330e-01f, -1.39707208e-01f,
  3.00552882e-02f, 9.54099223e-02f, 1.57650441e-01f, -3.27332579e-02f, -1.02180883e-01f, -1.30333662e-01f, -3.41743343e-02f, -5.42843714e-02f, 3.19705419e-02f, -2.00853255e-02f,
  5.84892333e-02f, -6.34575263e-02f, -1.59810539e-02f, -3.13834786e-01f, -1.90625191e-01f, -1.30048811e-01f, -3.13326940e-02f, 5.79399951e-02f, 5.95535710e-02f, 1.25918761e-01f,
  1.22686602e-01f, 1.21014364e-01f, -1.64015487e-01f, 2.62241811e-01f, 2.02232406e-01f, -9.76525173e-02f, 5.72854802e-02f, 3.51074636e-01f, -3.93187292e-02f, 3.06564033e-01f,
  -2.78665554e-02f, -5.89472502e-02f, 5.24397343e-02f, 5.84488064e-02f, -1.39728308e-01f, -1.99746162e-01f, -6.84900880e-02f, -2.29861140e-01f, -7.59377191e-03f, 4.44378629e-02f,
  -5.18861525e-02f, 1.32194594e-01f, 2.08598316e-01f, 1.47803770e-02f, -1.55445173e-01f, -1.66445181e-01f, -1.75071463e-01f, 1.28444523e-01f, -5.81591167e-02f, 2.08987534e-01f,
  1.51278321e-02f, 1.14489019e-01f, 1.18846511e-02f, 6.61116391e-02f, -1.84998184e-01f, -1.09390914e-01f, 1.28362924e-01f, 7.65146911e-02f, -6.99801818e-02f, 2.57196724e-02f,
  1.55121610e-01f, 9.05405134e-02f, 2.26707399e-01f, -1.57404765e-01f, -9.86799449e-02f, -1.52716219e-01f, 6.08693697e-02f, 1.42207667e-02f, 5.65767381e-03f, -1.27101764e-01f,
  -1.06818378e-01f, -7.21068531e-02f, 3.67590673e-02f, -4.67890874e-03f, 2.16287792e-01f, 1.29517213e-01f, -1.22362085e-01f, 8.08451474e-02f, -1.28619462e-01f, -1.20705396e-01f,
  1.26753584e-01f, 8.59972313e-02f, 1.26534358e-01f, 1.54730260e-01f, 2.35837564e-01f, 5.91455922e-02f, -9.76874232e-02f, 2.04824638e-02f, 1.24922872e-01f, 1.17765842e-02f,
  -3.04463655e-02f, 1.92905232e-01f, 1.87481403e-01f, -8.24416950e-02f, 6.82623908e-02f, 1.12579226e-01f, 4.89856899e-02f, 2.20820725e-01f, -1.16434125e-02f, -3.86307612e-02f,
  -2.57368267e-01f, -2.59240836e-01f, 6.33462146e-02f, 1.15315937e-01f, -2.17589084e-02f, 1.41078845e-01f, 1.66452453e-01f, 1.29834399e-01f, 3.24871004e-01f, -1.04397587e-01f,
  -1.35745749e-01f, 2.16825277e-01f, 1.19097577e-02f, 1.88585952e-01f, 1.46180883e-01f, 9.22717750e-02f, 8.83819014e-02f, 2.05484703e-01f, -1.94253802e-01f, -6.44603819e-02f,
  -7.63625577e-02f, 5.32133393e-02f, 7.04810694e-02f, -9.92130712e-02f, -5.33870533e-02f, 1.25528470e-01f, 1.18960701e-01f, 2.00969744e-02f, -1.30485132e-01f, 1.62189707e-01f,
  1.88388735e-01f, -8.66263732e-02f, -8.88591111e-02f, 1.14195883e-01f, 4.41124216e-02f, -7.46614486e-02f, -2.46299043e-01f, 2.24877684e-03f, 5.55541143e-02f, -7.91975632e-02f,
  -1.57978162e-01f, 2.37081140e-01f, -1.84582714e-02f, 8.64012465e-02f, 5.71419448e-02f, -1.07797615e-01f, 1.35835424e-01f, -2.87205964e-01f, -1.10983856e-01f, -2.90508922e-02f,
  -6.42654598e-02f, -2.67505020e-01f, 1.59912989e-01f, -6.03003800e-02f, -4.10046428e-02f, -1.42988995e-01f, -5.74489571e-02f, 1.82652995e-02f, 2.45213360e-01f, -1.71873972e-01f,
  -6.49066791e-02f, 1.38269350e-01f, 2.61739850e-01f, 1.18822992e-01f, 1.66076928e-01f, 2.49032393e-01f, 4.13707793e-02f, -5.64613268e-02f, 1.85441926e-01f, -1.12690613e-01f,
  1.71319451e-02f, 2.81549960e-01f, -1.19905673e-01f, 1.21307038e-01f, 1.50894970e-01f, 2.83375233e-01f, -8.45516771e-02f, 1.66522548e-01f, 3.61668356e-02f, 1.33967206e-01f,
  2.58576810e-01f, 1.55126723e-02f, -2.11276729e-02f, 7.15998411e-02f, -2.42944807e-02f, -7.05291480e-02f, 8.34213942e-02f, -9.09092650e-02f, -1.41546443e-01f, 1.65156871e-02f,
  1.84608102e-02f, 7.06209540e-02f, -1.39615089e-01f, -1.23094060e-02f, -7.60312974e-02f, 9.68398899e-02f, -3.62175666e-02f, 9.91506726e-02f, -1.27935037e-01f, 5.75758331e-02f,
  -1.46307936e-02f, -5.03398851e-02f, 1.21394150e-01f, 4.44737636e-02f, -1.32523969e-01f, -1.14810698e-01f, -5.36203198e-02f, 1.23097055e-01f, -7.30270892e-02f, 1.81863606e-01f,
  -7.90941641e-02f, -2.30475259e-03f, 1.41016066e-01f, 3.84658650e-02f, -9.66535360e-02f, -5.01642860e-02f, 1.19143911e-01f, -4.25983453e-03f, -3.63652743e-02f, 2.19961777e-01f,
  8.49199668e-02f, 2.99509138e-01f, 2.41331961e-02f, 1.54081121e-01f, 2.06070527e-01f, 4.95058596e-02f, 9.68244746e-02f, -6.07710481e-02f, -1.96450993e-01f, -5.08345924e-02f,
  1.41774938e-01f, 6.65080324e-02f, 2.59812307e-02f, 5.26154274e-03f, 1.95410803e-01f, 1.23526193e-01f, 1.29664736e-02f, -4.44824360e-02f, 1.95250884e-02f, 3.24088246e-01f,
  -1.75842166e-01f, -5.98047115e-02f, -4.92600575e-02f, -2.44688261e-02f, 2.47460902e-02f, 1.48035079e-01f, -1.14232795e-02f, -1.43050894e-01f, 3.54568623e-02f, 9.52285528e-02f,
  -2.23766729e-01f, -2.09046807e-02f, 1.98732629e-01f, -2.69905068e-02f, 1.05520658e-01f, -8.90241861e-02f, 1.56649962e-01f, 1.06458783e-01f, -7.22343773e-02f, -1.82068318e-01f,
  -2.78460942e-02f, -2.21088812e-01f, 1.00273564e-02f, -2.20039502e-01f, -6.98058009e-02f, 5.73940985e-02f, -2.87436265e-02f, 1.31423473e-01f, -1.83056191e-01f, -3.13539624e-01f,
  -9.77292135e-02f, -1.75405014e-02f, -2.65345991e-01f, -2.17307687e-01f, -2.95321912e-01f, -1.32496491e-01f, -3.32634263e-02f, -5.99343032e-02f, 6.68420643e-02f, -2.30412498e-01f,
  -3.15439813e-02f, -2.48388797e-01f, -1.00148350e-01f, 1.82928871e-02f, 9.05313343e-02f, -6.09272569e-02f, 1.48640350e-01f, -9.06280354e-02f, -1.54879987e-01f, 1.23071454e-01f,
  -5.62683120e-02f, -1.53457016e-01f, 1.40048146e-01f, -2.37940013e-01f, -5.84837720e-02f, -2.99047410e-01f, 1.21775627e-01f, 1.27445728e-01f, 1.36989057e-01f, -8.57656896e-02f,
  -2.54482329e-01f, -6.28289860e-03f, -1.08304145e-02f, 6.03330284e-02f, -1.87213086e-02f, 9.53193828e-02f, 9.78871584e-02f, -1.81641579e-02f, 2.90724516e-01f, -3.25447209e-02f,
  -2.66589016e-01f, 9.61473733e-02f, -2.36295331e-02f, -4.10940088e-02f, -1.16646253e-01f, -1.28068134e-01f, 2.57304870e-02f, 6.77481964e-02f, 1.92528725e-01f, 2.34762356e-01f,
  8.28900486e-02f, -1.80224851e-01f, -1.75127275e-02f, 6.42682388e-02f, -9.25481692e-02f, -2.49658331e-01f, 1.38799809e-02f, -1.10273287e-02f, 1.98948443e-01f, 1.34870023e-01f,
  -9.32750329e-02f, 1.03429288e-01f, 1.72140766e-02f, 7.92214274e-02f, -4.38037999e-02f, -1.31409531e-02f, -1.65807694e-01f, -2.16313839e-01f, -8.42118338e-02f, 4.44830507e-02f,
  -5.30941486e-02f, 1.13326058e-01f, 8.33888054e-02f, 1.04535609e-01f, 4.94336113e-02f, 9.57170203e-02f, 5.89982048e-02f, -3.59480679e-02f, -6.07755147e-02f, -2.25757152e-01f,
  1.22377850e-01f, 1.48077294e-01f, 7.79030249e-02f, 1.83053672e-01f, -1.91655308e-01f, 1.05112836e-01f, 1.98291034e-01f, 1.17658585e-01f, -8.44357535e-02f, -4.34458256e-02f,
  2.75811166e-01f, -2.07201287e-01f, 8.78154710e-02f, -4.86944467e-02f, 2.57830769e-01f, 4.43916917e-02f, 5.75744323e-02f, -2.90597565e-02f, -1.44514620e-01f, 9.66020674e-02f,
  5.27373515e-02f, 1.21505268e-01f, -1.36595070e-02f, 1.57751497e-02f, -1.42289668e-01f, 2.78222710e-01f, -1.97627962e-01f, -9.45113748e-02f, -6.15432262e-02f, -1.67780593e-01f,
  -2.26915658e-01f, 9.74682719e-02f, 1.33908913e-01f, -3.97566073e-02f, -8.35621804e-02f, 9.23681185e-02f, 2.17869552e-03f, 5.04027270e-02f, 2.07025651e-02f, -1.11806825e-01f,
  1.36494443e-01f, 2.98765744e-03f, 1.82678998e-01f, 1.05456270e-01f, -2.63588428e-01f, -9.38552469e-02f, 2.31826603e-02f, 5.90915829e-02f, -2.86050737e-01f, -1.77075174e-02f,
  -1.34772509e-01f, 1.02090962e-01f, 9.13359225e-02f, -8.88428465e-02f, -1.35339096e-01f, -3.00381035e-01f, -2.48877034e-01f, -3.20159823e-01f, -8.23047757e-02f, -7.89401606e-02f,
  -2.50947565e-01f, 7.56120682e-02f, 8.19017515e-02f, -3.48395437e-01f, -9.90016013e-02f, -1.05314568e-01f, -9.73552391e-02f, 1.91386715e-01f, 2.11182952e-01f, 4.97243330e-02f,
  -7.07101598e-02f, 1.02302626e-01f, -6.05942719e-02f, 2.64387876e-01f, -2.70507485e-02f, -1.31877530e-02f, 1.22017330e-02f, -7.94308782e-02f, 1.98294029e-01f, 2.25019902e-02f,
  1.51481032e-01f, 1.40482128e-01f, -2.36096978e-03f, -6.87478110e-02f, -1.67596132e-01f, 2.54011542e-01f, 1.99534297e-01f, 1.37830824e-01f, -7.95040131e-02f, -1.97089408e-02f,
  -5.71551099e-02f, 1.95190478e-02f, 6.75690249e-02f, -2.14523062e-01f, -1.53070956e-01f, 2.65098870e-01f, -8.45295563e-03f, -2.37434842e-02f, -3.39000635e-02f, 7.14079663e-02f,
  1.32730067e-01f, 1.22545406e-01f, -1.20119333e-01f, -2.97561772e-02f, 8.17915276e-02f, 1.92933083e-01f, -4.34416533e-02f, 1.31973088e-01f, 2.55641411e-03f, -2.31314523e-04f,
  -1.03004433e-01f, -5.98052070e-02f, -1.86212525e-01f, 1.23374015e-02f, -1.77859440e-01f, -6.27324879e-02f, -1.72251120e-01f, -1.94622248e-01f, -2.95601301e-02f, -1.46050364e-01f,
  1.97143368e-02f, -1.87724873e-01f, -2.70438164e-01f, -2.59525646e-02f, -1.90953597e-01f, 7.39461230e-03f, -8.16508308e-02f, 1.53418127e-02f, 1.57054141e-02f, -1.31047919e-01f,
  -1.94464818e-01f, 1.99004292e-01f, 3.30713838e-01f, 7.70077482e-02f, 5.99018037e-02f, 8.57870951e-02f, 7.73624852e-02f, -2.95129549e-02f, -1.75179824e-01f, -7.11300969e-02f,
  1.10518225e-01f, 3.97270955e-02f, -3.97390686e-02f, 4.08635065e-02f, 1.76523235e-02f, 1.10192291e-01f, 3.49035338e-02f, 6.43024780e-03f, -7.00995252e-02f, 8.78601670e-02f,
  6.86322078e-02f, -2.22412243e-01f, -1.81096241e-01f, 5.22645563e-02f, 2.57426184e-02f, -8.37385654e-02f, 1.60928905e-01f, 5.09886444e-02f, -1.29623204e-01f, 1.86125532e-01f,
  -1.40647322e-01f, 8.56983066e-02f, -2.82566845e-01f, -1.41028911e-01f, -1.24595314e-01f, 7.82712176e-02f, 7.55053759e-02f, 1.28384441e-01f, -2.25154027e-01f, -1.15865283e-02f,
  -2.39130929e-01f, -1.18468046e-01f, -5.67976153e-03f, 2.00805962e-01f, 2.64012720e-02f, -2.34889194e-01f, -1.65394455e-01f, -2.00724080e-02f, 2.27324180e-02f, -1.00191765e-01f,
  -9.14302096e-03f, 2.34352961e-01f, -9.82469618e-02f, 3.90543789e-02f, 1.82161197e-01f, -6.51872158e-02f, 6.64382875e-02f, 2.52993871e-02f, -2.70293579e-02f, 1.51504308e-01f,
  2.64090091e-01f, -6.39601471e-03f, -2.51589805e-01f, 1.30517483e-01f, -9.40392092e-02f, -8.43672231e-02f, 1.85655072e-01f, 1.15782507e-01f, 2.38163814e-01f, 3.76565456e-01f,
  -8.76901895e-02f, -6.34445995e-02f, -1.00345112e-01f, -2.84993481e-02f, -7.82584623e-02f, -1.14132151e-01f, -5.56277521e-02f, -1.61949359e-02f, -1.06159814e-01f, 3.00905909e-02f,
  9.22537223e-02f, 3.80445458e-03f, -9.23824310e-02f, -6.77603483e-02f, 6.92633260e-03f, -6.42708838e-02f, -1.47801310e-01f, -1.35327846e-01f, -9.40643027e-02f, 1.36562111e-02f,
  -1.93217307e-01f, 1.27608329e-01f, -2.05803424e-01f, 2.11116150e-01f, 2.22517073e-01f, -1.85072005e-01f, -2.17106447e-01f, -4.77653407e-02f, -1.09689943e-01f, 4.05719988e-02f,
  -2.10365914e-02f, 6.23322986e-02f, -2.87710354e-02f, -2.12509688e-02f, 2.72474978e-02f, 2.47081984e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.58706689e-01f, 7.60699958e-02f, -9.24680158e-02f, 1.35837242e-01f, 3.63057494e-01f, 1.79113865e-01f, 3.79449338e-01f, 2.44854704e-01f, 1.23127192e-01f, -3.81194592e-01f,
  -1.89457297e-01f, 1.06596589e-01f, -1.20753959e-01f, -2.91259050e-01f, 1.50931165e-01f, 2.02698126e-01f, 2.40136944e-02f, -1.67015955e-01f, 5.96840382e-02f, 2.57556975e-01f,
  3.04270983e-01f, 1.08705975e-01f, 1.01726882e-01f, 2.31049340e-02f, -1.39189497e-01f, 3.03806394e-01f, -1.09234892e-01f, -4.90517169e-02f, 2.21507356e-01f, 2.54227132e-01f,
  2.64434308e-01f, 3.62574756e-01f, -2.33464792e-01f, 1.54046491e-01f, 2.40782529e-01f, 1.25002265e-01f, 2.24716336e-01f, 3.76734436e-01f, -2.19392210e-01f, 1.07677775e-02f,
  -5.22179231e-02f, 1.24820717e-01f, -1.90096155e-01f, 2.43977662e-02f, -1.27030089e-01f, -2.26319432e-01f, 2.62608558e-01f, 4.62574922e-02f, -1.30080935e-02f, -2.23588169e-01f,
  9.05840769e-02f, -2.02449784e-01f, 7.88255185e-02f, -4.59538490e-01f, -2.53215075e-01f, 1.74784765e-01f, 1.51580527e-01f, -3.18684161e-01f, -7.61222094e-02f, -5.52502275e-02f,
  -4.14864197e-02f, -2.65193731e-01f, -2.17292178e-02f, 8.53479058e-02f, -4.09779110e-04f, -2.20496170e-02f, -1.37780188e-02f, -3.66873071e-02f, -8.82505178e-02f, -7.95965642e-02f,
  -1.15950949e-01f, -1.00727707e-01f, -1.22770660e-01f, -3.04620657e-02f, 4.09984216e-02f, 6.22075386e-02f, 1.40764460e-03f, -8.20274428e-02f, 4.60126139e-02f, -2.08726823e-02f,
  7.98602551e-02f, -1.23520568e-02f, 1.22887991e-01f, 1.06071517e-01f, -2.21271068e-02f, -5.77001609e-02f, 3.77370343e-02f, -5.91139030e-03f, 8.78132358e-02f, 3.25051509e-02f,
  1.19962499e-01f, 2.28691678e-02f, 1.34283245e-01f, 1.30605474e-01f, -1.45653263e-01f, -1.34645656e-01f, -2.26181015e-01f, -1.83924218e-03f, -1.17376350e-01f, -1.89055540e-02f,
  1.31692052e-01f, 1.53381407e-01f, 4.41408381e-02f, -2.05197521e-02f, 6.05468964e-03f, -9.58619118e-02f, -1.02717549e-01f, 2.33220961e-02f, 9.80859101e-02f, -2.64374074e-02f,
  6.85306042e-02f, -1.01934396e-01f, -1.31735280e-02f, 1.52919948e-01f, 1.42129034e-01f, 1.45077482e-01f, 1.97450131e-01f, -1.49355620e-01f, -1.43118903e-01f, 1.98495120e-01f,
  -1.01942189e-01f, -1.41241038e-02f, 5.79995364e-02f, -3.09428060e-03f, 2.23257169e-02f, -1.91740207e-02f, 6.18894137e-02f, 5.90494946e-02f, -1.09556034e-01f, 1.56618759e-01f,
  1.51532412e-01f, -8.99593383e-02f, 1.94820523e-01f, 4.43944812e-01f, 1.43762663e-01f, 1.04344331e-01f, 1.58113480e-01f, 4.04224336e-01f, 4.89608459e-02f, -1.91260591e-01f,
  -2.20606461e-01f, -1.77002832e-01f, 1.03409374e-02f, 2.01889366e-01f, -2.53235519e-01f, 2.96775788e-01f, 2.44627923e-01f, 1.46924123e-01f, -3.80398840e-01f, 1.92625806e-01f,
  2.72696346e-01f, -8.81951302e-02f, -1.45105630e-01f, -1.30109787e-01f, -5.14125705e-01f, -6.43078163e-02f, 1.39610916e-01f, 3.00562799e-01f, -4.85693872e-01f, 3.16614449e-01f,
  -1.33893445e-01f, -5.10426164e-02f, -6.88281953e-02f, 4.86420840e-02f, -3.76021206e-01f, 3.68667990e-02f, -5.53122796e-02f, 1.08202815e-01f, 3.86557775e-03f, 1.30402725e-02f,
  -1.08879931e-01f, 4.46167327e-02f, 2.15182841e-01f, 1.21661052e-01f, 3.75327691e-02f, -7.29453191e-03f, -6.08474463e-02f, -2.81890005e-01f, 3.35137427e-01f, -8.55446886e-03f,
  -1.41482696e-01f, -1.99725032e-01f, 9.31234956e-02f, 1.74244463e-01f, 1.30675599e-01f, -1.80695322e-03f, 5.99769317e-02f, 5.79919443e-02f, 2.16558009e-01f, 2.49309968e-02f,
  -5.09199128e-02f, 2.07799539e-01f, 8.06981772e-02f, -8.33331943e-02f, 2.69660782e-02f, 1.72389209e-01f, 7.15438128e-02f, 4.26294506e-02f, 9.84870866e-02f, 1.41099796e-01f,
  2.87669271e-01f, -4.26171213e-01f, -2.08193809e-01f, 9.53160524e-02f, -6.04954585e-02f, -2.76351929e-01f, 2.30210334e-01f, -2.92532265e-01f, -3.01901773e-02f, -1.92651317e-01f,
  1.34193869e-02f, -2.29037061e-01f, 3.50705624e-01f, 2.69361496e-01f, -1.53980330e-01f, 1.61053464e-01f, -2.61437178e-01f, 2.51676023e-01f, 9.36114714e-02f, 7.01046512e-02f,
  1.66216835e-01f, -5.13306148e-02f, 5.06402552e-01f, -9.66290832e-02f, -1.12254508e-01f, -1.64087281e-01f, 5.27171075e-01f, 7.31853470e-02f, 5.04061401e-01f, 2.29618147e-01f,
  -1.24499157e-01f, 1.60022138e-03f, -8.36146474e-02f, 8.53302553e-02f, -6.47407444e-03f, 1.76832631e-01f, 4.19435352e-02f, 8.92681479e-02f, 1.19069144e-01f, -5.59440926e-02f,
  -1.09877147e-01f, 2.17217565e-01f, -1.06687233e-01f, 1.08485175e-02f, 1.42691836e-01f, 1.74516156e-01f, 2.97288895e-02f, 1.41511589e-01f, -4.62436117e-02f, -1.28557533e-01f,
  4.54836786e-02f, 1.64323792e-01f, 9.45551917e-02f, -2.21217170e-01f, 2.21776694e-01f, 1.72092140e-01f, -3.29110861e-01f, -2.62488425e-01f, -4.10537161e-02f, 7.40961805e-02f,
  -1.08987696e-01f, 1.10408135e-01f, 1.23786747e-01f, 4.48502265e-02f, 1.59766972e-01f, -2.05055535e-01f, -2.91059613e-01f, 2.86624432e-02f, 1.20308325e-01f, -1.27948761e-01f,
  4.72070230e-03f, -1.40941069e-01f, -1.15597382e-01f, 4.87120412e-02f, -6.51081651e-02f, -1.82990596e-01f, 1.97152019e-01f, 2.20265731e-01f, -1.46389067e-01f, 6.62413463e-02f,
  -2.36464813e-02f, 1.35703713e-01f, 2.03313917e-01f, 2.95604706e-01f, 3.65354903e-02f, 7.73015991e-02f, 2.96724916e-01f, -1.65298283e-01f, -5.04731536e-02f, -2.33748317e-01f,
  4.37157273e-01f, -3.11721303e-02f, 1.49080485e-01f, -2.55531192e-01f, -5.54081500e-02f, -4.89741899e-02f, -1.31218389e-01f, 2.37212881e-01f, -1.48325264e-01f, 2.07181722e-01f,
  3.25068742e-01f, 1.92852318e-01f, -1.44445747e-01f, 3.15789469e-02f, -9.44394618e-02f, 4.63128835e-01f, -3.14649284e-01f, 2.81311929e-01f, -2.14218155e-01f, 1.57851335e-02f,
  1.64572448e-01f, 1.31581752e-02f, 6.61125481e-02f, 4.38576713e-02f, -5.95594719e-02f, -1.08769005e-02f, 2.49655887e-01f, 1.26478389e-01f, 1.25682667e-01f, 1.97484627e-01f,
  1.94456711e-01f, 1.44242048e-01f, 2.44227841e-01f, 1.36793792e-01f, 1.27316296e-01f, -8.34073499e-02f, -1.82305962e-01f, -3.19386125e-02f, -9.23127681e-02f, -1.50660742e-02f,
  1.23126201e-01f, 2.62735695e-01f, 1.72776788e-01f, -2.06483170e-01f, 1.13700286e-01f, -9.87716988e-02f, 3.50659907e-01f, -8.68749544e-02f, 4.99460511e-02f, -3.23115289e-01f,
  1.19681368e-02f, 9.53970850e-02f, -1.42744035e-01f, 1.29288793e-01f, -8.45195428e-02f, 3.38394135e-01f, 3.93828630e-01f, 1.64329946e-01f, 2.24968478e-01f, -3.35951075e-02f,
  2.52146751e-01f, -1.91003904e-01f, -5.03625453e-01f, -1.65662412e-02f, 7.10004121e-02f, -1.53846860e-01f, 3.16477507e-01f, -2.06571996e-01f, 6.21324405e-02f, -9.36228037e-03f,
  2.47598570e-02f, 2.53362238e-01f, -2.95132279e-01f, -5.54094799e-02f, -2.04957664e-01f, 1.68068081e-01f, 2.66299993e-01f, 1.29341394e-01f, -8.22992250e-02f, 6.49950700e-03f,
  -1.10650808e-01f, 3.10256295e-02f, 1.09564900e-01f, 1.63762063e-01f, -2.33950801e-02f, -5.99849261e-02f, 1.65711343e-01f, 1.12049386e-01f, 1.27623439e-01f, 1.89093649e-01f,
  7.61635825e-02f, -2.35164203e-02f, 3.08441222e-01f, 1.65102482e-01f, 5.33695556e-02f, -1.00097291e-01f, 2.48466674e-02f, 1.59910828e-01f, -7.02028424e-02f, 2.10074671e-02f,
  -1.58014357e-01f, -2.03160226e-01f, -8.97437707e-02f, 9.82254967e-02f, 1.89299151e-01f, 1.81482002e-01f, 1.44091681e-01f, 2.82960564e-01f, 2.35747844e-01f, -1.10965539e-02f,
  2.74365544e-01f, 3.03193256e-02f, 1.12566337e-01f, -1.88832395e-02f, -8.91954824e-02f, 1.42361715e-01f, 3.77888173e-01f, 8.93972963e-02f, -2.69841254e-01f, -1.93029359e-01f,
  -1.02373101e-01f, -8.85767564e-02f, -1.15944751e-01f, 1.38791919e-01f, 5.82992099e-02f, -3.36326212e-01f, 1.34326920e-01f, -8.82253647e-02f, 9.96851251e-02f, -3.68711442e-01f,
  -3.11912149e-01f, -2.61307836e-01f, 3.22051183e-03f, 3.83189395e-02f, 2.66726613e-01f, 9.94009711e-03f, -2.03239202e-01f, 8.79133120e-02f, 1.66125730e-01f, 1.14648327e-01f,
  -2.45071262e-01f, -2.35945620e-02f, -8.59192982e-02f, -4.17010896e-02f, 3.44240218e-01f, 3.83889414e-02f, -5.83722666e-02f, -2.40680814e-01f, 3.09058160e-01f, -5.02943397e-02f,
  4.33149608e-03f, -4.51522544e-02f, -4.64733541e-02f, -3.11621018e-02f, 1.93157732e-01f, -1.27838880e-01f, 7.01653585e-02f, 3.67321819e-02f, 3.69635612e-01f, 9.48651955e-02f,
  2.10787117e-01f, -4.08721939e-02f, 9.37569812e-02f, 5.23772463e-02f, -3.50640476e-01f, -2.62460001e-02f, -2.94043142e-02f, -1.84568867e-01f, -1.72619492e-01f, 3.78691107e-01f,
  2.93839306e-01f, 1.78608701e-01f, 2.28290290e-01f, 2.20568359e-01f, 2.03264996e-01f, -2.30002105e-01f, 2.53227413e-01f, -4.52157930e-02f, 3.26194048e-01f, 1.67488068e-01f,
  -4.31187034e-01f, -1.76415294e-01f, 2.28776485e-01f, 3.61980081e-01f, 7.52927065e-01f, 1.68290332e-01f, -2.51169391e-02f, -3.04890603e-01f, 4.92257923e-01f, -2.48770535e-01f,
  -2.63210267e-01f, -9.81060490e-02f, 1.53378174e-01f, -7.27515370e-02f, 1.13082074e-01f, -7.24076554e-02f, 1.49482816e-01f, -1.08954124e-01f, 1.55756092e-02f, -2.64533274e-02f,
  3.62052321e-01f, -4.54696901e-02f, -2.38723680e-03f, 2.27287009e-01f, 7.37256259e-02f, 6.63869977e-02f, -3.42534073e-02f, 3.35128725e-01f, -5.38379923e-02f, -1.16484724e-01f,
  1.84030854e-03f, 3.68871182e-01f, 9.43166465e-02f, -1.78397492e-01f, 1.23197630e-01f, 6.51449412e-02f, -6.36512265e-02f, 1.67706743e-01f, 1.95853144e-01f, 3.19272466e-02f,
  3.72188956e-01f, -1.10903550e-02f, -3.33886474e-01f, 1.53227331e-04f, 1.51990531e-02f, 1.42253473e-01f, -8.83764029e-02f, 3.38663608e-01f, 7.62385130e-02f, -1.62705109e-01f,
  1.12220235e-01f, 1.23965263e-01f, 5.85628748e-02f, -3.15836877e-01f, 5.85226417e-02f, -3.09704393e-01f, -1.14157014e-01f, -5.31265400e-02f, -6.22729920e-02f, -1.10153951e-01f,
  3.86524908e-02f, -1.84333473e-01f, -1.10930391e-01f, -4.14522737e-03f, 3.46405096e-02f, -5.41073196e-02f, 2.46199429e-01f, 3.06980796e-02f, -1.18482552e-01f, 2.39392176e-01f,
  -1.96025684e-01f, -3.68922278e-02f, -1.18893482e-01f, -2.51721829e-01f, -6.75106719e-02f, -4.04233932e-01f, -2.58887708e-01f, -1.18864179e-02f, -5.40925525e-02f, -2.35422738e-02f,
  4.36631925e-02f, -5.51410951e-02f, -1.90794870e-01f, -1.20793032e-02f, 6.46127462e-02f, 3.57233733e-02f, 3.54533255e-01f, -1.95583463e-01f, -1.36212498e-01f, -1.99312922e-02f,
  2.47356206e-01f, -2.58860320e-01f, 2.19500676e-01f, 2.61629730e-01f, 9.10632089e-02f, 1.40863791e-01f, -8.30865130e-02f, 1.71355292e-01f, -6.66715950e-02f, 1.43380091e-01f,
  -4.31416109e-02f, -1.43045159e-02f, 1.42586580e-03f, 2.39037722e-01f, -1.13188900e-01f, -4.32190560e-02f, 2.01511711e-01f, -1.54749125e-01f, 2.41613969e-01f, -3.78106944e-02f,
  2.11478278e-01f, 4.52082336e-01f, -5.81989847e-02f, -5.60811646e-02f, 1.43181592e-01f, 8.21490660e-02f, -6.92876801e-02f, 5.35865985e-02f, -3.80107537e-02f, 1.20607605e-02f,
  2.76554555e-01f, 1.85418963e-01f, 1.38301522e-01f, -2.29807302e-01f, 2.91147351e-01f, -1.53502315e-01f, -2.37779953e-02f, 7.08405748e-02f, 1.16566755e-01f, -3.34726661e-01f,
  -2.27307621e-02f, 1.03261873e-01f, 1.04077421e-01f, -7.50805810e-02f, 2.42835982e-03f, -1.17449515e-01f, -6.56702816e-02f, -2.34518513e-01f, -2.46092498e-01f, 2.31845472e-02f,
  2.03460287e-02f, -6.48495257e-02f, -3.61684471e-01f, -4.17677388e-02f, -6.45775944e-02f, -7.59969652e-02f, 3.48579645e-01f, -1.01016253e-01f, 2.37943918e-01f, -7.30590075e-02f,
  2.84337878e-01f, 6.51548803e-02f, -8.11885521e-02f, -1.08665690e-01f, -4.72622216e-02f, -4.39646579e-02f, 1.98264539e-01f, -4.57107812e-01f, -1.48758054e-01f, 2.46209636e-01f,
  1.58307254e-01f, 1.53175086e-01f, 1.14200808e-01f, 1.94647908e-01f, -5.46701811e-02f, -3.31872478e-02f, 2.54889011e-01f, 6.15707189e-02f, 2.95358896e-01f, 5.16524212e-03f,
  3.53052229e-01f, -2.27846295e-01f, 1.76629350e-01f, -4.52143550e-01f, 4.66774911e-01f, -1.12857698e-02f, -2.26985309e-02f, 1.15237609e-01f, 1.99881531e-02f, 4.01146971e-02f,
  2.05995828e-01f, 3.45531143e-02f, 1.25861079e-01f, 3.44799787e-01f, 5.05536683e-02f, -1.40348330e-01f, 3.72894228e-01f, 3.79952043e-01f, -5.17763615e-01f, 4.16674882e-01f,
  -2.78457195e-01f, -3.53094608e-01f, 5.35570569e-02f, -9.68812332e-02f, -8.99152830e-02f, -2.87904769e-01f, -1.68345138e-01f, -8.83872658e-02f, -5.07632941e-02f, 6.51204661e-02f,
  -1.87931329e-01f, 1.29710391e-01f, -2.35665098e-01f, 3.46258353e-03f, -4.44144249e-01f, -1.39885783e-01f, 4.36853766e-02f, -1.87789157e-01f, 1.48358464e-01f, -6.27192855e-02f,
  -6.54130876e-02f, -5.69018014e-02f, -2.11670116e-01f, -4.65154499e-02f, -4.06094044e-02f, -2.94350415e-01f, 3.89816612e-01f, 1.28546879e-01f, 4.75688428e-02f, -2.72512645e-01f,
  2.04551890e-01f, -1.72860071e-01f, 2.98472285e-01f, -1.67970940e-01f, -9.91704687e-02f, 1.03409141e-01f, -1.31711334e-01f, -2.81974450e-02f, -3.30653116e-02f, 3.85517068e-02f,
  1.07445549e-02f, 9.24983844e-02f, 2.00799286e-01f, -1.53182879e-01f, 3.54997486e-01f, 1.78744555e-01f, -6.81753382e-02f, 9.48317796e-02f, -1.39917329e-01f, 1.97850876e-02f,
  9.92906094e-02f, 2.07782835e-01f, -9.94561054e-03f, -8.29304904e-02f, -8.01915154e-02f, 1.80535600e-01f, 2.31327489e-03f, 1.86828747e-01f, 7.83445090e-02f, 2.03307554e-01f,
  -1.03228595e-02f, 4.80774604e-02f, 6.78845048e-02f, -1.57924555e-02f, 1.22249283e-01f, 1.89179018e-01f, 2.56981477e-02f, 2.92921007e-01f, -2.50507444e-01f, -4.18404350e-03f,
  -1.81932207e-02f, -1.56918764e-01f, 3.11826020e-01f, 6.27038181e-02f, 2.49685213e-01f, -1.73994809e-01f, 2.84396168e-02f, 1.64966255e-01f, 5.40294826e-01f, 2.17654854e-02f,
  2.02152461e-01f, 1.48147736e-02f, -2.33039618e-01f, 3.36833060e-01f, 1.71606094e-01f, 1.52381957e-01f, 2.15292424e-01f, 1.99560627e-01f, -2.51423508e-01f, 1.74048126e-01f,
  -1.03497207e-01f, 7.89800752e-03f, -4.90619510e-01f, 1.17312036e-01f, 6.77800700e-02f, -3.37642953e-02f, 3.92473526e-02f, -1.71638820e-02f, 1.90680206e-01f, 1.15569465e-01f,
  3.36445540e-01f, -6.63376078e-02f, 8.38387758e-02f, -1.81504235e-01f, 1.16183564e-01f, -3.20675194e-01f, 1.28773466e-01f, 1.98429614e-01f, 8.87362808e-02f, -1.42929293e-02f,
  8.35369825e-02f, -2.85672699e-03f, 7.24027455e-02f, 1.40321627e-01f, -1.10599793e-01f, -1.96302146e-01f, -2.15495914e-01f, 1.47184744e-01f, 2.01288424e-03f, -3.42449918e-02f,
  2.80321866e-01f, 1.83755960e-02f, -3.01279109e-02f, -4.75766696e-02f, 2.93741107e-01f, -1.84045419e-01f, -5.57815395e-02f, -4.45165664e-01f, -9.17294025e-02f, -1.66035548e-01f,
  -2.41055503e-01f, -3.31888080e-01f, 3.02224070e-01f, 3.29435080e-01f, 1.86605826e-01f, 5.32533601e-03f, -1.87630787e-01f, 1.69119462e-01f, 1.74933691e-02f, -2.56619513e-01f,
  -5.28315425e-01f, -2.74920434e-01f, -5.01491547e-01f, 5.15350401e-02f, -1.47880524e-01f, -1.74507365e-01f, 1.14270940e-01f, -8.94069150e-02f, -5.07919006e-02f, 7.59355277e-02f,
  1.80464834e-01f, -6.38729036e-02f, 2.02634826e-01f, 7.15602860e-02f, 1.73440501e-01f, -9.86108333e-02f, 2.93459922e-01f, -2.84059703e-01f, 1.24978893e-01f, -2.97388613e-01f,
  1.41151650e-02f, 1.64165333e-01f, -6.92787990e-02f, -9.80206951e-02f, -1.99167088e-01f, 2.54192084e-01f, 3.15550044e-02f, 3.28614831e-01f, 1.15444683e-01f, 3.24579656e-01f,
  4.75566909e-02f, -9.67612490e-02f, 1.88424066e-01f, -4.76927571e-02f, -1.81002378e-01f, 2.40380734e-01f, 1.60786137e-01f, 5.30565344e-02f, 1.93006948e-01f, 9.05134082e-02f,
  9.78267118e-02f, -4.10240352e-01f, -2.13448927e-01f, 2.18467489e-02f, -1.77928936e-02f, -2.59402275e-01f, 1.90509349e-01f, -3.41238171e-01f, 5.23523241e-02f, -3.03477973e-01f,
  6.83929306e-03f, -4.93234783e-01f, 2.97757953e-01f, 1.63037583e-01f, 1.86743196e-02f, 1.97371200e-01f, 3.53958309e-02f, 8.01964253e-02f, -2.33524144e-01f, 8.82911310e-02f,
  1.43349811e-01f, 1.79590136e-01f, 6.23133719e-01f, -1.17741704e-01f, -9.16756392e-02f, -2.61677444e-01f, 4.15048182e-01f, 5.13361581e-02f, 1.12324908e-01f, 2.95718998e-01f,
  -3.14109355e-01f, 1.88936502e-01f, 5.64317219e-02f, 1.85063377e-01f, -1.49498791e-01f, 3.06463778e-01f, -1.84791327e-01f, -1.93901565e-02f, 9.20621082e-02f, -7.45664760e-02f,
  -2.65968740e-01f, -1.76743001e-01f, 4.52161059e-02f, -1.24796540e-01f, -1.51362792e-02f, 7.60489181e-02f, -7.49475881e-02f, 3.37250084e-01f, 1.06748678e-01f, -3.09508860e-01f,
  1.23164922e-01f, 1.08461939e-01f, 1.47730723e-01f, -3.57296884e-01f, 2.09334061e-01f, 1.41650587e-01f, -1.50444165e-01f, 1.74630731e-01f, 1.49006695e-01f, 4.27653752e-02f,
  9.36377048e-02f, -1.70667395e-01f, 1.04267262e-01f, -1.67649239e-02f, -1.61871970e-01f, 2.29992256e-01f, -3.88495997e-02f, 1.43894494e-01f, 1.48445010e-01f, -1.18889615e-01f,
  -2.10468799e-01f, 6.10682275e-03f, 1.72407880e-01f, 9.47910771e-02f, 1.48405850e-01f, -1.87167898e-01f, -3.69469255e-01f, 2.91368086e-02f, -2.82634288e-01f, 1.42590076e-01f,
  7.01850057e-02f, 1.95470348e-01f, 1.18408784e-01f, 1.97662815e-01f, -2.54096985e-02f, 3.14308017e-01f, -1.68003619e-01f, 1.30874336e-01f, -2.33078331e-01f, -3.05544529e-02f,
  -5.31984977e-02f, -1.22835413e-01f, 3.63962650e-02f, -3.06044042e-01f, 1.03574961e-01f, 3.10678594e-02f, -8.22622627e-02f, 3.41893882e-01f, -3.78751218e-01f, -1.33118823e-01f,
  -1.47782892e-01f, 3.68454516e-01f, 2.83753872e-01f, -1.03771828e-01f, -6.93157911e-02f, 3.60588133e-01f, -2.65810013e-01f, 1.21493265e-01f, 1.21140778e-02f, -1.54884681e-01f,
  -8.70790705e-02f, -4.01455648e-02f, 2.03524664e-01f, 2.80390173e-01f, 5.62138706e-02f, 3.14331591e-01f, 1.14410289e-01f, 2.17787057e-01f, 9.02300403e-02f, 2.52623498e-01f,
  -2.93377768e-02f, -1.89422473e-01f, 5.67531921e-02f, 9.61098745e-02f, -5.17002568e-02f, 5.07184975e-02f, 5.21022007e-02f, 1.70145363e-01f, 1.71700701e-01f, -2.04609394e-01f,
  6.46195635e-02f, 3.35498936e-02f, -1.38876840e-01f, 1.77467868e-01f, 9.48895141e-02f, 1.09454289e-01f, 2.87022501e-01f, -4.40713018e-02f, 9.47497133e-03f, 7.57831261e-02f,
  2.42879558e-02f, -3.39730307e-02f, 2.17182651e-01f, -8.63292143e-02f, -2.63222456e-01f, 1.10297203e-01f, 1.29361063e-01f, 2.46014535e-01f, -1.67768940e-01f, -2.27886021e-01f,
  -1.08936064e-01f, -2.31533810e-01f, -5.68245798e-02f, 2.90252924e-01f, 6.06721640e-02f, -2.53848165e-01f, -1.20603569e-01f, -1.62907183e-01f, -6.40505701e-02f, 1.95265085e-01f,
  3.54743212e-01f, -1.05606891e-01f, -1.62306488e-01f, -1.03982925e-01f, 3.40172052e-01f, 3.29161763e-01f, -4.53738272e-01f, -1.16590582e-01f, -1.21208012e-01f, 1.16125934e-01f,
  2.75865406e-01f, 1.95756808e-01f, -3.93808931e-01f, -7.30819942e-04f, 4.45241392e-01f, -8.79376102e-03f, 1.31808087e-01f, 1.83045432e-01f, 1.24766916e-01f, -2.69655474e-02f,
  2.61067748e-01f, 1.32873937e-01f, 1.55662656e-01f, -5.95037751e-02f, -9.16465372e-02f, -1.74979299e-01f, 9.31050256e-02f, 5.17816804e-02f, 5.39278351e-02f, 2.24020794e-01f,
  5.67075796e-02f, 2.06557363e-02f, 2.04499364e-01f, -1.68006539e-01f, -1.35210559e-01f, -2.78677493e-01f, -9.65854153e-02f, -8.11969340e-02f, -1.14838950e-01f, 2.97064874e-02f,
  -1.84983432e-01f, -2.06402361e-01f, -1.41085148e-01f, 8.77140090e-02f, -3.85706909e-02f, -1.79411486e-01f, 3.06822002e-01f, -1.96456596e-01f, 1.41984299e-01f, -2.99815889e-02f,
  -1.73885748e-01f, 1.26203358e-01f, -1.60764486e-01f, -1.06674440e-01f, 4.71226610e-02f, -3.10516030e-01f, 3.36392343e-01f, -1.99772716e-01f, -2.30557639e-02f, -1.63236171e-01f,
  -9.94788185e-02f, -1.43419355e-01f, 8.77117179e-03f, -4.48222756e-02f, 1.73042849e-01f, -2.70691901e-01f, 1.32211208e-01f, -1.20397538e-01f, 5.29887199e-01f, 2.49118288e-03f,
  -6.92211911e-02f, 1.13153178e-03f, 2.05858365e-01f, -5.71235456e-02f, 2.84237534e-01f, -3.93257976e-01f, -2.79878557e-01f, 3.54192257e-02f, 6.72207773e-02f, 1.46825895e-01f,
  -1.02374002e-01f, -7.45064467e-02f, 3.69790271e-02f, 9.43455771e-02f, 6.26025870e-02f, 9.62912291e-02f, 2.15392709e-02f, 2.23240908e-02f, -9.72058326e-02f, -9.00848806e-02f,
  -2.81655312e-01f, -1.90615028e-01f, 5.77277504e-02f, -4.52141106e-01f, 3.09234679e-01f, 1.56114817e-01f, -1.73713297e-01f, -5.57634756e-02f, 1.41684011e-01f, -5.26168644e-01f,
  1.16758227e-01f, 2.51733482e-01f, -4.09793586e-01f, -3.80626976e-01f, 8.68224725e-02f, 1.98226064e-01f, -6.38336122e-01f, 1.92146450e-01f, -8.19871128e-02f, -2.87893206e-01f,
  -1.28300577e-01f, 1.80579245e-01f, -1.38488516e-01f, -2.28417426e-01f, -2.99946368e-01f, -2.41676018e-01f, 1.54137006e-02f, -2.41070092e-01f, -1.95025533e-01f, 3.28935474e-01f,
  9.90406349e-02f, 1.08893022e-01f, -5.25364935e-01f, 2.32523710e-01f, 7.27077350e-02f, -2.45221734e-01f, 1.15514331e-01f, 4.20250326e-01f, -1.24098100e-01f, 4.18333039e-02f,
  9.28622782e-02f, -1.58719078e-01f, 5.62227853e-02f, -1.38367459e-01f, 1.16760008e-01f, 2.33941209e-02f, 3.57048154e-01f, 2.39999354e-01f, 2.15578139e-01f, 3.60880673e-01f,
  5.17928898e-02f, 1.33418605e-01f, 8.76921788e-02f, -1.72912166e-01f, 3.22776549e-02f, -1.34716677e-02f, -8.70245099e-02f, 1.78757966e-01f, -2.80019566e-02f, 2.94995993e-01f,
  -1.56628817e-01f, -4.77869660e-02f, 7.64486268e-02f, -6.60965079e-03f, -1.98683828e-01f, -6.84614554e-02f, 2.72528946e-01f, 3.05911541e-01f, 3.57805878e-01f, -5.95669746e-02f,
  2.14241534e-01f, -1.26962200e-01f, -1.04957990e-01f, -1.24177411e-01f, -1.36403367e-01f, -3.39311481e-01f, 4.81152870e-02f, 5.55236936e-02f, -9.42260325e-02f, -1.74215285e-03f,
  1.59864593e-02f, 2.20481813e-01f, 1.01354621e-01f, 1.53402552e-01f, 4.99270469e-01f, -2.94908788e-02f, 3.41378041e-02f, -1.61348879e-01f, -4.61007774e-01f, -1.81839123e-01f,
  5.65440804e-02f, 8.55187103e-02f, 1.32165968e-01f, 3.27068239e-01f, -2.25704923e-01f, 5.27870834e-01f, 9.21529531e-02f, 3.89732242e-01f, 2.38215610e-01f, 5.38443506e-01f,
  -3.59735101e-01f, -6.04403764e-02f, 1.20907404e-01f, -1.23694770e-01f, -2.14653164e-01f, 1.65104225e-01f, -2.43126631e-01f, -1.27698943e-01f, 1.49936363e-01f, 8.89779720e-03f,
  -1.78202897e-01f, -4.59658653e-01f, 1.70743510e-01f, -3.37538272e-01f, 1.51474858e-02f, -1.18678957e-01f, -2.73002684e-01f, 1.75904617e-01f, -2.49506310e-02f, -4.04806405e-01f,
  8.26769099e-02f, -5.12872823e-02f, -9.96754244e-02f, -6.16704404e-01f, -4.32380214e-02f, 1.45729527e-01f, -2.33453706e-01f, -7.07178656e-03f, -2.28395358e-01f, -2.38703918e-02f,
  -2.97019958e-01f, -1.47905752e-01f, 5.15704751e-02f, 1.25607461e-01f, 1.51596785e-01f, -2.26543546e-01f, -1.55783236e-01f, -3.02889556e-01f, -6.75092563e-02f, -1.89926416e-01f,
  -2.14362562e-01f, -1.31417245e-01f, -1.45935649e-02f, -1.07409760e-01f, -2.09619105e-02f, -9.77318641e-03f, 6.05450943e-02f, -2.57815421e-01f, -2.41419494e-01f, 7.42363781e-02f,
  3.01262647e-01f, 1.80360571e-01f, -2.68843491e-02f, 1.66814569e-02f, 1.30827069e-01f, -1.78037718e-01f, -1.47101849e-01f, 8.64381120e-02f, 1.50053769e-01f, -4.29129601e-02f,
  -1.65093899e-01f, 2.51192123e-01f, 5.22732995e-02f, -1.50707811e-02f, 8.38324651e-02f, 1.52339235e-01f, -1.85111761e-01f, 9.79716629e-02f, 4.84410405e-01f, -1.73265010e-01f,
  -5.88645227e-03f, 1.40441015e-01f, -1.13897510e-01f, 3.59795503e-02f, 1.60942331e-01f, 1.58691943e-01f, -9.58854109e-02f, 2.84232825e-01f, -3.98386233e-02f, 4.71058607e-01f,
  -4.58976254e-02f, -2.98635900e-01f, -5.22077903e-02f, 2.87389886e-02f, 4.48427573e-02f, 6.05502427e-02f, -9.06302929e-02f, 1.89946264e-01f, -1.81033745e-01f, -6.82549477e-02f,
  -4.23941344e-01f, -1.02379009e-01f, -1.21782355e-01f, -1.29539203e-02f, -5.72735846e-01f, -1.84769094e-01f, 2.44404554e-01f, 1.11352041e-01f, 6.07360294e-03f, -1.17872708e-01f,
  6.62361905e-02f, -2.28375420e-01f, 1.17596328e-01f, 8.37010071e-02f, -3.55002761e-01f, -2.39291146e-01f, 3.02769449e-02f, 2.62465566e-01f, -1.49884641e-01f, -2.65202689e-04f,
  1.99261621e-01f, 9.03618149e-03f, -6.39367104e-02f, 3.57799917e-01f, -1.24589019e-01f, -6.81814849e-02f, 1.45966141e-03f, -7.75391329e-03f, 1.72273323e-01f, -9.28942263e-02f,
  1.48298405e-02f, 4.23452675e-01f, 4.24780369e-01f, 1.01644640e-04f, 1.91326961e-01f, -3.29615884e-02f, 7.71466419e-02f, 1.14054745e-02f, 9.85356867e-02f, 2.51202613e-01f,
  -7.27780163e-02f, 2.52007574e-01f, -4.48427126e-02f, 2.22413510e-01f, -7.85992667e-02f, 6.35682791e-02f, -8.77404138e-02f, 5.96349649e-02f, 1.66774631e-01f, 2.84228802e-01f,
  3.42771113e-02f, 6.46073520e-01f, 1.61044493e-01f, 2.00614668e-02f, 4.22508903e-02f, -1.08382121e-01f, 9.70321968e-02f, 9.93724912e-02f, -1.86963111e-01f, 2.41182834e-01f,
  1.32028252e-01f, 2.04614460e-01f, -2.71448255e-01f, 2.32140645e-01f, 8.87372494e-02f, 5.81049956e-02f, 2.48765270e-03f, -1.00437723e-01f, 4.61619496e-02f, 3.92317399e-02f,
  -1.02739275e-01f, 8.70188326e-02f, 1.13935471e-02f, -6.67301342e-02f, -7.86715746e-02f, 7.43922293e-02f, 3.01398654e-02f, 1.93709135e-02f, 4.36373614e-02f, -1.11235961e-01f,
  -3.53258587e-02f, 6.25301301e-02f, -4.47048107e-03f, -1.01084244e-02f, 1.28079563e-01f, 8.10655765e-03f, -1.81360841e-02f, 6.35891557e-02f, -5.75117348e-03f, -2.05126945e-02f,
  1.31437197e-01f, -2.67782491e-02f, 4.17660140e-02f, -1.14570200e-01f, -8.09835494e-02f, -2.78326441e-02f, 4.42309678e-02f, 1.07902445e-01f, -4.40756306e-02f, -1.99246164e-02f,
  1.50693029e-01f, 7.67277479e-02f, -7.27443323e-02f, -1.06020555e-01f, -1.10779725e-01f, -1.59608647e-01f, -3.71510126e-02f, 9.47825797e-03f, -4.50137770e-03f, 6.13346603e-03f,
  -6.46101981e-02f, -1.13894537e-01f, -6.76710457e-02f, -9.92114842e-03f, 5.40452357e-03f, -7.22380728e-02f, -8.50241482e-02f, 2.58707684e-02f, -1.50001645e-01f, 5.92972189e-02f,
  -5.88603392e-02f, -6.78147078e-02f, -7.96187371e-02f, 8.97584781e-02f, -4.79639368e-03f, -1.10562056e-01f, -1.02750555e-01f, -7.92383477e-02f, -1.78891104e-02f, 7.35254958e-02f,
  -6.89247772e-02f, 1.67176828e-01f, 1.43895805e-01f, 3.95255804e-01f, -1.53839681e-03f, 3.29642743e-02f, 1.85014024e-01f, 1.56863138e-01f, 1.85264513e-01f, 2.15220749e-02f,
  -3.28706950e-02f, 1.14404606e-02f, 1.63019702e-01f, -1.45489043e-02f, -7.68369855e-03f, 6.49245903e-02f, 1.61847234e-01f, -1.67031080e-01f, -4.91455384e-02f, 1.02542751e-01f,
  3.62558395e-01f, -1.57494530e-01f, -2.81508058e-01f, -5.38195251e-04f, -3.60451579e-01f, -9.90476161e-02f, -1.93666145e-02f, 1.34496912e-01f, -1.99848667e-01f, -8.41546804e-02f,
  -2.50047058e-01f, -1.31785810e-01f, 2.36043260e-01f, -8.44357461e-02f, -3.71566027e-01f, -7.33358562e-02f, -1.71176061e-01f, 1.88583419e-01f, 3.94171596e-01f, -1.76398963e-01f,
  -1.26779705e-01f, 2.32711047e-01f, 3.63729686e-01f, 2.17118293e-01f, 2.02974435e-02f, 5.42690381e-02f, 1.08455040e-01f, -1.86848164e-01f, 4.35672909e-01f, -5.01771346e-02f,
  -6.07368127e-02f, 1.14794314e-01f, 1.89020112e-01f, 1.19524404e-01f, 3.06187104e-02f, -3.76832522e-02f, -1.16627187e-01f, -1.89343452e-01f, 2.01166838e-01f, -2.18213573e-01f,
  -1.24790277e-02f, -1.57777928e-02f, -2.36861855e-02f, 1.33794188e-01f, 1.43151477e-01f, 7.78838098e-02f, 1.54654399e-01f, 3.37670058e-01f, 1.01795740e-01f, 2.19982088e-01f,
  -5.04112989e-03f, 3.89631599e-01f, -3.27211432e-02f, -3.14167500e-01f, -1.51462927e-01f, -1.93311960e-01f, -9.86701548e-02f, 2.26441938e-02f, -9.13125575e-02f, -3.68634127e-02f,
  2.43756801e-01f, -1.42056227e-01f, -3.29919815e-01f, -6.65419623e-02f, 2.22950518e-01f, -1.94444671e-01f, 2.16770083e-01f, -3.84991593e-03f, -2.45125517e-01f, -3.58712040e-02f,
  -5.61800562e-02f, 2.35440940e-01f, -1.31793678e-01f, -9.76695195e-02f, -1.62494361e-01f, -1.52162164e-01f, -2.33148396e-01f, -3.18622328e-02f, -3.22498411e-01f, 2.95289196e-02f,
  5.70409186e-02f, -2.31808364e-01f, -1.15398780e-01f, 1.62432298e-01f, -1.01422958e-01f, 5.38437255e-02f, 2.91387767e-01f, -1.59538418e-01f, 3.75584513e-01f, 8.85763541e-02f,
  3.76985282e-01f, -1.92627952e-01f, 1.97267681e-01f, -1.63759604e-01f, 7.21307993e-02f, -1.32074237e-01f, -2.45287359e-01f, 3.28407913e-01f, 2.86648013e-02f, 1.79807469e-01f,
  4.63066697e-02f, 3.41364235e-01f, 8.28027204e-02f, 2.12218583e-01f, -7.18406290e-02f, -8.42968526e-04f, 1.35382727e-01f, 1.47560805e-01f, 2.06930324e-01f, 1.05949879e-01f,
  -2.10601762e-01f, 2.40630150e-01f, 1.05095394e-01f, 2.15853915e-01f, 3.26431841e-02f, 8.06051791e-02f, -4.42471839e-02f, 6.99681938e-02f, -4.70463634e-02f, 1.52341351e-01f,
  2.40067765e-01f, 1.12200297e-01f, -1.58315226e-01f, 5.19058287e-01f, 2.68675387e-01f, -1.20818451e-01f, 4.53452356e-02f, 5.35821356e-02f, 1.72987878e-01f, 4.28018808e-01f,
  -9.79766399e-02f, 5.96866794e-02f, -2.34342694e-01f, 2.43288577e-02f, 3.33167225e-01f, 3.11116904e-01f, 3.42062674e-02f, 5.27840108e-03f, 2.56580055e-01f, -2.69061267e-01f,
  1.66093290e-01f, -1.66956335e-01f, 8.63570943e-02f, 6.80869296e-02f, -7.25324899e-02f, 3.86926413e-01f, 6.54164096e-03f, 2.94451535e-01f, -9.38722342e-02f, 3.65351945e-01f,
  -1.63999245e-01f, -2.85177022e-01f, 2.12733537e-01f, -1.09226778e-01f, -1.14296824e-01f, -1.97741508e-01f, 2.33153865e-01f, 4.63467807e-01f, 4.13899511e-01f, -2.43261620e-01f,
  -8.17136243e-02f, 3.29488784e-01f, 2.52121031e-01f, -9.18620825e-02f, -6.14158483e-03f, 3.12428862e-01f, 2.57326484e-01f, -3.76465842e-02f, 8.56469497e-02f, 1.63319454e-01f,
  7.87494481e-02f, -5.54532884e-03f, -1.54064316e-02f, -4.65829708e-02f, -2.03703299e-01f, 1.30921736e-01f, -3.14293206e-01f, -1.65322930e-01f, -2.38225777e-02f, 1.32099524e-01f,
  2.45679960e-01f, 1.11258991e-01f, 2.90904492e-01f, -1.69184223e-01f, 1.28021538e-01f, -1.18709013e-01f, 1.74025759e-01f, 2.96379235e-02f, 6.38291165e-02f, 3.77373733e-02f,
  5.02759852e-02f, 6.89699203e-02f, 3.59045327e-01f, 1.10215515e-01f, 3.19682108e-03f, -3.19746166e-01f, -1.14529662e-01f, 4.03713025e-02f, -4.60624956e-02f, -1.33250460e-01f,
  7.96291903e-02f, -3.46228093e-01f, 1.91630304e-01f, -2.61006821e-02f, 2.02343315e-02f, -2.18266964e-01f, 1.35653898e-01f, 3.83286685e-01f, 3.76262069e-02f, 2.32827470e-01f,
  1.36281848e-01f, -8.53142291e-02f, 1.09182401e-02f, 8.33326653e-02f, -1.54121527e-02f, -2.81099796e-01f, -7.09349588e-02f, 6.23141509e-03f, 1.30111381e-01f, -7.73354396e-02f,
  3.32270026e-01f, 3.62349719e-01f, 3.86718154e-01f, 8.96856487e-02f, 3.93772461e-02f, -1.21315211e-01f, -2.23487586e-01f, 7.46649653e-02f, -1.59518030e-02f, -1.63133312e-02f,
  -4.23506573e-02f, -8.32700357e-02f, -6.62215427e-02f, 8.22583139e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  7.16933459e-02f, 9.57055613e-02f, -1.71193536e-02f, 1.43806696e-01f, 2.97710206e-03f, 5.71032763e-02f, 2.83120153e-03f, 2.48709857e-01f, -3.99774946e-02f, 1.42383249e-02f,
  6.72271475e-02f, 1.31437823e-01f, 1.20428398e-01f, 2.18995032e-03f, 1.81449763e-02f, 6.78390339e-02f, -1.22356035e-01f, 1.06129676e-01f, 4.90421914e-02f, -1.02692246e-01f,
  6.60580471e-02f, -1.51602000e-01f, -1.21771339e-02f, 1.56808957e-01f, 5.64500242e-02f, -7.98520371e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.14522406e-01f, -6.45183921e-02f, -1.85943112e-01f, -2.30988503e-01f, 1.42575800e-01f, -2.00164989e-01f, 1.11790814e-01f, -1.31097659e-01f, 1.05120026e-01f, -7.18286932e-02f,
  -2.89851964e-01f, 4.01536971e-02f, -1.48518011e-01f, -1.42851518e-02f, 2.91864164e-02f, -1.87747717e-01f, -1.08343609e-01f, -1.87799372e-02f, -3.48517329e-01f, -1.88171715e-01f,
  9.61176232e-02f, 5.05095487e-03f, 1.97202358e-02f, -4.11622971e-01f, 1.77743301e-01f, 6.54540658e-02f, -6.41731322e-02f, 2.38752544e-01f, 5.57989404e-02f, -2.20717296e-01f,
  7.19598457e-02f, 1.12968393e-01f, -2.67761331e-02f, 1.52246296e-01f, -2.04635352e-01f, 2.09802493e-01f, 1.74309835e-01f, 9.28110331e-02f, -8.19946468e-01f, -2.66460836e-01f,
  -3.59805524e-01f, -3.49770367e-01f, -1.94441691e-01f, -2.86264867e-01f, -2.50962049e-01f, 3.56618278e-02f, 1.64852977e-01f, 3.67280766e-02f, -1.68020353e-01f, -4.35368836e-01f,
  1.60786703e-01f, -3.51684660e-01f, -2.24746615e-01f, -6.61394224e-02f, 2.86339909e-01f, 9.89972353e-02f, -1.47996277e-01f, 1.67599991e-01f, -8.04560333e-02f, -1.69950768e-01f,
  -5.16724065e-02f, 9.11933482e-02f, -5.95694602e-01f, -2.16446761e-02f, 2.11754233e-01f, -7.26791546e-02f, -2.52238344e-02f, -2.45012954e-01f, 9.54527929e-02f, 1.01405762e-01f,
  -2.07948059e-01f, 1.80651218e-01f, -2.68441796e-01f, 6.47075986e-03f, -2.58682549e-01f, -1.26345474e-02f, 2.66420413e-02f, -1.66299924e-01f, 9.74923559e-03f, -7.63927922e-02f,
  2.01146170e-01f, 4.21347730e-02f, -6.07741475e-02f, -1.36056274e-01f, -7.96637535e-02f, -1.97657138e-01f, -1.06966823e-01f, -3.98060799e-01f, -2.38784235e-02f, -9.89440456e-02f,
  -2.03742430e-01f, -2.02012271e-01f, -1.44752320e-02f, -1.10947222e-01f, -3.16906758e-02f, 1.90527663e-01f, -9.38103944e-02f, 2.72582024e-01f, 3.33618335e-02f, -1.77378625e-01f,
  5.02953045e-02f, -2.76969194e-01f, -4.79290009e-01f, -2.62837827e-01f, -3.62652868e-01f, 2.33261541e-01f, 1.41426548e-01f, 2.03839466e-01f, 4.38828580e-02f, 2.60273546e-01f,
  -5.26593253e-02f, 1.39377058e-01f, -6.55351698e-01f, 4.44540977e-02f, 5.57653345e-02f, 6.66229874e-02f, 3.70369665e-02f, 2.02105030e-01f, 5.99303916e-02f, -3.09183776e-01f,
  -3.28685582e-01f, -6.50614873e-02f, -3.45695436e-01f, 3.48266102e-02f, 4.28592227e-02f, -1.13142103e-01f, -4.55676794e-01f, -1.97120488e-01f, -1.18272357e-01f, -2.32139111e-01f,
  -2.41110235e-01f, 8.84750262e-02f, -6.41100407e-02f, 1.49638057e-01f, 3.22774798e-01f, 8.35655909e-03f, -2.52709985e-02f, 2.85807867e-02f, 8.37922841e-02f, 1.28344327e-01f,
  1.36726022e-01f, 6.24039620e-02f, -3.49544510e-02f, 2.45782465e-01f, 4.71575670e-02f, 1.98545083e-01f, -6.18842505e-02f, 1.58467785e-01f, -2.26658322e-02f, 1.29465410e-03f,
  -2.79987872e-01f, -1.31017104e-01f, 2.96664804e-01f, -1.97593763e-01f, 3.26287597e-01f, 9.53009203e-02f, -2.56705731e-01f, 1.92627475e-01f, -1.61054105e-01f, 2.80722952e-03f,
  -2.40892187e-01f, 2.11968541e-01f, 1.20845057e-01f, 1.10174365e-01f, -1.15535289e-01f, 3.01443100e-01f, -5.06328583e-01f, 1.24541610e-01f, -3.38781983e-01f, -3.14737201e-01f,
  -6.39434695e-01f, 1.06555544e-01f, -1.63044389e-02f, 2.28879631e-01f, -1.91365853e-02f, 8.03512484e-02f, 5.58598161e-01f, -1.12394422e-01f, 2.56351620e-01f, -5.64471543e-01f,
  1.07901596e-01f, -4.30854082e-01f, -2.75131136e-01f, -3.37853283e-01f, -2.14617878e-01f, -1.65038824e-01f, -6.50453568e-01f, -1.21633768e-01f, -2.03758165e-01f, 6.37923628e-02f,
  -9.34735909e-02f, 3.56034547e-01f, -1.89031243e-01f, 4.79885079e-02f, -1.68228745e-01f, -1.96044236e-01f, -1.77576631e-01f, 3.54668610e-02f, 3.69696051e-01f, 6.03071377e-02f,
  1.53247835e-02f, -1.23129785e-01f, -2.24286810e-01f, -3.73821914e-01f, -2.32486159e-01f, -6.98460713e-02f, -7.08963946e-02f, 9.10546854e-02f, 1.34734735e-01f, -2.55828023e-01f,
  -5.31248422e-03f, 3.41527835e-02f, 4.16055210e-02f, -2.66445000e-02f, 4.48202565e-02f, 2.34926879e-01f, -1.23955077e-02f, 2.49686107e-01f, 4.21511173e-01f, 4.81352508e-02f,
  -1.19159877e-01f, 1.40367508e-01f, -2.21309997e-02f, 2.14512777e-02f, -8.85971487e-02f, 2.20845655e-01f, -2.23535359e-01f, -1.64339259e-01f, 5.83595000e-02f, 1.58552960e-01f,
  -2.28866145e-01f, -1.02306515e-01f, -9.50432345e-02f, -5.16701460e-01f, -3.58695388e-01f, -2.09861070e-01f, -1.53431401e-01f, -7.23569393e-01f, 1.40001923e-01f, -4.44654167e-01f,
  -3.91881704e-01f, -1.69664741e-01f, -4.12769383e-03f, -4.73162591e-01f, -3.85417901e-02f, -2.82902122e-01f, -1.77051380e-01f, 1.08439028e-01f, -3.94716918e-01f, 1.05007261e-01f,
  1.72608286e-01f, 6.44878224e-02f, 4.28786986e-02f, 5.79614639e-02f, 1.38158314e-02f, 3.31684917e-01f, -1.48335651e-01f, -9.47845951e-02f, 3.32737595e-01f, -9.60860327e-02f,
  -1.20242022e-01f, -1.04030073e-01f, -5.72741210e-01f, 2.35540234e-02f, -3.17725599e-01f, 6.23054840e-02f, 2.60712922e-01f, 2.65935510e-01f, 2.51222372e-01f, -4.80205342e-02f,
  4.54628579e-02f, -2.85615295e-01f, -1.42083138e-01f, 1.47190109e-01f, 7.58653581e-02f, -1.61474366e-02f, 2.90260836e-02f, 1.76332504e-01f, -2.06330925e-01f, 6.48200065e-02f,
  -3.55292350e-01f, -1.13351405e-01f, -3.64260226e-01f, -9.44168568e-02f, -8.86029676e-02f, -3.63800116e-02f, 1.37808278e-01f, 2.44016394e-01f, -2.55633593e-02f, -3.97035182e-01f,
  -1.67437326e-02f, 3.33878547e-01f, 2.44579598e-01f, -1.93767443e-01f, 2.39205174e-02f, -2.47725114e-01f, -1.84683260e-02f, -1.87618151e-01f, -1.08117282e-01f, 7.35941082e-02f,
  -1.95358291e-01f, -3.60608727e-01f, -6.58377782e-02f, -2.77519375e-01f, 2.70633340e-01f, -2.90308520e-02f, 8.45585316e-02f, -1.56136617e-01f, 2.67465651e-01f, -8.53991508e-02f,
  -1.41483307e-01f, 1.80763245e-01f, -9.56803933e-02f, -1.05725182e-02f, 1.56078460e-02f, -5.16509116e-02f, -2.18765065e-01f, 1.02688663e-01f, -1.64870560e-01f, -3.02227914e-01f,
  1.36192843e-01f, -3.88007574e-02f, -1.17078848e-01f, 1.44435599e-01f, -8.98938179e-02f, 2.05873214e-02f, -4.65853550e-02f, -2.72182047e-01f, 1.58061296e-01f, 5.02002984e-02f,
  -6.04474880e-02f, 1.72209084e-01f, 2.25723580e-01f, -6.87181205e-02f, -2.44487450e-01f, 2.01761410e-01f, -1.29557073e-01f, -2.24709585e-01f, 6.85945004e-02f, -3.86194378e-01f,
  -1.13028325e-01f, 4.30470482e-02f, 1.14842467e-02f, 4.40603912e-01f, -4.62676920e-02f, -4.42819968e-02f, -9.65683311e-02f, -2.69936800e-01f, -3.28747869e-01f, -4.30783421e-01f,
  9.58648603e-03f, -1.04394041e-01f, -2.17471287e-01f, -2.12832540e-01f, 9.43155512e-02f, 3.49436373e-01f, -1.00482017e-01f, 5.60628958e-02f, -4.74837303e-01f, -5.14359549e-02f,
  2.73179710e-01f, -9.71617624e-02f, 1.47803053e-01f, -7.11378381e-02f, 1.27295628e-02f, -1.86962202e-01f, 1.73581779e-01f, 1.04126580e-01f, -5.40464818e-01f, -1.77203566e-01f,
  5.59371784e-02f, -1.88078940e-01f, 1.59777611e-01f, 4.01132144e-02f, 1.54970333e-01f, -3.24234873e-01f, -4.43954349e-01f, -1.78797230e-01f, -9.85155329e-02f, -6.68121278e-02f,
  1.28551841e-01f, 2.33641848e-01f, 5.32845967e-03f, -2.41655543e-01f, 2.26168513e-01f, 2.42101550e-01f, 1.15576945e-01f, 6.08207658e-02f, 1.45096391e-01f, 1.13735639e-01f,
  2.22635552e-01f, 1.08349822e-01f, 2.34927014e-01f, 9.08662230e-02f, -9.04340073e-02f, -7.01698288e-02f, 1.81988865e-01f, 9.45169665e-03f, 4.24048118e-02f, 1.00371607e-01f,
  1.97001591e-01f, 2.92965248e-02f, 6.45479560e-02f, -3.42816085e-01f, 1.25999227e-01f, -3.20049465e-01f, 2.68943369e-01f, 1.43920556e-01f, 9.67363194e-02f, 1.78649172e-01f,
  -2.81970143e-01f, -2.45283499e-01f, 1.04018725e-01f, 2.03346834e-01f, 8.95877182e-02f, -9.88359377e-02f, 3.23241472e-01f, 1.55899897e-01f, 6.34789616e-02f, 4.50458705e-01f,
  2.01913923e-01f, -1.51546657e-01f, 3.24077159e-01f, -1.52958557e-01f, 1.75514877e-01f, 1.70650616e-01f, -2.43136957e-01f, -2.93970965e-02f, -1.61779240e-01f, -1.33880973e-01f,
  -1.93007171e-01f, 1.03996128e-01f, 1.79097429e-01f, 1.37415096e-01f, -3.58783960e-01f, 1.93371609e-01f, -2.36508861e-01f, -4.02973056e-01f, -1.07725963e-01f, -3.72304529e-01f,
  7.41349101e-01f, 3.76179591e-02f, -5.57626605e-01f, -1.08940743e-01f, 1.47191063e-01f, 1.83799472e-02f, 8.59928690e-03f, -1.76487327e-01f, 1.71340808e-01f, -1.52559400e-01f,
  -1.69284582e-01f, 2.89370507e-01f, -1.61045611e-01f, -2.11795658e-01f, -4.00868766e-02f, -1.47543728e-01f, 2.25314852e-02f, -2.64335126e-02f, -3.37843262e-02f, 1.55203715e-02f,
  -3.23319845e-02f, 6.02332084e-03f, -2.31946319e-01f, -1.40339211e-01f, -4.66615483e-02f, 1.11435011e-01f, -6.68898895e-02f, 1.65913701e-01f, -5.76063544e-02f, -1.46772070e-02f,
  2.75877882e-02f, -1.04973182e-01f, -2.77096429e-03f, 1.49718970e-01f, 8.15738440e-02f, -8.80114734e-02f, 8.25975165e-02f, 2.19225168e-01f, 2.30716482e-01f, -8.71085823e-02f,
  -1.56178623e-01f, 9.76996422e-02f, 1.85892180e-01f, 1.29634365e-01f, -1.21699134e-02f, 7.54705966e-02f, -7.87589490e-01f, -3.52406204e-01f, -3.13183755e-01f, -2.02493109e-02f,
  2.38747850e-01f, 2.13768091e-02f, -2.41764203e-01f, 2.99936673e-03f, -2.28965670e-01f, -2.17454940e-01f, -6.05093360e-01f, 7.09572136e-02f, -2.73577243e-01f, -5.48657238e-01f,
  1.34649023e-01f, 1.35496389e-02f, -2.55713928e-02f, 8.14844742e-02f, -3.98606174e-02f, 2.82229520e-02f, 2.24437922e-01f, -1.10668384e-01f, -3.91205043e-01f, -4.70463097e-01f,
  -3.66817527e-02f, -1.31596014e-01f, -1.90173626e-01f, 3.11403215e-01f, -9.01637450e-02f, 2.58284986e-01f, 1.46342278e-01f, 2.01915279e-02f, -2.09870711e-01f, -2.58250415e-01f,
  7.33839348e-02f, -1.98810324e-01f, -1.66047900e-03f, -2.09769353e-01f, -3.49339128e-01f, -7.17791691e-02f, 9.20883417e-02f, 2.47567207e-01f, -3.13142538e-01f, 1.50615960e-01f,
  -2.81185359e-01f, 2.81978726e-01f, -9.16308910e-02f, -3.16969544e-01f, 1.21141903e-01f, -3.88849713e-02f, 1.30789150e-02f, 6.91666976e-02f, 1.92965060e-01f, 8.11029673e-02f,
  2.44108453e-01f, 3.41037601e-01f, 2.26401716e-01f, -2.12235283e-02f, 3.12759221e-01f, -2.74875462e-01f, 1.02971911e-01f, -5.12785196e-01f, -2.57556319e-01f, 1.46955550e-01f,
  -1.93120003e-01f, -2.56128460e-01f, 2.93901145e-01f, -4.33851540e-01f, -2.48286545e-01f, -2.30935425e-01f, 2.01833218e-01f, -6.48218840e-02f, -5.34789026e-01f, 1.63663596e-01f,
  -2.10647404e-01f, 1.17952429e-01f, -3.70188534e-01f, -4.27413583e-01f, -4.99269329e-02f, 2.67638594e-01f, 5.23602068e-02f, -2.60300964e-01f, -4.62851971e-01f, -4.20340113e-02f,
  -1.64825201e-01f, -1.42560139e-01f, 2.88948745e-01f, -1.77782267e-01f, -4.80280817e-02f, -1.30221263e-01f, -3.39845747e-01f, 1.25825062e-01f, 1.14068471e-01f, 1.83810219e-01f,
  -4.91124056e-02f, 1.08868908e-03f, -1.58862084e-01f, -1.29478529e-01f, 2.56869674e-01f, 1.04472861e-01f, 1.49702296e-01f, -4.27569402e-03f, -2.98266076e-02f, 2.93304741e-01f,
  1.21224917e-01f, -1.99507639e-01f, -2.97404617e-01f, -2.04491913e-01f, 5.61394691e-02f, 6.78896308e-02f, 5.59796542e-02f, -2.00872362e-01f, 2.05793023e-01f, 7.17809647e-02f,
  2.57978469e-01f, 1.35018721e-01f, 3.64355505e-01f, 2.29818881e-01f, 1.20055079e-01f, 5.27047589e-02f, 1.30938843e-01f, 4.80949581e-02f, -7.72626624e-02f, -1.45072505e-01f,
  2.48470396e-01f, -3.48659933e-01f, -2.12113798e-01f, 3.60845894e-01f, 5.96114174e-02f, -3.23079713e-02f, -3.64509583e-01f, 2.66708404e-01f, -5.23349717e-02f, 2.20735803e-01f,
  -8.96232724e-02f, 2.28449672e-01f, -2.65518934e-01f, -2.20305204e-01f, -2.70458192e-01f, 1.48436949e-01f, -2.25468293e-01f, 2.03190356e-01f, 7.08656758e-02f, -4.42429215e-01f,
  -6.39768094e-02f, -6.49869442e-01f, -5.60680449e-01f, -6.49775743e-01f, -1.66917756e-01f, -5.97792119e-02f, -3.32918942e-01f, -4.18339111e-02f, 1.75726980e-01f, -2.70310521e-01f,
  1.49783716e-01f, -2.08620820e-02f, 5.74971884e-02f, -4.32549864e-01f, 1.18103147e-01f, -1.33496284e-01f, 1.60338525e-02f, 1.69683188e-01f, 9.35659707e-02f, 2.61131153e-02f,
  1.01330139e-01f, -3.14169228e-02f, 8.88811797e-02f, 2.21622407e-01f, 2.42885500e-02f, 1.81528460e-02f, 9.16112512e-02f, -2.38875479e-01f, -1.58490986e-02f, 2.30783314e-01f,
  2.70800173e-01f, -2.12558270e-01f, -7.96243176e-02f, -1.63725644e-01f, -2.00054705e-01f, 5.11031896e-02f, -1.77370250e-01f, 3.30162346e-01f, 3.61721575e-01f, 2.20554039e-01f,
  -3.07274938e-01f, -1.45809561e-01f, -1.51029453e-01f, -1.65942073e-01f, -4.49760437e-01f, -3.25231016e-01f, -3.91539000e-03f, -7.31989741e-02f, -3.87264580e-01f, 2.15584934e-01f,
  5.52651361e-02f, -1.59256637e-01f, -4.29828644e-01f, -7.99588919e-01f, 7.71313906e-02f, -5.59983075e-01f, 1.73322424e-01f, 2.25327909e-02f, 4.68636155e-01f, -6.29914284e-01f,
  -7.37717152e-02f, -2.69280344e-01f, -5.41939080e-01f, 1.58532798e-01f, 2.56739795e-01f, 1.44830212e-01f, -3.36962819e-01f, -3.07313532e-01f, -2.83337981e-01f, -7.67588094e-02f,
  7.88196176e-02f, 6.80707544e-02f, -1.57395676e-01f, 3.03122163e-01f, -2.44931653e-02f, -2.47849107e-01f, -1.32873416e-01f, -2.63603389e-01f, -1.33325472e-01f, -5.08422442e-02f,
  2.94701308e-01f, 3.36464584e-01f, -1.40497357e-01f, -1.29585549e-01f, -2.25083753e-01f, -8.67410973e-02f, -7.32707512e-03f, 1.31532341e-01f, 9.91794392e-02f, -2.21753061e-01f,
  2.18586072e-01f, -2.20299989e-01f, 5.70504554e-02f, 3.45316559e-01f, -2.04854667e-01f, 5.43119013e-01f, 9.06595495e-03f, 2.20920816e-01f, 3.89842331e-01f, -1.15794711e-01f,
  -9.62108299e-02f, -1.52347863e-01f, -1.15422286e-01f, -6.61241859e-02f, -9.31579992e-02f, -2.99494475e-01f, 1.87808856e-01f, 1.58964202e-01f, 1.31919563e-01f, 1.56727955e-01f,
  1.14314169e-01f, -2.50735670e-01f, -1.78497955e-01f, -8.13934743e-01f, -6.67080209e-02f, -1.06748985e-02f, 2.65498906e-02f, -5.40584065e-02f, 2.22230047e-01f, -4.36572045e-01f,
  -3.10938865e-01f, -6.05463833e-02f, -1.84105754e-01f, 1.60728902e-01f, -3.58261019e-01f, 3.53038795e-02f, -6.59290552e-02f, -7.69701600e-02f, -3.54912043e-01f, -1.21458843e-01f,
  -4.77590472e-01f, -5.27917802e-01f, 1.07920080e-01f, 6.41247779e-02f, 9.17258039e-02f, -2.42050365e-01f, 2.44378403e-01f, 1.95695430e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.07836127e-01f, 5.15045710e-02f, 1.76418737e-01f, -6.67969137e-02f, -3.84528637e-02f, -7.97813833e-02f, -1.79373119e-02f, -1.45968631e-01f, 1.11747764e-01f, 4.15334627e-02f,
  -6.47670031e-02f, 1.13528958e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    