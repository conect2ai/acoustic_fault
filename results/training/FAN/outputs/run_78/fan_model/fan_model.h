/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.52507618e-01f, 1.97835922e-01f, -2.70303134e-02f, 2.88151234e-01f, 1.01339273e-01f, 2.99751591e-02f, 1.08561829e-01f, 1.35137752e-01f, 2.51700789e-01f, 1.39420331e-01f,
  2.39495978e-01f, -5.60650788e-02f, -4.42080311e-02f, 2.89374799e-01f, -2.93044508e-01f, 2.17909478e-02f, 2.78976381e-01f, 7.03932047e-02f, -7.50810727e-02f, 1.19329795e-01f,
  3.61440107e-02f, 2.60003060e-01f, -1.10222287e-02f, 4.14028391e-03f, 1.31314456e-01f, -1.79659110e-02f, -1.13411453e-02f, -3.00098378e-02f, 2.15161163e-02f, -1.94335785e-02f,
  8.79334658e-02f, 6.06122278e-02f, 2.17889831e-03f, 2.87974533e-02f, 7.41235074e-03f, 2.95090415e-02f, 4.72764522e-02f, -1.02251567e-01f, -2.58459640e-03f, 5.14836200e-02f,
  2.72413362e-02f, -4.60935086e-02f, 2.35798713e-02f, 5.51232174e-02f, 3.84611003e-02f, 2.70104763e-04f, -6.04689755e-02f, 3.15053947e-02f, -2.72058938e-02f, -1.84763558e-02f,
  -1.18262572e-02f, 7.10204593e-04f, 1.67580657e-02f, 1.31470766e-02f, -4.78250049e-02f, 1.14778586e-01f, 2.31562508e-03f, -3.79451215e-02f, 3.30761485e-02f, 1.79743785e-02f,
  -4.53905277e-02f, -4.62929346e-02f, -2.01517195e-02f, -1.92070305e-02f, -7.00821728e-02f, 1.79567374e-02f, -8.05091206e-03f, -6.88159317e-02f, -1.46602083e-03f, -6.03050217e-02f,
  4.56773899e-02f, -1.17492089e-02f, 2.73680445e-02f, -4.57377695e-02f, 4.10834737e-02f, 1.15671316e-02f, -4.73653972e-02f, -3.85562554e-02f, 1.45258248e-01f, -3.43803093e-02f,
  -1.93039197e-02f, -1.20757468e-01f, -1.18729388e-02f, 3.09877191e-03f, 5.38967876e-03f, -8.14166367e-02f, -4.58277427e-02f, -7.63933314e-03f, -3.71080115e-02f, 2.01296303e-02f,
  2.58663148e-02f, 3.92134376e-02f, 4.24840972e-02f, 6.88253343e-02f, -4.67177071e-02f, 4.58000489e-02f, 3.97198088e-02f, 1.26726761e-01f, 1.21834300e-01f, 1.29700154e-01f,
  5.48820645e-02f, 4.56391135e-03f, -3.50027904e-02f, -5.19506522e-02f, -3.25233191e-02f, -6.52681710e-03f, -1.36045441e-02f, -9.50506106e-02f, 6.05673157e-03f, 8.78493488e-03f,
  3.66649479e-02f, 7.98795000e-03f, -2.57615987e-02f, 4.92338017e-02f, 9.08687040e-02f, 4.26418968e-02f, 9.61386785e-03f, 2.70574465e-02f, -4.10225093e-02f, 1.84562302e-03f,
  2.92262554e-01f, -2.83465087e-01f, -1.42460521e-02f, 4.60526943e-02f, -1.01589739e-01f, -4.64853406e-01f, -2.09080055e-01f, -1.03225544e-01f, -4.38586473e-02f, -2.22372934e-01f,
  -3.58159840e-02f, 1.07754588e-01f, 7.33790025e-02f, -1.12917766e-01f, 1.45793617e-01f, 7.25975782e-02f, -1.40486747e-01f, -1.51184842e-01f, 1.37227580e-01f, -1.78656913e-02f,
  1.33036345e-01f, -1.04346946e-01f, 1.94430202e-01f, -3.56219970e-02f, -6.48325160e-02f, 1.20629795e-01f, 5.06039225e-02f, 5.65816164e-02f, -1.89364493e-01f, 2.85096560e-02f,
  2.64669675e-02f, 4.38964181e-02f, 4.60333563e-02f, -1.79007545e-03f, -8.49311426e-02f, -3.71960066e-02f, 9.37746242e-02f, 4.24392745e-02f, 7.32860938e-02f, -1.02111008e-02f,
  -9.69719738e-02f, 4.77402173e-02f, -1.25395730e-01f, -3.58666554e-02f, -1.04194812e-01f, -1.52466252e-01f, 2.97940169e-05f, 1.01674292e-02f, -2.90430840e-02f, 6.58665746e-02f,
  -1.64237693e-02f, 5.13265021e-02f, -2.21916586e-02f, -4.84389486e-04f, -4.69598966e-03f, 7.99551532e-02f, 4.21813801e-02f, 2.18629502e-02f, -5.22584580e-02f, -9.74714607e-02f,
  -9.44322720e-02f, -4.24381830e-02f, 4.81689498e-02f, -2.91752182e-02f, -6.66552335e-02f, 1.89226195e-02f, -5.73299192e-02f, 5.78759387e-02f, 6.98364154e-02f, -1.67502835e-02f,
  -8.34011286e-02f, 5.06186262e-02f, 1.07924277e-02f, 7.93296769e-02f, 5.10940030e-02f, 4.52801883e-02f, 5.57582453e-02f, 3.86865549e-02f, 9.28753242e-03f, 1.13822613e-02f,
  7.96141848e-02f, -4.73251753e-02f, -7.76926950e-02f, -3.80076207e-02f, -6.07751124e-02f, -4.09088396e-02f, -8.93991664e-02f, 1.50076346e-02f, 4.32948917e-02f, 3.98547798e-02f,
  -1.81994095e-01f, -1.81922585e-01f, -4.86004949e-02f, 1.61957704e-02f, 1.52481183e-01f, 1.98758002e-02f, -1.62513778e-02f, -1.05843328e-01f, 4.46829647e-02f, -6.81190267e-02f,
  -7.41841197e-02f, 9.22806002e-03f, -3.29785272e-02f, 4.60604616e-02f, -5.67676909e-02f, -9.36274976e-02f, 5.46992868e-02f, -3.67566198e-02f, -4.13934671e-04f, -7.71791721e-03f,
  2.35002134e-02f, 2.99127791e-02f, 2.29191165e-02f, -8.11264962e-02f, -8.20560232e-02f, -2.96820290e-02f, -8.12787712e-02f, 2.12917179e-02f, -2.17968933e-02f, 1.05675356e-02f,
  1.14954881e-01f, -1.27629966e-01f, 2.67590225e-01f, 6.31339476e-02f, -4.14986461e-02f, -2.01876923e-01f, 1.11165335e-02f, -1.03878699e-01f, -1.04617238e-01f, -2.65333831e-01f,
  -5.90020493e-02f, 1.32378817e-01f, -3.08533907e-02f, -1.53278306e-01f, 1.21843182e-01f, 3.34960148e-02f, -2.07409680e-01f, -4.21159938e-02f, 7.79984668e-02f, -2.13989645e-01f,
  9.91685223e-03f, -1.48604497e-01f, 9.17151719e-02f, -1.21443070e-01f, -7.64300749e-02f, 9.70525742e-02f, -1.68336718e-03f, 1.10031299e-01f, -1.71855986e-02f, 1.11851327e-01f,
  -1.37798950e-01f, 7.16077760e-02f, 7.21012009e-03f, 4.31535905e-03f, -1.27677873e-01f, -5.35211451e-02f, 7.57952854e-02f, 6.36588633e-02f, 2.81949658e-02f, 1.78770151e-03f,
  4.34468035e-03f, 1.30464798e-02f, -2.39193216e-02f, 8.56820270e-02f, -5.86677715e-02f, -1.61722079e-02f, 3.35327499e-02f, -6.44446909e-02f, 7.11174980e-02f, -6.19878173e-02f,
  5.42509668e-02f, -1.20525649e-02f, 7.23703355e-02f, 1.62754785e-02f, 1.12851813e-01f, -6.36366531e-02f, 3.58909257e-02f, 9.34456214e-02f, -6.41684085e-02f, -9.65070873e-02f,
  8.63380283e-02f, 1.19147981e-02f, 4.95161340e-02f, -8.24637804e-03f, 7.73214102e-02f, -8.59465264e-03f, -4.88249213e-03f, 3.74617390e-02f, 2.61483472e-02f, -6.02100696e-03f,
  -6.23730682e-02f, 1.18847878e-03f, 8.09020642e-03f, -3.99738476e-02f, 6.73138276e-02f, -1.95153784e-02f, -9.98374540e-03f, -5.51686920e-02f, 7.17305532e-03f, 2.41420958e-02f,
  -8.69133789e-03f, -7.74017870e-02f, 1.03227928e-01f, 7.07152486e-02f, -4.72009229e-03f, -1.16719110e-02f, 1.98591948e-02f, -2.22102553e-03f, 1.98565442e-02f, 5.78003637e-02f,
  -3.50637704e-01f, -2.51013279e-01f, -9.15497914e-02f, -5.32173961e-02f, -8.91748257e-03f, -4.30016480e-02f, 5.01436889e-02f, 5.12114093e-02f, -4.29742113e-02f, -1.34088948e-01f,
  -1.27265543e-01f, 8.40302184e-02f, -2.80270912e-03f, 3.06058265e-02f, 5.23511134e-02f, 1.05142605e-03f, -3.88666652e-02f, -5.49154580e-02f, -6.30067736e-02f, -1.11481398e-01f,
  -1.72226310e-01f, -4.21144906e-03f, 6.31353259e-02f, 7.99709857e-02f, 7.11929500e-02f, -2.59409323e-02f, -3.02002742e-03f, 3.72475013e-02f, -1.15482872e-02f, -9.14601013e-02f,
  4.46850598e-01f, 8.55138227e-02f, 1.91944897e-01f, 3.67718518e-01f, -3.01813381e-03f, -1.03471182e-01f, 1.90553337e-01f, -6.00096956e-03f, 1.74457088e-01f, -1.66568100e-01f,
  -1.70446597e-02f, 1.48956314e-01f, -2.42111593e-01f, 2.53926247e-01f, 1.07371278e-01f, -2.30034441e-01f, 2.29533404e-01f, 1.31146431e-01f, -5.56388311e-02f, 7.57721141e-02f,
  1.65247664e-01f, -1.14698699e-02f, 2.17822507e-01f, -1.13188118e-01f, 2.68017858e-01f, 1.27300620e-01f, -6.35626540e-02f, -9.71047133e-02f, 1.26364484e-01f, -4.45184782e-02f,
  8.09943751e-02f, -3.96668613e-02f, 1.03647731e-01f, -2.34467313e-02f, -6.26487716e-04f, 3.37352306e-02f, 9.96397361e-02f, -5.19134663e-02f, -4.59225178e-02f, -3.09204701e-02f,
  1.03203788e-01f, -3.36058661e-02f, -1.30558910e-03f, 3.50553207e-02f, 3.06884348e-02f, 2.41760649e-02f, 6.94066510e-02f, 1.91671267e-01f, 7.40531087e-02f, 5.72386160e-02f,
  6.37807474e-02f, 1.24013454e-01f, 3.34988236e-02f, 2.44520176e-02f, 3.78559306e-02f, 4.46288427e-03f, 2.91178469e-02f, -4.10586043e-04f, 9.09118280e-02f, 9.00057796e-03f,
  -2.69219540e-02f, -9.67225656e-02f, -2.08074823e-02f, 3.68653075e-03f, -7.16399122e-03f, -3.14579830e-02f, -1.52370362e-02f, -6.65012375e-02f, 1.48837632e-02f, -8.76918212e-02f,
  3.41918282e-02f, 7.78810531e-02f, -2.10870393e-02f, -4.23208904e-03f, 8.65054503e-03f, 2.57782266e-02f, 3.54841501e-02f, -8.58257152e-03f, 8.97211134e-02f, 5.79556115e-02f,
  -4.24597412e-02f, -3.13153714e-02f, 6.91771181e-03f, -4.69061658e-02f, -4.86105606e-02f, 3.31939645e-02f, -9.38621163e-02f, 7.20648170e-02f, -1.89670268e-02f, 3.65068298e-03f,
  -1.79921940e-01f, -1.87071651e-01f, -1.55684114e-01f, 7.96809867e-02f, -2.43964344e-02f, 1.20175987e-01f, -2.01163162e-02f, 6.63340166e-02f, 4.89428043e-02f, 5.51977344e-02f,
  -1.34762656e-02f, -3.16943116e-02f, -2.20322199e-02f, -7.01771677e-02f, 1.85077935e-02f, -4.25242726e-03f, -6.42406866e-02f, 7.93040078e-03f, 3.49184722e-02f, -1.97740714e-03f,
  3.81220654e-02f, -4.47000042e-02f, -1.06069207e-01f, 4.97030690e-02f, 7.65508488e-02f, 1.02982074e-02f, -1.55037791e-02f, 2.70919595e-02f, -1.19710125e-01f, -1.02997370e-01f,
  1.17137939e-01f, -9.37030539e-02f, -2.45278794e-02f, 2.11479843e-01f, 7.52674267e-02f, 1.10810794e-01f, 2.94046760e-01f, 3.98745015e-02f, 1.78962111e-01f, -9.22437906e-02f,
  1.46835387e-01f, -5.90129048e-02f, 4.32266742e-02f, 1.60672963e-01f, 4.97853279e-01f, 9.55766886e-02f, 2.83415139e-01f, 6.24627806e-02f, -3.36083286e-02f, 1.11564443e-01f,
  2.28887856e-01f, 1.90805539e-01f, 1.10065140e-01f, -2.07582057e-01f, -6.32502288e-02f, -2.49796927e-01f, 5.51888682e-02f, -7.22418055e-02f, 1.39581356e-02f, 1.28039166e-01f,
  7.25243166e-02f, -5.83901890e-02f, -6.40375316e-02f, -7.76696056e-02f, 8.29727799e-02f, -1.10086249e-02f, 1.16097622e-01f, -5.93276471e-02f, -1.91984102e-02f, 1.46438956e-01f,
  3.47850621e-02f, 1.45131931e-01f, 9.66214854e-03f, -1.29801840e-01f, 6.72522858e-02f, 5.84074743e-02f, -2.28007808e-02f, -1.88134704e-02f, 1.40325412e-01f, 1.04982652e-01f,
  5.08329906e-02f, -3.39608341e-02f, 4.57508080e-02f, 3.76123115e-02f, -5.46318702e-02f, 1.30420163e-01f, -3.90420621e-03f, 1.89745426e-02f, 7.28265867e-02f, 6.29781708e-02f,
  8.28191116e-02f, -4.92845923e-02f, -1.27904713e-01f, -5.87611236e-02f, -4.14980948e-02f, 3.99909206e-02f, -3.01232785e-02f, -7.72360340e-02f, -7.77030885e-02f, 1.06607862e-01f,
  -3.18809561e-02f, -3.05072349e-02f, 8.72130990e-02f, 3.10430899e-02f, -4.07526940e-02f, -4.23654802e-02f, 9.85458568e-02f, -8.81480798e-02f, -3.20463479e-02f, -7.76423365e-02f,
  2.50313077e-02f, -4.76489728e-03f, -1.53944239e-01f, 6.69274181e-02f, 4.04021703e-03f, -1.00931019e-01f, 3.36510092e-02f, -1.96892902e-01f, 3.37139219e-02f, -4.64657806e-02f,
  6.65294677e-02f, -3.73521410e-02f, -5.76914996e-02f, 3.73298563e-02f, -9.47623625e-02f, -1.64359495e-01f, -1.63934880e-03f, 3.42455343e-04f, -3.34890261e-02f, -5.50025180e-02f,
  4.35105599e-02f, 8.42501372e-02f, -1.12199493e-01f, -3.51255983e-02f, 1.23048477e-01f, 9.74568948e-02f, 1.89319044e-01f, 6.17961250e-02f, 7.36837685e-02f, -2.85583325e-02f,
  -2.15806421e-02f, 8.27289838e-03f, 9.82588455e-02f, -1.65073592e-02f, 5.54534490e-04f, 1.19468793e-01f, -1.01234078e-01f, 5.49594052e-02f, -1.37381791e-03f, 3.47730406e-02f,
  -1.13381140e-01f, -2.01154519e-02f, 5.87834865e-02f, 7.11568445e-03f, 4.07873094e-02f, -1.83210105e-01f, -2.84763277e-01f, 9.91209447e-02f, 2.39810780e-01f, -1.25128329e-01f,
  -1.17568046e-01f, 9.09903273e-02f, -6.36613229e-03f, -3.21755826e-01f, -2.92584419e-01f, -6.90207481e-02f, -1.41223550e-01f, -2.18276560e-01f, 1.03493951e-01f, 4.25213389e-02f,
  1.71713576e-01f, -2.30727538e-01f, -1.02469094e-01f, 6.58401847e-02f, -1.87663540e-01f, 2.44440898e-01f, 8.44608843e-02f, 6.76963776e-02f, 4.93493415e-02f, -1.21778011e-01f,
  -1.60681874e-01f, 1.55739114e-01f, 1.55948168e-02f, -8.93865246e-03f, -2.26016133e-03f, -5.88257285e-03f, -7.86775053e-02f, -1.68790609e-01f, 2.86694542e-02f, 3.78947146e-02f,
  5.70240151e-03f, 4.52427752e-02f, 8.70900974e-02f, -2.66564786e-02f, 3.92629802e-02f, 5.75273633e-02f, 7.25967214e-02f, -3.09406202e-02f, 9.50922519e-02f, -1.26156798e-02f,
  1.08131990e-01f, -2.87659746e-02f, 1.71611942e-02f, 8.62184539e-02f, 1.26597047e-01f, -2.20518038e-02f, 3.78369936e-03f, 4.88728173e-02f, 6.70958310e-02f, 7.96670839e-02f,
  -3.90592925e-02f, 3.42285447e-02f, -9.12313238e-02f, -7.95392618e-02f, -3.32150757e-02f, -3.05371173e-02f, 2.35868320e-02f, 1.23860259e-02f, -3.00266016e-02f, -6.84712902e-02f,
  3.38146389e-02f, -1.32301733e-01f, 1.07039707e-02f, 3.08726970e-02f, -4.73753475e-02f, -2.40527168e-02f, -2.43766159e-02f, -5.25914356e-02f, 6.92709535e-02f, -3.81573401e-02f,
  9.00751278e-02f, -2.83910297e-02f, -1.17999516e-01f, -4.02065814e-02f, -8.81565139e-02f, 3.82435434e-02f, 3.40430662e-02f, -5.98976715e-03f, -2.24082377e-02f, -1.19097844e-01f,
  4.09557112e-03f, 1.40839452e-02f, 9.30037573e-02f, -6.18609153e-02f, 4.71113361e-02f, -3.81474011e-02f, -8.82529169e-02f, -1.94234625e-02f, -4.54495801e-03f, 1.68568175e-02f,
  -3.49932350e-02f, -1.18696643e-02f, 2.55809631e-02f, 5.49167469e-02f, -3.70950513e-02f, 6.51123822e-02f, 2.65781395e-02f, 4.17461358e-02f, 8.34314749e-02f, 9.40583274e-02f,
  3.23960558e-02f, -7.03032017e-02f, 6.90765232e-02f, 5.91704017e-03f, -6.55434951e-02f, 2.43909447e-03f, 6.64614066e-02f, 5.96630909e-02f, 7.71397576e-02f, 7.93745220e-02f,
  -1.30120739e-01f, -2.87118465e-01f, -3.76687258e-01f, 2.08423976e-02f, 7.26382956e-02f, 1.90732941e-01f, 2.54648000e-01f, 4.89767492e-02f, 3.19086574e-02f, 2.15971246e-01f,
  1.75840020e-01f, -1.24236852e-01f, 2.86702961e-02f, 1.90581679e-01f, -5.63751115e-03f, 4.45845500e-02f, 1.98066473e-01f, 3.45799327e-02f, 2.05227286e-02f, -2.78766565e-02f,
  -3.10383067e-02f, 2.17354983e-01f, -1.05396703e-01f, 7.51956850e-02f, 7.49630406e-02f, -1.39331788e-01f, 9.61832330e-02f, 7.74928927e-02f, 1.23476222e-01f, -6.77500069e-02f,
  6.83327988e-02f, -6.82181865e-02f, -4.35851216e-02f, -5.85202463e-02f, 2.39361171e-02f, -3.66245955e-02f, -2.03410275e-02f, -7.79120624e-02f, 3.09291743e-02f, 1.08858958e-01f,
  6.44595874e-03f, -2.71074381e-02f, -5.86470589e-02f, 4.00721319e-02f, 9.08865780e-02f, 6.45527318e-02f, 1.54385727e-03f, -3.52891833e-02f, 5.00428379e-02f, -4.79717143e-02f,
  8.12427327e-03f, 1.75313111e-02f, 5.99842817e-02f, -2.52842205e-03f, 1.16892401e-02f, -6.40654415e-02f, 3.98641266e-03f, 7.38399848e-03f, 1.33740790e-02f, 1.84981078e-02f,
  -3.70576940e-02f, 1.91483330e-02f, -3.50752808e-02f, 2.23283693e-02f, -2.23485124e-03f, 5.59571274e-02f, 6.99891672e-02f, 7.83640444e-02f, 3.26211099e-03f, 5.37090115e-02f,
  -1.40920384e-02f, -9.67478231e-02f, 7.06245601e-02f, 2.16340423e-02f, 5.72978444e-02f, -2.44851131e-03f, -4.24503833e-02f, -7.74674416e-02f, 2.61545293e-02f, 5.97177185e-02f,
  4.62229401e-02f, 4.56606299e-02f, -5.94317503e-02f, -1.54595645e-02f, -4.93986271e-02f, 7.88514391e-02f, 6.98835924e-02f, -2.99399942e-02f, 7.18307868e-02f, -9.82203111e-02f,
  8.60617608e-02f, -5.93436742e-03f, -1.66100729e-02f, -2.51294952e-02f, -4.87075336e-02f, -4.98213731e-02f, -2.70601809e-02f, -7.01511418e-03f, -4.03701849e-02f, 2.51898367e-04f,
  -1.74640194e-02f, 3.90641019e-03f, 7.92406648e-02f, 2.05315761e-02f, -4.60521691e-02f, 4.04949039e-02f, -3.23236063e-02f, -2.36165430e-02f, 4.89828065e-02f, 2.61178948e-02f,
  -7.51137659e-02f, 7.11334273e-02f, -6.92299427e-03f, 7.62840966e-03f, 3.62411886e-02f, -1.22293402e-02f, 1.35522217e-01f, -1.64059624e-02f, 3.68944257e-02f, 7.48743415e-02f,
  -4.47492413e-02f, -1.39214694e-01f, -3.15446630e-02f, -9.95494425e-02f, -1.08589604e-01f, 1.70097366e-01f, -2.51356093e-03f, -1.15373425e-01f, -1.81899127e-02f, -7.53255337e-02f,
  3.55601162e-02f, -1.01376675e-01f, 1.70803741e-01f, -2.32667811e-02f, 5.07368505e-01f, 2.48105869e-01f, 1.88586004e-02f, -3.85750011e-02f, 3.05281766e-03f, -1.12861767e-01f,
  -8.00739694e-03f, 4.19843681e-02f, -1.14345454e-01f, -5.68806380e-02f, -1.38096035e-01f, -1.24353096e-01f, 5.72161488e-02f, 2.49233618e-02f, -6.18796498e-02f, 1.27369493e-01f,
  -1.27234086e-01f, -1.23287417e-01f, -2.07468290e-02f, 6.67333752e-02f, 3.71792838e-02f, 3.98528166e-02f, 1.52230831e-02f, 1.48858264e-01f, 2.21827216e-02f, 4.58039902e-02f,
  4.82531562e-02f, 8.86160880e-02f, 2.44870298e-02f, 6.64950162e-02f, -4.82767597e-02f, -7.80080482e-02f, 2.19845772e-02f, 8.12685117e-02f, -1.38627276e-01f, 8.07575416e-03f,
  -7.51526803e-02f, 4.22422364e-02f, 4.20318767e-02f, 9.82386470e-02f, -3.79264988e-02f, 1.93609751e-03f, 6.56898320e-02f, -1.50383310e-02f, -1.20459814e-02f, -1.92292202e-02f,
  1.61290884e-01f, 4.26037936e-03f, 1.66294426e-02f, -3.91960964e-02f, -3.57483998e-02f, -2.00375747e-02f, 6.30909726e-02f, -1.39628602e-02f, 3.25265042e-02f, -8.11323598e-02f,
  -5.01222946e-02f, -6.50929883e-02f, -7.25857839e-02f, 2.32723877e-02f, -4.06237133e-02f, -1.09179601e-01f, 5.96911460e-02f, 1.10766426e-01f, 5.85074574e-02f, -1.95936784e-02f,
  -7.62371942e-02f, 2.54887026e-02f, -2.23472118e-02f, -1.76334139e-02f, -2.47875154e-02f, -2.26300880e-02f, -2.76030526e-02f, 1.87964682e-02f, 5.26003307e-03f, 3.83601449e-02f,
  -1.59200817e-01f, -9.03010741e-02f, -9.04597118e-02f, -9.92192701e-03f, -8.07955116e-02f, 5.54369427e-02f, 1.32863056e-02f, 8.84784982e-02f, 1.72333233e-02f, 1.03971459e-01f,
  6.50901869e-02f, -6.66363165e-02f, -3.84672603e-04f, 6.61196783e-02f, 9.81971435e-03f, -2.50916220e-02f, -4.24361229e-03f, -3.29584219e-02f, -2.14018766e-02f, 5.23431227e-02f,
  -1.60925761e-02f, 8.13685432e-02f, -6.15021512e-02f, -5.74984476e-02f, 1.00589789e-01f, -2.42876485e-02f, -1.73361436e-03f, 4.43505272e-02f, 8.07533562e-02f, -1.54775735e-02f,
  1.91197261e-01f, 4.30639908e-02f, 1.78196177e-01f, 2.36475337e-02f, 1.67312682e-01f, -1.77911308e-03f, -2.90741250e-02f, 1.69530928e-01f, 2.58307457e-01f, -1.19120523e-01f,
  1.41286310e-02f, 1.00292325e-01f, -5.08997366e-02f, 1.16058970e-02f, -2.46550351e-01f, -1.21467687e-01f, 8.19597393e-02f, 4.62129153e-03f, 1.14613935e-01f, -1.42243681e-02f,
  -4.38187970e-04f, -1.20400831e-01f, 7.94290565e-03f, 2.85123214e-02f, 1.71538785e-01f, 1.01565249e-01f, -2.52451450e-01f, 9.29076672e-02f, -1.51616588e-01f, -3.46778929e-02f,
  -4.51114476e-02f, 1.39631897e-01f, 1.30895138e-01f, -2.76302863e-02f, -1.57616828e-02f, -5.32907359e-02f, -9.92884189e-02f, -4.67180908e-02f, 9.64695439e-02f, -4.76480043e-03f,
  -1.19758755e-01f, -1.43166617e-01f, -5.77109419e-02f, 5.34058958e-02f, 1.65262789e-01f, 1.88168287e-01f, 3.60896774e-02f, 4.49218526e-02f, -6.24380819e-03f, 1.35335494e-02f,
  1.13195226e-01f, 4.39173728e-02f, 6.17441908e-02f, -1.40131041e-01f, -4.28852104e-02f, -5.99925593e-03f, -8.82494450e-02f, -1.03871599e-01f, -8.44383538e-02f, -5.39241498e-03f,
  -2.84666941e-02f, 4.72207852e-02f, -5.41813262e-02f, 2.38100588e-02f, 6.97045475e-02f, 1.18686706e-02f, 1.28102720e-01f, -7.26571083e-02f, 7.66224936e-02f, 3.94312926e-02f,
  -5.14992923e-02f, -2.92817000e-02f, 1.28564220e-02f, 2.42712162e-02f, -6.64312392e-02f, -5.87016195e-02f, -1.15377218e-01f, 3.69358025e-02f, 4.17175479e-02f, 3.73465084e-02f,
  -9.70494375e-02f, -9.66372681e-06f, 9.04577784e-03f, -9.77092609e-03f, -1.77030470e-02f, -3.94001603e-02f, -4.77174036e-02f, 1.77213717e-02f, 1.00991212e-01f, -5.17095253e-02f,
  -1.68765873e-01f, -1.33915171e-01f, 5.92090786e-02f, -5.10019362e-02f, 2.89103035e-02f, 1.03033110e-02f, -1.82530321e-02f, -3.80683760e-03f, 5.11124590e-03f, -2.72177421e-02f,
  -6.86491579e-02f, -5.97965010e-02f, -9.74870175e-02f, -2.27921493e-02f, -6.30336553e-02f, -6.30308874e-03f, -1.22360922e-01f, -6.82433695e-03f, -9.27555189e-02f, -4.52906750e-02f,
  -5.64182773e-02f, -1.08391777e-01f, -6.04641670e-03f, -3.62369046e-02f, -6.13470525e-02f, -6.59999549e-02f, 9.61305350e-02f, -4.00839858e-02f, -6.80172592e-02f, 4.68830727e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.50719726e-01f, 1.71869397e-01f, 3.09420943e-01f, 3.24119568e-01f, -1.82378329e-02f, 1.65030181e-01f, 1.08436473e-01f, 2.57718444e-01f, 6.20021462e-01f, 7.66472565e-03f,
  -2.31975883e-01f, 1.95666701e-01f, -2.05539301e-01f, 1.04226321e-01f, -2.17857867e-01f, 4.58520018e-02f, 3.10074568e-01f, 1.14926100e-01f, 2.42255554e-01f, 1.59882635e-01f,
  1.82707548e-01f, -2.94923365e-01f, -1.87970698e-01f, -3.12609017e-01f, 3.78517769e-02f, 1.14790358e-01f, -4.96997088e-01f, -1.19800247e-01f, -1.28725424e-01f, -4.56271581e-02f,
  -2.78179012e-02f, 1.10282041e-01f, -8.59768242e-02f, -5.04699955e-03f, 5.42196222e-02f, -3.21745239e-02f, -7.25552365e-02f, -8.78808796e-02f, 2.88348757e-02f, 6.76587075e-02f,
  2.49800961e-02f, -2.08034907e-02f, 1.07864663e-01f, -1.02068968e-01f, 6.37631640e-02f, 2.32236157e-03f, 9.53408852e-02f, 4.15094793e-02f, -3.45919691e-02f, 1.75172943e-04f,
  1.39358304e-02f, -1.12946955e-02f, 4.07188013e-02f, 1.11779101e-01f, 2.58315187e-02f, 5.65435588e-02f, 3.26392800e-02f, 1.62447547e-03f, 3.12557979e-03f, 1.15285605e-01f,
  -2.19218489e-02f, 1.12193353e-01f, -5.38497642e-02f, -2.19172593e-02f, -1.70748774e-02f, -1.80828217e-02f, -4.64654043e-02f, -2.58637164e-02f, 1.06305420e-01f, 3.20131611e-03f,
  5.96532375e-02f, -4.77077626e-02f, 9.19856727e-02f, -1.17811039e-01f, 7.40165263e-02f, 1.40247280e-02f, -2.22335365e-02f, 6.83636218e-02f, 1.27497435e-01f, 4.84936833e-02f,
  -6.83984384e-02f, 5.86816631e-02f, -1.94910750e-01f, -3.32219638e-02f, -4.81376279e-04f, 1.72740389e-02f, -5.06567657e-02f, 2.81508658e-02f, -3.84353399e-02f, -5.13610020e-02f,
  8.41838568e-02f, 1.60162270e-01f, 6.05352707e-02f, -5.52954823e-02f, 8.68515074e-02f, -1.13891743e-01f, 1.85775265e-01f, 5.85414283e-02f, 5.76268956e-02f, 3.96541357e-02f,
  -5.05901175e-03f, 3.94393578e-02f, 1.47009017e-02f, -5.72100915e-02f, -3.71576138e-02f, 9.81834903e-03f, -3.40406746e-02f, 5.51512884e-03f, 4.89832461e-02f, -8.74754786e-03f,
  -7.43064135e-02f, 1.02460235e-02f, 1.17191218e-01f, -3.83891948e-02f, 3.14868577e-02f, -9.32664722e-02f, 7.63463080e-02f, 1.74255669e-02f, -4.24118042e-02f, 2.50722207e-02f,
  2.17329353e-01f, 5.08331299e-01f, 2.67691702e-01f, 3.88503641e-01f, -1.62999302e-01f, -2.98596054e-01f, -2.54839629e-01f, 2.44175315e-01f, -3.75814587e-02f, -9.62240770e-02f,
  -5.15425578e-02f, 1.02634907e-01f, 2.27984991e-02f, 1.64721832e-01f, 1.17063023e-01f, -1.07371859e-01f, 2.08702013e-01f, -1.06590884e-02f, 9.36390236e-02f, 2.23113596e-01f,
  1.32147998e-01f, -4.08168696e-03f, 3.20646524e-01f, 1.58807531e-01f, 2.18747601e-01f, 2.20648915e-01f, 2.45123684e-01f, 7.22070560e-02f, 1.37499213e-01f, -1.19913846e-01f,
  -9.29104909e-02f, -2.00464576e-02f, -1.18916286e-02f, -2.00489834e-01f, 1.06094263e-01f, -7.03029707e-02f, -8.21624696e-02f, -1.37224987e-01f, -7.56686404e-02f, -8.90050605e-02f,
  3.08460481e-02f, 2.17139209e-03f, 9.21802074e-02f, 4.11785999e-03f, -4.34619933e-02f, 2.10947767e-02f, 6.10775277e-02f, 3.24024223e-02f, 8.21144713e-05f, 5.47070801e-02f,
  1.97974592e-01f, 4.86387014e-02f, 2.58050356e-02f, 6.81380108e-02f, 1.40464589e-01f, 5.82929654e-03f, 2.51112431e-02f, 6.39721751e-02f, 3.30989882e-02f, -1.53457373e-02f,
  -9.47958604e-03f, 7.66024739e-02f, 6.37298450e-03f, -1.31565211e-02f, 8.17016419e-03f, 3.36921844e-03f, 6.51165619e-02f, -2.94402801e-02f, 3.44436020e-02f, -9.00818557e-02f,
  5.16328104e-02f, 4.66519259e-02f, -5.58977164e-02f, -5.30742258e-02f, 3.45720798e-02f, -5.43597993e-03f, 3.21611911e-02f, -1.08418763e-01f, -1.36071265e-01f, -2.87927222e-02f,
  -1.23679442e-02f, 2.25663297e-02f, 6.27058968e-02f, -1.90768670e-02f, -3.93066444e-02f, 9.58899781e-03f, -1.94602627e-02f, 3.24438587e-02f, -2.13956181e-02f, 1.11112423e-01f,
  8.17422718e-02f, 2.47110248e-01f, -3.83638963e-02f, -1.66436985e-01f, -2.13033147e-02f, -3.48826349e-02f, 1.40284887e-02f, 1.51297018e-01f, -2.85944920e-02f, -1.80999693e-02f,
  -8.31383318e-02f, -1.80823915e-03f, -1.21746145e-01f, 5.23082027e-03f, -6.17079288e-02f, 6.51762709e-02f, -6.96950853e-02f, -4.00065929e-02f, 7.77007267e-02f, 1.23192012e-01f,
  1.23476289e-01f, -2.26835143e-02f, 5.55244721e-02f, 2.11849064e-03f, 1.61316488e-02f, 8.20633695e-02f, -7.24720135e-02f, -6.34541810e-02f, 1.07048094e-01f, 6.37664422e-02f,
  9.57632735e-02f, 1.12974592e-01f, 1.25116304e-01f, 2.10083336e-01f, 3.72125916e-02f, -3.95672582e-02f, -4.72914785e-01f, 2.51133174e-01f, -2.44595826e-01f, -1.77375361e-01f,
  3.57914716e-02f, -4.64090332e-02f, -2.50639468e-01f, 2.39431977e-01f, 1.22584730e-01f, -4.56132472e-01f, 2.45264113e-01f, 4.56225080e-03f, -1.51250958e-01f, 1.19370103e-01f,
  1.17898099e-01f, 2.02428579e-01f, 2.21165389e-01f, 2.82436192e-01f, 5.85812889e-02f, 1.39185816e-01f, 1.76509321e-01f, -9.00976807e-02f, 4.17189419e-01f, 4.34171259e-02f,
  -1.92915462e-02f, 4.76398282e-02f, 5.10979816e-02f, -2.60235928e-02f, 1.75243914e-02f, 8.68133083e-02f, 9.71620679e-02f, -3.04957628e-02f, 5.66103943e-02f, -5.73332980e-02f,
  -3.42143737e-02f, 1.47706077e-01f, 1.52409241e-01f, 9.21499878e-02f, 8.93117189e-02f, 6.04748763e-02f, 5.03108688e-02f, 6.43420368e-02f, 3.75241070e-04f, 8.11494216e-02f,
  9.46487859e-03f, 5.21742627e-02f, 9.17187631e-02f, 6.40345216e-02f, -2.44719889e-02f, 3.31017352e-03f, 3.74929011e-02f, -1.57023855e-02f, 1.17403574e-01f, 1.37531042e-01f,
  5.56624830e-02f, -6.11583255e-02f, -9.09520462e-02f, 3.04635633e-02f, -2.45146715e-04f, 6.63656369e-03f, 4.61890624e-04f, -4.51521985e-02f, 2.22029723e-02f, 5.64999580e-02f,
  -3.16473492e-03f, 6.00522617e-04f, 3.58508504e-03f, 1.15057588e-01f, 8.84827897e-02f, 9.13688987e-02f, 2.79252063e-02f, 1.95948947e-02f, -3.68617475e-02f, -1.97861344e-02f,
  -3.07472441e-02f, 9.99144241e-02f, -4.66680601e-02f, 8.10963213e-02f, 5.93000501e-02f, 3.30549874e-03f, 3.51821072e-02f, -3.81922945e-02f, 1.21053066e-02f, 1.42721841e-02f,
  5.95953641e-03f, 4.56800833e-02f, -1.60976619e-01f, 2.67117303e-02f, -8.01332444e-02f, -2.84003317e-02f, 3.08723748e-02f, 1.42555922e-01f, 8.31593201e-02f, -5.57023771e-02f,
  1.70482665e-01f, 5.36004007e-02f, 1.54520785e-02f, 8.84440318e-02f, 7.55666196e-03f, 1.17632505e-02f, -3.62493731e-02f, 1.04102321e-01f, 1.23426251e-01f, 1.36300832e-01f,
  2.23101303e-02f, -7.92237371e-02f, -1.22164339e-02f, -1.85790155e-02f, 7.14751706e-02f, -7.24117085e-02f, -1.69603378e-02f, -5.81326634e-02f, 2.96773668e-02f, 6.87969327e-02f,
  -8.58792543e-01f, 8.92434046e-02f, -1.04698852e-01f, -1.40165776e-01f, -2.33112708e-01f, -1.80701613e-01f, 7.81767294e-02f, -9.52948183e-02f, -4.33914922e-02f, 1.37564525e-01f,
  2.46852338e-02f, -1.65707469e-01f, 1.42621115e-01f, 2.03384638e-01f, -2.71533608e-01f, 3.43301475e-01f, -1.24794945e-01f, 8.23848471e-02f, 9.45391431e-02f, -2.70207107e-01f,
  -1.17329754e-01f, 5.71631081e-02f, 4.79511619e-02f, -6.45257309e-02f, -2.59587616e-01f, -1.14831939e-01f, 5.39881438e-02f, -1.02823943e-01f, -8.81099999e-02f, -4.68560532e-02f,
  -3.88471067e-01f, -3.66684109e-01f, -5.84664792e-02f, -1.11732177e-01f, -6.38292655e-02f, 2.83004530e-02f, -9.08013880e-02f, -2.47808010e-03f, -4.36107144e-02f, -1.48015976e-01f,
  1.62322596e-02f, -9.64821577e-02f, -7.40761310e-02f, -4.38806154e-02f, -5.86773008e-02f, -6.38723671e-02f, 9.43035260e-02f, -1.01796724e-02f, 3.70447114e-02f, 5.58082648e-02f,
  -8.33408535e-03f, -5.40726706e-02f, -2.07427982e-03f, -2.46279631e-02f, -4.73624468e-02f, -8.36330280e-02f, 1.27487883e-01f, -7.20825046e-02f, -1.55103132e-01f, -1.85903668e-01f,
  7.09251501e-03f, 3.82426567e-02f, 6.13477752e-02f, -2.43341420e-02f, 1.44439228e-02f, -1.46022812e-03f, 1.33267328e-01f, 1.06792390e-01f, 5.02172746e-02f, -2.35232525e-02f,
  -7.05890730e-02f, -1.01199232e-01f, -5.88812493e-02f, 4.69720587e-02f, -2.58800127e-02f, 1.19916769e-02f, -3.06812599e-02f, -3.75978872e-02f, 1.39987305e-01f, -5.25168851e-02f,
  -8.48281384e-02f, 9.15688798e-02f, 8.26442316e-02f, 1.10207818e-01f, -5.67421801e-02f, -1.23329321e-02f, -6.69700801e-02f, 2.10902691e-02f, 1.17373392e-02f, -3.05496361e-02f,
  -5.50898612e-01f, -5.14324844e-01f, 3.88785731e-03f, -1.52114630e-01f, -6.93811178e-02f, -6.06399290e-02f, 8.14734176e-02f, -4.93750311e-02f, -9.82555002e-02f, -1.10454746e-01f,
  -5.73390909e-02f, 5.45421094e-02f, -1.04135774e-01f, -3.41581553e-02f, 4.73180264e-02f, -2.04663761e-02f, 2.18859445e-02f, -1.16927214e-02f, -6.77197948e-02f, -2.98508890e-02f,
  -4.22319397e-02f, 1.53728183e-02f, 6.33883700e-02f, 4.89521138e-02f, 9.47328582e-02f, -4.20578495e-02f, 5.69749251e-03f, -5.08458652e-02f, -1.41631201e-01f, 4.33060192e-02f,
  2.01586008e-01f, 3.19848657e-02f, -2.61354834e-01f, -6.20156452e-02f, 1.08245634e-01f, 1.75040156e-01f, -5.29389679e-02f, 1.40269935e-01f, -2.29325414e-01f, 1.46728665e-01f,
  1.74418911e-01f, -9.55487341e-02f, -2.83282757e-01f, 1.27053782e-01f, 7.86365941e-02f, -2.09578946e-01f, 1.63919896e-01f, 4.75592911e-02f, -8.97147804e-02f, 2.93500632e-01f,
  1.38314098e-01f, 3.74322921e-01f, -8.52829963e-02f, 2.99483836e-01f, 1.88260511e-01f, 6.02416508e-02f, 2.23704189e-01f, 2.28411369e-02f, 3.38447511e-01f, 5.80894537e-02f,
  -3.32192667e-02f, 5.07048843e-03f, -3.67106870e-02f, -7.25617483e-02f, 1.28440440e-01f, 1.96938902e-01f, 6.77506551e-02f, -1.78010650e-02f, -1.69613630e-01f, -9.77105349e-02f,
  -3.28438217e-03f, -1.04400180e-01f, 1.46899214e-02f, -3.39314155e-02f, 1.99489649e-02f, -1.43744960e-01f, -1.43000752e-01f, -1.03260934e-01f, -1.98389277e-01f, 4.90877852e-02f,
  -1.62496269e-01f, -1.22257836e-01f, -8.30796361e-02f, -1.30241975e-01f, -1.08858407e-01f, -9.46918130e-02f, 2.85118464e-02f, 3.23729701e-02f, -1.25428468e-01f, 4.98097800e-02f,
  1.61063328e-01f, 2.02074327e-04f, 5.93374968e-02f, -8.17695409e-02f, 2.16593798e-02f, -2.21744999e-02f, -9.06128064e-03f, -5.76639809e-02f, 5.09480201e-02f, 2.82830857e-02f,
  -7.36277625e-02f, 3.38879116e-02f, -3.75059657e-02f, 1.08163759e-01f, -4.85097291e-03f, -3.74793522e-02f, 4.30672690e-02f, 1.01159878e-01f, -1.75357647e-02f, -9.51059312e-02f,
  -2.20606953e-01f, -5.24590723e-02f, 7.10583553e-02f, -1.14752091e-01f, 1.13904597e-02f, -3.56083438e-02f, 1.02930464e-01f, 1.49369729e-03f, -4.11035791e-02f, 5.24021983e-02f,
  1.70318946e-01f, 1.48250371e-01f, -1.07779056e-01f, -6.25100881e-02f, 2.55989898e-02f, 1.49167523e-01f, -3.84621844e-02f, 1.43859237e-01f, 2.83742752e-02f, 1.66185915e-01f,
  1.84135914e-01f, -6.74113305e-03f, 5.41781867e-03f, 1.27993785e-02f, -1.68292131e-02f, 1.78517565e-01f, -1.23300345e-03f, -3.14783975e-02f, -9.31350589e-02f, 6.36128038e-02f,
  4.90675308e-02f, -7.97179341e-03f, -5.28649464e-02f, -2.08798125e-02f, 6.90769963e-03f, 6.39975518e-02f, 2.19122414e-02f, 4.01754305e-02f, -2.66972687e-02f, -1.21366262e-01f,
  4.31027710e-01f, -6.85693443e-01f, -1.89105138e-01f, 3.58230382e-01f, 3.18855494e-01f, 3.12825143e-02f, 1.31461844e-01f, 1.13806516e-01f, 6.66028857e-02f, -3.01675707e-01f,
  7.48906806e-02f, -2.44607076e-01f, -2.30756089e-01f, 1.22454137e-01f, 3.53779942e-01f, -1.56303719e-01f, 2.30050907e-01f, 6.14093095e-02f, -4.14521918e-02f, -7.30122998e-02f,
  1.54726282e-01f, 2.22460747e-01f, 6.47837808e-03f, 1.49580657e-01f, 1.23506449e-01f, -3.76265608e-02f, -5.80344908e-02f, -1.71728849e-01f, 2.10857525e-01f, 1.10006422e-01f,
  4.08026166e-02f, 8.51987004e-02f, 3.66672687e-02f, -1.22797638e-02f, -6.59423470e-02f, -5.40202111e-02f, -1.28652871e-01f, -3.37032825e-02f, 7.92596191e-02f, -3.35722119e-02f,
  -9.29939896e-02f, -2.70243622e-02f, 1.04974695e-01f, 3.24260369e-02f, -6.60838932e-02f, 8.33036080e-02f, 1.55834407e-01f, -1.46601042e-02f, -3.08888666e-02f, -2.43519712e-02f,
  -5.70273064e-02f, -6.63164118e-03f, 4.09804173e-02f, 2.67004371e-02f, -5.48676588e-02f, 3.00341193e-02f, 1.60701741e-02f, -7.02208430e-02f, -3.23377200e-03f, 3.57934572e-02f,
  2.02223621e-02f, 1.44661302e-02f, -8.20432380e-02f, -3.40484106e-03f, 1.76778547e-02f, 7.03337640e-02f, 5.78469085e-03f, 6.75737560e-02f, -6.55484423e-02f, -1.26719981e-01f,
  1.05805300e-01f, 3.34100984e-02f, -3.01204883e-02f, -1.38567060e-01f, 5.74700050e-02f, 2.77913492e-02f, -3.95100974e-02f, -2.30897982e-02f, -2.17919033e-02f, 7.91733153e-03f,
  1.48818925e-01f, 1.13047529e-02f, -3.96844260e-02f, -2.53797937e-02f, 7.68693760e-02f, 6.21385798e-02f, -4.28982191e-02f, -2.83288751e-02f, -3.34044732e-02f, 4.73045446e-02f,
  -4.31075543e-01f, -4.10516500e-01f, 5.70717864e-02f, 3.08049731e-02f, -8.22572410e-02f, -1.71123538e-02f, 1.38503173e-02f, 2.67340150e-02f, -1.67734206e-01f, -3.74483429e-02f,
  -8.67499635e-02f, 1.41883772e-02f, -2.11135522e-02f, 4.15256396e-02f, 3.60865667e-02f, -2.01346334e-02f, -1.22124448e-01f, -1.34264857e-01f, 8.22794959e-02f, -2.84318049e-02f,
  -6.85713664e-02f, -9.80115458e-02f, 4.22606803e-02f, 3.38070504e-02f, 2.31376197e-02f, 3.08714267e-02f, 2.21445300e-02f, 1.25112934e-02f, -6.89173350e-03f, 4.00939910e-03f,
  8.08293074e-02f, 1.85395315e-01f, -7.41118565e-02f, 4.40182574e-02f, -2.30256602e-01f, -3.40381593e-01f, -1.69115990e-01f, -1.54009797e-02f, 2.37235889e-01f, 1.57682389e-01f,
  -2.11396188e-01f, 3.77985001e-01f, 4.35012132e-02f, 1.94832664e-02f, -3.43775421e-01f, -5.70515133e-02f, -3.90940487e-01f, 1.94088444e-02f, -8.74500535e-03f, -1.77500725e-01f,
  -1.29088700e-01f, -2.89055258e-01f, -1.88122645e-01f, -6.38282578e-03f, -2.39813961e-02f, 1.83376357e-01f, -4.36914861e-02f, -5.64808622e-02f, 8.56837332e-02f, 3.12594953e-03f,
  2.21833382e-02f, 1.79716021e-01f, 1.40239477e-01f, -3.64970304e-02f, -1.87087104e-01f, -5.94520792e-02f, -1.38750896e-01f, -2.65636612e-02f, 5.37008867e-02f, 7.89076388e-02f,
  6.63893148e-02f, 3.09405457e-02f, -8.74659717e-02f, 1.28660902e-01f, 3.92977372e-02f, 1.73820049e-01f, 3.29693919e-03f, -8.04994404e-02f, 1.33994192e-01f, 2.89725922e-02f,
  4.48803827e-02f, 1.06748275e-01f, -7.78724477e-02f, 7.60299191e-02f, 3.62009518e-02f, 4.12922055e-02f, -5.51205501e-02f, -1.56343319e-02f, 1.32420719e-01f, 1.19154498e-01f,
  -9.49969292e-02f, -7.42708519e-02f, 2.89440174e-02f, 1.03573732e-01f, 9.68121514e-02f, -1.12468563e-02f, 6.61569461e-02f, -8.05128515e-02f, -1.75448600e-02f, -2.01048031e-02f,
  6.26743808e-02f, 7.38197640e-02f, 6.92261457e-02f, 1.69485118e-02f, -5.78762889e-02f, 1.42213702e-01f, -7.55002871e-02f, 5.07915877e-02f, -8.25111493e-02f, -5.49016967e-02f,
  1.73334271e-01f, -5.47279455e-02f, 4.71397117e-02f, -1.28370179e-02f, -1.28388135e-02f, 1.05468690e-01f, 8.01057890e-02f, 8.19188058e-02f, -2.43538581e-02f, -8.00668821e-02f,
  -2.22776607e-01f, -1.47194490e-01f, 3.06889936e-02f, 1.27948239e-01f, 2.64154170e-02f, 1.99613310e-02f, -8.77912492e-02f, 5.30924164e-02f, -1.47234663e-01f, -4.58824895e-02f,
  -6.39489964e-02f, 3.81151028e-02f, -5.53352721e-02f, 2.92615611e-02f, 1.18868221e-02f, -2.02388335e-02f, -6.14189878e-02f, -2.66637895e-02f, -3.46407592e-02f, -2.97385864e-02f,
  7.53412992e-02f, -2.11203378e-02f, -3.01661287e-02f, -1.39524583e-02f, -1.04570784e-01f, 2.71906648e-02f, 3.87996323e-02f, 1.14400335e-01f, -8.75832886e-02f, -1.00751929e-01f,
  -8.98373127e-01f, 3.31830084e-01f, 1.86089292e-01f, -5.35824239e-01f, 1.93013340e-01f, 2.65202131e-02f, -1.22955546e-01f, 3.14114958e-01f, -1.10677771e-01f, 8.81310832e-03f,
  -7.50474120e-03f, -9.77061167e-02f, 1.79511130e-01f, 8.39842111e-03f, -2.33035371e-01f, 4.83498462e-02f, -2.18707621e-01f, -2.33680829e-01f, 1.02580167e-01f, -3.00907791e-02f,
  -5.93407899e-02f, 8.32245648e-02f, 5.71260927e-03f, 4.03014988e-01f, 8.35865363e-02f, -6.72905967e-02f, -2.07215860e-01f, 2.59458870e-01f, -1.54015377e-01f, 1.33249253e-01f,
  -2.81806868e-02f, 8.76548737e-02f, 2.34991871e-02f, 4.19272259e-02f, -9.40988772e-03f, 7.42877051e-02f, -5.06241694e-02f, 1.13048628e-01f, 6.68079266e-03f, 4.66013141e-02f,
  -2.50788890e-02f, 8.05987790e-02f, 2.46933792e-02f, 5.19657135e-02f, 7.59306969e-03f, 4.70082164e-02f, 6.27000928e-02f, -1.94067098e-02f, -3.58820036e-02f, 4.97982055e-02f,
  8.72635692e-02f, 5.45168370e-02f, -9.25153941e-02f, -1.51195362e-01f, -1.36676177e-01f, 1.09564625e-01f, -3.93072739e-02f, -7.32288659e-02f, -8.24657604e-02f, -4.48926762e-02f,
  8.55274126e-02f, -2.73834895e-02f, -1.73769612e-02f, 2.05431553e-03f, -3.89443561e-02f, 1.09071717e-01f, 9.10924748e-03f, -1.58246011e-02f, -1.65440701e-03f, 1.03219142e-02f,
  -4.32459190e-02f, -4.95043732e-02f, 7.32080564e-02f, -3.60763818e-02f, -3.90360914e-02f, -5.92063516e-02f, -8.63591582e-02f, 7.49107450e-02f, 3.46182361e-02f, -1.36699947e-02f,
  -8.94899480e-03f, -7.43407086e-02f, -5.39636910e-02f, -1.30111410e-03f, 1.36858732e-01f, -4.04505469e-02f, 6.26073852e-02f, 4.97369133e-02f, -3.70564535e-02f, -4.01198007e-02f,
  -4.50463206e-01f, -2.75887579e-01f, 3.02405469e-02f, -3.93529274e-02f, -3.49089801e-02f, -8.05203430e-03f, 6.08809888e-02f, -3.23274964e-03f, -6.87015355e-02f, 5.87769784e-02f,
  6.45226613e-02f, -6.67629242e-02f, -1.80075958e-01f, -1.04193445e-02f, 4.52701822e-02f, -1.55325355e-02f, -2.70609818e-02f, -3.93938385e-02f, -7.24158511e-02f, -4.82420027e-02f,
  -4.00865115e-02f, -1.68630611e-02f, -1.39611075e-02f, -4.98334654e-02f, -1.45062909e-01f, -1.84905939e-02f, -6.51357695e-02f, -1.60635787e-03f, -6.03247480e-03f, -3.98028009e-02f,
  2.59477764e-01f, -2.40921110e-01f, 2.37120956e-01f, 6.10494986e-02f, 5.27772903e-01f, 2.79465944e-01f, 3.37986022e-01f, -1.28992945e-02f, 1.56207886e-02f, -3.81328702e-01f,
  -1.09720685e-01f, -1.79379866e-01f, 1.36226982e-01f, -2.47289106e-01f, 2.02148482e-01f, 7.76963085e-02f, 9.92682762e-03f, -1.29643157e-01f, 1.31228313e-01f, 6.37761280e-02f,
  1.98172480e-01f, 4.90859225e-02f, 4.08174634e-01f, 2.51330761e-03f, 1.73689857e-01f, -1.02859229e-01f, -1.16149575e-01f, 8.14771876e-02f, -3.61899942e-01f, -1.57970432e-02f,
  1.23087103e-02f, 9.36626643e-03f, 1.10299595e-01f, -1.22256778e-01f, 4.62374799e-02f, 5.93420975e-02f, 1.61153860e-02f, 2.29325052e-02f, 2.54951939e-02f, 8.89751315e-03f,
  -7.17058182e-02f, -2.42316094e-03f, -1.04089640e-02f, 2.14325152e-02f, 3.80022153e-02f, 1.34516163e-02f, 1.08868860e-01f, 6.94114566e-02f, -7.09895464e-03f, 1.68645948e-01f,
  1.00696653e-01f, -5.33540398e-02f, 3.10072098e-02f, -1.60102338e-01f, 3.68005261e-02f, -3.76324803e-02f, 3.16070840e-02f, 4.99792658e-02f, 8.02186280e-02f, -4.74407598e-02f,
  -1.39409187e-03f, -1.50341755e-02f, 3.38038430e-02f, -4.49008383e-02f, 1.25136137e-01f, 6.19308203e-02f, 5.46470396e-02f, 3.19096036e-02f, -4.47666785e-03f, -6.12302087e-02f,
  1.46865202e-02f, -1.84989460e-02f, -3.27698723e-03f, -2.92278193e-02f, -2.43515819e-02f, 3.89855839e-02f, -1.00723244e-01f, -1.33714408e-01f, -8.90388191e-02f, 4.63947915e-02f,
  -3.56535874e-02f, 2.47705467e-02f, 3.79147306e-02f, 5.75848110e-02f, -6.47772774e-02f, 6.18738607e-02f, -1.15325816e-01f, 7.18874261e-02f, 7.83994794e-02f, 4.59022410e-02f,
  -2.05752641e-01f, -4.16345984e-01f, -6.99981302e-02f, -1.04479633e-01f, -5.69337159e-02f, -9.36456323e-02f, -6.56384081e-02f, -1.12021267e-01f, -4.94363271e-02f, 3.09850778e-02f,
  2.34627295e-02f, -2.69100768e-03f, 1.81644950e-02f, -1.29303336e-01f, -3.67065445e-02f, -1.91084500e-02f, -1.23958379e-01f, -1.17069311e-01f, -6.53612241e-02f, 5.48329502e-02f,
  1.59701239e-02f, 1.70163326e-02f, -3.13674323e-02f, 1.83721364e-01f, -1.51546046e-01f, -2.08094697e-02f, 6.07240945e-03f, -7.88119808e-02f, -5.05868159e-02f, 5.22233136e-02f,
  1.83149993e-01f, 5.71244732e-02f, -2.39160150e-01f, -9.87230688e-02f, -2.98854917e-01f, -8.79594013e-02f, -2.31693257e-02f, -5.36624193e-02f, -9.20702964e-02f, 2.62281597e-01f,
  -4.07125689e-02f, -9.45513770e-02f, 3.71362001e-01f, 2.97420826e-02f, 3.95390131e-02f, 3.04716945e-01f, 1.61911339e-01f, 1.01058252e-01f, -1.00475088e-01f, -2.33442336e-02f,
  -9.10301059e-02f, 3.32677998e-02f, -1.10075520e-02f, -1.10616110e-01f, -1.92971632e-01f, -1.20623074e-01f, 3.40745039e-02f, -2.75263697e-01f, -1.68434262e-01f, -1.03798993e-01f,
  -5.70651144e-03f, -4.77380604e-02f, -2.69900579e-02f, 6.68530092e-02f, 1.80984605e-02f, 5.70301004e-02f, -9.64545608e-02f, 3.03515960e-02f, -1.67005375e-01f, 2.07546935e-03f,
  -6.89873891e-03f, 2.42288578e-02f, 2.10196048e-01f, -3.15091088e-02f, -1.95941985e-01f, -1.16867684e-01f, -4.70829643e-02f, -6.84337765e-02f, -7.48747066e-02f, 7.25351050e-02f,
  -2.41235308e-02f, -3.14486511e-02f, -1.17280401e-01f, 5.32552339e-02f, -1.00968532e-01f, 4.06405702e-02f, 1.51666537e-01f, -3.37652490e-02f, 6.20570444e-02f, 1.85947865e-02f,
  1.06124282e-02f, 1.00516275e-01f, 2.06417143e-01f, -1.30017167e-02f, -9.30049270e-02f, -1.66489184e-02f, -6.67066034e-03f, 5.05712144e-02f, -1.49738118e-02f, 4.65716235e-02f,
  -1.27165750e-01f, -7.77906403e-02f, -5.47585115e-02f, 1.42819226e-01f, 8.38459730e-02f, 4.93223146e-02f, -2.39809714e-02f, -1.29918322e-01f, -7.31374770e-02f, 1.59790572e-02f,
  3.06941718e-02f, -1.16040632e-02f, 6.08550608e-02f, 8.54988843e-02f, -8.34782869e-02f, 8.29373952e-03f, -1.79216582e-02f, -1.34371296e-02f, -6.13643304e-02f, -4.41115499e-02f,
  4.38390300e-02f, 1.55086234e-01f, 3.92680094e-02f, -6.96896240e-02f, 8.97087809e-03f, -4.85973097e-02f, 2.26363000e-02f, 5.68338260e-02f, -1.37381461e-02f, -5.35150394e-02f,
  1.01440270e-02f, 8.43198225e-02f, 3.75641920e-02f, -1.00300223e-01f, -5.32055870e-02f, 8.16168487e-02f, 8.61842409e-02f, 1.92579143e-02f, -1.05197988e-02f, 8.12219605e-02f,
  -2.05342751e-02f, 3.32308598e-02f, 1.25364855e-01f, 7.11317807e-02f, 4.54821102e-02f, -4.62283306e-02f, -3.10189333e-02f, -5.60957976e-02f, -5.62038720e-02f, 6.67162240e-02f,
  -3.92236054e-01f, -2.62763184e-02f, 5.12085319e-01f, -2.01538622e-01f, 5.97298481e-02f, 4.79764253e-01f, 4.20728117e-01f, -3.81436236e-02f, -1.10097401e-01f, -1.41384870e-01f,
  -1.36210084e-01f, 7.87220821e-02f, 1.91949829e-01f, -9.20233130e-02f, 4.89143252e-01f, 1.76329046e-01f, -4.48361114e-02f, -4.00870666e-02f, 6.73075467e-02f, -2.48562932e-01f,
  -1.08515970e-01f, -1.51716486e-01f, 2.14908049e-01f, -1.74736857e-01f, -9.64612886e-02f, -1.61374092e-01f, -1.09557308e-01f, 2.22777218e-01f, -9.55346450e-02f, 1.41167358e-01f,
  8.32321122e-03f, -3.05603743e-01f, 1.85902175e-02f, 1.48464721e-02f, -5.80183277e-03f, 8.10754970e-02f, -3.24088745e-02f, 2.19856948e-01f, -1.01965654e-03f, 4.03248966e-02f,
  1.46904355e-02f, 2.93285456e-02f, -1.18439630e-01f, 7.28863478e-02f, -3.17029022e-02f, -6.50351346e-02f, -9.98012628e-03f, -2.07993444e-02f, 1.47821950e-02f, 4.17282805e-02f,
  -1.21072480e-04f, 5.35266707e-03f, 2.04343889e-02f, -1.06455751e-01f, -1.08107715e-03f, -2.06826944e-02f, 1.10905498e-01f, 1.32279977e-01f, -2.33610510e-03f, -2.37667374e-02f,
  -3.07900668e-03f, 4.27481458e-02f, -4.35581617e-02f, -9.91002768e-02f, -1.76889393e-02f, -2.87958920e-01f, 1.81869715e-02f, -1.74448714e-02f, -5.79079241e-02f, -4.04604934e-02f,
  -7.07382709e-02f, -3.86600979e-02f, -4.08830456e-02f, 5.50862476e-02f, -3.65420245e-02f, -1.33294255e-01f, 3.19311954e-02f, 8.53249058e-02f, -7.80517906e-02f, -1.36255130e-01f,
  -4.24266383e-02f, 3.67283374e-02f, -1.09538119e-02f, 3.88144366e-02f, 4.10227850e-02f, 1.57267764e-01f, -4.43605743e-02f, -1.03423618e-01f, -6.27335310e-02f, 1.06333792e-01f,
  1.04998037e-01f, 1.77185386e-02f, 1.00674823e-01f, -5.32099269e-02f, -2.35726032e-02f, -2.68128142e-02f, 1.02090985e-01f, -7.68859237e-02f, -3.59978266e-02f, -2.80821994e-02f,
  -1.18268408e-01f, -4.83923964e-03f, 5.32195009e-02f, -4.68883291e-02f, -6.17437763e-03f, -2.43536625e-02f, 1.93288792e-02f, -6.38623163e-02f, 5.29744513e-02f, -2.23833025e-02f,
  -9.47932601e-02f, -2.82461960e-02f, -4.01687389e-03f, -8.48231465e-02f, -9.48080271e-02f, -7.64714926e-02f, -6.33567348e-02f, -6.35844395e-02f, 5.22689186e-02f, 7.70326033e-02f,
  -7.65445888e-01f, 1.85862809e-01f, 1.20924838e-01f, 3.14906240e-01f, -2.19994321e-01f, -7.58417919e-02f, 6.12920821e-02f, -2.11258531e-02f, -1.36773422e-01f, 1.49865150e-01f,
  2.71433275e-02f, -2.08761603e-01f, 1.10815488e-01f, 2.26919472e-01f, 6.79867528e-03f, 2.85800159e-01f, 2.16204271e-01f, 1.09888747e-01f, 2.04765439e-01f, 6.85084984e-02f,
  1.02766499e-01f, 2.21636876e-01f, 4.86062050e-01f, 1.05688617e-01f, 1.45451531e-01f, 4.73057181e-02f, 1.36036277e-01f, 3.42874415e-02f, 8.11388865e-02f, 1.80207994e-02f,
  -4.54195216e-02f, 2.67769337e-01f, 2.44257711e-02f, -2.78393459e-02f, 1.79541651e-02f, -1.33344218e-01f, -2.95658149e-02f, -1.86809286e-01f, -5.07400148e-02f, -1.20076938e-02f,
  -1.53502226e-01f, -1.35932267e-01f, 4.75704558e-02f, -2.92870495e-02f, -1.53262436e-01f, 3.69280912e-02f, 1.03493489e-01f, 1.37819750e-02f, 3.60870734e-02f, -1.20319575e-01f,
  1.04250081e-01f, 2.85485890e-02f, 6.86904564e-02f, 2.22046599e-02f, -7.89598599e-02f, 5.95164560e-02f, 6.63320534e-03f, -5.97903468e-02f, -3.93342897e-02f, 3.58657017e-02f,
  -6.85796365e-02f, -4.78547474e-04f, -3.46944630e-02f, 1.02217356e-03f, -1.68960616e-02f, 4.39561829e-02f, -8.62706825e-02f, -1.38241686e-02f, -5.10343462e-02f, 7.12368116e-02f,
  -2.28849500e-02f, -5.56196496e-02f, 2.71372590e-03f, -7.34807476e-02f, -6.54014423e-02f, 6.09007813e-02f, -3.62019539e-02f, -1.79931673e-03f, -1.24570139e-01f, -5.18865064e-02f,
  1.26287369e-02f, -6.12089708e-02f, -1.67133585e-02f, -4.26020361e-02f, 9.09704342e-02f, 5.31885996e-02f, -4.22163643e-02f, 6.36688396e-02f, 4.95054498e-02f, -3.03671714e-02f,
  1.12224147e-01f, 2.93130368e-01f, 1.70097470e-01f, 5.40722385e-02f, 1.37170196e-01f, 1.99304465e-02f, 2.63147820e-02f, -1.10389724e-01f, 1.23801850e-01f, 8.57872590e-02f,
  -1.18911438e-01f, 8.09394661e-03f, -2.07326151e-02f, -1.68108661e-02f, -8.72190893e-02f, 3.00557148e-02f, 3.92406583e-02f, -1.34635139e-02f, 1.86658800e-02f, 7.95458406e-02f,
  5.85825481e-02f, -5.44975922e-02f, -1.20453280e-03f, 1.07291766e-01f, -1.01153739e-01f, 7.43711814e-02f, -1.11159600e-01f, 9.67452303e-03f, -3.84269506e-02f, 2.80047930e-03f,
  -4.33187187e-01f, 1.45211956e-02f, -1.56460270e-01f, -1.48627192e-01f, 2.72570461e-01f, -1.28379073e-02f, 1.34146819e-02f, 6.65048882e-02f, -2.55515069e-01f, 1.47600114e-01f,
  -2.91943997e-02f, -2.21814394e-01f, -9.62782726e-02f, -3.45998049e-01f, -6.36661172e-01f, -4.48863268e-01f, -2.68940628e-01f, -2.10805878e-01f, -1.92883551e-01f, -1.65954530e-02f,
  -1.24963194e-01f, 1.17209114e-01f, -2.34049648e-01f, 3.70650291e-01f, 1.71477422e-01f, 1.75211430e-01f, 1.81374818e-01f, 3.31631184e-01f, 1.34504929e-01f, 9.98711586e-02f,
  -3.15489359e-02f, -7.72010162e-03f, 9.98356380e-03f, -2.61208136e-02f, 1.02402620e-01f, 1.13517232e-01f, 2.28949003e-02f, 7.51496181e-02f, -2.07066592e-02f, 9.24304128e-02f,
  -4.28373963e-02f, 9.43325907e-02f, 1.00189401e-02f, 2.85880286e-02f, 1.02491692e-01f, -7.05411807e-02f, -3.48529853e-02f, -5.40640168e-02f, 6.41202554e-02f, -9.98880044e-02f,
  -1.29748121e-01f, -1.44644110e-02f, 5.55208288e-02f, -6.79316185e-03f, 2.82006781e-03f, -7.33499825e-02f, 3.65665667e-02f, 5.60905635e-02f, -3.37369405e-02f, -1.00967757e-01f,
  1.20533191e-01f, 8.52051303e-02f, -1.06897047e-02f, -3.16426344e-02f, -1.76974013e-02f, 2.53937114e-02f, -6.15796670e-02f, 1.02789076e-02f, -4.99228947e-03f, 4.91608046e-02f,
  -1.13296710e-01f, 5.13617992e-02f, -6.84703365e-02f, 5.87052107e-02f, 4.25667092e-02f, -9.46955197e-03f, 8.94165114e-02f, 2.56518014e-02f, -1.38771623e-01f, -4.05459888e-02f,
  2.23067813e-02f, -2.48459596e-02f, -3.01923137e-03f, 5.29869460e-02f, -3.06537338e-02f, 8.29762444e-02f, -2.11225171e-03f, -6.81647509e-02f, -1.05621880e-02f, -3.87371667e-02f,
  -1.65672958e-01f, 3.32531482e-02f, 1.65607128e-02f, 2.19477490e-02f, -2.27279402e-02f, -1.73599310e-02f, 1.60429403e-02f, -5.04423454e-02f, -2.71719638e-02f, 4.65407223e-02f,
  7.46646896e-02f, 8.99891704e-02f, 1.69864759e-01f, -1.46899819e-01f, -5.85870519e-02f, -3.20637226e-02f, -2.26747189e-02f, 1.31977051e-01f, 4.04101573e-02f, 6.20308295e-02f,
  5.10930382e-02f, 3.24883610e-02f, -5.58237312e-03f, 1.14662506e-01f, -1.55750206e-02f, 1.78115755e-01f, 5.41823218e-03f, 1.39800040e-02f, 1.38000846e-01f, 1.11604847e-01f,
  1.84808195e-01f, 6.12680130e-02f, 2.10338727e-01f, 2.73716092e-01f, -5.56617491e-02f, -2.99098790e-01f, -2.86984295e-01f, 1.59070626e-01f, -6.56278580e-02f, -2.06909567e-01f,
  7.83459470e-02f, -6.55033290e-02f, -8.30006301e-02f, 1.93610355e-01f, 2.53246605e-01f, -1.67795420e-01f, 1.47121206e-01f, 3.05064637e-02f, -8.06985795e-02f, 1.45113394e-01f,
  1.08422503e-01f, 8.87539536e-02f, 2.92571247e-01f, 1.67446047e-01f, 1.03121996e-01f, 1.93024486e-01f, 1.93857923e-01f, -2.75631677e-02f, 1.09917313e-01f, -9.73381624e-02f,
  4.02335354e-05f, 8.11139196e-02f, 7.15912953e-02f, -2.39705443e-02f, 4.47584242e-02f, -7.34147727e-02f, -6.86364993e-02f, 7.37753361e-02f, 5.37949055e-02f, -5.19205108e-02f,
  -2.28557382e-02f, -3.01258042e-02f, 7.99489766e-02f, 1.21113941e-01f, -4.56493720e-02f, -1.61916073e-02f, -3.21563259e-02f, -6.21432345e-03f, -1.27491951e-01f, -3.61903869e-02f,
  -7.61434212e-02f, 5.57654537e-02f, -1.05633244e-01f, -1.39053410e-03f, 3.52161005e-02f, -4.46122251e-02f, -1.17806010e-01f, -9.79209226e-03f, -5.19043319e-02f, -3.19008604e-02f,
  1.19082347e-01f, -8.02967921e-02f, -1.34603828e-01f, -7.69816060e-03f, -3.26123834e-03f, 3.20170354e-03f, -1.01709120e-01f, -6.20719828e-02f, 4.68447618e-02f, -1.62424237e-01f,
  3.84278931e-02f, 9.51798037e-02f, -1.89311251e-01f, -2.42139921e-02f, 9.12501570e-03f, 6.15073694e-03f, 2.26374641e-02f, 2.78147440e-02f, -3.43642458e-02f, 4.81199101e-03f,
  -1.03325747e-01f, -6.85118958e-02f, 6.51840344e-02f, -1.28718745e-02f, -3.41662094e-02f, 9.61093307e-02f, -9.29772556e-02f, 6.14352114e-02f, 1.11538274e-02f, -1.27270003e-03f,
  4.50773127e-02f, 1.52935296e-01f, -1.21259345e-02f, -2.95876875e-03f, 2.56031901e-02f, -8.90482739e-02f, 1.40315397e-02f, 4.28867936e-02f, 5.94021864e-02f, 5.48068509e-02f,
  2.62647532e-02f, -8.66380036e-02f, -5.69089316e-02f, -6.98737130e-02f, 2.86679808e-02f, -1.25487909e-01f, -1.12064462e-02f, -4.31249365e-02f, 1.54205495e-02f, 1.48585066e-01f,
  5.00570610e-02f, -4.11585122e-02f, -5.30834980e-02f, -1.25570185e-02f, -2.17652358e-02f, -1.26340628e-01f, 5.74120693e-02f, -9.88090262e-02f, 2.01966148e-03f, 6.91512004e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.72211641e-01f, 2.29030177e-02f, 2.96121389e-01f, 2.22893998e-01f, 3.14104587e-01f, 8.99509862e-02f, 1.24460451e-01f, 1.66873336e-01f, 3.12200963e-01f, 2.31553521e-02f,
  3.24034661e-01f, 2.48561829e-01f, 3.40424091e-01f, 4.49088775e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.42838855e-02f, 4.51383293e-02f, 2.18185708e-01f, -7.60938972e-02f, -4.96595949e-02f, -1.60870939e-01f, -6.16401061e-02f, -2.88204867e-02f, -1.47333592e-01f, -4.96472940e-02f,
  9.16757062e-02f, -1.09971166e-01f, -2.17729464e-01f, -5.78841791e-02f, 5.24215624e-02f, 1.47403777e-01f, -1.20263748e-01f, -1.42205030e-01f, -2.59657830e-01f, -2.66722947e-01f,
  3.41192782e-01f, 2.41914302e-01f, 9.96249318e-02f, 2.12864861e-01f, 8.44891090e-03f, 1.80025473e-01f, -4.33456689e-01f, -9.68675613e-02f, -2.00619921e-01f, 2.97007561e-01f,
  2.56375164e-01f, -9.02835280e-02f, 3.64995062e-01f, 2.46064618e-01f, -3.94712314e-02f, -7.42086023e-02f, 7.40701146e-03f, -1.15888752e-01f, 2.43147284e-01f, -5.67887835e-02f,
  5.63376769e-02f, 7.74550214e-02f, 4.56281304e-02f, -8.84389505e-02f, 5.79993948e-02f, 1.49665112e-02f, -2.32463434e-01f, 8.04939270e-02f, -4.76645045e-02f, 5.87443495e-03f,
  1.27671883e-01f, -2.65121400e-01f, -1.24778293e-01f, -2.26361379e-01f, 3.21099162e-02f, 2.47086883e-01f, -4.49721292e-02f, -4.71527874e-02f, -7.26151466e-02f, -7.78256878e-02f,
  -2.77190566e-01f, -1.59584224e-01f, 2.84727365e-01f, -9.91586298e-02f, -6.82286620e-02f, -6.32782206e-02f, 9.33049619e-02f, -1.16829120e-01f, 2.17437282e-01f, 1.07527807e-01f,
  -7.89832547e-02f, -2.78332025e-01f, -1.13749787e-01f, 1.53924264e-02f, -2.71502826e-02f, 1.71062112e-01f, -5.36659062e-02f, -2.63721257e-01f, 9.21993032e-02f, -2.57060766e-01f,
  -8.32091719e-02f, 1.39583230e-01f, 6.25344068e-02f, 1.89126685e-01f, -1.38049722e-02f, 3.24193209e-01f, -1.90362409e-02f, -4.11925852e-01f, 2.84390122e-01f, 3.48844111e-01f,
  -2.15020180e-01f, 1.28452137e-01f, -1.54072911e-01f, 4.06082004e-01f, -2.04319760e-01f, 1.11014597e-01f, 8.43844712e-02f, -3.70179676e-02f, -1.16333500e-01f, 2.86500245e-01f,
  -3.94994281e-02f, -1.07049063e-01f, -4.75045554e-02f, 1.16489872e-01f, 1.83726311e-01f, -1.26671478e-01f, -2.65489399e-01f, -4.96685266e-01f, -2.51485527e-01f, 8.51678997e-02f,
  -2.44701922e-01f, 1.02180287e-01f, 2.29603052e-02f, -1.89086258e-01f, -6.50469661e-02f, -2.33011067e-01f, -9.84975975e-03f, -6.78979233e-02f, 3.44384164e-02f, -2.10428089e-01f,
  -3.59932274e-01f, -1.91046819e-01f, -1.37240484e-01f, 6.21054508e-02f, 2.99230009e-01f, -3.80313024e-02f, -6.96314313e-03f, -1.63749546e-01f, 3.01599532e-01f, 1.95907325e-01f,
  6.14315905e-02f, 2.68075377e-01f, -6.09800257e-02f, 1.30456507e-01f, 1.21709771e-01f, 3.36580575e-01f, 3.40850681e-01f, -1.76245764e-01f, 7.37269893e-02f, -1.14462823e-01f,
  -5.77555150e-02f, 1.31299451e-01f, -1.29317269e-01f, 1.29167929e-01f, 6.90179318e-02f, -8.76844674e-02f, 1.90646350e-01f, 2.75344104e-01f, 2.84458578e-01f, -3.92588049e-01f,
  2.14266837e-01f, 1.66742474e-01f, -2.93730885e-01f, -1.55971467e-01f, 9.69265960e-03f, -4.45254520e-02f, 2.70238608e-01f, -2.68611573e-02f, 1.75275192e-01f, 2.45228320e-01f,
  1.91846803e-01f, -4.71969210e-02f, -2.78477103e-01f, 1.91555187e-01f, -2.06666902e-01f, -1.81856051e-01f, 4.84800413e-02f, -1.60549618e-02f, -9.89471823e-02f, 6.82779029e-02f,
  2.79877335e-01f, -1.12442069e-01f, 1.68336660e-01f, 1.62778929e-01f, -2.59171516e-01f, 2.64634490e-01f, -2.28800755e-02f, -1.14076296e-02f, -3.24720830e-01f, 1.63578615e-01f,
  1.02225877e-01f, -2.01757178e-02f, 1.91210508e-02f, 2.08899871e-01f, -4.19508845e-01f, -1.04425184e-01f, 2.20032364e-01f, -1.54952690e-01f, 3.17334570e-02f, 2.99334139e-01f,
  -8.10936019e-02f, 1.19063035e-01f, -1.55147672e-01f, -3.95232022e-01f, -2.73659945e-01f, 7.76888058e-02f, 1.99242428e-01f, -2.63670474e-01f, -1.63222075e-01f, 8.15805048e-03f,
  8.64068419e-02f, -3.77817117e-02f, -1.56401485e-01f, 2.89531276e-02f, 1.63485155e-01f, 2.23988011e-01f, -1.75489917e-01f, -1.47974268e-01f, 2.52254725e-01f, 1.87757090e-02f,
  -1.68167964e-01f, 2.25233048e-01f, -1.49548769e-01f, 1.01000205e-01f, 2.89568245e-01f, -3.18837702e-01f, -1.03138030e-01f, -5.53919859e-02f, -1.06657490e-01f, 3.07922035e-01f,
  2.97077507e-01f, 2.37034306e-01f, -5.00706673e-01f, 1.31119485e-03f, -1.99066147e-01f, -1.54502213e-01f, -1.35120898e-01f, -1.12027854e-01f, 7.51087815e-02f, -2.25819461e-02f,
  -1.40957713e-01f, -1.15581207e-01f, -9.55415443e-02f, -1.12255059e-01f, 1.20251283e-01f, 4.18685883e-01f, 2.30845779e-01f, -1.68460742e-01f, 8.33452642e-02f, -2.39285007e-01f,
  4.55875210e-02f, 6.71728924e-02f, -4.39692885e-02f, 1.35884091e-01f, -5.73628508e-02f, -5.92166483e-02f, -1.69608206e-01f, -3.18483055e-01f, 2.55881041e-01f, -2.09771693e-02f,
  2.59362251e-01f, -5.01425192e-02f, 1.44822389e-01f, 6.15652204e-02f, -1.51004791e-01f, 3.01116318e-01f, -1.59215078e-01f, -1.14240788e-01f, 4.46973518e-02f, 1.76225573e-01f,
  1.83597833e-01f, 2.14051917e-01f, -9.01648626e-02f, 1.43516764e-01f, -4.84548956e-02f, -1.60373762e-01f, -2.05930024e-01f, 3.13805282e-01f, 3.30532908e-01f, 5.50463572e-02f,
  8.03613961e-02f, -1.68829829e-01f, 2.44912386e-01f, 8.83898661e-02f, 2.76981264e-01f, 3.23713660e-01f, -5.48495688e-02f, -1.17901817e-01f, -2.14129314e-01f, -3.18240970e-01f,
  8.53001252e-02f, -8.44680592e-02f, 3.85485440e-01f, 4.82183322e-02f, 2.94942558e-01f, 9.65317618e-03f, -2.71738142e-01f, 1.50253130e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.48624557e-01f, 4.05455679e-02f, 3.51797312e-01f, 1.93712652e-01f, 2.19125599e-01f, 3.19073558e-01f, 4.94600475e-01f, 1.99903071e-01f, 3.27171504e-01f, -1.72607288e-01f,
  -5.38026452e-01f, -2.26898775e-01f, -2.19536215e-01f, 2.10958526e-01f, 7.89029077e-02f, -3.12697411e-01f, 1.09885834e-01f, -9.95006859e-02f, 5.60004830e-01f, 4.33047563e-01f,
  2.29781084e-02f, -3.79776150e-01f, 4.17453259e-01f, -4.29992259e-01f, -1.49591565e-01f, 1.82312667e-01f, 2.21134976e-01f, 9.51969028e-02f, 4.35687661e-01f, 7.45907873e-02f,
  -2.06708629e-02f, 2.77738385e-02f, 1.75869629e-01f, 2.27834031e-01f, 2.73158699e-01f, 3.90671901e-02f, 2.03426808e-01f, 1.17759563e-01f, 5.96318781e-01f, 8.42076540e-02f,
  -1.40176043e-01f, 3.94459635e-01f, -3.02088380e-01f, -3.54147553e-01f, -3.48893076e-01f, -8.82335901e-02f, 2.15393305e-01f, 9.92506668e-02f, 2.39272982e-01f, -1.09438829e-01f,
  7.92546347e-02f, -1.25531569e-01f, -1.84180021e-01f, 5.97776532e-01f, -1.55907542e-01f, -2.15587512e-01f, 4.76736203e-02f, 5.72236121e-01f, -2.15479001e-01f, 5.08714467e-03f,
  2.00980529e-01f, 5.41074932e-01f, 1.74894601e-01f, -1.64888129e-01f, 2.38918051e-01f, -1.46051660e-01f, -2.08300520e-02f, 3.68059933e-01f, 5.01825772e-02f, -1.68569181e-02f,
  -1.43911824e-01f, 1.63935810e-01f, 4.03427720e-01f, -2.11877078e-01f, 2.02970505e-01f, 1.30931616e-01f, -1.81279913e-01f, 8.00262541e-02f, -3.27374250e-01f, 1.68621317e-01f,
  8.37744176e-02f, -2.19471484e-01f, -5.23728848e-01f, 3.40911262e-02f, 3.24114531e-01f, 1.93381637e-01f, 2.90610313e-01f, 2.98194885e-01f, -2.93887943e-01f, 2.10793257e-01f,
  5.89982560e-03f, 8.42033103e-02f, 2.22743228e-01f, 3.00006151e-01f, 1.32583708e-01f, 2.02313483e-01f, 3.03163677e-01f, 3.17891330e-01f, 2.93977797e-01f, 2.34584242e-01f,
  1.36623845e-01f, 2.91130155e-01f, 2.53666312e-01f, 1.71651110e-01f, 8.81885886e-02f, 2.29297489e-01f, 2.29887441e-02f, 1.93953261e-01f, 2.92718083e-01f, 8.18628073e-02f,
  -2.33683795e-01f, 1.42060637e-01f, -9.75690708e-02f, 9.44842175e-02f, 5.22945523e-01f, 4.32561785e-01f, 3.11372846e-01f, -4.80332047e-01f, 6.35762438e-02f, 3.04839939e-01f,
  4.35428061e-02f, -1.58166081e-01f, 2.58567363e-01f, -1.72330178e-02f, -1.58507545e-02f, -2.29855657e-01f, 1.74263582e-01f, 1.26128003e-01f, -1.74811900e-01f, -1.83017910e-01f,
  -4.59377021e-02f, 4.47622120e-01f, 2.11360559e-01f, 5.79665266e-02f, 2.58559864e-02f, 4.10095036e-01f, 4.19073664e-02f, 4.67086345e-01f, 4.32856428e-03f, -3.92633855e-01f,
  2.42084116e-01f, 9.65764001e-02f, -3.41613926e-02f, 2.15628892e-01f, -3.03130466e-02f, -7.19731972e-02f, 1.32192299e-01f, 4.42870438e-01f, 3.11673045e-01f, 4.44627106e-01f,
  2.58908600e-01f, -1.46359220e-01f, 1.38712907e-02f, -8.90611392e-03f, -1.80467352e-01f, 2.39064127e-01f, -8.25464725e-03f, 5.44530571e-01f, -2.47899517e-01f, 4.61550444e-01f,
  1.96541250e-01f, 1.44050062e-01f, 5.38061783e-02f, 2.35266715e-01f, 1.99138448e-01f, -3.71067692e-03f, 3.43796074e-01f, 1.81868866e-01f, -2.13671178e-01f, 4.51383859e-01f,
  -4.78407033e-02f, -5.58523983e-02f, 2.03753680e-01f, 3.18329185e-01f, -1.36999562e-01f, 3.59752446e-01f, 2.38472715e-01f, 6.25972077e-02f, 3.75426412e-01f, -1.64324746e-01f,
  -2.75639445e-01f, 1.74312174e-01f, -1.68045163e-01f, 4.54492688e-01f, -2.80477852e-01f, 7.30513688e-03f, 1.48059607e-01f, 2.05538422e-01f, 6.94522411e-02f, 3.21116626e-01f,
  -2.90934414e-01f, -4.95639741e-02f, 1.57332063e-01f, -1.01589367e-01f, 9.59137604e-02f, 3.11071366e-01f, 1.94909975e-01f, 1.67952880e-01f, 4.00422722e-01f, 1.46246120e-01f,
  1.97536975e-01f, -3.68200302e-01f, -2.50885099e-01f, 3.90228242e-01f, -1.99827403e-01f, 1.17050419e-02f, -1.26070172e-01f, -2.28725120e-01f, 5.04083991e-01f, -1.33828685e-01f,
  -2.46661350e-01f, -2.75040656e-01f, -3.89829695e-01f, 5.43655217e-01f, -1.41419068e-01f, -2.22001504e-02f, 2.55272478e-01f, 6.19966745e-01f, 3.20507526e-01f, 1.25126734e-01f,
  6.35297894e-01f, 2.88229704e-01f, -3.10805172e-01f, -1.89379111e-01f, 1.19815789e-01f, -1.18100323e-01f, 4.80710901e-02f, 2.49588862e-01f, -1.21355385e-01f, 6.24075234e-02f,
  -2.00038478e-01f, 4.33702059e-02f, 1.89926609e-01f, 4.46127020e-02f, 4.47742671e-01f, 2.39126965e-01f, 2.71277755e-01f, 2.71322727e-01f, -4.05939400e-01f, 1.40956134e-01f,
  1.68840095e-01f, 6.53389767e-02f, -2.07623303e-01f, 1.77285582e-01f, 3.47941190e-01f, 2.76528355e-02f, 2.16340080e-01f, 4.95172620e-01f, -4.01891232e-01f, 6.23640865e-02f,
  3.87737602e-01f, 4.23789257e-03f, 1.08313084e-01f, 1.28116801e-01f, -1.37604490e-01f, 1.78943411e-01f, 3.44806612e-02f, 7.31080770e-02f, 1.42828301e-01f, 3.52979213e-01f,
  2.64546216e-01f, -4.52767722e-02f, 2.28272021e-01f, 3.85725975e-01f, 2.04117205e-02f, 1.19813055e-01f, -4.62104261e-01f, -7.34077513e-01f, -2.42014572e-01f, 1.90749824e-01f,
  -2.61850715e-01f, 4.63897347e-01f, 7.06161484e-02f, -1.47838533e-01f, 2.54527062e-01f, -2.35211536e-01f, 2.32313350e-02f, 1.13172852e-01f, 2.56825924e-01f, -1.14180505e-01f,
  -3.05889040e-01f, -3.60890180e-01f, -4.99095291e-01f, 1.12063661e-01f, 6.59908131e-02f, 4.40034419e-02f, 1.21015854e-01f, -3.32901865e-01f, 5.06716132e-01f, 4.07326549e-01f,
  1.57315671e-01f, 5.02439365e-02f, -2.31672055e-03f, 2.34245032e-01f, 3.93015027e-01f, 1.39941379e-01f, 8.45926404e-02f, -2.14300174e-02f, 1.47867918e-01f, 1.48113281e-01f,
  -2.82200903e-01f, -1.74084216e-01f, 1.32516861e-01f, -7.61769991e-03f, -1.06070168e-01f, 1.23998754e-01f, -3.15165073e-01f, -3.46970230e-01f, 4.65760976e-02f, -3.63570489e-02f,
  -7.97942877e-02f, 4.25402284e-01f, 7.57616535e-02f, 4.76942390e-01f, 3.59666139e-01f, -5.30129254e-01f, 1.88603327e-01f, -1.51923984e-01f, 5.81571758e-01f, 2.81918552e-02f,
  4.98404711e-01f, 4.25514728e-01f, 2.94438183e-01f, 3.00441179e-02f, 1.02699719e-01f, 3.21705252e-01f, 2.70115376e-01f, 1.18184537e-01f, -1.14468768e-01f, 3.45182508e-01f,
  -1.35463819e-01f, -1.37604862e-01f, 2.17102151e-02f, -4.18836951e-01f, 3.27121794e-01f, -2.04277381e-01f, -3.13829154e-01f, 2.37835735e-01f, 3.17173332e-01f, 2.81539023e-01f,
  1.87097788e-01f, -1.15206912e-01f, -3.24216709e-02f, 7.08586276e-02f, 2.76801139e-01f, 5.17436922e-01f, 1.47461906e-01f, -2.96957642e-01f, -1.58395410e-01f, 4.70941924e-02f,
  3.82956058e-01f, 1.12373993e-01f, 1.93238094e-01f, -1.23026013e-01f, -6.55742213e-02f, 5.34169525e-02f, 3.74458581e-02f, -1.50811866e-01f, -2.78993756e-01f, 3.21783096e-01f,
  2.00018629e-01f, -1.34011609e-02f, -1.16288058e-01f, -2.43797138e-01f, -1.22816935e-01f, 5.80406860e-02f, -3.42144042e-01f, 2.36938894e-01f, -5.89088947e-02f, -2.72831649e-01f,
  -4.01877761e-01f, 1.04761891e-01f, 3.60632539e-01f, -8.37589353e-02f, 5.03121614e-01f, 2.98799872e-01f, -4.25964266e-01f, -2.07603425e-01f, -3.34617108e-01f, 3.46035534e-03f,
  -3.36975992e-01f, -2.35568918e-02f, 3.95695865e-01f, -1.29233813e-02f, 2.64631808e-01f, 2.16425642e-01f, -1.22037143e-01f, 8.52694139e-02f, 1.37731405e-02f, 3.99050862e-02f,
  3.80202293e-01f, 2.12176517e-01f, 2.34255925e-01f, 1.05720103e-01f, 3.91132772e-01f, 1.53843075e-01f, 3.22775334e-01f, 2.82879561e-01f, -3.42333615e-01f, 3.16276491e-01f,
  4.14329655e-02f, 4.77073789e-02f, 1.46174803e-01f, -1.25306815e-01f, -1.02065176e-01f, -3.33189636e-01f, -7.81720802e-02f, 3.90372127e-01f, -1.29216671e-01f, -2.15341687e-01f,
  4.76200223e-01f, 9.63009521e-02f, 2.42567360e-01f, -3.20780933e-01f, 7.75517104e-03f, 3.93461548e-02f, 4.51281905e-01f, 3.93973827e-01f, 3.87415826e-01f, -1.32306725e-01f,
  -2.23381087e-01f, 1.21120781e-01f, 4.18168381e-02f, -1.10644333e-01f, -1.71566218e-01f, 2.97601998e-01f, 4.26520735e-01f, 3.01811337e-01f, 4.02104586e-01f, -1.27844587e-01f,
  1.47193745e-01f, -1.30755305e-01f, -2.49289095e-01f, 2.04189464e-01f, 3.01513821e-01f, 5.01276441e-02f, 3.35313380e-01f, 4.66684960e-02f, -1.05423838e-01f, 3.23379278e-01f,
  4.02509630e-01f, 1.83995649e-01f, -8.65776930e-03f, -3.29139978e-01f, -4.39146996e-01f, -7.76434597e-03f, 4.33303177e-01f, 1.61711857e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.35829851e-01f, 2.45731667e-01f, 2.97369182e-01f, 3.47834259e-01f, 3.53619531e-02f, 9.11198184e-02f, 3.04216892e-01f, 2.45132878e-01f, 2.15808228e-01f, 2.55797207e-01f,
  8.65821019e-02f, 3.10839832e-01f, 2.51770139e-01f, 1.28416047e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.08815514e-01f, 3.86928730e-02f, -8.26074108e-02f, 1.21201687e-02f, 9.94511247e-02f, -1.71131521e-01f, 2.89343119e-01f, -6.89793155e-02f, 2.34417003e-02f, -8.96344855e-02f,
  2.07546249e-01f, 1.76238716e-01f, 4.71472181e-02f, 1.86024368e-01f, -4.16074507e-02f, -2.27538303e-01f, -3.10600782e-03f, 1.16023645e-01f, 2.50537489e-02f, -6.61635911e-03f,
  -4.66341488e-02f, 3.12833637e-02f, -2.21823812e-01f, -2.23298296e-01f, 3.18543196e-01f, -2.73378640e-01f, 1.73962638e-02f, 2.68540174e-01f, 2.00287610e-01f, -1.39812186e-01f,
  -3.96515727e-02f, -2.91741509e-02f, 1.71044953e-02f, 2.21009448e-01f, 3.89821902e-02f, 1.32133747e-02f, 1.32797167e-01f, 8.23401809e-02f, 7.87978023e-02f, -8.31956491e-02f,
  -1.44995451e-01f, 1.04439564e-01f, 7.87784904e-02f, 2.57033348e-01f, -1.61879063e-02f, -9.34464410e-02f, -1.76576957e-01f, -8.85180831e-02f, -1.53988868e-01f, 7.25560486e-02f,
  1.31732628e-01f, 4.03814137e-01f, -1.03699490e-01f, -1.02306619e-01f, -8.77422374e-03f, -5.00814691e-02f, 1.65080741e-01f, -2.63171703e-01f, 2.24833369e-01f, 3.92173864e-02f,
  2.36352086e-01f, -2.00765491e-01f, -1.01499908e-01f, 2.53015365e-02f, 2.89559662e-02f, 9.61274747e-03f, 1.49929792e-01f, -2.67293807e-02f, -6.35176897e-02f, 1.27795786e-01f,
  -3.13474476e-01f, 4.81308140e-02f, -1.70717821e-01f, 5.57317771e-02f, -1.30324289e-01f, -1.19347952e-01f, 1.43800154e-01f, 5.23224473e-02f, 3.32586467e-01f, 9.89653245e-02f,
  -4.62561212e-02f, -1.26412496e-01f, -3.21906656e-01f, -2.14634389e-01f, 1.62213773e-01f, 5.45057431e-02f, 1.69107497e-01f, 9.55554843e-02f, -8.16232711e-02f, 2.68181950e-01f,
  4.82102633e-02f, 4.22191434e-02f, -1.36579365e-01f, 3.06849927e-01f, 1.08108893e-01f, 9.93520468e-02f, -1.09249249e-01f, -8.94249454e-02f, -5.29719926e-02f, -3.16199176e-02f,
  5.96661530e-02f, 1.38190284e-01f, -6.47307038e-02f, -3.88350226e-02f, -5.51373474e-02f, 1.97703272e-01f, 2.42410421e-01f, -1.30307674e-01f, 9.99779776e-02f, -2.43801102e-02f,
  8.87747034e-02f, -2.14927778e-01f, -1.43534675e-01f, -2.01612785e-01f, 8.36882815e-02f, -1.23167038e-01f, 1.05505057e-01f, -2.07975239e-01f, -3.08138788e-01f, -2.38872573e-01f,
  -8.90977308e-02f, 1.52601212e-01f, -9.94399861e-02f, 4.11023557e-01f, 8.09546784e-02f, 1.45831525e-01f, 2.34566242e-01f, -6.99409889e-03f, 6.18731268e-02f, -4.47133668e-02f,
  1.73313618e-01f, 4.41808701e-02f, -7.11376816e-02f, 1.07495412e-01f, 4.00231361e-01f, 3.26628648e-02f, -6.09725267e-02f, 1.84476643e-03f, 5.01354400e-04f, 1.14513367e-01f,
  -6.13091215e-02f, 1.25910521e-01f, 9.42789167e-02f, -3.84772122e-02f, -3.09363063e-02f, 1.01832196e-01f, 1.82103798e-01f, 3.10713619e-01f, -1.43359125e-01f, 5.22895977e-02f,
  8.74900073e-02f, 2.67032981e-02f, 1.06845878e-01f, -1.13185570e-01f, -1.89088732e-01f, 2.75386930e-01f, 2.39558041e-01f, -3.76900911e-01f, 5.19024506e-02f, -1.40456915e-01f,
  9.26558450e-02f, -6.96096346e-02f, 6.79092184e-02f, -3.39182913e-02f, 3.39139365e-02f, 1.10413097e-01f, -1.95072055e-01f, 1.28042087e-01f, 8.52199830e-03f, -3.84755209e-02f,
  7.72836357e-02f, 2.75785089e-01f, -1.74146369e-01f, -6.18926138e-02f, -3.18302602e-01f, -1.34313717e-01f, -1.29916012e-01f, -1.53955827e-02f, 3.67845029e-01f, 1.21955231e-01f,
  -1.56740680e-01f, -9.12415038e-04f, -1.18135912e-02f, -2.15010226e-01f, -5.56808002e-02f, -8.58367085e-02f, -1.44057587e-01f, 1.02475971e-01f, 3.33818942e-01f, -1.93231925e-01f,
  -6.85223341e-02f, -4.23488021e-02f, -1.80674672e-01f, 8.43670592e-02f, -1.11065634e-01f, 5.78978546e-02f, 1.13183469e-01f, -2.68031389e-01f, 1.99711099e-01f, 1.09095909e-01f,
  2.25438159e-02f, 2.21541449e-01f, -1.00153618e-01f, 8.24660361e-02f, -1.22272335e-02f, -1.36941478e-01f, -3.45843956e-02f, 6.85387775e-02f, 2.15192169e-01f, -1.17668130e-01f,
  -3.43563497e-01f, 1.88004017e-01f, 5.57106212e-02f, -2.88241774e-01f, -1.79007471e-01f, -7.10198237e-03f, 2.61207372e-01f, -2.94071008e-02f, -1.26209304e-01f, 1.29824057e-01f,
  -1.49837196e-01f, -3.24465632e-01f, 3.26403342e-02f, -2.40587853e-02f, -5.95513955e-02f, -1.58439390e-02f, 1.52548760e-01f, -1.06774129e-01f, 1.41241122e-02f, 8.58247131e-02f,
  -7.28385746e-02f, -1.02134645e-01f, 3.20274085e-02f, -2.35267669e-01f, 2.82298267e-01f, -2.05563933e-01f, 8.94380584e-02f, 2.31173232e-01f, -1.55073091e-01f, 7.06166923e-02f,
  -1.71136558e-01f, 2.47884303e-01f, 1.40597463e-01f, -1.99335173e-01f, -2.22561732e-01f, 2.27341160e-01f, -2.05058441e-01f, 1.62491709e-01f, 7.04454631e-02f, -1.47776514e-01f,
  1.48018450e-01f, -1.03000887e-01f, -7.69067258e-02f, -1.02419011e-01f, 2.90576577e-01f, 5.25402725e-02f, 3.63294557e-02f, -6.34202436e-02f, -6.73273951e-02f, 9.11834463e-02f,
  2.25524171e-04f, -9.65111107e-02f, 3.16555947e-01f, -6.16729185e-02f, 4.65362668e-02f, 1.97632909e-01f, -2.86457449e-01f, -2.82444302e-02f, -3.98432948e-02f, -4.11261097e-02f,
  2.02028349e-01f, 3.10147107e-01f, -5.62473647e-02f, 6.30602986e-02f, -1.30620480e-01f, -1.09675243e-01f, 8.17810968e-02f, 1.88915938e-01f, 2.99638659e-01f, 4.53207754e-02f,
  1.05364032e-01f, 4.61343229e-02f, 9.62200910e-02f, -4.34338003e-02f, -1.23525731e-01f, 1.20636851e-01f, -1.02085859e-01f, -1.23438455e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  4.08598691e-01f, 1.25181735e-01f, 3.66423249e-01f, 2.31518045e-01f, -6.71482608e-02f, 4.56303090e-01f, -1.62123665e-02f, 1.27147049e-01f, 5.14314845e-02f, -1.50968432e-01f,
  5.31311966e-02f, -3.59518349e-01f, 5.13534784e-01f, 4.27974463e-01f, -7.85066281e-03f, -1.00607462e-01f, -2.80087471e-01f, 2.24393919e-01f, 5.58333158e-01f, 1.56858414e-01f,
  1.06331058e-01f, 3.69031876e-02f, 1.66996196e-01f, 3.55718762e-01f, 1.87864870e-01f, -3.53058167e-02f, 4.84610766e-01f, 1.74138024e-01f, -8.08134079e-02f, 3.62030566e-01f,
  1.32929850e-02f, -5.43604612e-01f, 9.83191058e-02f, 2.45949224e-01f, -8.68865177e-02f, 3.92326824e-02f, -3.20602596e-01f, 4.58873324e-02f, 3.79334956e-01f, -7.34749883e-02f,
  -4.18365635e-02f, -3.30523014e-01f, 1.25424385e-01f, -5.21929979e-01f, 3.61864328e-01f, 4.73086536e-01f, 2.73411036e-01f, 3.75109196e-01f, -3.49060446e-02f, 1.79709479e-01f,
  2.97901724e-02f, -4.48861301e-01f, 2.91438788e-01f, 3.69540714e-02f, -4.99784686e-02f, 1.20858746e-02f, 8.70891288e-02f, 3.45315278e-01f, 3.57709855e-01f, -2.76325713e-03f,
  -5.03458619e-01f, 2.73222685e-01f, 3.10158551e-01f, -5.60578704e-01f, -8.39564651e-02f, 9.69685912e-02f, 8.05859193e-02f, 1.09042920e-01f, -3.58880222e-01f, -1.23442054e-01f,
  1.41021684e-01f, -2.80424565e-01f, 1.88788194e-02f, 3.40803593e-01f, 1.56884298e-01f, -3.07776630e-01f, 2.28773698e-01f, 9.16101858e-02f, 7.10887164e-02f, 6.24643452e-02f,
  -3.52398902e-01f, -3.11627805e-01f, 6.11601472e-02f, 3.13850909e-01f, 3.44962716e-01f, 3.97763044e-01f, 4.23979014e-01f, 2.18313545e-01f, -4.59711254e-01f, 2.75944531e-01f,
  5.94080091e-01f, -7.30879307e-02f, 6.84787929e-02f, 4.25538629e-01f, -3.05048674e-01f, 3.35260242e-01f, -2.79603228e-02f, 2.77699739e-01f, 3.47799212e-02f, 4.22681898e-01f,
  -3.62443477e-02f, 1.35878384e-01f, -2.66335011e-01f, 2.92888820e-01f, -2.00014617e-02f, 1.50889441e-01f, -3.21147824e-03f, -7.60610998e-02f, 1.29307792e-01f, 1.60808593e-01f,
  1.61908582e-01f, -4.61229235e-01f, -1.11788036e-02f, -3.90991002e-01f, 2.35941023e-01f, -9.48560834e-02f, 5.41307390e-01f, -1.40695885e-01f, -4.24196392e-01f, -3.80230367e-01f,
  3.29693735e-01f, 2.51347780e-01f, -3.67470205e-01f, 7.60275424e-01f, 1.75828531e-01f, 3.22188824e-01f, -3.53648886e-02f, 1.07323274e-01f, 2.48152673e-01f, 9.07029733e-02f,
  -5.34289293e-02f, 6.43338487e-02f, 4.89512265e-01f, -9.68366116e-03f, 2.54667133e-01f, 3.47789705e-01f, 3.39143038e-01f, 2.96791255e-01f, -4.77005839e-01f, 6.13774121e-01f,
  -2.67380744e-01f, -2.83702224e-01f, -2.58626282e-01f, -2.52053346e-02f, 3.22305471e-01f, 3.56039286e-01f, 1.08246669e-01f, 7.02942491e-01f, 1.19407803e-01f, -2.73154378e-01f,
  2.70393372e-01f, 1.22615896e-01f, 6.92457855e-01f, 9.13983658e-02f, -6.89722179e-03f, 2.03714017e-02f, 1.59744367e-01f, -2.96473891e-01f, -3.59321296e-01f, 2.77798623e-01f,
  1.96764156e-01f, 2.52454430e-01f, 2.96814471e-01f, 1.17429078e-01f, 2.05822796e-01f, 2.49736682e-01f, -1.37060732e-01f, -2.76646819e-02f, -5.53817041e-02f, 1.76319674e-01f,
  1.93821803e-01f, -2.10337602e-02f, 4.92661774e-01f, 2.77506769e-01f, -1.29908592e-01f, -9.66164321e-02f, -4.92031425e-01f, -3.11953992e-01f, 4.99380469e-01f, 5.85856080e-01f,
  1.54453278e-01f, -1.77357018e-01f, 2.21699655e-01f, 2.91461021e-01f, 1.59357220e-01f, -2.99986243e-01f, 6.92950130e-01f, -1.02301493e-01f, 3.06444168e-01f, 4.25837576e-01f,
  -4.45593059e-01f, -4.77427036e-01f, 4.46007550e-01f, 2.37587109e-01f, 4.77877725e-03f, 3.29554111e-01f, -3.06198727e-02f, -8.25025216e-02f, 4.50422615e-01f, 1.68573365e-01f,
  2.24980563e-01f, -3.06978285e-01f, -4.67278063e-01f, -8.25131238e-02f, 1.69075459e-01f, 2.08970919e-01f, -9.01070386e-02f, 4.53465283e-01f, 3.23376060e-01f, 5.37922680e-01f,
  3.98609847e-01f, 9.60734189e-02f, 3.15464079e-01f, 7.07481205e-02f, 3.10710609e-01f, -3.95130441e-02f, 5.95358014e-01f, 1.04519464e-01f, 1.55324101e-01f, -1.50502384e-01f,
  -2.98299223e-01f, -6.79258481e-02f, -5.95237873e-02f, -5.68559945e-01f, 2.63071656e-02f, 2.42216513e-01f, 2.21517518e-01f, 1.95371911e-01f, -2.20096279e-02f, 1.26509722e-02f,
  -2.06681131e-03f, 1.87054709e-01f, 5.58680668e-02f, -5.40968418e-01f, 3.07189852e-01f, -6.87859952e-02f, -1.65690631e-01f, 4.00162011e-01f, -5.52241087e-01f, -3.54461521e-01f,
  -1.07469030e-01f, 5.10414720e-01f, 6.65689945e-01f, 2.98494518e-01f, -3.98126721e-01f, 3.22555929e-01f, -3.44220608e-01f, 1.19769521e-01f, 7.64361545e-02f, -4.08553988e-01f,
  7.06201941e-02f, 2.16230154e-01f, 4.68998462e-01f, -5.50107121e-01f, 3.72937053e-01f, 3.90576184e-01f, 2.25662882e-03f, 8.35586712e-02f, -1.62388802e-01f, -6.77297786e-02f,
  -2.21371025e-01f, 1.81356482e-02f, 2.75101960e-01f, -2.49713566e-02f, 1.58739790e-01f, -1.47157371e-01f, -1.57468379e-01f, -1.26194686e-01f, 1.46120042e-01f, 2.65896738e-01f,
  1.98630542e-01f, 2.98727304e-01f, -1.14705503e-01f, 9.43876430e-02f, 3.79367292e-01f, -2.23338827e-01f, 1.08698033e-01f, 2.18916386e-01f, 4.99660045e-01f, -1.07077479e-01f,
  -4.75635588e-01f, 2.15224594e-01f, 8.67099091e-02f, -4.28288132e-01f, 1.74135745e-01f, 2.82783270e-01f, -1.76505327e-01f, -1.72799289e-01f, 3.47446114e-01f, 9.68744606e-03f,
  6.68664575e-02f, 5.14583057e-03f, -2.27201685e-01f, 1.85633361e-01f, 1.12441197e-01f, 2.48226866e-01f, 2.78827816e-01f, -5.61451256e-01f, 1.82474285e-01f, -3.17896783e-01f,
  -9.02492329e-02f, 3.76918852e-01f, 5.67170754e-02f, -4.50055540e-01f, 1.89232171e-01f, 5.64558268e-01f, 3.87830704e-01f, -2.21925139e-01f, 3.75166051e-02f, 5.71429908e-01f,
  3.85204479e-02f, 2.99053609e-01f, 9.35827717e-02f, 5.37213385e-01f, -3.51778895e-01f, -2.14236453e-02f, 2.52756745e-01f, 6.96692541e-02f, 5.01802385e-01f, 1.44169524e-01f,
  2.13820294e-01f, -5.34666590e-02f, 6.40446097e-02f, -1.85049877e-01f, 1.96226433e-01f, 4.52331789e-02f, -1.67237327e-01f, 2.29848519e-01f, 1.30535945e-01f, -3.80696058e-01f,
  3.26541215e-01f, 1.52479693e-01f, -1.33523703e-01f, 2.92787105e-01f, -2.95723736e-01f, -3.16950470e-01f, 1.45173356e-01f, 2.66611844e-01f, 3.37166376e-02f, -3.99165064e-01f,
  -4.68525946e-01f, 4.46116000e-01f, -3.28273505e-01f, -1.51545182e-01f, -4.18232471e-01f, -2.05695942e-01f, -2.00158864e-01f, 2.08945647e-01f, 3.43749553e-01f, -3.27644736e-01f,
  3.45915675e-01f, 5.21204472e-01f, 4.58319992e-01f, 1.25611112e-01f, 1.20211802e-01f, 5.33701256e-02f, 2.09786966e-01f, -2.73647398e-01f, 2.98140466e-01f, 3.06085795e-01f,
  1.37435257e-01f, -3.40308771e-02f, -6.25852883e-01f, 6.68683410e-01f, -4.37941730e-01f, -3.45915914e-01f, -2.01432943e-01f, -1.26339719e-01f, 3.74540836e-01f, 5.49708426e-01f,
  3.63350213e-01f, -7.40807578e-02f, 1.51072234e-01f, 7.65598193e-02f, 2.97747254e-01f, -6.88134968e-01f, 2.08180398e-01f, 1.10930353e-01f, -5.41398466e-01f, 9.62478369e-02f,
  2.87047863e-01f, 3.98655459e-02f, -6.32646739e-01f, 2.33821511e-01f, -1.28312737e-01f, 1.40540555e-01f, -5.55106364e-02f, 1.05153583e-01f, 3.62353593e-01f, 3.65986437e-01f,
  -1.59213692e-01f, 3.18930745e-01f, 1.03251971e-01f, -5.63886538e-02f, 1.47712767e-01f, -2.66345799e-01f, 7.65966848e-02f, 1.09080449e-01f, 6.30890191e-01f, -9.18765590e-02f,
  1.17593175e-02f, 1.04857190e-02f, -1.84397534e-01f, 1.96162120e-01f, 2.07829699e-01f, 4.80649136e-02f, 3.90144996e-02f, 6.26779199e-01f, 4.48325485e-01f, 6.23886108e-01f,
  -2.56547630e-01f, 3.69878113e-01f, -2.37284124e-01f, -1.30626291e-01f, 4.46906686e-01f, -7.15577230e-02f, -1.70036152e-01f, 2.38232166e-02f, -7.92582259e-02f, -3.18963453e-02f,
  2.50111103e-01f, 2.33661637e-01f, -5.27149796e-01f, 1.30068108e-01f, 5.80829829e-02f, 4.76470083e-01f, 2.19094127e-01f, 1.22861922e-01f, -2.18547434e-01f, 2.94134840e-02f,
  -1.04925513e-01f, -4.63983327e-01f, -2.14484975e-01f, -5.93617141e-01f, -5.61969914e-02f, 3.09125364e-01f, 4.96186137e-01f, 1.90352961e-01f, -1.20210141e-01f, -2.94491053e-01f,
  4.80351672e-02f, 3.55571538e-01f, -2.96227425e-01f, 6.96321607e-01f, 5.50295055e-01f, 3.33418727e-01f, -2.60545373e-01f, 6.36572599e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.08891644e-01f, 2.09151968e-01f, 1.13368377e-01f, -1.08056245e-02f, 1.43463671e-01f, 1.23016171e-01f, 1.93027154e-01f, 2.31401905e-01f, -2.65313406e-03f, 4.09850068e-02f,
  6.71275705e-02f, 2.31781393e-01f, -1.13570504e-01f, 3.37930806e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.58643037e-01f, -1.58688292e-01f, 1.89685971e-01f, -4.05789196e-01f, 1.25888780e-01f, -2.21203491e-01f, 8.03564787e-02f, -1.04383126e-01f, -4.19930547e-01f, -3.47419232e-01f,
  4.35634255e-02f, 3.00899863e-01f, -1.71018109e-01f, 1.70575246e-01f, -2.99487114e-01f, 3.67249191e-01f, -2.58253068e-01f, 1.35941818e-01f, 1.34128481e-01f, -5.06125867e-01f,
  1.93254724e-01f, -6.05854988e-01f, 3.89185756e-01f, 3.51353198e-01f, 1.75779443e-02f, -6.63842320e-01f, -3.08661282e-01f, -7.31876671e-01f, 4.11527492e-02f, -5.31999350e-01f,
  3.63982022e-01f, -3.22422624e-01f, 3.44591103e-02f, 3.34466517e-01f, -1.86178535e-02f, 1.48153752e-01f, 1.60827354e-01f, -2.85823733e-01f, -2.60445237e-01f, 2.19625786e-01f,
  -1.45147800e-01f, -3.91987383e-01f, -1.54743493e-01f, 1.45598114e-01f, -3.15713771e-02f, -2.85286665e-01f, -2.33291537e-01f, -3.46112609e-01f, 2.64763504e-01f, 1.77905917e-01f,
  2.52346218e-01f, 6.14445925e-01f, 2.09705919e-01f, -3.42299104e-01f, -7.62844086e-01f, 1.60900831e-01f, 1.70356661e-01f, -6.34364724e-01f, 4.29086059e-01f, -6.69686273e-02f,
  -1.94606390e-02f, -4.84518826e-01f, -1.08453400e-01f, -3.21700811e-01f, 9.16742384e-02f, -2.29634076e-01f, -4.71549481e-03f, -1.27608687e-01f, 4.25262712e-02f, -2.86112756e-01f,
  1.01594090e-01f, 8.22119266e-02f, -6.66030720e-02f, -1.61622569e-01f, -2.99051791e-01f, -1.53864935e-01f, 1.24154910e-02f, -3.13009620e-01f, -2.30246484e-01f, -1.16863489e-01f,
  -1.30779773e-01f, 3.04539859e-01f, -4.38519567e-01f, -1.75040122e-02f, 3.56531352e-01f, 3.64891171e-01f, -5.07870197e-01f, -5.88010430e-01f, -3.62253577e-01f, -6.15989983e-01f,
  -2.84762174e-01f, 2.90693790e-01f, -5.26097178e-01f, -3.97150487e-01f, 9.61913615e-02f, 4.25429583e-01f, -1.63890123e-01f, 1.28414959e-01f, -7.81873837e-02f, -3.20492499e-02f,
  -3.91048878e-01f, -1.76407292e-01f, -1.76217198e-01f, -2.93811172e-01f, -9.98762995e-02f, -2.49922588e-01f, -2.29836062e-01f, -4.42321002e-01f, 4.58438098e-01f, -4.04814444e-02f,
  -1.06267922e-01f, 3.72163296e-01f, -2.43661553e-01f, -2.31619582e-01f, -5.86838305e-01f, -2.89041549e-03f, -4.04165626e-01f, 3.73596668e-01f, 4.07024443e-01f, -1.06569670e-01f,
  -7.96888292e-01f, 3.07374075e-02f, -9.85895619e-02f, -1.00595140e+00f, -2.16448158e-01f, -1.05677664e-01f, -1.92298423e-02f, 4.90938991e-01f, -2.34871104e-01f, -9.84307472e-03f,
  6.31143339e-03f, 3.64411086e-01f, 8.06534812e-02f, -2.03814358e-01f, 1.40051857e-01f, 2.07918137e-01f, 2.46182024e-01f, -2.04914317e-01f, -7.78622702e-02f, 3.12145770e-01f,
  5.03245667e-02f, -6.73189878e-01f, 1.76652864e-01f, 1.55190453e-01f, -4.18089867e-01f, -1.52545385e-02f, 2.12860584e-01f, -4.33286518e-01f, -4.85014588e-01f, 3.92432183e-01f,
  2.16465428e-01f, 3.21233943e-02f, 1.55465052e-01f, -1.63318172e-01f, -3.05858940e-01f, 3.21016088e-02f, -3.62409413e-01f, 3.20948333e-01f, 4.96181883e-02f, -5.83596304e-02f,
  2.86044598e-01f, -2.61998683e-01f, 2.04876423e-01f, -2.79511511e-01f, -3.35310787e-01f, -8.57201740e-02f, 1.94971606e-01f, -3.78894031e-01f, 1.73223391e-01f, 4.49999832e-02f,
  3.33000243e-01f, -4.60175008e-01f, -2.53478199e-01f, 1.44363195e-01f, 4.09177989e-01f, -3.35144043e-01f, 3.84787619e-01f, 6.65126508e-03f, 2.18893722e-01f, -1.18158251e-01f,
  -3.65193486e-02f, -6.71349645e-01f, -1.01053551e-01f, 2.58030355e-01f, 2.07556143e-01f, 4.81790692e-01f, -1.95270866e-01f, 1.69296235e-01f, -2.29993537e-01f, -5.38970649e-01f,
  -1.26763389e-01f, -8.13587368e-01f, 2.57090986e-01f, 2.31090024e-01f, 3.17026936e-02f, 1.40070483e-01f, -1.09164879e-01f, 1.66857585e-01f, -2.56221015e-02f, -2.67235816e-01f,
  1.76455855e-01f, -2.45184861e-02f, -2.48028755e-01f, 2.70665675e-01f, 1.58746496e-01f, 2.41231471e-01f, 3.78106564e-01f, -3.90765697e-01f, 4.02942263e-02f, -1.79063737e-01f,
  1.39261447e-02f, -3.48234683e-01f, -3.21789235e-01f, -1.75747946e-01f, -7.30759025e-01f, -3.77468288e-01f, -5.90211391e-01f, 1.10079311e-01f, -3.41248542e-01f, 4.56768334e-01f,
  4.49357092e-01f, -5.70469499e-01f, 3.00742388e-01f, 7.10222721e-02f, 3.41297612e-02f, 2.20659435e-01f, -5.66637069e-02f, 3.05681173e-02f, 3.26261610e-01f, 2.42950857e-01f,
  -3.69892329e-01f, 1.21857554e-01f, 1.61344379e-01f, 2.86824256e-01f, 4.26061094e-01f, -5.00359416e-01f, -3.29274297e-01f, 3.26452434e-01f, 1.10708460e-01f, 2.50947624e-01f,
  -3.86576116e-01f, 3.82618666e-01f, -4.32137489e-01f, -1.15378596e-01f, -3.62392366e-01f, -3.95853728e-01f, 6.06940091e-01f, -5.34482896e-01f, 6.31499052e-01f, -2.07346290e-01f,
  -2.04465911e-01f, -4.67495352e-01f, -2.53304511e-01f, 7.17003882e-01f, -4.95423079e-01f, -6.89843476e-01f, 2.93670464e-02f, -4.00721133e-02f, 1.08712479e-01f, -2.77941793e-01f,
  -1.39654696e-01f, -2.56774072e-02f, 2.59412490e-02f, -2.32112467e-01f, -1.38582513e-01f, -2.33162060e-01f, -8.64483491e-02f, 1.51878074e-01f, -1.53449178e-01f, 1.69831157e-01f,
  -2.97298376e-03f, 1.57355964e-02f, -2.62956202e-01f, -1.51667044e-01f, -2.17929438e-01f, -3.98927242e-01f, 1.62317619e-01f, -2.83252448e-01f, -1.55488089e-01f, -4.59857374e-01f,
  8.18437040e-02f, -3.46725315e-01f, 4.55362320e-01f, 3.22900236e-01f, -2.99335003e-01f, 5.47736883e-01f, -2.60297507e-01f, -9.78282988e-02f, 1.21316172e-01f, 3.44090223e-01f,
  1.81533657e-02f, -4.42298986e-02f, -1.78165317e-01f, 5.59902154e-02f, -6.47603646e-02f, 2.39932723e-02f, 1.51402935e-01f, 2.64338225e-01f, -3.68597537e-01f, 4.38714087e-01f,
  1.39637113e-01f, 1.45958617e-01f, -2.90651917e-01f, 3.52726012e-01f, 3.91081959e-01f, 1.16865553e-01f, 8.19583237e-02f, 6.44343615e-01f, -5.45139432e-01f, 3.80430669e-01f,
  -3.38114977e-01f, -6.89304173e-01f, 4.12333339e-01f, -8.85120854e-02f, -3.18632096e-01f, 1.29945010e-01f, -3.59451175e-01f, -5.13530016e-01f, 3.13806236e-01f, -4.07651842e-01f,
  -6.96753757e-03f, -1.15030371e-01f, 1.52645931e-01f, 8.26437995e-02f, -5.65427504e-02f, -5.71633019e-02f, -1.19305857e-01f, 2.83547401e-01f, 1.72278389e-01f, 3.47005695e-01f,
  4.01129693e-01f, 1.36033744e-01f, 4.33165550e-01f, 3.06363851e-01f, 2.99849033e-01f, -3.89651418e-01f, -1.27026290e-02f, -2.53585249e-01f, 2.28990108e-01f, -3.44505101e-01f,
  3.38267654e-01f, 4.33880657e-01f, -5.90438247e-01f, 4.06772643e-01f, -5.41744828e-01f, 1.24192042e-02f, -4.01461720e-01f, -4.60975647e-01f, -8.25063363e-02f, -4.92152184e-01f,
  -5.14285326e-01f, 2.55922437e-01f, -2.81098217e-01f, -1.45143107e-01f, -5.14302440e-02f, 1.91614032e-01f, -6.15321398e-02f, -1.05102755e-01f, 4.31887731e-02f, 2.91647851e-01f,
  7.49989823e-02f, 4.73076403e-02f, 4.28579390e-01f, -1.13920599e-01f, -2.09245846e-01f, 2.22309425e-01f, 4.58654575e-02f, -4.47127491e-01f, 2.61518896e-01f, -2.88178891e-01f,
  -4.03818369e-01f, -7.59492293e-02f, -3.68144453e-01f, -2.55600482e-01f, 3.93650793e-02f, -3.95029932e-01f, -4.20739383e-01f, 2.37052396e-01f, -9.27285925e-02f, 2.19877779e-01f,
  5.98537147e-01f, 5.32674313e-01f, -7.85574198e-01f, -2.88838111e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.76244220e-02f, 9.06516686e-02f, -1.32088751e-01f, 1.26755178e-01f, -1.05429634e-01f, 9.30462480e-02f, 5.41567728e-02f, 9.98320654e-02f, -2.44805768e-01f, -1.24669243e-02f,
  -5.70263937e-02f, 4.15184796e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    