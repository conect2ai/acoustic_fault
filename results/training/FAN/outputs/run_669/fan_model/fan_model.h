/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.31461203e-01f, -1.19907774e-01f, -3.16661485e-02f, 9.74840298e-02f, -5.67224398e-02f, -1.50586590e-02f, 1.15565002e-01f, 1.97406366e-01f, 6.85925707e-02f, -4.15828079e-02f,
  4.33397256e-02f, -9.79258195e-02f, -5.30352932e-04f, -6.44114166e-02f, 8.64472538e-02f, -4.49762344e-02f, -8.72103870e-02f, -5.89333884e-02f, 1.12156652e-01f, 1.26297593e-01f,
  -3.95241231e-02f, -7.50350161e-03f, 9.65635031e-02f, 1.16802705e-02f, -5.11183441e-02f, -3.33885141e-02f, 1.86096821e-02f, -1.42366916e-01f, -1.79596171e-01f, -3.13648522e-01f,
  -2.57836312e-01f, 5.84119298e-02f, 4.70782295e-02f, -1.39421206e-02f, -8.06170702e-02f, 2.32406221e-02f, -2.42762454e-03f, -1.52459629e-02f, 2.56647635e-02f, 3.22757885e-02f,
  -9.80335772e-02f, -3.16716055e-03f, 1.44258067e-02f, 7.04488456e-02f, 2.04352345e-02f, -4.88661863e-02f, 1.35481134e-02f, 8.21094587e-02f, -2.13559177e-02f, 1.65763753e-03f,
  -1.46143034e-01f, -6.41595274e-02f, 1.86628546e-03f, 4.81939390e-02f, -1.49864666e-02f, -3.33071128e-02f, -5.28405085e-02f, -3.98985930e-02f, 2.49365941e-02f, 6.60492927e-02f,
  3.43952663e-02f, -2.67831795e-02f, -1.04134545e-01f, 4.43913639e-02f, 1.78746488e-02f, 3.96840982e-02f, 3.08949891e-02f, -2.96464898e-02f, 4.59378473e-02f, 2.82858703e-02f,
  -1.27505735e-02f, -8.55794773e-02f, 8.82180631e-02f, 5.74961789e-02f, -3.43649797e-02f, 1.97707359e-02f, -5.50391339e-02f, 2.22887583e-02f, -7.28040643e-04f, -2.09345911e-02f,
  6.52275383e-02f, 3.61997448e-02f, -3.68751436e-02f, -4.51922417e-02f, -7.94858579e-03f, -4.41021137e-02f, -3.53806876e-02f, 4.80979495e-02f, 6.99321628e-02f, -2.32191494e-04f,
  -1.08194184e-02f, 3.96686904e-02f, 6.68068677e-02f, -1.77623965e-02f, -1.52319465e-02f, 2.84737088e-02f, -6.06608018e-02f, -8.00256580e-02f, -1.44276172e-01f, -1.88691802e-02f,
  -6.01890013e-02f, 2.55260873e-03f, -4.74061221e-02f, -9.85352546e-02f, 1.65933758e-01f, 9.40244459e-03f, -4.20345217e-02f, -4.04827483e-02f, -4.63593490e-02f, -1.18479468e-01f,
  6.06107749e-02f, 1.50001580e-02f, 1.01623125e-01f, 1.06352106e-01f, 9.50558260e-02f, 1.06104091e-01f, 3.29467691e-02f, 7.24746380e-04f, 4.79707383e-02f, 2.33755514e-01f,
  -1.00079328e-01f, -2.79794157e-01f, -1.93110649e-02f, 9.75443423e-03f, -3.75970751e-02f, 3.08600478e-02f, -3.02739382e-01f, 6.63818344e-02f, 9.26090702e-02f, -1.25108913e-01f,
  -2.06159487e-01f, 4.09377851e-02f, 5.23113422e-02f, 1.83681801e-01f, 2.11729109e-01f, -4.28316556e-02f, 6.61031753e-02f, 2.36579895e-01f, 4.12210524e-01f, 1.45538330e-01f,
  -3.32144760e-02f, -4.27285954e-02f, 1.22235440e-01f, 1.25323325e-01f, -1.56555384e-01f, 1.50328249e-01f, -9.11588445e-02f, -1.82747647e-01f, -1.82270080e-01f, -2.82369405e-01f,
  -1.49489477e-01f, -2.59455174e-01f, 1.88335419e-01f, -6.39808327e-02f, -4.54324484e-02f, 2.12509856e-02f, 3.78070250e-02f, -8.62852670e-03f, -4.03782055e-02f, -6.33387193e-02f,
  -7.01069832e-02f, -6.69860456e-04f, -2.58658696e-02f, -8.51902887e-02f, -1.16071627e-01f, -4.92800325e-02f, -9.24696401e-02f, 1.63130481e-02f, 2.24677697e-02f, -5.91321550e-02f,
  -1.62112027e-01f, -4.06704061e-02f, -1.22745208e-01f, -5.04508102e-03f, 8.20607767e-02f, 6.16778024e-02f, -1.54370621e-01f, -5.20960726e-02f, -5.13682142e-03f, -1.59777135e-01f,
  2.16136011e-03f, 3.48861851e-02f, -4.61170077e-02f, 5.04186284e-03f, -6.82756603e-02f, 3.80534977e-02f, 3.47012444e-03f, 4.73275520e-02f, -5.27888956e-03f, -5.71696497e-02f,
  1.32201416e-02f, -2.32549012e-03f, 1.09992325e-01f, -6.81500509e-02f, -2.08142921e-02f, 7.72870379e-03f, -5.11128902e-02f, 3.35231088e-02f, 6.35449425e-04f, -8.16574320e-02f,
  4.46858592e-02f, 7.62992948e-02f, -9.97186266e-03f, -1.10136345e-03f, -4.51316610e-02f, 2.10567340e-02f, -5.40332645e-02f, -3.95023217e-03f, -2.95160841e-02f, -3.32399383e-02f,
  1.70384914e-01f, 1.01885580e-01f, -9.61595867e-03f, 1.04108304e-01f, -2.57426649e-02f, -3.41633111e-02f, 2.96507012e-02f, -1.37718320e-02f, 2.46958733e-02f, 1.52088851e-01f,
  3.48721780e-02f, 3.61966603e-02f, -6.24105930e-02f, 1.21728815e-02f, 7.62180388e-02f, -1.97923053e-02f, -5.10921702e-02f, 1.21766087e-02f, 2.58189943e-02f, 3.77092627e-03f,
  8.90013427e-02f, 6.57951161e-02f, 4.02824320e-02f, 5.39700277e-02f, 9.43936929e-02f, 1.75160229e-01f, 3.86901870e-02f, 1.55171566e-02f, 1.23502716e-01f, 6.36901781e-02f,
  -1.39195353e-01f, 3.31319064e-01f, 4.31553781e-01f, -1.02909456e-03f, -1.07456110e-01f, -1.51949644e-01f, -1.02780582e-02f, -9.06622037e-02f, -2.40484759e-01f, -8.06063041e-02f,
  1.86696738e-01f, 5.37304655e-02f, 5.73730506e-02f, 1.34365335e-01f, 4.47853431e-02f, -7.27591366e-02f, 7.33777359e-02f, 1.13204770e-01f, -4.21225838e-02f, -8.43220428e-02f,
  -4.70051691e-02f, -7.46964365e-02f, 1.38504967e-01f, 1.08155580e-02f, 3.22187878e-02f, -7.17881396e-02f, 1.78067043e-01f, 1.15380742e-01f, 1.51571840e-01f, 2.71397144e-01f,
  -2.10325979e-02f, 2.72549212e-01f, 1.82424113e-02f, 8.79574120e-02f, 9.57309604e-02f, 3.39183249e-02f, -1.93182025e-02f, 1.19426772e-01f, -2.31478140e-02f, 1.54977277e-01f,
  2.11684346e-01f, 8.55737776e-02f, 6.01828136e-02f, 1.12211490e-02f, 2.17376165e-02f, -1.02992719e-02f, 1.01677343e-01f, 1.97773248e-01f, 7.56437033e-02f, 9.27456841e-02f,
  1.63995966e-01f, 6.36670440e-02f, -8.34391173e-03f, 7.75147676e-02f, 1.40709341e-01f, 2.78945640e-03f, 1.75750703e-01f, 1.47032067e-01f, 6.20144270e-02f, 7.49323666e-02f,
  -1.52837187e-02f, -1.07726846e-02f, -6.48685992e-02f, 2.54620872e-02f, -4.31792811e-02f, 2.30262187e-04f, 4.06439863e-02f, -6.78551896e-03f, -5.15275933e-02f, 2.97734663e-02f,
  2.66214330e-02f, 5.14538884e-02f, 7.70029128e-02f, 1.27167702e-01f, 5.18339276e-02f, 3.61029059e-02f, -4.32316773e-02f, 8.07812586e-02f, 4.13669944e-02f, -2.03099214e-02f,
  -7.94287864e-03f, 1.13469012e-01f, -6.39461866e-03f, 1.28870040e-01f, 1.28198862e-01f, 1.25287622e-01f, 1.39754713e-02f, 3.08606774e-02f, -6.83596805e-02f, 6.46048561e-02f,
  -3.00337583e-01f, 1.77161500e-01f, -1.10887639e-01f, 5.17011527e-03f, -7.06009790e-02f, -4.72384319e-02f, 3.54568437e-02f, -1.90639608e-02f, 1.80965699e-02f, -3.56059261e-02f,
  4.99550365e-02f, -2.20141672e-02f, -1.95293631e-02f, 3.94522622e-02f, -4.87639084e-02f, -4.32371814e-03f, -4.41584550e-02f, 8.57003555e-02f, 5.20817563e-02f, 9.31041390e-02f,
  2.71136556e-02f, -9.99622270e-02f, -2.31703967e-01f, -1.20637737e-01f, -4.63418588e-02f, -1.48033977e-01f, -1.22139744e-01f, -1.39336288e-01f, -1.30290106e-01f, -3.55029434e-01f,
  -3.63059163e-01f, 3.67884576e-01f, 1.38525680e-01f, -1.45035148e-01f, 6.51757196e-02f, 4.01881263e-02f, 5.04142642e-02f, -6.22821935e-02f, -6.33896440e-02f, 1.01011254e-01f,
  2.32394770e-01f, 1.29120573e-01f, 2.64053158e-02f, 7.44734779e-02f, 2.25498080e-02f, 6.29367307e-02f, -8.94459896e-03f, -4.86822501e-02f, -9.35438722e-02f, -2.23624445e-02f,
  8.06723461e-02f, -2.81596575e-02f, -2.14119509e-01f, -4.77520190e-02f, 1.63644582e-01f, -7.68930465e-02f, -1.25783095e-02f, 1.17476553e-01f, 2.00711295e-01f, 4.04035807e-01f,
  1.06288053e-01f, 2.47189224e-01f, -2.68290509e-02f, 3.65027972e-03f, 7.51434714e-02f, 8.72172182e-04f, -9.16497782e-02f, 4.86424156e-02f, 2.99895052e-02f, -2.53676828e-02f,
  4.14904170e-02f, -2.92987935e-02f, -7.48799741e-02f, 5.01615070e-02f, -2.55103093e-02f, -9.38274898e-03f, 1.07154390e-02f, -5.01055159e-02f, 6.52402788e-02f, -7.31558958e-03f,
  -1.03409088e-03f, 1.24812335e-01f, 7.55462870e-02f, 3.42966951e-02f, 2.05429997e-02f, 3.70660461e-02f, 6.06020465e-02f, 1.37259156e-01f, -1.46470871e-02f, 1.03003435e-01f,
  2.07523666e-02f, -1.68564264e-02f, 5.76829654e-04f, 3.77923134e-03f, 1.85790733e-02f, -2.81035295e-03f, 1.60294492e-02f, -1.05758980e-01f, -5.54899033e-03f, -5.06767109e-02f,
  4.85708416e-02f, -7.37453699e-02f, -7.20552308e-03f, -5.64233251e-02f, 3.62718292e-02f, 1.23031028e-02f, 4.17898595e-02f, -3.37882712e-03f, 3.91264036e-02f, 2.02025846e-02f,
  3.60314585e-02f, 1.27962932e-01f, 3.74880619e-02f, -2.18754243e-02f, 1.00199115e-02f, 5.62432148e-02f, -2.74666641e-02f, -5.89766055e-02f, -9.80375931e-02f, -3.60339694e-02f,
  -2.67171323e-01f, 1.15908645e-01f, -1.13345338e-02f, 1.07152134e-01f, 1.54244499e-02f, -3.04136761e-02f, 4.29946780e-02f, 7.42189437e-02f, -8.72274414e-02f, 7.42222592e-02f,
  -1.22575900e-02f, -6.18865117e-02f, 5.65937385e-02f, -4.53465804e-02f, -3.78111526e-02f, 5.73857641e-03f, 9.02078524e-02f, -2.65005212e-02f, 6.21705055e-02f, 3.56011689e-02f,
  2.93078516e-02f, -1.12834886e-01f, -1.51943922e-01f, 2.59231925e-02f, -1.45274308e-02f, -5.15926369e-02f, -7.82563239e-02f, -1.22854456e-01f, -1.07971564e-01f, -2.46353045e-01f,
  3.77733499e-01f, -3.44036371e-01f, 2.52718180e-01f, 4.36956137e-01f, 3.06177527e-01f, 4.29237299e-02f, -1.14021040e-01f, 8.92433226e-02f, 1.93604544e-01f, 3.91697250e-02f,
  -2.87101278e-03f, -5.52581139e-02f, -1.63541973e-01f, -4.35728021e-02f, -1.28442734e-01f, 3.02080307e-02f, 8.16121697e-02f, 9.37079936e-02f, 4.25971870e-04f, 1.37058780e-01f,
  -8.76924619e-02f, 1.45078868e-01f, 2.02674955e-01f, 2.69569680e-02f, 1.27797827e-01f, -6.73624352e-02f, -5.14078140e-02f, 3.61574553e-02f, -1.22538738e-01f, 2.37418398e-01f,
  1.57687232e-01f, 5.84573746e-02f, 1.77264348e-01f, -1.52781222e-03f, -4.13447581e-02f, -7.23881274e-02f, -9.40627605e-02f, -4.96214367e-02f, -5.69454134e-02f, 2.70132031e-02f,
  1.14535755e-02f, -2.11820528e-02f, 5.34684993e-02f, -4.75773662e-02f, 9.02530029e-02f, -4.86636581e-03f, -1.62892509e-02f, -5.26425801e-03f, 8.91027320e-03f, 4.98698726e-02f,
  -1.26475459e-02f, 1.12692788e-01f, 5.43906316e-02f, -6.20322749e-02f, -4.42778841e-02f, 4.91066426e-02f, 4.11163382e-02f, 4.63860203e-03f, 8.88147578e-03f, 9.36466306e-02f,
  6.08256981e-02f, -5.82579188e-02f, -5.45753865e-03f, 2.30565052e-02f, -2.82076467e-02f, -6.80677220e-02f, 6.06786013e-02f, -4.93734293e-02f, 5.07206097e-02f, -3.93558480e-02f,
  -3.84201407e-02f, 1.10058814e-01f, -5.59115596e-02f, -4.33289967e-02f, 5.19657284e-02f, -1.79726945e-03f, -1.37726404e-02f, 4.40510511e-02f, 4.54901904e-03f, 7.39036128e-02f,
  4.95783538e-02f, 5.54654747e-02f, -3.47527228e-02f, -1.54855719e-03f, -3.06870714e-02f, 8.71489570e-03f, -1.44533254e-02f, 8.95414781e-03f, -8.47976655e-02f, 5.37402332e-02f,
  -8.77894238e-02f, 1.39927000e-01f, 5.39501989e-03f, -9.79962852e-03f, 2.68088263e-02f, -4.44563515e-02f, 1.39557779e-01f, -7.73315355e-02f, 4.45914380e-02f, 6.68987930e-02f,
  3.24245021e-02f, -2.11128946e-02f, -7.71160051e-02f, -7.61678591e-02f, -3.08185257e-03f, 2.83317058e-03f, -7.84736276e-02f, 3.39594223e-02f, -2.90052164e-02f, 2.55214237e-03f,
  -9.83746350e-03f, -3.02499812e-02f, -7.23608583e-02f, -1.98532976e-02f, 2.32488420e-02f, 8.28082338e-02f, -4.61017378e-02f, 9.18034613e-02f, -5.07522114e-02f, -1.97551936e-01f,
  2.86945522e-01f, 3.00031811e-01f, 4.27994691e-02f, 2.14485139e-01f, 1.24377877e-01f, 7.23213628e-02f, 2.86764383e-01f, 6.29768819e-02f, 1.58931032e-01f, 1.32684916e-01f,
  2.85107978e-02f, -2.08999723e-01f, -3.38440299e-01f, -2.45435193e-01f, -1.96068153e-01f, 2.42560670e-01f, 1.75649181e-01f, -2.33002186e-01f, -2.68129915e-01f, -2.57236175e-02f,
  2.02637278e-02f, 1.42987236e-01f, 3.57774273e-02f, -1.79139264e-02f, 1.88706353e-01f, -6.78417087e-02f, 1.48222700e-01f, 1.64771885e-01f, -2.40050741e-02f, 4.01304483e-01f,
  -3.38109285e-02f, 1.52723536e-01f, -3.54609005e-02f, 2.10813154e-02f, -2.00405903e-02f, 7.90195912e-02f, -2.77786609e-02f, 1.27848266e-02f, 4.48282734e-02f, 3.99939567e-02f,
  4.03316952e-02f, -2.30434835e-02f, 1.91473197e-02f, 6.47269711e-02f, 1.35003617e-02f, 8.49093646e-02f, 5.45854419e-02f, -2.09472254e-02f, 1.06545473e-02f, 1.91045161e-02f,
  7.69744515e-02f, 6.34845719e-02f, -5.96959516e-02f, 1.14985975e-02f, -5.47314715e-03f, 3.19649884e-03f, 3.58333215e-02f, -4.85989898e-02f, -1.13879949e-01f, 1.96815997e-01f,
  1.08816223e-02f, 1.57344434e-03f, -1.52988117e-02f, 7.35583603e-02f, -2.47411057e-02f, 2.29964908e-02f, 1.25806201e-02f, 5.62156513e-02f, -5.93305342e-02f, 1.55526316e-02f,
  -6.31706789e-02f, -7.27611929e-02f, 1.53643768e-02f, 3.54253128e-02f, -5.58085479e-02f, 4.26816568e-02f, 2.34019887e-02f, 6.09582625e-02f, -2.19924673e-02f, 5.81929199e-02f,
  -6.73136720e-03f, 1.69354919e-02f, -2.30570883e-02f, -2.14660261e-03f, 2.55480390e-02f, 2.15172973e-02f, -5.26660914e-03f, 2.01547462e-02f, 9.61716473e-03f, 8.98338556e-02f,
  -2.37328466e-02f, -1.64070457e-01f, 5.65567613e-02f, 1.25323115e-02f, 3.52537893e-02f, -6.10139705e-02f, 3.96447331e-02f, 7.59891346e-02f, -3.72585692e-02f, 8.42169970e-02f,
  -6.26944527e-02f, 7.38958223e-03f, -8.46175551e-02f, 8.55281297e-03f, -1.10760726e-01f, 3.84108676e-03f, 7.58033618e-02f, 1.81927364e-02f, 1.86939500e-02f, 1.85664341e-01f,
  1.42490745e-01f, 9.02284756e-02f, -2.99250335e-02f, 6.24268316e-02f, 1.61401015e-02f, -6.64746985e-02f, 2.05257591e-02f, 1.04998775e-01f, -9.17431563e-02f, 2.20924541e-01f,
  3.54860455e-01f, -2.46023864e-01f, 2.38208413e-01f, 7.97951669e-02f, -3.35729755e-02f, -7.06695467e-02f, -1.49255976e-01f, -1.86421141e-01f, -1.36872306e-02f, 4.57473285e-02f,
  -6.40139431e-02f, 1.24375954e-01f, 9.70645696e-02f, -3.50560807e-02f, 9.16268080e-02f, 6.48847129e-03f, 2.96160895e-02f, 2.18509406e-01f, 6.41406402e-02f, 2.88265608e-02f,
  -1.53698638e-01f, 2.32114233e-02f, 9.86609161e-02f, 6.08717464e-02f, -9.40589756e-02f, 3.16539370e-02f, 6.80776685e-02f, 4.73558642e-02f, 3.39126699e-02f, 2.84196455e-02f,
  4.95589748e-02f, -1.87145378e-02f, 7.49766305e-02f, 2.30465438e-02f, 3.33802029e-03f, -5.33219539e-02f, -1.02986641e-01f, 5.08803800e-02f, -9.66871306e-02f, -4.72082794e-02f,
  4.62809093e-02f, 5.71634471e-02f, 1.16514072e-01f, -7.70784318e-02f, -3.24056856e-02f, -2.10296363e-02f, -1.18421922e-02f, 3.72699946e-02f, 1.59725137e-02f, 9.53044929e-03f,
  -1.43503044e-02f, -5.34375459e-02f, 8.82004052e-02f, -5.97845428e-02f, 9.55084711e-02f, 9.22809020e-02f, -1.07725896e-01f, 7.79438624e-03f, 1.32620215e-01f, -2.85320226e-02f,
  2.03361362e-02f, -1.43344030e-02f, 3.89271579e-03f, 3.49595398e-02f, -4.20220308e-02f, -2.94535235e-02f, 2.65964773e-02f, 4.20156308e-02f, 3.60048153e-02f, -7.55117163e-02f,
  4.49114628e-02f, 1.02729827e-01f, 8.06350727e-03f, 2.25080010e-02f, -5.01323193e-02f, 8.71118605e-02f, -5.87423611e-03f, -4.40729521e-02f, 1.05243117e-01f, 2.08879095e-02f,
  7.92130008e-02f, 1.22008352e-02f, -5.86072728e-02f, -2.49019824e-02f, 4.93650474e-02f, 1.70571506e-02f, 4.77385446e-02f, -8.35155919e-02f, 4.29775380e-02f, -5.15307672e-02f,
  -2.29087055e-01f, 3.83672804e-01f, 1.54338637e-02f, 1.30399048e-01f, -1.77104250e-02f, 2.74577085e-02f, 1.27003625e-01f, 1.51129095e-02f, 4.45223600e-02f, 4.68669087e-02f,
  6.77111149e-02f, 9.82005224e-02f, 1.02948196e-01f, 3.89381684e-02f, -5.20198382e-02f, 7.56235942e-02f, -1.06810778e-02f, 3.53496261e-02f, 4.15591821e-02f, -3.07165482e-03f,
  -1.39173092e-02f, -1.00900434e-01f, -8.13183561e-03f, -2.71902140e-02f, -2.84377560e-02f, 7.58808479e-02f, -8.40673894e-02f, -1.48868961e-02f, 5.64936772e-02f, -1.78665161e-01f,
  -2.06167296e-01f, -4.51400608e-01f, -1.70510516e-01f, -8.53019431e-02f, -1.36697873e-01f, 6.47401786e-04f, -1.42996445e-01f, -1.12907559e-01f, 6.00099228e-02f, -2.60752708e-01f,
  -3.24276865e-01f, -1.15835987e-01f, -1.92779139e-01f, -5.14566712e-02f, -1.46222964e-01f, -2.29508251e-01f, -7.93218836e-02f, 9.58359316e-02f, 1.93253443e-01f, -1.04556344e-01f,
  -1.59523636e-01f, 2.83006765e-02f, 9.03781801e-02f, 6.46523386e-02f, -2.56325841e-01f, 4.72747684e-02f, -1.04116790e-01f, -1.03198513e-01f, -1.03012502e-01f, -2.87575066e-01f,
  -3.21346164e-01f, -2.87387222e-01f, -1.65335387e-01f, -2.64244080e-01f, -1.87013969e-01f, -2.11985514e-01f, -1.08148679e-01f, -1.01512045e-01f, -5.12444153e-02f, -1.01614423e-01f,
  -2.21601292e-01f, -1.92777455e-01f, -2.61411965e-01f, -1.61402121e-01f, -1.05161078e-01f, -2.06557363e-01f, -1.19480692e-01f, -2.01187119e-01f, -1.30479187e-01f, -3.37300360e-01f,
  -3.04516464e-01f, -2.85930097e-01f, -2.57048339e-01f, -2.43119001e-01f, -3.00764859e-01f, -9.61154401e-02f, -2.08557993e-01f, -1.97020978e-01f, -2.50016332e-01f, -2.01139092e-01f,
  -4.60733147e-03f, -4.40772958e-02f, 2.08516773e-02f, 9.08362865e-02f, 9.63803288e-03f, -8.71791020e-02f, -2.19332650e-02f, -8.43006670e-02f, 1.45721480e-01f, 6.91539571e-02f,
  -6.48527071e-02f, 1.32017834e-02f, 8.01008567e-02f, 1.63255557e-02f, 3.88346263e-03f, -6.94808960e-02f, 1.41082937e-02f, 8.54294598e-02f, 4.91238385e-02f, 1.09598860e-01f,
  -3.61627191e-02f, -2.78023966e-02f, -4.68376130e-02f, 4.42164838e-02f, -6.78498521e-02f, 8.13430995e-02f, -4.88203913e-02f, -1.18522309e-02f, 8.43238551e-03f, -6.27768040e-02f,
  -3.26228440e-02f, 4.84905019e-02f, -1.01518676e-01f, -1.40736833e-01f, 2.72427499e-02f, 3.95749882e-02f, -9.09081008e-03f, -2.12741531e-02f, -8.11478198e-02f, -1.11001961e-01f,
  -6.05969727e-02f, -1.51898488e-01f, -1.06820188e-01f, -2.89858356e-02f, -2.35702284e-02f, -6.03573397e-02f, -1.12597588e-02f, -1.23756975e-01f, 4.64447439e-05f, -6.94161430e-02f,
  -7.85337985e-02f, 1.12581722e-01f, 5.43038137e-02f, 5.16791418e-02f, -6.56411350e-02f, -1.14456832e-01f, 2.15221502e-04f, 1.55088268e-02f, -1.08876117e-02f, -3.39516066e-02f,
  5.29333353e-01f, 1.84432209e-01f, -7.39532411e-02f, 2.72713024e-02f, -2.55295694e-01f, 3.97570338e-03f, 3.04892629e-01f, 2.48081326e-01f, 4.69764620e-02f, 5.05385064e-02f,
  -1.97280616e-01f, -1.75406367e-01f, -6.61971420e-02f, -9.29670557e-02f, 1.64470717e-01f, 2.04567090e-01f, 1.73652261e-01f, 1.93476588e-01f, -6.80010989e-02f, -8.94038603e-02f,
  -9.63867754e-02f, 1.72983244e-01f, 2.20137492e-01f, 1.19942442e-01f, 1.76402494e-01f, -5.39246798e-02f, -1.47278607e-02f, 1.23337604e-01f, -5.72624095e-02f, 3.16219628e-01f,
  -1.02194753e-02f, 2.49880776e-01f, 6.44288957e-03f, -1.49451697e-03f, -6.51813969e-02f, 2.32142925e-01f, 8.68387073e-02f, 1.16111293e-01f, 7.44761154e-02f, 1.59824714e-01f,
  1.57865342e-02f, 4.55597341e-02f, 1.21698761e-02f, 5.82582057e-02f, 3.44443023e-02f, 1.21029273e-01f, 9.75673720e-02f, 2.60547310e-01f, 1.70715913e-01f, 1.15397666e-02f,
  -1.30053321e-02f, 4.29665484e-02f, 1.81177616e-01f, 1.18455559e-01f, 1.14795513e-01f, 1.03584416e-01f, 2.10913524e-01f, 2.59727716e-01f, 9.26047191e-02f, 2.38139644e-01f,
  -1.73964445e-02f, -1.68564997e-03f, -8.23292732e-02f, 7.96392038e-02f, -2.80267652e-02f, -6.37289733e-02f, -9.29131061e-02f, -1.38009340e-02f, -9.09036770e-03f, 1.67550277e-02f,
  -6.83631599e-02f, 1.00312606e-02f, 2.11598375e-03f, 5.21059670e-02f, -2.87948530e-02f, 4.11373116e-02f, -1.65023580e-02f, 3.78421992e-02f, -6.80246353e-02f, 4.74252403e-02f,
  -1.73275396e-02f, 1.88257098e-02f, -4.62722704e-02f, 6.60770833e-02f, 1.21545568e-02f, 1.09089334e-02f, 2.83724032e-02f, -1.02138080e-01f, -2.16164067e-03f, -5.70081249e-02f,
  7.11927712e-02f, 8.32194090e-02f, 8.64927396e-02f, 9.79788601e-02f, 3.76521982e-02f, 5.74890152e-02f, -1.30866822e-02f, 1.01725131e-01f, -2.11766027e-02f, 1.22890398e-01f,
  4.09948640e-02f, 1.07340887e-01f, -7.07605761e-03f, 9.66559574e-02f, 1.16195502e-02f, -2.29083020e-02f, -3.95751968e-02f, 3.58275101e-02f, 1.30852923e-01f, 1.49758682e-01f,
  5.55788204e-02f, 1.11270115e-01f, 9.36146453e-02f, 1.62697569e-01f, 1.41823649e-01f, -1.00080110e-02f, 5.13018854e-02f, 1.18737951e-01f, 1.11070938e-01f, 1.68419942e-01f,
  2.00737994e-02f, -4.22527604e-02f, -8.71311277e-02f, -1.43472469e-04f, -9.70557779e-02f, -2.66685132e-02f, -5.00228703e-02f, 7.59612769e-02f, -5.04010217e-03f, 3.62899937e-02f,
  1.75642222e-01f, 2.72179663e-01f, 3.05673242e-01f, 1.99991897e-01f, 1.54431894e-01f, 2.51869131e-02f, -1.89484730e-01f, -2.29956936e-02f, 4.81768213e-02f, 5.19645885e-02f,
  2.36832034e-02f, -9.96656623e-03f, -3.58575233e-03f, 2.33646054e-02f, -1.10992109e-02f, 2.14140162e-01f, -4.45015095e-02f, -2.65318006e-02f, -2.45816223e-02f, -1.66729242e-01f,
  4.07627821e-02f, -3.70850675e-02f, 2.10048303e-01f, 1.11376636e-01f, -8.48283172e-02f, -1.09021693e-01f, 1.38981137e-02f, -1.80095702e-01f, 5.13209850e-02f, -6.92659318e-02f,
  -4.97596227e-02f, -5.42872325e-02f, -1.13274723e-01f, -4.99436334e-02f, -1.29678115e-01f, -2.93836258e-02f, -8.67417306e-02f, -1.00808211e-01f, -3.82287353e-02f, 1.46817295e-02f,
  -3.54788043e-02f, -1.35601848e-01f, -7.06638619e-02f, -1.12206221e-01f, 3.50858755e-02f, -2.23865621e-02f, -1.33663509e-02f, -1.05608769e-01f, 1.04328245e-02f, -6.63962737e-02f,
  7.53823891e-02f, -2.23072655e-02f, 1.16341161e-02f, -1.05639838e-01f, 2.89693126e-03f, -8.70293975e-02f, 6.08103757e-04f, -2.62208469e-02f, 5.31288935e-03f, -6.24719486e-02f,
  -1.72010735e-02f, 1.63865667e-02f, -4.05750424e-02f, 9.38713609e-04f, 1.05336808e-01f, -1.06554396e-01f, -3.57043557e-02f, -6.02107146e-04f, 3.17037553e-02f, -5.62030114e-02f,
  -2.40137987e-02f, -3.68745029e-02f, -4.50231470e-02f, 5.90681471e-02f, -5.10996953e-03f, -8.30064192e-02f, -4.05269489e-02f, 3.46802212e-02f, -3.71059887e-02f, -8.14613327e-02f,
  1.25410885e-01f, 3.60876508e-02f, 2.12801740e-01f, 6.16846122e-02f, 1.14326030e-02f, -2.76801847e-02f, -1.07675306e-01f, -7.44216191e-03f, -2.36541349e-02f, 7.14334920e-02f,
  4.18158025e-02f, 1.79138258e-02f, -4.42298502e-03f, -1.16718479e-01f, 3.36205028e-02f, 1.33698713e-02f, -2.72626635e-02f, -3.53145264e-02f, -3.39479037e-02f, -2.69404147e-02f,
  -6.43175980e-03f, -1.05500901e-02f, 4.90423031e-02f, 6.53943419e-02f, 2.75925472e-02f, 7.91104883e-02f, 8.98508877e-02f, 3.09326630e-02f, -7.59674609e-03f, 1.14503577e-01f,
  3.33759449e-02f, 5.60477555e-01f, 9.85300913e-02f, 4.47356440e-02f, 1.70988902e-01f, 8.94855782e-02f, 2.64335245e-01f, 1.28195435e-01f, -5.05163819e-02f, 1.93981081e-01f,
  2.92283952e-01f, 4.43958342e-02f, -5.82454540e-02f, 2.53060423e-02f, -9.56568569e-02f, 3.90799344e-02f, -4.51270267e-02f, -2.49565735e-01f, -3.12896013e-01f, -5.47071919e-02f,
  1.24964369e-02f, -6.91692531e-02f, -6.34859502e-02f, -9.05571654e-02f, 9.41486135e-02f, -5.03025278e-02f, 6.83795288e-02f, 1.22692682e-01f, 1.35647625e-01f, 1.22160852e-01f,
  1.82278782e-01f, 2.85485953e-01f, -2.05087706e-01f, 6.49117231e-02f, 1.48138076e-01f, -5.52050062e-02f, -1.17613422e-02f, -4.59055416e-02f, -2.18546633e-02f, 4.92799236e-03f,
  7.27298260e-02f, 7.57915974e-02f, 1.96054112e-02f, 1.32436544e-01f, 7.44972900e-02f, 8.13958794e-02f, 8.38999152e-02f, 7.92251453e-02f, -7.19898865e-02f, 1.69737652e-01f,
  1.25089943e-01f, 7.52372742e-02f, 4.72277813e-02f, -2.23839991e-02f, 3.46895419e-02f, -6.72885701e-02f, 1.29090160e-01f, 6.95401877e-02f, -6.69001415e-02f, 2.47376058e-02f,
  4.45599901e-03f, -1.76403448e-02f, 5.67972437e-02f, -2.27862205e-02f, -1.32348072e-02f, -1.66478995e-02f, 5.38458601e-02f, 2.51470245e-02f, -1.58399288e-02f, -2.38176268e-02f,
  6.04904518e-02f, -7.24874735e-02f, -1.74131747e-02f, -1.59949176e-02f, -1.67063817e-01f, -1.67640820e-02f, 2.12118458e-02f, -1.00828670e-01f, -8.38920251e-02f, -1.10965766e-01f,
  -8.78432244e-02f, -5.74424751e-02f, -1.03199080e-01f, -2.15931982e-02f, -5.93254194e-02f, 5.76179055e-03f, 6.96058124e-02f, 4.29029092e-02f, 2.92201596e-03f, 4.18122225e-02f,
  -3.31136286e-02f, -1.35474175e-01f, -6.15385845e-02f, -6.20472617e-02f, 1.02732738e-03f, 5.52494302e-02f, 3.22310179e-02f, 1.79814752e-02f, 6.07819017e-03f, 3.47864106e-02f,
  4.70342040e-02f, 8.93577654e-03f, 1.05537824e-01f, 6.20623156e-02f, -8.99907127e-02f, -5.61422296e-02f, 4.87514324e-02f, -3.32745239e-02f, -8.65019187e-02f, 7.24428147e-02f,
  4.07666266e-02f, -7.39380419e-02f, -7.58096799e-02f, -5.80873936e-02f, -5.41319624e-02f, -2.35698178e-01f, -8.25470313e-02f, -1.12738818e-01f, -1.14827573e-01f, -7.74240494e-02f,
  6.76692277e-02f, -1.55789480e-01f, 5.20064950e-01f, 5.47407828e-02f, 2.02109978e-01f, 1.35100067e-01f, 3.73714790e-02f, -6.32953718e-02f, -1.21248119e-01f, 7.58520812e-02f,
  -9.03375819e-02f, -1.69834584e-01f, -1.61847323e-01f, -2.28611603e-02f, 1.22985814e-03f, -1.35027170e-02f, 1.89415812e-01f, 1.27580166e-01f, 2.01692730e-01f, 2.99009774e-02f,
  -3.19130905e-02f, 6.70227334e-02f, 4.33586910e-02f, -4.17353772e-02f, -1.13902604e-02f, -4.03303653e-02f, 6.98742419e-02f, 6.78816251e-03f, -2.19662581e-02f, 1.79106221e-02f,
  2.79216081e-01f, 6.41574785e-02f, 1.54316157e-01f, 2.68034823e-03f, 3.74963246e-02f, -7.69510046e-02f, 1.06310278e-01f, 7.72571117e-02f, -3.22980620e-02f, -5.88026177e-03f,
  -2.86206976e-02f, -1.33041114e-01f, 4.13672067e-03f, 7.41216913e-02f, -2.09692176e-02f, 9.45113897e-02f, -5.89059182e-02f, 1.26887159e-02f, 4.76074368e-02f, -5.89887202e-02f,
  -4.12460528e-02f, 1.17512621e-01f, 2.11261287e-02f, -1.07293646e-03f, -4.94877696e-02f, 7.28908181e-02f, 5.51250614e-02f, -6.61861077e-02f, 1.29638404e-01f, -5.39157204e-02f,
  -1.18711121e-01f, 4.07446586e-02f, -9.32315644e-03f, 6.48973435e-02f, -1.32905811e-01f, 2.26763058e-02f, 7.67063210e-03f, -1.73272863e-02f, -7.23124668e-02f, -5.82753196e-02f,
  -2.62227021e-02f, 1.10860556e-01f, 5.34543768e-02f, 2.29612533e-02f, 4.93496992e-02f, 7.44121745e-02f, 1.40279755e-02f, -5.76384366e-02f, -5.93463145e-02f, -6.41518012e-02f,
  -4.37648818e-02f, -7.20032956e-03f, -2.73233093e-02f, -2.79035512e-02f, 1.06095284e-01f, -2.36970671e-02f, 8.47249385e-03f, -1.22023664e-01f, -1.45313125e-02f, 4.43858877e-02f,
  -6.00111261e-02f, 6.86875582e-02f, -3.91524620e-02f, -6.10236339e-02f, -2.95623131e-02f, 1.36363069e-02f, -3.77795808e-02f, -2.28044800e-02f, 5.44128083e-02f, 1.20948389e-01f,
  -3.84747842e-03f, 6.85363039e-02f, 4.82097194e-02f, 1.72603074e-02f, 9.77392271e-02f, 2.69475058e-02f, -7.24906176e-02f, 4.23066281e-02f, 1.38697820e-02f, -5.73334210e-02f,
  -7.19939917e-02f, -4.60959561e-02f, -2.44431943e-02f, 2.22054087e-02f, 3.13378237e-02f, 7.24977329e-02f, 2.76951678e-02f, 4.94203307e-02f, -3.05058658e-02f, -1.38003170e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.47516504e-01f, 1.31840557e-01f, -4.27423596e-01f, 2.31552467e-01f, 1.17977999e-01f, -1.55089945e-01f, -1.09623656e-01f, -1.45974413e-01f, 1.90302521e-01f, 9.54270288e-02f,
  1.32716913e-02f, -3.31367878e-03f, 1.69605836e-02f, -9.59361196e-02f, -1.97446555e-01f, 1.30347729e-01f, 2.08657697e-01f, -2.22994074e-01f, -4.83649313e-01f, -3.14786315e-01f,
  3.63013148e-01f, 1.46785364e-01f, -1.24799743e-01f, -6.48675784e-02f, 2.94743448e-01f, 1.26611084e-01f, 9.31659341e-02f, -2.25133300e-02f, -1.17907025e-01f, 3.78186971e-01f,
  -3.25809628e-01f, -3.16101313e-01f, -3.24240513e-02f, 2.59973593e-02f, 1.36348708e-02f, -7.91274104e-03f, -9.66710672e-02f, -1.13008134e-02f, 1.99166369e-02f, 1.11247063e-01f,
  -3.31091583e-02f, -3.99481058e-02f, 1.45729735e-01f, 1.36571489e-02f, 1.15128621e-01f, -1.36013404e-01f, 1.85793161e-03f, -2.58302420e-01f, -3.11120421e-01f, -1.90565765e-01f,
  9.37795341e-02f, -2.14668676e-01f, -3.61106068e-01f, -1.06769733e-01f, -2.63157159e-01f, -1.15682982e-01f, -3.03430527e-01f, -2.84687221e-01f, -2.72562385e-01f, 2.27532517e-02f,
  7.80841634e-02f, 1.34752374e-02f, -5.47427200e-02f, -5.08915447e-02f, 1.21631168e-01f, 3.72598991e-02f, 4.19080742e-02f, -1.70204472e-02f, 7.75343627e-02f, -1.09397508e-01f,
  1.98481925e-04f, 1.62605613e-01f, 3.32865193e-02f, 4.51861359e-02f, 7.77018517e-02f, 3.20160463e-02f, -1.20462745e-01f, 1.61302667e-02f, 2.24921703e-02f, 5.40056312e-03f,
  -5.08646369e-02f, -8.65648594e-03f, 8.52254331e-02f, -3.97342891e-02f, -6.62478879e-02f, -3.18324007e-02f, -1.19078299e-02f, -6.23429865e-02f, -1.72393844e-02f, 5.31039797e-02f,
  2.36284792e-01f, 7.92830586e-02f, 4.20597121e-02f, -5.86973950e-02f, -8.33665952e-03f, 1.77827608e-02f, 6.80946931e-02f, 4.02748957e-03f, 5.32051846e-02f, -3.77523117e-02f,
  -3.40225138e-02f, 1.32601568e-02f, 9.05284807e-02f, 2.06643175e-02f, 3.42433788e-02f, 9.35800821e-02f, -2.77241375e-02f, 3.54621969e-02f, -8.74513909e-02f, 1.13212787e-01f,
  1.85399786e-01f, 1.15866307e-02f, -2.06886947e-01f, -7.08279312e-02f, 1.56610250e-01f, 7.88980573e-02f, 1.29943471e-02f, -1.12779751e-01f, -1.25430137e-01f, 1.51823685e-01f,
  -9.40212309e-01f, 5.74314035e-02f, -2.57181168e-01f, -1.20578803e-01f, 2.16783583e-01f, 3.39337140e-01f, 4.84383404e-01f, 2.10837498e-01f, 2.45078597e-02f, 1.59620792e-01f,
  -1.59556583e-01f, -1.23541236e-01f, -8.66829529e-02f, 1.30204290e-01f, 3.38635743e-02f, 2.91226774e-01f, 4.83998597e-01f, -9.07144770e-02f, -2.42996365e-01f, -9.72625166e-02f,
  2.33239904e-01f, -2.09472805e-01f, -4.97271448e-01f, -2.24325269e-01f, -6.67844387e-03f, -3.59085053e-02f, -1.16260082e-01f, -1.14283316e-01f, -2.89333519e-02f, 1.13511615e-01f,
  -3.00197244e-01f, -1.71943918e-01f, 1.62766203e-01f, -1.07977569e-01f, -5.98555766e-02f, -9.35068205e-02f, -3.31284255e-02f, -1.68903917e-01f, -8.79847109e-02f, -1.12922629e-02f,
  1.86080281e-02f, -1.01052091e-01f, -4.95098755e-02f, -7.42547363e-02f, -6.06186464e-02f, -8.29942003e-02f, -8.99720713e-02f, -9.62394103e-02f, -1.08200148e-01f, 3.06219645e-02f,
  2.81214297e-01f, -1.23256937e-01f, -1.23895451e-01f, 1.27058938e-01f, 1.25442043e-01f, -3.33448723e-02f, -1.53722763e-01f, -1.08636782e-01f, -1.51545510e-01f, -9.14156586e-02f,
  1.05057269e-01f, -1.03892341e-01f, 4.97802766e-03f, 5.52419573e-02f, 7.46893929e-03f, 1.19500561e-03f, 2.89151929e-02f, 1.27192456e-02f, 1.34651035e-01f, -1.38593828e-02f,
  4.08112630e-02f, 3.58420387e-02f, 6.90437555e-02f, 7.05323182e-03f, 7.99943879e-03f, -6.64825179e-03f, -4.36018780e-02f, -9.11998749e-02f, -8.04477260e-02f, -4.96202260e-02f,
  -1.29391253e-02f, -1.10462308e-02f, -4.10676338e-02f, -4.08693142e-02f, 4.44133356e-02f, -6.20864183e-02f, 4.28750403e-02f, -3.13464403e-02f, -3.62617821e-02f, 2.06840318e-02f,
  -2.34800782e-02f, 1.01440214e-01f, 1.66656524e-02f, 3.29657085e-02f, -5.96936420e-02f, -2.03951467e-02f, -1.03580408e-01f, 1.60498191e-02f, -3.33899669e-02f, -4.25184891e-02f,
  -6.04609661e-02f, -6.18631504e-02f, -8.31886977e-02f, 1.02076251e-02f, -1.11903436e-01f, -9.00822133e-02f, 9.92169902e-02f, -3.71256396e-02f, 9.57373083e-02f, 9.92566347e-03f,
  1.30001992e-01f, 1.03592724e-01f, 2.50663627e-02f, 1.35808617e-01f, 2.82193482e-01f, 4.52463254e-02f, 6.59825280e-02f, -6.50947541e-02f, 1.23120308e-01f, 2.67448455e-01f,
  -8.68321434e-02f, -1.14262655e-01f, -3.63940567e-01f, 2.44587675e-01f, -2.12115943e-01f, -1.40818045e-01f, -2.78471053e-01f, 1.87543124e-01f, 3.21265966e-01f, -2.22076401e-01f,
  -5.75958453e-02f, 8.63228962e-02f, -1.30049139e-01f, -8.67627487e-02f, -2.03662500e-01f, -3.02366793e-01f, -4.02992457e-01f, -4.01677132e-01f, -1.81332499e-01f, 5.68311438e-02f,
  4.95553389e-02f, 1.45355299e-01f, 9.28905532e-02f, 8.28030109e-02f, 4.67400402e-02f, 1.03932783e-01f, -4.56841029e-02f, 7.22747222e-02f, -5.76013252e-02f, -4.29329216e-01f,
  -2.56901890e-01f, 1.02998838e-01f, -3.40882912e-02f, 5.15389778e-02f, -1.43138990e-02f, 9.21050087e-02f, -3.43374982e-02f, -2.03041881e-02f, 9.28230584e-03f, -1.56408012e-01f,
  -4.34419923e-02f, -7.28959963e-03f, -9.58084837e-02f, 1.87052727e-01f, -1.13714635e-02f, 4.88873497e-02f, 9.30422619e-02f, -3.18136066e-02f, -2.00073849e-02f, -1.39729679e-01f,
  1.66135598e-02f, -1.87405482e-01f, -3.15631896e-01f, -5.97019866e-02f, 4.90660556e-02f, -1.32548632e-02f, -1.19047370e-02f, 9.90894660e-02f, -5.34253307e-02f, 9.89330374e-03f,
  2.01826748e-02f, -6.29955679e-02f, -4.82983403e-02f, 7.86908939e-02f, 2.25636158e-02f, 3.63627123e-03f, -3.92117314e-02f, -5.25084324e-02f, -5.94936945e-02f, -2.48063612e-03f,
  -5.85080299e-04f, -3.98534350e-02f, 8.34377296e-03f, -1.14324994e-01f, 2.16875747e-02f, 7.39989243e-03f, -5.09581007e-02f, -9.58806500e-02f, -1.28114149e-02f, -2.79905321e-03f,
  2.00072154e-02f, 8.57814103e-02f, 1.86584089e-02f, 1.40098900e-01f, -6.59130961e-02f, -8.33804384e-02f, -4.62692603e-02f, -1.15713768e-01f, 9.73243192e-02f, -7.59782568e-02f,
  2.42494687e-01f, -2.29349688e-01f, -2.45718900e-02f, 9.52040553e-02f, 5.33303432e-02f, 8.94882903e-02f, -3.05654146e-02f, 3.12340297e-02f, -1.53551614e-02f, 9.57886279e-02f,
  4.77941881e-04f, -4.76187877e-02f, -1.77038796e-02f, -1.57180324e-01f, -1.02933049e-01f, 2.13262346e-02f, 6.05778135e-02f, -5.12814522e-02f, 7.16765374e-02f, 1.28919799e-02f,
  -1.94100547e-03f, -1.07007638e-01f, -3.02039739e-03f, 7.19447285e-02f, 1.05652153e-01f, -1.47108376e-01f, -9.69878137e-02f, 9.37499944e-03f, -7.89255798e-02f, -9.16092619e-02f,
  9.50581208e-02f, 1.51237071e-01f, -2.09347680e-01f, -1.17651381e-01f, -1.43291727e-01f, -2.87103504e-01f, -9.74496230e-02f, -2.59858966e-02f, -2.31713243e-02f, 5.95963597e-02f,
  -2.14895114e-01f, -7.35895783e-02f, 3.37831751e-02f, -1.17577501e-01f, -7.70391850e-03f, 1.59293160e-01f, 2.35901713e-01f, 1.94665957e-02f, -1.63809478e-01f, -6.91362321e-02f,
  6.40579239e-02f, 7.35465437e-02f, -6.90090135e-02f, -1.54068144e-02f, 3.04746389e-01f, -8.45652595e-02f, 7.27007464e-02f, -1.08606383e-01f, -4.57494892e-02f, 4.00555044e-01f,
  -2.14605078e-01f, -2.83813566e-01f, -3.25935632e-01f, -2.84624368e-01f, 5.55613190e-02f, 1.54081598e-01f, 1.17482856e-01f, 1.95078254e-01f, -5.75209670e-02f, 2.27513816e-02f,
  2.47979760e-02f, 8.67059231e-02f, -1.41496416e-02f, -1.31466061e-01f, -1.23432457e-01f, 1.81249008e-02f, 2.08439276e-01f, 4.13152650e-02f, -4.13443744e-02f, 1.53335591e-03f,
  -2.93799005e-02f, -2.49302864e-01f, -2.22701967e-01f, -1.17802881e-01f, -5.66261113e-02f, -1.64633110e-01f, -2.77360588e-01f, 3.46905105e-02f, -2.74614215e-01f, 1.12113878e-01f,
  -7.16330633e-02f, -4.37212661e-02f, -1.00071067e-02f, -1.49967810e-02f, 1.75144315e-01f, -2.15270300e-03f, 4.88970540e-02f, 3.11834607e-02f, -1.18388899e-01f, 1.25540614e-01f,
  5.21701109e-03f, -1.36012966e-02f, -2.06326786e-03f, -3.54057886e-02f, -1.50238767e-01f, -1.96819771e-02f, 1.32579386e-01f, 6.11207709e-02f, -8.65465477e-02f, -1.23032749e-01f,
  -6.49236739e-02f, -1.33489883e-02f, -1.27294762e-02f, 1.71474859e-01f, -6.76472783e-02f, 2.78388616e-02f, -4.20841128e-02f, -9.12689492e-02f, -5.90615124e-02f, -3.89425270e-02f,
  -1.07467480e-01f, -2.85181701e-01f, 3.09064873e-02f, 9.74226147e-02f, -1.72232404e-01f, -1.35880098e-01f, -4.05196957e-02f, -1.20353010e-02f, -9.59909856e-02f, -8.33266322e-03f,
  -6.72500730e-02f, 2.09027171e-01f, 6.05424354e-03f, 6.98218495e-02f, 5.59676625e-02f, -1.25805857e-02f, 9.33363587e-02f, -6.21351711e-02f, 6.69248179e-02f, 7.94819370e-02f,
  3.56633626e-02f, -1.76677391e-01f, -1.72835186e-01f, 1.02482229e-01f, -6.17243163e-02f, -2.20707119e-01f, -1.29632235e-01f, -8.54228809e-02f, -2.96807528e-01f, 4.78251763e-02f,
  -1.07687163e+00f, 7.97770768e-02f, -8.94097798e-03f, -3.99772614e-01f, -1.73854351e-01f, -2.47257575e-02f, 4.37504016e-02f, -3.20967548e-02f, -3.31163108e-01f, -9.57836509e-02f,
  5.17008603e-02f, 1.47317335e-01f, -2.24110764e-02f, 3.46710235e-02f, -3.72707918e-02f, -3.31740290e-01f, -4.17302638e-01f, -4.72464561e-01f, 1.21147320e-01f, 2.58373201e-01f,
  4.86650169e-02f, -1.94396421e-01f, -3.53358507e-01f, 1.93818826e-02f, 6.55696392e-02f, 1.32603258e-01f, -2.10526839e-01f, -7.99414143e-02f, 2.09546313e-01f, -1.11569561e-01f,
  2.50035346e-01f, -1.32124752e-01f, -6.70306310e-02f, -4.43422943e-02f, -5.67439422e-02f, -4.76595946e-03f, -9.94076133e-02f, -5.04861474e-02f, -3.60939316e-02f, 4.64762971e-02f,
  -1.33645207e-01f, 4.35571857e-02f, 1.17470091e-02f, 1.68177649e-01f, 5.02904058e-02f, -6.07872941e-02f, -8.19168463e-02f, 3.62852635e-03f, -1.49995551e-01f, 1.82294145e-01f,
  1.51794553e-01f, -4.93972823e-02f, 2.86882813e-03f, 1.30662695e-01f, -1.33763673e-02f, -7.36909658e-02f, 2.71931142e-01f, 3.97066325e-02f, 1.15024686e-01f, 1.55437529e-01f,
  1.02489255e-02f, 4.04956676e-02f, 3.07981502e-02f, 1.17773376e-02f, 1.83525365e-02f, -7.59076700e-02f, 1.66167191e-03f, 1.03980668e-01f, 1.03622908e-02f, 5.13362698e-03f,
  1.48637425e-02f, -1.07287303e-01f, -2.25186124e-02f, -5.66496104e-02f, 4.09237146e-02f, 2.58216690e-02f, -1.51323602e-01f, 1.56579599e-01f, 9.16515514e-02f, -7.44972602e-02f,
  -4.30657528e-03f, -2.66631396e-04f, -8.16588178e-02f, 4.09077629e-02f, -1.18410243e-02f, -4.34728786e-02f, 3.85605963e-03f, 4.10664380e-02f, -5.17141260e-02f, 1.82550456e-02f,
  3.08865607e-02f, -2.66076475e-01f, -1.70854896e-01f, 1.36478186e-01f, -1.03467159e-01f, -6.86120018e-02f, 1.21219987e-02f, -1.26572978e-02f, -1.57997832e-01f, 5.71020180e-03f,
  3.63295339e-02f, -5.89294657e-02f, -5.91202192e-02f, 1.23479359e-01f, -3.47973704e-02f, 1.25668302e-01f, 2.35158075e-02f, -2.43115164e-02f, 8.54265615e-02f, 1.63275227e-01f,
  2.56243311e-02f, 1.92341115e-03f, -9.04721841e-02f, 3.37111205e-02f, 4.22745831e-02f, -1.51154771e-01f, 1.15276068e-01f, 1.44744501e-01f, -8.42364579e-02f, 7.73802847e-02f,
  -8.82282972e-01f, 1.13448270e-01f, 9.29876193e-02f, -2.94862270e-01f, -5.37231602e-02f, -5.37974946e-02f, -5.11021838e-02f, 1.07764818e-01f, -4.46100719e-02f, -1.95466727e-02f,
  1.29958659e-01f, 2.82964706e-02f, 2.77804714e-02f, 5.55618443e-02f, -9.22484919e-02f, -9.78739932e-03f, -1.75228849e-01f, -2.70253658e-01f, -1.96289569e-01f, -4.29887697e-02f,
  -1.32934719e-01f, -4.75646406e-01f, -4.10864800e-01f, -1.73798293e-01f, 8.24185833e-02f, 5.77602871e-02f, 4.06563953e-02f, -4.67972830e-02f, 2.60368008e-02f, -8.03795010e-02f,
  2.83735275e-01f, 1.09528229e-01f, 1.66337579e-01f, 2.29736026e-02f, 1.33032218e-01f, 7.10383654e-02f, 7.58486707e-03f, 1.32592410e-01f, 1.82969704e-01f, 2.42515728e-01f,
  7.07537755e-02f, -4.89254929e-02f, -8.03890973e-02f, 1.06916726e-01f, -3.92575823e-02f, -5.92932552e-02f, -3.97836156e-02f, 1.08744211e-01f, -6.30080774e-02f, 1.95261508e-01f,
  4.52845879e-02f, 4.08078097e-02f, -3.37853655e-02f, 8.86706933e-02f, 9.48349610e-02f, 1.50710978e-02f, 1.69759467e-01f, 5.47429509e-02f, 1.38146669e-01f, 1.02645159e-01f,
  -1.14758611e-01f, 1.50765982e-02f, -9.65527538e-03f, 5.57027347e-02f, -1.37822747e-01f, 1.68611348e-01f, 4.49665962e-03f, -2.35675424e-01f, -1.87263995e-01f, -1.39842749e-01f,
  -2.29676422e-02f, -1.21038314e-02f, 1.27056643e-01f, 5.69153838e-02f, 8.78913999e-02f, 2.81633791e-02f, -6.65562078e-02f, 6.09431369e-03f, 8.52851495e-02f, -6.46967813e-02f,
  6.26650592e-03f, 1.04677431e-01f, -3.27381156e-02f, -2.89358851e-03f, 5.47856838e-02f, -2.17305236e-02f, 9.63713303e-02f, -1.21120838e-02f, -9.99005511e-02f, -3.29990946e-02f,
  1.35489985e-01f, -9.75618064e-02f, -1.45889784e-03f, 1.13293566e-01f, 6.01720698e-02f, -4.25052922e-03f, 6.37897328e-02f, 1.39961869e-01f, 9.17433500e-02f, 1.15490891e-01f,
  8.40524286e-02f, -7.34851323e-03f, -9.11346897e-02f, -1.44129414e-02f, -9.95597988e-03f, -5.01579084e-02f, 1.23603746e-01f, 6.33692071e-02f, 5.41997328e-02f, 4.88621220e-02f,
  -4.01652902e-02f, -1.88494474e-02f, -2.24742219e-01f, 1.66315496e-01f, 8.42231736e-02f, -2.87153348e-02f, 1.24385029e-01f, 5.49747981e-02f, -4.85703759e-02f, -1.11471593e-01f,
  -1.79615334e-01f, -5.17104194e-02f, 1.47721872e-01f, 3.80311012e-02f, -1.10934697e-01f, -4.04053003e-01f, -4.14624304e-01f, -1.61223352e-01f, -1.03013292e-01f, -7.64436871e-02f,
  -2.46566817e-01f, -5.71123883e-02f, 1.54046476e-01f, 4.11276855e-02f, -7.29310364e-02f, 4.67644967e-02f, 2.33292729e-01f, 8.50696340e-02f, -3.28382224e-01f, -3.94448251e-01f,
  2.64073466e-03f, 1.09324969e-01f, -7.83404633e-02f, -1.53483795e-02f, 2.28817075e-01f, 1.51267380e-01f, 1.60186246e-01f, 1.77802578e-01f, -3.07923798e-02f, 6.60148084e-01f,
  3.90433855e-02f, -8.43542221e-04f, 1.16756752e-01f, 5.53651201e-03f, 8.54540169e-02f, 6.11932576e-02f, -1.88281760e-01f, 1.72684759e-01f, 5.80307841e-02f, 7.00820386e-02f,
  -3.18957791e-02f, -9.74715278e-02f, 7.40987360e-02f, -4.73336130e-02f, -1.35694206e-01f, -2.80476183e-01f, 9.04972106e-02f, -4.50132899e-02f, -1.41634587e-02f, -4.33476046e-02f,
  7.78651834e-02f, -1.72922507e-01f, -5.38909696e-02f, -7.82516843e-04f, 2.83687729e-02f, 2.89967190e-02f, -1.10708177e-01f, -1.06465574e-02f, 2.02711746e-02f, 1.18644491e-01f,
  1.01901956e-01f, -1.63001299e-03f, 2.23326404e-02f, 7.52786323e-02f, -7.08878115e-02f, 4.92006354e-02f, 4.69302945e-02f, -3.95524763e-02f, 1.20030351e-01f, -5.06581331e-04f,
  1.84176769e-03f, -1.00583784e-01f, -9.98226553e-02f, -6.08091950e-02f, -9.73425433e-03f, -6.35344982e-02f, -3.70269008e-02f, -1.22424820e-02f, 1.99435633e-02f, -5.78127913e-02f,
  -3.11853625e-02f, -7.55169466e-02f, 1.12443291e-01f, -3.64378914e-02f, 6.01008050e-02f, 8.82810354e-03f, 4.64970805e-02f, 3.07710040e-02f, 2.88839191e-01f, 2.98412256e-02f,
  2.68215593e-02f, -1.35470554e-01f, 1.02168746e-01f, -1.49216531e-02f, 6.48946166e-02f, 1.53136581e-01f, 5.97965270e-02f, -8.03929120e-02f, -1.05149418e-01f, -2.47927099e-01f,
  -1.80552781e-01f, -3.88950817e-02f, -4.37467359e-03f, 3.04450048e-03f, -7.98966810e-02f, -6.53819740e-02f, -9.22354385e-02f, -7.82720074e-02f, -9.31559205e-02f, -7.63936192e-02f,
  -4.03444096e-02f, -2.34319031e-01f, -2.50663966e-01f, -1.01629123e-01f, -4.07897048e-02f, -1.65860429e-01f, 4.33084518e-02f, -8.59722644e-02f, -1.95312455e-01f, 3.97207914e-03f,
  -7.61900842e-01f, -2.15126812e-01f, 1.82598978e-02f, -3.66572678e-01f, 1.57713413e-01f, 1.48430124e-01f, -4.03238349e-02f, 7.44160712e-02f, -4.66346256e-02f, -2.30672911e-01f,
  1.17005371e-01f, 9.55279917e-02f, -2.36420229e-01f, 4.97054532e-02f, -1.71294361e-01f, -2.15088919e-01f, -1.31268382e-01f, -6.70873299e-02f, 2.21581504e-01f, 4.74840283e-01f,
  3.34265381e-01f, -1.63640350e-01f, -1.49538383e-01f, 2.55562179e-02f, -1.35008782e-01f, -9.20095593e-02f, -2.29203135e-01f, -1.95249408e-01f, 1.11150511e-01f, -3.44549477e-01f,
  -3.33101243e-01f, -1.67654246e-01f, 3.02614152e-01f, 1.17706537e-01f, 2.56861784e-02f, 5.51160090e-02f, 5.65200895e-02f, 1.29698887e-01f, 1.23677395e-01f, -5.88380732e-02f,
  4.02628165e-03f, 2.17022747e-01f, 3.19897272e-02f, 5.21425828e-02f, 2.37348676e-02f, 2.00147647e-02f, 1.19876802e-01f, -2.82286783e-03f, -4.72713336e-02f, 3.70378532e-02f,
  6.98360875e-02f, 1.94404840e-01f, -1.51503727e-01f, 2.00098053e-01f, -5.36187924e-02f, 1.04819305e-01f, 4.44670543e-02f, 3.72655019e-02f, 1.65305641e-02f, -4.03681785e-01f,
  6.25427812e-02f, -7.62906894e-02f, -3.85498926e-02f, 2.86797639e-02f, -9.47509985e-03f, -4.07798821e-03f, 3.92764201e-03f, -6.41740635e-02f, 1.36155356e-02f, -8.12105238e-02f,
  6.58534393e-02f, 7.06297010e-02f, 1.14349453e-02f, -4.49221581e-02f, -2.47658323e-02f, -3.35294046e-02f, -1.87475923e-02f, -5.78531846e-02f, -2.82832496e-02f, -8.00419897e-02f,
  1.06621943e-02f, -4.00979072e-02f, 5.71763469e-03f, 2.58897096e-02f, 7.24991262e-02f, -1.21850871e-01f, 4.29619625e-02f, 5.82971834e-02f, -5.00078574e-02f, 1.77569494e-01f,
  -4.21826690e-01f, 2.23856002e-01f, -3.39671850e-01f, 1.87177723e-03f, -1.51989058e-01f, 2.19587367e-02f, -1.22166835e-01f, 2.17161514e-02f, -1.17679834e-01f, -5.37814945e-03f,
  -5.47203496e-02f, -1.09347381e-01f, -1.67495310e-01f, -9.40082595e-02f, 3.00219413e-02f, -1.28633246e-01f, -1.65851116e-01f, -6.22532405e-02f, 2.67937630e-02f, -1.94452628e-02f,
  -1.07522920e-01f, -2.55413949e-01f, -2.75718153e-01f, -1.46637127e-01f, -1.92364737e-01f, -1.70843974e-01f, -3.01008880e-01f, -1.25159100e-01f, -2.73270458e-01f, -5.52595794e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.87575394e-01f, 1.54734910e-01f, 2.03041866e-01f, 3.24013978e-01f, 4.68561500e-02f, -8.83083344e-02f, 4.11563396e-01f, 1.70648396e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.21725135e-01f, 1.40817389e-01f, -1.25082061e-01f, -8.47751647e-02f, 2.90816948e-02f, 1.42986864e-01f, 7.13155717e-02f, 9.65741053e-02f, -1.80330232e-01f, 5.23331352e-02f,
  4.45271321e-02f, -1.87189043e-01f, 8.56435150e-02f, -5.74277714e-03f, -5.84386010e-03f, -2.75550485e-01f, 2.16054425e-01f, 5.34196556e-01f, -2.18115836e-01f, 9.37258750e-02f,
  1.73379824e-01f, 6.19888343e-02f, 1.06072754e-01f, 8.73243064e-02f, 3.36093843e-01f, 5.55713117e-01f, 1.78510442e-01f, 2.87314832e-01f, -1.92034155e-01f, -2.33711362e-01f,
  -1.26283571e-01f, -5.75888455e-01f, 1.54688969e-01f, 4.29433845e-02f, -1.53508991e-01f, 3.86197865e-02f, 3.62850487e-01f, 1.26397461e-02f, 2.35356301e-01f, -5.99745139e-02f,
  -4.03286628e-02f, 2.24835768e-01f, 7.40042850e-02f, 4.67558652e-02f, -2.94551328e-02f, 2.03674600e-01f, 7.21812174e-02f, -3.79940011e-02f, 6.48618698e-01f, 2.01431945e-01f,
  4.37906012e-02f, 2.09024280e-01f, 2.09885612e-01f, -1.26356333e-01f, -7.33164176e-02f, 4.76176649e-01f, 1.14006490e-01f, -2.85686012e-02f, 3.62694226e-02f, 2.49132857e-01f,
  -3.61890942e-01f, -3.98032457e-01f, 3.56811732e-01f, 8.74826163e-02f, -5.30062988e-02f, -1.44625321e-01f, 3.11685782e-02f, 3.72007266e-02f, -2.36132964e-01f, -3.98619510e-02f,
  4.89366334e-03f, -6.73232414e-03f, -5.42142950e-02f, -2.03008890e-01f, -3.11875902e-02f, 1.77353218e-01f, -1.12572923e-01f, -2.43736550e-01f, 3.71785909e-02f, 1.84086487e-01f,
  -1.50738373e-01f, 3.99362016e-03f, -7.87522346e-02f, -1.63460761e-01f, 1.69460386e-01f, 7.35502616e-02f, 2.26530910e-01f, -7.55410129e-03f, -2.47476667e-01f, 5.71200103e-02f,
  9.18419659e-02f, -3.19598973e-01f, 1.41435146e-01f, 2.62021035e-01f, -2.13551939e-01f, 2.76926488e-01f, -2.56892055e-01f, -2.15950429e-01f, -1.05279326e-01f, -1.11451663e-01f,
  1.12529658e-01f, -5.43970391e-02f, -4.72928211e-02f, 4.39240709e-02f, -2.17881069e-01f, 5.90750985e-02f, -7.88601339e-02f, 5.00897095e-02f, -3.46232653e-01f, -5.43347716e-01f,
  2.94297308e-01f, 4.58504856e-01f, 2.73191839e-01f, 1.09081976e-01f, -1.93485562e-02f, -1.69465557e-01f, -2.37834640e-02f, -2.97781557e-01f, 8.63849819e-02f, 2.63296515e-01f,
  -5.16408011e-02f, 1.46641478e-01f, -2.05688775e-01f, -1.40792243e-02f, 2.15741768e-02f, 1.36973441e-01f, 1.14664279e-01f, 8.75752643e-02f, -2.73666114e-01f, -1.22236691e-01f,
  8.24484751e-02f, 9.78182033e-02f, 7.76921958e-02f, -2.46039201e-02f, 4.19869013e-02f, 2.09619496e-02f, 7.67486468e-02f, 6.67769760e-02f, -1.92625776e-01f, -5.65237515e-02f,
  3.24947774e-01f, 3.83273512e-01f, -3.21506299e-02f, -1.08555846e-01f, -2.36715063e-01f, -8.45628083e-02f, -3.47962603e-02f, 3.67555395e-02f, -2.15772521e-02f, -8.57783575e-03f,
  -3.58337648e-02f, -7.19164833e-02f, -1.96265817e-01f, -2.82648891e-01f, 7.92733133e-02f, -2.01124549e-01f, 9.75347608e-02f, -2.15518802e-01f, -1.21952966e-01f, 2.32517824e-01f,
  -2.30275214e-01f, 1.26798421e-01f, 2.64692724e-01f, 2.78651685e-01f, -1.31727740e-01f, 1.50730506e-01f, -1.35664701e-01f, 1.53299540e-01f, -5.87990023e-02f, -2.27412090e-01f,
  -8.22115596e-03f, 3.18140715e-01f, -3.14290851e-01f, -6.98748976e-02f, 4.07078378e-02f, 3.58819157e-01f, 3.20931338e-02f, -1.24696128e-01f, -1.46798864e-02f, -3.70013155e-02f,
  -3.62782061e-01f, 1.66409135e-01f, -6.58495277e-02f, -2.91852374e-02f, 4.22232211e-01f, 2.22834125e-01f, 1.55610904e-01f, -2.37811700e-01f, 2.41866052e-01f, 3.14583778e-01f,
  1.64566681e-01f, 3.27532083e-01f, -1.50244012e-01f, 8.20090547e-02f, 1.74783662e-01f, -8.68276209e-02f, -1.71757340e-02f, -9.14914086e-02f, -1.08068846e-01f, 1.20053487e-02f,
  -2.86591649e-02f, -1.11953504e-01f, -1.96102764e-02f, 1.05412096e-01f, -1.50926411e-01f, 3.59053701e-01f, -1.00883566e-01f, -1.60326973e-01f, -4.41077977e-01f, -4.85725142e-02f,
  8.13966915e-02f, 1.30231574e-01f, 1.98095456e-01f, -1.05894037e-01f, -5.93462512e-02f, -4.64660525e-01f, 2.67071813e-01f, -2.70287007e-01f, 2.49348789e-01f, -1.18838802e-01f,
  -1.56615004e-01f, 3.13453555e-01f, -2.01544706e-02f, -2.70774305e-01f, 2.80841440e-01f, 1.44368291e-01f, -1.06513090e-01f, 2.43349984e-01f, 4.80132364e-02f, 1.07279859e-01f,
  2.26739809e-01f, 2.52971262e-01f, 2.36304272e-02f, 2.02102020e-01f, -2.19437908e-02f, 3.07670146e-01f, -3.56396496e-01f, -2.19674587e-01f, 1.48697034e-01f, 1.37896955e-01f,
  1.28514722e-01f, 3.21494758e-01f, -4.75937091e-02f, 7.21154213e-02f, -3.50421280e-01f, -1.81977063e-01f, 2.84456536e-02f, 3.60812843e-01f, 7.43841678e-02f, 2.46246740e-01f,
  -2.84633845e-01f, 1.11206278e-01f, -1.20828021e-02f, 1.11671407e-02f, 1.89390346e-01f, -1.18058883e-01f, -6.39355630e-02f, 1.04354687e-01f, 2.33714413e-02f, -8.07977319e-02f,
  -1.07619278e-01f, 1.64019726e-02f, 1.00969881e-01f, -2.46541407e-02f, 8.39695036e-02f, 3.76685522e-04f, -1.69159714e-02f, -2.99848139e-01f, -3.24279368e-02f, 2.43053526e-01f,
  -4.23315078e-01f, -3.74308139e-01f, 2.32179593e-02f, 4.08704221e-01f, -1.68022111e-01f, -1.67918205e-02f, 2.03928962e-01f, 1.35758519e-02f, -1.54137090e-01f, -9.52649787e-02f,
  3.07507932e-01f, 6.33474708e-01f, -1.52692571e-01f, 1.30972760e-02f, 3.14152211e-01f, -1.16136819e-01f, -1.43184900e-01f, -1.83005452e-01f, -8.16828981e-02f, -1.40743375e-01f,
  7.92396069e-02f, -1.34524196e-01f, -8.17954987e-02f, 7.63744041e-02f, -7.59057999e-02f, -1.51812926e-01f, 4.35328819e-02f, -4.45771813e-02f, 8.57158974e-02f, -1.02494463e-01f,
  -3.03756237e-01f, -3.84949088e-01f, -8.52040797e-02f, 2.38843188e-01f, 3.42621095e-02f, 1.69102296e-01f, -6.06489331e-02f, -2.28022859e-01f, 1.21023960e-01f, 3.53673548e-02f,
  1.44351035e-01f, -2.17074081e-01f, 3.24518174e-01f, 5.34065068e-01f, -3.32235284e-02f, -6.00166395e-02f, 2.78359577e-02f, 6.20523244e-02f, -1.61093950e-01f, 3.91302586e-01f,
  9.10593048e-02f, 7.56713450e-02f, 9.30206999e-02f, 2.27521136e-01f, -3.41426916e-02f, 3.31466086e-02f, -1.37065187e-01f, 3.29556875e-02f, -8.04019719e-03f, -1.17444038e-01f,
  1.92046672e-01f, 2.09916368e-01f, 3.74837399e-01f, 5.84429085e-01f, -2.83565968e-02f, -3.14920485e-01f, -3.64971161e-01f, -3.92233849e-01f, 2.32408941e-01f, -8.48012269e-02f,
  1.56457767e-01f, 1.35061711e-01f, -8.10045227e-02f, 1.70713842e-01f, -3.29094410e-01f, 1.66778877e-01f, -1.18058108e-01f, 8.93169257e-04f, 2.26960465e-01f, -8.73505920e-02f,
  -3.08269262e-01f, 3.04679960e-01f, 6.67448789e-02f, -9.39636678e-03f, -5.85838594e-03f, -7.86474273e-02f, -2.45164335e-01f, -2.00428143e-01f, 8.58294070e-02f, -3.75215593e-03f,
  4.08188961e-02f, -1.07179925e-01f, 2.40402035e-02f, 1.60778835e-01f, -3.44790846e-01f, 1.83735251e-01f, 1.09606497e-01f, 3.13764006e-01f, -1.14533817e-02f, -4.10907030e-01f,
  7.74903074e-02f, 7.53312791e-03f, -5.68650179e-02f, 2.42089495e-01f, -9.26507860e-02f, 1.42662704e-01f, -2.08971515e-01f, 7.22897947e-01f, -5.01455307e-01f, 1.07703567e-01f,
  -4.00874875e-02f, -5.20370081e-02f, -4.42202650e-02f, 1.46859124e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.99548006e-01f, 1.98238239e-01f, 2.94766426e-01f, 5.88485301e-02f, 1.48026124e-01f, 1.25196368e-01f, 1.25415519e-01f, 2.26226062e-01f, -1.70673564e-01f, 9.44198593e-02f,
  8.33707452e-02f, 3.02271217e-01f, -4.32450205e-01f, -5.90856254e-01f, 1.52868256e-01f, 5.33966064e-01f, 3.38073373e-01f, -3.41236889e-02f, 1.15919150e-01f, -1.67968437e-01f,
  1.66511144e-02f, -1.53075844e-01f, 2.28889644e-01f, 8.11990649e-02f, 3.03072512e-01f, 3.58199358e-01f, -3.06205247e-02f, 4.91967499e-01f, -4.99620698e-02f, 4.06408533e-02f,
  3.92696768e-01f, -6.81210011e-02f, -9.27434117e-02f, 2.00345531e-01f, 1.06389731e-01f, -5.59246400e-03f, 1.08024679e-01f, 1.44655004e-01f, 1.76022947e-01f, -1.60948291e-01f,
  1.39405906e-01f, 1.92856789e-01f, 3.21711063e-01f, -2.40547925e-01f, 2.22930342e-01f, 1.33771345e-01f, -2.41824895e-01f, -2.77240463e-02f, -1.68482497e-01f, 4.89073515e-01f,
  -1.41776279e-01f, 8.47215876e-02f, 1.58209577e-01f, -2.09166599e-03f, 1.78601578e-01f, -2.92248875e-01f, 1.80317998e-01f, -8.36336091e-02f, 2.11317882e-01f, 1.23988010e-01f,
  2.74900317e-01f, -3.62540036e-02f, -5.37974954e-01f, 3.76951575e-01f, 1.09690420e-01f, -1.27678504e-03f, -3.08421291e-02f, 1.41107067e-01f, 2.35863402e-01f, -6.86130002e-02f,
  -4.14372012e-02f, 1.13536119e-01f, -1.56074781e-02f, 3.00759226e-02f, -2.04646826e-01f, -2.22824082e-01f, -6.29685581e-01f, -1.59782693e-02f, 1.71753485e-02f, 5.81282899e-02f,
  -1.13387994e-01f, -1.46034092e-01f, -8.95843506e-02f, -6.02002032e-02f, -8.18477795e-02f, -1.95724949e-01f, -1.82015374e-02f, -1.28760025e-01f, 5.48697710e-02f, 4.63672787e-01f,
  4.80824709e-02f, -1.42973199e-01f, 4.99307454e-01f, 1.31911248e-01f, 1.09543711e-01f, 4.87446040e-01f, -8.30393136e-02f, 8.27874914e-02f, 1.22244366e-01f, 1.05871499e-01f,
  1.20964341e-01f, 8.21621791e-02f, -3.48933488e-02f, 1.72107760e-02f, -1.19553236e-02f, 7.71627873e-02f, 2.16062680e-01f, 2.91711956e-01f, -2.30109066e-01f, 3.32298100e-01f,
  1.49269104e-01f, -8.38789865e-02f, -1.31228417e-01f, -3.10735226e-01f, 1.03963427e-01f, -2.91310698e-02f, -2.79451400e-01f, 1.99419051e-01f, 4.90365177e-03f, 1.10974222e-01f,
  2.54238188e-01f, -4.48941439e-01f, 4.41058367e-01f, 1.60311207e-01f, 5.08246005e-01f, 4.50786836e-02f, 1.32352382e-01f, 5.35143256e-01f, 1.82448179e-01f, -3.26733738e-02f,
  3.19124162e-02f, 4.05709818e-02f, -6.95448443e-02f, 5.19572105e-03f, 2.73306668e-01f, 2.12346777e-01f, 1.68669179e-01f, 1.91858903e-01f, -1.17527664e-01f, -2.58024931e-01f,
  3.11433643e-01f, 4.04700972e-02f, 6.70263246e-02f, -5.27606830e-02f, 2.53247231e-01f, 2.52554446e-01f, -1.11552015e-01f, 9.25476775e-02f, 4.13207300e-02f, 3.40045132e-02f,
  1.26015827e-01f, 2.93198138e-01f, -2.65799254e-01f, 8.52536708e-02f, 1.07834339e-01f, -3.75032365e-01f, -3.71860176e-01f, 3.64715368e-01f, -6.91066265e-01f, 1.70453578e-01f,
  2.18623392e-02f, 3.66750687e-01f, 1.64352320e-02f, 1.80912271e-01f, 3.33331078e-01f, -1.74122583e-02f, 1.33048102e-01f, 2.35190928e-01f, 7.50143677e-02f, -8.07652622e-02f,
  1.57077774e-01f, 4.10392582e-01f, 3.75670344e-01f, -1.21370092e-01f, -1.18696280e-01f, 3.35936397e-02f, -6.33764446e-01f, -3.46785598e-02f, -2.75747240e-01f, -5.84831424e-02f,
  4.11711335e-02f, 2.34722972e-01f, 6.88772500e-02f, -2.61037529e-01f, 2.29920775e-01f, 1.07588120e-01f, 4.44839038e-02f, -2.42001429e-01f, 6.29298508e-01f, 1.47067919e-01f,
  -1.92388743e-01f, -2.84486264e-01f, 1.03492454e-01f, 1.74115226e-01f, 2.29419380e-01f, 1.52481906e-02f, 1.66345939e-01f, 1.29086047e-01f, 1.60949323e-02f, -3.21884453e-02f,
  7.39526004e-02f, 1.21548869e-01f, 2.50421673e-01f, 2.78391570e-01f, -5.54197669e-01f, -1.16508603e-01f, 2.04838961e-02f, 2.72865772e-01f, 5.06894998e-02f, -2.15300068e-01f,
  8.29785988e-02f, 3.28669921e-02f, 1.18589342e-01f, -5.95511459e-02f, 8.93478468e-03f, 7.65224099e-02f, 2.98540350e-02f, 5.97648740e-01f, -3.43062967e-01f, 1.18123762e-01f,
  6.03080057e-02f, 3.41744628e-03f, 5.01557231e-01f, 1.26559407e-01f, 2.05034330e-01f, -8.83073434e-02f, 7.39285946e-02f, 1.90920696e-01f, 1.93883017e-01f, -9.88541767e-02f,
  2.07874328e-01f, 3.48511264e-02f, 1.13570015e-03f, 6.02802411e-02f, -1.57036796e-01f, -8.56189057e-02f, -4.48320329e-01f, 1.12784669e-01f, 1.98243052e-01f, 1.69442341e-01f,
  -9.35631245e-02f, -1.85528714e-02f, 1.19175971e-01f, 1.64242178e-01f, -2.13928491e-01f, -1.07023887e-01f, -7.46552572e-02f, -2.31165662e-01f, 1.88579768e-01f, 6.50899336e-02f,
  1.59312874e-01f, 7.99928326e-03f, 4.06065350e-03f, 8.54437798e-02f, 3.07244696e-02f, 5.91314554e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -5.86102493e-02f, 2.10907996e-01f, -1.26022711e-01f, -2.40942631e-02f, 1.84403703e-01f, 1.04859814e-01f, 3.04010510e-03f, -1.99153423e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.21650615e-01f, -1.97086126e-01f, -1.18902571e-01f, 5.78501672e-02f, 2.74313182e-01f, -1.10968752e-02f, 1.14863724e-01f, 2.93199748e-01f, -2.24521413e-01f, 2.20453188e-01f,
  1.46341041e-01f, 8.29105675e-02f, 5.84501565e-01f, -1.09352231e-01f, -2.59307504e-01f, -1.64089501e-02f, -5.23287237e-01f, -3.98389399e-01f, 1.22001439e-01f, 2.86096096e-01f,
  1.28502414e-01f, -3.40307742e-01f, -1.23457946e-01f, -3.60017329e-01f, 1.60727784e-01f, -6.95162788e-02f, -2.04424679e-01f, -1.25095367e-01f, 8.94703344e-03f, 1.64789528e-01f,
  -2.66247857e-02f, -3.28021258e-01f, -8.38493258e-02f, -5.04496038e-01f, -6.94883838e-02f, 2.08123952e-01f, -3.01339984e-01f, 3.11531246e-01f, 1.03625491e-01f, -2.88026154e-01f,
  1.25199437e-01f, -3.89612079e-01f, 6.48287609e-02f, -2.41817906e-01f, -1.85018912e-01f, 2.02880099e-01f, -1.30869642e-01f, 1.52309656e-01f, 3.09226394e-01f, -2.88198054e-01f,
  -1.58047915e-01f, -2.74922270e-02f, 2.15936616e-01f, -3.50389272e-01f, 1.84918046e-01f, 3.26901227e-01f, 1.28229484e-01f, -1.01424649e-01f, -1.69055104e-01f, 3.24957492e-03f,
  6.95197880e-02f, -2.39485040e-01f, 2.18675449e-01f, 7.47149810e-02f, -1.03792906e-01f, -1.42812505e-01f, -2.17493266e-01f, 7.83357695e-02f, -8.28313977e-02f, -3.92832726e-01f,
  7.68947303e-02f, -1.74191475e-01f, 7.14017004e-02f, -2.45393753e-01f, -1.45841122e-01f, 4.54216413e-02f, -2.48610124e-01f, 1.71806857e-01f, 2.27281064e-01f, 8.71677771e-02f,
  -2.14542255e-01f, 6.03351951e-01f, 1.49169073e-01f, 3.07294577e-01f, 2.48890847e-01f, -1.29221216e-01f, 2.85355121e-01f, 4.70558196e-01f, -5.54927625e-02f, 1.42568305e-01f,
  2.84785777e-01f, 1.46030545e-01f, -5.26230633e-01f, 5.79121849e-03f, 2.25509077e-01f, 2.09878564e-01f, -3.00382048e-01f, -2.11712375e-01f, 7.31178187e-03f, 3.33818465e-01f,
  -5.99148907e-02f, 8.20523128e-02f, -2.32883811e-01f, -2.05345333e-01f, -2.37126127e-01f, -3.08769718e-02f, 2.11537346e-01f, -2.25705400e-01f, 2.64279634e-01f, 3.43366355e-01f,
  -1.78811520e-01f, 1.61313340e-01f, -5.00028491e-01f, -7.37958550e-02f, -5.78003526e-02f, 3.00578088e-01f, -1.60262689e-01f, -1.47225037e-01f, -2.47784648e-02f, 3.75856981e-02f,
  3.31843525e-01f, -1.84816033e-01f, -2.56421119e-01f, -2.21135497e-01f, -4.21787441e-01f, -8.52151215e-02f, 4.19655770e-01f, -1.13318473e-01f, 4.79407400e-01f, 2.98684567e-01f,
  3.82492602e-01f, 1.19294241e-01f, 4.59444612e-01f, -7.60410652e-02f, 3.64187896e-01f, 1.67627230e-01f, 1.71522424e-01f, 2.90687561e-01f, -2.91381478e-01f, 3.00474048e-01f,
  -3.98273438e-01f, -2.62934774e-01f, 2.80168474e-01f, -1.11468047e-01f, -9.45606455e-02f, 2.26341784e-01f, 1.84393510e-01f, 1.06149986e-01f, -2.57208645e-01f, 9.65992585e-02f,
  -2.58720547e-01f, -1.95421591e-01f, 1.02291271e-01f, -3.50394070e-01f, 9.46873147e-03f, 1.15245491e-01f, -2.22301885e-01f, 1.79173991e-01f, -6.86294734e-02f, -2.82348655e-02f,
  1.18099034e-01f, 3.59483153e-01f, 1.31357789e-01f, -3.59612674e-01f, 3.98312986e-01f, 2.93508112e-01f, 1.63829148e-01f, 9.20956060e-02f, -2.26121042e-02f, 3.34452659e-01f,
  -1.16016187e-01f, -7.70619288e-02f, 1.05993608e-02f, 3.99339288e-01f, -3.21698189e-01f, -2.55057871e-01f, -3.17629501e-02f, 4.21416789e-01f, 3.15186322e-01f, -1.18710853e-01f,
  -2.82063395e-01f, 2.17699617e-01f, -2.39423141e-01f, -4.81259108e-01f, -1.21079408e-01f, 1.98073268e-01f, -4.81072068e-02f, 3.57968956e-01f, 7.53683597e-03f, 6.34211153e-02f,
  -1.52639702e-01f, -1.47078428e-02f, -4.18220907e-01f, -2.38572717e-01f, -3.09641510e-01f, -1.72003880e-01f, 1.13954239e-01f, -8.70161653e-02f, 5.25245257e-02f, 4.71032523e-02f,
  -1.28607944e-01f, 6.81762844e-02f, 2.30639845e-01f, -1.80301100e-01f, 4.42521751e-01f, 4.75177765e-02f, -2.61040423e-02f, -3.87000330e-02f, -1.72047317e-01f, 8.88494998e-02f,
  1.86621621e-01f, 4.85194415e-01f, 4.74172950e-01f, -3.32823098e-01f, 9.88335535e-02f, 2.05519155e-01f, 7.02247992e-02f, -2.71074921e-02f, 5.52538969e-02f, -2.24152401e-01f,
  -2.30206028e-01f, 2.91215867e-01f, 1.72851384e-01f, -2.81252503e-01f, 2.29805335e-01f, -1.24978669e-01f, -2.31285617e-01f, 7.36437291e-02f, -7.02540725e-02f, -1.79926351e-01f,
  -3.76884639e-02f, -1.56644821e-01f, 2.18342513e-01f, 3.53308432e-02f, -3.56381297e-01f, 2.41914198e-01f, -3.64907295e-01f, -1.79249033e-01f, 3.58237863e-01f, 2.11855307e-01f,
  1.47077337e-01f, 2.72676405e-02f, -4.06584926e-02f, -1.77474588e-01f, -2.93374032e-01f, -1.21449046e-01f, 2.18639314e-01f, 3.20164949e-01f, -1.97966129e-01f, 1.80348694e-01f,
  2.32923821e-01f, 1.03976361e-01f, 5.52109964e-02f, 1.00277029e-01f, -1.67969972e-01f, 1.87180668e-01f, 1.84301689e-01f, -3.43356043e-01f, 1.64756671e-01f, 1.26232848e-01f,
  2.95735896e-01f, -5.34832440e-02f, -2.10373268e-01f, 1.23589151e-01f, -3.26287687e-01f, 1.09186813e-01f, 6.79216981e-02f, 1.99214458e-01f, 4.80778888e-03f, 1.31859377e-01f,
  2.64635742e-01f, 9.71770063e-02f, -2.40196735e-01f, -1.40754133e-01f, -1.08629085e-01f, 1.67811736e-01f, -4.73519772e-01f, -1.71827465e-01f, 6.52560592e-02f, -1.21814586e-01f,
  3.93070802e-02f, 1.26786232e-01f, -1.49634749e-01f, -2.08195403e-01f, 2.46812910e-01f, 6.55333847e-02f, -2.11242974e-01f, -3.34361047e-02f, -4.35539573e-01f, -2.77564913e-01f,
  -3.11779469e-01f, -1.09349219e-02f, 4.73971441e-02f, 2.59543993e-02f, 2.00376838e-01f, 5.18339276e-02f, -3.03361744e-01f, -2.12405309e-01f, 4.20866683e-02f, -2.72881866e-01f,
  3.06801796e-01f, 3.04043442e-01f, -1.78973556e-01f, -3.06045771e-01f, 3.82623523e-01f, 3.44307870e-01f, -2.37845723e-02f, 3.97012644e-02f, 3.57848048e-01f, -4.53897454e-02f,
  3.41024369e-01f, 1.47035837e-01f, -4.50705498e-01f, 2.94372946e-01f, 2.70262122e-01f, 1.38085052e-01f, 1.61103353e-01f, -1.19820721e-02f, -1.48212224e-01f, 7.95713663e-02f,
  -1.34418178e-02f, 3.60190749e-01f, 9.58344638e-02f, 1.44176856e-01f, -3.55655134e-01f, -1.56091660e-01f, -2.81286389e-01f, 1.19007245e-01f, 2.30501413e-01f, -1.62620246e-01f,
  2.52250940e-01f, -3.41478378e-01f, 1.14470117e-01f, 8.53613541e-02f, 1.15770400e-01f, -4.62814793e-02f, -1.55419067e-01f, 1.99779704e-01f, 2.03035936e-01f, 4.01204340e-02f,
  -4.45268750e-02f, 4.30433124e-01f, -3.01938593e-01f, -1.99996218e-01f, 2.41370499e-01f, -2.98697036e-02f, 3.01338077e-01f, 6.81120961e-04f, -1.69001490e-01f, -1.32054850e-01f,
  1.06872849e-01f, 1.10101677e-01f, -1.20033547e-01f, 3.81877311e-02f, 4.16118763e-02f, -3.44819464e-02f, -5.32168858e-02f, 1.09190099e-01f, -2.68722773e-01f, 1.18607685e-01f,
  -1.07800871e-01f, 3.40407759e-01f, 4.24662456e-02f, 8.94100145e-02f, 1.75808117e-01f, 1.99770227e-01f, -2.44399905e-01f, 9.79765654e-02f, -1.17919371e-02f, -2.73444951e-01f,
  1.19124785e-01f, -1.61956236e-01f, -2.05872551e-01f, -4.70380411e-02f, -2.64374852e-01f, -3.83279651e-01f, 2.52707284e-02f, 1.45159230e-01f, -2.10949004e-01f, 5.19387946e-02f,
  2.76104003e-01f, -9.47417989e-02f, -2.47773692e-01f, 5.61766932e-03f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.10916325e-01f, 1.12566873e-01f, 1.92954436e-01f, -4.22655605e-02f, 5.00367880e-01f, 1.64539114e-01f, 1.78455457e-01f, 2.67803460e-01f, 1.82981744e-01f, 2.37985298e-01f,
  2.53646016e-01f, 1.11033060e-01f, 5.77249408e-01f, 9.19511318e-02f, -2.82612741e-01f, -1.93942890e-01f, 1.53495491e-01f, -1.29981181e-02f, 2.59682387e-01f, 1.89887151e-01f,
  6.94987237e-01f, -3.42682093e-01f, 9.64887142e-02f, -6.88317418e-02f, -2.25246206e-01f, 3.91708314e-01f, -1.40631288e-01f, -1.79965869e-01f, -2.87455708e-01f, 4.06582803e-01f,
  -2.03927308e-01f, -6.95027232e-01f, 1.41448513e-01f, -1.06406510e-01f, 1.05993012e-02f, 4.52431776e-02f, -5.90307117e-01f, 1.95644259e-01f, -1.70229673e-01f, -1.14225470e-01f,
  -5.20593897e-02f, -1.53729692e-01f, 2.70517707e-01f, -1.22376584e-01f, 6.82748318e-01f, 3.55231047e-01f, 6.17119186e-02f, 5.50280511e-01f, -3.69541407e-01f, -1.41449124e-01f,
  7.17085227e-03f, 1.90187603e-01f, -1.51086599e-02f, 1.38860255e-01f, -6.79201365e-01f, -1.30202854e-02f, 5.77720940e-01f, -1.63805321e-01f, -2.04007432e-01f, -2.86569178e-01f,
  -2.50804394e-01f, -2.54107378e-02f, 4.97092932e-01f, -2.63569623e-01f, 6.92761317e-02f, -3.88589829e-01f, 1.78606406e-01f, -7.73888128e-03f, 5.04229724e-01f, 4.08184439e-01f,
  4.16945875e-01f, 1.92808524e-01f, 1.12490840e-01f, 5.20741880e-01f, 4.10166346e-02f, 2.09733024e-01f, 1.63420156e-01f, -1.46730229e-01f, -2.89732188e-01f, -1.47801608e-01f,
  3.71258371e-02f, 1.32218689e-01f, 1.42331630e-01f, 2.60706306e-01f, 2.10284606e-01f, -6.63439751e-01f, 4.12941396e-01f, 3.12987030e-01f, -7.79060125e-02f, -2.67204106e-01f,
  -1.14789866e-01f, 1.92773223e-01f, -3.80656868e-01f, 2.37563014e-01f, 3.07166815e-01f, -4.85408694e-01f, 5.61990380e-01f, 2.68328875e-01f, 2.85138696e-01f, -2.46534705e-01f,
  2.87110209e-01f, 1.19681001e-01f, 1.77287519e-01f, -1.41758814e-01f, 4.23162729e-02f, -1.39867991e-01f, -1.65295571e-01f, 6.15361566e-03f, -4.32997972e-01f, -1.12627722e-01f,
  5.17967880e-01f, -2.15885580e-01f, 4.36380357e-01f, 3.00035983e-01f, 3.41530979e-01f, -7.37770438e-01f, 4.06834602e-01f, -1.77410513e-01f, 5.54226875e-01f, 1.85069889e-01f,
  -2.05912411e-01f, 2.53230810e-01f, 3.59246522e-01f, 2.41520315e-01f, -1.42680138e-01f, 2.37711444e-01f, -1.28213286e-01f, 4.88812700e-02f, -9.91326645e-02f, 1.71519831e-01f,
  2.29473695e-01f, -4.47389305e-01f, 3.67970645e-01f, 4.47123162e-02f, 1.04275793e-01f, 4.67181802e-01f, -1.54915899e-01f, 5.46129107e-01f, 1.50021330e-01f, 2.58751452e-01f,
  4.33877230e-01f, 1.19234473e-01f, 8.87977555e-02f, -9.52381939e-02f, 2.35994663e-02f, 3.54031205e-01f, 4.46732163e-01f, -1.89064234e-01f, 2.88379461e-01f, 2.10969314e-01f,
  9.61969569e-02f, -5.13641000e-01f, -1.62796825e-01f, 4.99678791e-01f, -1.08100824e-01f, 2.06622183e-01f, -3.43554246e-04f, 4.25343096e-01f, -4.75061417e-01f, -1.13984168e-01f,
  9.41665750e-03f, 1.91779733e-01f, 4.92885485e-02f, 1.12575702e-01f, 1.70624346e-01f, -3.84677291e-01f, 2.23355353e-01f, 1.95171922e-01f, 1.64488778e-02f, -3.87259543e-01f,
  2.31751367e-01f, -2.05745816e-01f, 1.41778931e-01f, 1.22544691e-01f, 2.21907333e-01f, -2.24137321e-01f, -1.93553612e-01f, 2.03330785e-01f, 1.87056720e-01f, 3.28803778e-01f,
  4.26053464e-01f, 1.26495346e-01f, -4.12451737e-02f, -8.00123438e-02f, 3.11420768e-01f, 1.06372319e-01f, 6.48978949e-01f, 3.01566273e-01f, -1.89997494e-01f, 3.79497856e-01f,
  3.06411177e-01f, 2.85615265e-01f, 2.52036959e-01f, -3.34541470e-01f, 2.35074997e-01f, 1.58273906e-01f, -2.68732524e-03f, 3.69175673e-01f, 2.13520557e-01f, 3.65543813e-01f,
  2.71076579e-02f, 6.24463737e-01f, 2.62732387e-01f, 3.48511845e-01f, 2.30174139e-01f, 2.45259345e-01f, -7.17188716e-01f, -2.11149976e-02f, -3.55496049e-01f, -1.59003332e-01f,
  -1.82477206e-01f, 1.44101650e-01f, -3.32105666e-01f, -1.24886721e-01f, 4.34379838e-02f, -3.01678270e-01f, 3.88958126e-01f, 1.22500218e-01f, -2.87314326e-01f, 3.16884160e-01f,
  -4.90323275e-01f, -3.09636652e-01f, 4.25834596e-01f, 8.46255571e-03f, 2.07685381e-01f, 5.38747489e-01f, 3.57779950e-01f, -2.63134360e-01f, 4.84411687e-01f, -3.37927230e-02f,
  2.56460875e-01f, 3.06252867e-01f, 3.11277062e-01f, 3.02942663e-01f, -2.68231798e-02f, 1.35042027e-01f, 4.03488651e-02f, -2.13759586e-01f, 1.71707556e-01f, -4.46175300e-02f,
  -8.12661201e-02f, 2.93551266e-01f, 6.61391675e-01f, -4.71643388e-01f, 2.04525128e-01f, 3.54490250e-01f, 9.25048664e-02f, -4.70477402e-01f, 9.95285157e-03f, 1.09098747e-01f,
  -1.05593528e-03f, 1.20875485e-01f, -4.41248327e-01f, 2.36797318e-01f, -1.81765184e-01f, -2.38454506e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.08899081e-01f, 2.17762172e-01f, 3.82663906e-01f, 1.69167981e-01f, 3.57856989e-01f, -5.06639220e-02f, 1.68598861e-01f, 3.88659984e-02f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  5.67790985e-01f, 2.69536048e-01f, 1.91576332e-01f, -6.87679350e-02f, -1.95450559e-01f, 3.46354336e-01f, 4.04233783e-01f, 1.82697713e-01f, 2.05877081e-01f, -1.92973107e-01f,
  1.61350772e-01f, 5.32140322e-02f, -6.05854802e-02f, -8.62517022e-03f, -1.92135364e-01f, 9.76961553e-02f, 1.18151568e-01f, 3.31593722e-01f, -1.77092344e-01f, -1.49939105e-01f,
  1.02121621e-01f, 1.09748200e-01f, 1.62784070e-01f, 2.83157200e-01f, -1.53842971e-01f, 3.45726818e-01f, 3.92854474e-02f, -8.90744105e-02f, -9.75755006e-02f, -1.93812832e-01f,
  3.45874757e-01f, -3.89034808e-01f, -1.74211934e-01f, -5.63218966e-02f, 5.50944507e-01f, -1.80269107e-01f, -3.07492375e-01f, 1.67525008e-01f, 1.75648555e-01f, 1.10259885e-02f,
  3.95122886e-01f, 7.94122070e-02f, 3.38167250e-02f, 5.53956032e-01f, -1.11980833e-01f, -2.56163657e-01f, 4.76942444e-03f, -6.32878423e-01f, -1.15951084e-01f, -3.40011299e-01f,
  -5.93338348e-02f, 2.27883784e-03f, 2.77857095e-01f, -5.40994763e-01f, 2.98840553e-01f, 2.43483767e-01f, 2.20275357e-01f, 3.33239019e-01f, 7.21796155e-02f, -1.09108858e-01f,
  -2.56360322e-02f, -1.61876857e-01f, -2.86767557e-02f, -3.84009629e-02f, 3.52343470e-01f, 1.02739997e-01f, -9.61770490e-02f, -2.69748837e-01f, 7.99074695e-02f, 2.96557248e-01f,
  3.62908185e-01f, -2.31791958e-01f, 3.98925185e-01f, 2.25464463e-01f, -2.77868003e-01f, 7.74242133e-02f, -1.74778447e-01f, 7.45593309e-02f, 1.34236321e-01f, -2.06707492e-01f,
  -1.98542327e-01f, 6.81408681e-03f, -3.31271768e-01f, 4.10125673e-01f, 5.19172773e-02f, -2.09677890e-01f, 7.73245096e-02f, 2.52863690e-02f, -1.89981028e-01f, 3.85236263e-01f,
  -9.58307907e-02f, 1.02411292e-01f, -2.34485060e-01f, 5.38206436e-02f, -1.52983725e-01f, -2.56094545e-01f, -1.58967316e-01f, 2.71333516e-01f, -2.32967753e-02f, 1.08180484e-02f,
  4.05381054e-01f, 5.22584558e-01f, -2.01335996e-01f, 1.98932648e-01f, -1.16305016e-02f, 2.66091861e-02f, 6.91319823e-01f, 7.34611154e-02f, 3.32981020e-01f, -2.94199526e-01f,
  -4.96719182e-01f, -1.23202965e-01f, -3.43474835e-01f, -9.31534693e-02f, 1.17724635e-01f, 1.62628174e-01f, 6.45698190e-01f, 2.96849906e-01f, -9.50161740e-02f, 6.73707545e-01f,
  7.98277482e-02f, 2.16724281e-03f, 8.75512064e-02f, 8.28204490e-03f, 1.12794019e-01f, -8.32970887e-02f, -1.07328527e-01f, -1.48148134e-01f, 2.86849111e-01f, -2.56710928e-02f,
  -1.08412437e-01f, 3.53302181e-01f, -2.88334519e-01f, 7.44274855e-02f, -1.69017669e-02f, 1.89367279e-01f, -1.28076777e-01f, -3.39083700e-03f, 1.65098563e-01f, -1.01206854e-01f,
  1.02637202e-01f, -3.26468140e-01f, 7.76974261e-02f, 2.24544242e-01f, -3.25206041e-01f, -3.64940800e-02f, 1.21374421e-01f, 3.67055349e-02f, -2.27735355e-01f, 8.82063657e-02f,
  -3.86066325e-02f, -6.73138872e-02f, 3.35980952e-01f, -1.85992405e-01f, 6.73011914e-02f, -1.06585823e-01f, 3.04835260e-01f, 3.47347446e-02f, -2.14758813e-01f, 2.80079842e-01f,
  -4.85760778e-01f, -1.77761510e-01f, 1.70884356e-02f, -9.45927873e-02f, 2.25704029e-01f, 4.28577363e-02f, 2.38136426e-01f, -2.19259933e-01f, 6.32488728e-02f, -2.05047861e-01f,
  3.60291719e-01f, -1.49338588e-01f, 8.24544355e-02f, 3.26444358e-01f, -5.04890919e-01f, 1.24364831e-01f, -1.59159079e-01f, -4.35142845e-01f, -1.29634202e-01f, -2.98890591e-01f,
  3.74812007e-01f, 1.30422682e-01f, 1.73487276e-01f, 1.93448678e-01f, -7.90916849e-03f, 7.66204670e-02f, 7.69972056e-02f, -5.88005520e-02f, -1.61670178e-01f, -1.34400204e-01f,
  2.99885184e-01f, -2.73659348e-01f, -5.36878817e-02f, 1.57660261e-01f, -5.67837916e-02f, -1.18243806e-01f, -2.02401914e-02f, 3.62480640e-01f, 2.84488767e-01f, -5.40802591e-02f,
  2.24842206e-01f, 3.42823230e-02f, -7.43954908e-03f, -7.47492090e-02f, -2.25338675e-02f, 5.91836631e-01f, -6.64048851e-01f, -1.09160811e-01f, 3.48291308e-01f, -5.09234890e-02f,
  -2.36362237e-02f, -4.42831293e-02f, -2.75899589e-01f, -2.16327041e-01f, 1.25001118e-01f, 4.73364629e-03f, 1.77126788e-02f, 4.31180708e-02f, 2.73301274e-01f, -2.10510474e-02f,
  -3.01808089e-01f, -3.35351646e-01f, 2.42925316e-01f, -9.58520453e-03f, 1.76196888e-01f, -2.13812411e-01f, 2.91570038e-01f, 6.51839301e-02f, -2.20034137e-01f, -5.70723593e-01f,
  1.27197400e-01f, 1.12809902e-02f, -1.09715953e-01f, 6.62097055e-03f, -4.56135839e-01f, -3.82554121e-02f, -2.98040658e-01f, -3.59609693e-01f, 1.94426849e-01f, -2.31597170e-01f,
  -1.94099862e-02f, 8.19019303e-02f, -2.12838814e-01f, 2.33491361e-01f, -1.96932271e-01f, -1.65940493e-01f, 3.67568254e-01f, -7.15530515e-02f, -1.53453261e-01f, 6.34194613e-02f,
  -3.52664024e-01f, 9.35525000e-02f, -3.10393255e-02f, 1.59386232e-01f, -6.63102418e-02f, 1.55379891e-01f, -2.28027686e-01f, -4.13064569e-01f, 1.31801600e-02f, 3.35960686e-01f,
  -1.07636280e-01f, -4.75421518e-01f, -3.06073695e-01f, 6.31825253e-02f, -9.94702950e-02f, 2.51381751e-02f, 1.23123135e-02f, 1.74679458e-02f, -1.79142728e-01f, 3.08873355e-02f,
  4.89177555e-01f, 8.65084603e-02f, 8.22977200e-02f, -2.59360448e-02f, 3.99208777e-02f, 1.29188597e-01f, -3.52762908e-01f, 2.48459160e-01f, 2.95678794e-01f, -3.08654040e-01f,
  -2.80614257e-01f, -4.61448729e-01f, 2.77017653e-02f, -1.41300604e-01f, 5.78861758e-02f, 1.87883809e-01f, -3.68797481e-02f, 2.30881572e-01f, 4.34138745e-01f, 1.19274482e-02f,
  6.19382225e-02f, -3.15108784e-02f, -2.18076870e-01f, 3.81829560e-01f, -2.77635772e-02f, 1.81503192e-01f, 2.92482615e-01f, 3.75320196e-01f, -4.60562073e-02f, 3.17958035e-02f,
  1.53408453e-01f, -5.88225186e-01f, 2.19040617e-01f, -3.05530459e-01f, -1.03458986e-01f, 4.99461830e-01f, -5.36248460e-02f, 3.56887668e-01f, 5.17507009e-02f, -2.02178851e-01f,
  7.49647915e-02f, -3.57087180e-02f, 1.60737216e-01f, -2.20841259e-01f, -1.14906030e-02f, -2.20968679e-01f, 2.86496818e-01f, 1.10878266e-01f, -1.41182780e-01f, 1.80902407e-01f,
  -4.48231786e-01f, -1.18936002e-01f, -3.11784390e-02f, 4.01688784e-01f, 2.92178571e-01f, -1.06078550e-01f, -4.12799360e-04f, 5.61238043e-02f, -1.62263244e-01f, -4.74716902e-01f,
  3.32728446e-01f, 9.36029777e-02f, 2.43569866e-01f, 1.17129058e-01f, -4.51712757e-01f, 3.70419979e-01f, 1.12983696e-01f, -3.26842606e-01f, -1.40613094e-01f, -3.30723166e-01f,
  4.81029093e-01f, 1.91765457e-01f, 2.96512783e-01f, 6.14343286e-01f, -1.80030048e-01f, 2.78665703e-02f, -1.19128317e-01f, 7.53475726e-02f, 2.33606324e-01f, -1.35677904e-01f,
  1.88048631e-01f, -1.29890263e-01f, 7.52014145e-02f, 2.70130217e-01f, -1.02025270e-01f, 2.66771436e-01f, 1.87491756e-02f, 4.20762330e-01f, -1.91182625e-02f, -3.24778371e-02f,
  5.54653555e-02f, 2.81400263e-01f, 4.32372808e-01f, -3.18770647e-01f, 9.34151746e-03f, -9.05043259e-02f, -8.06972802e-01f, -1.82692721e-01f, 2.29275730e-02f, -6.42695576e-02f,
  3.39162685e-02f, -3.93178081e-03f, 1.14356689e-01f, 3.25473584e-02f, -2.45051846e-01f, 1.66985989e-01f, 2.33670324e-01f, -1.83745310e-01f, 3.49915296e-01f, 2.60321409e-01f,
  -1.27484366e-01f, -1.21639721e-01f, -1.02299944e-01f, 2.11237267e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.07144850e-01f, 2.79060125e-01f, 7.31642544e-03f, 1.93386033e-01f, -4.28104065e-02f, 4.42992419e-01f, 3.89101863e-01f, 6.07819557e-01f, 2.13824347e-01f, -3.49030703e-01f,
  2.15471715e-01f, 4.92343694e-01f, 2.24794880e-01f, 3.08045030e-01f, 1.33857515e-03f, 6.73151672e-01f, 8.49992216e-01f, 4.82353449e-01f, -5.72056711e-01f, -3.81705642e-01f,
  3.30152243e-01f, -1.94207177e-01f, 1.58136815e-01f, 4.79357764e-02f, 7.60814697e-02f, -8.40836950e-03f, 1.37452438e-01f, -4.34684427e-03f, -1.91765353e-01f, -2.91888028e-01f,
  6.57312453e-01f, -2.14346603e-01f, 6.36764705e-01f, -1.85706824e-01f, -1.45197570e-01f, -6.31371856e-01f, -5.45601487e-01f, -2.34145135e-01f, 4.47158128e-01f, 4.17961508e-01f,
  7.03981638e-01f, 8.49841774e-01f, -6.73895299e-01f, 3.35975975e-01f, -3.53585303e-01f, 6.83133528e-02f, 3.54023397e-01f, -5.79487562e-01f, -4.34157312e-01f, 6.67438269e-01f,
  -2.83239543e-01f, 3.27295214e-01f, -4.54701036e-01f, 1.04215242e-01f, 3.08472663e-01f, -4.13058370e-01f, -1.08875409e-01f, 3.90872091e-01f, 1.01226471e-01f, 2.09429627e-03f,
  -1.90386310e-01f, 2.05412373e-01f, 4.24325883e-01f, 8.18384737e-02f, -7.85763323e-01f, -5.00698268e-01f, 3.67370397e-01f, -1.91651713e-02f, 7.74001658e-01f, -1.67742446e-01f,
  -3.18026580e-02f, -3.54080141e-01f, 2.50423342e-01f, -3.69892091e-01f, -1.05736464e-01f, 3.45095783e-01f, 3.74942243e-01f, 5.95616937e-01f, 2.67279536e-01f, -3.91779751e-01f,
  -3.54726970e-01f, -6.69633627e-01f, 9.73420441e-01f, -7.40314364e-01f, 8.40651914e-02f, 4.90644962e-01f, 9.99065302e-03f, 2.62238383e-01f, 4.91188228e-01f, 1.90678313e-01f,
  1.41551480e-01f, -3.64439517e-01f, 2.95606703e-01f, 1.33063644e-01f, 4.21521336e-01f, -1.33355767e-01f, -3.25268507e-01f, -1.73862740e-01f, 3.77926305e-02f, -2.90213572e-03f,
  -4.03938562e-01f, -3.44679832e-01f, 1.65665120e-01f, -6.00585997e-01f, -8.09935555e-02f, -2.53610790e-01f, -1.19985521e-01f, -4.11863178e-01f, 1.60840139e-01f, -4.47328657e-01f,
  2.14761402e-02f, -8.18398297e-02f, 1.60793453e-01f, -3.89382482e-01f, 7.77362704e-01f, 2.63490528e-02f, -5.86858809e-01f, -2.86246333e-02f, 9.17838588e-02f, -5.26746869e-01f,
  1.68257698e-01f, 4.49831456e-01f, -9.73004252e-02f, 7.81804621e-01f, 3.89359027e-01f, 1.03409851e+00f, 1.76751196e-01f, 6.62906349e-01f, 3.68183464e-01f, 1.20019272e-01f,
  -1.22871995e-02f, 1.74032673e-01f, 2.92882416e-02f, 2.40207329e-01f, 2.64934808e-01f, 2.29264691e-01f, 5.31270385e-01f, 3.50615948e-01f, 6.19127870e-01f, -3.54825668e-02f,
  2.69835740e-01f, -1.81966379e-01f, 1.23190887e-01f, -1.58930480e-01f, -2.05225144e-02f, 6.60730243e-01f, 5.16109347e-01f, 3.59430701e-01f, 2.06871733e-01f, 4.08856928e-01f,
  -5.27944803e-01f, -4.49803650e-01f, 5.51363826e-01f, -4.01852340e-01f, 1.02128875e+00f, 1.90941676e-01f, 4.40896451e-01f, -2.44555563e-01f, 2.89640248e-01f, 1.37877181e-01f,
  5.07130444e-01f, 4.53566492e-01f, 6.55057967e-01f, 1.51276961e-02f, -8.31300917e-04f, -2.19418421e-01f, 3.49704891e-01f, 4.73075628e-01f, 2.96153933e-01f, -2.37389088e-01f,
  6.05048798e-02f, 6.82204664e-01f, -1.56922370e-01f, -3.73337150e-01f, -3.45669568e-01f, 3.41520399e-01f, 6.91307724e-01f, 5.19186139e-01f, -1.15671313e+00f, -1.31073758e-01f,
  3.88090312e-01f, -7.53577948e-01f, 2.60181457e-01f, 5.37640870e-01f, 4.72718589e-02f, 4.50605422e-01f, -1.27611995e-01f, 3.58880430e-01f, 2.93678492e-01f, -2.93399900e-01f,
  3.56334597e-01f, 4.11490887e-01f, -1.85257047e-01f, -5.74462831e-01f, 3.57046127e-01f, -2.15422317e-01f, 2.43352264e-01f, -1.94425076e-01f, 1.45109236e-01f, -3.11109781e-01f,
  1.11182489e-01f, -1.23069681e-01f, -1.79438367e-01f, 2.74812758e-01f, -2.11730555e-01f, 4.62250024e-01f, 1.16987146e-01f, -5.95342398e-01f, -6.33955479e-01f, -1.01777756e+00f,
  6.03977501e-01f, -1.81641560e-02f, 7.16459304e-02f, -5.77179015e-01f, -1.61610525e-02f, -3.04108351e-01f, -2.82297164e-01f, 7.12620497e-01f, -1.89304441e-01f, -2.90753335e-01f,
  -4.06742454e-01f, -1.75863430e-02f, 3.54763597e-01f, -1.49880022e-01f, -2.34433278e-01f, 7.03322813e-02f, 8.76247138e-02f, 2.36664146e-01f, 6.60967678e-02f, -4.41026866e-01f,
  1.56690434e-01f, 2.93401361e-01f, -6.03999376e-01f, -1.38205275e-01f, 4.18738067e-01f, 3.59945297e-01f, 4.23960239e-01f, -4.44956511e-01f, -5.82282424e-01f, 1.40308425e-01f,
  3.25282067e-01f, 1.66449457e-01f, -3.34412605e-01f, -1.79266542e-01f, 3.42343599e-01f, -2.63183385e-01f, -1.25837579e-01f, 3.77423048e-01f, 2.80468255e-01f, 2.70022690e-01f,
  4.77517955e-03f, 2.45451346e-01f, 5.19285381e-01f, -1.28961965e-01f, -4.05693464e-02f, 4.24279869e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.99391121e-01f, 4.34487164e-01f, 6.55795932e-02f, 3.46973807e-01f, 2.06162035e-01f, 4.72102284e-01f, 1.93621919e-01f, 2.84218699e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -7.27529824e-02f, -3.43713790e-01f, -8.93101096e-02f, 1.86586529e-02f, -2.24590987e-01f, -1.15502708e-01f, -4.79693949e-01f, -2.35738099e-01f, -1.81547910e-01f, 4.50066268e-01f,
  2.87625968e-01f, 1.53728858e-01f, 3.29296589e-01f, -2.78428316e-01f, -7.66300797e-01f, -2.66500175e-01f, 2.30542347e-01f, -2.73660481e-01f, 9.03983712e-02f, 3.41301888e-01f,
  4.55400974e-01f, 7.34597296e-02f, 3.54911029e-01f, 2.78717846e-01f, -3.06368470e-01f, -8.88430238e-01f, -6.27882481e-01f, 3.35663706e-01f, -2.22736508e-01f, -1.12984717e-01f,
  -3.55496973e-01f, 4.20848370e-01f, 3.18333149e-01f, -1.57499090e-02f, 1.22535326e-01f, 2.94751346e-01f, -8.05786327e-02f, -2.07102373e-01f, 8.70871842e-02f, 2.24112812e-02f,
  -8.09198618e-02f, -2.88670003e-01f, -5.93863130e-02f, -3.99351776e-01f, -2.83986807e-01f, 2.11010173e-01f, -6.88392222e-01f, 4.95406628e-01f, 5.75538874e-01f, -2.19180718e-01f,
  2.31851175e-01f, -1.31242424e-01f, -4.46201533e-01f, 4.20837522e-01f, -3.21037352e-01f, -8.29996988e-02f, -2.13700856e-04f, -5.80185093e-02f, -7.74224997e-01f, -2.56525457e-01f,
  3.69931787e-01f, 3.12488139e-01f, -2.64157385e-01f, 2.77618736e-01f, 1.33538619e-01f, 2.78472215e-01f, 4.62657094e-01f, 9.55696478e-02f, 6.89032152e-02f, 2.49624550e-01f,
  -4.39108819e-01f, 1.95431888e-01f, 3.74117166e-01f, 3.44389170e-01f, 9.38970521e-02f, 4.95649308e-01f, 3.20668936e-01f, -1.14645135e+00f, -2.39876911e-01f, -4.87414151e-01f,
  -1.42837077e-01f, 3.60814869e-01f, 3.15641463e-01f, -4.53992277e-01f, 3.46764594e-01f, -3.05603057e-01f, -8.43946934e-02f, 1.89038485e-01f, 3.03339243e-01f, 4.24845934e-01f,
  -5.97051382e-01f, -3.60516667e-01f, 3.73944998e-01f, -2.72796005e-01f, -7.46693492e-01f, -6.16823971e-01f, 3.16235013e-02f, -7.18746722e-01f, 1.52966723e-01f, 2.98591048e-01f,
  4.11385059e-01f, 2.78850645e-01f, 4.07544374e-01f, -6.90122023e-02f, 5.94365478e-01f, 4.58689421e-01f, 4.82199937e-01f, 3.10211271e-01f, -9.23208356e-01f, -6.77059054e-01f,
  7.33910680e-01f, -6.07575834e-01f, -2.83189833e-01f, -1.67709425e-01f, -3.34718674e-01f, 6.18003428e-01f, 3.86364400e-01f, -4.38172162e-01f, -5.47760189e-01f, 3.82512748e-01f,
  -6.65726185e-01f, -1.17224596e-01f, -3.66201997e-01f, 4.41853702e-01f, -6.20812416e-01f, -9.95636284e-01f, -6.27722263e-01f, -5.04352808e-01f, -1.71832725e-01f, 3.08636278e-01f,
  3.13382000e-01f, -7.33770370e-01f, 2.28646800e-01f, -4.45469767e-01f, -4.84206796e-01f, -4.68540817e-01f, -3.30030978e-01f, -5.50623894e-01f, -2.29197338e-01f, 1.65771976e-01f,
  3.26582819e-01f, 3.57479826e-02f, 5.38181737e-02f, 7.54372403e-02f, 5.25286913e-01f, 1.05614647e-01f, -4.67326976e-02f, -2.04664007e-01f, 5.66190928e-02f, 4.65919733e-01f,
  -3.77815813e-01f, -4.57742691e-01f, -5.31962633e-01f, 7.70732641e-01f, -2.27841631e-01f, 1.27285525e-01f, -2.79016107e-01f, -2.47272253e-01f, -8.06257367e-01f, 2.61510890e-02f,
  9.81419347e-03f, 1.56112835e-01f, -2.05036938e-01f, -1.70208976e-01f, -1.06686004e-01f, 5.20874143e-01f, -6.05253577e-02f, 7.87778646e-02f, 4.90625679e-01f, -1.11670651e-01f,
  4.02532429e-01f, 2.95281172e-01f, -3.08563769e-01f, 9.68728662e-02f, 7.89637744e-01f, 2.39321440e-01f, -1.97050810e-01f, -3.58335733e-01f, -5.26500285e-01f, -7.43072256e-02f,
  1.23897651e-02f, 8.08096901e-02f, 2.14292616e-01f, 4.76561747e-02f, -6.89758301e-01f, -4.94341552e-01f, 5.64482987e-01f, -1.99158303e-02f, 2.41467968e-01f, -1.04062811e-01f,
  -2.64479011e-01f, 2.16002762e-01f, 3.68564725e-01f, -7.34087706e-01f, 2.46279202e-02f, 3.57969314e-01f, 5.81802092e-02f, 8.34546313e-02f, 2.75064036e-02f, -7.39021599e-02f,
  3.17514502e-02f, -6.90447271e-01f, -5.07500947e-01f, 2.70986170e-01f, 2.81938761e-01f, -4.53080565e-01f, 4.18720275e-01f, 8.59612644e-01f, 1.35018259e-01f, -7.79004276e-01f,
  -1.47982836e-01f, 8.38475525e-02f, 2.53833115e-01f, 1.41779691e-01f, 3.40965576e-02f, -1.77589417e-01f, 5.58368005e-02f, -1.68257013e-01f, 4.86459494e-01f, -3.44661921e-01f,
  -2.74093449e-01f, 1.57278389e-01f, 4.08203304e-01f, -2.65012473e-01f, 1.56421363e-01f, 5.71412817e-02f, -3.94792318e-01f, -3.39719504e-01f, 1.11951172e-01f, 4.40350533e-01f,
  3.68862152e-01f, 2.99453884e-01f, -1.98842317e-01f, 1.65355916e-03f, 1.26212656e-01f, -5.11922061e-01f, 5.55209994e-01f, 3.96166682e-01f, 1.40691280e-01f, -2.40608662e-01f,
  -4.03797388e-01f, 3.83231878e-01f, -9.29600298e-02f, 1.29136562e-01f, -2.19886199e-01f, -5.28956018e-02f, -9.83013883e-02f, 5.57128564e-02f, -6.80598438e-01f, 3.60891849e-01f,
  1.68158635e-01f, -4.77747917e-02f, -2.48944178e-01f, -2.00011805e-01f, 6.85142994e-01f, -2.24610239e-01f, 3.03831488e-01f, 2.23030165e-01f, -3.57373089e-01f, -5.07909298e-01f,
  3.31447691e-01f, -3.03889327e-02f, 1.51934102e-01f, 7.12219253e-02f, -6.48249149e-01f, 4.29728955e-01f, 7.57069560e-03f, -1.72989279e-01f, 6.66001499e-01f, 3.18986237e-01f,
  -3.64619851e-01f, -5.37223667e-02f, 2.68554419e-01f, 5.20197093e-01f, 5.66951454e-01f, 3.08742613e-01f, 7.13491589e-02f, -9.93704498e-02f, 6.86580315e-02f, 2.52653122e-01f,
  -4.66991290e-02f, -3.87497663e-01f, 6.94545925e-01f, -8.97965729e-01f, 2.74309307e-01f, -2.26660296e-01f, -9.14787874e-02f, 8.03400502e-02f, -2.80582368e-01f, -1.94730669e-01f,
  -4.65743959e-01f, 1.89327821e-01f, -4.26585734e-01f, -1.53645515e-01f, -3.94527726e-02f, 2.38427207e-01f, -1.29489452e-01f, 4.57126468e-01f, 7.87722468e-01f, -7.69072175e-01f,
  -2.11938947e-01f, 6.60145819e-01f, 3.39297950e-01f, -9.28398132e-01f, 5.38353287e-02f, 5.93847454e-01f, 3.93259525e-01f, -5.90002798e-02f, -2.43281394e-01f, -2.37704173e-01f,
  3.67444515e-01f, -1.56542242e-01f, 3.11864078e-01f, 3.53634268e-01f, 1.82800703e-02f, -1.30695567e-01f, -5.77481687e-01f, 3.02177042e-01f, -1.44379139e-01f, -7.40101457e-01f,
  -2.07161590e-01f, 7.22176060e-02f, -1.65106002e-02f, 5.58412015e-01f, -3.50793868e-01f, -5.61563015e-01f, -2.11819232e-01f, 5.65198362e-01f, 3.41356099e-01f, -3.84944290e-01f,
  -9.63801980e-01f, -7.72590756e-01f, -2.97019929e-01f, -2.34382525e-01f, -3.70444387e-01f, -1.03047408e-01f, 1.18663438e-01f, 1.08160309e-01f, -4.30926830e-01f, -4.45682965e-02f,
  5.66870809e-01f, -2.99790710e-01f, 3.46567892e-02f, 3.11705649e-01f, -3.72236758e-01f, -7.85036013e-02f, -6.42154992e-01f, 2.27043822e-01f, 5.33581972e-01f, -1.14862657e+00f,
  -2.35477477e-01f, -2.27955043e-01f, -4.20499653e-01f, 4.19304281e-01f, 3.32077563e-01f, 4.34756279e-02f, 3.77927721e-02f, -2.67877519e-01f, 2.28778925e-02f, -5.66654913e-02f,
  -3.52066636e-01f, -1.94171324e-01f, -6.67938471e-01f, 2.55667627e-01f, -2.90028244e-01f, 2.41810143e-01f, -1.86668217e-01f, 5.84912539e-01f, -5.94537199e-01f, 3.71476144e-01f,
  3.59719515e-01f, -4.94182944e-01f, -2.19168719e-02f, -5.09112298e-01f, 1.41517639e-01f, -1.29538059e-01f, 4.73544270e-01f, -7.67883718e-01f, -6.05371654e-01f, -6.68896496e-01f,
  -4.26101834e-01f, 4.92905885e-01f, -2.82880306e-01f, 2.86130667e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.34020522e-01f, -9.48592946e-02f, 7.27461204e-02f, -1.05183832e-02f, 1.08656429e-01f, -4.45428193e-02f, 3.38529199e-02f, 3.50596383e-02f, 2.71658629e-01f, -1.07090041e-01f,
  -6.70773983e-02f, -3.24568786e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    