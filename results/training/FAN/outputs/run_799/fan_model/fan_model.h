/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.20349199e-02f, -1.78218365e-01f, -4.85905334e-02f, 1.55928815e-02f, -2.90644735e-01f, -1.79977491e-01f, -1.86548054e-01f, -1.42747819e-01f, -1.18093714e-02f, 9.68468636e-02f,
  -2.13879809e-01f, 8.02662037e-03f, 4.04946953e-02f, 1.27644446e-02f, -1.78523958e-02f, -9.31436270e-02f, 4.63308580e-02f, 1.01198971e-01f, -1.61625132e-01f, -2.04218820e-01f,
  -1.33887008e-01f, 7.00270981e-02f, 1.42954707e-01f, -2.49933824e-02f, 1.03746064e-01f, 4.83279303e-02f, 6.55110031e-02f, 8.10120702e-02f, -3.03819478e-02f, 4.22122598e-01f,
  2.98617762e-02f, -2.47977972e-02f, 5.94698638e-02f, 7.23751858e-02f, 4.37742695e-02f, 2.58761328e-02f, 1.01605002e-02f, 4.35637049e-02f, 6.01781048e-02f, 9.17511731e-02f,
  5.12551703e-02f, 7.97224492e-02f, 1.08916096e-01f, -4.24949937e-02f, 1.05847102e-02f, 6.43863529e-02f, 1.13331668e-01f, 8.06336701e-02f, 9.36944559e-02f, 2.00627353e-02f,
  -2.38849930e-02f, -4.48703095e-02f, 3.54318507e-02f, -4.99843620e-02f, 2.09373180e-02f, 8.69020373e-02f, 9.58061665e-02f, 1.13723844e-01f, 1.07967243e-01f, 2.46630460e-01f,
  1.82365142e-02f, 3.98781225e-02f, -4.35477961e-03f, 1.25556394e-01f, -2.02371478e-02f, 7.09525272e-02f, 2.21851319e-02f, 3.92315090e-02f, -1.21358894e-01f, 5.16420938e-02f,
  -4.32129763e-02f, -7.99126327e-02f, -3.08887213e-02f, -2.61115357e-02f, -1.66662801e-02f, 5.11266999e-02f, -9.74574760e-02f, 4.09002751e-02f, 7.06867501e-02f, 7.85986483e-02f,
  3.35620604e-02f, 9.11728740e-02f, -1.64949987e-02f, 4.91010956e-02f, 2.16494799e-02f, -6.02700328e-03f, -1.09183826e-02f, -5.89161664e-02f, 4.14266810e-02f, -1.51389325e-02f,
  6.99814409e-02f, -7.00668991e-02f, 3.52254175e-02f, -1.57880671e-02f, 8.94163251e-02f, 6.61219507e-02f, 9.46394578e-02f, 1.05842531e-01f, -1.85704287e-02f, -4.35384959e-02f,
  2.33435817e-02f, 4.59551491e-04f, 1.20313108e-01f, -5.29875569e-02f, -4.31438759e-02f, -3.76465581e-02f, 6.73720688e-02f, -2.41364446e-02f, -3.07312235e-02f, 5.04006445e-02f,
  1.93017256e-02f, 1.34659950e-02f, 1.43590033e-01f, 2.20726915e-02f, 1.59425195e-02f, 8.74389112e-02f, -2.81738094e-03f, 3.93740423e-02f, 1.00175492e-01f, 1.05974808e-01f,
  -5.68296790e-01f, -9.30948630e-02f, -4.12915170e-01f, -2.31693890e-02f, 3.88036042e-01f, -1.32518947e-01f, -1.21578440e-01f, -1.27894714e-01f, 7.46347383e-02f, 7.88616240e-02f,
  7.75771290e-02f, 8.03643167e-02f, -7.08210543e-02f, 1.70141384e-01f, -2.06266150e-01f, 7.22864643e-02f, 1.12088077e-01f, -2.24698335e-01f, -3.13948452e-01f, 2.16713488e-01f,
  4.21950400e-01f, 1.03505701e-02f, -2.61266977e-01f, -2.70145871e-02f, 1.61714345e-01f, 8.54972098e-03f, -4.21064049e-02f, 1.48809690e-03f, 7.54341558e-02f, 3.81782502e-01f,
  -1.82565078e-01f, -1.81567073e-01f, 7.98635185e-02f, 5.51738143e-02f, 2.93028150e-02f, -2.04604547e-02f, -4.33578007e-02f, -1.39724771e-02f, 3.79064716e-02f, 4.33383249e-02f,
  7.96711966e-02f, 1.29830152e-01f, 1.73969809e-02f, 1.59395915e-02f, -3.93929519e-03f, 1.03158303e-01f, -3.38995345e-02f, -1.26023531e-01f, -2.87527349e-02f, 1.82877481e-03f,
  2.77475536e-01f, 2.70355698e-02f, -9.31974500e-02f, 8.73532221e-02f, -8.50487724e-02f, 9.25699994e-02f, -4.70263883e-02f, 5.67642413e-02f, -1.11226186e-01f, 5.00589982e-03f,
  4.53212783e-02f, -3.65981879e-03f, -2.37076245e-02f, -3.47745419e-02f, -1.67838414e-03f, -1.51996985e-02f, 2.90498324e-02f, -5.12815043e-02f, -1.43739965e-03f, -1.00489482e-01f,
  1.94419418e-02f, -2.30907761e-02f, 1.46582266e-02f, -8.88693184e-02f, 3.41403708e-02f, 2.62851063e-02f, -8.83191917e-03f, -4.08203900e-02f, -2.19034199e-02f, 1.09581817e-02f,
  -1.62774008e-02f, 1.40034864e-02f, -6.87929913e-02f, 5.65784685e-02f, -1.30522940e-02f, -4.66269813e-02f, 4.31713201e-02f, -1.31157478e-02f, -6.23203181e-02f, 6.32041097e-02f,
  -1.24391042e-01f, 1.02254348e-02f, 2.41798200e-02f, 9.90747660e-03f, 4.14928421e-02f, 5.17885089e-02f, 5.17241918e-02f, 3.41048688e-02f, 4.46982831e-02f, -1.16187464e-02f,
  -2.22140588e-02f, -4.53632101e-02f, 2.21262779e-02f, -1.51985474e-02f, 7.28736222e-02f, -1.19739324e-02f, 3.53674516e-02f, -1.20298974e-02f, 9.96527374e-02f, 8.12856946e-03f,
  2.60999445e-02f, 4.94255545e-03f, -6.65092692e-02f, -8.35906491e-02f, 4.42663617e-02f, -2.09192038e-02f, -7.82237500e-02f, -1.38857765e-02f, -1.69098556e-01f, -1.44225612e-01f,
  -1.07111335e+00f, 1.11214705e-01f, 1.08890258e-01f, -3.85229409e-01f, -7.88125098e-02f, -9.11593661e-02f, -4.32436205e-02f, 3.89323272e-02f, -6.47521615e-02f, 2.31042155e-03f,
  -7.27100000e-02f, -3.64941061e-02f, 6.28583729e-02f, 1.60740122e-01f, -3.38470116e-02f, -1.33075295e-02f, -1.03207640e-01f, -1.11867979e-01f, 2.18853373e-02f, 1.06503747e-01f,
  4.15576696e-02f, -1.41752303e-01f, -9.36029106e-02f, 1.60236001e-01f, -4.71914746e-02f, 8.31246898e-02f, 6.63445070e-02f, -5.37300035e-02f, 5.52540738e-03f, -1.01868421e-01f,
  2.70173363e-02f, -1.76912695e-01f, -3.24056624e-03f, -1.79934744e-02f, 3.51373553e-02f, -6.19057082e-02f, -1.02365352e-02f, 1.71604380e-02f, -2.20897496e-02f, 3.65868695e-02f,
  -8.00055638e-02f, 9.82900634e-02f, -1.10476956e-01f, 1.72926053e-01f, -1.14733130e-01f, -4.40743417e-02f, 6.13462254e-02f, 1.16811329e-02f, -4.03603502e-02f, 1.19111761e-01f,
  8.18554021e-04f, -8.86669978e-02f, -1.33808166e-01f, 5.35626477e-03f, -5.12893125e-02f, -3.30756791e-02f, 6.12426503e-03f, -1.01551138e-01f, 4.70944867e-02f, 2.20263321e-02f,
  -8.84705782e-03f, -3.37801501e-02f, 1.83558390e-02f, 4.08787876e-02f, -9.73006617e-03f, 3.02194841e-02f, -6.28888234e-02f, 3.02002952e-02f, -3.40952328e-03f, 4.80400324e-02f,
  2.47402173e-02f, 2.11180933e-02f, 2.33040983e-03f, 4.16531190e-02f, 1.51461000e-02f, -5.01994230e-02f, -1.50741879e-02f, 5.71674593e-02f, 5.94262639e-03f, -2.86303665e-02f,
  1.13215577e-02f, -4.71779630e-02f, -2.94486471e-02f, 5.13944887e-02f, 1.05921878e-02f, 9.19623673e-03f, -3.41003239e-02f, 6.11695126e-02f, 1.42577235e-02f, -2.31620464e-02f,
  1.37614191e-01f, -1.11925431e-01f, 6.89863637e-02f, 3.37631367e-02f, -3.28020239e-03f, 2.26101242e-02f, 1.10780429e-02f, -2.45895493e-03f, -2.87909098e-02f, -8.19562301e-02f,
  1.63148008e-02f, -4.26812768e-02f, -2.49846112e-02f, 1.95958763e-02f, 4.77389693e-02f, -3.50197591e-02f, 4.08929139e-02f, -5.08223549e-02f, 3.29781882e-02f, -1.89809734e-03f,
  3.90717648e-02f, 2.60216743e-02f, -1.05434246e-01f, 1.06660677e-02f, -3.71078476e-02f, -7.54043609e-02f, 1.64937064e-01f, 2.61116251e-02f, -5.68484329e-02f, 2.66166002e-01f,
  -2.80939877e-01f, 4.72372383e-01f, -1.13034751e-02f, -1.22515403e-01f, 3.58981580e-01f, 1.63569450e-01f, 3.51494938e-01f, 5.43907322e-02f, -1.65236354e-01f, 6.17848970e-02f,
  1.92826748e-01f, -1.55023634e-01f, -1.42996892e-01f, -2.14694068e-02f, 9.32648256e-02f, 9.32574570e-02f, 1.14402525e-01f, -1.17246956e-01f, -2.55717963e-01f, -3.24511528e-02f,
  1.41372323e-01f, -5.62265106e-02f, -2.08440259e-01f, -1.81068659e-01f, 2.87165400e-02f, -2.65201658e-01f, -4.50389199e-02f, 4.55906242e-02f, 7.20269606e-02f, 5.80113009e-02f,
  -1.43933252e-01f, 1.93431318e-01f, -9.77785885e-02f, -1.82334241e-02f, -1.06763821e-02f, -1.05242036e-01f, -7.38941133e-02f, -5.71414903e-02f, 5.74214347e-02f, -1.12817734e-01f,
  3.60641219e-02f, -4.62307930e-02f, -3.24191637e-02f, 1.57010760e-02f, 7.88856880e-04f, -2.03579869e-02f, -4.97710146e-03f, -6.34758994e-02f, 1.54242786e-02f, -8.75224732e-03f,
  1.95132121e-01f, 1.50963068e-01f, 1.40476480e-01f, 1.29983976e-01f, 6.71200873e-03f, -7.70118684e-02f, 7.41397440e-02f, -1.00620061e-01f, 5.19897789e-03f, -8.03782120e-02f,
  -3.73859182e-02f, -2.18384489e-02f, 4.55915146e-02f, 3.60457003e-02f, -6.51072115e-02f, -2.28678975e-02f, 1.93684839e-03f, 3.22081037e-02f, -3.36882472e-02f, -5.88569976e-03f,
  -1.83680002e-02f, 9.78203714e-02f, -4.30973284e-02f, 3.78118902e-02f, -9.04447678e-03f, 5.57900742e-02f, -3.10069807e-02f, 2.14247033e-03f, 8.00411329e-02f, -7.19757155e-02f,
  -9.51075088e-03f, 1.27051659e-02f, -1.53264413e-02f, -2.72480352e-03f, 5.39645441e-02f, 9.07148700e-03f, 9.08363238e-03f, 9.66078490e-02f, -6.11103624e-02f, 3.05110980e-02f,
  -1.95461482e-01f, 1.85832217e-01f, -1.29239187e-01f, 8.81889183e-03f, 3.38550545e-02f, 1.05398837e-02f, 1.76619589e-02f, 2.20498256e-02f, -3.93793359e-02f, 5.35829403e-02f,
  -1.44470790e-02f, 8.92605074e-03f, 4.34630811e-02f, -5.82739413e-02f, -1.12657718e-01f, -2.71978099e-02f, 2.82800104e-02f, 1.86748281e-02f, 1.17408223e-02f, 1.57393832e-02f,
  -1.11347316e-02f, -6.64461330e-02f, -7.66775906e-02f, 5.30839758e-03f, 3.55424136e-02f, -4.22470383e-02f, 1.88661236e-02f, -7.62918815e-02f, -3.99488322e-02f, -8.26218501e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.82025695e-01f, -7.27290139e-02f, -6.33847177e-01f, 1.25168175e-01f, -2.30170175e-01f, -2.31493741e-01f, -3.43051165e-01f, 1.23765208e-02f, 2.16012314e-01f, -2.74584264e-01f,
  -6.87864274e-02f, 1.39332280e-01f, -8.65015835e-02f, -6.19847216e-02f, -6.06434643e-02f, -3.92564923e-01f, -3.82193118e-01f, -3.49075139e-01f, -3.20578255e-02f, -4.14820500e-02f,
  -4.09071445e-02f, -2.38103811e-02f, -8.64974863e-04f, 1.89540297e-01f, -8.29377472e-02f, 1.56650856e-01f, -2.12520421e-01f, -1.53538212e-01f, -8.72592926e-02f, -2.20360190e-01f,
  -4.98244435e-01f, -4.10858765e-02f, -5.68364821e-02f, 7.57383034e-02f, -6.37895390e-02f, 4.92813475e-02f, -6.33907169e-02f, 4.97912318e-02f, 9.37110856e-02f, -7.78444530e-03f,
  4.89857979e-03f, 7.30897486e-02f, 1.04893662e-01f, 2.28884928e-02f, -3.10331937e-02f, -1.04328687e-03f, 6.90396279e-02f, -1.15816548e-01f, -6.49962276e-02f, 1.10434210e-02f,
  4.25172709e-02f, -5.55550382e-02f, -1.29542664e-01f, -3.37571055e-02f, 2.66106799e-02f, -7.66799673e-02f, -8.14984515e-02f, 4.81662080e-02f, -1.47910630e-02f, -7.67341256e-02f,
  -3.05654835e-02f, -7.17457309e-02f, -5.18488288e-02f, 6.01568557e-02f, 4.44128066e-02f, -2.18683165e-02f, 2.44837403e-02f, -1.86047740e-02f, -4.95596528e-02f, 5.49336383e-03f,
  -2.41312310e-02f, -1.51496651e-02f, 1.32921534e-02f, -2.35561337e-02f, -2.20488897e-03f, -1.06285274e-01f, 3.90682407e-02f, -2.67812815e-02f, 2.86097396e-02f, -4.43122163e-02f,
  2.26157662e-02f, 2.16941964e-02f, -5.02947494e-02f, 1.36711031e-01f, -3.62383612e-02f, -3.12298979e-03f, -7.49927014e-03f, 4.41330411e-02f, 4.08422388e-02f, -9.28412564e-03f,
  1.54628068e-01f, -8.27602390e-03f, -7.81590343e-02f, 6.01071268e-02f, 9.23413858e-02f, 3.99238393e-02f, 1.73203796e-02f, 5.87810129e-02f, 1.08509690e-01f, -2.93202754e-02f,
  -3.46400426e-03f, 5.99187240e-03f, -6.68054372e-02f, -2.58505829e-02f, 2.65356004e-02f, -2.18288656e-02f, 8.60588476e-02f, -4.47823573e-03f, 3.58831324e-02f, 5.64154647e-02f,
  7.72466790e-03f, -1.40356692e-03f, -2.97301784e-02f, -1.14796273e-02f, 2.99457293e-02f, 6.48626089e-02f, -3.80246304e-02f, -4.58484367e-02f, 3.46132889e-02f, 2.81724744e-02f,
  2.57489860e-01f, -3.10699254e-01f, -3.60405654e-01f, 4.78068925e-02f, -1.05062768e-01f, -2.29320582e-03f, -2.05949917e-02f, 2.15353921e-01f, 1.10852830e-01f, 2.09953859e-02f,
  1.14967123e-01f, 3.08750451e-01f, 2.85344031e-02f, 1.55962825e-01f, 1.00749746e-01f, -2.67403662e-01f, -2.62794048e-01f, -1.00630023e-01f, 1.63631782e-01f, 3.26894462e-01f,
  1.97347894e-01f, -8.08997452e-03f, 1.02769576e-01f, 1.45155683e-01f, -7.65686184e-02f, 3.13611664e-02f, -2.31865495e-01f, -9.74757895e-02f, 1.18714683e-02f, -3.73636723e-01f,
  -5.92689402e-02f, -2.02345550e-02f, 2.06978604e-01f, 5.73708378e-02f, -1.64728880e-01f, -3.24605708e-03f, 5.87421954e-02f, -9.83656347e-02f, 5.59517927e-03f, 5.99268936e-02f,
  -3.79530899e-02f, -4.67708781e-02f, 2.09431928e-02f, 7.20049515e-02f, -1.86124165e-02f, 5.39977700e-02f, 3.29402611e-02f, 7.36406669e-02f, 3.62173393e-02f, 5.22582531e-02f,
  8.18143338e-02f, -3.48196104e-02f, 1.03163891e-01f, 8.10973272e-02f, 7.27697760e-02f, 2.93398723e-02f, -5.81551758e-05f, 4.44063656e-02f, 8.19197670e-02f, -1.37445265e-02f,
  2.86393333e-02f, -7.43934363e-02f, 1.02899000e-02f, 1.17687741e-03f, 6.27966076e-02f, -2.48722807e-02f, -3.72561030e-02f, -3.58052216e-02f, 3.32961045e-02f, -9.06395912e-02f,
  4.86224964e-02f, -3.57651897e-02f, 4.25447449e-02f, 1.37536945e-02f, -4.23227437e-03f, 2.90760435e-02f, -8.71004909e-02f, 2.83702333e-02f, 6.58688396e-02f, 2.30791094e-03f,
  4.31866609e-02f, 4.06589406e-03f, -3.78496014e-02f, -2.87127215e-02f, 7.34309200e-03f, -1.34676090e-02f, 7.07566459e-03f, -2.08731852e-02f, 5.69087490e-02f, 2.04450097e-02f,
  7.27361441e-02f, -6.67166710e-02f, -4.53725308e-02f, 2.08081994e-02f, -3.42679285e-02f, -4.19301167e-02f, 4.50135805e-02f, 2.06135809e-02f, -7.82480165e-02f, 5.15546426e-02f,
  7.01961815e-02f, 5.62469400e-02f, -8.28748047e-02f, -5.59956655e-02f, -1.55942645e-02f, 5.55888414e-02f, -1.42730922e-02f, -7.12687224e-02f, 2.78466903e-02f, 3.81886289e-02f,
  -6.50310814e-02f, -6.05371371e-02f, -5.73716685e-03f, 4.01474498e-02f, -1.32176857e-02f, -5.05326241e-02f, -1.22016102e-01f, 5.06038731e-03f, -3.93440761e-02f, -1.24605253e-01f,
  3.74962449e-01f, -2.26192877e-01f, 4.95704025e-01f, 9.10233855e-02f, 1.36481538e-01f, 3.38592052e-01f, 2.13653669e-01f, 1.64263010e-01f, 7.89195597e-02f, 5.72374240e-02f,
  -2.58555770e-01f, -3.28850478e-01f, -3.07613343e-01f, -2.14784399e-01f, -1.60280257e-01f, 7.06358328e-02f, 9.02323797e-02f, 1.17045611e-01f, 3.01922590e-01f, 2.53013760e-01f,
  -1.68583289e-01f, 5.92121184e-02f, 3.63919549e-02f, 1.11667272e-02f, 1.03794634e-01f, -4.10269760e-02f, 5.92076480e-02f, -1.48352864e-03f, -8.73860791e-02f, 1.12182654e-01f,
  1.66033670e-01f, 1.47052437e-01f, -1.96929220e-02f, -2.02636078e-01f, -1.24139981e-02f, 3.38519402e-02f, -3.52453836e-03f, 1.09110422e-01f, -3.91927036e-03f, 8.90007243e-03f,
  -7.59543478e-02f, 2.68296096e-02f, -6.55597216e-03f, 4.95814309e-02f, 6.90634027e-02f, 5.05627692e-02f, 5.46001010e-02f, -7.68626900e-03f, 3.36630121e-02f, -4.70942445e-02f,
  -1.32355541e-01f, 3.73844244e-02f, 5.59664667e-02f, -2.56413426e-02f, 7.10941777e-02f, -1.06890768e-01f, -5.71280830e-02f, 7.95339271e-02f, -2.63223909e-02f, 6.09893017e-02f,
  -2.87090465e-02f, 3.98960011e-03f, 2.51741633e-02f, -6.39042957e-03f, 1.60775296e-02f, 5.57307936e-02f, 3.82507704e-02f, 5.49768321e-02f, 5.86520182e-03f, 7.32770413e-02f,
  3.51224095e-02f, 9.34883580e-02f, -1.06339052e-03f, 4.73466739e-02f, -6.23687617e-02f, 3.18558663e-02f, 1.02783129e-01f, -1.02915972e-01f, 1.98529921e-02f, -3.57891130e-03f,
  1.23500908e-02f, 5.44764437e-02f, -9.57388524e-03f, 4.83445004e-02f, -1.76318791e-02f, 6.24327399e-02f, 4.46266271e-02f, 1.96370333e-02f, -2.58675236e-02f, 2.22961623e-02f,
  -2.81949759e-01f, -2.22077742e-01f, 7.84170330e-02f, 1.99105442e-02f, 1.23531491e-01f, -8.57500210e-02f, -3.67460512e-02f, -9.60382298e-02f, -1.02866568e-01f, 5.05447164e-02f,
  -2.82491893e-02f, 1.54482210e-02f, -3.10719665e-02f, 3.63339521e-02f, 1.32168621e-01f, 3.15964259e-02f, -5.40407822e-02f, -3.78474370e-02f, -5.61960302e-02f, -2.19204351e-02f,
  -7.41093531e-02f, 3.36979479e-02f, -6.45030811e-02f, -4.64406908e-02f, -6.73089083e-03f, -8.92622769e-02f, -5.66544244e-03f, 1.93373468e-02f, -1.77832637e-02f, -7.72495661e-03f,
  1.06355742e-01f, -1.96674481e-01f, 1.18604004e-01f, -1.38546541e-01f, 1.63965613e-01f, 2.02556983e-01f, 1.63593307e-01f, 1.67554691e-02f, -3.68824974e-02f, -5.89040890e-02f,
  -8.68348330e-02f, -2.08786964e-01f, -9.35819522e-02f, -9.20056105e-02f, -4.55581509e-02f, -5.74453585e-02f, 9.28278863e-02f, 1.74150988e-01f, 1.48828834e-01f, -5.34773991e-02f,
  -5.51936515e-02f, -4.64027151e-02f, 4.08818461e-02f, -9.02961791e-02f, -1.29036412e-01f, 2.68209353e-02f, -4.53481339e-02f, 7.26217628e-02f, -1.32886861e-02f, -5.13472222e-02f,
  -9.33259949e-02f, 9.38665718e-02f, 1.27075076e-01f, -1.19059153e-01f, 6.81869090e-02f, 8.04855675e-03f, -4.06001396e-02f, -1.64133217e-02f, 5.56248473e-03f, -8.32061246e-02f,
  6.55519441e-02f, 5.10050133e-02f, -5.18431328e-03f, 1.09310143e-01f, 6.94996044e-02f, 1.20069161e-01f, -8.26666579e-02f, -1.55914709e-01f, -9.70986560e-02f, -7.78400479e-03f,
  -1.59124121e-01f, -3.57867591e-02f, 1.29847646e-01f, 1.84593927e-02f, -6.76038191e-02f, 5.10973260e-02f, -9.37569048e-03f, -3.84822674e-02f, -1.51292346e-02f, -7.47270957e-02f,
  -6.34937212e-02f, -3.14790122e-02f, 1.25077385e-02f, -9.08499435e-02f, -6.74973801e-02f, -1.02146953e-01f, -1.18439775e-02f, 2.04977486e-02f, 3.18760537e-02f, -5.90823255e-02f,
  -9.88221467e-02f, -1.99767370e-02f, -2.64959056e-02f, -1.15311742e-01f, -3.17953527e-03f, -2.18481496e-02f, 3.34767736e-02f, -2.58190129e-02f, 2.49828547e-02f, -1.25548327e-02f,
  -5.40477596e-02f, 4.29741442e-02f, 8.68878439e-02f, 6.87236199e-03f, -1.40882537e-01f, -5.54637760e-02f, -4.85616624e-02f, -2.99583059e-02f, 3.52329127e-02f, -3.55535373e-02f,
  -2.23542288e-01f, 1.97885767e-01f, -4.04160423e-03f, -6.76212683e-02f, 7.85897300e-02f, -1.85161363e-02f, -6.96542710e-02f, 9.33867320e-02f, 3.30572054e-02f, -6.38339743e-02f,
  -1.10473335e-02f, -9.93943810e-02f, -1.09706290e-01f, -9.53061506e-02f, 4.75280806e-02f, 2.53802892e-02f, -8.97480026e-02f, 7.78656080e-02f, 5.11397906e-02f, -7.07500428e-02f,
  -8.37660804e-02f, 2.77582817e-02f, 3.89268324e-02f, 1.83153637e-02f, -4.41119932e-02f, 1.27856672e-01f, 7.52461776e-02f, -2.87481174e-02f, 9.46242958e-02f, -2.68055834e-02f,
  4.57760066e-01f, 1.27062187e-01f, -7.26368055e-02f, 6.84727207e-02f, -2.91174442e-01f, -3.12326610e-01f, -4.72003162e-01f, -1.83003798e-01f, -7.46982470e-02f, -4.89626490e-02f,
  -6.14420660e-02f, 6.19300222e-03f, -2.68570296e-02f, 4.75531677e-03f, 7.72766322e-02f, -2.67409626e-03f, 1.01201907e-01f, 1.79538876e-01f, -4.86627519e-02f, -1.99194252e-01f,
  -1.18438900e-01f, 5.04264869e-02f, 3.25385898e-01f, -2.48207804e-02f, 1.35101750e-01f, 2.90785842e-02f, 3.18098776e-02f, 1.12198755e-01f, 1.35334057e-03f, 4.00925726e-01f,
  5.00206426e-02f, -2.35923324e-02f, -8.75421613e-02f, 7.38535449e-02f, -4.63533076e-03f, 9.57388356e-02f, -3.72995920e-02f, 3.71140465e-02f, -4.58994024e-02f, -4.51076031e-02f,
  5.02654864e-03f, -1.22003831e-01f, -2.16482184e-03f, -3.09592169e-02f, -8.59919470e-03f, -2.66081523e-02f, 1.16708994e-01f, 9.53496546e-02f, 1.02092810e-01f, 3.95221226e-02f,
  -1.21489465e-02f, -1.00515462e-01f, -5.59992902e-02f, -1.29779011e-01f, -3.37452181e-02f, 5.06139211e-02f, -9.31173190e-02f, 3.82372849e-02f, -7.88756385e-02f, 1.13751270e-01f,
  -4.82240431e-02f, 9.99200158e-03f, 2.44402210e-04f, -7.20052794e-03f, -2.33917348e-02f, -4.41098325e-02f, -8.46953019e-02f, -2.03604493e-02f, -1.39416326e-02f, -1.28171863e-02f,
  -1.30299255e-02f, 3.12574916e-02f, -9.92584322e-03f, 1.24985781e-02f, 2.36078128e-02f, -7.23237498e-03f, -9.34159681e-02f, 6.04682527e-02f, -7.06375344e-03f, -4.15708497e-02f,
  5.17843990e-03f, -3.60059477e-02f, 2.35749828e-03f, 3.67609411e-02f, 6.36687800e-02f, -2.28602532e-02f, -3.01217549e-02f, 1.88809652e-02f, 8.70446712e-02f, -6.55948604e-03f,
  -2.07096130e-01f, -7.87767917e-02f, 7.02508166e-03f, -8.83165840e-03f, -9.41948667e-02f, -3.25096063e-02f, -4.11738716e-02f, -2.25920454e-02f, -3.31429429e-02f, -9.21321288e-02f,
  -8.28029141e-02f, 6.01586215e-02f, -5.76342493e-02f, 2.91209873e-02f, -2.75023282e-02f, -8.35171044e-02f, 1.10832620e-02f, -7.81388655e-02f, -2.92185601e-02f, -4.24277857e-02f,
  3.82986851e-02f, -6.70044050e-02f, -1.69686973e-01f, -1.43001765e-01f, -8.18799436e-02f, -2.00800553e-01f, -8.85267258e-02f, -1.32376030e-01f, -1.15357853e-01f, -2.07312331e-01f,
  -4.00901765e-01f, 4.81199175e-02f, -1.80038825e-01f, 7.62406411e-03f, 6.23816624e-02f, -5.39344139e-02f, -2.60867387e-01f, 8.72116387e-02f, 4.40355763e-02f, -2.04319686e-01f,
  -1.42792836e-01f, -1.65254131e-01f, -1.83837965e-01f, -2.10225418e-01f, -3.35099638e-01f, -2.41488993e-01f, -3.84577453e-01f, -3.99768889e-01f, -1.06402382e-01f, 1.91269070e-01f,
  4.07439470e-03f, -3.15127909e-01f, -2.66473562e-01f, 4.72060964e-02f, 5.66454716e-02f, 9.87658948e-02f, -7.67153502e-02f, -4.96675149e-02f, 1.16345480e-01f, -7.60580450e-02f,
  -7.99446478e-02f, 2.30467319e-01f, -2.77884211e-02f, -3.79169546e-02f, 2.38226019e-02f, 8.20984766e-02f, -5.11544012e-02f, 2.03737449e-02f, -3.99235338e-02f, -4.35343646e-02f,
  -1.15043269e-02f, 2.86523625e-02f, -1.08177448e-02f, -5.32756783e-02f, -2.47152001e-02f, 3.32516222e-03f, 4.20658663e-02f, -1.61169305e-01f, -8.90816655e-03f, 3.68043445e-02f,
  -4.88494076e-02f, -2.63673849e-02f, 2.57284082e-02f, 2.30354778e-02f, 1.47211477e-02f, -9.38831642e-02f, 7.58127570e-02f, 1.52302891e-01f, 1.41304936e-02f, 1.72272697e-01f,
  -5.31901978e-02f, 7.10105151e-02f, -9.97933466e-03f, 7.37780407e-02f, -1.13299862e-01f, 4.05206494e-02f, -9.60849039e-03f, -7.20061688e-03f, 2.52769012e-02f, -7.82329366e-02f,
  -1.28320260e-02f, -1.28779151e-02f, -2.77594365e-02f, -3.84480469e-02f, 3.46383825e-02f, -4.64258492e-02f, -4.50400934e-02f, -2.35109646e-02f, 8.97218511e-02f, -4.36297916e-02f,
  1.77697148e-02f, 1.20716207e-01f, 1.00917919e-02f, 3.77667695e-02f, -2.16124654e-02f, -2.01157504e-03f, -6.05795830e-02f, 4.68702205e-02f, 1.12399928e-01f, -6.08953722e-02f,
  -4.53899466e-02f, -2.28529125e-01f, -5.71243726e-02f, -5.38125373e-02f, -4.83543752e-03f, 4.12871800e-02f, -8.58155340e-02f, -7.68651580e-03f, 1.70728900e-02f, -1.16937943e-01f,
  -4.30560112e-02f, -5.48059382e-02f, -3.09915058e-02f, 3.95380035e-02f, -2.85364836e-02f, -1.67661868e-02f, -1.42037170e-02f, -5.40288985e-02f, 4.05718684e-02f, 1.62864255e-03f,
  2.06541419e-02f, -1.13372784e-02f, -5.99727817e-02f, -1.15302406e-01f, 9.90844425e-03f, -2.88295001e-01f, -8.02997127e-02f, 2.71226838e-03f, -1.72845885e-01f, -2.36509517e-02f,
  -4.89738509e-02f, 2.28165358e-01f, -2.96217144e-01f, 1.96513444e-01f, 1.34240091e-01f, -1.94271840e-03f, -7.72768185e-02f, -1.66424885e-01f, 7.86723644e-02f, 7.47905821e-02f,
  9.03365463e-02f, 1.49213359e-01f, 1.42872944e-01f, -3.22767645e-02f, -1.86486036e-01f, 6.06353115e-03f, 1.42052576e-01f, -1.58492893e-01f, -2.04680517e-01f, -5.47026731e-02f,
  3.02645594e-01f, 8.56816173e-02f, -4.23282087e-02f, -7.55640343e-02f, 2.15156928e-01f, 1.86526492e-01f, -9.38840769e-03f, 1.77715600e-01f, 1.18200839e-01f, 4.51928049e-01f,
  9.40088555e-02f, -2.07204614e-02f, -8.02205130e-02f, 5.39926738e-02f, 6.19887598e-02f, 1.24416724e-02f, 1.19850435e-03f, 4.39666994e-02f, -5.08534089e-02f, -3.85168456e-02f,
  1.24718852e-01f, 1.05269412e-02f, 8.56972113e-02f, 7.72085041e-02f, -4.31855619e-02f, -3.12289596e-02f, -9.18988585e-02f, -2.22204030e-02f, -2.06681564e-01f, -6.55705035e-02f,
  1.96009457e-01f, 1.57878131e-01f, -9.99547169e-02f, -1.72255009e-01f, -7.40417242e-02f, 1.88130364e-02f, -4.57090279e-03f, -4.37690690e-03f, -1.06048703e-01f, 1.25323698e-01f,
  -1.45628424e-02f, 7.22773150e-02f, 3.00423186e-02f, 8.69784281e-02f, 1.98726058e-02f, 4.73480336e-02f, 1.89268440e-02f, 3.35730277e-02f, 5.52291796e-03f, 5.96459070e-03f,
  -3.89197539e-03f, -9.05450583e-02f, 2.09253225e-02f, -3.57862078e-02f, -8.92319754e-02f, 4.39384952e-02f, 6.81348667e-02f, -5.49895912e-02f, 4.28790879e-03f, 3.39488499e-02f,
  -4.27949894e-03f, 2.86820717e-02f, 6.98973835e-02f, 3.42226983e-03f, 2.81037278e-02f, 9.43014398e-02f, 4.58153524e-02f, -6.73094466e-02f, 2.99538448e-02f, 2.55876519e-02f,
  -8.47986084e-04f, -3.00347835e-01f, 1.49352491e-01f, -3.78913339e-03f, 2.66435035e-02f, -6.17270498e-03f, 5.49029000e-02f, -3.22862272e-03f, 6.48345053e-02f, -7.77725726e-02f,
  3.82499732e-02f, -2.33823489e-02f, -3.25751840e-04f, -3.22658531e-02f, -2.77494062e-02f, -3.64440456e-02f, 1.75908525e-02f, -5.97644458e-03f, -1.10569462e-01f, -2.52589341e-02f,
  -7.72897601e-02f, -1.55976892e-01f, -2.16392383e-01f, -8.64689201e-02f, 8.07954520e-02f, -8.89367461e-02f, -1.02439895e-01f, -8.53586495e-02f, -1.52808592e-01f, -2.04192594e-01f,
  7.47312427e-01f, -5.12783229e-01f, -7.42576867e-02f, 1.39077738e-01f, 3.72305028e-02f, 1.43582106e-01f, -1.74174473e-01f, -4.65674475e-02f, 1.70005858e-01f, -1.13171376e-01f,
  -7.30062202e-02f, 1.27651006e-01f, 2.11478934e-01f, 9.42025706e-02f, 1.42348409e-01f, -1.34670600e-01f, 3.34840044e-02f, 1.65984914e-01f, 2.56567538e-01f, 1.89075291e-01f,
  -5.40348813e-02f, -9.87484381e-02f, 7.32696652e-02f, 5.94147108e-02f, -1.71157375e-01f, 2.34180704e-01f, -1.00711711e-01f, -2.90452123e-01f, -1.73136681e-01f, -2.73989886e-01f,
  -3.50272423e-03f, -1.15750030e-01f, 1.56842291e-01f, 7.27608353e-02f, -9.44929868e-02f, 7.28366002e-02f, -2.07775682e-02f, -7.37760216e-02f, 1.47876777e-02f, -9.53487456e-02f,
  6.82964921e-02f, 1.42024327e-02f, 1.06099285e-01f, -9.43985060e-02f, -6.20560981e-02f, -3.72367143e-03f, -5.95468804e-02f, -1.03389658e-02f, 2.90487409e-02f, -9.03650820e-02f,
  -8.17864388e-02f, 3.12576555e-02f, -1.98608357e-02f, -1.70512106e-02f, 6.42054453e-02f, 4.97444682e-02f, -1.38413370e-01f, -9.73935425e-02f, 1.16285823e-01f, -5.05267009e-02f,
  -1.72672179e-02f, 6.50429726e-02f, 5.46365902e-02f, -8.83354396e-02f, -4.41386644e-03f, -2.03446373e-02f, -5.01335114e-02f, -3.86681817e-02f, 2.82618124e-02f, -5.63891307e-02f,
  -3.90667841e-03f, -3.06358724e-03f, -9.91515350e-03f, 1.76163483e-02f, 1.01058614e-02f, 2.79051941e-02f, 7.23279221e-03f, -8.80405714e-04f, 2.11326499e-02f, -4.51304670e-03f,
  6.66145654e-03f, 4.33604047e-03f, -5.82206585e-02f, -2.21233200e-02f, -1.51940435e-02f, -3.62210795e-02f, 6.78213611e-02f, 3.74589153e-02f, 1.86485350e-02f, 3.04220654e-02f,
  -2.15893686e-01f, 2.84079194e-01f, 1.15712188e-01f, -1.02265486e-02f, -1.38880368e-02f, -5.61380200e-02f, 3.13220881e-02f, -4.17071208e-02f, -8.73060673e-02f, -4.65815403e-02f,
  -6.18465059e-02f, 2.00299472e-02f, -5.72586805e-02f, -7.14640990e-02f, 1.80353280e-02f, 1.52859488e-03f, -1.13687344e-01f, 9.53130201e-02f, 9.20325145e-02f, -1.60286367e-01f,
  -3.15108523e-02f, 1.28495261e-01f, 1.21312991e-01f, 1.05517440e-01f, 3.60368453e-02f, 3.09257835e-01f, 1.12638101e-02f, -5.53733530e-03f, 2.04641283e-01f, -1.58806682e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.21289414e-01f, -3.84415761e-02f, 1.34855479e-01f, 1.65142387e-01f, 4.24441814e-01f, 1.68304414e-01f, 3.41147661e-01f, 9.77285653e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.68184504e-01f, -5.48461676e-01f, 2.37048611e-01f, -3.41114402e-01f, -1.17496490e-01f, 1.86647251e-01f, -2.70744115e-01f, -1.15670763e-01f, 4.99146551e-01f, 1.82715163e-01f,
  -2.56008804e-01f, -1.16105504e-01f, -9.35660973e-02f, 2.41727605e-01f, 3.28189880e-01f, 1.95756137e-01f, -3.28028053e-02f, -6.35108054e-01f, -2.81285755e-02f, -1.17497340e-01f,
  1.15392819e-01f, 3.98097992e-01f, -6.33099794e-01f, 5.57233453e-01f, -4.20550048e-01f, -1.26243699e-02f, 2.10453063e-01f, 1.00306988e-01f, 3.25845569e-01f, -5.56741834e-01f,
  5.07883906e-01f, -3.31569523e-01f, 7.07341433e-02f, 3.66938353e-01f, -1.23860642e-01f, -1.76205605e-01f, 3.02886188e-01f, -2.93094456e-01f, 2.80552804e-01f, -1.57566220e-01f,
  -3.76827270e-01f, -3.52567315e-01f, 2.20849905e-02f, 7.41503611e-02f, 1.65774107e-01f, -1.68308601e-01f, -2.21058160e-01f, -3.65859896e-01f, 2.11169198e-01f, 1.87488627e-02f,
  7.21306577e-02f, -1.36283711e-01f, -1.92376394e-02f, 3.08410138e-01f, -4.76268172e-01f, 4.39018071e-01f, -2.05561310e-01f, -3.01271349e-01f, 2.83280879e-01f, 3.83627921e-01f,
  1.70991614e-01f, -2.08318770e-01f, -1.16042122e-01f, -2.07197919e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.64305466e-01f, -1.37367129e-01f, 4.92308736e-01f, 4.37988132e-01f, 1.58045262e-01f, 4.97586727e-01f, -1.61767919e-02f, 2.88614541e-01f, 5.73260859e-02f, -3.39867860e-01f,
  -4.04347181e-01f, -3.55875939e-02f, 6.21810317e-01f, 2.19597995e-01f, 6.59895301e-01f, -2.81127542e-01f, 1.04989633e-01f, 4.01325464e-01f, 5.07824302e-01f, 3.79698396e-01f,
  -3.82197976e-01f, 3.49265069e-01f, 4.42604959e-01f, -1.41814113e-01f, 8.97646964e-01f, 6.08003497e-01f, -4.01032478e-01f, -3.91790599e-01f, -2.78221756e-01f, 9.48096037e-01f,
  2.36121729e-01f, 2.61090487e-01f, -6.86403289e-02f, 4.46834303e-02f, -1.84302166e-01f, -1.70610234e-01f, -2.44599327e-01f, -8.80996659e-02f, 7.09260106e-02f, -2.24378854e-02f,
  -1.61010846e-01f, 2.60200977e-01f, 3.45965207e-01f, -2.02663243e-01f, 1.36802271e-01f, 1.57838419e-01f, 3.05181384e-01f, 1.42583907e-01f, -8.06638226e-02f, 1.55440345e-02f,
  2.33734995e-01f, -2.42734611e-01f, 4.36423384e-02f, 1.60987508e-02f, -2.67975211e-01f, 3.70215178e-01f, -1.75315805e-03f, 1.88697517e-01f, 2.31116146e-01f, -8.73984583e-03f,
  2.98162282e-01f, 1.07892521e-01f, 5.53026140e-01f, -2.72318184e-01f, 3.80382836e-01f, 2.28865996e-01f, 6.62308097e-01f, 1.15581304e-01f, 4.21008945e-01f, 4.07060266e-01f,
  -6.14769995e-01f, -3.78451496e-01f, 4.76555437e-01f, -1.37690594e-02f, 1.35988474e-01f, -6.11218363e-02f, 6.19105577e-01f, 4.60961321e-03f, 1.23886354e-01f, 1.04189022e-02f,
  -1.35856867e-01f, -3.95132676e-02f, 3.16883057e-01f, 2.42231146e-01f, -1.72864020e-01f, -4.20220792e-01f, -3.19099814e-01f, -2.06747636e-01f, 4.57378209e-01f, 4.00891364e-01f,
  3.06350976e-01f, -1.31441921e-01f, -9.56939533e-03f, -2.30068877e-01f, -7.97527470e-03f, 7.59919763e-01f, 2.23516494e-01f, 5.13990700e-01f, 4.53196317e-01f, 4.59648073e-01f,
  2.95823246e-01f, -8.26066583e-02f, 1.11654662e-02f, -6.52717650e-01f, 3.45833153e-01f, 9.91954207e-02f, -5.64569011e-02f, -2.62106419e-01f, 5.16164482e-01f, -1.42876104e-01f,
  1.52388781e-01f, -1.11604944e-01f, 2.32330620e-01f, 4.28207308e-01f, 4.16015923e-01f, 4.75880116e-01f, 2.30523631e-01f, -4.05992478e-01f, -3.87170404e-01f, -5.31336904e-01f,
  3.66697192e-01f, 2.27351561e-01f, 6.75256848e-01f, 4.14560318e-01f, 4.17039156e-01f, -1.42545640e-01f, -2.81802937e-02f, 5.56696594e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.22738320e-01f, 5.41967511e-01f, -8.47349688e-02f, 4.24583972e-01f, 3.06495670e-02f, 1.12991840e-01f, 2.29718402e-01f, 1.02490000e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.65277535e-01f, 4.41750616e-01f, -1.51285259e-02f, 1.85671374e-01f, -1.35851920e-01f, -8.96418393e-01f, -2.60450363e-01f, -2.33140346e-02f, -3.64447683e-01f, 4.67757642e-01f,
  9.66901109e-02f, -3.52088735e-02f, -3.81780982e-01f, 5.04393160e-01f, -4.05150682e-01f, -1.11854494e-01f, 4.23270345e-01f, 7.23878201e-03f, 3.82445961e-01f, 2.03546196e-01f,
  -3.76599908e-01f, -6.64431928e-03f, 4.90675628e-01f, 1.91578701e-01f, 4.67902236e-03f, -3.85585457e-01f, 5.02633899e-02f, -2.25802455e-02f, 1.82762340e-01f, -3.34834397e-01f,
  7.39883304e-01f, 1.61609620e-01f, 2.20210716e-01f, -2.85879612e-01f, 4.49052125e-01f, 3.69229138e-01f, 3.30063224e-01f, 6.82186663e-01f, -1.78229883e-01f, 4.27081257e-01f,
  3.52761716e-01f, -5.56602299e-01f, 4.65834839e-03f, 6.59011006e-02f, 1.93917409e-01f, 9.08478498e-02f, 1.73435852e-01f, 5.77904359e-02f, 5.35160713e-02f, -1.08362004e-01f,
  3.59189361e-01f, 2.72508353e-01f, 4.92850877e-03f, 3.28656971e-01f, -1.39898688e-01f, 2.32294649e-01f, 5.22492528e-01f, -1.82997212e-01f, -2.03267008e-01f, 1.28539339e-01f,
  6.17426299e-02f, -5.26895404e-01f, -5.25929093e-01f, -4.80916768e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.23975933e-01f, -5.01079559e-02f, -2.58451700e-01f, -4.93847221e-01f, -1.16865471e-01f, 3.46438438e-01f, 1.10803470e-02f, -1.27090633e-01f, -4.50644530e-02f, 8.82416427e-01f,
  1.68520436e-01f, 2.42631778e-01f, 2.03626826e-01f, -2.34638214e-01f, -1.99746087e-01f, -5.50565660e-01f, 2.71505117e-01f, -2.15132982e-01f, -1.69596210e-01f, 3.71386141e-01f,
  8.45530748e-01f, -1.93840995e-01f, -8.06629360e-01f, -2.04240471e-01f, 1.07903373e+00f, 1.24675238e+00f, -6.17969781e-02f, 3.66850793e-01f, 5.59645295e-01f, -1.67142823e-02f,
  2.80003548e-01f, -5.07376850e-01f, -1.36994436e-01f, 4.50477935e-02f, 7.15915114e-02f, -1.03082769e-02f, -1.81290165e-01f, 1.26671176e-02f, 1.28364027e-01f, 2.37084508e-01f,
  -2.23330664e-03f, -3.65257524e-02f, -2.21138626e-01f, 1.73720777e-01f, -6.36096895e-02f, 1.87547460e-01f, -1.50833830e-01f, -3.31633203e-02f, 2.36995310e-01f, 7.39243776e-02f,
  -5.08736521e-02f, 1.89529538e-01f, 1.67112291e-01f, -1.47444323e-01f, -1.80055112e-01f, 1.36519507e-01f, 1.16992444e-02f, 3.32835376e-01f, 1.69301182e-02f, -1.60345554e-01f,
  -2.32060164e-01f, -3.26548189e-01f, -4.74533260e-01f, -1.14597723e-01f, -2.09151402e-01f, 1.99340925e-01f, -7.31100291e-02f, 5.49771003e-02f, 2.14542896e-01f, 1.27261937e-01f,
  -1.45031689e-02f, -1.81837904e-03f, -1.36255041e-01f, 5.37202895e-01f, -1.98919341e-01f, -1.90539911e-01f, -7.09878951e-02f, -1.79077178e-01f, -2.31795922e-01f, -1.74909115e-01f,
  2.91349620e-01f, 3.47872019e-01f, 3.87090921e-01f, 1.27455622e-01f, 1.26182377e-01f, 9.32124257e-01f, -3.24824661e-01f, 8.87880504e-01f, -2.38002818e-02f, -5.98531306e-01f,
  -6.23121951e-03f, 2.44172253e-02f, 1.18331194e+00f, 4.29189593e-01f, 4.89927948e-01f, 1.09162927e+00f, -4.64104533e-01f, -2.37740919e-01f, -4.44143057e-01f, -2.99457133e-01f,
  3.25606197e-01f, 8.06369185e-02f, -1.10844582e-01f, -1.73775047e-01f, -2.64744848e-01f, 1.70744076e-01f, 4.08373475e-01f, -6.46446412e-03f, 1.56559587e-01f, 6.57347560e-01f,
  1.21041641e-01f, 5.97665548e-01f, 4.29206461e-01f, 1.10595234e-01f, 3.93686682e-01f, 4.78973210e-01f, 2.05083877e-01f, 7.91773140e-01f, -3.71390343e-01f, 6.48002744e-01f,
  5.42577803e-01f, -1.54171824e-01f, 3.87442589e-01f, 7.97514260e-01f, -3.18624638e-02f, -2.51700282e-01f, -1.19658388e-01f, -3.11989039e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.15484834e-01f, 4.06535387e-01f, 1.10609137e-01f, -2.42975168e-02f, -1.77300394e-01f, 5.21145277e-02f, 1.39577687e-01f, 6.01368368e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.25009775e-01f, -5.44310689e-01f, -5.40413320e-01f, -7.26188898e-01f, 2.57573068e-01f, -6.43721163e-01f, 2.00451031e-01f, 6.70364559e-01f, 8.96967053e-01f, 2.57620484e-01f,
  1.63006000e-02f, -3.55266184e-01f, 3.76920342e-01f, -5.58490276e-01f, 2.32169360e-01f, -1.19703338e-01f, 2.24137485e-01f, 1.13473499e+00f, 6.79224968e-01f, 3.77623081e-01f,
  -7.40297362e-02f, -5.50914228e-01f, 2.91193306e-01f, 4.37408507e-01f, -3.03707033e-01f, -1.56245291e-01f, 1.62387397e-02f, -2.26088464e-01f, -1.64961189e-01f, 1.01293921e-01f,
  9.20744836e-01f, -3.21994543e-01f, 5.42996585e-01f, -1.47604203e+00f, 5.51165938e-01f, -8.30549896e-01f, -8.68507326e-01f, -2.71682292e-01f, 9.02005494e-01f, -3.50926965e-01f,
  -2.51212716e-01f, 8.67384151e-02f, 9.50757042e-02f, -1.13688655e-01f, -7.55789801e-02f, 5.84668577e-01f, -1.75350636e-01f, -4.49319273e-01f, -1.11809111e+00f, -7.61564150e-02f,
  -9.90207121e-02f, 1.18134248e+00f, 6.16193235e-01f, -7.06308424e-01f, -5.61554611e-01f, 7.70240277e-02f, 2.16850385e-01f, 5.61412752e-01f, -9.98855010e-02f, 5.85793495e-01f,
  2.78195858e-01f, -9.17381942e-01f, -6.68375969e-01f, 2.24516213e-01f, 4.86199200e-01f, 7.07872272e-01f, 3.26709896e-01f, -1.11131065e-01f, 1.97695475e-02f, -9.34053540e-01f,
  -7.24257708e-01f, -8.96815419e-01f, 3.95695448e-01f, 6.94282055e-01f, 4.88579348e-02f, -1.27010763e-01f, -1.55614942e-01f, -8.02166402e-01f, -1.71428546e-01f, -1.50688380e-01f,
  7.64821023e-02f, 4.83843505e-01f, 7.21894979e-01f, -1.15939999e+00f, 2.87623167e-01f, 6.16936207e-01f, 1.61777288e-01f, 5.65237224e-01f, -3.41522723e-01f, 6.43596947e-01f,
  6.57356158e-02f, -2.22679060e-02f, 4.79911864e-02f, -7.68089667e-02f, -2.83882581e-02f, -5.77196777e-01f, -7.94548333e-01f, -6.00345969e-01f, -5.58439136e-01f, -1.36117935e-02f,
  6.09403513e-02f, -6.18206918e-01f, -6.48686051e-01f, -2.72944778e-01f, -4.81362380e-02f, -7.20693231e-01f, 7.71465013e-03f, 1.70049876e-01f, -2.27149323e-01f, 9.10890102e-01f,
  -1.86560243e-01f, 2.55863041e-01f, 1.11466106e-02f, 3.88192773e-01f, -5.09349227e-01f, 1.81632414e-01f, -8.13975096e-01f, -4.56864566e-01f, 5.19756794e-01f, 1.47705722e+00f,
  4.84603010e-02f, 3.85202587e-01f, -1.56999305e-01f, -1.21995710e-01f, -3.04359257e-01f, -5.92897415e-01f, 1.55060709e-01f, 9.13868904e-01f, 4.82764244e-01f, -6.69554546e-02f,
  -1.96785647e-02f, -5.73045671e-01f, 7.95129240e-02f, 2.45388180e-01f, 6.20991945e-01f, -8.09311643e-02f, -2.61151761e-01f, -1.38583219e+00f, 8.57925564e-02f, 1.54786631e-01f,
  2.25513250e-01f, 1.05179214e+00f, 2.53425330e-01f, -9.22667384e-01f, -1.00001216e+00f, -4.41984147e-01f, -4.70410615e-01f, 9.52611268e-01f, -3.04546386e-01f, 2.16547668e-01f,
  2.83649266e-02f, 1.20476373e-01f, -4.30199265e-01f, 5.61433077e-01f, 8.72119665e-02f, -2.36091644e-01f, -1.36408404e-01f, 1.17142409e-01f, -2.99347609e-01f, 3.16072613e-01f,
  6.51688755e-01f, 9.98451263e-02f, 1.13587248e+00f, -2.60913968e-01f, 8.86539519e-01f, 1.22498429e+00f, -9.76016700e-01f, -1.30488396e+00f, -4.78497669e-02f, 3.14101934e-01f,
  -7.51404613e-02f, 1.36512071e-01f, -2.45167360e-01f, -8.83791685e-01f, -4.08712439e-02f, -2.53415346e-01f, 3.36053193e-01f, -1.09416388e-01f, -3.13932896e-01f, 1.32829726e+00f,
  -6.47416592e-01f, 5.38336933e-01f, 6.18650675e-01f, -3.59527797e-01f, -3.01527858e-01f, -1.04722095e+00f, 2.71422058e-01f, -3.46392766e-02f, 1.28822893e-01f, 6.09924912e-01f,
  -2.57916301e-01f, 7.78295517e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.55528766e-01f, 5.02499700e-01f, 1.03700392e-01f, 3.23382020e-01f, -3.58880609e-01f, 2.57547736e-01f, -3.15323621e-01f, -2.63317805e-02f, -3.10737193e-01f, -3.10975522e-01f,
  1.00826418e+00f, 1.75440863e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    