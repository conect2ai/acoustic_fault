/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.21954477e-01f, 5.77958785e-02f, 4.75695319e-02f, -1.58936694e-01f, 6.77137822e-02f, -7.63234571e-02f, -1.73782483e-02f, -7.60485455e-02f, -1.62362725e-01f, -4.67057899e-02f,
  -8.85180980e-02f, -1.94234341e-01f, -1.34980053e-01f, -6.23150729e-02f, -1.03513315e-01f, 1.26640782e-01f, 1.79573461e-01f, -1.40624911e-01f, -1.94322810e-01f, 2.87187900e-02f,
  9.19564888e-02f, -9.96637717e-02f, -1.77270859e-01f, -8.99673179e-02f, 7.74933994e-02f, 5.59263816e-03f, 2.30114125e-02f, -8.46049339e-02f, 6.54659793e-02f, 1.22343928e-01f,
  -2.51296833e-02f, -2.90717512e-01f, -3.33800130e-02f, -8.28131512e-02f, -4.00907174e-02f, -1.35377795e-01f, -7.83177540e-02f, -1.26235366e-01f, -6.48667067e-02f, 1.76082626e-02f,
  -7.51609877e-02f, -1.53370187e-01f, -1.48844451e-01f, -1.38294011e-01f, -7.24779442e-02f, -4.61345613e-02f, -1.35378480e-01f, -5.51122203e-02f, -1.40046194e-01f, -7.43524507e-02f,
  6.65420964e-02f, -1.22188754e-01f, -9.88285616e-02f, -8.58745426e-02f, -1.55957460e-01f, -2.08304226e-01f, -1.36641532e-01f, -2.31125981e-01f, -1.80819750e-01f, -4.40325178e-02f,
  7.66798034e-02f, 1.95354968e-02f, 3.72225754e-02f, 3.77245732e-02f, 2.66747139e-02f, 3.23706269e-02f, 8.37651193e-02f, 1.44314229e-01f, 6.86551351e-03f, 3.82478945e-02f,
  3.43936384e-02f, -1.38396518e-02f, 5.64972125e-02f, 5.19386046e-02f, 9.37120840e-02f, 4.58729491e-02f, 8.64866097e-03f, 1.07985653e-01f, -3.22024152e-03f, 6.14154004e-02f,
  7.82520790e-03f, 6.30828887e-02f, 2.80688051e-02f, 4.68520932e-02f, -7.08222389e-03f, 2.47889608e-02f, 7.20377173e-03f, -2.28633098e-02f, 9.64365825e-02f, 1.53356316e-02f,
  4.91292961e-02f, -2.43436038e-01f, 7.12075159e-02f, -3.60969342e-02f, -1.11815274e-01f, -5.68115972e-02f, -2.77018715e-02f, -7.64438137e-02f, -6.12540916e-02f, -7.33327642e-02f,
  -1.44070506e-01f, -9.41768140e-02f, -1.34048522e-01f, -9.42417383e-02f, -7.10925981e-02f, -8.10818598e-02f, -2.27953419e-02f, -7.70907998e-02f, -1.09896734e-01f, -7.71375820e-02f,
  -6.80126250e-02f, 3.93819297e-03f, -1.14089094e-01f, -6.76861480e-02f, 2.12536356e-03f, -5.41111082e-02f, -8.37987382e-03f, -8.72367099e-02f, -1.36407927e-01f, 7.38008618e-02f,
  -1.00950943e-02f, -1.77233532e-01f, -6.38748929e-02f, 1.50729269e-01f, 5.30776307e-02f, -1.23406239e-01f, 1.23224044e-02f, -2.48461530e-01f, -6.90280870e-02f, -1.62779838e-01f,
  -3.77314836e-02f, -9.12024304e-02f, -2.33973131e-01f, -1.55743390e-01f, -1.14079259e-01f, -7.56162554e-02f, 6.64438605e-02f, -1.34305969e-01f, -7.45440573e-02f, -1.24584928e-01f,
  -2.40655001e-02f, -1.07483065e-03f, -4.07533208e-03f, -1.52164012e-01f, 1.42682083e-02f, -5.48105277e-02f, -2.61411835e-02f, -1.20351603e-02f, -1.18759200e-01f, -1.41818477e-02f,
  -6.89692721e-02f, 1.94993634e-02f, -3.41765210e-02f, -6.33319244e-02f, 4.35374863e-02f, -1.21720396e-01f, 2.33708993e-02f, -4.30253185e-02f, -1.31058380e-01f, 3.18571031e-02f,
  2.36166883e-02f, -9.32359621e-02f, -1.71572976e-02f, -5.14806360e-02f, 3.23665775e-02f, 6.10417388e-02f, -5.14258109e-02f, -1.10759370e-01f, -1.43751338e-01f, -9.77215096e-02f,
  1.91454252e-03f, 1.20953314e-01f, 6.24332279e-02f, -7.52165541e-02f, -1.02357231e-01f, -7.35952035e-02f, -8.62703621e-02f, -7.52533823e-02f, -1.49878725e-01f, -1.17994845e-01f,
  1.09833188e-01f, 3.68414633e-02f, 2.98501980e-02f, 4.30454500e-02f, -1.60656311e-02f, 4.62498777e-02f, 3.45160440e-02f, 3.24385613e-02f, 5.10670207e-02f, 1.38409555e-01f,
  5.09341881e-02f, 9.88660729e-04f, 1.32131334e-02f, 2.32038554e-02f, 4.43988889e-02f, 7.60153085e-02f, -5.09639904e-02f, 7.09561482e-02f, -6.54122829e-02f, -2.57352758e-02f,
  7.98436850e-02f, -1.36830276e-02f, 5.16056977e-02f, -7.65852705e-02f, 1.23158451e-02f, 1.06197791e-02f, 9.57683846e-02f, 4.75983880e-02f, 3.49611863e-02f, 1.01410985e-01f,
  -8.70224535e-02f, -1.49567068e-01f, -6.48031384e-02f, -8.32298025e-02f, -1.62863545e-02f, -2.02160433e-01f, -1.26549425e-02f, -1.36928558e-01f, -3.58711667e-02f, -1.31397411e-01f,
  -8.38128254e-02f, -1.30106390e-01f, -2.35750470e-02f, -1.11681551e-01f, 2.40819585e-02f, -1.29951015e-01f, 3.28314304e-03f, -2.97686886e-02f, -3.20011154e-02f, -1.15653574e-01f,
  -2.53149029e-02f, -1.19135641e-01f, -8.81232470e-02f, -5.03340811e-02f, -6.32156665e-03f, -1.06915556e-01f, -2.01363355e-01f, -9.97312739e-02f, -1.05346195e-01f, -2.40488037e-01f,
  2.99081385e-01f, -1.35441303e-01f, -3.44190598e-02f, 1.52897894e-01f, 1.78553790e-01f, 7.71102682e-02f, -9.31351185e-02f, 6.11695498e-02f, 2.44498551e-01f, -4.46139723e-02f,
  9.82820913e-02f, 3.08796436e-01f, 1.07094109e-01f, 1.09267808e-01f, 1.62050784e-01f, -1.50697259e-02f, -7.56253302e-02f, 1.12956986e-01f, 2.40501657e-01f, 2.56517023e-01f,
  1.43119246e-01f, 1.46305561e-01f, 2.88905770e-01f, 1.93051890e-01f, 6.06045946e-02f, 8.86781290e-02f, 1.23114502e-02f, -6.02591410e-03f, 2.09983299e-03f, -1.74617082e-01f,
  -5.97308688e-02f, -9.74284708e-02f, 1.11267820e-01f, -9.06375144e-03f, 1.34456111e-02f, 1.78385805e-02f, 3.04118823e-02f, -2.00032489e-03f, 3.72258760e-02f, -2.96661332e-02f,
  4.37214151e-02f, 1.19801946e-01f, -3.80580649e-02f, 1.88724454e-02f, 7.53274336e-02f, 1.02371454e-01f, 9.52019617e-02f, 1.28944861e-02f, 1.02570847e-01f, 2.18832996e-02f,
  -3.59720580e-04f, 5.86602353e-02f, 2.30842624e-02f, -4.87923436e-02f, -8.66506174e-02f, 7.63862208e-02f, -3.38482112e-02f, -3.44864875e-02f, 3.03793289e-02f, -3.04999184e-02f,
  1.76628679e-02f, -7.15762228e-02f, 1.97918229e-02f, -1.00894786e-01f, -4.49730903e-02f, 1.40992226e-02f, -4.18762229e-02f, -1.23143397e-01f, 3.75540555e-02f, -4.28971983e-02f,
  -6.50212467e-02f, -8.33761916e-02f, -1.06948078e-01f, -9.03326571e-02f, 1.78243581e-03f, -2.67727599e-02f, -8.18613172e-02f, -1.03797968e-02f, -3.89829837e-02f, -6.66656867e-02f,
  -1.31360933e-01f, -1.87975541e-02f, -1.57984644e-01f, 8.89466237e-03f, -7.57460892e-02f, -1.33412048e-01f, -4.63715158e-02f, -8.98848474e-02f, -2.66564898e-02f, 2.06079893e-02f,
  1.66741669e-01f, 1.12502389e-01f, -4.91283275e-02f, 2.70625688e-02f, 6.24942780e-02f, 8.04356784e-02f, 9.36240107e-02f, 5.98431043e-02f, 2.14420184e-02f, 9.87017453e-02f,
  6.01926781e-02f, 1.52128592e-01f, 3.21846940e-02f, 4.91017997e-02f, 8.33506882e-02f, 1.24221131e-01f, 7.32559189e-02f, -3.32580544e-02f, -2.39723385e-03f, 8.18826929e-02f,
  1.69233829e-02f, 1.36469200e-01f, 1.87047318e-01f, 7.60096312e-02f, -3.16722021e-02f, 1.64409578e-01f, 3.78748551e-02f, -1.52846128e-02f, 9.68772396e-02f, 7.35136941e-02f,
  2.79602736e-01f, -1.63045272e-01f, -5.44332378e-02f, 2.44954042e-03f, -1.36370003e-01f, -8.25919881e-02f, -1.13908738e-01f, 4.09370326e-02f, 1.03180565e-01f, -1.74649715e-01f,
  -1.37454689e-01f, 1.02612093e-01f, 7.60217309e-02f, 2.02908292e-01f, 2.05405861e-01f, -1.99591205e-01f, -4.12488282e-02f, 2.38318905e-01f, 3.43301535e-01f, 1.42329689e-02f,
  -9.22198892e-02f, 3.68098170e-02f, 2.54507780e-01f, 1.02708876e-01f, -2.00517908e-01f, -2.89883967e-02f, -1.85964152e-01f, -1.04941159e-01f, -2.00721979e-01f, -2.25114629e-01f,
  -1.51415393e-01f, -1.41459048e-01f, 1.04843572e-01f, -4.51378636e-02f, -8.62642974e-02f, 8.28196034e-02f, 2.47317664e-02f, 6.00290373e-02f, 6.88828304e-02f, 4.51945774e-02f,
  -5.64416163e-02f, 4.26502861e-02f, -4.96236235e-02f, 8.04411131e-04f, -1.35664223e-02f, 6.54446110e-02f, -1.47541203e-02f, 1.13434404e-01f, 9.13286135e-02f, -5.91413751e-02f,
  -5.06431684e-02f, -1.66134864e-01f, -4.30516340e-02f, -4.75329459e-02f, 6.34490028e-02f, 9.98807605e-03f, -1.14257164e-01f, -6.72541633e-02f, -6.55488018e-03f, 1.90941133e-02f,
  -5.31362034e-02f, -5.20381741e-02f, -1.30066564e-02f, 4.41838689e-02f, -1.27358101e-02f, -4.95049311e-03f, 2.29129773e-02f, 7.62353279e-03f, -1.38280401e-02f, 3.77489291e-02f,
  -4.78260629e-02f, -3.72959003e-02f, 3.44022289e-02f, -6.27063215e-02f, 2.06322800e-02f, -6.71182200e-02f, -9.14979577e-02f, -3.34938653e-02f, -8.76855385e-03f, -1.73517391e-02f,
  7.60049745e-02f, -1.34919360e-02f, -9.53510683e-03f, 9.55047831e-03f, -7.98707530e-02f, 4.25680317e-02f, -1.37809766e-02f, 3.75194922e-02f, 5.41134328e-02f, -1.88543405e-02f,
  1.29665703e-01f, 1.17401257e-01f, -1.42182820e-02f, 8.40666294e-02f, 2.38732956e-02f, 4.58843298e-02f, 5.29867150e-02f, 4.68657585e-03f, 2.15351991e-02f, -8.24035797e-03f,
  -1.92115158e-02f, 9.10281539e-02f, 6.60722777e-02f, 5.00471368e-02f, 5.69501407e-02f, -3.50335817e-04f, -4.46248502e-02f, -3.68786044e-03f, -2.15831376e-03f, -6.08931482e-02f,
  6.29943283e-03f, 8.92325640e-02f, 7.37618804e-02f, 9.11218897e-02f, -1.01172607e-02f, 1.11627497e-01f, 8.84589776e-02f, -3.43815424e-03f, 1.91339374e-01f, 1.34545872e-02f,
  3.97399634e-01f, -6.73129708e-02f, -1.32905453e-01f, 2.81071723e-01f, -2.10745424e-01f, -3.21882993e-01f, -2.53363520e-01f, -1.02812812e-01f, 8.44441354e-02f, -8.93434882e-03f,
  2.47813482e-02f, 2.66183436e-01f, 1.71601564e-01f, 7.45791867e-02f, 1.30911162e-02f, -2.69824326e-01f, -5.61470650e-02f, -2.19148630e-03f, 2.54584160e-02f, -8.05078223e-02f,
  -3.48632596e-02f, 1.21631220e-01f, 1.74548522e-01f, 1.22082017e-01f, 1.65348962e-01f, 7.97042623e-02f, 2.24720091e-02f, -7.94236362e-03f, -4.24799398e-02f, 1.94880903e-01f,
  -2.01359950e-02f, 6.42109588e-02f, 1.96466618e-03f, 2.05813572e-01f, 2.82911994e-02f, 4.95960191e-02f, -1.24773476e-02f, 9.72696766e-03f, 8.87368694e-02f, 2.68936548e-02f,
  1.42776206e-01f, 1.50047868e-01f, 1.52627140e-01f, 3.84960510e-02f, 3.66661921e-02f, 2.95561785e-03f, 9.15198848e-02f, 1.21384121e-01f, -4.30454947e-02f, 2.01646201e-02f,
  1.13105876e-02f, 3.41363959e-02f, -7.79803377e-04f, -3.83917503e-02f, 7.49460608e-02f, 6.57604858e-02f, -2.87531130e-02f, 7.46393949e-02f, -4.15506437e-02f, 1.42618222e-02f,
  -4.88148853e-02f, 1.08170686e-02f, -2.62027998e-02f, -6.67283125e-03f, 1.61109194e-02f, -3.61170471e-02f, -1.20729348e-02f, -7.10185245e-02f, -6.65058102e-03f, -3.76346968e-02f,
  -2.76173949e-02f, -1.20631017e-01f, 1.03366245e-02f, -3.14613841e-02f, -2.14602519e-02f, -3.08317225e-02f, -9.31899622e-03f, -1.80909000e-02f, 2.19740588e-02f, -1.63997039e-02f,
  3.54471244e-02f, -3.73009369e-02f, 2.92220581e-02f, 1.55354599e-02f, 1.48983498e-03f, 1.36619210e-02f, -3.53759795e-04f, -8.03399011e-02f, 3.47288735e-02f, -1.46591645e-02f,
  8.66305754e-02f, -1.14367995e-02f, 7.33525828e-02f, 8.68579671e-02f, 3.40747498e-02f, 8.83748978e-02f, 5.21164760e-02f, 2.17654579e-03f, 7.24776909e-02f, -2.79561654e-02f,
  3.60000134e-02f, 3.22567038e-02f, -2.81005409e-02f, 1.24550723e-02f, -1.96113698e-02f, 1.08340746e-02f, 4.11371589e-02f, 6.50320053e-02f, 7.37748854e-03f, -5.31082749e-02f,
  -2.43016444e-02f, -4.92129810e-02f, 7.03807697e-02f, -1.82279572e-02f, 1.13069341e-02f, 1.01354599e-01f, -1.44067826e-02f, -4.86734249e-02f, -4.70449999e-02f, -1.93232130e-02f,
  -2.35987410e-01f, 2.95636296e-01f, 2.38791496e-01f, -3.59754963e-03f, 6.06794022e-02f, -1.43968523e-01f, -5.86421601e-02f, -3.77598330e-02f, -8.23557973e-02f, 9.30877775e-02f,
  1.45230398e-01f, -4.08505648e-02f, 4.01932411e-02f, -1.66725367e-02f, -4.09397595e-02f, 1.00032315e-01f, 1.02782346e-01f, -1.08470894e-01f, -2.61537671e-01f, -1.89305812e-01f,
  -6.01518713e-02f, -6.57803416e-02f, -8.60707462e-03f, 4.03355435e-02f, 5.81453554e-02f, 2.41183247e-02f, 1.49234056e-01f, 5.78813404e-02f, 2.39966005e-01f, 2.06083819e-01f,
  9.84843299e-02f, 1.66073009e-01f, -6.98493645e-02f, -1.57745909e-02f, 3.64559367e-02f, 1.72692239e-02f, -2.68325023e-02f, 3.93859074e-02f, 6.82696477e-02f, 5.71936890e-02f,
  6.24190085e-02f, -8.98543671e-02f, -5.17419726e-02f, -4.57699634e-02f, 7.23354146e-02f, -5.44045195e-02f, 7.00578094e-02f, -8.43166783e-02f, 7.66831264e-02f, 3.71928364e-02f,
  1.59190260e-02f, 8.96511674e-02f, -2.49664262e-02f, 4.35416885e-02f, -1.51903862e-02f, -5.54636754e-02f, -1.73702110e-02f, -3.70745249e-02f, 2.07115281e-02f, 2.95879785e-02f,
  -1.15447059e-01f, 1.06189311e-01f, 1.12549245e-01f, 1.16033249e-01f, -3.07706147e-02f, 2.14840882e-02f, 2.30687484e-02f, 1.12715341e-01f, -2.35440526e-02f, 3.84759642e-02f,
  5.55743501e-02f, 3.61432843e-02f, 7.94248879e-02f, -2.00781859e-02f, 8.70591030e-02f, 1.02051422e-01f, 6.86399289e-04f, 1.23287961e-01f, 1.19630948e-01f, 6.66952953e-02f,
  7.03104585e-02f, 8.39407668e-02f, 3.60024571e-02f, 8.66781026e-02f, 5.85599132e-02f, 8.75545070e-02f, 6.46592081e-02f, 1.09725446e-03f, 5.74463904e-02f, 9.13482606e-02f,
  -1.66131631e-01f, 1.16985757e-02f, -8.98036137e-02f, -2.30132584e-02f, -4.01355103e-02f, 1.41222831e-02f, 8.71016979e-02f, -2.87476052e-02f, 2.05108966e-03f, -2.42526419e-02f,
  -1.39468424e-02f, 2.37262417e-02f, -4.93099205e-02f, 7.13706808e-03f, -9.27064568e-02f, 1.87245687e-03f, -4.35695089e-02f, -7.52450153e-02f, 6.98455572e-02f, 1.40234753e-02f,
  2.84647774e-02f, -9.96446460e-02f, -1.19605817e-01f, -5.42905554e-02f, -1.89540051e-02f, -1.54537842e-01f, -7.81763569e-02f, 3.45561579e-02f, -1.08514927e-01f, -1.66333124e-01f,
  3.27709317e-01f, -7.33653009e-02f, 3.54281105e-02f, 1.12399578e-01f, -1.66571915e-01f, -1.26329109e-01f, -1.26814783e-01f, 8.86491686e-02f, 1.68069999e-03f, -3.94297093e-02f,
  1.68674663e-02f, 1.08373582e-01f, 1.18493721e-01f, 5.37006073e-02f, -5.31511381e-02f, -8.42844248e-02f, -7.96951354e-02f, 6.84883166e-03f, 1.80302173e-01f, 2.80888733e-02f,
  -1.10781580e-01f, -7.06445798e-02f, 2.09956780e-01f, 7.42571354e-02f, 4.88530248e-02f, -4.05827165e-02f, -1.12424336e-01f, -3.85299660e-02f, -1.00764073e-01f, -1.52057111e-01f,
  1.92488059e-01f, 3.43977585e-02f, -1.85386673e-01f, -1.12093568e-01f, -8.62466451e-03f, 5.42229973e-03f, -1.22658767e-01f, 2.63305418e-02f, -4.52998094e-03f, 1.21230287e-02f,
  2.75397729e-02f, -8.33318233e-02f, -4.86999080e-02f, -9.65258628e-02f, -7.91175663e-02f, -4.57947999e-02f, -6.61718696e-02f, 1.20763682e-01f, 4.67629507e-02f, -1.32246809e-02f,
  -6.47763014e-02f, -4.65595759e-02f, -9.56728682e-03f, -6.00823574e-02f, -4.68373671e-02f, -1.24403492e-01f, -3.72120552e-02f, 1.54777700e-02f, -9.78585333e-02f, -1.07950717e-02f,
  -8.76723826e-02f, 1.43291146e-01f, 2.91726571e-02f, 1.31138623e-01f, 8.91897604e-02f, 3.43714058e-02f, 2.55201906e-02f, 1.23252891e-01f, -4.27009873e-02f, 1.00236773e-01f,
  1.01723328e-01f, 3.07284240e-02f, 6.04209909e-03f, -5.71785681e-03f, 6.77539334e-02f, 1.02862775e-01f, 2.81386562e-02f, 4.84107062e-02f, 1.29155163e-02f, 8.62045735e-02f,
  6.94912374e-02f, 1.51770458e-01f, 2.99379323e-02f, 3.72415967e-02f, 1.21648073e-01f, 4.42304015e-02f, 6.04744069e-02f, 6.55651242e-02f, 6.21449724e-02f, 4.53577265e-02f,
  6.51702583e-02f, -1.32581651e-01f, 8.47070944e-03f, -1.16381329e-02f, -1.17899507e-01f, -5.25425263e-02f, -9.70106646e-02f, -9.66773182e-02f, -2.01289440e-04f, -5.01029082e-02f,
  -1.17331091e-02f, 6.54785931e-02f, -3.67165767e-02f, -3.16322260e-02f, 2.00817045e-02f, -4.06506769e-02f, -9.33408216e-02f, 3.23529392e-02f, -6.72929212e-02f, 3.30635789e-03f,
  -1.38080895e-01f, -8.39546621e-02f, 4.55167778e-02f, -9.35816541e-02f, -8.50540325e-02f, -8.69893059e-02f, -3.06246765e-02f, -5.09275757e-02f, -2.54835170e-02f, -6.44745678e-02f,
  2.00216919e-01f, -5.52188531e-02f, 1.36501417e-01f, 1.36191800e-01f, 1.23858348e-01f, -1.22808129e-01f, -3.25613953e-02f, -1.73307538e-01f, 4.38091047e-02f, -4.90222909e-02f,
  -4.11087610e-02f, 6.55506030e-02f, -1.07778572e-02f, -1.03642687e-01f, -5.35952970e-02f, 1.61717553e-02f, 1.92656934e-01f, 1.68094605e-01f, 2.47957911e-02f, 4.57249203e-04f,
  1.09930530e-01f, 5.21838404e-02f, 1.26289964e-01f, 7.13227615e-02f, -9.42606758e-03f, 6.62357733e-02f, 8.69859233e-02f, 3.47582214e-02f, 4.83395122e-02f, 1.55165583e-01f,
  4.01164182e-02f, -4.48790267e-02f, 6.87458888e-02f, 1.08559929e-01f, -5.09860925e-02f, 5.25536761e-02f, -4.17868868e-02f, -7.10285529e-02f, -9.28798616e-02f, -6.53831661e-02f,
  -2.93197706e-02f, 1.64336665e-03f, 6.26713485e-02f, 2.91544497e-02f, 1.45668946e-02f, 8.79558697e-02f, 4.85899337e-02f, -1.93674937e-02f, 3.04624457e-02f, -1.57983061e-02f,
  5.44109680e-02f, 4.45446335e-02f, -4.44872603e-02f, -1.23917952e-01f, -4.17648405e-02f, 6.19685557e-03f, -3.12331021e-02f, -4.88612242e-02f, -1.26787990e-01f, -1.83530860e-02f,
  -7.64179304e-02f, -1.11178979e-01f, -4.52513061e-02f, 1.94180608e-02f, 2.70204395e-02f, -6.72775805e-02f, 5.61013222e-02f, 4.97363554e-03f, 4.11492586e-02f, -6.10130168e-02f,
  -1.49645226e-03f, 6.71340898e-02f, -3.46629159e-03f, 1.49289751e-02f, -1.33082950e-02f, 1.18320487e-01f, 5.00941183e-03f, -1.08014364e-02f, 3.38916779e-02f, -3.06639392e-02f,
  2.87806671e-02f, 1.68711152e-02f, -3.31652313e-02f, 4.91214134e-02f, 2.62445640e-02f, 9.74335447e-02f, 5.63512109e-02f, -2.21711677e-02f, 7.45554939e-02f, 5.29259071e-03f,
  7.50772282e-02f, -9.72321033e-02f, 1.40604794e-01f, -1.11304745e-02f, 9.08898562e-02f, -6.95531666e-02f, 1.28994593e-02f, -3.06407623e-02f, 9.48157609e-02f, 1.14567310e-01f,
  3.50219943e-02f, 7.95375090e-03f, 4.15390469e-02f, -8.29681456e-02f, 5.47593459e-02f, -1.67044234e-02f, -8.47391412e-03f, 8.41637701e-02f, 2.95801871e-02f, -4.59753238e-02f,
  -5.37848473e-02f, -1.78973936e-02f, -5.40772639e-02f, -1.07199773e-01f, -8.34778696e-03f, -1.74188539e-02f, -6.66496158e-02f, -1.99116748e-02f, 3.15505229e-02f, -4.49445769e-02f,
  -4.53125775e-01f, -2.47851685e-01f, -9.04579535e-02f, -2.37941116e-01f, -7.92665705e-02f, -1.66694447e-02f, -1.67114556e-01f, -1.35805532e-01f, -4.03921567e-02f, -5.78416325e-02f,
  1.14875741e-01f, 1.20445997e-01f, -1.48732020e-02f, -4.77383174e-02f, -1.74242809e-01f, -2.41236791e-01f, -3.08011860e-01f, -1.73352018e-01f, -1.89532079e-02f, 4.97008264e-02f,
  -7.60071650e-02f, -6.10542335e-02f, -5.32588996e-02f, -4.10216898e-02f, -5.74999228e-02f, 6.62390143e-02f, -9.64583755e-02f, -9.51526612e-02f, -1.05063252e-01f, -2.53291935e-01f,
  -9.09605399e-02f, -5.92115372e-02f, -2.71506216e-02f, -8.73587281e-03f, 1.62875261e-02f, -8.72965902e-02f, -6.81879446e-02f, -3.24895643e-02f, 3.52764763e-02f, -2.01053917e-02f,
  -4.85804081e-02f, -6.31644204e-02f, -6.13288544e-02f, 7.55887777e-02f, -8.82220939e-02f, -1.02697700e-01f, -5.64651191e-02f, -1.26330510e-01f, -1.18237570e-01f, -7.05003738e-02f,
  -1.51524041e-02f, 5.71209900e-02f, -1.29062548e-01f, -2.90291496e-02f, 3.33042927e-02f, -6.71336427e-02f, -1.84820220e-02f, -2.79631559e-03f, -5.64827509e-02f, -1.60938025e-01f,
  3.17661017e-02f, 1.45308301e-02f, 9.11060944e-02f, 1.11048132e-01f, 4.27247994e-02f, 3.95916626e-02f, 1.66611429e-02f, 5.61218411e-02f, 4.04927731e-02f, 7.56889731e-02f,
  7.73470551e-02f, 1.70406010e-02f, 7.41238967e-02f, -6.67624772e-02f, 1.18090712e-01f, 4.70563285e-02f, 9.38776787e-03f, 6.14087693e-02f, 1.48288891e-01f, 1.61459278e-02f,
  1.06449850e-01f, 3.64116468e-02f, 9.66061950e-02f, 7.92145506e-02f, 5.90664856e-02f, 9.01442766e-02f, 8.16159919e-02f, 7.73485899e-02f, 1.45039946e-01f, 4.34226505e-02f,
  -3.00693116e-03f, -7.70522505e-02f, -1.75931215e-01f, -8.32012743e-02f, -1.85005721e-02f, 1.67833753e-02f, -1.87936947e-02f, 4.80433628e-02f, -2.00461433e-03f, -5.55960611e-02f,
  4.80191000e-02f, 2.16817968e-02f, 1.10147782e-02f, -3.52897979e-02f, -6.13754280e-02f, 7.39816129e-02f, 3.33698876e-02f, -8.41223225e-02f, -3.27746458e-02f, -1.22081721e-02f,
  -1.21418558e-01f, -1.26738967e-02f, 5.41804312e-03f, 1.45702036e-02f, -2.03927029e-02f, -4.04345356e-02f, 2.98049226e-02f, -9.44872126e-02f, -3.38108838e-02f, -2.43627742e-01f,
  -3.11020643e-01f, -1.27184808e-01f, -2.08612710e-01f, 6.63128942e-02f, 2.33071059e-01f, -2.77554803e-02f, -1.32774994e-01f, -8.56171325e-02f, 1.15802594e-01f, 1.12941386e-02f,
  3.37099768e-02f, 1.26896678e-02f, -1.43592343e-01f, -3.72448154e-02f, -2.28799850e-01f, -1.89588174e-01f, -5.93522452e-02f, -3.02074496e-02f, -1.44015804e-01f, 1.26528800e-01f,
  1.04312189e-01f, -1.52142607e-02f, -1.68719307e-01f, 2.50941813e-02f, 1.56675145e-01f, 1.59385785e-01f, 6.49615303e-02f, 4.63687852e-02f, 5.30589670e-02f, 6.97586238e-02f,
  -9.83002782e-02f, -3.35212201e-02f, 8.79551843e-03f, 3.08681633e-02f, -9.42895841e-03f, -1.97043791e-02f, 4.33555618e-02f, -3.60088497e-02f, 1.53469862e-02f, -8.99346545e-02f,
  -3.69094796e-02f, 7.93321654e-02f, 7.16003329e-02f, 1.08101360e-01f, 8.38516057e-02f, -4.45037931e-02f, 8.89337584e-02f, 4.13559228e-02f, 1.28459418e-02f, -1.52406814e-02f,
  1.72074839e-01f, 1.40114546e-01f, 5.89544997e-02f, -1.72703806e-02f, 9.38921720e-02f, 3.43805701e-02f, -1.18104713e-02f, 1.12458818e-01f, 7.32170939e-02f, -5.77675886e-02f,
  -3.33469100e-02f, -7.44505376e-02f, 9.26463529e-02f, -4.55316454e-02f, -2.15612128e-02f, 3.16622853e-03f, -1.09432442e-02f, -9.66565236e-02f, 2.52982639e-02f, -4.53609712e-02f,
  2.93481871e-02f, 5.92504591e-02f, 4.57517505e-02f, -8.92559811e-02f, 4.82123755e-02f, -5.12914211e-02f, -2.83132195e-02f, -4.11873832e-02f, 6.28003404e-02f, -5.81879355e-02f,
  8.51738900e-02f, 3.68869826e-02f, 4.42975760e-02f, 4.76422459e-02f, 1.10539263e-02f, 8.83345231e-02f, 7.34432717e-04f, -5.46243880e-03f, -1.66950524e-02f, 3.82132269e-02f,
  -1.25582337e-01f, 5.68895042e-02f, -5.63433729e-02f, 1.84361525e-02f, 2.48995721e-02f, 4.45950627e-02f, -4.95765992e-02f, -7.88511150e-03f, 4.01888527e-02f, 3.02539952e-02f,
  5.73208146e-02f, -4.15747799e-02f, 2.74926648e-02f, -2.76828352e-02f, 7.49541819e-02f, 7.55729154e-02f, -3.24081406e-02f, 6.38453439e-02f, 4.12066691e-02f, 6.78329244e-02f,
  9.32462066e-02f, -5.93537875e-02f, -1.04006827e-01f, -8.62405375e-02f, 1.33597910e-01f, -4.46891561e-02f, -1.05893295e-02f, -5.37597910e-02f, -7.35928863e-02f, -1.23810589e-01f,
  -4.20763493e-02f, -2.05597714e-01f, -1.34512410e-01f, 7.05892220e-02f, 1.66859820e-01f, 1.05778322e-01f, 2.06713807e-02f, 6.34469464e-02f, 1.00926951e-01f, -1.75600111e-01f,
  2.58838739e-02f, 2.02305391e-01f, 6.35822788e-02f, 3.64726111e-02f, 3.53703126e-02f, -1.03468873e-01f, -4.07698900e-02f, 8.24898034e-02f, 2.32963488e-01f, 8.19410235e-02f,
  1.27185702e-01f, 1.41640335e-01f, 7.51217604e-02f, 9.55424681e-02f, -9.67408437e-03f, 4.11304720e-02f, -4.67618816e-02f, -1.53353631e-01f, -1.46804824e-01f, -2.66004175e-01f,
  -1.79916710e-01f, -2.36536801e-01f, 1.38557479e-01f, 6.75277114e-02f, -8.37412756e-03f, 7.25733936e-02f, 2.95614526e-02f, 3.48873958e-02f, 8.56742114e-02f, -8.07752535e-02f,
  -2.08935533e-02f, 3.65634356e-03f, 8.67849439e-02f, 7.09559694e-02f, -1.00155421e-01f, -7.18859956e-02f, -9.90916938e-02f, -9.19404179e-02f, 5.14271371e-02f, -1.32840946e-01f,
  -1.18606556e-02f, -8.63815695e-02f, -1.39168119e-02f, 1.52203515e-02f, -3.27099748e-02f, 9.58456174e-02f, -2.67369710e-02f, -9.73162428e-02f, -5.28262109e-02f, -3.85455191e-02f,
  3.14414203e-02f, 3.14348340e-02f, -4.31310534e-02f, -2.21129376e-02f, 6.93653710e-03f, -2.33595110e-02f, -4.46260273e-02f, -7.18217436e-03f, -4.10535522e-02f, 4.18247245e-02f,
  -1.59337898e-04f, -9.47435945e-03f, -4.69610430e-02f, -2.41331980e-02f, 5.83889633e-02f, -5.86427487e-02f, -4.47938554e-02f, 3.38449664e-02f, -8.47868100e-02f, -1.76411737e-02f,
  -5.61092570e-02f, -5.77444173e-02f, -8.13437402e-02f, 4.72342931e-02f, -5.10427132e-02f, -1.88510716e-02f, 2.22887490e-02f, 3.25365886e-02f, -3.25589217e-02f, -5.19026816e-02f,
  1.74284697e-01f, 1.65892184e-01f, 1.96198635e-02f, -1.02005461e-02f, 2.23729992e-03f, -9.79914442e-02f, 4.91297729e-02f, 3.07691540e-03f, 5.60047664e-02f, 2.11914051e-02f,
  7.40055041e-03f, 8.46563950e-02f, 1.38702132e-02f, -5.92593662e-02f, 1.03492469e-01f, 1.93014108e-02f, -7.37480633e-03f, 1.23456396e-01f, 3.99569161e-02f, -7.58057758e-02f,
  1.03320992e-02f, 7.72102997e-02f, 1.27166420e-01f, 8.77264068e-02f, 4.89095300e-02f, 1.76234514e-01f, 3.77881713e-02f, 5.25893085e-02f, 1.35030150e-01f, 8.98862854e-02f,
  1.96889117e-01f, -3.01277906e-01f, -3.80409628e-01f, -1.02647528e-01f, -1.69110715e-01f, -2.22516004e-02f, -1.77449450e-01f, -4.35124971e-02f, 6.66079968e-02f, -1.98557675e-01f,
  -5.63327484e-02f, -6.10298924e-02f, -1.15236394e-01f, 6.01105429e-02f, 1.04014121e-01f, -2.55407542e-01f, -3.24841708e-01f, 8.56787339e-03f, 1.40652999e-01f, -3.93756367e-02f,
  -7.76143884e-03f, -8.23969170e-02f, 4.33732346e-02f, -4.17261682e-02f, -1.68905467e-01f, -3.57213058e-02f, -2.92470306e-01f, -2.59657949e-01f, -1.08320102e-01f, -2.74172038e-01f,
  -2.81260908e-01f, -1.25533774e-01f, 2.02297848e-02f, -4.18393314e-02f, -1.27734110e-01f, -9.13138762e-02f, -1.50919527e-01f, -5.33147976e-02f, -9.87450555e-02f, -1.56273246e-01f,
  -9.57697481e-02f, -1.01529151e-01f, 1.19915511e-03f, -1.15325056e-01f, -1.18194195e-02f, -1.24503218e-01f, -6.30521700e-02f, -8.68408754e-02f, -1.44536778e-01f, -9.60892364e-02f,
  -1.79256275e-01f, -1.57244951e-01f, -1.74824119e-01f, -7.72478804e-02f, 1.59942899e-02f, -9.95991528e-02f, -6.12153932e-02f, -1.13306008e-01f, 3.38261351e-02f, -3.25219845e-03f,
  8.47659186e-02f, 3.48645560e-02f, 8.07056762e-03f, 1.54369280e-01f, 1.06884232e-04f, 9.39602554e-02f, 4.88385409e-02f, 5.27337305e-02f, 6.56851679e-02f, 4.60032746e-02f,
  9.91093591e-02f, 5.80495372e-02f, 3.56803164e-02f, 9.42921340e-02f, -2.36346107e-02f, -5.95385469e-02f, 3.82337086e-02f, 9.44885835e-02f, 2.10881997e-02f, 5.74934855e-03f,
  3.70119736e-02f, 5.02803065e-02f, -1.88384764e-02f, -1.31032532e-02f, 1.03842489e-01f, 7.49177486e-02f, 6.64214194e-02f, 4.93219756e-02f, 9.58548635e-02f, 7.87396207e-02f,
  -1.44382507e-01f, -5.78527413e-02f, -1.31857321e-01f, -8.73775780e-03f, -1.18851818e-01f, -1.21915579e-01f, -2.99706105e-02f, -1.20899767e-01f, -1.56745940e-01f, -7.31618404e-02f,
  -1.18232757e-01f, 1.52445650e-02f, -1.44847482e-01f, -7.43583292e-02f, -6.21728674e-02f, 2.18143594e-03f, -9.75373313e-02f, -2.87348013e-02f, -1.06569938e-01f, -1.90668657e-01f,
  -2.17946470e-02f, -5.71789667e-02f, 3.58233489e-02f, -3.07691675e-02f, -7.30833923e-03f, 7.80874342e-02f, -5.74154854e-02f, -5.73758483e-02f, 2.61918101e-02f, 6.30409569e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.32598454e-01f, -1.77468911e-01f, 3.68655622e-01f, 3.10907304e-01f, 1.99372053e-01f, 3.67129326e-01f, 2.05347314e-01f, 8.00930485e-02f, 1.65114522e-01f, -9.03510861e-03f,
  -1.33335367e-01f, -1.07733563e-01f, -9.23408419e-02f, -9.37018618e-02f, -3.89923044e-02f, 1.00039303e-01f, 2.63587505e-01f, 2.33171552e-01f, 2.22078145e-01f, 2.12870389e-01f,
  1.40471396e-03f, 5.04828990e-02f, 1.28032239e-02f, 2.50664204e-02f, -7.52834530e-05f, 2.32838206e-02f, -2.45149545e-02f, 2.65385509e-02f, -6.51935115e-02f, 6.95982799e-02f,
  1.33067355e-01f, -2.22517345e-02f, 4.49037179e-02f, -2.44838119e-01f, -1.21098384e-01f, -2.81506069e-02f, 1.92720052e-02f, -1.49269536e-01f, -9.34753120e-02f, 3.14796646e-03f,
  -1.05381668e-01f, -1.20944954e-01f, -9.28798094e-02f, -1.66335836e-01f, -8.45101029e-02f, -8.15172046e-02f, -1.49512544e-01f, -2.60094106e-02f, 1.16729870e-01f, -6.57000542e-02f,
  -1.48669466e-01f, -2.46531460e-02f, 1.73791386e-02f, 2.26369426e-02f, 3.91139314e-02f, 4.42456566e-02f, -2.82126181e-02f, -1.94579512e-02f, 1.13817379e-01f, -5.70159219e-02f,
  1.89688638e-01f, 1.08636796e-01f, 4.37661596e-02f, -7.01360928e-04f, 2.45465841e-02f, 1.56922489e-01f, 1.30774230e-01f, 1.90638490e-02f, -5.64301163e-02f, -3.30097810e-03f,
  -1.50472462e-01f, 4.07536663e-02f, 1.19896047e-01f, 6.28221706e-02f, -1.88832860e-02f, 8.83010104e-02f, 9.78764147e-02f, -7.16853216e-02f, -8.63551348e-02f, 5.26420726e-03f,
  1.34856887e-02f, -9.44489241e-03f, -1.31069988e-01f, -5.59624545e-02f, -1.19212277e-01f, 1.55018608e-03f, 1.92037318e-02f, -1.08338602e-01f, -1.08939052e-01f, -6.25875369e-02f,
  -9.91255865e-02f, 6.73930347e-02f, 1.33605629e-01f, -5.98082915e-02f, 3.16978469e-02f, -1.13242261e-01f, 3.20286863e-02f, 4.27250452e-02f, -6.52707219e-02f, 5.00251167e-02f,
  7.14076087e-02f, 5.85225336e-02f, 7.74635375e-02f, -9.54360142e-02f, -2.53671911e-02f, 6.01343662e-02f, -4.10942584e-02f, 1.74763694e-01f, 1.25044540e-01f, 5.23757115e-02f,
  -9.87960547e-02f, 1.76481530e-01f, 1.89755484e-01f, 1.82232738e-01f, 1.04137473e-01f, 5.18623590e-02f, 9.90155265e-02f, 4.69684340e-02f, 1.02309041e-01f, 3.38663086e-02f,
  6.02346361e-01f, 3.11428010e-01f, 2.67586321e-01f, 1.64411813e-01f, 1.69611007e-01f, 1.32540807e-01f, 3.02742213e-01f, 1.63146898e-01f, 3.02600749e-02f, 1.87039629e-01f,
  4.16103452e-02f, -7.47543871e-02f, -4.58118245e-02f, -3.30949873e-02f, 1.48373663e-01f, 5.52181154e-02f, -1.13528229e-01f, 1.69547856e-01f, 9.82838646e-02f, 1.18782170e-01f,
  -1.87727474e-02f, 1.57592207e-01f, 1.67921588e-01f, 6.81608319e-02f, 4.64895181e-02f, -1.16078019e-01f, 5.56575358e-02f, 1.99435681e-01f, 1.07955985e-01f, -4.45477143e-02f,
  -7.17041790e-02f, 3.11599642e-01f, -1.94113389e-01f, -1.20007522e-01f, 6.23905957e-02f, -6.07755482e-02f, 1.01331957e-02f, 9.17010289e-03f, -1.98390409e-02f, -7.90971741e-02f,
  -7.79780746e-02f, -6.60748854e-02f, -8.38998407e-02f, -8.49203914e-02f, -8.66920426e-02f, -6.90729395e-02f, -3.97104621e-02f, 2.97793597e-02f, -6.91808909e-02f, 2.11013034e-02f,
  -1.22693419e-01f, 7.96344504e-02f, 8.70150328e-02f, -5.29174022e-02f, 4.89515215e-02f, -5.11275865e-02f, 9.12966058e-02f, 2.27486212e-02f, 3.77488844e-02f, 3.20751965e-02f,
  -2.20631421e-01f, -4.10301983e-02f, -8.61488096e-03f, -9.79877487e-02f, -5.12934849e-02f, -1.12621613e-01f, -3.61722754e-03f, -6.22638986e-02f, -6.54603764e-02f, 1.62755419e-02f,
  -1.24995433e-01f, 1.42531749e-02f, -7.15530142e-02f, 8.23877999e-05f, -9.76436734e-02f, -1.17019750e-01f, -5.58766276e-02f, -1.94577388e-02f, -1.16398044e-01f, -9.11058113e-02f,
  -1.00867879e-02f, -1.34799793e-01f, -1.31598879e-02f, -9.07745212e-02f, -1.06980532e-01f, -7.17023090e-02f, -9.11835805e-02f, -9.42076594e-02f, -2.66860309e-03f, -1.08099192e-01f,
  -4.00423765e-01f, -1.16721556e-01f, -1.48243323e-01f, 4.40001041e-02f, 1.64809644e-01f, -7.17475172e-03f, -3.43314521e-02f, 3.01864091e-02f, 8.78916457e-02f, -2.58093588e-02f,
  7.32333586e-02f, 8.96092951e-02f, 9.44204926e-02f, 2.49423552e-02f, -3.09841335e-02f, -1.24900050e-01f, -3.88595462e-02f, -7.98303783e-02f, -9.61398110e-02f, -7.36125931e-02f,
  -1.41820967e-01f, -1.28219336e-01f, -6.09285310e-02f, -9.24193636e-02f, -9.09839272e-02f, -1.53699741e-01f, -9.45964679e-02f, -1.17493853e-01f, -4.32877503e-02f, -6.50337785e-02f,
  3.78555804e-01f, 5.11122644e-01f, -2.27687702e-01f, 1.74852803e-01f, -1.70969024e-01f, -1.46233961e-01f, 1.93156861e-02f, 2.64295548e-01f, 2.59233356e-01f, 2.86240458e-01f,
  7.58598074e-02f, -6.91663623e-02f, -1.22558214e-01f, -9.81182978e-02f, -6.79659843e-02f, 1.03285864e-01f, -2.76380256e-02f, -2.83027530e-01f, -3.49386603e-01f, -1.04272619e-01f,
  -5.73595390e-02f, -4.35014069e-03f, -2.45581716e-02f, 3.85302380e-02f, 1.21884733e-01f, -1.99297249e-01f, -8.60416070e-02f, -1.59937650e-01f, -1.11549713e-01f, -1.75204012e-03f,
  -3.64961535e-01f, -1.14719950e-01f, -3.19194160e-02f, 1.64411977e-01f, 1.21119201e-01f, 1.38104603e-01f, -5.28868809e-02f, 1.54594332e-01f, 2.07710311e-01f, 2.07358062e-01f,
  2.15416048e-02f, -6.04283325e-02f, 6.63110390e-02f, 8.20537563e-03f, 1.23022214e-01f, 5.85962385e-02f, 7.38950372e-02f, 9.52008516e-02f, -9.95246246e-02f, 2.52978262e-02f,
  7.64456838e-02f, -9.96547341e-02f, -8.79235044e-02f, 3.65755893e-02f, -1.07041277e-01f, -1.28216386e-01f, 6.45126179e-02f, -4.41243351e-02f, -1.89916223e-01f, 6.20166808e-02f,
  3.67348269e-02f, 1.76167384e-01f, -3.47397886e-02f, 4.00831699e-02f, 4.39372174e-02f, 1.14087611e-01f, -1.25605324e-02f, 1.79567095e-02f, -1.11080162e-01f, 1.30601346e-01f,
  1.31773800e-01f, -1.67347834e-01f, -7.33542517e-02f, -4.44942340e-02f, 2.74249222e-02f, -6.48982450e-02f, -6.66131219e-03f, 1.47956284e-02f, -9.22838077e-02f, 9.95526016e-02f,
  -1.70471996e-01f, 6.41775876e-02f, 7.60184182e-03f, -1.06435396e-01f, 3.62200662e-02f, 6.96450844e-02f, -1.67490095e-01f, -6.79341629e-02f, 3.47624645e-02f, 8.68434608e-02f,
  1.37946367e-01f, -5.79787850e-01f, 4.03689407e-02f, 6.59354851e-02f, -4.96907085e-02f, 1.76752642e-01f, -8.92879814e-02f, -6.19513094e-02f, 8.58957767e-02f, -1.58726964e-02f,
  -2.30100341e-02f, 5.18000834e-02f, 8.49850029e-02f, 6.91210404e-02f, 3.17114592e-02f, -5.47722019e-02f, 1.97845533e-01f, 7.86761418e-02f, -5.22756251e-03f, 6.72841817e-02f,
  7.77421147e-02f, 2.34633796e-02f, -1.69564399e-03f, 7.54243433e-02f, -2.88077388e-02f, 2.88571939e-02f, -4.04937454e-02f, 1.94083378e-02f, -1.58763066e-01f, 3.17527324e-01f,
  -3.41591954e-01f, 2.31491536e-01f, -7.15142488e-02f, 1.25935256e-01f, 7.97758922e-02f, 3.22965756e-02f, -7.75810331e-03f, -7.24152550e-02f, 1.14935771e-01f, 1.66830435e-01f,
  6.97617978e-02f, -3.52649353e-02f, 4.79138643e-02f, 1.46023193e-02f, 2.12737564e-02f, 9.06005725e-02f, 2.70295203e-01f, -1.01063758e-01f, -2.60284960e-01f, -2.72354662e-01f,
  1.15727283e-01f, -5.60388118e-02f, -2.21586823e-01f, -6.19362816e-02f, 1.37473539e-01f, 4.72970791e-02f, -1.90448873e-02f, 7.63389328e-03f, -4.58541699e-02f, 2.47333959e-01f,
  -1.78445384e-01f, -5.44138849e-02f, -9.07744095e-02f, 1.84810825e-03f, -2.45228596e-02f, -1.46484464e-01f, -2.14207005e-02f, -2.71499902e-03f, 1.22009352e-01f, 6.39576986e-02f,
  -1.55457124e-01f, -3.07286531e-02f, 1.32599279e-01f, -3.20976377e-02f, -1.94134057e-01f, -2.67719477e-01f, -7.47410357e-02f, -6.89358786e-02f, -6.40138164e-02f, -2.00404495e-01f,
  2.09479094e-01f, -5.21336347e-02f, -1.97909653e-01f, -1.06397808e-01f, -7.01637790e-02f, 3.61259319e-02f, -1.14896283e-01f, -1.26065046e-01f, -2.22081020e-01f, -8.54650363e-02f,
  1.85861439e-02f, -5.12064882e-02f, 1.32060036e-01f, 1.51839539e-01f, 4.69917320e-02f, -1.49475615e-02f, 7.34035596e-02f, 7.78300092e-02f, -3.16778310e-02f, -2.11845129e-03f,
  7.78458193e-02f, -8.67859423e-02f, -5.52113652e-02f, 4.28397674e-03f, 6.66552037e-02f, -5.51898926e-02f, 8.54534209e-02f, -2.64899265e-02f, -2.51777600e-02f, 5.59178777e-02f,
  -1.17516862e-02f, 8.13118834e-03f, 8.89356509e-02f, -3.08040064e-02f, 4.40494753e-02f, 6.80982098e-02f, -9.88991931e-03f, -4.18956205e-02f, 6.78122267e-02f, 6.50846511e-02f,
  -1.96586233e-02f, -6.42478094e-02f, 8.64525232e-03f, -7.07258582e-02f, 1.71438679e-02f, -8.06070864e-02f, 6.31861463e-02f, 1.00798532e-02f, 6.37733042e-02f, -1.18930027e-01f,
  -1.98566675e-01f, -8.77904892e-03f, 1.02984913e-01f, -3.80153023e-02f, -2.35465303e-01f, -1.61655154e-02f, 5.49794175e-02f, -2.31549959e-03f, 1.57212988e-02f, -1.01690456e-01f,
  1.22373551e-01f, -1.19145975e-01f, -2.34102115e-01f, -1.08729191e-01f, 3.82275805e-02f, -1.21812098e-01f, -1.59669861e-01f, -2.07850784e-01f, -2.07154319e-01f, -6.56758472e-02f,
  -3.98232788e-01f, -3.43676448e-01f, 3.99671674e-01f, -2.26729475e-02f, 5.67643940e-02f, -5.74701354e-02f, -1.90392539e-01f, -1.96050078e-01f, -6.15850165e-02f, -5.01451939e-02f,
  -1.96783058e-02f, 1.53765278e-02f, 1.60649329e-01f, 9.51955542e-02f, -1.12033868e-02f, 1.97471548e-02f, 8.23303238e-02f, 3.35812867e-01f, 2.86131591e-01f, 1.32062405e-01f,
  -5.94712272e-02f, -5.68905026e-02f, -4.86546569e-02f, -4.38378230e-02f, 5.24508804e-02f, 2.16598317e-01f, 1.06114417e-01f, 2.96323318e-02f, 7.20933825e-02f, 1.41631529e-01f,
  5.60798347e-01f, -4.71567698e-02f, 1.01212278e-01f, 1.50651187e-02f, -6.63711354e-02f, -1.92703828e-02f, 3.56250852e-02f, -5.22410721e-02f, -1.28672287e-01f, -1.06816739e-01f,
  -4.67234803e-03f, -1.05839362e-02f, 1.05404541e-01f, -7.90612102e-02f, 6.79802522e-02f, -2.54891552e-02f, -1.08610146e-01f, 2.31372770e-02f, -2.60618124e-02f, -7.70609304e-02f,
  -4.78522405e-02f, 1.11451484e-01f, 1.49852201e-01f, -5.51336706e-02f, -4.39683199e-02f, 1.30489131e-03f, -6.52948171e-02f, -1.24104291e-01f, -3.46350856e-02f, -7.45558962e-02f,
  2.05908883e-02f, 3.14911157e-02f, 1.36567578e-01f, 1.10731080e-01f, 2.53077671e-02f, -1.31433427e-01f, 1.89588424e-02f, -2.24891100e-02f, -4.84071439e-03f, 5.81657328e-02f,
  -3.77670713e-02f, -1.96042750e-02f, 6.52201939e-03f, 9.59404409e-02f, -1.52713116e-02f, 2.31329096e-03f, -6.50199801e-02f, 4.47804369e-02f, -3.80682908e-02f, -7.01540112e-02f,
  4.62309048e-02f, -6.21457919e-02f, -7.75675662e-03f, 8.80835205e-02f, 9.81136411e-03f, 4.47359271e-02f, -3.16045545e-02f, 2.72305906e-02f, -2.70065926e-02f, -7.79843926e-02f,
  2.66506195e-01f, 1.61859035e-01f, 1.48056895e-01f, -9.67099592e-02f, 7.57762566e-02f, -8.44150856e-02f, 1.52513646e-02f, 1.70137390e-01f, -2.03854609e-02f, 6.48379978e-03f,
  4.35571410e-02f, 8.26661736e-02f, 8.16929806e-03f, -4.91213240e-02f, -2.69809645e-03f, 1.22388229e-01f, -1.16190612e-01f, 8.93215686e-02f, -7.50498772e-02f, 1.73624549e-02f,
  -6.92521110e-02f, 5.34501337e-02f, 2.06675157e-01f, 1.44900426e-01f, 1.16845407e-02f, 1.69756457e-01f, 2.16962993e-01f, 1.16404794e-01f, 1.77761704e-01f, 1.70650780e-02f,
  -3.40118587e-01f, 2.26492986e-01f, -3.25932056e-02f, -1.26978382e-01f, -2.15043262e-01f, -1.13241956e-01f, 1.72021374e-01f, -1.14746373e-02f, -7.86709413e-02f, 1.94651499e-01f,
  1.02327123e-01f, -1.50096133e-01f, -6.16316795e-02f, -1.10527664e-01f, -1.17479809e-01f, 1.15461037e-01f, -4.67188209e-02f, -2.66688257e-01f, -4.45340186e-01f, -2.34046951e-01f,
  -6.53364360e-02f, -3.08844429e-02f, -2.19957784e-01f, -1.13977060e-01f, -5.41453529e-03f, -1.44033045e-01f, 5.84848002e-02f, -5.09228483e-02f, -1.06200568e-01f, 1.82597544e-02f,
  9.42135155e-02f, -9.39463153e-02f, -1.36258826e-01f, -1.11660525e-01f, 3.17373201e-02f, 8.01739618e-02f, 8.40426683e-02f, 1.16537280e-01f, -5.71038648e-02f, -1.16428481e-02f,
  -1.24741666e-01f, -3.39874290e-02f, -9.78591759e-03f, -6.05311431e-03f, -8.55415538e-02f, -2.39999313e-02f, 1.85204751e-03f, -1.55620605e-01f, -6.34759758e-03f, 7.12494031e-02f,
  1.22773051e-01f, 4.82862443e-02f, 1.69000663e-02f, 1.11954957e-01f, 3.48708816e-02f, -3.56014445e-02f, 1.41516188e-03f, 3.97334956e-02f, -4.02699076e-02f, 2.61536956e-01f,
  1.03569433e-01f, 9.65178981e-02f, 4.34280634e-02f, 2.43022725e-01f, 7.50868917e-02f, -1.51922582e-02f, -5.57661429e-02f, 1.06074616e-01f, -4.19869870e-02f, 9.48627200e-03f,
  7.74892867e-02f, 1.70996889e-01f, 1.70980260e-01f, 1.91886827e-01f, -2.18813848e-02f, -1.74992364e-02f, -4.15681005e-02f, 1.32075906e-01f, 6.99511394e-02f, 6.34725317e-02f,
  -1.01197675e-01f, -8.43204856e-02f, -2.36626547e-02f, 1.03437953e-01f, 1.88580621e-02f, 8.00936595e-02f, 7.63927326e-02f, 1.07255712e-01f, -6.80143759e-02f, -8.33445638e-02f,
  1.57883316e-01f, -2.15751454e-01f, 4.26183939e-02f, -1.54623315e-01f, 5.68314716e-02f, 1.02749886e-02f, -8.55926424e-03f, -2.66945735e-03f, 1.63825661e-01f, 1.44149676e-01f,
  -1.54222056e-01f, 3.22182812e-02f, -7.33477622e-02f, -8.38699043e-02f, -1.12311900e-01f, -3.51233594e-02f, 1.54093578e-01f, -1.72366365e-03f, 8.27063620e-02f, -2.07455419e-02f,
  1.02110237e-01f, 1.04530239e-02f, 8.66986811e-02f, 9.73604247e-02f, 1.15759850e-01f, -1.23336583e-01f, 5.57324737e-02f, 1.09221399e-01f, 4.90118451e-02f, 3.27430815e-01f,
  4.00314510e-01f, -4.65122573e-02f, -6.06947362e-01f, 1.08323589e-01f, -2.45072246e-01f, -9.24328938e-02f, 1.65731713e-01f, 3.39477062e-01f, 2.60875165e-01f, 9.01242644e-02f,
  -1.16778135e-01f, -1.62174746e-01f, -2.58789361e-01f, -1.04136281e-01f, 5.30580245e-02f, 6.65529072e-02f, -1.28093392e-01f, -2.36066595e-01f, -3.07955384e-01f, -1.89335067e-02f,
  1.46958255e-03f, 7.18518943e-02f, 3.39345112e-02f, -6.76798224e-02f, -4.42629196e-02f, -1.06018066e-01f, -2.03796297e-01f, -1.32716686e-01f, -1.99709386e-01f, -2.61378050e-01f,
  -2.69947886e-01f, 8.55717137e-02f, -5.72137274e-02f, -5.06975986e-02f, -3.75028811e-02f, -9.32349414e-02f, -1.03451312e-01f, -3.10396962e-02f, -5.00115193e-02f, -6.14008866e-02f,
  -3.30121428e-01f, 6.57417695e-04f, -2.01527029e-01f, -4.02251519e-02f, -1.26338825e-01f, -1.24595121e-01f, -1.51867926e-01f, -3.58865321e-01f, -1.87380672e-01f, -6.40649945e-02f,
  4.00142511e-03f, -2.82481223e-01f, -2.01234728e-01f, 1.42731592e-02f, -1.35348439e-01f, -1.74564153e-01f, -1.03729695e-01f, -9.77290496e-02f, -9.36511233e-02f, 2.38661274e-01f,
  1.46578297e-01f, -8.44428241e-02f, 8.06284770e-02f, 1.25717431e-01f, 9.02063623e-02f, -3.11282948e-02f, 4.18633930e-02f, -4.87169903e-03f, 9.55784470e-02f, 2.58351564e-02f,
  2.89968774e-02f, 9.47671607e-02f, 2.18098853e-02f, 1.35094393e-02f, -1.42666891e-01f, -6.22872412e-02f, 1.27209648e-01f, 1.74994275e-01f, 7.81352445e-02f, 1.04436316e-01f,
  -6.48211390e-02f, -2.45549413e-03f, 1.71107240e-02f, 7.52185509e-02f, -4.87453341e-02f, -6.20909072e-02f, 1.03859775e-01f, 2.21233517e-01f, 1.03888594e-01f, 1.09632857e-01f,
  2.23791048e-01f, 1.52950019e-01f, 1.88222453e-01f, 2.69007534e-02f, -4.54247259e-02f, -1.89054757e-01f, 1.37667023e-02f, 4.65285918e-03f, -1.07379228e-01f, 8.15867558e-02f,
  -2.08523005e-01f, -2.35881004e-02f, 1.07529340e-02f, -2.04828791e-02f, 6.85927197e-02f, 2.38715280e-02f, -5.82101420e-02f, -2.82705754e-01f, -4.43487875e-02f, 1.51659042e-01f,
  2.03523859e-01f, 1.51397377e-01f, 1.46826997e-01f, 1.20061085e-01f, 3.05469912e-02f, -2.72893459e-02f, 2.64359433e-02f, 3.73561233e-02f, 1.60683915e-01f, 4.92078274e-01f,
  7.20934868e-01f, 8.21251720e-02f, 2.84981459e-01f, 1.82258382e-01f, -4.39742282e-02f, -1.61477000e-01f, -2.03129917e-01f, -6.96860030e-02f, 1.23485327e-01f, 1.63300574e-01f,
  1.49971098e-01f, 9.79127288e-02f, 1.13165729e-01f, 1.38249636e-01f, 1.11085899e-01f, 3.27769620e-03f, 1.44510241e-02f, 3.07958484e-01f, 1.80635825e-01f, 1.72229081e-01f,
  5.37751429e-02f, -5.98501638e-02f, 2.45660752e-01f, 1.14345722e-01f, 1.13100730e-01f, 8.21485445e-02f, 4.48022634e-02f, 8.53367075e-02f, 7.56791905e-02f, 8.58364031e-02f,
  1.70351565e-01f, 2.07611188e-01f, 7.37932026e-02f, 3.72351729e-04f, -1.76969972e-02f, 1.15795404e-01f, 5.68397194e-02f, -3.31084169e-02f, -3.53004374e-02f, -3.55593860e-02f,
  -1.55623525e-01f, 4.00870554e-02f, -4.19516154e-02f, -5.87427728e-02f, -7.45435581e-02f, -4.22389582e-02f, -4.38045850e-03f, 1.48768108e-02f, 5.21495827e-02f, -2.00266295e-04f,
  -6.15487173e-02f, -8.00029710e-02f, -1.49718823e-03f, -1.75578341e-01f, 1.35290578e-01f, -1.22649623e-02f, -2.35747769e-02f, 9.55007449e-02f, 1.10597856e-01f, 1.25674903e-01f,
  2.06719130e-01f, 1.79111645e-01f, 3.06679696e-01f, 2.19616115e-01f, 2.40995407e-01f, 9.83228236e-02f, 1.39938936e-01f, 7.81545229e-03f, 2.03583483e-02f, -1.47017324e-02f,
  8.24212879e-02f, 1.00177534e-01f, -1.94730572e-02f, 5.02445213e-02f, 8.39254558e-02f, -3.92460730e-03f, 3.03247962e-02f, 8.69434252e-02f, -1.38858156e-02f, -2.37631593e-02f,
  1.84953004e-01f, -1.56810526e-02f, 3.09424102e-02f, -1.70297027e-02f, -4.66274284e-02f, 1.76315948e-01f, 7.81433582e-02f, 1.18422650e-01f, -8.14440474e-03f, 8.30951855e-02f,
  -5.28284431e-01f, -4.32919264e-02f, 2.17450067e-01f, 2.74816193e-02f, -6.07624166e-02f, -7.47868344e-02f, -1.19395182e-03f, -9.50861722e-02f, -2.21169531e-01f, -7.66162425e-02f,
  5.04781259e-03f, -2.09737904e-02f, -9.97618437e-02f, 3.58240902e-02f, -7.18458071e-02f, -4.21009846e-02f, -7.04464987e-02f, -1.69002730e-02f, -4.58356142e-02f, -6.81757033e-02f,
  -4.90015410e-02f, -9.97545347e-02f, -6.84693530e-02f, -8.31327215e-02f, -1.25038819e-02f, -9.23692659e-02f, -4.65902388e-02f, -2.53147501e-02f, -4.86525521e-02f, -6.52583614e-02f,
  -4.71597642e-01f, 3.16976309e-01f, 1.67134508e-01f, -1.32269353e-01f, 9.69395265e-02f, 2.20138922e-01f, 4.25042450e-01f, 1.88698643e-03f, -6.08001910e-02f, 1.30235806e-01f,
  8.47907513e-02f, -8.71518254e-02f, -8.45969990e-02f, -3.12831178e-02f, 6.12846669e-03f, 2.56732076e-01f, 1.97886214e-01f, -5.90117201e-02f, -2.58898973e-01f, -2.36826733e-01f,
  -4.44499850e-02f, -2.20446765e-01f, -3.89305413e-01f, -9.79003608e-02f, 5.84813133e-02f, -5.72248846e-02f, 1.86341435e-01f, 6.81788027e-02f, 7.50644803e-02f, 4.13263068e-02f,
  -5.72061576e-02f, -3.27836908e-02f, -3.28082107e-02f, -1.93382874e-01f, 1.99698750e-02f, -6.45176396e-02f, -4.45984275e-04f, 1.94191351e-03f, 1.20346688e-01f, -6.55114874e-02f,
  -4.10680547e-02f, -1.83794135e-03f, 2.17476729e-02f, 2.19072197e-02f, -1.01412954e-02f, -1.31967202e-01f, -6.60488158e-02f, -1.29782274e-01f, -1.24578066e-01f, -4.82123233e-02f,
  2.03538716e-01f, -5.71359135e-02f, -6.81682304e-02f, 3.80770266e-02f, 1.98364407e-02f, -8.03301856e-02f, -5.56564033e-02f, -2.93840200e-01f, -1.42426565e-01f, -2.03269839e-01f,
  -5.72728328e-02f, 1.97050590e-02f, 2.42056958e-02f, -7.75178000e-02f, -1.16723560e-01f, 5.24600176e-03f, 4.95442860e-02f, -3.83038132e-04f, 6.89793974e-02f, -1.09065451e-01f,
  1.29126217e-02f, 1.08083626e-02f, -7.27418885e-02f, 6.77472353e-02f, -3.36630084e-02f, -1.78789217e-02f, 3.98806036e-02f, -2.22979318e-02f, -7.12192850e-03f, -2.91838078e-04f,
  -4.43064142e-03f, -2.95763053e-02f, 3.45997028e-02f, -6.98367655e-02f, 7.39795342e-02f, 5.53616807e-02f, -6.38416708e-02f, -1.58969928e-02f, -1.38911530e-01f, 2.35312134e-02f,
  -3.94463390e-01f, 1.37896895e-01f, -7.55081475e-02f, 5.69504499e-02f, 7.52629638e-02f, -7.14817047e-02f, 7.99854621e-02f, 1.70713603e-01f, 8.29517096e-02f, -4.09862697e-02f,
  8.03230628e-02f, 3.19839157e-02f, 1.01120114e-01f, -1.52738458e-02f, -1.34693710e-02f, 6.92739896e-03f, 7.24717379e-02f, 7.77586550e-02f, 3.57549787e-02f, -9.79009196e-02f,
  -8.37444291e-02f, -1.16202176e-01f, -2.17430592e-01f, -2.14344985e-03f, -3.53893489e-02f, -1.84930116e-01f, -2.22215444e-01f, -1.09486051e-01f, -1.05803693e-02f, -2.50427127e-01f,
  7.52489045e-02f, 3.06703776e-01f, 1.57796189e-01f, 2.29853362e-01f, 3.97523642e-01f, 3.07052523e-01f, 3.89505327e-01f, 2.92204589e-01f, 1.45039648e-01f, 2.34733880e-01f,
  2.98224598e-01f, 1.89405695e-01f, 2.09619865e-01f, 7.86990672e-02f, 7.28062317e-02f, 1.21941537e-01f, 2.16306999e-01f, 2.77403160e-03f, 2.98215449e-02f, 2.40769818e-01f,
  2.21310675e-01f, 1.59388945e-01f, -7.49010444e-02f, 4.49100621e-02f, 1.20471194e-01f, 3.00433505e-02f, 2.24006325e-01f, 2.45151058e-01f, 1.89636812e-01f, 1.21574521e-01f,
  7.51922950e-02f, 8.06389824e-02f, -8.04786459e-02f, -1.00548640e-01f, -2.77279466e-02f, -8.65864903e-02f, 1.94310192e-02f, -1.35354728e-01f, -1.06172904e-01f, -4.27797325e-02f,
  -5.24256267e-02f, -5.18372096e-02f, 3.06304637e-02f, -2.46157367e-02f, -1.37968272e-01f, -1.27582073e-01f, 4.92130639e-03f, 7.62201697e-02f, 9.68381688e-02f, -5.27016632e-02f,
  7.24591464e-02f, 9.48579386e-02f, 4.16324250e-02f, 3.35123613e-02f, 5.22962473e-02f, 7.39425644e-02f, -1.58271316e-04f, -1.36441933e-02f, -4.00890037e-02f, -9.57824588e-02f,
  2.77628213e-01f, 1.16454817e-01f, 9.58906487e-02f, 9.98566598e-02f, -1.83266178e-02f, 1.82653498e-02f, -3.78846414e-02f, 4.77240123e-02f, 5.18682562e-02f, -4.54738364e-02f,
  3.17219049e-02f, 1.57549530e-01f, 1.39480308e-01f, 7.44911507e-02f, 9.02936049e-03f, 6.05591498e-02f, -7.90405422e-02f, -1.07712634e-02f, -9.90759432e-02f, -1.09485030e-01f,
  -9.84992832e-02f, -4.72587459e-02f, -1.57008290e-01f, -7.90287256e-02f, 1.61869242e-03f, 1.01293541e-01f, 7.25495517e-02f, -2.97313705e-02f, 1.11370787e-01f, -2.08909195e-02f,
  2.33156577e-01f, 1.58560574e-01f, -1.93181653e-02f, -8.75604078e-02f, -1.58529058e-01f, -1.62128061e-01f, -4.09357212e-02f, -6.04547486e-02f, -7.37152174e-02f, -3.95345315e-02f,
  -4.24714237e-02f, -1.29633129e-01f, -1.41071022e-01f, -1.06251031e-01f, -9.06375498e-02f, -1.28291532e-01f, -5.27127087e-02f, 1.88055590e-01f, 1.09274149e-01f, 2.46488433e-02f,
  -4.28853594e-02f, 1.70089662e-01f, 6.58151805e-02f, -1.81323774e-02f, -1.29741821e-02f, -2.31095273e-02f, -1.03533871e-01f, 1.41814649e-02f, -4.97794002e-02f, -7.73575529e-02f,
  -5.41044354e-01f, 1.47718906e-01f, 3.14927548e-01f, -2.34898672e-01f, -8.28736424e-02f, 3.29122655e-02f, 2.60139376e-01f, -3.81491184e-02f, -1.77004397e-01f, 7.50717372e-02f,
  6.47232533e-02f, -5.07172532e-02f, -1.63964480e-02f, -7.19114905e-03f, -1.37349712e-02f, 7.84038082e-02f, 6.93145096e-02f, 2.65999269e-02f, -1.14942238e-01f, -2.53955632e-01f,
  -1.10800415e-01f, -1.81430578e-01f, -1.77246809e-01f, -1.85899094e-01f, -4.45767045e-02f, -3.13863978e-02f, 1.58305749e-01f, 6.67528075e-04f, 1.05649516e-01f, 7.37079382e-02f,
  3.91579419e-01f, 1.41969472e-01f, 3.22462320e-02f, -1.45200670e-01f, -1.24911526e-02f, -3.15946601e-02f, -4.92669232e-02f, 7.46815186e-03f, -2.47029681e-03f, 5.22649251e-02f,
  7.89007545e-02f, 4.22746167e-02f, 8.26969892e-02f, 8.02107453e-02f, 1.05059825e-01f, -7.29888156e-02f, -7.35770389e-02f, -3.85493680e-04f, -4.86701401e-03f, 8.51193815e-02f,
  -9.06264037e-02f, 1.22476714e-02f, 1.40458435e-01f, 7.15305621e-04f, -3.71437632e-02f, 5.67971841e-02f, 1.72358602e-01f, -7.41292909e-03f, -7.60232583e-02f, -6.36685491e-02f,
  -1.20302930e-01f, -2.00168028e-01f, -1.51879683e-01f, 3.38195413e-02f, 1.32506648e-02f, 1.16962083e-01f, 2.05961123e-01f, 1.01708673e-01f, -5.82183413e-02f, 1.04804158e-01f,
  1.60531208e-01f, 2.91568518e-01f, 1.91074312e-01f, 7.67709017e-02f, 6.94157705e-02f, 1.19999647e-01f, 1.43759519e-01f, 1.62902087e-01f, 1.94468647e-01f, 1.82181284e-01f,
  8.60489458e-02f, 8.32148418e-02f, 2.21400023e-01f, 2.15873227e-01f, 1.15282372e-01f, 7.95578212e-02f, 2.21648395e-01f, 2.70887408e-02f, -3.16275880e-02f, 5.13432436e-02f,
  2.17315674e-01f, 1.13015346e-01f, 5.41887209e-02f, -1.17340125e-01f, -3.23226787e-02f, -2.30399910e-02f, 1.23868119e-02f, -8.14320669e-02f, 1.12353064e-01f, 2.24434193e-02f,
  2.29810812e-02f, 1.07820019e-01f, 1.42867178e-01f, 9.19698551e-02f, -2.60749571e-02f, -1.02027869e-02f, -1.20453484e-01f, 1.83723886e-02f, -1.00198358e-01f, 2.96452697e-02f,
  -7.68332705e-02f, -2.13048905e-01f, -2.80742589e-02f, 5.96465096e-02f, 9.17332098e-02f, 8.01793188e-02f, 1.77685857e-01f, 6.80083707e-02f, 1.01805545e-01f, 7.66655356e-02f,
  4.17695284e-01f, 4.42605346e-01f, 3.22560757e-01f, 1.40119242e-02f, 2.60346085e-01f, 1.75764829e-01f, 2.41555974e-01f, 2.89829019e-02f, -1.91219658e-01f, 9.74536315e-02f,
  2.29331627e-01f, -5.08547835e-02f, -7.91903362e-02f, -2.29640290e-01f, -3.54006112e-01f, -2.82888114e-01f, -2.27608740e-01f, -4.06934291e-01f, -3.11745554e-01f, -1.91432193e-01f,
  -2.50452548e-01f, -5.70661984e-02f, -9.20648798e-02f, -2.22181767e-01f, 4.30181809e-02f, -1.10521503e-01f, 1.19211100e-01f, 2.90202200e-01f, 1.59179658e-01f, -1.79822594e-01f,
  -6.71336707e-03f, 3.97560775e-01f, -2.62914121e-01f, 8.88748467e-03f, 9.17472467e-02f, -1.31994203e-01f, -1.40521988e-01f, -5.49994521e-02f, -1.47646546e-01f, -5.35601303e-02f,
  1.95545942e-01f, 1.17451608e-01f, 1.82706147e-01f, -1.27533942e-01f, 7.00058341e-02f, 1.69435854e-03f, 4.72704396e-02f, -1.32891178e-01f, -1.52756914e-01f, 1.60874635e-01f,
  -1.34000003e-01f, 1.35808244e-01f, 3.70823264e-01f, 1.58536643e-01f, 3.56040453e-03f, -7.58846775e-02f, 2.44096771e-01f, 1.28247708e-01f, 1.12082966e-01f, 6.52907416e-02f,
  -1.71573877e-01f, 1.27837732e-01f, 9.25845504e-02f, 1.45939589e-01f, -4.60658048e-04f, 1.09442271e-01f, -3.54413167e-02f, -5.37279935e-04f, 4.32459265e-03f, 8.11460763e-02f,
  -3.51804346e-02f, -4.40097339e-02f, -3.81574817e-02f, -2.48393640e-02f, -8.87465924e-02f, 2.86425538e-02f, -2.05320809e-02f, -1.29874527e-01f, -1.25683974e-02f, -4.50838776e-03f,
  -1.38473257e-01f, 7.10004941e-02f, 5.29989079e-02f, -8.74536186e-02f, -8.60944972e-04f, -1.49019025e-02f, -1.10204458e-01f, 1.11019641e-01f, 8.04594979e-02f, 3.75816785e-02f,
  -1.09960206e-01f, 6.82902336e-02f, -1.74996912e-01f, -2.29901046e-01f, 2.43816059e-02f, 2.25243904e-02f, 2.52176709e-02f, -1.25703231e-01f, 1.54254466e-01f, 3.23227234e-02f,
  8.77387673e-02f, -1.24424666e-01f, 8.66258517e-02f, -9.65827629e-02f, -7.52780885e-02f, -5.39561808e-02f, -1.75670579e-01f, -8.16231892e-02f, -2.43621141e-01f, 2.10700840e-01f,
  -9.93188545e-02f, -2.77729124e-01f, -2.36440510e-01f, -2.03104630e-01f, -1.28178313e-01f, -2.68159479e-01f, -4.62293625e-02f, -5.91895431e-02f, -1.39023215e-01f, -2.38043338e-01f,
  -7.21629798e-01f, 1.36074200e-01f, 2.69400626e-02f, -2.27509782e-01f, -7.42223635e-02f, 9.75333750e-02f, 2.53774196e-01f, 2.84652598e-02f, -1.17006719e-01f, 2.23302675e-04f,
  5.12824729e-02f, 1.45245567e-01f, 2.14994073e-01f, 9.51775759e-02f, 1.32875964e-01f, 2.84880579e-01f, 1.20492451e-01f, 1.86632555e-02f, 2.12458447e-02f, 3.90381739e-02f,
  9.81616825e-02f, 1.05736852e-02f, -2.62702227e-01f, -1.19119957e-02f, 4.73912917e-02f, 1.09558485e-01f, 8.16644132e-02f, -6.04952574e-02f, 7.94891790e-02f, -2.71629766e-02f,
  3.17632228e-01f, -2.99525917e-01f, 5.56832589e-02f, 1.41569180e-02f, -1.22107022e-01f, -9.35062114e-03f, -3.85335349e-02f, 4.54774685e-02f, 1.71033107e-02f, 1.00844525e-01f,
  -7.63347000e-03f, -1.40147507e-01f, 2.71812268e-02f, 8.08870420e-03f, 1.56074306e-02f, -6.15552366e-02f, -6.62930682e-02f, 4.86848801e-02f, 1.90118149e-01f, 1.96351945e-01f,
  3.83739136e-02f, -8.70736167e-02f, 1.04335427e-01f, 9.91547108e-03f, 2.45081112e-02f, -5.09595983e-02f, 9.42307059e-03f, -4.85937931e-02f, 4.11410183e-02f, 3.50942053e-02f,
  1.26951933e-01f, 1.77857757e-01f, -4.49217297e-02f, -1.19128346e-01f, -2.54858518e-03f, -2.29530204e-02f, 2.09930912e-03f, 4.26350236e-02f, -2.68601906e-02f, -1.53545365e-01f,
  7.75081199e-03f, 9.01034027e-02f, 8.07491411e-03f, -1.09831385e-01f, -9.77431163e-02f, -9.09507945e-02f, -9.41090807e-02f, 6.72639683e-02f, -1.08534619e-02f, -1.09819032e-01f,
  -5.12906909e-02f, 6.86966702e-02f, 2.43205968e-02f, 6.07824959e-02f, 8.82200673e-02f, 1.06124319e-01f, -3.15813124e-02f, 6.93903342e-02f, 1.93574931e-02f, 1.39510214e-01f,
  4.25919384e-01f, -1.75406441e-01f, -5.84651856e-03f, 4.70139040e-03f, -2.09653035e-01f, -2.19663650e-01f, -2.66968161e-02f, 1.30105168e-02f, -1.01683214e-02f, 1.16727360e-01f,
  9.07372031e-03f, -3.10662705e-02f, -2.98739113e-02f, 7.90591538e-03f, -5.85422814e-02f, -1.25040039e-01f, 1.43211437e-02f, -4.64494675e-02f, 2.32917175e-01f, 2.23536417e-01f,
  5.37716560e-02f, -3.44715118e-02f, 5.33900969e-02f, 2.01922264e-02f, -6.40078783e-02f, 1.10769318e-02f, 6.85402798e-03f, 3.77071276e-02f, 8.80090818e-02f, -4.79975939e-02f,
  -3.68643373e-01f, 5.80956697e-01f, 2.02098444e-01f, -3.04837674e-01f, 2.39441335e-01f, 2.31662154e-01f, 4.54964072e-01f, 3.81283984e-02f, -1.84459805e-01f, 9.28063616e-02f,
  1.83912367e-01f, -1.67644382e-01f, -1.58781588e-01f, -1.42633826e-01f, 1.86355859e-01f, 3.27539384e-01f, 2.04061061e-01f, -9.32616666e-02f, -2.11452499e-01f, 1.02065771e-03f,
  9.05117393e-02f, -2.48551875e-01f, -2.00151786e-01f, -9.25365016e-02f, -1.19325578e-01f, -2.15601683e-01f, 1.19152106e-01f, 5.85590713e-02f, 2.62937725e-01f, -3.12173255e-02f,
  -3.81925106e-02f, 1.37208775e-01f, -1.25980198e-01f, -1.47005498e-01f, 6.23562485e-02f, -1.56445831e-01f, 7.66298408e-03f, -1.23032354e-01f, 5.18691763e-02f, -5.07586971e-02f,
  3.91012691e-02f, 1.19376794e-01f, -6.24894425e-02f, -5.77973425e-02f, -8.60873759e-02f, -7.65481684e-03f, -1.27363324e-01f, -9.09110531e-02f, -1.73943937e-01f, 2.96272039e-02f,
  9.53301042e-02f, 1.27524585e-01f, 6.91324621e-02f, 1.44228622e-01f, 8.09349418e-02f, -1.86571911e-01f, 9.83501375e-02f, -1.92936152e-01f, 3.63638997e-03f, -2.42398769e-01f,
  5.75484708e-02f, 3.32399122e-02f, 4.85631227e-02f, 2.72788387e-02f, 3.92050147e-02f, 1.12091810e-01f, -1.84187340e-03f, 9.54137519e-02f, 1.08481208e-02f, -5.43868318e-02f,
  -2.02054102e-02f, -8.67978409e-02f, -8.39439854e-02f, 3.44321094e-02f, -2.26019267e-02f, 3.32529657e-02f, 4.20674421e-02f, 2.10620183e-02f, 3.62982117e-02f, 3.32964696e-02f,
  -8.09317529e-02f, 1.85913388e-02f, -9.88234207e-02f, -6.45843148e-02f, 4.29500490e-02f, 2.98413318e-02f, -6.45149872e-02f, -5.08648641e-02f, -4.76642102e-02f, 4.98888083e-02f,
  -3.65779251e-01f, 2.86732227e-01f, -2.54436493e-01f, 4.52798232e-02f, 2.94433851e-02f, 3.61589789e-02f, 8.27828869e-02f, 3.06482390e-02f, 4.25270200e-02f, -5.76094538e-02f,
  7.40933120e-02f, -2.14061663e-02f, -1.76832732e-02f, 1.64408851e-02f, -1.36758164e-01f, -3.61805484e-02f, -7.79212103e-04f, -6.66895956e-02f, -1.94874965e-02f, 1.44339288e-02f,
  -9.87932682e-02f, 3.74998190e-02f, -1.14157736e-01f, -3.32964957e-02f, -1.47331938e-01f, -1.55061468e-01f, -1.24986283e-01f, -1.51717395e-01f, -7.84425363e-02f, -2.98579663e-01f,
  -6.16177022e-01f, 2.82700330e-01f, 8.68728757e-02f, -4.15187359e-01f, 1.19443104e-01f, 2.98426569e-01f, 4.59549457e-01f, 2.40996312e-02f, -2.48205572e-01f, 9.85786784e-03f,
  1.39523193e-01f, -2.23833576e-01f, -1.30558759e-01f, 1.16123661e-01f, 1.94591433e-01f, 2.76253730e-01f, 1.78688169e-01f, -9.55226198e-02f, -1.76667228e-01f, -4.04729228e-03f,
  -2.57205740e-02f, -2.46165872e-01f, -4.28754151e-01f, -1.57425508e-01f, -1.34707332e-01f, -1.85287163e-01f, 2.34605428e-02f, -9.63132977e-02f, 5.71515448e-02f, 3.02999690e-02f,
  6.89953417e-02f, -2.99542189e-01f, 4.75269742e-02f, -1.26511797e-01f, -5.43828383e-02f, -1.77230150e-01f, -6.78676441e-02f, -1.51576653e-01f, -6.92914948e-02f, -7.64155313e-02f,
  -1.65319797e-02f, -6.97138384e-02f, -6.52650446e-02f, -1.46463690e-02f, -1.28887340e-01f, -1.94041897e-02f, -1.53925354e-02f, -1.43838711e-02f, -8.42828527e-02f, 8.52916613e-02f,
  3.42822254e-01f, -2.86399294e-02f, -1.89734530e-02f, 3.37873511e-02f, 5.14260828e-02f, -6.50197938e-02f, 1.26670823e-02f, -6.10583462e-02f, -6.50165007e-02f, -1.96878076e-01f,
  4.22606692e-02f, 3.71827409e-02f, 4.36807685e-02f, -5.12439981e-02f, -3.19113806e-02f, -6.09483831e-02f, 1.26622329e-02f, -1.63350776e-02f, -3.02250162e-02f, 3.43614966e-02f,
  3.90554890e-02f, 7.61153027e-02f, 5.35361841e-02f, -1.80309117e-02f, -6.42660484e-02f, 4.43752073e-02f, 1.51994685e-02f, 2.56575784e-03f, -8.54059532e-02f, -4.95266765e-02f,
  -6.69266805e-02f, 3.82113978e-02f, -1.05548486e-01f, -2.31064633e-02f, 5.48054650e-02f, 1.78028233e-02f, 4.03287672e-02f, 4.64954637e-02f, 7.49724433e-02f, 6.88218996e-02f,
  -1.37637258e-01f, 2.11272225e-01f, -5.28954752e-02f, -2.34523397e-02f, -9.18057486e-02f, -1.57080237e-02f, -9.82442722e-02f, -6.15582541e-02f, 1.54366251e-02f, -7.49892816e-02f,
  1.57047575e-03f, -1.18603468e-01f, -4.16484028e-02f, 1.25948442e-02f, -4.03354540e-02f, -9.33132246e-02f, 9.05310437e-02f, -5.17776795e-03f, 5.66961765e-02f, 1.76296402e-02f,
  6.84093237e-02f, -3.31111066e-02f, -1.58634603e-01f, 2.89424956e-02f, -1.30268754e-02f, -1.24986880e-01f, 9.45946500e-02f, -4.39434266e-03f, 1.24016888e-01f, 1.49582029e-05f,
  2.22679526e-01f, -1.37327909e-01f, 3.60407889e-01f, -9.71488208e-02f, -4.21359897e-01f, -4.22930598e-01f, -4.04884309e-01f, -1.43862233e-01f, -1.45474836e-01f, -9.71133038e-02f,
  -1.99392200e-01f, -1.87102079e-01f, 9.86887738e-02f, -7.04749599e-02f, 3.53395604e-02f, 9.90923941e-02f, 2.91142434e-01f, 2.93635428e-01f, -1.41631633e-01f, -5.17773747e-01f,
  -3.50260049e-01f, 7.99717158e-02f, 2.24699065e-01f, 1.30307764e-01f, -1.67587847e-02f, -3.62266554e-03f, 3.22794378e-01f, 5.66943362e-02f, 3.70181091e-02f, 2.43663847e-01f,
  1.53151900e-01f, 2.13305458e-01f, -5.56663685e-02f, -3.02792783e-03f, -4.56281751e-02f, 5.22535108e-02f, -8.42872355e-03f, 2.62952030e-01f, -2.60804463e-02f, 1.03615500e-01f,
  -1.91367745e-01f, -1.42593116e-01f, -9.24333036e-02f, -6.63971752e-02f, -2.15706035e-01f, -1.70973271e-01f, 1.05115712e-01f, 2.46915638e-01f, 2.59393960e-01f, -2.86323484e-02f,
  -3.72909933e-01f, -5.32546975e-02f, 4.51206006e-02f, -1.20145800e-02f, 7.10038692e-02f, 1.60780385e-01f, 4.27535214e-02f, 4.72380966e-02f, 1.18497767e-01f, 6.21052906e-02f,
  -2.41717640e-02f, 4.61234115e-02f, -1.01505354e-01f, 1.89392231e-02f, -1.94085777e-01f, -7.54365921e-02f, 5.78298718e-02f, -1.03278957e-01f, 1.11161090e-01f, -6.81575201e-03f,
  -4.76783030e-02f, 4.49764132e-02f, 3.86984274e-02f, 1.23610458e-04f, -4.51799892e-02f, 4.21202108e-02f, -1.06035590e-01f, 2.13309582e-02f, 1.35496436e-02f, 6.65343702e-02f,
  -4.57363091e-02f, -1.13130230e-02f, -1.59332994e-02f, -1.05834417e-01f, 1.25123516e-01f, 1.48919106e-01f, 1.79613149e-03f, 1.77534129e-02f, 8.25650841e-02f, 2.82773264e-02f,
  -1.93719774e-01f, 1.74735427e-01f, -5.11612855e-02f, -3.03597674e-02f, -7.88372681e-02f, -5.57823293e-02f, 1.03085309e-01f, 4.65118475e-02f, 3.90872136e-02f, -4.50824983e-02f,
  -1.06477723e-01f, 3.17028798e-02f, 4.51907143e-02f, -4.80926111e-02f, -1.93314508e-01f, -1.79304481e-01f, -2.48954743e-01f, -2.35216483e-01f, -1.74748868e-01f, 4.58322167e-02f,
  -1.26219034e-01f, -2.11688891e-01f, -2.25847661e-01f, -2.59235412e-01f, -2.14805007e-01f, -2.81866372e-01f, -1.34969100e-01f, -2.42720187e-01f, -1.45548984e-01f, -2.84281671e-01f,
  7.35783637e-01f, -1.32429078e-01f, -2.26746984e-02f, 9.78433788e-02f, 1.19708702e-02f, -1.73051909e-01f, -3.33238751e-01f, -1.30122900e-01f, 6.65837526e-02f, -6.34663925e-02f,
  1.11355692e-01f, 4.24406528e-01f, 2.05486447e-01f, 1.59770802e-01f, 7.90315866e-02f, -2.51567245e-01f, -2.13928297e-01f, 8.70327055e-02f, 2.00691089e-01f, -1.59274228e-02f,
  -1.38701409e-01f, -1.94559276e-01f, 4.63076271e-02f, -9.40662175e-02f, -2.36615837e-01f, 9.99488533e-02f, -2.00016186e-01f, 2.73338915e-03f, -5.06462380e-02f, -1.27649114e-01f,
  9.69993100e-02f, 2.91826308e-01f, 1.41093686e-01f, 1.26974002e-01f, 1.34433359e-01f, 9.62424651e-02f, 3.89707163e-02f, -1.48774356e-01f, -2.41287109e-02f, -1.60500959e-01f,
  -1.94596592e-02f, 9.28409323e-02f, 3.00540519e-03f, 1.35820759e-02f, -3.39698158e-02f, -7.57802054e-02f, -2.83020642e-02f, 4.96411743e-03f, -4.40445244e-02f, -1.36770263e-01f,
  -3.50491679e-03f, 6.61869533e-03f, 7.29233548e-02f, 2.10030265e-02f, 1.31652936e-01f, 2.33162239e-01f, 5.30943274e-02f, 2.06105765e-02f, 1.44741505e-01f, 3.36864498e-03f,
  1.03379756e-01f, -2.02044267e-02f, 1.87904164e-01f, 1.72454983e-01f, 2.12198980e-02f, 5.74368574e-02f, 2.92527694e-02f, -5.41976392e-02f, 1.20027997e-01f, 5.64971156e-02f,
  -1.78708062e-02f, 8.69960859e-02f, 1.20907724e-01f, 2.46497970e-02f, 6.72975704e-02f, 8.68952051e-02f, 2.42130719e-02f, -1.30754020e-02f, 1.06945075e-01f, 6.86485395e-02f,
  2.93559916e-02f, -8.03785250e-02f, -4.65615429e-02f, -1.38265133e-01f, -1.61603615e-02f, 6.21436276e-02f, -3.28261033e-02f, -6.01429008e-02f, 3.51436133e-03f, -9.48809162e-02f,
  1.34640941e-02f, 3.96267533e-01f, 1.15195289e-01f, 2.14919597e-02f, -2.81750057e-02f, 7.08382502e-02f, 1.56800672e-01f, -5.40484525e-02f, -2.48648338e-02f, -1.76830098e-01f,
  3.53355855e-02f, 3.05084530e-02f, 3.17644626e-02f, -1.42216891e-01f, -4.47574668e-02f, 5.47363348e-02f, 6.09077923e-02f, 1.34216338e-01f, -6.72773793e-02f, -5.40418699e-02f,
  -6.64625615e-02f, 1.17876522e-01f, 1.68660641e-01f, 1.17296753e-02f, 2.28649378e-02f, 1.70589119e-01f, -8.74515157e-03f, -1.40144462e-02f, 7.13379532e-02f, -1.94519699e-01f,
  -5.84166408e-01f, -2.92806849e-02f, 4.50054258e-01f, -4.02629852e-01f, -2.27592230e-01f, -2.91795015e-01f, -2.26661846e-01f, -2.97006279e-01f, -2.53117800e-01f, -1.26530584e-02f,
  2.72513956e-01f, 2.01298565e-01f, 2.77617872e-01f, 6.61670193e-02f, -1.61812991e-01f, -7.73636475e-02f, -1.00230880e-01f, -7.58068562e-02f, -1.80367842e-01f, -4.16128129e-01f,
  -3.15910608e-01f, -1.71959162e-01f, -3.89729172e-01f, -2.70266682e-01f, 1.74187899e-01f, 1.61554784e-01f, 3.39621276e-01f, 3.53824943e-02f, 1.02724224e-01f, 1.94984704e-01f,
  4.00011599e-01f, -2.27472723e-01f, 3.87577266e-02f, -9.85239372e-02f, 1.28753141e-01f, -6.29776274e-04f, -3.37409265e-02f, -6.17502965e-02f, -6.58769906e-02f, 1.63387619e-02f,
  -5.42860553e-02f, -2.96667833e-02f, -5.71284033e-02f, 5.76712284e-03f, -2.11190298e-01f, -1.67010516e-01f, -1.47888258e-01f, -5.35285659e-02f, -5.59350923e-02f, 3.47578079e-02f,
  -2.11785436e-01f, -1.81645185e-01f, 1.50707409e-01f, 5.79041094e-02f, 2.76542846e-02f, 2.98245866e-02f, 1.97542995e-01f, -2.00680625e-02f, 1.08713679e-01f, 1.48676306e-01f,
  -2.51871403e-02f, 1.35768414e-01f, -8.12136456e-02f, 1.38780236e-01f, -3.71227115e-02f, 1.19700134e-01f, 9.79005098e-02f, 3.32949460e-02f, -7.08340332e-02f, 9.74081233e-02f,
  -2.03003641e-02f, 3.48329283e-02f, 1.99535955e-02f, 7.10324571e-02f, 3.66747007e-02f, -2.75382474e-02f, -1.13338549e-02f, -3.65851651e-04f, -5.95456967e-03f, -7.11577162e-02f,
  -9.66665894e-02f, -1.05239533e-01f, -4.22139838e-02f, -3.37363183e-02f, -8.36060662e-03f, -1.14961348e-01f, -7.45203421e-02f, -2.50012819e-02f, -2.52791140e-02f, -3.79357450e-02f,
  2.13601530e-01f, -9.77497548e-02f, 9.35941488e-02f, -1.47425188e-02f, 6.09239899e-02f, 1.39112672e-04f, 2.65769120e-02f, -1.38456896e-01f, 9.98292677e-03f, 5.15733920e-02f,
  -1.29925519e-01f, -3.40851098e-02f, -1.37643469e-02f, -6.17237165e-05f, -7.05441460e-02f, 1.33332424e-02f, -2.03986272e-01f, 7.91918337e-02f, -4.93531376e-02f, -4.39166874e-02f,
  -8.10710192e-02f, -2.21291304e-01f, 1.24024533e-01f, 1.67165354e-01f, 1.10426955e-02f, -1.88015047e-02f, 1.65771320e-01f, 1.29834488e-01f, 2.16832310e-02f, 1.15411937e-01f,
  -1.89075500e-01f, -1.65042356e-01f, -2.61258155e-01f, -9.62516759e-03f, 1.93108305e-01f, -9.33076143e-02f, -3.96525294e-01f, -2.13572070e-01f, -1.21088745e-02f, -1.30852461e-01f,
  1.39546394e-01f, 2.01638564e-01f, -9.62385461e-02f, -8.48822370e-02f, -4.65514272e-01f, -4.33299154e-01f, -1.67271197e-01f, -2.32021809e-01f, -2.26223856e-01f, 1.50372878e-01f,
  2.57106036e-01f, -2.16132980e-02f, -8.24369043e-02f, -2.16651219e-03f, 9.50527266e-02f, 1.34659857e-01f, -1.80599894e-02f, -6.27258653e-03f, 9.90326703e-02f, -8.69529974e-03f,
  -9.37934518e-02f, -1.79962665e-01f, 6.57464340e-02f, 7.54230618e-02f, 2.16119289e-01f, -9.71864834e-02f, 4.50233705e-02f, 5.86677045e-02f, 9.76405218e-02f, -1.12801865e-01f,
  1.21976078e-01f, 3.69220244e-04f, 1.33551463e-01f, -3.70721295e-02f, -2.82479152e-02f, -1.70920506e-01f, -1.61841214e-01f, -1.19549729e-01f, -2.00658262e-01f, 6.04314990e-02f,
  1.95681691e-01f, 2.13513765e-02f, -2.57659167e-01f, -1.34547353e-01f, -2.43532181e-01f, 7.29598328e-02f, -4.20973264e-02f, 6.73669949e-02f, -2.01779976e-01f, -1.53290316e-01f,
  -1.10510038e-02f, 3.04974746e-02f, -7.32021481e-02f, -1.47304703e-02f, -4.78611104e-02f, 1.15743905e-01f, 2.01802384e-02f, -1.08590961e-01f, 1.14507325e-01f, -5.30754775e-03f,
  -1.84756182e-02f, 7.70111606e-02f, 1.35791693e-02f, -2.97993347e-02f, 1.92128047e-02f, -9.40296650e-02f, -9.52618495e-02f, -2.18976066e-02f, -1.82853974e-02f, -1.59204025e-02f,
  -1.91801023e-02f, -2.51080915e-02f, -1.84403341e-02f, -5.28359115e-02f, -1.35715343e-02f, 9.09083057e-03f, -1.12657342e-02f, 1.15863241e-01f, 6.02092594e-03f, -5.06097637e-03f,
  -7.98224881e-02f, 2.44293362e-02f, -1.52656898e-01f, -1.43502131e-01f, 1.38735786e-01f, 3.58548947e-02f, 6.78632259e-02f, 5.95835447e-02f, -3.24957520e-02f, -1.37019038e-01f,
  4.84154634e-02f, -5.05011082e-02f, 3.74739915e-02f, 9.94762108e-02f, -2.61777155e-02f, 8.19580629e-02f, 6.07053414e-02f, -3.54890376e-02f, -7.74857476e-02f, 1.04972199e-01f,
  -1.31558537e-01f, -2.38710195e-01f, -2.95423865e-01f, -2.68040240e-01f, -1.15400828e-01f, -5.04510812e-02f, -1.21249735e-01f, -1.13895833e-01f, -2.49844819e-01f, -3.19502622e-01f,
  2.08805576e-01f, -4.47437495e-01f, 3.38265181e-01f, 2.50837445e-01f, 3.32105428e-01f, 3.86941284e-01f, 2.22586483e-01f, 1.95542619e-01f, 1.20139480e-01f, -9.74824131e-02f,
  -2.70093828e-01f, -1.84635952e-01f, -2.01914683e-01f, -1.38487503e-01f, -1.81502014e-01f, 4.24922220e-02f, 1.97409973e-01f, 3.03509355e-01f, 2.14376420e-01f, 1.39111817e-01f,
  -1.94831926e-03f, 8.14925879e-02f, 8.93249437e-02f, -2.91185994e-02f, -1.05863526e-01f, 1.18910242e-02f, -3.16769667e-02f, -5.26333302e-02f, -1.34436801e-01f, 1.80636963e-03f,
  -1.52286530e-01f, -2.69132793e-01f, 1.34665132e-01f, -1.47814378e-01f, -1.52658373e-01f, -4.29401221e-03f, 1.94349289e-02f, -9.61598083e-02f, -1.15200281e-01f, -8.42291042e-02f,
  -3.82505171e-02f, -4.65001315e-02f, -1.78147182e-02f, -7.90309682e-02f, 1.52136132e-01f, 5.45124058e-03f, -1.20081954e-01f, -1.00219920e-01f, -1.17377765e-01f, -8.28901157e-02f,
  -1.64341360e-01f, 9.68124270e-02f, 7.02486709e-02f, 1.07369535e-01f, 8.57015625e-02f, 7.76651278e-02f, 7.94645026e-03f, 4.39478457e-02f, 5.53649366e-02f, 3.21688643e-03f,
  4.81316634e-02f, 1.76504076e-01f, 4.31504026e-02f, 1.36583656e-01f, 4.74064760e-02f, 5.88904880e-03f, 2.31939834e-02f, 4.63834964e-02f, 1.20915718e-01f, 1.07687622e-01f,
  1.43438816e-01f, 1.34055778e-01f, 1.36106670e-01f, -1.90269705e-02f, -4.05000858e-02f, -2.88476199e-02f, 1.19196055e-02f, -6.34378046e-02f, 3.43768187e-02f, -1.00303642e-01f,
  2.27694772e-02f, 7.92414472e-02f, 5.81573099e-02f, -6.42877817e-02f, 4.04248424e-02f, 1.25763759e-01f, 2.70217843e-02f, -5.42164333e-02f, 4.85817716e-02f, 9.29522216e-02f,
  -2.54624754e-01f, -8.58634114e-02f, -1.98218636e-02f, -1.43471986e-01f, 2.67715063e-02f, -7.68984258e-02f, -5.97712100e-02f, -9.16834548e-02f, -8.22238177e-02f, 3.21821235e-02f,
  -4.63406965e-02f, -7.82567356e-03f, -9.48641747e-02f, -1.44376094e-02f, 2.67883778e-01f, 5.54911755e-02f, -1.23555504e-01f, 5.44615053e-02f, -7.81615004e-02f, -3.82614918e-02f,
  -8.14010426e-02f, 1.28679231e-01f, 2.29971632e-01f, 1.46424770e-01f, -4.89075435e-04f, 1.18254207e-01f, 7.24978298e-02f, 6.16825372e-02f, 1.72323063e-01f, 1.01321101e-01f,
  -7.98103437e-02f, -5.03319390e-02f, -1.63596079e-01f, -1.21239208e-01f, 8.06269944e-02f, -2.39253771e-02f, -3.97959322e-01f, -1.88721165e-01f, 6.58297166e-03f, -1.47698075e-01f,
  8.30627605e-02f, 6.63029850e-02f, -1.42771065e-01f, -2.95960426e-01f, -5.29408276e-01f, -5.14330685e-01f, -4.59726304e-01f, -3.61078143e-01f, -2.46074378e-01f, -1.27980411e-01f,
  -4.64121699e-02f, -1.95853069e-01f, -2.03778699e-01f, -9.58795398e-02f, 2.66574264e-01f, 1.71772406e-01f, 1.42113447e-01f, 3.22031900e-02f, 1.73050538e-01f, -4.46341857e-02f,
  -2.94310600e-01f, 6.18236028e-02f, -1.59612611e-01f, -3.64344604e-02f, -3.00348643e-02f, 9.20566265e-03f, -7.35397413e-02f, 5.35084233e-02f, 8.51682872e-02f, -2.17618436e-01f,
  7.68655911e-02f, -4.66444455e-02f, 4.09268960e-02f, 1.11082099e-01f, -1.09654158e-01f, -9.48244855e-02f, -1.55994818e-01f, -1.38176098e-01f, -1.77189186e-01f, -2.09229048e-02f,
  -1.58571117e-02f, 3.37163769e-02f, -1.51106762e-02f, 6.19164482e-02f, 4.42241915e-02f, -7.45337233e-02f, 1.31903782e-01f, 2.20067576e-01f, 1.19474672e-01f, 7.48513192e-02f,
  2.21968889e-02f, 2.25612912e-02f, -8.26676041e-02f, 9.72964764e-02f, -9.94892940e-02f, 1.50300682e-01f, -7.31091127e-02f, -8.63713548e-02f, -7.83711299e-03f, 4.36048992e-02f,
  -1.03873037e-01f, 2.66252900e-03f, -1.15786202e-01f, -5.92361130e-02f, -1.08965568e-01f, 3.96269485e-02f, 8.98506641e-02f, -9.17143300e-02f, 1.15963787e-01f, -5.25133386e-02f,
  -5.81757762e-02f, 2.54257070e-03f, -1.12381596e-02f, -7.23306164e-02f, 9.79632288e-02f, -7.95162171e-02f, 7.87115842e-02f, 6.43178001e-02f, -2.53504757e-02f, 5.75582962e-03f,
  -1.04585946e-01f, -1.23626500e-01f, -1.02556802e-01f, -1.43711925e-01f, -7.24378303e-02f, 9.75886211e-02f, 1.83311328e-02f, 1.81817226e-02f, 3.21655385e-02f, -9.73857120e-02f,
  -3.53432819e-02f, 9.81063675e-03f, -1.12383693e-01f, -3.99275608e-02f, -1.83764189e-01f, -3.98028782e-03f, -6.35891929e-02f, -2.51900405e-02f, -1.16261337e-02f, 1.04360104e-01f,
  -1.09591909e-01f, -1.16515212e-01f, -2.06785321e-01f, -1.31668553e-01f, 2.10346747e-02f, -5.26604094e-02f, -2.25904235e-03f, 1.05140684e-02f, -1.50627822e-01f, -1.60585105e-01f,
  5.04523814e-01f, 1.07811153e-01f, 2.07442358e-01f, -7.13274628e-02f, -3.91715139e-01f, -2.46538475e-01f, -1.52966738e-01f, 8.43087882e-02f, -1.02846056e-01f, -6.53814003e-02f,
  -2.47016937e-01f, -1.19593069e-01f, -1.84076369e-01f, 4.85365745e-03f, 3.05024777e-02f, 8.76055136e-02f, 2.11439449e-02f, 3.40245157e-01f, 1.22466631e-01f, 3.90815325e-02f,
  -6.50389344e-02f, 6.80006891e-02f, 3.07920754e-01f, 2.40837932e-01f, 1.00095488e-01f, -6.38914667e-03f, 8.75106677e-02f, -5.51784970e-02f, -1.92202870e-02f, 1.84799060e-01f,
  6.41209334e-02f, 8.27896968e-02f, -1.94072574e-02f, 5.27488329e-02f, 2.17973650e-03f, 2.25981727e-01f, 4.62203622e-02f, 9.37943831e-02f, 4.68623005e-02f, -4.46612574e-02f,
  8.06100608e-04f, -5.73429391e-02f, -5.68873771e-02f, -3.74959037e-03f, 2.73272861e-02f, 5.63665926e-02f, -6.85517192e-02f, -5.09897340e-03f, -4.27597836e-02f, -1.36422152e-02f,
  -1.28009990e-01f, -9.38503444e-02f, -1.65050298e-01f, -1.15958408e-01f, -1.64981671e-02f, -1.22196667e-01f, -1.16551451e-01f, 1.11053148e-02f, 3.86253297e-02f, 1.89149052e-01f,
  2.46965345e-02f, -8.62009078e-02f, -1.25508144e-01f, -1.24573158e-02f, -1.22612551e-01f, -7.51320645e-02f, -1.27417609e-01f, -9.90733877e-02f, 5.29576801e-02f, -1.67258251e-02f,
  -1.55004814e-01f, -1.24483086e-01f, 1.10331215e-02f, -1.37689963e-01f, 7.46608377e-02f, -2.21774727e-03f, -7.65929073e-02f, -1.02318358e-02f, -8.11826810e-02f, -1.12413717e-02f,
  -1.49349883e-01f, -5.80484867e-02f, 2.62982752e-02f, -2.34872103e-03f, -1.16531914e-02f, 3.10968291e-02f, -3.19231898e-02f, -4.03468981e-02f, 3.99268642e-02f, -1.42104309e-02f,
  -3.40618640e-01f, -1.89236060e-01f, -1.63002759e-02f, 7.94978142e-02f, 5.34209013e-02f, 2.19821539e-02f, -3.03130746e-02f, 2.41889954e-02f, -2.93336436e-02f, 6.11415058e-02f,
  1.38255581e-02f, 1.82889462e-01f, 3.49003673e-02f, 4.15410735e-02f, 5.58866672e-02f, 2.41798945e-02f, -2.08627097e-02f, -1.27470866e-01f, -1.37119656e-02f, -1.01445206e-02f,
  -8.72420445e-02f, -6.94023725e-03f, -1.28428847e-01f, -9.62710008e-02f, -1.81155968e-02f, 1.93891842e-02f, -3.45254969e-03f, -5.26824109e-02f, -1.04599688e-02f, 1.55316815e-01f,
  -4.21592236e-01f, -3.46733332e-01f, 7.54189193e-02f, -6.02533937e-01f, -3.46396536e-01f, -1.92256019e-01f, -4.08212632e-01f, -1.75877571e-01f, -1.98933080e-01f, -3.95219356e-01f,
  -2.80775607e-01f, 1.15114003e-02f, -4.39160317e-02f, 2.48830393e-01f, 3.71054262e-01f, -2.83922642e-01f, 7.93372840e-03f, 4.21341270e-01f, 5.96243501e-01f, 6.07818626e-02f,
  -2.05622718e-01f, -5.76864043e-03f, 3.23172361e-01f, 1.74272165e-01f, -6.01937294e-01f, 1.75894164e-02f, -1.48879752e-01f, -2.47258186e-01f, -8.99987295e-02f, -6.14054263e-01f,
  -2.59948850e-01f, -1.91687152e-01f, 6.17557392e-02f, 1.37138337e-01f, 4.22446356e-05f, 2.83278991e-02f, -2.08318889e-01f, 2.18301341e-02f, 8.28964561e-02f, -2.93768868e-02f,
  -8.52125958e-02f, -9.56590399e-02f, -3.84048223e-02f, -7.59822205e-02f, -1.14800751e-01f, 1.01295644e-02f, 9.34318826e-02f, 1.77240536e-01f, 2.42261719e-02f, -1.42384320e-01f,
  -9.12195221e-02f, -1.18891567e-01f, -1.68313403e-02f, 8.47069100e-02f, 1.68801516e-01f, 1.24640636e-01f, 3.89830116e-03f, 3.43961716e-02f, 1.60228983e-01f, -4.53370571e-01f,
  -3.10402662e-02f, -3.47425342e-02f, -3.89532447e-02f, -6.95719346e-02f, 1.29977509e-01f, 2.78317910e-02f, 5.79472445e-02f, -5.72634675e-02f, -8.14176816e-03f, -2.41464190e-02f,
  9.15789753e-02f, 4.81706224e-02f, -3.93837749e-04f, -8.98992792e-02f, -5.54735884e-02f, -8.84909332e-02f, 4.36360128e-02f, 2.51432508e-02f, -2.05989578e-03f, 7.59086311e-02f,
  1.66682974e-02f, -1.57540068e-02f, 7.72214914e-03f, 8.48139450e-02f, 1.11433320e-01f, 9.86775234e-02f, 3.43042277e-02f, 2.47278269e-02f, -9.23610926e-02f, -2.35222466e-02f,
  -1.80956453e-01f, 4.39150393e-01f, -3.51715177e-01f, -4.12132442e-02f, -7.92950913e-02f, 5.52709848e-02f, -1.30540580e-01f, 1.82883784e-01f, -2.48972280e-03f, -9.88668948e-02f,
  -3.92847322e-02f, -1.24516852e-01f, -6.01587854e-02f, -7.76831284e-02f, -4.34178598e-02f, -2.56303065e-02f, -1.63156152e-01f, -1.17744178e-01f, 1.05695769e-01f, -6.72081262e-02f,
  3.70991230e-02f, -1.15677816e-04f, -8.44505355e-02f, -5.93767762e-02f, -9.37806144e-02f, -1.97505895e-02f, -1.18415423e-01f, -1.92479804e-01f, 1.41671196e-01f, -3.26694489e-01f,
  -1.59116298e-01f, -1.69674829e-01f, -5.51506877e-01f, -7.98478574e-02f, 2.34205052e-01f, 2.07083323e-03f, -1.90462917e-01f, -1.09283239e-01f, 3.49882036e-01f, 6.24447577e-02f,
  3.52303565e-01f, 4.93320107e-01f, 2.86558777e-01f, 1.00454874e-01f, -1.16270684e-01f, -3.13342571e-01f, -2.72225946e-01f, -1.63130447e-01f, 7.82210082e-02f, 2.87465274e-01f,
  4.45544034e-01f, 1.07620671e-01f, 1.18657388e-02f, 7.41249919e-02f, 1.99844509e-01f, 2.93936461e-01f, -1.95580512e-01f, -3.91714126e-02f, -3.59808514e-03f, -1.76281095e-01f,
  -3.67754325e-02f, -6.74626976e-02f, 2.53962036e-02f, 4.11385089e-01f, 4.46163416e-02f, -6.97146282e-02f, -8.88019204e-02f, -4.74358015e-02f, -2.78233010e-02f, -6.23189658e-02f,
  1.19271904e-01f, -6.46623364e-03f, 1.47186301e-03f, 1.18861124e-02f, 1.37890968e-02f, 6.44786060e-02f, -2.35833600e-01f, -3.50838780e-01f, -3.78618270e-01f, -5.81908040e-02f,
  9.74491909e-02f, 2.43383810e-01f, -1.73234418e-01f, -3.32525909e-01f, -3.40189308e-01f, 4.74214889e-02f, -2.12685779e-01f, -1.46521598e-01f, -3.52030873e-01f, -3.71369094e-01f,
  7.57498518e-02f, -8.23063683e-03f, -7.23036975e-02f, -5.36454245e-02f, 8.67048725e-02f, -6.15274087e-02f, 7.30187893e-02f, 5.57468757e-02f, -7.63759241e-02f, -1.10108085e-01f,
  5.86839579e-02f, 1.02915488e-01f, 1.10502966e-01f, -1.80079211e-02f, 1.19544305e-01f, -1.30021777e-02f, 3.85621469e-03f, -3.81997153e-02f, -1.22694008e-03f, 7.21485466e-02f,
  3.22060175e-02f, -1.08805679e-01f, -8.04419070e-02f, -4.42813970e-02f, -3.67762186e-02f, -3.27680521e-02f, 1.85281374e-02f, 5.32888025e-02f, 2.92465743e-02f, 6.09929189e-02f,
  2.51871571e-02f, -4.06003185e-02f, 2.38168091e-02f, -3.84475403e-02f, -6.41036257e-02f, -2.89332885e-02f, 1.19771166e-02f, -2.18240283e-02f, 4.10436392e-02f, -4.32403088e-02f,
  -1.38215318e-01f, -1.47963271e-01f, -1.05307549e-01f, -2.39915289e-02f, 7.62766153e-02f, -1.77370496e-02f, -8.36607516e-02f, 4.48407494e-02f, -1.31488591e-01f, -8.29070061e-02f,
  -2.69919515e-01f, -1.35444149e-01f, 1.97460856e-02f, -1.52488619e-01f, -1.24581203e-01f, 9.21355709e-02f, -8.51405114e-02f, -1.23849973e-01f, -2.19018996e-01f, -2.19863847e-01f,
  2.92361863e-02f, 3.22220683e-01f, 1.22683369e-01f, -3.26748267e-02f, 1.59287006e-01f, -3.23452093e-02f, 1.75241098e-01f, -3.55442800e-02f, -9.37305763e-02f, 4.68491875e-02f,
  2.01069117e-01f, -2.66902111e-02f, 2.23255996e-02f, -1.35576632e-02f, -1.62068561e-01f, -3.32082920e-02f, 1.07598454e-01f, -1.14453405e-01f, -2.07029551e-01f, -1.52540654e-01f,
  -8.44539423e-03f, -1.70044601e-02f, -1.22064548e-02f, -3.38777015e-03f, 2.82526672e-01f, -3.75338830e-02f, 1.81460921e-02f, 1.55904934e-01f, 2.46418238e-01f, 2.30407611e-01f,
  1.00811779e-01f, 2.45671824e-01f, -3.28022897e-01f, -2.43509561e-02f, 3.67235765e-02f, -1.16691269e-01f, -1.60329297e-01f, -1.46665126e-01f, -1.03384554e-02f, -1.61137745e-01f,
  1.44402236e-01f, 1.07979260e-01f, 1.70670733e-01f, -1.32793896e-02f, -5.87081090e-02f, -9.52358246e-02f, 1.31907547e-02f, -8.86484236e-03f, -1.70139119e-01f, -8.38927776e-02f,
  1.45247251e-01f, 1.88163474e-01f, 4.90110321e-03f, -2.81320155e-01f, -1.51700854e-01f, -1.98089778e-01f, -7.05872625e-02f, -1.24867536e-01f, -2.43573517e-01f, -1.88642874e-01f,
  -2.52199709e-01f, 2.67456025e-02f, -1.11235743e-02f, -1.09994940e-01f, -2.01427285e-02f, -1.90166786e-01f, -7.65694976e-02f, -7.20030814e-03f, -7.01847002e-02f, -9.36364159e-02f,
  -7.23243579e-02f, -1.20012015e-01f, -4.65718023e-02f, -1.63225189e-01f, -1.08319834e-01f, 1.92253944e-02f, -1.71511397e-01f, -8.11306611e-02f, -5.57244681e-02f, -2.39557661e-02f,
  8.61739665e-02f, -3.36945336e-03f, 9.53794420e-02f, 2.17111502e-02f, -4.09908034e-02f, -1.88489869e-01f, -1.42929986e-01f, -1.75475493e-01f, -1.13181241e-01f, -1.01843560e-02f,
  -5.36152311e-02f, 8.83286670e-02f, -1.87315065e-02f, 1.79326147e-01f, 2.19969094e-01f, 6.22210242e-02f, 2.17025191e-01f, 1.69898868e-01f, 1.48495898e-01f, -1.05173104e-01f,
  -3.58011238e-02f, 6.93283677e-02f, 1.80664837e-01f, 5.77165522e-02f, -8.39592516e-02f, 1.39294453e-02f, 1.50497437e-01f, 1.18398154e-02f, 3.97551991e-02f, 1.19079225e-01f,
  7.11305961e-02f, -1.05005465e-01f, -2.13326529e-01f, -1.63029298e-01f, -1.60582155e-01f, -2.50352949e-01f, -4.57520299e-02f, -1.48132697e-01f, -1.47919625e-01f, -2.04087242e-01f,
  -2.33893022e-01f, -2.19187930e-01f, -1.33807003e-01f, -3.94631267e-01f, -2.99182907e-02f, 8.98115709e-02f, -1.79099634e-01f, -8.70378688e-02f, -1.78780124e-01f, -2.68461466e-01f,
  3.59122269e-02f, 2.23631680e-01f, -9.14434195e-02f, -4.52938154e-02f, -1.65710762e-01f, -4.60789829e-01f, -4.44186807e-01f, -2.66933590e-01f, 2.86240280e-01f, 3.65176946e-01f,
  1.46558106e-01f, -5.50699905e-02f, 4.48606573e-02f, 2.50404142e-02f, -7.43392622e-03f, -1.88199431e-02f, -2.71246523e-01f, -4.80940053e-03f, -1.85972627e-03f, -1.71111673e-01f,
  3.64757217e-02f, -1.44340796e-02f, 1.84240729e-01f, 5.64877130e-02f, 1.21568553e-01f, 9.21641067e-02f, 1.00301355e-01f, -9.64592323e-02f, 9.27280411e-02f, -8.82507339e-02f,
  -7.57739833e-03f, 2.16124475e-01f, -7.52541199e-02f, 1.84456646e-01f, -8.31519738e-02f, -1.46856442e-01f, -1.25030801e-01f, -4.02231999e-02f, -1.48039192e-01f, 1.14363292e-02f,
  2.45193578e-02f, -2.04918291e-02f, -8.59104916e-02f, -4.23660614e-02f, -1.81611963e-02f, -1.20617852e-01f, 1.91798419e-01f, 1.45710021e-01f, -1.37073576e-01f, -2.52888858e-01f,
  2.16855835e-02f, 1.54593093e-02f, -6.72712177e-03f, 7.03995749e-02f, -4.83381338e-02f, -1.27076626e-01f, 3.57694402e-02f, 3.41609307e-02f, 1.21358953e-01f, -9.93733015e-03f,
  -3.56305279e-02f, 1.03489924e-02f, -3.58900428e-02f, -7.10387677e-02f, 4.52572294e-02f, -1.23802431e-01f, -7.40389992e-03f, -5.06715626e-02f, 2.17450596e-02f, -1.02010936e-01f,
  9.93969291e-03f, 9.43681039e-03f, -8.12667608e-02f, -4.44714054e-02f, -1.01753093e-01f, -1.22086585e-01f, -6.81723282e-02f, 1.20766193e-01f, -2.52090283e-02f, -8.49965587e-02f,
  -2.23229267e-02f, 2.04495061e-03f, -4.06511389e-02f, -4.26197089e-02f, -6.64781258e-02f, -8.95504281e-02f, -4.07569483e-02f, 7.78765753e-02f, 5.72633706e-02f, 1.58351976e-02f,
  2.93293335e-02f, 1.33626699e-03f, -1.39142454e-01f, 7.89760202e-02f, 9.45910290e-02f, -6.02186732e-02f, -1.52776986e-01f, -8.53514671e-02f, 1.25413045e-01f, -2.79738544e-03f,
  -2.12838545e-01f, -5.95055558e-02f, -1.43189833e-01f, -1.82590395e-01f, -9.53265578e-02f, -1.54734120e-01f, -2.51729321e-02f, -2.41187662e-02f, -5.85849583e-02f, -2.62438267e-01f,
  4.84848589e-01f, -5.36799967e-01f, 2.94679981e-02f, -3.83879505e-02f, 3.34151126e-02f, 1.37867883e-01f, -8.24316517e-02f, 4.25242446e-02f, 1.19915120e-01f, -1.37421712e-01f,
  -2.36970801e-02f, 2.89151818e-01f, 2.77075022e-01f, 2.17264250e-01f, 1.78278282e-01f, -8.91605988e-02f, 3.85788269e-02f, 3.15704405e-01f, 3.10548306e-01f, 6.76520467e-02f,
  -6.88829124e-02f, -2.16972351e-01f, -1.28700852e-01f, -3.83762904e-02f, -3.00213963e-01f, 4.16786522e-02f, -2.02644005e-01f, -2.74554372e-01f, -9.01893526e-02f, -2.92689443e-01f,
  -8.54879916e-02f, -1.13739401e-01f, 1.27205953e-01f, -2.09518429e-02f, -1.20388523e-01f, -8.67489278e-02f, -1.48292165e-02f, -9.97711942e-02f, 2.08718330e-02f, -1.14825517e-01f,
  -2.70167664e-02f, -1.14330381e-01f, 4.43184469e-03f, -8.43400434e-02f, -1.21963196e-01f, 1.27602089e-03f, -9.15261805e-02f, 1.60752106e-02f, -1.23285195e-02f, -1.42207891e-01f,
  -1.27907217e-01f, -3.40948664e-02f, 6.53119907e-02f, -4.81458530e-02f, -2.37799902e-02f, 1.36350274e-01f, -8.79311860e-02f, 7.03116227e-03f, 1.16094671e-01f, -2.12114871e-01f,
  -1.25922393e-02f, 5.63712455e-02f, -2.19699051e-02f, 5.30936457e-02f, 3.32706561e-03f, 3.61006819e-02f, 1.30296005e-02f, -6.83050156e-02f, 9.27238017e-02f, -5.70096150e-02f,
  -5.74728809e-02f, -1.20288869e-02f, -6.39225682e-03f, -6.86677918e-02f, 1.30841164e-02f, 7.67928408e-03f, -1.04849022e-02f, -8.28467458e-02f, 4.89239991e-02f, 8.99801478e-02f,
  1.20247684e-01f, 2.23809723e-02f, 1.54921005e-03f, -2.40095742e-02f, 3.34190158e-03f, -1.49352299e-02f, -4.09494564e-02f, 1.10073085e-03f, 1.43744927e-02f, -7.45286644e-02f,
  -2.60728538e-01f, 2.63532430e-01f, 6.07887544e-02f, -2.08093654e-02f, -3.56003493e-02f, -4.74503413e-02f, -5.88622838e-02f, -2.33065952e-02f, -6.69307485e-02f, 6.06466504e-03f,
  -8.46731439e-02f, 4.85152602e-02f, -1.09732069e-01f, 2.23713554e-02f, -4.35535982e-02f, -6.34615216e-03f, 8.59676115e-03f, 5.08367494e-02f, 9.55118984e-02f, -1.09882146e-01f,
  -1.61304608e-01f, 5.32847755e-02f, 5.04122674e-02f, 1.12499893e-01f, -3.20476107e-03f, 1.50673375e-01f, 8.00045282e-02f, -8.70915782e-03f, 1.73280448e-01f, -5.75406998e-02f,
  1.11521268e-02f, -5.22946179e-01f, -1.98469181e-02f, -2.80332178e-01f, -9.41236392e-02f, 2.53390651e-02f, -3.62018235e-02f, -1.90417338e-02f, -2.62587786e-01f, -2.29669556e-01f,
  -3.26035410e-01f, -1.48386076e-01f, -1.55351236e-01f, -6.42280579e-02f, 2.77491193e-02f, -1.58366501e-01f, -1.06676877e-01f, 1.55178428e-01f, 4.23261881e-01f, 1.72140345e-01f,
  -1.42986793e-02f, -1.00012973e-01f, -1.08956126e-02f, -1.44620687e-01f, -3.05518061e-01f, 8.51041824e-02f, -2.19850332e-01f, -2.35904932e-01f, -2.02198550e-01f, -4.28641379e-01f,
  2.24504396e-01f, -2.95241535e-01f, 3.57399359e-02f, -1.74372345e-01f, -1.83766529e-01f, -1.35989757e-02f, 1.48155447e-02f, -7.72251487e-02f, -4.39329036e-02f, 6.71420246e-02f,
  -7.20947757e-02f, -8.07292294e-03f, 7.95209929e-02f, 8.60244930e-02f, 5.86254597e-02f, 5.92294671e-02f, -5.94249889e-02f, -1.09721489e-01f, -2.34466642e-01f, -5.27128763e-03f,
  -5.31718060e-02f, 8.03328119e-03f, 2.20984146e-02f, 8.88737733e-04f, -1.92519948e-02f, 4.37323116e-02f, -1.10148758e-01f, -1.64808296e-02f, -6.62317052e-02f, -5.33752665e-02f,
  1.17453868e-02f, -4.67104577e-02f, -8.79053026e-03f, 5.36762737e-02f, 8.81662369e-02f, 4.51571494e-02f, 6.25099093e-02f, -9.19736549e-03f, -3.72507460e-02f, 2.53089201e-02f,
  -1.49959013e-01f, -6.23534732e-02f, -1.01353079e-01f, -1.44601285e-01f, -1.70975566e-01f, -8.79382789e-02f, -6.13449514e-02f, -1.08865216e-01f, -6.38978407e-02f, -4.09608819e-02f,
  -1.57780752e-01f, -5.80696687e-02f, -5.80584537e-03f, -6.69605210e-02f, -2.19195336e-01f, -4.82268073e-02f, -1.11111827e-01f, 1.56609882e-02f, 1.20212875e-01f, -8.60196203e-02f,
  5.01294509e-02f, -4.77409698e-02f, 1.15150280e-01f, 8.71083587e-02f, 1.71075165e-02f, -2.04866409e-01f, -1.40830979e-01f, -4.72856127e-02f, -1.05216861e-01f, 8.89908895e-02f,
  1.59273017e-02f, 2.18261406e-02f, 2.94876806e-02f, -4.65111434e-02f, 2.15855181e-01f, 1.40257016e-01f, -5.21387197e-02f, -1.66574456e-02f, 4.01083753e-03f, 1.02469195e-02f,
  -1.14408068e-01f, 4.02637720e-02f, 1.42322317e-01f, 1.45562857e-01f, -2.23288648e-02f, 1.35720059e-01f, 4.67325673e-02f, 9.53156576e-02f, 2.21466914e-01f, 1.61740810e-01f,
  -2.32046947e-01f, -3.32544625e-01f, 8.69068503e-02f, 2.99140811e-01f, 2.60457635e-01f, -1.46653518e-01f, -4.19332415e-01f, -2.56487966e-01f, -6.65138615e-03f, -6.81362748e-02f,
  -8.10306892e-03f, 3.29416603e-01f, 3.06746513e-01f, 2.43277594e-01f, -2.56274641e-02f, -1.43270731e-01f, 3.71672451e-01f, 3.74680668e-01f, 2.17034891e-01f, 7.69352987e-02f,
  2.74217188e-01f, 2.63296843e-01f, 3.07460517e-01f, 2.98154682e-01f, 1.38178021e-01f, 2.93989092e-01f, 2.16041431e-01f, 1.10795736e-01f, 5.46219908e-02f, 2.13887289e-01f,
  -3.06431264e-01f, -3.18275422e-01f, 1.14215873e-01f, 2.74431370e-02f, 8.71726945e-02f, 1.94820836e-02f, -6.04933612e-02f, 1.23666108e-01f, -7.69096389e-02f, -8.06279555e-02f,
  3.67241167e-02f, -1.16887815e-01f, 2.41108052e-02f, 5.22543751e-02f, -1.15752794e-01f, -1.49736792e-01f, 1.29085621e-02f, -1.47913754e-01f, -8.26636329e-02f, -1.20312624e-01f,
  2.49195099e-01f, 8.23936891e-03f, -2.71814883e-01f, -1.18765764e-01f, -2.91037560e-01f, 2.32354984e-01f, -1.56699896e-01f, -9.90686268e-02f, -1.84148565e-01f, -1.28318951e-01f,
  5.45914099e-02f, 1.95147358e-02f, -1.48734599e-01f, -1.52227551e-01f, -3.49270888e-02f, -6.12105466e-02f, 3.26107405e-02f, 2.36372799e-02f, -2.13872716e-02f, 8.68341047e-03f,
  4.08063456e-02f, 4.27556671e-02f, 2.06089877e-02f, -6.89085349e-02f, 1.64516240e-01f, -5.80758676e-02f, -2.74268761e-02f, 2.07727612e-03f, 6.67454451e-02f, -1.03383884e-01f,
  -9.44553968e-03f, -7.06322864e-02f, 1.00147329e-01f, 9.41025838e-02f, 3.04467641e-02f, 9.95832160e-02f, 3.25735249e-02f, 1.08521301e-02f, -5.82662318e-03f, 5.91302551e-02f,
  6.18019626e-02f, 2.65984952e-01f, -2.10469678e-01f, -7.61209652e-02f, -6.12978972e-02f, -1.82263944e-02f, 6.37462363e-02f, 5.73505200e-02f, -9.32097435e-02f, 2.79152263e-02f,
  -1.08120754e-01f, -1.16207249e-01f, -6.38831183e-02f, -1.58066321e-02f, 5.09036854e-02f, -6.37599975e-02f, -1.28473744e-01f, -7.25349262e-02f, -8.25392362e-03f, -1.07282281e-01f,
  9.83034074e-03f, -1.45381212e-01f, -1.83921337e-01f, -2.32044786e-01f, -1.87765777e-01f, 9.19425488e-02f, -1.30178422e-01f, -2.39960164e-01f, -1.52043328e-01f, -3.18518460e-01f,
  3.55395436e-01f, 1.86716959e-01f, -2.78968364e-01f, 2.92845726e-01f, -1.85430050e-01f, -4.33209777e-01f, -3.19313824e-01f, -2.10924238e-01f, 1.15198620e-01f, 8.45864862e-02f,
  6.23529032e-02f, -1.44549951e-01f, 7.26047754e-02f, -2.85601616e-01f, -2.94962972e-01f, -1.06667697e-01f, -4.21693064e-02f, -3.27885509e-01f, -5.28432190e-01f, -5.83449483e-01f,
  -3.03719074e-01f, 5.01508117e-02f, -1.39898986e-01f, -1.52759507e-01f, 7.19736814e-02f, -2.45375913e-02f, 2.60346830e-02f, -7.87471309e-02f, -2.06512347e-01f, -3.97976525e-02f,
  2.11745538e-02f, 2.45438237e-02f, -8.56338069e-02f, -6.70011118e-02f, 5.09067886e-02f, 4.33916412e-02f, -2.79256050e-02f, -6.23018481e-02f, 6.49212897e-02f, -7.14234188e-02f,
  -5.28536253e-02f, -1.86139762e-01f, -1.76904574e-01f, -7.08048344e-02f, -1.69123843e-01f, -1.35163441e-01f, -9.22818109e-02f, -1.24519303e-01f, -7.52088130e-02f, -1.88596681e-01f,
  -1.45559236e-01f, -1.12585202e-01f, 1.84354130e-02f, -2.41079908e-02f, -1.21410012e-01f, -8.97119939e-02f, -4.98839170e-02f, -2.78636068e-01f, -6.72616363e-02f, 3.25464636e-01f,
  -8.45860764e-02f, 1.24002822e-01f, -7.27048516e-02f, 2.09389422e-02f, 8.60426798e-02f, 6.64985850e-02f, 1.28174247e-02f, 6.53109774e-02f, -1.16048850e-01f, 2.75754984e-02f,
  -3.69460359e-02f, 4.03789425e-04f, -1.96846644e-03f, 4.93058637e-02f, 6.89417822e-04f, -7.85777494e-02f, -5.49544878e-02f, 2.11268328e-02f, -9.00903642e-02f, -5.62290363e-02f,
  3.61344442e-02f, -2.50353198e-02f, 9.06914920e-02f, -2.03507417e-03f, -9.95825753e-02f, 6.04845248e-02f, -6.81194589e-02f, -1.01789191e-01f, -4.94154915e-02f, -1.12490423e-01f,
  3.06534886e-01f, -5.47641255e-02f, 2.80976534e-01f, -9.56991240e-02f, 7.34732375e-02f, -1.25440555e-02f, 8.70043486e-02f, -9.53294709e-03f, 1.40247881e-01f, 6.62509650e-02f,
  -1.48065090e-01f, 1.90172403e-03f, -5.56860454e-02f, 3.71680073e-02f, -1.87975571e-01f, -4.16759141e-02f, 9.47827566e-03f, -2.09038169e-03f, -1.57613277e-01f, 8.83227959e-03f,
  1.52587742e-01f, 1.19509161e-01f, 2.26420566e-01f, 2.14585528e-01f, 1.06032668e-02f, 1.58085302e-01f, 1.44244984e-01f, -3.73181440e-02f, 6.63084071e-03f, 3.14565212e-01f,
  -1.02401800e-01f, -6.29031137e-02f, -5.44648990e-02f, -1.43825814e-01f, 2.92341672e-02f, 9.63085070e-02f, -2.48527437e-01f, 9.35019255e-02f, 2.01728359e-01f, -1.03653118e-01f,
  6.13077320e-02f, 8.73786211e-02f, -1.67533278e-01f, -9.20592025e-02f, -1.63847372e-01f, -2.71892786e-01f, -3.31968158e-01f, -2.23127484e-01f, -2.89980844e-02f, -1.73822194e-02f,
  -7.54889473e-02f, 2.87453961e-02f, -1.29630148e-01f, -4.67764772e-02f, -1.36760399e-01f, -1.00234792e-01f, -1.45901948e-01f, -9.05676559e-02f, -1.55170664e-01f, -3.05603832e-01f,
  -1.44918129e-01f, 6.40094653e-02f, 2.37116721e-02f, -4.42731334e-03f, 3.10809072e-02f, 3.15944403e-02f, 2.35730670e-02f, 2.14287359e-02f, 9.73154381e-02f, -1.36110216e-01f,
  5.42070828e-02f, 1.92640960e-01f, 2.33949181e-02f, 5.00972830e-02f, -5.82297109e-02f, -9.34526399e-02f, 1.07565396e-01f, -2.87773348e-02f, -1.18502714e-01f, 1.72005504e-01f,
  6.16642907e-02f, -1.91086948e-01f, -1.47492573e-01f, -5.10606878e-02f, 3.61005217e-02f, -1.70693129e-01f, -4.60557193e-02f, -8.44761953e-02f, -2.07771748e-01f, -3.66206706e-01f,
  3.51169700e-04f, 4.51295674e-02f, 1.56859905e-01f, 1.03531562e-01f, -5.43911122e-02f, -6.73798611e-03f, 4.13460238e-03f, -1.79053441e-01f, -1.92725472e-02f, -3.42093743e-02f,
  3.58027704e-02f, 7.73467049e-02f, -3.77574787e-02f, -1.40338957e-01f, -9.76520479e-02f, -1.82479620e-02f, -1.00048780e-01f, -1.36077449e-01f, -1.93143904e-01f, -6.11856207e-02f,
  -2.39469875e-02f, 1.45339929e-02f, 8.57428685e-02f, 2.15951446e-02f, -4.82056923e-02f, -7.93429017e-02f, 3.18709426e-02f, 5.07921167e-02f, -1.22126907e-01f, 4.84738909e-02f,
  -6.99906126e-02f, 9.82175246e-02f, -1.50266185e-01f, -1.24257617e-01f, 9.90793779e-02f, 2.92262551e-03f, -1.08832661e-02f, 1.41733751e-01f, 7.75212273e-02f, 8.69812146e-02f,
  -4.59798574e-02f, 4.21388261e-02f, -6.25524595e-02f, 6.17340915e-02f, -6.64619775e-03f, -1.11600570e-01f, -9.92674474e-03f, -1.66465268e-01f, 3.86210717e-03f, 3.90000232e-02f,
  -6.19415827e-02f, -3.05423975e-01f, -3.28322172e-01f, -2.33109608e-01f, -1.07537366e-01f, -3.12515765e-01f, -1.87935844e-01f, -2.15616539e-01f, -2.41418570e-01f, -3.93474579e-01f,
  -1.71590015e-01f, -1.44609977e-02f, 2.93325126e-01f, 6.15380555e-02f, -1.90333664e-01f, -3.11109543e-01f, -3.65433544e-01f, -1.75573096e-01f, -8.52086172e-02f, -1.51640654e-01f,
  -2.94558197e-01f, -8.52572098e-02f, -3.99723984e-02f, 9.06191170e-02f, 1.43110991e-01f, 2.13946536e-01f, 4.14595872e-01f, 4.60030168e-01f, 1.67628497e-01f, 9.77766421e-03f,
  1.33790448e-01f, 2.86613196e-01f, 2.08687350e-01f, 2.78738350e-01f, 1.55569211e-01f, 1.02124169e-01f, 1.76023021e-01f, 1.11172691e-01f, 3.38789634e-03f, 4.34029520e-01f,
  -2.33456641e-01f, -1.52983963e-01f, 1.41050201e-02f, -9.12526809e-03f, 1.36858663e-02f, 1.37799643e-02f, -1.07975882e-02f, 1.79837167e-01f, -1.26255348e-01f, -2.01868583e-02f,
  2.51402357e-03f, -7.29885697e-02f, -5.61502427e-02f, 1.41671449e-01f, -4.99448441e-02f, -1.49994671e-01f, 3.14257503e-01f, 2.91745245e-01f, 1.11653864e-01f, -7.53328353e-02f,
  2.93732099e-02f, -1.66595504e-01f, -2.54326016e-01f, -1.18137218e-01f, -1.35454133e-01f, 6.67012706e-02f, -5.61321601e-02f, 5.45738339e-02f, -2.09017575e-01f, -2.93324888e-02f,
  -1.80372521e-01f, -8.55850205e-02f, 5.48679754e-02f, 1.03067704e-01f, 1.15641929e-01f, 3.79883591e-03f, 3.88289914e-02f, 1.17965294e-02f, 1.28196925e-01f, 6.39047548e-02f,
  -7.62489390e-06f, -2.82328669e-02f, -2.58214335e-04f, -4.41790298e-02f, -5.30577712e-02f, -4.80086617e-02f, -3.91255431e-02f, 7.30765462e-02f, -4.53251041e-02f, 4.10770588e-02f,
  2.09882334e-02f, 5.63622154e-02f, 1.00388959e-01f, 6.65163770e-02f, -2.59298924e-02f, 3.84272411e-02f, -1.31353617e-01f, -4.47925963e-02f, 1.35580208e-02f, -7.29688853e-02f,
  -6.54942244e-02f, 1.16788507e-01f, -1.53041542e-01f, 1.12208225e-01f, -1.21353455e-01f, -6.89640194e-02f, -1.92557722e-02f, -7.47032762e-02f, -9.98997986e-02f, -6.24487177e-02f,
  -1.23038568e-01f, 2.68488284e-02f, 7.94793814e-02f, 1.03761762e-01f, 2.68686078e-02f, -1.74426854e-01f, 5.03800884e-02f, 3.18362340e-02f, 3.96016762e-02f, -9.39671025e-02f,
  1.23952962e-01f, -2.94994891e-01f, -3.23542595e-01f, -1.31078541e-01f, -2.36073405e-01f, -2.81248778e-01f, -1.74416542e-01f, -2.03407034e-01f, -3.38589996e-01f, -2.63582647e-01f,
  6.60086989e-01f, 3.06644320e-01f, 2.17663139e-01f, 1.64055273e-01f, -1.46101220e-02f, 1.78608000e-01f, 2.77336180e-01f, 1.53100297e-01f, 2.43097730e-02f, 1.25215903e-01f,
  1.51408017e-01f, 1.24920629e-01f, 8.71532261e-02f, 1.49257690e-01f, 1.35343447e-01f, 9.82540697e-02f, 1.15290675e-02f, 6.10367171e-02f, 1.12626456e-01f, 1.66650027e-01f,
  -1.42386639e-02f, 6.77354410e-02f, 2.16703430e-01f, 1.67237207e-01f, -4.58254628e-02f, -1.67728528e-01f, -2.41489392e-02f, 1.10121414e-01f, 9.27732810e-02f, -1.49803981e-01f,
  -2.33288705e-01f, 3.06176364e-01f, -8.94005820e-02f, -1.81633174e-01f, -6.52442276e-02f, 1.05599895e-01f, 6.50853813e-02f, 1.62125602e-02f, 1.98959876e-02f, -1.51839674e-01f,
  -1.31014436e-01f, -2.11560726e-03f, -1.45088779e-02f, 5.44896722e-02f, 5.32888323e-02f, 6.54875487e-02f, 6.88617304e-02f, 2.86431685e-02f, 3.82496715e-02f, -1.33566307e-02f,
  -9.20125619e-02f, -1.00798897e-01f, 4.35915329e-02f, -8.43506381e-02f, 7.92874470e-02f, -1.16557620e-01f, -6.47951141e-02f, -4.83494177e-02f, -4.30616401e-02f, 4.55306470e-02f,
  -2.01673627e-01f, -6.45933375e-02f, 3.87470946e-02f, 9.64089334e-02f, 1.28304750e-01f, 3.48032518e-05f, 4.52790000e-02f, -6.38698339e-02f, 4.26132455e-02f, 2.19750367e-02f,
  -7.79366568e-02f, -1.20239528e-02f, 3.40926237e-02f, 8.28491077e-02f, 4.72215749e-03f, -3.97194065e-02f, -1.00707822e-01f, 6.03218004e-02f, 4.52619195e-02f, 5.70939528e-03f,
  -5.10323346e-02f, -1.01857357e-01f, 1.60976052e-01f, 1.29296541e-01f, 3.43554690e-02f, 1.68213956e-02f, 2.89340969e-02f, 3.88129205e-02f, 1.18283130e-01f, -5.77411093e-02f,
  -2.24489152e-01f, 2.40874693e-01f, -1.08713008e-01f, -1.85610086e-01f, -1.17577881e-01f, -3.65898833e-02f, 5.64331114e-02f, -8.52593593e-03f, -1.71555176e-01f, -1.79830089e-01f,
  -9.38650891e-02f, 8.01720247e-02f, 1.49029404e-01f, 5.87770296e-03f, 2.12125992e-03f, -9.34239849e-02f, -4.29658629e-02f, -1.11903302e-01f, -2.69577019e-02f, -1.19271204e-01f,
  8.93432926e-03f, -1.25140578e-01f, -2.27668613e-01f, -1.84210822e-01f, -1.23165697e-02f, -8.25573206e-02f, 4.95822541e-03f, -1.19381838e-01f, -1.28411846e-02f, 3.97746312e-03f,
  4.56808835e-01f, -1.95963979e-01f, -5.42417347e-01f, -8.25692937e-02f, -2.48802975e-01f, -1.65326938e-01f, -1.81781352e-01f, 1.42117087e-02f, -3.67673337e-02f, -2.31366649e-01f,
  -1.34358436e-01f, 2.38121748e-01f, -6.74519241e-02f, -9.88922920e-03f, 1.91617832e-01f, -3.16314787e-01f, -4.31631029e-01f, -1.11482553e-01f, 2.06193805e-01f, 8.27282891e-02f,
  -7.28321597e-02f, 1.27173617e-01f, 2.76576355e-02f, -3.39028314e-02f, -1.80315748e-01f, -7.72914141e-02f, -3.48244846e-01f, -2.86321044e-01f, -1.73143625e-01f, -4.13755894e-01f,
  -3.57496679e-01f, -2.26544783e-01f, -1.62177816e-01f, 1.58333749e-01f, -1.87470317e-01f, 8.64566267e-02f, 5.69860488e-02f, -2.45360155e-02f, -1.34120686e-02f, -2.14089260e-01f,
  -1.20617211e-01f, 1.31539613e-01f, 2.47955829e-01f, -4.63735238e-02f, -1.16590418e-01f, 8.75429902e-03f, -4.42277156e-02f, 3.94266061e-02f, -5.79702966e-02f, -6.90348595e-02f,
  -5.71553856e-02f, -1.43186683e-02f, -2.21759584e-02f, 1.48373684e-02f, -7.23990351e-02f, -1.46416444e-02f, -2.25455582e-01f, -1.80912632e-02f, -9.44538116e-02f, -1.67420506e-01f,
  -3.03179305e-02f, -3.48232724e-02f, -6.60105497e-02f, 8.91048536e-02f, 9.13321674e-02f, -6.39223829e-02f, 1.50772721e-01f, 1.97368562e-01f, 5.72451241e-02f, 2.50011571e-02f,
  3.45095247e-02f, -5.18278889e-02f, -1.82376653e-02f, 7.02623054e-02f, -2.77286731e-02f, 5.70235066e-02f, 2.35831812e-02f, 4.23579589e-02f, -4.21329476e-02f, 6.01431951e-02f,
  8.60808864e-02f, -2.50124242e-02f, -1.56675324e-01f, 1.49379671e-01f, -9.04763564e-02f, -1.56492961e-03f, 6.07173070e-02f, 8.26219935e-03f, 3.57712358e-02f, -6.48034364e-02f,
  2.88822621e-01f, -1.01168357e-01f, -1.45728976e-01f, 2.07311928e-01f, -4.70729396e-02f, -2.17781425e-01f, -1.05715901e-01f, 1.42762050e-01f, 9.08675566e-02f, 7.87488818e-02f,
  2.64489703e-04f, 1.21732861e-01f, 4.95295832e-03f, -4.65336666e-02f, 2.25466047e-03f, 3.14516425e-02f, -3.38916779e-02f, 1.44673556e-01f, 9.43507850e-02f, -3.31407003e-02f,
  -1.23309441e-01f, 3.27133566e-01f, 3.93173993e-01f, 2.74369977e-02f, 1.49779052e-01f, 1.64707780e-01f, -9.80699286e-02f, 5.68943769e-02f, 1.19468033e-01f, 1.39094502e-01f,
  -3.61081898e-01f, 1.45298883e-01f, -2.48041496e-01f, 5.49047813e-02f, 3.11581880e-01f, 1.34925172e-01f, 7.17664137e-02f, -7.93003812e-02f, 1.17902949e-01f, 7.16501381e-04f,
  -1.72197133e-01f, 1.89875811e-02f, 3.36540379e-02f, 7.73538277e-02f, -1.43030241e-01f, 2.01106116e-01f, 2.44018242e-01f, -1.18549950e-01f, -1.52277231e-01f, 4.65005264e-02f,
  3.29208821e-01f, 1.56647682e-01f, -6.92189932e-02f, 5.26452698e-02f, 1.85861796e-01f, 6.33701161e-02f, 1.84914157e-01f, 5.59302382e-02f, 1.87930554e-01f, 2.06439048e-01f,
  -2.17884511e-01f, -3.44832450e-01f, -3.90897738e-03f, -6.65642545e-02f, -1.09285302e-01f, -2.41371810e-01f, -2.40087986e-01f, -2.32090965e-01f, -1.76304147e-01f, 5.95582500e-02f,
  5.26149459e-02f, -1.35425106e-01f, -1.03305653e-01f, 3.46167237e-02f, 1.26720136e-02f, -2.29460731e-01f, -1.09050676e-01f, -3.47564965e-01f, -2.58296549e-01f, -3.52764517e-01f,
  3.18997025e-01f, 2.65876856e-02f, -1.51546538e-01f, -3.90182831e-03f, -1.72045812e-01f, -1.40360102e-01f, -1.77507460e-01f, -2.37408459e-01f, -3.89301956e-01f, -5.57946451e-02f,
  -5.16033359e-02f, -5.56760468e-02f, 8.63679424e-02f, 5.06238081e-02f, 1.68174863e-01f, 9.06620696e-02f, 1.07816786e-01f, 1.45622930e-02f, 3.05047557e-02f, 4.72835414e-02f,
  -1.51059985e-01f, -1.94458857e-01f, -2.22826391e-01f, -1.90541551e-01f, -8.99017453e-02f, 1.36000328e-02f, 2.06246115e-02f, 7.30705783e-02f, -1.78328771e-02f, -7.04524294e-02f,
  4.53067571e-02f, -5.27224177e-03f, 7.46852309e-02f, -1.94207609e-01f, 4.69915457e-02f, -9.19632316e-02f, -1.15820453e-01f, -1.14426099e-01f, -1.12895057e-01f, -9.91633981e-02f,
  1.12086996e-01f, 7.65408427e-02f, -5.87524250e-02f, 7.57250041e-02f, 5.36019132e-02f, 3.22938375e-02f, 1.02280721e-01f, -2.02944353e-02f, -5.60784973e-02f, -2.08757803e-01f,
  -1.62321344e-01f, -2.01706797e-01f, 3.65870930e-02f, 1.41017959e-01f, -1.75750032e-01f, -1.73240695e-02f, 1.87623739e-01f, 8.60017389e-02f, 2.05811635e-01f, 8.29939246e-02f,
  3.17339629e-01f, 2.56676912e-01f, 1.57545269e-01f, 4.62190434e-02f, 2.81257425e-02f, 1.01292938e-01f, 1.93684459e-01f, 2.07878780e-04f, -6.44923300e-02f, 1.87014565e-01f,
  -2.81333059e-01f, -2.10627735e-01f, -7.11367652e-02f, 1.20176420e-01f, -2.29260325e-01f, -1.64766014e-01f, -3.07236135e-01f, -5.43788746e-02f, 1.92958295e-01f, -1.22175127e-01f,
  -1.29483446e-01f, -9.33650434e-02f, 2.88076848e-02f, -1.71594352e-01f, -2.87425578e-01f, -9.06830877e-02f, -2.15485506e-02f, -2.13216022e-01f, -1.96289897e-01f, -1.82215109e-01f,
  -2.30151772e-01f, -1.34749860e-01f, -1.60751462e-01f, -4.59682867e-02f, 1.85824603e-01f, 7.92952776e-02f, 1.77127421e-01f, -5.56276599e-03f, -2.40726098e-01f, -1.48911148e-01f,
  -6.87991604e-02f, 1.46089777e-01f, -8.85020494e-02f, -8.80135372e-02f, 1.40281036e-01f, 1.00775674e-01f, -7.34702870e-02f, 1.29209816e-01f, 6.53462112e-02f, 8.98928475e-03f,
  -1.85683668e-01f, 8.72732475e-02f, -6.55461475e-02f, -7.59193972e-02f, -1.75406218e-01f, -2.32243072e-02f, 3.42974178e-02f, 5.94042102e-03f, 7.71512091e-02f, 3.28219905e-02f,
  -3.53231639e-01f, -2.47982338e-01f, -2.76061177e-01f, -1.22448271e-02f, 3.08728129e-01f, -1.41871139e-01f, 2.93371174e-02f, -2.67411508e-02f, 3.81779522e-02f, -6.17104955e-02f,
  1.33607954e-01f, 6.82526380e-02f, 2.23969817e-02f, -9.63484868e-04f, 4.37696697e-04f, 4.44875807e-02f, 7.06337765e-02f, -1.04625404e-01f, 5.54948896e-02f, -1.54588290e-03f,
  8.97805616e-02f, -1.06817810e-02f, 4.47234623e-02f, 8.51662830e-02f, 9.99153182e-02f, -2.98531484e-02f, -3.85543332e-02f, -1.00811929e-01f, -1.54468417e-02f, 6.75201565e-02f,
  -9.97141004e-02f, 2.26152353e-02f, 1.87420011e-01f, -4.77017574e-02f, -9.59824622e-02f, 6.24666410e-03f, 3.46644819e-02f, -1.15952015e-01f, -3.90054360e-02f, -1.00513153e-01f,
  1.44214660e-01f, -9.21866149e-02f, 3.34860431e-03f, -5.33009060e-02f, 4.97664362e-02f, 1.07963338e-01f, -4.84979562e-02f, -9.43400115e-02f, -5.67348814e-03f, -1.05228752e-01f,
  -1.15628533e-01f, -9.07929465e-02f, 8.57888237e-02f, 2.25319546e-02f, -1.82316050e-01f, -6.68851361e-02f, -2.67505467e-01f, -2.09769085e-01f, -2.06813172e-01f, 6.29863888e-02f,
  -2.04165548e-01f, -3.43831241e-01f, -4.55389500e-01f, -1.57998398e-01f, 1.36144727e-01f, -2.89121211e-01f, -1.56920806e-01f, -1.29245102e-01f, -1.77101761e-01f, -2.92270303e-01f,
  4.96485054e-01f, 5.32067120e-02f, 1.97700903e-01f, 1.50263950e-01f, 1.56349346e-01f, 1.31157935e-01f, 3.22168529e-01f, 3.59312892e-01f, -1.50217758e-02f, 1.51099056e-01f,
  -3.56831789e-01f, -4.60276514e-01f, -4.13848579e-01f, -3.88069600e-01f, 2.77459584e-02f, 1.25638887e-01f, 1.86197534e-01f, 8.33439007e-02f, 9.01397690e-02f, 6.26066327e-02f,
  -1.39167160e-01f, 3.34648520e-01f, 2.83398777e-01f, 1.51545793e-01f, -1.01654172e-01f, -1.83524713e-01f, 2.40717992e-01f, 1.56020626e-01f, -8.21419731e-02f, -1.05829589e-01f,
  -5.11904955e-02f, 3.61674100e-01f, -2.29423076e-01f, -2.44676515e-01f, -9.04952064e-02f, -2.63345279e-02f, -5.77413850e-02f, 2.55310126e-02f, -1.62494764e-01f, 8.86297226e-02f,
  -1.56150386e-01f, -1.72652364e-01f, -2.81980425e-01f, -5.99256642e-02f, 5.30870184e-02f, -1.41311353e-02f, 6.71264827e-02f, 1.46624818e-01f, -1.79653853e-01f, -2.13663623e-01f,
  -3.70064616e-01f, 4.29054946e-02f, 1.08465299e-01f, -1.08656287e-02f, -7.96298906e-02f, -2.36178041e-01f, 1.28662840e-01f, -1.04921907e-01f, 5.75646609e-02f, 1.59211546e-01f,
  -2.81133864e-04f, 4.50373664e-02f, -2.73062242e-03f, 1.84661508e-01f, -1.45930909e-02f, -5.98385185e-02f, -6.33100420e-02f, -3.97306234e-02f, 9.25325509e-03f, 1.48531988e-01f,
  -5.45804016e-02f, 6.45678043e-02f, 5.52958921e-02f, 3.39236893e-02f, -8.06094185e-02f, -2.98309196e-02f, 1.30729035e-01f, -3.68498489e-02f, 2.57241242e-02f, 9.52738002e-02f,
  1.72397401e-02f, 6.86935559e-02f, -1.12191483e-01f, -4.56858985e-03f, 8.94405246e-02f, -5.25690988e-02f, -1.22596279e-01f, -1.40395626e-01f, -1.83630846e-02f, 1.28234267e-01f,
  -1.23479582e-01f, -1.18455328e-01f, 1.13853514e-02f, -1.38986200e-01f, 1.40683144e-01f, -1.38030499e-01f, -7.92687312e-02f, -6.99778087e-03f, -8.70066434e-02f, -1.81924533e-02f,
  -4.53877188e-02f, -9.48594734e-02f, -6.32260814e-02f, -4.26046131e-03f, -2.71808505e-02f, 4.06615734e-02f, -1.51599675e-01f, 3.32443453e-02f, -5.97520582e-02f, 4.25145496e-04f,
  2.45815217e-02f, 1.94170490e-01f, 1.83836147e-01f, 9.88598634e-03f, -1.38954269e-02f, -4.58427742e-02f, 1.45233229e-01f, 2.61205696e-02f, 6.98566213e-02f, 2.59989351e-01f,
  3.95389259e-01f, 9.23961848e-02f, 1.89559862e-01f, 2.92084068e-01f, 4.21589194e-03f, -4.55703080e-01f, -5.61969459e-01f, -3.05806518e-01f, 1.23344429e-01f, 9.45017710e-02f,
  1.99112147e-02f, 1.44978706e-02f, 1.02414049e-01f, -3.74025442e-02f, -2.92376786e-01f, -1.23992972e-01f, 3.17496993e-02f, 5.36234416e-02f, -2.79890984e-01f, -2.51191050e-01f,
  -5.42973839e-02f, 6.25668168e-02f, 8.84783417e-02f, 2.91848518e-02f, 2.29543582e-01f, -5.21411896e-02f, 1.24065749e-01f, 2.12998018e-01f, -9.40868855e-02f, 4.26069766e-01f,
  4.24495250e-01f, 1.27243996e-01f, -3.22818846e-01f, 1.28665909e-01f, 1.74918860e-01f, 2.99319923e-02f, -3.41500118e-02f, 2.61989146e-01f, -4.82808426e-02f, 1.05432890e-01f,
  1.67085513e-01f, 6.50748461e-02f, 1.36069462e-01f, -2.30884142e-02f, 5.11008427e-02f, -2.52167821e-01f, -1.67853069e-02f, -5.65833114e-02f, -5.51433824e-02f, 6.49220794e-02f,
  8.30680206e-02f, 1.88777130e-02f, -9.29905102e-02f, -1.65853798e-01f, -5.11279218e-02f, -4.24601287e-02f, -9.71753225e-02f, -6.84538810e-03f, -3.09011400e-01f, 1.17245905e-01f,
  -1.13227069e-02f, 3.51612316e-03f, -4.05208804e-02f, -2.03143433e-02f, -6.21785261e-02f, 8.08689669e-02f, 1.07839905e-01f, -4.39402685e-02f, -3.64163965e-02f, -3.63873914e-02f,
  -2.32833903e-02f, -4.37721945e-02f, 3.01362704e-02f, -5.58480844e-02f, -1.93153396e-02f, -6.17657863e-02f, -3.31648663e-02f, -6.38869181e-02f, -7.17804134e-02f, -2.44807508e-02f,
  4.19740044e-02f, 2.09462084e-02f, 6.13430552e-02f, -7.92111009e-02f, -5.91102429e-02f, -2.93712467e-02f, 2.72737797e-02f, 4.02406976e-02f, 7.54253939e-02f, 1.21509470e-01f,
  -1.39225125e-01f, -3.10420096e-01f, 1.06455959e-01f, -5.22260144e-02f, 1.26670804e-02f, -3.18255648e-02f, 4.68332879e-02f, 2.67068809e-03f, 1.56309247e-01f, -3.39618064e-02f,
  -1.66264430e-01f, -1.40397698e-01f, 8.02716762e-02f, -1.38361882e-02f, -1.37436837e-01f, -2.47737914e-02f, -1.44604042e-01f, -6.40949607e-02f, -1.61858559e-01f, 1.74087733e-02f,
  -7.88086057e-02f, -3.02031636e-01f, -2.13448733e-01f, -2.62588203e-01f, -1.17812224e-01f, -2.21059784e-01f, -2.71323860e-01f, -2.68068880e-01f, -4.64536577e-01f, -2.84781516e-01f,
  -4.65819925e-01f, -3.39411348e-01f, -3.55846733e-01f, -4.30946559e-01f, -3.51402521e-01f, 1.01342415e-02f, 3.66622880e-02f, -5.93993552e-02f, -1.29136071e-01f, -2.54028440e-01f,
  -4.81130108e-02f, -3.42088640e-02f, -1.35846376e-01f, -1.02206618e-01f, -8.20069164e-02f, -3.75645906e-01f, -1.91791013e-01f, -1.84342757e-01f, 6.64939284e-02f, 5.82102090e-02f,
  -1.37904629e-01f, -2.39651963e-01f, -1.66948587e-01f, -2.22435892e-01f, -3.56353372e-01f, -2.95866847e-01f, -3.00931275e-01f, -2.62529194e-01f, -3.74031775e-02f, -4.18773741e-01f,
  -2.04282358e-01f, 1.25237867e-01f, 1.12264559e-01f, 8.25578272e-02f, -4.26959246e-02f, 7.26515502e-02f, 1.41400332e-02f, -6.91199526e-02f, 1.87208131e-02f, 3.90372239e-02f,
  -3.30302715e-02f, 5.49763329e-02f, -2.80515701e-02f, -4.99574319e-02f, 4.00934294e-02f, 1.30699784e-01f, 1.88822106e-01f, 1.59940377e-01f, 7.55510926e-02f, 4.63234037e-02f,
  1.72251791e-01f, 1.70170277e-01f, 1.37010589e-01f, 2.54749417e-01f, 2.62747198e-01f, 1.70203120e-01f, 1.37408152e-01f, 2.80905098e-01f, 9.82787162e-02f, -1.72012988e-02f,
  -3.63333412e-02f, -4.33710627e-02f, -2.36213277e-03f, 4.90516908e-02f, 8.27278476e-03f, -1.29020559e-02f, -1.27833202e-01f, -1.94473732e-02f, -3.87538108e-04f, -8.38996544e-02f,
  1.43142911e-02f, 1.01908214e-01f, 1.23345762e-01f, -8.44354406e-02f, -4.80769649e-02f, -1.83372982e-02f, -1.35317324e-02f, -3.93347628e-02f, -1.08649973e-02f, 4.52854373e-02f,
  1.54548794e-01f, 1.26556695e-01f, 6.59723021e-03f, 1.02788731e-01f, 9.77888107e-02f, -5.12301512e-02f, 4.31768410e-02f, 1.45864068e-02f, -5.97605705e-02f, 1.01952635e-01f,
  -2.99809277e-01f, 9.51944962e-02f, -2.24048510e-01f, 5.90976328e-02f, 2.62730643e-02f, 7.72237182e-02f, -6.59885257e-02f, 2.39840802e-03f, 5.39011694e-02f, 1.33554667e-01f,
  8.67739916e-02f, -8.64862353e-02f, -1.56640217e-01f, 7.70841092e-02f, -6.28363788e-02f, 4.76094447e-02f, 3.87854502e-02f, -1.21122841e-02f, 1.29080907e-01f, 7.19578192e-02f,
  1.05855510e-01f, 3.40523124e-02f, -1.48832612e-02f, -6.74695289e-03f, 9.90870595e-03f, 1.44978985e-02f, -4.27632518e-02f, 5.47599653e-03f, 3.46368849e-02f, -2.59276718e-01f,
  1.79236084e-01f, 1.89449534e-01f, -5.70461869e-01f, -4.30302061e-02f, -4.13002729e-01f, -3.04815799e-01f, 8.83091241e-02f, 2.73164332e-01f, 2.74934113e-01f, 1.13602072e-01f,
  -1.03092985e-02f, -1.25721082e-01f, -2.90779650e-01f, -1.10200323e-01f, 7.19130598e-03f, -1.45515278e-01f, -1.76321924e-01f, -4.11957681e-01f, -2.03014746e-01f, -1.76840965e-02f,
  2.20173020e-02f, 1.19759031e-01f, 3.91885079e-02f, 1.54913757e-02f, -1.76582083e-01f, -2.34537393e-01f, -2.30534926e-01f, -2.73495138e-01f, -2.81903625e-01f, -4.22066569e-01f,
  -3.56129259e-01f, -2.14651644e-01f, -1.37084186e-01f, -1.79379135e-01f, -7.92441592e-02f, -6.48619886e-03f, -7.14495778e-02f, -1.67266965e-01f, -3.18339318e-02f, -1.30407572e-01f,
  -1.69047132e-01f, -1.08201467e-01f, -1.38818264e-01f, -1.61411241e-01f, -7.94184953e-02f, -1.77874062e-02f, 1.38672352e-01f, -9.75640044e-02f, -1.17333494e-01f, -1.45240769e-01f,
  -1.44041061e-01f, -3.48915637e-01f, -3.89889061e-01f, -1.66214094e-01f, 1.14081928e-03f, -2.76063830e-01f, -2.44135454e-01f, -2.13106409e-01f, -1.64110884e-01f, -1.52817527e-02f,
  4.02028561e-02f, 3.26737389e-02f, 4.09155078e-02f, 6.70728609e-02f, 2.06196323e-01f, -6.26239702e-02f, 4.42724238e-04f, -5.58025725e-02f, -9.83787514e-03f, -2.91927624e-03f,
  -8.19661617e-02f, -2.32952069e-02f, -1.29627055e-02f, 7.03248084e-02f, -1.10609204e-01f, -2.79680956e-02f, -8.98781791e-02f, 5.90127110e-02f, 5.58602661e-02f, -7.27436915e-02f,
  -2.95857247e-02f, -2.67704688e-02f, -1.21226318e-01f, -5.54589741e-02f, -2.79128477e-02f, -1.50589287e-01f, -1.40406666e-02f, -4.66647260e-02f, 1.08070925e-01f, -5.33831716e-02f,
  2.28128046e-01f, -2.33710185e-02f, 9.06520337e-02f, -8.39358196e-03f, -8.91330764e-02f, -9.89518687e-03f, 3.62500101e-02f, 4.73286994e-02f, -7.30067864e-02f, -1.64829195e-01f,
  -4.09611315e-02f, 4.84069176e-02f, 2.02820655e-02f, -4.22685146e-02f, 9.77809280e-02f, -4.71731499e-02f, 2.29114801e-01f, -1.39475435e-01f, 6.59025833e-02f, 3.61417644e-02f,
  1.74975723e-01f, 1.32709816e-01f, 1.51198404e-02f, 5.70285432e-02f, 1.47681013e-01f, -1.33739188e-01f, 2.37256158e-02f, 3.53567824e-02f, -4.39973250e-02f, 2.80987948e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  8.79700854e-02f, 4.21565264e-01f, 1.65697902e-01f, 1.90723747e-01f, 2.98842847e-01f, 2.44050354e-01f, 4.54950958e-01f, 2.69419372e-01f, 2.73707181e-01f, 1.76447496e-01f,
  1.42314851e-01f, 2.54483730e-01f, 1.36509407e-02f, 3.14703226e-01f, 2.54151702e-01f, 3.62074524e-01f, 1.71644613e-01f, 2.12784708e-01f, 1.93649292e-01f, 2.04511300e-01f,
  1.94940612e-01f, 7.11940974e-02f, 3.79215598e-01f, 2.82921016e-01f, 3.61448616e-01f, 2.38878101e-01f, 3.42063516e-01f, 4.75000739e-01f, 3.67791384e-01f, 3.71982813e-01f,
  1.52095005e-01f, 3.78897667e-01f, 4.00420189e-01f, 1.89385116e-01f, 4.45862859e-01f, 1.91062003e-01f, 3.69116545e-01f, 1.48987874e-01f, 6.08128533e-02f, 4.40532416e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.44186631e-01f, 1.17477484e-01f, 4.16583754e-02f, 5.38136065e-02f, 6.08914755e-02f, 3.79268788e-02f, -9.19672251e-02f, -1.81307122e-02f, -1.14349328e-01f, -1.13973785e-02f,
  -8.75831544e-02f, 6.25967933e-03f, 1.75144836e-01f, -3.17349881e-02f, 8.60117152e-02f, 1.88357994e-01f, -1.85230210e-01f, -1.66932419e-01f, 7.34898970e-02f, -1.30310833e-01f,
  -4.23170887e-02f, -1.64661705e-01f, 1.43878311e-01f, 1.90889627e-01f, 3.59355249e-02f, -6.57487139e-02f, 4.46775695e-03f, -6.33108169e-02f, 1.44454882e-01f, 2.35302672e-02f,
  1.31522402e-01f, 1.26504958e-01f, -3.19554985e-01f, -2.04861626e-01f, -3.50157648e-01f, -1.42322391e-01f, 7.81654473e-03f, -1.52469769e-01f, -1.97497338e-01f, -4.41834182e-02f,
  -6.01120926e-02f, -1.42489806e-01f, -8.77372026e-02f, 1.35843322e-01f, -1.35695234e-01f, 1.90440968e-01f, 2.27766916e-01f, 7.96781182e-02f, -1.16144396e-01f, 3.79917882e-02f,
  4.74745892e-02f, 2.41397545e-01f, 1.11752890e-01f, -1.75738364e-01f, -8.59633461e-02f, -4.26702537e-02f, 4.15332317e-02f, 2.26381317e-01f, -5.49061038e-02f, -1.08925767e-01f,
  1.01586111e-01f, -2.54145026e-01f, 5.23330271e-02f, 2.21035212e-01f, -4.78362525e-03f, -3.15239690e-02f, -9.06353593e-02f, -2.83743553e-02f, -1.15597606e-01f, -4.92424779e-02f,
  -3.74526018e-03f, 4.45669815e-02f, -9.46091022e-03f, 5.36806211e-02f, 1.05923563e-01f, 1.08764187e-01f, 8.68081208e-03f, -5.09017296e-02f, 9.67402309e-02f, -3.34436744e-02f,
  -2.93485940e-01f, -7.48038813e-02f, -9.16589573e-02f, -1.33236334e-01f, -3.10561806e-02f, 8.59567970e-02f, 1.48752090e-02f, 1.33114025e-01f, 1.70945264e-02f, 1.08503155e-01f,
  -8.96826014e-02f, -2.18833759e-01f, -9.16664451e-02f, 1.41428430e-02f, 8.44215751e-02f, 6.36506006e-02f, -1.71359092e-01f, 1.02823667e-01f, 9.67524201e-02f, 2.72113103e-02f,
  -2.33164877e-01f, 1.63630947e-01f, 1.55939236e-01f, -2.92813748e-01f, -1.37953877e-01f, -1.31445155e-01f, 7.90061895e-04f, 2.47944191e-01f, 9.51698944e-02f, 6.27286285e-02f,
  -7.73681188e-03f, 2.03365237e-01f, 5.86128198e-02f, 2.34238386e-01f, 9.85760614e-02f, 2.80822039e-01f, -1.88633680e-01f, -1.72129691e-01f, -1.97336264e-02f, -2.21036255e-01f,
  9.71327536e-03f, 1.79964453e-01f, -3.57687548e-02f, 4.98813167e-02f, 1.05941445e-01f, -2.53650934e-01f, 1.64026514e-01f, -1.26811219e-02f, 3.17194313e-02f, 3.94597761e-02f,
  -4.55902070e-02f, 1.76103592e-01f, 1.21734500e-01f, -7.71834031e-02f, 9.73771699e-03f, 1.57332063e-01f, -8.00062194e-02f, -9.15081799e-02f, -1.09579936e-01f, -6.44398329e-04f,
  -1.06030777e-01f, -9.85704735e-02f, -1.28376922e-02f, 1.30699083e-01f, -5.71947619e-02f, -2.90228520e-02f, 1.37059718e-01f, -2.10358948e-01f, -7.90483728e-02f, 2.63890587e-02f,
  2.73393299e-02f, -2.89565464e-03f, -8.44301656e-02f, 6.42265379e-02f, 2.29154751e-01f, -1.77340493e-01f, -1.63678735e-01f, 4.56247255e-02f, 1.60888314e-01f, 6.54668584e-02f,
  -1.72171697e-01f, 7.67714456e-02f, -1.37134194e-01f, -4.33539227e-02f, 8.68951678e-02f, -2.67295212e-01f, -3.91209245e-01f, -2.93302368e-02f, -2.38442272e-02f, -1.67453945e-01f,
  -7.12561384e-02f, -4.85942811e-02f, 7.35424012e-02f, 6.58296198e-02f, -5.59955649e-02f, 1.39112100e-01f, -2.48801515e-01f, 8.42753500e-02f, -2.83120871e-02f, -2.75335815e-02f,
  -5.50568737e-02f, 8.35457370e-02f, 1.65247604e-01f, -9.47392434e-02f, 2.92899385e-02f, 1.26054615e-01f, -4.45740670e-02f, 1.55281827e-01f, 2.43048713e-01f, -1.23391412e-01f,
  8.24093446e-02f, 1.74626455e-01f, 3.38826776e-02f, 3.55163105e-02f, 5.63874319e-02f, 6.20920537e-03f, -4.42615598e-02f, 1.18329309e-01f, 1.74597576e-01f, -1.65996496e-02f,
  -1.23790450e-01f, -5.01751378e-02f, -7.46992156e-02f, 1.48185521e-01f, -5.23537621e-02f, 2.37363968e-02f, 3.60028408e-02f, 2.37611622e-01f, -5.13062514e-02f, -5.25422096e-02f,
  2.36749917e-01f, -4.23899069e-02f, 1.67102944e-02f, -1.59003198e-01f, 2.05074698e-01f, -2.80381683e-02f, 4.01531719e-02f, 9.84820575e-02f, -1.75991923e-01f, -2.09429696e-01f,
  7.14698732e-02f, -1.87339097e-01f, -5.29794060e-02f, -1.10300854e-02f, -2.59468496e-01f, 1.35087609e-01f, -6.06903769e-02f, -7.67842904e-02f, 8.31398666e-02f, -3.14678043e-01f,
  6.45049522e-03f, 3.44216861e-02f, 1.33623049e-01f, -1.67077202e-02f, -1.77475557e-01f, -7.94368833e-02f, -3.58585455e-02f, -1.84473991e-02f, 2.49330312e-01f, -5.90472668e-02f,
  -3.36208105e-01f, 1.45603865e-01f, 1.50937021e-01f, 1.23802617e-01f, 3.46542113e-02f, -7.75620118e-02f, -9.65585038e-02f, 2.03123122e-01f, 1.19143233e-01f, 2.44627163e-01f,
  -1.27410486e-01f, 4.11741957e-02f, -3.61704051e-01f, -6.67235926e-02f, 1.04492851e-01f, 1.63395312e-02f, -3.52307968e-02f, -1.56592776e-03f, -1.58501834e-01f, -3.84361893e-02f,
  -4.39729467e-02f, 9.28016305e-02f, 2.00640801e-02f, -2.21236423e-02f, -2.04622676e-03f, 8.62652138e-02f, 9.71199945e-02f, 2.32859571e-02f, -9.20308605e-02f, 9.49162468e-02f,
  3.59645896e-02f, -1.24861866e-01f, -4.05690037e-02f, 5.26422597e-02f, 4.28254940e-02f, 7.79173076e-02f, 5.05225174e-02f, 1.93046451e-01f, -4.79263030e-02f, -1.40418425e-01f,
  -6.04489818e-03f, 3.32305282e-02f, -1.01190954e-01f, 3.11212689e-02f, -1.67328212e-02f, -8.66820216e-02f, -6.84925765e-02f, -1.04765519e-01f, -1.82611272e-02f, 1.05394736e-01f,
  5.59477555e-03f, 3.67484689e-01f, -6.45128265e-02f, 1.82923570e-01f, -1.16697364e-01f, 3.69319841e-02f, 6.63811862e-02f, -1.62425086e-01f, 2.74484664e-01f, -1.46393865e-01f,
  1.52779073e-01f, -4.77879047e-02f, -7.54202530e-02f, 9.66401473e-02f, 2.53860563e-01f, 1.18719585e-01f, -6.06635474e-02f, -2.33833626e-01f, -1.64595395e-01f, -2.50587732e-01f,
  2.00034231e-01f, 1.34156778e-01f, -5.55471443e-02f, -8.51537213e-02f, -7.39904121e-02f, -3.37791704e-02f, 1.38026878e-01f, 2.02788398e-01f, 1.96437940e-01f, -1.89542294e-01f,
  2.52101123e-02f, -3.60129662e-02f, 9.73830372e-03f, 9.95841995e-02f, 1.73190206e-01f, -6.49951249e-02f, 7.83807859e-02f, 1.80418696e-02f, -1.15975048e-02f, 5.15253469e-02f,
  1.27943680e-01f, 8.88408348e-02f, -3.03809214e-02f, -2.51739305e-02f, 2.97314912e-01f, 1.12667806e-01f, 9.01348069e-02f, -1.73549410e-02f, -2.87659094e-02f, -3.78739089e-02f,
  1.31740153e-01f, 2.14377910e-01f, 7.66398162e-02f, -2.91609969e-02f, -3.32081281e-02f, -1.70406699e-01f, -1.23768531e-01f, -1.25745474e-03f, 1.20842494e-01f, -1.86227039e-02f,
  1.24745578e-01f, 1.16989575e-01f, -3.10443372e-01f, -1.39450923e-01f, -1.54479211e-02f, 2.67549939e-02f, -1.63686574e-01f, -2.14533180e-01f, -3.13001096e-01f, -1.93961099e-01f,
  -4.71175648e-02f, -3.82464714e-02f, 1.70360759e-01f, 6.34629354e-02f, 1.00852773e-02f, -8.63234221e-04f, 3.09695937e-02f, 1.26758888e-01f, 1.70840561e-01f, 8.32548179e-03f,
  -1.66006908e-01f, 2.99398929e-01f, 2.26202026e-01f, 2.65706211e-01f, -5.40875420e-02f, 4.37255949e-02f, -2.34805256e-01f, 1.41820714e-01f, 2.92867552e-02f, -3.32284602e-04f,
  -4.22764979e-02f, 8.16750154e-02f, -1.21328488e-01f, -2.34681424e-02f, 7.75481537e-02f, 9.09066796e-02f, -2.06729490e-02f, -1.91992279e-02f, -2.70867115e-03f, -1.46771101e-02f,
  -1.44700827e-02f, 4.27539274e-02f, -7.75749832e-02f, -4.40289229e-02f, -6.08351082e-03f, -4.90525812e-02f, 1.57267734e-01f, -3.13089266e-02f, 1.03121892e-01f, 4.78934646e-02f,
  -1.10328838e-01f, -3.23271193e-03f, -8.69575217e-02f, -5.49299046e-02f, 9.75462496e-02f, 9.42684412e-02f, 1.92414507e-01f, 1.05533890e-01f, -1.76664314e-03f, -1.60757780e-01f,
  2.31971033e-02f, 1.45391703e-01f, -4.45988821e-03f, -1.34058930e-02f, -3.76878716e-02f, -1.53778046e-01f, -9.88553986e-02f, 1.54162616e-01f, 3.13149095e-02f, -1.09435931e-01f,
  2.11032346e-01f, -1.62382144e-02f, 1.63248152e-01f, -3.12515110e-01f, 9.87610817e-02f, -1.50967881e-01f, 1.97680444e-01f, -1.54296130e-01f, -4.71987762e-03f, -1.75919741e-01f,
  -1.24900304e-01f, 2.58090496e-01f, -4.11408544e-02f, 1.71263769e-01f, 3.30160074e-02f, -1.51406184e-01f, 2.00919926e-01f, -1.15370035e-01f, 1.06654674e-01f, -1.17361955e-01f,
  -1.18093304e-01f, 7.51831084e-02f, 2.41159692e-01f, 5.82073815e-02f, -4.39921916e-01f, -2.19786555e-01f, 1.30450726e-01f, 7.99231455e-02f, -6.02133200e-02f, -3.85402702e-02f,
  -1.52400881e-01f, -1.58109039e-01f, 2.99041308e-02f, 7.46631324e-02f, -5.55483103e-02f, 6.62251860e-02f, 1.90039113e-01f, -8.53541940e-02f, -4.07309495e-02f, -7.91647434e-02f,
  -8.79165530e-02f, 1.96319476e-01f, 8.93182755e-02f, 1.75164595e-01f, 2.41156697e-01f, -4.77283560e-02f, -1.13477811e-01f, 2.32497349e-01f, -1.05375133e-01f, 1.08644582e-01f,
  1.21220440e-01f, 1.43250644e-01f, 6.98600262e-02f, -1.71308983e-02f, -2.57570744e-01f, -1.90198440e-02f, 1.49464607e-01f, 5.70160933e-02f, -1.79106020e-03f, 1.60624657e-03f,
  -4.99550737e-02f, -6.27067089e-02f, -1.60640657e-01f, 3.80481370e-02f, -9.10845399e-02f, -7.18736947e-02f, 5.68275377e-02f, -1.31403819e-01f, 1.43420607e-01f, -1.63903013e-01f,
  2.80022528e-03f, 1.36348501e-01f, 7.85226561e-03f, -1.46004677e-01f, 2.85504282e-01f, 1.66737020e-01f, -3.20406398e-03f, 5.04311025e-02f, 6.71909302e-02f, 1.40252113e-01f,
  3.26772660e-01f, -1.51368275e-01f, 7.59032592e-02f, 1.29933193e-01f, -2.74783731e-01f, 1.94985017e-01f, 1.63769498e-01f, -2.00395778e-01f, -3.60888690e-01f, -4.21696417e-02f,
  -1.49284750e-01f, -2.40516160e-02f, -7.10992515e-02f, 8.27562511e-02f, 8.41055885e-02f, -5.68414144e-02f, -2.01107919e-01f, -8.76254663e-02f, 1.23379298e-01f, -1.14705935e-02f,
  6.95587099e-02f, -8.09678249e-03f, -1.02873132e-01f, -1.06183745e-01f, -3.05430535e-02f, -6.01018453e-03f, -2.26189762e-01f, -2.29614034e-01f, -7.85774514e-02f, 1.33457020e-01f,
  5.94494399e-03f, 9.54525396e-02f, -9.10884812e-02f, 1.00743003e-01f, -2.29400426e-01f, 9.45460126e-02f, 1.39031351e-01f, -6.89709634e-02f, -5.80528826e-02f, 1.22626662e-01f,
  8.61743689e-02f, 2.88540591e-02f, -1.10387713e-01f, -1.88775249e-02f, 2.72135615e-01f, 1.70720175e-01f, -3.12690996e-02f, 1.63811594e-01f, -8.66587237e-02f, 2.16250300e-01f,
  7.69580752e-02f, -1.34572998e-01f, 9.60213095e-02f, -1.82578385e-01f, 2.45021805e-01f, 1.57322258e-01f, 2.29904190e-01f, -2.52049506e-01f, -2.89910048e-01f, 8.32480118e-02f,
  1.06622905e-01f, -7.37383366e-02f, 1.39527455e-01f, -1.12203829e-01f, -4.06357571e-02f, 6.20632358e-02f, 1.71927437e-01f, -8.44077468e-02f, 9.08498168e-02f, -2.64700919e-01f,
  -8.64703730e-02f, 9.40566417e-03f, -2.06587315e-01f, 1.20154612e-01f, -1.42101720e-01f, 2.63607986e-02f, -1.34449959e-01f, -1.46835178e-01f, -3.21144313e-02f, -1.56270303e-02f,
  -1.36818781e-01f, -3.48426914e-03f, -9.25519317e-02f, -1.04552388e-01f, -4.56225798e-02f, -1.13686480e-01f, 2.42369510e-02f, 1.30727753e-01f, -3.22717987e-02f, -9.28415731e-03f,
  -6.87218979e-02f, -2.28823349e-01f, -2.28827149e-01f, 5.08317351e-03f, -8.66621062e-02f, 1.18831605e-01f, -5.10232411e-02f, 9.74291638e-02f, -2.15339929e-01f, -1.04219124e-01f,
  -1.53445154e-01f, 2.62866896e-02f, -2.22589761e-01f, 1.19333290e-01f, 8.28989297e-02f, 1.56068742e-01f, -1.96984202e-01f, -9.52525288e-02f, 3.21148098e-01f, 1.61050826e-01f,
  1.85332850e-01f, 2.67365621e-03f, 1.31158799e-01f, 2.36006930e-01f, 3.45392674e-01f, -5.51109351e-02f, -8.17562416e-02f, 1.24926336e-01f, 7.14970008e-02f, -3.34756076e-02f,
  -5.20815030e-02f, -1.48178130e-01f, -2.33421326e-01f, 4.89885025e-02f, 2.53702015e-01f, 8.79236311e-02f, -1.18108191e-01f, 1.01245651e-02f, -1.08746059e-01f, 3.79746519e-02f,
  -9.08688754e-02f, -4.08077054e-02f, -6.37469366e-02f, -2.13578671e-01f, 1.12817422e-01f, -1.86527014e-01f, -9.20976400e-02f, 1.57696664e-01f, -6.27963617e-02f, -2.99014058e-02f,
  -1.67352948e-02f, 4.95847315e-02f, -1.78494602e-02f, 5.25285564e-02f, 1.90906562e-02f, 1.97261875e-03f, -4.54687253e-02f, 1.64092164e-02f, -9.83828455e-02f, 1.98973008e-02f,
  -3.34477164e-02f, -2.57108659e-02f, 5.78804612e-02f, 6.04745140e-03f, 9.83285680e-02f, -8.24708268e-02f, -1.59857690e-01f, -4.56931926e-02f, -2.66930424e-02f, -1.48374170e-01f,
  -1.20973729e-01f, -2.15491164e-03f, -1.23285808e-01f, -1.36448964e-01f, -1.59395844e-01f, 1.23274878e-01f, -1.19032100e-01f, -2.37660348e-01f, -1.67692110e-01f, 1.51280791e-01f,
  1.36247620e-01f, -3.05505525e-02f, 5.56125445e-03f, -5.89396805e-02f, 1.42610177e-01f, 2.97696348e-02f, -1.70582160e-02f, 2.54865974e-01f, 3.24089319e-01f, 1.03200875e-01f,
  -1.97061628e-01f, 9.70111862e-02f, -1.04131795e-01f, 6.98983669e-02f, -1.52543485e-01f, -1.24239828e-02f, -5.92414662e-02f, -1.65437028e-01f, -3.19262557e-02f, -5.03106453e-02f,
  -1.89413875e-01f, 1.62136823e-01f, -1.78623170e-01f, -1.02405652e-01f, 5.49636744e-02f, 1.15432395e-02f, 3.08572859e-01f, -1.11883648e-01f, -3.02183107e-02f, -8.67577568e-02f,
  4.07450587e-01f, -2.83049643e-01f, 1.94117930e-02f, -4.12889145e-04f, 2.97508109e-02f, -1.17699295e-01f, 9.74174589e-02f, -3.07776569e-03f, 9.03087184e-02f, -8.60477760e-02f,
  -8.60422477e-02f, 1.22043245e-01f, -4.27144673e-03f, -1.10592142e-01f, 1.00044616e-01f, 4.02395986e-02f, -6.06883839e-02f, -1.05106585e-01f, 1.94138423e-01f, 5.81007190e-02f,
  8.75608847e-02f, -3.58414054e-02f, -8.35098103e-02f, -2.22236902e-01f, 2.80188948e-01f, 7.70096406e-02f, -1.05377421e-01f, 8.92040282e-02f, -3.28539964e-03f, -6.13081418e-02f,
  -1.79941237e-01f, -1.52661070e-01f, 7.33761210e-03f, 5.47457375e-02f, 3.46671566e-02f, -1.65912062e-02f, -1.77350149e-01f, -1.43886745e-01f, -3.07094287e-02f, -1.16066299e-01f,
  1.65718794e-01f, 5.46886586e-02f, 1.19703449e-01f, -6.87024668e-02f, -1.41341493e-01f, 1.54169694e-01f, 7.84168243e-02f, -1.50963053e-01f, 9.56727266e-02f, -7.78942788e-03f,
  3.20837617e-01f, 1.49204895e-01f, 5.39547578e-02f, 1.56147242e-01f, 2.28124280e-02f, 8.32006112e-02f, 2.25097209e-01f, -2.87054777e-01f, 9.28327814e-02f, 3.48085985e-02f,
  -4.90812622e-02f, 2.22118258e-01f, -3.93740088e-03f, -5.01429811e-02f, -3.17557268e-02f, -3.96792352e-01f, 2.39112213e-01f, 1.62746951e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -4.39934544e-02f, 8.41181129e-02f, 4.98750526e-03f, -6.73916116e-02f, 1.74875587e-01f, 4.90960442e-02f, 1.93295721e-02f, -8.15963559e-03f, 1.02608867e-01f, 8.73343274e-02f,
  8.29806775e-02f, -4.84754192e-03f, -8.58839005e-02f, -2.64203325e-02f, 7.10706338e-02f, -8.67920965e-02f, 3.49801838e-01f, -1.00235514e-01f, 4.44738427e-03f, 1.57987118e-01f,
  2.21792962e-02f, 1.48678407e-01f, -4.41994891e-03f, 2.76717693e-01f, 2.15811804e-01f, 2.82688588e-02f, 1.00142881e-01f, 1.84239253e-01f, 4.70714904e-02f, -1.66545082e-02f,
  -5.01513742e-02f, 3.42858702e-01f, -1.82790771e-01f, 2.34776437e-01f, -1.49683595e-01f, 1.51374757e-01f, -1.63848791e-02f, -3.99602056e-01f, -4.02407408e-01f, -6.60057440e-02f,
  6.20515645e-02f, -2.19610669e-02f, 2.20894098e-01f, -3.95743102e-02f, 3.39717984e-01f, -4.80288044e-02f, -1.80771798e-01f, 3.55493516e-01f, 1.05349712e-01f, 1.41714543e-01f,
  9.46396030e-03f, -2.09336013e-01f, 1.48364514e-01f, 1.44243196e-01f, 8.99826437e-02f, -2.83211526e-02f, 1.55220971e-01f, 1.12525091e-01f, 4.13515568e-02f, 1.78457618e-01f,
  -6.17377758e-01f, 2.48845771e-01f, 2.51699865e-01f, 3.53389345e-02f, 1.70287028e-01f, 1.48371365e-02f, -1.37526989e-01f, 5.14202416e-02f, 8.06592628e-02f, 8.88690352e-02f,
  1.27673700e-01f, -4.76173647e-02f, 1.84779108e-01f, -5.65117085e-03f, 1.71489924e-01f, -1.31338350e-02f, 1.22249313e-01f, 1.67504951e-01f, -6.58022389e-02f, -3.66184860e-01f,
  -2.78374758e-02f, 1.14694461e-01f, -3.34954143e-01f, -8.43741149e-02f, 1.33604914e-01f, 2.94083118e-01f, -1.79615051e-01f, -3.70298512e-02f, -2.16169655e-01f, 1.42420486e-01f,
  -2.42928625e-03f, 1.68498069e-01f, -1.76868603e-01f, 2.92842656e-01f, 3.86759685e-03f, -2.50309091e-02f, 4.52902436e-01f, 6.08006679e-03f, 1.35014728e-01f, 6.65355027e-01f,
  -8.95732790e-02f, 5.79196930e-01f, 3.00504267e-01f, -7.03426227e-02f, 1.51225045e-01f, -2.43877679e-01f, 2.93110192e-01f, 7.88251087e-02f, 4.50042039e-01f, -3.67875963e-01f,
  -2.38780484e-01f, 4.38806653e-01f, 2.73603320e-01f, 3.92502755e-01f, -2.65861601e-01f, -2.98754662e-01f, 5.62829748e-02f, -5.18576875e-02f, 3.77932400e-01f, -1.79623321e-01f,
  -1.68270357e-02f, -1.59488693e-01f, 2.39552259e-01f, 6.81341887e-02f, -8.34858418e-02f, 8.29216167e-02f, 4.92178261e-01f, 7.09980801e-02f, 1.84350624e-03f, 5.57911657e-02f,
  1.12213209e-01f, 9.02634636e-02f, 9.04448554e-02f, 8.86277184e-02f, 1.07759155e-01f, 4.42282297e-02f, 1.62065491e-01f, -5.10976138e-03f, -1.01355202e-01f, 1.38724551e-01f,
  -7.32517540e-02f, -1.15664966e-01f, 1.22506060e-01f, 9.20259804e-02f, 5.31186871e-02f, 4.82146703e-02f, 3.13559696e-02f, -9.95512158e-02f, 1.53236553e-01f, 6.51696846e-02f,
  -2.34780665e-02f, -7.01626204e-03f, -2.20921442e-01f, 1.29008647e-02f, 4.63629037e-01f, -5.29186949e-02f, -2.55745500e-01f, 2.32674539e-01f, 2.10425571e-01f, -3.28165084e-01f,
  -4.15580064e-01f, 1.38955694e-02f, -2.75693256e-02f, 9.08373147e-02f, 4.53387834e-02f, -2.07501650e-01f, -2.45764345e-01f, -5.05168103e-02f, -1.75537139e-01f, -7.21468404e-02f,
  1.53372064e-01f, -2.48812348e-01f, 1.94250420e-01f, -1.87349573e-01f, -1.31147906e-01f, 2.43402600e-01f, -1.56665683e-01f, -8.38026106e-02f, -5.07623255e-01f, 1.27713904e-01f,
  2.22520545e-01f, 3.55461001e-01f, 2.21255034e-01f, -2.26493597e-01f, 2.25617439e-01f, -1.29179917e-02f, 2.14476526e-01f, 1.13074049e-01f, 1.62854359e-01f, -1.15609504e-02f,
  1.32408589e-01f, 2.83377826e-01f, -8.71347487e-02f, -8.50503668e-02f, 1.22930765e-01f, 8.28272700e-02f, 1.91887096e-01f, 1.32091716e-01f, 1.77172106e-02f, 1.13799989e-01f,
  -7.32835010e-02f, 3.68161052e-02f, -1.73046514e-02f, 1.18463516e-01f, 2.60994975e-02f, 1.23133607e-01f, -1.56362429e-01f, 1.77568421e-02f, 3.55988182e-02f, -2.14999188e-02f,
  -1.15523882e-01f, 2.76652306e-01f, -2.64769793e-01f, 5.92416301e-02f, 1.42914921e-01f, 5.57453036e-02f, 1.22652955e-01f, 7.04487562e-02f, -2.12444499e-01f, 2.14411423e-01f,
  1.73530951e-01f, 1.39769563e-03f, -6.63799122e-02f, 1.47107229e-01f, 1.42976597e-01f, 4.57859933e-02f, 8.95824730e-02f, -5.13066232e-01f, 2.41704762e-01f, 9.56034437e-02f,
  2.72868842e-01f, -4.57775071e-02f, -3.55752930e-02f, 3.88615094e-02f, -2.17470348e-01f, 5.16214259e-02f, -4.14309055e-01f, -8.19691047e-02f, -1.95347309e-01f, -5.18791229e-02f,
  1.08747438e-01f, -1.34210670e-02f, 9.35270339e-02f, 2.95763105e-01f, 1.28435254e-01f, -9.40098315e-02f, -3.50125879e-01f, 3.13181520e-01f, -1.66888908e-02f, 1.96226761e-01f,
  2.55619317e-01f, -1.05475999e-01f, -1.43322758e-02f, 2.44206674e-02f, -2.55921364e-01f, -2.05684721e-01f, -2.39226278e-02f, -5.60563058e-02f, 5.52849323e-02f, 2.92528868e-01f,
  2.39305750e-01f, 6.04348108e-02f, 2.57758588e-01f, 2.76332378e-01f, -1.45248761e-02f, 7.72587880e-02f, 1.12887874e-01f, 2.29397431e-01f, -4.65705656e-02f, -9.63282362e-02f,
  -3.02854180e-02f, -1.41952738e-01f, -8.74973312e-02f, 7.19275698e-02f, -8.08522031e-02f, -1.24422140e-01f, 6.71740994e-02f, 9.83079225e-02f, 7.93468356e-02f, -1.73365116e-01f,
  -3.79400700e-02f, 1.51917979e-01f, -1.30135059e-01f, -1.76956832e-01f, 9.19113457e-02f, 5.58780693e-02f, -1.26612596e-02f, -2.30420500e-01f, 7.66230524e-02f, -3.70249040e-02f,
  3.60985398e-01f, 4.74378169e-01f, -3.94438468e-02f, 6.92597032e-02f, 3.14349085e-02f, -1.77707702e-01f, -2.34266087e-01f, 3.47689956e-01f, 3.14259753e-02f, 2.85611033e-01f,
  2.18804389e-01f, -7.26495013e-02f, -4.14573364e-02f, 6.75389990e-02f, 4.09480818e-02f, 7.99878985e-02f, 1.82200167e-02f, 2.84307897e-01f, -3.33966315e-01f, 3.33369412e-02f,
  1.74200952e-01f, -3.27964962e-01f, -5.65793039e-03f, 2.99612023e-02f, -1.95919815e-02f, 2.22057715e-01f, 5.57309747e-01f, 2.82551814e-02f, 7.65223429e-02f, -6.84648333e-03f,
  1.79203615e-01f, 8.49192875e-05f, 3.32580984e-01f, 3.20431441e-01f, 1.35156279e-02f, 1.57728329e-01f, 3.01267534e-01f, 2.99615443e-01f, 1.68564126e-01f, 1.78360000e-01f,
  3.01561654e-01f, 2.49724999e-01f, 1.91742927e-01f, -2.36123711e-01f, 7.33422339e-02f, 8.93118232e-02f, -2.17562795e-01f, -7.09473491e-02f, -3.03213820e-02f, -2.19649114e-02f,
  -3.56374942e-02f, -1.78371951e-01f, 1.01218425e-01f, -1.01134837e-01f, 1.45657863e-02f, 1.35100961e-01f, -5.42183444e-02f, -4.26005907e-02f, 2.50458628e-01f, 1.97473451e-01f,
  2.43370220e-01f, 6.09440506e-02f, -1.16339944e-01f, -2.94835210e-01f, 8.80472511e-02f, -5.67330539e-01f, 8.08920115e-02f, -2.77867496e-01f, 9.91637930e-02f, 4.51241195e-01f,
  -3.60442936e-01f, 4.05817509e-01f, -2.98662689e-02f, 3.71358961e-01f, -1.83074981e-01f, 3.00978571e-01f, 1.14066109e-01f, -2.44181067e-01f, -2.21400782e-02f, -1.76969022e-01f,
  -1.12964310e-01f, 3.32308233e-01f, 3.05917293e-01f, 2.51178220e-02f, -9.25330594e-02f, 5.18835962e-01f, -9.19589102e-02f, -1.39720842e-01f, 3.97019058e-01f, 2.33847454e-01f,
  3.82870764e-01f, 3.63566697e-01f, -1.09131508e-01f, 4.16590199e-02f, -1.09068491e-02f, 1.63773298e-02f, 5.67953475e-02f, 1.85788140e-01f, 1.58337951e-01f, 3.38414498e-02f,
  9.20296237e-02f, 1.71955392e-01f, 1.49640247e-01f, -4.58766446e-02f, 3.42767723e-02f, -4.04480053e-03f, 1.16094954e-01f, -1.90724265e-02f, -9.57314745e-02f, -3.89061183e-01f,
  4.66624171e-01f, 3.17670524e-01f, 5.60730994e-02f, 2.65775084e-01f, 1.40111282e-01f, 4.86779809e-01f, -2.59103239e-01f, -1.55013084e-01f, -1.35864928e-01f, -2.40153223e-02f,
  1.85909629e-01f, 3.45332354e-01f, 7.76424706e-02f, 9.36122090e-02f, -5.23925610e-02f, 4.09316838e-01f, -1.41804174e-01f, -1.55358970e-01f, -4.59217094e-03f, 1.72616214e-01f,
  -2.31983081e-01f, -2.78155386e-01f, -2.39674509e-01f, 4.13143098e-01f, -1.79035496e-02f, 3.65686893e-01f, 2.57585943e-01f, -6.91042915e-02f, 1.97302595e-01f, 6.09657802e-02f,
  -1.71034813e-01f, 1.45852238e-01f, 1.51425019e-01f, -1.89520081e-03f, -2.74676651e-01f, -3.50242853e-01f, 2.76345342e-01f, 2.74869263e-01f, 9.03695971e-02f, 3.40414315e-01f,
  -1.73718020e-01f, -9.99844745e-02f, 1.65001020e-01f, 2.35124707e-01f, -3.54668707e-01f, 4.94133592e-01f, -2.00285316e-01f, -1.48629382e-01f, -2.44788881e-02f, -5.80076054e-02f,
  -1.55206174e-02f, 5.62398992e-02f, 2.62089968e-01f, -2.50906982e-02f, 3.41777392e-02f, 3.40613067e-01f, 2.13192463e-01f, 2.92652458e-01f, 6.15440123e-02f, -2.56644692e-02f,
  -2.98190713e-01f, 1.43685937e-01f, 1.31674577e-02f, 1.74718618e-01f, 2.39551082e-01f, -2.27440551e-01f, 8.16565659e-03f, -1.29066736e-01f, -2.59263009e-01f, -1.31436989e-01f,
  1.61556825e-01f, -2.73053721e-02f, 2.43155938e-02f, 4.61057454e-01f, -7.62913525e-02f, -7.26417080e-02f, -2.94656724e-01f, 1.39315343e-02f, 2.53396213e-01f, 2.48905763e-01f,
  -4.00032997e-02f, 1.25983104e-01f, 1.16312787e-01f, 1.71205208e-01f, -2.35297948e-01f, 1.39343515e-01f, -1.75108761e-01f, 1.04602739e-01f, 7.94532523e-02f, -3.21275622e-01f,
  -3.19269061e-01f, 1.49969175e-01f, -1.50937527e-01f, -3.51820439e-02f, 1.11320712e-01f, -8.69379640e-02f, 2.47155622e-01f, -1.71149775e-01f, 1.07406698e-01f, 2.12228596e-02f,
  -1.87931404e-01f, 3.61007065e-01f, -1.47119209e-01f, -1.43300503e-01f, 3.84484142e-01f, 5.39095521e-01f, -2.18668625e-01f, -2.32708916e-01f, 3.40944231e-01f, -2.17414141e-01f,
  1.20749645e-01f, 2.84689546e-01f, -2.41547786e-02f, 1.43694475e-01f, -1.17311664e-01f, 3.92038934e-02f, 2.00281695e-01f, 2.04042986e-01f, 7.81044830e-03f, 1.61245137e-01f,
  -7.65425116e-02f, -7.51799420e-02f, -5.88579811e-02f, 4.07530405e-02f, -5.51636368e-02f, 2.22026989e-01f, 1.60032045e-02f, 1.85487539e-01f, 4.03851449e-01f, -8.81642252e-02f,
  -8.43237862e-02f, 1.51387438e-01f, -8.93288925e-02f, 2.39145920e-01f, 7.59314522e-02f, 1.71835095e-01f, 1.86077822e-02f, 1.22898258e-01f, 2.73524165e-01f, 2.49898627e-01f,
  -7.63475243e-03f, -8.52415487e-02f, 2.90145904e-01f, 1.42990574e-01f, -2.03853235e-01f, 1.55753553e-01f, -2.32585490e-01f, 1.36876144e-02f, 1.60673887e-01f, -3.88928413e-01f,
  -4.07007039e-01f, -7.67365843e-02f, 6.09890670e-02f, -2.79831052e-01f, 1.84148267e-01f, -7.45393038e-02f, 3.15986611e-02f, 4.90503497e-02f, 3.87724750e-02f, 1.49091452e-01f,
  -2.21640598e-02f, -2.02696361e-02f, 2.12304011e-01f, -2.36918017e-01f, 3.29090655e-01f, 2.80458957e-01f, 8.29835832e-02f, 1.55743897e-01f, 1.54481128e-01f, 3.00977498e-01f,
  2.47031584e-01f, 2.13528410e-01f, -4.80915487e-01f, 2.36238003e-01f, 1.05479635e-01f, 2.04063058e-01f, -7.94477463e-02f, 9.54263434e-02f, 5.20975478e-02f, 3.79184745e-02f,
  3.40451896e-01f, 2.21488789e-01f, 1.16368094e-02f, 1.77119732e-01f, 1.23164535e-01f, 1.38674527e-01f, 1.73037872e-01f, 7.46714175e-02f, -8.78804773e-02f, 2.54922301e-01f,
  -4.36990038e-02f, 1.69536516e-01f, 1.45583093e-01f, -1.70692429e-01f, -1.41376629e-01f, 1.26702413e-01f, -1.69762969e-01f, -4.85125929e-02f, 1.05637588e-01f, 2.25720659e-01f,
  3.28314602e-01f, 2.71779001e-01f, 1.14860520e-01f, 1.95885822e-01f, 1.03327287e-02f, -4.22863141e-02f, 4.09231991e-01f, 2.56961421e-03f, 2.29104698e-01f, 3.03958893e-01f,
  -5.31058721e-02f, 1.14678126e-02f, 1.59025460e-01f, 1.63946927e-01f, -5.57117164e-02f, 4.26560603e-02f, -6.97983056e-02f, -3.50009233e-01f, -1.64050817e-01f, 7.79914260e-02f,
  -2.37384453e-01f, 3.06996051e-02f, -3.41870546e-01f, -1.57009095e-01f, 4.15430218e-02f, -4.74911600e-01f, -2.35079750e-02f, 1.41535193e-01f, 5.80663607e-02f, 3.67932081e-01f,
  -1.73178613e-01f, 6.45258203e-02f, 1.93287715e-01f, 4.45513338e-01f, 1.18050680e-01f, -6.63831234e-02f, 5.06392539e-01f, -2.04063669e-01f, -4.19268072e-01f, 3.72901350e-01f,
  -7.20732734e-02f, 3.52884866e-02f, -1.83856338e-02f, 1.08870797e-01f, 2.95867547e-02f, 1.21380486e-01f, -3.63858417e-02f, -2.44335216e-02f, -2.24418998e-01f, 2.59151706e-03f,
  -5.66564221e-03f, -9.21357051e-03f, -5.70154488e-02f, -5.53788953e-02f, 1.42336056e-01f, 2.12101787e-02f, -1.43115342e-01f, 9.32112411e-02f, -1.44853622e-01f, -1.49346307e-01f,
  2.57105291e-01f, 2.33097941e-01f, -6.60946220e-02f, 2.73628458e-02f, -1.81521606e-02f, -6.08579963e-02f, -8.67618993e-02f, 2.51130909e-01f, -3.60380709e-01f, 1.08793005e-01f,
  2.76443679e-02f, -5.30021116e-02f, 4.51591045e-01f, 5.91147542e-02f, 1.43632665e-01f, 2.59873122e-01f, 2.03443259e-01f, 4.18578565e-01f, 3.66900623e-01f, -4.24723119e-01f,
  -3.53552550e-01f, -1.01040296e-01f, 2.88245201e-01f, 1.00729980e-01f, 1.37459368e-01f, -1.07822217e-01f, 1.65843129e-01f, 1.61106497e-01f, 7.91052654e-02f, 2.63435364e-01f,
  -2.71428436e-01f, 5.01117529e-03f, -2.72076465e-02f, -3.67295235e-01f, 3.37304056e-01f, -4.51362096e-02f, 8.55453089e-02f, -7.24489763e-02f, 2.10790545e-01f, 2.79734522e-01f,
  -5.63078932e-02f, -5.56790471e-01f, 3.08282405e-01f, 2.18922704e-01f, 9.21842083e-02f, -1.25529274e-01f, 1.23774484e-01f, 1.40162092e-02f, 6.95553571e-02f, 9.10131447e-03f,
  3.83597240e-02f, 1.83462173e-01f, 2.68046975e-01f, 9.47084278e-02f, 2.27315709e-01f, 1.70409918e-01f, 5.75665683e-02f, -9.23190340e-02f, -1.61632851e-01f, -1.65321738e-01f,
  -3.50359455e-02f, 2.77437001e-01f, -3.18514168e-01f, -7.41361156e-02f, 1.47427186e-01f, 3.08212310e-01f, -1.01090312e-01f, -9.74115655e-02f, -1.89537764e-01f, -8.40632319e-02f,
  6.45446554e-02f, 9.71132591e-02f, -1.48623571e-01f, 2.34874133e-02f, -1.33646727e-01f, -3.35633755e-02f, 3.51620108e-01f, -6.82392493e-02f, 8.94620456e-03f, 2.95687258e-01f,
  -7.52294138e-02f, 4.14678544e-01f, 2.72029907e-01f, 2.57701635e-01f, -1.93320930e-01f, 1.68827072e-01f, 2.28778109e-01f, 2.77722087e-02f, 1.81881770e-01f, -2.80526489e-01f,
  2.70009220e-01f, 2.76332237e-02f, 3.34923953e-01f, 5.71751259e-02f, 3.06459628e-02f, -2.92434007e-01f, 2.38195240e-01f, -2.09783763e-02f, 1.84013829e-01f, 2.69750357e-01f,
  -1.22675532e-02f, -2.37795502e-01f, 2.11231709e-01f, 2.28079915e-01f, -2.18863502e-01f, 2.11560667e-01f, 6.68110326e-02f, -1.11984365e-01f, 1.98504478e-01f, 3.87337841e-02f,
  1.98007405e-01f, 3.39990318e-01f, 1.97671160e-01f, 2.44908288e-01f, 2.05412790e-01f, 1.51970789e-01f, 2.38105044e-01f, 2.40939796e-01f, 8.84359255e-02f, 6.56866431e-02f,
  9.73400846e-02f, -1.06891036e-01f, 1.61404207e-01f, 1.73926577e-01f, -6.62195385e-02f, -2.33014509e-01f, 7.56853893e-02f, -6.15095198e-02f, 1.73003506e-02f, -2.90248752e-01f,
  2.90135533e-01f, 2.92967856e-02f, -4.20847870e-02f, 2.00286120e-01f, -4.42857593e-02f, -6.58143237e-02f, -4.48839478e-02f, 2.00519010e-01f, 3.36609989e-01f, -8.87422413e-02f,
  -2.08684489e-01f, 7.75651112e-02f, 2.39879489e-01f, -6.49043024e-02f, -4.93776985e-02f, -2.22196087e-01f, -1.07248411e-01f, -1.21360332e-01f, -1.48240089e-01f, 2.87897885e-01f,
  -6.44294918e-02f, 2.43768588e-01f, 2.62427069e-02f, -1.19519703e-01f, -3.50459218e-01f, 1.27916977e-01f, 6.95938542e-02f, -1.67067856e-01f, -8.29649344e-02f, 2.35402450e-01f,
  1.01621337e-02f, 3.75990659e-01f, -1.56551212e-01f, -3.47156614e-01f, 2.07175940e-01f, 1.74016163e-01f, 1.62987262e-01f, 1.02482341e-01f, 3.69218975e-01f, 5.84047399e-02f,
  -2.91491032e-01f, 1.69070169e-01f, 9.97413844e-02f, 2.99171042e-02f, 9.90160853e-02f, 2.44475842e-01f, 7.63165429e-02f, -3.48109417e-02f, 2.13958398e-01f, 1.55568466e-01f,
  2.11796790e-01f, 1.16486959e-01f, 1.39935926e-01f, 1.04153246e-01f, -1.56740457e-01f, 2.58367648e-03f, -6.08349871e-03f, -4.57752645e-02f, -1.93362340e-01f, 2.57215947e-01f,
  1.52540565e-01f, -1.52350977e-01f, 1.03962131e-01f, -8.90096370e-03f, -1.17337503e-01f, -9.61700678e-02f, -2.36987680e-01f, 1.56779885e-01f, 2.49622151e-01f, 5.12016602e-02f,
  -1.00595979e-02f, 2.55068421e-01f, -1.14012547e-01f, -2.16535717e-01f, -5.48489206e-02f, -1.23517727e-02f, 4.68786895e-01f, 4.85796660e-01f, 1.36775807e-01f, 8.16964954e-02f,
  -1.60187855e-01f, 2.39530072e-01f, 1.09539896e-01f, 2.00927719e-01f, 1.64266154e-01f, -1.95831403e-01f, 7.04216436e-02f, 2.11864873e-03f, 1.45101339e-01f, -8.74842033e-02f,
  1.73953086e-01f, -4.98376824e-02f, -2.51199841e-01f, -1.57035381e-01f, 2.39830986e-02f, 2.09356681e-01f, 2.63533331e-02f, 3.67310434e-03f, 2.03447059e-01f, -3.20216268e-01f,
  -1.30301937e-01f, 2.80645460e-01f, 1.77537322e-01f, 1.76206473e-02f, 7.07610846e-02f, 1.12756997e-01f, 1.30644172e-01f, 9.22966972e-02f, -6.09645061e-02f, 1.03825033e-01f,
  2.56363526e-02f, 7.70816728e-02f, 8.66899267e-02f, 1.97307155e-01f, 1.50961488e-01f, 8.57411604e-03f, 1.40762851e-01f, 7.94322714e-02f, 1.76545326e-02f, 1.15805298e-01f,
  2.11020321e-01f, 7.50694657e-03f, 8.76723900e-02f, 9.79282800e-03f, 2.52851337e-01f, -9.41997468e-02f, -1.04309060e-02f, 1.38881162e-01f, 1.45708591e-01f, 2.10070059e-01f,
  -3.70278656e-01f, 1.19473115e-01f, 4.24846470e-01f, -6.52372316e-02f, -3.86114597e-01f, 1.99417457e-01f, 3.70787561e-01f, -9.53245237e-02f, -4.44455206e-01f, 1.38361976e-01f,
  -1.22040123e-01f, 3.32566619e-01f, -1.67129442e-01f, -2.28664801e-01f, -4.54133898e-01f, -2.60065883e-01f, -1.70896411e-01f, -3.31274569e-01f, 2.78631181e-01f, -2.66678840e-01f,
  2.36637577e-01f, -1.54722244e-01f, -3.65624875e-01f, 4.70109791e-01f, 2.02405592e-03f, 1.02174915e-01f, -6.69040263e-01f, 8.78570825e-02f, 9.09730047e-02f, 3.98212940e-01f,
  1.25623748e-01f, -2.27752000e-01f, 2.76301146e-01f, 3.51859517e-02f, 2.43659899e-01f, 4.51587066e-02f, 1.50545284e-01f, 3.68100077e-01f, -4.86910753e-02f, 3.39838803e-01f,
  1.49029180e-01f, 7.48560727e-02f, 1.23707518e-01f, 1.09846957e-01f, -1.35622844e-01f, 9.86523330e-02f, 1.36524037e-01f, 2.08671361e-01f, 3.05057317e-01f, 8.52546990e-02f,
  1.26518533e-01f, -4.12001228e-03f, -1.93232134e-01f, -1.27877906e-01f, -1.32606059e-01f, -1.16970718e-01f, 2.21958295e-01f, 9.61276982e-03f, 1.19191758e-01f, -2.69196113e-03f,
  1.31178707e-01f, 2.17151716e-01f, -2.07324877e-01f, -5.16032055e-02f, -1.03260458e-01f, -4.97851558e-02f, -1.47320973e-02f, -1.63392872e-02f, 2.62313247e-01f, -7.57616907e-02f,
  -7.16223717e-02f, 2.63794750e-01f, -2.12305680e-01f, -2.36477122e-01f, -6.85363412e-02f, 3.04816931e-01f, -6.42168671e-02f, 2.27784645e-02f, -3.25160891e-01f, 1.75262496e-01f,
  2.21300542e-01f, 1.97658055e-02f, 4.25906181e-01f, 2.43924558e-02f, 4.82742488e-01f, 1.91623375e-01f, 2.66899973e-01f, 3.21615726e-01f, 1.51836261e-01f, 2.90082693e-01f,
  7.29326010e-02f, -3.28999460e-01f, 2.61324435e-01f, -6.37052357e-02f, 4.01312888e-01f, 2.48054247e-02f, -2.88938046e-01f, -1.52854040e-01f, 1.21514555e-02f, 3.08414638e-01f,
  -1.38176262e-01f, 2.02383012e-01f, 3.14220548e-01f, 2.01479167e-01f, 1.40399605e-01f, -2.73719579e-02f, 5.14642000e-02f, -7.78605370e-03f, 1.31710038e-01f, 1.41363114e-01f,
  2.27986768e-01f, 6.47143647e-02f, 2.68588394e-01f, -1.60916857e-02f, 1.14460334e-01f, 1.67060181e-01f, -2.50036716e-01f, -1.32792160e-01f, 2.50272453e-01f, 3.26787353e-01f,
  2.90784895e-01f, -1.77956700e-01f, 1.76086977e-01f, 2.01785043e-02f, -6.67915568e-02f, -7.95625225e-02f, 3.83692980e-01f, 9.91334468e-02f, -2.51556814e-01f, -3.75086931e-03f,
  9.66142192e-02f, -1.99366584e-01f, -2.04518691e-01f, 1.06264412e-01f, 2.31723875e-01f, 3.35214674e-01f, -6.05033278e-01f, -2.68595610e-02f, -3.37680161e-01f, -1.82222620e-01f,
  -9.95836034e-02f, -3.50246727e-01f, -3.48303407e-01f, 1.52812287e-01f, 1.16902910e-01f, -2.73471802e-01f, 4.50993143e-02f, -3.38824570e-01f, 5.42999879e-02f, 1.45280764e-01f,
  3.06798100e-01f, 2.78120816e-01f, -2.99993694e-01f, -6.20576460e-03f, 9.94073525e-02f, 4.74468470e-02f, 4.23872441e-01f, 6.67860731e-02f, -3.07181999e-02f, 1.36571720e-01f,
  3.42325181e-01f, 4.11619157e-01f, -7.16354549e-02f, -8.35464150e-02f, -1.29603952e-01f, -2.25909337e-01f, 2.97492500e-02f, 4.19887513e-01f, 7.84801766e-02f, 6.54244125e-02f,
  1.56299993e-01f, 2.76443273e-01f, -1.69089045e-02f, 1.35884872e-02f, 1.05921082e-01f, 1.55329853e-01f, 1.44626603e-01f, 1.40784502e-01f, 1.34602398e-01f, 1.61182791e-01f,
  7.63278306e-02f, -1.60200596e-01f, 7.86020793e-03f, -1.79366216e-01f, 4.61221635e-02f, -1.61549333e-03f, 1.52159378e-01f, -5.13752736e-02f, 6.01278618e-03f, -2.43248671e-01f,
  -2.11085036e-01f, -8.05859268e-02f, -4.95562889e-02f, 1.92659184e-01f, 2.80436724e-01f, -2.31602462e-03f, 6.70648441e-02f, 3.59615922e-01f, 1.96963340e-01f, 1.57978028e-01f,
  -3.64660203e-01f, -8.39927867e-02f, 1.41330078e-01f, 2.64484715e-02f, 8.28252509e-02f, -3.39619756e-01f, -1.39983878e-01f, 3.23713332e-01f, -1.77295044e-01f, 2.93758243e-01f,
  -2.01775193e-01f, -4.18102771e-01f, -6.72086626e-02f, 1.74224347e-01f, -2.75378227e-01f, 6.23081140e-02f, 2.40864441e-01f, -1.52372852e-01f, -4.51220006e-01f, 1.44761369e-01f,
  -4.63613570e-02f, 3.64150017e-01f, -1.33950308e-01f, 5.38698323e-02f, 1.15224123e-01f, 4.72778529e-02f, 6.53999746e-02f, 8.16352367e-02f, 2.31069162e-01f, 3.30146432e-01f,
  -1.99130476e-01f, 1.07755303e-01f, 1.01785332e-01f, 1.94309965e-01f, 3.04884225e-01f, 9.44210589e-02f, -2.49764062e-02f, 8.74354690e-02f, 4.32168990e-02f, 1.17550589e-01f,
  2.34515108e-02f, 5.27557656e-02f, 5.80771454e-02f, 1.65155813e-01f, -3.70488577e-02f, 1.67073444e-01f, -1.51355773e-01f, -1.19480528e-01f, 2.90535968e-02f, 9.30038914e-02f,
  2.47347891e-01f, 2.56035089e-01f, -1.96756184e-01f, 1.98552907e-02f, -2.77708352e-01f, -1.76689342e-01f, -4.96543981e-02f, 2.34198749e-01f, -1.07253984e-01f, 7.66228437e-02f,
  -1.44380838e-01f, 2.78186146e-02f, -3.29533964e-01f, 5.43717861e-01f, 1.68463260e-01f, -8.11358690e-02f, 2.62105733e-01f, 4.29524302e-01f, -1.28031611e-01f, 2.95709759e-01f,
  6.93800151e-02f, 2.98320144e-01f, 1.36084840e-01f, -2.84968555e-01f, 1.11318111e-01f, 8.43033493e-02f, -1.77929271e-02f, 1.81228980e-01f, 2.24408731e-01f, 5.21162301e-02f,
  4.24822778e-01f, 3.17330599e-01f, 4.77135368e-02f, -1.44889504e-01f, 1.87301502e-01f, -3.65854263e-01f, 5.15498742e-02f, 3.32326472e-01f, 2.84891754e-01f, -3.18116605e-01f,
  -1.28523961e-01f, -1.07283562e-01f, 8.04901719e-02f, 6.38885617e-01f, -1.14437677e-01f, -3.29673856e-01f, -7.95428306e-02f, 6.04411364e-02f, -1.70208979e-02f, 1.93541855e-01f,
  5.96308112e-02f, 4.65251096e-02f, 6.37717592e-03f, -5.36356010e-02f, -2.19141573e-01f, -4.48265262e-02f, 1.14261284e-02f, 1.82339445e-01f, 1.24781236e-01f, -5.44471405e-02f,
  -5.31447679e-02f, -6.56308234e-02f, -3.03008080e-01f, -8.23232010e-02f, -9.64537039e-02f, -9.64113846e-02f, 1.13347135e-01f, 3.16008270e-01f, 6.20980095e-03f, -1.70331061e-01f,
  1.16331525e-01f, -1.13504030e-01f, -1.33513004e-01f, 3.64760220e-01f, 9.72681046e-02f, 2.11123321e-02f, -9.83113572e-02f, -3.57181162e-01f, 6.54382646e-01f, 1.00389168e-01f,
  -1.33602515e-01f, 6.13413230e-02f, 1.81090444e-01f, 5.36325872e-01f, 4.03055817e-01f, -1.54997796e-01f, -1.20254904e-01f, -2.52588809e-01f, 3.17868888e-01f, 2.99405418e-02f,
  6.80440441e-02f, -1.47524074e-01f, 3.35950255e-01f, 1.97960794e-01f, -1.24712236e-01f, 4.01110381e-01f, -2.69918740e-02f, -6.14660047e-02f, 3.13387513e-01f, -4.65115428e-01f,
  3.64900768e-01f, 3.20632368e-01f, -7.50426799e-02f, -1.10882781e-01f, 2.49927133e-01f, 3.17481935e-01f, -9.70379636e-03f, -3.09806556e-01f, 3.71124685e-01f, 1.17681570e-01f,
  1.93298701e-02f, 8.55816826e-02f, -6.28922433e-02f, -4.61316854e-02f, 2.68588215e-01f, 8.48918036e-02f, 1.29915625e-01f, -2.48229001e-02f, 1.95672467e-01f, -4.16794121e-02f,
  1.88873649e-01f, 7.15870336e-02f, -5.03523136e-03f, -2.28107318e-01f, 3.76274697e-02f, 3.04498971e-01f, -9.29284394e-02f, -7.59071857e-02f, -8.08065385e-02f, -3.00751030e-01f,
  3.13502252e-01f, -2.01167494e-01f, 1.10470437e-01f, 1.14857875e-01f, -4.04225498e-01f, -5.85655868e-02f, -1.07956663e-01f, -2.55278870e-02f, -7.31183589e-02f, 2.11123988e-01f,
  2.02580884e-01f, -3.71547192e-01f, 2.28742674e-01f, -1.16554566e-01f, 9.23173204e-02f, 1.61801686e-03f, 1.57652665e-02f, 1.93809643e-01f, 4.23153400e-01f, -3.40801962e-02f,
  3.67000587e-02f, 6.28506899e-01f, 1.29315227e-01f, -2.07030594e-01f, 3.13058615e-01f, -1.20596811e-01f, 5.52664936e-01f, 2.57522702e-01f, 4.78089973e-03f, 4.97637749e-01f,
  6.12714440e-02f, 2.44994402e-01f, -4.93909001e-01f, 3.63531142e-01f, 1.55032441e-01f, -5.30709863e-01f, -7.29869157e-02f, 4.02909070e-01f, -1.06101267e-01f, 2.39628717e-01f,
  -3.14412951e-01f, -3.76082838e-01f, 4.03427780e-01f, 1.97381839e-01f, 1.27803370e-01f, 1.55081257e-01f, -1.52771790e-02f, -5.14719151e-02f, 1.47528708e-01f, 8.87431130e-02f,
  -3.33916419e-03f, 1.22791983e-01f, 1.55957595e-01f, 1.22285850e-01f, 1.22122809e-01f, 9.86188948e-02f, -1.94830835e-01f, -2.09287688e-01f, 1.48824736e-01f, 2.45471567e-01f,
  2.22831920e-01f, 4.65099438e-04f, 1.32852465e-01f, -1.63432658e-01f, 2.04332083e-01f, -2.40317330e-01f, 2.18912020e-01f, 1.25854045e-01f, -1.71795651e-01f, -2.49357186e-02f,
  1.23953834e-01f, 6.02134541e-02f, 1.60024576e-02f, -6.91326559e-02f, 3.27201307e-01f, -2.00081214e-01f, -1.21189371e-01f, -1.83522031e-02f, -1.21516198e-01f, -6.53687865e-02f,
  -1.51813522e-01f, -1.88827872e-01f, -9.95898098e-02f, 2.59513646e-01f, 2.83897638e-01f, 5.23699671e-02f, 2.23489590e-02f, -2.21437842e-01f, 1.68566078e-01f, 8.50677043e-02f,
  7.10070670e-01f, 2.16973901e-01f, -2.08452925e-01f, -6.11118320e-03f, 1.93566024e-01f, -6.44675875e-03f, 3.39782059e-01f, 3.47347319e-01f, 3.12370151e-01f, 6.75903410e-02f,
  1.96104661e-01f, 2.38441616e-01f, -1.28672630e-01f, 2.81544685e-01f, -1.99383348e-01f, -4.22819257e-01f, 3.99853021e-01f, 2.58998156e-01f, 1.05517417e-01f, -9.86502767e-02f,
  8.33493248e-02f, 2.34453201e-01f, 6.48233891e-02f, 1.27306581e-01f, 2.13409171e-01f, -2.79035419e-02f, 2.81636328e-01f, 1.05404235e-01f, 8.34955126e-02f, 2.57546842e-01f,
  2.66151667e-01f, -6.21734634e-02f, -1.32411852e-01f, -1.64586037e-01f, -2.01105267e-01f, 4.26310115e-02f, -1.99677452e-01f, -4.06108759e-02f, 6.89884499e-02f, 8.40731803e-03f,
  -9.72670154e-04f, -1.13424309e-01f, -2.28033945e-01f, -1.24236964e-01f, 2.69273371e-01f, 4.54672277e-01f, -6.67423755e-02f, 4.17960554e-01f, 2.06941158e-01f, -3.56922209e-01f,
  3.51486176e-01f, -1.33478671e-01f, 1.60906464e-01f, -1.25211999e-01f, 1.33223951e-01f, 2.62497872e-01f, 4.54635888e-01f, -1.08606912e-01f, -2.72244960e-01f, 5.91430068e-01f,
  1.73544995e-02f, -2.53285795e-01f, 1.52514458e-01f, -2.86049843e-01f, -2.73135483e-01f, 1.54702470e-01f, 1.58540472e-01f, -2.47184802e-02f, -3.27908307e-01f, 1.14899114e-01f,
  3.40751290e-01f, 1.87589765e-01f, 1.48292437e-01f, 1.88098520e-01f, -1.18830167e-02f, -5.60852475e-02f, 4.12703753e-01f, 9.52555537e-02f, -1.60068162e-02f, -1.12529911e-01f,
  5.85154071e-02f, 2.64625192e-01f, 1.96203604e-01f, 1.11267038e-01f, -4.24213447e-02f, 1.80380002e-01f, 6.76809922e-02f, 1.49315119e-01f, 8.93286020e-02f, 2.33601749e-01f,
  9.35682505e-02f, 1.93085909e-01f, 6.38723597e-02f, 4.84143831e-02f, -6.64193481e-02f, 1.07833162e-01f, 1.17726527e-01f, 1.43502131e-02f, 3.89522493e-01f, -1.78467393e-01f,
  2.66636997e-01f, 1.96712241e-01f, -1.16062023e-01f, 6.99671805e-02f, -1.45510018e-01f, 2.92315595e-02f, 4.02354188e-02f, 3.08962613e-01f, 4.05757368e-01f, 3.20745050e-03f,
  -1.05380043e-01f, 3.48943114e-01f, 3.41253012e-01f, 1.84875533e-01f, -4.48344529e-01f, -2.55579632e-02f, -5.84464893e-02f, 3.16032588e-01f, -1.30851686e-01f, -2.73534447e-01f,
  -5.58413088e-01f, 1.37441671e-02f, 5.58003299e-02f, -4.31638271e-01f, 6.58563301e-02f, -2.20634505e-01f, 2.27614328e-01f, 1.47327676e-01f, -3.17234814e-01f, 3.94176334e-01f,
  2.73253143e-01f, 1.19093925e-01f, -2.88570285e-01f, -2.29699716e-01f, 8.97775218e-02f, 3.15229028e-01f, 1.99995592e-01f, 1.76404472e-02f, 1.42396063e-01f, 2.55011439e-01f,
  3.44271623e-02f, 5.02360351e-02f, 8.49289745e-02f, 3.88218075e-01f, -6.28671469e-03f, 2.28752419e-01f, 6.14323840e-02f, 1.58618450e-01f, 2.90918294e-02f, 1.90046877e-01f,
  -2.78996117e-02f, 1.51214138e-01f, 1.31251469e-01f, 9.03738663e-02f, 1.75763160e-01f, 8.44124332e-02f, 1.38864860e-01f, -6.04293356e-03f, 9.97326896e-03f, 9.90144163e-02f,
  -1.37554616e-01f, 2.63409019e-02f, -2.32712939e-01f, 1.75241634e-01f, -2.08120108e-01f, -2.35207044e-02f, 1.44175012e-02f, -3.69213000e-02f, 9.86227095e-02f, 5.91188520e-02f,
  -1.83938578e-01f, 1.11774661e-01f, 7.04088286e-02f, 2.49104604e-01f, -5.62122762e-01f, 2.33994037e-01f, 2.66494632e-01f, -3.27959247e-02f, 3.44966739e-01f, 2.93890890e-02f,
  1.28176123e-01f, 1.05699748e-01f, -1.01453491e-01f, 3.74490559e-01f, 3.85813355e-01f, 8.60743895e-02f, -1.97078705e-01f, -8.84151533e-02f, 7.34498817e-03f, -2.44789422e-01f,
  -9.10984427e-02f, -6.45085722e-02f, 1.42807573e-01f, 9.18253362e-02f, 4.91144061e-02f, -5.43094166e-02f, -4.76782203e-01f, -1.22734554e-01f, 2.98245788e-01f, 7.12412223e-02f,
  1.18816204e-01f, 2.46464908e-01f, 2.15076268e-01f, 5.90965301e-02f, 2.79207617e-01f, 1.78033933e-02f, 1.41034827e-01f, -3.35091352e-01f, 3.38899263e-04f, 2.74130404e-01f,
  1.33057356e-01f, 1.28029168e-01f, 9.33410600e-02f, 3.22602727e-02f, 1.31943449e-01f, 1.66723475e-01f, 6.61538467e-02f, 4.65298519e-02f, 1.82215765e-01f, 1.63606822e-01f,
  5.86992577e-02f, 1.70622259e-01f, 2.47357696e-01f, -3.52555215e-02f, -4.24137153e-02f, -5.51580563e-02f, -3.83145437e-02f, -7.90867805e-02f, -1.34077951e-01f, 6.33896515e-02f,
  -1.56272873e-01f, -5.98415732e-02f, 2.52007365e-01f, 1.21715367e-01f, -2.48037860e-01f, -1.46693349e-01f, 3.75165164e-01f, 1.22022055e-01f, -2.78112799e-01f, 2.97683835e-01f,
  2.79775172e-01f, -3.29924256e-01f, 1.35226041e-01f, 1.70807287e-01f, -5.00168046e-03f, -3.89435947e-01f, -7.99270719e-02f, -4.17829193e-02f, 1.34517789e-01f, -1.57233641e-01f,
  -2.62843877e-01f, -1.01779193e-01f, -1.52860675e-02f, -4.36106138e-03f, -1.29117012e-01f, -9.83099267e-02f, -4.22639638e-01f, 2.47519299e-01f, -1.01417869e-01f, -2.80357450e-01f,
  -4.44177330e-01f, -5.11302352e-02f, 3.00029904e-01f, 2.83792168e-01f, -1.01582721e-01f, 2.20964611e-01f, -9.09557100e-03f, 6.92579150e-02f, 4.35951948e-01f, 1.29478663e-01f,
  1.38983995e-01f, -2.82906443e-01f, -1.71985149e-01f, 3.56957972e-01f, 7.41485730e-02f, 1.23175316e-01f, 2.38642588e-01f, 1.26481280e-01f, 2.22486153e-01f, 7.41464049e-02f,
  5.80441467e-02f, 1.06171824e-01f, 1.64632052e-01f, 1.98940039e-01f, -5.94105897e-03f, -5.53491786e-02f, -1.64539292e-01f, -2.16233749e-02f, 5.02137952e-02f, 2.27171183e-01f,
  -1.91832557e-02f, -1.00278482e-01f, 7.10994899e-02f, -2.59017274e-02f, -7.21319020e-02f, -1.63572401e-01f, 2.30481297e-01f, 2.58567426e-02f, 1.55386731e-01f, 8.19636807e-02f,
  2.56152391e-01f, -1.06812485e-01f, 3.89836519e-03f, -3.13487709e-01f, 2.72919029e-01f, -3.59751247e-02f, -3.53581250e-01f, -7.48675838e-02f, -1.74731359e-01f, -5.09651959e-01f,
  -9.25161242e-02f, -4.66825128e-01f, -2.68915504e-01f, 2.63495684e-01f, 2.89591700e-01f, -2.13057846e-01f, -1.20541878e-01f, 3.65132540e-01f, -8.67961347e-03f, 1.88003317e-01f,
  6.04722857e-01f, -4.34409268e-03f, -2.73208141e-01f, -3.72101702e-02f, 2.24203303e-01f, 2.14032352e-01f, 2.13004753e-01f, -1.41202763e-01f, 3.22674513e-01f, 1.18337676e-01f,
  2.88680166e-01f, 2.11790442e-01f, -1.67922050e-01f, 3.02718014e-01f, 2.15229362e-01f, -2.02336639e-01f, 2.75311440e-01f, 2.85605758e-01f, 9.96173844e-02f, 1.32122278e-01f,
  1.37403980e-01f, -4.52953763e-02f, 1.02386564e-01f, 2.07668558e-01f, 1.93147391e-01f, 2.62837768e-01f, 1.20503284e-01f, 6.65654615e-02f, 7.96178952e-02f, 1.30846232e-01f,
  -2.34045506e-01f, 5.09065986e-02f, 4.28435318e-02f, 1.03831105e-01f, -1.79908127e-02f, -3.21813345e-01f, -4.56502773e-02f, -2.36810790e-03f, -1.01970755e-01f, -3.93800810e-02f,
  2.54558653e-01f, 2.32031658e-01f, 1.01146862e-01f, 3.22987527e-01f, -2.35321760e-01f, -2.87856460e-01f, 2.38377713e-02f, -2.16534823e-01f, 1.32291391e-01f, 3.06909055e-01f,
  -2.62408584e-01f, -7.44612515e-02f, 3.54256928e-02f, 1.03566032e-02f, -2.38300011e-01f, -7.91761745e-03f, -8.55053589e-02f, 2.35557452e-01f, 1.67386338e-01f, -3.65777493e-01f,
  1.18614733e-01f, 3.78143907e-01f, 2.95191277e-02f, 1.59082517e-01f, 4.63546693e-01f, -2.62017902e-02f, -1.35297522e-01f, 1.93383336e-01f, 2.04980358e-01f, 3.10885191e-01f,
  3.08851033e-01f, -3.03448021e-01f, 2.05611661e-01f, 2.02073902e-01f, 1.27460197e-01f, 2.76117176e-01f, -1.50382772e-01f, -1.21933565e-01f, 2.28562310e-01f, -2.24003926e-01f,
  1.42910764e-01f, 8.02858174e-02f, -2.29150318e-02f, -3.23625356e-02f, -1.40041849e-02f, -1.63622550e-03f, 7.27732927e-02f, 2.27008611e-01f, -3.73975411e-02f, 2.52406508e-01f,
  1.45136595e-01f, 5.81428483e-02f, 3.70644301e-01f, 3.50792736e-01f, -3.65747288e-02f, 7.16562793e-02f, -3.43358256e-02f, -2.71961510e-01f, -3.27458769e-01f, -5.12587018e-02f,
  -1.94098040e-01f, -9.30322334e-02f, 3.56300250e-02f, -2.13753618e-02f, -3.69169079e-02f, -2.14230955e-01f, 1.35181621e-01f, 1.98427841e-01f, -5.34348004e-02f, 1.72855899e-01f,
  4.14014533e-02f, 2.85218030e-01f, 7.45474547e-02f, -3.18345964e-01f, 4.04942244e-01f, 2.60734588e-01f, 3.75237405e-01f, 4.19048190e-01f, 2.44055539e-01f, 4.36882645e-01f,
  5.52983999e-01f, -2.35951930e-01f, -2.22312227e-01f, 2.77895242e-01f, 3.95521000e-02f, 3.98153216e-02f, -7.23243579e-02f, -2.44153306e-01f, -2.52779186e-01f, 2.15367034e-01f,
  1.08499371e-01f, 3.14619904e-03f, -1.37184579e-02f, 3.35104674e-01f, -4.74411957e-02f, 1.64587155e-01f, -1.52151138e-01f, -7.17900917e-02f, -4.91250716e-02f, -2.26905774e-02f,
  4.71321136e-01f, -1.75313383e-01f, 4.02905703e-01f, -1.75263569e-01f, 1.09944932e-01f, -8.02820548e-02f, 2.11067244e-01f, 1.56244025e-01f, 2.54427493e-01f, 3.57070118e-02f,
  -5.16283959e-02f, 2.37742051e-01f, 3.01202744e-01f, -1.94213092e-02f, 2.41329707e-02f, 1.21804292e-03f, 1.28876477e-01f, 2.41362587e-01f, 3.98073345e-02f, -2.55995601e-01f,
  1.70054570e-01f, -6.27803802e-02f, 4.95032445e-02f, 1.58623040e-01f, 1.23103157e-01f, -2.95814931e-01f, 2.32786566e-01f, -9.15907845e-02f, -7.72404224e-02f, -1.55921906e-01f,
  -3.48772496e-01f, -1.22310415e-01f, -1.24697872e-01f, 9.70058292e-02f, 1.99762776e-01f, 4.00835842e-01f, 2.04838395e-01f, 9.53604206e-02f, -5.66750243e-02f, -2.10324526e-01f,
  1.41963571e-01f, -1.49466351e-01f, 2.58160412e-01f, -8.75211731e-02f, 2.75359660e-01f, 1.26141295e-01f, 3.91712561e-02f, 5.68743944e-01f, 2.26937696e-01f, -3.41055334e-01f,
  7.57364184e-02f, -7.98872560e-02f, 3.50333810e-01f, 3.55423033e-01f, 1.09962471e-01f, 2.65958369e-01f, -2.53273007e-02f, 1.78590089e-01f, 3.28695804e-01f, 7.33233765e-02f,
  1.26371190e-01f, 1.51083529e-01f, -3.59702021e-01f, -1.13484468e-02f, 2.43076071e-01f, 1.36382505e-01f, -3.76244336e-01f, 4.76702675e-02f, 2.26542890e-01f, 1.95668265e-01f,
  2.39239912e-02f, 3.63523886e-02f, 8.19162428e-02f, 4.33323830e-02f, 1.27576798e-01f, 1.84735060e-02f, 1.77544169e-02f, 1.05615430e-01f, 7.98431784e-02f, 1.93029538e-01f,
  1.95410609e-01f, 2.09409773e-01f, -3.10799599e-01f, -3.65503579e-02f, 1.67997167e-01f, -3.16485278e-02f, -4.45483327e-02f, -3.09420288e-01f, -1.30279988e-01f, -1.39167026e-01f,
  -6.98537380e-03f, 5.61272278e-02f, 1.93145409e-01f, 2.69189835e-01f, 9.82416868e-02f, 4.48808968e-01f, -2.74129510e-01f, -8.75702351e-02f, -8.22201520e-02f, -4.07825783e-02f,
  1.80209115e-01f, 7.06214784e-03f, 1.77898407e-01f, 1.23698197e-01f, 5.05368710e-02f, 1.02262288e-01f, -2.30296224e-01f, 4.28609908e-01f, 2.56749451e-01f, -3.44513237e-01f,
  -4.20750938e-02f, -3.13056409e-01f, 3.92622538e-02f, 4.26045388e-01f, 1.89403206e-01f, -7.66848251e-02f, 2.42353663e-01f, 2.86096007e-01f, 5.84194250e-02f, 2.43495181e-01f,
  2.26786897e-01f, 1.02768339e-01f, -2.39660501e-01f, -1.38404012e-01f, 4.36513945e-02f, -3.20124060e-01f, 3.69152814e-01f, 3.68610173e-01f, 5.82660623e-02f, -9.54271182e-02f,
  2.64654428e-01f, -5.21161914e-01f, 2.99021453e-01f, 2.99461489e-03f, 2.14449354e-02f, 1.49061203e-01f, -4.50021364e-02f, 9.66569558e-02f, 3.28952707e-02f, 3.84715088e-02f,
  1.07142784e-01f, 9.30409506e-02f, 3.64881083e-02f, 3.09357308e-02f, -1.51587680e-01f, -1.22515269e-01f, -1.51013061e-01f, -4.79980186e-02f, -1.30477339e-01f, -5.97461797e-02f,
  -5.26915975e-02f, 1.44939661e-01f, -2.55115516e-02f, -7.89117143e-02f, -3.25084627e-02f, -8.93568471e-02f, -1.71305835e-01f, -1.91492185e-01f, 3.92868556e-03f, 1.38806581e-01f,
  4.38850420e-03f, 8.92542601e-02f, -1.79926634e-01f, 1.07402854e-01f, 5.92274144e-02f, 6.55235797e-02f, 4.38571334e-01f, 3.35235476e-01f, 5.13700321e-02f, 3.22258860e-01f,
  5.54821715e-02f, 3.45974743e-01f, 5.36589809e-02f, 5.14800608e-01f, 8.27206299e-02f, 2.27134004e-01f, -9.64434072e-02f, -4.45400029e-02f, -2.38311943e-02f, 1.06736630e-01f,
  1.81215450e-01f, -1.59874916e-01f, 3.18545908e-01f, -9.75025743e-02f, 9.83123481e-02f, -1.29266754e-01f, -4.63434398e-01f, 2.28678331e-01f, -6.76079281e-03f, -2.22134665e-01f,
  3.36367786e-01f, -4.93528880e-02f, -3.40739965e-01f, 4.24084924e-02f, 1.97343924e-03f, 7.96164200e-02f, 2.52519511e-02f, 6.72719106e-02f, 1.13796659e-01f, 8.36136937e-02f,
  8.02330077e-02f, 1.34005964e-01f, 6.08341321e-02f, 1.42436102e-01f, 2.25260314e-02f, -7.30661377e-02f, 1.81316957e-01f, 1.53638750e-01f, 2.03218102e-01f, 1.58693522e-01f,
  2.59616733e-01f, -5.30254422e-03f, -8.45208205e-03f, -2.90373489e-02f, -1.64672554e-01f, 4.69194949e-02f, -3.89079392e-01f, -9.24267992e-02f, 2.94776279e-02f, 3.65652889e-01f,
  9.30743292e-02f, -4.97638062e-03f, -1.10034384e-01f, -2.15824857e-01f, 1.94295228e-01f, 2.16720685e-01f, -3.65338653e-01f, 3.24367315e-01f, 3.07855811e-02f, -2.66858548e-01f,
  4.02511895e-01f, -4.13426645e-02f, -7.18877763e-02f, -1.05180904e-01f, 4.67009172e-02f, 4.33325380e-01f, 4.74328786e-01f, 2.07476780e-01f, -2.53800035e-01f, 9.08395201e-02f,
  1.68146625e-01f, 2.90841702e-02f, -4.49142914e-04f, -1.88199148e-01f, 3.66512626e-01f, 1.18254237e-01f, 8.22996944e-02f, 1.60937399e-01f, -3.39445882e-02f, -3.50278243e-02f,
  3.89709204e-01f, -1.90807909e-01f, 1.54864863e-01f, 4.16328609e-01f, -5.49386442e-02f, -1.47307202e-01f, 4.31696177e-01f, 2.74742723e-01f, -3.53515744e-01f, -3.39183331e-01f,
  1.04957052e-01f, 1.63140476e-01f, 2.44054254e-02f, 1.30139351e-01f, 1.45511270e-01f, 6.94966167e-02f, 1.36110991e-01f, 5.82955368e-02f, 1.39192253e-01f, 3.95940542e-02f,
  8.50033239e-02f, 4.37146239e-02f, 5.92619665e-02f, 9.13514420e-02f, 4.76562828e-02f, -1.24510698e-01f, -2.52882075e-02f, -1.89000055e-01f, -5.47188409e-02f, -7.63701051e-02f,
  1.15793802e-01f, 7.58652762e-02f, 2.32534319e-01f, -5.34513444e-02f, 8.57242942e-03f, -1.23482674e-01f, -2.39134599e-02f, 2.04078276e-02f, -2.04856187e-01f, 2.86734998e-01f,
  2.84125268e-01f, 1.90784648e-01f, -1.43851757e-01f, 2.84030437e-01f, -4.25192043e-02f, 3.64999235e-01f, -1.57173946e-02f, -4.92881350e-02f, 1.40683621e-01f, -4.36506569e-01f,
  -1.25438213e-01f, -2.20260039e-01f, 1.26915976e-01f, 5.05868196e-01f, 1.71876729e-01f, -6.81970790e-02f, 6.59031346e-02f, -1.80779323e-01f, -3.37834328e-01f, 3.46352547e-01f,
  7.98421726e-02f, 1.33837193e-01f, 1.51697353e-01f, 1.26727402e-01f, 2.26311937e-01f, 3.49728465e-01f, 1.04300432e-01f, -1.97147578e-01f, -1.71764717e-02f, 1.53777838e-01f,
  2.32928231e-01f, -1.21726952e-02f, -7.18673229e-01f, 2.55173475e-01f, -3.81101608e-01f, 9.86142531e-02f, 3.38029116e-02f, 6.91537857e-02f, 1.50088832e-01f, 2.34554753e-01f,
  7.53840953e-02f, -4.87413853e-02f, 5.54937460e-02f, 1.07781991e-01f, 1.38226479e-01f, 2.42960319e-01f, 1.96066368e-02f, 2.98047103e-02f, -2.84259528e-01f, -1.20859239e-02f,
  -1.36622563e-02f, -2.38024034e-02f, 1.43163949e-01f, 2.27621660e-01f, 6.98583275e-02f, 1.46827891e-01f, -6.80583045e-02f, -1.02103971e-01f, -2.13670552e-01f, 2.07984895e-02f,
  -5.57731949e-02f, 3.80150825e-01f, 9.59908962e-02f, -2.30691954e-02f, -8.02999809e-02f, -8.92668813e-02f, -5.24456911e-02f, 2.79779911e-01f, 8.06345642e-02f, 6.19417056e-03f,
  2.83236355e-01f, 3.88296127e-01f, -1.88329265e-01f, 1.47653997e-01f, -1.24421433e-01f, 4.56710070e-01f, 4.98061767e-03f, -7.50723407e-02f, -2.44913861e-01f, -7.25888298e-04f,
  7.48204812e-02f, 5.69103770e-02f, 4.31939572e-01f, -4.65376616e-01f, 3.19209248e-01f, -1.17417291e-01f, -3.95868812e-03f, 3.84793468e-02f, -1.32320691e-02f, 1.79033130e-01f,
  -3.39361280e-02f, 2.20408097e-01f, 3.66364837e-01f, -1.48832873e-01f, -3.62728745e-01f, 2.35061198e-01f, 3.83010805e-01f, 3.57304811e-01f, -2.46867072e-02f, -8.02172571e-02f,
  4.34427783e-02f, 8.39890167e-02f, -1.98931471e-02f, 2.49001503e-01f, 1.05156697e-01f, 8.19618553e-02f, 2.88947672e-01f, 3.39399368e-01f, 3.43549475e-02f, 6.19402155e-03f,
  -8.34832489e-02f, 2.11987093e-01f, -2.28118345e-01f, 6.11588508e-02f, -2.18136638e-01f, -2.08590388e-01f, 4.20092762e-01f, 2.26961106e-01f, 4.79672328e-02f, 1.66162446e-01f,
  -1.31581023e-01f, -6.02590628e-02f, -4.33811486e-01f, -2.06361488e-01f, -1.99414909e-01f, 2.94425279e-01f, 4.64558341e-02f, -4.47692946e-02f, -1.60165235e-01f, 5.08416295e-02f,
  -2.34022856e-01f, 2.61956364e-01f, -1.05453536e-01f, -1.83290377e-01f, 3.13062072e-01f, 4.21555102e-01f, -5.91035932e-02f, -2.41814643e-01f, -4.21240211e-01f, 5.86767137e-01f,
  -1.66452646e-01f, -8.09518807e-03f, -4.06396016e-02f, -9.13077667e-02f, 8.60180557e-02f, 2.51095027e-01f, -7.77599290e-02f, -2.30972722e-01f, 4.28009212e-01f, -7.50854239e-02f,
  -2.04766408e-01f, -8.40160549e-02f, -2.07598209e-01f, 1.33564517e-01f, 1.86128795e-01f, 2.92712450e-01f, 8.97882581e-02f, -2.16432989e-01f, -2.96801597e-01f, 3.55440497e-01f,
  3.95136952e-01f, 5.96170902e-01f, 2.26245206e-02f, -1.88667685e-01f, 2.16480166e-01f, -4.60001156e-02f, 2.89806038e-01f, 3.19638774e-02f, -1.31067280e-02f, 2.41367146e-01f,
  2.30833948e-01f, 2.24462420e-01f, 1.90588295e-01f, 2.10069850e-01f, 1.65281653e-01f, 1.89731926e-01f, 1.76795870e-02f, -9.63009894e-02f, 2.81329036e-01f, 6.61007613e-02f,
  -1.74125507e-02f, -1.30346686e-01f, 2.69875526e-01f, 2.08654299e-01f, 8.84450153e-02f, -2.66459525e-01f, 5.09209968e-02f, 5.95565187e-03f, 7.95260910e-03f, -9.23553407e-02f,
  -1.25007167e-01f, 9.58806928e-03f, 2.43434653e-01f, -2.73556374e-02f, 8.53141584e-03f, 8.23509172e-02f, -4.33262959e-02f, -1.86826274e-01f, 3.12924653e-01f, -2.39426449e-01f,
  -5.72571084e-02f, -3.37496430e-01f, -4.61205281e-02f, 2.15518609e-01f, 1.02881111e-01f, 1.58936337e-01f, 1.77305385e-01f, 3.53447586e-01f, -7.14904070e-02f, 8.02122653e-02f,
  2.20827475e-01f, 6.54170290e-02f, 2.20144928e-01f, -4.35835458e-02f, 5.50514273e-02f, 5.99650621e-01f, 3.56843024e-01f, 3.21265787e-01f, -1.13481477e-01f, 3.02023143e-01f,
  -2.31179804e-01f, 2.63080388e-01f, 2.05907688e-01f, -2.07526043e-01f, 1.01966951e-02f, 4.14904505e-01f, -2.38004804e-01f, -1.74243450e-01f, 9.04141739e-02f, 1.28850088e-01f,
  -8.33025649e-02f, -3.94469500e-02f, 1.99641883e-01f, 8.81787464e-02f, -1.83188900e-01f, 1.79756269e-01f, 6.16976544e-02f, -1.52574042e-02f, 2.35913638e-02f, -6.93247095e-02f,
  -2.14432433e-01f, 9.88653526e-02f, 7.41258487e-02f, 2.74751306e-01f, 2.06313536e-01f, -3.14940602e-01f, 2.26515472e-01f, -5.60159348e-02f, 8.30929354e-02f, -1.28345862e-01f,
  2.52792418e-01f, 2.29932606e-01f, -6.11656681e-02f, 2.66824305e-01f, -2.49210522e-01f, -2.33103000e-02f, 2.05513895e-01f, -3.68528277e-01f, -1.15305968e-02f, 2.73958117e-01f,
  -2.61538416e-01f, 3.31609622e-02f, -2.01717541e-01f, 2.23159902e-02f, -2.13044152e-01f, -1.27537385e-01f, -4.79519635e-01f, -2.15818793e-01f, 2.99320072e-01f, 6.62178472e-02f,
  1.91558106e-03f, -1.05351724e-01f, 1.96685836e-01f, -1.56149313e-01f, 2.44668305e-01f, 3.69271874e-01f, -9.48003400e-03f, 2.37283707e-01f, 3.03310633e-01f, -8.34154617e-03f,
  2.00105414e-01f, -2.06602290e-02f, 2.16782823e-01f, -2.85161287e-01f, 5.97972870e-02f, 4.12064135e-01f, -3.22454870e-01f, 9.37480032e-02f, -6.72306001e-01f, 3.00466478e-01f,
  2.69921184e-01f, -3.64957601e-02f, -8.36272165e-02f, 1.06678903e-01f, 5.55401109e-03f, 1.41989067e-01f, 6.39566109e-02f, 1.05340011e-01f, 5.12064546e-02f, 1.33103311e-01f,
  -1.79518033e-02f, 1.76573932e-01f, 1.79109901e-01f, 9.55399349e-02f, -1.15784537e-02f, 1.02803566e-01f, -5.16516715e-02f, -5.82635030e-02f, 1.30340740e-01f, -9.30133536e-02f,
  -1.38531938e-01f, 1.41883701e-01f, -1.77473292e-01f, -8.18728805e-02f, 7.64193311e-02f, -7.80382529e-02f, -8.93373042e-03f, 2.97075342e-02f, -5.32656237e-02f, 2.70498037e-01f,
  1.41979933e-01f, -2.05852091e-01f, -2.17456654e-01f, -5.93895763e-02f, 1.26158133e-01f, -8.97254124e-02f, 2.81307817e-01f, -2.33051226e-01f, -1.59509899e-03f, 1.37185872e-01f,
  -1.26386108e-02f, 2.68955261e-01f, 1.27182320e-01f, 2.16110814e-02f, -1.80935226e-02f, 1.05884641e-01f, -1.79344669e-01f, -4.15910259e-02f, 2.33142570e-01f, -4.38424885e-01f,
  7.06426576e-02f, -1.03884190e-01f, 1.81411713e-01f, 2.04352424e-01f, 1.48810774e-01f, -2.41787747e-01f, -9.69267190e-02f, 4.94475424e-01f, -2.17189223e-01f, -1.42738789e-01f,
  2.53087014e-01f, 1.15464523e-01f, 5.53141236e-01f, 2.94694811e-01f, -1.00209258e-01f, -4.79433358e-01f, 1.00826629e-01f, 1.71363547e-01f, 1.14040151e-01f, 1.88674226e-01f,
  1.21628150e-01f, 1.26146898e-01f, 1.17551968e-01f, 9.17508975e-02f, 1.39451906e-01f, 1.86890125e-01f, -6.31257966e-02f, -5.27297780e-02f, 1.89670831e-01f, -3.86623293e-02f,
  -1.88959911e-01f, 6.64921338e-03f, 2.16081515e-01f, 4.24360931e-02f, 4.29165587e-02f, 8.41276646e-02f, -2.34595656e-01f, -2.01439038e-01f, -1.86411917e-01f, -4.96984310e-02f,
  -2.43699104e-01f, 8.34934264e-02f, 2.38860965e-01f, 2.87679106e-01f, -2.95619100e-01f, 2.09328651e-01f, 3.12585741e-01f, 6.23652190e-02f, -6.23042462e-04f, 2.54276078e-02f,
  -2.08184272e-02f, -7.99757522e-03f, -1.19328246e-01f, 1.23020671e-01f, -6.68435097e-02f, 1.45769387e-01f, -2.40652770e-01f, -8.07116702e-02f, -6.32117018e-02f, -2.92749286e-01f,
  -6.96851462e-02f, 8.90374109e-02f, -3.41469437e-01f, -9.94162038e-02f, 2.22439393e-01f, -2.49303713e-01f, -3.88892084e-01f, -3.02725911e-01f, 2.06514299e-02f, 3.07978660e-01f,
  -1.10313639e-01f, 2.41841227e-01f, 2.51352549e-01f, 1.91490352e-01f, 4.95003797e-02f, 2.31538236e-01f, 2.92006642e-01f, 2.37934709e-01f, -2.79374808e-01f, 2.77156830e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  8.14701915e-02f, 1.29023716e-01f, 2.59337485e-01f, 2.85325229e-01f, 2.61031777e-01f, 2.17325017e-01f, 1.70588180e-01f, 2.45988026e-01f, 2.37528697e-01f, 2.44775400e-01f,
  1.15807950e-01f, 1.94066554e-01f, 2.37922326e-01f, 1.31098062e-01f, 8.72541368e-02f, 1.24004848e-01f, 1.61780879e-01f, 2.30125263e-01f, 3.11059445e-01f, 2.00244918e-01f,
  8.19577202e-02f, 1.55908525e-01f, 2.17329457e-01f, 5.96476980e-02f, 9.88010913e-02f, 9.34987888e-02f, 2.26249948e-01f, 2.82992154e-01f, 3.19331616e-01f, 3.28821748e-01f,
  2.47636467e-01f, 8.12055245e-02f, 8.48805904e-02f, 2.20448807e-01f, 2.27103814e-01f, 9.75989550e-02f, 2.99192399e-01f, 1.13940224e-01f, 1.39809147e-01f, 2.12208584e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  8.11938476e-03f, -3.24456871e-01f, -2.35190690e-01f, -1.54379770e-01f, -1.06510818e-01f, -2.37171546e-01f, -4.05219674e-01f, 9.27331597e-02f, 9.32914093e-02f, -2.10619688e-01f,
  1.16411313e-01f, -1.19656743e-02f, 3.18735600e-01f, -2.78884977e-01f, -3.50964218e-01f, 1.52190208e-01f, 1.90240860e-01f, 2.53523201e-01f, 1.80595443e-01f, 1.82596669e-01f,
  -9.70844179e-02f, -1.31751135e-01f, 1.89448833e-01f, -2.18894973e-01f, 2.03414947e-01f, 1.39635056e-01f, 1.71339095e-01f, -3.49599183e-01f, 1.03978433e-01f, -4.67834294e-01f,
  -8.01433027e-02f, -2.20261201e-01f, 1.56664282e-01f, -6.16688967e-01f, 2.70859003e-01f, -1.58474684e-01f, -2.56506711e-01f, -6.48070946e-02f, 1.67726278e-01f, 1.80027887e-01f,
  1.70559987e-01f, -4.64023709e-01f, -3.20947230e-01f, 2.41973177e-01f, 1.13188744e-01f, 9.63564739e-02f, -1.84164673e-01f, 1.56129658e-01f, -8.69236365e-02f, -2.20994532e-01f,
  2.32407033e-01f, 2.47729287e-01f, -3.77826244e-01f, 5.67388022e-03f, 1.95018843e-01f, -2.63021916e-01f, -2.91164815e-05f, -2.69451916e-01f, -5.27416527e-01f, -3.04866254e-01f,
  -3.08406174e-01f, 2.93057948e-01f, 8.65788013e-02f, -4.94540036e-01f, 7.61338770e-02f, 8.75244886e-02f, 1.27037629e-01f, -2.48225957e-01f, 5.89669980e-02f, -9.46002081e-02f,
  2.71369398e-01f, 2.19625626e-02f, -2.42267355e-01f, 1.71094090e-02f, -9.43886191e-02f, -2.41255596e-01f, 4.62633036e-02f, 3.27311099e-01f, 2.12338671e-01f, 3.01346123e-01f,
  -1.55681700e-01f, -6.42850175e-02f, 6.41585663e-02f, 4.10271257e-01f, 2.19264254e-01f, -1.73774645e-01f, -5.28849483e-01f, -4.57456149e-03f, 1.47593573e-01f, -3.55453491e-01f,
  -7.58758560e-02f, 2.46558916e-02f, -1.34023428e-01f, -4.40811932e-01f, -4.59212214e-01f, 3.60665500e-01f, 1.31997436e-01f, 2.85616983e-02f, -5.83624244e-01f, -4.56912458e-01f,
  7.00071175e-03f, -2.77296782e-01f, -2.02815205e-01f, -7.08947191e-03f, 2.89358675e-01f, -1.72243252e-01f, 1.60382539e-01f, -4.04152095e-01f, 3.59351367e-01f, 2.58645743e-01f,
  -4.84216958e-01f, 4.59035710e-02f, -4.43401366e-01f, -4.20453995e-01f, 2.17881799e-01f, 2.51316547e-01f, -2.01332584e-01f, -4.00689207e-02f, 2.57834792e-01f, 7.17504397e-02f,
  -5.17751157e-01f, 7.86264092e-02f, 5.99181140e-03f, -1.95975438e-01f, 2.33360361e-02f, 4.13365960e-01f, -1.84110537e-01f, -3.07019204e-01f, 1.48570538e-01f, 6.03665002e-02f,
  5.67159578e-02f, -8.40777718e-03f, 2.70661443e-01f, -1.23142570e-01f, 5.97099513e-02f, -5.39548174e-02f, 4.29220200e-02f, 3.31633873e-02f, -2.57063657e-01f, -1.12574093e-01f,
  -4.03982624e-02f, -3.68245929e-01f, -1.23315072e-02f, 4.14358079e-01f, -3.02630812e-02f, 1.74223315e-02f, -2.72728875e-02f, 6.85573965e-02f, -2.48113260e-01f, -4.04476047e-01f,
  -9.16988179e-02f, 1.52809948e-01f, -1.50311559e-01f, -3.54928613e-01f, -2.79512018e-01f, -1.29101738e-01f, -1.95073217e-01f, 3.12403649e-01f, -6.32977411e-02f, -3.72575521e-01f,
  -3.75612965e-03f, -5.20303249e-01f, -2.98512667e-01f, 2.00311899e-01f, -4.98071551e-01f, 2.31023803e-01f, -6.91777289e-01f, 1.84365585e-01f, 2.37209678e-01f, -1.71981037e-01f,
  1.35031983e-01f, -8.96056145e-02f, -3.72994900e-01f, 2.27541789e-01f, -2.46665135e-01f, -2.67495334e-01f, 1.40682250e-01f, -1.66419357e-01f, 3.07218581e-01f, 2.88003057e-01f,
  -3.04626107e-01f, 2.32180938e-01f, -3.98053944e-01f, -9.16931778e-02f, 3.78114283e-01f, -2.50498801e-01f, 7.17152655e-02f, -8.05735365e-02f, 2.73967683e-01f, -3.01162750e-02f,
  1.98263913e-01f, -3.47050786e-01f, -2.68360507e-02f, -3.52146000e-01f, 2.69810498e-01f, -2.98702829e-02f, 8.53829011e-02f, -3.56862368e-03f, 3.35713327e-02f, 2.83282548e-02f,
  -1.15799539e-01f, 1.17028793e-02f, -1.80944681e-01f, -2.81766027e-01f, 8.72934312e-02f, 2.53788412e-01f, -2.07407162e-01f, -2.56182432e-01f, 1.10739298e-01f, -5.39897263e-01f,
  2.75252610e-01f, -1.15213655e-01f, 1.65322363e-01f, 4.67363954e-01f, 3.89647782e-01f, 1.09798700e-01f, -2.82746494e-01f, 2.66184092e-01f, -7.92128071e-02f, -3.22874665e-01f,
  8.01047757e-02f, -8.03241059e-02f, -2.59244680e-01f, -2.40839034e-01f, -7.28479803e-01f, -2.81546235e-01f, 2.89036363e-01f, 1.54143810e-01f, -2.47897252e-01f, -5.51786199e-02f,
  -3.54117274e-01f, 4.89880666e-02f, -2.62700886e-01f, -3.78247768e-01f, -1.21689916e-01f, 2.88493633e-01f, 1.95139125e-01f, -2.41786707e-02f, 1.47016793e-01f, -7.65302539e-01f,
  2.67168045e-01f, -2.40146533e-01f, -6.83379620e-02f, -6.75588893e-03f, 2.23994076e-01f, 1.56812862e-01f, 2.41030321e-01f, 1.98119432e-01f, 3.35429430e-01f, -3.47971112e-01f,
  -3.55008930e-01f, -5.57750583e-01f, -3.55622500e-01f, -4.34951246e-01f, -3.19513321e-01f, -2.38588735e-01f, -1.00874029e-01f, 1.96517587e-01f, -3.97530161e-02f, -1.03769034e-01f,
  1.22281440e-01f, 1.43690735e-01f, -1.19796835e-01f, -3.55440319e-01f, -5.43816239e-02f, 4.77085114e-01f, 2.25024447e-01f, -9.72690806e-02f, -4.13850337e-01f, 8.74771178e-02f,
  4.34525132e-01f, -4.50670272e-01f, 1.79313138e-01f, 3.12596828e-01f, -1.08314328e-01f, -3.86383593e-01f, -1.03033371e-01f, 4.02127616e-02f, -1.09521993e-01f, 6.92621350e-01f,
  1.62020519e-01f, 1.58078328e-01f, 1.94573268e-01f, -1.04871571e-01f, 1.90365091e-01f, -2.37657651e-01f, 2.88158357e-01f, -2.86710441e-01f, -8.92426353e-03f, -4.55318615e-02f,
  7.82479793e-02f, 1.39222741e-01f, -1.03732020e-01f, 1.86717153e-01f, 4.77675460e-02f, 7.09222704e-02f, -4.83441412e-01f, 3.07431109e-02f, -4.87551302e-01f, 5.56587521e-03f,
  7.66332746e-02f, -1.45017095e-02f, 1.51302695e-01f, 2.25384487e-03f, -1.84042603e-01f, -3.76577169e-01f, 8.25083107e-02f, -3.34068894e-01f, -3.39924432e-02f, 5.35408147e-02f,
  -1.71094075e-01f, 2.72773027e-01f, -1.55024519e-02f, 1.78485960e-01f, -5.15703037e-02f, 3.44114929e-01f, -3.24314296e-01f, -7.05929324e-02f, -2.07795188e-01f, -1.18525051e-01f,
  1.79499146e-02f, 1.22321032e-01f, -3.31145108e-01f, 2.79487282e-01f, -6.40913025e-02f, -1.66587934e-01f, 9.45826098e-02f, -1.86778337e-01f, 2.60095745e-01f, -4.16568778e-02f,
  3.67174245e-04f, 1.33586794e-01f, 1.41832113e-01f, 2.26873998e-02f, 1.29788056e-01f, 5.95543385e-02f, -3.05072337e-01f, -6.17140206e-03f, 1.18351273e-01f, -9.44725946e-02f,
  -2.62334585e-01f, -3.31805021e-01f, 2.17024937e-01f, -6.42320737e-02f, -6.82381541e-02f, -1.52405307e-01f, 4.09207314e-01f, -1.54306054e-01f, -2.06285417e-01f, 1.76249109e-02f,
  -2.36651748e-01f, 7.70511255e-02f, 1.53301999e-01f, 2.02387437e-01f, -3.67318362e-01f, -3.45682621e-01f, 2.37071425e-01f, 2.50106174e-02f, 4.65135723e-01f, -1.43399134e-01f,
  2.54364252e-01f, 2.98314273e-01f, -4.01047081e-01f, -3.38928014e-01f, -1.10869288e-01f, 1.02353409e-01f, 1.53208911e-01f, 3.55378062e-01f, 2.71279573e-01f, 5.61886013e-01f,
  1.53957456e-01f, -1.90926045e-01f, -5.17166480e-02f, -1.04803473e-01f, -1.92931458e-01f, -7.75689110e-02f, 6.31110072e-02f, -2.34671444e-01f, -2.13034183e-01f, -5.60284376e-01f,
  -1.65364206e-01f, -5.29413342e-01f, -2.49053121e-01f, 4.50169176e-01f, 1.47920415e-01f, -9.76675898e-02f, 1.58801302e-01f, 3.73415537e-02f, -7.52812773e-02f, 1.49453476e-01f,
  -2.97820896e-01f, 1.13715783e-01f, 1.09454349e-01f, 1.21965662e-01f, 2.81985849e-01f, -2.26546898e-02f, -4.55724560e-02f, -1.51056111e-01f, -6.29880577e-02f, -9.97678041e-02f,
  1.27314568e-01f, -2.68729836e-01f, -3.77389230e-02f, -3.18316817e-01f, -9.92540717e-02f, -2.48751730e-01f, -1.23262294e-02f, -2.03581497e-01f, -8.46696943e-02f, -6.20711565e-01f,
  -2.85226911e-01f, 5.18852752e-03f, -5.59496641e-01f, 1.78837046e-01f, 2.15427816e-01f, 1.73579063e-02f, 1.36963828e-02f, -2.33536270e-02f, -1.82515025e-01f, -1.83127999e-01f,
  -3.11824352e-01f, -3.05935629e-02f, -2.27473572e-01f, -6.01269901e-02f, 3.09965536e-02f, 2.79991329e-01f, 2.45480806e-01f, -4.81664240e-01f, -1.79120108e-01f, -4.26950336e-01f,
  -5.36103129e-01f, 2.74466097e-01f, -3.37218978e-02f, -1.79134995e-01f, -6.02203086e-02f, 2.98937950e-02f, -5.94919920e-01f, -3.50148231e-01f, -5.86503685e-01f, 5.15442118e-02f,
  -3.71454090e-01f, -4.57271427e-01f, 3.32426965e-01f, 4.29864198e-01f, -6.20862804e-02f, -4.14132446e-01f, 2.19386816e-01f, 3.82748663e-01f, -1.66304886e-01f, -2.74512661e-03f,
  -1.48119166e-01f, 1.63763333e-02f, 5.72019070e-02f, 7.14959130e-02f, -1.05510958e-01f, 1.42679349e-01f, -1.10528924e-01f, -2.59571433e-01f, -2.39204586e-01f, 1.97356015e-01f,
  -1.61944926e-01f, -3.62699240e-01f, -1.25004932e-01f, -1.34030879e-01f, 1.19605944e-01f, -2.70393282e-01f, 1.37199476e-01f, 2.81270951e-01f, 2.07659215e-01f, 4.80228178e-02f,
  -2.47401655e-01f, -2.83787817e-01f, 4.52467129e-02f, 1.12920910e-01f, -1.94044039e-01f, 2.93952852e-01f, -1.06780477e-01f, -2.73598880e-01f, 8.61543044e-02f, -1.67371184e-01f,
  9.39322412e-02f, 1.65283754e-01f, 1.30335286e-01f, 2.02195585e-01f, -2.81678110e-01f, -2.42602482e-01f, -1.68402463e-01f, -4.21793133e-01f, -4.59186196e-01f, -5.84685504e-01f,
  -1.94215730e-01f, 4.58715707e-01f, -7.23490417e-01f, -5.09413540e-01f, 2.44031951e-01f, -3.43875766e-01f, 2.20253617e-01f, 2.99193352e-01f, -2.08991930e-01f, -4.81011808e-01f,
  2.94377685e-01f, -2.13379875e-01f, -9.26659107e-02f, -5.04060136e-03f, 3.69693339e-01f, 1.56633481e-01f, -2.67397791e-01f, -3.38080853e-01f, -1.46551087e-01f, -9.39920172e-02f,
  1.95966259e-01f, 1.00524433e-01f, -5.89212701e-02f, -1.39193833e-01f, 1.54465869e-01f, 1.62509680e-01f, 9.00519714e-02f, 1.39966011e-02f, 6.59818798e-02f, 1.48512676e-01f,
  1.79017842e-01f, -1.60489511e-02f, 1.56734064e-01f, 8.64433050e-02f, 3.98611963e-01f, 2.39545852e-01f, 5.04422337e-02f, -2.17500255e-02f, -3.06266636e-01f, 3.65550071e-01f,
  -4.38528270e-01f, 3.32938544e-02f, 5.06845815e-03f, -3.13193172e-01f, 1.91201881e-01f, -8.70025307e-02f, -3.40067983e-01f, -3.35247248e-01f, -3.14380586e-01f, 1.59007877e-01f,
  3.55411321e-01f, 4.46090370e-01f, -2.43951544e-01f, 1.23272367e-01f, -3.01386774e-01f, 2.07938150e-01f, -6.25761747e-02f, -2.36148492e-01f, 2.88880736e-01f, -3.78703147e-01f,
  -4.07719910e-01f, -3.23326349e-01f, -3.80939364e-01f, -1.29485875e-01f, -1.43856719e-01f, -3.90511788e-02f, -4.62721348e-01f, -3.54440153e-01f, -4.41528827e-01f, -4.96433973e-01f,
  -1.83496028e-01f, 2.25648340e-02f, 2.63496339e-01f, 3.82621586e-01f, 1.77928939e-01f, -4.90204751e-01f, 2.56478697e-01f, -2.89158374e-01f, -2.02366918e-01f, -2.23817497e-01f,
  -4.14248742e-02f, -2.95630902e-01f, 3.36355954e-01f, -5.19442201e-01f, 3.39865446e-01f, -2.05541030e-01f, -2.09725291e-01f, 1.95248052e-01f, -3.97624187e-02f, 1.45867735e-01f,
  -1.91304788e-01f, 9.01778713e-02f, 3.47068429e-01f, 2.41190106e-01f, -9.79657993e-02f, 1.32384434e-01f, -2.77752638e-01f, 3.69246036e-01f, -1.66468725e-01f, -5.73261864e-02f,
  -3.60828906e-01f, -3.20353448e-01f, 7.54010975e-02f, 4.94442999e-01f, -4.07901227e-01f, 2.36549795e-01f, 3.02660763e-01f, 3.29819739e-01f, -4.70116526e-01f, -2.41771162e-01f,
  2.30358407e-01f, 3.37009698e-01f, -6.95379376e-02f, -1.19711071e-01f, -1.18554965e-01f, 2.62550563e-02f, 3.69790435e-01f, -4.11406726e-01f, -8.49121362e-02f, -3.98739219e-01f,
  -7.32125103e-01f, 1.09890327e-01f, -1.65759891e-01f, -4.54389080e-02f, 3.10969353e-01f, 2.55917847e-01f, -2.04141170e-01f, 1.73381828e-02f, 2.14853853e-01f, -2.46138006e-01f,
  -7.32301176e-01f, -4.30814207e-01f, -1.56111777e-01f, 2.72577018e-01f, -3.50512527e-02f, -9.22908187e-02f, -5.21066666e-01f, -8.36803913e-02f, -1.60579503e-01f, 2.02547148e-01f,
  -3.77628893e-01f, -3.09637725e-01f, -9.33251008e-02f, 3.15032482e-01f, -1.40573323e-01f, 6.30070940e-02f, 2.78612137e-01f, 1.01344958e-01f, -3.87326628e-02f, -9.59170684e-02f,
  -1.22358790e-02f, 9.75448862e-02f, 1.57621101e-01f, -4.19492424e-02f, -6.86076283e-02f, 1.00128472e-01f, 9.69422981e-02f, -3.36153246e-02f, -1.17481887e-01f, 1.22227021e-01f,
  3.57814669e-03f, -2.05257699e-01f, 2.47468963e-01f, 1.04157170e-02f, -3.57247926e-02f, 1.63948283e-01f, -2.68523037e-01f, 2.31327489e-01f, 1.62281394e-01f, -1.13406479e-01f,
  -3.48722875e-01f, 2.86303401e-01f, 3.25604379e-01f, 1.69726491e-01f, -5.82799137e-01f, -4.65246230e-01f, -5.34490347e-02f, 1.14037171e-01f, 2.47331336e-01f, 3.12025875e-01f,
  -1.63859367e-01f, -2.89387912e-01f, -5.08295894e-01f, -3.29223037e-01f, -1.62560329e-01f, -2.74111241e-01f, 3.05457801e-01f, 4.04142812e-02f, -2.23390236e-01f, -4.44413424e-01f,
  -1.19170681e-01f, 4.03177857e-01f, -3.47682893e-01f, -1.91821575e-01f, 3.24862242e-01f, -3.18233520e-01f, 3.64720315e-01f, -6.29880428e-01f, -2.06399202e-01f, 8.02196711e-02f,
  -4.14607137e-01f, -3.98359239e-01f, 2.67575413e-01f, 4.24520254e-01f, -3.06012958e-01f, -3.19989234e-01f, -1.08687863e-01f, 3.85580242e-01f, -3.39622885e-01f, -2.78087109e-01f,
  1.72809467e-01f, -8.07758644e-02f, -1.49904698e-01f, -3.95249456e-01f, -2.44297922e-01f, 1.30110487e-01f, 7.99756944e-02f, 1.15762673e-01f, -1.80238977e-01f, -6.31333292e-02f,
  -1.81952402e-01f, -1.91714481e-01f, -1.25672286e-02f, -1.06111079e-01f, -1.78388447e-01f, -7.05810934e-02f, -1.05591699e-01f, 9.60185677e-02f, -1.98905438e-01f, -2.82077253e-01f,
  2.70886093e-01f, -2.11250111e-01f, -1.40580595e-01f, -1.48723871e-01f, 1.93543002e-01f, 2.92022318e-01f, 4.01617497e-01f, -6.38076439e-02f, -3.33798409e-01f, 3.01118970e-01f,
  -1.88388735e-01f, -1.61445275e-01f, 3.33574474e-01f, -5.28858304e-01f, -3.43758553e-01f, 2.92668253e-01f, -2.93109208e-01f, 2.97746267e-02f, -6.09189309e-02f, 5.26651256e-02f,
  3.67947370e-02f, 2.82622159e-01f, 1.62855849e-01f, -2.24464476e-01f, -4.06831086e-01f, -1.14135511e-01f, 2.05927864e-01f, -2.91176379e-01f, -1.11875214e-01f, -3.52558106e-01f,
  -2.62492746e-01f, 1.81757715e-02f, 1.13045551e-01f, -1.95526481e-01f, -5.21109641e-01f, -4.85369732e-04f, 3.32039475e-01f, -2.31791064e-01f, 1.62110180e-01f, 1.37847513e-01f,
  -2.82614648e-01f, -4.87740755e-01f, 2.78719336e-01f, 1.91204503e-01f, -1.88930899e-01f, -1.45540521e-01f, -2.26764139e-02f, 1.00770138e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.41002709e-01f, 1.24403335e-01f, 6.51615486e-02f, -5.05915321e-02f, -1.16284639e-01f, 1.06151290e-01f, -2.04813071e-02f, -6.07626243e-05f, 8.17947462e-02f, 7.61865601e-02f,
  5.04412465e-02f, 2.47438531e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    