/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.79475203e-01f, 1.41087905e-01f, 3.06097180e-01f, 3.33383344e-02f, -1.68034092e-01f, 6.92503527e-02f, 9.37183648e-02f, 1.10164933e-01f, -1.07751228e-01f, 3.40602808e-02f,
  -1.62152678e-01f, -3.05023998e-01f, -2.65305430e-01f, -2.22419471e-01f, 1.48968883e-02f, 1.49686843e-01f, 6.09012395e-02f, -5.01348749e-02f, -1.23253226e-01f, -1.44288559e-02f,
  -2.04182178e-01f, 4.41398956e-02f, 1.35619447e-01f, -7.13196173e-02f, 2.07261026e-01f, -1.22467369e-01f, 2.19978660e-01f, 2.10663706e-01f, 4.26178277e-02f, 9.23719779e-02f,
  2.89269805e-01f, 1.67302445e-01f, -2.87975334e-02f, -9.54527855e-02f, -5.71602806e-02f, 7.05109015e-02f, -5.78923710e-02f, 1.37985766e-01f, -3.51406001e-02f, 9.04688910e-02f,
  -4.06329446e-02f, -4.81255464e-02f, -1.36440052e-02f, -2.39863098e-02f, 8.72518346e-02f, 1.33225909e-02f, 6.69824407e-02f, 1.23896502e-01f, 1.20980246e-02f, 1.35276139e-01f,
  -1.66660219e-01f, -5.38418256e-02f, 1.02872849e-01f, 1.20672144e-01f, 1.47265986e-01f, -2.73871608e-02f, 1.04331262e-01f, 1.65967390e-01f, 1.11943267e-01f, 3.07585001e-01f,
  7.06905127e-02f, -7.04924986e-02f, -2.94193439e-02f, 3.86325968e-03f, -7.07586408e-02f, -1.06744848e-01f, -2.98982132e-02f, -4.99950498e-02f, -4.06825580e-02f, 4.09757607e-02f,
  -4.09307890e-02f, -1.15410779e-02f, -1.18232109e-01f, -2.40037907e-02f, -7.44327679e-02f, 5.23114130e-02f, -6.48762211e-02f, -1.87549815e-02f, 6.36840332e-03f, -1.94239281e-02f,
  -1.29290044e-01f, 7.89955258e-03f, 8.50992557e-03f, -2.68811993e-02f, -8.60812888e-02f, -5.18309213e-02f, -4.38847095e-02f, -1.17946059e-01f, -4.07174602e-02f, -4.28923443e-02f,
  1.22277260e-01f, -2.36696377e-01f, 3.87084186e-02f, 5.52187040e-02f, 3.64204310e-02f, -1.53129334e-02f, -1.23170644e-01f, 1.62603185e-02f, -1.39109448e-01f, 1.90653671e-02f,
  4.68438538e-03f, -1.42753152e-02f, -1.18289918e-01f, -1.54603934e-02f, 6.04873756e-03f, -3.78300413e-03f, -4.15058993e-02f, -5.99236377e-02f, -5.51874302e-02f, 1.26128584e-01f,
  5.09734005e-02f, 4.06405888e-02f, -3.80006023e-02f, -3.13889682e-02f, 1.11017525e-02f, -8.86091068e-02f, 4.84381244e-02f, 1.31945848e-01f, -1.82723943e-02f, 2.34458327e-01f,
  -4.14956331e-01f, 2.46472672e-01f, 3.24324399e-01f, 5.41243143e-02f, 1.01531476e-01f, 1.35570198e-01f, 1.38289347e-01f, -2.56900620e-02f, -1.27843931e-01f, 1.29761457e-01f,
  -1.57147005e-01f, -2.00842932e-01f, -1.86083704e-01f, -1.26303390e-01f, -1.84715688e-01f, 3.07463735e-01f, 2.49266028e-01f, 2.23457627e-02f, -1.27124414e-01f, -8.56623203e-02f,
  -2.62565538e-02f, -6.69612661e-02f, -1.81460544e-01f, -1.39558405e-01f, 2.20010191e-01f, -1.04940981e-01f, 2.69475251e-01f, 7.46566132e-02f, 1.37517914e-01f, 4.09765840e-01f,
  6.53628334e-02f, -3.31640453e-03f, -1.21917330e-01f, -1.51211604e-01f, 1.02812842e-01f, -6.47024959e-02f, -3.17682475e-02f, 1.35243433e-02f, -4.78213988e-02f, 2.78467517e-02f,
  1.12357398e-03f, 2.87486799e-02f, -5.71179613e-02f, 1.10272951e-01f, -6.06792979e-02f, -2.22552884e-02f, 5.19688195e-03f, -5.03990799e-02f, -1.49879558e-02f, -5.97206131e-03f,
  6.09421581e-02f, 9.47251022e-02f, 6.87461793e-02f, -5.85543141e-02f, -7.80310407e-02f, -7.81801641e-02f, 2.05404032e-03f, 2.95895766e-02f, -1.41851798e-01f, 2.41560191e-02f,
  -7.22222254e-02f, 4.26517799e-02f, -3.66705656e-02f, 2.78335381e-02f, -3.19091640e-02f, 7.23874941e-03f, 6.09014034e-02f, 8.79810378e-03f, 3.46141867e-02f, 6.83843344e-02f,
  -6.98857829e-02f, 3.11202593e-02f, -4.49117720e-02f, -1.89782362e-02f, 3.82780866e-03f, 4.61691953e-02f, 9.60240141e-02f, -6.10886626e-02f, -4.66298275e-02f, -7.44726881e-03f,
  -9.51484591e-03f, -2.36764923e-02f, 5.21664433e-02f, -2.41201278e-02f, 2.31924970e-02f, 6.98908642e-02f, 5.16787954e-02f, 7.85126239e-02f, 1.70838963e-02f, -3.30251530e-02f,
  -1.66981384e-01f, -1.50680274e-01f, -1.07736997e-02f, -8.35142508e-02f, 3.11248600e-02f, 2.08700728e-02f, -2.82591139e-03f, -6.87200949e-02f, 2.56538149e-02f, 1.95319373e-02f,
  -2.79509723e-02f, -2.23277435e-02f, 2.99421642e-02f, 1.89917395e-03f, -1.24061771e-03f, -1.75863262e-02f, 3.23468819e-02f, 5.41636012e-02f, -2.17853803e-02f, 2.38917042e-02f,
  2.22412609e-02f, 3.74303176e-03f, -7.94933885e-02f, -1.49809336e-02f, 2.34907307e-03f, -5.22806719e-02f, 3.45594622e-02f, -1.76005275e-03f, -1.54441491e-01f, -1.11833483e-01f,
  -5.73149145e-01f, -1.60233110e-01f, 1.16748728e-01f, -3.58587354e-01f, -6.99261427e-02f, 2.95852050e-02f, 5.90203740e-02f, 2.67105196e-02f, -4.72817086e-02f, 4.18733880e-02f,
  -6.53395876e-02f, -1.06024452e-01f, 8.33901688e-02f, 1.42810464e-01f, 1.62055999e-01f, 3.38352710e-01f, 3.97675186e-01f, 2.81166136e-01f, 2.46543549e-02f, -3.10827680e-02f,
  7.63160037e-03f, -1.35893345e-01f, -1.25528261e-01f, 2.25965574e-01f, 8.76771882e-02f, 1.44003004e-01f, 2.38263085e-01f, -2.55275751e-03f, 1.83380261e-01f, 3.56245667e-01f,
  -6.77032322e-02f, -9.55670550e-02f, -2.97383033e-02f, -7.73137854e-03f, -9.78594795e-02f, -5.58034144e-02f, -6.51680529e-02f, -1.57849435e-02f, -6.18939288e-02f, 6.15738072e-02f,
  4.24423702e-02f, -4.57401201e-03f, -8.56630318e-03f, 6.26866966e-02f, -6.73785359e-02f, -3.55392359e-02f, 2.96846107e-02f, 2.39733863e-03f, 5.03408052e-02f, -1.05946073e-02f,
  4.17963490e-02f, -2.78917905e-02f, -7.90253803e-02f, 5.97757436e-02f, -4.05561589e-02f, -9.24847461e-03f, 5.13105020e-02f, 1.40918359e-01f, 1.38754785e-01f, 5.03056198e-02f,
  2.43632775e-02f, -1.08765669e-01f, -4.78854999e-02f, -1.28289089e-01f, -1.65737942e-02f, -8.01583827e-02f, 1.17131546e-02f, -5.81451245e-02f, -1.99334361e-02f, -3.88197089e-03f,
  -6.88723251e-02f, 2.08486486e-02f, -1.53437275e-02f, -5.80563731e-02f, 2.79469062e-02f, -4.87353094e-02f, -4.28589955e-02f, 4.64247055e-02f, 1.28141902e-02f, 2.41863895e-02f,
  -1.36661083e-01f, 2.28918139e-02f, -5.50659969e-02f, 8.10047090e-02f, -3.86135764e-02f, 3.51906009e-02f, -1.25354985e-02f, -8.13733488e-02f, -2.17125546e-02f, -7.33259926e-03f,
  -2.47711286e-01f, 3.69836465e-02f, 2.61668153e-02f, 1.01321481e-01f, 2.37277225e-02f, 6.52433783e-02f, 3.41528803e-02f, 2.33592074e-02f, -4.22952808e-02f, 3.71348001e-02f,
  -2.55853496e-02f, -3.77894416e-02f, 4.17361297e-02f, 1.09207056e-01f, -1.27330991e-02f, -2.31042244e-02f, -1.54421516e-02f, 4.76668738e-02f, 6.39137849e-02f, 6.19834438e-02f,
  2.88128667e-02f, 8.52702409e-02f, -4.35086042e-02f, 6.90549910e-02f, -7.37798447e-03f, -6.12411462e-03f, 4.03040387e-02f, 5.53984940e-02f, 4.23590764e-02f, -4.08798344e-02f,
  -5.82923144e-02f, -3.71167392e-01f, -6.65905653e-03f, -1.91257466e-02f, -5.30485734e-02f, 3.69621702e-02f, -1.52080640e-01f, 4.57674935e-02f, 4.17411514e-02f, -2.17459992e-01f,
  -3.10076863e-01f, -1.64521188e-02f, -4.15684171e-02f, -6.02365360e-02f, 1.56885877e-01f, 8.18938017e-02f, 1.00254983e-01f, 1.96605518e-01f, 2.99690038e-01f, 8.89520496e-02f,
  -6.23182841e-02f, -1.10183574e-01f, -7.24852756e-02f, 4.36080433e-02f, -1.97086573e-01f, 5.34735136e-02f, -2.41315201e-01f, -1.98417544e-01f, -7.98700079e-02f, 3.90560995e-03f,
  -1.62761644e-01f, -1.56630516e-01f, 9.59813744e-02f, 6.28627976e-03f, -2.04661205e-01f, -2.62641963e-02f, 2.90830005e-02f, -2.18408164e-02f, -9.07705501e-02f, 1.56340961e-04f,
  -1.73376855e-02f, -8.90874937e-02f, -8.40078592e-02f, -3.29668471e-03f, -8.94595236e-02f, -4.91328239e-02f, -8.25270414e-02f, 2.78840940e-02f, 1.97752323e-02f, -1.80492118e-01f,
  -8.69192109e-02f, -2.33994965e-02f, -3.14273946e-02f, -8.55311286e-03f, -4.19377834e-02f, 3.71622406e-02f, -6.96529076e-02f, -2.73985248e-02f, -6.04232447e-03f, -1.95063055e-02f,
  6.27311841e-02f, 5.88885993e-02f, 2.74745189e-02f, -2.03141896e-03f, 1.79910306e-02f, 3.92783992e-02f, 1.18712753e-01f, 3.68253738e-02f, 6.27777204e-02f, 5.56729781e-03f,
  2.16039061e-03f, 7.69700706e-02f, 1.74000189e-02f, 3.50672640e-02f, -5.79785295e-02f, -1.40448632e-02f, 5.86466603e-02f, -4.35968488e-02f, -6.19715638e-02f, 3.88725847e-02f,
  8.43794346e-02f, 9.21455622e-02f, 3.69439609e-02f, 4.83487174e-02f, 4.76885103e-02f, 2.13671271e-02f, 2.95160804e-02f, -6.66201189e-02f, -1.33077623e-02f, 3.27303112e-02f,
  -2.01027021e-01f, 4.87724543e-02f, -1.04179427e-01f, -1.79942641e-02f, -3.50801237e-02f, -4.55040149e-02f, -2.01804508e-02f, -1.02904849e-02f, -9.64705348e-02f, -3.77123170e-02f,
  -8.61098617e-02f, -2.05494650e-02f, -9.18073952e-02f, -3.21375206e-02f, 2.98672169e-02f, -9.80691239e-02f, -1.77589998e-01f, -2.89019607e-02f, -8.70568380e-02f, -1.29133448e-01f,
  -9.89643261e-02f, 1.18567876e-03f, 4.56589125e-02f, 2.37398650e-02f, 4.05880399e-02f, 8.99715349e-02f, -6.14340082e-02f, -6.58372268e-02f, 1.53854853e-02f, -3.94708887e-02f,
  -6.36025816e-02f, 6.56697974e-02f, -1.02651887e-01f, -1.00849412e-01f, -6.09788038e-02f, 3.17151062e-02f, -1.92025244e-01f, -6.87135160e-02f, 3.80921327e-02f, -6.92133680e-02f,
  3.46892066e-02f, 1.34757638e-01f, 3.40553746e-02f, 3.04613933e-02f, 5.62336016e-03f, -1.97505876e-01f, -1.37043446e-01f, -1.48343205e-01f, -2.77357340e-01f, -1.97890505e-01f,
  -1.02508388e-01f, -2.30321541e-01f, -8.75035152e-02f, 3.07021663e-02f, -2.12393895e-01f, 3.96142304e-02f, 4.88233268e-02f, 3.36948745e-02f, 2.48576775e-02f, -2.16205031e-01f,
  -3.49842042e-01f, -1.02754638e-01f, -8.02143514e-02f, 5.99611588e-02f, 5.63648455e-02f, 8.15134570e-02f, -1.22125754e-02f, 6.75180405e-02f, 1.04414776e-01f, -2.72652712e-02f,
  -1.40133696e-02f, 6.21439181e-02f, 8.77070576e-02f, -5.29274717e-03f, -3.19088101e-02f, -3.13550010e-02f, 3.42777781e-02f, -1.02333963e-01f, 7.00267628e-02f, 3.22584175e-02f,
  -3.33626345e-02f, -5.49614476e-03f, -7.92777017e-02f, -2.39402540e-02f, -7.09066121e-03f, 8.77609849e-02f, -9.82850417e-02f, -9.86679047e-02f, 6.85426891e-02f, -1.48688957e-01f,
  -3.67129897e-03f, 6.12026937e-02f, 6.04420379e-02f, 9.06795934e-02f, 1.77645963e-02f, 7.46094659e-02f, 6.13712780e-02f, -5.38387448e-02f, 1.50035629e-02f, -1.48107279e-02f,
  4.54170071e-02f, 2.04478838e-02f, 5.39319329e-02f, 7.78790265e-02f, -4.85824123e-02f, 1.71048678e-02f, 7.02237859e-02f, 1.22568896e-02f, 4.64163953e-03f, 6.62792567e-03f,
  -6.09140173e-02f, 3.11970934e-02f, -2.83821113e-02f, 4.17428426e-02f, 3.62086594e-02f, -4.34620772e-03f, 5.20231538e-02f, 9.54376608e-02f, 9.26174298e-02f, 2.29592696e-02f,
  -2.41980441e-02f, 2.30320662e-01f, -3.99771146e-02f, -9.96597633e-02f, 5.01165614e-02f, 2.29373295e-02f, -1.67465266e-02f, 5.86764282e-03f, -2.97670122e-02f, -7.38556087e-02f,
  -7.37227350e-02f, -1.00378446e-01f, -1.45562580e-02f, -8.38388503e-02f, -5.37151061e-02f, -1.12048000e-01f, -4.55044359e-02f, -7.81814307e-02f, -5.87487444e-02f, 3.31814215e-02f,
  -9.68388095e-03f, 3.71152312e-02f, -6.97736740e-02f, -3.00045684e-02f, 4.79755998e-02f, -1.16779350e-01f, -7.24281669e-02f, -7.42832944e-02f, -1.65220443e-02f, -1.38885334e-01f,
  -1.21336542e-01f, -2.28808433e-01f, -2.61744082e-01f, -9.06779766e-02f, -1.17913730e-01f, -4.49203290e-02f, -3.43268901e-01f, -1.35028467e-01f, 4.62727435e-02f, -9.41296890e-02f,
  2.91455179e-01f, 3.27590019e-01f, 2.92449266e-01f, 2.78559238e-01f, 1.16662771e-01f, -2.35054895e-01f, -2.49861553e-01f, -6.74782917e-02f, 1.69666529e-01f, 2.74955165e-02f,
  8.50999504e-02f, -4.36854102e-02f, 1.73818439e-01f, 8.10185969e-02f, -1.27419606e-01f, 6.88211322e-02f, -5.82981333e-02f, -3.54114659e-02f, 9.15468410e-02f, -1.89187542e-01f,
  -7.01911340e-04f, -1.31715223e-01f, 2.11859182e-01f, 1.60606474e-01f, 1.21959783e-01f, 4.00494374e-02f, 1.25859439e-01f, 1.41901206e-02f, 1.92726955e-01f, -5.22182621e-02f,
  3.71605493e-02f, 2.22597010e-02f, 5.47833033e-02f, 4.65679951e-02f, -3.42459828e-02f, 4.38559540e-02f, 4.55862051e-03f, -4.07441854e-02f, 7.68824965e-02f, -8.06876048e-02f,
  -7.53384363e-03f, -1.04535557e-01f, -1.24830641e-01f, 1.73613410e-02f, 1.03655092e-01f, 1.74502239e-01f, 6.27620667e-02f, -5.57268299e-02f, 1.39981568e-01f, -1.30092010e-01f,
  6.32088259e-02f, 8.28842726e-03f, 2.57535446e-02f, 5.12794591e-02f, 3.75040658e-02f, 2.78707333e-02f, -3.60488519e-02f, 8.10802169e-03f, -3.29145417e-02f, -6.45723268e-02f,
  7.07516000e-02f, -7.63839111e-02f, 2.66120564e-02f, -4.52041961e-02f, 1.56497881e-02f, -4.51420695e-02f, -4.19959985e-02f, 1.02529060e-02f, 3.78089026e-02f, 3.02700941e-02f,
  7.84453899e-02f, -4.26646993e-02f, 2.45473292e-02f, -5.87911392e-03f, -5.80942305e-03f, -3.07076331e-02f, -4.13716510e-02f, 5.98987639e-02f, -5.81499264e-02f, -8.70144889e-02f,
  1.61070764e-01f, 1.79093614e-01f, 2.67540105e-02f, 3.58898416e-02f, -3.74999084e-02f, 1.11965403e-01f, 2.03198791e-02f, 1.04668602e-01f, 5.28362468e-02f, -2.29265094e-02f,
  2.30731554e-02f, -4.36198153e-02f, -5.37105883e-03f, 7.67345130e-02f, -7.21438602e-02f, -3.21651846e-02f, 1.67965934e-01f, 7.63219669e-02f, -3.38331051e-02f, 2.12191790e-02f,
  1.43062156e-02f, -9.14582163e-02f, 4.17811647e-02f, -3.39866914e-02f, -9.11259092e-03f, 7.35006779e-02f, -8.24133828e-02f, -3.58085074e-02f, -1.91400293e-02f, -1.59478337e-02f,
  2.83009440e-01f, -2.96645522e-01f, -3.72315720e-02f, -1.54637918e-01f, -1.33528545e-01f, -7.52034187e-02f, -4.74876650e-02f, -1.44292489e-02f, 3.88371870e-02f, -2.01944396e-01f,
  -2.97050774e-01f, -1.92942575e-01f, -1.00487351e-01f, -1.13208726e-01f, 1.14916898e-01f, -1.58398405e-01f, -1.71744630e-01f, 4.54680771e-02f, 7.14061856e-02f, -6.77083433e-02f,
  -1.27381861e-01f, -1.61257833e-01f, -3.35197523e-02f, -4.57617221e-03f, -5.23990579e-02f, 1.61120649e-02f, -6.23873360e-02f, -6.84028864e-02f, -1.14095882e-01f, -3.55194598e-01f,
  -2.26796553e-01f, -1.79676022e-02f, -5.26905879e-02f, -1.94871575e-01f, -2.72809058e-01f, -1.18746810e-01f, -1.94393456e-01f, -1.39510080e-01f, -6.70242831e-02f, -2.29680926e-01f,
  -2.65102297e-01f, -1.51298806e-01f, -1.95333794e-01f, -2.00170755e-01f, -1.94346666e-01f, -9.71998796e-02f, -1.57096356e-01f, -1.14112519e-01f, -9.61205214e-02f, -1.77922890e-01f,
  -1.95220158e-01f, -1.93410680e-01f, -1.51842311e-01f, -4.79490645e-02f, 1.31102353e-02f, -1.43512666e-01f, -6.31112531e-02f, -6.52194694e-02f, -1.57698076e-02f, -2.43345991e-01f,
  5.17194681e-02f, 4.24042642e-02f, 7.77586326e-02f, 1.18062280e-01f, 5.74072637e-02f, 9.86666456e-02f, 4.28841747e-02f, 6.20874539e-02f, 6.33601695e-02f, 9.81332064e-02f,
  8.04051682e-02f, 5.66637181e-02f, -5.75667135e-02f, 4.44984660e-02f, 1.38922542e-01f, 7.59324953e-02f, 9.22781304e-02f, -2.84301620e-02f, 7.83653334e-02f, 7.73351714e-02f,
  4.99255322e-02f, 4.48418930e-02f, 2.97368318e-02f, -2.22230610e-03f, 6.58333078e-02f, -4.11436334e-02f, 4.98645753e-02f, 2.55717132e-02f, 9.29927826e-02f, 1.69070326e-02f,
  -1.45768031e-01f, 6.88675940e-02f, -2.22202718e-01f, -1.61114857e-01f, -1.20177157e-01f, -9.82478112e-02f, -1.20918408e-01f, -1.46128282e-01f, -9.95092914e-02f, -9.67584550e-02f,
  -8.08141232e-02f, -3.60346660e-02f, -1.44593269e-01f, -1.58934832e-01f, -9.64924172e-02f, -1.37483150e-01f, -2.10769907e-01f, -1.30738884e-01f, -1.72881171e-01f, -2.14873880e-01f,
  -1.20675310e-01f, -1.19969174e-01f, -1.93083733e-01f, -1.54313996e-01f, -1.32670790e-01f, -6.60861507e-02f, -9.06735137e-02f, -1.63683936e-01f, 3.60330082e-02f, -2.32159749e-01f,
  3.83796066e-01f, 1.85959861e-01f, 2.02006504e-01f, 1.04396179e-01f, -1.71038255e-01f, -1.73970222e-01f, -1.02924757e-01f, -1.00040369e-01f, -1.22992210e-02f, -4.87664482e-03f,
  1.70985952e-01f, 3.29023488e-02f, 1.18727805e-02f, -1.00479044e-01f, -3.48465331e-02f, -1.01278290e-01f, -1.59990862e-01f, -8.50275755e-02f, -2.00847715e-01f, -1.94104448e-01f,
  -9.54037234e-02f, 6.66707456e-02f, 9.20757800e-02f, 2.33859662e-02f, 1.70640767e-01f, -4.53069843e-02f, 2.12460577e-01f, 2.50892043e-01f, 5.47077954e-02f, 2.60216296e-01f,
  1.90677568e-01f, 3.63132268e-01f, -1.48133904e-01f, 2.32113693e-02f, 2.63051260e-02f, 7.07751587e-02f, -5.69019951e-02f, 1.06503598e-01f, -6.69818521e-02f, 8.17267299e-02f,
  6.95844144e-02f, 3.67930233e-02f, 9.38323736e-02f, 6.76508695e-02f, 1.29944593e-01f, -3.92550742e-03f, 1.31065115e-01f, 1.25749946e-01f, 5.24943136e-02f, 1.18811585e-01f,
  2.96243373e-02f, 1.55920058e-01f, -7.17077637e-03f, -1.18739523e-01f, -5.32635897e-02f, -1.39937386e-01f, 4.79101650e-02f, 1.47530735e-01f, 4.31047752e-02f, 1.89379469e-01f,
  -9.94350389e-02f, 1.11742383e-02f, 2.52294820e-03f, -2.74946075e-02f, -1.31284762e-02f, 2.03992575e-02f, -2.25589629e-02f, -1.26933819e-02f, -1.12034880e-01f, 2.99490727e-02f,
  1.47471968e-02f, 1.69478450e-02f, -6.61097560e-03f, 5.56595577e-03f, 7.03510130e-03f, 4.09986936e-02f, -9.70275374e-04f, -6.30953675e-03f, 2.81402990e-02f, -3.01776105e-03f,
  -1.81805678e-02f, -5.78939244e-02f, 9.12350416e-03f, 2.59581022e-02f, 1.05019100e-03f, -8.67025703e-02f, -7.23779574e-02f, -8.58294871e-03f, 4.15780433e-02f, 2.08166731e-03f,
  -1.06205940e-01f, -1.20585412e-01f, 1.00444453e-02f, -4.15138192e-02f, -3.87990922e-02f, 3.91485542e-03f, 5.70338108e-02f, -3.76549885e-02f, 1.88393835e-02f, 9.74974781e-03f,
  -7.19472021e-02f, -5.02971234e-03f, 3.89027856e-02f, -4.01843004e-02f, -8.92027467e-02f, -6.43921718e-02f, -6.57264516e-02f, -6.53814599e-02f, -3.02251671e-02f, 2.25001201e-02f,
  -1.21157967e-01f, -1.31628677e-01f, -1.50289610e-01f, -8.81278142e-02f, -2.92353705e-03f, -2.11669609e-01f, -8.30551535e-02f, -1.79020628e-01f, -1.79165438e-01f, -2.94293791e-01f,
  5.92615940e-02f, 1.06372051e-01f, -2.13517204e-01f, -7.03078555e-03f, 2.06892401e-01f, 1.99282601e-01f, 2.46442556e-01f, 4.94987778e-02f, -7.15643540e-02f, 1.65497154e-01f,
  -3.40943746e-02f, -1.52350381e-01f, -2.44982243e-01f, -2.03555554e-01f, -1.33018941e-01f, 5.82296699e-02f, 1.05607614e-01f, -2.20870882e-01f, -2.08705500e-01f, -5.26735261e-02f,
  5.96643351e-02f, -5.64198978e-02f, -2.17015341e-01f, -1.83774590e-01f, 4.69214804e-02f, 6.88720569e-02f, 3.58905010e-02f, 1.24512896e-01f, 3.28590646e-02f, 9.47563425e-02f,
  -1.51191875e-01f, -7.09699020e-02f, -1.27235442e-01f, -5.77237085e-02f, -2.85384711e-02f, -5.57468981e-02f, -3.84984687e-02f, -3.10435668e-02f, -9.71308872e-02f, -9.34010893e-02f,
  5.59910852e-03f, -1.18206695e-01f, -2.72883358e-03f, -8.68361220e-02f, -5.91213815e-02f, -4.92966585e-02f, -6.92772344e-02f, -1.13593131e-01f, -2.32637405e-01f, -1.01341151e-01f,
  -3.54776271e-02f, -4.89349291e-02f, -7.81256109e-02f, -8.17164853e-02f, -1.64328933e-01f, -1.08265735e-01f, 1.31977526e-02f, 1.50212301e-02f, -1.23856161e-02f, 1.62008062e-01f,
  1.52097300e-01f, -2.81778183e-02f, -5.59015479e-03f, 7.16809183e-02f, 2.29905080e-02f, 4.53798994e-02f, -2.64541097e-02f, 9.34613645e-02f, -1.23311300e-02f, 6.29432797e-02f,
  -4.23126072e-02f, 6.17687255e-02f, -3.47959762e-03f, 1.04583845e-01f, -3.75546166e-03f, -3.09777446e-02f, 1.00841351e-01f, -5.94739895e-03f, -4.33603227e-02f, 7.29115456e-02f,
  8.13153684e-02f, -2.66822912e-02f, 3.44638713e-02f, -3.06726694e-02f, 7.66762346e-02f, -2.89662238e-02f, 2.06169710e-02f, -2.74506211e-02f, 6.67954013e-02f, 8.36917460e-02f,
  1.47696752e-02f, -1.65243000e-01f, 8.69381055e-02f, -1.77516807e-02f, -1.17771104e-02f, -1.12330534e-01f, -1.26913495e-04f, -8.68983194e-02f, -6.94286823e-02f, -7.76475519e-02f,
  -7.02574998e-02f, -1.07958786e-01f, -5.82623184e-02f, -6.77025169e-02f, -4.44535986e-02f, 3.70379016e-02f, -4.01995555e-02f, -9.57881138e-02f, -4.71720062e-02f, 1.87776964e-02f,
  -5.71766011e-02f, 6.66567162e-02f, -6.48427242e-03f, 6.88369498e-02f, -2.82899551e-02f, 9.31406841e-02f, -7.03184083e-02f, 3.18950117e-02f, 6.58141971e-02f, 2.47765750e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.00203258e-01f, -5.25253750e-02f, -9.20428216e-01f, 2.44905159e-01f, -5.40238619e-01f, -5.65776885e-01f, -2.68160194e-01f, 1.68028533e-01f, 3.90660822e-01f, 2.58226115e-02f,
  -2.18852878e-01f, -9.22495276e-02f, -1.05638944e-01f, -1.91408470e-01f, -2.79447496e-01f, -2.68200248e-01f, -4.16319340e-01f, -5.39648294e-01f, -5.65874517e-01f, -1.63508907e-01f,
  -7.96162151e-03f, 1.03790708e-01f, 5.60217816e-03f, -7.43413270e-02f, 1.17919572e-01f, 4.09722216e-02f, -1.78643659e-01f, -1.59299970e-01f, -2.63453335e-01f, -1.35096997e-01f,
  -3.86094034e-01f, -3.52900118e-01f, -5.15036285e-02f, 7.86352232e-02f, -1.67743415e-01f, 1.13101723e-02f, -6.21746108e-02f, -1.27532199e-01f, 7.64523819e-02f, -9.88426283e-02f,
  -7.95963854e-02f, 2.23360563e-04f, -2.48585522e-01f, -1.18788779e-01f, -3.41576263e-02f, -8.52795504e-03f, 2.75153592e-02f, -9.83864367e-02f, 5.10599092e-03f, -1.74593300e-01f,
  8.57056025e-03f, -3.07389677e-01f, -3.49748552e-01f, -5.32288887e-02f, -2.37036690e-01f, -1.09147526e-01f, -4.40432206e-02f, -1.19933590e-01f, -2.09656313e-01f, 3.38061750e-01f,
  1.55593473e-02f, -2.71966383e-02f, -4.46707904e-02f, -5.16714230e-02f, 1.64183900e-01f, -7.13844076e-02f, 3.23064104e-02f, 1.17944762e-01f, 1.32570714e-01f, -7.86862746e-02f,
  -3.15805897e-02f, -2.46069096e-02f, -3.66451740e-02f, 1.76531877e-02f, -1.10399731e-01f, -3.27545926e-02f, -7.47145340e-03f, 7.34212771e-02f, -1.13034979e-01f, -2.11848635e-02f,
  -4.54855375e-02f, -1.33246174e-02f, -1.21065294e-02f, 1.12517312e-01f, -9.01177898e-02f, -7.11880028e-02f, -4.25490662e-02f, 7.06028417e-02f, 7.22957253e-02f, -1.99932344e-02f,
  2.30156124e-01f, -2.26157963e-01f, 1.74075097e-01f, 9.94909331e-02f, -1.48601502e-01f, 2.64601372e-02f, 4.62089293e-02f, -2.04639211e-02f, -5.68317957e-02f, 3.60268056e-02f,
  -1.46135107e-01f, -2.05189958e-02f, -1.30691469e-01f, 1.18654221e-01f, 3.78335873e-03f, 1.69761435e-04f, 1.48624316e-01f, -2.43016332e-02f, -9.29610655e-02f, 2.09464803e-01f,
  2.58076072e-01f, 1.26297340e-01f, 8.22056383e-02f, 1.70531601e-01f, 6.96493909e-02f, -1.14331111e-01f, 7.41334818e-03f, 1.33260638e-01f, -9.69390646e-02f, 5.05765438e-01f,
  -9.91427660e-01f, 2.88087755e-01f, 2.55564898e-01f, -7.55873382e-01f, -2.49433860e-01f, 4.36285399e-02f, 2.92643189e-01f, -1.26971349e-01f, -2.62435764e-01f, 3.04708898e-01f,
  2.51024514e-01f, -5.46492683e-03f, 6.76155612e-02f, 7.67989755e-02f, -2.06403553e-01f, 2.27526262e-01f, -1.16583258e-01f, -4.26030904e-01f, -5.06563485e-01f, -2.61250138e-01f,
  -1.66808158e-01f, -4.89639461e-01f, -6.38032615e-01f, -3.22255194e-01f, 5.45412451e-02f, -1.53241679e-01f, 1.58193305e-01f, -2.52784967e-01f, 3.37630995e-02f, 5.07294163e-02f,
  4.48701888e-01f, -2.51892596e-01f, -7.40858540e-02f, -2.26709530e-01f, 7.48393014e-02f, -8.09333473e-02f, 1.82826852e-03f, -5.47151268e-02f, 1.74602289e-02f, 2.91923676e-02f,
  -1.86773449e-01f, -3.24878516e-03f, -1.83551297e-01f, 2.62814295e-02f, -1.12974152e-01f, 4.51914594e-02f, 7.87785947e-02f, -1.51675627e-01f, 6.14589080e-02f, 3.21161121e-01f,
  1.72862917e-01f, -5.96635267e-02f, -1.16305538e-01f, 1.78642944e-01f, 1.23819329e-01f, -1.52552515e-01f, 8.37010518e-02f, -8.94658044e-02f, -7.96017721e-02f, 8.15509185e-02f,
  -3.83699127e-02f, 2.44095296e-01f, 2.54079159e-02f, -1.04921721e-01f, -7.99879655e-02f, 5.29941283e-02f, -6.92872033e-02f, -3.45721394e-02f, 9.44592117e-04f, 3.39842141e-02f,
  8.17020461e-02f, 2.87021347e-03f, 6.16028998e-03f, -7.82920346e-02f, 4.14765179e-02f, -1.17589213e-01f, -1.14455730e-01f, 8.60750973e-02f, 3.65239158e-02f, -8.75434354e-02f,
  -1.48499534e-01f, -1.33583061e-02f, -3.84774245e-03f, -9.46711078e-02f, 2.39015110e-02f, -8.30409452e-02f, 4.71863896e-02f, -4.52954285e-02f, 1.38215953e-02f, 1.61198266e-02f,
  -5.87173626e-02f, -1.17057033e-01f, 5.93198091e-03f, -1.18196435e-01f, 2.52125375e-02f, 9.42278579e-02f, -1.58918940e-03f, -5.80131523e-02f, -9.42379758e-02f, -8.94224420e-02f,
  1.33879832e-04f, 2.89952513e-02f, 5.37804179e-02f, 1.73583627e-01f, -1.08768634e-01f, -9.66226682e-04f, -7.17855692e-02f, -5.23967892e-02f, -1.55832171e-01f, 1.02273531e-01f,
  9.97369662e-02f, -3.32014002e-02f, -9.65094939e-02f, 8.98440555e-03f, 3.37379873e-02f, -1.23618603e-01f, 1.26734719e-01f, 1.05312325e-01f, -6.30364195e-02f, 1.49078697e-01f,
  7.82464743e-02f, 6.07972980e-01f, -1.27840534e-01f, -7.16198236e-02f, 2.63354480e-01f, 3.44425380e-01f, 7.78918386e-01f, 3.29975843e-01f, 8.43051523e-02f, 1.99253231e-01f,
  4.46527191e-02f, -3.89877409e-01f, -3.15796912e-01f, -2.04221994e-01f, -7.65128341e-03f, 2.07448080e-01f, 5.40578291e-02f, -3.86402279e-01f, -4.05955881e-01f, -8.85726884e-02f,
  7.56440908e-02f, -1.68751869e-02f, -7.08787590e-02f, 8.73168483e-02f, 1.41965121e-01f, -9.92574245e-02f, 1.48617432e-01f, 2.34309196e-01f, 1.74364984e-01f, -1.72248721e-01f,
  -6.56373739e-01f, 3.23677748e-01f, -3.59587044e-01f, -3.13385134e-03f, -3.42405029e-02f, -2.80655831e-01f, -6.51658177e-02f, -8.14920738e-02f, -4.86210585e-02f, -1.32482335e-01f,
  5.04853837e-02f, -5.12463748e-02f, -4.01754584e-03f, 7.95193166e-02f, 4.52718288e-02f, -1.01893976e-01f, 1.64548263e-01f, -6.01909570e-02f, -2.30164185e-01f, -4.95341085e-02f,
  -5.52236028e-02f, 1.16531976e-01f, 1.63366020e-01f, 1.65731102e-01f, -3.01002245e-02f, -4.19602953e-02f, 1.44255593e-01f, -3.03658508e-02f, -2.61199690e-04f, -1.04865702e-02f,
  -1.02389172e-01f, 4.36505675e-02f, 5.49187809e-02f, 1.40554577e-01f, 4.28727333e-04f, 5.84278069e-03f, -6.33910820e-02f, 7.35202208e-02f, -5.18072061e-02f, 2.58059744e-02f,
  -1.12714276e-01f, -3.31087299e-02f, -1.25730112e-01f, 5.78036485e-03f, -2.02474385e-01f, -4.59150178e-03f, -4.74987701e-02f, -7.71427304e-02f, -3.47882733e-02f, 6.02293275e-02f,
  1.03961527e-01f, -1.17087692e-01f, 3.89065221e-02f, -5.98672591e-02f, 6.66838558e-03f, -1.34500116e-01f, -2.09521782e-02f, -4.14738841e-02f, -2.53600609e-02f, 8.62998050e-03f,
  -1.93871573e-01f, 5.62421866e-02f, -2.91351110e-01f, -1.21960610e-01f, 1.13657467e-01f, -5.93923405e-02f, -1.31704226e-01f, -1.15346804e-01f, 1.42775476e-01f, -2.07031399e-01f,
  1.45771578e-01f, -2.28851661e-01f, -1.86117455e-01f, 3.81323695e-02f, -1.10347986e-01f, 4.09391476e-04f, 6.15641586e-02f, -1.61914080e-01f, 6.99932277e-02f, -6.47477284e-02f,
  6.45364895e-02f, 5.05810902e-02f, -3.52548212e-02f, 1.42138572e-02f, -1.00705802e-01f, -2.23404080e-01f, -6.22721873e-02f, -1.30617931e-01f, -2.24044435e-02f, 4.88868877e-02f,
  -3.54975700e-01f, -8.93305615e-02f, -1.15897544e-01f, 4.67836201e-01f, 4.52604443e-01f, 3.72671723e-01f, 2.23342970e-01f, 2.16427833e-01f, 2.32694492e-01f, 1.54514328e-01f,
  9.75248441e-02f, 4.08457816e-01f, 3.37858766e-01f, 2.74390340e-01f, 6.34772480e-02f, 2.35767946e-01f, 1.84198305e-01f, -3.42175514e-02f, 2.10290849e-02f, 2.39032120e-01f,
  2.29236707e-01f, 1.65976226e-01f, -2.16480017e-01f, 1.24266021e-01f, 1.60154939e-01f, 3.10584813e-01f, 7.83316866e-02f, 1.80764906e-02f, 1.31842732e-01f, 1.11720271e-01f,
  4.20588553e-02f, -3.07360142e-01f, 2.35982075e-01f, -1.61401201e-02f, -1.64427325e-01f, -2.35906005e-01f, -1.01215854e-01f, -1.63424507e-01f, -2.06422992e-02f, 3.66562903e-02f,
  -9.88023952e-02f, -1.07509933e-01f, -6.22354448e-02f, -4.37625572e-02f, -7.06569627e-02f, -2.23719999e-01f, -1.88048407e-01f, -4.70688529e-02f, 1.12231821e-01f, 1.17513845e-02f,
  5.38117923e-02f, 4.43117172e-02f, 1.48889003e-02f, 2.50427611e-02f, 5.80297820e-02f, 7.34114051e-02f, -9.66060013e-02f, -3.58196236e-02f, -1.21500142e-01f, -7.61063844e-02f,
  2.42014468e-01f, 2.25616898e-02f, -5.17363213e-02f, -3.00860554e-02f, 1.24494359e-01f, 5.20647457e-03f, 7.84533471e-02f, 2.68563610e-02f, 5.42012528e-02f, -1.56754896e-01f,
  -2.58325376e-02f, 3.79167534e-02f, -1.92537159e-02f, 2.35070977e-02f, 2.01111343e-02f, -2.68773381e-02f, -1.28404483e-01f, -5.27134500e-02f, -1.21149622e-01f, -1.46827206e-01f,
  -4.20940258e-02f, -1.58147678e-01f, -1.33309200e-01f, -1.37722611e-01f, 2.11424418e-02f, -1.68650094e-02f, 3.58347781e-02f, -7.51785859e-02f, 1.02853933e-02f, 3.33506837e-02f,
  4.26952243e-01f, -2.40214132e-02f, -3.65259126e-03f, -6.39789030e-02f, -7.80816153e-02f, -1.77024007e-01f, 5.34490310e-02f, 2.90800701e-03f, 3.30127105e-02f, 1.52370274e-01f,
  -1.33247823e-01f, -2.47753233e-01f, -1.16271198e-01f, -1.65214479e-01f, -1.76598117e-01f, -1.07825967e-02f, -9.16411504e-02f, 1.63895097e-02f, 5.53383399e-03f, -1.18565664e-01f,
  -1.40680537e-01f, 1.16840221e-01f, 2.11477265e-01f, 8.08207616e-02f, 7.37420321e-02f, 2.26569623e-01f, 1.32172629e-01f, 5.89342900e-02f, 3.31831537e-02f, 1.48509234e-01f,
  -6.57345295e-01f, 6.67295605e-02f, 5.28153032e-04f, -1.30872875e-01f, -1.65102944e-01f, -5.10988571e-02f, 1.30192742e-01f, 1.49814367e-01f, -4.64378446e-02f, -1.49712965e-01f,
  -3.17958057e-01f, -7.60762170e-02f, 1.17233861e-02f, 4.79430258e-02f, 1.72313616e-01f, 2.91557550e-01f, 3.82720649e-01f, 8.72588009e-02f, -2.50406154e-02f, 2.73683970e-03f,
  1.43170103e-01f, -1.32769480e-01f, -1.21687122e-01f, 1.26329228e-01f, 1.07669331e-01f, 3.91407870e-03f, 7.35547021e-02f, -1.81744307e-01f, 1.40642628e-01f, 6.08191311e-01f,
  -3.20121795e-01f, -2.14672275e-02f, 3.22974324e-02f, -2.13269755e-01f, -2.10662425e-01f, 7.04212114e-02f, -1.19106084e-01f, -1.35423495e-02f, -1.59643916e-03f, 2.13081799e-02f,
  -1.74427047e-01f, -4.20758575e-02f, 4.36893962e-02f, 1.85788944e-02f, -4.97460067e-02f, -7.17569934e-03f, 1.63873151e-01f, 6.41020387e-02f, 5.22202663e-02f, -1.26552896e-03f,
  1.15868926e-01f, -4.45421398e-01f, -3.90505075e-01f, 3.37190926e-02f, 5.85365929e-02f, -2.42108449e-01f, -1.76200956e-01f, -1.29196197e-02f, -1.53825983e-01f, 5.86522967e-02f,
  -3.50993387e-02f, -1.31235451e-01f, -5.33309057e-02f, 1.43733807e-02f, -4.31140848e-02f, 4.99134324e-02f, 1.16528094e-01f, 1.99483171e-01f, -5.38534895e-02f, -4.49576192e-02f,
  -5.05124964e-02f, 3.94674623e-03f, 3.62646766e-03f, -3.20061692e-03f, -2.18407866e-02f, -9.11008418e-02f, 1.64258882e-01f, 4.07323875e-02f, -7.32200220e-02f, -7.34959692e-02f,
  -1.91327199e-01f, 2.09154245e-02f, -1.06546082e-01f, 2.96537042e-01f, -2.54232176e-02f, 6.83071464e-02f, -1.39034912e-01f, -1.14476845e-01f, -1.62290782e-01f, -1.13823168e-01f,
  -1.99872226e-01f, -7.49794766e-03f, -8.82323608e-02f, 7.77653605e-02f, -8.89802203e-02f, -9.75117385e-02f, -7.77238905e-02f, -1.53364033e-01f, -4.57992405e-02f, -6.66265562e-02f,
  -6.04494810e-02f, 5.81724308e-02f, -1.13522179e-01f, 1.39064178e-01f, 2.68989950e-02f, -1.21609755e-02f, -4.16620187e-02f, 5.41248471e-02f, 7.02519016e-03f, -5.95346130e-02f,
  3.94691303e-02f, -8.47249255e-02f, -3.83645296e-01f, 3.96641158e-02f, -1.95496276e-01f, -4.50051606e-01f, -2.42315233e-01f, -2.25995407e-01f, -4.31529403e-01f, -2.38430902e-01f,
  4.75057513e-01f, 2.54875481e-01f, 1.08542368e-01f, 3.80888551e-01f, 2.95736104e-01f, 2.31293812e-01f, 4.74487960e-01f, 2.89822280e-01f, 2.35605210e-01f, 1.51004300e-01f,
  7.38630667e-02f, 7.75351673e-02f, 1.19008973e-01f, 9.10830647e-02f, 2.06666499e-01f, 2.18043953e-01f, 6.71914816e-02f, 1.27669483e-01f, 1.09965533e-01f, 2.32189223e-01f,
  5.45371473e-02f, 2.90020704e-02f, 4.35041301e-02f, 1.08148912e-02f, 7.59773850e-02f, -1.62138920e-02f, -2.95011513e-03f, 7.73654282e-02f, 6.09018207e-02f, 1.03917196e-02f,
  -2.35556602e-01f, 1.90750405e-01f, -7.52516612e-02f, -8.86775702e-02f, -1.20748512e-01f, -1.57995105e-01f, -2.04147212e-02f, -6.40951917e-02f, -1.25903651e-01f, -1.81876987e-01f,
  -1.23838879e-01f, 5.54873794e-02f, 9.00213048e-02f, -2.74311602e-02f, 2.11676117e-03f, -8.67085382e-02f, -5.20302430e-02f, 1.11895300e-01f, 9.04395357e-02f, -9.77534726e-02f,
  3.62098999e-02f, 1.61800012e-02f, 1.03654690e-01f, 6.26564547e-02f, -9.57558956e-03f, 2.58423220e-02f, -1.42342383e-02f, -4.80285399e-02f, 1.96116380e-02f, 1.04176447e-01f,
  2.82427669e-01f, 1.69942662e-01f, 1.36822850e-01f, 7.56417960e-02f, 2.31688526e-02f, -3.37867588e-02f, 2.31347885e-02f, 8.64666328e-02f, 1.04871199e-01f, 9.90309417e-02f,
  -7.48916715e-02f, 1.19252205e-01f, 1.33013070e-01f, 3.45879346e-02f, 9.36064497e-02f, 2.14391965e-02f, -1.23133585e-01f, -3.53231356e-02f, 1.96008012e-02f, -3.84547487e-02f,
  1.38388691e-03f, 5.08914553e-02f, 1.65798347e-02f, 2.54385397e-02f, -3.79487798e-02f, 5.21329157e-02f, -2.39287335e-02f, 2.33255420e-02f, -4.64631274e-04f, 7.51976594e-02f,
  -3.48435044e-01f, 2.29809716e-01f, -5.54308891e-02f, 7.89469928e-02f, 6.43118396e-02f, -7.83885121e-02f, 4.72814143e-02f, -1.89957619e-01f, -2.22740516e-01f, -1.23923838e-01f,
  -1.34456297e-02f, 2.68889982e-02f, 1.19605377e-01f, -6.84397575e-03f, -7.86809474e-02f, -1.65747195e-01f, 1.59184877e-02f, 8.66654590e-02f, 2.70815683e-03f, -1.46266907e-01f,
  1.89815834e-02f, -4.51765838e-04f, -9.82533619e-02f, -4.99112271e-02f, 3.63893062e-02f, 2.04776376e-02f, -3.14580016e-02f, -6.19124547e-02f, 7.06237601e-03f, 9.53560844e-02f,
  -4.82434690e-01f, 3.18440378e-01f, 2.32738152e-01f, -1.46266654e-01f, 6.12856336e-02f, -1.17148250e-01f, 3.26713398e-02f, -2.29870483e-01f, -8.40462819e-02f, 2.90448457e-01f,
  1.89999744e-01f, -2.15751037e-01f, -9.91748944e-02f, -1.43450648e-01f, -5.85319936e-01f, -1.43379569e-01f, -2.14740202e-01f, -5.28215826e-01f, -7.01106608e-01f, -4.79728371e-01f,
  -9.93868709e-02f, -3.37993622e-01f, -5.10785103e-01f, -2.11145833e-01f, 4.30976272e-01f, 1.28979817e-01f, 2.51783967e-01f, -6.92359209e-02f, 2.21607998e-01f, 4.18538481e-01f,
  1.11393765e-01f, 1.49547771e-01f, 1.38714641e-01f, 2.30311193e-02f, 1.46330416e-01f, -6.07695542e-02f, 5.43799177e-02f, 3.92470248e-02f, -6.10886700e-02f, -8.45739432e-03f,
  -4.97694425e-02f, 4.11313400e-02f, -2.06686527e-01f, -4.81824316e-02f, -1.72077104e-01f, -1.49821043e-01f, -7.51164034e-02f, -2.53859371e-01f, -7.13049471e-02f, 1.04886100e-01f,
  -7.78726786e-02f, -3.58519033e-02f, -1.15146942e-01f, 1.23148121e-01f, -6.54582605e-02f, -3.89448851e-02f, 1.79531723e-01f, 1.82786733e-01f, 2.98606064e-02f, 3.67351115e-01f,
  6.23530261e-02f, -2.40388382e-02f, -2.10942961e-02f, 4.14305273e-03f, 4.68368866e-02f, -5.86802624e-02f, 2.20382195e-02f, 3.93012129e-02f, -8.41724351e-02f, -1.17719643e-01f,
  -1.11345416e-02f, 3.39207463e-02f, -3.58810611e-02f, 6.13384359e-02f, 1.58057228e-01f, 4.17461358e-02f, 1.02996029e-01f, 7.68565983e-02f, 1.02662452e-01f, -3.84728201e-02f,
  3.69379930e-02f, -8.91230181e-02f, 4.17168997e-02f, 4.58670743e-02f, 5.86058795e-02f, 1.19437873e-01f, 1.08732760e-01f, 1.03045955e-01f, 8.07486195e-03f, -4.36310694e-02f,
  1.30113468e-01f, -1.70100331e-01f, 1.28470629e-01f, -8.39508250e-02f, 4.98595312e-02f, 8.71731639e-02f, 1.75336555e-01f, 1.55517161e-01f, 1.85883477e-01f, 4.23461990e-03f,
  1.93776209e-02f, 5.78553788e-02f, 1.19878396e-01f, -5.53057864e-02f, -1.87341332e-01f, -8.85388535e-03f, -4.17160578e-02f, 3.65616344e-02f, -6.92858547e-02f, 1.65256664e-01f,
  -1.50421485e-02f, -6.90530520e-03f, -1.43101797e-01f, 2.74016242e-02f, 4.83909324e-02f, -1.69843122e-01f, 1.16731480e-01f, 2.16670707e-01f, 2.26067659e-02f, 3.77945602e-01f,
  3.60485427e-02f, 4.78843190e-02f, 6.40102476e-02f, 5.60838208e-02f, -1.10174507e-01f, -3.56441140e-01f, -5.43660283e-01f, -3.67116630e-01f, 1.82962639e-03f, -1.30164735e-02f,
  -1.28577173e-01f, 4.99477163e-02f, 1.04729630e-01f, 9.80517268e-02f, -2.01507639e-02f, 6.15407191e-02f, 2.74073750e-01f, 2.62496024e-01f, -1.10327816e-02f, -1.81686789e-01f,
  4.25749533e-02f, 6.85695484e-02f, 7.84591660e-02f, -3.79360206e-02f, 1.33458704e-01f, -5.26317134e-02f, -2.33875513e-02f, 1.24848336e-01f, -1.23573346e-02f, 6.95655882e-01f,
  1.96491048e-01f, 8.16945583e-02f, -1.86281323e-01f, 1.73588470e-01f, 8.40468854e-02f, 2.85017025e-02f, 3.75132188e-02f, 2.27494389e-01f, 3.39130238e-02f, 4.60921787e-02f,
  2.07980543e-01f, 7.31744990e-02f, -7.01437891e-02f, -3.57197039e-02f, -7.96974599e-02f, -2.02622414e-02f, 5.75295947e-02f, -6.98704422e-02f, -1.73894510e-01f, -8.43249727e-03f,
  1.32158488e-01f, -6.14579692e-02f, -1.39993921e-01f, -1.92555338e-01f, -1.09296285e-01f, 1.04401127e-01f, -2.33929306e-01f, -3.01657710e-02f, -1.81377083e-01f, 1.61525369e-01f,
  8.04530364e-03f, -6.57317182e-03f, 8.93503502e-02f, 4.24522758e-02f, -1.98724084e-02f, 8.50416347e-02f, 6.14647828e-02f, -2.85578100e-03f, 3.52234021e-02f, 1.65233202e-02f,
  3.68070379e-02f, -2.83774734e-02f, 3.00004482e-02f, -7.30216131e-02f, -5.52235581e-02f, 1.24875560e-01f, -1.89868566e-02f, -2.67256424e-02f, 3.21848951e-02f, 1.54495090e-01f,
  2.48040706e-02f, 8.09113383e-02f, 5.16497865e-02f, 9.33279842e-02f, 6.81136027e-02f, 3.92135382e-02f, 6.99651539e-02f, -1.99402757e-02f, 4.68000881e-02f, 9.03194100e-02f,
  -3.97330970e-01f, -7.16687590e-02f, 1.77033782e-01f, 1.68155760e-01f, 1.35096252e-01f, 3.54140103e-02f, 4.17887270e-02f, 2.28961254e-03f, -6.61477121e-03f, -4.77903038e-02f,
  -2.54346728e-01f, -9.10253152e-02f, -3.48734809e-03f, -5.63576706e-02f, -2.24623948e-01f, 9.42177977e-03f, 1.50598109e-01f, 4.86940667e-02f, 2.55603977e-02f, 2.30650455e-02f,
  -2.77595613e-02f, -3.59964013e-01f, -3.98884982e-01f, -2.07866296e-01f, -1.68130562e-01f, -1.26665890e-01f, -1.14276953e-01f, -2.15605766e-01f, -4.05588955e-01f, -4.96922553e-01f,
  -7.81873882e-01f, -2.34736562e-01f, -8.85366574e-02f, -2.68684208e-01f, -9.48382169e-02f, 1.21249706e-01f, -2.81455010e-01f, 1.59818798e-01f, 1.22529157e-01f, -1.98735893e-01f,
  6.92861304e-02f, -3.11961118e-02f, -1.96899667e-01f, -3.28146829e-03f, -1.18152469e-01f, -4.36884791e-01f, -2.68271804e-01f, -1.70584917e-01f, 2.02453524e-01f, 3.47179055e-01f,
  5.44753158e-03f, -9.32509229e-02f, 9.48540941e-02f, 1.14725739e-01f, -3.10622709e-04f, 4.74103950e-02f, -1.45911634e-01f, -1.40547141e-01f, 1.28169274e-02f, -3.94655287e-01f,
  -3.00488621e-01f, -1.03504375e-01f, 1.00295827e-01f, -6.30510896e-02f, 9.63895693e-02f, 1.72584374e-02f, -1.21802427e-02f, 4.47019339e-02f, 2.50406060e-02f, -1.46765513e-02f,
  -3.26061361e-02f, 9.72550511e-02f, -2.16509029e-02f, 3.12191322e-02f, 3.58298458e-02f, 3.65127251e-02f, 3.82627212e-02f, 1.38104022e-01f, -1.24527654e-02f, -2.06944486e-03f,
  -4.16111527e-03f, -4.66063851e-03f, -1.29717231e-01f, 6.35141060e-02f, 9.30290446e-02f, -3.35448310e-02f, 1.41463220e-01f, 2.62486428e-01f, 2.48818636e-01f, -3.00425947e-01f,
  9.90812629e-02f, -7.35892504e-02f, 1.10911531e-03f, 7.82460868e-02f, -9.73222181e-02f, -9.52685773e-02f, -1.20556228e-01f, -1.05572172e-01f, 7.66246021e-02f, -1.35545790e-01f,
  6.01995699e-02f, 4.45215739e-02f, -1.64420325e-02f, -3.36898863e-02f, 5.13485726e-03f, -7.84529075e-02f, -4.23992835e-02f, 1.98010728e-02f, -2.57189367e-02f, 1.13787400e-02f,
  4.39391732e-02f, -1.02190319e-02f, -7.58947656e-02f, 3.44353132e-02f, 4.93098460e-02f, 2.40759216e-02f, -1.54805172e-03f, 1.19981617e-01f, 2.20101662e-02f, -8.60492662e-02f,
  -1.50512263e-01f, 7.66736194e-02f, -2.32229277e-01f, 2.70080771e-02f, -9.33825970e-02f, 1.78430881e-02f, -7.28131235e-02f, 1.08630173e-01f, -1.25068709e-01f, -6.68692067e-02f,
  1.46718249e-01f, -1.45605609e-01f, -2.29439870e-01f, 1.82742663e-02f, -5.03024422e-02f, -4.62456495e-02f, -9.21419188e-02f, -1.25818431e-01f, 7.91693255e-02f, 7.07091391e-02f,
  -4.12088223e-02f, -5.49808927e-02f, -1.77209646e-01f, -2.73667216e-01f, -7.28324428e-02f, -2.08691403e-01f, -2.41977632e-01f, -2.28067972e-02f, -1.81113645e-01f, -3.19369376e-01f,
  8.31435621e-01f, 6.67725384e-01f, 4.75381762e-01f, 1.83172360e-01f, -1.06701910e-01f, 4.24486995e-02f, 2.19397366e-01f, 7.23774210e-02f, -1.37254357e-01f, 2.26223439e-01f,
  2.36099333e-01f, 1.12466505e-02f, -2.02253424e-02f, 6.55219927e-02f, 2.34015778e-01f, -1.21982537e-01f, -2.62592047e-01f, 1.47861734e-01f, 8.49956200e-02f, 3.04434244e-02f,
  -5.29328175e-02f, 2.43326332e-02f, 2.26692900e-01f, 1.03110358e-01f, -4.58482839e-02f, -4.84033711e-02f, 1.21552952e-01f, 6.92006871e-02f, 8.45827162e-02f, 1.82080045e-01f,
  4.65421617e-01f, 5.23917794e-01f, -2.11456850e-01f, 2.05471963e-02f, 1.75624505e-01f, 2.14144811e-02f, 3.58645730e-02f, 3.96101065e-02f, 5.48855253e-02f, 5.02670743e-02f,
  7.98791200e-02f, 1.31592378e-01f, -3.22812460e-02f, 5.05699217e-02f, 1.27084740e-02f, 1.11357793e-01f, 1.15816653e-01f, 1.68780625e-01f, 1.57818273e-01f, 1.12380311e-01f,
  1.46767655e-02f, 8.79189149e-02f, 1.14886388e-01f, -1.36378527e-01f, -5.21720620e-03f, -1.18664943e-01f, 5.61001897e-02f, 1.95978489e-02f, -4.21600193e-02f, 9.00466368e-02f,
  -1.08615384e-01f, -1.44438714e-01f, 4.37572077e-02f, -7.04464465e-02f, -2.64008380e-02f, -6.78415820e-02f, -2.82510538e-02f, -6.31527975e-02f, -1.21590476e-02f, -1.35277212e-01f,
  -9.50648114e-02f, 1.58707127e-01f, 3.67467888e-02f, 9.98807326e-02f, 6.06157742e-02f, 5.03628217e-02f, 3.64531353e-02f, 8.29678699e-02f, 6.34922273e-03f, -2.74015814e-02f,
  4.69078533e-02f, 1.13321177e-03f, 1.91807956e-03f, 4.07371260e-02f, 7.90951177e-02f, 1.15266994e-01f, 1.14507958e-01f, 6.64941892e-02f, -7.52902403e-02f, -1.02210008e-01f,
  -1.80866376e-01f, 1.01386428e-01f, -1.44388735e-01f, -9.33578834e-02f, 1.60121709e-01f, 2.60176696e-02f, 1.06018461e-01f, -5.07584177e-02f, -1.28699429e-02f, -4.33836430e-02f,
  1.98333308e-01f, -3.34733631e-03f, -2.56976150e-02f, -5.37297316e-02f, -1.04798742e-01f, -3.83357666e-02f, -7.15330392e-02f, 1.46750472e-02f, -4.01150137e-02f, -8.50833079e-04f,
  -4.41363640e-02f, -5.05309477e-02f, -1.23674739e-02f, -2.39789352e-01f, -1.38550982e-01f, -1.21327542e-01f, -6.04628325e-02f, 2.12284960e-02f, -4.19990830e-02f, -2.97590762e-01f,
  -4.01269078e-01f, -3.75618219e-01f, -2.81293541e-01f, -8.33485305e-01f, -1.96350306e-01f, 3.18020433e-01f, 9.88129377e-02f, -3.69832711e-03f, -2.21365064e-01f, -2.55330592e-01f,
  -7.54133165e-02f, -5.12329005e-02f, -3.33848149e-01f, -1.60610646e-01f, 1.15467988e-01f, -2.32077926e-01f, -1.13676913e-01f, -8.17063788e-04f, 2.40929008e-01f, 2.90910244e-01f,
  5.50156720e-02f, -4.50733840e-01f, -3.03766757e-01f, -1.27699852e-01f, -3.27429861e-01f, -6.12356439e-02f, -5.05165339e-01f, -2.93222457e-01f, 2.49418646e-01f, -5.37190735e-01f,
  -3.65639269e-01f, -2.18290597e-01f, -2.25668643e-02f, 4.39670123e-02f, -1.91604763e-01f, -6.25497326e-02f, -2.00611004e-03f, -2.86898375e-01f, -2.89082155e-02f, -1.02344565e-01f,
  -1.09387539e-01f, 2.78717466e-02f, -1.41490847e-01f, -5.71543649e-02f, -1.62830949e-01f, -6.11354150e-02f, -2.46787965e-02f, -3.97562124e-02f, -2.56836582e-02f, -4.93414178e-02f,
  8.92846361e-02f, 1.34096339e-01f, 1.18659101e-01f, 2.86554769e-02f, 1.25640303e-01f, -1.00963317e-01f, 2.58466955e-02f, 9.32274461e-02f, 1.98311150e-01f, -1.48381814e-01f,
  -3.49615179e-02f, -1.15615623e-02f, -2.93188654e-02f, 4.56588119e-02f, -1.55327353e-03f, 3.19611579e-02f, 1.54124517e-02f, 3.80709916e-02f, 3.94648202e-02f, -3.24990973e-02f,
  -8.26106295e-02f, -3.08129191e-02f, -8.56249109e-02f, -7.95901939e-02f, 5.92427403e-02f, 6.49821237e-02f, 1.10505462e-01f, -7.95366466e-02f, 6.62274212e-02f, -7.20588937e-02f,
  1.24404073e-01f, 7.20544457e-02f, -1.49148777e-01f, 8.91165924e-04f, 6.27726912e-02f, -4.05923985e-02f, 4.18384075e-02f, 2.03659654e-01f, -1.24507705e-02f, 1.46295413e-01f,
  -3.17369103e-01f, 4.11136210e-01f, -1.92219764e-01f, 3.57589051e-02f, 6.39252812e-02f, -2.96731703e-02f, -7.79906958e-02f, 1.38034113e-02f, -6.35961890e-02f, -2.53666975e-02f,
  1.21520013e-02f, -2.74275057e-03f, -4.45517711e-02f, 8.83550942e-02f, -4.36166450e-02f, 6.69312999e-02f, 6.28881156e-02f, 6.37338636e-03f, 6.83834776e-02f, -2.62594875e-02f,
  -2.14574803e-02f, 2.47244954e-01f, 7.78035149e-02f, 1.42809018e-01f, 4.89122234e-02f, 1.58517540e-01f, 8.92906860e-02f, 2.29222625e-01f, 2.00479731e-01f, -1.20205162e-02f,
  -3.86500299e-01f, -1.89497918e-01f, 1.56829447e-01f, -2.56870627e-01f, 1.50202336e-02f, 6.62842020e-02f, -4.85643111e-02f, -1.27671063e-01f, -1.50274947e-01f, 5.52928448e-02f,
  -2.37914100e-02f, 1.09694801e-01f, 5.59257343e-02f, 9.25793573e-02f, 3.15888673e-02f, 1.26113519e-01f, 8.08726996e-02f, 9.36417878e-02f, 1.51862979e-01f, -4.29664850e-02f,
  -6.21148534e-02f, -1.32442921e-01f, -2.82480866e-01f, -1.69472530e-01f, -1.73659399e-01f, -3.77120748e-02f, -2.18765956e-04f, -7.18386695e-02f, -1.48595169e-01f, -7.58279487e-02f,
  5.22745013e-01f, -1.58891663e-01f, 1.26293972e-01f, -4.34689038e-03f, -3.00861876e-02f, -9.14515108e-02f, -7.94242695e-02f, -5.98905832e-02f, -1.74762681e-02f, 1.20738424e-01f,
  -6.38041571e-02f, -1.14583969e-01f, -1.08523309e-01f, -5.25815599e-02f, 8.99323523e-02f, 4.65671793e-02f, 3.02237868e-02f, 1.39159143e-01f, 1.59889366e-02f, 4.25008647e-02f,
  6.68761134e-03f, 2.39024982e-02f, 6.83607534e-02f, 6.78166524e-02f, -1.34509904e-02f, 4.15273681e-02f, -1.63803659e-02f, 3.03250534e-04f, -4.78131510e-03f, 9.89506990e-02f,
  -9.82979685e-02f, -3.71256918e-02f, 6.06551999e-03f, 7.64787197e-02f, -8.84150993e-03f, -3.59921791e-02f, 5.61814643e-02f, 1.77586645e-01f, 1.05054239e-02f, 4.70546037e-02f,
  9.52210352e-02f, 3.49186622e-02f, -1.23301044e-01f, 4.66291606e-02f, -5.57855964e-02f, -1.70509323e-01f, -5.32869883e-02f, -6.21122830e-02f, -4.79989983e-02f, -1.58432111e-01f,
  4.59813103e-02f, 3.33403051e-02f, -1.35040924e-01f, -6.20972626e-02f, -1.32295089e-02f, -3.16111594e-02f, 6.84142299e-03f, -3.99314836e-02f, -1.48035556e-01f, -8.67062509e-02f,
  4.02594835e-01f, -5.29842936e-02f, 1.42929122e-01f, -8.04870203e-03f, -5.86964861e-02f, -1.50089581e-02f, -1.59326626e-03f, -1.27918541e-01f, 2.74308436e-02f, -1.38590811e-02f,
  9.43634361e-02f, -8.22044909e-02f, -1.81821391e-01f, 5.50224110e-02f, 1.11067750e-01f, 3.16914842e-02f, -2.82005612e-02f, 1.65245116e-01f, 7.73939192e-02f, 1.66858248e-02f,
  -4.37058434e-02f, 2.15686440e-01f, 2.76222259e-01f, 2.74958074e-01f, 1.74203590e-01f, 2.22804591e-01f, 2.45020494e-01f, 1.85992196e-01f, 1.17090471e-01f, 1.57691315e-01f,
  -3.90242338e-01f, -1.02764688e-01f, -2.81074286e-01f, 6.23693457e-03f, 1.92961812e-01f, 1.62409410e-01f, 8.71414021e-02f, 3.21112782e-01f, 2.72043586e-01f, -2.18499675e-02f,
  1.00026399e-01f, 8.30111504e-02f, -2.59075373e-01f, -1.49502128e-01f, -9.77489054e-02f, -2.31184378e-01f, -2.45505095e-01f, -4.26705778e-01f, -6.31009266e-02f, 1.71750754e-01f,
  3.57345194e-02f, -1.51246890e-01f, -2.77970374e-01f, -9.85428914e-02f, -2.36491449e-02f, -2.97654480e-01f, -4.65160072e-01f, -3.45551252e-01f, -4.11493450e-01f, -4.75265324e-01f,
  -4.14622992e-01f, 1.48897424e-01f, 1.64694205e-01f, -8.15568715e-02f, -9.65863466e-02f, 2.77804919e-02f, 3.15102935e-02f, 9.76522937e-02f, 1.89353600e-01f, 1.92584306e-01f,
  1.00144021e-01f, 1.42040476e-01f, 6.19540773e-02f, 3.91605273e-02f, 1.08119160e-01f, 1.89129353e-01f, 1.64640680e-01f, 4.76000160e-02f, 1.35338213e-03f, 2.57854670e-01f,
  1.55029029e-01f, -1.11423731e-01f, 2.19567418e-02f, 1.22419693e-01f, 2.39781201e-01f, -7.09705502e-02f, -1.19884303e-02f, 1.94090188e-01f, -7.25170895e-02f, -1.75196767e-01f,
  -4.51748259e-02f, -3.18081491e-02f, 1.12344157e-02f, -1.02157533e-01f, 8.60917494e-02f, 1.56260803e-02f, -4.20230329e-02f, -4.44713160e-02f, -4.25884202e-02f, -1.17174700e-01f,
  1.35797188e-01f, 9.20584649e-02f, 1.12948440e-01f, -1.14282720e-01f, -5.15780225e-02f, 4.61703613e-02f, 2.04854198e-02f, -7.44636506e-02f, 2.88528465e-02f, 7.87178129e-02f,
  3.20086777e-02f, -3.85973379e-02f, -9.08469111e-02f, -9.40616522e-03f, -2.45013908e-02f, 1.69543289e-02f, 6.68355823e-02f, 9.40099210e-02f, 1.22217350e-01f, 1.10811360e-01f,
  -4.77856509e-02f, -1.23934299e-01f, -2.42024790e-02f, 1.66506603e-01f, -8.82264078e-02f, 4.00260612e-02f, -4.25026640e-02f, 6.61667362e-02f, -3.04522924e-02f, 1.35106981e-01f,
  2.65585929e-01f, -7.43601983e-03f, -5.16892001e-02f, -5.99118471e-02f, 1.60569862e-01f, 8.20515826e-02f, -1.84351858e-02f, -2.41848856e-01f, 4.62008938e-02f, 1.68206841e-01f,
  5.60322776e-02f, -3.56638581e-02f, -1.54892251e-01f, -7.42807090e-02f, -4.51784544e-02f, -1.66612908e-01f, -2.54349113e-01f, -4.99803107e-03f, -3.25678349e-01f, -3.69404972e-01f,
  -1.21696390e-01f, -5.15778184e-01f, -2.30174974e-01f, 2.90444553e-01f, 1.95300609e-01f, -1.91865399e-01f, -7.27065325e-01f, -5.39607048e-01f, 1.68792903e-01f, -1.80386305e-01f,
  2.00504810e-01f, 3.38802993e-01f, 1.81799665e-01f, -4.08035591e-02f, -5.08550048e-01f, -4.32842702e-01f, -2.04505011e-01f, -5.18613309e-02f, -5.81510440e-02f, -7.50456080e-02f,
  2.29601413e-01f, 2.38395050e-01f, 1.74229115e-01f, 8.42127278e-02f, 2.57384628e-01f, 2.42808953e-01f, 1.29705727e-01f, 2.20319822e-01f, 1.76090106e-01f, 2.07648024e-01f,
  1.32615700e-01f, -2.62365997e-01f, 8.67156386e-02f, 1.39278546e-01f, -1.55317206e-02f, -3.28114659e-01f, -1.67551368e-01f, -2.26553530e-02f, -6.94383159e-02f, -1.18163668e-01f,
  2.73708701e-01f, -7.88906813e-02f, 1.45198613e-01f, 1.67738259e-01f, -4.52595204e-02f, -2.95036018e-01f, -2.49959007e-02f, -9.09966007e-02f, -1.05991952e-01f, -9.43600908e-02f,
  1.82328105e-01f, 3.82464677e-01f, -1.04944311e-01f, -1.53983667e-01f, -2.56440818e-01f, 3.35862301e-02f, -1.01552710e-01f, -2.67860889e-02f, -2.12064624e-01f, -2.06397101e-01f,
  -2.71054525e-02f, 2.58865785e-02f, -4.74975770e-03f, -9.29426923e-02f, -1.40058935e-01f, 6.83753267e-02f, 1.42588288e-01f, 4.46582697e-02f, 4.74371575e-02f, -7.32463896e-02f,
  -1.31028825e-02f, 5.82125485e-02f, -8.06466118e-02f, -1.34424763e-02f, 1.35902166e-01f, 2.75377817e-02f, -3.06357685e-02f, -4.28749807e-02f, 6.20858446e-02f, -1.05716489e-01f,
  1.03509342e-02f, -3.69712636e-02f, 1.94738612e-01f, -1.43381178e-01f, -4.74199727e-02f, -4.02775109e-02f, -1.40311405e-01f, -1.70872316e-01f, -1.37885794e-01f, 5.60423583e-02f,
  1.26203587e-02f, 1.37723342e-01f, -1.80432796e-01f, -3.14974636e-01f, 1.13348112e-01f, 5.50894774e-02f, 5.57789616e-02f, -1.28172472e-01f, 8.96615535e-02f, -1.92228422e-01f,
  -1.35972962e-01f, -6.38320995e-03f, 1.24269262e-01f, 6.84685167e-03f, 5.81426080e-03f, 2.21701190e-02f, -6.43377751e-02f, -7.88435265e-02f, -4.46592458e-02f, 2.70554982e-02f,
  -1.33780301e-01f, -1.67316720e-01f, -2.26575941e-01f, -2.57287294e-01f, -3.02009098e-02f, -3.40122022e-02f, -1.12488739e-01f, -6.48688450e-02f, -2.82308936e-01f, -5.34670472e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.29320782e-01f, 3.60503793e-01f, 6.33282185e-01f, 3.24293822e-01f, 2.41629317e-01f, 4.00984466e-01f, 3.36232483e-01f, 3.88274819e-01f, 7.95877725e-02f, 1.99278802e-01f,
  3.13845754e-01f, 8.97998177e-03f, -9.98052210e-03f, 1.62700847e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  5.98068051e-02f, 3.40979435e-02f, -3.00784502e-02f, -8.91911089e-02f, -2.14916527e-01f, -2.18510732e-01f, 1.44818768e-01f, -9.38753709e-02f, 5.11737689e-02f, 2.64462858e-01f,
  1.27255946e-01f, 4.53004688e-02f, 2.74774760e-01f, -8.84627923e-02f, -3.06633323e-01f, 1.92612022e-01f, -9.52244923e-02f, -6.89009379e-04f, -2.84767985e-01f, -2.93794185e-01f,
  1.52713746e-01f, 1.21431671e-01f, 1.92357451e-01f, 7.91194960e-02f, -3.28573048e-01f, 1.20257940e-02f, -1.37116447e-01f, -1.28968015e-01f, 2.82498270e-01f, 1.75336242e-01f,
  -1.71951652e-01f, -4.29727107e-01f, 8.72549787e-02f, -7.92463869e-02f, -1.30194649e-01f, 1.75941456e-02f, -9.04938132e-02f, -1.29760489e-01f, -3.09196636e-02f, -5.86039983e-02f,
  2.01358143e-02f, 7.37838000e-02f, 1.98849529e-01f, 2.73545254e-02f, 1.36869416e-01f, 1.67280570e-01f, 6.76144809e-02f, -8.35242495e-03f, 1.79155827e-01f, -1.42812237e-01f,
  -2.87945926e-01f, 4.80181128e-02f, -2.86259204e-01f, -2.27868468e-01f, -1.05946772e-02f, -9.38031524e-02f, 8.23005587e-02f, 2.00991090e-02f, 3.35555732e-01f, -1.26387030e-01f,
  3.00586849e-01f, -1.59642234e-01f, 1.71727076e-01f, 3.87540132e-01f, 7.64814112e-03f, -1.53952867e-01f, 1.46530032e-01f, 1.45230979e-01f, 1.45273328e-01f, 4.33071107e-02f,
  3.88675695e-03f, 1.64319918e-01f, 1.15002126e-01f, -4.22684178e-02f, 1.31155001e-02f, -1.17091592e-02f, 4.76135537e-02f, 1.04651824e-01f, 2.24993795e-01f, -7.03289509e-02f,
  1.37426509e-02f, -7.48012438e-02f, -2.36490145e-01f, 3.95607054e-02f, -3.66964608e-01f, 6.65844679e-02f, 2.47663572e-01f, -1.34158432e-01f, 3.46697867e-02f, 3.23729157e-01f,
  -6.75887093e-02f, 1.37354285e-01f, 3.05295974e-01f, 1.41436532e-01f, -2.54963428e-01f, 1.41868703e-02f, 1.03172578e-01f, -2.89666384e-01f, -9.52591524e-02f, -9.59251300e-02f,
  9.26727653e-02f, 7.94300362e-02f, 1.03299268e-01f, 1.58644214e-01f, 8.55871439e-02f, -2.17051193e-01f, -1.16332106e-01f, 8.46055001e-02f, -3.50399241e-02f, 1.78966269e-01f,
  2.92212307e-01f, 1.72586441e-02f, -3.24056953e-01f, 7.97357131e-03f, -1.39245689e-01f, 4.39869948e-02f, 1.87248383e-02f, 2.63628751e-01f, 1.32230297e-01f, 3.36952321e-02f,
  -1.38802767e-01f, -1.42629430e-01f, 2.69361079e-01f, -2.39708140e-01f, 1.95696101e-01f, -2.00518779e-02f, 2.60915584e-03f, -2.66867504e-02f, -6.90344423e-02f, -2.96223521e-01f,
  1.31624788e-02f, 3.73641960e-02f, -6.47211745e-02f, 4.19230722e-02f, -9.93634313e-02f, 3.85938697e-02f, -3.96155268e-02f, 5.54154962e-02f, -5.00737540e-02f, 7.07068145e-02f,
  8.04455504e-02f, 3.01889390e-01f, 1.74790502e-01f, 1.26181319e-02f, -1.99928284e-02f, -1.46303624e-01f, 1.03942521e-01f, -1.67960033e-01f, -2.89846901e-02f, -1.46464318e-01f,
  -1.55494809e-01f, -6.52155355e-02f, -4.12208773e-02f, -5.04525788e-02f, 2.23044366e-01f, -1.51738524e-01f, 3.25238973e-01f, -4.63919081e-02f, 2.04442050e-02f, 1.13509849e-01f,
  -3.51580754e-02f, -1.31138414e-01f, -5.25435098e-02f, -1.05609968e-01f, 6.30151927e-02f, 1.24327245e-03f, -6.12476096e-02f, 3.65154967e-02f, 7.22136199e-02f, -7.48735070e-02f,
  -1.45382836e-01f, -1.13482341e-01f, -1.14346184e-01f, 1.95757911e-01f, 1.31770641e-01f, 3.61282714e-02f, 1.05811246e-01f, 6.25283867e-02f, 4.96902674e-01f, -1.70727223e-01f,
  -8.03482831e-02f, 1.89715192e-01f, -3.52739424e-01f, -8.61817598e-02f, -3.35867591e-02f, -5.47621585e-02f, -1.76238015e-01f, 4.71806154e-02f, -2.19186395e-01f, -3.63996327e-01f,
  1.43406227e-01f, 5.57960868e-01f, -2.92100571e-02f, -1.89808995e-01f, -8.29605013e-02f, 3.26810442e-02f, 1.49404153e-01f, -6.55886680e-02f, 4.05286811e-02f, 1.16807595e-01f,
  7.75339156e-02f, -1.36132434e-01f, -2.66038954e-01f, -7.32900724e-02f, 8.10822845e-02f, 1.49386331e-01f, 1.64084673e-01f, -2.63533406e-02f, 5.51055856e-02f, -6.39854297e-02f,
  3.06429148e-01f, -2.01379001e-01f, -2.49695688e-01f, 2.37987842e-02f, -2.40758970e-01f, 9.01180357e-02f, -2.37148121e-01f, -1.50923073e-01f, 1.42853469e-01f, -3.44831403e-03f,
  1.22728404e-02f, -2.03195676e-01f, -1.49580017e-01f, 2.68018097e-01f, 8.24210271e-02f, -1.63470984e-01f, -1.42383799e-01f, -1.40710664e-03f, 1.06787935e-01f, -8.65400303e-03f,
  -1.14953659e-01f, 1.78808481e-01f, -5.77564761e-02f, -1.64197206e-01f, -1.86534718e-01f, -4.48920205e-02f, 1.70352474e-01f, 2.35614359e-01f, 4.53680277e-01f, 1.35659888e-01f,
  3.61586064e-02f, -2.51131684e-01f, -1.57671198e-01f, -1.06397845e-01f, -4.48053211e-01f, -8.31291825e-02f, -8.62357989e-02f, 7.91354477e-02f, -4.23118204e-01f, 6.21121451e-02f,
  1.32902831e-01f, 9.21448991e-02f, 1.63640022e-01f, 3.09123415e-02f, -3.65952820e-01f, -2.24885091e-01f, 4.86613736e-02f, -1.10250615e-01f, 7.85083398e-02f, 5.64948618e-02f,
  -5.39836623e-02f, 1.32771641e-01f, -1.09622851e-01f, -7.14723319e-02f, 1.96546316e-03f, -2.18335465e-01f, 7.25260451e-02f, 1.33791622e-02f, 1.26414239e-01f, 4.12457064e-02f,
  7.33058602e-02f, -1.38704553e-01f, 5.34522273e-02f, -9.26109105e-02f, -3.04358870e-01f, -1.17199294e-01f, -4.30907696e-01f, 3.45400232e-03f, 2.72114277e-01f, -6.78052753e-02f,
  -1.65396929e-01f, 5.52738607e-01f, -4.43999022e-01f, -5.22002764e-02f, 5.65170981e-02f, 2.58768082e-01f, -7.88737461e-02f, -2.49385778e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.92242046e-03f, 5.22285700e-01f, 2.34524652e-01f, 3.40846956e-01f, 8.99135619e-02f, 8.85616988e-02f, 2.31077969e-01f, -8.52627531e-02f, 8.44183862e-02f, 5.66648722e-01f,
  1.36831775e-01f, 2.14022905e-01f, -2.52156612e-03f, -1.04136452e-01f, -1.64833874e-01f, 2.45909348e-01f, 4.51976866e-01f, -5.39450049e-01f, -4.59942639e-01f, -4.25515056e-01f,
  1.91038474e-01f, -3.00404072e-01f, 2.07173154e-01f, -5.87635338e-02f, -4.14614648e-01f, 3.05496335e-01f, 2.09992275e-01f, 2.35996678e-01f, -3.46825302e-01f, -1.79313734e-01f,
  -2.21188083e-01f, 1.08860873e-01f, 4.65405770e-02f, 1.06060706e-01f, 7.43889585e-02f, 2.34982774e-01f, 1.22948755e-02f, 2.77157098e-01f, 1.30034968e-01f, 6.10103942e-02f,
  1.34927094e-01f, -1.84541896e-01f, 4.10677552e-01f, 1.33436248e-01f, -2.20005527e-01f, 2.50630230e-01f, -4.95261252e-02f, -2.21092459e-02f, 2.54531294e-01f, 2.54722778e-02f,
  1.42062809e-02f, 4.25468683e-01f, 4.95696962e-01f, 3.26403797e-01f, 2.11870924e-01f, 1.81832433e-01f, 3.56983453e-01f, 3.77647430e-01f, -5.04262559e-02f, 1.52462885e-01f,
  -1.46778092e-01f, -9.60978046e-02f, -6.02274053e-02f, 2.46416017e-01f, 1.65748626e-01f, 5.46566367e-01f, 1.81821585e-01f, 1.66998833e-01f, 5.27414158e-02f, 5.11425972e-01f,
  3.18374008e-01f, 1.96755692e-01f, -1.37943812e-02f, -8.44235420e-02f, 1.04377881e-01f, -1.72406491e-02f, -2.23240927e-01f, -1.80865347e-01f, 1.19691551e-01f, -1.06520854e-01f,
  2.24632606e-01f, 3.82622361e-01f, 2.28563398e-01f, 4.93762314e-01f, 4.33304429e-01f, 5.36215194e-02f, -6.89614117e-02f, 7.46937692e-02f, 5.62972128e-01f, 2.20244125e-01f,
  -1.10269420e-01f, -3.26813012e-01f, -8.25658068e-02f, -2.01959200e-02f, 3.62711817e-01f, 6.64329886e-01f, -1.89453419e-02f, 3.70353699e-01f, 9.04874280e-02f, 3.79597396e-01f,
  2.98287481e-01f, 4.30996537e-01f, -7.99157247e-02f, -1.54650912e-01f, 3.40376019e-01f, 9.12219584e-02f, 1.03196077e-01f, 1.80900097e-01f, 3.34510535e-01f, -4.10721749e-01f,
  -1.13921434e-01f, -3.04499686e-01f, 4.21385884e-01f, -3.55647117e-01f, -2.92229712e-01f, -6.45707309e-01f, -4.80172187e-01f, 9.86055508e-02f, 4.52291012e-01f, 7.70779848e-02f,
  -1.98112488e-01f, 7.57525027e-01f, -4.47299331e-02f, 2.89744250e-02f, -3.45652580e-01f, -3.04575354e-01f, -4.16246891e-01f, 4.51018870e-01f, 7.20359012e-02f, 8.87235925e-02f,
  1.78393409e-01f, 1.54429033e-01f, -1.12534367e-01f, -6.92378655e-02f, 1.31676614e-01f, -9.99578834e-02f, 7.85563588e-02f, 3.43661755e-02f, 5.10478914e-01f, 2.03769401e-01f,
  2.12761104e-01f, -4.99990821e-01f, -6.87784255e-01f, -1.78360343e-01f, -1.72491059e-01f, 2.65837044e-01f, -5.54364443e-01f, -5.75755477e-01f, 3.46406043e-01f, 2.92472273e-01f,
  4.94873315e-01f, 9.39971060e-02f, -1.19289704e-01f, 3.97854075e-02f, -3.19345176e-01f, -3.30112785e-01f, 4.87529719e-03f, 4.79351245e-02f, -1.19160317e-01f, -4.14548546e-01f,
  2.88359970e-01f, 1.97377160e-01f, 4.80263174e-01f, 2.38920912e-01f, 6.71593249e-02f, 4.79256921e-02f, 1.17630117e-01f, -6.35351315e-02f, 8.36499557e-02f, 2.50782013e-01f,
  -1.31532565e-01f, -4.71464783e-01f, 2.75511801e-01f, -2.32972741e-01f, -4.27017719e-01f, 9.63149965e-02f, -7.52990395e-02f, 4.94919270e-02f, 5.17353475e-01f, -3.33687007e-01f,
  5.94012260e-01f, -1.41686186e-01f, -6.06692471e-02f, 3.82426530e-01f, -1.66665301e-01f, -1.26162127e-01f, -4.87828523e-01f, 5.50050065e-02f, 2.42668495e-01f, -1.54600158e-01f,
  -1.27045274e-01f, -3.69600296e-01f, 8.84139389e-02f, -1.43776992e-02f, -9.81898513e-03f, -7.13483989e-02f, -1.93350226e-01f, 1.82152420e-01f, -2.55603995e-02f, -3.57835228e-03f,
  1.86035469e-01f, -2.01658294e-01f, 2.46727005e-01f, -2.22741172e-01f, -3.18251729e-01f, 1.25491321e-01f, -2.04248920e-01f, -2.08653927e-01f, 4.28941637e-01f, 6.50333390e-02f,
  2.48291969e-01f, 2.47106273e-02f, 7.93280974e-02f, 1.68746695e-01f, -1.46929070e-01f, -8.05246606e-02f, 4.38449472e-01f, 4.42974478e-01f, -7.66250342e-02f, 7.53883719e-02f,
  -3.97862911e-01f, -2.14416496e-02f, -1.04706690e-01f, 6.51161671e-01f, -3.01927533e-02f, -4.07614522e-02f, 1.21735714e-01f, 2.25771204e-01f, 2.75614709e-01f, 1.06720544e-01f,
  -3.21922600e-02f, 2.95703143e-01f, 2.33078107e-01f, -8.39761645e-02f, -2.66153812e-01f, -4.03565139e-01f, -4.36369151e-01f, 2.18582407e-01f, 1.15881316e-01f, 2.86675960e-01f,
  3.75384033e-01f, -1.56287421e-02f, 5.76389313e-01f, -3.10617238e-01f, 7.13806212e-01f, -1.00186266e-01f, -3.94842774e-01f, 3.12971413e-01f, -1.66154787e-01f, -2.80359298e-01f,
  -3.08447897e-01f, 1.89188465e-01f, -3.60776708e-02f, -3.70460927e-01f, 3.05906445e-01f, 1.55262306e-01f, 3.09997410e-01f, 4.78100121e-01f, 4.24258709e-01f, 2.18166545e-01f,
  -3.25263198e-03f, 5.14960468e-01f, 1.50458336e-01f, 2.57633924e-01f, 1.76500872e-01f, -1.85496613e-01f, 1.67887866e-01f, 1.97363392e-01f, 2.68336888e-02f, -6.35194452e-03f,
  2.58816868e-01f, -2.48153478e-01f, -1.32140249e-01f, 5.38901053e-02f, -4.52137701e-02f, 6.53100669e-01f, 2.41443053e-01f, 2.05242068e-01f, 7.78367184e-03f, -1.92199886e-01f,
  2.74592876e-01f, 2.00320899e-01f, -4.03206438e-01f, -4.99675900e-01f, 3.32561791e-01f, 1.06783949e-01f, -3.27060610e-01f, 3.19777094e-02f, 2.80962765e-01f, 5.13404369e-01f,
  3.94119531e-01f, 2.38242343e-01f, -5.14842384e-02f, -1.37554957e-02f, 1.04704648e-01f, -1.74596027e-01f, 3.00623417e-01f, 3.04651827e-01f, 1.38541088e-01f, 3.13430429e-01f,
  -1.23213455e-01f, -2.77431786e-01f, -2.30434194e-01f, 2.51662545e-02f, 1.59602001e-01f, 1.34080857e-01f, -3.39078382e-02f, 6.87098265e-01f, 2.77834982e-01f, -2.88540900e-01f,
  -3.87806855e-02f, -3.32137346e-02f, 4.55105901e-01f, 4.80079234e-01f, -1.68142736e-01f, 2.45269015e-01f, -1.00193933e-01f, 1.77206740e-01f, -7.98644945e-02f, 1.56969398e-01f,
  3.32796900e-03f, -2.11610377e-01f, 1.41616270e-01f, 2.14540899e-01f, 3.41346040e-02f, 3.57580441e-03f, 1.82409048e-01f, 2.23287284e-01f, 8.44463706e-02f, -2.73499966e-01f,
  -2.42328987e-01f, -2.30210528e-01f, 1.97123960e-01f, 2.12908179e-01f, 1.45490259e-01f, -3.00465468e-02f, -1.00492552e-01f, 6.21592663e-02f, 3.80255431e-01f, -5.12997899e-03f,
  9.49688852e-02f, 4.79199700e-02f, 4.40546751e-01f, 2.58153249e-02f, -2.70796716e-02f, -2.03037098e-01f, 4.20403779e-01f, -3.73304659e-03f, 5.76272666e-01f, 5.26333675e-02f,
  4.82774764e-01f, 1.48133874e-01f, -2.18703926e-01f, 5.93823195e-03f, -2.78498203e-01f, -1.56478897e-01f, 6.64925426e-02f, -1.61773767e-02f, -8.46551582e-02f, 1.06610596e-01f,
  -7.31071606e-02f, 5.95815964e-02f, 3.02349180e-01f, 3.92676294e-01f, -2.26527840e-01f, 1.12626694e-01f, -2.66504824e-01f, -1.58209205e-01f, 3.40194330e-02f, 3.72242503e-04f,
  -5.26849404e-02f, 1.98105887e-01f, 5.87553024e-01f, -1.48948207e-01f, 3.45843583e-01f, -8.96198079e-02f, 2.05078259e-01f, 1.90177076e-02f, 4.69036996e-01f, -1.77290469e-01f,
  4.01373744e-01f, 4.66361754e-02f, 4.76565570e-01f, 1.22461252e-01f, -7.00070485e-02f, 2.88489312e-01f, 1.00652799e-02f, 2.72959709e-01f, 3.25035512e-01f, 1.57753512e-01f,
  4.07363549e-02f, 5.20159245e-01f, -7.19778985e-02f, -2.35819131e-01f, 2.53723532e-01f, 4.92230326e-01f, 2.40135625e-01f, 2.32060492e-01f, -1.03024639e-01f, 1.36430368e-01f,
  1.67346880e-01f, -2.88335443e-01f, -2.18128964e-01f, 2.88674593e-01f, 2.30996773e-01f, 1.71584580e-02f, 5.89683235e-01f, 7.54939020e-02f, 1.23742603e-01f, 3.12728047e-01f,
  7.38082528e-01f, -4.40524906e-01f, 3.04283500e-01f, -2.73395300e-01f, 2.53316134e-01f, 4.16743696e-01f, 2.52715290e-01f, 2.57204715e-02f, 1.58047706e-01f, 3.29141319e-01f,
  3.30390900e-01f, 1.60056561e-01f, 3.20191771e-01f, 2.46662632e-01f, 3.51859868e-01f, -1.68317482e-01f, -1.45742074e-01f, -1.10389829e-01f, 1.48595989e-01f, -5.55726625e-02f,
  3.20513695e-01f, -2.53729701e-01f, -3.00337613e-01f, 1.55037120e-01f, 5.28059959e-01f, 2.43848190e-01f, -5.45733012e-02f, 4.54943419e-01f, 1.84147447e-01f, 3.43906611e-01f,
  -9.85181853e-02f, -3.07360202e-01f, -1.19251683e-01f, 3.28306034e-02f, 6.20446265e-01f, 1.19130522e-01f, -1.82752535e-01f, -6.85788989e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.79796302e-01f, 2.25351080e-01f, 1.04746722e-01f, 2.83196688e-01f, 4.21333820e-01f, 4.67642277e-01f, 5.87827452e-02f, 3.42036009e-01f, 3.10306251e-01f, 4.07466650e-01f,
  1.82829663e-01f, -2.85714298e-01f, 1.62798911e-01f, 3.44141811e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  5.43680415e-02f, -6.65080845e-02f, -4.50324774e-01f, 3.06057304e-01f, -4.08586621e-01f, -4.93258573e-02f, -4.12249640e-02f, -1.12730332e-01f, 5.77281527e-02f, 2.51618385e-01f,
  1.78115562e-01f, 2.79635906e-01f, 2.69769311e-01f, 3.48264612e-02f, 2.93989003e-01f, 4.55406487e-01f, 2.00528547e-01f, 2.04675838e-01f, -5.65827899e-02f, -2.06490189e-01f,
  -2.55468935e-01f, 1.31148160e-01f, 3.14457297e-01f, 6.21662103e-02f, -1.03475004e-01f, -9.98044536e-02f, -1.76171899e-01f, -8.16897750e-02f, 2.75611311e-01f, 6.26642779e-02f,
  -3.76069248e-02f, 1.04739033e-01f, 1.64642558e-01f, -1.26305101e-02f, 1.99106812e-01f, 1.71234772e-01f, 2.67550796e-01f, 2.22728297e-01f, 1.65733129e-01f, 2.07772195e-01f,
  8.17121863e-02f, 2.87925750e-01f, -4.19507533e-01f, 3.44672710e-01f, -1.84339121e-01f, -1.72320440e-01f, -6.08908594e-01f, -4.43845063e-01f, -2.97439247e-01f, -7.74753764e-02f,
  2.15049878e-01f, -7.55257383e-02f, -8.83133039e-02f, 4.68052924e-02f, 1.41965151e-01f, 2.27182746e-01f, -3.37233841e-01f, 1.16357937e-01f, 2.70973951e-01f, -1.66101143e-01f,
  3.67189087e-02f, -9.71138999e-02f, -1.60994798e-01f, -2.25051969e-01f, 6.46201968e-02f, 1.58014923e-01f, 1.35162771e-01f, -9.22893137e-02f, -3.98322433e-01f, 1.96544036e-01f,
  1.70403287e-01f, 1.30213359e-02f, 1.22240325e-02f, 3.64123397e-02f, 4.04006913e-02f, 4.70241129e-01f, -3.83138150e-01f, -1.33386016e-01f, 4.51699942e-01f, 4.77265656e-01f,
  4.14924026e-01f, -5.32887243e-02f, 3.00116986e-01f, -9.91181135e-02f, -7.89809823e-02f, 1.49170950e-01f, -1.59741104e-01f, 6.98857605e-02f, 1.24865636e-01f, 1.68861821e-01f,
  -4.27922547e-01f, 1.14481568e-01f, 1.85874552e-01f, -6.40455186e-02f, -8.39965865e-02f, -1.84555314e-02f, 2.59323001e-01f, 1.97589517e-01f, 1.39323086e-01f, -2.13541210e-01f,
  -8.61461014e-02f, -2.24045321e-01f, -1.98145792e-01f, 6.94180187e-03f, 4.35601175e-01f, 2.69237846e-01f, 1.30160095e-03f, 9.53367427e-02f, 1.92296028e-01f, -2.54057407e-01f,
  -7.71155596e-01f, -5.36650062e-01f, 1.16964750e-01f, 3.29490989e-01f, 1.65850028e-01f, -6.39218986e-02f, -3.18190873e-01f, 3.84251811e-02f, -3.01317628e-02f, 8.82724896e-02f,
  -1.64990172e-01f, -2.97849290e-02f, -6.79127872e-02f, 2.66031623e-01f, 1.32217824e-01f, -3.15832980e-02f, -2.54584581e-01f, 1.64605990e-01f, -1.49289370e-01f, -1.94161639e-01f,
  -2.55541001e-02f, 2.58144766e-01f, 5.79174235e-02f, -3.76592652e-04f, -3.71363945e-02f, 1.33519843e-01f, 8.26886520e-02f, -1.12942897e-01f, 1.27489865e-01f, -5.97434817e-03f,
  -8.84407759e-02f, 5.87895364e-02f, 4.36660871e-02f, -1.14943311e-02f, 2.27856524e-02f, 3.43919150e-03f, -2.42249683e-01f, -1.15979731e-01f, 2.42158487e-01f, 1.08680886e-03f,
  2.98939407e-01f, -1.10464022e-01f, -1.28505841e-01f, -3.03279608e-01f, 2.79760063e-01f, -1.02305904e-01f, -4.82134894e-03f, 2.44217515e-01f, 6.70664534e-02f, -8.09921026e-02f,
  -1.67023405e-01f, -1.23031419e-02f, -7.54908696e-02f, -5.83816543e-02f, 1.93865031e-01f, 1.55886471e-01f, -9.36386287e-02f, -3.41775641e-02f, 2.25159690e-01f, 2.43795499e-01f,
  4.50214595e-02f, 2.44817942e-01f, -1.91543773e-01f, -6.34877756e-02f, -5.21081924e-01f, -2.10958838e-01f, 4.09928672e-02f, -9.52701867e-02f, 1.37741759e-01f, -8.20800737e-02f,
  1.73810422e-02f, -1.54163539e-02f, 4.23633128e-01f, 6.88555166e-02f, -1.11276209e-01f, -3.86385292e-01f, 3.54322821e-01f, -7.55769312e-02f, -8.59533697e-02f, -1.09069042e-01f,
  2.35946402e-01f, -1.04976751e-01f, 4.36404496e-02f, -1.70179084e-01f, -1.37732625e-01f, -2.52003551e-01f, 4.21679914e-02f, -2.01633006e-01f, -1.87739715e-01f, 4.36014533e-02f,
  2.14600801e-01f, 2.57954866e-01f, -4.88115489e-01f, 4.29341644e-01f, -5.32958135e-02f, 3.62135358e-02f, -4.29038852e-01f, -3.35147023e-01f, 2.97616720e-01f, 2.49489009e-01f,
  -1.42979160e-01f, 1.62896775e-02f, -2.21742600e-01f, 9.06228349e-02f, 1.74542353e-01f, -9.60695371e-02f, 2.92541608e-02f, -2.07400575e-01f, 2.48450622e-01f, -1.57825664e-01f,
  -1.28541142e-01f, 9.30742025e-02f, 4.24759090e-02f, 3.55702609e-01f, 1.54740185e-01f, 3.79589312e-02f, 3.12080145e-01f, 2.44996786e-01f, -8.41664523e-02f, 1.23296291e-01f,
  -1.11731976e-01f, 1.04860872e-01f, -9.06234384e-02f, -2.70794541e-01f, 9.82692689e-02f, -1.78570330e-01f, 9.15016830e-02f, 1.77200940e-02f, 8.06868017e-01f, 5.24944186e-01f,
  -6.32923841e-02f, -2.67797112e-01f, 1.38095945e-01f, -1.91638038e-01f, 1.07700445e-01f, -1.29328683e-01f, -1.05925143e-01f, 4.16258201e-02f, 1.60651952e-01f, 1.49249181e-01f,
  -1.78321511e-01f, 8.71696398e-02f, 9.04364884e-02f, -2.59566233e-02f, -8.07499066e-02f, -1.04026869e-01f, 2.52513766e-01f, -2.52485126e-02f, -5.46589270e-02f, 6.46239296e-02f,
  1.89285621e-01f, -2.52117753e-01f, -9.13060755e-02f, -1.23055810e-02f, -2.87101835e-01f, -3.42253476e-01f, -3.06379408e-01f, 1.85766920e-01f, -3.19307178e-01f, -2.17195809e-01f,
  3.70962620e-01f, 1.54724851e-01f, -1.60092160e-01f, 2.58704603e-01f, 1.13093741e-02f, 2.33706266e-01f, -1.10617634e-02f, -7.01546520e-02f, -4.93088305e-01f, -8.61723348e-03f,
  1.75910100e-01f, 1.51807651e-01f, 1.94358557e-01f, -6.58148006e-02f, -1.16378017e-01f, -2.48929054e-01f, -1.53047889e-01f, 2.35349968e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.81844938e-01f, -3.35123092e-01f, 2.29448751e-01f, 4.36162442e-01f, 3.46242249e-01f, 1.96373776e-01f, 4.63655889e-01f, 3.60910594e-02f, -4.61198390e-01f, -2.26335809e-01f,
  2.55667150e-01f, -7.50668824e-01f, 2.73878396e-01f, 1.90486103e-01f, 5.49848676e-01f, 4.44633871e-01f, -4.85109389e-01f, -9.37054753e-02f, -1.58659205e-01f, 2.56906509e-01f,
  6.57195091e-01f, -1.53075621e-01f, -1.84334993e-01f, -3.50750864e-01f, 4.25764352e-01f, 1.24395534e-01f, 2.34028608e-01f, 1.45982072e-01f, 4.71183479e-01f, 2.92470664e-01f,
  6.10097289e-01f, 3.01231239e-02f, -2.04030015e-02f, 9.58383307e-02f, 4.14990157e-01f, 6.22247696e-01f, 2.09517345e-01f, 2.38842264e-01f, 5.95067501e-01f, 1.42461881e-01f,
  2.19873294e-01f, 3.86452340e-02f, -5.15714765e-01f, 2.14916602e-01f, -3.11989903e-01f, 3.58458725e-03f, 8.21274281e-01f, 3.22688431e-01f, -3.01772207e-01f, -4.59113449e-01f,
  -1.82664171e-01f, 2.11852923e-01f, 1.73218429e-01f, -2.98268050e-01f, -1.57141075e-01f, 5.11088133e-01f, 2.34447584e-01f, 5.41331530e-01f, 2.90002018e-01f, -4.96192239e-02f,
  3.51800360e-02f, -1.75518885e-01f, -4.35259402e-01f, 4.05688912e-01f, 1.29123107e-01f, 2.25431353e-01f, 4.78715688e-01f, 1.98318645e-01f, 5.53041697e-01f, 1.55923337e-01f,
  3.17060471e-01f, 5.18710494e-01f, 3.25810522e-01f, 1.71966553e-01f, -7.29609787e-01f, 4.23910618e-01f, -1.66418999e-01f, 1.35650346e-02f, 1.52738482e-01f, -2.59869993e-01f,
  -8.16756189e-01f, -4.73191440e-01f, 8.67618471e-02f, -2.33144715e-01f, 3.64703871e-02f, -2.15743911e-02f, 2.21363604e-01f, 6.18864357e-01f, -3.57294947e-01f, 4.24890012e-01f,
  4.48710799e-01f, 3.30139071e-01f, 1.51075162e-02f, -4.03137535e-01f, -6.77877665e-01f, 2.99116224e-01f, 5.00737250e-01f, 3.69461954e-01f, 3.63787562e-01f, 5.27406149e-02f,
  -4.90185440e-01f, 2.37208128e-01f, 1.16527028e-01f, 1.62694559e-01f, -2.00477447e-02f, -8.99935067e-02f, -2.40822092e-01f, 3.57655138e-01f, -1.91735495e-02f, 3.99918221e-02f,
  4.96637613e-01f, 6.64169908e-01f, -2.48433441e-01f, -6.50599420e-01f, 1.33029848e-01f, 4.95166555e-02f, -1.19770296e-01f, -9.10423100e-02f, 3.45714003e-01f, 3.82726163e-01f,
  5.15033398e-03f, 7.55326986e-01f, -3.66609514e-01f, -1.03549911e-02f, 5.66147923e-01f, -4.51841466e-02f, -3.36853713e-01f, 2.91275471e-01f, 1.68419145e-02f, 1.00170404e-01f,
  -6.03079736e-01f, 1.84912533e-01f, 1.30125299e-01f, 2.52465755e-02f, -5.88702597e-02f, 6.14498332e-02f, 4.42957580e-01f, -3.40108037e-01f, 2.27417350e-01f, 7.41992533e-01f,
  -1.63029045e-01f, -4.81847346e-01f, -4.36079428e-02f, -1.69794381e-01f, 3.39351684e-01f, 5.03921688e-01f, -8.36001784e-02f, 5.35618484e-01f, 1.03413455e-01f, 4.92304951e-01f,
  1.35377333e-01f, -3.72452110e-01f, 5.22014022e-01f, -1.58193171e-01f, 6.89819455e-01f, 2.41349395e-02f, -9.97274593e-02f, -1.25586092e-02f, 3.22508007e-01f, 3.74002278e-01f,
  2.13914379e-01f, 2.63187528e-01f, 1.29501864e-01f, -2.24016845e-01f, -1.32044375e-01f, 2.58506507e-01f, 4.52500582e-01f, -4.97869737e-02f, 4.07918364e-01f, 4.84575242e-01f,
  1.87584653e-01f, 4.95421588e-01f, -2.69133985e-01f, -2.16386184e-01f, -8.53488803e-01f, -7.53202736e-01f, -1.94880113e-01f, 3.67465079e-01f, 4.87870306e-01f, 2.26017728e-01f,
  -2.47831032e-01f, 3.76307935e-01f, 6.94334328e-01f, 3.23015720e-01f, -8.95032883e-02f, -1.83795333e-01f, -2.84892410e-01f, 2.01041922e-01f, 2.28120863e-01f, 1.79415017e-01f,
  1.59496024e-01f, 3.17230940e-01f, -1.34155184e-01f, 3.02155465e-01f, 4.06112432e-01f, 5.30117154e-01f, 8.97925377e-01f, -1.70268342e-01f, 4.55374837e-01f, 1.48489684e-01f,
  -2.55246490e-01f, 8.50226209e-02f, -8.49453568e-01f, -2.93993235e-01f, -6.32208884e-01f, -4.32611734e-01f, 1.73726957e-02f, -6.93697810e-01f, -7.93937624e-01f, -1.99293777e-01f,
  -4.09224182e-02f, 2.21692517e-01f, 5.87160587e-01f, -1.92087531e-01f, -1.04217403e-01f, 4.38408792e-01f, 4.57933843e-01f, 3.56895506e-01f, 5.39351940e-01f, 4.23363149e-01f,
  -2.93153018e-01f, -2.84493361e-02f, -2.35421360e-01f, -2.07212836e-01f, 5.38212657e-01f, 2.13116869e-01f, -5.53052090e-02f, 2.98402071e-01f, -1.10511959e-01f, 3.83288592e-01f,
  2.85841137e-01f, 2.33917668e-01f, 6.82047963e-01f, -2.53905356e-01f, 6.17029369e-01f, 8.01536202e-01f, 5.16240835e-01f, 5.65943182e-01f, -1.94735765e-01f, 6.20516121e-01f,
  1.07264924e+00f, -3.96715432e-01f, 1.84600770e-01f, 1.62886664e-01f, -5.38468733e-02f, 1.99134767e-01f, -4.47540611e-01f, 2.36298040e-01f, -5.18494964e-01f, 1.43440977e-01f,
  3.53800893e-01f, -5.39671957e-01f, 1.22178629e-01f, 2.98604846e-01f, 2.46848807e-01f, 1.77993372e-01f, 2.10303873e-01f, 1.76247865e-01f, -1.85246393e-02f, 5.25140166e-02f,
  -6.72036827e-01f, 3.84232402e-01f, 3.49785686e-01f, -6.32544160e-02f, -2.49917939e-01f, 1.97603345e-01f, 1.56916514e-01f, -5.25730588e-02f, -4.69198525e-01f, -3.75029773e-01f,
  -7.05259442e-01f, -1.40682101e-01f, -2.06044856e-02f, 3.01319182e-01f, 5.64498186e-01f, 2.75921166e-01f, 2.05040216e-01f, 2.57100970e-01f, 3.03258598e-01f, 7.22974688e-02f,
  3.38347167e-01f, 2.79196262e-01f, -6.25689864e-01f, 3.21737319e-01f, 9.54185948e-02f, 1.43859774e-01f, 4.43189353e-01f, -1.55104622e-01f, 3.45344394e-01f, 2.70441592e-01f,
  -1.39512658e-01f, 1.10647298e-01f, 1.38670444e-01f, 5.25626004e-01f, 1.65110212e-02f, 6.12301640e-02f, 3.54412049e-01f, -5.00500023e-01f, 2.36013725e-01f, 4.84553099e-01f,
  -3.31119299e-01f, -3.13648582e-01f, -1.96602389e-01f, 1.58184215e-01f, 4.56160218e-01f, 1.68539897e-01f, 7.43858576e-01f, -8.03379435e-03f, 6.09911047e-02f, 6.14592433e-01f,
  -4.20011133e-01f, -1.14585288e-01f, 2.18346193e-02f, -2.29255944e-01f, 2.61475384e-01f, 6.15939617e-01f, -1.69209078e-01f, -9.36397791e-01f, 3.49187911e-01f, -7.32652098e-02f,
  -3.83425057e-02f, 1.24542773e-01f, 1.71742618e-01f, -9.36463773e-02f, 7.38977594e-03f, -3.60726297e-01f, 8.60702097e-02f, 6.82990951e-03f, -5.91116548e-01f, -3.20222914e-01f,
  3.22252423e-01f, -8.29218984e-01f, 4.14039820e-01f, 4.84362751e-01f, -2.84339618e-02f, 2.32760489e-01f, -7.68458009e-01f, -3.80116254e-01f, -6.69062972e-01f, 1.92170888e-01f,
  5.38384855e-01f, -4.54774618e-01f, -8.21670368e-02f, -2.84578025e-01f, -3.48841101e-01f, -1.64556295e-01f, 5.30336678e-01f, 6.21089153e-02f, 3.08792293e-01f, 3.90178472e-01f,
  3.60671997e-01f, 3.94526005e-01f, 2.05279291e-01f, 7.71123031e-03f, -1.71254471e-01f, -2.50013918e-01f, -4.22290683e-01f, 5.46577513e-01f, -3.44937108e-02f, 2.22333744e-01f,
  4.74285543e-01f, -5.87386250e-01f, 4.93823349e-01f, 6.75767899e-01f, 8.44390094e-01f, 2.39371359e-01f, -3.63815486e-01f, 1.17977656e-01f, 5.82915127e-01f, -2.24033430e-01f,
  2.36503005e-01f, -4.57427651e-02f, 3.29456553e-02f, -7.72412419e-02f, -7.05661297e-01f, -3.77004296e-01f, -6.97493911e-01f, -2.01238200e-01f, 6.04332507e-01f, 4.66909617e-01f,
  4.02346879e-01f, 3.38423550e-01f, 4.96627748e-01f, 1.17554367e-01f, 8.95866826e-02f, -7.40845874e-02f, 2.25645900e-02f, 2.98679501e-01f, 3.09183002e-01f, -1.21481135e-01f,
  -1.03567995e-01f, 1.50723651e-01f, 1.70472965e-01f, -3.78832102e-01f, -3.99622828e-01f, 6.13661647e-01f, -3.11862499e-01f, 1.61379203e-02f, 1.75469205e-01f, 2.30883062e-01f,
  -2.30602711e-01f, 3.43690515e-02f, 4.14705783e-01f, -1.42424218e-02f, 3.67875755e-01f, 6.14643514e-01f, -5.47538519e-01f, -1.15350783e-01f, -1.17291333e-02f, -3.89916629e-01f,
  7.06387639e-01f, 3.27690631e-01f, -3.17721456e-01f, -2.18247131e-01f, 7.79899284e-02f, 1.83518797e-01f, -1.30074844e-01f, -3.52324545e-01f, 1.95292547e-01f, 4.71220583e-01f,
  6.01541903e-03f, -6.89820526e-03f, 1.71308309e-01f, 3.13219309e-01f, -3.08616515e-02f, -2.42809020e-02f, -2.31674075e-01f, 2.46839151e-01f, 4.29117411e-01f, -4.13830131e-02f,
  3.10131848e-01f, 5.65477967e-01f, -4.22394544e-01f, 1.66311920e-01f, 6.62682950e-02f, -1.32051706e-01f, -2.64633301e-04f, 1.76820189e-01f, 6.94883764e-01f, 3.84599030e-01f,
  -3.87235522e-01f, -2.40069687e-01f, 3.79676163e-01f, -6.94895566e-01f, 4.14028227e-01f, -4.08328213e-02f, 2.54812092e-01f, 2.16762453e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.96615337e-02f, 4.10058737e-01f, 1.97425604e-01f, 2.91225106e-01f, 5.12188114e-02f, 7.84663260e-02f, 1.17660299e-01f, 6.22075684e-02f, 1.97614670e-01f, 2.05619365e-01f,
  1.65023580e-01f, 2.69394934e-01f, 1.46754980e-01f, 4.20721263e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  7.44269714e-02f, -5.00254869e-01f, 2.81105310e-01f, -2.17693269e-01f, -7.97116607e-02f, -3.98240238e-01f, -2.97237903e-01f, 3.11515946e-02f, 4.11155261e-02f, 5.50424218e-01f,
  -2.49679126e-02f, 1.90958649e-01f, -1.88699648e-01f, -4.14410718e-02f, -2.67898858e-01f, -6.20155513e-01f, 6.40318274e-01f, -4.62702066e-01f, 3.95437688e-01f, -2.24447265e-01f,
  -4.09184009e-01f, 1.70094416e-01f, -7.27505863e-01f, -3.39551896e-01f, -7.72522330e-01f, -6.28689956e-03f, 1.92920700e-01f, 2.09648073e-01f, 1.73819110e-01f, 1.95108265e-01f,
  -6.52949870e-01f, 3.05641592e-01f, -5.94964772e-02f, 1.52416259e-01f, 3.42645310e-02f, 4.71427858e-01f, 1.97647005e-01f, 3.90798688e-01f, 3.58556569e-01f, 2.06295758e-01f,
  -1.42968506e-01f, 4.93650317e-01f, -8.98327529e-02f, 6.97247624e-01f, 3.68829310e-01f, -5.29970303e-02f, -6.43058181e-01f, 4.50042427e-01f, 2.57369101e-01f, 4.85013515e-01f,
  -3.84808242e-01f, 3.65455836e-01f, 1.09733008e-01f, 4.39907134e-01f, -2.99290288e-03f, 4.43160087e-02f, -5.82337618e-01f, 5.59511721e-01f, -4.30380143e-02f, -2.44821653e-01f,
  -4.10097480e-01f, 1.87256485e-01f, -9.75024998e-02f, 1.33020520e-01f, 4.19508308e-01f, 1.25668705e-01f, 3.50948095e-01f, 3.32826287e-01f, 1.47272468e-01f, 1.59778725e-02f,
  4.99711484e-01f, 4.64676946e-01f, 2.96340942e-01f, 1.45530179e-01f, -2.70042747e-01f, 3.99425805e-01f, -2.46661842e-01f, -7.77023360e-02f, 2.84918547e-01f, -4.55206633e-02f,
  7.33211562e-02f, 2.78855920e-01f, -4.26277220e-02f, -4.83816117e-01f, -4.55383956e-01f, -5.64609408e-01f, 3.89722958e-02f, -2.28786469e-01f, -6.37141705e-01f, 4.53521162e-01f,
  -3.85820493e-02f, 5.58988869e-01f, -5.74523985e-01f, 4.49748993e-01f, 2.81431615e-01f, 1.54671058e-01f, -3.03275347e-01f, -1.77551344e-01f, -6.05556488e-01f, 2.73874760e-01f,
  -1.95793197e-01f, -2.49368280e-01f, -5.95601536e-02f, -5.16508579e-01f, -6.26178831e-02f, -1.37853518e-01f, -3.53267699e-01f, 1.95440188e-01f, -5.37278891e-01f, 2.54967585e-02f,
  6.51888549e-01f, 6.99438751e-01f, -6.60169482e-01f, -4.19922382e-01f, 7.32453912e-02f, -7.01952338e-01f, -2.58139312e-01f, -7.01663256e-01f, -5.09684607e-02f, 7.16487551e-03f,
  -2.28272915e-01f, 4.42797810e-01f, -4.02993470e-01f, -8.50670278e-01f, 2.48934135e-01f, 5.26036620e-01f, -7.77110159e-02f, -2.18651444e-01f, -8.44677389e-02f, -3.51075530e-01f,
  1.15742750e-01f, -4.36322421e-01f, -2.70358562e-01f, 2.03938201e-01f, -1.19089969e-01f, 2.08572701e-01f, 4.23176616e-01f, -4.65936333e-01f, -1.48238949e-02f, -1.01180375e+00f,
  3.37245703e-01f, 5.48115194e-01f, 6.86059818e-02f, -6.20929778e-01f, 3.97381008e-01f, -6.07847273e-01f, 4.10631299e-01f, 2.18957871e-01f, -3.00601035e-01f, -4.35368359e-01f,
  -1.36549091e-02f, -7.37193674e-02f, 3.91436726e-01f, -1.37635022e-01f, -4.31049168e-02f, -5.84938169e-01f, 4.08472866e-02f, -1.00331917e-01f, -1.89959660e-01f, -6.80257857e-01f,
  4.08082634e-01f, 2.82319278e-01f, 4.32548195e-01f, 3.00153084e-02f, 2.26865709e-01f, -6.91527352e-02f, 8.30519646e-02f, 1.58034518e-01f, -5.59738636e-01f, -3.55477691e-01f,
  1.05022550e-01f, -1.39297545e-01f, -5.72994590e-01f, -1.16751291e-01f, -6.29393160e-01f, -3.39705616e-01f, 3.24451059e-01f, 1.42447546e-01f, 1.52548939e-01f, 3.30792218e-01f,
  2.76316434e-01f, 2.35865802e-01f, -4.03502703e-01f, -6.57652557e-01f, 4.12666380e-01f, -2.71025836e-01f, -5.82683504e-01f, -5.44875979e-01f, 1.89955920e-01f, -6.49648845e-01f,
  6.68105930e-02f, 1.84373468e-01f, -9.57638472e-02f, 6.91371039e-02f, -1.83198646e-01f, 9.57098417e-03f, -3.46514225e-01f, 2.64001414e-02f, 3.60024646e-02f, -4.32988554e-02f,
  -4.47293110e-02f, -2.61854857e-01f, 9.23121333e-01f, 1.85654163e-01f, 4.91143644e-01f, -3.68740797e-01f, 4.28407550e-01f, 3.92124057e-01f, -3.72660667e-01f, 2.17267126e-01f,
  -7.38083005e-01f, -6.35560155e-01f, -2.10959762e-02f, -1.04793578e-01f, -1.10217586e-01f, 5.06940126e-01f, 5.02791330e-02f, -6.09671652e-01f, 3.15716028e-01f, 4.34744745e-01f,
  8.59399959e-02f, -4.38729137e-01f, 1.44913822e-01f, -5.73211074e-01f, 8.81616548e-02f, 2.62243420e-01f, -2.25544557e-01f, 8.38882923e-02f, 1.45016938e-01f, -1.12379380e-01f,
  -3.58046889e-01f, -6.96020603e-01f, -3.97277698e-02f, 2.18396127e-01f, -3.86454910e-01f, -6.36367559e-01f, -1.32468835e-01f, -3.37620415e-02f, 2.76843309e-01f, -7.51396939e-02f,
  6.38113990e-02f, 1.73209220e-01f, -4.83128875e-02f, -1.89658970e-01f, -5.18091023e-01f, 1.21188415e-02f, 2.76340067e-01f, 3.78413439e-01f, -5.03024220e-01f, -2.84104824e-01f,
  3.47539485e-01f, -4.80417013e-01f, 1.70149945e-03f, -3.12191397e-01f, -5.25494576e-01f, 4.76473093e-01f, 4.51488167e-01f, -4.79737282e-01f, -1.89547494e-01f, -1.85622826e-01f,
  3.11423659e-01f, -3.97775233e-01f, -5.84269091e-02f, -5.16706258e-02f, 4.78928030e-01f, -2.44077817e-02f, 3.10013086e-01f, -6.09452009e-01f, 4.83566016e-01f, 5.48402011e-01f,
  9.09900665e-01f, 5.55400848e-01f, -4.41008180e-01f, -5.55749178e-01f, -5.85904121e-01f, 3.20621401e-01f, 5.43383896e-01f, -7.89595768e-03f, -3.03641200e-01f, 1.87713012e-01f,
  3.53358120e-01f, -6.55266106e-01f, -4.73372370e-01f, -4.84844863e-01f, -3.55034053e-01f, -5.84040761e-01f, -1.35753587e-01f, 5.52947402e-01f, -3.06776524e-01f, 1.92263305e-01f,
  2.85902649e-01f, -1.20947853e-01f, 4.77988929e-01f, 4.16117698e-01f, -1.19307756e-01f, 1.04384296e-01f, -3.79223228e-01f, 2.42671549e-01f, -7.73717105e-01f, 4.26447511e-01f,
  -5.05949080e-01f, -2.32304037e-01f, -4.73150969e-01f, 2.04611957e-01f, -2.10824013e-01f, 1.91710204e-01f, 2.17529893e-01f, -1.90261811e-01f, -5.79932749e-01f, -5.14694452e-01f,
  3.96418929e-01f, -2.55657583e-01f, 4.20836419e-01f, -6.48554683e-01f, 8.18081871e-02f, 2.05160290e-01f, -9.61015224e-01f, -9.10624206e-01f, 2.60680169e-01f, -4.54718977e-01f,
  -5.85078299e-01f, 4.86211032e-02f, -3.61400217e-01f, -1.18878081e-01f, -2.19521359e-01f, -3.65234822e-01f, -2.99605757e-01f, -2.93355376e-01f, -3.89344573e-01f, -1.57312766e-01f,
  1.78730279e-01f, -1.49943352e-01f, 1.29493356e-01f, 2.58915097e-01f, 5.39410532e-01f, 1.07714131e-01f, -2.18244046e-01f, 9.59913731e-02f, -4.33044493e-01f, 6.08684272e-02f,
  2.68906116e-01f, -8.01589847e-01f, -2.14156769e-02f, -4.37146693e-01f, 2.56784827e-01f, -1.24132857e-01f, -8.30758095e-01f, 3.10985357e-01f, 6.33094311e-02f, 3.27201456e-01f,
  5.21991730e-01f, -4.70376462e-01f, -6.57854259e-01f, -2.11293269e-02f, 9.92126092e-02f, -1.19436560e-02f, -4.54874635e-01f, 1.65154979e-01f, -1.46899477e-01f, 3.46654981e-01f,
  4.43482362e-02f, -2.02388063e-01f, 5.02598047e-01f, 3.67395878e-01f, 7.77976811e-02f, -2.79689431e-01f, -1.16296768e-01f, -6.94864333e-01f, 3.63719106e-01f, 4.22749341e-01f,
  -3.07314456e-01f, 1.50982618e-01f, 2.74375319e-01f, 4.08065736e-01f, -7.35479593e-01f, -1.46041322e-03f, 4.98959064e-01f, -6.11102045e-01f, 3.93434495e-01f, -8.80169198e-02f,
  -7.29215801e-01f, -4.89043027e-01f, -8.14578652e-01f, -6.89856827e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.06699129e-02f, 2.33665645e-01f, 1.77511111e-01f, -1.11581586e-01f, -1.14646917e-02f, 3.09505407e-02f, -9.62056071e-02f, 1.50670102e-02f, -2.09582578e-02f, 8.86373371e-02f,
  -2.59073168e-01f, -1.54344469e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    