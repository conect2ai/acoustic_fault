/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.00584090e-01f, 2.70227104e-01f, -1.61561593e-01f, 4.62001450e-02f, -1.45474389e-01f, -8.35225638e-03f, -1.20130733e-01f, 1.43009737e-01f, 1.42141849e-01f, 1.37524366e-01f,
  -5.09741679e-02f, -1.68236271e-02f, 3.51852514e-02f, -6.21158890e-02f, -1.30932778e-01f, 8.83592144e-02f, 8.56320281e-03f, 4.79341224e-02f, -1.43371271e-02f, 9.61921290e-02f,
  1.28203919e-02f, -3.33585814e-02f, -6.14946187e-02f, 1.99791975e-02f, -3.72653380e-02f, -4.83696945e-02f, 5.34451893e-03f, -5.65409325e-02f, -1.51560688e-02f, -9.40308869e-02f,
  2.44294037e-03f, 1.01228140e-01f, -7.59690404e-02f, 3.96284498e-02f, 6.61587045e-02f, -3.51656005e-02f, 6.88064769e-02f, -1.56429991e-01f, -3.99169810e-02f, -2.19710488e-02f,
  6.63376739e-03f, -4.94247712e-02f, -5.87743744e-02f, -1.03401318e-01f, 3.99269164e-03f, -1.50262918e-02f, -1.68917160e-02f, 4.77056354e-02f, -8.89689848e-03f, -5.43438792e-02f,
  3.35712992e-02f, 4.02729064e-02f, -2.33737100e-02f, -1.45031009e-02f, -7.14004412e-02f, 4.73620631e-02f, -1.31099656e-01f, -3.64085920e-02f, 4.58918558e-03f, -2.88363975e-02f,
  7.22620413e-02f, -2.38551553e-02f, 4.37134737e-03f, -1.00540472e-02f, 3.34748812e-02f, -1.54364491e-02f, 1.13277715e-02f, 2.51510590e-02f, -5.84134795e-02f, 4.55209464e-02f,
  5.24800457e-02f, 7.19997333e-03f, 3.57157700e-02f, -4.06776294e-02f, -1.56233944e-02f, 5.38589843e-02f, -3.91904004e-02f, -3.45672928e-02f, -3.94833460e-03f, 2.79976148e-02f,
  1.88336801e-02f, -2.38984241e-03f, 6.59887046e-02f, -2.09289845e-02f, -5.05827330e-02f, -6.51990762e-03f, 1.04953898e-02f, -4.05268557e-02f, 6.13986002e-03f, -5.52434623e-02f,
  2.23352596e-01f, 3.47546726e-01f, 6.70349896e-02f, 2.05657370e-02f, -2.00948175e-02f, -3.08624264e-02f, 8.55159108e-03f, 3.43756266e-02f, 5.38673019e-03f, -6.23486424e-03f,
  -3.92350331e-02f, -1.57467334e-03f, 4.91721295e-02f, -3.14514362e-03f, 1.20786559e-02f, 4.95822020e-02f, -1.02662491e-02f, 5.53897433e-02f, 1.67097691e-02f, 2.35282853e-02f,
  2.47407258e-02f, 2.43725628e-02f, -4.28345390e-02f, -1.89517736e-02f, 6.87085837e-02f, -4.73313704e-02f, 2.93648802e-02f, 1.36176609e-02f, -3.74980904e-02f, -1.02028504e-01f,
  -3.45712334e-01f, -2.15535715e-01f, 8.85676742e-02f, -1.18103936e-01f, 2.08944455e-02f, -6.86133280e-02f, -9.21792444e-03f, 1.06316041e-02f, -2.34549031e-01f, -8.34299177e-02f,
  -1.96522009e-02f, -1.67791814e-01f, -1.43200876e-02f, -1.67484656e-01f, -5.09588234e-02f, -1.55798376e-01f, -1.18804798e-01f, -5.88739030e-02f, -3.11103575e-02f, -8.10628198e-03f,
  7.05713630e-02f, -7.95339271e-02f, 7.09678903e-02f, 5.49965426e-02f, 2.60003991e-02f, 6.58760071e-02f, 7.36581068e-03f, 1.51425183e-01f, -5.07424548e-02f, -5.80259375e-02f,
  -7.13725984e-02f, -6.46159872e-02f, 4.90721948e-02f, 1.22572146e-02f, -9.51078236e-02f, 2.99829338e-02f, 7.35155717e-02f, 9.53271091e-02f, -3.11611011e-03f, -1.96185485e-02f,
  9.42525361e-03f, 6.30618706e-02f, 3.58865298e-02f, -2.28460226e-02f, -4.19059768e-03f, 4.69403639e-02f, -2.36518844e-03f, -5.40709831e-02f, 1.83065999e-02f, 3.55877131e-02f,
  1.25110418e-01f, 7.52214789e-02f, 1.12687699e-01f, -1.55406222e-02f, 9.27634537e-02f, 9.44887921e-02f, 9.07566920e-02f, 9.65948328e-02f, -6.55988008e-02f, -2.22743154e-02f,
  -5.11483997e-02f, 2.18027029e-02f, 2.07344107e-02f, -7.13080913e-02f, -3.79497334e-02f, 8.15768819e-03f, 4.57511432e-02f, 2.19900198e-02f, 6.68963045e-03f, -2.73107439e-02f,
  -5.28688766e-02f, -5.53079124e-04f, -5.21824248e-02f, 1.16922803e-01f, -2.02268455e-02f, 7.77005330e-02f, 6.26232028e-02f, -6.91241072e-03f, 1.52746774e-03f, 4.44033444e-02f,
  5.27502503e-03f, -1.02113737e-02f, 1.14947632e-02f, -2.64344122e-02f, 7.18452036e-03f, 4.14118730e-02f, 1.27241109e-02f, -4.29924857e-03f, 2.03471109e-02f, 9.65006649e-04f,
  -5.04167788e-02f, 9.96782258e-03f, -1.81775112e-02f, 4.84127272e-03f, 7.09430361e-03f, -6.50352836e-02f, -6.25329912e-02f, -5.38041517e-02f, 1.06339656e-01f, -7.89089054e-02f,
  4.68300618e-02f, 6.97005764e-02f, 2.76031103e-02f, -3.33658159e-02f, 7.87974428e-03f, -1.80308819e-02f, 4.98569831e-02f, -2.70502251e-02f, 4.40186150e-02f, 5.45967482e-02f,
  5.51377423e-02f, -8.60268325e-02f, 3.42340209e-02f, 5.27570909e-03f, 6.41901270e-02f, -3.47413793e-02f, 2.24175453e-02f, -5.62802481e-04f, -1.10236201e-02f, 3.11628450e-03f,
  1.50054961e-01f, 1.46027744e-01f, 1.62631735e-01f, -1.07207254e-01f, 9.95642468e-02f, -7.39210099e-03f, 1.07286051e-01f, -2.09728945e-02f, 3.55546564e-01f, -1.45121276e-01f,
  -6.06708266e-02f, -6.42688870e-02f, 5.56831360e-02f, -1.29132316e-01f, -1.02448419e-01f, 6.42355531e-02f, -8.66981372e-02f, -1.84949189e-02f, 1.76484421e-01f, -8.69482085e-02f,
  4.52474738e-03f, -2.88129538e-01f, -1.55854583e-01f, -5.60818352e-02f, -4.16952260e-02f, -6.76179156e-02f, -2.26559654e-01f, -2.27596629e-02f, -1.23990461e-01f, -9.22460016e-03f,
  -5.49387001e-02f, -3.91483009e-02f, 4.49013859e-02f, 3.88422944e-02f, -8.01928192e-02f, -2.50193551e-02f, -7.23358840e-02f, 5.35102971e-02f, 3.65573727e-02f, 4.66254242e-02f,
  8.51663873e-02f, -7.62782097e-02f, -1.47236930e-02f, 3.07206046e-02f, 8.26159716e-02f, 2.91363336e-02f, 1.36231733e-02f, -1.79426428e-02f, 1.00574093e-02f, -1.66720562e-02f,
  -8.06478560e-02f, -3.14219669e-02f, 9.96856135e-04f, 3.20088555e-04f, 4.87566069e-02f, 5.12316078e-02f, -1.57206121e-03f, -7.16094896e-02f, -9.64861140e-02f, 3.80130000e-02f,
  9.99373123e-02f, 1.30051523e-01f, -5.47642596e-02f, -4.16652821e-02f, -4.30112854e-02f, -8.60239714e-02f, -1.35740023e-02f, -8.89216810e-02f, -3.72963026e-03f, -6.30407706e-02f,
  -9.50000584e-02f, -6.50436804e-02f, 7.98701271e-02f, 6.50600865e-02f, -2.29575783e-02f, -7.23709390e-02f, 5.69014391e-03f, -4.33417968e-02f, 2.69958545e-02f, -5.85551895e-02f,
  1.43187614e-02f, -1.89229455e-02f, -7.73002058e-02f, 8.16154946e-03f, -3.50911394e-02f, 4.35744645e-03f, 7.16201775e-03f, -5.12294807e-02f, -3.51109318e-02f, -3.24387960e-02f,
  -2.38824055e-01f, -1.65539727e-01f, 2.38205437e-02f, -2.72203069e-02f, -1.62542872e-02f, 1.10608407e-05f, 1.46390945e-01f, -3.83487791e-02f, -4.66602407e-02f, -3.17976065e-02f,
  -3.94897647e-02f, -6.41584992e-02f, -3.38159949e-02f, 5.48173068e-03f, -1.95020363e-02f, 1.57789569e-02f, -3.59921232e-02f, 7.11400760e-03f, -7.86450878e-02f, -8.32480490e-02f,
  -9.47807878e-02f, 1.05579525e-01f, 5.77317690e-03f, -6.50114939e-02f, -4.40519527e-02f, 4.04533297e-02f, -6.38433620e-02f, 5.33561334e-02f, -6.38824105e-02f, -3.25689994e-04f,
  -3.32960457e-01f, 1.68980196e-01f, -1.21704400e-01f, -1.18090644e-01f, -5.72627783e-02f, -5.66932198e-04f, -1.03968360e-01f, 2.46355459e-02f, -1.09947719e-01f, 4.25541699e-02f,
  8.72711390e-02f, -1.82158858e-01f, 1.73821911e-01f, -1.38268797e-02f, 1.43154442e-01f, 3.00308987e-02f, 6.61871582e-02f, -1.31018713e-01f, 1.65031757e-03f, -3.87507938e-02f,
  2.79092193e-02f, 7.40003139e-02f, 7.99244940e-02f, 9.57501680e-02f, -1.01699695e-01f, -5.48949875e-02f, 2.01960549e-01f, 6.14158995e-02f, -7.05528334e-02f, -3.01256087e-02f,
  7.97232706e-03f, -1.73066899e-01f, -7.13459495e-03f, 4.07341197e-02f, 3.55228074e-02f, -2.84289774e-02f, -4.23962437e-03f, 1.75267365e-02f, -2.91310344e-02f, 2.19530356e-03f,
  4.21247520e-02f, 2.90827677e-02f, -7.09707513e-02f, -4.34491187e-02f, -3.23791876e-02f, -4.52402830e-02f, -3.25164944e-02f, 6.38266047e-03f, -2.75222380e-02f, -3.80813070e-02f,
  -3.24654989e-02f, -4.05973531e-02f, -8.16876348e-03f, -8.19880292e-02f, 6.53852373e-02f, -5.62323518e-02f, -8.91715139e-02f, -1.00610115e-01f, 2.36597043e-02f, -1.90349743e-02f,
  -5.83207719e-02f, 5.81577793e-02f, -9.62129757e-02f, 5.72823919e-03f, -6.40723184e-02f, 2.74915923e-03f, -3.18092704e-02f, -7.51370753e-05f, -2.93839443e-02f, 2.39133220e-02f,
  2.89041121e-02f, -4.24221493e-02f, -5.26785739e-02f, -8.19933787e-02f, 3.57091281e-04f, -1.77551508e-02f, 2.59511862e-02f, -4.75570075e-02f, 5.35689443e-02f, 5.25154080e-03f,
  -4.46719415e-02f, 6.77106611e-04f, 3.43843512e-02f, -5.18934578e-02f, 4.47485186e-02f, -5.01844771e-02f, 4.07392718e-02f, -9.87311602e-02f, 4.20738868e-02f, -1.39737995e-02f,
  3.71904999e-01f, 2.03420788e-01f, 1.29270390e-01f, 3.89007814e-02f, 1.04951926e-01f, 1.03941426e-01f, 6.67087547e-03f, -6.16122782e-02f, 7.23702833e-02f, 5.38726663e-03f,
  6.30780533e-02f, 5.66496002e-03f, -1.18299415e-02f, -9.21392962e-02f, 3.92902456e-02f, -2.05427930e-02f, 2.01686304e-02f, 3.97080295e-02f, 1.01721406e-01f, 4.87782918e-02f,
  3.87738384e-02f, -1.50043201e-02f, -4.88796122e-02f, -1.57362893e-02f, 2.85734423e-02f, 1.00221336e-02f, -4.09862027e-02f, -1.97538566e-02f, -6.83441292e-03f, 5.81106171e-02f,
  -1.38683170e-01f, -1.92548230e-01f, -2.61326343e-01f, -1.68082211e-03f, 8.55305642e-02f, -3.11831832e-01f, -1.73298717e-01f, -6.03519417e-02f, -1.05594911e-01f, -1.44044384e-01f,
  6.20396696e-02f, 1.37304068e-02f, -8.69677886e-02f, -8.47818404e-02f, -7.43814558e-02f, -2.25009881e-02f, -1.08432695e-01f, -1.13267498e-02f, 6.59581572e-02f, -1.07603312e-01f,
  -5.01312837e-02f, 4.54541743e-02f, -1.31188214e-01f, -6.50375783e-02f, -1.31700635e-01f, -2.15456206e-02f, 9.59939659e-02f, -8.23482350e-02f, 1.14488505e-01f, -2.24998184e-02f,
  -8.84774700e-02f, -9.09242779e-02f, 8.41907933e-02f, -2.74333246e-02f, -5.17277755e-02f, -3.11648706e-03f, -1.03634410e-01f, 2.84912232e-02f, -2.02694256e-02f, 1.04073295e-02f,
  -2.62976717e-02f, -7.01880679e-02f, 2.99824728e-03f, -3.82235460e-02f, -9.67257991e-02f, -3.44623700e-02f, 2.34713946e-02f, 3.44106890e-02f, -4.06518467e-02f, -7.43214339e-02f,
  -1.31138461e-03f, 2.99042910e-02f, -5.45183867e-02f, -4.32629837e-03f, 3.65835591e-03f, 3.28494310e-02f, 5.09399921e-02f, 9.00967792e-03f, -5.78916818e-02f, -3.30783464e-02f,
  9.40651745e-02f, 2.68786419e-02f, -1.46016199e-02f, 2.84791142e-02f, 6.75297668e-03f, 1.19737945e-02f, -4.18936498e-02f, 9.35091823e-02f, -5.00071757e-02f, -9.90729779e-03f,
  -2.52798945e-02f, 2.43330877e-02f, 4.31116931e-02f, -4.57227081e-02f, 5.07685393e-02f, -1.09404391e-02f, -8.66401754e-03f, -6.77168649e-03f, 4.03543264e-02f, 4.83349301e-02f,
  -5.08337021e-02f, -3.91230434e-02f, -2.33734082e-02f, -5.75286932e-02f, 3.09248688e-04f, -4.39298637e-02f, -5.83869368e-02f, -1.37302086e-01f, -1.44777750e-03f, 1.47037336e-03f,
  -3.03965181e-01f, -2.07961932e-01f, -6.67384500e-03f, -3.08011891e-03f, 6.26746938e-02f, 4.79800366e-02f, 3.14544141e-02f, 1.77160185e-02f, -8.81806016e-03f, 4.48482670e-02f,
  -7.21665993e-02f, -1.43099176e-02f, -8.10645372e-02f, -1.50527731e-02f, -6.16778480e-03f, 4.30482291e-02f, 2.69445088e-02f, -3.91444936e-03f, 1.56444721e-02f, 1.00453366e-02f,
  -3.57800350e-02f, 4.22610492e-02f, 7.69824609e-02f, -7.14946091e-02f, 6.38587587e-03f, 4.44899499e-02f, 1.12616853e-03f, -1.22986529e-02f, 8.52047503e-02f, -1.38317992e-03f,
  3.48146826e-01f, 5.66945970e-02f, 1.80810243e-01f, 2.52718776e-01f, -2.15728041e-02f, -1.99090853e-01f, -1.28844470e-01f, 5.73506253e-03f, 1.56164140e-01f, -1.18643217e-01f,
  -2.23137857e-03f, 1.22273244e-01f, -1.66427493e-02f, 6.90459535e-02f, -1.77184418e-02f, -1.16002839e-02f, -2.10847445e-02f, 4.32252176e-02f, 8.88208896e-02f, 8.35172459e-02f,
  2.73066610e-02f, -5.79281058e-03f, 9.18693170e-02f, -3.07570063e-02f, 4.47302535e-02f, 1.10993065e-01f, -1.35517046e-01f, -1.37754679e-01f, 6.89715371e-02f, -4.90992516e-02f,
  3.54409106e-02f, 1.96216092e-01f, 8.63382891e-02f, 2.90162116e-02f, -1.61719322e-02f, 5.57743420e-04f, 3.37578952e-02f, 4.35749553e-02f, 1.66240241e-02f, -4.31318320e-02f,
  -5.46266772e-02f, 1.61066875e-02f, -6.03896938e-03f, -9.10892934e-02f, 4.23299987e-03f, -1.64290436e-03f, 3.07291076e-02f, 4.25851122e-02f, 4.79224510e-02f, 3.71328071e-02f,
  1.02409692e-02f, 2.64876373e-02f, -4.59703580e-02f, 3.73333357e-02f, 3.23186889e-02f, 6.49840087e-02f, -3.06381006e-02f, 5.01852222e-02f, 6.75214753e-02f, 1.10779181e-02f,
  5.03777415e-02f, -1.46782948e-02f, 8.08968302e-03f, -6.14015758e-02f, -5.13805682e-03f, -4.08981256e-02f, -5.51889949e-02f, -6.74025267e-02f, -6.20835535e-02f, -8.35077465e-02f,
  1.05131427e-02f, -5.98216848e-03f, -4.00229357e-02f, -8.22924450e-03f, -6.10845312e-02f, 1.09118996e-02f, -4.84867990e-02f, 3.21508832e-02f, 9.41998959e-02f, -6.46304637e-02f,
  -3.46138887e-03f, 2.56541576e-02f, -3.01843807e-02f, -4.95949201e-02f, -4.64959070e-02f, -1.71557479e-02f, 2.94313990e-02f, -2.87292562e-02f, -3.20829563e-02f, 4.59614908e-03f,
  -2.23870024e-01f, -6.13307580e-03f, -4.37205881e-02f, -3.78368646e-02f, -8.07310417e-02f, -8.76883715e-02f, 2.63011120e-02f, 2.00378825e-03f, -3.98964882e-02f, -5.38832657e-02f,
  6.87629804e-02f, -5.14091253e-02f, -3.03905290e-02f, -7.63033424e-03f, 1.20060844e-02f, -7.67606497e-02f, -2.07588915e-02f, 1.55159561e-02f, -3.01162302e-02f, 1.90655864e-03f,
  -7.26673082e-02f, -1.52885998e-02f, 4.54552472e-02f, 5.70673943e-02f, -4.43149582e-02f, -2.23726351e-02f, 1.05033368e-01f, 2.04569045e-02f, -6.47248402e-02f, 1.55889485e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.03953278e-01f, -1.42572913e-02f, -2.87111789e-01f, -1.06388770e-01f, -2.22927690e-01f, -3.80186647e-01f, -1.52691007e-01f, -2.65767753e-01f, 5.38181253e-02f, 2.28147790e-01f,
  1.35849044e-01f, -2.09275737e-01f, 1.83659330e-01f, 5.64822741e-02f, -1.78211629e-01f, 2.52051026e-01f, 2.57080831e-02f, 3.08286548e-02f, 5.16235782e-03f, -1.51121438e-01f,
  -2.43122298e-02f, -6.00675994e-04f, 2.18966734e-02f, -1.48677910e-02f, -1.83192834e-01f, -5.28579541e-02f, 1.40823245e-01f, -2.00790569e-01f, -7.97219016e-03f, -1.70137793e-01f,
  -3.26663762e-01f, -1.65740773e-01f, -1.10455632e-01f, -8.86961818e-02f, -1.13202348e-01f, -6.93951994e-02f, 3.29936706e-02f, -1.05813570e-01f, -4.25397009e-02f, -9.10855234e-02f,
  -6.30534962e-02f, -8.82687867e-02f, -3.13975778e-03f, -1.54148256e-02f, 2.32257531e-03f, -6.20923601e-02f, -8.66289511e-02f, 6.19967245e-02f, -7.37090483e-02f, -7.18332604e-02f,
  -3.57728787e-02f, -3.97032797e-02f, 6.03538081e-02f, 1.15895256e-01f, -6.57358021e-02f, 3.59175503e-02f, 6.64228946e-02f, -2.17570085e-02f, -1.66840386e-02f, -6.73447624e-02f,
  1.06482534e-02f, 6.13668412e-02f, 4.95419577e-02f, 2.55161356e-02f, -7.20788613e-02f, 9.20631737e-02f, -5.01103960e-02f, -1.72804222e-02f, -4.26387377e-02f, 3.91795784e-02f,
  -7.08397254e-02f, -5.05755469e-02f, -5.48301302e-02f, 3.32458951e-02f, 2.06325931e-04f, 1.44917611e-02f, 4.54085991e-02f, -4.13307883e-02f, -6.72187656e-02f, 5.84550127e-02f,
  1.07691088e-03f, -3.33309658e-02f, 8.32886696e-02f, 1.33958384e-01f, -7.22117573e-02f, 3.77915166e-02f, 1.62187242e-03f, 6.86550289e-02f, 5.54180741e-02f, -9.05551165e-02f,
  -3.11892539e-01f, -2.11817741e-01f, -2.24893005e-03f, -7.84292519e-02f, 8.40913784e-03f, -5.12989908e-02f, -1.00802295e-02f, 1.80741232e-02f, -6.61093369e-02f, -1.03931926e-01f,
  -5.61261438e-02f, 4.96193767e-02f, -9.56532732e-02f, 2.93163881e-02f, -1.75648406e-02f, 5.19309863e-02f, -6.11554906e-02f, 2.73217950e-02f, -3.97398658e-02f, -5.33079952e-02f,
  2.41070036e-02f, -2.63127796e-02f, 3.08703668e-02f, 9.52242594e-03f, 3.93003002e-02f, 6.18823571e-03f, -4.39733192e-02f, 5.17192408e-02f, -8.29154439e-03f, 5.59577532e-03f,
  -3.50867808e-01f, -2.12856546e-01f, 3.72923017e-01f, -2.68943101e-01f, -7.22959191e-02f, 2.92946845e-01f, 2.15376258e-01f, 2.95565166e-02f, -1.75322220e-01f, -3.04764718e-01f,
  -3.27135056e-01f, 6.61369190e-02f, 3.04561794e-01f, -2.55169362e-01f, 5.55268347e-01f, 2.51794308e-01f, -7.81515092e-02f, -1.61181554e-01f, 6.24302328e-02f, -1.77139893e-01f,
  -5.33933491e-02f, -2.50937194e-01f, 3.33465010e-01f, -2.70953774e-01f, -2.55873531e-01f, -2.48866364e-01f, -1.82791911e-02f, 8.58682673e-03f, -2.87162662e-01f, 8.96259621e-02f,
  -3.47171992e-01f, -1.55669644e-01f, -1.21813037e-01f, 1.33748492e-02f, -6.23414256e-02f, -1.16800964e-01f, 1.03351764e-01f, 1.05815843e-01f, -3.97749096e-02f, -3.80270509e-03f,
  -1.26458304e-02f, -4.96093510e-03f, -7.97600597e-02f, -9.32044629e-03f, -4.80130687e-02f, -1.15543995e-02f, 1.86524298e-02f, -8.22352096e-02f, -4.52401116e-02f, 9.33545977e-02f,
  1.07057013e-01f, -4.04124521e-02f, 1.88960880e-02f, 4.18119319e-02f, 7.00867847e-02f, -5.65516166e-02f, 1.55333370e-01f, 2.24774078e-01f, 3.69641744e-02f, -9.16505903e-02f,
  5.68758436e-02f, 5.39323725e-02f, -3.62701192e-02f, -1.50004923e-01f, 1.99736003e-02f, -2.03340158e-01f, -4.37860424e-03f, 1.10246792e-01f, -5.64258993e-02f, 2.41169315e-02f,
  -4.58437577e-02f, 1.29609322e-02f, -7.00510591e-02f, -5.37806489e-02f, -7.08267763e-02f, -4.66111936e-02f, 2.20164489e-02f, -6.29125386e-02f, -1.08149134e-01f, -8.75415802e-02f,
  -3.51517275e-02f, 5.43640926e-02f, 3.04095298e-02f, -3.00567113e-02f, 1.07429642e-02f, 1.01202078e-01f, -9.97935012e-02f, 2.09958740e-02f, 1.59379281e-02f, 1.32379621e-01f,
  -2.31421024e-01f, -1.91472292e-01f, -4.66081761e-02f, -1.54431731e-01f, -8.48612785e-02f, 2.31650043e-02f, 5.07511348e-02f, -4.38989252e-02f, -3.40811996e-04f, 8.29374418e-02f,
  4.92646731e-03f, -7.85188451e-02f, 7.88569227e-02f, -1.09193579e-03f, -1.42619917e-02f, -6.58285990e-02f, -4.43307310e-02f, -7.35883862e-02f, 3.35961697e-03f, -5.47671467e-02f,
  -5.71994372e-02f, -4.81476337e-02f, -6.74015610e-03f, -3.33714522e-02f, -6.52097613e-02f, -3.31788547e-02f, -3.37075032e-02f, -3.91567089e-02f, -1.86319556e-02f, 1.29405223e-02f,
  4.74352330e-01f, 1.36810407e-01f, 3.09379622e-02f, 4.13993061e-01f, 8.99203122e-02f, -1.90686390e-01f, 6.49649128e-02f, 2.84300178e-01f, 3.75998110e-01f, -1.68135658e-01f,
  2.32044198e-02f, 7.54902363e-02f, -1.14896856e-01f, 1.86143190e-01f, 3.21134329e-01f, -1.79295018e-01f, 3.47481370e-01f, -1.10343978e-01f, 1.44065008e-01f, 1.73063233e-01f,
  2.66056299e-01f, 1.61624283e-01f, 4.65146229e-02f, -2.16091238e-02f, 7.40935281e-02f, 1.07115053e-01f, 9.18094739e-02f, -2.28282988e-01f, -6.31234497e-02f, -1.40073583e-01f,
  -2.24606553e-03f, 5.25896028e-02f, 6.87210783e-02f, -6.41274303e-02f, 8.69216993e-02f, -2.81580612e-02f, -7.79275000e-02f, -8.00067335e-02f, 1.39690503e-01f, 9.33892000e-03f,
  -3.75073031e-03f, 4.64087725e-03f, 8.27720389e-02f, -4.15547825e-02f, 1.47254825e-01f, 2.26222724e-02f, -1.73049457e-02f, 6.76601902e-02f, 9.00730193e-02f, 4.54138182e-02f,
  1.47652119e-01f, -7.70704374e-02f, 1.51844710e-01f, 7.95193948e-03f, 5.91307431e-02f, 7.18601234e-03f, -4.81430301e-03f, -7.58248046e-02f, -7.75699541e-02f, 1.71965256e-01f,
  7.36699924e-02f, -1.02073096e-01f, -1.39392242e-01f, -6.33073896e-02f, -2.11823476e-03f, 4.85506356e-02f, 1.37372196e-01f, 4.50328104e-02f, -4.20924611e-02f, 3.65968444e-03f,
  6.50995672e-02f, -4.46842499e-02f, -2.63912361e-02f, -1.01849973e-01f, 3.14332768e-02f, 4.92513999e-02f, -1.33593036e-02f, -2.30823666e-01f, -1.68152750e-02f, 1.07217848e-01f,
  -2.38003246e-02f, 6.69110715e-02f, -2.56707799e-02f, -5.52980080e-02f, -7.61748012e-03f, -8.98462683e-02f, -7.89498314e-02f, 1.32830562e-02f, 8.23481679e-02f, 3.44450735e-02f,
  7.47534819e-03f, 1.61337197e-01f, 4.14297543e-02f, 2.36371979e-02f, -2.84006912e-02f, 5.07914014e-02f, 6.31269664e-02f, 8.06755573e-03f, 4.82721217e-02f, 2.63906363e-02f,
  -2.74246633e-02f, 1.15807749e-01f, -9.56328399e-03f, -4.53578904e-02f, -6.14352673e-02f, 3.54939662e-02f, -9.39334854e-02f, 6.15727864e-02f, 8.75039250e-02f, -7.32731745e-02f,
  4.16460149e-02f, -1.04541169e-03f, 4.14579660e-02f, 7.32015446e-02f, 1.21622205e-01f, -3.08553241e-02f, 1.44736037e-01f, -2.50533186e-02f, -3.23011056e-02f, 8.50167125e-02f,
  6.53726608e-02f, -4.24487144e-02f, -2.87052095e-01f, -1.58104107e-01f, -1.60829678e-01f, -4.99061912e-01f, -3.79126728e-01f, -3.37227210e-02f, 1.92589447e-01f, 4.94728386e-02f,
  -1.95953593e-01f, 1.69070274e-01f, 1.14302360e-01f, -2.50906467e-01f, -3.67143080e-02f, 3.74430381e-02f, -3.80852550e-01f, -1.86543226e-01f, 4.84182127e-02f, -2.34183222e-01f,
  -1.18415035e-01f, -2.91478813e-01f, -2.69228786e-01f, -9.53140259e-02f, -3.18437934e-01f, -4.72101234e-02f, 8.80612154e-03f, -4.76424433e-02f, -2.15120956e-01f, -2.80766431e-02f,
  -5.80697097e-02f, 1.61255881e-01f, 3.17636766e-02f, -5.38212294e-03f, -7.64997378e-02f, -1.16528317e-01f, -1.72356904e-01f, 3.68295312e-02f, 1.07208174e-03f, 2.10108999e-02f,
  6.32383153e-02f, 4.53503318e-02f, 2.92413291e-02f, 1.30544081e-01f, -1.08600035e-02f, 5.65894432e-02f, -3.27191912e-02f, -1.21797193e-02f, 6.02453053e-02f, -2.15442218e-02f,
  -4.17953394e-02f, 8.31949413e-02f, -6.24115095e-02f, 7.79008716e-02f, -2.19312981e-02f, -7.40969330e-02f, -6.87436685e-02f, 3.53560187e-02f, 1.14674391e-02f, 1.41207337e-01f,
  -1.96251869e-02f, -9.82306749e-02f, 3.16934548e-02f, 4.71672858e-04f, -5.32538295e-02f, -2.19453266e-03f, 2.52424814e-02f, 4.15361114e-02f, 1.57272983e-02f, -7.42087066e-02f,
  6.06726520e-02f, -1.88158136e-02f, 2.76938695e-02f, 4.33551595e-02f, -7.95819312e-02f, 4.95515764e-02f, -5.80099858e-02f, 2.43456122e-02f, -1.00143313e-01f, -4.47079465e-02f,
  1.04355067e-01f, 3.86958607e-02f, 5.85918725e-02f, -1.44075202e-02f, 2.98718531e-02f, 3.20216827e-02f, 5.02703488e-02f, 3.60949636e-02f, 6.69459999e-02f, -9.78637710e-02f,
  -1.19174711e-01f, -6.45037461e-03f, 6.58590719e-02f, 1.50662616e-01f, -1.63861625e-02f, 7.59682730e-02f, -3.20887826e-02f, 2.84500327e-02f, 3.64413410e-02f, -4.28668559e-02f,
  2.38280613e-02f, 5.28323464e-02f, -4.18935046e-02f, 6.34486601e-02f, 9.67814922e-02f, -8.85435864e-02f, -1.03622749e-01f, 7.08304569e-02f, -4.96376455e-02f, 7.86382481e-02f,
  1.09289000e-02f, -1.51389455e-02f, 3.48489285e-02f, -4.84379902e-02f, 5.04756952e-03f, 8.29153415e-03f, -5.47738783e-02f, 3.22616957e-02f, -2.86701359e-02f, 1.55265033e-02f,
  1.42343836e-02f, 4.31027293e-01f, 1.50295302e-01f, 1.82429120e-01f, -3.05176139e-01f, 1.14993267e-01f, -1.31607465e-02f, -4.60874178e-02f, 3.43937844e-01f, 2.00546712e-01f,
  -4.21943873e-01f, 5.53927302e-01f, -1.51683256e-01f, 4.97548431e-02f, -1.52053371e-01f, 3.18400338e-02f, 1.02217957e-01f, 1.99184671e-01f, 1.35304973e-01f, -1.07656218e-01f,
  -5.90528734e-02f, -4.08413291e-01f, -2.73874462e-01f, -2.46971086e-01f, -1.74755663e-01f, 6.13301545e-02f, -2.07601920e-01f, -1.88251704e-01f, 1.63825620e-02f, -6.23024851e-02f,
  2.72752281e-04f, -5.23226187e-02f, -9.98939425e-02f, 1.24213442e-01f, -6.71805590e-02f, -5.31174317e-02f, 1.36656374e-01f, -2.39467286e-02f, -1.55825047e-02f, 7.46677071e-02f,
  1.76715329e-01f, 2.49971723e-04f, 1.13386661e-01f, -3.05344313e-02f, 2.53484827e-02f, 2.58396883e-02f, 9.01894271e-02f, -3.15479264e-02f, 4.54042628e-02f, -2.14569606e-02f,
  7.48346299e-02f, 1.33220607e-03f, -1.51109984e-02f, 2.26320084e-02f, -3.23139504e-02f, -3.96980438e-03f, 1.48161992e-01f, -6.08816296e-02f, 1.45378202e-01f, 7.18769357e-02f,
  -6.60297796e-02f, 9.30473655e-02f, -1.08354494e-01f, 8.27362388e-02f, -1.09317727e-01f, -1.43467233e-01f, -2.23783720e-02f, -1.10393174e-01f, 1.46547168e-01f, -5.96461371e-02f,
  -3.96374241e-02f, -5.56112602e-02f, -9.76320580e-02f, -5.60032129e-02f, -3.71483937e-02f, -1.73146203e-02f, 4.51551713e-02f, 6.16244227e-02f, 1.14889890e-01f, -8.48961100e-02f,
  -2.13908069e-02f, 5.01089171e-02f, 2.93902941e-02f, -7.22519383e-02f, -1.00301560e-02f, -3.59377488e-02f, 2.81732976e-02f, -9.69344692e-04f, -6.88405409e-02f, -1.25391752e-01f,
  1.70887914e-02f, 1.36479259e-01f, 9.08727124e-02f, 6.28632456e-02f, 3.09484899e-02f, -3.34209017e-02f, 4.88214940e-02f, 4.13327962e-02f, 1.63788125e-01f, 3.27388309e-02f,
  8.17200914e-02f, 4.26023081e-02f, 4.35911380e-02f, -6.84046820e-02f, 5.99740678e-03f, 8.45192149e-02f, 6.84474856e-02f, 1.05447248e-02f, 9.62669924e-02f, -2.14713570e-02f,
  -2.46180664e-03f, 1.21478878e-01f, 4.52054478e-02f, -6.13858216e-02f, 3.87240597e-03f, -2.22305320e-02f, 1.07216246e-01f, 1.79047763e-01f, -5.18922182e-03f, 6.32556155e-02f,
  2.66383618e-01f, -2.47731030e-01f, 2.56783694e-01f, 3.08809578e-01f, 3.33054662e-01f, 2.73101360e-01f, 2.65967876e-01f, 1.11451745e-01f, 3.95872474e-01f, -2.65911311e-01f,
  -5.09390980e-02f, -3.41747329e-02f, 2.39952449e-02f, -8.45303759e-02f, 1.17297284e-01f, 4.22126465e-02f, 1.76290587e-01f, 7.94976726e-02f, 1.85995311e-01f, 2.06730440e-02f,
  7.32519031e-02f, -1.85361169e-02f, -1.65041193e-01f, -2.88979083e-01f, 9.36004743e-02f, -1.52743429e-01f, -1.60425842e-01f, 9.52741802e-02f, -3.62659961e-01f, 3.05033661e-03f,
  4.90000360e-02f, 2.02716375e-03f, 9.88824014e-03f, -1.71584319e-02f, -3.32352822e-03f, -1.50065944e-01f, -1.38251126e-01f, -1.42255291e-01f, -4.66944240e-02f, 1.29995206e-02f,
  -1.40881628e-01f, -1.16009638e-01f, 2.41708774e-02f, -9.48660225e-02f, 1.66734997e-02f, -1.51327625e-01f, -1.01704346e-02f, -1.48162376e-02f, -1.07280076e-01f, -7.95883909e-02f,
  -7.31197894e-02f, 3.16050686e-02f, 8.98039434e-03f, -1.41906232e-01f, -1.45811271e-02f, 5.67105934e-02f, -5.17968200e-02f, 1.43730212e-02f, 4.85821553e-02f, 4.57083061e-02f,
  -7.19716549e-02f, 2.54439116e-02f, 2.93089636e-02f, 1.02265435e-03f, -4.30014171e-02f, 1.48937451e-02f, -6.14750274e-02f, 7.61544034e-02f, 6.34654686e-02f, 1.15242831e-01f,
  8.66391286e-02f, 8.66796002e-02f, 5.89414015e-02f, 1.66465759e-01f, 1.47947118e-01f, 2.10291650e-02f, 3.11891437e-02f, -2.07785796e-02f, -4.17250721e-03f, 8.03037956e-02f,
  4.72717583e-02f, -2.87350174e-03f, 1.27211556e-01f, 4.60898206e-02f, -2.74442732e-02f, 1.09302690e-02f, -1.12258615e-02f, 2.38994956e-02f, 1.27357403e-02f, 1.00129889e-02f,
  9.68573838e-02f, 8.54725838e-02f, 3.62955667e-02f, -3.95130850e-02f, 4.47840989e-02f, 9.95897129e-03f, 1.07478552e-01f, 7.97666833e-02f, 9.56460014e-02f, -5.96763715e-02f,
  -3.53039093e-02f, 9.54652578e-02f, 3.50887887e-02f, -4.80498858e-02f, 2.43896805e-02f, 5.25497608e-02f, -1.24338241e-02f, -3.95635003e-03f, -8.05352852e-02f, -4.89173122e-02f,
  -6.29382730e-02f, 1.58237126e-02f, -5.83472603e-04f, -1.12666637e-01f, -1.22250624e-01f, -1.05031319e-01f, -8.74345750e-02f, 3.08008604e-02f, 1.79711655e-02f, -9.80914291e-03f,
  8.14895779e-02f, 4.96455990e-02f, -1.69287041e-01f, -2.52081007e-01f, -3.38543355e-01f, 1.55020699e-01f, -4.74081421e-03f, -1.71855316e-01f, -1.97347224e-01f, 7.95542374e-02f,
  -2.43462071e-01f, -2.20096093e-02f, 1.72921330e-01f, 1.28565580e-02f, 2.51445115e-01f, 4.24873471e-01f, 4.16474827e-02f, 1.22535853e-02f, 4.89818454e-02f, -2.40862798e-02f,
  2.20227595e-02f, 3.17051783e-02f, 7.50583559e-02f, -8.80332142e-02f, -1.15456812e-01f, -1.20581567e-01f, -2.22378388e-01f, -1.16526313e-01f, -1.79885387e-01f, -1.10528141e-01f,
  8.66125748e-02f, 6.10433184e-02f, -5.44326380e-03f, 6.89536035e-02f, 4.20351401e-02f, -1.05648469e-02f, -5.95064834e-02f, 9.94085670e-02f, -9.06588957e-02f, 3.91909182e-02f,
  -5.28797098e-02f, 6.42613471e-02f, -9.35942307e-02f, 3.45082139e-03f, -6.45951703e-02f, -1.00222446e-01f, -3.83773483e-02f, -6.21753521e-02f, 8.01007524e-02f, -2.37584207e-02f,
  -2.53010783e-02f, -4.35821898e-02f, -9.41443443e-02f, 4.09975909e-02f, -1.83736518e-01f, -1.61083173e-02f, 3.74769792e-02f, -6.15906678e-02f, 9.52409580e-03f, 6.02561124e-02f,
  -8.89978781e-02f, 9.49256569e-02f, 1.07345581e-01f, -4.67174463e-02f, 6.33117333e-02f, 8.75435583e-03f, 1.10623369e-04f, -7.39235431e-02f, -9.43792537e-02f, -4.63716127e-02f,
  -8.61236379e-02f, -3.29189450e-02f, 4.19877581e-02f, -7.04404712e-02f, 1.29470423e-01f, -1.12997498e-02f, -5.31630814e-02f, -1.89023148e-02f, -4.13545892e-02f, 8.93899500e-02f,
  -6.72358423e-02f, 9.82353017e-02f, -3.41684967e-02f, 1.29060005e-03f, -7.59629160e-02f, -6.06614910e-02f, -1.34039730e-01f, 4.58636507e-02f, 2.96211634e-02f, 9.18276608e-02f,
  1.22077189e-01f, 7.65808150e-02f, -7.03658536e-03f, -2.58762874e-02f, 1.24959528e-01f, 4.71750535e-02f, -3.34215052e-02f, 2.36082338e-02f, -4.89037707e-02f, -2.77828500e-02f,
  -3.83833162e-02f, -9.50109214e-03f, -6.86946362e-02f, -1.84417386e-02f, -1.11555189e-01f, -3.91155444e-02f, -8.74460638e-02f, 3.51936370e-02f, -8.53457898e-02f, -1.03740608e-02f,
  -6.54600188e-02f, 4.54623699e-02f, 9.46057811e-02f, -1.11579038e-01f, -6.70517981e-03f, -4.08027433e-02f, -2.29053739e-02f, -3.60943517e-03f, -5.93683198e-02f, -7.96691328e-02f,
  -7.12810755e-02f, -6.32138476e-02f, -1.81698427e-01f, -1.48588613e-01f, -3.72593030e-02f, -3.58401954e-01f, -3.25230360e-01f, -3.15534100e-02f, 9.73845348e-02f, 2.76264306e-02f,
  -2.02140808e-01f, -7.04634190e-02f, 9.51987654e-02f, -1.82056889e-01f, -6.81577250e-02f, 2.03250915e-01f, -3.80131304e-01f, -6.66753426e-02f, 9.71062034e-02f, -1.92524791e-01f,
  9.34969708e-02f, -1.05775520e-01f, -1.79893926e-01f, 2.93684229e-02f, -2.29485288e-01f, 2.56436542e-02f, 1.00031525e-01f, -1.87422976e-01f, -1.63262993e-01f, -2.49891765e-02f,
  -1.81579590e-01f, -6.09908812e-02f, -8.23061690e-02f, -5.34998327e-02f, -2.56245941e-01f, -3.56178284e-02f, -6.57980442e-02f, -1.59021821e-02f, 3.57084647e-02f, 3.99956480e-02f,
  -5.20037562e-02f, 4.90151420e-02f, -3.05086337e-02f, -6.65407348e-03f, -3.91470529e-02f, -9.83890146e-02f, 2.46452726e-02f, -1.15640476e-01f, -1.94624722e-01f, 8.58571157e-02f,
  -1.58842385e-01f, -1.29919082e-01f, -6.36075586e-02f, 1.02445427e-02f, -4.24555317e-02f, -1.32676214e-01f, -4.49309051e-02f, 7.02580884e-02f, -1.70558572e-01f, -5.60119487e-02f,
  -6.74917400e-02f, -1.84006477e-03f, -4.51596044e-02f, 8.68817493e-02f, -3.17037441e-02f, -9.45886895e-02f, -2.60699391e-02f, 2.47505493e-02f, -4.40998301e-02f, -2.83369515e-02f,
  -3.86431366e-02f, 5.76507449e-02f, 1.80018321e-02f, -9.30735692e-02f, -3.05132437e-02f, -3.85161899e-02f, -1.65274646e-02f, -3.37807089e-03f, 1.12349443e-01f, 1.07868366e-01f,
  -5.14641963e-02f, -4.80577126e-02f, -1.88033143e-03f, -6.33133203e-02f, -1.10666223e-01f, -2.67206095e-02f, -8.06103796e-02f, -8.25137645e-02f, -1.21049441e-01f, 7.21378997e-02f,
  -1.87677696e-01f, 1.09772617e-02f, -3.30879986e-02f, 1.59241464e-02f, 1.19762696e-01f, -1.13860428e-01f, 7.88230076e-02f, -6.94150571e-03f, 8.51953328e-02f, -6.31083697e-02f,
  7.44448742e-03f, 5.18121086e-02f, 3.94576490e-02f, 8.18786863e-03f, 3.78242172e-02f, -1.09099790e-01f, -2.16968860e-02f, -3.05803418e-02f, -5.91278188e-02f, 1.70337688e-02f,
  4.24342928e-03f, 5.06113544e-02f, 1.32012323e-01f, 3.84218507e-02f, -4.96059544e-02f, 5.80124743e-02f, 9.12695453e-02f, -8.36198777e-02f, 8.10223911e-03f, -5.77931516e-02f,
  -1.09281177e-02f, 3.03414524e-01f, -4.82028797e-02f, -2.38795765e-03f, -4.59902622e-02f, 4.69833553e-01f, 4.42845941e-01f, 1.57367676e-01f, 1.59673452e-01f, 4.42109048e-01f,
  2.58361697e-01f, -6.22375309e-02f, 1.91585809e-01f, 3.78101617e-01f, 1.38450384e-01f, 1.72971383e-01f, 2.48483658e-01f, 2.04393134e-01f, -2.31756195e-01f, 1.87100768e-01f,
  -8.71941373e-02f, 3.31240028e-01f, -1.40401065e-01f, 2.96085011e-02f, 7.75907189e-02f, -2.93042958e-01f, -1.68560997e-01f, -2.12901488e-01f, -2.69066002e-02f, -1.45824328e-02f,
  6.96347356e-02f, 2.11271625e-02f, 2.60817329e-03f, 3.68967168e-02f, -3.31027135e-02f, 2.53807697e-02f, -1.10625036e-01f, -4.60046642e-02f, -1.07085273e-01f, -1.75934657e-02f,
  -6.87523931e-02f, -2.67666411e-02f, 1.05063856e-01f, 2.45504919e-02f, 1.13164987e-02f, -1.76973250e-02f, -4.07407098e-02f, -1.01659790e-01f, 5.58927357e-02f, 3.15672718e-02f,
  -2.45980341e-02f, -1.80788971e-02f, 4.49356586e-02f, 3.59566510e-02f, -1.30036414e-01f, 9.60717872e-02f, 1.05404727e-01f, -3.19702439e-02f, -5.79696111e-02f, 3.72787123e-03f,
  -1.57160498e-02f, -1.73245966e-02f, 1.27798662e-01f, -3.64162736e-02f, 1.26019109e-03f, -1.31641224e-01f, -3.18612643e-02f, 2.97996365e-02f, -9.44511667e-02f, 6.51005208e-02f,
  -8.45097974e-02f, -8.98429528e-02f, -2.42495723e-02f, 4.58831564e-02f, 2.98132282e-02f, 2.46638935e-02f, -2.42966115e-02f, -4.09432501e-02f, 2.26880107e-02f, 6.82740882e-02f,
  6.03057891e-02f, -2.19841637e-02f, 7.80343711e-02f, -3.25742960e-02f, 2.38673408e-02f, -5.89729920e-02f, -3.01930439e-02f, -7.31836110e-02f, 2.26291344e-02f, -9.02671218e-02f,
  1.58859774e-01f, 9.41212177e-02f, 3.10373511e-02f, 7.51603171e-02f, -8.07087123e-02f, -2.73684729e-02f, -7.81805515e-02f, 4.54460196e-02f, 3.46227549e-03f, 2.02847663e-02f,
  -1.34530431e-02f, 3.65833193e-02f, 5.52476496e-02f, -2.50324346e-02f, -6.85268193e-02f, 5.31646945e-02f, 4.60572876e-02f, 2.94756405e-02f, -6.37599304e-02f, -6.03335686e-02f,
  3.53798941e-02f, -5.13612432e-03f, -5.44440059e-04f, 2.98420293e-03f, 7.66355023e-02f, 9.01610553e-02f, -2.04297388e-03f, -8.58542025e-02f, -4.47299480e-02f, 1.67407438e-01f,
  3.02017182e-01f, 2.43623108e-02f, 1.59485871e-03f, 2.60913044e-01f, -7.99158514e-02f, -1.47715032e-01f, -1.40495449e-01f, 9.07521248e-02f, -1.48955584e-01f, -8.33852589e-02f,
  -1.56617779e-02f, -9.19719972e-03f, -8.87445584e-02f, 1.83383718e-01f, 3.26805830e-01f, -1.66454777e-01f, 7.77376890e-02f, -4.78387550e-02f, -7.37805814e-02f, 2.15013117e-01f,
  2.34816879e-01f, 2.60397732e-01f, 2.43066400e-01f, 2.38522217e-01f, 5.04897982e-02f, 3.35554898e-01f, 2.98540145e-01f, 4.65060882e-02f, 1.41049325e-01f, -3.65612060e-02f,
  -8.15350637e-02f, 3.63653190e-02f, 9.47611872e-03f, -2.50053499e-02f, 6.55239001e-02f, -6.71621487e-02f, -7.52126426e-02f, 8.64808634e-02f, -1.00121997e-01f, -1.01552106e-01f,
  -2.09710617e-02f, 5.02489880e-02f, 3.00255399e-02f, 3.17164250e-02f, 7.75457546e-02f, 1.23430593e-02f, -9.71289128e-02f, -5.07668331e-02f, -1.55177191e-01f, 2.96837986e-02f,
  -6.90200105e-02f, 2.69602402e-03f, -9.94043704e-03f, 7.74176121e-02f, 1.55802235e-01f, 7.27169141e-02f, -4.54643555e-02f, -1.07056871e-01f, -1.04280494e-01f, -9.39575583e-02f,
  6.54578581e-02f, 8.85137077e-03f, 8.55765194e-02f, -1.20979669e-02f, 8.44410807e-03f, -7.49628767e-02f, -1.82645768e-02f, -1.24561258e-01f, -2.43295599e-02f, -4.80406247e-02f,
  -7.99957290e-02f, 6.86622597e-03f, -1.75826754e-02f, -8.27912390e-02f, 2.10112091e-02f, -9.81385186e-02f, -9.88769382e-02f, 3.50091532e-02f, 6.90686852e-02f, -4.74197567e-02f,
  -1.38885647e-01f, -5.69341099e-03f, 2.52058841e-02f, 5.04949912e-02f, -2.43565906e-02f, -2.88881809e-02f, -1.65439630e-03f, 4.58684005e-02f, -1.10195227e-01f, -2.56218761e-02f,
  7.15437904e-02f, 1.30976185e-01f, 2.27920935e-02f, -4.73652472e-04f, -2.42528152e-02f, 4.33536619e-02f, -1.91007252e-03f, 3.37763205e-02f, 3.97642367e-02f, 6.61617517e-02f,
  7.36840144e-02f, -1.00912005e-01f, -8.94418955e-02f, 1.02460116e-01f, -9.30512091e-04f, -3.17206001e-03f, 8.18542913e-02f, -4.14907597e-02f, -5.55038229e-02f, 1.13385670e-01f,
  7.70248100e-02f, -1.44660860e-01f, 1.54347224e-02f, -6.96938932e-02f, -2.84714047e-02f, 7.16999620e-02f, -8.13948177e-03f, 5.10399565e-02f, 7.04821870e-02f, -2.92378990e-03f,
  1.00242525e-01f, 3.06578353e-02f, -1.93455577e-01f, 8.04418232e-03f, 1.24587782e-01f, -1.07181258e-01f, 1.16092069e-02f, 2.29464859e-01f, -1.13031380e-01f, 1.27927184e-01f,
  -3.11746765e-02f, -5.70529327e-02f, -2.36120045e-01f, -2.31916934e-01f, -3.18314433e-01f, -3.47844273e-01f, -1.29746115e-02f, -1.95027459e-02f, -1.60968974e-01f, 5.64493798e-02f,
  -1.70785636e-01f, 1.07032331e-02f, -1.51278138e-01f, 3.11728656e-01f, 2.98288316e-01f, 3.07996511e-01f, 2.24414423e-01f, 2.10293844e-01f, 1.88215747e-01f, 6.19396381e-02f,
  -1.02784321e-01f, -1.80169255e-01f, 1.11103408e-01f, 3.87453958e-02f, -3.54511216e-02f, 6.72283098e-02f, -4.13653404e-02f, 7.54208071e-03f, -4.22234535e-02f, -1.09171852e-01f,
  -7.99816661e-03f, 1.31507516e-01f, 4.77279611e-02f, 7.79685006e-02f, 6.98759481e-02f, -1.27221160e-02f, -9.39690769e-02f, -4.85085882e-02f, -4.63738814e-02f, -1.77039579e-01f,
  -5.91483675e-02f, -2.07579345e-03f, 1.42859533e-01f, 3.81435007e-02f, -7.22583309e-02f, -1.42072871e-01f, 1.01849444e-01f, -3.68389674e-02f, 4.77046110e-02f, 1.58185046e-02f,
  -2.60676648e-02f, 8.35313573e-02f, 5.50427176e-02f, 7.87258297e-02f, -1.24941161e-02f, 3.16417925e-02f, -1.63891390e-01f, -1.95637755e-02f, 2.14473940e-02f, -8.12262937e-04f,
  1.46914467e-01f, -2.72196140e-02f, -7.36376345e-02f, -7.97231123e-02f, -7.67159313e-02f, 6.19886480e-02f, 3.91662447e-03f, -1.24561049e-01f, -1.15521014e-01f, 1.08153611e-01f,
  6.91651106e-02f, -1.20800823e-01f, 1.06150053e-01f, 1.73193112e-01f, 3.76610681e-02f, 4.21096571e-02f, -5.56098223e-02f, 5.17137498e-02f, 7.61063993e-02f, 1.11494131e-01f,
  -3.78253758e-02f, -1.19860373e-01f, -6.06198832e-02f, 2.96896007e-02f, 5.44300675e-02f, -3.03604058e-03f, 1.28923822e-02f, -6.18276298e-02f, 7.07811490e-02f, -7.10895807e-02f,
  3.66996601e-02f, 4.28289175e-02f, 1.16334110e-01f, 1.75723620e-03f, 3.89227048e-02f, -8.06715861e-02f, 2.56522223e-02f, 3.57071050e-02f, 1.61327064e-01f, 3.02871652e-02f,
  6.22761697e-02f, -1.47796333e-01f, 5.36118932e-02f, 1.36434302e-01f, 8.69857818e-02f, -3.31676453e-02f, -3.75859551e-02f, 4.62752581e-02f, 4.06913087e-02f, -3.23417261e-02f,
  -3.60339999e-01f, 1.87639147e-01f, -1.11599617e-01f, -1.71287060e-01f, 5.28097115e-02f, -1.11835077e-01f, -8.91293660e-02f, 9.80176404e-02f, -9.38259512e-02f, 1.69448867e-01f,
  1.07552506e-01f, -1.84398204e-01f, 2.15271130e-01f, -1.90490738e-01f, -3.80622715e-01f, -1.57026902e-01f, -2.10325316e-01f, -2.69397736e-01f, -5.04427776e-02f, 2.06711218e-02f,
  -1.93161324e-01f, -2.71959715e-02f, -1.89145178e-01f, 2.67614424e-01f, -1.02631245e-02f, -1.69477444e-02f, 9.52587742e-03f, 1.60502791e-01f, -1.47988588e-01f, 3.14584337e-02f,
  2.56935190e-02f, 7.54396394e-02f, 9.78369415e-02f, 5.43068834e-02f, 1.77624263e-02f, -2.92341560e-02f, -7.22035915e-02f, -5.03960475e-02f, 9.72698331e-02f, -3.51558998e-02f,
  -4.78293672e-02f, -5.30164018e-02f, -3.62206399e-02f, 4.88286987e-02f, 3.54622081e-02f, -3.22838053e-02f, 2.89169606e-02f, -7.38010630e-02f, -2.08521131e-02f, -2.88496204e-02f,
  -1.19534016e-04f, 2.51161288e-02f, -3.74777876e-02f, 8.56468454e-02f, -8.09882805e-02f, 7.66027570e-02f, -1.83472127e-01f, -1.72850657e-02f, 8.64933059e-03f, -1.12349307e-02f,
  -7.41653517e-02f, -4.19959938e-03f, 2.82716583e-02f, 5.67906350e-02f, -4.37843241e-02f, 3.75159718e-02f, 1.26369931e-02f, -6.91805035e-03f, 3.05817854e-02f, 8.04711059e-02f,
  -3.07710413e-02f, 1.55048519e-02f, 3.45601588e-02f, -3.88300307e-02f, -1.63791340e-03f, -2.03303657e-02f, -3.15578319e-02f, 1.82794388e-02f, -5.22829369e-02f, 8.27399362e-03f,
  6.73956722e-02f, -1.53597025e-02f, 4.80765812e-02f, 5.65347401e-03f, 4.33325246e-02f, 1.10393070e-01f, -3.82641330e-02f, 5.31499386e-02f, 4.17586863e-02f, -5.25893867e-02f,
  1.02015927e-01f, 9.55939591e-02f, 7.47060701e-02f, 1.07410438e-01f, 4.99904640e-02f, -1.17594332e-01f, -5.45038842e-02f, -6.11068308e-02f, -3.69107611e-02f, -6.48349300e-02f,
  -8.29144008e-03f, 7.34549854e-03f, -2.34977715e-02f, -9.44385976e-02f, 3.45865972e-02f, -6.82109296e-02f, 1.61879081e-02f, 6.81800619e-02f, -2.79950947e-02f, -4.79210652e-02f,
  2.67249309e-02f, 1.87242813e-02f, -8.27856660e-02f, -1.52202658e-02f, -6.61362112e-02f, 2.42776750e-03f, -2.53499169e-02f, 1.63638275e-02f, -1.22499671e-02f, -1.65217236e-04f,
  1.22569352e-01f, 2.78880209e-01f, 3.01636249e-01f, 3.80443364e-01f, 4.59288321e-02f, -4.04330790e-01f, -1.80204675e-01f, 4.95293513e-02f, -6.68577030e-02f, 9.40112323e-02f,
  -8.18601102e-02f, 1.00325391e-01f, -1.34407029e-01f, 1.04476482e-01f, -3.63446802e-01f, -3.19155067e-01f, -1.77167729e-01f, -9.56974626e-02f, -2.95918286e-02f, 2.44780913e-01f,
  9.72756594e-02f, -3.47122066e-02f, 1.91956028e-01f, 1.42083883e-01f, 1.01622060e-01f, 3.23495299e-01f, 1.50136888e-01f, 3.89606357e-02f, 2.73667902e-01f, -1.17303722e-01f,
  -1.71993941e-01f, 5.69639876e-02f, 1.60816744e-01f, -1.66853461e-02f, 6.91489130e-02f, -1.71670765e-02f, 1.85853962e-04f, -9.69195291e-02f, -3.44286971e-02f, 3.03739589e-02f,
  -3.00425440e-02f, -9.06377137e-02f, 1.15266986e-01f, -5.26190922e-02f, 8.95290077e-03f, 7.08661005e-02f, 1.12641148e-01f, 1.99850146e-02f, 4.54718769e-02f, 6.08342737e-02f,
  1.04065135e-01f, -4.63567749e-02f, -7.99758956e-02f, -4.03576531e-02f, 3.40270586e-02f, 4.75924276e-02f, -4.03057635e-02f, 1.16805457e-01f, -5.99024370e-02f, -1.27107091e-02f,
  -7.84951150e-02f, 2.74910945e-02f, 1.45371696e-02f, -2.20813975e-02f, -8.01748503e-03f, 6.40579909e-02f, -2.47308537e-02f, 6.60387566e-04f, -8.98674130e-03f, 1.32009918e-02f,
  -2.39742137e-02f, 1.35649532e-01f, -3.63549287e-03f, 1.69771209e-01f, 5.08274920e-02f, 7.43416920e-02f, 7.73191899e-02f, -4.14835624e-02f, 8.38793889e-02f, 4.40912396e-02f,
  -1.07056405e-02f, -4.39310856e-02f, -6.28758445e-02f, -1.15969665e-01f, -7.07682967e-02f, 3.86921205e-02f, -2.09447416e-03f, -5.08109070e-02f, 2.61067078e-02f, -5.10584889e-03f,
  -1.18678547e-01f, 2.17189223e-01f, 2.39766929e-02f, -6.70320019e-02f, -8.31825435e-02f, 4.62809093e-02f, -7.29230344e-02f, 1.33808600e-02f, 4.49911617e-02f, -4.05391827e-02f,
  7.33528137e-02f, -1.79510042e-02f, 3.73594984e-02f, -4.87123951e-02f, -1.00792862e-01f, -6.23861961e-02f, 6.61898702e-02f, 1.47970393e-01f, 4.54568714e-02f, 4.10725586e-02f,
  1.84098855e-01f, -6.73549809e-03f, 5.68942502e-02f, 5.24820201e-02f, 4.97736633e-02f, -1.92736704e-02f, -4.07538153e-02f, 1.01351216e-01f, 1.90402456e-02f, -6.41917884e-02f,
  4.22428995e-01f, -3.97077858e-01f, 8.08372125e-02f, 3.63348514e-01f, 2.36952782e-01f, 6.44582286e-02f, 2.44043976e-01f, 2.80146245e-02f, 1.27473250e-01f, -2.29711637e-01f,
  4.66559594e-03f, -1.60415828e-01f, -1.85090080e-01f, 5.84619120e-02f, 5.12127876e-01f, -9.03623402e-02f, 2.63541132e-01f, 6.21925592e-02f, -8.05678442e-02f, 1.11410335e-01f,
  1.96754649e-01f, 2.30638310e-01f, -7.30160326e-02f, -2.03968048e-01f, 4.03140448e-02f, -1.28651112e-01f, 1.12875193e-01f, -1.64202034e-01f, -1.34981960e-01f, 6.02899294e-04f,
  -1.73151735e-02f, -3.62510793e-02f, -6.83552921e-02f, -8.40459466e-02f, -7.78863132e-02f, -3.86100486e-02f, -4.04605046e-02f, -7.05015380e-03f, 6.44590333e-02f, -8.18411335e-02f,
  2.73579266e-02f, -1.18322473e-03f, 7.31651625e-03f, 5.72258905e-02f, -5.21334645e-04f, 5.95649444e-02f, -6.72896206e-03f, -2.76438668e-02f, -8.52007419e-02f, -3.13425213e-02f,
  -2.24066004e-02f, -8.72741342e-02f, 8.11531302e-03f, -1.95381552e-01f, -5.76625168e-02f, 2.81742439e-02f, 3.24366875e-02f, -7.03369305e-02f, -2.46998537e-02f, -6.64364994e-02f,
  -1.31945804e-01f, 6.52367715e-03f, -5.58412587e-03f, 2.66722254e-02f, 5.84009029e-02f, 3.92114669e-02f, -3.94907258e-02f, -5.48866810e-03f, 6.29794318e-03f, 3.89503804e-03f,
  3.63926180e-02f, 5.46447858e-02f, 8.89928453e-03f, -7.45644607e-03f, 4.15045805e-02f, 4.74393833e-04f, 3.27868713e-03f, 4.74213362e-02f, -1.89121533e-03f, -2.20627636e-02f,
  -4.30224873e-02f, -2.55548069e-03f, -1.92306414e-02f, -4.10260893e-02f, 6.27064183e-02f, 8.93572792e-02f, 4.52873409e-02f, -3.42987068e-02f, -1.07495273e-02f, -5.44885173e-02f,
  -5.40651791e-02f, -2.23505031e-02f, -5.55169769e-02f, 8.17394480e-02f, -3.36052738e-02f, -3.62029411e-02f, -5.51465340e-02f, 7.33923912e-02f, -8.21755677e-02f, 5.32667004e-02f,
  5.19680884e-03f, 3.30376811e-03f, -9.92880575e-03f, 4.46672477e-02f, 5.98268863e-03f, 3.03925723e-02f, -1.93576701e-02f, -9.60008875e-02f, 7.74249285e-02f, -2.93711084e-03f,
  -3.23939584e-02f, 3.61587517e-02f, -3.67130563e-02f, 4.25422676e-02f, -3.30984890e-02f, -1.02057280e-02f, 1.88722517e-02f, -2.67663668e-03f, -4.65740040e-02f, -6.93626776e-02f,
  1.71331421e-01f, -3.18563998e-01f, -1.80436894e-01f, 2.21266728e-02f, 2.69884374e-02f, 3.12657326e-01f, 5.07424355e-01f, -3.93685788e-01f, -3.61963540e-01f, -2.07778737e-02f,
  2.91084290e-01f, 4.26396355e-03f, -9.61089283e-02f, 3.06554377e-01f, 3.56217742e-01f, -5.19093908e-02f, 2.00538382e-01f, 2.06258610e-01f, -2.26704150e-01f, -1.93846717e-01f,
  -1.67124927e-01f, 3.75430465e-01f, 6.65376484e-02f, -7.70521313e-02f, 1.37210652e-01f, -2.50543982e-01f, 1.40538469e-01f, -1.42148146e-02f, 2.66776890e-01f, 2.91540235e-01f,
  7.78812096e-02f, -1.80490375e-01f, 1.64492782e-02f, 4.95459475e-02f, 7.17483694e-03f, 2.44201645e-02f, 2.02127278e-01f, 2.58242846e-01f, 9.22227800e-02f, -3.35624591e-02f,
  4.05417643e-02f, -4.49060611e-02f, -3.81097272e-02f, 1.06051739e-03f, -3.19164954e-02f, -1.41479447e-01f, -1.11410923e-01f, -3.25057805e-02f, -4.68883291e-02f, -1.76545437e-02f,
  -1.32738709e-01f, -1.11734390e-01f, -7.52075836e-02f, 4.40607779e-02f, 2.15660464e-02f, -5.39801233e-02f, -1.09022498e-01f, -2.05189325e-02f, -7.14872703e-02f, 1.44191831e-02f,
  -7.92161468e-03f, 2.19812058e-02f, -1.46249533e-01f, 8.96454379e-02f, 2.77126655e-02f, 1.17120653e-01f, 2.79075783e-02f, 5.90942129e-02f, -4.86961789e-02f, -5.89951724e-02f,
  -3.27987969e-02f, 5.80777507e-03f, -1.15842827e-01f, -8.26056153e-02f, 5.14073223e-02f, 2.54226923e-02f, -2.06946637e-02f, 2.35367566e-02f, -1.06043192e-02f, 1.35510834e-02f,
  -5.79880923e-02f, 1.69261489e-02f, 5.65732867e-02f, 9.23077948e-03f, 1.65004916e-02f, -1.76010840e-02f, 3.65048833e-03f, -1.33147299e-01f, -4.82723229e-02f, 8.56526941e-02f,
  -1.20549776e-01f, -3.27388942e-01f, 1.18744769e-03f, 9.57791433e-02f, -1.48386071e-02f, 1.28142154e-02f, 4.82031051e-03f, -1.01350144e-01f, -5.07774577e-02f, -2.91693187e-03f,
  3.56587395e-02f, 5.83341047e-02f, -3.08231059e-02f, 3.53596261e-04f, 1.45232081e-01f, -6.77780136e-02f, -5.66159971e-02f, 1.19830213e-01f, -3.68249752e-02f, -6.74755052e-02f,
  3.50762419e-02f, 4.13780510e-02f, 1.54546544e-01f, -6.85969507e-03f, 1.88019499e-02f, 1.12885591e-02f, 1.65710952e-02f, -3.87183093e-02f, 3.04398709e-03f, -1.29075319e-01f,
  9.77151766e-02f, 2.81633019e-01f, 2.55031765e-01f, -2.08131969e-02f, -1.23282209e-01f, -5.92074357e-02f, -1.60857126e-01f, 1.80710793e-01f, 1.76263958e-01f, 2.55635530e-01f,
  -1.89314354e-02f, 2.58485019e-01f, -8.95034056e-04f, 6.62645996e-02f, -3.49074304e-01f, -1.61271796e-01f, -2.24125788e-01f, -1.27724081e-01f, -4.38642576e-02f, -6.18438004e-03f,
  -2.18672320e-01f, -1.61602244e-01f, -1.28627703e-01f, -3.35362405e-02f, 1.44217193e-01f, 2.02146426e-01f, -2.38841429e-01f, -2.19449773e-02f, 5.93212619e-02f, -1.69941764e-02f,
  -5.34913987e-02f, 1.94222823e-01f, 5.37438467e-02f, 1.08781643e-01f, -7.44555667e-02f, 2.64196303e-02f, -9.40909684e-02f, -3.37328538e-02f, -1.64363980e-02f, 6.20487370e-02f,
  9.68179926e-02f, 4.82835583e-02f, 8.74080881e-02f, 3.03243753e-02f, 7.50257000e-02f, 1.29684955e-01f, -5.90448342e-02f, -1.10226355e-01f, 1.18596114e-01f, 7.52703520e-04f,
  6.77662864e-02f, 5.56294881e-02f, -1.55551368e-02f, -1.60692930e-02f, 3.38871330e-02f, 3.80436145e-02f, -2.99546979e-02f, 8.50844808e-05f, 1.02418959e-01f, 3.64404842e-02f,
  -2.74795834e-02f, -5.41526079e-02f, -2.19991859e-02f, 7.81858936e-02f, -7.57636782e-03f, 6.94423616e-02f, -7.91911334e-02f, -8.43313113e-02f, -1.27173647e-01f, 6.40450194e-02f,
  -7.43719116e-02f, 4.32043849e-03f, 3.16470792e-03f, 3.55951628e-03f, -3.16586979e-02f, 9.72453803e-02f, -7.04792663e-02f, -3.93594727e-02f, -5.61618991e-02f, -4.26491648e-02f,
  5.56036159e-02f, -1.37003019e-01f, 1.02517009e-01f, -8.63418803e-02f, -1.87607203e-02f, 2.75565460e-02f, 6.80963770e-02f, 1.63144037e-01f, -1.57040730e-02f, -1.03240684e-01f,
  -3.59504044e-01f, -1.62782148e-01f, 4.32558507e-02f, 9.60190073e-02f, -1.16310101e-02f, 9.84750390e-02f, -7.34315962e-02f, 1.31424934e-01f, -1.49134934e-01f, 3.45715118e-04f,
  -3.42859253e-02f, -1.52321635e-02f, -1.00447193e-01f, 1.67242456e-02f, -6.27707168e-02f, -4.19422537e-02f, -1.14565894e-01f, -9.66195613e-02f, -1.36068776e-01f, -2.88969022e-03f,
  5.72338365e-02f, -9.79371294e-02f, 6.10385202e-02f, -6.22906014e-02f, -4.72467914e-02f, -5.28673641e-02f, 4.27472852e-02f, 1.84688568e-02f, -1.36442780e-02f, -4.29696552e-02f,
  2.08015516e-01f, -1.88023970e-01f, -2.72737533e-01f, 3.59126143e-02f, -1.15273278e-02f, 5.63529097e-02f, -1.74379379e-01f, 1.30724847e-01f, -1.50312573e-01f, 1.33565709e-01f,
  1.06893659e-01f, -5.32785021e-02f, -3.14281136e-01f, 3.14959288e-01f, 2.73117810e-01f, -2.38672167e-01f, 2.72365063e-01f, 9.45502296e-02f, -2.54489854e-02f, 5.67845516e-02f,
  1.04733892e-01f, 3.53549629e-01f, -5.54544516e-02f, 2.58581728e-01f, 1.22909039e-01f, -1.18451573e-01f, 1.18599966e-01f, -3.08614314e-01f, 3.87100756e-01f, 2.34366000e-01f,
  8.98769796e-02f, 4.63414975e-02f, -2.22331956e-02f, -7.50657469e-02f, 2.31214217e-03f, 3.49412933e-02f, -7.01390430e-02f, -5.73962228e-03f, -6.43433034e-02f, 1.63727663e-02f,
  -3.62004787e-02f, 9.38520133e-02f, 9.00392830e-02f, 7.01170862e-02f, 3.57832983e-02f, -4.84369807e-02f, 9.70027037e-03f, -6.50952682e-02f, -9.01518315e-02f, 9.36576873e-02f,
  -1.23675473e-01f, 6.26690537e-02f, -9.32691619e-02f, -1.49873151e-02f, -1.48838475e-01f, 6.14397153e-02f, -5.89847844e-03f, -1.53737806e-03f, -1.60163529e-02f, 1.30883440e-01f,
  2.62528770e-02f, -4.17083725e-02f, -2.15078983e-03f, 4.28535677e-02f, -4.55668122e-02f, -4.99715656e-02f, 3.56987119e-02f, -7.40934238e-02f, -1.42679326e-02f, 9.00640711e-02f,
  -6.34091645e-02f, 2.85979882e-02f, 8.42004716e-02f, 5.49181513e-02f, 8.51354897e-02f, -3.41173708e-02f, -1.12502873e-02f, -1.70713733e-03f, -7.90891796e-02f, -8.18784460e-02f,
  -5.51925674e-02f, -8.60236585e-03f, -5.00478335e-02f, 2.65327934e-03f, -4.03165631e-02f, 1.92863718e-02f, 1.54892027e-01f, 2.82905381e-02f, -7.62298778e-02f, -1.83912329e-02f,
  1.83784980e-02f, -2.29593050e-02f, 1.50732901e-02f, 1.49801131e-02f, -1.44066319e-01f, -2.57248208e-02f, -2.06545833e-02f, 4.74728942e-02f, -6.10943250e-02f, -2.25211941e-02f,
  1.26921356e-01f, -5.29446006e-02f, 2.75512114e-02f, 3.72107215e-02f, 5.57224303e-02f, 8.84911492e-02f, 7.30915815e-02f, -5.60815297e-02f, 1.14101246e-02f, 1.06122673e-01f,
  -9.60359871e-02f, 1.94239442e-03f, -7.15965554e-02f, -8.54651555e-02f, 1.00729614e-01f, -5.60388155e-02f, -1.97371393e-02f, -5.37117710e-03f, 2.03375965e-02f, -2.33911350e-02f,
  -1.28025666e-01f, -2.80365441e-02f, -2.67294079e-01f, -3.08301121e-01f, 1.95661306e-01f, 8.54236931e-02f, -2.02126369e-01f, 2.78593209e-02f, -3.10907692e-01f, 1.14248104e-01f,
  -7.75499865e-02f, -2.63892710e-01f, -1.20100439e-01f, -3.67842823e-01f, -4.28511500e-01f, -3.07226121e-01f, -1.08762056e-01f, -2.50678323e-03f, -1.32130176e-01f, 1.57922477e-01f,
  -2.47545034e-01f, 1.13103643e-01f, -3.86085719e-01f, 1.31192699e-01f, 1.47410473e-02f, 2.57017650e-02f, 3.46783727e-01f, 2.88986806e-02f, 1.88995570e-01f, -5.95735684e-02f,
  1.32139586e-02f, 6.12267256e-02f, -4.35074344e-02f, -2.55006067e-02f, 4.14243191e-02f, 1.21757179e-01f, 1.00780398e-01f, -7.38695562e-02f, 1.14259345e-03f, 1.24432985e-02f,
  7.36480504e-02f, -8.60912725e-02f, -6.53969706e-04f, -9.48755145e-02f, -3.20631787e-02f, -2.39109416e-02f, -5.24056479e-02f, -2.90588778e-03f, -1.19822705e-02f, -1.42248169e-01f,
  -9.24243405e-02f, 4.13715504e-02f, 9.55007132e-03f, -1.58751514e-02f, -6.79222420e-02f, -2.36070417e-02f, -8.25656652e-02f, 3.79330739e-02f, 8.95597562e-02f, 1.11345593e-02f,
  1.15566678e-01f, 1.06011614e-01f, -6.63797185e-02f, -1.25317704e-02f, 2.67452258e-03f, 6.07372541e-03f, 5.68810441e-02f, 2.39033322e-03f, -1.21381588e-01f, 2.47125160e-02f,
  5.20271109e-03f, -3.84089798e-02f, -2.74344217e-02f, -1.45686055e-02f, 3.44232991e-02f, 3.26532386e-02f, -6.48224652e-02f, 9.64938998e-02f, 3.03946659e-02f, -3.95177528e-02f,
  -1.88368931e-02f, 1.11498900e-01f, -2.35781856e-02f, 1.01374559e-01f, -1.98489483e-02f, -7.46963918e-02f, 1.02069862e-01f, 1.45254266e-02f, -1.04800658e-02f, -6.56724628e-03f,
  1.20387077e-01f, 2.09417805e-01f, -8.19114372e-02f, -1.51638258e-02f, 1.73745502e-03f, 5.83240539e-02f, -6.20426238e-02f, 6.64394423e-02f, -9.95841846e-02f, 8.56606066e-02f,
  1.23843797e-01f, -1.42932544e-02f, 1.27219811e-01f, -4.91946600e-02f, 9.22165718e-03f, 4.77274358e-02f, 2.06786953e-02f, 2.42415499e-02f, 7.36731067e-02f, 3.15292962e-02f,
  1.82606399e-01f, 1.55486256e-01f, -3.59000005e-02f, -2.48959777e-03f, 3.67886424e-02f, 1.35715604e-01f, 1.00410789e-01f, 6.40961109e-03f, 1.54355451e-01f, -5.00295535e-02f,
  -3.58160317e-01f, 4.41096038e-01f, 5.64282760e-02f, -4.20129597e-01f, 1.94852829e-01f, -6.18941970e-02f, -2.01194137e-01f, 1.61567613e-01f, -2.25833535e-01f, -1.06544331e-01f,
  -1.62795231e-01f, -4.22542915e-02f, 1.71619490e-01f, -1.14101134e-01f, -2.48820931e-01f, -4.79997322e-03f, -1.52611509e-01f, -2.34165490e-01f, 2.24318430e-01f, -1.02910697e-01f,
  -8.67786177e-04f, 1.03506014e-01f, 4.30508284e-03f, 2.93804735e-01f, 4.79883067e-02f, 5.70804030e-02f, -2.78574198e-01f, 2.35365868e-01f, -1.00065328e-01f, 1.15637876e-01f,
  1.47918433e-01f, -6.23617657e-02f, 6.49795756e-02f, -3.30809057e-02f, -7.21538290e-02f, 5.38867433e-03f, -5.17741814e-02f, 3.56579758e-02f, -1.34194881e-01f, -1.13569401e-01f,
  2.82186419e-02f, -2.34984625e-02f, -5.65498360e-02f, 1.03602231e-01f, -9.41850320e-02f, 1.13219051e-02f, 8.06936398e-02f, 8.26583654e-02f, 8.75404254e-02f, 3.98974679e-02f,
  1.37352243e-01f, -8.10859725e-02f, -1.59022629e-01f, -2.38839000e-01f, -7.56148547e-02f, -8.43838230e-02f, -8.95919874e-02f, -7.12111145e-02f, -3.66414338e-02f, -4.74240556e-02f,
  1.54163800e-02f, -6.39837906e-02f, 3.17927301e-02f, 8.37247260e-03f, 1.01129681e-01f, -4.49676486e-03f, 2.98438780e-02f, -4.44565937e-02f, -1.57505292e-02f, -5.76550700e-02f,
  -9.55180526e-02f, -4.89149690e-02f, -3.26982960e-02f, -1.43519640e-01f, -2.18123533e-02f, -2.82664929e-04f, -6.47158474e-02f, 2.36191060e-02f, 3.40474001e-03f, 2.19606683e-02f,
  -1.60237923e-02f, -1.58180408e-02f, 1.20955631e-01f, 5.72789758e-02f, 2.12268941e-02f, -7.19115883e-02f, 8.34105089e-02f, -1.06258886e-02f, 8.28321800e-02f, 5.22954017e-02f,
  -8.01138878e-02f, -2.24084646e-01f, 5.67068234e-02f, -5.37573025e-02f, 1.03127947e-02f, -6.00579157e-02f, 3.24501768e-02f, 9.53099411e-03f, -1.12105429e-01f, -8.36307369e-03f,
  -8.02348778e-02f, -6.95501789e-02f, -1.35912135e-01f, -2.23731250e-02f, 6.13202229e-02f, -6.28256425e-02f, -5.14552481e-02f, -1.11240424e-01f, -1.75443679e-01f, 8.76615383e-03f,
  -3.80325094e-02f, -6.27970546e-02f, -6.07785694e-02f, -5.00387475e-02f, -8.27831998e-02f, -8.65630656e-02f, -5.21559268e-02f, 1.70599315e-02f, 1.13616753e-02f, -9.54308957e-02f,
  -9.71265510e-03f, 4.30030048e-01f, -9.31457710e-03f, 3.76910657e-01f, 1.76411308e-02f, -1.12050958e-02f, 2.41327402e-03f, 1.28846124e-01f, 6.01811111e-02f, 1.44855738e-01f,
  1.17172107e-01f, 1.73536595e-02f, 4.00113538e-02f, 2.79352069e-01f, 5.52055240e-02f, 1.79581165e-01f, 3.53982836e-01f, 9.47056189e-02f, 1.95174158e-01f, 1.14766240e-01f,
  1.03220008e-01f, 2.60449111e-01f, 3.07301804e-02f, 3.76429968e-03f, 1.19932421e-01f, 7.84947947e-02f, 9.56470892e-02f, -9.06029418e-02f, 2.61930943e-01f, 1.80221107e-02f,
  3.13452370e-02f, 1.14259891e-01f, -9.40356851e-02f, -1.73120558e-01f, -2.40619155e-03f, -5.46278171e-02f, -1.13742352e-01f, -8.96410048e-02f, -4.34494354e-02f, -7.38236867e-03f,
  -1.13973003e-02f, -4.08739876e-03f, -6.02446683e-02f, 4.30913158e-02f, -1.22755682e-02f, -1.32236183e-02f, -1.80316363e-02f, 4.05051000e-02f, -5.36883958e-02f, -8.48438144e-02f,
  2.00846493e-02f, 7.69192213e-03f, 6.35469109e-02f, -9.30622127e-03f, -3.39236856e-02f, 3.16392295e-02f, 1.15942612e-01f, 1.30573697e-02f, 9.70656797e-02f, -3.62191722e-02f,
  2.23835856e-02f, 6.23472296e-02f, -5.58818243e-02f, -7.50442296e-02f, 5.00613973e-02f, -5.78211769e-02f, 1.05652317e-01f, 6.21867441e-02f, -2.53780950e-02f, 1.78700443e-02f,
  7.21206442e-02f, 7.12794960e-02f, 1.98291726e-02f, 7.40674958e-02f, 3.04256491e-02f, -3.24096717e-02f, 1.06115909e-02f, -1.16925379e-02f, -4.94121164e-02f, -9.44397375e-02f,
  8.03765208e-02f, -4.04287092e-02f, 3.11015844e-02f, 1.50049515e-02f, 7.71808773e-02f, -1.78509727e-02f, 1.49967268e-01f, 9.21973437e-02f, -1.35846779e-01f, 5.49599007e-02f,
  2.19848320e-01f, 2.08202213e-01f, -5.72686642e-03f, -7.96922296e-02f, -6.64304644e-02f, 4.55007553e-02f, 6.93873838e-02f, 6.28386915e-04f, 1.35864854e-01f, 6.63125962e-02f,
  5.75830489e-02f, -7.00216070e-02f, -1.36278169e-02f, -7.73449689e-02f, -6.01265952e-03f, 9.70827043e-02f, -4.52813576e-04f, -1.12731531e-01f, 1.31431386e-01f, 1.07705377e-01f,
  8.92958604e-04f, -3.49254347e-02f, -7.33802514e-03f, -9.00505930e-02f, -4.45782542e-02f, -9.06927660e-02f, 5.43399900e-02f, -6.89391047e-02f, -1.35904260e-03f, -2.66312268e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  7.43447095e-02f, 4.86287355e-01f, 2.73900151e-01f, 1.06329069e-01f, 3.36252689e-01f, 2.55086541e-01f, 2.78310925e-01f, 1.02260530e-01f, 1.93709448e-01f, 1.37763098e-01f,
  3.27826768e-01f, 1.58556402e-01f, 3.15689504e-01f, 2.84667522e-01f, 2.70731658e-01f, 2.31665984e-01f, 2.28627790e-02f, 2.93136239e-01f, 1.93143979e-01f, 2.16679007e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  7.08999857e-02f, 4.02400456e-02f, -2.19786778e-01f, 1.69440284e-01f, -1.11474589e-01f, -1.08328931e-01f, -3.86784859e-02f, 1.93201900e-01f, -3.22599709e-01f, 1.83908254e-01f,
  -7.50708804e-02f, -9.52033550e-02f, 2.57139862e-01f, 2.23871231e-01f, 5.77699058e-02f, 4.18885350e-02f, 5.02305850e-03f, -3.52894887e-02f, -2.13062465e-01f, 2.20705777e-01f,
  -2.35104591e-01f, 8.84058625e-02f, -2.23195657e-01f, -2.15953603e-01f, 1.83089525e-01f, -1.86396733e-01f, -2.68907815e-01f, -2.89185462e-03f, -1.35498732e-01f, -3.27641249e-01f,
  -1.06965326e-01f, 3.08516055e-01f, 1.97938740e-01f, 3.12784225e-01f, 7.35675842e-02f, -1.41692206e-01f, 7.58828893e-02f, 2.26946309e-01f, -9.12399516e-02f, 2.09775642e-01f,
  2.67299891e-01f, -8.24315026e-02f, -1.82447229e-02f, 2.43958145e-01f, 2.41768524e-01f, 2.73595929e-01f, 9.07956511e-02f, 3.55973005e-01f, -6.43288568e-02f, 2.34509066e-01f,
  -9.60168988e-02f, 2.02891767e-01f, -3.16299833e-02f, -1.30591050e-01f, -2.28634119e-01f, 1.09027728e-01f, -1.00933006e-02f, 1.28192872e-01f, -8.40317011e-02f, 7.45074898e-02f,
  -2.93583155e-01f, -3.23353201e-01f, 2.53276229e-01f, -2.20262483e-01f, -6.68715909e-02f, 8.94515365e-02f, 1.28298551e-01f, -9.23096687e-02f, -1.66781992e-01f, -8.98589715e-02f,
  -2.67471731e-01f, 1.69625759e-01f, -8.51854384e-02f, -1.40985012e-01f, 2.95620888e-01f, -2.26200908e-01f, -2.61811856e-02f, -2.14597404e-01f, -1.30846933e-01f, -1.68492533e-02f,
  2.14441121e-01f, -3.18328768e-01f, -3.01164657e-01f, -6.58516809e-02f, -1.90682873e-01f, -4.17521782e-02f, 9.69310626e-02f, 2.08764523e-01f, -1.01730853e-01f, -1.59292847e-01f,
  2.04813689e-01f, 1.73142835e-01f, 1.43618971e-01f, 1.04466699e-01f, 8.41596574e-02f, -1.03561752e-01f, 1.01607777e-02f, 7.62423053e-02f, -9.58753973e-02f, -1.87249824e-01f,
  -1.32985696e-01f, -6.21674396e-02f, 1.05289489e-01f, -1.72727555e-01f, -2.25696176e-01f, 4.80215289e-02f, 3.45589221e-01f, 3.65948915e-01f, -7.50759477e-03f, -1.38434425e-01f,
  -1.43485540e-03f, 3.51604849e-01f, -3.82548720e-02f, -2.53175110e-01f, -4.82642092e-02f, 3.10090989e-01f, -3.22609842e-01f, -8.32792080e-04f, 1.39689639e-01f, 1.14130983e-02f,
  3.42772961e-01f, 1.79572403e-01f, 2.91347578e-02f, 2.77095199e-01f, 2.20939964e-01f, 1.13658413e-01f, 4.37004566e-02f, 4.12436835e-02f, -1.30995318e-01f, 3.38637233e-02f,
  -1.66868821e-01f, 4.58219424e-02f, 4.12596166e-02f, -1.82405189e-02f, -1.07102841e-01f, 9.94073972e-02f, -6.06923699e-02f, 7.62548596e-02f, 2.94916242e-01f, 2.28919700e-01f,
  -1.08867340e-01f, -2.26322919e-01f, 9.48247164e-02f, -1.68022081e-01f, -1.37054712e-01f, -5.04788980e-02f, -2.37196207e-01f, -2.21804395e-01f, -1.70525238e-01f, 1.52234565e-02f,
  4.26652461e-01f, 2.32625633e-01f, 2.70381898e-01f, 3.29144269e-01f, 3.30909379e-02f, 2.62780249e-01f, 9.73251387e-02f, 7.86277577e-02f, 2.67609417e-01f, -1.64036959e-01f,
  -1.10267932e-02f, -1.48359165e-01f, 1.18385069e-01f, 1.53712228e-01f, -1.40026987e-01f, -1.45189032e-01f, -2.12418020e-01f, 2.70304352e-01f, -8.44242945e-02f, 7.60767534e-02f,
  2.11113527e-01f, -2.10881919e-01f, 3.20951104e-01f, -1.11825094e-01f, -2.51721561e-01f, 4.72403429e-02f, 6.50808737e-02f, -2.10898548e-01f, 3.49496268e-02f, 2.09926978e-01f,
  -1.33066446e-01f, -4.65276390e-01f, -1.34764269e-01f, 3.11978042e-01f, 3.38178836e-02f, -2.73513764e-01f, -1.02907538e-01f, 1.86187863e-01f, 3.15909758e-02f, 9.54596326e-02f,
  2.57008642e-01f, 7.88777880e-03f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.32579768e-01f, 6.88362643e-02f, 3.15180749e-01f, 1.80510193e-01f, 6.45574927e-02f, 1.25441507e-01f, 6.59046229e-03f, 6.27923980e-02f, 3.59615907e-02f, 9.78902504e-02f,
  2.82967746e-01f, -2.61363357e-01f, 5.28591096e-01f, 1.25845894e-01f, -1.87500924e-01f, 2.34152466e-01f, 3.22206646e-01f, -4.72139120e-02f, -6.86040819e-02f, 5.17820477e-01f,
  1.38019517e-01f, -2.13086054e-01f, -1.57729592e-02f, 2.32277229e-01f, 3.33230138e-01f, -3.99229288e-01f, -1.47349045e-01f, 4.07759398e-01f, 4.53684758e-03f, 2.60230303e-01f,
  3.36464107e-01f, 4.49600369e-01f, 3.55670810e-01f, 3.40370893e-01f, 6.80797473e-02f, 3.34640563e-01f, 2.32017979e-01f, 3.28191698e-01f, 3.68126146e-02f, 1.12570547e-01f,
  9.54613015e-02f, 1.51566654e-01f, -1.42606199e-01f, -3.77094112e-02f, 4.67606604e-01f, 4.37577456e-01f, -2.19454378e-01f, 2.26735517e-01f, 1.86358780e-01f, -1.68746248e-01f,
  3.55209708e-01f, 4.09244090e-01f, 2.50218213e-01f, -1.64389387e-01f, -1.50094196e-01f, 2.81958938e-01f, -1.03291553e-02f, -3.14183086e-01f, 3.82618085e-02f, 4.33448553e-01f,
  2.12369971e-02f, 1.37751214e-02f, 3.31975609e-01f, 1.82529852e-01f, 1.25643998e-01f, 2.09466130e-01f, 5.86877726e-02f, 4.17024605e-02f, -3.54015492e-02f, -1.12688877e-01f,
  1.47519872e-01f, 2.28419855e-01f, -4.30063643e-02f, -1.59445763e-01f, 2.23478332e-01f, 2.32295915e-01f, 1.65469840e-01f, -1.55879647e-01f, -1.45636797e-01f, 4.84337151e-01f,
  3.48408490e-01f, -1.17397606e-01f, -2.03329489e-01f, 3.51066262e-01f, -3.09660643e-01f, -1.79091752e-01f, 4.83751416e-01f, 1.06351882e-01f, 5.38801134e-01f, -4.53565687e-01f,
  -4.10793006e-01f, 2.27381930e-01f, 4.71539646e-02f, 5.31876683e-01f, 1.70742542e-01f, 1.37630358e-01f, 2.96370685e-01f, -6.31471053e-02f, -9.07308597e-04f, 3.09546679e-01f,
  1.57033294e-01f, -9.90215316e-03f, 3.89692515e-01f, -1.69939145e-01f, -3.02692205e-01f, 3.91881913e-01f, 7.67360479e-02f, -2.16660351e-01f, 2.50270754e-01f, -1.92082345e-01f,
  2.42764130e-01f, 4.26107854e-01f, -4.55396101e-02f, -2.36710371e-03f, 7.49299303e-02f, 4.03357744e-01f, 2.94134974e-01f, 3.08029324e-01f, 1.75573945e-01f, -2.23951429e-01f,
  1.98011816e-01f, 6.58899918e-02f, 3.18175346e-01f, -3.50869119e-01f, 4.54798937e-01f, 3.77606601e-01f, -4.18652534e-01f, 3.26040357e-01f, 3.81236792e-01f, 3.28193903e-01f,
  4.46096450e-01f, 1.39315441e-01f, 2.10201979e-01f, 3.24691981e-01f, -2.11122587e-01f, -5.14221489e-02f, 4.82203484e-01f, -1.19706400e-01f, -4.51738805e-01f, 1.58198342e-01f,
  -4.69313443e-01f, 4.29668844e-01f, 2.36071005e-01f, -2.48721957e-01f, 3.61619532e-01f, 4.05201286e-01f, 1.81201801e-01f, -4.45924520e-01f, -1.44849122e-01f, 2.60881335e-01f,
  -9.04773399e-02f, -1.09156691e-01f, 2.86516666e-01f, -8.00749213e-02f, -3.18015814e-01f, 4.82831389e-01f, -3.98254722e-01f, -2.73500770e-01f, 4.08776194e-01f, -7.30081722e-02f,
  4.21900690e-01f, 6.56714812e-02f, 2.46607155e-01f, 3.75336409e-01f, 2.77243435e-01f, 3.61186683e-01f, 2.51581073e-01f, -2.20834225e-01f, -2.49397457e-01f, 3.38690549e-01f,
  -1.98192075e-01f, -1.70051441e-01f, 8.96585807e-02f, -1.91795200e-01f, 2.45283291e-01f, -1.54537886e-01f, 1.92507386e-01f, 3.13781649e-01f, 2.38129839e-01f, -2.41050106e-02f,
  3.22260767e-01f, 5.05197406e-01f, 2.07774147e-01f, -6.36119023e-02f, 3.53392720e-01f, 6.59568608e-02f, 2.20088184e-01f, -4.78509188e-01f, 2.98434168e-01f, 2.12805066e-02f,
  -2.74963349e-01f, 2.70709068e-01f, 1.48091540e-01f, -1.87329561e-01f, 2.18156844e-01f, 1.05667219e-01f, 2.95984417e-01f, -3.65572870e-02f, 3.29870045e-01f, 1.58091322e-01f,
  -2.80499339e-01f, 4.43266422e-01f, -2.12429792e-01f, -3.31393838e-01f, 1.76768787e-02f, -4.00492013e-01f, -1.68804154e-02f, -4.51319993e-01f, -2.78107703e-01f, -8.98560733e-02f,
  1.82875078e-02f, -7.65701085e-02f, 3.67156088e-01f, 3.22728276e-01f, 3.51270705e-01f, 3.81797403e-02f, 2.51785964e-01f, -1.15353175e-01f, 7.51839355e-02f, -4.29083437e-01f,
  3.86931926e-01f, 4.71716404e-01f, -1.72565416e-01f, 4.65669692e-01f, 2.26619542e-01f, 3.32283020e-01f, 4.46184054e-02f, -1.72679588e-01f, 3.68527621e-01f, 8.72874558e-02f,
  -6.49419054e-02f, -1.41079068e-01f, 4.42328662e-01f, -3.08779925e-01f, 2.16358110e-01f, 2.46078536e-01f, 1.75285991e-02f, -7.64550343e-02f, 3.67128521e-01f, -7.75901526e-02f,
  -5.63840121e-02f, 3.85072470e-01f, -2.21149221e-01f, 7.58897513e-02f, -1.61750883e-01f, 2.52361268e-01f, 2.38300070e-01f, 1.58174813e-01f, 2.08038166e-01f, 3.50531131e-01f,
  -5.25360219e-02f, 5.07429361e-01f, 6.69044107e-02f, -2.60809541e-01f, 2.30284110e-01f, -1.18546225e-01f, 3.86653751e-01f, 2.20671758e-01f, -6.46702498e-02f, -7.62292817e-02f,
  3.66642207e-01f, 6.31663799e-02f, 3.59573036e-01f, -2.94865519e-01f, -2.25861281e-01f, -2.24001687e-02f, -1.11498572e-01f, 4.75801677e-01f, -3.20626140e-01f, -2.76431084e-01f,
  5.75301290e-01f, 1.64954484e-01f, 4.64359403e-01f, 1.28731489e-01f, 7.86286816e-02f, 1.89852908e-01f, -1.19493417e-01f, 4.66764212e-01f, 2.93408096e-01f, 9.78625789e-02f,
  5.86774051e-01f, 3.17961067e-01f, -2.27707148e-01f, 3.23424965e-01f, 2.96268135e-01f, 2.30337739e-01f, -3.20171937e-02f, 3.38103026e-01f, 2.67940313e-01f, 1.56849381e-02f,
  7.55335018e-02f, 3.98023039e-01f, 1.01661738e-02f, 3.56215209e-01f, 2.91752279e-01f, -4.47447479e-01f, 1.78267285e-01f, 9.07296985e-02f, -3.85911852e-01f, -2.92378664e-01f,
  1.04410723e-01f, 1.67139262e-01f, -2.03215539e-01f, 8.25062394e-02f, 2.01579720e-01f, 1.17932007e-01f, 2.39908949e-01f, 8.62694606e-02f, 6.12909079e-01f, -2.05686182e-01f,
  -3.07516187e-01f, -2.16728166e-01f, -3.62091392e-01f, -1.12873763e-01f, 3.13530982e-01f, -1.72447816e-01f, 2.31970266e-01f, -6.98082820e-02f, -1.02188215e-01f, 2.98378915e-01f,
  2.06165954e-01f, 2.27136746e-01f, 2.60301709e-01f, -1.26815401e-03f, 5.36332726e-02f, 2.08495826e-01f, -4.23071273e-02f, -3.86556208e-01f, 3.27778637e-01f, -4.40380007e-01f,
  -2.19378829e-01f, 3.99607241e-01f, -6.01961195e-01f, 1.56804174e-01f, 4.83090311e-01f, 1.18508553e-02f, 3.34166974e-01f, 4.61354733e-01f, 2.46507093e-01f, -3.77233326e-01f,
  1.00902915e-01f, 2.26848572e-01f, 3.66308510e-01f, -3.67965758e-01f, 2.49468103e-01f, 4.43598956e-01f, 2.14129984e-01f, 1.55864492e-01f, 7.33028799e-02f, -1.19091667e-01f,
  -3.22449580e-02f, 2.64896248e-02f, 2.58480698e-01f, 2.21952692e-01f, 3.74740660e-01f, 4.80152279e-01f, 3.55679542e-01f, 2.96157628e-01f, 2.57036975e-03f, 1.53249741e-01f,
  -1.58224538e-01f, 3.14100176e-01f, 6.84139132e-03f, -4.31054384e-01f, 2.73171633e-01f, 5.30768991e-01f, -2.53449678e-01f, 1.66464165e-01f, 1.69411957e-01f, -9.75790992e-02f,
  4.10770655e-01f, 1.39256433e-01f, 3.32332253e-01f, -1.35560185e-01f, -1.51443720e-01f, -2.08602652e-01f, -2.86397278e-01f, 9.21199694e-02f, 3.78260285e-01f, -2.56968558e-01f,
  5.77842630e-02f, 1.93028197e-01f, 3.61312367e-02f, 1.33854881e-01f, 1.37885958e-01f, 3.00803065e-01f, 4.08985578e-02f, -4.12879623e-02f, 2.71023393e-01f, 1.94105193e-01f,
  -1.66100398e-01f, 4.98443723e-01f, 8.88612196e-02f, 1.83115661e-01f, 3.44563097e-01f, -2.08627343e-01f, 1.25723988e-01f, -8.42121020e-02f, 3.73330981e-01f, 1.73611730e-01f,
  -1.13639683e-01f, 1.73467651e-01f, -1.47993505e-01f, 2.92691320e-01f, -4.22036022e-01f, 1.11185364e-01f, 3.84484619e-01f, 5.52160323e-01f, 3.62257391e-01f, 2.22830236e-01f,
  -2.26445541e-01f, 2.80107498e-01f, 4.86456156e-02f, 3.86508375e-01f, 6.57312453e-01f, -5.88800479e-03f, 3.48052308e-02f, 4.12504584e-01f, 3.53218108e-01f, 3.80726546e-01f,
  4.84626204e-01f, 2.73669273e-01f, -2.68629372e-01f, 3.60978186e-01f, -2.51963735e-01f, -5.51619679e-02f, 8.30695629e-02f, -2.65648395e-01f, 1.04142033e-01f, 3.60372066e-01f,
  1.23236574e-01f, -4.48390782e-01f, -2.87060112e-01f, 2.35887811e-01f, 2.86053181e-01f, -3.19598496e-01f, 3.09466690e-01f, 2.88851798e-01f, 2.31792077e-01f, 1.22590087e-01f,
  5.65731025e-04f, 3.61633331e-01f, 6.00277126e-01f, -1.87353805e-01f, 9.32087153e-02f, 3.58693510e-01f, 1.48914810e-02f, 3.61344628e-02f, -5.35634719e-02f, 2.19765946e-01f,
  -1.19095437e-01f, 3.30977775e-02f, 4.97878194e-02f, 1.41297400e-01f, -2.57582009e-01f, -1.51909441e-02f, -2.22922400e-01f, -3.15160125e-01f, 2.54487365e-01f, 3.41628104e-01f,
  -6.07364058e-01f, 2.59077817e-01f, 4.07539964e-01f, -7.29042850e-03f, -4.37847644e-01f, 3.02545339e-01f, 4.28593019e-03f, -3.86178076e-01f, 3.80011201e-02f, 5.58137357e-01f,
  3.94133210e-01f, -2.03111082e-01f, 2.69396938e-02f, 3.88571411e-01f, 3.79147202e-01f, -3.13356519e-01f, 4.76477116e-01f, -1.25559092e-01f, -3.89434725e-01f, 1.42017066e-01f,
  9.60723162e-02f, 3.41913313e-01f, 4.87363301e-02f, 3.95291336e-02f, 6.60821423e-02f, 9.58636329e-02f, 1.29586667e-01f, -1.58413529e-01f, 4.37597811e-01f, -1.45287648e-01f,
  -3.26751679e-01f, 1.98372662e-01f, -3.93786818e-01f, 3.24221432e-01f, 5.34471631e-01f, 2.45592058e-01f, 4.53400701e-01f, 3.37043345e-01f, 2.87580073e-01f, 1.46590680e-01f,
  3.21348873e-03f, 7.33689740e-02f, 1.41708389e-01f, 2.32319888e-02f, 3.40737224e-01f, 3.51270586e-01f, -3.36715728e-01f, 2.95148432e-01f, -4.61211801e-01f, -3.62724811e-01f,
  1.05495103e-01f, -3.01644616e-02f, 1.45162821e-01f, -3.48379761e-02f, -1.40130166e-02f, 2.70560533e-01f, 1.47177309e-01f, 3.03768069e-01f, 4.31026578e-01f, -3.39536577e-01f,
  -2.13668078e-01f, 6.87430725e-02f, -7.45492661e-03f, 1.23194747e-01f, -4.71129626e-01f, -2.69696712e-01f, 2.78486043e-01f, 4.37613316e-02f, 1.28350303e-01f, 1.20796368e-01f,
  -2.35435255e-02f, 3.72223109e-02f, 2.89267659e-01f, 4.07668263e-01f, 5.69361567e-01f, -2.34639302e-01f, 1.80375576e-01f, 3.36473137e-01f, 9.73591805e-02f, -1.30750701e-01f,
  2.83495188e-01f, 2.69614935e-01f, -1.55167535e-01f, 3.64988327e-01f, 5.05213719e-03f, 8.42802003e-02f, 2.30793908e-01f, 3.82990956e-01f, -1.15105122e-01f, 4.10863370e-01f,
  6.50533885e-02f, -1.92056909e-01f, 3.40002835e-01f, -3.21102701e-02f, -2.12125927e-01f, 1.73992261e-01f, 2.49134570e-01f, 3.42558652e-01f, 1.08927906e-01f, 5.39591193e-01f,
  3.80730867e-01f, 1.26054078e-01f, 3.25276971e-01f, 4.74740982e-01f, 3.06217015e-01f, 1.01993367e-01f, -2.90206164e-01f, 6.07834756e-02f, -1.24954157e-01f, -2.52311140e-01f,
  -1.04460027e-02f, 3.25211674e-01f, -1.04010560e-01f, -3.84623595e-02f, 4.75043327e-01f, 9.79356244e-02f, 2.75330245e-01f, 3.35344553e-01f, 2.45044097e-01f, 1.31922096e-01f,
  1.09936185e-01f, 4.33925211e-01f, -5.96126616e-01f, 4.29619431e-01f, -6.90645874e-02f, 7.58186057e-02f, 1.53509989e-01f, -4.22096014e-01f, 2.89917082e-01f, 5.99373102e-01f,
  -2.51998782e-01f, 3.54412317e-01f, -1.72596470e-01f, -7.51456618e-02f, 6.92477897e-02f, 1.88873842e-01f, -2.16925308e-01f, -5.76401055e-02f, 1.66806996e-01f, 4.11338657e-01f,
  -9.83579606e-02f, -6.91252574e-02f, 2.04177260e-01f, 4.28465456e-01f, -2.06877768e-01f, 4.36115503e-01f, 5.49236715e-01f, -2.16268837e-01f, -1.18909419e-01f, 2.65071958e-01f,
  2.44741708e-01f, -2.13016905e-02f, 1.37882987e-02f, 1.28353551e-01f, -5.94651103e-01f, 6.22221753e-02f, -5.52783683e-02f, -6.20105803e-01f, 4.93374288e-01f, 1.73536763e-01f,
  -1.66099265e-01f, 3.52159679e-01f, 1.81838706e-01f, -1.42169148e-01f, -2.66885072e-01f, 2.14147851e-01f, 4.18607369e-02f, -2.39383340e-01f, -3.69141698e-01f, -5.80632724e-02f,
  3.88088077e-01f, -2.11407900e-01f, 1.11433387e-01f, 4.14597809e-01f, 5.36239982e-01f, -5.09341136e-02f, 1.59681112e-01f, -2.15645209e-01f, -1.84710294e-01f, -4.29773748e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.86600968e-01f, 2.08663881e-01f, 3.17132384e-01f, 7.63838068e-02f, 3.33543360e-01f, 1.31982893e-01f, 1.54972926e-01f, 3.19108307e-01f, 2.48153344e-01f, 1.83584720e-01f,
  2.40992099e-01f, 1.25215694e-01f, 3.56588572e-01f, 3.67898434e-01f, 6.37283325e-02f, 2.26323396e-01f, 1.14918374e-01f, 2.51026869e-01f, 3.07472467e-01f, -2.44969558e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.21388683e-01f, 1.57373860e-01f, 1.68810040e-01f, 4.10034284e-02f, -9.79787577e-03f, -1.02108844e-01f, -2.87310213e-01f, 2.21835002e-01f, 2.28742540e-01f, 1.84194311e-01f,
  2.87061930e-01f, -1.03513198e-03f, -1.02068946e-01f, -1.15383051e-01f, 2.72991806e-01f, -1.55876696e-01f, 1.64408058e-01f, -2.41141796e-01f, 3.76504399e-02f, 1.82203948e-01f,
  2.13570856e-02f, -2.48579547e-01f, -6.28640354e-02f, -2.44607218e-03f, 6.96318969e-03f, 1.87120795e-01f, 1.34925798e-01f, -9.24766511e-02f, -3.85146253e-02f, -9.18969512e-02f,
  1.91555172e-01f, 2.65189379e-01f, 1.63516909e-01f, 1.72007099e-01f, 1.02003433e-01f, -5.79726174e-02f, -1.99204441e-02f, 6.79197013e-02f, 1.72045693e-01f, 1.43053055e-01f,
  -2.57843882e-01f, -4.90823798e-02f, -1.15044624e-01f, 1.48534119e-01f, -9.84431943e-04f, 1.18243292e-01f, -2.31667280e-01f, 9.23752934e-02f, -3.90541973e-03f, 1.28691897e-01f,
  -2.17447639e-01f, -2.84683496e-01f, -2.00244293e-01f, 1.34539381e-01f, 1.74620524e-01f, 1.86661825e-01f, -1.42025650e-01f, -1.17389224e-02f, -4.96271476e-02f, 1.13403484e-01f,
  -2.05385000e-01f, 2.13108301e-01f, 9.82900783e-02f, -1.34420544e-01f, 8.86850283e-02f, 1.16012022e-01f, -9.98720378e-02f, 1.84768096e-01f, -1.61027029e-01f, -2.65144501e-02f,
  -1.20553672e-01f, 7.06641423e-03f, 1.80800527e-01f, 1.56448856e-01f, 9.59905908e-02f, -2.33915716e-01f, -5.54397367e-02f, -3.60057466e-02f, -2.23406218e-02f, -2.14209825e-01f,
  6.17752550e-03f, -4.66777235e-02f, -3.56349260e-01f, 1.23883650e-01f, -1.39745265e-01f, -1.60999805e-01f, 3.02067012e-01f, -1.06806226e-01f, 7.70291984e-02f, 1.25992626e-01f,
  2.63554952e-03f, 9.58817154e-02f, 9.57975164e-02f, -5.58612831e-02f, -1.19794019e-01f, 2.95857340e-01f, 6.33577257e-02f, 2.41231933e-01f, 9.88006294e-02f, -1.21595122e-01f,
  4.20582667e-02f, 2.60819465e-01f, 2.82331437e-01f, -3.84137109e-02f, -5.28285839e-03f, 2.37239093e-01f, -2.40881965e-01f, 2.24761516e-01f, 1.06724061e-01f, 1.46772131e-01f,
  1.47431910e-01f, 3.93526666e-02f, -1.54255956e-01f, -2.35510245e-02f, 1.86288983e-01f, -2.99530569e-02f, -1.21303409e-01f, -3.68225165e-02f, -2.58455694e-01f, 1.94708452e-01f,
  3.12704593e-02f, 1.50138870e-01f, -7.13491365e-02f, 8.52420460e-03f, -4.13426347e-02f, -1.04651667e-01f, -6.16059974e-02f, -4.23454531e-02f, -1.05225965e-01f, -5.35289124e-02f,
  1.04797907e-01f, -7.33179674e-02f, -6.79007322e-02f, -1.18767105e-01f, -3.25808972e-02f, 2.10335344e-01f, 2.61796582e-02f, -2.42930884e-03f, -2.35066772e-01f, 6.70013800e-02f,
  8.47083852e-02f, -7.99927190e-02f, 8.69094133e-02f, -1.12708919e-01f, 2.03155145e-01f, 8.41127932e-02f, -2.90517449e-01f, 1.17921364e-02f, -2.81744953e-02f, 7.56752640e-02f,
  -1.80402502e-01f, 1.27794147e-01f, 1.23231739e-01f, -2.92205125e-01f, -8.31025839e-02f, 5.40897176e-02f, 1.85839057e-01f, 2.14669958e-01f, 5.67889772e-03f, -2.77757078e-01f,
  -1.18250303e-01f, -5.79650290e-02f, 1.76744051e-02f, 5.08577414e-02f, -1.56612501e-01f, -1.95492789e-01f, 7.66455755e-02f, -1.19395249e-01f, -1.18737556e-01f, -9.37872082e-02f,
  9.37150698e-03f, -2.47892424e-01f, -1.52931839e-01f, -1.16330363e-01f, -2.14283481e-01f, 1.69454411e-01f, -5.45221306e-02f, 7.77898505e-02f, 8.57635140e-02f, -1.24608561e-01f,
  -1.86430246e-01f, 1.65326461e-01f, 1.88863039e-01f, 9.81602073e-03f, 8.49417150e-02f, 6.70686737e-02f, 1.27764195e-01f, 1.02217793e-01f, 1.51125029e-01f, 1.66704029e-01f,
  -2.66528428e-01f, 7.55644515e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.27624947e-01f, 3.36392783e-02f, 4.33373779e-01f, 2.45847657e-01f, 1.08591802e-01f, 1.19184650e-01f, 2.16944873e-01f, 3.80270690e-01f, -1.80999950e-01f, -1.35670334e-01f,
  -1.13882892e-01f, 4.69768763e-01f, 6.56107664e-01f, 3.42676580e-01f, 1.31376699e-01f, 1.11957677e-01f, -5.02661318e-02f, 1.48839811e-02f, 2.64165968e-01f, -5.42475246e-02f,
  -4.14523005e-01f, -7.85448705e-04f, -4.18579668e-01f, 5.72753072e-01f, 5.32337666e-01f, 2.87471294e-01f, -1.37551442e-01f, -2.03900918e-01f, -3.12671214e-01f, 1.66770592e-01f,
  4.86685008e-01f, 2.11781830e-01f, -6.14764616e-02f, -2.20648631e-01f, 1.33727610e-01f, -3.08370590e-01f, -2.75233779e-02f, -3.38613182e-01f, 5.57196379e-01f, -1.75216809e-01f,
  -4.84505624e-01f, 3.11552972e-01f, 3.14299107e-01f, 3.98723446e-02f, 2.68131256e-01f, 4.83597547e-01f, 1.40646994e-01f, 1.89715222e-01f, -2.90639818e-01f, 3.67592156e-01f,
  3.04972798e-01f, -1.19757064e-01f, 3.78298134e-01f, 1.52220204e-01f, -2.72351712e-01f, 6.49876520e-02f, 2.84474611e-01f, -1.13167055e-01f, 2.10981861e-01f, 1.11613467e-01f,
  3.00411522e-01f, 5.12367010e-01f, 3.45265657e-01f, -6.37364924e-01f, 2.66950160e-01f, -9.75332111e-02f, 1.65469199e-01f, 4.12373513e-01f, 4.22898173e-01f, 1.27471805e-01f,
  -4.15477872e-01f, 2.66110688e-01f, 2.20343262e-01f, 1.68701693e-01f, 6.42069161e-01f, -3.00979018e-02f, -5.04040718e-02f, 1.01556502e-01f, 1.34949088e-01f, -4.85027373e-01f,
  5.41655362e-01f, -1.49348211e-02f, -2.41107613e-01f, 4.07578796e-01f, 1.44544408e-01f, -3.23867530e-01f, 2.52791882e-01f, -7.43062869e-02f, 3.20637226e-01f, 3.28580439e-01f,
  9.31680128e-02f, -8.51927176e-02f, -1.69530720e-01f, -3.26709934e-02f, 4.43583101e-01f, 6.00248158e-01f, 1.49047807e-01f, -1.07261473e-02f, 2.52090216e-01f, 3.52524012e-01f,
  2.50320077e-01f, 1.89524934e-01f, 1.38410449e-01f, 4.56932813e-01f, -4.03787404e-01f, -3.42425793e-01f, -1.07813539e-04f, -7.67119527e-02f, -4.13853973e-02f, -1.19229637e-01f,
  -1.67218149e-01f, -3.80275637e-01f, 7.84153938e-01f, 9.89991724e-02f, -1.50442630e-01f, 5.35571754e-01f, 1.97378770e-01f, 9.40833837e-02f, 5.39832592e-01f, -1.63700536e-01f,
  2.18382120e-01f, -3.40565518e-02f, -4.20469977e-02f, 5.65183043e-01f, 7.42797107e-02f, 8.15488920e-02f, -3.40421796e-02f, -5.93970232e-02f, 7.50744063e-03f, 2.01837197e-01f,
  -9.67469588e-02f, 1.96308643e-01f, 1.91190690e-01f, 5.16103469e-02f, -3.02527875e-01f, -1.83119178e-01f, -2.10621133e-01f, 3.16442028e-02f, 2.67873377e-01f, -2.53485769e-01f,
  -8.88718888e-02f, -3.51441413e-01f, 1.89531565e-01f, 3.59052271e-02f, 2.80260891e-01f, 3.26978654e-01f, 3.80877793e-01f, -4.30020578e-02f, 4.03582215e-01f, 1.09110244e-01f,
  1.89685941e-01f, 5.29877581e-02f, 1.03799663e-01f, 2.29205683e-01f, 1.06732421e-01f, 2.00203687e-01f, 3.85734379e-01f, -2.39510790e-01f, 1.45721203e-02f, -2.50708014e-01f,
  -7.94736966e-02f, 6.86091790e-03f, -1.92047954e-01f, 1.63423836e-01f, 1.20204069e-01f, -3.20018351e-01f, 6.90064654e-02f, 3.84549946e-01f, -4.68049735e-01f, -2.61925966e-01f,
  7.51936734e-02f, -2.63710469e-01f, -1.65313467e-01f, 3.87745053e-02f, -3.26124609e-01f, 7.65981525e-02f, 1.18934482e-01f, 2.47177050e-01f, 1.33443866e-02f, 3.60496581e-01f,
  1.81753546e-01f, -2.93683223e-02f, 2.64368236e-01f, -3.26991260e-01f, 1.45991027e-01f, 7.61067420e-02f, 2.51196660e-02f, 4.40963447e-01f, 2.12737530e-01f, 2.17547446e-01f,
  -4.26523805e-01f, -2.78041840e-01f, 1.14133261e-01f, -2.04578832e-01f, -8.41962174e-02f, -3.95606875e-01f, -2.32024387e-01f, -1.91720933e-01f, -5.95214851e-02f, 1.64132208e-01f,
  2.62858570e-01f, 4.05181319e-01f, 2.41396278e-01f, -2.51551330e-01f, 1.99013263e-01f, 3.14722098e-02f, 2.30902672e-01f, 3.42075229e-02f, -2.07987547e-01f, -1.03339016e-01f,
  -4.73114818e-01f, 5.19557536e-01f, 1.30123824e-01f, -2.74517059e-01f, 3.65935147e-01f, 7.11892024e-02f, 1.14962064e-01f, -7.72530586e-02f, 3.52044046e-01f, 1.69726744e-01f,
  -8.92759338e-02f, 3.82327050e-01f, 2.36853912e-01f, 6.00575089e-01f, 1.04193561e-01f, -1.69445455e-01f, 1.04271136e-01f, -5.07539511e-02f, 8.26894939e-02f, 2.63109542e-02f,
  -5.08934677e-01f, 3.11839104e-01f, 3.33340079e-01f, 1.13181494e-01f, 2.52284825e-01f, -2.59811819e-01f, -6.03492707e-02f, 8.69948883e-03f, 2.40690529e-01f, -3.81511360e-01f,
  6.86456710e-02f, -2.46440724e-01f, -5.17526150e-01f, 5.23903012e-01f, 2.21424580e-01f, -5.96310422e-02f, 3.20577353e-01f, -6.72150105e-02f, 2.43549690e-01f, 2.18614593e-01f,
  3.36680889e-01f, 1.79896742e-01f, -1.44730717e-01f, -4.86872531e-02f, 3.14366780e-02f, 5.61820447e-01f, -1.47287725e-02f, 2.50866085e-01f, 2.02439442e-01f, 8.18967936e-04f,
  -1.41110271e-01f, 3.66066217e-01f, -3.70893925e-01f, -5.22012770e-01f, 2.77461022e-01f, 9.07603428e-02f, -3.15216780e-01f, -3.55157331e-02f, 1.26902303e-02f, 1.37992293e-01f,
  5.15851267e-02f, 4.59034652e-01f, -4.52286571e-01f, 3.67825627e-01f, 2.86612898e-01f, -4.19200420e-01f, 7.92829394e-02f, 5.68964779e-01f, 1.90269366e-01f, 4.76724297e-01f,
  -2.96297073e-01f, 1.53134495e-01f, 2.71337330e-01f, -3.75552148e-01f, 4.56830114e-01f, 1.34729907e-01f, 8.91874358e-02f, 1.10755399e-01f, 3.15900534e-01f, -1.08108476e-01f,
  3.50623280e-01f, 3.60041440e-01f, 7.20500797e-02f, 2.37411171e-01f, -3.98669928e-01f, 3.32730025e-01f, -2.00315207e-01f, -5.44212580e-01f, -2.94353157e-01f, -3.38038236e-01f,
  -2.35819399e-01f, 1.54288877e-02f, -6.18772864e-01f, -1.81504905e-01f, 3.63977194e-01f, 2.88420141e-01f, -2.10442673e-02f, 3.33803684e-01f, -4.15368915e-01f, 3.82312626e-01f,
  1.19175330e-01f, 4.13074970e-01f, -4.76419441e-02f, 5.36176801e-01f, 4.21001464e-01f, 4.54746634e-02f, -9.23350230e-02f, 1.40480876e-01f, 1.93817109e-01f, 3.84383470e-01f,
  2.44951576e-01f, 2.28169113e-01f, -7.00790435e-02f, 1.57001801e-02f, -3.74361500e-02f, 3.35820854e-01f, -4.49241586e-02f, -4.34502214e-01f, 4.38809246e-02f, 1.09295085e-01f,
  -1.13497697e-01f, 2.70035062e-02f, 6.96705729e-02f, 7.53019145e-03f, 8.22509527e-02f, 6.35662436e-01f, -4.96019125e-01f, 5.31552613e-01f, 6.42181933e-01f, -5.30654550e-01f,
  1.38510525e-01f, 3.53472054e-01f, 5.07235266e-02f, 5.48981309e-01f, -1.29717551e-02f, 4.79678243e-01f, 1.14527382e-01f, -2.50634909e-01f, 5.33464909e-01f, -1.23914167e-01f,
  -2.37065163e-02f, 1.99628159e-01f, 3.67771178e-01f, 4.75792177e-02f, 1.96558237e-01f, -1.41900238e-02f, 1.37221649e-01f, 3.24431092e-01f, 4.49234992e-01f, 4.50208694e-01f,
  -2.05527797e-01f, -3.61307919e-01f, -2.11203039e-01f, -1.84503004e-01f, 1.36427417e-01f, 4.96718407e-01f, -2.36989707e-02f, -3.92369330e-01f, 6.99012935e-01f, -5.44811338e-02f,
  -2.51525939e-01f, -6.56125974e-03f, -1.47570416e-01f, 1.74945012e-01f, 2.12144807e-01f, 4.26451653e-01f, -3.19123268e-01f, 1.43586487e-01f, -2.46123254e-01f, 5.03387690e-01f,
  -4.12381262e-01f, 4.34353292e-01f, 2.74880648e-01f, 1.64872810e-01f, 9.68548954e-02f, 3.47097933e-01f, 4.65403125e-02f, 6.90907165e-02f, -8.13686699e-02f, -3.99269998e-01f,
  -3.38622695e-03f, 1.80914193e-01f, 1.14428811e-02f, 4.17030811e-01f, 3.69531304e-01f, -1.00542180e-01f, 2.15528309e-01f, -3.02420616e-01f, 3.82083446e-01f, 2.14412138e-01f,
  8.86401460e-02f, 2.47906148e-01f, -3.96900363e-02f, 5.41432798e-01f, 5.27827919e-01f, -3.59088451e-01f, -2.83361995e-03f, -6.69998467e-01f, 6.05479658e-01f, -1.76185682e-01f,
  1.99029431e-01f, 3.94053668e-01f, 2.26857319e-01f, -1.77862108e-01f, -7.67417476e-02f, 1.08513661e-01f, 2.03621462e-01f, 1.86662637e-02f, 1.27019674e-01f, 1.52440891e-01f,
  8.44279453e-02f, -4.43518795e-02f, -2.73827612e-01f, 2.38738377e-02f, -4.00588177e-02f, 2.52406716e-01f, 3.73113543e-01f, -4.35130149e-01f, -4.99970645e-01f, -2.68614262e-01f,
  1.65358763e-02f, 2.49809623e-01f, -5.70561141e-02f, 3.14226478e-01f, 6.86615556e-02f, 5.58778822e-01f, 4.66023952e-01f, -1.14824772e-01f, 4.30699557e-01f, -1.11167863e-01f,
  2.32005358e-01f, 3.60802352e-01f, 7.71027446e-01f, 7.91498795e-02f, 3.30865920e-01f, -3.62005204e-01f, -4.49462160e-02f, 5.42820632e-01f, 2.17174768e-01f, -1.12331919e-01f,
  3.82545203e-01f, 1.86716631e-01f, 2.69073159e-01f, 3.56574476e-01f, 1.82992876e-01f, 2.33642876e-01f, 2.74609834e-01f, 3.57202232e-01f, 1.19286023e-01f, 4.59783405e-01f,
  4.55995709e-01f, 3.59452993e-01f, 6.18803859e-01f, -7.08766356e-02f, 2.68981248e-01f, -3.29289228e-01f, 1.30849347e-01f, 2.32708156e-01f, 2.79943377e-01f, -4.57426369e-01f,
  -2.67223507e-01f, 1.30801618e-01f, 7.27543354e-01f, 1.09437704e-01f, -9.20764804e-02f, 7.93223158e-02f, -2.28387684e-01f, 3.02091956e-01f, 5.62402010e-01f, -2.40379974e-01f,
  9.17762071e-02f, 4.28693116e-01f, 2.09646523e-01f, 2.49008343e-01f, -6.27151951e-02f, 4.46249276e-01f, -1.89959273e-01f, 2.36205325e-01f, -2.45069489e-01f, -1.18382663e-01f,
  -3.81038457e-01f, 1.28382459e-01f, 7.70247996e-01f, 5.01379073e-01f, 2.45759130e-01f, 9.89630669e-02f, 1.76048219e-01f, 4.20197099e-02f, -1.20289461e-03f, -2.21421514e-02f,
  3.63785803e-01f, 3.54583830e-01f, 4.16763276e-02f, 1.47406682e-01f, -2.49547735e-01f, -2.42090166e-01f, -5.93033671e-01f, 1.70173064e-01f, 3.75947282e-02f, 5.58094203e-01f,
  -1.53393060e-01f, -3.50531042e-01f, 4.04402763e-02f, 6.80699721e-02f, -1.47949055e-01f, 2.53742456e-01f, 2.11967438e-01f, -1.64948925e-01f, -3.73066306e-01f, 4.79563884e-02f,
  -4.97087866e-01f, -4.62555915e-01f, -4.76002038e-01f, -4.26984161e-01f, -3.25675905e-01f, 4.75685783e-02f, -4.97674048e-01f, 1.55875430e-01f, 3.31384577e-02f, 1.32786408e-01f,
  -1.25304788e-01f, 1.25452533e-01f, -1.26955017e-01f, 4.11207557e-01f, 2.36948803e-01f, 5.33654392e-01f, -3.61535281e-01f, 2.92999059e-01f, 9.58209038e-02f, 4.51958090e-01f,
  1.18830977e-02f, 4.32331234e-01f, 2.95606941e-01f, 1.25426948e-01f, -6.66191941e-03f, 1.72343537e-01f, -1.27113700e-01f, -1.94499157e-02f, 2.26140395e-01f, 1.17774941e-01f,
  2.28142574e-01f, -1.24483675e-01f, -1.51356339e-01f, 2.71789730e-01f, 2.16131255e-01f, -2.82456905e-01f, -9.31607783e-02f, -1.94278068e-03f, 1.42747954e-01f, 1.66803241e-01f,
  4.31916565e-01f, 2.85605907e-01f, -3.34944203e-02f, 3.35390538e-01f, 5.89585602e-01f, -4.10127044e-02f, 5.32261908e-01f, -4.10715759e-01f, -2.07690597e-01f, -9.07811597e-02f,
  6.08577318e-02f, 2.46567249e-01f, 5.63574433e-01f, 1.09054849e-01f, -4.46925223e-01f, -4.27880585e-01f, 2.31828485e-02f, 1.38816252e-01f, 2.98411310e-01f, 3.68061885e-02f,
  2.14209259e-01f, 3.14428300e-01f, 4.08873051e-01f, 1.03037879e-01f, -2.91368991e-01f, -2.12238617e-02f, -4.85605180e-01f, -3.95878851e-02f, 3.95950265e-02f, 1.03413478e-01f,
  -1.09055884e-01f, -8.19141567e-02f, 5.89502752e-01f, 2.02490747e-01f, -2.31326118e-01f, 2.20992655e-01f, 1.35664130e-02f, 1.00109339e-01f, 2.87297577e-01f, 2.91364044e-01f,
  -1.82959855e-01f, -4.39921319e-02f, -3.49759609e-01f, 4.94460225e-01f, -2.77308434e-01f, 5.43317497e-01f, 2.05650151e-01f, 2.65995469e-02f, -3.26069561e-03f, 2.20481679e-01f,
  3.43012959e-02f, 1.25173822e-01f, 2.90580899e-01f, 1.20708913e-01f, 3.52837831e-01f, 9.32828784e-02f, -4.37248379e-01f, -2.99315721e-01f, -3.35742891e-01f, -3.86920154e-01f,
  5.08268736e-02f, 2.55008787e-01f, -4.46596682e-01f, 3.98227334e-01f, -1.28985167e-01f, 3.23639989e-01f, 2.62535721e-01f, -2.61274099e-01f, 1.74106330e-01f, 3.23826253e-01f,
  1.06123857e-01f, 3.88030767e-01f, -4.95803952e-01f, 3.59037369e-01f, 2.01642722e-01f, -3.01649481e-01f, 9.82550010e-02f, -3.33536975e-02f, -7.03665018e-02f, -7.17321336e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.86653638e-01f, 1.49252757e-01f, 7.51328841e-02f, -5.62811270e-03f, 8.89631882e-02f, 1.70355871e-01f, 1.26928128e-02f, 1.74486831e-01f, -4.79707047e-02f, 1.89591810e-01f,
  1.83601454e-02f, 2.97819674e-01f, 3.15597728e-02f, 2.75495835e-02f, 1.29630521e-01f, 3.19543071e-02f, 1.25338301e-01f, 1.02120817e-01f, 1.97120324e-01f, -1.78492013e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -5.25647029e-02f, -1.54244542e-01f, -9.40660164e-02f, -3.73137623e-01f, 3.89134660e-02f, 2.36641854e-01f, -3.57658535e-01f, 1.82013616e-01f, -8.41874480e-02f, 7.74583071e-02f,
  -1.62961960e-01f, 2.67340839e-01f, 4.37912226e-01f, -6.60637990e-02f, -6.33005083e-01f, -6.27088606e-01f, -1.94149852e-01f, -8.48859549e-02f, -6.34794831e-01f, -2.48388201e-01f,
  1.73620850e-01f, 2.22108394e-01f, 3.51027966e-01f, 1.44978806e-01f, -2.45809868e-01f, -5.28142989e-01f, -3.47151071e-01f, 2.42905334e-01f, 1.21844284e-01f, -5.47952235e-01f,
  1.02349050e-01f, 2.90623248e-01f, 2.67701354e-02f, 3.47137332e-01f, -4.43246663e-02f, 2.11975366e-01f, -2.21985266e-01f, -9.42859352e-02f, -3.31617802e-01f, 1.73138171e-01f,
  -3.27129453e-01f, -4.52856198e-02f, -3.60893369e-01f, -1.88498050e-02f, -3.59583259e-01f, 1.38744265e-01f, -5.13345659e-01f, -2.34542936e-01f, 2.82701433e-01f, 7.98073970e-03f,
  -5.91599405e-01f, -6.86067939e-01f, 2.71467745e-01f, 1.08315023e-02f, 3.87198001e-01f, -5.36101282e-01f, -3.80814821e-01f, 1.37136936e-01f, -4.28092748e-01f, -1.45738989e-01f,
  3.35292041e-01f, 3.16989236e-02f, -1.11990541e-01f, 2.50276953e-01f, -2.57083863e-01f, 4.06052060e-02f, -2.90531963e-02f, 1.90613046e-01f, -3.25348139e-01f, -1.40330642e-01f,
  2.48105913e-01f, -2.18135603e-02f, 4.27027643e-01f, -2.99310181e-02f, -1.64181571e-02f, 3.36438566e-02f, -3.65434110e-01f, -3.63046676e-01f, 1.53197303e-01f, -3.17459643e-01f,
  -7.78137222e-02f, -3.37137640e-01f, 3.73496860e-01f, 1.93162143e-01f, 3.49121600e-01f, 2.51444012e-01f, 3.38027209e-01f, -4.07563418e-01f, 2.43918508e-01f, 3.98227125e-01f,
  -2.26392344e-01f, -4.33088511e-01f, -3.12002242e-01f, -1.26753926e-01f, -4.46373284e-01f, -1.57479391e-01f, -1.68891281e-01f, 2.79820949e-01f, 7.67681077e-02f, 1.36709347e-01f,
  -2.30807409e-01f, -1.31848752e-01f, 2.61234343e-01f, -1.27534583e-01f, -1.31560907e-01f, 9.44294035e-02f, 1.37616381e-01f, -8.90515894e-02f, 3.42246801e-01f, 2.25297868e-01f,
  2.99476653e-01f, -3.63652736e-01f, -3.85016769e-01f, -2.80475318e-01f, 4.20657694e-01f, 3.44382882e-01f, -6.70787454e-01f, -5.57155252e-01f, -5.72135866e-01f, -1.22727908e-01f,
  1.78299978e-01f, -2.56830394e-01f, 2.82502025e-01f, -3.61519866e-02f, -5.69488883e-01f, -4.31463748e-01f, -2.00218394e-01f, -2.41279528e-01f, 4.06622201e-01f, -7.31839240e-02f,
  3.56003344e-01f, 1.03099011e-01f, 2.23271638e-01f, 2.75773227e-01f, 8.08256119e-02f, 2.35794708e-01f, -2.38795817e-01f, 8.32961053e-02f, 3.09536755e-01f, -4.77604538e-01f,
  3.07010949e-01f, -2.20668197e-01f, 2.44719759e-01f, 2.71121949e-01f, -1.92761302e-01f, -1.61937952e-01f, -3.50505710e-01f, -1.38061777e-01f, -2.97763884e-01f, 3.43813598e-01f,
  -2.30464503e-01f, 3.54393691e-01f, -4.81135488e-01f, -4.48662609e-01f, 2.97958225e-01f, 2.52818484e-02f, -2.28861887e-02f, -3.10429871e-01f, 2.78082103e-01f, -1.65245265e-01f,
  6.17653690e-03f, -2.28489444e-01f, 2.96310753e-01f, 1.76863804e-01f, 2.09612641e-02f, -2.05599070e-01f, -3.34769517e-01f, 1.41158536e-01f, 1.80831440e-02f, -3.84673625e-01f,
  2.72431970e-01f, 3.59812945e-01f, -4.94187683e-01f, -1.73313200e-01f, -3.27399284e-01f, 3.43591899e-01f, 1.38978258e-01f, 2.11703286e-01f, -2.71866888e-01f, -2.94972092e-01f,
  -4.80249040e-02f, 1.99688524e-01f, -7.98360165e-03f, 3.36624920e-01f, 6.93733692e-02f, -2.27343619e-01f, -6.17365301e-01f, 3.57900351e-01f, 3.76693279e-01f, 1.00737803e-01f,
  3.66976947e-01f, -2.18395889e-02f, 1.55669689e-01f, 1.74266338e-01f, -2.22318575e-01f, -2.33579025e-01f, 1.35739565e-01f, 1.98793281e-02f, 5.30504212e-02f, -2.12553114e-01f,
  1.02257334e-01f, 9.49433167e-03f, -3.18772793e-01f, 3.66342276e-01f, -7.39731073e-01f, -5.23469985e-01f, 1.63102224e-01f, 3.04285318e-01f, 1.15971245e-01f, 4.20932561e-01f,
  1.14193641e-01f, 3.50130558e-01f, -4.82446313e-01f, 2.25173846e-01f, -4.71952617e-01f, -1.15478098e-01f, 3.45901012e-01f, 2.46242896e-01f, -2.73632169e-01f, -4.12517250e-01f,
  1.68121278e-01f, 2.62622144e-02f, -9.95430872e-02f, -3.23679894e-01f, 1.53933495e-01f, -2.29548082e-01f, -1.82398811e-01f, -2.52958119e-01f, -1.87159225e-01f, 1.47131681e-01f,
  -4.53892946e-01f, 2.68760085e-01f, 8.40620399e-02f, 2.19017975e-02f, 3.76101658e-02f, -2.99624532e-01f, 1.92315757e-01f, 2.58604884e-01f, -5.72260499e-01f, -5.19059181e-01f,
  -3.26118112e-01f, -1.34888873e-01f, 2.59188712e-01f, -4.03133422e-01f, 7.06932023e-02f, -6.73777997e-01f, -9.93533293e-04f, 1.90467194e-01f, -2.66772598e-01f, -1.62804931e-01f,
  2.25769728e-01f, 1.69992626e-01f, 1.96102378e-03f, -1.65312842e-01f, 2.65832841e-01f, -3.05871457e-01f, 1.99560270e-01f, -1.85211018e-01f, 9.88005847e-02f, 7.97007158e-02f,
  -2.28327870e-01f, 5.23604341e-02f, -6.02482334e-02f, -1.71553358e-01f, -1.96545944e-01f, -1.19014882e-01f, -1.22637562e-01f, 1.84037238e-01f, -4.67269987e-01f, 3.78343463e-01f,
  -2.64293432e-01f, 1.97841555e-01f, 1.95043236e-01f, 2.93199569e-01f, -2.29240194e-01f, -4.13669944e-01f, -3.07826757e-01f, -5.62226176e-01f, 1.17550299e-01f, -3.97572845e-01f,
  3.94751638e-01f, 2.18430147e-01f, -4.50302139e-02f, -3.07792187e-01f, -4.00602013e-01f, 2.73010999e-01f, -7.71098363e-04f, 1.08577132e-01f, -2.44142219e-01f, -1.84508227e-02f,
  2.32896209e-02f, 9.14114267e-02f, -2.09826697e-02f, 2.37607598e-01f, 2.41809696e-01f, 3.68676573e-01f, 4.58041012e-01f, -3.70812714e-01f, -3.47706199e-01f, 3.73230278e-01f,
  -2.31965352e-02f, -7.21645296e-01f, 1.08326003e-01f, -2.58180369e-02f, -1.35196950e-02f, -8.35055411e-02f, 1.60774246e-01f, 2.56661981e-01f, -2.18673542e-01f, 4.22765702e-01f,
  -2.73606144e-02f, 3.15424532e-01f, -6.48361146e-01f, 1.23475783e-01f, -2.01054275e-01f, -5.75715721e-01f, 4.11020756e-01f, -5.72409928e-01f, 1.78108662e-01f, 1.08380832e-01f,
  -2.89015114e-01f, 7.70462751e-02f, -1.45991758e-01f, -1.95595130e-01f, 2.84812212e-01f, 1.91158615e-02f, 2.96007574e-01f, -2.75174946e-01f, -1.51742995e-01f, 1.48772374e-01f,
  -3.27222109e-01f, -3.50336581e-01f, 2.53223747e-01f, 2.98406184e-02f, 5.29822260e-02f, -4.95818287e-01f, 4.03914392e-01f, -4.24517721e-01f, -2.47874871e-01f, -2.94381410e-01f,
  1.34423137e-01f, -4.05626655e-01f, 5.13338566e-01f, -5.08808672e-01f, 1.37544379e-01f, 1.47199817e-02f, 3.36033016e-01f, -2.63243932e-02f, -2.78817505e-01f, -3.70468229e-01f,
  -5.15874684e-01f, -4.67739075e-01f, -1.48963362e-01f, 1.22956812e-01f, 8.23443681e-02f, 2.27476701e-01f, 3.86176817e-02f, -4.52171937e-02f, -7.95041621e-02f, -2.42523983e-01f,
  3.58744502e-01f, -2.15021566e-01f, 1.79791242e-01f, -4.77658868e-01f, -4.67728108e-01f, -4.46852177e-01f, 2.08679378e-01f, 2.10811555e-01f, -1.42236182e-03f, -1.03541225e-01f,
  2.05273867e-01f, 3.67113411e-01f, -3.07570770e-02f, -5.25754571e-01f, -2.66680688e-01f, 1.46927536e-01f, 2.32649714e-01f, -5.09713106e-02f, 1.31846964e-01f, 2.73018301e-01f,
  -5.92469752e-01f, 3.54725331e-01f, 2.37991527e-01f, -3.91241759e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.83210057e-02f, -9.56429169e-02f, 1.62868693e-01f, 1.42219290e-01f, -1.01169929e-01f, 8.83491486e-02f, 1.06838616e-02f, 3.19303907e-02f, -1.17744431e-01f, 1.54908940e-01f,
  1.89608559e-01f, 1.69393286e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    