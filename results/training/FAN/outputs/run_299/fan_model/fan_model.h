/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.60433143e-01f, 2.31435016e-01f, 1.74581975e-01f, -3.45812552e-02f, -3.69400054e-01f, -2.38578677e-01f, -5.92308678e-02f, -1.31254867e-01f, 2.08372455e-02f, 1.93666622e-01f,
  -3.59195210e-02f, 2.06375197e-01f, 2.72059351e-01f, -6.95760399e-02f, -2.89101630e-01f, 1.69008315e-01f, -1.97605297e-01f, -1.64956949e-03f, -8.17331672e-02f, -2.00098470e-01f,
  -9.65912342e-02f, -2.99160570e-01f, 5.86900115e-02f, -1.46009311e-01f, -1.68813482e-01f, 7.72604346e-02f, -3.46546210e-02f, 1.23773061e-01f, -1.07767470e-01f, 3.85005251e-02f,
  -1.39550373e-01f, -2.30287183e-02f, 7.41301663e-03f, 1.29598543e-01f, -1.10074684e-01f, 5.66216791e-03f, 4.06912342e-02f, 3.94890048e-02f, 3.84905487e-02f, 8.30285251e-03f,
  2.87453993e-03f, -6.36658370e-02f, -6.61290577e-03f, 4.32959050e-02f, -2.29315534e-02f, -3.64998579e-02f, -2.17755735e-02f, 1.53578119e-02f, 2.76548266e-02f, -4.65814993e-02f,
  5.37389815e-02f, 3.55478674e-02f, 2.08268482e-02f, 6.62445743e-03f, 3.38275277e-04f, -3.70360129e-02f, -1.81187596e-02f, 5.18034920e-02f, -3.83596830e-02f, -3.48434299e-02f,
  -2.86725373e-03f, 2.04810817e-02f, 2.57500727e-02f, -1.90339163e-02f, 2.14577764e-02f, -1.90712456e-02f, 3.21092620e-03f, 4.55112383e-02f, -1.19636992e-04f, 1.18989879e-02f,
  -5.46800271e-02f, 3.73820662e-02f, -6.67873956e-03f, -1.53603954e-02f, 1.07825650e-02f, -7.87498336e-03f, -3.82633391e-03f, -2.63999263e-03f, -1.91576760e-02f, -1.07923280e-02f,
  5.08969575e-02f, -2.39068475e-02f, 5.87073490e-02f, -1.47003289e-02f, -3.74443345e-02f, 5.37071005e-02f, 2.25687809e-02f, 3.33280712e-02f, -3.73509638e-02f, -9.53699742e-03f,
  -2.06213906e-01f, -8.38037133e-02f, -1.76157355e-02f, -6.22061715e-02f, -1.41084651e-02f, -2.91228518e-02f, -7.56951608e-03f, -1.22799100e-02f, -6.69811806e-03f, -8.57698247e-02f,
  -2.59366874e-02f, 2.47170869e-03f, -6.86699077e-02f, -6.73744967e-03f, -4.17272709e-02f, -3.22646648e-02f, -1.52944038e-02f, -2.06018034e-02f, -1.05100743e-01f, 4.79387818e-03f,
  1.27442915e-03f, -6.74648955e-02f, 1.61399934e-02f, -9.31836367e-02f, -2.95321550e-03f, -1.80117600e-02f, -2.01730039e-02f, 5.39821461e-02f, -1.10468129e-02f, -1.97987556e-02f,
  -3.35246116e-01f, 5.41254759e-01f, -2.00201079e-01f, 1.43974768e-02f, 7.07293674e-02f, -8.40324350e-03f, -1.37069836e-01f, 1.96434140e-01f, -7.76962489e-02f, 3.55220139e-01f,
  1.96449727e-01f, -5.39493263e-02f, 4.13608402e-02f, 3.17901134e-01f, -3.65388989e-01f, 4.36975062e-03f, 8.77603143e-02f, 4.81778048e-02f, -8.56666490e-02f, 8.55711624e-02f,
  -8.20195377e-02f, 2.65702367e-01f, -1.64061859e-02f, 2.67001122e-01f, 9.34189484e-02f, -3.39547135e-02f, -7.49717727e-02f, -7.11942986e-02f, 1.76224664e-01f, -1.94364134e-02f,
  3.69700864e-02f, 1.05736107e-01f, 5.15789315e-02f, -5.89710660e-02f, -7.72230923e-02f, -5.31021878e-02f, -7.38338679e-02f, -6.48190454e-02f, -8.55422206e-03f, 1.06478035e-02f,
  -8.11137259e-02f, -5.40324114e-03f, 1.61576159e-02f, -1.23928972e-02f, 4.74354960e-02f, -2.63213273e-02f, 4.29126732e-02f, -2.93802004e-03f, 4.38756682e-02f, 4.13422473e-02f,
  1.33740148e-02f, 1.71058550e-02f, -3.74719612e-02f, 5.43731414e-02f, -5.98355867e-02f, -3.73179605e-03f, -1.70267578e-02f, -6.39121011e-02f, -2.34250315e-02f, -1.73502490e-02f,
  2.97794258e-03f, -6.63928166e-02f, 3.97775136e-02f, 4.66692029e-03f, 4.55382802e-02f, 3.73696312e-02f, 2.27251463e-02f, 2.76868306e-02f, -8.23235139e-02f, 2.86200270e-02f,
  -2.76634675e-02f, 6.92384690e-02f, 4.01154384e-02f, 1.56387258e-02f, 2.96719093e-02f, 5.19882441e-02f, -5.22439852e-02f, 6.99833501e-03f, -2.00718250e-02f, 1.10800071e-02f,
  2.15571397e-03f, -3.66162416e-03f, 5.37149496e-02f, -1.36049965e-03f, 7.81568978e-03f, -4.97734286e-02f, 3.79822664e-02f, -1.02470135e-02f, -4.13984284e-02f, -6.38453364e-02f,
  8.93473700e-02f, 1.09525621e-01f, -6.37111161e-03f, 6.71746433e-02f, 1.37322852e-02f, 6.96963817e-02f, 1.74688678e-02f, 4.13067788e-02f, -6.25222623e-02f, -3.82812065e-03f,
  -2.31099967e-02f, 1.39804734e-02f, -1.85960066e-02f, 1.64321420e-04f, -5.15761636e-02f, 5.25844619e-02f, -3.57545316e-02f, -3.81038077e-02f, -7.09325969e-02f, 1.52438339e-02f,
  1.32135693e-02f, 1.08573791e-02f, -1.78766586e-02f, -4.72136121e-03f, -1.10910973e-02f, -1.81143880e-02f, -1.96483321e-02f, -1.58990715e-02f, -1.37875229e-02f, 1.68592688e-02f,
  -2.44594425e-01f, 3.77526551e-01f, 2.86783546e-01f, -2.57137805e-01f, -1.98845759e-01f, -2.77739298e-02f, -1.59005210e-01f, -4.79460098e-02f, -1.24411121e-01f, -4.72895913e-02f,
  -3.42033952e-01f, 2.38131270e-01f, 1.28115043e-01f, -3.02134156e-01f, -1.65938258e-01f, -4.67248401e-03f, -1.68007240e-01f, -2.87661552e-02f, 2.26396155e-02f, -3.76089476e-02f,
  -8.73758867e-02f, -4.01230454e-01f, 6.66483343e-02f, -1.54499328e-02f, -1.52165622e-01f, 1.37420371e-01f, -8.58882889e-02f, 1.36569470e-01f, 8.70013330e-03f, 1.43520646e-02f,
  -1.38353378e-01f, -9.70295519e-02f, 2.15477701e-02f, 9.41902623e-02f, -2.86544897e-02f, 2.26627779e-03f, 1.37065761e-02f, 1.83039941e-02f, -2.56863292e-02f, -4.01628297e-03f,
  4.78286780e-02f, 1.00339297e-02f, -7.93751180e-02f, 2.18088203e-03f, -2.43083443e-02f, 9.57993139e-03f, -1.95343941e-02f, 4.11745794e-02f, 1.23125557e-02f, -7.90443458e-03f,
  3.77090201e-02f, 5.01346355e-03f, -2.65107807e-02f, 2.79911365e-02f, 6.40450791e-02f, -4.45795208e-02f, 3.57872546e-02f, 7.56811574e-02f, -1.36067974e-03f, -1.48531655e-03f,
  -1.54919503e-03f, 6.39308169e-02f, 2.48865671e-02f, 4.71610110e-03f, 2.36158390e-02f, -1.98190343e-02f, -4.94616032e-02f, 1.59706287e-02f, 4.85215224e-02f, 1.33566314e-03f,
  -1.82875358e-02f, -3.51143703e-02f, -6.91777244e-02f, 1.22764073e-02f, -6.81201741e-02f, -2.85554193e-02f, 6.95924461e-03f, -1.74887870e-02f, 7.88194314e-03f, 3.42446119e-02f,
  -3.27705406e-03f, -4.66425009e-02f, 2.82191322e-04f, 2.15158556e-02f, 3.48728313e-03f, -3.43782343e-02f, 2.00613937e-03f, 5.00034615e-02f, -5.42535540e-03f, -1.62267927e-02f,
  1.16910599e-01f, 2.51659274e-01f, 1.63446590e-02f, -1.08874403e-02f, 8.73691589e-02f, 1.59572475e-02f, 2.12523527e-02f, -2.59289667e-02f, 3.86351310e-02f, 1.05448207e-02f,
  2.24528909e-02f, -5.65271154e-02f, 6.58940598e-02f, -6.75275475e-02f, 2.91088317e-02f, -1.54410144e-02f, -9.61298496e-03f, -3.08251213e-02f, -4.03175279e-02f, 4.38308790e-02f,
  7.44462386e-03f, -5.39674517e-03f, -1.78559124e-02f, -6.69464329e-03f, -6.75517321e-02f, -2.70867199e-02f, -1.03801899e-02f, 4.99036983e-02f, 4.01767250e-03f, 6.63469872e-03f,
  -1.16448663e-01f, 2.72602528e-01f, 4.87881415e-02f, -2.04826266e-01f, 4.31287521e-03f, 1.49060071e-01f, -2.19632044e-01f, 9.85344648e-02f, -2.66995192e-01f, 1.07342884e-01f,
  -1.56715494e-02f, 9.34710503e-02f, -2.05640063e-01f, 8.16320181e-02f, -2.84604460e-01f, -2.90125102e-01f, -6.17814586e-02f, 5.60424179e-02f, -1.29605040e-01f, 5.24692163e-02f,
  -1.27149507e-01f, 1.85827315e-02f, -1.25403538e-01f, 2.19366536e-01f, 6.80371225e-02f, 1.28731474e-01f, -4.44190875e-02f, 6.11478612e-02f, 3.24075460e-01f, 1.67692468e-01f,
  2.93787755e-02f, -5.73076606e-02f, 5.15866280e-02f, -2.85496544e-02f, -1.37687568e-02f, 1.44150862e-02f, 8.84312168e-02f, 2.80449651e-02f, -4.96586338e-02f, -1.05117811e-02f,
  -6.16427977e-03f, 6.64121732e-02f, 6.10903874e-02f, -2.74237413e-02f, 1.43681206e-02f, 2.94286292e-02f, 4.02034260e-02f, 9.46181826e-03f, 3.41131277e-02f, 4.01699655e-02f,
  -5.83676994e-02f, 7.26190284e-02f, -3.78708728e-02f, -4.84965183e-03f, -5.44765070e-02f, 1.34399524e-02f, -1.93945039e-03f, 6.62535951e-02f, 8.09935257e-02f, 8.55031714e-04f,
  2.56555602e-02f, 3.76873068e-03f, -3.35332677e-02f, 5.00845583e-03f, 8.05716682e-03f, -5.28273080e-03f, 1.01040909e-02f, -1.52523294e-02f, -5.71123026e-02f, 1.17337983e-02f,
  -7.62683526e-03f, -3.19405235e-02f, -6.10435614e-03f, 3.38396232e-04f, 2.67334580e-02f, -4.39630076e-02f, -4.89884429e-03f, 7.12317750e-02f, -3.79526094e-02f, 1.17983324e-02f,
  -4.66980301e-02f, 4.46812473e-02f, -1.30679077e-02f, 3.23473513e-02f, -2.88308263e-02f, -3.40692396e-03f, -6.95607858e-03f, 4.85065021e-02f, -2.24663187e-02f, -2.83919387e-02f,
  9.02679637e-02f, 2.89332494e-02f, 4.78124898e-03f, 5.62861608e-03f, -8.02381430e-03f, 9.26938280e-02f, -1.98182128e-02f, 4.31775413e-02f, 1.93767957e-02f, -4.15873481e-03f,
  2.76246648e-02f, -3.97499427e-02f, -1.95722980e-03f, 3.58580835e-02f, 1.70301143e-02f, 3.16383354e-02f, -3.44172828e-02f, 4.47795279e-02f, -4.15882431e-02f, 1.25372753e-01f,
  1.80980843e-02f, -2.18206011e-02f, -1.04503958e-02f, -1.41146360e-02f, 6.86331093e-02f, -2.28984635e-02f, 5.67156561e-02f, 9.70354490e-03f, 6.55852705e-02f, 3.48919164e-03f,
  9.68564972e-02f, -4.70417887e-01f, -2.52835870e-01f, -7.33002126e-02f, 2.81236887e-01f, -1.72691241e-01f, 1.00684902e-02f, -5.27767874e-02f, -3.70742232e-02f, -1.39007464e-01f,
  6.41253293e-02f, -2.38245249e-01f, -2.31500212e-02f, -4.02402163e-01f, -1.35461241e-01f, -2.31299490e-01f, -2.94704735e-01f, -1.31728321e-01f, -5.99379279e-02f, -4.19137180e-02f,
  -6.84002414e-02f, -3.97768840e-02f, -1.64926872e-01f, 2.88214311e-02f, 5.52742481e-02f, 7.77722150e-02f, 2.59335607e-01f, 1.61257699e-01f, -1.07364051e-01f, 7.48122996e-03f,
  -8.54734108e-02f, -1.17417797e-02f, -6.86330535e-03f, -5.33599071e-02f, -2.17617732e-02f, 6.28993213e-02f, 1.27977440e-02f, 2.39706524e-02f, 5.61036766e-02f, -5.10842316e-02f,
  4.56621759e-02f, -9.31245275e-03f, -3.63203026e-02f, 2.15121694e-02f, 8.90994966e-02f, -7.26197138e-02f, -7.15289488e-02f, -5.71748707e-03f, -1.26841199e-02f, -6.55057728e-02f,
  -6.89487159e-02f, 2.01469418e-02f, 5.89638576e-02f, -8.51894692e-02f, -1.83430035e-02f, -9.12169367e-03f, -2.29629204e-02f, -5.90780973e-02f, -1.02606528e-02f, -5.39055560e-03f,
  3.57700214e-02f, 3.46388705e-02f, -1.77816320e-02f, 1.89082641e-02f, -1.02157742e-02f, -2.90014490e-04f, -7.07574375e-03f, 2.14989427e-02f, 2.76020281e-02f, -1.42308008e-02f,
  -3.09636421e-03f, -9.49670654e-03f, -7.94816948e-03f, 9.97172482e-03f, 2.24001110e-02f, 7.31376640e-04f, 1.92718618e-02f, 5.82203828e-03f, 1.24732647e-02f, -1.07279909e-03f,
  2.14850921e-02f, -8.06869939e-03f, -6.89033046e-03f, 6.05565310e-02f, -5.42917736e-02f, 5.07878214e-02f, 5.34497295e-03f, -3.93825658e-02f, 2.99689528e-02f, 7.33725354e-02f,
  -5.36042824e-02f, -1.47537127e-01f, -7.18518198e-02f, 1.14644980e-02f, -3.18228453e-02f, -1.13901999e-02f, -3.16738933e-02f, -4.89160456e-02f, -5.83752692e-02f, 4.64124465e-03f,
  1.53089883e-02f, 4.88298312e-02f, 2.13021599e-02f, 8.92134011e-03f, -1.85828898e-02f, 3.82246040e-02f, 5.05151935e-02f, 3.54158282e-02f, 1.65796541e-02f, 9.25584882e-03f,
  1.17479168e-01f, 3.96080390e-02f, -1.89016107e-02f, 8.64907801e-02f, 2.60153487e-02f, 6.71700537e-02f, 2.50121765e-02f, 9.06720478e-03f, 2.07527149e-02f, -4.26820666e-02f,
  -2.66696185e-01f, 3.16392750e-01f, -2.13631615e-01f, -2.29928419e-01f, -1.53635861e-02f, -9.74813327e-02f, -2.34945148e-01f, 7.98077434e-02f, 9.44665223e-02f, 2.62720168e-01f,
  2.14624386e-02f, 1.08672585e-02f, 1.30861387e-01f, -1.86768100e-01f, -2.17393577e-01f, 1.57481432e-01f, -9.60580930e-02f, 3.60216685e-02f, 2.87851915e-02f, 8.25767368e-02f,
  -7.88665712e-02f, -6.35583624e-02f, -2.30522811e-01f, 1.70988142e-01f, -8.69624764e-02f, 7.14602135e-03f, 9.33731794e-02f, 4.62058000e-02f, -9.80323255e-02f, -1.06640443e-01f,
  -6.22114614e-02f, 4.66513969e-02f, -6.21595047e-02f, 2.58572437e-02f, 3.22670527e-02f, 4.51881858e-03f, 5.54491915e-02f, -3.22954617e-02f, -7.14089125e-02f, -1.60075957e-03f,
  6.34952113e-02f, -4.46056090e-02f, -4.09914590e-02f, -3.84338982e-02f, 3.06787994e-03f, -5.98482788e-02f, -2.64803264e-02f, -4.87887971e-02f, -6.06291257e-02f, -6.17157072e-02f,
  -9.04301479e-02f, 1.92579953e-03f, -4.50491048e-02f, 2.41062306e-02f, -9.56928416e-04f, -2.76601650e-02f, -6.70901015e-02f, -4.16009128e-03f, -1.00652026e-02f, 3.42229716e-02f,
  7.98531771e-02f, 2.86868098e-03f, -2.68540625e-02f, -7.20593408e-02f, -8.48059208e-05f, -8.52283835e-02f, -8.19174387e-03f, -1.52980722e-02f, -2.76971608e-02f, 4.50913869e-02f,
  -6.56951545e-03f, -1.18899401e-02f, 2.96189319e-02f, -3.54703292e-02f, -3.01194917e-02f, -2.59686913e-02f, -1.09328749e-02f, -1.50555540e-02f, 2.51817908e-02f, -4.26309705e-02f,
  2.56363507e-02f, 1.38732167e-02f, 4.96999398e-02f, -3.09841279e-02f, 3.43011059e-02f, 8.24896153e-04f, 2.39777397e-02f, -3.50259542e-02f, 1.50868557e-02f, -3.14518809e-02f,
  3.20770055e-01f, 2.69404888e-01f, -4.66730669e-02f, 4.18553613e-02f, 5.65426387e-02f, 9.57312509e-02f, 3.02886707e-03f, 8.05042405e-03f, 9.37414542e-02f, 4.07393090e-02f,
  1.97227634e-02f, -1.87283345e-02f, 8.83244425e-02f, 3.48275267e-02f, 3.93910594e-02f, 6.63091838e-02f, 4.46874052e-02f, 6.13132827e-02f, 6.47813603e-02f, 3.32235694e-02f,
  3.61935571e-02f, 1.50084971e-02f, -4.76519875e-02f, -1.23331025e-02f, -8.20837542e-03f, -2.95808744e-02f, 4.54927348e-02f, -2.10208222e-02f, 7.34503905e-04f, -3.19666718e-03f,
  -3.05276215e-01f, 2.62924939e-01f, -1.75402537e-02f, -2.69211888e-01f, -1.45650730e-01f, 1.04694560e-01f, 5.96661530e-02f, 2.43769903e-02f, 9.86111760e-02f, 2.98538864e-01f,
  3.83654274e-02f, -2.46752933e-01f, 1.70486584e-01f, -4.64100540e-02f, -2.88301617e-01f, 2.23232090e-01f, 1.29502194e-04f, -9.21364799e-02f, 6.65720478e-02f, -8.10284242e-02f,
  -1.90010861e-01f, -1.60189018e-01f, -1.26622081e-01f, 8.35867673e-02f, -1.71460092e-01f, -9.86236706e-02f, -1.10686585e-01f, 1.35739595e-02f, -1.60802469e-01f, -1.04582429e-01f,
  -2.19801888e-02f, 5.52611351e-02f, -4.29768898e-02f, 3.88790406e-02f, -9.18438099e-03f, -2.99044698e-02f, -3.30725871e-02f, -9.08546448e-02f, -5.06569259e-02f, 4.99688601e-03f,
  3.16379359e-03f, -8.40301141e-02f, -2.08082013e-02f, -3.51796001e-02f, -5.69210164e-02f, 1.46672530e-02f, 1.06815472e-02f, 5.66810463e-03f, -1.67232417e-02f, -7.13229254e-02f,
  6.08995222e-02f, 3.50318253e-02f, -5.51800393e-02f, 3.29214556e-04f, -7.01511279e-02f, 2.35674214e-02f, 1.58836488e-02f, -3.26577798e-02f, -1.88987479e-02f, -1.69104675e-03f,
  2.41638646e-02f, 1.51848737e-02f, 4.06189300e-02f, 2.03058533e-02f, 2.38760584e-03f, 2.48434357e-02f, 1.84237044e-02f, 5.25692385e-03f, 6.34645252e-03f, 3.11266873e-02f,
  2.16910578e-02f, -2.28063110e-03f, -1.20455166e-02f, -2.54900078e-03f, -7.85629090e-04f, -7.59020820e-03f, -6.93461969e-02f, 5.45754097e-02f, -5.87733416e-03f, -5.26760034e-02f,
  1.53286075e-02f, 8.37040879e-03f, 2.55127493e-02f, 1.07391877e-02f, 3.66329551e-02f, 7.10458914e-03f, -2.24424414e-02f, 3.64912450e-02f, -2.38512531e-02f, -4.92119268e-02f,
  7.91263059e-02f, 1.22680567e-01f, 7.86166862e-02f, -4.14662175e-02f, 8.65591243e-02f, -7.15435133e-04f, -5.73848560e-03f, 1.97785273e-02f, 2.96609905e-02f, 4.83543277e-02f,
  -6.51397631e-02f, 3.31918746e-02f, 9.59492475e-03f, -5.07121943e-02f, 3.13055962e-02f, 5.24914172e-03f, -1.38508035e-02f, 1.39342928e-02f, -4.00510617e-02f, -3.06595806e-02f,
  -3.17666940e-02f, -4.65223566e-03f, 1.69418436e-02f, 5.24548478e-02f, -5.81570948e-03f, 2.15559565e-02f, -4.28418592e-02f, 8.29072483e-03f, -6.08289475e-03f, 3.15549187e-02f,
  4.88347635e-02f, 1.18098572e-01f, -2.53131270e-01f, -8.03030841e-03f, -2.75764633e-02f, -1.10402070e-01f, -1.50968313e-01f, -5.84667027e-02f, 1.52830333e-01f, 1.30490050e-01f,
  -2.59523746e-02f, 2.34706402e-01f, -1.85715154e-01f, -1.12838730e-01f, -3.18269014e-01f, -2.12673560e-01f, -2.46224061e-01f, -9.32370499e-02f, -3.35872471e-02f, -6.86743781e-02f,
  -1.86208040e-01f, -1.10776477e-01f, -3.32304746e-01f, -5.72435148e-02f, -6.91642761e-02f, 3.25134769e-02f, -2.79684421e-02f, -1.02217846e-01f, -4.02755216e-02f, -1.15828654e-02f,
  -3.16655375e-02f, 1.02758877e-01f, -2.94466168e-02f, -6.25652224e-02f, -6.02461435e-02f, -7.86367506e-02f, -2.43139192e-02f, -1.26602836e-02f, -5.45589440e-02f, -3.51123996e-02f,
  6.19830228e-02f, 9.28869657e-03f, 3.62579525e-02f, 6.74831774e-03f, 2.54890844e-02f, 4.30117622e-02f, -3.10568772e-02f, -6.27358556e-02f, 1.24934986e-02f, 8.95499892e-04f,
  -9.10941362e-02f, 3.08756251e-02f, -5.97061478e-02f, -1.70712806e-02f, -4.97343317e-02f, -8.57309252e-03f, 3.02645359e-02f, -4.58909087e-02f, 1.84231829e-02f, 5.02835326e-02f,
  1.45689994e-02f, -6.06455877e-02f, -9.40037593e-02f, -5.14357388e-02f, -2.21216232e-02f, -1.12457760e-03f, -6.53133467e-02f, 5.30951750e-03f, 3.69731374e-02f, 1.88912284e-02f,
  1.13447160e-02f, 2.44758483e-02f, -3.10933515e-02f, 2.20150892e-02f, -1.90342460e-02f, 2.95549762e-02f, -3.19249630e-02f, 5.11140078e-02f, -5.64915910e-02f, -4.16806974e-02f,
  2.11341437e-02f, -4.84751128e-02f, -3.72821763e-02f, -1.79652460e-02f, -3.42953913e-02f, 1.01449853e-03f, 3.99436466e-02f, 4.61915173e-02f, -6.30883276e-02f, -3.35566960e-02f,
  1.47331809e-03f, 3.46035026e-02f, 2.57971846e-02f, 1.04584485e-01f, -1.76376570e-02f, 3.79031152e-02f, 4.61045234e-03f, 5.72657026e-02f, 3.36860046e-02f, -1.76744051e-02f,
  -2.85252016e-02f, 5.20250723e-02f, 1.49201835e-02f, -2.86249351e-02f, 9.09236912e-03f, -2.19201799e-02f, 3.46112326e-02f, -2.30659526e-02f, 1.60598699e-02f, 1.39047410e-02f,
  7.86384642e-02f, 1.13543514e-02f, -4.45509963e-02f, -6.84649274e-02f, 3.67455231e-03f, 6.33601099e-02f, 3.17204715e-04f, 1.02752119e-01f, 1.25440229e-02f, 4.85132523e-02f,
  -1.92938875e-02f, 1.22330800e-01f, -6.17451817e-02f, 1.48089975e-01f, 1.63823217e-01f, -1.11252040e-01f, -7.06125125e-02f, 2.83020347e-01f, 5.29879987e-01f, 1.04151353e-01f,
  6.17134720e-02f, -1.03453016e-02f, -1.69368342e-01f, 1.67852759e-01f, -2.34860390e-01f, 7.67082348e-02f, 2.80198511e-02f, 7.13777542e-02f, 1.43669844e-01f, -4.06654961e-02f,
  8.07177089e-03f, 1.64253026e-01f, -1.91627771e-01f, 7.01143816e-02f, -2.12876010e-03f, 4.43384657e-03f, -1.11048222e-01f, -6.58603210e-04f, -8.93856436e-02f, 6.07611090e-02f,
  4.41954657e-02f, 1.24748856e-01f, -7.12055117e-02f, 8.12855642e-03f, -4.89569083e-02f, -1.19739197e-01f, -1.11997828e-01f, -3.69435437e-02f, 8.26286972e-02f, 2.98196692e-02f,
  -3.98170054e-02f, 5.38769644e-03f, 4.38033417e-02f, 2.81420480e-02f, 3.13087255e-02f, -1.55048026e-02f, -7.69895464e-02f, 3.55468616e-02f, -1.40642002e-02f, -1.24550231e-01f,
  -7.63188079e-02f, -2.75168521e-03f, 2.37132069e-02f, -3.61750163e-02f, 1.11195184e-02f, -2.45625637e-02f, -9.51466635e-02f, -7.98075497e-02f, 1.48316165e-02f, 3.82234529e-02f,
  -5.13917990e-02f, -5.78994025e-03f, 1.42501518e-02f, 9.60591659e-02f, 4.08070311e-02f, 7.77402818e-02f, -8.20199493e-03f, -2.54567992e-02f, 5.47818467e-03f, -4.55816351e-02f,
  5.53082563e-02f, 2.18281783e-02f, 1.03016995e-01f, -5.39661720e-02f, -4.37965207e-02f, 4.97352071e-02f, 1.37793217e-02f, 6.98099807e-02f, 6.35519922e-02f, 5.54933436e-02f,
  6.92123771e-02f, 2.00966764e-02f, 3.39377224e-02f, 3.44588161e-02f, 5.81384031e-03f, 7.46790553e-03f, -2.43291655e-03f, -4.64821188e-03f, -1.72408987e-02f, 9.17068310e-03f,
  -9.88075510e-02f, 6.97291493e-02f, 5.00944164e-03f, -6.75230520e-03f, 2.49711014e-02f, 4.11315523e-02f, 5.32168448e-02f, -4.00483143e-03f, -2.06171833e-02f, 4.25247848e-02f,
  -6.69060051e-02f, 3.71038392e-02f, -8.76948237e-02f, -9.89452354e-04f, 2.10637785e-03f, 3.74016128e-02f, 1.90987140e-02f, 1.53279714e-02f, 4.89356071e-02f, 8.05425865e-04f,
  4.00993275e-03f, -4.36392203e-02f, -2.66357362e-02f, 2.05294900e-02f, -7.06468374e-02f, -2.12694649e-02f, -1.63302161e-02f, -6.86955452e-02f, -3.93828303e-02f, -3.60923856e-02f,
  -3.13856006e-01f, 4.32876721e-02f, 5.11981472e-02f, -1.33878902e-01f, -1.86085626e-01f, -1.39097609e-02f, -1.34562701e-02f, 5.86097725e-02f, 2.97657326e-02f, 6.61115274e-02f,
  7.56987408e-02f, -2.06953958e-01f, 4.77041639e-02f, 2.02861533e-01f, 2.62412280e-01f, 2.72701472e-01f, 1.11137062e-01f, 5.97039703e-03f, 4.26918641e-02f, -1.12198107e-01f,
  -5.22002429e-02f, -3.06712720e-03f, 2.71646559e-01f, 5.62731624e-02f, -1.23553179e-01f, -1.89042747e-01f, -4.52711955e-02f, -6.81536123e-02f, 6.96317181e-02f, -1.05808880e-02f,
  9.85433161e-02f, -1.04961162e-02f, 6.88861981e-02f, 3.28640528e-02f, -4.31505814e-02f, -7.04044625e-02f, -7.55255818e-02f, 4.68931794e-02f, -5.72598428e-02f, 9.45691892e-04f,
  -9.04918928e-03f, -3.05747351e-04f, -5.40269986e-02f, 4.67555644e-03f, -1.03733689e-01f, -3.38192135e-02f, -5.43420156e-03f, 4.60201651e-02f, -1.38417976e-02f, 3.09226904e-02f,
  -6.17094710e-03f, 6.79453909e-02f, -4.80052531e-02f, 4.80481125e-02f, 1.86475273e-02f, 1.74233019e-02f, -2.13512331e-02f, -9.93606225e-02f, -1.10299274e-01f, 7.67518301e-03f,
  -8.20852593e-02f, -5.83944321e-02f, -1.66023280e-02f, 5.51970750e-02f, 5.87918563e-03f, 6.47294801e-03f, -4.45824228e-02f, 5.11703938e-02f, -6.73132017e-02f, 3.09730824e-02f,
  -8.21395665e-02f, -3.44653688e-02f, -3.38280685e-02f, -1.73404142e-02f, -7.58254826e-02f, 8.56126565e-03f, -4.60660160e-02f, -9.36373882e-03f, 3.12388763e-02f, 8.06940198e-02f,
  7.94888139e-02f, -5.92300259e-02f, 4.26438414e-02f, 3.27230729e-02f, 6.18614070e-02f, 2.93549639e-03f, 6.46393560e-03f, 2.59054378e-02f, 1.34444376e-02f, -2.21906509e-03f,
  2.58530267e-02f, -5.76316053e-03f, -1.61473230e-02f, -7.22688138e-02f, 2.74325572e-02f, -5.28704226e-02f, 1.65872872e-02f, 2.01950576e-02f, 3.34612466e-02f, 1.71282291e-02f,
  -3.44608016e-02f, -5.55620603e-02f, -3.26399058e-02f, -2.79574394e-02f, 2.08064355e-02f, 1.21394834e-02f, -6.75911037e-03f, -7.52651393e-02f, -3.20772529e-02f, 1.54872574e-02f,
  2.09124889e-02f, -1.02444336e-01f, 4.97658597e-03f, -8.74579102e-02f, -1.63599346e-02f, -7.92647824e-02f, -4.62958105e-02f, 5.83224185e-02f, 4.44543585e-02f, 9.74910520e-03f,
  -2.72322241e-02f, -3.30020219e-01f, -2.12954521e-01f, -3.05853158e-01f, 1.05210617e-01f, -2.55095661e-02f, -1.36056140e-01f, -1.56789675e-01f, -3.25795680e-01f, -9.92179811e-02f,
  1.25941083e-01f, -9.45231244e-02f, 1.59176290e-02f, -9.59223658e-02f, 1.65191829e-01f, -2.89349351e-03f, -9.96226668e-02f, -5.93099296e-02f, -6.53912798e-02f, -1.76975384e-01f,
  -5.68443947e-02f, 6.72366237e-03f, 4.90585901e-02f, 7.75576755e-02f, -1.74327269e-02f, -1.73579186e-01f, 1.05331585e-01f, 1.04998000e-01f, 5.41850142e-02f, 1.25877813e-01f,
  9.72258896e-02f, -5.91986999e-02f, -4.77137342e-02f, -5.58692068e-02f, -6.38881177e-02f, 6.88451529e-03f, 9.87020694e-03f, 1.42142072e-01f, -1.54438457e-02f, -5.42427115e-02f,
  -3.12642008e-02f, -4.15312760e-02f, -2.38966681e-02f, 6.24970198e-02f, 3.16276797e-03f, -2.83169728e-02f, -1.40175493e-02f, -3.56769450e-02f, -3.15745510e-02f, -6.54407358e-03f,
  1.06672700e-02f, 9.20209941e-03f, -7.10107237e-02f, -6.95536733e-02f, -5.68617880e-03f, -3.25719044e-02f, -1.75849516e-02f, 9.59465932e-03f, -9.20041725e-02f, -6.02589967e-03f,
  1.19375074e-02f, -9.87623725e-03f, 1.59580298e-02f, 4.81303409e-02f, 6.98163081e-03f, 2.40458716e-02f, 7.05043897e-02f, 3.06220576e-02f, -1.27473045e-02f, -8.07402469e-03f,
  -2.91387830e-02f, 5.99932903e-03f, -6.07469343e-02f, 1.20902816e-02f, -4.73300852e-02f, -1.72168501e-02f, 1.53630087e-02f, -4.54448052e-02f, -4.35177758e-02f, 1.06557710e-02f,
  6.60848618e-02f, 5.58930403e-03f, 2.29895096e-02f, 6.11003749e-02f, -1.32248097e-03f, 5.17980196e-02f, 3.55238467e-02f, -3.55356075e-02f, 1.12965805e-02f, -7.20782578e-03f,
  -1.18658282e-01f, -2.73705423e-01f, -4.40683849e-02f, 6.46747053e-02f, 8.93394276e-03f, 4.49658781e-02f, 2.82083303e-02f, -3.13497968e-02f, -5.38130328e-02f, 1.12325500e-03f,
  2.18086480e-03f, 8.35150480e-02f, -2.38272920e-02f, -2.76165782e-03f, -4.40486073e-02f, -3.79447229e-02f, 2.45612133e-02f, 1.33358091e-02f, -1.57546401e-02f, -1.06820918e-03f,
  -3.36030237e-02f, -8.55224952e-03f, -2.24924739e-02f, 3.37394811e-02f, -3.54984105e-02f, 1.45828659e-02f, -3.61121371e-02f, -2.67149415e-02f, 7.26624653e-02f, -8.55237618e-02f,
  -7.54437149e-02f, 1.42397076e-01f, 4.20912318e-02f, 1.53552711e-01f, 1.24358214e-01f, -3.04624081e-01f, -1.74243793e-01f, 6.53972998e-02f, 1.00930102e-01f, 5.62165491e-02f,
  -1.67598035e-02f, 2.94132181e-03f, -1.79584876e-01f, 5.27860224e-02f, -4.91113067e-01f, -3.40025604e-01f, -1.08465597e-01f, -8.00031945e-02f, -1.10277496e-02f, 6.91684261e-02f,
  4.71373126e-02f, -5.20538241e-02f, 3.10752634e-02f, 1.86106086e-01f, 2.05472142e-01f, 2.46754095e-01f, 2.27989648e-02f, 6.19276166e-02f, 9.77538526e-02f, -6.66384920e-02f,
  -8.62922519e-02f, 1.29107133e-01f, 7.84836411e-02f, -3.13561037e-02f, 4.61781546e-02f, 5.69126345e-02f, -2.71863230e-02f, -4.53833826e-02f, 3.19142528e-02f, 2.50691944e-03f,
  -2.16726065e-02f, -3.54162566e-02f, 2.40075812e-02f, -3.68361063e-02f, 6.82124794e-02f, 1.09337375e-01f, 4.00588550e-02f, 1.85265008e-03f, -1.64146069e-02f, -2.96646059e-02f,
  6.64480031e-02f, 2.08119862e-02f, 1.66511647e-02f, -4.21582721e-02f, 1.32359145e-02f, 4.66478765e-02f, -7.38113821e-02f, 1.73959415e-02f, 5.56380907e-03f, -4.27451804e-02f,
  -4.50856611e-02f, 1.03125935e-02f, 1.72079019e-02f, 4.63350862e-02f, -2.19313633e-02f, 1.04846992e-01f, 1.10580083e-02f, -6.38645701e-03f, -2.63035239e-04f, 3.68915573e-02f,
  3.71206515e-02f, 2.48265155e-02f, -1.18366908e-02f, 1.93988048e-02f, 8.72248411e-03f, 5.32652251e-02f, -5.68244308e-02f, 1.54662756e-02f, 4.74837534e-02f, 2.50091050e-02f,
  9.64857265e-03f, -5.01208790e-02f, 1.47587573e-02f, -1.97164733e-02f, -1.61354442e-03f, -5.86930253e-02f, -3.70342135e-02f, 5.04930615e-02f, 5.63395023e-02f, -3.47531140e-02f,
  -6.80492818e-02f, -5.50382771e-02f, 5.58216460e-02f, 6.88817725e-03f, -3.14655080e-02f, 6.41868776e-03f, -6.93127140e-02f, -4.15923223e-02f, -6.31517172e-02f, -3.10774129e-02f,
  5.52615104e-03f, 2.85333209e-02f, -1.50887324e-02f, 4.21579145e-02f, -1.75745077e-02f, -5.02449386e-02f, -1.89491306e-02f, 4.85428646e-02f, -5.28321555e-03f, -3.03129237e-02f,
  -6.88503077e-03f, 2.65227873e-02f, -4.90351282e-02f, -8.40372778e-03f, 2.26197429e-02f, -6.27033040e-02f, 3.71597670e-02f, -2.28220951e-02f, -5.94618805e-02f, 9.99298040e-03f,
  4.59873646e-01f, -3.18989515e-01f, -7.22016320e-02f, 1.91813439e-01f, 2.54926860e-01f, 4.60756123e-02f, 5.56307286e-02f, 1.21840350e-01f, -3.94413024e-02f, -1.67447805e-01f,
  7.61717036e-02f, -1.66246295e-02f, -2.72049874e-01f, 6.71708062e-02f, 1.03849225e-01f, -3.83434087e-01f, 1.13184787e-01f, 1.66575669e-03f, -6.46526739e-02f, 2.06612885e-01f,
  1.02908269e-01f, 3.67418155e-02f, -4.91358526e-02f, 1.55413607e-02f, 1.73843607e-01f, 8.61906782e-02f, 1.38444901e-02f, -8.41817409e-02f, 1.28418282e-01f, -2.72012502e-02f,
  1.39404178e-01f, 2.71100318e-03f, 4.93499562e-02f, 1.14524290e-02f, 1.09370798e-01f, 1.20447427e-01f, 1.64190196e-02f, -6.54640123e-02f, 1.92329325e-02f, 6.59534857e-02f,
  -3.73911709e-02f, 2.99863145e-02f, 4.03976850e-02f, -1.08515225e-01f, 9.59658250e-03f, 2.90503185e-02f, 3.46643031e-02f, 5.74244186e-02f, -5.35831153e-02f, 4.29808497e-02f,
  1.04049360e-02f, -2.39322092e-02f, 4.22326736e-02f, -2.51514167e-02f, 7.30984146e-03f, 5.12366481e-02f, 3.38613652e-02f, 1.27921514e-02f, -1.54835870e-02f, 4.96138893e-02f,
  4.00806367e-02f, 1.52551010e-02f, -3.39014083e-02f, -1.23189474e-02f, 4.90543013e-03f, 7.67907649e-02f, -8.71882141e-02f, 1.00043900e-02f, -7.67833227e-03f, 4.25621010e-02f,
  2.93647647e-02f, 3.82334366e-02f, 3.26081887e-02f, -5.16558113e-03f, 1.96221694e-02f, 2.91977357e-03f, -3.05685997e-02f, 1.26499319e-02f, 4.45569605e-02f, 3.48465629e-02f,
  -1.03195824e-01f, 1.08597185e-02f, 1.61101725e-02f, 2.92798392e-02f, 6.12691278e-04f, -3.32963876e-02f, -5.39188199e-02f, -9.06013977e-03f, 1.75565742e-02f, 9.89060383e-04f,
  8.57429802e-02f, -4.14443463e-02f, -2.55193617e-02f, -2.93719973e-02f, -4.68170941e-02f, -2.98964921e-02f, -5.58157451e-02f, 3.66118699e-02f, -8.05180427e-03f, 2.42049852e-03f,
  9.53961015e-02f, 4.88540754e-02f, 1.69863664e-02f, 2.62872484e-02f, -5.11157475e-02f, -6.09916262e-03f, -4.20756415e-02f, -3.41175124e-02f, 3.94522622e-02f, -2.70283036e-02f,
  2.25245301e-02f, 5.95319457e-02f, -7.27739334e-02f, 4.17004339e-02f, 3.68312784e-02f, 3.63353752e-02f, 3.88104022e-02f, -1.31316972e-03f, -5.58660962e-02f, -4.50724214e-02f,
  -3.09086084e-01f, 1.63690791e-01f, -9.47115198e-03f, 1.33385971e-01f, -1.85293123e-01f, -2.28271008e-01f, -2.70657629e-01f, -5.34438640e-02f, -3.36422652e-01f, -3.20697129e-02f,
  -7.78180212e-02f, -7.28968978e-02f, -2.24711746e-02f, 7.28115439e-02f, 2.68626753e-02f, 3.97392362e-03f, 9.42087397e-02f, 1.26541341e-02f, 9.81049910e-02f, 8.93519148e-02f,
  1.47548780e-01f, 1.72243953e-01f, 2.91954994e-01f, 2.09895819e-01f, 1.10071771e-01f, 7.62055591e-02f, 1.75522313e-01f, -1.38221160e-02f, 1.73253864e-01f, -7.91221559e-02f,
  -1.01660369e-02f, -1.25773802e-01f, -7.23374560e-02f, -5.34243248e-02f, 5.84156485e-03f, -1.80636123e-02f, 5.29290400e-02f, -5.74579947e-02f, 1.07652638e-02f, -4.92607430e-02f,
  5.59104607e-02f, 9.77190584e-03f, -3.88584137e-02f, -7.73068070e-02f, -6.12229183e-02f, 1.91643834e-02f, 1.66630894e-02f, 1.82959102e-02f, 5.30384965e-02f, 8.59562531e-02f,
  -1.23959379e-02f, 6.24109283e-02f, 5.71135655e-02f, 5.51235788e-02f, 1.92064065e-02f, 3.44028063e-02f, 5.91680314e-03f, 6.82325521e-03f, 4.38570902e-02f, -3.45261507e-02f,
  -6.32729083e-02f, -1.22793866e-02f, 8.31728242e-03f, -3.50840576e-02f, -2.87733153e-02f, -3.61296837e-03f, 2.20257677e-02f, 1.14086280e-02f, 8.66573676e-03f, 3.18631157e-02f,
  1.01543451e-02f, 3.61539051e-02f, 8.48644879e-03f, 1.80855300e-02f, 1.06766364e-02f, -3.33472081e-02f, 9.76097677e-03f, 1.69384982e-02f, -7.64437579e-03f, 3.67778316e-02f,
  -5.53950667e-02f, -1.91223435e-02f, -1.35613782e-02f, 2.97080781e-02f, -1.43386340e-02f, -1.28002057e-06f, 1.90593358e-02f, -2.94330437e-02f, 3.21976724e-03f, 7.69442618e-02f,
  -8.23058188e-02f, -7.60670751e-02f, 3.22581716e-02f, -1.45198330e-02f, 3.76955532e-02f, -4.78652213e-03f, -3.73758189e-02f, -3.70269604e-02f, 4.29356587e-05f, -6.32252395e-02f,
  -2.94583328e-02f, -4.08363761e-03f, 3.22476437e-04f, 2.94873808e-02f, 6.25731722e-02f, -6.56375363e-02f, 1.06149882e-01f, -7.99694508e-02f, -2.65262444e-02f, 4.89946306e-02f,
  7.57747293e-02f, -3.59022655e-02f, 5.26390150e-02f, 1.21602165e-02f, -1.82131829e-03f, -3.93837579e-02f, -4.94958274e-02f, 1.83561409e-03f, 6.68642297e-02f, -2.33562123e-02f,
  7.12849721e-02f, -1.85689956e-01f, -1.45716354e-01f, -8.27252269e-02f, 1.03574283e-02f, -2.71749556e-01f, 4.29841243e-02f, -9.01377499e-02f, -3.42626660e-03f, -9.37286858e-03f,
  1.90114543e-01f, -8.63120556e-02f, 2.30647907e-01f, -8.85568187e-02f, 4.42640334e-02f, 1.47226200e-01f, -1.27010688e-01f, -1.06343135e-01f, 5.11637069e-02f, 5.36501817e-02f,
  4.47370782e-02f, 1.22042269e-01f, -2.13377154e-03f, -1.96423940e-02f, -1.21968083e-01f, -9.89224613e-02f, 2.53183901e-01f, 1.62213385e-01f, -1.88606605e-01f, 4.03505974e-02f,
  -4.54443730e-02f, 6.56133369e-02f, -3.03723235e-02f, -6.22974820e-02f, -7.61142671e-02f, -5.63216917e-02f, 1.68245155e-02f, 3.88506986e-02f, 4.36767749e-02f, 3.39661501e-02f,
  -1.01190254e-01f, -4.94469441e-02f, -8.36563855e-02f, 9.17932019e-02f, -1.68007128e-02f, -1.80300791e-02f, -6.41993359e-02f, -7.97016099e-02f, -6.17458262e-02f, -1.13087986e-02f,
  -7.34322667e-02f, -7.55020529e-02f, -4.25385647e-02f, -1.27612859e-01f, -1.46856606e-02f, -4.01573488e-03f, -6.81350604e-02f, -6.53125625e-03f, -1.12287410e-01f, 2.28547547e-02f,
  6.30055144e-02f, -1.28179211e-02f, 5.00917770e-02f, -2.91496962e-02f, 1.56852677e-02f, 2.71221641e-02f, -2.11402718e-02f, 1.34674683e-02f, 2.04465408e-02f, 4.48267199e-02f,
  4.99786809e-02f, 1.38709294e-02f, 1.63194779e-02f, 5.95624838e-03f, 1.27107427e-02f, 1.87635571e-02f, -1.88260358e-02f, 3.76059189e-02f, 3.56928725e-03f, -4.92771119e-02f,
  7.06516532e-03f, 2.41648629e-02f, 5.72541468e-02f, 3.65282558e-02f, 4.51821648e-02f, 8.12306702e-02f, -1.06976787e-02f, -1.31257726e-02f, 2.54631024e-02f, -1.26653248e-02f,
  -5.20581268e-02f, 1.01863235e-01f, 3.20023224e-02f, 1.95721649e-02f, 6.51614219e-02f, -4.42359447e-02f, -4.93866764e-02f, -6.48368597e-02f, 3.24044190e-02f, 6.40423372e-02f,
  -9.89151001e-03f, -4.24529193e-03f, -2.67091878e-02f, -5.56461699e-02f, 1.10585552e-05f, -2.32958198e-02f, 5.15434258e-02f, 7.05606630e-03f, -3.07055879e-02f, -2.09775604e-02f,
  2.05330942e-02f, -1.23044336e-02f, 6.30184170e-03f, -5.90123385e-02f, -3.03278770e-02f, 1.59759056e-02f, -4.48644273e-02f, -1.35876266e-02f, -4.98892516e-02f, -5.14134914e-02f,
  5.21759689e-01f, -1.29814129e-02f, -7.42379874e-02f, 3.61524791e-01f, -1.28770769e-01f, -1.93599701e-01f, -1.38776628e-02f, 3.60380746e-02f, 3.25385243e-01f, -2.70708068e-03f,
  -7.28943720e-02f, 8.72319788e-02f, -1.17521495e-01f, -1.08349681e-01f, 1.19225219e-01f, -6.82893023e-02f, 1.03266910e-01f, 7.20588118e-02f, 1.11327432e-02f, 1.40959129e-01f,
  1.31246254e-01f, -1.42084166e-01f, -7.21813589e-02f, -1.20457634e-01f, -3.51541899e-02f, 7.58895129e-02f, -2.23497916e-02f, -7.67891780e-02f, -1.01305388e-01f, -1.74049690e-01f,
  7.55916610e-02f, 1.92934290e-01f, -6.49925545e-02f, -3.09889968e-02f, 3.85914370e-02f, -8.18456756e-05f, 3.88495624e-02f, -5.62462211e-02f, -3.42810266e-02f, 3.03422567e-02f,
  3.14944610e-02f, 3.17521952e-02f, -2.59194449e-02f, 5.64982323e-03f, 1.53350476e-02f, -3.63130458e-02f, -7.87656680e-02f, -4.18397710e-02f, -7.00854957e-02f, -6.10950263e-03f,
  -4.78726104e-02f, -1.97543912e-02f, 1.53282676e-02f, 3.96753363e-02f, 8.45880341e-03f, 2.97622960e-02f, -3.98960523e-02f, 1.01978658e-02f, 4.93997820e-02f, 3.47370580e-02f,
  6.01963848e-02f, 9.29222908e-03f, -9.46328975e-03f, -1.51509978e-02f, 5.04637137e-02f, -1.03147127e-01f, -1.45417382e-03f, -3.92343737e-02f, 3.73595841e-02f, 8.56577791e-03f,
  -2.48340853e-02f, 6.43261150e-02f, -3.98261957e-02f, 4.52443995e-02f, 6.09007152e-03f, 2.51545552e-02f, -6.41808510e-02f, -2.75882538e-02f, -3.75710707e-03f, -3.13025154e-02f,
  9.14211106e-03f, 2.63778288e-02f, 4.70698858e-03f, -3.86862941e-02f, -1.31629584e-02f, 1.42703243e-02f, -3.96390669e-02f, 1.57421809e-02f, -1.86737848e-03f, 6.82586897e-03f,
  1.48203492e-01f, 3.49394321e-01f, -4.84961551e-03f, 4.24715243e-02f, -1.70626305e-02f, -4.41046059e-02f, -1.70614235e-02f, 3.02771274e-02f, 8.08089823e-02f, 2.00035069e-02f,
  2.83979941e-02f, 2.42033917e-02f, 7.09679872e-02f, -8.97024292e-03f, -4.69315127e-02f, 3.20164822e-02f, 2.10759789e-02f, 4.33207536e-03f, 6.28362745e-02f, 1.83624066e-02f,
  5.98434024e-02f, 8.86789523e-03f, -5.09976409e-03f, 3.39496657e-02f, 2.44857743e-02f, -8.96037929e-03f, 5.92857599e-02f, 1.37773203e-02f, 4.36056480e-02f, -1.01748956e-02f,
  4.09821361e-01f, 3.00127238e-01f, 3.02916855e-01f, 2.59284079e-01f, -1.45219013e-01f, 1.67051047e-01f, 1.50992975e-01f, 9.64086279e-02f, 9.42543615e-03f, -5.98045662e-02f,
  -4.28201519e-02f, 2.12599754e-01f, -2.96923202e-02f, 9.09137800e-02f, 1.96542025e-01f, -4.58424119e-03f, 1.74283117e-01f, 1.68774035e-02f, -6.24783291e-03f, 2.42346212e-01f,
  6.40291274e-02f, -5.13300262e-02f, 7.92334005e-02f, -4.82519194e-02f, 2.23195568e-01f, 5.87867908e-02f, -6.99993297e-02f, -4.16486412e-02f, -4.56836866e-03f, 1.15840323e-02f,
  1.41021296e-01f, 2.10940670e-02f, 4.59530950e-02f, -7.96615053e-03f, 1.17220348e-02f, -2.89850887e-02f, 4.25026240e-03f, -3.15683745e-02f, 1.92793980e-02f, 1.46507267e-02f,
  9.30636935e-03f, -3.93789895e-02f, -7.01082721e-02f, -2.44013220e-02f, 2.88518146e-03f, 1.89946853e-02f, 1.73156392e-02f, 5.68910576e-02f, 7.21255457e-03f, -7.58177461e-03f,
  6.84558004e-02f, 5.08067310e-02f, -1.78703535e-02f, -3.59431654e-02f, -6.99982280e-03f, -3.78398001e-02f, -6.93140691e-03f, -2.63137165e-02f, 5.61058614e-03f, 4.86309500e-03f,
  -6.70070872e-02f, 2.66390946e-03f, -4.60927561e-02f, 4.26474493e-03f, 1.38811506e-02f, -1.03316354e-02f, 1.71363652e-02f, -8.21214095e-02f, 2.29275562e-02f, 6.24945238e-02f,
  3.45637947e-02f, 6.25350848e-02f, -4.31039296e-02f, -7.28091504e-03f, 3.50269675e-02f, 1.16852140e-02f, -1.67601984e-02f, 1.27281249e-02f, 1.80047713e-02f, -3.56872343e-02f,
  -1.13263046e-02f, 1.32072121e-02f, 1.65499449e-02f, 3.08536255e-04f, -3.77265774e-02f, 2.25586537e-02f, 1.44866742e-02f, 6.33850843e-02f, -6.28144369e-02f, 1.17306849e-02f,
  2.70049572e-01f, 2.47431517e-01f, -7.68906772e-02f, -4.37798239e-02f, 2.56426372e-02f, 1.49175348e-02f, 1.10465791e-02f, 1.43848015e-02f, 5.64161316e-02f, 1.07773980e-02f,
  -1.30579891e-02f, 8.71913321e-03f, 7.65457973e-02f, 2.66732499e-02f, -3.74347786e-03f, -2.69445926e-02f, -9.80470330e-03f, 3.07823066e-02f, 9.83041245e-03f, 5.89894913e-02f,
  3.76145579e-02f, -2.97220070e-02f, -2.40986682e-02f, -4.66749594e-02f, -5.91614693e-02f, 3.26003209e-02f, 3.66809480e-02f, 1.53674828e-02f, 2.19655763e-02f, 3.60860974e-02f,
  6.25480413e-01f, -4.47131991e-02f, 6.08166680e-02f, 4.33487236e-01f, 8.32001045e-02f, -2.19535559e-01f, -2.12966695e-01f, 8.82004872e-02f, 2.19592005e-01f, -2.98964381e-01f,
  -1.08915545e-01f, 1.17377259e-01f, -2.97468483e-01f, 4.60846163e-02f, 2.42512465e-01f, -1.71417758e-01f, 6.67930543e-02f, 2.49507511e-03f, 5.24350740e-02f, 1.17876291e-01f,
  2.18779907e-01f, -4.40504309e-03f, 5.07084019e-02f, -1.68987643e-03f, 1.38617992e-01f, 1.34939313e-01f, 6.24757670e-02f, -1.22099809e-01f, 5.84321842e-02f, -4.09035161e-02f,
  -6.74565360e-02f, 9.64077488e-02f, 4.81600082e-03f, 2.78509259e-02f, 3.96374837e-02f, -3.82682716e-04f, -3.08411922e-02f, -5.06122410e-03f, 2.01438107e-02f, -3.23956541e-04f,
  -2.07409579e-02f, -7.68724736e-03f, 5.82099147e-03f, -9.52740945e-03f, 8.49738121e-02f, 1.91499665e-02f, 4.73832525e-02f, 5.05943894e-02f, -1.62790436e-02f, -3.91208846e-03f,
  1.00717545e-02f, 3.35709900e-02f, 7.77244270e-02f, -7.49374507e-03f, 8.35452899e-02f, -9.46551468e-03f, -1.26666389e-02f, 1.01093715e-02f, 9.71785560e-03f, 5.48630059e-02f,
  2.03949828e-02f, -6.47492409e-02f, -2.29706485e-02f, 5.88366250e-03f, -8.16703495e-03f, -1.36511102e-02f, 1.98771469e-02f, -1.05553111e-02f, 1.70835238e-02f, -3.44917700e-02f,
  3.23761664e-02f, 2.83257384e-02f, 5.36860265e-02f, -2.26114877e-02f, 1.15227923e-02f, -2.90692095e-02f, -3.73547077e-02f, -4.76614665e-03f, 3.76405120e-02f, 5.21258488e-02f,
  -1.02308448e-02f, 9.87784937e-03f, -3.97674367e-02f, -1.65220089e-02f, -6.48520291e-02f, 1.23477699e-02f, 1.45944515e-02f, 2.32502930e-02f, -1.05641577e-02f, -1.21749528e-02f,
  -7.54278079e-02f, 4.23573479e-02f, -5.48560591e-03f, -7.90839940e-02f, -5.96531443e-02f, 9.43866279e-03f, 6.73572859e-03f, 1.31858988e-02f, 6.99380599e-03f, 1.39044290e-02f,
  -1.90701634e-02f, 2.38415375e-02f, -1.03611872e-02f, 1.45736896e-02f, -5.46728587e-03f, 2.54010372e-02f, -4.15919796e-02f, -1.22371605e-02f, 2.06659567e-02f, 2.72100568e-02f,
  8.92050564e-03f, -3.04817893e-02f, 3.32288537e-03f, 1.63105433e-03f, -4.65031080e-02f, -1.87609382e-02f, 2.36531869e-02f, 7.05573289e-03f, 8.57546087e-03f, 2.41728388e-02f,
  4.43738177e-02f, -1.67644083e-01f, 2.05069825e-01f, 2.23899648e-01f, -3.08121979e-01f, 4.05876711e-03f, 1.78643480e-01f, -2.19084889e-01f, 1.89711764e-01f, -8.12076777e-02f,
  -1.41231447e-01f, 1.89533964e-01f, 8.83806720e-02f, 1.10459767e-01f, 7.46548995e-02f, 3.17772925e-01f, 8.53485316e-02f, 1.19596146e-01f, 2.48653125e-02f, -1.56841666e-01f,
  1.31358951e-01f, -2.73967624e-01f, 8.45123753e-02f, -3.95959347e-01f, -9.74221006e-02f, -5.09074107e-02f, -2.43413568e-01f, -8.67326781e-02f, -1.98382467e-01f, 2.16799881e-02f,
  -3.85473482e-03f, 1.58830697e-03f, 3.74073125e-02f, 3.34177888e-03f, -6.72070831e-02f, 1.88472159e-02f, 3.52596417e-02f, 7.45751709e-02f, -1.50809903e-02f, 6.64053932e-02f,
  1.91708244e-02f, 2.50358544e-02f, 2.11883779e-03f, -1.32054426e-02f, -2.62315907e-02f, 4.83459830e-02f, 3.18274051e-02f, -4.60887514e-02f, 5.55260386e-03f, 3.53624858e-02f,
  7.24109933e-02f, 1.28713129e-02f, 9.25239474e-02f, 5.25131524e-02f, 8.70189369e-02f, 8.09969008e-03f, 8.14341009e-02f, 3.44481319e-02f, 4.39892960e-04f, -2.69664470e-02f,
  4.55498695e-02f, -2.91274711e-02f, -2.49581132e-03f, -3.41722704e-02f, -3.78914475e-02f, -2.72130966e-02f, -8.60731490e-03f, 8.52373615e-03f, 3.27738002e-02f, -6.97501528e-04f,
  -7.13975802e-02f, 1.71739105e-02f, -8.11495725e-03f, -2.29760166e-03f, 9.73710418e-03f, 1.61592662e-02f, 3.37733217e-02f, -1.46775478e-02f, 4.62059900e-02f, 3.22659090e-02f,
  1.12080453e-02f, 1.02522410e-02f, -2.21957825e-02f, -3.62564251e-02f, 1.38685014e-02f, 3.18536460e-02f, -2.91641541e-02f, 9.89511143e-04f, 4.30153869e-02f, 1.92699973e-02f,
  -2.45570645e-01f, -2.45292917e-01f, -3.63470241e-02f, -4.54193912e-02f, -2.95428443e-03f, -4.24552988e-03f, 6.43139184e-02f, -2.62168739e-02f, 9.64908302e-03f, -5.10564856e-02f,
  7.99565017e-03f, -4.28911112e-03f, -6.69375286e-02f, 2.60675140e-02f, -6.39792997e-04f, -5.28342314e-02f, 7.75273610e-03f, 5.94413765e-02f, -6.31979108e-02f, -3.47654037e-02f,
  -5.44049107e-02f, 2.34149210e-02f, -4.03507613e-03f, -5.21710403e-02f, -2.76272465e-02f, 1.36594279e-02f, -7.57011622e-02f, 7.91387036e-02f, -1.21712098e-02f, 4.59540002e-02f,
  4.64818738e-02f, 5.29617853e-02f, -1.53171867e-01f, 1.81490690e-01f, -1.62980795e-01f, -8.52141753e-02f, 7.96638206e-02f, -1.92192886e-02f, -2.08798081e-01f, 2.54810125e-01f,
  1.04024529e-01f, 1.01192094e-01f, 1.79730114e-02f, 3.33844572e-01f, 1.34192422e-01f, -7.42075741e-02f, 2.23611683e-01f, 1.54522568e-01f, -1.76939741e-01f, 1.48591638e-01f,
  -4.78666537e-02f, 2.77008891e-01f, 7.43341297e-02f, 3.19625176e-02f, 9.07086805e-02f, -3.15988697e-02f, 3.20730031e-01f, -1.51944235e-01f, 2.70554602e-01f, 6.32832050e-02f,
  -9.22144055e-02f, -8.25864822e-02f, 5.37285581e-03f, -5.19935973e-03f, 1.61879521e-03f, 1.55982729e-02f, -1.38791022e-03f, 4.43254576e-05f, -6.79962859e-02f, -3.99488844e-02f,
  -1.97506393e-03f, -1.11529399e-02f, 5.10323793e-02f, -3.09231002e-02f, -6.90957457e-02f, -3.79980616e-02f, -6.06692694e-02f, 3.77183291e-03f, -1.35306707e-02f, -5.53983450e-02f,
  -3.60009447e-02f, 1.40693113e-02f, -1.17753809e-02f, 8.65944624e-02f, -3.39896791e-02f, -9.94527154e-03f, 1.22682946e-02f, 3.68209630e-02f, -4.05198056e-03f, -2.02202387e-02f,
  5.70680909e-02f, -7.79565284e-03f, 2.27387599e-03f, -2.09302660e-02f, -1.96634177e-02f, -5.77963423e-03f, 1.88266840e-02f, 2.62518600e-02f, -4.07032445e-02f, 2.11117091e-03f,
  3.03353579e-03f, 1.79170743e-02f, -1.36329904e-02f, 1.15349479e-02f, 6.33250028e-02f, -1.94146968e-02f, 3.32823358e-02f, -2.12436561e-02f, -7.01771444e-03f, -5.57683557e-02f,
  4.11333665e-02f, -2.21856497e-02f, -2.31028423e-02f, 4.60299384e-03f, -2.33867932e-02f, 4.71773883e-03f, 5.54146282e-02f, -1.66716166e-02f, 1.38920024e-02f, 3.97539139e-02f,
  1.28571853e-01f, 2.10100576e-01f, -3.93415354e-02f, -1.42972674e-02f, -1.17263338e-02f, -2.10297797e-02f, 7.32911974e-02f, 1.03500963e-03f, 5.98546341e-02f, 3.78801674e-02f,
  4.67276834e-02f, -3.27708609e-02f, 6.92206025e-02f, 5.31469053e-03f, 5.87482378e-03f, 3.40165608e-02f, 6.82571456e-02f, 1.33199217e-02f, 1.07555978e-01f, 3.43721770e-02f,
  3.42635182e-03f, 1.22259650e-02f, 6.99319644e-03f, 2.68204208e-03f, 2.57700328e-02f, -3.70287336e-03f, -1.49642406e-02f, -8.90675932e-02f, -2.21689953e-03f, 4.68683392e-02f,
  2.45946065e-01f, 1.39564142e-01f, 9.94229466e-02f, -7.39859417e-02f, -7.74256289e-02f, -4.99881059e-01f, -1.93464011e-01f, -3.02967131e-02f, 8.80927667e-02f, -2.35752407e-02f,
  -9.40086022e-02f, 1.01032928e-01f, 1.65583640e-01f, -2.05168158e-01f, -2.67277211e-01f, 4.68790084e-02f, -3.86620164e-01f, -1.49854586e-01f, 1.19030781e-01f, 5.74349836e-02f,
  2.14991793e-02f, -2.27876365e-01f, 4.29993011e-02f, -1.05914697e-01f, 1.94801837e-02f, 1.48661897e-01f, -3.37794609e-02f, 1.25118792e-01f, -1.59849271e-01f, -1.00612640e-01f,
  -4.28570658e-02f, 1.39464170e-01f, 3.40487026e-02f, 6.84881732e-02f, -5.48855998e-02f, -2.18286198e-02f, -6.41955212e-02f, 2.84623494e-03f, -1.12925749e-02f, -1.63148101e-02f,
  7.91757181e-03f, 5.10465614e-02f, -5.54735214e-02f, 2.75563728e-02f, 6.17344081e-02f, 4.26982716e-03f, 1.13177402e-02f, 1.01447850e-02f, 8.74776766e-02f, 8.87430906e-02f,
  6.73644096e-02f, -6.06841743e-02f, 1.71696825e-03f, 1.20793795e-02f, -2.50561517e-02f, 2.77550276e-02f, -2.86425538e-02f, -2.24498864e-02f, -2.99854353e-02f, -5.71880937e-02f,
  -1.86134744e-02f, -2.77502695e-03f, -1.65965930e-02f, 5.22833951e-02f, -5.76359928e-02f, 8.21451750e-03f, -5.67496894e-03f, -3.76388356e-02f, 4.12492752e-02f, -1.75188817e-02f,
  -4.56322543e-02f, 5.78649715e-03f, 2.56928448e-02f, -9.59310308e-03f, -3.46080065e-02f, -1.48523953e-02f, -2.34643333e-02f, 2.44220644e-02f, -3.07368990e-02f, -6.46761879e-02f,
  5.68198599e-02f, -1.54397590e-02f, -2.63193063e-03f, 1.10247303e-02f, -4.60031256e-02f, -1.67969372e-02f, 3.73289436e-02f, 4.91645150e-02f, 1.26074776e-02f, -5.54491095e-02f,
  -1.82853147e-01f, -3.81189995e-02f, -8.97121523e-03f, -6.20894320e-02f, -5.87110445e-02f, -2.01053750e-02f, -1.65645666e-02f, -7.44964257e-02f, -1.06313583e-02f, -1.23512177e-02f,
  -7.54407002e-03f, -1.06527098e-02f, -5.36494665e-02f, 4.06170599e-02f, -7.57585838e-02f, -2.57612225e-02f, 2.52481867e-02f, -2.86550242e-02f, -1.23902768e-01f, -5.74380755e-02f,
  -3.87313552e-02f, 4.52407710e-02f, -5.13736084e-02f, -3.49491425e-02f, -4.12130915e-02f, -2.67345868e-02f, -5.78391515e-02f, 6.27054200e-02f, -1.34569698e-03f, 3.15842219e-02f,
  -4.30544987e-02f, 1.65971726e-01f, -5.26294522e-02f, 1.03165083e-01f, -7.56647512e-02f, -3.29631597e-01f, -2.33573839e-01f, 2.72764247e-02f, -1.91132829e-01f, 2.99708664e-01f,
  5.24909310e-02f, 2.77292673e-02f, -1.56276533e-03f, 1.32114226e-02f, -4.19537544e-01f, -2.01956362e-01f, -5.08013070e-02f, 4.23069261e-02f, -1.05930768e-01f, 1.09006912e-01f,
  -2.05354486e-02f, 6.47674128e-02f, -9.28087831e-02f, 1.36447474e-01f, 1.00030765e-01f, 2.15697780e-01f, 2.89548129e-01f, -7.53698274e-02f, 2.19080865e-01f, -9.75025669e-02f,
  -6.20118938e-02f, 1.34266140e-02f, 4.37860191e-02f, -5.31908721e-02f, 6.07065298e-02f, -6.40578801e-03f, 8.04587267e-04f, -5.43079302e-02f, -7.76582062e-02f, 2.06185225e-02f,
  7.23986700e-02f, -3.31424735e-02f, -3.35020758e-02f, -1.13437334e-02f, -7.50903692e-03f, 1.82849623e-03f, 5.88406436e-03f, 1.45540377e-02f, 2.14123968e-02f, -5.11152148e-02f,
  -4.75825917e-04f, 3.15078907e-02f, 9.93703082e-02f, 9.29404274e-02f, 4.94967513e-02f, -2.25608889e-02f, -4.06489223e-02f, -1.02959909e-02f, 3.46392510e-03f, -6.15974069e-02f,
  3.68671380e-02f, -1.42493658e-02f, 2.30732374e-02f, 1.15103675e-02f, -2.70091090e-02f, -1.14887152e-02f, 2.45105885e-02f, 2.07874104e-02f, -3.99729935e-03f, 2.20610332e-02f,
  3.11512463e-02f, 4.99335304e-02f, -6.24037720e-03f, -1.01410383e-02f, 2.46025715e-02f, 4.56700362e-02f, 3.19515578e-02f, -6.11709710e-03f, 6.71145990e-02f, -2.50805374e-02f,
  1.39128868e-04f, -4.82988134e-02f, 4.81305309e-02f, 5.70721924e-02f, -1.97992045e-02f, 1.66661441e-02f, 8.09941143e-02f, -3.50348502e-02f, -3.61831598e-02f, 3.46443802e-02f,
  -4.68573682e-02f, 2.05510199e-01f, 3.94013710e-02f, 1.98310986e-02f, -8.41234578e-04f, 6.47967607e-02f, -6.71929345e-02f, -1.36002898e-02f, 3.89502035e-03f, -1.47302458e-02f,
  1.18311130e-01f, 6.12732135e-02f, 3.78473066e-02f, -4.20372747e-02f, -5.11261113e-02f, 1.37330303e-02f, 2.66094655e-02f, 2.23837197e-02f, 6.47267550e-02f, 7.94280320e-02f,
  8.76735598e-02f, -3.35647864e-03f, -3.63833569e-02f, 4.67434339e-02f, 4.72568609e-02f, 8.59298557e-02f, 2.31975075e-02f, -1.47034945e-02f, 3.78366858e-02f, 3.44235972e-02f,
  -1.39293328e-01f, -1.71762735e-01f, -1.52337663e-02f, -3.15996744e-02f, -7.72201717e-02f, 6.99058324e-02f, -1.23005053e-02f, -2.36699924e-01f, -1.47274300e-01f, 1.68325216e-01f,
  -8.01478997e-02f, -7.56749557e-03f, -1.08347304e-01f, -1.94162324e-01f, -1.87689289e-01f, 1.21004758e-02f, -6.92930371e-02f, 1.23182103e-01f, -1.31154045e-01f, -9.85539109e-02f,
  -9.59098488e-02f, -1.06816001e-01f, -3.50446440e-02f, -9.23249125e-02f, -3.79981287e-02f, -1.58640612e-02f, 1.13088023e-02f, -3.79720889e-02f, 7.27289766e-02f, -3.76586965e-03f,
  -8.83668289e-02f, -9.16310698e-02f, 2.13651732e-02f, 2.09521111e-02f, 3.88776027e-02f, 1.30326627e-02f, 3.52576822e-02f, 2.70689260e-02f, 2.41207667e-02f, -9.73710697e-03f,
  9.86889675e-02f, 3.25349085e-02f, -4.40106727e-02f, -1.34468842e-02f, -5.47389612e-02f, -1.10286884e-01f, -5.29343151e-02f, 1.35040674e-02f, -1.77332889e-02f, -1.60653628e-02f,
  -9.53925774e-02f, -6.83317706e-03f, 1.26134261e-01f, 5.69539517e-02f, 4.14109416e-02f, -7.35912323e-02f, 9.65547189e-02f, -1.98010877e-02f, -4.08418998e-02f, -2.75552385e-02f,
  -2.94011203e-03f, 5.60778603e-02f, -2.32808162e-02f, 5.15034720e-02f, -5.81917763e-02f, 5.82514256e-02f, 7.64354989e-02f, -1.19000627e-02f, 5.99211492e-02f, -3.99350934e-03f,
  2.95096143e-05f, 7.74603663e-03f, 1.50649017e-03f, 1.75633701e-04f, -1.27612492e-02f, 2.44957320e-02f, 6.86916383e-03f, 3.20388228e-02f, 5.50484695e-02f, -1.11431247e-02f,
  4.33097631e-02f, -3.95987891e-02f, 2.32425090e-02f, 8.55697915e-02f, -4.92561571e-02f, -1.00636412e-03f, -6.59677982e-02f, 3.26768309e-02f, -9.91216023e-03f, 1.83464475e-02f,
  -7.31390789e-02f, -2.47460410e-01f, 2.75669456e-03f, -4.68811840e-02f, 3.94378342e-02f, -3.34987864e-02f, -1.16452072e-02f, -2.59914994e-02f, 4.08605847e-04f, -1.09913222e-01f,
  9.41751674e-02f, 1.98192825e-03f, -2.92343944e-02f, -3.27961519e-02f, 8.38545263e-02f, -4.05139755e-03f, 8.01183283e-02f, 5.51702268e-02f, 7.27554783e-02f, -1.78365000e-02f,
  9.42898989e-02f, 7.51045253e-03f, 1.56017011e-02f, 2.17340905e-02f, 2.57186126e-02f, 5.98302595e-02f, 1.29699474e-02f, -1.10607538e-02f, -3.33107039e-02f, 1.92159098e-02f,
  3.02865744e-01f, -1.22186569e-02f, -7.13368431e-02f, 2.74920594e-02f, 6.78265169e-02f, 1.18191785e-03f, 2.30750158e-01f, -5.57392649e-02f, 6.15100972e-02f, 7.29461834e-02f,
  1.79086290e-02f, 2.81626463e-01f, 6.44278899e-02f, -1.67552695e-01f, 2.59188443e-01f, 3.81053872e-02f, 1.08123504e-01f, 2.40328252e-01f, -1.21223114e-01f, 9.15098414e-02f,
  -3.71845625e-02f, -6.08141497e-02f, -1.46858707e-01f, -1.82620987e-01f, -5.91980033e-02f, -1.24269530e-01f, 1.04994088e-01f, -1.22508280e-01f, 5.77316508e-02f, 1.43570881e-02f,
  -2.46574520e-03f, 7.94477686e-02f, -4.37360741e-02f, 6.71839640e-02f, 5.20955510e-02f, 5.03296964e-02f, 5.93702458e-02f, -6.78602457e-02f, -4.19321097e-02f, -6.84501510e-03f,
  6.47799224e-02f, -5.42851537e-02f, -8.22978839e-02f, -3.44980992e-02f, 5.74308783e-02f, -1.37462795e-01f, -8.17895830e-02f, -4.64178436e-02f, -4.54781614e-02f, -3.65717672e-02f,
  -3.87218446e-02f, -3.25450227e-02f, -4.32045124e-02f, 3.83530669e-02f, 4.21121065e-03f, -1.77418180e-02f, 4.93682064e-02f, 4.83600348e-02f, 9.18807983e-02f, 4.37057279e-02f,
  -6.85352832e-02f, -4.49895207e-03f, 8.16205740e-02f, -2.08108146e-02f, 3.85755338e-02f, 1.83305163e-02f, 4.56204228e-02f, 4.80576195e-02f, -4.94690379e-03f, 5.09428941e-02f,
  7.52983540e-02f, -1.87723488e-02f, 2.38065552e-02f, 6.32274821e-02f, 3.15669030e-02f, 7.82246590e-02f, 3.11072003e-02f, 5.40561043e-02f, -4.09096554e-02f, 9.46436357e-03f,
  2.85462998e-02f, 2.64449269e-02f, -3.27448994e-02f, 2.85199508e-02f, 2.49237027e-02f, -1.48776453e-02f, 3.94851988e-04f, 2.81244908e-02f, -1.83847155e-02f, 5.12337871e-02f,
  3.39614183e-01f, 2.51122862e-01f, 3.96857820e-02f, -8.07464868e-03f, 1.94858294e-02f, 1.04378127e-01f, -4.32507433e-02f, 6.18857145e-02f, 2.38288790e-02f, 1.74194444e-02f,
  2.24701818e-02f, 9.30855870e-02f, 2.79286560e-02f, -1.08667593e-02f, -7.88625388e-04f, 9.93881002e-02f, 1.28882185e-01f, 3.20888646e-02f, 1.40158132e-01f, -1.91027764e-02f,
  2.37772465e-02f, 7.06497356e-02f, 1.26015116e-02f, -7.94613920e-03f, 4.02500518e-02f, 1.98397115e-02f, 2.02731434e-02f, -7.00345356e-03f, -1.63793296e-03f, -1.21408410e-03f,
  1.29185133e-02f, 1.88801974e-01f, 1.91882476e-01f, 5.31233475e-02f, 7.16472641e-02f, -3.10613573e-01f, -1.99584872e-01f, 1.50462866e-01f, 2.96355039e-01f, 1.07298186e-03f,
  -1.51368439e-01f, 5.65698184e-02f, 5.03209569e-02f, -1.08525902e-01f, -3.55867863e-01f, -8.17847177e-02f, -1.76949814e-01f, -1.52717844e-01f, 1.23635612e-01f, 1.00247217e-02f,
  -2.67187729e-02f, -1.63128644e-01f, -3.81733775e-02f, 5.03232107e-02f, 1.63037609e-02f, 1.20687552e-01f, -1.25941619e-01f, 1.07101344e-01f, -1.44458517e-01f, -1.35555968e-01f,
  -3.04847769e-02f, 1.29195750e-01f, 6.29615039e-02f, 4.70245704e-02f, -7.33621558e-03f, -8.89372230e-02f, -1.07087031e-01f, -1.06213138e-01f, -9.70414781e-04f, 6.37420788e-02f,
  -2.07708757e-02f, 4.94928174e-02f, -1.74031109e-02f, 3.66824269e-02f, 4.21154983e-02f, 1.10639684e-01f, 5.48366196e-02f, 5.57140000e-02f, 9.09176916e-02f, 1.51009066e-02f,
  8.22075680e-02f, -3.74167599e-02f, -4.97615039e-02f, -7.22728446e-02f, 4.13352363e-02f, 1.71212163e-02f, -2.71799657e-02f, 7.34086893e-03f, -2.98304372e-02f, 5.04247099e-03f,
  -6.89781979e-02f, -6.71124235e-02f, -1.87910702e-02f, 1.54716671e-02f, -4.07874696e-02f, 4.99912910e-02f, 4.99968417e-03f, -3.70243676e-02f, 2.91939564e-02f, -3.64218056e-02f,
  -2.26522535e-02f, -1.94644481e-02f, -2.57251430e-02f, -4.83322218e-02f, -7.75690526e-02f, 3.80745009e-02f, -7.46253580e-02f, 1.44696431e-02f, -1.58990256e-03f, 2.75274087e-02f,
  1.73381902e-02f, -6.07824512e-02f, 3.50310877e-02f, -4.71689552e-02f, 8.45617987e-03f, 3.73725705e-02f, 3.32258977e-02f, 6.56451210e-02f, 2.31612716e-02f, -5.80059402e-02f,
  -1.04342848e-01f, -2.48543709e-03f, 1.12244092e-01f, 3.68498638e-02f, 4.96225916e-02f, -3.15147005e-02f, 1.76627990e-02f, 6.60979673e-02f, -2.49854364e-02f, -7.61510283e-02f,
  -2.31478233e-02f, -1.82279553e-02f, -2.59852167e-02f, -2.98474506e-02f, -6.65650815e-02f, -6.27230182e-02f, -6.97313473e-02f, -2.45478712e-02f, -1.10165469e-01f, 4.83059278e-03f,
  -1.06903212e-02f, -4.52721380e-02f, -6.24047918e-03f, 3.16370912e-02f, -5.73944673e-02f, -4.31070626e-02f, 3.17462012e-02f, 1.91184052e-03f, -4.23302501e-02f, 1.77855305e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.45084599e-01f, -2.37458333e-01f, -1.33503616e-01f, 1.40613541e-01f, 8.70293155e-02f, -2.79044092e-01f, -2.99738348e-01f, 1.30823597e-01f, -1.73530489e-01f, -1.68886304e-01f,
  8.69832654e-03f, -3.18107456e-01f, -3.01805377e-01f, -1.20066710e-01f, 1.57770410e-01f, -2.31960431e-01f, 7.02553168e-02f, -1.42005086e-01f, -2.20307447e-02f, 1.70236483e-01f,
  2.34277457e-01f, 1.75886735e-01f, 2.20014349e-01f, 3.71148437e-01f, 4.40513454e-02f, 3.63228291e-01f, 4.37515855e-01f, 1.54966354e-01f, 2.83417434e-01f, 4.83308844e-02f,
  -4.75000888e-02f, 4.78050485e-02f, -5.33255339e-02f, -6.87517272e-03f, 5.27904853e-02f, 3.07405330e-02f, 2.70550735e-02f, 4.38376516e-02f, 2.51363441e-02f, 1.37838535e-03f,
  -4.84865233e-02f, 5.10534272e-02f, -1.76834576e-02f, -3.21707614e-02f, 1.03297001e-02f, 8.33198205e-02f, 2.36084163e-02f, -3.04248184e-02f, 5.78254694e-03f, -1.07706934e-01f,
  -4.23940755e-02f, -5.04797846e-02f, -5.14441431e-02f, -4.27098013e-02f, 8.33935589e-02f, -7.14838281e-02f, -2.45995889e-03f, -6.22326955e-02f, -5.09399138e-02f, 5.36273196e-02f,
  -1.05453636e-02f, -1.02711255e-02f, -1.58019155e-01f, -6.23995066e-02f, -2.77946983e-02f, -1.16275921e-02f, 6.77387714e-02f, 6.25473857e-02f, -1.51272947e-02f, 1.74163934e-03f,
  2.90670600e-02f, 2.41899509e-02f, -6.31998181e-02f, 4.32525277e-02f, -8.36451445e-03f, -6.59890324e-02f, 1.87684353e-02f, 1.50380144e-02f, -3.24880518e-02f, -2.09866241e-02f,
  4.96778861e-02f, -5.52728809e-02f, -5.82863726e-02f, 3.02151013e-02f, -1.65838841e-02f, -3.02443150e-02f, 8.39497745e-02f, -6.18685484e-02f, -2.89757121e-02f, -3.54356738e-03f,
  8.74692649e-02f, 2.93718874e-01f, 3.33949700e-02f, -6.29210249e-02f, 8.31923932e-02f, 2.41947398e-02f, 6.27821907e-02f, -4.78508323e-02f, 1.52721643e-01f, 3.30197699e-02f,
  2.33477987e-02f, 9.56543237e-02f, 1.55293429e-02f, -9.79262032e-03f, 1.35816693e-01f, -2.15002149e-02f, 7.53710195e-02f, 5.75537905e-02f, 7.82392696e-02f, 1.43879712e-01f,
  1.18521908e-02f, -5.70551818e-03f, 8.66718218e-02f, 4.82835434e-02f, 4.46125418e-02f, 6.11075088e-02f, -3.40749435e-02f, 8.73497948e-02f, 6.35670424e-02f, 4.11974490e-02f,
  1.71736032e-01f, 1.70691386e-01f, 3.16193789e-01f, 6.49430929e-03f, 5.07305712e-02f, -1.32671028e-01f, -1.01749353e-01f, 1.60402656e-01f, 3.08965653e-01f, -1.77677482e-01f,
  -5.08597419e-02f, 1.81957439e-01f, -1.03441272e-02f, -7.60527775e-02f, -5.24825696e-03f, -6.12117723e-02f, -1.04517508e-02f, -2.97504198e-02f, 3.84825319e-02f, 1.67647135e-02f,
  -2.91024614e-02f, -2.59577692e-01f, -3.15752216e-02f, -2.13649832e-02f, 3.04980315e-02f, 1.10559098e-01f, -2.21390709e-01f, -1.03172623e-01f, 2.16813711e-03f, -3.12865339e-02f,
  -8.67009237e-02f, 1.79742388e-02f, 1.70087546e-01f, 1.42022982e-01f, -4.14977819e-02f, 5.40788509e-02f, -9.21272188e-02f, -6.89184517e-02f, 2.90675350e-02f, -1.05898073e-02f,
  3.92775647e-02f, -9.44690593e-03f, 8.45441744e-02f, 4.91937399e-02f, 1.10909075e-01f, -1.65750012e-02f, 2.67783124e-02f, 8.09026957e-02f, 1.20938458e-01f, 1.24150969e-01f,
  7.48859569e-02f, 1.04699619e-01f, 9.11073014e-02f, 9.79624968e-03f, 5.75044453e-02f, -1.76338535e-02f, -7.37076029e-02f, -8.25959370e-02f, -6.72755539e-02f, 7.27135986e-02f,
  1.01786956e-01f, -1.65876432e-03f, 1.06846290e-02f, -2.35808175e-02f, -1.86047833e-02f, -6.79759979e-02f, 4.39382531e-02f, 3.38828042e-02f, -6.98474050e-02f, -1.68081019e-02f,
  3.78566310e-02f, -4.15649004e-02f, -6.49454668e-02f, -2.64838748e-02f, -2.04739887e-02f, -5.03782975e-03f, 3.30016352e-02f, -1.63027961e-02f, 5.28370924e-02f, 2.20669322e-02f,
  -8.40306282e-03f, 2.48478595e-02f, -5.42218350e-02f, -4.74385405e-03f, 5.91632463e-02f, -1.43734738e-02f, -6.59657270e-02f, -3.32466550e-02f, -6.68747351e-02f, -5.32671399e-02f,
  -4.48612384e-02f, -1.49713680e-01f, 3.52435894e-02f, -4.69056293e-02f, -9.33906808e-02f, 4.52554114e-02f, -7.47087151e-02f, 1.19731545e-01f, -6.19907454e-02f, 6.44999892e-02f,
  1.41389286e-02f, -7.96295889e-03f, 1.04336394e-03f, 2.74818614e-02f, -9.24792662e-02f, -8.37347284e-02f, 4.04877104e-02f, 4.52723578e-02f, -2.45415289e-02f, -6.96173236e-02f,
  1.08079612e-02f, -1.07156552e-01f, 4.28610779e-02f, 7.84097388e-02f, 7.14395195e-02f, -5.39425053e-02f, -2.59134965e-03f, -2.61328351e-02f, -1.05381660e-01f, -1.55985979e-02f,
  3.50777030e-01f, 1.65498063e-01f, -3.37168157e-01f, -4.24918979e-02f, -3.58062498e-02f, 1.67602271e-01f, 1.79067537e-01f, 7.02246800e-02f, 2.23383963e-01f, 1.31115109e-01f,
  1.98572844e-01f, -6.57057762e-02f, 5.12869731e-02f, 2.73751318e-01f, 9.44531932e-02f, 1.57657415e-01f, 3.28966945e-01f, 2.63580650e-01f, -5.98183759e-02f, 9.92269516e-02f,
  9.70924497e-02f, 2.94899553e-01f, -1.84972003e-01f, -8.90001506e-02f, 1.17053613e-02f, -1.39867410e-01f, -2.09843740e-01f, -3.09876174e-01f, 2.77174246e-02f, -6.40970469e-02f,
  7.29743317e-02f, 1.16630346e-01f, -3.37005481e-02f, -7.47913262e-03f, 1.60660949e-02f, -6.59414893e-03f, -1.28178343e-01f, -4.73505184e-02f, -7.71482512e-02f, -1.66021287e-02f,
  6.91536143e-02f, 3.71042043e-02f, 2.18399875e-02f, -2.13240404e-02f, 4.99969982e-02f, -7.97994062e-02f, -9.51503068e-02f, -7.59958401e-02f, -4.47525345e-02f, -7.58578256e-03f,
  -8.29394236e-02f, -2.56946310e-03f, -3.65102291e-02f, -3.27023119e-02f, -8.40759277e-02f, -2.34277025e-02f, 5.55967819e-03f, -1.04202710e-01f, -1.50035918e-02f, 3.93578224e-02f,
  7.66034126e-02f, 6.92870915e-02f, 9.61096287e-02f, 2.68751811e-02f, -5.64461425e-02f, -6.19685650e-02f, 1.44056296e-02f, 3.90861407e-02f, 6.32134527e-02f, -3.81928720e-02f,
  -4.12935726e-02f, 8.81962758e-03f, -4.35254909e-02f, -5.01481667e-02f, 7.78508410e-02f, 1.66660938e-02f, -7.44963363e-02f, -1.79802179e-02f, 1.33014452e-02f, -1.49964718e-02f,
  -2.29312479e-02f, 9.08597186e-02f, -1.55300377e-02f, -3.97138894e-02f, -2.97880787e-02f, -4.18643579e-02f, 5.29573262e-02f, 8.83299857e-03f, -8.49323645e-02f, -6.68116426e-03f,
  1.75726652e-01f, 1.00650169e-01f, 3.43798697e-02f, 1.81238670e-02f, 2.08635796e-02f, 8.35161135e-02f, 6.69906735e-02f, 1.82558019e-02f, 5.29825240e-02f, 1.33391544e-01f,
  -1.39506562e-02f, -7.91220069e-02f, 2.99559273e-02f, 2.10560914e-02f, -2.08165892e-03f, 2.30081584e-02f, -2.15161927e-02f, 1.28898015e-02f, -8.45072344e-02f, -1.15068592e-02f,
  -5.47754169e-02f, 2.70989165e-02f, 7.53575936e-02f, -1.87831167e-02f, 5.46729118e-02f, 5.89419436e-03f, 3.90504636e-02f, 1.06395278e-02f, -3.51589955e-02f, -7.06237331e-02f,
  1.78570122e-01f, 4.92601916e-02f, 1.17725424e-01f, 2.39501551e-01f, 8.43079016e-02f, 1.53430328e-01f, 2.12204587e-02f, 1.22006163e-02f, 4.24947232e-01f, -1.41063571e-01f,
  -2.60441512e-01f, 8.75106454e-02f, -2.82646060e-01f, 3.40793282e-02f, 5.75933903e-02f, 7.66240805e-03f, 1.24255508e-01f, -2.42373869e-02f, 1.98769718e-01f, -2.16912366e-02f,
  1.39097339e-02f, -1.32516414e-01f, -1.58112392e-01f, -2.28993014e-01f, -2.00981479e-02f, 4.88989651e-02f, -2.68053681e-01f, -1.23192318e-01f, -9.10690352e-02f, 9.02932137e-03f,
  -4.58679860e-03f, 9.46231261e-02f, -4.70974781e-02f, 9.66905877e-02f, 3.61004993e-02f, -7.39581883e-02f, 7.52151832e-02f, -2.23505832e-02f, 1.26644909e-01f, 3.93240936e-02f,
  1.11993039e-02f, 1.14474455e-02f, 1.22338980e-01f, -2.41121687e-02f, 6.93678558e-02f, -9.39412136e-03f, 3.20728607e-02f, 2.52972525e-02f, 5.16056716e-02f, 3.77799161e-02f,
  8.22816342e-02f, 1.86769627e-02f, 2.46581491e-02f, -7.30620371e-03f, -1.30074993e-02f, -2.92018112e-02f, 3.26344818e-02f, -1.16407610e-01f, 7.49065131e-02f, 6.45750538e-02f,
  -1.14223652e-01f, 3.93443853e-02f, -8.97560120e-02f, 1.35792065e-02f, -6.25145137e-02f, -4.46879528e-02f, -1.24944758e-03f, -9.99928936e-02f, -1.68583672e-02f, -5.64050078e-02f,
  4.54758853e-02f, -4.80853096e-02f, 8.01655799e-02f, 7.99390227e-02f, 4.83403727e-02f, 3.78078781e-03f, -4.58750091e-02f, -5.48383184e-02f, 5.48715815e-02f, -1.61971301e-02f,
  -2.25596013e-03f, -1.86586231e-02f, 1.56119168e-02f, 1.19762532e-02f, -8.23715795e-03f, -6.31557405e-02f, 4.64259535e-02f, -9.77502763e-03f, -6.88908026e-02f, -5.59200607e-02f,
  4.51383144e-02f, -1.48425534e-01f, -1.96268652e-02f, 7.30570033e-02f, 4.24682675e-03f, 1.06956111e-03f, 8.45618472e-02f, 5.09635434e-02f, 1.88774813e-03f, -6.31006211e-02f,
  -5.32339923e-02f, 5.44561408e-02f, -8.56381133e-02f, -1.41461296e-02f, 7.39287958e-02f, -3.19668129e-02f, -4.46598837e-03f, -8.88757594e-03f, 4.25399989e-02f, -6.54114932e-02f,
  -7.22778291e-02f, 3.29352058e-02f, 2.67466381e-02f, 6.11069379e-03f, 4.61182073e-02f, -4.32460010e-03f, -4.41465676e-02f, -1.14782499e-02f, -4.76266779e-02f, 6.90292791e-02f,
  1.14047766e-01f, -2.33085603e-01f, -6.73415586e-02f, 2.07529985e-03f, 1.31440341e-01f, 8.17549527e-02f, 9.19719040e-02f, -2.18723714e-01f, -2.22705275e-01f, -3.08737606e-01f,
  6.45594001e-02f, 4.09226939e-02f, -1.30593970e-01f, 8.13456476e-02f, 3.40162337e-01f, 1.23914517e-03f, -3.52675654e-02f, 1.30189598e-01f, 6.71419203e-02f, -1.13632374e-01f,
  5.65009527e-02f, 4.92028408e-02f, 1.29071146e-01f, 4.39531840e-02f, 4.64098118e-02f, 3.77779640e-02f, 7.80153871e-02f, 2.44969968e-02f, 3.01715657e-02f, 1.83502376e-01f,
  3.47550679e-03f, -7.12893158e-02f, -4.55931062e-03f, 5.05731516e-02f, -3.59471552e-02f, -5.22325858e-02f, 5.16552553e-02f, 9.37243626e-02f, -3.28394696e-02f, 1.26116872e-02f,
  8.90245661e-02f, 8.18911791e-02f, -6.74392506e-02f, 1.02050237e-01f, -2.28196345e-02f, -2.26579644e-02f, -7.15602785e-02f, -1.24150850e-01f, -4.15880531e-02f, 3.16512026e-02f,
  3.72420484e-03f, -7.14485571e-02f, -7.38315880e-02f, 1.93228573e-02f, 7.29860961e-02f, -9.42392498e-02f, -6.28858805e-02f, -1.68523123e-03f, -7.72532821e-02f, -7.31763691e-02f,
  8.20745528e-02f, 9.85382497e-02f, 1.23044371e-03f, 7.08129779e-02f, 4.84403484e-02f, -4.16340418e-02f, 6.52119070e-02f, 2.56181415e-02f, 3.36811729e-02f, 5.92893623e-02f,
  2.58006454e-02f, 1.50817186e-02f, -7.39255548e-02f, -8.83337036e-02f, -6.55519962e-02f, -5.20814061e-02f, -3.59679796e-02f, 8.58403519e-02f, 4.60605510e-02f, 5.00120297e-02f,
  -3.08052599e-02f, 4.55196463e-02f, -6.37483411e-03f, 7.16760233e-02f, -4.10580635e-03f, -2.55653728e-02f, -4.00866615e-03f, -3.18710394e-02f, -6.32231086e-02f, 6.32309690e-02f,
  -1.19086035e-01f, -1.32147834e-01f, -2.08866820e-02f, -1.96594913e-02f, -3.35772447e-02f, 7.79208168e-02f, -2.26528738e-02f, -1.20086479e-03f, -5.75219886e-03f, -8.04390311e-02f,
  -2.47902740e-02f, -5.05170561e-02f, 4.74170921e-03f, 1.38801225e-02f, 8.62966478e-02f, -9.84921008e-02f, 4.67365682e-02f, -1.92033686e-02f, -6.10260628e-02f, -4.57960963e-02f,
  -8.25879127e-02f, 2.73227096e-02f, 3.15446854e-02f, 7.46938735e-02f, -3.87690999e-02f, 6.89871013e-02f, 8.65159277e-03f, 2.13329028e-02f, 5.59828244e-02f, -8.28967616e-03f,
  -1.13383554e-01f, 6.96034282e-02f, -1.49778441e-01f, 5.42855775e-03f, 1.42521590e-01f, 9.17427093e-02f, 1.38268113e-01f, 1.58237070e-01f, 1.96133852e-01f, 1.59649923e-01f,
  1.55047461e-01f, 2.89843716e-02f, -5.96972816e-02f, 1.26160964e-01f, -1.88799538e-02f, 4.84522618e-03f, 2.55986422e-01f, 1.52458057e-01f, 7.91793019e-02f, 7.91045949e-02f,
  -3.65151651e-02f, 1.93374842e-01f, -5.87254204e-02f, -1.21876569e-02f, -3.66661488e-03f, -2.61015054e-02f, 3.41112986e-02f, -2.12452039e-01f, 1.00394487e-01f, 8.45569670e-02f,
  -4.61258441e-02f, -6.79299608e-02f, -5.13010956e-02f, -5.99594191e-02f, -9.15690437e-02f, 5.89854792e-02f, -1.19504720e-01f, -7.78820440e-02f, -9.36362669e-02f, 3.66161130e-02f,
  -9.83385071e-02f, 2.27822997e-02f, -1.40260784e-02f, -2.73019690e-02f, -5.01863211e-02f, 8.60262364e-02f, 6.57330081e-02f, -7.94836041e-03f, -7.80321583e-02f, -1.12728737e-01f,
  -5.22177853e-02f, -9.48018208e-02f, 6.96403906e-02f, 3.44942547e-02f, -1.93603821e-02f, 4.75636162e-02f, -4.90057981e-03f, -9.22791585e-02f, -4.71153483e-02f, 6.04119897e-02f,
  -5.16191944e-02f, 3.30177583e-02f, -5.14248423e-02f, 6.71178773e-02f, -2.72643995e-02f, -6.21351339e-02f, -6.35241643e-02f, 3.46321538e-02f, -8.72274712e-02f, 5.42221367e-02f,
  -3.11441384e-02f, -2.18087770e-02f, 3.28651741e-02f, -1.57004911e-02f, -1.21275699e-02f, -2.35776752e-02f, -8.16792622e-02f, -2.38368101e-02f, 9.14974883e-02f, -2.21014880e-02f,
  3.46316546e-02f, 1.26404045e-02f, -5.61931496e-03f, -8.23485851e-02f, 2.78774351e-02f, 3.26674581e-02f, 8.30440447e-02f, 4.27887924e-02f, 4.39855494e-02f, -8.31760168e-02f,
  -7.15998411e-02f, -1.14606872e-01f, -1.26948056e-03f, -8.37879255e-02f, 1.46926185e-02f, -4.92580293e-04f, -4.24963497e-02f, -4.22891602e-02f, 4.32851166e-02f, -7.17234612e-02f,
  4.77422215e-02f, -8.04935098e-02f, -6.70688227e-02f, -3.98161858e-02f, -4.81923446e-02f, 1.57926586e-02f, 2.72452626e-02f, -2.10736915e-02f, -4.68900055e-02f, 1.36278430e-02f,
  -5.06034419e-02f, 1.51611837e-02f, 3.22357155e-02f, 3.30048278e-02f, -1.36390643e-03f, 6.77242801e-02f, 4.28688601e-02f, -1.99835766e-02f, 2.57503036e-02f, 2.02481784e-02f,
  1.80824623e-01f, -1.42460838e-01f, -1.70162261e-01f, 2.45410409e-02f, -6.87721446e-02f, -2.62955785e-01f, -3.12320262e-01f, -1.34550288e-01f, -5.41728660e-02f, -8.96717533e-02f,
  -9.27700549e-02f, -1.83996372e-03f, 4.99684624e-02f, -2.03925163e-01f, 4.60322313e-02f, 1.71327144e-01f, -1.44216701e-01f, -1.34820402e-01f, 7.70893171e-02f, -1.79363817e-01f,
  7.10150450e-02f, -1.14971578e-01f, -6.56740516e-02f, -6.74691498e-02f, -8.95402282e-02f, 4.04481664e-02f, 2.26764992e-01f, -4.42631133e-02f, -1.41768098e-01f, -4.68462966e-02f,
  -1.13097772e-01f, -2.65615750e-02f, -1.23844795e-01f, 3.25798094e-02f, 2.30402108e-02f, -9.04909596e-02f, -5.02387732e-02f, 2.09302455e-02f, 5.78349978e-02f, -6.89513683e-02f,
  -3.98675501e-02f, -1.86527316e-02f, -7.44300038e-02f, 8.97585005e-02f, -5.53807691e-02f, 5.62261753e-02f, 9.43512097e-02f, 3.16681750e-02f, -9.13041085e-02f, -3.38424891e-02f,
  -1.73470899e-02f, -5.44974096e-02f, -2.67175008e-02f, -5.74245378e-02f, 3.20848040e-02f, 3.41787213e-03f, 3.33849899e-02f, -3.66623960e-02f, 4.49692197e-02f, 2.93658804e-02f,
  3.34604532e-02f, -4.27525975e-02f, 4.88773361e-02f, -2.16190424e-02f, 9.12480894e-03f, 4.87272441e-02f, -1.51903192e-02f, 7.59332702e-02f, 4.38320711e-02f, 6.16256855e-02f,
  1.07765077e-02f, 1.44179584e-02f, 5.54199964e-02f, -3.74338999e-02f, 7.01704109e-03f, -1.62395854e-02f, -9.05326158e-02f, 4.93448712e-02f, -2.54682507e-02f, -6.57207370e-02f,
  8.25995207e-02f, 1.00536970e-02f, 5.18747419e-02f, -4.43179458e-02f, -1.05972908e-01f, 6.91604763e-02f, 2.10688282e-02f, 3.12601477e-02f, 1.20813334e-02f, -4.41195555e-02f,
  -5.13319150e-02f, -8.59266743e-02f, 5.48515022e-02f, -1.03672063e-02f, 3.58878896e-02f, 3.62665206e-02f, 5.67264073e-02f, -2.97531132e-02f, -6.70321472e-03f, 7.99782388e-03f,
  1.76468138e-02f, 6.29865453e-02f, 7.23800361e-02f, 5.00915684e-02f, 6.49326816e-02f, -8.78352672e-02f, -4.13454957e-02f, 6.26826435e-02f, -6.39679655e-02f, 1.14862591e-01f,
  -3.30430306e-02f, 4.60924581e-02f, 8.63203257e-02f, -9.41581056e-02f, -1.30218463e-02f, 2.86836177e-02f, -4.47827973e-04f, -4.84545119e-02f, -6.56259432e-02f, -9.75780003e-03f,
  2.48284470e-02f, -6.41808205e-04f, -5.35315394e-01f, -1.79255635e-01f, -2.23619595e-01f, -2.27562636e-01f, -1.01592422e-01f, -1.50434867e-01f, -1.62227094e-01f, 3.51079613e-01f,
  1.57621056e-01f, -4.09015566e-02f, 1.08535826e-01f, 3.99495959e-02f, -4.72186878e-02f, 1.68140888e-01f, 1.64768249e-01f, 2.27238819e-01f, -4.64800261e-02f, -1.38327256e-01f,
  -7.63365030e-02f, 1.19718894e-01f, -1.25786960e-01f, -7.85842389e-02f, -1.36124387e-01f, -1.82016924e-01f, 1.94621593e-01f, -3.10949326e-01f, 5.27324760e-03f, -4.87757176e-02f,
  -5.30612804e-02f, -1.15397282e-01f, -3.33857089e-02f, -3.59879178e-03f, -4.53478731e-02f, 7.99307153e-02f, 6.20829388e-02f, -1.26959726e-01f, -4.87852357e-02f, -3.49677466e-02f,
  9.44491699e-02f, -3.72677157e-03f, 1.50071494e-02f, -1.36246560e-02f, -5.78964837e-02f, -1.08998470e-01f, -8.60210210e-02f, 5.47595397e-02f, -6.69064671e-02f, -4.58569191e-02f,
  -1.21194638e-01f, 1.01644162e-03f, 5.90709783e-02f, 1.70129519e-02f, 3.01730037e-02f, -1.98866595e-02f, 1.68794300e-02f, -1.23661794e-02f, 8.86206031e-02f, -6.47389218e-02f,
  -3.44504081e-02f, 4.33550514e-02f, 4.05564606e-02f, 1.24734510e-02f, -8.77570808e-02f, 5.63977398e-02f, -1.71597698e-03f, -1.46797886e-02f, -8.32636207e-02f, 2.81941686e-02f,
  -6.92442656e-02f, -4.01522294e-02f, -9.13790427e-03f, -1.79607645e-02f, 7.78472126e-02f, 2.10404005e-02f, -2.50371732e-02f, 6.00654585e-03f, -1.11772493e-01f, 1.55034512e-02f,
  6.28985232e-03f, -8.98770392e-02f, -6.24196008e-02f, 1.45401448e-01f, -4.45744023e-02f, -2.90655345e-02f, -2.79358532e-02f, 2.32111830e-02f, 1.92232579e-02f, -2.50017806e-03f,
  -7.89137259e-02f, -8.05798993e-02f, -1.20262995e-01f, -4.49311017e-04f, -2.27665100e-02f, 3.69606018e-02f, 6.75534755e-02f, -2.49525096e-04f, 1.76021247e-03f, -7.40221888e-02f,
  -3.00798230e-02f, -1.04492651e-02f, 6.23571221e-03f, 4.14259322e-02f, 8.92813969e-03f, -7.56214261e-02f, 5.73125482e-02f, 4.37627211e-02f, 1.31934304e-02f, -3.35053355e-02f,
  1.87731478e-02f, 2.23440323e-02f, -1.42629184e-02f, -6.21465733e-04f, 3.63112539e-02f, 8.25957283e-02f, 1.37615465e-02f, 8.07650096e-04f, 8.48751329e-03f, -8.66933726e-03f,
  -1.70842111e-02f, -3.86681221e-02f, 1.52733952e-01f, 1.30027950e-01f, -8.20462480e-02f, -1.61700770e-02f, -8.44205022e-02f, 8.93406279e-04f, 6.36330224e-04f, -1.33129908e-03f,
  9.00382251e-02f, 1.21551111e-01f, -1.19072147e-01f, 1.32274389e-01f, -9.33195725e-02f, -7.54287019e-02f, -3.20586227e-02f, 1.32638454e-01f, -2.07218826e-02f, -3.59572284e-03f,
  1.01361154e-02f, 1.09666334e-02f, 6.97473958e-02f, 1.11885056e-01f, 2.52826046e-02f, 3.53629589e-02f, 8.64619613e-02f, -3.43752876e-02f, 1.68555856e-01f, -2.61928048e-02f,
  3.44549492e-02f, -6.32599667e-02f, 7.04174563e-02f, 1.02692261e-01f, -4.54803463e-03f, -8.22245795e-03f, 1.50535166e-01f, 1.00547135e-01f, 9.50111728e-03f, 2.78253155e-03f,
  -2.57502571e-02f, -7.19142258e-02f, -2.17136983e-02f, 7.86463916e-02f, 8.01655054e-02f, 9.66153368e-02f, -1.35529693e-02f, -2.76617659e-03f, 3.80059220e-02f, -6.20801672e-02f,
  -5.31565174e-02f, -4.60956655e-02f, 6.69511184e-02f, -1.68940611e-02f, -7.49060586e-02f, 1.97333414e-02f, -2.37680785e-02f, 5.55238947e-02f, 1.40014952e-02f, -2.16019861e-02f,
  -2.73051839e-02f, 8.95710569e-03f, 4.90118153e-02f, 4.41525951e-02f, -2.84543703e-03f, -6.65877536e-02f, -7.04181269e-02f, -7.38104805e-02f, 1.29536334e-02f, -8.53141248e-02f,
  -5.96818998e-02f, -4.59824689e-02f, -2.79825367e-02f, -5.27824499e-02f, 6.98636770e-02f, 9.24972966e-02f, -2.48758756e-02f, 3.25874351e-02f, 7.48746619e-02f, -1.07262032e-02f,
  -5.02714589e-02f, 3.00425962e-02f, -4.49371338e-02f, -5.02173677e-02f, 9.37591195e-02f, 4.08703312e-02f, 5.65753244e-02f, -1.17594888e-02f, 1.89107228e-02f, 6.41211420e-02f,
  3.44401821e-02f, -1.80892006e-01f, 2.61761434e-02f, 4.21422608e-02f, -5.18518128e-02f, -6.17116615e-02f, -6.55481964e-02f, -2.92313863e-02f, 4.92616557e-02f, -3.68786678e-02f,
  -6.35476187e-02f, 9.93664339e-02f, 1.50277913e-02f, -1.62515622e-02f, -6.98923469e-02f, -6.37982711e-02f, -3.24497409e-02f, 9.64844152e-02f, 8.70132297e-02f, -2.34837178e-02f,
  9.19706300e-02f, -7.31911287e-02f, 1.61889680e-02f, -8.35777447e-03f, 1.19823823e-02f, 4.32346836e-02f, 7.75742829e-02f, -4.37689982e-02f, -7.40512758e-02f, 4.80246805e-02f,
  6.14106283e-03f, 7.87213165e-03f, -1.00777760e-01f, 2.60897018e-02f, -1.44489065e-01f, 7.46793766e-03f, -6.69830590e-02f, -4.17157933e-02f, -1.99450180e-02f, -1.36192054e-01f,
  -1.25485063e-01f, -3.19078378e-02f, -5.64264506e-03f, -1.10953830e-01f, 1.95370480e-01f, 1.69354752e-01f, 4.55517508e-02f, 3.54396887e-02f, 8.28270912e-02f, -1.30842268e-01f,
  -2.15033162e-02f, 1.72341112e-02f, -8.36829131e-04f, -1.69272169e-01f, -1.45344481e-01f, -9.90833938e-02f, -7.03392476e-02f, -3.89127843e-02f, -1.58152521e-01f, 7.22596515e-03f,
  -3.04572098e-03f, -1.59713551e-02f, -9.59515050e-02f, 6.19802345e-03f, 5.77847548e-02f, -2.56509185e-02f, -6.53029010e-02f, -7.15046795e-03f, -7.55919144e-02f, -1.66951586e-02f,
  -6.57638386e-02f, 3.82005051e-02f, -3.25036957e-03f, 1.78596787e-02f, -2.28843056e-02f, -7.02703819e-02f, 4.59543429e-02f, -3.30820382e-02f, 2.26287786e-02f, -4.15492943e-03f,
  -5.46869226e-02f, 2.52367835e-02f, -8.75969604e-03f, 1.87916625e-02f, -4.52546440e-02f, -1.68537870e-02f, 8.05217251e-02f, -5.29744439e-02f, 1.90572150e-03f, 1.85132287e-02f,
  -8.56302530e-02f, -1.24792401e-02f, 3.34016830e-02f, -3.48056331e-02f, -4.69380245e-02f, -7.27560744e-02f, -7.59450942e-02f, -1.31130731e-02f, -4.98546064e-02f, -4.04458679e-02f,
  -4.10107188e-02f, 5.91193140e-02f, -7.50475079e-02f, 6.53593168e-02f, 1.15364734e-02f, 8.79813433e-02f, 5.77013893e-03f, 6.27191961e-02f, 8.31405073e-02f, -6.96132109e-02f,
  -7.02104941e-02f, 9.05680750e-03f, -2.01056129e-03f, -4.89292666e-02f, 4.77178581e-02f, -6.69455677e-02f, 3.74200083e-02f, 1.28121092e-03f, 3.63817811e-02f, 6.69961348e-02f,
  7.99001679e-02f, 2.77741514e-02f, -6.44584298e-02f, -9.26823076e-03f, -4.07545418e-02f, 3.89686450e-02f, -4.56831604e-02f, -7.76150897e-02f, 4.61500473e-02f, -1.64467227e-02f,
  5.57134971e-02f, 1.25259301e-02f, 6.16882276e-03f, -5.06487899e-02f, 5.77786192e-02f, -4.29096930e-02f, 3.27840005e-03f, 2.05981024e-02f, -6.31027967e-02f, -3.97022367e-02f,
  4.39750627e-02f, -5.04907779e-02f, 1.89635549e-02f, -7.74118826e-02f, 6.16488159e-02f, -4.34226841e-02f, 4.04332317e-02f, -2.96140108e-02f, 2.12786580e-03f, -1.64960846e-02f,
  2.10305210e-02f, -2.49425158e-01f, -1.15236156e-01f, -1.13842189e-01f, 1.39299273e-01f, 1.87800795e-01f, 2.86165476e-01f, 2.55170595e-02f, -1.16536185e-01f, 1.00607529e-01f,
  2.24441290e-01f, -2.42616594e-01f, -3.16648893e-02f, 8.92008021e-02f, 3.21543664e-02f, -1.78604275e-02f, 1.23810261e-01f, 1.24567233e-01f, -1.03491329e-01f, -5.59226098e-03f,
  7.69039690e-02f, 2.41473597e-02f, -3.62155959e-02f, -8.30990672e-02f, 1.09148331e-01f, -1.01298973e-01f, 5.49255461e-02f, 3.29041854e-03f, -2.05971245e-02f, 5.33536151e-02f,
  1.56319499e-01f, -4.22832035e-02f, 8.16981718e-02f, -7.42055699e-02f, 1.64201409e-01f, 1.43149480e-01f, 3.74228060e-02f, -3.01599689e-02f, -5.87358139e-02f, -5.37540019e-02f,
  -8.54251757e-02f, -5.64495288e-02f, -5.63173443e-02f, -1.08385175e-01f, -8.30898881e-02f, -2.20853575e-02f, -1.04291819e-01f, 3.95450331e-02f, 3.50361168e-02f, 5.09333536e-02f,
  -8.06479529e-03f, -1.04783894e-02f, 1.50616942e-02f, -1.04149826e-01f, -9.99809951e-02f, -8.36954042e-02f, -7.60113029e-03f, 1.04232922e-01f, 3.98668461e-02f, 2.31594732e-03f,
  -7.28193074e-02f, 6.88401014e-02f, 2.64148209e-02f, -2.28659827e-02f, 7.57732689e-02f, -4.64913286e-02f, -8.00654739e-02f, -1.60477050e-02f, -6.65189475e-02f, 1.30576640e-01f,
  3.36652435e-02f, -4.06706035e-02f, 6.37320131e-02f, 3.91766094e-02f, 1.81156676e-02f, -3.29327099e-02f, -4.36861068e-02f, 4.68029119e-02f, 9.55977216e-02f, 2.23585702e-02f,
  -8.50925371e-02f, 4.35688235e-02f, 4.05242480e-02f, -2.91207265e-02f, -1.40931401e-02f, -2.71556024e-02f, -3.92172635e-02f, 2.00852174e-02f, -5.14956787e-02f, -4.92656566e-02f,
  1.25699118e-01f, -4.70454358e-02f, -2.95090824e-02f, 3.61471027e-02f, -5.66594042e-02f, 1.55305922e-01f, -5.53528741e-02f, -4.02272306e-02f, -7.45845065e-02f, 9.66700912e-03f,
  6.98273182e-02f, -2.15353668e-02f, 4.76712584e-02f, 3.64317596e-02f, -8.46219808e-02f, 5.82575835e-02f, 7.30807632e-02f, 6.47454560e-02f, 5.41673861e-02f, -1.02964079e-03f,
  2.60766670e-02f, 2.80867741e-02f, -3.44812199e-02f, -7.00694323e-02f, 5.40572926e-02f, -9.83073469e-03f, -7.99512938e-02f, -5.82263470e-02f, 5.25265895e-02f, -4.88614216e-02f,
  -3.32006425e-01f, 1.41992241e-01f, 6.15936294e-02f, -1.67861760e-01f, 6.27176613e-02f, 1.90365136e-01f, 9.24574956e-02f, 1.11703478e-01f, -1.44843176e-01f, 1.80473784e-03f,
  -8.22786987e-03f, -1.47796586e-01f, 2.47237738e-02f, 1.93586498e-02f, 4.82699927e-03f, 1.42007649e-01f, 1.02393962e-01f, -9.89328250e-02f, 5.45081645e-02f, -1.37800053e-01f,
  1.01607163e-02f, 3.32349874e-02f, 2.01237332e-02f, 1.51548773e-01f, -4.47112098e-02f, -1.81439683e-01f, -6.70271218e-02f, 1.21182099e-01f, -2.35546306e-02f, 1.67225644e-01f,
  -9.76720601e-02f, -1.05723113e-01f, -6.81882650e-02f, -1.15707733e-01f, -4.58407961e-02f, -1.17904328e-01f, -1.23007104e-01f, -6.99865967e-02f, 9.19765607e-03f, 3.48502435e-02f,
  -1.41865253e-01f, 1.09466001e-01f, -8.07502773e-03f, 7.97553435e-02f, 1.56323705e-02f, 1.26842884e-02f, -2.85775568e-02f, 2.29422367e-04f, 6.12560101e-02f, 2.19739079e-02f,
  8.92633572e-02f, -2.01623961e-02f, -7.08437860e-02f, 2.32293420e-02f, 1.09152040e-02f, 5.58539480e-02f, 3.50055227e-04f, 6.55574277e-02f, 3.83118987e-02f, 2.96457987e-02f,
  2.98654418e-02f, -1.36229992e-01f, 1.50340656e-02f, -8.07112381e-02f, 4.60838340e-02f, -4.00168374e-02f, -5.74473199e-03f, 2.38400325e-02f, 1.19265374e-02f, -6.03424907e-02f,
  5.01663052e-02f, 2.94937752e-02f, 5.50649017e-02f, 3.57405059e-02f, -3.00969575e-02f, 7.23955408e-02f, -4.83964384e-02f, -5.35497777e-02f, -5.01769073e-02f, -8.32606032e-02f,
  1.83807744e-04f, 1.02206193e-01f, -4.34448831e-02f, -7.42770955e-02f, -5.36556169e-02f, -2.28808466e-02f, -8.42252970e-02f, 1.08404055e-01f, 2.34323051e-02f, 5.57300895e-02f,
  -1.96591631e-01f, -2.39490777e-01f, -1.97309479e-02f, 2.40219701e-02f, 3.08713745e-02f, 3.69683243e-02f, -4.93653007e-02f, 6.28732219e-02f, -4.59079631e-02f, -3.53124477e-02f,
  5.43816853e-03f, 2.80853119e-02f, 3.31682004e-02f, -1.99455256e-03f, -5.64128309e-02f, 4.70219217e-02f, -1.37063330e-02f, -5.10008782e-02f, -9.58814695e-02f, -4.66724895e-02f,
  5.03574312e-02f, 6.56906366e-02f, -1.00074276e-01f, -8.31764266e-02f, 4.45054062e-02f, 1.50347333e-02f, -6.06726818e-02f, 3.23880762e-02f, 4.61673317e-03f, 4.87893969e-02f,
  -2.63992041e-01f, 3.23920488e-01f, -9.02821273e-02f, 1.40743345e-01f, -2.47718990e-01f, -1.18872382e-01f, 9.39171612e-02f, -7.60769695e-02f, 1.56884566e-01f, 2.83378780e-01f,
  4.59353626e-02f, 1.62283167e-01f, 2.88506467e-02f, 3.48918855e-01f, -1.05765155e-02f, 2.28234634e-01f, 2.63900399e-01f, 1.70995310e-01f, -3.72210518e-02f, 1.65837735e-01f,
  -2.91272812e-02f, 2.45682776e-01f, 3.53037263e-03f, 4.20152508e-02f, -9.24855247e-02f, 1.04735047e-03f, 3.68755050e-02f, -7.23048449e-02f, 8.81068036e-02f, 6.28351420e-02f,
  3.03245969e-02f, 1.21029271e-02f, -7.50168636e-02f, -2.25541405e-02f, -3.27426754e-02f, -1.51305020e-01f, -8.35841596e-02f, -1.02522723e-01f, -8.79883021e-02f, 2.97918562e-02f,
  -4.05137092e-02f, -4.64792810e-02f, 7.22657815e-02f, 3.03605311e-02f, 1.55436769e-02f, 8.59228056e-03f, 1.89989433e-02f, 3.32346410e-02f, 1.85671374e-02f, -9.83665735e-02f,
  -3.51544321e-02f, 1.34973815e-02f, -5.46254180e-02f, 8.38398859e-02f, -7.55805448e-02f, 5.44350930e-02f, 9.00731534e-02f, -3.15456353e-02f, 4.18877564e-02f, -3.92554095e-03f,
  -1.52137019e-02f, 9.58994105e-02f, 5.11853322e-02f, -7.99148232e-02f, 1.41258473e-02f, 1.11742958e-03f, 8.13837126e-02f, -1.75293684e-02f, 1.28121944e-02f, -2.65694838e-02f,
  -6.57856911e-02f, -7.08589703e-02f, -7.75331929e-02f, 4.68772203e-02f, -3.46035995e-02f, -5.56777529e-02f, -3.79051082e-02f, 3.80468071e-02f, 2.27854885e-02f, 5.27547225e-02f,
  3.09264027e-02f, 4.05569263e-02f, 7.13931248e-02f, -2.44221147e-02f, 8.13336577e-03f, -2.83677541e-02f, -7.14046462e-03f, 3.60519662e-02f, 8.74383077e-02f, -9.77254435e-02f,
  1.35521010e-01f, 2.79304206e-01f, 1.07144885e-01f, -1.34273833e-02f, -2.49833092e-02f, -2.84113698e-02f, 7.86566734e-02f, 1.33458683e-02f, 8.86318833e-02f, -6.41881451e-02f,
  4.76026256e-03f, 4.89446521e-02f, -7.62491748e-02f, -1.34953263e-03f, 4.79864627e-02f, 1.27368510e-01f, 1.41823336e-01f, -5.08610420e-02f, 3.87486331e-02f, -1.21928519e-02f,
  1.71248186e-02f, 3.76363359e-02f, -3.85357551e-02f, -1.35941124e-02f, 8.30833167e-02f, 1.26694283e-02f, -2.08941288e-02f, -5.67007065e-02f, 2.86594070e-02f, 1.13397181e-01f,
  1.52319476e-01f, 1.15780041e-01f, 3.86724696e-02f, -8.73625055e-02f, -8.80937353e-02f, -9.45915505e-02f, -5.12294620e-02f, -3.64066027e-02f, -1.68979436e-01f, -5.51367737e-02f,
  -7.89468214e-02f, 1.88855097e-01f, -9.48750526e-02f, -2.05064490e-02f, -1.64666772e-02f, 4.53489693e-03f, -1.46236047e-01f, 6.77782893e-02f, -8.59315395e-02f, -5.65978289e-02f,
  -2.17547864e-02f, -1.13643177e-01f, 1.16044253e-01f, -1.05036356e-01f, 1.29336819e-01f, 1.08136490e-01f, -1.23070270e-01f, 6.41689226e-02f, -4.23369408e-02f, -5.42683108e-03f,
  9.77665707e-02f, 7.39030018e-02f, 5.13533801e-02f, -1.48176989e-02f, 3.14443186e-02f, 1.37906849e-01f, 8.75688568e-02f, 4.67009768e-02f, 6.68300763e-02f, -7.96378497e-03f,
  6.68974072e-02f, 7.57747889e-02f, -3.89756486e-02f, -7.27480277e-02f, -5.74679896e-02f, 2.41992753e-02f, 2.65476499e-02f, 8.86103660e-02f, 6.57331347e-02f, 2.47068740e-02f,
  9.38064307e-02f, 6.40496463e-02f, -1.38691524e-02f, -4.97845374e-02f, 2.12528668e-02f, 3.09032612e-02f, 7.43822008e-02f, 1.40425870e-02f, -2.62481049e-02f, -1.48354610e-02f,
  2.19188035e-02f, -9.34567899e-02f, -7.30024576e-02f, 3.39236110e-02f, 2.20456216e-02f, -1.58419199e-02f, 5.02206199e-02f, -3.34287807e-02f, -2.15815883e-02f, -1.42268883e-02f,
  1.56133315e-02f, -2.99288891e-02f, -1.89547781e-02f, 2.95763351e-02f, -1.54099828e-02f, -5.15896343e-02f, 8.79562646e-02f, 4.47560064e-02f, 3.24096568e-02f, -6.66693822e-02f,
  -5.75256422e-02f, 2.27933750e-03f, -2.07292661e-02f, 5.04266061e-02f, -6.77103701e-04f, 7.68755972e-02f, -4.86758016e-02f, -2.22371276e-02f, 7.18893334e-02f, 2.90832929e-02f,
  -1.06549978e-01f, -1.25700474e-01f, -2.72674952e-02f, 5.91261536e-02f, 6.41627759e-02f, 5.84087186e-02f, -4.78070863e-02f, -1.56654380e-02f, 2.98782308e-02f, 6.52467981e-02f,
  -1.64669231e-02f, -1.22273825e-02f, -3.58318985e-02f, -1.66943148e-02f, -2.49457043e-02f, -2.83747017e-02f, -8.94079134e-02f, -2.37096893e-03f, 6.75034225e-02f, 7.96980336e-02f,
  3.01477239e-02f, 3.74259092e-02f, -1.28490431e-02f, 2.16748361e-02f, -4.04495448e-02f, -3.06150615e-02f, -7.28941709e-02f, -1.23194531e-02f, 2.19643069e-03f, -3.31064612e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.55718642e-01f, 1.61833927e-01f, 2.14991167e-01f, 2.69730985e-01f, 4.31602523e-02f, 1.92975290e-02f, 7.52098560e-02f, 3.14232588e-01f, -2.56056469e-02f, 1.32774591e-01f,
  1.58317134e-01f, 1.63878754e-01f, 2.33042091e-01f, 6.74561039e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  8.01258907e-02f, -2.96657026e-01f, 4.13423181e-02f, -1.19554847e-02f, -1.15814283e-01f, 8.44493136e-02f, -2.14086592e-01f, -1.56661756e-02f, 9.64268073e-02f, -2.72259533e-01f,
  2.09476780e-02f, 2.90911458e-02f, -2.40509957e-01f, 2.08107561e-01f, -4.27855775e-02f, -1.82158843e-01f, 4.26910780e-02f, -4.29971069e-01f, -1.64026301e-02f, -1.83161665e-02f,
  -8.81134421e-02f, 2.12171048e-01f, -9.90510955e-02f, 1.06246129e-01f, -1.47943020e-01f, 4.34527487e-01f, 2.73098975e-01f, -3.11015993e-01f, -2.18935281e-01f, -3.28607559e-01f,
  1.39270416e-02f, 3.30702662e-01f, -3.42262626e-01f, 1.05561214e-02f, 3.91963989e-01f, -2.10095495e-02f, -9.10057127e-02f, -4.87668574e-01f, 2.01971680e-01f, -2.64804866e-02f,
  -3.37154776e-01f, -2.90264368e-01f, -4.86584634e-01f, 3.59344602e-01f, 5.82500279e-01f, -2.55639315e-01f, 7.94631541e-02f, 3.04259330e-01f, -1.02290183e-01f, -3.40565681e-01f,
  -3.71159434e-01f, -2.69222498e-01f, 2.20588550e-01f, -2.31684268e-01f, -1.15966991e-01f, 3.34514320e-01f, -2.17692956e-01f, 5.25966823e-01f, 8.42154399e-02f, 3.89228053e-02f,
  2.48506904e-01f, 1.15483634e-01f, 4.82823431e-01f, -5.25374077e-02f, -2.53737777e-01f, -6.57696724e-02f, -3.51472229e-01f, 6.44110516e-02f, 9.02645960e-02f, 3.35949898e-01f,
  3.96612257e-01f, 1.94381028e-01f, -2.05338523e-01f, 3.19715925e-02f, 7.01772720e-02f, 7.50452057e-02f, 3.56435333e-03f, -1.07067741e-01f, -1.90419182e-01f, 3.81114781e-02f,
  -3.76467407e-02f, 2.97894269e-01f, -1.73140895e-02f, -2.51895010e-01f, -4.11245823e-01f, 2.62743622e-01f, -1.14823312e-01f, -2.47049302e-01f, -2.54548818e-01f, -5.54283559e-01f,
  5.61733365e-01f, -4.52701181e-01f, 2.66933054e-01f, -1.98813289e-01f, 1.29508674e-01f, -2.98319042e-01f, -9.03739780e-02f, -1.80889815e-02f, -2.92114839e-02f, 3.54030356e-02f,
  -3.84308308e-01f, 3.17825854e-01f, -2.23265082e-01f, -1.57189146e-02f, 2.46457532e-02f, 3.92827362e-01f, -1.75578017e-02f, -7.00789750e-01f, 4.56581295e-01f, 3.18463077e-03f,
  5.86813502e-02f, -2.47547373e-01f, 4.05934423e-01f, -5.57982147e-01f, -1.71647578e-01f, -2.25173667e-01f, 6.74611866e-01f, -2.14727610e-01f, 8.71346965e-02f, 3.30154330e-01f,
  -3.65797244e-02f, 3.63204807e-01f, -1.11515053e-01f, 3.16925384e-02f, 3.68770003e-01f, -2.04514991e-03f, 1.71761736e-01f, 1.41561911e-01f, -2.65316695e-01f, 1.90969095e-01f,
  -2.81799614e-01f, -6.60426617e-02f, 1.35863140e-01f, -4.32872921e-01f, -5.39745688e-01f, 6.57712743e-02f, 1.08257309e-01f, -3.02709686e-03f, -3.96529958e-02f, -9.57043916e-02f,
  -3.03063095e-01f, 5.23315817e-02f, -7.89623559e-02f, 3.27659659e-02f, 1.91303432e-01f, -1.08980909e-01f, 2.15742132e-03f, 2.20282236e-03f, -5.36369622e-01f, 2.02186674e-01f,
  -6.47650138e-02f, -7.66335502e-02f, -2.23139718e-01f, -3.48558962e-01f, -2.25567929e-02f, -4.03275490e-01f, 3.72563660e-01f, 4.72511724e-02f, -5.60748577e-01f, -3.61151040e-01f,
  -6.04605488e-02f, 3.15049514e-02f, -1.34145208e-02f, 3.77874821e-01f, 5.40110767e-02f, 3.44747126e-01f, 4.72211778e-01f, -1.93773791e-01f, -2.43216991e-01f, -1.87478781e-01f,
  4.87505585e-01f, -1.39954224e-01f, 3.87428313e-01f, -5.34445524e-01f, -8.89575407e-02f, 8.20620358e-02f, -2.44983509e-01f, -4.10517424e-01f, 5.77053308e-01f, -8.95486102e-02f,
  -1.07456155e-01f, 1.08035058e-01f, 4.30214256e-01f, 1.87016904e-01f, 2.38537285e-02f, -1.49594778e-02f, 2.52178818e-01f, 4.55572568e-02f, 3.43893305e-03f, 3.35953310e-02f,
  -5.67252040e-02f, 1.13351354e-02f, -1.91102102e-01f, -2.21374035e-01f, -3.84462960e-02f, 9.65698361e-02f, 1.31138757e-01f, -2.01998204e-01f, -1.59832165e-01f, -2.04527274e-01f,
  -7.46082589e-02f, 1.85814455e-01f, 2.10320994e-01f, 3.75029892e-02f, -1.83320805e-01f, 1.39469355e-01f, 4.73063923e-02f, -2.89593518e-01f, -1.81031957e-01f, -2.84269542e-01f,
  9.04819667e-02f, 1.11175813e-01f, -3.09959352e-01f, 1.89350501e-01f, -5.52064329e-02f, -2.15109363e-01f, -4.14477021e-01f, 3.48125517e-01f, 5.18077314e-01f, 3.91659439e-02f,
  2.01106131e-01f, 5.15089810e-01f, 2.96597183e-01f, 3.81128997e-01f, 4.09915596e-01f, 4.17213202e-01f, -1.61309749e-01f, 1.33880675e-01f, 5.04758179e-01f, -4.72440720e-01f,
  -9.85434055e-02f, 3.56980413e-01f, -4.23737764e-01f, -4.77300316e-01f, -3.83429468e-01f, -5.74488878e-01f, -4.74176288e-01f, 5.54848373e-01f, 4.51688081e-01f, -6.85597509e-02f,
  -3.45942140e-01f, 5.09762526e-01f, -2.01833472e-02f, 5.92041314e-02f, -1.32108614e-01f, -2.22008198e-01f, -1.20684646e-01f, 1.34424090e-01f, -6.50786385e-02f, 1.61704998e-02f,
  -1.17698750e-02f, -2.04639077e-01f, -2.78983474e-01f, 1.40692428e-01f, 6.44681677e-02f, 1.24419043e-02f, 4.28618155e-02f, 3.51570785e-01f, 7.34555051e-02f, 3.85783017e-01f,
  2.66571224e-01f, 3.73448372e-01f, -4.20928039e-02f, -1.47255316e-01f, 4.60217595e-02f, 6.62827864e-02f, 2.86332089e-02f, 3.69601876e-01f, -9.35264677e-03f, -1.98356077e-01f,
  -1.75564364e-02f, -2.64012754e-01f, 2.24832520e-01f, -6.63512200e-03f, 3.32200736e-01f, -1.13526441e-01f, 4.23090637e-01f, 9.20815617e-02f, 8.57701004e-02f, -1.93232402e-01f,
  1.17474213e-01f, 5.89076318e-02f, 2.32122820e-02f, 6.80058599e-01f, 2.08760783e-01f, -3.15182537e-01f, 2.37337165e-02f, 3.90810817e-01f, -3.38306814e-01f, -2.90451258e-01f,
  4.50908780e-01f, 7.38531128e-02f, -2.98022598e-01f, -3.86073470e-01f, 1.74054682e-01f, -2.19948277e-01f, -6.41217411e-01f, -1.72491089e-01f, -4.91506338e-01f, 1.46497011e-01f,
  -5.53421259e-01f, 4.66175340e-02f, -6.04432940e-01f, -6.01352043e-02f, -5.26363432e-01f, 2.75749177e-01f, 5.97197711e-02f, 2.42742345e-01f, -2.96419293e-01f, 4.63500917e-02f,
  1.15750609e-02f, -2.30073985e-02f, -2.09449619e-01f, -4.26289290e-01f, -7.92102292e-02f, 1.33509040e-01f, 1.43762201e-01f, 4.69043911e-01f, -2.44844511e-01f, 9.04045328e-02f,
  3.77681345e-01f, 5.35633326e-01f, 3.57579201e-01f, 1.82214379e-01f, -2.10579410e-01f, 2.01032087e-01f, 7.79753327e-02f, 1.75528109e-01f, -1.75944403e-01f, 1.83083773e-01f,
  -2.64981449e-01f, -7.61886984e-02f, 1.88635454e-01f, -1.11449823e-01f, 8.77875090e-02f, 1.01444684e-01f, -5.08774556e-02f, 1.66813985e-01f, 7.25547820e-02f, 3.01365554e-01f,
  1.87624082e-01f, -4.99972329e-02f, -2.40867082e-02f, -6.01699166e-02f, 1.89886704e-01f, -1.50204256e-01f, -2.50153333e-01f, 1.73710763e-01f, -2.16087788e-01f, -4.18690026e-01f,
  2.90250719e-01f, 4.01065350e-01f, 9.86609608e-02f, 2.55988896e-01f, -4.10982333e-02f, -5.51891685e-01f, -2.84143746e-01f, -2.06877515e-01f, -4.66040701e-01f, -2.25363195e-01f,
  5.78128397e-01f, 3.99194956e-01f, -1.66800633e-01f, 3.95792127e-01f, 2.67001502e-02f, -3.86394858e-01f, -3.50583047e-01f, -8.11105594e-02f, 5.10603130e-01f, -7.47900233e-02f,
  -2.34580010e-01f, -3.07683088e-03f, 3.83618802e-01f, 3.87736171e-01f, -1.97314560e-01f, 1.18105628e-01f, -2.71360278e-01f, -1.02432944e-01f, -1.54012412e-01f, 1.85019642e-01f,
  -1.36969373e-01f, -1.58000752e-01f, 3.19214553e-01f, -1.98256642e-01f, -6.63840771e-03f, 6.82859942e-02f, -2.63053417e-01f, -1.55132174e-01f, -6.75337687e-02f, -1.99727684e-01f,
  1.66435868e-01f, 2.64231294e-01f, 1.17323119e-02f, -5.37685454e-02f, 1.00469619e-01f, 2.05253169e-01f, -2.23472983e-01f, 3.06241084e-02f, 3.18110995e-02f, 9.50448439e-02f,
  2.09642425e-01f, -3.25886428e-01f, -1.70836017e-01f, 3.11160870e-02f, 2.95522779e-01f, -3.68290730e-02f, 1.09493710e-01f, 1.34349748e-01f, 7.30808079e-02f, -4.97502029e-01f,
  -4.44418103e-01f, -5.59375942e-01f, -5.52056551e-01f, 3.14902365e-01f, -5.93351245e-01f, -3.81453127e-01f, -2.96405971e-01f, 4.37644392e-01f, -2.03384668e-01f, -3.27946186e-01f,
  2.27524772e-01f, 6.10680997e-01f, -3.75808299e-01f, -3.02644093e-02f, 3.19272280e-01f, 1.57592028e-01f, 5.96683025e-01f, 7.57013336e-02f, -5.73380530e-01f, 4.82872725e-02f,
  -3.65466684e-01f, -1.60076842e-01f, -1.68954596e-01f, 3.49217206e-01f, 1.27869716e-03f, 2.79429555e-01f, 2.13641524e-01f, 4.71514344e-01f, -7.79168010e-02f, 1.52084395e-01f,
  -8.87484774e-02f, -3.50328892e-01f, -1.17038265e-01f, 5.31772673e-02f, 2.11299941e-01f, -1.03105992e-01f, -4.12302405e-01f, -1.81996047e-01f, -3.20802808e-01f, -1.33896247e-01f,
  -1.33650556e-01f, -1.98939234e-01f, 1.94694903e-02f, -1.36321574e-01f, -1.52094901e-01f, -8.68843645e-02f, -5.51800895e-03f, -6.36509247e-03f, -3.78952688e-03f, -9.31507051e-02f,
  -8.77351239e-02f, -7.35870004e-02f, -1.55428005e-02f, 8.57406482e-02f, -3.13642293e-01f, -5.19324988e-02f, -9.33498219e-02f, -8.48416686e-02f, -5.03924787e-01f, 9.66811478e-02f,
  -1.14378892e-02f, 5.49382418e-02f, 1.00794688e-01f, 3.01064968e-01f, -5.55571914e-01f, 1.51637927e-01f, -4.68003303e-01f, 3.02274078e-01f, 4.50099796e-01f, -2.98533961e-03f,
  3.42174768e-01f, -1.33458823e-01f, 4.31909747e-02f, 3.37973148e-01f, -1.99577928e-01f, -3.17347258e-01f, -2.36824900e-02f, 3.34655583e-01f, 2.69038051e-01f, -3.34943742e-01f,
  9.77652967e-02f, 3.47865969e-01f, -7.45219290e-02f, 3.58525008e-01f, -5.27003855e-02f, 2.03983948e-01f, 2.36397415e-01f, 2.84466386e-01f, 5.71759082e-02f, 1.13939315e-01f,
  4.66671214e-03f, 9.40667912e-02f, 6.42134398e-02f, -1.21479101e-01f, 5.32862902e-01f, 5.05553961e-01f, -1.39987156e-01f, 2.98983127e-01f, -2.15792373e-01f, -1.67511642e-01f,
  -3.49611044e-02f, 1.06684275e-01f, 1.44652367e-01f, 5.01457229e-03f, 1.86807513e-01f, 8.68917033e-02f, 2.36799307e-02f, 2.48326242e-01f, -7.25707114e-02f, -1.19086176e-01f,
  5.06670661e-02f, 4.40381393e-02f, 2.46115793e-02f, -2.22857781e-02f, 7.25513995e-02f, -4.72622991e-01f, 8.28111246e-02f, -1.31723791e-01f, -2.82148242e-01f, -4.72403109e-01f,
  -1.64558575e-01f, -4.25500035e-01f, 1.02563642e-01f, -2.86385626e-01f, -1.37732387e-01f, 6.11679144e-02f, 1.99297890e-01f, -6.62793145e-02f, 7.36293271e-02f, 5.71182035e-02f,
  2.74291411e-02f, -3.50273341e-01f, 6.26505539e-02f, -2.97076195e-01f, -2.51656502e-01f, -4.12439145e-02f, 1.35071337e-01f, -3.29319000e-01f, 1.84603930e-01f, 1.23695686e-01f,
  4.94455725e-01f, 2.51982123e-01f, 3.92422765e-01f, 3.76144379e-01f, 4.32521999e-01f, -2.59561509e-01f, 4.73977536e-01f, 1.93565086e-01f, 3.70951295e-01f, -4.52816695e-01f,
  -3.60474326e-02f, 5.77917770e-02f, 7.11201131e-01f, 4.45649326e-02f, -7.47695565e-02f, -2.32178956e-01f, -8.94388109e-02f, -2.26103608e-02f, 7.58201927e-02f, -2.05506951e-01f,
  5.58445081e-02f, 5.68547919e-02f, -1.92013144e-01f, -2.35694081e-01f, 3.52817684e-01f, -2.92698550e-03f, 2.81935841e-01f, -4.36639577e-01f, 2.53479898e-01f, -7.84985647e-02f,
  2.44692579e-01f, -2.75566131e-01f, -3.48283611e-02f, -1.49621302e-02f, -1.63650408e-01f, -2.08797529e-02f, -6.75032660e-02f, -2.38039687e-01f, 3.48132521e-01f, 2.75965035e-01f,
  4.52834405e-02f, 1.69938132e-01f, 3.60381752e-02f, 3.76634777e-01f, -1.68800890e-01f, 2.77666509e-01f, 3.09156448e-01f, -2.63385892e-01f, 1.25818670e-01f, 2.57096440e-01f,
  -4.67790887e-02f, 1.08147547e-01f, -5.65815687e-01f, -8.51032138e-02f, -2.39533275e-01f, 3.20676893e-01f, -4.27728444e-01f, -4.53275323e-01f, -4.52305704e-01f, -5.35514712e-01f,
  -6.29677102e-02f, 3.17699403e-01f, -4.51676905e-01f, 1.21758528e-01f, -3.24562639e-01f, 2.28312865e-01f, -2.74936110e-01f, 1.53170943e-01f, -1.42534792e-01f, 5.12806356e-01f,
  -2.00089753e-01f, -9.63278562e-02f, -4.22458470e-01f, 2.31882676e-01f, 3.01960319e-01f, -3.81943882e-01f, -3.73758852e-01f, -1.15272492e-01f, -3.40930790e-01f, -1.11846231e-01f,
  4.20307487e-01f, -2.69237876e-01f, -6.58669844e-02f, -2.49253109e-01f, 3.28753926e-02f, 1.45362109e-01f, 2.15213165e-01f, 2.05672043e-03f, -3.48540485e-01f, 1.54796958e-01f,
  3.94828677e-01f, 1.95383653e-01f, 1.20790102e-01f, -6.98337331e-02f, -4.46454197e-01f, -8.06031749e-02f, 1.09984979e-01f, 1.25378147e-01f, -2.85065491e-02f, -1.92188010e-01f,
  1.11265115e-01f, 3.61992121e-02f, 1.26097187e-01f, 2.13736176e-01f, 8.25640000e-03f, 2.97159493e-01f, 2.26543829e-01f, 1.76689237e-01f, -3.11956286e-01f, 2.46985257e-01f,
  4.00625587e-01f, -2.97460705e-01f, -9.95683596e-02f, 2.45689139e-01f, 1.54348373e-01f, -2.24235669e-01f, 2.46290751e-02f, 2.05964267e-01f, 4.51496005e-01f, 5.94142079e-01f,
  5.54939866e-01f, 1.62731901e-01f, 3.91819060e-01f, -3.13668549e-01f, -3.99558157e-01f, 2.74054389e-02f, 2.08185956e-01f, 3.24630857e-01f, 9.37643871e-02f, -2.33341046e-02f,
  -2.38151997e-02f, -3.02621394e-01f, -4.17187780e-01f, -4.81133640e-01f, -2.03163866e-02f, 3.44997682e-02f, 5.21585763e-01f, 3.18810761e-01f, 2.07884327e-01f, 1.92945935e-02f,
  4.08100307e-01f, -2.29605719e-01f, -2.31621861e-01f, -2.64264941e-01f, -1.62458271e-01f, -6.26044720e-02f, -5.50582856e-02f, 1.22305691e-01f, -4.97603826e-02f, -1.40705839e-01f,
  2.57891506e-01f, -2.35285670e-01f, -2.03714117e-01f, -6.25600740e-02f, 8.45237672e-02f, 2.52680242e-01f, -2.01688528e-01f, -2.04118431e-01f, 1.64879754e-01f, 1.63428858e-01f,
  1.94483891e-01f, -6.50035916e-03f, 1.03418902e-01f, -1.36379704e-01f, -6.20519370e-02f, -1.93521798e-01f, 1.89791471e-01f, 2.32613325e-01f, -2.86203474e-01f, 8.42992403e-03f,
  -5.63163646e-02f, 1.19408108e-01f, 1.70206115e-01f, 2.20222354e-01f, 5.02986871e-02f, 7.62699246e-02f, 9.42908879e-03f, 1.27239421e-01f, -2.34923124e-01f, 5.08117735e-01f,
  9.14746895e-02f, 3.81394893e-01f, 4.77489620e-01f, -3.97646219e-01f, -1.37965634e-01f, -1.64971501e-01f, 3.78556252e-01f, -1.18724965e-01f, -3.35132033e-01f, -4.32505161e-01f,
  4.90802795e-01f, 2.51818508e-01f, 5.47581315e-02f, -5.22923172e-01f, 1.48647681e-01f, 4.48311985e-01f, 3.40126723e-01f, 2.60660321e-01f, -2.08952785e-01f, 4.58969176e-01f,
  4.45632309e-01f, 1.34805873e-01f, 8.08836669e-02f, 4.58092093e-01f, -4.40395594e-01f, 4.59242553e-01f, -1.04985334e-01f, 3.51866752e-01f, -1.35822803e-01f, -1.04438767e-01f,
  -1.75501347e-01f, -5.76475523e-02f, 2.21495181e-01f, -1.85546517e-01f, -2.61885434e-01f, -2.76346982e-01f, -4.69461717e-02f, 3.62533212e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.78425825e-02f, 6.00182973e-02f, 7.41715804e-02f, 1.81483030e-01f, 1.71587437e-01f, -7.86570609e-02f, -6.20005988e-02f, -5.26347607e-02f, -9.48971584e-02f, 8.35141167e-02f,
  -3.85463499e-02f, 1.82505459e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    