/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.60001501e-01f, -5.96161373e-02f, -3.64184193e-02f, -3.74847233e-01f, -9.78985280e-02f, -3.51598293e-01f, -5.12324758e-02f, -2.93722749e-01f, -3.20858181e-01f, -6.82556182e-02f,
  -1.05821766e-01f, -2.21449230e-02f, 1.09613672e-01f, -3.90455872e-01f, -1.39970064e-01f, -2.38430500e-02f, -3.14313740e-01f, -5.85289672e-02f, -4.00057919e-02f, -6.30121827e-02f,
  -4.40897606e-02f, -3.20538819e-01f, -6.86237291e-02f, -1.32086188e-01f, -2.76481472e-02f, -2.09078919e-02f, 1.37640208e-01f, 1.15609065e-01f, -5.06305769e-02f, 5.05556762e-02f,
  -5.87309077e-02f, -6.61124960e-02f, -8.50765314e-03f, -7.20103756e-02f, -2.03556269e-02f, 9.30991843e-02f, 6.63216189e-02f, 5.31646051e-02f, -1.28268143e-02f, -2.39550397e-02f,
  7.48611316e-02f, -1.06101278e-02f, -8.72449726e-02f, -2.43149549e-02f, -1.31740775e-02f, -1.82415592e-03f, -2.16743238e-02f, -8.52518249e-03f, 1.69978105e-02f, 1.93885155e-02f,
  -2.74093300e-02f, 2.54384149e-02f, 3.13686999e-03f, 4.50770445e-02f, 5.96081652e-03f, 5.27422829e-03f, 2.39202306e-02f, 1.25671625e-01f, -2.92861890e-02f, -6.64828271e-02f,
  2.83176862e-02f, 3.84045169e-02f, 3.65548916e-02f, 2.54851743e-03f, 2.25483876e-04f, 5.66878282e-02f, -5.05276881e-02f, 3.71523574e-02f, 3.83099392e-02f, 1.74863301e-02f,
  -6.67742416e-02f, -3.57854292e-02f, -3.84463817e-02f, 6.17136899e-03f, -3.73824574e-02f, -2.58044079e-02f, 1.99966077e-02f, 3.26698236e-02f, -3.50625105e-02f, -7.46298954e-02f,
  4.50862199e-03f, 7.93709233e-03f, 1.20291077e-02f, 1.27468202e-02f, 6.58139994e-04f, -2.62203775e-02f, 2.29516253e-02f, 1.98971760e-02f, 2.70742867e-02f, 2.54962351e-02f,
  -5.35148568e-02f, -6.81291595e-02f, -6.66474104e-02f, 3.94039927e-03f, 4.29876596e-02f, -2.22343765e-02f, -3.07165626e-02f, -1.78582892e-02f, -2.76114568e-02f, -2.79987492e-02f,
  2.59688422e-02f, -1.26816323e-02f, 4.83068042e-02f, 1.72917601e-02f, 3.99743393e-03f, -2.31217630e-02f, 8.43306556e-02f, -3.87118105e-03f, -4.12387401e-02f, 8.08809977e-03f,
  2.82348506e-02f, 2.17299834e-02f, 4.66547497e-02f, -6.32055923e-02f, -1.09390384e-02f, -4.37804684e-03f, -1.03230661e-04f, -2.54160427e-02f, 7.19777867e-02f, -3.72125022e-02f,
  7.68826663e-01f, 1.10875912e-01f, 1.23715632e-01f, 1.33790091e-01f, 1.73616916e-01f, 2.27975443e-01f, 5.33132792e-01f, -5.41410670e-02f, 2.86139190e-01f, 1.20654711e-02f,
  1.47127375e-01f, 6.98364004e-02f, 2.17185304e-01f, -8.43202248e-02f, 1.41821831e-01f, -1.65024307e-02f, 6.90439641e-02f, -5.29843522e-03f, 7.59771792e-04f, 9.14328322e-02f,
  1.99614540e-02f, -5.17555736e-02f, -1.38358548e-01f, -7.58151561e-02f, 1.28549218e-01f, -8.85392874e-02f, -2.20468879e-01f, -2.58032493e-02f, -1.12521134e-01f, -6.89736232e-02f,
  -5.72443381e-02f, 1.28056258e-01f, 6.85392618e-02f, -4.79212925e-02f, 7.22386241e-02f, 3.78442332e-02f, -2.88202222e-02f, 1.66062973e-02f, 3.70207039e-04f, -1.31222093e-03f,
  3.67241539e-02f, -9.70015302e-03f, -5.62792122e-02f, 1.28424130e-02f, 8.33583027e-02f, -1.57793313e-02f, 2.23682774e-03f, -5.64106449e-04f, -1.55870216e-02f, 4.17740010e-02f,
  6.07592352e-02f, -5.52880988e-02f, 3.43940407e-02f, -2.53281984e-02f, 1.54856127e-02f, 5.17011806e-02f, -1.27267340e-04f, 4.31704111e-02f, 1.52673237e-02f, 2.46877335e-02f,
  6.54201731e-02f, -1.89103466e-02f, 1.70475859e-02f, -3.13471332e-02f, 5.30978329e-02f, -4.51162532e-02f, 4.92456602e-03f, -3.70620340e-02f, 5.34388423e-03f, 6.21737689e-02f,
  -3.42258736e-02f, 5.76840434e-03f, -3.78849264e-03f, 3.38422284e-02f, -2.57426761e-02f, -1.14077644e-03f, -1.65544953e-02f, -1.78018007e-02f, 3.19858547e-03f, -4.42110971e-02f,
  -9.71541461e-03f, -1.19701149e-02f, -1.60678793e-02f, -2.75023095e-03f, -2.23056506e-02f, -1.30300072e-03f, -3.78528573e-02f, 5.21551957e-03f, -4.16094698e-02f, 1.47525817e-02f,
  6.39035925e-02f, -1.75927095e-02f, -2.48745419e-02f, -5.89285642e-02f, -8.26425925e-02f, -4.74291705e-02f, -2.51722969e-02f, -3.13119479e-02f, -2.19199378e-02f, 3.99311036e-02f,
  -4.07490246e-02f, -1.63392792e-03f, -7.15573668e-04f, -3.72070819e-03f, -6.90365583e-02f, 2.48086657e-02f, -2.46670824e-02f, -7.21783936e-02f, -8.13672505e-03f, -6.94172084e-02f,
  -2.66729668e-02f, 4.14702445e-02f, -1.70898670e-03f, 4.51760180e-02f, -8.70529748e-03f, 5.85145876e-03f, 5.42713627e-02f, -4.06521857e-02f, -2.29635593e-02f, -1.41385319e-02f,
  2.49780908e-01f, -1.14781491e-01f, 1.66850418e-01f, 2.98820406e-01f, -2.42778882e-01f, -1.63404837e-01f, 2.33549580e-01f, -2.47548580e-01f, -5.97673170e-02f, -1.07221985e-02f,
  -8.53655934e-02f, 2.99565256e-01f, -1.59947239e-02f, 1.10236265e-01f, 3.70171487e-01f, 1.35934129e-01f, 1.96549416e-01f, 1.57637298e-01f, -1.47996172e-01f, 2.55141011e-03f,
  4.68087383e-02f, -3.18505391e-02f, 2.34584540e-01f, -3.29012483e-01f, -1.07957646e-01f, -7.16318041e-02f, 3.36985737e-02f, -1.30594403e-01f, 2.80649625e-02f, 4.50051241e-02f,
  5.66027798e-02f, -1.21336468e-02f, 5.58740459e-02f, -5.68914413e-02f, -4.38216235e-03f, 5.86867519e-02f, 7.07847476e-02f, 4.17024866e-02f, 2.05269959e-02f, -6.49312977e-03f,
  5.00951037e-02f, 5.39816543e-03f, -1.45818982e-02f, -1.17590129e-01f, -2.48176455e-02f, -2.02527530e-02f, -4.45099780e-03f, 5.89094311e-02f, -3.41760442e-02f, 2.33925208e-02f,
  2.62099821e-02f, 7.17125386e-02f, 4.68889624e-02f, 8.30503255e-02f, 5.21298684e-02f, 1.92515068e-02f, 5.62218502e-02f, 3.25063244e-02f, -2.38162605e-03f, -4.35245708e-02f,
  -4.60988050e-03f, -2.38616373e-02f, 2.69071590e-02f, -1.79543756e-02f, 7.18797790e-03f, 1.57952048e-02f, 3.46570089e-02f, -4.00305307e-03f, -9.39069409e-03f, -1.94293866e-03f,
  -7.10070878e-03f, 2.55725849e-02f, 6.15569716e-03f, 2.26076972e-02f, 4.27149087e-02f, -7.53214816e-03f, 4.21771780e-02f, -3.95058803e-02f, 1.63174532e-02f, -7.51134055e-03f,
  -3.26322834e-03f, 2.27673072e-02f, 3.13697159e-02f, -2.58203279e-02f, -1.99810416e-02f, 2.35008905e-04f, -3.98088843e-02f, -3.05523835e-02f, 1.77559033e-02f, 3.93171608e-02f,
  -4.97888029e-02f, -7.14241788e-02f, -5.98845668e-02f, -7.08056754e-03f, 1.63276009e-02f, -4.52523120e-02f, 1.27289044e-02f, 9.66802984e-03f, -1.29877087e-02f, -5.10368459e-02f,
  -2.18655802e-02f, -1.47204902e-02f, -2.45657433e-02f, 4.25904058e-02f, 1.80049594e-02f, -1.10877603e-02f, 8.65544155e-02f, 1.33482823e-02f, 4.97712083e-02f, -2.71147471e-02f,
  2.03478765e-02f, -4.11046408e-02f, 9.64035466e-03f, -1.20372780e-01f, -3.01162689e-03f, 2.88691390e-02f, -2.52551045e-02f, 9.52956732e-03f, 2.16676295e-02f, 3.04142442e-02f,
  -4.11270857e-01f, -3.18629116e-01f, -3.49372417e-01f, 3.53851318e-02f, -6.85982034e-02f, -3.16390842e-01f, -3.90578024e-02f, -6.12854697e-02f, -1.76408321e-01f, 4.54950035e-02f,
  7.05534369e-02f, -8.33144858e-02f, -6.62975833e-02f, -9.50097293e-03f, -5.40304109e-02f, -2.38207951e-01f, -4.30789106e-02f, -3.58655187e-03f, -2.20540047e-01f, 8.54879692e-02f,
  -1.08481750e-01f, 2.14749739e-01f, -2.13971913e-01f, 6.46338239e-02f, -8.23255256e-02f, -2.59932168e-02f, 3.91893834e-01f, -7.65159354e-02f, 1.63655043e-01f, 4.05130610e-02f,
  -1.46257639e-01f, -9.78143588e-02f, -1.04166428e-02f, -1.63255278e-02f, -3.95544060e-03f, 6.73237443e-02f, 7.09035471e-02f, 3.73235159e-02f, -2.24162638e-02f, -9.02040005e-02f,
  5.61310165e-02f, 3.37391943e-02f, 4.02414203e-02f, -2.80778389e-02f, -7.11638248e-04f, -2.70549171e-02f, -5.93226627e-02f, -6.37367219e-02f, -1.05758989e-02f, -1.01366170e-01f,
  -1.43259466e-01f, -2.36627124e-02f, 3.24354880e-02f, 4.85907681e-02f, 3.73756625e-02f, -5.96933663e-02f, -5.75671811e-03f, 3.60319950e-02f, 1.55404275e-02f, -4.13857587e-02f,
  3.00519187e-02f, 2.19202936e-02f, -1.03816902e-02f, -3.85443419e-02f, -9.53343604e-03f, 1.60024641e-03f, 6.25002291e-03f, 3.57021205e-02f, -5.36787398e-02f, 1.39220860e-02f,
  2.52290908e-02f, 2.98028765e-03f, 2.07682401e-02f, 8.06187466e-03f, 4.04737666e-02f, 2.29852125e-02f, 1.16953272e-02f, 8.88165552e-03f, -3.81165966e-02f, -4.90193181e-02f,
  9.17374529e-03f, 6.66207774e-03f, 1.61878169e-02f, 4.63996790e-02f, -1.26158250e-02f, -4.82418714e-03f, 3.68112922e-02f, -6.48240969e-02f, 1.65000744e-02f, 5.17236441e-02f,
  1.01182789e-01f, 3.04950297e-01f, -1.34630641e-02f, 2.62505580e-02f, 8.82235449e-03f, -2.17440538e-02f, -4.94890884e-02f, 6.46688393e-04f, 3.86819616e-02f, 5.55261970e-02f,
  2.64616422e-02f, 4.64014187e-02f, 5.92165813e-02f, 2.22319365e-02f, 2.37993579e-02f, 3.30922529e-02f, 4.99664322e-02f, 1.10169299e-01f, 6.56309500e-02f, 4.77475040e-02f,
  1.10575274e-01f, 4.21145856e-02f, -8.35051667e-03f, -8.32619891e-03f, 3.17018963e-02f, 4.64306287e-02f, 3.46213505e-02f, -6.34865537e-02f, 3.65172587e-02f, 4.66413051e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.80759502e-02f, 7.34549284e-01f, 4.59681094e-01f, 5.27250826e-01f, -1.51566446e-01f, -8.41624618e-01f, -3.41213405e-01f, 3.21667135e-01f, 1.32276297e-01f, 1.37607172e-01f,
  -4.11414541e-04f, 3.37523580e-01f, 6.37169331e-02f, -1.41739827e-02f, -6.12178862e-01f, -4.18085128e-01f, -3.01223010e-01f, -2.42849335e-01f, 2.22965386e-02f, 3.27172518e-01f,
  -6.20227717e-02f, 1.98306777e-02f, 1.81664273e-01f, 1.53399080e-01f, 2.34201118e-01f, 5.15217304e-01f, 1.93409324e-01f, 1.41115621e-01f, 1.64008215e-01f, -1.09246314e-01f,
  -1.11558951e-01f, 2.54408479e-01f, 1.75955638e-01f, 2.67053079e-02f, -7.27321953e-02f, -5.83099797e-02f, -4.95506776e-03f, -9.03586149e-02f, 7.04461113e-02f, -3.95448646e-03f,
  -1.56764053e-02f, 1.53056579e-03f, -9.24502406e-03f, 3.87112983e-03f, -2.12740116e-02f, 1.85378760e-01f, 1.80548057e-02f, 1.94110591e-02f, 9.96487960e-02f, -2.41252743e-02f,
  1.11482970e-01f, 1.40351821e-02f, 8.62376168e-02f, -2.28620861e-02f, 4.76744100e-02f, -5.35144471e-03f, -7.54757226e-02f, 2.89386865e-02f, 2.13733525e-03f, -3.83910127e-02f,
  8.41606408e-02f, -5.89303114e-02f, -5.95971197e-02f, 3.51260528e-02f, -6.17876053e-02f, 1.38934832e-02f, -1.01194624e-02f, -2.46255863e-02f, 1.23893814e-02f, -1.97756123e-02f,
  -2.64423676e-02f, 5.86367659e-02f, -1.21444259e-02f, -8.39753971e-02f, 1.22348573e-02f, 3.73211987e-02f, -5.24564907e-02f, -2.10305490e-03f, -3.57338227e-02f, 2.86891069e-02f,
  3.17893326e-02f, -7.68851638e-02f, 4.15637828e-02f, -5.53071760e-02f, -1.30597455e-02f, -1.94062293e-02f, 7.09840506e-02f, 9.51815862e-03f, -1.12288613e-02f, -3.25298980e-02f,
  9.45427164e-04f, 4.33002591e-01f, 8.48098248e-02f, -3.01198885e-02f, -2.48019006e-02f, -1.47882774e-01f, -7.58506507e-02f, 6.41179979e-02f, 6.41775057e-02f, -2.27070805e-02f,
  -1.72194447e-02f, -3.56206112e-02f, -1.79562513e-02f, -1.86081696e-02f, 5.21948561e-02f, -4.80533130e-02f, 1.21605501e-01f, -9.80454031e-03f, 1.93572231e-02f, 9.93401781e-02f,
  1.19654097e-01f, -7.27137774e-02f, -9.49935466e-02f, -2.03028936e-02f, -9.70959314e-04f, 2.36262716e-02f, 7.29130860e-03f, 2.13967580e-02f, 3.63220125e-02f, 5.71095720e-02f,
  -2.02639818e-01f, 4.84571755e-01f, -3.33186090e-01f, 3.37452650e-01f, -1.80345893e-01f, 3.69899839e-01f, 5.28650403e-01f, 6.58273622e-02f, 3.92428748e-02f, 5.65783203e-01f,
  3.16480458e-01f, 1.23421222e-01f, 2.20054790e-01f, 5.53855062e-01f, 1.75600827e-01f, 3.01550746e-01f, 6.27576232e-01f, 3.00175607e-01f, -1.62608400e-01f, 1.22664258e-01f,
  -2.27895156e-02f, 5.09165347e-01f, -4.22595814e-02f, 1.59125533e-02f, 5.75517155e-02f, -2.08832517e-01f, 2.00338423e-01f, -2.09318429e-01f, 1.62837803e-01f, 1.26246884e-01f,
  4.97424081e-02f, -5.10961264e-02f, -1.23437047e-01f, -3.83092612e-02f, -2.66782250e-02f, -2.81203985e-02f, -6.48689456e-03f, -3.69714238e-02f, -1.66879013e-01f, 2.26527709e-03f,
  2.08919253e-02f, -1.13186717e-01f, 4.32140268e-02f, -2.65843533e-02f, -1.12546012e-01f, -1.43582121e-01f, -1.05805852e-01f, -1.08910084e-01f, -1.34873409e-02f, -8.92868116e-02f,
  -1.73783362e-01f, -5.49624227e-02f, -4.78655733e-02f, 8.44088346e-02f, -1.23712137e-01f, 1.76308174e-02f, 1.25743479e-01f, -8.07261188e-03f, 2.14146990e-02f, 5.61118945e-02f,
  6.49864227e-02f, 7.40821660e-02f, 5.14001548e-02f, -4.68999371e-02f, 4.13220599e-02f, -7.00369403e-02f, 7.48007149e-02f, 2.50485931e-02f, -2.59563737e-02f, 3.73109356e-02f,
  -3.33597623e-02f, -4.86343913e-02f, -9.23562571e-02f, 2.81891413e-02f, 2.93530151e-03f, 1.19292401e-01f, -8.16390589e-02f, 3.59194912e-02f, -9.88064781e-02f, -9.14631337e-02f,
  3.39921527e-02f, -3.69407460e-02f, -1.07478444e-03f, 8.65104666e-04f, 2.54235175e-02f, 5.11340378e-03f, 5.43247648e-02f, 6.57233968e-02f, -7.73259103e-02f, -4.33449186e-02f,
  2.83120006e-01f, 4.71728295e-01f, -2.51476169e-02f, -5.83716556e-02f, 3.36431079e-02f, 5.56995859e-03f, 9.75686759e-02f, -1.27348593e-02f, 1.49503991e-01f, 2.80459486e-02f,
  -4.11455482e-02f, 9.00339801e-03f, 1.39824124e-02f, 1.75068295e-03f, 5.29388264e-02f, 6.57209679e-02f, 1.27954647e-01f, 2.99857371e-02f, 1.28956094e-01f, -6.27467362e-03f,
  3.79074961e-02f, 6.87578246e-02f, -3.64198200e-02f, -9.61061120e-02f, 8.65844935e-02f, 2.31636930e-02f, 2.48007495e-02f, -8.38014390e-03f, 3.91348079e-02f, 6.64807484e-02f,
  1.04769933e+00f, -2.40399659e-01f, -4.01337117e-01f, 4.72909510e-01f, 3.76686871e-01f, 8.33399370e-02f, -1.86957240e-01f, 2.45377645e-01f, 5.80525547e-02f, -1.81892425e-01f,
  1.43026769e-01f, -1.44022048e-01f, -6.09782457e-01f, 3.77290428e-01f, 4.54392076e-01f, -3.13843220e-01f, 4.82596070e-01f, 4.16824743e-02f, 6.38286397e-02f, 3.54523838e-01f,
  3.67746890e-01f, 7.33499527e-01f, -1.52524337e-01f, 2.09340423e-01f, 4.38923985e-01f, 9.38222855e-02f, 2.69390374e-01f, -4.02211457e-01f, 2.44152814e-01f, 1.05171055e-01f,
  1.89492051e-02f, 7.67600238e-02f, 1.15038762e-02f, -1.21608034e-01f, 8.38641748e-02f, -6.80993544e-03f, -3.78267840e-02f, -1.38597131e-01f, -1.00182956e-02f, -4.65267114e-02f,
  -2.82173138e-02f, 3.69753130e-02f, 7.83403441e-02f, -6.93649352e-02f, 1.36419401e-01f, 1.84326340e-02f, 1.88946538e-02f, -3.45262028e-02f, -1.19033188e-01f, -3.56088728e-02f,
  -1.35633782e-01f, -1.42949279e-02f, 9.23495889e-02f, -2.41311621e-02f, -3.43092866e-02f, 3.04212887e-02f, -5.15462011e-02f, -4.82741855e-02f, -7.09378952e-03f, 1.01425916e-01f,
  1.41731545e-01f, -2.89913844e-02f, -2.64891479e-02f, -2.96392571e-02f, 1.08112782e-01f, -3.31180356e-02f, -1.68159548e-02f, -1.08196801e-02f, 2.16983967e-02f, 3.76403406e-02f,
  -2.32491599e-04f, 5.20624295e-02f, 3.08333952e-02f, -1.11242374e-02f, 9.75077748e-02f, -4.77838825e-04f, -1.97567381e-02f, 3.51000316e-02f, -6.14021830e-02f, -3.47416215e-02f,
  -5.84307835e-02f, 7.14034885e-02f, -2.31574308e-02f, -2.71927640e-02f, -1.26118362e-02f, -6.13948447e-04f, 4.12029885e-02f, 6.18036091e-03f, -2.68939026e-02f, 1.95665825e-02f,
  -4.29282933e-02f, 2.20196530e-01f, -9.72463712e-02f, -3.17944847e-02f, -7.45408162e-02f, 8.43911320e-02f, -1.95610113e-02f, 4.21969332e-02f, 2.79347412e-02f, 5.94717190e-02f,
  8.48451555e-02f, -5.51395714e-02f, 6.68393895e-02f, 3.49711142e-02f, -6.75330684e-02f, 1.32170647e-01f, 1.42398954e-03f, 3.89664285e-02f, 1.03739046e-01f, 4.32769358e-02f,
  4.57129627e-02f, 2.42460687e-02f, -9.73136164e-03f, 5.71500547e-02f, 2.82800589e-02f, 8.98118247e-04f, 9.67909545e-02f, -3.07835005e-02f, 3.75188030e-02f, -9.71781909e-02f,
  -4.89173979e-02f, -1.27789509e+00f, -1.91069275e-01f, 5.01977801e-01f, 5.05794942e-01f, 8.71888548e-02f, 4.20376480e-01f, -3.82470012e-01f, -1.57042518e-01f, -5.32302380e-01f,
  1.32698014e-01f, -8.76996517e-02f, -4.36590552e-01f, -3.03368568e-01f, 4.03142244e-01f, -6.11663580e-01f, -1.83679000e-01f, -1.42949978e-02f, -1.82939589e-01f, 4.85406108e-02f,
  1.75296307e-01f, -1.05652707e-02f, -3.23853120e-02f, -2.91836739e-01f, 1.01253301e-01f, 1.24000691e-01f, 3.89083236e-01f, 1.33593157e-01f, 9.50893089e-02f, 9.36935693e-02f,
  -1.35695115e-01f, -1.98857382e-01f, -5.23560084e-02f, -1.79268852e-01f, 1.97544396e-02f, 4.57433946e-02f, 1.94941625e-01f, 1.64680779e-01f, 1.92009658e-01f, -5.69611378e-02f,
  5.13351560e-02f, 9.52140093e-02f, -2.32980102e-02f, 6.16824105e-02f, 2.88276430e-02f, -7.95533657e-02f, 4.28570360e-02f, -6.31397516e-02f, 1.23852612e-02f, -4.23070118e-02f,
  -1.06289357e-01f, -4.43377271e-02f, 6.54755533e-02f, 6.95128515e-02f, 4.77346480e-02f, -1.87576413e-02f, 1.75167024e-01f, 1.20710582e-01f, -2.91199964e-02f, 4.12469544e-02f,
  1.78453419e-02f, 4.36300971e-02f, 2.53632170e-04f, -4.00499813e-02f, 2.89194118e-02f, 4.23233397e-02f, 4.24051248e-02f, 2.42849980e-02f, 2.04008026e-03f, -6.60021370e-03f,
  1.01924494e-01f, 4.62265052e-02f, -2.44827429e-03f, 4.36456688e-02f, 3.16719674e-02f, 3.72084118e-02f, 8.55222493e-02f, -1.32582756e-02f, 2.55214050e-02f, -2.07264051e-02f,
  -4.01862748e-02f, -1.76860951e-02f, -2.31929310e-02f, 2.93827821e-02f, -8.99096802e-02f, 1.71367489e-02f, -1.01751775e-01f, -4.77180770e-03f, 7.81533793e-02f, 8.12164322e-02f,
  -5.23656793e-02f, -3.20318609e-01f, -7.45289177e-02f, 1.13925681e-01f, -1.01277359e-01f, -1.65647287e-02f, -9.76617336e-02f, -8.95334259e-02f, -7.53486156e-02f, -3.34646516e-02f,
  1.08403951e-01f, 1.14646316e-01f, -4.52399030e-02f, 1.11290127e-01f, 3.11494879e-02f, -3.38599533e-02f, 9.16142091e-02f, 3.17557380e-02f, 5.54546677e-02f, -2.44950633e-02f,
  2.73016784e-02f, 1.06311381e-01f, 2.08990965e-02f, 3.53592187e-02f, 1.59355439e-02f, 1.17077731e-01f, 7.26584643e-02f, 1.04471054e-02f, 3.62407370e-03f, -8.53066295e-02f,
  3.79786760e-01f, 1.09284475e-01f, 1.77280262e-01f, 3.85842323e-01f, 5.60793504e-02f, -6.61670715e-02f, 9.65007767e-02f, 1.14256302e-02f, 5.40779173e-01f, 1.48779854e-01f,
  -3.84962231e-01f, 4.28884745e-01f, -4.48160887e-01f, -8.85456875e-02f, -4.87615019e-01f, -3.89662474e-01f, 4.55034524e-02f, 1.91955388e-01f, 5.50868968e-03f, 1.81177646e-01f,
  1.38243511e-01f, -4.06686634e-01f, -4.77817416e-01f, -3.75669122e-01f, 1.02994189e-01f, 4.13487881e-01f, -1.60377458e-01f, -2.73762673e-01f, -2.57101376e-02f, -2.81796128e-01f,
  -1.63593456e-01f, -2.19953191e-02f, 2.10190769e-02f, 4.71117646e-02f, 7.67393261e-02f, 1.18542783e-01f, 2.43724007e-02f, -1.82266980e-01f, -3.90848368e-02f, 3.21702100e-02f,
  1.51865736e-01f, -6.31812811e-02f, -6.28959201e-03f, -1.01456210e-01f, 1.01807438e-01f, 7.29750991e-02f, 9.42274034e-02f, 1.16792798e-01f, 7.51650855e-02f, -5.77660836e-02f,
  8.72832313e-02f, 4.39494215e-02f, 1.17517702e-01f, 1.99311618e-02f, 2.51171496e-02f, 1.75347142e-02f, 1.37064248e-01f, -6.64711595e-02f, 1.02611341e-01f, 1.19215315e-02f,
  -1.53542263e-02f, 2.64575705e-02f, -4.04038765e-02f, -5.75857051e-02f, -2.49945819e-02f, 2.48035174e-02f, 2.78505567e-03f, 2.33687315e-05f, 3.24177034e-02f, 1.91409444e-03f,
  6.53841421e-02f, 5.47496490e-02f, -1.29401749e-02f, 5.96729927e-02f, 1.82105694e-02f, 7.42664859e-02f, -4.72244434e-02f, 5.09024709e-02f, 3.08426004e-02f, -3.73939127e-02f,
  -7.32506961e-02f, -3.66594903e-02f, -4.98803295e-02f, 2.65231449e-03f, -5.08781299e-02f, -4.68708947e-02f, 2.12126505e-02f, 3.32464129e-02f, 6.41261414e-02f, 3.22455652e-02f,
  1.59609407e-01f, 3.64709347e-01f, 4.41314513e-03f, 2.06886865e-02f, 2.09784098e-02f, -3.94573528e-03f, -8.29687938e-02f, 5.75919226e-02f, 3.93443033e-02f, -4.06275652e-02f,
  1.28774881e-01f, 1.22149944e-01f, 1.03153758e-01f, -6.35575876e-02f, -1.01038598e-01f, 3.27078030e-02f, 6.48854822e-02f, 4.78333719e-02f, 7.31199160e-02f, -1.90971754e-02f,
  7.50386193e-02f, 1.19429708e-01f, 8.20704028e-02f, 6.03832975e-02f, 3.44176553e-02f, 9.20965225e-02f, 1.10531755e-01f, 9.05137435e-02f, -1.40149109e-02f, 2.25177035e-02f,
  -1.98910996e-01f, 4.99292724e-02f, -4.00021285e-01f, -7.69926012e-02f, -3.13982338e-01f, -3.89633387e-01f, -1.60520181e-01f, -2.10713089e-01f, 9.44610760e-02f, 5.04772544e-01f,
  2.90088356e-01f, -1.61050797e-01f, 4.60530847e-01f, 2.60212749e-01f, -4.32297975e-01f, 4.37615722e-01f, -4.54763323e-02f, 1.25166282e-01f, 2.40138583e-02f, -2.27465928e-01f,
  -1.34862259e-01f, 1.47760704e-01f, -5.57261985e-04f, -1.12075135e-01f, -2.32140452e-01f, -9.88327712e-02f, 8.31540078e-02f, -1.12171248e-01f, -2.13727746e-02f, -6.86826408e-02f,
  1.61978036e-01f, 2.30760768e-01f, -1.34631723e-01f, 1.77189093e-02f, -1.28830492e-01f, -9.41166952e-02f, -8.96172822e-02f, -1.17873885e-01f, -5.67230675e-03f, -2.38725189e-02f,
  -7.72111863e-02f, -1.05169222e-01f, 3.53225283e-02f, 8.07179064e-02f, -3.06277554e-02f, -1.40534956e-02f, 4.15593125e-02f, 6.83373027e-03f, -1.38600916e-02f, -4.35521081e-02f,
  1.89254750e-02f, -3.14846449e-02f, -6.20407611e-02f, 3.96639444e-02f, -1.26672953e-01f, 2.45538652e-02f, -7.41957724e-02f, -7.19044060e-02f, -2.17789803e-02f, -1.17482685e-01f,
  -7.75851682e-02f, 1.41292193e-03f, 1.30426846e-02f, 1.16419502e-01f, -2.36062687e-02f, 7.03253374e-02f, -3.73567007e-02f, 1.02233902e-01f, -2.43284237e-02f, 3.77609283e-02f,
  -5.15015842e-03f, -1.29919536e-02f, 7.05389082e-02f, -1.23797348e-02f, 4.69114333e-02f, -2.98121590e-02f, 2.62000877e-02f, -2.92260554e-02f, 3.83964740e-02f, 1.73361450e-02f,
  6.32446036e-02f, -1.89959016e-02f, 1.35226669e-02f, 7.77332783e-02f, 5.41411489e-02f, -3.05612874e-03f, 8.55810288e-03f, -5.32869734e-02f, 5.70381470e-02f, -6.71826154e-02f,
  -1.02483220e-01f, -1.68638572e-01f, 5.34935407e-02f, 4.82767820e-03f, 2.41279975e-02f, -5.08376658e-02f, -4.54327166e-02f, -7.06229284e-02f, -6.70290515e-02f, -6.05989732e-02f,
  -6.53990880e-02f, 1.66355912e-02f, -7.12825358e-02f, 2.12124698e-02f, -3.52760330e-02f, -1.84678230e-02f, 2.22108047e-02f, -4.54626232e-02f, -1.02497987e-01f, -4.49596606e-02f,
  -6.75647482e-02f, 2.72826292e-02f, -1.03645045e-02f, 3.08578927e-02f, 1.23654688e-02f, 1.02279540e-02f, -1.30304888e-01f, 2.01359857e-02f, -6.71566874e-02f, 8.95216782e-03f,
  3.87487859e-02f, 9.36317518e-02f, -9.64856744e-02f, 1.96660846e-01f, -3.13486993e-01f, -1.76635250e-01f, -1.43106014e-01f, -1.22892223e-01f, 5.72200716e-01f, -1.27675071e-01f,
  -3.49083394e-01f, 2.74445593e-01f, -1.56628492e-03f, -2.07163706e-01f, 4.87862349e-01f, 4.54890519e-01f, 6.03517108e-02f, -2.47287713e-02f, 2.18199864e-01f, -1.17070515e-04f,
  1.07416734e-01f, -1.92959204e-01f, -1.90869242e-01f, -3.68685603e-01f, -4.70624417e-01f, -1.06043294e-01f, -7.25133270e-02f, -1.40013918e-01f, -3.27826411e-01f, -1.30276676e-04f,
  -1.76444575e-01f, -3.92390502e-05f, -1.26025930e-01f, 5.89221530e-02f, -5.07902652e-02f, -1.59170970e-01f, 1.37477592e-02f, -4.39147511e-03f, 8.27996805e-02f, 2.64444984e-02f,
  4.18026634e-02f, -2.72026882e-02f, 5.35256043e-02f, 5.88986315e-02f, -4.63778265e-02f, -4.55560870e-02f, -9.12200660e-02f, -2.08986491e-01f, -2.68817451e-02f, -1.40629530e-01f,
  -1.21613033e-01f, -2.90237684e-02f, -1.09487213e-01f, 5.67759611e-02f, 3.97127867e-02f, -1.77532975e-02f, 6.06323928e-02f, -7.13084452e-03f, 1.99374668e-02f, 6.47330880e-02f,
  9.59456936e-02f, 2.26899981e-02f, -3.81021574e-02f, -8.11127350e-02f, -7.07198353e-03f, -8.25252011e-02f, -9.02259070e-03f, -8.98514763e-02f, 7.88314417e-02f, -3.57580557e-02f,
  1.71360765e-02f, -3.40560302e-02f, 2.78079491e-02f, 1.34691327e-05f, -8.09933525e-03f, 4.19261046e-02f, -4.69269976e-03f, 3.10973357e-02f, 5.64891696e-02f, -4.30176519e-02f,
  1.69291124e-02f, 8.00827146e-02f, -6.93728700e-02f, -6.01451173e-02f, 4.74848179e-03f, -3.39978747e-02f, 2.48953607e-03f, -6.72249645e-02f, -5.49070118e-03f, -3.31859067e-02f,
  1.40330672e-01f, 5.20483553e-01f, 1.15127414e-01f, 8.21181014e-03f, 3.24692689e-02f, -1.83107927e-02f, 7.41357356e-02f, 4.56073172e-02f, 1.34481028e-01f, 7.40901381e-02f,
  -8.54514614e-02f, -1.33872470e-02f, 2.63915211e-02f, -6.11271383e-03f, 1.00230366e-01f, 5.32916188e-02f, 1.36669755e-01f, 1.06751032e-01f, 2.36719754e-02f, -2.12224331e-02f,
  -5.70330098e-02f, -2.45875642e-02f, 5.87343909e-02f, -1.51927164e-02f, 2.95314053e-03f, -5.09306490e-02f, 5.01198061e-02f, 1.95157994e-02f, -1.37299439e-02f, 3.87219600e-02f,
  -2.35131636e-01f, -6.33733571e-02f, -2.42724210e-01f, -4.65078920e-01f, -1.24954693e-01f, -5.09953797e-01f, -2.93477237e-01f, -6.48669824e-02f, 2.17201740e-01f, -3.31580453e-02f,
  -1.03397265e-01f, 1.85030207e-01f, 3.76732737e-01f, -4.54314977e-01f, -7.33459666e-02f, 2.28629574e-01f, -6.25288010e-01f, -3.23722601e-01f, 1.32623687e-01f, -3.99138063e-01f,
  -3.09746236e-01f, -3.28529477e-01f, -2.63009936e-01f, -1.20515324e-01f, -4.46541339e-01f, -1.37383223e-01f, -8.63644034e-02f, 7.83347115e-02f, -3.77752542e-01f, 9.58096087e-02f,
  -8.13698918e-02f, 1.87166080e-01f, -1.13417335e-01f, 1.07970715e-01f, -1.69872612e-01f, -1.30148873e-01f, -1.98773921e-01f, 8.43338296e-02f, 5.35130687e-02f, -1.56216035e-02f,
  1.48391351e-02f, 7.66631737e-02f, -4.68534753e-02f, 9.47673172e-02f, -7.37107918e-02f, 4.76367120e-03f, 1.40896793e-02f, -3.18019167e-02f, 4.72605377e-02f, 7.46242842e-03f,
  -1.01530124e-02f, -1.04449712e-01f, -1.59079447e-01f, -6.48221150e-02f, -8.39293078e-02f, -1.93897337e-02f, -5.78464791e-02f, 1.44726299e-02f, -1.38285369e-01f, -6.22110665e-02f,
  -1.85728818e-02f, -3.77956927e-02f, -5.32096624e-02f, 1.67446677e-03f, 2.29628924e-02f, 3.13416086e-02f, -2.26907879e-02f, 4.86794673e-02f, 1.96932591e-02f, -6.10656478e-02f,
  -4.06193808e-02f, 3.10541857e-02f, 1.40662892e-02f, -1.42588466e-01f, -1.12974502e-01f, -1.47343716e-02f, -4.48757187e-02f, -3.93473320e-02f, -8.72847214e-02f, -3.36878747e-02f,
  -1.33090895e-02f, -7.33197853e-02f, 2.12977943e-03f, -8.99908468e-02f, -5.22173243e-03f, 3.70645970e-02f, -2.58031134e-02f, 5.86371087e-02f, -4.78320718e-02f, -3.54084745e-02f,
  -1.35408908e-01f, -9.86388475e-02f, 3.83223891e-02f, 1.81409065e-02f, 5.09081595e-03f, -7.01724812e-02f, -4.37960252e-02f, -1.43104374e-01f, -5.03926612e-02f, -5.74478321e-03f,
  -1.74132898e-01f, -8.68313164e-02f, -1.22582428e-01f, -4.87945601e-02f, 2.67851893e-02f, -5.49087077e-02f, -4.71677482e-02f, -8.72825086e-02f, -4.59525771e-02f, -6.07402511e-02f,
  3.97018157e-02f, 3.01250312e-02f, 6.54940158e-02f, -2.39640437e-02f, -3.98580395e-02f, 5.27739991e-03f, 1.02477586e-02f, -1.26299532e-02f, 2.77151931e-02f, 5.15073687e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.67095220e-01f, 5.24028361e-01f, 6.28236532e-01f, 8.51217628e-01f, 8.32583070e-01f, 9.72913057e-02f, 3.99459243e-01f, 3.83311033e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  8.66409838e-02f, 1.87787414e-01f, -1.78855702e-01f, 3.68294448e-01f, -4.66250449e-01f, -1.40548959e-01f, 6.12380147e-01f, 3.64520460e-01f, -2.40667850e-01f, 1.06864047e+00f,
  -6.22477531e-01f, -5.18173277e-01f, -3.30709368e-01f, 1.07448912e+00f, -3.75794381e-01f, -3.70232046e-01f, -5.28337598e-01f, -2.62672752e-01f, 1.95011407e-01f, 5.92041351e-02f,
  5.45321815e-02f, 6.31561816e-01f, -1.17991447e-01f, 2.08418056e-01f, -5.57104647e-01f, 9.61951852e-01f, 1.39850187e+00f, -5.86366951e-01f, -4.29968446e-01f, 5.29028177e-02f,
  -4.99264896e-01f, -3.43397290e-01f, -4.04710501e-01f, -1.50339365e-01f, -1.80573389e-01f, -3.02672565e-01f, -5.41768849e-01f, -9.93575692e-01f, -4.22505252e-02f, 7.45661318e-01f,
  -3.07835340e-01f, -1.56373054e-01f, 9.53893542e-01f, 9.48640645e-01f, -6.36876166e-01f, -2.89514422e-01f, -1.61899328e-01f, -4.99191850e-01f, -1.58997118e-01f, 2.34982491e-01f,
  -6.99537158e-01f, 4.41034794e-01f, 6.18555069e-01f, -6.01436257e-01f, -4.63856190e-01f, 5.06815970e-01f, 7.45607615e-01f, -3.17859441e-01f, -4.86113459e-01f, -6.73153102e-01f,
  -1.51806906e-01f, 5.05080760e-01f, -6.11090064e-01f, 8.50824714e-01f, 1.28958142e+00f, 6.30124331e-01f, 9.18318927e-01f, 2.96346266e-02f, 4.68393177e-01f, -3.02787393e-01f,
  -1.29738915e+00f, -1.40387344e+00f, -4.48690683e-01f, -3.02923203e-01f, -2.04392269e-01f, -3.40904117e-01f, -2.52166897e-01f, -1.55742392e-01f, -1.75782129e-01f, 4.89056647e-01f,
  -7.94038400e-02f, 1.52124733e-01f, 2.24236175e-01f, -1.42020047e-01f, -1.06156468e+00f, 7.79788017e-01f, 1.64306015e-01f, -2.48945653e-01f, -3.34756523e-01f, 6.78440869e-01f,
  -2.90343255e-01f, -5.00142992e-01f, 6.64764225e-01f, -3.51038903e-01f, 1.04048085e+00f, -1.41587272e-01f, -2.13364791e-02f, -4.27595258e-01f, 2.23100141e-01f, -1.54199690e-01f,
  -1.27726078e+00f, 9.01907682e-01f, -2.09679976e-01f, -8.29893887e-01f, -1.36511162e-01f, -8.96079838e-01f, 5.72254181e-01f, 7.22192466e-01f, 4.29623812e-01f, -2.32490480e-01f,
  2.25604191e-01f, -3.66116762e-01f, -7.82327950e-01f, -7.49621391e-01f, -4.87040877e-02f, -1.13377944e-01f, 1.29219994e-01f, -2.11425662e-01f, 3.38771492e-01f, 6.51732460e-02f,
  -3.37047845e-01f, -1.85176507e-01f, -2.46134177e-01f, -9.04750377e-02f, 1.16456427e-01f, 4.22667950e-01f, 6.68137789e-01f, 9.53307927e-01f, -6.53673485e-02f, -6.22914553e-01f,
  -1.16831725e-02f, -5.83960593e-01f, -2.43779179e-02f, -4.93993163e-01f, 4.09908205e-01f, 3.89399320e-01f, 1.31617892e+00f, 3.72188926e-01f, 7.42702186e-01f, -2.44302303e-01f,
  -3.01638663e-01f, -1.12602919e-01f, 1.35799707e-03f, -4.88117725e-01f, 6.49995923e-01f, 1.58109695e-01f, -3.24184984e-01f, 2.84904540e-01f, 6.76903844e-01f, 7.89764285e-01f,
  1.18752217e+00f, -2.38556072e-01f, -4.09489870e-01f, -1.82288200e-01f, -5.93530476e-01f, 1.34178162e+00f, -6.56318069e-01f, -3.95527661e-01f, 8.67601633e-02f, 1.86655149e-02f,
  1.52520929e-03f, 3.49411517e-01f, -2.18953401e-01f, -5.83590686e-01f, 1.30921435e+00f, -8.35300565e-01f, -1.11244130e+00f, 1.39849675e+00f, 4.84956086e-01f, -1.92767188e-01f,
  -1.36133760e-01f, 7.21613348e-01f, 5.98560333e-01f, -3.08063805e-01f, -3.75870258e-01f, -3.08324873e-01f, 1.42073229e-01f, 1.84294373e-01f, 3.78163517e-01f, -1.81067735e-01f,
  4.01588887e-01f, 1.91044897e-01f, 5.48599303e-01f, -6.43732727e-01f, 9.23841655e-01f, -4.89909410e-01f, -5.19522667e-01f, -4.16151524e-01f, 1.15375245e+00f, -3.95815164e-01f,
  -2.20699653e-01f, -5.49310505e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.75918216e-02f, -2.70648837e-01f, -3.56277466e-01f, -1.44021377e-01f, 1.17340159e+00f, -1.57353058e-02f, 7.49916211e-03f, -4.35535282e-01f, -4.37047213e-01f, 7.04692230e-02f,
  3.40523869e-01f, -3.18237007e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    