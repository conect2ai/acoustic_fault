/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.74925554e-01f, -3.01258951e-01f, -2.78704941e-01f, 2.18691304e-01f, -2.29656562e-01f, -2.18286127e-01f, -2.47341827e-01f, 2.12483078e-01f, 2.45248318e-01f, -2.11460702e-02f,
  -2.20803887e-01f, 1.36390567e-01f, 1.44846901e-01f, 1.07196726e-01f, 9.64264125e-02f, -1.76501647e-01f, -2.55200684e-01f, 1.85987413e-01f, 3.29909384e-01f, 1.35990337e-01f,
  4.13469999e-04f, 1.72747999e-01f, 2.96861261e-01f, 1.18172988e-01f, -7.64502212e-02f, 1.04966778e-02f, -1.32493764e-01f, -1.16460964e-01f, -2.30523705e-01f, -2.18662620e-01f,
  -1.53906703e-01f, 2.54267137e-02f, 1.03395700e-01f, 6.35276884e-02f, -1.15813270e-01f, 1.47339031e-01f, 1.14854515e-01f, 1.30303457e-01f, 7.22143948e-02f, 5.48174791e-02f,
  -1.06697930e-02f, 9.48819369e-02f, 6.95659295e-02f, 4.65103462e-02f, 7.70880375e-04f, 8.82741436e-02f, 6.12597317e-02f, 1.74916908e-01f, 2.54814699e-02f, 1.22852745e-02f,
  -1.55322477e-01f, -1.59865186e-01f, -1.81470234e-02f, -6.18094131e-02f, 4.96549569e-02f, -1.11850305e-02f, -1.59630626e-01f, 7.30644688e-02f, 1.28355958e-02f, 1.29034743e-01f,
  1.19519398e-01f, -6.39141947e-02f, -3.22603472e-02f, -5.26441075e-02f, 3.93037237e-02f, -2.57274741e-03f, 5.14813792e-03f, -7.76067376e-02f, 1.51364356e-02f, -1.32130953e-02f,
  -8.99169371e-02f, -5.13820313e-02f, -5.20526394e-02f, -4.52092327e-02f, -4.37991358e-02f, -1.16761111e-01f, -8.51342529e-02f, -9.68080666e-03f, -4.74284701e-02f, -2.53199358e-02f,
  1.96714867e-02f, -1.34824375e-02f, -3.47047709e-02f, 5.62710017e-02f, -4.90488596e-02f, 2.03973567e-03f, -6.23406991e-02f, -5.53674921e-02f, -2.65013576e-02f, -7.63336346e-02f,
  2.21190542e-01f, -1.45653740e-01f, 1.22553863e-01f, 1.54553935e-01f, 1.53873246e-02f, 2.74022315e-02f, 5.90623170e-03f, 1.54228117e-02f, -2.48988178e-02f, 7.71258324e-02f,
  1.77482478e-02f, 1.23269364e-01f, 8.05253570e-04f, -1.09568844e-02f, 3.83136719e-02f, 7.92832896e-02f, 2.38421019e-02f, -2.52560899e-02f, 5.43334428e-03f, 1.11125996e-02f,
  7.65958626e-04f, 1.69730455e-01f, 1.94460049e-01f, 3.96988839e-02f, 5.52299730e-02f, 1.42702222e-01f, 2.59585138e-02f, 5.88452145e-02f, 9.31288004e-02f, 1.68086886e-01f,
  1.02443285e-01f, -8.13125726e-03f, -7.67514706e-02f, 2.66716361e-01f, 3.47535133e-01f, 2.61057794e-01f, 2.01423034e-01f, 3.29372138e-02f, 5.48529029e-02f, 5.62200248e-02f,
  -1.56498402e-02f, -1.04593448e-01f, -2.28415266e-01f, -2.10989505e-01f, -3.23056132e-01f, -6.14438131e-02f, 1.33843124e-01f, -6.76881149e-02f, -2.13510096e-01f, -2.42367182e-02f,
  9.29220766e-02f, 1.19039975e-01f, -8.64644125e-02f, 3.45496386e-02f, 1.76221922e-01f, 7.29845390e-02f, 4.49948832e-02f, 8.86255503e-02f, 1.31692886e-01f, 3.06397945e-01f,
  -2.33575895e-01f, 2.87861943e-01f, -3.93343866e-02f, 6.01833872e-02f, 9.39018205e-02f, 3.45659554e-02f, -4.72694682e-03f, 7.29547516e-02f, 3.96187119e-02f, 4.55234982e-02f,
  2.20393073e-02f, 5.58528826e-02f, 3.09377331e-02f, 6.69257268e-02f, 4.18075025e-02f, 9.48947743e-02f, -3.29496153e-02f, 3.83618511e-02f, -1.26606628e-01f, 4.07529920e-02f,
  1.64849252e-01f, 2.57234573e-01f, 8.64605233e-02f, 7.31279797e-05f, 7.09303245e-02f, 4.35904488e-02f, 6.03351146e-02f, 7.05880821e-02f, 5.19560911e-02f, 7.41765946e-02f,
  9.36689079e-02f, 3.68173569e-02f, 5.64319976e-02f, -2.64215320e-02f, -7.38464743e-02f, -4.69334982e-02f, 1.80014055e-02f, 6.96030958e-03f, -2.34464295e-02f, 3.45405824e-02f,
  -2.78689824e-02f, -9.11683217e-02f, -2.91593242e-02f, -8.53899643e-02f, -4.43742983e-02f, -1.48588205e-02f, -2.94556059e-02f, -9.61459428e-02f, -6.57653287e-02f, -1.27673545e-03f,
  -6.69610053e-02f, -9.20268893e-02f, 2.37804297e-02f, -3.22497077e-02f, -2.24341396e-02f, 7.40350410e-02f, -5.28225452e-02f, 4.07590903e-03f, 2.82025002e-02f, 7.62144178e-02f,
  -3.17233831e-01f, -1.52493224e-01f, -8.12881067e-02f, -2.65745874e-02f, 6.61873594e-02f, 7.78855458e-02f, 1.99647769e-02f, 8.61156508e-02f, 7.55011067e-02f, 6.62411228e-02f,
  1.23033218e-01f, -3.23611870e-02f, -3.23745236e-02f, 3.47159989e-02f, 1.44016579e-01f, 3.27177234e-02f, 7.69535452e-02f, -1.72709152e-02f, 2.51783412e-02f, 1.32386431e-01f,
  -1.24343103e-02f, 3.42602730e-02f, -4.60179634e-02f, -5.21449409e-02f, 1.03021443e-01f, -3.26131806e-02f, -2.09442573e-03f, -7.32416883e-02f, -3.88073064e-02f, -1.05733223e-01f,
  -4.23415065e-01f, -8.62341002e-02f, -1.98652055e-02f, 1.25158671e-02f, 1.46060884e-01f, -8.00916925e-02f, -1.17652103e-01f, -4.97811586e-02f, 6.51416779e-02f, -6.70328215e-02f,
  -8.23543444e-02f, 6.54570162e-02f, 5.71963452e-02f, 1.32215425e-01f, -4.12328765e-02f, -1.55558094e-01f, -5.18797524e-02f, 7.22394437e-02f, 3.15200500e-02f, 3.11880738e-01f,
  1.60485998e-01f, 4.89973575e-02f, 4.96547930e-02f, 1.44149214e-01f, 1.70386076e-01f, 2.31292136e-02f, -7.99584761e-02f, 9.12194103e-02f, 1.28551975e-01f, 3.86037439e-01f,
  1.09471738e-01f, 1.52272701e-01f, -1.18784765e-02f, 6.52533676e-03f, 5.73435128e-02f, -3.13168094e-02f, 9.46331173e-02f, 7.47826844e-02f, 6.19706102e-02f, -2.34507620e-02f,
  -1.10796206e-02f, 3.89672965e-02f, 6.22381493e-02f, 5.34478612e-02f, 1.17127420e-02f, -4.10337932e-03f, 2.82307342e-02f, 7.48897046e-02f, -8.22226554e-02f, 9.85465944e-02f,
  1.41396616e-02f, 5.97550832e-02f, -1.11740991e-01f, -9.98446643e-02f, 7.35321715e-02f, -7.10147843e-02f, 5.10392524e-02f, 3.89261469e-02f, -1.26885474e-01f, -4.95428704e-02f,
  -1.38186410e-01f, -7.06542656e-02f, -5.98646440e-02f, -8.31965953e-02f, -9.50264856e-02f, -6.32129908e-02f, -1.41418306e-02f, -4.76856567e-02f, -2.19100229e-02f, -2.27015428e-02f,
  -8.24871436e-02f, -3.00460309e-02f, -4.06644642e-02f, -7.39463791e-03f, -1.83482263e-02f, -4.30648923e-02f, -1.40768560e-02f, -2.95567531e-02f, -4.41630185e-02f, -4.39015813e-02f,
  -1.97605393e-03f, -1.99283622e-02f, -5.78284822e-02f, -6.15835004e-03f, -9.91412774e-02f, -1.13310918e-01f, -1.50738833e-02f, -2.41629109e-02f, -1.20278373e-01f, -9.79070514e-02f,
  -8.78653452e-02f, -3.48387472e-02f, 8.58294070e-02f, 5.18894643e-02f, 5.38473316e-02f, -2.36247368e-02f, -3.48708741e-02f, -6.19951747e-02f, 3.03283259e-02f, -2.26252563e-02f,
  9.13805962e-02f, 4.76566702e-02f, 2.09074281e-02f, 1.04652680e-01f, -5.20189665e-02f, -6.23925999e-02f, -1.43669844e-01f, 5.38125932e-02f, -2.45762654e-02f, 4.82096039e-02f,
  -9.79898199e-02f, -4.36573103e-02f, -8.99322629e-02f, -1.37705863e-01f, 1.69944204e-02f, -1.79440349e-01f, -6.87206537e-02f, -1.32837817e-01f, -2.87607968e-01f, -2.11559877e-01f,
  8.31808150e-03f, 2.46087670e-01f, 2.41124138e-01f, 9.58126858e-02f, 5.90430349e-02f, 3.02120715e-01f, 3.71794164e-01f, 1.44675732e-01f, 1.17261559e-01f, 1.69169188e-01f,
  -2.54153997e-01f, -1.93187594e-01f, -1.42383978e-01f, -1.61057971e-02f, 2.30035439e-01f, 5.54170728e-01f, 4.85097289e-01f, 4.65144843e-01f, 2.88914472e-01f, 1.50721446e-01f,
  6.96987584e-02f, 1.45966664e-01f, 1.76140010e-01f, 1.85484290e-01f, 1.79221064e-01f, 1.89488649e-01f, 2.30117202e-01f, 1.66303888e-01f, 2.81956494e-01f, 3.79081875e-01f,
  2.07362056e-01f, 9.95698944e-02f, 4.22422960e-02f, -1.37965605e-01f, 7.01682549e-03f, 2.57566888e-02f, 3.43886353e-02f, 1.05792448e-01f, 6.22768700e-02f, 1.86279963e-03f,
  1.84799172e-02f, 9.67152044e-03f, 4.53528725e-02f, -7.02557527e-03f, 1.00303605e-01f, 1.09926187e-01f, 1.79242175e-02f, 1.71353400e-01f, 6.09460473e-02f, 8.50241408e-02f,
  -8.20615962e-02f, 1.60359085e-01f, 1.09559715e-01f, 9.80321318e-02f, 1.75149992e-01f, 8.79987627e-02f, 6.01637326e-02f, 1.49236605e-01f, 2.20266923e-01f, 2.86463737e-01f,
  -5.39986007e-02f, -6.53714985e-02f, -1.06813274e-01f, -4.46767434e-02f, -9.16064307e-02f, -4.56495360e-02f, -4.29534130e-02f, -9.25224740e-03f, -2.30229110e-03f, 3.05018537e-02f,
  -1.03376552e-01f, 4.32616938e-03f, -5.77034242e-02f, 7.49653354e-02f, 1.88019890e-02f, -6.37019724e-02f, 3.63059528e-02f, 4.24981583e-03f, 4.60638665e-02f, -5.57997189e-02f,
  -2.67603504e-03f, 1.09032961e-04f, -2.27156095e-02f, 4.90043461e-02f, 5.23033403e-02f, -1.51930870e-02f, -1.18410029e-02f, -1.42179718e-02f, -9.41586569e-02f, -8.15210044e-02f,
  -1.11754447e-01f, -5.72213307e-02f, 6.93824068e-02f, 1.43159524e-01f, 5.52940108e-02f, 1.08618297e-01f, 2.32543759e-02f, 1.17964998e-01f, -5.41455895e-02f, 1.35135710e-01f,
  -1.19289784e-02f, 5.48079684e-02f, 1.05758077e-02f, 7.78694823e-02f, 9.91249755e-02f, 4.76092100e-02f, 6.21101856e-02f, 6.87820241e-02f, 9.91003215e-02f, 1.55836148e-02f,
  8.34705587e-03f, 2.01241329e-01f, 9.53435823e-02f, 1.63398504e-01f, 1.09241195e-01f, 8.73715580e-02f, 2.04741284e-01f, 6.06858619e-02f, 2.10094750e-01f, 2.53356963e-01f,
  8.27357531e-01f, 2.26994287e-02f, -2.55084246e-01f, 2.13714540e-01f, 1.83186427e-01f, 6.75201342e-02f, 1.87206111e-04f, 1.63070709e-01f, 1.41436040e-01f, 5.81168644e-02f,
  3.06015998e-01f, 3.60593349e-01f, 3.61731648e-01f, 2.84348667e-01f, 2.88533509e-01f, -1.00741886e-01f, -1.70072734e-01f, 1.93016261e-01f, 2.94364542e-01f, 9.76867229e-02f,
  1.37738571e-01f, 1.35779902e-01f, 3.59968483e-01f, 2.14313820e-01f, -4.49166335e-02f, 1.57099500e-01f, -2.90043317e-02f, 1.67789683e-01f, 1.78201690e-01f, -1.39303043e-01f,
  1.15059853e-01f, 3.77282441e-01f, 2.38671914e-01f, 3.80641431e-01f, 2.04023495e-01f, 1.73837453e-01f, 1.99843585e-01f, 1.36740938e-01f, 1.63046703e-01f, 1.27193093e-01f,
  1.70032650e-01f, 1.38262495e-01f, 1.48371205e-01f, 1.00444525e-01f, 1.43228814e-01f, 2.07420304e-01f, 7.64835626e-02f, 2.07629979e-01f, 9.33192372e-02f, 5.41439913e-02f,
  2.13579208e-01f, 3.16266745e-01f, 2.94323146e-01f, 1.47918746e-01f, 2.22626030e-01f, 3.87479216e-01f, 1.13721594e-01f, 1.79395616e-01f, 2.19947338e-01f, 5.62434010e-02f,
  -1.40207127e-01f, -2.06686243e-01f, -2.05810905e-01f, -2.04049796e-01f, -2.65511245e-01f, -2.24404752e-01f, -2.18821079e-01f, -2.19210669e-01f, -1.84090316e-01f, -2.36634538e-01f,
  -1.64839268e-01f, -9.73024368e-02f, -1.71556324e-01f, -7.91695789e-02f, -9.61631313e-02f, -1.22832827e-01f, -1.15034796e-01f, -1.30166009e-01f, -1.69205919e-01f, -2.17214927e-01f,
  -4.34359014e-02f, -2.05152154e-01f, -1.30734041e-01f, -1.93169251e-01f, -1.10337630e-01f, -1.81393787e-01f, -8.92109796e-02f, -1.69802636e-01f, -1.27322599e-01f, -1.82668433e-01f,
  6.85613528e-02f, 4.98115867e-01f, 1.18023522e-01f, 1.85867101e-01f, 1.84944227e-01f, 1.85253501e-01f, 2.01949164e-01f, 2.69437253e-01f, 2.09431976e-01f, 1.28892958e-01f,
  2.90884882e-01f, 2.49070704e-01f, 1.87049747e-01f, 8.85097384e-02f, 1.71094030e-01f, 1.70402169e-01f, 1.74679875e-01f, 1.45329401e-01f, 2.28287682e-01f, 1.09111734e-01f,
  1.13234274e-01f, 1.16917290e-01f, 1.56832889e-01f, 9.87104625e-02f, 1.75769508e-01f, 2.52492845e-01f, 1.02281533e-01f, 1.96856707e-01f, 2.15479046e-01f, 7.22231790e-02f,
  -8.07930052e-01f, -2.30318040e-01f, -3.47097009e-01f, -2.08263606e-01f, 1.12361461e-01f, 1.16361573e-03f, -6.45156056e-02f, -8.94904956e-02f, 3.89781408e-02f, -1.70641299e-02f,
  9.41119194e-02f, 1.49658769e-01f, -7.84479380e-02f, -1.28568143e-01f, -2.27098033e-01f, -2.83046514e-01f, -2.68086314e-01f, -3.11809540e-01f, -1.38810381e-01f, 6.15204945e-02f,
  2.15830997e-01f, -1.19665995e-01f, -2.78166950e-01f, -1.22679919e-01f, 1.23573698e-01f, 8.95821303e-02f, -1.84405267e-01f, -1.71013504e-01f, -7.86068365e-02f, -1.95682660e-01f,
  -4.29662876e-02f, -3.01962584e-01f, -1.25251368e-01f, -2.74470840e-02f, -5.43829910e-02f, -2.27318760e-02f, -1.16616838e-01f, -1.03518672e-01f, -4.94732782e-02f, -1.27913713e-01f,
  -9.24546421e-02f, -3.12492456e-02f, -1.45458549e-01f, 1.10791577e-02f, -1.02293395e-01f, 8.90355185e-03f, -4.71942872e-02f, -2.38129780e-01f, -9.84538123e-02f, -3.00462954e-02f,
  1.21476740e-01f, -6.03257827e-02f, -1.91387907e-01f, -7.91028515e-02f, -2.03649968e-01f, -1.06212601e-01f, -9.42477882e-02f, -2.78522763e-02f, -1.85464904e-01f, -7.07982033e-02f,
  -5.17621785e-02f, 5.94780110e-02f, 1.60555810e-01f, 1.59833178e-01f, 2.23191738e-01f, 1.53239921e-01f, 1.59279183e-01f, 1.23673886e-01f, 1.09777771e-01f, 1.68610811e-01f,
  9.74053219e-02f, 1.10024057e-01f, 1.65563956e-01f, 3.81890647e-02f, 2.21896127e-01f, 6.58909604e-02f, 3.18445638e-02f, 1.00007460e-01f, 1.92429945e-01f, 7.71739334e-02f,
  1.78798944e-01f, 1.42572373e-01f, 7.31477067e-02f, 1.92647368e-01f, 1.61868826e-01f, 4.52152006e-02f, 1.00082211e-01f, 2.46839270e-01f, 1.80323124e-01f, 1.07715763e-01f,
  5.43642528e-02f, -2.31161997e-01f, -1.00956365e-01f, -1.61504194e-01f, -1.21118650e-01f, -6.69302344e-02f, -1.45770073e-01f, -1.01307981e-01f, -1.11053675e-01f, -5.98511137e-02f,
  -5.16033508e-02f, -1.74145207e-01f, -9.99090821e-02f, -9.41319577e-03f, -5.92116490e-02f, -2.30970960e-02f, -3.04419529e-02f, -6.13451228e-02f, -9.30887833e-02f, -6.26859218e-02f,
  -5.14495485e-02f, -8.03185254e-03f, -1.06495418e-01f, -2.56468984e-03f, -6.59642741e-02f, -1.66760653e-01f, -1.20449789e-01f, 5.10264784e-02f, -1.87753066e-01f, -4.28366549e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.73591638e-01f, 2.86254734e-01f, 9.10735317e-03f, 3.23489249e-01f, -2.89977998e-01f, -7.95516968e-01f, -8.73927712e-01f, -5.10932446e-01f, -5.25462106e-02f, 9.06164199e-02f,
  2.21277371e-01f, 4.53831792e-01f, 4.14239317e-01f, 1.69703692e-01f, -5.53795248e-02f, -1.03941031e-01f, -2.28475749e-01f, 8.39986578e-02f, -3.24649364e-01f, -3.05342913e-01f,
  3.28785107e-02f, 9.71400663e-02f, 2.79571444e-01f, 2.59478521e-02f, 4.13524568e-01f, 1.78507775e-01f, 2.51087487e-01f, 8.78952444e-02f, -2.93256901e-02f, 6.06774628e-01f,
  7.60295153e-01f, -2.23991215e-01f, -1.60713956e-01f, -9.74534824e-03f, 1.43197104e-01f, 4.18474972e-02f, -3.45602036e-02f, 7.20042065e-02f, 6.09122068e-02f, 2.08471548e-02f,
  4.62681837e-02f, 4.20056134e-02f, -4.77668718e-02f, 4.86706197e-02f, 5.61436750e-02f, -2.02321121e-03f, -8.70887749e-03f, -1.41937688e-01f, -2.55805198e-02f, 1.30020723e-01f,
  8.26880410e-02f, -1.71223819e-01f, -1.64607808e-01f, -3.15102786e-01f, -3.31480175e-01f, -1.21252842e-01f, -1.34559020e-01f, -2.89846182e-01f, -3.86636734e-01f, -7.08240867e-02f,
  -2.24819914e-01f, 1.86505929e-01f, -9.05706212e-02f, -7.55195618e-02f, 3.42829190e-02f, -5.82983121e-02f, 4.01185080e-02f, 9.44953859e-02f, -1.12551838e-01f, -7.73337111e-02f,
  1.07413689e-02f, 4.89486940e-03f, -2.33136609e-01f, -1.13072041e-02f, 1.05147839e-01f, -5.28544486e-02f, -8.31466988e-02f, 7.56415427e-02f, -2.34366469e-02f, 8.11694488e-02f,
  5.80368796e-03f, -7.60843679e-02f, 1.48084551e-01f, -2.19439849e-01f, -6.00005351e-02f, -6.79512098e-02f, 2.54673902e-02f, -7.27719143e-02f, 1.12110168e-01f, 8.90663862e-02f,
  2.46444732e-01f, -6.36243105e-01f, 4.22909349e-01f, 1.05780385e-01f, 1.47747602e-02f, 2.44490713e-01f, 2.18654990e-01f, 2.80846562e-02f, 1.32085651e-01f, 4.00754483e-03f,
  -1.57494947e-01f, 1.84807908e-02f, 1.47285014e-01f, -3.72760706e-02f, -3.17563973e-02f, -9.90460962e-02f, -3.96060459e-02f, 5.20850420e-02f, -2.62579359e-02f, 1.23583056e-01f,
  1.10022679e-01f, -9.09179896e-02f, 8.96188244e-02f, 5.35909906e-02f, -1.12944357e-01f, -3.67455110e-02f, 2.34390318e-01f, 4.60757799e-02f, -1.30517751e-01f, -1.35701718e-02f,
  -8.38580132e-01f, -1.85722843e-01f, 1.46793678e-01f, 1.77034348e-01f, 4.54576284e-01f, 8.61996859e-02f, 3.55144627e-02f, -3.69430423e-01f, -1.31307006e-01f, -5.49399341e-03f,
  1.43161669e-01f, 4.22585994e-01f, 3.56084019e-01f, 1.37833372e-01f, -8.16484541e-02f, 5.37485592e-02f, 1.36356875e-01f, 1.14362866e-01f, 2.72795618e-01f, 1.44857198e-01f,
  3.63255352e-01f, 1.46743923e-01f, -2.22499058e-01f, -1.55131361e-02f, 1.48309633e-01f, 3.50579292e-01f, 8.03208649e-02f, 2.52433062e-01f, 2.41754889e-01f, 5.08254647e-01f,
  5.17665207e-01f, -6.00239217e-01f, -2.09906250e-02f, -6.90790638e-02f, 1.77479943e-03f, -3.41945469e-01f, -5.23424745e-02f, -2.40618497e-01f, -2.55025387e-01f, -2.11619943e-01f,
  7.57862777e-02f, -1.94637522e-01f, 6.69871494e-02f, -6.84734061e-02f, -1.08768605e-01f, -1.26730546e-01f, -4.52161968e-01f, -2.92765349e-01f, -1.36536568e-01f, -1.01716571e-01f,
  8.03076290e-03f, 1.69546142e-01f, 2.09755510e-01f, -3.99877280e-02f, -9.14813653e-02f, 1.34443715e-01f, -6.56270832e-02f, -1.24224693e-01f, -1.70475945e-01f, -2.30697945e-01f,
  1.97385818e-01f, -6.24795491e-03f, -9.33519378e-03f, -1.04077846e-01f, 2.44551748e-02f, -1.35358069e-02f, 2.44013090e-02f, 5.20384461e-02f, 1.56856865e-01f, 1.33800581e-01f,
  3.12792994e-02f, 8.60225186e-02f, 7.08222985e-02f, -4.80540246e-02f, 5.87269589e-02f, 7.18048066e-02f, 1.70324408e-02f, -9.09351856e-02f, -8.08212161e-03f, 1.11000929e-02f,
  5.49414344e-02f, -1.18676111e-01f, -1.33671135e-01f, -3.46280299e-02f, -2.06840634e-01f, -9.69619080e-02f, 4.61556651e-02f, 2.25467756e-02f, -3.83886434e-02f, 2.90638562e-02f,
  7.26879418e-01f, -4.76794951e-02f, 1.82360396e-01f, -6.95711076e-02f, 3.58791687e-02f, -1.55181870e-01f, 1.44263566e-01f, -7.55839273e-02f, -1.02446921e-01f, -4.50215302e-02f,
  -9.56548601e-02f, -1.29284978e-01f, 3.20097171e-02f, -5.99173345e-02f, 1.67930469e-01f, 3.42634134e-02f, -1.78336754e-01f, 6.88148960e-02f, -7.27998167e-02f, -6.13378175e-03f,
  -2.06822008e-01f, -5.58648296e-02f, 2.91830808e-01f, 2.63566226e-01f, 1.28436074e-01f, 3.54843497e-01f, 1.99863151e-01f, 1.95380986e-01f, 3.87013145e-02f, -2.10296959e-02f,
  -1.98406592e-01f, -3.16659696e-02f, -2.87651032e-01f, 2.48053879e-01f, -3.60648893e-02f, -3.51514459e-01f, -4.22336638e-01f, -3.64995360e-01f, -1.56551644e-01f, -1.15539074e-01f,
  -3.27464521e-01f, -9.98357777e-03f, -5.11858910e-02f, 5.39660901e-02f, -5.19257486e-02f, 7.02273920e-02f, 3.99756163e-01f, 2.79181004e-01f, 1.95125699e-01f, 2.84651108e-02f,
  3.40777934e-01f, 3.80777091e-01f, 3.23259234e-01f, 3.30686897e-01f, 3.57770532e-01f, 3.22310537e-01f, 7.07279891e-02f, 1.79375410e-01f, 1.71672523e-01f, 5.11662662e-01f,
  -4.46965158e-01f, -5.33150911e-01f, -1.81367427e-01f, 2.13130638e-01f, -1.27119347e-01f, -5.04187606e-02f, -1.84399057e-02f, 9.67623368e-02f, 4.84123044e-02f, 1.28665611e-01f,
  1.12413920e-01f, -9.74052213e-03f, 1.48372680e-01f, 1.94179192e-01f, 5.17390966e-02f, -1.90965027e-01f, 1.07713230e-01f, 2.99053509e-02f, -1.11876510e-01f, -2.60394633e-01f,
  3.79475862e-01f, 4.27284390e-02f, -4.08713043e-01f, -3.68122160e-01f, -2.38623366e-01f, 3.23530912e-01f, -2.82384962e-01f, -6.77527636e-02f, -4.24270242e-01f, -7.24658147e-02f,
  -2.53924936e-01f, -6.95904121e-02f, -2.44477782e-02f, -9.35064331e-02f, 9.73345563e-02f, 7.40073323e-02f, 1.87197179e-01f, 2.29971126e-01f, 8.08584616e-02f, 2.93045901e-02f,
  -8.77884328e-02f, -9.74353701e-02f, -1.30680576e-01f, -1.69167265e-01f, 3.64346877e-02f, -1.45436451e-01f, 2.21125826e-01f, 9.01334137e-02f, 7.87590072e-03f, -1.33922100e-01f,
  -1.80826947e-01f, -6.54791221e-02f, 3.52445364e-01f, 3.46477985e-01f, -1.22034647e-01f, -1.61096588e-01f, 1.44675016e-01f, 1.01985201e-01f, 1.08833387e-01f, -1.16435185e-01f,
  -6.16176315e-02f, -6.59367219e-02f, -1.58339247e-01f, 1.23599753e-01f, -1.03173159e-01f, -2.86844937e-04f, 5.19517064e-02f, -7.96756372e-02f, 1.46287661e-02f, -6.30584806e-02f,
  -9.07810777e-02f, 5.16080633e-02f, 1.92800704e-02f, 1.62232280e-01f, -1.09128252e-01f, -4.65455681e-01f, 4.07797704e-03f, 3.95634845e-02f, -1.49852112e-01f, -1.47521198e-01f,
  6.42739981e-02f, -2.11048245e-01f, -1.19317196e-01f, -4.33677644e-01f, -1.97113022e-01f, -1.34484589e-01f, -1.97739586e-01f, -2.21823782e-01f, -4.81858522e-01f, -5.47864377e-01f,
  1.30501568e+00f, 6.35557592e-01f, -1.59772098e-01f, 1.45627797e-01f, 1.97833434e-01f, 3.59815955e-01f, 4.75163460e-01f, 3.81870896e-01f, 1.20634817e-01f, 2.02884316e-01f,
  4.56217349e-01f, 2.82896459e-01f, 2.64852911e-01f, 6.03852533e-02f, 7.84383714e-02f, -2.64682740e-01f, -4.22717661e-01f, -3.15627903e-01f, -7.63936490e-02f, -4.02843244e-02f,
  -8.70437101e-02f, 1.68592349e-01f, 1.58052340e-01f, -1.61443844e-01f, -2.59784758e-01f, -1.32926300e-01f, 1.02233365e-01f, 4.93949689e-02f, -1.75301850e-01f, -7.89385080e-01f,
  -6.65254116e-01f, 2.53653616e-01f, -3.07129234e-01f, -3.14756557e-02f, 3.11181713e-02f, -9.10702869e-02f, -1.68798789e-02f, -2.36346766e-01f, 8.86436328e-02f, -7.95941353e-02f,
  -1.55829325e-01f, -8.54759663e-03f, 1.41686633e-01f, 8.28299019e-03f, 1.28065616e-01f, 1.15373708e-01f, 9.05274972e-02f, 5.81149831e-02f, -4.84449677e-02f, -1.55985922e-01f,
  -8.53924602e-02f, -1.70606058e-02f, 7.17703104e-02f, -5.61417118e-02f, 4.25159466e-03f, 2.90080290e-02f, 1.29926950e-01f, -3.01690921e-02f, 1.28680348e-01f, 7.37984665e-03f,
  1.10090643e-01f, -9.23021436e-02f, -2.29283795e-01f, 4.88788076e-02f, 1.89360783e-01f, -4.39297631e-02f, -2.95071080e-02f, 9.83600020e-02f, 1.72900423e-01f, 1.34063721e-01f,
  -4.36402373e-02f, -4.96888645e-02f, -6.68386072e-02f, 7.59310052e-02f, -1.13264710e-01f, -4.73717898e-02f, -6.08577579e-02f, -9.44219679e-02f, -5.08751795e-02f, 1.04637062e-02f,
  -1.40121847e-01f, -5.46803325e-02f, -6.36887625e-02f, -1.85436174e-01f, -1.97059140e-01f, 2.04059388e-02f, -1.26079977e-01f, 1.62328541e-01f, 2.29114145e-01f, 1.30765676e-01f,
  2.62356550e-01f, 1.66931584e-01f, -2.67641902e-01f, -1.43097058e-01f, -1.80407956e-01f, -5.46555221e-02f, -1.89528540e-01f, -1.73121408e-01f, -1.25672594e-01f, -2.30438069e-01f,
  -2.51928139e-02f, -7.81590641e-02f, 1.44639090e-01f, -4.04277928e-02f, -5.26599176e-02f, -3.55740339e-02f, 4.83634695e-02f, 1.49754405e-01f, -6.55451417e-02f, -2.49148726e-01f,
  -3.84215359e-03f, 1.69932589e-01f, 8.77736062e-02f, 6.47529960e-02f, 1.61114149e-02f, 1.26696661e-01f, 1.15059771e-01f, -3.82363461e-02f, 1.17175594e-01f, 3.01322073e-01f,
  -1.55319527e-01f, -1.16987419e+00f, 8.28394115e-01f, -7.46084452e-02f, 6.06702492e-02f, 1.48812324e-01f, -3.85338902e-01f, -2.71605611e-01f, -1.41893432e-01f, -3.12367141e-01f,
  -1.20073445e-01f, 2.52122134e-01f, 2.31319174e-01f, 2.02032506e-01f, 1.23665720e-01f, -2.12758362e-01f, 1.11595809e-01f, 6.06793225e-01f, 6.22093320e-01f, -1.14476733e-01f,
  -4.53965396e-01f, -1.83418587e-01f, 5.72216101e-02f, 1.36694819e-01f, -3.21042240e-01f, 6.61243051e-02f, 7.57259130e-02f, -2.11283043e-01f, -2.96290070e-01f, -3.72848809e-01f,
  4.76610839e-01f, -5.25719106e-01f, 3.03704828e-01f, -8.39158446e-02f, -1.91858951e-02f, -1.10132834e-02f, -2.93526109e-02f, 9.79488418e-02f, -5.12540489e-02f, 1.06760021e-02f,
  -3.36227007e-02f, -1.03238232e-01f, 7.51143992e-02f, -3.84821221e-02f, -4.20312695e-02f, 7.46563151e-02f, 6.78202184e-03f, -6.62524700e-02f, -3.56699787e-02f, -1.37084350e-01f,
  -2.71924287e-01f, -2.81789973e-02f, 2.16695815e-02f, 3.84120494e-02f, -5.42812720e-02f, 1.15917869e-01f, -1.37696430e-01f, -6.49103746e-02f, 2.43030544e-02f, -2.32370287e-01f,
  3.38377766e-02f, 1.60998508e-01f, 2.80514527e-02f, 9.34752300e-02f, 4.51149717e-02f, 4.03932668e-02f, 4.97785099e-02f, -2.29559764e-02f, 5.66300303e-02f, -5.19607253e-02f,
  1.96714103e-02f, -3.11987028e-02f, -9.41142589e-02f, -1.46813691e-01f, -1.54408813e-02f, -6.70198277e-02f, -1.79802161e-02f, -9.03866515e-02f, 1.75352678e-01f, -5.04590757e-02f,
  -5.80740673e-03f, 6.06994964e-02f, 4.08985764e-02f, 2.49251984e-02f, -1.33488178e-01f, 1.90389425e-01f, 5.66786565e-02f, -9.12874937e-03f, 6.94943815e-02f, -5.29702157e-02f,
  -7.19686225e-02f, 3.47661316e-01f, 5.72401751e-03f, 7.84413796e-03f, -2.63885409e-02f, 2.94413473e-02f, -3.49418931e-02f, 5.01828315e-03f, -1.12400651e-01f, 2.66825985e-02f,
  4.01808042e-03f, 7.68464729e-02f, 1.72331091e-02f, -5.73797487e-02f, 9.29139033e-02f, -1.06535703e-02f, -6.01946972e-02f, 1.75115809e-01f, -7.85506442e-02f, -2.21662801e-02f,
  -6.33805096e-02f, -1.11324247e-02f, 2.52426773e-01f, 8.13549161e-02f, -8.97119269e-02f, 2.54544348e-01f, 1.19269855e-01f, 2.34248508e-02f, 3.03058267e-01f, -8.18971470e-02f,
  -5.61527252e-01f, -1.70702543e-02f, 4.31108147e-01f, 2.07195938e-01f, 5.91089427e-01f, 4.05892096e-02f, -3.24821949e-01f, -6.38789773e-01f, -8.36225785e-03f, 7.15147406e-02f,
  2.79816240e-01f, 2.96505392e-01f, 5.01397967e-01f, 1.59599349e-01f, -4.61879224e-01f, 8.67300257e-02f, 2.84494340e-01f, -1.08599767e-01f, -5.87031782e-01f, -5.66523969e-01f,
  2.82710753e-02f, -2.24958509e-01f, -5.26719272e-01f, -3.57544541e-01f, 2.21892580e-01f, 2.60978580e-01f, 4.98290986e-01f, 1.78886265e-01f, 1.96906835e-01f, 6.03755236e-01f,
  8.39429423e-02f, -5.12022488e-02f, -2.10271981e-02f, 1.78269356e-01f, 3.12594652e-01f, -5.15035808e-01f, -2.48620942e-01f, -1.63571000e-01f, -5.09223377e-04f, -9.37218741e-02f,
  2.98526376e-01f, -1.14212051e-01f, 2.40930304e-01f, -4.32055024e-03f, -1.98196769e-01f, -2.81402469e-01f, -3.41851234e-01f, -4.33739662e-01f, -3.08771580e-01f, -4.25620288e-01f,
  4.88799691e-01f, 1.74502686e-01f, -9.81685445e-02f, -1.85279444e-01f, -2.81426102e-01f, 1.03080861e-01f, -3.41343701e-01f, -4.11715597e-01f, -6.05856240e-01f, -7.35855579e-01f,
  -8.89470521e-03f, 1.18145468e-02f, 6.42163679e-02f, -9.94575694e-02f, -1.94899589e-01f, 3.52391779e-01f, 3.08286428e-01f, 8.21509212e-02f, 6.96024522e-02f, -2.00433046e-01f,
  1.73245877e-01f, -1.13734730e-01f, -1.66272402e-01f, -1.40648112e-01f, 3.82744074e-02f, -1.36689827e-01f, -4.63451892e-02f, -2.32608572e-01f, -1.02375366e-01f, -5.77915907e-02f,
  -3.55233476e-02f, 1.87788889e-01f, 1.26065046e-01f, -1.09312952e-01f, 5.37765510e-02f, 5.60147390e-02f, -1.40979011e-02f, -1.95340469e-01f, -1.40210018e-01f, -1.03722945e-01f,
  -3.11062396e-01f, 3.64458889e-01f, -1.29607633e-01f, -1.53732121e-01f, 2.56611139e-01f, 1.38608873e-01f, -2.83415876e-02f, -4.40212935e-02f, 3.39358971e-02f, -2.18848497e-01f,
  -2.40415499e-01f, -1.80224717e-01f, 2.48244762e-01f, 4.35192101e-02f, -1.14119031e-01f, -2.19110046e-02f, 2.03971058e-01f, 6.29682094e-02f, -1.38706192e-01f, 2.96515692e-02f,
  1.33749232e-01f, -4.15025532e-01f, -3.54807556e-01f, -1.52729958e-01f, -4.93427143e-02f, -1.41572341e-01f, -1.96417883e-01f, -4.04541194e-01f, -5.36573648e-01f, -9.38062489e-01f,
  3.10999125e-01f, -9.60078776e-01f, -3.52343529e-01f, -4.01021153e-01f, -4.00106251e-01f, -1.02892585e-01f, -4.84389722e-01f, 3.03049367e-02f, -8.71943682e-02f, -7.42773831e-01f,
  -1.28590867e-01f, 5.81245542e-01f, 1.07634673e-02f, 3.06163371e-01f, 3.93223315e-01f, -1.01475704e+00f, -6.72153234e-01f, 3.63513738e-01f, 1.03012455e+00f, 7.02343404e-01f,
  4.78912368e-02f, 1.12987921e-01f, 5.19614220e-01f, 2.36963063e-01f, -5.72782695e-01f, -3.62949856e-02f, -7.06331372e-01f, -8.62112716e-02f, -3.12377214e-01f, -8.25079620e-01f,
  -2.45295271e-01f, 6.00398034e-02f, 2.17962056e-01f, 1.86534464e-01f, -6.71435939e-03f, -1.77755430e-02f, -8.47193077e-02f, -1.12657674e-01f, -6.93724677e-02f, -2.20714480e-01f,
  -1.09938197e-01f, 1.63230628e-01f, 7.72193372e-02f, -2.09280215e-02f, -8.57718755e-04f, 1.02151252e-01f, -4.51082326e-02f, 2.72023082e-01f, 4.50660624e-02f, -7.90780857e-02f,
  -2.03106418e-01f, -8.36407542e-02f, 1.33378699e-01f, 2.39777304e-02f, 1.19315259e-01f, 3.46072204e-02f, 4.52180281e-02f, 3.21714878e-01f, -8.41882005e-02f, -6.97180748e-01f,
  -2.00133711e-01f, -1.46218777e-01f, -1.22569157e-02f, 1.01647735e-01f, -1.14785582e-01f, -6.71390668e-02f, -1.03436664e-01f, 3.18766423e-02f, 1.48579165e-01f, -1.00459501e-01f,
  6.88912272e-02f, -7.95117840e-02f, 1.43916592e-01f, -2.32315376e-01f, 4.00210789e-04f, -1.11057162e-01f, -9.79401246e-02f, -9.35177878e-02f, 5.45200333e-02f, -1.60774414e-03f,
  1.35403067e-01f, 6.00036569e-02f, -9.46908891e-02f, 1.37546077e-01f, -4.21638712e-02f, -7.20738396e-02f, -5.29623181e-02f, 1.12360492e-01f, -1.00709330e-02f, -1.33400545e-01f,
  -1.21986002e-01f, 3.80787432e-01f, -4.80722189e-01f, 1.57422140e-01f, -8.15712437e-02f, 6.28912672e-02f, -1.40927255e-01f, 3.72514501e-02f, -5.12130372e-02f, 6.53276742e-02f,
  3.30237061e-01f, -5.78149408e-02f, -1.22264192e-01f, 7.67206699e-02f, -2.68287547e-02f, -1.05646374e-02f, -1.40605822e-01f, -3.76011967e-03f, -2.50642020e-02f, -6.03849441e-02f,
  -1.62284583e-01f, -6.38071224e-02f, -4.96093975e-03f, -1.75758153e-01f, -8.01176578e-02f, 8.03617015e-02f, -2.33983636e-01f, 4.62518679e-03f, -8.84422064e-02f, -9.30077136e-01f,
  -8.57953370e-01f, 9.93048191e-01f, 8.50993693e-01f, -5.91791987e-01f, 5.95006756e-02f, 2.56089777e-01f, 6.76300526e-01f, 1.42562121e-01f, -1.21718712e-01f, 1.09616801e-01f,
  -6.31175488e-02f, -6.90715134e-01f, -1.39247581e-01f, -2.57852703e-01f, -1.62056647e-02f, 3.53336513e-01f, 3.74242783e-01f, -8.52743536e-02f, -4.80939299e-01f, -3.95249009e-01f,
  -2.84732074e-01f, -2.54413456e-01f, -4.05901164e-01f, -9.03282166e-02f, 1.26481161e-01f, -2.02617943e-01f, 3.49593103e-01f, 8.39299560e-02f, 3.61516267e-01f, 1.12241842e-01f,
  -3.31736386e-01f, 3.97533774e-01f, -3.19648564e-01f, -3.53471220e-01f, 4.56454828e-02f, 5.25807589e-03f, 1.38271973e-01f, 1.62057653e-01f, -9.27097723e-02f, 3.75930667e-02f,
  -2.67234802e-01f, -1.44907624e-01f, 4.56790626e-02f, 1.37803629e-01f, -1.29366025e-01f, 1.85503741e-04f, 1.27689406e-01f, 6.49164766e-02f, 2.48886287e-01f, 2.41766572e-01f,
  1.68151706e-02f, -3.98230739e-02f, 1.83554068e-01f, 3.03776056e-01f, 4.59617525e-01f, -3.84454250e-01f, 1.29993483e-01f, -8.38373154e-02f, 1.34308100e-01f, -3.88998032e-01f,
  -1.82454616e-01f, -2.39291981e-01f, 1.61655352e-01f, -2.10214015e-02f, -1.75049037e-01f, -1.43338833e-02f, -3.68652530e-02f, 3.97176854e-02f, -2.05197539e-02f, -1.81337774e-01f,
  2.69053936e-01f, 1.13109104e-01f, 4.90216091e-02f, 1.00026771e-01f, -1.21710114e-02f, 5.43639325e-02f, 3.13427113e-02f, 1.42742842e-01f, 2.16921985e-01f, 1.37289137e-01f,
  -4.75357436e-02f, 1.77960590e-01f, 1.80135936e-01f, 3.61536443e-02f, 3.25014353e-01f, 5.43381572e-02f, -6.57175332e-02f, -5.03183436e-03f, -6.47561848e-02f, -1.48053160e-02f,
  -5.90090573e-01f, 2.43400604e-01f, -1.73993975e-01f, -2.44346991e-01f, 5.62204048e-03f, 1.71223823e-02f, 8.00357908e-02f, -1.59871895e-02f, -2.08461672e-01f, -8.07685107e-02f,
  5.47530130e-02f, -1.34948313e-01f, 1.44981802e-01f, 7.38643482e-02f, -3.08510154e-01f, -1.57917753e-01f, -2.83590943e-01f, -2.34035283e-01f, 5.76777570e-02f, -6.33384585e-02f,
  -3.84092331e-02f, -1.52550071e-01f, -5.42904913e-01f, -2.58954704e-01f, -5.16047589e-02f, -5.74252844e-01f, -2.01629564e-01f, -3.21246028e-01f, -2.29051456e-01f, -6.81753874e-01f,
  8.76497865e-01f, -7.07042813e-01f, 4.36454087e-01f, 1.91322818e-01f, -1.97635680e-01f, -1.86111361e-01f, -4.85352248e-01f, -1.55211478e-01f, 2.45108530e-01f, -2.45666504e-01f,
  -3.94024432e-01f, -1.06427930e-01f, 2.24493891e-02f, 8.47086869e-03f, 2.01361313e-01f, 1.68526303e-02f, 3.12641561e-01f, 6.80577934e-01f, 6.00748062e-01f, -8.88011754e-02f,
  -3.32717359e-01f, 7.14796856e-02f, 3.35943907e-01f, 2.30209902e-01f, -3.44923347e-01f, 1.49259806e-01f, -2.15858985e-02f, -1.63882837e-01f, -2.17094675e-01f, -1.12672262e-01f,
  -3.87821764e-01f, -2.50810683e-01f, 2.69191176e-01f, 1.51731465e-02f, -1.73946276e-01f, 1.02984741e-01f, 8.80984291e-02f, -4.92110699e-02f, -1.58456057e-01f, -2.05021039e-01f,
  -1.62439328e-02f, -2.34822230e-03f, 1.80653278e-02f, -1.41402185e-01f, -1.12914987e-01f, 1.15141296e-03f, 4.59289216e-02f, -1.24132372e-02f, 1.67515874e-02f, -1.99540660e-01f,
  -2.54260540e-01f, -7.82213062e-02f, -1.02925867e-01f, 1.93480123e-02f, 1.20833501e-01f, 1.41845584e-01f, -2.64665604e-01f, -9.06464234e-02f, 6.39284849e-02f, 1.12516806e-01f,
  1.49271786e-01f, -1.99395362e-02f, -1.02284893e-01f, -2.27394644e-02f, 1.89897865e-01f, -3.01542170e-02f, 9.80266556e-02f, -1.25657683e-02f, 2.12434947e-01f, 2.00610146e-01f,
  -9.78527740e-02f, 9.78477821e-02f, -2.16698684e-02f, -7.65584707e-02f, 2.11556274e-02f, -1.44259959e-01f, 3.57410498e-02f, -1.86582401e-01f, 5.48578650e-02f, -3.60792167e-02f,
  1.97033688e-01f, 1.25805084e-02f, -8.82401243e-02f, -1.68044344e-01f, -2.33153149e-01f, -2.50826273e-02f, 1.08301848e-01f, 5.29496931e-02f, 6.78268000e-02f, -4.91019674e-02f,
  -4.37004536e-01f, 4.32491243e-01f, 1.06567234e-01f, 1.56285204e-02f, -1.63780451e-02f, 6.69280589e-02f, 5.41084781e-02f, -6.49102405e-02f, -1.87044919e-01f, -6.90420344e-02f,
  -1.19126849e-01f, 1.82102442e-01f, -1.40211076e-01f, -1.14793098e-02f, 1.65811792e-01f, 1.69714272e-01f, -1.58902392e-01f, 4.87102307e-02f, -7.98142999e-02f, -2.39868507e-01f,
  6.82332590e-02f, 1.37200087e-01f, 2.53881127e-01f, 1.85054556e-01f, 1.39381006e-01f, 4.19423074e-01f, 6.52465373e-02f, -3.90877575e-02f, 1.73341885e-01f, 8.65720287e-02f,
  -5.82330644e-01f, -4.28860754e-01f, 2.70639300e-01f, -7.41620004e-01f, 3.02322228e-02f, 5.33188343e-01f, 8.85060608e-01f, 1.91768244e-01f, -3.11781526e-01f, 1.00546367e-01f,
  -3.82825911e-01f, -6.42790973e-01f, -5.29937625e-01f, -1.78042024e-01f, 1.60026982e-01f, 7.45910943e-01f, 4.12681013e-01f, 1.65526703e-01f, 3.77951920e-01f, 4.37772900e-01f,
  2.22672746e-01f, -2.17661649e-01f, -3.44301999e-01f, -3.18517745e-01f, -2.10640550e-01f, -2.09630266e-01f, -3.19069237e-01f, -4.11975294e-01f, -3.86262089e-02f, -3.13458353e-01f,
  3.95702869e-01f, -5.43891311e-01f, 1.89330980e-01f, -3.73833895e-01f, -1.87126771e-01f, -1.16047733e-01f, -1.55855892e-02f, -1.58093557e-01f, -5.10907136e-02f, 3.13835964e-02f,
  -3.31333548e-01f, -8.18697289e-02f, -1.58709332e-01f, -3.19801830e-02f, 3.70957777e-02f, 8.45803320e-02f, -2.28046253e-01f, -4.94885929e-02f, -2.00471997e-01f, -2.16034167e-02f,
  -5.93477227e-02f, -4.13726419e-02f, 3.70013900e-02f, 1.25076950e-01f, -2.66683906e-01f, 2.04633176e-02f, 2.62956426e-04f, -8.28171447e-02f, -6.32514730e-02f, 1.52043000e-01f,
  1.86179385e-01f, 3.94253768e-02f, -1.54872864e-01f, -1.04177125e-01f, -7.13170692e-02f, 1.00230332e-02f, -1.00903764e-01f, -2.44959760e-02f, -4.56239060e-02f, -5.70352636e-02f,
  6.94814026e-02f, -2.03879531e-02f, -9.72697064e-02f, 2.25292016e-02f, -1.81019470e-01f, -2.04020336e-01f, 3.00501585e-02f, -4.52416725e-02f, -1.36318013e-01f, -6.50983304e-02f,
  -1.51098415e-01f, -9.20978785e-02f, -1.20541103e-01f, 2.22477634e-02f, 5.07110357e-02f, -8.44917446e-02f, -8.63470510e-02f, -1.71721384e-01f, -4.47430201e-02f, 5.21547347e-02f,
  1.31820589e-01f, -2.59939641e-01f, 1.24139145e-01f, -2.01390669e-01f, -5.62394448e-02f, -2.24959224e-01f, -3.92241061e-01f, -1.62564859e-01f, -2.33275101e-01f, -1.38308649e-04f,
  -1.35616288e-01f, -1.23753168e-01f, -7.16632158e-02f, -4.68656085e-02f, 2.14276865e-01f, 6.93110004e-02f, -1.00165382e-01f, 2.27223150e-02f, -1.10409304e-01f, -2.47246362e-02f,
  -5.28124571e-02f, 2.24136651e-01f, 5.08872747e-01f, 2.95402706e-01f, -3.51872817e-02f, 2.90729731e-01f, 3.17734569e-01f, 3.22313935e-01f, 3.62779111e-01f, 6.18617177e-01f,
  8.60384941e-01f, 8.13162252e-02f, -1.32463515e+00f, 5.96289754e-01f, 8.88092592e-02f, -4.59018141e-01f, -2.50685453e-01f, -1.63939327e-01f, 3.80813926e-01f, 3.49056065e-01f,
  2.74076730e-01f, -1.83550745e-01f, -5.96751153e-01f, -4.99774635e-01f, -9.44237173e-01f, -7.44924903e-01f, -5.58259189e-01f, -1.16796458e+00f, -1.04853415e+00f, -1.73568934e-01f,
  4.23465997e-01f, 3.32419217e-01f, 2.14773163e-01f, -2.19751775e-01f, 7.20500126e-02f, -5.00860810e-01f, -3.47169727e-01f, -1.43393666e-01f, -3.71566504e-01f, -2.26733401e-01f,
  -6.32790208e-01f, -4.67356771e-01f, -4.02746588e-01f, 2.19300061e-01f, 1.63299590e-01f, -2.63264384e-02f, -1.00497387e-01f, -1.09228879e-01f, 1.79809138e-01f, -1.49418503e-01f,
  4.40857857e-02f, 1.31426141e-01f, -5.42127341e-02f, -1.94101095e-01f, -8.55836719e-02f, -2.25634217e-01f, 4.86721061e-02f, -5.52624822e-01f, -4.85366821e-01f, -1.69749171e-01f,
  2.69950122e-01f, -1.89387098e-01f, -5.61018765e-01f, -2.00322419e-01f, -6.02714837e-01f, -3.49226356e-01f, -4.11889076e-01f, -4.39496368e-01f, -8.60565484e-01f, 8.55498984e-02f,
  5.54480776e-02f, 1.38680100e-01f, 2.39716992e-01f, 2.15396091e-01f, 1.22425161e-01f, 2.24396363e-02f, -1.15571611e-01f, -4.29383330e-02f, 6.13447279e-02f, 1.94848850e-01f,
  -4.07089554e-02f, -6.61904588e-02f, -1.20349318e-01f, -1.90836340e-01f, -8.91186818e-02f, -8.19274038e-02f, 7.40717649e-02f, -4.19505360e-03f, -2.06100166e-01f, -4.88050357e-02f,
  1.09439045e-01f, 4.01030779e-02f, -1.51571992e-03f, -1.82755262e-01f, -9.93252620e-02f, -1.20607957e-01f, 8.27527642e-02f, 7.55044222e-02f, -1.71757460e-01f, 1.29291654e-01f,
  1.40997410e-01f, -1.80728883e-01f, 9.59172770e-02f, -2.40001574e-01f, -7.57220685e-02f, 9.14655402e-02f, 2.44961277e-01f, 1.87543422e-01f, 1.05563246e-01f, -5.07248640e-02f,
  -1.97301716e-01f, -9.44651812e-02f, -6.56548887e-02f, 1.95635408e-01f, -4.74059805e-02f, -6.98929653e-02f, 2.27421150e-01f, -1.13281468e-02f, -6.97357133e-02f, 4.29587990e-01f,
  3.25404733e-01f, -2.15789024e-02f, 7.22928792e-02f, 8.64558145e-02f, 1.24992713e-01f, -3.30624253e-01f, -1.36430785e-01f, -1.05115660e-01f, -5.16178071e-01f, 5.09342253e-01f,
  -1.01650369e+00f, 4.55285817e-01f, -3.18838686e-01f, -2.83063889e-01f, 2.54436463e-01f, 3.79682422e-01f, 6.35617614e-01f, 4.72503155e-02f, -3.23838174e-01f, -4.64334302e-02f,
  -1.46868452e-01f, -2.21884966e-01f, -2.51886934e-01f, 2.75187772e-02f, 2.80231863e-01f, 4.65827793e-01f, 3.19944859e-01f, 2.16881838e-02f, 7.88371603e-04f, 2.35199302e-01f,
  3.68807495e-01f, 9.60349217e-02f, -3.46519083e-01f, -5.58735356e-02f, -1.66493267e-01f, -1.13370754e-01f, -1.16312996e-01f, -2.37248335e-02f, 2.53507525e-01f, -1.15630035e-04f,
  -6.86024308e-01f, -5.68379760e-01f, 3.25663716e-01f, -1.55835241e-01f, -3.32489997e-01f, -2.25398511e-01f, -8.67185965e-02f, -2.76946306e-01f, -1.72239885e-01f, -3.89861584e-01f,
  -2.14884430e-01f, -1.04357600e-01f, -1.78915158e-01f, 1.83449134e-01f, -1.84398979e-01f, -7.02660680e-02f, 1.95853189e-01f, -1.73192129e-01f, -2.82673210e-01f, -2.25271463e-01f,
  5.88499188e-01f, 2.72602066e-02f, -6.26791358e-01f, 2.64568865e-01f, 4.62042689e-02f, -1.96645349e-01f, -5.57040758e-02f, -1.83397487e-01f, -1.53382704e-01f, -5.02495229e-01f,
  3.69157866e-02f, 2.32917771e-01f, 1.42753080e-01f, 6.44672364e-02f, 2.21132621e-01f, 1.60114467e-02f, 1.70340553e-01f, 2.60225296e-01f, 9.77261513e-02f, 1.30748332e-01f,
  -1.84899598e-01f, -2.60509789e-01f, -8.69041979e-02f, -2.62329787e-01f, -2.37638831e-01f, -3.70124765e-02f, -7.79489204e-02f, 1.00729302e-01f, 1.66468415e-02f, -7.13203177e-02f,
  -2.20860556e-01f, 1.62557922e-02f, -2.05589518e-01f, -2.00203672e-01f, 8.64103884e-02f, 8.48551765e-02f, -9.84917730e-02f, -6.47774860e-02f, 5.10522127e-02f, -1.59297988e-01f,
  -3.69232446e-01f, 7.84805954e-01f, -5.05662858e-01f, -4.90440391e-02f, -1.01759218e-01f, 8.29058886e-02f, 2.73403898e-02f, -6.95492402e-02f, -5.68811931e-02f, -2.85189629e-01f,
  -4.64530429e-03f, -1.92338437e-01f, -1.82497725e-01f, 3.55791599e-02f, -2.25563556e-01f, -3.63653004e-01f, 2.19239622e-01f, -8.06477889e-02f, 2.52124630e-02f, -1.00825906e-01f,
  8.08004364e-02f, 1.39948726e-01f, -6.81865692e-01f, -2.44672611e-01f, -2.31274515e-02f, -3.13523054e-01f, -1.83651671e-01f, -2.91375905e-01f, -8.42072666e-02f, -8.20722058e-02f,
  7.06281185e-01f, -2.26825401e-01f, -7.52571046e-01f, 6.46301687e-01f, -4.63509381e-01f, -7.11313605e-01f, -7.28542924e-01f, 1.79296061e-01f, 3.26605737e-01f, -2.19309092e-01f,
  -7.47292519e-01f, -2.88590997e-01f, -3.41932178e-01f, -2.50580639e-01f, -3.81927848e-01f, -1.98740512e-01f, -1.36002406e-01f, 4.63096499e-02f, -1.13548674e-01f, -6.07587397e-02f,
  1.34354860e-01f, 6.93711936e-01f, 8.13457251e-01f, 3.13247681e-01f, 1.47342071e-01f, -1.17086977e-01f, 1.29536107e-01f, 2.89333463e-01f, -1.86754599e-01f, 1.45116016e-01f,
  -9.20715332e-02f, 1.77593127e-01f, -3.32792282e-01f, 1.27355725e-01f, -6.86107427e-02f, 7.89462328e-02f, 2.66989786e-02f, 2.33357817e-01f, -2.80042320e-01f, 4.45537604e-02f,
  -3.11761469e-01f, -3.09483349e-01f, -2.70631731e-01f, -2.64076233e-01f, 1.47748873e-01f, -2.33709648e-01f, 2.24256188e-01f, 1.58269733e-01f, 2.03974873e-01f, -1.07283041e-01f,
  -3.91536504e-01f, -2.94810563e-01f, -5.02463639e-01f, -1.81049913e-01f, -1.90692989e-03f, -1.15522265e-01f, -2.22011358e-01f, -7.69290105e-02f, -6.37381449e-02f, 5.95570743e-01f,
  2.28021905e-01f, -9.66841057e-02f, -7.68812895e-02f, -1.25873744e-01f, 6.21098578e-02f, -1.20511115e-01f, 5.55857792e-02f, -1.14064338e-02f, -1.67639300e-01f, -8.08886439e-03f,
  -7.30180666e-02f, 8.92628059e-02f, 1.87836722e-01f, 2.11518094e-01f, 1.40266167e-02f, 1.62837040e-02f, -2.54303664e-01f, 2.04265922e-01f, 1.06688656e-01f, 1.99958906e-01f,
  2.83612031e-02f, -2.43649602e-01f, 5.18795550e-02f, 3.41018923e-02f, -6.66434839e-02f, 4.40619662e-02f, 2.65358627e-01f, 4.64606844e-02f, 2.30631903e-01f, -6.20144457e-02f,
  3.76670927e-01f, -2.57465929e-01f, -4.48793657e-02f, -3.95749323e-03f, 1.31771788e-02f, -1.55548006e-01f, -9.29593295e-02f, -8.76465440e-03f, -8.96985903e-02f, -1.76181614e-01f,
  -2.53346801e-01f, -2.82563806e-01f, -8.37208331e-02f, -9.53299031e-02f, -5.22048213e-02f, -1.32874072e-01f, -7.77155980e-02f, -3.34862620e-01f, -2.04750642e-01f, -9.26788375e-02f,
  1.96533222e-02f, -2.46689215e-01f, -1.34291574e-01f, -2.63636321e-01f, 2.44100526e-01f, -4.54907030e-01f, -2.53329873e-01f, -1.11898899e-01f, -4.83597606e-01f, 1.97269246e-01f,
  1.06560731e+00f, 5.47259927e-01f, 7.05662251e-01f, 3.10400039e-01f, 2.65274972e-01f, 5.09563804e-01f, 6.41883492e-01f, 3.90839577e-01f, -3.54921781e-02f, 9.51003358e-02f,
  -1.45269737e-01f, -4.62230235e-01f, -4.51169312e-01f, -2.84707785e-01f, 1.25294447e-01f, 1.96102351e-01f, 3.13276708e-01f, 2.75777519e-01f, 1.88830510e-01f, 2.59440690e-01f,
  -2.36979388e-02f, 2.19846845e-01f, 3.01024497e-01f, 9.30518061e-02f, 1.52044952e-01f, -2.71282136e-01f, 1.61770344e-01f, 1.46184534e-01f, 1.60418645e-01f, 1.78919986e-01f,
  2.46601298e-01f, 3.30309182e-01f, -3.50974023e-01f, -2.56026000e-01f, -1.12307891e-01f, -1.52158374e-02f, -9.98185277e-02f, -1.30634636e-01f, -1.84055269e-01f, 1.60256103e-02f,
  -4.39563766e-03f, -5.13448343e-02f, 1.46559337e-02f, -1.01456873e-01f, 1.32291093e-01f, -1.31403163e-01f, -8.41040313e-02f, -5.96838072e-03f, -1.71330899e-01f, -6.08900785e-02f,
  -2.09840685e-01f, -3.10623925e-02f, 8.06971341e-02f, -8.94149691e-02f, -1.88188497e-02f, -1.95717424e-01f, 7.77126402e-02f, -2.34900322e-02f, -7.28938505e-02f, -1.01342368e-04f,
  -3.37225795e-01f, 1.60184607e-01f, 1.38905510e-01f, 2.57800636e-03f, 1.10791847e-01f, -8.43754038e-02f, -8.64538625e-02f, -2.76291166e-02f, 7.37930760e-02f, 2.44731545e-01f,
  -7.20188469e-02f, 3.42328846e-02f, 1.67620834e-03f, -1.01092160e-01f, -2.10117921e-01f, 9.46426541e-02f, 7.93814138e-02f, -1.64080754e-01f, -1.34424204e-02f, -4.76921871e-02f,
  6.10776618e-03f, 1.48335530e-03f, -1.27059564e-01f, -8.04769322e-02f, -2.44906723e-01f, -8.46341699e-02f, -5.40071614e-02f, -1.52968153e-01f, -6.76375404e-02f, -1.28802299e-01f,
  -2.06074059e-01f, -3.63328725e-01f, -1.70952573e-01f, -5.56680970e-02f, 1.85245305e-01f, -2.09039345e-01f, 3.70097421e-02f, -1.44120634e-01f, 7.62952538e-03f, 3.79735157e-02f,
  1.06154140e-02f, 4.89211790e-02f, 5.73667437e-02f, -7.88186211e-03f, 2.04509832e-02f, -1.58965632e-01f, -1.11342378e-01f, -1.09421670e-01f, -2.27498770e-01f, -1.05014339e-01f,
  -3.98959331e-02f, 4.69662994e-02f, 1.21955303e-02f, -7.00587630e-02f, -2.48064682e-01f, -2.74854481e-01f, -1.08453162e-01f, -3.10196802e-02f, -7.34855011e-02f, -6.97801113e-02f,
  6.36227548e-01f, 4.12887186e-01f, 7.45582283e-01f, 2.09491953e-01f, -9.70668048e-02f, -3.85837704e-01f, -5.13649344e-01f, -3.02354604e-01f, -4.28931639e-02f, 1.14558101e-01f,
  -1.10767871e-01f, -4.29963440e-01f, -7.95255378e-02f, -4.67622161e-01f, -4.14681554e-01f, -2.55974941e-02f, 7.65357092e-02f, 4.76766974e-02f, -5.05159259e-01f, -6.82904840e-01f,
  -6.12953842e-01f, -8.28193575e-02f, 2.91159227e-02f, 6.63405517e-03f, 3.30935478e-01f, -8.98879915e-02f, 5.53317368e-01f, 4.51183349e-01f, 7.58609846e-02f, 5.57293355e-01f,
  4.80528593e-01f, 5.79968274e-01f, -5.57666659e-01f, -1.07302569e-01f, 2.71897286e-01f, -3.04967053e-02f, -1.38023153e-01f, 3.58802170e-01f, 9.75853279e-02f, 7.18628988e-02f,
  9.97614563e-02f, -5.75058982e-02f, 4.12498116e-02f, -5.10166474e-02f, -8.97329524e-02f, -1.24848217e-01f, 6.17388003e-02f, 7.45053142e-02f, 2.68848892e-02f, 1.33675039e-01f,
  -4.00984794e-01f, 6.34399382e-03f, 2.69670814e-01f, -7.11603910e-02f, 2.13115975e-01f, -1.35999203e-01f, 1.47398904e-01f, 2.15697393e-01f, 9.66245234e-02f, 4.73783225e-01f,
  -1.01312056e-01f, 1.44898906e-01f, 7.42127970e-02f, -4.98800650e-02f, -1.93620130e-01f, -3.96485999e-02f, 2.64282525e-02f, -1.81427017e-01f, -9.13464502e-02f, 3.88728045e-02f,
  -1.68323725e-01f, -5.97326383e-02f, -6.07675985e-02f, -4.39415798e-02f, -2.11345032e-01f, 1.61307782e-01f, -5.45905577e-03f, -1.64874494e-01f, -5.38297631e-02f, -3.59698497e-02f,
  -2.13434041e-01f, -4.80670594e-02f, 4.88480888e-02f, -9.37289894e-02f, -5.00778705e-02f, 1.23966001e-02f, -4.03203107e-02f, -7.93966204e-02f, 6.38797879e-03f, -3.40694040e-02f,
  -9.92516279e-02f, -4.71839517e-01f, 8.25994015e-02f, -3.69999968e-02f, 1.38703480e-01f, 1.01581179e-01f, 1.28793344e-02f, -1.18202701e-01f, 1.10399902e-01f, 4.58434550e-03f,
  4.54972312e-02f, -7.55135994e-03f, 1.25975296e-01f, -9.47228372e-02f, -5.27234495e-01f, -1.12009920e-01f, -4.17539030e-01f, -1.73912719e-01f, -1.84695005e-01f, 7.31481016e-02f,
  -9.18191746e-02f, -4.69040960e-01f, -5.20136595e-01f, -2.56503165e-01f, -2.08155036e-01f, -5.25046349e-01f, -1.47706956e-01f, -1.68241605e-01f, -3.54228228e-01f, -3.10260475e-01f,
  -8.18362653e-01f, -1.31411582e-01f, -8.77501249e-01f, -8.81411910e-01f, -9.36996520e-01f, -5.76100469e-01f, -4.26050305e-01f, -1.09457336e-01f, -3.46855909e-01f, -5.01500726e-01f,
  7.96134546e-02f, 5.72033405e-01f, 1.77073240e-01f, 1.79680377e-01f, 1.69694752e-01f, -5.29902458e-01f, -7.73067236e-01f, -6.81573629e-01f, -4.68567938e-01f, -3.96320224e-01f,
  -4.19790864e-01f, -8.07396352e-01f, -5.99422455e-01f, -4.40051287e-01f, -3.53889972e-01f, -2.58652538e-01f, -5.31429529e-01f, -5.62496006e-01f, -3.40208203e-01f, -6.08141959e-01f,
  9.26026627e-02f, -3.41663301e-01f, -1.24632053e-01f, 5.84111847e-02f, -3.21650803e-01f, 1.27835706e-01f, -1.28919901e-02f, -2.20694140e-01f, 1.56012801e-02f, -1.88381180e-01f,
  -2.40701690e-01f, -1.73384085e-01f, 3.27754319e-02f, 6.79926649e-02f, -3.38506848e-01f, -2.31486052e-01f, -1.72351956e-01f, -3.10263187e-01f, -1.53970823e-01f, 8.07800367e-02f,
  -1.81243531e-02f, -1.57003805e-01f, 1.63108498e-01f, 1.07324205e-01f, 1.86414897e-01f, 7.78324530e-02f, 1.09205972e-02f, 5.58610335e-02f, -4.94938456e-02f, -2.74248924e-02f,
  1.61646083e-02f, 1.56733409e-01f, -7.85545111e-02f, -1.53645933e-01f, -3.65213118e-02f, -7.02661052e-02f, -4.06107157e-02f, 4.60040104e-03f, -1.27165481e-01f, -2.74720620e-02f,
  -2.30937265e-02f, -1.15668170e-01f, 3.28230187e-02f, 3.01265437e-03f, -9.68804061e-02f, -2.74599284e-01f, 1.83582366e-01f, 8.24173018e-02f, 3.16237919e-02f, -1.50652617e-01f,
  1.12939486e-02f, 1.03231603e-02f, -5.97315766e-02f, 1.49093494e-01f, -5.46330176e-02f, -6.78548068e-02f, 3.49834114e-02f, 1.59652546e-01f, 1.03007160e-01f, -6.37592897e-02f,
  5.44858754e-01f, -3.76442112e-02f, 1.66715324e-01f, 1.59707606e-01f, -1.98720619e-01f, 3.83211933e-02f, -2.74249800e-02f, 1.91744661e-03f, 5.32074384e-02f, 1.67110503e-01f,
  3.75277363e-02f, 1.19118892e-01f, -3.47942417e-03f, -1.09029301e-02f, -2.27398887e-01f, -8.12184960e-02f, 1.50750130e-01f, -2.12979212e-01f, 9.80824679e-02f, -6.88189492e-02f,
  1.60241555e-02f, 1.28654838e-01f, 4.39120144e-01f, 3.12842935e-01f, 2.42098004e-01f, 2.35992253e-01f, 1.97338805e-01f, 2.18630984e-01f, 2.62887120e-01f, 1.49303555e-01f,
  -1.08561695e+00f, 7.40298703e-02f, -7.72077069e-02f, -9.70328212e-01f, -4.06861007e-02f, 1.67485759e-01f, -4.36428040e-02f, -3.16305995e-01f, -2.97137082e-01f, 1.02183074e-02f,
  5.04032612e-01f, 5.07484563e-02f, -2.48100102e-01f, -4.04899538e-01f, -6.80453300e-01f, -4.07084405e-01f, -5.87584615e-01f, -6.34381831e-01f, -3.89628649e-01f, 1.72305867e-01f,
  2.02682585e-01f, -3.02516520e-01f, -5.51004469e-01f, -1.48442164e-01f, 2.64643073e-01f, 8.36242363e-02f, 5.31963855e-02f, -3.86400707e-02f, 2.12659851e-01f, -7.31151178e-02f,
  5.66597760e-01f, 1.18026450e-01f, 1.79979518e-01f, -1.42927632e-01f, 2.55689770e-01f, 7.94086233e-02f, 1.51486591e-01f, 5.10053001e-02f, -6.33096099e-02f, -1.40441163e-02f,
  -3.82495634e-02f, 1.69907033e-01f, -8.78538713e-02f, -1.52728409e-02f, -4.21601012e-02f, 1.15222827e-01f, -3.14045012e-01f, -2.01662675e-01f, -2.59576350e-01f, 3.83738905e-01f,
  1.79219786e-02f, -1.34542622e-02f, -2.32349604e-01f, 1.48490891e-01f, 1.93078831e-01f, -1.29666612e-01f, 4.55606133e-01f, 4.37518686e-01f, 1.39962792e-01f, 7.39018396e-02f,
  -4.03616764e-03f, 4.30267826e-02f, 1.52327687e-01f, 6.22932687e-02f, -2.68990219e-01f, 1.18111037e-01f, -4.30467390e-02f, 1.69846211e-02f, 1.67447299e-01f, 2.17826273e-02f,
  -1.96102597e-02f, 6.87796697e-02f, 1.41029134e-01f, -1.84591755e-01f, -5.01568392e-02f, -2.19580173e-01f, -1.67955965e-01f, 3.90742123e-02f, 8.87772962e-02f, -6.62596300e-02f,
  -1.72865435e-01f, -2.26575248e-02f, -9.76001397e-02f, -2.20906809e-01f, -1.32275671e-01f, -6.72229081e-02f, -5.72866807e-03f, 1.25053033e-01f, -2.45036241e-02f, -2.72605326e-02f,
  -2.53406167e-01f, -8.84248689e-02f, -3.64049785e-02f, -2.92191714e-01f, -3.96144688e-02f, 1.87199637e-01f, -1.87753513e-01f, 8.75909552e-02f, -2.96593428e-01f, 7.40092173e-02f,
  2.40184320e-03f, -4.62352745e-02f, 8.38661566e-03f, 1.04876161e-01f, 1.15944810e-01f, -2.23696884e-02f, -3.10147017e-01f, -3.48984182e-01f, -1.58995211e-01f, 1.46229789e-01f,
  -4.14648086e-01f, -5.81715047e-01f, -8.47872496e-01f, -4.91892636e-01f, 1.48892403e-02f, -3.53300810e-01f, -3.11149694e-02f, 1.27809390e-01f, -2.22293898e-01f, -5.04224002e-01f,
  -3.60500067e-01f, -8.02660108e-01f, -9.18332413e-02f, -5.51960468e-01f, -2.83669651e-01f, -1.72081694e-01f, -8.52512956e-01f, -4.21084523e-01f, -2.97218580e-02f, -7.93192625e-01f,
  -3.13510686e-01f, 1.95359915e-01f, 1.39994815e-01f, 1.51538685e-01f, -1.29879668e-01f, -8.68527651e-01f, -4.63777959e-01f, 2.12714240e-01f, 5.21135569e-01f, -5.81676774e-02f,
  -4.45198894e-01f, -2.37180635e-01f, 2.49561116e-01f, 8.75055194e-02f, -6.16349041e-01f, -5.46946935e-02f, -2.85660475e-01f, -2.63706893e-01f, -2.69467741e-01f, -6.57642603e-01f,
  -4.57995445e-01f, 4.16154563e-02f, 4.58015561e-01f, 2.66491175e-01f, -2.15689421e-01f, 9.86056402e-03f, -9.24850851e-02f, 1.37478396e-01f, 7.49260262e-02f, -9.82295647e-02f,
  -7.18197003e-02f, -1.38104027e-02f, 1.56656921e-01f, 5.60591742e-02f, -1.20636813e-01f, -1.43036485e-01f, 8.89636874e-02f, 1.32312551e-01f, -4.93877335e-03f, -2.50777960e-01f,
  -4.36021566e-01f, -1.70849591e-01f, 2.89407410e-02f, 1.14073612e-01f, 3.24068568e-03f, 1.75127372e-01f, -3.42979729e-02f, 1.54428542e-01f, 5.42016700e-02f, -5.82722306e-01f,
  -3.31059098e-02f, 1.16736531e-01f, -9.32821259e-02f, -1.65638030e-02f, -7.33624622e-02f, 9.18786135e-03f, -6.76539168e-02f, -1.24148145e-01f, 1.28920292e-02f, -2.91449539e-02f,
  -9.67940036e-03f, -4.90496345e-02f, -1.26861036e-01f, -1.46860749e-01f, 1.19484596e-01f, -1.42990053e-01f, -1.56439934e-02f, -1.72490075e-01f, -1.34655952e-01f, -3.83078866e-02f,
  5.81584834e-02f, 5.51092438e-03f, -2.96679381e-02f, -7.89561942e-02f, -4.49499190e-02f, 4.29963395e-02f, 6.59114346e-02f, 1.80252016e-01f, 8.13879073e-02f, 2.04605788e-01f,
  -2.31711119e-01f, 4.27195102e-01f, -4.56757247e-01f, 5.55690937e-02f, -9.93323326e-02f, 4.53721210e-02f, -7.40251988e-02f, 1.02890290e-01f, 4.08832841e-02f, -1.74055099e-01f,
  -1.71028003e-01f, -2.83551514e-01f, -1.58051178e-01f, 5.06476723e-02f, 6.80443347e-02f, 3.38767953e-02f, -1.02123067e-01f, -2.39438295e-01f, 3.26426723e-03f, -2.84495533e-01f,
  -2.31340587e-01f, -2.28321284e-01f, -3.30684751e-01f, -1.28071502e-01f, -3.01621944e-01f, 6.73418567e-02f, -9.02095884e-02f, -1.89894989e-01f, -1.71739563e-01f, -8.09325457e-01f,
  -6.99304864e-02f, 1.00028314e-01f, -6.13083839e-02f, 2.37149060e-01f, 2.22834423e-02f, 7.69878402e-02f, 2.74527669e-02f, 1.23421684e-01f, 3.47060710e-01f, 1.02717258e-01f,
  1.94348410e-01f, 3.49508464e-01f, 3.94486964e-01f, 3.33307117e-01f, 2.25485697e-01f, 2.35150069e-01f, 1.64977014e-01f, 7.59047717e-02f, -5.20611294e-02f, -6.39864951e-02f,
  1.36557862e-01f, 3.89148518e-02f, -1.54029295e-01f, 5.60228750e-02f, 1.07886128e-01f, 1.24799557e-01f, 3.05535644e-02f, -1.19661123e-01f, -9.45879444e-02f, 1.78193793e-01f,
  6.23385645e-02f, -1.10738754e-01f, 3.98266256e-01f, 1.62866518e-01f, -2.06711306e-03f, -6.04982115e-03f, 4.17477265e-02f, -7.75397494e-02f, -1.03853330e-01f, -2.11650599e-02f,
  2.56561544e-02f, -1.66720703e-01f, 1.12664746e-02f, -8.17520991e-02f, -2.03118369e-01f, -1.08043611e-01f, 6.31829798e-02f, 6.37940019e-02f, 1.68035567e-01f, 1.44700080e-01f,
  7.68064708e-02f, -1.05907038e-01f, -3.24528776e-02f, 7.53208846e-02f, 1.71354622e-01f, 8.54871795e-02f, 3.95444520e-02f, 5.91410175e-02f, 9.42463428e-02f, 1.25640258e-01f,
  3.32790464e-01f, 1.23847164e-01f, 1.50291815e-01f, 8.76070559e-02f, 5.21715656e-02f, -4.87676170e-03f, -1.50430590e-01f, -1.14829456e-02f, -7.43713155e-02f, -1.84872001e-01f,
  -9.27870199e-02f, 9.38363075e-02f, 1.01023853e-01f, -1.37949064e-01f, 4.33661565e-02f, -7.91775882e-02f, -7.52342641e-02f, 1.35071184e-02f, -1.01102360e-01f, 2.58562099e-02f,
  -3.67009677e-02f, -2.15469196e-01f, -2.36891314e-01f, -1.21252663e-01f, -6.57124296e-02f, -3.70176621e-02f, -1.57702506e-01f, 4.23960052e-02f, -6.85691983e-02f, -2.30378866e-01f,
  3.56551647e-01f, 1.63811356e-01f, 2.02433825e-01f, 8.07421058e-02f, -9.73625928e-02f, -1.14317037e-01f, 1.84164301e-01f, -1.48788512e-01f, -1.42188028e-01f, -3.35057192e-02f,
  -1.53854236e-01f, -9.59512666e-02f, 2.81492509e-02f, -7.99424872e-02f, -2.40991652e-01f, -2.18128383e-01f, -3.07915024e-02f, 9.86843631e-02f, 1.45442262e-01f, -3.71974930e-02f,
  -2.24690307e-02f, 1.71109401e-02f, 6.54273182e-02f, 6.81097433e-02f, 8.70927200e-02f, 4.57301289e-02f, -2.01743990e-01f, -1.23096466e-01f, -9.28928927e-02f, -1.60871267e-01f,
  1.16703546e+00f, -1.14146136e-01f, 2.69678179e-02f, 1.23455323e-01f, -1.34112686e-01f, -2.95061857e-01f, -2.05741689e-01f, -4.57989648e-02f, 5.22218738e-03f, 1.87428653e-01f,
  2.49370709e-01f, 2.54587382e-01f, 1.83784768e-01f, 5.54538630e-02f, 1.11962773e-01f, 4.05608937e-02f, -1.14467241e-01f, 1.87133268e-01f, 1.72478721e-01f, 3.43592674e-01f,
  1.28840685e-01f, 1.38607785e-01f, 1.96668521e-01f, 5.75459786e-02f, 3.84520032e-02f, 1.10054389e-01f, -5.21030463e-02f, 8.38092640e-02f, 6.55000210e-02f, 3.21665347e-01f,
  6.09356642e-01f, 3.98626149e-01f, -4.08095606e-02f, 4.61092964e-02f, -2.51644775e-02f, 3.06964424e-02f, -4.51707877e-02f, -9.68147814e-03f, -3.06552108e-02f, -1.27850369e-01f,
  -4.79424791e-03f, 5.17203994e-02f, -1.72687718e-03f, -1.15202628e-01f, -5.76132648e-02f, -5.54479472e-02f, -2.57210713e-02f, 1.14240013e-01f, 1.93321193e-03f, 1.14288099e-01f,
  -2.00100876e-02f, 8.07459727e-02f, -1.72623411e-01f, -1.99097127e-01f, -2.76956148e-02f, -8.36359710e-02f, -1.24248369e-02f, -4.44066636e-02f, -3.43316235e-02f, 7.55442753e-02f,
  2.52038270e-01f, 2.27562666e-01f, 3.08562130e-01f, 1.37961194e-01f, 2.53507048e-01f, 2.07261562e-01f, -2.80781984e-02f, 1.95675176e-02f, 1.39329489e-02f, -2.35285498e-02f,
  -4.98871803e-02f, 1.47439480e-01f, 9.34992265e-03f, 6.54821321e-02f, 6.33012578e-02f, 1.41461827e-02f, -1.00008644e-01f, -1.23593397e-01f, 8.22494775e-02f, 1.45061389e-02f,
  1.72819987e-01f, -9.42840278e-02f, 5.00628259e-03f, -1.03648812e-01f, -1.18241616e-01f, 7.94941708e-02f, 2.00750470e-01f, 1.79656297e-02f, -2.74498314e-02f, 1.25920251e-01f,
  -7.74224043e-01f, -4.69275713e-02f, 3.81609797e-01f, -5.28095406e-04f, -6.76879883e-02f, -3.87686901e-02f, 1.46702588e-01f, -7.59909600e-02f, -1.40607685e-01f, -1.22892059e-01f,
  -3.62746492e-02f, 4.71967785e-03f, -8.98140296e-02f, -6.75340444e-02f, -9.00857747e-02f, 7.87250046e-03f, 5.53133618e-03f, 9.36727133e-03f, -7.55649209e-02f, -1.14531673e-01f,
  -2.20047295e-01f, -1.08177252e-01f, -1.21805593e-01f, -2.47371659e-01f, -4.32798155e-02f, -2.00342834e-02f, -1.62041709e-01f, -6.23567291e-02f, -1.60805687e-01f, -1.83946773e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.45371068e+00f, 6.73264682e-01f, 5.71492434e-01f, 1.08754575e+00f, 9.29570794e-01f, 3.31629544e-01f, 3.88813555e-01f, 1.01350594e+00f, 1.05770302e+00f, 1.30420363e+00f,
  1.01230133e+00f, 6.19863629e-01f, 1.07135272e+00f, 8.44859004e-01f, 7.82563508e-01f, 7.31461942e-01f, 9.20350432e-01f, 3.42953444e-01f, 1.31817713e-01f, 5.66507876e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  1.47266882e-02f, 7.14626163e-02f, -3.52914244e-01f, -2.79833436e-01f, -1.51743159e-01f, -1.38192177e-01f, 4.50107217e-01f, 1.46480218e-01f, 3.66625875e-01f, 2.41897225e-01f,
  4.09455985e-01f, 1.50889203e-01f, -7.26818800e-01f, -5.08669496e-01f, 1.35580167e-01f, -2.52477050e-01f, -3.89030695e-01f, -9.83582377e-01f, 1.08323061e+00f, -7.42644668e-01f,
  -7.52165139e-01f, -7.33190060e-01f, 2.07917795e-01f, 2.90258557e-01f, 1.61681119e-02f, -3.37024510e-01f, -1.28511226e+00f, 9.69687030e-02f, 2.69759506e-01f, 3.63647491e-01f,
  2.67898560e-01f, -3.59891325e-01f, -2.91180104e-01f, -8.44580308e-03f, 2.59272475e-03f, -5.12926877e-02f, -2.89096743e-01f, 6.15785308e-02f, 3.75059843e-01f, -1.46991715e-01f,
  -2.45457739e-01f, -3.36080402e-01f, 2.61386335e-01f, -9.45663601e-02f, -2.85727352e-01f, -1.81102768e-01f, -7.98154712e-01f, 3.33820581e-01f, 3.21170807e-01f, 1.96319148e-01f,
  9.16529179e-01f, -1.09705043e+00f, 7.05677509e-01f, -8.96609664e-01f, -3.58712077e-01f, -1.10467613e+00f, -7.09643364e-01f, 2.15634644e-01f, -3.23356003e-01f, 3.87566090e-01f,
  -1.42837954e+00f, 6.46748304e-01f, 3.98482978e-02f, 7.97023356e-01f, 6.29853383e-02f, 2.27617577e-01f, 1.18008323e-01f, 3.89175981e-01f, 6.15444183e-02f, -6.93110600e-02f,
  -1.82112791e-02f, -3.95269692e-01f, 1.00864045e-01f, -8.07687342e-02f, -1.57820374e-01f, -2.09152520e-01f, -4.76953201e-02f, -4.08406556e-01f, 4.28348064e-01f, -9.28491473e-01f,
  5.81263125e-01f, 2.43371069e-01f, 7.30302513e-01f, -9.12011191e-02f, 7.22258329e-01f, -4.37238693e-01f, -8.31437409e-01f, 1.46296427e-01f, 3.68784934e-01f, -8.57558250e-01f,
  8.50381702e-02f, -1.06599557e+00f, -8.43575180e-01f, 9.09346938e-01f, 1.10677466e-01f, -6.95012569e-01f, -4.77376133e-01f, 9.36974585e-02f, -1.72012791e-01f, -2.31765747e-01f,
  2.96120793e-02f, 1.19347923e-01f, -8.60771477e-01f, 2.10394204e-01f, 3.63092124e-01f, -1.59487784e-01f, -1.82750508e-01f, 2.67746598e-01f, -1.74612939e+00f, -8.59840572e-01f,
  -4.69982684e-01f, -1.18193841e+00f, -4.86393988e-01f, 1.92742497e-01f, -7.17487752e-01f, 9.46296751e-01f, -2.91292053e-02f, 7.79579163e-01f, -3.35556746e-01f, 6.20614469e-01f,
  -1.54220581e+00f, -6.00826740e-01f, -8.43114793e-01f, 4.65764523e-01f, 4.53024179e-01f, -6.82454482e-02f, -7.75257230e-01f, -2.72646304e-02f, 2.86616176e-01f, -8.50470513e-02f,
  -1.49490058e-01f, -1.57043532e-01f, 1.36022838e-02f, 1.16768606e-01f, -1.62050694e-01f, 1.88891545e-01f, 1.65992957e-02f, 5.70318028e-02f, -3.14748824e-01f, 2.59066582e-01f,
  2.51319170e-01f, -4.19392407e-01f, -1.17471731e+00f, 5.08320868e-01f, 6.41080976e-01f, 5.79138160e-01f, -1.35800576e+00f, 3.84594679e-01f, -9.04375672e-01f, -1.38120472e+00f,
  1.40222702e-02f, -8.19634438e-01f, 6.34411052e-02f, -1.05728686e+00f, 7.73474634e-01f, 4.27869678e-01f, 2.88015306e-01f, 1.36478133e-02f, 8.34534243e-02f, -4.18499827e-01f,
  4.27685603e-02f, 3.26225132e-01f, 3.23056877e-01f, 2.17063427e-02f, 2.43696943e-02f, 3.42110634e-01f, 8.91594231e-01f, -3.19321692e-01f, -4.39218044e-01f, -2.92432815e-01f,
  5.02693094e-02f, 1.29085435e-02f, 2.89844096e-01f, -4.13821608e-01f, 3.65712851e-01f, 5.14496088e-01f, -1.40308416e+00f, -8.32577050e-01f, -1.60625994e+00f, -1.21736193e+00f,
  -2.39316851e-01f, 1.00828566e-01f, 1.26091695e+00f, 1.19412556e-01f, 9.72774744e-01f, 2.95669064e-02f, -1.40356588e+00f, 1.51202846e-02f, -3.97422343e-01f, -6.10047162e-01f,
  -2.83316523e-02f, -6.92806065e-01f, -2.40749214e-02f, 1.45603968e-02f, 8.06821361e-02f, -1.58533499e-01f, -1.86781548e-02f, -1.21524438e-01f, 3.20579380e-01f, -8.88916850e-02f,
  7.06659779e-02f, 4.21562582e-01f, -1.77563071e-01f, -2.66466379e-01f, 6.13596380e-01f, -1.26021028e+00f, 3.68322074e-01f, -6.45439148e-01f, -7.36622453e-01f, -1.06537271e+00f,
  -3.73434216e-01f, 4.89163063e-02f, 9.72356424e-02f, -6.28606796e-01f, -1.04769635e+00f, -6.25850022e-01f, 6.51479423e-01f, 4.53265160e-01f, 8.71860921e-01f, -6.71472073e-01f,
  -1.13213217e+00f, -7.57051408e-01f, 9.96312574e-02f, 3.07095408e-01f, -3.74197900e-01f, -8.12424123e-02f, -1.82046399e-01f, -1.29969865e-01f, -1.80433676e-01f, -2.12284684e-01f,
  -1.13500379e-01f, 1.32204145e-01f, 2.54225731e-01f, -5.35780750e-02f, -2.89815426e-01f, 1.83713377e-01f, -7.03842282e-01f, 6.09990954e-01f, 4.45351094e-01f, -3.45127404e-01f,
  -8.83253440e-02f, 6.55866086e-01f, -5.02951920e-01f, 6.18384719e-01f, -4.45891261e-01f, 4.53706384e-02f, -3.44480038e-01f, 9.48159516e-01f, -9.11105573e-01f, -1.66029528e-01f,
  -4.33121055e-01f, -8.26238394e-01f, -7.33148277e-01f, -6.25560462e-01f, 2.42218524e-01f, -7.72134960e-01f, 2.82634676e-01f, 1.83508128e-01f, -8.03389996e-02f, -6.02124810e-01f,
  1.24620020e-01f, 1.32324710e-01f, 2.69918710e-01f, 5.31515777e-01f, -6.19558431e-02f, 2.02857733e-01f, -2.89378226e-01f, -2.16676667e-01f, -1.14566135e+00f, 4.50930923e-01f,
  -1.96918949e-01f, -3.40658903e-01f, 5.36704123e-01f, -4.38657224e-01f, -3.94327581e-01f, -1.52503639e-01f, 8.61503959e-01f, 8.99722397e-01f, -4.11523521e-01f, 6.40890449e-02f,
  -3.99163455e-01f, 5.58106959e-01f, -6.31219447e-01f, -1.14687061e+00f, -7.12478042e-01f, -5.00175714e-01f, -5.95938861e-01f, -3.95113736e-01f, 1.56547278e-01f, -1.51414245e-01f,
  -2.11721361e-01f, 3.41115236e-01f, 2.23568022e-01f, -1.78499267e-01f, -3.47458094e-01f, 2.72941619e-01f, 4.63438958e-01f, -7.45936155e-01f, 2.21456319e-01f, 4.07471299e-01f,
  7.84658194e-01f, 2.55971581e-01f, 4.08268660e-01f, -9.68379796e-01f, -1.12394714e+00f, 8.07844698e-01f, -1.26296610e-01f, -1.04574144e+00f, -5.92695653e-01f, -9.71908033e-01f,
  7.73937941e-01f, -3.04778963e-01f, 1.88042745e-01f, -5.76030314e-01f, 1.38232559e-01f, -1.21940339e+00f, 1.32107452e-01f, -5.38511932e-01f, -1.04073770e-01f, 5.68670928e-01f,
  1.76621869e-01f, -3.29380721e-01f, 3.93152505e-01f, 2.31285200e-01f, -2.11465567e-01f, -3.56207222e-01f, -1.74910977e-01f, -5.80650628e-01f, -2.18592122e-01f, -1.04878277e-01f,
  -5.31328678e-01f, 2.31642857e-01f, 1.52318686e-01f, 7.02721596e-01f, -3.00498456e-01f, -4.69262987e-01f, 3.96039426e-01f, -6.01101756e-01f, -3.78664911e-01f, -6.89731956e-01f,
  -1.16461813e+00f, 6.15375876e-01f, -5.16893089e-01f, -2.65482098e-01f, -7.51285970e-01f, -5.38744628e-01f, -5.03505409e-01f, 1.35273457e-01f, 6.32231116e-01f, -4.75221336e-01f,
  -5.42121112e-01f, -5.58495164e-01f, -1.61557510e-01f, 1.47396950e-02f, 5.55343702e-02f, 1.68944493e-01f, 6.56930804e-02f, -2.93744087e-01f, -7.15660393e-01f, 2.19734773e-01f,
  -3.06942880e-01f, 2.37303674e-01f, 3.21166575e-01f, -4.73145425e-01f, -1.14062309e+00f, -5.60902357e-01f, -1.06664455e+00f, 9.42803502e-01f, -4.09952462e-01f, -2.82365382e-01f,
  2.07641631e-01f, 9.28673685e-01f, -1.36848378e+00f, -3.85088742e-01f, -4.85860348e-01f, -7.00203255e-02f, -1.06742251e+00f, 8.40398967e-01f, 7.18443632e-01f, -5.65229416e-01f,
  -2.92771161e-01f, -4.34755206e-01f, -8.48019421e-01f, 1.92830861e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.80399889e-01f, -1.45857841e-01f, 2.45388746e-01f, 5.14372066e-02f, -6.74930681e-03f, 4.39702362e-01f, -3.44021827e-01f, -3.33483279e-01f, 1.42088875e-01f, -1.61763385e-01f,
  -7.72570193e-01f, 4.74627644e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    