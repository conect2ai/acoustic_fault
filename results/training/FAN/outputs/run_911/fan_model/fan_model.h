/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.23184539e-01f, -1.08992562e-01f, 5.22677526e-02f, -8.25775415e-02f, -3.04455627e-02f, 3.12524177e-02f, 1.16857566e-01f, -8.23024362e-02f, 2.12395508e-02f, 1.41963298e-02f,
  1.60535976e-01f, -2.15316331e-03f, 8.75730067e-02f, 3.20817530e-02f, 7.43595511e-02f, 3.91284488e-02f, 4.25487980e-02f, 3.73428352e-02f, 1.27736539e-01f, 7.02759810e-03f,
  -2.38676816e-02f, 8.12941268e-02f, 1.27623335e-01f, 1.03472151e-01f, -6.52052760e-02f, 1.91902891e-01f, 1.69467881e-01f, 8.58154818e-02f, 1.71348318e-01f, -9.99652129e-03f,
  1.56154007e-01f, 6.77994490e-02f, 1.13871731e-01f, 1.46466466e-02f, 6.01967680e-04f, 4.52138893e-02f, -7.06187040e-02f, 1.67078711e-02f, -8.12749565e-02f, -6.61019012e-02f,
  -3.75836492e-02f, 6.20758254e-03f, -4.55566086e-02f, 1.70929672e-03f, 6.00434542e-02f, 4.62183170e-02f, -4.78532026e-03f, -5.21804951e-02f, -1.03040859e-01f, 2.76597086e-02f,
  7.14046136e-02f, -6.57812273e-03f, 3.90719548e-02f, -8.39999691e-02f, -2.41771061e-02f, -6.53801113e-02f, 6.61295205e-02f, -7.46300357e-05f, 4.14966233e-02f, 4.32352982e-02f,
  5.79920709e-02f, -5.85435480e-02f, -1.68321317e-03f, -4.89160083e-02f, -1.21921329e-02f, -4.98843454e-02f, -3.24616954e-02f, -3.22302729e-02f, -5.19706309e-02f, -6.72880635e-02f,
  1.57877395e-03f, -7.04732239e-02f, -4.75944094e-02f, -4.22318429e-02f, -4.33109701e-02f, -5.34833148e-02f, 4.71114973e-03f, 1.76859610e-02f, -3.35745998e-02f, 9.04795900e-03f,
  -3.64549085e-02f, -4.77811657e-02f, 8.69223848e-02f, 7.85083398e-02f, 7.94501156e-02f, -4.64568585e-02f, -5.62905967e-02f, 3.34830582e-02f, -7.63981443e-05f, -1.34670332e-01f,
  3.74074443e-03f, 1.11594841e-01f, 9.64900032e-02f, 5.88603988e-02f, 4.24796231e-02f, 3.27144414e-02f, -6.27904534e-02f, -2.79631820e-02f, -4.79366519e-02f, -5.40894456e-02f,
  2.14193333e-02f, -8.88423026e-02f, 9.96704474e-02f, 1.31655745e-02f, -5.51423654e-02f, -1.15593322e-01f, -4.43972684e-02f, -8.80070776e-02f, -9.68257338e-03f, -1.02149233e-01f,
  4.86373901e-02f, 7.10135996e-02f, 4.28796187e-02f, 1.40440259e-02f, 1.76415741e-02f, 2.44873781e-02f, 6.56246021e-02f, 7.49271214e-02f, 1.20453581e-01f, 3.87848355e-02f,
  -2.05828965e-01f, 2.12334543e-01f, 3.20712268e-01f, -1.31142691e-01f, 3.69538553e-02f, 3.98400016e-02f, 1.55559540e-01f, -9.49367359e-02f, -2.50665635e-01f, 1.72006652e-01f,
  -2.85555925e-02f, 8.93562883e-02f, 2.19882071e-01f, 1.18652381e-01f, 5.61112501e-02f, 1.58838451e-01f, -3.83482762e-02f, 3.24582458e-02f, 5.48424609e-02f, -9.10839438e-03f,
  -1.57321572e-01f, -1.80442840e-01f, -1.35497317e-01f, -1.69184834e-01f, 1.05083972e-01f, 9.88008529e-02f, -1.23785587e-03f, -5.20154871e-02f, 1.08309560e-01f, 3.36103956e-03f,
  4.56036776e-01f, -7.18120337e-02f, 4.19681296e-02f, -1.07149348e-01f, 1.76458377e-02f, -6.94130883e-02f, 1.57321855e-01f, -5.94292842e-02f, -2.12008320e-02f, -2.79561281e-02f,
  -2.07334980e-02f, -1.45919591e-01f, -2.90623587e-02f, -4.48634960e-02f, 8.21524579e-03f, 2.13912036e-03f, -1.19982250e-01f, 2.05960684e-02f, -3.29674035e-02f, 4.76303473e-02f,
  5.30639179e-02f, 7.89504312e-03f, -6.12992235e-03f, -3.05885146e-03f, -4.80733514e-02f, -2.00789478e-02f, 2.83130091e-02f, -2.26269066e-02f, -1.97399314e-02f, 9.68033671e-02f,
  1.03252791e-02f, 1.01753853e-01f, 3.09127904e-02f, 2.72370633e-02f, -6.66648895e-02f, 2.67840046e-02f, 2.72179563e-02f, 1.39727304e-02f, -1.00747943e-01f, 1.02591276e-01f,
  -2.77274847e-02f, -2.98258010e-02f, 3.69674042e-02f, 3.87463719e-02f, 4.68997331e-03f, -5.11093205e-03f, -2.99005844e-02f, 1.43084014e-02f, -7.70469233e-02f, -2.68842950e-02f,
  1.76349399e-03f, 2.92642396e-02f, 2.93590166e-02f, 2.42468473e-02f, -4.97070141e-02f, -4.13001813e-02f, 2.67203171e-02f, 1.67282205e-02f, 1.23438910e-02f, -9.67119336e-02f,
  5.01876771e-02f, -1.23606049e-01f, 1.23740457e-01f, 8.44092816e-02f, -2.23391764e-02f, -1.40260300e-02f, 4.19388637e-02f, -1.04229981e-02f, 2.84465421e-02f, 3.19340229e-02f,
  1.90641712e-02f, 5.97703643e-02f, 5.49583174e-02f, 6.66159904e-03f, 1.54173579e-02f, -6.72415495e-02f, -2.64798570e-02f, 4.18118089e-02f, -9.96084511e-02f, 2.81525739e-02f,
  -2.14688834e-02f, -5.71348295e-02f, 1.22555792e-01f, 6.59973249e-02f, -5.53125292e-02f, 9.49095190e-02f, 3.24255764e-01f, 1.15318045e-01f, 1.49813786e-01f, 1.87512040e-01f,
  2.08944574e-01f, 3.53523083e-02f, 1.93198755e-01f, 1.05564622e-02f, -5.29898666e-02f, 3.66725065e-02f, 9.47426036e-02f, -5.26111722e-02f, -1.30112059e-02f, -1.53310979e-02f,
  9.93458088e-03f, -1.46853596e-01f, -8.06546211e-02f, -2.13752948e-02f, 1.06300429e-01f, 3.23521462e-03f, -3.42169814e-02f, -7.47729465e-02f, -6.51030317e-02f, -1.38266385e-01f,
  -1.08540185e-01f, 1.37036636e-01f, 1.97403088e-01f, 6.00562431e-02f, -4.73633334e-02f, -7.50027746e-02f, 1.15291350e-01f, 1.07709080e-01f, -7.45012090e-02f, -2.42633484e-02f,
  1.24693066e-01f, 1.30359337e-01f, -1.31552324e-01f, -3.57250534e-02f, 2.74569057e-02f, 4.84100878e-02f, -1.42782182e-02f, 1.14514075e-01f, -2.01872364e-02f, 1.21164314e-01f,
  -9.39836055e-02f, -7.44271502e-02f, -1.50744943e-02f, -1.78505853e-02f, -7.03643681e-03f, 2.69720703e-02f, -5.74782267e-02f, 1.25809520e-01f, 7.38145411e-02f, 6.33693207e-03f,
  -2.43035238e-02f, 1.02489898e-02f, 3.44413742e-02f, 5.82489781e-02f, -2.43588537e-02f, -1.47279119e-02f, 1.55131416e-02f, -7.85953254e-02f, 3.25277708e-02f, 3.87608446e-02f,
  -8.29869062e-02f, -4.14469950e-02f, -6.29299209e-02f, -5.64150000e-03f, -1.00063764e-01f, 3.79074039e-03f, -1.25421941e-01f, 1.12914732e-02f, -6.64769039e-02f, 4.34295014e-02f,
  -4.63876128e-02f, 1.05642557e-01f, -4.36735293e-03f, -3.52332816e-02f, -5.71563169e-02f, 4.23518755e-02f, 1.23308238e-03f, -5.37943188e-03f, 1.80214550e-02f, 5.99591509e-02f,
  -1.18432254e-01f, -1.46871628e-02f, -2.06613750e-03f, -4.38034721e-02f, 7.07638934e-02f, 3.16688046e-02f, -2.19053533e-02f, 3.44504416e-02f, 1.64075196e-02f, -2.35245973e-02f,
  1.67403132e-01f, -1.12320147e-01f, 9.33604613e-02f, 4.76020016e-03f, -6.73900545e-02f, -3.41389515e-02f, 1.15719549e-01f, 8.13160017e-02f, 9.83542502e-02f, 2.31845882e-02f,
  -3.50985373e-03f, -6.14395328e-02f, 5.34502268e-02f, 5.26262540e-03f, -3.59250396e-03f, -3.77284102e-02f, -1.00949086e-01f, -1.70802604e-02f, -4.12063263e-02f, 2.02099998e-02f,
  1.20262876e-02f, -6.14985526e-02f, 2.65856795e-02f, -2.83457600e-02f, 2.48458311e-02f, -9.09108222e-02f, -3.42021920e-02f, 3.68256937e-03f, 6.79253638e-02f, 1.14044294e-01f,
  -2.95592874e-01f, 2.05925301e-01f, -1.82343766e-01f, -3.60273793e-02f, -2.08681777e-01f, -2.27375686e-01f, -2.93887883e-01f, -7.07270801e-02f, -2.73260735e-02f, -1.33444339e-01f,
  1.71022471e-02f, 8.11159015e-02f, 8.26967880e-02f, 6.69043437e-02f, -3.29401679e-02f, -8.46358240e-02f, -5.24296537e-02f, -1.27028719e-01f, -9.81209949e-02f, -2.26148620e-01f,
  7.56353289e-02f, -3.14870551e-02f, 2.15489119e-02f, 3.38853039e-02f, -1.34214148e-01f, 9.19112563e-02f, 1.35025987e-02f, -3.73331346e-02f, 1.95246696e-01f, -1.16589509e-01f,
  -8.06324184e-02f, -2.01553375e-01f, -1.45311818e-01f, -4.93987799e-02f, -2.75141541e-02f, -1.57051701e-02f, -5.81039442e-03f, 4.54927944e-02f, 1.10536166e-01f, -3.55677046e-02f,
  -2.87664123e-03f, 9.36343372e-02f, 4.95502353e-02f, 7.93045610e-02f, 4.72923033e-02f, -7.17591047e-02f, 2.50015259e-02f, -3.24379019e-02f, -1.24184579e-01f, -8.76332913e-03f,
  1.24291509e-01f, 7.89778978e-02f, -9.16937292e-02f, 3.79489199e-03f, -3.85265574e-02f, -6.29896671e-02f, 7.26831034e-02f, -6.17196970e-02f, -5.80756180e-02f, 5.31036071e-02f,
  -4.44214009e-02f, 4.30430323e-02f, 1.30856633e-02f, 5.74482866e-02f, -1.86166186e-02f, 4.21282835e-02f, 8.62775818e-02f, 1.23639721e-02f, -3.94856045e-03f, 3.81144509e-02f,
  1.70795079e-02f, -9.14309546e-02f, 9.49461479e-03f, -3.01827714e-02f, -4.60280152e-03f, 1.11156274e-02f, -3.94256487e-02f, 2.04981747e-03f, -1.02034220e-02f, 8.89790803e-03f,
  -3.05427592e-02f, 3.65367793e-02f, -6.10687723e-03f, 9.26110074e-02f, -3.57222036e-02f, -6.19244110e-03f, -2.71565770e-03f, 6.63204538e-03f, 4.67541516e-02f, -4.59640697e-02f,
  2.04501078e-01f, -9.66331512e-02f, 1.29847070e-02f, 7.28149563e-02f, -4.88515235e-02f, 7.15474924e-03f, 7.72636291e-03f, 2.70837955e-02f, -4.74880040e-02f, -1.31722707e-02f,
  -5.27282059e-02f, 7.82905221e-02f, 2.38623600e-02f, 2.27519311e-02f, -6.54783472e-02f, -1.22736633e-01f, 1.38528839e-01f, -1.79875102e-02f, 5.23373066e-03f, 1.00714497e-01f,
  1.24103069e-01f, -2.47691050e-02f, -2.64599212e-02f, 1.67083871e-02f, 1.13241130e-03f, -5.28759435e-02f, 7.60114044e-02f, -9.13168956e-03f, -2.32241326e-03f, 4.52908464e-02f,
  2.62154847e-01f, 1.36316597e-01f, 2.80504804e-02f, 5.87133653e-02f, -6.62294775e-02f, -1.70344338e-01f, -4.91334163e-02f, -3.79400104e-02f, -8.17305744e-02f, -5.05729280e-02f,
  -1.93158835e-02f, -4.29722406e-02f, -7.16651827e-02f, -1.75704025e-02f, -3.60625237e-02f, 3.19484994e-02f, 9.72052440e-02f, 1.00491226e-01f, -2.38321945e-02f, -2.74242796e-02f,
  8.57487321e-02f, 3.32868584e-02f, 1.36877224e-01f, -5.91062270e-02f, 1.21209994e-02f, 4.67681959e-02f, 5.23956232e-02f, 7.09316041e-03f, 9.68114063e-02f, 1.92023903e-01f,
  9.96431410e-02f, 1.09269042e-02f, -1.25776500e-01f, 2.38323137e-02f, -7.50144571e-02f, -4.12813164e-02f, 1.01975780e-02f, 6.86354414e-02f, -4.19034734e-02f, 2.91732363e-02f,
  -5.21542467e-02f, 6.37280568e-02f, -8.72916803e-02f, 4.37743329e-02f, 3.56988944e-02f, -7.25041106e-02f, -6.27730116e-02f, 6.84368461e-02f, -6.77582771e-02f, -8.80941469e-03f,
  4.07253988e-02f, 8.83364826e-02f, -9.72888321e-02f, 1.52607821e-02f, -5.88185117e-02f, 2.10893620e-02f, 4.20778580e-02f, 3.47067006e-02f, -1.08114965e-01f, 6.88825697e-02f,
  -2.11671721e-02f, 9.50963274e-02f, -4.52274345e-02f, 1.55821219e-01f, 6.82307780e-03f, 5.95120639e-02f, 1.87926125e-02f, -6.17294088e-02f, 2.04314161e-02f, -1.52682997e-02f,
  -5.94911836e-02f, -3.29830758e-02f, -2.69759609e-03f, -6.53331056e-02f, 1.24144405e-02f, 8.93376395e-02f, 1.61275137e-02f, -4.61610630e-02f, 3.78266983e-02f, -1.65331252e-02f,
  -5.68269044e-02f, 1.81834362e-02f, 2.70319283e-02f, -2.89184935e-02f, 6.13130629e-02f, 3.51408683e-02f, 6.86747371e-04f, -5.49706034e-02f, 1.04307972e-01f, 2.79490259e-02f,
  6.89699873e-02f, -2.64379811e-02f, -2.93933209e-02f, -6.89307973e-02f, -4.97374721e-02f, -1.53239584e-03f, -1.65167972e-02f, 5.17919324e-02f, -8.31464976e-02f, -1.31652539e-03f,
  -5.83127029e-02f, 6.32792488e-02f, -5.69488714e-03f, -4.89464263e-03f, -8.06423649e-02f, 4.87088524e-02f, -7.83832073e-02f, -1.08503237e-01f, -1.34384371e-02f, -9.15841609e-02f,
  -3.80294840e-03f, 1.10113500e-02f, -8.65050219e-03f, -8.49990267e-03f, -4.04740423e-02f, -4.64504361e-02f, 6.98963404e-02f, 2.97638681e-02f, -1.73355080e-02f, 9.01977569e-02f,
  2.13491008e-01f, -3.34815115e-01f, -2.80045718e-02f, -1.16472766e-01f, 1.46183938e-01f, 1.60802647e-01f, 1.11065201e-01f, -6.01920746e-02f, 2.68415101e-02f, -1.76206920e-02f,
  -3.88511084e-02f, 1.50358856e-01f, 7.87485912e-02f, 1.21935718e-01f, 2.31350753e-02f, -9.82959121e-02f, -1.72328621e-01f, 1.16847502e-02f, 3.13529044e-01f, 2.73899943e-01f,
  1.10822454e-01f, 2.01855823e-02f, -3.05249244e-02f, 8.84946361e-02f, -1.75279588e-01f, 5.15434379e-03f, -1.86650947e-01f, -1.02964237e-01f, 4.97682244e-02f, -1.68255225e-01f,
  9.31297764e-02f, -2.00883254e-01f, 1.41260430e-01f, -1.11078238e-02f, -6.28609657e-02f, 8.29213560e-02f, -5.23928553e-02f, -8.23824480e-03f, -6.62110597e-02f, -3.95864919e-02f,
  -8.65839720e-02f, 1.22682685e-02f, -1.73917282e-02f, 4.73696887e-02f, -8.11191648e-02f, 6.23109713e-02f, -1.78661317e-01f, -1.11672739e-02f, -7.08912015e-02f, -2.76178643e-02f,
  -1.44951999e-01f, -8.32408667e-02f, -1.78260989e-02f, 1.42292604e-02f, -6.29795194e-02f, 2.15943679e-02f, -1.41550213e-01f, -9.36633348e-02f, -3.98435406e-02f, -3.69201191e-02f,
  -4.64253463e-02f, 2.36061607e-02f, 2.08250843e-02f, 5.15027205e-03f, -2.22949814e-02f, -3.46766016e-03f, -1.11871146e-01f, 3.82056534e-02f, 4.96544503e-02f, -1.27005279e-02f,
  -2.30268352e-02f, -4.66033444e-02f, 3.22247716e-03f, 1.07375551e-02f, -2.42078006e-02f, -1.16359610e-02f, 4.60745469e-02f, -6.34892657e-02f, 9.55762621e-03f, 1.16698816e-02f,
  3.67328012e-03f, 3.17274081e-03f, -3.72096635e-02f, 6.89916834e-02f, -2.10522786e-02f, -2.95828599e-02f, 7.25502446e-02f, 4.24158946e-02f, 1.84050463e-02f, 4.85513546e-02f,
  2.67017707e-02f, -3.89478356e-02f, 1.50755763e-01f, 6.29229564e-03f, -3.58102620e-02f, -4.41165715e-02f, 1.31061133e-02f, -1.77853229e-03f, -9.29340497e-02f, 4.15651500e-02f,
  7.68475384e-02f, -3.20547037e-02f, -6.85749203e-02f, -7.35506564e-02f, 4.38731089e-02f, 9.53385457e-02f, -1.02127017e-02f, 9.89585370e-02f, -3.04983053e-02f, -2.32814103e-02f,
  -1.15084179e-01f, 1.68103233e-01f, 2.89329737e-01f, 5.68149313e-02f, 1.57764226e-01f, 1.01471670e-01f, 8.87325406e-02f, 1.17102437e-01f, 1.30580574e-01f, 1.81228817e-01f,
  -2.64542520e-01f, -1.25093171e-02f, 4.36475389e-02f, -8.45495760e-02f, -2.61725318e-02f, 2.91146934e-02f, -1.33605868e-01f, -1.13843434e-01f, 3.52635793e-02f, 1.02353673e-02f,
  -8.32351390e-03f, 3.17556784e-02f, 3.64102051e-02f, 1.15193360e-01f, -1.06017493e-01f, -4.87772888e-03f, 2.92646363e-02f, -5.15326336e-02f, -1.84026808e-02f, -4.78751995e-02f,
  4.15873379e-02f, 2.33379513e-04f, -9.15770531e-02f, 3.22244167e-02f, 1.75042689e-01f, -6.91724941e-02f, 6.25608265e-02f, 1.20600417e-01f, 1.62756979e-01f, 2.26430491e-01f,
  -6.69475719e-02f, 1.52087271e-01f, -2.33960561e-02f, -7.58094192e-02f, -4.22983468e-02f, -6.01303056e-02f, -3.96163994e-03f, 3.37992236e-02f, 7.56895170e-02f, 7.12057129e-02f,
  2.51564924e-02f, 1.65911915e-03f, -4.82720174e-02f, 6.97691739e-02f, -2.35370528e-02f, 9.73120797e-03f, -2.06916481e-02f, 8.13337117e-02f, -1.32353501e-02f, 6.50005788e-02f,
  1.37082666e-01f, 6.19871169e-02f, -8.57599676e-02f, 6.13545701e-02f, 1.79155804e-02f, 5.57197928e-02f, 4.37407941e-02f, 1.85167771e-02f, -8.58505722e-03f, -1.08380225e-02f,
  -3.06938626e-02f, 5.07709496e-02f, -1.57297196e-04f, 5.35809994e-02f, -3.94249931e-02f, -9.60031450e-02f, 9.02277902e-02f, -2.50430312e-02f, 6.13536499e-02f, -4.34490405e-02f,
  -3.22052278e-02f, 5.39037995e-02f, -2.57200375e-02f, -5.09238169e-02f, 9.82023869e-03f, 9.63340849e-02f, -6.87130203e-04f, -3.27660963e-02f, 4.69842628e-02f, 5.21021150e-02f,
  -6.83036074e-02f, 6.84806257e-02f, -1.11219361e-02f, -3.51141319e-02f, 1.20732626e-02f, 6.79966286e-02f, -6.08355217e-02f, 6.62428439e-02f, -3.42904851e-02f, 1.08118698e-01f,
  -1.71625882e-01f, 8.96230415e-02f, -6.56146407e-02f, -1.29349977e-01f, 1.99913848e-02f, 3.45365820e-03f, 2.92739142e-02f, 4.71851379e-02f, 6.35941252e-02f, -2.83162575e-04f,
  2.73507740e-03f, -5.41187115e-02f, -1.15046255e-01f, -2.97661275e-02f, -4.17868309e-02f, -6.73290640e-02f, -4.56355624e-02f, -3.65365259e-02f, -3.76027217e-03f, 2.83388700e-02f,
  -1.28931224e-01f, -7.02777654e-02f, -1.11163534e-01f, -1.11117847e-01f, -9.39312279e-02f, -1.85745880e-01f, -1.33497790e-01f, -2.90058255e-02f, -2.01228991e-01f, -3.14796567e-01f,
  4.85322654e-01f, 1.74311083e-02f, 1.25326619e-01f, 1.10785894e-01f, 6.75211847e-02f, 1.65635660e-01f, 2.51151890e-01f, 1.29811198e-01f, -2.63262410e-02f, 8.38345438e-02f,
  1.47549897e-01f, -3.70710455e-02f, -1.34544641e-01f, -5.80082200e-02f, 4.50546592e-02f, 3.10056731e-02f, 5.72483661e-03f, -2.52626725e-02f, 3.39903794e-02f, -2.69305520e-03f,
  -1.29326686e-01f, 5.85810058e-02f, 7.40497336e-02f, 3.15181054e-02f, -1.13311641e-01f, 4.33927737e-02f, -7.04601221e-03f, -4.92826737e-02f, 9.90950782e-03f, -3.42109263e-01f,
  3.32743488e-02f, 1.43327460e-01f, -1.32304162e-01f, -1.07433973e-02f, -3.26911099e-02f, -1.54377753e-02f, 1.21672995e-01f, -2.39738375e-02f, -3.34869809e-02f, 4.29006846e-04f,
  8.83708373e-02f, -1.27568319e-02f, 2.30972422e-03f, 2.25645434e-02f, 6.65799379e-02f, -3.07867918e-02f, 6.76292053e-04f, -2.29249839e-02f, 1.46941915e-02f, -8.70471634e-03f,
  1.58635024e-02f, 2.52710525e-02f, 1.13601863e-01f, 3.80956605e-02f, 1.31208990e-02f, -6.61343262e-02f, 3.65002081e-02f, 3.90690826e-02f, 2.27865651e-02f, 5.21293469e-02f,
  -1.16143622e-01f, -6.62043924e-03f, -1.22307511e-02f, -2.73072775e-02f, 2.72283033e-02f, -4.56711389e-02f, -9.48878452e-02f, 2.59072986e-02f, -1.19328918e-03f, -2.61806268e-02f,
  -2.33422946e-02f, 1.27971042e-02f, -5.55613823e-02f, 8.73610154e-02f, -8.37307982e-03f, 5.26200458e-02f, 4.41152379e-02f, 3.23174372e-02f, -6.23978153e-02f, -2.03001816e-02f,
  -3.87783200e-02f, 1.67884883e-02f, 9.70863923e-02f, 6.92126229e-02f, -9.08980519e-02f, -7.39632547e-02f, 8.77612010e-02f, 5.46466447e-02f, -3.48152630e-02f, 1.23942411e-02f,
  4.07993197e-02f, -8.90701264e-02f, -5.51419519e-02f, 6.18692562e-02f, -4.00646171e-03f, -4.85504717e-02f, 1.51567499e-03f, -9.02969986e-02f, 4.89716493e-02f, 6.10602945e-02f,
  1.06885321e-02f, 1.04058571e-01f, 5.98755628e-02f, -6.41390979e-02f, -9.78520587e-02f, 3.38363610e-02f, -1.28073497e-02f, 6.12223567e-03f, -6.23220801e-02f, 1.34180129e-01f,
  5.80333844e-02f, 9.11222175e-02f, 1.33417994e-01f, 1.33673951e-01f, 5.25639057e-02f, 4.07237411e-02f, 9.06068236e-02f, 7.62687847e-02f, 1.84779972e-01f, 1.55007213e-01f,
  2.31589690e-01f, 7.23071098e-02f, -7.27760345e-02f, 1.20037414e-01f, 8.04205611e-02f, 1.50960386e-01f, 2.21773565e-01f, 5.70944808e-02f, -4.05572765e-02f, 1.18782170e-01f,
  1.32623568e-01f, -9.94522348e-02f, -6.54104799e-02f, -4.18925472e-02f, -2.03031413e-02f, -1.22044925e-02f, -5.41893393e-02f, -4.60412912e-02f, -4.61403988e-02f, 4.02559899e-02f,
  1.13968616e-02f, 8.85762554e-03f, -9.73139331e-02f, -1.33457765e-01f, -1.07850328e-01f, -1.12300895e-01f, -9.24731418e-02f, 4.07365821e-02f, -1.91848539e-02f, -5.07416911e-02f,
  -1.34171873e-01f, 8.00731108e-02f, -1.24211296e-01f, 5.35203004e-03f, -2.38158014e-02f, -2.78619863e-02f, -3.06745470e-02f, -1.31339014e-01f, 3.83717194e-02f, -1.15293907e-02f,
  4.84139472e-02f, 5.73346093e-02f, -4.57459241e-02f, 2.53965352e-02f, 4.17051986e-02f, -5.67434244e-02f, -8.92689079e-02f, -9.34826136e-02f, -1.09208934e-01f, -6.26788959e-02f,
  2.24784645e-03f, 1.49469159e-03f, 3.35297287e-02f, -5.98385297e-02f, 7.32632130e-02f, -2.25994946e-03f, 3.30612026e-02f, -2.83890087e-02f, -5.52069321e-02f, -5.38845919e-02f,
  3.62261645e-02f, 3.66823338e-02f, -6.22622631e-02f, -7.13487789e-02f, -7.71160275e-02f, 1.52346957e-02f, -7.32851848e-02f, -6.44953474e-02f, -4.09659818e-02f, 2.15337221e-02f,
  -1.18332252e-01f, 2.57597677e-02f, -4.49751168e-02f, 5.97929358e-02f, 1.89598221e-02f, -5.09749800e-02f, -9.93930921e-03f, 5.49775921e-02f, -7.32100904e-02f, 2.16417182e-02f,
  3.65277752e-02f, -7.80067891e-02f, -1.21800574e-02f, 3.07722539e-02f, -4.19980213e-02f, 1.52264889e-02f, -1.00760482e-01f, -7.13282973e-02f, 4.66857590e-02f, -1.78867877e-02f,
  -1.20596820e-02f, -3.57092060e-02f, -1.84261911e-02f, -1.14249566e-03f, 3.52775641e-02f, 5.66203557e-02f, 4.71791215e-02f, -3.94306704e-02f, -1.59222763e-02f, -1.48781696e-02f,
  8.61696750e-02f, 7.46720508e-02f, -1.83121730e-02f, 8.29835087e-02f, -5.78029156e-02f, 5.51775098e-02f, 9.59539637e-02f, 5.52725829e-02f, 1.49433436e-02f, -6.40819371e-02f,
  1.46589549e-02f, -4.20591375e-03f, -3.09866536e-02f, -4.72384319e-02f, -2.18625236e-02f, 3.78960744e-04f, -4.37284224e-02f, 1.69072952e-02f, 9.12573487e-02f, 6.22492097e-02f,
  -2.94241369e-01f, -6.21851441e-03f, 1.52284652e-01f, -2.65749581e-02f, -8.05128589e-02f, -1.18939057e-01f, -1.17721736e-01f, -1.82676211e-01f, -1.59376040e-01f, -9.18268636e-02f,
  -1.48869500e-01f, 1.55197401e-02f, 9.36908275e-03f, 2.59719118e-02f, -4.52256650e-02f, 6.82794452e-02f, 1.79949090e-01f, 9.49755013e-02f, -5.85976280e-02f, 8.01957585e-03f,
  5.57387397e-02f, -6.25483096e-02f, 8.25525001e-02f, -4.96196141e-03f, 1.04005702e-01f, 3.39135416e-02f, 1.19681925e-01f, 3.94010581e-02f, 3.46470401e-02f, 3.79992574e-01f,
  -5.28241917e-02f, 2.44792197e-02f, -3.57781164e-03f, -1.75195131e-02f, -3.20990942e-02f, 2.04172898e-02f, -9.33114886e-02f, 7.78455734e-02f, -9.99439582e-02f, -5.20362519e-02f,
  -6.59056678e-02f, -2.24669036e-02f, -8.79408345e-02f, 1.22354580e-02f, -7.93296844e-02f, 5.41223958e-02f, -2.45335288e-02f, 1.00944951e-01f, 3.71207781e-02f, -6.35436028e-02f,
  1.62004903e-01f, 2.73181163e-02f, -1.02966959e-02f, 1.91554315e-02f, 1.34826535e-02f, -5.80440871e-02f, -1.24566201e-02f, 6.50465041e-02f, 9.80850607e-02f, 4.42912392e-02f,
  -5.62485568e-02f, -3.59358341e-02f, 3.72615494e-02f, -1.21057229e-02f, 6.53339103e-02f, -4.39245347e-03f, -7.47340098e-02f, -1.00307241e-01f, -2.98636369e-02f, -4.51100897e-03f,
  8.85340106e-03f, 2.00278386e-02f, -6.53875917e-02f, 2.88986266e-02f, -2.90766452e-02f, -1.16475429e-02f, -2.15108264e-02f, 4.30710474e-03f, 5.37887327e-02f, 2.72990149e-02f,
  -2.05519935e-03f, -1.38811832e-02f, 5.21774441e-02f, 7.28004873e-02f, -1.42036704e-02f, 9.15567204e-02f, -8.71635322e-03f, 1.54259391e-02f, -1.49726346e-02f, -9.38987434e-02f,
  -2.97041416e-01f, 6.05582334e-02f, -4.49368171e-02f, 1.30115926e-01f, -1.44792395e-03f, 5.57157695e-02f, 6.30214140e-02f, 2.07726806e-02f, 2.55175456e-02f, -6.34446144e-02f,
  -8.68752599e-02f, 2.60963012e-02f, 3.88157740e-02f, 1.62999094e-01f, -5.16862161e-02f, 1.54857822e-02f, -1.27598830e-02f, 3.12875248e-02f, -6.21923618e-03f, -8.43058079e-02f,
  -1.67320296e-02f, -1.50128767e-01f, -1.56770736e-01f, -5.48906997e-02f, 4.69014943e-02f, -5.12724109e-02f, -1.28163189e-01f, -1.41560853e-01f, -5.46988323e-02f, -2.61026740e-01f,
  3.69214296e-01f, -3.88578661e-02f, 8.61835480e-02f, 1.71749189e-01f, 1.21226475e-01f, 2.55691726e-02f, 9.04118642e-02f, -2.18670350e-02f, -3.67762968e-02f, 8.78508091e-02f,
  -1.17987610e-01f, -2.59768963e-01f, -2.65780419e-01f, -7.19817877e-02f, -2.09553726e-02f, -2.32255291e-02f, 1.71711013e-01f, 1.07870638e-01f, 4.88042273e-03f, -5.99241443e-02f,
  1.85390785e-02f, 2.21958116e-01f, 8.95599723e-02f, 9.93652176e-03f, 3.31292674e-02f, -1.40242159e-01f, 1.90393850e-01f, 5.70683256e-02f, -2.44873967e-02f, 3.23001355e-01f,
  -1.66438088e-01f, 8.11815858e-02f, 1.04073115e-01f, 4.21021059e-02f, 5.16597480e-02f, -5.42702936e-02f, 5.98849803e-02f, 4.60441299e-02f, -1.25257839e-02f, -1.13163665e-01f,
  -1.93224498e-03f, -2.84323562e-02f, 4.43495438e-03f, -7.77925272e-03f, 3.90621759e-02f, -5.25677241e-02f, 8.54120851e-02f, -6.87463442e-03f, 1.23563237e-01f, 2.59787170e-03f,
  -3.24973464e-02f, 9.03699175e-02f, -4.25049290e-02f, -2.08314620e-02f, -2.89165545e-02f, 3.92094105e-02f, 1.77234598e-02f, 2.41612364e-02f, 1.20114028e-01f, 1.86023846e-01f,
  -2.72772443e-02f, -8.70389566e-02f, 7.31070042e-02f, -6.48341626e-02f, -4.42421809e-03f, -2.84845755e-02f, 3.23903300e-02f, 1.80408657e-02f, 6.02813512e-02f, -3.83257051e-03f,
  -2.41707116e-02f, -1.87003296e-02f, 1.53399128e-02f, -6.57596514e-02f, 1.29280752e-02f, 1.15799434e-01f, -4.98967199e-03f, 9.71696898e-03f, -6.70346916e-02f, 3.72623242e-02f,
  -8.77716914e-02f, -4.40239534e-02f, 5.34209907e-02f, -9.08798054e-02f, 7.84698054e-02f, -2.43027005e-02f, 2.30228771e-02f, 5.07257413e-03f, 7.49302953e-02f, 1.12069480e-01f,
  -1.03900902e-01f, -9.82021261e-03f, -1.29852723e-02f, -5.79319112e-02f, 1.23278536e-02f, -1.27753185e-04f, -4.94908914e-02f, 2.06707185e-03f, -5.01239337e-02f, -6.69765994e-02f,
  6.40849676e-03f, 6.56354055e-02f, 2.19027163e-03f, 1.24471225e-02f, -4.16819453e-02f, -1.93052087e-02f, 2.49788724e-02f, -1.31170796e-02f, 3.84518765e-02f, 5.78724071e-02f,
  9.24635604e-02f, 8.49875808e-02f, -6.91907406e-02f, 1.57285593e-02f, -8.58406723e-02f, 5.46690151e-02f, -3.46597396e-02f, 6.01768978e-02f, -5.19955158e-02f, 1.63209811e-01f,
  6.71894476e-02f, -3.38955857e-02f, 5.31100743e-02f, 7.86914527e-02f, 2.94290893e-02f, -6.32125512e-02f, -2.68662035e-01f, -1.16755746e-01f, -1.01965785e-01f, -2.41912007e-02f,
  -4.10107784e-02f, 1.04019947e-01f, 1.17357289e-02f, 8.75452384e-02f, -1.78753585e-01f, -9.17646140e-02f, -2.73398936e-01f, -3.35966162e-02f, 8.67479816e-02f, -4.96372655e-02f,
  -1.35280974e-02f, -6.14667572e-02f, 1.16041291e-03f, 8.16105828e-02f, -7.56928772e-02f, 1.56708717e-01f, -1.00726150e-01f, -2.96461713e-02f, 8.37975740e-02f, -9.68533680e-02f,
  1.14534028e-01f, -1.82210524e-02f, -2.19169334e-02f, 3.34473588e-02f, 7.21349707e-03f, -5.56610860e-02f, 8.29720199e-02f, 4.36833948e-02f, 1.05471201e-01f, 9.90734920e-02f,
  -2.18321942e-03f, 1.71363670e-02f, 3.41066271e-02f, 6.38713986e-02f, -9.12669972e-02f, 1.12700434e-02f, -1.53978737e-02f, -4.35837545e-03f, -4.58691157e-02f, 5.58757223e-02f,
  1.52860209e-02f, -8.95591751e-02f, -4.68426794e-02f, 3.45945880e-02f, -4.99324501e-02f, 6.55172020e-02f, -5.71370646e-02f, 2.72804089e-02f, 4.30618301e-02f, 3.72697674e-02f,
  -3.68795767e-02f, 9.49332397e-03f, 2.01145746e-02f, 6.01924919e-02f, -3.28413211e-02f, 1.90369282e-02f, -1.83234215e-02f, 3.19592357e-02f, -1.96824428e-02f, -1.12125158e-01f,
  -6.16347082e-02f, -1.49376476e-02f, -1.20909996e-02f, -5.80089800e-02f, 9.96780619e-02f, -2.60425191e-02f, -6.78951889e-02f, 4.47396003e-02f, 2.63423026e-02f, 3.75807472e-02f,
  -2.11534910e-02f, -4.68682274e-02f, -1.40796388e-02f, -6.70069605e-02f, 4.01906557e-02f, -1.52553841e-02f, -5.57845496e-02f, 5.77715598e-02f, -7.26304427e-02f, 1.07539989e-01f,
  1.17222756e-01f, 6.56412169e-02f, -9.71949250e-02f, -6.33648857e-02f, -7.24854469e-02f, -3.18252854e-02f, -1.85425878e-02f, -3.88283730e-02f, 1.30042791e-01f, 7.68153742e-02f,
  8.57262686e-02f, -2.82655153e-02f, -2.78405170e-03f, -3.15197967e-02f, -1.63365586e-03f, -2.50468682e-02f, -9.61744189e-02f, 5.50011955e-02f, -5.69281504e-02f, -7.86608160e-02f,
  -6.94384947e-02f, -8.82817730e-02f, 5.12309447e-02f, -1.41072661e-01f, -6.88508302e-02f, -2.52075568e-02f, -9.11635384e-02f, -8.01827759e-02f, -2.82354839e-02f, 2.91262865e-02f,
  -2.21101381e-02f, 1.43292770e-01f, 1.16900049e-01f, -1.40389264e-01f, 2.39907295e-01f, 7.03829676e-02f, 2.73718715e-01f, 1.29787415e-01f, -6.59527304e-03f, 1.55989274e-01f,
  1.29451931e-01f, -2.01152489e-01f, -1.34120956e-01f, -1.34852156e-01f, -9.76553839e-03f, 5.52599840e-02f, 8.09871852e-02f, -1.06821083e-01f, -1.92987487e-01f, 9.40256640e-02f,
  -2.21082624e-02f, -8.78011808e-03f, -9.35842469e-02f, -7.29335919e-02f, 3.38003561e-02f, -9.80290994e-02f, 3.78302708e-02f, 8.66418853e-02f, 5.10212453e-03f, 1.86354145e-02f,
  -1.90146640e-02f, 1.78000420e-01f, -7.12023079e-02f, -1.02088168e-01f, 6.34923428e-02f, 5.69608323e-02f, -7.60167614e-02f, -5.62134497e-02f, -4.85511981e-02f, -4.78130095e-02f,
  -1.69299673e-02f, 3.76494639e-02f, 5.69345318e-02f, 7.74487294e-03f, -2.64025908e-02f, 2.58607753e-02f, 4.83456738e-02f, 8.43804982e-03f, -1.09431162e-01f, 5.00490330e-03f,
  2.66342517e-02f, 2.00863332e-02f, 1.53994694e-01f, 7.18428195e-02f, -5.77350259e-02f, 9.10005532e-03f, -8.66118632e-03f, 5.40711991e-02f, -3.84209789e-02f, 8.23819339e-02f,
  7.93967675e-03f, 2.21085735e-02f, 4.93558161e-02f, 1.34539872e-01f, -1.19871227e-02f, -8.37977156e-02f, -2.96895653e-02f, -2.15199161e-02f, 8.05850029e-02f, -1.39132366e-02f,
  -1.10783786e-01f, 1.43090647e-03f, 4.26001474e-02f, 3.62364226e-03f, 6.55565187e-02f, 4.77846675e-02f, 2.08780803e-02f, 7.12425858e-02f, -1.02875084e-01f, -2.01048441e-02f,
  8.82193912e-03f, 7.62378350e-02f, 2.61795018e-02f, -5.37088141e-03f, 3.40441987e-02f, -1.34798989e-01f, -3.71650644e-02f, -4.27801311e-02f, 5.08854389e-02f, 3.59200239e-02f,
  -6.56669587e-02f, 5.99375665e-02f, 4.76537924e-03f, 2.14187521e-02f, -5.37478849e-02f, -8.34742486e-02f, 4.38508689e-02f, -2.23884396e-02f, -6.01000562e-02f, 7.93694705e-02f,
  7.26458617e-03f, 4.72134575e-02f, -2.58707777e-02f, -2.50423308e-02f, 5.65927178e-02f, -6.68986468e-03f, 4.95252162e-02f, -1.03924692e-01f, -6.23562280e-03f, -5.00330776e-02f,
  8.73666331e-02f, -1.26159526e-02f, -9.93927121e-02f, -9.99595597e-02f, 1.22145284e-02f, -1.24107622e-01f, 2.46230420e-02f, -1.80964582e-02f, -9.11839306e-02f, -8.97763446e-02f,
  -2.18461424e-01f, 3.96481901e-01f, 1.05376787e-01f, -3.91624235e-02f, -5.70318438e-02f, -1.72616377e-01f, 7.85827264e-02f, 2.93369871e-02f, -1.14420615e-01f, 3.86031382e-02f,
  3.29385027e-02f, 4.15147981e-03f, -3.55473091e-03f, 3.66306631e-03f, 6.58573136e-02f, 1.22488596e-01f, 1.10340327e-01f, -8.55955482e-02f, -1.87483877e-01f, -1.17813721e-01f,
  4.70038913e-02f, -2.22811848e-02f, -8.85272212e-03f, -1.04696654e-01f, 1.75607517e-01f, -1.80772603e-01f, -9.86646488e-02f, 1.02123946e-01f, 1.85575970e-02f, 1.60310194e-01f,
  -3.76295894e-02f, 6.87486827e-02f, -1.40290514e-01f, -6.80504516e-02f, 4.80757952e-02f, 5.87884374e-02f, 1.67823490e-02f, -2.04927363e-02f, 8.83824378e-02f, 2.90295575e-02f,
  1.25409201e-01f, 5.49645983e-02f, 6.74028546e-02f, 2.87106987e-02f, 8.72470438e-02f, -1.32195652e-02f, -1.09340157e-02f, 7.29003400e-02f, -6.11928850e-02f, 7.68731087e-02f,
  1.22040845e-01f, -6.22918531e-02f, -3.54141928e-02f, 1.82752870e-02f, -1.31854266e-02f, -6.40120730e-02f, 3.73053253e-02f, 1.16951102e-02f, -3.98497880e-02f, 1.12235755e-01f,
  4.24116738e-02f, -5.41071631e-02f, -1.10610195e-01f, -1.94673252e-03f, 3.32731493e-02f, -2.16238946e-03f, 5.38274050e-02f, -1.53607754e-02f, 1.50202084e-02f, 2.82846037e-02f,
  1.10421879e-02f, -4.36443575e-02f, 4.30669747e-02f, 4.91956100e-02f, -3.49863619e-02f, -9.08519235e-03f, -1.40733679e-03f, 3.34360451e-02f, -1.69383120e-02f, -7.61798024e-03f,
  -1.80649124e-02f, -8.06071684e-02f, -2.28300737e-03f, -5.40642105e-02f, 2.64719408e-02f, 9.94253904e-02f, 7.50914142e-02f, 1.43041946e-02f, 8.70093517e-03f, 7.95484614e-03f,
  -1.20325625e-01f, 2.49985373e-03f, -8.68816525e-02f, -8.64959322e-03f, -8.22121128e-02f, -8.52187425e-02f, -3.19133885e-02f, -5.25957868e-02f, 2.38749441e-02f, 5.93612455e-02f,
  5.02821542e-02f, 3.98690030e-02f, 2.35450882e-02f, -6.91158846e-02f, 2.84505542e-02f, 2.50525232e-02f, 5.64172640e-02f, -9.79212597e-02f, 2.21115462e-02f, -8.19787011e-02f,
  2.56463103e-02f, -1.60357833e-01f, -1.43963143e-01f, -9.47334766e-02f, 8.39398894e-03f, -2.04213485e-01f, -1.72943518e-01f, -6.55956641e-02f, -1.47129148e-01f, -6.49638101e-02f,
  3.37137967e-01f, -1.05348736e-01f, -2.14211568e-02f, 7.02460855e-02f, 6.22542761e-02f, 2.31448129e-01f, 1.27045587e-01f, 1.94358788e-02f, 3.67516391e-02f, -3.15283537e-02f,
  -1.28502063e-02f, -7.10249469e-02f, -9.15548280e-02f, -1.37861148e-01f, 1.06709465e-01f, -5.21910265e-02f, -1.88516174e-02f, -3.96013558e-02f, 9.89077166e-02f, 2.57871374e-02f,
  -4.70741391e-02f, -4.90725264e-02f, 1.08320471e-02f, -1.60236575e-03f, 8.87535885e-03f, -8.43551978e-02f, 2.17661522e-02f, 3.35576311e-02f, 5.19765317e-02f, -1.76317811e-01f,
  4.42610122e-02f, 1.26472369e-01f, -3.55249830e-02f, 5.44339381e-02f, 8.94382149e-02f, -7.88853988e-02f, 3.84457745e-02f, -2.97900569e-02f, 1.00662112e-01f, 1.31333200e-02f,
  -1.68585149e-03f, 1.65133122e-02f, 5.35477400e-02f, 2.63871439e-02f, 4.80067991e-02f, 4.11576405e-02f, -3.00580543e-02f, -3.51221785e-02f, -5.79921119e-02f, -2.40592230e-02f,
  -6.36103600e-02f, 1.12202233e-02f, 1.13874845e-01f, 6.74947351e-02f, -1.95571147e-02f, 6.45100474e-02f, -2.34236941e-02f, -5.55943325e-02f, 5.89719824e-02f, -6.81606606e-02f,
  -2.72503551e-02f, -3.62008400e-02f, 6.17389642e-02f, -1.11900910e-03f, -3.76803451e-03f, -7.55434632e-02f, 6.57780766e-02f, -3.44342291e-02f, -5.70698678e-02f, 1.69200543e-02f,
  7.99007155e-03f, -2.76267827e-02f, -1.50339408e-02f, 6.36849105e-02f, -1.53108230e-02f, 3.31596658e-02f, -6.01149574e-02f, -1.12618757e-02f, -1.15832249e-02f, 1.77648850e-02f,
  -1.80148182e-03f, -4.10852171e-02f, 8.88182446e-02f, -7.20993280e-02f, 8.15192908e-02f, 6.19983561e-02f, -5.44242971e-02f, 1.26614561e-02f, -6.29598126e-02f, -6.05694503e-02f,
  2.21995730e-02f, 1.26163617e-01f, -6.98354840e-02f, -9.04810503e-02f, -1.90824233e-02f, 1.23271737e-02f, -6.27230480e-02f, 3.82566638e-02f, -3.02491523e-02f, 1.07299276e-01f,
  -5.61239291e-03f, -6.97719231e-02f, -2.16851737e-02f, 1.47197396e-02f, -9.82952397e-03f, -4.67762761e-02f, 1.67216901e-02f, 2.63874065e-02f, 3.54702361e-02f, 1.40401786e-02f,
  -1.04504630e-01f, 1.20387375e-01f, 8.22640881e-02f, -9.84293967e-03f, -3.70147377e-02f, 6.84269518e-02f, 6.86457232e-02f, 2.48031858e-02f, 6.42655715e-02f, -3.74806449e-02f,
  -2.37478137e-01f, 6.16878010e-02f, 1.19384220e-02f, 7.26144090e-02f, -6.71628788e-02f, 6.35540336e-02f, -1.87744096e-01f, 9.94990543e-02f, 6.83560148e-02f, 7.41665158e-03f,
  3.86789441e-02f, 9.31909978e-02f, 1.06693827e-01f, 1.15830889e-02f, 5.88024445e-02f, -8.83040354e-02f, -1.58552125e-01f, -6.52582869e-02f, 2.70071365e-02f, 7.78237805e-02f,
  3.83686461e-02f, -1.09753616e-01f, 5.69340773e-02f, 2.23011166e-01f, 1.05075501e-02f, 2.31750146e-01f, -3.53358798e-02f, -4.37901877e-02f, 1.73007295e-01f, -8.18043426e-02f,
  2.26821937e-02f, -1.76026374e-02f, 4.28158902e-02f, -1.94675289e-02f, 5.77462278e-02f, 4.90908213e-02f, 1.09690465e-01f, -4.59486060e-02f, -1.09180741e-01f, -1.24260023e-01f,
  -6.94457591e-02f, -4.09282744e-02f, -5.95943816e-02f, -3.64379771e-02f, -1.23411708e-01f, 5.59748746e-02f, -6.00575395e-02f, -7.84333795e-02f, -9.32734087e-02f, -2.28000917e-02f,
  5.76973669e-02f, -8.48017037e-02f, -1.30185544e-01f, 1.76048391e-02f, 4.36133519e-02f, -8.32104087e-02f, 5.19461581e-04f, -1.06312729e-01f, -7.10117370e-02f, 7.23677054e-02f,
  1.99502315e-02f, -6.58011287e-02f, -5.88773824e-02f, -9.64999869e-02f, -1.44691970e-02f, -3.98796573e-02f, -6.05975762e-02f, -1.53784342e-02f, 3.49624716e-02f, -2.52429321e-02f,
  -3.58536607e-03f, 5.51296324e-02f, 4.36327718e-02f, 4.54348288e-02f, 3.16530862e-03f, 1.96278971e-02f, 7.27837682e-02f, -1.19635575e-02f, 2.99507808e-02f, -7.84346908e-02f,
  -4.33339085e-03f, -5.67265674e-02f, -8.45073629e-03f, 6.11064695e-02f, -1.03053682e-01f, -1.11503424e-02f, -3.18237767e-03f, -1.67978909e-02f, 7.21257478e-02f, -9.54699330e-03f,
  1.44410297e-01f, -7.81650096e-02f, 4.61763069e-02f, -1.17949201e-02f, -2.00337060e-02f, -6.23840243e-02f, -5.68227880e-02f, -6.68563368e-03f, -5.52566648e-02f, 4.14302945e-03f,
  6.41683191e-02f, -1.34392921e-02f, -6.26828223e-02f, -2.43252609e-02f, 1.00031145e-01f, -3.11711300e-02f, -8.84963870e-02f, -4.28222045e-02f, 1.64688583e-02f, -5.40384986e-02f,
  -2.61596162e-02f, 2.48495396e-02f, -1.05845779e-01f, -7.19738156e-02f, -5.05932830e-02f, -5.47788516e-02f, -3.26769724e-02f, 7.12190866e-02f, -1.68353636e-02f, -3.00334627e-03f,
  1.63753942e-01f, 9.96402949e-02f, 2.17394829e-01f, -4.09606583e-02f, -2.22669244e-01f, 1.56193161e-02f, -4.20005880e-02f, 6.35582283e-02f, -1.09945707e-01f, 1.00360140e-01f,
  -1.06999520e-02f, -1.29215240e-01f, -5.63498288e-02f, -1.41324624e-02f, 1.02914691e-01f, 1.07936725e-01f, -1.26611993e-01f, 1.20820105e-01f, 5.31717576e-02f, -1.10433258e-01f,
  -2.14541063e-01f, 4.26262245e-02f, 1.51810318e-01f, 8.33690241e-02f, -8.85775909e-02f, -6.28671795e-02f, 9.04704481e-02f, -5.93222827e-02f, -1.69077590e-02f, -5.97215034e-02f,
  7.87703618e-02f, 4.21411283e-02f, 3.41193005e-02f, 2.23571272e-03f, 1.90877374e-02f, 2.74307188e-02f, -6.20512292e-02f, 3.22901644e-02f, -1.24372467e-01f, 1.29769705e-02f,
  -3.38100605e-02f, -1.04920201e-01f, -5.14208637e-02f, -1.68626141e-02f, 2.18516290e-02f, 4.58250009e-02f, 3.84447537e-02f, 1.13735884e-01f, 9.41881984e-02f, -2.87900120e-02f,
  -6.96857348e-02f, -1.00966915e-01f, 8.42216015e-02f, 1.68514531e-02f, 5.14989011e-02f, 3.66988927e-02f, 4.75284047e-02f, 3.63330357e-02f, 1.10930063e-01f, 9.81699154e-02f,
  7.22216489e-03f, -7.29282349e-02f, 7.65305087e-02f, 4.08814400e-02f, 2.25108839e-03f, -2.25080848e-02f, -1.51138054e-02f, -2.63713188e-02f, 5.29880337e-02f, -2.97838468e-02f,
  -2.00415812e-02f, 2.39230301e-02f, 4.37178910e-02f, -9.57851019e-03f, -5.08683734e-03f, -1.57689955e-02f, -1.12118963e-02f, 3.70771289e-02f, 1.11327663e-01f, 2.92966496e-02f,
  1.14792116e-01f, 6.91465149e-03f, 5.18957824e-02f, -7.72409812e-02f, 6.45346120e-02f, 7.96375051e-02f, 6.86672404e-02f, 8.49709734e-02f, 3.01092900e-02f, 5.62693477e-02f,
  -2.08117682e-02f, -9.93330255e-02f, 2.84048859e-02f, 7.92126656e-02f, -6.47976696e-02f, -4.86792922e-02f, -8.00208189e-03f, 4.42743488e-02f, 2.57926751e-02f, 2.56121103e-02f,
  5.41122891e-02f, 4.91012186e-02f, -2.76187696e-02f, -9.35059693e-03f, 7.12697729e-02f, 1.08974829e-01f, 8.20549726e-02f, 9.28371996e-02f, 1.24792717e-02f, -3.89168970e-03f,
  8.10365081e-02f, -1.57581195e-02f, 1.35065094e-01f, 4.40716296e-02f, 1.35954097e-02f, 1.41905639e-02f, 2.49125045e-02f, 3.57807353e-02f, 5.18507846e-02f, 1.62118033e-01f,
  2.90504903e-01f, -7.88226053e-02f, -1.45811409e-01f, 1.26188397e-01f, 4.48038056e-02f, 9.93829742e-02f, -2.35773418e-02f, -7.62935542e-03f, 2.14141365e-02f, 7.49345752e-04f,
  -4.34668437e-02f, 1.44339381e-02f, 2.22852435e-02f, -1.22449778e-01f, -4.48373929e-02f, 1.00734614e-01f, -6.05399497e-02f, -7.44323954e-02f, 4.88937236e-02f, 3.59478742e-02f,
  -1.05190866e-01f, 7.06976652e-02f, 1.40400067e-01f, 3.90658230e-02f, -1.06094033e-01f, -1.23690061e-01f, -3.87949683e-02f, -9.40270908e-03f, -6.79187179e-02f, -1.04900524e-01f,
  -1.57061413e-01f, 7.69564509e-03f, -1.39368419e-02f, 1.07042259e-03f, -7.73835555e-02f, -3.70978601e-02f, -7.28146639e-03f, -2.75262799e-02f, 7.72642996e-03f, -6.39113635e-02f,
  -2.17168368e-02f, -6.28922060e-02f, -5.19434512e-02f, 8.33297614e-03f, 1.57459863e-02f, 6.02595732e-02f, 1.25071213e-01f, -4.39080223e-02f, -8.23838785e-02f, 4.07983512e-02f,
  7.00045750e-02f, 6.84290826e-02f, -5.40615059e-02f, -2.20781229e-02f, -7.16342777e-02f, 5.76099381e-02f, -4.35113497e-02f, -2.81927940e-02f, -3.01062632e-02f, 3.61894234e-03f,
  -5.54691441e-02f, 9.71158221e-03f, 5.15345670e-02f, -4.53273840e-02f, 1.10667698e-01f, -1.66933201e-02f, -4.15079556e-02f, -1.01046093e-01f, 1.16030723e-02f, -1.05329882e-02f,
  -5.86552583e-02f, 6.21848740e-02f, 4.83055487e-02f, 8.78130272e-02f, -9.98051837e-02f, -2.27390765e-03f, 1.10767065e-02f, -3.58659662e-02f, -6.71930984e-02f, -1.85797289e-02f,
  -4.44057118e-03f, -4.48671691e-02f, 7.77703077e-02f, -3.07014696e-02f, 1.95165481e-02f, -1.04849404e-02f, -6.05982430e-02f, -1.51762348e-02f, 6.16090186e-02f, 4.13649306e-02f,
  -9.24562104e-03f, -6.49036616e-02f, -6.63535595e-02f, -4.36328910e-02f, 1.02001823e-01f, -2.09422037e-02f, 5.21042794e-02f, -4.44684252e-02f, 6.32934645e-02f, -6.37697056e-02f,
  2.53562890e-02f, -1.08032286e-01f, -7.84607753e-02f, 9.20443982e-02f, 2.10822877e-02f, -6.45740479e-02f, 2.18798891e-02f, -6.76529529e-03f, 5.03373519e-02f, -1.20347729e-02f,
  2.78500076e-02f, -5.56653142e-02f, -2.26009861e-02f, 6.21067621e-02f, -1.04400888e-01f, 1.79757141e-02f, -1.29916251e-01f, -1.06013164e-01f, -4.90834825e-02f, -4.13390662e-04f,
  3.81228745e-01f, -1.84646189e-01f, 2.80128330e-01f, -3.84470336e-02f, -3.79198417e-02f, -5.92365935e-02f, 1.13678001e-01f, 1.98658705e-02f, -1.23239540e-01f, -3.73629071e-02f,
  -5.49459830e-02f, -3.63135375e-02f, 9.34178233e-02f, -1.24226948e-02f, 2.47681946e-01f, 1.68143749e-01f, 2.00586319e-01f, 2.61100024e-01f, 2.60196984e-01f, 7.57698417e-02f,
  -3.57414931e-02f, -1.63031582e-04f, 1.11052990e-01f, -1.72415364e-03f, -1.13967367e-01f, -3.82618769e-03f, 4.71416023e-03f, 1.00334091e-02f, 2.10833829e-02f, -5.70288524e-02f,
  1.21282883e-01f, 2.18176581e-02f, 3.97089534e-02f, -1.61709622e-01f, -1.76782999e-02f, -6.20461665e-02f, -5.96238114e-02f, 9.33081806e-02f, 6.77112839e-04f, 5.32526635e-02f,
  -3.12126819e-02f, -4.46415395e-02f, 8.13368559e-02f, -5.34252152e-02f, -4.89035761e-03f, -1.25530257e-03f, -6.67052791e-02f, 1.77492976e-01f, -8.00674260e-02f, -1.50332022e-02f,
  -8.36625695e-02f, -1.86457355e-02f, 5.27822832e-03f, -1.03932945e-02f, 3.64996381e-02f, 1.03974463e-02f, -1.24361672e-01f, -1.06460415e-02f, 2.23534629e-02f, -9.24188569e-02f,
  -1.50319738e-02f, 9.11048427e-02f, -3.21018435e-02f, 1.92569457e-02f, -3.09683215e-02f, 1.85388196e-02f, 2.99353004e-02f, 4.88012284e-02f, -8.59165192e-03f, 4.56217490e-03f,
  -5.22386767e-02f, 2.21139733e-02f, 1.38694029e-02f, -9.56718251e-03f, -7.12219393e-03f, -2.84963157e-02f, -1.60467662e-02f, -6.07647710e-02f, -6.45219237e-02f, 5.42167686e-02f,
  9.64452419e-03f, 8.28198642e-02f, -4.77816444e-03f, 8.06468427e-02f, -1.65314097e-02f, -1.76864993e-02f, -3.76208127e-02f, 1.31772005e-03f, 8.89269486e-02f, 4.39261682e-02f,
  -5.98834734e-03f, 4.53951843e-02f, -7.04648122e-02f, 5.73740825e-02f, -4.27605910e-03f, -2.21827850e-02f, -9.79468971e-02f, -6.92472607e-02f, -6.20147921e-02f, 2.55045872e-02f,
  1.41830016e-02f, 5.21774814e-02f, -9.42364782e-02f, -1.20537612e-03f, 3.89180630e-02f, -6.47908589e-03f, -1.17997177e-01f, -1.52168544e-02f, -1.69218238e-02f, -2.15396397e-02f,
  -5.53847887e-02f, -5.46792941e-03f, -9.34439078e-02f, -2.22743936e-02f, -1.15129529e-02f, 1.57890357e-02f, 3.06810532e-03f, -8.65658280e-03f, 2.93025584e-03f, -1.97847843e-01f,
  3.99704929e-03f, -4.82824072e-03f, 1.03513777e-01f, 1.24162167e-01f, 5.18634655e-02f, -9.70844626e-02f, -9.54201296e-02f, -1.70217887e-01f, 3.48558873e-02f, -3.07133850e-02f,
  -1.09413564e-01f, -1.16822161e-02f, 2.21724082e-02f, -6.13827370e-02f, 6.94161952e-02f, 4.29286510e-02f, 2.68829077e-01f, 3.08763273e-02f, 7.72075132e-02f, -7.31608272e-02f,
  1.35983871e-02f, 1.71323687e-01f, 1.46730825e-01f, 1.20329224e-01f, 1.09964862e-01f, -3.47726122e-02f, -1.91822629e-02f, 1.61184579e-01f, 2.13856553e-03f, 1.88595220e-01f,
  1.64168812e-02f, -1.02613717e-01f, 7.79209137e-02f, 7.08471388e-02f, -3.34590371e-03f, -2.54402049e-02f, -1.25241410e-02f, 6.51678815e-02f, 6.00991175e-02f, -5.43234572e-02f,
  -6.24471903e-02f, -5.30428858e-03f, -1.21565066e-01f, -9.62419510e-02f, 3.53670456e-02f, 2.02377569e-02f, 5.69181740e-02f, -8.78805816e-02f, -5.16679995e-02f, -1.22611411e-01f,
  -3.15376818e-02f, -1.94208939e-02f, -2.03524213e-02f, -1.22398086e-01f, -7.94078503e-03f, -4.41675112e-02f, -3.07938904e-02f, -6.87955841e-02f, 3.16792503e-02f, 2.63896193e-02f,
  2.20539933e-03f, 5.70594743e-02f, 4.72912425e-03f, 4.37353589e-02f, -2.22027805e-02f, -9.17595811e-03f, 4.01744135e-02f, 1.78691614e-02f, -6.22370131e-02f, 2.88386755e-02f,
  -6.40941784e-02f, 4.19583172e-02f, -1.61859810e-01f, -3.64820519e-03f, 2.48363819e-02f, -5.74257299e-02f, -5.56452619e-03f, -2.97482293e-02f, 2.29947455e-02f, -4.85319495e-02f,
  7.09842294e-02f, -9.71245468e-02f, 1.11282259e-01f, -9.46380757e-03f, -6.16769753e-02f, -6.79049492e-02f, -6.74855188e-02f, 1.24844313e-02f, -6.66515529e-02f, 1.97604131e-02f,
  -1.56038282e-02f, -1.87932953e-01f, -7.54208788e-02f, 8.25040489e-02f, -2.94900462e-02f, 1.59329139e-02f, 1.46335866e-02f, 1.88063160e-02f, 1.98944230e-02f, -6.94378912e-02f,
  -4.62663062e-02f, -5.13718538e-02f, -8.17093775e-02f, 6.03040168e-03f, 3.81090529e-02f, 1.64854955e-02f, 5.31687178e-02f, -2.39181388e-02f, -1.27737835e-01f, 5.45031577e-02f,
  -5.55200018e-02f, 3.66510414e-02f, 2.81948186e-02f, -5.36860861e-02f, -3.30563560e-02f, 6.63149282e-02f, -7.46657476e-02f, 2.26862151e-02f, 4.97098453e-02f, -6.40166178e-02f,
  -1.27021130e-02f, -1.98220760e-01f, -1.99134305e-01f, -5.82968183e-02f, 4.22172472e-02f, 1.68781832e-01f, 1.70610584e-02f, 8.91264603e-02f, 7.91317225e-02f, 9.21997353e-02f,
  1.10838786e-01f, 7.55764097e-02f, 2.66518798e-02f, -5.20854220e-02f, 8.54256738e-04f, 9.89158973e-02f, 3.16621214e-02f, -9.07386020e-02f, 2.66225431e-02f, 9.80062336e-02f,
  1.36226684e-01f, 3.34506817e-02f, -1.15720719e-01f, 7.97226727e-02f, 8.18690583e-02f, 8.69796500e-02f, -9.20566544e-02f, -4.44986597e-02f, -7.08486810e-02f, -1.25107244e-01f,
  -3.81068774e-02f, -1.26940921e-01f, 8.70011523e-02f, 1.26941979e-01f, 2.81020496e-02f, 3.97155993e-02f, 6.37682378e-02f, -8.82858709e-02f, 5.94555363e-02f, -8.96512643e-02f,
  9.51648802e-02f, -7.65182152e-02f, 8.05971473e-02f, -6.23702407e-02f, 2.38462836e-02f, -5.27911223e-02f, -8.52580555e-03f, -1.21672764e-01f, -8.41618925e-02f, 2.90670176e-03f,
  1.55032156e-02f, 9.58331153e-02f, -4.05970290e-02f, -2.62513310e-02f, 3.63641307e-02f, -5.43387011e-02f, -4.66716178e-02f, 1.49053652e-02f, -8.03909451e-02f, -1.07598141e-01f,
  -5.70320105e-03f, -4.38866541e-02f, -3.51691130e-03f, -1.07319750e-01f, -5.64867631e-02f, 1.32212117e-01f, 9.04735476e-02f, 2.70045046e-02f, 4.48697098e-02f, -5.93462363e-02f,
  -7.14297779e-03f, 7.93733075e-02f, 9.89648234e-03f, 2.09699501e-03f, 2.31004693e-02f, -3.88519056e-02f, 8.51862580e-02f, 6.15702905e-02f, -5.48235793e-03f, -4.03626487e-02f,
  -7.21188486e-02f, 1.73215233e-02f, -1.77639667e-02f, -2.05845665e-02f, 6.47676289e-02f, -2.77645588e-02f, 4.49305512e-02f, -6.95614470e-03f, 3.20628881e-02f, 3.74670327e-02f,
  -1.80199239e-02f, 9.92270410e-02f, 2.60208715e-02f, 7.02038631e-02f, -8.40301216e-02f, -2.77339760e-03f, -1.05407042e-02f, -3.23951505e-02f, -8.29315977e-04f, -7.95998648e-02f,
  4.69768420e-02f, -6.03837939e-03f, -6.27833530e-02f, -3.13103944e-02f, 9.47229341e-02f, -5.16934730e-02f, -4.85157482e-02f, 1.49803637e-02f, 3.19812857e-02f, -1.33021660e-02f,
  3.66649292e-02f, 3.36714946e-02f, -1.28964588e-01f, 1.83842722e-02f, 5.17432541e-02f, 4.86189574e-02f, -6.82903046e-04f, -8.04154202e-02f, 1.18263522e-02f, -8.22216719e-02f,
  9.42457244e-02f, -1.65819913e-01f, 1.44395754e-01f, 1.29854456e-01f, 3.37734222e-02f, 1.24664428e-02f, 8.03680941e-02f, 8.31358582e-02f, 5.11245653e-02f, -5.25428392e-02f,
  -3.72899771e-02f, 8.30716491e-02f, 2.11673346e-03f, 5.17643467e-02f, 2.90706735e-02f, -1.88289471e-02f, -1.05669856e-01f, 2.74487454e-02f, 1.87811330e-01f, 1.91763699e-01f,
  -1.15792006e-01f, 3.17309089e-02f, 4.81471047e-03f, 2.40966491e-02f, -1.03918903e-01f, 4.60534282e-02f, -1.21485770e-01f, -8.70667696e-02f, -1.19110882e-01f, -3.60593885e-01f,
  -1.18219621e-01f, 1.37736099e-02f, 1.09188199e-01f, 3.88241373e-02f, -6.99832737e-02f, -2.49976963e-02f, 2.98130810e-02f, 6.35071918e-02f, 2.09454708e-02f, -4.95005287e-02f,
  2.50472594e-02f, -2.63385335e-03f, 5.96674234e-02f, -7.00076222e-02f, -4.15343009e-02f, -2.27487069e-02f, 3.74863334e-02f, 8.83802697e-02f, 2.98373476e-02f, -2.18082815e-02f,
  4.41452414e-02f, 2.49729510e-02f, 3.39508951e-02f, -2.51933951e-02f, 1.00603523e-02f, 1.04715697e-01f, -1.10598177e-01f, -1.05004318e-01f, -1.56445727e-02f, -7.74078593e-02f,
  -2.33857743e-02f, 6.86669722e-02f, 4.63090278e-02f, 8.99271294e-03f, 7.91903660e-02f, 1.16128884e-02f, 2.13728733e-02f, -2.74775866e-02f, -2.27992218e-02f, 9.70825106e-02f,
  -7.91765191e-03f, -2.79313996e-02f, -3.22565623e-02f, -6.17785193e-02f, -4.14845906e-02f, -7.54719302e-02f, -1.00882776e-01f, 2.95306556e-03f, 1.66578330e-02f, -3.17418911e-02f,
  -4.66969237e-02f, 5.26879281e-02f, 2.24966891e-02f, -7.29378015e-02f, -4.71912660e-02f, -3.72130089e-02f, 2.75049359e-02f, 6.21492267e-02f, 8.18543807e-02f, 1.56051107e-02f,
  -1.03958838e-01f, 1.38636762e-02f, -7.90006369e-02f, 9.58230905e-03f, -6.07780665e-02f, -6.29602894e-02f, 4.15902101e-02f, -9.16994214e-02f, -3.82958017e-02f, -2.39119753e-02f,
  -2.41756719e-03f, 6.97462559e-02f, 4.01057750e-02f, 3.41778919e-02f, 2.46441346e-02f, 3.71649303e-02f, -1.69419649e-03f, 1.54504424e-03f, -6.46127164e-02f, -8.44089687e-02f,
  -5.17023057e-02f, -1.89807434e-02f, 9.54372361e-02f, 4.76133600e-02f, -7.31026148e-03f, 2.99371760e-02f, 2.82627475e-02f, 5.59357740e-02f, -3.33498418e-02f, -3.28185223e-02f,
  2.96224982e-01f, -1.75732207e-02f, 4.87423576e-02f, 7.90859945e-03f, -1.77938059e-01f, -3.09932581e-03f, -3.11392779e-03f, 5.05739124e-03f, -3.87672111e-02f, 5.12675159e-02f,
  -2.46091746e-02f, -1.35168001e-01f, -1.68228205e-02f, -1.81819037e-01f, -8.69477838e-02f, -5.83409965e-02f, 1.67192034e-02f, 3.38647552e-02f, 5.23002334e-02f, -1.69148043e-01f,
  -1.46403581e-01f, -2.55261399e-02f, 8.04056041e-03f, 2.82982476e-02f, -8.14148039e-02f, -6.92578852e-02f, 1.08493544e-01f, -9.15540010e-02f, -3.88959912e-03f, -9.86841768e-02f,
  8.83703902e-02f, -1.97685361e-02f, -7.84548819e-02f, -4.68973443e-02f, -9.71532166e-02f, 9.46309268e-02f, 2.05067769e-02f, -7.94439111e-03f, -7.17137158e-02f, -4.35169823e-02f,
  -1.09233700e-01f, 6.46392256e-02f, -3.76564041e-02f, 3.14211696e-02f, 8.61104876e-02f, 2.29297187e-02f, -1.43766645e-02f, 1.58908349e-02f, 6.15036627e-03f, 6.11808561e-02f,
  -9.64544937e-02f, 3.14484164e-02f, -1.03124909e-01f, 5.14808856e-02f, 1.87466778e-02f, 7.42984004e-03f, -8.88304263e-02f, -1.06776230e-01f, 3.44452299e-02f, 4.98948134e-02f,
  5.65872602e-02f, 5.29464781e-02f, -9.62896273e-02f, 5.59516326e-02f, 2.83092856e-02f, -8.51655472e-03f, 3.53439897e-02f, 3.90252359e-02f, 7.83696771e-02f, 7.66417990e-03f,
  -6.12185970e-02f, 3.80325206e-02f, 5.04772644e-03f, 2.33736895e-02f, -6.44323751e-02f, 2.50280090e-02f, -1.84106622e-02f, 5.95785230e-02f, 3.80927362e-02f, -5.93623891e-02f,
  -7.17234239e-02f, 5.46443136e-03f, -3.52997072e-02f, -5.84715903e-02f, -3.26770656e-02f, 1.52967367e-02f, 4.33576629e-02f, 6.45837607e-03f, 2.96500809e-02f, -4.30857167e-02f,
  -6.71986490e-02f, -5.58936298e-02f, 2.19503362e-02f, -6.02938235e-02f, -7.28601962e-02f, 1.96818612e-03f, -1.62636917e-02f, 4.59330194e-02f, -4.27004993e-02f, 2.33843774e-02f,
  4.26061172e-03f, 4.42401357e-02f, -6.68224469e-02f, -1.79773718e-02f, 2.95553561e-02f, 5.79227135e-02f, 2.04639509e-02f, 6.71683624e-02f, -2.63791885e-02f, 4.39398596e-03f,
  -8.11116397e-02f, 5.22722937e-02f, 2.62839515e-02f, 6.68107495e-02f, -9.25711542e-03f, -1.23873234e-01f, -8.31956193e-02f, 1.13562383e-02f, 1.93597563e-02f, 4.26257066e-02f,
  -7.10373372e-02f, -7.45681077e-02f, 1.85699135e-01f, 3.43860351e-02f, -8.92377570e-02f, 9.29422602e-02f, 3.85082364e-02f, 1.69368237e-02f, -3.75030078e-02f, -4.33448888e-02f,
  -8.84448737e-02f, 4.00556587e-02f, -1.48695963e-03f, -1.21921708e-03f, 8.57484490e-02f, -6.48469925e-02f, 3.23928148e-02f, 6.08157017e-04f, 1.26422599e-01f, 1.30806312e-01f,
  -5.29287308e-02f, -7.42597207e-02f, -1.80583093e-02f, -2.53866762e-02f, -1.68662325e-01f, 1.34467809e-02f, -1.05740856e-02f, -9.05870050e-02f, 7.48319551e-02f, -1.60865277e-01f,
  4.45201099e-02f, 7.20324144e-02f, 2.35857219e-01f, -3.33335884e-02f, 4.70480733e-02f, 1.43955890e-02f, -6.17019571e-02f, 1.10591672e-01f, -1.59462970e-02f, 1.99926849e-02f,
  2.80552618e-02f, 5.87820001e-02f, -8.97277426e-03f, 6.41290173e-02f, -1.30084828e-02f, -8.72456701e-04f, -3.82772163e-02f, 5.92453852e-02f, 1.11018859e-01f, -5.16876243e-02f,
  -6.15888275e-02f, -9.22604054e-02f, -2.75762919e-02f, 2.20334604e-02f, -4.53685457e-03f, -4.72977720e-02f, 4.05414402e-02f, -1.15572661e-03f, -1.85088534e-02f, 2.71597155e-03f,
  1.01881906e-01f, -1.49099957e-02f, -8.01465586e-02f, 9.01843756e-02f, -6.29816875e-02f, -2.92189959e-02f, 7.46942163e-02f, 6.35460066e-03f, -4.69085807e-03f, -1.31943047e-01f,
  -5.39921038e-02f, -1.19942809e-02f, -6.75928891e-02f, -5.18887639e-02f, 1.36034057e-01f, -3.57830003e-02f, 1.04106531e-01f, 7.57395662e-03f, -4.42974605e-02f, -1.83260217e-02f,
  6.31806701e-02f, -4.47791405e-02f, -5.72587624e-02f, -1.11901708e-01f, 5.22525087e-02f, 5.02642542e-02f, -2.91276686e-02f, -8.58849958e-02f, -3.65543319e-03f, 2.40066051e-02f,
  -8.13981220e-02f, 6.45102784e-02f, 6.56358674e-02f, -4.66331951e-02f, 1.09685168e-01f, 1.46341836e-02f, 6.49706693e-03f, 8.60531405e-02f, 7.04773366e-02f, 3.43560949e-02f,
  4.40022722e-02f, 2.62744203e-02f, 2.05548611e-02f, -9.65235531e-02f, 4.44049574e-02f, 1.28662931e-02f, 7.98214041e-03f, 1.36089930e-02f, 1.14870578e-01f, -3.92888375e-02f,
  -5.96325099e-02f, -2.39423979e-02f, -4.09246348e-02f, 2.31171958e-02f, -5.04765809e-02f, 9.87325385e-02f, 2.98683755e-02f, 1.22294649e-01f, 2.10496727e-02f, 1.35224402e-01f,
  5.67326844e-01f, -5.26432246e-02f, -1.98520914e-01f, 5.38751900e-01f, 1.42815694e-01f, -1.37289271e-01f, -1.26480058e-01f, -1.07207678e-01f, 1.29619524e-01f, 8.19632336e-02f,
  2.66087204e-02f, 1.53681770e-01f, 4.82654795e-02f, -4.72321659e-02f, -7.28825331e-02f, -6.29374310e-02f, 1.08782165e-01f, 1.79718181e-01f, 3.14295255e-02f, 1.92919914e-02f,
  -2.73831319e-02f, 4.13010389e-01f, 3.03570896e-01f, 2.81677339e-02f, 6.57772273e-02f, -4.93507236e-02f, 4.84317318e-02f, -1.23955561e-02f, -2.30238307e-02f, 3.28761518e-01f,
  -1.38368187e-02f, 1.84590518e-02f, 4.92845848e-02f, 8.78731068e-03f, -1.08709268e-03f, 4.45057824e-02f, -5.30041978e-02f, 2.11838931e-02f, -4.36919183e-02f, -5.45749329e-02f,
  1.03194892e-01f, -3.98521498e-02f, 1.17534302e-01f, 5.36202416e-02f, 5.34389317e-02f, -7.28242472e-02f, 4.64832075e-02f, -5.33514991e-02f, -1.64501630e-02f, -6.49605393e-02f,
  1.19481692e-02f, 6.25457242e-02f, 1.71291027e-02f, -4.23507094e-02f, -1.74491420e-01f, 1.60011455e-01f, 6.90235570e-03f, -1.39456615e-01f, -6.32369220e-02f, 4.80457917e-02f,
  3.07396222e-02f, -9.16916877e-02f, -5.24798334e-02f, 3.27404179e-02f, 6.23619929e-02f, -2.79738121e-02f, -2.29278412e-02f, 6.34410456e-02f, -1.41661186e-02f, 1.98356025e-02f,
  -3.98616642e-02f, -1.04734898e-02f, 3.13616395e-02f, -1.82985682e-02f, 4.67538759e-02f, -3.29772793e-02f, 5.25112264e-03f, 4.34241518e-02f, 2.93205436e-02f, 3.29117104e-02f,
  3.83382887e-02f, -1.04024582e-01f, 8.21049213e-02f, -9.77959707e-02f, -1.89854600e-03f, 4.01450805e-02f, 3.69177340e-03f, -4.74715680e-02f, 1.62146688e-02f, -1.60574075e-02f,
  8.36322978e-02f, -5.31547628e-02f, 1.34659991e-01f, -1.68499555e-02f, 5.53182922e-02f, -4.30931933e-02f, 4.97897938e-02f, -1.29372105e-01f, 4.77421321e-02f, 4.15850691e-02f,
  -2.88873799e-02f, 1.86325852e-02f, 3.48495767e-02f, -1.04408845e-01f, 6.32235967e-03f, 1.40154408e-03f, 4.72629182e-02f, 7.89429173e-02f, -2.53980849e-02f, -1.06484100e-01f,
  -9.53772292e-02f, -1.28514590e-02f, 1.68059975e-01f, -2.97125354e-02f, -1.10039031e-02f, 1.35579035e-01f, -7.93608502e-02f, -4.49221879e-02f, -1.14195086e-01f, -1.18488610e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.65635243e-02f, 8.53553116e-02f, -9.83149931e-02f, 4.29068170e-02f, 7.84584507e-03f, -2.16997173e-02f, -4.06129397e-02f, 6.10044412e-02f, -7.62586668e-02f, -4.52934168e-02f,
  2.26184875e-02f, -4.27484065e-02f, -9.30982530e-02f, -1.68699082e-02f, -1.39799014e-01f, -1.12316474e-01f, -8.08184519e-02f, -1.66373879e-01f, -1.21671997e-01f, 3.67319435e-02f,
  5.90832308e-02f, 4.71301787e-02f, 6.31747544e-02f, 4.45395522e-02f, 3.06188483e-02f, -2.10811440e-02f, -3.47117870e-03f, 4.25569601e-02f, 4.52271327e-02f, -8.26287419e-02f,
  -6.52537420e-02f, 1.02887578e-01f, -7.45373359e-03f, -5.21979257e-02f, -2.66462867e-03f, -1.87299624e-02f, -9.76293162e-03f, -6.22451641e-02f, 5.19416444e-02f, -7.01624481e-03f,
  1.26579115e-02f, 4.39605936e-02f, -9.21473876e-02f, 9.94251948e-03f, -5.68759702e-02f, 6.79707676e-02f, -1.13419071e-02f, -7.52635598e-02f, -1.90042034e-02f, 8.19354206e-02f,
  -1.76318642e-02f, 5.64050302e-02f, -1.40781766e-02f, 5.35629643e-03f, -1.60235167e-02f, -9.28588435e-02f, -4.68818704e-03f, 5.94626777e-02f, 8.01319256e-02f, 1.39681652e-01f,
  -9.96845216e-03f, 6.33677766e-02f, -2.88488325e-02f, 9.52487439e-03f, -3.25645953e-02f, -8.72994214e-02f, -6.76471964e-02f, -4.42108102e-02f, -2.18216535e-02f, -8.20373073e-02f,
  2.09930781e-02f, 3.18278819e-02f, 1.71809625e-02f, 1.73180178e-02f, 5.25288656e-02f, 2.01375615e-02f, 4.57820296e-03f, 7.73681626e-02f, -1.59779843e-02f, 1.39089557e-03f,
  -1.81097705e-02f, 4.00736220e-02f, -5.02923550e-03f, -2.12650690e-02f, 6.29257932e-02f, 1.97872128e-02f, 1.65977459e-02f, -6.40395358e-02f, -3.27654891e-02f, 4.20331918e-02f,
  -2.47813091e-02f, -7.62184486e-02f, -8.63767192e-02f, 2.69842520e-02f, 5.89168519e-02f, 1.02082537e-02f, -3.83822359e-02f, -8.55548773e-03f, -6.73989058e-02f, 4.45848219e-02f,
  6.63027912e-02f, -6.76579550e-02f, 6.50669932e-02f, 1.71916280e-02f, -6.06368901e-03f, -5.78188151e-02f, 5.48097305e-02f, 8.67859349e-02f, -3.72411944e-02f, -2.10676305e-02f,
  1.14690326e-02f, -4.04527597e-03f, 3.21445242e-02f, 3.86238284e-02f, -2.08923668e-02f, -7.08353370e-02f, -3.16149667e-02f, 1.22458667e-01f, 5.73485717e-02f, 1.25879601e-01f,
  2.68644281e-03f, 2.49566026e-02f, 1.62748955e-02f, -4.38884385e-02f, -4.18156609e-02f, -1.60100803e-01f, -5.50808832e-02f, -1.28138855e-01f, -2.35247463e-02f, -1.95400175e-02f,
  -4.02228460e-02f, 3.20443548e-02f, 5.66130653e-02f, 4.12833132e-02f, -5.44580072e-03f, 1.22234700e-02f, -5.40202484e-02f, 1.27890371e-02f, 8.66245711e-04f, -7.58121982e-02f,
  -1.00247767e-02f, 3.39682214e-02f, 6.08141609e-02f, 9.71271396e-02f, 7.55825713e-02f, 1.61927640e-02f, 4.66967486e-02f, 4.52016257e-02f, 3.48155089e-02f, 4.82563563e-02f,
  1.62424613e-02f, 4.11462523e-02f, 4.26572300e-02f, 2.23184880e-02f, -2.96438728e-02f, -6.64771944e-02f, -2.04135515e-02f, 4.61095721e-02f, -1.43328228e-03f, -4.08187583e-02f,
  -1.55692024e-03f, -4.44911830e-02f, -4.92221415e-02f, 1.57126989e-02f, 3.92140858e-02f, -8.63205735e-03f, -4.18940932e-02f, 8.06871355e-02f, 3.87740545e-02f, -7.99171925e-02f,
  9.09586903e-03f, -7.81291127e-02f, 5.15839532e-02f, 8.73814151e-03f, -6.34720474e-02f, 5.87792955e-02f, -4.40928945e-03f, 4.59784083e-02f, 5.58972498e-03f, -4.98531014e-02f,
  7.15660825e-02f, -5.65113164e-02f, 1.10328197e-02f, -2.36485135e-02f, -5.59497736e-02f, 6.54041544e-02f, -8.51854384e-02f, 5.60442321e-02f, 2.40409728e-02f, -4.32779342e-02f,
  3.77375074e-02f, -3.58857326e-02f, 4.26916555e-02f, 7.41058812e-02f, 2.81103998e-02f, -5.65087385e-02f, 4.07889187e-02f, 2.66478341e-02f, -5.65380678e-02f, -3.69575471e-02f,
  1.97644383e-02f, -1.37002710e-02f, 7.39675462e-02f, -2.09475439e-02f, -8.57474729e-02f, -5.41329123e-02f, -5.30891344e-02f, -6.06437176e-02f, -2.73872819e-02f, 5.44114411e-02f,
  -8.37131124e-03f, 1.18895419e-01f, 7.78447166e-02f, 2.93763932e-02f, 5.31565882e-02f, -1.87434182e-02f, -9.51042101e-02f, -1.58368815e-02f, -7.17665777e-02f, 2.86769457e-02f,
  -9.77046490e-02f, 1.22930193e-02f, -8.09594542e-02f, 6.82678148e-02f, -4.09044735e-02f, -9.21489298e-02f, -7.29535818e-02f, 7.74848238e-02f, -8.05134103e-02f, -5.64183667e-02f,
  -2.35322248e-02f, 6.58563375e-02f, -2.47779011e-04f, -1.04659900e-01f, -2.85601467e-02f, 1.35939922e-02f, -9.64429453e-02f, -5.51490951e-03f, 2.26619728e-02f, -9.42553580e-02f,
  1.69321373e-01f, -1.95615232e-01f, 1.15480146e-03f, 4.84926850e-02f, -8.26100484e-02f, -2.91580074e-02f, -6.88639954e-02f, -7.17698485e-02f, 6.10283874e-02f, 2.81556370e-03f,
  -2.70630475e-02f, 1.18898325e-01f, 9.60926190e-02f, 8.30261931e-02f, 2.98590809e-02f, -3.61663550e-02f, 1.33712962e-02f, 1.20962188e-01f, 6.79008104e-03f, 9.45081860e-02f,
  -8.20112079e-02f, 1.79995853e-03f, 1.23878516e-01f, 8.13455656e-02f, 3.28465104e-02f, 6.47757426e-02f, 6.85553774e-02f, -6.01174086e-02f, -1.55077241e-02f, -8.08454007e-02f,
  -4.65420522e-02f, -4.77545373e-02f, 1.38183460e-02f, -1.30197955e-02f, -5.36903329e-02f, -4.26743887e-02f, 1.09883342e-02f, 7.11399838e-02f, -4.50206846e-02f, -4.22130525e-02f,
  -3.99579853e-02f, -5.70650771e-02f, -3.65430606e-03f, -2.89857443e-02f, -5.46190925e-02f, -1.82503574e-02f, 2.72032935e-02f, 3.90834466e-04f, 1.01455361e-01f, -1.05185300e-01f,
  -6.35898635e-02f, 1.75454412e-02f, 3.17962058e-02f, -6.32809550e-02f, -9.41545144e-03f, 6.03704713e-02f, -2.32230574e-02f, -2.85575334e-02f, 8.09727423e-03f, -3.34868170e-02f,
  3.93796759e-03f, 1.03339270e-01f, 9.68605131e-02f, 4.51789275e-02f, 1.98640712e-02f, -2.69660056e-02f, -8.31849948e-02f, -9.13630873e-02f, 9.32499394e-03f, 4.63408045e-02f,
  -2.62712017e-02f, -8.75914656e-03f, -4.03882749e-03f, -9.84776765e-04f, -1.55528700e-02f, 4.17321287e-02f, -1.82800721e-02f, 7.29266852e-02f, 1.08082078e-01f, 2.57306043e-02f,
  1.16336964e-01f, 7.44158924e-02f, 1.25240795e-02f, 1.31855637e-01f, 2.15661880e-02f, 9.24992114e-02f, 6.62714094e-02f, -1.24378055e-02f, 5.42918742e-02f, -8.10616184e-03f,
  2.06049923e-02f, 1.10772811e-01f, -7.00801462e-02f, 4.23382148e-02f, -5.93516864e-02f, -8.41912329e-02f, 3.68024856e-02f, -5.53336740e-02f, 2.37141382e-02f, 5.26424013e-02f,
  5.66688962e-02f, 1.52743496e-02f, 1.66308861e-02f, -9.98289138e-02f, 1.79163255e-02f, -6.21139519e-02f, 3.44315730e-02f, -6.03396036e-02f, 4.99813557e-02f, -3.16916294e-02f,
  -9.98354238e-03f, 3.62642370e-02f, 1.47513635e-02f, 2.82137394e-02f, 4.92488965e-02f, 7.24665150e-02f, 7.89968371e-02f, -4.28074785e-02f, 6.54210746e-02f, 1.90589428e-02f,
  1.41541258e-01f, 7.56523311e-02f, -3.52398828e-02f, 9.14527625e-02f, 5.48367612e-02f, -3.21309417e-02f, 1.32646859e-01f, -2.56464090e-02f, 7.06005171e-02f, -1.10156536e-02f,
  6.44370839e-02f, -1.20318465e-01f, -9.57000554e-02f, -5.69710918e-02f, 4.27385271e-02f, -1.06657790e-02f, -3.74643393e-02f, -4.24335822e-02f, -4.23434712e-02f, -9.14224982e-02f,
  1.10771060e-02f, -1.21342214e-02f, -6.33810386e-02f, 1.24768149e-02f, -9.34955627e-02f, -6.43626228e-02f, -5.06599247e-02f, 8.54065940e-02f, 5.65475151e-02f, -7.22249895e-02f,
  -2.59516034e-02f, 5.61520904e-02f, -6.55836388e-02f, -8.72688517e-02f, -1.03004336e-01f, 3.24262632e-03f, 6.77717254e-02f, 3.88722792e-02f, -3.67235132e-02f, -3.66435982e-02f,
  -1.34322485e-02f, 6.02150634e-02f, -2.05655918e-02f, 7.28346081e-03f, 6.69248169e-04f, 2.66525671e-02f, -5.83606735e-02f, 3.08138784e-02f, -2.87701096e-02f, -9.26852375e-02f,
  -2.61375718e-02f, -4.33134325e-02f, 1.02220468e-01f, 1.13407271e-02f, 5.58003038e-02f, -3.56402956e-02f, 6.67552426e-02f, -2.77103800e-02f, -5.41526116e-02f, -6.75301030e-02f,
  -2.53658090e-02f, 1.29817054e-02f, 6.06718324e-02f, 5.79081615e-03f, -3.25083621e-02f, -1.78208302e-05f, -1.05598904e-02f, 9.55297053e-02f, -2.44519450e-02f, 1.13060236e-01f,
  -2.84247026e-02f, 1.20218329e-01f, -7.70637169e-02f, 7.69043993e-03f, -5.94130298e-03f, 8.91105272e-03f, 8.90207291e-02f, 1.07833140e-01f, 9.61692929e-02f, -2.36498192e-02f,
  5.11372574e-02f, 3.08439368e-03f, -2.57075927e-03f, -3.14696729e-02f, -6.81864936e-03f, -3.63108627e-02f, 7.66767040e-02f, -9.75985266e-03f, -2.80887801e-02f, 1.09988943e-01f,
  -8.54088441e-02f, 9.13498085e-03f, -3.45466323e-02f, -5.79818338e-02f, 1.74798016e-02f, 7.40841776e-02f, -7.32758120e-02f, 7.23313019e-02f, 4.23438698e-02f, 1.09908478e-02f,
  8.17337334e-02f, -4.79152054e-03f, 3.91125046e-02f, 3.58544774e-02f, 3.02150869e-03f, 2.37174798e-02f, 7.68627003e-02f, -3.20706852e-02f, -1.17221951e-01f, 8.98752362e-02f,
  8.94048437e-02f, 1.14499955e-02f, 2.60079454e-04f, 8.51137042e-02f, 1.00030445e-01f, -5.21608889e-02f, 7.29036331e-02f, 3.97825129e-02f, 9.00775343e-02f, 2.64362432e-02f,
  -1.38385192e-01f, 1.10857114e-01f, -1.31569639e-01f, 1.12015037e-02f, 6.14998601e-02f, -3.91886756e-02f, 2.61062253e-02f, 3.34332436e-02f, 7.67689273e-02f, 2.16277316e-02f,
  7.82862902e-02f, 7.06799924e-02f, 5.11668995e-02f, -3.40822972e-02f, 4.32925336e-02f, 4.00360376e-02f, 1.66919157e-01f, 8.59325100e-03f, -9.99042615e-02f, -3.14853899e-02f,
  -2.49553509e-02f, -7.26518631e-02f, -1.50640622e-01f, -2.66692117e-02f, -1.96953733e-02f, 4.49631847e-02f, 5.04937880e-02f, 5.80324382e-02f, -9.73193720e-02f, 1.51858687e-01f,
  2.18690075e-02f, 1.89922340e-02f, 6.72726408e-02f, -1.96776483e-02f, -4.32991248e-04f, -4.65337299e-02f, 1.67946622e-03f, -3.99583543e-04f, -1.03532270e-01f, 5.18936999e-02f,
  1.08954288e-01f, 5.22475541e-02f, 8.97670612e-02f, -2.20908727e-02f, -7.07456470e-02f, 7.22553441e-03f, -6.23047315e-02f, -4.39129248e-02f, -1.08888149e-01f, -3.76316458e-02f,
  8.99396390e-02f, -3.69441994e-02f, -1.24695629e-01f, -1.01891890e-01f, -5.61459630e-04f, -8.11533555e-02f, -1.36603890e-02f, -6.00656159e-02f, -1.23654366e-01f, 9.09711793e-02f,
  -1.34913489e-01f, 4.66201566e-02f, 8.54531378e-02f, -7.49749914e-02f, 6.16707727e-02f, 1.03151858e-01f, 2.61755381e-02f, 6.02394454e-02f, -7.92279765e-02f, -3.05826552e-02f,
  6.41734293e-03f, -1.26483738e-01f, -6.28059283e-02f, -1.19041502e-01f, -4.00490575e-02f, -3.63045335e-02f, -1.67839546e-02f, 6.12900630e-02f, 1.94740277e-02f, -9.67482254e-02f,
  5.64079508e-02f, -5.61578460e-02f, -7.14642107e-02f, -6.51347637e-02f, -6.22852258e-02f, -1.75311510e-02f, 3.06213107e-02f, 2.73636058e-02f, -1.13408469e-01f, -1.05848148e-01f,
  -9.67836007e-03f, 7.85470307e-02f, -2.39820927e-02f, 3.56412716e-02f, -6.52333647e-02f, -3.72043438e-02f, -4.30235378e-02f, -9.40473005e-02f, -4.60820608e-02f, -3.30503173e-02f,
  1.71074029e-02f, 7.79691711e-02f, 3.23659219e-02f, 5.29889427e-02f, 4.48550917e-02f, -4.13303263e-02f, 2.52405135e-03f, 5.12333214e-03f, 2.71235779e-02f, -9.90527123e-02f,
  -6.92543611e-02f, -5.03905956e-03f, 6.40163943e-02f, -1.21488562e-02f, -3.22766304e-02f, -9.03878957e-02f, -5.81268705e-02f, -5.71160987e-02f, -1.52749419e-01f, -4.19454165e-02f,
  -2.87451506e-01f, -5.00519946e-02f, -9.24654305e-02f, -5.68147004e-02f, 1.78653255e-01f, 2.08240956e-01f, 6.81874976e-02f, 3.50790732e-02f, 1.36196733e-01f, -8.30757692e-02f,
  -2.30605062e-03f, 6.22014888e-02f, -2.29991172e-02f, 5.01010753e-03f, -1.11212797e-01f, -1.08318880e-01f, -1.18880533e-01f, -1.81901559e-01f, 3.63178514e-02f, 2.41606921e-01f,
  8.30904543e-02f, -1.02906674e-01f, -1.25199184e-01f, -9.46191326e-02f, 5.60556278e-02f, -7.09778741e-02f, -2.63481021e-01f, -1.61219060e-01f, -2.97437198e-02f, -1.11844026e-01f,
  -1.65693387e-01f, 8.06395710e-02f, 9.08093452e-02f, 2.73200404e-03f, -9.76334363e-02f, -3.20794806e-02f, -2.28767544e-02f, 3.26626077e-02f, -5.89341819e-02f, 4.59764060e-03f,
  2.87529323e-02f, 1.22023143e-01f, -1.20203145e-01f, 1.04948595e-01f, 9.22732502e-02f, -4.47410755e-02f, 7.23677874e-02f, 5.16798757e-02f, -1.16433967e-02f, 3.18253562e-02f,
  2.54387408e-02f, -4.96504866e-02f, -1.05237998e-02f, -3.93170565e-02f, 2.18104906e-02f, -1.84100047e-02f, -4.91571389e-02f, 1.46467369e-02f, 3.72660793e-02f, -1.04277000e-01f,
  3.77208483e-03f, 1.08742556e-02f, 1.09203853e-01f, 4.11276817e-02f, -2.19581723e-02f, -2.67185625e-02f, 8.42842367e-03f, 2.05365755e-03f, -6.12096414e-02f, 3.74835581e-02f,
  -6.07933383e-03f, -6.04732968e-02f, -2.04714923e-03f, -1.30319759e-01f, -9.78722349e-02f, -2.78118216e-02f, -3.83919254e-02f, -2.41217995e-03f, -1.18219383e-01f, -2.11455617e-02f,
  6.88648000e-02f, -1.09583266e-01f, 5.66228591e-02f, -4.55114665e-03f, 2.36946233e-02f, -8.21156334e-03f, 1.50567830e-01f, 1.76900297e-01f, 6.16347566e-02f, 1.19388122e-02f,
  -1.79391205e-01f, -3.94239612e-02f, -2.74519809e-02f, 4.45146821e-02f, -4.93772700e-03f, 2.33691689e-02f, -7.39441365e-02f, 5.93235008e-02f, 3.93710658e-02f, 8.45155418e-02f,
  1.06481314e-01f, 1.48482416e-02f, -4.99813110e-02f, 7.90246651e-02f, 3.32956761e-03f, 8.97044390e-02f, 2.16587912e-02f, -5.63812554e-02f, 2.16659717e-02f, 1.02402546e-01f,
  1.17966617e-02f, -8.42837989e-02f, -1.10613048e-01f, -4.30617258e-02f, 1.70730837e-02f, -5.67913651e-02f, -1.43562883e-01f, -1.71167608e-02f, -1.33740395e-01f, -2.32649237e-01f,
  9.09810439e-02f, -6.67084232e-02f, 1.01564154e-01f, -2.03880463e-02f, -2.12630108e-02f, 2.63407975e-02f, 1.78525541e-02f, -4.32625227e-02f, -6.93096519e-02f, 3.15772183e-02f,
  -6.02018670e-04f, -8.64445884e-03f, 1.45431459e-02f, -9.45888832e-02f, 8.20915774e-02f, -8.79027247e-02f, -1.00325614e-01f, 1.02123760e-01f, -1.01929689e-02f, -3.75989415e-02f,
  -5.86470813e-02f, -1.34091666e-02f, 1.08100042e-01f, 6.17165007e-02f, -9.36325341e-02f, 6.13125004e-02f, -4.43186536e-02f, 4.65715267e-02f, 2.01257747e-02f, -6.89846277e-02f,
  -9.99028534e-02f, 1.10896662e-01f, 1.05722427e-01f, -5.63206337e-02f, -6.90452894e-03f, 1.64018269e-03f, -6.05488978e-02f, 5.66467382e-02f, -6.18793741e-02f, -2.27876697e-02f,
  -4.39049350e-03f, -7.26143718e-02f, 1.13837697e-01f, 1.24605440e-01f, -2.36484539e-02f, 1.02501877e-01f, 1.01035379e-01f, 1.23019307e-03f, -2.76523046e-02f, -1.36059280e-02f,
  -4.92081866e-02f, 2.85909344e-02f, 9.54831019e-02f, 8.34956169e-02f, 1.55588323e-02f, 1.51178315e-02f, 5.97803630e-02f, 1.22821620e-02f, 3.76939364e-02f, 7.85206333e-02f,
  -7.41686001e-02f, -1.66088250e-02f, 5.12217134e-02f, 2.17785928e-02f, 9.90026258e-03f, 8.98467656e-03f, 3.68313976e-02f, -5.62665910e-02f, 6.97569773e-02f, 8.03849474e-03f,
  -6.68466389e-02f, 4.93648946e-02f, -5.08836433e-02f, -5.17849028e-02f, 5.58737759e-03f, 5.23053557e-02f, 7.43692517e-02f, 4.84178625e-02f, 2.18786225e-02f, 3.07855029e-02f,
  -7.60732815e-02f, 4.29446623e-02f, -9.27526504e-02f, 2.20324937e-02f, -1.25468925e-01f, -8.78652707e-02f, -9.24230814e-02f, -1.62910484e-03f, -9.75136384e-02f, -7.39905462e-02f,
  -1.43800467e-01f, 5.48573099e-02f, -8.89418945e-02f, -5.85424853e-03f, -3.57518680e-02f, 1.43563384e-02f, -4.25579734e-02f, -8.30220059e-02f, -1.14267342e-01f, 5.92244007e-02f,
  -1.81338657e-02f, -5.75323701e-02f, -2.25344207e-02f, 8.04302022e-02f, 9.16383937e-02f, 3.41215953e-02f, -9.31827724e-02f, -9.14409012e-03f, -5.00495173e-02f, -8.98527503e-02f,
  5.15447892e-02f, -6.97704107e-02f, -7.76774511e-02f, 6.67361021e-02f, 1.37698436e-02f, 1.04354724e-01f, -4.41222005e-02f, 2.44470537e-02f, -4.57970239e-02f, 8.19971934e-02f,
  -2.40219995e-01f, -3.01760975e-02f, -1.18194737e-01f, -1.60495695e-02f, 1.14876300e-01f, 5.54883629e-02f, 3.44113670e-02f, 4.88487817e-02f, -2.60232911e-02f, -6.17550761e-02f,
  -5.39168119e-02f, -9.91389602e-02f, -7.19749555e-02f, 9.06061828e-02f, -5.67915961e-02f, -2.09952556e-02f, -5.33787720e-02f, -1.18877418e-01f, -8.10569003e-02f, 2.19425429e-02f,
  5.04606217e-02f, -1.09726656e-02f, -9.45857465e-02f, 2.97262203e-02f, -3.20213498e-03f, 1.86807122e-02f, 8.00894201e-02f, 2.98293512e-02f, 7.20525235e-02f, 7.10384771e-02f,
  5.35114408e-02f, -3.07398662e-02f, 5.55491932e-02f, -2.89495569e-02f, 3.23835425e-02f, 1.94147776e-03f, 2.28158175e-03f, -5.35795130e-02f, -8.84135067e-02f, 6.59630299e-02f,
  4.36011255e-02f, -1.04217187e-01f, 4.00625877e-02f, -1.12899296e-01f, -7.34392852e-02f, -8.46589264e-03f, -5.48960678e-02f, -1.52297923e-02f, 2.83668581e-02f, 1.08168758e-01f,
  1.17515430e-01f, 4.02525738e-02f, -4.64252904e-02f, -2.31193192e-02f, -2.54943315e-03f, 7.63474479e-02f, 8.81455690e-02f, 4.07250375e-02f, 7.11553320e-02f, 1.36571210e-02f,
  1.05158612e-02f, 5.32015562e-02f, 2.28778478e-02f, -6.46530464e-02f, -1.21089175e-01f, 1.36441868e-02f, 2.10441351e-02f, -9.41011086e-02f, 1.96940120e-04f, -1.31262302e-01f,
  -8.34280699e-02f, 3.64336595e-02f, 1.95225663e-02f, -8.03658590e-02f, -2.53581535e-02f, 2.90071163e-02f, 1.63329858e-02f, -1.08630778e-02f, 8.24841559e-02f, 9.05375108e-02f,
  4.74554375e-02f, -8.80369730e-03f, 5.89247644e-02f, 3.03683784e-02f, 1.01339266e-01f, 1.41134160e-02f, 2.66421735e-02f, -6.05145022e-02f, -7.01060221e-02f, 7.80124143e-02f,
  3.18098105e-02f, -3.86423096e-02f, -5.82951941e-02f, 3.74018736e-02f, 1.23896040e-02f, 4.60215285e-02f, 1.03553366e-02f, 2.04537213e-02f, -7.60739809e-03f, -6.66691884e-02f,
  -4.12782282e-02f, -1.02363266e-01f, -6.06630445e-02f, 3.35041769e-02f, -2.38198172e-02f, -3.69982868e-02f, -7.16102645e-02f, 9.30839702e-02f, 1.69087142e-01f, 1.09615214e-02f,
  1.28442928e-01f, 4.05449308e-02f, 2.82665845e-02f, -1.34623493e-03f, 8.80288705e-03f, 2.26408243e-02f, 1.59684401e-02f, 1.90251563e-02f, -4.23697904e-02f, -8.91886204e-02f,
  4.77849282e-02f, -5.89712756e-03f, 7.84651041e-02f, -2.02711243e-02f, -9.16249901e-02f, -6.16724230e-02f, -4.31555994e-02f, 2.42622327e-02f, 1.84461568e-02f, 2.78614312e-02f,
  -2.33782455e-03f, 5.15712127e-02f, -2.55620796e-02f, 1.62582286e-02f, 3.63678411e-02f, -3.86698022e-02f, 6.08997121e-02f, 1.16510063e-01f, 7.40293562e-02f, 1.04839303e-01f,
  -6.34735972e-02f, 2.26726439e-02f, 9.72485021e-02f, 1.01495624e-01f, 1.20715469e-01f, -5.79654388e-02f, -1.08596450e-02f, 1.19562775e-01f, 1.15460329e-01f, -6.11605681e-03f,
  5.72032481e-03f, 8.34684297e-02f, -1.08116409e-02f, -3.43250670e-03f, -8.57041776e-02f, 6.43078983e-02f, -3.66496220e-02f, -6.19896203e-02f, -3.96570638e-02f, -5.76816313e-02f,
  3.15927826e-02f, 4.33002673e-02f, -3.84179577e-02f, 6.83121681e-02f, -1.03836291e-01f, 2.60116030e-02f, 1.12537229e-02f, 5.43381199e-02f, 7.46109113e-02f, 8.31755698e-02f,
  6.36008754e-02f, -7.94861466e-02f, 6.55142367e-02f, -7.81269222e-02f, -3.32668284e-03f, -9.46621373e-02f, 1.38296653e-02f, -6.54327273e-02f, -6.64139539e-02f, 3.63383740e-02f,
  6.12493902e-02f, 2.53016967e-02f, -1.58085935e-02f, -4.55716588e-02f, -9.72751006e-02f, 2.81268470e-02f, 4.46832441e-02f, 5.77453710e-02f, 6.58586621e-02f, 5.66657400e-03f,
  -4.68544140e-02f, -6.82591423e-02f, -7.49917254e-02f, -1.28501216e-02f, -7.18609318e-02f, -6.34746403e-02f, -4.59193848e-02f, -1.84074584e-02f, -2.37618722e-02f, 1.63268521e-02f,
  7.98063427e-02f, 7.97336623e-02f, -9.92105678e-02f, -5.17306514e-02f, -5.39819822e-02f, 5.06211445e-02f, -3.92206386e-02f, -2.56211450e-03f, 4.45711315e-02f, -6.52864054e-02f,
  1.58790667e-02f, 7.17610270e-02f, -5.03995048e-04f, 1.24377742e-01f, -4.70568687e-02f, -5.28500415e-02f, 1.66508146e-02f, -2.78683901e-02f, -8.07971805e-02f, -6.64688507e-03f,
  6.13452718e-02f, 4.23241071e-02f, -5.79480641e-02f, 4.15180922e-02f, -4.66505177e-02f, -5.25782667e-02f, 3.79723907e-02f, -6.58874437e-02f, 8.66653770e-02f, 1.61175933e-02f,
  -1.95457432e-02f, -6.28212243e-02f, -8.93450677e-02f, 3.60385366e-02f, -6.57481775e-02f, 1.54690482e-02f, 6.04137369e-02f, 3.38373594e-02f, 3.60827819e-02f, -5.82772940e-02f,
  -2.88921356e-01f, 8.70406404e-02f, -1.52496532e-01f, -1.26037911e-01f, 1.55356646e-01f, 1.57427415e-01f, 3.07699740e-01f, 1.98871538e-01f, 2.97942236e-02f, 9.33803543e-02f,
  4.33390997e-02f, 2.95530818e-02f, 2.20577680e-02f, -4.00072001e-02f, 2.88132336e-02f, 1.59119535e-03f, 8.13478827e-02f, -2.36902870e-02f, -2.13738501e-01f, 1.74765419e-02f,
  3.64747532e-02f, -1.28074184e-01f, -1.81564063e-01f, -3.20284069e-02f, -2.97735855e-02f, -7.84180090e-02f, -2.99731810e-02f, -9.04414132e-02f, 3.26193981e-02f, 6.28568558e-03f,
  -1.20681331e-01f, -9.18666273e-02f, -6.81316927e-02f, -3.58019359e-02f, -9.94061679e-02f, -2.11356711e-02f, 8.06899089e-03f, 2.33125612e-02f, 3.11665684e-02f, 1.59517955e-03f,
  6.77175000e-02f, 1.94006078e-02f, -8.34497735e-02f, 4.78033498e-02f, -1.52182460e-01f, -2.53047831e-02f, -3.98844779e-02f, -1.06171198e-01f, -2.04001553e-02f, -2.29179226e-02f,
  1.28653497e-01f, 1.51806520e-02f, 1.80645436e-02f, 3.03776413e-02f, 6.15820326e-02f, -6.31075799e-02f, -9.61009488e-02f, -4.94945832e-02f, -6.95271939e-02f, -3.35351340e-02f,
  6.31570518e-02f, 4.30431701e-02f, -4.87625934e-02f, -5.49854636e-02f, -1.44857951e-02f, 6.42971471e-02f, -4.02606688e-02f, 1.72560960e-02f, -4.45952900e-02f, 1.85528882e-02f,
  -1.70503799e-02f, 8.27975646e-02f, -4.94313426e-02f, -5.81032783e-03f, 4.17788699e-02f, -6.09071851e-02f, -4.16936353e-02f, -8.63977969e-02f, 4.70527038e-02f, -4.06003334e-02f,
  -4.49888110e-02f, 9.17350780e-03f, -3.78113724e-02f, 7.26325214e-02f, 1.84177104e-02f, -6.56424165e-02f, -1.48691870e-02f, -4.77822013e-02f, -1.70977525e-02f, 2.97949910e-02f,
  -5.19516431e-02f, 3.94203179e-02f, -9.35894996e-02f, -5.94874248e-02f, 5.92344664e-02f, -8.39627385e-02f, 1.78771112e-02f, -1.73338279e-02f, 3.79009335e-03f, 1.11560319e-02f,
  -3.27001587e-02f, -6.02724664e-02f, -1.17632234e-02f, 5.91641590e-02f, -1.13152735e-01f, 4.99240570e-02f, 1.20106250e-01f, -4.75125946e-02f, 1.31702662e-01f, -3.53332199e-02f,
  1.07624255e-01f, 8.43649656e-02f, -2.42464151e-02f, 1.66636467e-01f, -2.06263270e-02f, 2.20835656e-02f, -1.00992829e-01f, -2.47719022e-03f, -6.35752380e-02f, -4.83004935e-02f,
  -1.15306936e-02f, -6.06148206e-02f, -1.15549281e-01f, 3.80314887e-02f, 1.11021521e-02f, 2.54816469e-02f, -1.85411237e-02f, -4.91506495e-02f, -8.24151710e-02f, -2.31118407e-02f,
  -9.99648403e-03f, -2.23373566e-02f, 5.90450615e-02f, -7.87152946e-02f, -1.11861221e-01f, -5.10007292e-02f, 2.83555705e-02f, -4.55783829e-02f, 6.40465170e-02f, -6.70249164e-02f,
  -5.88446483e-03f, -4.94272299e-02f, 5.20449802e-02f, -8.83995518e-02f, 3.60515602e-02f, 7.83369970e-03f, 3.09730079e-02f, 4.89434227e-02f, 2.55531762e-02f, -1.11137077e-01f,
  1.38014676e-02f, 2.24127970e-03f, 6.56188056e-02f, -7.21164942e-02f, 2.52936725e-02f, 6.30760714e-02f, 6.47893399e-02f, -5.89901116e-03f, 2.76729856e-02f, -7.01852143e-02f,
  2.77109463e-02f, -7.17990845e-02f, -1.39842285e-02f, -3.92218754e-02f, -3.13341361e-03f, -8.53484422e-02f, -3.83077562e-02f, -8.45381320e-02f, 5.69200218e-02f, 2.01954669e-03f,
  -4.54749912e-02f, -4.07718867e-02f, -4.29107398e-02f, -3.89945433e-02f, -7.65707716e-02f, 4.53499937e-03f, -4.75223437e-02f, 3.45091447e-02f, -7.01505393e-02f, -4.11327295e-02f,
  -9.53552723e-02f, 9.03393477e-02f, -5.81459515e-02f, 7.74870962e-02f, 7.60169253e-02f, 1.16868336e-02f, -8.72655362e-02f, 9.85436738e-02f, -1.17632654e-03f, 6.00722916e-02f,
  -6.25883713e-02f, -1.16538014e-02f, 2.55948398e-02f, 7.66084045e-02f, 2.94202520e-03f, 2.00937595e-02f, 3.69535340e-03f, -8.82477537e-02f, -3.47068645e-02f, -4.84179258e-02f,
  6.22571539e-03f, 7.71097988e-02f, 3.09770694e-03f, -5.04576787e-02f, -2.50798389e-02f, -6.27776384e-02f, -6.28823638e-02f, -6.86012208e-02f, -4.04390916e-02f, -6.74678460e-02f,
  -1.05044067e-01f, 5.65824471e-02f, 8.36083144e-02f, 6.42467216e-02f, -6.05005957e-02f, 7.49966502e-02f, -6.67192973e-03f, 6.56036362e-02f, 5.92229608e-03f, -9.62940753e-02f,
  6.90419972e-02f, 8.93601868e-03f, 4.45107035e-02f, -5.27626798e-02f, -2.00026654e-04f, -6.91296458e-02f, 1.25407837e-02f, 1.42140426e-02f, -5.09741865e-02f, 1.52259227e-02f,
  -9.80687439e-02f, 2.08600760e-02f, -5.86847365e-02f, -8.02701935e-02f, 7.78678507e-02f, -6.05070069e-02f, -3.55318673e-02f, -5.35704836e-04f, -5.44593856e-02f, -2.85019949e-02f,
  2.86723543e-02f, 5.90009950e-02f, 4.95909378e-02f, 4.97462414e-02f, 2.37714313e-03f, -1.11612760e-01f, -7.94510171e-02f, -9.14703086e-02f, -5.63291200e-02f, 3.27739827e-02f,
  -1.06100701e-01f, -5.98765463e-02f, 7.88084641e-02f, -3.58034298e-02f, -1.41203906e-02f, 1.20001584e-02f, 6.52897283e-02f, 5.65624200e-02f, -1.59638990e-02f, 7.66271874e-02f,
  1.09898813e-01f, -3.33479053e-04f, -3.47970822e-03f, 9.77687240e-02f, 1.46229779e-02f, -2.27684081e-02f, 1.98063478e-02f, 1.17622718e-01f, 5.59968874e-02f, 3.31762396e-02f,
  1.26412660e-01f, -1.27809392e-02f, 4.42282930e-02f, 9.90272015e-02f, 9.77167636e-02f, 1.17014527e-01f, -6.94844499e-02f, 1.13590427e-01f, -7.99892992e-02f, -6.91015050e-02f,
  -5.46421716e-03f, 4.88369316e-02f, 5.16482443e-02f, -1.45724078e-03f, 7.93812890e-03f, 3.92609760e-02f, -3.04194586e-03f, 3.02000623e-02f, -3.69019918e-02f, -6.02956302e-02f,
  -9.07911658e-02f, -4.14757542e-02f, 4.88154739e-02f, -2.05000881e-02f, -8.04708451e-02f, -2.01280620e-02f, 8.68754685e-02f, 5.07650450e-02f, 3.01094819e-02f, 9.07016266e-03f,
  -7.01114582e-03f, -1.03892192e-01f, -7.23114088e-02f, -1.16369165e-02f, -1.08791947e-01f, -5.87767027e-02f, -1.53900525e-02f, 2.50020865e-02f, -5.49816154e-02f, -6.07394688e-02f,
  -7.87616074e-02f, 2.96222921e-02f, 1.81946077e-03f, 5.33387884e-02f, -3.98628637e-02f, -1.94686465e-02f, -3.01225837e-02f, -1.09464936e-02f, -7.32742101e-02f, -7.57429227e-02f,
  8.34627002e-02f, 8.56328085e-02f, 1.07764855e-01f, 2.33008936e-02f, -7.01172352e-02f, -3.30180861e-02f, 9.17958319e-02f, -2.83106565e-02f, -4.78848256e-02f, 2.45464500e-03f,
  7.26318136e-02f, 3.23170759e-02f, -4.46625240e-02f, -2.34437422e-04f, 3.58035713e-02f, 6.35875389e-02f, -2.72820797e-02f, 1.15919925e-01f, -2.89289877e-02f, 6.33877665e-02f,
  -4.86650690e-02f, 1.47401998e-02f, 5.64732254e-02f, -7.50524327e-02f, 4.92990948e-02f, 2.53775474e-02f, -1.05824374e-01f, 7.80548900e-02f, 8.29393193e-02f, 6.99857697e-02f,
  6.09220937e-02f, -6.56787977e-02f, 1.63287148e-02f, -1.28886858e-02f, -4.02749293e-02f, 5.43784201e-02f, -1.05764372e-02f, 3.89325209e-02f, 8.39334726e-02f, -1.40123246e-02f,
  -1.41610429e-01f, 8.51655975e-02f, -1.18108220e-01f, 5.39359972e-02f, 4.56953347e-02f, 1.65453508e-01f, 2.37593025e-01f, 1.61984742e-01f, 1.22507364e-01f, -3.81390378e-02f,
  -5.63148558e-02f, 1.29895192e-02f, 1.07332923e-01f, 2.96780287e-04f, 1.76617131e-02f, 2.35154871e-02f, 1.75522611e-01f, -5.40364459e-02f, 5.83475456e-02f, -3.99033204e-02f,
  1.43361792e-01f, 2.72717513e-02f, -4.07292619e-02f, -1.98233854e-02f, 1.09264143e-01f, -9.37988684e-02f, -2.07375409e-03f, 2.43533850e-02f, 6.51975395e-03f, 1.10437207e-01f,
  -1.16270505e-01f, -9.77342054e-02f, 8.77164006e-02f, -6.06406070e-02f, 6.07097819e-02f, -8.94338265e-02f, 4.56711873e-02f, 3.92701216e-02f, 8.07707831e-02f, 5.33202551e-02f,
  -5.99301234e-02f, 5.15086614e-02f, 6.28249422e-02f, -7.04213679e-02f, 5.70639223e-02f, -1.06851421e-01f, -9.73419026e-02f, -4.35570367e-02f, -2.44359463e-03f, -5.79720624e-02f,
  1.11254677e-01f, 6.13528816e-03f, -5.83368130e-02f, 2.66433973e-02f, -3.30067091e-02f, -1.80505197e-02f, 3.26736122e-02f, -4.08414006e-02f, -2.30234750e-02f, -9.87613574e-02f,
  5.38229682e-02f, -6.56230524e-02f, 1.32536776e-02f, 2.64917277e-02f, 7.10991621e-02f, 5.82371913e-02f, -2.58478113e-02f, 3.32193784e-02f, 6.67054132e-02f, -7.68611282e-02f,
  4.71662395e-02f, -1.43154664e-02f, -2.53012292e-02f, -8.56439099e-02f, -1.52713377e-02f, 1.46025764e-02f, 1.27759963e-01f, 5.13359047e-02f, -2.82867905e-03f, -4.50519100e-02f,
  -4.58590500e-02f, 9.74997804e-02f, -4.81920503e-02f, 7.41893873e-02f, 2.35433672e-02f, -2.07355656e-02f, -6.87563047e-02f, -6.24865256e-02f, -6.18991628e-02f, 4.33770120e-02f,
  1.03562482e-01f, -6.64800331e-02f, 7.16237947e-02f, 3.38773094e-02f, -4.95733581e-02f, -6.45981357e-02f, -9.00816023e-02f, -8.85852650e-02f, 3.49797867e-02f, -4.11256924e-02f,
  2.43104678e-02f, 2.99733467e-02f, 7.43275583e-02f, -4.23289947e-02f, -3.64192426e-02f, 3.42311263e-02f, -8.72672349e-03f, 2.95315161e-02f, -5.45501709e-02f, -1.44967660e-02f,
  7.72740170e-02f, 1.67641621e-02f, -3.76922935e-02f, 7.40781426e-02f, -2.20639557e-02f, -9.39145982e-02f, 7.08502298e-03f, 2.82940604e-02f, 4.96726483e-03f, -1.07655920e-01f,
  1.70023859e-01f, 8.50498118e-03f, 5.42615913e-02f, 8.47945809e-02f, -2.23236401e-02f, -4.86341491e-02f, 4.81249429e-02f, 2.47329865e-02f, 1.02481827e-01f, 1.16965748e-01f,
  1.00121766e-01f, 1.30542204e-01f, 2.16025949e-01f, 1.51004493e-01f, 9.13081095e-02f, 6.00190759e-02f, -6.13367185e-02f, 1.10131390e-01f, 1.65507928e-01f, 8.19041878e-02f,
  -7.25675821e-02f, -9.97153223e-02f, 7.49533102e-02f, -1.33932596e-02f, 5.31473476e-03f, 1.18008345e-01f, -9.72816497e-02f, -9.21647400e-02f, -2.06640689e-03f, -1.79987773e-01f,
  1.59279313e-02f, 7.59922042e-02f, 3.54216062e-02f, 4.35281843e-02f, 2.92599872e-02f, 2.12485548e-02f, 1.19253444e-02f, 2.64380407e-02f, -3.81072313e-02f, 2.10192800e-02f,
  1.11751698e-01f, 3.65689844e-02f, -7.99451545e-02f, -2.64399499e-02f, 6.65262118e-02f, -2.68141516e-02f, -2.12400649e-02f, 3.53322923e-02f, -4.59784046e-02f, 5.10207750e-02f,
  1.23195956e-02f, 1.57217793e-02f, -3.29752676e-02f, -1.37728844e-02f, -2.23188940e-02f, 1.20519586e-01f, 1.75218247e-02f, -6.96475105e-03f, -2.26994101e-02f, 2.59070639e-02f,
  6.47233576e-02f, -4.88704070e-02f, 6.14282079e-02f, 6.67424202e-02f, -3.44910361e-02f, 8.53762701e-02f, -5.65786920e-02f, 6.63490891e-02f, -4.07409184e-02f, -1.90744027e-02f,
  6.00179769e-02f, 1.09781422e-01f, 3.27287093e-02f, 6.59576729e-02f, 1.62038568e-03f, 8.52404046e-04f, -2.57080775e-02f, -5.34743909e-03f, -4.14407440e-02f, -2.56670229e-02f,
  -6.18231818e-02f, -5.39985597e-02f, 5.21536358e-02f, -1.39399648e-01f, -2.47591231e-02f, -5.15166149e-02f, -3.26126441e-02f, -2.40100585e-02f, -3.17911394e-02f, 4.08416800e-02f,
  -1.95012271e-01f, 1.73427895e-01f, 2.12020334e-02f, 3.90322059e-02f, -9.52342972e-02f, 5.27260676e-02f, 7.35298693e-02f, -1.03494093e-01f, -1.03050120e-01f, -7.71403089e-02f,
  -1.22461386e-01f, 4.32737358e-02f, -2.92168912e-02f, 4.92573008e-02f, 1.98064628e-03f, 9.40814242e-02f, 1.03258260e-01f, -2.78620422e-02f, 4.96933125e-02f, 3.51605751e-02f,
  7.97957033e-02f, -4.36107861e-03f, 1.27463862e-01f, -1.85928331e-03f, -2.99814306e-02f, 1.25784501e-01f, 1.81467272e-03f, -1.10690825e-01f, 2.75569893e-02f, -3.96370590e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.82232778e-02f, 1.01184413e-01f, -3.17052864e-02f, 8.49345922e-02f, -6.26078397e-02f, 5.56514747e-02f, 5.15731350e-02f, 6.51122928e-02f, 5.42723434e-03f, 1.16725422e-01f,
  -5.05283102e-02f, 1.05532303e-01f, -1.31542273e-02f, -5.87819926e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.77460656e-02f, -1.73564002e-01f, 1.12124301e-01f, -7.66809359e-02f, 1.33125380e-01f, -5.72043937e-03f, 2.72306092e-02f, 9.15017426e-02f, 6.08904660e-02f, -5.27205169e-02f,
  -1.15013933e-02f, -6.30139634e-02f, 6.46716952e-02f, 4.25209291e-02f, 1.94803193e-01f, -1.24681666e-01f, -1.08789550e-02f, -4.73417602e-02f, 1.00644536e-01f, 2.26471163e-02f,
  -1.14658982e-01f, -9.76629332e-02f, 1.64237633e-01f, 1.04080848e-01f, -7.23827556e-02f, 7.76302218e-02f, 2.50637271e-02f, 1.39906043e-02f, 2.99539000e-01f, -1.80652179e-02f,
  5.70392609e-02f, -9.53619257e-02f, 6.24086894e-02f, 1.19340017e-01f, -2.43001297e-01f, -2.17953578e-01f, 1.36089046e-02f, -1.00972772e-01f, -3.15444581e-02f, 1.45933647e-02f,
  2.29785368e-01f, 9.02137309e-02f, 6.65817708e-02f, -1.33992895e-01f, -1.81351438e-01f, 1.54928472e-02f, 1.10484019e-01f, -5.81417307e-02f, -6.68315366e-02f, -1.51088506e-01f,
  1.93485007e-01f, -7.99141154e-02f, -1.04156315e-01f, -5.16323652e-03f, -1.39796495e-01f, 1.75206929e-01f, 1.23143367e-01f, -1.61751565e-02f, -1.75358132e-02f, -3.09101492e-02f,
  -7.86934868e-02f, -6.90450147e-02f, 8.57757032e-02f, 6.71387836e-02f, -1.13055646e-01f, -1.52696624e-01f, 6.55907393e-02f, 2.67632902e-01f, -1.49065420e-01f, 8.70519578e-02f,
  -1.53240621e-01f, 5.75966649e-02f, 1.41089261e-01f, 1.28394235e-02f, 1.24214359e-01f, 5.32585271e-02f, 2.32764810e-01f, 1.71019137e-01f, 8.33131745e-02f, 1.67823792e-01f,
  -1.60958126e-01f, 9.97225195e-02f, -6.03354648e-02f, -6.38150051e-02f, 4.21314910e-02f, -9.64624658e-02f, 1.22669429e-01f, -1.57278925e-02f, -2.49421328e-01f, -6.76153824e-02f,
  -4.89812456e-02f, -8.44412521e-02f, 2.10273325e-01f, 1.24127962e-01f, 2.31834017e-02f, 1.82991475e-01f, -1.90059006e-01f, -2.27979496e-01f, 2.42322788e-01f, 4.39326465e-02f,
  6.51391521e-02f, -1.14799291e-01f, 1.46961540e-01f, -2.25253120e-01f, 1.89739078e-01f, -3.83171178e-02f, -2.81912178e-01f, -2.29107942e-02f, 5.05508147e-02f, -1.65820941e-01f,
  -4.80207875e-02f, -7.50536565e-03f, 4.37098593e-02f, -3.49151455e-02f, 6.72778115e-02f, 1.26206428e-01f, -1.24562018e-01f, -8.15550014e-02f, 4.11043167e-02f, 9.02871490e-02f,
  -9.68420953e-02f, 9.00425017e-02f, 2.39675492e-02f, -1.01843350e-01f, -2.21087262e-02f, 1.63439035e-01f, -1.58079207e-01f, -6.16663210e-02f, -7.76249096e-02f, 4.16196436e-01f,
  2.43295170e-02f, 7.21459836e-02f, -1.26997784e-01f, 6.09262362e-02f, -1.40941769e-01f, -1.23119757e-01f, 3.93364057e-02f, -6.38215616e-02f, 1.32854521e-01f, -1.25708766e-02f,
  5.45766801e-02f, -1.56414628e-01f, -8.23260173e-02f, 6.49810433e-02f, 1.37144759e-01f, 1.52647957e-01f, -7.20708147e-02f, 3.03336158e-02f, 1.17397077e-01f, 1.53682157e-01f,
  2.37835478e-02f, -4.03981730e-02f, 1.28777817e-01f, -6.29766956e-02f, -1.85603742e-02f, -2.07292046e-02f, -1.42312393e-01f, 1.29344389e-01f, -6.25377297e-02f, 2.20485665e-02f,
  -5.07765338e-02f, 3.41425394e-03f, -7.69296847e-03f, 2.52187312e-01f, -5.96970096e-02f, 1.69229865e-01f, 7.74108320e-02f, 3.24022993e-02f, -2.03345761e-01f, 2.65785754e-02f,
  1.96528006e-02f, -1.38085201e-01f, 1.21604227e-01f, -3.94661799e-02f, -9.27294642e-02f, 1.48344621e-01f, -8.60464796e-02f, 1.95186153e-01f, 3.62772420e-02f, -3.10326982e-02f,
  9.90545005e-02f, 1.97352588e-01f, 9.87505168e-02f, -1.61096096e-01f, 7.11100101e-02f, 8.48410949e-02f, -1.05437562e-01f, 1.78957403e-01f, 4.58384603e-02f, 7.73754343e-02f,
  7.94755518e-02f, -2.44568765e-01f, -1.17980905e-01f, -7.62296841e-02f, -6.26346394e-02f, 5.93457557e-02f, 1.02886923e-01f, 5.56131005e-02f, 7.30852336e-02f, -1.01626553e-01f,
  -4.52004261e-02f, -2.72932481e-02f, 4.88296384e-03f, 3.29460241e-02f, -1.05576189e-02f, -6.58177808e-02f, 1.26712948e-01f, 1.78165585e-02f, 5.44899441e-02f, -3.74212973e-02f,
  1.18626863e-01f, 1.41488045e-01f, 6.11290634e-02f, -1.16005778e-01f, 8.22176412e-02f, -4.69169132e-02f, 1.05804041e-01f, -6.72296882e-02f, 2.74803638e-02f, 2.10050624e-02f,
  1.87435634e-02f, 1.07069023e-01f, 4.74589765e-02f, -8.22426602e-02f, 1.27287749e-02f, 1.39938712e-01f, -1.10566668e-01f, -3.58844176e-02f, 1.55598402e-01f, -5.31239398e-02f,
  -1.12797715e-01f, -1.65246669e-02f, 9.57728401e-02f, -6.44531175e-02f, 1.40123770e-01f, 1.64223984e-02f, -1.35847971e-01f, -5.84957972e-02f, -1.55736627e-02f, 7.49825910e-02f,
  -1.82390362e-02f, -8.79821107e-02f, 6.23155236e-02f, -7.03395065e-03f, 5.75493127e-02f, 7.09943995e-02f, 3.13491337e-02f, 3.08548398e-02f, 1.57740619e-02f, -1.02790631e-01f,
  4.83701564e-02f, 2.00833995e-02f, -6.61746934e-02f, -1.17861174e-01f, -2.90922560e-02f, -2.33541634e-02f, 7.52223954e-02f, -1.69676811e-01f, -5.46022952e-02f, -4.92047705e-02f,
  1.29878059e-01f, -1.76341102e-01f, 1.45526022e-01f, 6.67643920e-02f, -9.82102305e-02f, 6.71499148e-02f, -1.20201118e-01f, 7.29239881e-02f, -3.21159102e-02f, 2.72067785e-02f,
  -3.53958234e-02f, -6.87707728e-03f, 1.55206293e-01f, 4.33931351e-02f, 1.36336619e-02f, -4.39561680e-02f, 1.48577616e-01f, -4.77906652e-02f, -4.71533462e-02f, 3.16457637e-02f,
  2.41402179e-01f, 5.56913950e-02f, 4.42794524e-02f, 1.09732397e-01f, -1.76064566e-01f, 1.51587930e-02f, -1.08442098e-01f, -2.13039309e-01f, 5.94523847e-02f, 2.18992233e-02f,
  -1.66618630e-01f, 7.79756606e-02f, 9.21827778e-02f, -5.92530966e-02f, -5.68814240e-02f, -4.22062073e-03f, -1.44724548e-01f, -5.88489026e-02f, 2.78808828e-02f, 2.44796515e-01f,
  9.67356488e-02f, -6.31289929e-02f, 8.29216167e-02f, 1.49296597e-02f, 1.79828748e-01f, -7.86912814e-02f, -1.66368425e-01f, 1.17115334e-01f, 1.55024335e-01f, 1.35014266e-01f,
  -7.38557875e-02f, -1.73272356e-01f, 9.95513424e-02f, -1.82629079e-01f, 1.31875888e-01f, -1.54139712e-01f, -8.36198032e-02f, -1.48789734e-01f, 3.69234942e-02f, 4.12613675e-02f,
  -1.75272357e-02f, -2.58027073e-02f, -3.22951451e-02f, -2.33363852e-01f, -5.57153448e-02f, -3.38122696e-02f, -9.13662910e-02f, -2.85556577e-02f, -1.51011497e-01f, 6.11462146e-02f,
  7.84970671e-02f, 1.09043419e-01f, -1.86511621e-01f, -1.01077765e-01f, -1.87270656e-01f, -1.08333468e-01f, 1.96057096e-01f, -1.65538102e-01f, 1.20792076e-01f, -1.55600026e-01f,
  1.47127479e-01f, 7.50315413e-02f, -1.07803948e-01f, -4.54345010e-02f, 2.79549241e-01f, -3.75719764e-03f, -1.39121916e-02f, 7.16678053e-02f, -9.34946090e-02f, -1.22622915e-01f,
  6.52800798e-02f, -3.25493813e-02f, 8.31925720e-02f, 1.88206583e-01f, -1.70067012e-01f, 3.69459316e-02f, 1.48375006e-02f, 1.36057869e-01f, 4.75931540e-02f, 1.82899967e-01f,
  -6.37471005e-02f, 8.81839395e-02f, 6.18156344e-02f, 2.10045084e-01f, -7.87463188e-02f, 1.95670258e-02f, 1.92422599e-01f, 1.61222845e-01f, 6.09294437e-02f, -9.15540475e-03f,
  -4.24833223e-02f, -7.81643689e-02f, 4.00960492e-03f, 1.31458789e-01f, -5.97588383e-02f, -2.07175270e-01f, 3.55663360e-03f, 5.66091239e-02f, 1.48197725e-01f, -1.06847204e-01f,
  -8.35869368e-03f, -6.34590611e-02f, 8.30190480e-02f, 4.71742861e-02f, -2.76305564e-02f, -2.65835166e-01f, 1.18948989e-01f, -8.72010961e-02f, 1.70782179e-01f, -2.83872962e-01f,
  -2.94586644e-02f, -2.95120832e-02f, 1.30886696e-02f, 3.76927480e-02f, -1.17898762e-01f, 1.40174463e-01f, 3.49776680e-03f, -1.63833261e-01f, -1.10353164e-01f, -6.41709045e-02f,
  6.21377230e-02f, -1.21652961e-01f, -7.96960294e-02f, -3.81489806e-02f, -8.76152050e-03f, -1.37728900e-01f, 1.97822638e-02f, 1.26742333e-01f, -2.88458373e-02f, 7.23235309e-02f,
  -8.18298310e-02f, -2.82288110e-03f, 6.83363304e-02f, 5.40272817e-02f, 1.46923885e-01f, -1.47949964e-01f, 2.05414608e-01f, 1.00854516e-01f, -7.05191568e-02f, -1.71022099e-02f,
  -8.94572958e-02f, -1.26317933e-01f, -1.80717230e-01f, 8.59737471e-02f, 3.56225967e-02f, -4.70752195e-02f, 7.68298283e-02f, 3.17438063e-03f, -8.23356435e-02f, 1.59279272e-01f,
  1.31393582e-01f, -6.61621056e-03f, 8.46818760e-02f, -2.00688764e-01f, 5.45543283e-02f, -1.76332220e-02f, 1.70841366e-02f, -3.88907827e-02f, -1.04900107e-01f, 6.12504929e-02f,
  9.44147184e-02f, 1.01430073e-01f, -6.16616085e-02f, -1.56870008e-01f, 1.36574015e-01f, -4.93786782e-02f, -6.36460856e-02f, 2.68216394e-02f, -8.02691560e-03f, -2.59927064e-01f,
  1.51236951e-01f, 1.20922858e-02f, 1.23794429e-01f, -1.63463905e-01f, -6.74828142e-02f, 4.45712395e-02f, 7.74896517e-02f, 1.24323688e-01f, -6.09491393e-02f, 1.55282930e-01f,
  -5.97812682e-02f, -7.10649341e-02f, 4.16003466e-02f, 7.74186030e-02f, -4.78935316e-02f, 6.78692386e-02f, 1.62982464e-01f, -2.10606530e-02f, 9.21569914e-02f, -5.57296686e-02f,
  1.51880801e-01f, 9.36291926e-03f, 1.29927158e-01f, 6.72473088e-02f, 7.60778710e-02f, -1.64949764e-02f, 7.13600442e-02f, -5.46725243e-02f, 8.83614942e-02f, -2.44651854e-01f,
  7.50171021e-02f, -2.65159854e-03f, -1.27947435e-01f, -4.35844027e-02f, -4.77700047e-02f, 4.65809964e-02f, -1.96540803e-01f, 1.85247943e-01f, 3.18471268e-02f, 6.80348054e-02f,
  -5.44178411e-02f, 9.06688124e-02f, -3.81023623e-02f, 1.37119845e-01f, 4.81019169e-02f, -8.98868870e-03f, 1.00622214e-01f, -3.79200913e-02f, 1.75157751e-04f, -9.90075767e-02f,
  2.80627212e-03f, 1.16776131e-01f, -3.93568315e-02f, -9.88366604e-02f, -8.88743624e-02f, -8.82753208e-02f, 6.07942510e-03f, -1.23831257e-01f, -4.39816937e-02f, -1.02776483e-01f,
  1.32279679e-01f, 3.20796892e-02f, 1.59230396e-01f, 5.35039008e-02f, -3.90599482e-02f, -3.24262083e-02f, 1.82383619e-02f, 1.06954254e-01f, 5.58838211e-02f, -9.05605480e-02f,
  2.97294576e-02f, -5.32491952e-02f, 1.05254613e-01f, 1.11430742e-01f, -2.26855110e-02f, -6.16250038e-02f, 8.33651423e-03f, 4.88235839e-02f, 6.47628903e-02f, 1.38181048e-02f,
  1.24599403e-02f, -7.14238286e-02f, 5.93972690e-02f, 5.34569956e-02f, -8.27542916e-02f, 1.36472464e-01f, 5.79897016e-02f, 1.38300238e-02f, -6.44154176e-02f, -7.13854935e-03f,
  -1.95607319e-01f, -4.43578847e-02f, 6.70474675e-03f, -7.54830390e-02f, -1.08783275e-01f, -1.03470862e-01f, 5.38892373e-02f, 2.44525328e-01f, 2.98063979e-02f, 1.69126298e-02f,
  8.46028551e-02f, 3.71556147e-03f, -2.15665266e-01f, -2.96432525e-02f, -4.49307123e-03f, 1.42401263e-01f, 2.13749528e-01f, 4.15546149e-02f, -1.54135570e-01f, -1.07880063e-01f,
  6.42599678e-03f, 2.29879513e-01f, -1.55701622e-01f, -2.15018429e-02f, 1.15061423e-03f, 8.17004293e-02f, 1.38759986e-01f, -7.40223750e-02f, -3.88598070e-02f, -1.07754745e-01f,
  8.84094462e-02f, -5.09664305e-02f, 5.73877506e-02f, 1.60696074e-01f, 7.87827447e-02f, -2.05113254e-02f, 4.68179658e-02f, 1.16056211e-01f, -2.73190048e-02f, 1.49106070e-01f,
  5.40288091e-02f, 1.70690641e-01f, 2.31363699e-02f, 4.31045257e-02f, 8.63759294e-02f, -1.99586675e-02f, 4.15613279e-02f, 9.13548768e-02f, 4.32429276e-02f, 9.43108127e-02f,
  7.84204528e-02f, -4.37057354e-02f, -1.24889813e-01f, -2.56589763e-02f, 2.07886435e-02f, 5.49745560e-02f, 8.06668103e-02f, 6.71511143e-02f, -3.37158181e-02f, -1.06672220e-01f,
  4.98267077e-02f, -3.57075445e-02f, 1.07626326e-01f, 1.14957243e-01f, -1.53447851e-03f, 1.33801296e-01f, -8.28716680e-02f, -2.57027745e-02f, 4.51636463e-02f, 2.02068299e-01f,
  -3.48168835e-02f, 6.22614957e-02f, -1.81824744e-01f, 1.63732916e-01f, 6.35571480e-02f, 5.34103364e-02f, 3.77883948e-02f, -4.89209741e-02f, 3.05943731e-02f, -8.09897482e-02f,
  3.96409668e-02f, 3.94478738e-02f, -1.64014012e-01f, -6.92235678e-02f, -1.39195651e-01f, 2.40414187e-01f, 7.96076581e-02f, -1.19641885e-01f, -1.50820285e-01f, 1.92315709e-02f,
  1.01516835e-01f, 9.61531594e-04f, -2.81984899e-02f, 5.68995401e-02f, -3.45062464e-02f, 2.36960337e-01f, -1.55864149e-01f, -7.69941881e-02f, 5.36705228e-03f, -1.16543934e-01f,
  -6.03537932e-02f, -1.93020359e-01f, -6.33769408e-02f, -1.74827933e-01f, 1.34035900e-01f, -1.48110420e-01f, 7.86262080e-02f, 1.10722659e-03f, -5.41113392e-02f, -1.81694388e-01f,
  -4.07103822e-02f, 2.05361053e-01f, -1.35484546e-01f, 6.70623407e-02f, -5.50604202e-02f, 5.71123585e-02f, 1.41805589e-01f, -7.93890804e-02f, -4.66849059e-02f, 1.91373184e-01f,
  1.95622668e-01f, 1.83526009e-01f, 9.39859226e-02f, 2.24023506e-01f, 2.10926265e-01f, 1.57733947e-01f, -1.32449523e-01f, 2.86391824e-01f, 6.68430254e-02f, 1.80669144e-01f,
  -1.86070621e-01f, -2.05149144e-01f, 2.32659206e-01f, 1.05433084e-01f, -1.46183327e-01f, 1.37374222e-01f, 1.68802559e-01f, -9.17614326e-02f, -1.80202261e-01f, 3.38704363e-02f,
  1.72698483e-01f, 1.15546942e-01f, 2.43066967e-01f, 2.03026384e-01f, 1.54797837e-01f, -1.82289779e-01f, -3.66646759e-02f, 1.01903819e-01f, -3.25121209e-02f, -2.08669052e-01f,
  9.32710171e-02f, 9.55733135e-02f, 8.58768225e-02f, 9.14203674e-02f, -1.11699976e-01f, -2.35631511e-01f, 1.39146894e-01f, -2.34914541e-01f, 6.27361313e-02f, -6.26131892e-02f,
  9.25671533e-02f, 2.04840489e-02f, -2.17715502e-01f, -7.28073940e-02f, 7.86302164e-02f, 2.99086899e-01f, -1.83775946e-02f, 4.04315218e-02f, 5.96637949e-02f, 1.73862368e-01f,
  6.84536546e-02f, -7.62261078e-02f, 1.07602943e-02f, -8.63740146e-02f, 1.55073524e-01f, 8.05426389e-02f, -1.52854219e-01f, -7.54988492e-02f, -1.17850907e-01f, -8.61796376e-04f,
  2.34339722e-02f, 1.29059702e-01f, 8.14456865e-02f, 1.49183730e-02f, 4.51689065e-02f, 1.67085767e-01f, -1.08004481e-01f, -4.42855954e-02f, 1.44914091e-01f, -1.56128541e-01f,
  8.76871422e-02f, -5.65426350e-02f, -6.74451739e-02f, -3.47954854e-02f, 1.28226047e-02f, 2.09310800e-02f, 6.82665706e-02f, 1.74295940e-02f, 4.92072888e-02f, 2.24254176e-01f,
  -9.86851603e-02f, -6.78040162e-02f, 1.68478727e-01f, -6.44649416e-02f, -2.36158714e-01f, 8.60341042e-02f, 1.53890103e-01f, -7.82533512e-02f, 1.23014517e-01f, -2.10081004e-02f,
  -1.92041714e-02f, 5.82208671e-02f, -6.01906981e-03f, 1.92429453e-01f, -7.04786479e-02f, 1.03151619e-01f, -3.93034443e-02f, 2.66842563e-02f, -3.39896083e-02f, -2.20750540e-01f,
  -8.81433338e-02f, -1.18854031e-01f, -2.73207147e-02f, 1.79198775e-02f, -6.65076599e-02f, 8.42539370e-02f, 2.80053485e-02f, 4.25528660e-02f, -8.00872520e-02f, -1.03425696e-01f,
  1.30327970e-01f, 1.36168703e-01f, 1.40097499e-01f, -9.17689726e-02f, -1.14234857e-01f, 4.00216989e-02f, -8.10292922e-03f, 5.17636202e-02f, 5.20497328e-03f, 2.98228767e-02f,
  1.42738238e-01f, 8.21628198e-02f, -7.17921555e-02f, -1.25799060e-01f, 4.15695719e-02f, -1.20512284e-01f, 9.78982355e-03f, 2.69070821e-04f, -9.22799632e-02f, -9.15713534e-02f,
  -3.67725976e-02f, -1.17707968e-01f, -2.48647735e-01f, 1.21485963e-01f, -6.45731688e-02f, -1.64085016e-01f, 2.76415616e-01f, 1.15074432e-02f, -4.81084175e-02f, 5.20027988e-02f,
  -1.11497484e-01f, -7.35425353e-02f, -1.49928302e-01f, -1.72251254e-01f, 2.71632552e-01f, 2.68610138e-02f, -1.41759530e-01f, -2.23721527e-02f, 2.08422273e-01f, 6.56915382e-02f,
  -1.66036207e-02f, -1.39307216e-01f, -1.67006522e-01f, -2.63536703e-02f, 1.20895371e-01f, 3.27414498e-02f, 7.24831000e-02f, -1.23314284e-01f, 5.10956682e-02f, 6.88736439e-02f,
  1.13327391e-01f, 2.25429013e-02f, -9.26588010e-03f, 6.03131317e-02f, -1.69427674e-02f, 1.10910507e-03f, 3.53076421e-02f, 1.85865741e-02f, 1.02233790e-01f, 1.44524919e-02f,
  -1.97581753e-01f, 3.04382980e-01f, 2.41793436e-03f, 1.38631752e-02f, 7.18958750e-02f, -9.26607847e-02f, -5.00154905e-02f, 9.16485786e-02f, 2.10751668e-02f, -4.75564599e-02f,
  5.24501652e-02f, 6.23066798e-02f, -1.06080100e-01f, 1.25737026e-01f, 1.38834059e-01f, 4.46081311e-02f, 4.33179960e-02f, -1.50081348e-02f, 6.16203509e-02f, 8.07088148e-03f,
  -3.13061364e-02f, 1.16191335e-01f, -3.52052599e-02f, 3.73359621e-02f, 3.54703292e-02f, 9.11142677e-02f, -7.85145164e-02f, 2.24751234e-02f, 1.10825442e-01f, -8.99210423e-02f,
  -3.46870744e-03f, 6.60789832e-02f, 7.98301101e-02f, 6.02697581e-02f, -1.96128692e-02f, -7.90768936e-02f, -2.20502596e-02f, 2.76065543e-02f, 4.22546491e-02f, -1.77109390e-02f,
  -1.09413669e-01f, -7.33612105e-03f, 6.56450987e-02f, -2.52154619e-02f, 1.04167506e-01f, -1.09584350e-02f, 4.86235553e-03f, -7.27518871e-02f, -8.80188718e-02f, 1.09682038e-01f,
  6.50972128e-02f, -1.18658736e-01f, 4.92812619e-02f, 9.00425613e-02f, -5.05242385e-02f, 6.84355870e-02f, 1.73972771e-02f, -5.21384329e-02f, 5.66275045e-02f, -9.22610834e-02f,
  -7.98619688e-02f, -2.51668412e-03f, 8.57907310e-02f, 4.82216850e-02f, -3.98315862e-02f, -1.39853299e-01f, 2.29765624e-02f, 1.45519182e-01f, -7.83569738e-02f, 1.32065415e-01f,
  -1.22809067e-01f, 5.11461124e-02f, 2.06080116e-02f, -6.60163686e-02f, -5.68885766e-02f, -5.54247461e-02f, -4.60363589e-02f, -1.77940845e-01f, -1.31963417e-01f, -1.73628122e-01f,
  7.31998682e-02f, -9.50415060e-03f, 7.38405585e-02f, 6.30410537e-02f, 4.07877676e-02f, 1.31890681e-02f, 7.34554008e-02f, -1.06052145e-01f, 4.91877683e-02f, -1.65506244e-01f,
  -6.40916526e-02f, -2.40789801e-02f, -1.91628635e-02f, 6.64284751e-02f, -4.24253903e-02f, -2.00594738e-02f, -6.45885393e-02f, 4.77630869e-02f, -1.30884334e-01f, -3.87740205e-03f,
  1.55909598e-01f, 8.34147409e-02f, -8.15311074e-02f, -3.80686224e-02f, 7.07671419e-02f, 6.28007725e-02f, -1.11086937e-02f, -4.37039956e-02f, -6.34859130e-02f, 1.58472285e-01f,
  -2.37546638e-02f, -3.38192396e-02f, 2.58147828e-02f, 1.01302102e-01f, -9.63017195e-02f, 6.76257908e-02f, -1.20869897e-01f, 1.17474012e-02f, 1.85656343e-02f, -8.38970840e-02f,
  1.32667139e-01f, -1.45867057e-02f, -8.13335627e-02f, 7.73784593e-02f, 1.76144931e-02f, -6.03514239e-02f, -1.22525543e-01f, 8.92214477e-02f, 3.93749475e-02f, -1.04767404e-01f,
  9.37364027e-02f, -6.73757195e-02f, -8.66409615e-02f, -4.30764519e-02f, -4.57293820e-03f, 1.57195672e-01f, 6.85728937e-02f, 4.84538218e-03f, -1.10573068e-01f, 8.13400932e-03f,
  -9.26466510e-02f, -1.81105956e-01f, -1.46329835e-01f, 2.62808707e-03f, -8.13577846e-02f, 4.87506166e-02f, 3.63512039e-02f, 1.15477163e-02f, -6.42630458e-02f, 6.42579570e-02f,
  3.30375247e-02f, -1.06495187e-01f, -4.14426886e-02f, -6.92065656e-02f, -2.78488286e-02f, 1.04948223e-01f, 1.39228746e-01f, -9.14763883e-02f, -1.66546151e-01f, 9.42586362e-02f,
  3.64394370e-03f, 7.87127297e-03f, -1.93250969e-01f, -1.65984824e-01f, 9.27077234e-02f, 4.79650795e-02f, -5.28621599e-02f, 2.55036037e-02f, 1.42807543e-01f, -3.46059985e-02f,
  1.11170858e-02f, 9.44504216e-02f, 4.01989482e-02f, 8.34884271e-02f, 1.00640237e-01f, -9.12543461e-02f, -1.99289426e-01f, -1.51432171e-01f, -1.13661706e-01f, 2.11759821e-01f,
  -9.47230905e-02f, 1.20680565e-02f, 7.17261806e-02f, -9.06897113e-02f, 1.42925709e-01f, 5.12240790e-02f, 5.05334511e-02f, 1.03317037e-01f, 1.02217853e-01f, -9.87913534e-02f,
  -8.87748748e-02f, 1.56396758e-02f, 9.52747092e-02f, -1.39333963e-04f, 1.12479314e-01f, 4.07361358e-01f, 2.91027576e-02f, 1.52108505e-01f, -4.44410481e-02f, 1.46244571e-01f,
  -1.40006348e-01f, -1.54451147e-01f, 8.00229162e-02f, -6.06165752e-02f, 2.06954166e-01f, 9.35367942e-02f, 8.04612562e-02f, -1.25407400e-02f, 1.19621031e-01f, 5.80954254e-02f,
  -2.45190635e-02f, 2.78839562e-03f, 4.16679606e-02f, -8.51381496e-02f, 1.48945197e-01f, -1.79252513e-02f, -1.52867854e-01f, -8.66005421e-02f, -1.35210045e-02f, -1.41322896e-01f,
  2.07956269e-01f, 1.52306706e-01f, 3.40954810e-02f, 1.23966791e-01f, -2.31680125e-01f, 2.63282448e-01f, -2.22184777e-01f, -8.07731524e-02f, 1.72213957e-01f, 2.37709552e-01f,
  -1.55913383e-01f, 1.01113953e-01f, 1.50843352e-01f, -1.14396639e-01f, -6.30718097e-02f, 1.58905275e-02f, -1.25230461e-01f, -1.84876010e-01f, 1.22216688e-02f, -2.03873903e-01f,
  -2.80888379e-01f, -6.52987063e-02f, -7.70499259e-02f, 1.42729938e-01f, 7.32084811e-02f, 1.30467251e-01f, -4.22719084e-02f, 1.74775273e-02f, 8.40034932e-02f, -1.83962435e-02f,
  -1.06107250e-01f, 1.13162249e-01f, 1.24927305e-01f, 1.06746070e-01f, -6.74785599e-02f, -5.19157909e-02f, 3.52332853e-02f, -1.26213700e-01f, 7.23687001e-03f, -1.81774959e-01f,
  5.57485707e-02f, 9.42484066e-02f, 5.53688705e-02f, 5.22884093e-02f, 3.85675244e-02f, -3.18487696e-02f, -1.15805510e-02f, 8.23620986e-03f, 6.77196905e-02f, 1.29408807e-01f,
  1.21524945e-01f, 1.26733616e-01f, -7.64435204e-03f, -4.63302620e-02f, -1.32597774e-01f, -2.33831778e-02f, -3.32113132e-02f, -1.03351019e-01f, -8.57586935e-02f, 8.65202695e-02f,
  5.20222187e-02f, 1.11846663e-02f, -5.77772316e-03f, -8.81487969e-03f, -1.48247674e-01f, 1.09436801e-02f, 1.58821926e-01f, 9.10757408e-02f, 6.62457794e-02f, 8.27087276e-03f,
  -2.88579683e-03f, 4.60922625e-03f, 5.44036739e-02f, -8.62082615e-02f, 8.35409611e-02f, -1.61038801e-01f, 4.56675440e-02f, 1.15195975e-01f, -1.55765014e-02f, 3.39813121e-02f,
  1.17109947e-01f, -1.19262934e-01f, 6.96001202e-02f, 1.34622017e-02f, 7.39013478e-02f, -6.45916238e-02f, 4.25109034e-03f, -1.19844399e-01f, 1.37857303e-01f, 5.61815389e-02f,
  5.67463934e-02f, 5.97181991e-02f, -4.74990830e-02f, 1.40671015e-01f, -1.30678564e-01f, 1.23175122e-01f, 2.38611121e-02f, 3.16539258e-02f, -2.55228747e-02f, -1.08207107e-01f,
  -3.44458222e-02f, -1.79371074e-01f, -5.59917130e-02f, -1.12325259e-01f, 5.37349246e-02f, -4.97615598e-02f, 2.61326060e-02f, -5.14273569e-02f, -2.58428026e-02f, -8.20969418e-02f,
  -1.25657823e-02f, -4.30250354e-02f, -7.14143887e-02f, 1.32852420e-01f, 1.45921484e-01f, -1.76804569e-02f, 9.60149541e-02f, 2.77853608e-02f, 3.85862142e-02f, -9.76335332e-02f,
  -2.96371635e-02f, 8.36611763e-02f, -8.96070339e-03f, -3.09618358e-02f, 1.44706488e-01f, -3.35692801e-02f, 7.65578821e-02f, -6.98932707e-02f, -1.80348441e-01f, -5.98199666e-02f,
  2.33709902e-01f, -4.37285639e-02f, 4.45628259e-03f, -7.17276931e-02f, 9.78670120e-02f, 4.77417000e-02f, -2.06996247e-01f, -6.72849715e-02f, 3.75945978e-02f, -1.52602389e-01f,
  -6.51397109e-02f, 1.19224913e-01f, 1.76913083e-01f, -6.82562962e-03f, 1.26592636e-01f, -4.30249572e-02f, 6.62109107e-02f, 3.23937535e-02f, 1.77074131e-02f, 5.41042089e-02f,
  1.78798437e-01f, -1.61982954e-01f, -8.24984461e-02f, 1.03284016e-01f, -6.77722916e-02f, 1.26398318e-02f, 3.16471905e-02f, -3.09467558e-02f, -5.39673828e-02f, -1.03960009e-02f,
  -6.25235438e-02f, -1.16719283e-01f, -8.77155513e-02f, -1.82306886e-01f, -1.18143559e-01f, -1.15914121e-02f, 6.82007223e-02f, 1.40268460e-01f, -7.52630383e-02f, 6.17197156e-02f,
  -4.02510241e-02f, 2.60016322e-01f, 5.24622276e-02f, -7.21671432e-02f, 1.02971271e-01f, -1.54777654e-02f, 1.92228541e-01f, -1.80137470e-01f, -1.36436433e-01f, 1.55016974e-01f,
  1.65343806e-02f, 5.63887618e-02f, -1.70777410e-01f, -4.85280268e-02f, -8.65672678e-02f, -1.42013088e-01f, -3.15353423e-02f, -3.99190597e-02f, -2.55222246e-02f, -9.49909985e-02f,
  -1.20667256e-01f, -4.64558452e-02f, 6.90782666e-02f, -1.20713271e-01f, -7.57985190e-02f, -1.01544052e-01f, -6.95773587e-02f, 1.35894895e-01f, 1.66223163e-03f, 1.52326137e-01f,
  -1.04353182e-01f, 4.37820926e-02f, -1.18351154e-01f, 1.72576442e-01f, 4.63592969e-02f, -4.87955697e-02f, -1.74644306e-01f, -1.11503445e-01f, -1.50341764e-01f, -2.21780315e-01f,
  -1.22677304e-01f, 1.36973754e-01f, -2.18934730e-01f, -6.79219589e-02f, -1.62350446e-01f, 8.44215304e-02f, 1.14294484e-01f, -6.05640262e-02f, -1.82988301e-01f, 1.15967840e-01f,
  1.45761117e-01f, -1.19803743e-02f, -8.14110413e-02f, 1.49833336e-01f, 2.79837064e-02f, 2.59727418e-01f, 4.33177724e-02f, -2.25523412e-02f, 1.45939782e-01f, -9.37472805e-02f,
  1.02502011e-01f, -2.00507581e-01f, -1.15199365e-01f, -2.43827105e-02f, -1.49228454e-01f, -5.32951169e-02f, -2.43938286e-02f, -1.07434988e-01f, -8.75066370e-02f, -1.57621354e-01f,
  1.05375715e-01f, -2.21481219e-01f, -1.98437259e-01f, -1.63180083e-01f, -1.71235308e-01f, -1.08914815e-01f, -1.03067448e-02f, -8.22865069e-02f, 6.75748214e-02f, -2.35133190e-02f,
  -1.36882156e-01f, -1.01736464e-01f, -2.05286697e-01f, -2.12359786e-01f, 9.39075053e-02f, 1.70619011e-01f, 1.75005242e-01f, 6.50087669e-02f, -4.12695795e-01f, 1.24546640e-01f,
  -1.12513408e-01f, 1.64743528e-01f, 1.68311521e-01f, 1.47809032e-02f, 1.40267536e-01f, 1.94042921e-01f, -1.79819390e-01f, 1.63612038e-01f, 1.26136839e-01f, 1.00939579e-01f,
  -1.79199964e-01f, -5.61674051e-02f, 4.74042073e-02f, 2.63631761e-01f, 1.38727322e-01f, -1.70912564e-01f, 2.34149247e-02f, -5.32832071e-02f, -2.73020491e-02f, 1.71887875e-01f,
  2.56304704e-02f, -3.91594544e-02f, -1.30415902e-01f, 9.77533460e-02f, 3.76999676e-02f, 3.55478632e-03f, 9.69985351e-02f, -5.93617857e-02f, 1.85928475e-02f, 1.36533514e-01f,
  -9.12859589e-02f, 4.02627401e-02f, 1.04052313e-01f, -1.70135275e-01f, 1.29699809e-02f, -8.73540267e-02f, 7.66980648e-02f, 1.66252702e-01f, -3.74183953e-02f, 1.36694074e-01f,
  7.56685883e-02f, 8.86662230e-02f, -4.10529375e-02f, 4.01351862e-02f, -7.64404684e-02f, -3.44355553e-02f, 1.18897609e-01f, 4.34916951e-02f, 1.07402481e-01f, -7.70580992e-02f,
  -6.22802833e-03f, -7.12219300e-03f, 1.27046525e-01f, 1.42850220e-01f, -8.27115402e-02f, -2.23748162e-02f, -8.20424855e-02f, 7.34581947e-02f, 7.47793820e-03f, -6.89861476e-02f,
  1.18694380e-01f, -1.01523884e-01f, 1.86870947e-01f, 8.22667703e-02f, 1.39807180e-01f, 1.24803208e-01f, -1.87938929e-01f, -1.07962914e-01f, -1.58468056e-02f, -6.03432469e-02f,
  1.50876209e-01f, -1.24756999e-01f, -2.35119238e-02f, -2.10259274e-01f, 1.22096516e-01f, -1.29786983e-01f, -1.92043692e-01f, -1.19236656e-01f, 7.01674968e-02f, -7.59885758e-02f,
  -9.27363336e-02f, -1.19074747e-01f, 5.00696264e-02f, -6.68536425e-02f, -1.42202387e-02f, -1.14578478e-01f, -1.71015128e-01f, -3.39494795e-02f, 1.38522340e-02f, 1.27177387e-01f,
  7.95013607e-02f, 1.37984917e-01f, -3.12142130e-02f, -3.01701743e-02f, -3.76661159e-02f, 1.65574163e-01f, 4.15390842e-02f, -4.39189263e-02f, -1.02223732e-01f, -3.73358876e-01f,
  -1.38029354e-02f, -4.77871187e-02f, 9.48989838e-02f, -1.72384292e-01f, 1.15549631e-01f, 9.55050141e-02f, 3.44323292e-02f, -1.49309143e-01f, -5.05718682e-03f, 8.06040540e-02f,
  -8.75480548e-02f, 1.61878571e-01f, 1.47322835e-02f, -2.02183276e-02f, -8.51017982e-02f, -1.80976167e-01f, 4.05497067e-02f, 2.35397182e-02f, -2.11979859e-02f, 2.36362144e-02f,
  -4.14187908e-02f, -1.52792230e-01f, -6.90647140e-02f, 9.63637009e-02f, -1.57566026e-01f, -3.25652733e-02f, 1.94698378e-01f, -8.60672146e-02f, 6.30941913e-02f, 4.92720380e-02f,
  -2.88084690e-02f, -3.33934650e-02f, -1.23134561e-01f, -1.19638540e-01f, 1.85743257e-01f, -1.31411208e-02f, -5.75804636e-02f, -4.27649766e-02f, 1.51252821e-01f, -4.87987660e-02f,
  -1.50859147e-01f, -5.70229776e-02f, -2.11505279e-01f, -1.14217460e-01f, 5.29321507e-02f, -1.50303110e-01f, -7.30650499e-02f, 2.14362470e-03f, 9.49864164e-02f, 1.30134672e-01f,
  2.05165055e-03f, -8.56680498e-02f, -1.28481328e-01f, 1.66519836e-01f, 6.49127066e-02f, 4.51515056e-02f, 2.88213082e-02f, -5.35265021e-02f, 5.47587266e-03f, 8.28289911e-02f,
  -5.94892204e-02f, 1.39192894e-01f, -1.15464717e-01f, -2.03030296e-02f, -3.74659034e-03f, -4.56843013e-03f, -4.64996845e-02f, -1.71624050e-01f, 6.81098327e-02f, 7.98184797e-02f,
  -1.09236501e-01f, -1.79159507e-01f, 8.22803751e-02f, -1.28118843e-02f, 1.73956472e-02f, -1.61904413e-02f, 5.61222853e-03f, 7.54363555e-03f, -6.13832995e-02f, -1.01454660e-01f,
  -7.20564425e-02f, 2.69373897e-02f, 1.35893241e-01f, -3.99897248e-03f, 1.18917376e-02f, -2.52248943e-02f, 2.30659917e-01f, 2.56400760e-02f, 1.59381758e-02f, 4.92194854e-03f,
  -2.40270160e-02f, -8.70048627e-03f, -3.99461575e-02f, -5.05687371e-02f, 1.51970610e-01f, 1.90607026e-01f, -8.27627704e-02f, 1.43140629e-01f, -1.51052848e-01f, 1.13004871e-01f,
  -6.75876439e-02f, 1.39431953e-01f, -4.84743528e-02f, 7.13161528e-02f, 1.85431764e-01f, 6.09255470e-02f, -3.07768658e-02f, -9.56822038e-02f, 5.48555255e-02f, 1.24838673e-01f,
  1.10275984e-01f, 3.52968760e-02f, 4.30954322e-02f, 1.64494142e-02f, -4.62522916e-02f, -5.43231294e-02f, -7.44794216e-03f, -1.53915897e-01f, 1.50855497e-01f, -3.79625782e-02f,
  6.21883199e-02f, -7.24770576e-02f, 1.02621935e-01f, -9.92797092e-02f, -1.25473231e-01f, -1.55173406e-01f, 4.85658012e-02f, 6.99427426e-02f, -9.32606012e-02f, 9.72068682e-03f,
  -1.19356163e-01f, 1.77594900e-01f, -6.33206293e-02f, -5.99171184e-02f, 1.14074498e-01f, -1.00524621e-02f, -1.66127216e-02f, -1.87611014e-01f, 4.90245819e-02f, 7.56473094e-02f,
  -7.70233665e-03f, 1.11044951e-01f, -5.59923872e-02f, 2.10131854e-02f, -2.58624107e-02f, -3.68595198e-02f, -4.30982597e-02f, -3.51115428e-02f, 8.59161001e-03f, -1.61410972e-01f,
  -2.35519528e-01f, -1.26456380e-01f, -8.63949358e-02f, -2.04154536e-01f, 3.83662917e-02f, -1.72298700e-01f, 1.00484930e-01f, 4.83594313e-02f, -1.35806307e-01f, 5.16033210e-02f,
  -1.43921794e-02f, 7.32788965e-02f, -1.60922483e-02f, 1.76148295e-01f, 9.98543873e-02f, 7.46540502e-02f, -6.42443821e-03f, -1.99689984e-01f, 1.09970428e-01f, -2.87014335e-01f,
  1.84439414e-03f, 1.18972927e-01f, -1.59701228e-03f, -1.03853531e-01f, -9.53680053e-02f, -4.20272537e-02f, -3.38150784e-02f, -4.65211906e-02f, -1.16799131e-01f, 1.11664914e-01f,
  -2.40247305e-02f, 3.28414172e-01f, 4.84661385e-02f, 1.08378798e-01f, -1.50778085e-01f, 1.82920426e-01f, -3.63825783e-02f, -1.42636567e-01f, 7.58071542e-02f, 6.97027659e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.10964835e-01f, -1.03963993e-01f, 1.58648297e-01f, 7.23465234e-02f, 6.08693846e-02f, -1.10738665e-01f, -8.47316384e-02f, -5.88887148e-02f, -5.76105155e-02f, 7.79687986e-02f,
  9.55791548e-02f, 1.51104685e-02f, 4.49683629e-02f, 5.67151234e-02f, -9.92869958e-02f, -6.34980574e-02f, 1.74508970e-02f, -7.99070075e-02f, -9.38736573e-02f, 8.02077204e-02f,
  -3.87979299e-02f, 1.10748373e-01f, -2.90721399e-03f, 1.05801061e-01f, 9.04699415e-02f, 9.61849093e-02f, -8.57575238e-02f, 7.77889788e-02f, 6.95824111e-03f, 8.54056552e-02f,
  9.14345458e-02f, -1.03303738e-01f, -4.51804660e-02f, -4.92051523e-03f, 1.20141491e-01f, -9.40838456e-02f, -4.27249819e-02f, -9.09838527e-02f, -8.77225026e-02f, -1.06269484e-02f,
  -5.67989908e-02f, -1.60794016e-02f, -6.84531182e-02f, 1.90101359e-02f, 1.16631314e-01f, -3.73714715e-02f, 2.15969309e-02f, 1.53576769e-02f, 8.39649364e-02f, -6.83379918e-02f,
  -1.64292324e-02f, 9.60448310e-02f, -3.49851474e-02f, -1.06535703e-01f, -1.93990190e-02f, 6.91476241e-02f, 7.53962323e-02f, 1.06940642e-01f, -9.04665813e-02f, 4.64237183e-02f,
  1.30289450e-01f, 4.25682170e-03f, -1.69959255e-02f, 2.73045003e-02f, -6.19558431e-02f, -1.88692566e-02f, 2.91785225e-02f, -5.92405200e-02f, 1.76916979e-02f, -1.85729954e-02f,
  6.83013201e-02f, -1.05624795e-01f, 9.88220200e-02f, -9.44069251e-02f, 1.09989747e-01f, -1.55260311e-02f, -1.47720603e-02f, 1.09755814e-01f, -4.25918661e-02f, -3.38663533e-02f,
  -1.00601785e-01f, 1.25322193e-01f, -7.46268183e-02f, 2.72460375e-02f, -1.08227842e-01f, 9.01315883e-02f, -8.26231912e-02f, 3.60903665e-02f, -4.19130607e-04f, -1.36817455e-01f,
  -1.21548794e-01f, -7.55324811e-02f, 1.68860674e-01f, -1.80209670e-02f, -1.55947795e-02f, 4.12102640e-02f, -3.89666520e-02f, 3.67221236e-02f, -1.51529416e-01f, 1.72940046e-02f,
  -2.79058795e-02f, 8.21256489e-02f, 1.12442866e-01f, 5.12537453e-03f, -2.96263732e-02f, 1.49232000e-02f, 1.14210337e-01f, -5.36157973e-02f, -1.29914030e-01f, -2.93987058e-02f,
  1.20694451e-02f, 4.38407920e-02f, -2.76065879e-02f, 1.38202161e-02f, 7.19568180e-03f, -1.21823929e-01f, -9.17600766e-02f, 5.15998118e-02f, -1.05180271e-01f, 1.15504429e-01f,
  2.64391042e-02f, -9.73483771e-02f, 5.04976325e-03f, 1.25312328e-01f, 3.30675207e-02f, -5.45294881e-02f, 3.04925665e-02f, -1.09134488e-01f, -3.28896046e-02f, -1.97736081e-03f,
  -6.99234158e-02f, 8.81962925e-02f, -1.00297041e-01f, -5.15303649e-02f, -1.58206082e-03f, 7.93462247e-02f, 6.01939149e-02f, -1.85091216e-02f, 8.39902461e-02f, 9.22999978e-02f,
  3.10851354e-02f, 7.58812577e-02f, -3.58891464e-03f, -2.53156908e-02f, -5.03438246e-03f, 1.14589177e-01f, 3.87396291e-02f, -5.66941090e-02f, -1.40565243e-02f, -6.41191080e-02f,
  -6.42591268e-02f, -2.78795101e-02f, -1.02841482e-03f, 9.72011536e-02f, -1.00963973e-01f, 1.14964187e-01f, 7.75367916e-02f, 1.43058226e-01f, 5.67436665e-02f, 4.17898856e-02f,
  -4.09912225e-03f, -5.85966595e-02f, -9.93422884e-03f, 1.27636030e-01f, 1.01934105e-01f, -1.21282088e-02f, 1.29088655e-01f, 1.00625321e-01f, -9.21894982e-02f, 9.55616832e-02f,
  -1.15820765e-01f, 4.53415811e-02f, 7.24019781e-02f, 8.44762251e-02f, 2.90731620e-02f, 1.22601390e-02f, -1.07492559e-01f, 1.25922099e-01f, -6.59125373e-02f, 1.12036876e-01f,
  -1.01854559e-03f, 4.72872239e-03f, 8.08966458e-02f, 2.51330510e-02f, 8.63096789e-02f, -6.20417017e-03f, 5.40401302e-02f, 8.80894214e-02f, -8.35452154e-02f, -8.10691789e-02f,
  1.17517173e-01f, -9.58039761e-02f, -1.04965612e-01f, -4.54955362e-02f, -1.19276538e-01f, -1.07484899e-01f, -1.18859515e-01f, 9.89826620e-02f, 3.83494794e-02f, -9.91534293e-02f,
  -5.82537688e-02f, 9.69510823e-02f, 3.19202314e-03f, -4.68431190e-02f, -2.06601582e-02f, -5.33962995e-02f, -6.71270639e-02f, -3.21261100e-02f, 7.65992329e-02f, 9.16363820e-02f,
  1.37104290e-02f, 2.11512186e-02f, -4.83622923e-02f, -8.05417821e-02f, 1.05168335e-01f, -7.81009048e-02f, 1.26258478e-01f, 6.94550499e-02f, 6.55128360e-02f, 1.01031937e-01f,
  -1.02800809e-01f, 9.72511098e-02f, -6.83337227e-02f, 2.26153471e-02f, 1.11943418e-02f, -2.37264913e-02f, -1.22537814e-01f, -2.56700665e-02f, -8.09403956e-02f, -2.76765767e-02f,
  -5.02146110e-02f, 1.26925036e-01f, -1.04073197e-01f, -8.63335505e-02f, 2.59947628e-02f, -4.59512509e-02f, -1.03148706e-01f, 3.21521796e-02f, -1.21990994e-01f, 7.48705640e-02f,
  -1.29233688e-01f, 2.57777553e-02f, 3.49858366e-02f, -1.04694381e-01f, 3.53675447e-02f, 9.19427276e-02f, 4.51533720e-02f, -1.06148943e-01f, -5.20348959e-02f, -4.57463898e-02f,
  -7.99828768e-02f, 1.35521665e-01f, -7.96351209e-02f, -9.96704251e-02f, -5.28684370e-02f, 3.94115262e-02f, -5.49254678e-02f, -1.08087048e-01f, 4.49508354e-02f, -7.36035705e-02f,
  1.10842869e-01f, 8.77341479e-02f, -2.96004917e-02f, -1.05400190e-01f, -5.69033623e-02f, 2.69753486e-02f, 1.11826009e-03f, -6.15428537e-02f, 3.55697498e-02f, -6.49627950e-03f,
  9.89392921e-02f, -3.74894589e-02f, -6.82452917e-02f, -7.98743963e-02f, 1.13129208e-03f, 3.30245346e-02f, -3.57149541e-02f, -9.89877284e-02f, -8.02535862e-02f, 8.44301432e-02f,
  -2.19654921e-03f, 1.19082563e-01f, 2.82783769e-02f, -1.12499595e-01f, 1.11796468e-01f, -8.29826072e-02f, -1.31431622e-02f, 7.87406936e-02f, -5.92815354e-02f, -5.03965653e-02f,
  -9.90805700e-02f, -3.23702730e-02f, -2.43453495e-02f, -9.23069566e-02f, -6.21638820e-02f, -9.88629311e-02f, -1.49975382e-02f, 1.26764685e-01f, 5.24433479e-02f, 1.02673925e-01f,
  7.73092136e-02f, 8.97938907e-02f, -6.88271075e-02f, -3.04768588e-02f, 1.21293463e-01f, -1.06980242e-01f, 1.48155605e-02f, -1.17248029e-01f, 1.53080449e-02f, 1.22002058e-01f,
  8.41840580e-02f, -3.39282975e-02f, 2.03512087e-02f, -1.11445755e-01f, 1.40638053e-02f, 1.52711328e-02f, 1.14041448e-01f, 9.78499502e-02f, -2.77524143e-02f, 1.27505615e-01f,
  -3.29152532e-02f, -2.22708471e-02f, -9.75628719e-02f, -6.48136809e-02f, -7.75087997e-02f, -1.00587703e-01f, 1.75744016e-02f, 3.07294019e-02f, -5.21182641e-02f, -7.00970590e-02f,
  -1.14163168e-01f, 1.02483466e-01f, -6.87761977e-02f, -4.33222484e-03f, -1.01289921e-01f, 8.85207728e-02f, 6.31423891e-02f, 4.71187793e-02f, -6.87440336e-02f, -4.84016128e-02f,
  -2.84010340e-02f, 5.86917251e-02f, -1.12194158e-01f, -6.67571127e-02f, 6.10301495e-02f, -4.11876813e-02f, -6.49849549e-02f, -5.57662360e-02f, -1.09329205e-02f, 7.59346187e-02f,
  6.46110997e-02f, 1.09254226e-01f, 2.64678039e-02f, -8.45240653e-02f, 3.74835059e-02f, 1.20160513e-01f, -1.12851195e-01f, 6.97895661e-02f, -9.35267936e-03f, -4.85276105e-03f,
  9.71389003e-03f, 9.55640897e-03f, 2.76677664e-02f, 6.46086186e-02f, -6.48541301e-02f, 2.53604865e-03f, -4.30685282e-02f, -8.43929797e-02f, -2.27963421e-02f, -2.58750450e-02f,
  1.11930296e-01f, -6.01210669e-02f, -1.10569224e-01f, -1.01848304e-01f, -8.53088945e-02f, -4.16624323e-02f, -3.19688581e-02f, -2.18948792e-03f, -7.97003806e-02f, -4.12436165e-02f,
  7.13055432e-02f, -5.36806248e-02f, -9.28826481e-02f, -7.34347105e-02f, 1.18823901e-01f, -7.86712617e-02f, -1.10015549e-01f, 4.10988852e-02f, -4.51600589e-02f, 6.41341582e-02f,
  -8.20892081e-02f, 7.94209689e-02f, 1.21958211e-01f, -1.49092944e-02f, -1.13664888e-01f, -8.47642496e-02f, 3.14034596e-02f, -3.96444909e-02f, 1.39730304e-01f, 5.47392778e-02f,
  -4.26617730e-03f, 4.98190448e-02f, -8.07151943e-02f, 8.72168094e-02f, -5.00484928e-03f, 6.31938279e-02f, 9.84148458e-02f, 2.13262606e-02f, -9.77291092e-02f, -6.54739439e-02f,
  -9.65085104e-02f, -1.47415906e-01f, -1.67766921e-02f, -1.41771525e-01f, -7.10984915e-02f, 9.71842632e-02f, -1.17686324e-01f, -9.71172005e-02f, 6.20705783e-02f, -2.47827694e-02f,
  1.27813807e-02f, -2.91900598e-02f, -9.76388007e-02f, 5.75947501e-02f, -6.27331883e-02f, 6.12128675e-02f, -9.78730470e-02f, 3.36403698e-02f, 3.02415956e-02f, -1.92753854e-03f,
  4.18482460e-02f, -1.11126982e-01f, 5.82479797e-02f, -2.97208503e-03f, 2.73456089e-02f, -8.93088058e-02f, 4.71582264e-02f, -4.60020117e-02f, -9.30507258e-02f, -7.50295864e-03f,
  -6.60626218e-03f, 5.95330633e-02f, -3.51564102e-02f, 9.72734392e-02f, -3.72270383e-02f, -9.46380123e-02f, -5.57405390e-02f, -9.30430717e-04f, 1.38156489e-01f, 3.85243110e-02f,
  1.14203840e-01f, -7.26438910e-02f, 6.99489936e-02f, -1.70402955e-02f, 7.21321180e-02f, -2.79546659e-02f, 1.15367256e-01f, -4.42149602e-02f, -7.91800953e-03f, 7.90984854e-02f,
  3.08679752e-02f, -7.09178597e-02f, 5.67930415e-02f, -1.20348874e-02f, 1.96402356e-01f, 1.61613896e-01f, 1.84088259e-03f, -7.21347928e-02f, 1.79999933e-01f, 4.04766537e-02f,
  1.15565717e-01f, 1.27468839e-01f, 3.86892743e-02f, 1.25969574e-01f, -4.89869751e-02f, 3.20175029e-02f, -6.92752898e-02f, -1.10557526e-01f, 6.88918903e-02f, 2.87550148e-02f,
  5.60379326e-02f, -1.40489280e-01f, 1.14697084e-01f, 1.11814290e-01f, 1.65543314e-02f, -2.00460795e-02f, -1.14782006e-01f, -4.50353846e-02f, -4.20601815e-02f, 8.65386799e-02f,
  -3.35292593e-02f, 1.59685045e-01f, -3.70464250e-02f, -5.06286584e-02f, 1.02457376e-02f, 1.31406754e-01f, 1.66390091e-01f, -5.64366020e-02f, -5.43812625e-02f, 1.20266579e-01f,
  1.86960205e-01f, 6.03426695e-02f, -1.25389263e-01f, -1.29109085e-01f, -4.83407229e-02f, -3.38636674e-02f, 2.95062549e-02f, -1.72770798e-01f, -4.77121100e-02f, 1.73323527e-02f,
  -5.01366295e-02f, 1.37881249e-01f, 1.04513295e-01f, 5.74679673e-02f, 2.05742747e-01f, -1.34394720e-01f, 1.09923854e-01f, -6.01062402e-02f, 9.09071118e-02f, -2.00576172e-03f,
  -5.28455786e-02f, -6.01122752e-02f, 4.30501625e-02f, 1.50885582e-01f, 1.37743384e-01f, 1.56584069e-01f, -4.56076115e-02f, 1.10102452e-01f, 1.28776357e-01f, -7.29800062e-03f,
  3.23769785e-02f, 1.65861875e-01f, -5.09510143e-03f, 2.03243360e-01f, 1.36325300e-01f, 1.19606733e-01f, 9.77359433e-03f, 1.29016293e-02f, 4.33399789e-02f, 1.43588454e-01f,
  -2.96825934e-02f, 1.27465948e-01f, 1.37425870e-01f, -1.91509455e-01f, 5.24302199e-02f, -6.77798092e-02f, -2.31525615e-01f, 3.59188509e-03f, 4.08396684e-02f, -1.17953494e-01f,
  9.24749300e-02f, 9.98473987e-02f, 1.35942232e-02f, 7.41207823e-02f, -3.07554826e-02f, -3.23579423e-02f, 4.09028679e-02f, 2.05585230e-02f, 9.05484855e-02f, 5.75387590e-02f,
  -2.10637762e-03f, -2.23147705e-01f, -8.97549093e-02f, -1.36702180e-01f, 7.20561221e-02f, -5.86385690e-02f, -1.54485479e-01f, -1.41703784e-01f, -2.68116798e-02f, -2.55022775e-02f,
  -9.44087356e-02f, -1.30461976e-01f, -9.08587053e-02f, -2.39023962e-03f, -1.20416293e-02f, 5.49347065e-02f, 1.05647907e-01f, -8.47935304e-02f, 1.60324812e-01f, -8.67254660e-02f,
  4.54849273e-04f, 1.92637034e-02f, -4.70468104e-02f, 1.41398087e-01f, 1.03971176e-01f, 1.62723809e-02f, 4.12359871e-02f, 9.80412588e-02f, -2.73702815e-02f, 1.51029304e-01f,
  1.75180003e-01f, 1.57428216e-02f, 1.94043554e-02f, -3.91880870e-02f, 3.82652692e-02f, -3.23427655e-02f, -7.59267360e-02f, 1.45956883e-02f, 1.74826160e-01f, 8.52313638e-02f,
  -6.80017024e-02f, 4.03176621e-02f, -1.48224384e-02f, -8.10894519e-02f, -3.21096159e-03f, -1.16852872e-01f, 1.04858287e-01f, 2.59558186e-02f, -8.19189195e-03f, -1.61451861e-01f,
  -1.10570796e-01f, -9.61240977e-02f, 4.15533222e-02f, -1.20240301e-01f, -5.45639731e-02f, 3.32116298e-02f, 1.75372019e-01f, 1.17160834e-01f, -7.87572339e-02f, 1.48897348e-02f,
  -3.15687843e-02f, 1.34710163e-01f, 1.36716589e-01f, -1.41397879e-01f, -4.01198342e-02f, -1.25696331e-01f, -1.29751831e-01f, 4.11854088e-02f, 6.13792799e-02f, -2.93770917e-02f,
  -1.14560463e-01f, -5.74498698e-02f, 6.08521327e-02f, -4.03256156e-02f, -5.11422940e-02f, -1.45054430e-01f, -3.55080254e-02f, -2.54326966e-02f, 3.17753032e-02f, 3.03984936e-02f,
  -5.67174628e-02f, -7.97798634e-02f, 1.14300206e-01f, -5.51884770e-02f, -2.93917470e-02f, -1.02472000e-01f, -8.52302685e-02f, 3.60306278e-02f, -2.95972005e-02f, 1.05859950e-01f,
  -1.97548722e-03f, -7.75174471e-03f, -4.56920676e-02f, -6.80187196e-02f, -2.69939639e-02f, 1.23116635e-01f, 6.67426586e-02f, -5.32997325e-02f, 5.99779375e-02f, 5.09206466e-02f,
  3.37143876e-02f, 8.23553354e-02f, -6.95484579e-02f, -4.21237089e-02f, 2.03117728e-02f, 8.48965049e-02f, 1.58900861e-02f, -2.98000965e-02f, -1.05297692e-01f, -9.86503344e-03f,
  9.63487774e-02f, -9.63234454e-02f, 5.35598882e-02f, 8.50451142e-02f, -1.55155569e-01f, -5.89864217e-02f, 1.73017774e-02f, 1.15104355e-01f, -1.37468696e-01f, 4.93222103e-02f,
  -4.23668921e-02f, -6.53734952e-02f, 5.97930513e-02f, 3.51053886e-02f, 6.95749819e-02f, 1.07007354e-01f, 6.05655946e-02f, 1.72291193e-02f, 1.14063382e-01f, 8.32791701e-02f,
  -3.75538059e-02f, 1.82941277e-02f, -5.79470303e-03f, -1.11355640e-01f, -2.63158251e-02f, -6.75801411e-02f, 1.07018404e-01f, 1.02114774e-01f, 7.45193986e-03f, -1.26741052e-01f,
  6.44286573e-02f, -4.72643562e-02f, -4.18584123e-02f, 1.29221842e-01f, 8.29342287e-03f, 8.52917728e-04f, 5.71386963e-02f, -1.01749249e-01f, 1.03825219e-02f, 7.08455034e-03f,
  1.18176401e-01f, 7.08781704e-02f, 1.14084467e-01f, -2.50595715e-02f, 4.44835238e-02f, 7.81148970e-02f, 1.68168731e-03f, 9.75490734e-02f, 2.05726679e-02f, 7.51820058e-02f,
  -4.34797034e-02f, 9.90257412e-03f, -4.47470471e-02f, -7.60287344e-02f, -3.34228314e-02f, 1.80619229e-02f, -5.38567780e-03f, 3.24585512e-02f, 8.60000122e-03f, -1.25076979e-01f,
  3.85106429e-02f, -5.84763773e-02f, 1.02688715e-01f, -9.57829729e-02f, 4.18403968e-02f, 7.25798905e-02f, -1.97786950e-02f, -2.96984520e-02f, -1.49272576e-01f, 5.39024323e-02f,
  -1.21039925e-02f, 1.17697887e-01f, -7.11620674e-02f, 1.11624062e-01f, 8.20285901e-02f, -1.59977585e-01f, 9.67125893e-02f, -1.73321426e-01f, 6.76932484e-02f, 1.77690238e-01f,
  1.15900762e-01f, -4.89253029e-02f, -9.50216651e-02f, 5.59977666e-02f, 7.75980651e-02f, 7.74627775e-02f, 8.20034519e-02f, -1.01284653e-01f, 1.30790949e-01f, 1.80852443e-01f,
  -7.54273906e-02f, 2.43504811e-02f, -1.22522954e-02f, 1.57247037e-01f, -8.04491416e-02f, -1.04515262e-01f, 1.36824418e-02f, -8.26394632e-02f, -7.29461089e-02f, 2.10847393e-01f,
  6.73027933e-02f, 4.85656597e-02f, 1.57454461e-02f, 3.57530192e-02f, 1.30879164e-01f, -3.26125957e-02f, 3.98758538e-02f, 1.17163017e-01f, 3.15303206e-02f, -2.98922770e-02f,
  1.50887713e-01f, -4.42403667e-02f, 1.28455788e-01f, 7.19457641e-02f, -1.68480147e-02f, -3.77806835e-02f, -1.10047787e-01f, 1.89685803e-02f, -6.76332787e-02f, 1.22644857e-01f,
  -7.02216327e-02f, -3.93014681e-03f, -3.04278582e-02f, -1.67939007e-01f, 6.11439198e-02f, -1.16273269e-01f, -5.28277718e-02f, 4.55536544e-02f, -4.58105206e-02f, 3.68772037e-02f,
  -1.26172826e-01f, 1.30054116e-01f, 6.31257966e-02f, 1.53458146e-02f, 5.59905637e-03f, 1.00305177e-01f, 9.48238969e-02f, 4.43489254e-02f, -9.66234952e-02f, -1.01190589e-01f,
  -1.12582438e-01f, -4.77679484e-02f, -1.68062225e-02f, 1.51032448e-01f, -6.77710325e-02f, -3.76815721e-02f, 6.46905079e-02f, -8.18258226e-02f, -8.19346830e-02f, -2.28207977e-03f,
  -1.42855078e-01f, 9.40851569e-02f, 5.30871972e-02f, 2.15042040e-01f, -1.35172129e-01f, -5.16578667e-02f, 1.47939846e-02f, 2.45586380e-01f, 6.92970455e-02f, -1.89604927e-02f,
  6.79829195e-02f, -1.23296499e-01f, 1.12582751e-01f, -2.50928849e-02f, 4.98617860e-03f, 1.00794025e-01f, -8.59090835e-02f, 1.22287534e-01f, 9.53552425e-02f, -1.00140959e-01f,
  -5.88444471e-02f, -7.63198435e-02f, -8.18155333e-02f, 2.16159932e-02f, 7.92814270e-02f, -5.48839942e-02f, -9.78677720e-02f, 3.14113908e-02f, 2.84164511e-02f, 1.35322556e-01f,
  1.22602731e-01f, 6.86830729e-02f, 2.27958374e-02f, 1.28898453e-02f, -8.79702792e-02f, 1.21543467e-01f, 8.41290876e-02f, -9.54126716e-02f, 1.03709891e-01f, 1.19331896e-01f,
  3.50967310e-02f, 3.34995128e-02f, -6.02799058e-02f, -1.51012331e-01f, -3.49910893e-02f, 9.20116231e-02f, -7.21238405e-02f, 2.46840436e-02f, 5.55821396e-02f, 2.02677753e-02f,
  8.06093886e-02f, -1.17260851e-01f, -1.30086690e-01f, -5.05081788e-02f, 5.41409552e-02f, 5.02393655e-02f, -1.47451134e-02f, -1.16741158e-01f, -2.41957847e-02f, -8.27027410e-02f,
  7.92419836e-02f, 1.93950720e-02f, -7.69082829e-02f, 1.76319480e-02f, 2.48541608e-02f, 2.43073218e-02f, -9.29428861e-02f, -9.93051901e-02f, 2.59145908e-02f, -1.26735926e-01f,
  -9.74585041e-02f, 8.75443146e-02f, -5.07860333e-02f, -5.62578738e-02f, 1.04524054e-01f, -1.13770567e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -3.45433839e-02f, 3.32773365e-02f, 1.11572221e-01f, 3.20695490e-02f, 1.27454266e-01f, 1.19376667e-01f, 1.39498681e-01f, 5.74844442e-02f, 6.57157153e-02f, 7.04846904e-02f,
  1.32261664e-01f, 1.49118587e-01f, -6.49631470e-02f, -1.63502954e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  2.23610640e-01f, 1.34474412e-01f, 9.27609217e-04f, 2.70826612e-02f, -7.30514303e-02f, -1.06431745e-01f, -1.92196786e-01f, 1.24733016e-01f, 9.56798717e-02f, -1.17754005e-01f,
  -2.25921378e-01f, 6.42408477e-03f, -6.38018595e-03f, 6.55249506e-02f, 1.29528180e-01f, -1.80825517e-02f, 3.20072323e-02f, 1.51629969e-01f, 1.23400144e-01f, -1.09927334e-01f,
  1.76561594e-01f, 1.15023233e-01f, 1.41897067e-01f, -4.44471240e-02f, 9.15303081e-02f, -1.59780771e-01f, -4.09405157e-02f, 1.74828589e-01f, -7.32301101e-02f, -1.34133294e-01f,
  3.57279740e-02f, -6.88271224e-02f, -2.66229082e-02f, 1.69541821e-01f, 1.29558161e-01f, -1.25227049e-01f, 2.35486731e-01f, -1.29361317e-01f, 8.55073184e-02f, 1.64768532e-01f,
  1.59468517e-01f, 3.15677017e-01f, -7.21518463e-03f, -1.47279128e-01f, 2.89005131e-01f, 1.83946148e-01f, -1.92201987e-01f, -1.80679470e-01f, 2.86074877e-02f, 8.34376588e-02f,
  3.51258181e-02f, -7.70023614e-02f, 8.36383775e-02f, 9.43687633e-02f, -4.75898944e-02f, 7.13881105e-02f, 1.11219466e-01f, 9.79050323e-02f, -5.73670305e-02f, -7.11825192e-02f,
  -1.42416641e-01f, -2.55343877e-02f, 1.56138703e-01f, 1.12496518e-01f, 1.13916397e-01f, -4.67363484e-02f, -4.15451452e-02f, -1.11583918e-01f, -8.75409395e-02f, -5.09330593e-02f,
  -1.63913488e-01f, 4.64835390e-02f, -8.60775337e-02f, -1.05623659e-02f, -1.69175059e-01f, 7.40936399e-02f, 9.53325480e-02f, -1.32494941e-01f, 5.45620732e-02f, -5.55660948e-02f,
  3.39554325e-02f, 5.18387035e-02f, -4.55906503e-02f, 1.13999687e-01f, 4.93350513e-02f, 5.48458360e-02f, 4.95482236e-02f, 3.66427265e-02f, 5.21364110e-03f, 1.87956542e-02f,
  1.14766575e-01f, 3.06260973e-01f, 4.61757602e-03f, -1.94741577e-01f, 3.19762342e-03f, -1.56806871e-01f, -1.20950311e-01f, -2.46517491e-02f, 1.27171665e-01f, 6.39788285e-02f,
  1.53506890e-01f, -5.78242987e-02f, -2.83737574e-02f, 2.26658899e-02f, -1.02241710e-01f, 3.13632160e-01f, -9.95769631e-03f, -1.25431255e-01f, 8.84009302e-02f, 5.97353354e-02f,
  -1.10611811e-01f, -2.29017615e-01f, 7.03539774e-02f, 1.56918079e-01f, -1.51727991e-02f, -3.78754782e-03f, 1.05013587e-01f, 7.50265792e-02f, -1.38682965e-02f, 9.76793244e-02f,
  -5.67060597e-02f, -5.27762063e-02f, -7.19712600e-02f, -1.63255498e-01f, -6.73395768e-02f, -8.03466216e-02f, 1.44809633e-01f, 9.60849132e-03f, -4.32793647e-02f, 3.49064954e-02f,
  -7.78753459e-02f, 4.62982543e-02f, 8.42374712e-02f, -1.24300063e-01f, 8.57510716e-02f, -1.42060906e-01f, 3.32125300e-03f, 1.25948340e-01f, 1.18039757e-01f, -4.98190802e-03f,
  1.00308679e-01f, 1.06232077e-01f, -4.45490107e-02f, -1.21646449e-01f, 7.90008530e-02f, -9.15638134e-02f, 6.08087704e-02f, 3.64243947e-02f, -1.46391541e-01f, 8.78969878e-02f,
  -3.49965245e-02f, 1.12902515e-01f, -8.94829705e-02f, 4.65405807e-02f, -9.21830684e-02f, -3.12800288e-01f, 9.45134237e-02f, 4.98056971e-02f, 1.15863979e-01f, 7.53213987e-02f,
  1.11136317e-01f, -7.65464008e-02f, -1.70561671e-01f, -1.10201514e-03f, -1.44754738e-01f, 1.82525381e-01f, 3.04429047e-02f, -4.77360934e-03f, -1.35738000e-01f, -2.88946062e-01f,
  1.39672697e-01f, -1.09664258e-02f, -3.05838734e-02f, -2.35620160e-02f, -9.19365138e-02f, 1.79418206e-01f, 6.75014406e-02f, -2.64102202e-02f, 1.44452944e-01f, -7.47753084e-02f,
  -6.74452633e-03f, 9.11369100e-02f, 5.56552596e-02f, 1.01316154e-01f, 3.61894779e-02f, 1.15221515e-01f, -1.86824780e-02f, 1.75706074e-01f, 1.57009512e-01f, 1.59542352e-01f,
  -8.97597969e-02f, -8.44674334e-02f, 1.63853809e-01f, 1.01885468e-01f, 1.45596236e-01f, 1.37344554e-01f, 1.61728457e-01f, -7.40147680e-02f, -1.53627664e-01f, 1.56859487e-01f,
  -5.37697040e-02f, 2.99427025e-02f, -1.03609048e-01f, 4.35584858e-02f, -8.09429958e-03f, 9.88896191e-02f, 1.36374906e-01f, -6.89307302e-02f, -5.59480451e-02f, 1.72990963e-01f,
  9.10339803e-02f, 7.78706223e-02f, 1.87555850e-01f, 1.41290933e-01f, 4.39149514e-02f, 2.83079036e-02f, 1.37766138e-01f, -1.35706797e-01f, 2.17080235e-01f, 1.82916626e-01f,
  -1.29031790e-02f, -8.40217471e-02f, -1.18816286e-01f, -3.14769536e-01f, -6.82601035e-02f, 2.12835133e-01f, 1.84148818e-01f, -1.32278740e-01f, 1.88249528e-01f, -1.75116152e-01f,
  3.68140042e-02f, 1.63855135e-01f, 3.13672386e-02f, 4.12714869e-01f, -4.48726602e-02f, -1.71259701e-01f, 7.91798681e-02f, -3.99177931e-02f, 5.42084277e-02f, -2.17103243e-01f,
  9.77206677e-02f, 2.84488685e-03f, -6.94880486e-02f, 1.92918535e-02f, -1.81333516e-02f, 5.53183109e-02f, -7.28252232e-02f, 5.09527177e-02f, -9.12737027e-02f, 3.56923603e-02f,
  -1.36980325e-01f, 3.94774452e-02f, -1.36581719e-01f, -7.29702190e-02f, 1.03289314e-01f, 1.09774500e-01f, 1.87188908e-02f, 5.25766648e-02f, -6.33751899e-02f, 3.07362862e-02f,
  -1.17714934e-01f, -1.11812554e-01f, -1.02341868e-01f, -4.73489463e-02f, -1.55031234e-02f, -1.61677361e-01f, 3.85314450e-02f, 5.09758182e-02f, 7.36638159e-02f, -1.55075490e-01f,
  -8.26151222e-02f, 4.17547263e-02f, -9.42272767e-02f, 3.86970341e-02f, -4.81952652e-02f, -2.29997970e-02f, -6.13215519e-03f, 1.27856001e-01f, -1.17087355e-02f, -1.15584500e-01f,
  9.38480943e-02f, -9.46970806e-02f, 1.26817942e-01f, 1.31186262e-01f, 8.37612301e-02f, -2.54270546e-02f, -4.41703871e-02f, -1.86195429e-02f, -1.93835236e-02f, 4.83869202e-02f,
  1.83562011e-01f, 1.19943872e-01f, 2.22536236e-01f, -1.80364192e-01f, 5.75166680e-02f, -4.60193828e-02f, 2.40732171e-02f, 1.74920171e-01f, -2.86228713e-02f, -6.74659014e-02f,
  1.61800206e-01f, -2.53281184e-02f, -9.39964056e-02f, -2.30534419e-01f, 8.01006332e-02f, 8.10816661e-02f, 9.03454199e-02f, -7.26315603e-02f, 2.05229092e-02f, 1.99819691e-02f,
  -6.71092570e-02f, -5.74529059e-02f, 1.12747671e-02f, -1.35490850e-01f, -1.18439145e-01f, -2.00354114e-01f, -4.40012813e-02f, 8.94336775e-02f, 2.41377223e-02f, 8.06072354e-02f,
  9.33049396e-02f, -4.79070880e-02f, -1.23832732e-01f, 1.94147304e-02f, -6.71942085e-02f, 1.39711201e-01f, -5.60926050e-02f, -9.72427353e-02f, -5.57903945e-02f, 1.33212402e-01f,
  8.65338296e-02f, 8.78469050e-02f, -1.75444350e-01f, 5.54789491e-02f, 7.47410059e-02f, 1.39318123e-01f, -2.92361714e-02f, 4.52207625e-02f, -4.54794504e-02f, 4.44508195e-02f,
  1.76925417e-02f, -9.34213847e-02f, 5.52310757e-02f, -1.84727367e-02f, 1.52433172e-01f, -2.27063999e-01f, -2.22397953e-01f, -4.05666754e-02f, -6.18844014e-03f, 2.35316053e-01f,
  2.65913278e-01f, 1.76900551e-01f, -1.12263814e-01f, 1.95797291e-02f, -1.73557967e-01f, 7.61613697e-02f, -5.98286055e-02f, -1.24548912e-01f, -1.31498829e-01f, 1.25258982e-01f,
  5.91949224e-02f, -1.02645934e-01f, -2.93606203e-02f, 2.07386701e-03f, -1.57547116e-01f, 7.25995079e-02f, -3.89885232e-02f, 8.69615674e-02f, 1.41507620e-02f, -3.72215882e-02f,
  1.19743466e-01f, 6.45896867e-02f, -3.73628587e-02f, 1.01278737e-01f, 1.39375106e-01f, 5.83941676e-02f, 1.38079319e-02f, 1.63352966e-01f, 9.24298018e-02f, 1.37392372e-01f,
  -3.10630314e-02f, -9.86836329e-02f, -1.06618375e-01f, -5.37476800e-02f, 9.03529301e-02f, -7.25912908e-03f, 2.76523810e-02f, 5.33983037e-02f, -8.62519592e-02f, 7.15978518e-02f,
  -4.22668085e-02f, 1.81461200e-02f, 6.52856976e-02f, 4.11004685e-02f, -5.04267551e-02f, 2.44561229e-02f, -1.51595563e-01f, -7.62785897e-02f, 1.00285575e-01f, -1.50706461e-02f,
  3.43675166e-02f, -1.39691859e-01f, -1.43293925e-02f, -1.02401428e-01f, 2.34671906e-01f, 8.54623318e-02f, -1.10953845e-01f, -9.47092101e-02f, 2.32970193e-02f, -2.68072754e-01f,
  -1.06386192e-01f, -1.77128334e-02f, -1.17265195e-01f, 6.43965900e-02f, 2.73942530e-01f, -1.15568833e-02f, -7.14588612e-02f, 2.22976178e-01f, -1.94862664e-01f, 1.97440311e-01f,
  2.20962986e-01f, -1.96938142e-01f, -3.47971218e-03f, 1.10236578e-01f, 5.46222292e-02f, 2.09345352e-02f, -2.52064049e-01f, -2.03694388e-01f, -1.52527869e-01f, 3.23607355e-01f,
  -7.15791732e-02f, -2.00511053e-01f, -4.75795567e-02f, -2.05244422e-02f, 7.30759501e-02f, -1.47209868e-01f, 7.77897909e-02f, -2.55721100e-02f, -5.79919294e-02f, -6.19207695e-02f,
  -1.08069502e-01f, 1.72045738e-01f, -3.49615961e-02f, -3.69513929e-02f, 6.70266151e-02f, -1.03002816e-01f, -1.42213106e-02f, 6.81947991e-02f, -8.17120075e-02f, -9.66952294e-02f,
  -1.16495833e-01f, -8.71496201e-02f, -7.70778432e-02f, -6.90907985e-02f, 1.06612649e-02f, -1.23899601e-01f, 1.20508015e-01f, -7.77889416e-02f, -8.51023011e-03f, 7.85391554e-02f,
  7.10033402e-02f, -2.62376554e-02f, -1.08607017e-01f, -9.54452977e-02f, -2.86041405e-02f, -2.13579945e-02f, 7.03419298e-02f, 1.69988945e-01f, -6.91709220e-02f, -3.73807326e-02f,
  -6.97572343e-03f, 1.83274671e-02f, 1.10178635e-01f, 8.58711824e-02f, -2.69647568e-01f, 4.55334596e-02f, 1.60219952e-01f, 2.88618468e-02f, 1.74539983e-01f, 2.08476022e-01f,
  1.82750136e-01f, -1.65688485e-01f, -4.13868576e-02f, 2.14901477e-01f, 2.44801529e-02f, 2.12325305e-02f, -7.51271173e-02f, -9.59285945e-02f, -2.47538164e-01f, -1.22517027e-01f,
  8.86304751e-02f, 2.13284716e-01f, -2.01012060e-01f, -1.03318110e-01f, 4.22445163e-02f, -7.82328099e-02f, 2.00969562e-01f, -8.43432918e-02f, 8.16975608e-02f, 4.99885119e-02f,
  -8.68691504e-03f, 5.79543114e-02f, -7.82544315e-02f, -8.42812881e-02f, -1.00709327e-01f, -4.94103208e-02f, 1.64960518e-01f, 5.34698963e-02f, 1.55836582e-01f, 1.12617269e-01f,
  -4.12733294e-02f, 1.21927008e-01f, 9.73747596e-02f, 5.62471598e-02f, 1.10269472e-01f, -1.06640972e-01f, 4.82835993e-03f, -7.75746033e-02f, -1.07974611e-01f, 5.17654642e-02f,
  -5.31129427e-02f, 4.81427982e-02f, -7.45167434e-02f, -7.59961456e-02f, 8.80466253e-02f, -1.22517616e-01f, -6.88461065e-02f, 6.58150166e-02f, -1.48955613e-01f, -5.07202223e-02f,
  1.31267654e-02f, -1.18807323e-01f, 1.26008704e-01f, 5.28879315e-02f, -3.63109820e-02f, -6.33635521e-02f, -1.52291670e-01f, 3.08246892e-02f, 3.49445015e-01f, 6.62201792e-02f,
  -2.09183633e-01f, -2.71505266e-01f, -2.78501213e-01f, -1.15279198e-01f, -1.74253911e-01f, -2.43823249e-02f, -4.15661857e-02f, -2.45526314e-01f, -8.62333551e-02f, 8.40154290e-02f,
  6.26944518e-03f, 1.87120616e-01f, 1.40296027e-01f, 1.84901223e-01f, -1.99297797e-02f, -1.03665002e-01f, 4.29142751e-02f, -2.02558562e-01f, 9.88012105e-02f, 5.76792657e-02f,
  -1.02701664e-01f, 1.07561789e-01f, 3.04937791e-02f, -2.75156461e-03f, 7.69651234e-02f, -1.03078291e-01f, 1.60005856e-02f, 9.12847221e-02f, 7.77300540e-03f, -6.94913836e-03f,
  -2.34888762e-01f, -2.55597569e-02f, -1.14002913e-01f, 7.14995414e-02f, 1.45315072e-02f, -1.16863668e-01f, -1.53926030e-01f, 4.89157811e-02f, -2.28580534e-02f, 4.73869443e-02f,
  -2.53351834e-02f, -1.04863264e-01f, 6.53255060e-02f, -4.72358204e-02f, -2.07882077e-02f, 1.71397820e-01f, 3.37119162e-01f, -8.90541747e-02f, 1.01071611e-01f, 8.45202133e-02f,
  3.49147841e-02f, 1.62181452e-01f, 4.34846729e-02f, -3.80330865e-04f, 1.83821917e-01f, 9.79559347e-02f, 2.19384581e-02f, 9.90818888e-02f, 1.06097810e-01f, 1.64558575e-01f,
  7.62812719e-02f, 1.67507365e-01f, 9.14521813e-02f, -1.02048799e-01f, 1.37080163e-01f, 8.06393567e-03f, -1.24650717e-01f, 1.74061523e-03f, 2.36839354e-02f, -1.82037011e-01f,
  -6.21223152e-02f, -2.57629808e-02f, -2.28397205e-01f, 2.06509516e-01f, 2.08342522e-01f, 2.45328471e-02f, -7.64991045e-02f, -4.52392809e-02f, 1.22877367e-01f, 1.72687039e-01f,
  -2.61674255e-01f, -2.59957552e-01f, 2.26348743e-01f, 1.69751778e-01f, -1.49782211e-01f, -1.21274427e-01f, 1.27365351e-01f, -1.32369414e-01f, 1.43857277e-03f, 2.20350157e-02f,
  1.01597711e-01f, 7.68194646e-02f, -6.54908046e-02f, 1.00699820e-01f, 6.53554723e-02f, 9.56005827e-02f, -4.45386171e-02f, -1.40524030e-01f, -1.60554826e-01f, -7.66554028e-02f,
  1.44519761e-01f, 9.05011222e-02f, -4.15423103e-02f, -5.36943153e-02f, -1.16108125e-02f, 8.59473869e-02f, -2.90244520e-02f, -6.21970855e-02f, -3.69951054e-02f, -1.13921866e-01f,
  -2.01413020e-01f, 1.43731967e-01f, -1.33631647e-01f, -2.23705056e-03f, -6.47985637e-02f, 4.26717810e-02f, 2.28757970e-02f, 1.19457180e-02f, -9.21133533e-02f, -1.11327596e-01f,
  2.40515754e-01f, -8.83673802e-02f, -1.07939333e-01f, -1.43835202e-01f, 9.25441831e-02f, -1.13081802e-02f, -1.61681131e-01f, 2.32441798e-01f, -1.59491107e-01f, -8.56059324e-03f,
  1.65600792e-01f, -1.23872772e-01f, -1.12110585e-01f, 9.43859369e-02f, -8.24792385e-02f, -1.19875744e-01f, 1.11265905e-01f, -1.31242529e-01f, -1.50198177e-01f, 8.94414037e-02f,
  -3.95632982e-02f, 1.32192880e-01f, -1.76432535e-01f, -1.93392679e-01f, 6.97071254e-02f, 1.63010195e-01f, -1.96589723e-01f, -1.92284018e-01f, 1.01612769e-01f, 3.34986113e-02f,
  -8.02330952e-03f, 3.71474735e-02f, 1.05006166e-01f, -6.00906238e-02f, 2.68823449e-02f, -2.99573336e-02f, -9.37665403e-02f, -6.76382557e-02f, -1.39818937e-01f, -1.23132005e-01f,
  -5.66869155e-02f, -2.93423627e-02f, -1.46834217e-02f, -2.01248564e-03f, -7.36521482e-02f, -3.31703611e-02f, -1.93320774e-02f, 4.83454540e-02f, -6.42371550e-02f, 3.38952988e-02f,
  1.65351480e-01f, -4.26300056e-02f, 2.71345936e-02f, 4.01325077e-02f, -7.96091929e-02f, 3.01626194e-02f, 1.91933215e-01f, 3.91500592e-02f, -5.39615862e-02f, -9.24199969e-02f,
  -7.37626627e-02f, -5.67036532e-02f, -1.31865181e-02f, 8.45888779e-02f, -1.88491315e-01f, -7.32489154e-02f, 4.61151302e-02f, -8.39402527e-02f, -4.50284407e-02f, 2.37682432e-01f,
  -9.04731303e-02f, -2.38414258e-01f, -8.43623653e-02f, 6.04384281e-02f, -2.87396349e-02f, 5.44224717e-02f, -3.74906464e-03f, -2.65411943e-01f, 2.86212452e-02f, -8.23675618e-02f,
  -6.72070459e-02f, 2.38258943e-01f, 1.09987363e-01f, -1.51975617e-01f, 3.78452875e-02f, -2.24629298e-01f, 3.30949202e-02f, 1.92012952e-03f, -2.58136056e-02f, -1.29934207e-01f,
  3.02678440e-02f, 2.45725200e-01f, -1.79416358e-01f, 1.34881780e-01f, 1.12130053e-01f, 1.26078352e-01f, -1.45321801e-01f, -6.11236691e-02f, -7.63025507e-02f, -1.18338525e-01f,
  1.13891840e-01f, -1.28107190e-01f, 8.09773505e-02f, 1.08358860e-01f, 1.62615422e-02f, 6.23218715e-02f, -3.17773931e-02f, 5.32521605e-02f, 1.88116387e-01f, -2.87389029e-02f,
  4.01178300e-02f, -2.47304626e-02f, 8.27605575e-02f, -5.28093055e-03f, 1.33985896e-02f, -1.03118354e-02f, -2.02283249e-04f, -5.41735291e-02f, 1.29988939e-01f, 6.25409931e-02f,
  -4.38760668e-02f, 7.50214159e-02f, -2.65948791e-02f, -1.21178165e-01f, -9.46476385e-02f, -2.79362332e-02f, -6.68041930e-02f, 5.92734069e-02f, 1.92110855e-02f, 1.16999179e-01f,
  -5.18015474e-02f, 9.76959392e-02f, 2.12317541e-01f, 2.31247973e-02f, -3.08081090e-01f, 1.88986748e-01f, 1.18570291e-01f, 2.31520116e-01f, 1.23136349e-01f, 7.71181807e-02f,
  6.73228577e-02f, 1.15248680e-01f, -1.49163574e-01f, 2.71084815e-01f, 8.89243111e-02f, -1.66069627e-01f, -1.35957614e-01f, 1.06391624e-01f, -4.72254865e-02f, -7.81767890e-02f,
  -9.19820592e-02f, -6.16763495e-02f, -1.98898092e-01f, 1.78226620e-01f, -2.43605867e-01f, -1.64509237e-01f, 1.56661093e-01f, -4.23255153e-02f, -1.40750157e-02f, -1.03033826e-01f,
  9.64901820e-02f, 1.10291734e-01f, -8.14076364e-02f, 7.15093978e-04f, -1.55444682e-01f, 3.20286304e-03f, -1.00009121e-01f, 3.20028476e-02f, 8.45968276e-02f, 5.15347980e-02f,
  -1.39648527e-01f, 4.94000353e-02f, -7.42508247e-02f, -1.19210191e-01f, -9.38008651e-02f, -9.00161937e-02f, 3.75649817e-02f, 4.11331244e-02f, -2.26031765e-02f, -9.19991061e-02f,
  -1.13260120e-01f, 4.71650958e-02f, 1.51154295e-01f, 8.96331593e-02f, 2.20458768e-03f, 1.13089740e-01f, 1.02857739e-01f, 5.08722030e-02f, 4.99804094e-02f, -4.45392504e-02f,
  2.61927545e-02f, 3.84544278e-03f, -4.08370867e-02f, 5.68120517e-02f, -1.02213897e-01f, 6.19284213e-02f, -1.04907706e-01f, 1.01444591e-02f, -1.13472436e-02f, -2.85766035e-01f,
  9.76069272e-02f, 5.27356938e-02f, -6.70808181e-02f, 2.45031416e-01f, 1.07988603e-01f, 3.57384421e-03f, -1.58972949e-01f, 9.31627899e-02f, -1.49695173e-01f, 6.40520602e-02f,
  7.77885243e-02f, -7.73266852e-02f, -1.12673296e-02f, -2.83567071e-01f, -5.78963421e-02f, 9.22376961e-02f, -1.43587455e-01f, -8.64865482e-02f, -4.90434431e-02f, 2.51054525e-01f,
  -1.15804911e-01f, -2.67943479e-02f, 1.53447717e-01f, 2.29766741e-02f, -1.34458303e-01f, -4.15375270e-02f, 9.85682011e-02f, -1.31230608e-01f, 6.24765418e-02f, 1.19735554e-01f,
  -6.89112991e-02f, 5.82320914e-02f, 7.79754296e-02f, -5.73357567e-02f, -7.77467936e-02f, -8.89311880e-02f, -1.86553337e-02f, 3.48549709e-02f, -8.03250894e-02f, -1.43811596e-03f,
  -1.26576707e-01f, 1.56768691e-02f, -1.44981235e-01f, 3.32456455e-02f, 3.13247591e-02f, -1.11854099e-01f, -1.29468754e-01f, 3.78051475e-02f, -8.44034255e-02f, 5.77309392e-02f,
  1.27056420e-01f, -1.21995576e-01f, -1.33658797e-01f, -6.54888302e-02f, -1.62725493e-01f, -9.05080065e-02f, -1.00212395e-01f, -3.62237990e-02f, 1.19840674e-01f, -1.11078732e-01f,
  -6.87944591e-02f, 7.84201697e-02f, 2.14617670e-01f, 1.79762561e-02f, -4.28036787e-03f, -3.08925807e-01f, -2.90691316e-01f, -5.42621575e-02f, -4.30513732e-02f, -5.26669063e-02f,
  4.25937995e-02f, -1.88044906e-01f, -1.52080253e-01f, -1.08014951e-02f, 4.44758534e-02f, 6.98405951e-02f, 7.40421414e-02f, 1.50464192e-01f, 1.72189191e-01f, -6.97890595e-02f,
  2.14488447e-01f, -7.95446038e-02f, 1.80305451e-01f, 8.98724198e-02f, -7.37649500e-02f, 2.30190665e-01f, -1.16546437e-01f, 7.24737123e-02f, 4.21774723e-02f, 1.06094584e-01f,
  -5.14833406e-02f, 4.13394719e-03f, 4.52632532e-02f, -1.24365598e-01f, -6.16909489e-02f, 7.58681744e-02f, 1.04012974e-02f, 1.18150115e-01f, 7.31076226e-02f, 8.38693455e-02f,
  1.74066335e-01f, -9.92598087e-02f, 5.81480674e-02f, -1.19076949e-02f, 1.51062101e-01f, 1.52892210e-02f, -9.86586735e-02f, 1.94428727e-01f, -5.41579127e-02f, -1.27406716e-01f,
  -2.78539825e-02f, -2.40964722e-02f, -1.28495008e-01f, 1.07906811e-01f, 1.45837218e-01f, 6.69691041e-02f, 1.03085607e-01f, 1.45664364e-02f, 1.47232488e-01f, -1.09931909e-01f,
  2.06037715e-01f, -5.14484830e-02f, 2.97026206e-02f, -2.45731305e-02f, 9.11436155e-02f, -2.59200305e-01f, 3.42231803e-02f, 1.52756080e-01f, -5.92593253e-02f, 1.09088011e-01f,
  -7.08765313e-02f, -2.38708705e-01f, -1.19571373e-01f, 2.69867629e-01f, -4.26133797e-02f, 1.24654081e-02f, 2.25686878e-01f, -6.95654526e-02f, -8.96347985e-02f, 2.35018265e-02f,
  2.13853583e-01f, 1.10908933e-01f, -3.88176143e-02f, -2.54489541e-01f, 1.66773438e-01f, 3.58514115e-02f, 5.45215085e-02f, 3.00606396e-02f, -1.10502727e-01f, -5.80061488e-02f,
  1.92596521e-02f, -1.66576669e-01f, 5.17289005e-02f, -4.06401902e-02f, -3.47270370e-02f, 4.46083024e-02f, 5.04274108e-02f, 4.63901013e-02f, -1.11255199e-01f, -8.46726354e-03f,
  -7.79917538e-02f, -1.54568106e-01f, -1.08449273e-01f, 4.46438566e-02f, 9.74478871e-02f, -6.90174103e-02f, 9.51993652e-03f, -7.87866712e-02f, 7.00664446e-02f, 1.96121186e-01f,
  -2.79492717e-02f, -8.23119506e-02f, -4.17499654e-02f, 4.32698466e-02f, 2.32782230e-01f, 2.59531289e-02f, 1.71088487e-01f, -7.75091350e-02f, -8.31750259e-02f, 5.54863438e-02f,
  4.49197658e-04f, 4.37199743e-03f, 9.40210447e-02f, 3.96915115e-02f, -7.48268738e-02f, 5.34951389e-02f, 1.50555059e-01f, 1.46867231e-01f, -3.60202715e-02f, 2.20994763e-02f,
  -1.62592292e-01f, -1.22161530e-01f, 1.03689156e-01f, 2.10196391e-01f, 2.78776973e-01f, -1.06472775e-01f, 1.05510116e-01f, 2.44716257e-02f, -1.71991158e-02f, 3.67475212e-01f,
  1.13850117e-01f, -1.86356157e-02f, 9.24561098e-02f, 5.06777465e-02f, 1.29198572e-02f, -2.41449028e-02f, -1.70637131e-01f, -3.39629985e-02f, -2.88046181e-01f, 1.04446085e-02f,
  -1.16336778e-01f, 8.66357004e-04f, 1.73028395e-01f, -3.43815714e-01f, -9.08699185e-02f, -3.41406241e-02f, -2.35492513e-02f, -5.73189408e-02f, 9.61877592e-03f, -5.08577656e-03f,
  -1.03604287e-01f, 1.18554600e-01f, 2.71546066e-01f, 1.64475553e-02f, 8.98564383e-02f, -2.13262305e-01f, -2.10149050e-01f, 1.40484422e-01f, -7.35232756e-02f, 8.81551355e-02f,
  -6.27327189e-02f, 6.56787306e-02f, -8.61250758e-02f, 8.00628960e-02f, -6.58325329e-02f, -1.33113503e-01f, -4.16569784e-03f, -2.72108465e-02f, 1.86373413e-01f, 1.16371110e-01f,
  -1.37689263e-01f, 1.23968185e-03f, 2.76383553e-02f, 6.51883781e-02f, -5.07758297e-02f, -3.24637480e-02f, -2.97570191e-02f, 1.21004194e-01f, -5.52229024e-02f, 4.97616082e-02f,
  -8.35215673e-02f, -7.47168437e-02f, -3.06786522e-02f, -7.62214139e-02f, 8.86666179e-02f, 8.60799700e-02f, -7.08831772e-02f, 1.18886404e-01f, 1.15358770e-01f, -5.99970035e-02f,
  -7.83298723e-03f, -1.70912892e-02f, -8.06209445e-02f, 1.65919363e-01f, -4.93588112e-02f, 3.30717787e-02f, -3.05188354e-02f, -8.04999694e-02f, 4.91183437e-02f, -1.50668442e-01f,
  7.39031006e-04f, 2.69695166e-02f, -1.13609836e-01f, 7.85795450e-02f, 4.76871692e-02f, -1.19359024e-01f, 3.91023653e-03f, -1.48257345e-01f, -1.67020112e-02f, 7.25898966e-02f,
  -8.21098164e-02f, 1.13661058e-01f, 1.12698175e-01f, -7.11809695e-02f, -9.84049141e-02f, 1.41281500e-01f, -5.69726117e-02f, 8.29688087e-02f, 8.39862376e-02f, -6.59011602e-02f,
  -1.53272539e-01f, 5.76461591e-02f, -2.92303804e-02f, 1.10154018e-01f, -6.31491560e-03f, 5.13721397e-03f, 2.20151898e-02f, 6.63075820e-02f, 1.26081146e-02f, 1.75169975e-01f,
  -7.88243189e-02f, -8.97813663e-02f, -1.50069416e-01f, -1.01986565e-01f, -8.05244967e-02f, -1.96513981e-02f, 7.26885796e-02f, -9.90355909e-02f, -1.01367151e-02f, 3.91726755e-02f,
  -9.25400108e-02f, 2.22291313e-02f, -8.94553363e-02f, -8.64363834e-02f, 3.88080180e-02f, 4.20425758e-02f, -1.13062397e-01f, 8.21873322e-02f, -5.11272140e-02f, 8.55425596e-02f,
  1.33511825e-02f, -1.87336013e-01f, -7.83201158e-02f, 2.48538926e-02f, -1.61850020e-01f, 1.32037085e-02f, -2.63188500e-02f, -2.07178101e-01f, 9.18955505e-02f, -6.11457787e-02f,
  -5.60669601e-03f, -7.19780251e-02f, 8.03935677e-02f, 6.52529597e-02f, -4.88938689e-02f, -9.31666270e-02f, 2.80197948e-01f, 6.48679882e-02f, -5.31853037e-03f, 6.46002516e-02f,
  -8.55332892e-03f, 2.55302697e-01f, -2.31075380e-02f, -7.16522858e-02f, -8.71952549e-02f, 7.27213100e-02f, 1.05680756e-01f, 9.78617743e-03f, -8.05269107e-02f, -6.20991783e-03f,
  -2.01794654e-02f, -1.02747686e-01f, 5.10551184e-02f, 1.36530653e-01f, 4.92073409e-02f, 4.87917252e-02f, -1.81308314e-01f, -7.52011091e-02f, -6.71452880e-02f, -3.56484670e-03f,
  5.29109761e-02f, -7.76341259e-02f, 5.14138415e-02f, -7.48290867e-02f, -8.46626610e-02f, 6.79347515e-02f, -6.46803379e-02f, -6.35870248e-02f, -9.40066800e-02f, -6.01003282e-02f,
  -5.98888248e-02f, -1.14755057e-01f, -5.79515696e-02f, 6.26425147e-02f, 8.14715624e-02f, 2.17412766e-02f, 7.49968179e-03f, -6.50494248e-02f, -1.76869985e-03f, -2.87286807e-02f,
  -4.27033044e-02f, 1.64014231e-02f, 2.66863346e-01f, -2.31258243e-01f, 1.09333573e-02f, -1.60724044e-01f, -1.25572696e-01f, 9.20902789e-02f, 7.24882411e-04f, -1.74814597e-01f,
  5.38532389e-03f, -1.31123111e-01f, -9.66933146e-02f, 2.08629087e-01f, -1.17518462e-01f, 2.28092317e-02f, 1.47150218e-01f, -1.07797943e-01f, 6.72171637e-02f, -5.58598675e-02f,
  -4.61239628e-02f, -1.61397532e-01f, 2.51357764e-01f, 2.13117465e-01f, -1.38602421e-01f, 1.89548489e-02f, -5.69577180e-02f, -7.90769830e-02f, 6.42510578e-02f, -1.20312171e-02f,
  -6.00858182e-02f, 3.95605676e-02f, 5.24764135e-02f, -1.02369972e-01f, -5.04420623e-02f, 7.39227086e-02f, -5.67936935e-02f, 5.16343452e-02f, 8.04441050e-02f, -2.88371295e-02f,
  -1.84957176e-01f, 3.75848543e-03f, -4.04785201e-02f, 2.49235961e-03f, -7.17024505e-02f, -1.03442460e-01f, -2.33353507e-02f, -9.51840878e-02f, -1.04675896e-01f, -9.56227304e-04f,
  -1.14544503e-01f, -4.82325964e-02f, 1.90406457e-01f, -2.22972222e-02f, -1.38576642e-01f, -7.94828236e-02f, -5.14678136e-02f, -7.69746751e-02f, -1.60090793e-02f, -1.06023297e-01f,
  -2.58589417e-01f, 4.24072482e-02f, 7.88121670e-02f, 3.89835984e-02f, 2.82363780e-03f, 2.72722244e-01f, -1.15457028e-02f, 4.28872630e-02f, 1.56931460e-01f, -1.71952382e-01f,
  -8.10647234e-02f, -7.16145411e-02f, -2.70843189e-02f, -2.47437790e-01f, 1.01784013e-01f, 6.50300533e-02f, -2.05824211e-01f, 4.34720442e-02f, -2.22049356e-02f, -1.63518101e-01f,
  -1.69292882e-01f, 9.06873569e-02f, -3.55004612e-03f, 1.14192747e-01f, 1.05118088e-01f, -1.39027670e-01f, 5.19736148e-02f, -4.41823527e-02f, 1.12712085e-02f, 1.70225099e-01f,
  4.09192313e-03f, 1.21627428e-01f, 4.21237126e-02f, 9.65145975e-02f, 5.12837619e-02f, -5.89051992e-02f, -9.59697589e-02f, -1.39493033e-01f, 8.31129700e-02f, 1.35923192e-01f,
  -9.03772190e-02f, -7.10142180e-02f, 4.12003770e-02f, 1.24820121e-01f, 5.38979769e-02f, 1.27729163e-01f, 1.01606091e-02f, 7.92254210e-02f, 1.04246721e-01f, 6.30637035e-02f,
  -1.03203543e-01f, 1.18084133e-01f, -1.19544186e-01f, -1.77329838e-01f, -1.26415059e-01f, -6.37440756e-02f, -1.59412295e-01f, -2.45777629e-02f, 8.02959874e-02f, 5.67205697e-02f,
  -1.50268739e-02f, 1.03039749e-01f, -4.21046913e-02f, -1.58082142e-01f, 1.11304820e-01f, 8.76393542e-02f, -1.07197136e-01f, 1.90261770e-02f, 1.31224589e-02f, -6.97046742e-02f,
  -1.77243307e-01f, 2.64275700e-01f, -2.80705262e-02f, 4.27746866e-03f, 1.73975721e-01f, -1.59339726e-01f, 8.69867355e-02f, -3.33599858e-02f, 1.95739567e-01f, 1.01532200e-02f,
  1.76379800e-01f, -2.10207388e-01f, 7.36230868e-04f, 5.19651696e-02f, -5.48308939e-02f, 2.21735314e-01f, -6.53054789e-02f, -5.16182818e-02f, 2.11754501e-01f, 2.62747377e-01f,
  -2.25773975e-02f, -2.25740567e-01f, 1.13623261e-01f, 1.56719908e-01f, -7.11986348e-02f, -3.68353687e-02f, -7.44614601e-02f, 1.52669758e-01f, 3.85080278e-02f, 2.30037943e-02f,
  -1.43350614e-02f, -1.66880727e-01f, 8.09207782e-02f, -1.67651698e-01f, -6.33764267e-02f, 4.57349718e-02f, 1.31662309e-01f, -5.72750578e-03f, -3.14929597e-02f, -9.43072289e-02f,
  2.96369307e-02f, 1.02641501e-01f, -5.12625016e-02f, 6.00343496e-02f, 2.22692534e-01f, -1.57313153e-01f, 3.88505459e-02f, 6.10440113e-02f, 2.33303472e-01f, 1.34448797e-01f,
  -2.30504833e-02f, 3.50459479e-02f, -3.24996226e-02f, 7.50581101e-02f, 7.28103369e-02f, -8.32791105e-02f, 1.14547811e-01f, -3.07596717e-02f, -1.35257259e-01f, 1.12582281e-01f,
  -9.46472809e-02f, 1.77150480e-02f, 1.64756868e-02f, 2.31802821e-01f, -1.36712745e-01f, -2.27867499e-01f, -2.12349221e-02f, 6.70341179e-02f, 1.19001448e-01f, 2.40404174e-01f,
  -4.17902358e-02f, -1.58799797e-01f, -1.48907378e-01f, 3.40500474e-02f, -2.41595536e-01f, 2.26504460e-01f, 7.33592063e-02f, -6.10089153e-02f, -1.44510269e-01f, -3.13619584e-01f,
  4.18008603e-02f, 1.68611526e-01f, -1.34133384e-01f, -1.64335430e-01f, -9.10709202e-02f, 1.42455339e-01f, -1.33182764e-01f, -6.49368912e-02f, -8.43254998e-02f, 9.61370468e-02f,
  -1.22045286e-01f, -3.08895074e-02f, 1.42804876e-01f, 3.22819054e-02f, -1.23962974e-02f, -4.23361808e-02f, -3.66399251e-02f, 3.76482271e-02f, 5.87723292e-02f, -3.67196798e-02f,
  1.31754726e-01f, -1.29186092e-02f, -6.32097349e-02f, -4.16963510e-02f, 1.00870021e-01f, 9.62904766e-02f, -1.01434678e-01f, -8.66456889e-03f, 1.26354188e-01f, 3.30834612e-02f,
  -3.92823182e-02f, 9.36211646e-02f, 1.80639669e-01f, 7.85107166e-02f, 1.60736427e-01f, -7.40401074e-02f, 4.27489541e-03f, 2.82835662e-02f, -9.37255993e-02f, 3.91099565e-02f,
  6.64042905e-02f, 5.74986562e-02f, -9.08003747e-02f, -1.12564318e-01f, 3.33041251e-02f, -9.03335884e-02f, 8.79839808e-02f, 4.96685579e-02f, -5.68426475e-02f, 1.90561414e-02f,
  -5.30476347e-02f, 2.04980925e-01f, 4.32656938e-03f, 8.83398801e-02f, 1.02803864e-01f, 6.77609742e-02f, -1.27094667e-02f, 2.61466444e-01f, 1.63653549e-02f, -8.81517306e-02f,
  9.29718241e-02f, -2.15232950e-02f, 1.90953035e-02f, -4.61625904e-02f, 6.23080432e-02f, 1.43053472e-01f, -2.51010031e-01f, 4.25873399e-02f, -1.14117414e-01f, -5.71727566e-02f,
  1.41923487e-01f, -2.62057871e-01f, 1.59916192e-01f, 1.54339401e-02f, -1.02468617e-02f, 1.83177050e-02f, 1.07168360e-02f, 7.14005902e-02f, 6.60066307e-02f, 1.62707001e-01f,
  1.54214025e-01f, 1.66046977e-01f, -2.05892902e-02f, -1.05586730e-01f, -1.35162637e-01f, 1.07687004e-01f, 1.58221409e-01f, 5.37709333e-02f, -5.74070327e-02f, -4.92643453e-02f,
  -1.23014696e-01f, -7.79514108e-03f, 8.77672881e-02f, 1.68051454e-03f, 1.04778305e-01f, 9.26065892e-02f, 3.03218011e-02f, 7.42516741e-02f, -1.60135757e-02f, -1.87872555e-02f,
  6.92674145e-02f, 1.63844414e-02f, -3.98133881e-02f, 2.29366496e-02f, 1.00067504e-01f, -2.28596274e-02f, -2.84786988e-02f, -1.21247303e-02f, 2.22657435e-02f, 7.16045275e-02f,
  -2.48718485e-02f, 7.17040002e-02f, -1.80356294e-01f, 7.34497309e-02f, -6.38376549e-02f, 7.21438974e-02f, 2.43416250e-01f, 1.37257099e-01f, 1.45745289e-03f, -1.05336793e-02f,
  -7.24902451e-02f, 1.33937582e-01f, 1.22987650e-01f, -1.01837099e-01f, 8.63988250e-02f, -2.61169188e-02f, -1.11721985e-01f, 7.31681213e-02f, -7.85850510e-02f, -1.27123654e-01f,
  1.23487547e-01f, 7.82339945e-02f, -1.91992939e-01f, -1.01283431e-01f, 9.17470083e-03f, -7.77676478e-02f, -1.30608857e-01f, 9.87709761e-02f, -1.11464106e-01f, 1.40591294e-01f,
  3.01950071e-02f, 6.59411699e-02f, -8.72504190e-02f, 5.48077561e-02f, 4.66389721e-03f, -1.47617549e-01f, -7.78349256e-03f, 9.97115299e-02f, -6.27533272e-02f, 5.21643832e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -8.95993188e-02f, 1.19390659e-01f, 9.85647216e-02f, 9.63667557e-02f, -1.11373207e-02f, -1.12870760e-01f, 1.16085798e-01f, -1.02437347e-01f, -1.14318013e-01f, 1.26163661e-01f,
  -7.75549039e-02f, 3.80788855e-02f, -5.65127209e-02f, -1.10950172e-01f, -9.41507444e-02f, -1.23267896e-01f, -7.97773898e-02f, 7.95632973e-02f, 6.50406927e-02f, -5.64484671e-02f,
  8.37621391e-02f, -9.73438099e-02f, -4.46330830e-02f, -1.22777537e-01f, 8.23419243e-02f, 7.82638788e-02f, -1.31096452e-01f, -2.81368345e-02f, 1.05693884e-01f, 4.41088863e-02f,
  -7.92802349e-02f, -5.09354100e-03f, -4.27060910e-02f, 7.97381178e-02f, 8.40681344e-02f, -2.94642653e-02f, -1.07030831e-01f, -6.58158213e-02f, 1.21301785e-01f, 9.84750129e-03f,
  6.97595254e-02f, -3.78769543e-03f, 9.15951505e-02f, 7.01014027e-02f, 3.99412923e-02f, -5.43313473e-02f, -7.36945719e-02f, 1.96546577e-02f, -7.20938668e-02f, 7.64117092e-02f,
  -6.32647499e-02f, -1.04624949e-01f, 6.09406009e-02f, -1.13084458e-01f, 7.95681849e-02f, -2.71661263e-02f, 1.93852617e-03f, -1.16381623e-01f, -9.03239753e-03f, 2.30219550e-02f,
  3.14616859e-02f, 7.71551505e-02f, -8.26021582e-02f, 7.77051896e-02f, -9.78476256e-02f, -5.24479821e-02f, 1.33046180e-01f, -4.73834872e-02f, -3.67500000e-02f, -4.83231135e-02f,
  -5.96435852e-02f, 4.49196734e-02f, -6.76330104e-02f, 1.02395564e-02f, -8.67282152e-02f, 6.97641447e-02f, -5.75621016e-02f, -5.71438596e-02f, -5.09415902e-02f, -9.81769711e-02f,
  9.33842082e-03f, 1.02305144e-01f, 7.89441764e-02f, 1.04402162e-01f, -1.19684860e-01f, 1.04714401e-01f, 1.00953862e-01f, 4.55343053e-02f, 1.05927929e-01f, -5.09453751e-02f,
  -6.85717165e-02f, -1.09394573e-01f, 6.84347823e-02f, -9.62193310e-02f, -1.28813609e-01f, -2.07209680e-02f, -9.82992444e-03f, -1.72496364e-02f, 8.28894675e-02f, -1.43423021e-01f,
  -3.78708504e-02f, 1.32677644e-01f, 9.69032869e-02f, -5.72297536e-03f, 1.01477973e-01f, -1.91788469e-02f, -5.39100096e-02f, 1.21717028e-01f, 1.20981961e-01f, -1.33221880e-01f,
  8.09416622e-02f, 4.17063087e-02f, -1.67665519e-02f, 7.85013661e-02f, 3.89056429e-02f, 1.16989799e-01f, 2.26400308e-02f, -4.15602922e-02f, -1.40992496e-02f, 6.30800426e-02f,
  -4.02087346e-02f, -8.94746333e-02f, 9.12003294e-02f, 1.02329195e-01f, -1.00645132e-01f, -4.35154811e-02f, 1.49140581e-01f, -9.33031514e-02f, 7.80315027e-02f, -1.09591223e-01f,
  3.18404995e-02f, -2.16309894e-02f, 1.19336620e-01f, 4.02877480e-02f, 9.39574242e-02f, -8.59891847e-02f, 9.15162079e-03f, 9.04999152e-02f, 1.03991017e-01f, 8.50670710e-02f,
  -5.41904233e-02f, 8.71428102e-02f, 8.09175372e-02f, 1.19729988e-01f, 1.51860133e-01f, 1.48862094e-01f, 7.10653216e-02f, 1.62402943e-01f, -7.29207397e-02f, 1.05568655e-01f,
  8.57073218e-02f, 1.30242050e-01f, 1.12803921e-01f, 3.54521088e-02f, 5.25032021e-02f, -7.40792677e-02f, 6.87467754e-02f, 7.76396543e-02f, -3.50510664e-02f, 4.75173667e-02f,
  9.93085355e-02f, 5.95004708e-02f, -1.96200814e-02f, 2.23796546e-01f, 1.44749116e-02f, -5.21878116e-02f, 1.16407946e-01f, -9.80162174e-02f, -1.77113771e-01f, 4.93779667e-02f,
  7.25020990e-02f, 7.54946144e-03f, -1.38874218e-01f, 9.90149658e-03f, 5.11783932e-04f, 9.20169652e-02f, 5.02049886e-02f, -1.72240570e-01f, 1.08472988e-01f, 7.84401223e-02f,
  9.55254883e-02f, -4.97113541e-02f, -3.29315104e-02f, 2.26747859e-02f, 5.10773296e-03f, 1.83509588e-01f, 2.15556666e-01f, -3.17632072e-02f, -7.27488697e-02f, 4.77852449e-02f,
  -1.24400094e-01f, -7.00095622e-03f, -1.97183993e-02f, 1.14228353e-01f, -6.25839382e-02f, 1.57024828e-03f, -6.50792792e-02f, 1.85993940e-01f, -2.68123448e-02f, -8.16621184e-02f,
  6.63110018e-02f, -1.42432731e-02f, -4.03503403e-02f, -5.92276715e-02f, -9.26483423e-03f, 1.18380658e-01f, -4.64449301e-02f, 4.83943103e-03f, 1.33138463e-01f, 2.07064524e-02f,
  -1.94405075e-02f, -1.75505038e-03f, -5.36566079e-02f, 5.43215591e-03f, 2.22698487e-02f, 1.66140068e-02f, 1.13125511e-01f, 1.10392682e-01f, -1.74518675e-01f, -9.96962413e-02f,
  7.42816851e-02f, 1.39696980e-02f, 1.91322237e-01f, -5.67930238e-03f, 1.67153552e-01f, 1.45495355e-01f, 7.31698945e-02f, 1.24064647e-01f, -2.21831840e-03f, -6.78968662e-03f,
  -5.43057593e-03f, 2.84979660e-02f, 4.74487245e-02f, -1.35358408e-01f, 1.74440555e-02f, -8.87578353e-02f, -1.52188390e-01f, -5.12036271e-02f, -1.50180534e-01f, 6.35620877e-02f,
  6.45731390e-03f, -8.88032839e-02f, 5.32470345e-02f, -9.07199383e-02f, -1.11743115e-01f, -2.53905263e-02f, -2.95962617e-02f, -8.50136951e-02f, 7.80487284e-02f, 1.07003637e-01f,
  1.51929736e-01f, 1.71271916e-02f, 8.57668892e-02f, 1.94758140e-02f, -7.18251318e-02f, 6.83084652e-02f, -1.29158143e-02f, 1.36477575e-01f, 2.39978880e-02f, 1.45416126e-01f,
  -2.61545498e-02f, -6.01769192e-03f, 4.99704592e-02f, -4.24917191e-02f, 1.22456163e-01f, 1.13893777e-01f, 2.42104143e-01f, -7.03821778e-02f, 6.86124042e-02f, 9.83660370e-02f,
  -1.05099268e-02f, -2.32493822e-02f, 1.22040130e-01f, 2.81864256e-02f, -1.00824796e-02f, 1.36398263e-02f, -9.07693058e-02f, 8.97063836e-02f, 1.01291694e-01f, -9.83926188e-03f,
  2.10904241e-01f, 1.25722304e-01f, -2.46161491e-01f, 1.50894850e-01f, -1.98186114e-02f, 1.39170676e-01f, 2.18058839e-01f, -1.59577243e-02f, 2.22524196e-01f, -1.34591050e-02f,
  9.19901654e-02f, 3.87992002e-02f, 1.03594594e-01f, -1.55867189e-01f, -2.73765135e-03f, -1.71949655e-01f, -2.16800690e-01f, -1.69216126e-01f, 1.11934908e-01f, 1.37623385e-01f,
  -1.29378624e-02f, -1.00089677e-01f, -1.13389477e-01f, -8.15462098e-02f, 4.78169359e-02f, -8.69745612e-02f, -5.34839928e-02f, -6.76295385e-02f, -6.96951002e-02f, -4.50900085e-02f,
  5.08185029e-02f, 1.75440703e-02f, -1.53464258e-01f, 6.57239556e-02f, 1.78718477e-01f, 3.65282185e-02f, 3.26912664e-02f, -2.40055360e-02f, -4.83402889e-03f, 1.03051245e-01f,
  -8.41836557e-02f, -6.83626672e-03f, -9.04866382e-02f, -9.91956294e-02f, 7.72199854e-02f, 8.00756291e-02f, 5.62954620e-02f, 1.45292105e-02f, -5.77588752e-02f, 7.77789205e-02f,
  -1.06749244e-01f, -4.10073772e-02f, -5.36738597e-02f, -1.15899310e-01f, 3.36640291e-02f, 9.95729715e-02f, 6.18956089e-02f, -1.20181121e-01f, 8.34838971e-02f, 3.06085916e-03f,
  -2.11406164e-02f, -5.35513237e-02f, -8.23311210e-02f, -9.69809070e-02f, -2.43877154e-02f, -1.21353948e-02f, -2.40724161e-02f, -1.12648912e-01f, -1.14646651e-01f, -1.20271996e-01f,
  -1.01155154e-01f, -1.66551117e-02f, 6.13921471e-02f, -2.43379991e-03f, -3.76209021e-02f, 1.59010477e-02f, 2.45381836e-02f, 8.59943628e-02f, -2.65747141e-02f, -9.59482118e-02f,
  3.41102444e-02f, 8.34410936e-02f, 3.41827981e-02f, 3.21188159e-02f, -8.94858912e-02f, 8.19358453e-02f, 5.96545376e-02f, -4.91750240e-03f, -5.51680811e-02f, -7.32377842e-02f,
  -4.75867540e-02f, 4.69854437e-02f, -9.16205719e-02f, -7.59960636e-02f, 5.12520261e-02f, 3.01542003e-02f, -8.68569762e-02f, 3.17078754e-02f, -3.41757573e-02f, 3.50174345e-02f,
  -1.73958973e-03f, -1.11633278e-01f, -4.56898287e-02f, -1.19136423e-01f, 3.32134180e-02f, -5.05074561e-02f, -6.58644214e-02f, 5.95911965e-03f, -3.64046748e-04f, -8.45692828e-02f,
  -1.81336962e-02f, 1.34376645e-01f, -8.50031152e-02f, 8.53218436e-02f, -4.79616225e-02f, -1.07663482e-01f, 9.04729143e-02f, 1.35385558e-01f, 6.57699630e-02f, 9.85811204e-02f,
  -8.25699046e-03f, -6.44150004e-02f, 1.01220265e-01f, 4.59494144e-02f, -9.18413550e-02f, 3.74971218e-02f, 1.03211924e-02f, -8.26515704e-02f, 1.14322640e-01f, -8.40422958e-02f,
  8.30623694e-03f, -4.41986620e-02f, -6.58764243e-02f, 8.02195817e-02f, -9.54498947e-02f, -4.44470569e-02f, -3.17009315e-02f, -2.92766821e-02f, 2.37590019e-02f, -1.53973535e-01f,
  1.60401985e-02f, -1.08978413e-02f, -1.60651014e-03f, 8.02835636e-03f, 1.08779602e-01f, -9.73512307e-02f, 8.17928091e-03f, 7.90596902e-02f, 1.30360886e-01f, -7.03193024e-02f,
  -1.09753028e-01f, -3.25449854e-02f, 5.52482828e-02f, 1.06450833e-01f, 4.79895957e-02f, -9.12772939e-02f, -7.65178502e-02f, -1.96211338e-02f, 6.55276403e-02f, 9.56996828e-02f,
  8.80237371e-02f, -1.23591490e-01f, -1.02880090e-01f, -7.39712045e-02f, -3.89545411e-02f, -7.93712139e-02f, 3.08596604e-02f, 7.39669800e-02f, 4.23796661e-02f, -8.76075923e-02f,
  -3.36778127e-02f, 5.08413743e-03f, -2.50337250e-03f, -1.80989001e-02f, -8.00177604e-02f, 1.82696879e-02f, 9.39301401e-02f, -9.65943709e-02f, 8.14211145e-02f, 7.57280439e-02f,
  -8.25216919e-02f, 2.48040352e-02f, 6.09491840e-02f, -5.34698218e-02f, 9.00172442e-02f, -3.88374142e-02f, 9.36206207e-02f, -8.85346234e-02f, -8.73327553e-02f, 2.81336457e-02f,
  -9.87647772e-02f, -9.28601921e-02f, 4.92210761e-02f, 5.06340228e-02f, -5.96628077e-02f, 7.06747323e-02f, -9.93271638e-03f, 4.64376286e-02f, -7.71022588e-02f, 6.59943298e-02f,
  4.92012640e-03f, 9.70427617e-02f, -4.99230623e-02f, 4.98297065e-02f, -1.18198484e-01f, 1.06822833e-01f, -9.67412069e-02f, -1.17136575e-01f, -9.33058783e-02f, -5.59818782e-02f,
  4.62403074e-02f, -5.45690209e-02f, -8.40253904e-02f, -1.04001462e-02f, 2.09399179e-04f, 3.88889015e-03f, -7.08136186e-02f, -7.49974996e-02f, -1.18603997e-01f, -5.15693612e-02f,
  5.04280142e-02f, -3.30680460e-02f, 2.92537380e-02f, 4.29047123e-02f, 3.04325484e-02f, 2.28461474e-02f, -2.96211783e-02f, 1.14740297e-01f, 4.01544347e-02f, -8.37626979e-02f,
  -1.64939873e-02f, -7.64588714e-02f, 1.04373898e-02f, 1.36056449e-02f, -4.06652614e-02f, -4.51725014e-02f, -5.07242121e-02f, -1.76392011e-02f, -5.31627052e-02f, -1.04307391e-01f,
  1.82012990e-02f, 5.46813644e-02f, -7.73269758e-02f, 6.21009246e-02f, -7.94959292e-02f, -1.11446232e-02f, 5.46661802e-02f, 3.92413214e-02f, -5.87478988e-02f, 4.03902009e-02f,
  7.51364380e-02f, 1.32025555e-01f, 4.14309092e-02f, 1.09042540e-01f, -8.34644437e-02f, 2.57088225e-02f, 1.31410658e-01f, -6.77462146e-02f, -1.34932235e-01f, -3.96196507e-02f,
  6.84657181e-03f, 1.48558676e-01f, 6.87273368e-02f, 7.01450035e-02f, 1.37820080e-01f, 4.75230254e-02f, -1.50638297e-02f, 5.94377592e-02f, -4.63403761e-02f, -1.11648075e-01f,
  8.94948691e-02f, -8.79057348e-02f, 2.69556530e-02f, -1.27140462e-01f, 1.79426502e-02f, -1.06152810e-01f, 6.08853437e-02f, 8.53928253e-02f, 2.97362451e-02f, -1.42270207e-01f,
  1.36961356e-01f, -1.60842240e-01f, 8.45820606e-02f, -9.32333991e-02f, 9.41792876e-02f, -2.37329230e-02f, 7.02516288e-02f, 8.27190727e-02f, 1.05307311e-01f, 1.26942858e-01f,
  8.12544897e-02f, -7.84893408e-02f, -1.84412804e-02f, -8.28571394e-02f, -5.76420091e-02f, -4.26446460e-02f, -1.09866157e-01f, -7.77677670e-02f, 1.13373652e-01f, -5.76719195e-02f,
  -1.05220951e-01f, 8.07248279e-02f, -6.01141602e-02f, -1.10595524e-01f, -8.13200995e-02f, 6.23670444e-02f, 7.99835473e-02f, 1.33176716e-02f, 5.99439181e-02f, -9.09134150e-02f,
  4.91695255e-02f, -8.32043961e-02f, -6.25506192e-02f, -1.27030656e-01f, -3.65270898e-02f, 1.10831715e-01f, 9.54872668e-02f, 6.62105456e-02f, 8.76005553e-03f, 1.11067466e-01f,
  -9.16738659e-02f, -8.83931741e-02f, 3.90710011e-02f, -1.30612299e-01f, -2.92038880e-02f, 4.98506241e-03f, 6.59627020e-02f, 7.29011670e-02f, 3.15565430e-02f, 1.11123640e-02f,
  9.40609374e-04f, -8.43616575e-02f, -9.09383148e-02f, 8.58992860e-02f, -5.48386201e-02f, 6.65038750e-02f, 4.00753245e-02f, -8.39216188e-02f, 7.91541412e-02f, -6.45642504e-02f,
  2.27878708e-02f, 8.52662101e-02f, -2.00117826e-02f, 3.62018333e-03f, -1.18031025e-01f, 4.83943410e-02f, 1.03804126e-01f, -1.33764157e-02f, 1.08596675e-01f, -1.25828922e-01f,
  8.85817260e-02f, -5.97089715e-02f, -3.59205715e-02f, 4.15562503e-02f, -3.25464550e-03f, 7.07270578e-02f, -8.82163644e-02f, 1.01258218e-01f, 6.88023865e-02f, 1.13522395e-01f,
  -4.94540706e-02f, -8.34829211e-02f, -3.26804072e-02f, 8.18912014e-02f, 8.00307468e-02f, 3.09690572e-02f, -1.86357517e-02f, -2.88870744e-02f, -1.14192531e-01f, 1.06799714e-01f,
  -5.88937998e-02f, -7.01140985e-02f, -1.21686257e-01f, 6.57545701e-02f, 7.42287934e-02f, -1.27827257e-01f, -2.01364178e-02f, -1.11532509e-01f, -1.13662496e-01f, -9.63791013e-02f,
  -9.92363840e-02f, -5.09329513e-02f, 4.52890545e-02f, -1.07605336e-02f, -4.41597998e-02f, -7.90792108e-02f, -4.79839072e-02f, 6.39040694e-02f, -5.29161561e-03f, -8.98605883e-02f,
  -9.85901728e-02f, 1.53415278e-02f, -9.54016522e-02f, -1.10323958e-01f, -5.83178625e-02f, 6.47507608e-02f, -2.42891423e-02f, 9.20476988e-02f, -2.92492118e-02f, 4.52829199e-03f,
  -4.95867282e-02f, 1.04402609e-01f, 5.58933616e-02f, 9.72072780e-02f, -1.01999044e-01f, -3.18422019e-02f, 1.03707649e-01f, 3.60808596e-02f, 7.52179176e-02f, -7.36931935e-02f,
  7.46875033e-02f, -4.11937758e-02f, 3.97137702e-02f, 7.49476627e-02f, 6.49830326e-04f, 5.84143214e-03f, 2.73840898e-03f, 2.36182418e-02f, 2.80494597e-02f, 2.27174605e-03f,
  8.11184421e-02f, 2.45332271e-02f, 9.58262086e-02f, 9.52372700e-02f, -9.49468017e-02f, -1.40580591e-02f, -5.24458811e-02f, -2.18826029e-02f, -1.69032998e-02f, -9.53073129e-02f,
  -7.82829002e-02f, -9.47147906e-02f, 5.53306788e-02f, 1.06069252e-01f, -2.35255733e-02f, -2.07858216e-02f, 8.81402045e-02f, 9.70725939e-02f, 1.01733655e-01f, 6.41122684e-02f,
  1.30352661e-01f, 3.98067832e-02f, -3.18866596e-02f, 1.93659756e-02f, -8.68991613e-02f, -1.09559447e-01f, 7.53770694e-02f, -5.59057519e-02f, 4.91272323e-02f, 2.06568707e-02f,
  -1.13390721e-01f, -4.56600599e-02f, -5.41154891e-02f, -7.46120811e-02f, 4.12588613e-03f, 1.21090323e-01f, -5.02264984e-02f, 4.14937222e-03f, 8.09105262e-02f, 7.48348683e-02f,
  8.49747881e-02f, 4.52169515e-02f, 1.30131409e-01f, 7.98631683e-02f, -5.72500713e-02f, -1.59770285e-03f, 4.18487228e-02f, 9.51361507e-02f, -5.10141030e-02f, -1.30769253e-01f,
  7.54469307e-03f, -3.29103470e-02f, -6.20160513e-02f, -6.88814297e-02f, 9.88317057e-02f, 4.87908907e-02f, 1.16926275e-01f, 3.46930102e-02f, -1.12086788e-01f, -6.13590144e-02f,
  -7.31417537e-02f, -4.13418785e-02f, 1.35196343e-01f, 1.19090982e-01f, 1.11740693e-01f, 1.69981942e-02f, -7.90573955e-02f, 5.13253659e-02f, 6.11237846e-02f, -9.12625641e-02f,
  4.64761741e-02f, -5.75298555e-02f, 1.53115559e-02f, -1.09461233e-01f, 1.02145694e-01f, 1.17171362e-01f, 8.19215551e-02f, -9.20620188e-02f, 1.44230545e-01f, 1.43881708e-01f,
  1.12591028e-01f, -5.06700911e-02f, -1.03921786e-01f, 7.25221187e-02f, -1.05557695e-01f, 7.89209455e-02f, 1.34745538e-02f, -9.02950466e-02f, -2.08466295e-02f, 2.21368130e-02f,
  -7.92297215e-05f, 2.62319893e-02f, -5.72371855e-02f, -1.51432734e-02f, 1.13760166e-01f, 2.04434618e-03f, 8.91853422e-02f, -5.21502495e-02f, 1.26606440e-02f, 3.35451327e-02f,
  -1.48104429e-01f, -5.90091385e-02f, 1.11154318e-01f, -4.66755331e-02f, 9.63525325e-02f, 4.96840291e-02f, -3.16121988e-02f, -1.10609822e-01f, 1.01125047e-01f, 5.71818613e-02f,
  8.53977427e-02f, -3.01669221e-02f, -1.32184839e-02f, -1.54137358e-01f, -1.34793641e-02f, 9.28542297e-03f, 3.31059694e-02f, 1.05782613e-01f, 5.32635748e-02f, -8.10776949e-02f,
  -1.78734977e-02f, 5.74795753e-02f, -5.05028293e-02f, -6.07882366e-02f, 5.51812127e-02f, 6.34000171e-03f, -5.71108907e-02f, -5.68009168e-02f, 1.02346390e-01f, 5.72291389e-02f,
  7.42775872e-02f, -7.94086084e-02f, 3.29140425e-02f, -9.24953148e-02f, -4.73730713e-02f, 1.63157374e-01f, 7.07574412e-02f, 1.31668821e-01f, 2.86600813e-02f, 1.29220691e-02f,
  1.11062638e-01f, 1.62714675e-01f, 1.11764027e-02f, 3.75632159e-02f, 1.55965477e-01f, 4.14924277e-03f, 6.69735521e-02f, 1.90643594e-02f, 4.87461761e-02f, -4.17471081e-02f,
  1.26167178e-01f, -3.75613011e-02f, -6.90308362e-02f, 3.07223271e-03f, 1.44247949e-01f, 9.64891613e-02f, -6.05259798e-02f, 1.29211396e-01f, 2.52645731e-01f, -1.05573339e-02f,
  -5.93189336e-02f, -1.03357255e-01f, -1.91720277e-01f, -9.52798501e-02f, -6.40044287e-02f, 2.03739591e-02f, -3.04422453e-02f, -1.20589085e-01f, -5.36032952e-02f, -5.76021895e-02f,
  -7.33829476e-03f, -3.63493674e-02f, -1.99191734e-01f, -2.63921488e-02f, 1.86233371e-01f, 1.78925142e-01f, -1.24515221e-01f, -5.80434687e-02f, 2.02354476e-01f, -3.04473639e-02f,
  -1.12881958e-01f, 2.91939620e-02f, 1.25962436e-01f, 1.33200616e-01f, -1.55774280e-02f, -3.32026295e-02f, -9.76941660e-02f, -8.28689411e-02f, 4.31504510e-02f, -2.40834951e-02f,
  -1.00051668e-02f, -7.73400953e-03f, -2.30209939e-02f, 1.34441569e-01f, 9.52189639e-02f, 6.04290795e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.08849242e-01f, -2.38703936e-02f, -5.33082895e-02f, 1.68473408e-01f, -2.30440628e-02f, 1.70155484e-02f, 1.44469455e-01f, -9.39162374e-02f, 1.37008041e-01f, -5.02159074e-02f,
  -1.33661598e-01f, 7.48306513e-02f, 5.31842038e-02f, 8.71064216e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.16698416e-02f, 1.32473752e-01f, 6.37032315e-02f, -3.87093484e-01f, 2.73142904e-02f, -3.70632447e-02f, 1.66805729e-01f, 3.77514698e-02f, -1.80787733e-03f, 3.56561989e-02f,
  8.42602327e-02f, 5.46539165e-02f, 1.53513663e-02f, -1.13551788e-01f, 2.04449862e-01f, -4.88107987e-02f, 2.39222944e-01f, -1.12085707e-01f, 5.47987744e-02f, 1.72064751e-01f,
  1.14764728e-01f, 1.97634414e-01f, 8.31532385e-03f, -3.36541655e-03f, 1.18301727e-01f, 3.53713900e-01f, 3.46144110e-01f, -1.43267632e-01f, 1.81362107e-01f, 1.33051679e-01f,
  -5.01626544e-02f, -2.78872754e-02f, -2.46356517e-01f, 2.34291151e-01f, 6.82794973e-02f, 7.13090748e-02f, -1.81887627e-01f, 2.37714667e-02f, -2.85338372e-01f, 1.13742694e-01f,
  2.98961699e-01f, -1.24373429e-01f, -8.53103921e-02f, 1.22102208e-01f, -1.82730749e-01f, 3.43969949e-02f, 6.52724952e-02f, -2.20413119e-01f, -4.40280512e-02f, -1.44056588e-01f,
  -1.05445921e-01f, -6.22674190e-02f, -6.50065020e-02f, -1.66394189e-01f, -1.14398032e-01f, -3.54368649e-02f, -1.92605052e-02f, -2.44586077e-03f, -2.28600688e-02f, -8.61512497e-02f,
  1.03214540e-01f, -4.60189693e-02f, 9.45882406e-03f, 1.26725316e-01f, 3.09271753e-01f, -3.03078219e-02f, -2.99183559e-02f, 2.67137289e-01f, 5.95345069e-03f, 7.12530315e-02f,
  -4.33854461e-02f, 1.59339294e-01f, 1.75721958e-01f, -2.39282027e-01f, 1.10398017e-01f, 4.62514795e-02f, 8.47820789e-02f, 8.92189518e-02f, 3.97679172e-02f, 5.23718894e-02f,
  8.82894620e-02f, 3.74511443e-02f, -5.30623347e-02f, 2.45537192e-01f, -1.58622876e-01f, 2.17000216e-01f, -1.23040989e-01f, 1.33522704e-01f, 9.05094668e-02f, -2.79252082e-01f,
  -1.69352323e-01f, 2.02680379e-01f, -6.98204860e-02f, -6.47224784e-02f, 5.77756092e-02f, -2.33830079e-01f, -2.45749895e-02f, 1.25414893e-01f, 3.71407390e-01f, -2.71956921e-01f,
  1.86834499e-01f, -1.68629989e-01f, 2.23308101e-01f, -1.68990552e-01f, -5.61116599e-02f, -2.63504055e-03f, 1.40824214e-01f, -1.27152577e-01f, 1.83187857e-01f, 8.66618529e-02f,
  -3.94690156e-01f, 3.20685744e-01f, 9.93895084e-02f, -1.28062457e-01f, -6.66158721e-02f, 3.00443405e-03f, 1.92904770e-02f, 1.01611763e-01f, 3.07234675e-02f, 2.43851356e-02f,
  9.13562998e-03f, -4.71035717e-03f, 1.09375194e-02f, 2.70966645e-02f, 4.97368313e-02f, -8.70742872e-02f, 7.96383694e-02f, 1.46796882e-01f, -1.03509575e-01f, 1.36139959e-01f,
  -4.59966585e-02f, 1.37597937e-02f, 3.23138423e-02f, 1.71535373e-01f, 1.45431131e-01f, -2.07426194e-02f, 8.84098783e-02f, 1.41240329e-01f, -9.19083878e-02f, 2.99779549e-02f,
  -1.03712603e-01f, -4.62806411e-02f, -1.61633879e-01f, -8.90975818e-02f, -2.05137432e-02f, 1.13426961e-01f, 3.58726047e-02f, -1.23093434e-01f, 5.52429110e-02f, -1.77413121e-01f,
  -8.85549560e-02f, 5.96704707e-02f, -9.75269079e-02f, 6.06550137e-03f, -1.61891535e-01f, 1.66863501e-01f, -6.40698597e-02f, -8.80495459e-02f, 2.36661464e-01f, 2.46491432e-01f,
  8.49184766e-02f, -2.09043562e-01f, -1.10150747e-01f, 1.94723770e-01f, -1.23260289e-01f, 3.03091854e-01f, 7.27974921e-02f, -3.03184420e-01f, 5.91118373e-02f, 3.22543949e-01f,
  6.74036443e-02f, -8.71054158e-02f, -3.92052159e-02f, -1.90603703e-01f, 2.31651235e-02f, 5.47803715e-02f, 2.29615241e-01f, 1.85383230e-01f, -5.93813211e-02f, -1.50228545e-01f,
  5.69274351e-02f, 1.38610259e-01f, 1.13387041e-01f, -7.47663006e-02f, 5.93005717e-02f, 1.10750966e-01f, -6.95950463e-02f, 1.05016060e-01f, -4.48296145e-02f, 5.31569645e-02f,
  -3.18916142e-02f, -1.33130297e-01f, 2.71787122e-02f, -1.58909306e-01f, -1.52559206e-01f, 1.48288831e-01f, -1.83124438e-01f, -1.47448480e-01f, -1.28814861e-01f, 8.64219293e-02f,
  3.86377610e-02f, -5.78602590e-02f, -1.55736163e-01f, 7.02365637e-02f, -5.14323600e-02f, -1.49666056e-01f, -1.23523384e-01f, 5.99393761e-03f, -1.57510638e-02f, -4.30280641e-02f,
  -6.60475940e-02f, 1.18416250e-01f, -5.54577224e-02f, 6.38088509e-02f, -8.89597908e-02f, 4.54906896e-02f, 6.86141150e-03f, -2.52438635e-01f, -1.89708173e-01f, 1.47771612e-01f,
  -2.13168770e-01f, -3.80613953e-02f, -3.50881480e-02f, -5.90045713e-02f, 1.14247687e-01f, 6.63244054e-02f, 1.83439508e-01f, -1.53352052e-01f, 2.27094248e-01f, -2.00685740e-01f,
  1.49079293e-01f, 1.51052391e-02f, -2.10535109e-01f, -1.39824077e-01f, -5.07819243e-02f, -5.30448407e-02f, 2.04686567e-01f, -2.32156832e-02f, -2.94949681e-01f, 1.82542056e-01f,
  1.14267297e-01f, -6.72153309e-02f, 1.22244976e-01f, -2.52289306e-02f, 1.14056595e-01f, -2.69523915e-02f, 9.37178209e-02f, 1.16597004e-01f, -3.87996770e-02f, 3.05059552e-02f,
  5.29621392e-02f, 1.13113403e-01f, 3.48084457e-02f, 1.40416920e-01f, -4.74692583e-02f, -2.06200257e-02f, -1.66555762e-01f, -6.16943985e-02f, 3.89037989e-02f, 1.97205946e-01f,
  -1.18875941e-02f, -1.27017617e-01f, 5.82449771e-02f, -8.85994732e-02f, -1.52708739e-01f, 1.75140053e-01f, 3.08407284e-02f, 5.54270111e-02f, -1.63737267e-01f, 1.00015976e-01f,
  -2.62318850e-01f, 4.03806046e-02f, -2.65701503e-01f, -1.62968449e-02f, -3.34869139e-02f, -2.03165278e-01f, 5.87194301e-02f, -1.09482437e-01f, -5.08005964e-03f, -5.35903731e-03f,
  -1.01807721e-01f, 1.62605103e-02f, 1.17548471e-02f, 1.38879180e-01f, -6.51220530e-02f, -3.16925459e-02f, 2.47596100e-01f, 1.93339229e-01f, -7.66560063e-02f, -5.22843152e-02f,
  -2.43986428e-01f, 1.52815834e-01f, -3.68170962e-02f, 6.41046464e-02f, 7.77085731e-03f, -1.69543028e-01f, -7.12858513e-02f, 3.88997048e-02f, -1.89897139e-02f, 5.22293039e-02f,
  3.23350802e-02f, -1.77329555e-01f, 7.35424608e-02f, 1.73225179e-01f, -1.59294814e-01f, 5.38939610e-02f, 1.06054671e-01f, 4.06428501e-02f, -1.07744582e-01f, 1.29717395e-01f,
  -2.49635652e-02f, 9.43497121e-02f, -5.84502742e-02f, -2.42205448e-02f, 1.04341418e-01f, -7.81555846e-02f, -3.72353978e-02f, -1.31589368e-01f, -1.35299459e-01f, -1.72995389e-01f,
  -1.79384664e-01f, -1.64396733e-01f, -5.31284488e-04f, 1.57783434e-01f, 3.04997265e-02f, -4.97918315e-02f, 6.79170946e-03f, -2.28128536e-03f, -1.51952982e-01f, 9.70433727e-02f,
  -3.45591120e-02f, -2.08209187e-01f, -1.10453777e-01f, -1.79701932e-02f, -2.09051177e-01f, -4.81812377e-03f, -1.87608808e-01f, 1.22949049e-01f, -8.04763883e-02f, -4.43326645e-02f,
  -1.90795332e-01f, -2.61257261e-01f, -3.74204591e-02f, -9.29550305e-02f, 4.86640446e-02f, 6.32639835e-03f, -1.84960604e-01f, 1.07499264e-01f, -2.41847858e-01f, -1.07119702e-01f,
  2.68058866e-01f, 2.82753050e-01f, -1.05445333e-01f, -2.08232462e-01f, -3.78346480e-02f, 1.76269799e-01f, -9.10026506e-02f, 2.13864982e-01f, 1.69814676e-01f, -2.30475321e-01f,
  2.16004718e-02f, 9.90124941e-02f, 5.81973158e-02f, 3.20604630e-02f, -1.75858438e-02f, -2.05468327e-01f, -1.05577700e-01f, -2.44424455e-02f, 2.03458983e-02f, -2.62568761e-02f,
  -3.60442847e-02f, -6.85978755e-02f, -1.12244943e-02f, 1.16521366e-01f, 8.58642906e-02f, 7.66246393e-02f, 3.17533650e-02f, 1.04800180e-01f, 1.42314717e-01f, 1.13610914e-02f,
  3.44641283e-02f, -7.96876103e-02f, -8.30010101e-02f, -1.53506041e-01f, 1.55127514e-02f, 9.63381007e-02f, 7.71168843e-02f, -2.75768340e-01f, 1.31977037e-01f, -1.03625864e-01f,
  3.99646088e-02f, -1.07152820e-01f, 6.31068945e-02f, 2.56283343e-01f, 1.93388402e-01f, -6.17133342e-02f, 9.10865366e-02f, -2.70212386e-02f, -1.05825119e-01f, -5.62842898e-02f,
  -8.69687647e-02f, -3.16166021e-02f, -1.47815384e-02f, -8.17800611e-02f, -1.46238208e-01f, -5.96377365e-02f, -4.18917416e-03f, 5.99986129e-02f, -8.91282111e-02f, 2.25188792e-01f,
  3.13981384e-01f, -2.39930436e-01f, 1.65460315e-02f, 8.29381868e-02f, -4.21476476e-02f, 1.09616816e-01f, -1.28074154e-01f, 4.02053073e-02f, -2.60071959e-02f, 2.37399265e-01f,
  -3.00088137e-01f, 1.12644911e-01f, -7.52927214e-02f, 9.88013670e-02f, 8.33881199e-02f, 6.96455836e-02f, -6.79890998e-03f, -1.64616443e-02f, -8.83245692e-02f, -1.49575576e-01f,
  1.00743078e-01f, -2.13266075e-01f, -1.66483387e-01f, 7.65229613e-02f, 4.95144837e-02f, -6.63201511e-02f, -1.34229541e-01f, -1.54078797e-01f, -1.10756099e-01f, -1.08028769e-01f,
  9.21990648e-02f, 3.50706838e-02f, 1.88548155e-02f, -1.44725004e-02f, -1.05775341e-01f, -7.16870949e-02f, 1.30767263e-02f, 4.06877650e-03f, -2.38039494e-01f, 8.38346779e-02f,
  -1.83954984e-02f, -2.26811603e-01f, 9.08984151e-03f, 3.48220244e-02f, -3.25446948e-02f, -2.50696272e-01f, -1.97393410e-02f, 2.03637201e-02f, 7.38430098e-02f, -2.45801341e-02f,
  1.13658823e-01f, 6.50203675e-02f, 7.78440312e-02f, -5.43116592e-02f, 9.83146951e-02f, 4.42851000e-02f, -1.05886035e-01f, -2.14183684e-02f, -8.16241652e-02f, -5.15060350e-02f,
  -3.47529612e-02f, -6.45311549e-02f, -3.83346295e-03f, 2.73822308e-01f, 1.29880443e-01f, -5.75506054e-02f, -8.19502771e-02f, 6.69091120e-02f, -1.86280847e-01f, -4.26040106e-02f,
  -2.41568014e-01f, 2.25858822e-01f, -1.66396182e-02f, 1.01259664e-01f, -1.02547571e-01f, -1.62325829e-01f, -5.68364039e-02f, 2.87514716e-01f, 2.09142864e-01f, -2.13372767e-01f,
  -1.35944396e-01f, 1.36093110e-01f, 1.87515449e-02f, -1.12687588e-01f, 2.00329557e-01f, -1.74255446e-01f, -1.56173006e-01f, -1.14138670e-01f, -4.68962863e-02f, -3.21603194e-02f,
  -4.47659753e-02f, -7.83507600e-02f, -2.01375633e-01f, 1.33559898e-01f, -5.26902527e-02f, -8.41768738e-03f, 9.23525468e-02f, 1.36744395e-01f, 1.16643514e-02f, 4.48379340e-03f,
  -9.90230739e-02f, -9.34192613e-02f, 1.23274960e-01f, 7.04516396e-02f, 9.68882516e-02f, 2.09780857e-01f, -1.31056100e-01f, -3.12712453e-02f, -1.40591264e-01f, 1.73293158e-01f,
  -1.99067906e-01f, -2.08690017e-01f, -1.75622851e-01f, 4.12360020e-02f, -1.87929124e-01f, 9.74436328e-02f, -2.16956511e-01f, 2.44182035e-01f, -3.92713584e-02f, 1.59781054e-02f,
  4.03380319e-02f, 8.82833749e-02f, 1.88650340e-01f, -8.81120265e-02f, 5.71764819e-02f, -7.53287375e-02f, 3.29475254e-02f, -2.88281649e-01f, -1.53237209e-02f, 2.90413409e-01f,
  2.21345052e-02f, -3.30244824e-02f, 8.16313997e-02f, -2.80239910e-01f, 2.59595901e-01f, -2.40047887e-01f, 4.56247292e-02f, -1.03337415e-01f, 1.83296502e-01f, -1.16794981e-01f,
  -2.95004565e-02f, -1.69113621e-01f, -3.17163736e-01f, -9.74172652e-02f, -7.61003569e-02f, 8.74715224e-02f, 8.62854794e-02f, 2.21662253e-01f, -1.33190647e-01f, 2.46400431e-01f,
  1.77006975e-01f, -2.89146119e-04f, 8.76096543e-03f, -6.75790906e-02f, 1.52650222e-01f, 1.25063688e-01f, 2.97996849e-01f, -1.04990743e-01f, 4.52220589e-02f, -1.91599671e-02f,
  -2.11351365e-03f, -2.03960966e-02f, 3.78203243e-02f, 7.94632137e-02f, -6.90159276e-02f, 9.99882072e-02f, 1.24943495e-01f, -8.72321948e-02f, -8.55765194e-02f, 6.39461563e-04f,
  -1.02159306e-01f, 8.13877955e-02f, 1.29470587e-01f, 1.79328218e-01f, -1.05913565e-01f, 5.17330728e-02f, 9.25926864e-02f, -1.37074530e-01f, -3.13840732e-02f, 5.63477241e-02f,
  -4.77196574e-02f, -6.16353452e-02f, -4.23457520e-03f, -5.06940447e-02f, 5.11818714e-02f, -1.98895320e-01f, -1.02142528e-01f, 3.02066039e-02f, -1.11653842e-01f, -9.11091939e-02f,
  -1.56419184e-02f, -1.11694232e-01f, 3.51724029e-02f, -5.91027029e-02f, 3.18752863e-02f, 1.82538331e-02f, 2.37555817e-01f, 2.60795712e-01f, 4.82173488e-02f, -2.12758809e-01f,
  4.55380455e-02f, -6.52897581e-02f, -7.90368393e-02f, 3.30359936e-01f, 8.03052820e-03f, -2.99114853e-01f, 1.45658841e-02f, 4.89421666e-01f, 2.16278702e-01f, -2.89506078e-01f,
  -1.60444692e-01f, -1.24906071e-01f, 1.08453818e-01f, -2.03444157e-02f, 2.20634356e-01f, 4.01890138e-03f, -3.90064456e-02f, 7.64708174e-03f, 1.03477031e-01f, 1.51763424e-01f,
  2.93572061e-02f, -1.30988792e-01f, 7.65452208e-03f, 5.44607863e-02f, 1.12750858e-01f, 4.26440574e-02f, 1.00237235e-01f, 7.76856840e-02f, 5.04028834e-02f, -3.89297009e-02f,
  1.09622777e-01f, 2.58117542e-02f, -1.48216914e-02f, 1.93047658e-01f, -7.87716582e-02f, 5.99055663e-02f, -1.18500888e-02f, 2.01416746e-01f, 8.74641410e-04f, -2.01304093e-01f,
  -1.96315110e-01f, 1.49044171e-01f, -4.19129245e-02f, 9.27323699e-02f, 4.26723994e-03f, 1.96273774e-01f, -2.25661527e-02f, 3.75965573e-02f, 6.06412068e-02f, 1.57821700e-01f,
  1.26265720e-01f, -3.38995159e-02f, -4.40661311e-02f, -1.23207793e-02f, 1.55887380e-01f, -2.83197612e-01f, -5.99979460e-02f, 6.04496896e-02f, -1.68093309e-01f, -2.58020312e-01f,
  -7.56975040e-02f, -1.21021420e-01f, 1.19670190e-01f, -6.18034601e-02f, 2.32069492e-01f, -5.21354079e-02f, 1.49651870e-01f, -5.27723357e-02f, 1.26480952e-01f, -2.86728367e-02f,
  -2.80330092e-01f, -7.66088590e-02f, -2.92854011e-02f, -5.85702062e-02f, 4.64848056e-02f, -1.50234997e-03f, -3.06821048e-01f, 2.83618450e-01f, 1.39350459e-01f, -1.67466983e-01f,
  2.99501419e-03f, 2.00892668e-02f, 1.52844586e-03f, -3.08720171e-02f, 1.64576665e-01f, -1.99900102e-02f, -4.82410332e-03f, 9.02611762e-02f, -1.13239609e-01f, 9.75005925e-02f,
  -1.06991008e-01f, 9.80525017e-02f, -7.58339316e-02f, 2.16918647e-01f, 2.14990228e-01f, -7.54129887e-02f, -9.41509660e-03f, 2.35765837e-02f, 1.13211870e-01f, -1.11572258e-01f,
  -6.64905980e-02f, -9.84550547e-03f, -1.91924840e-01f, 2.49754131e-01f, 1.90057978e-01f, -4.35503833e-02f, -1.44713297e-01f, 5.07219248e-02f, -1.42635182e-01f, 1.91985026e-01f,
  -9.42753032e-02f, -1.54401928e-01f, -1.63984761e-01f, -9.89717618e-02f, -1.80449970e-02f, 1.94432780e-01f, 2.16033056e-01f, -8.02477077e-02f, -7.22105056e-03f, 2.23278388e-01f,
  1.46757990e-01f, -1.99460331e-02f, 6.59550652e-02f, 1.50656998e-01f, -3.41901444e-02f, 1.20014120e-02f, 2.32869238e-01f, -7.25772455e-02f, 1.49449319e-01f, 1.17107585e-01f,
  5.45781367e-02f, 1.68863744e-01f, -1.37867793e-01f, -2.01816142e-01f, 7.94230998e-02f, 1.11179985e-01f, 3.34622934e-02f, 6.37536719e-02f, -2.02724516e-01f, 4.53974344e-02f,
  8.39635581e-02f, -2.11783149e-03f, 1.39353991e-01f, 1.04742453e-01f, -7.86713604e-03f, 7.41184205e-02f, -6.07282892e-02f, -1.92375313e-02f, 1.46826103e-01f, -5.63065112e-02f,
  -2.87460648e-02f, 1.01039454e-01f, 2.62762476e-02f, -7.68952072e-02f, -4.71927635e-02f, 4.49077561e-02f, 1.23570599e-02f, -1.92090303e-01f, -8.36851355e-03f, 1.15252882e-01f,
  1.05189703e-01f, -8.36047754e-02f, 1.31810203e-01f, 5.85474968e-02f, -1.32482737e-01f, -1.11675240e-01f, -1.65656582e-02f, 1.14543185e-01f, 4.73914854e-02f, 7.98089430e-02f,
  -2.46735308e-02f, -1.19026259e-01f, -1.30530177e-02f, -5.73223233e-02f, 8.82468373e-02f, -1.02525003e-01f, -1.20666055e-02f, 9.59178731e-02f, -1.36747137e-01f, 6.09090105e-02f,
  5.91019168e-02f, -9.74155888e-02f, -1.30134851e-01f, 2.37109780e-01f, 2.43756980e-01f, -1.93591520e-01f, 6.06442845e-05f, -5.09436093e-02f, 2.25988887e-02f, -1.07873313e-01f,
  -5.81336655e-02f, 9.10784379e-02f, -1.04828484e-01f, 9.12660062e-02f, -8.08021426e-02f, -2.84781437e-02f, -1.79046765e-01f, 2.51699597e-01f, 5.28368019e-02f, -2.74351925e-01f,
  -5.03295958e-02f, 6.82200044e-02f, -5.72721921e-02f, 2.93252133e-02f, 4.57085110e-02f, -6.09925538e-02f, -1.78231224e-01f, 7.12146312e-02f, 1.05227895e-01f, -5.25345020e-02f,
  2.47361492e-02f, -9.32665169e-02f, -1.44145623e-01f, -3.16043980e-02f, 1.33862495e-01f, 8.15569088e-02f, -7.96972662e-02f, 6.10756427e-02f, 1.03398047e-01f, -1.24643389e-02f,
  1.24721304e-01f, 9.76408869e-02f, 5.34128025e-02f, -9.69650820e-02f, 6.06485307e-02f, 9.99962613e-02f, 1.79067329e-02f, 5.92373572e-02f, -1.24997611e-03f, 1.52704731e-01f,
  4.66571525e-02f, -1.40944436e-01f, -2.35349685e-01f, -3.34933517e-03f, -2.86848359e-02f, 9.93156210e-02f, -5.72056733e-02f, 2.09339827e-01f, -4.59219180e-02f, -1.23813242e-01f,
  -3.24562099e-03f, -1.38593931e-02f, 3.71163003e-02f, 1.29845977e-01f, 1.52442664e-01f, 6.51466399e-02f, -5.32877930e-02f, -1.08681731e-01f, -6.64707348e-02f, 9.96510908e-02f,
  -9.20429826e-02f, 7.66551867e-02f, -1.68124422e-01f, -3.82899284e-01f, 1.88424528e-01f, 6.08642213e-02f, 9.82587039e-02f, -2.69153446e-01f, 8.49459618e-02f, -1.49848267e-01f,
  6.16991371e-02f, 2.31899157e-01f, -3.48598063e-01f, -1.27563819e-01f, 6.78994656e-02f, -8.06808695e-02f, 6.59115030e-04f, 2.94139862e-01f, -2.30272979e-01f, 2.66551346e-01f,
  -5.51024079e-02f, 6.99679926e-02f, 4.07651179e-02f, 6.42744079e-02f, 8.07102546e-02f, -8.20111600e-04f, 9.92865935e-02f, -9.90703925e-02f, -6.83535589e-04f, -7.51060173e-02f,
  3.21432501e-02f, -4.79705669e-02f, -7.73988105e-03f, -1.02070663e-02f, 4.59569842e-02f, 1.57409713e-01f, -5.04581779e-02f, 1.03344768e-02f, 1.25707477e-01f, -1.79130018e-01f,
  1.17698714e-01f, -2.15637330e-02f, 3.32904756e-02f, -4.48587835e-02f, 5.46676181e-02f, 2.18785763e-01f, -1.08485399e-02f, 1.74847484e-01f, -3.43889892e-02f, -7.81368464e-02f,
  1.23989388e-01f, -1.96071044e-02f, 1.05718791e-01f, 4.38187383e-02f, 1.20488174e-01f, 2.45986972e-02f, 1.10578045e-01f, 5.36584631e-02f, 1.25929387e-02f, 9.46317986e-02f,
  -8.50102529e-02f, 1.46589145e-01f, 3.00315082e-01f, -1.48805454e-01f, 2.65719384e-01f, 1.31683931e-01f, -8.69580433e-02f, -2.15606734e-01f, -7.59154856e-02f, 1.29689038e-01f,
  9.89170838e-03f, -7.64111280e-02f, -6.30444065e-02f, -8.65332782e-02f, -2.19841674e-01f, 1.23427503e-01f, 4.37997095e-02f, -1.02459483e-01f, -8.84490609e-02f, 5.92125915e-02f,
  -2.07123786e-01f, 6.75211400e-02f, 1.49082497e-01f, -2.87942261e-01f, 6.01151921e-02f, 2.53305994e-02f, 4.83616441e-03f, 7.43286982e-02f, -9.17195082e-02f, -3.53112221e-02f,
  6.00083470e-02f, -2.71623321e-02f, 5.43937013e-02f, -1.09763309e-01f, 7.26101696e-02f, -2.14758143e-02f, 7.65239149e-02f, 1.02916181e-01f, 9.08803344e-02f, 8.04935843e-02f,
  -2.12308899e-01f, -1.12511612e-01f, -1.02971792e-02f, -1.40890270e-01f, -4.85598259e-02f, -1.09705351e-01f, 6.89378977e-02f, -6.23630732e-02f, -1.23068597e-02f, 1.18577383e-01f,
  1.16729952e-01f, 3.24922465e-02f, 6.21363074e-02f, -1.30957425e-01f, -1.48811996e-01f, -2.28168324e-01f, -1.56856887e-02f, -1.06385984e-01f, 7.49651566e-02f, 3.00169252e-02f,
  3.76648605e-02f, -1.25055507e-01f, -5.87020703e-02f, -6.82317987e-02f, -5.93755692e-02f, -6.18789345e-02f, 3.75414267e-02f, -1.08786859e-01f, 4.04412672e-02f, -1.23805225e-01f,
  1.45275623e-01f, 2.46615142e-01f, -1.85228676e-01f, -5.40920906e-02f, -2.73727208e-01f, 2.93354183e-01f, -1.13113172e-01f, 3.97568680e-02f, 3.40745598e-02f, -2.11970005e-02f,
  1.20077118e-01f, -8.15147385e-02f, 7.95535222e-02f, 1.18105195e-01f, -7.80650880e-03f, -1.17065765e-01f, 1.26055107e-01f, -1.76974565e-01f, -6.82826042e-02f, 8.20278600e-02f,
  -4.37741764e-02f, -1.59834445e-01f, -1.09118149e-02f, 8.44501927e-02f, -1.38316259e-01f, -9.76119936e-02f, -1.86862797e-02f, -7.67230541e-02f, 3.29126194e-02f, 1.20005578e-01f,
  -3.30582336e-02f, -6.36536777e-02f, -6.34302497e-02f, -7.49437064e-02f, -4.61430438e-02f, -3.41690369e-02f, 4.12528142e-02f, -2.82658599e-02f, 1.03366217e-02f, -7.67077878e-02f,
  -5.83530255e-02f, -5.62534705e-02f, -2.34352708e-01f, 2.12964326e-01f, 2.10635677e-01f, -1.13320507e-01f, -7.81933367e-02f, 3.35277133e-02f, -2.23331869e-01f, 1.06693126e-01f,
  -1.40470132e-01f, 7.50755146e-02f, 1.42195132e-02f, -1.33192509e-01f, -2.66385153e-02f, -1.26836702e-01f, 1.44058943e-01f, -1.63273141e-01f, 4.11816947e-02f, 1.83825836e-01f,
  2.12164685e-01f, -1.77466318e-01f, 1.62032157e-01f, 1.40914440e-01f, 7.59201720e-02f, 2.29771361e-01f, 1.02413028e-01f, -1.85081512e-01f, -2.58180946e-02f, 1.19651854e-01f,
  -1.95072651e-01f, 1.94958180e-01f, -1.75217703e-01f, -1.80574983e-01f, 1.96513087e-01f, 1.20019503e-01f, -7.94292316e-02f, 1.20883342e-02f, -2.13559065e-02f, 3.90350856e-02f,
  3.33259642e-01f, -2.02827305e-02f, 1.04135135e-02f, 6.44590557e-02f, 1.19116567e-01f, 5.58573492e-02f, 6.72417134e-02f, -5.23972558e-03f, 4.33401056e-02f, -1.04456417e-01f,
  3.43568027e-02f, 5.28008230e-02f, 1.07571632e-01f, 6.53921068e-02f, -2.96510989e-03f, -1.54617429e-02f, -4.24989834e-02f, -2.20136672e-01f, -3.92706804e-02f, 2.43437011e-02f,
  -3.68357226e-02f, -2.79013932e-01f, 9.39912647e-02f, -8.09076652e-02f, 2.14630216e-01f, 6.10178569e-04f, 1.66760996e-01f, 1.55441552e-01f, 1.71634719e-01f, -7.14402348e-02f,
  7.59515762e-02f, -2.55081970e-02f, 1.86956421e-01f, -1.58609331e-01f, 1.74447954e-01f, -7.94438347e-02f, 1.25774249e-01f, 8.37808102e-02f, -1.13514028e-01f, 7.21143112e-02f,
  7.67830908e-02f, 2.00487152e-01f, 1.04077265e-01f, 1.85298637e-01f, 1.55676693e-01f, -2.03191817e-01f, 2.23067477e-02f, 9.99748260e-02f, -1.54252514e-01f, -7.39779696e-02f,
  -1.79939628e-01f, 1.11725211e-01f, 5.91250397e-02f, -5.17414324e-02f, -1.32407509e-02f, 2.05694064e-01f, -2.03357488e-01f, -5.12103997e-02f, 1.83659941e-01f, 1.58912204e-02f,
  -1.21901296e-01f, 7.78819770e-02f, -8.58783349e-02f, -3.66472788e-02f, 1.67482361e-01f, -7.51022547e-02f, -1.49908051e-01f, 1.80064112e-01f, -1.37835383e-01f, 3.10818739e-02f,
  -1.00032650e-01f, 3.97992209e-02f, -4.88308705e-02f, -7.17081204e-02f, -1.11561298e-01f, 1.13787428e-01f, -8.10880959e-02f, -8.73563588e-02f, 7.23754913e-02f, -4.63121831e-02f,
  -6.24425933e-02f, -1.78175300e-01f, 1.58519849e-01f, 1.56772658e-01f, -9.48172249e-03f, -1.29217371e-01f, 1.37500927e-01f, 4.78600040e-02f, 1.46005258e-01f, 9.26441625e-02f,
  -4.95111682e-02f, 3.09951678e-02f, 1.31546617e-01f, 1.04188971e-01f, -6.35801256e-02f, 2.52346750e-02f, 6.34515472e-03f, -7.68860355e-02f, -1.03139445e-01f, 2.58335322e-02f,
  6.66173175e-02f, -9.48968530e-02f, -1.50488466e-01f, 1.22277923e-01f, -1.02162408e-02f, 1.24747604e-01f, -1.36614770e-01f, 1.50721103e-01f, 1.05584368e-01f, -1.21049779e-02f,
  8.48912224e-02f, 1.70821622e-01f, -1.58632512e-03f, 7.36031011e-02f, 4.90987524e-02f, -3.27719026e-03f, 2.33560592e-01f, -1.51093835e-02f, -2.00915813e-01f, 1.87226996e-01f,
  5.61365187e-02f, -1.41168803e-01f, 6.00437224e-02f, 5.75069385e-03f, 5.61621413e-02f, -1.99152514e-01f, -5.22767194e-02f, -1.77266076e-01f, -1.13041140e-02f, -1.64928123e-01f,
  1.50804386e-01f, 1.11343138e-01f, -2.27731168e-02f, -9.63362493e-03f, 8.91826451e-02f, -9.16952789e-02f, 1.33682787e-01f, 8.64710063e-02f, 1.89381428e-02f, 3.94565314e-02f,
  1.31100252e-01f, -5.93222156e-02f, 1.08902007e-01f, 7.61298910e-02f, 1.79254338e-02f, 5.14719374e-02f, -1.69005677e-01f, 2.21096396e-01f, 1.14829488e-01f, -1.33284405e-01f,
  4.52771895e-02f, -7.13500474e-03f, -7.56423175e-02f, -8.24001506e-02f, -1.49462149e-01f, 2.02480808e-01f, 2.23362401e-01f, -4.81740162e-02f, -1.58887714e-01f, 9.81558859e-02f,
  -1.22643486e-01f, -9.77651998e-02f, 7.19886646e-02f, 4.64211367e-02f, 1.77971274e-01f, 1.98528189e-02f, -2.77117062e-02f, 8.93598422e-02f, 1.65946588e-01f, 9.39107314e-02f,
  1.04734208e-02f, 2.68647552e-01f, 1.41774356e-01f, -1.96043134e-01f, 1.35828942e-01f, 9.97179821e-02f, 7.80608952e-02f, 1.35078460e-01f, -1.00283183e-01f, -1.29242335e-02f,
  -2.03620657e-01f, 2.25657567e-01f, -2.02527836e-01f, 6.27461970e-02f, -1.92870066e-01f, 7.94325471e-02f, 9.67673492e-03f, -8.11961293e-02f, 2.58078054e-02f, 1.68801308e-01f,
  -1.38981625e-01f, -1.70523211e-01f, 2.03055069e-01f, -9.03880969e-02f, -1.57845899e-01f, 1.01823285e-02f, 1.39013981e-03f, -8.60283896e-02f, -1.19682170e-01f, 7.20960274e-02f,
  7.96827972e-02f, 4.65103947e-02f, -2.37760451e-02f, -6.07823692e-02f, 7.53291883e-03f, -4.99732755e-02f, -4.18875217e-02f, -1.01794295e-01f, 3.50764170e-02f, -1.00236237e-02f,
  6.02611676e-02f, -7.61616901e-02f, 1.56971067e-01f, -5.38354099e-04f, 6.32009134e-02f, 7.88772106e-02f, 8.41204971e-02f, 5.14329374e-02f, -6.20189756e-02f, 6.93836715e-03f,
  1.14184907e-02f, 1.34329628e-02f, -2.41289809e-02f, -5.77060618e-02f, -2.17960730e-01f, 1.89499080e-01f, 5.11796474e-02f, -1.55223548e-01f, -6.47871941e-02f, -2.82151490e-01f,
  -3.64424437e-02f, 1.00926779e-01f, 9.31646600e-02f, -1.85148016e-01f, -1.73999846e-01f, 1.93785220e-01f, 6.91666976e-02f, 6.30786270e-02f, 6.73557296e-02f, -5.10341264e-02f,
  4.53228652e-02f, 1.91056579e-01f, 2.94762552e-01f, -3.06225955e-01f, 1.28513286e-02f, -5.23167066e-02f, -1.67016372e-01f, 2.58034527e-01f, -1.28391951e-01f, -1.88676074e-01f,
  -5.79490885e-02f, 3.26719016e-01f, 7.56194666e-02f, -2.17120439e-01f, -1.07222095e-01f, -3.89071442e-02f, 2.11632371e-01f, 1.03207543e-01f, 2.98511177e-01f, 1.34750158e-01f,
  -2.54090168e-02f, -1.83970273e-01f, 1.28046989e-01f, 2.03778778e-04f, 1.46637782e-01f, 6.67004138e-02f, -7.51269087e-02f, 6.61212998e-03f, 1.42480984e-01f, -1.50835132e-02f,
  -3.15009896e-03f, -8.60939175e-02f, -4.15244624e-02f, -1.67156756e-02f, -1.64619640e-01f, 6.61643744e-02f, 7.05659986e-02f, -1.04780868e-01f, -3.19282822e-02f, 6.91536590e-02f,
  -9.92807597e-02f, 5.26641235e-02f, 6.75609484e-02f, 1.24326214e-01f, -1.04951382e-01f, -6.71804994e-02f, 1.03252485e-01f, -1.33572236e-01f, -5.60873523e-02f, -1.44240007e-01f,
  -2.37028841e-02f, 2.71960944e-02f, -1.17973149e-01f, -1.04352251e-01f, 2.78048329e-02f, -9.04790089e-02f, -1.06180318e-01f, 1.26575558e-02f, 8.76834244e-02f, -8.17134511e-03f,
  5.19777136e-03f, -3.31213400e-02f, -1.13137509e-03f, 3.32145765e-02f, 1.43965214e-01f, 3.78020033e-02f, -8.67118463e-02f, 5.98284649e-03f, -1.72268540e-01f, 1.75998911e-01f,
  -1.21479861e-01f, 1.56141803e-01f, -8.54208544e-02f, -1.22665808e-01f, 1.26877412e-01f, 7.02615306e-02f, 6.13252595e-02f, 2.09973715e-02f, -6.15964569e-02f, 5.10286465e-02f,
  2.72096077e-04f, -1.91280574e-01f, 1.23363905e-01f, 1.64938569e-02f, 1.19471245e-01f, -2.39404663e-02f, 6.39473572e-02f, 8.45071524e-02f, 5.39135598e-02f, 1.01338990e-01f,
  4.57731262e-02f, 3.21547724e-02f, -5.70675544e-02f, 2.23961957e-02f, -2.02451702e-02f, -1.19462602e-01f, -1.00996844e-01f, 5.65961376e-02f, 1.37622297e-01f, 3.20477709e-02f,
  -2.06765234e-02f, 4.33788598e-02f, 7.90060498e-03f, 7.58870644e-03f, -7.57057294e-02f, 8.21086839e-02f, -2.52165675e-01f, 1.07265353e-01f, 6.00554869e-02f, 8.87353346e-02f,
  -1.34917751e-01f, -9.99362618e-02f, -9.72323790e-02f, -6.72375932e-02f, 3.86163816e-02f, 4.06780001e-03f, -1.82114169e-02f, -5.76260760e-02f, 3.57919708e-02f, 9.81530398e-02f,
  1.74315095e-01f, -1.90534785e-01f, -1.00730518e-02f, 1.31357342e-01f, -1.44788563e-01f, 1.01053640e-01f, 6.70847222e-02f, -5.99677972e-02f, 1.06381603e-01f, 1.53178349e-02f,
  2.62691587e-01f, -2.06167817e-01f, 3.32531035e-02f, 1.29839271e-01f, -5.85240312e-02f, 3.12865317e-01f, -9.55509096e-02f, -2.06770763e-01f, 1.46589279e-02f, 3.61626774e-01f,
  4.08784971e-02f, -1.61394253e-01f, -1.14284046e-01f, -2.69313641e-02f, -1.68892555e-02f, 9.15753394e-02f, 2.19126701e-01f, -1.14360061e-02f, 6.02451526e-02f, -1.88094988e-01f,
  1.44232318e-01f, 1.88458070e-01f, 1.79115266e-01f, -4.51988243e-02f, -2.32781414e-02f, -1.13745525e-01f, 1.77355886e-01f, 5.74234985e-02f, -1.28405839e-01f, 2.50416733e-02f,
  -1.00956991e-01f, -2.21622661e-01f, -9.79040340e-02f, 7.13870600e-02f, -8.20103586e-02f, -1.39969245e-01f, -2.18278989e-02f, -2.57112850e-02f, -1.11165680e-01f, -3.24964570e-03f,
  7.60550201e-02f, 1.17027752e-01f, 8.02487060e-02f, -5.22745810e-02f, -8.61110911e-02f, -1.13220975e-01f, -1.02010600e-01f, -6.62738979e-02f, -1.02394456e-02f, 1.04372334e-02f,
  9.44657400e-02f, -1.84219390e-01f, 5.13331266e-03f, -9.73729417e-02f, -1.20286629e-01f, -1.32695888e-03f, 2.31983382e-02f, -3.76212373e-02f, 4.21354547e-02f, -6.43894896e-02f,
  -7.21831322e-02f, 6.26989603e-02f, 1.12544343e-01f, 2.01968819e-01f, -1.71106458e-01f, 1.34480193e-01f, -1.37798607e-01f, 2.04797462e-01f, -3.96633446e-02f, 1.48985520e-01f,
  -7.97293633e-02f, 1.69629350e-01f, 2.12641656e-01f, -2.50973344e-01f, -2.79764999e-02f, 1.29229188e-01f, 6.78781271e-02f, -1.26192808e-01f, 8.93211216e-02f, -3.85625921e-02f,
  -1.68774486e-01f, -1.57449804e-02f, 4.38823625e-02f, -3.97230648e-02f, -1.24133222e-01f, -1.00377247e-01f, 3.36838700e-02f, -6.20457157e-03f, 1.11706860e-01f, -9.23919827e-02f,
  -7.93460160e-02f, -4.70047705e-02f, -5.01928329e-02f, -6.68237135e-02f, 5.44228218e-02f, -1.14433907e-01f, -7.87622947e-03f, -1.93447128e-01f, -7.32265189e-02f, 2.68960625e-01f,
  1.37910098e-02f, 9.08313319e-02f, 3.05284690e-02f, 3.66552249e-02f, -1.66598693e-01f, -1.48069471e-01f, -1.22674733e-01f, -3.97308022e-02f, -1.96957529e-01f, 2.59118397e-02f,
  -2.00474083e-01f, 5.85420653e-02f, -4.22294326e-02f, 3.80961262e-02f, -8.81856531e-02f, -2.27126732e-01f, -2.17637703e-01f, -2.55083948e-01f, -3.75881717e-02f, 8.86528473e-03f,
  -1.10429294e-01f, -2.03080267e-01f, -6.00137711e-02f, 2.14895800e-01f, -4.26293239e-02f, -1.64066598e-01f, 1.67905867e-01f, 1.85526758e-01f, 2.23990470e-01f, -2.97812372e-01f,
  -5.24345562e-02f, 1.87705383e-01f, 1.36187095e-02f, 2.76274741e-01f, 1.60649046e-01f, -1.86368540e-01f, -2.21156105e-01f, 1.86093196e-01f, 1.14500768e-01f, 1.95899531e-02f,
  -1.01604022e-01f, -1.71643663e-02f, -3.45935822e-02f, 1.24494165e-01f, 2.03515545e-01f, 1.63243011e-01f, 8.93357992e-02f, -1.11669585e-01f, 1.33869484e-01f, 7.04810321e-02f,
  1.87610239e-01f, -7.33568240e-03f, -1.52084142e-01f, 1.11192793e-01f, 1.38438702e-01f, 1.23780474e-01f, 1.08976625e-01f, 1.37290642e-01f, -1.33992210e-01f, -2.16094665e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.42129357e-02f, -2.48608482e-03f, -2.09368765e-03f, 1.07306473e-01f, -1.14014605e-02f, -3.45537476e-02f, -4.30243798e-02f, 1.14476578e-02f, -8.36459696e-02f, 1.26208827e-01f,
  2.92579532e-02f, 8.04141238e-02f, -4.06265147e-02f, 9.21813697e-02f, 2.29732320e-02f, 6.33011237e-02f, 1.59553215e-02f, 3.17205340e-02f, -1.12852501e-02f, -9.00879949e-02f,
  -3.36021148e-02f, -6.74602017e-02f, 9.18619260e-02f, -5.50136715e-02f, -1.66560672e-02f, 1.99411511e-02f, -2.83877645e-02f, -6.71840832e-02f, 1.51866093e-01f, -7.63079002e-02f,
  -2.04056278e-02f, 1.52125657e-01f, 1.25655517e-01f, -5.14877997e-02f, 3.41254994e-02f, 1.53990403e-01f, -1.54940560e-01f, 1.50273725e-01f, -4.68697883e-02f, -2.73751263e-02f,
  -6.75033852e-02f, 2.76850518e-02f, 6.69661090e-02f, 5.13184182e-02f, 4.14943583e-02f, -4.44027744e-02f, 1.15946047e-01f, -5.16062379e-02f, 6.83213994e-02f, 1.02060616e-01f,
  -6.57328889e-02f, 5.97208105e-02f, -1.74526833e-02f, 7.88342580e-02f, 1.61882266e-01f, -2.46803295e-02f, 8.16196054e-02f, 4.67097759e-02f, -3.98840457e-02f, -3.34153064e-02f,
  1.00483438e-02f, 1.18299998e-01f, 8.38744864e-02f, -1.17026903e-01f, -7.54280686e-02f, 3.39829177e-02f, -3.38077098e-02f, -3.73821035e-02f, 8.96668285e-02f, 1.15091121e-02f,
  5.62567748e-02f, 1.15726054e-01f, -3.62848006e-02f, -2.37237200e-01f, -1.54378563e-01f, -3.79185495e-03f, 1.51636764e-01f, 7.53065059e-03f, 6.41334355e-02f, 1.94467269e-02f,
  -7.14341253e-02f, 1.27383411e-01f, 1.40691727e-01f, 8.15495029e-02f, -1.07639842e-02f, 1.07795317e-02f, -1.06326684e-01f, 1.13578938e-01f, 1.41599312e-01f, -8.84929672e-03f,
  -1.42225355e-01f, 1.59364074e-01f, -5.26835546e-02f, -1.49379134e-01f, -4.35767174e-02f, -4.66898680e-02f, -6.46910025e-03f, 6.23561302e-03f, -8.26174319e-02f, -1.39413610e-01f,
  9.34945606e-03f, -1.54791847e-01f, 8.36662482e-04f, 7.19401017e-02f, 2.30652057e-02f, -4.38091829e-02f, 2.00164076e-02f, 5.55945374e-02f, 9.14866105e-02f, -6.27377033e-02f,
  -2.17379436e-01f, 1.45901054e-01f, 9.37556848e-02f, 4.97967713e-02f, -1.78753529e-02f, 8.67487565e-02f, 1.82522953e-01f, -1.67954825e-02f, -1.07459158e-01f, 9.02815387e-02f,
  -5.08489124e-02f, 9.38614607e-02f, -7.22130165e-02f, -5.99058941e-02f, -1.06266864e-01f, 1.08833022e-01f, -9.25966874e-02f, 7.39276549e-03f, -5.60909770e-02f, -4.88079619e-03f,
  -1.27927586e-01f, 1.54489815e-01f, -9.05801430e-02f, -1.16969779e-01f, -7.71869123e-02f, 5.67988828e-02f, 9.28818211e-02f, 3.83143164e-02f, 4.43230793e-02f, -1.29737869e-01f,
  3.14379185e-02f, -3.16088684e-02f, 4.90768366e-02f, -1.17961697e-01f, -1.23832271e-01f, -5.23629934e-02f, 1.27146333e-01f, 3.40946130e-02f, -6.77161589e-02f, -1.29231870e-01f,
  -3.60794030e-02f, 4.80269156e-02f, -6.83473870e-02f, -1.52856512e-02f, -3.65030430e-02f, -8.98200125e-02f, -9.18221846e-02f, -7.75957629e-02f, -1.19649425e-01f, -9.19073522e-02f,
  1.30340755e-01f, -8.05153251e-02f, 1.42064855e-01f, 6.75913319e-02f, 1.08505256e-01f, 1.01502039e-01f, 1.33149669e-01f, 6.89236820e-02f, 4.81926948e-02f, -8.38025212e-02f,
  -3.13358307e-02f, 9.41064507e-02f, 1.23147048e-01f, 6.97662495e-03f, 2.52560377e-02f, 1.45949155e-01f, 2.60741673e-02f, -6.63750172e-02f, 9.63865295e-02f, 9.69705805e-02f,
  -5.46644395e-03f, 2.58953217e-02f, 5.11568189e-02f, -1.26182809e-02f, -6.00478500e-02f, -4.35237065e-02f, -2.07236949e-02f, 1.22769825e-01f, -6.20654561e-02f, 6.86111208e-03f,
  -3.14932950e-02f, -2.46954318e-02f, -3.52986865e-02f, 9.57463235e-02f, 9.06556696e-02f, 6.48121238e-02f, -1.47691863e-02f, 3.78911123e-02f, 1.00953832e-01f, -1.53306946e-02f,
  7.06650764e-02f, 4.07339521e-02f, 4.78726346e-03f, -6.83042929e-02f, -7.23301247e-02f, 1.07319683e-01f, -2.08704099e-01f, 6.26018196e-02f, -6.33684080e-03f, 8.38957876e-02f,
  -2.11326871e-02f, -1.34302169e-01f, -4.96217422e-02f, 5.19110523e-02f, -8.27537253e-02f, -1.49200693e-01f, -9.66125056e-02f, 1.03296533e-01f, -6.98885545e-02f, 1.58202916e-01f,
  1.03432283e-01f, -3.52724679e-02f, 1.29735142e-01f, 8.98162201e-02f, 1.39610156e-01f, -1.27679929e-01f, 3.49293952e-03f, -8.98151621e-02f, 4.65161987e-02f, 5.22481725e-02f,
  1.15803167e-01f, 1.42439618e-03f, 1.19928956e-01f, -6.09729439e-02f, 1.47034705e-01f, 2.34083105e-02f, 4.87177074e-02f, -6.76153749e-02f, -9.74465460e-02f, 9.38680172e-02f,
  1.45367235e-01f, 1.26358703e-01f, -2.16415897e-02f, 4.18884084e-02f, 6.76549301e-02f, 4.77484465e-02f, 4.22309060e-03f, 3.00224009e-03f, 8.91605988e-02f, -2.37844251e-02f,
  1.65226966e-01f, -1.22574285e-01f, -7.65869021e-02f, 1.24209234e-02f, 6.61842823e-02f, -1.23802880e-02f, -2.35348381e-02f, -1.05146416e-01f, -7.39376619e-02f, -7.28592798e-02f,
  -8.88840333e-02f, 3.57718542e-02f, 9.89150722e-03f, 6.40145913e-02f, -1.29530400e-01f, 1.15811266e-01f, -1.80714447e-02f, -5.29886223e-02f, -4.41328809e-02f, -1.85120180e-02f,
  -5.48444651e-02f, 1.40249848e-01f, -8.09452757e-02f, 3.64834815e-02f, 1.21188000e-01f, -3.33114192e-02f, -2.89530084e-02f, 4.55078594e-02f, -8.75414386e-02f, 7.42704719e-02f,
  -2.91607585e-02f, -1.01111434e-01f, -1.33640513e-01f, 9.45005640e-02f, -8.84047709e-04f, 4.86124456e-02f, -5.42175137e-02f, -6.65619597e-02f, 8.68343636e-02f, -1.08931951e-01f,
  -8.16368461e-02f, -7.66461343e-02f, 7.06190988e-02f, 1.03402108e-01f, -3.96794081e-02f, 1.01873152e-01f, 3.04906629e-03f, 5.63252009e-02f, 7.86376223e-02f, -1.34648696e-01f,
  -4.58638072e-02f, 6.22440986e-02f, 6.08752556e-02f, 1.56150594e-01f, 9.61762965e-02f, -1.12747669e-01f, -1.24986805e-01f, -6.10488048e-03f, 7.45569989e-02f, -6.98331371e-02f,
  -2.93669496e-02f, 9.56517309e-02f, 1.19988479e-01f, 1.07087500e-01f, -1.31127527e-02f, 1.07564762e-01f, 7.56660476e-02f, -1.05331190e-01f, -1.69078074e-03f, 5.31784929e-02f,
  1.57532431e-02f, 1.48295999e-01f, 2.32578628e-02f, 4.14625247e-05f, 9.83671006e-03f, -1.28853023e-02f, 1.58846632e-01f, 8.75915214e-02f, -6.17479160e-02f, 1.11537594e-02f,
  1.43032715e-01f, 9.55776428e-04f, 9.97761115e-02f, 7.63907703e-03f, 6.40211627e-02f, 1.32953152e-01f, 2.77691148e-02f, -6.09004870e-03f, 1.47453904e-01f, 1.03248106e-02f,
  -5.08724153e-02f, 3.19852941e-02f, 8.74612480e-02f, 1.71758458e-01f, -1.01087531e-02f, 1.57846004e-01f, 3.33052017e-02f, -9.94618088e-02f, 1.05877236e-01f, 1.51560768e-01f,
  -1.19697668e-01f, 1.54786706e-01f, -1.49719805e-01f, -5.63816987e-02f, -3.95054184e-02f, 1.33879006e-01f, -1.84230097e-02f, 9.74393636e-02f, -1.05632715e-01f, 6.22703545e-02f,
  9.29233581e-02f, -4.31051478e-02f, -9.81847174e-04f, 1.20153781e-02f, -2.01327562e-01f, -5.35209551e-02f, 8.49471614e-02f, -1.19755737e-01f, -9.43474919e-02f, 6.01992337e-03f,
  -8.86720978e-03f, -8.04887861e-02f, 4.65154350e-02f, -2.42279246e-02f, 1.30136535e-01f, -2.19465364e-02f, 1.04251727e-01f, -3.74774225e-02f, 5.31833954e-02f, -6.91755116e-02f,
  -1.33800507e-01f, 6.24624006e-02f, -4.86065187e-02f, 5.94149530e-03f, -9.35087502e-02f, 1.78789925e-02f, -2.99604274e-02f, -8.10954794e-02f, -5.49522117e-02f, -2.40919683e-02f,
  1.44870028e-01f, -8.25559795e-02f, -8.67374241e-03f, -1.84465235e-03f, 5.27758449e-02f, 6.92527890e-02f, -1.21569401e-02f, -5.19504352e-03f, -7.98738524e-02f, -9.25612636e-03f,
  6.70157522e-02f, 1.33752182e-01f, 4.98993285e-02f, -5.44785485e-02f, -8.48285332e-02f, -1.58747018e-03f, 1.07083626e-01f, 4.81153019e-02f, -6.41361475e-02f, -3.31730694e-02f,
  1.14395685e-01f, -6.32465184e-02f, 5.26683666e-02f, -3.67638357e-02f, -8.47017765e-03f, 1.86254084e-01f, 5.39809205e-02f, 1.02306269e-01f, -1.43979922e-01f, 1.55551150e-01f,
  1.34965293e-02f, -2.82344930e-02f, -1.39249101e-01f, -1.13978140e-01f, 1.73785180e-01f, -1.60622206e-02f, 8.26548487e-02f, -1.61414985e-02f, -1.27986580e-01f, -3.64298001e-02f,
  1.33665532e-01f, -7.32204020e-02f, -1.10141896e-01f, 2.67611705e-02f, -1.62445977e-02f, 5.45868054e-02f, 5.41550294e-02f, 2.72998847e-02f, -4.46909964e-02f, -8.57375115e-02f,
  1.20902359e-01f, -8.62756446e-02f, 4.06734571e-02f, -1.18158385e-02f, -8.72672200e-02f, -8.09732676e-02f, -5.46940863e-02f, -2.45995782e-02f, 4.73732240e-02f, 1.65211439e-01f,
  -5.08783571e-02f, -7.22281262e-02f, -1.85654890e-02f, -6.05848804e-02f, 2.02872488e-03f, 8.84352624e-02f, 1.22756183e-01f, 1.37565508e-01f, -4.01714928e-02f, 1.51314825e-01f,
  -6.88341185e-02f, 1.28918603e-01f, 1.18859880e-01f, 3.60386632e-02f, -1.22221351e-01f, 4.69679944e-02f, 1.22653462e-01f, 6.11986816e-02f, 1.20960362e-01f, 8.09117854e-02f,
  -9.73698217e-03f, 1.37149885e-01f, 1.12006292e-01f, -9.02678296e-02f, 1.14193447e-01f, 8.17935914e-02f, 6.41223565e-02f, -8.73294696e-02f, -1.39961511e-01f, -1.02293855e-02f,
  -1.40687183e-01f, 1.22171208e-01f, 4.94119003e-02f, -3.40276547e-02f, 7.31524751e-02f, 9.10323020e-03f, -1.44094778e-02f, 1.05762072e-01f, -9.21904817e-02f, -2.46469468e-01f,
  -1.81101158e-01f, 8.90566781e-02f, 5.71152940e-02f, -4.66299281e-02f, -1.00967675e-01f, 4.57683653e-02f, -2.23672250e-03f, 4.28547934e-02f, -9.39014405e-02f, -6.36674976e-03f,
  -1.30423680e-01f, 6.49804920e-02f, -8.75207037e-02f, -4.12332937e-02f, 1.22547388e-01f, -4.90991399e-03f, -7.27351084e-02f, -2.50471216e-02f, 4.54728007e-02f, 7.52182351e-03f,
  7.65850544e-02f, 1.89071745e-01f, -1.08034410e-01f, -1.13970309e-01f, -1.38494834e-01f, -7.56167695e-02f, 7.82873631e-02f, 1.14184223e-01f, -2.46626064e-02f, 3.12479213e-02f,
  -6.62646592e-02f, -1.45159423e-01f, -4.14509699e-02f, -3.57075408e-03f, -4.90126535e-02f, -2.44229641e-02f, -9.09733325e-02f, -5.04532009e-02f, -1.06403887e-01f, -4.46963608e-02f,
  -1.25719637e-01f, -8.75517279e-02f, 3.20032090e-02f, 1.47989672e-02f, -8.45848769e-02f, 8.13012198e-02f, 2.01471001e-02f, -8.87055695e-02f, -1.09672502e-01f, 1.10946372e-01f,
  -1.02656446e-01f, 6.48916960e-02f, 5.72524332e-02f, -8.44898671e-02f, -4.83696908e-02f, 2.42025610e-02f, -2.28691287e-03f, -6.92318156e-02f, 2.56849304e-02f, -1.08286530e-01f,
  -1.21919066e-02f, -1.10944614e-01f, -8.03943947e-02f, -1.57219786e-02f, -8.47532749e-02f, -1.24767683e-01f, 4.96093603e-03f, 7.60107711e-02f, 3.10786460e-02f, 8.63338336e-02f,
  3.87057178e-02f, -1.22660197e-01f, 7.67105306e-03f, -4.17171344e-02f, 7.22448602e-02f, 2.06892248e-02f, -5.71329147e-02f, -1.19950570e-01f, -9.09177735e-02f, 7.59238303e-02f,
  3.24376412e-02f, -1.14481091e-01f, 5.78320362e-02f, 1.19689398e-01f, -6.88262433e-02f, 4.80186343e-02f, 1.94432586e-01f, 4.72663417e-02f, 1.40386596e-01f, 1.21693037e-01f,
  9.92170870e-02f, 5.84052280e-02f, 2.02088013e-01f, 1.06890246e-01f, -1.24000974e-01f, 1.40673742e-01f, 1.95336327e-01f, 3.00429344e-01f, -1.17948679e-02f, 1.79337859e-01f,
  1.36296004e-01f, 2.24721998e-01f, -7.15588173e-03f, 5.52788638e-02f, 1.70269042e-01f, -4.43625562e-02f, 8.58321339e-02f, 1.63074717e-01f, 2.55624443e-01f, 1.86278418e-01f,
  1.16374165e-01f, -1.19531572e-01f, -1.97091885e-02f, 1.24943905e-01f, 3.03917587e-01f, -6.90027401e-02f, -1.84473619e-01f, -2.37137645e-01f, 2.67151892e-01f, -3.00566554e-01f,
  1.82195395e-01f, -2.57770449e-01f, 6.75214231e-02f, 1.71646595e-01f, -2.48016894e-01f, -1.15988314e-01f, -7.55473301e-02f, 2.10637406e-01f, -2.60281805e-02f, -2.81073786e-02f,
  -2.36868128e-01f, 1.42829850e-01f, 9.27682817e-02f, 1.59599602e-01f, 1.65518776e-01f, 1.90911904e-01f, -8.85100011e-03f, -5.65103740e-02f, 8.45846981e-02f, -4.04293649e-02f,
  1.51305944e-01f, 1.75474994e-02f, -5.26659004e-03f, -5.97018301e-02f, -7.51846656e-02f, -1.67778373e-01f, 7.97691420e-02f, -6.04338245e-03f, 3.64380069e-02f, -9.25793350e-02f,
  2.55995721e-01f, 1.59651682e-01f, 2.21018761e-01f, 1.01980679e-01f, 1.76892444e-01f, 9.38276667e-03f, 2.34014615e-01f, 1.14494041e-01f, -1.60751328e-01f, 2.44096205e-01f,
  4.27857898e-02f, 1.63494274e-01f, 5.18363416e-02f, 1.25691816e-01f, -1.99580163e-01f, 5.57177998e-02f, 3.89459617e-02f, 1.89417340e-02f, 4.89692576e-02f, -2.50896752e-01f,
  3.35386135e-02f, 5.31786084e-02f, 2.37722367e-01f, -1.02669233e-02f, 1.27297699e-01f, 1.35356650e-01f, -3.55429649e-02f, 7.71599039e-02f, 2.10551709e-01f, 1.09451041e-01f,
  1.39836267e-01f, 1.96698114e-01f, 1.17708363e-01f, -2.05345914e-01f, 1.65788248e-01f, -1.33653835e-03f, -2.41547093e-01f, 2.92132378e-01f, 6.27967790e-02f, -1.91038445e-01f,
  1.34677395e-01f, 2.51113236e-01f, 7.22637251e-02f, -1.70463458e-01f, -3.10105443e-01f, -1.68822944e-01f, 2.07078934e-01f, 5.47217354e-02f, 1.79048166e-01f, 1.83494911e-01f,
  -1.46192953e-01f, -1.07357301e-01f, 2.26297840e-01f, 1.11191735e-01f, 2.76898921e-01f, -3.33328295e-04f, -1.02497354e-01f, -5.97411469e-02f, 1.08022593e-01f, -6.47658855e-02f,
  6.83147386e-02f, 1.23625748e-01f, -4.27277246e-03f, -3.15916277e-02f, -7.94897676e-02f, 8.35741311e-02f, 1.50052175e-01f, -8.86416361e-02f, 2.91340426e-02f, -6.99745342e-02f,
  5.48037514e-03f, 1.32633492e-01f, 6.37133780e-04f, 1.35404751e-01f, 9.54669937e-02f, 7.45987669e-02f, -2.47266721e-02f, 1.25212863e-01f, -3.59494276e-02f, -1.13457955e-01f,
  9.23529565e-02f, -2.34579854e-02f, -3.89844254e-02f, -1.40040487e-01f, 5.54009974e-02f, -2.94290930e-02f, -1.42242601e-02f, 9.64453910e-03f, -2.25866735e-02f, -3.90658639e-02f,
  -3.58998664e-02f, -8.01633447e-02f, 1.66825533e-01f, -3.08917910e-02f, 1.08706288e-01f, 9.50037390e-02f, 5.70044294e-02f, -1.61596779e-02f, -7.94837922e-02f, 7.69293606e-02f,
  -5.62864691e-02f, 6.60641640e-02f, -5.99952489e-02f, 4.14153077e-02f, 1.41955152e-01f, -3.85512784e-02f, -4.93862256e-02f, 1.40582293e-01f, -9.89508778e-02f, -4.55271527e-02f,
  3.61820534e-02f, -9.19219777e-02f, 3.89117710e-02f, -1.52812786e-02f, 9.72339287e-02f, -5.53035997e-02f, -8.09204504e-02f, -1.10715792e-01f, -2.95434669e-02f, -8.52120593e-02f,
  3.67059372e-02f, -6.95155328e-03f, 2.96005439e-02f, -1.07843973e-01f, 7.50292391e-02f, 7.19227865e-02f, -2.88124289e-02f, -3.83790322e-02f, -3.82825211e-02f, -3.50551754e-02f,
  4.84173074e-02f, -2.54190899e-02f, -1.02753945e-01f, 6.75426424e-02f, -4.69991453e-02f, -8.83128718e-02f, -7.28341788e-02f, 1.27027947e-02f, -1.03115514e-01f, 1.15123503e-01f,
  -3.95274907e-02f, -8.46912060e-03f, -3.17167379e-02f, 8.50225985e-02f, 6.86842725e-02f, -7.36753270e-02f, -7.60807795e-03f, -6.91804513e-02f, -1.13351099e-01f, -1.21480390e-01f,
  9.51598212e-02f, -4.76610996e-02f, 8.04754812e-03f, -1.15326837e-01f, -5.46870045e-02f, -6.04159720e-02f, 7.77877122e-02f, -7.77074993e-02f, 1.19077042e-01f, -7.77777135e-02f,
  -9.41832215e-02f, -8.04448407e-03f, -3.24275643e-02f, 8.63650665e-02f, 1.17663987e-01f, 1.08369321e-01f, 4.69021797e-02f, -4.73259687e-02f, -6.95954859e-02f, 1.51133016e-01f,
  4.62005995e-02f, 5.28544635e-02f, 1.23437926e-01f, -2.59457491e-02f, -1.22634880e-01f, 9.04578343e-02f, -8.75479430e-02f, 4.23817858e-02f, 6.05182536e-03f, -1.09098546e-01f,
  -9.00975019e-02f, 1.16326839e-01f, 6.19865358e-02f, 1.12581611e-01f, -1.24578595e-01f, 1.56910699e-02f, 8.68370906e-02f, 8.77364632e-03f, -1.15166351e-01f, 9.33804922e-03f,
  -6.15437515e-02f, 8.66286270e-03f, 4.81056981e-02f, 1.61574483e-01f, 1.56687330e-02f, -1.49528027e-01f, 5.60439862e-02f, -4.05933745e-02f, 1.27736926e-01f, -3.79595743e-03f,
  2.50980675e-01f, -1.20269530e-01f, 5.08128889e-02f, -4.46643941e-02f, 2.50115037e-01f, 1.49323512e-02f, 1.18736781e-01f, -1.55474067e-01f, 7.75995702e-02f, 1.50557771e-01f,
  7.07462355e-02f, -3.34882252e-02f, 1.09577060e-01f, 1.76659510e-01f, -2.31630243e-02f, -7.96436295e-02f, 1.65133074e-01f, 1.57881558e-01f, 1.05616502e-01f, -2.72809062e-02f,
  -7.90024102e-02f, 1.43820107e-01f, 8.18596184e-02f, -3.33524160e-02f, -1.89234927e-01f, 7.99703076e-02f, 2.46032223e-01f, -1.83449358e-01f, -1.68935388e-01f, 7.76243582e-02f,
  -1.18813619e-01f, -1.28281042e-01f, 1.82311267e-01f, 2.16723144e-01f, 1.14951439e-01f, -5.43315113e-02f, -1.02496333e-02f, -1.72119915e-01f, -9.61075649e-02f, -5.05621247e-02f,
  4.73452099e-02f, -1.57797247e-01f, 4.56213579e-02f, -3.33311632e-02f, 2.07139105e-01f, -1.29405916e-01f, -7.92920403e-03f, 4.32909802e-02f, -4.71078558e-03f, 2.67821532e-02f,
  -5.06552421e-02f, -5.80098964e-02f, -1.04506128e-01f, -5.71440160e-02f, 8.63369554e-02f, 1.06782839e-03f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  5.39786927e-02f, 1.76127404e-01f, -2.55525168e-02f, 3.54094035e-03f, -8.54622275e-02f, 7.36599267e-02f, 1.75538018e-01f, -3.81328771e-03f, -2.12882040e-03f, 7.95553178e-02f,
  1.57005757e-01f, 4.60251868e-02f, -7.72299767e-02f, -8.80980641e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.86229602e-01f, -1.40608057e-01f, 3.62094864e-02f, -2.00166434e-01f, 2.84959506e-02f, -2.15186700e-02f, -3.38564694e-01f, 3.08227818e-03f, -2.44221881e-01f, -1.06177539e-01f,
  -2.50541806e-01f, -3.61812115e-01f, 1.15920402e-01f, -1.53990388e-01f, 1.90678492e-01f, -2.30184302e-01f, -3.27651232e-01f, -1.67136177e-01f, 8.97722095e-02f, -5.25229685e-02f,
  -2.94935912e-01f, 3.26406509e-02f, -1.08648732e-01f, 1.76433831e-01f, 3.65568399e-01f, -6.62169814e-01f, -5.18368557e-02f, -4.19899255e-01f, 5.18000543e-01f, -1.43156111e-01f,
  -2.15040147e-01f, -1.97645202e-01f, -1.83228806e-01f, 1.09975196e-01f, -4.61042613e-01f, -1.45877689e-01f, -2.94285595e-01f, -2.58968294e-01f, 5.87942675e-02f, -2.34917194e-01f,
  -1.86946809e-01f, 8.50550756e-02f, -3.43084067e-01f, -2.42925957e-01f, -1.90924644e-01f, -4.03406233e-01f, -1.06526501e-01f, -3.26493502e-01f, -9.01494920e-03f, -1.84310064e-01f,
  -9.90099013e-02f, 2.89313227e-01f, 1.60173014e-01f, -2.83335783e-02f, -1.85314808e-02f, -2.02805951e-01f, -1.98481321e-01f, 2.71139354e-01f, 1.00338534e-01f, -3.58406037e-01f,
  -3.13747466e-01f, -1.94628254e-01f, -9.46540609e-02f, -2.42062867e-01f, -1.45118952e-01f, -3.71224284e-01f, -1.85198337e-01f, 2.05721691e-01f, 2.94038981e-01f, 2.22191438e-01f,
  -1.40261039e-01f, -2.39141881e-01f, 1.83052476e-02f, -1.80174083e-01f, -2.29691744e-01f, 3.32138449e-01f, -2.48547435e-01f, 7.40700439e-02f, 1.33957490e-02f, -5.78398351e-03f,
  3.88655156e-01f, 2.06904043e-03f, 5.21237962e-02f, -2.75424868e-02f, -9.45856199e-02f, 1.60353184e-02f, -2.71106601e-01f, 2.67094541e-02f, 3.25053260e-02f, -2.85855502e-01f,
  6.31227717e-02f, 2.95819074e-01f, 4.34665143e-01f, 1.88274026e-01f, 3.58835727e-01f, -1.98540121e-01f, 1.06753945e-01f, 4.97336965e-03f, 3.23244900e-01f, 1.84886247e-01f,
  2.02922642e-01f, -1.74279898e-01f, 2.33937111e-02f, -5.97121060e-01f, 9.23425052e-03f, -2.38018125e-01f, -7.94991702e-02f, 2.02324182e-01f, -2.39465296e-01f, 3.58841240e-01f,
  -1.17438756e-01f, 3.19549501e-01f, -1.19216822e-01f, 2.88165927e-01f, -7.76041672e-03f, 3.66955437e-02f, -1.79699939e-02f, 2.13946730e-01f, 8.45665187e-02f, -1.29605934e-01f,
  1.37545252e-02f, 1.78088099e-02f, -9.73092020e-02f, 3.11339051e-01f, 2.10426882e-01f, -1.50855243e-01f, 4.49829884e-02f, -6.53460696e-02f, -1.33916900e-01f, 2.88267136e-01f,
  4.09586549e-01f, 1.05859704e-01f, -2.24507362e-01f, -9.34540853e-02f, 4.32957590e-01f, 1.65342838e-01f, 6.39343441e-01f, 1.90688834e-01f, 1.92143679e-01f, 3.85406390e-02f,
  1.12050153e-01f, 4.05531973e-01f, 4.07064445e-02f, 1.14166126e-01f, 2.29242355e-01f, 1.83050275e-01f, -1.72351196e-01f, 2.85514772e-01f, 1.61327988e-01f, 7.24095199e-03f,
  2.25302294e-01f, -1.41493946e-01f, 1.98179170e-01f, 3.78604352e-01f, 3.46414894e-01f, 8.94597769e-02f, -2.41164461e-01f, -4.71611582e-02f, -3.21473092e-01f, -5.17202578e-02f,
  -1.44499600e-01f, -3.56385224e-02f, 4.37075853e-01f, 3.86727691e-01f, -2.66355090e-02f, -8.61817002e-02f, 1.60336066e-02f, 1.84664056e-01f, -3.16815197e-01f, -1.17083296e-01f,
  7.00160563e-02f, 1.67604849e-01f, -1.79869279e-01f, 4.74171132e-01f, 1.08352348e-01f, 2.96644092e-01f, -9.54687744e-02f, -5.11318147e-01f, -7.79091641e-02f, 1.10303126e-01f,
  7.50278123e-03f, 8.39104354e-02f, -8.96116197e-02f, -1.46388225e-02f, -8.58597737e-03f, 1.71507869e-04f, 1.22562274e-01f, 2.35828161e-02f, 2.63561636e-01f, -5.76452613e-02f,
  -1.46633953e-01f, 3.48624378e-01f, -2.64401942e-01f, 2.96748459e-01f, -4.02781248e-01f, 5.07565439e-01f, 2.83787940e-02f, -2.87924200e-01f, 3.72568011e-01f, 3.08863163e-01f,
  3.59377623e-01f, -3.33280474e-01f, 1.19655408e-01f, 2.62625009e-01f, -9.77016836e-02f, 4.59899530e-02f, -2.83044934e-01f, -7.01790527e-02f, 1.30103827e-01f, 1.21659271e-01f,
  2.32291237e-01f, 1.75479770e-01f, -9.89407301e-02f, -6.21324368e-02f, 3.02169602e-02f, 1.99446559e-01f, -3.12368810e-01f, 2.94055223e-01f, 3.39597881e-01f, -7.02393055e-02f,
  -8.27664584e-02f, -1.77127704e-01f, -1.78468544e-02f, 4.39168811e-02f, 3.16320151e-01f, 2.80249327e-01f, -3.21732044e-01f, 2.40022928e-01f, 1.58601791e-01f, 3.42332482e-01f,
  4.56943393e-01f, 1.96076378e-01f, -2.05074698e-01f, -1.53493941e-01f, 2.34835923e-01f, -4.11830470e-02f, 2.02277794e-01f, -1.72645703e-01f, -2.02305421e-01f, -1.32423088e-01f,
  -1.26716971e-01f, 1.03259226e-03f, -9.04708877e-02f, -9.79764834e-02f, 6.84258947e-03f, -5.25638051e-02f, 6.48851180e-03f, 5.94853498e-02f, 3.81229483e-02f, 3.32270890e-01f,
  5.49337901e-02f, -1.45796379e-02f, -3.26612800e-01f, -1.55471832e-01f, -5.39621115e-02f, -1.82805881e-01f, 4.25708443e-01f, -2.80983031e-01f, -1.87078103e-01f, 3.35445672e-01f,
  -2.42207229e-01f, -3.66912812e-01f, -6.93728402e-02f, 1.35292709e-01f, -9.37715173e-02f, 7.16298819e-02f, -2.86589921e-01f, 4.72618155e-02f, 2.21480876e-01f, -1.60382047e-01f,
  1.28068015e-01f, -2.96174258e-01f, -1.04767412e-01f, 3.41530919e-01f, 8.07511955e-02f, 2.05032676e-01f, 1.64720714e-01f, -9.63417739e-02f, 6.97849393e-02f, -1.10877387e-01f,
  -1.50172412e-01f, 3.76708657e-01f, 4.49527092e-02f, -3.62383127e-01f, 3.11534166e-01f, 3.31055671e-02f, 4.41738814e-02f, -4.64229286e-01f, -2.27891505e-01f, 3.97684097e-01f,
  -5.14031351e-01f, 1.90780967e-01f, -2.77920663e-01f, 1.49782971e-01f, 1.04154713e-01f, 3.61758530e-01f, -1.20262332e-01f, -1.73893735e-01f, -9.64306295e-03f, -2.29236092e-02f,
  -2.80691922e-01f, -3.58588696e-01f, -1.60464004e-01f, -2.98642039e-01f, -2.39760458e-01f, -5.44768870e-01f, 6.27492145e-02f, 1.53442800e-01f, -1.47901177e-01f, -2.80625257e-03f,
  2.41754800e-02f, -4.09162976e-02f, -8.33907649e-02f, 1.26736730e-01f, -5.70672899e-02f, 2.64708966e-01f, -2.76513278e-01f, -1.05514592e-02f, 8.97234306e-03f, -2.47375295e-02f,
  5.88227153e-01f, 1.45661518e-01f, 2.59869009e-01f, 2.15158254e-01f, -9.25535187e-02f, -1.51585177e-01f, 9.33730528e-02f, -2.65596658e-01f, -2.89523512e-01f, 2.94061959e-01f,
  -1.24166682e-01f, 3.94553058e-02f, 7.07544154e-03f, 4.83068042e-02f, -2.82837660e-03f, -2.25515828e-01f, 2.71601975e-02f, 2.51566291e-01f, -3.58266272e-02f, 2.65684277e-01f,
  -1.71643332e-01f, 3.30658667e-02f, -9.89348516e-02f, -1.68532491e-01f, 5.88731587e-01f, -1.68312818e-01f, 2.58970052e-01f, 5.84558621e-02f, -9.88826603e-02f, -2.18494758e-01f,
  -4.10367459e-01f, -3.15400511e-01f, -3.00448716e-01f, 4.41626638e-01f, 1.23374574e-01f, 3.39306265e-01f, 3.49748582e-01f, -2.35645860e-01f, 3.15668464e-01f, 2.98960865e-01f,
  2.94659734e-02f, 1.54396981e-01f, -4.77455445e-02f, -4.00741287e-02f, -4.76367287e-02f, 2.06418335e-01f, -1.60934869e-02f, 2.74072945e-01f, -6.05508909e-02f, 2.97378957e-01f,
  3.95901538e-02f, -1.67611361e-01f, 4.98583503e-02f, -1.72397375e-01f, -2.79977992e-02f, 7.83200189e-02f, -4.24670801e-02f, -2.99389325e-02f, -6.05020523e-02f, 7.09987998e-01f,
  2.08991215e-01f, -3.72895636e-02f, -3.29003446e-02f, -7.52645433e-02f, -1.93306372e-01f, 2.27658778e-01f, 1.81168914e-01f, -2.84251124e-01f, 1.98414996e-01f, 3.40242267e-01f,
  -1.73106238e-01f, 1.74122259e-01f, -3.81722718e-01f, -2.60724723e-01f, 6.87937215e-02f, 1.23704061e-01f, 1.21674336e-01f, -2.14823499e-01f, 1.64960232e-02f, 2.16022819e-01f,
  9.68865305e-02f, -2.04475299e-01f, -5.87309375e-02f, -6.94337338e-02f, 2.59602189e-01f, -8.80680829e-02f, 4.19567674e-01f, 9.73390490e-02f, 2.28040710e-01f, 2.04632521e-01f,
  -4.53781724e-01f, 3.95569950e-01f, -1.85277939e-01f, -1.39314935e-01f, 1.11993000e-01f, 2.96646327e-01f, 4.05190468e-01f, -1.88878253e-01f, 5.59510767e-01f, -2.77907848e-01f,
  2.55914837e-01f, -2.63845176e-03f, -2.21779332e-01f, 1.73739925e-01f, 1.99045897e-01f, 4.28573400e-01f, 1.45572528e-01f, 1.19067095e-01f, 2.57378340e-01f, 3.61279637e-01f,
  1.64455324e-01f, 1.55053213e-01f, 6.15615435e-02f, -5.02475917e-01f, 5.26817814e-02f, -1.30940899e-01f, -7.59626180e-02f, -1.59175694e-01f, -1.24968380e-01f, 1.61742404e-01f,
  1.74310178e-01f, 2.44631153e-02f, 2.04371326e-02f, -3.47667634e-01f, 6.20356947e-02f, -6.27932698e-02f, 6.81248456e-02f, 3.30382079e-01f, -3.22559416e-01f, -4.39626038e-01f,
  1.93095934e-02f, -2.85811573e-01f, 2.60714114e-01f, 2.13752627e-01f, -5.45686036e-02f, -4.09002304e-01f, -1.58936039e-01f, 3.61705176e-03f, 9.32224989e-02f, 3.40394513e-03f,
  -1.46127131e-03f, -9.53252465e-02f, -5.43075204e-02f, -3.86952981e-02f, 1.05046466e-01f, 7.78092816e-03f, 3.10249686e-01f, -2.89823800e-01f, -2.31583547e-02f, 9.94064379e-03f,
  -9.29355472e-02f, -1.40848905e-01f, -2.57493198e-01f, 2.05439523e-01f, -4.29774106e-01f, 1.91540811e-02f, -2.38530830e-01f, 1.24131538e-01f, -2.23612949e-01f, 1.90617219e-01f,
  3.44112426e-01f, -2.87218601e-01f, -3.44756514e-01f, -2.87003994e-01f, -2.82416165e-01f, 3.74787837e-01f, -3.93548757e-01f, 2.60868102e-01f, 5.75020075e-01f, 1.08470947e-01f,
  1.59873381e-01f, -1.27330139e-01f, 3.01642329e-01f, -3.61459106e-01f, 2.03535303e-01f, -4.60245430e-01f, 4.01694149e-01f, -1.66294247e-01f, -3.58371772e-02f, 8.45722109e-02f,
  -6.86495155e-02f, 3.00118122e-02f, -1.70416266e-01f, 2.32273370e-01f, 2.52233267e-01f, 1.69525772e-01f, 7.18655959e-02f, -4.93601471e-01f, -3.50733250e-01f, 8.50848854e-02f,
  -9.29813646e-03f, -1.19333617e-01f, 1.00068845e-01f, 5.14210761e-01f, -2.62625128e-01f, 1.10563517e-01f, 1.91075876e-02f, -1.31582201e-01f, 2.80603021e-01f, -1.30463421e-01f,
  1.27369940e-01f, -1.43395886e-01f, 2.71674484e-01f, -3.25740784e-01f, 3.47567201e-02f, 2.55339593e-01f, -5.52450530e-02f, 1.52614459e-01f, -2.65528262e-01f, 1.09767519e-01f,
  -1.48786947e-01f, 5.52164353e-02f, -3.06205839e-01f, 9.33279544e-02f, -3.23912799e-01f, 9.43555012e-02f, -1.78373128e-01f, -2.46994764e-01f, -2.18950361e-01f, 2.49727651e-01f,
  -2.71751404e-01f, 3.61530513e-01f, 4.09029216e-01f, 2.51069176e-03f, -3.28769416e-01f, 2.71247029e-01f, 1.80086583e-01f, -2.17729043e-02f, 2.40811899e-01f, -7.45002329e-02f,
  -5.80703467e-02f, -1.61732122e-01f, -4.85062739e-03f, 3.66811931e-01f, -4.22881812e-01f, -4.69852313e-02f, 3.09591204e-01f, -4.87960204e-02f, -2.36061104e-02f, -9.48905796e-02f,
  -1.13067716e-01f, 3.39227974e-01f, 2.51109093e-01f, -9.97314528e-02f, 9.32980925e-02f, 2.70636976e-01f, 6.61340952e-02f, 4.20722179e-02f, 4.08661328e-02f, -1.39314532e-01f,
  6.17923103e-02f, -6.72814548e-02f, 5.21915555e-01f, -6.53536841e-02f, 4.52576838e-02f, -1.28382608e-01f, -2.76411951e-01f, 5.09360313e-01f, 3.23977053e-01f, 3.01634911e-02f,
  -3.77335340e-01f, -1.92215949e-01f, 1.94177866e-01f, 4.37082350e-02f, -1.19059697e-01f, 5.50639689e-01f, 3.79562140e-01f, 1.17923982e-01f, 5.16871028e-02f, 2.95184433e-01f,
  -3.00283819e-01f, 1.75788552e-01f, 2.28818417e-01f, -3.80043328e-01f, -1.06925733e-01f, -2.78514270e-02f, 2.76435345e-01f, 4.56968695e-02f, 2.79286891e-01f, 2.63286412e-01f,
  -3.97283703e-01f, -1.06481262e-01f, -8.03501755e-02f, -4.28462267e-01f, -2.95177579e-01f, -9.79659148e-03f, -1.80949882e-01f, 2.62780100e-01f, 4.15603340e-01f, -4.84419078e-01f,
  -2.59271532e-01f, -2.27419928e-01f, 2.40813214e-02f, 1.29579172e-01f, -2.28255503e-02f, 1.16213121e-01f, -1.95487142e-01f, -9.94496420e-02f, 1.51729107e-01f, 2.41698608e-01f,
  8.89775231e-02f, -2.80001581e-01f, -2.07061470e-02f, -2.63194978e-01f, 4.84052151e-02f, 4.83661853e-02f, -4.80591170e-02f, 5.79344481e-02f, 9.58820507e-02f, -9.35927965e-03f,
  6.73753843e-02f, 1.27718046e-01f, -3.34299318e-02f, 7.41067063e-03f, -3.13251279e-02f, -1.17194831e-01f, -4.75274213e-02f, -6.21242300e-02f, 4.92762364e-02f, 3.60403776e-01f,
  -3.72908205e-01f, -1.08425952e-01f, 2.04559952e-01f, -2.69732386e-01f, 6.62921891e-02f, 2.31825367e-01f, -3.38392556e-01f, -3.95542741e-01f, -2.12903649e-01f, 3.07982326e-01f,
  -2.72916466e-01f, 3.05807926e-02f, -1.75256595e-01f, -1.61054686e-01f, -3.03105712e-02f, -5.13092615e-02f, -2.08850980e-01f, -2.92081684e-01f, 6.69943690e-02f, -2.97584563e-01f,
  2.94494867e-01f, 9.34967212e-03f, 6.31962419e-02f, -3.54789913e-01f, -8.32088292e-02f, -2.77054489e-01f, 1.34344682e-01f, 1.36336908e-01f, 2.98517019e-01f, -9.55833346e-02f,
  1.05189547e-01f, 1.08594351e-01f, -2.19868198e-01f, -1.32245347e-01f, 2.65668631e-01f, -1.24407791e-01f, -4.27182108e-01f, -3.12492698e-01f, 2.06049994e-01f, -2.96513170e-01f,
  -1.71762481e-01f, -2.95287967e-01f, -9.67074707e-02f, -3.84070307e-01f, -4.18961458e-02f, 7.78427115e-03f, 5.93275353e-02f, 2.54289210e-01f, -4.70967293e-02f, 4.00445163e-01f,
  -1.08645655e-01f, 2.47712553e-01f, 9.01735798e-02f, 2.66691757e-04f, 9.19248685e-02f, -2.61861891e-01f, -5.59634119e-02f, -2.16141179e-01f, 2.37202153e-01f, -1.17322713e-01f,
  -4.78280783e-01f, -1.29310668e-01f, 1.46401569e-01f, 6.48586033e-03f, 1.52256966e-01f, -2.50832140e-01f, -3.68027568e-01f, -5.24327934e-01f, 1.52741626e-01f, -3.50057818e-02f,
  -4.94523719e-03f, 8.83706287e-02f, 2.57172823e-01f, -1.57471791e-01f, -3.46133560e-02f, -7.48894289e-02f, 1.54534549e-01f, -2.06062332e-01f, 4.25634161e-02f, 7.09603801e-02f,
  -3.35034490e-01f, -5.89024872e-02f, -1.59695998e-01f, -3.31619173e-01f, -1.57889232e-01f, -1.85344830e-01f, -2.18888670e-01f, 9.07500312e-02f, 4.09471184e-01f, 3.44173878e-01f,
  -4.20292169e-01f, 1.11397266e-01f, -1.28098696e-01f, 4.25064713e-01f, 3.04295629e-01f, 2.75614768e-01f, -1.18181787e-01f, -2.86102206e-01f, 5.12671396e-02f, -3.04286659e-01f,
  3.35169882e-01f, -1.43546090e-02f, -1.97968736e-01f, 8.80395994e-02f, 2.32204080e-01f, 1.72197044e-01f, 2.70425141e-01f, -9.09006223e-02f, 4.29090485e-02f, 2.09297568e-01f,
  2.54935771e-01f, 2.15867698e-01f, 2.24253908e-01f, 3.65889072e-01f, 2.29372337e-01f, -9.05665904e-02f, -7.46204853e-02f, 3.73622142e-02f, -5.02350107e-02f, 2.06400678e-01f,
  1.59287140e-01f, -1.44675180e-01f, 7.68866390e-02f, -1.95097066e-02f, 3.96493495e-01f, 1.64838538e-01f, -5.37347235e-02f, -2.16725424e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.81018573e-02f, 4.20114100e-02f, -1.38503611e-01f, 1.51706263e-01f, 7.85281360e-02f, 3.19487927e-03f, -1.03403397e-01f, -5.23603929e-04f, -9.46894884e-02f, -9.92668346e-02f,
  2.48399302e-02f, -3.05265784e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    