/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.60772994e-02f, 1.98738873e-01f, -3.30041000e-03f, 1.40396804e-02f, 1.19938059e-02f, 6.90239593e-02f, -1.31028950e-01f, 2.66594231e-01f, 3.56876582e-01f, 1.86351717e-01f,
  4.76659127e-02f, -2.24727288e-01f, 5.54372296e-02f, 2.13777386e-02f, -2.55873054e-01f, 8.34170356e-02f, 1.27555281e-01f, -1.97614580e-01f, 1.52393490e-01f, 8.81369133e-03f,
  2.22491426e-03f, -9.84336138e-02f, -1.47342592e-01f, -4.15492915e-02f, -6.12455718e-02f, 7.82651976e-02f, -3.60673606e-01f, -2.78595965e-02f, -2.11784527e-01f, 2.39176527e-02f,
  1.01010585e-02f, 1.15690112e-01f, -4.86822277e-02f, -7.69518241e-02f, 2.54942682e-02f, 1.19502969e-01f, -5.81733100e-02f, -1.12390570e-01f, 8.21309462e-02f, -3.16758156e-02f,
  5.27911223e-02f, 5.85737489e-02f, 1.10728033e-01f, -3.17324474e-02f, 2.98495404e-02f, -8.10546204e-02f, -8.90382528e-02f, -3.99270467e-03f, -5.31015396e-02f, 6.79852907e-03f,
  3.74868214e-02f, -7.03798607e-02f, -3.32515873e-02f, -8.96605700e-02f, -4.14985083e-02f, -2.84595042e-02f, -1.90004557e-02f, -7.47544467e-02f, 8.32743645e-02f, 3.51651013e-02f,
  1.24152705e-01f, 1.41042965e-02f, -2.27918345e-02f, 2.05467809e-02f, 1.01893395e-02f, -1.65517200e-02f, 2.44537424e-02f, 1.86472647e-02f, -6.65375441e-02f, -8.07687938e-02f,
  2.72378344e-02f, 9.62036476e-02f, 3.41229700e-02f, 1.74406543e-02f, -5.25604514e-03f, 8.07459801e-02f, -1.02750391e-01f, 3.05434577e-02f, 1.63444728e-01f, -9.44775864e-02f,
  3.50569859e-02f, 1.61927968e-01f, -6.84376284e-02f, 1.15605984e-02f, 1.08756274e-01f, -1.18531603e-02f, -5.40919788e-02f, 5.60522154e-02f, -4.62659784e-02f, -1.67706087e-01f,
  -9.94986389e-03f, 1.12569898e-01f, -2.48526148e-02f, -1.39393821e-01f, -6.77501336e-02f, 8.87080058e-02f, 1.11972071e-01f, -6.14213124e-02f, 3.33822817e-02f, -1.57261509e-02f,
  -4.34337258e-02f, -7.58418888e-02f, 5.26091978e-02f, -3.74650136e-02f, -8.44162330e-03f, -3.90477991e-03f, -1.41307218e-02f, -1.61903292e-01f, -3.53390314e-02f, 9.44851935e-02f,
  -1.32366940e-01f, -1.54080078e-01f, -1.56738441e-02f, -1.24806598e-01f, -1.51876053e-02f, -1.53742447e-01f, 2.32360363e-02f, 1.55321043e-02f, 8.33809096e-03f, 5.48968092e-03f,
  3.14259976e-01f, -2.61378020e-01f, 2.09446028e-01f, -1.58143211e-02f, 1.32686049e-02f, 1.39771223e-01f, 1.90635994e-01f, 4.12618294e-02f, 1.36093438e-01f, -4.09832075e-02f,
  1.65815219e-01f, 8.71628746e-02f, 1.04220897e-01f, 5.91044500e-02f, 1.31392255e-01f, -5.53081147e-02f, 9.05350670e-02f, 1.09610498e-01f, -1.71940461e-01f, -5.38272224e-02f,
  5.67781888e-02f, -8.06159154e-02f, 1.37752414e-01f, -1.97311088e-01f, 1.61372438e-01f, 5.93523234e-02f, 1.55980811e-02f, -3.38391811e-02f, 1.55490509e-03f, -3.71820182e-02f,
  5.49803600e-02f, 3.93920057e-02f, 5.40918894e-02f, 1.07499650e-02f, 1.45668566e-01f, 6.81673959e-02f, 8.66350755e-02f, 9.06521920e-03f, 7.71250799e-02f, -2.69514490e-02f,
  1.60264019e-02f, 1.60016250e-02f, 4.64504920e-02f, 1.17520049e-01f, -8.48259777e-02f, 1.43915182e-02f, -1.44504175e-01f, 1.95907373e-02f, -3.17041166e-02f, -2.22518519e-02f,
  9.35495794e-02f, 5.09998901e-03f, -2.27827169e-02f, 2.04917956e-02f, 2.71628071e-02f, -3.76082025e-02f, 4.49380986e-02f, 7.62452371e-03f, -8.51227716e-02f, -2.60936283e-02f,
  1.02215178e-01f, 1.48278186e-02f, 3.86351719e-02f, -5.04979398e-03f, -1.04212081e-02f, -8.52364674e-02f, -1.16630970e-03f, -5.35705015e-02f, -2.76677404e-02f, -5.53107727e-03f,
  -5.20038307e-02f, 5.11538498e-02f, -2.00855429e-03f, 4.96491641e-02f, 2.11538877e-02f, 7.38574341e-02f, -4.71459888e-02f, 1.68692078e-02f, 4.65836935e-03f, 1.99536961e-02f,
  -2.21938696e-02f, -1.27207428e-01f, -2.54322700e-02f, -9.10246149e-02f, 1.26493275e-02f, 5.79868071e-02f, 3.37854959e-02f, -1.21215932e-01f, -2.13934872e-02f, 5.01532666e-02f,
  -1.28293201e-01f, -1.18032008e-01f, -2.20081322e-02f, -9.20787156e-02f, 6.37026178e-03f, -4.70193140e-02f, 1.75488256e-02f, -3.39526720e-02f, 6.71921521e-02f, 8.52985960e-03f,
  2.26153284e-02f, 5.27296253e-02f, 5.16367704e-02f, 6.69834837e-02f, -8.31715241e-02f, -6.17090836e-02f, -1.00236014e-01f, 1.07358620e-01f, 1.29442010e-02f, -5.40663637e-02f,
  3.81570421e-02f, 3.12079582e-02f, -1.09595060e-02f, 7.19422698e-02f, 6.23963103e-02f, -3.38012725e-03f, 3.58591266e-02f, -9.21653360e-02f, -8.49044174e-02f, 1.32039003e-02f,
  3.86433788e-02f, -1.22234151e-01f, 2.84935087e-01f, -8.07418209e-03f, -2.57299960e-01f, 1.21595420e-01f, 1.25741959e-01f, -1.41469836e-01f, 2.26973057e-01f, -1.13208413e-01f,
  -1.26869872e-01f, 1.53154522e-01f, 7.36575201e-02f, -1.98628277e-01f, 4.36069332e-02f, 1.44952923e-01f, -1.26686156e-01f, -4.95169088e-02f, 1.88283920e-02f, -1.32176623e-01f,
  1.46241114e-01f, -3.30359995e-01f, -1.21464178e-01f, -2.52099812e-01f, -1.40177608e-01f, 6.69984818e-02f, -3.02236915e-01f, 1.60572141e-01f, -1.80451080e-01f, -5.80542609e-02f,
  -1.22093521e-01f, 9.43904649e-03f, -3.15923914e-02f, 9.17960033e-02f, -1.27612874e-01f, 6.81756884e-02f, 6.55918792e-02f, 1.47648836e-02f, 1.13765538e-01f, 5.79065410e-03f,
  -9.78799090e-02f, -9.00592506e-02f, -1.21103704e-01f, 1.38806701e-01f, 1.16370574e-01f, 2.49435585e-02f, -9.38510895e-02f, -4.44326364e-02f, -3.49030122e-02f, 2.99220979e-02f,
  1.73885480e-01f, 3.05815022e-02f, 1.02394916e-01f, -2.36999728e-02f, 8.53020102e-02f, 2.88155563e-02f, 9.29891244e-02f, -9.24421381e-03f, 1.77964978e-02f, -8.86646099e-03f,
  -4.48791916e-03f, 1.77072778e-01f, 9.06203315e-02f, -8.16771090e-02f, -1.72383487e-02f, -1.15265653e-01f, 1.83096886e-01f, -6.89138770e-02f, -9.02004447e-03f, 4.08880785e-02f,
  -1.51360556e-01f, 6.88164011e-02f, 3.61318998e-02f, 1.54632539e-01f, 7.09009692e-02f, 5.25291525e-02f, -4.18812893e-02f, -5.93528617e-03f, 2.50420105e-02f, -7.94847310e-03f,
  1.66898984e-02f, 3.72241959e-02f, -1.39751866e-01f, -2.03832369e-02f, 6.11298420e-02f, 1.61585987e-01f, 1.38301626e-01f, 7.06699938e-02f, -6.14748299e-02f, 8.25821832e-02f,
  -1.34136051e-01f, -1.11588567e-01f, -1.99699271e-02f, -5.59141375e-02f, -1.32313296e-01f, -1.27131313e-01f, 4.04028632e-02f, 6.45092279e-02f, 1.10237166e-01f, 2.57137045e-02f,
  -8.75387490e-02f, -1.45866305e-01f, 1.09483160e-01f, -1.44370720e-02f, 1.11393489e-01f, 5.59139699e-02f, 3.01170219e-02f, -2.26126201e-02f, -7.50252008e-02f, -1.02453806e-01f,
  6.03543012e-04f, -3.82347442e-02f, -5.63945957e-02f, -8.10284242e-02f, -4.60638106e-02f, -3.32117900e-02f, 2.77923811e-02f, 1.03040367e-01f, -1.57103539e-01f, -6.86443150e-02f,
  -2.43086647e-02f, -2.00467885e-01f, -3.32317412e-01f, -3.56184989e-01f, 1.97945163e-01f, 1.15472630e-01f, -3.51055890e-01f, -7.38644153e-02f, -1.96926981e-01f, -7.78505057e-02f,
  -3.55543904e-02f, -1.68328553e-01f, -2.75475919e-01f, -1.70060873e-01f, 4.99696918e-02f, -1.61123067e-01f, 1.72884315e-02f, -5.04358187e-02f, -1.20048322e-01f, -1.43004194e-01f,
  4.91485000e-02f, 5.75163700e-02f, -1.51343465e-01f, 8.20403397e-02f, -1.04038931e-01f, -2.20268350e-02f, 2.29640603e-01f, -1.07571989e-01f, 1.32575557e-01f, -9.43364501e-02f,
  2.32570376e-02f, -5.15479334e-02f, 1.11213766e-01f, -1.73325874e-02f, 7.02237338e-02f, 3.28651518e-02f, -9.21357051e-03f, -1.12665020e-01f, 4.09418605e-02f, 2.31079087e-02f,
  -1.01993851e-01f, 4.53103557e-02f, -1.95621178e-02f, 9.74856988e-02f, 6.38008565e-02f, 9.71043780e-02f, -1.32250577e-01f, 1.02369450e-02f, 1.51827047e-02f, 3.98960449e-02f,
  -7.10356832e-02f, -2.94553339e-02f, 9.08987131e-03f, -1.49204517e-02f, -1.24538131e-02f, -3.39031629e-02f, -1.48924422e-02f, -9.85487849e-02f, 4.56890091e-02f, 6.36225790e-02f,
  1.57111913e-01f, 8.53220150e-02f, -1.93622056e-02f, -7.18208328e-02f, -5.70629984e-02f, -9.48292091e-02f, 4.34057154e-02f, -4.08663191e-02f, -6.89395964e-02f, 9.42734554e-02f,
  -8.80235210e-02f, 1.16666900e-02f, -2.47101020e-02f, -3.87711450e-02f, 1.05433492e-02f, 1.62794232e-01f, 2.64527220e-02f, -7.41706714e-02f, -6.93482310e-02f, 5.79460263e-02f,
  -7.11364076e-02f, -4.67344234e-03f, -5.32026812e-02f, -4.15964648e-02f, -3.22915874e-02f, -4.39943396e-04f, 8.89523104e-02f, 2.30928939e-02f, 1.74327791e-02f, -2.84779742e-02f,
  2.21193898e-02f, 4.95200220e-04f, 3.96988876e-02f, 5.44599779e-02f, -5.90091944e-02f, -4.26849797e-02f, -5.78697771e-02f, -3.45415808e-02f, 5.30645475e-02f, 1.28502950e-01f,
  2.49361452e-02f, -1.63813327e-02f, 4.43018861e-02f, 1.16570391e-01f, 5.68187200e-02f, 6.72109276e-02f, -6.46836832e-02f, 1.25102624e-01f, 1.25275711e-02f, 1.39196977e-01f,
  2.74485238e-02f, -1.30400047e-01f, 3.74617651e-02f, 2.07884070e-02f, 1.07185788e-01f, -1.42416004e-02f, 1.14859380e-01f, -6.88448548e-02f, -2.38321815e-02f, 4.61815000e-02f,
  -1.64192945e-01f, 3.14069539e-01f, -1.45551577e-01f, -8.16995427e-02f, -2.91252341e-02f, 2.35528409e-01f, 1.49907574e-01f, 1.37136638e-01f, 1.72811344e-01f, 3.16781670e-01f,
  7.00422330e-03f, 1.93846270e-01f, 1.11626022e-01f, 1.94464773e-02f, -1.12935252e-01f, -1.14906924e-02f, -1.24528557e-01f, 1.69723779e-02f, -2.12227702e-01f, -6.04582876e-02f,
  -2.70250827e-01f, -1.28288820e-01f, -2.69196153e-01f, -3.39624919e-02f, -2.08016127e-01f, -1.58614054e-01f, -8.51899087e-02f, 7.17568249e-02f, 5.09924851e-02f, 9.97817963e-02f,
  -6.95420951e-02f, -9.38672721e-02f, -9.16693807e-02f, -4.47600782e-02f, -1.19441621e-01f, -7.73685798e-02f, -1.11014731e-01f, 4.38450612e-02f, -1.29322752e-01f, 5.60771748e-02f,
  9.49219316e-02f, -7.24117234e-02f, 3.39604798e-04f, 3.09290327e-02f, 9.41636041e-02f, -6.99924082e-02f, -2.80304328e-02f, 5.63114956e-02f, 2.49747764e-02f, -6.23877905e-02f,
  -2.32739169e-02f, -2.89099012e-02f, -1.12705352e-02f, 1.19535467e-02f, -1.40673481e-02f, 4.20744577e-03f, -2.08918713e-02f, 5.33567369e-02f, -2.42362916e-02f, -4.30120565e-02f,
  9.58232284e-02f, -1.13101184e-01f, -5.84924407e-02f, -7.46484920e-02f, -9.40442830e-02f, -2.64953058e-02f, 2.53075697e-02f, -1.16157427e-01f, -8.75581950e-02f, -2.21668463e-03f,
  -1.22290356e-02f, -5.80166169e-02f, -4.02883328e-02f, -6.43160269e-02f, -3.82949710e-02f, 2.07345337e-02f, 1.02609634e-01f, -7.76370661e-03f, -7.86891058e-02f, -1.59128848e-02f,
  -4.11783857e-03f, -2.41239518e-02f, 5.17520607e-02f, 2.32290011e-02f, 8.53636861e-02f, -3.91475596e-02f, -8.55854973e-02f, 4.91474345e-02f, -4.63908836e-02f, -8.03164765e-02f,
  1.80818975e-01f, 1.11694321e-01f, -4.14067060e-02f, 4.51990925e-02f, 4.58956696e-02f, -6.44634813e-02f, -1.61917247e-02f, -5.61547503e-02f, 7.51901418e-02f, 5.75942779e-03f,
  -5.45565672e-02f, -3.71125005e-02f, 4.92539667e-02f, -1.10051800e-02f, 1.09041736e-01f, 1.98766179e-02f, 7.46811694e-03f, 9.46386978e-02f, 5.39279394e-02f, 1.45946920e-01f,
  -2.92101875e-02f, 4.30481732e-02f, -4.15237620e-02f, -1.01652585e-01f, -1.11068618e-02f, -3.29917148e-02f, 7.08161443e-02f, 1.60801530e-01f, -8.63015205e-02f, -4.45785113e-02f,
  -5.03553599e-02f, 2.97900345e-02f, -1.27476469e-01f, 1.28637493e-01f, 1.64326951e-01f, -1.37277171e-01f, -1.56167850e-01f, 2.12415293e-01f, -5.51361740e-02f, 7.91231841e-02f,
  1.10455103e-01f, -3.23511302e-01f, -8.36804882e-02f, 1.05730206e-01f, -3.03314269e-01f, -2.62605578e-01f, -7.14444220e-02f, -1.78682074e-01f, -1.26130536e-01f, 2.51456708e-01f,
  -1.34101519e-02f, 3.44119698e-01f, -8.04981310e-03f, 3.41413170e-01f, 1.51218832e-01f, -8.58936906e-02f, 2.96989769e-01f, -4.82582338e-02f, 1.85274944e-01f, -1.02308452e-01f,
  8.65153745e-02f, 6.80841580e-02f, 8.84670094e-02f, -2.50394177e-02f, 1.25697613e-01f, 3.44860144e-02f, -5.91776147e-02f, -1.29815817e-01f, -4.30666246e-02f, 5.33878133e-02f,
  -9.13126767e-02f, -6.68907762e-02f, -9.91105917e-04f, 6.67861477e-02f, 5.19937314e-02f, -4.31784317e-02f, -1.07686751e-01f, 5.66421263e-03f, 4.60886844e-02f, -6.38573691e-02f,
  -4.43023816e-02f, -9.22164097e-02f, 9.62686762e-02f, -3.69450077e-02f, 4.89520691e-02f, -1.15564615e-01f, 1.53355282e-02f, -1.74459055e-01f, -2.72862520e-03f, -3.66992839e-02f,
  -2.38114856e-02f, 8.78130347e-02f, 6.30583242e-02f, 6.01641685e-02f, 6.54444797e-03f, -1.12126432e-02f, 3.07091810e-02f, -7.51596093e-02f, -7.56892515e-03f, 8.00753012e-02f,
  3.18516418e-02f, 3.89291942e-02f, -4.10191491e-02f, -9.74634737e-02f, -1.74161028e-02f, 2.62111984e-02f, -5.04745729e-02f, -1.24768950e-01f, -7.34211132e-02f, -2.67965999e-02f,
  3.48372161e-02f, -5.52919917e-02f, 7.84418508e-02f, -5.53357899e-02f, -5.13449199e-02f, 8.06297176e-03f, 1.37843236e-01f, 4.07445133e-02f, -4.98395637e-02f, 3.46741490e-02f,
  8.10708925e-02f, 1.51514232e-01f, 1.70583874e-02f, 7.84706790e-03f, 3.49691659e-02f, 2.34315209e-02f, -1.98213924e-02f, 3.82797979e-02f, -3.58704627e-02f, 1.36919886e-01f,
  -1.00244852e-02f, 1.12298951e-01f, 4.27173264e-02f, 8.83727521e-02f, 4.87554967e-02f, 4.61115055e-02f, -1.08197354e-01f, 7.25655779e-02f, 5.93370572e-02f, 3.52588370e-02f,
  1.52348071e-01f, -5.20337047e-03f, 4.17513922e-02f, 7.55910650e-02f, 1.21301457e-01f, -1.01135164e-01f, 8.62279609e-02f, -6.96018636e-02f, -5.88562973e-02f, -4.39449809e-02f,
  3.88171881e-01f, -1.63418818e-02f, 8.32799673e-02f, 1.87907606e-01f, 2.26416156e-01f, 2.66241401e-01f, 2.59974748e-01f, 1.31572187e-01f, 1.22616328e-01f, -1.05500281e-01f,
  2.11817861e-01f, -2.41988096e-02f, -4.65763398e-02f, 9.91320983e-03f, 3.20572436e-01f, -4.42662872e-02f, 6.22686930e-03f, -1.90634560e-03f, -1.57764237e-02f, 1.74848139e-01f,
  1.07185654e-02f, -2.92129703e-02f, 3.98819521e-02f, -1.45341069e-01f, -1.74052119e-02f, -1.79690108e-01f, 8.82373005e-03f, 6.78688735e-02f, 2.03001518e-02f, 7.78189003e-02f,
  3.15237157e-02f, -1.17092788e-01f, -2.13042855e-01f, -1.60234928e-01f, -1.15976036e-02f, -1.18464544e-01f, -1.24065571e-01f, -5.32732345e-02f, -2.69389935e-02f, 3.70313898e-02f,
  -1.30316773e-02f, -5.44956475e-02f, -8.95131230e-02f, -9.84449238e-02f, 7.98644200e-02f, -5.89900650e-02f, -6.80206418e-02f, 8.78558028e-03f, -7.30074644e-02f, 1.01763539e-01f,
  2.08042171e-02f, 4.06632237e-02f, 4.79052737e-02f, 1.93843339e-02f, 7.64943808e-02f, 5.06819524e-02f, -1.32546306e-01f, 4.72939163e-02f, 2.10226588e-02f, 1.05750784e-01f,
  5.47498353e-02f, -1.79094765e-02f, -5.38532063e-02f, -7.60985166e-02f, -5.24175242e-02f, -8.16054493e-02f, -2.66843494e-02f, -1.29310980e-01f, -2.88315415e-02f, -1.25084566e-02f,
  2.68071666e-02f, 1.67803541e-02f, -7.34535828e-02f, -6.93171471e-02f, -1.65642630e-02f, -5.72314188e-02f, 1.31664813e-01f, 5.24564125e-02f, -6.32939860e-02f, 5.33577390e-02f,
  -1.10838041e-01f, 5.56748286e-02f, 1.01737320e-01f, 1.80397462e-02f, 1.75593258e-03f, 1.18450150e-02f, -4.15466242e-02f, 6.14421330e-02f, 4.52605784e-02f, 5.36083505e-02f,
  1.56701550e-01f, 4.57546078e-02f, -1.45080993e-02f, -1.01790419e-02f, -5.67656904e-02f, -6.92807734e-02f, -1.59158647e-01f, 1.29581278e-03f, 1.77015010e-02f, 1.40695885e-01f,
  -7.03610927e-02f, -8.91937762e-02f, -1.49889318e-02f, -3.09406910e-02f, 1.14460312e-01f, 1.02832533e-01f, 4.75306809e-03f, 6.56491239e-03f, 3.87262292e-02f, 1.31836027e-01f,
  8.40217173e-02f, 5.52855097e-02f, 7.15296017e-03f, -7.92573914e-02f, 1.38603551e-02f, 1.52532449e-02f, -2.85813473e-02f, 9.13825724e-03f, 7.05016181e-02f, -5.13121895e-02f,
  -4.65346426e-01f, 6.13118410e-02f, -2.69934356e-01f, -1.74694970e-01f, 3.43370140e-02f, -1.45547003e-01f, -1.21777870e-01f, 6.84745610e-02f, -2.84926951e-01f, 2.77180791e-01f,
  2.74368048e-01f, -1.09811589e-01f, -2.20790952e-02f, 3.39136422e-01f, -1.11268863e-01f, 7.29316333e-03f, 2.36201622e-02f, 8.43470320e-02f, -1.52786255e-01f, -1.90591425e-01f,
  -7.78115988e-02f, 1.67115360e-01f, -7.60673312e-03f, 1.94578141e-01f, 3.51580717e-02f, 6.02715127e-02f, 3.53188634e-01f, 1.28515571e-01f, 2.48877749e-01f, 1.88222528e-01f,
  -5.93455462e-03f, 2.71814540e-02f, -3.81667316e-02f, -1.16382279e-01f, -7.32618049e-02f, -5.13790883e-02f, 1.60277009e-01f, 3.11003961e-02f, -1.19147308e-01f, -2.03751717e-02f,
  3.39206010e-02f, 1.02177247e-01f, 1.19888589e-01f, -5.03458418e-02f, 5.35472482e-03f, -4.97142822e-02f, 3.68692242e-02f, -2.22773105e-02f, -5.95049113e-02f, 1.86848473e-02f,
  -6.41194880e-02f, 1.07982367e-01f, -7.35581443e-02f, 2.07857952e-01f, -3.14552709e-02f, 4.49354015e-02f, 5.98479211e-02f, 1.35896996e-01f, 6.23920076e-02f, -5.91323972e-02f,
  6.19147196e-02f, -1.00314051e-01f, -1.12244617e-02f, -1.64948329e-02f, -3.81337702e-02f, 3.63334157e-02f, -4.85411622e-02f, 4.30633798e-02f, -4.24550883e-02f, -3.92511114e-02f,
  -1.58340130e-02f, -9.23061185e-03f, -4.93873060e-02f, -8.04947689e-02f, -4.82066460e-02f, 8.15614164e-02f, -4.99649048e-02f, 4.78334203e-02f, 6.52722735e-03f, -1.74244773e-02f,
  -9.84238982e-02f, -4.34537157e-02f, -1.67857483e-01f, -3.14580509e-03f, -2.16772640e-03f, -5.33966646e-02f, 7.70391598e-02f, -1.51875481e-01f, 2.20934972e-02f, -1.07398346e-01f,
  -4.00184616e-02f, 2.03704759e-02f, -9.57435071e-02f, -1.81008633e-02f, -2.23929994e-03f, 6.00404218e-02f, -5.22279404e-02f, -1.26699451e-02f, 1.58816390e-02f, 2.04042681e-02f,
  1.56800106e-01f, 1.53890783e-02f, 7.10788593e-02f, 1.05173253e-01f, -1.59897320e-02f, -1.89815406e-02f, -3.54197063e-02f, -1.18051730e-02f, 1.58288740e-02f, 1.38671160e-01f,
  8.28336850e-02f, -1.03144711e-02f, -4.08297740e-02f, 1.97359622e-01f, 4.09527831e-02f, 9.66565832e-02f, 1.46603100e-02f, 9.22230035e-02f, 4.03617062e-02f, 4.38754484e-02f,
  -2.37240672e-01f, -1.39571342e-03f, -1.58881336e-01f, -2.16230452e-01f, 1.28051192e-01f, 1.52904645e-01f, 1.30329981e-01f, 4.11381498e-02f, -2.87277605e-02f, 1.97467268e-01f,
  1.53446600e-01f, -2.18006209e-01f, 2.69178271e-01f, -5.47237210e-02f, -4.02335674e-01f, 4.09423672e-02f, -3.45780015e-01f, -3.53728570e-02f, -1.01002023e-01f, -9.91223007e-02f,
  3.13231610e-02f, -8.60641524e-02f, -1.90791994e-01f, 4.18436863e-02f, 8.29541609e-02f, 1.06951417e-02f, -3.27719674e-02f, 1.08832590e-01f, -1.38949022e-01f, -8.78992230e-02f,
  -4.41096053e-02f, 1.01112146e-02f, 3.48430313e-02f, -5.54982126e-02f, 3.13586071e-02f, 1.54408440e-01f, -2.48662606e-02f, -6.67173862e-02f, -5.67405336e-02f, 5.23558334e-02f,
  5.56063950e-02f, -6.91376179e-02f, -8.24920833e-02f, 2.34085992e-02f, -7.92075135e-03f, -1.38856515e-01f, -9.83778089e-02f, -1.20400842e-02f, -1.13735229e-01f, -2.61332020e-02f,
  -7.66786113e-02f, -3.81317101e-02f, -5.42944744e-02f, -7.11630732e-02f, -1.31748378e-01f, -1.01341046e-01f, -6.48415415e-03f, -8.43400359e-02f, -1.12534784e-01f, -9.28373188e-02f,
  2.36480702e-02f, 1.13033153e-01f, 3.96927744e-02f, 7.98549429e-02f, -2.50649713e-02f, 2.87376549e-02f, 1.27265519e-02f, 3.97881912e-03f, -3.97490896e-02f, 8.35201591e-02f,
  3.55776288e-02f, 3.13309804e-02f, -8.28555301e-02f, 5.14397733e-02f, 8.88546482e-02f, 5.36280759e-02f, -6.95123337e-03f, 9.32884440e-02f, -3.90756652e-02f, 4.18749861e-02f,
  2.70123947e-02f, -6.75948784e-02f, -3.78958993e-02f, 7.66915306e-02f, -6.54260591e-02f, -2.57785488e-02f, -8.83758534e-03f, -1.29769623e-01f, -3.28013524e-02f, 9.95956808e-02f,
  -1.72025487e-02f, 1.06697138e-02f, 8.57900232e-02f, -6.30173609e-02f, -3.98803167e-02f, 1.81389824e-02f, -1.07109562e-01f, -8.63392949e-02f, 6.70597749e-03f, 1.11405514e-01f,
  5.40802926e-02f, 1.01818100e-01f, 4.18811142e-02f, 8.88151005e-02f, -3.14724781e-02f, -7.95895532e-02f, 9.21509811e-04f, -3.02772801e-02f, -9.44867060e-02f, 2.95567252e-02f,
  1.38959428e-02f, 1.19187258e-01f, -1.16356142e-01f, 1.09476410e-01f, 1.58488490e-02f, -4.62679304e-02f, 1.71042308e-02f, 5.25223184e-03f, -2.67631542e-02f, -8.21280256e-02f,
  -5.36777914e-01f, 2.21156418e-01f, 3.38459909e-02f, -2.55922467e-01f, 8.38261005e-03f, 1.39343143e-02f, -2.90190969e-02f, -3.30175972e-03f, -2.20634967e-01f, 1.64633647e-01f,
  -8.81180819e-03f, 1.09331338e-02f, 8.76000971e-02f, 1.17065925e-02f, -3.05016875e-01f, -6.71728030e-02f, -3.04142386e-01f, -1.55611075e-02f, -8.97699669e-02f, 7.91026838e-03f,
  -1.17428429e-01f, -1.10649943e-01f, 8.07993338e-02f, 1.61431059e-01f, 1.03884377e-01f, 1.42722763e-02f, 7.89577514e-02f, 3.12254220e-01f, -3.28160301e-02f, 1.32642269e-01f,
  3.16017941e-02f, 2.81819794e-03f, 5.53539135e-02f, 2.89051346e-02f, 2.49981284e-02f, 4.38085720e-02f, 3.42846178e-02f, 7.34976977e-02f, -2.72182375e-02f, 3.67118455e-02f,
  8.53843763e-02f, -1.54894680e-01f, -7.22337216e-02f, -7.68585280e-02f, -5.16221896e-02f, -1.68110859e-02f, 8.52314234e-02f, -2.28540152e-02f, 9.60478932e-02f, -9.35166478e-02f,
  2.73270439e-03f, -3.73007506e-02f, -1.14974238e-01f, -2.51110513e-02f, -3.10528800e-02f, -2.10556667e-02f, 9.36098956e-03f, 8.20077136e-02f, -6.83778152e-02f, -7.37332925e-02f,
  -6.57256618e-02f, -8.06951970e-02f, -1.06757373e-01f, 5.69950603e-02f, -5.74999489e-03f, 1.19610587e-02f, -1.41348287e-01f, 2.26963889e-02f, -2.28564930e-03f, -1.69806462e-02f,
  -1.52709763e-02f, -1.11108653e-01f, 4.38329503e-02f, -7.50551894e-02f, -1.43128365e-01f, -3.73094864e-02f, 3.84495854e-02f, 1.32647768e-01f, -1.05008883e-02f, 5.72184324e-02f,
  3.02578881e-02f, 8.19959119e-02f, 5.82580939e-02f, 9.12784562e-02f, -5.89989766e-04f, -1.05724953e-01f, -2.78708879e-02f, 7.47962762e-03f, 8.35937634e-02f, -3.04375589e-02f,
  4.76815850e-02f, 9.71495658e-02f, 4.83125374e-02f, 8.09166729e-02f, 1.15826756e-01f, 4.72608656e-02f, -1.17081240e-01f, -2.31906381e-02f, -1.61841474e-02f, 8.44717324e-02f,
  3.63820493e-02f, -3.77754644e-02f, -3.15147489e-02f, -1.74159221e-02f, -2.03106273e-02f, -1.46912001e-02f, 7.36911446e-02f, -2.91323382e-02f, 3.17926630e-02f, 3.39393318e-02f,
  4.42195125e-02f, 3.24821435e-02f, -1.32093847e-01f, 4.51524109e-02f, -1.10213920e-01f, 1.44884273e-01f, 2.63525732e-02f, 2.13227421e-02f, 5.20150028e-02f, 1.13389781e-03f,
  4.24407944e-02f, 2.44859114e-01f, -8.50210562e-02f, 3.05504769e-01f, -4.71824370e-02f, 5.58235168e-01f, 4.77542728e-01f, 4.20879014e-02f, 7.56715983e-02f, 2.84756780e-01f,
  1.33771792e-01f, 1.37253836e-01f, -2.09562648e-02f, 4.14338917e-01f, 1.80796146e-01f, 1.34182647e-01f, 3.26078117e-01f, 2.09009558e-01f, -6.20346293e-02f, 5.13778254e-02f,
  -4.35369201e-02f, 2.50958979e-01f, 1.58828199e-01f, -6.54062107e-02f, 6.02862574e-02f, -2.49011889e-01f, -1.45195872e-01f, -2.01786384e-01f, 1.75417781e-01f, -5.98534883e-04f,
  -6.76094517e-02f, -7.75191337e-02f, -5.18177561e-02f, -1.03150755e-01f, -1.72725786e-02f, -8.91315341e-02f, -8.17507058e-02f, 4.23772559e-02f, -1.03338562e-01f, 5.05166389e-02f,
  5.64828031e-02f, 2.47136671e-02f, 1.24772474e-01f, 8.83789442e-04f, -6.61012530e-02f, -4.01315875e-02f, -9.42167267e-02f, 3.98914106e-02f, 6.08799346e-02f, 7.60430098e-02f,
  1.18499398e-01f, 8.55152309e-02f, 2.85145137e-02f, 9.89408791e-03f, 5.63794151e-02f, 2.64289007e-02f, 9.36843604e-02f, 3.39552574e-02f, 1.07347757e-01f, 1.16054967e-01f,
  1.00704484e-01f, -6.65241778e-02f, -5.88855371e-02f, -9.10773501e-02f, -5.11354022e-02f, -2.07201555e-01f, -9.46072638e-02f, -1.02948867e-01f, -2.07112670e-01f, -8.84462241e-03f,
  -8.25300887e-02f, -6.29643202e-02f, -2.22708024e-02f, -3.29215713e-02f, -6.93037137e-02f, -5.57915904e-02f, -3.09060831e-02f, -7.76217505e-03f, -1.45523520e-02f, -3.71325798e-02f,
  -1.39361441e-01f, -2.02241000e-02f, -1.26374653e-02f, -3.80092598e-02f, 2.68963780e-02f, -4.13151942e-02f, -1.76621508e-02f, 2.12935172e-02f, -5.59622683e-02f, -4.18414660e-02f,
  8.04198310e-02f, 6.93424940e-02f, 2.08249856e-02f, -5.66777848e-02f, -7.35807791e-02f, -1.87759772e-02f, 1.30491450e-01f, 2.39467602e-02f, -1.28404915e-01f, -7.44916545e-03f,
  -5.01545779e-02f, -3.28882001e-02f, -2.04032272e-01f, -2.78355740e-02f, 3.09528150e-02f, 1.24156997e-01f, -6.44832700e-02f, -8.12198222e-02f, 2.19982378e-02f, 6.94691539e-02f,
  4.85247411e-02f, 5.99977560e-02f, 1.69065949e-02f, -3.67498547e-02f, -3.22982483e-03f, 4.08453457e-02f, 8.79141241e-02f, -3.57244816e-03f, 9.34457779e-03f, 1.18254041e-02f,
  4.82088000e-01f, 1.12417571e-01f, 1.90079778e-01f, 2.87257582e-01f, -9.39512625e-02f, -1.41517594e-01f, -1.50752701e-02f, -3.04675265e-03f, 2.18555182e-01f, -8.01147372e-02f,
  -1.76425382e-01f, 3.40992063e-01f, -2.10286811e-01f, 1.35082975e-01f, 2.11326033e-01f, -1.07470237e-01f, 2.70298839e-01f, 8.46514702e-02f, 6.66700006e-02f, 1.90962479e-01f,
  7.29696676e-02f, 6.03614785e-02f, 1.06915226e-02f, -1.20658748e-01f, 2.02114105e-01f, 6.36550188e-02f, 7.93931484e-02f, -1.28164098e-01f, 4.86615598e-02f, -3.99546586e-02f,
  -1.56344518e-01f, -2.57608835e-02f, 2.02779612e-03f, -2.38609724e-02f, 7.10608065e-02f, -4.59391661e-02f, -4.78124097e-02f, -9.84738860e-03f, 4.30066288e-02f, 8.37367475e-02f,
  -5.06997742e-02f, 8.42517018e-02f, 5.87283596e-02f, 8.02220255e-02f, 4.72594462e-02f, 7.18015507e-02f, -3.37599367e-02f, -3.42562906e-02f, -3.53478417e-02f, 4.03207578e-02f,
  1.06888274e-02f, -3.14528123e-02f, 1.62086621e-01f, 4.30943146e-02f, 8.07070658e-02f, 1.84686203e-02f, -2.15897895e-03f, -8.20157081e-02f, 9.79164317e-02f, 1.06665321e-01f,
  1.46132149e-03f, 9.09369588e-02f, 1.04049586e-01f, -2.54655164e-02f, 3.18778008e-02f, -4.90268208e-02f, 3.90311889e-02f, -4.23074961e-02f, 1.14429019e-01f, 2.90362351e-02f,
  -7.65124857e-02f, 2.44718287e-02f, -3.70055027e-02f, 2.39815768e-02f, 1.30728200e-01f, 5.63977025e-02f, 9.24750492e-02f, -2.22485792e-02f, 9.25738923e-03f, -8.66106376e-02f,
  5.45984646e-03f, 2.66198777e-02f, -4.20700423e-02f, -5.97193688e-02f, -5.75903654e-02f, 9.88294557e-02f, 6.99795485e-02f, 8.08049217e-02f, -1.27882987e-01f, -5.34642264e-02f,
  2.32152082e-02f, 2.14519963e-01f, 2.65413383e-03f, -2.91853268e-02f, -3.95076238e-02f, -6.60766959e-02f, 9.20166671e-02f, 4.18137051e-02f, 4.56661955e-02f, -2.03258432e-02f,
  -5.34985736e-02f, 5.34953848e-02f, -2.61552744e-02f, 1.17403464e-02f, -2.16865018e-02f, -1.98477902e-03f, -4.38043959e-02f, 4.86797504e-02f, 2.36848500e-02f, 1.90528296e-02f,
  -6.35312200e-02f, 6.99518807e-03f, 8.47871080e-02f, -3.97529975e-02f, 4.22096401e-02f, -4.44560759e-02f, 5.76776043e-02f, -9.17871371e-02f, -6.33237585e-02f, 5.78287020e-02f,
  -8.28325823e-02f, -2.44198158e-01f, -1.82471275e-01f, -5.16200624e-02f, 5.24029434e-02f, 2.81156540e-01f, 2.06773803e-01f, -2.08506584e-01f, -1.87890247e-01f, 1.40341893e-01f,
  3.00595254e-01f, -3.96369994e-01f, 2.31529269e-02f, 1.60697013e-01f, 1.12325892e-01f, 1.19638301e-01f, 1.28283784e-01f, 1.10222422e-01f, -9.33841020e-02f, -5.02526574e-02f,
  -9.74603072e-02f, 1.99407682e-01f, 7.05168843e-02f, -1.95472211e-01f, 1.14996554e-02f, -1.52271539e-01f, 1.23528920e-01f, -1.22080818e-01f, -3.18502411e-02f, -7.46924356e-02f,
  1.78672880e-01f, 4.38108295e-03f, -9.52991024e-02f, 6.16433807e-02f, 9.77543965e-02f, 1.70137927e-01f, 1.32218882e-01f, -4.37981486e-02f, 5.97999059e-02f, -1.47799909e-01f,
  -3.24031003e-02f, 6.31641150e-02f, -1.29596427e-01f, 8.01056176e-02f, -3.02870572e-02f, -4.66883294e-02f, 8.60730745e-03f, -1.53248589e-02f, -4.58593704e-02f, -4.44389880e-02f,
  -2.75770901e-03f, -3.80341113e-02f, -9.29949805e-02f, 1.53625160e-02f, -1.08434923e-01f, -4.40322943e-02f, 2.83470713e-02f, -4.73499671e-02f, 1.08062431e-01f, -1.03332378e-01f,
  -9.62016806e-02f, 2.14071497e-02f, 6.39307424e-02f, 1.17534883e-01f, 1.27680853e-01f, -1.77954640e-02f, 3.54237127e-04f, 1.26811743e-01f, 9.71065909e-02f, 1.24486379e-01f,
  4.75845560e-02f, 1.94621105e-02f, -2.34372560e-02f, 3.85716036e-02f, 4.89347316e-02f, -1.26319826e-02f, -1.40592352e-01f, -2.74829175e-02f, 7.34895095e-02f, 8.29673931e-03f,
  2.44407542e-03f, 1.51505455e-01f, -3.39581147e-02f, -4.76258546e-02f, -2.11830605e-02f, -3.31547111e-02f, 4.26126644e-02f, -1.05501935e-01f, 1.82807986e-02f, -1.11503564e-02f,
  1.21008456e-01f, 3.19817849e-02f, -1.97352134e-02f, -7.13730976e-02f, 9.24205873e-03f, 7.94681162e-02f, 1.60862267e-01f, -3.46876532e-02f, 1.48831867e-02f, -1.04868896e-01f,
  2.90782657e-03f, 1.54086620e-01f, 5.02159186e-02f, 1.09601341e-01f, -1.00860119e-01f, 4.05237637e-02f, 6.82967305e-02f, 2.11795932e-03f, 1.37333050e-02f, -2.15337068e-01f,
  6.18247688e-02f, 1.12710185e-01f, -9.21440274e-02f, -3.41394991e-02f, -3.04985922e-02f, 3.43185179e-02f, -2.47802325e-02f, -3.65620665e-02f, 3.89859490e-02f, -3.83665189e-02f,
  2.92649657e-01f, -8.07047039e-02f, -6.64087236e-02f, 8.10594633e-02f, -1.04167759e-01f, -3.27615201e-01f, -2.76487935e-02f, -1.76421538e-01f, -8.16433877e-02f, -2.78974678e-02f,
  -4.00057957e-02f, 2.00498506e-01f, -1.05810678e-03f, 8.99868011e-02f, -1.02550551e-01f, -2.24215701e-01f, -7.43803009e-02f, 9.68661010e-02f, -2.93955743e-01f, 1.51139751e-01f,
  -1.03095897e-01f, -1.29666673e-02f, -2.87132058e-02f, 3.62342075e-02f, 9.33734849e-02f, -1.27162784e-02f, 1.56863630e-01f, -1.01312017e-02f, 8.41210112e-02f, -1.25821084e-01f,
  -1.68883458e-01f, -1.06262177e-01f, -2.31466647e-02f, -1.43967330e-01f, -4.82561998e-02f, -3.21055837e-02f, -1.98539365e-02f, -7.69779161e-02f, 6.80608898e-02f, 4.87015694e-02f,
  1.15644813e-01f, 2.21346635e-02f, 8.94461796e-02f, -3.51340622e-02f, 9.58520100e-02f, 4.30778712e-02f, -1.73538029e-02f, -1.45271784e-02f, 5.71347326e-02f, 5.68223260e-02f,
  1.28635183e-01f, 9.46669877e-02f, 1.34724841e-01f, 1.77378114e-02f, 7.69045427e-02f, -1.67235974e-02f, -4.93249670e-02f, 4.88601141e-02f, 1.50159681e-02f, -5.39553314e-02f,
  1.67834103e-01f, -4.19771411e-02f, 7.30183572e-02f, -6.90837875e-02f, -1.06327660e-01f, -9.69564319e-02f, 1.46510908e-02f, -1.00476734e-01f, -1.33420378e-01f, 4.21748161e-02f,
  -4.92918817e-03f, 8.44440609e-02f, -7.91354198e-03f, -2.49723867e-02f, -3.51707451e-03f, -5.23440614e-02f, 2.32206956e-02f, 7.31636351e-03f, -1.16665252e-02f, -6.73893560e-03f,
  3.34694684e-02f, 2.46909391e-02f, -8.03517997e-02f, -9.35734734e-02f, 3.30649056e-02f, 6.50110319e-02f, 6.17264211e-02f, -1.53177632e-02f, -1.20040305e-01f, 1.08135922e-03f,
  -2.59782225e-01f, -3.18037808e-01f, -1.45085081e-01f, -7.11443052e-02f, 1.10042207e-02f, -8.67384300e-03f, -6.72068074e-02f, -1.36890903e-01f, -5.84505387e-02f, -2.09190175e-02f,
  -2.70571504e-02f, 7.29021803e-02f, 7.94214606e-02f, 2.31863242e-02f, 1.62713051e-01f, -8.71597305e-02f, -6.26197979e-02f, -7.63079450e-02f, -7.23310784e-02f, 2.67281085e-02f,
  1.77442104e-01f, 1.23865567e-01f, 8.23934600e-02f, -2.49948949e-02f, 9.03324410e-02f, -1.32469425e-03f, 5.35215139e-02f, 6.06624596e-02f, -4.61850576e-02f, 1.59560665e-02f,
  3.98310006e-01f, 3.21626067e-01f, 7.04683959e-02f, 3.54680210e-01f, -1.92304283e-01f, -1.71406820e-01f, 1.51930442e-02f, 3.35521884e-02f, 2.56915510e-01f, 8.81907642e-02f,
  1.34703284e-02f, 1.56002656e-01f, -1.48710341e-03f, 2.87277363e-02f, 2.23884284e-02f, -7.74364546e-02f, 8.27596113e-02f, 1.57472640e-01f, -2.94252131e-02f, 1.60614774e-01f,
  2.31967773e-02f, -6.28077537e-02f, -1.20485537e-01f, 3.59409712e-02f, -5.74048236e-02f, 6.31270111e-02f, -2.33335048e-02f, -1.04399823e-01f, -2.54965350e-02f, -6.00528643e-02f,
  -5.06684231e-03f, 1.06619149e-01f, -6.06914982e-02f, 5.18580936e-02f, -4.88292798e-02f, -4.01978120e-02f, 2.82791033e-02f, -5.92725612e-02f, -7.62503128e-03f, -6.99895024e-02f,
  2.91437153e-02f, -4.16079760e-02f, -2.32290030e-02f, 3.09870504e-02f, -2.17807163e-02f, -8.94956812e-02f, -9.52815115e-02f, -7.83923827e-03f, -5.01804389e-02f, -1.63749889e-01f,
  -1.72050651e-02f, -1.42232358e-01f, -8.75147432e-02f, -8.36541355e-02f, -8.68950933e-02f, -7.44601786e-02f, -1.46060795e-01f, -3.53739560e-02f, -5.77378906e-02f, -3.75436060e-02f,
  -6.95332587e-02f, -4.97265868e-02f, -2.88946964e-02f, 7.23611414e-02f, 1.66692231e-02f, -2.33079251e-02f, 1.02716319e-01f, -7.67205581e-02f, 5.74021451e-02f, -5.24936430e-03f,
  1.94321014e-02f, 7.18066171e-02f, 1.28559144e-02f, 6.23965710e-02f, 1.23504652e-02f, 6.65804222e-02f, 3.25755391e-05f, 3.31201614e-03f, 8.53641406e-02f, -5.28581301e-03f,
  3.98208983e-02f, 1.26534596e-01f, 3.65599692e-02f, -5.83168790e-02f, -6.15556724e-03f, 4.58962768e-02f, -1.64109364e-01f, -6.23379610e-02f, -7.13766590e-02f, -3.81846912e-02f,
  2.05308080e-01f, 3.38888854e-01f, 4.78832163e-02f, -8.57768860e-03f, -8.62099081e-02f, -8.47786963e-02f, -8.73037893e-03f, -6.37854934e-02f, 1.67749671e-03f, -7.49814557e-03f,
  4.33467068e-02f, 2.35043764e-02f, 2.33889110e-02f, 1.83108412e-02f, 5.05500995e-02f, -4.30991687e-02f, 1.34195700e-01f, 8.12211558e-02f, 4.67014611e-02f, 5.80948070e-02f,
  -3.04220412e-02f, 1.09026678e-01f, -1.44051969e-01f, -1.40950531e-01f, -7.21535534e-02f, -5.59972785e-03f, 5.59784770e-02f, 6.55714199e-02f, -9.31062028e-02f, -9.52019915e-03f,
  -3.22939381e-02f, -1.53472751e-01f, 2.03116283e-01f, 4.60093915e-02f, -1.76412478e-01f, 3.79862845e-01f, 1.51744634e-01f, 5.50005808e-02f, -1.93328019e-02f, -6.33990169e-02f,
  4.19626571e-02f, -1.64858922e-01f, -6.23485371e-02f, 1.43363476e-01f, 3.12703937e-01f, 8.29221159e-02f, 3.25808793e-01f, 3.31103206e-02f, 8.94955266e-03f, -5.09776399e-02f,
  1.39067143e-01f, -4.03152555e-02f, 2.52255172e-01f, -5.27719706e-02f, -3.81051078e-02f, 1.48187708e-02f, -1.94707423e-01f, -8.53164569e-02f, 1.04311578e-01f, -3.06176096e-02f,
  -7.16877803e-02f, -1.12571262e-01f, -8.96664783e-02f, -3.93439494e-02f, 1.52027145e-01f, 4.47611399e-02f, -2.03484353e-02f, 7.21109007e-03f, 1.54824760e-02f, -3.53320986e-02f,
  -1.72029641e-02f, 5.40541708e-02f, 3.17209028e-02f, -9.74677429e-02f, 3.03386059e-02f, -1.02103226e-01f, 3.55515219e-02f, 6.44667819e-02f, -3.15831788e-02f, 5.01029044e-02f,
  4.65921909e-02f, 1.64429098e-01f, 1.75690707e-02f, -1.38945766e-02f, 1.34564899e-02f, 9.04765651e-02f, 2.67923400e-02f, 4.87071425e-02f, 1.38834655e-01f, 6.77036308e-03f,
  9.48055089e-02f, -7.01887086e-02f, -4.81930189e-02f, -1.04059920e-01f, -5.67501709e-02f, -6.72867373e-02f, -1.21889293e-01f, -2.46060323e-02f, -9.42771956e-02f, 1.79930814e-02f,
  -9.48726013e-03f, -4.80771661e-02f, -1.62776727e-02f, 8.46311599e-02f, -1.91798229e-02f, 1.76266266e-03f, -2.54300833e-02f, -6.20112270e-02f, 1.39127403e-01f, 9.07656476e-02f,
  -9.33166519e-02f, 1.12857357e-01f, -3.64318416e-02f, -3.03191412e-02f, 5.53480797e-02f, 4.44542430e-02f, 5.58819156e-03f, 8.85457918e-03f, 4.18718494e-02f, -2.40478795e-02f,
  -2.41268143e-01f, -1.77265331e-01f, -1.67891532e-02f, -3.82239223e-02f, -4.68137935e-02f, -6.25439957e-02f, 1.11711629e-01f, 7.10624829e-02f, -1.91534441e-02f, -7.76413009e-02f,
  5.52565642e-02f, -9.00124833e-02f, -6.95966976e-03f, -7.40092918e-02f, -2.65687015e-02f, -2.77098063e-02f, 1.85818933e-02f, -4.83995155e-02f, -1.17219370e-02f, 5.26708551e-02f,
  -6.81502447e-02f, -4.87076454e-02f, 1.05695361e-02f, -2.54088119e-02f, -2.44828872e-02f, -1.41657740e-02f, -3.13976556e-02f, 6.54837489e-02f, 1.01921462e-01f, 4.46616784e-02f,
  -4.13855553e-01f, 2.91822881e-01f, -1.02499105e-01f, 9.69522819e-03f, -8.10879692e-02f, -7.10341707e-02f, -2.40013391e-01f, 6.88173845e-02f, -2.92902514e-02f, 1.97349876e-01f,
  -1.05765052e-01f, 1.03602409e-02f, -9.17357728e-02f, 5.98684028e-02f, -2.78011262e-01f, -1.57752067e-01f, -3.69166993e-02f, 3.66173163e-02f, 3.14236134e-02f, 7.88181797e-02f,
  -8.88938904e-02f, -1.76582821e-02f, -1.29234910e-01f, 1.84800237e-01f, -8.17251578e-02f, 4.01957817e-02f, 9.38654542e-02f, 1.05821472e-02f, 1.19552225e-01f, -6.21937439e-02f,
  -3.04905213e-02f, -3.42142917e-02f, 3.19483615e-02f, 8.85421410e-02f, -4.83015366e-02f, -5.03837466e-02f, -7.26708630e-03f, -4.76430468e-02f, -7.31015354e-02f, 3.00680269e-02f,
  1.56688113e-02f, -9.95607767e-03f, 3.23176906e-02f, -1.17963336e-01f, 1.11203857e-01f, -7.21534640e-02f, 4.09521535e-02f, -1.61979366e-02f, 1.13428265e-01f, -7.25598633e-02f,
  -1.04527362e-01f, 5.38464636e-03f, 8.43802243e-02f, -1.48987368e-01f, -8.62155333e-02f, -8.00793469e-02f, 4.03330438e-02f, 3.83405341e-03f, 2.82729249e-02f, 5.00612371e-02f,
  -1.87239014e-02f, -1.03584692e-01f, -1.75660048e-02f, 7.60141714e-03f, -3.29062305e-02f, 3.76311652e-02f, -1.31876851e-02f, 5.70611507e-02f, -5.57094961e-02f, 3.48955533e-03f,
  -6.16156636e-03f, -7.73911327e-02f, 6.89731240e-02f, 1.58075634e-02f, -6.87779859e-02f, 5.39392233e-02f, -2.73541617e-03f, -4.77411374e-02f, -3.33144478e-02f, -7.34166950e-02f,
  -6.04883581e-02f, 5.45188300e-02f, 2.39120442e-02f, 2.65918467e-02f, -1.06895473e-02f, -4.44423072e-02f, -1.19222496e-02f, 2.34569646e-02f, -4.03811932e-02f, -1.16357595e-01f,
  1.31121740e-01f, 3.21152270e-01f, 4.42208201e-02f, 1.32266268e-01f, -8.67361724e-02f, -1.72906835e-02f, -4.10722382e-02f, -5.90730691e-03f, -6.72813728e-02f, 3.79264005e-03f,
  -5.05968407e-02f, -1.77791063e-02f, 9.70764682e-02f, -3.44886817e-02f, 1.01351336e-01f, 4.64528799e-02f, 6.72010239e-04f, -7.32871890e-02f, 4.04563844e-02f, 8.37202892e-02f,
  -3.89789119e-02f, 1.44783244e-01f, -5.01105860e-02f, -2.84598563e-02f, -2.32100170e-02f, 7.59285968e-03f, 4.10181545e-02f, 1.02178052e-01f, 1.07980214e-01f, 3.23873498e-02f,
  -2.57693261e-01f, 2.29361087e-01f, 1.86668679e-01f, -6.79386361e-03f, -1.48841947e-01f, 3.56631279e-02f, 6.69598728e-02f, 4.76306379e-02f, -1.16209410e-01f, 2.25830495e-01f,
  -5.92228435e-02f, 1.44127801e-01f, 1.53520092e-01f, -1.49655059e-01f, -1.18645929e-01f, 1.96281642e-01f, -7.10630342e-02f, 9.54423025e-02f, 6.04707561e-03f, 2.10470078e-03f,
  -1.10568136e-01f, -2.04188392e-01f, 6.76947236e-02f, 6.55700220e-03f, -2.77034491e-02f, 1.75965026e-01f, -1.44626284e-02f, 6.29802644e-02f, 2.15935875e-02f, 2.90119164e-02f,
  -9.12579000e-02f, -1.36476159e-01f, -3.63775296e-03f, 8.15118197e-03f, 1.59884952e-02f, 1.69527065e-02f, -4.77780181e-04f, 1.94286600e-01f, -1.12933427e-01f, 8.12938213e-02f,
  1.59944102e-01f, 2.09080838e-02f, -1.27641382e-02f, -5.91294356e-02f, -6.30493313e-02f, -9.08070877e-02f, 8.39737579e-02f, 2.67286673e-02f, 2.20143087e-02f, 3.23911011e-02f,
  1.04640640e-01f, 9.03337821e-02f, 5.26995456e-04f, 6.41352683e-02f, 8.10896382e-02f, 4.65433151e-02f, 1.98926660e-03f, 1.55934528e-01f, 5.39297573e-02f, 4.39486019e-02f,
  5.55375218e-02f, -2.93149706e-02f, -2.92268097e-02f, -3.38571779e-02f, -5.03849648e-02f, 2.97594583e-03f, -1.30809546e-01f, -1.65625364e-02f, -1.27668176e-02f, -7.18589798e-02f,
  -1.67359263e-02f, -3.31339315e-02f, 3.37911360e-02f, -1.23013966e-02f, -4.36723232e-02f, -1.23870097e-01f, 1.15198560e-01f, 8.15908238e-02f, 4.00785655e-02f, -7.47365598e-03f,
  -6.10381365e-02f, -9.05770902e-03f, 3.01042497e-02f, 6.76552728e-02f, 3.51881683e-02f, 2.32541114e-02f, -3.27967554e-02f, 3.75911891e-02f, -6.60489127e-03f, 1.59481373e-02f,
  1.01665892e-02f, 1.73561618e-01f, 3.61513458e-02f, 1.38745466e-02f, 1.00384161e-01f, 1.06089227e-01f, -3.12505327e-02f, 6.18869066e-02f, -6.84606060e-02f, 2.39330605e-02f,
  1.16289645e-01f, -1.16908031e-05f, -5.85544705e-02f, -9.65546817e-02f, 2.26945132e-02f, 8.23746398e-02f, 1.30837470e-01f, -2.50674114e-02f, 4.92217764e-02f, -1.99130774e-02f,
  2.80524138e-02f, 1.00579575e-01f, 9.57693830e-02f, -5.22241369e-02f, 1.63507368e-03f, 1.28013775e-01f, -1.29359677e-01f, 1.72064945e-01f, 1.82057366e-01f, 5.63043058e-02f,
  3.46336931e-01f, -1.57351717e-01f, 4.39391658e-02f, 1.62604854e-01f, 1.35289490e-01f, 1.98145702e-01f, 1.70065269e-01f, 2.04878345e-01f, 3.33931327e-01f, -4.28915203e-01f,
  -1.24885730e-01f, -1.30013198e-01f, -1.98320299e-01f, -1.12150498e-01f, 2.39460155e-01f, 4.23449790e-03f, 1.81269199e-01f, 3.29216681e-02f, 5.86281866e-02f, -1.95757881e-01f,
  -2.94215567e-02f, -1.79079801e-01f, -1.66936561e-01f, -2.25795776e-01f, 6.57365024e-02f, 2.05946453e-02f, -9.27101895e-02f, -5.10521792e-02f, -9.06477273e-02f, 4.89744432e-02f,
  7.72552863e-02f, -3.61860767e-02f, -9.22291074e-03f, -3.60204019e-02f, 7.00906888e-02f, -6.69046268e-02f, 1.36898505e-02f, -7.15498924e-02f, 2.40207817e-02f, -1.79746151e-01f,
  -1.47567034e-01f, -5.52530885e-02f, -1.02771170e-01f, -1.65269664e-03f, 1.05649054e-01f, 5.13666682e-02f, 1.05181038e-01f, 1.99938193e-01f, 6.60588071e-02f, 3.35952044e-02f,
  2.74487343e-02f, 1.36314318e-01f, 1.49173871e-01f, 4.07218784e-02f, 6.89474791e-02f, 5.92972822e-02f, -6.75120801e-02f, 6.82350323e-02f, -7.68117830e-02f, 7.92824402e-02f,
  -2.52790004e-02f, 1.16489977e-01f, 4.54059355e-02f, -1.21936433e-01f, 5.33755356e-03f, -5.76813594e-02f, -7.34179318e-02f, 3.89827453e-02f, 5.13096303e-02f, 1.04339337e-02f,
  3.48960944e-02f, 3.74457575e-02f, 9.66730416e-02f, 2.27049328e-02f, 2.00823005e-02f, 7.96449408e-02f, -1.13158800e-01f, -1.80621613e-02f, 7.58400634e-02f, 1.15317345e-01f,
  2.89380867e-02f, -2.51233689e-02f, -2.24357862e-02f, -1.03312612e-01f, -1.44800879e-02f, 9.13135931e-02f, 9.53312777e-03f, 4.25703675e-02f, 5.78362159e-02f, -1.43439705e-02f,
  6.26586676e-02f, -4.50735316e-02f, -2.13677790e-02f, -9.11541432e-02f, -1.16781458e-01f, -1.34543285e-01f, 7.34129623e-02f, -2.38571484e-02f, 1.69673413e-02f, -1.39453694e-01f,
  -8.21593963e-03f, 1.68997217e-02f, 1.68147720e-02f, 3.53816152e-02f, -4.35880087e-02f, -2.70086862e-02f, -1.25944719e-01f, 1.09212488e-01f, 1.91494413e-02f, -1.65501628e-02f,
  4.05313075e-03f, -4.89019342e-02f, -2.73758154e-02f, 3.11288033e-02f, -6.44059256e-02f, 2.58358289e-02f, -1.22275082e-02f, -3.98989916e-02f, -9.09081567e-03f, 1.16775259e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.85525358e-01f, 3.51844043e-01f, -4.47750911e-02f, -6.06368445e-02f, -2.29982600e-01f, 1.41133696e-01f, 4.18770537e-02f, 1.41253129e-01f, -5.01421355e-02f, 3.08125973e-01f,
  -7.09729642e-02f, -1.01470053e-01f, 2.00357959e-01f, 7.37004951e-02f, -1.57891273e-01f, 2.65653133e-01f, 8.11580271e-02f, 1.93329807e-02f, -6.57409057e-02f, 2.94719217e-03f,
  -6.46299347e-02f, 2.87701879e-02f, 8.54077116e-02f, 1.20644659e-01f, -2.38001063e-01f, -2.18780309e-01f, -2.52422601e-01f, -5.53568862e-02f, -1.43108666e-01f, -4.58709449e-02f,
  -2.97076374e-01f, -2.83413529e-01f, -3.03023100e-01f, -1.94506288e-01f, -1.37079254e-01f, -4.62346710e-02f, -6.75089434e-02f, -3.38090621e-02f, -3.07756905e-02f, 1.49925444e-02f,
  1.68998875e-02f, 9.36242715e-02f, -5.28328493e-02f, 1.71371363e-02f, -1.03784941e-01f, -2.66934913e-02f, -3.60641330e-02f, -2.13575624e-02f, -1.05499581e-01f, 3.45245078e-02f,
  1.01097450e-01f, -4.39935587e-02f, -5.21636009e-02f, -2.33138278e-02f, -5.40935211e-02f, -7.33709186e-02f, 7.12713227e-02f, -1.60546470e-02f, -6.67320713e-02f, -3.59954834e-02f,
  -3.77104827e-03f, 3.24921459e-02f, 3.83873023e-02f, 3.63497734e-02f, 6.54896870e-02f, -7.97846392e-02f, 1.33102369e-02f, -3.87385041e-02f, -1.14887217e-02f, -1.82956755e-02f,
  -9.10495296e-02f, -5.87169603e-02f, -2.38533709e-02f, 2.92817019e-02f, 8.45041052e-02f, -1.09109901e-01f, 2.43815314e-02f, -5.73067218e-02f, 2.09330209e-02f, -9.76516008e-02f,
  -1.01475269e-01f, 4.08881269e-02f, 3.57174650e-02f, -1.68039538e-02f, -5.33197029e-03f, 3.70489508e-02f, -3.88771296e-02f, 9.47199389e-02f, -9.41155702e-02f, -6.72086850e-02f,
  -3.85684520e-01f, -3.42474163e-01f, -1.51074827e-01f, -1.82725236e-01f, -1.37610272e-01f, 1.42178200e-02f, 6.84665143e-02f, -8.85143504e-03f, -5.08841425e-02f, -1.53120691e-02f,
  2.75126789e-02f, 5.68901747e-02f, -1.03555836e-01f, -4.94118072e-02f, 5.27951159e-02f, 5.67143783e-02f, -6.39028996e-02f, -6.77004233e-02f, -2.25830525e-01f, -4.26622219e-02f,
  4.87226956e-02f, 3.96947041e-02f, 1.05642378e-01f, -9.31857601e-02f, -6.04391322e-02f, -1.26714319e-01f, -4.20536511e-02f, -4.77558821e-02f, -1.19913019e-01f, 8.93487632e-02f,
  5.30277133e-01f, -5.09504497e-01f, -2.10523263e-01f, 2.43100241e-01f, 3.44545245e-01f, 1.07354395e-01f, 2.10249439e-01f, 1.69330284e-01f, 1.56019643e-01f, -1.63193777e-01f,
  1.46580786e-01f, -2.34063536e-01f, -2.97154218e-01f, 1.24321058e-01f, 3.64410073e-01f, -1.54954806e-01f, 2.00337455e-01f, -3.23010013e-02f, 4.55439091e-02f, 6.54776022e-02f,
  1.86498851e-01f, 3.23208809e-01f, 8.44862834e-02f, 7.48548880e-02f, 9.49588567e-02f, -5.77054583e-02f, 2.34385692e-02f, -2.19888628e-01f, 5.60240373e-02f, -2.35919915e-02f,
  9.83530805e-02f, 3.76199298e-02f, 7.08370879e-02f, -1.48162082e-01f, -5.43954149e-02f, -1.29671022e-02f, -1.45499669e-02f, -4.97441813e-02f, 6.69818893e-02f, 2.10192334e-02f,
  -3.54775451e-02f, 1.53142452e-01f, 1.29406840e-01f, -5.03888875e-02f, -1.11681875e-02f, 6.04032679e-03f, -4.89653982e-02f, -8.05312768e-02f, -4.68599796e-02f, -9.54618379e-02f,
  4.49541919e-02f, 9.16825905e-02f, 6.55661225e-02f, -1.09332718e-01f, -4.60755713e-02f, -1.81226787e-04f, -3.37872617e-02f, -5.03635220e-02f, -4.45849188e-02f, 6.40590712e-02f,
  9.12381569e-04f, 3.14151943e-02f, -8.69164243e-02f, 5.07208854e-02f, -6.80623427e-02f, 5.72205596e-02f, -1.72017310e-02f, -4.19962071e-02f, -3.96871977e-02f, -6.51266575e-02f,
  5.45781851e-02f, 4.37156931e-02f, -1.83149856e-02f, -2.79393326e-02f, -2.24790536e-02f, 1.31959245e-01f, -3.01297512e-02f, 3.02691311e-02f, 3.46513279e-02f, 8.34132135e-02f,
  3.94522585e-02f, 1.69170257e-02f, -1.71937179e-02f, -1.76982749e-02f, 7.77768642e-02f, -5.74196167e-02f, -3.63724399e-03f, -3.41576599e-02f, 5.05811349e-02f, -9.58017856e-02f,
  -2.41216391e-01f, -4.85180318e-01f, 6.85353205e-03f, 3.00380867e-02f, -9.68483090e-02f, -1.24294125e-02f, -1.21094501e-02f, 6.39958978e-02f, -8.77224281e-03f, -3.95652875e-02f,
  6.72457665e-02f, -5.87572297e-03f, 7.92454407e-02f, 1.49142938e-02f, 5.72017534e-03f, -8.29279348e-02f, -1.36957645e-01f, -7.99703822e-02f, -1.87254064e-02f, -9.50897560e-02f,
  6.30650073e-02f, -3.35633173e-03f, 4.61696610e-02f, -2.35784184e-02f, -6.01248397e-03f, -3.70575115e-02f, 5.37620997e-03f, 1.63110271e-02f, -8.86009187e-02f, -4.72644754e-02f,
  -1.51049942e-01f, -5.76779656e-02f, -2.11668402e-01f, -3.44292045e-01f, 6.88734129e-02f, -3.20152611e-01f, -3.09981346e-01f, -1.40792146e-01f, -8.32344666e-02f, -1.22353435e-01f,
  -6.42625168e-02f, -5.74734621e-02f, 1.51110217e-01f, -3.03671837e-01f, -1.41443193e-01f, 1.34589240e-01f, -2.83217400e-01f, -1.85801640e-01f, 1.24767728e-01f, -3.05346753e-02f,
  3.17574404e-02f, -1.40672415e-01f, -8.63676369e-02f, 4.84128408e-02f, -1.87756225e-01f, 8.59078672e-03f, 1.56736970e-01f, 4.05357443e-02f, -2.64542580e-01f, -6.52363449e-02f,
  -7.14503974e-02f, -4.16224338e-02f, -1.02605976e-01f, -1.04611479e-01f, -1.41372234e-01f, -7.27465600e-02f, -1.31014613e-02f, -2.73978636e-02f, -9.23799202e-02f, 3.59588489e-02f,
  2.83771902e-02f, 4.33185361e-02f, -6.02802150e-02f, 8.06534812e-02f, -1.91259552e-02f, -8.29035230e-03f, -2.81597227e-02f, -1.28670275e-01f, 2.64700148e-02f, -6.04547523e-02f,
  2.97087301e-02f, -1.11258335e-01f, -5.15280738e-02f, 5.62084615e-02f, 2.43700072e-02f, -1.15070470e-01f, -2.55869050e-02f, 2.45205406e-02f, -2.74052881e-02f, 1.29040265e-02f,
  -3.83091643e-02f, 6.34033903e-02f, -4.18625884e-02f, 5.45261614e-02f, -8.77290964e-02f, -2.72708777e-02f, 1.60635021e-02f, -7.94529915e-02f, 7.19738007e-03f, 8.22935030e-02f,
  -5.80768883e-02f, -5.13929687e-02f, -2.69126967e-02f, -8.61786306e-02f, -3.10137011e-02f, 5.03988788e-02f, 3.41942869e-02f, -1.35148996e-02f, 1.72207728e-02f, -4.86389212e-02f,
  3.50559242e-02f, -8.43251050e-02f, 8.53463262e-02f, 8.20036083e-02f, -1.14887863e-01f, 7.18623921e-02f, 6.29158765e-02f, -7.91014954e-02f, -5.77397421e-02f, 1.47837559e-02f,
  -4.88043204e-02f, -1.22518167e-01f, -1.16898298e-01f, -7.85172805e-02f, 7.10126981e-02f, -1.40860006e-01f, -5.50921680e-03f, -5.02414554e-02f, -1.43924475e-01f, 3.33726816e-02f,
  -1.19794518e-01f, 2.32146261e-03f, 4.35073115e-02f, -8.44897237e-03f, 8.29691591e-04f, 2.37332135e-02f, -6.35191202e-02f, -2.27557607e-02f, 2.42725830e-03f, -2.11189184e-02f,
  1.05762698e-01f, -8.11780691e-02f, 8.48480314e-02f, -1.61810964e-02f, 3.50569859e-02f, 2.52099019e-02f, 8.32581222e-02f, 2.14227457e-02f, -8.94612148e-02f, 6.11774698e-02f,
  2.99222648e-01f, -3.09428684e-02f, -3.16597342e-01f, -1.25811413e-01f, 9.37485471e-02f, 2.65881807e-01f, 3.42690237e-02f, 4.01670635e-02f, -2.00249285e-01f, 2.04064488e-01f,
  1.06216051e-01f, -1.55131817e-01f, -8.71008188e-02f, 2.10641339e-01f, 2.43735295e-02f, -1.84680417e-01f, 2.83089340e-01f, 1.26727313e-01f, -1.90039545e-01f, 1.20911770e-01f,
  6.21165559e-02f, 3.96389127e-01f, -2.55221754e-01f, 1.85967132e-01f, 2.62688190e-01f, -1.65523142e-01f, 9.55705792e-02f, -2.52983570e-01f, 8.99815559e-02f, 3.07640284e-02f,
  -5.44604547e-02f, -3.45879793e-02f, -9.05528292e-02f, -6.31323233e-02f, 5.10471687e-02f, 1.35275304e-01f, -5.94401024e-02f, -3.44247967e-02f, -1.14415735e-01f, -9.31768492e-03f,
  5.21584414e-02f, 1.96735319e-02f, 5.80301955e-02f, 5.49812019e-02f, 1.27620041e-01f, -7.44594634e-02f, -1.13323934e-01f, -1.52838334e-01f, -1.20871261e-01f, 4.73257601e-02f,
  -6.92532286e-02f, -1.75908748e-02f, 2.31907852e-02f, -7.20444024e-02f, 2.09545363e-02f, -9.37907398e-03f, -7.01999441e-02f, -1.14943512e-01f, -4.96271029e-02f, 2.59577148e-02f,
  1.60213038e-01f, 9.56894755e-02f, 1.28673524e-01f, -1.22104045e-02f, -3.08222361e-02f, -9.58589837e-02f, 1.21837772e-01f, -1.95957813e-02f, -4.84423190e-02f, 3.16187646e-03f,
  -1.60746425e-02f, 5.78312986e-02f, -1.38980299e-02f, 6.89686760e-02f, 1.72810912e-01f, 1.25631252e-02f, -1.12950914e-02f, 2.70012207e-02f, -5.25856800e-02f, -3.27098779e-02f,
  -2.79952995e-02f, 6.48244619e-02f, -1.16446063e-01f, 1.26936380e-02f, 7.62583539e-02f, -1.97285134e-03f, 1.66761950e-01f, 2.62740534e-02f, -1.53984547e-01f, 3.40403803e-02f,
  1.57875661e-02f, 8.90824720e-02f, -4.51254249e-02f, -6.35731369e-02f, -5.95643744e-02f, 1.85415015e-01f, 7.73744434e-02f, 2.57648900e-02f, -2.94924602e-02f, 5.68647943e-02f,
  1.26865163e-01f, -5.87560162e-02f, 9.88579094e-02f, -5.99653833e-02f, -2.78098118e-02f, -1.16096623e-03f, 3.79047692e-02f, -1.16504513e-01f, -5.16863689e-02f, 7.20634684e-02f,
  2.59632040e-02f, 7.17610866e-02f, 1.77018922e-02f, -1.89948697e-02f, 1.00667603e-01f, -7.87039101e-02f, 9.27134082e-02f, -1.09240435e-01f, 6.05969876e-02f, -1.64721191e-01f,
  7.50623494e-02f, 2.98466295e-01f, 2.84435570e-01f, 2.44127661e-01f, -2.52689540e-01f, -3.62175047e-01f, -2.81535804e-01f, 2.62311623e-02f, -6.89850375e-02f, 4.21936139e-02f,
  -2.28028923e-01f, 4.81756419e-01f, -2.41874367e-01f, 2.45526075e-01f, -4.08326574e-02f, -2.57113129e-01f, 3.03620733e-02f, 1.09001674e-01f, 2.02702079e-02f, 1.43077791e-01f,
  6.91083446e-02f, -2.00003430e-01f, 1.17467135e-01f, 5.90356998e-02f, 1.75672472e-01f, 2.54069597e-01f, 6.01557977e-02f, -2.60264426e-02f, 3.84005159e-01f, 1.39932858e-03f,
  -8.63135755e-02f, -5.61918095e-02f, 1.72607765e-01f, -6.64353021e-04f, -8.64669308e-02f, -1.79196093e-02f, 6.34830520e-02f, -5.39050512e-02f, 4.75996807e-02f, 6.14294745e-02f,
  1.37794651e-02f, 6.52580038e-02f, 3.70531417e-02f, -4.33788709e-02f, -9.22127068e-02f, 4.87275347e-02f, -3.46128419e-02f, -6.03580885e-02f, 9.66473520e-02f, 9.30866152e-02f,
  1.48081034e-01f, 1.78366527e-02f, 3.02814450e-02f, 3.85587029e-02f, 1.10847101e-01f, -6.87479451e-02f, 6.15322888e-02f, 3.55512351e-02f, 9.28352401e-02f, 1.10731479e-02f,
  -1.06035545e-01f, -7.62007758e-03f, -3.23691778e-02f, 2.37138085e-02f, 3.23973112e-02f, -4.24464978e-02f, 9.12737087e-05f, -4.13684621e-02f, -1.33772090e-01f, -1.35633975e-01f,
  -1.02894709e-01f, -8.39268602e-03f, -3.83031256e-02f, -2.22566649e-02f, 6.07468113e-02f, -2.13154592e-02f, 3.04783247e-02f, -2.28684600e-02f, -2.29049549e-02f, -4.20287102e-02f,
  -1.60908043e-01f, -6.93030134e-02f, -2.22263969e-02f, -8.41853693e-02f, -4.38898988e-02f, -3.23572718e-02f, 3.61481383e-02f, 6.50754943e-02f, -6.78828806e-02f, -1.91154350e-02f,
  -9.37496051e-02f, 1.12370051e-01f, 8.23256820e-02f, -5.81135564e-02f, -1.50030376e-02f, 8.11038166e-02f, 2.51143370e-02f, 5.00347838e-02f, -4.06645983e-02f, -5.75292669e-02f,
  -3.51703390e-02f, -6.46172091e-03f, -3.19012590e-02f, -1.16946874e-03f, 1.77123975e-02f, 5.19371033e-02f, 5.67262573e-03f, -3.60714346e-02f, 4.85881558e-03f, 6.47547245e-02f,
  2.33297702e-03f, -6.05316944e-02f, 3.05028073e-02f, 4.38630319e-04f, -1.15031302e-01f, -1.25792902e-02f, 4.59552146e-02f, 9.46428478e-02f, -3.05660497e-02f, 8.80004317e-02f,
  -7.70554319e-02f, -3.94115120e-01f, 4.27090982e-03f, 2.50483811e-01f, 1.58086330e-01f, -1.44341931e-01f, -1.81820318e-01f, 1.11455828e-01f, 4.48673964e-02f, -3.34926933e-01f,
  -3.86960502e-03f, 5.00538908e-02f, -2.76183903e-01f, 4.73396145e-02f, 2.22686216e-01f, -1.04511887e-01f, 2.05821648e-01f, 1.67537317e-01f, 1.99730530e-01f, 2.02094555e-01f,
  2.44580001e-01f, 2.82462895e-01f, 4.01861072e-01f, 3.24695677e-01f, 2.01988667e-01f, 1.63582921e-01f, 1.58930272e-01f, 1.36288047e-01f, 2.89853930e-01f, 1.07524619e-01f,
  -3.35535444e-02f, -7.61523843e-02f, 9.16295722e-02f, -4.45698807e-03f, -3.88811454e-02f, -1.29968524e-01f, -2.37154532e-02f, -6.95198923e-02f, -1.16580538e-02f, -1.13159316e-02f,
  -9.24064070e-02f, 1.42519414e-01f, 7.66233504e-02f, 5.08461446e-02f, -4.54657003e-02f, 9.20085087e-02f, -6.74600340e-03f, -5.92624806e-02f, -3.16109695e-02f, -2.40135379e-02f,
  2.01112088e-02f, 4.50238213e-02f, -7.15516359e-02f, 1.02847749e-02f, 1.13669440e-01f, -1.70398243e-02f, -1.25453528e-02f, -4.42924239e-02f, -8.26408342e-02f, -2.58897301e-02f,
  -2.09345862e-01f, -1.01392008e-02f, 3.74013968e-02f, 6.01962581e-02f, 1.31617403e-02f, -6.32764697e-02f, -1.37816025e-02f, 1.05585098e-01f, 8.04141536e-03f, -1.32254124e-01f,
  -4.37245928e-02f, -3.67864892e-02f, 3.19615752e-02f, -5.54576255e-02f, -8.64239261e-02f, 6.53237337e-03f, 2.55978908e-02f, 8.64230841e-02f, 1.63933977e-01f, 3.09691131e-02f,
  -1.16063729e-02f, 1.88120715e-02f, -2.86421906e-02f, 2.84997635e-02f, -7.01010525e-02f, 1.97055042e-02f, 8.72580037e-02f, 4.30363230e-02f, -8.32065195e-02f, 1.03608899e-01f,
  -1.21690944e-01f, -5.36247641e-02f, -1.93610433e-02f, 7.05484673e-02f, -1.03976272e-01f, -5.65643273e-02f, 8.03986788e-02f, 8.98766145e-02f, -1.85596962e-02f, -6.91544712e-02f,
  -4.20069620e-02f, 1.24259941e-01f, -3.40907946e-02f, 1.32503435e-01f, 3.93616110e-02f, -5.46121374e-02f, -1.15859866e-01f, -4.64188717e-02f, 4.11025956e-02f, 6.13672251e-04f,
  1.54266031e-02f, -4.59539518e-02f, 6.88103586e-02f, 9.10061821e-02f, 1.26663551e-01f, -1.17025554e-01f, -3.82736698e-02f, 9.73314419e-02f, 7.42911324e-02f, -6.96019977e-02f,
  -3.34920466e-01f, -2.35817462e-01f, 3.60014915e-01f, -3.69985431e-01f, 1.28162205e-01f, 3.82836014e-01f, 1.44865766e-01f, -4.08496112e-02f, -3.26127112e-01f, -3.33575457e-01f,
  -9.19336602e-02f, -1.29943818e-01f, 6.30266443e-02f, -1.32743508e-01f, 4.29762125e-01f, 7.32071698e-02f, -1.16918921e-01f, -1.99929867e-02f, -7.70065114e-02f, -1.70935318e-01f,
  -9.85400602e-02f, -1.51556522e-01f, 2.51442224e-01f, -1.29059657e-01f, 1.71288084e-02f, -9.07006636e-02f, -2.92072985e-02f, 2.48857111e-01f, -1.92772634e-02f, 1.69412851e-01f,
  4.02626619e-02f, -2.61173129e-01f, -6.01538830e-02f, 1.57386176e-02f, 1.20384805e-02f, -3.68016809e-02f, 6.85981587e-02f, 1.45249456e-01f, -1.19652696e-01f, -6.00998811e-02f,
  -1.54637999e-03f, 5.95524237e-02f, -1.24395736e-01f, 5.44856824e-02f, -6.32122830e-02f, 1.36892507e-02f, 5.76892272e-02f, 5.75423911e-02f, 6.42099082e-02f, 8.31452608e-02f,
  5.13021648e-02f, 1.48374200e-01f, -6.67942837e-02f, -8.47864617e-03f, 3.64085063e-02f, -2.43749022e-02f, -1.05722591e-01f, 1.33422360e-01f, -4.74645607e-02f, -5.33698946e-02f,
  1.59833014e-01f, 7.34466538e-02f, 8.66728500e-02f, -2.58750524e-02f, -1.52000384e-02f, -1.58535056e-02f, -4.02075518e-03f, 3.54199074e-02f, -5.19696027e-02f, 2.65766568e-02f,
  1.04461405e-02f, -2.03730967e-02f, -8.57683048e-02f, -3.62941660e-02f, -4.60790657e-02f, -9.41291973e-02f, 2.11937539e-02f, -6.21241480e-02f, -1.93042662e-02f, 3.08050308e-02f,
  -9.06906128e-02f, -6.03791513e-02f, 1.63603034e-02f, -2.94351093e-02f, 6.93489537e-02f, 5.30798547e-02f, 4.43739891e-02f, 4.92196903e-02f, -1.14013553e-02f, 3.70611995e-02f,
  -7.97102675e-02f, -2.23106593e-01f, -8.00738633e-02f, -1.13272823e-01f, -1.68138482e-02f, -2.00304091e-02f, -2.87291575e-02f, -1.03018850e-01f, -5.89563176e-02f, -5.15942313e-02f,
  -4.28250767e-02f, -6.98440894e-02f, 3.83677483e-02f, -5.86009696e-02f, 5.30784987e-02f, 3.89817916e-02f, -4.42190021e-02f, -8.84167179e-02f, 2.71530356e-02f, -1.47688165e-02f,
  -6.37715217e-03f, 1.82387307e-02f, 1.02747589e-01f, -1.50106037e-02f, -1.49891809e-01f, -3.23571898e-02f, -1.20377414e-01f, 5.48418984e-02f, 1.04310438e-02f, 8.14336613e-02f,
  1.47921041e-01f, 2.85257757e-01f, 3.39597017e-01f, 3.86864752e-01f, -1.65852278e-01f, -3.91522169e-01f, -2.57799834e-01f, 1.44929647e-01f, -5.58732217e-03f, -9.84925330e-02f,
  6.48589246e-03f, 2.12853566e-01f, 4.18806868e-03f, 2.87297934e-01f, -1.28444983e-02f, -3.44967842e-02f, 5.84485494e-02f, -8.12538639e-02f, -6.18754476e-02f, 8.66680220e-02f,
  3.63010429e-02f, -8.28699023e-02f, 2.59270638e-01f, 1.36533976e-01f, 2.20684901e-01f, 1.71460092e-01f, 8.87685642e-02f, 8.42024237e-02f, 1.01172313e-01f, -1.05622895e-02f,
  -3.79417837e-02f, 1.31182089e-01f, 8.44760984e-02f, -2.13477202e-02f, 3.21710967e-02f, -1.14575706e-01f, 4.16720808e-02f, -9.37118232e-02f, -6.89233616e-02f, -5.56857884e-02f,
  1.03222787e-01f, -4.78514619e-02f, 2.65545510e-02f, -1.55372098e-01f, 1.44006899e-02f, 6.87862188e-02f, 3.03912070e-02f, 5.26210181e-02f, 1.20921448e-01f, 7.72895366e-02f,
  1.58426985e-01f, 5.71597442e-02f, 1.11546725e-01f, -1.85956742e-05f, -2.40820665e-02f, -5.07960021e-02f, -3.05388719e-02f, 2.94005265e-03f, 7.70480931e-02f, 2.87766308e-02f,
  1.59605473e-01f, -1.59247860e-01f, -5.14733493e-02f, -3.60661149e-02f, -3.91015001e-02f, -4.32570390e-02f, -7.86317438e-02f, -7.12022707e-02f, -1.79753691e-01f, -1.59450039e-01f,
  -8.20386410e-02f, 4.55938801e-02f, 1.12378588e-02f, -2.22329199e-02f, 3.49076167e-02f, 3.92296463e-02f, -5.34353927e-02f, -5.32791950e-02f, 8.50116685e-02f, 7.81101808e-02f,
  -5.05520962e-03f, -1.38196528e-01f, -9.41173639e-03f, 6.36221915e-02f, -1.26676857e-01f, -8.03822726e-02f, 3.60864662e-02f, 2.25740522e-02f, -1.12769017e-02f, 8.95815417e-02f,
  1.41424417e-01f, 1.51610240e-01f, 4.20802273e-02f, -2.88252924e-02f, -4.17294540e-02f, 3.34195681e-02f, 1.78811997e-02f, 5.76936342e-02f, -1.56218978e-02f, -2.22902335e-02f,
  3.34184952e-02f, -1.04363874e-01f, -3.71909477e-02f, -3.87755111e-02f, 3.14248689e-02f, 8.53862688e-02f, -4.93717119e-02f, -9.75818001e-03f, 1.10789306e-01f, 7.25056902e-02f,
  9.50837359e-02f, -5.78842051e-02f, 9.52256378e-03f, -3.90623771e-02f, -9.69105065e-02f, 6.75341412e-02f, -7.34675750e-02f, 5.07201068e-02f, 1.23960771e-01f, 5.74070215e-02f,
  -1.08539790e-01f, 2.14579582e-01f, 7.88902044e-02f, 4.41890568e-01f, -2.88750291e-01f, -1.15652695e-01f, 1.60340413e-01f, -1.84982955e-01f, -3.06802541e-02f, 2.71354109e-01f,
  5.29078692e-02f, 7.52437785e-02f, 8.97501931e-02f, 3.57359409e-01f, -4.83480543e-01f, 3.22589837e-02f, 2.75021702e-01f, 2.16236964e-01f, -1.00544095e-01f, -4.53361869e-02f,
  -5.96807860e-02f, -6.18482791e-02f, 1.99156389e-01f, -1.69722289e-01f, -3.04797348e-02f, -8.81983861e-02f, 5.49931079e-04f, -3.34189057e-01f, 1.32870778e-01f, -9.16179419e-02f,
  -9.01610106e-02f, -2.04185452e-02f, 8.56263265e-02f, -7.76429921e-02f, -1.40095696e-01f, 4.37309481e-02f, 2.20817830e-02f, -3.77906039e-02f, 3.33906077e-02f, -3.86203714e-02f,
  1.65450394e-01f, 1.48582831e-03f, 2.89932755e-03f, -3.57469842e-02f, -4.26723249e-02f, -1.09196752e-02f, -5.54311574e-02f, 1.45664632e-01f, -5.81486858e-02f, -9.37375799e-02f,
  1.00154556e-01f, -2.51912773e-02f, 1.12605870e-01f, 1.42219169e-02f, -5.43945283e-02f, 2.87753772e-02f, 1.34051859e-01f, -9.88698453e-02f, -4.64799255e-03f, -4.60589826e-02f,
  -2.35466715e-02f, 7.86481947e-02f, -4.98335809e-03f, -1.85583029e-02f, -5.07199876e-02f, -1.26632020e-01f, 3.72722349e-03f, -1.91124063e-02f, -2.64521949e-02f, -6.87255263e-02f,
  -2.60021556e-02f, 4.93763573e-02f, -9.57626924e-02f, 2.76907925e-02f, 1.58391982e-01f, -6.78650588e-02f, -3.67415287e-02f, -1.98774859e-02f, 1.23263951e-02f, -6.97686151e-02f,
  3.18347551e-02f, 4.11463678e-02f, 3.26015875e-02f, 2.92231403e-02f, 1.15365284e-02f, -3.17294486e-02f, -5.46313226e-02f, -1.02371657e-02f, -7.88409356e-03f, -5.14660999e-02f,
  -1.74815044e-01f, -3.13052446e-01f, -1.45842833e-02f, -1.24251969e-01f, -5.92958666e-02f, -2.29074806e-02f, 5.35669141e-02f, -2.63875108e-02f, -8.46477821e-02f, -1.25657320e-01f,
  6.21385053e-02f, 1.07626230e-01f, -3.51256393e-02f, 1.70353074e-02f, -1.65152494e-02f, 2.93626525e-02f, -5.56182377e-02f, 6.98777149e-03f, -8.22505504e-02f, -1.14520386e-01f,
  3.98003906e-02f, -2.08760966e-02f, -1.56535693e-02f, 1.15799978e-02f, -5.64965233e-02f, -3.57671753e-02f, -7.95745328e-02f, 4.93962871e-05f, -8.79545212e-02f, -2.73076110e-02f,
  -2.02605218e-01f, -1.97054505e-01f, -3.23092580e-01f, -2.78035682e-02f, 3.00833166e-01f, 3.10975403e-01f, -1.11334855e-02f, 1.61992341e-01f, -2.02064112e-01f, 1.53528705e-01f,
  9.63752642e-02f, -1.98813006e-01f, -2.09231153e-01f, -1.27600342e-01f, -1.74940452e-01f, -3.84540498e-01f, 1.16070010e-01f, -2.21207179e-03f, -2.32527658e-01f, 6.47863373e-03f,
  -1.00660726e-01f, 2.89500002e-02f, -2.54727453e-01f, 2.98250109e-01f, 9.67720225e-02f, -2.89511010e-02f, 2.56704003e-01f, -7.74541451e-03f, 2.46202156e-01f, 1.26797438e-01f,
  -1.13785714e-02f, -1.67456508e-01f, -2.86685582e-02f, -1.87817644e-02f, 1.09318219e-01f, 7.76811615e-02f, 3.05544548e-02f, -2.00458076e-02f, -5.46128638e-02f, -5.59292212e-02f,
  8.58127624e-02f, 8.90565198e-03f, -1.18174199e-02f, -1.34383719e-02f, 4.49470878e-02f, -8.21368918e-02f, -1.01271763e-01f, 1.27700027e-02f, 6.11692760e-03f, -1.16074771e-01f,
  -1.85000941e-01f, 3.60865034e-02f, 8.19659904e-02f, 9.75340828e-02f, -1.30627275e-01f, 1.63579546e-02f, -1.53690860e-01f, -3.84120494e-02f, 1.56005055e-01f, 3.58203016e-02f,
  6.13115281e-02f, 1.44481212e-02f, -8.40607584e-02f, 8.71530920e-02f, -1.33630797e-01f, 5.16150370e-02f, -1.08533325e-02f, 4.34672758e-02f, -3.00157029e-04f, 1.23630933e-01f,
  1.79551784e-02f, -9.53223780e-02f, 4.09424044e-02f, -9.34811030e-03f, -6.27384782e-02f, 2.89778747e-02f, -1.88335590e-02f, -1.21670119e-01f, -8.90179649e-02f, -1.21358976e-01f,
  2.83195339e-02f, -8.04147273e-02f, 1.33057788e-01f, 8.97866189e-02f, -1.01836756e-01f, 7.39133358e-02f, -6.46655122e-03f, -7.11145401e-02f, -1.27783075e-01f, -6.98571652e-03f,
  1.27416598e-02f, -3.88002619e-02f, -8.75528529e-02f, -1.41949020e-03f, -3.99509594e-02f, 2.65274886e-02f, 1.86507590e-02f, -2.94621717e-02f, -4.86999750e-02f, -6.40350133e-02f,
  1.57246098e-01f, 8.77151117e-02f, 5.30862585e-02f, -2.40973365e-02f, 9.68692526e-02f, 4.41897707e-03f, -2.05292795e-02f, 1.48619637e-01f, 2.06446931e-01f, 6.54177666e-02f,
  1.53610148e-02f, 4.03828844e-02f, 1.06532149e-01f, 1.07423052e-01f, 1.00055970e-01f, 8.96749198e-02f, -3.86013761e-02f, 1.51043490e-01f, 3.30654457e-02f, -1.44992978e-03f,
  -4.30448920e-01f, 4.09272850e-01f, 1.26795799e-01f, 3.37355971e-01f, -2.21962616e-01f, -1.08474098e-01f, 8.68861098e-03f, 5.84354326e-02f, -1.20096626e-02f, 4.46881577e-02f,
  -6.40344247e-03f, -2.63818819e-02f, 1.58125654e-01f, 3.31934601e-01f, 2.06703171e-01f, 2.51634657e-01f, 1.64436236e-01f, 4.78342623e-02f, 2.02742577e-01f, 9.43025574e-02f,
  1.74158856e-01f, 1.48849487e-01f, 3.04664344e-01f, 8.49700943e-02f, 7.22937733e-02f, 4.34723794e-02f, 1.52578562e-01f, 1.45552427e-01f, 1.30875558e-01f, 1.01296440e-01f,
  -1.77195251e-01f, -4.39498164e-02f, -1.17573738e-01f, 5.40855862e-02f, 4.77109402e-02f, -1.81830093e-01f, -1.24155261e-01f, 3.97813842e-02f, 8.65861773e-02f, 7.77922049e-02f,
  3.86568233e-02f, -2.15227306e-02f, -5.17156161e-02f, 7.02044666e-02f, -1.14421830e-01f, 3.62859853e-02f, -6.47739395e-02f, 4.60490808e-02f, 3.73647474e-02f, -1.15542024e-01f,
  4.17824015e-02f, -7.14540575e-03f, 7.86261111e-02f, 1.21011160e-01f, 1.08054720e-01f, 1.58194441e-03f, -1.30744511e-02f, -1.34977490e-01f, 1.30352564e-02f, 2.82521192e-02f,
  4.63515986e-04f, 1.23970315e-01f, -7.32137030e-03f, -3.01218852e-02f, 1.03740312e-01f, -3.58188758e-03f, -3.87821831e-02f, -3.37912813e-02f, 1.27459854e-01f, 7.16664791e-02f,
  -4.29510884e-02f, -5.75929321e-02f, -5.96190579e-02f, 1.71104278e-02f, -1.28392223e-02f, -8.23473185e-02f, -4.44019772e-03f, -5.58092780e-02f, -6.71859756e-02f, -1.03140779e-01f,
  1.19940534e-01f, -2.66239066e-02f, -4.74545509e-02f, -7.57988393e-02f, -1.04631800e-02f, 9.50947702e-02f, 4.87495959e-02f, 9.11343098e-02f, 6.87954724e-02f, -2.54305396e-02f,
  9.75036174e-02f, 2.84114689e-01f, 1.86330248e-02f, -1.51601911e-01f, -6.51768148e-02f, -1.73320938e-02f, 6.16814867e-02f, 3.51459859e-03f, 1.07280016e-01f, -4.19563577e-02f,
  -6.19226694e-02f, -9.01334807e-02f, -6.50608391e-02f, -7.25046396e-02f, 1.18805445e-03f, 1.65781796e-01f, 6.04928322e-02f, 1.12197757e-01f, 1.30275683e-02f, -5.86417504e-02f,
  4.50414866e-02f, 2.66999211e-02f, 9.46900174e-02f, -2.65317596e-02f, -6.96636587e-02f, 3.75228226e-02f, -6.69120401e-02f, -2.05839530e-01f, -3.75934057e-02f, 2.97338106e-02f,
  -1.22822657e-01f, -1.87645182e-01f, -2.68710077e-01f, -1.83807418e-01f, 5.62238693e-02f, -4.79226619e-01f, -3.56065035e-01f, -1.27214566e-01f, 1.01606920e-01f, 1.36008322e-01f,
  -3.06238141e-02f, 9.33069959e-02f, 1.91469043e-01f, -3.16522539e-01f, -3.08736295e-01f, 3.05179991e-02f, -4.76346910e-01f, -2.79062003e-01f, 1.11193269e-01f, -2.04636633e-01f,
  -1.21615887e-01f, -1.56155407e-01f, -1.63228109e-01f, 6.93356991e-02f, -2.40291625e-01f, 2.88441014e-02f, 1.93381310e-01f, 1.22907139e-01f, -2.02913716e-01f, 3.62862200e-02f,
  -6.72267079e-02f, 2.16733962e-01f, 4.03962620e-02f, -8.36654231e-02f, -1.20432489e-01f, -3.24333943e-02f, -1.17298916e-01f, -5.90570718e-02f, 5.13879210e-02f, -6.01298036e-03f,
  6.01226427e-02f, 5.31934947e-02f, -3.66132893e-02f, 6.92938641e-02f, -4.52217869e-02f, -1.80307217e-02f, 6.42218366e-02f, -3.22267525e-02f, 1.03626169e-01f, -6.55749738e-02f,
  6.14575781e-02f, -1.09750638e-02f, -4.59010378e-02f, 2.46434197e-01f, 3.78242247e-02f, 2.72045024e-02f, -5.02021611e-02f, -5.86406980e-03f, -1.14612080e-01f, 4.99258675e-02f,
  7.58143589e-02f, -1.46506689e-02f, -8.45549852e-02f, 4.21305100e-04f, 2.68940013e-02f, 3.62273455e-02f, 1.66997369e-02f, 7.79720545e-02f, 3.32191512e-02f, -5.48880501e-03f,
  4.75490130e-02f, -7.29017425e-03f, 5.02110906e-02f, -1.31961241e-01f, -1.67949080e-01f, 1.64168119e-01f, -3.30265388e-02f, 1.17099034e-02f, -1.21521778e-01f, -5.95151000e-02f,
  1.66143045e-01f, -8.34988877e-02f, 6.23293556e-02f, -2.18721479e-02f, -2.06279725e-01f, 1.33074000e-02f, 9.61345807e-02f, -1.49656162e-01f, 5.69717139e-02f, -1.05876461e-01f,
  -1.23318583e-02f, 1.22597933e-01f, 9.82148722e-02f, 1.20066563e-02f, -2.66661029e-02f, -6.38192073e-02f, -8.51119906e-02f, -1.38019890e-01f, -5.19861393e-02f, 9.18375235e-03f,
  -4.99000587e-02f, -3.63443755e-02f, 2.35786978e-02f, 8.67826529e-05f, -1.22286305e-02f, -8.68000016e-02f, 9.61549729e-02f, 8.31880644e-02f, -5.54770650e-03f, 3.36033218e-02f,
  9.99330506e-02f, 8.54949467e-03f, 3.39874774e-02f, 5.42120785e-02f, -2.00885497e-02f, 1.21761315e-01f, 5.05395699e-03f, 7.45702013e-02f, -3.73822600e-02f, 4.33572344e-02f,
  7.36114904e-02f, 9.67295840e-02f, 3.52972984e-01f, -1.48625538e-01f, 5.91906207e-03f, 7.77773559e-02f, -2.49842647e-02f, -9.30250138e-02f, -2.01689467e-01f, 6.46962784e-03f,
  -1.36562690e-01f, 2.29650483e-01f, -6.22791275e-02f, -1.38641164e-01f, -2.31558159e-01f, -2.10857436e-01f, -1.53179675e-01f, 5.58640398e-02f, -8.81147310e-02f, -1.95630357e-01f,
  -2.04194456e-01f, -4.51025128e-01f, -7.20670000e-02f, -2.80969054e-01f, 1.04503252e-01f, 1.52660206e-01f, -1.42759472e-01f, 1.26457229e-01f, 2.37498358e-02f, -5.51273394e-03f,
  1.91586837e-02f, -1.27659827e-01f, 2.65463796e-02f, 3.23854685e-02f, -2.75142025e-02f, 1.97615102e-02f, 6.99923038e-02f, -1.10372692e-01f, -6.77327858e-03f, -2.39350945e-02f,
  3.96598652e-02f, 2.13152114e-02f, -2.26055067e-02f, -7.73327723e-02f, 6.24390841e-02f, -1.42544229e-02f, 1.32027671e-01f, 1.33943677e-01f, 3.63357887e-02f, 1.61206126e-01f,
  3.76423001e-02f, 2.28400245e-01f, 3.10185924e-02f, 7.40288645e-02f, -4.63247895e-02f, 7.90658072e-02f, 9.09403060e-03f, 1.01145923e-01f, 1.02039687e-01f, -8.01217705e-02f,
  7.09990263e-02f, -4.06365283e-02f, 1.07040130e-01f, 4.21109535e-02f, -1.41324192e-01f, -8.97899212e-04f, -9.17823911e-02f, -1.05815912e-02f, -6.37120306e-02f, 5.99992201e-02f,
  -8.48839208e-02f, 8.62309709e-03f, -1.35092169e-01f, -1.33657962e-01f, 1.10295583e-02f, 1.89241897e-02f, -3.83721404e-02f, -8.61766487e-02f, -4.42225672e-02f, 5.72725609e-02f,
  -5.02312370e-02f, -8.39640275e-02f, -1.13474518e-01f, -4.80055325e-02f, -1.73085239e-02f, 9.77838691e-03f, 5.45717850e-02f, 4.25467938e-02f, -5.84403658e-03f, 1.73622333e-02f,
  -8.44611004e-02f, -2.09850252e-01f, -1.18253328e-01f, -1.47423241e-02f, -6.55761063e-02f, 8.05459023e-02f, -1.37750804e-01f, 6.52097836e-02f, 8.89065787e-02f, -3.57446261e-02f,
  6.83288053e-02f, 7.69541133e-03f, 1.48905680e-01f, -1.34592839e-02f, 2.26501785e-02f, -8.42801034e-02f, 1.16147194e-02f, 1.50748178e-01f, 6.48952127e-02f, 8.17079246e-02f,
  1.21648416e-01f, -6.34692088e-02f, 5.80567904e-02f, 3.06538716e-02f, -6.27541840e-02f, 5.10439426e-02f, -9.61644517e-04f, 1.07520618e-01f, -1.29859732e-03f, 5.51329739e-02f,
  3.58261198e-01f, 2.42418811e-01f, 8.44716281e-02f, 3.16190869e-01f, 2.17502519e-01f, -2.16709897e-01f, 1.15934551e-01f, 2.02976659e-01f, 4.64407414e-01f, 5.31521738e-02f,
  -1.35032520e-01f, 2.54028797e-01f, -6.59311786e-02f, 9.42610577e-02f, -5.50987005e-01f, -2.30503261e-01f, -1.61665618e-01f, 7.53040016e-02f, 1.43602118e-01f, 1.10808440e-01f,
  6.21270761e-03f, -2.90414870e-01f, -1.97626010e-01f, -5.97337447e-02f, 2.97171772e-01f, 2.10870907e-01f, -3.73351038e-01f, 1.15381248e-01f, -9.22578499e-02f, 4.67368849e-02f,
  1.26281217e-01f, 2.43577361e-01f, 5.67946658e-02f, 1.33258864e-01f, 9.42321494e-03f, -4.01072986e-02f, -1.01327803e-03f, -4.49391864e-02f, -1.01240547e-02f, 6.17440008e-02f,
  1.80281565e-01f, -8.86585936e-02f, 4.89016399e-02f, -5.48817627e-02f, 2.00789988e-01f, 1.15398958e-01f, 1.25715479e-01f, 7.93218836e-02f, 1.09157756e-01f, 7.47354329e-02f,
  5.50637543e-02f, 1.54897332e-01f, 1.15405135e-02f, 3.73331197e-02f, -3.37953493e-02f, 8.43256041e-02f, -1.06678098e-01f, -4.03662585e-02f, -1.99615359e-02f, 5.36089800e-02f,
  -6.97777718e-02f, -1.03469186e-01f, -1.60753161e-01f, 3.74691524e-02f, 7.74678662e-02f, 1.34774297e-01f, 3.03410254e-02f, -2.11638082e-02f, 2.19202787e-02f, -7.44972453e-02f,
  6.40083253e-02f, -2.41356362e-02f, 9.36675891e-02f, 5.63497804e-02f, -3.88345085e-02f, 1.14383996e-02f, -9.70655531e-02f, 9.55428183e-03f, 1.32810667e-01f, -1.48602743e-02f,
  -6.48494661e-02f, -3.77811529e-02f, 5.93495555e-02f, 8.06313008e-02f, -3.03306850e-03f, -9.40898433e-03f, 4.08380143e-02f, 6.87230751e-02f, 9.66834798e-02f, -2.89702099e-02f,
  -7.44288787e-02f, -2.73048133e-01f, -8.78462493e-02f, 9.24326107e-02f, 7.08857104e-02f, -8.36235657e-02f, -1.29358042e-02f, 6.29574433e-02f, -2.60521658e-02f, 1.67202950e-02f,
  -6.41936511e-02f, 2.06593517e-02f, 7.78792286e-03f, 3.39465700e-02f, -1.14842631e-01f, -5.80857024e-02f, -1.10468037e-01f, -1.01914145e-01f, -2.09298328e-01f, -8.72007832e-02f,
  -4.18336503e-02f, 6.13232367e-02f, 3.40203792e-02f, -2.39933636e-02f, -7.73194209e-02f, -4.09374125e-02f, -1.09507702e-02f, 1.79319214e-02f, -1.24712726e-02f, 5.03587127e-02f,
  7.08933920e-03f, -3.07009339e-01f, -2.97576576e-01f, -1.40723348e-01f, 1.06576875e-01f, 1.62988111e-01f, -1.18989527e-01f, 1.11111319e-02f, -2.23892778e-01f, 1.01748563e-01f,
  5.31933233e-02f, -2.10297346e-01f, -2.88224250e-01f, -1.12967692e-01f, -8.23725536e-02f, -3.67727846e-01f, 1.12502389e-01f, 4.33470942e-02f, -1.53418913e-01f, 6.90318123e-02f,
  -3.88363702e-03f, 1.64599836e-01f, -2.13274896e-01f, 1.96691200e-01f, 1.49165004e-01f, 1.75633162e-01f, 2.22418293e-01f, 9.61598456e-02f, 2.57810771e-01f, 5.75480647e-02f,
  1.91699322e-02f, -1.38262153e-01f, -1.17408209e-01f, 9.17977560e-03f, 5.19702174e-02f, 1.34433165e-01f, 1.03445888e-01f, 2.57886704e-02f, 1.90749355e-02f, -5.07960469e-02f,
  4.78146737e-03f, 3.89974341e-02f, 5.39714061e-02f, 5.53276315e-02f, 4.08542864e-02f, 2.93342699e-03f, -1.32640079e-01f, -1.01190163e-02f, -1.34880692e-01f, -9.71144512e-02f,
  -1.21105410e-01f, -1.12185162e-02f, 4.61354181e-02f, -1.22741135e-02f, -9.91833434e-02f, 1.78811885e-02f, 1.65625680e-02f, -3.81482355e-02f, 9.23119411e-02f, 2.21352037e-02f,
  1.07959941e-01f, 1.60827786e-01f, 8.12431127e-02f, -8.69772211e-02f, -5.89514412e-02f, -4.23985086e-02f, -1.69849340e-02f, -2.11507678e-02f, -1.39791798e-02f, 4.87328507e-03f,
  -4.88675684e-02f, 1.34734176e-02f, -5.72986007e-02f, 4.32145074e-02f, 7.13864043e-02f, -1.91679765e-02f, 4.81351875e-02f, 1.35853868e-02f, -7.46069700e-02f, -5.55402786e-02f,
  8.22657533e-03f, 9.39439833e-02f, -5.21852449e-02f, 8.36753845e-03f, 6.61223084e-02f, 6.43530861e-02f, 9.28110480e-02f, 4.49038893e-02f, -7.39170685e-02f, -6.39013201e-02f,
  7.56967142e-02f, 3.52967680e-02f, -3.86473835e-02f, -5.65525983e-03f, -9.79401767e-02f, 9.51005146e-02f, 3.23622525e-02f, -5.60962334e-02f, 3.82252224e-02f, 1.54836243e-02f,
  1.18564755e-01f, 1.54520929e-01f, 6.18023351e-02f, 1.23748899e-01f, 7.33537376e-02f, -6.98163919e-03f, 1.21434473e-01f, 1.21311150e-01f, 5.59385829e-02f, -2.69062575e-02f,
  6.65279031e-02f, 2.76043676e-02f, 6.52024373e-02f, 3.77025828e-02f, 1.00846544e-01f, 5.61446100e-02f, 1.27248898e-01f, 1.50036756e-02f, -7.80855538e-03f, -7.74655193e-02f,
  -1.69452578e-01f, 1.19222768e-01f, -4.87513021e-02f, -1.77456245e-01f, -1.25931159e-01f, -1.58132687e-01f, -2.68311203e-01f, 1.55077660e-02f, 8.97748396e-02f, 1.33921623e-01f,
  1.72159150e-02f, 1.23461775e-01f, 1.84597135e-01f, -2.18904838e-01f, 1.63471594e-01f, 1.19701102e-01f, -1.70888782e-01f, -1.23420008e-01f, 6.24344163e-02f, -6.36111796e-02f,
  2.65916344e-02f, -1.27672791e-01f, -1.72724098e-01f, 1.25191761e-02f, -3.05507034e-01f, -9.03408080e-02f, -1.54555112e-01f, -1.32853359e-01f, -2.74261415e-01f, -2.55859215e-02f,
  -3.05923581e-01f, -2.20512018e-01f, -2.35316996e-02f, -1.81683138e-01f, -1.09493546e-01f, 8.71288031e-02f, -1.11485898e-01f, -1.51037602e-02f, 1.98329613e-02f, 6.85581118e-02f,
  2.76913866e-02f, 9.16186944e-02f, -2.45332513e-02f, 1.35899201e-01f, -7.06187487e-02f, -6.45582154e-02f, -1.88281581e-01f, -2.86438137e-01f, 2.19417159e-02f, 9.51135978e-02f,
  1.12260260e-01f, -4.97125499e-02f, -2.13646561e-01f, -8.24528188e-02f, -1.31488457e-01f, -1.98358700e-01f, 2.86573227e-02f, -4.62043174e-02f, -1.14522740e-01f, -1.80876181e-02f,
  2.56703608e-02f, 1.04852289e-01f, 5.65592460e-02f, 6.20078370e-02f, 1.89362206e-02f, -2.68602953e-03f, -5.08697890e-03f, -4.34398502e-02f, -7.36876279e-02f, -4.00670618e-02f,
  -4.92706522e-02f, 2.81688068e-02f, 1.27914436e-02f, -3.51268165e-02f, 3.97128090e-02f, 7.47743621e-02f, -1.81257240e-02f, -9.19089653e-03f, -8.31594691e-04f, -6.98200241e-02f,
  -3.71569693e-02f, -2.77636275e-02f, 2.19585747e-03f, -4.55511138e-02f, 8.33423287e-02f, 3.29123973e-03f, -4.74957339e-02f, 2.67978292e-03f, -1.22019760e-02f, -2.80328859e-02f,
  -1.85642079e-01f, -1.44509941e-01f, 4.91422489e-02f, -1.25469521e-01f, -7.69274449e-03f, 5.58795892e-02f, 2.19010580e-02f, 6.56392202e-02f, -5.24891205e-02f, 1.08278558e-01f,
  -1.14779569e-01f, -4.99294139e-02f, -1.46157801e-01f, -1.90824103e-02f, 1.29950553e-01f, 1.17717743e-01f, -3.25457454e-02f, -8.99193138e-02f, -1.31606981e-01f, 9.17283520e-02f,
  1.99823864e-02f, 4.33338545e-02f, 7.97012225e-02f, -6.49578869e-02f, -6.73086091e-04f, -6.75296932e-02f, 1.29269175e-02f, -1.19407708e-02f, -1.12571858e-01f, -1.53215853e-02f,
  -2.59640273e-02f, -1.09657515e-02f, 1.01503581e-01f, -2.05546081e-01f, 2.52858736e-03f, 1.03688054e-01f, -1.05288990e-01f, 2.36606542e-02f, -2.96336114e-01f, 1.87773898e-01f,
  -1.31887600e-01f, 1.12577148e-01f, -1.89069033e-01f, -2.34337181e-01f, -4.34651315e-01f, -4.27657247e-01f, -1.37314439e-01f, 1.10723190e-01f, -2.51250088e-01f, 1.82186574e-01f,
  -7.47754499e-02f, -3.53953779e-01f, -8.06048512e-02f, 4.31885868e-02f, 6.35053515e-02f, 3.42448413e-01f, 1.27633825e-01f, 1.99044254e-02f, 3.31577539e-01f, -1.33781374e-01f,
  -1.53074846e-01f, -1.63205028e-01f, 8.84520784e-02f, 2.57169288e-02f, 1.04296833e-01f, 9.41445306e-03f, 6.02362268e-02f, -1.11942321e-01f, -4.69575860e-02f, 4.84831519e-02f,
  3.73187624e-02f, -1.83771159e-02f, -3.28207426e-02f, -1.42018273e-01f, 3.86666395e-02f, -7.15755299e-02f, 1.65648498e-02f, -2.78602634e-02f, -7.45560750e-02f, 9.89812762e-02f,
  2.14647036e-02f, 3.40796039e-02f, 6.87263459e-02f, 8.15033913e-02f, 3.85046043e-02f, 2.81995572e-02f, 4.68892679e-02f, 1.18281834e-01f, 3.77774835e-02f, 5.44246547e-02f,
  -3.65537070e-02f, 2.42765006e-02f, -6.91720396e-02f, -4.43003699e-02f, -9.25270692e-02f, -1.04144678e-01f, -1.98100075e-01f, 1.74503122e-03f, -4.02004011e-02f, -2.27566008e-02f,
  1.54905207e-02f, -8.65472183e-02f, -1.23441473e-01f, 8.60044584e-02f, 2.05356143e-02f, -8.37446079e-02f, 2.50468845e-03f, 2.75074914e-02f, 4.33663987e-02f, -2.05048416e-02f,
  -1.72580197e-01f, -5.11253104e-02f, -5.39315715e-02f, -5.79386204e-03f, -1.40194148e-01f, 6.85598701e-02f, 5.01643121e-02f, -9.65977460e-02f, 2.69667841e-02f, -6.82767713e-03f,
  8.94382074e-02f, 1.38611898e-01f, 1.49843609e-02f, -6.65801466e-02f, -8.95515084e-02f, -7.50177875e-02f, -1.82151034e-01f, 7.65775144e-02f, -5.36363758e-02f, -7.79138580e-02f,
  1.28672138e-01f, 1.23722367e-01f, 5.87562211e-02f, 5.09663485e-02f, 1.37087973e-02f, 4.63630706e-02f, -4.23385482e-03f, 7.36380508e-03f, 6.36764541e-02f, 2.10612297e-01f,
  2.77177058e-02f, 6.51547462e-02f, -1.30653590e-01f, -1.82386488e-02f, -1.84774343e-02f, 6.21703453e-02f, 1.67458430e-01f, 1.57658160e-01f, 1.41534777e-02f, 6.48086965e-02f,
  2.88887024e-01f, -1.97322592e-01f, -2.94616044e-01f, -1.40970737e-01f, -2.13732347e-02f, 3.04085016e-01f, 4.26528782e-01f, -1.31821424e-01f, -9.90525112e-02f, 2.51202732e-01f,
  3.77932698e-01f, 2.96291299e-02f, 3.25690150e-01f, 3.76656473e-01f, 1.08023517e-01f, 1.53438792e-01f, 2.36292899e-01f, 2.36138105e-01f, -1.31791219e-01f, 1.20002657e-01f,
  1.63981035e-01f, 3.61601293e-01f, 1.12181649e-01f, -2.07874268e-01f, 1.56783998e-01f, -3.36429328e-01f, -7.17357844e-02f, -8.70514587e-02f, -3.23328711e-02f, 6.75560832e-02f,
  2.83425376e-02f, -6.43656328e-02f, -1.04438141e-02f, -2.98912395e-02f, -1.01265954e-02f, 2.57415716e-02f, -4.08022344e-04f, 3.48250680e-02f, -1.26671180e-01f, 4.69594859e-02f,
  -2.84605511e-02f, -6.17149882e-02f, -8.09762552e-02f, 6.36772141e-02f, -4.04812805e-02f, -1.29469022e-01f, -9.30792466e-02f, 2.22960543e-02f, -1.68274984e-01f, 9.13677290e-02f,
  2.51881704e-02f, -7.15864748e-02f, 3.32262963e-02f, -1.10290736e-01f, 7.32249441e-03f, -6.62735254e-02f, -4.70294133e-02f, -5.74567588e-03f, -3.63372490e-02f, -6.78161308e-02f,
  -3.02322628e-03f, 7.04349950e-02f, 1.07646756e-01f, 4.77970503e-02f, -3.96505781e-02f, -9.28273723e-02f, 8.89273509e-02f, 2.78902091e-02f, -7.49179795e-02f, 7.39324316e-02f,
  1.25765577e-02f, 1.28078517e-02f, 7.45602250e-02f, 1.07602932e-01f, 1.43628582e-01f, 4.44324836e-02f, 1.63190767e-01f, 2.32214835e-02f, 8.65981877e-02f, -2.10833531e-02f,
  8.25265199e-02f, -3.31097245e-02f, -3.61017585e-02f, 3.83834653e-02f, 4.74120900e-02f, 3.85227315e-02f, 8.03271979e-02f, 6.89525083e-02f, 1.10639008e-02f, 4.25673425e-02f,
  -4.63037491e-02f, -1.23724334e-01f, -6.11054488e-02f, 2.81878542e-02f, -1.22074932e-01f, -6.15138449e-02f, -1.81747843e-02f, -6.17615841e-02f, 1.61091574e-02f, 6.99322224e-02f,
  -1.10944077e-01f, -8.66061226e-02f, -4.25427221e-02f, -1.55487098e-03f, -3.78054976e-02f, 3.45590897e-02f, 4.69239242e-03f, -1.41376138e-01f, -9.51678902e-02f, -8.74607116e-02f,
  -7.18215620e-03f, -1.16992101e-01f, -5.09060137e-02f, -3.92590985e-02f, 1.60226449e-02f, -1.84560642e-02f, -8.77608210e-02f, -1.69352982e-02f, -8.38712975e-02f, -6.16755150e-02f,
  1.68220192e-01f, 7.55870193e-02f, -1.69510096e-01f, 1.49411902e-01f, -1.43956885e-01f, -8.96295384e-02f, -1.04862176e-01f, 1.47495955e-01f, -3.07882965e-01f, 1.44229606e-01f,
  1.81360096e-01f, -8.22444856e-02f, 2.34277640e-02f, 3.21095020e-01f, 2.28620604e-01f, -6.86271442e-03f, 2.74255514e-01f, 6.99052662e-02f, -6.07249252e-02f, 2.72396863e-01f,
  2.05984116e-01f, 4.32438642e-01f, 1.24690242e-01f, 2.33634755e-01f, 9.48712230e-02f, 1.12551607e-01f, 2.11025909e-01f, -7.83105120e-02f, 3.04653674e-01f, -7.51125515e-02f,
  -4.18089442e-02f, 4.27575298e-02f, -4.13597375e-02f, -1.10882454e-01f, 1.60187915e-01f, 1.49948582e-01f, -8.40577483e-02f, 4.52409759e-02f, -1.07918233e-01f, -1.07064778e-02f,
  -6.02164529e-02f, 1.40154790e-02f, 1.09987251e-01f, -3.04201040e-02f, -1.23236030e-02f, -1.39453799e-01f, -1.26254737e-01f, -1.10877372e-01f, -1.08086109e-01f, 3.80183682e-02f,
  -8.82046446e-02f, -4.88590635e-02f, -3.87681164e-02f, 1.10138375e-02f, -3.82383391e-02f, -2.81074774e-02f, -5.02663404e-02f, -4.40457575e-02f, -7.75311068e-02f, 8.30411538e-02f,
  7.94770047e-02f, 6.47938326e-02f, 6.64601997e-02f, -4.63833325e-02f, -2.60301642e-02f, 8.24839249e-03f, 4.55124862e-02f, 3.05407378e-03f, -7.69330189e-02f, 6.94501847e-02f,
  6.52476167e-03f, 9.91469994e-02f, -2.61496864e-02f, -5.48471250e-02f, 1.60855904e-01f, -3.78819518e-02f, 2.82794628e-02f, 5.37872612e-02f, -4.37235720e-02f, -1.03891626e-01f,
  -3.11313942e-02f, -8.61793682e-02f, -7.61239510e-03f, -3.74294594e-02f, 2.43425127e-02f, 8.30546580e-03f, 4.07324843e-02f, 5.36617562e-02f, -1.94785640e-01f, 1.39946388e-02f,
  1.00656025e-01f, 2.17977881e-01f, 1.13343005e-03f, -1.16838217e-01f, -4.87733223e-02f, 9.79428217e-02f, 3.82916629e-02f, 7.79733211e-02f, 1.00683898e-01f, 4.61525321e-02f,
  1.03505015e-01f, -2.78199017e-02f, 2.54100636e-02f, -2.51344722e-02f, -4.37890962e-02f, 3.53206992e-02f, 2.00608522e-02f, -6.54800683e-02f, -6.10890388e-02f, 1.45048961e-01f,
  -8.39171112e-02f, -6.70679733e-02f, -5.49259372e-02f, -1.37366384e-01f, 2.23701466e-02f, -8.98063648e-03f, 7.73716066e-03f, 1.94866899e-02f, 5.78831285e-02f, -6.53407350e-02f,
  -2.60639936e-01f, 2.87103951e-01f, -1.61420852e-01f, 2.27906480e-01f, -4.08317894e-01f, 1.03526399e-01f, 4.06648189e-01f, -2.71255765e-02f, 7.51305297e-02f, 3.78821850e-01f,
  1.17006205e-01f, 8.05720314e-02f, 1.94951639e-01f, 3.23209077e-01f, -2.55768299e-01f, 3.16002518e-01f, 1.12330832e-01f, 2.89969653e-01f, -1.65230734e-03f, -6.39751777e-02f,
  -1.11844182e-01f, 7.62046129e-02f, -1.93723291e-02f, -4.59262319e-02f, -2.05100924e-02f, -6.93071857e-02f, -9.25572142e-02f, -1.94814295e-01f, 4.15540673e-02f, -4.32338677e-02f,
  2.72812378e-02f, 2.36389022e-02f, -5.93645759e-02f, 1.31249920e-01f, 6.40422106e-02f, 1.57599095e-02f, 3.16396207e-02f, -1.85766537e-02f, -5.10977805e-02f, 6.52391091e-02f,
  1.74626380e-01f, -5.84136210e-02f, 1.45413458e-01f, -1.22427300e-01f, -1.31548196e-01f, -1.30691126e-01f, 1.33954585e-01f, 2.44856980e-02f, 1.04822136e-01f, -7.84880221e-02f,
  -1.93705875e-02f, 5.40416799e-02f, 8.70921090e-02f, 1.78719699e-01f, -7.22231418e-02f, 6.52306974e-02f, 1.22338399e-01f, 3.54793333e-02f, 1.08871760e-03f, -1.89481527e-02f,
  -8.75101909e-02f, 8.75865296e-02f, -1.05839238e-01f, -1.57316495e-02f, -6.29657805e-02f, 2.75512356e-02f, -1.15991637e-01f, 6.31313026e-02f, -8.61780439e-03f, 2.25051902e-02f,
  8.15979317e-02f, -7.18277171e-02f, 5.37352972e-02f, -8.43410566e-03f, -1.49696032e-02f, 4.53818589e-02f, -3.01366895e-02f, 4.50254902e-02f, 6.12285882e-02f, -1.36421606e-01f,
  6.84351698e-02f, -7.66095892e-02f, 3.86578850e-02f, 1.29968002e-01f, 9.78864804e-02f, -1.14368670e-01f, -5.83175756e-02f, 4.28357050e-02f, 1.26388326e-01f, -8.71463344e-02f,
  7.23808035e-02f, 5.74061312e-02f, 9.83162969e-02f, 2.02057883e-01f, 1.28038973e-01f, 1.75775792e-02f, 1.23360129e-02f, 2.22311113e-02f, -8.64361823e-02f, 2.56903134e-02f,
  -2.11845543e-02f, 1.23082854e-01f, -6.15581796e-02f, -1.16669536e-01f, -1.12350490e-02f, 3.92491668e-02f, 1.97665527e-01f, -5.65459579e-02f, 9.09398720e-02f, -3.40535827e-02f,
  -3.88770737e-02f, -1.90842978e-03f, 1.09445602e-02f, 1.23294562e-01f, 5.14006726e-02f, 1.01565786e-01f, -1.41007975e-01f, 7.05686882e-02f, -1.22333996e-01f, 9.22280848e-02f,
  -7.98252702e-01f, 2.11516947e-01f, -2.11005464e-01f, -1.52867357e-03f, -1.75303027e-01f, -1.90581501e-01f, 2.62332838e-02f, -1.32150963e-01f, -7.34111443e-02f, 2.73892850e-01f,
  1.48315385e-01f, -3.59306335e-02f, 2.17068151e-01f, 2.49926791e-01f, -3.87553036e-01f, 2.07126111e-01f, -7.81072602e-02f, 1.15562184e-02f, 6.52627721e-02f, -1.36378750e-01f,
  2.99847610e-02f, 2.26732031e-01f, -4.34404947e-02f, 1.42081097e-01f, -5.97394956e-03f, -3.87199894e-02f, 4.12414335e-02f, 1.23004258e-01f, -1.54344589e-02f, 1.07523771e-02f,
  -2.69419968e-01f, -1.37696326e-01f, -1.87019035e-02f, -1.29063293e-01f, -1.73298344e-01f, -4.68856916e-02f, -7.13363811e-02f, 6.94315657e-02f, 4.66954820e-02f, -1.93969253e-02f,
  5.27424039e-03f, -6.75216392e-02f, 2.22466830e-02f, 9.40016285e-02f, -4.14598100e-02f, 1.69078168e-02f, -7.80945122e-02f, 2.34112935e-03f, 3.97677124e-02f, -1.08119538e-02f,
  -2.74384040e-02f, -6.86445013e-02f, -4.79072705e-03f, 2.34042201e-02f, -2.26491299e-02f, 4.24500592e-02f, 1.11563876e-01f, -2.09272280e-02f, -1.02520585e-01f, -5.89242876e-02f,
  -5.37866401e-03f, 6.45163208e-02f, 5.22640981e-02f, -4.59328517e-02f, 5.23012727e-02f, -2.98802145e-02f, -5.15738316e-02f, -7.44182095e-02f, 3.54477242e-02f, 4.27698903e-02f,
  -6.70059770e-02f, -2.84153186e-02f, -3.47111747e-02f, -2.51339860e-02f, 5.21052442e-02f, -1.06669828e-01f, 1.31427543e-02f, -1.08813867e-02f, -4.98972237e-02f, -4.52563539e-02f,
  -4.02060598e-02f, 5.00452183e-02f, 5.30979112e-02f, 6.27074018e-02f, -7.15634599e-02f, -1.32152308e-02f, -2.65919720e-03f, -7.11491182e-02f, -8.18811283e-02f, -5.18724397e-02f,
  -5.11205077e-01f, -4.08898175e-01f, 3.30461860e-02f, -1.96596935e-01f, 4.46385108e-02f, -4.94773723e-02f, 5.49285188e-02f, 2.89006047e-02f, 2.84786876e-02f, -6.98048901e-03f,
  -9.09883305e-02f, -1.64986625e-02f, -1.39593333e-01f, 1.79699622e-02f, 7.18639605e-03f, 6.07878566e-02f, -8.63851979e-02f, -8.14649835e-02f, -2.20686391e-01f, -4.90669049e-02f,
  -1.15283646e-01f, -7.57921413e-02f, -8.66152439e-03f, 8.79719760e-03f, 1.47846490e-02f, 2.16652616e-03f, 1.38135133e-02f, -4.89777848e-02f, -2.47859173e-02f, 6.09645844e-02f,
  -2.10583061e-02f, -3.08780134e-01f, -1.31259426e-01f, 4.00069952e-02f, 9.27141532e-02f, -5.67654036e-02f, -1.16618879e-01f, -7.79809430e-02f, -2.69677192e-01f, -1.84817627e-01f,
  7.09693283e-02f, 2.44019568e-01f, -1.86964467e-01f, 1.61279693e-01f, 4.07259554e-01f, -1.13957308e-01f, 1.04584612e-01f, 9.85412896e-02f, -1.14884757e-01f, -6.56786859e-02f,
  1.01520605e-01f, 2.09636122e-01f, 1.83010876e-01f, 1.37835175e-01f, 1.35846823e-01f, 1.10606417e-01f, 3.19846272e-01f, 1.21679962e-01f, 2.93535113e-01f, 2.37143174e-01f,
  -3.34572345e-02f, -8.61411989e-02f, -3.79801691e-02f, 2.64171697e-02f, -1.47473127e-01f, -2.97861286e-02f, 1.31590873e-01f, 3.04805879e-02f, 1.31205022e-01f, -4.78691161e-02f,
  -6.16195649e-02f, 1.14401221e-01f, -3.59328203e-02f, 8.70555118e-02f, 7.26665258e-02f, -4.68205065e-02f, -7.04787485e-03f, 3.68975848e-02f, -6.03800341e-02f, -3.94558385e-02f,
  -1.66735962e-01f, -5.71970120e-02f, -6.04085177e-02f, 6.96167275e-02f, -1.32935597e-02f, -5.90586625e-02f, -4.56629544e-02f, -8.10610279e-02f, 1.37419058e-02f, -1.50704771e-01f,
  -2.45115887e-02f, 6.16254397e-02f, -1.58978984e-01f, -1.38785550e-02f, -9.07996222e-02f, 9.67768803e-02f, 1.74564391e-01f, 1.10336803e-02f, -2.14758068e-02f, -2.70326100e-02f,
  3.74575481e-02f, 1.50153324e-01f, -7.08446801e-02f, -2.64640637e-02f, 8.63738656e-02f, -3.83278057e-02f, -6.11590371e-02f, 8.44692960e-02f, -6.35345355e-02f, 4.82672043e-02f,
  6.99536279e-02f, 7.09665939e-02f, -7.94878975e-02f, 3.56730483e-02f, -2.37386320e-02f, -3.92660014e-02f, 6.97350129e-02f, -1.95636451e-02f, 3.31937373e-02f, 8.97669047e-02f,
  1.94215775e-02f, -1.78019255e-01f, -4.34838645e-02f, 5.30296983e-03f, -1.95784494e-02f, 3.11001297e-02f, 2.25878693e-02f, -3.68732102e-02f, 1.28803477e-01f, -1.26956716e-01f,
  -4.24792245e-03f, 1.20275415e-01f, 6.62868172e-02f, 7.88628459e-02f, 5.20806685e-02f, -8.33620429e-02f, 1.72340311e-02f, -2.39594113e-02f, -1.69066153e-02f, 4.14816588e-02f,
  -4.19806279e-02f, -6.29124418e-02f, -1.23763289e-02f, -2.03440059e-02f, -1.89973172e-02f, -2.96621863e-02f, 1.02387972e-01f, -1.23379566e-01f, 3.68121266e-02f, -8.01161304e-03f,
  1.46890849e-01f, -1.29721269e-01f, -1.73246175e-01f, -1.75882980e-01f, -4.08892408e-02f, -2.26482116e-02f, 2.52215331e-03f, -4.18238118e-02f, 2.87635267e-01f, 7.88280889e-02f,
  -2.31310621e-01f, 1.19378485e-01f, -1.10575669e-01f, -2.41091833e-01f, 2.36167401e-01f, 2.19017357e-01f, 1.97976768e-01f, 1.70643851e-01f, 4.12050933e-02f, -3.29267159e-02f,
  1.66753437e-02f, -4.00676485e-03f, -3.68420005e-01f, -1.42746836e-01f, -2.06584558e-01f, -1.07352138e-01f, -2.47591823e-01f, -1.71922088e-01f, -2.64699638e-01f, 3.18759424e-03f,
  -6.24985509e-02f, -1.48661891e-02f, -1.25517383e-01f, 5.84639385e-02f, -3.93065214e-02f, -1.79078635e-02f, -2.17998363e-02f, 8.75299796e-02f, 1.72818149e-03f, 2.74948105e-02f,
  7.90228546e-02f, 8.23569894e-02f, 8.54913071e-02f, 4.95256446e-02f, -2.07822565e-02f, -3.04407608e-02f, -6.69923872e-02f, -1.08313359e-01f, -1.17154390e-01f, -8.14895481e-02f,
  -6.15859292e-02f, -5.18532023e-02f, -9.07157175e-03f, 5.27366400e-02f, 9.90982819e-03f, -7.50421407e-03f, 2.26835459e-02f, 5.40629961e-03f, 1.18717194e-01f, 1.78277597e-01f,
  7.54808709e-02f, 9.83358920e-02f, 1.27392143e-01f, -7.79588893e-02f, -2.38962267e-02f, -1.51065633e-01f, 4.20043878e-02f, -2.63739545e-02f, 9.49775055e-02f, -7.88826775e-03f,
  -9.65525582e-02f, -6.53024465e-02f, -2.34822910e-02f, -4.91341650e-02f, 2.32908726e-02f, 6.38821442e-03f, 9.15604681e-02f, 1.01214707e-01f, 1.14299461e-01f, -5.68836071e-02f,
  -3.86734605e-02f, 9.14304405e-02f, -1.13194227e-01f, -2.70369444e-02f, -9.18477699e-02f, 4.43915837e-02f, 5.04821725e-03f, -7.86833763e-02f, -1.37968987e-01f, -1.57255933e-01f,
  1.09670244e-01f, 2.95037508e-01f, -1.86054048e-03f, -6.99817464e-02f, -8.80701691e-02f, -8.95509031e-03f, 9.84083340e-02f, 9.64340642e-02f, 1.10927224e-01f, 7.79618993e-02f,
  -3.39861028e-02f, 6.13487177e-02f, 3.77477333e-02f, 3.09567321e-02f, -8.64797551e-03f, 4.69301827e-02f, 4.08490673e-02f, -7.01287836e-02f, 1.14831641e-01f, -1.05065592e-01f,
  -1.15383498e-01f, 9.78764426e-03f, 6.54768273e-02f, 5.85579276e-02f, 4.65084650e-02f, -7.14466348e-03f, 1.23629563e-01f, -3.99383791e-02f, 7.41392896e-02f, 1.39311850e-01f,
  7.54756182e-02f, -2.08848849e-01f, 2.01043636e-02f, -1.28467485e-01f, 4.35972363e-02f, -1.08738676e-01f, -1.65568199e-02f, -1.79084241e-01f, -8.46337974e-02f, -2.16784447e-01f,
  1.75784547e-02f, 1.09614439e-01f, 1.45361781e-01f, -2.63950497e-01f, 3.75405222e-01f, 2.69343436e-01f, -2.09854215e-01f, 6.29106760e-02f, -8.85145564e-04f, -1.70462534e-01f,
  -1.08975224e-01f, -2.89007366e-01f, 3.05315685e-02f, -3.37524861e-01f, -2.13223994e-01f, -7.82997683e-02f, 6.04446679e-02f, 1.08354010e-01f, -3.13168079e-01f, 1.06861368e-02f,
  -1.03182204e-01f, -1.92746684e-01f, -3.57210338e-02f, -1.19523346e-01f, -1.14343256e-01f, 3.52679975e-02f, -7.71102449e-03f, 1.68601930e-01f, -1.81402676e-02f, 1.89215671e-02f,
  1.49171734e-02f, 5.79808541e-02f, -1.07405193e-01f, 8.37965161e-02f, -3.67658697e-02f, -4.18753400e-02f, -3.02398996e-03f, -3.43831405e-02f, -1.05110601e-01f, 9.53756943e-02f,
  7.07493126e-02f, 8.81227553e-02f, -1.43316910e-01f, 3.39886099e-02f, -5.47962934e-02f, -2.13826336e-02f, 4.73753028e-02f, 1.35046452e-01f, -1.15344068e-02f, -9.01805162e-02f,
  -8.81112516e-02f, 9.79219824e-02f, -1.79631803e-02f, -3.95110510e-02f, -1.16326079e-01f, 3.75317708e-02f, 2.94472091e-02f, 5.80504686e-02f, -5.32216728e-02f, 4.63001095e-02f,
  1.59916431e-02f, 3.10402410e-03f, -3.98766175e-02f, 6.46071434e-02f, -6.49276897e-02f, 3.42343040e-02f, 7.26852044e-02f, 6.24021590e-02f, -1.22230733e-02f, 1.92474108e-02f,
  3.37541886e-02f, -7.18040913e-02f, -5.42854331e-02f, 8.11605752e-02f, -6.42715069e-03f, 2.39545237e-02f, -4.21983451e-02f, -3.07958126e-02f, 6.27509058e-02f, -2.98733194e-03f,
  -5.64432070e-02f, -1.63087159e-01f, -6.47828355e-02f, -1.03939511e-01f, 6.48906529e-02f, -3.32545605e-03f, -6.36989474e-02f, 6.13903403e-02f, -4.75776866e-02f, -5.49580902e-02f,
  -4.52845618e-02f, -5.80946133e-02f, 4.07551751e-02f, 2.73237359e-02f, -2.10823417e-02f, -1.81528442e-02f, 7.58699998e-02f, 1.95596833e-02f, 8.72981623e-02f, 1.31470636e-02f,
  -1.48388753e-02f, 3.19470614e-02f, 3.96812055e-03f, -7.45342001e-02f, -5.15635386e-02f, 4.79677804e-02f, 8.20562020e-02f, 5.45137562e-02f, 4.44168523e-02f, 3.54131944e-02f,
  -3.42707753e-01f, 2.97860652e-01f, 1.85780749e-01f, -1.08726546e-01f, 1.15175113e-01f, -1.77243590e-01f, -9.59522352e-02f, 1.79621771e-01f, 3.07061285e-01f, 1.90125600e-01f,
  -3.62779386e-02f, 1.54027998e-01f, 1.87960014e-01f, 3.43950419e-03f, -2.59362996e-01f, -3.67437140e-03f, -3.18264544e-01f, -2.18021110e-01f, -7.74230585e-02f, -1.48997366e-01f,
  -9.61702839e-02f, -1.87245861e-01f, -1.65716007e-01f, 2.41955251e-01f, 1.55295148e-01f, 5.16595170e-02f, -2.30288878e-01f, 1.08012147e-01f, -9.06423628e-02f, 1.64362460e-01f,
  -9.95035172e-02f, 1.43726707e-01f, 1.93772435e-01f, 1.16131805e-01f, -1.36050195e-01f, -1.46749588e-02f, -1.42044589e-01f, 1.24989506e-02f, 1.07457370e-01f, 6.33924156e-02f,
  -2.21271291e-02f, 3.66706476e-02f, -5.51289469e-02f, 1.04195774e-01f, 1.19809620e-01f, 1.00784168e-01f, 9.25526321e-02f, -6.18525269e-03f, 1.86398089e-01f, 5.45025058e-02f,
  1.05744682e-01f, 2.79432479e-02f, -5.67937922e-03f, -1.80864334e-02f, -4.60245907e-02f, 4.12316583e-02f, -7.39693120e-02f, -9.24545676e-02f, -2.81130839e-02f, 3.45250405e-02f,
  8.13501030e-02f, 2.70009823e-02f, 1.92057312e-01f, 1.74434725e-02f, 4.75457776e-03f, 1.06730342e-01f, 7.39034936e-02f, -1.59211591e-01f, -4.81447428e-02f, -1.39998108e-01f,
  -3.23661305e-02f, 5.75044565e-02f, -3.73186953e-02f, -3.30123231e-02f, 9.80988331e-03f, 1.06773973e-02f, -7.72401784e-03f, 4.86323982e-02f, -2.05942482e-01f, -6.35967553e-02f,
  -9.15320311e-03f, -1.02882974e-01f, 9.88797471e-02f, -1.22338116e-01f, 2.36792922e-01f, -1.24313077e-02f, -1.28875449e-01f, 8.41525793e-02f, -1.27072513e-01f, -6.86722472e-02f,
  -3.44483644e-01f, -1.62612692e-01f, 3.83862667e-02f, 7.98341632e-02f, 4.28903326e-02f, -3.07298005e-02f, -5.26836701e-02f, 2.35381350e-02f, 6.76903203e-02f, 1.13000371e-01f,
  -6.42159134e-02f, -4.51359935e-02f, -1.98864639e-01f, -6.03867434e-02f, 2.01320574e-02f, -2.48257071e-02f, -5.52142672e-02f, -1.24906100e-01f, -7.93928504e-02f, -1.33734792e-01f,
  1.37518952e-03f, -7.19555318e-02f, 1.87460035e-02f, -5.56596182e-02f, -1.57961220e-01f, -1.48296691e-02f, -7.70233944e-02f, -1.17725953e-02f, -2.73330379e-02f, -5.05511127e-02f,
  1.77531660e-01f, -1.91344112e-01f, 1.85184941e-01f, -3.11301589e-01f, -1.63029563e-02f, 1.28575936e-01f, 1.88863978e-01f, -2.11412802e-01f, -3.76555592e-01f, -2.14975208e-01f,
  -1.16942979e-01f, 1.34150311e-01f, 3.44927549e-01f, -1.93006009e-01f, 3.69228542e-01f, 1.71726629e-01f, -2.28406742e-01f, -4.88616154e-02f, -1.25053048e-01f, -2.50235140e-01f,
  -1.54854059e-01f, -2.38628983e-01f, 2.53617585e-01f, -2.92365104e-01f, -3.70284133e-02f, -1.28238007e-01f, -2.64763534e-02f, 1.37670621e-01f, -2.41868839e-01f, 4.79409751e-03f,
  2.17433739e-02f, -1.18252151e-01f, 9.23367515e-02f, 1.01436218e-02f, -4.71365359e-03f, 5.79557493e-02f, 8.69846344e-02f, 2.24445954e-01f, -7.03712627e-02f, -1.20431967e-02f,
  -6.64887950e-02f, 3.18155885e-02f, -1.49659932e-01f, 1.15828179e-01f, -1.62605107e-01f, -2.65236851e-02f, -7.42345154e-02f, -2.11494323e-02f, -3.61748296e-03f, 1.09734342e-01f,
  4.55315001e-02f, 7.19561651e-02f, -7.94783533e-02f, -3.62358280e-02f, -5.24962544e-02f, -9.00709927e-02f, 2.60324553e-02f, 1.85847238e-01f, -1.47757530e-02f, -8.98282900e-02f,
  7.17566982e-02f, 6.53296858e-02f, 1.01618141e-01f, -7.31430799e-02f, 2.51016095e-02f, -3.42658646e-02f, 3.71863768e-02f, 2.72487681e-02f, -5.17714098e-02f, 4.02687863e-02f,
  -2.66350843e-02f, 4.76021394e-02f, -3.64192463e-02f, 3.52258123e-02f, -1.11176819e-02f, -3.87963690e-02f, 8.75107720e-02f, 1.99037623e-02f, -7.12539479e-02f, 5.30491844e-02f,
  3.23501043e-02f, -6.70771375e-02f, 1.70032680e-03f, 1.29080247e-02f, -2.76742829e-03f, 2.19619665e-02f, 4.24165316e-02f, -1.21711046e-02f, -1.00179827e-02f, 1.06866501e-01f,
  -4.43180017e-02f, -1.83861807e-01f, -1.04212081e-02f, -2.78078150e-02f, 1.05487518e-01f, -6.72286563e-03f, 3.85690801e-04f, -1.45349830e-01f, -4.57201526e-02f, -1.08282864e-02f,
  -1.04004048e-01f, 5.69911823e-02f, -2.91979928e-02f, -2.21616179e-02f, -1.13167569e-01f, -3.21642645e-02f, 3.36020738e-02f, 2.32503135e-02f, -6.41465141e-03f, -9.65557098e-02f,
  7.89237618e-02f, -1.67001225e-02f, -8.46988708e-03f, -4.30918150e-02f, 6.72947476e-03f, -2.28951275e-02f, 2.14993358e-02f, -1.38309181e-01f, -1.12244971e-02f, -1.71061456e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.64022565e-01f, 1.74893811e-01f, 1.53247178e-01f, 1.43935889e-01f, 1.90989524e-01f, 5.78003041e-02f, 1.76014662e-01f, 3.65872495e-02f, 7.38190413e-02f, 2.06371590e-01f,
  2.37431616e-01f, 1.34806067e-01f, 3.15655887e-01f, 2.26419836e-01f, 2.00008973e-01f, 1.20884426e-01f, 1.55577123e-01f, 1.64157718e-01f, 2.25582570e-01f, 1.42500892e-01f,
  9.38839838e-02f, 9.78639647e-02f, 1.63383886e-01f, 1.57670245e-01f, 1.77350864e-01f, 1.70742467e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.33260944e-01f, -3.97508815e-02f, -1.34625882e-01f, -1.15928307e-01f, -7.52789676e-02f, -7.84870088e-02f, -2.47222502e-02f, 5.95407970e-02f, 7.49955699e-02f, 7.75135756e-02f,
  1.96540654e-01f, 1.22530803e-01f, 1.90236583e-01f, 9.90122259e-02f, -3.15773562e-02f, 8.25785622e-02f, -2.61298865e-02f, -6.35419264e-02f, 2.65710559e-02f, -1.35850951e-01f,
  3.98023427e-02f, 9.46835801e-02f, -6.43647136e-03f, -2.15411276e-01f, -1.44951761e-01f, 1.02627419e-01f, -1.05292983e-01f, -1.46270037e-01f, -1.14017799e-02f, 8.49900618e-02f,
  -1.73881613e-02f, -6.99745268e-02f, 8.90635103e-02f, -1.65735453e-01f, 1.29217580e-01f, -1.19771458e-01f, -4.03037816e-02f, 1.84885561e-01f, -8.12646821e-02f, 1.40023857e-01f,
  -2.01449078e-02f, -1.27892017e-01f, 2.14569159e-02f, 1.48023069e-01f, 1.74516022e-01f, -6.73215762e-02f, -2.44449914e-01f, -1.73441961e-01f, -1.28058597e-01f, 1.66529924e-01f,
  1.19329058e-02f, -9.71038416e-02f, 9.53051727e-03f, 1.13889240e-01f, -2.81718373e-01f, -7.02679083e-02f, -1.41848639e-01f, -1.88208699e-01f, -9.18245167e-02f, 2.56106019e-01f,
  1.31622508e-01f, 1.63053989e-01f, -9.30985145e-04f, 1.94589719e-01f, -2.95502730e-02f, 3.72215621e-02f, 2.08893120e-01f, -8.04123096e-03f, 5.81177846e-02f, 3.33517157e-02f,
  1.08503804e-01f, -2.35207696e-02f, -1.04160964e-01f, -7.48040304e-02f, 5.98057285e-02f, -2.37722006e-02f, 1.67331532e-01f, 1.14723004e-01f, 2.54048947e-02f, 1.06935479e-01f,
  -1.52908742e-01f, 4.55299653e-02f, -1.50145432e-02f, -1.41529460e-02f, 1.02223098e-01f, 1.11438081e-01f, -8.32001492e-02f, -4.16098349e-02f, -9.86093283e-02f, -3.31170447e-02f,
  -1.19735219e-01f, 2.29872670e-02f, -2.79341242e-03f, 9.24652666e-02f, 3.80435586e-02f, -6.10966161e-02f, 1.82219252e-01f, -1.01868510e-02f, -3.36346403e-02f, -8.25098604e-02f,
  2.56578680e-02f, 1.47251859e-01f, -3.71019281e-02f, -5.25810793e-02f, 1.25684321e-01f, -2.17611164e-01f, 1.21596463e-01f, -1.03298634e-01f, 4.48747054e-02f, -7.04877377e-02f,
  1.09044993e-02f, -1.05065458e-01f, -2.99801439e-01f, 1.39141545e-01f, 2.36056224e-01f, 1.94695279e-01f, -1.16791680e-01f, 1.84027433e-01f, 1.24849051e-01f, -1.61255181e-01f,
  -2.58727849e-01f, -4.02349653e-03f, 2.12401878e-02f, -1.32182091e-01f, 1.44618778e-02f, 2.17984468e-01f, 1.91461027e-01f, 6.24205098e-02f, -4.51551415e-02f, -8.75009224e-02f,
  9.41613093e-02f, -3.66387740e-02f, 3.95749323e-03f, -4.57760878e-03f, 7.74171725e-02f, 2.08661873e-02f, 4.75009531e-03f, -3.92236263e-02f, -2.56091654e-02f, 1.08959619e-03f,
  -4.50841747e-02f, 5.12166135e-02f, -5.19684553e-02f, -1.20467491e-01f, -2.02576350e-02f, 6.67716935e-02f, 1.17816031e-01f, -9.38545838e-02f, -1.06797189e-01f, 8.02956298e-02f,
  8.54239687e-02f, -1.34060115e-01f, 1.31657243e-01f, -1.85086831e-01f, 2.36322433e-01f, 9.02668908e-02f, 2.10054874e-01f, -2.81548738e-01f, -2.87647724e-01f, -1.77293234e-02f,
  5.23287989e-02f, -2.25081384e-01f, -1.45565048e-01f, 5.66721447e-02f, 5.38694374e-02f, -7.10390732e-02f, 4.30710502e-02f, -1.99252144e-01f, 2.34775349e-01f, -1.84705004e-01f,
  -1.32435620e-01f, -4.92847078e-02f, 1.77306458e-01f, -1.06499135e-01f, -5.93546219e-02f, -1.13916826e-02f, 5.63749932e-02f, 2.83007503e-01f, 6.79198876e-02f, -9.11928490e-02f,
  -3.58630270e-02f, 4.87653650e-02f, -3.45735513e-02f, -5.31209409e-02f, 4.69481535e-02f, -3.17757204e-02f, 2.70639390e-01f, -3.74571756e-02f, -1.50846109e-01f, 8.19165334e-02f,
  1.62675664e-01f, 1.22030154e-01f, -1.85002573e-02f, -2.55490430e-02f, -1.01634674e-01f, -1.27525046e-01f, 1.00595042e-01f, -9.59460437e-02f, 6.54400811e-02f, -8.06399435e-02f,
  -5.67493513e-02f, 1.04042083e-01f, -5.28319979e-05f, 5.82677200e-02f, -1.05157964e-01f, -6.44559115e-02f, 4.62917760e-02f, -7.39931092e-02f, -7.17334300e-02f, -4.82622311e-02f,
  -5.51686995e-02f, -1.22733653e-01f, 2.30607577e-02f, 2.60346439e-02f, 3.41083184e-02f, 1.33783937e-01f, -2.60004587e-02f, 6.92238063e-02f, -6.74661845e-02f, 3.11362445e-02f,
  8.45339336e-03f, -9.69444495e-03f, 4.85478118e-02f, -8.83583277e-02f, 1.44101858e-01f, 5.14735468e-02f, -1.60145625e-01f, 6.89876676e-02f, 6.93367869e-02f, 2.67022848e-02f,
  -3.04397523e-01f, -1.38750508e-01f, -3.95617485e-02f, 3.57391462e-02f, 1.02069743e-01f, -2.44349152e-01f, -9.69535261e-02f, -1.55191511e-01f, -7.46194869e-02f, 7.22091421e-02f,
  -1.80175021e-01f, 2.78225057e-02f, 1.75954252e-01f, 2.42952276e-02f, 9.19649974e-02f, -1.14531010e-01f, 2.59507060e-01f, -3.30556110e-02f, -1.46834403e-01f, -6.28760532e-02f,
  -3.14785480e-01f, -1.04094952e-01f, 8.56300518e-02f, 3.54195759e-02f, -1.18142664e-01f, 3.70947868e-02f, 1.47713676e-01f, -8.46847240e-03f, -5.23483418e-02f, 2.64424104e-02f,
  8.48304331e-02f, 1.26660243e-02f, -8.50757807e-02f, -4.68413942e-02f, 1.31921992e-01f, 3.63369100e-02f, -5.20236194e-02f, 1.00287080e-01f, 3.95056605e-02f, -4.93953228e-02f,
  1.69031650e-01f, 9.33804139e-02f, -1.68041848e-02f, 5.72799966e-02f, -1.34721175e-01f, 9.47601870e-02f, 1.08888984e-01f, -7.19931349e-02f, -6.77120760e-02f, 1.47896424e-01f,
  -8.22784603e-02f, 2.46576682e-01f, -2.12466210e-01f, -6.33527637e-02f, -2.12892056e-01f, 1.72765583e-01f, 2.69334435e-01f, 1.02075748e-01f, -7.97908008e-02f, 2.56787807e-01f,
  -6.88647572e-03f, -8.40123594e-02f, -6.63645864e-02f, 1.07264845e-02f, -9.07621756e-02f, 1.48236707e-01f, -1.12296723e-01f, 1.95138901e-01f, -6.10675700e-02f, -1.57436818e-01f,
  -1.29876241e-01f, -5.68561703e-02f, 6.04236051e-02f, 4.97910343e-02f, -7.48920590e-02f, -1.65962443e-01f, -8.43537673e-02f, 6.32335758e-03f, 7.25801894e-03f, -1.22984476e-01f,
  -4.54499153e-03f, 1.83593392e-01f, -4.05274192e-03f, 1.24595270e-01f, -2.32480183e-01f, -1.30102292e-01f, 1.47169635e-01f, -4.03342471e-02f, -2.13289261e-01f, -4.73189503e-02f,
  8.50736052e-02f, -2.86137313e-02f, -4.51000482e-02f, -3.68677303e-02f, -7.18767792e-02f, -1.13654532e-01f, 2.03524102e-02f, -1.34338319e-01f, -3.60427126e-02f, -1.54675171e-01f,
  -4.53363247e-02f, -8.01770538e-02f, -2.14829162e-01f, -3.29569727e-02f, -1.38283912e-02f, 2.42422838e-02f, -2.46154815e-02f, -1.40475243e-01f, -2.03034505e-01f, 1.33966142e-02f,
  1.28047928e-01f, -9.34222266e-02f, -2.13962644e-02f, -1.77171633e-01f, 2.25055858e-01f, -9.66975018e-02f, 5.08545898e-02f, -4.29566726e-02f, -6.14355803e-02f, 3.90761383e-02f,
  4.25137356e-02f, 1.54511631e-01f, 2.57070027e-02f, 3.63290459e-02f, 1.50255874e-01f, -1.27774954e-01f, -9.21377465e-02f, -2.13293955e-02f, 1.36032119e-01f, 2.15268105e-01f,
  -1.37780890e-01f, -2.44116243e-02f, -5.94106279e-02f, 1.27019182e-01f, -2.34772548e-01f, 1.02566876e-01f, 3.19232017e-01f, 5.03374375e-02f, 5.53461872e-02f, -1.72535792e-01f,
  -1.73160166e-01f, 8.90085846e-02f, -2.75058839e-02f, -8.79788399e-02f, -2.44099379e-01f, 9.96110886e-02f, 1.24248415e-01f, 1.42904848e-01f, 1.65816531e-01f, -4.33411896e-02f,
  -1.46149829e-01f, -8.44002739e-02f, 1.24227768e-02f, -2.12876230e-01f, -4.58206348e-02f, -3.22042070e-02f, -3.15619111e-02f, -7.28194639e-02f, 5.74737042e-02f, -8.83224830e-02f,
  1.90154940e-03f, 1.97584014e-02f, 2.65769809e-02f, -6.76016696e-03f, 5.98164685e-02f, 1.60763171e-02f, -2.46388465e-01f, -3.84102054e-02f, 5.63713349e-02f, -7.90573936e-03f,
  -5.34033813e-02f, 4.66663539e-02f, 1.62783697e-01f, -2.97549099e-01f, 2.67654154e-02f, -1.29901424e-01f, -1.41280487e-01f, 7.62474164e-02f, 6.14466891e-02f, 4.97026034e-02f,
  1.08853586e-01f, 7.94438496e-02f, 5.64568564e-02f, -2.06188440e-01f, -3.69751989e-03f, -6.87561631e-02f, 1.34408131e-01f, 7.74118528e-02f, -1.97821036e-01f, 8.72993916e-02f,
  8.09278339e-02f, -6.89395294e-02f, -2.31592044e-01f, -1.66794360e-01f, -3.97530943e-02f, 2.76569314e-02f, 1.02269121e-01f, -9.69955623e-02f, -3.35720070e-02f, 8.00182074e-02f,
  8.57417881e-02f, 1.19283378e-01f, 2.42244914e-01f, 5.01566269e-02f, 1.75399572e-01f, -1.12025186e-01f, 1.31938502e-01f, -2.15386644e-01f, 2.30863675e-01f, 2.13080302e-01f,
  1.76741526e-01f, 2.45446414e-02f, -1.04762964e-01f, -5.58082350e-02f, -1.51086807e-01f, -4.63655218e-04f, -2.06225723e-01f, 1.44800127e-01f, 1.39300510e-01f, 5.52721545e-02f,
  9.27148461e-02f, 8.16636160e-02f, 9.38180536e-02f, -2.55191512e-02f, 7.87444413e-02f, 5.28834015e-02f, -2.94136368e-02f, -4.44049314e-02f, -2.76618898e-01f, -2.01921351e-02f,
  -7.54595473e-02f, -7.51200393e-02f, 9.04731676e-02f, -2.86141001e-02f, 1.19727351e-01f, 6.32213801e-02f, -1.92653731e-01f, 7.59190246e-02f, -1.18281068e-02f, -2.09949985e-02f,
  -4.25381921e-02f, 1.82597309e-01f, 8.28050151e-02f, -4.25714515e-02f, -1.54072702e-01f, 5.28418310e-02f, -1.32755235e-01f, 4.98518050e-02f, 1.54993415e-01f, -7.41489418e-03f,
  -1.13854581e-03f, 1.94446161e-01f, -2.07167879e-01f, 1.09617434e-01f, 5.03887571e-02f, -1.37019709e-01f, -9.24900407e-04f, -1.02831408e-01f, 7.21737444e-02f, 1.70984700e-01f,
  2.95298197e-03f, -2.21609995e-01f, -2.49905229e-01f, 4.05785665e-02f, 1.47642598e-01f, 6.58015460e-02f, 3.59211862e-03f, 2.14773327e-01f, -6.59497976e-02f, 2.39839897e-01f,
  4.01132032e-02f, 4.71661985e-02f, 1.54071093e-01f, 2.94416584e-02f, 8.87285694e-02f, 2.57110894e-01f, -6.10050708e-02f, -1.72232106e-01f, 2.33431190e-01f, -5.96897863e-03f,
  -8.20794776e-02f, -1.13701105e-01f, 4.17073555e-02f, -2.01748610e-02f, -4.66232635e-02f, -1.24173937e-02f, -6.91168159e-02f, -8.51635411e-02f, -1.05381139e-01f, -6.58706501e-02f,
  -2.06908248e-02f, -1.33770928e-01f, -5.31018414e-02f, -4.76062410e-02f, -2.83875436e-01f, -5.17767183e-02f, -3.43559086e-02f, -7.12295994e-02f, -3.83198224e-02f, -7.53433630e-02f,
  -1.03603549e-01f, 1.65354997e-01f, -3.17766406e-02f, -3.04388814e-02f, -4.00662310e-02f, -1.06688000e-01f, 1.14268683e-01f, -3.08801621e-01f, 9.77831781e-02f, -1.32857352e-01f,
  -4.78565767e-02f, -1.95289224e-01f, 5.32052405e-02f, -2.34746025e-03f, 7.55234808e-02f, 1.93555236e-01f, -7.16416612e-02f, 6.39359429e-02f, -4.28685732e-02f, -1.41348869e-01f,
  1.47916824e-01f, -1.97169203e-02f, -7.83045143e-02f, 4.56537828e-02f, 1.34988934e-01f, 5.59188612e-02f, -2.72190779e-01f, 2.37659752e-01f, 2.78577238e-01f, -8.19008648e-02f,
  9.30442810e-02f, 1.85185950e-02f, 2.98843011e-02f, 2.06400350e-01f, -5.43516316e-02f, -2.32900362e-02f, -1.45481154e-01f, 1.14566097e-02f, 2.63886154e-01f, 6.62276447e-02f,
  2.16479689e-01f, -2.82083787e-02f, -8.67310241e-02f, -1.23452902e-01f, 1.75363123e-01f, -1.93246752e-01f, 9.28516239e-02f, 6.03743717e-02f, -8.53675455e-02f, 2.27631517e-02f,
  1.09594449e-01f, 8.63839090e-02f, 9.73780174e-03f, -3.38997180e-03f, 1.60406351e-01f, 1.26315221e-01f, 7.34830946e-02f, 5.12766391e-02f, -7.97060579e-02f, -4.21644608e-03f,
  1.12272277e-01f, 1.96009934e-01f, -2.50121709e-02f, -3.56037654e-02f, 9.60225388e-02f, -1.44285396e-01f, 1.54592633e-01f, 8.62849690e-03f, -1.89329296e-01f, 1.01697452e-01f,
  -1.58903122e-01f, 2.27849901e-01f, -6.31955639e-02f, -1.32291734e-01f, -1.27895877e-01f, 2.23163083e-01f, 1.29720554e-01f, 1.64620414e-01f, 4.42967825e-02f, 2.58238018e-01f,
  3.98219451e-02f, -1.13647871e-01f, -7.92486817e-02f, 1.20906591e-01f, -6.25426993e-02f, 2.12485477e-01f, -1.52896106e-01f, 6.74373657e-02f, 5.96528463e-02f, -7.05329031e-02f,
  3.65836546e-02f, 4.19669226e-02f, 1.98236898e-01f, 5.78202643e-02f, -3.92552698e-03f, -2.37511411e-01f, 5.66672422e-02f, 4.78163287e-02f, -3.04257069e-02f, -1.75838277e-01f,
  2.25395188e-02f, 1.94537058e-01f, -2.49136076e-03f, 1.59274846e-01f, -2.17662334e-01f, 9.24463496e-02f, 5.54090329e-02f, -9.35664773e-03f, -2.31480017e-01f, 7.60829374e-02f,
  -1.26113489e-01f, 5.64000197e-02f, -8.08819085e-02f, -3.27066071e-02f, 1.61243547e-02f, -3.79310288e-02f, 9.02720019e-02f, -3.81371826e-02f, -1.82843357e-02f, 1.15274685e-02f,
  2.67775059e-01f, 7.12252548e-03f, -4.11128215e-02f, 1.27967238e-01f, 1.08109079e-02f, -3.36457491e-02f, -1.21525377e-01f, -1.03955723e-01f, 1.07506141e-01f, -2.07666352e-01f,
  7.89059550e-02f, -3.88530120e-02f, -1.53197795e-01f, -1.52105346e-01f, -3.84878591e-02f, 7.74654374e-02f, -6.91189021e-02f, -8.77009332e-02f, -3.58654745e-02f, 2.86530685e-02f,
  3.15221995e-02f, -1.01408325e-01f, 1.97719663e-01f, -1.22327968e-01f, 4.13700789e-02f, -3.13083977e-02f, 3.47343273e-02f, 4.81803939e-02f, -2.05366760e-01f, 6.58740401e-02f,
  -1.35558888e-01f, -1.19954616e-01f, 1.76852673e-01f, 1.62907436e-01f, 1.01003781e-01f, 1.12958774e-01f, -1.18816905e-01f, 1.24978587e-01f, -7.99068287e-02f, -6.84287474e-02f,
  2.22034916e-01f, 2.68193949e-02f, 1.20934531e-01f, -1.32112801e-01f, 2.04526886e-01f, -1.40302405e-01f, -1.03467628e-01f, -2.05564260e-01f, -2.65518486e-01f, 1.91768423e-01f,
  -3.60208866e-03f, 6.05204664e-02f, -7.28920773e-02f, -2.26515364e-02f, -6.55404776e-02f, -2.21693199e-02f, -1.60671353e-01f, -6.80653900e-02f, 4.76376601e-02f, -3.84285226e-02f,
  -9.92698316e-03f, -1.01570161e-02f, 1.35838419e-01f, 4.73533012e-02f, -2.38656849e-02f, 1.35029018e-01f, 1.48212120e-01f, -3.39969881e-02f, 9.55696777e-02f, 7.18019083e-02f,
  -2.82930508e-02f, -6.84535876e-02f, -2.40081456e-02f, -2.01808549e-02f, 7.56658837e-02f, -1.27569661e-01f, 1.79904010e-02f, -1.17211451e-03f, -8.01315233e-02f, 2.96119779e-01f,
  -2.71835566e-01f, -6.72411844e-02f, -1.44554138e-01f, 1.67664647e-01f, 2.07779527e-01f, 6.86157867e-02f, 3.09346709e-02f, 6.14198148e-02f, 1.07304752e-01f, -1.16523869e-01f,
  -9.41017494e-02f, 1.11003108e-01f, -2.07188800e-01f, 2.57074773e-01f, -1.97973382e-02f, 5.93609773e-02f, -7.73983598e-02f, 5.97191453e-02f, -4.99252230e-03f, -7.82414749e-02f,
  -1.42077640e-01f, 7.66817247e-03f, -1.04872636e-01f, -2.21015420e-02f, -8.26750994e-02f, -8.97670686e-02f, 6.89511374e-02f, 4.94861640e-02f, -8.78590047e-02f, 8.51728022e-02f,
  -7.79535994e-02f, -3.28841247e-02f, -3.40023190e-01f, 1.23179950e-01f, 2.70923048e-01f, 1.75386310e-01f, -2.05733493e-01f, 3.95595543e-02f, -1.25759929e-01f, -7.20895268e-03f,
  -2.38410473e-01f, -9.82674882e-02f, -5.37154004e-02f, 2.60692071e-02f, -5.49750589e-02f, 8.46866220e-02f, 1.56377107e-01f, 1.88927233e-01f, 1.01168886e-01f, 1.68721288e-01f,
  1.41905367e-01f, -5.47273755e-02f, 3.15352343e-02f, 1.83683541e-03f, -5.55718951e-02f, 1.10907825e-02f, 2.55162537e-01f, -1.25657454e-01f, -1.35728735e-02f, -1.04271404e-01f,
  1.10215388e-01f, -7.45862871e-02f, -1.93032041e-01f, 2.02467769e-01f, -8.06605592e-02f, -7.18856528e-02f, -7.61114806e-02f, 1.14041597e-01f, 1.18718911e-02f, 7.55446479e-02f,
  -3.28817554e-02f, -1.39691412e-01f, 1.71222806e-01f, -5.37612922e-02f, -5.99257089e-02f, 1.15759037e-01f, -5.74650168e-02f, 1.75708696e-01f, 2.46586110e-02f, 4.86734807e-02f,
  -1.46816060e-01f, 1.34388700e-01f, 2.24144340e-01f, -1.60359666e-01f, -2.29931712e-01f, -1.69530814e-03f, -7.31795654e-02f, -3.40375565e-02f, -1.75103750e-02f, -2.36770123e-01f,
  1.02013543e-01f, 3.48980613e-02f, -1.97106734e-01f, 1.02138795e-01f, -3.20671536e-02f, -1.64914384e-01f, -2.25008979e-01f, 2.53035069e-01f, 6.53952211e-02f, 1.69449285e-01f,
  -9.78939384e-02f, 2.43064269e-01f, -3.92300077e-02f, -1.09089958e-02f, -2.46559735e-02f, 1.17295319e-02f, -5.85329048e-02f, -1.14288116e-02f, 5.67335486e-02f, 1.02792948e-01f,
  -9.72927511e-02f, -5.59794530e-02f, -1.04684994e-01f, -1.11875646e-01f, -6.02786690e-02f, -2.19875667e-02f, -7.59789646e-02f, -1.01296112e-01f, 7.69933164e-02f, 7.55699500e-02f,
  1.66217491e-01f, -2.63535939e-02f, -1.59288824e-01f, -3.23541164e-02f, 9.17742252e-02f, -8.96156281e-02f, 1.58440962e-01f, -1.88575596e-01f, 2.83455133e-01f, 5.12513295e-02f,
  1.86126217e-01f, -2.55433202e-01f, -3.02114755e-01f, 2.86892671e-02f, -7.49872476e-02f, -2.04400480e-01f, -8.72367918e-02f, 9.58765000e-02f, 4.69483212e-02f, -1.40412271e-01f,
  1.20812260e-01f, -2.94352084e-01f, 1.58555359e-01f, -4.76835333e-02f, -1.13436393e-01f, 7.35135823e-02f, 1.02271192e-01f, 6.39000013e-02f, -2.76312139e-02f, 9.09426156e-03f,
  1.95456371e-01f, 1.60438702e-01f, 3.46321496e-03f, -1.77029267e-01f, 2.11092993e-03f, 5.60642108e-02f, -5.50719686e-02f, -7.10888654e-02f, 2.78082043e-01f, -8.28749239e-02f,
  2.63266325e-01f, -5.39977278e-04f, -1.55855328e-01f, -1.01492248e-01f, 1.70343027e-01f, 1.10183721e-02f, 1.66583769e-02f, -2.20267512e-02f, -5.36579899e-02f, -3.00607700e-02f,
  -5.21240458e-02f, 6.56841248e-02f, -3.92742530e-02f, 2.26350985e-02f, 7.75792897e-02f, 3.23182121e-02f, 1.61103547e-01f, 4.92480285e-02f, -1.11782417e-01f, 8.58229920e-02f,
  5.06122001e-02f, 1.76899657e-01f, 1.99308824e-02f, 1.39505155e-02f, 6.50145262e-02f, -7.65849724e-02f, 8.59959051e-02f, -4.41957302e-02f, -2.13763490e-01f, -2.63295025e-02f,
  -1.06332906e-01f, 1.82437301e-01f, -9.96583421e-03f, -1.13610536e-01f, -6.05473146e-02f, 1.35124490e-01f, 2.72970228e-03f, 1.37997955e-01f, 2.11320072e-02f, 1.40382335e-01f,
  5.52001223e-02f, -8.55333507e-02f, -1.82145581e-01f, 4.44816127e-02f, 1.14239231e-02f, 2.28769615e-01f, -1.95103198e-01f, 5.39686643e-02f, -2.37333924e-02f, 1.46791702e-02f,
  8.45181663e-03f, 1.19075611e-01f, 1.94669649e-01f, 4.96444367e-02f, 1.00105047e-01f, -2.59048879e-01f, 4.53802198e-03f, 1.29547883e-02f, -6.27618283e-02f, -1.69720098e-01f,
  -1.18478969e-01f, 1.96240053e-01f, 4.77593243e-02f, 1.99839100e-01f, 3.79777397e-03f, 1.17596418e-01f, -6.35309741e-02f, -5.80573715e-02f, -1.19975582e-01f, 1.22340702e-01f,
  1.58085451e-01f, 3.64214256e-02f, -2.78638490e-02f, 7.93832764e-02f, -5.04272804e-02f, 9.97628346e-02f, 1.11491112e-02f, -4.98419479e-02f, 1.12213440e-01f, -1.72351032e-01f,
  8.55127648e-02f, 6.97685853e-02f, -1.32933274e-01f, -1.43670645e-02f, 1.74856007e-01f, -3.33064012e-02f, -4.36272882e-02f, 7.84928538e-03f, -1.16343740e-02f, 1.97968215e-01f,
  -1.16170049e-01f, -2.53113568e-01f, 1.22538783e-01f, -3.16754822e-03f, 7.37386197e-02f, 4.05217595e-02f, 4.11293358e-02f, 1.19800627e-01f, 1.08801961e-01f, -1.19345024e-01f,
  -4.54067998e-03f, 5.74818403e-02f, -1.80527549e-02f, -3.67511250e-02f, -2.61917524e-02f, 1.09279260e-01f, -4.04959433e-02f, -8.33146572e-02f, -1.34657994e-01f, 1.97540045e-01f,
  -4.98658828e-02f, 1.13681085e-01f, -6.14340007e-02f, -1.23131394e-01f, -6.54478818e-02f, -4.13808897e-02f, -2.89133079e-02f, 2.97103286e-01f, -1.30505383e-01f, -6.15408495e-02f,
  1.51713789e-01f, 7.65932500e-02f, 1.62914708e-01f, -1.67524472e-01f, 1.24918818e-01f, 7.41996840e-02f, 7.86550120e-02f, -1.36812955e-01f, 5.21279685e-02f, -2.57447939e-02f,
  -1.35954887e-01f, -1.97713718e-01f, 1.02534316e-01f, -1.20917730e-01f, 5.77684306e-02f, -4.40402180e-02f, -1.97912619e-01f, -2.06516087e-02f, -3.30060944e-02f, -3.08434162e-02f,
  -1.15631580e-01f, -6.30731881e-02f, -2.16293465e-02f, -8.09195116e-02f, 2.98584159e-03f, -1.53631074e-02f, -1.31961182e-01f, 4.95046452e-02f, 5.61068431e-02f, -1.27905577e-01f,
  -1.45607963e-01f, -6.74427077e-02f, -3.92974727e-02f, 7.01144338e-02f, -9.27051157e-03f, -2.62943566e-01f, 5.92261776e-02f, -1.10232227e-01f, 1.62583411e-01f, 6.01843260e-02f,
  -1.64701995e-02f, -6.55240566e-02f, -1.41220316e-01f, -8.16206038e-02f, 1.25907227e-01f, -4.66404110e-02f, 3.59956399e-02f, 6.58081099e-02f, 1.02765076e-01f, 2.82021076e-03f,
  -6.99050426e-02f, -1.90555174e-02f, -3.29084307e-01f, 2.68392473e-01f, -1.18667737e-01f, 1.56262875e-01f, 6.32979795e-02f, 2.52547473e-01f, -2.13402346e-01f, 1.19732767e-01f,
  -1.00256111e-02f, 2.73764431e-01f, 4.46208715e-02f, -1.08867757e-01f, -1.10768594e-01f, -2.39793807e-02f, 1.33272961e-01f, -2.70241022e-01f, 7.65751451e-02f, -1.71291344e-02f,
  1.63004711e-01f, -1.36161715e-01f, -1.76722065e-01f, 1.19149022e-01f, 1.86088774e-02f, -1.51458323e-01f, -1.72966391e-01f, -1.64024413e-01f, -5.40074594e-02f, -1.05607398e-01f,
  -1.39676303e-01f, -3.16428137e-04f, -1.19556084e-01f, 4.70057279e-02f, -8.13997239e-02f, -3.38507444e-02f, 8.44549015e-02f, -7.00875074e-02f, 1.06773898e-01f, 1.85984239e-01f,
  8.20106640e-03f, -5.82495295e-02f, 8.29292014e-02f, -1.29978970e-01f, -1.44269630e-01f, 5.28607927e-02f, -1.73047222e-02f, 7.30079114e-02f, -6.64530620e-02f, -1.65314198e-01f,
  1.68987766e-01f, -7.53947794e-02f, 2.42216829e-02f, 8.78893360e-02f, -5.36617590e-04f, 7.53534436e-02f, 7.02313473e-03f, -2.76445900e-03f, -9.78184193e-02f, 5.64416870e-02f,
  -1.26133248e-01f, -1.50164455e-01f, 5.30392751e-02f, 4.41398546e-02f, -2.65006423e-02f, 1.34126425e-01f, -1.68056339e-01f, 2.02755749e-01f, -5.20487279e-02f, 1.86148092e-01f,
  -1.89071968e-01f, 8.25283006e-02f, 1.27281711e-01f, -1.53504893e-01f, -2.31856525e-01f, 1.69303000e-01f, -1.39636055e-01f, -5.65607212e-02f, 4.53449506e-03f, -9.72322002e-02f,
  1.96359575e-01f, -1.11608848e-01f, -2.47885957e-02f, 6.47257864e-02f, -9.96517912e-02f, -2.23234132e-01f, -1.51997894e-01f, 6.91476092e-02f, -2.31525768e-02f, -8.06721970e-02f,
  -5.40610440e-02f, -1.15270878e-03f, -9.34189707e-02f, -2.74034273e-02f, -1.20374486e-01f, 2.33122930e-02f, -4.65219244e-02f, -6.95243180e-02f, 1.88996959e-02f, 2.40509883e-02f,
  -1.23836979e-01f, -1.00406244e-01f, -9.06138271e-02f, 1.67533383e-01f, -8.71485695e-02f, 1.45911891e-02f, -1.97201949e-02f, -1.27308160e-01f, -2.66704261e-02f, -9.16290060e-02f,
  -4.43115421e-02f, -1.54709201e-02f, -6.47513494e-02f, -1.37186527e-01f, 9.37488973e-02f, -2.45178137e-02f, 1.91768348e-01f, -5.90668060e-02f, 1.12290926e-01f, 7.93909431e-02f,
  1.07763626e-01f, -2.03648373e-01f, -1.60479322e-01f, -9.60888341e-02f, 1.49567261e-01f, -1.21932149e-01f, -1.41095206e-01f, 1.43860221e-01f, 3.03291786e-03f, -1.13279238e-01f,
  -2.05100000e-01f, 2.62462106e-02f, 1.98680446e-01f, 3.78121063e-02f, -1.16259515e-01f, 3.37095708e-02f, -9.36935991e-02f, -1.30530849e-01f, -1.58149302e-01f, 2.87715942e-01f,
  -1.40863657e-01f, 2.85517842e-01f, -2.96523478e-02f, -5.93026206e-02f, 2.48081997e-01f, 4.09868546e-03f, 1.79015085e-01f, -2.42659426e-03f, 1.52253266e-02f, -3.76584046e-02f,
  -7.39815682e-02f, 1.62551537e-01f, 3.68889533e-02f, 5.41815814e-03f, -8.53899494e-02f, -1.54914781e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.58785477e-01f, 1.59977954e-02f, -1.28424719e-01f, 1.02906205e-01f, 3.64456698e-03f, 2.14952931e-01f, 5.77306338e-02f, 2.43544690e-02f, 1.31999090e-01f, -2.10462213e-02f,
  1.28805250e-01f, 1.25797719e-01f, 6.77453130e-02f, 5.04331924e-02f, 5.76277450e-02f, 5.15251644e-02f, 1.33705333e-01f, 1.43425494e-01f, 1.77317932e-01f, 2.22801492e-01f,
  -2.94194758e-01f, -3.64897221e-01f, 2.70801008e-01f, -2.11950168e-02f, 1.67487562e-01f, 7.96353072e-02f, 1.94441229e-01f, 1.61096990e-01f, 2.03866675e-01f, -2.63766378e-01f,
  -2.21146107e-01f, 1.00058988e-01f, -2.31246263e-01f, -2.03090355e-01f, 5.84816933e-02f, 1.96712315e-01f, -3.30168642e-02f, -8.32747892e-02f, 1.65884197e-02f, 2.43064329e-01f,
  4.63846736e-02f, 3.94243836e-01f, -1.45295784e-01f, 3.37946355e-01f, 2.44688675e-01f, 9.96098593e-02f, -3.06298316e-01f, 4.05332088e-01f, 1.74644604e-01f, -4.98709977e-02f,
  9.25413519e-02f, -1.86510697e-01f, 3.34153563e-01f, -7.51146451e-02f, 1.82733938e-01f, 7.00422283e-03f, 3.57044339e-01f, -2.71055400e-01f, -2.18768716e-02f, 2.53301352e-01f,
  -1.02097467e-01f, -2.77552009e-01f, 2.24070415e-01f, -8.49655196e-02f, -5.90575440e-03f, 3.28832828e-02f, 1.60855234e-01f, 1.03939772e-01f, 1.01184793e-01f, 1.28418669e-01f,
  2.27753788e-01f, 4.79321256e-02f, 1.19349144e-01f, 1.82862177e-01f, 2.49046117e-01f, 6.89974278e-02f, 4.57822919e-01f, 6.14880845e-02f, 5.32737784e-02f, 2.36782297e-01f,
  1.30315065e-01f, 3.05518713e-02f, -3.12949009e-02f, 1.07378557e-01f, 1.17676184e-01f, 4.70121473e-01f, -7.92294517e-02f, -7.29555264e-02f, -2.65747666e-01f, 1.78386033e-01f,
  -3.78203601e-01f, -1.34301707e-01f, -1.79755956e-01f, 3.92017007e-01f, 2.36315131e-01f, -8.55966881e-02f, -1.38944253e-01f, 3.14909704e-02f, 3.24909180e-01f, -1.68334335e-01f,
  5.15282527e-02f, 3.34376425e-01f, 2.02980608e-01f, 6.38180822e-02f, 3.09789237e-02f, -1.89367875e-01f, 1.40672579e-01f, 7.66638741e-02f, 2.48810738e-01f, -1.99673232e-03f,
  -1.50652930e-01f, -2.65909255e-01f, -1.23896666e-01f, -2.04384595e-01f, 1.00594155e-01f, 1.84306115e-01f, -2.50475585e-01f, 2.18204871e-01f, 3.42902429e-02f, -2.03836560e-01f,
  -3.43219995e-01f, -8.13057497e-02f, -2.12321714e-01f, -2.72108838e-02f, 2.36396343e-01f, 1.41669199e-01f, 1.66254625e-01f, 1.84357747e-01f, 1.50203168e-01f, 1.54330492e-01f,
  5.87864444e-02f, 1.44802421e-01f, 2.18620867e-01f, 2.52443943e-02f, 1.40281066e-01f, 1.53422698e-01f, 3.68973874e-02f, 1.69431984e-01f, -2.04696864e-01f, 1.22909732e-01f,
  3.05687934e-02f, 1.58458948e-02f, 1.99747860e-01f, 1.06986269e-01f, 1.95618823e-01f, 1.57576114e-01f, 6.81923255e-02f, 6.94592148e-02f, -5.49985208e-02f, -9.49005336e-02f,
  -5.54658566e-03f, 4.35758173e-01f, 8.97907838e-02f, 1.94344267e-01f, 5.16554117e-02f, 5.10505848e-02f, -2.89676189e-02f, 9.91801172e-02f, 1.01287648e-01f, 1.47637650e-01f,
  -1.84837312e-01f, 3.65497351e-01f, -1.75927311e-01f, 2.34116361e-01f, 1.12471007e-01f, -1.13379896e-01f, 2.75104903e-02f, -1.89518422e-01f, 1.33044720e-01f, 3.43400508e-01f,
  -5.51619902e-02f, -2.53234297e-01f, -2.33556136e-01f, 2.26119254e-02f, 4.50896993e-02f, 1.79547027e-01f, 2.86665231e-01f, 8.96912739e-02f, -7.90093914e-02f, -1.12613507e-01f,
  1.55229583e-01f, 6.96675181e-02f, 3.10901374e-01f, 1.98371962e-01f, 2.83472300e-01f, 3.65361929e-01f, -2.01235145e-01f, -1.53647676e-01f, 3.54856402e-01f, -2.87556159e-03f,
  -2.89935619e-01f, -1.43575892e-01f, 3.01942229e-01f, 9.29295793e-02f, 1.36866821e-02f, 2.31719445e-02f, -3.71525176e-02f, 1.75751612e-01f, 1.26017660e-01f, -6.63433820e-02f,
  1.48374379e-01f, -1.02739736e-01f, 8.44628662e-02f, 1.88472256e-01f, -1.64068758e-01f, 1.36092663e-01f, 1.04449391e-01f, -2.49379743e-02f, 2.12462060e-02f, -3.25737372e-02f,
  -1.30862162e-01f, 5.19445213e-03f, -2.90378463e-02f, -2.72749722e-01f, 2.34211355e-01f, -1.43410400e-01f, 1.71914876e-01f, 7.30751604e-02f, 1.45041823e-01f, 1.89140245e-01f,
  2.35290974e-02f, -5.72948270e-02f, -1.76644653e-01f, 3.02713215e-01f, 1.40256137e-02f, -1.44812897e-01f, 1.49308532e-01f, 1.80582926e-02f, -1.63011491e-01f, -4.75044325e-02f,
  -1.82817727e-01f, 4.05186266e-01f, -4.21387404e-02f, 2.86407441e-01f, -2.47008070e-01f, -2.24900506e-02f, -9.81174707e-02f, -2.72945434e-01f, 1.84139416e-01f, 4.97417867e-01f,
  -1.70145556e-01f, -8.94697830e-02f, 1.43486917e-01f, 5.94580844e-02f, 3.21046680e-01f, -3.63845289e-01f, 2.05862895e-01f, 3.03634852e-01f, 7.57383406e-02f, 2.38377918e-02f,
  -4.50506881e-02f, 1.38027713e-01f, -1.18138466e-03f, -1.71117648e-01f, -1.87645793e-01f, -1.73640013e-01f, 1.78398743e-01f, 1.37540191e-01f, 1.48899376e-01f, 9.88442078e-02f,
  -1.09546231e-02f, 5.79194315e-02f, 8.76319967e-03f, -3.61469179e-01f, -1.96913201e-02f, -1.92776501e-01f, 2.15163380e-01f, 5.00870794e-02f, -3.32987607e-02f, 1.83914840e-01f,
  2.15367883e-01f, -3.93086337e-02f, -8.58107582e-02f, -1.96313396e-01f, -4.94695961e-01f, 2.24873617e-01f, 1.98100984e-01f, 5.98307997e-02f, -1.02865316e-01f, -4.14701104e-01f,
  1.96074873e-01f, 4.43244241e-02f, -2.94136137e-01f, -4.50816378e-02f, -2.54757911e-01f, 4.52642813e-02f, 2.23904714e-01f, -1.16333716e-01f, 1.33240446e-01f, -6.53321743e-02f,
  2.41211668e-01f, -2.65613675e-01f, -2.14922264e-01f, 1.20368615e-01f, -2.23674595e-01f, 6.12310052e-01f, -2.43120998e-01f, -1.42684489e-01f, 1.53479919e-01f, 2.72221833e-01f,
  -2.68275380e-01f, 1.03250846e-01f, 2.78615087e-01f, 2.28074566e-01f, -5.51329315e-01f, 2.84882393e-02f, 6.03183284e-02f, 7.04351127e-01f, 6.54116422e-02f, -1.80625409e-01f,
  4.22232635e-02f, -5.77173717e-02f, -2.20757067e-01f, -1.39141217e-01f, -5.31908451e-03f, -7.46816024e-02f, 4.76610586e-02f, -7.22568780e-02f, 2.14472413e-01f, -2.88246721e-01f,
  1.47538230e-01f, 8.58551934e-02f, 2.07711816e-01f, 1.51269197e-01f, 6.99073598e-02f, 5.45265637e-02f, 6.67074919e-02f, -3.61356661e-02f, 4.94499318e-02f, -1.59466527e-02f,
  7.53190666e-02f, -2.02578921e-02f, 3.72719057e-02f, 7.03608692e-02f, 7.57311508e-02f, 1.17572583e-01f, 5.93772158e-02f, 1.10056430e-01f, -9.42810476e-02f, 1.25202700e-01f,
  1.36656776e-01f, 1.58017069e-01f, -2.15948537e-01f, -8.70016683e-03f, 8.98153260e-02f, -6.60841912e-02f, -1.26116782e-01f, -4.62315604e-02f, -3.81786488e-02f, 4.37858468e-03f,
  1.81567997e-01f, -7.54212588e-02f, 1.32304728e-02f, 2.20909745e-01f, -9.47057735e-03f, -7.43279159e-02f, -1.11252680e-01f, 1.20531172e-02f, 2.45543122e-01f, -3.73202115e-02f,
  -1.31940007e-01f, -1.04762008e-02f, 1.21232651e-01f, -9.41762477e-02f, -1.43822849e-01f, 3.16246599e-01f, 2.67015308e-01f, -1.42306611e-01f, 1.51366025e-01f, -1.13822639e-01f,
  -1.11845173e-02f, 3.61240953e-01f, -2.08495468e-01f, -3.01477108e-02f, -5.03267758e-02f, 1.19569369e-01f, 1.08120225e-01f, 2.81685889e-01f, 3.00933838e-01f, -1.33869395e-01f,
  1.83115192e-02f, -1.08592644e-01f, 2.60775745e-01f, -5.71567044e-02f, -1.14298083e-01f, 1.89521790e-01f, 1.17348105e-01f, 8.21811706e-03f, 1.60092339e-01f, -5.43095544e-02f,
  2.76441664e-01f, 2.35515833e-01f, -5.46056665e-02f, 2.55617589e-01f, -1.29375067e-02f, -1.48536414e-01f, 1.39034629e-01f, -3.49064060e-02f, -1.74048871e-01f, 1.44948110e-01f,
  2.75619149e-01f, 2.88715195e-02f, 1.28034696e-01f, 1.09293452e-02f, -7.03526065e-02f, 3.72807831e-01f, -1.65882185e-01f, 1.58665150e-01f, -1.96988657e-01f, -1.66955575e-01f,
  -2.53086746e-01f, -1.97027266e-01f, -6.73336461e-02f, 2.69440830e-01f, 2.37965107e-01f, -2.06064582e-01f, 4.61613899e-03f, 2.45723397e-01f, 5.70925325e-02f, 1.78976417e-01f,
  2.24822864e-01f, 3.16082984e-02f, 3.14235449e-01f, -4.54158813e-01f, 5.45925274e-02f, -1.74907520e-01f, 4.42906648e-01f, 7.90467411e-02f, -8.27076565e-03f, 3.64018619e-01f,
  8.77597556e-02f, -3.22664410e-01f, 3.37235987e-01f, 7.41199628e-02f, 1.67704269e-01f, 2.35454187e-01f, -1.50652915e-01f, 2.93582708e-01f, 2.68237412e-01f, -3.11495513e-01f,
  6.74274117e-02f, 2.05079809e-01f, -1.38057604e-01f, -7.85852745e-02f, 2.87495792e-01f, 9.91520137e-02f, 4.00094315e-02f, -6.27869293e-02f, -5.68273887e-02f, 5.69635555e-02f,
  -6.19114675e-02f, 1.02274314e-01f, 1.14458546e-01f, -2.72477195e-02f, -2.92323474e-02f, 1.37612492e-01f, 1.69294059e-01f, 2.20345169e-01f, 9.91341099e-02f, 7.57622942e-02f,
  2.99712151e-01f, 8.07599723e-03f, 1.29089594e-01f, 2.22093254e-01f, 1.04223594e-01f, 1.88404188e-01f, 2.60189146e-01f, -3.04810852e-02f, 2.41900235e-02f, -3.14193107e-02f,
  -9.73961502e-02f, 9.27278474e-02f, -1.26551926e-01f, 2.99525768e-01f, -2.64972389e-01f, -2.12161884e-01f, -2.66527832e-01f, 1.27729103e-01f, 2.89197087e-01f, -9.05708894e-02f,
  -1.29827946e-01f, 2.17160702e-01f, 1.36185335e-02f, -4.91959006e-02f, 9.99133196e-03f, 1.70188323e-01f, -9.01947320e-02f, 1.95265904e-01f, 1.32734165e-01f, 2.05050170e-01f,
  1.38154119e-01f, 2.68507838e-01f, 1.94657356e-01f, 2.15005875e-01f, -3.01029712e-01f, -8.76004323e-02f, 2.85334051e-01f, -4.86316998e-03f, -9.03825983e-02f, -2.26858526e-01f,
  2.17578951e-02f, 2.16099232e-01f, -1.82121798e-01f, 5.83227761e-02f, 2.32226148e-01f, -1.52488708e-01f, -2.44567245e-01f, 2.51304984e-01f, 3.14987510e-01f, 2.69288182e-01f,
  -1.49047568e-01f, 2.53213227e-01f, 4.82984595e-02f, 4.22363095e-02f, 5.41728884e-02f, 3.13422009e-02f, 1.61079302e-01f, 5.96904084e-02f, -3.03593595e-02f, 7.53368735e-02f,
  2.11174697e-01f, 1.54474348e-01f, -1.24394104e-01f, 1.44054756e-01f, 1.23932518e-01f, -9.22077044e-04f, 3.79855633e-02f, 1.53892636e-01f, 8.10194388e-02f, 1.51490554e-01f,
  1.60647720e-01f, -9.81528312e-02f, 1.20203115e-01f, 1.05612360e-01f, -4.47500758e-02f, 5.78927957e-02f, -9.75981206e-02f, 1.36769533e-01f, -3.88927087e-02f, -1.21151982e-02f,
  -6.37156144e-02f, 1.90694168e-01f, -5.60577661e-02f, 2.28560984e-01f, -7.54570812e-02f, 7.00070560e-02f, -4.62699085e-02f, -2.01527253e-01f, -4.19291705e-02f, 4.59822156e-02f,
  2.57743716e-01f, 3.27112824e-02f, 2.15561077e-01f, 8.32415894e-02f, -1.91980094e-01f, -1.89591244e-01f, 1.69920638e-01f, -3.24130729e-02f, 1.48118734e-01f, -1.55765936e-01f,
  1.34450495e-01f, 1.31447971e-01f, -1.39303535e-01f, -7.08715022e-02f, -1.02414280e-01f, 1.65101096e-01f, -2.55115449e-01f, 4.10764188e-01f, 1.93230808e-02f, 3.22967410e-01f,
  1.35268316e-01f, -5.62876910e-02f, 1.79636210e-01f, 2.15998560e-01f, -1.08999856e-01f, 3.19425941e-01f, -1.11971818e-01f, 3.32392305e-02f, 1.63432688e-01f, 4.98803370e-02f,
  -6.65514823e-03f, 4.22196742e-03f, 1.48613015e-02f, 1.04723871e-01f, -1.33611038e-01f, 2.66970899e-02f, -1.88041046e-01f, -1.87887251e-02f, 1.87342569e-01f, 4.75708544e-02f,
  -6.59852549e-02f, -1.30128087e-02f, 1.16363928e-01f, 7.71552697e-02f, -7.92890191e-02f, 2.07945138e-01f, -5.30232899e-02f, 9.55852792e-02f, -6.24678358e-02f, -2.23438777e-02f,
  -1.02198590e-02f, -2.48435348e-01f, -6.17365129e-02f, -5.02466522e-02f, -6.34233728e-02f, 9.11830924e-03f, -1.01477414e-01f, -1.41324520e-01f, -1.71212226e-01f, 9.59041808e-03f,
  2.51358561e-02f, 1.24703171e-02f, 2.94659268e-02f, -1.18705124e-01f, 4.39278990e-01f, -1.00867674e-01f, 2.48285174e-01f, -1.40484586e-01f, -6.97863521e-03f, 2.50442833e-01f,
  -7.30917975e-02f, 2.43997574e-01f, -1.84372384e-02f, -2.83087581e-01f, 2.18365744e-01f, 3.87898833e-01f, -2.67695040e-01f, 9.55647156e-02f, -2.01287776e-01f, 4.46743876e-01f,
  -3.40732068e-01f, -1.00398429e-01f, 1.40237033e-01f, 1.66395545e-01f, 4.39762920e-01f, -4.46059965e-02f, 1.99317634e-01f, 1.41686618e-01f, 3.50184381e-01f, -7.89717510e-02f,
  -4.44374979e-03f, 3.30337696e-02f, -3.57147353e-03f, 6.09778725e-02f, 6.24724291e-02f, 1.64236929e-02f, -3.68746147e-02f, 1.09100685e-01f, -3.58332768e-02f, 8.75117555e-02f,
  -1.10944211e-01f, 1.39124691e-01f, 1.28203660e-01f, 6.35559261e-02f, 1.55859739e-01f, -4.19791788e-03f, 6.14500307e-02f, 1.46712452e-01f, 7.84369186e-02f, -1.20167909e-02f,
  -9.38958395e-03f, -2.68438727e-01f, 7.47965425e-02f, 2.00959429e-01f, 1.12510854e-02f, 1.54567614e-01f, 2.90804356e-02f, -1.12366170e-01f, -2.52566367e-01f, -1.64201818e-02f,
  1.33237079e-01f, -1.10116380e-03f, 1.40936757e-02f, 1.99638933e-01f, -1.23402596e-01f, 1.03675639e-02f, -4.16618064e-02f, 7.82816857e-03f, -2.04350829e-01f, 2.34135672e-01f,
  2.31443644e-01f, 2.81964898e-01f, 5.58642112e-02f, 1.09128468e-01f, -1.11720353e-01f, -1.10773221e-02f, -2.16210723e-01f, 1.81370795e-01f, -2.50012260e-02f, 3.45947057e-01f,
  -6.31207153e-02f, -2.58905571e-02f, 1.92934513e-01f, 2.10688516e-01f, -5.72689921e-02f, 1.75792500e-01f, 7.32787773e-02f, 1.89643633e-02f, -1.40628085e-01f, 2.63748318e-01f,
  3.37433040e-01f, 2.52650023e-01f, -2.14575492e-02f, 6.15710169e-02f, 1.26848370e-01f, 1.17120206e-01f, -2.52747424e-02f, 7.04585016e-02f, 4.83813360e-02f, 1.58842251e-01f,
  3.63165252e-02f, 1.15455106e-01f, 2.97460735e-01f, 2.41586804e-01f, 2.21133813e-01f, -2.87870560e-02f, 4.39039618e-02f, 5.85903935e-02f, -3.51993181e-02f, 2.64730304e-01f,
  1.31101593e-01f, 3.87697779e-02f, 2.81387001e-01f, -6.25686944e-02f, 1.40082926e-01f, 1.15427278e-01f, -1.71758041e-01f, -9.00702178e-02f, -1.62301049e-01f, 1.34446025e-01f,
  2.17091618e-03f, -1.38297752e-01f, -1.15499301e-02f, 2.41510496e-01f, 1.42716095e-01f, 1.31415501e-01f, -3.75704244e-02f, 1.24123573e-01f, 2.09342420e-01f, -1.06410198e-01f,
  -5.11177517e-02f, 8.48469362e-02f, 2.92436153e-01f, 1.65019438e-01f, -2.62597620e-01f, 1.51971176e-01f, 2.49018416e-01f, 5.49945198e-02f, 1.93652630e-01f, 2.89580405e-01f,
  2.64790952e-01f, -1.10411003e-01f, 2.89076567e-01f, -3.51650417e-01f, 2.34837413e-01f, 9.96730998e-02f, -1.02016859e-01f, -1.02782771e-01f, -5.59491180e-02f, 2.36787140e-01f,
  3.30539197e-01f, 2.17216328e-01f, 5.33719175e-02f, 1.46687478e-01f, -1.28434330e-01f, -7.70397261e-02f, 3.85153145e-02f, 2.04780385e-01f, 1.81551427e-01f, -8.31477866e-02f,
  -3.48461904e-02f, -1.10625084e-02f, 9.74118412e-02f, 1.68288633e-01f, -2.93804854e-02f, 7.69146159e-02f, 2.94773370e-01f, 1.45139396e-01f, 1.87762871e-01f, 1.15915142e-01f,
  -3.10691372e-02f, -8.38730931e-02f, 1.87837556e-02f, 9.66332555e-02f, 7.38860434e-03f, 1.71219587e-01f, 1.79826215e-01f, -1.01724394e-01f, 1.97763927e-02f, 9.47665796e-02f,
  -8.51702839e-02f, 1.20576836e-01f, -1.88890830e-01f, 1.80971563e-01f, -5.40153906e-02f, 5.03384396e-02f, 5.97140118e-02f, 7.72881806e-02f, -4.73607033e-02f, 1.63734868e-01f,
  -4.59756926e-02f, 7.56920502e-02f, -9.24561080e-03f, -1.37635261e-01f, -1.02505900e-01f, -8.77006724e-03f, 9.54744220e-03f, -2.63340995e-02f, -6.67303354e-02f, 1.54167414e-01f,
  -7.51342177e-02f, -2.32185110e-01f, 2.04641223e-01f, -8.62654224e-02f, 6.80914894e-02f, -4.48569767e-02f, -1.68353673e-02f, -1.09475650e-01f, 1.88685551e-01f, -1.63598899e-02f,
  -3.39487717e-02f, -1.50826529e-01f, -3.10656894e-02f, 2.78119475e-01f, -9.06113535e-03f, 1.60087317e-01f, -8.00170153e-02f, -8.74767825e-02f, -9.11713839e-02f, 7.93217644e-02f,
  -1.33797750e-01f, 3.26720893e-01f, -1.51221396e-03f, 1.30748739e-02f, 9.20811072e-02f, -8.36820528e-02f, -7.37589877e-03f, -5.75285442e-02f, 2.12201593e-03f, -4.57806252e-02f,
  -7.27634295e-04f, 3.84562612e-02f, -5.33385724e-02f, -1.01726085e-01f, -3.20272557e-02f, 5.52248843e-02f, -8.30755979e-02f, -1.25536591e-01f, 5.73660107e-03f, 1.19805569e-02f,
  -5.68800839e-03f, 3.01051382e-02f, -8.03079233e-02f, 3.16144601e-02f, 6.32523745e-02f, 6.80554211e-02f, -1.24048069e-01f, -2.70737946e-01f, -4.03804705e-02f, -4.43502329e-02f,
  -4.41769809e-02f, -1.94941327e-01f, 1.22986801e-01f, -2.33649686e-01f, 2.07787290e-01f, 2.35467851e-02f, -2.19450697e-01f, 2.22199839e-02f, 6.58062026e-02f, -2.97787171e-02f,
  -6.38655424e-02f, -1.94889650e-01f, 2.87129670e-01f, -1.11866206e-01f, 2.31924027e-01f, -1.70049071e-01f, -1.75817236e-01f, 1.68104246e-02f, 1.19344525e-01f, -1.99250445e-01f,
  -2.24055246e-01f, 4.62598622e-01f, 2.98459560e-01f, 2.57902384e-01f, -1.41562685e-01f, 2.16676936e-01f, -2.34876554e-02f, -1.35275856e-01f, -1.98735639e-01f, -1.27137378e-01f,
  1.60647616e-01f, -5.61848320e-02f, 5.02719916e-02f, 2.00979307e-01f, 2.71410704e-01f, 6.64146021e-02f, 1.45129219e-01f, 2.00475231e-02f, 5.25235981e-02f, 8.64748284e-02f,
  1.34062842e-01f, 1.48285627e-01f, 6.83601871e-02f, -3.40656042e-02f, 1.37507185e-01f, -1.36391846e-02f, 1.78726718e-01f, 1.79077476e-01f, 1.90091878e-01f, 1.38262495e-01f,
  2.49458894e-01f, 1.73798561e-01f, -7.03477040e-02f, 5.54517619e-02f, -8.16312879e-02f, 2.13500820e-02f, 1.06144860e-01f, -2.13715285e-02f, 6.18386045e-02f, -7.50420988e-02f,
  -1.09349109e-01f, 4.05315191e-01f, -1.56608418e-01f, 4.71879691e-02f, -1.10754773e-01f, 6.50417730e-02f, 6.65983409e-02f, 9.76766869e-02f, 4.07285616e-02f, -3.18142921e-02f,
  7.13766664e-02f, -1.78013623e-01f, -4.52408977e-02f, 2.49554709e-01f, -1.99279159e-01f, 3.73570681e-01f, 4.05967049e-02f, 5.72870336e-02f, -1.18015990e-01f, 5.87105453e-02f,
  2.01263189e-01f, -2.47196153e-01f, -8.36848617e-02f, 1.72889411e-01f, -2.51858234e-01f, -2.56951470e-02f, 1.38289958e-01f, -2.87721623e-02f, 1.32668406e-01f, 2.67832540e-03f,
  3.91614847e-02f, 8.29558820e-02f, -1.54862687e-01f, -1.60616040e-01f, -1.64181247e-01f, 1.07369073e-01f, 1.15531221e-01f, 1.68435782e-01f, -5.84088638e-02f, 1.14126705e-01f,
  -2.01539919e-01f, 1.72034279e-02f, -1.36166081e-01f, -2.12202482e-02f, 8.38609338e-02f, -7.08225891e-02f, 7.12714419e-02f, 6.18804321e-02f, 5.66782616e-02f, 2.13056937e-01f,
  1.51318014e-01f, 2.49291714e-02f, 7.14913905e-02f, 2.14587495e-01f, 1.00716382e-01f, 3.18427086e-02f, -7.14831380e-03f, 7.59221166e-02f, 4.32071596e-01f, -4.04430956e-01f,
  -3.94042358e-02f, -1.99235231e-01f, 9.67333913e-02f, -2.44225897e-02f, -1.62507609e-01f, 1.21617131e-01f, 2.40607530e-01f, -1.02553070e-01f, -1.71846207e-02f, -5.37834167e-02f,
  -4.37298566e-02f, 1.14880495e-01f, 1.41757801e-01f, -1.70096725e-01f, -3.67876515e-02f, 2.85916291e-02f, 9.77070704e-02f, -3.17370929e-02f, -2.47863784e-01f, 9.48856026e-02f,
  2.11852118e-01f, 2.19765194e-02f, 1.50290504e-01f, 2.91804224e-01f, 3.50376189e-01f, 2.24749688e-02f, -1.89902961e-01f, 1.96677685e-01f, 2.11592138e-01f, 2.31879860e-01f,
  1.72215402e-01f, -4.66913998e-01f, 3.18809092e-01f, 1.43998563e-01f, 1.08904891e-01f, 5.95084280e-02f, 1.94670886e-01f, -1.37691990e-01f, -2.81477004e-01f, 5.19158900e-01f,
  8.67967755e-02f, 3.88397843e-01f, -2.81714737e-01f, 3.26292455e-01f, 2.07674846e-01f, 2.08777171e-02f, 1.20017156e-01f, 1.17440917e-01f, 1.55178636e-01f, 1.26966268e-01f,
  5.89410253e-02f, 8.49797670e-03f, 3.33728804e-03f, -1.53269455e-01f, -1.69133320e-01f, 1.33944020e-01f, -2.03258738e-01f, 6.09530881e-02f, 1.90890640e-01f, 4.76638153e-02f,
  -1.13055147e-02f, 1.92302451e-01f, -1.13256626e-01f, 4.49713394e-02f, -7.43460888e-03f, -3.16243142e-01f, 9.66975912e-02f, 2.14803919e-01f, 2.14908585e-01f, -1.62405282e-01f,
  2.80666918e-01f, 1.62585050e-01f, 7.67597258e-02f, -2.47472316e-01f, -4.35120203e-02f, 2.64917701e-01f, 7.45959058e-02f, 2.10534021e-01f, -3.20166826e-01f, 4.10369113e-02f,
  -3.88553664e-02f, -2.20109582e-01f, 1.79481115e-02f, 4.79737148e-02f, 1.76308826e-01f, 2.95285434e-01f, -1.38578817e-01f, -3.05010408e-01f, -3.13466728e-01f, -1.98308423e-01f,
  4.09636885e-01f, 2.43082181e-01f, -4.04823907e-02f, 1.85118869e-01f, 1.16528779e-01f, 1.27011776e-01f, 1.41935125e-01f, -2.95656379e-02f, 1.21157080e-01f, 3.86145473e-01f,
  2.52987277e-02f, 3.73212546e-01f, 2.54969180e-01f, -2.21361816e-01f, -4.07542624e-02f, -7.69477012e-03f, 6.34104805e-03f, -4.95844670e-02f, -5.55035882e-02f, 1.08443044e-01f,
  4.53170277e-02f, -5.24297766e-02f, 7.55554885e-02f, 1.59722105e-01f, 1.75169036e-01f, 1.25883564e-01f, 1.49102852e-01f, 1.43892109e-01f, 2.78937280e-01f, 9.46397856e-02f,
  7.63308629e-02f, 1.37229323e-01f, -1.15794502e-01f, 1.36577755e-01f, 1.06388465e-01f, 2.90188147e-03f, 1.92458838e-01f, -2.52940416e-01f, 7.45116100e-02f, 2.13575229e-01f,
  -8.47577676e-02f, -2.43351385e-01f, -1.48047432e-01f, -7.71424845e-02f, 8.98742080e-02f, 2.94916090e-02f, 2.05757439e-01f, 9.08617973e-02f, -2.67875284e-01f, 1.22912347e-01f,
  1.98857002e-02f, -2.61019737e-01f, 2.54659116e-01f, -1.32136077e-01f, -1.14560174e-02f, 8.27861726e-02f, 1.98939845e-01f, -4.26758453e-03f, -1.84420273e-01f, -1.66572690e-01f,
  -1.67988315e-02f, 2.41563451e-02f, 3.57650518e-01f, -9.23140272e-02f, 8.26303959e-02f, -2.76230518e-02f, 9.47781198e-04f, -2.29591444e-01f, 2.60484129e-01f, -2.50873007e-02f,
  -4.63403799e-02f, -1.67058751e-01f, 1.05886936e-01f, 9.09157470e-02f, -1.02947280e-01f, 8.52115527e-02f, 7.64616057e-02f, 1.77753136e-01f, -2.44690597e-01f, 5.61823808e-02f,
  2.37376858e-02f, 2.69972265e-01f, 1.53945580e-01f, 2.29837298e-01f, 3.27525198e-01f, 6.67174309e-02f, 7.99117312e-02f, 1.99557781e-01f, 2.31726512e-01f, 1.69262782e-01f,
  -9.84665006e-03f, 6.37530535e-02f, 2.50154976e-02f, 1.51781654e-02f, 8.92265961e-02f, 1.93270054e-02f, -8.39875042e-02f, 6.81289062e-02f, 2.26608261e-01f, 1.74677759e-01f,
  -4.22924459e-02f, 1.74714938e-01f, -1.28257796e-01f, 3.89641136e-01f, -1.11780375e-01f, 2.56121874e-01f, -1.58745889e-02f, -2.28600502e-01f, 6.20769896e-03f, 1.57860786e-01f,
  3.28460187e-01f, -2.47980338e-02f, -2.38652557e-01f, -1.55445516e-01f, -1.20112270e-01f, -3.73594984e-02f, -8.71284008e-02f, 3.12472463e-01f, 1.05273455e-01f, -1.42427087e-01f,
  3.88862103e-01f, -3.12327772e-01f, 5.08125871e-02f, -1.33834749e-01f, 1.07293800e-01f, -1.73529640e-01f, -2.07249299e-02f, -1.82703906e-03f, 2.25576088e-01f, 3.05470359e-02f,
  1.36296880e-02f, 6.20829090e-02f, 1.52955413e-01f, 4.04035807e-01f, -3.12169679e-02f, 1.49273187e-01f, 3.52219611e-01f, -1.65237114e-01f, -8.65481943e-02f, 3.32984239e-01f,
  3.86343807e-01f, -1.97303861e-01f, 3.50451842e-02f, -1.89680859e-01f, 4.72179949e-01f, -5.55080846e-02f, 6.02111593e-02f, 6.83403090e-02f, -1.42651469e-01f, -1.18707484e-02f,
  6.17819540e-02f, -9.23590288e-02f, 4.37359251e-02f, 1.03708483e-01f, 5.03837550e-03f, 1.13523789e-01f, -1.51606351e-01f, 2.02134494e-02f, 7.09921718e-02f, 6.02620617e-02f,
  8.22874904e-02f, 3.00954301e-02f, 1.55635104e-01f, 8.23711883e-03f, 1.74370125e-01f, -8.68409220e-03f, -8.02194998e-02f, -2.32831195e-01f, 1.67744830e-01f, 1.63463235e-01f,
  -3.36779794e-03f, 1.00069076e-01f, -2.06064228e-02f, -2.25587741e-01f, -1.96788460e-01f, 5.91334477e-02f, 2.24669382e-01f, 5.26246149e-03f, -1.62433591e-02f, 1.89262494e-01f,
  2.28607189e-02f, 1.87292859e-01f, 7.12366998e-02f, -1.07298493e-01f, -1.71874657e-01f, 9.17832181e-02f, 8.89131725e-02f, 2.83231407e-01f, 2.93873012e-01f, 1.46940514e-01f,
  -1.57798424e-01f, 1.50920615e-01f, -7.23104030e-02f, 2.13910028e-01f, 2.36638024e-01f, 1.44149333e-01f, 3.52296047e-02f, -7.67989606e-02f, 2.70456076e-01f, 1.54622808e-01f,
  1.98638335e-01f, -8.12103078e-02f, 2.95943975e-01f, -1.00415796e-01f, -3.16665709e-01f, 1.57875881e-01f, 2.83508301e-01f, 1.37425378e-01f, -2.06816912e-01f, -9.34377611e-02f,
  -1.15956821e-01f, 1.51954100e-01f, 3.55175398e-02f, 9.92022380e-02f, -1.92000587e-02f, 3.81500833e-02f, 2.53125489e-01f, 4.75977510e-02f, -9.13123190e-02f, -5.51247224e-02f,
  1.74791366e-01f, -2.71899756e-02f, 1.73176974e-01f, 1.45373687e-01f, 5.92686702e-03f, -7.36961141e-03f, 9.64543223e-02f, -2.60131396e-02f, 1.85093537e-01f, -4.90767099e-02f,
  -2.47967631e-01f, -6.37103170e-02f, 1.30087763e-01f, -2.02462956e-01f, 2.01813355e-01f, -3.13877553e-01f, 3.05522382e-01f, 7.40727335e-02f, 2.32520118e-01f, -3.41132790e-01f,
  -2.61135489e-01f, -2.63595611e-01f, 4.32015024e-02f, -3.29265654e-01f, -8.24374240e-03f, 2.08756074e-01f, 2.05514520e-01f, -1.34795725e-01f, 1.54278442e-01f, -9.75292474e-02f,
  2.89518744e-01f, -1.40360713e-01f, 2.42142394e-01f, 4.03851122e-01f, 2.98085660e-01f, 2.10381284e-01f, -2.10495442e-01f, 1.96269244e-01f, 1.67432457e-01f, 3.58544856e-01f,
  3.67193162e-01f, 5.94065674e-02f, 2.50289708e-01f, 1.01511493e-01f, 2.92218745e-01f, -3.19220424e-01f, 1.60483971e-01f, -3.34149331e-01f, 2.04979792e-01f, 2.74706483e-01f,
  -1.57258108e-01f, -2.12353896e-02f, 4.73636389e-01f, -4.14454974e-02f, 2.46268168e-01f, -1.59931295e-02f, 4.61059511e-02f, 1.62167490e-01f, 5.85492328e-02f, 1.45332087e-02f,
  -1.59536093e-01f, -7.93766081e-02f, 2.35183656e-01f, -2.31652688e-02f, 2.17387360e-02f, 7.14681894e-02f, -2.26570189e-01f, 6.36584684e-02f, 2.08379209e-01f, 3.05846278e-02f,
  -1.69454202e-01f, 1.77055284e-01f, -9.74323675e-02f, 8.63740444e-02f, 9.90800261e-02f, -1.91630900e-01f, -1.37660623e-01f, 7.74269551e-03f, 1.00088216e-01f, 8.18553939e-02f,
  -1.46480590e-01f, -1.13047529e-02f, -1.17412224e-01f, -2.63624340e-01f, 2.60763466e-01f, -1.50604963e-01f, 1.27310127e-01f, 2.26412341e-01f, -2.68599004e-01f, -1.03928335e-01f,
  -1.38219878e-01f, -1.06533490e-01f, -2.29460284e-01f, 1.38222381e-01f, 1.82480305e-01f, 2.02318415e-01f, 1.97243005e-01f, -6.93720654e-02f, -1.75474778e-01f, 3.48207414e-01f,
  1.91507474e-01f, -3.86613049e-02f, 1.76682174e-02f, 3.09355438e-01f, 2.24000767e-01f, 2.84861565e-01f, -6.95717484e-02f, -2.31509246e-02f, -7.37515315e-02f, 1.97961941e-01f,
  7.65611976e-02f, -6.89173769e-03f, 1.51972100e-01f, -9.80858058e-02f, -2.24078372e-02f, 1.60661191e-01f, 1.56369686e-01f, 2.02508375e-01f, 1.25811204e-01f, -2.07491051e-02f,
  2.69728675e-02f, 7.97807947e-02f, 1.14567675e-01f, 1.46259487e-01f, 3.49632055e-02f, 1.12513818e-01f, 1.66534051e-01f, 7.67892152e-02f, 9.94326919e-02f, 9.97467637e-02f,
  -9.19905771e-03f, 1.25650510e-01f, 9.17064324e-02f, 8.50540847e-02f, -1.57616027e-02f, 1.31268501e-01f, 2.67247498e-01f, -2.07409099e-01f, -9.36530605e-02f, -5.38636185e-02f,
  7.72010610e-02f, -1.76261943e-02f, -2.82678232e-02f, -1.46246667e-03f, 2.87719190e-01f, 1.47739097e-01f, 2.69443601e-01f, -1.89160764e-01f, -3.38774830e-01f, 2.44725212e-01f,
  -2.16463301e-02f, -2.25121886e-01f, -7.67021775e-02f, -4.73175943e-02f, 3.84167023e-02f, -1.33256137e-01f, 1.78549916e-01f, -8.72169659e-02f, 2.32439354e-01f, 1.17546218e-02f,
  -2.72621483e-01f, -1.21727549e-01f, 3.70071977e-01f, -1.53857723e-01f, 4.01860736e-02f, 3.95444073e-02f, 1.78391010e-01f, 1.66463062e-01f, 1.40164733e-01f, -2.01358944e-01f,
  8.07634443e-02f, -2.19098777e-02f, -1.37421504e-01f, 3.01362276e-01f, 8.96936432e-02f, 7.90050924e-02f, 3.58568072e-01f, 2.43250374e-02f, -2.25157380e-01f, 2.27641925e-01f,
  8.49755555e-02f, 3.24197531e-01f, -1.32229745e-01f, 2.16784060e-01f, 4.96644080e-02f, -1.20918564e-01f, 7.79598951e-02f, -4.12913151e-02f, 2.08871484e-01f, 6.35773614e-02f,
  -2.23836690e-01f, 1.71651214e-01f, 5.65317981e-02f, -8.45364705e-02f, 2.90762447e-03f, 2.04699069e-01f, -4.61834408e-02f, 1.14520807e-02f, 1.45925507e-01f, -7.44347796e-02f,
  1.90437466e-01f, -2.39896476e-01f, 2.60445494e-02f, -6.34452775e-02f, 7.36449435e-02f, -1.40141532e-01f, -3.20324078e-02f, -1.46111548e-01f, 1.25088498e-01f, -2.45599270e-01f,
  1.48917371e-02f, 4.22017574e-02f, 1.39750645e-01f, -1.84095293e-01f, 2.61741340e-01f, -4.90914062e-02f, 1.63312666e-02f, 1.40304998e-01f, 7.65497014e-02f, -2.83665787e-02f,
  -1.89222589e-01f, -4.92139272e-02f, 2.15152167e-02f, -1.60370424e-01f, 4.42496508e-01f, 2.36952245e-01f, -4.73939329e-02f, 1.91943780e-01f, 4.55334857e-02f, 9.62238163e-02f,
  8.16169083e-02f, 1.11234702e-01f, 3.15196544e-01f, 8.24314654e-02f, 1.28313720e-01f, 9.06651765e-02f, 4.27505136e-01f, -3.02442282e-01f, 4.57619270e-03f, -8.84659886e-02f,
  -1.70814037e-01f, 3.64041597e-01f, 8.36609006e-02f, 1.23993382e-01f, -5.97767578e-03f, -1.29468843e-01f, 4.43268344e-02f, 1.52015835e-01f, 1.91328079e-02f, 2.36868532e-03f,
  7.30577856e-02f, 1.71436623e-01f, 2.36204993e-02f, 2.05523491e-01f, 1.21975668e-01f, 2.47534513e-01f, -1.11736737e-01f, 1.75053477e-01f, 1.86367854e-01f, -7.65702799e-02f,
  -5.41355163e-02f, 1.51263595e-01f, 2.13779762e-01f, 2.30326861e-01f, 2.28305474e-01f, 9.34459716e-02f, -2.01514661e-02f, 1.57955065e-01f, 3.06566898e-02f, 2.17330351e-01f,
  -2.41701722e-01f, -5.50165214e-02f, 7.43175223e-02f, -8.06417502e-03f, 7.24008232e-02f, 2.28220686e-01f, -2.17284873e-01f, 2.51449376e-01f, -1.44675598e-01f, -7.14604883e-03f,
  7.02893808e-02f, -2.44072862e-02f, -3.31089608e-02f, 6.34529581e-03f, 3.97357911e-01f, -7.39775375e-02f, 1.89408556e-01f, 1.03875935e-01f, -1.86557606e-01f, -1.53292820e-01f,
  2.70194650e-01f, -1.45993054e-01f, 7.87841007e-02f, -2.38905594e-01f, 2.00929791e-01f, 6.30037412e-02f, -1.88329682e-01f, -1.38428658e-01f, -1.53829828e-01f, 2.49004886e-01f,
  -3.45690697e-01f, 3.06740195e-01f, 1.02708630e-01f, 3.27883840e-01f, 2.45015368e-01f, 6.75533339e-02f, 1.02170780e-01f, 1.43862471e-01f, 9.71167758e-02f, 3.17120582e-01f,
  -3.43348831e-03f, 1.15292184e-01f, 9.55815837e-02f, 3.06283664e-02f, 1.08303003e-01f, 8.51362050e-02f, 2.21028551e-01f, 1.03579108e-02f, 1.30944714e-01f, 1.29274338e-01f,
  2.69211203e-01f, 9.63403285e-02f, 2.61731327e-01f, 1.90180466e-01f, 3.13974321e-02f, 1.38635844e-01f, 8.59491378e-02f, 7.09552178e-03f, 1.28319591e-01f, -3.59414592e-02f,
  8.56417716e-02f, 1.93581849e-01f, 9.05075744e-02f, -3.67874026e-01f, -9.27639306e-02f, 6.14669640e-03f, -1.70924604e-01f, -4.10503596e-02f, -1.65812373e-02f, 5.03701903e-02f,
  -2.28189789e-02f, -6.58994466e-02f, 5.98565042e-02f, -2.91279495e-01f, 3.06844711e-01f, -2.41472185e-01f, 1.49838487e-02f, 2.43325070e-01f, 4.65485901e-02f, 1.40485093e-01f,
  1.25435799e-01f, -1.99398220e-01f, 1.82280213e-01f, 2.51119822e-01f, 3.60590458e-01f, -1.18526323e-02f, -1.22770973e-01f, -1.56406701e-01f, -2.39486739e-01f, 9.96733755e-02f,
  3.56146723e-01f, 2.57408440e-01f, -9.33194607e-02f, 1.84375837e-01f, -2.37620920e-02f, -1.27694353e-01f, -2.24569023e-01f, -1.43873587e-01f, -5.48155345e-02f, 9.54670012e-02f,
  6.07576892e-02f, 2.93479741e-01f, 1.77426234e-01f, 2.28716657e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.68495327e-01f, 1.32484540e-01f, 8.21540132e-02f, 1.02291562e-01f, 1.64954036e-01f, 1.36268422e-01f, 3.57765853e-02f, 1.04945458e-01f, 1.62627131e-01f, 1.04067191e-01f,
  1.19456664e-01f, 6.15143329e-02f, 7.20977187e-02f, -2.19390113e-02f, 7.14504421e-02f, 2.60547306e-02f, 3.15075181e-02f, 7.30967522e-02f, 1.96981117e-01f, 3.88587750e-02f,
  1.61846489e-01f, 9.85219032e-02f, 1.71866007e-02f, -1.32431341e-02f, 1.92846671e-01f, 1.15593091e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.80215681e-01f, 1.21565633e-01f, 8.02554712e-02f, -2.40865797e-01f, 2.23665729e-01f, -1.43828705e-01f, 7.36215189e-02f, -7.35322088e-02f, 1.22760637e-02f, -8.03111270e-02f,
  -1.40013471e-01f, -1.84998870e-01f, -1.16387568e-01f, -3.31174843e-02f, -2.51032919e-01f, 8.12827051e-02f, 1.03079509e-02f, -2.84226805e-01f, 1.02387788e-02f, -4.17814888e-02f,
  -1.61194891e-01f, 1.90970212e-01f, -4.65995185e-02f, 3.17261256e-02f, 3.50303918e-01f, 1.65179148e-01f, 1.72901109e-01f, 3.00684243e-01f, 1.77941129e-01f, 4.48502153e-02f,
  -2.07839847e-01f, -2.73514688e-01f, 2.99913347e-01f, 2.42991015e-01f, -8.78410712e-02f, -1.52261913e-01f, -1.36514187e-01f, -1.04589425e-01f, -3.61478746e-01f, -3.99316341e-01f,
  1.24923572e-01f, 1.42769381e-01f, -8.45560133e-02f, 2.53012091e-01f, -9.99848843e-02f, -5.00076175e-01f, 2.67396867e-01f, 1.15295872e-01f, -4.55728084e-01f, 2.33445734e-01f,
  1.72772124e-01f, -1.79682434e-01f, -3.82992923e-01f, -3.77961069e-01f, 3.85489613e-01f, 1.55092418e-01f, 1.94045439e-01f, -3.10074061e-01f, -4.97916907e-01f, -6.78250641e-02f,
  2.75223076e-01f, -2.75138348e-01f, 3.47655535e-01f, -4.87944156e-01f, 1.07779959e-03f, 2.35658884e-02f, 6.97884932e-02f, -2.81259194e-02f, -2.53104866e-01f, 2.69585028e-02f,
  1.19568914e-01f, 3.14264223e-02f, 7.20951408e-02f, -2.43303314e-01f, 8.73114541e-03f, 4.75551151e-02f, 4.03408855e-02f, 1.63370997e-01f, -2.43913874e-01f, -1.31196126e-01f,
  1.87688366e-01f, 1.81076393e-01f, 2.30735660e-01f, -3.66190463e-01f, -2.33132362e-01f, -3.96368921e-01f, -1.87852234e-01f, 1.49506554e-01f, 1.24392502e-01f, 1.20656073e-01f,
  2.71830201e-01f, 8.20582435e-02f, 9.48536471e-02f, -3.02043676e-01f, 2.89014190e-01f, 1.53006896e-01f, -1.10940993e-01f, 1.69848070e-01f, 2.68722743e-01f, 3.12211990e-01f,
  1.40355900e-01f, -2.21328303e-01f, 2.53774434e-01f, -4.84540969e-01f, 2.76773185e-01f, 2.37635925e-01f, -3.91485006e-01f, -1.12181986e-02f, -5.37788987e-01f, 2.29570195e-01f,
  8.51673782e-02f, -3.93732935e-01f, 2.88575292e-01f, 1.65303141e-01f, 1.85520068e-01f, -1.52552694e-01f, 7.92716965e-02f, 3.07723638e-02f, 2.95259863e-01f, -3.31252068e-01f,
  -6.49882734e-01f, 2.52999276e-01f, -5.97465396e-01f, 3.00388515e-01f, 1.18357623e-02f, -5.47630191e-01f, 9.62607637e-02f, -5.79914987e-01f, -9.14296731e-02f, 1.58208963e-02f,
  -5.20209223e-02f, -2.26413161e-01f, 1.45716354e-01f, -7.88676832e-03f, 1.83644488e-01f, -8.25248063e-02f, 1.34659261e-01f, 9.40511283e-03f, -1.70738444e-01f, -3.05043347e-02f,
  -3.37038815e-01f, 2.48988971e-01f, -1.69443965e-01f, -7.52476901e-02f, -2.72182465e-01f, 3.09748314e-02f, 1.24373093e-01f, 3.39670867e-01f, -3.70671809e-01f, -1.38890728e-01f,
  -9.16059241e-02f, -1.60520941e-01f, 2.38399908e-01f, -2.22662106e-01f, -2.93549180e-01f, -1.97638143e-02f, 1.53288648e-01f, 1.71199977e-01f, 2.78116763e-01f, 2.18980193e-01f,
  -1.37193739e-01f, 5.55198342e-02f, 2.57713515e-02f, 2.11742327e-01f, 3.12885612e-01f, 1.29820138e-01f, 2.88385361e-01f, -1.66223943e-01f, -3.96141410e-01f, 3.00884634e-01f,
  1.99486971e-01f, -3.61294091e-01f, -5.25731087e-01f, -7.78063387e-03f, -3.87487352e-01f, -2.02952594e-01f, 1.98411897e-01f, 3.34214000e-03f, -4.01677758e-01f, -1.37958288e-01f,
  1.27907693e-01f, 3.96956593e-01f, -4.27186608e-01f, 9.21535492e-02f, -4.62088794e-01f, 2.24388063e-01f, 1.99536383e-01f, -6.20527565e-01f, -3.01453114e-01f, 3.65810156e-01f,
  -1.56369135e-01f, -5.26875295e-02f, 1.27540976e-01f, -4.47401851e-02f, -1.97945386e-01f, 1.05751483e-02f, -1.35724172e-01f, -3.39251310e-02f, 1.36055142e-01f, 5.53856976e-02f,
  1.23347547e-02f, -1.70349091e-01f, -1.73273712e-01f, -2.23997071e-01f, -1.18676543e-01f, -4.85297404e-02f, -7.49113411e-02f, 5.80381975e-02f, -2.47124404e-01f, 1.52841538e-01f,
  2.28304282e-01f, -1.97309241e-01f, 1.26716375e-01f, -1.43659130e-01f, -2.53247499e-01f, -1.53659061e-01f, -1.52220264e-01f, -2.68047035e-01f, 7.68069401e-02f, 2.81941712e-01f,
  1.43538527e-02f, -2.70362288e-01f, 7.00514838e-02f, -2.44289398e-01f, 2.74857995e-03f, -2.99460858e-01f, 2.27501377e-01f, -1.68256626e-01f, -7.11945668e-02f, 3.79810542e-01f,
  -2.50345767e-02f, -4.35094982e-01f, -1.96671188e-01f, -3.22814912e-01f, -2.54697911e-02f, 1.09808028e-01f, -2.53654480e-01f, -4.89495516e-01f, -1.79392412e-01f, 4.10530269e-01f,
  4.43500802e-02f, -6.61316872e-01f, -1.98425367e-01f, 3.22346658e-01f, -3.19558591e-01f, -5.85620105e-01f, 2.35925794e-01f, -3.68330032e-01f, 3.45381200e-01f, -4.58478034e-01f,
  3.54675084e-01f, 2.55250603e-01f, 1.30309775e-01f, -2.15509951e-01f, 3.18873227e-02f, -1.63559079e-01f, 3.67431700e-01f, 1.20050274e-02f, -2.33345926e-01f, -1.45974219e-01f,
  -8.26124251e-02f, 7.44031444e-02f, -7.69186541e-02f, 1.89885646e-01f, 6.50030077e-02f, 3.06270450e-01f, 1.52302399e-01f, 4.50804979e-02f, 1.87828138e-01f, -2.05887988e-01f,
  4.45287257e-01f, 2.26319894e-01f, -2.44341101e-02f, 1.14745751e-01f, 2.24110968e-02f, 1.36863917e-01f, -9.72123072e-02f, 4.70784307e-01f, 1.26734562e-02f, -4.10423368e-01f,
  -2.25465372e-01f, -2.92274475e-01f, -4.42981601e-01f, -8.80918056e-02f, -6.56548262e-01f, -3.05207968e-01f, -3.79360616e-01f, 3.32059026e-01f, 4.43595946e-01f, -1.94412261e-01f,
  7.69916996e-02f, 9.15668160e-02f, 1.43869981e-01f, -3.33651602e-01f, 3.27181250e-01f, 2.98262507e-01f, -3.55136603e-01f, -1.16666518e-01f, -4.95244622e-01f, 2.66166520e-03f,
  6.33847490e-02f, -1.33674100e-01f, -1.02945762e-02f, 1.00942269e-01f, -5.19764662e-01f, 1.44291759e-01f, 1.07583843e-01f, -2.15404466e-01f, -9.51418355e-02f, -1.30567133e-01f,
  -4.06648308e-01f, 3.59552920e-01f, 1.88503906e-01f, -2.50930458e-01f, 3.45810533e-01f, -4.51699317e-01f, 2.49017805e-01f, -2.58195519e-01f, 2.80440867e-01f, 3.31479400e-01f,
  3.46205711e-01f, 3.05943191e-01f, 2.49535590e-02f, 1.46039858e-01f, -3.33206840e-02f, 6.60945326e-02f, 5.75379767e-02f, -1.74965739e-01f, 9.43391547e-02f, -5.62463105e-02f,
  -1.37385875e-02f, 2.35560417e-01f, 1.71778545e-01f, 1.74772829e-01f, 1.11066438e-01f, 1.15431502e-01f, -1.00395055e-02f, 7.97858611e-02f, -3.90990339e-02f, -1.76515847e-01f,
  2.94476092e-01f, -4.37364310e-01f, -1.70197964e-01f, 3.22624892e-01f, -3.21341366e-01f, -3.32908005e-01f, 3.89641434e-01f, -4.00011420e-01f, 3.36171746e-01f, -2.94659317e-01f,
  4.21446443e-01f, -1.16169255e-03f, -5.30075490e-01f, 9.65712219e-02f, -4.23320681e-01f, -1.31850109e-01f, -3.70472819e-01f, -1.61103263e-01f, -4.80118543e-01f, 4.69419986e-01f,
  3.16013128e-01f, -4.10588026e-01f, -4.00949270e-01f, 1.36093274e-01f, 5.20810664e-01f, 2.72289872e-01f, 1.59363985e-01f, 2.27004677e-01f, 7.92715698e-02f, 2.68346239e-02f,
  2.11756565e-02f, -3.23462725e-01f, 1.69147812e-02f, -3.45877111e-01f, -2.28625670e-01f, -2.15709969e-01f, 2.10388109e-01f, 1.00352384e-01f, -7.72562265e-01f, -2.93572903e-01f,
  -4.62229937e-01f, -1.07123725e-01f, 2.74291605e-01f, -1.69586048e-01f, 6.49477020e-02f, -3.65421809e-02f, -1.11446448e-01f, 9.28129181e-02f, 2.67184023e-02f, 1.17908269e-01f,
  -5.82330488e-02f, 8.51499364e-02f, 1.78144470e-01f, 8.95592496e-02f, 1.64477870e-01f, -1.01776198e-01f, 2.37194359e-01f, -1.37664005e-01f, 1.20951608e-02f, -2.32691206e-02f,
  2.97088087e-01f, 2.09398359e-01f, 7.71779567e-02f, 2.03500688e-01f, 3.87753338e-01f, -2.73168683e-01f, -1.84542090e-01f, 1.97508618e-01f, 3.44071448e-01f, -3.21054846e-01f,
  5.34260869e-02f, -4.44769561e-02f, 4.46176715e-02f, 1.72852516e-01f, 2.52513647e-01f, 2.52599776e-01f, -1.83364689e-01f, 4.03513946e-02f, 1.58059821e-01f, 3.34984541e-01f,
  2.24761784e-01f, -6.26358911e-02f, -6.43268749e-02f, 2.55007386e-01f, -4.11778182e-01f, 2.47726977e-01f, 1.21522415e+00f, 2.06181571e-01f, -5.41666865e-01f, -6.61036223e-02f,
  -1.10341959e-01f, -2.23770235e-02f, -8.36127922e-02f, -1.86382625e-02f, -1.15749687e-01f, -2.55263418e-01f, 2.98451364e-01f, -5.66578269e-01f, -9.61464867e-02f, -1.19795144e-01f,
  -4.08020258e-01f, -2.13244453e-01f, -2.55945235e-01f, 2.64564186e-01f, -4.83405739e-01f, -2.95431495e-01f, -3.46244156e-01f, 2.61681199e-01f, -1.80517048e-01f, -3.03580370e-02f,
  -1.50158510e-01f, 5.78856878e-02f, -3.30926962e-02f, -1.37380123e-01f, -9.34969038e-02f, -7.80992657e-02f, 1.21559128e-02f, 9.77487341e-02f, -9.97378752e-02f, -1.60185378e-02f,
  -7.10662976e-02f, -2.75942106e-02f, -1.45993367e-01f, -1.29843876e-01f, -4.05483181e-03f, -9.47305560e-02f, 5.31193204e-02f, 2.95285553e-01f, -1.44797817e-01f, 1.23996958e-01f,
  -7.12444633e-02f, -8.96707475e-02f, -7.00439736e-02f, -7.60394037e-02f, 1.21612899e-01f, 4.83233705e-02f, -1.79652780e-01f, -1.91308200e-01f, 2.20808759e-01f, 2.79379487e-01f,
  9.74274427e-02f, -1.92954123e-01f, -3.09122711e-01f, 6.15318902e-02f, -1.05232507e-01f, 1.32023141e-01f, -3.99167925e-01f, -4.90527339e-02f, -7.29993172e-03f, -2.41391554e-01f,
  -2.84706503e-01f, -4.29877132e-01f, 2.21415028e-01f, 1.16190329e-01f, 1.71084613e-01f, 3.09626192e-01f, 2.78055578e-01f, -4.88081127e-01f, -7.15999305e-02f, 4.02426928e-01f,
  -8.72669592e-02f, 3.99229825e-01f, -4.13286835e-02f, -3.67584288e-01f, -3.93229544e-01f, 1.99089229e-01f, 6.76510036e-02f, 1.04219258e-01f, 1.04369558e-01f, 1.07672706e-01f,
  1.45280018e-01f, 2.16721311e-01f, 7.54766539e-02f, -8.54959264e-02f, 1.62215978e-01f, -2.64616638e-01f, 8.14747587e-02f, 1.45667344e-01f, -2.42548957e-01f, 1.42694013e-02f,
  -2.58235753e-01f, 1.53159559e-01f, 1.33389542e-02f, 7.45364605e-03f, 2.13059746e-02f, -1.50408864e-01f, -3.58481668e-02f, 1.60517395e-01f, -1.54812932e-01f, -1.94114953e-01f,
  -6.24022298e-02f, -1.93262771e-01f, -2.30176955e-01f, -1.04174294e-01f, -1.63685501e-01f, -2.26808682e-01f, 2.90550381e-01f, 3.16721112e-01f, -1.10620379e-01f, 3.30322355e-01f,
  1.57118700e-02f, 2.60957599e-01f, -9.68979076e-02f, -2.23334745e-01f, 3.10343206e-01f, 1.11305699e-01f, -1.17187902e-01f, 3.40146482e-01f, -2.73842096e-01f, -1.31506816e-01f,
  1.55980945e-01f, -3.07359993e-01f, 3.98936197e-02f, -5.26758015e-01f, -4.37036008e-01f, 2.01696381e-01f, 4.26697552e-01f, 3.94353151e-01f, -4.15628642e-01f, 2.72384346e-01f,
  2.46369466e-02f, 2.85296857e-01f, -3.05307537e-01f, -3.28034461e-01f, -4.14023310e-01f, 2.17033088e-01f, -4.04600233e-01f, -3.02101940e-01f, -3.48688066e-01f, 3.44885498e-01f,
  3.35617155e-01f, 2.13640362e-01f, -3.72948647e-01f, 2.79278189e-01f, -4.29733723e-01f, -4.37802434e-01f, -3.99021775e-01f, -1.01771280e-01f, 1.45214289e-01f, 1.19696967e-01f,
  2.10827023e-01f, -8.52100626e-02f, 1.09293684e-01f, -1.82077661e-01f, -4.47916895e-01f, -2.01039463e-01f, -3.99217345e-02f, -2.47005839e-02f, -3.63383383e-01f, 1.52541667e-01f,
  -2.02872217e-01f, -6.92649977e-03f, 6.38850853e-02f, 2.82681491e-02f, -6.71997294e-02f, 1.91412374e-01f, 2.74932951e-01f, 1.70817882e-01f, -1.15268193e-01f, -4.37580086e-02f,
  -3.64209503e-01f, 1.47936344e-01f, -4.05696899e-01f, -1.03648201e-01f, 1.39930964e-01f, 3.15588921e-01f, 2.09632516e-01f, 1.86380949e-02f, -4.17116165e-01f, 2.23100036e-01f,
  -2.04911068e-01f, -2.89048791e-01f, 1.90946460e-02f, -1.29514202e-01f, -4.09784138e-01f, 1.91091388e-01f, -4.58576828e-01f, -2.65449733e-01f, -4.25938368e-01f, -9.45985094e-02f,
  -3.60128939e-01f, 3.01536471e-01f, 1.85882315e-01f, -5.35625219e-01f, -1.49879688e-02f, 1.41400918e-01f, 2.68127888e-01f, -1.35943592e-01f, 2.56659150e-01f, 4.23224509e-01f,
  -3.68674040e-01f, 3.27503741e-01f, -5.09250164e-01f, -3.82985920e-01f, -3.20281744e-01f, 1.24535635e-02f, 2.37488285e-01f, -1.71670407e-01f, 1.37704685e-01f, 2.20870912e-01f,
  -2.06622809e-01f, 1.71854779e-01f, -1.41030967e-01f, 2.46446908e-01f, 1.01448670e-01f, -1.28045335e-01f, -1.56668946e-01f, -1.13382086e-01f, 8.93752351e-02f, 1.02185689e-01f,
  2.01014847e-01f, -1.38338329e-02f, 4.72159348e-02f, -2.89576259e-02f, -4.62779179e-02f, -2.10546300e-01f, 1.71010822e-01f, 1.17760465e-01f, -2.52137750e-01f, -2.08304405e-01f,
  7.28358105e-02f, 3.37315053e-01f, 3.06995451e-01f, -2.07782045e-01f, -2.28848696e-01f, 2.72450179e-01f, 2.02151552e-01f, -1.98145166e-01f, -4.16732609e-01f, 3.06773242e-02f,
  -3.28661203e-01f, -3.51074696e-01f, 2.07887635e-01f, -3.74919206e-01f, 1.36449665e-01f, 6.07093722e-02f, 1.97587267e-01f, 3.40494692e-01f, 3.44976991e-01f, -3.51879537e-01f,
  3.40437382e-01f, 3.84204566e-01f, -3.47120762e-01f, -2.71030724e-01f, -2.83607513e-01f, -6.04335964e-01f, -4.10359979e-01f, -4.87844974e-01f, 3.00532915e-02f, -4.98588890e-01f,
  -6.87148869e-02f, -2.78497189e-01f, 1.74133237e-02f, 8.01763982e-02f, 3.33649606e-01f, -1.12251990e-01f, 5.07294051e-02f, 6.80227950e-02f, 2.73309380e-01f, -1.64627552e-01f,
  1.27700880e-01f, 9.86121371e-02f, -4.41418439e-01f, -2.79699445e-01f, -7.66227543e-02f, -3.49397272e-01f, 1.95957407e-01f, 7.02501163e-02f, 1.36246622e-01f, 5.69954049e-04f,
  -4.03862670e-02f, -8.49321932e-02f, -1.94003303e-02f, 1.18138030e-01f, -8.31668451e-02f, -1.04173012e-01f, -1.36359230e-01f, 1.10770822e-01f, 3.86206619e-03f, -9.48716551e-02f,
  5.54277264e-02f, -1.94967806e-01f, 5.81290610e-02f, -6.32576197e-02f, 2.41697170e-02f, -3.30047868e-02f, 3.97458225e-01f, -2.66720414e-01f, -3.18204761e-01f, 2.24973917e-01f,
  1.71902329e-01f, 1.89919472e-01f, 1.18370228e-01f, 3.35868299e-01f, -1.72522753e-01f, -2.38745093e-01f, -2.74769098e-01f, -1.54663950e-01f, 1.13710068e-01f, -3.04122984e-01f,
  -9.54971556e-03f, -9.22746956e-02f, -4.61703688e-01f, 9.70093086e-02f, -2.21765772e-01f, -1.05917208e-01f, 2.94848025e-01f, 1.98406860e-01f, 3.98504198e-01f, -3.90636891e-01f,
  -4.45848078e-01f, -3.90246332e-01f, -2.47360915e-01f, 1.30959287e-01f, 7.68617392e-02f, 4.37766641e-01f, -1.40484393e-01f, -2.80917317e-01f, 2.16550808e-02f, 5.44306785e-02f,
  2.75784224e-01f, -1.18107293e-02f, 5.73041849e-02f, 3.02633703e-01f, -3.71152818e-01f, 4.11456406e-01f, -5.38938403e-01f, 1.66849852e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.77432683e-02f, 5.39664701e-02f, -1.83191560e-02f, -1.11797459e-01f, -4.64823954e-02f, 1.35849684e-01f, 1.73165828e-01f, -1.24021336e-01f, -6.90848008e-02f, -8.00933316e-02f,
  2.81520840e-02f, -1.20012134e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    