/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.22944576e-02f, 2.76216686e-01f, 8.66782665e-02f, 1.60393253e-01f, -1.36100665e-01f, -3.53986062e-02f, -2.41951436e-01f, -4.53870697e-03f, -1.49054572e-01f, -4.82697301e-02f,
  -3.54676023e-02f, 6.45728484e-02f, -2.27870688e-01f, 1.19924411e-01f, -5.47508895e-02f, -7.18048736e-02f, 1.94079980e-01f, 1.55745551e-01f, 8.51017684e-02f, 1.48661897e-01f,
  3.22997496e-02f, 1.04565725e-01f, 2.00901646e-02f, 1.17772557e-01f, 9.66716111e-02f, 5.18002398e-02f, 1.29143568e-02f, -3.01841255e-02f, 2.16490373e-01f, 7.80896284e-03f,
  4.83056828e-02f, 5.54851219e-02f, -9.73076448e-02f, 1.33991344e-02f, -3.98990959e-02f, -7.22866729e-02f, -9.45564881e-02f, -5.04833795e-02f, 5.59718348e-03f, -6.22733012e-02f,
  -1.29133482e-02f, -1.44793140e-03f, 1.84102416e-01f, -4.07020338e-02f, -2.73003411e-02f, -4.46804659e-03f, 4.75994684e-02f, 2.00797897e-02f, -3.88737433e-02f, -4.78516612e-03f,
  -3.64667960e-02f, 5.74235804e-02f, 2.89959164e-04f, 7.47442320e-02f, -2.84640933e-03f, -2.71081831e-02f, -7.40714595e-02f, -3.69292572e-02f, 9.87000167e-02f, 9.44304094e-02f,
  -7.48822019e-02f, -4.08495106e-02f, 4.79703856e-04f, 7.02360794e-02f, -1.81506705e-02f, 2.90747955e-02f, -2.68598413e-03f, -3.27361450e-02f, -8.29098374e-02f, 2.88538449e-02f,
  9.74520147e-02f, 5.33394422e-03f, -7.28214085e-02f, 2.27952958e-03f, -6.51096255e-02f, -3.47368233e-03f, 3.83582860e-02f, 2.01940946e-02f, 9.45447460e-02f, -1.82308648e-02f,
  -9.87778530e-02f, -2.56796740e-02f, 7.21358135e-02f, -7.42625538e-03f, 5.39299324e-02f, -4.89539579e-02f, 9.52903852e-02f, 1.88321751e-02f, -2.48346850e-02f, -8.10836926e-02f,
  1.89990655e-01f, 8.38589296e-02f, -4.67371345e-02f, -3.89895402e-02f, 4.88770790e-02f, -2.83252802e-02f, 1.63822416e-02f, 6.43912852e-02f, 1.27542228e-01f, 1.60963833e-02f,
  4.49563824e-02f, 5.66156693e-02f, 1.30784437e-01f, 8.77559483e-02f, 4.99096233e-03f, -3.53355594e-02f, 8.00202973e-03f, 1.00056976e-01f, 9.80804488e-02f, 1.05429910e-01f,
  -3.71681377e-02f, -3.29174101e-02f, 4.11429554e-02f, 1.26656583e-02f, -2.62690068e-04f, 5.69293536e-02f, 1.55995169e-03f, 2.70621590e-02f, 8.33459273e-02f, -1.01749543e-02f,
  1.64871514e-02f, 4.83248234e-02f, 2.23157242e-01f, 5.90407141e-02f, -1.35748684e-01f, 9.56045687e-02f, 2.61151761e-01f, -6.64511025e-02f, 1.78482354e-01f, -3.47809456e-02f,
  -1.33126780e-01f, 1.51427850e-01f, 1.77481294e-01f, -1.35292038e-01f, -2.49293521e-01f, 2.09437743e-01f, -1.61192730e-01f, -7.50475377e-02f, 4.40023327e-03f, -9.82431769e-02f,
  -6.77890852e-02f, -2.76298612e-01f, -1.26088306e-01f, -2.54160076e-01f, -5.82116731e-02f, -9.82427299e-02f, -2.91903794e-01f, 8.74156430e-02f, -2.98115671e-01f, -1.37125507e-01f,
  2.26306170e-02f, -4.74451482e-02f, 8.03123564e-02f, 8.49909559e-02f, -5.64728975e-02f, 3.60691585e-02f, 1.25774117e-02f, -4.94106747e-02f, 4.06314693e-02f, 3.27651873e-02f,
  4.10294309e-02f, 1.17705883e-02f, -1.10757463e-02f, -1.60380695e-02f, 8.10611397e-02f, -1.69468578e-02f, -1.26980059e-02f, 3.19086276e-02f, 1.32536356e-04f, 6.84858263e-02f,
  3.48937772e-02f, 6.70757890e-02f, 6.86754733e-02f, 2.78260037e-02f, 7.90010318e-02f, 6.97329547e-03f, 3.35136503e-02f, 3.69230881e-02f, 2.61272397e-02f, -3.09261051e-03f,
  -1.20415233e-01f, 7.06552789e-02f, 5.03327847e-02f, -6.83339611e-02f, 1.48447426e-02f, -5.41270077e-02f, 2.71913316e-02f, -1.02202661e-01f, -3.02099008e-02f, 2.51868158e-04f,
  -2.66660750e-02f, 2.36193859e-03f, -5.39470762e-02f, 1.88998077e-02f, 7.41110230e-03f, -3.14357914e-02f, 2.84255128e-02f, -1.94565915e-02f, 1.11140627e-02f, -2.40019485e-02f,
  4.10439558e-02f, -2.49115489e-02f, -3.15576307e-02f, 2.15627290e-02f, 5.23754545e-02f, 3.77166271e-02f, 7.81934112e-02f, 3.31879221e-02f, 4.49700207e-02f, -7.27121299e-03f,
  -1.71028614e-01f, -1.71620339e-01f, 8.92562978e-03f, -5.50684258e-02f, 6.43191161e-03f, -1.40359446e-01f, -4.06659953e-02f, 1.43825701e-02f, -2.40203310e-02f, 2.17672456e-02f,
  -9.64264274e-02f, 3.92400622e-02f, -9.90124047e-03f, 3.12918127e-02f, -4.31377664e-02f, 3.34675377e-03f, -1.72922947e-02f, -7.34648779e-02f, -1.20322354e-01f, -1.48466781e-01f,
  2.70559806e-02f, -5.92385593e-04f, -3.43370028e-02f, -2.18115728e-02f, -1.03389556e-02f, -1.62497768e-03f, -6.20468073e-02f, 5.54449037e-02f, -4.15424146e-02f, 3.10327448e-02f,
  6.29088283e-02f, 1.63846865e-01f, 2.65735269e-01f, 1.72287703e-01f, -1.43778563e-01f, 5.17499484e-02f, 1.05192661e-01f, -2.33589008e-01f, -5.63157536e-02f, -1.34564072e-01f,
  -7.00534359e-02f, 2.62573510e-01f, 1.07279800e-01f, 7.28970915e-02f, 1.50121719e-01f, 7.03679472e-02f, 1.31276688e-02f, -2.25397032e-02f, -7.05698729e-02f, 3.53239551e-02f,
  4.46329415e-02f, -1.73339382e-01f, 5.54731935e-02f, -1.95663258e-01f, -4.36644852e-02f, -3.35704163e-02f, 1.64852645e-02f, 5.27051911e-02f, -1.13539554e-01f, -6.75589740e-02f,
  -1.71438977e-02f, 4.80786338e-02f, 5.18745445e-02f, -9.51729938e-02f, 2.75443178e-02f, 2.47433856e-02f, 8.05042535e-02f, 3.94316763e-02f, 1.37873711e-02f, -3.08325756e-02f,
  1.62339345e-01f, -3.16174887e-02f, -7.48238638e-02f, -2.94850804e-02f, -3.05245649e-02f, -4.09216993e-02f, -5.56402467e-02f, 8.12278781e-03f, 3.57811414e-02f, 1.09941304e-01f,
  1.79585680e-01f, 7.89536908e-02f, 7.35760480e-02f, 1.14129782e-02f, 1.50824096e-02f, -2.95048524e-02f, 2.84327287e-02f, 1.25648856e-01f, -1.61525570e-02f, 1.23542912e-01f,
  -8.58771876e-02f, 7.32638985e-02f, -3.12256459e-02f, -7.82613084e-02f, 7.82444999e-02f, -4.37133238e-02f, -3.76268886e-02f, 3.15454155e-02f, -4.52354923e-02f, 8.18920583e-02f,
  -4.74132523e-02f, -4.04929109e-02f, -4.46912572e-02f, 2.91433800e-02f, 2.28982009e-02f, 2.59625278e-02f, 4.29112837e-02f, -6.02724813e-02f, -8.69577006e-02f, 3.44364457e-02f,
  1.33490190e-03f, -3.45669873e-02f, 2.25354731e-02f, -3.97665128e-02f, 2.56732646e-02f, 4.68559973e-02f, -9.79798958e-02f, -7.79249594e-02f, 1.80392154e-02f, -6.00227900e-02f,
  1.06507659e-01f, 9.20115709e-02f, -4.13591191e-02f, 4.24101539e-02f, 7.69615546e-02f, -9.52487886e-02f, 6.17933273e-02f, -5.01090959e-02f, -3.92490365e-02f, 3.15242223e-02f,
  -2.48677395e-02f, -2.53035091e-02f, -7.03523010e-02f, -7.95216113e-02f, 2.23257393e-03f, 2.88104196e-03f, 8.44111666e-02f, 6.67770114e-03f, -5.58110885e-02f, 9.28451270e-02f,
  -1.20169325e-02f, 4.51055961e-03f, -3.51169705e-02f, -4.86207055e-03f, -2.05921428e-03f, 7.44070858e-02f, -1.19163200e-01f, -9.34800785e-03f, -6.49481267e-02f, -3.28895985e-03f,
  1.77540362e-01f, 1.15347235e-02f, 2.22686902e-01f, 1.83340147e-01f, 3.24315391e-02f, -1.73376322e-01f, -9.87270847e-02f, 7.84086809e-02f, 9.94341448e-02f, -1.06898047e-01f,
  9.78261232e-02f, 1.01621032e-01f, -1.92413162e-02f, 9.51926410e-02f, 2.79961407e-01f, -1.45265991e-02f, 8.81823432e-03f, -7.39504918e-02f, -5.93902019e-04f, 8.99091288e-02f,
  2.87986137e-02f, 1.12867400e-01f, 1.48742065e-01f, 5.73297553e-02f, 1.72178984e-01f, 7.12183937e-02f, 2.80459262e-02f, 9.90987122e-02f, -3.20929661e-02f, 5.90832606e-02f,
  -1.19811622e-03f, 2.44679358e-02f, 2.72022039e-02f, -1.47969089e-02f, -9.68153998e-02f, -5.60299344e-02f, -2.72659585e-03f, 1.03679568e-01f, 2.52721030e-02f, -4.55022156e-02f,
  -3.56896296e-02f, 6.93653375e-02f, -7.42599322e-03f, 7.28381425e-02f, -2.74923351e-02f, -3.11566871e-02f, 9.88322776e-03f, -3.83592732e-02f, -3.54081020e-02f, 9.10413358e-03f,
  1.86112616e-02f, -3.06828767e-02f, -2.49596629e-02f, -1.55407012e-01f, 7.27233216e-02f, -3.84994745e-02f, -1.74210779e-02f, -2.99372990e-02f, -9.62359384e-02f, -9.29012429e-03f,
  -5.21409772e-02f, 4.96281199e-02f, -3.27228755e-03f, 3.66513319e-02f, 8.38620514e-02f, -1.57974064e-02f, 1.86159015e-02f, 1.66425146e-02f, 7.41929114e-02f, 6.18686527e-02f,
  -6.06851801e-02f, 2.88709905e-02f, -1.21506155e-02f, 3.27109918e-02f, 5.66682499e-03f, -3.41014974e-02f, 1.60162691e-02f, -1.33478660e-02f, -1.16897970e-01f, -1.73304919e-02f,
  3.56787373e-03f, 1.14825383e-01f, 3.03811878e-02f, -9.34329182e-02f, 8.52676481e-03f, 3.05921454e-02f, 1.21562388e-02f, -2.72189304e-02f, 1.03614144e-02f, -5.55545315e-02f,
  -1.04550779e-01f, -1.54474576e-03f, 2.04046089e-02f, 4.10796031e-02f, 1.88386831e-02f, 4.64293957e-02f, -4.40622447e-03f, 6.59963191e-02f, 4.27701809e-02f, 6.41219541e-02f,
  -6.09201528e-02f, -3.28450091e-02f, -6.35932460e-02f, 3.16823237e-02f, 3.80513333e-02f, -1.78891104e-02f, -5.60587607e-02f, -4.58833016e-02f, 7.88678695e-03f, -3.04163974e-02f,
  1.88922621e-02f, 3.70571832e-03f, 3.49035636e-02f, 2.89425049e-02f, -1.04364879e-01f, -3.13220173e-02f, -7.82496706e-02f, -6.48787171e-02f, -2.41057537e-02f, 2.05324609e-02f,
  1.91577971e-01f, 2.80150384e-01f, 1.27591193e-01f, 2.27347016e-01f, -8.66155848e-02f, 1.24944486e-01f, 2.18054149e-02f, 7.47653246e-02f, 3.20287868e-02f, 1.48375198e-01f,
  -6.29163980e-02f, 1.96874104e-02f, -1.27379641e-01f, 1.44464925e-01f, -2.52717733e-01f, -7.87447914e-02f, 2.59088576e-01f, 2.10944489e-01f, -8.05506259e-02f, 5.40441610e-02f,
  -2.98997108e-02f, -2.57094856e-02f, 8.08710754e-02f, -7.92821124e-02f, 3.28578874e-02f, 4.83336411e-02f, -9.56557542e-02f, -9.19235423e-02f, 1.67861491e-01f, -1.21363558e-01f,
  4.13909294e-02f, 7.75934616e-03f, 6.46911785e-02f, 7.29519427e-02f, 1.29979983e-01f, 2.10839678e-02f, 1.83116123e-02f, -7.23023042e-02f, -7.44961351e-02f, 4.37873006e-02f,
  3.47612314e-02f, -1.97120402e-02f, -2.31466512e-03f, -1.51428627e-02f, 8.25410802e-03f, 1.78343002e-02f, 4.22441028e-02f, 1.09366309e-02f, 6.93498328e-02f, -1.02308333e-01f,
  9.56108887e-03f, 2.74087470e-02f, 1.15178250e-01f, 6.48038238e-02f, -2.12023482e-02f, 8.30481723e-02f, 5.73864579e-02f, 3.96353789e-02f, 9.75678489e-03f, 4.24069017e-02f,
  1.48119172e-02f, 1.69123604e-03f, 1.93304513e-02f, 1.52131272e-02f, -5.91868348e-02f, 6.95739686e-02f, -3.53152379e-02f, -3.44664492e-02f, -4.01946045e-02f, 7.49882087e-02f,
  3.57331410e-02f, -2.34731250e-02f, 2.82667056e-02f, 3.83693241e-02f, -9.91312190e-05f, 6.60888329e-02f, -2.73032151e-02f, -4.56375666e-02f, 5.94353005e-02f, -1.99336410e-02f,
  -2.22646557e-02f, 4.37040208e-03f, -6.54183030e-02f, -2.29782071e-02f, -3.31527032e-02f, -9.95287001e-02f, -3.68780158e-02f, 2.59721335e-02f, -4.71870266e-02f, -2.61758640e-02f,
  2.69582644e-02f, -4.53512929e-02f, -1.00590261e-02f, -3.26074734e-02f, -7.46114105e-02f, -2.17154119e-02f, -3.37002352e-02f, 2.92328093e-02f, 3.78804840e-02f, -3.60381603e-02f,
  4.26944010e-02f, 3.63005884e-02f, 9.17030126e-02f, -4.78084497e-02f, 8.63573689e-04f, -2.94310190e-02f, 2.58814637e-02f, 6.80959551e-03f, -6.89012976e-03f, -8.76559038e-03f,
  -5.13191894e-03f, -3.29444446e-02f, -8.01708773e-02f, -3.50715257e-02f, 9.76121575e-02f, -4.73769866e-02f, 7.01172650e-03f, -2.93681100e-02f, -5.08784913e-02f, 2.17714235e-02f,
  1.15671024e-01f, 3.11090827e-01f, 1.99485928e-01f, 2.37731844e-01f, -1.32433638e-01f, 2.34264985e-01f, 1.90163821e-01f, 6.16636593e-03f, -1.57744056e-04f, 1.07790805e-01f,
  5.40543944e-02f, 1.74766421e-01f, 9.86701623e-02f, 2.36684412e-01f, -1.09001227e-01f, 9.70495567e-02f, 2.49006689e-01f, 1.84040233e-01f, -1.20862789e-01f, 7.65071586e-02f,
  -1.60903987e-02f, -3.14486846e-02f, 1.32981971e-01f, -1.38370156e-01f, 1.84934169e-01f, -1.08682126e-01f, -1.80469662e-01f, -1.73400491e-01f, 9.92693454e-02f, -6.66951463e-02f,
  5.29465154e-02f, 4.92449664e-02f, -2.68319733e-02f, 1.34640122e-02f, 2.68022381e-02f, 7.98247233e-02f, -3.80210616e-02f, -7.24834576e-02f, -2.15231497e-02f, 4.40875739e-02f,
  3.02847615e-03f, -5.64559698e-02f, 6.22428022e-02f, -5.01501672e-02f, 2.74578929e-02f, -5.73427454e-02f, 1.01919491e-02f, 5.94890714e-02f, 6.08906224e-02f, 7.01873079e-02f,
  6.30537421e-02f, 7.34482259e-02f, 4.02910933e-02f, 9.87310037e-02f, 4.99985144e-02f, 2.41911840e-02f, 5.73618002e-02f, 2.18496993e-02f, 9.67348665e-02f, 5.75321307e-03f,
  -1.64186358e-02f, 2.83902325e-02f, 3.13892104e-02f, -3.86440172e-03f, -3.28932144e-03f, -1.56064918e-02f, -9.76464804e-03f, 2.30552480e-02f, -2.72267498e-02f, 8.18903185e-03f,
  -1.99104496e-03f, -1.55488933e-02f, -3.58601213e-02f, -7.12568238e-02f, -1.28037960e-03f, -5.76043576e-02f, -1.25438096e-02f, -4.59290296e-02f, -2.64560251e-04f, 3.81623693e-02f,
  -6.62745759e-02f, -3.84868085e-02f, 8.83326028e-03f, -5.83656169e-02f, -2.29860954e-02f, 7.32068962e-04f, 5.35826832e-02f, 1.13591449e-02f, -1.07378988e-02f, -4.97303903e-02f,
  1.06793389e-01f, -3.11374711e-03f, 6.27021417e-02f, -4.01225826e-03f, -4.45212871e-02f, -1.51546514e-02f, 5.25126308e-02f, 1.29869729e-02f, 1.36476140e-02f, -3.80009115e-02f,
  1.98959243e-02f, -2.55211703e-02f, 1.26240691e-02f, 1.68363582e-02f, -7.08547980e-02f, 7.22193345e-02f, -5.83975948e-03f, -1.86867788e-02f, -6.40362576e-02f, 7.22436095e-03f,
  -2.64616925e-02f, -8.80896002e-02f, -6.69560954e-02f, 4.51913923e-02f, 5.69467582e-02f, 8.96069780e-03f, -3.09727229e-02f, 2.14674626e-03f, -2.08031423e-02f, 1.47489831e-02f,
  -3.51898879e-01f, -2.71878149e-02f, 1.26638114e-01f, -1.67754680e-01f, -7.94696584e-02f, -6.54155314e-02f, -8.23928392e-04f, -9.80052054e-02f, -1.17872218e-02f, -8.99798647e-02f,
  -4.99475263e-02f, -1.89608540e-02f, 2.24725738e-01f, -9.52788517e-02f, 2.01375023e-01f, 1.41827509e-01f, -2.50995606e-02f, 3.16823162e-02f, 1.83557793e-02f, -1.47122696e-01f,
  3.20548913e-03f, -1.72232538e-01f, 1.32010028e-01f, -1.25944972e-01f, -1.73668012e-01f, -9.36007425e-02f, -3.61553989e-02f, 1.95523024e-01f, -1.77708659e-02f, 2.79762633e-02f,
  -3.79470736e-02f, -6.95101544e-02f, -1.01964571e-01f, 4.93424833e-02f, -3.94962355e-02f, 5.38974255e-02f, 5.03629185e-02f, 9.45977941e-02f, 7.71388486e-02f, 5.45786843e-02f,
  -1.56852975e-02f, 2.09903698e-02f, -8.91557261e-02f, 3.85603532e-02f, 3.55876610e-03f, -3.45305912e-02f, 1.92270186e-02f, -2.67866459e-02f, -6.83265850e-02f, 8.72948840e-02f,
  8.56528431e-02f, -4.67408914e-03f, 5.40002473e-02f, -9.11485776e-03f, 4.73724194e-02f, -3.41555700e-02f, 1.14042968e-01f, 3.54000144e-02f, -1.56456139e-02f, -1.42520713e-02f,
  2.71834284e-02f, 1.24040946e-01f, -2.24490315e-02f, -3.19491774e-02f, -4.33661193e-02f, -5.87758534e-02f, 1.55352382e-02f, -1.52753228e-02f, -2.06964178e-04f, 6.45901402e-03f,
  -3.69826183e-02f, 2.34351959e-03f, -8.11056979e-03f, 6.63738400e-02f, 3.38787511e-02f, -4.88617755e-02f, 1.79637820e-02f, -3.68714035e-02f, -1.14761546e-01f, 3.93616855e-02f,
  -3.16536650e-02f, 3.38387899e-02f, 2.17921380e-02f, 2.98502343e-03f, 4.55140844e-02f, 3.30445506e-02f, 1.11884549e-01f, 6.79364651e-02f, 2.86383536e-02f, 3.01679820e-02f,
  -9.91066694e-02f, 6.72978675e-03f, 4.38363738e-02f, -6.07961789e-02f, 1.99698955e-02f, 4.02242318e-02f, -4.72849794e-02f, -5.52939065e-02f, 2.92409323e-02f, -8.45844522e-02f,
  -4.60894313e-03f, -9.43616871e-03f, -3.55694406e-02f, 7.21848430e-03f, 7.13444576e-02f, 6.63816854e-02f, 6.85346825e-03f, -2.37927940e-02f, -3.99246514e-02f, -5.39782830e-03f,
  -9.10995249e-03f, 7.90720433e-03f, 8.02604705e-02f, -6.26501366e-02f, -1.12947561e-01f, 2.57126447e-02f, -8.41543600e-02f, 2.01826636e-02f, 6.64779693e-02f, -2.37932913e-02f,
  3.47815871e-01f, 1.40297145e-01f, 2.24820048e-01f, 2.67591059e-01f, -1.64425462e-01f, -2.05113888e-01f, 1.37481168e-01f, 1.21934116e-02f, 3.13076407e-01f, -5.22527546e-02f,
  -1.07594363e-01f, 2.98580825e-01f, 5.22067174e-02f, 8.94800585e-04f, 1.25301825e-02f, 2.78820600e-02f, 7.38451108e-02f, 1.16819076e-01f, 4.95869257e-02f, 1.66365325e-01f,
  6.86875656e-02f, -2.21161529e-01f, 9.86762941e-02f, -1.98860288e-01f, -1.51177952e-02f, 1.54151380e-01f, -1.54421300e-01f, -4.48986180e-02f, -1.45607024e-01f, -3.92829217e-02f,
  -7.76450336e-02f, 4.06548567e-02f, 8.92307609e-02f, 6.24493733e-02f, -1.97913628e-02f, -4.60069515e-02f, 2.17446424e-02f, 1.00540901e-02f, 3.72826792e-02f, -4.00702544e-02f,
  1.58142876e-02f, -4.48695524e-03f, 7.49089429e-03f, 3.47644053e-02f, -3.20163332e-02f, -4.02854867e-02f, 9.34188906e-03f, -9.21368152e-02f, 5.92726357e-02f, -9.51952711e-02f,
  1.07961837e-02f, -2.77497694e-02f, -9.94900474e-04f, 5.97532615e-02f, -1.12344036e-02f, -3.51215042e-02f, 6.53033331e-02f, -7.51301413e-03f, -6.98838606e-02f, 2.60466635e-02f,
  -3.42810899e-02f, 3.43293846e-02f, 5.34311384e-02f, -3.29047367e-02f, -5.95700517e-02f, -2.23259139e-03f, -4.27594967e-02f, -3.54559384e-02f, 8.14866275e-02f, -9.02879834e-02f,
  4.14153114e-02f, 8.45624134e-03f, 3.94575810e-03f, 1.97874103e-02f, 1.39427390e-02f, 1.04931984e-02f, -3.40217054e-02f, 2.83028763e-02f, 6.53132945e-02f, 1.44495843e-02f,
  1.72083359e-02f, -3.83967645e-02f, 3.52125876e-02f, -4.07863818e-02f, -4.21124883e-03f, 3.75462212e-02f, 5.24761062e-03f, 1.98668987e-02f, 3.63343768e-02f, -2.41451859e-02f,
  -9.29444581e-02f, 1.40683144e-01f, -3.62044014e-02f, 7.48246834e-02f, -5.42929657e-02f, -9.11270306e-02f, -2.96437591e-02f, 6.90963641e-02f, -3.14761628e-03f, 4.24743369e-02f,
  -5.13174161e-02f, -1.97770391e-02f, -1.47758462e-02f, -2.52944161e-03f, 1.78791452e-02f, -3.14426720e-02f, 4.08371836e-02f, 4.19785678e-02f, 7.34701240e-03f, 3.71529348e-02f,
  -2.73623187e-02f, -1.79236885e-02f, 1.01523539e-02f, -4.13782895e-02f, 8.00096914e-02f, -1.90377310e-02f, -2.48949267e-02f, 8.63346681e-02f, 3.85128222e-02f, 1.03263119e-02f,
  -1.83916055e-02f, 1.41613275e-01f, 8.95434469e-02f, 2.99263839e-02f, -1.34283841e-01f, 4.23476458e-01f, 2.14286506e-01f, 1.21228389e-01f, -1.23069681e-01f, 2.28494201e-02f,
  5.40348850e-02f, -2.36801915e-02f, -7.60438666e-02f, 3.23853344e-01f, 2.88730562e-01f, 1.80543721e-01f, 2.23355696e-01f, 1.35420635e-01f, -3.90481986e-02f, 1.63796060e-02f,
  -1.65327825e-02f, 1.90452769e-01f, 2.20679998e-01f, 1.59692429e-02f, -1.61251251e-03f, -1.91134989e-01f, -1.65549010e-01f, -1.50622919e-01f, 1.63429081e-01f, 1.39158443e-01f,
  9.50961038e-02f, -5.83457351e-02f, -8.42316542e-03f, -4.08342434e-03f, 1.08246198e-02f, -2.03683900e-04f, -1.67003106e-02f, 1.42260687e-02f, -5.86142279e-02f, 2.47590430e-02f,
  -1.62175111e-02f, 8.22408777e-03f, 9.04073380e-03f, 1.47407213e-02f, -8.78167376e-02f, 3.41794528e-02f, -2.10026316e-02f, -1.12258466e-02f, 4.48891670e-02f, 2.35460456e-02f,
  -3.77491489e-02f, 7.41195381e-02f, -5.55033945e-02f, 1.03216721e-02f, -1.45152118e-02f, -2.36758590e-02f, 5.49890846e-02f, -9.22843814e-04f, 7.83281103e-02f, 3.86080518e-02f,
  1.91479046e-02f, -3.98267806e-02f, 5.12749888e-02f, 3.47359106e-02f, 3.15769278e-02f, 2.14651437e-03f, 2.50782967e-02f, -2.29803324e-02f, -9.07127634e-02f, 2.03993618e-02f,
  -6.57329261e-02f, -1.09261950e-03f, -3.04007176e-02f, 5.41730896e-02f, 1.65822599e-02f, -1.01506524e-02f, -7.14636501e-03f, -3.38262357e-02f, 2.40244158e-02f, 3.08636855e-03f,
  -2.98634320e-02f, -5.79759362e-04f, 1.15383305e-02f, -4.18198481e-02f, 5.07478341e-02f, 1.17312046e-03f, -2.10013390e-02f, 1.73919760e-02f, -8.83915722e-02f, -3.24730128e-02f,
  9.93760899e-02f, -2.09934562e-02f, 3.03383358e-02f, 5.51631600e-02f, 5.59072057e-03f, 4.93593514e-02f, 5.13576753e-02f, -2.39118151e-02f, 4.82391380e-03f, -6.46981224e-03f,
  -5.15939370e-02f, -7.02821612e-02f, -7.51547292e-02f, -3.66347400e-03f, -6.57243580e-02f, 3.94534394e-02f, -3.90887819e-02f, -2.73283217e-02f, 4.13296185e-03f, -3.18978876e-02f,
  -1.95858050e-02f, -8.29280168e-02f, 2.70673586e-03f, 2.95486208e-02f, -1.98264513e-02f, -1.67445224e-02f, -5.79397455e-02f, -3.03530861e-02f, 6.39590109e-03f, 1.74639151e-02f,
  2.01668844e-01f, -1.00644231e-01f, -5.49064800e-02f, 1.48212701e-01f, 2.47153252e-01f, -3.05242953e-03f, 6.40572608e-02f, -1.16896695e-02f, -4.10820208e-02f, -2.45568156e-01f,
  2.39375923e-02f, -1.93598792e-02f, -1.49039820e-01f, 1.10419365e-02f, -1.58634298e-02f, -1.64636508e-01f, -2.85111442e-02f, -2.43873969e-02f, 2.53869202e-02f, 3.30000408e-02f,
  1.28753018e-02f, 3.19386087e-02f, 7.36917853e-02f, 4.16461378e-02f, 7.29523227e-02f, 5.31570688e-02f, -3.68194208e-02f, 1.03933159e-02f, 1.16460338e-01f, 5.53192059e-03f,
  6.57813475e-02f, 5.22757657e-02f, 9.67323333e-02f, -4.43739705e-02f, -4.40610647e-02f, 1.13529615e-01f, 8.86290893e-02f, 8.17401484e-02f, -2.52890978e-02f, -4.79497202e-03f,
  2.31293961e-02f, 3.95323560e-02f, -2.77797356e-02f, -8.96967128e-02f, 7.20874220e-02f, -3.21797072e-03f, -3.87279652e-02f, 9.94743556e-02f, 8.40971544e-02f, 1.11098653e-02f,
  -1.00639006e-02f, 8.47047940e-03f, -3.90322506e-02f, 4.15174812e-02f, 9.06667039e-02f, 4.77384254e-02f, -5.42920036e-03f, 2.40273513e-02f, 9.76757985e-03f, -2.49635875e-02f,
  3.27261053e-02f, -2.31048334e-02f, -2.53400970e-02f, -6.25500223e-03f, 2.47556879e-03f, 6.77817687e-02f, -9.72391739e-02f, 4.41849232e-02f, -8.98697674e-02f, 2.59019760e-03f,
  1.64163932e-02f, 8.29520971e-02f, 5.10791168e-02f, 5.67075126e-02f, 7.35210627e-02f, 7.72172539e-03f, -1.28976144e-02f, -5.35877645e-02f, 6.96437582e-02f, -5.35145355e-03f,
  -6.86099753e-02f, -5.14985155e-03f, -8.91105756e-02f, 6.64057434e-02f, -2.26690881e-02f, 2.69859452e-02f, 5.07665314e-02f, 6.01049140e-02f, -4.35486948e-03f, -3.72679383e-02f,
  -1.58614084e-01f, -3.29129785e-01f, -6.79453835e-02f, 6.42522797e-03f, -1.09976992e-01f, -8.28521773e-02f, -2.09540538e-02f, 1.04868691e-02f, -5.52446246e-02f, -1.01579521e-02f,
  4.92213257e-02f, 2.76882332e-02f, -5.25591522e-02f, 7.87534565e-02f, -2.64445078e-02f, -5.26537411e-02f, 2.70784162e-02f, -7.27450475e-02f, 1.21726627e-02f, -5.11163510e-02f,
  -3.57191451e-02f, -1.19478352e-01f, 2.50220578e-02f, 9.51245427e-02f, 9.23657883e-03f, -2.93241777e-02f, 2.41527855e-02f, -8.24954659e-02f, -6.21233098e-02f, -2.11688895e-02f,
  -4.28930484e-02f, 1.29469018e-02f, -1.85076565e-01f, 1.45338744e-01f, 6.84830993e-02f, -2.35971157e-02f, -3.52781974e-02f, 7.27104470e-02f, -2.11877406e-01f, 1.87828228e-01f,
  1.82607472e-01f, -1.50778741e-01f, 2.01594085e-03f, 2.25274935e-01f, -2.15333000e-01f, -1.94107071e-01f, 2.29089409e-02f, -4.51175980e-02f, -1.91437304e-02f, 1.39416724e-01f,
  -1.12708062e-01f, 2.78365642e-01f, -2.83606257e-02f, 1.71068773e-01f, 1.83886439e-01f, 2.84756292e-02f, 1.43876120e-01f, -5.66412695e-02f, 2.16335475e-01f, 3.73502187e-02f,
  4.61986996e-02f, 8.02001432e-02f, -2.31175926e-02f, -8.56029466e-02f, -2.05683592e-03f, 7.12675229e-02f, 6.29017362e-04f, -7.90189952e-02f, -4.36228625e-02f, 1.84760094e-02f,
  -3.09827942e-02f, 8.31064582e-02f, 3.65244113e-02f, -4.26185690e-02f, 1.99476238e-02f, 2.29240116e-02f, -4.51649055e-02f, -2.54317075e-02f, 1.77500956e-02f, 1.79405343e-02f,
  -7.93295875e-02f, 5.21631055e-02f, -1.46388505e-02f, 4.08511702e-03f, -5.34125939e-02f, -8.88652634e-04f, -5.31740971e-02f, -3.37939188e-02f, -3.59815336e-03f, -1.48661043e-02f,
  2.20669247e-02f, -2.45031044e-02f, 1.20611666e-02f, 5.60462959e-02f, 5.80398664e-02f, 7.93450400e-02f, 2.26385817e-02f, 5.59865050e-02f, -6.87407777e-02f, 5.83045371e-02f,
  3.29026803e-02f, -2.89613716e-02f, 7.77218342e-02f, -9.45581123e-03f, 9.55304354e-02f, 8.11051801e-02f, -5.95843010e-02f, -1.27126807e-02f, 2.28218772e-02f, 1.26209040e-03f,
  -1.51046161e-02f, -2.62270253e-02f, 1.19697079e-02f, 5.15683778e-02f, 5.44007774e-03f, 1.77461300e-02f, 2.48259585e-02f, -7.25876465e-02f, -5.33599593e-03f, 3.58173694e-03f,
  -6.37905076e-02f, 7.01212659e-02f, 1.91346537e-02f, 2.09838580e-02f, -4.84319255e-02f, 6.46367669e-03f, -4.50134650e-02f, -1.23721166e-02f, -3.42309624e-02f, 2.58207787e-02f,
  7.58352801e-02f, 3.82870398e-02f, -6.93664402e-02f, 1.06654033e-01f, 6.70795212e-04f, 1.93710830e-02f, 3.35740559e-02f, 3.84609355e-03f, 7.96309039e-02f, -6.40873099e-03f,
  9.88435969e-02f, -4.56029400e-02f, 8.76965187e-03f, 1.10013681e-02f, 1.37885995e-02f, 1.46952644e-03f, -2.82603744e-02f, -6.23388588e-02f, 5.36978543e-02f, -5.81914745e-02f,
  -2.01718628e-01f, -1.28443524e-01f, 2.30755493e-01f, 4.16995212e-02f, -3.17407288e-02f, 3.28140482e-02f, 1.13273971e-01f, -1.01900390e-04f, -1.69242635e-01f, 2.37498414e-02f,
  5.78797236e-02f, -1.05490722e-01f, -1.20620914e-01f, 1.10639304e-01f, -2.11701959e-01f, -1.73312575e-01f, 2.64349785e-02f, 2.70492118e-02f, -4.39956635e-02f, 4.87679727e-02f,
  -5.15351333e-02f, -7.32270703e-02f, 1.46938384e-01f, -1.03473170e-02f, 6.26858920e-02f, 1.09604195e-01f, -6.17095307e-02f, 7.20087364e-02f, 1.14768129e-02f, -8.35008025e-02f,
  1.08951211e-01f, -3.07074264e-02f, 4.83643115e-02f, 5.26735559e-02f, 7.64049813e-02f, -1.53127173e-02f, 6.15658686e-02f, 4.41218577e-02f, 3.82014513e-02f, 5.17669395e-02f,
  -6.31448179e-02f, 7.38866953e-03f, 1.44814467e-02f, -5.42188250e-02f, -4.95623983e-02f, 5.56332208e-02f, 5.09109050e-02f, 4.61578043e-03f, 7.19968081e-02f, -1.79554895e-02f,
  -3.04913428e-02f, 1.66734233e-02f, 8.53653550e-02f, -6.93955347e-02f, -1.17991501e-02f, 4.44021262e-02f, -1.99188404e-02f, -1.19227460e-02f, -6.40844181e-02f, -3.27429059e-03f,
  -5.15945368e-02f, 5.79850711e-02f, -4.57102023e-02f, 4.46356498e-02f, -3.01609766e-02f, -4.54408303e-03f, 3.16056944e-02f, 2.32016593e-02f, 1.11140823e-02f, 2.15872768e-02f,
  2.34927274e-02f, -3.52522507e-02f, 2.45630462e-02f, 1.59661355e-03f, 2.53188275e-02f, -3.33323516e-02f, 1.03599697e-01f, -4.05755825e-03f, 7.52718821e-02f, 2.62657702e-02f,
  7.49981925e-02f, 4.43396233e-02f, 5.18417843e-02f, 9.30254534e-02f, -5.45206154e-03f, -2.46264674e-02f, 1.47358896e-02f, -9.04908776e-03f, 3.53307761e-02f, -1.44834295e-02f,
  -9.29655507e-02f, -2.17958957e-01f, -4.44844253e-02f, 1.31654330e-02f, -9.43047088e-03f, -3.43809612e-02f, -4.76931687e-03f, -2.77766325e-02f, -3.63940783e-02f, -1.19736753e-01f,
  3.68576795e-02f, 3.29940766e-02f, 3.99362408e-02f, 3.29414494e-02f, 8.66295863e-03f, -7.05092028e-02f, -5.48881404e-02f, 4.05215621e-02f, -3.25331315e-02f, -3.19693498e-02f,
  6.74256459e-02f, 2.26707831e-02f, -3.48935053e-02f, 4.04293137e-03f, 5.46857379e-02f, -2.43047364e-02f, -4.99823317e-02f, 7.28716999e-02f, -6.69372305e-02f, -1.08359111e-02f,
  3.11901987e-01f, -1.83103114e-01f, -1.42895177e-01f, 1.40341103e-01f, 9.35371667e-02f, 1.77153736e-01f, 1.16642311e-01f, 6.17929436e-02f, 1.86542571e-01f, -1.79136932e-01f,
  5.42591475e-02f, -1.38421640e-01f, -2.08258629e-01f, 1.19666502e-01f, 1.50457859e-01f, -1.55342638e-01f, 1.91071823e-01f, -4.04976048e-02f, 5.71129657e-02f, 9.97761413e-02f,
  1.91785499e-01f, 1.83551192e-01f, -3.15812677e-02f, 3.81469019e-02f, 1.54276595e-01f, -3.90674472e-02f, -2.14125607e-02f, -1.91672325e-01f, 8.02665800e-02f, -6.01778850e-02f,
  2.47705970e-02f, -1.78771652e-02f, 2.38597076e-02f, 1.71372797e-02f, 3.31708137e-03f, -4.49035391e-02f, 4.08762470e-02f, -7.01548010e-02f, 7.93097913e-02f, -4.49623819e-03f,
  2.01485306e-02f, -2.52000187e-02f, 6.09115288e-02f, -4.63525718e-03f, 1.28771767e-01f, -5.07684574e-02f, 3.83129269e-02f, 7.61711225e-02f, -4.72171307e-02f, 2.26953384e-02f,
  -5.60702421e-02f, 2.73126382e-02f, 1.22149087e-01f, -3.70492861e-02f, 2.83052921e-02f, -3.01591605e-02f, 2.74870521e-03f, -8.30993056e-02f, 2.17477288e-02f, 9.67523530e-02f,
  3.18240188e-02f, -1.77096426e-02f, -3.90340537e-02f, 1.25890169e-02f, 4.31775069e-03f, -5.83999567e-02f, 4.64437157e-02f, -1.09200709e-01f, 3.57531458e-02f, -1.62516516e-02f,
  -1.92187037e-02f, 5.43407463e-02f, -5.83342537e-02f, 3.62939131e-03f, 3.35833840e-02f, 5.10264188e-02f, 1.07961232e-02f, -5.54365329e-02f, -1.04907295e-02f, 3.73102091e-02f,
  -7.04860836e-02f, 1.15678702e-02f, -7.25881457e-02f, 4.15170640e-02f, 2.44298093e-02f, -6.34099543e-02f, 7.05929026e-02f, -3.35454233e-02f, 6.39885012e-03f, -6.22487208e-03f,
  3.29804048e-02f, -5.37021197e-02f, -2.01629964e-03f, -8.60541537e-02f, -2.53505725e-02f, 5.07068001e-02f, -4.97608520e-02f, 4.12124433e-02f, -1.46276960e-02f, 7.47963563e-02f,
  6.87864656e-03f, -5.95205165e-02f, 4.83052693e-02f, -2.65771840e-02f, 4.70129587e-02f, 6.78098127e-02f, -5.54765090e-02f, 2.80456245e-02f, 8.40936974e-03f, -1.17742429e-02f,
  2.17507612e-02f, 2.31411159e-02f, -6.47796094e-02f, 2.11052736e-03f, 4.86623757e-02f, -4.22487920e-03f, -5.38439781e-04f, 5.82531318e-02f, 6.57182038e-02f, -5.70670106e-02f,
  -3.35345984e-01f, 3.59477550e-01f, 1.85428903e-01f, 1.27866074e-01f, -2.55911767e-01f, 1.34002164e-01f, -1.07066646e-01f, 1.53792992e-01f, 1.94161877e-01f, 2.31377244e-01f,
  3.58220842e-03f, 5.94555512e-02f, 3.77312489e-02f, 1.25873461e-01f, -5.70568740e-02f, 2.35731781e-01f, 1.71730369e-01f, 3.17224115e-02f, -9.19946528e-04f, 4.84629273e-02f,
  1.43900633e-01f, 7.36459941e-02f, 6.59130141e-02f, 9.29783210e-02f, 1.20670907e-01f, 6.97480096e-03f, -1.39927953e-01f, 4.97639664e-02f, 2.73748245e-02f, -1.79024246e-02f,
  2.86712870e-02f, 1.59070138e-02f, -6.95686936e-02f, -3.34400460e-02f, -1.07538156e-01f, -9.99976993e-02f, 7.60642404e-04f, -8.44879150e-02f, 5.06858118e-02f, 2.19029561e-02f,
  -4.84559536e-02f, -2.37062983e-02f, 2.28771195e-02f, 6.65908232e-02f, 1.04625477e-02f, 4.28724810e-02f, 1.56566687e-02f, 8.63152444e-02f, 1.14966191e-01f, -4.16672381e-04f,
  5.97276799e-02f, 1.25269983e-02f, 5.38428761e-02f, 7.11165816e-02f, 2.00424111e-03f, 5.08510992e-02f, 5.74093079e-03f, 4.19276580e-03f, 5.81049398e-02f, -2.20808368e-02f,
  -1.04604430e-01f, 1.24463011e-02f, -3.65726911e-02f, -2.40074191e-02f, 4.31326441e-02f, 2.86169369e-02f, 2.61795688e-02f, -1.17341772e-01f, 6.17417740e-04f, 3.31500173e-03f,
  -2.78822165e-02f, -4.77316305e-02f, 3.95985506e-02f, 6.93270704e-03f, -3.74522130e-03f, 8.76163412e-03f, -9.21661779e-03f, -9.23253894e-02f, -2.23168172e-02f, -8.71636420e-02f,
  1.75189581e-02f, 1.00148670e-01f, 4.56094928e-02f, -6.65305033e-02f, 7.15970120e-04f, 1.05557494e-01f, 1.77141912e-02f, 5.13765290e-02f, 6.57183304e-02f, -5.26358224e-02f,
  2.33450178e-02f, 1.80887818e-01f, 5.69582060e-02f, 6.32061809e-02f, -1.97375324e-02f, 8.72166604e-02f, -2.23488156e-02f, 7.64701888e-02f, 2.50236434e-03f, 1.71529502e-02f,
  3.72770876e-02f, -6.21060282e-02f, 4.06507477e-02f, -1.71163492e-02f, 3.37240286e-02f, 5.44295870e-02f, -2.50139311e-02f, -2.17960496e-02f, -6.76083844e-03f, 6.56064320e-03f,
  -2.59330478e-02f, -5.42603880e-02f, 4.59716329e-03f, 6.07696809e-02f, -7.65022710e-02f, -4.21692394e-02f, -7.40662962e-02f, -4.08750586e-02f, 5.11104986e-03f, 6.22008927e-02f,
  2.54282206e-02f, -3.66282947e-02f, -1.28037304e-01f, -2.33416528e-01f, 1.71848685e-01f, 4.35534827e-02f, -2.33999103e-01f, -5.28042540e-02f, -2.18802765e-02f, 1.67878121e-02f,
  -1.56613231e-01f, 1.75899282e-01f, -9.08042267e-02f, -2.72132456e-01f, -8.71042609e-02f, -2.07916871e-01f, -2.61644691e-01f, -9.26990286e-02f, -5.66545986e-02f, -1.08004764e-01f,
  -4.51307185e-02f, -1.79507017e-01f, -1.52153283e-01f, 3.65485661e-02f, -4.24642637e-02f, 8.35060105e-02f, -1.30941689e-01f, 1.32292449e-01f, -3.01072188e-02f, 8.44626650e-02f,
  -5.18162102e-02f, 6.68602437e-02f, -8.55923072e-03f, 1.13744056e-02f, -1.26973927e-01f, 3.14268321e-02f, -2.48718373e-02f, 5.48540801e-02f, 5.50553985e-02f, -7.14807659e-02f,
  4.68818061e-02f, 3.60835791e-02f, 9.13332105e-02f, 1.74553413e-02f, 1.03530161e-01f, -1.44712040e-02f, 2.50597466e-02f, 5.54068200e-02f, 6.15375638e-02f, 1.34344874e-02f,
  -2.91491151e-02f, 1.73229550e-03f, 3.96052226e-02f, 1.86808931e-03f, -3.30232829e-02f, 7.33547211e-02f, 3.70146707e-02f, -1.12710670e-02f, -3.76747623e-02f, 6.77000955e-02f,
  3.01773027e-02f, -2.49560978e-02f, -7.09831119e-02f, -7.95687288e-02f, -2.45422833e-02f, -4.88394909e-02f, 2.25690287e-02f, 7.62487277e-02f, -4.44982992e-03f, 1.95861608e-02f,
  9.56331380e-03f, 4.78666611e-02f, -2.36905068e-02f, -4.17079479e-02f, 1.78388245e-02f, -1.08068287e-02f, -1.82776228e-02f, 8.96369368e-02f, -7.13970279e-03f, 2.28287652e-02f,
  6.62204251e-02f, 3.76251154e-02f, -3.55305262e-02f, -5.07975854e-02f, -7.67321065e-02f, -9.29747988e-03f, 3.50626782e-02f, -2.90505402e-02f, -9.88705009e-02f, -1.93232782e-02f,
  8.13354179e-03f, -9.29007903e-02f, 4.73881066e-02f, 2.80619096e-02f, 5.36786281e-02f, 5.17311618e-02f, -1.09266024e-02f, 5.02232872e-02f, 1.91706922e-02f, -8.92437645e-04f,
  -4.29189838e-02f, -8.36466849e-02f, -2.19175592e-03f, 4.29292955e-02f, -3.79624590e-02f, 2.59353481e-02f, -8.12922120e-02f, 7.65583590e-02f, -2.08751429e-02f, -4.22705943e-03f,
  -8.60520080e-02f, 4.32346985e-02f, -8.51293057e-02f, -6.77984674e-03f, 4.71153669e-02f, -1.34034716e-02f, -3.24969366e-03f, -5.77555485e-02f, 1.78858340e-02f, -6.11854978e-02f,
  5.84155023e-02f, -5.57017215e-02f, 1.75180063e-01f, 2.28158996e-01f, -1.47915762e-02f, -2.55869120e-01f, -2.70729423e-01f, 1.28461465e-01f, 7.27007464e-02f, -2.88901299e-01f,
  -2.49407470e-01f, -1.47103844e-02f, -1.58193648e-01f, -1.19740263e-01f, 3.11676979e-01f, -5.99016026e-02f, 1.60474867e-01f, -7.69402133e-03f, 9.88164917e-02f, -4.22316641e-02f,
  1.29217207e-01f, -1.20164946e-01f, 1.64074421e-01f, 1.47777334e-01f, 2.20713904e-03f, 1.71648394e-02f, 1.50023133e-01f, -9.20001492e-02f, -1.08240776e-01f, -9.79129300e-02f,
  -1.15637831e-01f, 1.70173086e-02f, 5.63412979e-02f, -6.10417351e-02f, 2.33676787e-02f, -8.52965117e-02f, -9.72310379e-02f, -2.53733248e-02f, 3.16377915e-02f, -5.92880473e-02f,
  -2.94859428e-02f, 5.13550360e-03f, 7.26663992e-02f, 1.36338947e-02f, -2.12388709e-02f, 7.05793053e-02f, 4.03824262e-02f, -1.34169638e-01f, -9.12270416e-03f, 9.61939245e-03f,
  -7.86755681e-02f, -1.15315644e-02f, -4.58385376e-03f, 4.46596276e-03f, 6.82141483e-02f, -1.65207486e-03f, -3.44640091e-02f, -6.06062599e-02f, 3.61614078e-02f, 1.47822484e-01f,
  -5.34634776e-02f, -6.13652356e-02f, -4.78665493e-02f, -8.32245722e-02f, 2.25904174e-02f, -5.35150953e-02f, -1.85008242e-03f, 1.73452832e-02f, 3.14744301e-02f, -4.40253541e-02f,
  -5.38519118e-03f, -2.65750103e-02f, -1.98846199e-02f, -6.27637208e-02f, -7.25304661e-03f, -7.93416239e-03f, -7.15190470e-02f, -5.77895455e-02f, 2.84643471e-02f, 5.21999262e-02f,
  3.22347768e-02f, -2.01853528e-03f, -1.05976434e-02f, -1.14588384e-02f, -5.48896492e-02f, -5.88907599e-02f, 3.09184697e-02f, 1.88311767e-02f, 4.43196446e-02f, -2.26936247e-02f,
  1.02314740e-01f, 4.68346998e-02f, -1.75361261e-02f, -6.75495118e-02f, 2.35443003e-02f, 2.67048627e-02f, 3.07328021e-03f, 4.32268344e-02f, 6.20096140e-02f, -4.75240387e-02f,
  -1.97182447e-02f, 1.40546039e-02f, -7.17413127e-02f, 4.40843813e-02f, 1.11747123e-02f, 6.24784827e-02f, -3.20650972e-02f, 2.51238570e-02f, 6.25035167e-02f, -1.97342765e-02f,
  2.59362813e-03f, -8.52237940e-02f, 1.44868931e-02f, -2.07734983e-02f, -4.62157279e-02f, -3.71720493e-02f, 3.30560580e-02f, 1.52311726e-02f, 3.10205910e-02f, -1.50387166e-02f,
  3.94796610e-01f, -4.06182051e-01f, 1.50045842e-01f, 1.80975512e-01f, 2.59421449e-02f, 2.93864850e-02f, 1.38856262e-01f, -1.37227178e-01f, 1.19531587e-01f, -1.70872167e-01f,
  8.98095667e-02f, 6.84915632e-02f, 1.15833052e-01f, 2.35218462e-02f, 2.71851361e-01f, 1.27747476e-01f, -2.32163947e-02f, -8.56711790e-02f, 1.27174050e-01f, -4.28681225e-02f,
  2.10869014e-01f, -4.62738462e-02f, 1.72438189e-01f, -2.50168711e-01f, -9.41139832e-02f, -8.75439644e-02f, -2.00244159e-01f, 3.39175537e-02f, -1.23602301e-01f, -4.35976647e-02f,
  9.43505615e-02f, 4.55295332e-02f, 8.86271372e-02f, 4.54693176e-02f, 1.61523912e-02f, -4.34334110e-03f, -1.35452803e-02f, -7.78781995e-02f, 6.28535897e-02f, -3.47864144e-02f,
  3.52748372e-02f, 4.84792748e-03f, 7.88469613e-02f, 7.87416939e-03f, -1.60610594e-03f, -1.94605179e-02f, 5.93404211e-02f, 5.44580556e-02f, 5.31246364e-02f, -1.71104744e-02f,
  1.72299910e-02f, -1.05219536e-01f, -5.78282168e-04f, -5.08122668e-02f, 2.45788712e-02f, 4.04380225e-02f, -3.99408154e-02f, -3.16991694e-02f, -9.40401778e-02f, -5.16364053e-02f,
  -2.23814699e-04f, -6.18006326e-02f, -4.61330228e-02f, 7.02459514e-02f, 5.77834733e-02f, 8.79494250e-02f, -6.66597784e-02f, -5.00718802e-02f, 8.47785082e-03f, -2.72731693e-03f,
  3.27793472e-02f, -1.66050103e-02f, 1.18134376e-02f, -4.65539135e-02f, -7.84098506e-02f, -2.86484081e-02f, 5.52821942e-02f, -7.65164942e-02f, 2.79607102e-02f, 2.23278478e-02f,
  -3.60675044e-02f, -8.75862688e-03f, 1.16757192e-02f, -4.69650887e-02f, -5.66322580e-02f, 1.15063086e-01f, -9.99788381e-03f, -5.83617308e-04f, -1.82509571e-02f, -2.44566426e-02f,
  -1.82595968e-01f, -1.64419040e-01f, -9.03361361e-04f, -5.22797741e-02f, 5.08061573e-02f, -5.99644408e-02f, 3.97863686e-02f, -8.13690666e-03f, 2.49216612e-02f, 7.75671899e-02f,
  -4.91379807e-03f, 1.59278065e-02f, -3.63364555e-02f, 8.45401809e-02f, -3.32121663e-02f, 9.83960461e-03f, -6.94209859e-02f, -3.37819494e-02f, 3.03873938e-04f, -7.13303313e-02f,
  -8.85782614e-02f, -1.43551892e-02f, 2.23333109e-02f, 2.85965651e-02f, -5.36638759e-02f, -2.82720849e-02f, -9.58298147e-02f, -1.63932424e-02f, -8.81154239e-02f, -1.21015161e-02f,
  -2.02234358e-01f, -2.73327619e-01f, 1.05263352e-01f, -1.92506894e-01f, -3.43977399e-02f, 1.62079185e-01f, -5.85603807e-03f, -1.23749618e-04f, -3.97962853e-02f, -1.78039923e-01f,
  -2.02680305e-02f, -2.27003232e-01f, 9.95593742e-02f, -4.09304313e-02f, 2.13113159e-01f, 2.13120490e-01f, -3.97755131e-02f, -3.37330885e-02f, 5.17335869e-02f, -1.85771585e-01f,
  1.03522286e-01f, -9.35403407e-02f, 6.78035319e-02f, -9.12664011e-02f, 5.92603395e-03f, -4.57141660e-02f, -8.76438394e-02f, 5.94377369e-02f, -8.29039887e-02f, 1.01125024e-01f,
  -1.41613275e-01f, -5.62665798e-02f, -9.49725956e-02f, 2.34187134e-02f, 3.18084587e-03f, -4.67063934e-02f, 5.32287508e-02f, 3.75280418e-02f, -3.38202678e-02f, -7.37218857e-02f,
  -5.66015169e-02f, 5.99620305e-02f, 2.50306465e-02f, 2.38275733e-02f, -6.16973601e-02f, -6.34869412e-02f, -3.79475094e-02f, -5.63058928e-02f, -2.07968894e-02f, 7.07109198e-02f,
  -4.21326701e-03f, -1.39050772e-02f, -3.56485508e-02f, -4.86552231e-02f, 3.57470959e-02f, -6.56825900e-02f, -4.12866324e-02f, 1.16020478e-01f, 3.14352699e-02f, 2.56185587e-02f,
  6.55903816e-02f, -2.79200673e-02f, -3.01785488e-02f, -5.34468107e-02f, -7.03244284e-02f, 3.52676143e-03f, -5.70678711e-02f, 9.64692794e-03f, 2.32382189e-03f, 5.47663905e-02f,
  7.35741481e-02f, -1.23807989e-01f, 2.97503062e-02f, 5.03485240e-02f, -9.90093499e-02f, 2.46650614e-02f, -8.04204866e-03f, 5.18876016e-02f, 5.02557382e-02f, 7.37717450e-02f,
  -1.02119651e-02f, -2.55558118e-02f, -4.75119911e-02f, -3.76913846e-02f, -6.66734879e-04f, -2.34978087e-02f, -1.31943896e-02f, -6.96344599e-02f, -2.91090384e-02f, 6.25618324e-02f,
  -1.85838923e-01f, -1.87172920e-01f, 3.47442254e-02f, -1.39574230e-01f, -6.16230676e-03f, 6.70210272e-02f, -2.14125123e-02f, 7.33809099e-02f, 7.07456023e-02f, -7.45077506e-02f,
  6.16148226e-02f, -1.16155051e-01f, 5.73255122e-02f, 2.47012498e-03f, 2.54197512e-02f, -2.45761666e-02f, -3.92125472e-02f, -2.91250460e-02f, -6.04164740e-03f, 3.22976299e-02f,
  -1.25960454e-01f, -5.49695455e-02f, 1.74356648e-03f, 6.32836064e-03f, 5.22927335e-03f, -5.15269698e-04f, -6.40068874e-02f, 4.41010520e-02f, 9.09810662e-02f, 8.53374787e-03f,
  1.08422399e-01f, -2.19091892e-01f, -1.05742864e-01f, 5.12478910e-02f, 8.13469142e-02f, 2.47253820e-01f, -1.85359307e-02f, 5.72936013e-02f, 1.88114002e-01f, 1.81352487e-03f,
  4.16310802e-02f, -2.61586219e-01f, -1.67495281e-01f, -8.41602981e-02f, 8.10708152e-04f, -3.79489064e-02f, 2.12182969e-01f, -5.35417274e-02f, 1.05904713e-01f, 1.36888370e-01f,
  3.60778309e-02f, 1.25604868e-01f, -1.95139751e-01f, 1.90930814e-01f, -1.80988535e-02f, -8.08503851e-03f, -2.35207602e-02f, -6.23580404e-02f, -8.94175917e-02f, 2.31921133e-02f,
  -4.11244184e-02f, -5.10071628e-02f, -6.03165515e-02f, -8.34862962e-02f, 9.70929936e-02f, 2.73231640e-02f, 1.25898300e-02f, -4.94904816e-02f, -3.15863043e-02f, -2.13892609e-02f,
  -8.30512494e-02f, -4.71399240e-02f, -9.36904829e-03f, 2.18745135e-02f, 4.01678346e-02f, -2.07833946e-02f, 1.26103126e-02f, 8.00524559e-03f, 7.23241502e-03f, -4.03356142e-02f,
  1.27421983e-04f, -7.49536529e-02f, 8.49092826e-02f, 1.15642208e-03f, -9.27595422e-02f, 8.73490889e-03f, -3.37661356e-02f, 7.62882642e-03f, 6.95291162e-02f, -2.15537883e-02f,
  7.81690776e-02f, 4.31136154e-02f, -1.39998905e-02f, -5.21358885e-02f, 7.06476048e-02f, 1.79896578e-02f, 2.34183967e-02f, -7.12761581e-02f, 3.98174748e-02f, -3.64427082e-02f,
  2.79463567e-02f, -6.37212172e-02f, 3.01392144e-03f, 1.13338120e-01f, 4.36130017e-02f, 7.37271085e-02f, -8.05664435e-02f, -1.11116813e-02f, 7.90017471e-02f, 1.05215264e-02f,
  -6.88097998e-02f, 4.77185212e-02f, -2.03022528e-02f, -8.01171362e-02f, -1.22823641e-02f, -2.36893073e-03f, -4.80649993e-02f, -6.98670745e-02f, 4.44711223e-02f, -4.14837524e-03f,
  6.87880516e-02f, 3.13511938e-02f, -1.19311188e-03f, 6.72263876e-02f, -8.98040161e-02f, 1.50920711e-02f, 4.52749804e-02f, -7.27346074e-03f, 8.73880312e-02f, 7.91125819e-02f,
  4.10295166e-02f, 3.46418209e-02f, 8.21853280e-02f, 9.20295194e-02f, -6.06454536e-02f, 2.57338528e-02f, 2.44308095e-02f, 2.46212091e-02f, 6.72282577e-02f, 1.87552515e-02f,
  3.65100466e-02f, 1.09266839e-03f, -9.44579893e-04f, 1.06319174e-01f, 1.10130094e-01f, 5.83772324e-02f, 4.31359857e-02f, -2.96854917e-02f, -3.25201117e-02f, 4.17845584e-02f,
  3.18104267e-01f, 4.38047647e-02f, 1.07474536e-01f, 1.18093289e-01f, 9.79723558e-02f, -7.16271773e-02f, 3.54013667e-02f, 1.21155351e-01f, 1.61638513e-01f, 8.48164931e-02f,
  -2.68992595e-02f, 1.88974053e-01f, -1.68187618e-01f, 1.20782003e-01f, -8.68752226e-02f, -1.37727752e-01f, 1.16579272e-01f, -5.70991263e-02f, 3.54487561e-02f, 1.76783666e-01f,
  7.78659657e-02f, 1.78627700e-01f, -1.09628081e-01f, 5.67875393e-02f, 1.90536827e-01f, 3.88823263e-02f, 9.76127535e-02f, -2.55546737e-02f, -6.19910564e-03f, 1.13100773e-02f,
  2.61181733e-03f, -2.51383949e-02f, -5.77213876e-02f, -2.20606513e-02f, 6.54730126e-02f, -3.31848785e-02f, -8.28370750e-02f, -6.38846233e-02f, 1.75754856e-02f, -8.11128542e-02f,
  1.14376307e-01f, 1.10572148e-02f, -5.01638162e-04f, -1.93855930e-02f, 7.32856542e-02f, -2.17508934e-02f, -1.24512892e-02f, 5.97245283e-02f, 1.25266882e-02f, 2.48988159e-04f,
  -7.47887418e-02f, -9.35841054e-02f, 1.22337751e-01f, -3.61490995e-02f, -5.54043017e-02f, -6.74886703e-02f, -3.27230282e-02f, -7.58922985e-03f, 5.51698655e-02f, 5.28366975e-02f,
  7.07623661e-02f, -6.32005706e-02f, -3.18612065e-03f, 4.46458422e-02f, -3.52174714e-02f, -3.64210568e-02f, -4.24838550e-02f, -4.29886207e-02f, 3.16149294e-02f, -3.00680287e-02f,
  3.21193831e-03f, 6.84167296e-02f, 7.51090497e-02f, -8.80871341e-03f, 1.09560497e-01f, 1.46996521e-03f, -1.46756764e-03f, 1.78653784e-02f, 5.13409190e-02f, 5.78191243e-02f,
  -4.70997207e-02f, -6.96295640e-04f, -3.57796177e-02f, 7.75166750e-02f, 4.63676732e-03f, 1.59116257e-02f, 8.59887078e-02f, -4.76603992e-02f, -2.80302912e-02f, 4.93622981e-02f,
  2.70171501e-02f, 1.31612286e-01f, 2.12024804e-02f, -5.19920550e-02f, -1.30097857e-02f, 4.76036631e-02f, -5.60044385e-02f, 1.82907470e-02f, -3.91685739e-02f, 2.86399256e-02f,
  5.35354987e-02f, -2.73909383e-02f, 3.40526216e-02f, -1.47679504e-02f, -2.23608073e-02f, 2.00192910e-02f, -2.28468031e-02f, -1.80112757e-03f, 8.80137235e-02f, 1.08654229e-02f,
  7.85540864e-02f, 2.49813125e-02f, -3.04363715e-03f, 1.76665355e-02f, 8.88723582e-02f, -4.64542881e-02f, 1.32528037e-01f, -4.92940992e-02f, 4.44490463e-03f, -5.13548218e-02f,
  1.19485877e-01f, -1.27327174e-01f, -9.96033177e-02f, 1.41600892e-01f, 1.11293852e-01f, -2.48159677e-01f, -1.43758386e-01f, 1.00034826e-01f, -1.95916057e-01f, -6.31295368e-02f,
  8.83487687e-02f, 4.58797961e-02f, -1.89005241e-01f, 1.78041294e-01f, 1.57667831e-01f, -1.14678390e-01f, 1.11390732e-01f, -4.71232608e-02f, -1.08921677e-01f, 7.43846521e-02f,
  1.82659701e-01f, 1.77127317e-01f, 1.03388958e-01f, 3.13355699e-02f, 1.16105244e-01f, 1.16771139e-01f, 2.11138085e-01f, -6.92710131e-02f, 6.03980161e-02f, 1.89333931e-02f,
  8.32294077e-02f, 1.46556690e-01f, 7.93064609e-02f, -2.02215295e-02f, 4.78384346e-02f, -2.95133349e-02f, -3.90495025e-02f, -3.71152833e-02f, 1.31344385e-02f, -5.66202737e-02f,
  -8.89506564e-02f, -3.65922414e-02f, -3.62202972e-02f, -1.44046163e-02f, -1.04197554e-01f, 1.25853000e-02f, 8.75495654e-03f, -1.69869307e-02f, 9.82617140e-02f, 9.03748646e-02f,
  9.37392190e-03f, 2.99904495e-02f, 4.95431870e-02f, 3.90733071e-02f, 2.55787335e-02f, -7.02414438e-02f, -7.96303824e-02f, 8.09401274e-02f, 1.24781348e-01f, 5.49276695e-02f,
  -6.75946474e-02f, -1.11630067e-01f, 7.55174309e-02f, 9.67951678e-03f, -5.26290834e-02f, 6.89211637e-02f, 1.09798778e-02f, 2.07149028e-03f, 1.22576253e-02f, 7.10254908e-02f,
  5.60622886e-02f, 7.47042522e-02f, -5.36222905e-02f, -4.76479232e-02f, -4.19900715e-02f, 6.88622966e-02f, 6.91994056e-02f, -3.66509594e-02f, -9.74679589e-02f, 5.69876842e-02f,
  6.74507469e-02f, 6.84433728e-02f, 5.44250421e-02f, 2.55463012e-02f, -3.23130526e-02f, 1.34405186e-02f, -1.12604193e-01f, -3.78764011e-02f, 7.17035532e-02f, 7.93130696e-02f,
  5.71350195e-02f, 1.35273576e-01f, 1.05096579e-01f, 7.98278823e-02f, 6.62920028e-02f, 1.03976853e-01f, 2.48410553e-02f, 1.65472843e-03f, -2.87751425e-02f, 5.08866124e-02f,
  6.60318285e-02f, 2.29980308e-03f, 4.06144299e-02f, -8.05520862e-02f, -5.37208393e-02f, 2.13808119e-02f, 4.81615439e-02f, 1.04800472e-02f, 1.11473024e-01f, -5.04939295e-02f,
  1.54542029e-01f, -5.92527092e-02f, 6.03029281e-02f, 1.51490167e-01f, -3.16292234e-02f, 1.16356723e-02f, 7.67486691e-02f, 2.29435619e-02f, 3.52440076e-03f, 7.05679879e-02f,
  -1.52386487e-01f, -2.55008601e-02f, -3.44496191e-01f, -1.85919255e-01f, 1.00853942e-01f, 1.48375541e-01f, -1.23896338e-01f, 8.46883357e-02f, 1.09349899e-02f, 1.71580538e-01f,
  9.11600515e-02f, -1.85056284e-01f, 3.76149453e-02f, 2.46633943e-02f, -2.12412611e-01f, 6.61355704e-02f, 1.83621436e-01f, -5.71687669e-02f, 1.82206497e-01f, -3.55241145e-03f,
  -2.82405391e-02f, 1.91793233e-01f, -8.39746296e-02f, 1.87716797e-01f, -1.05653167e-01f, -3.68463919e-02f, -2.82065831e-02f, -5.11647612e-02f, 2.15268955e-02f, -4.62047644e-02f,
  5.14247641e-02f, -3.27877700e-02f, -1.31399587e-01f, -1.10971548e-01f, 1.41175231e-02f, -9.20753926e-02f, -1.37786135e-01f, -1.53726250e-01f, 6.22138120e-02f, 5.86160738e-03f,
  5.91118820e-04f, -3.76472212e-02f, 3.83067131e-02f, 9.24342871e-02f, -1.99304670e-02f, -1.29030332e-01f, 1.34214601e-02f, 9.42890346e-02f, 3.45728658e-02f, -4.55697663e-02f,
  -2.93844088e-04f, 1.70792211e-02f, -3.26539986e-02f, -3.74030620e-02f, -2.79870685e-02f, 6.75317571e-02f, 6.60279915e-02f, -1.12480901e-01f, -1.71765871e-02f, -1.38001954e-02f,
  5.77879548e-02f, 1.50838355e-02f, -4.58777249e-02f, 5.72472140e-02f, 4.07166928e-02f, 1.78233236e-02f, 5.30226566e-02f, 8.15896243e-02f, -5.39733507e-02f, -1.54735642e-02f,
  4.04408984e-02f, -4.18684036e-02f, 4.82406802e-02f, 1.87054165e-02f, 1.17030509e-01f, 1.41763641e-02f, -6.33084625e-02f, -8.60566199e-02f, -1.29382778e-02f, 1.46528780e-02f,
  -4.65272479e-02f, -6.61056396e-03f, -6.91496208e-02f, -5.27282320e-02f, -2.50012204e-02f, 6.28986731e-02f, 1.14918992e-01f, 7.82997236e-02f, 5.61720990e-02f, -7.24521875e-02f,
  -2.70092972e-02f, -1.65665537e-01f, 4.74003479e-02f, -8.81353952e-03f, -7.77885318e-02f, 5.90645075e-02f, 5.53073250e-02f, 2.88901348e-02f, -4.11026254e-02f, -2.95354333e-02f,
  -3.80400084e-02f, 5.72826192e-02f, -3.50955799e-02f, 9.72395167e-02f, 8.01625755e-03f, 4.50022146e-02f, -1.18061285e-02f, -1.85904835e-04f, -2.15421021e-02f, 5.45138866e-02f,
  -7.03238919e-02f, -7.37065300e-02f, 5.12545975e-03f, 6.00048481e-03f, 4.73018251e-02f, -4.27851193e-02f, -9.86833870e-02f, -4.14445251e-02f, -2.82074865e-02f, 1.56603605e-02f,
  2.79172271e-01f, 1.63332760e-01f, 2.52402518e-02f, 2.43612844e-02f, -1.71567976e-01f, -2.27421120e-01f, -1.27726272e-01f, -1.30935341e-01f, -4.52052206e-02f, -3.39203514e-02f,
  -1.15968592e-01f, 1.52478829e-01f, 2.08141096e-02f, -1.34641811e-01f, -1.43167106e-02f, -1.25261620e-01f, -1.04628168e-01f, -1.16553484e-02f, -3.44353504e-02f, 3.66448089e-02f,
  -5.07908091e-02f, -5.06052263e-02f, -1.37067840e-01f, -1.27378237e-02f, -3.00197806e-02f, 6.51631355e-02f, 8.36160108e-02f, 1.26027241e-01f, 6.98479861e-02f, -8.77015293e-02f,
  1.27155520e-02f, 1.58876076e-01f, 7.51936138e-02f, 1.17170617e-01f, 5.37954681e-02f, 9.34711620e-02f, 1.47876203e-01f, -4.46692258e-02f, 2.32097972e-02f, -5.52175343e-02f,
  6.26069531e-02f, -1.17671993e-02f, -7.49218091e-02f, -7.38778636e-02f, 2.97192223e-02f, -5.08775609e-03f, -7.40379617e-02f, -5.96761815e-02f, -9.86586418e-03f, -3.09821572e-02f,
  -1.11216366e-01f, -4.32407036e-02f, 3.29163931e-02f, 3.33147831e-02f, 5.14942668e-02f, -7.01340707e-03f, -3.22789066e-02f, 1.78674385e-02f, 1.71378572e-02f, 3.96980196e-02f,
  2.42122523e-02f, 2.61471290e-02f, -1.25986766e-02f, 3.42836156e-02f, 1.09713059e-02f, -5.15850969e-02f, -2.26552300e-02f, -4.56145313e-03f, 7.36084804e-02f, -2.72967089e-02f,
  -1.00181058e-01f, -6.60207681e-03f, 3.15000936e-02f, 4.70425747e-02f, -8.50295764e-04f, 3.28379236e-02f, 4.62834015e-02f, -1.00613117e-01f, 6.42548874e-02f, -5.29101305e-02f,
  2.16890201e-02f, -4.53005731e-03f, 6.08967431e-03f, -6.48669526e-02f, 1.74093917e-02f, 5.73771745e-02f, 1.67408027e-02f, -9.20604691e-02f, -4.31840979e-02f, 3.54534127e-02f,
  1.34724423e-01f, 2.64591187e-01f, -1.35752596e-02f, -2.92767622e-02f, -2.43410207e-02f, 1.37106860e-02f, 2.04886757e-02f, -2.48415805e-02f, 1.23149633e-01f, 1.85922440e-02f,
  -7.02526048e-03f, 1.94234517e-03f, 3.78104858e-02f, 3.93890515e-02f, 3.71515565e-02f, -3.43258753e-02f, -9.79722943e-03f, 2.68429937e-03f, 3.54595594e-02f, 4.01640683e-02f,
  1.13876492e-01f, 4.39225994e-02f, -2.47328356e-02f, -2.56719477e-02f, 2.31644716e-02f, -1.72202773e-02f, 9.62922350e-02f, -1.38223367e-02f, -5.42251691e-02f, 3.45719568e-02f,
  -2.67805517e-01f, 4.48728427e-02f, -2.43340865e-01f, -7.46013084e-03f, -3.88807133e-02f, 1.89932045e-02f, -1.23656489e-01f, 1.72230780e-01f, -1.91779304e-02f, 2.06489757e-01f,
  -2.84654759e-02f, -1.44083679e-01f, -7.61825067e-04f, 6.62981570e-02f, -1.97826535e-01f, -9.28416625e-02f, -3.37793157e-02f, -7.13099316e-02f, -4.44514342e-02f, 7.68268779e-02f,
  -7.17023537e-02f, 1.72382459e-01f, -2.84961127e-02f, 2.76704103e-01f, -3.04657370e-02f, 5.08865863e-02f, 1.40125066e-01f, 7.44182151e-03f, 2.47920156e-02f, -4.25019525e-02f,
  -6.28843904e-02f, 7.59080276e-02f, 2.02543437e-02f, 6.32329611e-03f, 7.23001584e-02f, -2.81273741e-02f, -2.39796583e-02f, -2.00494491e-02f, -2.38503199e-02f, 1.58475302e-02f,
  -5.02531566e-02f, -1.65810380e-02f, 1.83259603e-02f, -2.94006057e-02f, 5.36002144e-02f, -1.73220690e-02f, -5.79480492e-02f, -3.60915326e-02f, -2.64454111e-02f, -1.80056408e-01f,
  -5.29723987e-02f, -1.13734692e-01f, -8.37698877e-02f, -4.00474109e-02f, -4.74371389e-02f, 7.39150271e-02f, -5.04840054e-02f, -1.60474524e-01f, 3.72879133e-02f, -3.33706252e-02f,
  3.23725492e-02f, 7.14593455e-02f, 1.54923566e-03f, 1.92742441e-02f, 1.49197569e-02f, -4.67267297e-02f, 4.07394022e-02f, -5.68175688e-02f, -1.13896206e-02f, -3.89685482e-02f,
  5.91554604e-02f, -7.69700902e-03f, -9.31520760e-03f, 1.42121492e-02f, 1.16968213e-03f, -4.57911193e-02f, -6.01819791e-02f, -6.48041070e-02f, 1.17577501e-02f, -1.67051423e-02f,
  -1.14548942e-02f, -5.00303283e-02f, 5.80208153e-02f, -2.98911780e-02f, 6.79724896e-03f, -3.67606878e-02f, -4.61040214e-02f, -4.40469533e-02f, 3.45965358e-03f, -8.61636922e-02f,
  1.13221236e-01f, 2.54670739e-01f, 2.71342192e-02f, 3.51938345e-02f, 7.20989630e-02f, -3.60186659e-02f, -4.83800359e-02f, 1.12306513e-02f, 1.17522262e-01f, 2.16075033e-02f,
  3.22503112e-02f, -2.97029335e-02f, 1.35998940e-02f, 3.52736600e-02f, 1.00869462e-01f, -6.73428923e-02f, -1.88761298e-02f, 9.50196385e-02f, 3.82417291e-02f, 4.57281545e-02f,
  4.55254875e-03f, 3.70203294e-02f, 2.05296054e-02f, 2.10778769e-02f, 3.73541452e-02f, -2.07145456e-02f, 2.02005263e-02f, 9.34155937e-03f, -3.46661843e-02f, -3.10653541e-02f,
  -2.42128327e-01f, 2.57997930e-01f, -1.00097366e-01f, 4.44049537e-02f, 4.39159982e-02f, -1.06772594e-01f, -1.15129665e-01f, 1.86777100e-01f, 1.06538013e-01f, 1.19955033e-01f,
  -2.02307478e-02f, -1.65128410e-01f, 1.87010076e-02f, 1.64482281e-01f, -2.49457687e-01f, 1.63165703e-01f, 1.65685862e-02f, -9.58643630e-02f, 1.62808821e-01f, -2.96867304e-02f,
  9.32561047e-03f, 4.12958488e-02f, -2.45430991e-02f, 8.63993540e-02f, -1.15770899e-01f, -3.09189539e-02f, -1.28543258e-01f, 8.53919312e-02f, -1.83270946e-01f, -4.69411463e-02f,
  -1.04880385e-01f, 1.00036249e-01f, -8.66343603e-02f, -5.36143919e-03f, -1.91684246e-01f, -4.31294888e-02f, -8.72404501e-02f, 4.69025262e-02f, 6.44358769e-02f, -2.22150963e-02f,
  -7.38317594e-02f, 8.53389800e-02f, 5.27656861e-02f, 6.91620586e-03f, 7.89597034e-02f, 1.87099036e-02f, 1.04318969e-01f, -4.70785312e-02f, 1.17001240e-03f, 8.19320604e-02f,
  6.16532825e-02f, 3.98150645e-02f, -3.24854776e-02f, 1.11788310e-01f, -6.63911030e-02f, 2.64000371e-02f, -5.19555584e-02f, -1.07824467e-01f, -1.44301146e-01f, -5.28427362e-02f,
  1.60556082e-02f, -1.27660245e-01f, 5.18682785e-03f, -4.99458238e-02f, 4.19036206e-03f, -4.01853956e-02f, -4.84306067e-02f, 8.21305998e-03f, 3.80128883e-02f, -2.39483938e-02f,
  -7.79705420e-02f, 5.18170111e-02f, 6.73754066e-02f, 1.84932724e-02f, 4.87592444e-02f, 3.13124284e-02f, -5.55471703e-02f, 4.42383587e-02f, 4.60485555e-02f, 6.24873079e-02f,
  1.35061607e-01f, 5.21921776e-02f, 1.30632939e-02f, 6.66119307e-02f, 5.58582321e-02f, 1.79599877e-02f, 9.11352877e-03f, 8.89969990e-02f, 3.40424664e-03f, 5.36823599e-03f,
  -1.76440582e-01f, -6.68236166e-02f, -3.64629999e-02f, -2.39809062e-02f, -3.04367114e-02f, -4.04339507e-02f, -1.35607421e-02f, -7.32688829e-02f, -1.08963461e-03f, -5.50039448e-02f,
  -5.44097871e-02f, -3.81622352e-02f, -1.25098690e-01f, -2.66305264e-02f, -6.81122914e-02f, -1.69102363e-02f, -7.45545700e-02f, -1.13058239e-01f, -8.35855901e-02f, -2.54360400e-02f,
  -4.40284163e-02f, -9.63829234e-02f, 9.82282385e-02f, -1.81625448e-02f, 5.24950549e-02f, 4.35095280e-03f, 1.81710464e-03f, 3.38288918e-02f, -6.54733777e-02f, 7.79693620e-03f,
  -2.06542507e-01f, 2.72037059e-01f, 2.24913850e-01f, -2.04164639e-01f, 3.95760983e-02f, -2.68641915e-02f, -2.35824093e-01f, 2.10359067e-01f, -1.77209005e-01f, 4.66732867e-02f,
  -1.88479386e-02f, 8.40773582e-02f, -2.79710684e-02f, -3.66073214e-02f, -2.52845377e-01f, -1.93546802e-01f, -9.98161659e-02f, -7.35376105e-02f, -5.09519503e-02f, 1.17865138e-01f,
  -3.96378301e-02f, -1.16994008e-01f, 8.58263448e-02f, 1.57019660e-01f, 4.32744399e-02f, 1.72441676e-01f, -3.35123762e-03f, 7.00606629e-02f, 5.54682873e-02f, -4.21464331e-02f,
  5.09056561e-02f, -3.40924673e-02f, 1.41396672e-01f, -1.05143134e-02f, 1.11376885e-02f, -5.01025654e-02f, -7.06359297e-02f, -7.25969449e-02f, -4.18850891e-02f, -1.27935680e-02f,
  -1.72205959e-02f, 2.44400110e-02f, -6.18835837e-02f, 5.92376012e-03f, -2.44379342e-02f, -3.10069658e-02f, 3.80358696e-02f, -1.69639438e-02f, 8.01325217e-02f, 4.98945452e-02f,
  -4.49926704e-02f, -1.25626102e-02f, -4.79298681e-02f, -4.30217721e-02f, -5.27305454e-02f, 1.78551096e-02f, -5.19379005e-02f, 1.40076904e-02f, -6.08567940e-03f, -1.96382105e-02f,
  1.31896958e-02f, -1.52468588e-03f, -6.55207112e-02f, 4.78403680e-02f, 1.86513625e-02f, -1.38947302e-02f, 1.41018583e-02f, -2.43131164e-02f, 6.39400398e-03f, 4.18426050e-03f,
  2.26557590e-02f, -1.37173040e-02f, -6.37993515e-02f, 1.70859676e-02f, -3.86298001e-02f, 1.99980550e-02f, -3.42242047e-02f, -2.42986809e-02f, 4.15078783e-03f, 4.55995314e-02f,
  1.61976349e-02f, -7.55001605e-02f, 6.06345795e-02f, -9.99326445e-03f, 5.95881678e-02f, -3.93779948e-02f, 2.48180497e-02f, -5.62617555e-03f, -3.24089155e-02f, 4.92573455e-02f,
  1.96953285e-02f, 9.19133350e-02f, -1.73605047e-02f, -1.19778169e-02f, -2.80476045e-02f, -5.72405150e-03f, -4.65705022e-02f, 4.24691550e-02f, 6.30841404e-02f, -4.39921245e-02f,
  2.81322785e-02f, -1.38308015e-02f, -9.12696961e-03f, -4.83726636e-02f, -3.38588506e-02f, 6.49359897e-02f, -2.06250995e-02f, -1.04986168e-02f, -3.44127752e-02f, -1.55192893e-02f,
  3.41126546e-02f, 3.44481412e-03f, 1.55536020e-02f, 3.72250602e-02f, 3.47536020e-02f, -6.48032278e-02f, 7.78253525e-02f, -1.43175321e-02f, 6.09772578e-02f, 4.56994735e-02f,
  8.62300172e-02f, 1.64308220e-01f, 2.82304525e-01f, 2.16210917e-01f, 3.01739597e-03f, -9.25437883e-02f, -2.27202233e-02f, 1.31103620e-01f, 1.62622780e-01f, -7.89581463e-02f,
  -1.44797042e-02f, 6.22497946e-02f, -1.20403059e-01f, 2.41060689e-01f, -1.22261316e-01f, -5.82498014e-02f, 6.36098608e-02f, 1.72602199e-02f, 1.06726103e-01f, 3.58457938e-02f,
  -3.37116391e-04f, -1.15884924e-02f, 1.09046996e-01f, 4.36628945e-02f, 1.06893621e-01f, 1.15565263e-01f, -1.40909433e-01f, 4.95119020e-02f, 7.76994303e-02f, 9.59712919e-03f,
  -7.57305622e-02f, 1.60674006e-01f, 4.94574010e-02f, 2.24691024e-03f, 3.34278010e-02f, -4.17262726e-02f, -3.33592780e-02f, -5.51312417e-02f, 7.99481757e-03f, 3.79361771e-02f,
  -1.54476315e-01f, -8.88324380e-02f, 5.86846620e-02f, 3.84626612e-02f, 2.69880053e-02f, 2.84404196e-02f, -4.96736029e-03f, 6.17002882e-02f, 6.88288659e-02f, -3.67875323e-02f,
  7.58704469e-02f, 6.96435049e-02f, 4.97139059e-02f, 2.49860212e-02f, 2.90186200e-02f, 9.91608277e-02f, 3.28664221e-02f, 3.66953835e-02f, 2.37006657e-02f, -1.55720785e-02f,
  1.32971257e-01f, 1.58363339e-02f, 5.51953204e-02f, -2.63070948e-02f, 1.43399304e-02f, 4.16804813e-02f, -6.03731349e-02f, -6.09085336e-02f, -4.01450060e-02f, -6.03230204e-03f,
  -7.02284873e-02f, -1.66442711e-02f, 4.20964621e-02f, -1.34447142e-02f, 2.96976976e-02f, 5.06522134e-02f, -7.92041495e-02f, -8.78359005e-03f, -1.84283052e-02f, -9.88185853e-02f,
  6.68640956e-02f, -3.75484861e-02f, -3.63863632e-02f, -1.05186880e-01f, -2.36570165e-02f, -5.63356876e-02f, 8.51668324e-03f, 5.63158542e-02f, -4.12216857e-02f, -1.01663686e-01f,
  -2.66865641e-01f, -2.65695229e-02f, -5.82858594e-03f, -7.98381269e-02f, -1.86934154e-02f, -8.48854184e-02f, 8.43821540e-02f, -5.06782606e-02f, 1.48743726e-02f, 1.80825666e-02f,
  -3.05654686e-02f, -3.01555227e-02f, -1.32135510e-01f, -1.41898738e-02f, -2.49442998e-02f, -5.07036485e-02f, -1.74201857e-02f, -2.76123849e-03f, -9.04558972e-02f, -9.25892848e-04f,
  -3.71288583e-02f, -4.88682054e-02f, -3.14780623e-02f, 7.22992793e-02f, -6.02502450e-02f, -4.61629070e-02f, -3.65626439e-02f, 1.26233641e-02f, -4.57416251e-02f, 9.31876674e-02f,
  -9.52651575e-02f, -1.56238256e-02f, 1.54788531e-02f, 7.26767704e-02f, -1.48744434e-02f, -1.59965828e-01f, -1.89171180e-01f, -3.92586254e-02f, -2.21501827e-01f, -1.67906642e-01f,
  -6.76448047e-02f, 9.81868804e-02f, -1.47941381e-01f, 8.99993815e-03f, 2.78492957e-01f, 7.99420662e-03f, 1.29083499e-01f, -1.19337859e-02f, 7.99079165e-02f, 4.74709049e-02f,
  2.96970885e-02f, 2.07972795e-01f, 2.33167350e-01f, 1.73645824e-01f, -2.05924604e-02f, 4.25445549e-02f, 1.16965286e-01f, -3.99014615e-02f, 1.81299657e-01f, -8.47645663e-03f,
  3.60481739e-02f, -1.17604934e-01f, -8.84993598e-02f, -7.01319054e-02f, 1.02126331e-03f, -1.72263887e-02f, -1.19420877e-02f, -4.62220311e-02f, -7.75887147e-02f, 1.40705183e-02f,
  -3.93312946e-02f, 8.73088688e-02f, 5.01449928e-02f, 1.40513564e-02f, -3.97338457e-02f, -1.86887383e-02f, 3.38796973e-02f, -4.05236632e-02f, -3.28723118e-02f, -2.50187796e-02f,
  3.45391333e-02f, -8.00415222e-03f, -4.36641574e-02f, 4.84998412e-02f, 3.65462080e-02f, -9.04978886e-02f, 3.88769223e-03f, -4.01348993e-02f, -4.25170884e-02f, -3.66656594e-02f,
  4.44141924e-02f, -5.50377034e-02f, 2.96524744e-02f, -7.56294578e-02f, -4.87979725e-02f, -2.98042921e-03f, 1.84393078e-02f, 1.19942343e-02f, -1.32348957e-02f, 3.11253611e-02f,
  -1.37636336e-02f, -3.93766025e-03f, -4.02805507e-02f, -4.55965400e-02f, -4.83071944e-03f, -7.75140198e-03f, 5.81589490e-02f, -1.30065465e-02f, -6.48128390e-02f, 8.72004777e-03f,
  1.91348996e-02f, 1.64878964e-02f, -2.42938828e-02f, 1.47210015e-02f, -1.16212387e-03f, -4.35299687e-02f, 3.51968147e-02f, -3.77206467e-02f, 3.19866166e-02f, 7.50758797e-02f,
  3.86278071e-02f, 1.65684432e-01f, -4.75345999e-02f, -1.62060559e-03f, -1.61743537e-02f, -2.71149278e-02f, 1.87724195e-02f, 3.28006670e-02f, 6.03958871e-03f, -8.50582346e-02f,
  4.09613252e-02f, -3.72765376e-03f, 8.02953914e-02f, 3.44219580e-02f, 2.54482254e-02f, -6.43419102e-02f, -4.02556658e-02f, 6.64665252e-02f, 7.65049309e-02f, 9.12345648e-02f,
  2.50419211e-02f, 7.31297433e-02f, -4.17547952e-03f, -4.87654135e-02f, 3.27071846e-02f, -5.23127476e-03f, 2.65863016e-02f, -1.36986068e-02f, 1.27730042e-01f, -3.94872054e-02f,
  1.98124260e-01f, -2.50309229e-01f, 6.64912090e-02f, 1.20231308e-01f, 7.37332404e-02f, 1.64921924e-01f, 1.59970939e-01f, 1.45655070e-02f, 5.31431064e-02f, -1.31113008e-01f,
  1.13561399e-01f, -1.12416603e-01f, -1.57061905e-01f, 3.72766182e-02f, 1.10875815e-01f, -1.87138870e-01f, 1.86066166e-01f, 7.56556839e-02f, -1.03539929e-01f, 1.06725566e-01f,
  1.25145301e-01f, 2.60899588e-02f, 1.40418589e-01f, -3.50215770e-02f, 1.01206727e-01f, 9.16819423e-02f, 1.46539941e-01f, -5.13097011e-02f, 2.09687948e-01f, -8.44003186e-02f,
  9.41853151e-02f, 3.98394875e-02f, 6.51743859e-02f, -3.52049433e-02f, 1.34564489e-01f, 4.44592424e-02f, 4.67051677e-02f, -4.97302935e-02f, 8.82827267e-02f, 7.35468641e-02f,
  -7.78862312e-02f, 9.45769176e-02f, 2.17917245e-02f, 2.03616824e-02f, -4.47986312e-02f, 3.43228057e-02f, 1.48056857e-02f, 7.52488002e-02f, -1.81044191e-02f, -5.42820850e-03f,
  -4.14109342e-02f, 1.20883018e-01f, 8.91410410e-02f, 7.59580284e-02f, -1.72976777e-02f, 9.96118486e-02f, 8.43605623e-02f, 5.54811656e-02f, 2.41609681e-02f, 1.13130324e-01f,
  -1.07149277e-02f, 1.30859837e-02f, -3.23836654e-02f, -5.40483668e-02f, -1.50362505e-02f, 1.95849817e-02f, -1.92601252e-02f, -1.79409198e-02f, -1.97912063e-02f, -1.37641421e-02f,
  6.53407127e-02f, -1.90609451e-02f, -1.29409377e-02f, 8.40542242e-02f, -3.15225730e-03f, -6.06449023e-02f, -6.96209297e-02f, -7.25135729e-02f, 3.73807922e-02f, 3.03323679e-02f,
  -1.00930808e-02f, -1.62944989e-03f, 9.54151619e-03f, -8.72599427e-03f, 2.54107006e-02f, 2.98469625e-02f, 1.00930147e-02f, 4.50708494e-02f, -2.91678924e-02f, -4.16102782e-02f,
  8.67029130e-02f, -9.95750725e-03f, -5.35653997e-03f, 1.08682578e-02f, -4.68751751e-02f, -7.01117702e-03f, -2.25259326e-02f, 1.22168986e-02f, -4.85476218e-02f, -6.73562214e-02f,
  -3.52392979e-02f, 7.66316652e-02f, 3.80641669e-02f, -3.47844400e-02f, -9.97402985e-03f, 4.19084541e-02f, -2.19029840e-02f, -1.81996860e-02f, 4.62628268e-02f, 7.43386848e-03f,
  3.70184891e-02f, -3.66301797e-02f, -6.54458255e-03f, 3.32166925e-02f, 8.84313062e-02f, 2.24637743e-02f, -4.10488583e-02f, -4.10740189e-02f, -7.27020949e-02f, 9.43171885e-03f,
  1.74363032e-01f, -6.97818100e-02f, 8.65286216e-02f, -9.88821387e-02f, -6.79410174e-02f, 4.58404534e-02f, -3.28853093e-02f, -1.02374405e-01f, -6.87370896e-02f, -1.37958884e-01f,
  -1.22744171e-02f, 1.36727929e-01f, -8.44729505e-03f, -9.77920666e-02f, 3.29938561e-01f, 5.19298725e-02f, 2.70224400e-02f, 6.87718242e-02f, 3.06742620e-02f, 4.48413193e-02f,
  1.34109646e-01f, -1.82487831e-01f, -3.53595763e-02f, -6.28854111e-02f, -2.49602288e-01f, -1.14253834e-01f, -4.02388796e-02f, 5.70004582e-02f, -8.61947164e-02f, 5.64102978e-02f,
  4.44277711e-02f, -1.24426186e-01f, -1.84610054e-01f, -3.86161916e-02f, 2.11341847e-02f, -5.71114570e-02f, -5.26337931e-03f, 1.74859315e-02f, 6.20977357e-02f, 1.08098790e-01f,
  4.98069860e-02f, 2.83723865e-02f, 4.69501615e-02f, 2.02678964e-02f, -2.91773286e-02f, -3.12867798e-02f, -5.51504418e-02f, -7.70834014e-02f, -5.13355657e-02f, 1.01145655e-02f,
  -1.61166582e-02f, -2.66371276e-02f, 1.57119501e-02f, 2.50636246e-02f, -6.07189490e-03f, -4.54193801e-02f, 4.10391111e-03f, 6.60114288e-02f, 3.79893780e-02f, 4.83344682e-03f,
  -4.47854623e-02f, 7.17118904e-02f, -3.56937572e-03f, -5.67702390e-02f, -2.43809316e-02f, -4.09433097e-02f, 9.91856232e-02f, -6.34445436e-03f, -3.72718833e-02f, 3.92837403e-03f,
  3.81664746e-02f, 2.71238815e-02f, 4.07853648e-02f, -5.15629575e-02f, 3.58666503e-03f, -6.69775754e-02f, 1.00243308e-01f, 8.78693187e-04f, 4.06445004e-02f, -4.39083837e-02f,
  7.39400685e-02f, 7.71905705e-02f, -2.78176945e-02f, 9.52235237e-03f, 4.21678983e-02f, 7.57936910e-02f, -2.34870967e-02f, 7.04999715e-02f, 1.16775269e-02f, 8.64504650e-02f,
  1.90032035e-01f, 2.09086388e-01f, -2.85087358e-02f, -2.34825965e-02f, 3.17002349e-02f, -7.40261376e-02f, -5.36870807e-02f, -7.44890720e-02f, 3.47848497e-02f, 3.58584486e-02f,
  -6.96254149e-02f, -6.95135221e-02f, 1.18212819e-01f, -5.65936305e-02f, 8.98710117e-02f, 2.76874788e-02f, 7.73004740e-02f, 9.21535566e-02f, 6.45470172e-02f, 8.87738466e-02f,
  3.50536369e-02f, -1.90067738e-02f, -1.03037721e-02f, -5.84058799e-02f, -5.97064719e-02f, 4.91632596e-02f, 1.14496360e-02f, -1.26892123e-02f, -8.66912305e-02f, -5.78189343e-02f,
  -1.69232890e-01f, 9.04671624e-02f, 2.01537177e-01f, -1.37165114e-01f, -1.75243169e-02f, -4.90002371e-02f, -5.56594059e-02f, 7.59284124e-02f, 2.15449646e-01f, -7.76158422e-02f,
  -7.96931759e-02f, 9.78043824e-02f, -7.43968636e-02f, -2.29495332e-01f, -6.59400783e-03f, 2.88474876e-02f, -1.05060525e-01f, -1.10392421e-01f, 9.99260694e-02f, -1.37142867e-01f,
  5.03494069e-02f, -2.21712649e-01f, -4.93008643e-03f, 5.34606576e-02f, -1.44182891e-01f, 1.68146387e-01f, -9.90099534e-02f, 1.80843145e-01f, -7.74978986e-03f, 6.62787482e-02f,
  5.80015741e-02f, 6.15456291e-02f, 3.52341775e-03f, 1.29955709e-01f, -3.63873728e-02f, -7.50075728e-02f, 5.61315492e-02f, -4.31738868e-02f, 9.30585563e-02f, -2.18255576e-02f,
  9.32372827e-03f, 1.39537565e-02f, 5.38453534e-02f, 6.57841489e-02f, -8.88437852e-02f, 5.76271638e-02f, 2.28766855e-02f, -1.04164369e-01f, 8.82457048e-02f, -6.10251836e-02f,
  7.76912794e-02f, -3.70067134e-02f, -7.47298524e-02f, -5.61018940e-03f, 2.07155012e-02f, -1.79394253e-03f, -2.29973830e-02f, -2.76618125e-03f, 7.01184943e-02f, 7.86075965e-02f,
  -7.15588480e-02f, 8.14142637e-03f, 8.63699242e-02f, -2.68501732e-02f, 1.81631166e-02f, -5.64549007e-02f, -2.16237865e-02f, -1.16661948e-03f, 5.45656011e-02f, -9.46540087e-02f,
  -6.66364981e-03f, -2.35533975e-02f, -7.17360154e-02f, -9.37513709e-02f, -1.08037487e-01f, 8.22317321e-03f, 5.44377752e-02f, -4.29938249e-02f, 3.49106267e-02f, -1.22275972e-03f,
  -6.64223284e-02f, -4.67239507e-02f, 6.47673756e-02f, -6.74143359e-02f, 2.98000500e-02f, -5.67568950e-02f, -4.17830013e-02f, -5.67012168e-02f, -7.04793260e-02f, -3.17063294e-02f,
  -1.81007292e-02f, -1.69071928e-02f, 1.11291729e-01f, -6.49034679e-02f, 6.15265965e-02f, -2.54231226e-02f, 2.19880920e-02f, 2.32992577e-03f, 8.95734131e-02f, -4.60906811e-02f,
  -6.29331693e-02f, 5.47134364e-03f, -1.19848168e-02f, -9.43227764e-03f, 4.06561866e-02f, 6.88370094e-02f, 5.77596538e-02f, 2.80239228e-02f, -1.42580895e-02f, -1.06956149e-02f,
  -1.48213133e-02f, 1.48984548e-02f, 2.52088159e-02f, -8.01202431e-02f, 7.79568963e-03f, 2.51436955e-03f, 5.80583364e-02f, 1.17019534e-01f, 2.04690937e-02f, 3.21206935e-02f,
  -3.46369855e-02f, -1.16482303e-01f, -7.62879550e-02f, 4.56309412e-03f, -2.02132463e-01f, -1.43352181e-01f, 9.11989361e-02f, -1.39761075e-01f, -1.40103363e-02f, 2.50820387e-02f,
  7.90581480e-02f, 6.02186583e-02f, 5.74282296e-02f, -4.03787382e-02f, 2.07511008e-01f, 2.23569140e-01f, -4.42316048e-02f, -8.84017162e-03f, -1.69459611e-01f, -6.80364370e-02f,
  -8.50298554e-02f, -3.66887674e-02f, 1.30540922e-01f, -1.26257405e-01f, -4.69896011e-02f, -1.37692899e-01f, 1.99761078e-01f, -9.74737853e-02f, 4.18515094e-02f, 1.05911843e-03f,
  -1.61889017e-01f, -1.20084751e-02f, -8.32578316e-02f, 3.07088606e-02f, 3.84355010e-03f, -5.64392358e-02f, 4.48404588e-02f, 1.00536443e-01f, 2.84559297e-04f, -3.65521312e-02f,
  -1.41304303e-02f, -4.86357845e-02f, 2.05856543e-02f, 1.04057968e-01f, -7.45484903e-02f, -8.91150758e-02f, -4.54351231e-02f, 3.82897407e-02f, -1.03587903e-01f, 3.48375663e-02f,
  -3.06711551e-02f, -1.55530032e-03f, -9.15833712e-02f, 4.00696732e-02f, 4.88144755e-02f, -2.21583564e-02f, 3.85370217e-02f, 3.44634950e-02f, -5.12377769e-02f, -1.87300846e-01f,
  5.10862507e-02f, -7.68277124e-02f, -8.56976025e-03f, 2.05869135e-02f, 8.32579806e-02f, 2.73984298e-02f, -1.53103778e-02f, 5.34503534e-02f, -5.59081063e-02f, 2.08050553e-02f,
  5.95349744e-02f, 3.26791359e-03f, -2.59983130e-02f, -2.04313584e-02f, 2.60135680e-02f, 1.53674809e-02f, 1.82952862e-02f, 3.93313952e-02f, 7.82433525e-02f, 1.02842472e-01f,
  -3.58509012e-02f, -5.43297231e-02f, 9.84791145e-02f, 5.84579296e-02f, -5.21980524e-02f, -2.37817466e-02f, 3.33187468e-02f, -4.14210148e-02f, 6.37082830e-02f, 9.18408185e-02f,
  -2.01934114e-01f, -1.68202728e-01f, -1.01616614e-01f, -9.67455730e-02f, -2.85022426e-02f, 7.15978444e-02f, -4.98582460e-02f, -3.75458114e-02f, 3.46695259e-03f, 8.27408209e-03f,
  -4.18536849e-02f, 7.37366313e-03f, -2.86623053e-02f, 3.17255333e-02f, 1.15259282e-01f, 4.38826382e-02f, 6.08897433e-02f, 4.16515954e-02f, -3.58453132e-02f, -5.98340370e-02f,
  -1.36837075e-02f, 4.26080980e-04f, 2.42725033e-02f, -3.47932950e-02f, 4.97746579e-02f, -5.39280623e-02f, 5.85708953e-02f, 4.30850014e-02f, 2.19429582e-02f, 3.25890854e-02f,
  -4.05442983e-01f, -5.55780195e-02f, -7.95902535e-02f, -1.69786975e-01f, -4.73618172e-02f, -1.87477127e-01f, -2.13528767e-01f, 3.69601175e-02f, 1.08103808e-02f, 6.15238696e-02f,
  1.41398339e-02f, -1.12329468e-01f, 1.16061099e-01f, -9.43323597e-02f, -8.89646560e-02f, 1.09178938e-01f, -5.07972650e-02f, -8.55431929e-02f, 1.44853324e-01f, -5.89539334e-02f,
  5.95233291e-02f, 6.53720424e-02f, -8.10440630e-02f, 2.04865634e-01f, -1.86185479e-01f, -2.89956294e-02f, 1.72840133e-01f, 5.20222224e-02f, -9.12044570e-02f, -2.81347334e-03f,
  2.88147796e-02f, 1.01787902e-01f, -7.56831393e-02f, 2.19234116e-02f, -1.08811967e-02f, -2.59566531e-02f, -5.86937517e-02f, -2.48046331e-02f, 2.41544116e-02f, -1.76409371e-02f,
  -2.93848310e-02f, 7.47849190e-05f, -4.00762148e-02f, 2.92130075e-02f, -7.56859928e-02f, -3.81316096e-02f, 1.20901931e-02f, -3.35983485e-02f, -1.93332899e-02f, -4.49327305e-02f,
  -1.01053260e-01f, -2.24161204e-02f, -2.08609998e-02f, 8.98595676e-02f, -8.63365978e-02f, 6.09146990e-02f, 5.10566458e-02f, -9.64532420e-02f, 7.75711564e-03f, -4.83320430e-02f,
  3.84495594e-03f, -2.30273954e-03f, -1.04418643e-01f, 9.57693756e-02f, -5.09761944e-02f, 1.19659960e-01f, -6.11098297e-02f, 4.74612713e-02f, 1.53464600e-02f, -6.27306998e-02f,
  1.09410158e-03f, -7.44616017e-02f, 5.05202822e-02f, -4.59594429e-02f, -7.65557513e-02f, -2.26082280e-02f, -5.86291635e-03f, 6.33311225e-03f, -5.56393452e-02f, 1.11420592e-03f,
  4.90927994e-02f, -2.14494355e-02f, 1.20489765e-02f, -2.29343511e-02f, 9.31549296e-02f, 5.37858084e-02f, 4.45724316e-02f, -2.39686351e-02f, -5.39522991e-03f, -3.00423149e-03f,
  -2.12768055e-02f, -2.10452313e-03f, 9.67761315e-03f, -1.06505761e-02f, 6.11570179e-02f, -2.50756517e-02f, 3.43831368e-02f, -5.67330606e-03f, -1.22253280e-02f, -3.62264318e-03f,
  -6.10492639e-02f, -2.13868227e-02f, -1.69734210e-02f, -2.84658521e-02f, 1.32753719e-02f, 1.11602964e-02f, -2.47925948e-02f, -2.35117469e-02f, 7.74057489e-03f, 3.07675768e-02f,
  -7.27362186e-02f, -7.31799752e-03f, 7.29251280e-02f, 2.61539011e-03f, 5.73181314e-04f, -9.47200432e-02f, -5.81268370e-02f, 4.91781272e-02f, -5.95939830e-02f, 6.84219152e-02f,
  -2.44963139e-01f, 1.87577903e-01f, 2.09978446e-01f, 4.65607271e-02f, 3.20596285e-02f, -1.07072657e-02f, -4.47611436e-02f, 1.86623588e-01f, -2.05370598e-02f, 2.48319637e-02f,
  -3.03890333e-02f, -8.63934681e-02f, -9.65256467e-02f, 1.40400648e-01f, -1.88215882e-01f, -1.25464395e-01f, 4.83354740e-03f, -2.16190368e-02f, -2.57275682e-02f, 2.45411713e-02f,
  9.97199342e-02f, -3.27787399e-02f, 7.97675475e-02f, 6.59283921e-02f, 1.27917407e-02f, 3.83706242e-02f, -2.53370218e-02f, -3.55930887e-02f, 2.02688009e-01f, -5.13070934e-02f,
  -3.80430333e-02f, -1.32059364e-03f, 7.06743076e-02f, 1.23129990e-02f, 3.95566858e-02f, 5.11244237e-02f, -6.84441626e-02f, -2.24895384e-02f, -4.12355214e-02f, 7.16878772e-02f,
  -7.81896710e-02f, 7.23500177e-02f, -3.58644053e-02f, -1.14701569e-01f, 6.24101497e-02f, 5.83273284e-02f, 1.52346268e-01f, 2.43206266e-02f, 7.94242620e-02f, 8.45969692e-02f,
  8.18174556e-02f, 7.61319473e-02f, 1.42573833e-01f, 5.54916151e-02f, 8.69894102e-02f, -3.65494639e-02f, 1.20474845e-02f, -3.03011648e-02f, 5.68133891e-02f, 5.47922850e-02f,
  2.86970120e-02f, -3.32093947e-02f, -1.42958947e-02f, -5.75377792e-02f, -8.81119147e-02f, 5.69255929e-03f, -4.88181561e-02f, 7.61146545e-02f, -3.82605344e-02f, -4.31170464e-02f,
  -1.69472210e-03f, 1.38143953e-02f, 3.97531204e-02f, 4.98979818e-03f, 4.93162796e-02f, -2.64417119e-02f, 1.99813619e-02f, 4.16045170e-03f, 8.52440223e-02f, 3.77066135e-02f,
  4.99493117e-03f, 1.46674030e-02f, 1.17649185e-02f, -1.76554546e-02f, -5.58832176e-02f, -1.84319764e-02f, 1.69593748e-02f, 1.43619301e-02f, -2.27687997e-04f, -7.74758384e-02f,
  -1.35476694e-01f, -1.19362362e-01f, -3.94591177e-03f, 1.82992071e-02f, 6.69612456e-03f, 8.31944495e-02f, -6.04184717e-02f, -1.63011793e-02f, 1.07799685e-02f, -7.35698938e-02f,
  1.92243475e-02f, -4.09997255e-02f, 2.40828609e-03f, 4.39083111e-03f, -2.65608579e-02f, 6.67264760e-02f, -7.38947093e-02f, -8.14222172e-03f, 3.21718194e-02f, -1.54185327e-04f,
  -1.13617359e-02f, -5.66954911e-03f, -2.62172073e-02f, 3.49992737e-02f, 3.63763310e-02f, 6.34193048e-02f, 7.56626278e-02f, -5.20921648e-02f, -3.99005748e-02f, -1.38071282e-02f,
  4.94763911e-01f, 1.68559536e-01f, 6.79580420e-02f, 1.74778625e-01f, -1.37923315e-01f, -1.76241025e-01f, 1.79513365e-01f, 6.09931676e-03f, 2.70232052e-01f, -8.19577277e-02f,
  1.08505022e-02f, 1.27057716e-01f, 5.35201579e-02f, -6.75435364e-02f, 4.78583761e-02f, 3.16914357e-02f, 5.34716621e-02f, 9.77621973e-02f, 1.03495777e-01f, 2.04494715e-01f,
  3.47742923e-02f, -7.84718394e-02f, 1.43611535e-01f, -4.20046486e-02f, 2.43507192e-01f, 1.52405202e-01f, -1.35347471e-01f, -2.80848518e-02f, -2.01628327e-01f, -1.16799302e-01f,
  5.15567325e-03f, 1.67337488e-02f, -5.69602288e-02f, 1.85004044e-02f, 3.44983637e-02f, -4.82071675e-02f, -3.13805118e-02f, -5.56017794e-02f, 1.87514313e-02f, 2.72612628e-02f,
  -6.66895211e-02f, 2.79751588e-02f, -5.07057980e-02f, -3.23578194e-02f, 8.83236676e-02f, 3.95401381e-03f, -4.64617508e-03f, -5.95425479e-02f, -8.07581991e-02f, 1.53012052e-01f,
  1.53887808e-01f, 5.39167859e-02f, 5.53831458e-02f, -8.33756253e-02f, 9.81378108e-02f, 7.48343170e-02f, -5.28035760e-02f, -9.54061821e-02f, -1.39679134e-01f, -1.95659716e-02f,
  -1.56326729e-04f, -5.11720777e-02f, -2.76525645e-03f, -6.20120838e-02f, 1.71492435e-02f, 9.76640359e-03f, -1.74114984e-02f, -5.04865497e-02f, 9.99038480e-03f, -9.96828359e-03f,
  7.36227632e-02f, 2.47683562e-02f, -3.63065787e-02f, 1.13431737e-02f, -7.37357826e-04f, 9.33812335e-02f, -1.38681950e-02f, 1.16188517e-02f, -5.42524010e-02f, -3.06200925e-02f,
  3.13126929e-02f, -4.24343944e-02f, 5.12425788e-02f, 2.58974992e-02f, -5.81132025e-02f, -1.79314986e-02f, -2.30372511e-02f, 1.70519110e-02f, -8.91878549e-03f, 1.68335717e-02f,
  -1.25558794e-01f, 2.13583373e-02f, 1.01731174e-01f, -2.73639224e-02f, -6.23825379e-02f, 1.47191165e-02f, -5.56509271e-02f, 3.04045528e-02f, 4.54425486e-03f, -9.12732910e-03f,
  -8.32802244e-03f, -7.43081868e-02f, -3.76172960e-02f, 6.92446483e-03f, -1.68408081e-02f, -5.29713370e-02f, 4.19954918e-02f, -2.95051150e-02f, -1.48241511e-02f, -8.60436708e-02f,
  2.64489241e-02f, -3.49914678e-03f, 5.95577992e-02f, -2.77678221e-02f, -3.67288776e-02f, -7.38038346e-02f, 5.43453917e-02f, 2.71850042e-02f, 2.17045117e-02f, -4.75209281e-02f,
  3.90840888e-01f, -8.61122459e-02f, 1.49284108e-02f, 2.37524286e-01f, 1.30413011e-01f, -1.85395524e-01f, -1.13463216e-01f, 1.58855602e-01f, 3.02739218e-02f, -8.13878849e-02f,
  -3.64705957e-02f, 6.88073784e-02f, -1.36629045e-01f, 4.58557084e-02f, -4.41825204e-03f, -2.26039320e-01f, 1.06133424e-01f, -5.42621985e-02f, -5.70815913e-02f, 1.32155821e-01f,
  5.11966720e-02f, -6.47925362e-02f, 2.74456572e-02f, 4.59612906e-02f, 2.19517022e-01f, 1.90953448e-01f, -4.67908569e-02f, 5.13649359e-02f, 1.07847802e-01f, -7.75033757e-02f,
  -8.38155374e-02f, 1.24042548e-01f, 1.69712733e-02f, -8.13556463e-02f, -2.94838268e-02f, 1.86016802e-02f, -2.39831824e-02f, -2.54326835e-02f, -2.13764664e-02f, -3.21350060e-02f,
  1.57525763e-02f, -2.52699554e-02f, 3.47113013e-02f, 4.45791259e-02f, 5.20942360e-02f, 5.08659370e-02f, 4.96766567e-02f, 9.46245119e-02f, -3.14272195e-02f, 1.11045532e-01f,
  4.84547503e-02f, 3.50602083e-02f, -6.43045222e-03f, -2.55870484e-02f, 5.26196435e-02f, 2.48123929e-02f, -2.29201391e-02f, 6.12456948e-02f, -2.87654661e-02f, 1.14514343e-01f,
  -8.13321918e-02f, 4.69027534e-02f, -7.69150704e-02f, -2.70520821e-02f, -3.96488719e-02f, 3.82684022e-02f, -4.61970530e-02f, -9.48674008e-02f, -4.45924401e-02f, -2.64284834e-02f,
  -3.10485195e-02f, -4.55130190e-02f, -6.21976107e-02f, 5.27257239e-03f, -3.44215184e-02f, 2.36876030e-02f, -9.00415052e-03f, 1.73161607e-02f, 1.02125378e-02f, 2.91619394e-02f,
  -4.72403988e-02f, 5.47777973e-02f, -8.18966478e-02f, -2.79146302e-02f, -5.41105084e-02f, 4.00437973e-03f, -1.53250918e-02f, -9.68523510e-03f, -7.64473574e-04f, 1.97515655e-02f,
  -3.00167985e-02f, -5.15494402e-03f, -2.08767988e-02f, -4.29747477e-02f, -8.61520618e-02f, -3.62589583e-02f, -4.94572781e-02f, 2.59078871e-02f, 6.41134828e-02f, 2.40953751e-02f,
  5.30729331e-02f, 2.97968742e-02f, -4.94118854e-02f, 1.25411106e-02f, -3.73988203e-03f, 3.49876322e-02f, 2.82787601e-03f, 5.66513315e-02f, -6.40192330e-02f, -2.06788480e-02f,
  -1.58235570e-03f, -6.40280768e-02f, -8.96516591e-02f, -9.38730538e-02f, -4.19814698e-02f, 5.15905023e-02f, -1.22203650e-02f, 3.18338163e-02f, -4.40065050e-03f, -1.12345800e-01f,
  1.04853705e-01f, 1.02028571e-01f, 3.17586437e-02f, -1.27918348e-01f, -2.03648776e-01f, 4.95594479e-02f, 1.47412136e-01f, -1.14881426e-01f, -3.06857973e-01f, 2.14765385e-01f,
  9.35527403e-03f, 3.03395301e-01f, 2.12029189e-01f, 8.46951753e-02f, 7.53819197e-02f, 1.07388437e-01f, -3.89369093e-02f, 1.24266610e-01f, -2.59492308e-01f, -7.09142387e-02f,
  -1.27511799e-01f, 7.43056685e-02f, 1.51044711e-01f, -1.56150788e-01f, -2.87208669e-02f, -1.13344593e-02f, -3.18339132e-02f, 9.67170764e-03f, 1.05816826e-01f, 2.97676995e-02f,
  3.85480896e-02f, -7.48830661e-02f, 5.71205132e-02f, -1.35168592e-02f, 5.45762666e-02f, -1.69974323e-02f, 9.56017449e-02f, 3.07486355e-02f, -5.69790341e-02f, -5.00193201e-02f,
  1.43797472e-01f, -1.85711402e-02f, -2.92676110e-02f, 4.00881544e-02f, -7.24303424e-02f, 8.06712639e-03f, -5.62396757e-02f, -6.06280193e-02f, 1.19078876e-02f, 4.91831526e-02f,
  6.75071627e-02f, -5.41823097e-02f, -5.60242534e-02f, 3.53675485e-02f, 1.63793527e-02f, -7.02433810e-02f, -3.09463795e-02f, 1.29730806e-01f, 7.33314380e-02f, -1.38079107e-01f,
  6.82099983e-02f, -1.16431199e-01f, 6.20676531e-03f, -2.59207021e-02f, 3.38481702e-02f, -7.78631121e-02f, 5.45112118e-02f, 7.29203448e-02f, -5.78732751e-02f, 7.55039379e-02f,
  -4.23084050e-02f, -6.72263876e-02f, -4.01878096e-02f, -5.50287627e-02f, 3.46010067e-02f, 4.26823832e-02f, 1.26766684e-02f, 3.01933344e-02f, -2.59060934e-02f, -6.49065897e-02f,
  3.07927821e-02f, -8.06616768e-02f, 4.37374972e-02f, -5.00586554e-02f, -4.34456803e-02f, -3.23505956e-03f, -7.04035386e-02f, 4.03914303e-02f, -1.06128328e-01f, 1.21972106e-01f,
  8.98243561e-02f, 7.91704208e-02f, -2.23735925e-02f, -5.95699288e-02f, 4.10994664e-02f, 8.08363110e-02f, -4.61859927e-02f, -1.64608825e-02f, 3.21032479e-02f, -3.73502783e-02f,
  1.25149917e-02f, -1.55126154e-02f, 5.44397198e-02f, 1.39879435e-02f, -3.22369784e-02f, 4.81598563e-02f, 2.29699537e-02f, -4.28997241e-02f, -1.49407899e-02f, -1.49901723e-03f,
  -7.07000867e-03f, -2.59513035e-02f, 9.54767049e-04f, 1.35110691e-02f, 4.10736799e-02f, 6.61200806e-02f, 5.86519539e-02f, 1.07206022e-02f, 2.33384175e-03f, 4.48824372e-03f,
  1.30434006e-01f, -1.02164686e-01f, 2.18171433e-01f, -5.35720289e-02f, 8.03479478e-02f, 1.60506051e-02f, 9.54536572e-02f, -5.44527955e-02f, 2.57786989e-01f, -1.06866188e-01f,
  -3.13368700e-02f, 1.82198092e-01f, 1.63509533e-01f, -1.70784995e-01f, 8.26996937e-03f, 1.00868098e-01f, -1.70163125e-01f, -1.12508982e-01f, 2.64556293e-04f, -8.82732868e-02f,
  -7.16480389e-02f, -9.59434956e-02f, -1.22163199e-01f, -2.06589848e-01f, 7.31649846e-02f, -9.49582309e-02f, -2.18335435e-01f, -5.68248704e-02f, -2.01673791e-01f, 3.85937840e-02f,
  2.55233720e-02f, 1.02928154e-01f, -5.09520806e-02f, 1.03963993e-01f, 1.82931386e-02f, -6.03410183e-03f, -1.53246745e-02f, 6.17811307e-02f, 3.35637704e-02f, 5.02062552e-02f,
  4.96721566e-02f, -6.07121475e-02f, -2.35373192e-02f, 5.62103800e-02f, 1.53761422e-02f, 6.58274144e-02f, 1.01845980e-01f, 4.82346676e-02f, 7.87109584e-02f, 5.77998795e-02f,
  6.71918392e-02f, 9.91792604e-02f, 1.23910177e-02f, 5.29636927e-02f, 5.53701781e-02f, 5.67767210e-02f, -2.89512351e-02f, 5.44231664e-03f, 2.21319273e-02f, -6.07104301e-02f,
  -2.35110149e-02f, 1.32015040e-02f, -3.07920370e-02f, 3.33863683e-02f, -8.71763472e-03f, -3.64771485e-02f, 1.94856208e-02f, -2.78933272e-02f, 4.76173460e-02f, 1.68050472e-02f,
  1.50448829e-03f, 1.11500723e-02f, 2.16049105e-02f, -6.36901036e-02f, -5.23550883e-02f, 4.60694805e-02f, 3.55160497e-02f, -5.58013804e-02f, 3.63948569e-02f, 2.36584106e-03f,
  -5.11698984e-03f, 8.66687577e-03f, -3.94415371e-02f, -1.96626429e-02f, -6.12757914e-03f, 2.17374135e-03f, -1.10667134e-02f, 3.74265760e-02f, -1.01013156e-02f, -1.63089558e-02f,
  -3.30070667e-02f, -1.50244519e-01f, -3.69642884e-03f, 2.81736944e-02f, -6.48988858e-02f, 4.90614101e-02f, 3.68232164e-03f, -4.62814160e-02f, -5.57027720e-02f, -3.47508453e-02f,
  -5.71121871e-02f, 7.25277746e-03f, 7.82914609e-02f, 1.98317729e-02f, -1.00409627e-01f, -6.18916564e-02f, -2.88688000e-02f, 3.71357389e-02f, -1.63119752e-02f, -1.44559845e-01f,
  8.93361215e-03f, 6.24090098e-05f, 4.86312322e-02f, 6.29698709e-02f, 8.50290246e-03f, 5.80202192e-02f, -5.10496609e-02f, -7.41052702e-02f, -5.06618358e-02f, -1.14200814e-02f,
  3.04847091e-01f, 1.98724195e-02f, 1.83154300e-01f, 2.29561821e-01f, -1.14044324e-01f, -3.21790054e-02f, 2.86157914e-02f, 3.71782435e-03f, 2.36941621e-01f, 1.84357148e-02f,
  -1.86248079e-01f, 7.95943290e-02f, -3.69162136e-03f, -2.20582411e-01f, -1.43956140e-01f, -1.01246439e-01f, -1.08440384e-01f, 1.89066585e-02f, 1.22003173e-02f, 6.26350120e-02f,
  -2.45154854e-02f, -1.86698198e-01f, -1.37470499e-01f, -1.69538215e-01f, 4.98643816e-02f, -1.21385390e-02f, -1.49124756e-01f, -1.35784104e-01f, -1.83416888e-01f, -1.67244613e-01f,
  -1.22811198e-01f, 1.81910887e-01f, -4.31420617e-02f, 2.70589925e-02f, 3.95512246e-02f, 3.88678648e-02f, -7.84404501e-02f, 6.32647984e-03f, 4.23693061e-02f, -1.98714174e-02f,
  7.93879628e-02f, 4.50809784e-02f, -7.91304111e-02f, 4.01314981e-02f, -5.22555609e-04f, 1.50803039e-02f, 8.47916119e-03f, 1.89029109e-02f, 3.05132736e-02f, 1.05209365e-01f,
  -2.01092884e-02f, 8.50012228e-02f, -8.13075167e-04f, -2.85469852e-02f, 1.04477452e-02f, 5.56048341e-02f, 8.63170475e-02f, -6.56863526e-02f, 1.06060043e-01f, 2.42410041e-02f,
  5.79176322e-02f, -8.19240957e-02f, 5.30340057e-03f, -5.41524403e-02f, 6.86660856e-02f, 3.67905796e-02f, 9.70537309e-03f, -6.59563858e-03f, 1.07068121e-01f, 4.63709459e-02f,
  2.22127084e-02f, -5.26324213e-02f, -8.99292156e-02f, 5.74533381e-02f, 2.07446516e-02f, -4.70545935e-03f, -4.29625623e-03f, 1.24746617e-02f, -7.75248930e-02f, -9.88328382e-02f,
  -9.26661713e-04f, -5.22239506e-02f, 3.54968943e-02f, 7.91715458e-02f, 5.24023846e-02f, -1.14576956e-02f, 2.09620614e-02f, 8.26232135e-02f, -1.24816212e-03f, -2.00990923e-02f,
  -4.43408359e-03f, -3.98196280e-02f, -1.02139562e-01f, -1.99854914e-02f, 5.17359339e-02f, -5.65993674e-02f, 8.02203268e-02f, 3.72493145e-04f, 4.47344221e-02f, -1.38082588e-02f,
  1.44811692e-02f, 8.75710919e-02f, 1.38079226e-02f, -4.22035670e-03f, -8.45029950e-02f, -2.24418449e-03f, -4.53675874e-02f, 4.60196547e-02f, -8.14853832e-02f, -1.03968695e-01f,
  8.51473808e-02f, 3.76271233e-02f, 2.75501367e-02f, 3.38166691e-02f, 2.79992651e-02f, -3.62739861e-02f, 3.25174630e-02f, -1.38599379e-02f, -6.00182265e-02f, -4.06850874e-02f,
  3.21246147e-01f, 1.77037656e-01f, -4.18513007e-02f, 1.08327284e-01f, 1.34227211e-02f, 1.18590824e-01f, 2.13898197e-02f, -9.34245884e-02f, 7.60032535e-02f, 6.00860342e-02f,
  6.85277954e-02f, 1.75101906e-01f, -3.89672667e-02f, 2.38912329e-01f, 3.18302780e-01f, -8.44144076e-03f, 2.91303575e-01f, 1.78834006e-01f, 6.31365925e-03f, 1.23196289e-01f,
  2.21405681e-02f, 1.37275130e-01f, -7.65023530e-02f, -1.95590064e-01f, 3.56573239e-02f, -1.88161418e-01f, -1.38907760e-01f, -1.75157934e-01f, 1.06876440e-01f, -1.08517241e-02f,
  4.35798913e-02f, 8.78714174e-02f, 1.52550573e-02f, -9.16775167e-02f, 7.80846477e-02f, -4.00255509e-02f, 8.64912346e-02f, 1.68332811e-02f, -1.10035157e-02f, -4.23463248e-02f,
  -5.59983402e-02f, 3.01978481e-03f, 4.36365791e-03f, -3.69382016e-02f, -7.32975975e-02f, 1.22559385e-03f, 1.57693867e-02f, 3.19063254e-02f, -3.19381291e-03f, -3.86284664e-02f,
  -1.80304945e-02f, 1.98215619e-02f, -5.33922762e-02f, 6.50981348e-03f, -1.06449954e-01f, 2.44220831e-02f, -8.46091881e-02f, -6.54263124e-02f, 8.63849297e-02f, -6.90617785e-02f,
  -2.19655577e-02f, -4.37735841e-02f, -8.68117660e-02f, -3.62843834e-02f, -1.02332458e-02f, -5.34240939e-02f, 4.03834274e-03f, 6.26401918e-04f, -2.85510421e-02f, -1.12421867e-02f,
  4.33988422e-02f, 2.82079633e-02f, 4.06838655e-02f, -7.03517646e-02f, 5.29495347e-03f, -2.00551581e-02f, 2.53823306e-02f, 4.65559624e-02f, -5.15352450e-02f, -4.98151232e-04f,
  5.92862442e-02f, -7.63178524e-03f, 3.27044935e-03f, -3.13968360e-02f, 1.18659265e-01f, -4.14398350e-02f, -5.80980554e-02f, -4.24546152e-02f, 1.65184792e-02f, -9.60221607e-03f,
  1.25625819e-01f, 4.76443507e-02f, 3.58335115e-02f, 1.53589752e-02f, 4.25073653e-02f, 1.08554229e-01f, 4.48286496e-02f, -6.93932325e-02f, 4.90369573e-02f, -7.97953159e-02f,
  2.34354427e-03f, -8.00583586e-02f, 3.56818996e-02f, -3.99138266e-03f, 5.03773466e-02f, 3.71768959e-02f, 6.89742565e-02f, 3.31254816e-03f, 6.00471273e-02f, 6.97382763e-02f,
  -3.64553779e-02f, -1.60455257e-02f, 4.50231275e-03f, -3.25790308e-02f, 3.99531377e-03f, 7.09271133e-02f, 6.65387362e-02f, 3.82558741e-02f, -7.76060745e-02f, 2.90743522e-02f,
  1.23647384e-01f, -2.43142679e-01f, 6.26307279e-02f, 1.77212477e-01f, -1.77441776e-01f, -2.14396343e-01f, 9.36320499e-02f, -1.20718680e-01f, -6.71890825e-02f, -4.86121662e-02f,
  -2.70375516e-02f, -5.24557903e-02f, 1.20843835e-01f, 1.08205855e-01f, 2.58722067e-01f, -5.40495676e-05f, 1.47067398e-01f, -7.32706860e-03f, 2.51383614e-02f, -7.35491738e-02f,
  6.89894855e-02f, -3.60864438e-02f, 2.17139378e-01f, -1.71239465e-01f, -7.34845102e-02f, -1.07484413e-02f, 1.28208756e-01f, -2.85103768e-02f, -4.04145643e-02f, 3.83735523e-02f,
  -1.75162837e-01f, -5.35139218e-02f, -8.65986664e-03f, -2.45001242e-02f, -5.22617772e-02f, -8.84582773e-02f, -9.75359511e-03f, 4.61579859e-02f, -1.04668867e-02f, 6.49896786e-02f,
  -2.17842925e-02f, 4.04000133e-02f, 7.89738074e-03f, 9.90685774e-04f, -5.57456575e-02f, -1.24967180e-01f, -7.09637851e-02f, 1.17203910e-02f, -5.16713746e-02f, 8.36273748e-03f,
  -5.96698634e-02f, -7.38253146e-02f, 1.56338438e-02f, 9.91262961e-03f, -9.46588162e-03f, 6.40563592e-02f, 2.13523805e-02f, 1.49429776e-02f, -8.63430649e-03f, -7.22679123e-02f,
  -1.60603747e-02f, -3.14917900e-02f, 4.93881777e-02f, -8.46936554e-02f, 2.38737315e-02f, -1.09040439e-02f, -3.72804962e-02f, 7.08601996e-02f, 6.69337958e-02f, -2.55304612e-02f,
  -5.39639331e-02f, 3.92124541e-02f, -6.05032407e-02f, 3.38572264e-02f, 5.84007353e-02f, 4.58912514e-02f, -3.78912948e-02f, 7.15493187e-02f, 1.25443912e-03f, 7.21306191e-04f,
  7.73454411e-03f, -5.76412641e-02f, 2.07154807e-02f, 1.40970731e-02f, -5.06068394e-03f, 7.06535205e-02f, -7.24127144e-02f, 1.70293357e-02f, -3.61173265e-02f, 2.78763268e-02f,
  -1.73973814e-01f, -2.65280460e-03f, 3.92555371e-02f, -7.00549781e-02f, 1.77759994e-02f, -7.06890645e-03f, 3.19864340e-02f, -5.54595701e-02f, -3.73416245e-02f, -2.15427913e-02f,
  -5.69637306e-02f, 6.61252066e-02f, -5.68598397e-02f, 4.32645809e-03f, -1.87518895e-02f, -6.67156279e-02f, 2.72195954e-02f, -3.26627977e-02f, -1.98858697e-02f, 4.56267372e-02f,
  -2.79865554e-03f, 2.89127138e-02f, 9.99397691e-03f, -1.32009834e-01f, -5.04044443e-02f, -7.40811345e-04f, 5.48785878e-03f, -9.77966115e-02f, -1.90158635e-02f, 5.27017266e-02f,
  3.95084769e-01f, -2.28436753e-01f, -1.21853150e-01f, 2.93787539e-01f, 6.36260374e-04f, 1.69303030e-01f, 1.51539683e-01f, -7.76868081e-03f, 2.06778079e-01f, -1.90730318e-01f,
  2.40436494e-01f, -2.13387553e-02f, 1.49361640e-02f, 2.15584770e-01f, 2.63981968e-01f, -6.85052155e-03f, 3.19511503e-01f, 1.16604581e-01f, 4.42664623e-02f, 1.22703798e-01f,
  1.55312076e-01f, 1.79324552e-01f, 1.01069342e-02f, -1.73886865e-01f, -5.46899028e-02f, -1.72273383e-01f, 4.89957333e-02f, -1.82462141e-01f, 7.02472776e-02f, -8.84761959e-02f,
  1.32114301e-02f, 9.54381227e-02f, -8.70866403e-02f, -3.66321169e-02f, 3.34347673e-02f, -8.94409642e-02f, 4.37346287e-02f, -5.34443073e-02f, 4.68105376e-02f, 1.23483036e-03f,
  1.63716264e-02f, 9.62181091e-02f, 2.26206239e-02f, -3.10661979e-02f, -2.69510671e-02f, -1.11638196e-02f, 3.00035272e-02f, 1.67331360e-02f, 3.40956412e-02f, 6.75330013e-02f,
  1.37537355e-02f, 2.07396075e-02f, 7.98055306e-02f, -2.76902993e-03f, -1.95967350e-02f, 5.34481741e-02f, -4.08262275e-02f, -6.37389943e-02f, 3.92187051e-02f, 3.75931151e-02f,
  1.32558169e-02f, -2.97504254e-02f, -5.12881987e-02f, 4.92419712e-02f, 2.97107380e-02f, 3.08750439e-02f, -6.22995310e-02f, -3.62104885e-02f, -4.54275571e-02f, 2.64802575e-02f,
  1.25709459e-01f, -2.33409218e-02f, 1.40463365e-02f, -7.54632521e-03f, -4.19495739e-02f, -9.43931285e-03f, -2.49245185e-02f, -7.32110441e-02f, 7.74775594e-02f, -5.76481745e-02f,
  2.69333255e-02f, -2.36766730e-02f, 1.38130812e-02f, -3.61994691e-02f, 8.37933943e-02f, -9.81892645e-02f, 4.96123247e-02f, -6.82444721e-02f, 2.78984811e-02f, -3.41154449e-02f,
  1.49887413e-01f, -7.49753565e-02f, -5.81257278e-03f, -1.12802088e-02f, -7.17685223e-02f, 3.40075754e-02f, -1.92077626e-02f, -2.84425616e-02f, 7.81466998e-03f, -2.58358344e-02f,
  1.90897509e-02f, -7.05375150e-02f, -6.59147948e-02f, 1.15129091e-02f, 1.19842313e-01f, -1.16974488e-02f, 3.02478988e-02f, -1.57754607e-02f, 6.94444180e-02f, 8.08062777e-03f,
  1.18516816e-03f, 1.48576880e-02f, -1.88330617e-02f, -7.31680840e-02f, 2.73400787e-02f, -1.12055177e-02f, 6.21185033e-03f, 5.29325195e-02f, -2.68535060e-03f, 6.57113688e-03f,
  -1.61351487e-01f, 8.29137117e-02f, 1.81311265e-01f, 1.16755515e-01f, -2.35557124e-01f, -1.88355446e-01f, -2.16435958e-02f, -8.75028074e-02f, 2.66279101e-01f, 6.47404343e-02f,
  -1.21087536e-01f, 1.31132662e-01f, 1.25648618e-01f, 1.67763695e-01f, -3.01856752e-02f, 1.38687238e-01f, 4.77585234e-02f, -1.78390406e-02f, 7.23280087e-02f, -9.45124254e-02f,
  -4.64347824e-02f, -1.13979258e-01f, -2.73115281e-02f, -1.75245017e-01f, -1.06046565e-01f, -1.48621649e-01f, -1.15669623e-01f, -5.22555672e-02f, -2.25322217e-01f, 1.13650553e-01f,
  -1.28785580e-01f, 1.22502178e-01f, 1.60374667e-03f, 1.12683065e-02f, -5.20845130e-02f, -2.67917048e-02f, -5.70044480e-03f, 1.25367299e-01f, -3.91284525e-02f, 8.52944423e-03f,
  -4.19805609e-02f, 2.65628938e-02f, 6.37884811e-02f, 4.57056835e-02f, 1.03155794e-02f, 2.25757733e-02f, -2.09379829e-02f, -3.28085981e-02f, 6.36327118e-02f, -4.53784689e-02f,
  3.05270962e-02f, -9.53369401e-03f, 2.72401124e-02f, -3.49285938e-02f, 3.73680107e-02f, 3.00779901e-02f, 3.24109197e-02f, -3.80873382e-02f, 5.81757054e-02f, -6.54687285e-02f,
  1.94736645e-02f, -6.53458312e-02f, 2.79161390e-02f, -6.04490610e-03f, -2.61636116e-02f, 7.00539798e-02f, 8.97041485e-02f, -2.44205315e-02f, -1.28601259e-02f, -4.36943285e-02f,
  -3.01193353e-02f, -2.87646838e-02f, 7.00448677e-02f, -4.69896533e-02f, -2.81363018e-02f, 6.12785518e-02f, -1.33008091e-02f, -3.14915441e-02f, -7.19313696e-02f, 2.75343694e-02f,
  2.01386973e-01f, -6.03321157e-02f, -8.04836825e-02f, -1.19915558e-03f, 9.99424830e-02f, -5.15524969e-02f, 3.84839550e-02f, 5.06815724e-02f, 1.70806982e-02f, -6.12306595e-02f,
  -2.04583690e-01f, -9.32376534e-02f, -7.90714994e-02f, -1.20470785e-01f, -1.36876022e-02f, 8.30465332e-02f, 2.13200539e-01f, 1.44938556e-02f, 3.70982029e-02f, -4.65543643e-02f,
  -9.82112959e-02f, -1.99453179e-02f, 3.45801972e-02f, 1.81624815e-02f, 7.73714557e-02f, -1.12629190e-01f, 3.63506353e-03f, -2.97758691e-02f, 2.23045815e-02f, -6.42413497e-02f,
  -2.06708740e-02f, -1.10727221e-01f, 5.71927913e-02f, -5.28100505e-02f, -7.00334907e-02f, -9.93329063e-02f, -3.99950258e-02f, -8.90262127e-02f, 2.20583249e-02f, -2.57524215e-02f,
  -1.68703660e-01f, -7.95741975e-02f, 2.66126338e-02f, -7.11024851e-02f, -1.01839542e-01f, -7.68423406e-03f, -6.88415989e-02f, -2.77151376e-01f, -2.70524770e-01f, -1.06153063e-01f,
  -1.77020624e-01f, 2.24605858e-01f, -1.12461828e-01f, 2.00401664e-01f, 2.89850861e-01f, 1.37383848e-01f, 1.39563039e-01f, 2.12004423e-01f, 7.20205978e-02f, -1.65340435e-02f,
  1.29973128e-01f, 2.55197585e-01f, 3.22048634e-01f, 6.67650476e-02f, 1.31076679e-01f, 9.75592136e-02f, 2.82221556e-01f, 1.00411654e-01f, 2.23690823e-01f, 1.49108961e-01f,
  -2.97338236e-02f, -2.26473927e-01f, -1.01468846e-01f, 6.79124370e-02f, -1.05111927e-01f, -1.01627479e-03f, 1.12292118e-01f, 9.76873562e-02f, -7.14824675e-03f, 1.71462409e-02f,
  -1.16734048e-02f, 6.20445143e-03f, 3.52698304e-02f, 1.30273094e-02f, -1.65318176e-02f, -1.23639414e-02f, 3.15997936e-02f, -3.47953923e-02f, -5.20622581e-02f, -1.05363414e-01f,
  -6.40719682e-02f, 2.32661292e-02f, -2.63541769e-02f, 4.97278161e-02f, -9.54791438e-03f, -1.23022467e-01f, 2.30948105e-02f, 1.34050459e-01f, 5.99110164e-02f, -1.70560870e-02f,
  3.97315854e-03f, 3.08310473e-03f, 2.08793748e-02f, -1.02650616e-02f, 3.79331857e-02f, -7.54284486e-02f, 1.09097334e-02f, 6.52251691e-02f, 9.43296626e-02f, -4.51656990e-02f,
  2.08353531e-02f, -1.34219509e-02f, -1.24480566e-02f, -2.83022951e-02f, 2.15050951e-02f, -1.00049540e-01f, 1.36789992e-01f, 1.60367303e-02f, -3.93382199e-02f, 1.10533775e-03f,
  -2.80340556e-02f, 2.39102803e-02f, -4.50926280e-04f, 1.91518832e-02f, -9.73357260e-02f, -5.41806556e-02f, 1.13569582e-02f, -6.21118955e-02f, -2.42876094e-02f, 6.27551600e-02f,
  4.64184806e-02f, 7.47355893e-02f, -7.09831640e-02f, 5.07357605e-02f, -2.88745202e-02f, 1.77900065e-02f, 6.57245517e-02f, -4.52165604e-02f, -4.52151857e-02f, 1.90407094e-02f,
  -5.60728321e-03f, 7.10628852e-02f, 2.02410668e-02f, -2.40385588e-02f, 8.42695311e-02f, -6.83996305e-02f, 5.23897745e-02f, 7.64043555e-02f, -2.29103137e-02f, -1.58996321e-03f,
  3.73020815e-03f, -4.54420447e-02f, -9.05790180e-03f, -4.03343253e-02f, -1.06157893e-02f, 1.16355931e-02f, -5.83304651e-02f, -6.60089850e-02f, 5.56259863e-02f, -2.87196450e-02f,
  7.35409707e-02f, -1.06039688e-01f, 2.00733960e-01f, 1.32840604e-01f, 1.36469021e-01f, -1.11958832e-01f, -6.60293996e-02f, 1.51152879e-01f, 2.79073268e-01f, -2.48287603e-01f,
  -1.45931810e-01f, 1.47429571e-01f, -1.46203265e-01f, -2.29406953e-01f, -6.08261600e-02f, -1.73431069e-01f, -1.23283423e-01f, -1.03992648e-01f, 1.11426078e-01f, 9.36850682e-02f,
  2.67891698e-02f, -1.51712835e-01f, -3.83127853e-02f, -1.06340609e-01f, -3.40305232e-02f, 7.34671354e-02f, -1.59172043e-01f, 6.24556653e-03f, -2.06583291e-01f, -6.84778914e-02f,
  -5.09647615e-02f, 4.34057638e-02f, 1.01560213e-01f, 1.93034392e-02f, -7.51229972e-02f, -1.94267090e-02f, -1.13365881e-01f, -2.53048334e-02f, 1.29003853e-01f, 3.99572663e-02f,
  1.50357187e-02f, -6.54365346e-02f, -1.35532524e-02f, 5.65483272e-02f, 5.72230555e-02f, -2.92654503e-02f, -6.06429763e-03f, -1.81325376e-02f, 2.20547952e-02f, -5.59290964e-03f,
  2.92981919e-02f, 6.87696189e-02f, -1.42449457e-02f, -1.56725824e-01f, 3.64223756e-02f, 5.42015024e-02f, 1.78464763e-02f, -7.40740299e-02f, 1.37122776e-02f, 5.53886741e-02f,
  -3.43140960e-02f, 3.94467115e-02f, -2.78961807e-02f, 5.71275651e-02f, 6.54008761e-02f, 6.41731247e-02f, -6.09474182e-02f, -2.24777777e-03f, 1.10544385e-02f, 1.92199368e-02f,
  2.75545195e-02f, 2.64798589e-02f, 9.66744572e-02f, 9.21197534e-02f, 1.75764728e-02f, 3.69822569e-02f, -3.28760408e-02f, -6.17222041e-02f, -3.44967768e-02f, 9.13145691e-02f,
  -3.06177177e-02f, -4.82606366e-02f, 5.40046990e-02f, -8.66402388e-02f, -5.52303344e-02f, 5.01271673e-02f, -4.21439447e-02f, 2.62038354e-02f, 4.78758179e-02f, -1.21228187e-03f,
  -6.78071678e-02f, -2.00539976e-01f, 6.68239892e-02f, 8.10599923e-02f, 1.18960440e-02f, -4.45404798e-02f, 2.62400191e-02f, 6.19503632e-02f, -1.40234102e-02f, -7.84437582e-02f,
  -1.08783260e-01f, 8.76458734e-02f, -3.05746477e-02f, 3.11459526e-02f, 2.66702641e-02f, -3.41342911e-02f, -1.01010904e-01f, -3.38075822e-03f, -8.25121161e-03f, -7.90339801e-03f,
  -1.18797701e-02f, -3.89130004e-02f, 5.01409313e-03f, 1.14815328e-02f, 1.58140939e-02f, -4.17212322e-02f, 2.75966171e-02f, 8.31898395e-03f, -7.10273311e-02f, -5.40345497e-02f,
  -3.20162296e-01f, -6.35448694e-02f, -7.99838230e-02f, -2.65186667e-01f, 1.24535345e-01f, -8.90919045e-02f, -1.74160331e-01f, -1.15032651e-01f, -1.18514754e-01f, 1.85792353e-02f,
  -5.36793657e-02f, -1.35095650e-02f, 4.22017947e-02f, -2.16234639e-01f, -2.09653050e-01f, -3.81350517e-02f, -2.81306744e-01f, -3.47166769e-02f, -3.23009603e-02f, -2.79696397e-02f,
  -5.89395761e-02f, -1.06617652e-01f, -1.51748717e-01f, 8.39173347e-02f, -1.18391477e-01f, 1.33644873e-02f, 1.07838675e-01f, 1.15037628e-01f, -1.58273056e-01f, 7.94738065e-03f,
  -5.80607168e-02f, 9.68434103e-03f, -7.17463270e-02f, 2.87051201e-02f, -2.45894608e-03f, 4.34227847e-03f, 3.70176770e-02f, 7.24651292e-02f, -1.27644949e-02f, 1.44383800e-03f,
  2.72753201e-02f, -4.36499715e-02f, 2.70620380e-02f, 5.65495715e-02f, -7.34143555e-02f, 5.10970643e-03f, -7.64024183e-02f, -2.90154330e-02f, 1.52306743e-02f, -1.31336555e-01f,
  -2.31921263e-02f, 1.92976482e-02f, -5.81776127e-02f, 9.14602652e-02f, 6.67965114e-02f, -2.67534386e-02f, -5.35547435e-02f, 3.43424194e-02f, 3.06003814e-04f, -7.94761553e-02f,
  -3.54870223e-02f, 3.27000134e-02f, -6.19589686e-02f, -7.40513429e-02f, -1.87270087e-03f, -1.40491920e-03f, -5.25465943e-02f, 2.00157072e-02f, -5.19717149e-02f, -5.21458797e-02f,
  -5.19344695e-02f, -3.79976444e-02f, -2.60540489e-02f, 1.68778822e-02f, -1.48134017e-02f, -3.41133103e-02f, -7.54595129e-03f, 8.72897916e-03f, -1.16764586e-02f, -8.58578905e-02f,
  4.46095970e-03f, -2.92059872e-02f, -6.10105367e-03f, 4.36063185e-02f, -4.87337410e-02f, -3.21768597e-02f, 4.61956114e-03f, -5.80061264e-02f, -8.21273599e-04f, -6.83297664e-02f,
  5.93187436e-02f, -3.29867117e-02f, 8.81191716e-03f, 5.40997013e-02f, 4.87089753e-02f, -6.47320673e-02f, -6.22185506e-02f, -7.24447072e-02f, 7.62969814e-03f, -5.41813672e-03f,
  6.06576391e-02f, -5.44314198e-02f, 3.74867171e-02f, 1.35541325e-02f, 9.31062996e-02f, -1.95252262e-02f, 9.85196158e-02f, -1.91565882e-02f, 6.26468100e-03f, -1.52806249e-02f,
  -1.35035655e-02f, -7.85819162e-03f, 8.18257779e-03f, -2.98542855e-03f, -1.85748544e-02f, 6.89961761e-02f, -9.67073161e-03f, -3.35240923e-02f, -4.07736972e-02f, 7.20780641e-02f,
  -1.93516612e-01f, -4.70758192e-02f, 1.62915215e-01f, -1.78881332e-01f, 8.40924606e-02f, 2.86073238e-01f, 7.28130415e-02f, -9.78448987e-02f, -1.35392725e-01f, -9.97002870e-02f,
  -1.49726257e-01f, -5.67626245e-02f, -1.31520852e-01f, 3.52932848e-02f, 9.94351655e-02f, 5.22209257e-02f, 1.51955381e-01f, -2.95287417e-03f, -2.35638209e-02f, -2.26989146e-02f,
  -7.09583238e-02f, -9.82931629e-02f, 1.48174599e-01f, 6.01290092e-02f, 4.76968735e-02f, -5.19909598e-02f, -1.31887600e-01f, -8.77238344e-03f, 8.38491991e-02f, 1.39513565e-02f,
  2.90503595e-02f, -2.08371565e-01f, -2.55688615e-02f, 1.00493722e-01f, 2.36248728e-02f, 5.34860343e-02f, 8.32437053e-02f, -3.71839487e-05f, 3.96370739e-02f, 8.50905478e-03f,
  3.10034640e-02f, 8.57429653e-02f, -3.66476290e-02f, 3.04581560e-02f, 5.80933839e-02f, 4.46394086e-02f, 1.51459306e-01f, 1.14703380e-01f, -9.85162053e-03f, 6.59705177e-02f,
  1.50187267e-02f, 1.14218444e-01f, 3.46882455e-02f, 5.59282638e-02f, 6.73653409e-02f, 6.22068867e-02f, 6.93559200e-02f, 3.10660377e-02f, 8.30837116e-02f, 8.20831582e-02f,
  -3.71438265e-02f, -1.00821935e-01f, -7.50406832e-02f, -6.26200438e-02f, -4.38595898e-02f, -4.53154072e-02f, -2.64119245e-02f, -3.48693244e-02f, -4.44667712e-02f, 2.75969394e-02f,
  -7.86216184e-02f, -1.75441671e-02f, -4.04048823e-02f, 7.61714652e-02f, -1.09674178e-01f, -8.78075212e-02f, 1.16328225e-02f, -4.37109545e-02f, -4.25452590e-02f, -1.57522503e-02f,
  -3.56941521e-02f, 9.37760901e-03f, -3.38895060e-02f, 3.38021014e-03f, 3.82569097e-02f, 6.08096318e-03f, 1.91785451e-02f, 7.05471039e-02f, 2.20559351e-02f, 5.56512289e-02f,
  1.05667710e-02f, -1.46707743e-01f, -3.73260640e-02f, -2.48460341e-02f, -4.42797467e-02f, 2.73891538e-02f, -7.21202195e-02f, 1.32369865e-02f, -4.54015993e-02f, 8.12436454e-03f,
  7.02824295e-02f, -6.69603944e-02f, 8.64981860e-02f, -3.72702330e-02f, 1.78941693e-02f, 5.00167571e-02f, -5.11540994e-02f, -1.45338178e-01f, -1.15942191e-02f, -6.30843192e-02f,
  6.82676118e-03f, -2.47408394e-02f, 3.15239727e-02f, -2.90485471e-02f, 9.97441635e-03f, -3.33041549e-02f, -2.72235721e-02f, 9.41051468e-02f, 8.30489099e-02f, 5.28706647e-02f,
  -3.77038002e-01f, -1.58963323e-01f, 2.69531924e-02f, -1.72469750e-01f, 2.94346008e-02f, 1.00044727e-01f, 1.17524266e-01f, -3.35291661e-02f, -3.81412171e-02f, -4.42731343e-02f,
  1.32895485e-01f, -2.29495570e-01f, 9.89724770e-02f, 1.06162012e-01f, 2.90998984e-02f, 2.18046814e-01f, -3.26581746e-02f, -1.12917043e-01f, 4.04853784e-02f, -1.40442669e-01f,
  3.96064147e-02f, -4.06317972e-02f, 6.25129715e-02f, 4.40236181e-02f, -9.11317021e-02f, -1.04074506e-02f, -1.19655930e-01f, 7.82535374e-02f, -1.07694484e-01f, 2.94621252e-02f,
  -4.81360257e-02f, -1.05353020e-01f, 3.34427059e-02f, -2.36381013e-02f, -3.40724015e-03f, -2.99159158e-03f, -1.52787771e-02f, 1.66492894e-01f, 5.45224808e-02f, 7.04109520e-02f,
  3.88940200e-02f, -4.16599438e-02f, 2.65284330e-02f, 8.24707467e-03f, -8.14153105e-02f, 3.41104567e-02f, -6.71749329e-03f, 4.74326573e-02f, 4.87739593e-02f, 7.71036372e-02f,
  -4.28315392e-03f, 5.55041768e-02f, 2.60724369e-02f, -5.78551143e-02f, 4.97957058e-02f, -3.50025333e-02f, 1.68639477e-02f, -4.00104746e-02f, -1.12268776e-01f, -9.47072282e-02f,
  3.76041234e-02f, 2.54301541e-02f, -3.24067026e-02f, 3.57792228e-02f, -7.34247640e-02f, -5.81670217e-02f, -2.86583826e-02f, -3.40922214e-02f, -3.34894918e-02f, -5.36613986e-02f,
  -1.04045786e-01f, -4.48393635e-02f, -3.35817114e-02f, -3.16455029e-02f, -5.75264208e-02f, -2.70744301e-02f, -2.03428660e-02f, -8.21698532e-02f, -2.12102570e-02f, 5.32399453e-02f,
  -2.10057814e-02f, -2.90391985e-02f, -3.82852070e-02f, 4.38117087e-02f, 5.55302538e-02f, 4.38301079e-02f, -6.29187599e-02f, -9.48754400e-02f, 8.25587288e-02f, -4.13927902e-03f,
  -2.75826424e-01f, -3.14132839e-01f, 6.78064302e-02f, -4.37077368e-03f, -2.41939519e-02f, -2.07194816e-02f, 4.50629443e-02f, -4.55780998e-02f, -4.97060493e-02f, -5.98560134e-03f,
  -6.10453263e-02f, -6.44984990e-02f, -9.76340920e-02f, 2.30063666e-02f, 2.00541280e-02f, -2.45362695e-04f, 3.60743068e-02f, -2.94959676e-02f, -4.73565906e-02f, -1.22667059e-01f,
  -2.29973011e-02f, -6.70542717e-02f, -5.68922237e-03f, 6.19927458e-02f, -2.20051897e-03f, 6.55010517e-04f, -9.70959812e-02f, 2.66900640e-02f, -5.12494557e-02f, -1.08019039e-01f,
  -2.57945091e-01f, 6.15933612e-02f, -2.29215518e-01f, -5.63681684e-02f, 2.20100340e-02f, -2.00499788e-01f, -2.27341354e-01f, 1.43317819e-01f, -2.31666967e-01f, 1.84354007e-01f,
  2.21281514e-01f, -2.09263653e-01f, 2.99125966e-02f, 7.23287910e-02f, -8.99792016e-02f, -8.14775378e-02f, 3.00403312e-02f, 6.72976449e-02f, -5.35619669e-02f, 6.31656349e-02f,
  -1.87749453e-02f, 2.20318407e-01f, -5.61141744e-02f, 1.65173799e-01f, 1.00778610e-01f, -9.38142017e-02f, 1.91616267e-01f, 2.46672444e-02f, 2.33669132e-01f, 6.32115304e-02f,
  1.26636941e-02f, 7.63153508e-02f, -4.21737880e-02f, -5.71031384e-02f, 5.27449585e-02f, 1.19233970e-02f, -6.47501089e-03f, -4.32549603e-03f, -3.62496898e-02f, 4.22403100e-04f,
  -3.29534486e-02f, 1.92735344e-02f, 6.30352041e-03f, 4.60098591e-03f, -1.27116055e-03f, -3.52322310e-02f, -4.69803177e-02f, -3.68845835e-02f, -5.60100935e-02f, -9.41369962e-03f,
  -8.36847723e-02f, -4.14398424e-02f, 4.08626348e-02f, -6.42008409e-02f, -6.55323341e-02f, 6.81101531e-02f, -6.69234172e-02f, 8.85534286e-03f, -5.51911537e-03f, 1.23981414e-02f,
  6.49447814e-02f, -4.03570831e-02f, 8.45543593e-02f, -8.07881430e-02f, 1.94840934e-02f, 9.71337333e-02f, 3.00864922e-03f, 5.23588061e-03f, 1.05530499e-02f, -2.85413098e-02f,
  2.70825569e-02f, -6.25458732e-02f, -1.30508961e-02f, -1.87645853e-02f, -1.83289256e-02f, 1.09466128e-02f, -1.31396838e-02f, 5.97911961e-02f, -1.10711657e-01f, 4.35103588e-02f,
  -2.62799300e-02f, -3.68686728e-02f, 4.92142476e-02f, -4.02912162e-02f, 4.11022082e-02f, 2.63508055e-02f, 2.33801478e-03f, -4.62809987e-02f, 4.50767484e-03f, -2.93410998e-02f,
  -4.54768501e-02f, -8.49239063e-03f, -1.48763694e-02f, -1.08037390e-01f, 5.03791906e-02f, -2.45858766e-02f, -1.76792927e-02f, 5.71435541e-02f, 1.75268929e-02f, 2.32906686e-03f,
  -1.01043482e-03f, 4.11346108e-02f, 3.67873372e-03f, -3.55282836e-02f, -4.78559397e-02f, -1.24522783e-02f, 1.50818694e-02f, -3.74957137e-02f, -5.39950952e-02f, 8.77535790e-02f,
  4.24971655e-02f, -9.04873852e-03f, -9.24567506e-02f, 2.04140563e-02f, 7.41027072e-02f, -6.35977760e-02f, 1.84347108e-02f, 1.81490649e-02f, 1.04487963e-01f, -1.98146552e-02f,
  1.33659363e-01f, -1.19283125e-01f, 1.36758044e-01f, 1.82678699e-01f, -5.02626486e-02f, 2.14209139e-01f, 3.14140260e-01f, -1.27125150e-02f, 1.26030833e-01f, -5.74343242e-02f,
  -6.25898689e-02f, -2.02510078e-02f, 1.88563958e-01f, 6.23650923e-02f, 2.09523380e-01f, 9.29035246e-02f, -2.72830017e-02f, -4.05643135e-02f, 1.35243805e-02f, -3.73171456e-02f,
  1.68076996e-02f, 1.31832868e-01f, 1.72356158e-01f, -1.13902099e-01f, 1.62200570e-01f, -7.80976191e-02f, -1.05512388e-01f, 8.10467824e-02f, -9.81506258e-02f, -1.61391497e-03f,
  8.83641392e-02f, 4.62059714e-02f, 6.63291886e-02f, -1.36676626e-02f, -2.03902442e-02f, -7.31718121e-03f, -3.16547230e-02f, 7.84173608e-03f, -2.24241074e-02f, 1.73201747e-02f,
  1.75598972e-02f, -4.60153744e-02f, -5.29451109e-03f, 4.13665362e-03f, -1.89845134e-02f, -2.73292176e-02f, 2.84214015e-03f, 4.69090715e-02f, -2.48584757e-03f, 8.30119476e-02f,
  1.96476523e-02f, -4.29322850e-03f, 6.50965497e-02f, -8.91586766e-02f, -1.05534703e-01f, 3.97210009e-02f, -4.96276654e-02f, -4.02303785e-02f, 3.27098928e-02f, -5.80621734e-02f,
  4.93145250e-02f, -8.06931928e-02f, 7.29125962e-02f, 5.17889187e-02f, -2.60274578e-02f, 1.00529389e-02f, -5.19439802e-02f, -1.21422000e-02f, -8.88740197e-02f, -2.44258661e-02f,
  4.84095551e-02f, 2.09348239e-02f, -6.12008870e-02f, 4.11826894e-02f, -5.75437024e-02f, -1.64769292e-02f, 3.15802991e-02f, -5.32014556e-02f, -5.38477674e-03f, -2.55562412e-03f,
  6.82371333e-02f, -3.04051004e-02f, 7.11879507e-02f, 4.09037434e-02f, -2.83230506e-02f, 4.22175825e-02f, -2.30305847e-02f, 7.71491155e-02f, 2.55301241e-02f, -6.95769116e-03f,
  -3.17589864e-02f, -1.18646212e-01f, -9.43403989e-02f, -3.24483402e-02f, -8.16039518e-02f, -1.08238146e-01f, 2.04828065e-02f, -8.13387260e-02f, 4.10501026e-02f, 3.18208262e-02f,
  -9.94344801e-02f, -7.92090222e-03f, -5.05782217e-02f, 4.01178114e-02f, 7.09993299e-03f, -2.54891850e-02f, 2.82897544e-03f, -3.50630544e-02f, -5.40675186e-02f, -8.66336823e-02f,
  -7.62135684e-02f, -4.94331345e-02f, -9.46665183e-02f, -1.81190372e-02f, -9.69076753e-02f, -6.41217977e-02f, -4.56706025e-02f, -2.78070364e-02f, 9.75000579e-03f, -4.53403266e-03f,
  -2.48804361e-01f, 2.77491271e-01f, -1.10792190e-01f, -6.81208521e-02f, -2.18514711e-01f, -2.72380233e-01f, -2.18337342e-01f, -8.30289423e-02f, -5.14828041e-02f, 1.75901458e-01f,
  -9.81289335e-03f, 1.47428021e-01f, 1.56191885e-01f, 1.64291292e-01f, -2.52029628e-01f, 1.39224887e-01f, -1.47218555e-01f, -1.95615478e-02f, 2.09423862e-02f, -6.73393309e-02f,
  -8.36851522e-02f, -1.01852424e-01f, 9.47297662e-02f, 1.08731687e-01f, -5.69010340e-02f, -1.65988188e-02f, -1.07933767e-01f, -7.39232153e-02f, -1.30180418e-02f, -3.38317342e-02f,
  4.65289727e-02f, 7.87297189e-02f, 7.04767406e-02f, 2.11273972e-02f, -1.72228321e-01f, -1.15763359e-01f, -1.36204520e-02f, 6.86251651e-03f, -5.87204173e-02f, 2.68507469e-02f,
  6.77604377e-02f, -4.27938998e-02f, 6.32025450e-02f, 1.05434908e-02f, -5.65270633e-02f, 3.23650194e-03f, 5.63998781e-02f, -2.41451133e-02f, 1.50901044e-03f, 8.85271057e-02f,
  -8.12839600e-04f, 4.90156226e-02f, -1.48818921e-03f, 1.00037362e-02f, -6.90835118e-02f, -4.17710580e-02f, 2.71227472e-02f, 1.74489710e-02f, -2.34859646e-03f, -2.75929105e-02f,
  -8.16853866e-02f, -7.55676925e-02f, 3.96674648e-02f, 1.49295907e-02f, 1.37726199e-02f, 2.83188969e-02f, -2.82011298e-03f, 3.08754724e-02f, -5.94536774e-02f, 9.75292549e-03f,
  1.12431478e-02f, -2.59787906e-02f, 3.63158770e-02f, -5.79393208e-02f, -5.20279631e-02f, 2.31889654e-02f, 1.90171711e-02f, 1.59132164e-02f, -2.88662203e-02f, -3.21125649e-02f,
  -4.67714854e-03f, -2.16446035e-02f, 1.43783921e-02f, -2.46894695e-02f, -2.27259994e-02f, -1.63283292e-02f, -5.03635267e-03f, 3.68556241e-03f, -3.40958661e-03f, -1.02617495e-01f,
  -1.48308143e-01f, -1.08003013e-01f, 5.22783399e-02f, 4.64937240e-02f, 4.58545089e-02f, 7.06208497e-02f, 6.89667240e-02f, -1.93082634e-02f, -3.53922173e-02f, -1.98643785e-02f,
  -6.23546802e-02f, -2.71002352e-02f, -8.49504843e-02f, -1.88792627e-02f, -4.64957729e-02f, 1.54388584e-02f, -1.76235382e-02f, 5.41604906e-02f, -9.49242041e-02f, -8.45920108e-03f,
  -3.34933703e-03f, -6.27737418e-02f, -2.33618040e-02f, -2.00995039e-02f, 1.65743865e-02f, -9.61095020e-02f, -5.32458760e-02f, -1.13891708e-02f, -1.36183621e-02f, 1.39868306e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.50294875e-02f, -2.29837775e-01f, -2.47648999e-01f, -2.72599548e-01f, 7.75030404e-02f, 1.06142335e-01f, -1.39526650e-01f, 8.94840434e-02f, -1.12943821e-01f, 5.56305982e-02f,
  3.81438918e-02f, -2.39215001e-01f, -1.23849586e-01f, -1.84141427e-01f, -8.87519270e-02f, -2.83891857e-01f, 7.63011277e-02f, -9.36020985e-02f, -1.57093734e-01f, 1.48429543e-01f,
  -3.38606164e-02f, -3.98602895e-03f, -1.07879393e-01f, 2.36992478e-01f, 1.67213663e-01f, 5.83015308e-02f, 2.97944248e-01f, 1.01513542e-01f, 2.22578883e-01f, 9.00439397e-02f,
  -2.06206180e-02f, -8.95674601e-02f, -4.91833314e-02f, 3.21293436e-02f, 6.87912330e-02f, 1.53106106e-02f, 1.40574440e-01f, -9.81178805e-02f, -5.99628314e-02f, -9.32673216e-02f,
  2.21411581e-03f, -9.94610265e-02f, 1.06254043e-02f, -1.61587764e-02f, -1.77142024e-02f, -4.97346707e-02f, -1.26590699e-01f, 1.93220768e-02f, -2.30455890e-01f, -3.10005452e-02f,
  -6.10102452e-02f, -1.18347354e-01f, 2.32877061e-02f, -4.65483777e-03f, 4.65358421e-03f, 3.50246318e-02f, -1.80197775e-03f, 7.88826644e-02f, 1.35804981e-01f, -2.78009679e-02f,
  9.63339731e-02f, 9.27131325e-02f, -3.93533297e-02f, -6.88159242e-02f, -1.13593929e-01f, -6.25318587e-02f, -9.67030227e-02f, -2.81227268e-02f, -7.79873654e-02f, 4.41728905e-02f,
  7.52018243e-02f, -8.23007748e-02f, 2.46147700e-02f, 7.96026587e-02f, 6.35146126e-02f, -9.03821513e-02f, 1.00812890e-01f, 3.16857547e-02f, 2.98939366e-02f, -1.29914992e-02f,
  1.33527303e-02f, 4.91297692e-02f, -5.41091152e-02f, 1.36362687e-01f, -4.67227586e-02f, 3.40876617e-02f, 8.50274339e-02f, 6.52912185e-02f, -2.22539399e-02f, -3.17425504e-02f,
  -4.23757918e-03f, 2.16288015e-01f, -9.00486261e-02f, 1.76463798e-02f, 2.35954076e-02f, 8.88647288e-02f, -2.50971280e-02f, 6.21983893e-02f, 1.06365658e-01f, 3.59930545e-02f,
  1.97747976e-01f, 8.38421006e-03f, 1.46904930e-01f, 6.13471568e-02f, -6.37815520e-02f, 9.80303884e-02f, 3.26134972e-02f, 6.00335225e-02f, 1.13271050e-01f, -8.40187669e-02f,
  1.80184811e-01f, 1.11369155e-01f, -5.06002046e-02f, 1.39435921e-02f, 6.91256300e-02f, 2.00168397e-02f, 3.50301303e-02f, -3.72931696e-02f, -2.73806117e-02f, 3.39773484e-03f,
  1.01424016e-01f, -5.11814177e-01f, -1.52631164e-01f, 5.18998429e-02f, 2.67290801e-01f, -2.06361692e-02f, -6.45244196e-02f, -3.72466333e-02f, -1.20382778e-01f, -2.20161363e-01f,
  7.67207239e-03f, 2.41807953e-01f, -2.96306908e-01f, 8.94746110e-02f, 4.37428504e-01f, -2.50429865e-02f, 2.10455745e-01f, 2.40845054e-01f, 2.38032872e-03f, -1.10628260e-02f,
  1.72511369e-01f, 2.62342304e-01f, 1.76981345e-01f, -2.66789533e-02f, -3.83735751e-03f, -4.32849191e-02f, 7.52367601e-02f, -4.51350100e-02f, 1.47410259e-01f, 2.13689744e-01f,
  -1.66509032e-01f, -1.51477575e-01f, 7.45768771e-02f, 5.15474454e-02f, -1.51384816e-01f, -7.46629536e-02f, 6.40327185e-02f, 1.19163841e-01f, 1.40250593e-01f, 1.03097923e-01f,
  -8.76555592e-03f, 6.74385428e-02f, 1.32417781e-02f, 5.75647727e-02f, -8.73906389e-02f, 1.01422984e-02f, -6.70232698e-02f, -3.45924050e-02f, -9.75409150e-02f, -1.18151139e-02f,
  -4.84673195e-02f, 7.32951313e-02f, 1.00237355e-02f, 4.86272052e-02f, -3.30206603e-02f, -3.68173905e-02f, 7.65889436e-02f, 9.78028402e-03f, -1.37988664e-02f, 2.67566834e-02f,
  7.08211958e-02f, 1.08766384e-01f, -7.94324204e-02f, -7.59091228e-02f, -1.09241866e-01f, -2.90296338e-02f, -1.59997717e-02f, 1.10277638e-01f, 1.65054519e-02f, -5.87610677e-02f,
  2.39284560e-02f, 7.29134679e-02f, 8.19504634e-02f, -6.74959645e-02f, 9.09905359e-02f, 6.22308403e-02f, -2.80518122e-02f, 1.81867406e-02f, -1.18727416e-01f, 2.37736125e-02f,
  3.02965846e-03f, 2.98952986e-03f, -1.02614373e-01f, -1.40853133e-02f, 6.20775446e-02f, 1.96930673e-02f, -1.01129040e-01f, -4.91625220e-02f, -3.91761251e-02f, 2.78507788e-02f,
  -4.50216055e-01f, -3.16205353e-01f, -2.90109906e-02f, 4.81781811e-02f, -9.52920914e-02f, -1.57852143e-01f, 2.42278185e-02f, -2.71632653e-02f, -5.27476296e-02f, -7.65752494e-02f,
  -4.81803454e-02f, 1.84605792e-02f, 5.03994040e-02f, -1.51984915e-02f, 7.91028440e-02f, -4.62070182e-02f, 6.40502572e-03f, 6.43495694e-02f, -1.37238279e-02f, 6.04580194e-02f,
  -3.36908586e-02f, -7.98799023e-02f, 1.16489880e-01f, -4.99042757e-02f, 2.82621570e-02f, 5.19830883e-02f, 2.23832056e-02f, 1.22826286e-02f, 2.01365333e-02f, 1.98740140e-02f,
  1.96649507e-01f, 2.86898404e-01f, -2.61689782e-01f, -7.61875585e-02f, -1.48256803e-02f, 4.26396400e-01f, 2.97782570e-01f, 1.64339542e-01f, 5.18399030e-02f, 3.07598859e-01f,
  1.57435641e-01f, 7.63520971e-02f, 1.18029915e-01f, 4.49191928e-01f, 4.70476411e-02f, 2.84856290e-01f, 2.05579489e-01f, 2.56609142e-01f, 1.89052187e-02f, 1.36808679e-01f,
  1.12510044e-02f, 3.53061676e-01f, -1.89136535e-01f, 1.14065893e-01f, 1.76462546e-01f, -2.42528930e-01f, -1.79759040e-01f, -2.16651723e-01f, 4.90414500e-02f, -2.37751682e-03f,
  1.54192541e-02f, 2.85161682e-03f, 1.78104639e-02f, 1.91063844e-02f, -8.60848501e-02f, -5.97749129e-02f, -6.75957799e-02f, -7.68818855e-02f, -8.72036070e-02f, 2.13465840e-02f,
  -3.12041920e-02f, -3.06019429e-02f, 7.75182694e-02f, -4.71831597e-02f, 1.20184831e-01f, -1.05734318e-01f, 1.56571697e-02f, -5.64027540e-02f, 6.12626858e-02f, 9.60569903e-02f,
  -2.79295277e-02f, 4.48854789e-02f, 2.68984232e-02f, -6.60899356e-02f, -2.77413912e-02f, 4.28930633e-02f, 4.13931683e-02f, -4.31332439e-02f, -2.94649713e-02f, -1.04490966e-02f,
  -5.38870841e-02f, 7.72521421e-02f, 8.27813372e-02f, -3.39607336e-02f, -8.82343501e-02f, -1.36788487e-01f, 1.00431517e-01f, -7.85392616e-03f, -9.19062237e-04f, 8.34596530e-02f,
  1.77453831e-02f, -4.10005450e-02f, 1.29958829e-02f, -3.78440088e-03f, 6.04613759e-02f, 1.88730005e-02f, -4.36219089e-02f, 1.14305422e-01f, -7.74235576e-02f, 3.60316560e-02f,
  -1.98111660e-03f, -1.08434567e-02f, -7.11390050e-03f, -1.05726626e-02f, 1.01971745e-01f, -5.41619472e-02f, 6.32403567e-02f, -2.42751297e-02f, 2.94717103e-02f, -5.30865341e-02f,
  1.25568002e-01f, 1.29870802e-01f, -1.91085339e-02f, 2.01042928e-02f, -1.23448595e-01f, -5.10736592e-02f, -1.03152292e-02f, 5.36797941e-02f, 3.78473178e-02f, 4.85824384e-02f,
  -1.01421498e-01f, -2.56269192e-03f, 3.79616693e-02f, -2.52901800e-02f, -2.86002755e-02f, 6.55471161e-02f, -2.77731149e-03f, -7.31555149e-02f, -1.95033215e-02f, -1.02364518e-01f,
  -9.39374864e-02f, -4.95889038e-02f, 3.01769860e-02f, -8.81709903e-02f, -1.68228466e-02f, -2.14052256e-02f, 2.30366364e-03f, -1.07934795e-01f, -1.25234500e-02f, 4.34959754e-02f,
  -9.80346799e-02f, 2.05114216e-01f, 1.79135084e-01f, 1.81753263e-01f, 3.21801454e-01f, 2.35091075e-01f, 2.49959186e-01f, 1.64862737e-01f, 4.12486404e-01f, -1.43756062e-01f,
  -7.62024000e-02f, -6.41646236e-02f, -2.04770297e-01f, 4.86487709e-02f, 7.13519752e-02f, 1.53826594e-01f, 2.31162652e-01f, 1.86137244e-01f, 1.31865546e-01f, -8.67344141e-02f,
  1.08093180e-01f, -4.51215990e-02f, -2.72316724e-01f, -6.61850497e-02f, -1.17516547e-01f, 1.10000595e-02f, -2.68635541e-01f, 3.49998921e-02f, -1.90172464e-01f, 1.81825280e-01f,
  5.82788773e-02f, 8.58696923e-02f, -1.68448165e-01f, 2.00384483e-02f, 7.34446757e-03f, -8.36142004e-02f, 1.69707611e-02f, 2.55842339e-02f, -2.36095907e-03f, -2.44839638e-02f,
  -1.41164977e-02f, -5.32790050e-02f, 5.97200096e-02f, -2.25593317e-02f, -3.51867490e-02f, -7.98376352e-02f, 1.45519860e-02f, 3.70872505e-02f, -7.79729411e-02f, -6.25525266e-02f,
  -1.06564723e-01f, -1.92546975e-02f, 4.95538861e-02f, 1.04667105e-01f, -2.82005519e-02f, 7.63382763e-02f, -4.09020782e-02f, 2.45056804e-02f, 9.49368463e-04f, 1.36050344e-01f,
  -6.31910574e-04f, 1.83395371e-01f, -8.88906941e-02f, -1.20834010e-02f, 4.78969589e-02f, -3.63780186e-02f, -1.31322956e-02f, 6.30769953e-02f, 4.60891873e-02f, 4.46896963e-02f,
  3.11962813e-02f, -2.90325079e-02f, 7.55571723e-02f, -1.12030050e-02f, -7.48428181e-02f, 5.17500341e-02f, -1.86350103e-02f, -2.56552603e-02f, -2.02870946e-02f, -2.68422272e-02f,
  2.98788771e-02f, -6.73662266e-03f, -1.78423107e-01f, 7.67358691e-02f, 3.92883234e-02f, -3.35177071e-02f, -1.06527694e-01f, -5.46541996e-02f, -6.81952527e-03f, -4.03353311e-02f,
  2.04189852e-01f, 2.01961398e-01f, -6.79945573e-02f, -9.82758179e-02f, 2.01972816e-02f, -5.37605919e-02f, 5.43735437e-02f, 7.12607149e-03f, 6.21313928e-03f, 1.51261697e-02f,
  8.22653472e-02f, -7.77665973e-02f, -4.45754640e-03f, -2.12761648e-02f, -3.21741158e-04f, 1.15553811e-02f, -3.22429948e-02f, 5.19831926e-02f, 6.39893487e-02f, -6.21050037e-03f,
  -8.01360980e-02f, -2.60834675e-02f, -1.95052475e-02f, 7.76756108e-02f, -2.98742261e-02f, -6.16826117e-02f, 3.34749371e-02f, -1.83083594e-03f, -4.85080034e-02f, -4.41845246e-02f,
  -3.78181756e-01f, 6.08361587e-02f, -3.49859148e-02f, 3.14402103e-01f, -1.86236724e-01f, 1.36727318e-01f, 2.30234489e-01f, -1.35176852e-01f, 3.58457386e-01f, 2.23767072e-01f,
  1.68964475e-01f, -1.73076496e-01f, 2.94052605e-02f, 3.33474576e-01f, -2.51841635e-01f, 3.02453309e-01f, 2.16146320e-01f, 1.95800573e-01f, 2.99673807e-02f, -1.04995230e-02f,
  2.99769384e-03f, 1.06251240e-01f, -4.60207425e-02f, -2.07956731e-01f, -7.02705756e-02f, -1.23736292e-01f, -5.50563559e-02f, -2.37964243e-01f, -1.24659184e-02f, -1.28480092e-01f,
  -2.05051705e-01f, -1.11390529e-02f, -3.57438959e-02f, -3.16694081e-02f, 2.80696824e-02f, -2.98796017e-02f, -3.59578878e-02f, -6.01659790e-02f, -1.12343557e-01f, -2.20745262e-02f,
  7.04583228e-02f, -7.25806355e-02f, 4.81907874e-02f, -6.56000674e-02f, -1.21559920e-02f, -1.82264261e-02f, 4.27247360e-02f, 5.16506061e-02f, -5.70486858e-02f, -1.20109588e-01f,
  5.80464564e-02f, -6.54512271e-02f, 1.02046341e-01f, 8.14932510e-02f, -5.20038232e-03f, 3.95027027e-02f, 1.16459794e-01f, -7.08041852e-03f, 2.64366101e-02f, 4.24295887e-02f,
  -9.20326114e-02f, -7.52510652e-02f, 3.67529541e-02f, 5.63513339e-02f, -3.73656973e-02f, -7.23758787e-02f, -1.46925617e-02f, 4.54397947e-02f, -3.05250436e-02f, -6.14783317e-02f,
  9.68781300e-03f, -6.44789860e-02f, -1.74376946e-02f, -8.45189989e-02f, 4.15095016e-02f, 8.81437287e-02f, 3.49374302e-02f, -9.08957869e-02f, 4.89600487e-02f, -2.01908574e-02f,
  -3.25652063e-02f, 2.68467013e-02f, 9.71639901e-02f, -2.03348733e-02f, -1.87671129e-02f, -8.23283046e-02f, -1.49847323e-03f, 9.67390314e-02f, 6.76792413e-02f, -5.78475781e-02f,
  -2.26842955e-01f, -1.63905486e-01f, 2.42902692e-02f, -6.12956472e-02f, 3.93728241e-02f, -1.09253312e-02f, 9.04661939e-02f, -2.54197866e-02f, -1.29232824e-01f, -4.79699560e-02f,
  5.81287220e-02f, 1.37903839e-01f, 1.89198821e-03f, -8.75127390e-02f, -6.60639927e-02f, 1.24485113e-01f, 4.58744615e-02f, 5.57472296e-02f, -9.11175162e-02f, -1.07021190e-01f,
  1.99592207e-02f, 6.46602139e-02f, -6.09836988e-02f, -4.77171876e-03f, 2.40135938e-03f, -3.06245182e-02f, 3.42034176e-02f, -4.61448617e-02f, 6.21526409e-03f, -2.14394070e-02f,
  -8.18898082e-02f, 1.59634173e-01f, -5.64006343e-02f, 1.30486548e-01f, 3.03886861e-01f, 3.87455553e-01f, 2.24666774e-01f, 2.18792677e-01f, 4.06022906e-01f, 4.58918186e-03f,
  1.04075938e-01f, 8.07267427e-03f, -1.59730092e-01f, 1.12054408e-01f, 1.44147024e-01f, 7.82141834e-02f, 1.38898954e-01f, 1.48476675e-01f, 2.61171252e-01f, 7.34179914e-02f,
  8.32519233e-02f, 4.10850085e-02f, -2.17266709e-01f, -6.74804375e-02f, -7.18780532e-02f, -1.30907863e-01f, -2.35133052e-01f, -1.62705462e-02f, -1.44590676e-01f, 2.24152982e-01f,
  2.54734326e-03f, 7.63034523e-02f, -1.12056419e-01f, -8.72175619e-02f, -6.14800714e-02f, -8.02704021e-02f, -1.01644576e-01f, -1.25833061e-02f, -9.93017331e-02f, 5.06188758e-02f,
  -4.04353850e-02f, -7.43940007e-03f, 2.19928715e-02f, -2.84665786e-02f, 8.86463821e-02f, 9.65210721e-02f, -7.13384664e-03f, -1.47070093e-02f, 4.39310409e-02f, -3.10538076e-02f,
  -1.00330882e-01f, -1.30522344e-02f, -6.39795884e-02f, 4.21296954e-02f, -1.01161286e-01f, -5.03692888e-02f, 3.94061580e-02f, 1.29948733e-02f, 3.38753127e-02f, 6.40942827e-02f,
  1.04046419e-01f, 9.21106339e-02f, 2.66522244e-02f, -5.02200983e-02f, 2.54063495e-03f, -6.24784008e-02f, -5.41348197e-02f, 1.25466995e-02f, -7.01190829e-02f, 9.56195686e-03f,
  -2.10074568e-03f, 3.53046767e-02f, 8.48469287e-02f, 5.85731976e-02f, 1.13555185e-01f, 1.11355416e-01f, 5.71832322e-02f, 5.06724752e-02f, 6.55485317e-02f, 4.77632582e-02f,
  1.01052001e-01f, 4.47845422e-02f, -3.93521525e-02f, -5.42131364e-02f, -4.00113501e-03f, -1.06764272e-01f, -2.90979841e-03f, -5.00002019e-02f, 4.53912243e-02f, 8.61376747e-02f,
  1.65891677e-01f, 2.50662178e-01f, -5.98138943e-03f, 1.78433470e-02f, 1.50288094e-03f, 6.20051548e-02f, 8.88949409e-02f, 1.07736513e-01f, 1.69511393e-01f, 4.50311229e-02f,
  -2.33781449e-02f, -1.39961252e-03f, 3.17939781e-02f, 8.09953883e-02f, -8.46263021e-02f, -4.45896247e-03f, -1.01611137e-01f, 9.91871282e-02f, 9.05895829e-02f, -5.82529046e-02f,
  -6.98943809e-02f, 7.96837509e-02f, -5.45721389e-02f, 5.17425798e-02f, -3.63395251e-02f, 1.34433601e-02f, 1.02338783e-01f, 1.84094962e-02f, -1.15882039e-01f, 6.20902665e-02f,
  1.38330966e-01f, -2.74220377e-01f, -1.63119212e-01f, -7.25362673e-02f, -1.72562540e-01f, -2.31739059e-01f, -1.42854929e-01f, -2.15032488e-01f, 1.09036416e-01f, -1.91503525e-01f,
  -1.68450043e-01f, 1.11660942e-01f, 1.92797825e-01f, -3.35201621e-01f, 3.72807294e-01f, 2.05185324e-01f, -2.41051644e-01f, -7.23356456e-02f, 5.14767654e-02f, -1.22713439e-01f,
  -1.07328184e-02f, -2.39694104e-01f, -3.86774205e-02f, -1.58205733e-01f, -2.85343975e-01f, -1.39899030e-01f, -1.75250955e-02f, -1.03444465e-01f, -3.19961399e-01f, -9.42867771e-02f,
  -1.09853558e-01f, -8.72646347e-02f, -5.91604318e-03f, -5.50205745e-02f, -8.64928588e-03f, 4.79782633e-02f, -1.08727343e-01f, -2.94432957e-02f, -5.79662919e-02f, -3.49223204e-02f,
  1.39211848e-01f, 4.14478891e-02f, -5.02992906e-02f, 8.77611265e-02f, -5.78001216e-02f, -3.84481400e-02f, 3.30922827e-02f, 4.54050712e-02f, -2.34224973e-03f, -8.25631320e-02f,
  -4.72996756e-02f, -9.41447541e-03f, -5.41907996e-02f, -2.80344952e-02f, 5.21105826e-02f, -1.27973393e-01f, -6.01990297e-02f, 9.60256681e-02f, 7.71945193e-02f, -3.85278976e-03f,
  -8.43833610e-02f, 1.03393272e-01f, -3.27502154e-02f, -7.21634477e-02f, -3.26680839e-02f, -1.36169702e-01f, -2.14157049e-02f, -1.02586500e-01f, 4.46419604e-02f, -3.04647535e-02f,
  -7.32986107e-02f, -6.16944879e-02f, 6.74950480e-02f, 1.22554554e-02f, 1.58725288e-02f, -2.15097461e-02f, -1.41474474e-02f, -2.31710970e-02f, 6.98824152e-02f, 4.64608148e-02f,
  2.43047792e-02f, -6.62258873e-03f, 7.93195516e-02f, 3.46464701e-02f, -2.62337867e-02f, 1.06550686e-01f, -7.85694867e-02f, -6.42448217e-02f, -6.91676289e-02f, 9.31435497e-04f,
  -3.02624633e-03f, -9.90043283e-02f, -4.73042503e-02f, 2.34829821e-02f, -5.11706620e-02f, -4.72398549e-02f, -1.00745738e-01f, -5.55500165e-02f, -3.26710120e-02f, 3.53283994e-02f,
  -3.51057276e-02f, 5.96123599e-02f, -8.65869224e-03f, -4.11211625e-02f, 4.68439646e-02f, -2.57344060e-02f, 1.14313200e-01f, 2.51111370e-02f, 4.34293225e-02f, -3.96483354e-02f,
  7.90552273e-02f, 9.32315290e-02f, 5.48573956e-03f, -5.70128066e-03f, 1.99335776e-02f, 8.53305906e-02f, 1.17860146e-01f, -7.80105889e-02f, 1.01510949e-01f, 1.16565771e-01f,
  1.29939675e-01f, -1.52299419e-01f, -2.22012758e-01f, -1.41241208e-01f, -1.99268565e-01f, -2.76077688e-01f, -3.28316599e-01f, -1.36881322e-01f, -1.25649050e-01f, -8.40928853e-02f,
  -1.35291025e-01f, -3.07457726e-02f, 1.36960924e-01f, -2.59639740e-01f, 5.58094420e-02f, 2.77068973e-01f, -2.23217443e-01f, -7.28066489e-02f, -3.31103876e-02f, -2.79808808e-02f,
  -2.12757532e-02f, -1.68819502e-01f, -1.22302525e-01f, 6.98535750e-03f, -2.13670433e-01f, -7.01623112e-02f, -6.22126833e-02f, -1.91389188e-01f, -2.96028197e-01f, -1.79169938e-01f,
  -6.15345500e-02f, 3.69289443e-02f, -7.90274218e-02f, 4.41705249e-02f, -2.20067985e-02f, -1.83648244e-02f, -1.07210197e-01f, 2.44467007e-03f, -7.53144324e-02f, -3.49944010e-02f,
  1.24024905e-01f, 1.50079176e-01f, -1.14888197e-03f, -8.64476040e-02f, -4.33287919e-02f, -5.29398816e-03f, 6.40822724e-02f, -1.04551353e-01f, -1.76208578e-02f, -8.32575746e-03f,
  -4.50342819e-02f, -5.65390056e-03f, -1.25687569e-01f, 2.81280652e-02f, -3.22910361e-02f, -1.27942964e-01f, -1.19053265e-02f, -2.51399167e-02f, -1.39636518e-02f, 2.88188085e-02f,
  -4.33792779e-03f, 2.39002611e-02f, 4.16521132e-02f, -8.60256478e-02f, -4.46410179e-02f, -2.04368550e-02f, -7.06121102e-02f, 6.13121055e-02f, -7.80490488e-02f, 5.44735268e-02f,
  -4.44370732e-02f, 4.65100771e-03f, -7.65644573e-03f, -6.33938015e-02f, 2.49424763e-03f, 6.24416471e-02f, -5.38280196e-02f, -4.08393554e-02f, -6.62356392e-02f, -5.62044270e-02f,
  1.53444828e-02f, -2.39753490e-03f, -1.18574081e-02f, 4.47676517e-02f, -2.63232961e-02f, -5.14938543e-03f, -3.85210887e-02f, -6.33748574e-03f, -4.44214121e-02f, -8.32695514e-02f,
  -5.51329888e-02f, 3.08078006e-02f, 6.62303790e-02f, 2.03591119e-03f, 5.82980632e-04f, 5.25009818e-03f, -4.69477475e-02f, -3.45552899e-02f, -5.84174395e-02f, -6.10294715e-02f,
  -4.16073874e-02f, 4.50177044e-02f, 2.38326527e-02f, -9.84990969e-04f, -4.08247225e-02f, -1.36657199e-03f, -7.47992657e-03f, 9.48838741e-02f, -6.83994591e-02f, -4.17977013e-03f,
  2.74770148e-02f, -1.99221969e-02f, 1.20555475e-01f, 4.38417261e-03f, 6.73489124e-02f, 4.50754771e-03f, -1.41908387e-02f, -2.91908309e-02f, 4.30039801e-02f, -8.47946778e-02f,
  -8.60173168e-05f, 2.03507155e-01f, 1.46072116e-02f, 6.89298436e-02f, 4.96475324e-02f, 3.46803039e-01f, 1.59891978e-01f, 1.82341725e-01f, 2.28697538e-01f, 1.45362362e-01f,
  -1.73770264e-01f, -5.32623567e-02f, 1.12929400e-02f, -1.94029696e-03f, 1.61001116e-01f, 1.21865630e-01f, 9.41153467e-02f, -1.95676554e-02f, -8.32882151e-03f, -1.30921481e-02f,
  -1.44549698e-01f, -1.09527484e-01f, -9.96491238e-02f, -9.64234322e-02f, -2.36256540e-01f, -9.67876017e-02f, -2.80469477e-01f, -2.92861611e-02f, -1.45955503e-01f, -4.08820137e-02f,
  6.40598917e-03f, -1.33175671e-01f, -5.20869493e-02f, -2.25810278e-02f, 2.34130435e-02f, 1.79753527e-02f, 4.61266264e-02f, -1.81051996e-02f, -7.78235421e-02f, 1.69731770e-02f,
  -2.78934464e-02f, 9.42144319e-02f, 7.76922032e-02f, -4.24247887e-03f, -2.39232332e-02f, -4.27557342e-02f, 3.94596756e-02f, -1.19951159e-01f, -6.10640645e-02f, -7.59784505e-02f,
  -1.74415987e-02f, -3.41620093e-04f, -6.60077408e-02f, -7.52759166e-03f, -4.76459339e-02f, -1.65314432e-02f, 1.36184648e-01f, 1.68622360e-02f, 2.95390096e-02f, 5.88050373e-02f,
  1.64506845e-02f, 1.24660321e-01f, 1.69660654e-02f, 3.00751757e-02f, 4.69499975e-02f, 3.27350236e-02f, 6.98136166e-02f, -5.73616177e-02f, -7.43534556e-03f, -5.20686246e-03f,
  -5.89573272e-02f, 4.27931361e-02f, 3.02618369e-02f, 6.56693205e-02f, -5.90191595e-02f, -8.30020569e-03f, -8.01721662e-02f, 9.03365575e-03f, 3.36261541e-02f, 5.82705401e-02f,
  -4.26221043e-02f, 7.57352263e-02f, -2.93816184e-03f, -5.07555418e-02f, 7.37143084e-02f, -4.69440222e-02f, -2.69665588e-02f, -1.11888388e-04f, -1.05475128e-01f, 3.02105360e-02f,
  1.29586026e-01f, 2.90900648e-01f, -6.52765259e-02f, -8.59619156e-02f, 5.12707122e-02f, -4.11698185e-02f, 1.18162315e-02f, 2.01252406e-03f, 8.70937854e-02f, 7.73247629e-02f,
  2.35624108e-02f, -8.02257098e-03f, -3.63271907e-02f, -7.16297626e-02f, 6.37242422e-02f, 1.54085189e-01f, 2.99104415e-02f, -5.39058223e-02f, 1.61108077e-01f, -5.84405325e-02f,
  -5.22194915e-02f, 7.76447430e-02f, 7.20306952e-03f, -3.82036902e-02f, -1.42582171e-02f, -4.41355892e-02f, 9.12702531e-02f, -5.71091771e-02f, 2.99399775e-02f, 1.23374872e-01f,
  2.29965165e-01f, -3.85325819e-01f, -2.61025243e-02f, 2.44781256e-01f, 2.84529775e-01f, 1.08424827e-01f, -2.74521299e-02f, 2.57051528e-01f, 1.84538335e-01f, -3.12211484e-01f,
  -5.05691767e-02f, -3.34420621e-01f, -2.40351319e-01f, 1.63671196e-01f, 1.02659144e-01f, -1.12167500e-01f, 1.51240692e-01f, -1.01019435e-01f, 7.70200044e-03f, -7.41276443e-02f,
  1.61399335e-01f, 1.96725368e-01f, 4.18311544e-02f, 7.72713199e-02f, 1.00409411e-01f, -7.72633031e-02f, -8.58689547e-02f, -1.93512097e-01f, -4.66796197e-02f, 2.54214872e-02f,
  1.30150169e-01f, 1.29355891e-02f, -8.23220331e-03f, 3.55269127e-02f, 8.60759988e-02f, 3.05507910e-02f, -1.13931827e-01f, -5.17045856e-02f, 6.31600246e-02f, -2.50360556e-02f,
  -1.44525632e-01f, 2.66533438e-02f, 5.71845621e-02f, -1.16626071e-02f, 5.67578562e-02f, 5.99756278e-02f, 4.51162979e-02f, 2.87688593e-03f, -1.15491837e-01f, -4.96985279e-02f,
  1.71327535e-02f, -4.41346243e-02f, 3.74076143e-02f, -5.19335233e-02f, 3.99973653e-02f, -1.62272826e-02f, -7.09783062e-02f, -1.21180288e-01f, -7.85729010e-03f, 1.94903687e-02f,
  -8.85012671e-02f, -1.72777083e-02f, 5.48883667e-03f, -2.44357157e-02f, 9.51929539e-02f, 6.24607131e-02f, -3.37312035e-02f, -5.13967089e-02f, -1.01081818e-01f, 1.40898693e-02f,
  9.73818004e-02f, -1.09881721e-02f, 6.90685511e-02f, 7.34458715e-02f, 4.06635925e-02f, 2.78879851e-02f, 2.44631935e-02f, 9.09320451e-03f, 6.37859777e-02f, 8.84248614e-02f,
  -2.15886850e-02f, 6.95443451e-02f, 2.35038847e-02f, -6.34763613e-02f, -4.24249656e-02f, 4.18363623e-02f, -2.59339977e-02f, -3.21691595e-02f, 2.15758719e-02f, -1.41850477e-02f,
  1.74867874e-03f, -2.73553491e-01f, 2.03000922e-02f, 8.41019824e-02f, -7.29774162e-02f, 3.10911145e-02f, -4.31915298e-02f, 7.20958859e-02f, -9.27112624e-02f, 8.79072919e-02f,
  7.13622347e-02f, -2.05133185e-02f, -4.32319231e-02f, 3.51211382e-03f, 1.69826467e-02f, 8.28322172e-02f, -8.25914368e-02f, -2.71508116e-02f, 2.28312872e-02f, -9.06350650e-03f,
  -2.18780804e-02f, 3.46925184e-02f, -5.81073277e-02f, 9.58975628e-02f, 1.54205011e-02f, -1.60637438e-01f, 2.90968437e-02f, 8.12371448e-03f, -9.61968377e-02f, -6.46830499e-02f,
  -1.97287008e-01f, 2.79283132e-02f, -3.02669615e-01f, -8.82479101e-02f, -2.99645424e-01f, -2.63916880e-01f, 4.73034978e-02f, -2.26625443e-01f, 1.09677784e-01f, 3.28924209e-01f,
  9.76107717e-02f, -1.90841162e-03f, 2.98693657e-01f, 1.87068023e-02f, -2.85793662e-01f, 3.47310632e-01f, -3.23160030e-02f, 1.97875187e-01f, 8.84555355e-02f, -1.50750279e-01f,
  -6.91062286e-02f, 1.37006998e-01f, -1.43527165e-01f, 5.97381927e-02f, -2.86190540e-01f, -9.06898826e-02f, 7.70591125e-02f, -2.10362405e-01f, -6.75937757e-02f, -1.46520942e-01f,
  -1.71715431e-02f, 1.46524265e-01f, -7.87739307e-02f, 7.04474747e-02f, -1.11202501e-01f, -2.73177382e-02f, -2.23365929e-02f, -7.70480782e-02f, 1.77594144e-02f, 6.80147633e-02f,
  2.65967175e-02f, 8.31428021e-02f, 1.17187269e-01f, 8.12852830e-02f, -6.27948120e-02f, -5.59598468e-02f, 4.27623019e-02f, -2.08835807e-02f, -3.52622159e-02f, -2.27982067e-02f,
  -1.38282835e-01f, -5.36600202e-02f, -4.06832900e-03f, 1.03116825e-01f, -9.50722620e-02f, 8.99407119e-02f, -1.02542169e-01f, -1.89718362e-02f, 4.08273563e-02f, 5.80996834e-02f,
  -7.42288604e-02f, 2.49459445e-02f, -9.23538767e-03f, 1.41426437e-02f, -6.98338868e-03f, 2.23493241e-02f, -5.06621152e-02f, -3.54234055e-02f, -8.92254058e-04f, 7.36322477e-02f,
  4.43467721e-02f, 1.32871736e-02f, -2.16477942e-02f, 8.77494514e-02f, -2.95223459e-03f, -1.69462152e-02f, 1.40564479e-02f, 4.56140600e-02f, -5.49517907e-02f, 1.76300686e-02f,
  1.22882806e-01f, 8.24924186e-02f, 3.23350430e-02f, 1.95295718e-02f, 1.42536592e-02f, -7.37457955e-03f, -5.27507663e-02f, 2.68332865e-02f, 4.38123047e-02f, -4.03946452e-02f,
  -3.51602733e-02f, -2.29673320e-03f, 7.86430240e-02f, 7.93856233e-02f, 4.72230278e-02f, -1.41465232e-01f, -2.16449872e-02f, -5.36966808e-02f, 5.95749877e-02f, -9.82837081e-02f,
  5.75296432e-02f, 9.45684221e-03f, -3.43631394e-02f, -3.77862453e-02f, -3.78134921e-02f, -5.26507199e-02f, 1.61563084e-02f, 6.01612441e-02f, 1.20187933e-02f, -1.76900983e-01f,
  -1.69008449e-02f, 6.05869964e-02f, 1.09864093e-01f, 3.05570709e-03f, 5.15013300e-02f, 2.66674440e-02f, -1.06936999e-01f, -7.79513046e-02f, -1.00008868e-01f, 6.40266538e-02f,
  3.06847692e-01f, -1.51487812e-01f, -8.81240964e-02f, 7.78224692e-02f, 4.00173627e-02f, 1.67106912e-01f, -2.58293059e-02f, -1.52337119e-01f, -2.40056768e-01f, -3.08950134e-02f,
  -3.52521278e-02f, 5.83838448e-02f, -2.49937773e-01f, 2.08251655e-01f, -3.62185091e-02f, -1.49733350e-01f, 1.31228995e-02f, 3.08652781e-02f, -1.02319039e-01f, -1.57326072e-01f,
  -1.02170035e-01f, 1.19503681e-02f, -6.05012104e-02f, 1.93100888e-03f, 2.42744386e-01f, 1.72028858e-02f, -5.23803718e-02f, 6.60270825e-02f, 9.86378267e-02f, 2.44618773e-01f,
  9.95665938e-02f, -1.66261867e-02f, 3.03511899e-02f, 7.61288553e-02f, -5.51882610e-02f, 1.28059551e-01f, 7.40542784e-02f, 1.35810256e-01f, -1.04890071e-01f, -1.46841690e-01f,
  1.42445654e-01f, 8.40473995e-02f, 7.12139159e-02f, -7.36032054e-02f, 5.32666147e-02f, -8.43555406e-02f, -1.16861373e-01f, -5.66346124e-02f, -1.61593065e-01f, -6.02716058e-02f,
  -4.63067647e-03f, 1.05830714e-01f, 2.61366833e-03f, 1.31697729e-02f, -4.40060347e-02f, -1.28426068e-02f, -4.78921384e-02f, -4.52743173e-02f, -8.30061808e-02f, -1.48123605e-02f,
  1.53496573e-02f, 1.16146132e-01f, 7.23614171e-03f, 2.99140215e-02f, -2.14684010e-02f, 4.74585816e-02f, -7.74238110e-02f, -1.19459160e-01f, 4.84356396e-02f, -5.86471427e-03f,
  -1.24533713e-01f, -6.31706044e-03f, -4.89445813e-02f, 8.68652090e-02f, 1.35697380e-01f, 1.29921604e-02f, -2.15763245e-02f, -6.04843572e-02f, -2.33340655e-02f, 5.33427708e-02f,
  1.40587445e-02f, -2.49822158e-02f, -4.44465727e-02f, -4.69602980e-02f, 3.25833037e-02f, 4.19672802e-02f, 2.05693115e-02f, 7.64385536e-02f, -4.87170294e-02f, -3.36812586e-02f,
  3.22733261e-02f, -2.05123812e-01f, -1.22993410e-01f, -3.44336852e-02f, -5.29784262e-02f, 2.31629983e-02f, 8.95502716e-02f, -1.95325017e-02f, -2.21562646e-02f, -4.77390699e-02f,
  1.10252343e-01f, 5.31385094e-02f, 6.30223528e-02f, 3.22844982e-02f, 3.22314203e-02f, -1.03829756e-01f, -1.10338710e-01f, -5.62522002e-02f, -3.97355780e-02f, 9.90741700e-03f,
  3.55944820e-02f, 3.41467410e-02f, 1.38908058e-01f, -3.23873051e-02f, 4.81711887e-02f, -1.26275066e-02f, 7.62859508e-02f, -1.41249364e-02f, -8.82442221e-02f, 6.05583899e-02f,
  2.91897744e-01f, 2.75128782e-01f, 1.78220183e-01f, 3.43822718e-01f, -1.27723679e-01f, 1.80665664e-02f, -4.24006954e-02f, 3.49501260e-02f, 3.03477198e-01f, -1.52220884e-02f,
  -2.95265168e-01f, 3.14810842e-01f, -2.39515707e-01f, 1.95948005e-01f, -3.12120169e-01f, -1.74457934e-02f, 3.80824842e-02f, 1.02956429e-01f, 6.07057512e-02f, 4.02666908e-03f,
  1.41730338e-01f, -2.71019697e-01f, -1.58109397e-01f, -4.80575450e-02f, 5.45589216e-02f, 1.94226280e-01f, -3.42904121e-01f, -2.02465922e-01f, -5.22897299e-03f, -9.51552913e-02f,
  2.46968679e-02f, 1.18805192e-01f, 6.44232333e-02f, -4.11668941e-02f, 2.60925312e-02f, -1.13701396e-01f, -3.97407971e-02f, -1.47417620e-01f, -1.80781603e-01f, 2.60498263e-02f,
  8.39617774e-02f, -6.59229755e-02f, 9.26463753e-02f, -3.00109219e-02f, -2.52294056e-02f, 1.44747257e-01f, 1.52517959e-01f, 1.21364281e-01f, 6.37798291e-03f, 1.54916599e-01f,
  1.57558054e-01f, 1.59843013e-01f, -6.00666776e-02f, -8.02487284e-02f, -5.30164316e-02f, -8.40414986e-02f, 2.59331409e-02f, -3.93394418e-02f, 8.94983336e-02f, 1.43677797e-02f,
  8.07590112e-02f, -4.23386283e-02f, -1.69520304e-01f, 3.69844656e-03f, -8.02426506e-03f, -3.16468626e-02f, 1.18413806e-01f, -2.76560187e-02f, 8.48177448e-02f, -7.89469630e-02f,
  -7.27615133e-02f, 1.03327921e-02f, 1.14805512e-01f, 8.73367786e-02f, -2.75499038e-02f, 4.35348302e-02f, -9.56605002e-02f, 2.80558062e-03f, 1.18779331e-01f, -1.27487615e-01f,
  -1.22407690e-01f, -1.23727195e-01f, 8.09000507e-02f, 3.81389111e-02f, -1.43174648e-01f, 3.65754105e-02f, 1.13841169e-01f, 7.54862428e-02f, -1.20357461e-02f, -7.45090023e-02f,
  -2.91233569e-01f, -2.65728056e-01f, -3.64076458e-02f, 2.98225116e-02f, 1.65217835e-02f, -5.45914173e-02f, 3.76315303e-02f, 2.52194330e-02f, -2.07568899e-01f, 4.67564687e-02f,
  6.70903027e-02f, 4.36942615e-02f, 4.02557626e-02f, 3.76322959e-03f, 4.94957063e-03f, -1.24038897e-01f, -1.17797494e-01f, -1.10915214e-01f, -2.03010559e-01f, 1.47765595e-02f,
  8.25476572e-02f, -6.77599460e-02f, -4.20285612e-02f, 2.59695835e-02f, -1.47456154e-01f, -5.17616160e-02f, 8.73224959e-02f, 4.85498495e-02f, -1.03501655e-01f, -3.26858200e-02f,
  -4.06158656e-01f, 1.78739980e-01f, 3.05089891e-01f, -2.51746505e-01f, 2.05833033e-01f, 3.47539961e-01f, 7.43921697e-02f, 7.50835985e-02f, -1.34434476e-02f, -1.26582935e-01f,
  -1.13708772e-01f, -1.55893946e-02f, 1.72106370e-01f, -1.06883459e-01f, 5.39686121e-02f, 7.15437755e-02f, -1.09369792e-01f, -1.05245769e-01f, 7.65990689e-02f, -7.00474754e-02f,
  5.52011840e-02f, -1.01878352e-01f, 1.49829865e-01f, 1.23684011e-01f, 1.40800148e-01f, -1.48865148e-01f, -1.85342699e-01f, 9.85216051e-02f, 8.18870962e-03f, 6.44446388e-02f,
  -2.57508963e-01f, -2.30661705e-01f, -1.67332977e-01f, -9.97978747e-02f, -1.08441673e-01f, -6.07669577e-02f, -1.15555406e-01f, -4.91546243e-02f, -1.34143651e-01f, 4.74356627e-03f,
  -6.31173179e-02f, -2.99769025e-02f, -2.58308090e-03f, -7.90084898e-02f, -2.21642554e-02f, -5.41921966e-02f, 1.48309782e-01f, 1.80088773e-01f, 6.48815855e-02f, 1.25089020e-01f,
  4.69953753e-02f, 1.78425573e-02f, 8.03762116e-03f, -2.76657138e-02f, 4.49878238e-02f, 2.13268064e-02f, 4.26305532e-02f, 8.22608545e-02f, 1.53994873e-01f, -6.38863677e-03f,
  4.12537456e-02f, -2.46210471e-02f, 1.14075340e-01f, -8.55466872e-02f, 3.53568308e-02f, -3.24352682e-02f, -1.03814252e-01f, -9.10089090e-02f, 1.20465532e-01f, 3.42026800e-02f,
  -6.07727915e-02f, 4.24351543e-02f, -3.38073000e-02f, -9.66354832e-03f, 4.70352583e-02f, -6.65711612e-03f, -7.87054747e-02f, -7.04673911e-03f, -2.83329785e-02f, -1.99255906e-02f,
  -1.25476047e-01f, -1.16318807e-01f, 1.05882354e-01f, -1.67961500e-03f, 1.32323084e-02f, -1.38457650e-02f, -7.35419467e-02f, 8.61295499e-03f, 1.25860814e-02f, 1.31351233e-01f,
  -4.64895874e-01f, -2.93334544e-01f, -1.83940232e-01f, -1.61302045e-01f, -1.41529575e-01f, 5.04620187e-02f, -8.33720714e-02f, -2.76467353e-02f, -1.92233771e-02f, -3.44858225e-03f,
  8.80711675e-02f, 5.93122505e-02f, -4.95153666e-02f, -8.18100795e-02f, 1.01047061e-01f, -2.75824796e-02f, -1.11612633e-01f, -2.03879587e-02f, -7.98746720e-02f, -3.91759574e-02f,
  7.29454160e-02f, -1.04494214e-01f, -9.21581313e-03f, -2.25715823e-02f, -6.69770986e-02f, -4.93084230e-02f, 9.10539404e-02f, -1.14181481e-01f, -4.98527959e-02f, -2.43356247e-02f,
  -4.48968261e-01f, 1.53097615e-01f, -1.19286455e-01f, 3.50674748e-01f, -2.50762373e-01f, -2.10259601e-01f, 1.61435455e-01f, -1.88647117e-02f, 1.73590370e-02f, 2.71826446e-01f,
  2.95595378e-01f, -1.59236386e-01f, 2.79932264e-02f, 3.72747302e-01f, 4.73529287e-02f, 1.83648080e-01f, 2.93823153e-01f, 2.41767287e-01f, 8.36868957e-03f, -7.73940980e-02f,
  -2.94373613e-02f, 2.18586221e-01f, 2.99462348e-01f, 1.57877691e-02f, -1.40043437e-01f, -2.45911516e-02f, 3.03818285e-01f, -1.81003824e-01f, 1.99354589e-01f, 7.65564293e-02f,
  -1.20461404e-01f, -3.58484238e-02f, -3.98973934e-02f, -1.17372245e-01f, -1.10993288e-01f, -7.03817382e-02f, -1.32859692e-01f, 5.18131489e-03f, -5.64897107e-03f, 8.70989694e-04f,
  -1.16900757e-01f, -5.99651299e-02f, 8.46370906e-02f, 1.11122718e-02f, -1.30076081e-01f, -3.59962806e-02f, 3.48226242e-02f, 4.77158837e-02f, -3.27919447e-03f, -8.98533240e-02f,
  1.05185118e-02f, 8.17203987e-03f, 8.32876936e-02f, 1.53504148e-01f, 4.86583412e-02f, 6.04486205e-02f, 9.84101146e-02f, -8.76024589e-02f, -1.37240975e-03f, -1.99605227e-02f,
  -3.06100696e-02f, 6.31499439e-02f, -6.85666502e-02f, 6.25178963e-02f, 2.66077034e-02f, -5.15816472e-02f, 5.91080189e-02f, 9.47174281e-02f, 3.43070328e-02f, 1.88724883e-02f,
  5.37966602e-02f, 1.64947379e-02f, -4.98628505e-02f, 2.22543497e-02f, 5.11734821e-02f, 2.76461765e-02f, -1.06549516e-01f, -6.88604787e-02f, -4.93380688e-02f, 4.41727526e-02f,
  3.56631875e-02f, -6.11185431e-02f, 1.07654370e-02f, 5.88340610e-02f, -4.69566286e-02f, -2.08592303e-02f, 1.12157725e-01f, -6.76905457e-03f, 3.25436033e-02f, -2.36859899e-02f,
  -5.59575520e-02f, 6.63957074e-02f, 4.71815802e-02f, -3.60718854e-02f, 5.73847964e-02f, -3.35660204e-02f, 1.89611744e-02f, 1.64876524e-02f, 3.31351608e-02f, -6.56644404e-02f,
  -1.38373643e-01f, -2.72779725e-03f, -6.31400710e-03f, -1.44713493e-02f, 5.74546009e-02f, 1.59465253e-05f, 5.68494983e-02f, 3.00340774e-03f, 4.78947498e-02f, -2.11072881e-02f,
  9.05862302e-02f, 6.84752269e-03f, -1.74609832e-02f, -1.32876902e-03f, 1.18355043e-01f, 6.80247247e-02f, -1.81246344e-02f, -2.86807604e-02f, -7.62088597e-02f, 6.31072745e-02f,
  -1.48075536e-01f, 2.16280639e-01f, 2.44870827e-01f, 2.02905282e-01f, -1.55292273e-01f, -2.96694547e-01f, -3.61147314e-01f, 7.69479275e-02f, -6.20472990e-02f, -2.65013874e-01f,
  -1.01408949e-02f, -6.00491911e-02f, 1.89748555e-02f, 1.21778622e-01f, 2.15988681e-01f, 1.81665972e-01f, 1.72187671e-01f, -1.26960292e-01f, 9.33612064e-02f, 1.40903845e-01f,
  3.08376312e-01f, 2.12162390e-01f, 1.97908416e-01f, 2.05262005e-01f, 1.61318555e-01f, 2.23193333e-01f, 2.41712049e-01f, 2.04773605e-01f, 1.22494131e-01f, 2.78808568e-02f,
  -4.90871258e-02f, 1.29699424e-01f, 4.89047393e-02f, 6.63427040e-02f, 8.65315497e-02f, -1.96799546e-01f, -3.17537971e-02f, -1.92551315e-02f, -4.72259186e-02f, -1.20872771e-02f,
  -3.83395925e-02f, 1.76049508e-02f, 7.17342570e-02f, -4.40708809e-02f, -1.19101696e-01f, -3.40372208e-03f, 7.69652948e-02f, 2.24817265e-02f, -5.57197770e-03f, 4.29794949e-04f,
  9.70978960e-02f, 7.78271556e-02f, 1.14372149e-02f, 2.09646747e-02f, 3.94053608e-02f, 6.97477348e-03f, -1.04221471e-01f, 6.05749665e-04f, 3.55902314e-02f, -5.16293719e-02f,
  1.06998291e-02f, -3.64545211e-02f, -6.77135512e-02f, -2.75143348e-02f, -6.55429065e-02f, -1.52983880e-02f, -2.99179498e-02f, -9.59935784e-02f, 8.41334183e-03f, 6.01111874e-02f,
  7.62503641e-03f, 5.03448509e-02f, -6.95005134e-02f, -8.23449269e-02f, -1.88446287e-02f, -7.41530806e-02f, 7.65632093e-02f, 2.42431480e-02f, 9.19617340e-02f, 8.64706859e-02f,
  -5.05067334e-02f, -5.62487319e-02f, -1.15472106e-02f, 2.96001006e-02f, -1.43923044e-01f, 4.75446954e-02f, 7.65076205e-02f, -1.05101634e-02f, 5.00375070e-02f, 1.51327580e-01f,
  6.90547824e-02f, 3.10336769e-01f, 3.32680009e-02f, -1.29823387e-01f, 3.45392264e-02f, -3.14472765e-02f, 1.09003268e-01f, -3.46328132e-02f, 1.40357971e-01f, 4.49753068e-02f,
  3.03930789e-03f, -4.71371301e-02f, -3.49131674e-02f, -8.15831795e-02f, 4.23909277e-02f, 9.05488338e-03f, -1.72272287e-02f, 1.80530176e-02f, 1.21188641e-01f, 1.97256505e-02f,
  -3.76602262e-02f, -1.47422552e-01f, -4.09842059e-02f, 4.28121574e-02f, 7.54507817e-03f, 6.94011664e-03f, -7.91633502e-02f, 1.32432161e-02f, 3.75863910e-02f, 7.11197928e-02f,
  1.31572396e-01f, -8.92633293e-03f, -1.85575113e-02f, -8.78892466e-02f, 1.76168084e-01f, 2.71920711e-01f, 3.46856654e-01f, -1.42868325e-01f, -2.60748595e-01f, 1.34790838e-01f,
  2.14509442e-01f, -2.26466521e-03f, 2.00540885e-01f, 1.43687904e-01f, 2.24402219e-01f, 8.80186819e-03f, 1.52472332e-01f, 1.23939440e-01f, -2.38054842e-01f, 1.50127662e-02f,
  -1.09965943e-01f, 2.06982270e-01f, -1.02009391e-02f, -8.22930038e-02f, 1.55985713e-01f, -3.09478343e-01f, 8.67498294e-02f, -2.11241208e-02f, -6.00961000e-02f, 2.20580727e-01f,
  9.38162729e-02f, -1.36744022e-01f, 2.40554325e-02f, -5.62964799e-03f, -3.00581865e-02f, 1.18721230e-02f, 9.37652737e-02f, 3.88840958e-02f, -8.28554556e-02f, -6.84091747e-02f,
  -5.04471250e-02f, 3.91330421e-02f, -4.98232581e-02f, -7.48972595e-02f, -1.10038944e-01f, -1.07504316e-01f, 7.17493379e-03f, 2.53080018e-02f, -1.44432783e-01f, 9.77458805e-02f,
  7.80361984e-03f, -6.86257482e-02f, -4.80598398e-02f, -7.14853266e-03f, -5.63197024e-02f, -4.76261191e-02f, -8.15742686e-02f, -4.04476188e-02f, -1.38371615e-02f, -1.68130919e-02f,
  -2.28003953e-02f, 3.62749062e-02f, 3.47351506e-02f, 1.87363680e-02f, 4.18297835e-02f, 6.74176542e-03f, -4.60151769e-02f, -5.77544235e-02f, -6.28087223e-02f, 5.31116612e-02f,
  -9.09350365e-02f, -4.33690399e-02f, 7.46957734e-02f, 8.15008953e-02f, 3.29503529e-02f, -3.74720842e-02f, -4.46554311e-02f, 2.79768631e-02f, -4.80722357e-03f, -9.31748971e-02f,
  3.45360488e-02f, -1.23553120e-01f, 4.48953770e-02f, -6.44857138e-02f, 5.48803061e-02f, 6.52517304e-02f, -8.75829719e-03f, 2.02291086e-03f, -3.61967906e-02f, 1.29696414e-01f,
  3.22809070e-02f, 4.42059003e-02f, 1.85462516e-02f, 5.51385619e-02f, -7.00252736e-03f, -9.86182969e-03f, -3.66921201e-02f, -1.04782954e-02f, -6.20520264e-02f, -2.98410025e-03f,
  -4.50657681e-02f, -4.80654240e-02f, -3.48230228e-02f, -4.92529981e-02f, 2.11215615e-02f, 8.60630423e-02f, -2.32553836e-02f, -1.26391247e-01f, 5.78509420e-02f, 2.33408734e-02f,
  2.70074084e-02f, -2.70122532e-02f, 5.99037856e-02f, -1.26334447e-02f, -3.92134972e-02f, 5.38292192e-02f, -3.70235555e-02f, -7.26193562e-02f, -4.28892076e-02f, -4.29391898e-02f,
  -3.50169301e-01f, 4.04660553e-01f, -7.49063492e-02f, -4.54601320e-03f, 3.45770805e-03f, -3.99225324e-01f, -1.31470203e-01f, 4.04461697e-02f, -1.08711310e-01f, 2.28808388e-01f,
  -8.68471116e-02f, 3.17805737e-01f, -1.42007777e-02f, -1.46007210e-01f, -4.69933033e-01f, -2.18155429e-01f, -2.95408875e-01f, -4.02460694e-02f, 2.15682648e-02f, -3.67552564e-02f,
  -1.04376122e-01f, -1.34393886e-01f, -1.66898847e-01f, 8.05723816e-02f, 1.41821504e-01f, 1.22979730e-01f, -6.76186383e-02f, 8.20212662e-02f, -9.44347307e-03f, -4.35184501e-02f,
  -1.33607179e-01f, 1.47288114e-01f, 1.24859825e-01f, -4.37664427e-02f, -1.14703156e-01f, 1.01986192e-02f, 4.59402129e-02f, 3.72614712e-02f, -5.14656790e-02f, -9.09782029e-05f,
  9.64874178e-02f, 3.85597572e-02f, 3.47678214e-02f, 6.97823018e-02f, -8.96155741e-03f, 7.42427036e-02f, -4.49435450e-02f, 5.28036663e-03f, 3.43255363e-02f, 9.09014866e-02f,
  -2.27141362e-02f, -1.64598599e-02f, -6.90998808e-02f, -5.53991124e-02f, 3.02095078e-02f, -1.69115867e-02f, -5.63822724e-02f, 6.01859055e-02f, 8.94072000e-03f, -3.88099290e-02f,
  9.17226374e-02f, -9.48479399e-03f, 4.08762954e-02f, 3.39365676e-02f, -2.49632429e-02f, 5.01659364e-02f, -9.12242532e-02f, -3.53068709e-02f, -3.29919308e-02f, 4.23560366e-02f,
  -4.51450720e-02f, 4.51786481e-02f, -4.20103408e-02f, -4.45037149e-02f, 3.06927431e-02f, -2.34480947e-02f, -1.45911565e-02f, -2.51154732e-02f, -7.70618543e-02f, -8.42241719e-02f,
  7.65607059e-02f, -6.73179626e-02f, -3.08117326e-02f, -8.02792236e-02f, 2.61272285e-02f, -1.33299455e-02f, 6.93730451e-03f, -1.87138785e-02f, 3.28325294e-02f, -1.15656089e-02f,
  -1.85423747e-01f, 1.12125725e-01f, 2.23573251e-03f, -2.83207069e-03f, 2.14427076e-02f, -2.64135860e-02f, -3.56697068e-02f, -2.97779962e-02f, -2.59963814e-02f, -5.78220338e-02f,
  2.66586822e-02f, 2.82578841e-02f, -4.72574867e-03f, -9.68545154e-02f, 1.64839365e-02f, -3.39609347e-02f, 9.93534550e-03f, -1.97606385e-02f, 3.29292975e-02f, 5.57477400e-03f,
  1.07904062e-01f, 7.88798854e-02f, 3.46077830e-02f, -4.29716855e-02f, -6.02919608e-02f, 4.64415140e-02f, -1.52030429e-02f, 1.06264062e-01f, -3.06464639e-02f, 7.26845935e-02f,
  3.16395342e-01f, 1.73591152e-01f, 1.88912779e-01f, 8.01883042e-02f, -1.87454537e-01f, -2.39813030e-01f, -1.56219006e-01f, 9.84715819e-02f, -5.47691062e-02f, 3.50951180e-02f,
  -9.47349146e-02f, 1.62864730e-01f, -1.24171592e-01f, 1.11257002e-01f, -2.12753311e-01f, -7.29923546e-02f, -1.17240325e-02f, 7.89051354e-02f, -2.93994434e-02f, 1.26702055e-01f,
  4.89022434e-02f, -1.87951386e-01f, 3.72838415e-02f, -1.74552090e-02f, 1.17772765e-01f, 1.82386696e-01f, 5.76607930e-03f, -7.61546716e-02f, 2.36356929e-01f, -8.06504562e-02f,
  4.86658067e-02f, 7.81588927e-02f, 1.13069333e-01f, 4.35792878e-02f, 9.48697701e-02f, 9.23264921e-02f, 9.18490738e-02f, 1.32132024e-02f, -3.26173306e-02f, 1.38593167e-01f,
  5.38959391e-02f, 5.50254583e-02f, 1.33662656e-01f, -3.00141890e-02f, 8.82274508e-02f, 1.22235902e-01f, -3.56226950e-03f, 3.97827104e-03f, -2.36034226e-02f, 7.94379134e-03f,
  5.00608459e-02f, 1.75380912e-02f, 1.18493170e-01f, -3.68135124e-02f, -1.74963810e-02f, 9.28699679e-04f, 2.32046470e-02f, 1.42462701e-01f, 1.37369812e-01f, -2.70482320e-02f,
  9.94378999e-02f, -5.79645392e-03f, 5.34915887e-02f, -7.70922601e-02f, -8.47937353e-03f, -4.71777730e-02f, -3.03789731e-02f, -7.79060693e-03f, -8.19460955e-04f, -1.77617725e-02f,
  -3.35975476e-02f, 3.72513011e-02f, -5.21177351e-02f, 5.44306636e-02f, -2.60109007e-02f, 7.00117499e-02f, -1.45719703e-02f, 4.13319319e-02f, -3.47005315e-02f, -2.22068951e-02f,
  -6.12972479e-04f, -3.72270457e-02f, -9.20462012e-02f, -6.89578429e-02f, -9.41615179e-02f, -3.49604413e-02f, 1.24206334e-01f, 3.82758118e-02f, -8.81360918e-02f, -6.25497550e-02f,
  -1.63466111e-02f, 7.99205750e-02f, -3.30333523e-02f, 2.48025428e-03f, 1.23325894e-02f, 1.31534144e-01f, -6.21736012e-02f, 1.25765815e-01f, -3.67609411e-02f, -2.69102817e-03f,
  5.67293391e-02f, -1.15737215e-01f, 5.06501237e-04f, 1.10604689e-01f, -6.54072016e-02f, 3.01174484e-02f, 7.01721162e-02f, -9.74755436e-02f, 3.99762057e-02f, 1.62252188e-01f,
  3.58077027e-02f, -2.12608883e-03f, 6.99808225e-02f, -7.08421841e-02f, 2.66636536e-02f, -2.17009932e-02f, -5.97246513e-02f, -3.56500261e-02f, 7.23898225e-03f, -3.97297591e-02f,
  1.74248934e-01f, -1.65706113e-01f, -6.60095215e-02f, -1.32322237e-02f, 8.82354379e-02f, -2.83430964e-02f, -7.51214847e-02f, -5.62629253e-02f, -2.29052484e-01f, -3.79890651e-02f,
  -1.24333270e-01f, 8.43448117e-02f, -2.76954502e-01f, 8.60347040e-03f, -1.58922479e-01f, -2.56638408e-01f, 3.16923968e-02f, -4.08356898e-02f, -2.35770211e-01f, -2.14978650e-01f,
  -1.36934787e-01f, -1.22099482e-01f, -1.53779209e-01f, 8.83926079e-02f, 2.71286368e-01f, 1.70242593e-01f, 1.71628371e-01f, 1.24398239e-01f, 1.87312439e-01f, 1.28624886e-01f,
  9.22367647e-02f, -2.25091457e-01f, 2.23190412e-02f, 5.78307323e-02f, 1.74163226e-02f, 1.34034321e-01f, 1.91542417e-01f, -1.54007133e-02f, -3.89647521e-02f, -9.75511223e-02f,
  8.60995278e-02f, 2.16943603e-02f, 2.27733422e-02f, 1.13438061e-02f, 1.14947736e-01f, 2.76609361e-02f, 9.41168070e-02f, 7.22221732e-02f, 7.51769841e-02f, -4.16228995e-02f,
  -8.48628283e-02f, 5.43398783e-02f, 3.97040136e-02f, 1.55890226e-01f, -4.29085083e-03f, -2.94337906e-02f, 1.11742012e-01f, -1.74122991e-03f, 1.52722239e-01f, -8.30628723e-02f,
  -3.80491391e-02f, 5.29503562e-02f, -9.02675465e-02f, 3.12728286e-02f, -1.96169820e-02f, -7.92551115e-02f, -6.38770834e-02f, -1.61834471e-02f, 1.75630953e-02f, -6.59063980e-02f,
  7.17270672e-02f, -4.82863700e-03f, -2.48418618e-02f, 9.49135721e-02f, 3.71682160e-02f, 2.01727804e-02f, 4.93431427e-02f, 9.25095528e-02f, -5.16656935e-02f, 5.12624420e-02f,
  3.27620213e-03f, 1.24789029e-01f, 2.53128298e-02f, 8.20399970e-02f, -6.93342909e-02f, 3.06503810e-02f, 3.22891697e-02f, 2.27149203e-02f, 6.21930510e-02f, 7.02900812e-02f,
  -3.38715799e-02f, -9.72425193e-02f, -1.59458399e-01f, -3.68635505e-02f, -1.18405886e-01f, 6.50347620e-02f, 3.69726717e-02f, 1.43045336e-02f, 3.77269797e-02f, -1.19307227e-02f,
  1.35033339e-01f, 9.77096260e-02f, 8.55269581e-02f, 9.55114737e-02f, 3.19310427e-02f, -1.03309967e-01f, 7.36751929e-02f, 2.79093292e-02f, 1.39308825e-01f, 5.59286550e-02f,
  8.05120543e-02f, 2.54983641e-02f, 1.76171958e-01f, 1.27811404e-02f, -5.26060127e-02f, -8.57075378e-02f, 6.55977204e-02f, 1.53850289e-02f, 4.43744026e-02f, 9.97328013e-02f,
  -4.29896921e-01f, 1.12118401e-01f, 3.01167697e-01f, -3.22570473e-01f, 6.94488287e-02f, 2.81471640e-01f, -6.21222258e-02f, 9.04160216e-02f, -1.87085822e-01f, -7.92290494e-02f,
  1.29149784e-03f, -9.00915712e-02f, 1.71581715e-01f, -1.52004883e-01f, 2.98095107e-01f, 2.03959689e-01f, -1.72069043e-01f, -1.58056557e-01f, 7.54778013e-02f, -1.11788996e-01f,
  -9.64499712e-02f, -1.50493905e-01f, 5.42075187e-02f, 1.50276031e-02f, -2.65718326e-02f, -1.28225461e-01f, -2.42288738e-01f, 6.94216490e-02f, -1.45090759e-01f, 3.95846143e-02f,
  9.70067978e-02f, -2.05439031e-01f, 7.62438700e-02f, 7.32964948e-02f, 7.77489915e-02f, 8.62213001e-02f, 3.05198859e-02f, -2.01605260e-04f, -3.70637327e-02f, -4.62207124e-02f,
  -7.35195652e-02f, 7.35290796e-02f, -1.23091809e-01f, 4.64111678e-02f, -7.65906647e-02f, 2.26490721e-02f, 1.70495827e-03f, 6.17012195e-02f, 7.76850283e-02f, 5.43269366e-02f,
  1.00582518e-01f, 2.61230711e-02f, -5.10203019e-02f, -6.50016293e-02f, -4.70318906e-02f, 1.27026793e-02f, -8.66800696e-02f, -1.36592640e-02f, -3.99829894e-02f, -9.42740068e-02f,
  -9.68832672e-02f, 4.27107215e-02f, 1.08691096e-01f, 3.07304263e-02f, 7.35186599e-03f, -7.57578760e-02f, -2.62812153e-02f, -4.68390249e-02f, -8.01251978e-02f, -7.66938403e-02f,
  -1.13817221e-02f, -7.54966438e-02f, -5.95924631e-02f, -6.94296807e-02f, -4.78452444e-02f, -1.45008238e-02f, 1.63285565e-02f, 4.47055586e-02f, -8.70404541e-02f, 2.96609327e-02f,
  -4.69279103e-02f, 1.23784998e-02f, -3.56468596e-02f, -5.88485226e-03f, 9.94647518e-02f, 4.08873819e-02f, -5.22869565e-02f, 9.48125422e-02f, 5.23719331e-03f, -5.77298626e-02f,
  1.51942912e-02f, -2.63798594e-01f, 3.97202782e-02f, 5.66594675e-02f, 3.72835621e-02f, -1.88388489e-02f, -1.51104955e-02f, 2.19086800e-02f, 8.75061657e-03f, -3.52062732e-02f,
  -3.92027721e-02f, -8.23727995e-02f, -3.35332453e-02f, 9.96065214e-02f, 4.41127419e-02f, -2.24864054e-02f, -1.34568855e-01f, -1.43359661e-01f, -9.38253850e-02f, 6.47457317e-02f,
  -4.77182195e-02f, -8.93428028e-02f, 4.75829393e-02f, -1.31823540e-01f, -4.48915213e-02f, -7.16701522e-02f, -2.23380439e-02f, 5.73846772e-02f, -1.07481796e-02f, 2.03922410e-02f,
  -4.25217658e-01f, 2.69179434e-01f, -2.39076152e-01f, -8.47478658e-02f, 3.44539732e-01f, -1.26095727e-01f, 3.88838127e-02f, -2.36394629e-02f, -2.08004396e-02f, 9.46877971e-02f,
  2.65388787e-01f, 2.00846437e-02f, -7.84264598e-03f, 1.42095298e-01f, -3.28635722e-01f, -3.71771492e-02f, -7.10603073e-02f, -5.13446629e-02f, -1.58171549e-01f, 4.16332968e-02f,
  -2.58473605e-01f, 1.85544029e-01f, -2.42566824e-01f, 1.59856528e-01f, 9.68652871e-03f, -1.99155733e-01f, 1.40903816e-01f, -3.46125029e-02f, -2.30050590e-02f, 1.82427540e-02f,
  6.14470243e-03f, -2.39931662e-02f, -6.41983598e-02f, -1.06417676e-02f, -1.09382585e-01f, -1.20699972e-01f, -6.90946281e-02f, -3.66979241e-02f, -1.02322616e-01f, -1.33655086e-01f,
  1.37571180e-02f, -2.75365766e-02f, 2.96721533e-02f, -2.22262293e-02f, 1.96042694e-02f, 3.37712392e-02f, -2.46358663e-02f, -4.29363735e-02f, -4.37470898e-02f, -1.20101437e-01f,
  2.38520503e-02f, -2.33039092e-02f, -6.50129467e-02f, -6.68849424e-02f, 2.61732340e-02f, -6.12548515e-02f, -8.06917027e-02f, -7.10000247e-02f, 3.58407125e-02f, 4.95460304e-03f,
  -3.35444473e-02f, -6.59249127e-02f, 5.44168800e-02f, 4.46911938e-02f, 9.95078534e-02f, 8.14483836e-02f, 3.85814719e-02f, 6.58666948e-03f, -1.03213631e-01f, 8.38578641e-02f,
  -3.68259773e-02f, 1.14223689e-01f, 2.44174991e-02f, -6.45603240e-02f, -1.19378217e-01f, -4.40450646e-02f, -9.00859106e-03f, -3.29383463e-02f, -1.40305264e-02f, 6.58618566e-03f,
  -7.50303045e-02f, 3.46043408e-02f, 5.89365996e-02f, 1.49924066e-02f, -3.48085389e-02f, -4.13128734e-02f, 3.74350548e-02f, 8.58486891e-02f, 5.07653356e-02f, -4.86155748e-02f,
  7.57416785e-02f, -8.78083259e-02f, 2.11879723e-02f, 1.01888247e-01f, 2.67235972e-02f, 3.88642959e-02f, -8.52936655e-02f, -8.85124691e-03f, -2.26135552e-02f, 6.79710209e-02f,
  -4.89322208e-02f, -7.83109888e-02f, -2.55597662e-03f, 6.62187412e-02f, 3.80416214e-02f, 1.16923019e-01f, 7.08198026e-02f, -6.89043477e-02f, 8.35702717e-02f, -5.13149425e-02f,
  5.22680283e-02f, 9.50109120e-03f, -9.58814286e-03f, 4.97542433e-02f, -4.90438379e-02f, 4.36189538e-03f, -4.97340411e-02f, 2.95932721e-02f, 4.45550010e-02f, 9.93027091e-02f,
  -2.07546100e-01f, -5.04305437e-02f, 1.12051003e-01f, 5.38017415e-02f, -3.09334517e-01f, 1.80578172e-01f, 3.10105622e-01f, -2.25431278e-01f, -1.87158436e-01f, 4.46226336e-02f,
  1.34306535e-01f, 1.15034871e-01f, 2.41948768e-01f, -1.29414359e-02f, 9.78165865e-02f, 2.52586424e-01f, 1.33234084e-01f, 8.25214982e-02f, -2.17473045e-01f, -2.83780620e-02f,
  -1.40581369e-01f, -1.70966163e-01f, 2.44962722e-01f, -3.16892892e-01f, 6.58068731e-02f, -1.31616607e-01f, -8.34831316e-03f, 5.74697256e-02f, -9.85991433e-02f, 4.85341437e-02f,
  -1.71610460e-01f, -2.72843838e-01f, 3.58424187e-02f, -1.09600909e-01f, -6.12959042e-02f, -5.24024526e-03f, 2.55698375e-02f, 1.03657186e-01f, -4.94282618e-02f, 4.19348367e-02f,
  7.54660368e-02f, -2.11079121e-01f, -1.31853640e-01f, 3.43427472e-02f, -1.49888977e-01f, -1.10397093e-01f, -6.11820817e-02f, 4.69106138e-02f, 5.46392575e-02f, 2.39178222e-02f,
  -1.20077534e-02f, 5.95491230e-02f, 1.55161023e-02f, -2.45562494e-02f, -5.92790768e-02f, -7.66557157e-02f, 5.10246344e-02f, 4.80394401e-02f, -5.67443483e-02f, -1.33406408e-02f,
  5.56258447e-02f, 1.79608744e-02f, 8.18283670e-03f, -6.34740219e-02f, -9.87585168e-03f, -7.80667067e-02f, 9.71957967e-02f, -2.99301706e-02f, -2.76354440e-02f, -4.53608185e-02f,
  -5.20721152e-02f, -3.61686596e-03f, -4.35553789e-02f, 1.83325149e-02f, 1.74602363e-02f, 3.46018635e-02f, 1.29854515e-01f, -8.94929245e-02f, -3.87993045e-02f, 1.78194996e-02f,
  -5.58070652e-02f, 2.02307571e-03f, -4.72703204e-02f, -5.90578141e-03f, -5.29881865e-02f, 7.72104934e-02f, -1.31255254e-01f, -2.23186556e-02f, 5.71219623e-02f, 7.65596470e-03f,
  -3.00849736e-01f, -2.65251964e-01f, -6.10942133e-02f, -7.93088228e-02f, 4.32673423e-03f, -2.33061821e-03f, -5.75944446e-02f, -5.83232567e-03f, 4.47551580e-03f, 9.02244542e-03f,
  -1.07768634e-02f, 1.13264881e-01f, -7.67544881e-02f, 7.34897554e-02f, -6.88088015e-02f, -2.50721350e-03f, -1.67612489e-02f, 9.47569758e-02f, 9.17573422e-02f, -6.43639266e-02f,
  8.94632976e-05f, -2.32781228e-02f, 4.87131765e-03f, -7.87596032e-02f, 1.56098064e-02f, 5.68352565e-02f, -6.00113273e-02f, -1.01690292e-01f, -9.14912391e-03f, 4.14050408e-02f,
  2.04088852e-01f, 1.31983966e-01f, -1.99240670e-01f, -2.57967204e-01f, -8.62767324e-02f, 1.58817530e-01f, -4.68723103e-02f, 8.92212018e-02f, -7.99307376e-02f, -4.08902168e-02f,
  2.02747770e-02f, 3.93434875e-02f, 1.12197956e-03f, 3.76645550e-02f, 2.98509687e-01f, 3.80000062e-02f, 1.60280868e-01f, -7.50414133e-02f, 1.16026975e-01f, 1.69424668e-01f,
  -3.35495807e-02f, 2.16087714e-01f, -7.92047679e-02f, 1.12898782e-01f, -6.55781105e-02f, -1.49709031e-01f, -1.07455052e-01f, -9.77241993e-02f, -1.68778494e-01f, -4.96547259e-02f,
  -9.87346992e-02f, 5.06480895e-02f, -7.69711053e-03f, 1.18936986e-01f, -5.00536175e-04f, -7.29834512e-02f, -9.59799141e-02f, -3.89326066e-02f, -3.58232670e-02f, -8.02645832e-03f,
  1.63981486e-02f, 5.50617352e-02f, 2.84372438e-02f, 4.03721072e-02f, -1.51432576e-02f, 4.67598885e-02f, 7.44118541e-02f, -4.18527126e-02f, -4.16933093e-03f, 6.41038194e-02f,
  3.09031806e-03f, 9.58847404e-02f, -3.72184031e-02f, -1.00003995e-01f, -4.65906635e-02f, 8.39269757e-02f, 2.73630377e-02f, -1.02231920e-01f, 6.79901391e-02f, 6.89894482e-02f,
  9.26167369e-02f, -3.78861651e-02f, 8.69381502e-02f, -3.58898975e-02f, -1.07863350e-02f, -6.38701320e-02f, -8.95383060e-02f, -1.26639664e-01f, -6.59772083e-02f, -1.11915119e-01f,
  -5.13562076e-02f, -1.10810317e-01f, -4.50458610e-03f, 1.38193474e-03f, 1.15805529e-01f, -3.96261252e-02f, -5.60976006e-02f, 2.18049996e-02f, -9.68062505e-02f, -4.30552363e-02f,
  -7.76110068e-02f, 3.00393607e-02f, -6.04724474e-02f, -6.30551428e-02f, -4.74449657e-02f, -1.86946131e-02f, 1.06351897e-01f, -6.51896894e-02f, -1.15995936e-01f, -5.87471575e-02f,
  1.24061622e-01f, 1.27605319e-01f, -7.37872869e-02f, 4.66173813e-02f, 9.52647440e-03f, 1.26456559e-01f, -1.68143306e-02f, 2.06025645e-01f, -1.21471863e-02f, -4.77651972e-03f,
  -2.60640532e-02f, 3.85858957e-03f, 1.09207248e-02f, 3.28720771e-02f, 3.78263332e-02f, 1.07261119e-02f, 1.07914537e-01f, -1.32862046e-01f, -1.12404771e-01f, 2.85334066e-02f,
  7.85565749e-02f, -4.43148753e-03f, 6.21955954e-02f, 2.74390113e-02f, 4.57553193e-02f, -1.14352191e-02f, 1.18992798e-01f, -1.03288658e-01f, 7.82020912e-02f, -5.33620268e-02f,
  9.56847966e-02f, 9.64782550e-04f, -2.58060366e-01f, -1.59335032e-01f, 3.56641673e-02f, -1.10214800e-02f, -1.07737675e-01f, 6.13155812e-02f, -1.38396785e-01f, 1.04541130e-01f,
  2.07119018e-01f, -2.38294706e-01f, 1.56970769e-01f, 4.56116386e-02f, -9.11097899e-02f, 1.35915056e-01f, -7.55261034e-02f, -1.21998735e-01f, -8.86670873e-02f, 8.12648982e-02f,
  -1.18750550e-01f, 1.59417540e-01f, -1.93826139e-01f, 1.01737767e-01f, 7.74945244e-02f, -7.32088555e-03f, 7.65859783e-02f, 8.44492763e-02f, 5.97519614e-02f, -2.58697681e-02f,
  2.49653831e-02f, 2.39505664e-01f, -1.06970027e-01f, -1.29405051e-01f, 8.94424226e-03f, 7.14269578e-02f, -1.77958440e-02f, -8.73869881e-02f, -5.80122136e-02f, -6.19887672e-02f,
  5.15491702e-02f, -1.04677901e-01f, 3.67819853e-02f, -4.33299616e-02f, 1.17705557e-02f, 3.21775563e-02f, -6.85229152e-02f, -1.01231821e-01f, -7.97897577e-03f, -2.37385426e-02f,
  9.18436609e-03f, 5.99430734e-03f, -1.04345068e-01f, -1.19339421e-01f, -4.41929027e-02f, 8.38178471e-02f, -6.48103282e-02f, -2.24259365e-02f, 4.03558500e-02f, -3.45432386e-02f,
  1.27002522e-01f, -5.89812808e-02f, -2.65269428e-02f, -2.34983210e-02f, 2.29880363e-02f, -2.88341590e-03f, -3.15004513e-02f, 2.86998693e-02f, -8.82650688e-02f, 3.76108326e-02f,
  -5.34679890e-02f, -6.91950321e-02f, 5.56268431e-02f, -1.91774480e-02f, 1.65224839e-02f, -1.42847700e-02f, -2.77601648e-02f, 4.59416322e-02f, -1.29120424e-01f, -3.51587357e-03f,
  -1.11185305e-01f, 4.86257020e-03f, 2.63688974e-02f, 6.60581794e-03f, 1.58094745e-02f, -1.02472074e-01f, 1.83555894e-02f, 1.87466014e-03f, -1.41205728e-01f, -6.50776327e-02f,
  1.16358832e-01f, 8.19865763e-02f, 5.91937192e-02f, -7.73718432e-02f, 1.14280485e-01f, 1.57097176e-01f, 1.03808183e-03f, 4.92468104e-03f, -2.17302795e-02f, 1.33860633e-01f,
  -3.07027064e-02f, -1.53336167e-01f, 7.68709034e-02f, 1.02697119e-01f, -1.30538911e-01f, 7.24035352e-02f, 6.45668954e-02f, -1.07310779e-01f, -1.43028572e-02f, 1.23220813e-02f,
  9.92966294e-02f, 6.11700006e-02f, -1.71720907e-01f, -1.02697257e-02f, -6.09003045e-02f, 9.46453810e-02f, -3.65152396e-02f, 6.03590049e-02f, 1.51764914e-01f, -9.52610373e-02f,
  3.13889116e-01f, -4.70063329e-01f, 1.50712505e-02f, 2.00537950e-01f, 2.80454159e-01f, 1.20035946e-01f, 6.35689721e-02f, 1.29993400e-02f, -1.03246979e-03f, -2.61549532e-01f,
  1.11344151e-01f, -6.33573681e-02f, -1.99034810e-01f, 1.22514777e-01f, 3.72265786e-01f, -1.76555857e-01f, 5.52792437e-02f, 1.14412338e-01f, 5.19038062e-04f, 7.32578933e-02f,
  1.66914135e-01f, 1.57490373e-01f, -2.83978898e-02f, -1.05151832e-01f, 5.55882789e-02f, -9.16297883e-02f, -7.11829364e-02f, -8.70795846e-02f, 5.00347801e-02f, 7.86718130e-02f,
  -1.03457607e-01f, -3.65768559e-02f, -6.21556491e-02f, -5.75863309e-02f, 1.89670417e-02f, -1.03763901e-01f, 1.10461451e-02f, 3.41388807e-02f, 8.28320086e-02f, -4.03199457e-02f,
  -2.28394531e-02f, 3.79239134e-02f, 5.86890131e-02f, 3.18455920e-02f, 1.64929382e-03f, -7.56753888e-03f, 7.21424073e-02f, -1.11929372e-01f, 1.46924406e-02f, 1.57467835e-02f,
  -1.47548942e-02f, -3.68754156e-02f, -2.49863230e-02f, -3.64922658e-02f, 4.60912660e-02f, 1.19777270e-01f, 4.16656919e-02f, 6.17791303e-02f, 3.88708040e-02f, 1.95441656e-02f,
  7.74559379e-02f, -5.51805794e-02f, 8.66310000e-02f, -7.72968959e-03f, -1.48571120e-03f, 9.52726901e-02f, 9.05700102e-02f, 2.71515120e-02f, -1.22406194e-02f, -2.94875214e-03f,
  2.29450390e-02f, 3.71465972e-03f, 3.55235487e-02f, -5.72140589e-02f, -6.05300516e-02f, -5.13758957e-02f, 2.19033528e-02f, -1.58075225e-02f, -3.83524969e-02f, -5.25609739e-02f,
  5.92113845e-02f, -2.32956763e-02f, -3.60790864e-02f, 6.59835199e-03f, -2.43386067e-02f, -7.13060796e-02f, -3.47646954e-03f, 4.73230286e-03f, 5.62725961e-03f, -4.49219234e-02f,
  -3.50680411e-01f, -3.19751024e-01f, -1.27248898e-01f, -4.40089079e-03f, -1.07121654e-01f, 1.93924438e-02f, -5.02465933e-04f, -2.21710764e-02f, -6.75118268e-02f, -5.80485687e-02f,
  -3.03732585e-02f, 3.93979140e-02f, -6.64560311e-03f, 7.22392555e-03f, -7.11596385e-02f, 2.55603325e-02f, -3.86634618e-02f, -5.62010221e-02f, 1.06492275e-02f, -5.95217980e-02f,
  -5.00893481e-02f, -6.80495873e-02f, 2.81126089e-02f, 2.50889268e-02f, 7.57228117e-04f, 5.54113649e-02f, -2.89088469e-02f, 1.18579809e-02f, 8.09286237e-02f, -7.58076459e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  9.52452421e-02f, 1.78636655e-01f, 1.06042914e-01f, 7.50891790e-02f, 2.97184959e-02f, 6.91491514e-02f, 2.98213791e-02f, -1.72115471e-02f, 1.38965368e-01f, 1.85462698e-01f,
  1.96382061e-01f, 1.88701004e-01f, 3.39213341e-01f, 2.03985170e-01f, 5.15914001e-02f, 8.85933042e-02f, 1.79527715e-01f, 3.04734826e-01f, 2.16411158e-01f, 1.43621445e-01f,
  2.46800795e-01f, 1.65019557e-01f, 1.79404989e-01f, 2.48162419e-01f, 1.50706723e-01f, 8.82787779e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -2.84570325e-02f, 5.90413213e-02f, 1.02532223e-01f, -8.54738709e-03f, -1.94222350e-02f, 5.62620424e-02f, 5.67433871e-02f, -1.18824597e-02f, 3.16682383e-02f, 3.59295979e-02f,
  1.22815557e-01f, 1.49453118e-01f, 4.86998409e-02f, 3.64414533e-03f, -1.72625668e-02f, -4.75044288e-02f, 1.28813768e-02f, -4.91318889e-02f, -2.59145033e-02f, -2.84438953e-03f,
  2.99168541e-03f, 2.91536283e-02f, 1.00189172e-01f, 1.30011335e-01f, -5.48366038e-03f, -1.90388411e-02f, 3.92779820e-02f, 9.18756872e-02f, 1.65759530e-02f, 9.29145217e-02f,
  7.83094168e-02f, 9.78705063e-02f, -2.86105964e-02f, 8.84742737e-02f, -1.29433209e-02f, -2.01337840e-02f, 6.92131370e-02f, 6.52630702e-02f, -3.66013944e-02f, 6.41019717e-02f,
  4.92317006e-02f, 9.98783708e-02f, 2.73003709e-02f, 1.24397263e-01f, 6.24935376e-03f, 6.87110722e-02f, 1.60891339e-02f, 2.10522749e-02f, 5.34766205e-02f, -7.04372907e-03f,
  1.20562330e-01f, 1.06512137e-01f, 7.55432397e-02f, 3.82846817e-02f, -5.07976934e-02f, 1.91553876e-01f, 1.61228389e-01f, -7.03373402e-02f, 7.90628940e-02f, 8.78637135e-02f,
  -1.80534750e-01f, 2.19461154e-02f, 1.22959856e-02f, -1.50610536e-01f, 1.70902386e-01f, -3.00850607e-02f, -6.19444847e-02f, -1.57844782e-01f, -1.73481926e-01f, 1.42734190e-02f,
  1.82320718e-02f, -2.76975962e-03f, 5.09120598e-02f, 1.04774408e-01f, 1.82476684e-01f, 1.64360732e-01f, 7.75584504e-02f, 1.14148520e-01f, 1.44472485e-02f, 1.14259133e-02f,
  -5.32681309e-03f, 6.84042636e-04f, -1.22782014e-01f, 7.22862557e-02f, 1.22992784e-01f, -1.17472880e-01f, 3.71810943e-02f, 9.31393728e-03f, -1.21525742e-01f, 8.69254768e-03f,
  2.82061733e-02f, -1.00169815e-01f, 1.04286354e-02f, 1.06163561e-01f, -3.90475914e-02f, -1.28733099e-01f, 3.41620147e-02f, 1.77387837e-02f, -1.06516138e-01f, 1.43678844e-01f,
  -4.38714065e-02f, 4.57328968e-02f, 4.94593456e-02f, -1.00105762e-01f, 1.70604691e-01f, 9.24797207e-02f, 1.06948890e-01f, 1.26456007e-01f, -9.43410769e-02f, 1.18871192e-02f,
  1.39595538e-01f, -2.00465173e-01f, 1.62466437e-01f, -8.51315819e-03f, 2.42937170e-02f, 2.54204050e-02f, 1.55769765e-01f, 1.67893082e-01f, -5.29731363e-02f, 1.65147096e-01f,
  1.55192450e-01f, -4.74685617e-02f, 5.85493930e-02f, 1.71439290e-01f, 4.84959446e-02f, 9.47244167e-02f, 1.01908602e-01f, -2.29570687e-01f, -4.43759887e-03f, 1.18248418e-01f,
  5.56285493e-02f, 1.36727002e-02f, 3.59209739e-02f, 1.71135832e-02f, 1.04064807e-01f, -8.91643465e-02f, 6.61040321e-02f, -6.94822799e-03f, -1.23325028e-02f, 6.96697161e-02f,
  7.46441185e-02f, -3.62902842e-02f, -1.11261681e-01f, -1.04909346e-01f, 5.67444637e-02f, -3.87198036e-03f, 5.41248694e-02f, 2.26910003e-02f, -6.79883063e-02f, -8.41608867e-02f,
  -1.08889237e-01f, 1.09351881e-01f, -2.09623035e-02f, -9.43980813e-02f, -4.56183888e-02f, 5.74453212e-02f, 6.38106558e-03f, 2.96237841e-02f, -6.58959448e-02f, -6.77926913e-02f,
  -8.62274840e-02f, 3.01375594e-02f, -7.77877197e-02f, -3.79320793e-02f, -2.38059200e-02f, -2.61618849e-02f, -2.06057280e-02f, 3.30275367e-03f, -8.74744952e-02f, -7.91707039e-02f,
  2.50634607e-02f, -2.71657594e-02f, -2.33274549e-02f, -5.74836470e-02f, -5.38798608e-02f, 5.25206290e-02f, -5.64435832e-02f, -1.95478904e-03f, 1.71715836e-03f, -2.75820382e-02f,
  1.41129747e-01f, 4.31608595e-03f, -4.43710834e-02f, 2.57771045e-01f, 1.52032942e-01f, -1.84356272e-02f, 2.21825138e-01f, -7.95832127e-02f, -4.40099835e-02f, 4.21615615e-02f,
  8.63797218e-02f, -8.18503052e-02f, 1.47772580e-01f, -1.44031838e-01f, -8.42176378e-02f, -1.41283438e-01f, -7.60200620e-02f, 4.83778492e-02f, -2.79758442e-02f, -1.91238448e-01f,
  -8.72160196e-02f, 2.58611497e-02f, 1.39463961e-01f, 5.51869720e-02f, 1.87105551e-01f, 1.69256300e-01f, -1.12043828e-01f, -7.64317960e-02f, -1.79180235e-01f, 5.61357811e-02f,
  2.66195573e-02f, 1.05587207e-01f, 1.48689315e-01f, 7.79810697e-02f, 1.09399952e-01f, -2.59727333e-03f, -1.30090848e-01f, 1.54789343e-01f, -1.25100464e-01f, -5.17892465e-02f,
  -1.37880463e-02f, 1.24149583e-01f, -1.32890210e-01f, 1.05650024e-02f, -3.06594335e-02f, -9.57765877e-02f, -3.60094793e-02f, -8.67292378e-03f, -4.06510234e-02f, 9.01532397e-02f,
  -3.96014862e-02f, -1.80825636e-01f, -1.06574968e-01f, 2.90549453e-02f, 2.52745718e-01f, 5.60570434e-02f, -1.22658461e-01f, -5.03455140e-02f, -2.34761313e-02f, -7.40206316e-02f,
  1.07410505e-01f, -4.56435233e-02f, 2.51330823e-01f, 1.56364627e-02f, 3.37229408e-02f, 1.58903971e-01f, -6.54622838e-02f, 6.84482455e-02f, 8.86298642e-02f, -1.85136050e-01f,
  -1.48272455e-01f, 2.75041573e-02f, -7.61235133e-02f, -1.11692816e-01f, 1.42258415e-02f, -2.10715398e-01f, -7.17317238e-02f, 3.09506878e-02f, -1.29743889e-01f, 8.59088376e-02f,
  -2.49467157e-02f, -3.70643251e-02f, -1.00943118e-01f, -6.09494336e-02f, -1.80584453e-02f, -7.49430135e-02f, -7.66449049e-02f, 2.40731649e-02f, -4.64272052e-02f, 1.47259757e-02f,
  -4.33239341e-02f, 9.81406793e-02f, 2.85438988e-02f, 1.09119482e-01f, -2.94419602e-02f, -2.03924067e-03f, 1.68918520e-02f, 3.17546651e-02f, -9.95631069e-02f, -3.04915048e-02f,
  1.14119746e-01f, 8.59945342e-02f, -8.89487267e-02f, 8.76506120e-02f, 1.18833423e-01f, 8.57019797e-02f, -3.39649506e-02f, -3.90580297e-02f, -4.38667051e-02f, -9.50294584e-02f,
  -3.42325084e-02f, 5.01562702e-03f, -1.36104882e-01f, 4.66305912e-02f, -2.57071294e-02f, 5.49570210e-02f, -1.54287694e-02f, 9.39178374e-03f, 6.53853873e-03f, 1.57693416e-01f,
  -1.65121123e-01f, 5.75768128e-02f, 8.22783560e-02f, 4.76155952e-02f, -3.65978554e-02f, -2.36144830e-02f, -4.55813743e-02f, -1.05729457e-02f, -4.70284000e-02f, 4.96173836e-03f,
  -9.08859633e-03f, 1.57400280e-01f, 2.21083984e-01f, -1.83594212e-01f, 1.33954912e-01f, 7.49141127e-02f, 5.64406589e-02f, -7.44917765e-02f, 4.03861031e-02f, 3.10666393e-02f,
  -5.95302097e-02f, -5.61150685e-02f, -1.41888276e-01f, 1.50302991e-01f, -1.04131758e-01f, -2.50360146e-02f, 9.59837437e-02f, 8.20717663e-02f, -4.29880619e-02f, -1.16689876e-01f,
  -4.22865115e-02f, -1.93220705e-01f, -1.54052570e-01f, -2.85598841e-02f, -6.38002083e-02f, 5.57383113e-02f, -6.99879453e-02f, -1.31685331e-01f, -3.29002850e-02f, -2.33891040e-01f,
  3.22827846e-02f, 1.97805598e-01f, 1.54802144e-01f, 1.41156718e-01f, 9.95628536e-02f, 1.06515497e-01f, 1.77367210e-01f, 1.25241995e-01f, 1.32122263e-01f, -1.73598230e-02f,
  -4.83914167e-02f, 3.58482860e-02f, -1.95894718e-01f, 1.03291109e-01f, -1.14333838e-01f, -1.16760746e-01f, 1.23324193e-01f, -9.70429927e-02f, -5.51936030e-03f, 9.12339147e-03f,
  1.71336293e-01f, 9.29545015e-02f, 1.27448425e-01f, 2.93217860e-02f, -2.29680147e-02f, 2.23165527e-02f, -9.52291414e-02f, 1.06880471e-01f, 6.72026630e-03f, 1.46293893e-01f,
  8.61053839e-02f, -7.31609762e-02f, -6.92644045e-02f, -2.10074008e-01f, 9.27296430e-02f, -2.09019482e-01f, 9.34475195e-03f, 1.48488030e-01f, -1.63750216e-01f, -3.21141928e-02f,
  7.72721767e-02f, -4.29185145e-02f, -1.73685804e-03f, 1.19797915e-01f, -6.64104596e-02f, 1.04532301e-01f, -2.65870313e-03f, -6.16943128e-02f, 7.19228610e-02f, 6.47135526e-02f,
  2.27327179e-02f, 5.71011826e-02f, 2.10864499e-01f, 1.26051065e-02f, -2.10776925e-02f, -7.16284662e-02f, 3.75354849e-02f, -5.98297939e-02f, 5.11646178e-03f, -3.47274207e-02f,
  1.04398979e-02f, 4.67832088e-02f, -3.82357202e-02f, -1.00668445e-01f, -8.09356049e-02f, 3.11540347e-02f, -9.59847569e-02f, -5.28072305e-02f, -3.77353244e-02f, 8.03391784e-02f,
  -4.76698577e-03f, -1.03901871e-01f, -4.89709042e-02f, -4.63056304e-02f, 6.62505031e-02f, 3.61762159e-02f, 1.21719062e-01f, 3.15385871e-02f, 3.42289470e-02f, -5.95866889e-02f,
  -9.94750559e-02f, -5.03214225e-02f, 6.99720234e-02f, 1.45819828e-01f, 1.25469519e-02f, 7.14870915e-02f, 6.84269890e-02f, -9.41669792e-02f, 1.60417948e-02f, 1.51442096e-01f,
  -6.18153550e-02f, -6.95074052e-02f, 4.10111919e-02f, -7.69276470e-02f, -1.44821499e-02f, -1.04850128e-01f, 1.03590257e-01f, 5.72466329e-02f, 1.35114372e-01f, -1.67617664e-01f,
  -3.39214318e-02f, 3.78015079e-02f, 4.04982455e-02f, 1.57795250e-01f, 2.53422167e-02f, -1.67035341e-01f, -1.23644434e-01f, 1.00042008e-01f, 9.95979551e-03f, -8.61300603e-02f,
  2.21796200e-01f, 1.08409494e-01f, 1.98627383e-01f, 3.97522375e-02f, -1.70521587e-02f, 5.60154673e-03f, -6.09085001e-02f, 7.94486143e-03f, -1.07553437e-01f, -5.05520217e-02f,
  -1.24179445e-01f, -2.90187653e-02f, 5.38989119e-02f, 8.64334852e-02f, 1.04246140e-01f, 4.69679125e-02f, 1.02185525e-01f, -1.02389082e-01f, -1.00089043e-01f, 8.11886266e-02f,
  7.86311254e-02f, -1.10055715e-01f, 3.61608416e-02f, 5.04399724e-02f, 2.24652067e-02f, 6.57787845e-02f, 1.24866948e-01f, 7.84736127e-02f, 7.75318444e-02f, 1.53055608e-01f,
  -3.51334810e-02f, 1.12573333e-01f, 8.59711617e-02f, -1.66570798e-01f, 1.51584104e-01f, -1.33798376e-01f, -2.74382737e-02f, 4.85994630e-02f, -1.75192460e-01f, 4.16587666e-02f,
  -5.87933958e-02f, 3.91532518e-02f, 2.70947844e-01f, 2.19103023e-02f, 5.94293699e-02f, 1.62469819e-01f, -1.58201158e-01f, -4.79051545e-02f, -1.00134566e-01f, 5.11260070e-02f,
  -1.64823323e-01f, 1.95553064e-01f, -1.20949196e-02f, -1.77865177e-01f, -1.35885850e-01f, -1.13943554e-01f, 1.66539416e-01f, -1.34449095e-01f, 5.47363795e-02f, 3.50362919e-02f,
  -6.23932183e-02f, 1.10264279e-01f, 6.56081364e-02f, 6.29992336e-02f, 7.75581673e-02f, 4.03957218e-02f, -9.72377229e-03f, -2.50664428e-02f, 4.10289280e-02f, 2.18558758e-02f,
  1.60362571e-02f, 5.69974557e-02f, -7.75253326e-02f, -1.34257779e-01f, -1.62754189e-02f, -1.76628586e-02f, -1.02517515e-01f, 4.36366014e-02f, 8.81072730e-02f, 1.25118326e-02f,
  -6.47068098e-02f, 5.00428453e-02f, 4.18535136e-02f, -4.76548932e-02f, -4.06480357e-02f, 5.53589594e-03f, -6.08224757e-02f, -1.74984559e-02f, -1.27587933e-02f, 5.75671941e-02f,
  -6.62510321e-02f, -4.26984876e-02f, -1.16657640e-03f, -4.47649918e-02f, -9.98363420e-02f, 6.97606802e-02f, 7.79367313e-02f, 3.93734425e-02f, 1.84999593e-02f, -8.50606039e-02f,
  -2.17153654e-02f, 7.55594522e-02f, 1.44412043e-02f, 7.65080601e-02f, 1.05138108e-01f, -8.36851150e-02f, 6.55487329e-02f, -5.25278784e-02f, -9.05784369e-02f, -9.45761204e-02f,
  5.99176548e-02f, -4.91820686e-02f, 2.44299751e-02f, -1.70948729e-02f, 3.71602140e-02f, 6.87055513e-02f, -1.05991490e-01f, -1.35410354e-01f, -1.70867398e-01f, 1.32076576e-01f,
  -7.49919610e-03f, -1.18190264e-02f, 1.98989734e-02f, -4.07623574e-02f, -6.83020102e-03f, -1.24293670e-01f, 1.14411525e-02f, 2.00613514e-01f, 2.58107539e-02f, -5.87811768e-02f,
  8.92640278e-02f, -9.75438133e-02f, -5.84505461e-02f, -1.03565760e-01f, -6.67969733e-02f, 1.03988498e-01f, -1.29914246e-02f, 1.19849324e-01f, 1.93570748e-01f, -3.83452550e-02f,
  5.31831570e-02f, -6.80613741e-02f, -5.41774035e-02f, 8.55323523e-02f, 3.27759311e-02f, 1.94572628e-01f, 3.63639221e-02f, -1.42696694e-01f, -6.87671825e-02f, -1.44986426e-02f,
  -2.13827677e-02f, 3.19596194e-02f, -2.09594682e-01f, -7.59334937e-02f, -7.27152526e-02f, 5.37556671e-02f, 7.98040628e-02f, 6.57401681e-02f, 1.71109587e-01f, -3.73424254e-02f,
  -2.79282015e-02f, 7.08611831e-02f, -1.49469614e-01f, 1.79912090e-01f, -6.33955970e-02f, -4.85605672e-02f, -1.29687056e-01f, -2.08415031e-01f, -8.75497982e-02f, -6.14457875e-02f,
  3.23858261e-02f, 1.53968306e-02f, -1.05251029e-01f, -1.97677508e-01f, 1.58693902e-02f, -1.27923951e-01f, 5.31713525e-03f, 1.71613052e-01f, -2.17413493e-02f, 1.09852470e-01f,
  -5.55661432e-02f, 1.36963606e-01f, 1.06257901e-01f, -5.25884256e-02f, 1.13888182e-01f, 3.12190764e-02f, -2.26944834e-02f, -9.07878131e-02f, 8.09206739e-02f, -1.24488562e-01f,
  -6.68668896e-02f, 1.41113266e-01f, 2.80849077e-02f, 5.15755042e-02f, 1.18778711e-02f, -1.19554229e-01f, -3.82118784e-02f, 5.57970814e-02f, 3.81663777e-02f, -5.19188761e-04f,
  1.97357554e-02f, -2.45722178e-02f, -1.32321287e-02f, 7.92757720e-02f, 9.23578888e-02f, 4.04060967e-02f, 1.53586064e-02f, 3.53617668e-02f, 2.82833539e-02f, 9.92813520e-03f,
  1.00652844e-01f, 4.84079681e-02f, 1.88686390e-04f, 1.00378646e-02f, 5.40044084e-02f, -1.29473191e-02f, -7.19213113e-02f, 2.05041990e-02f, 5.20175807e-02f, -5.61520569e-02f,
  -6.18927032e-02f, -3.66109498e-02f, 1.50674582e-02f, 2.71799900e-02f, 4.01863754e-02f, -6.34042621e-02f, -1.58932596e-01f, -4.57961299e-02f, -4.25563902e-02f, 5.39886132e-02f,
  9.28366259e-02f, 1.29161179e-02f, -1.04342118e-01f, 6.90070838e-02f, -1.75259188e-01f, -6.18133731e-02f, 9.44547206e-02f, 5.03597371e-02f, -6.11954071e-02f, -3.46663147e-02f,
  -5.26437573e-02f, -5.28264865e-02f, 2.07534786e-02f, 2.18817443e-02f, -4.57041785e-02f, 2.10524336e-01f, 1.53235674e-01f, -1.08239099e-01f, 5.88614084e-02f, 1.46971330e-01f,
  -4.56053726e-02f, 1.07848808e-01f, 7.06074852e-03f, 2.18090281e-01f, 8.12393725e-02f, -1.22013927e-01f, -1.25442445e-01f, 6.60571605e-02f, -6.53760210e-02f, 3.76516879e-02f,
  9.82601270e-02f, 5.39123155e-02f, 9.51701477e-02f, -1.00912988e-01f, 1.50472432e-01f, 7.33410046e-02f, 2.20147986e-02f, -1.57694463e-02f, -4.47313525e-02f, 1.86278716e-01f,
  -1.22379497e-01f, -4.68656942e-02f, -3.15505862e-02f, -1.53315902e-01f, -1.95036083e-02f, 8.15417469e-02f, -6.07693754e-02f, 5.11713773e-02f, -1.84120964e-02f, 5.64935058e-02f,
  1.07051678e-01f, 6.39601564e-03f, 1.63080826e-01f, -5.07350415e-02f, -4.85945009e-02f, -1.41843826e-01f, -1.89482078e-01f, -1.33922987e-03f, -5.59998974e-02f, 1.42471483e-02f,
  6.94632754e-02f, -1.44603914e-02f, -1.07253142e-01f, -1.38961583e-01f, 2.50812531e-01f, 1.28734663e-01f, 5.71362674e-02f, 1.23085305e-01f, -1.32070020e-01f, -1.44960999e-01f,
  1.46534696e-01f, 1.67566165e-01f, 1.06443167e-01f, -8.03325102e-02f, 5.86391799e-02f, -1.16024360e-01f, 1.72966495e-02f, -7.65382200e-02f, 1.39423370e-01f, -2.45361671e-01f,
  -1.93088531e-01f, -1.46186695e-01f, -2.73471504e-01f, 5.11227548e-02f, 4.62860875e-02f, 2.93664727e-03f, -4.72493917e-02f, -1.42231420e-01f, -9.87560302e-02f, 6.04793802e-02f,
  -8.31808001e-02f, -9.12428573e-02f, 5.65033332e-02f, 3.75386700e-02f, 7.45910332e-02f, 9.08904448e-02f, 1.74777675e-02f, -7.54802972e-02f, -6.69090226e-02f, 2.99297888e-02f,
  -1.12985611e-01f, 1.68992326e-01f, -2.58441195e-02f, 2.38001570e-02f, -7.89749995e-03f, 1.07574478e-01f, 1.18727855e-01f, 8.43035206e-02f, -1.05543673e-01f, 6.52703717e-02f,
  3.10673676e-02f, -1.33539200e-01f, -1.15823532e-02f, 8.60381946e-02f, 1.18144140e-01f, -6.77349716e-02f, -1.37680531e-01f, 1.14469556e-02f, 1.29789904e-01f, 1.43102175e-02f,
  2.73792874e-02f, 1.78966038e-02f, 7.91666806e-02f, -5.21952137e-02f, 5.64146824e-02f, -7.01642483e-02f, 2.40571331e-02f, 3.50805968e-02f, -4.39263731e-02f, -3.56994160e-02f,
  1.04848728e-01f, -6.90332130e-02f, 2.22955924e-02f, -1.20601848e-01f, 5.69245964e-02f, 4.55922671e-02f, 1.56284422e-02f, 1.14328172e-02f, -5.43681197e-02f, -4.63942066e-02f,
  1.51270477e-03f, -4.19251844e-02f, 9.41047147e-02f, -4.63929027e-02f, -1.15793139e-01f, 3.13520804e-02f, -1.28044030e-02f, -8.05755407e-02f, -3.58694009e-02f, 3.74342315e-02f,
  2.79959254e-02f, 1.12086430e-01f, -1.49756834e-01f, -1.51109606e-01f, -6.81334957e-02f, 2.60697864e-02f, -3.86361661e-03f, 7.18607102e-03f, 4.85375784e-02f, 2.08074227e-02f,
  -5.86340688e-02f, 4.02926579e-02f, 1.06970787e-01f, -2.39064097e-02f, -1.83894455e-01f, 1.50775596e-01f, 6.62484299e-03f, -3.38490605e-02f, -1.28543347e-01f, -1.14497192e-01f,
  9.09476429e-02f, 3.43063436e-02f, -1.54830381e-01f, -8.84698182e-02f, 1.08954377e-01f, -9.83477235e-02f, -3.32251526e-02f, -3.10482979e-02f, -1.35306358e-01f, 9.93594900e-02f,
  8.88228118e-02f, 1.72462180e-01f, 2.77141891e-02f, 3.26962434e-02f, 3.79230008e-02f, -2.45165363e-01f, 1.13255084e-01f, 3.49724069e-02f, 5.93337379e-02f, -4.01527844e-02f,
  3.72534208e-02f, 2.20132157e-01f, -1.15061224e-01f, -3.03821731e-02f, 7.64630958e-02f, -1.29473150e-01f, 6.00156449e-02f, -1.23620033e-01f, -1.24852890e-02f, 1.10643156e-01f,
  1.90151080e-01f, 2.36842083e-03f, -9.62123573e-02f, -1.46625623e-01f, 1.83439121e-01f, -1.81486197e-02f, -5.52283116e-02f, 1.34717107e-01f, -3.91751975e-02f, 9.32784155e-02f,
  -1.02434963e-01f, 1.33311525e-01f, -1.62234362e-02f, 3.19792666e-02f, 5.30028865e-02f, 2.18069032e-01f, -1.41716758e-02f, 1.23468079e-01f, 3.92742790e-02f, -7.15598390e-02f,
  -2.66006347e-02f, 7.14097321e-02f, 1.95717849e-02f, 3.69414911e-02f, 1.25343010e-01f, -6.89081177e-02f, -5.49390800e-02f, -8.08217004e-02f, -5.99233583e-02f, -5.59452996e-02f,
  1.18275069e-01f, -1.10920556e-02f, 8.60803016e-03f, -7.21020997e-02f, -3.83695886e-02f, -3.37639749e-02f, -5.84417582e-02f, -6.95809498e-02f, -4.18100059e-02f, -5.75688928e-02f,
  4.29721959e-02f, 7.15028727e-03f, -2.07424513e-03f, -4.04365128e-03f, -5.28795123e-02f, -6.33071959e-02f, -7.20740333e-02f, -7.06814602e-02f, -1.98745243e-02f, -2.88962014e-02f,
  7.14501515e-02f, -2.98610888e-02f, -2.53876206e-02f, 8.33009705e-02f, 8.03134516e-02f, 6.68049082e-02f, 6.61803856e-02f, 8.14377442e-02f, -1.06401611e-02f, -9.18405652e-02f,
  4.09402931e-03f, -7.28474855e-02f, -1.10120540e-02f, 7.59298280e-02f, -5.72497174e-02f, -5.66167124e-02f, -9.87280011e-02f, -1.63035974e-01f, -2.07595807e-02f, 1.14679702e-01f,
  9.24987793e-02f, -6.70565367e-02f, 1.05393305e-02f, 3.49994935e-02f, 1.68552563e-01f, 8.83602649e-02f, -1.71995647e-02f, -2.23896250e-01f, -5.39507419e-02f, 6.19081371e-02f,
  5.98035008e-02f, -4.82884198e-02f, 1.06783740e-01f, 2.11701214e-01f, 1.37309551e-01f, 1.72505930e-01f, 1.50982719e-02f, -8.23076442e-02f, 1.43805025e-02f, 7.46286213e-02f,
  -4.45099734e-02f, -7.23905861e-02f, -1.83475211e-01f, 2.36423258e-02f, 5.57962842e-02f, 6.41103089e-02f, 1.79359615e-01f, 6.38706535e-02f, 6.69913692e-03f, 4.19781283e-02f,
  -1.69657111e-01f, 1.98374137e-01f, -2.03873627e-02f, -1.93327874e-01f, 1.44793645e-01f, 7.95954838e-02f, 1.12818256e-01f, 4.78823595e-02f, 1.50204137e-01f, 1.47140235e-01f,
  7.33905435e-02f, 7.25122318e-02f, -5.20514473e-02f, 4.79417741e-02f, 6.48488337e-03f, -1.82895795e-01f, 1.25926197e-01f, -6.65541440e-02f, -8.15607458e-02f, -3.48602480e-04f,
  -2.53807660e-02f, 9.15962011e-02f, 6.27251854e-03f, 1.30989373e-01f, 1.89633116e-01f, 1.16891153e-01f, 7.65652806e-02f, 3.25156711e-02f, -7.25121424e-02f, -1.21819541e-01f,
  -9.14841667e-02f, 3.32763158e-02f, -1.41225949e-01f, 6.31272495e-02f, -9.56287533e-02f, -1.91201165e-01f, -8.80623162e-02f, -2.12694064e-01f, 1.13499559e-01f, -9.45447683e-02f,
  6.65552914e-02f, 1.38586566e-01f, -8.37790743e-02f, 2.30203979e-02f, 6.00426681e-02f, -1.45183891e-01f, 9.06372219e-02f, -2.53186934e-02f, 3.26573104e-02f, 3.09958700e-02f,
  -1.88089199e-02f, 5.37297390e-02f, 4.97686937e-02f, 5.90697862e-02f, 4.67697345e-02f, 7.22419545e-02f, 4.61720154e-02f, -7.11811101e-03f, 1.37671322e-01f, 9.63411406e-02f,
  -5.99670969e-02f, -4.73637227e-03f, -1.92709137e-02f, 8.12911764e-02f, 7.27437809e-02f, 1.76460780e-02f, 8.54775384e-02f, -3.22850887e-03f, 7.31052086e-02f, -2.77282065e-03f,
  4.10593376e-02f, 7.84484763e-03f, 1.43345520e-01f, 8.43761414e-02f, 2.33946759e-02f, 8.75192508e-02f, 1.00777701e-01f, 3.36947516e-02f, -2.33363584e-02f, 8.12698901e-03f,
  -1.32764839e-02f, -1.44669563e-01f, 1.43672500e-04f, 1.01068141e-02f, -9.09752958e-03f, 4.08376791e-02f, -3.77123542e-02f, 5.66909499e-02f, -2.36978848e-02f, 1.49383292e-01f,
  -7.52911717e-03f, 2.86919791e-02f, 1.03589140e-01f, -3.98444682e-02f, 1.28686592e-01f, 8.41786563e-02f, -1.55288979e-01f, -5.28525934e-02f, 5.47300512e-03f, -2.33092904e-02f,
  -3.47846397e-03f, -4.06132452e-02f, -1.02420613e-01f, 9.17818695e-02f, 7.48397782e-02f, -1.11907050e-01f, 1.03846245e-01f, 4.46286201e-02f, -1.14541605e-01f, 8.39135349e-02f,
  -2.16499083e-02f, 1.59936026e-02f, -1.81149207e-02f, 2.01760232e-02f, -1.66167077e-02f, 9.65338498e-02f, 9.01813135e-02f, -1.85884833e-02f, -1.11070119e-01f, -1.63685605e-01f,
  8.60665739e-02f, -1.26264924e-02f, 4.15404961e-02f, 3.68952043e-02f, 8.60757008e-02f, -1.27940983e-01f, -2.07058284e-02f, -1.33299515e-01f, 5.48155606e-02f, 1.20970914e-02f,
  1.67950496e-01f, -1.69124212e-02f, -4.18018699e-02f, 1.80017191e-03f, -4.84352484e-02f, 6.05756603e-02f, -3.41441408e-02f, -2.83478230e-01f, 5.92011772e-02f, 4.53476869e-02f,
  -3.66412178e-02f, 8.10458511e-02f, -2.96491273e-02f, 5.97393885e-02f, 6.88415989e-02f, -2.07849875e-01f, 1.23804294e-01f, 1.09897688e-01f, 6.22896180e-02f, -4.43356410e-02f,
  -2.55065411e-01f, -6.80681393e-02f, -9.90617275e-02f, -7.89607316e-02f, 1.30954191e-01f, 9.39424410e-02f, -2.29468450e-01f, 9.12226140e-02f, -1.35204509e-01f, 8.66291076e-02f,
  -1.26512289e-01f, -3.23614702e-02f, 1.18272901e-01f, -1.39028773e-01f, 7.48356357e-02f, 2.35817626e-01f, 1.60572305e-01f, -3.73966508e-02f, -3.95315401e-02f, 2.30561644e-02f,
  5.29328212e-02f, 1.82067230e-01f, 7.80626340e-03f, 7.92127550e-02f, -2.89044529e-03f, -7.35624507e-02f, -8.54393840e-02f, 4.58874665e-02f, 4.70966138e-02f, -3.93593982e-02f,
  6.83151931e-03f, -9.07579530e-03f, -4.08372190e-03f, 1.15153134e-01f, 1.24279469e-01f, 5.42007526e-03f, -6.71209255e-03f, 3.17998603e-02f, 2.73368955e-02f, 1.97957307e-02f,
  -4.68893303e-03f, -6.35499358e-02f, 4.27851304e-02f, 6.33216323e-03f, 4.10185568e-02f, -7.30787739e-02f, 7.29749426e-02f, 5.47935888e-02f, 3.37714925e-02f, 1.50917724e-01f,
  7.64938518e-02f, 1.27186179e-01f, -1.27333384e-02f, 1.12997130e-01f, -1.99802965e-02f, 4.66453210e-02f, 6.50355145e-02f, 2.18199734e-02f, -3.86945158e-02f, 3.44050638e-02f,
  2.22060457e-02f, 9.89764836e-03f, -3.32912393e-02f, -3.53544354e-02f, -1.07072197e-01f, 1.47036135e-01f, -4.36502546e-02f, 4.00244864e-03f, 2.57484931e-02f, 9.03278291e-02f,
  -6.28257468e-02f, -1.17549784e-01f, 3.40612754e-02f, 4.72298497e-03f, 9.85558257e-02f, 2.06972063e-02f, -1.45234182e-01f, 2.02591538e-01f, 9.10112411e-02f, -1.77916914e-01f,
  1.82217374e-01f, -1.69238076e-01f, -8.11261982e-02f, 1.13851354e-02f, -7.55200610e-02f, -3.44140753e-02f, -6.53554797e-02f, -7.13448003e-02f, 4.13975269e-02f, -9.44148824e-02f,
  -2.32739553e-01f, 8.75245035e-02f, 1.91137850e-01f, 9.07278806e-03f, -1.28856115e-03f, 2.06162140e-01f, 1.64816994e-02f, -1.60969988e-01f, -5.85001241e-03f, 2.73274221e-02f,
  -2.35264166e-03f, 6.91659003e-02f, 8.33497420e-02f, -6.31419867e-02f, -3.10983378e-02f, -1.92663953e-01f, -7.57193416e-02f, 1.89787060e-01f, 5.71926124e-02f, 4.04334255e-03f,
  4.14670818e-02f, 1.69001535e-01f, 1.94088921e-01f, -8.60623419e-02f, 1.10146984e-01f, -1.05395705e-01f, -1.33782357e-01f, 7.38127902e-02f, -6.37614951e-02f, -1.68227792e-01f,
  -1.98763296e-01f, -6.93818033e-02f, 2.61754226e-02f, -1.94894612e-01f, 1.20225653e-01f, -2.34062940e-01f, 7.45856613e-02f, 1.10416777e-01f, -5.15489094e-02f, 8.94538090e-02f,
  -9.94762555e-02f, -6.16634972e-02f, 4.76816110e-02f, -1.14907101e-01f, -4.47621047e-02f, -7.97999054e-02f, 8.81874710e-02f, -1.18882842e-01f, -7.70434439e-02f, -8.41134489e-02f,
  -5.23299277e-02f, 3.70105319e-02f, 9.73555520e-02f, 8.79584849e-02f, -1.75167084e-01f, -1.03290714e-01f, -7.68097043e-02f, -1.67190010e-04f, -4.42330018e-02f, -1.10228352e-01f,
  -4.09755856e-02f, 4.86350432e-02f, 6.03005523e-03f, 8.99412632e-02f, -1.19590558e-01f, -1.04634002e-01f, -1.91655662e-02f, -2.45544016e-02f, 3.57154645e-02f, -9.67204664e-03f,
  -4.67989184e-02f, 5.82758486e-02f, 5.27025573e-02f, -8.10904875e-02f, -4.56967298e-03f, 7.48027489e-03f, 7.93617740e-02f, -2.04151534e-02f, 7.50966519e-02f, -3.87686305e-02f,
  6.58637146e-03f, -7.97810778e-02f, -1.19153649e-01f, 1.14561886e-01f, 4.00879420e-02f, -2.43742503e-02f, 3.26576084e-02f, -2.68138982e-02f, 7.13588372e-02f, 6.61743199e-03f,
  -8.54333565e-02f, 6.66335672e-02f, -6.33547036e-03f, -9.16120559e-02f, -5.61000854e-02f, -4.18787822e-02f, -2.74359975e-02f, 9.25333146e-03f, -1.10909296e-02f, -2.09474396e-02f,
  4.48356569e-03f, 9.21349898e-02f, 2.27126572e-02f, 1.11395299e-01f, -9.63858142e-02f, -3.33350375e-02f, -1.28850937e-01f, 4.27053962e-03f, 9.38016102e-02f, -1.70025472e-02f,
  -2.57790294e-02f, 6.40144423e-02f, -4.29071393e-03f, 6.28393516e-02f, -9.58028808e-03f, 1.33894831e-01f, 2.26803198e-01f, -9.58651677e-02f, 1.60879835e-01f, 1.83017477e-01f,
  -2.08684485e-02f, 9.76759791e-02f, -1.31508391e-02f, 6.11165464e-02f, 2.20267355e-01f, -1.81245610e-01f, -9.54124629e-02f, -5.33656254e-02f, -2.02754378e-01f, -9.87639725e-02f,
  5.29202586e-03f, -9.76519436e-02f, -2.93505024e-02f, -6.04706220e-02f, 4.06679437e-02f, 8.58872905e-02f, 9.60721895e-02f, 7.66741335e-02f, 1.53000839e-02f, -5.37939258e-02f,
  -8.57298896e-02f, -4.64675538e-02f, -1.13654256e-01f, -8.54532272e-02f, 6.83594402e-03f, 1.53040960e-01f, 1.16594806e-01f, 7.96946511e-02f, -1.63008869e-01f, 3.16079408e-02f,
  1.64128125e-01f, -4.58648503e-02f, 8.43468159e-02f, 1.22445978e-01f, -6.02757484e-02f, -1.28083408e-01f, -7.40361512e-02f, -4.18801531e-02f, -1.07406139e-01f, -7.27769211e-02f,
  3.44312079e-02f, 1.22092605e-01f, -8.38663522e-03f, -1.77441254e-01f, 1.95082366e-01f, 1.11803263e-01f, 1.45358473e-01f, 1.03745624e-01f, -1.44334495e-01f, 7.30286539e-02f,
  4.06343527e-02f, -4.67625409e-02f, 1.36653170e-01f, 4.78679873e-02f, 1.33921310e-01f, -3.97427287e-03f, 1.12647355e-01f, 4.42386791e-02f, -2.51068976e-02f, -1.32270113e-01f,
  1.39364138e-01f, -1.47792727e-01f, -7.92434141e-02f, -8.29435885e-02f, 1.47427144e-02f, -3.86369862e-02f, -2.16473453e-03f, -2.31458113e-01f, 9.87834707e-02f, 1.36684000e-01f,
  5.86466342e-02f, 1.41781839e-02f, -1.13085480e-02f, 1.63330361e-02f, -6.60824850e-02f, -2.51350459e-02f, 1.87723879e-02f, 4.25405167e-02f, 4.87347841e-02f, 7.28469193e-02f,
  -4.27831151e-02f, -4.76958044e-02f, 2.40460020e-02f, -5.17075807e-02f, 8.62737000e-03f, -6.69957623e-02f, 3.48769315e-02f, -9.87594854e-03f, -4.57017273e-02f, 8.21663588e-02f,
  -1.10217057e-01f, 3.59774753e-02f, -1.00585938e-01f, -2.67845523e-02f, 9.70082283e-02f, 5.20422049e-02f, 6.07876554e-02f, -4.28690016e-02f, -1.72318872e-02f, 9.03533213e-03f,
  -8.21145251e-02f, 8.82542133e-02f, 7.70465061e-02f, 5.96525222e-02f, -1.51345553e-02f, 1.24370381e-01f, -3.04574100e-03f, 1.30617887e-01f, -6.21879147e-03f, -4.45926860e-02f,
  5.88363335e-02f, -9.09221619e-02f, 4.10554698e-03f, 7.11513460e-02f, -1.07508143e-02f, -1.70122236e-02f, -7.25524276e-02f, 4.05606292e-02f, -3.05532776e-02f, -1.33424595e-01f,
  1.52321726e-01f, -5.13646677e-02f, -4.48016562e-02f, -8.04843828e-02f, -4.95563149e-02f, 1.62050024e-01f, 2.46339827e-03f, 1.74394488e-01f, -4.06098738e-02f, -7.32465163e-02f,
  -5.37073575e-02f, -2.29630861e-02f, 1.75055355e-01f, -5.42828478e-02f, 5.74664287e-02f, 1.51342764e-01f, 1.69888794e-01f, -5.62905446e-02f, -1.45978972e-01f, -1.64055422e-01f,
  5.00887260e-02f, -1.64466962e-01f, -1.53900370e-01f, 7.35590458e-02f, -1.66540772e-01f, 7.70126358e-02f, -6.16843402e-02f, -9.95720550e-02f, -3.73757742e-02f, 9.05557722e-02f,
  1.12958394e-01f, 7.24564567e-02f, 4.96530123e-02f, 5.65029718e-02f, -2.17909161e-02f, -7.06516802e-02f, 1.43204466e-01f, -1.09865675e-02f, 2.33699940e-03f, -3.51185463e-02f,
  7.12578045e-03f, 1.77871868e-01f, 1.79284718e-02f, -5.88359162e-02f, -6.28060028e-02f, 4.81357053e-02f, 1.67970061e-01f, -3.49120870e-02f, 6.38721511e-02f, 1.95722997e-01f,
  -1.08309425e-01f, -3.84055488e-02f, 1.78769883e-02f, 1.65213525e-01f, 1.90820813e-01f, -1.06596854e-02f, 1.14651531e-01f, -6.27914025e-03f, 2.18268540e-02f, 1.39261499e-01f,
  1.16359755e-01f, -5.40732592e-02f, 6.18828945e-02f, 7.51900598e-02f, 5.95400669e-02f, -5.03204130e-02f, -1.29368439e-01f, -1.20759159e-01f, -6.46372661e-02f, -6.70123622e-02f,
  1.33749902e-01f, 9.99507383e-02f, 1.77916124e-01f, 5.41673973e-02f, -3.51496488e-02f, -9.05811489e-02f, 7.02710748e-02f, -3.59694324e-02f, -1.04937904e-01f, -1.01230174e-01f,
  -7.10844919e-02f, 2.93765385e-02f, 7.86176249e-02f, 4.39186022e-02f, -1.97199769e-02f, 1.12520061e-01f, 7.58135170e-02f, 4.12988029e-02f, 1.25894204e-01f, 4.16169316e-02f,
  1.51328440e-03f, 4.16693278e-02f, -2.06535503e-01f, -4.82886210e-02f, -7.96060115e-02f, -3.33145037e-02f, 5.17781004e-02f, 7.53673539e-02f, 5.64928725e-02f, -1.59216337e-02f,
  1.34348199e-01f, -4.19628359e-02f, 4.36854661e-02f, 1.38945177e-01f, 1.15505323e-01f, 3.28196213e-02f, -7.04171807e-02f, 1.21535137e-01f, 1.15430141e-02f, -8.82897759e-04f,
  -1.13161243e-01f, -2.34152954e-02f, 2.97508519e-02f, -9.07874852e-02f, 1.04864784e-01f, -5.74004464e-03f, 5.15255630e-02f, -3.73199657e-02f, -1.43970937e-01f, 1.55282721e-01f,
  -8.88539329e-02f, 1.14636114e-02f, 5.21010682e-02f, -1.80762988e-02f, -1.41643488e-03f, -5.04707471e-02f, 1.28490880e-01f, -3.10970228e-02f, -1.54759679e-02f, 1.01394549e-01f,
  -8.56666267e-03f, 7.23936483e-02f, -3.57159860e-02f, -1.05239704e-01f, 5.24122603e-02f, -1.10605411e-01f, 9.56372842e-02f, 1.34600282e-01f, 7.78753236e-02f, -1.77350268e-02f,
  -1.58995062e-01f, -5.73710613e-02f, -1.60849169e-01f, -6.95747882e-02f, -4.00830694e-02f, -1.08504370e-02f, 8.18561539e-02f, 8.47322028e-03f, 2.16054972e-02f, 7.52976835e-02f,
  -3.31547260e-02f, -1.97382465e-01f, -1.87511428e-03f, -1.21426441e-01f, -8.53472129e-02f, 1.52096957e-01f, -3.89034785e-02f, -1.60172969e-01f, -2.37886980e-02f, -2.05858648e-01f,
  5.89671079e-03f, 6.10142387e-02f, 1.00231089e-01f, 7.40271136e-02f, 2.10239142e-02f, -5.42571619e-02f, -2.29254342e-03f, 5.85655756e-02f, 5.04473783e-02f, -2.77867019e-01f,
  -4.91595902e-02f, -1.15856025e-02f, -9.35620442e-02f, -6.10234737e-02f, -1.82365209e-01f, 7.32762218e-02f, 2.47805864e-02f, -2.02345982e-01f, 1.20565660e-01f, -9.54899341e-02f,
  3.52990367e-02f, -1.41352013e-01f, -1.64979905e-01f, -1.61782265e-01f, 1.60190053e-02f, -9.73393172e-02f, 6.76471135e-03f, -5.18673994e-02f, -7.96429664e-02f, 5.58103947e-03f,
  -1.89047426e-01f, -9.65316072e-02f, -1.22478660e-02f, -1.16857089e-01f, 1.74074501e-01f, -1.75623372e-02f, 1.33990906e-02f, 7.45775104e-02f, -1.68331593e-01f, 3.92241478e-02f,
  1.02440856e-01f, 3.60413529e-02f, 5.86028472e-02f, 1.23482823e-01f, -6.08409569e-02f, 1.69530794e-01f, -5.46457916e-02f, 9.41526890e-02f, 1.65845342e-02f, 7.53323454e-03f,
  -4.69205193e-02f, 6.59690425e-02f, 6.13627546e-02f, 9.54935700e-02f, 5.01952432e-02f, 3.59064192e-02f, 1.28226370e-01f, -4.91427369e-02f, -3.89197357e-02f, 4.78274375e-02f,
  1.38137087e-01f, 5.53862005e-02f, 7.91154876e-02f, -5.16779758e-02f, 1.17334545e-01f, -3.88669483e-02f, 1.03750497e-01f, -3.26466858e-02f, 3.39121521e-02f, -1.41589604e-02f,
  1.33363893e-02f, 1.65864229e-01f, -3.62179354e-02f, 1.38205096e-01f, 3.91838439e-02f, 3.89315188e-02f, -3.84333916e-02f, 7.68554732e-02f, 1.80743877e-02f, 1.09625086e-01f,
  -6.80746604e-03f, 6.76952153e-02f, 7.05555379e-02f, 1.24421321e-01f, 3.42626721e-02f, 1.54826164e-01f, 1.29019827e-01f, 6.60276040e-02f, 6.27099723e-02f, 8.64927545e-02f,
  -2.68009212e-02f, 1.15725920e-01f, -3.72191891e-02f, -1.90394372e-02f, -4.27192450e-02f, -1.21622503e-01f, 1.31426737e-01f, 1.72967836e-01f, -9.29773822e-02f, -3.21446545e-02f,
  6.06015548e-02f, 8.54493827e-02f, 8.67328718e-02f, -8.39848444e-02f, -8.24852735e-02f, -1.26200691e-01f, -5.00872061e-02f, -1.12652384e-01f, -1.43822795e-03f, 8.29021409e-02f,
  -1.12223372e-01f, -6.51783049e-02f, 1.59269534e-02f, -4.08914126e-02f, 5.58177978e-02f, -1.15714155e-01f, -8.22873861e-02f, 1.92840025e-01f, 2.39625946e-02f, -1.09197862e-01f,
  -7.63647407e-02f, -1.39476016e-01f, -1.04439192e-01f, -7.16226995e-02f, 1.48422688e-01f, 7.25806355e-02f, -9.88668427e-02f, -2.48147245e-03f, -8.03709105e-02f, 1.67346105e-01f,
  6.11149110e-02f, 7.94385150e-02f, 1.79375738e-01f, 1.73781335e-01f, 1.05861329e-01f, -9.88828689e-02f, 1.47991061e-01f, 3.43073159e-02f, 2.35260632e-02f, -1.06100896e-02f,
  6.56559914e-02f, -1.37379616e-01f, -9.79921073e-02f, -7.98704848e-02f, -2.37113722e-02f, -1.33741096e-01f, -2.38060709e-02f, -1.58715501e-01f, 1.95254162e-02f, 9.71570015e-02f,
  -6.92497194e-02f, 2.88547389e-02f, 5.44766970e-02f, 5.53290062e-02f, 1.22543328e-01f, -1.29202649e-01f, 1.06334105e-01f, -3.85895222e-02f, -9.01877806e-02f, -6.99245334e-02f,
  -1.21567689e-01f, -9.55238640e-02f, 3.44904438e-02f, 1.37793757e-02f, -2.32181530e-02f, 1.14738345e-01f, 3.32367271e-02f, 5.93430512e-02f, 7.81714097e-02f, -3.16074714e-02f,
  1.85317360e-04f, -1.62926856e-02f, -1.97148286e-02f, -1.01738222e-01f, 2.97766179e-02f, 6.56669810e-02f, 4.61033918e-02f, 7.40241036e-02f, 3.71463001e-02f, 5.84065132e-02f,
  9.44457129e-02f, 6.54075965e-02f, -7.30088819e-03f, 1.34429112e-01f, 5.16989306e-02f, -5.14274016e-02f, -4.99403961e-02f, -8.64222944e-02f, -1.27268776e-01f, 1.36860111e-03f,
  4.17963509e-03f, -7.06121996e-02f, -7.14014918e-02f, 9.35654789e-02f, 5.46289720e-02f, -5.68118542e-02f, 1.15468867e-01f, 5.54381907e-02f, 8.31694975e-02f, 6.25207871e-02f,
  1.22363262e-01f, 6.68695271e-02f, 1.07201368e-01f, 1.22283444e-01f, 1.42298535e-01f, 3.76823880e-02f, -1.05625227e-01f, 5.50494976e-02f, 1.09648228e-01f, -1.10701263e-01f,
  -2.67011020e-03f, 1.81065485e-01f, -7.71906525e-02f, 9.87647027e-02f, 4.98260111e-02f, 1.00614503e-01f, -3.23650651e-02f, 1.92636475e-02f, -7.59003013e-02f, 9.74199641e-03f,
  -5.26229814e-02f, -1.19867049e-01f, 8.96137133e-02f, -9.69130024e-02f, -3.97575274e-03f, 1.33174345e-01f, -4.49114256e-02f, 1.48392990e-02f, -3.35729569e-02f, 8.85952786e-02f,
  1.14574783e-01f, -4.88251708e-02f, 2.96091326e-02f, -9.73718762e-02f, 1.82877809e-01f, -6.78311065e-02f, -1.17020652e-01f, -6.37645926e-03f, 9.98607501e-02f, 1.33797586e-01f,
  -5.01818769e-02f, -8.38821102e-03f, -7.27306828e-02f, 7.20172450e-02f, -1.84692577e-01f, 1.47952288e-02f, -9.55543742e-02f, -1.66265845e-01f, 8.56295899e-02f, 5.23800701e-02f,
  8.61774292e-03f, 1.42203540e-01f, 4.75836508e-02f, 2.10189223e-02f, 9.88574699e-02f, -7.16437846e-02f, 1.25691086e-01f, 8.44618231e-02f, 1.07736543e-01f, -4.53540310e-03f,
  9.60215852e-02f, -4.22519483e-02f, -1.26763657e-01f, 1.51953921e-01f, -7.29062110e-02f, -3.63487005e-03f, 1.17407655e-02f, 9.03580114e-02f, -8.15793201e-02f, 4.38868925e-02f,
  -5.81429265e-02f, -6.32526958e-03f, 3.13882343e-02f, -3.88984680e-02f, 1.00477803e-02f, 1.16343389e-03f, -1.08682670e-01f, -1.17332630e-01f, -1.23117313e-01f, -1.88521996e-01f,
  1.06448401e-02f, -2.19574630e-01f, -6.26324415e-02f, -1.19247725e-02f, -2.06974849e-01f, -3.99770634e-03f, 1.99363530e-02f, 1.76018775e-01f, -1.35085002e-01f, 1.94767356e-01f,
  -2.67012399e-02f, -6.40685782e-02f, 5.55394776e-02f, 1.88029900e-01f, 5.44420145e-02f, -1.66399226e-01f, 2.13971175e-02f, -1.38406098e-01f, -1.27888411e-01f, 1.09258085e-01f,
  6.89885616e-02f, 1.12688124e-01f, 8.47835690e-02f, 2.78035309e-02f, 6.05919678e-03f, -3.03454138e-02f, -4.91009466e-02f, 9.41334665e-03f, 1.46437781e-02f, -5.40484712e-02f,
  3.15542631e-02f, 5.83136790e-02f, -1.20802701e-01f, 9.64871496e-02f, -5.31369995e-04f, -5.01449639e-03f, -8.88745040e-02f, 7.26688877e-02f, -3.01069836e-03f, -5.73492981e-02f,
  -8.35198238e-02f, 7.27167726e-02f, -2.13839952e-02f, -8.57873559e-02f, -7.72450026e-03f, -6.49620742e-02f, 9.17154253e-02f, -1.95958000e-02f, -6.10894971e-02f, -4.72517721e-02f,
  3.86365801e-02f, -6.90950602e-02f, -4.83462848e-02f, 1.06357589e-01f, -7.93300346e-02f, 7.22008198e-02f, 8.72564092e-02f, 2.27919045e-05f, 8.28282163e-03f, 6.12573922e-02f,
  3.47411521e-02f, -1.86966080e-02f, 9.63477194e-02f, -7.62131289e-02f, -1.98954940e-02f, 1.06879994e-01f, 5.98564558e-02f, 5.95145021e-03f, -3.97745259e-02f, -4.16307598e-02f,
  -3.87227982e-02f, -1.82713896e-01f, 9.61048976e-02f, 7.77791813e-02f, 7.20351785e-02f, -2.86138374e-02f, -3.42419930e-02f, 2.02407092e-02f, 4.12049405e-02f, -7.93730244e-02f,
  1.57987431e-01f, -4.60698791e-02f, 1.28954902e-01f, -5.69544779e-03f, -6.71917424e-02f, 1.17160790e-01f, -2.08713189e-02f, 2.66543627e-02f, 1.60816208e-01f, -1.18611753e-01f,
  -1.03255194e-02f, -9.66229662e-02f, -7.67530128e-02f, -5.52445203e-02f, -9.55203176e-02f, 3.76872420e-02f, -3.30957323e-02f, 4.90332171e-02f, -1.05857238e-01f, -5.28840125e-02f,
  -1.71862647e-01f, 6.42925426e-02f, 1.85043916e-01f, -6.75546974e-02f, 4.01176214e-02f, 8.05946649e-04f, 5.89455664e-02f, -1.25696406e-01f, 1.77036107e-01f, 1.38079077e-01f,
  -1.17260776e-01f, 1.51615357e-02f, -1.89166352e-01f, 7.29275644e-02f, -2.46287044e-02f, 1.58348396e-01f, 3.07959672e-02f, -2.58492511e-02f, 1.07215136e-01f, -1.13361664e-02f,
  6.16938621e-02f, 1.18622296e-01f, -1.26072064e-01f, 2.03443781e-01f, -1.86391771e-01f, -1.51535779e-01f, 2.56469082e-02f, -1.78167179e-01f, 2.77348161e-02f, -1.71952650e-01f,
  -9.57196653e-02f, 9.96541232e-02f, 8.31574425e-02f, -4.23375983e-03f, 1.22609071e-01f, 2.09833607e-01f, -2.65674796e-02f, -4.35011871e-02f, -1.46669045e-01f, 1.27302587e-01f,
  8.29154253e-03f, 4.62742150e-02f, 2.02807918e-01f, -5.88927651e-03f, 6.68705255e-02f, -1.25815779e-01f, -1.41628861e-01f, 1.69275746e-01f, 6.77888021e-02f, 1.63437009e-01f,
  1.12589002e-02f, 5.56802899e-02f, -4.59730886e-02f, -2.71714199e-03f, 3.12749967e-02f, 2.65811328e-02f, 8.36203098e-02f, 2.16356851e-02f, 3.34489010e-02f, -1.07283527e-02f,
  -1.03752196e-01f, -3.26897763e-02f, -1.30128313e-03f, -7.43883774e-02f, 3.30509655e-02f, 8.14399198e-02f, 2.93693207e-02f, 6.56541735e-02f, 6.73937262e-04f, -3.28545794e-02f,
  -1.71331484e-02f, 1.45793138e-02f, 4.00993563e-02f, -3.89462076e-02f, 7.45296627e-02f, -3.40875387e-02f, -2.00448800e-02f, 1.87571570e-02f, 2.34176535e-02f, 1.90713760e-02f,
  -2.80906782e-02f, 1.00548230e-01f, 5.74982679e-03f, -4.91946563e-02f, -6.09375127e-02f, -2.38411054e-02f, -3.26678082e-02f, -1.19253509e-01f, 6.10447936e-02f, -1.06452797e-02f,
  2.14039292e-02f, 5.92457540e-02f, -7.50689358e-02f, 2.69751041e-03f, -8.19820259e-03f, 6.27745017e-02f, 6.44820929e-02f, -9.03951377e-02f, 1.14851333e-02f, -1.21816568e-01f,
  6.46849647e-02f, -2.12060958e-02f, -8.07659626e-02f, -1.01935618e-01f, -9.45183635e-02f, -6.43958971e-02f, -7.90430754e-02f, -6.13919571e-02f, 4.67305779e-02f, -5.57278283e-03f,
  8.67939815e-02f, -5.45424111e-02f, 8.99069849e-03f, 5.00945114e-02f, 1.54474974e-02f, 2.57711671e-02f, 1.07351832e-01f, 9.63713303e-02f, -3.92315425e-02f, -1.13326490e-01f,
  7.49367252e-02f, -5.63674457e-02f, 6.07859418e-02f, 1.16931960e-01f, 7.05995634e-02f, 1.11273259e-01f, -1.58831328e-01f, -8.27386752e-02f, -1.16146766e-01f, 1.51177779e-01f,
  -1.22787923e-01f, 1.23233750e-01f, 2.27896851e-02f, -5.61392953e-05f, 3.66253927e-02f, -1.49348006e-01f, 2.70680953e-02f, 4.29651253e-02f, -2.05798909e-01f, -1.19026713e-01f,
  -1.45501137e-01f, 5.65959215e-02f, -1.90205261e-01f, 1.48769051e-01f, 1.34751961e-01f, 2.95087099e-02f, 1.81380421e-01f, 8.48311484e-02f, -3.66320275e-02f, 9.19002071e-02f,
  -2.49204244e-02f, -1.36111125e-01f, -4.42415439e-02f, 8.98089707e-02f, 2.85933837e-02f, 4.28764261e-02f, -7.81705230e-02f, -1.70703232e-02f, -3.80037017e-02f, 8.28872323e-02f,
  7.65822604e-02f, -8.74490514e-02f, 5.09994328e-02f, 1.13724619e-01f, -2.40750283e-01f, 1.08410127e-01f, -1.43409774e-01f, 1.12167262e-01f, -9.94318351e-02f, -1.56193286e-01f,
  4.04894873e-02f, -5.60484231e-02f, -1.77007020e-01f, 1.14515843e-02f, 1.40019745e-01f, -1.09991223e-01f, 3.63824479e-02f, -8.49682540e-02f, -4.70144600e-02f, -8.46979767e-02f,
  4.17387411e-02f, 2.61913836e-02f, -2.04384141e-02f, -3.81311625e-02f, -2.51468029e-02f, 5.70301451e-02f, -3.95882875e-02f, -8.25870112e-02f, -8.54145959e-02f, 1.95451453e-02f,
  -9.48522761e-02f, -2.19666380e-02f, -1.28033757e-01f, 4.78032604e-02f, 2.33613756e-02f, 3.92827243e-02f, -5.81923090e-02f, 4.34950367e-02f, -6.45985678e-02f, -4.21313895e-03f,
  7.00964406e-02f, -5.47429994e-02f, 1.00844139e-02f, -5.38889095e-02f, -6.23331070e-02f, -3.32133211e-02f, 4.19909544e-02f, -1.64528806e-02f, -2.82074753e-02f, 5.59199527e-02f,
  5.96818281e-03f, -7.77164102e-02f, -2.62150262e-02f, -4.95645143e-02f, 8.57992545e-02f, -3.58884186e-02f, -3.21308002e-02f, -7.41689801e-02f, -1.50258780e-01f, -2.74649672e-02f,
  6.82195323e-03f, -1.04722984e-01f, 1.31773412e-01f, -2.41742898e-02f, 5.69526618e-03f, 2.21427325e-02f, -5.31356782e-02f, 8.30835477e-02f, -1.49180025e-01f, -5.92343248e-02f,
  -4.17056568e-02f, 6.92964494e-02f, -9.14105866e-03f, -1.41477615e-01f, -1.61393881e-01f, 2.17607729e-02f, 8.49578530e-03f, 1.44157767e-01f, 7.03848600e-02f, 1.12933241e-01f,
  -1.72203511e-01f, -1.91244900e-01f, 4.18441147e-02f, -2.88454704e-02f, -5.82685433e-02f, 6.20464012e-02f, 1.35658802e-02f, 8.69223401e-02f, 1.99009776e-01f, -8.60563815e-02f,
  1.26814425e-01f, 2.08624229e-02f, -7.19444379e-02f, -1.51270211e-01f, 3.32281669e-03f, 6.75715953e-02f, -4.77070920e-02f, -2.39347100e-01f, 4.68786806e-02f, -6.12604730e-02f,
  1.41308876e-02f, 2.40594242e-02f, 1.03920840e-01f, 2.92890444e-02f, -1.38071358e-01f, -6.80445805e-02f, -7.14052143e-03f, 1.32335022e-01f, -8.28851573e-03f, -1.29831612e-01f,
  1.27034634e-03f, -1.76763594e-01f, -1.11445293e-01f, -8.52440298e-02f, -4.59525697e-02f, 1.15869403e-01f, -7.76227564e-02f, -1.81325987e-01f, 2.21055746e-01f, 1.17801987e-01f,
  9.72442850e-02f, -4.40438353e-02f, 3.31143588e-02f, -9.53486487e-02f, -1.03907138e-01f, -1.76919967e-01f, -7.21436739e-02f, 7.95217678e-02f, -5.42825051e-02f, 2.85092592e-02f,
  -1.52086109e-01f, -2.37290293e-01f, 1.00524865e-01f, -3.55986916e-02f, 1.08809792e-01f, 4.37329039e-02f, 5.13649955e-02f, 1.37975499e-01f, -2.52080500e-01f, 2.76965499e-02f,
  3.71080004e-02f, 5.75639606e-05f, 1.25703253e-02f, 1.42203972e-01f, 7.25332499e-02f, 2.58775875e-02f, 4.38216701e-02f, 3.12310904e-02f, 2.08462980e-02f, 1.02030106e-01f,
  -7.04056770e-02f, -5.68257123e-02f, 2.17634216e-01f, -1.24004744e-01f, -3.09483167e-02f, -2.75787152e-02f, 1.22993715e-01f, 3.10614854e-02f, 7.52911046e-02f, 8.04425329e-02f,
  1.46368623e-03f, -6.24979548e-02f, -7.58752227e-02f, -6.17378317e-02f, 1.28351664e-02f, 3.87916993e-03f, -1.62098631e-02f, 1.70339812e-02f, 1.04078792e-01f, -3.75181288e-02f,
  4.11450081e-02f, 9.48217437e-02f, 2.73653981e-03f, 4.99131419e-02f, 1.14922514e-02f, 6.76869554e-03f, 1.77909690e-03f, 2.42950134e-02f, -4.96820025e-02f, 6.73461035e-02f,
  7.15881735e-02f, -4.32759076e-02f, 2.78527625e-02f, 9.41488892e-02f, 1.03085056e-01f, 1.20479248e-01f, 4.13603224e-02f, -5.81056662e-02f, -1.29815768e-02f, 6.53410563e-04f,
  1.04239501e-01f, 6.03895150e-02f, 2.18898393e-02f, -4.26209606e-02f, 2.45300978e-02f, -1.16035091e-02f, 2.11769894e-01f, 5.42238094e-02f, 5.29958457e-02f, -7.16118887e-02f,
  7.87058473e-02f, 1.41893001e-02f, 2.08719686e-01f, 5.21778390e-02f, 1.27382651e-01f, -2.11013198e-01f, 1.85045414e-02f, -6.58610016e-02f, -1.01642102e-01f, 9.84022915e-02f,
  1.81586057e-01f, 1.20894149e-01f, 8.04208443e-02f, -3.32977180e-03f, -9.74394009e-02f, -1.05153434e-01f, -1.88553005e-01f, 1.15345478e-01f, -7.48206526e-02f, -6.29224330e-02f,
  -5.87785663e-03f, 6.80425689e-02f, -1.92161668e-02f, 3.87893841e-02f, 1.42985627e-01f, 1.15519233e-01f, 7.48555548e-03f, -1.15720078e-01f, -6.83044642e-02f, 1.84576556e-01f,
  6.83955699e-02f, -1.12706788e-01f, 5.59849627e-02f, 1.44095376e-01f, 5.39703779e-02f, -5.26108779e-02f, -7.20870197e-02f, 1.54582292e-01f, -9.00939330e-02f, 1.96199864e-01f,
  -2.00621486e-02f, 1.16332352e-01f, -4.88041118e-02f, -1.69857368e-01f, 9.03460234e-02f, -1.48590311e-01f, -1.45004854e-01f, -2.58968733e-02f, -1.13479204e-01f, 1.02254324e-01f,
  -1.89733282e-02f, -2.89643910e-02f, 1.25297010e-01f, 4.53109220e-02f, 7.91694149e-02f, 1.67346001e-02f, -8.93346220e-02f, 1.58666950e-02f, 1.51406422e-01f, 3.18875946e-02f,
  -1.35237992e-01f, 5.63299395e-02f, -1.00743540e-01f, -2.00937703e-01f, 3.06823794e-02f, 4.64416593e-02f, 5.94519414e-02f, -2.55804569e-01f, 9.81167108e-02f, 2.48746593e-02f,
  -1.21805452e-01f, 3.40560339e-02f, -9.73851010e-02f, -2.84951162e-02f, 1.99382789e-02f, -1.21571243e-01f, 4.47565354e-02f, -9.82415024e-03f, -9.83408745e-03f, -3.51348892e-02f,
  -1.69432521e-01f, -1.75412260e-02f, 3.03871501e-02f, 5.56273796e-02f, 3.86741050e-02f, -4.09730524e-02f, 5.94142228e-02f, 9.27083287e-03f, -1.30165368e-01f, -1.04048535e-01f,
  2.09193025e-02f, -2.19787657e-02f, -4.06964831e-02f, 1.31326839e-02f, 1.07674748e-01f, 4.44476400e-03f, -4.62019853e-02f, -2.68001258e-02f, -8.08753446e-02f, -6.54498637e-02f,
  -1.46904439e-02f, 6.09751604e-03f, 3.15341242e-02f, 7.43436590e-02f, 2.61356365e-02f, 2.35907659e-02f, -9.90490466e-02f, 6.42711436e-03f, 8.53991210e-02f, -1.23449527e-01f,
  -2.80810334e-02f, -9.30448025e-02f, 3.44809704e-02f, 5.22919334e-02f, -1.09916553e-01f, 1.04931273e-01f, 9.59468037e-02f, -7.51619712e-02f, -3.26796174e-02f, 6.05753474e-02f,
  -4.68961820e-02f, -1.08553708e-01f, 1.11956254e-01f, 3.82462963e-02f, -1.03259273e-01f, 2.81822179e-02f, -6.46409299e-03f, -4.51697446e-02f, -8.87173340e-02f, -7.26146698e-02f,
  -1.38283357e-01f, -1.09673329e-01f, 3.31605449e-02f, 1.67896166e-01f, -2.88122930e-02f, -3.85643984e-03f, -6.84850216e-02f, -3.97196636e-02f, 1.63853485e-02f, -4.86094393e-02f,
  -1.21793263e-01f, 2.09480394e-02f, 2.71743424e-02f, 1.51813552e-01f, 1.46836778e-02f, 1.04694568e-01f, 1.62668392e-01f, -1.77413017e-01f, 1.26339599e-01f, -8.81742910e-02f,
  1.00134149e-01f, 9.36534256e-02f, 1.28286704e-01f, -5.77135012e-02f, -5.54685369e-02f, -1.60347641e-01f, -6.14944957e-02f, -6.68006912e-02f, 1.56778451e-02f, 5.17236739e-02f,
  -1.00586243e-01f, -1.86999887e-01f, 8.37438330e-02f, 3.23087834e-02f, 1.46170571e-01f, -2.12486088e-01f, 6.92006946e-02f, -1.61482006e-01f, -3.99228744e-02f, -9.01163965e-02f,
  -1.07216075e-01f, 1.32696688e-01f, -3.25948894e-02f, -2.32249275e-01f, 1.70088902e-01f, 9.47039202e-02f, 6.52362555e-02f, -9.05639157e-02f, -2.39656121e-01f, 4.23867702e-02f,
  -7.95014873e-02f, -6.81870058e-02f, -5.71257100e-02f, -3.31828259e-02f, -1.98902607e-01f, -1.77870318e-02f, -2.60952622e-01f, -1.49861962e-01f, -9.43525787e-03f, 4.50861789e-02f,
  1.72671065e-01f, -2.40135822e-03f, 3.95042859e-02f, -1.52919441e-02f, -6.07411489e-02f, -5.14422283e-02f, -4.34394293e-02f, 3.97823006e-02f, 8.08918476e-02f, 4.18364368e-02f,
  -1.03210509e-01f, -1.33973509e-01f, 2.09006052e-02f, -8.57915804e-02f, 1.78721864e-02f, 1.33198515e-01f, -1.41944811e-01f, -2.62923166e-02f, -4.39601056e-02f, 2.23054849e-02f,
  -7.91006014e-02f, -5.13313450e-02f, -2.63654627e-02f, 3.76233794e-02f, 9.50501934e-02f, -1.22513827e-02f, 3.00658550e-02f, -1.41292229e-01f, -3.06814294e-02f, -3.78944501e-02f,
  -1.40018463e-01f, 9.00484473e-02f, 9.45585594e-03f, -1.60578042e-02f, -3.83859314e-02f, 7.76648670e-02f, 2.54729018e-02f, -1.31714523e-01f, 2.12087985e-02f, -5.37231863e-02f,
  -4.78523001e-02f, -6.52074069e-02f, 8.74012336e-02f, -4.61900793e-02f, -1.76053997e-02f, -6.45389929e-02f, 1.89790700e-03f, -1.63450316e-01f, 4.17995937e-02f, 1.07104085e-01f,
  -1.33636845e-02f, 5.57265021e-02f, 3.31097096e-02f, -9.94911194e-02f, 1.14629172e-01f, 1.24083951e-01f, -4.76058424e-02f, -1.42696099e-02f, 2.97187865e-02f, 3.14873755e-02f,
  2.11856961e-02f, 1.16291486e-01f, -1.36339173e-01f, 9.28505138e-02f, 9.03026015e-02f, -1.43850729e-01f, -7.69866779e-02f, 1.76267162e-01f, -1.97408363e-01f, 1.92851182e-02f,
  -8.19401368e-02f, -1.18231624e-01f, 7.24654570e-02f, -3.56942639e-02f, -7.85173476e-02f, 7.39497542e-02f, 8.41233805e-02f, -2.45270748e-02f, 1.43830791e-01f, -1.80326626e-02f,
  -6.41205013e-02f, -2.03297776e-03f, 6.68827742e-02f, -4.42183018e-02f, -9.97403786e-02f, -5.56777455e-02f, -1.84694119e-02f, -1.70245429e-03f, 1.65112242e-01f, -3.20437290e-02f,
  1.18878789e-01f, 4.89209034e-03f, 9.92668420e-02f, 7.56149413e-04f, 1.41573017e-02f, -7.26265609e-02f, -1.01690039e-01f, -5.60183898e-02f, -3.83949988e-02f, -1.61237970e-01f,
  -1.72246109e-05f, 1.08723797e-01f, -1.21083885e-01f, -7.11903870e-02f, 1.91758409e-01f, 2.26313211e-02f, 7.95406848e-02f, 1.39695898e-01f, 6.92977831e-02f, 1.90821961e-02f,
  3.24874297e-02f, -1.34417593e-01f, 8.06824937e-02f, 1.92787185e-01f, -2.34215930e-01f, -6.58995658e-02f, -1.43902615e-01f, -2.23201334e-01f, 1.32705525e-01f, 6.78660572e-02f,
  3.88470180e-02f, 7.14428350e-02f, -1.63112581e-01f, 6.21141493e-02f, -1.02688089e-01f, 9.92587768e-03f, 1.41800679e-02f, 1.86823487e-01f, -1.15220353e-01f, -1.71134651e-01f,
  -9.87498928e-03f, -8.48005060e-03f, 1.59194708e-01f, -1.65062904e-01f, 6.06129915e-02f, 7.53888711e-02f, -9.59685966e-02f, 8.15146565e-02f, 1.97186042e-02f, -2.38412675e-02f,
  9.37976614e-02f, 3.01912124e-03f, 4.97509167e-03f, -1.22149615e-02f, -3.35986987e-02f, 3.30231413e-02f, 2.73387171e-02f, -3.76749560e-02f, 3.29122916e-02f, 9.44898278e-02f,
  5.77557757e-02f, 3.79259102e-02f, -2.89076250e-02f, -4.55636419e-02f, 1.89602952e-02f, -4.65734425e-04f, 3.32419053e-02f, 4.38409522e-02f, -1.41264811e-01f, -4.52269092e-02f,
  9.11316201e-02f, 7.31652379e-02f, -4.44583371e-02f, 3.88469920e-02f, -2.40425635e-02f, -9.48559027e-03f, -9.02514234e-02f, -8.51583630e-02f, -5.46625024e-03f, -1.88970398e-02f,
  7.49269277e-02f, 3.50621082e-02f, 6.79925370e-06f, 1.01507887e-01f, -4.30306308e-02f, -5.17882667e-02f, -4.69340739e-04f, -2.87609212e-02f, 1.53297298e-02f, 7.92064667e-02f,
  1.36301532e-01f, -1.98182330e-01f, 2.95517370e-02f, 1.10798411e-01f, -7.83863291e-02f, 5.53121753e-02f, -4.54379953e-02f, -2.32342929e-02f, 2.34076008e-02f, 1.38087049e-01f,
  6.15884960e-02f, 1.38499681e-02f, 1.22558303e-01f, 9.35190395e-02f, -5.32938801e-02f, 3.57674062e-02f, 6.33354783e-02f, 1.40166715e-01f, 3.95158008e-02f, -8.24951455e-02f,
  6.91097677e-02f, 1.91289764e-02f, 3.13272811e-02f, 9.29050031e-04f, 9.33958218e-02f, -1.95979234e-02f, -4.75014597e-02f, -5.73734641e-02f, 2.77698115e-02f, -7.96030089e-02f,
  -7.25376979e-02f, -1.24503866e-01f, -1.37304030e-02f, 1.83861218e-02f, 1.37175322e-01f, 2.38319770e-01f, 4.66465503e-02f, -1.02392502e-01f, 6.14786297e-02f, 1.08732998e-01f,
  2.07840800e-02f, -8.72094780e-02f, 8.92189443e-02f, -1.05457254e-01f, 5.47350012e-02f, -4.79906984e-02f, -2.68395618e-02f, -1.27110239e-02f, 6.40045479e-02f, -9.18514282e-02f,
  -6.27470315e-02f, 1.86534911e-01f, 8.85043815e-02f, 1.14223123e-01f, -2.61462126e-02f, 2.01498732e-01f, 1.19591936e-01f, -5.41852526e-02f, -3.54472436e-02f, 1.39544293e-01f,
  -1.59168690e-01f, 2.17813134e-01f, -1.99366912e-01f, -2.80866623e-02f, -1.71286732e-01f, -4.36026864e-02f, -2.38032043e-01f, -2.88540702e-02f, -8.35860446e-02f, -2.70502884e-02f,
  -1.48264825e-01f, 7.11737052e-02f, 1.65745586e-01f, 9.71669108e-02f, -7.95208514e-02f, -1.70374308e-02f, -1.06849372e-01f, 1.39921129e-01f, 9.82832238e-02f, 1.00297429e-01f,
  2.12889448e-01f, -4.56168130e-02f, -1.63032059e-02f, -4.60756160e-02f, -7.19811842e-02f, 8.29325616e-02f, 8.99542123e-02f, -7.75453448e-02f, -9.25206244e-02f, 1.47137213e-02f,
  -1.83408440e-03f, 1.36880605e-02f, 6.73879609e-02f, -5.00364266e-02f, 1.85082934e-03f, 2.48097628e-02f, -8.43555480e-02f, 4.90377955e-02f, -1.87184606e-02f, -1.92528311e-03f,
  -3.96292061e-02f, -1.13272537e-02f, -1.38357386e-01f, 4.61780131e-02f, 2.42165588e-02f, -1.59153361e-02f, 5.92416078e-02f, 1.17049769e-01f, 1.02760501e-01f, 6.11155070e-02f,
  1.97777655e-02f, -6.56385645e-02f, -5.89876063e-02f, 5.19215912e-02f, -4.20977436e-02f, -5.94868464e-03f, 6.46682382e-02f, 8.04749802e-02f, 5.95272984e-04f, 7.90846050e-02f,
  -3.01964581e-02f, 3.88274267e-02f, -8.56511854e-03f, 1.65935233e-02f, -6.52325451e-02f, -2.40918528e-02f, -7.83734117e-03f, -8.44376162e-02f, -1.31135836e-01f, 3.40539552e-02f,
  2.75174715e-02f, -3.74634676e-02f, 6.02591783e-03f, 1.30336717e-01f, 9.60027426e-03f, -4.92548421e-02f, 4.17810231e-02f, -9.29988101e-02f, -1.31633535e-01f, -1.80506796e-01f,
  -5.73008470e-02f, -5.85947037e-02f, -1.85464755e-01f, -1.52487144e-01f, -1.00031994e-01f, -2.04238772e-01f, 6.07848354e-02f, -7.27040321e-02f, -1.57324910e-01f, 3.38655300e-02f,
  -2.84026414e-01f, 1.37598753e-01f, 4.11680751e-02f, 3.86586506e-03f, 7.77667994e-03f, 1.37896061e-01f, 2.09800117e-02f, 1.73833668e-01f, 1.21907540e-01f, 6.16431795e-02f,
  -6.40596300e-02f, -1.60707012e-01f, -2.10237235e-01f, -1.27569735e-01f, -9.50943753e-02f, 5.74133061e-02f, 1.05727255e-01f, -6.06879070e-02f, -2.29660403e-02f, -9.40077305e-02f,
  -1.27346694e-01f, 9.83311012e-02f, 1.37671098e-01f, -1.53670400e-01f, 1.18819878e-01f, 1.21659949e-01f, 1.95107684e-02f, -3.91448028e-02f, 1.49720550e-01f, -9.99708399e-02f,
  -1.06110416e-01f, 1.65581964e-02f, -4.48227227e-02f, -2.45770253e-02f, -9.76794064e-02f, 1.49053829e-02f, -9.60193202e-02f, -9.26586017e-02f, 4.60642949e-02f, 1.16126381e-01f,
  9.27216858e-02f, 8.64143763e-03f, -1.19459718e-01f, 5.39054945e-02f, 3.00371587e-01f, 1.29006645e-02f, -7.58930109e-03f, 1.37895748e-01f, 2.67307591e-02f, 8.40834826e-02f,
  -9.15119126e-02f, -9.06542540e-02f, -1.75079390e-01f, -2.34788135e-01f, 1.22764532e-03f, -1.36483938e-01f, -1.07233860e-01f, 1.55947924e-01f, -1.62845701e-01f, -5.16638421e-02f,
  -1.40628591e-01f, 4.94949073e-02f, -4.94139083e-03f, 1.37342587e-01f, 1.38823539e-02f, 1.01959631e-01f, 5.03969677e-02f, 5.74165769e-02f, 3.12800631e-02f, -7.45908264e-03f,
  -3.60076837e-02f, 8.01017582e-02f, -1.91496368e-02f, 1.08919449e-01f, -1.73017522e-03f, 1.47004090e-02f, -1.78578328e-02f, -5.65703027e-02f, 2.99486984e-02f, 8.81425515e-02f,
  -2.48472299e-02f, -2.44969223e-02f, -5.52552268e-02f, 2.24022791e-02f, 1.71415702e-01f, 1.23472689e-02f, 3.45446542e-03f, 6.55012876e-02f, 1.19845755e-03f, -3.42352712e-03f,
  -3.90952900e-02f, 7.84789324e-02f, 1.35006413e-01f, 1.98756866e-02f, -2.29116566e-02f, -7.61031657e-02f, -5.42700216e-02f, -7.36167580e-02f, -4.18078788e-02f, -4.72375825e-02f,
  -9.37366579e-03f, 9.18880627e-02f, 7.52839148e-02f, 2.84112431e-02f, -3.67057770e-02f, 1.74034074e-01f, -5.03026322e-02f, 9.92586538e-02f, -1.14265375e-01f, 1.47755757e-01f,
  -7.82667994e-02f, -9.24316272e-02f, 1.61432344e-02f, -2.08567572e-03f, 7.43327439e-02f, -7.47085214e-02f, -4.27084751e-02f, 1.27980784e-01f, -1.15457691e-01f, -1.41383648e-01f,
  5.53555265e-02f, 9.45497230e-02f, -1.89798370e-01f, 1.15255110e-01f, -1.58267751e-01f, -6.35451302e-02f, -7.34996647e-02f, 1.56567264e-02f, 9.24734026e-02f, -2.83788219e-02f,
  -1.55622914e-01f, 1.01117985e-02f, 1.18485220e-01f, -1.38087228e-01f, -6.64360225e-02f, -1.43943712e-01f, -9.41372290e-03f, -1.40604302e-01f, -1.13510236e-01f, -9.94882584e-02f,
  -6.26028627e-02f, -1.70305818e-01f, 1.53631298e-02f, -8.93912539e-02f, 2.39492301e-02f, 3.57084572e-02f, -1.71703435e-02f, 4.64229919e-02f, -1.25494925e-02f, -8.46842006e-02f,
  -5.63503616e-02f, 2.02099919e-01f, 1.30328789e-01f, 1.35410493e-02f, -4.94992100e-02f, -3.09809446e-02f, 6.65189400e-02f, 4.41886932e-02f, 1.59964845e-01f, -1.12192325e-01f,
  5.29206209e-02f, 1.59642711e-01f, 1.15488350e-01f, -5.25627136e-02f, 1.23795159e-01f, -1.36183891e-02f, -3.12940357e-03f, -4.91730198e-02f, 9.97748226e-02f, 5.91418631e-02f,
  8.34847987e-03f, -1.65263638e-02f, 1.40962377e-01f, 1.04706340e-01f, 1.24563888e-01f, -1.12239942e-01f, 5.56285344e-02f, -4.15544361e-02f, -2.28165075e-01f, 9.29316208e-02f,
  7.02150092e-02f, -9.89052653e-02f, 2.01993957e-01f, -2.88686782e-01f, -1.35901883e-01f, -9.15144905e-02f, 1.83924243e-01f, -1.55093633e-02f, 1.70104489e-01f, 5.70432805e-02f,
  8.07146654e-02f, -2.04231352e-01f, 7.87169561e-02f, 8.02505985e-02f, 7.84363225e-02f, 5.46719804e-02f, 1.55514777e-01f, 1.10481761e-01f, -7.18409196e-02f, 3.95012461e-02f,
  1.06679797e-01f, 2.09439006e-02f, -3.86449695e-02f, 7.08043352e-02f, 8.17162767e-02f, -3.52134183e-02f, 3.69615145e-02f, 2.80878209e-02f, -1.16484381e-01f, -7.07693771e-02f,
  -5.43071739e-02f, 9.83653814e-02f, 1.12469457e-01f, -2.47716159e-02f, 7.06953986e-04f, -1.70375630e-02f, 4.65452597e-02f, -7.64201358e-02f, 3.98468040e-02f, -9.07602347e-03f,
  8.43816698e-02f, 3.13368626e-02f, 8.93500596e-02f, -1.60397645e-02f, 4.79565188e-03f, 5.07806279e-02f, 7.14759827e-02f, 7.45633245e-02f, -2.68590916e-02f, -8.32550451e-02f,
  9.25833657e-02f, 6.66764826e-02f, -5.47210500e-02f, 4.62969244e-02f, -6.74586296e-02f, -2.22498756e-02f, 6.34853682e-03f, 1.44483179e-01f, 2.00188439e-02f, -3.58685404e-02f,
  4.25558612e-02f, -1.16592981e-01f, 2.93432754e-02f, -1.40699163e-01f, 8.73362124e-02f, -1.08787445e-02f, -1.25278980e-01f, -3.32692415e-02f, -1.70301348e-01f, 1.33314803e-01f,
  -9.70357656e-02f, 2.21820991e-03f, 8.25268179e-02f, -5.40891513e-02f, 2.58494876e-02f, -3.91938388e-02f, -1.64665490e-01f, 1.02738380e-01f, 3.69918607e-02f, 1.27141327e-01f,
  1.62374645e-01f, 3.54329795e-02f, -4.96572554e-02f, -3.19288149e-02f, -5.29409163e-02f, 4.36227303e-03f, -5.13233729e-02f, -2.74222400e-02f, 9.77719426e-02f, -5.36942184e-02f,
  -6.41628876e-02f, 8.45086202e-02f, 1.79898255e-02f, 7.31809884e-02f, -1.55467456e-02f, 6.59213308e-03f, 1.09274916e-01f, -1.07708961e-01f, -3.84882055e-02f, -7.78245507e-03f,
  2.57748775e-02f, 5.33074848e-02f, -1.82657942e-01f, -1.83081310e-02f, -1.36360466e-01f, -1.55660599e-01f, -6.75439555e-03f, 1.21794352e-02f, 1.26760915e-01f, 2.31389225e-01f,
  1.39780268e-01f, -1.24667987e-01f, -3.51240821e-02f, -1.64760519e-02f, 1.76229596e-01f, 1.76920041e-01f, -1.68868840e-01f, -9.68699306e-02f, -8.21147487e-02f, -1.50124416e-01f,
  -9.32787210e-02f, -1.62855446e-01f, -1.06423669e-01f, 1.06744654e-01f, -2.40263715e-01f, -8.01649839e-02f, -6.07471354e-02f, 1.28282607e-01f, -1.73516840e-01f, -5.91681823e-02f,
  2.76661087e-02f, -1.14018999e-01f, -1.27172291e-01f, 7.91056901e-02f, 1.13037169e-01f, -1.55148521e-01f, 6.83797151e-02f, -4.62808423e-02f, -8.42880905e-02f, 1.12555929e-01f,
  8.92300159e-02f, -1.81444976e-02f, -2.62937024e-02f, 9.52502862e-02f, 1.42281130e-01f, -1.12318946e-02f, -6.17298903e-03f, -9.19264567e-04f, 8.53321329e-02f, 1.29220495e-02f,
  5.19072562e-02f, 1.62515584e-02f, -7.08188340e-02f, 4.17509079e-02f, 6.86983839e-02f, -4.15174104e-02f, -3.31165977e-02f, -4.11021002e-02f, 8.09557363e-02f, 6.79940134e-02f,
  1.35689769e-02f, -6.02480322e-02f, 1.08819979e-03f, -5.14937192e-02f, -1.39491826e-01f, 4.49127257e-02f, 1.30694389e-01f, -5.74520566e-02f, -3.29937041e-02f, -7.41942525e-02f,
  -5.56519106e-02f, 6.27426580e-02f, 5.21597750e-02f, 6.20538704e-02f, 8.90579298e-02f, -5.01508266e-03f, -8.37769434e-02f, 7.85581768e-02f, 8.65746960e-02f, 7.03381300e-02f,
  -6.06156746e-03f, -6.50456101e-02f, -7.25187687e-03f, -5.34303263e-02f, -2.49197111e-02f, 7.02297166e-02f, 6.95405230e-02f, 5.84811643e-02f, 7.87691772e-02f, -5.10253794e-02f,
  -7.81718940e-02f, -1.00230999e-01f, 1.29221976e-01f, -3.71178463e-02f, 4.50186282e-02f, -9.64339823e-02f, -1.14173219e-01f, 1.40700921e-01f, 1.71543434e-02f, 8.72511566e-02f,
  3.24540883e-02f, -6.57647401e-02f, 8.94804448e-02f, -2.64757462e-02f, -7.50100538e-02f, 7.47157782e-02f, -1.28437459e-01f, 1.44105136e-01f, 1.12242647e-01f, -1.71671417e-02f,
  -7.63736516e-02f, -1.30698625e-02f, 4.05504480e-02f, -1.81655377e-01f, -1.41719943e-02f, 1.40323207e-01f, -4.10095342e-02f, 9.54125673e-02f, -1.32737175e-01f, -8.95422772e-02f,
  -1.40956238e-01f, 6.79990277e-02f, 4.17596921e-02f, -1.76264849e-02f, 7.89219663e-02f, -8.13455731e-02f, 2.40940452e-02f, -1.15558609e-01f, 1.24977484e-01f, 1.02487154e-01f,
  -1.47751793e-01f, -1.05123624e-01f, -6.11834116e-02f, 2.99242958e-02f, -1.26081750e-01f, 1.64707780e-01f, 1.01576336e-02f, 1.14244431e-01f, 1.37615189e-01f, 1.79586690e-02f,
  1.15763746e-01f, -2.26426106e-02f, -1.32310897e-01f, 1.50115952e-01f, -1.09954052e-01f, 9.58649740e-02f, 6.23336919e-02f, 8.64617303e-02f, -1.47338733e-01f, -1.92068666e-01f,
  -1.16023887e-02f, 2.13400513e-01f, -1.10754743e-02f, -3.24773304e-02f, 6.38339669e-02f, 1.82963401e-01f, -4.32588868e-02f, -1.23757057e-01f, 5.66148460e-02f, -4.29916345e-02f,
  1.82289798e-02f, 4.91170697e-02f, 1.68360204e-01f, 1.37397066e-01f, -2.06428790e-03f, -1.03440685e-02f, -5.86733446e-02f, 1.64600670e-01f, 7.21179992e-02f, -4.13479246e-02f,
  -5.46831228e-02f, -2.44980790e-02f, 6.37676194e-02f, 3.51617634e-02f, -2.22873203e-02f, 6.02285117e-02f, 2.45922781e-03f, 2.79892143e-02f, -4.61289808e-02f, 6.98838532e-02f,
  5.31137548e-02f, 1.08800188e-01f, 1.41933141e-02f, -7.02118054e-02f, 1.32393256e-01f, 7.10925385e-02f, 1.26653969e-01f, 9.66425017e-02f, -6.18748255e-02f, -3.91844362e-02f,
  1.21012758e-02f, 4.10327315e-02f, 1.43358123e-03f, -2.00250261e-02f, 1.45528197e-01f, -5.14816828e-02f, 2.66550109e-03f, 7.80638754e-02f, -2.35274453e-02f, 3.84425111e-02f,
  7.27085546e-02f, 9.16885736e-04f, -2.62561217e-02f, 9.82332453e-02f, 4.69891503e-02f, -4.98513654e-02f, 1.21783562e-01f, -6.58511668e-02f, 6.51284261e-03f, -5.97925894e-02f,
  3.98532152e-02f, -4.45277058e-02f, 4.65307347e-02f, -7.04471096e-02f, 9.30543467e-02f, -8.38643163e-02f, -5.18188206e-03f, -2.13461425e-02f, 9.83754247e-02f, 6.37643039e-02f,
  -1.36411384e-01f, 3.07677174e-03f, 1.45846354e-02f, 7.95328617e-02f, 1.03262626e-01f, 3.84545028e-02f, -1.37620717e-01f, 8.32651928e-02f, -8.77834335e-02f, 2.03370869e-01f,
  -8.04744102e-03f, -1.22667618e-01f, 1.83441043e-01f, -1.61396623e-01f, -1.33608013e-01f, -5.80965802e-02f, -1.11488983e-01f, -6.32017292e-03f, -3.24170925e-02f, -6.90747635e-04f,
  9.02629048e-02f, -7.47625455e-02f, 1.55254945e-01f, 1.40553698e-01f, 7.52179325e-02f, -5.30927926e-02f, 1.96820199e-01f, -8.97377506e-02f, -1.27007477e-02f, -8.18002820e-02f,
  -7.95058161e-02f, 1.15497023e-01f, 2.26453003e-02f, -2.36175567e-01f, -1.74127251e-01f, 6.89065233e-02f, -2.08891124e-01f, -2.37415120e-01f, -8.58899355e-02f, -5.28437644e-02f,
  -1.09434631e-02f, -9.84166786e-02f, 1.22310929e-01f, -7.03795180e-02f, 1.07942790e-01f, 1.63413752e-02f, -5.99102909e-03f, 1.99269637e-01f, 2.44141016e-02f, -5.74874729e-02f,
  1.22271232e-01f, -9.65112541e-03f, 1.27981886e-01f, 4.27026376e-02f, 4.97056283e-02f, -7.40168523e-03f, -2.07967207e-01f, -5.94268069e-02f, 5.30511364e-02f, 5.73711358e-02f,
  1.44290254e-02f, -4.89574745e-02f, -1.02558084e-01f, 1.28720086e-02f, 2.30027109e-01f, 1.06800899e-01f, 1.14895351e-01f, 8.92073885e-02f, -8.42870772e-02f, -1.17438704e-01f,
  4.69404496e-02f, 1.45274967e-01f, -6.59289956e-02f, 1.61003157e-01f, 3.40010189e-02f, -8.54051933e-02f, 1.14942482e-02f, 2.88107079e-02f, -6.09965995e-02f, -8.28825235e-02f,
  -7.85219297e-02f, 3.17287892e-02f, 7.37960916e-03f, 5.75037003e-02f, -1.72622666e-01f, 7.63029978e-03f, 1.21135831e-01f, 8.47462639e-02f, -5.19013789e-04f, 7.91396871e-02f,
  -1.46083906e-01f, -6.99206367e-02f, -7.10882545e-02f, -6.24466166e-02f, -7.26727322e-02f, 2.21414324e-02f, 7.58814365e-02f, -2.37637758e-02f, 1.13097085e-02f, -2.86262389e-02f,
  -9.08232182e-02f, 5.56559674e-03f, 9.17894319e-02f, 7.69188926e-02f, 7.04365671e-02f, -6.47922158e-02f, -8.06932598e-02f, 4.82619964e-02f, -1.41007319e-01f, 3.84893492e-02f,
  -5.17452843e-02f, -8.42796415e-02f, 2.04964802e-02f, -4.22802754e-02f, 5.58202900e-02f, -3.85128073e-02f, 2.34235134e-02f, 3.31922970e-03f, 8.73367712e-02f, 7.42526054e-02f,
  -9.12223905e-02f, 1.95025057e-02f, 1.80572346e-02f, -1.04283370e-01f, -9.92397889e-02f, -3.31648849e-02f, 2.54489686e-02f, 7.57014891e-03f, -1.31864129e-02f, -8.10612515e-02f,
  -1.50457963e-01f, 9.18444693e-02f, -1.57085042e-02f, 1.75418947e-02f, 3.91412228e-02f, -1.56881958e-01f, 5.07218093e-02f, 1.30630821e-01f, 1.29639655e-01f, -3.35753825e-03f,
  1.31317094e-01f, 1.14768622e-02f, -7.74284527e-02f, -3.07353213e-02f, -1.75699085e-01f, -1.12766676e-01f, 3.14151379e-03f, -2.45596729e-02f, 7.47403800e-02f, -4.56146337e-02f,
  8.78102332e-02f, 1.66464850e-01f, 5.46386838e-02f, -8.77664611e-03f, -1.84176847e-01f, 1.57377552e-02f, -1.63965672e-01f, -9.80402231e-02f, -1.15883395e-01f, 2.41961181e-02f,
  1.68478772e-01f, -1.36092693e-01f, 9.98570248e-02f, -8.56012478e-03f, -1.63566172e-01f, 7.28293955e-02f, -3.75282690e-02f, -4.84137125e-02f, -1.04215071e-01f, 4.33077216e-02f,
  -1.70661449e-01f, -1.08034527e-02f, 1.82567548e-03f, -7.72708803e-02f, 1.04443850e-02f, 1.94130912e-01f, -1.19068697e-01f, 1.85818285e-01f, -6.23027794e-02f, -2.54019629e-02f,
  -3.02267317e-02f, -1.60027638e-01f, 2.00334683e-01f, -4.89387475e-02f, -6.80321977e-02f, -9.35250595e-02f, -1.78147092e-01f, -8.51897225e-02f, 1.78823680e-01f, -3.95826772e-02f,
  6.31600991e-02f, -1.35695055e-01f, 1.19117312e-01f, 1.74828265e-02f, -4.42745686e-02f, 1.81489810e-01f, 7.55510032e-02f, -2.79748738e-02f, -8.64534602e-02f, 1.12461790e-01f,
  3.19511630e-03f, -8.30104202e-02f, 1.11608319e-01f, -6.24347031e-02f, 4.94415546e-03f, -6.97000558e-03f, -3.92944477e-02f, 6.25408143e-02f, -2.84000151e-02f, 8.33721384e-02f,
  -9.97016802e-02f, -1.28312543e-01f, 5.05781397e-02f, -5.99316545e-02f, -3.67692970e-02f, 2.04478372e-02f, 4.77166884e-02f, -1.09903418e-01f, 3.90917398e-02f, -7.09139109e-02f,
  1.56045705e-01f, -7.79555291e-02f, 2.33354364e-02f, -7.51619339e-02f, 5.54011315e-02f, -6.25676895e-03f, 1.28623154e-02f, 9.59777683e-02f, -4.86540124e-02f, 6.05766997e-02f,
  -8.64501595e-02f, -9.57462341e-02f, 7.34134838e-02f, 1.33268675e-02f, -2.30081808e-02f, -7.52936602e-02f, 8.58334452e-02f, 2.88307164e-02f, 2.17974950e-02f, 6.30934462e-02f,
  -1.99184893e-03f, -1.03537133e-02f, -1.01114564e-01f, -4.29608002e-02f, 7.07985684e-02f, 7.24624842e-02f, -3.24904546e-02f, -8.99285153e-02f, 1.15786895e-01f, 1.57833531e-01f,
  -1.29896626e-01f, 2.35740039e-02f, 9.51980613e-03f, 1.63056999e-02f, 1.44747868e-01f, 1.81202024e-01f, 9.55435634e-02f, 1.37684256e-01f, 1.05027027e-01f, 1.80843636e-01f,
  1.86843187e-01f, 8.69169757e-02f, -1.56091554e-02f, 1.99217305e-01f, -2.89824549e-02f, -1.11449055e-01f, 3.79540920e-02f, 3.89856286e-02f, 1.57115296e-01f, 6.19336069e-02f,
  1.26845837e-01f, -4.28915136e-02f, 1.71697289e-02f, 6.11307248e-02f, -9.86567438e-02f, -1.49093285e-01f, -6.10386916e-02f, 5.89154251e-02f, -1.11925174e-02f, -2.95725185e-02f,
  1.13177516e-01f, -2.56763380e-02f, 9.08076689e-02f, -1.13264933e-01f, 7.84824416e-02f, 1.00498907e-01f, -3.75161436e-03f, -1.01055294e-01f, 1.55009285e-01f, 8.44542775e-03f,
  -7.64909238e-02f, -4.95726280e-02f, -1.07969847e-02f, 8.19582418e-02f, 5.69315702e-02f, -1.66947544e-01f, -1.41653821e-01f, 3.51134352e-02f, 7.51348585e-02f, -3.46187651e-02f,
  -1.21870361e-01f, 2.31652439e-01f, -7.43189529e-02f, -8.99077952e-02f, 7.68203661e-02f, 5.88820837e-02f, -1.24994539e-01f, -1.96321502e-01f, -7.18595460e-02f, 6.80025667e-02f,
  -1.00384645e-01f, 9.73257646e-02f, -1.88186675e-01f, -3.43302302e-02f, 5.29167466e-02f, -2.06385687e-01f, -1.11292288e-01f, -6.15327358e-02f, 9.06056762e-02f, 1.55558422e-01f,
  -1.37005642e-01f, 1.12754278e-01f, -1.73233256e-01f, -1.28997058e-01f, 1.27965212e-01f, -5.66062257e-02f, 1.33010268e-01f, -1.60772756e-01f, -7.90764466e-02f, 6.18313886e-02f,
  -8.34780037e-02f, -3.03067774e-01f, -3.66129205e-02f, -4.22386043e-02f, -1.54135628e-02f, -6.36947900e-02f, -1.34601071e-03f, -3.69425155e-02f, -9.88387614e-02f, 2.95182224e-02f,
  -1.05867229e-01f, -1.52773838e-02f, -6.13842867e-02f, -5.03861308e-02f, -1.01566054e-01f, -5.15112653e-02f, 5.12474589e-03f, 9.49019741e-04f, 7.35077560e-02f, 1.06183663e-02f,
  3.02955247e-02f, -1.41141772e-01f, -1.08234905e-01f, -1.61784086e-02f, -9.27253217e-02f, 7.33704939e-02f, 5.55110350e-02f, -1.96268689e-02f, -8.37296695e-02f, -4.02992070e-02f,
  -7.85528310e-03f, -8.82113650e-02f, -1.39406687e-02f, 9.16231947e-04f, -7.67579526e-02f, 3.66716310e-02f, 2.07429230e-02f, 1.30465869e-02f, -1.15645409e-01f, 6.52815625e-02f,
  -5.77163063e-02f, 2.54294816e-02f, 4.50854488e-02f, -3.72943021e-02f, 3.44983712e-02f, 4.29909714e-02f, -2.20979713e-02f, -6.70169815e-02f, -8.06506947e-02f, -6.12446629e-02f,
  -5.31209111e-02f, 1.29815757e-01f, 6.98402105e-03f, 1.77772090e-01f, -2.17297390e-01f, -6.49878681e-02f, 9.71539319e-03f, -1.10626161e-01f, -5.01377694e-03f, 5.22188731e-02f,
  -1.30784065e-01f, 1.57784224e-01f, -1.28048481e-02f, 9.18437075e-03f, -1.53732494e-01f, -2.07784455e-02f, 1.52728572e-01f, -5.23379371e-02f, 4.58212048e-02f, -1.11643314e-01f,
  3.02764568e-02f, 3.84716876e-02f, -1.93550065e-02f, 2.94422731e-02f, 1.60816520e-01f, -1.08453967e-01f, 6.49522617e-02f, 1.33597821e-01f, -1.04511812e-01f, 3.45965847e-02f,
  1.88125685e-01f, -1.72542095e-01f, 1.24270037e-01f, -1.22422047e-01f, -3.33751626e-02f, 1.74606949e-01f, -6.82111531e-02f, 6.46619573e-02f, -6.12920485e-02f, -8.44898110e-04f,
  -1.07394561e-01f, -7.14972019e-02f, 1.10620424e-01f, 3.45220938e-02f, 5.47488369e-02f, 4.52160016e-02f, 1.73097715e-01f, -1.21793553e-01f, -9.17212591e-02f, -6.92231134e-02f,
  2.40211617e-02f, 1.27228111e-01f, -3.60080190e-02f, 1.29663125e-01f, -1.06353201e-01f, -1.19560614e-01f, 6.16988353e-02f, 7.76196048e-02f, 7.41999820e-02f, 1.80584043e-01f,
  1.12257220e-01f, 1.62288770e-01f, 1.22300647e-01f, -7.50234351e-02f, 6.35572374e-02f, -6.74506882e-03f, -2.88306382e-02f, 1.12459533e-01f, 1.08905166e-01f, 1.69190213e-01f,
  8.17957819e-02f, -9.99559388e-02f, -8.06400105e-02f, -1.54757813e-01f, 8.00933540e-02f, 2.03327313e-02f, -1.84507415e-01f, 1.20707884e-01f, 1.66955799e-01f, -1.97506279e-01f,
  1.14060231e-02f, -4.93411720e-02f, 9.58216712e-02f, -3.90385836e-02f, 5.71878441e-02f, 5.89886568e-02f, 1.20149463e-01f, 5.05177416e-02f, -1.80883072e-02f, -8.31462815e-02f,
  -6.31961226e-02f, 3.58027853e-02f, 2.04487741e-02f, 2.65738871e-02f, -1.20216787e-01f, -5.22154830e-02f, 1.25152007e-01f, -4.07725610e-02f, -5.90806194e-02f, -2.41623949e-02f,
  -5.03912643e-02f, 5.61091900e-02f, 8.02859217e-02f, 3.78563777e-02f, 4.27984223e-02f, -1.21922260e-02f, -7.86022246e-02f, -1.56857044e-01f, -1.56939909e-01f, -7.84626603e-02f,
  4.52404507e-02f, -4.03869245e-03f, 1.07863182e-02f, 3.08976714e-02f, 5.33343665e-02f, -1.95940919e-02f, -5.43378070e-02f, -4.47015576e-02f, -7.77200684e-02f, 5.76263219e-02f,
  4.52641919e-02f, -6.57635927e-02f, 1.07807733e-01f, -1.17421091e-01f, 1.23847783e-01f, -3.06217317e-02f, -6.22982867e-02f, 3.11810505e-02f, 1.15487799e-02f, 9.04246271e-02f,
  -3.84910777e-02f, 1.08322464e-01f, -7.08630541e-03f, -8.81107375e-02f, 4.51888256e-02f, -3.39783207e-02f, -1.41743988e-01f, -1.51497256e-02f, 8.72320607e-02f, -1.49472937e-01f,
  5.60400449e-02f, 1.03861131e-01f, 6.18552715e-02f, -1.11094959e-01f, 4.18718159e-02f, 3.33147384e-02f, 7.13429004e-02f, -1.03732981e-01f, -1.20139278e-01f, 1.76387150e-02f,
  3.65066119e-02f, 2.48215161e-02f, -1.75248366e-02f, 1.02723077e-01f, 7.43805617e-02f, 8.61625001e-02f, 1.07185371e-01f, 1.82546288e-01f, 1.11824691e-01f, -2.11912021e-02f,
  -1.60025418e-01f, 1.34800494e-01f, 8.04745965e-03f, 1.95944548e-01f, 4.80960030e-03f, -1.34893164e-01f, 2.86459294e-03f, -7.30686560e-02f, -3.98374312e-02f, -8.16311911e-02f,
  -1.10737912e-01f, 2.17611869e-05f, -1.54448435e-01f, 1.26549453e-01f, -4.46051098e-02f, 9.83851478e-02f, 9.05416682e-02f, -3.51509601e-02f, 1.66418701e-02f, 8.94751698e-02f,
  -1.00021712e-01f, 1.50265008e-01f, -4.03799564e-02f, 6.23508058e-02f, -8.62487629e-02f, -1.46386325e-01f, -3.96752469e-02f, -8.16444010e-02f, -6.59421831e-02f, 6.25792369e-02f,
  -1.08731799e-01f, 9.77849215e-03f, 9.92303938e-02f, -1.43542230e-01f, 2.00201601e-01f, -6.23135343e-02f, 1.17703676e-01f, 1.90874577e-01f, -1.68138787e-01f, 2.26151198e-01f,
  -1.96268759e-03f, 3.64005342e-02f, 5.51516004e-02f, 7.47497678e-02f, -1.69054121e-01f, -5.32786921e-02f, 8.74459818e-02f, 1.39603570e-01f, -2.84511708e-02f, -5.98991178e-02f,
  6.18153811e-02f, -4.33760174e-02f, -4.45603440e-03f, 6.16344996e-02f, -1.18259326e-01f, -6.10550819e-03f, 4.04172242e-02f, 4.03299667e-02f, 1.51771279e-02f, -5.71388900e-02f,
  -8.88784751e-02f, -6.10559732e-02f, 1.19249836e-01f, 1.84259396e-02f, 7.84658343e-02f, 4.82171588e-03f, -5.39562218e-02f, 7.44224787e-02f, -3.74790840e-02f, 9.97845009e-02f,
  -1.33889437e-01f, 9.82471257e-02f, -5.77685796e-03f, 5.38462140e-02f, 8.10045749e-02f, -1.03856558e-02f, 5.92246726e-02f, 3.49060111e-02f, -6.24566041e-02f, 1.42019494e-02f,
  1.73886105e-01f, 1.25399930e-02f, -2.99239019e-03f, 3.50463316e-02f, -1.19192833e-02f, -6.57715350e-02f, 2.85244491e-02f, -9.79767833e-03f, 4.46369909e-02f, 4.85934354e-02f,
  -2.12951213e-01f, -1.30335018e-01f, -6.45783916e-02f, 9.18817744e-02f, -1.17125757e-01f, -8.57577547e-02f, 2.65348610e-02f, 1.46920055e-01f, 1.16927557e-01f, 1.39856279e-01f,
  -5.28705753e-02f, -2.39256714e-02f, -2.56040376e-02f, 9.01273265e-02f, -6.11310713e-02f, 1.80216841e-02f, -1.55880377e-01f, 2.56543756e-01f, -5.10200262e-02f, 1.12752365e-02f,
  8.02581534e-02f, 7.11890534e-02f, 1.82277694e-01f, 3.13359834e-02f, 6.82328939e-02f, -2.30300482e-02f, 5.38590848e-02f, 1.30049199e-01f, -1.03524640e-01f, 4.82773222e-02f,
  1.58262849e-01f, -1.60226032e-01f, 8.65987986e-02f, 1.39365628e-01f, -1.31942173e-02f, -6.26588091e-02f, 4.13887165e-02f, 2.14966796e-02f, 1.03153987e-02f, 1.22565061e-01f,
  -8.82326886e-02f, 6.40454516e-02f, 1.12144731e-01f, -1.84092715e-01f, -1.56592414e-01f, -1.44158319e-01f, -1.79356858e-01f, -1.04234055e-01f, 8.60650018e-02f, -8.75773374e-03f,
  -4.48838621e-03f, -6.92705885e-02f, 7.66974613e-02f, -5.14050461e-02f, -4.89838943e-02f, 2.01494440e-01f, 1.23401381e-01f, -7.73628429e-02f, 1.77533738e-02f, -2.13197023e-02f,
  5.64524867e-02f, -3.01459897e-02f, 1.85910940e-01f, 1.60598576e-01f, 1.67440414e-01f, 2.40498632e-01f, -8.11505467e-02f, -1.06169611e-01f, 2.28806794e-01f, 9.95529518e-02f,
  -1.80965334e-01f, 3.43003906e-02f, 1.92735847e-02f, -9.60241258e-02f, -8.17111693e-03f, -1.18260667e-01f, -4.12342735e-02f, -2.67578810e-01f, -6.53324127e-02f, -2.48583797e-02f,
  9.36606675e-02f, -1.20194368e-01f, -7.80904219e-02f, 7.55635649e-03f, -2.65903194e-02f, 5.29509131e-03f, 8.43798742e-02f, 1.04176812e-01f, -2.06424147e-02f, -5.53424004e-03f,
  1.04455523e-01f, 2.35275831e-02f, -4.08504531e-02f, 5.05213141e-02f, -6.05118126e-02f, 1.48580134e-01f, -2.45662909e-02f, -4.17781658e-02f, 6.88675940e-02f, -1.20301962e-01f,
  -5.99686243e-02f, 5.47510609e-02f, -1.03513092e-01f, -6.74201399e-02f, 2.27998383e-02f, 5.88779449e-02f, 9.37809050e-02f, 5.84182218e-02f, 4.67228070e-02f, 7.59336650e-02f,
  1.12676844e-02f, 8.60499665e-02f, 7.82746524e-02f, 1.62413418e-01f, 8.48528072e-02f, 7.45756254e-02f, 3.39384489e-02f, 7.69286230e-02f, 4.20717783e-02f, -6.62080720e-02f,
  -2.16331668e-02f, 6.82418719e-02f, -3.70194353e-02f, -4.18149792e-02f, -4.65960801e-03f, 1.92820630e-03f, 1.07330326e-02f, -3.40061225e-02f, -4.83773127e-02f, 1.21807359e-01f,
  -3.54694173e-04f, 9.07863379e-02f, -5.49273267e-02f, -1.03012778e-01f, -5.02116680e-02f, -6.37826174e-02f, 6.57118410e-02f, -1.70271859e-01f, -4.98201884e-02f, 4.01034467e-02f,
  -5.35418764e-02f, -1.93250716e-01f, -8.49051625e-02f, 1.78017065e-01f, -1.28566891e-01f, 1.09703587e-02f, -1.21789895e-01f, -1.16481803e-01f, -6.66787922e-02f, -1.44587949e-01f,
  7.92433992e-02f, -1.40836062e-02f, -2.24030346e-01f, -1.33856043e-01f, -1.18343718e-02f, -4.82891537e-02f, -1.28215000e-01f, -9.99539495e-02f, -1.01570005e-03f, -4.63562235e-02f,
  2.33600568e-02f, -6.92391023e-02f, 2.87752785e-02f, -1.13961905e-01f, 4.45935801e-02f, -7.51733035e-02f, 8.02571923e-02f, 1.26660177e-02f, 1.11877583e-02f, -3.60479509e-03f,
  -1.70130618e-02f, -1.03161618e-01f, -9.21501815e-02f, 1.86934426e-01f, 1.07563166e-02f, -1.45194203e-01f, -5.68312891e-02f, -1.69638954e-02f, -3.34226079e-02f, -1.26126543e-01f,
  1.88732278e-02f, -8.59163478e-02f, 1.81823760e-01f, 1.90967515e-01f, 3.79269011e-02f, 2.62317099e-02f, 8.68286490e-02f, -6.25418092e-04f, 4.64500152e-02f, -7.55640119e-02f,
  4.66924533e-02f, 3.65628209e-03f, -1.22699112e-01f, 3.07826675e-03f, -8.10599029e-02f, 4.02126685e-02f, 2.40606032e-02f, -9.91770104e-02f, -9.50405281e-03f, -6.08121627e-05f,
  -1.90251917e-01f, 1.54781774e-01f, 6.03939686e-03f, -8.76515582e-02f, 2.40532532e-01f, -4.42191325e-02f, -1.25301704e-01f, -9.48146805e-02f, 1.03770606e-01f, 7.77900442e-02f,
  1.26955718e-01f, 1.49118854e-02f, 1.43267840e-01f, -3.95659804e-02f, 4.88823690e-02f, -5.56553565e-02f, 1.11700001e-03f, 4.16131169e-02f, -9.29920524e-02f, -5.03674001e-02f,
  -3.64050344e-02f, -5.95694259e-02f, 1.59864891e-02f, -2.54627913e-02f, 3.94609459e-02f, -6.17169999e-02f, 3.82787436e-02f, -2.53964569e-02f, -6.97496608e-02f, -9.98119265e-02f,
  -3.75468880e-02f, 1.84689909e-02f, 7.02174976e-02f, 3.16004753e-02f, -8.57407898e-02f, 3.45492028e-02f, -2.38565970e-02f, 9.74689201e-02f, 5.47667518e-02f, -1.11798935e-01f,
  -4.16256674e-02f, -7.01733232e-02f, -1.12360440e-01f, 9.64201242e-03f, -6.00799061e-02f, 3.26788798e-02f, -1.32883951e-01f, 1.29281785e-02f, -2.17604712e-02f, 6.18933327e-03f,
  -4.21164334e-02f, 9.16719344e-03f, 3.49556692e-02f, -8.35953131e-02f, 2.87349187e-02f, -1.70546528e-02f, 8.52811560e-02f, -1.04229905e-01f, -3.35886963e-02f, -1.55302167e-01f,
  -9.20367166e-02f, -1.11004852e-01f, -1.14540525e-01f, 4.67842668e-02f, -8.19097459e-02f, 2.23787669e-02f, 2.39824560e-02f, -7.14326128e-02f, 4.08028103e-02f, -6.79036006e-02f,
  -8.77943113e-02f, -1.57326106e-02f, 1.31774858e-01f, -1.57136127e-01f, 7.03823417e-02f, 3.29706408e-02f, -1.12568893e-01f, -1.43545121e-01f, 7.77626634e-02f, 1.43962145e-01f,
  1.24383196e-01f, 3.17902751e-02f, -5.80066592e-02f, -1.36524200e-01f, -9.94539708e-02f, -3.00285611e-02f, 2.76765712e-02f, 1.56657800e-01f, -9.40973088e-02f, 1.55513749e-01f,
  1.26611874e-01f, 1.28200054e-01f, -4.50598374e-02f, -1.60712734e-01f, -3.05080656e-02f, 6.74626157e-02f, -6.95916712e-02f, 1.89939499e-01f, 6.87969998e-02f, 2.54913419e-02f,
  6.58767000e-02f, -6.64002225e-02f, 4.46663797e-02f, 8.15444365e-02f, -4.08030599e-02f, -5.23505062e-02f, -1.38370156e-01f, 4.08662371e-02f, -1.04963919e-02f, 8.10737088e-02f,
  -8.85779224e-03f, -1.15412422e-01f, -5.45369014e-02f, 9.42188874e-02f, -9.31275338e-02f, 1.69959843e-01f, -7.17091486e-02f, -1.03533700e-01f, -1.52858391e-01f, -1.34977609e-01f,
  -1.68374866e-01f, 6.12036465e-03f, 1.12319246e-01f, 4.16345149e-02f, -1.59211367e-01f, -1.52161583e-01f, 1.45919379e-02f, -7.53374994e-02f, 1.31060794e-01f, 6.54384121e-02f,
  -2.30221320e-02f, 1.60618037e-01f, -1.89175561e-01f, 1.68562293e-01f, 1.52030125e-01f, -1.40088126e-01f, -3.76828723e-02f, -5.84262572e-02f, -1.04091838e-01f, -1.37127444e-01f,
  9.30091515e-02f, -9.04421434e-02f, -4.20747064e-02f, -1.26290154e-02f, -9.76632833e-02f, -7.64987692e-02f, 1.33410677e-01f, 1.25600528e-02f, 6.96302652e-02f, 5.51627427e-02f,
  -3.52969952e-02f, -4.54684012e-02f, 4.96764155e-03f, 1.15401015e-01f, -4.86214198e-02f, 7.43252188e-02f, -9.50174183e-02f, 1.17800469e-02f, -2.16565818e-01f, -1.85663521e-03f,
  9.76896584e-02f, 8.90729576e-02f, -2.40856386e-03f, -2.27245269e-03f, 2.48717144e-02f, -6.23866692e-02f, 6.39986545e-02f, 2.84091178e-02f, 4.53671813e-02f, 1.30864561e-01f,
  2.21253885e-03f, -8.76704231e-02f, -1.36161894e-02f, -8.76578782e-03f, -9.25127417e-03f, -7.40062911e-03f, 9.88996867e-03f, -6.96110129e-02f, -2.06889734e-02f, 3.86983738e-03f,
  2.76765320e-02f, 3.30764949e-02f, -1.15066497e-02f, -4.20081541e-02f, -7.55646545e-03f, 7.81666934e-02f, -9.97687578e-02f, -6.99001327e-02f, 1.28712893e-01f, 7.31305927e-02f,
  -7.70263374e-02f, 4.40748222e-02f, -6.93899393e-02f, -2.07923934e-01f, 1.25362173e-01f, 4.46731336e-02f, -3.30397822e-02f, -6.96736202e-02f, -7.40992948e-02f, 2.86464710e-02f,
  -1.08993053e-01f, -2.06921205e-01f, 1.54383913e-01f, 1.70873836e-01f, 1.47917822e-01f, 4.12333049e-02f, -1.69134125e-01f, 1.10513642e-02f, -8.29846039e-02f, -4.88120504e-02f,
  2.74504032e-02f, 4.35697101e-03f, 5.25512062e-02f, 1.22361369e-01f, -8.91021565e-02f, -4.87745479e-02f, 1.11587793e-01f, -1.91185474e-02f, -1.81645289e-01f, 5.39987497e-02f,
  -3.25011089e-02f, 1.66477427e-01f, -1.32854089e-01f, -1.32849887e-01f, 1.56725660e-01f, -1.45101929e-02f, -7.18669891e-02f, -4.68602963e-02f, 7.57121965e-02f, -2.95444448e-02f,
  -1.69343576e-02f, -4.98486264e-03f, -1.54272586e-01f, 1.79923102e-01f, -3.38240676e-02f, -4.24882025e-02f, -1.19827896e-01f, 3.03051770e-02f, -1.51450438e-02f, -8.87993351e-02f,
  1.34712994e-01f, 6.83772564e-02f, 4.39620912e-02f, -1.30274877e-01f, 4.81623523e-02f, 1.42448187e-01f, 1.02632456e-02f, -1.28725588e-01f, 1.57898456e-01f, -1.16029374e-01f,
  -4.42028381e-02f, -1.27440691e-01f, -1.79603934e-01f, 1.77233920e-01f, 3.82753015e-02f, 8.65141675e-02f, -1.06975451e-01f, -1.24882825e-01f, 1.64690509e-01f, -1.09870933e-01f,
  8.69145989e-02f, 2.82351315e-01f, -1.33898601e-01f, 1.21751912e-01f, -1.01730004e-01f, 1.51516825e-01f, 1.25633910e-01f, -1.07547194e-01f, 1.04656972e-01f, 2.47944146e-01f,
  4.55623753e-02f, -1.22827336e-01f, -1.13657571e-01f, -5.50885871e-02f, 6.01857416e-02f, 9.88627505e-03f, -7.36632571e-02f, 4.61100750e-02f, 1.12140849e-01f, -6.68328106e-02f,
  -5.69135249e-02f, -7.58986995e-02f, -9.12779849e-03f, 5.32099186e-03f, 3.81432883e-02f, -1.29275396e-01f, -8.52422565e-02f, -5.64231491e-03f, -2.89222114e-02f, -5.40250726e-02f,
  -1.34832680e-01f, 2.87021939e-02f, -2.18770336e-02f, -3.81440967e-02f, 6.88595325e-02f, -3.74581441e-02f, -4.73047979e-02f, -9.75362808e-02f, 7.54934549e-02f, -8.98211896e-02f,
  7.88360164e-02f, 2.53597554e-02f, -4.75473423e-03f, 4.79806289e-02f, -5.52068464e-02f, -2.97803171e-02f, -1.68729909e-02f, -1.02363035e-01f, -4.56653312e-02f, -5.66252396e-02f,
  6.33056089e-02f, -5.51513657e-02f, -3.19429412e-02f, -9.40404311e-02f, -3.75534617e-03f, -7.08002150e-02f, 5.84852435e-02f, -3.22360583e-02f, 1.48140441e-03f, -4.93996106e-02f,
  3.01992544e-03f, -3.25171649e-02f, -1.49339065e-01f, -6.18865415e-02f, 1.55780569e-01f, 9.42073911e-02f, -1.15302064e-01f, -1.63098774e-03f, 1.30532116e-01f, 3.47207002e-02f,
  1.30170519e-02f, -1.96949672e-02f, -1.53267875e-01f, 1.68241680e-01f, -1.09833039e-01f, -1.40717953e-01f, 2.02634513e-01f, 1.17505744e-01f, 2.64384337e-02f, 9.81849954e-02f,
  1.28560126e-01f, 8.17240849e-02f, 1.81954224e-02f, 7.64964223e-02f, 1.17234944e-03f, -7.46022612e-02f, -1.39463786e-02f, 5.90300709e-02f, 1.24975227e-01f, 1.22751191e-01f,
  1.04822598e-01f, -2.93530989e-02f, 3.77005413e-02f, -1.35961965e-01f, -2.64263302e-02f, 7.63555095e-02f, 6.71748891e-02f, -9.08985585e-02f, 2.91895233e-02f, 1.16284050e-01f,
  6.15333803e-02f, 9.72518399e-02f, 1.11159220e-01f, -1.30155131e-01f, 3.96030508e-02f, 8.21057931e-02f, -4.59459051e-02f, -1.06333569e-01f, -1.76512022e-02f, 2.39332728e-02f,
  -8.49750359e-03f, -1.71466187e-01f, 3.12697981e-03f, 1.86717417e-02f, -5.87587878e-02f, 1.55490384e-01f, -6.81226030e-02f, -3.21641304e-02f, -7.31849223e-02f, -1.61030710e-01f,
  1.11669183e-01f, 2.12994561e-01f, -1.64478302e-01f, -1.75852589e-02f, -7.44305737e-03f, -1.24404751e-01f, -3.78458537e-02f, 1.61080152e-01f, -8.24294314e-02f, -1.13487393e-01f,
  -1.01912096e-01f, 7.10294545e-02f, -1.12367302e-01f, -1.26694739e-01f, -1.32425100e-01f, 2.96117850e-02f, -1.27138153e-01f, 9.70452651e-02f, 3.42631675e-02f, -2.09710537e-03f,
  2.87988409e-03f, -4.35868725e-02f, -4.26314808e-02f, 3.67964916e-02f, 2.69995956e-03f, -5.50324135e-02f, 3.66407000e-02f, 5.12807146e-02f, 2.86825071e-03f, -8.10614228e-02f,
  1.52834997e-01f, 1.45262398e-03f, -2.61395909e-02f, 9.66443345e-02f, 9.83012021e-02f, 3.24754864e-02f, -6.88722506e-02f, 6.94066212e-02f, 1.24228708e-01f, 8.85576382e-02f,
  6.91665187e-02f, -2.68954020e-02f, 9.74125117e-02f, 5.84021248e-02f, 4.19745371e-02f, 1.09399743e-01f, -3.93368937e-02f, 1.12754680e-01f, -1.02082677e-02f, 1.28900222e-02f,
  9.94320028e-03f, -5.93677070e-03f, -2.57815346e-02f, 8.35412443e-02f, 6.48270175e-02f, -1.20570278e-02f, 9.28614065e-02f, 8.50998089e-02f, 2.93866079e-02f, 1.35446906e-01f,
  3.12824920e-02f, 3.77274700e-04f, 1.78407952e-01f, -1.18384669e-02f, 2.24314798e-02f, 2.84066238e-02f, 3.19956429e-02f, -1.12040587e-01f, 1.45807434e-02f, 3.25945988e-02f,
  -1.53290648e-02f, 9.40722004e-02f, -1.28320605e-01f, -1.37234956e-01f, -8.51091370e-02f, 6.46715984e-02f, 8.59974250e-02f, -1.71378285e-01f, -1.66722551e-01f, -9.28314701e-02f,
  -1.32018715e-01f, -7.66945034e-02f, 2.89754141e-02f, 1.74617797e-01f, -9.36811343e-02f, -1.11363716e-01f, -1.81944519e-02f, 2.72922125e-02f, 6.64530694e-03f, -6.62591904e-02f,
  -5.56917526e-02f, 1.64302811e-01f, -6.04902320e-02f, -1.26707047e-01f, 4.80266660e-02f, -1.57578155e-01f, -5.12993671e-02f, -1.04870826e-01f, 1.68067649e-01f, 1.71336353e-01f,
  -4.51064296e-02f, -4.27752808e-02f, -2.61606686e-02f, 2.29530782e-02f, -2.83603128e-02f, 1.21110022e-01f, 1.85685866e-02f, 1.09176762e-01f, 1.39834091e-01f, -1.25802815e-01f,
  5.41451611e-02f, -5.20101609e-03f, 7.67960697e-02f, 3.22420709e-02f, 1.11406945e-01f, 2.20072307e-02f, -2.24302441e-01f, -1.66864276e-01f, -1.06035240e-01f, -5.09879552e-02f,
  6.63274601e-02f, -9.71973836e-02f, 3.20002288e-02f, 1.56983182e-01f, -2.26052418e-01f, 3.19669619e-02f, 1.12752579e-01f, 1.79005399e-01f, 1.40471965e-01f, -2.84465373e-01f,
  -1.55522432e-02f, -7.85493702e-02f, -3.58463265e-02f, 4.12384570e-02f, -1.49143517e-01f, -1.54400859e-02f, -1.04655907e-01f, 4.73161265e-02f, 1.31832334e-04f, 4.32136916e-02f,
  1.49035631e-02f, 4.76427749e-03f, -4.32068072e-02f, 8.63275751e-02f, -8.28123540e-02f, -1.23970225e-01f, -7.57330507e-02f, 3.64342034e-02f, 1.64045356e-02f, -6.61234930e-02f,
  -2.10418906e-02f, -7.51729030e-03f, -8.89237300e-02f, -1.38868950e-02f, 5.03595285e-02f, -5.89952134e-02f, -4.44136001e-02f, -4.01601903e-02f, 1.46462709e-01f, -3.23378853e-02f,
  -1.03868060e-01f, 5.27096763e-02f, 4.76222783e-02f, 5.81137799e-02f, -8.06406438e-02f, 7.39556178e-03f, 2.09307373e-02f, 8.26502044e-04f, -1.22499652e-01f, -7.81186437e-03f,
  3.90901864e-02f, 3.44273797e-03f, -1.02454603e-01f, 5.17287813e-02f, 1.28184453e-01f, 6.08873814e-02f, -7.27790371e-02f, -1.37517393e-01f, -4.50824648e-02f, 1.55828362e-02f,
  3.64584476e-02f, -1.41345292e-01f, 4.57330793e-03f, -1.11876003e-01f, -4.51496467e-02f, 4.78552990e-02f, -4.63226959e-02f, 1.03981961e-02f, -3.82574201e-02f, 2.11016815e-02f,
  2.54611745e-02f, 8.73056725e-02f, -1.17672533e-01f, -8.14775005e-02f, 1.38179669e-02f, -4.64989617e-02f, 2.82424572e-03f, 1.21092685e-01f, 6.03705794e-02f, 2.68384088e-02f,
  -2.03793526e-01f, 2.40999103e-01f, 9.06047523e-02f, 1.09153993e-01f, -5.54059669e-02f, 1.31398216e-01f, -5.69581203e-02f, -3.98798175e-02f, 2.13549703e-01f, -1.58625573e-01f,
  1.30741030e-01f, -1.21459022e-01f, -4.54150774e-02f, -1.05645731e-01f, 1.22387391e-02f, -4.50450592e-02f, -1.33461699e-01f, -1.90183461e-01f, -5.95040061e-02f, 7.79278651e-02f,
  -6.81218803e-02f, 1.29315302e-01f, 1.19342722e-01f, 7.80940056e-02f, -7.42235705e-02f, -1.34028625e-02f, -9.82318223e-02f, 2.60210857e-02f, -3.73522118e-02f, -4.94862348e-02f,
  1.71653211e-01f, -1.10552765e-01f, -1.21755097e-02f, 1.56141063e-02f, -1.91173837e-01f, 5.46097383e-02f, -1.22382101e-02f, -8.29796642e-02f, -1.37035951e-01f, 1.83592886e-01f,
  4.26290669e-02f, -1.14633106e-01f, 7.21566901e-02f, 1.43458202e-01f, 3.09733469e-02f, 1.40814728e-03f, -9.10136625e-02f, 1.31573975e-02f, -2.01756284e-02f, -2.39152119e-01f,
  -1.07425131e-01f, -6.78076521e-02f, 1.00305073e-01f, -1.68114871e-01f, -2.64295906e-01f, -6.31282330e-02f, -8.95157456e-03f, -1.56068861e-01f, -4.75156344e-02f, -1.32810161e-01f,
  1.98912174e-01f, -4.74787923e-03f, 1.64030969e-01f, 7.04812109e-02f, 2.16311831e-02f, -6.54843971e-02f, 2.93153804e-02f, 5.56261279e-02f, -7.12913414e-03f, -7.25151002e-02f,
  1.37541994e-01f, -5.15951551e-02f, -7.15233013e-02f, -2.88040876e-01f, -4.20216750e-03f, 8.98064673e-02f, -5.63957915e-02f, -9.69235878e-03f, -2.72645298e-02f, -6.20028637e-02f,
  4.53954302e-02f, 6.15616851e-02f, -2.41694339e-02f, 7.44193560e-03f, 4.72509675e-02f, -1.30030349e-01f, -7.96330422e-02f, -2.18000170e-02f, -9.53272134e-02f, -4.24196348e-02f,
  1.00518845e-01f, -3.35827693e-02f, -1.41825376e-03f, -9.15425643e-02f, -1.64979305e-02f, 2.37178039e-02f, -3.02819777e-02f, 8.68310854e-02f, -3.73121947e-02f, 7.70927593e-03f,
  -4.51948978e-02f, 5.27924523e-02f, -4.88615520e-02f, -4.13340665e-02f, -1.18646942e-01f, -7.71379173e-02f, -9.19837952e-02f, -1.28334492e-01f, -6.23216899e-03f, -6.60873204e-02f,
  -4.13720533e-02f, 8.26688483e-03f, -1.97141021e-02f, -6.57463670e-02f, -2.64656264e-02f, 4.38570790e-02f, 2.81138886e-02f, -5.89513183e-02f, -1.20356068e-01f, -5.60912900e-02f,
  -1.99883021e-02f, -3.43170948e-02f, 9.21735987e-02f, 9.71971303e-02f, -4.81633544e-02f, -4.18534838e-02f, 7.74053810e-03f, -5.59355132e-02f, -1.46339133e-01f, 9.90038663e-02f,
  1.48802638e-01f, 2.11788863e-02f, -9.34819505e-02f, 1.32429063e-01f, -1.15647592e-01f, 1.33124227e-02f, -1.01672344e-01f, -1.85848288e-02f, 2.25860104e-01f, 9.18735787e-02f,
  -2.27585677e-02f, -7.05492049e-02f, 4.35406044e-02f, -5.97292557e-02f, -4.37464891e-03f, -3.93765531e-02f, 1.30808488e-01f, -1.10254638e-01f, -3.64964344e-02f, 2.14967042e-01f,
  3.02116796e-02f, -4.41498049e-02f, -1.67644136e-02f, -1.69538066e-01f, 2.23653782e-02f, 3.29356045e-02f, -2.79664882e-02f, 1.84595406e-01f, -3.67544107e-02f, 3.31420861e-02f,
  -1.47030830e-01f, -3.11364420e-02f, -9.95735265e-03f, 1.32952230e-02f, 9.36716388e-04f, -1.95820242e-01f, -7.90454075e-02f, 2.08418265e-01f, -7.24380650e-03f, -1.18620144e-02f,
  1.26094043e-01f, -1.12994586e-03f, 1.09452836e-01f, 5.12809642e-02f, 1.54484287e-02f, 5.90606146e-02f, -3.49873342e-02f, -1.01432115e-01f, 8.04920122e-02f, 1.21036604e-01f,
  1.48234770e-01f, 2.19415739e-01f, -4.07715775e-02f, 1.58982456e-01f, 1.25723392e-01f, -7.62062967e-02f, 2.04532459e-01f, 1.95573289e-02f, 1.84371114e-01f, -5.08810626e-04f,
  1.11961057e-02f, -1.31728679e-01f, -3.12615521e-02f, -7.28638545e-02f, 7.63976946e-03f, -1.23772971e-01f, 3.58929299e-02f, 1.04568847e-01f, -4.82733138e-02f, 5.82689121e-02f,
  1.82399750e-01f, -1.51787683e-01f, -1.16051240e-02f, -8.63836035e-02f, 2.81758215e-02f, 5.38266683e-03f, 8.02463852e-03f, 3.23871188e-02f, -1.39328865e-02f, -5.36588021e-02f,
  -4.92556579e-02f, -3.42401452e-02f, 7.61054829e-03f, -4.22664965e-03f, -1.12977289e-01f, 1.04646511e-01f, 2.07969118e-02f, 3.18691842e-02f, -5.06296102e-03f, 9.76226032e-02f,
  3.90629508e-02f, -4.63351682e-02f, -1.17211856e-01f, 4.78652976e-02f, -1.76321156e-03f, 7.75416568e-02f, 5.37863858e-02f, 1.56706702e-02f, 2.36584246e-02f, -1.27929434e-01f,
  -1.16080217e-01f, -2.09429953e-02f, 2.14816560e-03f, 1.07481554e-01f, 3.87265310e-02f, 1.19452253e-01f, -8.30169991e-02f, -1.09159919e-02f, -5.04135154e-02f, -3.34165134e-02f,
  -3.38216349e-02f, -3.85521092e-02f, 4.19213735e-02f, -2.13495731e-01f, 3.39762196e-02f, -8.95716599e-04f, 4.69897427e-02f, -1.21345542e-01f, 6.41581640e-02f, 9.74185914e-02f,
  -4.65786317e-03f, -3.43375057e-02f, -2.65023187e-02f, 3.50813568e-02f, -1.03021875e-01f, -1.39597043e-01f, 4.65637445e-02f, 7.86780566e-02f, -1.79074854e-02f, -1.98700309e-01f,
  1.27139106e-01f, -1.01126678e-01f, 3.11923516e-03f, 1.79958284e-01f, -1.31537393e-01f, 2.73410119e-02f, -7.09829256e-02f, 5.70983216e-02f, 1.80262685e-01f, -7.74079412e-02f,
  -1.93794578e-01f, 2.44413987e-02f, 1.02786377e-01f, 1.01750188e-01f, 1.64062038e-01f, 7.82618150e-02f, 1.69860542e-01f, 6.62134513e-02f, 5.86436712e-04f, 5.28722182e-02f,
  7.68417027e-03f, 2.07888540e-02f, -7.15457276e-02f, -1.49872741e-02f, -1.20904632e-01f, 3.74519005e-02f, -9.61151272e-02f, -1.21561475e-02f, 1.21091202e-01f, -2.46660054e-01f,
  -8.03690404e-02f, 6.63540587e-02f, 9.62005835e-03f, 6.93951994e-02f, 6.99915960e-02f, -9.29292943e-03f, -1.45745814e-01f, 1.37306660e-01f, -8.64325166e-02f, -2.26436228e-01f,
  -1.59740776e-01f, 1.07406378e-01f, -1.60540000e-01f, 5.07087111e-02f, 6.03457429e-02f, 1.30796865e-01f, 6.39446359e-03f, 7.64650926e-02f, -2.62583382e-02f, 4.70395498e-02f,
  -5.16091473e-02f, -1.04210153e-01f, 1.50637189e-02f, 1.85625121e-01f, -3.70872505e-02f, -9.56237502e-03f, 1.57986641e-01f, -1.61332086e-01f, -8.95942226e-02f, 2.86922827e-02f,
  -9.10558328e-02f, 1.03931159e-01f, 1.02486193e-01f, 5.48542626e-02f, -1.45089343e-01f, 1.08714469e-01f, -1.49340063e-01f, 9.27358642e-02f, 1.73887704e-02f, 1.81247696e-01f,
  8.49052072e-02f, -1.00961097e-01f, 5.96578941e-02f, 9.08482727e-03f, -5.91948926e-02f, 9.11271721e-02f, -1.82169769e-02f, -4.51014303e-02f, 1.11646093e-02f, -9.07857493e-02f,
  -1.14852779e-01f, -1.18795522e-01f, -1.26358360e-01f, 1.01050951e-01f, -5.27097583e-02f, 5.72290756e-02f, -1.51889607e-01f, -3.80602852e-02f, 3.47829051e-03f, -8.97512306e-03f,
  4.78132665e-02f, -2.90693529e-02f, -9.37103666e-03f, -6.82268441e-02f, -4.93895225e-02f, -7.27287531e-02f, -3.87857370e-02f, -1.06933974e-01f, -1.25280797e-01f, 7.06409439e-02f,
  9.81442705e-02f, 7.11294413e-02f, 4.54012826e-02f, 3.29364999e-03f, 5.08847982e-02f, 2.11333558e-02f, 7.03267306e-02f, -8.98123756e-02f, -7.78675452e-02f, 3.52759100e-02f,
  -8.62089619e-02f, -1.17225163e-01f, -9.21515673e-02f, -4.15713191e-02f, 8.15844070e-03f, -1.14628211e-01f, -7.35624321e-03f, 3.31826843e-02f, -4.28916812e-02f, 1.30425068e-02f,
  9.04376619e-03f, -4.89054658e-02f, -1.20039433e-01f, -1.84803888e-01f, -1.00377627e-01f, -8.98499265e-02f, -2.31499344e-01f, 9.22119170e-02f, -1.76031530e-01f, -1.58175886e-01f,
  1.17693711e-02f, -8.19633082e-02f, 6.75861612e-02f, 4.28637005e-02f, -2.15501785e-01f, 1.42578840e-01f, 1.49093211e-01f, -2.25323401e-02f, 1.55520692e-01f, -3.70683905e-04f,
  -8.32888931e-02f, 2.33580917e-01f, 1.27595693e-01f, 6.91342875e-02f, 4.77504767e-02f, -9.40900445e-02f, -1.11426450e-01f, -6.17514513e-02f, 1.48473317e-02f, 8.11738968e-02f,
  2.73501817e-02f, 6.62667379e-02f, 9.28557441e-02f, 1.60988212e-01f, -2.45656911e-02f, -9.09356028e-02f, -1.30057952e-03f, -1.43970221e-01f, 4.91970889e-02f, -1.27879292e-01f,
  -2.05913961e-01f, 4.47516926e-02f, -1.04046591e-01f, -9.37780440e-02f, 7.31612928e-03f, 2.89488006e-02f, 4.19594012e-02f, 7.05422610e-02f, 1.94839854e-02f, 1.31481677e-01f,
  -1.89076781e-01f, 2.18920074e-02f, 6.11803085e-02f, 1.69373199e-01f, -2.24650353e-01f, -1.68199614e-01f, -7.20252097e-02f, -4.33518998e-02f, 8.11516419e-02f, 7.66071454e-02f,
  -4.96803075e-02f, 1.00275464e-01f, -9.68371555e-02f, -3.46453190e-02f, -7.31465295e-02f, -5.39386570e-02f, -5.18140383e-02f, -8.80946144e-02f, -9.60534662e-02f, 1.47188857e-01f,
  -1.57472461e-01f, 1.27953589e-01f, 9.78182703e-02f, 2.22440809e-02f, -1.15691647e-01f, 3.71327959e-02f, -6.98656663e-02f, 1.81294054e-01f, 8.69985521e-02f, 6.67361096e-02f,
  -2.00774497e-03f, -2.48222388e-02f, -4.38751765e-02f, 1.18336298e-01f, 4.56860289e-02f, 1.99302062e-02f, -5.19459285e-02f, -7.20578665e-03f, -4.04527448e-02f, -2.40876805e-02f,
  7.90396780e-02f, 3.50272581e-02f, -3.55745666e-02f, 4.92788404e-02f, -1.40956879e-01f, -5.28606661e-02f, -2.05237232e-02f, 8.87675583e-02f, 4.21966203e-02f, 3.91437300e-02f,
  2.32829526e-02f, -5.31019419e-02f, 7.38853440e-02f, -1.87271200e-02f, 1.04144804e-01f, 3.60417813e-02f, 8.41566361e-03f, -5.36920642e-03f, -8.33256822e-03f, -3.93170491e-02f,
  -3.28673534e-02f, -3.19278650e-02f, -3.22691239e-02f, 1.23233087e-01f, 3.14881131e-02f, 6.26449212e-02f, -2.51734070e-02f, -2.57856362e-02f, -7.66365454e-02f, -6.03336841e-03f,
  -4.78602462e-02f, 4.16233055e-02f, 5.39378785e-02f, 3.78646888e-02f, 3.63044292e-02f, 4.58412468e-02f, 2.66000871e-02f, 5.50417937e-02f, -8.21193531e-02f, -1.08583616e-02f,
  2.43527722e-02f, -1.49449138e-02f, -7.44521171e-02f, -2.24574789e-01f, -1.91600844e-01f, 3.88043709e-02f, -1.35477096e-01f, -1.16357751e-01f, -7.12074637e-02f, -1.52021972e-02f,
  8.81290808e-03f, -1.55188024e-01f, -9.28179622e-02f, 1.05306529e-01f, -2.41394024e-02f, -8.81664753e-02f, 1.72092244e-01f, -1.23563096e-01f, -1.70448974e-01f, 5.54057285e-02f,
  -2.36536805e-02f, -5.08057624e-02f, -5.74818207e-03f, -3.39563191e-02f, -3.50187793e-02f, -1.79153159e-01f, -8.26992244e-02f, -1.13874920e-01f, -3.32360640e-02f, -2.39849230e-03f,
  -1.69951376e-02f, 8.22922438e-02f, 3.14669050e-02f, -2.24949792e-01f, -7.35483244e-02f, 1.47429481e-01f, -5.75251761e-04f, -1.22555092e-01f, -1.63840771e-01f, -1.62098333e-01f,
  -1.85356289e-01f, -8.36561769e-02f, 4.26047295e-03f, 3.35874222e-02f, 1.80097520e-01f, 6.68891519e-02f, 9.71387550e-02f, 1.54954135e-01f, -7.52900774e-03f, 1.36100918e-01f,
  6.27799854e-02f, 2.24390134e-01f, -6.58560991e-02f, -2.04690337e-01f, -6.50470927e-02f, -3.27543914e-02f, 1.17993474e-01f, 5.23608327e-02f, -1.18965492e-01f, -1.34516153e-02f,
  -7.47175291e-02f, -1.42882355e-02f, -1.69780597e-01f, 1.64346516e-01f, 1.03659462e-02f, -1.60344079e-01f, 1.10683486e-01f, 1.31264776e-01f, -1.06630348e-01f, -3.13056447e-02f,
  1.10379234e-01f, 1.13018833e-01f, 8.58961716e-02f, -4.95317504e-02f, 7.24742189e-02f, 9.03974399e-02f, -5.64464182e-02f, -2.00955734e-01f, 1.44385789e-02f, -6.45714775e-02f,
  6.41185045e-02f, -2.93855853e-02f, -1.71975587e-02f, -1.49919391e-02f, 4.76445556e-02f, 4.16226946e-02f, -4.84872088e-02f, 6.37973379e-03f, -1.64767783e-02f, -8.41511786e-02f,
  -1.37085943e-02f, 2.40274854e-02f, -6.32168502e-02f, -1.21654332e-01f, -4.79189195e-02f, 4.04679179e-02f, -1.49364350e-02f, -5.24158031e-02f, -9.55042318e-02f, -1.50926169e-02f,
  3.58819030e-02f, -5.45261540e-02f, -9.35229007e-03f, -3.99755053e-02f, 2.27460684e-03f, -3.05949841e-02f, -1.33385435e-02f, 4.95055784e-03f, 8.90255440e-03f, -8.17227811e-02f,
  -6.25896826e-02f, 4.47530039e-02f, -5.21111898e-02f, -2.95911878e-02f, 3.79265361e-02f, 7.00396672e-02f, -7.44131655e-02f, 2.66203899e-02f, -4.85514998e-02f, -1.22286677e-01f,
  1.47689581e-01f, -6.34607114e-03f, -1.02799766e-01f, -1.55807346e-01f, -1.03944562e-01f, 3.54564609e-03f, 7.89290667e-02f, 8.96613896e-02f, -6.03954531e-02f, 8.66441578e-02f,
  7.99167976e-02f, -1.43293321e-01f, -1.52067289e-01f, 1.47592187e-01f, 1.19240666e-02f, 6.79789707e-02f, 1.59396395e-01f, -1.15652084e-01f, 3.20245465e-03f, 1.48653490e-02f,
  1.28823230e-02f, -6.73726797e-02f, 1.67204946e-01f, 2.20189467e-02f, 9.18570980e-02f, -1.16862424e-01f, -3.63736078e-02f, 1.36938348e-01f, -7.07268938e-02f, -1.19473629e-01f,
  -8.24642256e-02f, -7.75194541e-02f, 8.62521902e-02f, 9.42629278e-02f, 1.27123579e-01f, 6.09869882e-02f, -5.86484745e-02f, -3.72008444e-03f, 2.07652282e-02f, -1.03370212e-01f,
  1.49228230e-01f, 3.04028895e-02f, 5.86074106e-02f, 6.64688274e-02f, 1.02060392e-01f, -1.24824874e-01f, -7.19621480e-02f, 1.44599661e-01f, -1.48467511e-01f, -1.20854601e-01f,
  2.72536408e-02f, 7.51144141e-02f, -1.27579108e-01f, 1.63570985e-01f, 4.78968285e-02f, 4.95222174e-02f, 1.09211743e-01f, 2.14234032e-02f, -8.62892419e-02f, 1.68543428e-01f,
  -5.32978550e-02f, -1.88267142e-01f, -1.82622239e-01f, -1.76881790e-01f, 1.20663652e-02f, -2.02037603e-01f, -7.82250240e-02f, 1.03565298e-01f, -2.01137215e-01f, 3.29280039e-03f,
  -6.15524463e-02f, 3.46809477e-02f, 1.69968954e-03f, 1.37523472e-01f, 2.04385612e-02f, -1.27232671e-02f, -6.14973120e-02f, 1.07962102e-01f, 1.98069558e-01f, -9.83309075e-02f,
  1.25483483e-01f, -7.81877339e-02f, -1.15353942e-01f, 1.90591678e-01f, 7.33564496e-02f, -1.67228654e-01f, -8.27365816e-02f, -1.89325232e-02f, 7.19167963e-02f, -1.08632617e-01f,
  -3.06057725e-02f, 2.09100824e-02f, -1.29089877e-01f, 3.46630299e-03f, 6.33496558e-03f, 2.85279416e-02f, -3.80409248e-02f, 4.97471280e-02f, 6.32107407e-02f, -1.07896075e-01f,
  -1.20897546e-01f, 3.53525579e-02f, -9.52363536e-02f, 5.69051888e-04f, 6.26226738e-02f, -2.41319388e-02f, 6.00567386e-02f, 8.47883336e-03f, 1.07064024e-01f, -1.42633542e-02f,
  -2.47939080e-02f, -4.08126377e-02f, -2.38754191e-02f, -2.53570676e-02f, 6.28709272e-02f, 4.74058501e-02f, 8.27717707e-02f, 8.12127069e-02f, -1.07421994e-01f, -2.93982420e-02f,
  7.11705387e-02f, -1.57130975e-02f, -9.56735834e-02f, 2.59681381e-02f, -1.97828803e-02f, -8.81650522e-02f, -1.38765082e-01f, 5.78194074e-02f, -1.62910651e-02f, -7.82878324e-02f,
  2.41963062e-02f, 2.47567315e-02f, -8.03687423e-02f, -2.45033223e-02f, 5.66097423e-02f, 6.89582974e-02f, -1.10039949e-01f, -8.69531482e-02f, -7.74517283e-02f, 1.36102483e-01f,
  7.14313313e-02f, -1.30315512e-01f, -1.57533325e-02f, -1.62092317e-02f, 1.41637994e-03f, 2.79719308e-02f, 1.10094473e-01f, 1.46343708e-01f, -4.80673201e-02f, -1.57255769e-01f,
  -1.29162604e-02f, -1.31903529e-01f, -1.57012716e-01f, 1.27983958e-01f, 1.32081687e-01f, 1.89427584e-01f, 1.43391088e-01f, 1.13759972e-01f, 1.05255418e-01f, 2.74102259e-02f,
  -1.28211930e-01f, -2.37011537e-02f, 7.19675273e-02f, 1.04505487e-01f, 8.30649678e-03f, -1.59446448e-01f, -1.19867232e-02f, 8.54161475e-03f, 3.77239543e-03f, -4.27766182e-02f,
  1.48789391e-01f, -1.51526645e-01f, -8.45778137e-02f, -7.36866668e-02f, -4.57961438e-03f, 7.17752501e-02f, 7.82841370e-02f, -3.12325750e-02f, -4.13038656e-02f, -1.38730451e-01f,
  -5.93864806e-02f, -1.53520629e-01f, -1.65847689e-01f, 3.68119292e-02f, -7.15742111e-02f, -1.36986077e-01f, 2.32816786e-01f, -2.86751390e-02f, 1.42430127e-01f, 6.81260675e-02f,
  2.56981850e-01f, -2.75655277e-02f, -9.50294584e-02f, -1.11682434e-03f, -2.05593240e-02f, 1.69434085e-01f, -6.46158680e-02f, 9.41784680e-03f, 5.74816298e-03f, -1.76321372e-01f,
  1.90687940e-01f, 9.56823230e-02f, -4.02074270e-02f, -2.18997691e-02f, -1.95401404e-02f, 1.01247672e-02f, -2.26206869e-01f, -1.39577761e-02f, -1.08847514e-01f, 6.20941594e-02f,
  2.71774177e-02f, 8.58767051e-03f, 2.53895428e-02f, 8.43554810e-02f, -1.05079405e-01f, 3.51919979e-02f, -5.68720959e-02f, -1.79689582e-02f, -2.58850809e-02f, -9.53023955e-02f,
  9.14646238e-02f, 2.27341764e-02f, -5.61973490e-02f, 4.47628833e-02f, 1.18139356e-01f, 1.07863909e-02f, 1.39310211e-01f, -1.39655946e-02f, -2.33357735e-02f, 5.78252003e-02f,
  4.08581421e-02f, 4.43590246e-02f, -1.18562358e-03f, -4.99114245e-02f, 1.81707349e-02f, -7.36523643e-02f, 1.06035478e-01f, -5.09121902e-02f, -1.46197537e-02f, 1.48182303e-01f,
  9.79044139e-02f, 3.40369530e-02f, -2.08650995e-02f, 3.30253430e-02f, 2.08402053e-02f, -4.11282144e-02f, -4.86854799e-02f, 5.19509353e-02f, 1.04565322e-01f, 1.13602988e-02f,
  6.45791069e-02f, 1.11716174e-01f, -3.62195782e-02f, -3.68736614e-03f, 8.73162784e-03f, 3.87411267e-02f, -5.28724417e-02f, 1.34780869e-01f, 1.20511755e-01f, 1.12012379e-01f,
  -3.17698494e-02f, -1.44268095e-01f, 1.00444572e-03f, -5.67454658e-02f, 1.40808195e-01f, 3.25657688e-02f, -1.01304529e-02f, 7.72003131e-03f, -5.80445454e-02f, 1.98402721e-02f,
  6.48348704e-02f, -1.12104714e-01f, 1.68456808e-01f, -1.56149687e-02f, 5.97019307e-02f, -3.37470928e-03f, -2.10891396e-01f, 1.73470974e-02f, -1.18347155e-02f, 1.17040738e-01f,
  1.01318240e-01f, 8.98179971e-03f, 7.29725435e-02f, 3.34128812e-02f, -1.38956651e-01f, 9.99647677e-02f, -4.68608961e-02f, -2.23519489e-01f, 4.54087555e-02f, -7.67908012e-03f,
  -9.65109169e-02f, 4.61123586e-02f, 4.25431468e-02f, -2.23340839e-02f, -9.41151306e-02f, -6.54191151e-02f, -8.15531984e-02f, 1.31598204e-01f, 9.60880071e-02f, -1.55266549e-03f,
  6.46881461e-02f, 1.32815897e-01f, 9.93727520e-03f, -2.12661847e-02f, 8.61742441e-03f, -1.59948692e-01f, -3.11122276e-02f, 9.27167684e-02f, -5.58948107e-02f, 9.13530961e-02f,
  -8.62160549e-02f, -1.78599358e-01f, -2.70249089e-03f, -1.62344158e-01f, 9.65529680e-02f, 1.73916516e-04f, -1.40144423e-01f, -9.80846584e-03f, -1.02353036e-01f, -9.15824771e-02f,
  -1.52682122e-02f, -1.23935960e-01f, -2.46982854e-02f, -4.63650376e-03f, -7.29065984e-02f, 1.25747323e-01f, -8.79492611e-02f, 9.57054552e-03f, -1.52808934e-01f, -2.25008145e-01f,
  -1.13334032e-02f, 9.86139383e-03f, 7.05618933e-02f, 2.40731329e-01f, -6.19542785e-02f, -1.02411196e-01f, 9.81419683e-02f, -6.70388266e-02f, -1.99148022e-02f, 1.71697319e-01f,
  -1.03530055e-02f, -7.08504952e-03f, 9.63582657e-03f, -1.46802729e-02f, -5.30116782e-02f, 1.63520351e-02f, 1.93432122e-02f, 1.54214865e-02f, 2.86802575e-02f, -2.78889667e-02f,
  -5.33349253e-02f, 4.80485596e-02f, 7.60794356e-02f, -1.13576487e-01f, 3.88484597e-02f, 2.96392366e-02f, -5.00199310e-02f, -1.21527771e-02f, 5.50548807e-02f, -2.34628264e-02f,
  4.47736792e-02f, -8.90569165e-02f, -4.18537250e-03f, 1.03896949e-02f, 4.97345403e-02f, -1.25600202e-02f, 4.59663011e-02f, 1.51983202e-01f, 1.10661902e-01f, -2.56748474e-03f,
  -8.12618062e-02f, -5.90085946e-02f, -1.54484641e-02f, -2.55899746e-02f, -5.24941599e-04f, 2.07472909e-02f, 8.86229500e-02f, 2.41156183e-02f, 1.83895715e-02f, 1.19554214e-01f,
  -2.62160189e-02f, 1.03968367e-01f, -5.84487629e-04f, 1.57147214e-01f, 3.88166644e-02f, 1.07322790e-01f, -1.08855329e-02f, -1.79255921e-02f, -3.07516102e-02f, -1.84928756e-02f,
  1.35468356e-02f, 8.92061964e-02f, 5.90026490e-02f, 1.72182292e-01f, -2.19386742e-02f, 3.91982570e-02f, 2.23357305e-01f, 7.71582574e-02f, 7.64333755e-02f, 6.22599423e-02f,
  -1.04650166e-02f, -9.51992646e-02f, -5.05133383e-02f, -3.74534652e-02f, 1.54546229e-03f, -1.21559510e-02f, -5.44759594e-02f, -1.04785440e-02f, -1.09067455e-01f, -6.97569782e-03f,
  4.93222401e-02f, -1.02234550e-01f, -7.42550641e-02f, 4.73625809e-02f, -1.79216638e-01f, -1.20031677e-01f, -8.78625289e-02f, -3.98661792e-02f, -2.50768755e-02f, -7.95784220e-02f,
  1.08945541e-01f, -1.38753861e-01f, 1.43034626e-02f, -1.85421214e-01f, -5.82926534e-02f, 3.60815302e-02f, -1.06021978e-01f, 1.69977248e-01f, 8.87351856e-02f, -9.08296779e-02f,
  2.21687809e-01f, 1.19869053e-01f, 6.83126226e-02f, 7.26782531e-02f, 1.31590277e-01f, -1.64823338e-01f, -1.51027694e-01f, 6.36783848e-03f, -1.00837655e-01f, -1.15731277e-01f,
  1.63189918e-01f, 9.85620171e-03f, -2.32664943e-02f, -7.45327026e-03f, 1.54608607e-01f, 6.22644424e-02f, 2.03295916e-01f, 1.47860050e-01f, 2.20272884e-01f, 7.43022040e-02f,
  3.19932923e-02f, -1.71743095e-01f, 1.35084376e-01f, 9.61328149e-02f, -2.10775081e-02f, -2.71655642e-03f, 2.19938785e-01f, -2.50894904e-01f, 1.13525137e-01f, -1.38405547e-01f,
  8.84880796e-02f, 1.28638577e-02f, -1.24553805e-02f, -3.90207418e-03f, 1.47985309e-01f, 1.35426506e-01f, 2.77095940e-02f, -6.36757389e-02f, 1.25848856e-02f, 9.94292051e-02f,
  7.24944845e-02f, -6.15792312e-02f, 1.13552935e-01f, -1.61677469e-02f, 1.22558838e-02f, 8.90130624e-02f, -8.00619461e-03f, -4.33949530e-02f, -9.12283584e-02f, -3.62916030e-02f,
  1.40177608e-02f, -7.15488046e-02f, 5.50476387e-02f, 3.26649174e-02f, 6.67152926e-02f, 4.94862646e-02f, 5.37914457e-03f, -1.94465443e-02f, 4.93905582e-02f, -8.18363484e-03f,
  1.17449313e-01f, 8.08448792e-02f, -5.00718039e-03f, 7.41981268e-02f, -4.37594615e-02f, -1.82491858e-02f, -3.65879089e-02f, 6.57902658e-02f, -1.84840746e-02f, 3.83612514e-02f,
  -6.27817214e-02f, -3.26129943e-02f, -1.13633703e-02f, 5.83291538e-02f, -7.96497688e-02f, 3.78256408e-03f, 1.62115723e-01f, 6.26025870e-02f, -2.06238292e-02f, 8.80357251e-02f,
  4.80469200e-04f, 4.78288233e-02f, 1.15772285e-01f, 7.78170973e-02f, -1.40157267e-01f, -2.76436266e-02f, 9.24728364e-02f, -1.13406450e-01f, -1.90955140e-02f, -1.76042333e-01f,
  -2.47491747e-02f, 1.37341516e-02f, -5.35946414e-02f, -1.35583952e-01f, -1.69621274e-01f, 1.89045608e-01f, 6.48572892e-02f, 2.31727213e-03f, -5.55785522e-02f, -1.40902102e-01f,
  -1.60225198e-01f, -9.56069306e-02f, 1.24279760e-01f, 4.95667942e-02f, 2.03245971e-02f, 5.35623170e-02f, 1.56431571e-01f, 2.21150983e-02f, -3.31173535e-03f, -1.31257132e-01f,
  -9.56452638e-02f, 1.03402190e-01f, 6.53823093e-02f, -8.15900415e-02f, -7.43149817e-02f, -9.04989690e-02f, -2.33721733e-02f, -1.20427661e-01f, 4.12247404e-02f, 1.55815750e-01f,
  3.39126363e-02f, 1.32292472e-02f, -8.92401040e-02f, -3.68995704e-02f, -1.00175954e-01f, 6.10967807e-04f, 1.60420612e-01f, -4.93078195e-02f, 1.56172353e-03f, -1.48564100e-01f,
  5.83301075e-02f, -2.60841846e-03f, -1.81744434e-02f, -1.18315555e-02f, 4.53233980e-02f, -4.00106981e-02f, 4.29720171e-02f, -2.80472767e-02f, -4.48924080e-02f, -1.94209982e-02f,
  3.56421396e-02f, -1.56342998e-01f, -1.68121353e-01f, 1.66524693e-01f, -1.06068909e-01f, 1.30195722e-01f, 1.68349687e-02f, 7.87483454e-02f, 1.43883795e-01f, -1.22361377e-01f,
  1.37696862e-01f, -1.60842285e-01f, -1.40171438e-01f, 1.31136790e-01f, -1.98085710e-01f, 1.08279930e-02f, 8.42377171e-03f, -3.94918323e-02f, -1.63921297e-01f, -1.66977659e-01f,
  1.84999332e-01f, -3.39668952e-02f, -8.10683444e-02f, 1.26145165e-02f, -4.80207894e-03f, -1.46028727e-01f, -8.32909420e-02f, -5.51196784e-02f, -4.60290955e-03f, 5.78377619e-02f,
  1.49421990e-01f, 8.10531750e-02f, -3.29146162e-02f, 1.69955625e-03f, -1.56128537e-02f, 3.75286862e-02f, 2.70795058e-02f, -1.01106083e-02f, -1.40127568e-02f, 9.65627059e-02f,
  8.55718255e-02f, 6.78620711e-02f, 8.88732523e-02f, -4.52600606e-02f, 2.63916664e-02f, 1.04760222e-01f, -2.08595052e-01f, 1.49627337e-02f, 5.28639443e-02f, 5.13370670e-02f,
  -7.79646412e-02f, 5.96602168e-03f, 1.49148643e-01f, -8.12574923e-02f, -1.36154443e-01f, 1.88977811e-02f, 9.27980170e-02f, 3.74165997e-02f, 3.82917672e-02f, 5.36387973e-02f,
  1.05253868e-02f, 1.01936720e-01f, 9.64804590e-02f, -1.66146327e-02f, 6.68864176e-02f, -2.45277677e-02f, 2.87450049e-02f, -1.13779768e-01f, 6.44550752e-03f, -1.15252741e-01f,
  9.39185396e-02f, 7.92849734e-02f, 2.02078838e-02f, -8.69693980e-02f, 6.29122332e-02f, 9.03794318e-02f, 5.13248220e-02f, 6.70078993e-02f, -6.78015575e-02f, -9.25589725e-02f,
  2.01373652e-01f, 6.43874332e-03f, -1.66999504e-01f, 1.46402977e-02f, -7.61934668e-02f, 1.17032774e-01f, 6.80716336e-02f, 1.12844370e-01f, 1.73387229e-01f, 2.98273508e-02f,
  8.44354928e-03f, 5.43763749e-02f, 2.59613860e-02f, -1.22496346e-02f, 8.38444605e-02f, 9.22229365e-02f, -3.71568799e-02f, -9.00957063e-02f, -5.02954386e-02f, -1.64864406e-01f,
  -4.24538851e-02f, 1.35151893e-01f, 3.19297500e-02f, 1.20090179e-01f, -1.24988593e-02f, 1.61847696e-02f, -1.40979618e-01f, 4.09086533e-02f, 6.01092959e-03f, 1.45499200e-01f,
  1.78668171e-01f, -1.01619713e-01f, 2.02197805e-02f, -1.35360155e-02f, -1.48648009e-01f, -1.60657406e-01f, -7.51660541e-02f, 4.82533053e-02f, -1.02228232e-01f, 9.44812745e-02f,
  1.73175912e-02f, 4.28532176e-02f, -2.68078912e-02f, 8.22743177e-02f, 1.94233969e-01f, -9.88405757e-03f, -1.58033092e-02f, 5.43768927e-02f, -4.17403132e-02f, 1.95705459e-01f,
  -1.97052151e-01f, 1.54578499e-03f, -6.73167929e-02f, -1.64133474e-01f, -1.67115375e-01f, -1.23540312e-01f, -7.78686255e-02f, 1.00746244e-01f, -1.31608732e-03f, 1.54387997e-02f,
  -5.61453514e-02f, 1.18869394e-01f, 8.23538601e-02f, 2.98284680e-01f, -3.19935828e-02f, 1.18476413e-01f, 5.33248996e-03f, -5.45434393e-02f, 2.22805962e-01f, 1.71969056e-01f,
  -3.57424915e-02f, -1.19345021e-02f, 4.18762527e-02f, 9.11524147e-02f, 1.71043187e-01f, -1.77352608e-03f, -2.50564646e-02f, 3.49295773e-02f, 1.24276988e-01f, 1.93894021e-02f,
  9.67201442e-02f, -7.60461986e-02f, -8.85849744e-02f, 8.42137635e-03f, 1.12595603e-01f, 3.83149125e-02f, -7.64308721e-02f, 8.07598419e-03f, 1.29057616e-01f, 1.32600620e-01f,
  -8.91025811e-02f, 1.38894722e-01f, -2.15584282e-02f, 9.80595648e-02f, 7.80247524e-02f, 1.32621899e-01f, -1.80882160e-02f, -1.92622636e-02f, 9.27127339e-03f, 2.44765915e-02f,
  -4.60670423e-03f, 2.06767861e-02f, -4.10356037e-02f, 6.63392246e-03f, 4.15936224e-02f, 1.28898814e-01f, -1.83814391e-02f, 3.60110253e-02f, -1.06356971e-01f, 1.15444981e-01f,
  -5.76367117e-02f, -4.44676615e-02f, 2.46396661e-02f, -2.31179185e-02f, 7.84296840e-02f, -1.39268637e-01f, -1.86119769e-02f, 7.15515837e-02f, 5.71122319e-02f, -1.47763819e-01f,
  -2.03072913e-02f, 1.66399535e-02f, -1.42619596e-03f, 2.24701352e-02f, 1.35220811e-02f, -2.07966324e-02f, -8.20976421e-02f, -9.86233726e-02f, -1.92137174e-02f, 4.38524932e-02f,
  -5.61725423e-02f, -1.94254890e-01f, 8.38491097e-02f, -1.24953717e-01f, 1.05068408e-01f, 1.15543090e-01f, -9.68601853e-02f, 1.53204113e-01f, -1.10480055e-01f, 6.18367717e-02f,
  -3.15028206e-02f, -5.59010729e-02f, -3.51185314e-02f, 1.39452457e-01f, 1.22167937e-01f, 7.12903515e-02f, 6.77485168e-02f, 6.03950247e-02f, 1.00612670e-01f, 3.66964638e-02f,
  -7.15664588e-04f, -9.71310306e-03f, -1.92383379e-01f, 7.77704120e-02f, -1.28665701e-01f, 3.91479991e-02f, -1.78708911e-01f, -2.12040786e-02f, -8.45816638e-03f, 1.43277645e-01f,
  1.73543796e-01f, -1.15026727e-01f, 7.33891577e-02f, 1.32194027e-01f, 6.47227168e-02f, -1.47334546e-01f, 1.10656030e-01f, -1.62918195e-01f, -2.54210502e-01f, 5.25204428e-02f,
  3.24071907e-02f, -1.36732683e-01f, -1.43493667e-01f, -1.11366166e-02f, -6.62077665e-02f, -1.42657282e-02f, 7.07451254e-02f, -1.51043296e-01f, 1.35055020e-01f, 2.00435206e-01f,
  2.52344832e-02f, 1.80778176e-01f, -1.24006122e-01f, -5.33003137e-02f, 3.14919315e-02f, 4.11163308e-02f, -5.18284701e-02f, -1.71302073e-02f, 1.68045126e-02f, -3.18730474e-02f,
  -1.79121986e-01f, -3.13440681e-01f, 1.97017081e-02f, -2.46397220e-03f, 2.66407570e-03f, -2.97652762e-02f, -1.43657148e-01f, -3.04410812e-02f, -1.73271298e-01f, 6.26868755e-02f,
  3.13785486e-02f, 1.22755878e-02f, -1.30685726e-02f, 3.08079980e-02f, 1.08003253e-02f, 8.30960199e-02f, 4.19517942e-02f, 5.76971658e-02f, -4.69302908e-02f, -4.17431369e-02f,
  9.67179462e-02f, -1.21733166e-01f, 3.69571634e-02f, 3.92403789e-02f, -1.90113373e-02f, 5.54682035e-03f, 1.19861126e-01f, 9.77841765e-02f, -5.77995628e-02f, 9.63331088e-02f,
  -3.89841311e-02f, -1.41258519e-02f, 4.55617579e-03f, 6.84354231e-02f, 4.48285751e-02f, 2.71421354e-02f, 3.25450227e-02f, -3.61841433e-02f, 3.30231339e-02f, 5.16839065e-02f,
  9.25388187e-02f, -2.63300519e-02f, 6.76494688e-02f, -3.02018393e-02f, 6.35014623e-02f, -7.89289996e-02f, -6.53257146e-02f, -2.50744708e-02f, -1.14374332e-01f, -4.56624553e-02f,
  -2.37920824e-02f, 8.58953409e-03f, 2.35069124e-03f, 3.19350176e-02f, -9.29806456e-02f, 2.87583228e-02f, 1.02963731e-01f, 3.22625712e-02f, 2.37629004e-03f, 1.07082881e-01f,
  7.03815967e-02f, 3.06957476e-02f, -2.73546819e-02f, -5.26811481e-02f, -3.16442437e-02f, 2.41680350e-03f, 3.90387774e-02f, 4.63212002e-03f, -3.45024355e-02f, 6.82004616e-02f,
  -4.90088873e-02f, 1.32981673e-01f, 1.25963211e-01f, -1.71947494e-01f, -3.52907479e-02f, 1.60906091e-01f, -6.36739731e-02f, -6.32649511e-02f, -6.16918914e-02f, 1.31209642e-01f,
  -2.25149076e-02f, 1.76971748e-01f, -1.39863500e-02f, -6.67477250e-02f, -2.04194561e-02f, -1.18344553e-01f, 3.75370346e-02f, -1.26646802e-01f, -6.88822344e-02f, -8.06049332e-02f,
  -4.69149649e-02f, 7.15670586e-02f, 1.23207524e-01f, -4.12959531e-02f, -4.28935550e-02f, -1.45799264e-01f, -1.39489640e-02f, 6.79313019e-02f, 5.16042933e-02f, -5.32574840e-02f,
  1.27406642e-01f, 1.38883172e-02f, 8.91206264e-02f, -6.41027763e-02f, 1.54073060e-01f, -3.23742032e-02f, 5.01111597e-02f, 3.86677682e-02f, -1.44938216e-01f, 1.42131552e-01f,
  -1.81794800e-02f, -1.95370972e-01f, 1.70921057e-01f, -1.96115181e-01f, -1.29768187e-02f, 3.91192660e-02f, 7.76260346e-02f, 8.53846893e-02f, 5.67606501e-02f, 1.78476334e-01f,
  1.51122361e-02f, 1.38277411e-02f, 1.35890812e-01f, 1.90227792e-01f, -9.82677639e-02f, 4.13313471e-02f, -1.15824200e-01f, -3.25361229e-02f, -2.21670806e-01f, -1.41732305e-01f,
  1.63730964e-01f, -1.81588322e-01f, -6.79442137e-02f, 2.41536507e-03f, -1.03354692e-01f, -5.32673374e-02f, 9.04189274e-02f, 1.37417819e-02f, -8.89012292e-02f, 8.53673518e-02f,
  3.10195256e-02f, -1.35557532e-01f, -2.06506364e-02f, -1.02916747e-01f, 8.55639577e-02f, 5.28968051e-02f, -2.09172238e-02f, 4.17954614e-03f, 9.24887657e-02f, 2.36315094e-02f,
  4.86387014e-02f, -6.32130355e-03f, 2.68689804e-02f, 1.04638636e-02f, -4.16386686e-02f, -4.31643240e-02f, 7.16063604e-02f, 1.97312143e-02f, 6.36222884e-02f, 3.20376568e-02f,
  4.18045186e-02f, -4.36404208e-03f, 1.84321087e-02f, -6.26130700e-02f, 4.27152999e-02f, 5.48218414e-02f, -5.97787686e-02f, 4.89722788e-02f, 1.43943969e-02f, 1.02845544e-04f,
  3.32719013e-02f, 2.29108408e-02f, 1.39092460e-01f, 1.14428708e-02f, 2.71841194e-02f, 8.31225142e-02f, 9.02062953e-02f, -7.20134377e-02f, -2.92164683e-02f, 3.57640311e-02f,
  3.42507139e-02f, 3.40496115e-02f, -4.05960679e-02f, 4.14961390e-02f, 1.26316426e-02f, -7.67125785e-02f, 1.35398313e-01f, 1.25723496e-01f, -9.23507810e-02f, -8.94393474e-02f,
  -2.39329301e-02f, 1.79445878e-01f, -5.03505580e-02f, 2.41070166e-02f, 2.63847988e-02f, 1.05019897e-01f, -9.06770770e-03f, -4.52668667e-02f, 7.85154700e-02f, -6.18823729e-02f,
  1.59972057e-01f, 5.86172827e-02f, 1.12243526e-01f, 1.37748262e-02f, -2.20192131e-02f, 2.17301827e-02f, 1.60878479e-01f, -4.20670509e-02f, -4.54207882e-02f, 1.15781985e-01f,
  6.45626932e-02f, 6.94677606e-02f, -1.33644029e-01f, 8.71461332e-02f, 8.86667753e-04f, -1.08685113e-01f, -5.69021935e-03f, 1.35456905e-01f, -2.13292744e-02f, 1.91181988e-01f,
  5.64086325e-02f, 2.44736522e-02f, -3.38368490e-02f, -9.05770808e-02f, 5.69205619e-02f, -3.75799127e-02f, 1.76731870e-01f, -1.40097335e-01f, -6.18969500e-02f, 3.68034467e-02f,
  -4.01118845e-02f, 1.21373504e-01f, -5.38184941e-02f, -6.93940371e-02f, -3.32858562e-02f, -6.05152082e-03f, -1.70444250e-02f, -3.86852287e-02f, -1.47442073e-01f, -4.88185138e-02f,
  -1.12059221e-01f, -1.90394610e-01f, 2.69071572e-02f, 8.18172470e-03f, -1.67463005e-01f, 4.68633398e-02f, -1.37541845e-01f, -5.34282997e-02f, -6.78008869e-02f, -6.77785352e-02f,
  1.53532028e-02f, -9.61032137e-03f, -2.44455978e-01f, -5.17057080e-04f, 3.89427245e-02f, -1.82767183e-01f, -2.60299742e-02f, 7.57647529e-02f, -2.07550779e-01f, -3.34436365e-04f,
  6.60696300e-03f, 1.35021910e-01f, -1.59131691e-01f, -1.14276469e-01f, -1.38158381e-01f, -1.20594688e-01f, -1.58976525e-01f, 1.00539848e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.39781311e-02f, 3.15432064e-02f, 4.89400737e-02f, 1.28145188e-01f, 1.66011468e-01f, 1.43123195e-01f, 1.52036488e-01f, 3.80605571e-02f, 2.36998916e-01f, 3.07452381e-02f,
  1.24774072e-02f, 1.37505427e-01f, 2.51700878e-02f, 1.31719321e-01f, 1.28980622e-01f, -2.86338255e-02f, 2.12124035e-01f, 2.06931587e-02f, 6.02978766e-02f, 1.20944552e-01f,
  1.77352130e-02f, 6.23189844e-02f, 1.15070706e-02f, 6.09749220e-02f, 6.80106953e-02f, 6.39069676e-02f, 1.33197099e-01f, 5.91482855e-02f, 5.04071862e-02f, 1.23061575e-01f,
  1.73323333e-01f, 1.41272604e-01f, 1.31893501e-01f, 4.14234549e-02f, 7.26555958e-02f, 8.00916627e-02f, -2.84916107e-02f, 7.14954436e-02f, 1.18385278e-01f, 9.78382397e-03f,
  4.83363643e-02f, 1.57992482e-01f, 8.88146460e-02f, -9.40430611e-02f, 8.07111561e-02f, 1.09468438e-01f, 1.02596126e-01f, 3.61797176e-02f, 6.14527240e-03f, 1.25897944e-01f,
  1.91208199e-02f, -4.61945944e-02f, 1.53301939e-01f, 1.30059019e-01f, 2.45920986e-01f, -1.52720427e-02f, -1.03512146e-01f, 4.90780082e-03f, 3.51795137e-01f, 9.00408775e-02f,
  -6.93045259e-02f, -1.52386472e-01f, -9.26745906e-02f, 1.93939265e-02f, 7.08312392e-02f, -1.41892489e-02f, 3.73303771e-01f, 2.46866643e-01f, 8.89130533e-02f, 1.98838249e-01f,
  7.46256039e-02f, -1.54576041e-02f, -1.83399871e-01f, 7.47982338e-02f, 5.12239859e-02f, 1.24218710e-01f, -2.92365756e-02f, 2.05989271e-01f, -4.25445326e-02f, -1.43052349e-02f,
  1.70591354e-01f, 2.03686342e-01f, -1.71874151e-01f, -2.24992204e-02f, 2.12243497e-02f, 2.52338260e-01f, 1.17138810e-01f, -3.01636398e-01f, 4.06679027e-02f, 2.24871174e-01f,
  -3.62493284e-02f, 7.35535398e-02f, 8.14821497e-02f, 7.27998167e-02f, -9.53750387e-02f, 2.66139477e-01f, -1.78690255e-01f, -1.96417999e-02f, 3.17499377e-02f, -2.31349930e-01f,
  1.57861069e-01f, -2.12574020e-01f, -2.59426516e-02f, -5.21234609e-02f, -1.07922316e-01f, 3.12636852e-01f, 2.64432449e-02f, 2.62546927e-01f, 1.37671307e-01f, -1.95634048e-02f,
  2.52399027e-01f, 9.54717845e-02f, -4.54548076e-02f, -1.06054276e-01f, 1.94906041e-01f, 2.02009141e-01f, -9.97596234e-02f, 4.31319416e-01f, -1.33476913e-01f, -2.58508325e-01f,
  1.16766421e-02f, -2.10313380e-01f, 2.32717708e-01f, -2.47266427e-01f, -1.41680464e-01f, 7.78179541e-02f, -2.22089574e-01f, 7.48727024e-02f, -1.20259129e-01f, -2.31370050e-02f,
  1.34397775e-01f, 2.13305969e-02f, 9.53563675e-02f, 9.76652503e-02f, -5.93786407e-03f, 1.64475903e-01f, 1.54532000e-01f, -2.05993932e-02f, 5.82457110e-02f, 1.02308370e-01f,
  9.84351709e-02f, -3.35155800e-03f, -4.10163738e-02f, -2.54705865e-02f, 1.75949618e-01f, -8.64487421e-03f, 1.70383230e-01f, -4.14940417e-02f, -1.64417610e-01f, 5.50373495e-02f,
  -2.68747546e-02f, 1.22724518e-01f, -9.04478803e-02f, 8.03471878e-02f, 1.24049559e-01f, -1.42045975e-01f, -7.55900592e-02f, 4.76151407e-02f, 8.20391774e-02f, 8.61394927e-02f,
  2.12422580e-01f, 1.36001915e-01f, 1.75218865e-01f, 9.94633585e-02f, 9.91882458e-02f, 1.82774857e-01f, 1.22648798e-01f, 1.27971470e-01f, 7.87467435e-02f, 1.85210705e-01f,
  2.56849140e-01f, -2.65973479e-01f, 8.76921862e-02f, 5.57870269e-02f, -1.08667113e-01f, -1.07121624e-01f, 2.00660527e-01f, 1.96722195e-01f, 7.03800470e-02f, 7.56650791e-02f,
  -8.54221135e-02f, 1.14224069e-01f, 4.69631031e-02f, -1.46128669e-01f, 1.04338981e-01f, 2.80537575e-01f, 2.16969904e-02f, 3.02743554e-01f, -2.38299116e-01f, -1.02711409e-01f,
  -8.75335261e-02f, -2.57685691e-01f, 2.85711527e-01f, -1.09674573e-01f, 2.31411085e-01f, 7.87357688e-02f, 1.41778082e-01f, -1.49141878e-01f, -2.13424936e-01f, -1.67125911e-01f,
  -5.16644008e-02f, -1.81209728e-01f, -4.42067236e-02f, 1.72178075e-01f, 1.04466729e-01f, 1.24105051e-01f, 1.71799988e-01f, -1.65148288e-01f, 1.41747832e-01f, 1.12953700e-01f,
  1.29232898e-01f, 2.26360381e-01f, 1.03530791e-02f, -1.86919913e-01f, -2.84536421e-01f, 5.73548265e-02f, -1.67026624e-01f, -2.39610359e-01f, -6.03107437e-02f, 1.52170017e-01f,
  -1.17896251e-01f, 3.04631859e-01f, 2.72059590e-01f, -1.41949967e-01f, 5.06307408e-02f, -4.75126766e-02f, 2.76358515e-01f, -4.72105900e-03f, 6.24053068e-02f, 1.73586950e-01f,
  -7.30477422e-02f, 1.70474157e-01f, -4.45293933e-02f, -8.50010961e-02f, 1.78988189e-01f, -5.24867326e-02f, 1.33912712e-01f, 2.67227501e-01f, 1.38130978e-01f, -2.76135076e-02f,
  2.94859499e-01f, -1.11170366e-01f, 5.07346056e-02f, 2.67190188e-01f, 3.55279356e-01f, 4.27044421e-01f, 5.21153994e-02f, 5.65087199e-02f, 1.14718832e-01f, -1.99837074e-01f,
  3.60304803e-01f, 9.17409882e-02f, 2.90881008e-01f, 1.64012983e-01f, 7.39698783e-02f, -1.34948134e-01f, 2.83573382e-03f, -2.40384764e-03f, 8.48961025e-02f, 1.53314486e-01f,
  -1.19300932e-02f, 1.42292053e-01f, -1.04424097e-02f, 1.12493746e-01f, 1.08375303e-01f, 2.77667996e-02f, -4.28516343e-02f, 3.38676083e-03f, 1.31368920e-01f, 7.16670305e-02f,
  1.97657645e-01f, 1.69752434e-01f, 1.83669657e-01f, 8.38628337e-02f, 1.21635415e-01f, 7.50138098e-03f, -4.13776040e-02f, 3.96745540e-02f, 1.60703450e-01f, 1.62012447e-02f,
  1.84244350e-01f, 1.13636032e-01f, 8.04258808e-02f, 1.61034733e-01f, -3.18420306e-02f, 4.70123217e-02f, 1.64636731e-01f, 1.21041462e-01f, 6.58421544e-03f, 1.32207185e-01f,
  1.53850138e-01f, 1.53373107e-01f, 1.33039445e-01f, 1.56487927e-01f, 7.64226541e-02f, 1.40355438e-01f, 1.51398078e-01f, 2.20574737e-01f, 1.21599711e-01f, 7.20275119e-02f,
  1.41792923e-01f, 1.38045043e-01f, 1.71403468e-01f, 1.13935210e-01f, 7.47856125e-02f, 8.28683004e-02f, -1.61133651e-02f, -1.39271587e-01f, 6.98867664e-02f, 1.21199727e-01f,
  6.64613694e-02f, -5.50370067e-02f, 1.93398409e-02f, 9.52707380e-02f, 3.64867300e-01f, 7.50058889e-02f, 5.21188509e-03f, -2.68930882e-01f, -1.65185273e-01f, 1.43507659e-01f,
  -1.06404327e-01f, 7.32694194e-03f, 2.23490134e-01f, 2.68703520e-01f, -3.82792391e-02f, -2.35999469e-02f, 1.65425256e-01f, -6.00793399e-02f, -2.87630051e-01f, 2.62025416e-01f,
  -2.55119264e-01f, -2.06594780e-01f, -2.59827018e-01f, -7.10875764e-02f, 1.85231566e-02f, 8.51511136e-02f, 2.98872381e-01f, 1.39699504e-01f, 2.01211393e-01f, -2.17759624e-01f,
  -3.03582668e-01f, 1.45992175e-01f, 1.33323342e-01f, 5.22455424e-02f, 2.17292264e-01f, 2.49381870e-01f, 2.46923879e-01f, 2.23221272e-01f, 2.79726595e-01f, 1.41710117e-01f,
  1.79478586e-01f, 2.31201112e-01f, -8.87468904e-02f, -1.81222204e-02f, -1.19100384e-01f, -3.08710754e-01f, 1.20030977e-01f, -2.17119068e-01f, -1.89219102e-01f, 3.02151591e-01f,
  -1.01675689e-01f, 2.25358576e-01f, -7.10196346e-02f, 1.95725054e-01f, 2.22236067e-01f, 2.10463986e-01f, 1.41181171e-01f, 1.48866344e-02f, 6.74495623e-02f, 1.16497487e-01f,
  1.99259341e-01f, 1.35734817e-03f, -2.05124050e-01f, -6.04409836e-02f, -7.70747513e-02f, -3.28996442e-02f, 1.00723796e-01f, 2.06146345e-01f, 8.31390694e-02f, -3.17530632e-01f,
  8.73131976e-02f, 9.29095820e-02f, -2.58456886e-01f, 2.77734041e-01f, 5.48573993e-02f, -5.05033843e-02f, 7.24190697e-02f, -3.25835235e-02f, 8.29239637e-02f, 4.85605001e-02f,
  -1.98515202e-03f, 9.33878571e-02f, -6.98618591e-02f, 1.49506137e-01f, 9.32729989e-03f, 5.13150124e-03f, 1.44222658e-02f, 9.98636559e-02f, 9.76532400e-02f, -2.49653347e-02f,
  4.95510250e-02f, 5.34443446e-02f, 2.96680070e-02f, 8.31620619e-02f, -4.20751050e-02f, 6.66446164e-02f, -5.69928857e-03f, 1.22124106e-01f, 1.29242912e-01f, 1.75489128e-01f,
  1.09416552e-01f, 1.04456425e-01f, 6.69939741e-02f, 5.41763827e-02f, 1.09463837e-02f, 1.26421511e-01f, 1.23423427e-01f, 8.44528433e-03f, 1.33006960e-01f, 1.13223739e-01f,
  9.25448984e-02f, 1.03016183e-01f, 1.10605843e-01f, 1.07849510e-02f, -2.32024863e-03f, 5.89439534e-02f, -2.65018996e-02f, 1.21196643e-01f, -5.86402342e-02f, 5.91844022e-02f,
  9.55905691e-02f, -8.28000456e-02f, 6.69380054e-02f, 1.34408906e-01f, 1.61058977e-01f, 1.22914657e-01f, -2.06575781e-01f, -1.45925492e-01f, 1.38115019e-01f, 3.89704369e-02f,
  7.76377618e-02f, -2.39143819e-01f, -2.97737926e-01f, 2.93135285e-01f, -1.01118296e-01f, 3.25575203e-01f, -2.70656683e-02f, 6.32819310e-02f, 1.59824386e-01f, -3.08630198e-01f,
  -1.48064390e-01f, -2.34610066e-01f, -1.27706826e-01f, -7.90381338e-03f, 2.21004467e-02f, 1.26243234e-01f, 1.35190174e-01f, -4.67826277e-02f, 2.56387591e-01f, -6.60044476e-02f,
  -1.93334386e-01f, -7.19929188e-02f, 2.12284371e-01f, 1.38578400e-01f, 7.89301917e-02f, -2.61459440e-01f, -3.30178603e-03f, -9.95364115e-02f, -9.93165150e-02f, -1.93054765e-01f,
  -6.69508278e-02f, 2.79776633e-01f, -3.50085825e-01f, -2.40729615e-01f, 2.20474765e-01f, 1.80437341e-01f, 2.14908004e-01f, -5.60026579e-02f, 2.66923279e-01f, -3.00034255e-01f,
  -2.34943062e-01f, -1.01159148e-01f, -5.55633530e-02f, 2.03424990e-01f, -5.09570949e-02f, -1.60830691e-01f, 1.87911436e-01f, 1.40609205e-01f, 4.15430725e-01f, 7.53687993e-02f,
  1.13593891e-01f, 2.11263359e-01f, -2.35197902e-01f, 6.73662871e-02f, 1.29289227e-02f, -8.04885477e-03f, 1.19618118e-01f, 8.34475607e-02f, -2.92330712e-01f, -3.42701942e-01f,
  3.52351457e-01f, 1.40639648e-01f, 2.94662535e-01f, -2.02215761e-01f, 1.01917379e-01f, 5.83912805e-02f, -1.49033397e-01f, 2.95043200e-01f, 1.02511257e-01f, 1.73734695e-01f,
  2.38260284e-01f, -5.08972220e-02f, 9.92092341e-02f, 2.33766824e-01f, -1.08019710e-02f, 1.38049379e-01f, 3.89405005e-02f, -5.78856841e-03f, 1.52410865e-01f, 6.05707690e-02f,
  1.37058154e-01f, 1.38852447e-01f, 1.67144209e-01f, 1.31245211e-01f, 3.75046656e-02f, 8.29921737e-02f, -3.07062622e-02f, 1.72846451e-01f, -5.97123764e-02f, 8.70361030e-02f,
  8.42734501e-02f, 6.65365756e-02f, 1.37467757e-01f, 4.51482460e-02f, 6.95472881e-02f, -4.87432927e-02f, 1.21089719e-01f, 1.43512329e-02f, 1.01374239e-01f, 2.13440150e-01f,
  1.18421502e-01f, -1.14744045e-02f, 1.39492959e-01f, 1.13756239e-01f, 3.86384577e-02f, 1.41795635e-01f, 4.46569361e-02f, 2.00463482e-03f, -6.99652545e-03f, 1.34284645e-01f,
  1.60927430e-01f, 8.08716640e-02f, 6.08490333e-02f, 3.57272364e-02f, 2.14393407e-01f, 2.31293261e-01f, -3.34858783e-02f, 1.30601317e-01f, 7.46782050e-02f, 8.79766271e-02f,
  1.14519978e-02f, 1.17826156e-01f, -4.79543954e-02f, -3.24818194e-01f, 3.64673436e-01f, 2.16252729e-01f, -2.31037455e-04f, 1.89366624e-01f, 1.94700927e-01f, -3.71511765e-02f,
  1.53407678e-01f, -2.12488882e-02f, 8.83166194e-02f, -1.51235908e-01f, 2.58023411e-01f, 7.02688340e-05f, 5.94472419e-03f, -3.07492097e-03f, -1.99753568e-01f, 1.96219772e-01f,
  1.74256228e-02f, -1.45385697e-01f, -9.03607979e-02f, -2.09084094e-01f, -9.76639986e-02f, -2.00161174e-01f, -1.24233663e-01f, 5.93630336e-02f, -1.19507043e-02f, 2.33183891e-01f,
  -3.17993999e-01f, 9.42865293e-03f, -2.26875558e-01f, 9.60531682e-02f, 4.39335294e-02f, -2.75585026e-01f, 5.54858819e-02f, 2.44707078e-01f, 1.59662683e-02f, 1.54630020e-01f,
  1.94540843e-01f, 2.07282424e-01f, 9.56806764e-02f, -3.49802990e-03f, -2.60189418e-02f, 2.22975925e-01f, -1.65933728e-01f, 1.29506826e-01f, -1.38529420e-01f, 3.36712785e-02f,
  1.97962955e-01f, -2.29045033e-01f, 2.85896182e-01f, 1.83680937e-01f, -3.79684955e-01f, -1.41604021e-01f, -5.21359071e-02f, -8.53672549e-02f, 2.16695264e-01f, -1.49195880e-01f,
  -2.21316610e-02f, -1.99232921e-01f, -8.21068883e-02f, 8.17509741e-02f, 2.33893186e-01f, 9.65377018e-02f, 2.28696957e-01f, 1.98928460e-01f, 1.07146412e-01f, -1.86615989e-01f,
  7.22238347e-02f, 2.84719765e-01f, 1.05111554e-01f, 7.30308294e-02f, 4.53733914e-02f, 7.03518987e-02f, 3.86068940e-01f, -1.58589661e-01f, -6.40397891e-02f, 1.55413330e-01f,
  -1.13027068e-02f, -2.13616699e-01f, -9.61060449e-03f, 1.00647345e-01f, 8.98850858e-02f, -1.02049415e-03f, 2.09893491e-02f, -4.62671965e-02f, 1.32176071e-01f, 7.59420544e-02f,
  3.91239338e-02f, 1.22918911e-01f, -3.46850720e-03f, 9.05934572e-02f, 6.61932677e-02f, 4.59997430e-02f, 3.20290476e-02f, 4.74046655e-02f, 5.40614165e-02f, -8.66500288e-03f,
  -9.77970427e-04f, 4.36354913e-02f, -1.13336422e-01f, 1.12432532e-01f, 1.19221359e-01f, 4.71290946e-02f, 8.83334056e-02f, -1.34464532e-01f, 8.31677020e-02f, 8.21515098e-02f,
  2.14848965e-02f, 9.86285955e-02f, 1.08089730e-01f, -2.71152332e-02f, 6.38456270e-02f, -5.22514665e-03f, 5.71634099e-02f, 1.44578731e-02f, -2.80407332e-02f, -8.98413658e-02f,
  9.87796038e-02f, -1.01561986e-01f, 1.27229124e-01f, 3.79204601e-02f, -9.29948911e-02f, -4.97928411e-02f, 5.01517914e-02f, 2.32521142e-03f, 1.13512367e-01f, 1.31668225e-01f,
  3.96610126e-02f, 3.09776902e-01f, -1.33832231e-01f, -1.24071509e-01f, 3.44747692e-01f, 1.47840351e-01f, 2.18498126e-01f, -3.41558993e-01f, 1.37517497e-01f, 1.48802638e-01f,
  2.54053891e-01f, 1.37172982e-01f, -4.72187363e-02f, 2.35872328e-01f, 1.02834068e-01f, -2.21830800e-01f, 2.55635560e-01f, 8.51186216e-02f, -1.67365372e-01f, -5.22952937e-02f,
  3.39820027e-01f, 3.20987165e-01f, -2.65436824e-02f, 1.98124889e-02f, -7.24230334e-02f, -5.80033809e-02f, -4.99668671e-03f, 2.75285631e-01f, 1.20053791e-01f, 2.23690376e-01f,
  1.37171838e-02f, -2.31703788e-01f, 1.49203371e-02f, -1.60451949e-01f, 6.15268350e-02f, 3.44949722e-01f, 3.67471933e-01f, -2.29998082e-02f, -1.50427505e-01f, 3.99593897e-02f,
  1.31002247e-01f, 1.73610747e-01f, 9.50873941e-02f, -3.81845701e-03f, 8.93995538e-02f, 8.11296925e-02f, -3.31806779e-01f, -2.49457344e-01f, -1.91864461e-01f, 8.16546306e-02f,
  -3.58537845e-02f, -1.08500525e-01f, 3.84446830e-02f, 3.75504941e-01f, 1.84754297e-01f, -6.95472583e-02f, 5.81873208e-02f, -5.97024849e-03f, 1.85707361e-02f, 1.40645131e-01f,
  -4.84021641e-02f, 2.96842873e-01f, -2.07413211e-01f, 2.41639808e-01f, 3.48273724e-01f, -9.26700905e-02f, 1.63319767e-01f, 3.02774906e-01f, -1.40002798e-02f, -4.87717614e-02f,
  3.58349234e-01f, 8.82716775e-02f, -3.20365429e-01f, -2.88182832e-02f, -1.65524513e-01f, 2.40521282e-01f, 1.70136645e-01f, 2.22441718e-01f, 8.49460959e-02f, -3.48265916e-02f,
  9.59580541e-02f, 9.07748342e-02f, 2.58786470e-01f, 2.14761198e-01f, 7.90972933e-02f, 1.05040953e-01f, 1.56048506e-01f, 6.25418965e-03f, 1.23007298e-01f, 1.41497210e-01f,
  3.57160345e-02f, 5.95262311e-02f, 4.42866832e-02f, 4.38051112e-02f, -4.77206595e-02f, 6.73667863e-02f, 9.89209488e-02f, 1.39752477e-01f, 1.75917950e-02f, 1.43449575e-01f,
  1.15531169e-01f, 3.58704291e-02f, 2.56785024e-02f, 1.55392200e-01f, 2.49673694e-01f, -1.13377556e-01f, 3.46923880e-02f, 1.09517686e-01f, 1.53482944e-01f, 5.22299223e-02f,
  2.11703822e-01f, 2.06794962e-01f, 4.55683097e-02f, 1.02269441e-01f, 2.38828763e-01f, -3.91676463e-02f, 8.46454725e-02f, 6.75827041e-02f, -3.48395407e-02f, 1.01751819e-01f,
  1.08117633e-01f, -1.38577104e-01f, 2.16663286e-01f, 3.39453458e-03f, 1.87738970e-01f, 1.69517010e-01f, 8.36183578e-02f, 1.20922774e-01f, 1.66100845e-01f, 8.59428495e-02f,
  -2.45386735e-01f, -2.08723664e-01f, 3.98953855e-02f, -5.79322129e-02f, -3.26391995e-01f, 9.39917862e-02f, -2.91701585e-01f, -2.11192131e-01f, -1.56549662e-02f, 1.23376995e-01f,
  8.90669823e-02f, -5.50850444e-02f, -1.70770481e-01f, 1.40364170e-01f, 1.81702390e-01f, -1.80622265e-01f, 6.08084872e-02f, 1.80467069e-01f, -6.59967288e-02f, 2.49827713e-01f,
  1.35689884e-01f, 1.52962342e-01f, 2.50950813e-01f, -4.56342585e-02f, 2.30101451e-01f, -5.85498139e-02f, 2.39517242e-01f, -2.01103799e-02f, 1.54957753e-02f, -9.28130820e-02f,
  -1.28514916e-01f, 2.39117071e-01f, 7.11867809e-02f, -2.45585695e-01f, 9.19158980e-02f, -2.18837097e-01f, -2.18707696e-01f, -2.88569719e-01f, -1.92531541e-01f, 6.49283305e-02f,
  -1.66713193e-01f, -1.28420815e-01f, 1.70012146e-01f, -2.31263489e-02f, 2.34969988e-01f, 1.84658617e-01f, -4.18141373e-02f, 2.02168792e-01f, -2.49800116e-01f, -5.58393672e-02f,
  3.38864386e-01f, 3.59035224e-01f, -1.56324252e-01f, -2.99657047e-01f, -2.76295125e-01f, -1.64597914e-01f, -2.10084885e-01f, -8.70114565e-02f, 2.69657560e-02f, 1.17921740e-01f,
  -2.60811597e-01f, -1.13005647e-02f, -2.24795043e-01f, 1.75824821e-01f, 4.69446965e-02f, 3.28492403e-01f, 6.23684563e-03f, 2.69759804e-01f, 8.62111673e-02f, 2.86704153e-01f,
  1.94978416e-01f, 7.09117651e-02f, -1.40745461e-01f, 1.41214624e-01f, 1.13092303e-01f, 3.03209156e-01f, -9.00088623e-02f, 4.56364639e-02f, 5.84797561e-02f, -3.66493165e-02f,
  -1.70018654e-02f, 1.55424997e-01f, 2.14417055e-02f, 8.63817707e-03f, 1.88055173e-01f, -1.37901744e-02f, 1.10692814e-01f, 1.09644778e-01f, 2.16117352e-01f, -1.27417013e-01f,
  3.82823683e-03f, -1.82176270e-02f, 2.60231316e-01f, 4.78934087e-02f, 5.84747046e-02f, 4.91517559e-02f, -6.96894825e-02f, -6.83295634e-03f, -5.68066686e-02f, 7.18475357e-02f,
  3.24389040e-02f, 9.99019220e-02f, 1.61887649e-02f, -2.08308585e-02f, 2.18340412e-01f, 1.06965758e-01f, 1.60218641e-01f, 7.76300356e-02f, 1.94206312e-01f, 9.55445841e-02f,
  1.49956167e-01f, -4.23640981e-02f, 1.84825704e-01f, 3.58358212e-02f, 9.43479240e-02f, 1.82875454e-01f, 1.07254937e-01f, 3.99484426e-01f, 1.02472611e-01f, 6.77742204e-03f,
  2.50948042e-01f, 3.85122240e-01f, 6.38008630e-03f, -9.87179205e-02f, 7.23276734e-02f, 1.66075140e-01f, 2.01210603e-01f, 1.19277127e-01f, 1.77643269e-01f, 4.41223770e-01f,
  6.05059182e-03f, 1.70885354e-01f, 3.63204688e-01f, 3.08888495e-01f, 2.51497388e-01f, 3.10201913e-01f, -2.59609997e-01f, -2.47994080e-01f, 1.99849844e-01f, -2.00446144e-01f,
  2.95265824e-01f, -1.36056632e-01f, 1.09214053e-01f, -5.63092157e-02f, 1.01733908e-01f, -2.03472808e-01f, -1.54331625e-01f, -2.26119980e-01f, -3.27453345e-01f, 2.37916447e-02f,
  -1.94882825e-01f, 4.23568301e-02f, 2.74306864e-01f, 3.05805027e-01f, 9.18151885e-02f, -7.28495345e-02f, 6.62271976e-02f, 1.64351687e-01f, 1.62560791e-01f, -7.39367977e-02f,
  2.29885548e-01f, -5.46901822e-02f, -6.89384118e-02f, 2.13648602e-01f, -1.37117118e-01f, -7.74891973e-02f, 7.43172318e-02f, 2.07826003e-01f, -6.66812286e-02f, 3.01380306e-01f,
  2.45693550e-01f, -5.84856607e-02f, -1.05869718e-01f, 2.77866751e-01f, 2.87333224e-02f, -1.48369417e-01f, 1.74673721e-01f, 1.25507951e-01f, -1.37860775e-01f, -2.10698903e-01f,
  -1.75661281e-01f, -8.60079899e-02f, 1.40033379e-01f, -1.35784253e-01f, -2.42833585e-01f, -1.98364407e-01f, 2.21123561e-01f, -2.14854732e-01f, 1.02059199e-02f, -6.47782683e-02f,
  1.21174589e-01f, 2.88844496e-01f, 2.29955867e-01f, 3.97846490e-01f, -9.96499043e-03f, 4.89593223e-02f, 2.00161964e-01f, 1.05629988e-01f, 3.32846999e-01f, -2.12798700e-01f,
  2.96258420e-01f, -3.26950215e-02f, -1.81466043e-01f, -1.77632973e-01f, 5.08274809e-02f, -7.05830902e-02f, 1.06811464e-01f, 2.31703240e-02f, 9.23275873e-02f, -4.15194454e-03f,
  7.52752423e-02f, 3.58574577e-02f, 6.83808625e-02f, 2.45284647e-01f, -6.40354352e-03f, 4.19442579e-02f, 7.23134130e-02f, 1.06584556e-01f, 6.88350201e-02f, 1.77700579e-01f,
  2.04507574e-01f, -5.25242724e-02f, 1.59737900e-01f, 9.33336169e-02f, 9.61345881e-02f, 6.15280382e-02f, 8.77372269e-03f, 1.96093321e-01f, 1.86043426e-01f, 1.32129058e-01f,
  -7.77599737e-02f, 1.20558739e-01f, 1.87641278e-01f, 1.22890331e-01f, -4.50364165e-02f, 2.24401578e-01f, 7.19787106e-02f, -5.55042848e-02f, -4.30572368e-02f, 9.34013799e-02f,
  7.75581971e-02f, 7.30373487e-02f, 8.67251009e-02f, -2.42490768e-02f, 5.14754280e-02f, 1.15084253e-01f, 1.10088859e-03f, 2.37980634e-01f, 5.25154062e-02f, 7.68567100e-02f,
  -1.69932321e-02f, -5.93890399e-02f, 8.43683332e-02f, 8.09802413e-02f, 1.83280900e-01f, 2.82116324e-01f, -2.17393339e-01f, 8.66415426e-02f, 7.12862536e-02f, 1.49028227e-01f,
  2.08242610e-01f, -1.50403872e-01f, 1.47178024e-01f, 4.07075398e-02f, -4.55183163e-02f, 1.74960986e-01f, -1.47844568e-01f, 1.03037722e-01f, 2.87474155e-01f, -5.91792390e-02f,
  -1.97534636e-03f, -1.65174335e-01f, -3.02510381e-01f, -5.04365787e-02f, 2.57153034e-01f, 1.59460142e-01f, -6.88244849e-02f, 2.36978754e-01f, 2.27610879e-02f, -1.41029358e-01f,
  1.22585066e-01f, -5.19987196e-02f, 7.13947043e-02f, 4.11702842e-02f, 3.92968059e-02f, -1.60133034e-01f, -2.59606272e-01f, -2.67070949e-01f, 1.52350441e-01f, 2.38253117e-01f,
  1.94758266e-01f, 2.26351663e-01f, -1.74277231e-01f, 1.23568065e-02f, 2.13353768e-01f, -2.14008555e-01f, 8.30136314e-02f, -2.35183150e-01f, 9.70923826e-02f, -1.86784610e-01f,
  -1.09765485e-01f, -1.34451181e-01f, -3.63198340e-01f, 1.06079184e-01f, -1.20421045e-01f, -8.54042172e-02f, 2.55451530e-01f, -1.81526363e-01f, 3.30517739e-01f, 6.11226633e-02f,
  -1.50503546e-01f, 2.18173593e-01f, -9.52343792e-02f, 7.12148398e-02f, 1.27413005e-01f, -2.42811486e-01f, -9.05499905e-02f, 1.46024041e-02f, 5.62431403e-02f, -1.92751929e-01f,
  -4.56032790e-02f, 1.65011078e-01f, 6.07225895e-02f, 1.32169932e-01f, 2.58355707e-01f, 1.21161290e-01f, -2.98942029e-02f, -8.51237029e-03f, -2.21927270e-01f, 2.26688340e-01f,
  7.98587799e-02f, -3.01837087e-01f, 2.01707929e-01f, -1.48673551e-02f, 1.03342213e-01f, 1.53125256e-01f, 9.69865918e-02f, 4.90498990e-02f, 1.49159744e-01f, 4.43017483e-02f,
  -2.53171287e-02f, 1.78629577e-01f, -2.41795033e-02f, 4.84253280e-02f, -4.22871187e-02f, 7.99583495e-02f, 1.17618151e-01f, 1.68534517e-01f, -2.00642012e-02f, 8.06984305e-02f,
  7.01814592e-02f, 1.51761219e-01f, 1.22402191e-01f, 1.96038738e-01f, 1.48758978e-01f, 8.93620104e-02f, 6.36932328e-02f, 5.41182756e-02f, 1.33715078e-01f, 7.63876364e-02f,
  -1.52916104e-01f, 9.79622826e-02f, 1.38823926e-01f, 1.01703510e-01f, 5.24756759e-02f, 9.63237286e-02f, 1.50016258e-02f, 1.01898417e-01f, 8.59704837e-02f, 1.26441523e-01f,
  2.57065706e-02f, 6.45670593e-02f, 7.70423114e-02f, -1.36473402e-01f, 1.29568025e-01f, -3.71855609e-02f, 1.28030509e-01f, 2.32483931e-02f, 2.13855982e-01f, 8.26678872e-02f,
  1.49119087e-02f, 1.48657799e-01f, 2.06374028e-03f, 4.02089134e-02f, -2.81475186e-01f, -2.41918564e-01f, -1.10147960e-01f, -3.02649736e-01f, -3.64332318e-01f, -2.27655023e-02f,
  -3.75469178e-01f, -2.60040432e-01f, -4.41627689e-02f, 1.66324988e-01f, -7.66210444e-03f, -6.60988614e-02f, -2.96981812e-01f, 2.61353552e-01f, -1.51146442e-01f, -2.57994443e-01f,
  2.79487800e-02f, 8.24958161e-02f, -4.07728963e-02f, 2.66288698e-01f, 3.20627183e-01f, -2.56123655e-02f, 1.34011626e-01f, 1.33670494e-01f, 4.83793020e-03f, -1.81927353e-01f,
  9.16603729e-02f, -1.05819143e-01f, -1.06231071e-01f, -2.30836812e-02f, -6.00552186e-02f, 3.44388306e-01f, 5.64520583e-02f, -3.82896215e-01f, -6.30857199e-02f, -1.86694428e-01f,
  -1.85434178e-01f, -2.98893183e-01f, -2.62188375e-01f, -2.31730938e-01f, -2.28631228e-01f, -8.59845504e-02f, 1.63229033e-02f, -4.85435314e-02f, 2.15676591e-01f, 2.87017860e-02f,
  -1.92346219e-02f, 2.32457504e-01f, -1.75357029e-01f, 6.99706450e-02f, 1.72430068e-01f, 3.13358575e-01f, -7.02326372e-02f, -2.49118537e-01f, -7.72906244e-02f, -1.94507856e-02f,
  2.14306012e-01f, 2.49833524e-01f, -8.48565996e-03f, 2.28612021e-01f, 1.73309565e-01f, 4.78524715e-02f, -3.06472648e-03f, 1.05106980e-02f, 5.56641556e-02f, -5.69180399e-02f,
  -5.85210994e-02f, 3.32999974e-01f, 5.09549454e-02f, 1.83469892e-01f, 1.74469337e-01f, 3.15636277e-01f, -2.68007189e-01f, 6.84502348e-02f, 2.46442348e-01f, 2.65720576e-01f,
  1.89449698e-01f, 2.84515917e-01f, 1.13109916e-01f, 1.74435779e-01f, 1.95618957e-01f, 1.60584912e-01f, 1.12431593e-01f, 4.81630750e-02f, 9.04036835e-02f, -1.70525368e-02f,
  1.30157426e-01f, 1.77878529e-01f, -4.35443185e-02f, 8.27613324e-02f, 4.85950299e-02f, 1.29970342e-01f, 5.53740114e-02f, 8.24723393e-02f, 1.18365668e-01f, 1.28702477e-01f,
  5.79108931e-02f, 4.73717600e-02f, -2.10019890e-02f, 8.99408087e-02f, 4.55593616e-02f, 9.38038751e-02f, 1.13700509e-01f, 9.16921068e-03f, -5.95361553e-03f, 1.54794171e-01f,
  -8.11961759e-03f, 4.84052002e-02f, 6.89457403e-03f, 4.93750721e-02f, 1.30727157e-01f, 1.03849299e-01f, 2.17824467e-02f, 1.92843586e-01f, 1.01211429e-01f, -2.21009944e-02f,
  1.73215628e-01f, -9.20860320e-02f, -5.77119067e-02f, 1.35481000e-01f, -5.88096268e-02f, 1.43921226e-01f, -1.84874181e-02f, 1.34396151e-01f, 4.33774330e-02f, 1.09370954e-01f,
  8.94042403e-02f, -1.52440116e-01f, 1.34523809e-02f, -2.53380805e-01f, -1.59622446e-01f, 4.32158932e-02f, -1.66898035e-02f, -2.58620176e-03f, -2.28270859e-01f, -6.89646378e-02f,
  1.38742859e-02f, 7.62303993e-02f, 9.05078351e-02f, -9.63279884e-03f, 8.94020945e-02f, 3.60591114e-02f, -9.42157358e-02f, -1.60486549e-01f, 9.79628041e-02f, 1.68954328e-01f,
  -2.59190351e-02f, -1.17851019e-01f, 2.68038541e-01f, -2.30236739e-01f, 1.17451593e-01f, 3.42958033e-01f, 1.65459961e-01f, -7.84351155e-02f, -1.31921992e-01f, 4.42351028e-02f,
  -2.10690722e-01f, 1.35584265e-01f, -1.12226389e-01f, 3.18309397e-01f, 1.80855677e-01f, -4.46202308e-02f, -1.47334635e-01f, -2.89713472e-01f, 3.80398072e-02f, -7.34276548e-02f,
  -2.62224615e-01f, -1.68045565e-01f, -1.70439333e-01f, -1.72098875e-02f, -3.55067849e-01f, -6.24085590e-02f, 9.32795033e-02f, 7.22456723e-02f, 2.94186652e-01f, 8.09925050e-03f,
  -1.97743811e-02f, 1.63991809e-01f, -2.24916153e-02f, -1.90060467e-01f, 1.42312080e-01f, 1.58520937e-01f, 3.33369374e-01f, 1.15686134e-01f, -1.77892342e-01f, -4.51757126e-02f,
  4.07648161e-02f, 2.44945869e-01f, 1.30364686e-01f, -2.14346200e-01f, 1.42944604e-01f, 1.88635588e-01f, -2.54784953e-02f, -8.54625702e-02f, -3.54150757e-02f, 1.74002156e-01f,
  -1.97660569e-02f, -1.71280220e-01f, 2.20709279e-01f, 2.76166946e-01f, -1.04980096e-01f, 5.16267940e-02f, 1.27866209e-01f, -1.45390660e-01f, -3.86269734e-04f, -3.69463712e-02f,
  1.04779623e-01f, -1.15818502e-02f, -8.94975066e-02f, -1.28400952e-01f, 1.23775661e-01f, 2.76213381e-02f, -5.71820177e-02f, 7.84425810e-02f, 8.56143460e-02f, 1.11332610e-01f,
  2.81858295e-01f, 3.19598019e-02f, -1.82958804e-02f, 7.76357651e-02f, 2.52377033e-01f, 9.10696685e-02f, 6.58889562e-02f, 8.55739340e-02f, 1.56346217e-01f, 7.30500370e-02f,
  6.13823943e-02f, 2.35625863e-01f, 1.27729833e-01f, 8.32085833e-02f, -4.38636020e-02f, 2.52871335e-01f, 2.06538215e-01f, 1.60255119e-01f, -6.37755729e-03f, 1.06376037e-02f,
  1.14324419e-02f, 4.31377068e-02f, -9.21017490e-03f, -7.13043730e-04f, 1.68580804e-02f, 1.97741583e-01f, 1.34671628e-01f, 6.20047860e-02f, 7.00901300e-02f, 1.16143413e-01f,
  -8.21468383e-02f, 1.82064012e-01f, -4.90735238e-03f, -2.38822289e-02f, 2.40246266e-01f, 1.34565845e-01f, 9.43687484e-02f, 9.10858959e-02f, 1.99543402e-01f, 2.32366413e-01f,
  -8.48531350e-02f, -3.82595733e-02f, -3.34418088e-01f, 4.17918235e-01f, 2.16955379e-01f, -1.99694067e-01f, 4.78501394e-02f, 8.57326537e-02f, -1.90390900e-01f, 1.99271336e-01f,
  -4.86992076e-02f, 1.99042577e-02f, 6.96395934e-02f, -1.96079835e-01f, -2.98508644e-01f, -1.42245471e-01f, -1.86613232e-01f, 4.23935913e-02f, 1.13655768e-01f, -2.16967631e-02f,
  1.41225830e-01f, 1.98604196e-01f, 2.01770976e-01f, -3.35225090e-02f, -6.71568140e-02f, -2.73539931e-01f, -8.23011994e-02f, -9.80891101e-03f, 1.92379877e-02f, -8.64973515e-02f,
  -1.15815356e-01f, -9.52212587e-02f, 4.35104873e-03f, -1.35743409e-01f, -1.32946759e-01f, 2.56016165e-01f, -1.53627262e-01f, 3.11807990e-02f, 2.94363409e-01f, -4.79176827e-02f,
  1.73353389e-01f, 1.70733351e-02f, 1.98523730e-01f, -3.18078488e-01f, -8.93009976e-02f, -2.40065884e-02f, -3.70896697e-01f, 3.12267267e-03f, -1.26140460e-01f, -2.03900356e-02f,
  1.41074225e-01f, -2.64305353e-01f, 5.78641415e-01f, 1.75051183e-01f, 2.72386163e-01f, 1.85265630e-01f, 1.20254457e-01f, 1.48887739e-01f, 2.10127085e-01f, -2.00297534e-01f,
  3.80375803e-01f, 7.45478645e-02f, 1.54372483e-01f, -3.82571578e-01f, 3.41645569e-01f, -2.80861795e-01f, 2.21279263e-02f, 2.90917773e-02f, 2.35192269e-01f, 1.66015461e-01f,
  -2.44045705e-01f, 1.14090875e-01f, 3.23044807e-02f, 3.28729041e-02f, 5.81680275e-02f, -4.04505730e-01f, 7.32976198e-02f, -6.29510358e-02f, 3.39920372e-02f, 1.30256936e-01f,
  1.18257374e-01f, 1.20049328e-01f, -5.98121993e-03f, 1.10195115e-01f, -7.36097619e-02f, 7.02959746e-02f, 6.23975545e-02f, 7.50715211e-02f, 1.42882735e-01f, 4.92064245e-02f,
  1.23405032e-01f, 1.70143723e-01f, -1.20600373e-01f, 5.12235016e-02f, 1.14323892e-01f, 1.25460058e-01f, 1.54608667e-01f, 2.36973390e-02f, 1.12551473e-01f, 4.07287851e-02f,
  3.84660996e-02f, 1.12562291e-01f, 1.13442041e-01f, 1.98529407e-01f, 4.31950763e-02f, 8.73976648e-02f, -8.00961256e-03f, 1.16475999e-01f, -1.39580341e-02f, 1.53883069e-03f,
  -2.74601881e-03f, 8.06517303e-02f, 1.69357911e-01f, 7.61526600e-02f, 6.27650172e-02f, 2.28376761e-02f, 7.28259459e-02f, 1.36932015e-01f, 7.31159523e-02f, 2.34254431e-02f,
  9.83955115e-02f, 5.30973226e-02f, 1.61213607e-01f, 1.48941904e-01f, 4.68958020e-02f, -2.94331871e-02f, 1.05487138e-01f, -1.16996758e-01f, -1.54421687e-01f, 9.61341783e-02f,
  1.08456286e-02f, -1.89844131e-01f, -7.25234449e-02f, -3.28307897e-02f, -1.22261569e-01f, -5.17489482e-03f, 1.33395255e-01f, 5.73153831e-02f, -1.44872084e-01f, 5.74403852e-02f,
  -2.30417565e-01f, 1.85873970e-01f, -1.56704485e-01f, -1.25809704e-04f, 6.00896552e-02f, 1.84873268e-02f, -4.83951010e-02f, 2.24325433e-01f, -1.08669229e-01f, 4.42782715e-02f,
  -7.41364658e-02f, -3.09478074e-01f, -2.92716980e-01f, -3.86602849e-01f, 1.15702309e-01f, 5.96059039e-02f, 2.13426575e-01f, -1.19001433e-01f, 1.23844095e-01f, -1.52597964e-01f,
  -2.14287236e-01f, -4.49057342e-03f, -7.56622553e-02f, 2.75320321e-01f, 8.10050592e-02f, -1.45289591e-02f, 1.53598145e-01f, 2.01207995e-01f, 1.60586193e-01f, -1.72554299e-01f,
  2.21286923e-01f, -5.44312373e-02f, -1.59242621e-03f, 6.29631132e-02f, -2.95578837e-02f, -1.45955577e-01f, 3.95214818e-02f, -1.75169289e-01f, 1.25821456e-01f, 2.28791758e-01f,
  1.08200952e-01f, -4.04308103e-02f, -1.56222358e-01f, 4.70857881e-03f, 3.48075986e-01f, 2.08021551e-01f, 5.89840300e-02f, -7.45382458e-02f, -5.51804667e-03f, 3.11019123e-01f,
  -3.69918346e-01f, -1.56339422e-01f, -1.50975347e-01f, -3.43768090e-01f, 3.07826102e-01f, -1.08180642e-01f, -6.24116547e-02f, 2.99958557e-01f, -3.10623366e-02f, -3.57490592e-02f,
  2.09713191e-01f, 1.75926417e-01f, -1.74204316e-02f, 2.35827997e-01f, 1.14278365e-02f, 8.65098089e-03f, 1.11394808e-01f, 2.05354318e-01f, 9.08552855e-02f, 6.80906549e-02f,
  1.55963406e-01f, 1.01833932e-01f, -1.39369897e-03f, 1.97940215e-01f, 1.82802990e-01f, 3.70375998e-02f, 2.08540149e-02f, 9.76107940e-02f, -1.66575203e-03f, 9.76348817e-02f,
  7.46813640e-02f, 7.52635449e-02f, 1.73711136e-01f, 2.11265951e-01f, 1.46846816e-01f, 5.04519641e-02f, 6.00023866e-02f, 3.43808159e-02f, 1.14294374e-02f, 9.25265178e-02f,
  1.63488567e-01f, 1.99931368e-01f, 4.96224985e-02f, 6.49667308e-02f, 7.21708909e-02f, -7.95283541e-02f, 8.58142413e-03f, -3.69894318e-02f, 6.07555732e-02f, 1.33215189e-02f,
  1.37104392e-01f, 4.35036570e-02f, -4.10216749e-02f, 1.01950355e-01f, -4.45952006e-02f, 8.31282139e-02f, 2.34693617e-01f, 2.98832711e-02f, -6.33646222e-03f, 1.15886778e-01f,
  1.01401754e-01f, 1.02866255e-01f, 4.16068323e-02f, 2.26597264e-01f, 8.80402327e-03f, 1.08135954e-01f, 1.19525559e-01f, 4.44612987e-02f, -1.50994807e-01f, -1.20820133e-02f,
  2.91291159e-02f, 9.62487608e-02f, -3.33385199e-01f, 1.51023224e-01f, 1.40314577e-02f, 1.26063794e-01f, 3.32428068e-01f, -2.55031168e-01f, 4.26954217e-02f, 2.29006365e-01f,
  -3.37992013e-01f, -2.25264028e-01f, 1.61684707e-01f, -3.50473702e-01f, -2.06637964e-01f, -6.43132180e-02f, 5.47426678e-02f, -2.52232403e-01f, -1.07640311e-01f, 1.21100910e-01f,
  1.08333834e-01f, 3.81135531e-02f, -1.03724590e-02f, -1.51788905e-01f, -9.15987566e-02f, 1.14721827e-01f, 1.77385405e-01f, 8.67312425e-04f, 1.24830097e-01f, -3.29999030e-01f,
  -2.64122456e-01f, 2.13956699e-01f, -1.13689654e-01f, -2.76805937e-01f, -1.09159172e-01f, -6.38200864e-02f, -2.27484033e-01f, 1.42901123e-01f, 1.81341857e-01f, -5.72967380e-02f,
  2.56005287e-01f, 2.48379588e-01f, 3.01956058e-01f, 1.88530415e-01f, -1.51550427e-01f, 2.58268416e-01f, -9.83818024e-02f, 3.29284787e-01f, -7.09085613e-02f, -2.66399831e-01f,
  -4.15243097e-02f, -2.06435487e-01f, -1.49123967e-01f, 1.56559628e-02f, -1.55153796e-01f, 1.12590436e-02f, 2.33669773e-01f, 2.62399882e-01f, 1.50452584e-01f, 3.52628678e-01f,
  3.62721711e-01f, -1.59169197e-01f, 1.87004417e-01f, 4.63091940e-01f, 1.82407200e-02f, 2.22547695e-01f, 3.71310890e-01f, 2.24140480e-01f, 3.92418832e-01f, -1.16074808e-01f,
  1.01796538e-01f, 1.63496926e-01f, 2.09344789e-01f, 3.48382303e-03f, 1.48471490e-01f, 1.33982956e-01f, -4.20032032e-02f, 5.34447059e-02f, 5.08249179e-02f, 1.88307371e-02f,
  -2.14154180e-02f, 1.89493507e-01f, 1.31376147e-01f, -1.60345044e-02f, 2.02217981e-01f, 4.37536389e-02f, 2.03206182e-01f, 2.23011315e-01f, 2.39531815e-01f, 2.68835155e-03f,
  -1.99063420e-02f, 2.22436711e-02f, 1.91144019e-01f, 1.64198458e-01f, 5.12497313e-02f, 2.12324977e-01f, 1.72741618e-02f, 7.39121512e-02f, -3.19047309e-02f, 1.48653954e-01f,
  2.16977552e-01f, 1.18953019e-01f, -6.56038597e-02f, 1.29299372e-01f, 5.13622798e-02f, 2.06997860e-02f, 2.69969553e-02f, -1.17306896e-02f, -3.02026104e-02f, 3.47615480e-02f,
  3.90524976e-02f, 2.92252507e-02f, 1.61412135e-01f, 2.13312507e-01f, -4.40251417e-02f, 1.86289281e-01f, 1.01000838e-01f, 2.04461347e-02f, -4.80879145e-03f, 6.55343831e-02f,
  -2.43591964e-02f, 1.17927402e-01f, 2.58545250e-01f, 1.65262595e-01f, -1.49552912e-01f, -1.10050067e-01f, -2.38252148e-01f, 1.07556276e-01f, 2.37363353e-01f, -1.26462430e-01f,
  -4.24738713e-02f, 1.65235728e-01f, -1.72770739e-01f, -6.89175120e-03f, -3.37123722e-02f, 5.09660020e-02f, 1.20589092e-01f, 8.31927881e-02f, -2.07830220e-01f, -7.21095204e-02f,
  -8.42934102e-02f, 1.69833809e-01f, 6.49210811e-02f, -2.52168346e-02f, 1.37670964e-01f, -4.02986668e-02f, 3.30500230e-02f, -1.30464166e-01f, 1.19181909e-01f, -1.76224887e-01f,
  -8.16664323e-02f, -4.26710844e-02f, 2.22168360e-02f, 6.13712855e-02f, -2.51988888e-01f, -6.23026341e-02f, 5.72396107e-02f, -5.85170053e-02f, -1.26591951e-01f, 7.92293325e-02f,
  -6.81285709e-02f, 5.16310483e-02f, 2.29604080e-01f, -2.58963883e-01f, -3.54118459e-02f, -2.50270605e-01f, -7.69197121e-02f, -6.03174716e-02f, -4.95279729e-02f, 2.79559821e-01f,
  -1.96506888e-01f, -1.35553673e-01f, -1.10463463e-01f, -3.83525677e-02f, 7.86169022e-02f, -2.35781848e-01f, 3.68155718e-01f, 3.28657717e-01f, -3.23980078e-02f, 2.58277655e-01f,
  -1.19936891e-01f, -4.66716923e-02f, 2.68758774e-01f, -1.20628767e-01f, -6.14956729e-02f, 1.38481662e-01f, 5.28698862e-02f, -5.67928813e-02f, -2.45184809e-01f, -2.39068165e-01f,
  1.63445517e-01f, -1.12146161e-01f, 1.47019967e-01f, 4.70974222e-02f, 2.72254664e-02f, 3.22799981e-02f, -1.11374229e-01f, 1.26904607e-01f, 4.17668037e-02f, -3.43338609e-01f,
  5.52838519e-02f, 1.54484957e-01f, 1.24324962e-01f, -1.78703982e-02f, -8.22073687e-03f, 1.71254650e-01f, 1.23856127e-01f, 1.45254195e-01f, 1.60975039e-01f, 4.68034893e-02f,
  -3.83613482e-02f, 5.79150654e-02f, 7.13158548e-02f, 5.64043224e-02f, 4.83335927e-02f, -6.08591363e-02f, 2.63498295e-02f, -1.30455503e-02f, 1.45574529e-02f, 1.02533713e-01f,
  -8.23074207e-02f, -6.72584847e-02f, 4.91836630e-02f, 6.87938556e-02f, -1.18103750e-01f, 1.51327953e-01f, 1.41842395e-01f, 7.82565027e-02f, 8.05737004e-02f, 5.69304712e-02f,
  6.34350628e-02f, 7.24886060e-02f, 2.17143842e-03f, 1.51209980e-02f, 1.90671653e-01f, -3.20275594e-03f, 1.69162512e-01f, 1.89416945e-01f, 1.15466602e-01f, 1.80619642e-01f,
  7.50776827e-02f, 1.14423841e-01f, 2.16047212e-01f, -1.08181544e-01f, 3.13998498e-02f, 6.53036088e-02f, -1.06411166e-02f, -4.90074186e-03f, 2.80568488e-02f, 6.26241136e-03f,
  -1.08536288e-01f, -1.25942200e-01f, 9.63819101e-02f, 2.73199767e-01f, -2.80810669e-02f, -2.23508075e-01f, -5.58077879e-02f, 2.89940894e-01f, 1.18539833e-01f, 1.13251835e-01f,
  -2.10987195e-01f, -1.66300222e-01f, 8.85803550e-02f, -2.21795946e-01f, 1.33499116e-01f, -1.35254517e-01f, 4.08723503e-02f, 5.98999038e-02f, 2.21019998e-01f, -2.72164047e-01f,
  -3.08434874e-01f, -2.56927848e-01f, -1.69649012e-02f, -6.35580048e-02f, 4.90614697e-02f, 1.32506207e-01f, -1.23738319e-01f, -3.18269990e-02f, -5.03921211e-02f, -1.91665232e-01f,
  1.17209777e-02f, 1.41453892e-01f, 2.62812972e-01f, 2.13461012e-01f, -5.07976115e-02f, -4.47852798e-02f, -3.02841961e-01f, 1.75838947e-01f, 4.76224944e-02f, -1.41996160e-01f,
  -1.73820063e-01f, 1.79429039e-01f, -2.03396529e-02f, 2.18417272e-01f, 1.31735325e-01f, -1.07226856e-01f, 4.95051518e-02f, -1.38201639e-01f, 3.79052192e-01f, -2.03405134e-02f,
  -1.08175622e-02f, 1.97807178e-01f, -2.43730485e-01f, 2.10485933e-03f, -1.38935149e-01f, -1.17940083e-01f, 1.96361899e-01f, -1.23879381e-01f, 1.47748455e-01f, 2.76472479e-01f,
  3.15585062e-02f, -1.88401595e-01f, 3.27343434e-01f, -1.36207640e-01f, 1.05051824e-03f, 3.58718872e-01f, 3.04403573e-01f, 3.48270446e-01f, 3.52320336e-02f, 2.36363456e-01f,
  -5.35091162e-02f, -2.40276694e-01f, 3.48780632e-01f, 1.18524857e-01f, 3.17338884e-01f, -4.67720851e-02f, 4.86445166e-02f, -1.65915102e-01f, 2.20971197e-01f, 5.17214462e-02f,
  -4.99733053e-02f, 4.75587584e-02f, 1.72491163e-01f, 6.93781748e-02f, 4.85840552e-02f, 3.80834262e-03f, -2.20778398e-03f, 2.87675001e-02f, 2.93090846e-03f, 5.82164750e-02f,
  -1.58151373e-01f, 1.05320640e-01f, 1.84593409e-01f, 4.96102385e-02f, -2.18361281e-02f, 1.28009394e-01f, -2.78874803e-02f, 1.56558245e-01f, -1.00864917e-02f, 1.72661409e-01f,
  2.02045236e-02f, 1.76560611e-01f, 3.91878635e-02f, 1.53674349e-01f, 5.39705567e-02f, 6.76103756e-02f, -6.73550041e-03f, 1.62882671e-01f, 8.65905955e-02f, 2.01773956e-01f,
  7.10070133e-02f, 1.33355230e-01f, -4.12813667e-03f, 6.62090406e-02f, -1.08790956e-01f, 4.06280831e-02f, 6.33718893e-02f, -1.61760643e-01f, 1.55915976e-01f, -9.43769589e-02f,
  -5.40897660e-02f, 1.60117283e-01f, 5.77430166e-02f, -4.62769531e-03f, 1.19467631e-01f, 8.24180245e-02f, 1.03649266e-01f, 9.11108255e-02f, -5.07284924e-02f, 3.72899137e-02f,
  -1.34461120e-01f, -2.39678428e-01f, 6.25204295e-02f, 9.69073027e-02f, -5.76318577e-02f, -2.93928742e-01f, 6.68536797e-02f, 4.01834249e-02f, 6.40916750e-02f, 9.03387889e-02f,
  -1.74697161e-01f, 2.15911016e-01f, 1.73302814e-02f, -1.57508880e-01f, 9.58558470e-02f, 5.33512644e-02f, -1.43313304e-01f, 3.50230753e-01f, 2.48123899e-01f, 1.93643585e-01f,
  2.13226333e-01f, -1.40323071e-02f, 2.51382083e-01f, 1.64370596e-01f, -1.73335657e-01f, 4.94448356e-02f, -1.03930578e-01f, 2.27478936e-01f, -1.00960083e-01f, -7.18415603e-02f,
  -2.52560407e-01f, -8.68560076e-02f, -5.07277697e-02f, 2.24676758e-01f, 1.81150854e-01f, -3.43274504e-01f, -7.23787025e-02f, 3.76111865e-02f, 1.47987247e-01f, -1.09721631e-01f,
  1.57444298e-01f, -1.53275356e-01f, -3.33378851e-01f, 4.21556048e-02f, -9.78554115e-02f, -1.90534920e-01f, -2.14604333e-01f, 8.81089419e-02f, 1.97101347e-02f, -1.72667161e-01f,
  2.12794945e-01f, -4.60916013e-02f, 3.82817030e-01f, 3.57726395e-01f, 1.22816615e-01f, 4.19720471e-01f, -7.79772401e-02f, 4.59063202e-02f, 1.31787971e-01f, 2.95673460e-01f,
  -4.51547466e-02f, 4.69873287e-02f, 1.32277710e-02f, -1.04823060e-01f, -8.51271898e-02f, -1.10632598e-01f, -5.61191253e-02f, -1.87942520e-01f, 6.46259412e-02f, -2.70865709e-02f,
  -3.01098078e-01f, 1.81935310e-01f, -2.99941331e-01f, 2.40035102e-01f, 1.17028601e-01f, 1.70302868e-01f, 1.56070009e-01f, 8.78129154e-02f, 2.42156878e-01f, 5.36087230e-02f,
  8.50518197e-02f, 5.08287288e-02f, 1.73778519e-01f, 6.50716424e-02f, -2.53880080e-02f, 1.53135091e-01f, 4.73855287e-02f, 2.48910394e-02f, 7.39189833e-02f, 1.62766248e-01f,
  2.06959248e-01f, 1.45325005e-01f, 1.79497406e-01f, 5.90759143e-02f, 1.17371432e-01f, 8.09817687e-02f, 1.28197491e-01f, 1.02783479e-01f, 1.39131531e-01f, 1.41974285e-01f,
  1.11000605e-01f, 1.90420270e-01f, 3.06295846e-02f, 3.41698118e-02f, 1.33895092e-02f, 1.22845419e-01f, 1.67109340e-01f, 9.38037485e-02f, 2.41180528e-02f, 1.85552418e-01f,
  1.05299212e-01f, 9.24901813e-02f, 1.95537508e-01f, 1.12995721e-01f, 1.36486128e-01f, 1.72590345e-01f, 9.05563086e-02f, 1.19442493e-01f, 2.13234723e-01f, 5.12562739e-03f,
  2.91327685e-01f, 8.11671987e-02f, 1.25438824e-01f, 2.11262062e-01f, 1.83579966e-01f, 1.07008234e-01f, -6.07240619e-03f, -5.11817783e-02f, 1.74756959e-01f, 3.48125352e-03f,
  -1.30709618e-01f, -2.06916675e-01f, -1.91761538e-01f, 9.28861722e-02f, 3.36874872e-02f, -1.87405422e-01f, -2.45233417e-01f, -1.84923470e-01f, -7.77423754e-02f, -3.02739233e-01f,
  5.18543608e-02f, 3.35503072e-01f, -2.68239733e-02f, -2.14498624e-01f, -8.15794989e-02f, -6.24923185e-02f, -2.82890201e-02f, -2.51607269e-01f, -1.85964387e-02f, 2.07717389e-01f,
  9.98394340e-02f, 1.18731566e-01f, 1.26708120e-01f, -1.21045016e-01f, -8.26845691e-02f, -2.11711496e-01f, 5.26798256e-02f, 2.41717488e-01f, -1.10418111e-01f, 2.29576558e-01f,
  -1.05862722e-01f, -1.63214236e-01f, -1.92665666e-01f, -3.54848057e-02f, 9.91602093e-02f, 1.44958660e-01f, -6.71284869e-02f, -2.85453588e-01f, -1.99486449e-01f, 7.46522024e-02f,
  -1.35508686e-01f, 1.22894026e-01f, 2.96644837e-01f, -1.59192204e-01f, -2.09715992e-01f, -3.93256322e-02f, -2.65236884e-01f, 1.64683372e-01f, 1.17251426e-01f, -6.50158599e-02f,
  -3.50567773e-02f, 7.14225918e-02f, -1.51411325e-01f, 2.37811357e-01f, 2.35825315e-01f, 2.30127171e-01f, 1.64866567e-01f, -3.79304171e-01f, 1.44591555e-01f, -5.76949269e-02f,
  1.77453086e-01f, 6.93132952e-02f, -2.73236692e-01f, 7.10804835e-02f, -1.84311405e-01f, 2.96546668e-01f, 6.35023713e-02f, 1.96113642e-02f, 2.63660192e-01f, 1.33373380e-01f,
  -1.68321863e-01f, 1.80166110e-01f, 5.93611188e-02f, -3.18845749e-01f, 4.62016761e-02f, 7.87175447e-03f, 3.66512723e-02f, 1.39770418e-01f, 2.44007379e-01f, 2.24168599e-01f,
  8.58196914e-02f, 2.09920421e-01f, 2.01917365e-01f, 1.20888434e-01f, 1.84986964e-01f, 1.62948936e-01f, 1.61922693e-01f, 8.61369967e-02f, 1.26989350e-01f, 1.15559734e-01f,
  -9.30822268e-02f, 4.41841967e-02f, 1.73983693e-01f, 5.23131825e-02f, 1.28123030e-01f, 8.40905458e-02f, 4.51679640e-02f, -1.71182305e-02f, 2.11175054e-01f, 6.05686530e-02f,
  1.03417411e-01f, 1.31677821e-01f, 2.96098173e-01f, 1.97797745e-01f, 5.69723472e-02f, 1.37672007e-01f, 2.10716113e-01f, 1.65933281e-01f, 5.96753024e-02f, 3.69632766e-02f,
  1.25564978e-01f, 6.53898045e-02f, 2.33528137e-01f, 9.57721025e-02f, 1.74613431e-01f, 6.48261160e-02f, -6.81374371e-02f, 1.58467263e-01f, 2.16083899e-02f, 2.23615348e-01f,
  9.63008627e-02f, 1.35257870e-01f, 1.01597801e-01f, 1.04211152e-01f, 2.02293560e-01f, -2.12226480e-01f, -1.31287292e-01f, 4.23028879e-02f, 1.14058807e-01f, -9.36073810e-02f,
  2.65999045e-02f, 1.20415553e-01f, -2.14208603e-01f, 1.31989837e-01f, 1.73046701e-02f, 5.82517758e-02f, 4.81698737e-02f, 2.11452812e-01f, -8.79773200e-02f, -1.37592927e-01f,
  7.20113888e-02f, 4.17440273e-02f, 1.64797410e-01f, 2.09612682e-01f, 3.91058326e-02f, 1.95711181e-01f, -2.13262513e-02f, -2.12094650e-01f, -5.36736771e-02f, -2.09358528e-01f,
  -6.62877411e-02f, -1.13221399e-01f, 8.47826600e-02f, 2.76472002e-01f, 1.42560467e-01f, -2.21380785e-01f, 5.21413162e-02f, -1.66791365e-01f, 2.60866992e-02f, 6.75788298e-02f,
  -7.51370862e-02f, -4.55038697e-02f, -9.99914706e-02f, -1.28991857e-01f, -7.84942955e-02f, 1.26589432e-01f, 6.77659810e-02f, -3.47049892e-01f, -1.44170457e-03f, -1.64020345e-01f,
  -1.74606279e-01f, 1.06814362e-01f, 2.08040968e-01f, 2.08541397e-02f, 2.70486921e-01f, -3.54530424e-01f, 2.80235857e-01f, 2.45104089e-01f, 1.47185937e-01f, 1.51762247e-01f,
  1.71812564e-01f, 1.22354038e-01f, 3.24338838e-03f, -1.30975932e-01f, 2.60043830e-01f, 3.52056146e-01f, -2.11610511e-01f, 2.37478763e-01f, -2.27013692e-01f, 1.38357416e-01f,
  -5.29208977e-04f, 1.75708443e-01f, 2.91352928e-01f, -2.58840382e-01f, 3.44737507e-02f, 1.12951817e-02f, 2.09303349e-01f, -5.02588367e-03f, 1.58959672e-01f, 1.88435614e-01f,
  1.50711924e-01f, 3.40927750e-01f, -1.31377757e-01f, 7.42351413e-02f, 1.09131798e-01f, -2.88574547e-02f, 2.99290288e-02f, -3.12446319e-02f, 2.79329112e-03f, 7.47627541e-02f,
  2.08377074e-02f, 2.10325629e-03f, -7.32070655e-02f, -3.45006697e-02f, 1.63951516e-01f, -7.18734646e-03f, -1.93992276e-02f, 3.70349474e-02f, 1.62734196e-01f, 1.02732457e-01f,
  8.78849030e-02f, 3.27708647e-02f, -1.07888974e-01f, 3.05099096e-02f, 4.16897871e-02f, 8.47000405e-02f, 1.15246356e-01f, 1.53520569e-01f, -1.41367530e-02f, 1.23435996e-01f,
  2.20220536e-02f, 3.93907912e-03f, 7.22842142e-02f, -7.03653470e-02f, 6.60358071e-02f, -7.36906081e-02f, 5.14056310e-02f, -6.44854009e-02f, 2.55752578e-02f, 4.53391336e-02f,
  7.64879435e-02f, 8.54948685e-02f, 1.10346414e-01f, 1.36772171e-01f, -1.58807007e-03f, 6.09123195e-03f, -9.47384089e-02f, 1.09643579e-01f, 5.61980382e-02f, 1.16656251e-01f,
  8.25591460e-02f, 4.69326861e-02f, -3.81990187e-02f, 1.98420156e-02f, -8.74739327e-03f, 1.62248552e-01f, -1.18269414e-01f, 1.35734168e-04f, 1.96136728e-01f, 1.00884497e-01f,
  1.89299494e-01f, 1.33210868e-01f, -3.13886911e-01f, -6.97641373e-02f, -1.96183413e-01f, 5.91689087e-02f, 1.53394388e-02f, -1.61987916e-01f, 4.35720980e-02f, 2.03480616e-01f,
  3.75972353e-02f, -1.92649215e-02f, -7.66308680e-02f, -6.71391934e-02f, -1.21427655e-01f, 2.41352633e-01f, 5.10936975e-02f, -3.49663794e-02f, -2.70330578e-01f, -1.44878268e-01f,
  5.22361659e-02f, 3.13267894e-02f, 1.54496729e-01f, -1.40952036e-01f, 2.04165354e-01f, 3.29804048e-02f, -2.64013380e-01f, 1.78989694e-02f, -1.67980850e-01f, 1.11699000e-01f,
  6.31814823e-02f, 4.18657288e-02f, 2.68548787e-01f, 3.07428658e-01f, 3.10146540e-01f, 2.73471415e-01f, 2.27059379e-01f, -2.11386368e-01f, 2.53415760e-02f, -2.58054376e-01f,
  -5.57261147e-02f, -1.41390309e-01f, 2.04955805e-02f, -1.17646661e-02f, -7.97995999e-02f, -5.12044393e-02f, 2.44817361e-01f, 1.96723983e-01f, 3.74915063e-01f, 6.45210519e-02f,
  3.22396725e-01f, 2.54865348e-01f, 2.06010073e-01f, -1.91836745e-01f, 4.89162236e-01f, -4.91957888e-02f, -9.21748579e-03f, -2.25252837e-01f, 3.73318195e-01f, 3.21507484e-01f,
  1.34682655e-01f, -1.60856143e-01f, 3.95367332e-02f, -1.28230482e-01f, -1.20187990e-01f, -5.53745255e-02f, 2.80794889e-01f, 4.19579484e-02f, 6.01682328e-02f, -2.50711650e-01f,
  3.86122288e-03f, 9.16038975e-02f, 7.52561959e-03f, -4.29316871e-02f, 4.90520336e-02f, 1.59984380e-01f, -5.59574664e-02f, 2.10344382e-02f, 1.02977619e-01f, -2.71572396e-02f,
  2.21135560e-02f, -1.23714536e-01f, 7.27419928e-02f, -9.31537300e-02f, 3.39176022e-02f, 4.19824235e-02f, 1.52037263e-01f, -3.30741033e-02f, -4.11043759e-04f, 3.99891473e-02f,
  -3.45946513e-02f, -2.23700050e-03f, -4.37217876e-02f, 7.31860995e-02f, -3.60821448e-02f, -6.15468472e-02f, 1.10298522e-01f, -1.54992402e-01f, -5.18602729e-02f, -6.79202517e-03f,
  -9.36678648e-02f, -3.30674239e-02f, 5.28748184e-02f, 6.85311779e-02f, -5.58968671e-02f, -1.47291664e-02f, -2.91724820e-02f, -1.79832112e-02f, -1.56440604e-02f, 9.14239883e-02f,
  8.80366713e-02f, 1.50137275e-01f, 4.84764427e-02f, -3.30190733e-02f, 5.58462217e-02f, 7.32161198e-03f, 1.73320761e-03f, -6.35245815e-02f, 1.12677187e-01f, 2.86565050e-02f,
  4.84715849e-02f, -1.15518786e-01f, -7.11325975e-03f, 7.41033927e-02f, 9.06805918e-02f, -8.43420476e-02f, -8.39453191e-02f, 1.24855444e-01f, -1.02303334e-01f, 1.90630294e-02f,
  4.55825292e-02f, -1.53323740e-01f, 1.14914114e-02f, -1.50077373e-01f, 4.86066714e-02f, 8.50659907e-02f, 1.02272555e-01f, 4.07084217e-03f, 1.79140955e-01f, -5.79052754e-02f,
  -1.02511846e-01f, -9.68173593e-02f, -1.82005540e-02f, 1.56438634e-01f, -8.67084786e-02f, 4.53935750e-02f, 2.20273837e-01f, -4.71841311e-03f, 8.97349715e-02f, 1.23876822e-03f,
  1.45584978e-02f, 1.51962414e-01f, -1.59105018e-01f, 5.56724668e-02f, 9.41382647e-02f, -1.10822216e-01f, -4.29099612e-02f, -1.27580956e-01f, -7.35026002e-02f, 7.38812552e-04f,
  -7.60798380e-02f, -1.42270952e-01f, -1.72058642e-01f, 8.44667945e-03f, -9.04194117e-02f, 8.08036178e-02f, 1.73740685e-01f, 9.18306336e-02f, 1.78425416e-01f, -1.07461393e-01f,
  1.20587349e-01f, 6.81538582e-02f, 6.58564717e-02f, -8.27986449e-02f, -1.59098674e-02f, 5.96096516e-02f, -8.20326433e-02f, -9.25507955e-03f, -1.18535757e-01f, -6.47728518e-02f,
  1.57208189e-01f, -1.40725896e-01f, -1.43661454e-01f, -1.55601855e-02f, -8.85916054e-02f, 1.97197661e-01f, -1.74914613e-01f, 2.73830712e-01f, -1.45727083e-01f, -1.90669686e-01f,
  -7.21652284e-02f, -9.61005166e-02f, 2.77631849e-01f, -9.98322889e-02f, -5.27453329e-03f, -6.50017634e-02f, -1.04506701e-01f, -2.77216494e-01f, -2.72617303e-03f, 1.02465272e-01f,
  1.95945859e-01f, -5.58240823e-02f, -1.68727990e-02f, 1.61678568e-01f, -5.78235425e-02f, 3.87117453e-02f, 1.70397446e-01f, 4.31427844e-02f, 6.02151640e-02f, -1.19293079e-01f,
  1.24061078e-01f, -3.08183525e-02f, 1.19926818e-01f, -2.62254197e-03f, 3.15369964e-01f, -1.10210280e-03f, 2.73157638e-02f, -5.02057858e-02f, -7.38536716e-02f, 2.00428907e-02f,
  9.76196975e-02f, 1.51725635e-01f, 7.77914897e-02f, 3.53517681e-02f, -5.92956357e-02f, -6.53752536e-02f, -2.77409386e-02f, 1.35122135e-01f, 7.24337529e-03f, -6.03352822e-02f,
  3.93803865e-02f, -4.00544470e-03f, 1.45032018e-01f, 1.87870692e-02f, 1.22514807e-01f, 7.00109527e-02f, 1.68398879e-02f, 1.68550134e-01f, 1.42393246e-01f, 3.17388296e-01f,
  3.77343819e-02f, -1.47718176e-01f, 2.03589559e-01f, 1.63201854e-01f, -2.78842151e-02f, 1.43006174e-02f, 1.30678713e-01f, 4.45250086e-02f, 2.72975452e-02f, 4.85350676e-02f,
  5.16126454e-02f, 8.69882256e-02f, -1.03525370e-01f, -1.58002719e-01f, 5.00754677e-02f, 3.42955440e-01f, 1.15258016e-01f, 1.15477152e-01f, -2.79336393e-01f, -3.21867675e-01f,
  -2.32889175e-01f, -5.38468510e-02f, 2.42964640e-01f, 2.59649046e-02f, 2.05118984e-01f, 1.90618560e-01f, 1.85408428e-01f, -2.19194510e-04f, -1.28770247e-01f, -1.27786905e-01f,
  -6.07720576e-02f, 1.34419307e-01f, -2.72419918e-02f, 5.89838699e-02f, -1.84083909e-01f, -1.11055911e-01f, 1.45315334e-01f, -2.02596128e-01f, 3.38559926e-01f, 2.90511906e-01f,
  5.56263961e-02f, 1.97482198e-01f, -1.92895055e-01f, -2.60117315e-02f, -1.85925484e-01f, -4.49840911e-02f, 1.73490699e-02f, 7.03653172e-02f, 1.28181472e-01f, 3.27140912e-02f,
  3.57664675e-02f, 1.29144222e-01f, 1.51928976e-01f, 4.87828106e-02f, 6.03349321e-02f, 1.46695256e-01f, 5.90007603e-02f, -2.37702489e-01f, -6.51736045e-03f, -8.61945152e-02f,
  -1.43100962e-01f, 2.16166135e-02f, 2.44252589e-02f, 2.44592130e-01f, -3.33160721e-02f, 1.86906531e-01f, 1.93319216e-01f, 2.56708741e-01f, 3.42937589e-01f, -1.28876761e-01f,
  1.12564676e-01f, -1.28690526e-01f, -4.27513290e-03f, 1.30928308e-01f, 1.60310008e-02f, 2.27866948e-01f, -1.37574300e-01f, -3.94706607e-01f, -3.05929836e-02f, -2.61135519e-01f,
  3.75562012e-01f, -2.77616858e-01f, 8.96465480e-02f, 1.96417212e-01f, -3.14643607e-02f, -2.86691159e-01f, 6.76815510e-02f, 4.14113812e-02f, 5.05855158e-02f, 1.54585317e-01f,
  7.81186298e-02f, 1.14540353e-01f, 1.68488741e-01f, 6.78978190e-02f, 8.86365622e-02f, 2.94256900e-02f, 8.20076987e-02f, 1.93097800e-01f, -1.22472763e-01f, 2.32749626e-01f,
  -5.14954701e-02f, 1.56398285e-02f, 2.11038701e-02f, -2.60685608e-02f, 2.47688610e-02f, 5.05892932e-02f, 3.65049765e-02f, 2.46345196e-02f, 4.99879420e-02f, -2.51964945e-02f,
  3.70877199e-02f, -4.28648666e-02f, 1.22933976e-01f, 2.09729141e-03f, 5.14298072e-03f, 1.32389784e-01f, -2.29870528e-02f, 2.93238573e-02f, 8.90347287e-02f, 1.28435269e-01f,
  3.04301661e-02f, 1.31843209e-01f, 1.70853417e-02f, 2.81818788e-02f, 3.29811238e-02f, -4.60558338e-03f, 5.65353967e-02f, -1.62449732e-01f, 2.24214405e-01f, -6.44930750e-02f,
  -4.77070138e-02f, 3.83478999e-02f, 1.49146030e-02f, 6.58199266e-02f, 1.26401363e-02f, 1.09857947e-01f, -3.45845036e-02f, -9.06331539e-02f, 2.42710531e-01f, 2.95201614e-02f,
  2.54391581e-01f, 2.87279170e-02f, 1.67417820e-04f, -1.21545397e-01f, 1.27214357e-01f, -9.37604811e-03f, 1.03467174e-01f, -3.90852429e-03f, 1.63524412e-02f, -4.06704284e-02f,
  1.41555533e-01f, 2.74025649e-03f, 9.98036042e-02f, 4.31872485e-03f, -3.28803924e-03f, -2.60906011e-01f, -2.27032341e-02f, -1.86636904e-03f, 1.47805747e-03f, -4.10402231e-02f,
  -1.51130542e-01f, 3.74106944e-01f, 3.26934457e-01f, 3.97045165e-01f, -1.15616292e-01f, -1.12024702e-01f, -2.18114287e-01f, 3.16314623e-02f, -1.58135995e-01f, 2.07185224e-02f,
  3.07053000e-01f, 2.39374772e-01f, 2.73911178e-01f, -3.68557833e-02f, 1.04568981e-01f, 1.54580593e-01f, -1.94838524e-01f, -1.25584111e-01f, -1.78235158e-01f, 1.25179678e-01f,
  -2.03448564e-01f, 2.89545566e-01f, -1.32981420e-01f, -1.26712155e-02f, 1.08316846e-01f, 9.32560116e-02f, 3.12602855e-02f, 2.14244723e-01f, -2.45288745e-01f, -1.15747802e-01f,
  -8.02635252e-02f, -1.78715035e-01f, -1.08380795e-01f, -1.68098330e-01f, -1.96911201e-01f, -1.18968740e-01f, -2.61879832e-01f, 2.37566426e-01f, -1.45571902e-01f, -1.53386876e-01f,
  3.96118551e-01f, 3.77671331e-01f, -1.27553761e-01f, 3.26621443e-01f, -1.51414156e-01f, 3.11426520e-01f, 3.08681220e-01f, -1.14860684e-01f, 2.47632787e-01f, 1.89778879e-01f,
  -3.08513804e-03f, 2.72330809e-02f, 1.24686040e-01f, 4.10749996e-03f, 1.28450677e-01f, 6.33751601e-02f, 4.17256244e-02f, 6.27854764e-02f, 1.44508660e-01f, 8.56996849e-02f,
  2.75219291e-01f, 3.80656868e-03f, 2.61194199e-01f, 4.47182655e-02f, 1.91784441e-01f, 2.02561527e-01f, 7.70770982e-02f, 1.10698909e-01f, 1.77545071e-01f, 6.51490614e-02f,
  6.67544231e-02f, 1.49324909e-01f, 1.65162325e-01f, -2.58466508e-02f, -4.71122041e-02f, 1.54210895e-01f, 1.30038802e-02f, 1.22501440e-02f, 2.01510295e-01f, 3.13865729e-02f,
  -1.91204622e-03f, 8.65098387e-02f, 7.40319267e-02f, 2.10877568e-01f, 2.10188076e-01f, 1.08282648e-01f, 8.67690146e-02f, 2.33489171e-01f, -3.19433473e-02f, 8.94392207e-02f,
  5.35269976e-02f, -1.36234434e-02f, 7.87112042e-02f, 2.17787609e-01f, 1.55864120e-01f, 2.18262710e-02f, 1.95881262e-01f, 6.06121160e-02f, 1.50156105e-02f, 1.15123004e-01f,
  1.22083902e-01f, 1.84978433e-02f, 4.64178249e-02f, 6.18897453e-02f, 5.00603653e-02f, 1.30092531e-01f, 4.11282986e-01f, 1.81272507e-01f, 2.46927440e-01f, 3.51328820e-01f,
  3.47155809e-01f, -1.53172091e-01f, 5.91856658e-01f, -1.00547425e-01f, 1.60267010e-01f, -1.56432241e-01f, -1.19646536e-02f, 6.01806231e-02f, 1.50393561e-01f, 1.07044717e-02f,
  4.52763259e-01f, 1.99244365e-01f, -2.37156749e-01f, -1.77063659e-01f, 2.79536664e-01f, -4.51004654e-02f, -3.89464021e-01f, 3.68693560e-01f, -1.01090096e-01f, -5.89617062e-03f,
  1.94211572e-01f, 3.76373321e-01f, -2.01986089e-01f, 1.80416778e-01f, -2.37959847e-02f, 1.40938431e-01f, -1.23264104e-01f, -2.07478777e-01f, 1.65223256e-01f, 4.80218589e-01f,
  4.93194848e-01f, -2.24891558e-01f, 2.21522242e-01f, 4.37302649e-01f, 1.35771215e-01f, 1.16516367e-01f, -2.06416268e-02f, 2.43414909e-01f, -3.87383342e-01f, 3.40111405e-01f,
  -2.82711595e-01f, -1.70958117e-01f, -2.43972227e-01f, -3.11585784e-01f, -6.96214214e-02f, 1.87140077e-01f, -2.21053004e-01f, -2.65835583e-01f, -1.64443418e-01f, 2.05904990e-01f,
  1.69050172e-01f, 6.76068291e-02f, 3.00689731e-02f, -9.34470668e-02f, -2.12972816e-02f, 3.93983275e-02f, -2.58914959e-02f, -4.90208603e-02f, 5.76277196e-01f, 1.64424032e-01f,
  -1.12419821e-01f, 3.80755007e-01f, -2.90065527e-01f, 3.84952128e-01f, 2.79666752e-01f, 5.63986525e-02f, -1.43023014e-01f, -3.36107284e-01f, -5.34177162e-02f, -6.31952062e-02f,
  -2.34627292e-01f, 5.65271750e-02f, 1.17570527e-01f, -9.01335627e-02f, 1.90887019e-01f, 1.93334594e-01f, 1.64952427e-02f, 1.79578010e-02f, 4.77591567e-02f, -5.12780845e-02f,
  8.89828876e-02f, -9.84066352e-03f, 1.28918350e-01f, 1.38244435e-01f, 1.13772146e-01f, 9.11939517e-02f, 8.37327987e-02f, 1.41363025e-01f, 5.74627072e-02f, 2.72856541e-02f,
  7.39096180e-02f, 8.75583589e-02f, 1.13387831e-01f, 1.02837570e-01f, 2.40582526e-02f, 9.90163460e-02f, 1.79151431e-01f, 1.35888830e-01f, 2.20720656e-02f, 1.13419861e-01f,
  4.44518104e-02f, 1.34757459e-01f, 1.13040641e-01f, 1.81506678e-01f, 1.46953166e-01f, 1.76713452e-01f, -5.99318705e-02f, 1.42318867e-02f, 9.55087785e-03f, 8.87200935e-04f,
  -3.74585837e-02f, -1.16433986e-02f, 1.09407730e-01f, 2.24636421e-02f, -1.05698816e-01f, 1.03756064e-03f, 5.52701876e-02f, 1.30852479e-02f, 1.42822295e-01f, 2.33918771e-01f,
  1.02156602e-01f, 2.10170165e-01f, 1.16109520e-01f, 1.05343632e-01f, -9.43713412e-02f, -1.54647738e-01f, -9.99729261e-02f, 2.39041179e-01f, -9.77395177e-02f, -2.10293904e-01f,
  -1.98302269e-01f, -1.99874844e-02f, 1.79396555e-01f, -3.55235860e-02f, 1.67925239e-01f, 1.08175285e-01f, -1.82283759e-01f, 2.00025037e-01f, 7.52251819e-02f, -1.75855353e-01f,
  8.66015069e-03f, 2.02859029e-01f, 6.13179952e-02f, 3.66434269e-02f, 1.70076534e-01f, -6.74803881e-03f, 5.30234501e-02f, 7.30458573e-02f, 1.75485283e-01f, 9.98699442e-02f,
  -7.33386576e-02f, 5.78728355e-02f, -1.82644084e-01f, 6.85174838e-02f, -1.91608652e-01f, -1.01686090e-01f, 2.05408320e-01f, -2.31492102e-01f, 7.81515911e-02f, -2.32355297e-01f,
  -9.53681320e-02f, -1.19639877e-02f, -1.04248434e-01f, -1.53723672e-01f, -3.40048969e-01f, -2.30509117e-01f, -1.47057965e-01f, 9.26350504e-02f, 1.29350901e-01f, 2.18024433e-01f,
  -1.39003977e-01f, 4.09523658e-02f, -1.35862127e-01f, -1.19707830e-01f, 2.98971891e-01f, 2.56778985e-01f, -7.20808357e-02f, 1.47789970e-01f, 1.68835814e-03f, 7.04274103e-02f,
  -2.86058187e-01f, -2.24640682e-01f, -6.20533340e-02f, 1.91748470e-01f, -2.05772012e-01f, 1.21485949e-01f, 4.34440732e-01f, 1.62997454e-01f, -1.45742729e-01f, -1.72250479e-01f,
  -2.45002851e-01f, 2.12732792e-01f, 2.91345101e-02f, 2.54622251e-01f, 1.73753887e-01f, 3.18235122e-02f, -2.21324787e-01f, -2.23487467e-02f, -7.53508508e-02f, 2.37265423e-01f,
  3.23596187e-02f, 8.88400152e-02f, 2.47873552e-02f, 1.41683951e-01f, 9.44470465e-02f, 1.82642952e-01f, 2.82604583e-02f, 1.61939651e-01f, 1.02761470e-01f, 4.97693429e-03f,
  7.98942745e-02f, 1.58849925e-01f, -1.74520875e-03f, 1.05844684e-01f, 2.54577398e-01f, 1.79742306e-01f, 1.62574753e-01f, 4.54806052e-02f, 6.02571703e-02f, 2.05536306e-01f,
  6.52906746e-02f, 1.47296011e-01f, 6.39903173e-02f, 9.30038616e-02f, -1.21985341e-03f, 9.52714086e-02f, 2.00236440e-01f, 1.16811328e-01f, 7.71634057e-02f, 4.61971760e-02f,
  -3.68392840e-02f, 5.63766994e-02f, 5.29169179e-02f, 7.07545429e-02f, 2.03488730e-02f, 1.07351258e-01f, -6.03109226e-03f, 1.96516961e-01f, 1.58194408e-01f, 8.50249454e-02f,
  5.50121441e-02f, 5.27101383e-02f, 1.01057947e-01f, 3.46303396e-02f, 2.27882192e-02f, 1.54658690e-01f, 1.10614516e-01f, 5.72032034e-02f, 9.11999792e-02f, 1.66898951e-01f,
  8.48518219e-03f, -6.63909167e-02f, -8.89007822e-02f, -6.62496909e-02f, 1.18692711e-01f, 6.46361802e-03f, 2.00966761e-01f, -4.85238098e-02f, -1.63288638e-01f, 3.08973759e-01f,
  6.65424541e-02f, -3.58207375e-02f, -5.03369831e-02f, 2.70018578e-01f, 3.09254713e-02f, -1.17091678e-01f, -1.47499397e-01f, 2.57261902e-01f, 2.63946056e-01f, 2.18610629e-01f,
  -1.17902867e-01f, -1.03566259e-01f, 1.50031760e-01f, -3.41741949e-01f, -9.62100103e-02f, 9.26373079e-02f, -1.36670560e-01f, 1.61237419e-02f, 1.70803443e-02f, 2.27445245e-01f,
  7.88001120e-02f, -1.26611501e-01f, 2.76351385e-02f, -1.33961469e-01f, -8.33524168e-02f, 4.27859761e-02f, -2.49136146e-02f, -1.35572627e-01f, 4.77711484e-02f, -1.36621431e-01f,
  2.54920542e-01f, -1.22502759e-01f, 1.64497197e-01f, 2.46612597e-02f, -4.84031178e-02f, -1.52276859e-01f, -1.78187579e-01f, 1.73743919e-01f, 2.75274307e-01f, -1.49555653e-01f,
  3.20838302e-01f, -2.17243880e-01f, -8.36796388e-02f, 1.93641782e-01f, 4.70769227e-01f, 3.37932587e-01f, 1.71832934e-01f, 3.84960204e-01f, 6.16444880e-03f, -1.01843633e-01f,
  2.25708008e-01f, 3.55376959e-01f, -1.41144261e-01f, 1.69956267e-01f, -2.49665836e-03f, 1.35157049e-01f, -6.16957769e-02f, -1.99033171e-01f, 2.33279482e-01f, -3.47527176e-01f,
  -1.93673760e-01f, -4.87464555e-02f, 1.53978229e-01f, -3.28263678e-02f, 1.11257680e-01f, 2.81095237e-01f, 2.87463088e-02f, 3.45758945e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.08180321e-03f, 1.81597605e-01f, 3.96520458e-02f, 8.38310644e-02f, 1.29493877e-01f, 5.15140034e-02f, 2.03402013e-01f, 2.86603030e-02f, -9.47980024e-03f, 6.94167316e-02f,
  1.58094093e-01f, 3.56871001e-02f, 8.46170560e-02f, 6.44130036e-02f, 8.33832100e-02f, 1.36080295e-01f, 2.58561634e-02f, 1.26211807e-01f, 4.85364981e-02f, 4.89034317e-02f,
  -7.06966445e-02f, -5.79726091e-03f, 1.69609234e-01f, 1.35879219e-01f, 6.80137426e-02f, 1.60034537e-01f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -5.31698763e-02f, 8.67963359e-02f, 1.27424687e-01f, -2.52187531e-02f, 8.64923969e-02f, -4.08243835e-02f, 3.40791009e-02f, 2.41915826e-02f, 2.23687403e-02f, 3.51704881e-02f,
  -8.76573175e-02f, -1.49586976e-01f, 1.10632062e-01f, 7.98558891e-02f, 1.42186144e-02f, 2.54166331e-02f, 9.77402627e-02f, 1.49581611e-01f, -2.64245849e-02f, -9.42905769e-02f,
  -2.73865648e-02f, 1.43285161e-02f, -1.67050481e-01f, -6.73691034e-02f, -1.58738643e-02f, 3.51793282e-02f, -1.75598100e-01f, -2.92263906e-02f, 1.40947606e-02f, 6.33244440e-02f,
  8.47751573e-02f, 8.77212174e-03f, -7.25730583e-02f, -1.63119465e-01f, 8.61616805e-03f, -1.83439925e-01f, 6.65642228e-03f, 4.78292666e-02f, 3.44516598e-02f, -5.36715910e-02f,
  -7.63092041e-02f, 7.21552223e-02f, -1.20142251e-01f, 7.08720759e-02f, -1.03244297e-01f, -9.21169370e-02f, 5.91775626e-02f, -3.47460993e-02f, 5.39951958e-03f, 1.23992324e-01f,
  -6.42032102e-02f, -1.15742780e-01f, 2.15773568e-01f, 1.02074571e-01f, -1.14563607e-01f, -2.05159530e-01f, 1.84906363e-01f, 1.00290418e-01f, -9.48910788e-02f, -2.01710671e-01f,
  -1.97504774e-01f, 2.22755954e-01f, 1.31231658e-02f, -1.11122794e-01f, 1.75737264e-03f, -9.37493518e-02f, -8.35631266e-02f, -1.38156593e-01f, 9.63412970e-02f, -2.72923172e-01f,
  -1.56995848e-01f, -5.93779720e-02f, -1.48576632e-01f, -1.65042758e-01f, 8.63242373e-02f, -1.58903807e-01f, 2.63871951e-03f, 5.41740879e-02f, 2.81578153e-01f, -2.40239561e-01f,
  7.71768615e-02f, -1.03467673e-01f, 1.34047896e-01f, 2.61987783e-02f, -7.66448900e-02f, 2.15452746e-01f, 2.79136486e-02f, -3.07578474e-01f, 3.09418380e-01f, 2.05371633e-01f,
  -1.90181687e-01f, 3.01236324e-02f, -6.79057604e-03f, -8.60369131e-02f, 1.34892225e-01f, -2.36741647e-01f, -4.66189161e-02f, -7.06997886e-02f, 6.66657388e-02f, -3.11427474e-01f,
  -7.16592297e-02f, -5.63512743e-02f, -3.46639901e-01f, 1.86013266e-01f, -2.30316997e-01f, 1.67735770e-01f, 1.45660549e-01f, -1.63002104e-01f, -3.81209999e-01f, 1.55579075e-01f,
  -2.69460946e-01f, -2.00557888e-01f, 1.13059744e-01f, 2.47429430e-01f, -1.54777691e-01f, 1.84904516e-01f, -9.67175663e-02f, 2.18250960e-01f, -1.91911548e-01f, -2.74407625e-01f,
  5.36761899e-03f, 2.39229172e-01f, 7.27416724e-02f, -1.11948997e-01f, -1.35924309e-01f, -3.17041010e-01f, -2.86226481e-01f, 4.68231291e-02f, -4.42837551e-02f, -6.89836591e-02f,
  -1.25614405e-01f, 3.84262539e-02f, -1.03590921e-01f, -1.26503080e-01f, 1.53955249e-02f, 2.96743792e-02f, -1.57273114e-01f, 1.23622835e-01f, 4.18497436e-02f, 1.54888019e-01f,
  -5.23587363e-03f, 1.50824934e-01f, -1.26126781e-02f, -1.53770462e-01f, -6.97116628e-02f, -4.94464897e-02f, -1.07891634e-01f, 8.03219676e-02f, -5.42713469e-03f, -3.12189981e-02f,
  1.10558294e-01f, 9.68534350e-02f, -7.34719411e-02f, -3.05202045e-02f, -1.66461825e-01f, 1.45686403e-01f, -1.09545060e-01f, -9.98416217e-04f, -6.93392530e-02f, 5.05763991e-03f,
  -1.28803519e-03f, -6.56780303e-02f, 7.04328865e-02f, 1.55868307e-01f, 1.12979487e-01f, -1.44309416e-01f, 2.26476789e-01f, 6.07099719e-02f, -3.98830026e-02f, 1.47377834e-01f,
  1.33969365e-02f, -3.95097546e-02f, -4.06398717e-03f, -1.43729657e-01f, -5.28226718e-02f, 7.50637352e-02f, 3.40258121e-03f, -3.61684673e-02f, 1.21295944e-01f, 1.42420813e-01f,
  -2.35546887e-01f, 2.80225337e-01f, -1.76684752e-01f, -1.20628841e-01f, 4.49454458e-03f, -3.63176838e-02f, -1.08911201e-01f, 2.34948575e-01f, 6.41445667e-02f, 2.90676653e-01f,
  -9.20229927e-02f, 2.69052804e-01f, 2.88876835e-02f, -3.19463074e-01f, -1.34412587e-01f, -2.62459755e-01f, 2.34810159e-01f, -3.07493657e-01f, 3.29573721e-01f, -4.91803978e-04f,
  -2.05940932e-01f, 1.12289295e-01f, 2.84319609e-01f, -1.98422700e-01f, -1.13103807e-01f, -4.26572114e-02f, -6.20568953e-02f, -2.89272927e-02f, 2.78343052e-01f, -1.94172308e-01f,
  1.03957824e-01f, 1.74577117e-01f, 5.77059053e-02f, 8.31441488e-03f, -7.56015778e-02f, -4.55232039e-02f, -6.63037673e-02f, 8.98022130e-02f, 1.01978384e-01f, -1.59327805e-01f,
  -9.89155471e-02f, -1.99783474e-01f, 1.39476582e-01f, -1.63520724e-01f, 1.24818102e-01f, -7.42740482e-02f, 5.24101965e-02f, 1.93144307e-01f, -2.38367841e-02f, -2.80503869e-01f,
  -3.02274436e-01f, -1.41651779e-01f, -1.10840559e-01f, 2.62857795e-01f, -2.30320111e-01f, 1.21782467e-01f, -1.56489909e-01f, -3.61784875e-01f, 2.47986510e-01f, -1.06162839e-02f,
  -1.03807345e-01f, 2.28690177e-01f, 1.57854587e-01f, -1.27077028e-01f, 1.95644855e-01f, -3.18711877e-01f, 2.03147247e-01f, -2.52971560e-01f, 1.55210644e-01f, -4.63012867e-02f,
  1.25758857e-01f, -2.09203988e-01f, -6.83008432e-02f, -5.17394364e-01f, -1.25189200e-01f, 1.54883325e-01f, 2.02269331e-01f, -2.34506935e-01f, 2.06170212e-02f, 1.04365088e-01f,
  -7.84334764e-02f, 1.14075623e-01f, -2.67759860e-01f, -8.79160017e-02f, -1.01437859e-01f, 7.21133966e-03f, -1.10077329e-01f, 6.25756904e-02f, 9.50354636e-02f, -7.31275082e-02f,
  7.45304003e-02f, 1.00035690e-01f, -9.09789577e-02f, -1.84774935e-01f, 1.29617736e-01f, 7.70786554e-02f, -1.96226820e-01f, -1.00065544e-01f, 7.73177063e-03f, -1.44906461e-01f,
  1.01814575e-01f, 1.79342824e-04f, -6.49388367e-03f, 1.16298590e-02f, -1.86479352e-02f, 1.21580087e-01f, -3.28115299e-02f, -5.02695851e-02f, -8.10710415e-02f, -1.99439511e-01f,
  -1.07290521e-01f, -1.14739323e-02f, -1.03244081e-01f, -1.55899405e-01f, -1.14535548e-01f, -1.64274976e-01f, 3.19109904e-03f, 1.03855826e-01f, -3.16160098e-02f, 1.20803630e-02f,
  -1.20393652e-03f, 1.08161978e-01f, -2.60800213e-01f, -2.22596139e-01f, 1.12936333e-01f, -1.11356964e-02f, -6.91875890e-02f, -4.22584638e-02f, -2.12025233e-02f, 1.73395440e-01f,
  8.44343752e-02f, -8.85845274e-02f, -1.32481426e-01f, 1.52614396e-02f, 1.28883207e-02f, -4.18954715e-02f, -2.27266371e-01f, -3.06581885e-01f, -7.43499994e-02f, 2.94582639e-03f,
  -3.27045709e-01f, 1.55051015e-02f, 5.18254377e-02f, -1.32307291e-01f, 1.12074099e-01f, -9.83872414e-02f, 1.87556803e-01f, 3.07216406e-01f, 2.69869924e-01f, 2.28104919e-01f,
  -2.58763522e-01f, 1.83292910e-01f, 1.66127816e-01f, 2.01823115e-01f, -1.46048158e-01f, -1.50295287e-01f, -1.45339981e-01f, 7.92873800e-02f, 2.21777186e-01f, -2.67308414e-01f,
  -7.41168112e-02f, 9.16850045e-02f, 3.07564646e-01f, -2.11254120e-01f, -1.55847631e-02f, -7.17775375e-02f, 6.78430349e-02f, 3.58111501e-01f, -2.90344376e-02f, 2.85462737e-01f,
  2.53874302e-01f, 8.02653730e-02f, -5.03203459e-02f, -5.28734289e-02f, -6.25506118e-02f, 6.18871339e-02f, 1.40055925e-01f, 2.63445258e-01f, -8.02311450e-02f, -2.53259595e-02f,
  3.44952643e-02f, 1.17262624e-01f, -4.08149272e-01f, 1.14506640e-01f, 2.83510536e-01f, -2.16775805e-01f, -2.01549619e-01f, 2.42186382e-01f, -3.31943542e-01f, -1.79056630e-01f,
  1.12505563e-01f, 7.94404373e-02f, -1.37496889e-01f, -2.15098470e-01f, 8.49063993e-02f, -4.27630872e-01f, 6.34820163e-02f, -2.08250076e-01f, 5.69807477e-02f, -9.59751457e-02f,
  -1.78736240e-01f, -3.80598634e-01f, 2.25644246e-01f, 9.47139040e-02f, -1.40003040e-01f, 8.85865930e-03f, -1.21229485e-01f, -1.44004956e-01f, -1.56433761e-01f, -5.52326851e-02f,
  -4.45038155e-02f, -7.54657537e-02f, 5.12949266e-02f, 1.97437638e-03f, -3.76939662e-02f, 1.19107313e-01f, 1.29480794e-01f, 5.85918687e-02f, -3.51143070e-02f, -3.47905606e-02f,
  -1.89414173e-01f, 1.67688243e-02f, -2.61333119e-02f, 1.49933239e-02f, -1.49461940e-01f, -4.17386293e-02f, -3.88160604e-03f, 7.07605109e-02f, 8.23634118e-02f, -1.01693191e-01f,
  -8.62778202e-02f, -1.34724855e-01f, -6.20429665e-02f, 1.14701837e-01f, -2.60289937e-01f, -7.67369270e-02f, -5.44051230e-02f, 9.41275712e-03f, 3.90483253e-02f, -2.02563688e-01f,
  1.05669007e-01f, 5.45170270e-02f, 4.98131551e-02f, 5.71891032e-02f, 9.03313607e-02f, -1.69043168e-01f, -1.53835967e-01f, 3.06230038e-02f, 8.45908076e-02f, 6.55094311e-02f,
  -9.04381182e-03f, -1.06166862e-01f, 3.15420181e-02f, -1.69167638e-01f, -9.77474600e-02f, 6.09103926e-02f, 2.56367952e-01f, -4.85339947e-02f, -8.97834823e-02f, 2.08163783e-01f,
  -1.71212003e-01f, 7.67524838e-02f, -1.46140829e-01f, -3.97648722e-01f, -1.17754571e-01f, -6.41690418e-02f, 2.04044357e-01f, -2.86685646e-01f, 9.00470614e-02f, -2.35694557e-01f,
  1.42865762e-01f, 1.53694659e-01f, -2.79911429e-01f, -2.04965457e-01f, -2.59319842e-01f, -1.56035393e-01f, 1.00999460e-01f, -1.50324002e-01f, -8.13247859e-02f, -6.08091354e-02f,
  2.01988786e-01f, 1.61881551e-01f, 1.83697402e-01f, -2.39707708e-01f, -6.35446981e-02f, 1.00053839e-01f, -2.27197781e-01f, 1.52559400e-01f, 3.53188574e-01f, 1.69838443e-01f,
  6.72754049e-02f, 1.06692463e-01f, -1.17709607e-01f, 2.60477036e-01f, 1.25663906e-01f, 6.43430799e-02f, 1.01676345e-01f, -1.29253298e-01f, -2.02170089e-01f, -3.03914219e-01f,
  -1.83986962e-01f, 1.42762974e-01f, 7.83384889e-02f, 1.45720333e-01f, -1.87074810e-01f, -1.71719611e-01f, -1.82681277e-01f, 3.93976346e-02f, -2.89021015e-01f, -2.33259097e-01f,
  5.68074994e-02f, -2.07959801e-01f, 7.91866407e-02f, -3.00976098e-01f, -2.57718801e-01f, 2.38696083e-01f, 2.15613157e-01f, -1.95725799e-01f, -2.71249473e-01f, 1.92411721e-01f,
  -1.75990388e-01f, 1.97085157e-01f, -3.12871896e-02f, 2.07708329e-01f, -4.96342003e-01f, -3.14757615e-01f, -2.13866793e-02f, -2.77877659e-01f, 2.51069605e-01f, -1.03785150e-01f,
  -8.67660195e-02f, -1.85770720e-01f, 1.14574693e-02f, 1.60801756e-05f, -9.23755914e-02f, 1.82878837e-01f, 8.76840055e-02f, 1.35334358e-01f, 7.98191130e-02f, 1.45349726e-01f,
  -3.31065096e-02f, -1.56797409e-01f, 1.16362229e-01f, -1.58824697e-01f, -6.85405284e-02f, 1.08765826e-01f, 1.05584919e-01f, -7.03665987e-02f, 2.15637572e-02f, -1.37506634e-01f,
  1.55197427e-01f, -2.21002456e-02f, 6.51154518e-02f, -3.12834606e-02f, -1.15481064e-01f, -9.47507098e-02f, -1.34655401e-01f, -1.37016401e-01f, -2.17436310e-02f, 1.16549365e-01f,
  7.54880894e-05f, 2.19088104e-02f, 2.11327791e-01f, -2.87350658e-02f, -1.39844865e-01f, 2.05976188e-01f, 6.03425168e-02f, -9.18538496e-02f, 1.15403235e-01f, 1.16255827e-01f,
  1.19505182e-01f, -5.64443357e-02f, 1.52528316e-01f, -4.16633971e-02f, 1.74116328e-01f, -1.36420369e-01f, 1.23572893e-01f, 2.55796671e-01f, -6.26082122e-02f, -2.24478677e-01f,
  4.25191149e-02f, 1.47209600e-01f, 3.77219580e-02f, 1.10634819e-01f, -2.29851343e-02f, -4.47872877e-01f, 1.51901528e-01f, 1.78520992e-01f, -1.45292446e-01f, -2.50120997e-01f,
  -1.14363572e-02f, 2.10331261e-01f, -1.64647281e-01f, -3.54877859e-02f, 3.61908749e-02f, -2.43990391e-01f, -9.80859175e-02f, 2.30276212e-01f, 1.70186535e-02f, 2.86086142e-01f,
  -6.97521195e-02f, 2.10643113e-01f, -3.60400006e-02f, 2.04661727e-01f, 2.69543707e-01f, -2.68818468e-01f, 2.38178238e-01f, 2.10200533e-01f, -5.99843338e-02f, 1.73879489e-01f,
  -2.41064832e-01f, 4.12457943e-01f, 7.71341696e-02f, -5.85705461e-03f, 3.12207729e-01f, 1.67538747e-01f, -2.28466839e-01f, -3.41231585e-01f, -1.50240168e-01f, -1.19434309e-03f,
  1.93336278e-01f, 9.37827826e-02f, -2.64300406e-01f, -1.37159735e-01f, 2.20736697e-01f, 1.07368417e-01f, -7.05928504e-02f, -1.12539925e-01f, 8.75697359e-02f, 1.30189225e-01f,
  4.30020206e-02f, -1.85168788e-01f, 2.13254988e-02f, -2.36414745e-01f, 7.18310773e-02f, 2.12446123e-01f, -1.94033250e-01f, -1.85068935e-01f, -7.32243061e-02f, -2.03399658e-01f,
  5.81756271e-02f, 2.66800344e-01f, -1.50208294e-01f, -4.31482159e-02f, 1.92751989e-01f, -3.48993152e-01f, -2.40381047e-01f, 1.16544679e-01f, 1.14427269e-01f, 1.09039232e-01f,
  -1.98280379e-01f, -3.11410101e-03f, 9.82878506e-02f, -3.17633122e-01f, 1.51421025e-01f, 1.56348243e-01f, 1.33041427e-01f, -1.50902048e-01f, 7.34739155e-02f, 1.18696988e-01f,
  -2.03730255e-01f, 1.69362471e-01f, -3.34946322e-03f, 5.81817627e-02f, -6.67290613e-02f, -1.45214591e-02f, 1.19359218e-01f, -2.88382005e-02f, 1.13132326e-02f, -4.12956551e-02f,
  -6.00000992e-02f, 4.42443006e-02f, -3.69048826e-02f, -2.80271322e-01f, 1.27481550e-01f, 9.03838947e-02f, 1.12531468e-01f, -6.88433601e-03f, 2.68816017e-02f, 7.00826198e-02f,
  -3.45569588e-02f, 1.00496814e-01f, 1.58364236e-01f, 1.10975735e-01f, -4.71168756e-02f, 2.53382418e-02f, 1.70703053e-01f, -5.19833714e-02f, 9.86027122e-02f, 1.20583721e-01f,
  5.43243326e-02f, -5.19835241e-02f, -2.58509498e-02f, -7.61674419e-02f, -5.71484342e-02f, 6.16907701e-02f, -1.09990664e-01f, 1.04138508e-01f, 1.03549086e-01f, 1.18419424e-01f,
  -2.49694273e-01f, -8.70065466e-02f, -2.02960864e-01f, 8.41203779e-02f, 1.68587193e-01f, -1.42204940e-01f, -2.19550673e-02f, -3.92560735e-02f, -1.23265805e-02f, -1.37869954e-01f,
  -8.24984387e-02f, 6.56233504e-02f, 5.57685271e-02f, 2.86462419e-02f, 1.49139673e-01f, -1.94759682e-01f, 2.37026572e-01f, -7.38992691e-02f, 3.22372854e-01f, -8.33092183e-02f,
  2.45523304e-01f, 3.29253227e-01f, 1.24527067e-01f, -1.27420112e-01f, 5.93186766e-02f, -2.55280674e-01f, -3.33592802e-01f, 1.15710022e-02f, -2.61869282e-01f, 3.19886982e-01f,
  -1.24614157e-01f, -1.26804695e-01f, 2.38012969e-02f, -6.01946861e-02f, 8.76696482e-02f, -1.90491214e-01f, -2.04179045e-02f, 2.24798203e-01f, -1.52573913e-01f, 3.25099081e-01f,
  8.10404718e-02f, -1.57726318e-01f, 6.87655658e-02f, -6.79702833e-02f, -1.34432822e-01f, -3.46740961e-01f, -5.83357401e-02f, 3.14904928e-01f, -1.31828964e-01f, 7.74204135e-02f,
  2.65002344e-02f, 2.74718497e-02f, -2.64824301e-01f, -5.29665090e-02f, -2.41514947e-02f, -6.61644936e-02f, 6.07253052e-02f, 2.90363401e-01f, -7.14737028e-02f, 1.07712530e-01f,
  2.11900786e-01f, 6.22227341e-02f, 2.30175287e-01f, 2.03270428e-02f, 1.74860790e-01f, -5.69625050e-02f, -4.68925238e-02f, -1.71097577e-01f, -4.17020380e-01f, 9.86972079e-02f,
  3.33060473e-02f, -5.60949504e-01f, -4.88474146e-02f, 1.97284505e-01f, -4.80637774e-02f, -3.65934521e-01f, 1.95942849e-01f, -3.78610380e-03f, 1.04730107e-01f, 1.18568093e-01f,
  -7.08335936e-02f, 1.64555818e-01f, -5.86245731e-02f, 2.60298669e-01f, -2.43518278e-01f, 4.11462970e-02f, -1.51336879e-01f, 9.98404175e-02f, 2.03680605e-01f, 1.01420365e-01f,
  -1.11871362e-01f, -1.38590559e-01f, -8.94589126e-02f, 2.61769444e-03f, 2.38672011e-02f, -2.05794442e-02f, -3.61020602e-02f, 1.12430632e-01f, 5.76563217e-02f, -9.60124657e-03f,
  9.89522506e-03f, 1.38296783e-01f, -2.25498825e-02f, 7.02469200e-02f, 5.90653867e-02f, 1.43729657e-01f, -8.34619179e-02f, -1.43839838e-02f, 8.80887881e-02f, 9.44315866e-02f,
  -1.25137165e-01f, 1.58326253e-01f, -8.24275427e-03f, -1.91386774e-01f, 7.55755380e-02f, 7.32879667e-03f, 3.70360911e-02f, -2.36607566e-02f, 1.19032515e-02f, 6.00424455e-03f,
  -8.23170226e-03f, -2.51348559e-02f, -3.84061188e-02f, -2.60825455e-02f, -7.03068450e-03f, -1.09179839e-01f, 2.37409025e-02f, 4.64231446e-02f, 1.45191804e-01f, 1.11039512e-01f,
  1.73768565e-01f, 9.63722467e-02f, -4.95899171e-02f, 1.18017174e-01f, 2.19307691e-02f, 4.28491347e-02f, -1.80159122e-01f, -9.25301313e-02f, 4.01455909e-02f, -7.96755031e-02f,
  -8.56244043e-02f, 1.05602898e-01f, 2.06738114e-01f, -3.25535648e-02f, 2.19537973e-01f, 9.38443542e-02f, 1.68417424e-01f, 5.21390513e-02f, 2.16562420e-01f, -8.48128274e-02f,
  7.90259987e-02f, 2.20792890e-02f, 4.51197848e-02f, 5.36526032e-02f, 2.51001924e-01f, 2.30953455e-01f, -5.60738184e-02f, 1.43623158e-01f, -1.88594386e-01f, -2.25038469e-01f,
  1.04733510e-02f, 2.54562706e-01f, -2.61653423e-01f, 1.84514984e-01f, 4.42330316e-02f, -2.79674709e-01f, -8.66606832e-02f, -1.18829146e-01f, -1.35540485e-01f, -7.97353461e-02f,
  2.73665059e-02f, -3.38162869e-01f, -1.47187442e-01f, 2.15967864e-01f, 2.21284926e-01f, -1.87875703e-01f, -6.68371320e-02f, -1.77459195e-01f, 2.35560462e-01f, -1.07938357e-01f,
  -2.39854231e-01f, -2.79399902e-02f, 8.65519047e-02f, 1.51858032e-01f, -1.06979281e-01f, -7.37873390e-02f, 1.08618021e-01f, 2.47428894e-01f, 7.48868138e-02f, 2.18002707e-01f,
  2.10150242e-01f, -3.36456954e-01f, 6.98159561e-02f, -3.13501060e-01f, 1.26168340e-01f, 8.12142491e-02f, -1.54190376e-01f, -2.67367870e-01f, -2.82675028e-01f, -1.00102864e-01f,
  1.81822732e-01f, -3.50799263e-01f, -1.23869643e-01f, -4.30272281e-01f, -9.39047709e-02f, -2.40779892e-01f, 2.57219464e-01f, -3.25624794e-01f, 1.61060080e-01f, -1.03182323e-01f,
  5.25917783e-02f, -1.75900757e-01f, 1.96021184e-01f, 2.40568131e-01f, 8.07443559e-02f, 1.70281455e-01f, 1.68209210e-01f, -8.86332914e-02f, 2.08607819e-02f, -1.13809993e-02f,
  -7.93130323e-02f, -8.01751465e-02f, 7.85459727e-02f, -6.02103304e-03f, 6.83029145e-02f, -6.75134687e-03f, -8.05991814e-02f, 3.79662178e-02f, -8.11526850e-02f, -8.24515074e-02f,
  5.93327731e-02f, 5.31590879e-02f, 5.07534333e-02f, -6.48764893e-02f, 4.59744129e-03f, -6.44835234e-02f, 6.41537830e-02f, 4.78273593e-02f, -4.56284657e-02f, -1.33586124e-01f,
  9.46252421e-02f, 4.84543405e-02f, 5.41766882e-02f, -7.30279014e-02f, -4.52697985e-02f, -1.93596128e-02f, 1.01414911e-01f, -4.23332304e-02f, 7.59641901e-02f, 3.79940197e-02f,
  4.80788238e-02f, -2.21916735e-02f, -1.31122872e-01f, -9.98732224e-02f, 4.34159255e-03f, -2.77970564e-02f, -7.62341172e-02f, -1.18870288e-01f, -1.00132748e-01f, 1.82293076e-02f,
  7.08864927e-02f, -1.65029764e-02f, -5.14828712e-02f, 1.25893444e-01f, -8.31230134e-02f, 5.91592714e-02f, -3.92807461e-02f, -3.88407186e-02f, -6.47902712e-02f, -1.28698975e-01f,
  1.10008590e-01f, 2.18712345e-01f, -4.06143768e-03f, 3.35883209e-03f, 1.43192828e-01f, -2.02219456e-01f, -1.49587914e-01f, -2.42396042e-01f, 1.34263068e-01f, -1.69145495e-01f,
  6.32554442e-02f, -8.54738280e-02f, 6.30412623e-02f, -8.06324315e-05f, 4.98899305e-03f, 2.19894126e-01f, -1.00042753e-01f, 2.07692817e-01f, -1.51767015e-01f, 1.87327668e-01f,
  1.18981503e-01f, -1.50272444e-01f, -1.76296636e-01f, -2.46835008e-01f, -1.97978184e-01f, -1.91617399e-01f, 1.83661893e-01f, 1.66564882e-01f, -1.61183298e-01f, 1.12836612e-02f,
  1.80190668e-01f, -2.13158965e-01f, -3.95218283e-02f, 1.07611626e-01f, -8.86476412e-02f, 1.44830540e-01f, -5.88519387e-02f, 2.66353726e-01f, 1.33336842e-01f, -2.22044196e-02f,
  -8.04575384e-02f, -1.34891137e-01f, 1.08312018e-01f, 1.80372521e-01f, -2.12199315e-01f, -1.90343082e-01f, -2.06563234e-01f, -1.38790995e-01f, 6.77239103e-03f, 2.25401029e-01f,
  2.43833289e-01f, -2.78736860e-01f, -3.11747253e-01f, -4.38173003e-02f, -1.23985797e-01f, -3.01420301e-01f, -1.84554815e-01f, 2.71966398e-01f, -2.04710782e-01f, 2.80581284e-02f,
  1.31854445e-01f, -7.10767806e-02f, -2.42720947e-01f, 1.89058810e-01f, -2.33980492e-01f, 2.35938787e-01f, -3.70671391e-01f, 3.40909213e-01f, -7.12241977e-02f, 2.59670913e-01f,
  -2.96212673e-01f, -9.52556208e-02f, -3.07540447e-01f, -2.79777557e-01f, -1.89155564e-01f, 5.08239157e-02f, -6.97460994e-02f, 5.48441894e-02f, 7.21063167e-02f, 5.32606356e-02f,
  -3.56669500e-02f, -1.68259759e-02f, -9.46033467e-03f, 9.19273272e-02f, -3.39202620e-02f, 1.31452624e-02f, 5.70788793e-02f, 1.43055856e-01f, -1.47842705e-01f, 2.98188180e-02f,
  -8.50541443e-02f, 1.58181973e-02f, 7.57221356e-02f, -2.02476606e-02f, 4.76576202e-02f, 3.22500281e-02f, 1.69487987e-02f, -7.34171942e-02f, 6.25720248e-03f, -9.61703286e-02f,
  -9.26949233e-02f, 1.57475416e-02f, 5.41666113e-02f, 8.74122530e-02f, -1.22121952e-01f, 9.43834931e-02f, 5.18739745e-02f, 3.45251523e-02f, 6.59934804e-02f, 3.66361924e-02f,
  7.49683604e-02f, 1.24917202e-01f, -1.19720832e-01f, -4.57691327e-02f, 4.79575843e-02f, -5.71614951e-02f, 1.05901547e-01f, -6.49008453e-02f, 9.29405019e-02f, 1.29997522e-01f,
  -7.73756504e-02f, -1.04241252e-01f, -4.48209904e-02f, -7.75112063e-02f, -4.50486057e-02f, 4.64823879e-02f, 1.26509264e-01f, -2.96541870e-01f, 4.83734161e-02f, 5.70433447e-03f,
  -8.47160146e-02f, 7.39533901e-02f, 5.87375462e-03f, 9.57830474e-02f, 1.49774104e-01f, 1.02327801e-01f, -1.48570389e-01f, 1.35757580e-01f, -1.28851727e-01f, 2.10413396e-01f,
  -1.87249586e-01f, -6.45842850e-02f, 1.85479686e-01f, -8.59470144e-02f, 2.18882740e-01f, 2.07590148e-01f, 4.00629379e-02f, -2.41782382e-01f, -2.46757373e-01f, -1.64599687e-01f,
  -2.53397673e-01f, 1.48282707e-01f, 6.57940283e-02f, 6.17001578e-02f, 1.34623900e-01f, 1.07470825e-01f, -2.08598331e-01f, -2.46394381e-01f, 1.09078787e-01f, 1.86371244e-02f,
  1.91408262e-01f, -2.01507099e-02f, -4.17273864e-02f, -1.42082110e-01f, 1.84089527e-01f, -1.28077880e-01f, -1.93810180e-01f, 1.87179968e-01f, 1.55679211e-01f, -1.93298638e-01f,
  8.27869307e-03f, -9.00738984e-02f, 5.60835265e-02f, -1.55232042e-01f, -2.49002248e-01f, 1.04784749e-01f, 1.50415927e-01f, 2.30910763e-01f, -5.58769368e-02f, 1.20907970e-01f,
  -3.30870628e-01f, 1.67590797e-01f, 2.06136569e-01f, 3.17130983e-01f, 1.95161790e-01f, -1.94763690e-01f, -3.56936514e-01f, -6.47425354e-02f, -2.80665994e-01f, -3.85228366e-01f,
  -2.46373758e-01f, 1.07251495e-01f, -2.82596536e-02f, -1.58590987e-01f, 8.77573416e-02f, 7.90255368e-02f, -2.83598825e-02f, -2.01691836e-02f, 1.86748952e-01f, 2.57847637e-01f,
  -2.65877277e-01f, -3.47395390e-01f, 1.43868163e-01f, -2.94201285e-01f, 8.97690505e-02f, -8.46933350e-02f, 1.22735739e-01f, 8.84328261e-02f, 4.31365008e-03f, -1.80346239e-02f,
  -1.16218567e-01f, 7.36369193e-02f, -9.47261900e-02f, -1.49828270e-02f, 5.11218458e-02f, -1.51181951e-01f, -2.01064810e-01f, -3.19867060e-02f, 1.06833307e-02f, 6.29932806e-02f,
  -8.21084753e-02f, 1.55758142e-01f, 6.87093064e-02f, 1.04364112e-01f, 5.43197319e-02f, -1.48459345e-01f, -1.48144379e-01f, -1.25003949e-01f, 9.48594958e-02f, -2.03343555e-01f,
  6.83236793e-02f, -9.74175557e-02f, -1.40617758e-01f, 9.73565578e-02f, -5.20367846e-02f, -2.15689659e-01f, -6.33715913e-02f, 9.98554677e-02f, 1.18889272e-01f, -5.38019612e-02f,
  -1.59027904e-01f, -1.27372742e-01f, 1.26680389e-01f, 1.07040890e-01f, 4.55686972e-02f, -1.22984409e-01f, -2.36866519e-01f, -2.32514739e-01f, 8.40585679e-03f, 3.88333201e-02f,
  1.35794476e-01f, -1.55635953e-01f, 1.21518197e-02f, -1.69463396e-01f, -7.24693574e-03f, 3.14358681e-01f, 4.18518484e-02f, -2.27386773e-01f, -1.13174647e-01f, 8.71309489e-02f,
  7.92261735e-02f, 1.21450186e-01f, -1.05262950e-01f, -2.91518688e-01f, 1.60515755e-01f, 1.76273495e-01f, 1.02660701e-01f, 1.87092960e-01f, 2.01151550e-01f, -2.95124173e-01f,
  -1.18130818e-01f, 1.68104425e-01f, -3.31937112e-02f, 2.37641782e-01f, 1.25651971e-01f, -7.42534921e-02f, 2.49172524e-01f, 1.84704289e-01f, 1.23450629e-01f, -1.41301855e-01f,
  -1.33286685e-01f, -9.96320397e-02f, -2.18024030e-01f, -1.61708385e-01f, -1.22681789e-01f, 2.76853263e-01f, -1.01926960e-01f, 2.11035803e-01f, -8.51280689e-02f, 1.10034660e-01f,
  -2.28336062e-02f, -2.09610343e-01f, -2.87650645e-01f, -1.07420355e-01f, 2.58721232e-01f, 2.35193163e-01f, -2.45156616e-01f, 2.30023235e-01f, 1.00858897e-01f, 1.07553773e-01f,
  9.69652832e-02f, -2.59834349e-01f, 1.22115828e-01f, -5.89114241e-02f, -2.59595122e-02f, 6.13230048e-03f, 2.07157716e-01f, -1.11086048e-01f, 1.70782745e-01f, -2.07382649e-01f,
  -7.23849237e-02f, 1.62631080e-01f, -2.65574992e-01f, -2.74834156e-01f, -3.59516919e-01f, -2.90937185e-01f, 3.07056099e-01f, 9.40648317e-02f, -1.85366735e-01f, 1.88417092e-01f,
  -3.64200860e-01f, -1.77364469e-01f, 1.97380200e-01f, 2.68995725e-02f, -2.01774463e-01f, 1.96093712e-02f, -1.18890420e-01f, -1.22909732e-01f, -3.01303595e-01f, 9.67698619e-02f,
  -9.31812003e-02f, 3.60159576e-02f, 8.18335786e-02f, -2.22051501e-01f, 8.23784992e-02f, 3.82512659e-02f, 1.07350968e-01f, -1.26044318e-01f, -6.77429363e-02f, -4.91081290e-02f,
  -1.35965394e-02f, -3.65068801e-02f, -1.10547371e-01f, 6.73245862e-02f, 9.49892327e-02f, 1.18992284e-01f, 7.84142911e-02f, 4.06016596e-02f, 6.02489188e-02f, 2.89014801e-02f,
  9.31859240e-02f, -5.71380444e-02f, 3.60745820e-03f, 2.99598509e-03f, -8.27578530e-02f, 9.89439338e-02f, -1.04657210e-01f, 8.32190216e-02f, -3.50937545e-02f, -4.58354913e-02f,
  8.64066109e-02f, 1.21281683e-01f, -7.62155354e-02f, 1.84514493e-01f, -2.27921121e-02f, -4.21626121e-02f, -7.88084716e-02f, 8.55332166e-02f, 9.91463661e-02f, -7.39897368e-03f,
  4.31405380e-02f, -1.23519830e-01f, -8.35867599e-02f, 3.55396941e-02f, 1.26596764e-02f, 1.17826976e-01f, 4.73437831e-02f, 1.34865284e-01f, -1.37473240e-01f, 1.08317025e-01f,
  5.29533699e-02f, 5.11644334e-02f, 5.49064279e-02f, -3.28310817e-01f, -1.37012437e-01f, 1.62318453e-01f, -1.38284132e-01f, 2.15018634e-02f, 1.50487702e-02f, 2.25886181e-01f,
  2.62964487e-01f, -2.80366749e-01f, -2.53125846e-01f, 2.68042713e-01f, 8.88303742e-02f, 8.48843157e-02f, -2.08870411e-01f, 2.02227592e-01f, 2.09184393e-01f, -1.98178560e-01f,
  3.23690236e-01f, -1.45427942e-01f, -2.18622074e-01f, 2.69847840e-01f, -3.32337944e-03f, 2.38964900e-01f, -6.58833161e-02f, 1.61623821e-01f, 2.61298180e-01f, -1.75438866e-01f,
  -1.71311513e-01f, 1.45827070e-01f, -1.64323859e-02f, 2.09078521e-01f, -1.01388030e-01f, 1.67058989e-01f, -9.96965766e-02f, 1.47937134e-01f, 5.52749150e-02f, -1.01304688e-01f,
  1.73411332e-02f, 2.70350188e-01f, 2.06554800e-01f, -7.48137534e-02f, 2.79540062e-01f, 2.16947272e-01f, -1.36714265e-01f, 3.28604667e-03f, 1.03161946e-01f, 6.49259239e-02f,
  -2.63411850e-01f, 1.24749795e-01f, -2.37759486e-01f, -4.19801891e-01f, -2.98976123e-01f, -2.82526910e-02f, -2.60129184e-01f, -3.56970727e-01f, 2.31398880e-01f, -1.72889471e-01f,
  8.65682214e-02f, 2.40398705e-01f, 1.27462268e-01f, 2.11595744e-01f, 8.03474188e-02f, -8.93421564e-03f, 2.07889348e-01f, -3.15522611e-01f, 6.60058856e-02f, 1.27575487e-01f,
  6.09611869e-02f, -2.72502214e-01f, -3.91239896e-02f, -2.51078069e-01f, -2.23838031e-01f, -2.07440645e-01f, 1.77450269e-01f, -2.09519595e-01f, -1.52545094e-01f, -6.61257505e-02f,
  -1.12640997e-02f, -7.75379315e-02f, 1.13308407e-01f, 1.46288022e-01f, 1.07130349e-01f, -8.75661299e-02f, 7.95710087e-02f, -1.40912876e-01f, -7.34306425e-02f, 1.56698793e-01f,
  -3.85921635e-02f, -2.82652881e-02f, -5.65632209e-02f, 8.47605541e-02f, -3.79010066e-02f, -8.48646536e-02f, -7.54151791e-02f, -1.53891211e-02f, -1.12488598e-01f, -1.66446686e-01f,
  -2.38942616e-02f, 9.53676924e-02f, -1.16674947e-02f, 1.61518484e-01f, 1.17824286e-01f, 4.06380072e-02f, -3.80271263e-02f, -1.88740522e-01f, 4.01908495e-02f, -1.44217238e-02f,
  -6.54204609e-03f, 1.66815370e-01f, 2.29343809e-02f, -4.34304625e-02f, -1.49436546e-02f, 1.40447482e-01f, 1.38778627e-01f, 8.29141513e-02f, -1.24726072e-01f, 3.82833625e-03f,
  7.18887523e-02f, 6.94988295e-02f, -3.02315801e-02f, -2.87033655e-02f, -7.83949271e-02f, 1.06833823e-01f, 7.78989941e-02f, 1.05227962e-01f, 3.64634581e-02f, 1.30048588e-01f,
  1.55979261e-01f, 2.62358636e-01f, -1.27477795e-01f, 9.37225223e-02f, -1.63107682e-02f, -2.38815263e-01f, -2.10229933e-01f, 6.34898543e-02f, 1.91933185e-01f, 2.76062310e-01f,
  -1.04580529e-01f, 1.66163605e-03f, 3.10737733e-03f, 1.43817186e-01f, 1.86371997e-01f, -5.99386469e-02f, -1.18142739e-01f, 1.86168224e-01f, -1.20543942e-01f, -1.90098539e-01f,
  1.87187135e-01f, -9.53883752e-02f, -2.44477987e-01f, -2.34177522e-02f, 7.13752955e-02f, -2.79975563e-01f, 1.42127469e-01f, 2.69862235e-01f, -1.09433442e-01f, 8.06064829e-02f,
  -2.21565425e-01f, -1.46207124e-01f, 1.48480132e-01f, -1.04301430e-01f, -1.98687345e-01f, 1.68080166e-01f, 1.91225663e-01f, -9.13178772e-02f, 5.44653682e-04f, -8.54365081e-02f,
  -3.36133502e-02f, -4.03704168e-03f, -1.33246914e-01f, 1.99893758e-01f, 6.82913512e-02f, -2.03668609e-01f, 2.55647525e-02f, 1.39181033e-01f, -1.42722845e-01f, 1.34887263e-01f,
  -1.03743173e-01f, -2.07956821e-01f, 6.01681955e-02f, -3.23039293e-01f, 2.50418127e-01f, 6.02710396e-02f, -2.76404709e-01f, 2.64407635e-01f, 1.78211093e-01f, -2.24686474e-01f,
  -1.61720976e-01f, 1.46287248e-01f, -1.21929973e-01f, 1.50995776e-01f, 1.29805416e-01f, -1.60429105e-01f, -2.06335440e-01f, 1.51410801e-02f, -3.49806517e-01f, -3.00687164e-01f,
  -1.44907311e-01f, -3.21272224e-01f, 2.22349107e-01f, 3.69868636e-01f, 1.44201115e-01f, -2.01080933e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.95124662e-02f, -8.36163834e-02f, -9.54406261e-02f, -3.93406600e-02f, 3.36832441e-02f, -9.11704004e-02f, -3.62774096e-02f, -3.72575745e-02f, -8.11866075e-02f, 1.07034370e-01f,
  1.59901421e-04f, 8.26241150e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    