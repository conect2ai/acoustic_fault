/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.86032874e-02f, -1.59489959e-01f, -1.52761400e-01f, 3.72873410e-03f, -1.22019097e-01f, -9.03670415e-02f, -1.09700272e-02f, 8.55015125e-03f, 7.59522198e-04f, -2.85048783e-01f,
  1.65982377e-02f, 9.92224813e-02f, 2.38366365e-01f, 1.04819424e-01f, 2.33351961e-01f, -1.47418017e-02f, 4.85484712e-02f, 1.05454177e-01f, 1.88367069e-01f, -4.12526354e-02f,
  -1.15963206e-01f, -4.08843420e-02f, -9.70770717e-02f, 2.50918984e-01f, -2.08273530e-01f, 8.20765942e-02f, -9.04457420e-02f, -2.51511127e-01f, -1.35692522e-01f, -2.52588451e-01f,
  -1.30704001e-01f, -1.34545133e-01f, 1.76190227e-01f, 7.73129165e-02f, -9.17688683e-02f, -1.09627135e-01f, -5.47270291e-02f, -1.95009127e-01f, -5.39972596e-02f, -1.39554024e-01f,
  4.32953276e-02f, -1.85310841e-02f, 3.45443524e-02f, -1.34311682e-02f, -5.78871742e-02f, -8.40139389e-02f, -3.74643109e-03f, 1.88010409e-02f, 6.37097806e-02f, -6.76806942e-02f,
  -7.26400390e-02f, -9.97370705e-02f, -9.95221436e-02f, 7.41694197e-02f, -5.98335732e-03f, 1.21268563e-01f, -5.11521008e-03f, -6.59728795e-02f, -1.26814684e-02f, -2.69795954e-01f,
  -2.17090566e-02f, 2.55944151e-02f, -2.63533928e-02f, -3.51587646e-02f, 7.63232261e-03f, 4.82964255e-02f, 1.06968068e-01f, 8.63401517e-02f, 8.09374172e-03f, -9.90908220e-02f,
  -3.15983407e-02f, -8.32584947e-02f, -8.26945454e-02f, -6.31866753e-02f, -1.65919140e-02f, -4.70602699e-03f, -1.64975133e-02f, 2.45886203e-02f, 6.01745807e-02f, 3.81176989e-03f,
  8.82007740e-03f, -3.40218656e-02f, -7.09118769e-02f, 2.92638838e-02f, -7.22872242e-02f, 9.65631828e-02f, -2.94138771e-02f, -3.74288745e-02f, -1.73920635e-02f, 2.05900315e-02f,
  8.97925906e-03f, 2.31820315e-01f, -3.48603576e-02f, 9.78696495e-02f, -2.23809499e-02f, -7.77392313e-02f, -1.43051669e-02f, 4.16462384e-02f, 7.70651326e-02f, -1.33991484e-02f,
  -6.23892527e-03f, 1.17865233e-02f, -4.99807671e-02f, 3.08527015e-02f, 7.68501461e-02f, 3.36859189e-02f, -7.24240467e-02f, 4.10170071e-02f, 1.11624273e-02f, -8.73128623e-02f,
  -1.19597964e-01f, -1.08853512e-01f, -2.17216443e-02f, 5.58278821e-02f, -7.69453272e-02f, -2.26532528e-03f, -1.77405730e-01f, -9.08814967e-02f, 3.32054645e-02f, -2.40203500e-01f,
  2.50036977e-02f, -5.53860366e-02f, -1.57903656e-01f, 6.21529631e-02f, 7.92221427e-02f, 4.53742407e-02f, -1.36086345e-01f, 1.87381878e-02f, 2.32173931e-02f, -1.06602818e-01f,
  1.53152898e-01f, 1.10609435e-01f, -8.64289980e-03f, 5.58373071e-02f, -5.52657470e-02f, -9.22272131e-02f, -2.09910557e-01f, -9.07562301e-02f, 1.52964517e-01f, 2.19078153e-01f,
  2.33154863e-01f, 8.71138126e-02f, -2.64657829e-02f, 1.21173136e-01f, -3.50873359e-02f, 1.47738561e-01f, -1.87062427e-01f, -8.89103189e-02f, -3.12455688e-02f, -4.29565758e-01f,
  7.45316967e-02f, -1.37913629e-01f, -2.11551525e-02f, 8.26670416e-03f, -2.07410492e-02f, -1.51825706e-02f, -1.93045358e-03f, -1.25650868e-01f, -4.86464538e-02f, -2.15370208e-02f,
  -4.38335128e-02f, -5.86960912e-02f, -1.41205052e-02f, -5.64061850e-02f, -1.03265569e-01f, -4.54738289e-02f, -9.74383652e-02f, -1.37699246e-01f, -1.55524895e-01f, -6.26252294e-02f,
  -3.08459736e-02f, -3.94303873e-02f, -1.04238965e-01f, -9.90335196e-02f, -2.11990505e-01f, -1.54926687e-01f, -2.00580746e-01f, -2.05621451e-01f, -1.21989675e-01f, -1.57009229e-01f,
  -7.66564719e-03f, 7.42273480e-02f, 7.70946071e-02f, -7.19576702e-02f, 3.82066853e-02f, 2.38324385e-02f, -3.48508693e-02f, -1.47296665e-02f, 1.70121286e-02f, 4.90092151e-02f,
  5.43362014e-02f, -3.27359475e-02f, 9.17968228e-02f, 4.96219136e-02f, 4.24510911e-02f, -3.86891589e-02f, 1.10847183e-01f, 3.10688782e-02f, 2.35860492e-03f, -2.14766636e-02f,
  2.67369729e-02f, -4.54790592e-02f, 6.55484796e-02f, -3.75251733e-02f, -5.22208726e-03f, -1.98959727e-02f, 9.15693119e-02f, 7.09203556e-02f, 1.50866836e-01f, 9.19467658e-02f,
  1.31111801e-01f, 9.38173085e-02f, -4.47802991e-02f, -2.26076934e-02f, 3.22399847e-02f, -9.44438577e-03f, 2.57366728e-02f, -6.93949908e-02f, -2.22265138e-03f, 1.77120063e-02f,
  9.97395888e-02f, 2.09244508e-02f, -2.67369095e-02f, 4.32612039e-02f, 4.36914526e-02f, 2.32074466e-02f, 2.05009766e-02f, -8.75522792e-02f, -1.31147094e-02f, -2.63636727e-02f,
  4.56452183e-03f, -9.34950449e-03f, 1.06802322e-01f, 3.58850174e-02f, 6.02435581e-02f, 4.08720598e-02f, 5.58341369e-02f, 8.46036896e-02f, -1.44096036e-02f, 1.48178130e-01f,
  -6.74760818e-01f, 2.40926202e-02f, 1.61095768e-01f, -2.78507799e-01f, 2.05607623e-01f, 2.31880546e-01f, 4.93958801e-01f, 2.03985140e-01f, 6.27081171e-02f, 7.18137696e-02f,
  -1.27998248e-01f, -2.28503168e-01f, -2.62698144e-01f, -2.32947111e-01f, -1.41848534e-01f, 2.96720803e-01f, 3.17044586e-01f, 1.43242134e-02f, -2.01135069e-01f, 6.56403750e-02f,
  5.58664836e-02f, 2.07460150e-01f, -2.54816115e-01f, -1.03222348e-01f, 9.63946655e-02f, -1.60139024e-01f, 1.17358349e-01f, -6.44934848e-02f, -1.59899577e-01f, 2.30283037e-01f,
  -1.76938176e-01f, -2.86153644e-01f, -2.57227093e-01f, -3.32834810e-01f, -1.68119818e-01f, -1.03484266e-01f, -8.67213458e-02f, -1.34186357e-01f, -8.89552161e-02f, -2.29109209e-02f,
  -5.62005751e-02f, -1.27786860e-01f, -4.73690145e-02f, 1.23987952e-02f, -3.42837088e-02f, 1.50847679e-03f, -4.58692275e-02f, -4.01157886e-02f, -7.87824020e-02f, -2.49252617e-02f,
  -4.33698706e-02f, -5.02084158e-02f, -1.74662292e-01f, -1.14284568e-01f, -1.95488438e-01f, -1.91673741e-01f, -1.27008051e-01f, -2.03273669e-01f, -1.67420104e-01f, 2.97001414e-02f,
  -4.06888761e-02f, 6.36097118e-02f, 3.76791582e-02f, 9.38835219e-02f, 3.59896421e-02f, 1.12360120e-01f, 1.19481891e-01f, 1.10346943e-01f, 1.65787801e-01f, 1.20285235e-01f,
  4.38547321e-02f, 4.57641147e-02f, 4.50517125e-02f, 3.48790027e-02f, 1.22539774e-01f, 6.71314774e-03f, 5.15594892e-02f, -2.13560499e-02f, -7.74000138e-02f, 4.82146852e-02f,
  6.18998287e-03f, 1.23978890e-02f, 1.34900182e-01f, 4.09701429e-02f, 5.77571802e-02f, -4.07265946e-02f, 5.61556444e-02f, 6.33335263e-02f, 1.28469810e-01f, 1.03617147e-01f,
  -1.15151025e-01f, -3.44937593e-01f, -9.20568109e-02f, -1.51620686e-01f, -1.49229780e-01f, -1.09875746e-01f, -1.13755591e-01f, -1.43536001e-01f, -3.05372570e-03f, -2.38444414e-02f,
  -1.38555795e-01f, -9.08424333e-02f, -8.12003985e-02f, 5.15963994e-02f, -3.60336639e-02f, 2.67386399e-02f, -2.97114477e-02f, -1.70113221e-02f, -4.21447039e-04f, 1.64089222e-02f,
  1.82491669e-03f, 3.14838998e-02f, -1.96592566e-02f, -3.22136730e-02f, -1.27359435e-01f, -5.16052544e-02f, 5.82845435e-02f, 1.38373338e-02f, -1.58503771e-01f, 6.64300397e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.19472855e-01f, 1.21157117e-01f, -2.12903917e-01f, 3.82806569e-01f, 2.56944597e-01f, 2.00205848e-01f, 2.86215305e-01f, 2.10263848e-01f, 2.51869112e-01f, 1.29609987e-01f,
  3.79450321e-01f, 3.83185595e-01f, 3.70728642e-01f, 3.79088104e-01f, 2.59180784e-01f, 3.54924165e-02f, 1.68621257e-01f, 2.30607484e-02f, 4.82673906e-02f, 1.45414725e-01f,
  2.98078328e-01f, -1.17802687e-01f, -1.09433807e-01f, 6.72770441e-02f, 7.18858605e-03f, 2.86776483e-01f, -2.05227714e-02f, 4.94157821e-02f, 7.83689544e-02f, -2.43274029e-02f,
  -1.50432866e-02f, -1.27779618e-01f, 6.10538498e-02f, -3.12760361e-02f, -1.79004312e-01f, -1.14461385e-01f, 1.92565285e-02f, -2.15549041e-02f, 1.35021701e-01f, -6.25417680e-02f,
  -4.30236980e-02f, -7.95625076e-02f, -5.66905141e-02f, -1.06598631e-01f, -1.99750468e-01f, -3.29176672e-02f, -8.43536761e-03f, 5.23520298e-02f, 3.59985717e-02f, -1.45834163e-02f,
  2.04696298e-01f, -2.15877704e-02f, -8.95265043e-02f, 1.41433284e-01f, 2.45334044e-01f, 5.29382527e-02f, -2.67986655e-02f, 9.66545790e-02f, -1.80255491e-02f, -9.27424803e-03f,
  2.90879190e-01f, -6.29052296e-02f, -1.04791090e-01f, -2.95124352e-02f, -6.86009303e-02f, -1.26338750e-01f, -2.73241609e-01f, 9.91558190e-03f, -1.73431486e-02f, -1.63314760e-01f,
  -3.78765762e-02f, 2.81975437e-02f, -8.85248110e-02f, 1.18932702e-01f, 1.01947792e-01f, -1.77397072e-01f, -1.33914754e-01f, -5.10653332e-02f, -4.14803997e-02f, 3.02393567e-02f,
  1.08917922e-01f, -9.02427733e-03f, -9.81827974e-02f, -1.53671533e-01f, 1.89529004e-04f, 1.26098633e-01f, 7.44639561e-02f, 2.69976854e-02f, -1.81884691e-02f, 6.74803481e-02f,
  -1.32714212e-01f, 1.14498265e-01f, 6.33221269e-02f, 1.45540699e-01f, -1.58869140e-02f, -3.52015756e-02f, 1.75630733e-01f, 4.76623140e-02f, -5.43813482e-02f, 4.31642011e-02f,
  -3.03078610e-02f, -3.76546308e-02f, -6.83118626e-02f, -9.80138630e-02f, -1.83687806e-01f, -6.02309499e-03f, 1.21872716e-01f, 2.88368650e-02f, 8.74966383e-03f, -1.88991606e-01f,
  1.44453526e-01f, -8.53442773e-03f, -9.96272266e-03f, 1.05656795e-01f, -6.46279054e-03f, 1.02142558e-01f, -1.23187259e-01f, -8.30398034e-03f, -1.02661707e-01f, -1.96491241e-01f,
  -6.53700888e-01f, -8.43211532e-01f, -7.84189254e-02f, -7.36637890e-01f, -1.36967152e-01f, -1.56944156e-01f, -8.32211494e-01f, -2.49854356e-01f, 6.63338825e-02f, -4.01056558e-01f,
  -3.06318313e-01f, 3.32463197e-02f, 1.20717585e-01f, 1.57489195e-01f, 1.47238478e-01f, -3.95218104e-01f, -2.26167917e-01f, 2.37669811e-01f, 4.73777086e-01f, 3.38608831e-01f,
  -7.23989401e-03f, -3.76239985e-01f, 2.19336972e-01f, 3.75905782e-01f, -5.61939299e-01f, -1.92584231e-01f, -2.51441896e-01f, -3.47818911e-01f, 2.93664604e-01f, -8.09028506e-01f,
  -4.74867404e-01f, -2.88618177e-01f, 4.41603273e-01f, 8.59106258e-02f, -2.22444654e-01f, 2.23109812e-01f, -1.19622843e-02f, 7.54986773e-04f, 2.07690164e-01f, 8.12103674e-02f,
  2.73030698e-02f, 2.96986848e-01f, -7.35187009e-02f, -3.45048821e-03f, -1.62104741e-01f, -1.39165387e-01f, 2.75837295e-02f, 6.90587834e-02f, 9.85718593e-02f, -2.23046448e-03f,
  -2.77872588e-02f, 1.04773149e-01f, 2.44383328e-02f, 1.29404679e-01f, 1.66506574e-01f, 1.86013907e-01f, 5.51317409e-02f, 6.42537102e-02f, 4.61732954e-01f, -6.40983582e-01f,
  7.84591734e-02f, -6.12775721e-02f, 4.68910225e-02f, -2.03046557e-02f, -8.84845331e-02f, 1.73903257e-02f, -4.54166792e-02f, -7.71554112e-02f, 8.20202976e-02f, -8.03676844e-02f,
  3.81558836e-02f, 1.39464121e-02f, 7.10843652e-02f, -1.57914966e-01f, 7.67441541e-02f, 4.69502471e-02f, -5.85660897e-02f, -7.47960359e-02f, 6.35507703e-02f, -3.34674530e-02f,
  7.83436298e-02f, 1.42475292e-01f, -8.14452395e-03f, 2.12171264e-02f, 9.48860794e-02f, 6.05945326e-02f, 7.53476024e-02f, 7.26961344e-02f, -2.14133367e-01f, 8.43359455e-02f,
  -6.04753315e-01f, 5.91879725e-01f, -4.02416438e-01f, -3.86908390e-02f, -3.08345854e-02f, 6.78227544e-02f, -1.55654415e-01f, 8.90588313e-02f, -6.37275204e-02f, -2.15169236e-01f,
  1.00407660e-01f, -2.08582535e-01f, -9.08455476e-02f, 5.52388728e-02f, -3.06546707e-02f, -3.34677212e-02f, 7.94719905e-02f, -2.62069285e-01f, 2.19420955e-01f, 2.94410046e-02f,
  4.12029922e-02f, -1.39986858e-01f, -1.49060905e-01f, -1.61156505e-01f, -1.73759535e-02f, -5.86738214e-02f, -1.46242082e-01f, -1.53638572e-01f, -1.78035602e-01f, -6.15245640e-01f,
  6.24693334e-01f, 3.20370160e-02f, -1.10791302e+00f, 2.38397673e-01f, -3.17396462e-01f, -3.09562176e-01f, -2.75798976e-01f, 3.81470680e-01f, 2.02903539e-01f, -3.53426665e-01f,
  3.45111899e-02f, 3.44225883e-01f, 3.56356837e-02f, 7.71017978e-03f, 2.27386523e-02f, -5.70681751e-01f, -5.27242005e-01f, -3.70427698e-01f, -9.93497372e-02f, 2.31027454e-01f,
  4.62169833e-02f, -8.02853182e-02f, 8.29593763e-02f, 3.02817356e-02f, -1.76162377e-01f, -1.58630207e-01f, -6.24256670e-01f, -3.66621524e-01f, -5.01130581e-01f, -7.94795454e-01f,
  -6.96789205e-01f, 9.25924331e-02f, 1.19567581e-01f, 9.85120833e-02f, -1.18196718e-01f, 1.91294357e-01f, 1.00097708e-01f, 1.14602827e-01f, 2.04383463e-01f, 1.00376174e-01f,
  -1.35081522e-02f, 1.81160465e-01f, 7.54439980e-02f, 1.36908377e-02f, 5.68919890e-02f, 1.40394300e-01f, 1.03162698e-01f, 1.43958986e-01f, 8.19513723e-02f, 6.98918328e-02f,
  1.83454841e-01f, -1.90310460e-02f, -7.36496225e-02f, 1.95594192e-01f, 6.54478222e-02f, -1.14582367e-01f, -2.57165320e-02f, -7.33467937e-02f, -1.97552785e-01f, 2.20547915e-02f,
  -9.98221934e-02f, -3.54514606e-02f, 4.24186146e-04f, 1.07556224e-01f, 9.13815275e-02f, 5.90839610e-02f, 1.32373990e-02f, -4.56508994e-02f, -7.20956689e-03f, 5.47076091e-02f,
  3.70533280e-02f, -8.74637961e-02f, 1.16451018e-01f, 5.41729294e-02f, -1.41096652e-01f, -2.88957097e-02f, -5.88577688e-02f, 3.55574451e-02f, 4.99518029e-02f, 9.79341045e-02f,
  8.70938227e-02f, -1.16023153e-01f, -2.68165749e-02f, 1.63062010e-02f, -7.82340989e-02f, 3.39570828e-02f, 5.52393608e-02f, -1.17213661e-02f, 2.67081521e-02f, 7.94639736e-02f,
  3.65485623e-02f, -1.76485881e-01f, 9.59551632e-02f, 1.36096507e-01f, -1.02454014e-01f, 9.46050975e-03f, -1.35557711e-01f, -6.43979013e-02f, 8.96112155e-03f, 5.56786954e-02f,
  -1.11182146e-02f, -4.27100584e-02f, -1.68413371e-01f, -1.37755182e-02f, -2.04967204e-02f, 5.39692156e-02f, 5.48849441e-02f, -1.27717435e-01f, -4.50358652e-02f, 3.54396850e-02f,
  -6.41212612e-02f, 6.34698123e-02f, 1.14856288e-01f, -1.90549344e-02f, -5.04737534e-02f, -6.75399750e-02f, -1.55731469e-01f, -5.83265834e-02f, -7.49478489e-02f, 1.69528812e-01f,
  5.48524261e-01f, 8.08577538e-01f, 4.40854162e-01f, -3.81431967e-01f, 1.63372055e-01f, 2.13375166e-01f, 3.60629201e-01f, 1.36099577e-01f, -4.04496044e-01f, 1.39886752e-01f,
  4.17640895e-01f, -5.21074951e-01f, -2.56942898e-01f, -2.12085515e-01f, 1.94060951e-01f, -1.05510689e-01f, -3.62330496e-01f, -1.94739148e-01f, -2.24895179e-01f, -2.90947836e-02f,
  -4.31961566e-01f, -2.12309852e-01f, -1.52442651e-02f, 6.25138283e-02f, -6.08157106e-02f, -5.01657069e-01f, 2.19605744e-01f, 2.82265604e-01f, 3.61293614e-01f, -1.54696479e-01f,
  4.06300098e-01f, 7.55113423e-01f, -3.84000748e-01f, -3.40416461e-01f, 1.11050002e-01f, -6.43028319e-02f, 5.11237793e-02f, 1.11385705e-02f, -9.76152793e-02f, -1.37860894e-01f,
  -5.00698201e-02f, 1.54191807e-01f, -6.34342358e-02f, -1.01567954e-01f, 8.40246603e-02f, 3.87019515e-02f, 4.18559350e-02f, 2.65152343e-02f, -1.17619196e-02f, 9.09686685e-02f,
  -4.35251832e-01f, 1.08515188e-01f, 2.33731806e-01f, -2.35281121e-02f, 2.36892164e-01f, -3.02156001e-01f, 2.77563751e-01f, 2.36431167e-01f, 3.00574958e-01f, 9.53944176e-02f,
  -1.56978354e-01f, 3.15768272e-02f, 1.54829696e-01f, 2.09821947e-02f, -1.32707059e-01f, 2.12060083e-02f, -4.36490327e-02f, -2.80727893e-02f, -8.77310708e-02f, -7.27362838e-03f,
  -8.66041780e-02f, -1.94244627e-02f, -5.51701635e-02f, 1.02557302e-01f, -2.46410653e-01f, -5.87851042e-03f, 3.27637186e-03f, 5.86585253e-02f, 5.32890530e-03f, 3.52218933e-02f,
  1.62910502e-02f, -4.16944139e-02f, 9.00235772e-02f, -1.91226210e-02f, -6.78567290e-02f, -4.76100761e-03f, -1.74065441e-01f, 7.42865130e-02f, 4.74732742e-02f, 9.74947214e-02f,
  -2.89809883e-01f, -1.08576395e-01f, -1.67633817e-02f, -3.51178870e-02f, 5.11704236e-02f, 4.77887355e-02f, -9.34700966e-02f, 1.76973596e-01f, 2.53835380e-01f, 1.32789895e-01f,
  1.13663584e-01f, -1.09787583e-02f, 6.21586964e-02f, -4.43630181e-02f, -2.79007912e-01f, -1.24416478e-01f, -1.09704956e-01f, -4.87904027e-02f, -2.58765191e-01f, -3.26664485e-02f,
  -2.07893059e-01f, -1.07587002e-01f, -4.90275472e-01f, -2.20382750e-01f, -3.79671246e-01f, -5.89587450e-01f, -1.84679970e-01f, -2.17586294e-01f, -1.44805303e-02f, -3.03672165e-01f,
  1.66665033e-01f, -2.19755620e-02f, -5.38565397e-01f, 3.74408305e-01f, 2.45271340e-01f, -4.44596969e-02f, -5.92867315e-01f, -3.06158155e-01f, 2.31689081e-01f, 1.37146682e-01f,
  6.36838615e-01f, 5.86577952e-02f, -4.11922097e-01f, -3.64981115e-01f, -9.18552220e-01f, -8.04786325e-01f, -6.48841381e-01f, -8.95749211e-01f, -6.63099289e-01f, -8.82428735e-02f,
  4.00623411e-01f, 3.06752831e-01f, 3.77981439e-02f, -7.47963786e-02f, 8.77164453e-02f, 3.88013393e-01f, 2.44035259e-01f, 4.55812216e-01f, 2.01854751e-01f, -1.16494045e-01f,
  -1.43820912e-01f, -1.34749427e-01f, 7.41285086e-03f, 1.29487202e-01f, 3.48869652e-01f, -2.45744646e-01f, -9.98388678e-02f, -4.72039096e-02f, 3.71335112e-02f, -1.19315602e-01f,
  1.67301416e-01f, 1.41165137e-01f, -1.19047545e-01f, 1.25826761e-01f, -1.19543619e-01f, -2.90306687e-01f, -4.16275859e-02f, -5.57724655e-01f, -3.26662481e-01f, -3.61605942e-01f,
  1.60979778e-01f, 4.58888933e-02f, -5.02946198e-01f, -7.70044103e-02f, -1.57918334e-01f, -7.69242868e-02f, 7.62633905e-02f, -1.80487428e-02f, -1.46476641e-01f, -1.19068548e-01f,
  1.69435255e-02f, -9.45981517e-02f, 1.55857414e-01f, 2.36143358e-02f, -9.34587419e-02f, 1.61910072e-01f, -4.41917963e-02f, 1.80948172e-02f, -2.65572034e-02f, -8.63009840e-02f,
  4.11419384e-02f, -7.64794350e-02f, -9.04086605e-02f, -1.68572575e-01f, 8.35395381e-02f, 1.01933800e-01f, -7.96826556e-02f, -1.41997576e-01f, -1.26957387e-01f, 1.17713764e-01f,
  -1.03145212e-01f, 1.00348040e-01f, 2.45964840e-01f, 4.89477813e-02f, 5.02082705e-02f, -7.81401992e-02f, -3.76714803e-02f, 6.50231689e-02f, -9.98670235e-02f, 1.10004231e-01f,
  3.31301332e-01f, 1.25969037e-01f, -1.40191242e-01f, -3.18309754e-01f, 3.54515240e-02f, 2.71751851e-01f, 1.93634123e-01f, 8.36859550e-03f, 1.14549011e-01f, -2.79572308e-02f,
  -1.87342897e-01f, -1.39315993e-01f, 1.71761289e-01f, -4.43008579e-02f, -1.33631825e-01f, 1.22416027e-01f, 9.95543152e-02f, -4.16785898e-03f, -4.86386716e-02f, 2.23741919e-01f,
  9.93754119e-02f, -2.38020539e-01f, -2.76554048e-01f, -2.10730538e-01f, 1.85562745e-02f, -2.61906952e-01f, -1.57088473e-01f, 1.29038226e-02f, -1.70018196e-01f, -1.27368048e-01f,
  -6.33927226e-01f, 6.28021777e-01f, 3.39842707e-01f, -3.67394954e-01f, 2.18429312e-01f, 4.08323884e-01f, 7.73448765e-01f, 3.64038706e-01f, -1.88878536e-01f, 1.05035201e-01f,
  2.08735481e-01f, -3.28120768e-01f, -3.80585343e-02f, -1.56070590e-01f, 1.33995965e-01f, 4.30847883e-01f, 2.37769783e-01f, -2.14526534e-01f, -4.63167101e-01f, -3.09278369e-01f,
  -8.02552924e-02f, -1.46527618e-01f, -2.83952683e-01f, -8.47675279e-02f, -5.51118925e-02f, -4.10429507e-01f, 3.69810045e-01f, 1.85292885e-01f, 3.15586120e-01f, -2.28040308e-01f,
  -3.40690017e-01f, 1.33639067e-01f, -1.45406559e-01f, -6.76080585e-02f, 1.98306665e-01f, -4.47287560e-02f, 4.02120352e-02f, 6.25813156e-02f, 7.99844414e-02f, -3.24999504e-02f,
  -4.74709012e-02f, 2.06261384e-03f, 1.35516375e-01f, -2.96027437e-02f, 5.26336990e-02f, 4.84482683e-02f, 1.67820707e-01f, 7.07932189e-02f, 1.10733984e-02f, 9.05764624e-02f,
  1.04026616e-01f, 4.58428413e-02f, 1.88045636e-01f, 2.72532672e-01f, 3.57198387e-01f, -1.09714791e-01f, 1.96660981e-01f, -4.68647741e-02f, 1.20152071e-01f, -1.25462472e-01f,
  3.82889025e-02f, -1.65557340e-02f, 8.91196430e-02f, -1.19648591e-01f, 4.34630178e-03f, -1.54712880e-02f, 7.16002733e-02f, -8.63929763e-02f, 7.51472078e-03f, -1.27010018e-01f,
  1.29260302e-01f, 1.52871730e-02f, -5.31925820e-03f, -3.99715938e-02f, -1.21815158e-02f, 1.91766061e-02f, 2.19881125e-02f, -6.34068623e-02f, -6.59740567e-02f, 7.11165220e-02f,
  -7.88886920e-02f, 1.50471225e-01f, 2.40749568e-02f, 9.17407200e-02f, 1.33104548e-01f, 2.79433392e-02f, -4.78421897e-02f, -4.79786135e-02f, 2.25099619e-03f, 2.54200045e-02f,
  -3.03338081e-01f, 1.40282542e-01f, -1.39433637e-01f, -1.10601429e-02f, -6.03626184e-02f, -4.05540280e-02f, -4.79152799e-02f, -1.82499707e-01f, -1.11234479e-01f, 6.51340326e-03f,
  -9.59560275e-02f, -1.81787401e-01f, 1.85378626e-01f, 3.81223783e-02f, -1.74181312e-01f, -5.42127080e-02f, -1.05995666e-02f, -1.17932327e-01f, -9.29765999e-02f, -6.53413013e-02f,
  7.96010643e-02f, -2.34527245e-01f, -5.33608675e-01f, -1.23590797e-01f, -1.19357966e-01f, -3.75381798e-01f, -1.45977542e-01f, -2.06059560e-01f, -1.44841805e-01f, -1.75369129e-01f,
  -7.02163875e-02f, 2.11883888e-01f, 2.12205052e-01f, 1.25779510e-01f, -1.67398825e-01f, -5.83067417e-01f, -6.35654211e-01f, -3.95789295e-01f, -7.65844584e-02f, -8.49289261e-03f,
  -2.23444119e-01f, -9.36314017e-02f, 6.44278452e-02f, -3.68187204e-02f, -1.22483909e-01f, 1.88978910e-01f, 3.67084295e-01f, 1.36431962e-01f, -4.36519265e-01f, -4.03654039e-01f,
  6.82919249e-02f, 2.04225942e-01f, 1.32349059e-01f, 6.10422380e-02f, 3.93489510e-01f, -1.44672915e-01f, 1.98411405e-01f, 3.84023577e-01f, 1.37406522e-02f, 8.59437883e-01f,
  7.87537917e-02f, 2.33863324e-01f, -2.24202260e-01f, -1.05104111e-02f, 2.33684853e-01f, 3.31484944e-01f, -1.06597916e-04f, 3.54151785e-01f, 1.24642169e-02f, 1.38061360e-01f,
  4.18344922e-02f, 8.30691084e-02f, -6.83652312e-02f, -5.57141341e-02f, -1.34417415e-01f, -2.95280069e-01f, 1.29542470e-01f, 4.69820015e-02f, 1.60658151e-01f, 2.20190510e-02f,
  2.05729991e-01f, -7.94477314e-02f, -2.42009833e-01f, -2.52332211e-01f, 1.10735148e-02f, -2.79701024e-01f, -1.96895435e-01f, 1.00920886e-01f, -3.16410005e-01f, 4.40532506e-01f,
  -3.35244536e-02f, 7.28984922e-02f, 4.73899618e-02f, 6.77316682e-03f, -7.38240108e-02f, -3.68029475e-02f, 1.68407083e-01f, -1.22910373e-01f, 2.01738812e-02f, 1.06878139e-01f,
  -1.08820088e-01f, 2.75295414e-03f, 4.22458686e-02f, 7.34629035e-02f, -8.71866420e-02f, 8.09384882e-03f, -4.29976024e-02f, -4.40224111e-02f, -3.50187905e-02f, -2.82311458e-02f,
  8.50625560e-02f, 7.82058239e-02f, 8.46305490e-02f, 3.97628732e-02f, -6.24897406e-02f, 4.67619635e-02f, 7.36613795e-02f, 2.42523607e-02f, -3.89713012e-02f, 1.15862750e-01f,
  -2.90773809e-02f, -3.13656479e-01f, 1.40746729e-02f, 1.02244079e-01f, 1.00385830e-01f, -9.78551432e-02f, 8.90087709e-02f, -1.07674040e-01f, 1.41805634e-01f, -7.05118477e-02f,
  -1.88980892e-01f, -1.93596676e-01f, 1.58685148e-01f, 5.09891622e-02f, -2.40294009e-01f, -7.23664388e-02f, 7.19320774e-02f, -1.07878901e-01f, -2.41258100e-01f, 7.50805661e-02f,
  2.75304783e-02f, -3.39382470e-01f, -7.25657642e-01f, -2.18543917e-01f, -7.81124309e-02f, -5.00157595e-01f, -3.12963605e-01f, -3.90574396e-01f, -5.31460702e-01f, -4.32231486e-01f,
  -9.91756797e-01f, 1.55025095e-01f, 4.73304957e-01f, -6.94577515e-01f, -2.04797179e-01f, 2.50885133e-02f, -2.36407411e-03f, -2.76315987e-01f, -5.30810177e-01f, -1.69551391e-02f,
  1.30237237e-01f, 5.31422272e-02f, 9.80037451e-02f, 4.94756922e-02f, -1.28744543e-01f, 5.99625036e-02f, -4.66566741e-01f, -2.95270711e-01f, -1.73871201e-02f, 1.73402354e-01f,
  -7.94337466e-02f, -3.43301773e-01f, -4.77782875e-01f, -1.41625822e-01f, 3.34271267e-02f, -1.90071911e-01f, -1.63362145e-01f, -3.08959842e-01f, 2.06931859e-01f, -4.72238332e-01f,
  7.76639223e-01f, -2.57268757e-01f, 1.78050339e-01f, -2.21091628e-01f, 1.53919667e-01f, 8.60454813e-02f, 3.91839538e-03f, -1.21491440e-01f, 5.17699048e-02f, 6.14133105e-02f,
  3.14403139e-02f, 7.50999302e-02f, -9.91380773e-03f, 1.32027939e-01f, -5.91342486e-02f, 6.34796917e-02f, 4.03809510e-02f, -1.22491375e-01f, 6.89165145e-02f, 4.29535627e-01f,
  1.70658872e-01f, -5.17842732e-02f, 2.13983059e-02f, 2.03906208e-01f, 1.69190481e-01f, -6.41689375e-02f, 2.97237426e-01f, 7.40788579e-02f, 1.02968104e-01f, -1.45412758e-01f,
  1.19087517e-01f, -1.19185250e-03f, 1.25005431e-02f, -3.12471073e-02f, 1.94732416e-02f, 1.02525577e-01f, 3.78715689e-03f, -3.34602743e-02f, -1.26709431e-01f, -2.90623307e-03f,
  4.28244211e-02f, 9.62703899e-02f, 3.13981958e-02f, -6.84208274e-02f, 1.93814725e-01f, -4.59023602e-02f, -1.05140075e-01f, 9.95852426e-02f, 1.56387478e-01f, -8.37600529e-02f,
  -1.19577833e-01f, -6.23459108e-02f, 2.19995920e-02f, 1.15535036e-01f, -5.96249476e-02f, 3.28801945e-02f, 1.12597182e-01f, -6.20027222e-02f, -1.74965877e-02f, -5.45423217e-02f,
  1.82626061e-02f, -6.60083890e-02f, -1.85316373e-02f, -8.76622200e-02f, -1.36880323e-01f, 7.91940615e-02f, 6.02603517e-02f, -5.23412153e-02f, -2.98665427e-02f, 6.88904598e-02f,
  -8.59090220e-03f, 1.30217820e-01f, 1.20562032e-01f, 8.82772878e-02f, 3.71396281e-02f, 1.06063232e-01f, -1.00536317e-01f, -7.08453283e-02f, 1.44003350e-02f, 9.60283056e-02f,
  7.40508661e-02f, -1.46241384e-02f, -1.18129291e-01f, 6.01643771e-02f, 1.92652345e-02f, -1.39466479e-01f, 2.32465476e-01f, 7.89267123e-02f, -1.89232975e-01f, -9.09961835e-02f,
  -5.96928716e-01f, 7.22256899e-01f, -3.33422571e-01f, -4.62679952e-01f, -5.18822074e-01f, -1.87826436e-02f, 2.52054840e-01f, 2.58923292e-01f, 9.31768343e-02f, 2.40818888e-01f,
  2.72801965e-01f, -2.87656724e-01f, -2.93768793e-01f, 9.41976309e-02f, 3.52804847e-02f, 9.20753926e-03f, -6.18296385e-01f, -7.24479795e-01f, -4.57489491e-01f, -2.32946947e-01f,
  -1.42950043e-01f, -2.32443824e-01f, -3.63847464e-01f, -1.93252757e-01f, -8.02332237e-02f, 1.03582619e-02f, -2.14933187e-01f, -3.35498244e-01f, -2.36318838e-02f, -5.48759997e-01f,
  -7.22552165e-02f, -3.90128344e-01f, -1.13449730e-01f, -6.74697012e-02f, 8.04003403e-02f, -1.27707303e-01f, -3.46319079e-02f, -6.65983632e-02f, 1.54796332e-01f, 2.03337327e-01f,
  -4.13857073e-01f, 9.42345187e-02f, -5.71470797e-01f, -2.78582394e-01f, -1.49243146e-01f, -1.16895035e-01f, 2.08229851e-03f, -9.05863754e-03f, -9.52610839e-03f, 8.02217498e-02f,
  -2.04172850e-01f, -3.57064396e-01f, -1.86765328e-01f, 1.73617795e-01f, 1.15778148e-01f, -2.49254704e-01f, 3.10985565e-01f, 1.23185508e-01f, 1.23062983e-01f, 5.22057354e-01f,
  2.51857579e-01f, 1.52075097e-01f, -4.50781435e-02f, -1.71624012e-02f, 5.33494614e-02f, -5.80173582e-02f, 2.76172981e-02f, -4.54162760e-03f, -1.09690391e-01f, 8.80728662e-02f,
  6.67867288e-02f, 7.18873516e-02f, -5.19451536e-02f, -1.61045447e-01f, -9.60154086e-02f, -1.82472393e-02f, -6.17527477e-02f, 1.88853770e-01f, -1.38673857e-01f, -3.37756090e-02f,
  -5.89240044e-02f, -1.31601291e-02f, -1.10016547e-01f, 1.09162457e-01f, 9.21626464e-02f, -1.55986268e-02f, -1.63397640e-01f, -9.48452502e-02f, -4.46427502e-02f, -1.97561786e-01f,
  3.15880418e-01f, -1.32061169e-01f, 4.99504153e-03f, 8.44640657e-02f, -1.88842788e-01f, -3.38252634e-02f, 4.05668048e-03f, 4.15237397e-02f, -6.95342645e-02f, 1.49611775e-02f,
  -1.23023085e-01f, 1.08394504e-01f, 4.69545387e-02f, 6.73681349e-02f, -1.56686440e-01f, -4.42585424e-02f, 1.78265318e-01f, -4.82820207e-03f, 1.75365154e-02f, 1.02827616e-01f,
  6.07155561e-02f, -4.60195579e-02f, -6.09081192e-03f, 4.91307862e-02f, -5.07441387e-02f, -2.78617203e-01f, 4.29900810e-02f, 7.99533054e-02f, 9.39914025e-03f, 8.34016562e-01f,
  9.63411152e-01f, -4.66657400e-01f, 7.41494372e-02f, -2.18626052e-01f, -2.94624656e-01f, -9.99877229e-02f, -4.80604768e-01f, -2.83187926e-01f, 6.94982782e-02f, -4.83286828e-02f,
  -2.37041175e-01f, -4.92333807e-02f, 2.57108569e-01f, 1.52565330e-01f, 1.45375639e-01f, -1.72753438e-01f, 9.28490162e-02f, 5.13482213e-01f, 1.19232185e-01f, -6.76241100e-01f,
  -3.38808149e-01f, -1.45708278e-01f, 4.02646154e-01f, -1.73507020e-01f, -8.69766414e-01f, -8.95275846e-02f, 5.01100905e-02f, -2.17411205e-01f, -2.67274886e-01f, -2.86078125e-01f,
  -1.01832308e-01f, -6.01516843e-01f, -6.75308853e-02f, 6.75078407e-02f, -1.62530720e-01f, -9.61097032e-02f, -1.46265239e-01f, -1.25011310e-01f, 7.87164178e-03f, 1.52706563e-01f,
  -1.78374454e-01f, 5.22034168e-02f, 5.21913655e-02f, -1.24298491e-01f, -1.74852684e-01f, -2.24538043e-01f, -9.17280987e-02f, 1.31026013e-02f, 2.74477471e-02f, -7.95156881e-02f,
  -1.46462992e-01f, -1.17542006e-01f, 6.73969015e-02f, 1.29163116e-01f, -1.02121122e-01f, 1.63047656e-01f, -2.56539702e-01f, -2.62319356e-01f, 1.60378695e-01f, -1.68157592e-01f,
  8.90732184e-02f, 1.36893883e-01f, -3.15214321e-02f, -6.48550317e-03f, -4.38454468e-03f, 1.37673438e-01f, 1.47572771e-01f, 5.12569882e-02f, -9.68014374e-02f, 2.94304965e-03f,
  5.74999824e-02f, -6.25299755e-03f, -5.00583276e-02f, 2.56867856e-02f, 6.83272257e-02f, -4.12229449e-02f, 9.71287787e-02f, -1.10007845e-01f, -3.69815826e-02f, 4.00052406e-02f,
  -1.12597644e-01f, -1.74587369e-02f, 2.02344060e-01f, -1.46903291e-01f, 6.94425479e-02f, 2.70074569e-02f, -2.13082135e-02f, 4.99147251e-02f, -5.70537560e-02f, -8.62466991e-02f,
  3.34079832e-01f, 3.42057198e-01f, 9.35201719e-03f, -3.06694865e-01f, -3.13301897e-03f, 3.22328880e-02f, 2.98795644e-02f, 4.55556065e-02f, 9.49332193e-02f, 4.91819717e-02f,
  -2.81842470e-01f, 1.18935287e-01f, 1.10703692e-01f, -7.56602511e-02f, -1.66189134e-01f, 1.33340642e-01f, -7.08344281e-02f, 2.02663075e-02f, -9.44080874e-02f, -2.64929205e-01f,
  9.98893529e-02f, 1.56055927e-01f, 3.93880904e-01f, 2.73072481e-01f, -9.33373570e-02f, 2.88158119e-01f, 1.43597811e-01f, -2.68580411e-02f, 3.34818691e-01f, 5.11907339e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -2.73199737e-01f, 4.02113795e-01f, 1.59119859e-01f, 4.22375381e-01f, 4.06569541e-01f, 2.42245600e-01f, 8.51751268e-01f, 2.92396218e-01f, 5.86198449e-01f, 1.04257655e+00f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.32650852e-01f, -1.49694294e-01f, 1.79966688e-01f, -3.63234013e-01f, -3.35259782e-03f, 1.50759026e-01f, 1.89636648e-01f, -3.30782771e-01f, 3.37310284e-01f, -4.71149921e-01f,
  3.56003404e-01f, -3.77013206e-01f, 2.15227902e-02f, 2.17923224e-02f, 3.79078925e-01f, -3.12577993e-01f, -9.15189385e-02f, -2.64054120e-01f, 3.12729537e-01f, -1.98280767e-01f,
  2.51167081e-03f, -3.59039344e-02f, -3.00329626e-01f, -3.01053286e-01f, 1.74254909e-01f, -2.76221037e-01f, 2.78839827e-01f, -7.06654668e-01f, 6.03818834e-01f, -4.69141603e-02f,
  1.74783200e-01f, -2.72048950e-01f, -1.34878904e-01f, 5.62600195e-02f, -4.79831286e-02f, -9.32950601e-02f, -2.25890636e-01f, 8.09490755e-02f, -2.82268137e-01f, 1.00935131e-01f,
  -4.85216975e-01f, 3.41001712e-02f, -1.14143863e-01f, 7.74733663e-01f, 1.20950155e-01f, 2.24723876e-01f, 1.04660168e-01f, -5.95142283e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.70810425e-01f, 1.76234052e-01f, 4.79363441e-01f, -6.66121662e-01f, -6.74753010e-01f, -2.02804990e-02f, -2.48748079e-01f, -5.54619133e-01f, 1.77362517e-01f, 9.08638537e-01f,
  2.65245885e-01f, 5.76485515e-01f, 1.08366883e+00f, 6.08397759e-02f, -7.38068521e-02f, 2.64820959e-02f, 1.91336006e-01f, 2.21406743e-01f, -2.40655333e-01f, 3.47984552e-01f,
  4.71110761e-01f, -2.51151711e-01f, 3.25397462e-01f, -1.41017303e-01f, 6.11958146e-01f, -2.48807684e-01f, 1.51166275e-01f, 3.35447878e-01f, 1.42866671e-01f, -7.72046149e-01f,
  5.89427203e-02f, 4.93407875e-01f, 6.37146473e-01f, 8.53532672e-01f, 6.45779610e-01f, -9.40837145e-01f, 3.10275614e-01f, 2.73969799e-01f, -3.53553087e-01f, -8.95005703e-01f,
  -3.37913692e-01f, -2.79942423e-01f, -3.34400944e-02f, -3.94122124e-01f, 2.47822180e-01f, 3.58787835e-01f, 4.44587052e-01f, 2.56106615e-01f, 5.62267303e-01f, 3.81598711e-01f,
  5.78806221e-01f, -1.16369009e-01f, -7.43465349e-02f, -1.87243689e-02f, -3.63770276e-01f, 1.93377763e-01f, -3.93961370e-01f, 2.06815422e-01f, 6.17266476e-01f, -7.93734372e-01f,
  1.02116227e+00f, 1.56626374e-01f, 6.42176151e-01f, 3.73422444e-01f, 9.92760509e-02f, 3.22137326e-01f, -4.42363232e-01f, 4.84109998e-01f, -8.58466178e-02f, 3.68680097e-02f,
  5.55110574e-02f, 8.19782197e-01f, -5.99187970e-01f, -1.30339161e-01f, -4.79245573e-01f, 4.97309923e-01f, 6.24378026e-01f, 1.29594086e-02f, 2.41652831e-01f, 5.77764809e-01f,
  5.14543474e-01f, 8.69029343e-01f, 1.51266739e-01f, 1.95724487e-01f, -2.06665248e-01f, 6.16111457e-02f, -1.26123559e-02f, -1.38764262e-01f, -1.34775108e-02f, -6.90453649e-01f,
  4.68366355e-01f, 1.37634486e-01f, 8.03690851e-01f, -5.07872045e-01f, -1.50322422e-01f, 8.46836269e-01f, -1.12440862e-01f, -1.39951119e-02f, -5.54543063e-02f, -3.17162752e-01f,
  -2.47770734e-02f, 4.09213960e-01f, 1.31973177e-02f, 5.34017265e-01f, 3.65942627e-01f, 7.17406154e-01f, 7.49175847e-01f, 3.17372710e-01f, -3.21123809e-01f, 2.77372599e-01f,
  5.69392145e-01f, -5.69853127e-01f, 2.83470094e-01f, 1.81575432e-01f, 3.63277465e-01f, 4.53292876e-01f, 8.27246606e-01f, -1.71756893e-01f, -1.02949843e-01f, 7.33394265e-01f,
  7.96858013e-01f, -1.06672500e-03f, 7.32161939e-01f, -6.45468295e-01f, 2.69134492e-01f, 2.10788772e-01f, 5.11372626e-01f, 8.41306988e-03f, 2.27891520e-01f, 3.32907349e-01f,
  3.57780188e-01f, 5.89411438e-01f, 2.41038531e-01f, -3.49184930e-01f, -5.16947694e-02f, 1.10487020e+00f, -2.42314011e-01f, 1.06176829e+00f, 4.50962543e-01f, 1.00525153e+00f,
  2.82171249e-01f, 5.91885924e-01f, 9.21365917e-01f, 4.00312960e-01f, 5.28505325e-01f, 3.71435106e-01f, 4.29341882e-01f, 4.65021282e-03f, 3.18468153e-01f, 1.85278729e-02f,
  -8.61997679e-02f, -2.97294497e-01f, 5.19296825e-01f, -1.40546337e-01f, 9.17499602e-01f, 4.22474474e-01f, -1.23700850e-01f, -2.23745666e-02f, 8.59918773e-01f, 1.04839873e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.28164822e-01f, -1.04862690e-01f, 2.49522537e-01f, 3.14046472e-01f, 3.66940558e-01f, 4.42478716e-01f, -3.21697176e-01f, 5.22970408e-03f, -3.05107012e-02f, 5.89160956e-02f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.16447318e-02f, -4.29443689e-03f, -4.87359047e-01f, 1.67257786e-01f, 5.08450687e-01f, -2.31988147e-01f, -2.21303955e-01f, 1.43706381e-01f, 9.42924172e-02f, 2.64322907e-01f,
  -1.53534010e-01f, -2.99134076e-01f, -4.36341725e-02f, 2.00274989e-01f, 4.57672477e-02f, -1.11590065e-01f, -4.44084525e-01f, -2.29930684e-01f, -6.95105076e-01f, -3.45960319e-01f,
  -5.55877268e-01f, -7.12102428e-02f, -1.97940916e-01f, -2.04624906e-01f, 7.39082545e-02f, 1.34464353e-01f, 3.72535661e-02f, -2.19941691e-01f, -3.92009288e-01f, -1.69908032e-01f,
  1.98700994e-01f, 2.19339117e-01f, 1.08997986e-01f, -1.16380863e-01f, -1.13875009e-01f, 5.69578886e-01f, -7.67860562e-02f, -1.46740675e-01f, -2.98452288e-01f, -4.09007788e-01f,
  -1.14937527e-02f, 4.09083992e-01f, 3.95198345e-01f, -4.00434852e-01f, 3.17980014e-02f, 6.41287491e-02f, 1.01938426e-01f, -2.37488508e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.53019476e-01f, -1.62652448e-01f, 1.11551672e-01f, 3.16101193e-01f, -8.39630812e-02f, -1.72461104e-02f, -4.98954028e-01f, -1.20682444e-03f, 8.18707645e-01f, 7.92289376e-01f,
  -3.45309049e-01f, 5.26912808e-01f, 3.29322845e-01f, 4.00376439e-01f, 4.02976930e-01f, 8.10817122e-01f, -3.53381485e-01f, 7.21102282e-02f, -1.05980843e-01f, 1.46270683e-02f,
  -6.30808547e-02f, -5.99401928e-02f, 7.86844730e-01f, -9.48630929e-01f, 9.46522504e-02f, 5.59296191e-01f, -2.63937190e-02f, -7.88798511e-01f, 6.87170267e-01f, 4.47950125e-01f,
  9.87679720e-01f, -1.65989354e-01f, -1.52526855e-01f, -2.44838461e-01f, -1.21386595e-01f, -5.83487153e-01f, -2.35962912e-01f, 1.31368852e+00f, 7.93822885e-01f, -6.79654896e-01f,
  -1.10998189e+00f, 1.29421905e-01f, 6.99212730e-01f, 2.40519449e-01f, -2.07439542e-01f, -3.66311014e-01f, 4.88683850e-01f, 5.66317886e-02f, -3.22013348e-01f, 2.20596462e-01f,
  -2.02148974e-01f, 2.65552491e-01f, 6.21474504e-01f, -9.06813741e-02f, -5.56155443e-01f, 2.89163917e-01f, -3.04910928e-01f, 1.35229841e-01f, 2.08063677e-01f, 3.90120387e-01f,
  3.57955933e-01f, 8.11063230e-01f, 5.39687455e-01f, 7.30929315e-01f, 5.15660703e-01f, 7.51877189e-01f, 9.54637229e-01f, 3.56980652e-01f, 1.05524921e+00f, 1.06804669e+00f,
  9.81876552e-01f, -1.58891380e-01f, 1.08052707e+00f, 8.03366780e-01f, 1.37277588e-01f, 6.83787882e-01f, -2.35736877e-01f, -2.04360843e-01f, -3.70564878e-01f, 1.84226528e-01f,
  1.88569129e-01f, 3.78903985e-01f, -1.54328734e-01f, -3.18752408e-01f, -1.94412231e-01f, 4.06760782e-01f, 2.68003345e-01f, 2.76752770e-01f, 3.43348086e-01f, -2.11405322e-01f,
  1.49262309e-01f, -2.18284681e-01f, 1.05786603e-02f, -1.96220279e-01f, 2.06184223e-01f, 4.52843010e-01f, 2.54431576e-01f, -2.34080032e-01f, -3.47207099e-01f, 8.20785642e-01f,
  5.81171274e-01f, -1.33514965e+00f, 6.62196338e-01f, 4.93625104e-01f, -7.48772800e-01f, 3.65427509e-02f, -4.69745994e-01f, 4.42209750e-01f, 4.04040337e-01f, 5.78864753e-01f,
  5.15798740e-02f, 3.35374147e-01f, -1.44049764e-01f, -2.49896854e-01f, -2.06440449e-01f, -6.18801594e-01f, 3.81831586e-01f, 2.91087806e-01f, 1.08259881e+00f, -4.72956263e-02f,
  1.13512009e-01f, -4.81479801e-02f, 1.40189856e-01f, 1.64902329e-01f, 2.15114176e-01f, -7.43405044e-01f, 7.84426853e-02f, -3.62429410e-01f, 2.84627110e-01f, 1.71854498e-03f,
  3.04748416e-01f, -3.35996419e-01f, -6.58207893e-01f, -1.89382046e-01f, 3.19857180e-01f, 1.47115931e-01f, -7.82723784e-01f, 1.24396764e-01f, 7.21243858e-01f, 8.24160576e-01f,
  -8.29404831e-01f, 7.09303692e-02f, 1.62207440e-01f, -5.01979530e-01f, 9.72752497e-02f, -6.72393739e-01f, -9.82611716e-01f, -3.69142324e-01f, -9.04781163e-01f, -2.12301195e-01f,
  -4.31164742e-01f, 3.36494505e-01f, -8.05019677e-01f, -2.18373835e-01f, 8.26915264e-01f, -8.09407160e-02f, 1.59543648e-01f, 8.45300406e-02f, 3.91979039e-01f, -4.20533419e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -3.26009886e-03f, -9.54048522e-03f, 1.97987668e-02f, -3.98623258e-01f, 3.27749908e-01f, -1.31025359e-01f, -1.79240517e-02f, 1.38005793e-01f, 3.04671735e-01f, -1.22964419e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.12249333e-01f, -2.22242713e-01f, -3.81856680e-01f, -7.17549503e-01f, 1.72830690e-02f, 6.80367470e-01f, 2.90893555e-01f, 2.44203508e-01f, -9.50161934e-01f, 9.85291377e-02f,
  -1.06780005e+00f, -4.61151809e-01f, -9.89398509e-02f, -5.25940597e-01f, -6.15257680e-01f, 2.73259073e-01f, 2.12510437e-01f, 2.17730075e-01f, 4.48270142e-01f, -1.68237649e-02f,
  8.51887405e-01f, -4.49258089e-01f, 1.66180730e-01f, -8.21169615e-01f, -6.12165809e-01f, 1.95530549e-01f, -8.80178630e-01f, 3.66799608e-02f, 3.97510976e-01f, -2.05705643e-01f,
  1.37590170e-01f, 6.00259483e-01f, 1.85182035e-01f, 1.64713055e-01f, 4.49167751e-02f, -2.56227046e-01f, 5.89005947e-01f, 1.34386098e+00f, 1.50728643e-01f, 1.38608739e-01f,
  3.87314975e-01f, -5.82735166e-02f, -1.92739993e-01f, -6.16765082e-01f, -3.38297069e-01f, -8.10674012e-01f, 5.42504609e-01f, -2.81934768e-01f, -6.77920461e-01f, 2.79018916e-02f,
  -1.16505456e+00f, 7.47066513e-02f, 1.01458299e+00f, 2.19904095e-01f, 1.04140274e-01f, 4.14722592e-01f, 2.82585174e-01f, -5.46193635e-03f, -1.01584685e+00f, 1.53401703e-01f,
  -6.44032121e-01f, -4.54613298e-01f, -8.71125042e-01f, 3.30119103e-01f, 2.67302711e-03f, -5.90833306e-01f, -2.86581963e-01f, 6.37260437e-01f, -1.30424571e+00f, 3.43681633e-01f,
  -3.53840888e-02f, 1.62829578e-01f, 2.15284243e-01f, 2.66091585e-01f, 1.70628366e-03f, -5.55668846e-02f, -6.10239953e-02f, -5.88158250e-01f, -5.67206025e-01f, -4.72464085e-01f,
  8.28541592e-02f, 3.42243388e-02f, 3.75676781e-01f, 8.56898367e-01f, -1.01770975e-01f, -7.23435283e-01f, 3.48667502e-01f, -7.53031135e-01f, -1.38844514e+00f, 3.64598334e-01f,
  6.01218045e-02f, 1.61649622e-02f, 4.41849232e-01f, -2.55407959e-01f, -8.45843077e-01f, -7.97081172e-01f, 6.12639129e-01f, 3.50121379e-01f, 2.59032726e-01f, -1.98326603e-01f,
  -5.79320610e-01f, -2.08803684e-01f, -8.95195603e-01f, 9.12642702e-02f, 9.04752910e-02f, -1.25001395e+00f, 5.98276377e-01f, -3.46856594e-01f, -1.37133911e-01f, 4.18306172e-01f,
  5.55466056e-01f, -4.58778352e-01f, -3.00443143e-01f, 4.04077262e-01f, -1.64419383e-01f, -2.73883879e-01f, 1.52289554e-01f, -1.20633483e-01f, -5.88707328e-01f, -9.58327234e-01f,
  7.17245817e-01f, -4.76159245e-01f, -9.48361978e-02f, -3.78471985e-02f, -2.96544023e-02f, 3.57047617e-01f, 6.22313619e-01f, 2.85998881e-01f, -4.23771232e-01f, 8.59667003e-01f,
  1.05362430e-01f, -1.17568994e+00f, -3.69118840e-01f, -7.17213929e-01f, 4.96133000e-01f, -1.36600173e+00f, -2.82490999e-01f, -4.75567222e-01f, 8.62857878e-01f, 3.02900195e-01f,
  -1.02719915e+00f, -3.92085612e-01f, -4.97831702e-02f, -5.56510277e-02f, 5.83968461e-01f, -9.89875376e-01f, 1.01129681e-01f, -1.85561597e-01f, -3.39266211e-01f, 3.97155225e-01f,
  9.28230882e-02f, -1.87873706e-01f, -2.67587781e-01f, -4.95949745e-01f, 4.74123925e-01f, -1.09796989e+00f, 7.55549848e-01f, -1.18894890e-01f, 1.68766826e-01f, -1.21532440e+00f,
  -1.62646472e-01f, -2.66948819e-01f, -7.00552464e-01f, 5.77510297e-01f, 1.28576863e+00f, 4.93300289e-01f, 3.58713478e-01f, 1.97907314e-01f, -4.42090839e-01f, 4.43162723e-03f,
  4.10759181e-01f, 1.43004924e-01f, -1.41452968e+00f, -5.78024030e-01f, -7.38637626e-01f, -6.12041771e-01f, 4.88090562e-03f, -9.42469016e-02f, -9.29924399e-02f, -3.74922186e-01f,
  2.94982791e-01f, -7.16998100e-01f, -4.86076802e-01f, 7.54338443e-01f, 3.99523497e-01f, -9.17694628e-01f, -6.00766957e-01f, 3.20321649e-01f, -2.12824177e-02f, 2.83217639e-01f,
  -3.22397619e-01f, -4.52368081e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.46786898e-01f, -3.50571610e-02f, 1.62845999e-01f, -4.38048661e-01f, -1.52027369e-01f, -2.75526226e-01f, 1.94971085e-01f, 1.52664721e-01f, 2.56304145e-01f, -2.71873236e-01f,
  -4.17673469e-01f, -8.33604634e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    