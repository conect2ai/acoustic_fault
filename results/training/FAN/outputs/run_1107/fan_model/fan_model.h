/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.61158040e-02f, -3.62107217e-01f, 3.58415008e-01f, 2.20236070e-02f, -2.86384765e-02f, -8.94974023e-02f, -1.89353764e-01f, -1.02115676e-01f, 2.86211781e-02f, -7.96765909e-02f,
  -2.81680703e-01f, -1.23355336e-01f, 2.18785182e-02f, 2.59553920e-02f, 6.29499853e-02f, 8.16821828e-02f, 2.59229451e-01f, 3.24074388e-01f, 3.07561785e-01f, 8.05359334e-02f,
  4.25246805e-02f, 1.33887485e-01f, 6.94146752e-02f, 1.96667150e-01f, 9.11302418e-02f, 1.02355316e-01f, 5.04865795e-02f, -1.20091895e-02f, -3.37202959e-02f, 3.05598199e-01f,
  1.91120282e-01f, -1.26118705e-01f, 6.88174069e-02f, 2.86329128e-02f, 5.10328263e-02f, 7.01834857e-02f, 1.30024562e-02f, 1.00136168e-01f, 3.48109640e-02f, 2.78687924e-02f,
  -1.25108445e-02f, -3.81562039e-02f, -1.36467926e-02f, 9.03599113e-02f, 3.31433937e-02f, -1.11960266e-02f, -2.85875630e-02f, 5.07220514e-02f, 3.29953060e-02f, 5.22904508e-02f,
  -1.04235848e-02f, 2.04711757e-03f, -2.19339337e-02f, -8.99129733e-02f, -4.32098508e-02f, 1.73600972e-01f, -5.07722832e-02f, 1.31791577e-01f, 1.63723737e-01f, 6.71277344e-02f,
  1.97995808e-02f, -9.00784731e-02f, 7.63866724e-03f, 8.58510146e-04f, -1.37027144e-01f, 9.44472663e-03f, -7.48587549e-02f, -8.83926898e-02f, 5.27902395e-02f, -9.25110560e-03f,
  -3.88270728e-02f, -3.63414548e-02f, -3.51802744e-02f, 3.78362201e-02f, 4.95836027e-02f, 7.03220591e-02f, -3.36752757e-02f, -4.46094275e-02f, 4.40919176e-02f, -6.67691678e-02f,
  -1.84815247e-02f, -2.27929521e-02f, -4.98386472e-02f, 3.07692178e-02f, -5.82491159e-02f, 5.22293001e-02f, 6.77859634e-02f, -1.00467727e-01f, -1.07888311e-01f, -5.92708122e-03f,
  -9.49635804e-02f, 6.64262846e-02f, 1.22829154e-01f, -1.53606366e-02f, 9.03800428e-02f, 4.62594256e-02f, 7.03689158e-02f, 1.34768933e-01f, -1.54859228e-02f, 5.19360453e-02f,
  2.00772621e-02f, 3.51959467e-02f, -3.74621414e-02f, 2.50841528e-02f, 1.31535113e-01f, 6.21201918e-02f, -9.65515897e-02f, 1.67938188e-01f, 1.96818542e-02f, -1.76280886e-02f,
  -8.18490982e-02f, -1.30140157e-02f, 3.12341228e-02f, 8.62643197e-02f, 5.59231173e-03f, 9.16556865e-02f, 8.88102278e-02f, 5.40364981e-02f, 9.27154869e-02f, 3.36902216e-02f,
  -1.87452897e-01f, 1.52531147e-01f, -1.27472192e-01f, -9.53154340e-02f, -8.56887475e-02f, -4.19687256e-02f, 4.36610132e-02f, 5.26390150e-02f, 2.17769537e-02f, 8.33579339e-03f,
  3.68140750e-02f, 2.14919746e-02f, -1.20820813e-01f, -9.52823758e-02f, -2.74541322e-03f, -1.17762715e-01f, -1.91201046e-01f, -1.51400000e-01f, -2.35745698e-01f, -4.99131605e-02f,
  -1.28981277e-01f, -1.19071797e-01f, -2.28919074e-01f, -1.81075677e-01f, -1.76157966e-01f, -1.40448928e-01f, -6.18228093e-02f, -7.02678338e-02f, -5.69953807e-02f, -1.82465568e-01f,
  -1.18848048e-01f, -2.28348151e-01f, -1.17737271e-01f, 2.33171061e-02f, -1.59849674e-01f, -2.78774705e-02f, -1.29807442e-01f, -1.05406187e-01f, -6.96154833e-02f, -6.28117695e-02f,
  -9.58114192e-02f, -1.19389564e-01f, -9.25433934e-02f, -2.54779756e-02f, -1.74503595e-01f, -2.77725831e-02f, -9.82058123e-02f, -1.47100195e-01f, -1.29212275e-01f, -1.64140353e-03f,
  -5.65817095e-02f, -2.03605980e-01f, -1.68004781e-01f, -1.00045100e-01f, -1.19273335e-01f, -1.01995051e-01f, -1.90795377e-01f, -1.55511871e-01f, -1.63705871e-01f, -7.90623203e-02f,
  -9.52968225e-02f, 8.97056330e-03f, -4.13645953e-02f, 1.02813341e-01f, 4.43836339e-02f, 4.77057323e-02f, 1.87521148e-02f, 3.78370890e-03f, 5.43365963e-02f, 5.83021902e-02f,
  9.98764858e-02f, 4.57076877e-02f, -9.79887089e-04f, 4.47445251e-02f, -3.64430696e-02f, 1.26592265e-02f, 9.16244313e-02f, 1.22491784e-01f, 6.09686710e-02f, -1.12455664e-02f,
  9.54548791e-02f, 2.88292728e-02f, 7.42738228e-03f, 7.18489885e-02f, 2.87603978e-02f, 4.08070860e-03f, 1.10671386e-01f, 1.49836525e-01f, 3.59287001e-02f, 4.80697416e-02f,
  1.47634327e-01f, -1.23370238e-01f, -3.21189724e-02f, -5.67856915e-02f, -1.03229389e-01f, -5.67185208e-02f, -5.60617931e-02f, 2.74675246e-02f, -1.27744228e-01f, -8.35975856e-02f,
  -1.03455342e-01f, -3.60570513e-02f, -8.11780095e-02f, -5.87694421e-02f, -7.25637050e-03f, -1.13896973e-01f, -7.47771561e-02f, -4.22546491e-02f, -2.72535887e-02f, 2.92317793e-02f,
  3.69594619e-02f, 4.66375016e-02f, -3.64280120e-02f, 3.44037190e-02f, -1.25786886e-01f, -1.07832532e-02f, -3.06882728e-02f, 4.31919321e-02f, -2.01427788e-02f, 1.73088357e-01f,
  -3.03967953e-01f, 1.21994942e-01f, 4.53946255e-02f, -1.02713391e-01f, 5.79695329e-02f, 3.43342423e-02f, 1.86962754e-01f, 5.92311239e-03f, -2.25745123e-02f, 1.71162367e-01f,
  2.11750731e-01f, 1.59976661e-01f, 1.00387409e-01f, 1.97242156e-01f, 7.21660256e-02f, 1.04547359e-01f, 7.67697915e-02f, -1.25630736e-01f, 2.48465929e-02f, -3.16310761e-04f,
  -1.28228795e-02f, -1.10871457e-01f, -2.56195903e-01f, 8.74543097e-03f, 4.35718335e-02f, 1.29031569e-01f, 8.65415931e-02f, -1.06922545e-01f, 1.52977809e-01f, 1.02645382e-01f,
  1.18999004e-01f, -2.09613159e-01f, -2.97106374e-02f, -5.94734661e-02f, -2.95124855e-02f, 3.69544365e-02f, -1.46624651e-02f, -3.99022587e-02f, 3.83846276e-02f, -5.16166948e-02f,
  -2.06356067e-02f, -7.03942776e-02f, -6.39164597e-02f, 7.50092268e-02f, -5.23520028e-03f, -1.03440620e-01f, 3.92187014e-02f, 1.52360937e-02f, 2.61800922e-02f, 1.02637619e-01f,
  1.80168107e-01f, -7.32001960e-02f, -1.11304827e-01f, 1.36529103e-01f, 1.02458373e-01f, -9.02184024e-02f, 9.90708917e-03f, 7.44606853e-02f, -6.25020117e-02f, 3.23414169e-02f,
  -5.66670205e-04f, -2.22635511e-02f, 3.65232676e-02f, -3.81486304e-02f, -3.28622456e-03f, 4.61225919e-02f, 9.49837081e-03f, -1.15354508e-02f, 2.55593639e-02f, -7.00972155e-02f,
  1.50443939e-02f, -2.14572456e-02f, 3.49733769e-03f, 4.44767810e-02f, 1.11469656e-01f, -5.43699637e-02f, -1.15099875e-02f, 6.79785386e-02f, -2.05714963e-02f, -1.07683212e-01f,
  -1.15947686e-02f, 3.09413783e-02f, 9.23041534e-03f, -9.72376671e-03f, 8.90845992e-03f, 5.53093962e-02f, -6.87666098e-03f, 5.73888719e-02f, -7.76932463e-02f, -1.18104666e-01f,
  -1.98226385e-02f, -9.89298150e-03f, -8.11322257e-02f, -5.16007170e-02f, 3.89922857e-02f, 2.67697386e-02f, 9.39460248e-02f, 3.89420055e-03f, -2.97069084e-02f, -7.23797083e-02f,
  1.14005040e-02f, -7.38420850e-03f, 5.32879792e-02f, 4.42298800e-02f, 4.73002763e-03f, -4.72846478e-02f, 8.54216367e-02f, -3.23192179e-02f, 2.95185633e-02f, 8.78599435e-02f,
  3.93463299e-02f, 2.70358436e-02f, -9.66860130e-02f, 7.41527081e-02f, -7.92348683e-02f, -1.46266734e-02f, 2.64749043e-02f, -7.26775751e-02f, -2.06737686e-02f, 1.70836076e-02f,
  3.65998864e-01f, -1.18869066e-01f, -9.22268629e-02f, 1.24543354e-01f, -4.17055301e-02f, -3.57815884e-02f, -2.40879238e-01f, -1.74155429e-01f, 2.69174110e-03f, -6.19052118e-03f,
  1.59760863e-01f, 2.65949637e-01f, 2.24236734e-02f, 3.63139585e-02f, -1.84054360e-01f, -1.64487526e-01f, -3.08656633e-01f, -1.77657932e-01f, -7.09657222e-02f, -2.67275218e-02f,
  -1.65537279e-02f, -8.73655304e-02f, -9.34606045e-02f, -4.78688329e-02f, -9.42074507e-02f, 4.44370583e-02f, -1.58363715e-01f, -1.71482824e-02f, -1.47088975e-01f, -1.83855087e-01f,
  1.84903845e-01f, -6.17345646e-02f, -7.90516734e-02f, 1.08412594e-01f, -3.38142589e-02f, 3.91178280e-02f, -3.01637780e-03f, -8.78142267e-02f, 9.21016932e-03f, -1.98185500e-02f,
  3.04604545e-02f, -6.51123328e-03f, 2.20677052e-02f, -1.75565872e-02f, -1.00924157e-01f, 5.54598235e-02f, -1.49115965e-01f, -1.54368535e-01f, -7.75461877e-03f, -9.15566608e-02f,
  2.46299133e-02f, -5.60515281e-03f, -8.06010887e-02f, -1.64226905e-01f, -1.28891513e-01f, 4.31292467e-02f, -7.59399384e-02f, -2.69047190e-02f, -2.49521695e-02f, 2.56079473e-02f,
  6.94500795e-03f, 1.68131609e-02f, -2.11596806e-02f, -2.86574084e-02f, 2.84248684e-02f, -8.62680189e-03f, 1.72165129e-02f, 4.47853059e-02f, -4.27165441e-02f, 4.84843962e-02f,
  1.51013359e-02f, 5.51794209e-02f, -4.70757335e-02f, -1.31644970e-02f, 9.62518677e-02f, -4.39730473e-02f, -1.74214561e-02f, 4.24908511e-02f, -3.72983813e-02f, -2.83151753e-02f,
  9.01809260e-02f, -6.85938522e-02f, 1.05289452e-01f, -4.80705053e-02f, 3.25802378e-02f, -1.22172860e-02f, 7.21267313e-02f, 5.41703776e-02f, -2.80450266e-02f, 4.67745475e-02f,
  2.96345174e-01f, -7.12445825e-02f, -1.46140121e-02f, -1.07088722e-01f, -1.07160071e-02f, -5.98564073e-02f, 3.31610651e-03f, 4.89020310e-02f, -5.08142039e-02f, -4.40679006e-02f,
  -3.91356014e-02f, -8.08146596e-02f, -4.79129851e-02f, -8.44410583e-02f, 2.46307366e-02f, 7.19369799e-02f, 6.97726011e-02f, 1.23536915e-01f, -1.10022783e-01f, 2.71445926e-04f,
  -5.19143865e-02f, 8.87074769e-02f, 1.87873557e-01f, 4.94870692e-02f, 1.62070692e-02f, 2.77937297e-02f, 6.46198094e-02f, 1.67260710e-02f, 2.68951561e-02f, 6.42607808e-02f,
  -2.81283498e-01f, 1.80789366e-01f, 3.16580087e-01f, -6.45049289e-03f, 2.64841855e-01f, 3.31448972e-01f, 2.29951710e-01f, 4.14944105e-02f, -3.01983822e-02f, 6.91558495e-02f,
  5.72717488e-02f, -1.28779501e-01f, -8.36778805e-02f, -7.79911429e-02f, 8.51154402e-02f, 1.77042872e-01f, 1.81224987e-01f, 1.85898036e-01f, 1.10232435e-01f, 1.22335300e-01f,
  2.11675033e-01f, -2.38881204e-02f, 3.27223167e-02f, 1.07692279e-01f, 1.38288559e-02f, 5.95199615e-02f, 1.58331111e-01f, 1.66599035e-01f, 2.36276358e-01f, 1.37391448e-01f,
  1.43501058e-01f, -1.81881699e-03f, 1.86434910e-02f, 8.74836519e-02f, 2.74106950e-01f, 1.34722576e-01f, 1.89382732e-01f, 8.38283673e-02f, 6.02770820e-02f, 1.50310859e-01f,
  1.33538499e-01f, 9.82830152e-02f, 1.04486063e-01f, 6.73034489e-02f, 1.20429993e-01f, 9.18391123e-02f, 3.27477679e-02f, 2.57794396e-04f, 1.04170926e-02f, 6.89502656e-02f,
  1.81060657e-01f, 2.95367956e-01f, 7.10531026e-02f, 1.53755516e-01f, 1.61566034e-01f, 8.04900378e-02f, 2.16908678e-01f, 1.36342598e-02f, 9.09752473e-02f, 7.59271085e-02f,
  -1.60320297e-01f, -3.41460593e-02f, 1.46740992e-02f, -1.42576873e-01f, -5.47248311e-02f, -1.35931462e-01f, -9.94409546e-02f, -2.44359318e-02f, -3.81363854e-02f, -1.74306095e-01f,
  -3.15746628e-02f, -1.51651621e-01f, -1.26445621e-01f, -1.91291034e-01f, -2.10188255e-02f, -1.43470436e-01f, -4.99604642e-02f, -4.92017344e-02f, -1.12923853e-01f, -5.94015196e-02f,
  -5.69643080e-02f, -7.94375911e-02f, -2.79084928e-02f, -1.38216764e-01f, -6.27768785e-02f, -5.23578264e-02f, -1.96389668e-02f, -1.18494764e-01f, -1.46938950e-01f, 1.13616511e-02f,
  -1.12476639e-01f, 1.41920790e-01f, 8.52400362e-02f, 1.17955906e-02f, 1.95312962e-01f, 1.06467456e-01f, 7.79759735e-02f, 1.14012659e-01f, 1.79083601e-01f, 1.32620245e-01f,
  7.56687298e-02f, 1.61886103e-02f, 6.20567612e-02f, 1.82633042e-01f, 1.26872823e-01f, 1.30229101e-01f, 1.67209119e-01f, 2.17887145e-02f, 1.14342749e-01f, 4.93490510e-02f,
  6.87883422e-02f, 1.03080101e-01f, -1.19665116e-02f, -4.04545851e-02f, 2.82256063e-02f, 4.89833169e-02f, 1.14058174e-01f, 1.57150611e-01f, -3.44586931e-03f, 7.65737519e-02f,
  2.95926511e-01f, 2.80991644e-01f, 1.07872546e-01f, 2.50926882e-01f, 2.48694122e-01f, 2.61777900e-02f, -9.38846171e-02f, -5.82346553e-03f, 3.06367815e-01f, 2.23457247e-01f,
  1.81130305e-01f, 1.31022900e-01f, -4.54657990e-03f, -2.92719016e-03f, -2.04973876e-01f, -9.16250125e-02f, -6.94025233e-02f, -1.62262022e-01f, -1.58228263e-01f, 2.03594435e-02f,
  3.19321714e-02f, 2.75856197e-01f, 1.61247551e-01f, 1.44660771e-01f, 2.23418668e-01f, 1.81484699e-01f, 2.25702196e-01f, 2.90722042e-01f, 8.96153674e-02f, 2.49052837e-01f,
  8.08783993e-02f, 3.40430945e-01f, -9.17013586e-02f, 8.01051855e-02f, 8.97917002e-02f, 1.49256945e-01f, 6.95767254e-02f, 1.78632095e-01f, 1.67140454e-01f, 1.88150212e-01f,
  1.97282568e-01f, 1.16115801e-01f, 1.14392951e-01f, 2.11822271e-01f, 2.18476281e-01f, 1.42046496e-01f, 8.91834497e-02f, 1.56690702e-01f, 1.14282325e-01f, 1.53457016e-01f,
  1.38558269e-01f, 1.45335510e-01f, 8.54317695e-02f, 4.41759117e-02f, 1.43342977e-02f, 6.42050896e-03f, 1.40779555e-01f, 1.31097481e-01f, 1.64967515e-02f, 1.96445063e-01f,
  -1.03603266e-01f, -7.21046925e-02f, -4.43325425e-03f, -8.42254087e-02f, -4.36557196e-02f, -4.39623790e-03f, -1.31520852e-01f, -9.53859091e-02f, -1.11555398e-01f, -6.34432072e-03f,
  -6.11845814e-02f, -1.10612139e-01f, -1.12025730e-01f, -5.08920364e-02f, -1.18082076e-01f, -2.94045787e-02f, -3.91779393e-02f, -1.83667108e-01f, -1.05808623e-01f, -8.49652216e-02f,
  -1.44793531e-02f, -1.30097613e-01f, -1.82235688e-02f, -5.35455719e-02f, -6.88418448e-02f, -1.21486537e-01f, -6.09725304e-02f, -7.75491372e-02f, -7.95086026e-02f, -4.82805036e-02f,
  1.52725130e-01f, -1.05603151e-01f, 1.62868708e-01f, 7.33632892e-02f, 2.35462964e-01f, 6.60537779e-02f, 1.47805110e-01f, 9.80710164e-02f, 1.56463921e-01f, 2.13449914e-02f,
  5.96780702e-02f, 1.67853668e-01f, 9.82394218e-02f, 1.84753444e-02f, 1.23058222e-01f, 1.33291870e-01f, 1.21683411e-01f, 7.40810186e-02f, 5.54483011e-02f, 2.05213949e-01f,
  1.41817153e-01f, 1.76277801e-01f, 1.70036554e-01f, 4.47904393e-02f, 1.02795638e-01f, 6.30425587e-02f, -3.17590102e-03f, 1.44958913e-01f, -7.53933657e-03f, 1.21709168e-01f,
  1.39336735e-01f, -1.34508882e-03f, 4.30522114e-02f, 1.38628349e-01f, 1.64512485e-01f, 3.03036440e-02f, 1.56960219e-01f, -3.65866981e-02f, 1.38464153e-01f, 1.40552774e-01f,
  -7.51384124e-02f, -3.00674923e-02f, 2.38634329e-02f, -4.03801389e-02f, 4.41011973e-02f, 2.21006900e-01f, 1.72563881e-01f, 1.49629816e-01f, 9.22167376e-02f, 4.44198139e-02f,
  1.77054122e-01f, 1.75263897e-01f, 8.95086899e-02f, 9.18401107e-02f, 2.47064888e-01f, 1.62226334e-01f, 1.16488419e-01f, 1.32321134e-01f, 6.41169846e-02f, 2.11739600e-01f,
  1.41598046e-01f, -1.33459747e-01f, -8.17500278e-02f, -1.10245027e-01f, 4.11731452e-02f, -7.67883984e-03f, -7.07228333e-02f, -1.41027302e-01f, -1.65794253e-01f, -2.82818973e-02f,
  -8.64438713e-02f, 3.31076421e-02f, -1.63882207e-02f, -4.19943780e-02f, -7.35403150e-02f, 1.47336125e-02f, -1.19428486e-01f, -8.84923339e-02f, -2.42947806e-02f, 1.97793841e-02f,
  4.81639691e-02f, -7.85101056e-02f, -6.53918087e-03f, -1.08487599e-01f, 5.22141121e-02f, -4.97157648e-02f, -2.05597393e-02f, -4.49505560e-02f, 7.18326718e-02f, 1.36906996e-01f,
  4.19747755e-02f, -1.13134861e-01f, -6.79773688e-02f, -1.45864591e-01f, -1.07631244e-01f, -1.21727809e-01f, 3.69322076e-02f, -2.25026365e-02f, -2.37400029e-02f, -5.41887246e-02f,
  -1.61660656e-01f, -3.76856849e-02f, -2.29044538e-02f, 9.09863636e-02f, -7.85836112e-03f, -3.86914685e-02f, 6.86459756e-03f, -5.03286049e-02f, 4.68143597e-02f, -4.44724858e-02f,
  -8.29684734e-02f, -8.75582695e-02f, -8.01261961e-02f, -3.77576724e-02f, -1.01040713e-02f, -1.11667015e-01f, -1.12560436e-01f, -1.38335042e-02f, -1.17759295e-01f, -9.48830023e-02f,
  -1.19310461e-01f, -1.59038305e-01f, 1.43302053e-01f, 6.67789280e-02f, 8.76179188e-02f, -1.37854274e-02f, -1.95428953e-02f, 1.26283010e-02f, -9.05570015e-03f, 6.53087869e-02f,
  1.09249474e-02f, 4.24541626e-03f, 6.97648376e-02f, 7.94845819e-02f, 4.86171804e-02f, 1.56298466e-02f, -6.04777373e-02f, -2.53759732e-04f, -3.29090729e-02f, -3.58422333e-03f,
  4.18860577e-02f, 8.63634720e-02f, 5.18111549e-02f, -5.97575977e-02f, 5.38518354e-02f, -3.26112309e-03f, 3.43915969e-02f, -5.03612384e-02f, 9.86042153e-03f, 5.17264754e-02f,
  -2.33136028e-01f, -2.60817204e-02f, 1.26964703e-01f, -1.57535672e-01f, -1.73612073e-01f, -1.16909377e-01f, -1.88832268e-01f, -6.91965371e-02f, -1.69685140e-01f, -6.53156713e-02f,
  2.16182936e-02f, -1.17884232e-02f, 9.83847585e-03f, 8.33759829e-02f, 3.93734872e-02f, -1.47781551e-01f, -1.38461798e-01f, -5.53843565e-02f, -5.56150712e-02f, -1.49165377e-01f,
  -1.41571760e-01f, -4.87180129e-02f, -9.03439336e-03f, -8.23054835e-03f, -3.57424170e-02f, 1.06950447e-01f, 2.79747788e-02f, 2.56842095e-02f, 1.02674559e-01f, -7.90333375e-02f,
  6.12357706e-02f, -6.43211380e-02f, 2.61401590e-02f, 7.54737332e-02f, -1.01550585e-02f, 3.38591300e-02f, -1.93348583e-02f, -3.21695991e-02f, 2.75946446e-02f, 6.32932112e-02f,
  1.28634408e-01f, -1.10504599e-02f, 7.05935732e-02f, 5.57940714e-02f, 7.44924173e-02f, 1.18763514e-01f, -2.36752201e-02f, -5.07994853e-02f, 8.87876675e-02f, 8.05517361e-02f,
  6.66985959e-02f, 6.97882473e-03f, 5.50474133e-03f, -1.98888853e-02f, 2.39879498e-03f, 3.45670022e-02f, 1.29301250e-01f, 1.63322866e-01f, 2.54899766e-02f, -1.04429282e-01f,
  1.28883019e-03f, -2.46896166e-02f, 3.21527608e-02f, -8.70203078e-02f, 4.88957241e-02f, 1.25683919e-01f, 2.63647456e-02f, 3.29310820e-02f, 9.10548680e-03f, 2.15821899e-03f,
  2.95412503e-02f, -2.63464991e-02f, -9.40161049e-02f, 5.05696572e-02f, 7.81445764e-04f, 3.42517123e-02f, 6.33044168e-02f, 4.46207486e-02f, 1.14754356e-01f, -5.93692847e-02f,
  5.35879545e-02f, 8.59312117e-02f, -9.56796259e-02f, -5.34407683e-02f, 7.96035230e-02f, 1.32084005e-02f, -6.97991997e-02f, 1.14161056e-02f, -6.75033107e-02f, -3.15865576e-02f,
  5.08873761e-02f, 2.53452212e-01f, 6.35602176e-02f, 8.08148682e-02f, -2.47195382e-02f, 1.34945869e-01f, 1.74179599e-01f, 1.05103679e-01f, 1.89758539e-02f, 4.95129451e-03f,
  1.55345947e-01f, 9.78312418e-02f, 5.41226342e-02f, 6.75751120e-02f, 2.03312351e-03f, 9.72400755e-02f, -2.36487091e-02f, -3.50761525e-02f, 9.16387364e-02f, 3.99573557e-02f,
  1.12490006e-01f, 4.28206548e-02f, 8.15686025e-03f, 1.52896166e-01f, 7.43790111e-03f, 1.02046318e-01f, 3.61849889e-02f, 4.61230390e-02f, 1.64870039e-01f, 3.20741124e-02f,
  4.33189511e-01f, 1.85865819e-01f, -2.22498193e-01f, 3.89028639e-02f, -5.90226986e-02f, -7.93560669e-02f, 7.29966611e-02f, 4.93669659e-02f, 1.97820559e-01f, 1.82774380e-01f,
  1.85787782e-01f, 7.50354677e-02f, 1.09269857e-01f, 6.46328628e-02f, 1.17797419e-01f, 3.68507989e-02f, -3.71863320e-02f, -1.38783246e-01f, 4.07810621e-02f, 9.62620229e-02f,
  1.83654517e-01f, 2.36977339e-01f, 2.53079444e-01f, 4.24550474e-02f, 9.03553888e-02f, -1.39764762e-02f, 7.76049197e-02f, 4.47670892e-02f, 8.88317451e-02f, 1.67612378e-02f,
  1.70129258e-02f, 2.25220740e-01f, 3.96211930e-02f, 2.98867136e-01f, 9.08016860e-02f, 1.78540111e-01f, 2.04444498e-01f, 1.21978141e-01f, 7.76926503e-02f, 1.21486969e-01f,
  1.78384304e-01f, 1.86150759e-01f, 1.50234401e-01f, 1.19076706e-01f, 1.59675404e-01f, 1.99381128e-01f, 9.71917957e-02f, 1.03098646e-01f, 1.76974088e-02f, 2.38288745e-01f,
  2.48344094e-01f, 4.72874492e-02f, -2.63456572e-02f, -7.54932174e-03f, 3.87732126e-02f, 6.38824254e-02f, 7.56358653e-02f, 1.06593944e-01f, 2.17157565e-02f, 2.69720674e-01f,
  -1.48071945e-01f, -1.60208389e-01f, -1.61786824e-01f, -1.33091643e-01f, -8.99898037e-02f, -1.80660740e-01f, -2.30696172e-01f, -1.19392775e-01f, -1.83918297e-01f, -1.49449170e-01f,
  -2.36969754e-01f, -8.11430216e-02f, -1.00782268e-01f, -1.64203763e-01f, -3.35554928e-02f, -2.22842768e-01f, -6.17039725e-02f, -1.84886381e-01f, -9.47336480e-02f, -1.29357368e-01f,
  -8.93968642e-02f, -1.88091740e-01f, -9.65814292e-02f, -9.05919224e-02f, -1.61707118e-01f, -1.73415989e-01f, -1.61044091e-01f, -1.14358537e-01f, -7.37854764e-02f, -1.49486884e-01f,
  9.04086828e-02f, 6.23096563e-02f, 1.35381743e-01f, 8.34873021e-02f, 2.02758178e-01f, 1.75838605e-01f, 2.05899462e-01f, 2.49842197e-01f, 1.31972238e-01f, 2.19252139e-01f,
  1.69210568e-01f, 1.03779115e-01f, 1.11263454e-01f, 1.31110102e-01f, 1.30352914e-01f, 1.50808632e-01f, 1.34835854e-01f, 1.39970914e-01f, 1.12969160e-01f, 1.80013955e-01f,
  7.14868978e-02f, 5.83678298e-02f, 7.14480355e-02f, 1.40300486e-02f, 7.23266229e-02f, -5.28577110e-03f, 1.21555164e-01f, 1.19139282e-02f, 4.16359082e-02f, 2.23945171e-01f,
  1.80166572e-01f, -1.26137644e-01f, -2.98984528e-01f, 2.84549017e-02f, 1.04648881e-02f, 7.40524381e-02f, 1.54351473e-01f, 1.54128999e-01f, 1.31605148e-01f, -7.44862705e-02f,
  -1.01623029e-01f, -3.80712450e-02f, -7.06425980e-02f, 9.87858176e-02f, 9.82431229e-04f, -1.34171285e-02f, -6.36703372e-02f, 4.55680005e-02f, 1.64913774e-01f, 2.57579058e-01f,
  6.00539669e-02f, 1.26237825e-01f, 3.25499065e-02f, 2.50181090e-02f, 5.53410081e-03f, -4.00813436e-03f, -2.17816159e-01f, -1.31550968e-01f, -1.03120588e-01f, -8.01154077e-02f,
  -1.95980906e-01f, -8.56229141e-02f, 2.20261469e-01f, 1.73022777e-01f, -4.65306686e-03f, 1.50560206e-02f, 1.11539297e-01f, 1.23559451e-02f, 4.19752784e-02f, 8.18520635e-02f,
  5.11244172e-03f, 6.76616952e-02f, -4.89402413e-02f, 7.65098706e-02f, 9.44143310e-02f, 6.58098608e-02f, 2.74684764e-02f, 4.61227354e-03f, -6.23296276e-02f, -1.24581894e-02f,
  -2.06250548e-02f, -1.68415420e-02f, 1.13017643e-02f, -2.69074645e-02f, -1.08863730e-02f, -1.38348546e-02f, -1.26026317e-01f, -9.82068181e-02f, 4.83013019e-02f, 7.37263784e-02f,
  2.21916929e-01f, -1.06106907e-01f, -5.42107373e-02f, -6.33294731e-02f, -9.18323100e-02f, -1.91144720e-01f, -1.29904255e-01f, -6.55171499e-02f, -3.55946831e-02f, -3.95931527e-02f,
  -1.89193904e-01f, -9.78329182e-02f, -3.26018520e-02f, -3.06127016e-02f, -4.47281152e-02f, -1.84188515e-01f, -1.27801806e-01f, -1.64289147e-01f, -8.91522765e-02f, -1.21122666e-01f,
  -1.23611324e-01f, -1.81604221e-01f, -1.06826529e-01f, -1.13354065e-01f, -1.23283766e-01f, -1.04618326e-01f, -5.65832928e-02f, -4.51076701e-02f, -1.83425426e-01f, -6.88510835e-02f,
  1.02270268e-01f, 1.33361086e-01f, 1.52149275e-01f, 1.38601393e-01f, 3.15311067e-02f, 1.43735232e-02f, 1.76828969e-02f, 8.10408443e-02f, 5.77853546e-02f, 3.03803459e-02f,
  5.09961136e-02f, -4.99898451e-04f, 2.99828593e-02f, -3.70953009e-02f, 1.73153982e-01f, 9.99529809e-02f, 6.89231083e-02f, -1.61068793e-02f, 2.33369134e-02f, 6.09283149e-02f,
  2.09195260e-02f, 2.04075485e-01f, 1.71157554e-01f, 3.04051135e-02f, 1.24155097e-01f, 1.82745561e-01f, 1.74610347e-01f, 1.46329433e-01f, 1.48164436e-01f, 2.00863779e-01f,
  -2.91521966e-01f, -1.89534068e-01f, 1.55433252e-01f, -1.34539485e-01f, -3.17816623e-02f, -7.74709880e-02f, -6.50919452e-02f, -1.09050386e-01f, -2.00384766e-01f, -1.60106242e-01f,
  -4.47320603e-02f, 3.88571061e-02f, -6.71762824e-02f, 7.60314614e-02f, -6.91528246e-02f, -1.47421986e-01f, -1.77110747e-01f, 7.51108006e-02f, 5.86649105e-02f, -1.04437806e-01f,
  -2.03172058e-01f, -4.12187986e-02f, -1.96571425e-02f, -3.73684466e-02f, -1.09558336e-01f, -6.01921454e-02f, 8.39907154e-02f, -1.86165143e-02f, 7.45371655e-02f, -1.67742353e-02f,
  1.52275398e-01f, 1.52095815e-03f, 2.96635274e-02f, -5.45362150e-03f, -2.23575030e-02f, -9.42334533e-02f, -5.67568815e-04f, 1.20485555e-02f, 3.13611776e-02f, -4.80926894e-02f,
  8.22429955e-02f, -5.97073138e-02f, 5.16436109e-03f, -7.00119510e-02f, -7.91458704e-04f, -2.89434189e-04f, -1.39488295e-01f, 5.36726564e-02f, 7.85670206e-02f, 5.60342036e-02f,
  -8.56005847e-02f, 3.51876728e-02f, 1.45797059e-02f, 9.57099423e-02f, -5.85676469e-02f, -6.99445931e-03f, 7.91153088e-02f, 1.57154026e-03f, 1.22615501e-01f, -1.33630708e-01f,
  -4.13257554e-02f, 4.78246585e-02f, 8.98938067e-03f, -6.22701459e-02f, -2.75133234e-02f, 1.46327969e-02f, -6.96889311e-02f, -1.09825850e-01f, 3.57269160e-02f, -7.87446946e-02f,
  -6.45175856e-03f, 7.27417693e-02f, 2.41373875e-03f, -5.52605428e-02f, 3.81106362e-02f, -6.09148014e-03f, -3.70369218e-02f, -2.43519358e-02f, -3.12058367e-02f, -6.13216572e-02f,
  -2.44374201e-02f, -2.25312542e-02f, 1.09383939e-02f, -6.39014095e-02f, -5.53750508e-02f, -3.04938331e-02f, 3.53727974e-02f, 3.87194864e-02f, 3.89291309e-02f, 6.08168356e-03f,
  -2.07538996e-02f, 2.30773732e-01f, -1.70169652e-01f, -1.09180190e-01f, -8.52945521e-02f, 2.33365106e-04f, -8.32109898e-03f, -3.31850350e-02f, 2.03124192e-02f, 1.40728923e-02f,
  8.61569270e-02f, 4.68616523e-02f, -3.66295651e-02f, -3.21011953e-02f, -6.70931265e-02f, -8.57385993e-02f, -1.61715806e-01f, -2.59796474e-02f, -3.22302282e-02f, 2.66124271e-02f,
  -1.47524595e-01f, -1.23138271e-01f, -1.18682340e-01f, -1.10596515e-01f, -3.68038863e-02f, -9.73708704e-02f, 7.79549330e-02f, 1.22710047e-02f, -7.56731853e-02f, -2.05720708e-01f,
  1.18217826e-01f, -3.08683664e-01f, 1.82752907e-01f, 6.96961284e-02f, 7.27659278e-03f, -1.77201495e-01f, -2.21435979e-01f, -1.84550494e-01f, -2.23402306e-02f, -6.83136936e-03f,
  -1.07802682e-01f, -2.22990606e-02f, 1.32056057e-01f, 1.41754774e-02f, -4.96343337e-02f, -2.76650721e-03f, 9.09849331e-02f, 1.21760868e-01f, 1.02599554e-01f, -9.93807092e-02f,
  -1.40374936e-02f, -5.60869314e-02f, 3.35852504e-02f, -5.71140274e-02f, 8.59750733e-02f, 5.96449412e-02f, 1.17958881e-01f, 8.64139944e-02f, -5.26133999e-02f, 2.84447163e-01f,
  3.19618464e-01f, -1.61303267e-01f, -4.91122082e-02f, -5.98329343e-02f, -8.33305493e-02f, -9.79998410e-02f, -5.59041239e-02f, -9.28800404e-02f, -1.22108296e-01f, -6.21771477e-02f,
  -4.03763875e-02f, -5.34558035e-02f, -4.12212424e-02f, -8.73679817e-02f, -2.79344544e-02f, -1.14316799e-01f, -3.57222296e-02f, -9.55955461e-02f, -1.99609715e-02f, -5.06906658e-02f,
  -5.56475855e-02f, -3.85937504e-02f, -6.05057329e-02f, -1.81535363e-01f, -1.87383190e-01f, 3.65309902e-02f, -6.13869876e-02f, -1.36254340e-01f, -1.37958288e-01f, -9.36460681e-03f,
  5.33217564e-02f, 1.64913371e-01f, -5.54406792e-02f, 3.96898501e-02f, 8.84260908e-02f, -3.49682979e-02f, 1.07379623e-01f, 1.16271786e-01f, 9.78811532e-02f, 5.51234744e-03f,
  -2.71548666e-02f, 9.64703336e-02f, -1.11389793e-02f, 2.90582497e-02f, 7.87814334e-02f, 9.77589116e-02f, 7.53864199e-02f, -5.78810554e-03f, 8.52861777e-02f, 3.31650153e-02f,
  6.64354935e-02f, 1.29992127e-01f, 5.69844432e-02f, -7.95094855e-03f, 5.23730405e-02f, 6.83484832e-03f, 1.07362926e-01f, -1.16055673e-02f, 1.11064084e-01f, 6.90629333e-02f,
  1.76299229e-01f, -2.48851612e-01f, 5.55603467e-02f, -3.29399947e-03f, -6.44185916e-02f, -8.37179795e-02f, -4.18080278e-02f, -6.40669018e-02f, -8.85423422e-02f, -3.09279887e-04f,
  -1.60382450e-01f, -6.01125546e-02f, -5.81569932e-02f, -6.97999150e-02f, -4.82444167e-02f, 6.36349469e-02f, -9.40937623e-02f, 7.57837389e-03f, -5.77233620e-02f, -1.07154548e-01f,
  -4.25395630e-02f, -2.36001648e-02f, 1.34433344e-01f, 4.61421832e-02f, -1.13940872e-01f, 9.44297984e-02f, -2.86026280e-02f, 4.41494212e-02f, 3.35003845e-02f, -2.62697088e-03f,
  9.82007459e-02f, 2.47197449e-01f, 2.37935424e-01f, 1.34488612e-01f, 2.32122630e-01f, 2.34727070e-01f, 1.62993416e-01f, 2.24148661e-01f, 1.30461484e-01f, 4.52833623e-02f,
  6.41609579e-02f, 6.22813366e-02f, 2.02983301e-02f, 1.14584811e-01f, 2.22226292e-01f, 3.01504344e-01f, 3.47142816e-01f, 2.71067619e-01f, 1.49094298e-01f, 4.84364815e-02f,
  1.18790260e-02f, 2.01379970e-01f, 1.70084730e-01f, 1.64233968e-01f, 2.05643605e-02f, -5.14961891e-02f, 1.08160652e-01f, 1.79399714e-01f, 1.43308610e-01f, 1.19631454e-01f,
  -4.94498499e-02f, 1.49159431e-01f, 1.26163200e-01f, 6.71254843e-02f, 6.47646040e-02f, 5.43497689e-02f, 1.12384535e-01f, 1.11886963e-01f, 7.29601458e-02f, 8.94095600e-02f,
  2.18778159e-02f, 7.14082317e-03f, 8.41961056e-02f, 8.35677460e-02f, 1.49580106e-01f, 2.04611570e-02f, 1.05265938e-01f, 1.58742428e-01f, 1.68130383e-01f, 1.37303248e-02f,
  1.88070573e-02f, 1.74301028e-01f, 1.72219977e-01f, 1.44399554e-01f, 9.13940519e-02f, 8.33642483e-02f, 9.45130885e-02f, -5.68612851e-03f, 4.52860072e-02f, 1.32441700e-01f,
  -1.21053219e-01f, 1.48736651e-03f, 1.12246117e-02f, -4.97024693e-02f, -6.50727823e-02f, -2.46234946e-02f, 1.65568944e-02f, -7.05459490e-02f, 4.54448722e-02f, -5.87839037e-02f,
  1.01066150e-01f, -5.74124679e-02f, 3.23491462e-04f, -1.85031593e-02f, -7.11373985e-03f, 2.12541409e-02f, -5.28668426e-02f, -6.67890981e-02f, -3.94051969e-02f, -1.24760672e-01f,
  6.76995516e-03f, 5.45642227e-02f, -8.52334499e-02f, -6.74395710e-02f, -4.83658910e-02f, -6.06711879e-02f, 2.53420398e-02f, -3.21729705e-02f, -4.29470167e-02f, -7.74541795e-02f,
  4.55485135e-02f, 9.85621959e-02f, 5.75020015e-02f, -3.83389704e-02f, 4.38503139e-02f, -4.24335785e-02f, 6.68402314e-02f, 3.65444506e-03f, 3.82344215e-03f, 7.77881220e-02f,
  2.16266178e-02f, 1.68914739e-02f, 9.93665978e-02f, -1.60791009e-04f, 1.67859375e-01f, 4.10988852e-02f, 8.73292610e-02f, 1.03943795e-01f, 3.20552140e-02f, 7.56059587e-02f,
  5.58077283e-02f, 1.88890249e-01f, 1.64961532e-01f, 7.60532245e-02f, 4.35314141e-02f, 7.47546405e-02f, 1.50541797e-01f, -4.63847779e-02f, 1.59776405e-01f, 3.88495885e-02f,
  -1.39321433e-03f, 6.47374690e-02f, 1.01133592e-01f, -3.26083541e-01f, 1.98854819e-01f, 2.81213582e-01f, 3.71463597e-01f, 2.01064825e-01f, -8.72161090e-02f, -7.91341439e-02f,
  1.70592908e-02f, -1.17263727e-01f, -7.62002468e-02f, -1.08766370e-01f, 4.37049344e-02f, -1.25701474e-02f, -1.44626230e-01f, -7.25725368e-02f, 2.07600862e-01f, 2.14875191e-01f,
  -9.60756540e-02f, -1.15367398e-01f, -1.54255867e-01f, -1.08562469e-01f, -2.96336502e-01f, -2.44433835e-01f, -1.12250105e-01f, -1.08834684e-01f, -7.49534220e-02f, -3.20985228e-01f,
  1.25362962e-01f, 1.54852480e-01f, 5.50472327e-02f, -2.07897760e-02f, 3.17093730e-02f, -5.46614975e-02f, 2.56525036e-02f, -4.93996926e-02f, 1.03596468e-02f, -2.68700495e-02f,
  -6.49336502e-02f, -1.61933601e-02f, -6.60623983e-02f, 5.41833751e-02f, -2.36351192e-02f, 7.57347047e-02f, -3.52601334e-02f, -9.83627662e-02f, -8.63901302e-02f, 3.08234040e-02f,
  -6.29158271e-03f, 7.72208050e-02f, 5.44005334e-02f, 9.88646597e-02f, -7.46562704e-03f, -6.06037825e-02f, 1.38165191e-01f, 2.74381414e-02f, 1.31098390e-01f, 1.57785900e-02f,
  2.07219962e-02f, 9.20317248e-02f, 7.94939473e-02f, -6.16666907e-03f, 1.73873510e-02f, -4.15007547e-02f, 1.42210126e-02f, 2.82091573e-02f, 1.44643465e-03f, -3.20687406e-02f,
  -2.93190945e-02f, -3.02007496e-02f, -3.33036040e-03f, 3.61282453e-02f, -9.11523104e-02f, 6.35726899e-02f, 3.03996727e-02f, 3.50210741e-02f, -2.87096817e-02f, 3.15444209e-02f,
  1.58835873e-02f, 1.77638568e-02f, -1.71580538e-02f, -7.75826350e-02f, -2.87682861e-02f, -3.99108492e-02f, -8.32291692e-02f, -3.12783830e-02f, 2.05279980e-03f, 3.99842076e-02f,
  -1.88087393e-02f, 2.40916666e-02f, -9.55592245e-02f, -4.92897965e-02f, -6.51897267e-02f, -1.47902649e-02f, -9.02416632e-02f, -4.38213727e-04f, -7.08630383e-02f, 7.71649927e-03f,
  3.32488343e-02f, -4.50229831e-02f, -1.96892694e-02f, -9.93320346e-02f, 5.60238399e-02f, -1.23810945e-02f, -9.74046811e-02f, -6.98297247e-02f, -1.28986454e-02f, -5.25343902e-02f,
  -3.21121737e-02f, 6.42309710e-02f, 1.52616560e-01f, 1.06456101e-01f, 3.09725734e-03f, 3.25069763e-02f, 6.19933270e-02f, 9.40914452e-03f, 1.35079503e-01f, 1.53896824e-01f,
  4.96425122e-01f, 2.61566718e-03f, -1.19281858e-01f, 1.93062663e-01f, 3.88475843e-02f, 6.98620602e-02f, -1.16328029e-02f, 8.53902325e-02f, 1.70961156e-01f, 4.07441966e-02f,
  7.71908835e-02f, 1.86845854e-01f, 1.78053275e-01f, 6.24560565e-02f, 1.26127183e-01f, -5.85861038e-04f, 1.60568871e-03f, 1.68704279e-02f, 1.74768772e-02f, -5.19086272e-02f,
  8.54317695e-02f, 5.65426797e-02f, 5.26679493e-02f, 3.65410857e-02f, -2.91398820e-02f, 4.19509038e-02f, -8.98164734e-02f, -2.27257013e-02f, 2.41045635e-02f, 5.21943085e-02f,
  5.19920476e-02f, 1.33443415e-01f, 2.83477139e-02f, 1.55721009e-01f, 1.00422755e-01f, 2.27687676e-02f, 1.51480332e-01f, 1.54863894e-02f, 7.16744065e-02f, 1.19623141e-02f,
  3.93238291e-02f, -1.96506213e-02f, 1.52185544e-01f, 6.20238446e-02f, 3.92848216e-02f, 4.57405299e-03f, -6.38698712e-02f, -1.04846647e-02f, 5.54451346e-02f, -1.48675041e-02f,
  6.22151159e-02f, 1.60088211e-01f, 1.10522524e-01f, 3.40036452e-02f, 7.84587637e-02f, 7.85816461e-02f, 8.45589191e-02f, 9.03135091e-02f, 4.41646688e-02f, 1.11899897e-01f,
  -6.47474378e-02f, -1.19416356e-01f, -1.35164052e-01f, -1.97907761e-01f, -9.49606001e-02f, -1.76962186e-02f, -1.49143919e-01f, -1.68956384e-01f, -1.53859720e-01f, -6.96220100e-02f,
  -9.99526903e-02f, -1.11899965e-01f, -3.23636718e-02f, -7.06539005e-02f, -4.49103527e-02f, -8.49654973e-02f, -1.33166790e-01f, -7.38595128e-02f, -7.92334676e-02f, -9.52208713e-02f,
  -4.60796468e-02f, -1.03588559e-01f, -1.57526344e-01f, -7.43709728e-02f, -1.75424322e-01f, -8.41499567e-02f, -1.45096585e-01f, -2.08286911e-01f, -1.50372013e-01f, -1.35009885e-01f,
  1.68946400e-01f, 1.31972283e-01f, 1.69848815e-01f, 2.19181627e-02f, 1.03113160e-01f, 7.87971690e-02f, 7.41163641e-02f, 1.65292937e-02f, 8.15590248e-02f, 1.63156822e-01f,
  1.15772337e-01f, 9.32179093e-02f, 1.93659943e-02f, -1.08885281e-02f, 1.18961714e-01f, 1.59743577e-01f, 1.67269278e-02f, 7.33873546e-02f, 1.48995444e-01f, 1.46955177e-02f,
  5.98631576e-02f, 2.76928067e-01f, 2.09101930e-01f, 1.82640091e-01f, 1.49522960e-01f, 3.12710851e-01f, 2.20408693e-01f, 1.42588198e-01f, 2.16200203e-01f, 2.22208366e-01f,
  -3.79107296e-01f, 5.00920117e-02f, 2.61962035e-04f, 7.58578554e-02f, -6.74256153e-05f, 6.35118857e-02f, 1.53751329e-01f, 1.84357107e-01f, 2.38206729e-01f, 6.65204301e-02f,
  7.18231946e-02f, 4.25507948e-02f, 6.59042597e-02f, -6.02672517e-04f, -1.18236877e-01f, 1.29139289e-01f, 9.10229906e-02f, -2.26994663e-01f, -6.01790287e-02f, -1.01253025e-01f,
  4.59267932e-04f, -1.18971780e-01f, -1.65128559e-01f, -2.23557968e-02f, 1.26868948e-01f, 1.91805267e-03f, 3.49694379e-02f, -1.42282888e-01f, -1.45847172e-01f, -1.71374436e-02f,
  2.50732759e-03f, -2.14382052e-01f, 6.72452524e-02f, 1.09648928e-02f, -5.81714921e-02f, -2.57885287e-04f, -6.63331151e-02f, -4.59420159e-02f, -7.04502910e-02f, -2.44848430e-02f,
  -1.02347173e-01f, -6.46362230e-02f, 1.11806309e-02f, -1.94726996e-02f, 3.17410473e-03f, -2.14605946e-02f, 6.03463054e-02f, -4.71897610e-02f, 5.01974709e-02f, 7.50830024e-02f,
  -6.21323287e-02f, -7.51239061e-02f, -1.39078021e-01f, 6.53557256e-02f, -3.07307076e-02f, 3.80519358e-03f, -3.97472829e-02f, -1.21009387e-01f, -1.00724168e-01f, -9.08972397e-02f,
  5.39738834e-02f, 3.57990590e-04f, -7.07893586e-03f, 5.13633490e-02f, 5.55812800e-03f, 1.26187727e-01f, -9.10516735e-03f, 2.97491364e-02f, -1.04613127e-02f, 9.09644738e-03f,
  1.54852076e-02f, -2.02652463e-03f, 9.79655534e-02f, 6.37122095e-02f, 2.33998932e-02f, 8.76249373e-03f, -5.93947209e-02f, 4.99243401e-02f, 5.40208369e-02f, 4.86026965e-02f,
  -4.56654057e-02f, -1.03395702e-02f, -7.97699317e-02f, -3.53455805e-04f, -4.76892218e-02f, -2.74212565e-02f, -4.58262339e-02f, -1.45272557e-02f, 5.91118447e-02f, 6.67013675e-02f,
  2.54931748e-01f, -9.80159491e-02f, -2.88233571e-02f, -1.22829489e-01f, -2.41530761e-02f, 8.72473642e-02f, -3.16896699e-02f, -3.05775646e-02f, -4.53889854e-02f, 4.90480550e-02f,
  -2.01720744e-02f, 3.24501954e-02f, -9.27008912e-02f, -1.31462775e-02f, 2.51963511e-02f, 2.28686202e-02f, 9.25003886e-02f, -4.50167106e-03f, -3.33683565e-02f, 3.24952304e-02f,
  1.07484855e-01f, 2.20365133e-02f, 1.69835414e-03f, 1.88850134e-03f, 1.19273894e-01f, 9.90855601e-03f, 7.97626972e-02f, 9.79258344e-02f, -7.94382114e-03f, 9.04018581e-02f,
  2.38810360e-01f, 4.34995502e-01f, 3.32530379e-01f, 1.88486829e-01f, -6.71304762e-02f, 1.12780049e-01f, 2.19637841e-01f, 2.69210845e-01f, 3.74595821e-02f, 1.65533394e-01f,
  -8.91790912e-02f, -2.14412823e-01f, -4.03022431e-02f, -6.29793182e-02f, 3.45629156e-02f, 2.08777338e-01f, 2.28077233e-01f, 1.27082497e-01f, -1.21973023e-01f, -7.26499707e-02f,
  -6.64550066e-02f, 1.57083929e-01f, 3.19755264e-02f, 8.92594904e-02f, 2.35278517e-01f, 2.16400921e-02f, 1.77716747e-01f, 1.85540885e-01f, 5.51225133e-02f, 1.33960351e-01f,
  4.20079567e-03f, 1.55910343e-01f, -8.95114522e-03f, -7.29204789e-02f, 7.43723884e-02f, 1.24116719e-01f, 2.87976582e-03f, 1.24132328e-01f, 4.94909249e-02f, 1.85592830e-01f,
  9.21396911e-02f, 6.01166626e-03f, 1.40503421e-02f, -2.91372975e-03f, 1.17150828e-01f, 2.80066784e-02f, 9.78052393e-02f, 7.62823671e-02f, 1.02410361e-01f, 1.38601467e-01f,
  3.81206758e-02f, 8.49992037e-02f, 9.73079130e-02f, 1.20969869e-01f, 6.61742315e-02f, 5.16250590e-03f, 9.27501023e-02f, 1.04796641e-01f, 1.57699749e-01f, 2.33526543e-01f,
  -4.16684598e-02f, 5.76586537e-02f, -8.98005441e-02f, 2.49017943e-02f, -9.70849991e-02f, -2.54356489e-03f, 2.80347019e-02f, -8.78649727e-02f, -4.62282673e-02f, 2.81758178e-02f,
  -6.43793028e-03f, -1.09153204e-01f, 2.49553937e-02f, -5.21021597e-02f, -3.08993831e-02f, -2.66301417e-04f, 4.08550426e-02f, -1.99773479e-02f, -1.49983671e-02f, -6.72930107e-02f,
  -1.10353120e-01f, -6.08000495e-02f, -9.14823562e-02f, 2.36582197e-02f, -9.43498760e-02f, 4.21280749e-02f, 4.70711291e-02f, 2.19379868e-02f, -2.33311523e-02f, 1.15369437e-02f,
  6.60482273e-02f, -2.20866546e-01f, 2.61653140e-02f, 1.01310052e-02f, 8.61116946e-02f, 5.89076765e-02f, 9.20025706e-02f, 9.52500924e-02f, -7.19877779e-02f, 1.27978876e-01f,
  1.82681512e-02f, 3.87395918e-02f, 1.34529278e-01f, 1.07181467e-01f, 1.39221195e-02f, 3.94511558e-02f, 5.73016182e-02f, 9.43257362e-02f, -4.50203791e-02f, 1.33735966e-02f,
  1.83324113e-01f, 1.27893552e-01f, 4.84316386e-02f, 7.30625689e-02f, 6.23731725e-02f, 8.35176110e-02f, 1.35592565e-01f, 1.65354326e-01f, 1.38704821e-01f, 2.13690937e-01f,
  -1.89341325e-02f, -9.23263952e-02f, -2.76338011e-01f, -3.14392596e-02f, 6.04942702e-02f, 1.91419180e-02f, -8.96078944e-02f, 6.95779622e-02f, 8.98162797e-02f, -1.01544634e-01f,
  1.91988215e-01f, 2.14575887e-01f, 2.28516117e-01f, 1.68621868e-01f, 3.80404443e-02f, -1.13863111e-01f, -1.06752187e-01f, -1.28230527e-01f, -3.78759531e-03f, -3.58628221e-02f,
  1.30966067e-01f, -7.79786408e-02f, -1.37513831e-01f, -1.23595662e-01f, 6.49126843e-02f, -3.78790013e-02f, -2.52590179e-01f, -7.47427493e-02f, -1.31892711e-01f, -5.19715548e-02f,
  -5.59024513e-02f, 8.06975141e-02f, 8.25136602e-02f, 2.10322917e-01f, 9.61318985e-02f, -1.82356499e-02f, 2.41790377e-02f, 1.57416202e-02f, 7.50069767e-02f, 3.01223248e-02f,
  1.26801934e-02f, 1.47839831e-02f, 9.67649966e-02f, 1.14355087e-01f, 1.07105216e-02f, -1.18967576e-03f, 6.21509664e-02f, -6.96694385e-03f, -2.36407649e-02f, 1.12951674e-01f,
  4.33919802e-02f, 2.17081979e-02f, -7.07784370e-02f, -1.09313451e-01f, 1.20221339e-02f, 8.79097506e-02f, -2.61705928e-02f, -8.98895413e-02f, -1.13813055e-03f, -1.16682939e-01f,
  -9.08365622e-02f, 8.85941379e-04f, -4.05320115e-02f, -5.69514446e-02f, -7.33404234e-02f, 3.33887152e-02f, -7.34006800e-03f, -9.94789042e-03f, -3.73278968e-02f, -9.95290503e-02f,
  8.72188620e-03f, -4.07455787e-02f, -1.05723524e-02f, -2.67555621e-02f, -2.76069567e-02f, -7.06630796e-02f, 5.89722618e-02f, -5.16742878e-02f, 2.82921568e-02f, 2.98632216e-02f,
  -8.83216504e-03f, -8.02310258e-02f, -4.83730137e-02f, -1.88996773e-02f, 2.12832298e-02f, -9.14743021e-02f, 5.49699850e-02f, -2.36245729e-02f, -6.34571314e-02f, -6.62513897e-02f,
  -1.83630884e-02f, 1.05330184e-01f, 1.01772323e-01f, 8.23637396e-02f, 7.34252706e-02f, 9.94084626e-02f, 4.95962724e-02f, -7.16751488e-03f, 7.77690336e-02f, 8.11740756e-02f,
  9.91786569e-02f, 8.61335993e-02f, -2.74428516e-03f, -7.49864243e-03f, -2.28904793e-03f, 7.81663358e-02f, 1.04285162e-02f, 8.07340518e-02f, 7.15644062e-02f, -5.61567433e-02f,
  -2.08058041e-02f, -1.08090028e-01f, -3.00233122e-02f, 5.69001287e-02f, 4.24929038e-02f, 3.67575437e-02f, -1.42752603e-01f, -1.29915979e-02f, -5.74662611e-02f, -1.82868510e-01f,
  -7.10454956e-02f, 1.13020189e-01f, 5.63144833e-02f, -3.19121256e-02f, -1.49737403e-01f, -1.15931571e-01f, 4.07317420e-03f, 7.61912987e-02f, -2.36320216e-02f, -5.20813689e-02f,
  3.23333926e-02f, -7.57773519e-02f, 2.88309511e-02f, -1.60908103e-02f, 1.68073282e-01f, 6.44835003e-04f, -1.37471035e-01f, -1.05433531e-01f, 2.61387322e-02f, 6.58040401e-03f,
  -4.85962331e-02f, 3.02140545e-02f, 5.37406793e-03f, -9.73002166e-02f, -1.36872694e-01f, -1.80405974e-01f, -1.70850173e-01f, -6.59009442e-02f, -1.56667560e-01f, -2.82426983e-01f,
  2.06982009e-02f, -4.67287041e-02f, -1.04081847e-01f, -1.16779014e-01f, 2.59071756e-02f, -7.93509632e-02f, 2.90204771e-02f, 8.10685381e-02f, -4.47336659e-02f, -1.78398788e-02f,
  -2.40628924e-02f, -3.53801474e-02f, -8.06482434e-02f, -1.31965363e-02f, 4.49473187e-02f, -1.30536593e-02f, -5.62491529e-02f, 4.31790799e-02f, 5.44660576e-02f, -5.30730039e-02f,
  -4.48385999e-02f, -1.43271625e-01f, -1.44245371e-01f, -7.51854805e-03f, -6.02889620e-02f, -1.00003734e-01f, 5.30409515e-02f, -1.17596142e-01f, -1.84808001e-02f, -1.11907370e-01f,
  -2.08986495e-02f, 7.64462724e-02f, 9.96935815e-02f, 8.77501592e-02f, 1.02140456e-01f, 4.47154865e-02f, -3.89769860e-02f, -1.40875308e-02f, 9.89665277e-03f, 1.11223664e-02f,
  1.23714842e-01f, 1.61869481e-01f, 7.77247921e-02f, 2.90514398e-02f, 3.63043025e-02f, 1.35298949e-02f, 2.51582637e-02f, -1.35354605e-02f, -6.50127977e-02f, -3.83708775e-02f,
  1.19539560e-03f, 1.92123801e-02f, 8.84798840e-02f, 6.29594410e-03f, -3.98834907e-02f, 3.11900992e-02f, 8.52952972e-02f, 1.53202498e-02f, 4.73874807e-02f, 1.01951703e-01f,
  1.39098823e-01f, -6.09288849e-02f, -1.89821552e-02f, -1.07443623e-01f, -4.48387414e-02f, -9.15651023e-02f, -1.13091320e-02f, -1.01128079e-01f, 4.59447764e-02f, -9.27439407e-02f,
  -2.99225394e-02f, 2.37217303e-02f, 4.32918966e-02f, 3.14097703e-02f, -1.10273324e-02f, -3.54455858e-02f, -9.43918340e-03f, -1.83214918e-01f, -7.24187493e-02f, -3.58261280e-02f,
  3.24657448e-02f, -2.03881219e-01f, -1.75219506e-01f, -1.46071032e-01f, -1.28976136e-01f, -1.11000188e-01f, -3.13959233e-02f, -1.39005736e-01f, -7.50586241e-02f, -1.60913140e-01f,
  1.49931073e-01f, 3.94799918e-01f, 1.98916420e-01f, 3.75197493e-02f, 9.98112187e-02f, 9.87135693e-02f, 8.58672634e-02f, 5.98204136e-03f, -8.13040882e-02f, 7.69012570e-02f,
  5.11331372e-02f, 4.29747961e-02f, 3.94915342e-02f, 2.95479577e-02f, -8.68480504e-02f, 8.72292444e-02f, 1.13982394e-01f, 5.45670390e-02f, -9.40981060e-02f, -1.64006501e-01f,
  -3.93507481e-02f, 8.22272748e-02f, 9.49897468e-02f, 4.35193256e-02f, 1.06807806e-01f, 9.27083641e-02f, 2.05012470e-01f, 2.57075846e-01f, 1.38930872e-01f, 1.92988172e-01f,
  1.24730349e-01f, 2.40650460e-01f, -4.65473160e-02f, 4.69514318e-02f, 1.85669303e-01f, 1.02051690e-01f, 2.99640521e-02f, 1.42483875e-01f, 1.66620478e-01f, 1.33875549e-01f,
  8.43977928e-02f, 1.16612047e-01f, 4.87701371e-02f, 1.38682544e-01f, 9.60786492e-02f, 2.85150278e-02f, 6.98146671e-02f, 2.17762396e-01f, 5.19930050e-02f, 7.24674538e-02f,
  9.28446949e-02f, 2.36157835e-01f, 1.45813867e-01f, 8.16306025e-02f, 1.78191572e-01f, 1.15096293e-01f, 2.50354558e-01f, 1.73069611e-01f, 1.33163989e-01f, 1.36233330e-01f,
  -3.01862136e-02f, -9.04936790e-02f, -5.36000356e-03f, -8.38118717e-02f, -8.87249857e-02f, -1.21635720e-01f, -4.28742804e-02f, -1.60020486e-01f, -3.10762208e-02f, -1.44847944e-01f,
  1.46360626e-03f, -2.14058775e-02f, -1.07843146e-01f, -7.63253942e-02f, -5.49681745e-02f, -1.22418605e-01f, -3.99756357e-02f, -1.43206090e-01f, -1.50823653e-01f, -6.80281445e-02f,
  -6.65630102e-02f, -1.00120507e-01f, -3.73513103e-02f, -5.70682883e-02f, -8.73012766e-02f, -1.40419289e-01f, -7.99129829e-02f, -1.18405014e-01f, -9.77868959e-02f, -1.68043718e-01f,
  3.43664289e-02f, 7.10329711e-02f, -5.99046722e-02f, 9.07043144e-02f, 5.28242476e-02f, 6.27904013e-02f, 1.40963182e-01f, 1.30177051e-01f, 7.23345280e-02f, 1.41986489e-01f,
  5.96716888e-02f, 4.84696403e-02f, 1.04389600e-01f, 5.16293980e-02f, 1.43536329e-01f, 8.24905485e-02f, -5.39194746e-03f, 3.10732126e-02f, 4.62531261e-02f, 1.31751359e-01f,
  8.45205877e-03f, 2.26200949e-02f, -5.51936030e-02f, -4.97365929e-02f, 1.23061582e-01f, -8.71303529e-02f, 1.12920485e-01f, -9.26485378e-03f, 4.40650135e-02f, 9.32323784e-02f,
  -1.77991807e-01f, -2.21599713e-01f, -2.54130304e-01f, -1.22429477e-02f, -6.26178235e-02f, -1.71361193e-01f, -2.35451445e-01f, 8.06437898e-03f, -5.54546248e-03f, -1.12669714e-01f,
  -1.36670321e-01f, -7.26944432e-02f, -5.68695925e-02f, -2.40035169e-02f, -1.64170284e-02f, -3.47531103e-02f, 5.93893193e-02f, 1.27300560e-01f, 1.60101011e-01f, 5.67948539e-03f,
  1.22332953e-01f, -8.89316201e-03f, 2.75476323e-03f, 1.96162954e-01f, 1.13984242e-01f, 5.98558038e-02f, 1.78421419e-02f, 1.15667786e-02f, 2.73297471e-03f, 1.88381635e-02f,
  -1.28818870e-01f, -6.45172521e-02f, 1.22876307e-02f, -1.95348710e-02f, -6.57023937e-02f, -1.04668811e-01f, -1.62686825e-01f, 2.19434476e-03f, -1.71863362e-02f, -1.34927155e-02f,
  -9.56782177e-02f, -1.14022382e-01f, -9.73148569e-02f, 4.35279347e-02f, -3.28303203e-02f, -8.25153440e-02f, -1.87990684e-02f, 9.96222049e-02f, -8.98554325e-02f, -5.93300126e-02f,
  -8.54448453e-02f, -5.12529612e-02f, -1.67637497e-01f, -4.39479314e-02f, -3.37917404e-03f, 2.40115402e-03f, -9.19751972e-02f, -8.61635990e-03f, -1.75899684e-01f, -1.83775835e-02f,
  1.93572473e-02f, -4.21489887e-02f, 8.70228261e-02f, 1.40880570e-02f, 9.06704962e-02f, 1.44738881e-02f, 8.37170482e-02f, 1.50538590e-02f, 4.84490134e-02f, 8.08420479e-02f,
  1.19056277e-01f, 6.33299202e-02f, 1.83535051e-02f, 2.47585848e-02f, 4.91533354e-02f, 5.36849834e-02f, 5.45023568e-02f, 3.92422751e-02f, 9.98007208e-02f, 9.34392586e-03f,
  1.79469343e-02f, -2.22675689e-02f, 9.74395052e-02f, 1.92991957e-01f, 8.35007802e-02f, 6.94804220e-03f, -8.84705968e-03f, 9.55245551e-03f, 7.20808059e-02f, 6.32661283e-02f,
  -1.51455909e-01f, -6.26308993e-02f, -1.36440307e-01f, 3.50621082e-02f, 4.95371700e-04f, -6.01917394e-02f, -7.29035735e-02f, 1.17105953e-02f, -1.08895175e-01f, 8.03606585e-03f,
  -1.27229571e-01f, 6.14162185e-04f, -1.10396501e-02f, -5.65891191e-02f, 1.70091074e-02f, 1.56865083e-02f, -2.67242384e-03f, -1.16587788e-01f, 7.35223070e-02f, -7.61515126e-02f,
  3.39979902e-02f, -1.51775584e-01f, -1.02580987e-01f, -3.55430326e-04f, -1.75878461e-02f, -1.32742569e-01f, -1.14543669e-01f, -8.02224725e-02f, -1.43701509e-01f, -4.15019393e-02f,
  -1.56244144e-01f, 5.37480786e-03f, 2.50708908e-02f, 1.61062693e-03f, 1.49714991e-01f, -8.12061355e-02f, -1.59182325e-01f, -7.58860111e-02f, -5.03338724e-02f, -9.26908180e-02f,
  3.84079814e-02f, 1.98985748e-02f, 4.03820053e-02f, -6.74002396e-04f, -7.19569027e-02f, -1.19480481e-02f, 1.27119362e-01f, 4.03441340e-02f, -6.65226802e-02f, 8.26424807e-02f,
  9.12307277e-02f, 6.00491092e-02f, 5.31535670e-02f, 4.08481918e-02f, 1.92434460e-01f, 3.22126821e-02f, 5.21287657e-02f, 1.76917151e-01f, -1.69783588e-02f, 1.99171811e-01f,
  -3.64786293e-03f, -7.45649710e-02f, -2.40497179e-02f, -5.70417233e-02f, -6.94940016e-02f, -2.92443037e-02f, -5.55150583e-02f, -6.53300658e-02f, -9.97586772e-02f, -7.87563156e-03f,
  1.68997310e-02f, -1.59880482e-02f, -6.19882941e-02f, -8.43654126e-02f, -8.63497183e-02f, -8.25474113e-02f, -9.64446459e-03f, 3.50423828e-02f, 3.80289331e-02f, -8.46314430e-02f,
  -9.14308727e-02f, -4.06565256e-02f, -6.13892451e-02f, -1.52536882e-02f, 2.39569601e-02f, 5.48345931e-02f, -5.65005094e-02f, -7.15193525e-02f, -6.35732338e-02f, 7.91996834e-04f,
  -1.39253557e-01f, 1.21592909e-01f, 9.00481492e-02f, 1.31177709e-01f, 1.15371943e-02f, 1.85495108e-01f, 1.73943982e-01f, 1.58589780e-01f, 1.04310215e-01f, 2.39895470e-02f,
  1.26227275e-01f, 1.55128777e-01f, 1.99754328e-01f, 8.14275369e-02f, 7.02279955e-02f, 1.19207673e-01f, 1.62290543e-01f, 6.72100931e-02f, -2.53770854e-02f, 6.38780966e-02f,
  2.53467951e-02f, 9.85760838e-02f, 6.63347691e-02f, 1.36970773e-01f, 1.40209362e-01f, 5.76263443e-02f, 3.29495408e-02f, 1.52984023e-01f, 1.34084091e-01f, 7.35066384e-02f,
  -1.52123317e-01f, -1.01165108e-01f, -1.90862611e-01f, -9.33610126e-02f, -6.32145330e-02f, 1.84384249e-02f, -6.41692355e-02f, -5.54945394e-02f, 4.94506881e-02f, -9.70988348e-02f,
  -2.52870517e-03f, -1.02708228e-01f, -1.71029776e-01f, -3.87082919e-02f, -8.33597332e-02f, -1.90457821e-01f, -2.12146133e-01f, -2.13400610e-02f, -5.45806885e-02f, -1.10502414e-01f,
  -1.27253175e-01f, -1.43833190e-01f, -6.91079050e-02f, -2.00964928e-01f, -2.85960175e-02f, -2.11219370e-01f, -1.25622794e-01f, -1.48490205e-01f, -7.05146790e-02f, -1.79370403e-01f,
  -1.49297044e-01f, -2.35507116e-01f, -3.21945399e-02f, -2.54493147e-01f, -1.13573328e-01f, -1.86295539e-01f, -2.36291766e-01f, -7.66472965e-02f, -6.83301017e-02f, -1.92950413e-01f,
  -5.39248399e-02f, 4.03407477e-02f, 7.03667849e-02f, 1.17972165e-01f, 3.96179482e-02f, -7.91439340e-02f, -4.38658334e-02f, -2.64853034e-02f, 4.59832437e-02f, -4.24970081e-03f,
  -6.42729029e-02f, 1.33378608e-02f, -1.24843521e-02f, 8.18167329e-02f, -1.38163075e-01f, -5.10103069e-02f, 4.41316143e-02f, -1.25921130e-01f, -1.18057437e-01f, -1.41701251e-01f,
  -2.68423945e-01f, -1.15612589e-01f, 3.31898108e-02f, 3.52091230e-02f, -3.96713847e-03f, 3.15160006e-02f, 2.43473388e-02f, 6.36201501e-02f, 4.98067029e-02f, 1.50879612e-03f,
  6.64655864e-02f, 1.33576080e-01f, -2.65099537e-02f, -4.51398194e-02f, 9.98625252e-03f, -7.11319782e-03f, 1.46039292e-01f, 2.77072727e-03f, 1.37837619e-01f, 3.43696289e-02f,
  -5.47332056e-02f, -9.72044319e-02f, 5.00820614e-02f, 1.89393479e-02f, 2.86663529e-02f, 1.31388694e-01f, -6.08229339e-02f, 1.79167241e-02f, 3.01627517e-02f, -1.12656811e-02f,
  -4.12079319e-02f, 5.08825034e-02f, 4.65317741e-02f, -9.82753001e-03f, -3.26864831e-02f, -3.94046754e-02f, -9.78269055e-02f, -8.42967555e-02f, -6.03390262e-02f, -3.34925987e-02f,
  -2.99023520e-02f, -6.69113249e-02f, -4.55760490e-03f, -8.18677023e-02f, -4.31593694e-02f, 1.35134244e-02f, -5.91977127e-02f, -9.00660902e-02f, 5.55599891e-02f, -1.13954693e-02f,
  -8.54256302e-02f, -6.92268386e-02f, -2.24545170e-02f, -2.38180086e-02f, 9.78752412e-03f, -9.36007798e-02f, 2.31198948e-02f, -7.13582560e-02f, 1.60737466e-02f, 4.57686596e-02f,
  1.77318037e-01f, 1.61168069e-01f, -7.89941922e-02f, 8.83345827e-02f, -2.18536220e-02f, 1.59794778e-01f, -1.06497249e-02f, 1.60721317e-01f, 8.54358077e-02f, 4.53211814e-02f,
  -6.55004010e-02f, 2.90938783e-02f, 6.46889806e-02f, 2.31088381e-02f, 6.38221502e-02f, 1.44638838e-02f, 1.79155730e-02f, -7.81261188e-04f, 1.34957671e-01f, 2.60064565e-02f,
  7.93807358e-02f, 4.44397628e-02f, 3.76736326e-03f, 4.48848568e-02f, 8.99679586e-02f, 7.10567534e-02f, 1.64650843e-01f, 1.35306701e-01f, 1.19103141e-01f, -6.88648969e-02f,
  2.72061706e-01f, 2.89641052e-01f, -5.69305709e-03f, 3.01065236e-01f, 4.79032919e-02f, -1.12994790e-01f, -1.17826775e-01f, -9.44636762e-02f, 1.79685012e-01f, 1.19954146e-01f,
  1.24739915e-01f, 7.29539692e-02f, 2.97185797e-02f, 1.36786789e-01f, -9.62865576e-02f, -2.82570831e-02f, 1.51376635e-01f, 7.28437603e-02f, -2.39511952e-02f, -1.32526634e-02f,
  1.95653766e-01f, 1.20349266e-01f, 2.07974955e-01f, 3.49373370e-02f, 1.69998035e-01f, 1.43012628e-01f, 7.65017839e-03f, 7.39858076e-02f, 9.36644077e-02f, 2.51053572e-01f,
  7.69898817e-02f, 1.36684090e-01f, 1.27075622e-02f, 1.51007414e-01f, -1.80007815e-02f, 1.01415806e-01f, 8.40008929e-02f, 7.73949325e-02f, 4.56743240e-02f, 1.31175756e-01f,
  1.79221317e-01f, 2.09806219e-01f, 1.74575031e-01f, 1.66772276e-01f, 9.85325053e-02f, 1.33448273e-01f, 4.28194553e-02f, 1.98273063e-01f, 1.14999637e-01f, 1.05937526e-01f,
  2.46784896e-01f, 9.73976552e-02f, 7.44535699e-02f, 4.96317521e-02f, 1.78526416e-02f, -5.40268794e-03f, -1.62933953e-02f, 3.01942062e-02f, -9.81074385e-03f, 1.82576582e-01f,
  -5.08911870e-02f, -4.29210216e-02f, -6.60347417e-02f, -9.83836353e-02f, -7.33700618e-02f, -2.45870724e-02f, -3.32403034e-02f, -9.76814181e-02f, -9.97364447e-02f, -1.56351283e-01f,
  -5.99418730e-02f, -4.71636280e-02f, -4.09856737e-02f, -1.37216588e-02f, -6.61558583e-02f, -1.18287839e-01f, -1.17954142e-01f, -4.93922876e-03f, -1.31432921e-01f, -1.68129597e-02f,
  -7.84616843e-02f, -1.59138635e-01f, -1.03573643e-01f, -1.42880633e-01f, -1.00157976e-01f, -1.66571215e-01f, -9.14967433e-02f, -6.29382506e-02f, -3.80466394e-02f, -8.21792930e-02f,
  -3.85417454e-02f, -1.30703747e-01f, 1.08351432e-01f, 9.48542804e-02f, 3.50800306e-02f, 6.27768561e-02f, 4.91626784e-02f, 5.96614368e-02f, 1.88763395e-01f, 6.51383102e-02f,
  1.01754554e-01f, 5.03256172e-02f, 6.39610738e-02f, 4.66465540e-02f, -4.64405119e-02f, 3.09234504e-02f, 8.16207752e-02f, 1.16363674e-01f, -9.88032576e-03f, 1.05785802e-01f,
  1.04056694e-01f, 2.25065444e-02f, 4.35044430e-02f, -5.63747846e-02f, -2.36578714e-02f, 4.60538715e-02f, 2.90701538e-02f, -6.70341998e-02f, -8.54034647e-02f, -7.68923983e-02f,
  1.14439927e-01f, -2.71793693e-01f, 1.14934467e-01f, -1.87146254e-02f, -1.49700548e-02f, -1.29663065e-01f, -3.05505842e-01f, -1.54028967e-01f, 5.43855838e-02f, 2.80271191e-02f,
  1.45467306e-02f, 2.44798735e-02f, 1.20733537e-01f, -6.75169230e-02f, 2.97172964e-02f, -1.54706404e-01f, -7.25675598e-02f, 1.42414302e-01f, 2.66910810e-02f, -8.89548883e-02f,
  -1.51964098e-01f, -1.60084814e-01f, 6.52114823e-02f, -2.84956489e-02f, -4.02596965e-02f, 6.60889149e-02f, -6.27023950e-02f, -8.38889182e-02f, -5.29842936e-02f, 5.56419156e-02f,
  1.59245089e-01f, 5.97639419e-02f, 8.72694515e-03f, -7.58089945e-02f, -2.69263182e-02f, -1.13311447e-01f, -1.11918196e-01f, -8.74207839e-02f, -5.48875146e-02f, -9.31789875e-02f,
  1.00595737e-03f, 1.50652705e-02f, -2.27547381e-02f, -9.99736041e-02f, 1.13735888e-02f, -7.36132264e-02f, -1.06000081e-01f, -9.80572030e-03f, -8.87993798e-02f, -6.66338429e-02f,
  -1.28614921e-02f, 7.42347017e-02f, 1.06790647e-01f, -7.36260936e-02f, -4.37857909e-03f, 9.98838097e-02f, -1.82886850e-02f, 7.29244351e-02f, 8.72586742e-02f, -1.17030919e-01f,
  -8.93320814e-02f, -2.09795441e-02f, 1.34752318e-02f, -4.33954820e-02f, 6.67659119e-02f, 4.94929822e-03f, 2.82100812e-02f, 1.04948843e-03f, -4.59195562e-02f, -7.31371120e-02f,
  1.13258444e-01f, 1.66966617e-01f, 1.89315472e-02f, 7.17214728e-03f, 1.37500077e-01f, 1.10183954e-01f, -1.62136331e-02f, 1.30190849e-02f, 2.37772409e-02f, 3.45100686e-02f,
  1.43046618e-01f, 1.05086267e-02f, 6.33136779e-02f, -6.43610209e-03f, 1.37886286e-01f, 3.29628661e-02f, -9.07361414e-03f, 1.15285702e-01f, 1.28051877e-01f, 7.84796104e-02f,
  -8.59922692e-02f, 9.39941406e-02f, 4.81066369e-02f, -5.66951782e-02f, -2.64059454e-02f, -1.54357990e-02f, -2.92156022e-02f, 5.05381003e-02f, 5.90393543e-02f, -9.70506221e-02f,
  -8.44475627e-02f, -4.17164974e-02f, -1.25471622e-01f, -4.77000363e-02f, -1.13414191e-01f, -7.74867237e-02f, -8.19638595e-02f, 6.30161017e-02f, 6.13697059e-02f, -7.49857817e-03f,
  -1.33196488e-01f, -8.65510032e-02f, 7.84810334e-02f, -7.70559609e-02f, -3.99137512e-02f, 2.80202497e-02f, -6.28378242e-02f, -1.14285670e-01f, -3.20892991e-03f, -2.21994922e-01f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.34874468e-02f, -3.74888539e-01f, -6.11610949e-01f, 5.48215210e-01f, 1.55505955e-01f, -4.22962755e-01f, -6.33180857e-01f, -3.37898999e-01f, 2.58974612e-01f, -5.09543568e-02f,
  2.74057388e-02f, 2.60788649e-01f, 8.70580897e-02f, -1.76079810e-01f, -4.03194547e-01f, -3.08094978e-01f, -1.03505529e-01f, -1.19368710e-01f, -1.77857041e-01f, -1.18237995e-02f,
  2.99327344e-01f, 3.49499375e-01f, 2.40651503e-01f, 1.14060059e-01f, 3.57688069e-01f, 2.03643560e-01f, 8.57730284e-02f, 2.40638569e-01f, -1.51579872e-01f, 7.97745511e-02f,
  -1.77123636e-01f, -4.07197237e-01f, -1.25502989e-01f, 1.61316320e-01f, 2.51216710e-01f, -1.69839963e-01f, -1.22941390e-01f, -2.68834159e-02f, -8.12461972e-02f, -1.27890289e-01f,
  1.40547171e-01f, -2.25893900e-01f, 1.58981159e-02f, -2.07175072e-02f, 1.45390242e-01f, -3.18488061e-01f, -5.00940643e-02f, -3.33221614e-01f, -1.60773203e-01f, -2.46103808e-01f,
  4.72504050e-02f, 1.23974524e-01f, -4.26161796e-01f, -2.86071330e-01f, -3.62711281e-01f, 1.44160450e-01f, -3.85858893e-01f, -2.48610258e-01f, -4.76733595e-01f, -1.81629941e-01f,
  -1.77944586e-01f, -1.86763983e-02f, 5.40104844e-02f, -3.53672765e-02f, 9.19915438e-02f, 3.43452655e-02f, 6.94255531e-02f, 2.17159595e-02f, -1.33702993e-01f, -8.32031444e-02f,
  -1.03457630e-01f, 6.24433234e-02f, 3.00326794e-02f, 2.10912712e-02f, 5.69098555e-02f, 2.09027026e-02f, 3.11280531e-03f, 6.67455345e-02f, 3.58657725e-02f, -3.89047302e-02f,
  3.55175957e-02f, -1.42909586e-01f, 1.60307407e-01f, -2.41432898e-02f, -1.67029068e-01f, -2.08942741e-01f, 1.76313259e-02f, -2.38476992e-02f, 1.54113071e-02f, -1.04703501e-01f,
  2.65957236e-01f, -9.06406939e-02f, -1.07052281e-01f, -1.47901624e-01f, 1.41392216e-01f, 4.14995775e-02f, 1.74192130e-03f, -2.96024252e-02f, -1.49213625e-02f, -2.59049386e-01f,
  -3.24940532e-01f, -2.63991594e-01f, 2.09335446e-01f, 4.60253097e-03f, -6.95501938e-02f, -1.98662326e-01f, 1.00242332e-01f, -1.36380836e-01f, -7.20449463e-02f, 5.97242415e-02f,
  1.37745991e-01f, -1.54260337e-01f, -1.88959554e-01f, -1.59026772e-01f, 8.47739726e-02f, -7.11022988e-02f, -2.47427464e-01f, -1.71456471e-01f, -3.22082669e-01f, -2.25602284e-01f,
  5.97908080e-01f, 1.58716634e-01f, 6.12960337e-03f, 7.25654364e-02f, 7.63194859e-02f, 1.89889848e-01f, 2.17202634e-01f, 7.73845613e-02f, -4.80841920e-02f, 1.59925759e-01f,
  2.38748848e-01f, 1.84112281e-01f, 1.75241213e-02f, -2.68676933e-02f, 1.66111082e-01f, -7.65087381e-02f, -4.66228351e-02f, 1.57939978e-02f, 1.04769133e-01f, 8.27541053e-02f,
  1.70060191e-02f, -2.75760442e-02f, -3.89846438e-03f, 8.44608899e-03f, -6.58986345e-02f, -8.26739669e-02f, 1.81831303e-03f, -2.54616477e-02f, 4.89286818e-02f, -1.73169985e-01f,
  -9.59750917e-03f, 1.48434862e-01f, 5.10538602e-03f, -1.47510529e-03f, -2.66581234e-02f, -2.90036127e-02f, 5.56957535e-02f, -7.56785646e-02f, 2.85902619e-02f, -1.45090640e-01f,
  -1.59246195e-02f, -3.40501554e-02f, 1.30953506e-01f, -5.45029603e-02f, 2.20133588e-02f, 6.77053407e-02f, -6.49524406e-02f, 9.04157758e-02f, 8.01185668e-02f, 4.96675856e-02f,
  -7.69279227e-02f, 4.40367870e-02f, 1.14702813e-01f, -8.41682404e-03f, 1.77088566e-02f, 5.46568213e-03f, 6.86675534e-02f, -2.71334453e-03f, 1.07976101e-01f, -2.49179397e-02f,
  5.37322536e-02f, 2.82047093e-01f, 1.67341769e-01f, 1.50400415e-01f, 2.16184661e-01f, 8.98499563e-02f, -1.71981622e-02f, 5.71848825e-02f, 8.27215053e-03f, 7.23294318e-02f,
  2.12491713e-02f, 1.95135698e-01f, 1.38061315e-01f, 1.43206596e-01f, 1.24166690e-01f, 1.75476506e-01f, 2.06679478e-01f, 3.52883153e-02f, 1.02770165e-01f, 1.05669722e-01f,
  1.44101143e-01f, 8.34956840e-02f, 7.41560850e-03f, 9.17546302e-02f, 1.91791683e-01f, 1.54369950e-01f, -6.58513419e-03f, 1.74022451e-01f, 3.45088057e-02f, 1.45307571e-01f,
  -2.64375299e-01f, 3.14009845e-01f, 3.01959254e-02f, -3.00952345e-02f, 5.44456840e-02f, -5.76339262e-05f, 2.25243457e-02f, -1.47051588e-01f, -8.54504481e-02f, -6.92460835e-02f,
  -2.28472538e-02f, -3.95835638e-02f, 3.86948250e-02f, -1.03257284e-01f, -3.50323990e-02f, -1.82184000e-02f, -8.20768476e-02f, -1.21919796e-01f, 4.48223436e-03f, 1.46291479e-02f,
  3.21664102e-02f, -9.08789784e-02f, 2.86408067e-02f, -2.44008414e-02f, -7.32580200e-02f, -6.26534596e-02f, -4.29413244e-02f, -6.78636134e-02f, 3.18019986e-02f, -1.31812841e-01f,
  -7.19389737e-01f, -1.46287113e-01f, 3.12057525e-01f, -2.22414792e-01f, 3.65656227e-01f, 4.76676017e-01f, 5.67375541e-01f, 4.56075519e-02f, -2.04511777e-01f, 1.71139255e-01f,
  -2.10702509e-01f, -3.59954089e-01f, -3.79359961e-01f, -9.08648819e-02f, 1.22426763e-01f, 5.01895070e-01f, 5.11860907e-01f, 1.05625279e-01f, -2.86120903e-02f, 1.09712161e-01f,
  1.99760079e-01f, -2.83922195e-01f, -4.90366340e-01f, -1.14270695e-01f, -1.58525482e-01f, -1.64535090e-01f, 1.57166347e-02f, -7.50942603e-02f, 1.16556808e-01f, 8.44036564e-02f,
  -1.85880750e-01f, -4.78094757e-01f, 1.31190017e-01f, -3.79312038e-01f, -2.68844217e-01f, -8.05155113e-02f, -8.10218602e-02f, -3.04034859e-01f, -9.62700173e-02f, 7.65151456e-02f,
  -1.84573412e-01f, -1.62373066e-01f, -1.61575362e-01f, 2.57121902e-02f, -2.45964512e-01f, -9.18302592e-03f, -1.69901654e-01f, -2.25598320e-01f, -1.62059277e-01f, -9.56554040e-02f,
  1.17079355e-01f, -1.15297474e-01f, -1.07084006e-01f, 9.96823013e-02f, -1.06235437e-01f, 5.10174185e-02f, -9.61164907e-02f, -3.96686494e-02f, -7.88943172e-02f, -9.40457433e-02f,
  1.98005930e-01f, 5.05284630e-02f, 5.27529679e-02f, -1.01316005e-01f, 2.82067358e-02f, -9.96183231e-03f, -1.17154174e-01f, -1.84106622e-02f, 1.17055047e-02f, -1.02972858e-01f,
  -3.64259668e-02f, 5.63883632e-02f, 6.13666663e-04f, -5.89422770e-02f, -3.43916789e-02f, 1.44081954e-02f, 2.00318590e-01f, -7.19767436e-02f, -2.89829485e-02f, -7.11577386e-02f,
  -3.18282880e-02f, -5.65992147e-02f, -1.45581245e-01f, 8.51788521e-02f, 1.41292796e-01f, -4.20228727e-02f, -5.86446226e-02f, 5.57059348e-02f, -3.47745828e-02f, 2.17137747e-02f,
  -4.90074784e-01f, 2.30168909e-01f, -1.75796852e-01f, -1.11607522e-01f, -1.43074572e-01f, -8.80962461e-02f, -2.67164111e-01f, 1.50457316e-03f, -1.34293094e-01f, -1.49687141e-01f,
  1.95557587e-02f, -1.31156266e-01f, -6.26942292e-02f, -2.93302722e-02f, 5.95313385e-02f, 1.38042197e-01f, 1.76404446e-01f, 1.60572678e-01f, 1.10420711e-01f, -4.55815829e-02f,
  1.69824272e-01f, 3.37827623e-01f, 3.16671617e-02f, 1.63611472e-01f, 3.96146951e-03f, 4.91936766e-02f, 5.07732555e-02f, 1.77310575e-02f, 1.19224228e-01f, 1.83432728e-01f,
  5.35687327e-01f, 3.85787398e-01f, -2.31174976e-01f, 4.30520833e-01f, -2.30109259e-01f, -5.00801444e-01f, -2.74457961e-01f, -2.21074238e-01f, 2.95786083e-01f, 3.35507214e-01f,
  5.48835509e-02f, -1.83054402e-01f, 8.82317964e-03f, -2.61024207e-01f, -4.32154387e-01f, 1.22477580e-02f, -7.38815516e-02f, -4.67690706e-01f, -7.63703585e-01f, -4.92203832e-01f,
  -4.75634560e-02f, 2.15062141e-01f, 8.65709856e-02f, -1.15705855e-01f, 3.60271573e-01f, 4.37376648e-02f, 3.72846156e-01f, 2.04632297e-01f, 7.47301290e-03f, 2.53947586e-01f,
  1.93505213e-02f, 4.56213094e-02f, -4.30877835e-01f, -9.44895744e-02f, 2.25567687e-02f, 2.79101375e-02f, -2.05270499e-01f, -7.09982142e-02f, -1.04553416e-01f, -6.45926669e-02f,
  -2.25397825e-01f, -1.80171087e-01f, -2.15764821e-01f, -2.75911298e-02f, -4.56025489e-02f, -2.73579150e-01f, 1.72574550e-01f, -1.82108790e-01f, -2.83544008e-02f, -2.09864348e-01f,
  3.73491794e-02f, -2.01142147e-01f, -2.52182990e-01f, -2.04690650e-01f, -1.50687218e-01f, -1.67268410e-01f, -2.94244615e-03f, -3.03341091e-01f, -2.73648500e-01f, 5.63439071e-01f,
  -1.56998951e-02f, -4.11913209e-02f, 5.12481704e-02f, 8.01643953e-02f, 1.25397250e-01f, 9.05837342e-02f, -5.05742058e-02f, -1.87059045e-02f, -1.25221446e-01f, -7.41256848e-02f,
  -1.23131640e-01f, -1.28820185e-02f, -1.08911619e-01f, -3.04458644e-02f, -7.83122256e-02f, -9.14255157e-02f, -1.25993475e-01f, 1.70113608e-01f, -9.94378552e-02f, 1.10729352e-01f,
  -7.40583688e-02f, -9.88172740e-03f, 6.38417676e-02f, -6.98894933e-02f, 2.29267646e-02f, 4.85674664e-03f, 9.77515429e-02f, -1.29586026e-01f, 1.54389003e-02f, -8.37642606e-03f,
  4.09659922e-01f, -2.56632984e-01f, 3.22087526e-01f, -1.21478528e-01f, -5.06595224e-02f, 4.19255570e-02f, 1.41897291e-01f, -6.87053800e-02f, -3.01090423e-02f, -4.82472405e-02f,
  -2.67214209e-01f, -8.98954794e-02f, -2.44550360e-03f, -1.05147235e-01f, -2.70342499e-01f, -9.36468244e-02f, 3.15011814e-02f, -2.05330886e-02f, -1.12832151e-01f, 1.42428894e-02f,
  2.92362124e-01f, -8.54591653e-02f, 3.34809199e-02f, 1.39876261e-01f, -5.96052818e-02f, -4.82112132e-02f, 6.83134124e-02f, -9.60370060e-03f, -2.22281948e-01f, 6.16215229e-01f,
  1.30660728e-01f, -3.20698880e-02f, 1.70643926e-01f, 1.94148690e-01f, 1.64991230e-01f, -3.32851052e-01f, -6.34914279e-01f, -2.44182825e-01f, 1.43602714e-01f, -1.80304632e-01f,
  6.60403222e-02f, 5.79834916e-02f, -1.13640100e-01f, -2.71239638e-01f, -3.92085761e-01f, -3.61063421e-01f, -1.83279023e-01f, -1.60226747e-01f, -2.33534023e-01f, -2.67467916e-01f,
  -1.37192056e-01f, 1.35401497e-02f, 9.41523910e-02f, 7.11495876e-02f, 4.76405263e-01f, 2.30247661e-01f, 2.23549590e-01f, 1.57081217e-01f, 2.18044650e-02f, 3.72491926e-01f,
  1.19183414e-01f, 3.65319401e-01f, -5.58557771e-02f, 2.25191444e-01f, 2.44500667e-01f, -7.16769099e-02f, -2.01599613e-01f, 1.46329716e-01f, -6.97197989e-02f, -5.35483919e-02f,
  3.76031846e-02f, 5.48330955e-02f, -6.40051216e-02f, -9.34763104e-02f, -4.16612364e-02f, -1.58616807e-02f, 6.41490743e-02f, -2.58948877e-02f, 5.89931943e-02f, 1.30923316e-01f,
  -1.46336764e-01f, 8.35592523e-02f, 2.65383516e-02f, 1.01887695e-02f, -7.01025175e-03f, -4.09503505e-02f, 1.12799138e-01f, 2.87216008e-01f, 8.26827660e-02f, 1.80126876e-01f,
  6.30885735e-02f, -1.40687805e-02f, -1.17588624e-01f, 3.49399559e-02f, -1.47640809e-01f, -6.03263825e-03f, 1.36516169e-01f, 3.36385827e-04f, -1.18191401e-02f, 1.46667473e-02f,
  -4.33836579e-02f, 1.03553414e-01f, 5.28685562e-02f, 6.55829161e-02f, 1.49040654e-01f, 1.69397220e-02f, 4.45530899e-02f, -7.01462477e-03f, -3.70592996e-02f, -2.48859394e-02f,
  -1.35279357e-01f, -1.30822351e-02f, 1.99592456e-01f, -5.69595285e-02f, 7.07302541e-02f, 7.62340724e-02f, -1.30258966e-02f, 7.97879323e-02f, 3.93750854e-02f, 7.34986737e-02f,
  -7.69820297e-03f, -1.38298973e-01f, -8.35011080e-02f, -9.84230936e-02f, 4.61008660e-02f, 2.20651209e-01f, 1.96466774e-01f, -5.19682467e-02f, 1.26320496e-01f, 1.88230760e-02f,
  -2.95645092e-04f, -9.56624746e-03f, 9.01184008e-02f, -1.78343669e-01f, -1.88101649e-01f, 2.33294554e-02f, -2.24317342e-01f, -2.09848341e-02f, -2.16248214e-01f, 1.59838304e-01f,
  -1.88933909e-01f, -3.81969482e-01f, -5.01705647e-01f, -4.06123281e-01f, -1.52710423e-01f, -3.31442505e-01f, -2.96879083e-01f, -6.98003918e-02f, -5.13356626e-01f, -6.11066997e-01f,
  5.48476338e-01f, 1.80271894e-01f, 2.52506316e-01f, 1.35508850e-01f, 3.43898050e-02f, 2.52401054e-01f, 4.88314956e-01f, 2.12130502e-01f, -1.71499420e-02f, 1.49638429e-01f,
  -1.54445127e-01f, -4.33295310e-01f, -2.56188273e-01f, -2.69408137e-01f, 1.05281502e-01f, 1.93372428e-01f, 5.60828522e-02f, 1.77852392e-01f, 7.41950050e-02f, 4.96764183e-02f,
  -1.21529587e-01f, 2.69629270e-01f, 2.19673321e-01f, 2.32337043e-02f, 3.33220325e-02f, -1.29498899e-01f, 6.96854293e-02f, 2.28571564e-01f, 6.67907819e-02f, -1.00871742e-01f,
  -1.11764804e-01f, 3.53087485e-01f, -2.36261085e-01f, -1.79104522e-01f, -9.10776183e-02f, -1.28843158e-01f, -1.30731374e-01f, -1.38209835e-01f, -8.91460404e-02f, -7.33606815e-02f,
  -6.52393252e-02f, -8.66672620e-02f, -2.23738458e-02f, -7.68670300e-03f, 8.80429521e-02f, -2.29559783e-02f, -3.15155368e-03f, 3.06101348e-02f, -1.39388919e-01f, -1.41269907e-01f,
  -2.53403664e-01f, -3.06440685e-02f, 1.19696550e-01f, -1.02694198e-01f, -4.87337634e-02f, -6.75990433e-02f, -3.40577997e-02f, 3.67018729e-02f, -1.02105243e-02f, 5.11789955e-02f,
  -2.88353384e-01f, -5.11327386e-02f, -1.14970565e-01f, 1.06175169e-02f, -2.45114341e-02f, -8.88437033e-02f, 1.00400392e-02f, -5.39496429e-02f, -9.17139128e-02f, 1.62527766e-02f,
  -1.38685554e-01f, -1.71753466e-02f, -1.84047483e-02f, -1.24159969e-01f, -2.10654393e-01f, -3.58255021e-02f, -5.42870872e-02f, -3.84812318e-02f, -1.07849151e-01f, 9.07067116e-03f,
  -2.61006039e-02f, -5.37478663e-02f, -6.31759539e-02f, -5.03220558e-02f, -1.54961750e-01f, -5.59246875e-02f, -9.42072794e-02f, -1.07194819e-01f, -5.07978462e-02f, -8.27785209e-02f,
  -3.26565564e-01f, -2.00647950e-01f, -2.08597884e-01f, -5.80574051e-02f, 1.23790968e-02f, -4.01521586e-02f, -1.75249994e-01f, -8.60619247e-02f, 4.51565124e-02f, 4.65248637e-02f,
  1.64042741e-01f, -6.31833524e-02f, -5.32061420e-02f, -1.08038701e-01f, -5.11040948e-02f, -5.02127632e-02f, -1.78986788e-01f, -7.10498765e-02f, -1.04843259e-01f, -9.37666222e-02f,
  -3.29752415e-02f, -5.74042462e-02f, -7.14748800e-02f, -1.15648352e-01f, -1.43891737e-01f, -1.70553908e-01f, -4.00845408e-02f, -2.10984293e-02f, -3.87063846e-02f, 6.44986928e-02f,
  -7.13436723e-01f, 1.22955345e-01f, 3.83667886e-01f, -3.89647245e-01f, 1.29973844e-01f, 2.67024517e-01f, 2.87467360e-01f, -3.04479394e-02f, -2.28326902e-01f, -1.37510777e-01f,
  -1.50450423e-01f, -2.24073961e-01f, 1.36114117e-02f, 6.03433363e-02f, 1.53459450e-02f, 3.54492724e-01f, 4.03543890e-01f, 1.20881759e-01f, -1.07250579e-01f, -6.92800805e-02f,
  2.83988044e-02f, -1.60430357e-01f, -3.34434658e-01f, -8.74705240e-02f, -7.05912849e-03f, 7.36261392e-03f, 7.46812224e-02f, 3.89232412e-02f, 1.06390782e-01f, 2.50520278e-02f,
  -3.71133476e-01f, -3.39427024e-01f, 3.25185835e-01f, -6.14363849e-02f, 9.79839563e-02f, -2.29733676e-01f, -1.15138091e-01f, -6.37388527e-02f, 6.13904521e-02f, 1.34806465e-02f,
  -8.69676098e-02f, -1.10392362e-01f, 6.84060678e-02f, 6.52986616e-02f, -1.07071124e-01f, -5.71238734e-02f, 8.95182714e-02f, -1.46360725e-01f, -4.55942266e-02f, -1.00649625e-01f,
  2.30619356e-01f, -1.20450795e-01f, -2.11205781e-01f, 3.20035398e-01f, 5.93823530e-02f, -2.17256725e-01f, -5.93441166e-02f, -2.80572444e-01f, -2.34098613e-01f, -3.47159833e-01f,
  -9.51409116e-02f, 1.91306755e-01f, 9.83740017e-02f, 2.37147976e-02f, -8.35056975e-03f, 4.85990234e-02f, 1.07632354e-01f, 1.58556532e-02f, 8.94305259e-02f, -2.43824217e-02f,
  4.03372198e-02f, -1.53009072e-01f, 3.48440069e-03f, -6.76099733e-02f, -1.07761368e-01f, -1.02125868e-01f, -1.11144640e-01f, -1.48260698e-01f, -4.67517301e-02f, -7.48154074e-02f,
  -9.44875330e-02f, -4.26180102e-03f, -1.35577142e-01f, 1.24077322e-02f, -7.23671867e-03f, 1.09798044e-01f, 5.50274514e-02f, 1.05531495e-02f, -2.71550138e-02f, 3.32025550e-02f,
  -2.90774018e-01f, 4.33487117e-01f, -1.98302165e-01f, 1.25110045e-01f, 1.44540425e-02f, 9.14291814e-02f, -6.24405555e-02f, 8.66809636e-02f, -4.66648629e-03f, -7.22379759e-02f,
  -9.21189487e-02f, -1.52714461e-01f, -1.23696953e-01f, 2.58855540e-02f, -2.70664487e-02f, -7.89147317e-02f, 6.45898702e-03f, -2.89796316e-03f, 1.69107229e-01f, -2.24418044e-02f,
  4.82294373e-02f, -2.34393150e-01f, -4.09135669e-01f, 2.42642872e-02f, -1.33429945e-01f, -4.13571864e-01f, -2.80747384e-01f, -1.98162436e-01f, -6.85837790e-02f, -2.82420039e-01f,
  2.70900987e-02f, -2.86858737e-01f, -1.60990283e-01f, -3.23013291e-02f, 1.32900000e-01f, -1.35254577e-01f, -3.51244837e-01f, -2.23997727e-01f, 2.98018511e-02f, -2.70858467e-01f,
  3.15815508e-02f, 2.85194248e-01f, -6.93229362e-02f, -1.30633801e-01f, -5.07849813e-01f, -7.25106180e-01f, -4.76785213e-01f, -3.67828369e-01f, -1.11015707e-01f, 1.00314364e-01f,
  9.06174257e-02f, 7.33995438e-02f, -7.02167079e-02f, 2.87167653e-02f, 2.07954392e-01f, 1.39025360e-01f, -1.63601458e-01f, 7.36375004e-02f, -1.93109274e-01f, -3.82322557e-02f,
  -1.39280841e-01f, 1.68961417e-02f, 7.53867254e-02f, 5.79814613e-02f, 1.10034486e-02f, 2.74214684e-03f, -8.50749686e-02f, 5.65618463e-02f, -3.02100461e-03f, -1.03419162e-01f,
  9.84491557e-02f, 9.48005766e-02f, -2.85534654e-02f, 1.23414010e-01f, -7.41305873e-02f, 5.04221246e-02f, -1.40995800e-01f, -1.35916665e-01f, -2.34805271e-01f, -3.55903152e-03f,
  2.28234776e-03f, -4.00604717e-02f, -1.89507067e-01f, -2.25131184e-01f, -1.08784229e-01f, -1.46428251e-03f, 1.15123622e-01f, 2.75796980e-01f, -2.05414444e-01f, 5.65592162e-02f,
  -1.79088518e-01f, -2.48687435e-02f, -1.61701161e-02f, 3.92921567e-02f, -1.64534934e-02f, 5.95949404e-02f, -5.24240173e-02f, -1.69041634e-01f, 1.36438876e-01f, 4.97163311e-02f,
  -2.67625563e-02f, -4.16445248e-02f, 6.64052144e-02f, -1.31607771e-01f, -5.26031218e-02f, 9.97006893e-03f, -9.62821990e-02f, -9.05694589e-02f, 5.81801012e-02f, -1.03781417e-01f,
  1.03630118e-01f, -2.64782831e-02f, 8.22229087e-02f, -1.61747802e-02f, -9.87008736e-02f, -2.35612601e-01f, -1.03698939e-01f, 1.21068299e-01f, 6.01186082e-02f, 4.23894450e-02f,
  1.14792297e-02f, -2.05450758e-01f, -3.18184718e-02f, -6.80262968e-02f, -7.99238458e-02f, 1.36149913e-01f, 8.38077590e-02f, 2.85272244e-02f, 1.06163055e-01f, 1.33967876e-01f,
  -5.20800799e-02f, -3.48508880e-02f, -1.34189188e-01f, 1.75675172e-02f, 6.20047301e-02f, 5.69351576e-02f, -3.31658930e-01f, 5.81621230e-02f, -3.71356867e-02f, 2.02621266e-01f,
  -1.54552907e-01f, -3.13836634e-01f, -3.14421028e-01f, -2.65967250e-01f, 4.51120399e-02f, -1.05598137e-01f, -1.24149859e-01f, 1.10515542e-01f, -3.51979971e-01f, -3.13685536e-01f,
  1.79631114e-01f, 3.44577968e-01f, 1.95410594e-01f, 3.70759159e-01f, 4.25819188e-01f, 2.60861546e-01f, 1.82120651e-01f, -1.73697039e-01f, 4.02891375e-02f, 1.82065293e-01f,
  2.17189699e-01f, 1.36742383e-01f, 9.54632685e-02f, -1.14050717e-03f, -1.39839649e-01f, -5.84859354e-03f, -7.31033012e-02f, -2.21407622e-01f, -9.15579423e-02f, 1.35793254e-01f,
  2.30438784e-01f, 1.18067645e-01f, -7.50718638e-02f, -5.69652431e-02f, 1.30701423e-01f, 1.08804204e-01f, 9.87752974e-02f, 1.62166163e-01f, 2.27818742e-01f, 5.28159179e-02f,
  3.42431180e-02f, 2.87128650e-02f, -2.34608278e-01f, 5.57115749e-02f, 6.29615113e-02f, -3.50700080e-01f, -1.96239948e-01f, -1.42982975e-01f, -1.51994273e-01f, -1.66216731e-01f,
  1.67959839e-01f, -5.38252667e-02f, 1.23771146e-01f, -5.10151722e-02f, -6.74026366e-03f, -1.13014728e-01f, -2.23406762e-01f, -1.56709641e-01f, -1.53440729e-01f, 4.25043935e-03f,
  2.31812850e-01f, 3.01349193e-01f, 1.58032775e-01f, -1.11686522e-02f, -1.24399453e-01f, -6.83849975e-02f, 3.81019637e-02f, -5.93379550e-02f, -1.06975108e-01f, -1.86033905e-01f,
  -1.75526887e-01f, 7.40775764e-02f, 4.90709431e-02f, -9.96396616e-02f, -4.02285298e-03f, -1.91834465e-01f, 4.06971350e-02f, 1.10790178e-01f, 3.94694433e-02f, -4.58888486e-02f,
  -3.41200829e-02f, -4.33081947e-02f, 4.19906303e-02f, -1.46936804e-01f, -4.14609164e-02f, -2.74820533e-02f, 1.15330242e-01f, -7.17813596e-02f, -2.20118370e-02f, -1.24249160e-01f,
  1.11740734e-02f, -7.57648349e-02f, -4.00536358e-02f, -6.37304485e-02f, -1.09213606e-01f, -1.85019925e-01f, -5.82095608e-02f, -1.26158416e-01f, -4.87055629e-02f, -1.54876128e-01f,
  -1.94060162e-01f, 3.16420719e-02f, -1.05529785e-01f, -1.28829181e-01f, 3.26103456e-02f, -7.80778229e-02f, 1.99382771e-02f, 6.25722557e-02f, 1.40931699e-02f, -2.32471094e-01f,
  3.72292027e-02f, -9.43867583e-03f, 1.26915406e-02f, -1.35239989e-01f, -1.53068572e-01f, -7.55276904e-02f, -3.91045660e-02f, 1.42517656e-01f, 2.44297516e-02f, 5.70695736e-02f,
  5.63137047e-02f, 1.49620883e-02f, 8.11618194e-02f, -6.67848065e-02f, -3.93474288e-02f, -1.69016961e-02f, -2.17535719e-01f, -1.90683931e-01f, -1.42568037e-01f, -2.55046517e-01f,
  -6.64043725e-02f, -3.75844777e-01f, -2.62262374e-01f, -2.36543894e-01f, -1.61762372e-01f, 1.23820826e-01f, 2.22100504e-02f, -7.17845261e-02f, 2.35431083e-03f, -1.12514384e-01f,
  -1.51079250e-02f, 1.44323558e-01f, 1.55262500e-01f, 1.23120442e-01f, 8.83023217e-02f, -5.01811225e-03f, -1.18730076e-01f, 1.08105324e-01f, 2.53361911e-01f, 1.56093776e-01f,
  -2.76383888e-02f, -2.19735242e-02f, -5.71284778e-02f, -1.20518617e-01f, -2.64508367e-01f, -2.95116454e-02f, -2.05036014e-01f, -2.37546876e-01f, -1.05310343e-01f, -3.72492909e-01f,
  1.72247767e-01f, 4.61855121e-02f, 3.46697643e-02f, 6.28760830e-02f, -8.32763985e-02f, 3.79613414e-02f, 8.67775083e-02f, -1.36482432e-01f, -2.15833038e-02f, -9.45849344e-02f,
  -5.81848919e-02f, -5.51034659e-02f, 4.38919701e-02f, -7.08258078e-02f, -9.56298783e-02f, 7.88964927e-02f, -4.95950207e-02f, 3.98983946e-04f, 1.72018372e-02f, -4.51120026e-02f,
  -3.49839367e-02f, -7.49684349e-02f, -9.72554460e-02f, 2.99397931e-02f, 2.03251258e-01f, 7.73903951e-02f, -6.63285330e-02f, 1.24378107e-01f, 1.15072899e-01f, 1.05471292e-03f,
  -1.33466616e-01f, -1.41122043e-01f, 7.14242309e-02f, 8.73200372e-02f, 1.75864160e-01f, 9.62583050e-02f, 4.72532623e-02f, 8.22850689e-02f, 6.25929981e-02f, 4.24789526e-02f,
  -1.45721972e-01f, 5.08013442e-02f, 7.67836347e-02f, -1.57092174e-03f, -4.74872068e-02f, -3.16703580e-02f, 3.00663840e-02f, 3.54418419e-02f, 1.05273701e-01f, 1.86790375e-03f,
  3.11018080e-02f, -1.08214103e-01f, -1.48127630e-01f, 6.48702383e-02f, -2.62659602e-02f, -1.32218271e-01f, -8.94258693e-02f, -2.05651056e-02f, 3.51321846e-02f, -1.12322308e-01f,
  2.43687145e-02f, 3.48968089e-01f, 3.37357000e-02f, 5.64595796e-02f, -2.79924925e-02f, -1.28584787e-01f, 1.32569507e-01f, 1.82685107e-02f, -9.61160660e-02f, 3.08375321e-02f,
  2.65543517e-02f, 8.00889730e-02f, 1.28552373e-02f, -1.14918007e-02f, 1.07711166e-01f, 3.49716917e-02f, 1.02641180e-01f, -3.88016738e-03f, 3.30726877e-02f, -1.42852187e-01f,
  -1.50606960e-01f, -2.15071104e-02f, 1.00061968e-01f, 9.89699960e-02f, 1.28150716e-01f, 2.13954940e-01f, 1.23170666e-01f, -2.01125890e-02f, 1.88723683e-01f, 3.10699036e-03f,
  6.99331760e-01f, -1.83224961e-01f, 2.79176801e-01f, 1.89940259e-01f, -2.16654092e-01f, -2.26359621e-01f, -3.47651869e-01f, -2.16715902e-01f, -6.32036626e-02f, 9.31847095e-03f,
  -4.16295491e-02f, 2.17368796e-01f, 6.88745677e-02f, 1.36717558e-01f, 1.78797081e-01f, -5.79376481e-02f, 1.21205010e-01f, 4.20824677e-01f, 3.92218888e-01f, 9.72393379e-02f,
  2.61770710e-02f, 1.80721730e-01f, 4.00824100e-01f, 2.54611880e-01f, 2.10618437e-03f, 1.15990989e-01f, 2.98360139e-02f, 9.45013911e-02f, 5.41919377e-03f, 3.01741928e-01f,
  3.32433671e-01f, 1.23710111e-01f, -3.70572740e-03f, 1.17047466e-01f, -3.94284464e-02f, -3.77921062e-03f, 4.02608514e-02f, 1.46496175e-02f, -5.49579151e-02f, -1.35225861e-03f,
  -2.68819593e-02f, 2.86177378e-02f, -8.54953825e-02f, -9.86193344e-02f, -1.10667095e-01f, 7.34950826e-02f, 3.98344621e-02f, 1.05301306e-01f, 7.14291111e-02f, 1.46605764e-02f,
  -1.13167435e-01f, -2.34609991e-02f, -1.08245827e-01f, -2.45268196e-01f, -3.08360085e-02f, 1.05432421e-01f, -4.37177829e-02f, 3.34919542e-02f, -1.23284627e-02f, 3.12207788e-02f,
  -1.20031545e-02f, 4.99555394e-02f, 4.98745032e-02f, 2.70110648e-02f, 2.74269097e-02f, 3.63822770e-03f, 3.24785896e-02f, -3.98198590e-02f, -7.76463700e-03f, 1.03556789e-01f,
  8.10466036e-02f, 2.02882811e-01f, 5.63647710e-02f, 1.02395199e-01f, 1.06677875e-01f, 8.09082910e-02f, 3.93537898e-03f, -7.82179609e-02f, 9.74639952e-02f, 4.10736911e-02f,
  1.32275745e-01f, 4.80733737e-02f, 3.32060270e-02f, -5.64070642e-02f, 3.82049605e-02f, 1.20583430e-01f, 1.24128602e-01f, 8.11928809e-02f, -3.12110782e-02f, -2.21423656e-02f,
  -2.20896930e-01f, -1.94716677e-01f, 1.67848155e-01f, 2.92424019e-02f, -7.49552399e-02f, 1.54364062e-02f, 3.94807681e-02f, -8.19879957e-03f, -1.67310517e-02f, -4.97073531e-02f,
  2.00695153e-02f, -8.52312893e-02f, -4.12295386e-02f, -6.72307834e-02f, -7.13111535e-02f, -5.65380864e-02f, -1.75899602e-02f, -7.21194744e-02f, -1.08004995e-01f, 6.21570088e-02f,
  -5.66061698e-02f, -2.31671557e-01f, 2.51905099e-02f, -1.95418194e-01f, -1.34020776e-01f, -6.31042793e-02f, -1.44095682e-02f, -6.72651455e-02f, -9.15483087e-02f, -1.03155792e-01f,
  -3.71386260e-01f, 2.81397432e-01f, -1.10013746e-01f, -3.06912035e-01f, -4.55678143e-02f, -2.64581889e-01f, -1.30834013e-01f, -5.88965952e-01f, -1.56216174e-01f, 4.93178070e-01f,
  3.88755023e-01f, 9.97274593e-02f, 9.54600722e-02f, 6.92605004e-02f, -2.32153550e-01f, 2.56451726e-01f, 3.11384171e-01f, -1.48021892e-01f, -5.12276232e-01f, -2.98018366e-01f,
  1.97628915e-01f, -1.51964381e-01f, -3.23868424e-01f, -3.11486632e-01f, 8.58149081e-02f, 7.57412314e-02f, 1.21516906e-01f, 2.44111102e-02f, 3.25432628e-01f, 4.44294453e-01f,
  4.54863667e-01f, -3.72136265e-01f, -1.42992631e-01f, -1.27146631e-01f, 7.14820102e-02f, -1.39545634e-01f, 1.15566580e-02f, -2.54472762e-01f, -4.95037660e-02f, 1.56207755e-01f,
  5.58709912e-02f, 1.03200927e-01f, -1.37904063e-01f, 1.26003996e-01f, -8.59750956e-02f, -2.49382615e-01f, -1.65975407e-01f, -3.19006324e-01f, -3.11783999e-01f, -7.30522871e-02f,
  2.49422505e-01f, 5.70926145e-02f, -3.04821759e-01f, -2.38530263e-01f, -3.20811212e-01f, -1.07117869e-01f, -2.37754270e-01f, -2.56460726e-01f, -3.23973507e-01f, 2.98108980e-02f,
  7.77343586e-02f, 2.93581150e-02f, -5.77993318e-02f, 5.75625971e-02f, 1.32807359e-01f, 1.79730996e-01f, 1.03484616e-02f, 3.59779149e-02f, 1.87170804e-02f, -4.77643907e-02f,
  -7.98340887e-02f, 2.33371053e-02f, -1.57995179e-01f, -2.22489730e-01f, -5.88621572e-02f, -1.98699739e-02f, 6.68052165e-03f, 1.47009060e-01f, 2.57442780e-02f, 6.70900717e-02f,
  -3.64756770e-02f, -4.92427610e-02f, 3.53591442e-02f, -4.84293550e-02f, 1.25097856e-01f, -3.89955379e-02f, -2.06008349e-02f, 6.74355105e-02f, -1.28652126e-01f, -2.18300987e-02f,
  -7.14363381e-02f, 3.39085795e-02f, 1.79726973e-01f, -6.43453598e-02f, 2.36338656e-02f, 4.19384576e-02f, 1.37253568e-01f, 8.11197311e-02f, 1.37681058e-02f, 2.41123233e-02f,
  -1.93296909e-01f, -7.74581134e-02f, 1.36786222e-01f, 5.40768765e-02f, -2.82980548e-03f, -1.31051898e-01f, 3.28489244e-01f, 1.61825836e-01f, 2.94753443e-02f, 1.06215045e-01f,
  7.05926046e-02f, -1.73759654e-01f, -3.32025625e-02f, -1.00066356e-01f, 7.10290447e-02f, -4.58132587e-02f, -3.36843058e-02f, -1.40064746e-01f, -1.97952047e-01f, 3.23719196e-02f,
  7.19015658e-01f, -1.36663064e-01f, -3.47444475e-01f, -2.87985150e-02f, -2.80900747e-01f, -1.88640147e-01f, -1.06357731e-01f, 6.58533350e-02f, 6.55118972e-02f, -8.40865076e-03f,
  -1.55136436e-02f, 8.80726576e-02f, 3.56979594e-02f, 9.15183201e-02f, 2.22275659e-01f, -1.11746505e-01f, -1.31038770e-01f, 2.55334582e-02f, 2.93407775e-02f, -7.38227442e-02f,
  5.15535139e-02f, 1.55648571e-02f, 1.74003571e-01f, -3.44259813e-02f, -2.57233739e-01f, -3.89089808e-02f, -1.64934173e-01f, -2.07244501e-01f, -1.37209281e-01f, -3.70247930e-01f,
  -3.23724985e-01f, -1.18793093e-01f, 1.34081632e-01f, 1.10390745e-01f, 3.13713066e-02f, 5.61858565e-02f, 9.35594365e-03f, 4.97072078e-02f, 1.32154271e-01f, -4.10256647e-02f,
  -5.37206307e-02f, 1.69285666e-02f, -8.37116167e-02f, -1.04471810e-01f, -1.03742726e-01f, 1.42442193e-02f, 6.26343191e-02f, -4.81406646e-03f, -1.21979625e-03f, -2.12527961e-02f,
  -1.70272291e-01f, -3.60244885e-02f, -1.15315139e-01f, 3.01872212e-02f, 5.51464707e-02f, 8.25063791e-04f, 8.33432972e-02f, -4.84253615e-02f, -3.38753387e-02f, 8.52654055e-02f,
  3.40597588e-03f, 1.77623510e-01f, 5.16866297e-02f, 8.91876370e-02f, 2.22085118e-01f, 3.63935269e-02f, 3.21701691e-02f, 1.01303764e-01f, 2.34727338e-01f, 1.31152660e-01f,
  1.57797895e-02f, 5.40829748e-02f, 8.06980655e-02f, -3.45410630e-02f, 1.81107968e-02f, -1.04648612e-01f, -9.27357748e-03f, -6.85670674e-02f, -5.10844924e-02f, -6.13108091e-02f,
  3.27327028e-02f, -5.09168282e-02f, -4.00147459e-04f, -7.19886124e-02f, -7.48110563e-02f, 1.87146235e-02f, -9.36381146e-02f, -7.74215115e-03f, -8.15387368e-02f, -7.50213563e-02f,
  7.22897658e-03f, -6.97817281e-02f, 1.34393111e-01f, 5.95031865e-02f, -5.58321327e-02f, -1.02676958e-01f, -5.54665104e-02f, -8.81566629e-02f, -7.04871193e-02f, -1.25146329e-01f,
  -2.44968049e-02f, 3.73954214e-02f, -5.00851795e-02f, 5.27669415e-02f, 1.61528334e-01f, 9.70229506e-02f, 1.26697764e-01f, 6.63718656e-02f, -8.91802309e-04f, -5.28317206e-02f,
  -4.77101430e-02f, 1.69570491e-01f, 2.33135149e-01f, 1.83587879e-01f, 1.26057804e-01f, 2.08603948e-01f, 7.80253559e-02f, 9.89658851e-03f, 6.54274318e-03f, 3.11812699e-01f,
  2.13245481e-01f, 5.88882454e-02f, 3.19870524e-02f, 2.82661706e-01f, 2.31011927e-01f, 1.75010115e-01f, 3.79743636e-01f, 1.12591036e-01f, -2.68381052e-02f, 9.61196497e-02f,
  2.24705875e-01f, 9.36705992e-02f, 2.67508589e-02f, 1.90219432e-02f, 5.16267456e-02f, -6.55854419e-02f, -7.88117200e-02f, -7.55476281e-02f, -5.25966333e-03f, -4.43458781e-02f,
  -3.82708535e-02f, 9.26506221e-02f, 7.96666741e-02f, 2.80137993e-02f, 3.02834646e-03f, 1.95578244e-02f, 1.73081338e-01f, 1.79927215e-01f, 7.64633017e-03f, -2.48900741e-01f,
  4.32667136e-02f, 4.40267250e-02f, 3.68967606e-03f, -1.56997249e-01f, 1.18061341e-01f, -5.28161079e-02f, 7.74306208e-02f, -7.87264407e-02f, -6.58708215e-02f, -4.57281582e-02f,
  -3.44456546e-02f, -4.77738865e-02f, 1.14473782e-01f, -4.64481115e-02f, 1.38948619e-01f, 3.72331627e-02f, -7.46439472e-02f, -9.65974480e-02f, 1.32568954e-02f, -1.72540590e-01f,
  -5.64560201e-03f, 5.32481559e-02f, 1.84874415e-01f, -4.07471061e-02f, -2.12758537e-02f, -8.22226750e-04f, 3.34073044e-02f, -5.26418239e-02f, 5.78062981e-02f, -1.28197938e-01f,
  2.79984862e-01f, 3.34301919e-01f, 2.39326090e-01f, 1.74330115e-01f, 3.64164859e-02f, 1.28510579e-01f, 2.95755379e-02f, 5.72607815e-02f, 1.98410198e-01f, 2.42817905e-02f,
  -1.29607478e-02f, 1.68411881e-01f, 1.27947465e-01f, 2.84593254e-01f, 1.46194354e-01f, 1.58259854e-01f, 1.70683593e-01f, 1.45438790e-01f, 2.30834737e-01f, 2.06297219e-01f,
  5.91276139e-02f, 1.65176362e-01f, 1.20341428e-01f, 9.32376534e-02f, 3.38877328e-02f, 2.17401490e-01f, 8.37187096e-02f, 1.80140808e-01f, 1.14229627e-01f, 2.11464286e-01f,
  1.32456884e-01f, 2.46746704e-01f, -6.95418492e-02f, -4.75319177e-02f, 7.51729086e-02f, -8.68819728e-02f, 3.94180901e-02f, -7.35064149e-02f, 1.34233488e-02f, 2.25919094e-02f,
  -3.38443667e-02f, -1.21416803e-02f, 1.82468250e-01f, -5.67864589e-02f, 5.66718131e-02f, 6.45479336e-02f, -3.29199694e-02f, -9.08808261e-02f, -1.53061107e-01f, -2.16705412e-01f,
  -1.18610546e-01f, -2.19346713e-02f, 1.19027093e-01f, -2.25178525e-02f, 5.75178228e-02f, 8.21782500e-02f, 9.00458843e-02f, -1.17928587e-01f, 7.06844777e-02f, -8.95964652e-02f,
  7.91826069e-01f, -1.99072003e-01f, -5.70453219e-02f, 2.15261027e-01f, -4.38996255e-02f, -5.15507013e-02f, -1.05429113e-01f, 1.33773917e-02f, 2.34908059e-01f, 4.99760583e-02f,
  -2.16704369e-01f, -6.51785433e-02f, 2.33831163e-02f, -1.02368854e-02f, 6.90055685e-03f, 1.14968847e-02f, 2.12871172e-02f, 1.99590996e-01f, 1.95333868e-01f, -1.56440716e-02f,
  -8.43409896e-02f, 1.44004777e-01f, 2.78086841e-01f, 1.04840994e-01f, -6.09985255e-02f, 6.30989969e-02f, -8.70048776e-02f, -1.59040153e-01f, -1.95341572e-01f, -1.19761634e-03f,
  -4.69229341e-01f, -9.36392397e-02f, 2.04174727e-01f, 5.91386482e-02f, -5.58511205e-02f, 7.05390275e-02f, 3.33050042e-02f, 2.93457555e-03f, -6.66548237e-02f, 8.62770826e-02f,
  -1.16478272e-01f, 8.45574494e-03f, -8.21470171e-02f, 2.52582738e-03f, -6.85206205e-02f, 1.18703414e-02f, -3.00453417e-02f, 2.48767175e-02f, -8.89093056e-02f, -1.57380253e-01f,
  -3.67275849e-02f, -8.13450515e-02f, -1.92512125e-01f, -8.68597850e-02f, 8.69205743e-02f, 8.07540864e-02f, -1.16728224e-01f, -3.94305512e-02f, -8.04125816e-02f, 1.41125426e-01f,
  1.19045481e-01f, 8.31868313e-03f, -1.56137362e-01f, -1.36135668e-01f, -4.81171273e-02f, 9.19304714e-02f, -5.22662960e-02f, -3.49194929e-02f, 3.16715166e-02f, 1.97356753e-02f,
  2.13933047e-02f, -1.76596537e-01f, -4.91340496e-02f, 4.84717377e-02f, 4.08790335e-02f, -1.43431216e-01f, 5.55071086e-02f, -2.65556257e-02f, -2.08122298e-01f, -1.56194180e-01f,
  2.81452853e-02f, -3.64728160e-02f, 2.38263421e-02f, -1.91261515e-01f, -6.20926172e-02f, -6.69070035e-02f, -2.91733141e-03f, 3.32599692e-02f, 1.26493722e-01f, 1.84383571e-01f,
  -2.87819862e-01f, -1.39887854e-01f, 1.29627958e-01f, -1.72032099e-02f, 7.07596540e-03f, 1.00446455e-01f, -7.56169707e-02f, -1.29337400e-01f, -1.94919154e-01f, -1.06102638e-01f,
  -8.02653432e-02f, 1.40105430e-02f, -8.40917528e-02f, 2.95769647e-02f, 4.45892625e-02f, 4.05314229e-02f, 7.74753047e-03f, 2.75908187e-02f, -2.54989509e-02f, -1.23065203e-01f,
  1.11239217e-01f, 1.44990087e-01f, 6.13944642e-02f, 1.61690131e-01f, 2.43751496e-01f, 9.21532437e-02f, 7.79510587e-02f, 8.77340287e-02f, 2.56051887e-02f, 2.82073647e-01f,
  4.90365177e-01f, 3.51473927e-01f, 4.22678173e-01f, 4.36503254e-02f, -2.94843346e-01f, -7.28460699e-02f, -4.06289548e-02f, 2.24498034e-01f, -1.11349091e-01f, -5.43420343e-03f,
  -1.77045166e-01f, -3.27725142e-01f, -6.30104914e-02f, -7.09692538e-02f, 2.02140123e-01f, 1.24446541e-01f, 1.73516691e-01f, 2.83155859e-01f, 3.50081593e-01f, 3.48887667e-02f,
  -1.90268084e-01f, 5.81933968e-02f, 4.18046087e-01f, 2.54081666e-01f, -1.46282673e-01f, -1.72146961e-01f, 9.34247598e-02f, 9.94073004e-02f, 1.50829798e-03f, 3.78935374e-02f,
  3.59331258e-03f, 3.23589742e-01f, -2.09810749e-01f, -1.86501250e-01f, 6.86845705e-02f, 4.85267788e-02f, -3.79769281e-02f, 1.08490974e-01f, -5.36532030e-02f, 7.77102858e-02f,
  -9.20032263e-02f, -7.37380609e-02f, 5.84506206e-02f, 6.11605644e-02f, -7.43390014e-03f, 2.91419793e-02f, 2.45639861e-01f, 1.89548820e-01f, 1.11331873e-01f, 1.06574938e-01f,
  -2.63550669e-01f, -8.09241310e-02f, 1.60000846e-02f, -4.88654934e-02f, 1.04740866e-01f, -1.53774589e-01f, 1.01515986e-01f, -2.28007678e-02f, 2.20330164e-01f, 1.84571192e-01f,
  -5.18062860e-02f, -2.06453279e-02f, -4.58697714e-02f, 6.42009899e-02f, 6.82049990e-02f, 8.34340900e-02f, -9.71197907e-04f, 4.52870354e-02f, 7.51440004e-02f, 3.43948491e-02f,
  1.07804589e-01f, 8.76395032e-02f, 1.47205383e-01f, 1.19371250e-01f, -8.61537904e-02f, 7.99529999e-03f, 7.27858320e-02f, -8.29334278e-03f, -1.32628288e-02f, 8.39196369e-02f,
  2.53668670e-02f, 1.11798033e-01f, 1.84091553e-02f, 2.35200644e-01f, 2.79976875e-02f, 7.86757097e-03f, 3.23851174e-03f, 9.74611007e-03f, -3.96091715e-02f, -7.10126106e-03f,
  -2.44075626e-01f, -6.62430674e-02f, -1.99085414e-01f, -3.69126759e-02f, -2.17589773e-02f, 1.51174590e-02f, -1.88875154e-01f, -7.09902048e-02f, -9.92928073e-02f, -9.07519981e-02f,
  7.05437586e-02f, -3.15816216e-02f, 1.55078983e-02f, 4.77026887e-02f, 3.41857597e-02f, -1.22742444e-01f, -6.49563074e-02f, -1.11604556e-01f, -1.14454851e-02f, -5.50554283e-02f,
  -6.96936995e-02f, -1.03746019e-01f, -2.13061735e-01f, -2.06865609e-01f, -1.52660191e-01f, -2.22241670e-01f, -1.78254262e-01f, -5.79613410e-02f, -3.47309955e-03f, -3.16431411e-02f,
  4.49344575e-01f, 2.86185861e-01f, -3.96273518e-03f, 2.03220174e-01f, 2.88528442e-01f, 3.23787630e-01f, 6.08980119e-01f, 4.14237231e-01f, 3.06405008e-01f, 2.04341248e-01f,
  -2.84113377e-01f, -9.07860100e-01f, -7.63530791e-01f, -4.90808576e-01f, -4.07232046e-01f, 2.90785819e-01f, 2.28194594e-01f, -5.41802168e-01f, -6.49590075e-01f, -3.17861497e-01f,
  -3.45789224e-01f, -2.79463604e-02f, -2.41214454e-01f, -2.83817887e-01f, 3.99088999e-03f, -3.64855677e-01f, 1.86209425e-01f, 6.98892474e-02f, -1.88887179e-01f, -7.42676184e-02f,
  -2.18082070e-01f, 1.81167930e-01f, -2.50389218e-01f, -3.98005903e-01f, -5.88166304e-02f, -1.86394498e-01f, -1.39415860e-01f, -3.93121988e-02f, -7.84788504e-02f, 1.05388410e-01f,
  -2.06727684e-01f, -1.68945312e-01f, -1.54656351e-01f, -1.56803355e-01f, -7.68226907e-02f, 1.18261427e-02f, -4.12773229e-02f, 3.03933583e-02f, -1.25485525e-01f, -7.01232776e-02f,
  -9.64993834e-02f, 1.17053956e-01f, 1.61689341e-01f, 8.90167579e-02f, 6.12539351e-02f, -1.57392681e-01f, 4.66142222e-02f, 6.33085473e-03f, 8.80684331e-02f, 2.93807507e-01f,
  2.21191019e-01f, 9.08864066e-02f, 5.90024367e-02f, 7.09426776e-02f, 1.38319269e-01f, -4.98177158e-03f, 1.00161880e-01f, -7.41980225e-02f, -6.15995005e-02f, -1.77391861e-02f,
  1.69162974e-01f, 2.25181818e-01f, -5.34707271e-02f, 4.93088067e-02f, -6.97309747e-02f, -8.43698084e-02f, -4.65092920e-02f, 1.04993917e-02f, -9.47142467e-02f, 2.69156434e-02f,
  -1.25550151e-01f, -1.12110384e-01f, -6.53068721e-02f, -4.52711843e-02f, 1.31986231e-01f, -7.55719393e-02f, -3.80322970e-02f, -1.00980923e-01f, 5.17385378e-02f, 3.80332656e-02f,
  -2.35282645e-01f, -2.25210175e-01f, 1.24067381e-01f, -9.05554891e-02f, 6.53698221e-02f, -7.52681121e-02f, -1.48965746e-01f, -2.87118671e-03f, 4.24591303e-02f, 2.10526332e-01f,
  -1.10440634e-01f, -9.08384398e-02f, -7.14677647e-02f, -9.02635977e-02f, -1.07214481e-01f, 8.76425393e-03f, 2.25610882e-02f, -5.36024570e-02f, -2.28613075e-02f, 1.55733922e-03f,
  2.22956195e-01f, 1.94299489e-01f, 5.63288555e-02f, 1.84365377e-01f, 1.46020859e-01f, -2.54353676e-02f, -4.38762940e-02f, 8.83458182e-02f, 1.09767020e-01f, 2.73067176e-01f,
  -6.42398953e-01f, -2.55977303e-01f, -3.29809338e-01f, -2.14224726e-01f, 2.29156166e-01f, -4.94160801e-02f, -1.13220945e-01f, -5.08630648e-02f, -1.56661302e-01f, -1.79299265e-01f,
  1.27346784e-01f, 2.24638693e-02f, -2.85596460e-01f, 7.47112334e-02f, -4.03326238e-03f, -2.92545378e-01f, -1.99334532e-01f, 2.09762398e-02f, 2.00343683e-01f, 5.31665862e-01f,
  2.63733000e-01f, 1.70155182e-01f, 1.42805725e-01f, 9.93100554e-02f, -1.14119910e-01f, 6.39356002e-02f, -1.49128631e-01f, -1.32988244e-02f, 1.02619529e-01f, -1.92965358e-01f,
  -3.82517576e-01f, -3.23031217e-01f, 8.90683681e-02f, 1.16224185e-01f, 1.17738232e-01f, -2.06138283e-01f, -1.15041979e-01f, -6.79547414e-02f, -2.07794067e-02f, -2.56423533e-01f,
  1.80673599e-01f, 2.67883912e-02f, 1.74432218e-01f, 2.16552801e-02f, -1.49442300e-01f, -1.67267188e-01f, -8.90379250e-02f, -2.15326995e-01f, -3.05805624e-01f, -1.35023415e-01f,
  3.85389447e-01f, 2.98302710e-01f, -2.63414174e-01f, -1.47039369e-01f, -2.91213781e-01f, 1.05826827e-02f, -3.79060511e-03f, 4.40698341e-02f, -1.89192995e-01f, -3.58371407e-01f,
  1.38054267e-01f, 1.50013668e-02f, 2.64049415e-02f, -8.95602480e-02f, -4.17665765e-02f, -5.87554500e-02f, 2.78609749e-02f, 1.39535755e-01f, 9.53119528e-03f, -4.62812819e-02f,
  -3.29061598e-02f, -2.53215116e-02f, -1.87524818e-02f, 5.18272072e-03f, 2.91993432e-02f, 2.84754634e-02f, -2.58234460e-02f, 8.79117027e-02f, 3.55358422e-02f, -2.61038598e-02f,
  -2.41171252e-02f, 4.69446033e-02f, 2.90481187e-02f, 6.55139461e-02f, -8.21269751e-02f, 2.39893589e-02f, -7.34318420e-02f, -6.00125864e-02f, -2.31750607e-02f, -3.26440670e-02f,
  -3.44547957e-01f, 1.58266708e-01f, -2.94352710e-01f, -1.27485525e-02f, 8.09401087e-03f, 5.89350611e-02f, -5.38509339e-02f, -4.33245115e-02f, -1.89789072e-01f, -1.39922783e-01f,
  3.46820168e-02f, -3.92668843e-02f, -1.55344665e-01f, 3.58027853e-02f, -7.26890638e-02f, -1.82233036e-01f, -9.85724926e-02f, -1.40948400e-01f, -1.25504509e-01f, 4.79882248e-02f,
  -2.75042474e-01f, -1.45436466e-01f, -3.56309831e-01f, -3.91108871e-01f, -1.72586128e-01f, -2.58494288e-01f, -2.18706608e-01f, -1.03069425e-01f, -3.43902379e-01f, -3.58015478e-01f,
  1.23839565e-01f, -1.39329612e-01f, -1.53232634e-01f, 8.44191313e-02f, 4.86485958e-02f, -4.06882092e-02f, -1.06564373e-01f, 6.16966151e-02f, 1.50665194e-01f, -4.38461713e-02f,
  -1.33965865e-01f, -1.63362309e-01f, -1.66626126e-01f, -2.26447120e-01f, -2.93025732e-01f, -3.56744766e-01f, -2.66250223e-01f, -1.93143621e-01f, -1.85403019e-01f, -7.68892840e-02f,
  -2.23249733e-01f, -2.03900576e-01f, -1.23543642e-01f, -2.90141534e-02f, -2.81729060e-03f, -1.11467957e-01f, -2.54491456e-02f, -1.36751637e-01f, -1.50337175e-01f, -2.24065244e-01f,
  -3.26333255e-01f, -8.90526772e-02f, 1.08212002e-01f, 6.84171543e-02f, 4.88400534e-02f, 3.32609564e-02f, -6.36798143e-02f, 5.06823473e-02f, 1.67322665e-01f, 1.12486281e-01f,
  4.09326032e-02f, 7.32331052e-02f, -6.83822706e-02f, 8.03412125e-02f, 6.39763102e-02f, 7.30525479e-02f, 1.12995319e-01f, 6.98205754e-02f, -3.71950329e-03f, 2.22652052e-02f,
  -8.82404819e-02f, 1.17684128e-02f, 1.48318648e-01f, 2.75114805e-01f, 1.72831789e-01f, 1.15756527e-01f, 1.00416012e-01f, 1.73324496e-01f, 1.02362782e-01f, 1.39257953e-01f,
  2.58609951e-02f, 2.88906902e-01f, 1.41761065e-01f, 1.01485580e-01f, 2.03509971e-01f, 1.48380131e-01f, 2.05704510e-01f, 1.07590012e-01f, -1.78098995e-02f, 4.84223515e-02f,
  -5.84635360e-04f, -4.63247532e-03f, -2.94265803e-02f, -6.75414549e-03f, -5.10641336e-02f, -6.62840009e-02f, -7.85912350e-02f, -1.11444697e-01f, 3.32268551e-02f, -3.11366543e-02f,
  -1.18460268e-01f, -8.86890143e-02f, 1.40511198e-03f, -7.30783418e-02f, 8.88264738e-03f, 5.06808981e-03f, -6.28220588e-02f, -4.48628701e-03f, -9.55432355e-02f, -1.13090113e-01f,
  1.15025407e-02f, -3.70103121e-01f, -2.30133235e-01f, -1.72936991e-01f, -2.67303712e-03f, 8.32478404e-02f, -1.76974133e-01f, -8.89032632e-02f, 2.07680315e-02f, 1.07539864e-03f,
  -1.75848175e-02f, -1.22310914e-01f, 6.98822178e-03f, 8.52474943e-02f, 1.31003797e-01f, 5.36963940e-02f, 2.92407684e-02f, 9.91060361e-02f, 4.94508110e-02f, 2.49570645e-02f,
  1.03859091e-02f, 9.42653418e-02f, 1.00452922e-01f, 1.54505953e-01f, 2.75994670e-02f, -4.28129286e-02f, 1.04342267e-01f, 7.87582919e-02f, 3.74802127e-02f, 2.75798142e-01f,
  2.27214128e-01f, 2.51015365e-01f, 1.39425308e-01f, 1.92883819e-01f, 2.46572942e-01f, 1.11546822e-01f, 1.05398729e-01f, -1.39137283e-02f, -2.32090447e-02f, 5.43091260e-03f,
  2.28178069e-01f, 8.36756229e-02f, 1.38541117e-01f, 3.68074365e-02f, 1.36659563e-01f, -3.26079838e-02f, -6.51057139e-02f, 5.60142398e-02f, 1.31402463e-01f, 4.54532057e-02f,
  1.43704146e-01f, 1.14718474e-01f, 6.12835363e-02f, -2.36856434e-02f, 9.44634378e-02f, 1.30833253e-01f, 6.77634403e-02f, 2.09710330e-01f, 1.78411692e-01f, 8.16592425e-02f,
  5.15791588e-02f, 1.37183279e-01f, -5.94981797e-02f, 3.59580442e-02f, -4.04459611e-02f, -6.41366914e-02f, -1.23966448e-01f, -8.44501331e-02f, 5.43540902e-02f, -1.65866837e-01f,
  -5.40847629e-02f, 5.39422780e-02f, 3.64240520e-02f, 3.70665006e-02f, 5.09949811e-02f, -1.35276109e-01f, -4.54153074e-03f, -9.69896466e-02f, -1.11261226e-01f, -1.02579489e-01f,
  2.54394431e-02f, 5.51001839e-02f, -3.52523848e-02f, -2.25145500e-02f, 5.58397220e-03f, 5.89930750e-02f, 9.31663737e-02f, 6.93190172e-02f, 2.24550739e-02f, -1.48492619e-01f,
  5.39769046e-02f, 3.88888419e-02f, 3.75893936e-02f, -2.16110591e-02f, 7.43873939e-02f, -6.32903054e-02f, -8.20679292e-02f, 1.13401571e-02f, -5.43968007e-02f, 1.30338222e-02f,
  -9.49779600e-02f, 1.70882065e-02f, -1.59910813e-01f, -2.39423644e-02f, 6.82346597e-02f, -7.14270025e-02f, -3.98056433e-02f, 3.44317853e-02f, 7.96416923e-02f, -1.02236770e-01f,
  -2.53906064e-02f, -1.09614775e-01f, 5.57528436e-02f, 5.67592727e-03f, -1.17236659e-01f, -8.27613287e-03f, 6.49954900e-02f, -3.64352725e-02f, 2.71046124e-02f, -6.32886216e-02f,
  -1.98287442e-01f, 7.34765083e-02f, -6.59447461e-02f, -1.09775156e-01f, 3.48673128e-02f, -1.88484378e-02f, 3.83146517e-02f, 1.38967242e-02f, 4.21804152e-02f, -1.78496335e-02f,
  2.91169323e-02f, -7.81100988e-02f, -2.88186520e-02f, -2.45576594e-02f, -1.48776993e-01f, -1.44986361e-01f, -6.17469437e-02f, 4.87024104e-03f, -1.59902140e-01f, -1.51791468e-01f,
  -4.70726117e-02f, -1.96187437e-01f, -1.70727223e-01f, -5.16091473e-02f, -1.89974327e-02f, 3.34589891e-02f, -4.07366231e-02f, -2.44823005e-02f, -7.82075450e-02f, -1.82498410e-01f,
  -4.52631086e-01f, -6.64165616e-02f, 3.06482643e-01f, 7.31207430e-02f, -1.06843642e-03f, -6.26316518e-02f, -1.52258843e-01f, -5.28389215e-02f, 1.04420729e-01f, 1.77880421e-01f,
  -1.64336100e-01f, -3.01419854e-01f, -1.86284542e-01f, -2.90413022e-01f, -4.22854900e-01f, 5.04767038e-02f, 1.19247854e-01f, -2.61723250e-01f, -5.08620322e-01f, -4.59019512e-01f,
  -4.06552762e-01f, -2.71793306e-01f, -2.85197467e-01f, -2.26831466e-01f, -3.16111036e-02f, -3.60653400e-01f, 1.28145933e-01f, -1.48148775e-01f, -3.85684252e-01f, -2.40844592e-01f,
  2.78751642e-01f, -1.19903319e-01f, -1.81576788e-01f, -2.66832560e-01f, -2.95162052e-02f, -2.33649500e-02f, -2.99971607e-02f, 1.31831720e-01f, -4.52596024e-02f, 1.05581835e-01f,
  6.39442727e-02f, 1.64395627e-02f, 7.30019659e-02f, 1.03889205e-01f, 8.44787210e-02f, 2.08182558e-02f, 1.40331343e-01f, -5.21696880e-02f, 3.46186720e-02f, 7.79339224e-02f,
  -1.04368664e-01f, -1.06663644e-01f, 1.35108709e-01f, -3.89331765e-02f, -1.55657396e-01f, 1.88715644e-02f, -7.92976543e-02f, -6.18585050e-02f, -5.79648502e-02f, -4.84348014e-02f,
  -1.54591966e-02f, 6.38024090e-03f, -1.00365572e-01f, -8.90519768e-02f, 5.20368069e-02f, 7.84943253e-02f, -2.80519761e-02f, 6.04646988e-02f, -7.85838347e-03f, 3.58446427e-02f,
  -3.83606479e-02f, -7.52944276e-02f, -2.28004958e-02f, -3.61666940e-02f, 4.61408757e-02f, 6.96637784e-04f, -3.55287641e-02f, 4.07723226e-02f, 8.26371685e-02f, -4.02593091e-02f,
  -1.29590690e-01f, -1.05993673e-02f, 4.33241650e-02f, -1.37404665e-01f, -1.07287027e-01f, -6.80451980e-03f, 9.81422663e-02f, -5.36328442e-02f, 8.20534602e-02f, 1.34156331e-01f,
  -3.56848538e-02f, -1.89240023e-01f, 2.81438641e-02f, -7.47951940e-02f, 1.22848138e-01f, 6.85549006e-02f, 6.05852231e-02f, 3.26252468e-02f, 9.17091370e-02f, -9.94026214e-02f,
  -9.18428823e-02f, 3.72720659e-02f, 1.94914460e-01f, 1.36781275e-01f, 5.78126721e-02f, 2.76058223e-02f, 9.86730754e-02f, 4.81460057e-02f, -3.04343626e-02f, 1.58605143e-01f,
  2.14356571e-01f, 8.62185657e-02f, 8.48520026e-02f, 9.45547372e-02f, -1.29266800e-02f, -4.09247242e-02f, 7.10664019e-02f, 1.17698237e-01f, -6.04175627e-02f, 1.93695858e-01f,
  7.49573708e-01f, -2.23999783e-01f, -3.64740878e-01f, 1.43110394e-01f, -2.64767528e-01f, -2.59272844e-01f, -1.81308165e-01f, 5.79879666e-03f, -1.08361147e-01f, -2.92739794e-02f,
  -7.40514100e-02f, 2.29200944e-01f, 1.87989488e-01f, 9.73026380e-02f, 3.84586543e-01f, -7.72252530e-02f, -1.54957950e-01f, 2.10721150e-01f, 1.52224123e-01f, -7.28897378e-02f,
  -1.18651889e-01f, 1.43351793e-01f, 2.65467107e-01f, -2.63908803e-02f, -4.03124124e-01f, -1.48329601e-01f, -2.15055659e-01f, -1.87843204e-01f, -2.57409394e-01f, -3.98312479e-01f,
  -1.81193486e-01f, -9.76818278e-02f, -8.46975371e-02f, -8.18188023e-03f, -1.42605960e-01f, -4.43352386e-02f, 1.72804240e-02f, -1.30473182e-01f, -6.22637756e-02f, -1.60936207e-01f,
  -1.60621837e-01f, -2.08611740e-03f, 1.80994216e-02f, -2.33344272e-01f, -7.64006972e-02f, -1.30627332e-02f, 2.53629573e-02f, 8.23795646e-02f, 1.06619485e-01f, -1.28753230e-01f,
  -9.47002918e-02f, -6.10279366e-02f, 5.85148744e-02f, -5.66107966e-02f, -9.65272188e-02f, 1.04736770e-03f, -2.68961489e-02f, -8.91362578e-02f, 9.08719655e-03f, -4.66259345e-02f,
  -1.71566263e-01f, 2.14104950e-02f, -1.13950476e-01f, -8.21901485e-02f, 3.99051085e-02f, 6.14659041e-02f, 1.19888887e-01f, 1.62972853e-01f, 9.85104665e-02f, -5.12069426e-02f,
  1.63531214e-01f, 3.98619957e-02f, 8.99684131e-02f, 1.05982274e-01f, -7.54187927e-02f, 2.54597291e-02f, 1.21985108e-01f, 1.20111495e-01f, 9.89450142e-02f, 5.02138101e-02f,
  7.59909600e-02f, 4.40739701e-03f, -9.54304487e-02f, 8.38885084e-02f, -2.33061239e-02f, 6.79502171e-03f, -2.30086525e-03f, 4.12056483e-02f, 5.17749926e-03f, 3.66058014e-02f,
  2.29616821e-01f, 3.47517312e-01f, -2.23572515e-02f, 1.00592181e-01f, -1.43245280e-01f, -1.11346930e-01f, -1.83102973e-02f, -3.11045684e-02f, -5.29497042e-02f, -4.81642410e-02f,
  -2.43689045e-02f, 4.96680252e-02f, 3.58400121e-02f, -7.84321204e-02f, 8.16367492e-02f, -1.29040360e-01f, 2.29628664e-02f, 9.50593203e-02f, 1.31706536e-01f, -1.17240258e-01f,
  -3.74189876e-02f, 1.96761385e-01f, 3.19335908e-01f, 8.79391581e-02f, -7.66325891e-02f, 1.31435052e-01f, 2.77409446e-04f, 3.33959274e-02f, 3.27658266e-01f, 1.75956801e-01f,
  -4.21833247e-01f, 6.07909024e-01f, -3.16357128e-02f, -2.85521179e-01f, 4.09529924e-01f, 3.93660665e-01f, 4.61047411e-01f, -6.54688552e-02f, -2.86046386e-01f, 1.32979512e-01f,
  4.71329480e-01f, -1.54865280e-01f, -1.89820990e-01f, -1.68282673e-01f, -1.45817533e-01f, 7.75484219e-02f, 7.93190449e-02f, -3.54976952e-01f, -4.09792483e-01f, 1.40578389e-01f,
  1.14735164e-01f, -1.25528917e-01f, -3.37930322e-01f, -3.10390413e-01f, -2.12240443e-02f, -2.01039195e-01f, 4.36555967e-02f, 1.89703047e-01f, 4.52586114e-01f, -4.32494618e-02f,
  -1.26759484e-01f, 2.62885481e-01f, -2.98528999e-01f, 1.03303567e-02f, 2.00689211e-01f, -2.16340318e-01f, -8.54536816e-02f, -2.56089538e-01f, 4.36027460e-02f, -1.95490107e-01f,
  1.21121228e-01f, 1.32367939e-01f, 2.28997082e-01f, -1.66447815e-02f, 8.41987059e-02f, 2.90396549e-02f, -2.64868289e-02f, -2.52648711e-01f, -1.75906271e-01f, 1.46560967e-01f,
  2.53066391e-01f, 4.02935565e-01f, 3.08596134e-01f, 1.19228706e-01f, -1.05036572e-01f, -7.31628388e-02f, 1.37627155e-01f, -2.56653298e-02f, -1.21645123e-01f, -3.85047078e-01f,
  -9.09782574e-02f, 6.02311380e-02f, 1.60829440e-01f, -1.57525882e-01f, -2.96362340e-02f, -9.72379595e-02f, -3.42266518e-03f, 9.36502442e-02f, -1.91491656e-02f, 1.78558435e-02f,
  6.23964071e-02f, -6.31247833e-02f, -1.15861803e-01f, -8.43879301e-03f, -9.91949886e-02f, 2.34375335e-02f, 7.08530992e-02f, -1.14308633e-01f, 1.43412694e-01f, -1.35142787e-03f,
  8.44695140e-03f, -5.25950156e-02f, -5.48615903e-02f, 1.25831515e-02f, 1.32519200e-01f, -1.02473930e-01f, -1.19907770e-03f, -1.04594141e-01f, 9.45152901e-03f, 3.01757604e-02f,
  -3.70199889e-01f, 1.46082386e-01f, -3.44032228e-01f, 1.92647532e-01f, 1.61291018e-01f, 1.37500882e-01f, 6.76813200e-02f, -2.62815300e-02f, 1.92225844e-01f, -1.76336557e-01f,
  1.35045975e-01f, -6.01214580e-02f, -1.74420048e-02f, 1.01390705e-01f, -5.51808849e-02f, -1.08372224e-02f, 1.63902104e-01f, -8.31684172e-02f, 5.68989143e-02f, 2.13834405e-01f,
  8.67870003e-02f, -7.07435142e-03f, -3.19910258e-01f, -2.01104805e-01f, -7.19357003e-03f, -4.36239272e-01f, -2.35831514e-01f, -8.97619650e-02f, -1.92209199e-01f, -4.73060906e-01f,
  7.06046028e-03f, 4.34070230e-01f, 1.83872413e-02f, -8.34574029e-02f, -1.86729461e-01f, -3.70627135e-01f, -1.46701008e-01f, -1.04050405e-01f, -2.09901065e-01f, 8.16714093e-02f,
  8.82533416e-02f, -2.90157404e-02f, 3.20727676e-02f, 6.67433888e-02f, -2.65744906e-02f, 6.01531118e-02f, -1.36749238e-01f, -1.00527629e-01f, -2.27951556e-01f, 1.19028911e-02f,
  1.48931161e-01f, 8.23228955e-02f, 8.98219943e-02f, 2.99955602e-03f, 2.96726316e-01f, 1.49863556e-01f, 9.02473852e-02f, 1.34141102e-01f, 8.22718814e-02f, 4.31906998e-01f,
  2.43917271e-01f, -2.51246512e-01f, -1.40119761e-01f, 5.50066195e-02f, -3.29820737e-02f, 4.47011590e-02f, -1.13858059e-02f, 2.02990472e-02f, -9.88349393e-02f, 1.15689216e-02f,
  -2.80203484e-02f, -3.00838668e-02f, -4.08418588e-02f, 6.14208095e-02f, 7.83260465e-02f, 4.98700924e-02f, -7.08344951e-02f, -8.41785595e-02f, 4.66750562e-02f, -3.52341644e-02f,
  5.50682563e-03f, -4.29699570e-02f, -1.82901889e-01f, -2.58214444e-01f, -2.20701680e-01f, -1.19784899e-01f, 2.32401881e-02f, -1.68766752e-01f, -1.41776890e-01f, 9.38071832e-02f,
  -2.34818578e-01f, 4.61019315e-02f, -5.59037253e-02f, -1.52844116e-01f, -6.85126409e-02f, -1.45194948e-01f, -4.07246221e-03f, -4.94283326e-02f, -1.52289644e-01f, -1.00264303e-01f,
  6.43560961e-02f, -8.94072279e-02f, -1.56385690e-01f, -1.65193584e-02f, 2.23640017e-02f, 1.83942690e-02f, 3.23035605e-02f, -2.56013032e-02f, -1.60711989e-01f, -6.63159266e-02f,
  -6.16668910e-02f, 2.23815180e-02f, 6.27929717e-02f, 1.15013393e-02f, -1.91961101e-03f, -1.31019950e-02f, -1.09396704e-01f, -8.57874379e-02f, 7.17169121e-02f, 1.25488311e-01f,
  3.51303548e-01f, -3.94163013e-01f, 2.05875680e-01f, 1.35725930e-01f, 7.89680853e-02f, 1.10376269e-01f, 3.79200988e-02f, 3.79316919e-02f, 5.36389202e-02f, 4.42504175e-02f,
  2.00547744e-02f, 8.10517743e-02f, -2.61222059e-03f, 9.36869606e-02f, -1.27781183e-02f, -9.71281081e-02f, 1.61935493e-01f, 1.54457211e-01f, 1.26169071e-01f, 1.84577912e-01f,
  1.80012882e-01f, -1.35045322e-02f, 4.90994863e-02f, -2.00464725e-02f, -1.08351044e-01f, -8.54362547e-02f, 5.30770086e-02f, -2.31128652e-03f, 3.04895844e-02f, 1.77179456e-01f,
  8.13316256e-02f, 1.10258184e-01f, -7.69499689e-02f, 1.87498525e-01f, -1.00904396e-02f, -8.04317072e-02f, -4.99035902e-02f, 6.50160909e-02f, 2.07363382e-01f, 7.56903691e-03f,
  -1.66047707e-01f, -1.34118617e-01f, -2.49149635e-01f, -1.62031740e-01f, -2.91131884e-01f, -1.10400468e-01f, -1.05899796e-02f, -2.03986898e-01f, -1.87893361e-01f, -1.95736274e-01f,
  -1.43348709e-01f, 1.61727928e-02f, 2.09225062e-02f, -5.95922023e-02f, 1.74090937e-01f, -6.88207150e-02f, 1.27677470e-01f, 1.06778823e-01f, -2.14736044e-01f, 1.46494806e-01f,
  -2.19420910e-01f, -2.25181486e-02f, -9.96851027e-02f, -1.39254227e-01f, 1.22554831e-01f, 2.07714558e-01f, 1.29003599e-01f, 9.78425890e-02f, 1.92989558e-01f, 1.56076521e-01f,
  1.57770902e-01f, -3.24692726e-02f, 1.12252608e-01f, 1.19004101e-01f, 1.11976646e-01f, 3.57757509e-02f, 1.18247263e-01f, -1.37088746e-01f, -8.37865323e-02f, 6.40234025e-03f,
  1.88585278e-02f, -1.85997095e-02f, -6.08837642e-02f, -1.49637070e-02f, 2.42285542e-02f, -1.93942204e-01f, -1.05467930e-01f, -1.34315148e-01f, -1.56074777e-01f, 1.26979560e-01f,
  1.16713107e-01f, 1.44113647e-02f, 4.86761183e-02f, 6.30359203e-02f, 1.27079979e-01f, 1.44263819e-01f, 3.27274323e-01f, 1.90501615e-01f, 7.35620111e-02f, 8.02331716e-02f,
  1.06436320e-01f, 1.49079844e-01f, 2.89258361e-01f, 1.93502039e-01f, 7.67842680e-02f, 1.20460816e-01f, 9.74930897e-02f, -1.56135354e-02f, 1.36796013e-01f, 3.10241193e-01f,
  6.24053255e-02f, 1.50911599e-01f, 1.26220569e-01f, 7.83402622e-02f, -1.57691371e-02f, 1.09532280e-02f, 1.00129753e-01f, 1.52776331e-01f, 1.51608825e-01f, 1.03194684e-01f,
  2.48053417e-01f, -1.44516036e-01f, -3.06597371e-02f, 2.88121477e-02f, 6.87140003e-02f, 2.33608648e-01f, 1.62422672e-01f, 6.50315285e-02f, 1.90491781e-01f, 2.13248014e-01f,
  5.14064915e-02f, 4.87828627e-02f, 4.23611365e-02f, 6.72360659e-02f, 9.56951082e-02f, 1.18878558e-01f, 5.77890016e-02f, -1.10361747e-01f, -4.47186343e-02f, 1.16678827e-01f,
  -6.47948384e-02f, -3.33787389e-02f, -8.85602236e-02f, 2.19723769e-02f, -6.56411052e-02f, -4.02092785e-02f, -7.86073357e-02f, -3.61172445e-02f, -7.69122466e-02f, 1.90687522e-01f,
  6.87190711e-01f, 3.08639258e-01f, 8.34600329e-02f, 3.92326340e-02f, 9.11494121e-02f, 1.08935148e-01f, 3.59066725e-01f, 1.85168803e-01f, 8.17249436e-03f, 7.22233504e-02f,
  6.24809302e-02f, 5.66210337e-02f, 5.93519956e-02f, 1.30906980e-02f, 1.62271217e-01f, -2.55192798e-02f, 1.48409642e-02f, 4.74677943e-02f, 9.82202888e-02f, 4.80356142e-02f,
  -6.89354837e-02f, 1.42399758e-01f, 1.26545802e-01f, -3.27782631e-02f, -1.36791244e-01f, -2.21754611e-01f, -9.22964588e-02f, -8.73770937e-02f, 2.09823344e-02f, -1.90357625e-01f,
  -3.29106927e-01f, 2.00780734e-01f, -1.82096541e-01f, -2.10983232e-01f, -2.79623736e-02f, 5.69158867e-02f, 5.83662912e-02f, -8.17265511e-02f, 5.92053356e-03f, -2.26268750e-02f,
  -1.57443494e-01f, -9.48607624e-02f, 6.75494671e-02f, 5.74265234e-02f, -3.64607684e-02f, -4.91468906e-02f, 7.94120952e-02f, 1.22724138e-02f, 3.41766067e-02f, -2.29137614e-02f,
  -6.15644790e-02f, -2.24120338e-02f, 2.86182798e-02f, -5.76960929e-02f, 1.12316892e-01f, 5.42507991e-02f, 6.04833066e-02f, 7.86119401e-02f, 1.06594436e-01f, 2.33828258e-02f,
  -1.58795699e-01f, 1.12078190e-01f, 3.48465256e-02f, -8.00996926e-03f, 1.79722473e-01f, -2.82330066e-02f, -5.36829345e-02f, -2.58800499e-02f, 8.23848695e-02f, 3.00950315e-02f,
  -1.43951192e-01f, 3.65742594e-02f, 1.54846698e-01f, -3.44952829e-02f, 8.81130248e-02f, 1.15887495e-02f, -1.76389161e-02f, 7.39779472e-02f, -4.61865328e-02f, -2.03256942e-02f,
  6.52084723e-02f, 4.31153849e-02f, -4.07608859e-02f, 2.06545256e-02f, 2.54299883e-02f, 5.39928749e-02f, -8.92745554e-02f, 7.84753338e-02f, 9.18898135e-02f, 9.90797579e-02f,
  -3.80019099e-01f, 2.34433725e-01f, -3.85471024e-02f, -5.74652031e-02f, -8.56576785e-02f, -8.33221599e-02f, 6.80890307e-02f, -1.46033138e-01f, -2.16393262e-01f, -1.39805317e-01f,
  -9.18146744e-02f, 5.84093481e-02f, 1.61473118e-02f, 1.46110490e-01f, 1.32320439e-02f, -5.18163443e-02f, 2.17537843e-02f, 5.49594350e-02f, -1.54464468e-01f, -1.66781619e-01f,
  7.63806552e-02f, 1.26971260e-01f, 3.35503444e-02f, 8.61694571e-03f, 8.02067965e-02f, 6.19825795e-02f, -1.46148540e-02f, -3.03089619e-02f, 1.24397524e-01f, 1.25348464e-01f,
  2.78612107e-01f, -1.54130459e-01f, 5.85094810e-01f, -2.61632968e-02f, -5.42990386e-01f, -4.79532748e-01f, -6.64253771e-01f, -2.46071532e-01f, -1.94339141e-01f, -2.94589520e-01f,
  -6.46604657e-01f, -3.85369152e-01f, 2.21628383e-01f, 9.07744691e-02f, 1.57253057e-01f, 4.44524363e-02f, 3.40255320e-01f, 5.67267776e-01f, 5.67285046e-02f, -5.60832441e-01f,
  -4.58213151e-01f, -2.67590303e-02f, 3.25546741e-01f, 2.68230319e-01f, -3.87508050e-02f, -1.65633168e-02f, 4.51420307e-01f, 5.59921525e-02f, -2.70070750e-02f, 4.86746013e-01f,
  3.21487695e-01f, 2.30135560e-01f, -9.95958317e-03f, -5.52749373e-02f, 2.88441051e-02f, 2.64202096e-02f, -3.45433652e-02f, 3.61722738e-01f, -3.61934155e-02f, 1.16534953e-04f,
  -1.98858619e-01f, -1.01839572e-01f, -4.42001224e-02f, -4.72365804e-02f, -2.00466573e-01f, -8.28940570e-02f, 3.61765504e-01f, 4.23828363e-01f, 4.51754004e-01f, -1.47557274e-01f,
  -6.30526006e-01f, -3.75505060e-01f, 7.15412050e-02f, -5.53333536e-02f, 7.99749941e-02f, 1.84244454e-01f, 6.69595897e-02f, 2.65487302e-02f, 2.12475136e-01f, 3.85417908e-01f,
  -1.22804523e-01f, -1.94676826e-03f, 1.52386665e-01f, 1.30462512e-01f, -1.15313210e-01f, -1.17025502e-01f, -4.86766994e-02f, -4.48353812e-02f, -9.76572465e-03f, -2.88347621e-02f,
  -4.54762764e-02f, -1.12679087e-01f, -1.12368567e-02f, -8.68320093e-02f, 3.86733338e-02f, 7.31519088e-02f, -1.34670764e-01f, 2.13440970e-01f, 1.54693395e-01f, -8.04305822e-03f,
  -3.34730335e-02f, -2.39799805e-02f, 1.60142452e-01f, 1.24804281e-01f, 2.35448182e-02f, -2.27124617e-03f, -9.52248946e-02f, -8.45448002e-02f, 1.27787113e-01f, -1.79268837e-01f,
  -8.30523446e-02f, -3.76173854e-02f, -4.71730456e-02f, 9.93238986e-02f, -4.79968861e-02f, -9.39290598e-03f, -1.55036047e-01f, 1.10751957e-01f, -2.70269960e-02f, -9.49928164e-02f,
  -2.66783297e-01f, -2.22170457e-01f, -3.24412957e-02f, 3.46625187e-02f, -2.11170554e-01f, -1.47776231e-01f, -3.49974006e-01f, -4.47205566e-02f, -1.05412826e-01f, -1.45571038e-01f,
  -5.67117780e-02f, -4.29185212e-01f, -2.93293715e-01f, -2.50555515e-01f, -2.50828445e-01f, -3.34027439e-01f, -9.37369242e-02f, -1.45286739e-01f, -3.15119654e-01f, -2.30457813e-01f,
  -5.88135608e-02f, -3.20103280e-02f, 1.59331523e-02f, 5.39442971e-02f, 6.11901730e-02f, 1.72029763e-01f, 8.61641020e-02f, 1.37639791e-01f, 1.08895175e-01f, 1.81988813e-02f,
  3.00086513e-02f, 1.34201542e-01f, 1.72096997e-01f, 1.88103944e-01f, 1.67574883e-01f, 5.41029908e-02f, 2.01849163e-01f, 1.56322703e-01f, 1.39904320e-01f, 2.48603877e-02f,
  1.22555997e-02f, 1.19609930e-01f, 2.24594027e-01f, 1.43186182e-01f, 9.41495970e-02f, 4.57205735e-02f, 1.32731512e-01f, 1.11692876e-01f, 7.47882426e-02f, -9.62168649e-02f,
  -2.68383026e-01f, 8.35699737e-02f, -5.52481832e-03f, -5.47799394e-02f, -2.60514505e-02f, -1.39415443e-01f, 1.91608313e-02f, -1.26940861e-01f, 8.77335519e-02f, 4.61192876e-02f,
  -3.52334753e-02f, -1.05203353e-01f, -1.02943869e-03f, -2.17714496e-02f, -5.26724569e-02f, -4.38888073e-02f, 3.54230516e-02f, 8.62574726e-02f, 2.26111621e-01f, -1.17805175e-01f,
  -2.77554560e-02f, -1.27165556e-01f, -7.41034672e-02f, 6.69552907e-02f, 2.21893504e-01f, 5.35282902e-02f, 1.21476479e-01f, -1.65731590e-02f, 5.55348657e-02f, -1.11264452e-01f,
  2.37105135e-02f, -4.36428972e-02f, 7.17866719e-02f, -7.45441318e-02f, 5.46005517e-02f, -7.04812855e-02f, -6.32203221e-02f, 1.41987363e-02f, 1.91399045e-02f, -8.97846222e-02f,
  2.55706199e-02f, -1.27281090e-02f, -5.15716113e-02f, -3.04627493e-02f, 3.71919125e-02f, -1.19040143e-02f, -7.01386407e-02f, 1.76437497e-02f, 1.32174082e-02f, 3.04425210e-02f,
  1.34662792e-01f, 4.18948289e-03f, -6.47567818e-03f, -1.43932905e-02f, -8.47402215e-02f, 5.30675100e-03f, -5.56254275e-02f, -3.92679088e-02f, -4.67933249e-03f, 9.21213906e-03f,
  -1.50909856e-01f, 2.90173173e-01f, -1.85122311e-01f, 9.21122879e-02f, -1.25489473e-01f, 8.97987746e-03f, 6.45947158e-02f, -5.39683513e-02f, 3.21531855e-02f, -6.83949143e-02f,
  3.27555160e-03f, -3.57585587e-02f, -5.46845868e-02f, 1.02153718e-01f, -4.84247319e-02f, -1.42950118e-01f, -1.56691372e-01f, -1.01851717e-01f, -1.43208588e-02f, -1.89813137e-01f,
  2.24424042e-02f, -2.83807069e-01f, -2.25768894e-01f, -8.36067721e-02f, 1.52818086e-02f, -1.82639465e-01f, -3.55688743e-02f, -1.43047109e-01f, 3.04683624e-03f, -1.51443169e-01f,
  3.29445094e-01f, -6.98552802e-02f, 2.65968263e-01f, 3.19720507e-01f, 2.73968250e-01f, 3.50991160e-01f, 2.56989837e-01f, 3.59142065e-01f, 2.73001641e-01f, 1.87558725e-01f,
  -2.19823942e-02f, 9.35681239e-02f, 1.21808812e-01f, 9.38030034e-02f, 2.31272951e-01f, 2.81789988e-01f, 2.71414161e-01f, 1.78899065e-01f, 1.58438563e-01f, 1.95319667e-01f,
  1.54270694e-01f, 9.97978151e-02f, 1.06971301e-01f, 4.00239713e-02f, -2.30055558e-03f, 3.42867263e-02f, 8.85895733e-03f, 7.52636651e-03f, -6.29913807e-02f, 1.05855130e-01f,
  -1.85713753e-01f, -1.95005476e-01f, 5.00716865e-02f, -4.97825891e-02f, -2.22908944e-01f, -7.64522180e-02f, 3.26503627e-02f, -9.03895646e-02f, -1.06461264e-01f, -1.10141449e-01f,
  -1.67938292e-01f, 1.24442494e-02f, -4.23641969e-03f, -1.25049278e-01f, -1.42674148e-02f, -7.59474859e-02f, 4.62795794e-02f, 1.20860033e-01f, 8.61805584e-03f, -8.30329359e-02f,
  -5.21078929e-02f, 7.26213381e-02f, 1.78172495e-02f, -5.72910160e-02f, -9.20796618e-02f, 5.09711765e-02f, -7.86691010e-02f, 2.07609739e-02f, -1.48199210e-02f, 2.91614253e-02f,
  1.70603514e-01f, 1.82852805e-01f, 8.94631594e-02f, 1.91410199e-01f, 3.27904858e-02f, -9.53385420e-03f, 1.08333349e-01f, -2.78133024e-02f, 1.04111880e-01f, -3.29449102e-02f,
  5.48527623e-03f, -7.27635203e-03f, 1.59499153e-01f, -4.96035293e-02f, -5.84700219e-02f, 9.96207297e-02f, -7.93397985e-03f, 3.18573229e-02f, -1.30893691e-02f, 3.96270156e-02f,
  -4.70662750e-02f, -4.34053279e-02f, -1.32955700e-01f, -1.70799434e-01f, -8.59209746e-02f, -4.87617329e-02f, -2.83551309e-02f, -1.08362950e-01f, -9.09009203e-02f, 3.86268832e-02f,
  1.04160026e-01f, -3.49928555e-03f, 9.99222174e-02f, 3.32270786e-02f, -2.36792974e-02f, -1.20039463e-01f, 8.34157243e-02f, -2.59726681e-02f, -1.80854142e-01f, -7.37949312e-02f,
  -1.47701174e-01f, -5.15978411e-03f, -8.99304301e-02f, -2.57473662e-02f, -6.58938363e-02f, 2.69089360e-02f, 1.38678178e-02f, 1.80538535e-01f, -2.11557932e-02f, -1.47450566e-02f,
  5.86340427e-02f, 2.45063409e-01f, 7.08859265e-02f, 1.48221701e-02f, 1.04207657e-01f, 4.08226699e-02f, -1.73980761e-02f, 3.00518442e-02f, -8.48458558e-02f, 2.88772513e-03f,
  4.47212338e-01f, -2.60642171e-01f, -1.90448284e-01f, 2.37559229e-01f, 7.26996437e-02f, -9.93992016e-02f, -4.46491748e-01f, -2.93417662e-01f, 2.04139665e-01f, -2.74666429e-01f,
  -1.90193430e-01f, 1.65661126e-01f, -1.62494066e-03f, -1.60583019e-01f, -3.74654591e-01f, -6.85849428e-01f, -5.27054965e-01f, -2.23227471e-01f, -4.51008156e-02f, 1.05671927e-01f,
  1.22998834e-01f, 1.90884560e-01f, 6.81407675e-02f, -1.42898026e-03f, 1.59316674e-01f, 1.80167943e-01f, -2.11494058e-01f, 5.50352894e-02f, -1.61995113e-01f, 1.51912063e-01f,
  -8.33575949e-02f, 2.65527427e-01f, -5.59655614e-02f, 4.70943600e-02f, 2.87532602e-02f, -3.41893993e-02f, -8.32113177e-02f, 6.84594661e-02f, 9.38012153e-02f, 2.78679803e-02f,
  3.86915542e-02f, 1.01895474e-01f, 5.09966388e-02f, 1.71248391e-01f, -6.11168109e-02f, 1.37041286e-01f, -8.43156800e-02f, -8.25340301e-02f, -6.25758469e-02f, 4.47853766e-02f,
  1.87648579e-01f, 3.52087915e-02f, -1.43478528e-01f, -1.12972908e-01f, -4.48357463e-02f, 1.79405943e-01f, -3.71376122e-03f, 2.49882579e-01f, -9.11027640e-02f, -2.21505929e-02f,
  1.08279204e-02f, 1.12675086e-01f, 5.05281985e-02f, 5.74427471e-02f, -9.59997810e-03f, -2.08380055e-02f, 6.10860856e-03f, -8.07840079e-02f, 2.71367840e-02f, 5.60147464e-02f,
  -4.93302010e-02f, -3.82006653e-02f, -5.45898266e-02f, -4.84824553e-02f, 1.36313885e-01f, 1.03519388e-01f, -2.17638630e-02f, -1.92513596e-02f, 7.57966610e-03f, 3.67582589e-02f,
  1.05929308e-01f, 6.97895885e-02f, -2.11819615e-02f, -5.17002493e-02f, -4.65140827e-02f, -2.17561070e-02f, 1.84483409e-01f, 1.14379868e-01f, 1.42301634e-01f, 9.47335139e-02f,
  5.53917773e-02f, -3.25755179e-01f, -2.86968723e-02f, -4.37032729e-02f, -5.43077290e-02f, 2.61266134e-03f, 5.70821315e-02f, -3.28609422e-02f, 1.50620043e-01f, 1.39716014e-01f,
  5.90081466e-03f, -1.60093263e-01f, -6.56314120e-02f, 2.04935065e-03f, -1.23917442e-02f, 1.09523155e-01f, -1.92786634e-01f, -3.24089192e-02f, -1.44278899e-01f, 1.50908455e-01f,
  -1.30998865e-01f, -3.06937993e-01f, -2.15817258e-01f, -2.00865149e-01f, -2.31271726e-04f, 5.30023477e-04f, -2.09866792e-01f, -9.45622623e-02f, -3.27089012e-01f, -3.51488769e-01f,
  5.96409917e-01f, 2.31292725e-01f, -8.90141279e-02f, 2.27477148e-01f, -4.93419450e-03f, -4.82243635e-02f, -2.62178063e-01f, -5.97716384e-02f, 4.06766646e-02f, 1.94048092e-01f,
  2.68440634e-01f, 2.46473163e-01f, 1.67588696e-01f, 2.80855447e-02f, -1.83352660e-02f, 4.25187424e-02f, -2.96236146e-02f, 2.38034446e-02f, -2.58334205e-02f, 2.11161748e-01f,
  1.18625075e-01f, 1.68659270e-01f, 1.62125111e-01f, 3.36976275e-02f, 2.68256307e-01f, 2.46763870e-01f, -1.05421077e-02f, 4.93772477e-02f, 1.38997301e-01f, 3.09468657e-01f,
  1.94260970e-01f, 2.43875980e-01f, -4.28347699e-02f, -5.46591496e-03f, -6.93834107e-03f, -2.48031802e-02f, 2.56510079e-02f, -2.21369751e-02f, -8.70971978e-02f, 1.75018776e-02f,
  9.14745554e-02f, 4.15222347e-02f, -1.61321790e-04f, -1.47102475e-02f, 1.79843660e-02f, 4.38713934e-03f, 5.80938011e-02f, 5.19953726e-04f, -1.00118086e-01f, -5.18397801e-02f,
  1.52679279e-01f, 8.55363458e-02f, -2.31162921e-01f, -5.30995205e-02f, 1.14702471e-01f, 4.70685912e-03f, -8.19320139e-03f, 4.90582623e-02f, 4.78210188e-02f, 9.40162241e-02f,
  1.64023608e-01f, 1.75679009e-02f, 2.01917633e-01f, 2.20963284e-01f, 2.29880184e-01f, 7.81107917e-02f, 4.59845029e-02f, 6.84571713e-02f, 8.89779776e-02f, -1.45221408e-02f,
  -6.44794945e-03f, 3.88930924e-03f, -3.64709948e-03f, 5.26017547e-02f, 1.50571555e-01f, 6.97413981e-02f, -2.81556640e-02f, -5.74716404e-02f, -7.60416016e-02f, -6.62311390e-02f,
  1.06354646e-01f, -2.48433203e-02f, -1.22972682e-01f, -1.13027871e-01f, 2.24266760e-02f, -5.60785010e-02f, -1.57212988e-02f, 4.28620875e-02f, -2.51416154e-02f, 3.26484218e-02f,
  -3.82959038e-01f, -2.46382311e-01f, 1.88492432e-01f, 3.35866697e-02f, -4.72509153e-02f, -9.69353765e-02f, 1.03564993e-01f, -1.88790895e-02f, -1.78789571e-02f, -6.58886358e-02f,
  -9.84132141e-02f, 2.87041273e-02f, -6.45618811e-02f, -9.96549800e-02f, -2.29821373e-02f, -6.43551052e-02f, -2.02678796e-02f, -3.50525379e-02f, -2.16859400e-01f, -4.90440503e-02f,
  -2.10061327e-01f, -1.17976673e-01f, -1.74519613e-01f, -1.63265646e-01f, -7.24409074e-02f, -1.70378104e-01f, -1.54907703e-01f, -1.69107616e-01f, -6.41186759e-02f, -4.67538200e-02f,
  -7.29686677e-01f, -2.41571113e-01f, 3.22244585e-01f, -5.80013096e-01f, -2.22764313e-01f, 2.14849040e-01f, 4.41455990e-01f, -1.27368076e-02f, -3.09657902e-01f, -9.87199172e-02f,
  -7.05695003e-02f, -1.17106393e-01f, -7.85166249e-02f, 1.96695387e-01f, 3.24483454e-01f, 3.05175006e-01f, 3.36557418e-01f, 2.76583254e-01f, 1.26493439e-01f, 2.69067194e-03f,
  6.36169985e-02f, -2.65121162e-01f, -9.64069664e-02f, -7.39925029e-03f, -4.39519614e-01f, -1.31941855e-01f, -5.96580096e-02f, -9.57022160e-02f, 1.87412977e-01f, -1.47727579e-02f,
  -3.85713995e-01f, -3.02741915e-01f, 1.64948985e-01f, -1.20261766e-01f, 1.25562949e-02f, 8.28994736e-02f, 3.38557400e-02f, -1.59701277e-02f, 5.15555479e-02f, -1.78638082e-02f,
  -4.62187231e-02f, 2.32482255e-02f, -2.20077470e-01f, 2.46249046e-02f, -1.75507620e-01f, 1.62422601e-02f, -7.95195922e-02f, 1.55675113e-01f, 2.12981805e-01f, 3.02331708e-02f,
  7.63123669e-03f, -2.11388871e-01f, -2.54042298e-01f, 1.20487407e-01f, -7.93079883e-02f, 2.83168964e-02f, -1.03097558e-01f, -2.45380938e-01f, 5.70479147e-02f, -2.74478614e-01f,
  -1.14852287e-01f, -9.94897410e-02f, 1.22847350e-03f, -6.88069239e-02f, -6.02333201e-03f, 8.16236995e-03f, 5.31307384e-02f, 1.57067135e-01f, 6.39682636e-02f, -2.00353712e-01f,
  3.44895944e-02f, 6.12250678e-02f, -4.35660407e-02f, -1.30117163e-01f, -6.87020645e-02f, -1.08776450e-01f, 1.80791281e-02f, 1.86406463e-01f, 7.82668367e-02f, 3.34933624e-02f,
  5.97484736e-03f, 8.32230598e-02f, -1.32430732e-01f, 2.16509476e-02f, 1.25087246e-01f, 3.04652788e-02f, -1.47413820e-01f, -4.01672646e-02f, -2.45862201e-01f, 8.92260969e-02f,
  -4.91569370e-01f, 5.71477354e-01f, -2.15944692e-01f, 7.85410255e-02f, -1.53209314e-01f, 1.03502348e-01f, -5.70053654e-03f, 3.73331532e-02f, -6.32649288e-02f, 5.39881736e-02f,
  -1.73452012e-02f, -1.70028076e-01f, -2.65909344e-01f, 6.48354134e-03f, 1.85052911e-03f, -4.98012379e-02f, 7.10579231e-02f, 1.05202004e-01f, 1.71280056e-01f, -1.66049585e-01f,
  3.83767411e-02f, -1.79056870e-03f, -2.15586632e-01f, -6.97952434e-02f, -2.72385031e-01f, -1.78007036e-01f, -1.55194893e-01f, -6.43429384e-02f, 1.23322681e-01f, -2.35716298e-01f,
  1.58352673e-01f, -5.27440846e-01f, 9.66950431e-02f, -1.26827776e-01f, -1.58280954e-01f, -1.94230855e-01f, -7.03199267e-01f, -2.98398823e-01f, -9.92838368e-02f, -4.20307785e-01f,
  1.21906795e-01f, 7.24721074e-01f, 4.73148316e-01f, 5.65038681e-01f, 2.74192691e-01f, -6.94337189e-01f, -3.65438521e-01f, 4.95228648e-01f, 6.04862452e-01f, 1.74735621e-01f,
  -5.00653423e-02f, -6.58138990e-02f, 1.06446996e-01f, -3.26978266e-02f, -4.65284854e-01f, 2.26076216e-01f, -3.41883868e-01f, -4.06847894e-02f, -1.28508046e-01f, -3.56002510e-01f,
  3.71541567e-02f, -2.17396811e-01f, 2.40550369e-01f, 1.56517699e-01f, 5.53764999e-02f, -4.25612628e-02f, -7.61061758e-02f, -3.78839299e-02f, 2.81200446e-02f, -8.22550505e-02f,
  1.61347941e-01f, 5.90371005e-02f, 1.07411677e-02f, -9.14675891e-02f, -2.86703050e-01f, -1.16978988e-01f, -1.91820085e-01f, 1.86557233e-01f, 6.37896881e-02f, -2.04509154e-01f,
  -6.31474331e-02f, 9.84470919e-02f, 1.45432293e-01f, -1.27194732e-01f, 1.09394928e-02f, 4.91149157e-01f, -1.68264180e-01f, -8.77420157e-02f, -9.67453942e-02f, -6.68535709e-01f,
  -2.27213744e-02f, 7.56163448e-02f, -5.97585291e-02f, 6.69173300e-02f, -1.04654701e-02f, 1.12366760e-02f, 7.45204389e-02f, -7.75746480e-02f, 6.63145632e-03f, -5.55992164e-02f,
  -2.47346256e-02f, -1.70591064e-02f, 1.47832990e-01f, -6.27575889e-02f, -2.74461564e-02f, 1.59288924e-02f, -9.77713708e-03f, -1.41263694e-01f, 1.50317689e-02f, -1.25465496e-03f,
  1.17134728e-01f, 8.63975063e-02f, 3.80205214e-02f, -9.00272503e-02f, 1.01264818e-02f, 1.39542883e-02f, -2.94393161e-03f, 6.24164827e-02f, 7.01934248e-02f, -1.38578176e-01f,
  -4.52260673e-02f, 3.53874952e-01f, -1.67568579e-01f, 8.48115087e-02f, 7.05437921e-03f, 8.82824659e-02f, 3.87251675e-02f, -4.23485460e-03f, 1.46541059e-01f, 5.80549352e-02f,
  8.04212503e-03f, -6.21495023e-03f, -8.18858966e-02f, -2.20829882e-02f, 3.67473662e-02f, 6.25732169e-02f, 2.98218299e-02f, 1.50862396e-01f, 6.30728854e-03f, -2.17874855e-01f,
  -3.76527339e-01f, -1.70439959e-01f, 4.27365974e-02f, -5.83770685e-02f, -1.38312913e-02f, 3.09177101e-01f, -2.02164911e-02f, -7.69799724e-02f, 1.61717728e-01f, -5.68379343e-01f,
  6.10814869e-01f, 3.27073693e-01f, 2.97137588e-01f, 1.36319101e-02f, -1.97413281e-01f, 1.32211223e-01f, 3.43331575e-01f, 1.85512498e-01f, -1.18040882e-01f, 7.47971535e-02f,
  1.65545166e-01f, -1.06904112e-01f, -1.10296104e-02f, 1.22044217e-02f, 1.89138174e-01f, 1.57841399e-01f, 4.07835282e-03f, 1.53723443e-02f, 4.79998291e-02f, 9.67864227e-03f,
  -1.53565317e-01f, -1.01478197e-01f, 1.06301710e-01f, -1.72281191e-02f, 1.86836887e-02f, -2.04191670e-01f, 5.90878762e-02f, 6.71215877e-02f, 9.72430333e-02f, -2.12304648e-02f,
  1.48958400e-01f, 3.48339707e-01f, -2.85056144e-01f, -1.47600725e-01f, 2.29550526e-02f, -3.57774459e-02f, 7.19616115e-02f, -6.77241236e-02f, -2.36385688e-02f, -1.03326729e-02f,
  -1.27099846e-02f, 4.19634841e-02f, 2.55516171e-02f, 9.82684083e-03f, 8.89602210e-03f, 8.45360756e-02f, 1.16389304e-01f, 2.12132499e-01f, 1.34060577e-01f, 1.47752911e-01f,
  -9.00173709e-02f, 6.88940287e-02f, -2.19149124e-02f, -3.35361063e-03f, 3.26094367e-02f, -1.07943207e-01f, 1.41054010e-02f, 2.46910471e-02f, 1.36803433e-01f, 5.72670624e-02f,
  -1.30288184e-01f, -3.88951786e-02f, 4.83084992e-02f, 9.97264087e-02f, 7.53662512e-02f, 6.43042848e-02f, 5.30255213e-02f, -1.33767324e-02f, 1.07527552e-02f, 3.36057395e-02f,
  1.34747595e-01f, 1.63142029e-02f, 9.92802605e-02f, 3.73096690e-02f, -1.24335364e-01f, 3.08965053e-02f, 3.69665436e-02f, 2.81574558e-02f, 1.16919130e-02f, 6.31703287e-02f,
  7.98049942e-02f, 7.66069666e-02f, 3.50303878e-03f, 1.69094861e-01f, -8.30380525e-03f, -7.89194033e-02f, -5.86941373e-04f, -3.23764496e-02f, -3.65578085e-02f, -1.18139066e-01f,
  -3.63269776e-01f, 9.14189070e-02f, 5.31171300e-02f, -5.19003794e-02f, 3.43055129e-02f, -7.04477876e-02f, 3.91314253e-02f, -1.05663776e-01f, -1.82350352e-01f, -1.41633879e-02f,
  -3.18164751e-02f, -4.34255488e-02f, 8.41946304e-02f, 9.97515917e-02f, -4.53111753e-02f, -1.21356227e-01f, -1.51717290e-02f, -7.32748061e-02f, -2.42753290e-02f, -7.91517943e-02f,
  -8.68498981e-02f, -1.99943811e-01f, -1.62647277e-01f, -1.09711908e-01f, -1.64984018e-01f, -1.82268456e-01f, -8.23903922e-03f, -9.30459797e-02f, -8.25373977e-02f, -8.62966403e-02f,
  8.30607235e-01f, -6.62968576e-01f, -2.88269788e-01f, 1.77099913e-01f, -3.02898169e-01f, -2.98489273e-01f, -5.47226429e-01f, 2.21520886e-02f, 2.22817034e-01f, -2.77438492e-01f,
  -5.39599285e-02f, 6.25560880e-01f, 4.44178641e-01f, 4.75708455e-01f, 5.66087425e-01f, -4.62945342e-01f, -2.82418668e-01f, 3.10892850e-01f, 4.71900791e-01f, 1.79027393e-02f,
  -2.23569781e-01f, -5.25900573e-02f, 5.18017590e-01f, 2.67467380e-01f, -5.34438789e-01f, 1.29371390e-01f, -4.74715412e-01f, -3.74852687e-01f, -3.67235065e-01f, -6.61929548e-01f,
  -8.03060904e-02f, -1.14986122e-01f, 1.82548136e-01f, 1.75414547e-01f, -5.60712442e-02f, 7.60037377e-02f, -1.00193568e-01f, -1.54821858e-01f, -6.76707178e-02f, -2.30400130e-01f,
  -1.63540453e-01f, 5.51028457e-03f, 4.18781787e-02f, -5.24710007e-02f, -1.38939098e-01f, 7.48132309e-03f, -1.62477344e-01f, 5.53511679e-02f, 7.89639428e-02f, -3.05451423e-01f,
  -3.91866952e-01f, -3.22809875e-01f, -2.03881055e-01f, -1.49286211e-01f, -1.28337458e-01f, 2.74100035e-01f, -5.04434466e-01f, -2.97656417e-01f, 2.97881216e-02f, -6.49234951e-01f,
  -3.39838229e-02f, 8.63069892e-02f, 4.67417724e-02f, -1.95059091e-01f, 2.65522581e-02f, -4.72486280e-02f, -3.99233401e-02f, -6.59421831e-02f, 1.79266371e-02f, -1.60697237e-01f,
  4.11245860e-02f, 4.66739796e-02f, 2.77083255e-02f, -1.11077376e-01f, -3.30765471e-02f, -1.71694934e-01f, -1.20271958e-01f, 4.22532298e-02f, 6.28962368e-02f, 1.06575117e-01f,
  2.99812779e-02f, -8.71867239e-02f, 3.33666876e-02f, 1.45372273e-02f, 3.28878849e-03f, 1.90380827e-01f, 4.71238792e-02f, 5.95821515e-02f, 1.05405360e-01f, -1.90703005e-01f,
  2.48120531e-01f, 4.46090996e-01f, -1.13936462e-01f, 1.11975260e-01f, -1.16637357e-01f, -3.31603251e-02f, -3.97543274e-02f, 6.84065372e-02f, -7.05918148e-02f, 1.15100421e-01f,
  -3.11465748e-02f, 1.75404072e-01f, 2.36817403e-03f, -1.58896625e-01f, -1.38488367e-01f, -8.47289860e-02f, -7.11725354e-02f, -1.17280670e-01f, -9.16035101e-02f, -2.10690707e-01f,
  -5.20614535e-02f, -9.78372917e-02f, 8.69756415e-02f, 3.63870449e-02f, -1.32347003e-01f, 1.84989810e-01f, -3.41024101e-01f, -2.86008537e-01f, 3.64647090e-01f, -3.19672495e-01f,
  -6.35089457e-01f, -2.66579222e-02f, 3.72884214e-01f, -6.63049459e-01f, -1.69245094e-01f, 2.31781244e-01f, 2.15142995e-01f, -2.15704128e-01f, -5.40211916e-01f, -2.92692363e-01f,
  1.03499088e-02f, -3.56771797e-01f, -3.34649116e-01f, 3.09999790e-02f, 2.94703096e-01f, 7.05779046e-02f, 6.75707608e-02f, 1.22237399e-01f, 3.52215618e-01f, 8.44950825e-02f,
  -6.02797745e-03f, -1.06654674e-01f, -5.29286265e-03f, -1.48581460e-01f, -4.08344865e-01f, -1.36419326e-01f, 2.72464007e-02f, -6.32575527e-02f, 2.29701325e-01f, -2.87823379e-01f,
  1.39612362e-01f, -2.16768965e-01f, 1.38437450e-01f, -6.35284334e-02f, 4.03266400e-02f, -7.49611948e-03f, -2.16490049e-02f, -1.94760486e-01f, -5.13593517e-02f, 1.05854392e-03f,
  -4.72303592e-02f, -4.92205434e-02f, -3.10421530e-02f, 7.89705664e-02f, -8.82847384e-02f, -8.20774511e-02f, -9.65227745e-03f, 1.37449622e-01f, 1.98908582e-01f, 6.72387630e-02f,
  1.92999437e-01f, 8.60004872e-02f, 1.54642969e-01f, 3.06924075e-01f, 2.39282057e-01f, 1.93392158e-01f, 2.53441662e-01f, 1.07109807e-01f, 2.55428255e-01f, -2.38822594e-01f,
  -1.21668251e-02f, -1.16328754e-01f, -4.05124649e-02f, 1.54451087e-01f, 9.08775702e-02f, 5.55219427e-02f, -6.63053468e-02f, -3.46102193e-02f, 7.37145692e-02f, 6.33402616e-02f,
  5.68479784e-02f, 1.98372141e-01f, 1.27241373e-01f, -2.92985700e-02f, 4.62096184e-02f, 2.55735833e-02f, 3.82209271e-02f, 4.54852879e-02f, 2.58122049e-02f, -1.18069783e-01f,
  1.83056318e-03f, -5.67142144e-02f, -2.40630247e-02f, 9.03429613e-02f, 1.76780909e-01f, -2.55577601e-02f, 1.08511960e-02f, 2.09572569e-01f, 7.60968477e-02f, 1.51077043e-02f,
  -2.05567360e-01f, 3.42138052e-01f, -4.57368195e-01f, -2.11314514e-01f, -2.82928228e-01f, -8.90923217e-02f, -1.35771945e-01f, 2.74882726e-02f, -1.71445817e-01f, -6.76080510e-02f,
  6.13493361e-02f, -6.55915514e-02f, 4.53219712e-02f, -1.47349164e-02f, -8.75310302e-02f, -3.25916298e-02f, -2.52859388e-02f, -9.22424868e-02f, -3.80588789e-03f, 8.29392299e-02f,
  5.09090088e-02f, -1.02886058e-01f, -1.92533761e-01f, 4.90091331e-02f, 7.41147343e-03f, -3.78476758e-03f, 1.33281583e-02f, -4.45795339e-03f, 4.01356891e-02f, -2.31678352e-01f,
  -5.93566954e-01f, 3.94468814e-01f, 1.18280888e-01f, -1.31025195e-01f, 3.69847596e-01f, 4.29668009e-01f, 3.26126248e-01f, 2.51245260e-01f, 1.89124554e-01f, 6.19153455e-02f,
  1.77835539e-01f, 5.97738475e-03f, 1.20443039e-01f, 2.07835026e-02f, -2.69850850e-01f, 1.85781330e-01f, 2.20438763e-01f, -4.62815583e-01f, -5.45354724e-01f, -3.36585552e-01f,
  6.59750402e-02f, -1.49505109e-01f, -5.42946219e-01f, -3.40278834e-01f, 7.25791305e-02f, -1.04375117e-01f, 8.31291452e-02f, -5.18355481e-02f, -8.63126740e-02f, 2.28758296e-03f,
  -5.28999209e-01f, 6.53463090e-03f, 6.13389239e-02f, 4.85691316e-02f, 9.06660184e-02f, -2.24106491e-01f, -1.32857189e-01f, -1.88074000e-02f, 4.08221297e-02f, -1.51933387e-01f,
  5.52118123e-02f, -3.73370461e-02f, 9.30393562e-02f, -2.59728748e-02f, -2.01497719e-01f, -2.84906682e-02f, 4.86779511e-02f, -1.76807702e-01f, -2.91038096e-01f, -2.21446142e-01f,
  2.94087470e-01f, -6.58845752e-02f, -2.84340382e-01f, -3.39486860e-02f, -1.72743812e-01f, -3.37090284e-01f, -1.34548187e-01f, -2.91594386e-01f, -4.68875498e-01f, -5.51800847e-01f,
  -5.65070510e-02f, 3.72916274e-02f, 3.28262001e-02f, 4.58429232e-02f, -2.53792796e-02f, 6.62257075e-02f, 1.23937257e-01f, 1.37428092e-02f, -5.28093204e-02f, -6.19949289e-02f,
  1.82172656e-01f, 6.79580942e-02f, -5.56307659e-02f, 6.38116375e-02f, -3.40119307e-03f, 4.82594781e-02f, 5.35234772e-02f, -6.08261786e-02f, -1.01723932e-01f, -7.09255412e-02f,
  4.53868359e-02f, -2.11102255e-02f, 6.75129741e-02f, -5.82437553e-02f, -3.23125981e-02f, 4.21328098e-02f, -1.59516156e-01f, -2.49925926e-02f, -4.75037172e-02f, -3.70569341e-02f,
  -2.18239576e-01f, 8.05594176e-02f, -2.41051093e-01f, 7.00718304e-03f, 1.20370701e-01f, 9.76087153e-02f, 6.88862205e-02f, 3.18062752e-02f, 1.39910102e-01f, -2.12993264e-01f,
  -5.20632453e-02f, -5.82307205e-02f, 1.24783121e-01f, 4.90163546e-03f, -2.89719492e-01f, -6.05822280e-02f, -2.08441496e-01f, 1.99789666e-02f, 8.39082804e-03f, 6.74405545e-02f,
  3.66911734e-03f, -3.61021161e-01f, -5.03824294e-01f, -1.37794122e-01f, -2.80140638e-01f, -3.93365204e-01f, -3.18241984e-01f, -4.01120603e-01f, -3.37082356e-01f, -6.32352650e-01f,
  6.67907119e-01f, -2.23754779e-01f, -5.19645095e-01f, 1.53822169e-01f, -3.17097843e-01f, -4.67976004e-01f, -6.97758615e-01f, -3.03996146e-01f, 2.21011668e-01f, -3.94526154e-01f,
  2.04571076e-02f, 3.11813235e-01f, 6.46432266e-02f, -2.65543014e-01f, -3.57807368e-01f, -7.29243159e-01f, -5.62256336e-01f, -2.63521999e-01f, -1.47482321e-01f, -2.33718365e-01f,
  3.98100540e-02f, 1.43151253e-01f, 1.41506746e-01f, -9.25826430e-02f, -1.93177938e-01f, -8.06884617e-02f, -2.74355590e-01f, -1.15702607e-01f, -2.83688366e-01f, -3.15243334e-01f,
  -4.29542065e-01f, -9.13808420e-02f, -1.63863689e-01f, 1.36860069e-02f, -1.92415831e-03f, 1.51956841e-01f, -9.05053094e-02f, 2.63635200e-02f, 1.27443731e-01f, -3.84378023e-02f,
  1.66271821e-01f, 1.04731761e-01f, 2.88434058e-01f, -8.75133798e-02f, -2.05301214e-02f, 7.23503530e-03f, -1.13515593e-02f, -3.23580839e-02f, -1.36462852e-01f, -3.58369872e-02f,
  -4.98672873e-02f, 1.24197446e-01f, -1.45049850e-02f, -1.51921630e-01f, -2.93817431e-01f, 1.37653694e-01f, -3.03188264e-01f, -1.09576784e-01f, -5.09532243e-02f, -1.56170189e-01f,
  -9.25594792e-02f, -7.48456493e-02f, -8.01048279e-02f, 1.12445273e-01f, 9.91429538e-02f, 2.36432236e-02f, 4.85425554e-02f, -3.89533006e-02f, 7.34632164e-02f, -1.34846121e-01f,
  -4.41274792e-02f, -1.19344682e-01f, 1.01365000e-01f, -5.72707616e-02f, 1.25079853e-02f, 9.22575593e-03f, -1.13261461e-01f, -1.54746830e-01f, -2.12908778e-02f, 4.31962609e-02f,
  -3.28743272e-02f, 1.71493720e-02f, 1.82652891e-01f, -6.82395250e-02f, -1.66653126e-01f, -1.23709440e-01f, -4.14145067e-02f, 2.07672361e-02f, -4.55809087e-02f, -1.06132746e-01f,
  1.14819244e-01f, -5.43030649e-02f, -1.73331648e-02f, -1.86508730e-01f, -8.88129994e-02f, 1.49375675e-02f, 7.14319497e-02f, -1.08621016e-01f, 1.47889897e-01f, -3.40180397e-02f,
  -3.00390363e-01f, -1.77072436e-02f, 1.17891833e-01f, -9.13105607e-02f, -7.57519752e-02f, 5.30692600e-02f, -5.61458319e-02f, 4.83218320e-02f, -2.29282919e-02f, -5.76561838e-02f,
  -3.99326868e-02f, 3.33414376e-02f, 1.91255853e-01f, 5.59876636e-02f, 4.23327833e-03f, 2.64580380e-02f, -2.81655043e-01f, -1.79888174e-01f, -6.84743151e-02f, -6.90151006e-02f,
  -4.92763698e-01f, 2.42830530e-01f, -2.19561145e-01f, -1.96499437e-01f, -1.07125692e-01f, -2.72769332e-02f, 8.98913667e-02f, -2.78432034e-02f, -2.21429169e-01f, -4.87175062e-02f,
  2.39229932e-01f, 1.40524745e-01f, 8.60760175e-03f, -4.81363833e-02f, -1.27265260e-01f, -2.40039974e-01f, -3.98731589e-01f, -3.23066175e-01f, -6.36557788e-02f, 1.98380738e-01f,
  1.79049283e-01f, 1.70479923e-01f, -2.57796561e-03f, -2.77500022e-02f, 2.09484622e-01f, 2.97216158e-02f, 7.32574463e-02f, 6.14729151e-02f, 1.15763322e-02f, -1.23065941e-01f,
  3.48732561e-01f, 7.48023018e-02f, -1.17420852e-01f, -4.71230820e-02f, 1.62874117e-01f, -1.10839106e-01f, -6.71949461e-02f, -1.36521757e-01f, 4.40153107e-02f, -6.62567392e-02f,
  1.14497997e-01f, -2.64362078e-02f, 1.15497902e-01f, 1.55651525e-01f, 1.42037213e-01f, -4.85788770e-02f, -1.36764720e-02f, -8.28143582e-02f, -9.62255076e-02f, 1.71227276e-01f,
  5.62761575e-02f, -3.80392000e-02f, 5.10993637e-02f, -5.58970459e-02f, 9.38504189e-03f, 3.83950360e-02f, 1.02430388e-01f, 1.09874532e-02f, -1.38648659e-01f, 4.84079085e-02f,
  -7.45332018e-02f, 1.63492153e-03f, 2.52998453e-02f, 1.49155900e-01f, 4.04413731e-04f, -6.44585118e-02f, -7.29837045e-02f, 8.42422917e-02f, 3.55511308e-02f, 6.30819947e-02f,
  5.11576422e-04f, -5.95549028e-03f, 3.25586647e-02f, -9.08119511e-03f, -1.31172230e-02f, -4.16918024e-02f, -1.13260457e-02f, 3.76854092e-02f, -5.40956408e-02f, -9.14139375e-02f,
  -5.54067567e-02f, 2.73264702e-02f, 1.37040600e-01f, 1.67166330e-02f, 8.44321698e-02f, -9.01372433e-02f, -2.28002835e-02f, 2.11408645e-01f, -1.53471688e-02f, 4.04867195e-02f,
  3.35841537e-01f, -1.90392837e-01f, -1.29144927e-02f, -1.38645738e-01f, -1.45887047e-01f, -7.82876834e-02f, -9.15408954e-02f, -1.79151267e-01f, -5.85268326e-02f, 1.46302029e-01f,
  4.87589575e-02f, 3.21704559e-02f, 5.04085701e-03f, -1.12365596e-02f, 6.36723116e-02f, 8.87987688e-02f, 5.88605227e-03f, 1.04695791e-02f, -1.71594426e-01f, -2.22515874e-02f,
  -9.56017524e-02f, -6.71049654e-02f, -5.33800311e-02f, -1.19409390e-01f, 6.83025196e-02f, -1.10661961e-01f, 2.17882752e-01f, 2.15611294e-01f, -1.17810354e-01f, 3.41348886e-03f,
  -2.92454213e-01f, -4.31236178e-01f, -1.26840603e-02f, -1.65880308e-01f, 1.31152004e-01f, 2.01229692e-01f, 2.92992979e-01f, 5.69650233e-02f, -1.12177894e-01f, -1.37013018e-01f,
  -2.58315831e-01f, -2.53317028e-01f, -1.92776904e-01f, -1.90157622e-01f, 4.44192812e-03f, 1.38095900e-01f, 1.47536755e-01f, 9.01774839e-02f, 2.68816024e-01f, 4.28903490e-01f,
  2.09894016e-01f, -8.87168571e-04f, -1.38344690e-01f, -2.12002635e-01f, -1.29742384e-01f, -7.03715757e-02f, -2.13408485e-01f, -1.91301048e-01f, -1.43706053e-01f, -2.81700581e-01f,
  2.08200082e-01f, -2.24869132e-01f, 4.71447594e-02f, -2.86055326e-01f, -7.76058510e-02f, -2.09030941e-01f, -1.22442411e-03f, -1.26904339e-01f, -1.53025329e-01f, -5.64247444e-02f,
  -8.96549150e-02f, -3.42373326e-02f, -1.22829609e-01f, -2.06356738e-02f, 1.29510701e-01f, 6.26635645e-03f, -1.01979725e-01f, -9.38888639e-02f, -7.78282285e-02f, -1.56003252e-01f,
  -2.53158122e-01f, -1.98560655e-02f, 9.38225761e-02f, -2.45362874e-02f, -6.49000853e-02f, -3.24647389e-02f, -7.42886513e-02f, -4.45016921e-02f, 8.99309106e-03f, 8.83776471e-02f,
  4.49092090e-02f, 1.19445752e-02f, -1.43774494e-03f, -2.94475537e-02f, 2.26566428e-03f, 1.52054131e-01f, 6.28822595e-02f, -4.47142450e-03f, -6.79862648e-02f, -4.33021374e-02f,
  -3.41252200e-02f, 1.57440137e-02f, -1.02281243e-01f, 3.20794843e-02f, -1.27592012e-01f, -1.53393790e-01f, -8.58543590e-02f, 2.97907852e-02f, -1.52916774e-01f, -4.86149788e-02f,
  2.49325298e-02f, 2.19124090e-02f, -9.18256938e-02f, 3.96556817e-02f, -7.85071775e-02f, -3.35546620e-02f, -1.40573278e-01f, -6.38873279e-02f, -8.50247815e-02f, -1.23533532e-01f,
  2.37426326e-01f, -1.62163109e-01f, 1.72194973e-01f, -1.73336491e-02f, -2.67485622e-02f, -8.98455679e-02f, -1.70944765e-01f, 1.10219277e-01f, 8.26925784e-02f, 5.95940016e-02f,
  -3.76555957e-02f, 4.91230227e-02f, 2.25925837e-02f, -1.03698131e-02f, 1.36582896e-01f, 6.09935336e-02f, -1.24637701e-01f, 3.16408910e-02f, 1.01400297e-02f, 7.77713358e-02f,
  -1.33642145e-02f, 1.07758053e-01f, 2.37074852e-01f, 2.34665409e-01f, 1.25329211e-01f, 2.88685620e-01f, 1.68440387e-01f, 1.94167525e-01f, 1.99091360e-01f, 4.03333694e-01f,
  -5.84635675e-01f, -2.35852718e-01f, -1.03337638e-01f, -3.38179141e-01f, 3.67682949e-02f, 1.94868490e-01f, 2.60430761e-02f, 2.62691230e-01f, 6.88247234e-02f, -2.62108266e-01f,
  -7.86867216e-02f, -2.58220620e-02f, -2.58095950e-01f, -1.54712126e-01f, -1.75224096e-01f, -2.61239618e-01f, -2.79805660e-01f, -2.25066811e-01f, 1.72444969e-01f, 2.64681190e-01f,
  -5.03237545e-02f, -1.71492249e-01f, -2.01505601e-01f, -4.71132398e-02f, -1.50895640e-01f, -3.12012792e-01f, -3.21894169e-01f, -3.38989258e-01f, -1.34945869e-01f, -5.29102862e-01f,
  -2.48316482e-01f, 2.44189799e-01f, 2.71098793e-01f, -1.00246035e-01f, -1.40725479e-01f, 6.31490573e-02f, 3.21725160e-02f, -1.96137279e-02f, 1.90359708e-02f, -4.43755612e-02f,
  -1.58591643e-01f, 1.67240575e-01f, 5.59654599e-03f, 7.25375116e-02f, 3.79697084e-02f, -7.62516782e-02f, 6.91288039e-02f, 1.25158012e-01f, -1.52756855e-01f, 1.96187720e-01f,
  -2.49463804e-02f, -1.58038646e-01f, -1.99558541e-01f, 1.63088396e-01f, 3.06934118e-01f, -1.27827361e-01f, 8.85321870e-02f, 8.93150419e-02f, -8.81652534e-02f, -5.13675451e-01f,
  9.51832011e-02f, 2.51155533e-02f, 3.01213712e-01f, 1.14981800e-01f, -5.49006388e-02f, 2.08827965e-02f, -8.67249966e-02f, -6.93476498e-02f, 3.05433348e-02f, 3.01919747e-02f,
  4.99403849e-02f, -8.80191661e-03f, -8.14029295e-03f, -8.86696577e-02f, -1.40074924e-01f, -1.71179667e-01f, -1.30233482e-01f, -1.57615364e-01f, -1.21682279e-01f, -4.12654765e-02f,
  -1.36117321e-02f, -4.79606278e-02f, -9.53265056e-02f, -3.63948345e-02f, 1.11007303e-01f, -1.56825885e-01f, 2.25824993e-02f, 1.43671408e-01f, 1.52806312e-01f, 1.77753549e-02f,
  -1.51937678e-01f, -6.36790937e-04f, -4.31248903e-01f, -6.39223233e-02f, -4.46545817e-02f, 9.21672285e-02f, -5.36810383e-02f, 6.90996572e-02f, -5.79373725e-02f, 6.75258711e-02f,
  2.35714957e-01f, -6.69269711e-02f, -9.37443450e-02f, 1.16321243e-01f, 2.70176735e-02f, 1.06302854e-02f, -4.82444391e-02f, -1.93777293e-01f, 5.54681420e-02f, 6.64474145e-02f,
  -2.08221212e-01f, -3.34846973e-01f, -4.14291114e-01f, -1.67150065e-01f, -1.77433744e-01f, -3.30186307e-01f, -2.44739756e-01f, -2.36616045e-01f, -3.43019575e-01f, -6.17809057e-01f,
  -4.64950085e-01f, -2.14258581e-01f, 2.90397685e-02f, -4.81309921e-01f, -2.69068480e-01f, -1.43951863e-01f, -3.97230774e-01f, -3.33135217e-01f, -2.32333302e-01f, -3.07321787e-01f,
  3.10680773e-02f, 1.13024183e-01f, -4.48500924e-02f, -1.24562077e-01f, -2.30789497e-01f, -3.00182223e-01f, -3.08162242e-01f, -3.45196486e-01f, -3.05250645e-01f, -2.61921644e-01f,
  -4.51593369e-01f, -5.09654105e-01f, -2.84297377e-01f, -2.55134314e-01f, -1.12292990e-01f, 3.10214609e-02f, 4.99752760e-02f, -1.60167366e-01f, 1.15728773e-01f, -4.90223393e-02f,
  8.33146572e-02f, 2.81062096e-01f, -6.15207851e-02f, -8.13482180e-02f, -9.44690257e-02f, 4.74132970e-02f, 2.73005292e-02f, 3.00878957e-02f, -6.28614519e-03f, 8.51802621e-03f,
  -2.11909171e-02f, 3.69831175e-02f, -7.59533271e-02f, 7.12999776e-02f, -5.97794214e-03f, 5.13026267e-02f, 6.61855098e-03f, 3.36532452e-04f, 8.11519325e-02f, 1.11422017e-01f,
  4.53054085e-02f, 8.22873600e-03f, -4.97038895e-03f, 1.08997136e-01f, 9.63895023e-02f, 6.56312034e-02f, 1.63280979e-01f, 1.28911480e-01f, 2.62877285e-01f, 1.42466545e-01f,
  -1.72164261e-01f, 1.35600092e-02f, 3.77568565e-02f, 7.20936731e-02f, -4.07174714e-02f, 5.24069555e-02f, -2.63245348e-02f, 2.32018228e-03f, -3.33301090e-02f, -9.90083665e-02f,
  -5.30968904e-02f, 2.67339908e-02f, 1.05251186e-01f, -1.67692587e-01f, -2.46240385e-02f, -2.53621787e-02f, -8.98426697e-02f, -1.36989504e-02f, -1.22021735e-02f, -4.29521762e-02f,
  -5.71150407e-02f, 5.83113916e-02f, -4.49459963e-02f, 2.28330977e-02f, 3.92860211e-02f, -1.08067080e-01f, -2.61659231e-02f, 1.38326734e-01f, -7.83683956e-02f, 4.15551253e-02f,
  -7.34478310e-02f, 1.88795373e-01f, -8.06694031e-02f, 1.27637520e-01f, 1.15816109e-01f, -9.58021823e-03f, 1.99366823e-01f, -2.51740478e-02f, 9.20994952e-02f, 1.00703500e-01f,
  4.82022874e-02f, -6.54762536e-02f, -6.13883324e-02f, 6.40005991e-02f, -3.38385850e-02f, -1.51957376e-02f, 9.42023750e-03f, -1.24626011e-01f, 1.61555126e-01f, 8.38384852e-02f,
  -1.02916837e-01f, -1.78416625e-01f, -1.64373830e-01f, -3.85262445e-02f, 8.57066810e-02f, 9.93433818e-02f, 1.77862849e-02f, 8.43560249e-02f, -9.80967134e-02f, -1.54510662e-01f,
  4.85991120e-01f, 2.97859043e-01f, 3.31556976e-01f, 1.44192606e-01f, -3.24055344e-01f, -4.14219052e-01f, -4.93140489e-01f, 1.40084466e-02f, 9.64762047e-02f, 1.77613959e-01f,
  -3.01915348e-01f, -3.10119361e-01f, 8.08448493e-02f, -1.15104817e-01f, -2.23450571e-01f, 2.11751401e-01f, 1.19649164e-01f, -9.44707077e-03f, -3.88210148e-01f, -5.65986991e-01f,
  -4.53500539e-01f, -1.29717216e-01f, 8.04334879e-02f, 2.45250538e-02f, 4.19970453e-01f, -1.05853058e-01f, 3.62797856e-01f, 1.78891018e-01f, 7.87338614e-02f, 5.27584553e-01f,
  3.16262513e-01f, 4.99100655e-01f, -4.09175545e-01f, -1.62601113e-01f, -1.15289271e-01f, 1.51132211e-01f, -6.09697253e-02f, 2.45364681e-01f, 7.87705276e-03f, 1.92931801e-01f,
  -1.70049459e-01f, -3.93895954e-02f, -5.50458301e-03f, -7.39417896e-02f, -7.98045471e-02f, -1.08638488e-01f, 1.18690804e-01f, 2.13513970e-01f, 2.07759529e-01f, 1.27135277e-01f,
  -4.02181864e-01f, -1.07758075e-01f, 7.64796138e-02f, -2.37193089e-02f, 2.41618752e-01f, -2.04876989e-01f, 2.14154311e-02f, 1.93187758e-01f, 1.02585949e-01f, 4.69265401e-01f,
  -1.07153505e-01f, 1.60662308e-02f, 5.36731891e-02f, 1.71492830e-01f, -1.35680914e-01f, -1.61758289e-02f, 1.10563278e-01f, -1.23741843e-01f, -3.85812148e-02f, 1.47919748e-02f,
  7.71481171e-02f, -6.69578761e-02f, 4.05043773e-02f, 3.75138931e-02f, 1.95806809e-02f, 2.44139116e-02f, -2.08628457e-02f, -3.59427743e-02f, 9.10049081e-02f, -1.65844783e-02f,
  -1.12768926e-01f, 7.65231205e-04f, 9.24790427e-02f, 9.82402191e-02f, 6.22307360e-02f, 8.54710415e-02f, -1.89246684e-02f, -6.37875050e-02f, -3.71378027e-02f, 3.79217491e-02f,
  -2.02255026e-01f, -4.23911572e-01f, 1.92840006e-02f, -1.10833300e-02f, -3.04216221e-02f, -4.80323518e-03f, 1.16506489e-02f, -1.14954405e-01f, 4.77819778e-02f, 5.90631589e-02f,
  -1.40405402e-01f, 1.12799995e-01f, 1.84689641e-01f, -1.35727063e-01f, -2.75538564e-01f, -7.07316399e-02f, -2.36642584e-01f, -1.98683262e-01f, -1.92779481e-01f, -7.26721510e-02f,
  -8.13765898e-02f, -3.38729978e-01f, -3.79237920e-01f, -1.41062543e-01f, -1.06318027e-01f, -4.79768485e-01f, -1.54020384e-01f, -3.13824713e-01f, -3.52930456e-01f, -1.36603773e-01f,
  5.01001060e-01f, -2.39249200e-01f, 2.97786236e-01f, 2.21488059e-01f, 3.91129911e-01f, 3.62759769e-01f, 4.47463334e-01f, 1.83733284e-01f, 1.17218733e-01f, 7.07373172e-02f,
  -2.33259574e-01f, -2.89787382e-01f, -1.97061419e-01f, -1.87121138e-01f, 5.48917018e-02f, 5.42388111e-02f, 2.20769495e-01f, 2.51247853e-01f, 1.67177305e-01f, 1.33472055e-01f,
  4.35103998e-02f, 1.91977203e-01f, 5.62710315e-02f, 9.84749496e-02f, -1.02726266e-01f, 7.80544356e-02f, 6.91818893e-02f, 8.39674026e-02f, -9.74961966e-02f, -2.05093369e-01f,
  -3.47074002e-01f, 4.54982333e-02f, -3.70633155e-02f, -1.92111805e-01f, -1.25823900e-01f, -7.34895021e-02f, -3.33599932e-02f, -7.14401305e-02f, -1.33497804e-01f, 3.27746719e-02f,
  -6.76916018e-02f, -7.33124539e-02f, -1.38727054e-01f, -1.44883409e-01f, 8.38383585e-02f, -4.81153559e-03f, -1.51366606e-01f, -9.59602091e-03f, -6.39284402e-02f, -1.59084186e-01f,
  -1.35184720e-01f, -6.42440468e-03f, 7.96891898e-02f, -2.80474592e-02f, -3.29784527e-02f, -5.20889908e-02f, 1.23651512e-02f, -6.76824078e-02f, -6.93118498e-02f, -7.17532411e-02f,
  -1.22925431e-01f, -7.43395388e-02f, -8.59318972e-02f, 8.05323869e-02f, 6.91269711e-02f, 9.95530859e-02f, 3.32467034e-02f, -5.40641695e-02f, -8.72011557e-02f, -1.00356787e-01f,
  -1.01416007e-01f, -1.20226085e-01f, -1.89601202e-02f, -1.33332452e-02f, -1.85221136e-01f, -1.07966058e-01f, -2.29300037e-02f, -1.62575334e-01f, -1.29221886e-01f, -7.04628751e-02f,
  -1.08214930e-01f, 4.22262624e-02f, 2.42337491e-02f, -1.07286893e-01f, -1.92373842e-01f, 2.54879296e-02f, -8.54789540e-02f, -1.96226507e-01f, 7.55054578e-02f, 1.53979585e-02f,
  -3.12471837e-01f, 2.69940346e-02f, 8.17460045e-02f, -1.12989746e-01f, -8.85735601e-02f, -1.67855576e-01f, -8.01558569e-02f, -2.54825372e-02f, -5.86658157e-02f, -1.34819697e-04f,
  4.17581126e-02f, -6.61075860e-02f, -1.16813675e-01f, -8.57306942e-02f, 1.87200248e-01f, 8.04971554e-04f, -9.29928273e-02f, -1.22206034e-02f, -1.46173313e-01f, -1.12536244e-01f,
  -1.43361941e-01f, 1.21620908e-01f, 1.74639001e-02f, 1.21895574e-01f, 9.76834223e-02f, 1.59395441e-01f, 7.91052822e-03f, 9.83146355e-02f, 8.52225199e-02f, 2.81936407e-01f,
  2.79905740e-02f, 4.80484664e-01f, 1.70504093e-01f, -3.09377223e-01f, -2.28820845e-01f, 4.12836522e-02f, 4.86959130e-01f, 1.38722911e-01f, -4.40103024e-01f, 2.18239680e-01f,
  2.82682240e-01f, -2.36585081e-01f, -2.10872833e-02f, -9.01961550e-02f, 5.15644029e-02f, 2.31686190e-01f, -1.08020961e-01f, -3.47872138e-01f, -2.76389778e-01f, -1.40638500e-01f,
  -1.39279244e-02f, 3.14397514e-01f, 2.28031039e-01f, -1.20822288e-01f, 3.90061215e-02f, -1.88080788e-01f, 1.39071167e-01f, 9.11698304e-03f, 4.51559946e-02f, -2.44176567e-01f,
  3.60742629e-01f, 5.14216274e-02f, -4.79829878e-01f, -2.30436385e-01f, 8.10664371e-02f, -2.94996560e-01f, 6.02312805e-03f, -1.65534467e-01f, -2.77524918e-01f, -1.16735639e-03f,
  -7.42230890e-03f, -3.00542742e-01f, -1.72982872e-01f, -4.25569303e-02f, 8.00339282e-02f, -1.05870008e-01f, -5.35783470e-02f, -1.79518685e-02f, -1.83817893e-01f, -2.07420643e-02f,
  -1.18982643e-01f, 2.91646570e-02f, 3.39100301e-01f, 5.32098440e-03f, -1.33369640e-01f, -2.81413257e-01f, 2.22397253e-01f, -8.76141563e-02f, 9.01507214e-02f, 8.71353745e-02f,
  -1.07657574e-02f, 7.27194995e-02f, -7.65269548e-02f, 2.13314548e-01f, 2.28151027e-02f, -6.57314435e-02f, 6.65229857e-02f, 2.84321159e-02f, -1.25379607e-01f, 1.91893205e-01f,
  -5.60861565e-02f, 2.68688351e-02f, 2.92516232e-01f, 1.40858859e-01f, -1.72777846e-01f, -7.72103146e-02f, -1.28417253e-01f, 3.85923274e-02f, -2.69401446e-02f, -5.20733707e-02f,
  -9.22047049e-02f, 4.13657762e-02f, -1.56060845e-01f, -3.46349105e-02f, -8.96125883e-02f, -1.65588677e-01f, -8.70116130e-02f, -4.71897237e-02f, -3.18014175e-02f, 4.74535339e-02f,
  2.20048919e-01f, -6.37579197e-03f, -1.15381263e-01f, -1.35426000e-01f, 1.09671682e-01f, -1.17319509e-01f, 1.20190449e-01f, -6.61542490e-02f, 7.35056549e-02f, 5.32572381e-02f,
  -1.60510708e-02f, -2.75376529e-01f, 1.21919349e-01f, -5.44664860e-02f, 3.57357673e-02f, -1.04151472e-01f, -1.60935462e-01f, -5.84256947e-02f, -1.08513363e-01f, 9.46433051e-04f,
  -9.75709334e-02f, 4.29200456e-02f, 2.52762079e-01f, 9.49255005e-02f, -1.89347770e-02f, -1.74380615e-01f, 2.88721770e-01f, -1.23995747e-02f, 9.46277007e-02f, 4.63631094e-01f,
  6.69462562e-01f, 5.52103102e-01f, -3.86384353e-02f, 4.72684801e-02f, -2.65338898e-01f, -1.82162344e-01f, -1.06272392e-01f, 1.89469397e-01f, 2.36982882e-01f, 1.40374079e-01f,
  1.15836978e-01f, 4.23941836e-02f, 2.11814106e-01f, 1.33486554e-01f, 1.78420991e-01f, 3.54539715e-02f, -1.23675680e-02f, 1.97794214e-02f, 2.62048244e-02f, -9.51591507e-02f,
  7.55662397e-02f, 2.75791790e-02f, 2.23456532e-01f, 1.34950191e-01f, 1.24745235e-01f, 1.97642315e-02f, 1.04704984e-02f, -1.22894682e-01f, -1.22192636e-01f, 2.10920140e-01f,
  -3.17997992e-01f, -3.52025889e-02f, -6.71853172e-03f, 1.31148145e-01f, 3.05765457e-02f, 1.80467799e-01f, 1.10894501e-01f, 4.54241820e-02f, -1.67831760e-02f, -1.25983030e-01f,
  1.34223737e-02f, 8.38368982e-02f, -8.16954076e-02f, -9.03703123e-02f, -7.45712668e-02f, -1.33416697e-01f, -2.47918218e-02f, -2.18199734e-02f, -2.97486261e-02f, -7.78794140e-02f,
  -2.83940369e-03f, -1.91002622e-01f, -2.39884362e-01f, -1.17837213e-01f, -1.00402519e-01f, -3.06811016e-02f, -1.21700108e-01f, -7.47863948e-02f, -1.37049049e-01f, -4.57638353e-02f,
  -6.44126758e-02f, 8.08119252e-02f, -1.90943867e-01f, -2.06483766e-01f, -1.12058915e-01f, -1.20947957e-01f, -1.51217863e-01f, -3.80119085e-02f, -5.86305819e-02f, 2.31588427e-02f,
  -9.89005640e-02f, -1.07731871e-01f, -1.29697576e-01f, -4.29999307e-02f, 1.09632567e-01f, -7.95512497e-02f, -1.10186428e-01f, -1.34155646e-01f, -2.69756556e-01f, -1.44416764e-01f,
  -1.27262563e-01f, 2.02496946e-02f, -8.52562860e-02f, -1.68850780e-01f, -1.02386422e-01f, -3.38233709e-02f, -5.50947227e-02f, 2.09182687e-02f, 9.47712362e-02f, 9.74546075e-02f,
  -2.40392104e-01f, -3.23310673e-01f, 7.13002831e-02f, 1.43047750e-01f, 6.03176989e-02f, 1.91034541e-01f, -1.10243998e-01f, 5.77369221e-02f, 8.53107776e-03f, -2.50459444e-02f,
  -1.00126334e-01f, 1.82873473e-01f, 3.62804718e-02f, 4.53862734e-02f, 1.97112132e-02f, -1.73650384e-02f, 4.73138556e-04f, 6.04507327e-02f, 6.33736849e-02f, -1.62264612e-02f,
  1.70568284e-02f, 3.67126986e-02f, -7.41783297e-03f, 3.64730582e-02f, -3.61624397e-02f, 7.84106031e-02f, -1.08981162e-01f, -4.72894870e-03f, -1.68003440e-01f, -3.55011076e-02f,
  -4.47149783e-01f, 5.61578050e-02f, -5.05760133e-01f, -2.35669613e-01f, -3.36937934e-01f, -1.60019502e-01f, 1.03146650e-01f, 2.26473790e-02f, -7.99281970e-02f, -7.80733153e-02f,
  -2.42420658e-01f, -3.74959737e-01f, -5.36243796e-01f, 3.73013243e-02f, 2.36601055e-01f, 1.80413857e-01f, 5.65324463e-02f, 9.68010444e-03f, 6.03653900e-02f, 5.39094210e-01f,
  2.47442096e-01f, -1.98514666e-04f, 8.41786489e-02f, 1.78602308e-01f, 9.62555632e-02f, -9.45190564e-02f, -2.52230436e-01f, -5.26028462e-02f, 4.38320003e-02f, -1.63854524e-01f,
  -1.56640440e-01f, -2.23649859e-01f, 6.14467915e-03f, 3.17985006e-02f, -2.19208226e-02f, 1.12471148e-01f, 3.18180434e-02f, -1.22313291e-01f, -2.10781500e-01f, -1.03487216e-01f,
  -2.51611203e-01f, 2.24850122e-02f, -3.32745373e-01f, -9.73538011e-02f, -3.93383987e-02f, -2.92251408e-02f, -1.70177922e-01f, -1.89630489e-03f, -1.81190250e-03f, 7.69013911e-02f,
  2.52091259e-01f, 2.20611524e-02f, -4.78309453e-01f, -1.68379769e-02f, 2.02891648e-01f, 3.33353947e-03f, -8.94935355e-02f, 2.15002298e-01f, 6.94717318e-02f, -1.71802029e-01f,
  2.08577052e-01f, -1.20779462e-01f, -2.10247248e-01f, -1.23168431e-01f, 7.97923356e-02f, -9.95811373e-02f, -1.87919904e-02f, 5.75778745e-02f, 4.43139039e-02f, -1.97723106e-01f,
  -7.18484297e-02f, -2.86234822e-03f, 9.67693031e-02f, 1.43960595e-01f, -4.96055670e-02f, 2.11073086e-02f, -1.52734611e-02f, 2.84247905e-01f, 3.74086499e-02f, 1.33148625e-01f,
  6.14972934e-02f, 1.56925708e-01f, 5.59181497e-02f, 7.42192119e-02f, 1.16829798e-01f, 1.10705934e-01f, 1.97089404e-01f, 5.38938753e-02f, 4.07249555e-02f, 4.43640836e-02f,
  -2.43436247e-01f, 2.42871076e-01f, -1.35840610e-01f, 1.61149278e-01f, -7.02329352e-02f, 1.66918546e-01f, -2.18774728e-03f, 1.48178920e-01f, -3.46104428e-02f, 8.13850313e-02f,
  -2.48833336e-02f, 1.64145455e-01f, -1.20004073e-01f, -5.31716868e-02f, -2.89883554e-01f, -2.27588981e-01f, 2.74418332e-02f, -2.42643386e-01f, -8.46771747e-02f, -1.24259248e-01f,
  -2.52645493e-01f, -7.02547505e-02f, -3.78184825e-01f, -3.47747177e-01f, -1.05757989e-01f, -2.47106642e-01f, -3.05056840e-01f, -3.26540209e-02f, -2.53440976e-01f, -2.04111829e-01f,
  -5.72239161e-01f, 1.60308570e-01f, 4.39921767e-01f, -3.88469920e-02f, 9.90245119e-02f, -1.38724446e-01f, -3.04570913e-01f, -3.88571441e-01f, 3.84649895e-02f, 2.27878422e-01f,
  1.53654516e-01f, 9.87731889e-02f, 3.19510221e-01f, -8.76292661e-02f, -2.30174229e-01f, 8.14477354e-02f, 9.74127129e-02f, -1.07674628e-01f, -5.12404323e-01f, -6.43059075e-01f,
  -2.98294544e-01f, -2.64324993e-01f, -4.20146316e-01f, -2.42576733e-01f, 3.70090365e-01f, 1.82729676e-01f, 2.98914671e-01f, 9.51479562e-03f, 1.13056719e-01f, 4.18856204e-01f,
  4.19289887e-01f, -1.97071716e-01f, 3.85952406e-02f, -1.63170904e-01f, 3.81069928e-02f, -1.15822582e-02f, -2.06111073e-01f, 9.18276906e-02f, -5.99344866e-03f, 5.48122823e-02f,
  1.00899130e-01f, -7.31044486e-02f, -1.09681629e-01f, 4.45808982e-03f, -1.70651361e-01f, -2.72738218e-01f, -1.55935422e-01f, -2.94037074e-01f, -1.28996730e-01f, 1.06981164e-02f,
  -7.00267032e-02f, -1.91606820e-01f, 1.00865811e-01f, 4.68071364e-02f, -4.30961512e-02f, -7.12386072e-02f, 1.12819716e-01f, -2.16750100e-01f, -4.79065776e-02f, 1.59946710e-01f,
  -8.89070928e-02f, 1.71919957e-01f, 3.04307640e-02f, -4.66366112e-02f, 4.82217111e-02f, 9.13957283e-02f, 1.23493940e-01f, -4.28682528e-02f, -1.93903893e-02f, -2.46089082e-02f,
  4.49584983e-02f, 8.89590755e-02f, 1.21329054e-02f, 4.15965430e-02f, 1.46330502e-02f, -3.20586003e-02f, -3.43154967e-02f, 1.27101913e-02f, -7.35553056e-02f, 2.58476045e-02f,
  -1.89903639e-02f, -1.75721496e-02f, 1.76539198e-01f, -2.36296710e-02f, 1.78176537e-02f, -6.09679855e-02f, -3.82897556e-02f, -4.08038124e-02f, -1.78233355e-01f, -1.36904582e-01f,
  2.48110130e-01f, -1.56145260e-01f, 3.11013222e-01f, -1.38010412e-01f, 7.52857327e-02f, 1.08770924e-02f, 6.80694208e-02f, -9.35196579e-02f, 7.22407103e-02f, -6.52940795e-02f,
  -9.28194523e-02f, -2.58262809e-02f, 1.80270642e-01f, 2.49133930e-02f, -1.77772626e-01f, -7.49013722e-02f, -6.63825274e-02f, 4.27148603e-02f, -1.86057333e-02f, 4.31456976e-02f,
  -1.47623822e-01f, -2.73289323e-01f, 6.94470480e-02f, 1.55099511e-01f, -7.06015388e-03f, -5.68665043e-02f, 2.56211430e-01f, -3.98658030e-02f, -4.39471826e-02f, 1.28843814e-01f,
  -2.35990897e-01f, -5.16689150e-03f, 1.43311888e-01f, 2.86543425e-02f, -8.27441830e-03f, -3.39090452e-02f, 1.01902828e-01f, 7.77570158e-02f, -9.46621969e-02f, 4.48261499e-02f,
  1.92349777e-01f, 2.49589860e-01f, 3.29060078e-01f, 1.82975277e-01f, 2.18717769e-01f, 2.00363528e-02f, -1.22971147e-01f, 3.70172076e-02f, 1.10774413e-01f, 1.20304655e-02f,
  6.08785935e-02f, -3.47077474e-02f, 1.93499047e-02f, -2.02279110e-02f, -5.14585860e-02f, 8.42736140e-02f, -2.99146455e-02f, -5.33697829e-02f, 2.17855405e-02f, -5.81986383e-02f,
  3.56432259e-01f, -3.69451307e-02f, 1.14315953e-02f, -5.51204532e-02f, 1.25057977e-02f, -9.75263566e-02f, 3.92081104e-02f, -6.63425997e-02f, -1.08485550e-01f, -1.62989631e-01f,
  -6.81844279e-02f, -6.66365623e-02f, -3.43783088e-02f, -1.93389263e-02f, -8.97995755e-02f, -1.48641109e-01f, -8.80323797e-02f, -1.73059367e-02f, 9.00768396e-03f, 1.66991819e-02f,
  -2.62626316e-02f, -4.40168977e-02f, 8.25596005e-02f, 1.45819739e-01f, 8.08894187e-02f, -4.45346199e-02f, 8.10261741e-02f, 1.43336318e-02f, 9.39505100e-02f, 7.54235610e-02f,
  1.12121612e-01f, 9.55924094e-02f, 1.39472127e-01f, 1.77996740e-01f, 5.96679561e-02f, 8.47957581e-02f, -3.33521999e-02f, 6.40711933e-02f, 6.21146597e-02f, -1.11661544e-02f,
  1.50899226e-02f, 7.15476498e-02f, 4.44048569e-02f, 8.34971741e-02f, 4.18533273e-02f, -5.07452190e-02f, 6.20662011e-02f, -4.84279394e-02f, 4.67200130e-02f, 4.96725775e-02f,
  4.88630719e-02f, -1.45009860e-01f, -1.10819243e-01f, -7.34047890e-02f, -1.15338527e-01f, -8.25167298e-02f, -1.64942145e-01f, 2.17286814e-02f, -2.62892842e-02f, -6.60387650e-02f,
  3.09381187e-01f, 1.76389784e-01f, 8.81214663e-02f, -1.23917349e-02f, -8.68247598e-02f, -5.39829209e-02f, -1.88093707e-02f, -8.32386017e-02f, -1.09341778e-01f, -4.46525253e-02f,
  3.34285796e-02f, -6.60566762e-02f, -8.87210481e-03f, -1.12716734e-01f, -4.65949699e-02f, -1.18076779e-01f, -8.46665502e-02f, -3.43564861e-02f, 4.50816005e-02f, 1.09460636e-03f,
  2.71853227e-02f, -1.78908221e-02f, 1.19592197e-01f, 9.64814499e-02f, 7.60082975e-02f, 5.66381514e-02f, 1.65048793e-01f, 4.96492945e-02f, 3.12335342e-02f, 4.35642302e-02f,
  4.42953527e-01f, 5.13329767e-02f, -6.13496363e-01f, 1.51700050e-01f, -3.06708515e-01f, -2.94564873e-01f, -1.16144545e-01f, 3.53408009e-01f, 3.11790824e-01f, 1.51829747e-02f,
  -1.50012448e-01f, -2.36683354e-01f, -3.85933101e-01f, -3.23933154e-01f, -2.54920334e-01f, -2.91228414e-01f, -3.58421803e-01f, -5.87865829e-01f, -3.36146384e-01f, -5.12808934e-02f,
  5.84831350e-02f, 1.16129443e-01f, 3.48623060e-02f, -1.04190275e-01f, -3.25738043e-02f, -3.08491826e-01f, -4.25756007e-01f, -3.57631505e-01f, -4.67123836e-01f, -3.23291361e-01f,
  -4.46000814e-01f, -1.62755996e-01f, -1.83634862e-01f, 2.06528366e-01f, -9.73252859e-03f, -3.45985293e-02f, 4.13250029e-02f, -4.03217785e-02f, 1.39443278e-01f, 4.85555194e-02f,
  -5.93840629e-02f, 8.09411183e-02f, -6.34348765e-02f, -1.10924758e-01f, -1.02870082e-02f, -4.33381461e-02f, 5.49559705e-02f, -2.08446920e-01f, -1.64139211e-01f, 7.06224293e-02f,
  6.92675710e-02f, -3.03881854e-01f, -3.18580121e-01f, 7.72829503e-02f, -2.06261396e-01f, -2.56271273e-01f, -9.39371213e-02f, -1.76440060e-01f, -4.28959906e-01f, 1.57772169e-01f,
  2.16199577e-01f, -1.19152181e-02f, 2.52790302e-02f, 8.98284987e-02f, 3.08913328e-02f, -1.84105858e-02f, -5.14412150e-02f, -2.79620569e-02f, -2.22698599e-02f, 6.03931472e-02f,
  1.08050322e-02f, 5.68353059e-03f, 1.56617071e-02f, -7.54906330e-03f, -2.24294245e-01f, -3.76303233e-02f, 7.72147328e-02f, -2.56947950e-02f, -1.74871445e-01f, -6.22107834e-02f,
  1.09728973e-03f, -2.55781766e-02f, -1.60555518e-03f, 1.28588602e-01f, -1.26496077e-01f, -9.17011797e-02f, -1.55351879e-02f, 5.60788065e-02f, 1.43874646e-03f, -1.38964755e-02f,
  6.84459358e-02f, -2.44838759e-01f, 6.68829978e-02f, 9.78213176e-02f, -7.22237453e-02f, -5.45747727e-02f, 2.34158933e-02f, 8.52220431e-02f, -8.93377587e-02f, 6.40868619e-02f,
  3.17922607e-02f, 2.43381828e-01f, -2.96285868e-01f, 7.50816613e-02f, -9.80584100e-02f, -1.25076041e-01f, 6.46823049e-02f, -2.05533192e-01f, -1.48975879e-01f, 1.52477503e-01f,
  1.10658035e-01f, 1.39735537e-02f, 1.73458096e-03f, 9.08482149e-02f, 6.45636544e-02f, -9.99842361e-02f, -5.32817692e-02f, -5.96050965e-03f, -2.73999095e-01f, 3.78335625e-01f,
  3.87084544e-01f, 2.39765510e-01f, 2.85348356e-01f, 5.56618124e-02f, 3.22919071e-01f, -1.47152156e-01f, -3.63893062e-01f, -3.02435458e-01f, -6.26442954e-02f, 3.15807074e-01f,
  5.90846360e-01f, 1.35370731e-01f, 1.22644842e-01f, -3.51730213e-02f, -2.91438222e-01f, -4.40102369e-02f, -6.88457489e-02f, -1.65904894e-01f, -4.34741288e-01f, -1.65429860e-01f,
  -2.41134912e-02f, -1.71324179e-01f, -1.01189315e-01f, -2.07323685e-01f, 7.28112236e-02f, -6.08517006e-02f, 1.67498320e-01f, 1.29928559e-01f, 2.02771246e-01f, 2.14901343e-01f,
  5.41597724e-01f, 4.45817649e-01f, -2.84417570e-01f, 2.16676801e-01f, 2.85973400e-01f, -1.20969646e-01f, -1.78078517e-01f, -1.13412991e-01f, -4.13185693e-02f, 2.97631007e-02f,
  3.04516584e-01f, 9.26824734e-02f, 6.54419512e-02f, -9.84580889e-02f, -9.90654808e-04f, -1.27111003e-01f, -8.38740841e-02f, -3.25859755e-01f, -1.72273025e-01f, -1.95449907e-02f,
  5.81358932e-02f, 1.94093302e-01f, 2.37431526e-01f, -2.43329108e-01f, -2.12965846e-01f, -4.75064963e-02f, -1.10220239e-01f, -1.14298515e-01f, -2.44325608e-01f, -4.91530634e-02f,
  -2.42375806e-02f, 1.12443939e-01f, 1.92527808e-02f, -1.18581899e-01f, -3.15947160e-02f, -3.85721885e-02f, 1.11381546e-01f, 1.21616058e-01f, -2.13392489e-02f, -1.43140972e-01f,
  -1.16027765e-01f, 3.59247923e-02f, -9.82122123e-02f, 1.10892594e-01f, -1.44175038e-01f, -9.33184624e-02f, -1.09866366e-01f, -1.37756839e-01f, 4.98770587e-02f, -6.40349090e-02f,
  4.47089151e-02f, -6.66970611e-02f, -2.06628758e-02f, -1.74403280e-01f, 8.06423835e-03f, -1.76851060e-02f, -1.54299540e-02f, -1.29234523e-01f, -6.48738569e-05f, 7.83066079e-02f,
  -2.20964506e-01f, 5.82311153e-02f, 6.30697757e-02f, -1.23112500e-01f, 1.43566594e-01f, 8.21701288e-02f, 1.41637087e-01f, 1.69360843e-02f, 1.38604239e-01f, -2.28365022e-03f,
  -3.83461267e-02f, -1.24217337e-02f, -1.98804364e-02f, -2.95404121e-02f, -8.45167339e-02f, -6.39679879e-02f, 1.12551257e-01f, 4.58205938e-02f, -2.38512039e-01f, -1.23760030e-01f,
  -2.09060594e-01f, -2.92744815e-01f, -7.25184605e-02f, -2.02310577e-01f, -1.29175290e-01f, -1.42153710e-01f, -1.79539338e-01f, -2.92001963e-01f, -2.85096794e-01f, -2.85571814e-01f,
  -1.19625971e-01f, -3.37693095e-01f, 1.66915134e-01f, 3.25903773e-01f, 2.52456874e-01f, 3.49707723e-01f, 2.46818483e-01f, 2.73194015e-01f, 1.77378237e-01f, 1.36615142e-01f,
  7.11316019e-02f, 1.61172643e-01f, 3.00062764e-02f, 3.29140387e-02f, 1.89169243e-01f, 2.59539276e-01f, 3.65320235e-01f, 2.20136300e-01f, 1.43108845e-01f, 2.42475420e-01f,
  1.60954028e-01f, 4.82835621e-02f, -1.07686169e-01f, -2.30970755e-02f, 1.70819819e-01f, 1.93211764e-01f, 1.92615390e-01f, 1.67555794e-01f, 7.45713860e-02f, 1.27380803e-01f,
  -6.66757226e-02f, -1.90587699e-01f, 1.32867694e-01f, -1.77620754e-01f, -7.43397102e-02f, -1.76175937e-01f, -5.06404079e-02f, -1.81106761e-01f, -1.78957075e-01f, -5.82553558e-02f,
  1.11721046e-02f, -1.58385128e-01f, 1.46088190e-02f, -6.58599660e-02f, -7.30984211e-02f, -9.53378603e-02f, -1.28905550e-01f, 7.94303939e-02f, -4.85942215e-02f, -2.57201176e-02f,
  -1.20054588e-01f, 8.13070610e-02f, 4.60785162e-03f, 2.59072706e-02f, 1.14515955e-02f, 8.55063796e-02f, -8.23935494e-02f, -1.53271690e-01f, 6.95050135e-02f, 6.65763319e-02f,
  2.75884569e-01f, 7.35933483e-02f, 3.77876163e-02f, 7.28253350e-02f, 6.28509820e-02f, -3.89102325e-02f, 1.79947853e-01f, 1.99638516e-01f, 1.05218686e-01f, 9.32857618e-02f,
  2.70502046e-02f, 1.97395876e-01f, 1.11185368e-02f, 8.56686980e-02f, -2.20118016e-02f, -3.29344943e-02f, 1.04309814e-02f, 4.34237905e-02f, -1.11207254e-01f, 3.17046829e-02f,
  1.35187488e-02f, 1.45284534e-02f, -1.16673291e-01f, -6.36946484e-02f, -1.15781970e-01f, 1.36282399e-01f, 2.93715261e-02f, -4.76236865e-02f, -3.89488898e-02f, -1.06718363e-02f,
  1.52573153e-01f, 6.05514944e-02f, 8.03769976e-02f, 1.95689425e-02f, -7.42057264e-02f, -1.48384303e-01f, -6.69171363e-02f, -9.62486025e-03f, -9.72007737e-02f, 4.16435488e-02f,
  -6.61136284e-02f, -1.44504592e-01f, -3.00660841e-02f, 9.10054594e-02f, 7.22869933e-02f, 2.93074213e-02f, -6.98742922e-03f, 1.34936869e-01f, 1.12502567e-01f, 2.72875354e-02f,
  -3.97667382e-03f, 1.19055651e-01f, 2.05821201e-01f, 9.99192819e-02f, 2.38149632e-02f, 1.70700535e-01f, 2.49407198e-02f, -6.04335666e-02f, 1.14369830e-02f, 1.27083272e-01f,
  2.62557268e-01f, 4.44334269e-01f, -1.03963530e+00f, 3.11267495e-01f, -3.94654214e-01f, -3.38835686e-01f, 3.51045758e-01f, 2.67448753e-01f, 1.49335384e-01f, 2.14266300e-01f,
  7.88566321e-02f, -3.95815857e-02f, 1.55431136e-01f, 3.43452692e-02f, 4.50654514e-02f, 1.46626890e-01f, -1.32419011e-02f, -3.38305563e-01f, -3.58807236e-01f, 1.07833833e-01f,
  3.98858041e-01f, 4.43923980e-01f, 1.66727081e-01f, 1.68447599e-01f, 2.44155545e-02f, 2.29413547e-02f, -6.86521009e-02f, -9.80884209e-02f, -4.44058180e-02f, -1.12729065e-01f,
  -5.06167889e-01f, -2.96165407e-01f, -3.21234465e-01f, -9.05634165e-02f, -4.76938963e-01f, -3.90726328e-02f, -5.12119532e-02f, -2.28342220e-01f, 1.08637705e-01f, -1.35418288e-02f,
  -2.53648609e-01f, 8.26629903e-03f, -1.71379335e-02f, 6.68737516e-02f, -8.41849484e-03f, -8.65771398e-02f, 1.39877945e-01f, -6.27924055e-02f, 9.91544649e-02f, -2.59376079e-01f,
  9.18531269e-02f, -4.97761548e-01f, -7.58806765e-01f, -1.30109906e-01f, -2.90085852e-01f, -4.97895449e-01f, -3.82075250e-01f, -4.62458432e-01f, -4.05781507e-01f, 1.16509028e-01f,
  -2.45423801e-02f, 4.74709310e-02f, -2.00012494e-02f, 9.27761495e-02f, 2.78012514e-01f, 1.12452703e-02f, 1.54645830e-01f, 1.44502729e-01f, 1.02916896e-01f, 6.70878515e-02f,
  -9.86994579e-02f, -9.46215838e-02f, -5.75493462e-02f, 1.65171444e-03f, 1.58170208e-01f, -7.71305114e-02f, -3.30593213e-02f, 1.60353214e-01f, -1.01572052e-02f, 1.64876789e-01f,
  -2.66425908e-02f, 3.57312430e-03f, -6.55127093e-02f, 7.89641738e-02f, -1.22610874e-01f, -1.35060489e-01f, 3.27922069e-02f, 6.44428432e-02f, -1.35785602e-02f, -7.77869252e-03f,
  5.29824913e-01f, -1.66391939e-01f, 2.11560190e-01f, 6.65399656e-02f, -9.38631818e-02f, -1.42625242e-01f, 7.01405853e-02f, -1.90435781e-03f, 3.19723785e-02f, 6.93795606e-02f,
  -1.48007184e-01f, -3.97230871e-02f, 3.61994468e-02f, 9.08957049e-02f, 2.45390292e-02f, 6.58693491e-03f, 2.70381093e-01f, -5.97605258e-02f, 1.33802935e-01f, -1.78199962e-01f,
  3.56975019e-01f, 1.72755569e-01f, 4.91341129e-02f, 1.54816210e-01f, 3.99936028e-02f, -4.63100476e-03f, -1.37388464e-02f, -1.68722067e-02f, -6.16576374e-02f, 7.14214861e-01f,
  -6.05500229e-02f, -2.06693128e-01f, -8.03914607e-01f, -3.23830009e-01f, -6.17849588e-01f, -5.50837696e-01f, -1.58084765e-01f, -3.37466709e-02f, -9.56084877e-02f, -1.36804029e-01f,
  -1.01334423e-01f, 1.12224177e-01f, -8.62618610e-02f, -3.61290611e-02f, 1.61483139e-01f, -1.59635246e-01f, -4.97038633e-01f, -4.92488772e-01f, -3.03402036e-01f, -9.81532335e-02f,
  -4.35891822e-02f, -2.51703620e-01f, -8.50928128e-02f, -2.05002800e-01f, -2.25018770e-01f, -3.66412282e-01f, -5.45563340e-01f, -5.30509889e-01f, -4.10556138e-01f, -6.29373193e-01f,
  -9.45266113e-02f, -3.34518224e-01f, 5.09685501e-02f, 4.32623327e-02f, 5.33893220e-02f, 7.31517002e-02f, 1.04648642e-01f, -1.63993388e-01f, 1.57409072e-01f, 2.86533386e-02f,
  1.43622537e-03f, -7.63646364e-02f, -1.08087249e-01f, -1.07771419e-01f, -1.75000086e-01f, -2.01488540e-01f, -1.66521460e-01f, -1.93042293e-01f, -1.44946635e-01f, -1.35265559e-01f,
  -5.21280691e-02f, -2.29872361e-01f, -9.02295858e-02f, -3.55973244e-02f, -2.08693147e-01f, -1.32156894e-01f, -1.90724269e-01f, -2.95420408e-01f, -2.84666538e-01f, 4.94847335e-02f,
  3.83325592e-02f, 4.12546843e-03f, -6.96303621e-02f, -5.89547679e-02f, 6.32089823e-02f, -4.18493710e-02f, -1.25290072e-02f, 8.39262679e-02f, -5.00867814e-02f, 4.59147245e-02f,
  -4.79128733e-02f, -1.15027837e-01f, 6.31391555e-02f, -1.68845896e-02f, -1.15059510e-01f, -9.53576118e-02f, 9.69737917e-02f, 1.55411631e-01f, 4.88328636e-02f, 2.29687802e-02f,
  -8.77629966e-02f, 2.14202423e-02f, -7.93745089e-03f, 6.20312616e-02f, -1.32924810e-01f, 9.87241883e-03f, -7.62789696e-02f, 9.17776302e-02f, -6.44018594e-03f, -1.44532025e-01f,
  2.84253329e-01f, -1.26961455e-01f, 3.84542674e-01f, 1.80527084e-02f, 2.76696626e-02f, -1.04411446e-01f, 1.36245657e-02f, 5.60904704e-02f, -3.19810882e-02f, 1.22111114e-02f,
  4.06083688e-02f, 7.72485659e-02f, -4.20966819e-02f, -2.90615242e-02f, -2.44157985e-02f, -7.84682110e-02f, -2.75013931e-02f, -1.07834518e-01f, -1.55325145e-01f, 6.81070331e-03f,
  -1.12547047e-01f, 9.41027179e-02f, 3.44865412e-01f, 2.81861424e-01f, 8.15612972e-02f, 1.12207823e-01f, 1.70123503e-01f, 1.12515800e-01f, 3.17377709e-02f, 4.38406706e-01f,
  -4.77828532e-01f, 2.52238512e-01f, 4.57304925e-01f, 2.08458863e-02f, 7.10835960e-03f, -8.54942352e-02f, -5.02888709e-02f, -2.50544716e-02f, 1.49781972e-01f, 2.59244025e-01f,
  7.26004392e-02f, -1.44814521e-01f, 2.11830169e-01f, -8.76972228e-02f, -1.36251494e-01f, 3.40891391e-01f, 2.65453994e-01f, -1.35225549e-01f, -5.00703514e-01f, -6.03239834e-01f,
  -3.64529520e-01f, -2.76680350e-01f, -2.89603591e-01f, -1.19062975e-01f, 2.48766288e-01f, -4.49786261e-02f, 3.52786362e-01f, 3.55073996e-02f, -3.49395792e-03f, 8.89975578e-02f,
  8.48670900e-02f, -2.60843821e-02f, -1.19457103e-01f, -1.88366711e-01f, 2.36527890e-01f, -1.87602863e-01f, -2.00460460e-02f, -5.52504919e-02f, 3.03942319e-02f, -1.04221553e-02f,
  4.95751351e-02f, -6.18715286e-02f, 1.34810463e-01f, 3.46964262e-02f, -8.99803117e-02f, -1.97303697e-01f, -6.24870099e-02f, -3.04480612e-01f, -8.21741298e-02f, -2.18346030e-01f,
  -1.07548319e-01f, -2.69111246e-01f, -4.98059988e-02f, 7.09760785e-02f, 1.38522789e-01f, -1.31950468e-01f, 6.14570454e-02f, -3.15572530e-01f, -1.99973881e-01f, -1.30647629e-01f,
  -1.05611913e-01f, 6.39403984e-02f, -2.94210706e-02f, 1.50322532e-02f, -7.60438740e-02f, 1.18408665e-01f, 1.80774122e-01f, -9.33034271e-02f, -9.17951316e-02f, 2.36854944e-02f,
  5.80733791e-02f, -8.22896324e-03f, 4.73112352e-02f, 1.45927995e-01f, -8.32411833e-03f, 2.27696146e-03f, -1.35069862e-01f, 2.33889855e-02f, 5.64153120e-02f, 8.64705592e-02f,
  -3.34434845e-02f, -1.32409036e-02f, 6.83187991e-02f, -6.33336455e-02f, -3.11386641e-02f, 1.46901190e-01f, -3.65241766e-02f, -6.63280487e-02f, -8.80725086e-02f, -2.48504337e-02f,
  2.34223098e-01f, -1.32601440e-01f, 5.92303723e-02f, -8.96368325e-02f, 5.05246557e-02f, 1.08650908e-01f, 1.45976409e-01f, -7.80862570e-02f, 1.82527825e-01f, -1.90223128e-01f,
  -5.01096472e-02f, -5.78252561e-02f, 2.54570395e-01f, -9.47604105e-02f, -2.23754093e-01f, -9.83669981e-03f, -1.52773470e-01f, -2.06650347e-02f, 1.98541079e-02f, 1.51090980e-01f,
  3.94063368e-02f, -2.19637930e-01f, -1.87149510e-01f, 9.77727175e-02f, 1.17275968e-01f, -1.65175498e-01f, 1.28009975e-01f, -6.53694272e-02f, -1.02237865e-01f, -5.10776713e-02f,
  6.87266216e-02f, -4.84405279e-01f, -5.14963865e-01f, -1.96459800e-01f, -3.05062652e-01f, -1.40938252e-01f, -7.56455138e-02f, 3.20176512e-01f, 5.19762449e-02f, -2.67716408e-01f,
  -1.63614571e-01f, 2.23389283e-01f, 2.03194022e-02f, 1.69678003e-01f, 1.52327716e-01f, -2.69070417e-01f, -2.96693593e-01f, -3.36190611e-02f, 4.01756078e-01f, 4.21200007e-01f,
  1.83554843e-01f, 1.10195428e-01f, 3.76818478e-01f, 2.45077491e-01f, -3.36724758e-01f, 1.87107138e-02f, -3.50657046e-01f, -3.44805390e-01f, -3.26660722e-01f, -6.56477094e-01f,
  -3.29944909e-01f, -1.39781296e-01f, 1.64827794e-01f, 1.36282966e-01f, -2.03716725e-01f, 2.12424621e-01f, -3.84887420e-02f, 7.86543824e-03f, -1.01490244e-01f, -2.50039756e-01f,
  -9.53081772e-02f, 2.03760341e-01f, 1.19789783e-02f, -6.29238412e-02f, 8.45529325e-03f, 4.76880968e-02f, 1.62259310e-01f, 1.97913824e-03f, 7.00885337e-03f, -4.83049490e-02f,
  -1.86055198e-01f, -4.00390983e-01f, -3.30673277e-01f, -1.37080640e-01f, 1.73954275e-02f, 1.28764391e-01f, -8.42314735e-02f, -1.12763032e-01f, 1.43422028e-02f, -4.99615252e-01f,
  -4.91009355e-02f, -6.09340593e-02f, 8.59569311e-02f, 4.14637998e-02f, 1.10648327e-01f, -9.34901740e-03f, -8.02149251e-02f, 2.72738896e-02f, 4.44347896e-02f, -1.40440166e-01f,
  7.36553445e-02f, -3.21096256e-02f, -7.20587820e-02f, -8.32096338e-02f, -2.16850992e-02f, -7.60034174e-02f, -1.02508441e-01f, 9.29801017e-02f, -4.72283214e-02f, 2.68417951e-02f,
  2.61804443e-02f, -7.59410858e-02f, 3.09613701e-02f, 1.09323546e-01f, -7.91509971e-02f, -2.05945995e-04f, 3.87401544e-02f, 1.61417155e-03f, 3.52974348e-02f, 8.99689421e-02f,
  2.38359764e-01f, 2.42578566e-01f, -2.32232377e-01f, 7.04813823e-02f, -7.97921047e-02f, 6.44744199e-04f, -1.10474460e-01f, 1.94230303e-01f, -8.98731649e-02f, -1.95311662e-02f,
  -7.76249245e-02f, 7.64361322e-02f, -6.99334964e-02f, -1.72486845e-02f, 5.54026626e-02f, 2.57913638e-02f, 9.03451294e-02f, -1.10487662e-01f, 1.27460152e-01f, -1.91922262e-02f,
  -1.27755672e-01f, -3.74805881e-03f, -1.24589808e-01f, -4.94323000e-02f, -7.11666867e-02f, 2.24753767e-02f, -1.69586629e-01f, -2.19319776e-01f, -2.00969093e-02f, -1.61198154e-01f,
  -2.63563037e-01f, -3.31621878e-02f, -1.75015867e-01f, -1.93367422e-01f, -1.66116476e-01f, -2.34841779e-02f, 4.11822498e-02f, 3.58040243e-01f, 2.41345733e-01f, -1.18302114e-01f,
  -1.45375028e-01f, -1.16108559e-01f, -3.23658556e-01f, -2.66746014e-01f, -1.21615395e-01f, -1.16413146e-01f, -3.57968062e-01f, -3.74431252e-01f, -3.68304029e-02f, 7.95405805e-02f,
  -3.47483866e-02f, -1.25257790e-01f, -2.65067339e-01f, -7.84652382e-02f, -1.33994654e-01f, -4.08690602e-01f, -3.41770589e-01f, -3.32640707e-01f, -3.90803963e-01f, -5.10428786e-01f,
  -3.62545364e-02f, 3.92679609e-02f, 5.38384318e-02f, -3.03731769e-01f, -6.64167777e-02f, 8.31841603e-02f, -1.38963303e-02f, 1.82031412e-02f, -8.04143474e-02f, 1.69578850e-01f,
  -1.10226400e-01f, 1.18333139e-01f, 1.21376023e-01f, -5.63433804e-02f, 9.61432233e-02f, -4.56126444e-02f, 7.66475871e-02f, 9.70843881e-02f, 8.32001045e-02f, 3.38788271e-01f,
  -6.83256090e-02f, -2.39765853e-01f, -4.08314168e-01f, 6.48428202e-02f, 4.57705289e-01f, -1.58522025e-01f, 5.42608323e-03f, -2.83725802e-02f, -1.20025486e-01f, -3.93318504e-01f,
  2.44391754e-01f, 2.95476262e-02f, 2.18405992e-01f, 1.68753982e-01f, -7.01713329e-03f, 1.30118474e-01f, -3.86390984e-02f, -1.00367546e-01f, -3.17877233e-02f, 3.26326713e-02f,
  1.63634196e-01f, -6.49449369e-03f, 6.94386521e-03f, -9.16187912e-02f, -1.50942862e-01f, 4.13234867e-02f, -1.56455591e-01f, -1.65445894e-01f, -6.30683154e-02f, -1.18046939e-01f,
  -1.66137442e-01f, 2.86480617e-02f, -1.78589241e-03f, 4.07129116e-02f, -5.31814732e-02f, 1.50292888e-02f, 7.79163837e-02f, 4.55100276e-02f, 1.42868638e-01f, -5.12380479e-03f,
  -7.31918961e-02f, -7.17533305e-02f, -1.93635076e-01f, -2.09750216e-02f, 1.07982799e-01f, 5.77319972e-02f, -1.00797348e-01f, 5.24821505e-02f, -6.82745799e-02f, 7.88701177e-02f,
  1.20366760e-01f, 1.61342680e-01f, -2.60902345e-02f, 2.97635365e-02f, 2.48667952e-02f, -6.13123439e-02f, -6.97813407e-02f, -3.66674006e-01f, -1.34575769e-01f, 1.06686398e-01f,
  5.07966205e-02f, -3.58510077e-01f, -3.93974096e-01f, -2.91755080e-01f, -2.44927444e-02f, -4.11024541e-01f, -4.24364269e-01f, -1.96048036e-01f, -2.88061649e-01f, -3.83563459e-01f,
  1.31259626e-02f, 3.02148461e-01f, 1.17906399e-01f, -1.81258246e-01f, 3.96943361e-01f, 3.20538640e-01f, 4.17391658e-01f, -1.46045089e-01f, -1.50158390e-01f, 1.23291470e-01f,
  2.23218143e-01f, -3.16490561e-01f, -2.71885365e-01f, -2.00729504e-01f, -2.05629826e-01f, 1.75706774e-01f, 8.40141326e-02f, -1.50524139e-01f, -2.11940408e-01f, -6.61796257e-02f,
  2.92581301e-02f, -1.22018524e-01f, -1.46349907e-01f, -2.07186475e-01f, -1.19177708e-02f, -1.71299875e-02f, 8.76743495e-02f, 2.46542975e-01f, 2.67930835e-01f, 1.00992844e-01f,
  1.51218832e-01f, 1.87172681e-01f, -5.71783409e-02f, -4.46724258e-02f, 7.49382377e-02f, -1.99499894e-02f, -6.11699885e-03f, 9.17333513e-02f, 3.90187837e-02f, 1.67957693e-02f,
  1.29365660e-02f, 1.01656534e-01f, -8.06703642e-02f, -1.29124075e-02f, -3.85440439e-02f, -1.89371221e-02f, -1.52040377e-01f, -1.30360663e-01f, -3.36205155e-01f, 6.93484349e-03f,
  8.65770057e-02f, 2.31215343e-01f, 1.24741539e-01f, -7.36268684e-02f, -1.90998062e-01f, -7.82650784e-02f, 1.38812661e-01f, 2.76061371e-02f, -1.20303676e-01f, -7.87462145e-02f,
  -1.13464087e-01f, 2.04431787e-01f, 1.37766674e-01f, 9.54995528e-02f, -7.75049403e-02f, 5.44882417e-02f, 2.29723416e-02f, 5.96563742e-02f, -5.13342321e-02f, 4.33858335e-02f,
  -1.84021331e-02f, 1.00246943e-04f, -6.15804903e-02f, 1.00070186e-01f, -1.28328195e-02f, 7.88997039e-02f, 2.36189038e-01f, -3.48414890e-02f, 1.00556262e-01f, 6.07041195e-02f,
  -2.54423041e-02f, -8.80360454e-02f, 3.60884741e-02f, -1.74275562e-01f, 1.26169845e-01f, 7.74156973e-02f, 3.89649272e-02f, -4.70899837e-03f, 5.95020242e-02f, 1.57633290e-01f,
  -3.99602711e-01f, 7.24275112e-02f, 5.30929975e-02f, 5.02947941e-02f, 2.01499522e-01f, 2.34908853e-02f, 8.36705267e-02f, 1.86643153e-01f, 1.39766604e-01f, -1.87488121e-03f,
  9.85447690e-02f, -1.28520615e-02f, 9.68739986e-02f, -3.79416533e-02f, -2.26556677e-02f, 7.83494040e-02f, 3.27080786e-02f, -9.18056667e-02f, -1.85365602e-01f, -2.60015596e-02f,
  -1.31057367e-01f, -2.83807497e-02f, -7.69563019e-02f, -1.36360824e-01f, -4.76010027e-04f, -1.31881004e-03f, 9.22399387e-02f, 1.55014962e-01f, -2.38592271e-02f, 4.31637950e-02f,
  6.13448918e-01f, -5.61734080e-01f, 1.93681836e-01f, -2.67054234e-02f, -5.78458086e-02f, 3.30493376e-02f, -1.09276325e-01f, 1.75114237e-02f, 1.20787114e-01f, -7.60072544e-02f,
  -1.74272075e-01f, 2.95624118e-02f, 1.65992185e-01f, 8.73798952e-02f, 8.12476575e-02f, 3.99235785e-02f, 5.78901172e-02f, 4.24108744e-01f, 3.56923103e-01f, 3.40518379e-03f,
  -1.57426178e-01f, -6.43336028e-02f, 2.46400580e-01f, 5.25877997e-03f, -1.84795216e-01f, 1.60743557e-02f, -2.08008029e-02f, -1.42552763e-01f, -1.06128186e-01f, -1.98789872e-02f,
  -3.20945866e-02f, -2.99926894e-03f, 6.72181174e-02f, 6.03581825e-03f, -8.85170028e-02f, -4.23818156e-02f, 3.19017991e-02f, 1.90043263e-02f, -5.15536591e-02f, -6.59092143e-02f,
  -7.79946074e-02f, 4.45847027e-02f, 7.97479674e-02f, -1.17093965e-01f, -4.05599959e-02f, -2.39614099e-02f, 2.29123998e-02f, -7.30435923e-03f, -1.24672383e-01f, -1.48886338e-01f,
  -1.69668466e-01f, -2.99652331e-02f, 1.26959262e-02f, -6.31931871e-02f, 1.43607900e-01f, 1.73099741e-01f, -1.14928827e-01f, 3.59684229e-02f, 1.13785401e-01f, 7.44236773e-03f,
  -1.74973626e-02f, 6.94657266e-02f, 1.02899089e-01f, 4.24271598e-02f, 1.02538615e-01f, 1.50212467e-01f, 7.63398930e-02f, -1.07922949e-01f, 1.42613217e-01f, 5.74493967e-02f,
  -1.00908093e-01f, 3.07307076e-02f, 8.16634223e-02f, -3.02059203e-02f, 5.76741295e-04f, 3.68244350e-02f, -4.30730246e-02f, -1.79803167e-02f, 1.41166216e-02f, 6.45324737e-02f,
  2.79441122e-02f, -8.69946107e-02f, 4.37373593e-02f, 1.78671861e-03f, -1.59038842e-01f, -5.27010486e-02f, -6.57347813e-02f, -2.68299934e-02f, -4.06098738e-02f, -1.14751823e-01f,
  -3.24617594e-01f, 4.09719914e-01f, 2.07871467e-01f, 2.07924414e-02f, -2.77970806e-02f, 1.34467697e-02f, 1.05923072e-01f, -1.27119496e-01f, -1.50741920e-01f, -5.38328663e-02f,
  -1.49834407e-02f, 1.02458470e-01f, -9.92659573e-03f, -5.59578165e-02f, 9.46183428e-02f, 1.42171402e-02f, -7.54337292e-03f, 1.12537295e-02f, -4.10400964e-02f, -5.78301735e-02f,
  -9.87701789e-02f, -2.39135511e-02f, 1.60956204e-01f, 1.55288950e-01f, -1.74807161e-02f, 2.47065499e-01f, -1.32744685e-02f, 4.50333348e-03f, 9.29824486e-02f, -4.00668457e-02f,
  -5.21316342e-02f, -3.41113401e-03f, 1.76481053e-01f, 1.13168962e-01f, -5.84791079e-02f, -3.82559448e-01f, -3.89522165e-01f, -2.79907256e-01f, -1.37786850e-01f, -1.45474002e-01f,
  -1.72593594e-01f, 4.00189832e-02f, 9.72704664e-02f, 9.51600075e-02f, 3.26880850e-02f, 1.20628498e-01f, 3.14119667e-01f, 3.57471317e-01f, 1.68271661e-01f, -1.12277739e-01f,
  1.31375819e-01f, 5.12929074e-02f, 1.73862264e-01f, 1.16604663e-01f, 1.58367693e-01f, 1.70017689e-01f, 1.83128849e-01f, 1.94728002e-01f, 2.00014059e-02f, 3.34349960e-01f,
  6.44911751e-02f, -1.61865562e-01f, -2.55882680e-01f, 1.46375328e-01f, 1.79300740e-01f, -1.12614129e-02f, -8.89245272e-02f, 1.82883024e-01f, -7.70364180e-02f, 1.42177626e-01f,
  6.91099912e-02f, 5.70050292e-02f, 4.03721593e-02f, 1.90096438e-01f, -3.68353873e-02f, -1.90076306e-01f, 2.48244002e-01f, 2.06304893e-01f, 8.60810280e-02f, -9.18298811e-02f,
  1.38820738e-01f, 1.51794879e-02f, -2.09274113e-01f, -1.17773980e-01f, -1.25939146e-01f, 7.53120482e-02f, -1.28583416e-01f, -8.79882127e-02f, -2.62109458e-01f, -9.50137991e-03f,
  5.19813038e-02f, 3.22577506e-02f, 5.11164777e-02f, 1.67408556e-01f, 5.29137254e-02f, 1.62839983e-02f, 3.19070444e-02f, 1.03039611e-02f, 7.02847093e-02f, 1.41183719e-01f,
  6.83316290e-02f, -7.80644417e-02f, 1.32146209e-01f, -5.73695414e-02f, -8.98333713e-02f, -3.80706526e-02f, -5.86363412e-02f, -1.29011855e-01f, -9.44836363e-02f, 1.07989123e-03f,
  -2.24296022e-02f, 7.64553621e-03f, -2.89531779e-02f, 1.02756239e-01f, -1.20133713e-01f, 1.17265461e-02f, 4.91410196e-02f, -8.76628757e-02f, -1.00838460e-01f, -1.12787178e-02f,
  -3.28796566e-01f, -1.43771812e-01f, -1.55475438e-01f, 1.21917553e-01f, 6.51411787e-02f, 4.03666869e-02f, -6.96010217e-02f, -2.88627017e-03f, 4.03107889e-02f, 1.55537378e-03f,
  -2.46705085e-01f, -7.07963258e-02f, 8.50264728e-03f, 1.08925462e-01f, 1.89968422e-02f, -1.71568349e-01f, 8.25914294e-02f, 7.00032040e-02f, -9.59684402e-02f, 6.60745949e-02f,
  1.02023385e-01f, -3.95904481e-01f, -3.80842328e-01f, -2.14287713e-01f, -1.52554005e-01f, -2.76145726e-01f, -1.80743814e-01f, -2.82343775e-01f, -4.75987166e-01f, -4.87723917e-01f,
  -3.58700514e-01f, 2.87742168e-01f, -6.50464743e-02f, 2.46856108e-01f, 9.06796530e-02f, 6.03493340e-02f, 1.12195909e-01f, 1.23015985e-01f, 1.16285898e-01f, 1.92683965e-01f,
  9.96207148e-02f, 2.59307086e-01f, 1.44116506e-01f, 2.55250484e-01f, 1.13360487e-01f, 1.13915354e-01f, 2.35210419e-01f, -9.89332329e-03f, 7.22217411e-02f, 7.55368322e-02f,
  2.94676036e-01f, 1.49099365e-01f, 2.53460128e-02f, -2.88887713e-02f, 2.37638563e-01f, 1.46173671e-01f, 1.45842046e-01f, 1.98065192e-01f, 2.82828718e-01f, 3.64666492e-01f,
  2.69349158e-01f, -5.08187041e-02f, 4.15136963e-02f, -2.87415721e-02f, -1.27732366e-01f, -1.91257134e-01f, -1.13011107e-01f, -3.47848460e-02f, -9.49034840e-02f, -3.85276154e-02f,
  7.81062059e-03f, -8.87570232e-02f, -7.48314038e-02f, -1.26911089e-01f, -1.88659564e-01f, -9.93469357e-02f, -1.43634900e-01f, 7.35810548e-02f, 1.64414883e-01f, 3.43517691e-04f,
  7.58073926e-02f, -2.91916728e-03f, -9.48882252e-02f, -6.00503087e-02f, 7.58043677e-02f, 3.52033190e-02f, 2.58180182e-02f, -1.45682067e-01f, -1.40002385e-01f, -1.77952442e-02f,
  3.85032147e-02f, -6.71286285e-02f, -4.55123559e-02f, -1.10361194e-02f, -9.32499394e-02f, -6.79491162e-02f, 2.87915263e-02f, 3.83171476e-02f, -2.13993099e-02f, -3.42371836e-02f,
  7.03977868e-02f, 6.13657087e-02f, -9.01088417e-02f, 6.83591142e-02f, -7.99752399e-02f, -1.68061018e-01f, -7.38690514e-03f, 5.06211519e-02f, -1.59991592e-01f, -4.70870808e-02f,
  3.53574194e-02f, -1.31977126e-01f, -6.28480986e-02f, 1.28546590e-02f, -3.38916406e-02f, -2.92043779e-02f, -1.10418044e-01f, -4.96991770e-03f, 7.29986746e-03f, -5.52234147e-03f,
  3.43853772e-01f, -4.94947955e-02f, 9.44364518e-02f, 4.20335904e-02f, 2.53135692e-02f, -9.70836580e-02f, 3.86187807e-02f, 7.45253917e-03f, -6.35281876e-02f, 6.27321675e-02f,
  -3.59936468e-02f, -2.92484947e-02f, 1.14634000e-02f, -5.23735061e-02f, -8.68257657e-02f, -1.60560831e-01f, 6.59076823e-03f, 7.26170912e-02f, 6.70579895e-02f, 8.55742544e-02f,
  5.81090152e-02f, -1.00211091e-01f, -1.12416651e-02f, -4.65769367e-03f, 1.60473492e-02f, -1.76926535e-02f, -7.42991939e-02f, 1.80878560e-03f, -5.25300950e-02f, -1.39258534e-01f,
  -4.14012343e-01f, -3.86625230e-01f, 3.83395672e-01f, 4.78116274e-02f, 3.90789241e-01f, 2.43612453e-01f, 1.48031399e-01f, 9.51398760e-02f, 7.41253374e-03f, -1.05394870e-02f,
  -2.91612148e-01f, -1.32883906e-01f, -1.52714491e-01f, -1.29130170e-01f, -1.68924317e-01f, 1.38540342e-02f, 2.59419411e-01f, 1.31894425e-01f, 2.57188529e-01f, 2.06746593e-01f,
  -7.38424286e-02f, -3.00827064e-02f, -1.53762817e-01f, -2.55158264e-03f, -1.74582936e-02f, 1.49799600e-01f, 1.08554870e-01f, -4.75920849e-02f, 4.45609316e-02f, 1.44289240e-01f,
  2.35594302e-01f, -4.21090513e-01f, 5.91335706e-02f, -1.93959162e-01f, -1.16142258e-01f, -1.06710866e-01f, 6.95735961e-02f, -2.68487036e-02f, 2.62108690e-04f, -8.89339019e-03f,
  -1.31806403e-01f, -7.29880929e-02f, -1.29431382e-01f, -4.00189310e-02f, 8.36934820e-02f, -3.69554423e-02f, -1.57472670e-01f, -2.41790265e-02f, -1.83324814e-02f, -1.29644170e-01f,
  -2.41586417e-01f, 4.33256924e-02f, 6.53013587e-02f, 9.76527482e-02f, -1.25732407e-01f, -7.76335970e-02f, -5.72418980e-02f, -6.95600733e-02f, 1.01293214e-01f, 1.16132898e-02f,
  -7.88192824e-02f, -3.01079135e-02f, -1.36985242e-01f, -2.12391093e-02f, -3.63806039e-02f, 1.21317133e-01f, 1.05423570e-01f, 1.48436666e-01f, 2.39191949e-02f, 9.85734165e-03f,
  1.15878358e-01f, 4.03474197e-02f, 5.00082970e-02f, -2.18660780e-03f, 5.53749539e-02f, -4.65765372e-02f, -4.73699547e-05f, -5.98274693e-02f, -6.89723790e-02f, 4.34170067e-02f,
  8.57436359e-02f, 1.53906038e-02f, 8.76916870e-02f, -3.51744704e-02f, 7.32753798e-02f, 9.91247371e-02f, -5.90471365e-03f, -1.06343269e-01f, 9.38365683e-02f, -2.15622243e-02f,
  1.76102757e-01f, -2.26368561e-01f, -4.10986086e-03f, -1.35491222e-01f, 4.26404588e-02f, 2.62941159e-02f, 3.62503284e-04f, -4.04836759e-02f, 2.64481604e-02f, 6.11589365e-02f,
  3.44194882e-02f, -5.17209359e-02f, -8.64183158e-02f, 8.71397406e-02f, 1.73347771e-01f, 1.45438090e-01f, -1.72103032e-01f, 5.81126064e-02f, -2.96677295e-02f, -2.62162220e-02f,
  -1.36133984e-01f, 1.76250041e-01f, 2.43315861e-01f, 7.75881186e-02f, -4.06581163e-03f, 2.11246327e-01f, 2.01805964e-01f, 2.30367668e-02f, 7.41852149e-02f, 1.63094029e-01f,
  3.10282409e-01f, 3.10229599e-01f, 3.07831496e-01f, 2.57440418e-01f, 2.19000965e-01f, 2.46699139e-01f, 3.08281749e-01f, 8.97453129e-02f, 1.31416231e-01f, 7.17787743e-02f,
  1.42628536e-01f, 2.61581000e-02f, 5.60909100e-02f, 1.29205078e-01f, 1.25577316e-01f, -1.23095792e-02f, 4.23866287e-02f, -2.65289955e-02f, 2.55124085e-02f, -4.46541794e-02f,
  -7.47183859e-02f, 3.45579498e-02f, -2.89396793e-02f, -1.13320075e-01f, -1.67122498e-01f, -8.97472128e-02f, 9.13413316e-02f, 1.22037910e-01f, 4.60467935e-02f, -2.57989019e-01f,
  9.61736143e-02f, 3.43279511e-01f, -5.79491444e-02f, 8.91135707e-02f, 2.16785029e-01f, 7.94496611e-02f, 1.48596391e-01f, -3.55926976e-02f, 9.43583176e-02f, 7.80335590e-02f,
  9.25210193e-02f, 1.19644471e-01f, 1.97113529e-01f, 9.44953933e-02f, 1.07305706e-01f, 9.10160094e-02f, 1.14190653e-01f, -5.66172265e-02f, -4.39866912e-03f, 1.01869106e-01f,
  1.44146616e-02f, 2.26511583e-01f, 1.41849339e-01f, 8.49343017e-02f, 1.32231712e-01f, 1.26570448e-01f, 1.79063827e-01f, 1.34095207e-01f, 1.33560956e-01f, 9.58285555e-02f,
  4.34400477e-02f, -9.89532471e-02f, 2.31723964e-01f, 9.45721939e-02f, 1.07020773e-01f, -2.11363714e-02f, -3.25611681e-02f, 7.22245649e-02f, 1.20745912e-01f, 3.05385944e-02f,
  -5.81505448e-02f, 5.79811186e-02f, 1.46400511e-01f, -7.51245581e-03f, 1.04655318e-01f, 8.18406194e-02f, -1.28103033e-01f, 1.53188154e-01f, 7.59006888e-02f, 9.78646055e-02f,
  1.43509775e-01f, 7.31665269e-03f, -5.09799868e-02f, 7.69273937e-02f, 1.09108016e-01f, 1.23617053e-01f, 8.68990049e-02f, -5.38402097e-03f, 5.26226014e-02f, -2.10320964e-01f,
  7.55709112e-02f, 4.78917986e-01f, -5.34274243e-02f, -8.09992999e-02f, 4.55167964e-02f, -1.15816854e-02f, 1.87972084e-01f, -4.30590920e-02f, -9.69645232e-02f, 5.01876697e-02f,
  1.21286787e-01f, -7.36476183e-02f, 8.82954821e-02f, -7.67409429e-02f, 4.17053923e-02f, 7.15892166e-02f, 1.46872133e-01f, 4.61827926e-02f, 5.18458709e-02f, 5.59925027e-02f,
  1.92860339e-03f, 6.83274865e-02f, -6.73400937e-03f, -1.20395564e-01f, 1.66368056e-02f, -1.63870007e-02f, -5.48395477e-02f, 1.51244877e-02f, 6.95011616e-02f, -1.29999742e-01f,
  -3.77702206e-01f, -2.85124213e-01f, -3.65749955e-01f, 4.89981472e-01f, 4.21376944e-01f, 5.65778241e-02f, -2.21309677e-01f, -1.98720366e-01f, 1.24169454e-01f, 7.91431516e-02f,
  1.24684364e-01f, 4.22357380e-01f, 1.88060209e-01f, 1.29943386e-01f, -2.16518760e-01f, -1.35613546e-01f, 2.66881704e-01f, -8.03834125e-02f, -8.81051123e-02f, 3.32280807e-02f,
  2.92066932e-01f, 1.63701802e-01f, 1.17215293e-03f, -6.40806928e-02f, 2.76919931e-01f, 2.74473339e-01f, 1.18144244e-01f, 8.98446813e-02f, -2.17896258e-03f, 2.05584586e-01f,
  -3.23704571e-01f, -4.04461771e-01f, 2.36148208e-01f, 2.83015132e-01f, 7.41409659e-02f, -8.53179395e-02f, 2.37138048e-02f, 4.26604673e-02f, 1.21915236e-01f, -9.31648165e-02f,
  1.40487865e-01f, -5.23865372e-02f, 2.84540385e-01f, 3.55833247e-02f, -1.06958978e-01f, 3.43631231e-03f, -3.40635702e-02f, -2.96313852e-01f, -4.94422555e-01f, -1.09612644e-01f,
  5.32528341e-01f, 2.64693975e-01f, -1.46832213e-01f, -7.15635940e-02f, -4.38855499e-01f, 4.62219976e-02f, -4.11371380e-01f, -2.94048160e-01f, -4.67656612e-01f, -4.47670966e-01f,
  3.72281559e-02f, -1.56935781e-01f, -1.36648521e-01f, -8.75767544e-02f, -1.67132486e-02f, 2.00397205e-02f, -8.93542320e-02f, -7.31038004e-02f, -1.04789786e-01f, -1.06204271e-01f,
  4.19063754e-02f, -6.00862242e-02f, -1.63774326e-01f, -1.39408007e-01f, 1.32980838e-01f, -5.03558703e-02f, -1.16392747e-01f, -1.58027440e-01f, -1.89084500e-01f, -1.08898677e-01f,
  -1.18736394e-01f, -1.54127494e-01f, -1.29470378e-01f, -4.21646014e-02f, -1.02751091e-01f, -5.28529622e-02f, -8.35051164e-02f, 7.52102360e-02f, 8.15993696e-02f, 3.78183313e-02f,
  -1.96395498e-02f, 8.30115303e-02f, 8.63473676e-03f, -1.64693013e-01f, -1.29046395e-01f, -8.37375447e-02f, 1.94489714e-02f, 1.03412746e-02f, -7.22275898e-02f, -9.61407796e-02f,
  -2.37207651e-01f, -3.75673980e-01f, 1.71582978e-02f, -3.36838588e-02f, 1.29283339e-01f, 4.06469107e-02f, 6.74586892e-02f, 2.89485436e-02f, -1.34228721e-01f, -1.99069217e-01f,
  -3.52448821e-02f, -1.22305803e-01f, -4.84788679e-02f, -7.99122825e-02f, -1.08959153e-01f, 1.21508159e-01f, -2.02563688e-01f, -1.83803990e-01f, -2.75613457e-01f, -2.23763064e-01f,
  -2.78315008e-01f, -5.25956810e-01f, -2.73148745e-01f, -6.16882086e-01f, -4.22072291e-01f, -2.46646881e-01f, -5.03952563e-01f, -2.10310921e-01f, -1.75632447e-01f, -5.33929467e-01f,
  -1.02554657e-01f, 8.79805461e-02f, 5.37648909e-02f, -1.93166912e-01f, -1.07647084e-01f, -4.72853780e-01f, -4.49083596e-01f, -2.46945620e-01f, -1.71374217e-01f, -3.87782454e-01f,
  -3.63985538e-01f, -5.13587415e-01f, -2.06508458e-01f, -2.28416845e-01f, -2.69338846e-01f, -7.19603002e-02f, -1.78730071e-01f, -1.93035349e-01f, -3.25519182e-02f, -2.98537642e-01f,
  -2.49218240e-01f, 2.23435193e-01f, 4.90184315e-02f, 2.38414705e-02f, -1.47592172e-01f, 3.14729959e-02f, -1.00785811e-02f, -6.04136754e-03f, 2.51106340e-02f, -1.17567182e-01f,
  -2.55047455e-02f, -4.00708728e-02f, 6.06967099e-02f, -5.69634140e-02f, -1.79172397e-01f, -1.28577679e-01f, -8.21772069e-02f, -8.15754086e-02f, 1.16648905e-01f, 1.43085346e-01f,
  8.34505484e-02f, 2.68240236e-02f, 1.30077913e-01f, 2.17445061e-01f, 2.65002608e-01f, 1.61661878e-01f, 6.39368221e-02f, 2.04686299e-01f, 2.82201260e-01f, -1.00934021e-01f,
  -9.18586329e-02f, 3.81728038e-02f, 1.09492011e-01f, -7.29195178e-02f, 5.52245900e-02f, 6.79958984e-02f, -3.26871723e-02f, -1.31402286e-02f, 1.21770106e-01f, -1.66611984e-01f,
  -3.53709161e-02f, 1.01436630e-01f, -2.10256465e-02f, 1.92272291e-02f, 7.27318302e-02f, 4.17169407e-02f, 1.75185818e-02f, -8.96892101e-02f, 2.37992834e-02f, 8.41470957e-02f,
  6.39248714e-02f, 5.88538833e-02f, -6.69004861e-03f, 5.24864011e-02f, -1.55287739e-02f, -1.08875290e-01f, 6.12610169e-02f, 8.87980387e-02f, 6.34754151e-02f, -3.25242132e-02f,
  -1.68296576e-01f, 1.18613973e-01f, -7.35557079e-02f, 1.17691971e-01f, -1.63184162e-02f, 2.99900770e-02f, -2.46216301e-02f, 4.55690771e-02f, 5.04243821e-02f, -1.31912544e-01f,
  1.10890567e-01f, -7.02493489e-02f, -2.28511766e-02f, -1.40744084e-02f, -7.19188573e-03f, -2.19789636e-03f, -1.69396475e-01f, -4.67936061e-02f, 9.97662023e-02f, 7.72893205e-02f,
  -7.92635381e-02f, 5.20356335e-02f, -1.22274451e-01f, 1.16765082e-01f, 1.71251714e-01f, 6.09122589e-02f, 3.93436290e-03f, 9.53994989e-02f, 5.41247688e-02f, -3.47415686e-01f,
  -8.54095161e-01f, 6.63720071e-02f, -1.32475317e-01f, -8.33155453e-01f, -3.71370107e-01f, -4.51875627e-02f, 3.78466815e-01f, -1.85424477e-01f, -4.31488812e-01f, 7.48343542e-02f,
  2.03600690e-01f, -7.54418746e-02f, -4.29522134e-02f, 1.47585541e-01f, 3.33284825e-01f, 3.17068964e-01f, -1.60638586e-01f, -4.43967292e-03f, 1.27694055e-01f, 1.68137357e-01f,
  2.36920208e-01f, -3.51252407e-01f, -3.60625774e-01f, -2.54747331e-01f, -3.16388071e-01f, -1.04642540e-01f, -2.04891011e-01f, -2.08045885e-01f, 4.07475121e-02f, -2.39238173e-01f,
  5.63787401e-01f, -3.93128157e-01f, 1.20131873e-01f, -1.15761302e-01f, -3.80787365e-02f, -1.05735529e-02f, -1.54865131e-01f, -2.01915443e-01f, -5.33493683e-02f, -9.18273032e-02f,
  -2.34881818e-01f, -7.89098293e-02f, -9.82081667e-02f, 3.03288810e-02f, -1.69625968e-01f, -8.39521512e-02f, -6.15879223e-02f, 2.22799592e-02f, -1.19468883e-01f, 1.55065253e-01f,
  5.86049855e-02f, -5.48463799e-02f, -1.06350053e-02f, 1.51719496e-01f, -1.14445109e-02f, 1.08042359e-02f, -2.05232650e-02f, -3.13831195e-02f, 5.17122634e-02f, 5.18199764e-02f,
  1.01131298e-01f, 9.12674069e-02f, -1.31727263e-01f, 1.44793885e-02f, 6.15329221e-02f, -1.14266969e-01f, -1.00999199e-01f, -9.82644409e-03f, 1.21704347e-01f, 5.57840504e-02f,
  -4.20280732e-02f, 1.06241643e-01f, -4.47034240e-02f, -3.91949341e-03f, 4.40022759e-02f, -1.12056136e-01f, 3.72754186e-02f, 1.26470685e-01f, -8.93829912e-02f, -1.50463805e-01f,
  -1.32891774e-01f, -3.54675502e-02f, -3.81711610e-02f, 1.28115147e-01f, 8.88343677e-02f, -8.89849737e-02f, 1.46565568e-02f, 1.52554899e-01f, 5.56636192e-02f, -9.22015235e-02f,
  7.21044689e-02f, 1.38664737e-01f, -6.55307993e-02f, 2.26825718e-02f, -4.71359789e-02f, -8.94412920e-02f, -9.09084529e-02f, -1.15564819e-02f, -1.68307453e-01f, 4.14097384e-02f,
  -9.48102102e-02f, -1.01423956e-01f, -9.20069665e-02f, -1.82659458e-03f, 1.29676104e-01f, -4.28826138e-02f, 6.45101741e-02f, -1.04616746e-01f, -6.54519424e-02f, -4.35602814e-02f,
  1.31096974e-01f, 1.11560389e-01f, 4.63068672e-02f, 2.02167019e-01f, 3.22632305e-03f, 1.15987986e-01f, 1.36490658e-01f, 1.99268311e-01f, 1.84662998e-01f, 2.46933460e-01f,
  -6.43453956e-01f, 8.39886591e-02f, 1.92286924e-01f, 5.85519001e-02f, -3.01529467e-02f, -1.64415711e-03f, 1.97897673e-01f, 7.67369643e-02f, -2.42391638e-02f, 4.82343994e-02f,
  -5.67002892e-02f, -3.76047976e-02f, 1.22353643e-01f, 1.16434067e-01f, 4.81603183e-02f, 2.30264202e-01f, 1.33057952e-01f, 7.87812546e-02f, 9.37855393e-02f, 9.87941306e-03f,
  1.17867813e-01f, 3.17974947e-02f, -1.02124311e-01f, 2.17624381e-02f, 1.11961007e-01f, -9.05255135e-03f, 1.74564645e-01f, 1.63922787e-01f, 1.14310399e-01f, 1.68526217e-01f,
  2.56080955e-01f, -2.78520226e-01f, -3.70407067e-02f, -1.04330815e-01f, -8.63837972e-02f, -2.64789872e-02f, -7.24180192e-02f, -1.41847041e-02f, 2.52307486e-02f, 1.89101696e-01f,
  3.36899646e-02f, 1.62862502e-02f, -5.01883551e-05f, 4.89630513e-02f, 2.27477271e-02f, -1.19084474e-02f, -1.08961098e-01f, 1.08080231e-01f, 2.82678753e-02f, 4.55874652e-02f,
  -1.48715246e-02f, -9.86155719e-02f, 4.11830731e-02f, 1.05240848e-02f, -5.06148934e-02f, -1.01133019e-01f, 4.61556278e-02f, -1.87686621e-03f, -6.87364638e-02f, 8.00005719e-03f,
  4.49478924e-02f, 7.22069666e-02f, -1.20165899e-01f, 2.80481037e-02f, 7.50985043e-03f, -3.89862731e-02f, 1.09197117e-01f, 1.27937689e-01f, 8.93921182e-02f, -7.22881630e-02f,
  3.40827294e-02f, 3.41230743e-02f, 1.41728763e-02f, -6.17125928e-02f, -6.18458726e-02f, -1.62138026e-02f, -2.49386653e-02f, 9.96258259e-02f, -5.26746595e-03f, -1.93138216e-02f,
  -1.33849442e-01f, 1.58936918e-01f, 2.07848139e-02f, 1.59193650e-01f, 8.19335505e-02f, 3.44402008e-02f, -9.58647579e-03f, 3.08037475e-02f, 1.47563964e-02f, -5.45474738e-02f,
  4.16032314e-01f, -3.97568524e-01f, -1.78113669e-01f, -2.10087048e-03f, 5.79384863e-02f, -1.60187319e-01f, -1.54884845e-01f, 3.30345295e-02f, 9.59819108e-02f, 8.12115073e-02f,
  -4.86818030e-02f, -1.03849759e-02f, -1.42208664e-04f, 2.62641832e-02f, -6.40556738e-02f, 8.63656774e-02f, -1.42912552e-01f, 6.75555691e-02f, 8.28188360e-02f, 9.21092648e-03f,
  1.27439782e-01f, -9.44129843e-03f, 1.55854702e-01f, 1.07322551e-01f, -4.36181501e-02f, -7.35823903e-03f, 1.13772281e-01f, 7.31399097e-03f, 9.95542631e-02f, 1.56021282e-01f,
  2.49469459e-01f, -1.65161580e-01f, 3.92590314e-01f, -1.71249360e-01f, -2.11244553e-01f, -7.00555295e-02f, -1.39337540e-01f, -2.00893790e-01f, -3.01292688e-01f, -2.93950856e-01f,
  -2.28300184e-01f, -2.76783526e-01f, -7.23108575e-02f, 6.39439821e-02f, 2.96459764e-01f, 1.10653944e-01f, 6.20256774e-02f, 3.33287477e-01f, 2.21676826e-01f, -1.81403279e-01f,
  -3.20991516e-01f, -1.58795148e-01f, 1.58608064e-01f, 1.79982647e-01f, -3.63328248e-01f, -3.17194536e-02f, 1.10532805e-01f, 4.63054441e-02f, 1.73846379e-01f, -1.22831114e-01f,
  -1.79271951e-01f, 7.70334527e-02f, -5.11044301e-02f, 4.58604023e-02f, -4.48231623e-02f, 1.02256894e-01f, -4.73064445e-02f, 1.12006413e-02f, -1.11518309e-01f, -6.67705834e-02f,
  6.98616207e-02f, -7.59899318e-02f, 3.73218395e-02f, -1.73548087e-01f, -1.06143117e-01f, -2.77621243e-02f, -8.29109177e-02f, -9.28044915e-02f, 5.15065603e-02f, 4.89749247e-03f,
  -1.01978578e-01f, 3.08852345e-02f, 1.61677793e-01f, 1.25046417e-01f, 2.56853580e-01f, 9.01632085e-02f, -4.16802429e-02f, 9.94356722e-02f, 2.52728492e-01f, -1.46010965e-01f,
  3.99062447e-02f, -1.83684938e-02f, -5.26263528e-02f, -6.92499653e-02f, -3.26481238e-02f, -1.42253423e-02f, 3.02144550e-02f, -7.17315897e-02f, 3.87017429e-02f, -5.43529727e-02f,
  -1.89413428e-01f, 9.52975359e-03f, -2.19255742e-02f, -1.31847396e-01f, -1.40084140e-02f, 6.86361417e-02f, 7.16466606e-02f, -4.38533723e-02f, -1.48997409e-02f, 3.23661901e-02f,
  -4.27406542e-02f, -1.31967708e-01f, -1.55882344e-01f, -1.59465596e-01f, -8.55796561e-02f, -9.57745537e-02f, -5.79882972e-02f, -3.79505865e-02f, -1.53561994e-01f, -2.21815288e-01f,
  -4.54634041e-01f, 2.61720121e-01f, -1.18432030e-01f, 6.43095374e-02f, 7.39488527e-02f, 9.98574644e-02f, 4.82148901e-02f, 7.06539825e-02f, -1.43649772e-01f, 4.93994318e-02f,
  1.97633237e-01f, 4.67138439e-02f, -8.69883150e-02f, -1.21070676e-01f, -1.44471779e-01f, -1.01897538e-01f, -7.40805566e-02f, -1.76634252e-01f, -5.31102754e-02f, -1.15099415e-01f,
  3.64550203e-02f, 1.13309942e-01f, -9.18032303e-02f, 3.67579721e-02f, -1.56779420e-02f, 5.94578609e-02f, -7.03348815e-02f, -1.23701133e-01f, 6.90103248e-02f, -1.73676163e-01f,
  -2.04199865e-01f, -2.83905774e-01f, -4.68393087e-01f, 3.38263288e-02f, -2.75960043e-02f, -3.67824823e-01f, -6.15557015e-01f, -4.05931920e-01f, -1.30792156e-01f, -2.62480855e-01f,
  -1.54653475e-01f, 5.10430802e-03f, -2.86704957e-01f, -1.31478589e-02f, -1.35925248e-01f, -1.89044580e-01f, 4.11764123e-02f, 4.49945740e-02f, 2.60338277e-01f, 4.67925400e-01f,
  3.96915197e-01f, 5.17265975e-01f, 5.07899106e-01f, 4.81522620e-01f, 3.88722450e-01f, 3.32363039e-01f, 7.22829252e-02f, 3.16465855e-01f, 2.48202741e-01f, 2.41703838e-01f,
  -3.56440216e-01f, -1.31680131e-01f, 1.52336612e-01f, 2.08451062e-01f, 5.98256290e-02f, 4.59202379e-02f, 5.05211800e-02f, 2.31397251e-04f, -1.39363930e-01f, 8.65629837e-02f,
  1.29213989e-01f, 8.69546160e-02f, -9.99647677e-02f, 2.11335078e-01f, 2.58003712e-01f, -1.12223729e-01f, 3.05595070e-01f, -1.12646922e-01f, -3.68085742e-01f, -1.52326804e-02f,
  1.87535375e-01f, 1.87213078e-01f, -3.19921583e-01f, -2.81286150e-01f, -4.11604822e-01f, 1.50973156e-01f, -1.93110853e-01f, 5.70921823e-02f, -3.37654322e-01f, -9.88999903e-02f,
  -1.45449772e-01f, -3.81732844e-02f, -4.89445738e-02f, -1.59694061e-01f, 1.04031138e-01f, 4.18586321e-02f, 6.51928410e-02f, 1.30933642e-01f, -3.36296633e-02f, -9.79487747e-02f,
  -1.77610621e-01f, 3.71600711e-03f, 1.09528109e-01f, 9.18353721e-02f, 1.36923134e-01f, -2.11453717e-02f, -8.41343589e-03f, 1.55640393e-01f, 8.05039480e-02f, 3.96639705e-02f,
  -8.92547742e-02f, 3.46390461e-03f, 1.91275612e-01f, 9.54540968e-02f, -1.02303281e-01f, 7.76113495e-02f, 8.24577287e-02f, -4.30929428e-03f, -5.84066808e-02f, -2.71682180e-02f,
  1.31582767e-01f, 1.29099056e-01f, -1.55667871e-01f, -4.75904457e-02f, -4.76172417e-02f, 5.98309152e-02f, 1.31118029e-01f, 7.06929713e-02f, -4.20747548e-02f, -1.90721676e-02f,
  -3.80607173e-02f, -1.00452572e-01f, -1.39733376e-02f, -7.65653402e-02f, 8.06812793e-02f, -1.80454209e-01f, 1.40648097e-01f, -2.48235330e-01f, -2.48802111e-01f, 6.32381253e-03f,
  -1.51956379e-01f, -5.62357865e-02f, -2.18701407e-01f, -4.26874727e-01f, -3.05542141e-01f, -1.57073900e-01f, -1.25861824e-01f, -5.95813990e-02f, -4.52599734e-01f, -4.36785787e-01f,
  1.85766548e-01f, -4.94300783e-01f, 5.51600195e-02f, -1.60505310e-01f, -2.10890517e-01f, -2.23115638e-01f, -6.21498168e-01f, -2.09278271e-01f, -2.03958809e-01f, -4.36353832e-01f,
  9.60505754e-03f, 6.95653021e-01f, 5.56484401e-01f, 4.59747732e-01f, 1.66380912e-01f, -6.40758216e-01f, -7.46366739e-01f, 1.53749719e-01f, 5.37847877e-01f, 5.86911403e-02f,
  -2.82072037e-01f, -3.37873548e-01f, 3.35097462e-02f, -2.63648015e-02f, -1.98318616e-01f, 1.79215342e-01f, -3.45853806e-01f, -2.59623617e-01f, -2.20602036e-01f, -3.53769183e-01f,
  3.13201070e-01f, -9.09815729e-02f, 1.84479758e-01f, -9.62345023e-03f, -1.43790662e-01f, 5.63602410e-02f, -4.49879654e-02f, -1.89904898e-01f, -4.30526920e-02f, -1.49274752e-01f,
  -7.39378342e-03f, 1.83254462e-02f, 7.42297620e-02f, -1.30472770e-02f, -1.82824820e-01f, -2.28134021e-02f, -3.56370211e-01f, -1.67541400e-01f, -1.77461207e-01f, -2.77449936e-01f,
  -3.81346226e-01f, -8.44076201e-02f, 1.55084863e-01f, -1.24434657e-01f, 1.04424089e-01f, 2.15301737e-01f, -4.14988287e-02f, 3.99510488e-02f, 1.00807458e-01f, -3.21697354e-01f,
  2.91325455e-03f, 7.24341273e-02f, -3.07798553e-02f, -9.11732540e-02f, -2.45014429e-02f, 4.37972555e-03f, -1.50230005e-02f, -2.23152880e-02f, -3.25376131e-02f, -2.94882562e-02f,
  7.39972591e-02f, -2.07796432e-02f, -5.17706992e-03f, -8.83387104e-02f, 5.33847734e-02f, -8.97791237e-02f, -4.55183871e-02f, -3.19631808e-02f, 4.91150357e-02f, -8.38950798e-02f,
  -1.02241769e-01f, 1.60381347e-02f, -4.18718206e-03f, 4.71367054e-02f, -1.53603911e-01f, 2.42001675e-02f, -1.82975288e-02f, -1.89519022e-02f, 4.57233265e-02f, -1.19321331e-01f,
  2.90197790e-01f, 5.27860261e-02f, 1.30122781e-01f, -7.28296414e-02f, -1.26906946e-01f, -6.69387877e-02f, -2.44757831e-02f, -1.19817719e-01f, 2.67776512e-02f, 1.49060220e-01f,
  2.20187455e-02f, 3.93205285e-02f, 4.55767065e-02f, 1.59886423e-02f, 1.90721937e-02f, -1.18803188e-01f, -1.48654029e-01f, -2.38954313e-02f, -7.61054233e-02f, -2.75386930e-01f,
  -3.09433967e-01f, -5.32498099e-02f, 1.85440898e-01f, 1.61151901e-01f, 7.16233626e-02f, 3.77284944e-01f, 2.05573067e-01f, 6.17930330e-02f, 3.44197839e-01f, -1.52620673e-01f,
  -6.25017285e-01f, 2.46629953e-01f, 2.44560584e-01f, -8.58447030e-02f, 4.60461169e-01f, 6.04688749e-02f, -1.46116167e-01f, -3.99089813e-01f, -8.14428926e-02f, 8.66262540e-02f,
  3.22373211e-01f, 1.12104759e-01f, 1.98446944e-01f, -1.19230663e-02f, -3.74416202e-01f, 7.94428661e-02f, 1.15024351e-01f, -2.60958195e-01f, -4.29127634e-01f, -3.06071460e-01f,
  1.29058868e-01f, -1.33055195e-01f, -3.66340905e-01f, -1.34505808e-01f, 1.86399519e-01f, 5.62804677e-02f, 2.97036886e-01f, 1.38820142e-01f, 1.46952376e-01f, 3.87942284e-01f,
  -3.96942347e-02f, -8.57503414e-02f, -5.84413530e-03f, 9.73244160e-02f, 3.47612828e-01f, -2.71558136e-01f, -2.51642317e-01f, -1.72785118e-01f, 1.54680777e-02f, -1.93587504e-02f,
  2.27298006e-01f, 8.85520056e-02f, 2.09305540e-01f, -1.24134161e-01f, -2.09582850e-01f, -2.73554653e-01f, -1.19731374e-01f, -4.05655324e-01f, -3.38892132e-01f, -1.18268073e-01f,
  2.79168129e-01f, 1.55319408e-01f, -3.35123129e-02f, -5.81460707e-02f, -1.20353930e-01f, 6.33297116e-02f, -1.58413555e-02f, -2.00456500e-01f, -2.64553845e-01f, -2.74067760e-01f,
  3.13682742e-02f, 9.01240855e-02f, -1.65089208e-03f, -4.80805943e-03f, -1.06595941e-01f, 1.84718221e-01f, 1.35405615e-01f, 1.01003416e-01f, 1.38961873e-03f, -4.49263006e-02f,
  1.17850929e-01f, -5.46657629e-02f, -9.65064168e-02f, -3.57567817e-02f, -8.60706642e-02f, -4.97274008e-03f, -5.94894178e-02f, -4.06021029e-02f, -3.40989754e-02f, -7.18743075e-03f,
  8.01390409e-03f, 2.59307157e-02f, 7.50803724e-02f, -8.03938434e-02f, 1.21300392e-01f, 8.21702704e-02f, -3.03338636e-02f, -4.48427871e-02f, -3.78724486e-02f, 7.79610202e-02f,
  -1.17576391e-01f, 7.96630308e-02f, -1.99748799e-01f, -1.83095425e-01f, 5.26278019e-02f, 1.26790747e-01f, 5.53097613e-02f, 5.84743991e-02f, 6.03101812e-02f, -1.75403237e-01f,
  -4.86579388e-02f, -7.38705229e-03f, 1.72292873e-01f, -1.29022032e-01f, -2.06153840e-01f, -2.95637362e-02f, 4.02851664e-02f, 7.21176937e-02f, 4.92842942e-02f, 9.33607519e-02f,
  1.18696697e-01f, -3.13037544e-01f, -3.48334521e-01f, -1.61469966e-01f, -2.39981245e-02f, -2.16070607e-01f, -2.40272373e-01f, -3.59098047e-01f, -3.68373811e-01f, -5.36055028e-01f,
  -1.64498463e-02f, -2.97761410e-01f, 1.69948652e-01f, 1.57715708e-01f, 3.29589456e-01f, 3.53273720e-01f, 2.55825758e-01f, 5.74262217e-02f, 1.67865768e-01f, 3.44528928e-02f,
  -1.40222117e-01f, -1.70904174e-01f, -2.72465259e-01f, -2.27988303e-01f, -1.71867415e-01f, 1.66521266e-01f, 1.60954013e-01f, 1.25372037e-01f, 1.81156173e-01f, 1.69756353e-01f,
  4.27795500e-02f, 5.07771894e-02f, 1.21113494e-01f, 7.90276453e-02f, 1.15471957e-02f, 1.05102755e-01f, 7.64688030e-02f, 1.82822362e-01f, 3.13028470e-02f, 5.06551303e-02f,
  -1.67337090e-01f, -2.61925638e-01f, -6.77998066e-02f, -1.57095775e-01f, -5.04742526e-02f, -1.64659798e-01f, 2.90477485e-03f, 6.68963743e-03f, -9.60168019e-02f, -6.05779095e-03f,
  -1.10977940e-01f, -2.12344095e-01f, -1.24860540e-01f, -2.85677351e-02f, -1.43084563e-02f, 2.83848010e-02f, -1.30650952e-01f, -1.55687019e-01f, -1.83584511e-01f, -2.26700500e-01f,
  -2.18836486e-01f, 6.97411150e-02f, -5.10347374e-02f, 4.90393117e-02f, -2.41463073e-03f, 1.41364271e-02f, -1.62687585e-01f, -1.07637845e-01f, -3.49965394e-02f, -1.07760943e-01f,
  -7.65823126e-02f, -1.20273596e-02f, -1.34134702e-02f, -9.66380239e-02f, -4.10294384e-02f, -5.12014255e-02f, 6.34403005e-02f, 3.44024069e-04f, 1.34208217e-01f, 8.46969485e-02f,
  7.82419592e-02f, 7.97123834e-02f, 2.72530876e-02f, 1.28262356e-01f, -4.09771390e-02f, 5.01432851e-06f, 1.01977341e-01f, -5.82051277e-02f, 6.33219630e-02f, 8.86521488e-02f,
  -2.55055614e-02f, 1.25642717e-01f, 1.37437098e-02f, 2.23878212e-02f, -1.11122085e-02f, -7.00078532e-02f, -4.62276451e-02f, 6.59156442e-02f, -4.84500341e-02f, 1.25086322e-01f,
  1.39698625e-01f, -2.39082556e-02f, 6.22917749e-02f, -6.46447837e-02f, 6.84328303e-02f, -2.59503201e-02f, 1.81993190e-02f, -8.80497042e-03f, 9.61127728e-02f, 6.59300387e-02f,
  -5.30440249e-02f, -7.98783079e-02f, 1.40959565e-02f, 4.38209474e-02f, 2.23719567e-01f, 6.70568496e-02f, -4.13473919e-02f, 1.11779213e-01f, 5.46836816e-02f, -2.29484923e-02f,
  -7.26218522e-02f, 1.50633037e-01f, 2.29558676e-01f, 6.27999604e-02f, 1.41483247e-01f, 1.78546906e-01f, 1.44110783e-03f, 5.62849268e-02f, 2.03731164e-01f, 1.87735006e-01f,
  1.82939306e-01f, 4.06938493e-01f, 4.61116284e-01f, -4.00677711e-01f, -1.05782554e-01f, 1.39600471e-01f, 1.79570407e-01f, 5.91134168e-02f, -1.81207031e-01f, 2.87115816e-02f,
  1.46738768e-01f, -2.27064520e-01f, -1.63491115e-01f, -2.10581068e-02f, 1.10425927e-01f, 1.96194246e-01f, -5.21651730e-02f, 2.14763433e-01f, 2.57053003e-02f, -1.24710806e-01f,
  -1.29309028e-01f, -1.42090479e-02f, 1.76666364e-01f, -5.74315712e-02f, -6.23365529e-02f, -3.57718080e-01f, 1.49553493e-01f, 1.82247628e-02f, 2.30519310e-01f, 9.40503329e-02f,
  3.59092027e-01f, 3.86964619e-01f, -3.01090509e-01f, -6.18451014e-02f, 1.80995092e-01f, -9.19478014e-02f, 3.15361805e-02f, 6.96237013e-02f, -5.83618805e-02f, -1.01489257e-02f,
  1.02014430e-01f, 1.60476446e-01f, -1.69386272e-03f, 9.07018706e-02f, 8.63426998e-02f, -1.94840301e-02f, 8.13078433e-02f, 1.64295062e-01f, -3.17509510e-02f, 7.82563612e-02f,
  -1.31227210e-01f, 3.38637717e-02f, 2.38548666e-01f, -8.08373690e-02f, -1.46692768e-02f, -1.97818890e-01f, 1.03892773e-01f, 2.47981306e-02f, -8.74496438e-03f, -1.04609028e-01f,
  -4.20339406e-01f, 7.96132237e-02f, 1.52939871e-01f, -1.50301456e-01f, -1.85918868e-01f, -4.98431548e-02f, -1.22697853e-01f, 9.31283832e-02f, -5.30672334e-02f, 1.00159701e-02f,
  -4.42696400e-02f, -5.34330942e-02f, -3.87533791e-02f, 3.27810906e-02f, -7.63020813e-02f, -6.95250742e-03f, 8.25237259e-02f, -4.70175734e-03f, 8.60529616e-02f, 2.66059022e-02f,
  -4.86728065e-02f, -4.08618823e-02f, 4.20067646e-02f, 8.21687654e-02f, -1.23058036e-01f, 4.06219587e-02f, -1.54157043e-01f, -6.69793040e-02f, -7.62894079e-02f, -7.61872604e-02f,
  -2.20230997e-01f, 2.52963126e-01f, -2.81458825e-01f, -1.46210106e-04f, 1.77285433e-01f, 3.14219808e-03f, 8.27037320e-02f, 3.07440814e-02f, 3.23344581e-02f, -1.85326599e-02f,
  1.80677012e-01f, 2.09311526e-02f, 8.33712667e-02f, 7.71923959e-02f, -1.16214745e-01f, -4.95902114e-02f, 3.08065619e-02f, -7.12498054e-02f, -4.96130495e-04f, 3.27402242e-02f,
  -7.06480369e-02f, -2.43048027e-01f, -3.79000276e-01f, -2.46393576e-01f, -2.65716523e-01f, -5.17780542e-01f, -1.88363060e-01f, -1.98359117e-01f, -7.56399557e-02f, -3.71472985e-01f,
  -2.16876447e-01f, 8.51424783e-03f, 1.80487677e-01f, -2.75676493e-02f, 3.08951382e-02f, -1.83830366e-01f, -1.31863922e-01f, -3.11106861e-01f, -1.69449270e-01f, -6.99609965e-02f,
  -1.19793020e-01f, -1.47048607e-02f, 9.23681259e-02f, 1.82002023e-01f, 1.73738256e-01f, -3.28011289e-02f, 1.53386354e-01f, 3.86006057e-01f, 2.06479758e-01f, -7.00375736e-02f,
  -2.74216081e-03f, 1.68963611e-01f, 2.40214109e-01f, 4.28697728e-02f, -2.84247771e-02f, 6.33404553e-02f, 2.08110344e-02f, 2.05419362e-01f, 2.53027231e-02f, 2.11271331e-01f,
  -9.77926478e-02f, -2.51166284e-01f, -8.86506438e-02f, 5.38996002e-03f, 2.24759281e-01f, -1.52892083e-01f, -2.19714448e-01f, 4.27755490e-02f, -9.49777812e-02f, -4.11390252e-02f,
  1.28703371e-01f, -5.39446659e-02f, 1.18985362e-01f, 9.92075633e-03f, -3.30813869e-04f, -1.84934050e-01f, 1.63454711e-01f, 1.44316584e-01f, 4.25991192e-02f, -1.01630576e-01f,
  2.88982332e-01f, 5.49495108e-02f, -4.71090488e-02f, -1.19202547e-01f, -1.66579083e-01f, 3.51110458e-01f, -3.08328941e-02f, -2.00475175e-02f, -6.53812364e-02f, -5.13587147e-02f,
  5.63192926e-02f, 1.52715981e-01f, 1.33743733e-01f, -8.77431966e-03f, 8.88951495e-02f, -4.29187678e-02f, -6.28354996e-02f, 8.98555890e-02f, -1.22602724e-01f, -5.63457794e-02f,
  4.87237498e-02f, -3.99214774e-02f, -3.70490141e-02f, -2.05647126e-01f, -2.78367512e-02f, -3.29526551e-02f, -8.83070752e-03f, -6.55993670e-02f, 1.04048640e-01f, -7.90293291e-02f,
  2.95794290e-02f, 4.59299721e-02f, -4.74936999e-02f, 4.37594811e-03f, -1.27699435e-01f, 1.27583027e-01f, -3.37426513e-02f, 5.62265143e-03f, -3.27023827e-02f, -2.78607477e-02f,
  -1.91737548e-01f, 1.08286992e-01f, -3.28143746e-01f, -3.63486782e-02f, -4.86430973e-02f, -1.01535497e-02f, 3.94845977e-02f, -1.33153200e-02f, -1.08441133e-02f, -9.01760533e-02f,
  2.05197372e-02f, 3.29018347e-02f, 8.05338398e-02f, 8.94009471e-02f, -5.77860326e-02f, -2.76309311e-01f, -5.45464233e-02f, -4.61436845e-02f, 3.56231481e-02f, -1.31884620e-01f,
  1.52749106e-01f, -2.09272131e-01f, -1.37714729e-01f, -1.56830490e-01f, -1.79817766e-01f, -9.87827703e-02f, -1.45628631e-01f, -2.27733225e-01f, -1.66136280e-01f, -2.43169636e-01f,
  -6.74592197e-01f, 4.44658875e-01f, 4.69887912e-01f, -3.23111475e-01f, -8.94264802e-02f, 2.39727050e-01f, 4.02056575e-01f, 4.66553010e-02f, -3.20882071e-03f, 2.73982227e-01f,
  1.06493294e-01f, -2.35814810e-01f, 1.13615558e-01f, -6.28159940e-02f, -4.75949869e-02f, 4.69017178e-01f, 3.28385413e-01f, -1.79832280e-01f, -5.26148319e-01f, -3.87347281e-01f,
  -1.43281072e-01f, -3.72899979e-01f, -5.23231566e-01f, -1.81452632e-01f, 1.45911083e-01f, -1.20671906e-01f, 3.14007491e-01f, -9.26704481e-02f, 6.30483404e-02f, 2.98983276e-01f,
  5.85959591e-02f, 3.08438297e-02f, 2.14876346e-02f, -1.77379429e-01f, 2.11634045e-03f, 7.28927329e-02f, 3.37891094e-02f, -3.91683131e-02f, -6.08267710e-02f, 8.24489966e-02f,
  -8.08348879e-02f, 5.32930531e-02f, 8.06490928e-02f, -8.81117396e-03f, -6.29982576e-02f, -1.70107633e-01f, -7.97500387e-02f, -5.30845374e-02f, 2.98737362e-02f, 9.15086642e-03f,
  1.38113126e-01f, -3.85048389e-01f, -2.26597205e-01f, 1.96159884e-01f, 1.46976605e-01f, -2.99047440e-01f, 5.49253309e-03f, -2.47749537e-01f, -2.69788969e-02f, -8.30075145e-02f,
  -1.53214000e-02f, -4.13445868e-02f, -1.35822743e-02f, -4.24151495e-02f, -5.12310490e-02f, 5.63392043e-02f, 3.98098566e-02f, 6.10271953e-02f, -1.12403437e-01f, -1.03996985e-01f,
  7.54280165e-02f, -2.26490647e-02f, -6.31623045e-02f, 6.44451752e-02f, 2.06443276e-02f, 4.67676576e-03f, -7.20968992e-02f, 1.82851106e-02f, 1.90535560e-02f, -5.90246450e-03f,
  -1.31912351e-01f, -1.01498403e-02f, 1.13828236e-03f, -1.85839161e-02f, 1.28985316e-01f, 1.09943844e-01f, 3.93538475e-02f, -2.29272377e-02f, -1.57417171e-02f, 8.97888541e-02f,
  -1.55537814e-01f, -2.21936814e-02f, 9.81751978e-02f, -1.93470549e-02f, -2.44314112e-02f, 1.35520371e-02f, -1.81837109e-04f, 4.38276120e-02f, 5.03619313e-02f, -7.93902427e-02f,
  1.06060028e-01f, -6.40734136e-02f, 6.86516687e-02f, 6.78231567e-02f, -1.71122164e-01f, -7.78477415e-02f, -1.05169088e-01f, -1.20553546e-01f, -1.13715343e-01f, -1.21768326e-01f,
  3.54350284e-02f, -2.71091074e-01f, -3.23144078e-01f, -5.24827428e-02f, -1.28955036e-01f, -3.84495288e-01f, -1.07734010e-01f, -2.59706020e-01f, -2.06147090e-01f, -2.09216356e-01f,
  2.20747128e-01f, -4.08055872e-01f, 1.58590585e-01f, 2.22212717e-01f, 1.12152353e-01f, -9.63715166e-02f, -3.78806472e-01f, -1.40663594e-01f, 6.17157333e-02f, 1.67681575e-01f,
  2.58080781e-01f, 3.78105253e-01f, 3.64149928e-01f, 2.08425507e-01f, 7.78586566e-02f, -4.84680198e-02f, 1.30428940e-01f, 1.64431527e-01f, 2.56594688e-01f, 1.21114098e-01f,
  7.73580596e-02f, 2.22511105e-02f, 7.48288119e-03f, -1.98078342e-03f, 8.46079513e-02f, 2.59846449e-01f, 2.20838003e-02f, 5.67368679e-02f, -1.76170550e-03f, 7.88225457e-02f,
  1.78444520e-01f, -2.02073380e-02f, 1.12971455e-01f, 2.22758040e-01f, 1.21217541e-01f, 1.90080982e-02f, 1.31802201e-01f, -9.75185782e-02f, -1.33819908e-01f, -1.31686525e-02f,
  1.95950404e-01f, 4.69599739e-02f, 1.69368014e-01f, -6.96858577e-03f, -5.93202077e-02f, 1.01233155e-01f, 4.80720624e-02f, -9.15188566e-02f, -1.01679437e-01f, 9.89770400e-04f,
  6.77367970e-02f, 8.75598341e-02f, -4.15625349e-02f, -9.72763598e-02f, 1.03434943e-01f, 1.66763052e-01f, 3.34109738e-02f, 3.84130366e-02f, 1.86452214e-02f, -1.01030737e-01f,
  3.14387947e-01f, 1.06876470e-01f, 2.07517862e-01f, 7.36970454e-02f, 5.37986308e-03f, 1.14815064e-01f, 2.69512255e-02f, -7.03974674e-03f, 1.52898267e-01f, 1.74474254e-01f,
  -2.27319286e-03f, 6.35662954e-03f, -8.97146910e-02f, 2.19193157e-02f, 2.98788846e-01f, 1.46736205e-01f, -4.99003641e-02f, -1.02870325e-02f, 1.78129062e-01f, 5.05884588e-02f,
  6.73521310e-02f, 1.57621056e-02f, 2.41974190e-01f, 8.62360373e-03f, 4.73624021e-02f, 2.01154798e-01f, 1.44138873e-01f, 1.25905693e-01f, 1.10021047e-01f, -2.25983560e-02f,
  -6.26848862e-02f, 2.47139186e-01f, 1.56040005e-02f, -2.26198491e-02f, -9.32081416e-02f, 4.63240147e-02f, -4.02529128e-02f, -1.40757129e-01f, -1.64168626e-01f, -1.97971418e-01f,
  1.20790489e-02f, 7.17990845e-02f, -1.51919588e-01f, 7.81413689e-02f, 6.74796924e-02f, 4.74244766e-02f, -4.04462405e-02f, -4.71083857e-02f, -1.49969786e-01f, 7.92440698e-02f,
  1.22785745e-02f, -5.94655834e-02f, 7.28342682e-03f, -7.74314478e-02f, -6.61461204e-02f, 1.99454218e-01f, 4.98547517e-02f, 2.98857745e-02f, 1.88250579e-02f, -1.37584507e-01f,
  4.33050990e-01f, 4.31733817e-01f, 1.71523184e-01f, 1.23397239e-01f, -2.71513127e-03f, -5.25554828e-02f, 1.55610994e-01f, 1.30448893e-01f, -2.74905097e-02f, 1.81111366e-01f,
  1.27093419e-01f, -1.02889195e-01f, -7.69596472e-02f, 4.22785012e-03f, 2.34187633e-01f, 2.43567824e-01f, 1.30282298e-01f, 1.27666399e-01f, -1.49366921e-02f, 1.33283839e-01f,
  1.44900516e-01f, 1.33817956e-01f, 1.94616482e-01f, 1.08974561e-01f, 1.11609265e-01f, 2.96560265e-02f, 1.13525786e-01f, 2.85945565e-01f, 1.63671777e-01f, 3.04702014e-01f,
  2.08129957e-01f, 1.92035913e-01f, -3.58285904e-01f, -1.47178397e-01f, -6.66987747e-02f, -5.96459024e-02f, -4.23625037e-02f, -4.43318300e-02f, -7.78837651e-02f, 3.31094190e-02f,
  -3.39396298e-02f, -6.75270185e-02f, 3.44929844e-02f, -4.47212197e-02f, 6.04856424e-02f, -3.34075354e-02f, 3.24188583e-02f, 9.39406455e-02f, -8.61797333e-02f, 3.00610885e-02f,
  -9.82200541e-03f, -2.77590267e-02f, 3.60426158e-02f, -9.45805460e-02f, 1.19131446e-01f, -9.28841829e-02f, -5.49609363e-02f, 2.33992860e-02f, -1.25036433e-01f, 1.46404281e-01f,
  -1.87032260e-02f, 6.75161630e-02f, 9.01237205e-02f, 8.67468566e-02f, 1.13502517e-01f, 3.20970714e-02f, 7.44396672e-02f, 1.27676681e-01f, -1.76001084e-03f, 9.07768607e-02f,
  -4.41392213e-02f, -1.73348584e-03f, -5.20280749e-03f, 1.52793834e-02f, 1.66998673e-02f, 2.66661439e-02f, 1.20260134e-01f, 9.11918953e-02f, -3.93808782e-02f, -5.28119653e-02f,
  -1.73493046e-02f, -6.59772158e-02f, -4.58904691e-02f, -6.93466282e-03f, -1.84785053e-02f, -7.83385634e-02f, 1.53404120e-02f, -8.06148909e-03f, 3.60643342e-02f, 1.11020178e-01f,
  -3.09998930e-01f, -2.81951189e-01f, -3.92896533e-02f, 1.92155987e-02f, 3.72911780e-03f, -6.84434101e-02f, -6.16329797e-02f, -9.44493338e-02f, -6.28949627e-02f, 4.87113418e-03f,
  -2.44233627e-02f, -9.96832363e-03f, -8.31557140e-02f, -1.31944716e-02f, -8.30238760e-02f, -1.56271026e-01f, -9.37284455e-02f, -4.83920500e-02f, -9.54317302e-02f, -3.51059181e-03f,
  -1.76785618e-01f, -1.79064274e-01f, -1.06498316e-01f, -2.13296711e-01f, -9.62698683e-02f, -2.74865925e-01f, -9.01848376e-02f, -1.83264256e-01f, -1.81790903e-01f, -1.04942292e-01f,
  -7.32945442e-01f, -9.90341008e-02f, 1.75457954e-01f, -3.28117937e-01f, -1.74541593e-01f, 2.45688394e-01f, 3.35872769e-01f, -9.03165936e-02f, -3.04623872e-01f, -1.11390859e-01f,
  1.50182704e-02f, 7.21155778e-02f, -1.07638061e-01f, 1.64622232e-01f, 3.81462947e-02f, 1.92166209e-01f, -1.23728126e-01f, -1.30217806e-01f, 3.33562531e-02f, 1.44065380e-01f,
  1.43818840e-01f, -2.02874705e-01f, -3.63541394e-01f, -2.22572893e-01f, 2.99053197e-03f, -9.86955389e-02f, 3.81405391e-02f, -1.27061024e-01f, 1.44758791e-01f, 1.43844439e-02f,
  5.27705312e-01f, 6.20959187e-03f, 1.15559995e-01f, -7.44794235e-02f, -2.34799832e-02f, -1.44320324e-01f, -9.07299866e-04f, -1.08381793e-01f, -1.46473199e-01f, 1.11777842e-01f,
  -3.70820872e-02f, -5.25735170e-02f, 3.56109329e-02f, -1.87465195e-02f, 6.00002334e-02f, 1.18539572e-01f, -8.00708756e-02f, -1.51231596e-02f, 1.48419335e-01f, 2.89362162e-01f,
  2.03964263e-01f, -2.39677746e-02f, 1.88503936e-01f, 1.22065179e-01f, 3.67277190e-02f, -3.92148308e-02f, 1.90604463e-01f, 1.46624789e-01f, 7.94194266e-02f, -1.13903806e-02f,
  8.70932043e-02f, -4.89378870e-02f, 9.91850123e-02f, 9.73029621e-03f, -5.60137294e-02f, -2.30977647e-02f, 2.38586776e-02f, 7.28662461e-02f, -3.59858871e-02f, -1.27923965e-01f,
  7.79555440e-02f, 1.96936324e-01f, 1.12333670e-01f, -8.30379948e-02f, 2.95252036e-02f, 6.18902706e-02f, -5.67612834e-02f, 8.44612047e-02f, 9.28357914e-02f, 7.20503256e-02f,
  1.14303436e-02f, 1.32216560e-02f, 5.03900135e-03f, 1.54109240e-01f, 1.58140376e-01f, 3.34718190e-02f, 1.11487471e-01f, 1.27998114e-01f, -1.16490655e-01f, -5.23140803e-02f,
  3.28334123e-01f, 2.31115166e-02f, 2.97386036e-03f, -2.25650351e-02f, -1.75674856e-01f, -1.27928406e-01f, 8.64840969e-02f, -6.05162010e-02f, 1.73311401e-02f, 2.02820659e-01f,
  1.56709835e-01f, -1.37079626e-01f, 1.03282563e-01f, 3.31266746e-02f, -1.13476321e-01f, -5.45908399e-02f, -9.15854871e-02f, 6.37837052e-02f, 1.71216249e-01f, 1.61444008e-01f,
  -3.12856659e-02f, -4.93807718e-02f, 1.56746339e-02f, 7.00255483e-02f, 1.55726288e-04f, -5.81269562e-02f, 1.68805480e-01f, 1.05843529e-01f, 1.76571235e-02f, -8.90997946e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  2.79414713e-01f, 3.24768245e-01f, 7.12132931e-01f, 4.23387885e-01f, 4.85188842e-01f, 5.06249130e-01f, 4.93978947e-01f, 1.12824127e-01f, 1.55289456e-01f, 3.40155691e-01f,
  3.96694988e-01f, 4.90300149e-01f, 3.98717016e-01f, 3.97599995e-01f, 4.79973286e-01f, 3.53765041e-01f, 7.17838824e-01f, 2.21363962e-01f, 1.35321960e-01f, 3.29241276e-01f,
  5.12514234e-01f, 5.24047911e-01f, 5.85343242e-01f, 4.91412610e-01f, 2.54220188e-01f, 5.71866870e-01f, 4.19179171e-01f, 3.11233401e-01f, 2.61524022e-01f, 9.54024494e-02f,
  3.13988298e-01f, 3.61575216e-01f, 5.68950593e-01f, 3.38162452e-01f, 6.23324811e-01f, 5.15492737e-01f, 1.10183254e-01f, 3.88654381e-01f, 5.36532342e-01f, 4.82586324e-01f,
  -8.61436203e-02f, 1.27204448e-01f, 2.89677382e-01f, 5.11163771e-01f, 5.84338427e-01f, 2.94780076e-01f, 4.63733822e-01f, 4.28950995e-01f, 1.99394703e-01f, 3.65370095e-01f,
  3.72905850e-01f, 2.53171206e-01f, 5.07656753e-01f, 4.38712507e-01f, 1.54822588e-01f, 3.76940489e-01f, 7.24385381e-02f, 6.96347654e-01f, 4.21347767e-01f, 3.74762118e-01f,
  1.55808881e-01f, 4.50529277e-01f, 1.65270772e-02f, 1.63894981e-01f, 8.70095287e-03f, 3.75816554e-01f, 2.55425036e-01f, 4.13313240e-01f, 4.56760287e-01f, 3.69024247e-01f,
  2.75045276e-01f, 3.29140902e-01f, 4.77611631e-01f, 3.85716051e-01f, 1.56920657e-01f, 3.77500653e-01f, 1.90799788e-01f, 1.87796682e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -6.35320470e-02f, 7.70789199e-03f, -1.67008266e-01f, -5.49117215e-02f, -5.61124347e-02f, -8.98107328e-03f, -1.26907080e-01f, 2.39980631e-02f, -1.51237369e-01f, -6.09022379e-02f,
  -5.99436238e-02f, -1.71484239e-02f, -7.58026168e-03f, -8.64559561e-02f, -2.36404240e-02f, 1.61170121e-02f, -1.98689356e-01f, -1.74941823e-01f, -1.52899668e-01f, -5.56807071e-02f,
  -1.82040557e-01f, 2.60269586e-02f, -1.14654422e-01f, -1.21031553e-01f, -5.16481251e-02f, -4.02722992e-02f, -2.05502778e-01f, -1.25953093e-01f, -3.36712673e-02f, -1.49661258e-01f,
  -3.65570150e-02f, 1.66698843e-01f, 1.87115297e-02f, 1.26371816e-01f, 2.93942243e-01f, 8.33459273e-02f, -2.20522135e-01f, 4.62732799e-02f, 1.42923966e-01f, 2.31036600e-02f,
  2.58755106e-02f, -1.29971251e-01f, 8.32404420e-02f, -1.24630406e-02f, -1.82230443e-01f, 1.28262952e-01f, 7.39891380e-02f, 1.03533491e-01f, -1.27427140e-02f, -1.23353370e-01f,
  1.31262228e-01f, -2.10529998e-01f, -3.86493951e-01f, -5.38766503e-01f, 3.37226391e-02f, -3.10287505e-01f, -1.95774958e-01f, 3.18461746e-01f, -1.02555089e-01f, 1.44469142e-01f,
  -1.27263442e-01f, -4.80252981e-01f, 3.14476565e-02f, -4.53778237e-01f, -1.73175395e-01f, -4.42629829e-02f, -1.04011469e-01f, 4.65662181e-01f, 2.15129927e-01f, -1.15354389e-01f,
  -3.58065426e-01f, -1.64444149e-01f, -5.83848171e-02f, -3.04135531e-01f, -3.29931438e-01f, -1.13319881e-01f, -6.90468311e-01f, 3.00265085e-02f, -2.05460757e-01f, 3.27905416e-01f,
  -7.66509399e-02f, -2.41015509e-01f, 2.27755144e-01f, -2.03491271e-01f, 1.84949696e-01f, -4.67758672e-03f, 5.41939251e-02f, 2.14747667e-01f, 1.90164149e-01f, -1.15253992e-01f,
  3.73244435e-01f, 2.36068387e-02f, -7.97678292e-01f, -1.95248634e-01f, -2.62295127e-01f, -3.68181407e-01f, 2.76629299e-01f, -9.28954363e-01f, 5.21801934e-02f, 2.78912485e-01f,
  -3.75205040e-01f, -4.15318459e-01f, -4.76681702e-02f, 1.04637221e-01f, -5.76556027e-01f, 3.58175099e-01f, 3.25653404e-01f, -4.25159335e-01f, -3.45680155e-02f, -2.20212385e-01f,
  -3.55221361e-01f, -1.35757491e-01f, 1.70882598e-01f, -4.79086712e-02f, 1.45888418e-01f, -3.40410583e-02f, -1.35243356e-01f, -7.60028660e-02f, 3.31466377e-01f, 1.12225816e-01f,
  -3.74394178e-01f, -6.58808500e-02f, -2.41227314e-01f, -1.99656591e-01f, -5.88542163e-01f, -3.01871836e-01f, -2.97545530e-02f, 7.90966079e-02f, 1.32771462e-01f, 1.22870490e-01f,
  -1.59177586e-01f, -1.47168413e-01f, -1.50868997e-01f, -8.78077280e-03f, -1.90863952e-01f, -1.97582647e-01f, 1.73295945e-01f, -1.48700774e-02f, -2.89330855e-02f, 1.08705759e-02f,
  -3.05644795e-03f, 8.25625136e-02f, -3.47556546e-02f, 3.90528664e-02f, 4.58118096e-02f, 5.29455505e-02f, 1.32979617e-01f, -1.45865619e-01f, 5.11671975e-03f, 3.40859666e-02f,
  -1.69839203e-01f, -9.90783945e-02f, -9.16074403e-03f, -7.85155743e-02f, 8.44997019e-02f, -5.43741658e-02f, 1.79818079e-01f, -1.99842781e-01f, -8.43064040e-02f, -6.20188611e-03f,
  1.18382454e-01f, 8.09473991e-02f, 1.42190918e-01f, 5.39833074e-03f, -1.32741839e-01f, -1.03991874e-01f, -3.51704238e-03f, 3.09975654e-01f, -1.24114186e-01f, -2.12827951e-01f,
  2.04932451e-01f, 2.49296874e-02f, -1.84978664e-01f, -9.16911140e-02f, -2.01578662e-01f, -5.37681729e-02f, -1.04373462e-01f, 2.99923688e-01f, -3.59858602e-01f, 2.24817365e-01f,
  -7.01291740e-01f, -5.49435914e-01f, -7.47241497e-01f, -4.10795435e-02f, -6.64490044e-01f, -5.88378944e-02f, 2.23810196e-01f, 1.81306466e-01f, 1.67698964e-01f, -5.51403821e-01f,
  2.58317143e-01f, 9.68519300e-02f, 1.25575736e-01f, -5.43471687e-02f, -4.80375469e-01f, -5.84562898e-01f, 4.24928218e-02f, 1.12183422e-01f, -3.57307613e-01f, 4.36258912e-01f,
  -5.54184318e-01f, -2.57082701e-01f, -2.91452020e-01f, 1.73336685e-01f, -1.87823400e-01f, 1.44496188e-01f, 1.23325944e-01f, 1.47880288e-03f, 2.54666865e-01f, 2.08121073e-02f,
  6.51311219e-01f, 9.91550460e-02f, 7.64077365e-01f, -1.77976653e-01f, -2.90227085e-01f, 4.13963705e-01f, -4.29585725e-01f, -1.31220654e-01f, -3.26150000e-01f, 6.01973459e-02f,
  -3.50213587e-01f, 9.40247625e-02f, -4.05176997e-01f, 3.05961259e-03f, -8.79386008e-01f, -1.60692379e-01f, 6.17303327e-02f, -1.20178781e-01f, 1.22875378e-01f, 9.64743122e-02f,
  -8.80153701e-02f, 2.35040724e-01f, -3.24637532e-01f, 2.78998286e-01f, -5.61519921e-01f, -3.89839470e-01f, 2.25187287e-01f, -4.41338062e-01f, -4.81486022e-02f, -2.50215769e-01f,
  2.69979667e-02f, -1.81949243e-01f, 3.56786668e-01f, -1.11966627e-02f, -1.80506960e-01f, 1.49917096e-01f, -8.03020656e-01f, 5.27895808e-01f, -3.78590435e-01f, -1.40710488e-01f,
  -2.76479214e-01f, -1.05303071e-01f, -1.59774721e-01f, 1.34385973e-01f, 4.87589128e-02f, -3.18098962e-01f, -4.62513342e-02f, 1.60105139e-01f, -6.70563579e-02f, -1.73630856e-03f,
  2.08568588e-01f, 5.86103313e-02f, 1.79815128e-01f, 2.05000281e-01f, -1.41580194e-01f, 7.85155520e-02f, -1.29106864e-02f, 6.21979982e-02f, 1.60857514e-01f, 5.68601340e-02f,
  3.77484560e-02f, 2.31888324e-01f, -6.83845282e-02f, 1.22089246e-02f, 2.07800847e-02f, 7.99665786e-03f, -4.78347987e-02f, -7.86055475e-02f, 2.88527515e-02f, 2.77170122e-01f,
  -9.18980911e-02f, 3.37754786e-01f, -1.40170723e-01f, -9.36007872e-02f, -2.17051327e-01f, 3.28581706e-02f, -3.20895225e-01f, -2.93133736e-01f, 1.66876629e-01f, -3.56548995e-01f,
  -1.08510137e-01f, 3.16800982e-01f, 2.27768913e-01f, 2.01923594e-01f, -2.85294235e-01f, -1.76290885e-01f, -3.58208530e-02f, -2.28214845e-01f, -5.17455377e-02f, 2.09043801e-01f,
  4.81094606e-02f, 2.21381128e-01f, 2.18056202e-01f, 2.38173947e-01f, 5.02342097e-02f, 1.66550487e-01f, 1.71370089e-01f, -3.17107081e-01f, 1.07416794e-01f, -3.39503616e-01f,
  6.57567009e-02f, -2.13389203e-01f, 3.62273008e-01f, -9.97131094e-02f, -4.98802841e-01f, 5.16424179e-02f, 2.67436087e-01f, -1.99842632e-01f, 7.10146176e-03f, -1.61798373e-01f,
  4.85534519e-02f, 2.25765362e-01f, -4.28794146e-01f, 2.03236088e-01f, -1.02944799e-01f, -7.87658393e-02f, -1.42487317e-01f, 4.19579409e-02f, -5.01097977e-01f, -1.35075107e-01f,
  -7.66799077e-02f, -2.41828099e-01f, 5.57001531e-01f, 1.68404892e-01f, -2.91225761e-01f, -8.44087601e-02f, -7.17061937e-01f, 5.35994291e-01f, 4.66791034e-01f, -4.73578840e-01f,
  4.73521650e-01f, 2.65158415e-01f, -3.03524107e-01f, -8.49697441e-02f, -2.47174427e-01f, 2.34568249e-02f, -5.07564247e-02f, -1.06634580e-01f, -2.05661118e-01f, -6.19543046e-02f,
  -1.00582354e-01f, -2.50374023e-02f, 1.19284280e-01f, -1.32770553e-01f, -5.61174974e-02f, -4.45405781e-01f, -4.40886021e-01f, -3.26852977e-01f, -6.46566391e-01f, -6.78732097e-01f,
  6.53777644e-03f, 1.62801370e-01f, -5.23792841e-02f, -4.32578862e-01f, 1.77312449e-01f, 4.01767552e-01f, -4.91105765e-01f, -1.32079035e-01f, 1.13053724e-01f, 1.44700222e-02f,
  -2.09820464e-01f, -3.24228108e-02f, -1.44635141e-01f, 1.30487353e-01f, 2.54940778e-01f, -1.58644300e-02f, -4.58366312e-02f, -2.64393568e-01f, 1.51740909e-01f, 4.35586691e-01f,
  -2.71716774e-01f, 3.57202649e-01f, -4.56973433e-01f, -1.53252855e-01f, 3.09357662e-02f, -2.35062297e-02f, 1.09510042e-01f, 1.16656445e-01f, -8.30906257e-02f, -1.16094458e-03f,
  6.79733902e-02f, -1.59571216e-01f, -6.17753752e-02f, -2.22720224e-02f, -2.31908172e-01f, -5.59396707e-02f, 1.95152462e-02f, -1.71932772e-01f, -4.54788618e-02f, -1.70916133e-02f,
  -8.01733807e-02f, -7.66436979e-02f, -1.21344239e-01f, -3.97064760e-02f, 9.28809568e-02f, -1.75587237e-02f, -4.10881788e-02f, -1.45862594e-01f, -8.59284624e-02f, -1.21663295e-01f,
  4.81099188e-02f, 4.17832434e-01f, -4.05939549e-01f, 3.47982377e-01f, -2.43195444e-01f, 8.80842004e-03f, 1.32059842e-01f, 1.22834437e-01f, 2.68067215e-02f, 1.26572788e-01f,
  -3.06070328e-01f, -1.34417862e-01f, 3.43684912e-01f, -7.90339485e-02f, 1.23013839e-01f, -1.08452953e-01f, 6.82586655e-02f, 3.48334946e-02f, -3.40029295e-03f, -5.87116219e-02f,
  -7.76978768e-03f, 8.25574249e-02f, -3.73684727e-02f, -8.87519345e-02f, -7.52367020e-01f, -2.57716086e-02f, 8.02882254e-01f, -6.53434455e-01f, -3.05915177e-01f, -4.26629394e-01f,
  4.19308454e-01f, -2.17029408e-01f, -3.51526380e-01f, 1.31963566e-01f, -8.36237520e-02f, 3.91390055e-01f, -2.51373708e-01f, -4.19873953e-01f, 1.34738060e-02f, -3.67805183e-01f,
  1.08311653e-01f, 1.51649177e-01f, -1.51592270e-01f, -1.44137308e-01f, -7.39963055e-02f, -4.97468531e-01f, 4.28204030e-01f, -5.64877868e-01f, -2.89903730e-01f, 8.75954404e-02f,
  -4.84636486e-01f, -1.27422556e-01f, -4.18104887e-01f, -3.72749776e-01f, -2.34398931e-01f, 6.27045751e-01f, -2.27283284e-01f, 4.82483618e-02f, -3.57740700e-01f, 6.71363831e-01f,
  2.23104924e-01f, -4.11626756e-01f, -1.00398973e-01f, -4.52457294e-02f, 1.65027291e-01f, 1.98443949e-01f, -4.57724392e-01f, -3.79762948e-01f, -6.24430031e-02f, -2.76205897e-01f,
  3.01502734e-01f, -3.75403948e-02f, -2.78204292e-01f, -1.31569743e-01f, 5.00532724e-02f, -3.81618083e-01f, -3.95351887e-01f, -5.02054952e-02f, 6.74818754e-02f, -4.32438068e-02f,
  6.08497635e-02f, 4.35953677e-01f, -2.27637827e-01f, -4.37271148e-01f, -6.12311006e-01f, -1.78637728e-03f, -3.76996636e-01f, -4.17195857e-01f, 1.73249796e-01f, 5.09548783e-01f,
  -1.70331255e-01f, 1.78403482e-01f, -3.06408927e-02f, -3.56686085e-01f, 1.36357442e-01f, 2.50830837e-02f, 4.49170530e-01f, -1.16709933e-01f, 5.26429474e-01f, -3.15334022e-01f,
  -2.46644288e-01f, 3.43500882e-01f, 1.20126558e-02f, -1.71181023e-01f, -4.80421958e-03f, 1.23358838e-01f, 3.58065814e-02f, 4.57937755e-02f, -6.74240440e-02f, -1.05702490e-01f,
  -5.81922308e-02f, 6.05394272e-03f, -1.39175057e-01f, -1.70450389e-01f, -2.25237295e-01f, 1.22914523e-01f, 8.19571596e-03f, -7.01987147e-02f, 6.69789761e-02f, -3.38497525e-03f,
  -1.92104682e-01f, -8.09488073e-03f, 1.61227640e-02f, -8.27649385e-02f, 7.64890611e-02f, 2.01591343e-01f, -6.56869188e-02f, -1.50860595e-02f, 1.85549989e-01f, 8.34360793e-02f,
  4.38022241e-02f, -2.10918784e-01f, 4.27944154e-01f, -3.21130663e-01f, 1.07624613e-01f, -1.35502070e-01f, -4.41767365e-01f, 6.13434389e-02f, 7.12236837e-02f, -8.32699537e-02f,
  -2.28292629e-01f, -3.86836715e-02f, 2.08798945e-01f, -1.29086180e-02f, 1.07774407e-01f, 1.06148288e-01f, 4.21212651e-02f, -6.48015812e-02f, -8.75838250e-02f, 1.55883804e-01f,
  -6.88915551e-02f, 1.37760580e-01f, 6.44731894e-02f, -1.67256430e-01f, -6.46614075e-01f, 3.46580654e-01f, 4.09590036e-01f, -1.53665990e-01f, -8.16386938e-02f, 1.08789131e-01f,
  -3.55300009e-01f, -3.50718766e-01f, -5.12227356e-01f, 6.38163462e-02f, -2.95864940e-01f, -7.96551257e-02f, -9.52444747e-02f, -1.50115028e-01f, 1.28479004e-01f, -3.03653479e-01f,
  -2.01951694e-02f, -3.23638707e-01f, 5.92665374e-01f, -6.13312840e-01f, 4.83363606e-02f, -1.76375452e-02f, 2.53488094e-01f, -5.12279533e-02f, 3.56163144e-01f, -1.92063525e-01f,
  1.83739886e-01f, 1.40267223e-01f, -1.21567562e-01f, -6.15909696e-01f, -1.80478707e-01f, -1.26145080e-01f, -2.32795849e-01f, -3.23488116e-01f, 2.19393492e-01f, 3.67592722e-02f,
  -1.30704250e-02f, -4.42912638e-01f, 2.52520945e-02f, 2.92249829e-01f, 5.32230318e-01f, -1.12800643e-01f, -7.24955574e-02f, 4.17195000e-02f, -1.50171533e-01f, 4.75335956e-01f,
  3.53923552e-02f, -3.63882817e-02f, 2.59922117e-01f, 9.60152820e-02f, -5.81581414e-01f, -1.23358376e-01f, 4.86020744e-01f, -2.09233776e-01f, 7.35568032e-02f, -8.71991962e-02f,
  -9.80778486e-02f, -1.78422883e-01f, 3.52596119e-02f, -1.42414585e-01f, 1.75922886e-02f, -1.71014115e-01f, 2.11450666e-01f, -3.11612755e-01f, 8.38347152e-02f, -8.89428407e-02f,
  -1.16198063e-01f, -4.17516753e-02f, 2.31474176e-01f, -3.55533421e-01f, -1.08250774e-01f, -3.61052275e-01f, 2.61595905e-01f, 8.90271813e-02f, -3.24234217e-01f, -1.38541088e-01f,
  5.05219661e-02f, -1.24372967e-01f, 1.83511421e-01f, 8.31588134e-02f, 1.69223607e-01f, 1.67690113e-01f, 1.26923889e-01f, 2.31453374e-01f, 4.45543714e-02f, 1.01598628e-01f,
  1.56144634e-01f, 7.15013370e-02f, 7.95678049e-02f, 1.06526420e-01f, 1.53827459e-01f, 4.05936465e-02f, 1.39722332e-01f, 6.20465316e-02f, 8.25676844e-02f, 1.41469836e-01f,
  1.60655398e-02f, 2.07643703e-01f, 1.92791134e-01f, 1.19131997e-01f, 5.83824366e-02f, -4.41048294e-01f, 2.80939102e-01f, -1.23333253e-01f, 1.99576929e-01f, -2.07022160e-01f,
  1.81990340e-01f, -2.25249887e-01f, -2.85825809e-03f, 2.80853957e-01f, 2.04541638e-01f, -3.25487316e-01f, 4.14821431e-02f, -1.21935137e-01f, -9.61904898e-02f, 5.91917001e-02f,
  1.48805961e-01f, 1.41552225e-01f, 4.43987511e-02f, 1.56872228e-01f, -1.13114148e-01f, -2.55922042e-03f, -6.29329216e-03f, 6.48806915e-02f, -3.28790620e-02f, -3.18336129e-01f,
  3.79382133e-01f, -8.62695277e-03f, -2.82790154e-01f, 8.46267164e-01f, -5.87319374e-01f, 6.25343546e-02f, -6.22165561e-01f, -3.61128151e-01f, -1.85068145e-01f, -2.82394439e-01f,
  -3.03016782e-01f, 1.91776276e-01f, 2.47377992e-01f, 1.11369543e-01f, 2.07769632e-01f, -2.35441282e-01f, 4.25282985e-01f, -3.19361955e-01f, 1.84756190e-01f, 6.34642914e-02f,
  1.20163761e-01f, 1.83755130e-01f, -5.58075547e-01f, 9.31290314e-02f, 4.91797030e-01f, -2.28155009e-03f, -3.63219827e-01f, 1.79755986e-01f, 2.48127338e-02f, -2.46609062e-01f,
  -2.56367568e-02f, -4.87940818e-01f, -7.90720046e-01f, -3.82083237e-01f, -1.83820054e-02f, -6.86184585e-01f, -3.97565305e-01f, 8.47627893e-02f, -7.76190124e-03f, -4.28029560e-02f,
  -2.88617641e-01f, -4.07057613e-01f, -3.45649183e-01f, 6.95559084e-02f, 2.71609306e-01f, 1.62728861e-01f, 1.35963455e-01f, -8.69697928e-02f, -1.84054539e-01f, 5.07993698e-01f,
  -2.61184841e-01f, -2.79616266e-02f, 9.68066275e-01f, 3.42652231e-01f, -6.58808798e-02f, 5.58460169e-02f, 2.17599981e-02f, -4.67899293e-02f, -3.27064395e-01f, -4.09334511e-01f,
  7.74841895e-03f, -5.86132765e-01f, -5.17428555e-02f, 3.52346182e-01f, -2.13189229e-01f, -1.45847793e-03f, 3.02971806e-02f, -2.43529081e-01f, 2.27380633e-01f, -4.11703527e-01f,
  -5.14530003e-01f, -1.62092969e-01f, -4.83105302e-01f, -1.35264561e-01f, -5.30294597e-01f, -2.79427081e-01f, -5.54098301e-02f, -3.95516455e-01f, -7.50399008e-02f, -1.05830997e-01f,
  -4.39398699e-02f, -5.12454659e-02f, 2.34212261e-02f, -1.27904490e-02f, -6.65066466e-02f, 8.13862905e-02f, 2.62603965e-02f, 5.12965396e-02f, 1.15098305e-01f, 1.29823998e-01f,
  1.26854435e-01f, -9.58263054e-02f, 5.20711765e-02f, -4.07657512e-02f, -1.37073547e-01f, -1.78660154e-02f, 1.32194370e-01f, -1.96463950e-02f, -7.24684224e-02f, -7.62141272e-02f,
  -4.44099829e-02f, -1.09999128e-01f, -3.48161906e-02f, 2.73308039e-01f, -1.22703314e-01f, -1.71112865e-01f, -1.64555579e-01f, -1.44231781e-01f, 2.54551232e-01f, 2.28975862e-01f,
  -2.79981971e-01f, 1.15672186e-01f, -1.32947773e-01f, -1.29937530e-01f, 2.00186089e-01f, 2.12884098e-01f, -1.70630723e-01f, -2.07544211e-02f, -8.93566683e-02f, 3.53241116e-01f,
  -2.41753221e-01f, -3.26653421e-02f, 2.53983408e-01f, 1.33914590e-01f, -1.83256082e-02f, -2.51267612e-01f, 2.93201774e-01f, 2.26843394e-02f, -3.51469606e-01f, -6.94367215e-02f,
  -3.53926599e-01f, 1.85574383e-01f, 2.28759766e-01f, 1.23103924e-01f, -4.80791122e-01f, -5.23686945e-01f, -3.87641609e-01f, -2.36312658e-01f, 4.25934881e-01f, -2.47824758e-01f,
  -3.16865295e-02f, -4.64428365e-01f, 1.67945564e-01f, 5.85786283e-01f, -5.03462911e-01f, -3.22921038e-01f, -4.47582096e-01f, -1.04922846e-01f, -3.12429070e-01f, -8.90563149e-03f,
  -5.90603709e-01f, 3.27811629e-01f, 1.16734155e-01f, -7.54836798e-02f, 5.08112788e-01f, -6.55987710e-02f, -2.95860264e-02f, 5.85471764e-02f, 2.64212489e-01f, -2.14388579e-01f,
  -6.53435230e-01f, 3.95592451e-01f, -3.54614049e-01f, -2.51327753e-01f, -6.51904762e-01f, -6.85528517e-01f, -4.29303288e-01f, -3.58419150e-01f, -2.45885924e-01f, -3.84327710e-01f,
  6.34330034e-01f, -2.14776039e-01f, 2.32465528e-02f, 3.30306500e-01f, 1.80549562e-01f, -2.96486348e-01f, -1.73997864e-01f, -4.89583969e-01f, -5.87927960e-02f, -2.75041491e-01f,
  -9.22724083e-02f, -1.59170181e-01f, -1.23755626e-01f, -3.50860059e-01f, -1.71676591e-01f, -1.77806765e-01f, 3.21776159e-02f, 3.84704083e-01f, 3.85163389e-02f, -3.91541332e-01f,
  -5.46994135e-02f, -4.66529548e-01f, -3.66253704e-01f, -1.06965214e-01f, -2.06765279e-01f, 8.36080238e-02f, 3.30277458e-02f, -4.97976512e-01f, -4.81400847e-01f, -6.12546921e-01f,
  3.90278965e-01f, 6.29251972e-02f, 4.39884700e-02f, -3.05500448e-01f, 4.00539190e-01f, -3.60575855e-01f, 1.72101744e-02f, 4.20601331e-02f, -3.27021688e-01f, -2.91754216e-01f,
  1.10616283e-02f, -9.46660191e-02f, -1.74874246e-01f, -1.41908810e-01f, -1.20302752e-01f, -5.31155355e-02f, -8.57803822e-02f, 4.18322198e-02f, 7.75402505e-03f, -1.32951990e-01f,
  -1.07957736e-01f, -2.21852446e-03f, -1.40105575e-01f, -1.41671039e-02f, -1.40679926e-01f, -1.15539834e-01f, -1.70822777e-02f, 3.11737917e-02f, -3.97477783e-02f, -8.05887729e-02f,
  -1.84465684e-02f, -1.29992729e-02f, -9.37997326e-02f, 1.29591241e-01f, -8.97530615e-02f, 1.54924780e-01f, -2.11985126e-01f, 1.14562482e-01f, -1.36868209e-01f, -1.49624377e-01f,
  1.27998427e-01f, -1.33697361e-01f, -1.71158969e-01f, 1.64298430e-01f, -1.93256602e-01f, -5.19762412e-02f, 1.45241782e-01f, 4.71770652e-02f, 1.78336278e-01f, -2.47755852e-02f,
  1.06434211e-01f, 2.19078287e-01f, 2.24509552e-01f, -7.70564675e-02f, 1.05866276e-01f, -2.12758258e-01f, -7.83185940e-03f, -2.46890187e-01f, 4.88797605e-01f, 8.63242801e-03f,
  -3.14016789e-01f, -2.14272633e-01f, 4.92139876e-01f, -3.01516473e-01f, 8.83783177e-02f, -4.91804369e-02f, -5.21512866e-01f, 1.59493476e-01f, -2.07686290e-01f, -1.46524534e-01f,
  -2.04748467e-01f, -4.18007731e-01f, -5.03935814e-01f, 1.98567688e-01f, -4.95159119e-01f, -1.61412507e-02f, -1.83571368e-01f, -1.98615044e-01f, 3.79611462e-01f, -1.32282779e-01f,
  -1.79199189e-01f, -2.74827003e-01f, -3.44990939e-01f, 9.39611122e-02f, 1.24372423e-01f, -2.64414608e-01f, -8.43435898e-02f, 2.09000856e-01f, -5.16072512e-01f, -1.41136989e-01f,
  -8.44918251e-01f, -1.04041696e-01f, 5.86142480e-01f, -1.92167923e-01f, -6.47739917e-02f, 2.95660663e-02f, -1.24438889e-01f, -3.02647054e-01f, -9.25007761e-02f, -1.07403286e-01f,
  -4.45157439e-01f, -1.64273188e-01f, 1.19725820e-02f, 1.23608232e-01f, 1.39400423e-01f, -3.45084727e-01f, -3.96264255e-01f, 2.13674799e-01f, 3.38576525e-01f, -4.26284373e-01f,
  3.75621408e-01f, -3.89614761e-01f, -4.85652655e-01f, -1.80211402e-02f, -1.43512413e-01f, 1.19616330e-01f, 2.06948206e-01f, 2.39260700e-02f, -2.36649066e-02f, 2.61021376e-01f,
  -1.32267341e-01f, -1.70527473e-01f, 1.45789981e-01f, -1.83853224e-01f, -8.41355398e-02f, -2.31620073e-01f, 3.63124162e-01f, 5.61642013e-02f, -4.14414138e-01f, 9.74295139e-02f,
  4.30518180e-01f, 4.27097920e-03f, -8.59277248e-02f, 8.66194963e-02f, -2.14399785e-01f, 3.65638249e-02f, 2.33036473e-01f, 1.62846580e-01f, 3.85781266e-02f, 1.56297207e-01f,
  -1.56937279e-02f, 1.51735380e-01f, 1.78089552e-02f, 3.24456356e-02f, 8.04718137e-02f, 8.28928128e-02f, -1.13213003e-01f, -8.71008486e-02f, 9.31691155e-02f, 1.79960832e-01f,
  2.27115657e-02f, -4.28350531e-02f, -1.56984571e-02f, 1.70623749e-01f, 4.16972563e-02f, 9.77959111e-03f, 4.85452041e-02f, 1.46467969e-01f, 1.24254569e-01f, 4.82699603e-01f,
  -2.41254374e-01f, -3.69923860e-01f, 4.16561142e-02f, 3.14691067e-01f, -4.33111712e-02f, 3.67100269e-01f, -2.68126100e-01f, -2.00590789e-01f, 3.47151667e-01f, -2.52037227e-01f,
  3.14417124e-01f, 2.04526559e-01f, 2.14888707e-01f, 1.03080906e-01f, -2.91158212e-03f, 2.77717024e-01f, -2.40727708e-01f, -3.35718602e-01f, -1.40346676e-01f, -7.18013868e-02f,
  -1.13740861e-01f, -1.63586453e-01f, -1.31025657e-01f, -1.62038412e-02f, -1.77591801e-01f, -8.97138715e-02f, 5.55426002e-01f, -4.12572056e-01f, -1.05230607e-01f, 2.71707058e-01f,
  1.03228249e-01f, -2.62676299e-01f, -7.29460642e-02f, 8.22697282e-02f, 1.25087142e-01f, -3.33315492e-01f, -1.03407085e-01f, 8.53481069e-02f, 1.24124192e-01f, 5.71236499e-02f,
  3.61856431e-01f, -2.13375881e-01f, 4.80341949e-02f, -2.85832256e-01f, 9.27013084e-02f, -8.63244478e-03f, -2.61614799e-01f, -3.45998198e-01f, 1.32203087e-01f, -5.41906320e-02f,
  -2.65191704e-01f, -2.34626681e-01f, 8.07605311e-02f, -1.01351202e-01f, -2.38735765e-01f, -2.98113562e-02f, -1.58358723e-01f, -2.20013782e-01f, -4.04290468e-01f, -3.41072619e-01f,
  -1.45225644e-01f, -4.29439127e-01f, -4.07519668e-01f, 4.79603082e-01f, -2.39581645e-01f, -1.37071967e-01f, -3.68445873e-01f, 5.24389923e-01f, -4.43073325e-02f, -2.18756720e-01f,
  -3.06661278e-01f, -1.24402486e-01f, -2.01262414e-01f, -4.18486357e-01f, -4.06956106e-01f, 1.83467120e-01f, -6.40299916e-01f, -3.62219602e-01f, -3.61275613e-01f, -3.60246748e-01f,
  -2.22645253e-01f, 2.27860495e-01f, 3.32229882e-01f, -1.33439898e-01f, -2.90061116e-01f, 5.88868499e-01f, -2.01585129e-01f, 5.02241822e-03f, -4.25713390e-01f, -5.29849119e-02f,
  1.62843913e-02f, 1.81364954e-01f, 1.16963826e-01f, 1.02939270e-01f, -1.90327317e-01f, 4.77541775e-01f, -3.52798164e-01f, -2.00112998e-01f, -3.74428034e-02f, -5.67843392e-03f,
  -2.03529701e-01f, -3.69637132e-01f, -1.65841058e-01f, -7.76727423e-02f, 3.17916274e-02f, 4.53435779e-02f, -2.67714746e-02f, 6.68997169e-02f, 1.38048574e-01f, 5.92764951e-02f,
  -1.06542483e-01f, -1.74001276e-01f, -4.22022641e-02f, -1.69667631e-01f, -1.32429108e-01f, -2.34490454e-01f, 7.50610232e-02f, 6.13449290e-02f, 1.26097903e-01f, 1.72488298e-02f,
  8.20428580e-02f, 1.21197432e-01f, -1.44718051e-01f, -5.72720915e-03f, 1.19336611e-02f, -1.07002571e-01f, -8.99675712e-02f, 1.17999651e-02f, 1.90156341e-01f, 3.75406293e-04f,
  3.30207139e-01f, 1.35773644e-01f, 2.45285720e-01f, 4.43292968e-02f, -4.94987443e-02f, 2.48992294e-01f, -8.50328282e-02f, 1.59693345e-01f, 1.61640331e-01f, -3.18474263e-01f,
  -1.21288642e-01f, 4.32552211e-02f, -1.64556742e-01f, -2.22075149e-01f, 2.11590409e-01f, -1.33670583e-01f, 1.65826529e-01f, 2.21106112e-02f, 2.10983709e-01f, -1.91239715e-01f,
  1.47688314e-01f, 3.04565042e-01f, 4.42415893e-01f, -1.45005947e-02f, -1.70958459e-01f, 3.24624360e-01f, 3.02186012e-01f, -3.06055486e-01f, -2.61036575e-01f, 4.65700299e-01f,
  3.15247089e-01f, -5.79945780e-02f, 2.30431676e-01f, 4.92132187e-01f, -2.62303382e-01f, 6.03619926e-02f, -2.43488342e-01f, -4.32213277e-01f, -3.76079679e-01f, 2.54711241e-01f,
  -2.80323207e-01f, 1.14360228e-01f, -2.66153991e-01f, -4.75189298e-01f, 1.93160236e-01f, 4.03965026e-01f, 1.20176524e-01f, -6.08784080e-01f, -2.08271936e-01f, -2.70159990e-01f,
  -2.96370983e-01f, 4.80506271e-01f, 2.92608649e-01f, -5.11631668e-01f, 8.17818791e-02f, -4.18930441e-01f, -4.07345444e-01f, -5.09913981e-01f, -1.83266446e-01f, 3.49432975e-01f,
  2.99007386e-01f, 6.96544200e-02f, -4.07190204e-01f, 5.58215417e-02f, -1.29521862e-01f, -3.87196928e-01f, -4.43225920e-01f, 2.57110083e-03f, -4.40350845e-02f, 1.92854077e-01f,
  -4.92048077e-02f, 6.82128668e-02f, 5.32016695e-01f, -1.95351496e-01f, -3.25440943e-01f, -4.44880426e-01f, -3.51494014e-01f, -6.86610520e-01f, -3.93066913e-01f, 2.37416193e-01f,
  -2.46792883e-01f, 2.69017637e-01f, 1.31809980e-01f, -7.81867579e-02f, -2.14702748e-02f, 3.80587012e-01f, -5.51065445e-01f, -3.45176041e-01f, -2.28664994e-01f, -5.27414203e-01f,
  3.61885041e-01f, -2.09768876e-01f, 3.98614526e-01f, -1.52329490e-01f, -1.57557294e-01f, 1.24692954e-01f, -5.80884516e-01f, 1.89851597e-01f, -3.04673295e-02f, -1.59403756e-01f,
  5.32796234e-02f, -5.46705276e-02f, -5.48801897e-03f, 5.25777750e-02f, 1.04436927e-01f, -7.07291439e-03f, -3.51180090e-03f, 1.79455429e-02f, 1.50801480e-01f, -3.30454037e-02f,
  5.67284450e-02f, 6.74660802e-02f, 1.08017791e-02f, 1.07222952e-01f, 1.33458093e-01f, 1.28516471e-02f, 1.03921063e-01f, 9.16125178e-02f, 1.00210242e-01f, 8.03385004e-02f,
  1.39044657e-01f, -2.87302583e-02f, 1.12609684e-01f, -6.44668043e-02f, -1.41974352e-02f, -4.09526518e-03f, 2.61645615e-01f, 3.13982099e-01f, 1.24060519e-01f, -1.48952946e-01f,
  -1.98993459e-01f, -4.00815019e-03f, 1.61311269e-01f, -2.63629794e-01f, -2.18337886e-02f, 1.73056275e-01f, 2.90765017e-01f, -7.09621087e-02f, 2.43803576e-01f, -1.91227242e-03f,
  2.42180437e-01f, -1.92388650e-02f, -1.12444833e-01f, 2.20228896e-01f, -1.46015301e-01f, -1.54451728e-01f, -1.20647863e-01f, 7.43647963e-02f, -1.82318702e-01f, -1.81749076e-01f,
  -4.17856842e-01f, -2.20385343e-02f, 9.78060365e-02f, -1.29336268e-01f, -3.62455934e-01f, -2.08801031e-01f, -2.77180344e-01f, -1.05547063e-01f, -2.09698156e-01f, 2.66341180e-01f,
  -1.38934791e-01f, 4.35719401e-01f, -5.68883047e-02f, 6.72874367e-03f, -3.67494136e-01f, -2.04960093e-01f, -6.48742020e-01f, -3.67905229e-01f, -2.18626782e-01f, -2.30383024e-01f,
  2.78337032e-01f, -1.92972302e-01f, -5.19374549e-01f, 2.92945951e-01f, -2.66517341e-01f, -3.23706806e-01f, -3.44009638e-01f, -2.08960950e-01f, -5.56203246e-01f, -2.69123584e-01f,
  -1.51028648e-01f, -1.60684749e-01f, 1.92816734e-01f, -1.07168786e-01f, -3.75791222e-01f, 2.16773614e-01f, -4.46480036e-01f, -5.78287363e-01f, 6.07714713e-01f, 3.06070864e-01f,
  -4.25811946e-01f, 4.04712521e-02f, -3.48017365e-01f, -2.32329935e-01f, 4.50005859e-01f, -3.38710070e-01f, -2.29784071e-01f, 5.08844495e-01f, 5.13382137e-01f, -4.27879602e-01f,
  -2.22154915e-01f, -3.05222541e-01f, 2.83268932e-02f, 2.22921818e-01f, 2.74619788e-01f, -3.66611391e-01f, -4.22585040e-01f, -1.43503711e-01f, -2.94032454e-01f, -1.39946565e-01f,
  7.94735327e-02f, 2.17930004e-01f, -7.06701040e-01f, -1.76400170e-02f, -2.67505050e-01f, 5.29763699e-01f, 4.03484911e-01f, -2.14584976e-01f, -2.09061280e-01f, 2.91077077e-01f,
  -2.91426808e-01f, -2.54283637e-01f, -1.83372319e-01f, -2.39003394e-02f, -8.98290146e-03f, -2.12313235e-01f, -1.15633108e-01f, 3.52467567e-01f, 1.83376387e-01f, -4.50009592e-02f,
  4.88727875e-02f, -8.02055150e-02f, 1.02175504e-01f, 3.59464325e-02f, 1.61536500e-01f, -3.77077907e-02f, -2.41348259e-02f, 5.52235469e-02f, 1.95593834e-02f, -1.31535396e-01f,
  -1.07735604e-01f, 1.18562631e-01f, 1.15336724e-01f, -9.77861360e-02f, -2.01944318e-02f, 9.64095592e-02f, 6.14502244e-02f, -5.33182211e-02f, -8.10028166e-02f, 7.86997303e-02f,
  1.88102219e-02f, 1.36136502e-01f, 5.34173362e-02f, -4.10846114e-01f, -1.45025020e-02f, -1.24468900e-01f, -1.44688696e-01f, 1.61966532e-01f, 1.66597992e-01f, -3.34651358e-02f,
  -7.07902238e-02f, -1.73721574e-02f, -1.40769139e-01f, 7.13763237e-02f, -2.86361158e-01f, 2.17135102e-01f, 4.68493015e-01f, 7.21452534e-02f, -1.82122231e-01f, 1.14253514e-01f,
  -2.14475572e-01f, 7.58583918e-02f, 2.04617858e-01f, -3.65121484e-01f, -7.28600547e-02f, -2.16482639e-01f, 3.93738784e-02f, -1.60862170e-02f, -4.20867205e-01f, 2.44664803e-01f,
  -3.48609507e-01f, -2.67044842e-01f, -3.80941778e-02f, 4.82586682e-01f, -3.39770615e-02f, -2.44520739e-01f, 3.20740789e-01f, -1.23511113e-01f, -3.69865328e-01f, -5.00307620e-01f,
  -2.89620578e-01f, 2.58168608e-01f, -4.45584774e-01f, 3.10184479e-01f, 5.12891471e-01f, 1.53892308e-01f, -3.85276586e-01f, 2.10598603e-01f, 1.32028356e-01f, 7.35064149e-02f,
  6.02472484e-01f, -2.79306740e-01f, 1.06801234e-01f, 2.65143842e-01f, -3.27787757e-01f, 1.24784820e-01f, -1.84221894e-01f, -4.42273796e-01f, -1.47769645e-01f, -2.00563729e-01f,
  -2.56203145e-01f, 3.80567312e-01f, -4.77854669e-01f, 2.78710455e-01f, 1.41453177e-01f, -3.94573174e-02f, 3.01127672e-01f, -4.54751879e-01f, -1.88352540e-01f, -1.84596434e-01f,
  -7.40580633e-03f, 1.76499337e-01f, 5.98150730e-01f, -1.85970113e-01f, -4.35758799e-01f, -2.29770988e-01f, -8.15497711e-02f, -3.27429861e-01f, 3.04337293e-01f, -3.00401658e-01f,
  -3.70174587e-01f, -3.27822059e-01f, 2.66563669e-02f, -2.54059941e-01f, -6.89759552e-02f, 5.00569880e-01f, -3.56382966e-01f, -3.53553593e-01f, -1.21791393e-01f, -3.96972865e-01f,
  1.51768336e-02f, -4.74685758e-01f, -2.60054529e-01f, -2.38345221e-01f, -1.64948642e-01f, 1.08117409e-01f, -5.62578797e-01f, -2.02895701e-01f, 7.66496211e-02f, -3.84730324e-02f,
  5.89694023e-01f, 1.42959096e-02f, -1.31721143e-02f, -2.78247386e-01f, 2.05626518e-01f, -7.51125962e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.44257545e-01f, 9.96214673e-02f, 4.99445982e-02f, -2.32216194e-02f, -3.97417173e-02f, 1.57774374e-01f, -6.91697299e-02f, -8.01508129e-02f, 1.78813189e-02f, 1.24410622e-01f,
  -4.60405611e-02f, -9.13265646e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    