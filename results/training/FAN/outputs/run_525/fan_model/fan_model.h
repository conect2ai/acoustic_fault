/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.27987619e-02f, -1.80409089e-01f, -2.49077126e-01f, -1.84328914e-01f, 7.58566037e-02f, -2.09132314e-01f, -1.78110048e-01f, 2.06072684e-02f, 6.85814098e-02f, -4.59037013e-02f,
  -4.59026322e-02f, -6.86368495e-02f, -1.09711252e-01f, -2.11181879e-01f, -2.94942528e-01f, -1.81028992e-01f, -1.55025274e-01f, -1.20387375e-01f, 3.56824026e-02f, -8.97500515e-02f,
  -1.11986458e-01f, -3.95638831e-02f, -2.52857238e-01f, 2.03032270e-02f, -1.63163632e-01f, 4.47682068e-02f, 5.29681258e-02f, -1.16450451e-01f, -5.27297184e-02f, -1.13548420e-01f,
  -9.13848802e-02f, -3.52757014e-02f, 4.29340936e-02f, -5.23094349e-02f, -2.21394412e-02f, -5.20364661e-03f, 4.97125834e-02f, -4.20093834e-02f, -2.62495340e-03f, -1.28677459e-02f,
  1.68686341e-02f, -5.81575073e-02f, 3.22659910e-02f, -2.90810782e-02f, 8.05497691e-02f, -1.75488107e-02f, 3.78528656e-03f, 3.55622619e-02f, 2.57429038e-03f, -2.77134459e-02f,
  -9.86477733e-02f, 4.44911793e-02f, 2.84943208e-02f, -3.56347188e-02f, 5.35814166e-02f, -4.53726389e-02f, 1.58981662e-02f, 3.18919532e-02f, -2.41665374e-02f, 1.76135041e-02f,
  -4.82340828e-02f, -6.57846592e-03f, 2.30896450e-03f, -8.15963780e-04f, 1.43132638e-03f, 2.50393562e-02f, 1.56666487e-02f, -2.63974741e-02f, -2.73600332e-02f, 4.52827886e-02f,
  -2.68082097e-02f, -3.79286967e-02f, 4.38473076e-02f, 5.13743423e-02f, -2.73897815e-02f, 6.78426214e-03f, 3.88820358e-02f, -1.96493734e-02f, 3.74221206e-02f, -1.50708836e-02f,
  3.24595831e-02f, -1.86587572e-02f, -7.20538571e-02f, -1.14224032e-02f, -2.22931821e-02f, 1.46497441e-02f, -1.21923201e-02f, -1.37121358e-04f, 2.77936850e-02f, -1.92438941e-02f,
  3.07301823e-02f, -2.73031928e-02f, -4.05609347e-02f, -2.39244476e-03f, 3.97525057e-02f, 9.75147709e-02f, -3.83601487e-02f, 2.39187432e-03f, -3.02034244e-02f, -3.81165445e-02f,
  7.63696432e-02f, 7.09134191e-02f, 4.28213924e-03f, 3.90382647e-03f, 1.91577637e-05f, 3.29691707e-03f, -6.74638972e-02f, 2.17172112e-02f, 3.21125835e-02f, 8.40388238e-02f,
  -6.95124082e-03f, 1.38025796e-02f, -4.91892062e-02f, -3.18978950e-02f, -4.54057194e-02f, 7.45659173e-02f, 6.07976727e-02f, 1.29013313e-02f, 4.67127264e-02f, 7.56367594e-02f,
  8.66245553e-02f, 1.23461597e-02f, -2.74551250e-02f, 1.78565010e-01f, 1.08916074e-01f, 6.51417822e-02f, -1.18970364e-01f, 5.98472320e-02f, 2.17104238e-02f, 1.32179335e-02f,
  -1.77624263e-02f, -7.19502494e-02f, -1.42346472e-01f, 9.30731297e-02f, -7.88050815e-02f, -1.83905095e-01f, 1.76961884e-01f, -7.58942068e-02f, -7.74457008e-02f, 9.26688313e-02f,
  5.74958920e-02f, 8.38316604e-02f, -1.08003765e-01f, 8.23060870e-02f, 1.89111307e-01f, 5.47433868e-02f, 6.49948716e-02f, -6.80255890e-03f, 8.81274045e-02f, -9.73595364e-04f,
  -1.02517560e-01f, 2.90857982e-02f, -3.81127931e-02f, -6.31760731e-02f, 3.48876193e-02f, 7.00529218e-02f, -2.79843342e-02f, -8.94873124e-03f, 2.62436830e-02f, 4.27253209e-02f,
  -5.33210821e-02f, 5.21228276e-02f, -9.24227759e-03f, 5.49626984e-02f, 8.27625617e-02f, 1.14415642e-02f, -3.92512418e-03f, -2.43645515e-02f, -4.07721475e-02f, 2.08610967e-02f,
  -1.08227916e-01f, 6.69317171e-02f, -6.60331547e-02f, 5.13384119e-03f, -4.03475873e-02f, 1.03331707e-01f, -7.39316493e-02f, -4.90045035e-03f, -7.07173273e-02f, 7.51615614e-02f,
  9.56081301e-02f, -1.01177217e-02f, 1.50533216e-02f, 1.71138030e-02f, -5.53509034e-03f, -4.90691513e-02f, 6.47582188e-02f, 5.16402833e-02f, 6.64373413e-02f, -9.09606442e-02f,
  -1.13933701e-02f, 2.03445759e-02f, 6.69921264e-02f, -3.24123465e-02f, 2.46325638e-02f, -3.59875783e-02f, -2.29145624e-02f, -6.68810755e-02f, -1.21784657e-02f, 1.80363450e-02f,
  -1.06947593e-01f, -3.48469019e-02f, -1.06776794e-02f, -2.08630133e-02f, 1.40732573e-02f, 4.21940573e-02f, 6.08564960e-03f, -4.27209474e-02f, 5.77660799e-02f, 1.01477280e-01f,
  1.00570641e-01f, 3.40846330e-02f, -4.88761589e-02f, -3.06217950e-02f, 4.88722473e-02f, 6.03451096e-02f, -3.41201201e-02f, 1.12306476e-01f, -5.34226419e-03f, 7.83381686e-02f,
  7.54954144e-02f, -6.27500713e-02f, -5.10565657e-03f, 1.10702053e-01f, -8.25246423e-03f, -3.44724432e-02f, -5.25968112e-02f, 5.66342659e-02f, -2.83327922e-02f, -7.43661774e-03f,
  7.12640882e-02f, -7.67852888e-02f, 3.81809622e-02f, 1.12020243e-02f, 4.51717563e-02f, -3.13974097e-02f, 1.23768471e-01f, -1.26142889e-01f, 1.04468316e-01f, -2.52296310e-02f,
  -5.17808869e-02f, 1.55025527e-01f, 1.12870179e-01f, 3.02155823e-01f, -7.91016594e-02f, 6.58942685e-02f, 1.53321385e-01f, 4.69733104e-02f, -1.71133310e-01f, 1.04534887e-01f,
  2.22686641e-02f, 5.38494587e-02f, 1.02769531e-01f, 2.10681051e-01f, 1.66262984e-01f, 5.58284074e-02f, 1.54876500e-01f, 1.21722132e-01f, -4.47841324e-02f, 3.94388959e-02f,
  1.42157469e-02f, 1.16896600e-01f, 1.47528455e-01f, -4.25184891e-02f, 1.01215323e-03f, -2.92925425e-02f, 2.14461908e-02f, -4.37338576e-02f, 1.35128707e-01f, -1.13281775e-02f,
  5.10413088e-02f, 4.78127636e-02f, -6.94142804e-02f, 1.57418493e-02f, 3.88068371e-02f, -4.16365117e-02f, 2.78442539e-02f, 3.75348330e-02f, -1.37619916e-02f, 7.23443851e-02f,
  -1.05005680e-02f, 2.09404938e-02f, 7.57146478e-02f, -1.23935491e-02f, -9.73907113e-02f, -1.01198973e-02f, 5.61750261e-03f, 2.65896153e-02f, -5.03760204e-02f, -8.96927062e-03f,
  1.34709068e-02f, 6.83296397e-02f, 1.07156346e-03f, -1.18746553e-02f, 5.65398894e-02f, -1.15066499e-03f, -3.97210801e-03f, -1.87103432e-02f, -1.41764097e-02f, 2.41943654e-02f,
  5.35270087e-02f, 8.23193938e-02f, -3.18228528e-02f, -4.90959883e-02f, 7.44750574e-02f, -3.15859467e-02f, 1.10323697e-01f, -1.90327857e-02f, -4.57440838e-02f, 3.27723101e-02f,
  -3.10457218e-02f, 3.96738797e-02f, -4.78397496e-02f, -8.25529546e-03f, 2.44283467e-03f, -1.91950332e-02f, 4.40588146e-02f, 3.46756168e-02f, -6.51616510e-03f, 1.81461778e-02f,
  6.84180716e-03f, -3.60251889e-02f, -7.30523393e-02f, 1.33633465e-02f, -7.19513223e-02f, -8.59707743e-02f, -6.67272434e-02f, -8.09706748e-02f, 3.24374884e-02f, 5.88402376e-02f,
  4.24197055e-02f, 3.22985575e-02f, 6.82609752e-02f, -7.41120204e-02f, 1.08307032e-02f, 4.08830643e-02f, 1.59084368e-02f, 4.60177613e-03f, -3.26653123e-02f, -3.46281007e-02f,
  3.79744824e-03f, 3.14194039e-02f, -6.00366965e-02f, -3.58735071e-03f, 1.22791510e-02f, -8.81212205e-03f, 2.59417146e-02f, 5.27511127e-02f, 2.10315380e-02f, 3.51398923e-02f,
  5.09540690e-03f, 1.42155932e-02f, 6.28855899e-02f, -6.40021823e-03f, 1.71225742e-02f, -3.59023176e-02f, 1.15582976e-03f, 1.50200464e-02f, 9.06599090e-02f, 3.84281501e-02f,
  9.78479162e-03f, -1.76392540e-01f, 9.59333479e-02f, -1.98590290e-02f, -3.15344818e-02f, -9.23704579e-02f, 5.83902635e-02f, -6.68761060e-02f, -1.96419340e-02f, -1.32857010e-01f,
  -4.07014117e-02f, 1.03001386e-01f, 2.69378908e-03f, -1.60859987e-01f, 3.29625338e-01f, 1.29249692e-01f, -5.12279086e-02f, -3.78290080e-02f, 1.01531744e-02f, -1.31533861e-01f,
  9.64872539e-02f, -1.65745988e-01f, 1.41591951e-01f, -1.31684661e-01f, -1.30280375e-01f, -6.13362938e-02f, -1.71850938e-02f, 9.75782052e-02f, -6.39804378e-02f, 9.63655412e-02f,
  -3.02285068e-02f, -1.14034683e-01f, -9.29702818e-02f, -4.60189618e-02f, -7.79393315e-02f, 6.24033855e-03f, 5.17038889e-02f, 1.39363587e-01f, -4.36781859e-03f, 3.76352705e-02f,
  -5.17633669e-02f, 3.55275236e-02f, 5.76147847e-02f, 1.76813137e-02f, -2.74471808e-02f, -9.49665159e-02f, 3.21115978e-04f, -5.83160818e-02f, -3.77762951e-02f, 1.24722593e-01f,
  -1.84821524e-02f, 2.77031381e-02f, -4.73847948e-02f, 9.20559186e-03f, 6.21708371e-02f, 6.40188679e-02f, 1.20024895e-03f, 8.24283585e-02f, -3.46483551e-02f, 4.48229648e-02f,
  5.06063066e-02f, 3.09579559e-02f, 7.45204231e-03f, -2.44719051e-02f, -1.24090657e-01f, -2.32593268e-02f, -2.55633015e-02f, -7.33795241e-02f, 8.38824511e-02f, -6.13482967e-02f,
  -4.03541885e-02f, 1.21744145e-02f, -7.62184039e-02f, 4.26691994e-02f, 3.22925299e-02f, -4.58980538e-02f, -3.30629759e-02f, -4.28530574e-02f, 3.51281650e-02f, -1.35218734e-02f,
  -3.90799596e-06f, 3.62645350e-02f, -7.77276829e-02f, 5.64930923e-02f, -5.30484393e-02f, 3.23035978e-02f, -1.05275430e-01f, -5.99906631e-02f, 5.54934740e-02f, 5.92517443e-02f,
  -1.15352415e-01f, -1.94216564e-01f, -2.68622534e-03f, -8.28078911e-02f, 9.53788608e-02f, -1.28578236e-02f, 5.31050703e-03f, -4.63849492e-02f, -5.38119227e-02f, 4.03996184e-02f,
  -1.27644343e-02f, -4.27287072e-02f, 1.33154234e-02f, -1.15661677e-02f, -5.15599139e-02f, 4.76367865e-03f, -4.57131770e-03f, 3.48789072e-05f, 1.66638475e-02f, -2.35031284e-02f,
  -5.85202686e-02f, -5.93791753e-02f, 1.11383475e-01f, 3.86049552e-03f, 1.67445187e-02f, 3.81415035e-03f, 1.51373595e-02f, -1.43114813e-02f, 1.01448409e-01f, -4.32931352e-03f,
  5.92140332e-02f, -3.07421014e-02f, 2.06017211e-01f, 1.86177567e-02f, -1.40754357e-01f, 1.44347444e-01f, 1.75250888e-01f, -9.44226757e-02f, 1.06817372e-01f, -2.20475450e-01f,
  -9.65269282e-02f, -8.45917314e-02f, 1.15376428e-01f, -2.54602879e-01f, 6.92556873e-02f, 6.40666485e-02f, -8.32504872e-03f, -2.78911628e-02f, 9.58761573e-02f, -4.99601960e-02f,
  1.39275849e-01f, -2.97742248e-01f, -1.26899416e-02f, -1.12560391e-01f, -9.68779847e-02f, 1.12280749e-01f, -2.80527025e-01f, 1.35637581e-01f, -2.13041455e-01f, -1.12369031e-01f,
  1.06992513e-01f, 1.21152520e-01f, -9.07193404e-03f, 9.48710144e-02f, 1.59823289e-03f, 1.00768246e-02f, 3.17555033e-02f, 7.71303922e-02f, 3.74672152e-02f, -3.63259800e-02f,
  -2.27275398e-02f, 7.03523052e-04f, -3.92374955e-02f, 6.13362761e-04f, 4.95900288e-02f, -1.54353939e-02f, -9.80234668e-02f, -1.66166890e-02f, -8.54758024e-02f, -1.54941771e-02f,
  -9.94349178e-03f, 4.00923491e-02f, -4.35907952e-02f, -4.81725149e-02f, 9.08398256e-02f, 5.24283350e-02f, -3.34273838e-02f, 5.15378155e-02f, -1.57904662e-02f, -1.80337485e-02f,
  -8.02220684e-03f, 7.40328357e-02f, -5.75944707e-02f, -8.81340057e-02f, 6.77545145e-02f, -1.63296405e-02f, -3.84614430e-03f, -1.14676528e-01f, -1.70329958e-02f, -9.89430398e-02f,
  -9.86231863e-02f, 9.76358280e-02f, -4.75045070e-02f, 5.29091507e-02f, -4.84659225e-02f, -4.41639386e-02f, -8.47341679e-03f, -5.71635962e-02f, -1.28118489e-02f, -1.64049845e-02f,
  -4.60349582e-02f, 4.10433710e-02f, 3.68496589e-02f, 5.07221147e-02f, 8.23130608e-02f, -2.90088099e-03f, -7.07730949e-02f, 5.66717945e-02f, 4.00553457e-03f, 1.41057894e-02f,
  -5.29204272e-02f, -3.24120969e-02f, -9.55147445e-02f, 2.61133723e-02f, -1.11949682e-01f, 5.55002987e-02f, -6.23570010e-02f, -2.09946372e-02f, 1.44296855e-01f, 7.09619895e-02f,
  -2.87440401e-02f, 5.70727549e-02f, -9.56214499e-03f, 2.02722978e-02f, 3.73047451e-03f, -6.52263835e-02f, 5.59301041e-02f, 6.72427714e-02f, -4.12676595e-02f, -8.48759711e-02f,
  -5.25131598e-02f, 5.93770742e-02f, -1.27837630e-02f, -6.75548241e-02f, -7.97131360e-02f, -1.42480051e-02f, -6.88547865e-02f, -3.32335681e-02f, -6.96462244e-02f, -1.75448973e-02f,
  -1.53226003e-01f, 1.44099504e-01f, 9.31913853e-02f, 6.66071624e-02f, -7.07373023e-02f, -3.52647156e-01f, -2.05188513e-01f, -7.73047730e-02f, -1.64086595e-01f, 5.31224348e-02f,
  -1.15518793e-01f, 7.87152499e-02f, 5.79012185e-03f, -2.18625441e-01f, -2.00588167e-01f, -1.24628596e-01f, -2.11467013e-01f, -7.07396418e-02f, -8.35852772e-02f, -5.68749011e-03f,
  -3.04418486e-02f, -1.59492239e-01f, 7.30625214e-03f, 1.25201628e-01f, -1.95345096e-02f, 2.25075528e-01f, 2.25653380e-01f, 5.11941314e-02f, 1.53942019e-01f, -3.66750509e-02f,
  -1.21913448e-01f, -2.59155091e-02f, -3.23737157e-04f, -6.31879345e-02f, 1.93129829e-03f, 8.53605494e-02f, 5.41918874e-02f, 1.21410033e-02f, 9.34699085e-03f, 1.42092519e-02f,
  2.83562839e-02f, 3.84072959e-02f, -5.12165986e-02f, 2.65380740e-03f, -4.04568156e-03f, -3.54377963e-02f, 2.01459806e-02f, -5.88342324e-02f, -2.35030912e-02f, -4.38862778e-02f,
  5.77974394e-02f, -3.13403644e-02f, 4.38203961e-02f, 3.53032909e-02f, 4.47452888e-02f, -1.20627493e-01f, -6.03406094e-02f, -3.02067865e-02f, 7.07834587e-02f, -6.88719039e-04f,
  2.29499359e-02f, -2.76137646e-02f, -1.86950136e-02f, 4.45210515e-03f, 3.32208499e-02f, -5.21321334e-02f, -5.99245057e-02f, 7.40065947e-02f, -2.23878026e-02f, 4.31564003e-02f,
  -4.02791761e-02f, 3.43843326e-02f, -1.59204025e-02f, 3.67147615e-03f, 1.68370716e-02f, 7.05099776e-02f, -3.08818324e-03f, -2.44092084e-02f, -5.19577274e-03f, 4.94999066e-02f,
  9.96013754e-04f, 5.18102907e-02f, -1.35097420e-02f, 1.83666162e-02f, -3.33184451e-02f, 1.22329304e-02f, 1.17855063e-02f, 1.83479507e-02f, 2.46408656e-02f, 4.29293774e-02f,
  2.69411765e-02f, 2.17038333e-01f, 3.29957791e-02f, 2.51398813e-02f, -8.05882085e-03f, -7.76023269e-02f, -3.07927039e-02f, -1.84821952e-02f, 3.60735171e-02f, 1.08020697e-02f,
  2.64764391e-03f, -5.55787385e-02f, 3.82065848e-02f, 4.26114425e-02f, -1.52972406e-02f, 7.48377852e-03f, 1.36243086e-02f, 8.96387473e-02f, 1.05520345e-01f, 4.36989069e-02f,
  1.24617465e-01f, 2.82007153e-03f, 4.41995263e-02f, 8.84004831e-02f, 2.19261721e-02f, 6.57078549e-02f, 4.78899851e-02f, 7.42789954e-02f, 5.99892170e-04f, 1.43616158e-03f,
  3.24402064e-01f, 1.13470666e-01f, 1.95735805e-02f, 3.50412339e-01f, -7.54749924e-02f, 7.83035085e-02f, 1.29917979e-01f, -1.20971147e-02f, 1.63551584e-01f, 8.85648578e-02f,
  -1.08228788e-01f, 8.47824067e-02f, -1.32756546e-01f, 1.55450597e-01f, 1.50584981e-01f, -4.26654797e-03f, 1.80852234e-01f, 2.01808423e-01f, 4.06798944e-02f, 7.19942078e-02f,
  1.13920853e-01f, -1.94145478e-02f, -1.14528157e-01f, -2.08635807e-01f, 3.16959602e-04f, 4.98389304e-02f, -9.14128572e-02f, -1.17225587e-01f, 5.27391545e-02f, -1.40924066e-01f,
  1.07703581e-02f, -4.37108167e-02f, -9.85743850e-03f, -3.01505867e-02f, 1.24756643e-03f, 2.95260865e-02f, 2.99849845e-02f, 3.37084606e-02f, 1.54841328e-02f, -1.25301993e-02f,
  2.89055388e-02f, -4.90082540e-02f, 7.37909749e-02f, 5.68580218e-02f, 5.63351475e-02f, -2.16087196e-02f, -3.15161496e-02f, 3.99503112e-02f, 3.13794315e-02f, -5.41045628e-02f,
  3.89511473e-02f, -1.73098799e-02f, 3.72809172e-02f, -1.70741212e-02f, 1.30014895e-02f, 4.87627164e-02f, -2.69368757e-02f, -2.08814684e-02f, 5.89570552e-02f, 7.66810104e-02f,
  7.63045531e-03f, 2.58101206e-02f, 2.21942943e-02f, -6.15184382e-02f, 3.51900072e-03f, -1.25151137e-02f, 5.23106605e-02f, 3.39392647e-02f, 8.91257823e-02f, 7.33339088e-03f,
  2.41676364e-02f, 2.11234577e-02f, -9.28656459e-02f, 6.80603012e-02f, 3.91114503e-02f, 9.68413614e-03f, -1.74680296e-02f, 3.72133777e-02f, 1.34694397e-01f, 2.54112594e-02f,
  -8.05214643e-02f, 6.26358613e-02f, -4.98721860e-02f, -1.06662028e-02f, -5.85937351e-02f, 4.51000035e-02f, 4.52974103e-02f, 6.26252294e-02f, 5.75887924e-03f, -5.85222170e-02f,
  -3.57809588e-02f, 3.29016931e-02f, 1.57595407e-02f, -2.45377179e-02f, 1.00810593e-02f, -3.70910810e-03f, 1.92603748e-02f, 2.74157468e-02f, -6.99769333e-02f, 1.84546839e-02f,
  -1.84270032e-02f, 8.11271816e-02f, 1.11997105e-01f, 7.60025484e-03f, -8.39010850e-02f, 1.90628562e-02f, -3.49361785e-02f, 4.03627045e-02f, 6.25597732e-03f, -2.84014065e-02f,
  -5.22947013e-02f, 3.79296690e-02f, 4.11077999e-02f, 4.13367301e-02f, 1.26500592e-01f, 2.87879929e-02f, 3.07919644e-02f, 5.28392522e-03f, 1.46712540e-02f, -4.17977870e-02f,
  3.27138782e-01f, 2.31387597e-02f, 9.08978581e-02f, 2.98009276e-01f, -3.44111286e-02f, 1.27722044e-03f, 1.00992464e-01f, 3.16183753e-02f, 2.87249118e-01f, -1.11604892e-01f,
  6.05984405e-02f, 1.13602720e-01f, -1.59913689e-01f, 2.35681638e-01f, 2.31815711e-01f, 3.86528410e-02f, 2.71836102e-01f, 3.78899761e-02f, 2.75301263e-02f, 1.86625607e-02f,
  1.05477594e-01f, 5.41048832e-02f, -2.99785044e-02f, -1.13322459e-01f, 9.75159481e-02f, -2.89684124e-02f, -1.81467570e-02f, -1.32640243e-01f, -5.81746139e-02f, -8.28490928e-02f,
  6.52367994e-02f, 2.80985516e-02f, -1.77668761e-02f, -1.54364929e-02f, 3.10008377e-02f, -2.84696091e-02f, 3.25904526e-02f, -2.65458622e-03f, -5.82211688e-02f, 2.28929948e-02f,
  8.75150114e-02f, 4.72007580e-02f, 4.46027368e-02f, -8.94598896e-04f, 9.67090055e-02f, -4.53576818e-02f, 4.36845012e-02f, 2.50909720e-02f, 1.46655450e-02f, -2.39576232e-02f,
  -6.49955198e-02f, -3.01936269e-02f, 1.62307024e-02f, -6.36498854e-02f, -1.45164123e-02f, -1.42564392e-02f, 5.73742203e-02f, -7.83918425e-02f, -2.87955906e-02f, -2.03223098e-02f,
  -5.31156473e-02f, -4.21897694e-03f, -2.66379248e-02f, 8.03186670e-02f, 4.12322022e-02f, -5.58654480e-02f, 3.76956712e-04f, -4.66807373e-02f, -3.90745066e-02f, -1.42705785e-02f,
  2.57944912e-02f, -1.77649055e-02f, 5.05993441e-02f, -4.73226570e-02f, -8.17510933e-02f, -1.97022222e-02f, -1.38717638e-02f, -9.91029143e-02f, -2.29509603e-02f, 5.70047721e-02f,
  5.56986444e-02f, 1.24754221e-03f, -1.49990553e-02f, 1.28534427e-02f, 3.16160843e-02f, -7.12511688e-02f, 1.92206185e-02f, 6.44616596e-03f, 8.08080286e-03f, 4.41209339e-02f,
  -7.26106018e-02f, -1.14908507e-02f, -7.04644397e-02f, -4.42114174e-02f, -5.93462586e-02f, -8.91935453e-03f, 6.32092953e-02f, -6.61694258e-02f, 7.98084810e-02f, -4.65837494e-02f,
  -7.23355934e-02f, -4.17286381e-02f, -5.53310141e-02f, 2.85935495e-02f, -6.00425936e-02f, 1.52104385e-02f, 3.94204333e-02f, 6.90784724e-03f, 1.67224277e-02f, 6.19281977e-02f,
  6.08326904e-02f, -3.60174254e-02f, 5.99399991e-02f, -5.93203306e-02f, -9.02995002e-03f, -3.34430300e-02f, -2.70835012e-02f, -5.05015589e-02f, 1.40081635e-02f, 5.75294383e-02f,
  8.12972803e-03f, 5.30937389e-02f, -1.66066885e-01f, -3.97912934e-02f, -1.48040086e-01f, -2.25620866e-01f, -2.74935365e-01f, -3.32172000e-04f, -1.00896783e-01f, 1.22256026e-01f,
  8.66168812e-02f, -6.50958493e-02f, 4.62132320e-03f, -1.03068829e-01f, -5.68172038e-02f, -1.03000171e-01f, 3.98040647e-05f, 9.94482785e-02f, -6.76030442e-02f, 1.76657680e-02f,
  -1.86898615e-02f, -3.28751653e-02f, -1.86852068e-01f, 2.31397543e-02f, -1.28180161e-01f, 2.84526460e-02f, 1.68613240e-01f, -1.08975574e-01f, 1.00972861e-01f, -2.25786529e-02f,
  -5.15952967e-02f, 8.68927129e-03f, -6.09712973e-02f, -1.24725867e-02f, 8.17097127e-02f, 8.98063853e-02f, -4.55091940e-03f, -3.97347286e-02f, 3.80034298e-02f, -3.53731997e-02f,
  -1.02872029e-02f, 4.21108827e-02f, -2.70562805e-02f, -6.96359873e-02f, 3.06766555e-02f, 4.75779474e-02f, 1.58198643e-02f, -5.23416288e-02f, -1.01468305e-03f, 9.84270405e-03f,
  -1.28754377e-01f, 5.25414683e-02f, -4.08577122e-04f, 1.08471874e-03f, -9.11690965e-02f, -1.23759456e-01f, -1.13768235e-01f, 2.68171541e-02f, 3.41307037e-02f, -1.23569220e-02f,
  -8.06647912e-02f, -3.86446416e-02f, 6.59723431e-02f, 8.03675503e-02f, -3.37100029e-02f, -6.20426387e-02f, -7.73501322e-02f, -2.61456855e-02f, -2.53681540e-02f, -3.95354442e-02f,
  6.36448190e-02f, 1.78800542e-02f, 4.24281806e-02f, 6.63730800e-02f, -3.01145148e-02f, -4.81639020e-02f, -1.57371163e-02f, 3.15030962e-02f, -3.30892392e-03f, -2.11230218e-02f,
  -8.29159766e-02f, -5.11264019e-02f, -3.52808647e-02f, 8.89027864e-02f, 1.07624689e-02f, -2.11121999e-02f, 3.61661203e-02f, -1.11064604e-02f, -2.45740581e-02f, 6.73383400e-02f,
  -4.01452146e-02f, 5.15947416e-02f, 4.42768540e-03f, 5.58257522e-03f, -6.06686994e-03f, 5.69607057e-02f, 3.95039804e-02f, 6.15245253e-02f, -2.57277787e-02f, -8.42207819e-02f,
  9.11991298e-02f, 5.14881611e-02f, -5.61622716e-02f, 7.56593496e-02f, 6.83445483e-02f, 4.29272912e-02f, 1.02371722e-02f, 4.90226448e-02f, -3.11999321e-02f, 4.60234731e-02f,
  5.74610718e-02f, 1.59570593e-02f, 7.66776204e-02f, -7.83997327e-02f, 6.31960481e-02f, 4.59688082e-02f, -1.72937457e-02f, -1.02729289e-04f, 6.50582910e-02f, -3.31143662e-02f,
  -1.29786149e-01f, 1.12295002e-01f, 2.38089487e-01f, -4.88387095e-03f, 7.69168437e-02f, 3.64901721e-02f, -3.08842473e-02f, -4.05332632e-02f, 1.82494134e-01f, -1.63870826e-01f,
  -1.39340401e-01f, 1.91339254e-01f, 1.06483556e-01f, -1.25262931e-01f, -3.30937887e-03f, 9.76229981e-02f, -1.76528543e-01f, 1.06900679e-02f, 1.91611767e-01f, -1.54018581e-01f,
  -6.70066103e-02f, -1.60065100e-01f, 1.93151589e-02f, -6.74838051e-02f, -1.16070390e-01f, -1.25839785e-01f, -3.54465961e-01f, 1.58007015e-02f, -1.10124670e-01f, -1.51422126e-02f,
  -6.03385009e-02f, -1.51529163e-01f, -3.45266759e-02f, 9.54705328e-02f, -8.45027268e-02f, 2.01705680e-03f, -3.39611806e-02f, 1.06954701e-01f, 8.15211385e-02f, 1.46731392e-01f,
  7.60846511e-02f, 3.17264572e-02f, 3.29829864e-02f, 5.17456308e-02f, 5.12872078e-02f, 7.58597180e-02f, 2.60313433e-02f, -3.47923711e-02f, -9.10684541e-02f, -3.23005281e-02f,
  2.74582859e-03f, 1.05571933e-01f, 2.33121775e-03f, -9.71669182e-02f, 1.70196574e-02f, -7.73541769e-03f, -1.13014681e-02f, -5.90142943e-02f, -8.63099396e-02f, 5.74778765e-02f,
  -6.41190400e-03f, 6.82346383e-03f, -2.24803761e-02f, 1.66895054e-02f, -8.73585716e-02f, -2.28931699e-02f, -5.98503910e-02f, -2.27598846e-02f, -1.65432226e-02f, -6.85443431e-02f,
  -1.13880830e-02f, -1.53596289e-02f, 8.02189112e-02f, 2.75239386e-02f, -5.00507560e-03f, -3.11655067e-02f, -7.09298551e-02f, 1.08878985e-01f, -9.65778530e-02f, -1.07207755e-02f,
  -7.18073919e-02f, -5.49191944e-02f, 3.10418326e-02f, -1.68867651e-02f, -4.62474823e-02f, -5.25675621e-03f, 6.04609847e-02f, 1.94997210e-02f, 2.53139101e-02f, -6.09154329e-02f,
  -1.35763630e-01f, -1.08542532e-01f, -1.00206519e-02f, -3.96777317e-02f, 1.65504795e-02f, -7.12939426e-02f, 1.32758155e-01f, -2.51455847e-02f, -3.87863778e-02f, 1.24483733e-02f,
  -3.40061076e-02f, 2.09992193e-03f, -1.35945737e-01f, -2.83708028e-03f, 6.73348606e-02f, -5.50855882e-02f, -4.97909114e-02f, 1.65790264e-02f, -3.56228696e-03f, -1.91466734e-02f,
  -1.76311601e-02f, 1.56049570e-02f, -5.39067090e-02f, -4.20599692e-02f, -5.94927073e-02f, -4.49708104e-02f, -5.58123849e-02f, 6.52503222e-02f, -3.00275926e-02f, -4.75934125e-04f,
  5.61887845e-02f, 1.72820464e-01f, 6.00996539e-02f, 5.26065603e-02f, 8.38552713e-02f, 1.70969859e-01f, 1.17838822e-01f, 4.84121926e-02f, 9.38936397e-02f, 4.46598306e-02f,
  -2.71521360e-02f, 1.71555996e-01f, -1.74762055e-01f, -1.15747683e-01f, -1.35600537e-01f, -1.88237101e-01f, 3.93162295e-02f, 2.33192276e-02f, 1.42090702e-02f, -3.67811858e-03f,
  -1.51407272e-02f, -7.25088492e-02f, -1.03869587e-01f, -9.47350562e-02f, -6.60825521e-02f, 6.28767461e-02f, -1.42653495e-01f, 7.07703456e-02f, -7.02723414e-02f, 7.07358588e-03f,
  -9.24693048e-02f, -6.98260218e-02f, -1.18168510e-01f, -7.04617426e-02f, -4.41064611e-02f, -8.07170197e-02f, 1.07723400e-01f, -1.63644273e-02f, -6.68762401e-02f, 6.05083480e-02f,
  1.09042123e-01f, -5.64752799e-03f, -7.85409436e-02f, -2.62565464e-02f, 4.50099967e-02f, 1.00904691e-03f, 3.76746766e-02f, 8.56898800e-02f, 1.70153096e-01f, 9.36462954e-02f,
  -6.46249903e-03f, -5.61228953e-04f, 5.35911741e-03f, 5.33073358e-02f, 7.02050934e-03f, -3.87646817e-02f, -1.21175740e-02f, -1.43908085e-02f, 5.19858859e-02f, 1.17057458e-01f,
  4.19311188e-02f, 7.62738613e-03f, -3.80323492e-02f, 9.53460764e-03f, 1.22198844e-02f, 1.91359855e-02f, -1.61633659e-02f, -5.53935692e-02f, 7.01722205e-02f, 8.35795514e-03f,
  3.92124429e-02f, -3.30738607e-04f, 1.31559660e-04f, -1.38017088e-02f, 5.12957312e-02f, 2.23523825e-02f, -1.19106015e-02f, 4.23286557e-02f, 7.41058439e-02f, -4.40860689e-02f,
  5.25015546e-03f, 4.86235879e-02f, -8.81439224e-02f, 1.67642161e-02f, 1.10452082e-02f, 4.04465497e-02f, 5.01862578e-02f, -3.70635875e-02f, -7.42804930e-02f, 3.19528915e-02f,
  1.09114379e-01f, -1.11005887e-01f, -8.26488063e-02f, 3.35610434e-02f, -2.28910358e-03f, 1.38958516e-02f, -7.55350739e-02f, -3.87438275e-02f, -7.74765685e-02f, -6.87014833e-02f,
  2.80259550e-02f, -4.34039421e-02f, 4.96796966e-02f, 5.34045212e-02f, 3.40925739e-03f, 4.24871817e-02f, -3.75793800e-02f, 1.33364704e-02f, -4.64088283e-02f, 3.46858203e-02f,
  6.00266457e-02f, -2.19242498e-02f, -2.45859772e-02f, -3.97688933e-02f, -5.28653264e-02f, -6.92231720e-03f, 3.38649191e-02f, -2.17600539e-02f, -6.05333634e-02f, -1.16073854e-01f,
  -3.04402143e-01f, 3.61219615e-01f, -4.99995751e-03f, 1.92970693e-01f, -1.16073377e-02f, -3.12393270e-02f, 2.51961276e-02f, 1.50765851e-01f, 1.11999348e-01f, 1.69183671e-01f,
  6.83066389e-03f, 7.25948215e-02f, -6.09135181e-02f, 1.08707234e-01f, -2.73986608e-01f, 1.19802944e-01f, 3.26381773e-02f, -8.28740075e-02f, 3.17564383e-02f, -9.86070484e-02f,
  6.53671622e-02f, 3.22698839e-02f, 3.77583504e-02f, 1.31673291e-01f, -9.09045488e-02f, -2.51268633e-02f, -1.11767001e-01f, -7.92842433e-02f, 4.74501103e-02f, -3.84781579e-03f,
  -1.07535176e-01f, -3.78211066e-02f, -4.10524271e-02f, -1.13980457e-01f, -8.62175599e-02f, -1.10054195e-01f, -8.38419944e-02f, 3.76802757e-02f, -9.63750705e-02f, 1.55201759e-02f,
  -7.83817172e-02f, 6.16772510e-02f, -3.54039185e-02f, -2.07964759e-02f, -2.58017480e-02f, 6.64823279e-02f, 6.93156049e-02f, -3.80345099e-02f, 1.78344641e-02f, 2.87615303e-02f,
  6.07074006e-03f, -5.13233319e-02f, 1.19397091e-02f, 6.98834360e-02f, 2.43774094e-02f, 1.15203366e-01f, -3.71483117e-02f, -3.04793287e-02f, 3.41952108e-02f, 4.17446643e-02f,
  1.75640509e-02f, -3.18806246e-02f, -1.35727832e-02f, 1.70110278e-02f, -2.04352532e-02f, 1.48160318e-02f, -7.59759173e-02f, 2.20352765e-02f, -3.72567512e-02f, 5.84818311e-02f,
  5.54885417e-02f, -3.31212655e-02f, 1.20010301e-01f, 6.19535521e-02f, 1.32173728e-02f, 2.16776635e-02f, -1.06789909e-01f, 6.17843531e-02f, -1.22702140e-02f, -7.58996233e-02f,
  6.80573285e-02f, 1.35806184e-02f, 3.19012925e-02f, 5.49259521e-02f, -6.93384930e-02f, -1.91656512e-03f, -1.27371754e-02f, 1.16297506e-01f, -3.07032373e-02f, -2.24519167e-02f,
  -1.71273723e-02f, 1.38998432e-02f, 2.28284057e-02f, 1.26793711e-02f, 1.81766227e-02f, 5.12886159e-02f, -3.28172594e-02f, -5.66595010e-02f, -8.75610486e-03f, 1.50979584e-04f,
  -5.47905155e-02f, -6.60725236e-02f, -9.53246579e-02f, 1.41462870e-02f, 1.81531236e-02f, 1.53053114e-02f, -7.69919828e-02f, -7.62755983e-04f, 2.72459611e-02f, 6.91427384e-03f,
  2.75700889e-03f, -9.44502726e-02f, 3.63022499e-02f, 1.65849552e-02f, 4.98274751e-02f, -5.66787533e-02f, -4.85254116e-02f, 6.20428696e-02f, 3.86117920e-02f, -7.30274096e-02f,
  -3.64291482e-02f, -1.70964792e-01f, -2.89293062e-02f, -1.96166173e-01f, 9.86504368e-03f, 2.02369671e-02f, 8.73632450e-03f, -8.86571035e-02f, -1.07697705e-02f, -8.63615796e-02f,
  6.65796846e-02f, 5.35306819e-02f, 1.50001511e-01f, -2.13095948e-01f, 1.60965964e-01f, -4.83543761e-02f, -1.36564404e-01f, -3.94429564e-02f, 1.02860950e-01f, -6.22591190e-02f,
  -1.27712882e-03f, -1.84790015e-01f, -4.78979684e-02f, -1.25521541e-01f, -2.55844146e-02f, -8.32502246e-02f, 2.52775513e-02f, 6.31658211e-02f, -1.65723741e-01f, 1.21368337e-02f,
  -3.39414962e-02f, 4.34061289e-02f, -9.35152993e-02f, -4.68706265e-02f, 2.82168165e-02f, -7.33950583e-04f, 3.65308183e-03f, 1.21517308e-01f, 2.89424299e-03f, 4.58658524e-02f,
  8.20514038e-02f, 1.84855890e-02f, -1.16755091e-01f, 5.13606444e-02f, 5.54032922e-02f, 2.30689831e-02f, -2.99796015e-02f, 6.85950667e-02f, 7.91356638e-02f, 1.21684214e-02f,
  4.18750197e-02f, -3.98274250e-02f, -4.86820899e-02f, -1.78463291e-02f, 5.78823350e-02f, -2.22893395e-02f, -5.54171465e-02f, -3.99562232e-02f, -1.44993821e-02f, -4.24912460e-02f,
  -2.61741895e-02f, -8.11915193e-03f, 4.12454754e-02f, -2.42649596e-02f, 4.80381250e-02f, 5.94351161e-03f, 2.54608155e-03f, 2.19561160e-02f, -3.73125635e-02f, 5.98536022e-02f,
  2.37371158e-02f, 7.67244771e-02f, -2.46819109e-02f, 1.90706197e-02f, -9.22602937e-02f, 2.27263886e-02f, 4.12135758e-03f, -1.44156325e-03f, -8.57970044e-02f, -5.24177589e-02f,
  -1.78213920e-02f, 7.42283370e-03f, -4.65678349e-02f, 7.93863013e-02f, -5.43067791e-02f, -5.83499596e-02f, -8.44258368e-02f, -1.42807579e-02f, 4.32932116e-02f, 2.83884928e-02f,
  -2.24731509e-02f, -1.43713981e-01f, 5.37061989e-02f, -8.77204072e-03f, 2.47875433e-02f, 1.65701900e-02f, -3.34011689e-02f, -1.05768993e-01f, 2.95042004e-02f, 6.62377151e-03f,
  -5.04953321e-03f, -3.40323970e-02f, 2.84006335e-02f, 6.75194412e-02f, 2.78087724e-02f, 1.40229398e-02f, -2.45502423e-02f, 3.45384814e-02f, -1.12798242e-02f, -7.27180624e-04f,
  -6.95474353e-03f, -5.54533899e-02f, 7.50784203e-02f, -2.47956458e-02f, -7.01616611e-03f, -1.88274868e-02f, 3.41653898e-02f, -1.02727776e-02f, 8.39511864e-03f, -3.19933705e-02f,
  -7.36571476e-02f, -7.25727081e-02f, 1.10425942e-01f, -1.19107306e-01f, 8.56401697e-02f, -8.04166421e-02f, 3.85997333e-02f, -1.50116012e-01f, -1.32214010e-01f, -2.04686090e-01f,
  -1.24953590e-01f, 1.31592125e-01f, 6.63383305e-02f, -2.14509189e-01f, 3.30171227e-01f, 1.86227605e-01f, -1.06469072e-01f, -7.31004104e-02f, -4.43294309e-02f, -1.29780799e-01f,
  -1.77255087e-02f, -2.00425401e-01f, 1.43835336e-01f, -1.56773537e-01f, -1.57928079e-01f, -6.04886897e-02f, 2.77449284e-02f, 1.56611696e-01f, -8.28816071e-02f, 2.00699046e-02f,
  -3.89608298e-03f, -1.50167242e-01f, 1.11804418e-02f, -1.57121159e-02f, -5.30217811e-02f, 7.99809471e-02f, -2.44562533e-02f, 1.14153817e-01f, 5.00252247e-02f, -5.82439229e-02f,
  -3.11636971e-03f, 1.60587560e-02f, -7.66225457e-02f, 1.24994479e-01f, -8.86218548e-02f, -7.92482868e-02f, 4.30944003e-02f, 2.36187372e-02f, 1.77466609e-02f, 1.39774203e-01f,
  -4.29089554e-02f, -5.83691038e-02f, 4.03078236e-02f, 3.46300267e-02f, 5.93886375e-02f, 4.94696491e-04f, 4.94667701e-02f, 4.20270972e-02f, 6.50699362e-02f, -3.34981233e-02f,
  -1.15390547e-01f, 9.36241001e-02f, -3.12296581e-03f, 1.38540911e-02f, -6.20775558e-02f, -1.13919498e-02f, -5.99108525e-02f, 2.63336133e-02f, 1.77123602e-02f, -1.11730047e-01f,
  -2.92671286e-02f, -3.68035920e-02f, -1.63709875e-02f, -2.66439468e-02f, -8.59464705e-03f, -3.31388339e-02f, 8.10262784e-02f, -2.94215232e-02f, 8.27894136e-02f, 8.10727850e-02f,
  -1.88407376e-02f, 1.11216865e-02f, 4.50629853e-02f, -6.11722060e-02f, -1.34214805e-02f, 1.06991731e-01f, 2.90927067e-02f, 2.04817113e-02f, 3.75131331e-02f, -6.17622957e-03f,
  -1.62453026e-01f, -1.78076193e-01f, 2.17133015e-02f, -9.15036500e-02f, 1.80784531e-03f, 3.05444375e-02f, 3.50651257e-02f, -3.91265340e-02f, -8.97455066e-02f, -3.42560075e-02f,
  -4.44359928e-02f, -2.66880877e-02f, 9.62489191e-03f, -6.87560961e-02f, 8.03332999e-02f, 3.78641896e-02f, -2.41637751e-02f, 1.09516596e-03f, 1.75470102e-03f, -4.53790314e-02f,
  -6.68002442e-02f, 1.47505756e-02f, -1.85628794e-02f, -7.85342976e-02f, -9.58253350e-03f, -5.10417186e-02f, -2.49707531e-02f, 4.89363857e-02f, 5.45919989e-04f, 1.62475333e-02f,
  -2.09843200e-02f, 3.04531395e-01f, 4.02145423e-02f, 2.16014549e-01f, -7.97112137e-02f, -1.57841537e-02f, 3.09379548e-02f, -3.72474752e-02f, 1.12473764e-01f, 2.13775784e-01f,
  -1.01992302e-01f, 3.14333081e-01f, -7.84136206e-02f, 1.34439036e-01f, -5.52743077e-02f, -4.83615436e-02f, 2.13860959e-01f, 1.07020617e-01f, -1.37990760e-02f, 7.17376843e-02f,
  -4.36924882e-02f, -1.18838303e-01f, -3.78185026e-02f, -1.72938526e-01f, -1.75849289e-01f, -2.28083357e-02f, -9.95765533e-03f, -1.79397658e-01f, 5.71106933e-02f, -6.51810765e-02f,
  3.81025895e-02f, 5.44003285e-02f, -2.49526445e-02f, 2.76422817e-02f, 1.18849212e-02f, -2.09713224e-02f, -6.95023313e-02f, -7.37235546e-02f, 7.86684081e-02f, -6.56072497e-02f,
  5.66044413e-02f, -6.47998694e-03f, -5.31820431e-02f, -8.63047540e-02f, 3.61941941e-02f, 4.81235720e-02f, -5.21641411e-03f, 2.15239339e-02f, 5.28886309e-03f, 6.84279855e-03f,
  5.18055558e-02f, -6.98845275e-03f, 6.43837303e-02f, 1.16201118e-01f, 1.99431721e-02f, 6.41316548e-02f, 7.89603740e-02f, 6.69222698e-02f, -1.18744345e-02f, 6.97996616e-02f,
  -7.45214373e-02f, -3.42127047e-02f, -3.86911514e-03f, -1.02224864e-01f, -1.12131611e-02f, -2.15194337e-02f, -1.83588490e-02f, 6.40776521e-03f, -2.58693993e-02f, -1.11696916e-02f,
  -5.25196269e-02f, -1.44092329e-02f, -3.29449475e-02f, 1.25942845e-02f, 6.65494353e-02f, 2.38817688e-02f, 4.58985642e-02f, -2.32831836e-02f, -1.22509152e-02f, -3.56116071e-02f,
  4.54115355e-03f, 3.76045480e-02f, -4.04492393e-02f, -4.37477082e-02f, 5.44520579e-02f, -5.99679761e-02f, -6.56254739e-02f, -9.61810350e-03f, 1.32661769e-02f, -2.72530671e-02f,
  9.41708460e-02f, 1.60007030e-01f, 5.85032105e-02f, -8.86641219e-02f, -5.26652560e-02f, -1.25663483e-03f, 6.60186261e-02f, 6.24067932e-02f, -2.53627542e-03f, -5.54133430e-02f,
  -2.43977867e-02f, 2.61781197e-02f, 1.82241816e-02f, -9.56733245e-03f, 3.39493938e-02f, 4.40939814e-02f, 1.04710661e-01f, -3.41170877e-02f, 7.77023360e-02f, 2.48587877e-02f,
  -3.58465426e-02f, -5.54316640e-02f, 9.68989637e-03f, -3.78848016e-02f, 2.12609209e-02f, -2.27803793e-02f, 7.08396435e-02f, 2.61957273e-02f, -2.92546097e-02f, 1.18832082e-01f,
  2.80849151e-02f, 2.33909532e-01f, 1.24838151e-01f, -9.21359807e-02f, 3.13158073e-02f, 2.35911250e-01f, -1.79023929e-02f, 1.10469438e-01f, 1.73361167e-01f, 3.90345156e-02f,
  -1.46432266e-01f, 1.22650370e-01f, 1.73196979e-02f, 1.43684328e-01f, -9.26643535e-02f, -4.98398058e-02f, 5.30161150e-02f, 3.33476216e-02f, 1.30214959e-01f, 1.88378040e-02f,
  -2.51168851e-02f, -5.30015156e-02f, -1.09809786e-01f, 2.87615787e-02f, 7.67924115e-02f, 9.16498750e-02f, -1.96396887e-01f, -9.34949145e-02f, 1.50299538e-02f, -1.54591361e-02f,
  -6.06063791e-02f, 6.66684881e-02f, -2.08379850e-02f, 1.04587436e-01f, 1.98839400e-02f, 4.64012325e-02f, -8.76545161e-02f, -6.81480244e-02f, -4.18519601e-02f, 7.00278729e-02f,
  -7.69975083e-03f, -5.45578357e-03f, 8.63604695e-02f, -2.66246554e-02f, 4.99104038e-02f, -1.94743241e-03f, 5.15104085e-02f, -3.69448401e-02f, 1.88082885e-02f, 1.94106475e-02f,
  4.46792319e-02f, -2.66353674e-02f, -2.86587644e-02f, -5.04265837e-02f, -2.59250421e-02f, 4.18870784e-02f, 3.72176827e-03f, 6.42148703e-02f, 3.40862642e-03f, -1.00972429e-02f,
  -1.77760646e-02f, 7.60834813e-02f, 5.88318445e-02f, -3.20365429e-02f, 8.23865533e-02f, -7.10287243e-02f, 8.26721266e-02f, -6.90962970e-02f, 6.93757236e-02f, -6.92964122e-02f,
  3.71964788e-03f, 5.71895093e-02f, 1.13143325e-02f, 6.63937777e-02f, -5.68878185e-03f, -8.22106656e-03f, -3.63229215e-02f, -5.04634902e-02f, -1.12013854e-02f, 1.48341693e-02f,
  -4.58610579e-02f, 4.16655727e-02f, 1.15089407e-02f, -2.10097078e-02f, 4.71656360e-02f, -4.16209996e-02f, -5.53957559e-03f, 5.86914122e-02f, -1.71053894e-02f, -9.99680310e-02f,
  1.25611313e-02f, 2.00619660e-02f, 1.54665736e-02f, -1.77335907e-02f, -2.82606557e-02f, -3.19103077e-02f, 3.13731916e-02f, 8.04254189e-02f, 6.80006389e-03f, -3.80084030e-02f,
  -1.31027075e-02f, -2.62923259e-02f, 5.01377024e-02f, 1.77191179e-02f, -7.06189591e-03f, 8.70246440e-02f, -6.50678724e-02f, 2.20185202e-02f, -2.70270370e-02f, 3.91853750e-02f,
  -1.34592786e-01f, -7.40115647e-04f, 3.23248357e-02f, 2.05310993e-02f, 8.13280791e-02f, -1.01781450e-01f, -4.33964800e-04f, 3.77893541e-03f, 2.55704913e-02f, 5.66062238e-03f,
  -7.19844401e-02f, -1.81306200e-03f, -8.62588659e-02f, -1.25414841e-02f, 8.40663463e-02f, -3.04112434e-01f, -3.20783645e-01f, 1.23179458e-01f, 1.12006128e-01f, 1.25238180e-01f,
  -7.60172009e-02f, -5.39646558e-02f, 1.59199201e-02f, -1.85965568e-01f, -1.08257376e-01f, -1.42380133e-01f, -1.28758952e-01f, -1.11351848e-01f, 6.86860904e-02f, -6.91917166e-02f,
  -4.23994474e-03f, -5.21241408e-03f, -8.14884156e-02f, 7.86709879e-03f, -5.90402335e-02f, 1.24796100e-01f, 1.55618042e-01f, -1.95875429e-02f, 9.93968695e-02f, -6.87262788e-02f,
  8.29986110e-03f, 5.67805879e-02f, -1.21506490e-02f, -8.01104307e-02f, -4.62699160e-02f, 8.89295619e-03f, -6.25237823e-02f, -4.57179286e-02f, -1.17101492e-02f, 3.61102782e-02f,
  -9.35857296e-02f, -1.45762702e-02f, 6.97373524e-02f, 4.29747440e-02f, 5.34016155e-02f, -4.59333956e-02f, 1.05253063e-01f, -5.15079610e-02f, -2.60192584e-02f, -8.62549171e-02f,
  9.84581746e-03f, -8.85108337e-02f, -4.11453955e-02f, 9.24510881e-02f, -9.74573940e-03f, 2.37074066e-02f, -2.10648552e-02f, -9.30218473e-02f, -1.13778017e-01f, 3.55851930e-03f,
  1.97844859e-02f, 5.74785434e-02f, 2.38388255e-02f, 1.09021636e-02f, -1.94789954e-02f, 8.66232533e-03f, -1.00058150e-02f, -3.38098966e-02f, 1.90249290e-02f, -9.46225151e-02f,
  -2.30867341e-02f, 6.20076619e-03f, -3.71206962e-02f, -9.14734788e-03f, 2.50360556e-02f, -1.01839555e-02f, -1.20621309e-01f, 2.20844280e-02f, -6.50078505e-02f, 5.75767048e-02f,
  3.18380184e-02f, -8.98903236e-02f, -1.01848394e-02f, 5.36324568e-02f, 5.00306953e-03f, -2.76416000e-02f, -5.14178677e-03f, -7.20479351e-04f, 9.68348160e-02f, -5.45877516e-02f,
  -8.01901370e-02f, 2.09734384e-02f, 5.70333190e-02f, 6.33729175e-02f, -9.23271179e-02f, -5.71630942e-03f, -6.13031574e-02f, -1.80626959e-02f, 3.31140906e-02f, 4.06538583e-02f,
  4.54165079e-02f, 4.44705635e-02f, -3.58697809e-02f, 3.97260673e-03f, -2.31849533e-02f, 1.90507360e-02f, -5.68385459e-02f, -1.15834162e-01f, -2.14175936e-02f, -2.21493859e-02f,
  7.66826794e-02f, -3.45215276e-02f, 7.34916776e-02f, 1.62178427e-02f, 5.91563620e-02f, -1.32596232e-02f, 4.17157002e-02f, -6.03639185e-02f, 4.18848321e-02f, 3.80240940e-02f,
  1.23515494e-01f, -3.24598163e-01f, -5.61106987e-02f, -2.27407515e-02f, 8.16163123e-02f, 1.25748664e-01f, 5.54833338e-02f, -3.00555695e-02f, -1.07183456e-01f, -7.47593492e-02f,
  -8.80699698e-03f, -9.88119543e-02f, -8.84511843e-02f, -1.30396977e-01f, 1.73644587e-01f, -3.69189605e-02f, 9.95948464e-02f, -1.45349503e-02f, -6.31163269e-02f, -8.22074413e-02f,
  5.28150499e-02f, 1.25335366e-01f, -6.25353903e-02f, -1.81690156e-01f, -9.26754102e-02f, -9.22480002e-02f, 1.38457760e-01f, -1.04459204e-01f, 6.05592094e-02f, -3.13605107e-02f,
  5.11574857e-02f, -1.41345486e-01f, -5.40796369e-02f, -9.56585482e-02f, -6.28529117e-02f, 2.91403495e-02f, 4.13817167e-02f, 1.74507890e-02f, 1.85679644e-02f, 6.16155379e-03f,
  -1.98632814e-02f, 9.67922434e-02f, 2.77624000e-02f, -1.06490767e-02f, 7.58643970e-02f, -5.06713837e-02f, 4.10003476e-02f, 2.37635057e-02f, -9.72237289e-02f, -6.58150613e-02f,
  7.99338450e-04f, -5.68919722e-03f, 8.14764649e-02f, -4.54653017e-02f, 2.11423058e-02f, -3.10812164e-02f, 3.53036709e-02f, -1.73008908e-02f, 3.82744297e-02f, -1.42638721e-02f,
  -2.65574083e-02f, 2.60974187e-02f, 8.88666734e-02f, -2.73263045e-02f, -3.33568454e-03f, -3.11940145e-02f, -4.38576266e-02f, -3.48466709e-02f, 4.35459688e-02f, -1.72565002e-02f,
  2.35739350e-02f, -2.01373380e-02f, 3.18985358e-02f, 5.84789999e-02f, 7.03856722e-02f, -1.71321072e-02f, -3.67442444e-02f, 3.69231291e-02f, 1.59385037e-02f, -6.69157598e-03f,
  -9.29314494e-02f, 2.09254287e-02f, 6.22157492e-02f, -9.08322539e-03f, -1.03276782e-01f, -3.09136417e-02f, -1.17289403e-03f, 2.42133420e-02f, 4.40359563e-02f, 1.10825025e-01f,
  -3.67233343e-02f, -1.07795909e-01f, -4.27592127e-03f, 6.14766926e-02f, -1.20179541e-01f, -4.50883321e-02f, 1.46121169e-02f, -8.35780278e-02f, -1.10936239e-01f, 1.42596960e-02f,
  6.59602322e-03f, 6.10745177e-02f, -6.95584938e-02f, 4.19238321e-02f, 4.99446020e-02f, 6.59994110e-02f, -5.92698231e-02f, 2.68886555e-02f, 6.48189187e-02f, 5.61721437e-02f,
  -5.86166345e-02f, 6.97880909e-02f, 4.28790487e-02f, 6.81942329e-02f, 3.39488476e-03f, 7.83042759e-02f, -5.16382270e-02f, 7.30848983e-02f, 4.43324121e-03f, -7.50869811e-02f,
  1.52581155e-01f, -2.61734068e-01f, -1.45925984e-01f, -2.01080471e-01f, 1.14297561e-01f, 1.33085877e-01f, 1.14902057e-01f, -1.28561586e-01f, -2.07100525e-01f, -4.39087860e-02f,
  4.80496557e-03f, -6.59561679e-02f, 7.87130073e-02f, -3.49415690e-02f, 1.84125707e-01f, -6.25049695e-02f, 9.69036445e-02f, -1.05980530e-01f, -7.18460009e-02f, 1.27507998e-02f,
  -1.54174522e-01f, -3.29680331e-02f, 7.78545886e-02f, 8.93350467e-02f, -3.07069570e-02f, -1.59408823e-02f, 3.84794809e-02f, -8.21042806e-02f, 6.33038506e-02f, 6.80282861e-02f,
  -1.51221007e-02f, -1.05435491e-01f, 5.04279174e-02f, -4.79917265e-02f, 1.13109097e-01f, 3.79733555e-02f, 1.73959900e-02f, -2.19308701e-03f, 2.85775866e-03f, -4.19258326e-03f,
  2.98773088e-02f, -3.42744105e-02f, -3.46531905e-02f, 1.23343784e-02f, 3.25573515e-03f, -3.94629128e-03f, 4.31140475e-02f, 1.77132692e-02f, -1.36520816e-02f, 2.19203369e-03f,
  1.44229764e-02f, -7.54504427e-02f, 8.84499401e-03f, 7.44150346e-03f, -5.04485108e-02f, 6.02356344e-02f, 1.79040525e-02f, 2.45931037e-02f, 2.44238321e-03f, -2.46021934e-02f,
  -3.88017041e-04f, -3.02761868e-02f, -3.87251168e-03f, -9.89080500e-03f, -2.39182822e-02f, 4.99801598e-02f, -1.72600467e-02f, 8.94337595e-02f, -8.12942535e-02f, 2.95157284e-02f,
  1.81045290e-02f, -2.43080463e-02f, -4.70149517e-03f, 2.23838370e-02f, 3.10332999e-02f, -6.45910949e-02f, -1.27595551e-02f, 1.26436651e-02f, -2.48680804e-02f, 1.19034491e-01f,
  1.40595837e-02f, -4.27812152e-03f, 2.64380407e-02f, 8.21314827e-02f, 5.42967096e-02f, 2.82098986e-02f, -4.34193425e-02f, -8.18194449e-03f, -1.82661451e-02f, 5.38331969e-03f,
  4.84175943e-02f, -7.02412874e-02f, -7.75082335e-02f, 2.34251730e-02f, -4.58574183e-02f, 6.42761812e-02f, -4.86330912e-02f, 6.32054955e-02f, -9.51142386e-02f, 1.03482893e-02f,
  1.31047107e-02f, -1.21740382e-02f, -8.89615738e-04f, -5.12180142e-02f, -2.79390365e-02f, 9.38440263e-02f, 4.89454158e-02f, -5.86417802e-02f, 9.43926442e-03f, 5.47222905e-02f,
  8.35797861e-02f, -9.96968895e-03f, 2.01208284e-03f, 1.10175936e-02f, -1.66184048e-03f, 6.51272088e-02f, 4.31659818e-02f, -1.50160119e-02f, 7.50811249e-02f, 8.70371982e-03f,
  4.14795894e-03f, 1.32346720e-01f, 2.07855809e-03f, 5.95717654e-02f, 1.93855658e-01f, 2.45432518e-02f, 7.62719810e-02f, 9.84718204e-02f, 8.18665102e-02f, -1.56201988e-01f,
  4.75994423e-02f, -4.20223773e-02f, -2.58618027e-01f, -1.08831772e-03f, -2.62158722e-01f, -2.06628308e-01f, 9.06145647e-02f, -3.17673781e-04f, 3.52154970e-02f, 1.40023440e-01f,
  9.40578133e-02f, 1.30550982e-02f, 9.69115198e-02f, 2.66541876e-02f, 1.79292470e-01f, 1.10687785e-01f, -6.82136118e-02f, -4.27562518e-05f, 7.76104927e-02f, -1.17187940e-01f,
  1.11993924e-01f, 3.97616066e-03f, -6.83995429e-03f, 2.80299247e-03f, 1.13812111e-01f, 2.14619722e-04f, 2.20318679e-02f, -1.08526237e-01f, -3.53662707e-02f, -7.59552792e-02f,
  -6.06071241e-02f, -4.14464250e-02f, -2.38128267e-02f, -1.53965345e-02f, 1.45089617e-02f, -1.92492940e-02f, -6.03077374e-03f, 7.76409656e-02f, 4.26309146e-02f, -3.98773095e-03f,
  -2.14893036e-02f, 4.12893668e-02f, 1.13142110e-01f, 3.03934459e-02f, 1.79534443e-02f, 8.06250572e-02f, -4.17718366e-02f, -5.71797267e-02f, 1.35567188e-02f, 5.27699664e-02f,
  -1.05822809e-01f, -1.38050383e-02f, -2.46870741e-02f, -4.41242866e-02f, 2.09532343e-02f, 3.24874036e-02f, -8.30898285e-02f, -3.31600918e-03f, -4.17464972e-02f, 1.01323754e-01f,
  -1.99554246e-02f, 3.85721726e-03f, -6.99254796e-02f, 4.52356227e-02f, 5.33425622e-02f, 7.21751675e-02f, -6.92832842e-03f, -1.00451866e-02f, 6.72658458e-02f, -7.97743127e-02f,
  -1.74499732e-02f, -5.36848195e-02f, -5.31904027e-02f, 4.48481254e-02f, -3.30041051e-02f, -9.29999650e-02f, -3.56635526e-02f, -8.53176117e-02f, 1.89191084e-02f, -1.14767114e-02f,
  1.17108122e-01f, 1.41413882e-01f, 7.10314065e-02f, -2.54155975e-02f, 1.10668503e-01f, 2.46268399e-02f, 3.98588143e-02f, -9.05018672e-03f, 4.01456505e-02f, -5.62822036e-02f,
  7.28664473e-02f, -5.08479141e-02f, 5.56144267e-02f, -5.15452437e-02f, 1.66405234e-02f, -3.15822959e-02f, 5.44023924e-02f, -4.54108417e-02f, -1.49424309e-02f, -1.25827389e-02f,
  9.73945260e-02f, -8.40015784e-02f, 4.64445475e-04f, 8.55526030e-02f, -6.04560934e-02f, -4.86521423e-02f, 9.78262257e-03f, -2.82179303e-02f, -9.75214243e-02f, 3.40323821e-02f,
  9.47650746e-02f, 1.18026547e-01f, -1.86636522e-02f, 4.22884859e-02f, -8.01951289e-02f, 8.43723416e-02f, -1.24410330e-03f, 2.30632517e-02f, -7.23634288e-02f, 7.14089051e-02f,
  3.10055539e-02f, 6.05646111e-02f, -1.38783768e-01f, 2.57230010e-02f, -1.75138056e-01f, -1.78832859e-01f, 6.92606643e-02f, 3.08099277e-02f, 3.11516598e-02f, 1.21370099e-01f,
  3.62287425e-02f, 1.01496167e-01f, 9.53742266e-02f, 6.50475621e-02f, 1.23995960e-01f, 8.83186236e-02f, 1.17356107e-02f, 1.22776404e-01f, 7.06772506e-02f, 4.34958078e-02f,
  -1.05361849e-01f, 6.15890138e-02f, 1.99121814e-02f, -9.59803313e-02f, 6.42119944e-02f, -5.38866548e-03f, -2.09163576e-02f, -3.48290280e-02f, -3.53444107e-02f, 6.94399327e-02f,
  -1.05853319e-01f, -4.89247367e-02f, 7.23074451e-02f, -6.34929314e-02f, 7.67476559e-02f, 3.64627577e-02f, -4.92076762e-02f, 1.12754824e-02f, -3.37290876e-02f, 5.20561598e-02f,
  -4.36824225e-02f, -3.24590914e-02f, 4.43976894e-02f, -6.36589974e-02f, -1.11912079e-01f, -5.83270751e-02f, 3.23542440e-03f, -8.33794922e-02f, -7.79219940e-02f, -2.20628157e-02f,
  4.05808352e-02f, 2.63588093e-02f, 2.73008589e-02f, -3.70149352e-02f, 2.56727096e-02f, 2.88263187e-02f, 6.34426549e-02f, -4.18753475e-02f, -9.11355484e-03f, 2.91858357e-03f,
  -7.14702345e-03f, 6.52293786e-02f, 7.17601404e-02f, -1.27125373e-02f, -4.78333421e-03f, 9.28367749e-02f, 3.73441838e-02f, -3.90936695e-02f, -9.03894380e-03f, -4.36047725e-02f,
  2.79573491e-03f, 3.37422378e-02f, 3.99113819e-02f, -1.84116922e-02f, 4.32460681e-02f, -1.06895298e-01f, 2.46608835e-02f, 5.34846671e-02f, 3.71833928e-02f, 3.54876556e-02f,
  -3.30980420e-02f, 2.97895609e-03f, -5.43750860e-02f, -8.25053826e-02f, -8.79526809e-02f, -3.04266866e-02f, 2.92980336e-02f, -2.88554579e-02f, -7.34091252e-02f, 6.41669556e-02f,
  1.35753714e-02f, -3.69833782e-02f, -3.58402431e-02f, 4.54952419e-02f, 7.07190335e-02f, -5.33812083e-02f, 1.33448601e-01f, 2.44289301e-02f, 1.09039232e-01f, 8.95491093e-02f,
  2.28334647e-02f, 1.04208710e-02f, 5.68599580e-03f, -1.24336138e-01f, 1.98849477e-03f, 2.35424619e-02f, 2.90943757e-02f, 4.83309366e-02f, -5.80398031e-02f, -8.23932812e-02f,
  -2.55663246e-01f, 1.86339244e-01f, -2.70630140e-02f, 5.42909652e-02f, -9.86665636e-02f, 2.52553940e-01f, 2.34300524e-01f, -1.72446311e-01f, -1.17435396e-01f, -4.08159792e-02f,
  -3.92765999e-02f, -4.21160907e-02f, 1.79942012e-01f, 1.23574160e-01f, 1.16450168e-01f, 1.01342633e-01f, 7.60616874e-03f, 1.36930384e-02f, 2.26840682e-04f, -8.05442482e-02f,
  -6.49059638e-02f, 1.82857942e-02f, 2.26504803e-01f, -6.99537843e-02f, -5.83337769e-02f, -1.53116286e-01f, -2.40088217e-02f, -1.05015524e-01f, -5.29879406e-02f, 3.41031440e-02f,
  1.21974526e-02f, -1.21791326e-02f, -7.00341538e-03f, 4.87005152e-02f, 8.99209827e-02f, 4.38538492e-02f, 2.58965176e-02f, 3.89938988e-02f, -5.93061708e-02f, -3.39173991e-03f,
  -4.74331379e-02f, -7.29635954e-02f, 2.95747519e-02f, -5.26342075e-04f, -2.39766221e-02f, -9.52182338e-02f, 6.44224063e-02f, 5.69678396e-02f, 6.54563755e-02f, 2.41764802e-02f,
  -5.41270599e-02f, -5.26025018e-04f, 3.46120074e-02f, 3.65639776e-02f, -2.71693640e-03f, -1.12726623e-02f, 8.75091329e-02f, 4.26637940e-02f, -3.01667731e-02f, -2.02277582e-02f,
  -7.71891549e-02f, 7.44815692e-02f, 3.78812253e-02f, -2.20929869e-02f, -3.02074067e-02f, 3.93185206e-03f, -1.90987177e-02f, -1.17370691e-02f, -2.89337784e-02f, 4.17946465e-02f,
  1.68681052e-02f, -2.25508455e-02f, 9.09602866e-02f, 1.13130987e-01f, -3.59169510e-03f, 3.54288593e-02f, 6.91183135e-02f, 1.63269285e-02f, -2.47112587e-02f, -4.88167927e-02f,
  5.33776172e-02f, 1.82002485e-02f, 7.64262304e-02f, -2.01371089e-02f, 5.60327806e-02f, 6.54450953e-02f, 2.18167733e-02f, -5.46533905e-04f, 2.97401138e-02f, 7.97802769e-03f,
  8.71301889e-02f, 1.80787034e-02f, 2.46951524e-02f, -5.84935993e-02f, -4.66731153e-02f, 6.46176115e-02f, 6.45427704e-02f, 4.75550555e-02f, -3.17304544e-02f, -1.56621318e-02f,
  -7.18005300e-02f, 4.74234633e-02f, -1.85350142e-02f, -5.43018281e-02f, -1.20988227e-01f, 1.89496689e-02f, 4.23166528e-02f, -7.13903978e-02f, -6.87542707e-02f, -5.27169108e-02f,
  -4.61188890e-02f, -3.04265860e-02f, -5.86856082e-02f, -3.87587659e-02f, 2.96490645e-04f, 6.93502203e-02f, -7.56548122e-02f, -8.71689059e-03f, 3.66612896e-03f, 2.33329907e-02f,
  1.41363025e-01f, 1.72864154e-01f, 5.16596697e-02f, -7.06170918e-03f, 6.41655400e-02f, 2.00639054e-01f, 5.54357916e-02f, 1.73687696e-01f, 2.33124599e-01f, 6.85664415e-02f,
  1.76342223e-02f, -1.04016215e-01f, -3.36698368e-02f, -5.69633506e-02f, -1.17346816e-01f, -1.60937980e-01f, 1.24483600e-01f, 2.15871613e-02f, 5.71907088e-02f, 1.66117236e-01f,
  5.89708053e-02f, -2.34104302e-02f, 5.28542465e-03f, 1.48379922e-01f, -4.07071598e-02f, 4.53857891e-02f, -1.90973803e-01f, -1.63776577e-02f, -3.87228429e-02f, -4.92550097e-02f,
  6.54920563e-02f, 8.25746804e-02f, 7.42379874e-02f, -6.67877495e-02f, 6.83991611e-03f, 3.16184796e-02f, -7.54012093e-02f, -1.68259054e-01f, 7.40457326e-02f, 6.31048949e-03f,
  -3.76786590e-02f, -2.22894140e-02f, 1.53788561e-02f, -8.33413191e-03f, -3.42928283e-02f, 6.65838793e-02f, 3.74955423e-02f, 5.04118465e-02f, 5.51950000e-02f, -6.46547135e-03f,
  1.05813919e-02f, -1.17653765e-01f, -3.44212609e-03f, 5.95158711e-02f, 3.65749039e-02f, 3.54848281e-02f, -3.59833799e-02f, -2.70583406e-02f, 5.73115572e-02f, 1.31855741e-01f,
  -1.23196095e-02f, -6.79982826e-02f, -3.16169462e-03f, 2.22968571e-02f, 3.92823527e-03f, -8.71446077e-03f, -6.60835356e-02f, 2.73294188e-02f, -9.12401602e-02f, -9.83118173e-03f,
  8.86764601e-02f, 2.04318762e-02f, 5.18370345e-02f, -7.70276487e-02f, -6.64887354e-02f, 6.31181523e-02f, 2.79168226e-02f, -7.46203260e-03f, 3.90200615e-02f, 1.34642818e-03f,
  3.42765525e-02f, -2.68156524e-04f, -4.60801236e-02f, -7.73277283e-02f, 2.89022047e-02f, -3.03885676e-02f, -2.33925786e-02f, 9.61728022e-02f, -5.24365867e-04f, 1.26364417e-02f,
  3.16107087e-02f, 1.85474768e-01f, 5.61185591e-02f, -1.36565631e-02f, 9.27754864e-03f, -6.29782453e-02f, -7.08376244e-02f, 1.61125772e-02f, 7.80791566e-02f, 3.16801965e-02f,
  3.60058397e-02f, -5.41028567e-02f, 4.67666797e-02f, -1.76244769e-02f, 2.08087154e-02f, 1.02436671e-03f, 1.03519678e-01f, -2.35543083e-02f, 7.02469470e-03f, -8.45571980e-02f,
  -3.03085558e-02f, 3.72722745e-02f, -6.90862089e-02f, -2.91713867e-02f, -2.84058452e-02f, -1.05575053e-02f, 9.68183875e-02f, 4.97075319e-02f, -1.95083860e-02f, -5.10446504e-02f,
  2.09498972e-01f, 8.58728681e-03f, -9.77402404e-02f, 4.19080853e-02f, 1.89437736e-02f, -2.31939584e-01f, -1.86671957e-01f, -2.64110062e-02f, -1.10012963e-01f, -5.51175363e-02f,
  -5.21099418e-02f, -1.18082464e-01f, -1.66457057e-01f, 6.07789727e-03f, -1.69244975e-01f, -1.98994726e-01f, -8.75673518e-02f, -8.98869857e-02f, -1.14541629e-03f, 8.61220621e-03f,
  9.49922428e-02f, 1.13247611e-01f, 3.64708491e-02f, 6.03505559e-02f, 1.15898289e-01f, 4.23650816e-02f, 1.05027156e-02f, 1.28980398e-01f, 9.97029692e-02f, -9.22747627e-02f,
  -1.31182253e-01f, -1.28370775e-02f, -1.22716799e-02f, -2.26886105e-02f, 4.72887605e-02f, 3.82201597e-02f, -2.26248521e-02f, -2.53442507e-02f, -8.15777108e-03f, -1.44098811e-02f,
  -7.62922466e-02f, 2.15066429e-02f, 3.00580095e-02f, 5.72975948e-02f, -2.87046488e-02f, 6.86828941e-02f, -1.86399035e-02f, 1.54718133e-02f, -4.66605239e-02f, 5.88329183e-03f,
  1.17340898e-02f, 5.75736463e-02f, 2.76867207e-02f, -1.22464225e-02f, 1.66440743e-03f, -1.75349554e-03f, -3.29044461e-02f, -1.94232780e-02f, -7.18644485e-02f, 6.01714253e-02f,
  1.85882114e-02f, 4.04548384e-02f, 2.19810139e-02f, -4.75893589e-03f, -6.03302158e-02f, 5.97671606e-02f, 5.32182008e-02f, -4.06481773e-02f, -2.19306815e-02f, -3.65123227e-02f,
  -3.71761783e-03f, 2.95846630e-02f, -5.04536415e-03f, -2.29378082e-02f, -3.80414166e-02f, 5.62158003e-02f, 5.02535179e-02f, 1.32218003e-02f, -6.31012907e-03f, -3.03786830e-03f,
  -5.94554581e-02f, 2.37241089e-02f, -3.14188818e-03f, 5.89548983e-02f, 1.01442169e-02f, 6.08569570e-03f, -5.75464927e-02f, 1.47254555e-03f, -6.72638640e-02f, -8.32782779e-03f,
  -7.18287565e-03f, 8.89102519e-02f, -1.23646259e-02f, 8.21552575e-02f, -6.16243370e-02f, 4.67840172e-02f, 4.48523387e-02f, 4.00835238e-02f, -5.67220524e-02f, 9.97728258e-02f,
  -1.50362439e-02f, 2.57717296e-02f, 5.07335551e-02f, 5.84549550e-03f, 3.79722975e-02f, 8.65696743e-02f, 3.59578542e-02f, 4.90379147e-02f, 2.55205054e-02f, -1.76528189e-02f,
  7.76794553e-02f, 1.30334906e-02f, -7.69580603e-02f, 3.11123971e-02f, 3.66706075e-03f, -4.78565916e-02f, -6.52702302e-02f, -5.67835607e-02f, 7.64491707e-02f, 5.31989634e-02f,
  -2.81291660e-02f, 1.05257295e-01f, -4.67757881e-03f, 2.78485287e-02f, 1.45315677e-02f, 2.87030102e-03f, 1.82712022e-02f, 1.63327500e-01f, -1.93825558e-01f, 7.87795335e-02f,
  3.20681296e-02f, -2.64194254e-02f, -1.33548662e-01f, 1.85000133e-02f, -3.37589025e-01f, -2.68095285e-01f, 6.69130459e-02f, 5.47634903e-03f, -2.10922062e-02f, 7.49406740e-02f,
  -1.09055631e-01f, 7.18092769e-02f, 2.35811044e-02f, 2.15946525e-01f, 1.99220762e-01f, 9.27985162e-02f, 2.18754888e-01f, 3.72257046e-02f, 1.35645494e-01f, 6.44342229e-02f,
  -4.99213254e-03f, -1.18092850e-01f, 7.49419555e-02f, 2.92952918e-02f, 4.95237857e-02f, 4.33487818e-02f, -3.79130989e-02f, -1.05882008e-02f, 3.50985602e-02f, -1.71766465e-03f,
  6.98873624e-02f, -1.80445202e-02f, -1.20070111e-02f, -2.10735835e-02f, -1.96902454e-02f, 5.22593483e-02f, -2.20415592e-02f, 4.30404879e-02f, 1.03931226e-01f, -4.86437380e-02f,
  3.35439388e-03f, -6.19807765e-02f, 1.60017125e-02f, -3.19328830e-02f, 2.01100740e-03f, 4.60898690e-02f, 4.73894514e-02f, 7.75809810e-02f, 3.56011391e-02f, 6.60146326e-02f,
  3.65742110e-02f, 4.85324487e-02f, -6.56716526e-02f, -2.86467839e-03f, -8.41260925e-02f, -4.89281304e-02f, -5.27864322e-02f, -9.03849583e-03f, 7.95255154e-02f, -1.48636522e-02f,
  2.97002327e-02f, 3.57070044e-02f, -2.84107104e-02f, -6.62802234e-02f, 6.18411787e-02f, -4.56206128e-02f, 1.01523980e-01f, -8.65918025e-02f, 9.06406492e-02f, -2.92578526e-02f,
  1.75973121e-02f, -1.88775230e-02f, -1.76011852e-03f, 5.53732403e-02f, -5.85158579e-02f, 9.38923936e-03f, -7.75246695e-02f, -1.04216607e-02f, -5.11202253e-02f, -3.74110118e-02f,
  -5.05696423e-02f, 2.90979352e-02f, 1.29939774e-02f, -4.70777787e-02f, -8.42849165e-03f, -2.10038549e-03f, -2.71470267e-02f, -9.75317135e-03f, 9.04577971e-03f, -2.77071912e-02f,
  -1.15228863e-02f, 7.36541525e-02f, 3.23834755e-02f, -2.96701156e-02f, 8.74740165e-03f, -5.06350510e-02f, -6.54133931e-02f, 3.43735889e-02f, 8.98757726e-02f, 3.64451669e-02f,
  2.64312178e-02f, 2.33682822e-02f, -3.56019735e-02f, 2.79445518e-02f, 5.93717471e-02f, -1.77523680e-02f, -2.62665097e-02f, 3.85052189e-02f, -4.79769148e-03f, -5.07528186e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.74686415e-02f, -2.29121432e-01f, -1.27228558e-01f, 6.05730973e-02f, 8.99716467e-02f, -1.16509706e-01f, -2.09821109e-02f, -3.81705016e-02f, 1.43799677e-01f, -1.77764505e-01f,
  2.97630671e-02f, -7.74582103e-02f, -1.16861105e-01f, -2.85009388e-02f, 9.90370810e-02f, -5.35793789e-02f, -2.19348613e-02f, -2.02383250e-02f, -2.34011430e-02f, -2.27770302e-02f,
  1.02653131e-01f, -1.43211275e-01f, -1.83498472e-01f, -1.32672593e-01f, -9.48904157e-02f, -1.34190023e-01f, 7.86442757e-02f, -1.74961984e-01f, -7.68539170e-03f, -5.12346020e-03f,
  -2.39379182e-02f, -4.59110253e-02f, -3.24619375e-02f, -4.15998064e-02f, 1.40639395e-02f, 1.88583005e-02f, 8.56687576e-02f, -1.61330938e-01f, 3.65427397e-02f, -6.09493032e-02f,
  -3.14015411e-02f, 8.41176212e-02f, 3.66150402e-02f, -6.70725927e-02f, -7.65033662e-02f, 2.94838604e-02f, -3.39382924e-02f, -6.56149089e-02f, -8.30925480e-02f, -4.28079702e-02f,
  -6.48048222e-02f, 5.43279238e-02f, -3.39351408e-02f, -4.56704088e-02f, 1.80544367e-03f, 5.96376993e-02f, -3.77461314e-02f, -9.20763332e-03f, 2.86258813e-02f, -1.77506753e-03f,
  8.65446404e-02f, 1.38587663e-02f, -1.20315112e-01f, -9.36584920e-02f, -7.08054155e-02f, 1.19275548e-01f, -9.22113359e-02f, -3.17016616e-02f, -2.71433964e-02f, -3.54070123e-03f,
  -3.09797395e-02f, -3.27503011e-02f, 7.34750032e-02f, 1.15514314e-02f, -7.65689239e-02f, 1.08621024e-01f, -8.58923979e-03f, -2.62415092e-02f, 2.06120498e-02f, 1.29629299e-01f,
  -2.82417461e-02f, 3.87739809e-03f, -9.66266170e-02f, 4.03973311e-02f, 4.06352308e-04f, -3.49296071e-02f, 2.62023993e-02f, -8.53343159e-02f, 4.30563763e-02f, -9.39564034e-02f,
  -1.50147185e-01f, -1.11212723e-01f, -2.12017968e-02f, -7.84757435e-02f, -1.83552559e-02f, 9.24602896e-02f, -3.10850050e-02f, -3.88108455e-02f, -6.20765090e-02f, -1.33085046e-02f,
  -1.27212014e-02f, -3.41628008e-02f, -5.54590113e-02f, -3.14546898e-02f, -6.41048178e-02f, -1.63506810e-02f, -5.87634416e-03f, -2.03474276e-02f, 9.66571942e-02f, -3.69868316e-02f,
  3.52035016e-02f, -8.27480573e-03f, 7.20887631e-02f, 2.42567230e-02f, 1.00249372e-01f, 1.02411784e-01f, 9.21646804e-02f, 4.30913679e-02f, 8.90676863e-03f, 5.07285856e-02f,
  2.10476622e-01f, 2.63716340e-01f, 2.37406358e-01f, 2.72291064e-01f, -1.24478489e-01f, -1.84184194e-01f, -1.24595508e-01f, -5.52436151e-02f, 3.51690464e-02f, 1.69197060e-02f,
  -7.96007514e-02f, 3.08536440e-01f, 4.32705879e-02f, 1.87419355e-01f, -7.51416534e-02f, -1.01544365e-01f, -2.12728754e-02f, 5.31936847e-02f, -2.43957806e-02f, 1.60771325e-01f,
  -2.28564721e-02f, -1.48820654e-01f, 4.11360525e-02f, 1.16911596e-02f, 1.32407382e-01f, 2.33323649e-01f, -8.15132335e-02f, -9.14210975e-02f, 3.44411023e-02f, -8.49358812e-02f,
  -4.12650108e-02f, -1.76154170e-02f, 6.64047152e-02f, 5.67402691e-02f, -4.68904823e-02f, -5.61746880e-02f, 1.67151354e-02f, -8.35447237e-02f, 2.37930063e-02f, 7.00793639e-02f,
  4.83298823e-02f, -4.61714156e-02f, -1.32966004e-02f, 1.47383381e-02f, -3.53110619e-02f, 1.68391645e-01f, 1.01830356e-01f, 6.27481788e-02f, 1.05173528e-01f, 1.57836944e-01f,
  1.12998769e-01f, 2.07723444e-03f, 2.41654739e-02f, 6.52571097e-02f, -2.15913597e-02f, -3.65580469e-02f, 4.27152216e-02f, -3.19980644e-02f, 9.93087701e-03f, -7.24414270e-03f,
  3.38382050e-02f, 3.15988902e-03f, 5.36103807e-02f, 5.06137684e-02f, 3.67342234e-02f, 1.50028756e-02f, 3.26940082e-02f, -5.95275266e-03f, -2.20788270e-02f, -1.62403267e-02f,
  -5.34847975e-02f, 3.76631715e-03f, -1.04073182e-01f, 8.62338915e-02f, 1.62438396e-02f, 2.78427321e-02f, -4.39460650e-02f, 2.18462050e-02f, -7.59949861e-03f, 1.16329826e-01f,
  -3.66461687e-02f, -6.56993166e-02f, 1.34442255e-01f, 1.43731944e-03f, -4.90785651e-02f, -1.56986099e-02f, 5.17389253e-02f, 6.30260259e-02f, -1.81321371e-02f, -2.61880048e-02f,
  -1.40756965e-01f, 4.98064123e-02f, -2.34051067e-02f, 5.22052608e-02f, -6.20791204e-02f, -1.72721762e-02f, -7.79226795e-02f, 9.06401575e-02f, -2.43129991e-02f, -4.21775393e-02f,
  7.39853084e-03f, -1.25179276e-01f, -6.93897977e-02f, -5.17466776e-02f, -7.26702735e-02f, -3.38313393e-02f, -1.82401370e-02f, 5.43439277e-02f, -2.43114941e-02f, 2.94352639e-02f,
  1.50512815e-01f, -2.17629839e-02f, -1.25954673e-02f, 3.24895326e-03f, 1.84580591e-02f, 6.00623824e-02f, 8.40351451e-03f, 1.13727964e-01f, -2.77538970e-02f, -6.80201426e-02f,
  1.95668638e-01f, 1.45621344e-01f, -1.95924547e-02f, 1.11387692e-01f, -1.10056862e-01f, -1.90186486e-01f, -2.72553191e-02f, 3.60671990e-02f, -6.70805797e-02f, 4.04046737e-02f,
  -5.79566807e-02f, -1.03236236e-01f, 1.53360486e-01f, 1.99929476e-01f, 6.19206876e-02f, -5.04458733e-02f, 1.38403922e-01f, -8.86646882e-02f, -7.39313737e-02f, 2.43256718e-01f,
  6.63476735e-02f, 1.10767961e-01f, 1.24858573e-01f, 2.05397271e-02f, 5.89333810e-02f, 4.49254327e-02f, 1.06910713e-01f, -5.73678827e-03f, -2.51735020e-02f, -8.40601884e-03f,
  7.16099516e-02f, 1.02303192e-01f, 1.80835444e-02f, -3.97388749e-02f, 6.53554574e-02f, 5.04605919e-02f, 2.88794730e-02f, -1.19610518e-01f, 1.33478483e-02f, -8.67914483e-02f,
  -4.52255458e-02f, -7.65395015e-02f, -1.15953432e-02f, -7.95998052e-02f, 5.06308256e-03f, -4.22939807e-02f, 4.98577021e-03f, -1.03196256e-01f, 5.92942769e-03f, 7.31215551e-02f,
  -5.71963973e-02f, -2.84307804e-02f, -5.29017001e-02f, -6.11519404e-02f, 2.00120546e-02f, -2.45101633e-03f, 5.64107709e-02f, 3.51326801e-02f, -1.79102011e-02f, -1.11349203e-01f,
  -1.19137308e-02f, -2.11566333e-02f, 7.59461597e-02f, -8.98544118e-03f, -7.43269175e-02f, 5.48025221e-02f, 3.75828170e-03f, -4.47757840e-02f, -7.79907182e-02f, 2.05955235e-03f,
  2.23919880e-02f, -3.27298008e-02f, -2.42927521e-02f, -4.13584635e-02f, -7.33458530e-03f, -5.10497987e-02f, -1.09982342e-02f, 6.85078576e-02f, -2.47201603e-02f, 2.65817568e-02f,
  -5.73613122e-02f, 3.41271572e-02f, 4.32679802e-03f, 2.29685772e-02f, 6.20279796e-02f, 3.32036312e-03f, -4.60527092e-02f, 3.63084599e-02f, -1.60058308e-02f, 4.88642491e-02f,
  5.59482947e-02f, 3.21080126e-02f, -8.34062323e-02f, -7.59309605e-02f, 3.01978737e-02f, 4.65284055e-03f, 5.59343249e-02f, -3.90990674e-02f, -6.59201518e-02f, 8.96110758e-02f,
  5.38982265e-02f, -3.97041999e-02f, 4.32262532e-02f, 6.00524284e-02f, -6.68695271e-02f, -1.82287116e-02f, 1.25718087e-01f, -6.92114830e-02f, 1.70156285e-02f, -4.74590287e-02f,
  9.77230743e-02f, 2.09368244e-02f, -3.63639258e-02f, -6.52492493e-02f, 4.78881299e-02f, 2.20633224e-02f, -2.51150280e-02f, -1.43037792e-02f, 1.03029579e-01f, -1.02878585e-01f,
  6.17329665e-02f, -3.03895324e-01f, -1.24045722e-01f, 1.88930258e-02f, 1.23939067e-01f, 2.06979476e-02f, 3.18517238e-02f, -6.96279407e-02f, -2.18039528e-01f, -2.63975896e-02f,
  6.97221681e-02f, 2.74136215e-02f, -1.09884277e-01f, 1.77878141e-01f, 2.50653028e-01f, -1.16757005e-01f, 8.61559212e-02f, 1.72988787e-01f, -3.37592475e-02f, -3.43314111e-02f,
  3.12685072e-02f, 2.10010305e-01f, 1.23585403e-01f, 5.48557611e-03f, 1.46466553e-01f, -1.21060327e-01f, 4.19833995e-02f, 6.66257888e-02f, 1.57304943e-01f, 1.79472312e-01f,
  4.17672507e-02f, -4.15222012e-02f, 5.11714816e-02f, 3.65042873e-02f, -1.04341069e-02f, -6.17444031e-02f, 7.13937357e-02f, 7.80372843e-02f, 3.29660960e-02f, 5.04068136e-02f,
  2.96498984e-02f, -4.02490795e-02f, 3.46269645e-02f, -2.80665252e-02f, -7.74649158e-02f, -5.73458988e-03f, -9.66203306e-03f, 2.04728972e-02f, -1.39356721e-02f, 4.78086695e-02f,
  -1.04559734e-01f, 3.68854143e-02f, -7.33578131e-02f, -1.15388138e-02f, -6.84291869e-02f, 2.48466595e-03f, -4.20351662e-02f, 5.54755749e-03f, 4.94635478e-02f, -7.18662962e-02f,
  1.42451273e-02f, 7.15212077e-02f, 5.52723482e-02f, 7.71359205e-02f, -9.19245370e-03f, -2.23642234e-02f, 7.37093017e-02f, 1.57446992e-02f, -8.36090669e-02f, -1.77445430e-02f,
  5.12095168e-02f, -2.70031858e-02f, 9.74371731e-02f, -1.05771758e-02f, -6.78428635e-02f, 7.63321593e-02f, 9.53142121e-02f, -6.26948103e-02f, -2.05330215e-02f, -4.64583449e-02f,
  7.81705976e-02f, -7.03275278e-02f, 5.99726439e-02f, 1.03495747e-01f, 7.77127594e-02f, -2.96993945e-02f, -1.11903632e-02f, 3.35611366e-02f, -1.50961787e-01f, 3.33140418e-02f,
  -9.03460309e-02f, -5.61652854e-02f, -1.02481805e-01f, 1.49002358e-01f, -7.37038767e-03f, -5.26876897e-02f, -5.37872501e-02f, -9.29916161e-04f, 2.40396336e-02f, 2.94145313e-03f,
  5.08481413e-02f, -2.94478005e-03f, 8.09481889e-02f, 1.95990736e-03f, 9.25531089e-02f, -9.26510766e-02f, -5.08351028e-02f, 1.09490536e-01f, 5.42577468e-02f, -1.04807183e-01f,
  6.28434047e-02f, 9.09768511e-03f, -5.97336777e-02f, -7.52836019e-02f, -2.02543393e-04f, 6.02315851e-02f, -3.03238668e-02f, 1.62211787e-02f, 3.81735414e-02f, 1.04316883e-03f,
  3.69752832e-02f, -3.16260576e-01f, 2.05703005e-01f, 1.45162672e-01f, 3.13805372e-01f, 1.42650321e-01f, 2.73257077e-01f, 1.09786335e-02f, 3.79489735e-02f, -1.32484242e-01f,
  4.99534346e-02f, -7.73093775e-02f, -1.08061656e-01f, 2.76316814e-02f, 2.37143695e-01f, -2.59761721e-01f, 6.74608946e-02f, -3.54491509e-02f, 7.72909299e-02f, 1.39674768e-01f,
  8.71113613e-02f, 8.97240266e-02f, -1.60205346e-02f, 6.69205561e-02f, 8.44637156e-02f, -6.42070966e-03f, -2.18890369e-01f, 1.11070340e-02f, 1.02029428e-01f, 6.99680299e-02f,
  2.54217349e-02f, -1.01160608e-01f, -1.89445599e-03f, -9.62955505e-02f, -4.40619737e-02f, -2.71844547e-02f, -1.27121449e-01f, 2.96964422e-02f, 6.20124340e-02f, -3.04111615e-02f,
  -1.89272553e-01f, -2.34730709e-02f, -1.10526942e-02f, -3.26709226e-02f, -5.24100512e-02f, 7.15806261e-02f, 7.55734071e-02f, -1.68490689e-02f, 4.84074578e-02f, 6.54694661e-02f,
  5.16105592e-02f, -8.46527517e-02f, 3.48765068e-02f, 2.19972134e-02f, 1.33539261e-02f, -2.24813726e-02f, -5.82711073e-03f, 5.73963895e-02f, -2.68719234e-02f, 4.52263057e-02f,
  2.90308408e-02f, 1.00373141e-02f, -1.69648062e-02f, -6.65753782e-02f, 4.92308997e-02f, 1.87929533e-02f, -3.22943851e-02f, 4.59315889e-02f, -1.53111778e-02f, 6.16569780e-02f,
  4.85137291e-02f, 3.28229889e-02f, -6.64857030e-02f, 1.77827962e-02f, -2.76389662e-02f, -6.87844679e-02f, -6.80131540e-02f, -6.67661801e-02f, -2.63434909e-02f, -6.69598859e-03f,
  -2.79150419e-02f, 1.56196486e-02f, 7.21211592e-03f, -5.90798557e-02f, -7.83684254e-02f, 2.88759805e-02f, 2.90686190e-02f, -3.87661420e-02f, -1.78060792e-02f, -5.71423136e-02f,
  -3.88395488e-01f, -2.18231499e-01f, 8.18796456e-02f, -2.87884120e-02f, -2.74520889e-02f, -7.87590221e-02f, 1.14647942e-02f, 8.21303204e-02f, 1.86952595e-02f, -1.50563167e-02f,
  -3.53682451e-02f, -4.64990586e-02f, -5.64908572e-02f, 6.48613498e-02f, 3.96647528e-02f, 3.96469748e-03f, -7.36477077e-02f, -2.97246706e-02f, -8.99472833e-02f, -3.31246597e-03f,
  -2.68859137e-02f, -4.54729088e-02f, 3.31441499e-02f, 2.75398549e-02f, 4.92673041e-03f, -3.36101577e-02f, -1.29852071e-01f, 7.92438984e-02f, -7.86917806e-02f, -2.12084614e-02f,
  -4.43045944e-01f, 1.77198589e-01f, -3.80994081e-02f, 3.29110846e-02f, -1.91800401e-01f, 1.56227261e-01f, 1.78260356e-01f, -1.20149031e-02f, -2.83010658e-02f, 2.08926722e-01f,
  2.10574374e-01f, -3.91488373e-02f, 4.97854352e-02f, 2.53641635e-01f, -5.71289286e-02f, 1.84325889e-01f, 7.70004988e-02f, 1.21559620e-01f, -1.13604553e-01f, -2.03739889e-02f,
  -1.11618973e-01f, 6.10405542e-02f, 2.33444627e-02f, -4.82244156e-02f, 5.48032438e-03f, 3.12184673e-02f, 1.03904344e-01f, 1.48825310e-02f, 6.28420860e-02f, 3.37575637e-02f,
  -7.45231658e-02f, -1.48736387e-01f, -6.17216416e-02f, -1.00572474e-01f, -6.62637427e-02f, 2.03271750e-02f, -5.74092902e-02f, -7.87589997e-02f, -6.79346249e-02f, -2.12571546e-02f,
  9.47745517e-02f, -5.76798320e-02f, -5.65607799e-03f, -4.19655852e-02f, -4.61213812e-02f, 6.23601042e-02f, -5.17818928e-02f, -7.16600567e-02f, 1.18076891e-01f, 4.37168516e-02f,
  8.83063003e-02f, 3.70692722e-02f, 1.43131524e-01f, -5.88595122e-02f, 4.78117391e-02f, -1.55092878e-02f, 2.30774153e-02f, -2.55143661e-02f, -6.76673353e-02f, -3.41046834e-03f,
  -3.43018919e-02f, -3.18363644e-02f, 6.58903271e-02f, -4.50587608e-02f, 3.83152440e-02f, 8.92367400e-03f, 7.95912594e-02f, -2.84678023e-02f, 4.34586927e-02f, -9.96510405e-03f,
  -2.35562120e-02f, 1.83569584e-02f, 4.67568915e-03f, 1.42634436e-01f, 3.61005366e-02f, 1.00937612e-01f, -1.06125526e-01f, 7.30389403e-03f, 2.25975271e-02f, 6.96723768e-03f,
  -4.09983844e-02f, 5.89601584e-02f, -5.04852608e-02f, -2.77854595e-02f, 1.95881017e-02f, 5.20617608e-03f, -9.68066379e-02f, 6.61767051e-02f, -8.08704458e-03f, 4.66994895e-03f,
  -1.23862520e-01f, -1.35024935e-01f, -2.85811070e-02f, 2.67291777e-02f, 2.70126555e-02f, -9.30372179e-02f, 3.50208841e-02f, -2.97456291e-02f, -5.44176213e-02f, -4.81795259e-02f,
  4.27078865e-02f, 4.69477735e-02f, -3.63443792e-02f, 6.47399426e-02f, 7.59029165e-02f, 3.84078398e-02f, 3.37506421e-02f, 4.26705144e-02f, -5.10731302e-02f, 4.53758277e-02f,
  -5.71441464e-03f, -7.71974921e-02f, 1.88665744e-02f, 4.50294204e-02f, -3.27077066e-03f, 3.59179527e-02f, -9.73006189e-02f, -1.69139332e-03f, -1.01318717e-01f, 3.68447490e-02f,
  -1.23407945e-01f, 1.76322743e-01f, -1.38402224e-01f, 9.92918611e-02f, -8.37739408e-02f, 3.75384599e-01f, 2.26279289e-01f, 3.62663232e-02f, 1.29744977e-01f, 3.01218450e-01f,
  1.35434538e-01f, 1.11592069e-01f, 1.15589716e-01f, 2.03316718e-01f, 4.72407751e-02f, 2.23702371e-01f, 2.91176319e-01f, 9.88784358e-02f, 6.00510128e-02f, 3.32301855e-02f,
  4.21902463e-02f, 1.52632833e-01f, -9.57121849e-02f, 2.67532710e-02f, -5.53724281e-02f, -2.12924242e-01f, -6.65139928e-02f, -2.12121978e-01f, -8.97019356e-02f, 5.35081550e-02f,
  4.36255485e-02f, -5.89912497e-02f, -4.56862114e-02f, -6.72123060e-02f, -1.23598808e-02f, 1.16734169e-02f, -7.71148726e-02f, 3.58342305e-02f, -1.61584951e-02f, 8.53642970e-02f,
  -2.02630032e-02f, -1.83562431e-02f, 1.61436483e-01f, 1.18149832e-01f, -4.73533850e-03f, -3.76165658e-02f, -7.91432559e-02f, -2.28456575e-02f, 1.83029752e-02f, -1.27809346e-01f,
  5.32158185e-03f, -6.12636916e-02f, -5.98655343e-02f, 7.53833205e-02f, -9.71190557e-02f, 3.37306759e-03f, 1.13303423e-01f, -1.01492129e-01f, -3.20968358e-03f, 3.03198285e-02f,
  7.40294978e-02f, -2.72992142e-02f, 1.67318694e-02f, -9.58698764e-02f, 5.83531074e-02f, -4.02894653e-02f, -1.95280425e-02f, 2.15992723e-02f, -6.80107251e-02f, 3.42656896e-02f,
  4.37649433e-03f, 9.17955302e-03f, -6.58594966e-02f, 9.26817730e-02f, 6.65585231e-03f, 8.86766016e-02f, -2.40138453e-02f, -4.71338294e-02f, -6.78691864e-02f, 5.49311470e-03f,
  6.13849238e-02f, -7.58337528e-02f, 2.72456203e-02f, 7.62093663e-02f, -6.09796261e-03f, 5.24839349e-02f, 3.43013965e-02f, -1.23481818e-01f, -6.87413150e-03f, -5.14577851e-02f,
  1.70381099e-01f, 1.65202633e-01f, -3.21849175e-02f, 5.27744405e-02f, -2.46329629e-03f, 3.40344980e-02f, -5.11921793e-02f, -3.29689011e-02f, 1.11242190e-01f, 1.77621637e-02f,
  3.50606404e-02f, -2.61589158e-02f, 1.11907907e-02f, -6.88524470e-02f, 1.12338334e-01f, 4.64854874e-02f, -1.77999716e-02f, 2.00419221e-02f, 2.49181464e-02f, 1.59035325e-02f,
  -5.54751381e-02f, 8.45574290e-02f, -3.20653170e-02f, 4.15153578e-02f, 2.94190086e-02f, -5.99842693e-04f, 2.10353080e-02f, 7.04097375e-03f, 1.82628240e-02f, 5.09487279e-02f,
  2.88089458e-03f, -1.91481173e-01f, -1.38366923e-01f, 1.57609776e-01f, 1.13447748e-01f, -5.54249063e-02f, -1.60582557e-01f, 6.77227601e-02f, -6.26476929e-02f, -7.42749870e-02f,
  1.80545077e-01f, 1.61363408e-01f, -4.37013917e-02f, 2.46035084e-01f, 3.34188998e-01f, 5.78790791e-02f, 6.59504831e-02f, 6.91375136e-02f, 5.83639108e-02f, -2.12654062e-02f,
  1.44415766e-01f, 2.14683294e-01f, 1.55660629e-01f, 1.79962650e-01f, 5.62041290e-02f, 1.51861668e-01f, 1.47642627e-01f, -6.42698556e-02f, 1.95820987e-01f, 1.59499586e-01f,
  -1.16133140e-02f, -1.92187857e-02f, 2.77295578e-02f, -5.49041219e-02f, 2.11457852e-02f, -1.15020433e-02f, -1.07907861e-01f, 8.26606899e-02f, 5.89407573e-04f, 3.96993682e-02f,
  -1.04850948e-01f, 3.54124196e-02f, -3.47463265e-02f, -5.97267598e-03f, -4.85760607e-02f, 4.18754071e-02f, 7.29642212e-02f, 7.94383045e-03f, 1.98605806e-02f, -5.45012429e-02f,
  -1.15960293e-01f, -2.55709626e-02f, -3.26950438e-02f, 4.32209671e-03f, 2.68482883e-02f, -6.60218671e-02f, 2.30269637e-02f, 5.23582920e-02f, -3.31666209e-02f, 6.18364103e-02f,
  7.53808022e-03f, 1.82709247e-02f, -1.79899689e-02f, 5.52353002e-02f, 8.01107511e-02f, 8.74721482e-02f, 3.58241461e-02f, 3.62049788e-02f, 4.00621332e-02f, 3.39027215e-03f,
  -8.34350567e-03f, 1.14409298e-01f, 2.60212664e-02f, 9.13789496e-02f, 2.61917450e-02f, -4.98522744e-02f, -5.40332720e-02f, 6.73828572e-02f, 1.61642153e-02f, 5.83636053e-02f,
  6.32857978e-02f, 5.79416007e-02f, 5.86987920e-02f, -1.36831611e-01f, 3.24423052e-02f, 1.93464197e-02f, 1.26313895e-01f, 7.25351647e-03f, -1.46050761e-02f, -7.96228573e-02f,
  1.37256430e-02f, 5.83751909e-02f, -5.09468205e-02f, -2.29951050e-02f, 4.69823480e-02f, 5.09307422e-02f, -1.56905521e-02f, -7.51018664e-03f, 6.38557896e-02f, 4.33032438e-02f,
  1.55166378e-02f, 2.91676093e-02f, 1.15094110e-02f, 7.97892287e-02f, 1.16439559e-03f, -9.38035995e-02f, 1.12524093e-03f, 8.16803649e-02f, 6.15141056e-02f, 8.22750777e-02f,
  -4.66028713e-02f, -1.12379175e-02f, -7.12894369e-03f, -3.42409834e-02f, 5.18494211e-02f, -7.79414084e-03f, 2.08125287e-03f, -4.93704379e-02f, -9.01365504e-02f, 1.21623641e-02f,
  1.57526836e-01f, 5.66028841e-02f, -9.83314142e-02f, 8.41859654e-02f, 9.17305723e-02f, 4.94921207e-02f, -7.12956069e-03f, 4.19977754e-02f, -1.18826956e-01f, 1.09195262e-01f,
  1.10850200e-01f, -4.31751385e-02f, -9.70921945e-03f, 7.71895722e-02f, -1.60846245e-02f, -2.06552401e-01f, 2.60391951e-01f, 7.46096745e-02f, -1.36580810e-01f, 2.10259408e-01f,
  -3.37392837e-02f, 2.44179308e-01f, 1.02127865e-02f, 1.36782497e-01f, 4.43289429e-03f, -4.01980132e-02f, 2.17126504e-01f, -5.46090603e-02f, 1.51429668e-01f, -3.89123932e-02f,
  8.94323140e-02f, 9.29983426e-03f, -4.97760586e-02f, -6.60153627e-02f, 5.53237535e-02f, 9.44680572e-02f, -5.51929511e-02f, 4.81311306e-02f, -2.09972207e-02f, 5.72945550e-02f,
  -1.38410125e-02f, -9.82823372e-02f, -6.01493903e-02f, 4.97082174e-02f, 5.43616526e-03f, -1.62064314e-01f, -8.47135931e-02f, -3.76360714e-02f, -7.09788650e-02f, 7.34359631e-03f,
  1.43056996e-02f, 7.70079494e-02f, -6.03034310e-02f, -5.60760833e-02f, 6.52770400e-02f, 2.70960690e-03f, -6.22509196e-02f, -2.11406127e-02f, -5.19224890e-02f, -2.33451985e-02f,
  7.99217522e-02f, 2.94993701e-03f, 6.79312050e-02f, -1.51625816e-02f, -3.66907865e-02f, 1.00733295e-01f, -8.97383988e-02f, 7.73785040e-02f, -5.35124205e-02f, 8.05719867e-02f,
  -1.54136373e-02f, 3.30681317e-02f, -4.75691780e-02f, -1.26948394e-02f, 5.64442202e-02f, 2.09811628e-02f, -2.76832636e-02f, 6.79298863e-02f, 1.07281439e-01f, -4.09821421e-02f,
  -4.40414622e-02f, 8.80683064e-02f, -3.21528502e-02f, -3.34905572e-02f, -1.16753556e-01f, 4.01194580e-02f, 6.60064742e-02f, 4.76648435e-02f, -1.15700409e-01f, -8.15054849e-02f,
  1.39931798e-01f, 9.18353125e-02f, -3.62437069e-02f, 4.65694480e-02f, 3.49229313e-02f, 1.45616785e-01f, -4.45204824e-02f, 7.94397667e-02f, -1.47468932e-02f, -8.73064026e-02f,
  1.36914954e-01f, -6.01149909e-02f, 6.50231391e-02f, 1.16859963e-02f, -1.06740683e-01f, 6.90614805e-02f, 1.87686495e-02f, -8.99309590e-02f, 5.07055521e-02f, -4.18825224e-02f,
  2.13993900e-02f, 4.75556962e-02f, -2.86676604e-02f, -2.44217197e-04f, -5.89826051e-03f, -2.44709980e-02f, -1.06923304e-01f, 4.69121225e-02f, 4.92634736e-02f, -4.11054231e-02f,
  6.91153556e-02f, -3.61826032e-01f, 1.48149449e-02f, 6.89515620e-02f, 1.37824371e-01f, -5.74755818e-02f, -1.29925340e-01f, -5.32582775e-02f, 1.22982971e-01f, -1.26142859e-01f,
  -6.21920116e-02f, 7.22470582e-02f, -2.75014162e-01f, 1.41050130e-01f, 7.00495318e-02f, -7.01825917e-02f, 7.07782358e-02f, 5.01250550e-02f, 3.61743495e-02f, -1.57922983e-01f,
  1.05107233e-01f, 2.60212515e-02f, -4.70399810e-03f, -4.47424082e-03f, 3.73287573e-02f, 1.05011007e-02f, 9.41475928e-02f, -1.63314953e-01f, -8.18517338e-03f, 1.22304931e-01f,
  -4.56749089e-03f, -2.60547623e-02f, -8.77149999e-02f, 1.32991942e-02f, -1.81723773e-01f, -2.79503725e-02f, -8.05591270e-02f, -1.18733011e-02f, -4.55954410e-02f, 2.88325790e-02f,
  4.36885580e-02f, -4.20139544e-02f, 2.04545051e-01f, 7.03279823e-02f, 6.66973069e-02f, -3.62523422e-02f, 5.26975244e-02f, 2.86573637e-02f, 2.43928824e-02f, -4.71010171e-02f,
  -4.62338664e-02f, 6.58049881e-02f, -1.47792918e-04f, -9.14997049e-03f, 2.26843078e-02f, 6.16354346e-02f, 1.62604824e-02f, -1.51839167e-01f, 8.19004104e-02f, -2.49066688e-02f,
  3.42007093e-02f, -1.59124173e-02f, -3.32347304e-02f, 4.53489125e-02f, -5.83502017e-02f, -8.28393828e-03f, 2.70918235e-02f, 4.70974967e-02f, 4.37969081e-02f, -2.22790278e-02f,
  -2.92799938e-02f, -3.66708413e-02f, 5.43660969e-02f, -2.50954516e-02f, 1.19761694e-02f, 8.40133205e-02f, -2.63422076e-02f, 5.72525561e-02f, -6.54868316e-03f, 5.53774573e-02f,
  -2.19903532e-02f, 8.57438222e-02f, -8.66009593e-02f, 2.91323196e-02f, -2.31894590e-02f, -4.93124835e-02f, -6.52543679e-02f, -1.99075639e-02f, 5.77273555e-02f, -3.98548096e-02f,
  -3.87396276e-01f, -2.21787900e-01f, -3.30240652e-02f, 5.61721474e-02f, -6.02406934e-02f, -8.13185573e-02f, 1.00695617e-01f, 1.79624446e-02f, -1.42917961e-01f, -7.19873160e-02f,
  -3.63517329e-02f, 3.80204618e-02f, 1.68371294e-02f, 4.18125875e-02f, 9.55912098e-03f, 8.02288353e-02f, -5.87047217e-03f, 2.06505531e-03f, 3.12057640e-02f, -1.82888899e-02f,
  -7.32578859e-02f, 3.33460569e-02f, 8.64874050e-02f, 6.14522249e-02f, 7.70222098e-02f, -2.83585843e-02f, -4.21223380e-02f, -8.13504606e-02f, -4.47600447e-02f, 5.76837435e-02f,
  1.34969130e-01f, -3.88488173e-02f, 6.86345994e-03f, 1.43570695e-02f, -2.24026456e-01f, 2.61835102e-02f, 1.03809766e-01f, -1.13572881e-01f, 6.58494011e-02f, 8.48995000e-02f,
  -4.94133718e-02f, 1.51030332e-01f, 6.83825538e-02f, 8.87170285e-02f, 8.14670324e-02f, 6.97698146e-02f, -1.19579449e-01f, 1.05918616e-01f, -3.80406417e-02f, 5.81645705e-02f,
  -1.08988993e-01f, 6.07661158e-02f, -4.62541617e-02f, 3.08629265e-03f, -5.94603345e-02f, 3.10962424e-02f, -3.42947096e-02f, 2.55044699e-02f, -1.85630903e-01f, 2.16963477e-02f,
  9.00024623e-02f, 6.58707842e-02f, 8.92791450e-02f, 6.83257207e-02f, -2.65438110e-02f, -1.72808710e-02f, 9.65817571e-02f, 8.44309181e-02f, 1.61291175e-02f, 2.90103611e-02f,
  -1.19959235e-01f, 7.18784407e-02f, -1.58212706e-02f, 1.02521241e-01f, -2.11008061e-02f, -9.73301008e-02f, -1.69007089e-02f, -1.18579194e-01f, 5.01877628e-02f, -6.50458410e-02f,
  -1.67321116e-02f, 6.70043426e-03f, -7.27053313e-03f, 3.37043330e-02f, -5.93484156e-02f, -1.14949327e-02f, 2.27192789e-03f, 6.56251535e-02f, -5.40705808e-02f, -7.05242753e-02f,
  4.21265177e-02f, -1.79349352e-02f, 5.80331385e-02f, 5.49252853e-02f, -1.15748703e-01f, -1.08574703e-01f, 4.74270340e-03f, 1.21426769e-01f, -3.21404785e-02f, -3.42348702e-02f,
  -4.75704074e-02f, -1.61946230e-02f, 1.47341238e-02f, -1.03479721e-01f, -5.16615920e-02f, 5.38097396e-02f, -1.83563679e-03f, -1.10714875e-01f, 4.25571799e-02f, 7.49904215e-02f,
  1.12083972e-01f, -3.22022513e-02f, -2.73983721e-02f, -1.03427023e-01f, 1.45401925e-01f, 2.34825369e-02f, 4.65038903e-02f, 6.37235045e-02f, 5.75788431e-02f, -4.80440445e-02f,
  -1.77502856e-02f, 7.76493326e-02f, 1.02168463e-01f, -3.67258559e-03f, 1.32773072e-01f, 1.02842011e-01f, 1.11628383e-01f, -1.68571863e-02f, -4.45739552e-02f, -6.73307618e-03f,
  -1.59113377e-01f, 2.15129741e-02f, -5.80835044e-02f, 6.19431026e-02f, -2.86813043e-02f, 4.15133312e-02f, -6.73261806e-02f, -5.56877106e-02f, -3.99143472e-02f, -8.39495659e-02f,
  -3.85313965e-02f, 6.78659752e-02f, 6.70993850e-02f, 8.18657577e-02f, -7.27005154e-02f, -2.56192405e-02f, 2.01311987e-02f, 1.14571594e-01f, -2.38249954e-02f, 6.03073612e-02f,
  1.46170065e-01f, -1.10655524e-01f, -1.51323173e-02f, 2.55862206e-01f, -1.41943589e-01f, -2.23455757e-01f, -1.28774583e-01f, 9.25434604e-02f, -1.76040053e-01f, -1.05169922e-01f,
  1.13882743e-01f, 1.28212562e-02f, 5.11607938e-02f, 1.13767028e-01f, 1.45912334e-01f, -3.26345041e-02f, 1.07989714e-01f, 5.22583199e-04f, 2.54381783e-02f, 5.57539724e-02f,
  2.17152447e-01f, 6.31829500e-02f, 1.79049984e-01f, 2.15216994e-01f, 6.75782412e-02f, 2.10925728e-01f, 1.51518956e-01f, 8.11950490e-02f, 1.85122475e-01f, 3.61400321e-02f,
  3.75776403e-02f, 8.04743636e-03f, 4.56937924e-02f, -2.99319886e-02f, -4.48226035e-02f, 6.10469049e-03f, 4.19044308e-02f, -4.01358418e-02f, 6.98640337e-03f, -3.48197743e-02f,
  -2.27389950e-02f, -2.03654775e-03f, -3.18114012e-02f, 1.47171225e-02f, 5.26861995e-02f, -6.56008795e-02f, -1.19068645e-01f, -1.57138593e-02f, -1.29059091e-01f, 8.05379450e-02f,
  -3.24283540e-02f, 1.10250933e-03f, -2.10470259e-02f, 3.82957272e-02f, 4.55607809e-02f, -1.19765615e-02f, -6.43018335e-02f, -2.78145764e-02f, -1.18459441e-01f, 3.10336482e-02f,
  4.41465527e-02f, 1.69606823e-02f, 2.67416295e-02f, 7.95218349e-02f, -3.09640318e-02f, 5.25063761e-02f, -6.57411013e-03f, 2.17464063e-02f, -2.02214886e-02f, -1.36570986e-02f,
  6.67213202e-02f, -2.02617068e-02f, -4.53356728e-02f, -3.01698986e-02f, 4.94577028e-02f, -1.88710988e-02f, -8.30463916e-02f, -6.46900237e-02f, -1.00126676e-01f, -8.75176713e-02f,
  -3.52137610e-02f, 6.98947385e-02f, -8.28726625e-04f, -7.03686732e-04f, 2.51574535e-02f, 1.26245514e-01f, 9.49140936e-02f, 5.32510094e-02f, 8.05216900e-04f, -6.78224564e-02f,
  3.68042360e-03f, 1.11704282e-01f, -5.94136454e-02f, -6.78531379e-02f, -2.89768204e-02f, -1.36565760e-01f, -4.29994613e-02f, 4.91983071e-03f, 1.28147081e-01f, 1.55502018e-02f,
  -3.16283628e-02f, 1.72041021e-02f, 5.15921079e-02f, -4.05023396e-02f, -2.23954185e-03f, 5.50266653e-02f, 2.74072252e-02f, 4.39188629e-02f, 7.70936534e-02f, -4.20779549e-03f,
  9.20034125e-02f, -1.79870695e-01f, 1.61200278e-02f, -1.15100533e-01f, 1.40901022e-02f, 2.06440203e-02f, -9.83971730e-03f, -6.29813522e-02f, 3.14815752e-02f, -3.13325003e-02f,
  -3.63609552e-01f, 2.16039449e-01f, -1.49801642e-01f, -4.96826470e-02f, -4.39811349e-02f, 2.10583374e-01f, 1.82520360e-01f, -4.79464158e-02f, 7.87480082e-03f, 1.03239208e-01f,
  1.24198489e-01f, -1.47478819e-01f, 1.09255157e-01f, 2.04350263e-01f, 1.52982874e-02f, 2.77545512e-01f, 1.46031380e-01f, 6.75108880e-02f, 9.57072154e-03f, 4.27206010e-02f,
  -8.73490050e-02f, 1.98267475e-01f, 1.43923327e-01f, -1.07698543e-02f, 1.97208114e-02f, -9.02299359e-02f, 4.45026606e-02f, -2.86525507e-02f, 9.93546546e-02f, -7.70271644e-02f,
  2.45102700e-02f, -2.11040676e-01f, 7.40459794e-03f, -9.13407207e-02f, -5.87579496e-02f, 4.90708947e-02f, 1.40094515e-02f, -4.39880155e-02f, 8.52780323e-03f, -3.29241790e-02f,
  1.23116709e-02f, -9.79860350e-02f, -2.64917407e-02f, -2.97618993e-02f, -1.08772554e-02f, -4.01241034e-02f, 9.45796911e-03f, 8.64012167e-02f, 6.40561879e-02f, 1.68126356e-02f,
  -5.31810038e-02f, -2.01473781e-03f, 6.94963560e-02f, 6.77194968e-02f, 1.42049631e-02f, 1.35243200e-02f, 1.80559754e-02f, -6.17969781e-02f, 6.30992204e-02f, 1.05246138e-02f,
  -9.86999869e-02f, -1.23679683e-01f, -2.09492799e-02f, -1.70396548e-02f, -3.18855308e-02f, -2.47328393e-02f, -2.57119443e-02f, -1.28184473e-02f, 4.01852578e-02f, -4.09891689e-03f,
  3.24830264e-02f, 7.49200881e-02f, -9.13046524e-02f, -1.74183790e-02f, -2.22181845e-02f, -7.54484013e-02f, 2.42311936e-02f, -2.57513542e-02f, 5.70195355e-02f, 5.07635139e-02f,
  -8.68800059e-02f, -6.56321123e-02f, -4.94074747e-02f, 1.00992419e-01f, -8.15247837e-03f, -4.12365608e-02f, 5.29535823e-02f, -3.00293174e-02f, 6.05703555e-02f, -1.31084546e-02f,
  -9.10928994e-02f, -1.35015145e-01f, 3.74711640e-02f, 6.36787200e-03f, 3.31438072e-02f, -2.73657218e-02f, 3.90022062e-02f, -1.54746845e-02f, -2.94893160e-02f, -6.30573258e-02f,
  3.55494097e-02f, -2.35219710e-02f, -2.05748137e-02f, -1.42431399e-02f, -4.13001888e-02f, 1.28293559e-01f, -2.09010057e-02f, 4.48342264e-02f, 9.43038836e-02f, -1.00644976e-02f,
  8.46856833e-02f, 1.00311795e-02f, -5.37427589e-02f, -3.35680693e-02f, -7.17631169e-03f, 5.68690300e-02f, -6.16023466e-02f, 5.94730601e-02f, -9.14098509e-03f, 8.96719098e-02f,
  -6.38144612e-01f, 1.62406936e-01f, 1.99534431e-01f, -1.76904157e-01f, -9.71919596e-02f, -1.31246727e-02f, 9.74970907e-02f, -1.11855492e-01f, -1.59544304e-01f, 7.12753236e-02f,
  7.09801689e-02f, -1.39737189e-01f, 2.44298100e-01f, 4.43386585e-02f, -1.37336090e-01f, 3.20346765e-02f, -2.95154266e-02f, -2.82416288e-02f, 2.83229612e-02f, -7.57655874e-02f,
  -5.11589013e-02f, -5.98537326e-02f, 6.65728226e-02f, 1.68537185e-01f, -7.88901374e-02f, -9.43948850e-02f, -1.00167781e-01f, 1.24070302e-01f, -2.28295326e-02f, -5.01363128e-02f,
  -3.83614838e-01f, -2.44620889e-01f, -1.79812640e-01f, -7.76887089e-02f, -9.13859829e-02f, -3.87723558e-02f, -1.01701412e-02f, 5.11303432e-02f, 8.61197710e-03f, 4.15859465e-03f,
  -1.95737537e-02f, 3.35262753e-02f, 3.55614461e-02f, 2.22053900e-02f, -2.63526626e-02f, 6.49330951e-03f, 8.91087502e-02f, 3.57903168e-02f, 2.39157025e-02f, 7.96590075e-02f,
  5.39043248e-02f, -5.20936027e-02f, -1.09397866e-01f, 3.60874310e-02f, 1.78411119e-02f, 1.35206962e-02f, -1.49275027e-02f, -5.19884285e-03f, -7.11096451e-02f, -6.29529133e-02f,
  1.37858197e-01f, -1.94997210e-02f, 8.97231549e-02f, -2.23643705e-02f, 6.21824972e-02f, 1.42319724e-02f, 5.61544448e-02f, 5.84909096e-02f, -3.45938839e-02f, 2.04925006e-03f,
  -5.01003042e-02f, -5.89944012e-02f, -1.02804482e-01f, -3.83231118e-02f, 1.32622616e-02f, 9.99865937e-04f, 2.18743328e-02f, -8.25258046e-02f, 4.28856537e-02f, -6.16301075e-02f,
  3.30014899e-02f, -3.69999446e-02f, 5.48500754e-02f, -7.90603980e-02f, -5.44300415e-02f, 2.21702456e-02f, -1.50028896e-02f, 7.01924087e-04f, -7.99120665e-02f, -9.86099895e-03f,
  -4.60420609e-01f, -3.08783412e-01f, -6.81010783e-02f, -1.57190815e-01f, -3.94822285e-02f, -7.24099809e-03f, -4.47092429e-02f, -1.84936579e-02f, -7.46242031e-02f, -5.03671430e-02f,
  -1.05529793e-01f, -9.04131457e-02f, 2.77358145e-02f, 2.37683989e-02f, 3.04147061e-02f, -5.35364151e-02f, 2.35521942e-02f, 2.88065672e-02f, -3.74412648e-02f, -4.81233224e-02f,
  4.53080283e-03f, 5.53597510e-02f, 8.16470087e-02f, -4.23613470e-03f, -6.23019114e-02f, -7.36551061e-02f, -6.85880482e-02f, -2.59186123e-02f, -1.56530202e-03f, 3.92404525e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.01083584e-01f, 4.85436395e-02f, -3.23590040e-02f, 2.79237796e-02f, 1.39374539e-01f, 7.68111423e-02f, 2.59448960e-02f, 1.35037169e-01f, 8.01522955e-02f, 2.71485117e-03f,
  1.11997344e-01f, 1.05647882e-02f, 5.74016683e-02f, 7.69938827e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.00888170e-02f, -3.01689468e-03f, -1.29946426e-01f, -1.45794883e-01f, 6.04505911e-02f, -1.75262347e-01f, 7.58956596e-02f, -7.17947856e-02f, -1.24802709e-01f, 1.26768425e-01f,
  1.30017579e-01f, 4.90294322e-02f, -1.38308689e-01f, -8.90513808e-02f, 1.16728023e-01f, -4.95024659e-02f, -1.30155042e-01f, 4.08219546e-02f, 1.03821434e-01f, -3.55405025e-02f,
  9.62585211e-02f, 7.54485354e-02f, -7.70620108e-02f, -1.25697479e-01f, -1.76440567e-01f, 3.39401551e-02f, -4.03945521e-02f, -9.00346860e-02f, 5.16559631e-02f, -1.62062645e-01f,
  6.63022920e-02f, 1.05526000e-02f, -7.15027452e-02f, 9.27392468e-02f, -9.64080319e-02f, -6.07370548e-02f, -2.36187533e-01f, 1.83266684e-01f, 8.56677517e-02f, -3.48829068e-02f,
  -1.21175103e-01f, 6.52819127e-02f, 1.81560665e-01f, 1.97617356e-02f, 5.50694242e-02f, 1.52699146e-02f, 1.41576147e-02f, 6.17636293e-02f, 4.17489223e-02f, -3.87675278e-02f,
  1.36870131e-01f, -5.17577156e-02f, 3.42608914e-02f, 1.96920961e-01f, 2.33240768e-01f, -1.73583135e-01f, -1.71712577e-01f, 1.62692815e-01f, -1.35833966e-02f, -7.78055713e-02f,
  -1.32872552e-01f, 5.81622906e-02f, -4.50298786e-02f, -1.42622411e-01f, -1.34334534e-01f, 1.67729724e-02f, -7.68207833e-02f, -6.50902390e-02f, -7.99392089e-02f, 7.28006065e-02f,
  3.37668248e-02f, 1.57287404e-01f, -3.11297644e-02f, 1.32076725e-01f, 3.04631852e-02f, -1.01659708e-01f, -1.42402157e-01f, -1.61254212e-01f, 5.49327806e-02f, -8.33964720e-02f,
  -1.43038392e-01f, 2.01514270e-02f, -1.19776562e-01f, -6.83589503e-02f, -1.20675229e-01f, 5.05630560e-02f, -1.44701585e-01f, 2.70800646e-02f, -8.83833393e-02f, -3.17458697e-02f,
  -1.96443573e-01f, -9.28414315e-02f, 2.68176377e-01f, 1.02346927e-01f, 3.22176144e-02f, -4.94086258e-02f, -2.85661742e-02f, -1.43677622e-01f, 1.52498111e-01f, 1.32865813e-02f,
  -2.05274642e-01f, 2.57897258e-01f, 2.18285218e-01f, -8.61413479e-02f, -7.66470730e-02f, -8.49223789e-03f, 1.01845086e-01f, 8.32059458e-02f, -9.97982845e-02f, -1.22197501e-01f,
  -5.25574572e-02f, -5.06298291e-03f, -1.47760302e-01f, -2.12057054e-01f, 8.48531947e-02f, 8.91897306e-02f, 5.91898747e-02f, -5.18063568e-02f, 1.14451582e-02f, -1.10933922e-01f,
  -1.60345808e-02f, -1.03798166e-01f, -1.11244969e-01f, -7.22183660e-02f, 4.05407734e-02f, 1.73025820e-02f, -1.31112665e-01f, 6.21700548e-02f, -1.73935398e-01f, 6.92022368e-02f,
  -3.28350672e-03f, -6.55862093e-02f, -1.12406582e-01f, -6.64039031e-02f, -4.68123183e-02f, -4.55942079e-02f, 1.59262754e-02f, 1.06463872e-01f, -5.20625412e-02f, 5.90418875e-02f,
  -1.09885819e-01f, -4.94010486e-02f, 2.01822519e-01f, 7.55397230e-02f, -1.13033339e-01f, 2.37314701e-02f, 1.98886156e-01f, -1.27689570e-01f, 4.61074226e-02f, 1.04685351e-01f,
  -7.57940635e-02f, 1.03956342e-01f, 6.43592793e-03f, 1.52297750e-01f, -3.60122472e-02f, 3.05682444e-03f, 1.20314769e-01f, -1.45144165e-01f, 9.20910314e-02f, -1.61386654e-01f,
  -3.51173729e-01f, 1.07643723e-01f, 7.15397298e-02f, -2.60936543e-02f, 5.62258326e-02f, -1.30464900e-02f, 1.04821146e-01f, -1.46578429e-02f, -1.70755491e-01f, 1.57897979e-01f,
  -6.82672933e-02f, -1.95678435e-02f, -1.57485619e-01f, -9.82963741e-02f, 1.34291500e-01f, -1.23939946e-01f, 1.01246145e-02f, -1.37859419e-01f, -2.68725125e-04f, -1.72875121e-01f,
  -1.24589384e-01f, 2.88516637e-02f, -4.60476950e-02f, 1.88772812e-01f, -2.24278957e-01f, -3.02590318e-02f, 6.25781417e-02f, 1.08196691e-01f, -1.02552712e-01f, 3.64370793e-02f,
  8.60908777e-02f, 3.07687551e-01f, 3.64849456e-02f, 3.79426777e-02f, -1.28344418e-02f, 5.09183593e-02f, -7.74936303e-02f, -1.41831338e-01f, -1.61987588e-01f, -1.01883911e-01f,
  -1.33526055e-02f, -1.21500328e-01f, -8.81277323e-02f, 6.94380924e-02f, -1.30365165e-02f, -3.62176970e-02f, -1.04593188e-01f, -1.36515662e-01f, 7.17328191e-02f, -1.07673006e-02f,
  -1.12368517e-01f, -3.52229550e-02f, -1.79382004e-02f, -1.42955128e-02f, 8.94141942e-03f, -4.70980816e-02f, 8.99175415e-04f, 1.70427307e-01f, 1.09433234e-01f, -1.08335307e-02f,
  -4.90669794e-02f, -5.94521500e-02f, 3.14659029e-01f, -9.25920531e-02f, -2.01732844e-01f, 5.50255813e-02f, -4.34832387e-02f, 8.60487595e-02f, 1.62954822e-01f, -7.94463977e-02f,
  2.87259165e-02f, -1.70006268e-02f, 7.90088698e-02f, 1.19124651e-01f, -1.27798945e-01f, -9.14799049e-02f, 6.28503859e-02f, 1.16991118e-01f, -2.30609793e-02f, -9.61992592e-02f,
  2.08164975e-01f, 2.04935908e-01f, 1.01028178e-02f, 2.96387017e-01f, 7.25970268e-02f, 1.65604744e-02f, -3.24294239e-01f, -7.76071623e-02f, -2.93493539e-01f, -1.06787510e-01f,
  -3.11358906e-02f, -1.87841520e-01f, 2.94589251e-02f, 9.40618366e-02f, -2.00023428e-01f, 8.24743509e-02f, 1.61505595e-01f, 1.29037881e-02f, -1.51600897e-01f, 1.66902728e-02f,
  -7.27806240e-02f, 4.43135947e-02f, -1.43273249e-01f, 8.55267942e-02f, 9.35370550e-02f, -1.90068677e-01f, -9.46198255e-02f, -1.57820821e-01f, -5.63667938e-02f, -8.90086666e-02f,
  3.26780342e-02f, -1.41802236e-01f, -1.48898691e-01f, -1.53385714e-01f, -1.35844797e-01f, 1.11110032e-01f, -5.90595342e-02f, -2.20522746e-01f, -5.71256429e-02f, 2.05870979e-02f,
  1.80928275e-01f, -3.32486816e-02f, -3.67498286e-02f, 1.72933385e-01f, -1.04147442e-01f, -9.20756757e-02f, -1.66350305e-01f, -1.23713434e-01f, -1.05961271e-01f, 4.37598452e-02f,
  5.61606660e-02f, 5.02018183e-02f, 2.01214597e-01f, -1.78997125e-02f, -1.05642810e-01f, 1.25725940e-01f, 1.76098719e-01f, -9.25792083e-02f, -1.59828663e-01f, -1.40668184e-01f,
  -1.67321190e-01f, 5.19608930e-02f, 1.04327843e-01f, 6.00507893e-02f, 1.41136507e-02f, -9.30571109e-02f, -1.41005486e-01f, -6.35013059e-02f, 1.73735190e-02f, -5.03691882e-02f,
  -1.56061783e-01f, 1.56874117e-02f, 2.14539915e-01f, -1.24860153e-01f, -7.98530970e-03f, -1.98336706e-01f, 2.61771493e-02f, 3.01394034e-02f, 2.26631224e-01f, 1.37681141e-01f,
  9.86279175e-02f, 9.57303643e-02f, 7.87415579e-02f, 7.93849081e-02f, 6.67861551e-02f, -8.83721486e-02f, -1.26391053e-01f, -2.71250792e-02f, 4.72489046e-03f, -7.53295422e-02f,
  -1.04362495e-01f, -3.44521292e-02f, 6.63491264e-02f, 1.03838354e-01f, -1.05315700e-01f, 4.86612804e-02f, 1.62090838e-01f, -6.59681037e-02f, -3.34318168e-02f, 8.00883323e-02f,
  -8.59842524e-02f, -5.02526481e-03f, 1.12573184e-01f, -1.07774541e-01f, 8.89985263e-02f, -8.94571915e-02f, -1.45625010e-01f, -8.85251984e-02f, -1.30917564e-01f, -7.15617016e-02f,
  -1.36390161e-02f, -6.04287349e-02f, -2.51634568e-01f, 1.24050647e-01f, 2.04198033e-01f, -2.28664260e-02f, 2.94080466e-01f, 9.73430928e-03f, -1.31345496e-01f, 7.00347871e-02f,
  1.45217329e-01f, 1.09931618e-01f, -3.56477387e-02f, -2.27166206e-01f, -4.79589999e-02f, 6.26257211e-02f, -6.41211076e-03f, -4.61943410e-02f, 1.10222563e-01f, -2.33836398e-02f,
  -1.14279479e-01f, 1.70324981e-01f, 7.82867428e-03f, -1.99122503e-01f, -9.52562764e-02f, 8.22341219e-02f, 1.77830160e-01f, -1.17109865e-02f, 6.07148781e-02f, -5.44475578e-02f,
  1.42445594e-01f, -6.72278926e-02f, 2.13043869e-01f, 6.70585409e-02f, 5.33022322e-02f, -1.57507285e-01f, -2.48457007e-02f, 8.23675394e-02f, -5.16798086e-02f, -1.59861460e-01f,
  -5.59330033e-03f, -4.83645275e-02f, -1.00366950e-01f, -7.28762671e-02f, -1.22104682e-01f, -4.08383124e-02f, 6.48309737e-02f, -5.32782730e-03f, -1.32079035e-01f, 7.32922461e-03f,
  -4.08345461e-02f, -2.02040337e-02f, -1.65282577e-01f, 3.64164226e-02f, 8.15068781e-02f, -1.57930285e-01f, 4.83538695e-02f, -7.60901943e-02f, -4.76918593e-02f, -1.61149070e-01f,
  4.21326570e-02f, 1.55358359e-01f, -3.03454936e-01f, -9.71095040e-02f, -4.87951487e-02f, 7.12277442e-02f, 1.79068558e-02f, 2.06117794e-01f, -8.38223398e-02f, -3.17939930e-02f,
  4.95034680e-02f, -1.95488155e-01f, -2.48461932e-01f, 1.91872507e-01f, 3.09478026e-02f, 8.94830897e-02f, -4.32934240e-02f, -5.29082827e-02f, -1.55405864e-01f, 1.27468169e-01f,
  1.85346171e-01f, -3.60380951e-03f, -6.97167516e-02f, 4.77828644e-02f, -1.12824246e-01f, -2.98742224e-02f, 1.28985450e-01f, -1.67417042e-02f, -3.11319977e-01f, 1.24229930e-01f,
  2.34665826e-01f, 1.34262636e-01f, 1.93336636e-01f, -1.87736064e-01f, 7.38568753e-02f, 1.40360907e-01f, 1.81408420e-01f, 4.84986156e-02f, -7.74760032e-04f, -1.49216086e-01f,
  -1.78738628e-02f, -1.60861880e-01f, -1.24938317e-01f, -1.26238525e-01f, 8.96124914e-02f, 1.05946749e-01f, -1.09862879e-01f, -9.73550156e-02f, -1.60108685e-01f, -1.34745270e-01f,
  -2.26231754e-01f, 8.38296041e-02f, 3.39654386e-02f, -1.68011799e-01f, -7.81726316e-02f, -1.92817654e-02f, -7.58569688e-02f, -3.76581550e-02f, -5.24962544e-02f, -1.37449846e-01f,
  3.75505760e-02f, -1.18107550e-01f, -3.53758074e-02f, -3.02048445e-01f, 6.89133555e-02f, 2.00577915e-01f, 5.22292368e-02f, -9.49611887e-02f, 4.32052165e-02f, -4.84833270e-02f,
  4.33264971e-02f, 7.59940669e-02f, -2.89336815e-02f, -1.46862403e-01f, 8.24197680e-02f, -1.46011263e-01f, 8.14538449e-02f, 6.47429079e-02f, -1.71536937e-01f, 4.54734229e-02f,
  2.18427218e-02f, -1.03684599e-02f, 2.40869448e-02f, 1.54746979e-01f, 2.21803561e-02f, -1.14542395e-01f, 5.53015508e-02f, -4.60356623e-02f, -3.38940285e-02f, -5.71869090e-02f,
  9.77865010e-02f, 9.81555283e-02f, 1.27983779e-01f, 1.49965227e-01f, -1.65280506e-01f, 2.76479423e-01f, -2.94642542e-02f, -1.09501565e-02f, -1.44360168e-02f, 1.33012459e-01f,
  -9.68777761e-02f, -8.42325836e-02f, -7.33365566e-02f, 2.07867636e-03f, 4.33603786e-02f, -9.70702171e-02f, 7.72112757e-02f, -2.81166658e-02f, -1.91047519e-01f, -2.44400054e-01f,
  -1.11701518e-01f, -1.36389211e-01f, 1.01860225e-01f, -7.78742284e-02f, -9.76716205e-02f, -1.69847142e-02f, -1.10356249e-01f, -1.38279960e-01f, 8.35665613e-02f, -4.17029969e-02f,
  -2.16838066e-02f, 9.77036357e-02f, -1.13898218e-01f, -5.38728908e-02f, 8.15706551e-02f, -2.81490218e-02f, -6.55550882e-02f, 2.57942080e-01f, -3.37260813e-02f, -2.28652418e-01f,
  -1.63174987e-01f, -7.81767666e-02f, 1.00392714e-01f, -5.47567084e-02f, -1.69627413e-01f, -7.37916818e-03f, 1.24763139e-01f, 1.57598838e-01f, 1.17532536e-01f, 7.51592964e-02f,
  -1.21937178e-01f, -2.06291452e-01f, 1.01061659e-02f, 6.12280890e-02f, -2.34199435e-01f, -1.26391485e-01f, 6.75110370e-02f, 1.49172738e-01f, 2.10310388e-02f, -3.05813234e-02f,
  -3.31979431e-02f, 1.55201629e-01f, -1.10606886e-01f, 1.69389710e-01f, -1.20476089e-01f, -2.74637818e-01f, -1.57401368e-01f, -1.47576839e-01f, -1.41215518e-01f, -2.92839766e-01f,
  -4.01808228e-03f, -2.02034488e-01f, -8.10728744e-02f, -1.95534304e-01f, -1.32262439e-01f, -3.21032517e-02f, 5.71150556e-02f, 1.17661215e-01f, 3.76308672e-02f, 1.03379488e-01f,
  -3.47158164e-02f, -4.61544506e-02f, -7.33311847e-02f, 8.50731507e-02f, 8.60756412e-02f, -8.08964595e-02f, -2.09384218e-01f, -9.76666361e-02f, -7.23352209e-02f, -4.79371622e-02f,
  -1.81463525e-01f, -1.51504353e-01f, 8.09596851e-02f, -1.27719656e-01f, -1.45025671e-01f, 1.04442067e-01f, 9.69034880e-02f, -1.29676759e-01f, 2.03447975e-02f, -5.26074283e-02f,
  6.00395678e-03f, -1.04972169e-01f, 9.78938863e-03f, 3.47484387e-02f, 2.52633169e-02f, -2.53761746e-02f, 1.29901469e-01f, 7.60141714e-03f, 2.08444502e-02f, -8.25965628e-02f,
  2.13208660e-01f, 9.42523628e-02f, 1.15292817e-01f, -1.47719443e-01f, -6.97733462e-02f, 1.66559458e-01f, 1.60143122e-01f, -1.32062554e-01f, -7.53145516e-02f, -1.42413408e-01f,
  4.17274050e-02f, 1.25864685e-01f, 2.05752514e-02f, 5.73958457e-02f, -1.11100450e-01f, -1.49329230e-02f, -1.00085557e-01f, 2.24024087e-01f, -3.94161381e-02f, -2.95278262e-02f,
  -1.88249290e-01f, -2.78524011e-02f, 2.19846293e-01f, 3.67818102e-02f, -3.48792933e-02f, -2.18627036e-01f, 2.75671040e-03f, 9.65563394e-03f, -1.14676572e-01f, -2.32588779e-02f,
  -1.57092303e-01f, -7.94185027e-02f, 1.35385701e-02f, -1.65678501e-01f, -5.92154376e-02f, -3.70906256e-02f, 1.78068668e-01f, 9.45979655e-02f, 4.10826951e-02f, 4.00810726e-02f,
  1.90037817e-01f, 3.74697931e-02f, -1.70990467e-01f, -1.78712741e-01f, 1.98547065e-01f, -8.78560636e-03f, -2.35548988e-02f, 1.22130536e-01f, 7.44990408e-02f, 4.73262481e-02f,
  -4.37593274e-02f, 4.64319177e-02f, 1.05564207e-01f, -4.00647558e-02f, 3.85230854e-02f, -2.76506469e-02f, 7.88889080e-03f, 1.28705293e-01f, 1.20814472e-01f, -5.93664423e-02f,
  1.47846770e-02f, -5.18468544e-02f, 9.23226103e-02f, 1.77045912e-01f, -1.61575213e-01f, 1.42583493e-02f, -2.02909544e-01f, 1.23974927e-01f, -7.76307955e-02f, 8.31200406e-02f,
  -2.07025990e-01f, -7.51016289e-03f, 1.92702398e-01f, 1.88965723e-01f, -4.42080870e-02f, -1.01007067e-01f, 4.32671420e-02f, -1.15316473e-01f, 1.02913395e-01f, -6.01868965e-02f,
  4.60203849e-02f, -4.41334173e-02f, -7.26011619e-02f, 2.03759566e-01f, -1.17388240e-03f, -5.36429845e-02f, -1.73340812e-02f, 8.22146237e-02f, 9.18612033e-02f, 7.86296204e-02f,
  -2.83756033e-02f, 1.03284225e-01f, 3.48167457e-02f, -4.06992584e-02f, 9.59200878e-03f, 3.87728661e-02f, 8.73434450e-03f, 1.28560528e-01f, -8.31837300e-03f, -2.02362776e-01f,
  4.61894237e-02f, -1.41908094e-01f, -9.31879878e-02f, -5.72668575e-02f, 6.40072450e-02f, 1.44590393e-01f, 1.01685941e-01f, 1.74958289e-01f, -1.51130334e-01f, -9.81705636e-02f,
  1.67695224e-01f, -2.06604898e-02f, -6.06499240e-02f, -4.99538854e-02f, -5.94237261e-02f, 1.36134535e-01f, 7.35942125e-02f, 9.20512155e-02f, -2.22374704e-02f, 5.15246503e-02f,
  1.78904697e-01f, 1.02054484e-01f, -1.80824269e-02f, 7.14119375e-02f, 1.16548903e-01f, 2.05302328e-01f, 2.17150420e-01f, -8.78882259e-02f, 2.59377789e-02f, 1.45372957e-01f,
  -6.86677247e-02f, -1.26191944e-01f, -1.00854352e-01f, 1.99092090e-01f, 8.91415402e-04f, -1.72814094e-02f, 1.88665897e-01f, -2.79726163e-02f, 1.68806568e-01f, 7.72613585e-02f,
  9.23429653e-02f, 8.07810873e-02f, 1.01605102e-01f, 4.74185012e-02f, -5.39422035e-02f, 1.69402987e-01f, 7.43689388e-02f, -1.28807858e-01f, -8.93102307e-03f, -1.94446355e-01f,
  6.86353371e-02f, 1.81061327e-02f, 3.01668011e-02f, -4.81766015e-02f, -4.33970094e-02f, 1.41277552e-01f, -1.95793644e-01f, -2.91151762e-01f, -5.55435680e-02f, 7.22969621e-02f,
  8.09042454e-02f, -2.70479452e-02f, 1.28815025e-01f, 7.48118907e-02f, -1.10752746e-01f, -1.98886961e-01f, 6.42148033e-03f, -7.44769052e-02f, 7.92844743e-02f, 7.44003197e-03f,
  -4.80999378e-03f, 1.64151877e-01f, -1.11925475e-01f, -8.81787464e-02f, 1.62329748e-02f, 8.86266977e-02f, -4.45544273e-02f, -1.09010637e-01f, -3.13768275e-02f, 1.66295059e-02f,
  -7.86519889e-03f, 1.44853756e-01f, -8.86324048e-02f, -1.60120074e-02f, -5.39013334e-02f, -2.15821266e-01f, 2.15215296e-01f, 2.37619758e-01f, 6.96745813e-02f, 8.08472037e-02f,
  -1.58939674e-01f, -1.22141510e-01f, 1.41143933e-01f, 7.83752874e-02f, 8.69335011e-02f, 1.89849269e-02f, 1.71345577e-01f, 4.86273170e-02f, 2.24024430e-01f, -1.73003357e-02f,
  -1.87842324e-01f, -1.87646195e-01f, 1.13621391e-01f, -6.49677068e-02f, -1.14540376e-01f, -3.07747927e-02f, 2.42525805e-02f, -4.14296724e-02f, 5.73271774e-02f, 1.29887804e-01f,
  -1.79714769e-01f, -2.00628281e-01f, -8.35507661e-02f, -1.68884411e-01f, -1.71541691e-01f, -2.57378638e-01f, -1.69559136e-01f, -1.15812831e-01f, -1.05634846e-01f, -1.52414337e-01f,
  -2.24979445e-01f, -9.86270830e-02f, 1.47769794e-01f, 4.13185209e-02f, 1.20477878e-01f, -1.16567560e-01f, -7.50693157e-02f, 1.70643143e-02f, 1.66020393e-01f, 1.65235937e-01f,
  3.35906516e-04f, 4.72551696e-02f, 8.31930374e-05f, 3.06204930e-02f, 9.40010697e-02f, -1.91578701e-01f, 4.94392775e-02f, 1.34871295e-02f, -5.78922369e-02f, 1.64952502e-01f,
  1.58788413e-01f, -5.14081083e-02f, -3.52655025e-03f, -4.08360884e-02f, 6.19643070e-02f, 9.24337134e-02f, 3.32294367e-02f, 2.47000474e-02f, -1.45898247e-03f, -8.63217190e-02f,
  1.80380404e-01f, 8.38599131e-02f, -3.12780172e-01f, 1.39573261e-01f, 2.15359539e-01f, -1.02881804e-01f, 2.04489809e-02f, -1.02216400e-01f, -1.88709109e-03f, 1.46255165e-01f,
  7.66587555e-02f, -9.99556631e-02f, 3.85488011e-02f, -2.69695997e-01f, 1.90292954e-01f, 2.22301781e-01f, 2.03341413e-02f, -1.06765583e-01f, -3.86768617e-02f, 1.63799286e-01f,
  -2.59524465e-01f, -1.79353714e-01f, 1.30492479e-01f, -3.27763110e-01f, -1.36957780e-01f, 9.97463390e-02f, 2.04470754e-01f, 2.14310974e-01f, 1.47483125e-01f, -1.32645639e-02f,
  3.66614349e-02f, 3.31318617e-01f, 1.31159201e-01f, -9.56751034e-02f, 1.73730791e-01f, -6.94871992e-02f, 1.07773788e-01f, 1.04544379e-01f, 1.51148081e-01f, -1.79337300e-02f,
  -2.28081811e-02f, 6.75226301e-02f, 2.34984756e-02f, 1.69507459e-01f, -1.51361898e-01f, -9.27323997e-02f, -1.15257539e-02f, 1.37018949e-01f, -1.42483003e-02f, 7.61243179e-02f,
  -2.29018226e-01f, -1.00716956e-01f, -1.08322747e-01f, 7.40190670e-02f, -1.17417865e-01f, 8.79544616e-02f, 1.74440697e-01f, 5.78899048e-02f, 5.36894836e-02f, -5.03276363e-02f,
  -2.14664470e-02f, -2.38785535e-01f, 1.05760418e-01f, 1.34653021e-02f, 1.51736692e-01f, 1.14752427e-01f, -1.05151303e-01f, 1.31088123e-01f, 7.06254393e-02f, -1.97553799e-01f,
  2.72557706e-01f, 2.43411690e-01f, -6.13738745e-02f, -1.99900717e-02f, 1.93500638e-01f, -1.77190125e-01f, 2.43502364e-01f, -2.46483132e-01f, -2.02893373e-03f, -1.92063544e-02f,
  1.12473637e-01f, 3.96180935e-02f, 1.10516548e-01f, 5.46317063e-02f, -5.42878881e-02f, 4.65778485e-02f, -1.55101076e-01f, 1.63582578e-01f, -5.67690236e-03f, -1.37988124e-02f,
  2.88757771e-01f, -1.42459916e-02f, 9.12679546e-03f, -2.43033633e-01f, -2.11118013e-01f, -9.14271399e-02f, 6.21115789e-02f, -1.87199503e-01f, -1.60533026e-01f, -1.38967246e-01f,
  -1.39347026e-02f, 6.97285533e-02f, 5.08997925e-02f, 5.82487416e-03f, 2.84301993e-02f, -5.30592501e-02f, -6.23316467e-02f, -4.36459780e-02f, 1.19476855e-01f, -6.54087216e-02f,
  1.11390419e-01f, 1.89136505e-01f, 4.15833257e-02f, 8.60458333e-03f, 6.03733473e-02f, 5.02920747e-02f, -1.99649781e-02f, 1.28297061e-01f, 5.38418368e-02f, -9.57541093e-02f,
  -9.59883034e-02f, 1.61815226e-01f, 1.24625385e-01f, 3.91480476e-02f, -1.06597193e-01f, 9.82280225e-02f, -3.53939831e-02f, 1.07004009e-01f, -1.05373256e-01f, -2.30594322e-01f,
  -6.50662035e-02f, 1.24250650e-01f, 2.02724278e-01f, 1.26185358e-01f, -4.91446629e-02f, 1.07758954e-01f, -1.64465308e-01f, -1.30196451e-03f, -1.14771046e-01f, 1.40934661e-01f,
  1.61392279e-02f, 8.05014521e-02f, 2.18393505e-01f, 1.14767868e-02f, 1.50448173e-01f, 1.57319352e-01f, 5.83957806e-02f, -1.02564357e-01f, 9.07198265e-02f, 1.99142203e-01f,
  1.98155031e-01f, 7.44065344e-02f, 9.77420621e-03f, 2.57092919e-02f, 3.00207790e-02f, -1.25504553e-01f, -5.18657789e-02f, 1.23349153e-01f, 4.81370911e-02f, 3.26966457e-02f,
  -1.61503196e-01f, 2.34893840e-02f, -1.19589962e-01f, -2.87584484e-01f, 6.05859794e-02f, 1.34384379e-01f, 3.85871204e-03f, -5.98719791e-02f, 7.21998140e-02f, 1.44913793e-01f,
  7.98600242e-02f, 6.50468618e-02f, -1.38022602e-02f, 2.68011447e-02f, 4.71066087e-02f, -1.56769201e-01f, 4.19944674e-02f, -1.79606840e-01f, 9.50259790e-02f, 8.47502500e-02f,
  -6.03893921e-02f, 7.74643719e-02f, 7.80364349e-02f, 1.51816994e-01f, 1.15947865e-01f, -3.96821834e-02f, -1.18006498e-01f, 7.33395144e-02f, -5.74757457e-02f, 7.13222986e-03f,
  -1.45606205e-01f, 1.84269585e-02f, 3.81693151e-03f, 1.68447793e-01f, -1.87433377e-01f, 4.77317497e-02f, 1.19931236e-01f, -1.79388858e-02f, 1.79631263e-01f, 1.66143086e-02f,
  -1.00513786e-01f, 6.22323565e-02f, 6.73475564e-02f, 5.19051291e-02f, -9.88335628e-03f, -2.24019989e-01f, -2.05944385e-02f, 4.56939079e-02f, -1.78694829e-01f, -2.58521031e-04f,
  1.31828219e-01f, -2.99808867e-02f, -1.32636920e-01f, -1.71589449e-01f, -5.47013432e-02f, -1.95710763e-01f, -7.04973266e-02f, -4.46016826e-02f, -1.24266528e-01f, 2.16643810e-01f,
  2.27370054e-01f, -8.22302923e-02f, 5.56280874e-02f, -1.99031040e-01f, 2.44056866e-01f, -7.13231340e-02f, 2.30135880e-02f, 9.54120085e-02f, -2.32599713e-02f, -8.38557556e-02f,
  -1.28229275e-01f, -1.13400906e-01f, 1.79723576e-02f, -2.97931507e-02f, 5.21375388e-02f, -6.06192015e-02f, 8.09284523e-02f, -4.40906808e-02f, 1.82790086e-01f, -4.27172706e-02f,
  5.88774681e-02f, -1.72893867e-01f, 6.76475763e-02f, 1.23997577e-01f, 1.33222928e-02f, -3.14237401e-02f, -5.02895303e-02f, 3.05435457e-03f, -5.16191404e-03f, -1.21472463e-01f,
  -9.96306632e-03f, 5.50464727e-02f, 3.89661305e-02f, 1.34478822e-01f, 4.76808250e-02f, -1.27519146e-01f, 1.08420826e-01f, -5.23369685e-02f, -2.25758046e-01f, -1.52802065e-01f,
  -1.48368433e-01f, -1.10581718e-01f, -2.18863897e-02f, 5.96776903e-02f, -1.91013310e-02f, 9.70381871e-02f, -1.40321612e-01f, -4.82403599e-02f, -6.71214797e-03f, -1.08991666e-02f,
  1.41246840e-01f, 2.37530187e-01f, 2.87480913e-02f, 4.50174883e-02f, -2.21430715e-02f, -1.75324064e-02f, -7.55134001e-02f, 5.97309247e-02f, 1.19849406e-01f, -2.78049290e-01f,
  8.53387043e-02f, 1.98350623e-01f, 3.08157891e-01f, 2.27186382e-01f, -7.12180659e-02f, 8.23323354e-02f, -3.18996310e-02f, 1.41084775e-01f, 6.82738796e-02f, -8.16505030e-02f,
  5.91801219e-02f, 5.20274639e-02f, -1.43296823e-01f, 8.40990171e-02f, -5.02923280e-02f, -6.32985979e-02f, -1.22863635e-01f, -1.87762126e-01f, -6.42221095e-03f, -2.63056099e-01f,
  -1.01864345e-01f, -5.77815063e-02f, 4.27268222e-02f, 1.99659526e-01f, 9.81753618e-02f, 1.75372452e-01f, 8.79131481e-02f, -2.40425803e-02f, -1.02462612e-01f, -3.64018939e-02f,
  1.17503963e-01f, 4.55099565e-04f, 2.19808761e-02f, 2.99872253e-02f, 6.54618517e-02f, 1.00202568e-01f, -1.67770699e-01f, 2.00037524e-01f, -1.99905075e-02f, -2.33847216e-01f,
  1.99842863e-02f, 7.12005273e-02f, 9.94113609e-02f, 1.87774390e-01f, -7.92432670e-03f, 1.31564483e-01f, -7.67712248e-03f, -4.62348247e-03f, -2.11690459e-02f, 5.30559793e-02f,
  -1.49857830e-02f, 1.97910160e-01f, 8.57403427e-02f, 1.80297777e-01f, -1.81161046e-01f, -2.46853709e-01f, 7.61517510e-02f, -3.74652706e-02f, -1.18203775e-03f, 2.02959225e-01f,
  -7.04699829e-02f, -9.15799439e-02f, 5.74067645e-02f, 3.09598267e-01f, -1.71157241e-01f, -1.25895992e-01f, -8.82503167e-02f, -1.46043420e-01f, -1.24432057e-01f, -1.24079734e-03f,
  -1.07755803e-01f, 1.01674534e-01f, 1.13302879e-01f, -8.37569386e-02f, -2.02455789e-01f, -1.36576489e-01f, 1.38155267e-01f, 1.17821008e-01f, 2.73586139e-02f, 7.27496520e-02f,
  5.04771899e-03f, -1.88855588e-01f, -2.55429354e-02f, -1.49142042e-01f, 2.48965658e-02f, -1.41693965e-01f, -6.56334087e-02f, 1.40939146e-01f, 9.59901586e-02f, 9.10902917e-02f,
  -1.39915287e-01f, -1.90309584e-02f, 1.05059505e-01f, 3.00471541e-02f, -5.01831658e-02f, -5.11148944e-02f, 2.08066963e-02f, -4.41183709e-02f, 1.67185828e-01f, -6.44397587e-02f,
  -4.09296751e-02f, 1.02243885e-01f, 2.71794140e-01f, -6.54720366e-02f, -1.96711004e-01f, -6.25821482e-03f, -9.41259339e-02f, 2.96260446e-01f, 3.42241138e-01f, -9.92137045e-02f,
  -2.67735362e-01f, 7.77504966e-02f, -8.15942977e-03f, -2.42857575e-01f, -2.13078052e-01f, 4.72910628e-02f, 1.32207870e-01f, -6.04170486e-02f, 1.54374078e-01f, 1.37947693e-01f,
  2.56365776e-01f, 2.18242124e-01f, -2.08988100e-01f, 2.70269990e-01f, 2.33485803e-01f, 2.32091546e-01f, 5.42374589e-02f, 2.22640410e-02f, -3.40727605e-02f, -3.33462916e-02f,
  1.80866450e-01f, -1.63309202e-01f, 9.40924287e-02f, -4.68373485e-02f, 2.50205487e-01f, 3.69198807e-02f, -1.16386279e-01f, 1.93841979e-01f, -2.17609361e-01f, -4.89573598e-01f,
  1.97466873e-02f, 7.29008615e-02f, -7.09312260e-02f, -8.59540105e-02f, -8.82501677e-02f, 1.80313026e-03f, -5.79872616e-02f, 8.65903050e-02f, -4.46148477e-02f, 4.93752249e-02f,
  2.38538324e-03f, -8.57107788e-02f, -6.31181523e-02f, 1.38576239e-01f, 1.37025397e-02f, -9.04642045e-02f, -5.68062020e-03f, -5.02267741e-02f, -6.21651746e-02f, 1.52786151e-01f,
  -6.92651793e-02f, -4.44255434e-02f, -1.87817477e-02f, 1.19213685e-01f, -1.27839744e-01f, 9.30297934e-03f, 2.24028513e-01f, 1.60312150e-02f, -1.22982122e-01f, -1.90677539e-01f,
  1.42855704e-01f, -1.42420819e-02f, -5.08386157e-02f, 1.92646310e-01f, -3.28031093e-01f, -3.40950955e-03f, -5.39999567e-02f, -1.75400302e-01f, -6.41549155e-02f, 7.94368982e-02f,
  -2.60765776e-02f, 2.29639169e-02f, 2.67910678e-02f, 2.38990977e-01f, 1.07676484e-01f, 4.56470959e-02f, -4.90860306e-02f, -8.30914453e-02f, 2.27107540e-01f, 2.04774171e-01f,
  -6.70644715e-02f, -7.97955841e-02f, -1.04899937e-02f, 1.99554116e-01f, 9.30290297e-03f, -2.16974080e-01f, 4.38221842e-02f, 2.36224249e-01f, 2.46686995e-01f, 8.97150487e-02f,
  -1.38574123e-01f, 4.55662794e-02f, 2.14547012e-02f, -3.11756194e-01f, -2.52758950e-01f, 4.02673632e-02f, -1.52709454e-01f, -1.79471314e-01f, -7.94475153e-02f, -1.28464475e-01f,
  8.31855014e-02f, -2.10975602e-01f, 9.85095277e-04f, -2.79967915e-02f, 4.02152538e-02f, 1.10242508e-01f, -1.75145745e-01f, 1.01646416e-01f, -4.57280651e-02f, 9.66492370e-02f,
  1.37754460e-03f, -1.17468379e-01f, 8.19552392e-02f, -2.45734658e-02f, -2.84277219e-02f, 1.50433972e-01f, 1.34467483e-01f, 5.83905466e-02f, -2.11094126e-01f, 8.27330500e-02f,
  1.50256678e-01f, -1.48303062e-01f, 2.45033652e-02f, -2.73197502e-01f, 1.25341594e-01f, -8.53822157e-02f, -7.96144903e-02f, 2.20692620e-01f, -2.49508634e-01f, -4.31317054e-02f,
  -1.66440550e-02f, 1.05428748e-01f, -8.30865800e-02f, -9.67885032e-02f, -4.13557179e-02f, 1.53273135e-01f, 2.19836935e-01f, 9.49706063e-02f, -1.59551725e-02f, -8.60544294e-02f,
  -4.89390641e-02f, 4.32580933e-02f, 1.11583453e-02f, 1.05506226e-01f, 2.93215681e-02f, -1.19644113e-01f, 2.88655832e-02f, 1.86692774e-01f, 7.82577042e-03f, -1.48565918e-01f,
  2.91571189e-02f, 5.52258678e-02f, 1.94964498e-01f, 2.64811469e-03f, 1.94185674e-02f, 1.89847633e-01f, 1.79267377e-02f, -9.86975208e-02f, -1.51729494e-01f, -9.67755448e-03f,
  -7.10813850e-02f, 5.08377887e-02f, -5.79281375e-02f, -2.08090227e-02f, -3.12935896e-02f, -2.47567445e-02f, -7.06370547e-02f, -7.51781687e-02f, -6.10684650e-03f, 7.08485628e-03f,
  -1.01540819e-01f, -1.33813232e-01f, -2.97966902e-03f, 3.08266282e-02f, -1.17486879e-01f, -1.07225962e-01f, 9.79187414e-02f, -1.27818152e-01f, -4.66342792e-02f, 1.09384671e-01f,
  -6.05866499e-02f, -6.06150962e-02f, -1.60531402e-01f, 1.64652511e-01f, -9.05242339e-02f, -1.24842860e-01f, 1.15486056e-01f, 9.91266593e-02f, -3.45484838e-02f, -8.58040005e-02f,
  -1.80085357e-02f, -7.60771409e-02f, -1.08164154e-01f, 1.55951947e-01f, -2.71834254e-01f, 1.49535224e-01f, 2.05452591e-01f, -2.15437919e-01f, 2.37669121e-03f, -3.21028531e-02f,
  1.29060924e-01f, 9.26272571e-02f, 6.04735725e-02f, -3.37819904e-02f, -1.74888894e-01f, 4.08131219e-02f, -7.99904093e-02f, 4.01719660e-02f, 6.75430074e-02f, -5.93504161e-02f,
  -5.78723326e-02f, -9.88484081e-03f, 2.51336753e-01f, -2.20167831e-01f, -7.45338351e-02f, 1.21211760e-01f, -1.05228908e-01f, 1.79955319e-01f, -1.21318102e-02f, -1.04778543e-01f,
  -1.49909958e-01f, 2.78661661e-02f, 7.86290988e-02f, -8.91929343e-02f, -1.71451986e-01f, -9.07123163e-02f, 4.73427586e-03f, -1.84177980e-01f, 7.93630481e-02f, -1.72318798e-02f,
  6.30566152e-03f, -6.46224171e-02f, -1.89470634e-01f, -1.47903055e-01f, 3.06995455e-02f, 3.97660173e-02f, -4.33076918e-02f, -6.84170276e-02f, -6.08226769e-02f, -1.59372613e-02f,
  2.01605614e-02f, 9.26942304e-02f, -9.37375650e-02f, -1.31515861e-01f, -1.19344480e-01f, -2.05767661e-01f, -5.48695810e-02f, -2.69087046e-01f, 1.63470075e-01f, 2.85782665e-01f,
  -1.94548607e-01f, -8.55366811e-02f, -9.42815617e-02f, 2.47447919e-02f, 1.61884069e-01f, -1.19859010e-01f, -1.74361199e-01f, -2.56778989e-02f, 2.16795906e-01f, -1.92634478e-01f,
  -1.03267916e-02f, -1.46831002e-03f, -1.24089077e-01f, 6.90543354e-02f, 8.94933715e-02f, -1.45780476e-04f, 3.07231601e-02f, -3.21741798e-03f, 1.45181492e-01f, -1.37264356e-01f,
  -5.19022644e-02f, 1.22795820e-01f, -3.16719785e-02f, -2.20499057e-02f, 2.33239576e-01f, 1.26569957e-01f, 3.11403954e-03f, 6.79522678e-02f, 2.36878499e-01f, 1.93817377e-01f,
  8.58155712e-02f, -3.84830534e-02f, 1.42733483e-02f, 2.81635672e-01f, 5.77869266e-02f, -9.14992690e-02f, 4.56433706e-02f, -2.23333784e-03f, 1.97768882e-01f, 1.03777712e-02f,
  5.12858592e-02f, -4.96585434e-03f, -9.86588746e-02f, 6.70244321e-02f, -1.43765867e-01f, -7.78263286e-02f, -7.06617981e-02f, -7.46783540e-02f, 1.56564321e-02f, 5.30803166e-02f,
  -1.79862063e-02f, 9.00635198e-02f, -7.66417682e-02f, 1.42220303e-01f, 2.62840595e-02f, -1.06319085e-01f, 1.31677672e-01f, 1.27936661e-01f, -1.29384622e-01f, 4.49452661e-02f,
  -6.02854602e-02f, 1.50078908e-01f, -1.26781240e-01f, -2.67485008e-02f, 2.16855556e-01f, 2.61977702e-01f, 4.50974852e-02f, 1.77199408e-01f, -2.82709356e-02f, -1.05382018e-01f,
  1.00175530e-01f, 1.91202983e-01f, -1.52832031e-01f, 1.42580926e-01f, -3.36758420e-02f, 5.35202473e-02f, 1.89110711e-01f, -1.64647043e-01f, -7.30942264e-02f, 6.60859868e-02f,
  7.90195093e-02f, -2.81078890e-02f, -6.29971623e-02f, 1.88011095e-01f, -3.38741615e-02f, -1.30231585e-02f, 5.84015958e-02f, 3.50634381e-02f, -1.20584235e-01f, -1.43064409e-01f,
  -9.83009711e-02f, -1.50271803e-01f, 7.75158033e-02f, -9.98089015e-02f, -1.44267708e-01f, -1.37555983e-03f, 1.38727680e-01f, -1.18616343e-01f, -2.13115364e-01f, 5.64310420e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.65320468e-02f, 1.08353920e-01f, 2.27918066e-02f, -3.44193988e-02f, 1.40155882e-01f, 8.39526057e-02f, 6.19896352e-02f, -1.45904675e-01f, -3.48131284e-02f, -2.54925527e-02f,
  1.32073596e-01f, -4.72555170e-03f, 5.05989790e-02f, 1.09127656e-01f, -3.80588956e-02f, 1.86239369e-02f, 1.68113261e-01f, 3.31929140e-02f, 9.83225405e-02f, 1.87737107e-01f,
  1.57481343e-01f, 7.84512013e-02f, 9.90138054e-02f, 1.10717170e-01f, 5.97531833e-02f, 2.86364764e-01f, -6.12203740e-02f, -1.42839715e-01f, -2.49020115e-01f, -3.19057032e-02f,
  1.96771413e-01f, -3.50195438e-01f, -4.55133140e-01f, 9.39635783e-02f, 1.48818433e-01f, 7.88026601e-02f, 1.57707527e-01f, -6.84884340e-02f, 5.75117134e-02f, -1.90462902e-01f,
  2.65360624e-01f, 1.55504718e-01f, -2.27265254e-01f, -1.06583960e-01f, 1.50148526e-01f, 3.81966457e-02f, -6.07001930e-02f, -1.06355347e-01f, 1.43135428e-01f, 2.11454615e-01f,
  -1.41030356e-01f, 5.21197543e-02f, -1.50391698e-01f, -1.39941975e-01f, -1.56551450e-01f, 4.45714705e-02f, -1.49368986e-01f, -3.03460270e-01f, -9.03404728e-02f, -1.85360000e-01f,
  1.09193772e-02f, -2.65470594e-01f, 6.81646764e-02f, 3.94319892e-01f, 1.58371404e-02f, 1.79601163e-01f, 1.03669442e-01f, 7.95173571e-02f, 4.66046706e-02f, 2.97389608e-02f,
  -1.75185949e-02f, 1.65062264e-01f, 7.82842785e-02f, 5.08721173e-02f, -3.69192474e-02f, 8.66853669e-02f, -4.41905390e-03f, 1.31787449e-01f, 2.38117892e-02f, 1.02855675e-01f,
  6.43958375e-02f, 1.97329760e-01f, 1.91038083e-02f, 4.53898422e-02f, 2.33584121e-02f, 3.21639813e-02f, 8.85398239e-02f, 2.54494101e-02f, 1.11971378e-01f, -1.68355212e-01f,
  -5.91909327e-02f, 1.45296246e-01f, -7.45417550e-02f, -5.79924174e-02f, 1.37035660e-02f, 2.32037634e-01f, 2.84720808e-01f, 6.42355159e-02f, -4.77186330e-02f, 1.31761387e-01f,
  1.22638322e-01f, -1.93152606e-01f, -1.31928874e-02f, 1.95951492e-01f, 1.15407698e-01f, -1.75773621e-01f, -1.11463815e-02f, -8.09997469e-02f, 1.10919997e-01f, 1.15807116e-01f,
  4.36590426e-02f, 2.07099095e-01f, 4.45688404e-02f, 1.29831374e-01f, 6.44303039e-02f, 7.94604495e-02f, 1.88745603e-01f, -1.69977710e-01f, -9.33335498e-02f, 4.71949391e-02f,
  2.96187222e-01f, 5.17704785e-02f, -1.99054200e-02f, -1.44600302e-01f, 9.59671438e-02f, 1.41192704e-01f, 1.56228170e-01f, -1.33831620e-01f, 7.06397742e-02f, -1.32742031e-02f,
  2.50260383e-01f, 1.84427157e-01f, 8.01917836e-02f, 9.74689573e-02f, 1.54520884e-01f, 1.95420414e-01f, 1.10365078e-01f, 1.35287300e-01f, 1.00159600e-01f, 1.12630306e-02f,
  7.95280114e-02f, 4.63820845e-02f, -6.36992753e-02f, 1.87267125e-01f, 9.40279812e-02f, -1.78537723e-02f, -6.07014149e-02f, 5.42001314e-02f, 8.50561336e-02f, -8.52777213e-02f,
  1.44774452e-01f, -1.60996802e-02f, 2.44761929e-01f, -1.82862014e-01f, -7.45359212e-02f, 6.52749613e-02f, 1.74138859e-01f, 2.78096080e-01f, -2.30509177e-01f, -3.87234129e-02f,
  -1.47772461e-01f, -2.01113179e-01f, 1.26136541e-01f, -1.39242902e-01f, 8.45518112e-02f, 1.50347069e-01f, -1.09478168e-01f, 1.10100701e-01f, 2.17526510e-01f, -1.15444817e-01f,
  -6.24959357e-02f, -8.65111202e-02f, 4.08079214e-02f, -5.29315174e-02f, 2.30734304e-01f, 8.02334249e-02f, -1.65813014e-01f, -1.50109068e-01f, -1.83506648e-03f, -1.60318837e-01f,
  7.85522684e-02f, 7.15287998e-02f, -1.14923194e-02f, 1.39563918e-01f, 2.64801204e-01f, -5.97400293e-02f, -1.02782473e-01f, -8.28605890e-02f, 3.22103314e-02f, -1.88337520e-01f,
  2.21990660e-01f, 2.49836564e-01f, 1.10635251e-01f, 2.86937319e-02f, 1.35849208e-01f, 2.35832229e-01f, 1.25394098e-03f, 6.66090474e-02f, 4.45425510e-02f, -1.31300449e-01f,
  -1.15100769e-02f, -4.95690629e-02f, 9.86696929e-02f, 2.04724580e-01f, 2.94132158e-02f, 6.63468018e-02f, 7.12802112e-02f, 1.31617695e-01f, 6.44147536e-03f, 6.29080879e-03f,
  6.66733235e-02f, 1.10478923e-01f, 1.65585905e-01f, 1.92473054e-01f, 2.63585478e-01f, 1.07760385e-01f, 1.18577689e-01f, 1.31748796e-01f, 2.16760579e-02f, 5.11370450e-02f,
  -1.29294246e-01f, 5.83804585e-02f, 1.23284310e-01f, 7.80786201e-02f, -2.66298428e-02f, 2.02948228e-02f, -5.80816716e-02f, 1.93111092e-01f, 9.02993232e-03f, -1.00934342e-01f,
  -4.24237400e-02f, 7.48490170e-02f, 8.54820460e-02f, -4.39194916e-03f, 1.30121529e-01f, 1.02818578e-01f, 1.68232948e-01f, 9.40348879e-02f, -9.02314335e-02f, 1.01216763e-01f,
  1.85412094e-01f, 2.08333999e-01f, 1.63760051e-01f, 1.56829655e-01f, -1.13586634e-01f, 7.56374821e-02f, 8.14056664e-04f, -2.03308854e-02f, -2.01589298e-02f, 1.30916417e-01f,
  2.65080154e-01f, 4.13679890e-02f, -3.22166085e-02f, 1.86380278e-02f, -1.90903857e-01f, -1.69721842e-01f, -1.07224345e-01f, 1.29915327e-01f, 1.11240685e-01f, 1.91317853e-02f,
  1.14667498e-01f, 2.03102063e-02f, -1.80831868e-02f, 1.74563695e-02f, 1.82078615e-01f, 5.33844456e-02f, 1.93591952e-01f, 3.91559862e-03f, 1.35774881e-01f, 2.48029958e-02f,
  1.70135915e-01f, 6.22915216e-02f, -4.51359190e-02f, 3.98650393e-02f, 2.53679991e-01f, 6.04616031e-02f, -7.03089908e-02f, 5.05176596e-02f, -3.83767672e-02f, 6.65433630e-02f,
  -1.22851089e-01f, 6.63403496e-02f, 6.49225116e-02f, -2.35231683e-01f, 1.46268159e-01f, -4.24501598e-02f, 1.27741739e-01f, -1.63568228e-01f, -9.64977741e-02f, 2.40642041e-01f,
  -1.83241561e-01f, -1.21171743e-01f, -1.99707031e-01f, 1.64363071e-01f, -1.00066170e-01f, -6.23929426e-02f, -2.09849119e-01f, 1.87438592e-01f, 1.03146374e-01f, 4.50453684e-02f,
  1.45005792e-01f, -8.73408616e-02f, -1.40873909e-01f, 9.78946760e-02f, 1.18129902e-01f, 4.67326120e-02f, 2.37602815e-01f, -3.01286075e-02f, -3.94024849e-02f, -2.87902206e-02f,
  2.89288666e-02f, -1.10483572e-01f, -2.51501203e-01f, 7.85174593e-02f, 7.93099329e-02f, 2.54169196e-01f, -1.44451167e-02f, 6.89858422e-02f, -1.70542151e-01f, 6.39684722e-02f,
  1.57006547e-01f, -3.04994844e-02f, 1.38586340e-03f, 9.09670889e-02f, 6.16347184e-04f, 1.39431313e-01f, -1.26160026e-01f, 1.39379772e-04f, 1.30651519e-01f, 1.60540819e-01f,
  1.00196451e-01f, -5.48027977e-02f, -5.46535850e-02f, -1.31007150e-01f, 1.63199067e-01f, 1.04823850e-01f, -1.07210875e-01f, 9.10874736e-03f, 1.85924023e-01f, 1.43900275e-01f,
  9.00433362e-02f, 1.31471381e-01f, -3.99697665e-03f, 9.49998647e-02f, 8.18310082e-02f, -7.88803492e-03f, 4.61382270e-02f, -1.88741565e-01f, -1.46444485e-01f, -1.73780665e-01f,
  -1.33273780e-01f, -2.65376449e-01f, -3.30368161e-01f, 2.03240260e-01f, -2.38748416e-02f, -1.84306756e-01f, 4.04379994e-01f, 1.65170117e-03f, -2.32186377e-01f, 3.37746814e-02f,
  3.49119641e-02f, 2.57218748e-01f, -8.10635909e-02f, -2.19824821e-01f, -8.86677802e-02f, -4.45759185e-02f, -1.54577494e-01f, -4.98516336e-02f, -9.09311101e-02f, -1.29486635e-01f,
  1.78020701e-01f, -1.92491096e-02f, 1.81568637e-01f, 1.07045230e-02f, 1.13617154e-02f, 2.95434237e-01f, 7.32315704e-02f, -1.32780685e-03f, 1.01585314e-01f, 2.06324264e-01f,
  4.24720719e-02f, -4.22796346e-02f, 3.29208165e-01f, 3.77366245e-01f, -1.60308219e-02f, 4.28886339e-02f, 7.83115402e-02f, 1.51971117e-01f, 5.46442866e-02f, 2.46498082e-02f,
  1.45738758e-03f, 1.58905219e-02f, -1.97667122e-01f, -4.60331416e-04f, -2.00527638e-01f, 9.31893736e-02f, -4.88227755e-02f, 4.13398184e-02f, 1.25841715e-03f, 1.37286752e-01f,
  6.55378401e-02f, 5.47035970e-02f, -1.27591178e-01f, -8.52466449e-02f, -1.65131897e-01f, -2.37931274e-02f, -2.47054975e-02f, 1.10229030e-01f, -2.04427302e-01f, 3.35349999e-02f,
  4.20462638e-02f, 8.48726705e-02f, 2.43266355e-02f, 3.38070467e-02f, 1.52039871e-01f, 3.70750606e-01f, 1.49499685e-01f, 1.22656353e-01f, 1.06286302e-01f, 3.00195843e-01f,
  -1.84665054e-01f, -4.30154800e-02f, 7.49091431e-02f, 3.75078559e-01f, 1.25792429e-01f, -1.52156353e-01f, 8.07497837e-03f, 3.08830757e-02f, 1.32035747e-01f, 1.44207209e-01f,
  8.38211998e-02f, -5.26970960e-02f, 6.20721914e-02f, 2.09074736e-01f, -3.02453302e-02f, 3.59910756e-01f, -6.42996058e-02f, 4.98976819e-02f, -2.65138060e-01f, 1.37612566e-01f,
  -1.54975578e-01f, -5.25927320e-02f, 1.83916420e-01f, 1.18064336e-01f, -1.72637664e-02f, -1.56853378e-01f, 3.61222178e-02f, -2.65072525e-01f, 7.93301091e-02f, 2.24525213e-01f,
  7.27744997e-02f, 1.75092027e-01f, 1.43429220e-01f, 5.31190597e-02f, 9.12758633e-02f, 5.13134897e-02f, 1.29619718e-01f, 1.23303637e-01f, -2.82520782e-02f, 2.18398079e-01f,
  2.52504349e-01f, 2.25769520e-01f, -1.07514476e-02f, 1.89446613e-01f, 6.39558882e-02f, 2.94096693e-02f, 4.93424200e-02f, 8.15610588e-02f, 1.03366949e-01f, 8.42052549e-02f,
  2.40190998e-01f, 2.05284595e-01f, 1.95453882e-01f, 5.43632843e-02f, 1.21588275e-01f, 9.08827558e-02f, -1.90416366e-01f, -6.64622784e-02f, -8.31511915e-02f, 1.21743366e-01f,
  1.98282748e-02f, 1.46306381e-02f, 1.94780100e-02f, 3.18264849e-02f, 3.13772976e-01f, -1.62418842e-01f, 1.23633370e-02f, 6.74691498e-02f, 4.07755226e-02f, -3.10180429e-02f,
  -1.36971444e-01f, -2.05325738e-01f, 1.09145842e-01f, -3.51371355e-02f, 6.84628710e-02f, 8.83974656e-02f, -7.10639730e-02f, 1.24791063e-01f, -6.23001754e-02f, 1.89388841e-01f,
  1.14761360e-01f, -1.55967519e-01f, -9.08330977e-02f, 2.22887725e-01f, 2.45731011e-01f, -2.94911563e-02f, 2.02196971e-01f, 6.88899755e-02f, -4.36801948e-02f, 1.00170635e-01f,
  1.51754439e-01f, 1.78337455e-01f, -1.33533582e-01f, 7.09625930e-02f, -1.23753184e-02f, 3.15532573e-02f, -1.42045855e-03f, 9.29427966e-02f, 1.56515867e-01f, 9.83199477e-02f,
  3.06172818e-02f, 5.05898194e-03f, 1.09525494e-01f, 1.68970674e-01f, -1.44343972e-01f, -3.17121595e-02f, 1.30478173e-01f, 2.00551212e-01f, 2.55514104e-02f, 2.25228965e-02f,
  1.99823394e-01f, 6.49686262e-05f, -9.91061926e-02f, 1.58278659e-01f, 6.03443943e-02f, -5.76503612e-02f, -9.54696164e-02f, 1.28602743e-01f, 1.28544504e-02f, -5.31405099e-02f,
  4.88693360e-03f, -2.41493791e-01f, 2.05195531e-01f, -1.75793201e-01f, -6.24503568e-02f, 3.17991495e-01f, -8.72164518e-02f, -1.48457989e-01f, -7.72552788e-02f, -5.89238293e-02f,
  -9.28605646e-02f, -1.15457382e-02f, -7.74433538e-02f, 1.76361799e-01f, 8.30379501e-02f, 1.27234086e-01f, 1.45127326e-01f, -1.04506493e-01f, -1.19121440e-01f, 9.83824953e-04f,
  1.99655369e-02f, 5.93468128e-03f, 1.04562387e-01f, -1.30311206e-01f, 4.91028391e-02f, 2.03591496e-01f, -1.18203266e-02f, -2.38840103e-01f, 1.09434240e-02f, 3.35830927e-01f,
  2.06997488e-02f, 1.05730698e-01f, -7.26454780e-02f, 1.69346452e-01f, -1.29246328e-03f, -1.82690069e-01f, 1.05601348e-01f, 1.55887678e-01f, -2.97776256e-02f, 2.52728403e-01f,
  1.59087300e-01f, -1.44909456e-01f, -4.92172241e-02f, 4.57261503e-02f, 7.98423141e-02f, -3.68847214e-02f, -6.28478378e-02f, 8.07411000e-02f, 1.28421456e-01f, 1.18451752e-01f,
  8.02344643e-03f, 8.20917785e-02f, 1.87402174e-01f, 1.71630844e-01f, -4.12818715e-02f, 1.45840585e-01f, 1.28230706e-01f, 1.84613422e-01f, 1.88096732e-01f, 2.35253247e-03f,
  -1.57731527e-04f, -8.43432993e-02f, 1.24499559e-01f, 1.79220244e-01f, 2.61503160e-02f, 2.68326364e-02f, 4.49861288e-02f, 2.91691661e-01f, 1.42662063e-01f, 3.30194496e-02f,
  -7.37404972e-02f, 6.72365725e-02f, 3.45282780e-04f, 1.72999818e-02f, -1.76510647e-01f, 2.32509077e-01f, 1.14737846e-01f, -8.08479264e-03f, -2.03714203e-02f, -3.62653062e-02f,
  7.24167451e-02f, 9.65358764e-02f, -1.43552229e-01f, 6.77551478e-02f, 3.82723585e-02f, -2.24893391e-02f, -3.71784940e-02f, 2.13361204e-01f, 7.72409840e-03f, 1.18585765e-01f,
  -2.64033838e-03f, -1.33329347e-01f, 9.99730527e-02f, 8.53388757e-02f, 2.06855372e-01f, 4.44701761e-02f, 1.01124212e-01f, 2.06970766e-01f, -1.64687768e-01f, -3.14834058e-01f,
  2.27037579e-01f, 8.06436315e-02f, -1.49185434e-02f, 1.17805060e-02f, 8.88145640e-02f, -1.13487523e-02f, 2.33743459e-01f, 2.54657954e-01f, 2.27542818e-02f, 2.38266736e-02f,
  2.05918938e-01f, 9.62589532e-02f, 8.70690867e-02f, -7.56965531e-03f, 1.97589621e-01f, 4.38179635e-02f, 7.16284364e-02f, -9.22210887e-03f, -6.33521080e-02f, 1.13407746e-01f,
  1.91109851e-01f, -1.04686007e-01f, 1.65955245e-01f, -7.67968744e-02f, 2.45185085e-02f, -4.67363074e-02f, -2.54723653e-02f, 1.26536399e-01f, -2.00595986e-03f, -7.66274631e-02f,
  -2.54569739e-01f, 9.01569724e-02f, 3.14822555e-01f, -1.87037706e-01f, -4.15590592e-02f, 1.40371948e-01f, -1.91067867e-02f, 8.73601362e-02f, -1.99402794e-01f, 2.89591029e-02f,
  -1.28683329e-01f, -4.70952205e-02f, 2.91653275e-01f, 2.70662010e-01f, 1.86151043e-02f, -5.57025382e-03f, 7.36502632e-02f, 7.41631016e-02f, -3.35829966e-02f, -5.86600229e-02f,
  1.31517574e-01f, -2.10173935e-01f, 1.65874764e-01f, 2.50907302e-01f, 2.95255274e-01f, 3.11107934e-01f, 1.90189302e-01f, 2.30404899e-01f, 2.69751489e-01f, 1.08552374e-01f,
  9.79198441e-02f, 3.63874361e-02f, 9.79963467e-02f, 7.61360303e-02f, 2.94261090e-02f, -5.72447926e-02f, -4.16563749e-02f, -1.00652263e-01f, -8.91900882e-02f, 2.16042280e-01f,
  1.16827123e-01f, 3.62844542e-02f, 1.30426571e-01f, 1.14627481e-01f, 2.04635635e-01f, 5.84742166e-02f, 9.40345302e-02f, -8.35430324e-02f, 1.50506586e-01f, 1.75064858e-02f,
  -5.47634289e-02f, 1.71416514e-02f, -6.85135834e-04f, -1.09999187e-01f, -7.56367221e-02f, 1.17243119e-01f, -4.44357619e-02f, 8.29682052e-02f, 5.25848120e-02f, 8.46591219e-02f,
  -4.86254916e-02f, -3.55772153e-02f, 2.04313979e-01f, 1.57992393e-02f, 2.89877951e-02f, -8.89430568e-02f, 1.54459374e-02f, 6.54838979e-02f, 1.15037248e-01f, -6.73438311e-02f,
  -1.51244178e-01f, 1.43770128e-01f, 6.40429109e-02f, -6.16418645e-02f, -1.85382366e-01f, 5.42153185e-03f, 2.29631722e-01f, 2.49977913e-02f, -7.21521750e-02f, -3.70292291e-02f,
  7.50199407e-02f, -1.08444072e-01f, 3.27540841e-03f, -1.38134629e-01f, 2.10718796e-01f, 1.62443817e-02f, -1.07608147e-01f, 2.57868081e-01f, 1.34944275e-01f, -8.40190202e-02f,
  -8.77954140e-02f, 1.31820351e-01f, -1.78027064e-01f, 2.51458645e-01f, 1.00089565e-01f, 2.74765473e-02f, -1.79145679e-01f, 1.40585661e-01f, 1.55602880e-02f, 3.37334648e-02f,
  -2.71205232e-02f, 1.55575067e-01f, 1.49571553e-01f, -3.35631557e-02f, -6.21799640e-02f, 1.09107904e-02f, 9.97732580e-02f, 1.11974582e-01f, 2.10598439e-01f, 1.28196761e-01f,
  3.75594459e-02f, 1.07348755e-01f, -3.44566349e-03f, 1.12161227e-01f, 1.13394752e-01f, 1.26407787e-01f, 1.69810504e-01f, -3.73836234e-02f, 1.38298243e-01f, 2.93115944e-01f,
  9.38501433e-02f, 2.32405484e-01f, -8.56425092e-02f, 2.83676654e-01f, -1.13454396e-02f, -2.51207680e-01f, 1.37937084e-01f, -3.36804837e-02f, -1.94292199e-02f, 9.50292349e-02f,
  -2.35442165e-02f, -2.10079793e-02f, -8.19925964e-03f, 1.33953765e-01f, 6.42347932e-02f, 1.69539735e-01f, -1.13597207e-01f, -2.99552772e-02f, 1.36434212e-01f, 1.45001739e-01f,
  -9.99691710e-02f, -2.53394008e-01f, 4.92337383e-02f, 6.04111925e-02f, -1.71627596e-01f, 2.55123496e-01f, 1.24053463e-01f, 1.44732744e-01f, 3.31028253e-01f, 2.18279943e-01f,
  1.17976069e-01f, -2.28110343e-01f, 2.34487578e-01f, -1.30788177e-01f, -2.31334820e-01f, -1.13725491e-01f, 5.33282682e-02f, 2.96502322e-01f, 9.02443752e-02f, -1.44531935e-01f,
  -1.46551594e-01f, 2.51778448e-03f, 1.41899377e-01f, 1.67079344e-01f, -3.09094340e-02f, -7.64609575e-02f, 1.10578336e-01f, 1.10647582e-01f, 1.04902185e-01f, -4.40614149e-02f,
  1.49050742e-01f, 2.00874314e-01f, 1.44538641e-01f, 1.25090674e-01f, 2.21602872e-01f, 4.87837680e-02f, 6.65394291e-02f, 8.32801536e-02f, 1.80591509e-01f, 5.72383143e-02f,
  6.75580874e-02f, 1.25828916e-02f, 2.16285467e-01f, 7.69829080e-02f, 1.39806435e-01f, 5.54314815e-02f, 1.50014341e-01f, 2.69109428e-01f, -1.30161285e-01f, -3.23459744e-01f,
  4.40114513e-02f, 1.61173746e-01f, 1.66189462e-01f, -3.63078892e-01f, -3.57760549e-01f, -4.79019731e-02f, 1.42630473e-01f, -2.71019526e-02f, 1.84538931e-01f, 1.34616308e-02f,
  -1.22901713e-02f, -1.57236516e-01f, 1.87753230e-01f, -5.07783592e-02f, -1.21510841e-01f, 1.43857300e-02f, 4.58282977e-02f, 4.99221049e-02f, 4.61992398e-02f, 2.45704073e-02f,
  -2.20925901e-02f, 1.05700932e-01f, 7.47543871e-02f, 1.18972890e-01f, -7.85778165e-02f, -1.28734320e-01f, 3.29031162e-02f, 1.31691754e-01f, -2.49233156e-01f, -2.17394587e-02f,
  -2.40582481e-01f, 1.93140581e-02f, -5.17509878e-03f, -1.42451882e-01f, -6.19478673e-02f, 2.65390009e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.25325143e-01f, 1.11596063e-01f, 1.97955236e-01f, 3.64488475e-02f, 2.02888817e-01f, 2.03694850e-01f, -6.16389746e-03f, 9.12980735e-02f, 6.45757765e-02f, -3.00392658e-02f,
  6.04913719e-02f, 1.52930737e-01f, 2.26142988e-01f, -4.97133425e-03f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.75264686e-01f, -1.55597115e-02f, -8.37564990e-02f, -2.62450948e-02f, -4.14357483e-02f, -7.33927712e-02f, 5.55378087e-02f, -2.73136720e-02f, -1.13376021e-01f, 1.14768066e-01f,
  -5.43430410e-02f, 1.91684946e-01f, -8.30448139e-03f, -8.40605572e-02f, 3.39589529e-02f, 4.62049693e-02f, -1.09580748e-01f, -3.20827365e-02f, 4.32923809e-02f, -7.33392360e-03f,
  -3.11841629e-02f, 1.44684389e-01f, 4.10354920e-02f, 8.62925276e-02f, 8.91178101e-02f, 1.10095114e-01f, 3.80892269e-02f, -2.22533584e-01f, -1.41083390e-01f, -8.40125456e-02f,
  -1.78166285e-01f, 1.67517141e-01f, 4.64892611e-02f, -1.72239408e-01f, -1.46424681e-01f, 1.84409723e-01f, -3.01023480e-03f, -7.21430257e-02f, 1.67193010e-01f, -8.56282562e-02f,
  2.61980053e-02f, 9.84116942e-02f, 1.90352142e-01f, -5.69289103e-02f, 9.98760015e-02f, 8.41516927e-02f, 1.55461311e-01f, -2.41305418e-02f, 1.24887131e-01f, -1.67090923e-01f,
  -2.78932542e-01f, 6.18328489e-02f, 1.25975208e-03f, -3.89232896e-02f, -5.12452796e-02f, -4.97072525e-02f, -1.47771388e-01f, -1.03682533e-01f, -3.83642539e-02f, 1.61001489e-01f,
  2.42485180e-01f, 4.60584126e-02f, -9.34441835e-02f, -1.14321083e-01f, -2.93001141e-02f, 3.17087211e-02f, -7.41342381e-02f, -3.08460165e-02f, -1.93364695e-02f, -1.69007760e-02f,
  -1.03488907e-01f, 1.52417809e-01f, -2.53911112e-02f, 3.42872739e-02f, -1.38814986e-01f, 8.44517946e-02f, -7.32653812e-02f, -9.95970070e-02f, -6.96019083e-02f, -5.78332180e-03f,
  -3.53922173e-02f, -3.78092341e-02f, -5.64612709e-02f, -6.59345016e-02f, 4.71885949e-02f, -2.24226667e-03f, 1.02665722e-01f, 1.04000673e-01f, 1.03767864e-01f, 8.93666968e-02f,
  1.00730024e-01f, -1.12610690e-01f, -1.62479758e-01f, -1.61994249e-01f, -3.04925591e-01f, -1.74403980e-01f, -9.95397493e-02f, 6.22407608e-02f, -1.97962224e-01f, 1.84939921e-01f,
  -1.45443082e-01f, 7.43792346e-03f, 1.24471456e-01f, 1.31115183e-01f, 8.72224867e-02f, 1.38250113e-01f, 2.35065803e-01f, 1.74083605e-01f, 1.66240916e-01f, -1.46024734e-01f,
  6.68438524e-02f, 1.86573863e-01f, 1.40340708e-03f, -7.26174284e-03f, -1.66085750e-01f, -1.40438810e-01f, -1.56866685e-01f, -1.68468412e-02f, 1.46536067e-01f, -3.24846096e-02f,
  -1.24828093e-01f, -3.75854895e-02f, -1.00901745e-01f, -6.05870970e-02f, 1.29505143e-01f, 1.22708961e-01f, 8.85562301e-02f, -1.00312121e-01f, -1.39595330e-01f, -8.94619450e-02f,
  -1.23722963e-01f, -4.83215116e-02f, 2.13034630e-01f, -1.80927981e-02f, 4.72364649e-02f, 1.40108436e-01f, -3.97854112e-02f, 1.25987694e-01f, -1.27735570e-01f, -6.61281943e-02f,
  4.18680953e-03f, -1.01602767e-02f, -7.47486725e-02f, 1.70340270e-01f, -9.54665691e-02f, 8.53758976e-02f, -4.08979468e-02f, 6.64233603e-03f, 3.61747034e-02f, 6.46952018e-02f,
  -9.49904695e-02f, -3.71657424e-02f, 1.34337708e-01f, -7.44077489e-02f, 1.51090160e-01f, 1.77214265e-01f, -1.68862626e-01f, 3.91965099e-02f, 4.85889427e-02f, 3.47291008e-02f,
  -1.34321600e-01f, -6.57521337e-02f, -1.35561243e-01f, 1.27620352e-02f, -3.09449106e-01f, -1.80071533e-01f, 1.73204303e-01f, -4.62422334e-02f, -2.00948805e-01f, -1.02245482e-02f,
  -4.48898552e-03f, 7.76264956e-03f, -4.14566219e-01f, -2.17990562e-01f, -1.74583718e-01f, -2.41194526e-03f, -1.57879159e-01f, 1.03044495e-01f, 2.92232167e-02f, -1.24578729e-01f,
  1.62016526e-01f, -2.29204193e-01f, 1.16545847e-02f, 6.33205026e-02f, -7.96765536e-02f, -8.92839208e-02f, 1.12741210e-01f, -1.21018149e-01f, -1.11816645e-01f, 2.21387818e-01f,
  -7.88543746e-02f, -1.63078774e-02f, 1.09888509e-01f, -5.02754413e-02f, 1.01331286e-01f, 1.37705535e-01f, 8.38466510e-02f, -2.75179837e-02f, -5.25506362e-02f, -5.06646670e-02f,
  6.97511435e-02f, 8.79063457e-02f, -6.20609932e-02f, -6.83081597e-02f, 1.21540885e-04f, -3.85890454e-02f, -4.69693504e-02f, -1.46148438e-02f, 1.81842828e-03f, -7.94898495e-02f,
  8.73579271e-03f, 8.12359080e-02f, -1.36353746e-01f, -1.26245528e-01f, 9.88873839e-02f, -9.46911797e-02f, -3.64357978e-02f, -4.62122783e-02f, -1.50267035e-01f, -4.81524654e-02f,
  1.48806140e-01f, -5.95496967e-02f, 3.91690023e-02f, -7.69968107e-02f, -5.73478453e-02f, 1.67361677e-01f, 1.13017268e-01f, 2.70555392e-02f, 1.52772874e-01f, 1.01850014e-02f,
  -2.04593211e-01f, -8.88099670e-02f, 1.55993894e-01f, -1.81267872e-01f, -7.99539220e-03f, 1.07141808e-01f, 1.46145150e-01f, 1.30409777e-01f, 9.29262564e-02f, -6.82963654e-02f,
  9.56727341e-02f, -1.52095571e-01f, 1.08006142e-01f, -1.74241364e-02f, -1.15976676e-01f, 9.96376052e-02f, 1.46138772e-01f, -9.49536189e-02f, -9.42366123e-02f, -7.63853490e-02f,
  2.94079576e-02f, 1.36603832e-01f, 3.15570757e-02f, 1.07125798e-02f, 4.99832034e-02f, 5.59737347e-02f, -1.23872496e-01f, 6.36042282e-02f, 6.85510859e-02f, -1.89160649e-02f,
  1.42024845e-01f, -1.49984241e-01f, -3.45900320e-02f, -7.65402839e-02f, -2.35220906e-03f, 1.91145867e-01f, 7.45799541e-02f, 1.13601405e-02f, 4.12256131e-03f, 1.35979220e-01f,
  3.95401344e-02f, 2.82750502e-02f, -8.79669264e-02f, 1.90771278e-02f, -9.17723309e-03f, 2.92484351e-02f, 8.49221498e-02f, 1.35290176e-02f, -1.40393928e-01f, 7.85227790e-02f,
  -1.39328167e-01f, -2.33560488e-01f, -6.63364008e-02f, 8.32782462e-02f, 9.42535475e-02f, 1.79888114e-01f, 2.63232440e-01f, 2.24294096e-01f, -1.80468801e-02f, 5.87288477e-02f,
  9.32282135e-02f, -2.96290755e-01f, -1.50502101e-01f, 1.10124089e-01f, 6.86887130e-02f, 2.10983865e-02f, -2.77034372e-01f, -2.47350745e-02f, -4.92960867e-03f, -1.26641497e-01f,
  -2.92066902e-01f, -2.03813761e-01f, -2.27781847e-01f, -1.97739512e-01f, 4.95622419e-02f, -1.34040326e-01f, 2.11797580e-01f, -8.21097642e-02f, 1.53794438e-01f, -9.02734101e-02f,
  -1.54407889e-01f, 9.01908278e-02f, 1.74831897e-01f, -2.38895640e-02f, -7.98447654e-02f, -8.77943560e-02f, -9.97043028e-02f, -5.73627558e-03f, -5.97943552e-02f, 2.04076946e-01f,
  -1.62293792e-01f, 2.94395387e-02f, -6.52750283e-02f, 6.74414486e-02f, 9.38519835e-02f, -5.08001931e-02f, -8.21545571e-02f, -4.82908115e-02f, -1.42907441e-01f, 9.88434479e-02f,
  -1.82158336e-01f, 3.34259607e-02f, -1.06153511e-01f, 1.78037792e-01f, -1.60502438e-02f, -3.15249152e-02f, -1.82319120e-01f, 5.33328718e-03f, -1.12377018e-01f, 9.53375846e-02f,
  -1.07691195e-02f, -2.96278275e-03f, 3.02499868e-02f, 9.22308583e-03f, -2.34140810e-02f, -5.71902022e-02f, 1.81522056e-01f, -1.37597695e-02f, -1.66949466e-01f, 1.50508478e-01f,
  -1.75761759e-01f, -2.76061594e-02f, -6.71616849e-03f, -1.53420255e-01f, 1.45014971e-01f, 1.42973691e-01f, -3.24321650e-02f, -1.19534098e-01f, 1.93449423e-01f, 5.95873073e-02f,
  -1.82380721e-01f, 1.63158104e-01f, 7.07390010e-02f, -2.83354759e-01f, -2.07666740e-01f, -9.88494903e-02f, -1.70615897e-01f, -1.08638644e-01f, 9.09984037e-02f, 4.70863171e-02f,
  -2.10696146e-01f, 3.28634977e-02f, 1.51054695e-01f, 1.40713807e-02f, -1.88400015e-01f, 6.46508187e-02f, -1.41513571e-01f, 1.15981260e-02f, -6.02007769e-02f, 1.85487270e-02f,
  -1.21269864e-03f, 8.23776796e-02f, -2.16434807e-01f, -7.46362284e-02f, 3.84716503e-02f, 3.05433460e-02f, -2.97273323e-02f, -9.20678154e-02f, 9.05703306e-02f, 7.87356645e-02f,
  -1.10281460e-01f, -1.15423113e-01f, -2.86457818e-02f, -1.15454242e-01f, -7.83484022e-04f, -5.31589091e-02f, 5.93298897e-02f, -3.29171796e-03f, -5.89050837e-02f, -3.21173742e-02f,
  -1.67877004e-01f, -8.06210712e-02f, 1.84953168e-01f, -1.07246295e-01f, -7.63797015e-02f, -6.77162260e-02f, 2.51321010e-02f, -1.62759140e-01f, -7.05536976e-02f, 1.07110858e-01f,
  1.47328660e-01f, -3.32975872e-02f, -7.87150338e-02f, 6.17493093e-02f, -1.16535865e-01f, 1.07026160e-01f, 2.65687723e-02f, -3.94581370e-02f, 1.37976959e-01f, 2.26584256e-01f,
  -3.27636637e-02f, -3.18030044e-02f, -9.87554714e-02f, -1.34400800e-01f, 1.78966597e-01f, -1.09800570e-01f, -2.15095267e-01f, -5.09600639e-02f, 3.55509333e-02f, 8.89366493e-02f,
  1.65679067e-01f, 4.92213108e-02f, 1.16019972e-01f, -4.08704542e-02f, -2.91309148e-01f, 3.69645422e-03f, -4.13487330e-02f, -1.35072097e-01f, 4.94719855e-02f, -3.61995138e-02f,
  -7.93633461e-02f, -1.18291847e-01f, 1.58653930e-01f, 1.04767270e-01f, 6.21947274e-02f, 4.79440987e-02f, 1.17131621e-02f, 8.02255701e-03f, 1.12684838e-01f, 3.77102122e-02f,
  -3.46725248e-02f, -8.87742043e-02f, 4.23821472e-02f, -8.78415257e-02f, 9.71518084e-03f, 9.05394554e-02f, -4.19502184e-02f, -1.04748920e-01f, -6.88891951e-03f, 2.17871517e-02f,
  -9.94248614e-02f, 6.89042434e-02f, 1.64365351e-01f, -1.07635975e-01f, -1.56252772e-01f, 6.00572489e-02f, 8.24422166e-02f, 7.91984517e-03f, 5.98488725e-04f, -7.68562183e-02f,
  1.08348735e-01f, 1.17564797e-01f, 5.72417118e-02f, 1.95701733e-01f, 4.42582034e-02f, 1.63395584e-01f, 1.93823129e-02f, -5.49238138e-02f, -1.14021339e-01f, 9.98946186e-03f,
  6.81565702e-02f, -1.72810871e-02f, -4.12970185e-02f, 1.43153086e-01f, -2.62265146e-01f, -8.02933984e-03f, 3.04086227e-02f, -1.81602255e-01f, -3.76604162e-02f, 2.15629563e-02f,
  8.59268531e-02f, 4.83019017e-02f, -1.84778333e-01f, -6.28239149e-03f, 5.71590774e-02f, 5.82573488e-02f, -1.14091918e-01f, -6.65481389e-02f, 6.24258928e-02f, 2.26521511e-02f,
  -3.96089479e-02f, -7.10207298e-02f, 7.90808275e-02f, 1.63465649e-01f, -8.33527744e-03f, -7.66779706e-02f, 1.00526579e-01f, -1.46912098e-01f, 9.10911039e-02f, 2.15709701e-01f,
  -1.27815098e-01f, 1.36166662e-01f, 2.14469612e-01f, -6.60869405e-02f, -6.26505390e-02f, 1.06555760e-01f, 8.77044871e-02f, 1.57840446e-01f, -9.01480094e-02f, -6.99078813e-02f,
  1.56384587e-01f, -5.05268276e-02f, -8.48726332e-02f, 7.17084110e-02f, 3.02227493e-02f, -1.08466513e-01f, 3.47642764e-03f, -9.59956944e-02f, 1.15206659e-01f, 1.16644725e-02f,
  4.57359925e-02f, -4.93591577e-02f, 9.54700485e-02f, 1.33669600e-01f, 1.10810511e-01f, -1.38445020e-01f, 8.49774033e-02f, 1.24027066e-01f, 2.53257863e-02f, 1.30412996e-01f,
  -7.57020116e-02f, -2.34204829e-02f, -6.30689412e-02f, -1.00966960e-01f, -4.51115891e-02f, -1.49928257e-01f, -2.20782354e-01f, 9.87465754e-02f, -6.89287111e-02f, -3.56947593e-02f,
  5.93506508e-02f, -1.05062470e-01f, -1.42244756e-01f, 2.35456992e-02f, 1.20130368e-01f, -2.62108684e-01f, -1.15363017e-01f, 1.16618827e-01f, 1.82041049e-01f, 1.00143962e-01f,
  9.15082097e-02f, -2.13786051e-01f, 8.08234438e-02f, -7.05902055e-02f, -3.13572884e-02f, -1.25051022e-01f, 1.49160624e-01f, 1.99487627e-01f, -1.24191076e-01f, 1.38243973e-01f,
  1.57428294e-01f, -7.94248581e-02f, -1.05059920e-02f, -6.19348362e-02f, -5.47853075e-02f, 1.72182381e-01f, -7.40214586e-02f, 5.02844304e-02f, 1.37922630e-01f, -9.57139581e-03f,
  5.88025749e-02f, 4.36165184e-02f, 1.69412140e-03f, 5.96348867e-02f, 5.61312847e-02f, 1.09218992e-03f, 1.63410176e-02f, 1.00108355e-01f, -2.79680490e-02f, 1.45599768e-01f,
  8.35351273e-02f, -5.79902232e-02f, 9.56448689e-02f, -1.03477865e-01f, 2.98784506e-02f, 1.70014784e-01f, -8.59525949e-02f, -1.07108124e-01f, 1.72171388e-02f, 1.14496581e-01f,
  8.75853077e-02f, -8.61882120e-02f, -1.38974980e-01f, -2.94980202e-02f, 2.34288108e-02f, -1.54696375e-01f, 9.74477679e-02f, 6.46002144e-02f, -6.70918226e-02f, 1.71180032e-02f,
  -3.42274010e-02f, -2.12340467e-02f, 2.56104469e-01f, 1.31975543e-02f, 1.51292920e-01f, 1.14885725e-01f, 1.29414782e-01f, -4.13910821e-02f, -1.66129265e-02f, 4.93174903e-02f,
  3.30405951e-01f, 1.50949433e-01f, 7.44473487e-02f, 1.07280789e-02f, -1.37026131e-01f, 2.35341668e-01f, 5.47239222e-02f, 8.31461046e-03f, 1.07257932e-01f, 1.80923119e-01f,
  4.98388968e-02f, -2.61122495e-01f, 9.63562801e-02f, -4.08112146e-02f, -5.04473820e-02f, 1.13995656e-01f, -1.61352269e-02f, -1.79611921e-01f, -2.85425317e-02f, -8.23735669e-02f,
  -6.49052188e-02f, 4.95186783e-02f, -1.88590609e-04f, -2.55597625e-02f, -9.27328616e-02f, 3.44569385e-02f, -1.35886744e-02f, -6.88002929e-02f, -9.40341651e-02f, -5.49845099e-02f,
  -8.08393434e-02f, -1.22916870e-01f, -3.43964919e-02f, 6.59520030e-02f, -2.93304212e-02f, -6.44042576e-03f, 1.24724716e-01f, 1.36957273e-01f, -1.23512700e-01f, -2.00712860e-01f,
  1.31306306e-01f, 8.51563439e-02f, -6.84692189e-02f, -6.69736341e-02f, 1.11856401e-01f, -8.46592057e-03f, -1.02315374e-01f, -1.40100801e-02f, -8.37247372e-02f, 4.07931022e-02f,
  6.91623986e-02f, -1.15273267e-01f, -1.11797772e-01f, 1.00886971e-01f, -7.13701770e-02f, -1.80929512e-01f, -2.09703565e-01f, -7.82249272e-02f, 7.55078718e-02f, -1.69269055e-01f,
  -1.83439419e-01f, 1.53424129e-01f, 9.09614637e-02f, 1.62458308e-02f, -2.09273890e-01f, -1.30608499e-01f, -7.22882599e-02f, 1.45263016e-01f, -1.18512206e-01f, -9.82771516e-02f,
  1.23935610e-01f, -2.17185363e-01f, 6.50385842e-02f, -1.78251371e-01f, 5.33479266e-02f, 2.59801000e-01f, -8.97219591e-03f, 3.37948985e-02f, -8.84727314e-02f, -1.96807593e-01f,
  -1.62387360e-02f, 2.25080587e-02f, 6.27231225e-02f, -7.46097267e-02f, 6.32177293e-02f, 1.52904332e-01f, 9.39089656e-02f, -1.23028226e-01f, -2.98399385e-02f, -9.99013856e-02f,
  -1.47866632e-03f, -3.67258750e-02f, -2.72729876e-03f, 1.66071542e-02f, 5.46116382e-02f, -7.29575083e-02f, -6.78776279e-02f, 7.15864077e-02f, 1.26999974e-01f, 3.44028510e-02f,
  1.86642170e-01f, -1.57990083e-02f, -8.34436491e-02f, -5.94161032e-03f, 5.88542558e-02f, 6.85628131e-02f, -6.34801686e-02f, 1.21922657e-01f, -7.90505577e-03f, -7.20340312e-02f,
  -1.09498702e-01f, -1.03601865e-01f, -1.13419995e-01f, 1.64729595e-01f, 1.52681068e-01f, 1.80827081e-01f, -1.09903358e-01f, 1.73767516e-03f, 1.32615179e-01f, -1.98878139e-01f,
  5.44340834e-02f, 1.15805626e-01f, -2.37522018e-03f, -1.71494335e-02f, -1.14396118e-01f, 2.32512355e-01f, 4.43080626e-02f, -1.13503426e-01f, -3.85377295e-02f, -1.28209725e-01f,
  -2.48303771e-01f, -1.50341168e-01f, -1.75814360e-01f, -1.45722423e-02f, 1.32995799e-01f, 9.17388350e-02f, 8.08697864e-02f, 3.49242352e-02f, -1.39021659e-02f, 1.51560083e-01f,
  1.59210235e-01f, 1.35347441e-01f, -1.49794742e-01f, -1.40252784e-01f, 3.50522213e-02f, -1.99596763e-01f, -1.16965160e-01f, 8.13945904e-02f, -5.08713052e-02f, -7.89557490e-03f,
  3.84607203e-02f, -3.21385376e-02f, -9.05156806e-02f, -1.44329146e-01f, 1.61869768e-02f, 1.11793876e-01f, 1.06978044e-01f, 2.04767939e-02f, 1.74172223e-02f, -1.74837202e-01f,
  9.13255885e-02f, -1.48083240e-01f, 8.06196034e-03f, -6.06922172e-02f, 4.48374934e-02f, -5.99723449e-03f, 7.02541322e-02f, 1.34586111e-01f, -3.92569527e-02f, 2.18906980e-02f,
  -8.58675316e-02f, -1.83773309e-01f, -8.26978460e-02f, 1.99336827e-01f, -1.25783667e-01f, 8.98557678e-02f, 2.31042951e-01f, -2.37608835e-01f, 6.54319897e-02f, -5.28027602e-02f,
  1.00741953e-01f, 2.31552452e-01f, 1.39939794e-02f, -1.22469328e-01f, 8.78988355e-02f, 1.51850924e-01f, -3.85328561e-01f, -2.54959852e-01f, 1.27367988e-01f, -2.65278906e-01f,
  -2.69187629e-01f, 2.49015495e-01f, -8.24224576e-02f, -4.09135148e-02f, 1.95765644e-01f, -4.40571457e-02f, 2.34395973e-02f, -1.03565231e-01f, 2.05088750e-01f, -4.02967781e-02f,
  -9.81330499e-02f, 3.24741565e-02f, 1.68676749e-01f, 2.01862790e-02f, 2.70106167e-01f, 4.52205725e-02f, 1.77399889e-02f, 1.13355108e-01f, -2.13321581e-01f, -1.06641747e-01f,
  3.74287879e-03f, 7.07322359e-02f, 2.83028428e-02f, -1.22797780e-01f, -2.63751056e-02f, -7.61520565e-02f, -3.86090390e-02f, -1.03476554e-01f, -2.08004788e-01f, 1.54411435e-01f,
  1.12077482e-02f, 9.53234062e-02f, -1.51041582e-01f, -4.37800474e-02f, -1.32186145e-01f, 1.38682991e-01f, 1.46670667e-02f, -4.02348302e-02f, 4.95447963e-02f, -6.83175847e-02f,
  -1.11387923e-01f, -1.49771020e-01f, 1.40052050e-01f, -1.91446599e-02f, -8.63845646e-02f, -7.06363246e-02f, 8.70971009e-02f, 2.24646274e-02f, 9.40555111e-02f, -2.53000930e-02f,
  -1.63352191e-01f, 1.44156247e-01f, -2.09938586e-01f, -8.95503238e-02f, 4.42220718e-02f, -1.98262092e-02f, -8.47232565e-02f, 1.13244735e-01f, -1.01778671e-01f, -1.85839623e-01f,
  1.58815265e-01f, -2.57137660e-02f, -1.95238039e-01f, 1.50911068e-03f, 4.53152061e-02f, -3.06632102e-01f, -2.35062346e-01f, -1.04982316e-01f, -1.85392231e-01f, 1.18759282e-01f,
  1.78814173e-01f, 5.51200956e-02f, -1.24867655e-01f, -8.67708772e-02f, 9.89895836e-02f, -7.12163150e-02f, -8.80230367e-02f, 5.11142835e-02f, -1.08393459e-02f, -4.59525697e-02f,
  -4.40155119e-02f, -1.52986854e-01f, 1.05836643e-02f, 1.25813544e-01f, -4.34862003e-02f, -2.79300865e-02f, -2.51986608e-02f, 3.77753489e-02f, -3.01563274e-02f, 9.83873680e-02f,
  -1.56217247e-01f, -1.33770466e-01f, 1.18015334e-01f, 7.01510068e-03f, -6.78181946e-02f, -1.19544238e-01f, -1.70903429e-02f, -3.75508852e-02f, 6.25587329e-02f, 1.88595820e-02f,
  -4.78391610e-02f, -1.51632726e-01f, 6.08226061e-02f, -1.72412723e-01f, 7.29357526e-02f, -1.46752164e-01f, 4.51813899e-02f, 6.36244118e-02f, 7.78341815e-02f, -2.83776037e-02f,
  -1.23439014e-01f, 1.55072942e-01f, -1.90968513e-01f, 1.64406583e-01f, 8.27813298e-02f, -1.75339192e-01f, 6.10995777e-02f, -2.38357082e-01f, 9.60834250e-02f, 8.40781331e-02f,
  -3.53362262e-02f, -1.35181993e-01f, 1.40843198e-01f, 1.85359538e-01f, -1.21536471e-01f, -9.44365654e-03f, 2.50965744e-01f, -2.27001578e-01f, -3.78976315e-02f, 3.03793639e-01f,
  7.64843524e-02f, 8.64686295e-02f, 1.98260084e-01f, 4.19608550e-03f, -8.93335566e-02f, 7.39725456e-02f, 9.26857814e-02f, -9.99697596e-02f, -2.10970026e-02f, 6.66272733e-03f,
  7.46918246e-02f, 5.57139795e-03f, 1.81109328e-02f, 8.70017186e-02f, 2.13641658e-01f, 6.99603483e-02f, -2.21929207e-01f, 7.01078176e-02f, 2.71957219e-01f, 3.71929221e-02f,
  -3.18835210e-03f, -4.60639521e-02f, -3.79047468e-02f, -2.53775511e-02f, -1.02505274e-01f, -1.45816095e-02f, -2.10335925e-02f, 1.11077197e-01f, -4.88668494e-02f, -1.67804398e-02f,
  -5.38186766e-02f, 1.20612912e-01f, -1.41020566e-02f, -1.22826744e-03f, -1.01051489e-02f, 1.20443001e-01f, 6.70498088e-02f, -4.55005765e-02f, 9.34400968e-03f, -2.12165583e-02f,
  9.74587798e-02f, -6.80900738e-02f, 2.00514600e-01f, 1.29105508e-01f, 8.39787871e-02f, -8.70253053e-03f, 7.26858303e-02f, -1.30520612e-01f, -1.08969182e-01f, -5.33223599e-02f,
  -2.03015044e-01f, -2.49815896e-01f, -1.90729707e-01f, 2.63659973e-02f, -2.16433644e-01f, -5.24852313e-02f, 6.15379289e-02f, 1.36425972e-01f, 1.64150506e-01f, 2.86532134e-01f,
  1.09637706e-02f, -2.57339757e-02f, 4.71145613e-03f, 2.73633003e-02f, 1.16249882e-01f, -2.10602686e-01f, -2.04594150e-01f, 1.14425898e-01f, -2.54257083e-01f, 2.13539377e-02f,
  1.02442883e-01f, -1.33231670e-01f, 3.57201397e-02f, -1.76147483e-02f, -4.88798842e-02f, -1.67155370e-01f, 2.38045067e-01f, -4.56779748e-02f, -2.31236309e-01f, -1.34712502e-01f,
  -2.41147224e-02f, 7.18581975e-02f, 7.37401620e-02f, 1.38413772e-01f, -4.49004620e-02f, -1.03646263e-01f, -9.12036598e-02f, 8.84553567e-02f, 1.28039300e-01f, -8.09208751e-02f,
  4.57201898e-03f, -1.62752364e-02f, 9.03428495e-02f, -6.56234622e-02f, -2.53547989e-02f, -5.53334542e-02f, 1.70704387e-02f, -3.51763479e-02f, -1.00240931e-02f, 1.20094664e-01f,
  -7.65566826e-02f, 1.77520339e-03f, 1.14936486e-01f, 1.43749297e-01f, -8.24850798e-02f, -2.72988547e-02f, -2.45910406e-01f, 1.94975100e-02f, 3.45435925e-02f, -1.75572067e-01f,
  4.55904007e-02f, -1.40507028e-01f, -1.36817526e-02f, 3.02773733e-02f, 8.04755464e-02f, 3.12536776e-01f, 1.27639413e-01f, -1.24842070e-01f, 1.34558439e-01f, -1.19754188e-01f,
  2.13701218e-01f, -2.32747849e-02f, 3.66917215e-02f, -2.01963857e-01f, 3.09855640e-02f, 4.65435646e-02f, -2.78415024e-01f, 1.55322000e-01f, 1.27995118e-01f, -3.40740643e-02f,
  1.76632609e-02f, -8.63987803e-02f, 1.94609880e-01f, -3.41141373e-02f, -3.20895135e-01f, 2.34216973e-01f, 6.49814904e-02f, -1.36600450e-01f, -1.59935474e-01f, 5.48763648e-02f,
  -6.95899054e-02f, 4.83102165e-02f, 6.70559332e-02f, 1.91491902e-01f, -9.05102678e-03f, -1.08432353e-01f, -2.06293166e-01f, -2.11896747e-01f, 1.17118813e-01f, -2.78638806e-02f,
  1.22309297e-01f, -7.38986954e-02f, -3.14339519e-01f, 5.02280816e-02f, -7.66657367e-02f, -1.01535678e-01f, 1.13594703e-01f, -1.19975321e-01f, -1.58259913e-01f, -3.02737802e-02f,
  7.05538690e-02f, -1.23299733e-01f, -1.83139458e-01f, 2.94073857e-02f, -4.50001508e-02f, 6.02434436e-03f, -8.07678327e-02f, -1.64091125e-01f, 4.02203687e-02f, -1.39023885e-01f,
  2.15673178e-01f, 1.69356972e-01f, 5.61314151e-02f, 3.02361488e-01f, 8.63399804e-02f, 3.56839597e-02f, -1.06227346e-01f, -1.15200266e-01f, -2.97657609e-01f, -2.51001328e-01f,
  -8.99865031e-02f, 1.63465247e-01f, -1.81441218e-01f, 1.17488213e-01f, 1.90558434e-01f, 3.25734243e-02f, 1.29996419e-01f, -9.46233608e-03f, 1.97202027e-01f, -2.73428299e-02f,
  2.54714161e-01f, 1.27805442e-01f, 1.85508639e-01f, 4.34539048e-03f, 2.95163784e-03f, 1.92621529e-01f, -1.94424778e-01f, 1.89557113e-02f, -4.30521220e-02f, -5.47433831e-02f,
  -4.24838699e-02f, 7.03940615e-02f, 2.01298371e-01f, -1.68774635e-01f, -1.61213472e-01f, -2.00592816e-01f, 1.19452946e-01f, -4.08126861e-02f, -5.49448356e-02f, 1.51328474e-01f,
  1.33743182e-01f, 8.50316733e-02f, -1.05099164e-01f, -6.38132170e-02f, -3.32112238e-03f, 5.22513315e-02f, -5.03645092e-02f, -1.03288271e-01f, -1.33957371e-01f, 3.20042148e-02f,
  -7.02182055e-02f, -7.58075193e-02f, -1.03777103e-01f, -1.40733361e-01f, -3.55203599e-01f, -4.01295349e-02f, 1.65144238e-03f, -1.11165933e-01f, 6.01279922e-02f, 1.22651458e-03f,
  -2.21657410e-01f, -3.22190374e-02f, -1.44333676e-01f, 7.27017522e-02f, -1.92235023e-01f, -9.59913209e-02f, -2.36694515e-01f, -4.21980284e-02f, -1.20341800e-01f, 6.14940748e-03f,
  1.97015807e-01f, 2.28196144e-01f, 1.37667254e-01f, 3.43737334e-01f, 2.39148840e-01f, -3.47125605e-02f, 7.23353252e-02f, -2.59925816e-02f, 8.89743716e-02f, -1.20061062e-01f,
  -1.73652142e-01f, -2.67371953e-01f, 7.28658736e-02f, -1.53085560e-01f, 1.63710371e-01f, -2.61385322e-01f, 1.18430093e-01f, 2.86597133e-01f, 2.64797837e-01f, 1.01739489e-01f,
  3.05947721e-01f, -1.55010507e-01f, -1.55756101e-02f, 1.10283293e-01f, 3.15468535e-02f, 3.28197554e-02f, -3.38884778e-02f, 4.43612859e-02f, -1.20894633e-01f, 8.45580250e-02f,
  5.58223249e-03f, 8.55681747e-02f, 1.21674873e-01f, -1.27221197e-01f, -1.95896238e-01f, -1.83426067e-01f, -1.12983488e-01f, 5.05280420e-02f, 9.65140909e-02f, -1.07592776e-01f,
  -4.00005607e-03f, 8.90045986e-02f, -1.01497829e-01f, 8.48177075e-03f, -1.60274684e-01f, 2.21101586e-02f, -1.04563549e-01f, -2.90589351e-02f, -1.50068745e-01f, -1.08370900e-01f,
  2.13158038e-02f, 1.09240890e-01f, -1.35004476e-01f, -1.47709297e-03f, 1.06363393e-01f, -5.49627319e-02f, -7.55967647e-02f, 1.04092725e-01f, -1.22071773e-01f, -6.04122914e-02f,
  -1.43383011e-01f, 2.05608420e-02f, -1.46030918e-01f, -1.64720491e-01f, -1.63746521e-01f, 9.15868506e-02f, -9.89327878e-02f, 2.12465167e-01f, 1.81035459e-01f, -9.66061428e-02f,
  1.03049725e-01f, 1.99505866e-01f, 1.14485197e-01f, -1.75015077e-01f, 2.25083046e-02f, 6.69815242e-02f, -1.38670325e-01f, 2.10825838e-02f, 1.07533142e-01f, -2.66368181e-01f,
  -1.99183486e-02f, 4.84665968e-02f, -1.09376751e-01f, 4.88160178e-02f, 2.63413519e-01f, -8.60217512e-02f, -2.14478105e-01f, 1.32063016e-01f, 7.01201409e-02f, -5.41531593e-02f,
  -7.70342201e-02f, -5.37874848e-02f, -1.44198492e-01f, -9.66472402e-02f, -1.47933783e-02f, 1.45695344e-01f, 2.25584120e-01f, -1.00996844e-01f, -1.23562768e-01f, -1.19230174e-01f,
  -4.83351685e-02f, 3.76919396e-02f, 7.93845579e-03f, -8.07047449e-03f, 1.42161390e-02f, 2.78353784e-02f, -8.51695091e-02f, -4.77041565e-02f, 1.18722264e-02f, -3.31840664e-02f,
  1.35545343e-01f, 1.33377612e-02f, -1.49018997e-02f, 1.69581547e-02f, -5.38977683e-02f, -5.21627581e-03f, -7.26532489e-02f, -1.38189554e-01f, 8.52240622e-02f, 1.69823647e-01f,
  3.51431258e-02f, -1.59873366e-02f, -9.87120271e-02f, -1.42037272e-02f, -1.67392064e-02f, 7.28667807e-03f, -1.43239856e-01f, 1.76411197e-01f, 2.99367577e-01f, -2.26335406e-01f,
  1.11575335e-01f, 1.94760934e-01f, -5.81508428e-02f, 1.20278880e-01f, 3.35018411e-02f, -1.10204495e-01f, 2.11050540e-01f, -1.15571953e-02f, -3.47324580e-01f, -2.43413642e-01f,
  6.57279268e-02f, -2.33635947e-01f, -1.84762776e-01f, 8.08288455e-02f, 7.55479187e-02f, -7.26129264e-02f, 1.77578449e-01f, -3.21751423e-02f, -1.14526274e-02f, -1.49427205e-01f,
  1.44491628e-01f, -1.92635190e-02f, -1.61383525e-01f, 1.83903217e-01f, 2.37453282e-02f, -4.96581336e-03f, 1.68301135e-01f, 3.93400379e-02f, -9.03065950e-02f, -4.03414033e-02f,
  -8.01668763e-02f, -8.18578973e-02f, 1.59843072e-01f, 1.20334223e-01f, -4.69924957e-02f, 2.15645000e-01f, 9.20679942e-02f, -1.13370121e-01f, -7.28616863e-02f, -7.88578531e-04f,
  -6.44056275e-02f, 7.32215196e-02f, 3.71731110e-02f, -1.06605485e-01f, 1.33637369e-01f, -1.21265091e-01f, 3.01571399e-01f, -8.21830854e-02f, -6.47659898e-02f, -7.66211096e-03f,
  -8.63058493e-02f, 6.01522997e-03f, 2.79306564e-02f, 1.83814578e-02f, -4.83866036e-02f, 1.05859168e-01f, 1.89756006e-01f, 4.53372598e-02f, -2.84317974e-02f, -1.54835060e-01f,
  1.67929560e-01f, -1.79828092e-01f, -2.02772632e-01f, -1.00209527e-01f, -1.40833497e-01f, -3.98923129e-01f, -1.38889000e-01f, -2.60596782e-01f, 4.40441407e-02f, -1.25552103e-01f,
  1.77816123e-01f, -6.52844757e-02f, 2.97286678e-02f, 3.90681803e-01f, -5.68142161e-03f, 5.68182282e-02f, -2.03027263e-01f, 8.97843614e-02f, -8.41576532e-02f, -1.29756793e-01f,
  -1.67283997e-01f, 3.32785049e-03f, -2.79743761e-01f, 2.20763668e-01f, -1.30139694e-01f, 9.06397030e-02f, 1.27882272e-01f, -1.41687855e-01f, 5.51418262e-03f, -2.36807540e-01f,
  1.74472094e-01f, 8.49931873e-03f, -3.18900019e-01f, 6.11313954e-02f, -4.41560410e-02f, 7.90426061e-02f, 2.68532149e-02f, -3.08379494e-02f, 5.05740158e-02f, 4.29311283e-02f,
  -3.35734412e-02f, 9.61483568e-02f, 6.91378713e-02f, 1.17196701e-01f, -1.15481421e-01f, -6.41537532e-02f, -1.46900252e-01f, 1.47791475e-01f, 1.64803579e-01f, -6.33823499e-02f,
  -1.22401096e-01f, -1.14835642e-01f, 6.05009589e-03f, 4.60442007e-02f, 7.90566429e-02f, 1.64776687e-02f, -1.82298139e-01f, 4.67792042e-02f, 1.85795560e-01f, 1.57908395e-01f,
  -1.84621394e-01f, 3.79459858e-02f, -3.96504775e-02f, -2.18464002e-01f, 2.50031631e-02f, 5.66113256e-02f, -8.06455240e-02f, 2.53743142e-01f, 5.62107638e-02f, 2.68733770e-01f,
  -1.58083841e-01f, -6.76267743e-02f, 4.48074155e-02f, 1.12264447e-01f, -7.54783228e-02f, -6.69213682e-02f, 1.19114839e-01f, 2.07756199e-02f, -7.36224651e-02f, 1.01151362e-01f,
  -4.04476561e-02f, -1.49374276e-01f, 9.88307968e-02f, 1.95174832e-02f, -1.85645133e-01f, -9.80453268e-02f, 1.35598823e-01f, -1.76670343e-01f, -1.35624722e-01f, 1.65642723e-01f,
  8.07775855e-02f, 2.53428742e-02f, -7.79118165e-02f, 1.67068869e-01f, 1.50010556e-01f, -2.27936264e-02f, -1.72231361e-01f, 2.78304219e-02f, 1.42209694e-01f, -1.75393373e-01f,
  -1.25138000e-01f, 1.66496243e-02f, 1.09450214e-01f, -7.66631067e-02f, 1.54836416e-01f, -9.08219814e-03f, -1.47318408e-01f, -2.36070286e-02f, 1.84201136e-01f, -1.34827137e-01f,
  -1.10022873e-02f, -1.10330805e-01f, -2.29433358e-01f, 6.12721033e-02f, 2.74415482e-02f, -3.03516518e-02f, -7.56935254e-02f, 6.03721552e-02f, -3.34709138e-02f, -2.88348980e-02f,
  4.18417491e-02f, -1.26260847e-01f, -1.52633086e-01f, -1.50840208e-01f, 8.36489201e-02f, 6.94029108e-02f, 6.69542775e-02f, 7.34937787e-02f, 3.90264168e-02f, 2.14322641e-01f,
  3.63165326e-02f, -1.72707543e-01f, -2.75089085e-01f, -1.29918933e-01f, 2.80508418e-02f, 7.03480318e-02f, -1.12485997e-01f, 9.17115808e-02f, -9.55965817e-02f, 7.17124864e-02f,
  2.02936113e-01f, 1.11691035e-01f, 5.87922446e-02f, 9.92564484e-02f, 5.79247698e-02f, 4.36493494e-02f, -2.48712674e-01f, 1.18727386e-01f, 5.57229780e-02f, 3.37593704e-02f,
  -2.43735045e-01f, 6.15905225e-02f, 2.38518178e-01f, -2.74352849e-01f, 2.20770836e-02f, 8.40945393e-02f, 1.18773639e-01f, -1.57736108e-01f, 2.44220030e-02f, -2.13455006e-01f,
  9.92033929e-02f, -1.08186282e-01f, -3.95367015e-03f, 1.83852285e-01f, -8.83707628e-02f, 9.04868320e-02f, 9.15272906e-02f, 8.30634385e-02f, 5.28056957e-02f, 1.03399150e-01f,
  2.17656489e-03f, 4.38789986e-02f, 1.23601183e-02f, -2.38432288e-02f, -5.08163720e-02f, 7.40008354e-02f, -1.26130313e-01f, 3.37703489e-02f, -3.13532501e-02f, -1.15736566e-01f,
  -1.21684425e-01f, -1.60903134e-03f, 1.37497216e-01f, -5.83247989e-02f, 1.30183965e-01f, 7.49729052e-02f, -1.35197282e-01f, 1.82241518e-02f, 8.04941431e-02f, -6.14640154e-02f,
  -5.47975786e-02f, 2.32464954e-01f, -3.51803117e-02f, 1.43436760e-01f, 2.63099484e-02f, -8.73569772e-02f, -6.59651542e-03f, -1.62430137e-01f, 1.09059446e-01f, 1.40164137e-01f,
  -1.12862222e-01f, 5.96028492e-02f, 1.33400440e-01f, 3.60351964e-03f, -1.51654214e-01f, -1.44506127e-01f, -1.50613524e-02f, -2.56026864e-01f, -3.39504257e-02f, 1.82184502e-01f,
  1.25220388e-01f, -6.87132850e-02f, 9.00779739e-02f, 1.25797927e-01f, -2.29646172e-02f, -2.29474762e-03f, 1.30436122e-01f, -1.29191086e-01f, -1.85979635e-01f, 1.46037757e-01f,
  2.19271287e-01f, 1.54985294e-01f, 5.90620041e-02f, 2.93312185e-02f, 1.52566880e-01f, 9.89824906e-02f, -1.77220717e-01f, 5.49790747e-02f, 2.22032964e-01f, -8.41014907e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.38695285e-01f, 2.14269254e-02f, 8.27761739e-02f, 1.81586873e-02f, -7.89391920e-02f, -2.62156222e-02f, 3.06109600e-02f, 3.78701068e-03f, 8.58972967e-03f, 1.74922988e-01f,
  1.36385933e-01f, 4.79139611e-02f, -1.28680050e-01f, 6.75543398e-02f, 1.00962751e-01f, 4.60666567e-02f, 1.94385305e-01f, 1.97812125e-01f, 1.94894858e-02f, 1.24269016e-01f,
  1.60180956e-01f, 3.29617411e-02f, -3.76913100e-02f, -7.94178154e-03f, -3.55792344e-02f, -6.62700459e-02f, -3.94382626e-01f, -1.39913097e-01f, 1.08622663e-01f, -1.05205975e-01f,
  2.11485416e-01f, 2.46176258e-01f, -7.09026977e-02f, 1.00102305e-01f, -8.19341615e-02f, -1.09980695e-01f, 3.42198759e-01f, -1.25232294e-01f, -5.34483045e-02f, -6.61283582e-02f,
  3.37357491e-01f, -2.02544928e-02f, -4.26870733e-02f, 6.78014830e-02f, 4.43880558e-01f, 2.53001839e-01f, 6.01081364e-02f, -2.08426490e-01f, 1.35827422e-01f, -1.72938377e-01f,
  5.03947996e-02f, 3.28795701e-01f, 1.47408634e-01f, 1.58193991e-01f, -5.76931797e-03f, 2.45412856e-01f, -2.18580440e-02f, 2.01029941e-01f, 2.01041535e-01f, 3.69066149e-01f,
  1.11822374e-01f, 1.48078066e-03f, 2.21420765e-01f, 8.52844398e-03f, 2.23236129e-01f, 1.45688891e-01f, -8.78913999e-02f, 1.15112089e-01f, -1.35488272e-01f, 5.03132232e-02f,
  1.46792591e-01f, 2.83674095e-02f, 1.33289009e-01f, -8.60877242e-03f, -2.00810004e-02f, 1.27229318e-01f, 1.35655105e-01f, 1.75626040e-01f, 9.24370997e-03f, 1.40893430e-01f,
  2.91090429e-01f, 1.84357867e-01f, 1.40484586e-01f, -8.66500884e-02f, 2.82506924e-02f, 3.28981467e-02f, 3.15034449e-01f, 3.88648398e-02f, 2.40114331e-01f, 2.75262803e-01f,
  -9.68706794e-03f, 2.56960452e-01f, -1.40093774e-01f, -1.05130784e-01f, -1.48001984e-02f, -2.78927147e-01f, -2.60066390e-01f, 1.56112656e-01f, -3.27145606e-01f, 5.71649708e-02f,
  -1.44320652e-01f, -4.39152792e-02f, 1.09432921e-01f, -1.74869761e-01f, 1.80424738e-03f, 3.34628411e-02f, 1.98483139e-01f, 2.44390845e-01f, 6.75045177e-02f, -7.06747621e-02f,
  2.57907122e-01f, 1.70752943e-01f, -3.17130238e-01f, 9.61644799e-02f, 1.91364571e-01f, -1.66030988e-01f, -9.87767894e-03f, 1.50013134e-01f, 3.58993739e-01f, 2.67266899e-01f,
  -1.49874538e-01f, -8.33957419e-02f, 2.11027235e-01f, 2.75335312e-02f, 4.12948430e-02f, 1.64329097e-01f, 2.18765676e-01f, 1.77667126e-01f, 1.45308450e-01f, -2.92713083e-02f,
  5.83327003e-02f, 2.33323947e-02f, 4.19948138e-02f, 1.33113027e-01f, -1.56785369e-01f, 2.70913750e-01f, -1.01040728e-01f, 1.87261432e-01f, -8.99495408e-02f, 1.81559939e-02f,
  -2.11408287e-01f, 1.36245713e-01f, 2.42226690e-01f, 8.08263272e-02f, 2.32522860e-02f, 3.55645865e-02f, -2.83547431e-01f, -8.79554152e-02f, 1.67637095e-01f, 1.11732379e-01f,
  -6.75784471e-03f, -3.74784693e-02f, 2.26122782e-01f, 8.20318237e-03f, -1.44724697e-02f, 1.84968323e-01f, -1.21795282e-01f, 2.26291314e-01f, 4.32504229e-02f, -1.41644441e-02f,
  -7.48985633e-02f, -2.73036640e-02f, -3.13877225e-01f, 1.47920027e-01f, -5.13184130e-01f, 3.11272871e-02f, 2.33588070e-01f, -2.73563832e-01f, -7.21247569e-02f, 7.63332993e-02f,
  3.63864452e-01f, -3.24939847e-01f, -2.36382291e-01f, -3.06746531e-02f, -4.36788797e-02f, 8.71020481e-02f, 1.42539710e-01f, -3.38883430e-01f, 1.42354041e-01f, 1.89618766e-02f,
  8.85263085e-02f, -8.68726000e-02f, 1.37794260e-02f, 2.89419115e-01f, -1.69602916e-01f, 1.56206116e-01f, 1.05980366e-01f, -2.17461929e-01f, 2.29331389e-01f, 2.29071572e-01f,
  1.81170329e-02f, 9.87510756e-02f, 2.72304773e-01f, 1.88107908e-01f, 2.03161135e-01f, 8.16016272e-02f, 6.11333922e-02f, 1.58454686e-01f, 1.38577163e-01f, 1.08803011e-01f,
  1.38681740e-01f, -3.65360975e-02f, 9.48321715e-04f, 7.25779831e-02f, 4.48506624e-01f, 1.58851430e-01f, 5.94415516e-02f, 7.19261318e-02f, 1.88599974e-01f, 2.70725340e-01f,
  7.70814642e-02f, -3.15316767e-02f, 8.02518576e-02f, 9.94186942e-03f, 2.44723424e-01f, 1.01170555e-01f, 2.06946567e-01f, 1.31011024e-01f, 2.40880623e-01f, 4.96402346e-02f,
  -1.69871107e-01f, -3.39690208e-01f, -6.34519830e-02f, -4.78224367e-01f, -3.48653078e-01f, -2.43726298e-01f, -1.00928932e-01f, 1.50487289e-01f, 1.60456486e-02f, -1.60481215e-01f,
  3.16764653e-01f, 1.07439779e-01f, 8.91319215e-02f, 8.08051750e-02f, 9.46422815e-02f, 2.62916923e-01f, -8.13403502e-02f, -2.66801536e-01f, -1.62754625e-01f, -3.25755067e-02f,
  -3.57572377e-01f, 3.24698389e-01f, 1.47111088e-01f, 7.75508163e-03f, 1.60431847e-01f, -3.86069454e-02f, 1.97656021e-01f, 1.35409059e-02f, -1.99825257e-01f, 1.37215452e-02f,
  5.55543741e-03f, -3.02933846e-02f, -2.82538440e-02f, 1.84687078e-01f, 3.26648802e-01f, 1.12887010e-01f, 3.17363173e-01f, -6.84546009e-02f, 2.62847662e-01f, -7.21062645e-02f,
  -1.37910008e-01f, 2.88421333e-01f, -5.23262806e-02f, 1.97602704e-01f, -1.23377115e-01f, 2.88139880e-02f, -3.29631381e-02f, 2.35848695e-01f, -1.56646878e-01f, -1.24234714e-01f,
  -3.15797664e-02f, 1.70213610e-01f, 9.99901071e-02f, 2.03520536e-01f, 2.13502705e-01f, -5.10225147e-02f, 2.38676686e-02f, 2.09465861e-01f, 1.27133265e-01f, 1.67317167e-01f,
  1.02282457e-01f, 2.72568196e-01f, -5.09413928e-02f, -4.05497327e-02f, -1.91101566e-01f, -3.33669990e-01f, -3.64857405e-01f, -1.75343513e-01f, 2.35245526e-02f, -1.47340640e-01f,
  -3.68682683e-01f, 3.61293703e-01f, 3.01264077e-01f, -7.34511539e-02f, 1.64756998e-01f, -1.24276221e-01f, 3.39408368e-01f, -1.80855006e-01f, 4.72023547e-01f, 4.78135571e-02f,
  4.04120386e-01f, 2.94459313e-01f, 3.78126830e-01f, 6.83447719e-02f, 1.60345525e-01f, -1.91565514e-01f, -1.09701782e-01f, 1.73990186e-02f, -1.05475351e-01f, 2.57236600e-01f,
  3.33563030e-01f, 7.68536627e-02f, -3.58137935e-01f, -7.40592405e-02f, 4.04008538e-01f, 2.00207785e-01f, 3.77207696e-01f, 3.47646207e-01f, 2.02714741e-01f, -6.57446906e-02f,
  3.34291682e-02f, 4.25106846e-02f, 4.90609556e-03f, 2.06028432e-01f, -1.66834649e-02f, 1.05897449e-01f, 5.34474552e-02f, 1.59420639e-01f, 7.43196905e-02f, 1.06601901e-01f,
  9.44786221e-02f, -8.84575397e-03f, -1.95788041e-01f, 1.01748310e-01f, 1.61278650e-01f, -1.47971243e-01f, 3.17117013e-02f, -1.37509638e-02f, -7.38815293e-02f, 1.30349100e-01f,
  -1.63386822e-01f, 1.30550623e-01f, 6.67921230e-02f, 1.12347724e-02f, 6.79928660e-02f, 1.42585516e-01f, -1.08254366e-01f, -1.11240946e-01f, 3.89640294e-02f, -1.44662037e-01f,
  -6.08085692e-02f, 3.25203180e-01f, 1.09436497e-01f, 6.50369609e-03f, -1.75144896e-02f, 2.90062010e-01f, 1.97722897e-01f, -2.04534948e-01f, -2.57249057e-01f, -1.06085196e-01f,
  2.09055349e-01f, -2.84776181e-01f, 4.29846011e-02f, -3.59458625e-01f, 3.77383858e-01f, 3.10635805e-01f, 4.57919329e-01f, -1.03185453e-01f, 3.23087007e-01f, -3.89841408e-01f,
  -1.20211206e-02f, 8.21985379e-02f, -6.72242343e-02f, 1.88536152e-01f, 1.03271835e-01f, 6.16689911e-03f, -2.96357721e-01f, 1.21737905e-01f, 4.32328552e-01f, 1.05616435e-01f,
  6.69763535e-02f, -2.76456680e-03f, -1.03948750e-01f, -1.07854724e-01f, 9.13838148e-02f, 9.48192701e-02f, 3.37477289e-02f, 1.00093238e-01f, 2.20872670e-01f, -1.90751180e-02f,
  2.45035842e-01f, 7.39623234e-02f, 1.31503701e-01f, 9.10892040e-02f, 1.41706064e-01f, 5.16097769e-02f, 2.56130606e-01f, 2.74637341e-01f, 1.30407423e-01f, 1.23079345e-02f,
  1.89832032e-01f, 1.67455763e-01f, 1.14354286e-02f, -3.47693488e-02f, 9.35206655e-03f, 1.17251314e-01f, 1.57677270e-02f, 1.02180935e-01f, 1.03708088e-01f, -8.82794987e-03f,
  -1.37398213e-01f, 2.86114633e-01f, 2.07744002e-01f, -4.36526500e-02f, 3.98103148e-01f, -1.88911721e-01f, -2.02984631e-01f, 3.64981979e-01f, -8.78258795e-02f, -1.65746018e-01f,
  -2.85631865e-01f, 3.28113697e-02f, -1.73746526e-01f, -1.97714791e-01f, 9.28844661e-02f, 1.48556411e-01f, 7.29411915e-02f, 2.26986051e-01f, -3.17725867e-01f, -5.84180318e-02f,
  1.76893011e-01f, -5.69183677e-02f, -3.73547047e-01f, -1.54593498e-01f, 4.18586195e-01f, -2.39134118e-01f, -7.08601847e-02f, 3.02186189e-03f, 1.15438752e-01f, 3.34349841e-01f,
  2.01892033e-01f, 7.07242191e-02f, 1.10987335e-01f, -2.06853941e-01f, -2.43513033e-01f, 4.42194268e-02f, 1.90297499e-01f, 2.50371516e-01f, -2.04397440e-01f, -8.77123177e-02f,
  7.99458325e-02f, -3.33225653e-02f, -3.78383473e-02f, 1.33116534e-02f, -3.33853103e-02f, 1.02224037e-01f, -2.00183749e-01f, 1.88177988e-01f, 2.25265503e-01f, 6.73934519e-02f,
  -3.56279343e-01f, 1.02131195e-01f, 6.71847071e-03f, 1.16477087e-01f, -1.95217803e-01f, 9.14534777e-02f, -9.57673714e-02f, 5.80478646e-02f, 1.71097815e-02f, 8.16032141e-02f,
  -3.15115929e-01f, 1.01228781e-01f, 1.02449030e-01f, -1.23059273e-01f, -1.66737735e-01f, -8.11360124e-03f, -2.64136732e-01f, 3.60592484e-01f, 2.49611009e-02f, 2.15830877e-01f,
  -1.30702630e-01f, -6.07869178e-02f, -1.55496597e-01f, 1.42384231e-01f, -2.46957198e-01f, -1.14574596e-01f, 2.83314586e-01f, -2.73969680e-01f, -1.67732984e-01f, 1.91251129e-01f,
  1.86340824e-01f, -2.10322395e-01f, -1.50193468e-01f, 1.93719193e-02f, -2.33481154e-01f, -6.06579073e-02f, 1.10426076e-01f, -2.47209966e-01f, 3.92451771e-02f, 6.31468445e-02f,
  1.30176172e-01f, -7.25824684e-02f, -1.11604877e-01f, 1.86607152e-01f, -6.22949824e-02f, 2.79465675e-01f, -1.22036487e-01f, 1.30307406e-01f, 1.53597206e-01f, 5.79103865e-02f,
  -5.04659899e-02f, -4.55331989e-02f, 7.46058673e-02f, 2.49913067e-01f, -1.08535208e-01f, 5.07601798e-02f, 1.83583826e-01f, 1.28714442e-01f, 1.47990912e-01f, -4.61510345e-02f,
  2.09331423e-01f, 1.40897766e-01f, 1.58863217e-01f, -4.33151945e-02f, 1.91804811e-01f, 8.33985433e-02f, -4.97233570e-02f, 3.23835760e-02f, 1.38758987e-01f, -7.92906731e-02f,
  1.57702386e-01f, 5.61193712e-02f, -3.29177864e-02f, -7.94511512e-02f, 9.83060151e-02f, 2.46206746e-01f, 7.20249712e-02f, -2.66969174e-01f, -1.19903408e-01f, -2.66640097e-01f,
  -1.57908365e-01f, -3.20664831e-02f, 2.49416530e-02f, -3.12156022e-01f, -3.77568714e-02f, -2.02652849e-02f, 1.31990150e-01f, -3.09478492e-01f, 2.14055941e-01f, 5.91714978e-02f,
  1.14945658e-01f, 3.61900151e-01f, -1.01724193e-01f, 1.99273705e-01f, -1.73359007e-01f, 9.57587734e-02f, 3.71553898e-02f, -1.25829354e-01f, -3.17888230e-01f, -1.83007181e-01f,
  -2.59604365e-01f, 3.20272207e-01f, 3.46989781e-02f, 4.32489142e-02f, 2.12717012e-01f, 1.69382602e-01f, -1.96040913e-01f, 5.36249690e-02f, 2.25228086e-01f, 1.15733363e-01f,
  -1.71245679e-01f, 1.30189523e-01f, -2.07654275e-02f, 4.46275994e-02f, 2.22744375e-01f, 9.40255150e-02f, 6.53208643e-02f, 2.78513938e-01f, 1.90236215e-02f, 7.85827711e-02f,
  2.25319311e-01f, 1.98009714e-01f, -2.02530604e-02f, 1.04878403e-01f, 3.35920155e-02f, 6.10788353e-02f, 2.97223181e-01f, 1.88503042e-01f, 2.04367340e-01f, 1.64489254e-01f,
  2.10630655e-01f, 1.30378023e-01f, 1.29589871e-01f, 1.17801353e-01f, 2.81846851e-01f, 9.67395827e-02f, 2.86851693e-02f, 1.06658258e-01f, 1.51796475e-01f, 2.51636595e-01f,
  2.31742784e-01f, -3.19504142e-01f, -1.34567395e-01f, -2.17879996e-01f, -7.03504160e-02f, -1.40890703e-01f, 2.53290296e-01f, 1.66104138e-01f, -2.75932103e-01f, -2.72772580e-01f,
  1.94968790e-01f, -1.64486393e-01f, 1.99926749e-01f, 9.13557187e-02f, 7.05590397e-02f, 3.07830781e-01f, 1.08888082e-01f, 9.82031822e-02f, -5.71530610e-02f, 6.68681413e-02f,
  1.80814967e-01f, -1.01720728e-01f, -2.54539847e-01f, -2.05408111e-01f, 3.69332321e-02f, 1.31708741e-01f, -2.81202402e-02f, 3.47892106e-01f, 9.25007090e-02f, 3.42169136e-01f,
  -9.03778076e-02f, 1.28894687e-01f, 1.29319921e-01f, 3.50772470e-01f, -1.05497807e-01f, 2.08770245e-01f, 2.40339041e-01f, -1.67445898e-01f, 1.41392842e-01f, 5.53258769e-02f,
  1.46837160e-01f, 6.47024512e-02f, -1.44879902e-02f, -2.56980807e-02f, 1.27374213e-02f, 2.46026963e-01f, -3.46614681e-02f, -5.35196625e-02f, 1.34112954e-01f, 2.13924929e-01f,
  1.90895006e-01f, 6.67867213e-02f, 2.08064571e-01f, -3.31322253e-02f, 1.45221055e-01f, 1.34021670e-01f, 1.50121182e-01f, -1.36756850e-02f, 2.70731986e-01f, 1.57975271e-01f,
  1.88404188e-01f, 1.51205048e-01f, 1.00495584e-01f, 1.02122903e-01f, 1.24202617e-01f, -1.51872754e-01f, -2.12997675e-01f, -2.88930744e-01f, 3.93359223e-03f, -1.17887326e-01f,
  6.99576735e-02f, 1.04197577e-01f, -1.81328237e-01f, -1.10690780e-01f, 3.91861871e-02f, -1.17497973e-01f, 4.61666167e-01f, 2.81034820e-02f, -1.95788071e-01f, 1.96367592e-01f,
  2.79426515e-01f, -7.35629573e-02f, -2.50593215e-01f, 1.49043999e-03f, 4.80091095e-01f, 1.31381124e-01f, -5.66851720e-02f, -1.74513653e-01f, 1.32237703e-01f, -3.62671763e-02f,
  1.09217353e-01f, 3.35790068e-01f, 4.57598222e-03f, 2.23569855e-01f, 1.90562755e-02f, -1.37469500e-01f, -6.48688450e-02f, 3.19809169e-01f, -2.20904388e-02f, 3.69855493e-01f,
  1.00729093e-02f, -1.38169095e-01f, 2.68109560e-01f, 8.67264792e-02f, 1.53190941e-01f, 1.17680822e-02f, 1.39654860e-01f, 2.09393129e-02f, 2.37381473e-01f, 3.71875651e-02f,
  1.33294851e-01f, 1.94397062e-01f, -1.34917453e-01f, 1.18517913e-02f, 1.48474023e-01f, 2.02101439e-01f, 7.64564723e-02f, -3.66192237e-02f, 2.49311969e-01f, 2.43108571e-01f,
  -5.41159809e-02f, 2.67903000e-01f, 1.24878168e-01f, -7.86834136e-02f, 1.93981007e-01f, 1.75494790e-01f, 1.73369303e-01f, 1.55913919e-01f, 1.14262916e-01f, 3.52194980e-02f,
  1.08413786e-01f, 7.77013972e-02f, -3.81162554e-01f, -1.22515380e-01f, -2.86684632e-01f, -1.03427604e-01f, 1.14129065e-03f, -2.33160987e-01f, -7.87516162e-02f, 1.88564718e-01f,
  -2.21968248e-01f, -1.23248935e-01f, 3.87817442e-01f, -5.49219139e-02f, -9.33071002e-02f, 2.73059934e-01f, 2.24567115e-01f, -3.91881734e-01f, -3.33932400e-01f, -1.81272715e-01f,
  -2.01780349e-01f, -1.09682620e-01f, 1.40968367e-01f, -1.98026404e-01f, -1.74837187e-01f, 4.62693535e-02f, 3.36490303e-01f, -2.29893215e-02f, 7.12012053e-02f, 1.24049619e-01f,
  -3.22889507e-01f, 6.79990277e-02f, 2.33631924e-01f, -5.30718789e-02f, 3.01133513e-01f, 1.69489846e-01f, 2.52595842e-02f, 2.14470252e-01f, 6.04351796e-03f, 3.26230340e-02f,
  5.66410795e-02f, 2.81585693e-01f, -1.72600880e-01f, 1.01567440e-01f, 2.38024399e-01f, -2.70963623e-03f, 1.21325128e-01f, -4.37527485e-02f, 5.93291260e-02f, -2.97187418e-02f,
  2.13445559e-01f, 1.49153680e-01f, -1.49222106e-01f, -1.88506115e-02f, 1.63329631e-01f, 2.36382964e-03f, 9.12287384e-02f, 9.68548506e-02f, -5.14073670e-02f, 2.18709428e-02f,
  7.59374499e-02f, 6.73062727e-02f, 6.98399916e-02f, 1.04116701e-01f, -1.25104219e-01f, 1.66008353e-01f, 4.77581203e-01f, -2.13069901e-01f, 1.61735624e-01f, 1.47817256e-02f,
  -2.14189902e-01f, 2.65973330e-01f, -9.59439650e-02f, 1.08742692e-01f, 1.13471374e-01f, -2.14527175e-02f, -3.62997860e-01f, -5.15421093e-01f, 2.30955079e-01f, -2.53587931e-01f,
  -1.85054049e-01f, 2.46068403e-01f, 8.91378671e-02f, 1.91313133e-01f, 3.85575056e-01f, -9.50046442e-03f, -2.83754796e-01f, 1.42891124e-01f, 2.31148139e-01f, 3.12164016e-02f,
  -1.59946486e-01f, 1.00616746e-01f, 1.65647358e-01f, -6.70703966e-03f, 2.88013816e-01f, 1.27885029e-01f, 1.79744273e-01f, 7.36265108e-02f, -1.98070854e-01f, -2.39331033e-02f,
  1.12714663e-01f, 1.11793898e-01f, 3.09237548e-05f, 2.28834793e-01f, 6.51496928e-03f, 1.90540314e-01f, 2.82341808e-01f, 2.18870770e-02f, 8.16617459e-02f, 3.61410193e-02f,
  1.77843571e-02f, 2.29647040e-01f, 2.39467457e-01f, 1.87256262e-01f, 3.24331135e-01f, 3.58606130e-02f, 1.41286358e-01f, 1.54493511e-01f, 7.87783861e-02f, 4.63606976e-03f,
  1.00807674e-01f, 2.06970036e-01f, 1.07771300e-01f, 1.55778617e-01f, 2.64748275e-01f, 1.94415137e-01f, 2.68246651e-01f, -2.92005599e-01f, -1.37999654e-01f, 4.12037671e-02f,
  -3.88397723e-02f, 7.24824565e-03f, 1.99522138e-01f, -1.69189855e-01f, -1.69163287e-01f, 8.40579644e-02f, -1.61424577e-01f, -2.07503945e-01f, -2.76364267e-01f, -1.22889757e-01f,
  -4.46864478e-02f, 1.38565242e-01f, -1.83760434e-01f, 2.50064820e-01f, -4.72971871e-02f, -1.43417493e-01f, -2.09566787e-01f, -3.22387815e-01f, -2.35338435e-01f, -2.53937870e-01f,
  -2.61975139e-01f, 4.25066464e-02f, 2.65331805e-01f, -4.18738984e-02f, 2.50031799e-01f, 8.17938671e-02f, 3.49157513e-03f, 3.29850852e-01f, 1.46166950e-01f, 1.13451041e-01f,
  -2.35262051e-01f, -8.63105878e-02f, -7.00326413e-02f, 1.45141900e-01f, 1.09787121e-01f, 2.94109702e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.16811134e-01f, 2.15495825e-01f, 2.11172849e-01f, 1.89738810e-01f, 3.41466516e-02f, 1.19345255e-01f, 6.79824725e-02f, 5.30460291e-03f, -6.35444298e-02f, 1.24093957e-01f,
  2.16333449e-01f, 1.50097087e-01f, 7.95768723e-02f, 8.49742666e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -8.37397575e-02f, 2.79709399e-02f, -1.03505226e-02f, -4.86843586e-02f, 1.65510774e-01f, 7.68791810e-02f, 9.81200561e-02f, 3.13540250e-02f, 1.37106150e-01f, 6.98441416e-02f,
  -4.99255508e-02f, 1.46712482e-01f, -1.42360002e-01f, -8.04612692e-03f, -5.84373362e-02f, -1.60426185e-01f, 5.78680225e-02f, 9.51780677e-02f, -3.27845179e-02f, 1.44184515e-01f,
  6.37900410e-03f, -3.60082649e-02f, 6.12645261e-02f, -1.20420389e-01f, 9.60473791e-02f, 4.49418277e-03f, -2.97101606e-02f, -1.93075016e-01f, 1.22816563e-01f, -1.28158167e-01f,
  4.78080474e-02f, -9.53424349e-02f, -3.24881785e-02f, -1.52230151e-02f, -4.71263416e-02f, -1.69976085e-01f, -6.57666475e-02f, 1.46694154e-01f, 7.57925063e-02f, -2.66311795e-01f,
  7.47495443e-02f, 2.29777858e-01f, 1.61390565e-02f, -5.95716648e-02f, 5.86370081e-02f, 1.98378190e-02f, 2.65354425e-01f, 2.16524769e-02f, -5.25667146e-02f, -4.44219187e-02f,
  1.24937579e-01f, 3.62461284e-02f, -1.70159772e-01f, 8.87091458e-02f, 1.03427224e-01f, 4.35177460e-02f, -2.80771375e-01f, 2.28797784e-04f, -3.05281579e-02f, 6.79618120e-02f,
  6.94530755e-02f, 2.08273088e-03f, -1.48125319e-02f, -6.99915141e-02f, 9.03989375e-02f, -2.36098021e-02f, -1.66886404e-01f, 1.30451275e-02f, -3.20970052e-04f, 1.39782913e-02f,
  5.17771579e-03f, 4.15414423e-02f, -2.09121518e-02f, 4.77657914e-02f, -6.30177110e-02f, -6.42100349e-02f, 2.57527754e-02f, -1.68691352e-01f, -4.39492520e-03f, 3.49953137e-02f,
  -1.13502666e-02f, 7.60387182e-02f, 6.71237856e-02f, 7.46182129e-02f, -9.20719951e-02f, -3.76209198e-03f, 1.51232600e-01f, 6.35066405e-02f, 1.70776382e-01f, -1.32704914e-01f,
  8.34308863e-02f, 8.05557147e-02f, -1.61029175e-01f, 1.44569084e-01f, 1.10004768e-01f, -3.98178287e-02f, 5.93384244e-02f, 2.96417437e-02f, 4.99343537e-02f, 7.13703111e-02f,
  9.87001434e-02f, -1.79143339e-01f, 1.66268751e-01f, 1.99826006e-02f, 1.66721586e-02f, -1.58725351e-01f, 1.08687416e-01f, -2.51997322e-01f, -2.41245642e-01f, -3.10933497e-03f,
  2.71530420e-01f, 1.48162827e-01f, 1.02522112e-01f, -9.16418359e-02f, -8.81315842e-02f, -1.51039466e-01f, 8.08823705e-02f, 1.64015859e-01f, -3.16705294e-02f, -1.53825045e-01f,
  1.12544624e-02f, 1.97002720e-02f, 7.36201555e-02f, 2.23628022e-02f, -4.91488799e-02f, 1.87068924e-01f, -6.72568381e-02f, 1.37207016e-01f, -1.45586412e-02f, 9.67863426e-02f,
  -1.27691805e-01f, -1.91048399e-01f, -9.41883400e-02f, -9.39426497e-02f, -1.20751157e-01f, 1.37429103e-01f, 1.05062267e-02f, 4.96476563e-03f, -1.25180304e-01f, 3.09946649e-02f,
  -1.30997896e-01f, -8.21970031e-02f, -3.64060216e-02f, -3.80375721e-02f, 6.46005049e-02f, 7.24453926e-02f, -9.53027084e-02f, -4.04504500e-02f, -9.57410112e-02f, 1.29753560e-01f,
  1.53994709e-01f, -8.34624283e-03f, 1.30443081e-01f, -9.87483561e-02f, -2.68017590e-01f, -5.54515123e-02f, -1.60747766e-02f, 2.47595876e-01f, 3.61619703e-03f, 3.14447619e-02f,
  7.21530765e-02f, 7.13734031e-02f, -7.44107664e-02f, -7.83002526e-02f, 9.93256271e-02f, 1.21500559e-01f, 1.77010342e-01f, -2.12705493e-01f, -4.99362126e-02f, 1.04132205e-01f,
  -2.18428984e-01f, 7.41715506e-02f, -1.13403380e-01f, 1.36124805e-01f, 8.10499266e-02f, 1.05016500e-01f, -5.25392331e-02f, -1.56227320e-01f, -4.50510755e-02f, -9.09825861e-02f,
  1.53627679e-01f, -1.52282164e-01f, -1.52811334e-01f, 1.11666948e-01f, -4.63940464e-02f, 5.99484108e-02f, -5.61692193e-02f, 9.19194743e-02f, 1.01992652e-01f, 1.37427077e-01f,
  6.51862985e-03f, 5.65945469e-02f, 4.35647070e-02f, -3.73715945e-02f, -1.57315657e-01f, -2.15830073e-01f, -1.07765049e-01f, -4.64771017e-02f, -9.88181084e-02f, 5.06453887e-02f,
  -1.23692065e-01f, 6.46090731e-02f, -1.13998689e-01f, 8.01081359e-02f, 2.71082073e-02f, -3.24577130e-02f, -6.88537443e-03f, -1.15007222e-01f, -3.58202718e-02f, 6.59477860e-02f,
  -7.88300950e-03f, 4.43630889e-02f, -1.01357296e-01f, 2.60299966e-02f, -2.63964268e-03f, -1.19079500e-02f, 3.30629125e-02f, 1.09781381e-02f, -3.96042690e-02f, 5.15221246e-02f,
  -1.44579917e-01f, -7.44262338e-02f, 5.40434942e-02f, -6.63729385e-02f, 1.54393166e-01f, 1.64356217e-01f, -7.23305345e-02f, 6.30550161e-02f, -1.77239761e-01f, 5.57010099e-02f,
  1.10067420e-01f, 1.29616946e-01f, 2.32674450e-01f, -2.48852313e-01f, 7.28161037e-02f, -1.11464262e-01f, 9.15801227e-02f, -1.32418334e-01f, -1.40182562e-02f, -7.38097578e-02f,
  1.62856400e-01f, 1.25044346e-01f, -1.13393418e-01f, -1.27796575e-01f, 6.82469551e-03f, -5.12542715e-03f, 5.64142056e-02f, 8.02884623e-02f, -2.41344050e-01f, -3.64925340e-03f,
  -9.71574336e-02f, -1.69200376e-01f, -1.52181610e-01f, 1.28643587e-01f, 1.58299237e-01f, -2.19288450e-02f, 2.86189854e-01f, 4.09006253e-02f, -1.36401474e-01f, 5.60453422e-02f,
  7.51845241e-02f, 1.36386111e-01f, 1.41358376e-01f, -1.55529842e-01f, -1.82228088e-01f, 5.50922342e-02f, -1.94793209e-01f, -7.73664266e-02f, 4.82967570e-02f, 6.87620342e-02f,
  1.87920019e-01f, 1.73103303e-01f, 4.99817282e-02f, -4.82667563e-03f, -1.46331079e-02f, 3.70498467e-03f, 9.45041701e-02f, -7.64233321e-02f, -1.51963145e-01f, -2.35819831e-01f,
  -1.71351150e-01f, -1.36270253e-02f, -2.08652318e-01f, 1.84561819e-01f, -1.40399903e-01f, 1.63476586e-01f, 6.14363067e-02f, 1.28647447e-01f, 4.01949771e-02f, -1.21285520e-01f,
  -1.06759459e-01f, 1.36935189e-01f, -6.67498559e-02f, -8.64130706e-02f, 3.32898796e-02f, 1.47389233e-01f, -1.88328400e-01f, 2.98317790e-01f, -2.56680012e-01f, -8.92184228e-02f,
  1.32754102e-01f, 3.84636857e-02f, 1.25960678e-01f, 1.15103042e-02f, -1.66101903e-01f, -6.06211014e-02f, -8.29322115e-02f, 3.21335979e-02f, 2.81059928e-02f, 1.35588467e-01f,
  -2.15159565e-01f, 3.87437940e-02f, -1.98831689e-02f, 1.47597983e-01f, 4.93844151e-02f, -6.38160557e-02f, 2.00225841e-02f, 7.98070207e-02f, 6.26358911e-02f, -2.51847468e-02f,
  6.34153280e-03f, -1.24561988e-01f, 6.50871992e-02f, -8.36252943e-02f, -4.48137447e-02f, 9.94931683e-02f, 6.90590292e-02f, 7.27457702e-02f, 1.78745966e-02f, 1.11144684e-01f,
  7.57536888e-02f, 8.90267417e-02f, 1.01869598e-01f, -8.96481797e-02f, 1.04315579e-01f, -1.35678157e-01f, 1.85174923e-02f, -8.03970620e-02f, -1.02994062e-01f, 2.49938313e-02f,
  -1.02147855e-01f, -4.17443104e-02f, 1.09983273e-02f, -1.67043179e-01f, -8.18898454e-02f, 1.25810569e-02f, -7.82461241e-02f, 1.94881350e-01f, -1.66268170e-01f, 9.32432637e-02f,
  1.84307903e-01f, 1.35362029e-01f, -1.25020405e-03f, 9.14748386e-02f, -2.73455121e-02f, 1.07354880e-03f, -9.45617780e-02f, -2.42570266e-02f, 1.65790945e-01f, -1.51950687e-01f,
  1.71099650e-03f, 2.33630821e-01f, -7.92744532e-02f, 1.92837551e-01f, 1.91226095e-01f, 6.57722279e-02f, -4.72435430e-02f, 6.78039789e-02f, 2.54120473e-02f, -1.86759502e-01f,
  -3.55570205e-02f, -3.89897600e-02f, 1.19252261e-02f, -3.29519100e-02f, -1.30754665e-01f, 5.99158928e-02f, -2.22183645e-01f, 1.46600664e-01f, -9.96099710e-02f, -6.69495314e-02f,
  -8.96042436e-02f, 1.35480434e-01f, 3.18548232e-02f, -4.59772125e-02f, 1.41605124e-01f, 2.65654363e-02f, 4.26403768e-02f, 7.63596073e-02f, -1.75235923e-02f, 7.40433633e-02f,
  -2.11054329e-02f, -1.68597087e-01f, 1.02020716e-02f, 3.41575197e-03f, -6.17556572e-02f, 1.06835878e-02f, 1.42216027e-01f, 3.92608270e-02f, 1.17576703e-01f, 1.98896348e-01f,
  -8.01929608e-02f, -6.28381595e-02f, -6.49245605e-02f, 5.60386293e-02f, -4.72087152e-02f, -9.43459645e-02f, 1.98655333e-02f, 2.14730818e-02f, -9.07663372e-04f, -3.18366662e-02f,
  9.27148014e-02f, 1.38853118e-01f, -1.75462186e-01f, 1.16381375e-02f, -1.68937761e-02f, 4.80700508e-02f, 1.85132757e-01f, 2.20690691e-03f, -2.47320496e-02f, 3.04899807e-03f,
  -4.61957641e-02f, -2.11501405e-01f, -4.88311313e-02f, -9.84199345e-04f, -8.41392111e-03f, -2.91445315e-01f, 1.77036941e-01f, -7.39110857e-02f, -1.86748728e-01f, -3.07532102e-01f,
  1.65980369e-01f, -1.10197864e-01f, 1.13726318e-01f, 6.05276115e-02f, -9.68220085e-02f, -2.37462297e-02f, -5.27174063e-02f, 1.19105257e-01f, 5.07766865e-02f, -2.21724063e-02f,
  -1.01684205e-01f, -4.75812927e-02f, 6.62156567e-02f, -8.35624263e-02f, -1.75984770e-01f, 1.19018584e-01f, -6.48170291e-03f, -5.75779341e-02f, 1.48598686e-01f, 8.47853050e-02f,
  -3.37688066e-02f, -1.86379880e-01f, -7.76064247e-02f, 3.77877876e-02f, -3.39537151e-02f, 7.14678913e-02f, -8.78625661e-02f, -1.20161347e-01f, 1.34611700e-03f, -7.53802881e-02f,
  1.23467743e-01f, -5.08467443e-02f, 1.00363463e-01f, 9.27626118e-02f, 1.74859613e-02f, 2.61347257e-02f, 3.33143808e-02f, -2.05055699e-02f, -1.46226659e-01f, -6.68206811e-02f,
  9.89018530e-02f, 1.12516612e-01f, -1.95617184e-01f, -1.90451398e-01f, -1.15104094e-01f, -8.75309482e-02f, 5.18815070e-02f, 1.11474611e-01f, -8.41005072e-02f, 8.50517005e-02f,
  -8.73284042e-02f, 8.95894412e-03f, 7.59028643e-02f, -8.38499442e-02f, -1.28374353e-01f, 2.00574115e-01f, -1.34684086e-01f, 7.84880593e-02f, 9.34360623e-02f, -6.52598664e-02f,
  9.49283168e-02f, -1.20248377e-01f, 3.09723075e-02f, -2.15324666e-02f, -1.79909840e-02f, 1.55547962e-01f, 3.91451083e-02f, 8.35586432e-03f, 3.69653478e-02f, -1.91722326e-02f,
  -1.98229015e-01f, -1.18786678e-01f, -6.85510635e-02f, 1.75234005e-01f, 1.21956892e-01f, -4.00953069e-02f, 1.26954257e-01f, 6.18655495e-02f, 1.41553372e-01f, -1.09318323e-01f,
  5.77218123e-02f, 7.56870164e-03f, 1.23790830e-01f, -3.57348919e-02f, -1.24980547e-01f, -3.81847657e-02f, -6.34094477e-02f, 9.29493271e-03f, -9.63132158e-02f, -1.35911673e-01f,
  8.83453116e-02f, 1.94082428e-02f, -5.57749346e-02f, 6.55706674e-02f, -3.85725237e-02f, 7.51798376e-02f, 1.44159496e-01f, 1.00569583e-01f, 1.25241160e-01f, -6.38466179e-02f,
  -1.32170901e-01f, 1.00033477e-01f, 1.80394743e-02f, 1.30924538e-01f, -5.56764565e-02f, -2.96649132e-02f, -1.22807615e-01f, 1.84447497e-01f, 1.41192451e-01f, 9.43980068e-02f,
  -1.34542122e-01f, -2.77991652e-01f, 1.36150673e-01f, 4.75135855e-02f, 2.27934751e-03f, 1.46163017e-01f, 3.38296816e-02f, 1.27687484e-01f, -2.07821846e-01f, -3.76513302e-02f,
  1.25437543e-01f, 3.67583707e-02f, 1.85017407e-01f, -1.46168143e-01f, 2.69454330e-01f, -6.06997199e-02f, -1.90880015e-01f, -2.46257316e-02f, 6.51535541e-02f, -2.02781968e-02f,
  1.55517623e-01f, 4.54149209e-02f, -8.29676241e-02f, 2.40361802e-02f, -1.27039894e-01f, 2.24702895e-01f, 9.58573446e-02f, 4.30300422e-02f, -1.08246736e-01f, -1.55332714e-01f,
  -1.24554195e-01f, 3.73044168e-03f, -1.20413706e-01f, 9.39494073e-02f, 4.87668626e-02f, 5.72921857e-02f, -1.49679750e-01f, -1.24863759e-01f, -7.65497535e-02f, -5.80385365e-02f,
  2.07383871e-01f, 8.56362507e-02f, 1.27925232e-01f, -1.82412788e-01f, -8.80042370e-03f, -3.42699140e-02f, -6.95657507e-02f, -5.15428893e-02f, -4.73500304e-02f, 5.38342670e-02f,
  7.97035620e-02f, 8.47004168e-03f, -4.88047069e-03f, -2.14012694e-02f, -9.87431183e-02f, 1.32787395e-02f, -9.27456319e-02f, 1.30235881e-01f, 1.08703740e-01f, -8.20175104e-04f,
  2.90782340e-02f, 9.92481112e-02f, -6.44918829e-02f, -1.13320313e-01f, 2.04982281e-01f, -2.40701035e-01f, -1.98556736e-01f, 1.69972241e-01f, -8.80001765e-03f, 1.20036595e-01f,
  9.82691050e-02f, -1.74910918e-01f, -9.74328965e-02f, 9.78974253e-02f, -4.05343547e-02f, 2.01215371e-01f, -3.38552222e-02f, -4.04856652e-02f, 1.66331545e-01f, 2.44993955e-01f,
  2.44401712e-02f, 1.55276299e-01f, -2.02904373e-01f, -1.88624859e-01f, 2.66534120e-01f, 1.74708277e-01f, 9.40268859e-02f, 1.60684943e-01f, -1.71964392e-01f, -2.46982742e-02f,
  3.37402411e-02f, 9.81736258e-02f, -3.23586129e-02f, -5.48273064e-02f, -2.14235157e-01f, -1.86646953e-01f, 9.05470643e-03f, -2.59069446e-02f, -3.39502767e-02f, 3.08710653e-02f,
  2.29861140e-01f, -2.57182177e-02f, -1.36423603e-01f, -1.69551983e-01f, 2.77222879e-02f, 7.32747689e-02f, 1.06817491e-01f, 4.00433913e-02f, -8.37819593e-04f, 5.92342243e-02f,
  9.79913324e-02f, 6.98750392e-02f, 9.12424251e-02f, -1.04113489e-01f, 4.23821211e-02f, 7.68485367e-02f, -5.78902550e-02f, -5.34720868e-02f, 5.50754331e-02f, 8.62152576e-02f,
  -3.90357673e-02f, -1.24229588e-01f, 1.22401431e-01f, 1.11552775e-01f, -1.15217276e-01f, 5.25248935e-03f, 1.37543321e-01f, -2.36590914e-02f, -2.04683468e-02f, -1.76637590e-01f,
  -6.41550571e-02f, -4.20998409e-02f, 5.68781532e-02f, 1.14924237e-01f, -3.70279066e-02f, 2.06228837e-01f, -6.88114464e-02f, 1.66114862e-03f, 6.92872778e-02f, 1.00147121e-01f,
  1.13379143e-01f, -2.24736363e-01f, 1.49365246e-01f, -8.70850831e-02f, -1.63330093e-01f, -1.23531083e-02f, 2.25194767e-01f, -1.12504698e-01f, 1.03510216e-01f, -7.89722353e-02f,
  -7.21936002e-02f, 8.48806649e-02f, -1.86504945e-02f, 2.07345113e-01f, 1.38145313e-01f, -1.29043177e-01f, 1.20980758e-02f, -4.64598313e-02f, 2.59407554e-02f, -1.37939304e-01f,
  4.76312414e-02f, 5.54390736e-02f, -4.23962623e-02f, -5.66526577e-02f, 1.87761694e-01f, 2.87258644e-02f, 1.42290547e-01f, 1.74361274e-01f, -2.32766852e-01f, -1.11751884e-01f,
  -1.56524718e-01f, 1.84317052e-01f, 3.85080394e-03f, -1.51138172e-01f, -6.41778857e-02f, -1.25517070e-01f, 1.03749879e-01f, -4.55178367e-03f, 4.23245504e-02f, -6.92724809e-02f,
  -2.81074317e-03f, -5.18339463e-02f, 1.13608994e-01f, -1.66953206e-01f, 1.45237789e-01f, -1.11929707e-01f, -1.22705027e-01f, -8.44679773e-03f, -4.28144820e-02f, -1.96258068e-01f,
  1.99564658e-02f, -3.84644903e-02f, -9.81935188e-02f, -6.23601824e-02f, -2.81844348e-01f, -1.52596891e-01f, -2.03742266e-01f, -5.45659810e-02f, -3.41691449e-02f, 1.75810963e-01f,
  1.99634835e-01f, 2.86461059e-02f, 1.11702923e-02f, 1.71002269e-01f, -7.07855448e-03f, -1.76736806e-02f, 9.27675422e-03f, -1.49806544e-01f, -2.29460701e-01f, -5.50961792e-02f,
  4.25903909e-02f, -5.59552237e-02f, -1.23209678e-01f, 8.70013610e-02f, 9.12857149e-03f, 1.13559663e-01f, 1.07605897e-01f, -4.39247899e-02f, -1.18511796e-01f, -1.07505456e-01f,
  1.44156486e-01f, 5.78480773e-02f, 5.44592515e-02f, -6.11681454e-02f, 4.68599126e-02f, 1.10922493e-02f, 8.83223116e-02f, 1.19543470e-01f, 9.80796441e-02f, 1.38800159e-01f,
  -8.15722421e-02f, 5.14103360e-02f, -1.66114345e-01f, 7.07764775e-02f, 6.76236749e-02f, 5.11319668e-04f, -4.08591516e-02f, -9.19388980e-02f, -2.93519739e-02f, -2.04152316e-01f,
  1.40555620e-01f, 1.01996794e-01f, 1.53718546e-01f, 1.42817736e-01f, 7.05997795e-02f, -5.45635037e-02f, 1.30872577e-01f, 9.03868824e-02f, 2.10668907e-01f, 4.08986099e-02f,
  -1.92435041e-01f, -3.85014489e-02f, 8.74345005e-02f, -3.50247212e-02f, 3.10839172e-02f, -1.24533995e-04f, -1.21225931e-01f, 1.96763456e-01f, 1.31751686e-01f, -1.55754954e-01f,
  7.78115029e-03f, -6.23639263e-02f, 1.35629684e-01f, 5.21954522e-02f, 4.58988510e-02f, -3.62848341e-01f, -2.97823437e-02f, 7.79158026e-02f, 3.07608228e-02f, 5.11288308e-02f,
  -8.85257944e-02f, -1.63435504e-01f, -1.11525327e-01f, -1.40621185e-01f, 1.04698934e-01f, 6.76411614e-02f, -1.48173064e-01f, -1.88312202e-03f, 4.14568484e-02f, -1.39209032e-02f,
  -5.50757088e-02f, -4.29598093e-02f, -1.28251091e-01f, -1.30220607e-01f, -9.74314213e-02f, -2.56748591e-03f, 3.70784923e-02f, 5.90350628e-02f, -1.37993574e-01f, 9.57931653e-02f,
  -3.32366899e-02f, 1.26085967e-01f, 8.81719813e-02f, 9.02795717e-02f, 6.89178929e-02f, 1.42384455e-01f, -3.82875674e-03f, -4.83653648e-03f, -1.54347988e-02f, 7.91100506e-03f,
  -1.10266492e-01f, 2.70536393e-02f, -6.64896891e-02f, -3.38866375e-02f, -1.23042509e-01f, 1.29049465e-01f, 1.38841167e-01f, -1.36939548e-02f, 2.23745666e-02f, 5.60287908e-02f,
  2.20196694e-02f, -2.78272964e-02f, 8.79726335e-02f, 1.14491358e-02f, -6.75593913e-02f, -1.12866111e-01f, 6.08586706e-02f, 1.86633334e-01f, 1.80948555e-01f, 2.33442754e-01f,
  -1.33052424e-01f, -5.84974512e-03f, 3.74974385e-02f, 4.65885587e-02f, 1.62516553e-02f, 2.13246614e-01f, -1.03840791e-01f, 1.87616989e-01f, -8.17044973e-02f, -2.90966511e-01f,
  -9.10501406e-02f, -7.71738216e-02f, 1.59714863e-01f, 1.58729516e-02f, 2.59053968e-02f, -1.72505185e-01f, 4.64323908e-02f, -2.39846125e-01f, 2.12408230e-01f, 2.28400882e-02f,
  5.48240058e-02f, -1.28629074e-01f, -1.37757301e-01f, 1.37495488e-01f, -1.16523288e-01f, 7.84504712e-02f, -2.95960121e-02f, -1.14950441e-01f, 8.12403485e-02f, -1.57692209e-01f,
  6.38581663e-02f, 5.51698953e-02f, -9.82544720e-02f, 1.42608956e-01f, -4.81085889e-02f, -1.66886149e-03f, 1.73391625e-01f, 5.72437569e-02f, -1.73805859e-02f, -8.47795531e-02f,
  9.11411736e-03f, -6.63392991e-02f, -1.26393408e-01f, -5.41346110e-02f, -1.17390446e-01f, -1.59060463e-01f, -3.64708304e-02f, 4.63664904e-02f, -3.94391492e-02f, 4.26716618e-02f,
  -4.50373814e-02f, 6.90574422e-02f, -1.06680915e-01f, -1.85044855e-02f, 4.55925427e-02f, 1.31125569e-01f, -1.01964802e-01f, -1.72597036e-01f, -1.28443211e-01f, 5.09499721e-02f,
  1.27580002e-01f, -6.77095633e-03f, -3.70317176e-02f, -1.04666337e-01f, 1.67560875e-02f, -1.28725186e-01f, 1.34669527e-01f, -4.63970238e-03f, -1.36785969e-01f, -1.22748934e-01f,
  2.09307581e-01f, -1.72052369e-01f, 1.93120182e-01f, -4.66740876e-02f, -1.48945646e-02f, -1.27261251e-01f, 1.92237467e-01f, 1.68579832e-01f, 9.48002338e-02f, -2.31337607e-01f,
  -1.95103586e-01f, 1.12546638e-01f, 2.99266070e-01f, 2.03375295e-01f, -1.15578510e-01f, -1.72389045e-01f, 1.15421414e-03f, -5.01400046e-03f, -1.06896833e-01f, 5.04605733e-02f,
  -2.78932843e-02f, 1.34394050e-01f, -1.39290005e-01f, -8.23557228e-02f, 1.91280663e-01f, 7.22952187e-02f, 1.17884785e-01f, -1.39043957e-01f, 3.63749489e-02f, 3.89288664e-02f,
  5.23969121e-02f, -9.08156931e-02f, -5.60428165e-02f, -4.18555830e-03f, 5.07712103e-02f, -1.91820398e-01f, 4.52123173e-02f, -2.27067638e-02f, -2.39309426e-02f, -1.18138164e-01f,
  3.40619273e-02f, -1.83482356e-02f, 3.68686579e-02f, -1.05817512e-01f, -1.00753576e-01f, 1.97784808e-02f, 1.15248896e-01f, 9.91700888e-02f, 8.14961419e-02f, 8.30738097e-02f,
  -1.72291622e-01f, -1.02341571e-03f, 1.40462950e-01f, 5.71239553e-02f, -5.62008237e-03f, 1.34348765e-01f, 2.25346684e-01f, -2.24325191e-02f, 6.35526255e-02f, -3.01314473e-01f,
  7.46932775e-02f, -1.25925168e-01f, 1.33540764e-01f, -1.56161329e-02f, 1.19968764e-02f, -8.48973403e-04f, -1.82053894e-01f, 1.91578224e-01f, 1.06894284e-01f, -1.08496800e-01f,
  1.20905071e-01f, -2.01279789e-01f, 3.11278015e-01f, -8.51427540e-02f, -5.50739542e-02f, -3.96684557e-02f, -9.46597159e-02f, -4.57381457e-02f, 1.77955940e-01f, -4.11111377e-02f,
  -1.79120317e-01f, 8.96973535e-02f, -3.76929380e-02f, 1.48984924e-01f, 1.18202873e-01f, -6.42930046e-02f, -2.77009439e-02f, 9.16680247e-02f, -8.30848292e-02f, -9.97998565e-02f,
  2.13886015e-02f, -4.02040035e-02f, 2.05032945e-01f, -8.15326571e-02f, 3.33353691e-02f, 1.54012352e-01f, -1.27448197e-02f, 1.16597772e-01f, -6.62327409e-02f, -1.02835358e-03f,
  1.18504696e-01f, 5.84153794e-02f, -9.85676274e-02f, 7.08180368e-02f, -2.88465805e-02f, -6.90277889e-02f, -8.29918087e-02f, 2.52221692e-02f, -1.88232437e-02f, -1.02349952e-01f,
  -1.85880199e-01f, 1.38296679e-01f, -1.60023242e-01f, 1.87082350e-01f, 1.05194755e-01f, 3.75938565e-02f, -1.96913749e-01f, 1.04285292e-02f, 2.66242065e-02f, 2.26597339e-02f,
  -4.25937660e-02f, 2.47807384e-01f, -1.17800258e-01f, 8.96898434e-02f, 1.85342014e-01f, -2.53035855e-02f, -5.54440245e-02f, 1.44454569e-01f, -1.37995213e-01f, 6.54850900e-02f,
  -1.26746759e-01f, -1.25416294e-01f, 5.58968894e-02f, -2.39960596e-01f, -9.93260369e-02f, 7.88664073e-02f, -2.00067520e-01f, -3.91369723e-02f, -3.82620469e-02f, -1.91498339e-01f,
  1.35187507e-01f, 1.97683144e-02f, -5.06321415e-02f, 7.33203348e-03f, -1.17700696e-01f, -1.13018163e-01f, -8.68527568e-05f, -4.62199301e-02f, -1.00998849e-01f, -5.12376912e-02f,
  9.19514969e-02f, 6.66449126e-03f, 8.14101696e-02f, 1.77194718e-02f, -1.27611369e-01f, 2.10226133e-01f, -1.16684772e-01f, 1.19448537e-02f, 7.42844492e-02f, -3.07032112e-02f,
  -7.47874081e-02f, 8.95447284e-02f, -1.84686348e-01f, -6.26450852e-02f, -2.43227527e-01f, 9.23733786e-02f, -1.14882730e-01f, 1.82422099e-03f, -1.20269716e-01f, -1.33147076e-01f,
  -1.35295587e-02f, -1.22816838e-01f, -5.13641164e-02f, 1.65812392e-02f, 2.89798174e-02f, -6.39516264e-02f, 9.37369931e-03f, -9.14996192e-02f, 6.16378561e-02f, 1.08158924e-01f,
  5.39004132e-02f, 8.23738240e-03f, -1.26057267e-01f, -2.47488663e-01f, -1.65857449e-02f, -1.17550261e-01f, 1.28930360e-01f, 5.03053367e-02f, -1.66973352e-01f, 5.33683822e-02f,
  8.30774941e-03f, 1.26505673e-01f, 1.52634621e-01f, -1.63757637e-01f, 1.21545114e-01f, 2.59793043e-01f, -5.48220798e-02f, 2.75033712e-01f, 1.55879527e-01f, -1.87072471e-01f,
  7.58102611e-02f, 1.75731108e-01f, -1.60868958e-01f, 1.06702797e-01f, -9.60352719e-02f, -3.31325755e-02f, 4.04947214e-02f, 1.05745398e-01f, -7.86262825e-02f, -1.00443184e-01f,
  5.64183556e-02f, -3.03108674e-02f, 3.02972086e-03f, 1.38292760e-01f, 2.62873560e-01f, -1.82288252e-02f, -5.92679493e-02f, 6.49411138e-03f, 8.16040337e-02f, -1.58083349e-01f,
  -3.01031712e-02f, -9.79532897e-02f, -1.67031169e-01f, 6.20164946e-02f, -7.47921392e-02f, 3.28861512e-02f, 3.08513623e-02f, -3.98951024e-02f, -2.75952704e-02f, 9.72452611e-02f,
  1.23153701e-01f, 9.21756551e-02f, 4.75917421e-02f, 2.14312386e-04f, -1.41583085e-01f, -1.05808437e-01f, -1.85163710e-02f, -1.43890947e-01f, -9.40391868e-02f, 8.84650648e-02f,
  4.07852568e-02f, 4.31119986e-02f, 3.84759810e-03f, 9.21439826e-02f, 8.64622295e-02f, -4.02802452e-02f, 1.36291413e-02f, 1.01571850e-01f, -1.83077216e-01f, -5.08935377e-02f,
  -4.67452556e-02f, 2.13837445e-01f, 9.04990286e-02f, 9.52235386e-02f, 5.74851595e-02f, 1.69996336e-01f, -1.94034636e-01f, -5.07838652e-02f, -8.58389214e-02f, -3.60313393e-02f,
  -9.74282250e-02f, -1.00610174e-01f, -1.09731175e-01f, 1.69384465e-01f, -1.94086701e-01f, 2.33376056e-01f, 2.80728698e-01f, 1.34137511e-01f, -1.44861042e-01f, -6.23062514e-02f,
  -2.52967458e-02f, -2.83839032e-02f, 9.51854512e-02f, -1.06074803e-01f, 5.65878376e-02f, -8.38529691e-02f, -6.53870627e-02f, 1.60882279e-01f, -9.95280501e-03f, 1.32400453e-01f,
  -5.36417328e-02f, -1.10637076e-01f, -1.47010669e-01f, 7.18289316e-02f, 1.96850896e-02f, 8.68095681e-02f, -1.58766866e-01f, 1.80324927e-01f, -8.51559788e-02f, 6.01330511e-02f,
  -1.44929543e-01f, 1.67953029e-01f, -1.88415617e-01f, -5.37556298e-02f, 2.28836481e-02f, -2.47542970e-02f, -1.79638490e-01f, 4.00327593e-02f, 2.64648870e-02f, -6.22740574e-02f,
  8.19151029e-02f, -9.54168886e-02f, 6.25915453e-02f, 1.31947622e-01f, -4.59357314e-02f, 2.32932772e-02f, -1.12319350e-01f, 1.13497175e-01f, -5.26559353e-02f, -1.17141828e-01f,
  -9.71556827e-03f, -2.18906149e-01f, -2.42198095e-01f, -2.23848239e-01f, 4.15258259e-02f, 2.64041513e-01f, -2.03675896e-01f, 7.15930685e-02f, -9.60136950e-02f, -5.41207194e-02f,
  8.21693018e-02f, 1.32174026e-02f, 6.81853443e-02f, -9.85592306e-02f, -1.02996945e-01f, -6.15262017e-02f, -8.14140588e-02f, 1.12824768e-01f, -3.39632988e-01f, -5.95727339e-02f,
  -1.13204658e-01f, 1.67397350e-01f, -1.04910899e-02f, 2.77807057e-01f, -2.42771655e-01f, 4.91296127e-02f, 1.44958645e-02f, 1.88124496e-02f, -4.67367657e-02f, -7.92319048e-03f,
  7.70948529e-02f, 8.56289640e-02f, 4.17283550e-03f, -1.29727423e-01f, 1.17766149e-01f, 9.55973342e-02f, 1.42310858e-01f, -3.67341377e-02f, -1.62956342e-01f, 1.92659721e-01f,
  1.13137446e-01f, 5.86805418e-02f, 1.43314498e-02f, 3.80745232e-02f, 3.40297818e-02f, -1.64131999e-01f, -1.25907153e-01f, 1.31162271e-01f, -6.75123334e-02f, -1.89192697e-01f,
  2.15881038e-02f, -8.19809437e-02f, -1.17450438e-01f, -5.17089814e-02f, 4.99014743e-02f, -2.64245365e-02f, 1.79252476e-01f, -6.45806566e-02f, 1.82164788e-01f, 1.46244273e-01f,
  1.67821273e-02f, -5.65154292e-02f, 2.98353825e-02f, 2.78907008e-02f, 2.09421180e-02f, 6.22738004e-02f, -1.50171831e-01f, -2.30764244e-02f, -1.40678838e-01f, 1.46112815e-02f,
  4.40705791e-02f, -1.68231294e-01f, -1.93560168e-01f, -2.22357586e-01f, 1.20537527e-01f, 6.50084391e-02f, 1.84659705e-01f, -2.00753689e-01f, 3.29421647e-02f, -2.37008221e-02f,
  5.63855991e-02f, 1.06551111e-01f, -1.09079301e-01f, -9.21602994e-02f, -2.56784502e-02f, 5.03864251e-02f, 2.00672299e-01f, 1.59449518e-01f, -2.44049788e-01f, -1.14766739e-01f,
  9.01872590e-02f, 4.08614539e-02f, 8.95594805e-02f, -6.56295791e-02f, -7.95836225e-02f, -7.27086961e-02f, -7.84763619e-02f, 1.36937574e-01f, 1.37506843e-01f, 8.27766806e-02f,
  -1.26046687e-03f, -3.16710956e-03f, -1.18801802e-01f, 7.65352175e-02f, 8.26805830e-02f, -2.99790315e-02f, -2.04039402e-02f, -6.31555244e-02f, 9.37950388e-02f, 7.02459887e-02f,
  1.45503625e-01f, -5.19746318e-02f, -1.55323222e-01f, 1.11611284e-01f, -5.49168997e-02f, -9.09881666e-02f, -8.41283649e-02f, 6.12483993e-02f, -5.12860455e-02f, 9.11793560e-02f,
  -1.69778080e-03f, -3.79674956e-02f, 8.55024755e-02f, 5.50072603e-02f, 7.35629648e-02f, -1.46924779e-01f, -7.31863976e-02f, 1.27893668e-02f, -9.34453085e-02f, 6.20228350e-02f,
  1.10451370e-01f, -3.85723934e-02f, 1.97833292e-02f, -2.90089905e-01f, -2.17370242e-01f, -4.62898165e-02f, 5.69341704e-02f, 6.67837709e-02f, 6.54201582e-02f, -1.66307837e-01f,
  -2.20460594e-01f, 1.55677542e-01f, -2.14710429e-01f, 1.48338586e-01f, -8.03661421e-02f, 2.96346545e-02f, 1.81128815e-01f, -7.62875080e-02f, 1.08229086e-01f, 5.01351245e-02f,
  -3.42120342e-02f, -1.99611429e-02f, 1.19325407e-01f, 1.42212257e-01f, -3.23920995e-02f, 3.38151716e-02f, -1.92382857e-01f, 1.07351951e-01f, 1.43928528e-01f, 2.49054320e-02f,
  -5.63562326e-02f, -3.90905775e-02f, -5.07854782e-02f, -8.87638517e-03f, 1.34428605e-01f, 2.48502549e-02f, -1.05755003e-02f, -1.66051537e-01f, 1.39169469e-01f, -1.03065558e-01f,
  -2.05997713e-02f, -1.04620062e-01f, 1.16920054e-01f, 1.23668887e-01f, 1.92315280e-01f, 4.27897461e-02f, 1.90792512e-02f, 7.83549771e-02f, 1.32383674e-01f, 2.42202152e-02f,
  1.15285367e-02f, -4.20417972e-02f, 1.51157722e-01f, -4.16871607e-02f, 5.19820675e-03f, -1.19617194e-01f, -7.83291757e-02f, 1.74104393e-01f, 7.67631978e-02f, 7.72587284e-02f,
  1.86700020e-02f, -9.85594988e-02f, -1.20772064e-01f, 6.70897216e-02f, 3.14496644e-02f, -1.87737033e-01f, 1.04669444e-01f, -8.80162492e-02f, -7.70900920e-02f, -3.18540335e-02f,
  2.73951460e-02f, -1.44788757e-01f, -4.49446205e-04f, 3.43536101e-02f, -2.08196476e-01f, -1.29093707e-01f, -4.68717963e-02f, -5.70049463e-03f, -1.36456592e-02f, 2.25472957e-01f,
  -6.59317300e-02f, 1.09856188e-01f, 2.25565955e-01f, 1.46295115e-01f, 6.11182973e-02f, 1.04671039e-01f, -6.43268810e-04f, -3.82891148e-02f, -1.54160494e-02f, -1.00961961e-01f,
  -1.32080451e-01f, -9.72917080e-02f, 5.96962832e-02f, 1.15170144e-01f, -2.29684040e-01f, -1.08451165e-01f, 1.31710202e-01f, 1.02796197e-01f, 1.92853078e-01f, 1.39149293e-01f,
  5.13219554e-03f, -8.48143324e-02f, 1.27302513e-01f, -1.06829442e-01f, -1.88909136e-02f, -1.73021350e-02f, 2.09064409e-01f, 1.56884953e-01f, 1.59373477e-01f, -4.15518545e-02f,
  2.94771474e-02f, 1.40888125e-01f, -1.96387968e-03f, 1.05086364e-01f, 3.66174914e-02f, 5.27804717e-02f, 7.01653734e-02f, -1.62337974e-01f, 1.71069913e-02f, -6.82546571e-02f,
  -1.97693333e-01f, 1.78891346e-01f, -4.60049212e-02f, 1.23521097e-01f, -3.74259613e-03f, -1.42701060e-01f, -5.57185523e-02f, 1.49494648e-01f, 1.36074200e-01f, 6.91422746e-02f,
  -1.63500905e-01f, -4.99668121e-02f, -7.15293512e-02f, 1.25865027e-01f, 4.71939258e-02f, 1.71481699e-01f, -1.47278428e-01f, 7.19852373e-02f, -1.65062621e-01f, 1.18622281e-01f,
  1.67789742e-01f, -2.31005140e-02f, 1.74478337e-01f, -4.31442373e-02f, 8.16955697e-03f, 5.83752990e-02f, -3.34731489e-02f, 2.65537258e-02f, 7.73617849e-02f, 1.06093928e-01f,
  7.17568472e-02f, 5.92923053e-02f, -4.78920713e-02f, -9.59363878e-02f, 5.82426116e-02f, 1.55998841e-01f, 5.90158850e-02f, 1.29215479e-01f, -1.32118836e-01f, -5.45950457e-02f,
  -5.01942374e-02f, -1.08458854e-01f, -3.30669917e-02f, 1.43868804e-01f, 2.68630367e-02f, -9.35211778e-02f, -3.18927243e-02f, 4.83715460e-02f, -2.13560183e-02f, -1.09752692e-01f,
  -1.89722076e-01f, -1.53543562e-01f, -2.52208789e-03f, 1.30124703e-01f, 2.91313548e-02f, -1.44992257e-02f, -1.89982265e-01f, 1.43391220e-02f, 8.97851810e-02f, -1.18141107e-01f,
  1.35382041e-01f, -3.49344686e-02f, 2.32750289e-02f, 1.91708542e-02f, -4.29082029e-02f, -3.10271159e-02f, 7.93544855e-03f, -8.32531229e-02f, -9.12765712e-02f, 2.12166961e-02f,
  -1.33857489e-01f, 6.51275963e-02f, -1.97995842e-01f, 1.24967925e-01f, 6.06030934e-02f, 2.41300002e-01f, -1.25449598e-01f, 6.77293073e-03f, 1.06826037e-01f, 8.32254738e-02f,
  -7.32939765e-02f, -6.32170886e-02f, 1.37324303e-01f, 2.37546429e-01f, 2.52576731e-02f, 5.85788600e-02f, -1.46993250e-01f, 2.94545740e-01f, -9.93574932e-02f, 1.29702643e-01f,
  2.36927733e-01f, 1.33768514e-01f, -1.36339307e-01f, 1.24181353e-01f, -1.70492515e-01f, 9.23973471e-02f, 4.30494882e-02f, -1.20109506e-01f, -1.21388137e-01f, -1.55146867e-01f,
  -1.64077401e-01f, 5.77693200e-03f, 8.80051926e-02f, 1.00608200e-01f, -3.90285887e-02f, 1.39325978e-02f, 6.91792816e-02f, -1.80742536e-02f, 6.48331195e-02f, 1.66949987e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  4.79817763e-02f, 2.24964395e-01f, 1.33387879e-01f, 2.08651856e-01f, 8.37030038e-02f, 2.71060318e-01f, 2.53215879e-01f, 2.50260502e-01f, 1.60176307e-02f, 2.51520395e-01f,
  1.32212520e-01f, 2.46279314e-02f, -1.87032983e-01f, 2.78839588e-01f, 2.91783866e-02f, 1.53520346e-01f, 5.23390658e-02f, 4.90285158e-02f, -1.02835052e-01f, 2.84464478e-01f,
  2.30689555e-01f, 8.97042304e-02f, -2.21745461e-01f, -5.19288220e-02f, 1.88716426e-01f, 2.97421832e-02f, -4.73574623e-02f, 1.61246285e-01f, -3.13159406e-01f, 2.50942916e-01f,
  4.21584666e-01f, -2.50800222e-01f, 5.17127924e-02f, 7.27738813e-02f, 1.24700569e-01f, 4.24895585e-02f, 2.75995672e-01f, -5.16073227e-01f, 1.47362322e-01f, -6.06142819e-01f,
  -1.14874385e-01f, 2.38809302e-01f, -1.95555732e-01f, -2.17244983e-01f, 1.98133752e-01f, -4.06065434e-01f, 2.56667882e-01f, 2.91008204e-01f, -1.33619964e-01f, -3.31029207e-01f,
  2.46667843e-02f, -5.51273078e-02f, 2.76050538e-01f, 2.13461012e-01f, 9.02425125e-03f, 4.82881516e-02f, -2.99620658e-01f, 2.85598516e-01f, 1.98451355e-01f, 2.69326299e-01f,
  5.36147729e-02f, 2.28401855e-01f, -6.71198368e-01f, 2.44704783e-01f, -1.25742927e-01f, -8.24697465e-02f, -3.03332917e-02f, -3.96675291e-03f, 3.53296787e-01f, 7.34009445e-02f,
  4.10485357e-01f, -3.26953903e-02f, 1.98968336e-01f, 4.49009016e-02f, 2.31482580e-01f, 1.72950104e-01f, -1.50496900e-01f, 8.37930962e-02f, -5.13554923e-02f, 1.10896319e-01f,
  1.87071964e-01f, -3.23815420e-02f, 1.52758449e-01f, -3.32771912e-02f, -8.79205912e-02f, -4.06417809e-02f, 4.78482693e-02f, -1.34770334e-01f, -3.71547192e-02f, 1.49739042e-01f,
  2.88664281e-01f, -9.11990926e-02f, 4.91354913e-02f, -5.74973166e-01f, 3.67357850e-01f, -5.71549833e-02f, 2.58118153e-01f, 2.72225529e-01f, 4.36470844e-02f, -1.93791449e-01f,
  -1.83674887e-01f, -1.11076541e-01f, 1.47306129e-01f, -2.10978612e-01f, -2.92352319e-01f, -8.68190527e-02f, 3.30360115e-01f, 2.47463852e-01f, 2.95336366e-01f, -5.51473722e-02f,
  -2.94674665e-01f, -3.10924411e-01f, 3.33609074e-01f, 9.67376530e-02f, 1.43296465e-01f, 1.97718069e-01f, 2.01498777e-01f, 8.80562961e-02f, 5.02208352e-01f, 4.55119997e-01f,
  -2.26301193e-01f, 1.04484171e-01f, -2.72769481e-01f, -3.67675498e-02f, 7.13160932e-02f, 2.65229106e-01f, 8.71938169e-02f, -3.77147347e-02f, 1.92858979e-01f, -1.21486466e-02f,
  1.80431336e-01f, 1.31715879e-01f, -1.31949559e-01f, 1.16307683e-01f, -5.01099601e-02f, 1.63059413e-01f, 1.51314154e-01f, 2.85847150e-02f, 8.01489800e-02f, -1.57686085e-01f,
  -2.34735593e-01f, -7.97203258e-02f, -4.21567708e-02f, 2.37601548e-01f, -1.80037301e-02f, 1.23941034e-01f, 1.12226576e-01f, 2.89883167e-01f, 4.66970317e-02f, -4.76797633e-02f,
  9.42120925e-02f, 6.80388212e-02f, 7.01059327e-02f, 2.39320382e-01f, -7.31131434e-02f, 3.54608297e-01f, -2.90751696e-01f, 4.22704667e-01f, 3.08106601e-01f, -2.11210683e-01f,
  1.16734520e-01f, -1.72637090e-01f, -9.09526050e-02f, 2.65363783e-01f, 2.64648527e-01f, -3.02127779e-01f, 1.62731215e-01f, -1.55375198e-01f, -3.19924280e-02f, 7.14748725e-02f,
  -1.63734183e-01f, -3.36673439e-01f, 2.89289653e-01f, -2.43223757e-01f, 3.73587430e-01f, 2.83720821e-01f, -1.61210269e-01f, -1.93394959e-01f, 8.62631053e-02f, 5.77237085e-02f,
  2.17466116e-01f, 1.98249742e-01f, -2.79993743e-01f, -3.58815700e-01f, 6.32209256e-02f, 3.54835898e-01f, 2.35464796e-01f, 2.84778833e-01f, 1.16166048e-01f, 1.84442878e-01f,
  -2.21677527e-01f, 3.95678401e-01f, 2.09080115e-01f, 2.34880149e-02f, 6.15062658e-03f, 5.03494851e-02f, -1.57855913e-01f, -4.86978702e-02f, -1.06089182e-01f, 1.17481381e-01f,
  -1.28723577e-01f, 8.11682418e-02f, -1.48376718e-01f, -5.03832474e-02f, 2.76811957e-01f, 9.82822850e-02f, 7.53018036e-02f, 4.81509827e-02f, -7.83375502e-02f, -1.37377884e-02f,
  -1.82999432e-01f, -1.45449445e-01f, -6.22910857e-02f, 2.42445335e-01f, 2.50762224e-01f, 8.58540386e-02f, -2.75115192e-01f, -1.44339666e-01f, -2.45432258e-01f, -4.65602539e-02f,
  3.10809463e-01f, 4.96960469e-02f, -5.44601738e-01f, 3.62429693e-02f, 1.43741578e-01f, 1.24517635e-01f, -1.05360329e-01f, 1.29332021e-01f, -1.84871405e-01f, 2.80037135e-01f,
  -3.64500344e-01f, 4.82361913e-01f, 1.98345128e-02f, -2.83411443e-01f, 4.34335880e-02f, -7.03340583e-03f, -2.35134691e-01f, 4.27827656e-01f, -4.54932958e-01f, -2.40979671e-01f,
  -5.35840392e-02f, 3.63367140e-01f, 1.48399800e-01f, 3.84158552e-01f, 3.34418789e-02f, 2.86207557e-01f, 2.73450732e-01f, 8.52165297e-02f, 3.75796586e-01f, -3.54809403e-01f,
  -8.91946405e-02f, 1.11528218e-01f, 4.58554551e-02f, -1.23560883e-01f, 6.34051144e-01f, 2.59018362e-01f, -8.54522642e-03f, -6.47964478e-02f, -3.06010135e-02f, 2.67944634e-01f,
  -1.25399008e-01f, 3.74349579e-02f, -5.64353429e-02f, 1.74465686e-01f, -9.48157236e-02f, 2.09914610e-01f, -3.26505825e-02f, -1.70164683e-03f, 7.48558939e-02f, 1.59226134e-01f,
  2.14996845e-01f, 1.34003580e-01f, -1.31529912e-01f, 1.94013700e-01f, -8.55658054e-02f, 5.21458462e-02f, 1.67292297e-01f, 7.49872476e-02f, 1.86437950e-01f, 2.44938403e-01f,
  2.54043072e-01f, -6.42180145e-02f, 1.55948207e-01f, 2.84739941e-01f, -3.04240108e-01f, 2.26432398e-01f, -1.47055417e-01f, -4.70960401e-02f, 7.39985406e-02f, 2.62217730e-01f,
  -2.43259594e-01f, 3.21344227e-01f, 8.55652019e-02f, -1.90775245e-01f, -9.36096534e-02f, 8.47685859e-02f, 2.60682851e-01f, -2.13100329e-01f, -3.65929268e-02f, -2.37198919e-01f,
  -3.17218870e-01f, -1.55410022e-01f, 2.98833072e-01f, 1.31126851e-01f, 1.81131586e-01f, 6.61601573e-02f, -2.70673931e-01f, 2.71089256e-01f, 7.83481747e-02f, 2.42768258e-01f,
  -1.35645252e-02f, -3.56364608e-01f, 2.12172106e-01f, -2.31894404e-01f, 1.08979210e-01f, -6.68812096e-02f, -9.56102684e-02f, 2.11691082e-01f, -1.89664736e-01f, 3.22172493e-01f,
  -1.21928528e-01f, 2.17051376e-02f, 6.71754479e-02f, -5.80894426e-02f, 1.66459337e-01f, -4.11335938e-02f, 5.52236363e-02f, 3.05745810e-01f, 1.48923635e-01f, 1.77410677e-01f,
  -5.92653342e-02f, 2.09247526e-02f, 2.30727978e-02f, -9.03647467e-02f, -7.00451899e-03f, -6.02239221e-02f, 7.81877637e-02f, 3.75776589e-02f, 2.03594968e-01f, 1.92105751e-02f,
  -1.06272615e-01f, -1.69567689e-01f, 1.65018782e-01f, 2.18669400e-01f, 3.48216146e-02f, 2.90002823e-01f, -1.84239507e-01f, -4.58798558e-01f, 3.12848091e-01f, -1.21895172e-01f,
  -3.53988588e-01f, -1.76506713e-01f, -2.01834053e-01f, 1.92226819e-03f, 1.89915404e-01f, -2.73853153e-01f, 5.65228797e-02f, 2.62390912e-01f, -3.81653786e-01f, 3.00804049e-01f,
  -3.98593098e-02f, 2.50564933e-01f, -1.85997516e-01f, -9.48102847e-02f, 2.46892571e-01f, 3.66424888e-01f, -1.66445956e-01f, 3.28210145e-02f, -3.55669618e-01f, 3.83210838e-01f,
  4.23487842e-01f, 2.09718615e-01f, -1.54572949e-01f, 4.19680141e-02f, 3.58976722e-01f, 4.36221749e-01f, 4.47793230e-02f, -2.36121923e-01f, 1.73342630e-01f, 2.64559031e-01f,
  2.49855280e-01f, -9.89797711e-02f, 4.19171244e-01f, 8.73167720e-03f, 3.95187974e-01f, 8.34967569e-02f, -1.11638844e-01f, -9.37674418e-02f, 3.76766354e-01f, -8.58485252e-02f,
  1.87397212e-01f, 1.92899615e-01f, 8.09890628e-02f, 2.44941507e-02f, 8.81799385e-02f, 2.01621979e-01f, 1.74101681e-01f, -1.84527174e-01f, -3.18557513e-03f, -1.87671691e-01f,
  5.90263270e-02f, 1.51808551e-02f, -1.81943566e-01f, 2.79878248e-02f, -1.52754962e-01f, 1.38928145e-01f, -3.59558389e-02f, -1.52083591e-01f, 1.31124139e-01f, 1.90006420e-01f,
  -3.64681125e-01f, -3.40283871e-01f, 2.62102097e-01f, -2.92557538e-01f, -1.08338930e-01f, -1.40646428e-01f, -4.71998960e-01f, -2.45380417e-01f, 3.94116729e-01f, -3.58960271e-01f,
  1.16043590e-01f, 1.97129130e-01f, -2.36391604e-01f, -7.95338862e-03f, 7.06779510e-02f, 4.33999300e-01f, -1.34337962e-01f, -1.71902448e-01f, -2.08306268e-01f, 2.51767129e-01f,
  2.05364466e-01f, 2.42181093e-01f, -3.72767001e-01f, 1.36031419e-01f, 4.01142478e-01f, -6.61302358e-02f, -4.42393839e-01f, 9.96645018e-02f, 1.80559561e-01f, 2.07274362e-01f,
  -1.12369575e-01f, -1.51446924e-01f, 2.17057958e-01f, 4.94676501e-01f, 5.83850443e-01f, -1.27318889e-01f, 4.66325164e-01f, 6.40775561e-02f, -2.34040037e-01f, -1.71574205e-02f,
  -5.66469096e-02f, 3.11571695e-02f, 1.17768705e-01f, 2.60876387e-01f, 1.88570783e-01f, -3.95732224e-02f, 6.09597899e-02f, 1.09375037e-01f, 8.28351304e-02f, 4.53006551e-02f,
  5.11319041e-02f, 3.05936247e-01f, -4.15435210e-02f, 4.78249341e-02f, 1.38371244e-01f, -3.77787240e-02f, -9.79617611e-02f, 7.06450418e-02f, 2.39573047e-01f, 6.35438710e-02f,
  5.54192849e-02f, 1.70054808e-01f, 2.21085310e-01f, 2.29298204e-01f, 3.79426926e-01f, 2.67147943e-02f, -1.01162314e-01f, -1.78137884e-01f, -5.44223115e-02f, -2.80120503e-02f,
  3.12443793e-01f, 3.25740427e-01f, -1.12536572e-01f, 2.93796062e-02f, -1.46718025e-01f, -3.65874439e-01f, 1.66263148e-01f, -1.89508423e-01f, 1.54942364e-01f, -3.14605623e-01f,
  2.85338968e-01f, 1.42492086e-01f, -2.38683298e-02f, -3.98016453e-01f, -3.71753089e-02f, -1.96118146e-01f, 1.99879050e-01f, 1.18803352e-01f, -2.86599081e-02f, 2.08706126e-01f,
  4.48090971e-01f, 9.47917551e-02f, 4.01042163e-01f, 1.54177338e-01f, -2.25991592e-01f, 5.78506067e-02f, -1.48315802e-02f, -5.17879054e-02f, -9.71837621e-03f, 1.81818128e-01f,
  -3.90586674e-01f, 3.79977524e-02f, -5.26019521e-02f, 1.52663678e-01f, -5.81259280e-02f, 3.20168644e-01f, 2.32308283e-01f, 2.86842287e-01f, 9.47803557e-02f, 1.32553995e-01f,
  5.02256081e-02f, -8.76324847e-02f, 2.14866519e-01f, -3.74092013e-02f, 1.71462253e-01f, 9.15768370e-02f, 2.10578382e-01f, 2.51637280e-01f, 9.04306322e-02f, 1.39720604e-01f,
  -4.08314951e-02f, 5.52919656e-02f, 1.43528089e-01f, 9.28299502e-02f, -5.87001536e-03f, -8.96287858e-02f, 3.60316068e-01f, -1.13856770e-01f, -1.36259615e-01f, -1.40546769e-01f,
  -7.25941807e-02f, 1.70682386e-01f, 6.30813763e-02f, -1.68237060e-01f, -4.14347768e-01f, -3.15592855e-01f, 3.72970968e-01f, -2.71158308e-01f, 3.74234051e-01f, -2.72758275e-01f,
  -2.52318680e-01f, -2.38269389e-01f, 3.77562717e-02f, 2.08185747e-01f, -2.48901427e-01f, -2.24270433e-01f, -1.82441935e-01f, -8.37772563e-02f, 3.09096277e-01f, 3.24403435e-01f,
  -3.57889056e-01f, -2.44635224e-01f, 7.53736123e-02f, -1.28655788e-02f, -1.69169649e-01f, 2.56379098e-01f, -6.23454303e-02f, -5.50985448e-02f, -2.46896651e-02f, -9.71052051e-02f,
  4.26747084e-01f, 4.03621405e-01f, 3.51887167e-01f, 6.68536723e-02f, -3.04115802e-01f, 1.57802060e-01f, -1.05180532e-01f, 6.49394989e-02f, 3.30424798e-03f, -1.06801232e-02f,
  -2.63685077e-01f, -6.09887578e-02f, -1.33701995e-01f, 3.68133634e-02f, 6.00036308e-02f, 1.20635502e-01f, 1.71494093e-02f, -7.43325725e-02f, 1.19747564e-01f, 1.00843735e-01f,
  -2.01109216e-01f, 2.65454650e-01f, 1.16665773e-01f, 7.86273405e-02f, 1.47639096e-01f, -1.78030223e-01f, 8.55790824e-02f, 2.24703968e-01f, -1.33585364e-01f, 1.60369545e-01f,
  -1.03072278e-01f, -2.35136777e-01f, -1.59895524e-01f, 3.02727461e-01f, -1.02288261e-01f, 1.90039396e-01f, 1.39775068e-01f, -1.15978509e-01f, 5.37332654e-01f, 3.24657857e-01f,
  -2.73541480e-01f, 3.82045895e-01f, 4.25700806e-02f, -7.46174827e-02f, 1.33500099e-01f, 1.32679686e-01f, -2.81769067e-01f, -2.18146577e-01f, 3.18494551e-02f, 1.32262811e-01f,
  -1.08362928e-01f, -9.27032717e-03f, -4.64739949e-01f, -4.30898964e-01f, 2.52859205e-01f, -1.25382826e-01f, 1.57753929e-01f, 2.09214404e-01f, 5.77791393e-01f, -4.09342311e-02f,
  5.15019633e-02f, 3.96335833e-02f, 5.45699954e-01f, 4.56566602e-01f, -1.06448404e-01f, -1.03677757e-01f, -5.58227785e-02f, 2.57494122e-01f, 3.63632977e-01f, 1.81307703e-01f,
  1.03381403e-01f, -1.26823470e-01f, 1.18175223e-01f, 7.48379976e-02f, 1.54310584e-01f, -1.39401659e-01f, -1.98859889e-02f, -4.13510241e-02f, -1.00577861e-01f, 9.97274416e-04f,
  1.45779967e-01f, 1.98247656e-01f, 1.35244802e-01f, 1.61263362e-01f, -1.30186016e-02f, 1.10473417e-01f, 7.22153559e-02f, 8.46147165e-02f, -1.75956070e-01f, -8.21572915e-02f,
  1.07481793e-01f, 1.08413771e-02f, 2.52358824e-01f, 3.02901357e-01f, 9.50445607e-02f, -8.47330466e-02f, 3.48900884e-01f, 1.44939078e-02f, -6.05978593e-02f, -2.69295573e-01f,
  -1.03217311e-01f, -6.19948432e-02f, 1.74360007e-01f, 2.22192809e-01f, -3.33525762e-02f, 3.12327713e-01f, -5.53304590e-02f, 4.51888554e-02f, 1.53211877e-01f, 2.91970611e-01f,
  2.77788550e-01f, -5.70769966e-01f, 3.00193101e-01f, -3.84241879e-01f, -3.06049764e-01f, -6.92387372e-02f, 1.34469539e-01f, -1.88988984e-01f, 1.10990867e-01f, 3.27912718e-01f,
  -2.97672860e-02f, 4.56060737e-01f, 1.06938206e-01f, 4.36908782e-01f, 2.26781636e-01f, -1.92349091e-01f, 3.92130286e-01f, -2.65966743e-01f, -9.36127361e-03f, 6.56936243e-02f,
  5.65847531e-02f, 6.19889759e-02f, 2.44073972e-01f, 7.86619037e-02f, -7.74565563e-02f, 9.79235247e-02f, 4.16364595e-02f, 2.52179742e-01f, -1.41180577e-02f, 3.12085778e-01f,
  2.77598917e-01f, 2.54413337e-01f, 2.34948233e-01f, 1.99812442e-01f, -2.88771633e-02f, 1.27818629e-01f, 5.00656813e-02f, 3.65497887e-01f, 2.05199942e-01f, -1.94826230e-01f,
  2.15235446e-02f, -1.79103211e-01f, -3.65974591e-03f, 3.18889737e-01f, 2.62012541e-01f, 1.91242516e-01f, -8.22202563e-02f, -1.94884371e-02f, 8.18627104e-02f, 3.76211345e-01f,
  2.37757608e-01f, -9.89733115e-02f, -1.66791499e-01f, -1.83169395e-01f, 7.64268935e-02f, 6.13197535e-02f, 5.82265146e-02f, 2.40578473e-01f, 1.06838033e-01f, 8.25327337e-02f,
  1.69144254e-02f, -3.89524698e-01f, 4.26258184e-02f, -2.60854214e-01f, -4.33784313e-02f, 1.98606253e-01f, 4.25248966e-02f, 2.11786360e-01f, 3.79903704e-01f, -1.93592206e-01f,
  -4.32427824e-02f, -4.48691659e-03f, -2.29230717e-01f, 1.55183272e-02f, 2.19656080e-01f, -8.16928446e-02f, 4.01415706e-01f, 3.15920189e-02f, 4.08337921e-01f, 2.08893552e-01f,
  -2.71220028e-01f, 4.31170672e-01f, -6.35908470e-02f, 2.50210375e-01f, 2.83464134e-01f, 4.42129701e-01f, -5.56208313e-01f, -5.18108495e-02f, -4.48742248e-02f, 2.61909992e-01f,
  -2.83152014e-02f, 1.42632812e-01f, -1.88935652e-01f, 1.46676302e-01f, 1.18979089e-01f, 4.78687212e-02f, -1.40270829e-01f, 9.75511149e-02f, 8.01085010e-02f, -2.35097036e-02f,
  2.01020569e-01f, 2.20568359e-01f, 1.43496573e-01f, 1.62962511e-01f, 1.05378017e-01f, -9.49130654e-02f, -2.83228662e-02f, -2.10103884e-01f, 2.86559790e-01f, 2.60956258e-01f,
  -3.61054689e-02f, 1.01765484e-01f, 1.98081322e-02f, -2.25848094e-01f, 1.22484460e-01f, 9.97489095e-02f, 1.40652731e-01f, -1.45743355e-01f, -1.16292059e-01f, -1.75156742e-01f,
  2.74459004e-01f, 2.91039705e-01f, -4.74641882e-02f, 2.14662746e-01f, -1.99847013e-01f, -2.17092425e-01f, 2.73842365e-02f, 1.62406400e-01f, -1.22852772e-01f, -3.19922745e-01f,
  -3.36247720e-02f, 8.52237865e-02f, -2.26970062e-01f, -2.00138599e-01f, -3.31890672e-01f, -2.45889068e-01f, 1.30580693e-01f, 5.30275069e-02f, -2.76529253e-03f, 2.84170479e-01f,
  4.80177283e-01f, 1.55704290e-01f, 1.41710386e-01f, 1.32427916e-01f, 2.83461869e-01f, 2.62621969e-01f, -1.12098657e-01f, -8.29072669e-03f, -7.66590983e-02f, 1.91952631e-01f,
  -1.90336853e-01f, -3.71165462e-02f, 1.74998268e-01f, -1.03136748e-01f, 9.44708288e-02f, 2.79066116e-01f, -4.39090794e-03f, 1.97205037e-01f, 3.26628201e-02f, -7.93686323e-03f,
  1.03354663e-01f, 1.68799907e-01f, 1.36908814e-01f, 5.56529462e-02f, -5.69144860e-02f, 1.45621318e-03f, 2.27299541e-01f, 8.19161162e-02f, -1.52839005e-01f, 2.48742290e-02f,
  -3.12007844e-01f, 1.99254513e-01f, -1.06223263e-01f, -1.18015468e-01f, 2.08643734e-01f, 1.35590643e-01f, 1.29867435e-01f, 3.25497589e-03f, 2.39041969e-01f, 1.06463842e-01f,
  -1.73240289e-01f, -8.08388516e-02f, 9.08968784e-03f, -2.39465475e-01f, 7.81472549e-02f, 1.29284784e-01f, -1.01223491e-01f, 3.25674862e-01f, 1.72052145e-01f, -1.49970740e-01f,
  1.27334232e-02f, 3.03688031e-02f, 4.21913475e-01f, -4.23476994e-01f, 1.48666143e-01f, -5.15772760e-01f, -1.20156407e-01f, -6.59222156e-02f, 3.64672035e-01f, 2.68021584e-01f,
  7.74769038e-02f, 1.57126501e-01f, -3.39958146e-02f, 1.81742504e-01f, -5.71907498e-02f, 4.13364500e-01f, 6.22037426e-02f, -3.81670147e-01f, 2.80330747e-01f, -2.19339922e-01f,
  3.59976947e-01f, 1.36183500e-01f, 7.12387934e-02f, 2.58311152e-01f, -1.37256552e-02f, 3.04695100e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.06956238e-01f, 6.69492856e-02f, 1.79877385e-01f, 3.83488946e-02f, 6.70077503e-02f, 9.75353196e-02f, 1.49631485e-01f, 1.65531695e-01f, 5.22452816e-02f, 4.47801203e-02f,
  7.82298520e-02f, 1.62416756e-01f, 9.39017460e-02f, 6.36436865e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.31235376e-01f, -1.07752658e-01f, -1.53593823e-01f, 1.09334245e-01f, -1.68535244e-02f, 5.74486777e-02f, 1.84591033e-03f, -7.78511241e-02f, 8.36050585e-02f, -2.35409111e-01f,
  1.52202873e-02f, -1.27632529e-01f, -9.07413587e-02f, 1.64175972e-01f, -1.56118721e-01f, -3.47890407e-02f, 5.14307171e-02f, -8.68639052e-02f, -1.86589718e-01f, 1.98063225e-01f,
  -2.01813146e-01f, -1.34465009e-01f, 1.41950399e-01f, 1.50700927e-01f, 4.37243693e-02f, -2.38614932e-01f, 2.47669190e-01f, 1.80092510e-02f, -4.70095649e-02f, 3.02906990e-01f,
  2.77203381e-01f, -2.27397814e-01f, -2.49759540e-01f, -1.77504465e-01f, 8.46143514e-02f, -2.81878293e-01f, 8.61879662e-02f, 2.31031388e-01f, -9.74176973e-02f, -1.50783777e-01f,
  -2.71449596e-01f, 2.77908266e-01f, -1.68144375e-01f, 1.93677798e-01f, -2.39749327e-01f, -3.68259177e-02f, -1.51657745e-01f, -2.32896209e-02f, -4.07297397e-03f, 2.96807349e-01f,
  7.70541131e-02f, 1.16385482e-02f, 1.99066326e-01f, -3.43025744e-01f, -2.69948870e-01f, -4.32368398e-01f, -4.29052562e-01f, 8.96264464e-02f, -2.12893918e-01f, 3.52195054e-01f,
  -4.84535545e-01f, 2.31480852e-01f, 1.09667361e-01f, -3.09168577e-01f, -1.66504160e-01f, 1.83116019e-01f, -3.52625214e-02f, -2.75852203e-01f, 2.01452658e-01f, 2.47261435e-01f,
  -1.74004033e-01f, 1.39395609e-01f, -6.39263317e-02f, 2.60359079e-01f, -1.85210466e-01f, 1.15990065e-01f, 1.77958146e-01f, 4.88012210e-02f, 2.72306174e-01f, -1.42057672e-01f,
  2.26727575e-01f, 1.43648302e-02f, 3.04015465e-02f, -7.52783641e-02f, 1.30822405e-01f, 2.22560793e-01f, -1.97955951e-01f, 1.51194394e-01f, 1.25490084e-01f, 1.77156404e-01f,
  -3.39597017e-01f, 1.33950263e-01f, -1.78878047e-02f, -1.24736048e-01f, 2.78780106e-02f, -1.61384836e-01f, -1.98560432e-01f, -2.26839378e-01f, -1.48924664e-01f, -2.45953768e-01f,
  -1.32158130e-01f, -1.70158967e-01f, -1.12750769e-01f, 3.92569266e-02f, -1.21229969e-01f, -4.83185127e-02f, -2.46037021e-01f, 2.47694016e-01f, 9.22786966e-02f, 2.46250078e-01f,
  7.72050470e-02f, 2.22720221e-01f, 1.93324103e-03f, -1.42058413e-02f, 1.96130276e-01f, 2.14652926e-01f, -1.99798942e-01f, -3.35873038e-01f, -2.83745825e-01f, -2.37385500e-02f,
  2.56843716e-02f, 1.47110030e-01f, 1.32793009e-01f, -7.78333247e-02f, -3.75543386e-01f, 2.37535879e-01f, 1.32134398e-02f, -5.88023007e-01f, -3.39306593e-02f, -2.17036325e-02f,
  -2.76995506e-02f, 1.92424640e-01f, -1.48053318e-01f, 1.47441542e-02f, 1.73310488e-01f, 1.52790487e-01f, 1.16430230e-01f, -1.24775305e-01f, -6.57951385e-02f, -6.78049922e-02f,
  8.27111900e-02f, 9.87048596e-02f, -7.84128457e-02f, 1.15781926e-01f, -1.52866453e-01f, 1.72361135e-02f, 1.66303381e-01f, 2.23559901e-01f, -4.57940735e-02f, -1.40860185e-01f,
  -1.47652850e-01f, 1.26404837e-01f, -5.11282869e-02f, 5.92463464e-02f, -1.83861032e-01f, -2.57755280e-01f, 7.50705600e-02f, -1.48363858e-01f, -4.19687666e-02f, 2.01090202e-01f,
  2.86707003e-02f, 2.93234080e-01f, 2.46317983e-01f, 1.53657049e-01f, -2.65652478e-01f, -2.13985190e-01f, -1.81693122e-01f, -2.58229077e-01f, 1.67912304e-01f, -1.22675657e-01f,
  2.02791486e-02f, 1.01239778e-01f, 9.12864879e-02f, -2.52785534e-01f, 7.15178773e-02f, 2.65232861e-01f, 3.45228165e-01f, -1.26700804e-01f, -2.71365583e-01f, 3.43687862e-01f,
  -3.27471167e-01f, 3.75853404e-02f, -4.09783721e-01f, 5.46287745e-02f, -4.43438709e-01f, 3.02219868e-01f, -4.00636792e-01f, 9.00220722e-02f, -8.30950886e-02f, 1.44220501e-01f,
  2.04381526e-01f, -4.37663347e-01f, -1.93021581e-01f, 1.29090518e-01f, 1.71380043e-01f, -1.17713839e-01f, 1.29793808e-02f, -2.00022489e-01f, -1.32385463e-01f, 1.37769595e-01f,
  5.13750575e-02f, 1.39580637e-01f, 1.83733061e-01f, -4.98477072e-02f, -2.31016092e-02f, 2.06605658e-01f, -4.92872391e-03f, 2.37934604e-01f, 1.39985070e-01f, 1.36821404e-01f,
  2.12554738e-01f, -1.76543385e-01f, 1.82391226e-01f, 8.59878510e-02f, -1.68846190e-01f, -2.12412789e-01f, -1.03285417e-01f, -1.74348623e-01f, 8.66230652e-02f, -8.45005177e-03f,
  4.16628830e-02f, 9.83994454e-03f, 2.71345656e-02f, -1.33104146e-01f, 2.36055359e-01f, -2.29390353e-01f, -1.50590912e-01f, 3.89573127e-02f, 2.33765598e-02f, -2.29035303e-01f,
  1.08823650e-01f, -2.61530429e-01f, -1.51775762e-01f, -1.88623711e-01f, 1.27882481e-01f, -5.90756536e-02f, 1.73650637e-01f, -3.72093578e-04f, -3.94386679e-01f, 2.17091758e-02f,
  -3.04259285e-02f, 2.79515982e-01f, -2.05165476e-01f, -4.62934524e-01f, 6.39734343e-02f, 2.45615587e-01f, 1.63390204e-01f, 1.19369656e-01f, -2.82803357e-01f, -4.01275873e-01f,
  -2.06882983e-01f, 2.62304604e-01f, 5.87760955e-02f, -4.43831056e-01f, -3.75036858e-02f, 1.23185501e-01f, 2.55919490e-02f, -8.13090578e-02f, -4.60918620e-02f, 1.18678905e-01f,
  8.57885480e-02f, 8.11883733e-02f, 1.72768652e-01f, 1.50513217e-01f, 1.34351179e-01f, -2.40553439e-01f, 9.65978578e-02f, -2.26599708e-01f, -2.15514734e-01f, -2.55284607e-02f,
  2.18822826e-02f, -3.51463407e-02f, 2.74520069e-02f, 1.38691112e-01f, 1.24293536e-01f, -1.77308440e-01f, 3.22582712e-03f, -1.87425837e-01f, -2.08238475e-02f, 4.37671244e-02f,
  2.56777495e-01f, -4.24608767e-01f, -2.50217646e-01f, 1.54627994e-01f, -2.41964087e-02f, 2.03205824e-01f, -2.21412331e-01f, 8.37376937e-02f, -3.54832821e-02f, 1.75872922e-01f,
  -4.37277481e-02f, 2.92263925e-01f, 1.79041594e-01f, 2.65577704e-01f, 8.23133141e-02f, 5.05790934e-02f, -1.39855623e-01f, 1.67897299e-01f, -1.65921971e-01f, -1.39094234e-01f,
  2.19742954e-02f, 2.25406751e-01f, -2.46526688e-01f, -3.11666638e-01f, 9.31958556e-02f, -8.46691430e-02f, 2.00532854e-01f, -6.30363405e-01f, 7.90026113e-02f, -8.38690698e-02f,
  3.16840559e-01f, -3.79299641e-01f, -2.64011830e-01f, 6.34316588e-03f, 1.57918066e-01f, 7.85207897e-02f, 3.17307599e-02f, -7.87450746e-02f, 1.08938098e-01f, 1.64989799e-01f,
  3.80368344e-02f, -7.95392785e-03f, 1.03041686e-01f, -9.11085233e-02f, -1.04367509e-01f, 6.73943833e-02f, 6.19218946e-02f, 1.76640406e-01f, 6.50371239e-02f, -2.97921337e-02f,
  1.57413915e-01f, 1.32326245e-01f, -2.69575685e-01f, 1.60941049e-01f, -2.30237946e-01f, -1.79895163e-01f, 1.44302145e-01f, -2.61113584e-01f, 2.49638945e-01f, -7.07131848e-02f,
  -1.63820907e-01f, 1.58007607e-01f, -2.15725929e-01f, 5.09341955e-02f, -1.51450047e-03f, 1.59399644e-01f, 1.26292080e-01f, 3.69859859e-02f, 4.27058823e-02f, 2.78967589e-01f,
  -8.35017413e-02f, -1.29887491e-01f, 2.31967255e-01f, -3.04299623e-01f, 7.43770450e-02f, -2.56622285e-01f, 2.14011267e-01f, 2.06764996e-01f, 1.40125349e-01f, 1.75338641e-01f,
  -2.18498588e-01f, 1.67637438e-01f, 2.06476171e-03f, -2.14256987e-01f, -1.18338637e-01f, -2.69284159e-01f, -1.05380965e-02f, -2.04363763e-02f, -2.49264657e-01f, 2.27035098e-02f,
  3.00294936e-01f, -2.43247405e-01f, 2.82655716e-01f, -4.40312117e-01f, -1.21240884e-01f, -4.42727981e-03f, 1.13362230e-01f, -2.68599868e-01f, 2.98676640e-01f, -3.50262135e-01f,
  -3.82876545e-01f, 5.41783916e-03f, -4.24355060e-01f, 1.90297831e-02f, -7.98418149e-02f, 4.84849922e-02f, -1.06937043e-01f, -2.35435784e-01f, -1.68252245e-01f, -2.20764101e-01f,
  1.73000112e-01f, 2.39109352e-01f, -5.68901710e-02f, 7.74905756e-02f, -2.08513752e-01f, -1.13443555e-02f, 2.47954624e-03f, 1.49334729e-01f, -3.45908292e-02f, 2.34445170e-01f,
  2.51849485e-03f, 6.85504079e-02f, -2.73113132e-01f, -3.25602159e-04f, -3.87408677e-03f, -3.40804420e-02f, -9.99320149e-02f, 1.62226140e-01f, -2.67869622e-01f, 1.27154678e-01f,
  2.02071697e-01f, -3.42784047e-01f, -2.15140834e-01f, -7.92849809e-02f, 5.48516139e-02f, -3.92239057e-02f, -2.11502463e-02f, 2.34551236e-01f, -1.75846905e-01f, 1.64716482e-01f,
  1.90732256e-01f, 2.04530414e-02f, 2.96521664e-01f, 2.47821540e-01f, 8.17724317e-02f, -1.03774756e-01f, -1.44450411e-01f, -1.02588326e-01f, 1.30034119e-01f, 2.35574067e-01f,
  1.82029545e-01f, 2.32516259e-01f, 1.07739724e-01f, -1.85161591e-01f, -5.21769337e-02f, -1.57663554e-01f, -9.91025493e-02f, -3.63675207e-02f, 4.56558466e-02f, 1.06132910e-01f,
  5.35409562e-02f, 1.21719234e-01f, 2.07830295e-02f, -4.58613724e-01f, 1.60041437e-01f, 1.47430032e-01f, -1.21078752e-01f, 1.71390355e-01f, -1.38575107e-01f, 1.69009715e-02f,
  -3.39402109e-01f, 2.24948928e-01f, -5.26875444e-02f, -7.95508996e-02f, -6.17970042e-02f, -1.11726403e-01f, -2.12391630e-01f, -1.55690294e-02f, -2.08777621e-01f, -1.44226411e-02f,
  -1.89696886e-02f, -1.81478634e-01f, -2.58403629e-01f, -4.30976041e-02f, 1.52318627e-01f, 2.26419657e-01f, -7.26457983e-02f, 9.64976549e-02f, -2.39296034e-01f, 3.85914221e-02f,
  5.79412505e-02f, -1.26773119e-01f, -7.91160911e-02f, -3.32473099e-01f, 8.40386897e-02f, -1.01098128e-01f, -3.87523114e-03f, 3.14193845e-01f, -1.95334852e-01f, 2.54515857e-01f,
  -2.60387689e-01f, 5.61351739e-02f, 3.16824198e-01f, 4.81748991e-02f, 1.82508916e-01f, -5.30273356e-02f, 1.82543933e-01f, -1.24732837e-01f, 3.31841260e-02f, 3.54251899e-02f,
  -1.36948377e-01f, -2.79018909e-01f, -3.05626810e-01f, -2.34749720e-01f, 2.78745472e-01f, -3.56352419e-01f, 1.70739114e-01f, -2.33681630e-02f, -3.25095236e-01f, 3.25741470e-02f,
  -3.70219827e-01f, 2.22366333e-01f, 1.06421404e-01f, -3.42182964e-01f, -3.58054370e-01f, 1.32369936e-01f, -2.63072610e-01f, 9.98325422e-02f, 2.49021530e-01f, -1.59115478e-01f,
  2.30522931e-01f, 5.33930883e-02f, -2.72085875e-01f, -1.75157800e-01f, 4.15524915e-02f, 1.42566219e-01f, 1.56537324e-01f, 2.14587361e-01f, -4.76879776e-02f, -2.04696000e-01f,
  1.27277628e-01f, 2.28921808e-02f, 1.30554721e-01f, 6.67968541e-02f, -2.81869650e-01f, -1.72619075e-01f, 6.65201321e-02f, 8.99102688e-02f, -1.83579803e-01f, 1.94465786e-01f,
  1.38661712e-01f, -1.39560491e-01f, 2.03730464e-01f, -9.01563764e-02f, -2.03483462e-01f, 1.17323197e-01f, -4.97809947e-02f, 8.89362767e-02f, -1.59663379e-01f, 2.29168072e-01f,
  5.51857315e-02f, -9.42507610e-02f, -7.96387121e-02f, -6.99057057e-02f, 1.37541398e-01f, -2.83639375e-02f, 3.20723265e-01f, -2.25283712e-01f, -1.93158776e-01f, -1.35447785e-01f,
  -1.83122367e-01f, 1.17148086e-01f, -1.65186256e-01f, -9.72753018e-02f, 1.97505236e-01f, 2.19364330e-01f, 5.12933359e-02f, -1.80124462e-01f, 2.47994348e-01f, -1.07877731e-01f,
  2.98103273e-01f, 2.89802849e-01f, -3.69354934e-01f, 5.24731539e-02f, -2.65649647e-01f, 2.18696773e-01f, -1.67072758e-01f, 2.67737567e-01f, 3.09709132e-01f, -1.98702395e-01f,
  -1.82231441e-01f, -4.55429077e-01f, -4.32673633e-01f, 1.31047264e-01f, -3.77866924e-01f, -3.18622202e-01f, 3.04807834e-02f, -2.85676330e-01f, 2.14615539e-01f, 2.29002893e-01f,
  1.74842790e-01f, 2.53733814e-01f, 5.68796182e-03f, -1.87854946e-01f, -2.75503874e-01f, 5.97005971e-02f, -1.96955696e-01f, 1.67268086e-02f, 6.69519082e-02f, -1.17530599e-01f,
  1.45093217e-01f, -1.73112184e-01f, 1.51866674e-01f, -2.84687519e-01f, 1.34329721e-01f, 1.08641028e-01f, 2.96011716e-01f, 2.05141336e-01f, 1.83909625e-01f, -3.01400751e-01f,
  -6.89237043e-02f, 1.62650600e-01f, -1.14298984e-01f, -9.83506814e-02f, 2.54767239e-01f, -8.15281346e-02f, 2.06039250e-01f, 1.42701820e-01f, -4.62485179e-02f, 1.69034287e-01f,
  -1.94798067e-01f, 1.70715630e-01f, -4.71908271e-01f, -1.61178708e-01f, 2.11112693e-01f, -2.51642853e-01f, 3.20069909e-01f, 3.30141455e-01f, 1.62988231e-01f, -5.70956990e-02f,
  -4.94156778e-01f, -5.65219820e-02f, -7.99165070e-02f, -2.21586041e-02f, 1.32168263e-01f, -6.75925286e-03f, 1.06530733e-01f, 2.97690183e-01f, 5.89747354e-02f, -4.20461863e-01f,
  1.37101412e-01f, -3.73927534e-01f, -3.51363331e-01f, 2.17009693e-01f, -1.76989615e-01f, -1.06505446e-01f, 9.75875780e-02f, 6.33351654e-02f, -1.20462656e-01f, 1.75890774e-01f,
  1.81584999e-01f, 6.75474182e-02f, 1.70460269e-01f, -1.37584016e-01f, -1.60163328e-01f, -1.71808317e-01f, -2.89646015e-02f, -1.60807714e-01f, 2.02067241e-01f, 1.77296966e-01f,
  -2.03329250e-01f, 8.06832686e-02f, -2.45323896e-01f, 1.35586336e-01f, 1.64553434e-01f, -1.64363369e-01f, -2.24752560e-01f, 1.00270145e-01f, 2.84780040e-02f, 1.53055832e-01f,
  9.37419198e-03f, 7.10834116e-02f, 1.67226657e-01f, 2.42671054e-02f, 2.25189686e-01f, 3.13837416e-02f, -9.32234228e-02f, -2.17461988e-01f, -1.51551634e-01f, -2.40513787e-01f,
  4.82118465e-02f, -1.61932319e-01f, 1.55341789e-01f, 1.40372083e-01f, 2.40768954e-01f, 2.76370615e-01f, 2.71373034e-01f, -8.80138054e-02f, -2.62912124e-01f, 3.02638680e-01f,
  2.52346903e-01f, 5.64356893e-02f, 1.96797997e-01f, -3.00558001e-01f, 1.83180869e-01f, -1.27014354e-01f, 2.14163646e-01f, -1.05941422e-01f, -3.66456836e-01f, -1.56844661e-01f,
  -2.79619902e-01f, 2.82755733e-01f, -3.61714453e-01f, 1.57982975e-01f, -2.86989570e-01f, 8.35583881e-02f, 9.43069607e-02f, -2.47308895e-01f, -1.12103499e-01f, 1.56811729e-01f,
  1.55921370e-01f, -4.72657144e-01f, 2.31674109e-02f, -7.64269158e-02f, 3.75134721e-02f, 1.24903329e-01f, 3.49272043e-02f, -7.36109540e-02f, 1.11653164e-01f, -1.15585200e-01f,
  -1.87792465e-01f, -2.97931045e-01f, -1.47510335e-01f, 1.28301546e-01f, 1.35018095e-01f, -2.46119555e-02f, 1.31158814e-01f, -4.29678299e-02f, -1.49825945e-01f, 1.37499809e-01f,
  -2.35279486e-01f, 1.38003260e-01f, -1.03576884e-01f, -7.20829144e-02f, -2.43450537e-01f, 1.37371391e-01f, 1.58322435e-02f, -8.07824731e-02f, 8.68058503e-02f, 1.24355346e-01f,
  2.23405465e-01f, 1.49577975e-01f, 1.10973947e-01f, -2.25924104e-01f, 2.10789740e-01f, -4.86870371e-02f, 6.56062514e-02f, -2.06273004e-01f, -2.87715673e-01f, -2.65763849e-01f,
  2.87307590e-01f, -9.63198990e-02f, -2.93322265e-01f, 1.79998979e-01f, -2.94178933e-01f, -1.60083622e-02f, 3.55800152e-01f, -2.98399121e-01f, -2.15041116e-01f, 1.65865738e-02f,
  -1.27816513e-01f, 2.87666470e-01f, -2.53117196e-02f, 1.41167969e-01f, -2.95484751e-01f, -4.36054170e-01f, 2.49610301e-02f, 2.69525126e-02f, -1.65458158e-01f, 1.68047592e-01f,
  3.11602384e-01f, -3.20815772e-01f, 3.17778438e-01f, -2.93077022e-01f, 3.62361618e-03f, -5.96891701e-01f, -4.14677948e-01f, 5.97202964e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.40097919e-02f, -1.73012465e-02f, 1.10331543e-01f, 5.72752170e-02f, 2.59392727e-02f, -6.48126230e-02f, 5.81748746e-02f, 1.10921357e-02f, 5.66645190e-02f, 4.39920649e-02f,
  9.54644904e-02f, 6.73681274e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    