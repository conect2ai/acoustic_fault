/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.36009908e-01f, 1.70832053e-01f, -1.88099176e-01f, -4.69829962e-02f, 7.01758936e-02f, 1.61166377e-02f, 1.95118843e-03f, -1.19917877e-01f, -5.40197045e-02f, -1.58994570e-02f,
  -8.84943977e-02f, -2.40488961e-01f, -1.19420856e-01f, -1.52752712e-01f, -3.31472576e-01f, 2.57611182e-02f, 1.84298202e-01f, -2.11080968e-01f, -2.86807179e-01f, -1.12791359e-01f,
  1.97181448e-01f, -4.97570075e-03f, -2.84865677e-01f, -1.67082876e-01f, 2.24201620e-01f, 3.24033424e-02f, 8.23220015e-02f, -7.10933730e-02f, -6.30399808e-02f, 2.78488964e-01f,
  -1.28097773e-01f, -2.52940923e-01f, -1.28052935e-01f, -7.89413303e-02f, 5.52444672e-03f, 3.11396159e-02f, -8.32813606e-02f, -5.36772758e-02f, -6.57596663e-02f, 3.71133722e-02f,
  -6.06433898e-02f, -3.27108651e-02f, -5.14676683e-02f, 2.18564644e-02f, -4.96466011e-02f, -1.29149616e-01f, -4.90907803e-02f, -1.07816786e-01f, -3.39143053e-02f, 7.76469056e-03f,
  -3.65398079e-02f, 7.04232091e-03f, -2.18643263e-01f, -9.77673084e-02f, -2.50609070e-01f, -1.50658891e-01f, -2.29123011e-01f, -1.11823179e-01f, -2.23941386e-01f, 5.29065020e-02f,
  9.55291614e-02f, 1.45249665e-01f, 1.39355376e-01f, 8.40544999e-02f, 1.82876170e-01f, 9.59062725e-02f, 1.31014779e-01f, 2.22959779e-02f, 1.16436809e-01f, 6.51980042e-02f,
  4.88733202e-02f, 1.04656406e-01f, 1.40054241e-01f, 1.36305854e-01f, 9.54482257e-02f, 8.34734812e-02f, 5.65815642e-02f, 1.34195313e-01f, 3.15104835e-02f, 7.46150389e-02f,
  -2.16255579e-02f, 6.28472790e-02f, 8.63757953e-02f, 1.05439253e-01f, 7.41315410e-02f, 7.77083635e-02f, 1.20017333e-02f, 9.62595120e-02f, 1.01334177e-01f, 8.03151261e-03f,
  4.04822417e-02f, -3.21489096e-01f, -5.83755709e-02f, -1.82931721e-01f, -9.17063188e-03f, -1.72838300e-01f, -6.13341480e-02f, 1.70071027e-03f, -2.89936457e-02f, -2.02432610e-02f,
  -1.40738934e-01f, -1.85481146e-01f, -1.84232295e-01f, -9.30449739e-02f, -1.22941054e-01f, -1.21326409e-01f, 3.66508067e-02f, -1.32632792e-01f, -1.57439932e-01f, -2.21362561e-02f,
  1.53454533e-02f, -2.54652910e-02f, -9.84992534e-02f, -6.22418337e-02f, -8.71010683e-03f, -1.36325255e-01f, -6.12562746e-02f, -6.29847422e-02f, -1.80845231e-01f, 1.96871817e-01f,
  -3.58510166e-02f, -2.02033430e-01f, -6.67379797e-02f, -8.69612396e-02f, -3.72931659e-02f, -6.60026893e-02f, -3.59878689e-01f, -1.60632774e-01f, -1.08339384e-01f, -2.20815867e-01f,
  8.56444165e-02f, 2.64266908e-01f, 2.89792605e-02f, -2.93767583e-02f, -3.91038321e-02f, -3.90111625e-01f, -3.00803810e-01f, 7.94287995e-02f, 3.40150803e-01f, 2.63396084e-01f,
  5.16813388e-03f, -3.32309157e-02f, 5.83682628e-03f, 5.83795458e-02f, -3.89798880e-02f, 1.37366533e-01f, -1.61297873e-01f, -3.64961708e-03f, -2.90499907e-02f, -2.02610299e-01f,
  1.40105337e-01f, -6.32637143e-02f, 8.66221189e-02f, -5.31840324e-03f, 7.32755885e-02f, -3.59320524e-03f, -2.42249873e-02f, 2.68618693e-03f, -5.57752885e-02f, 1.05132663e-03f,
  -4.51081293e-03f, -9.73897334e-03f, -8.02295655e-03f, 8.34528208e-02f, -4.96269949e-02f, 1.65672153e-02f, 1.17515242e-02f, -5.41615561e-02f, -5.10292612e-02f, 8.08975920e-02f,
  -7.60295168e-02f, 1.02273285e-01f, 1.09084718e-01f, -3.41719538e-02f, -8.99152458e-03f, -4.07446958e-02f, 1.43068396e-02f, -7.05765793e-03f, 1.39203295e-03f, -1.13840826e-01f,
  1.32135116e-02f, 7.61548132e-02f, 5.67533486e-02f, -3.23739997e-03f, -1.01270294e-02f, -3.48959751e-02f, -2.49438081e-02f, 3.38062942e-02f, 1.12303337e-02f, 1.25317499e-01f,
  -1.65477879e-02f, 7.93676823e-02f, -3.14233489e-02f, -9.07760486e-03f, 4.77136998e-03f, 7.11570159e-02f, 1.91875231e-02f, -4.14107703e-02f, 6.74005374e-02f, 7.81560037e-03f,
  6.73762485e-02f, 7.81052187e-02f, 2.15243399e-02f, -2.68193465e-02f, 4.26830836e-02f, 1.11783473e-02f, -4.44402583e-02f, 1.13945059e-01f, 1.66450324e-03f, 4.14203741e-02f,
  1.38661921e-01f, 3.65484208e-02f, -1.37499318e-01f, -9.12353992e-02f, -8.09829086e-02f, -5.69835901e-02f, -3.50409113e-02f, -7.40181580e-02f, -2.09794305e-02f, 2.74965428e-02f,
  7.13176839e-03f, -3.35670896e-02f, -1.38125420e-02f, 5.69875278e-02f, -7.54037965e-03f, 1.32026859e-02f, -9.13087055e-02f, -2.74353139e-02f, -7.02959578e-03f, -4.48958501e-02f,
  -8.70773792e-02f, -1.09078355e-01f, 9.01476964e-02f, 2.86162533e-02f, 5.25879078e-02f, -2.02822555e-02f, 1.09727748e-01f, 2.50219498e-02f, -2.26578340e-02f, -1.42436773e-01f,
  -2.15139806e-01f, -4.12744939e-01f, -1.91511706e-01f, -1.68459177e-01f, -1.56636015e-01f, -2.43329838e-01f, -5.02730787e-01f, -1.66254491e-01f, 9.24121141e-02f, -1.00563452e-01f,
  1.18711524e-01f, 3.33606124e-01f, 3.37885797e-01f, 2.10380450e-01f, -7.72017911e-02f, -3.32767248e-01f, -2.37114534e-01f, 8.67863744e-02f, 5.76903559e-02f, 2.59379186e-02f,
  8.19039717e-02f, -1.16568141e-01f, -2.19328627e-02f, -2.27170270e-02f, -1.85824912e-02f, 1.78561732e-01f, -6.81491643e-02f, -1.10225659e-03f, -1.18166178e-01f, -3.61347310e-02f,
  2.18401715e-01f, -1.95885301e-01f, 1.06746472e-01f, 1.39237806e-01f, -6.28047511e-02f, -8.48667026e-02f, 2.11188663e-02f, -7.27451686e-03f, -1.07022757e-02f, -9.08091739e-02f,
  4.13037054e-02f, 6.70323670e-02f, 6.11102115e-03f, -7.59504139e-02f, -1.51605517e-01f, -8.99969935e-02f, -1.14794679e-01f, -3.40892598e-02f, -1.47242412e-01f, -4.19814140e-02f,
  -4.79233563e-02f, -7.80400634e-02f, -8.77096131e-02f, -1.95348024e-01f, 1.13510350e-02f, -2.72225938e-03f, -4.61204387e-02f, -3.32118645e-02f, -5.24212234e-02f, -1.76565513e-01f,
  1.05278298e-01f, -1.65645760e-02f, -1.26359025e-02f, 5.11698425e-03f, 3.43109518e-02f, 3.67992301e-03f, -5.31342551e-02f, 2.23526843e-02f, -3.89596969e-02f, 9.37153026e-02f,
  1.95290819e-02f, -2.90644797e-03f, 1.33858509e-02f, -2.43393611e-02f, 1.20336168e-01f, -5.92151880e-02f, 2.74138842e-02f, 1.04357023e-03f, 3.66646312e-02f, 5.33666909e-02f,
  6.59667924e-02f, 1.84349492e-02f, -1.98420156e-02f, 1.68095734e-02f, 4.58075851e-02f, -1.29805943e-02f, -2.16103401e-02f, 1.10282592e-01f, 3.42395343e-03f, -2.94467509e-02f,
  1.91440821e-01f, 4.62732203e-02f, 3.41174081e-02f, 3.68130766e-02f, -5.39936423e-02f, 5.43079711e-02f, -2.13578064e-02f, -2.87467837e-02f, 2.92274058e-02f, -9.51227546e-02f,
  -2.52175424e-02f, -3.47115472e-02f, -6.14430234e-02f, -2.88006030e-02f, 7.97960255e-03f, 5.28082885e-02f, -1.13233980e-02f, -6.69818446e-02f, -1.10458918e-02f, -9.83648524e-02f,
  -8.22881386e-02f, -1.30368710e-01f, -6.24390543e-02f, -1.21211730e-01f, -5.69727905e-02f, 8.00042972e-02f, -7.00002909e-02f, -3.45634855e-02f, -4.61132638e-02f, -2.75329113e-01f,
  -4.92848158e-01f, 3.22284222e-01f, 2.67966688e-01f, -9.54506267e-03f, 8.18098113e-02f, 1.41640916e-01f, 8.63691270e-02f, -1.93649139e-02f, -3.57390232e-02f, 7.31041133e-02f,
  -1.42237976e-01f, -9.17737782e-02f, -1.68876678e-01f, -2.81303879e-02f, 2.31587398e-03f, 1.46828040e-01f, 2.00548753e-01f, 3.97400856e-02f, -1.42186478e-01f, -1.26524568e-01f,
  -6.48039207e-02f, -4.47561853e-02f, -1.26867846e-01f, 8.42199698e-02f, 2.60296464e-01f, 4.78850529e-02f, 1.39411390e-01f, 1.17988028e-01f, 1.59607783e-01f, 3.06273788e-01f,
  -1.10705476e-02f, 1.40461475e-01f, -1.74634124e-03f, 4.74022254e-02f, 9.64323506e-02f, 2.15183385e-02f, 3.68328020e-02f, 3.35191935e-02f, 5.45461252e-02f, 3.68244275e-02f,
  1.05594069e-01f, -1.00952415e-02f, 4.58108038e-02f, 8.90866667e-02f, 1.39247537e-01f, 1.51993111e-02f, 4.12029922e-02f, 1.04578167e-01f, 8.63687024e-02f, 1.35936931e-01f,
  8.84796530e-02f, 6.17292188e-02f, 1.15080759e-01f, 1.19642161e-01f, 1.50045708e-01f, 3.94588597e-02f, 5.13304435e-02f, -8.29335209e-03f, 4.24615033e-02f, -9.75707546e-03f,
  -1.48307651e-01f, -4.43864465e-02f, 6.12381436e-02f, 3.53734493e-02f, -3.70235438e-03f, 2.35225763e-02f, -9.51843243e-03f, 7.24340556e-03f, -9.96355154e-03f, 1.12337358e-02f,
  -2.49403734e-02f, -4.37540300e-02f, 4.74871136e-02f, -7.53732994e-02f, -4.90300693e-02f, 9.04993638e-02f, 4.90459614e-04f, -3.72455604e-02f, -1.41390581e-02f, -1.84176583e-02f,
  -6.18735142e-03f, -2.73930952e-02f, 4.25319597e-02f, -4.52036504e-03f, 7.21958186e-03f, 1.37375584e-02f, -2.57114582e-02f, -3.82631309e-02f, -7.22271064e-03f, -3.18858121e-03f,
  -2.32245669e-01f, -6.51623532e-02f, -3.17037441e-02f, -8.73195678e-02f, 1.95673145e-02f, 4.23245467e-02f, -7.28918426e-03f, -3.19835171e-02f, 5.95877529e-04f, -2.51802504e-02f,
  -7.03468500e-03f, 1.73786678e-03f, 2.28513614e-03f, 1.15048990e-01f, -6.88823964e-03f, 1.46588720e-02f, 4.67385575e-02f, -8.64480361e-02f, 2.48287208e-02f, 7.24073797e-02f,
  -1.13216080e-02f, -1.35377273e-01f, -1.73142552e-01f, -3.19325738e-02f, -3.00896857e-02f, -2.30558395e-01f, 2.26378534e-02f, -4.31092381e-02f, -1.02194995e-01f, -1.10539585e-01f,
  1.92330815e-02f, -2.08175719e-01f, -4.91387285e-02f, -1.14393137e-01f, -1.00043334e-01f, -3.51784565e-02f, -1.07605360e-01f, -1.20754138e-01f, -7.43719712e-02f, -6.66065961e-02f,
  2.25229785e-02f, 8.88092294e-02f, 1.54658034e-01f, 1.94244757e-01f, 1.99764445e-01f, 6.24690615e-02f, 7.75032416e-02f, 1.59126610e-01f, 2.82296658e-01f, 1.08882450e-01f,
  -4.40622233e-02f, -4.34026904e-02f, -3.91776636e-02f, -1.52062505e-01f, -1.33950025e-01f, 7.42457621e-03f, -2.20915541e-01f, -1.03263557e-01f, 5.07590063e-02f, -1.58632845e-01f,
  8.12577605e-02f, -2.59567142e-01f, 2.83595510e-02f, 6.01614974e-02f, -6.94445744e-02f, -6.25910386e-02f, 5.36754504e-02f, -7.36840721e-03f, -1.50986081e-02f, -7.86291808e-02f,
  -7.14207366e-02f, -4.09386754e-02f, 5.76473884e-02f, -1.04899622e-01f, -6.19659084e-04f, -1.11902803e-02f, -1.74543351e-01f, -7.87191540e-02f, 5.59073649e-02f, -1.05905183e-01f,
  4.68066297e-02f, 3.06399669e-02f, 1.32229989e-02f, -2.62170173e-02f, -7.99291059e-02f, 1.23295791e-01f, -9.52969864e-02f, -1.44618228e-01f, -2.53261942e-02f, -8.56855810e-02f,
  2.79334169e-02f, -3.75050493e-02f, -1.09300151e-01f, -1.37177870e-01f, -1.11726850e-01f, -2.62825564e-02f, -4.97264378e-02f, -3.34787816e-02f, 2.33579967e-02f, -1.46350756e-01f,
  -4.86763753e-02f, -2.61649638e-02f, -9.12015066e-02f, -8.14618841e-02f, 1.70311481e-02f, -4.92350757e-02f, 1.47976037e-02f, -6.46188855e-02f, -2.07623597e-02f, -1.18854076e-01f,
  -4.19370085e-02f, -9.38145667e-02f, -8.57909396e-02f, -1.26602070e-03f, -4.65965681e-02f, -9.19694752e-02f, -5.55905439e-02f, -1.25504866e-01f, -2.09820792e-02f, -8.03781822e-02f,
  -4.60252613e-02f, 1.09123208e-01f, 8.51764306e-02f, 2.59238072e-02f, -5.44976778e-02f, -2.30073533e-03f, -4.22005095e-02f, -1.55497128e-02f, -8.04076493e-02f, -3.59709784e-02f,
  -1.13911321e-02f, 2.40007956e-02f, -4.92502190e-02f, -4.94731637e-03f, -3.68192978e-02f, -3.89855099e-03f, -4.33391929e-02f, 6.13859929e-02f, 8.53985250e-02f, -7.21719414e-02f,
  -1.35895550e-01f, 5.06444573e-02f, 1.79633975e-01f, 1.06826052e-01f, 5.51816374e-02f, 2.52419829e-01f, 8.25877488e-02f, -1.02256341e-02f, 1.86824724e-01f, 1.76130116e-01f,
  -6.48224771e-01f, 3.90104800e-01f, 1.17181450e-01f, -2.06535965e-01f, 3.55549037e-01f, 3.31196100e-01f, 4.63842839e-01f, 9.25388560e-02f, -1.51227608e-01f, 1.35742068e-01f,
  1.59683049e-01f, -3.40471976e-02f, -1.81472711e-02f, 5.11050746e-02f, 8.66188388e-03f, 2.05435574e-01f, 2.64294744e-01f, -1.49527326e-01f, -2.29945928e-01f, 7.69389123e-02f,
  1.47127658e-01f, -1.03279099e-01f, -3.12939972e-01f, -1.96630284e-01f, 3.88790518e-02f, -1.02776671e-02f, 3.95524576e-02f, -7.10614547e-02f, 1.55899182e-01f, 1.14122909e-02f,
  -1.29700273e-01f, -1.34414136e-01f, -4.08639610e-02f, -7.19287843e-02f, 1.33326605e-01f, -8.06207508e-02f, 9.18023139e-02f, -6.25403151e-02f, 7.55521059e-02f, 1.10796846e-01f,
  -2.33491231e-02f, 4.89839800e-02f, 2.09262855e-02f, 3.76606211e-02f, 4.33020256e-02f, 2.02864800e-02f, 3.02257184e-02f, -1.13275498e-01f, 7.58359283e-02f, 1.31820336e-01f,
  2.52563298e-01f, 1.69753686e-01f, 1.10114709e-01f, 1.42539307e-01f, -1.48413461e-02f, 3.06478515e-02f, 1.37718484e-01f, 3.94235328e-02f, -4.88116033e-02f, 2.78908163e-02f,
  2.65840208e-03f, 6.17338829e-02f, -2.01530810e-02f, -4.95219789e-02f, 5.84119791e-03f, 1.85422623e-03f, -1.70833170e-02f, 2.92392843e-03f, -6.43697307e-02f, -3.78451161e-02f,
  3.33915912e-02f, -1.47072682e-02f, -1.44749414e-02f, -2.97646634e-02f, 1.29386121e-02f, 7.59183569e-03f, -4.64232191e-02f, -1.24742500e-02f, 1.75012946e-02f, -5.37159964e-02f,
  -1.27704099e-01f, -3.97279672e-02f, -7.34929740e-02f, -7.54557103e-02f, -2.92540044e-02f, -6.99804649e-02f, -2.42567826e-02f, -3.58804762e-02f, -1.86318588e-02f, 8.52276534e-02f,
  -1.01967029e-01f, 7.33421594e-02f, -4.92845327e-02f, -5.42166866e-02f, 8.94934162e-02f, 9.04165357e-02f, 7.71906748e-02f, -7.94658717e-03f, 9.04542878e-02f, -6.32646214e-03f,
  6.32190630e-02f, 2.10219752e-02f, 4.93353605e-02f, 6.17452674e-02f, 4.83914353e-02f, 1.01596070e-02f, 1.10383026e-01f, 7.67911747e-02f, 3.81711647e-02f, 1.19065911e-01f,
  9.45768133e-02f, 1.27206743e-01f, 3.73407714e-02f, 1.72553942e-01f, 6.11798801e-02f, -1.47762559e-02f, 1.66835085e-01f, 5.24721295e-02f, 5.55281937e-02f, 1.01519451e-01f,
  -1.73965827e-01f, -2.10031882e-01f, -4.09056187e-01f, 9.65568200e-02f, 2.04159245e-01f, 1.04837961e-01f, 1.26850560e-01f, 2.99061704e-02f, 8.90026987e-02f, -1.09539628e-01f,
  9.65644792e-02f, 2.83811361e-01f, 3.47411446e-02f, -5.88430315e-02f, -4.69887163e-03f, -1.49793521e-01f, -1.56922430e-01f, -1.22876376e-01f, 3.78289819e-02f, 2.94236541e-01f,
  2.03697726e-01f, 5.77598996e-02f, -5.74222952e-02f, -4.22273902e-03f, 2.01232899e-02f, 1.23187073e-01f, -1.17018946e-01f, -2.17577353e-01f, -1.27288103e-01f, -1.97641000e-01f,
  -2.50879586e-01f, -3.82350117e-01f, 5.92275113e-02f, 1.97722688e-02f, -7.92616159e-02f, -1.64016172e-01f, 3.52309868e-02f, -2.19807625e-01f, -1.14520013e-01f, -8.68006721e-02f,
  -9.94835496e-02f, 5.95373986e-03f, -1.10434011e-01f, -6.84314743e-02f, -8.92714709e-02f, -5.03753982e-02f, -2.54834384e-01f, -2.77659595e-01f, -1.69804052e-01f, -7.93863684e-02f,
  2.67045218e-02f, -1.89404622e-01f, -2.26669818e-01f, -4.87324856e-02f, -1.93686068e-01f, 2.44048098e-03f, -1.91604033e-01f, -1.46302372e-01f, -1.89361706e-01f, -8.25466067e-02f,
  6.37866929e-02f, 1.72326956e-02f, -1.66046210e-02f, 3.45463268e-02f, 7.61666521e-02f, 1.54041909e-02f, 3.36314254e-02f, 7.73370937e-02f, 9.17024240e-02f, -5.70253795e-03f,
  8.23506638e-02f, 4.95535461e-03f, 5.18313311e-02f, 6.58771098e-02f, 4.81375381e-02f, -2.31708344e-02f, 7.75086805e-02f, 5.47260279e-03f, 3.37222815e-02f, 5.20821176e-02f,
  -4.66374755e-02f, 4.56103496e-02f, 9.64382663e-02f, -3.62079195e-03f, 8.22914094e-02f, -8.73649865e-02f, 1.32641107e-01f, 1.68752274e-03f, 5.25863357e-02f, -7.46020535e-03f,
  1.11965016e-01f, 1.49078192e-02f, 4.11156900e-02f, -4.14738879e-02f, -7.97811449e-02f, -6.17674589e-02f, -8.09804257e-03f, 5.81798842e-03f, -3.36094014e-02f, -1.45745957e-02f,
  1.59299783e-02f, -5.71462177e-02f, -3.42443213e-02f, -5.28388657e-02f, 1.08067557e-01f, 5.72833493e-02f, 4.83867079e-02f, 7.58913159e-02f, 5.61224446e-02f, -2.19527334e-02f,
  -5.37094101e-02f, 6.13533668e-02f, 6.37140349e-02f, 1.03966542e-01f, 7.47325132e-04f, 2.34982595e-01f, 1.14036329e-01f, 1.52492583e-01f, 3.41444910e-02f, 1.93528131e-01f,
  -1.09581478e-01f, 1.02899648e-01f, 1.30383626e-01f, -1.59514740e-01f, 3.04779429e-02f, 1.65375829e-01f, 3.72516394e-01f, 1.15995780e-01f, -1.11408204e-01f, 2.85018841e-03f,
  -1.21772200e-01f, -9.21040550e-02f, -6.75036237e-02f, -6.98464736e-03f, 2.15995803e-01f, 2.84678668e-01f, 3.80930513e-01f, 3.07161659e-01f, 1.20712191e-01f, -2.97523644e-02f,
  3.86214978e-03f, -8.53913873e-02f, -7.05858916e-02f, 4.22781967e-02f, -8.68458226e-02f, 4.97345813e-02f, 1.68348551e-01f, 6.56268820e-02f, 1.28598168e-01f, 5.99763133e-02f,
  7.93411955e-02f, -7.12237209e-02f, 1.12235203e-01f, -4.48783748e-02f, 2.89668217e-02f, -9.19717830e-03f, 1.00709982e-02f, -8.16479474e-02f, -4.03400958e-02f, 3.09697576e-02f,
  -1.03124857e-01f, -1.29354969e-01f, 3.94936986e-02f, -1.19177528e-01f, -3.50100510e-02f, -7.22892061e-02f, -1.18662991e-01f, 2.45826188e-02f, 5.73022179e-02f, -9.35869440e-02f,
  -1.08396925e-01f, -7.54900500e-02f, -1.28088696e-02f, -2.68144216e-02f, -8.00759271e-02f, 1.83476508e-02f, 7.09492043e-02f, -6.40175343e-02f, 1.35851324e-01f, -1.13982270e-02f,
  1.90420579e-02f, -7.06347525e-02f, -9.20356661e-02f, -9.36514288e-02f, -9.82610211e-02f, -1.13832802e-01f, -6.56219721e-02f, -7.49120787e-02f, -5.59858344e-02f, -2.04808507e-02f,
  -2.77036093e-02f, 4.14234549e-02f, -3.89994122e-02f, 6.77194148e-02f, -2.67396849e-02f, -8.48368704e-02f, 3.78498249e-02f, 1.92910861e-02f, 1.06832664e-02f, -2.54645031e-02f,
  -3.37879136e-02f, -1.71352681e-02f, -1.17941722e-01f, 2.69034691e-02f, -8.29539169e-03f, 7.29998434e-03f, -4.26624715e-02f, -1.81113571e-01f, -7.49049932e-02f, -1.10637926e-01f,
  3.85925174e-02f, 1.50783405e-01f, 1.13850340e-01f, 2.62492392e-02f, 1.52041065e-02f, -1.25363674e-02f, 6.91988021e-02f, 8.67977887e-02f, -1.47206439e-02f, 5.07951193e-02f,
  -1.04760360e-02f, 6.48357868e-02f, 8.32721367e-02f, 4.69227433e-02f, 1.35871053e-01f, 6.81787953e-02f, 7.51603246e-02f, 1.35664284e-01f, 6.34893551e-02f, -3.15478221e-02f,
  8.51874240e-03f, 1.58067629e-01f, 9.43069905e-02f, 1.68756962e-01f, 9.33647603e-02f, 2.14629218e-01f, 1.78804949e-01f, 1.79915339e-01f, 2.87196308e-01f, 2.89824724e-01f,
  -3.12201977e-01f, 5.31921864e-01f, -5.66217303e-02f, -2.79726624e-01f, -6.75128996e-02f, -1.21733434e-02f, 3.74568224e-01f, 1.59322321e-01f, 5.36016338e-02f, 1.86872452e-01f,
  1.20437436e-01f, -6.06521256e-02f, -3.19727696e-02f, 7.95455277e-02f, 1.10000283e-01f, 2.88795739e-01f, 6.48944825e-02f, -2.72495389e-01f, -1.91675112e-01f, -1.67462051e-01f,
  7.63792591e-03f, -1.90702118e-02f, -1.60647422e-01f, -9.32843462e-02f, -3.02130822e-02f, -5.93696497e-02f, 1.43615454e-01f, -4.35724631e-02f, 7.92710558e-02f, -1.34673789e-02f,
  -2.34997869e-02f, 1.32066220e-01f, -6.97952732e-02f, 1.07797887e-02f, -1.63007993e-02f, -1.25120819e-01f, -3.64920646e-02f, -9.23554823e-02f, -4.68020998e-02f, 1.35199040e-01f,
  4.50278260e-03f, -4.38410342e-02f, 3.89799327e-02f, 4.37886380e-02f, 1.43437997e-01f, 1.05236240e-01f, 2.04868764e-01f, 7.16344789e-02f, -5.70218451e-02f, 2.00084150e-02f,
  1.77387316e-02f, -1.80842713e-01f, -1.09162614e-01f, 1.41738072e-01f, 5.38882762e-02f, -6.91396073e-02f, 6.03917353e-02f, 5.51537536e-02f, 5.17588891e-02f, 1.24075964e-01f,
  -8.04783106e-02f, -3.26716974e-02f, -5.04440032e-02f, 5.62787987e-02f, -3.10136471e-02f, -4.91915308e-02f, 1.25955576e-02f, -4.57947403e-02f, -5.93156740e-02f, -2.40393467e-02f,
  -2.09818836e-02f, -1.31930456e-01f, -4.11196426e-02f, -1.14496678e-01f, -5.45651540e-02f, -7.33061731e-02f, -9.40154344e-02f, 6.29001707e-02f, -6.25219941e-02f, -2.38393508e-02f,
  -1.27708107e-01f, -7.65444636e-02f, -8.98248553e-02f, 4.42685634e-02f, -9.29144546e-02f, -8.33726153e-02f, -1.96070690e-02f, -7.36880079e-02f, -5.81839755e-02f, -8.65208805e-02f,
  2.48948783e-01f, -4.62174602e-03f, 9.09525678e-02f, 9.20251757e-02f, -3.84198539e-02f, 5.33965379e-02f, 1.04940511e-01f, -2.06821878e-02f, 2.09073368e-02f, 4.41815034e-02f,
  4.69713993e-02f, 8.64562169e-02f, 9.37732533e-02f, 1.73480704e-01f, 4.27059978e-02f, 8.75293612e-02f, 1.90766484e-01f, -2.22661979e-02f, 2.81233806e-02f, 1.12994485e-01f,
  1.46558210e-01f, -8.44935551e-02f, -7.18273446e-02f, 1.24543764e-01f, 8.39987397e-02f, -1.73372224e-01f, 4.83639212e-03f, -1.78589094e-02f, -5.09453639e-02f, 1.36880219e-01f,
  -4.19711381e-01f, 3.56703877e-01f, 2.88396448e-01f, -3.12425464e-01f, 4.54938114e-02f, 1.74400538e-01f, 2.43873492e-01f, -6.00607716e-04f, -1.06414139e-01f, 1.25831679e-01f,
  4.68800634e-01f, 1.91707402e-01f, 1.61105022e-01f, 1.23415425e-01f, -6.25622272e-02f, -3.27243768e-02f, -1.63533941e-01f, -3.07663858e-01f, -1.55900538e-01f, -8.78066644e-02f,
  -5.13088927e-02f, -2.71221638e-01f, -2.08193734e-01f, -2.25586995e-01f, -6.73132166e-02f, 6.97006583e-02f, 1.48954615e-01f, 2.17048805e-02f, 1.38061583e-01f, -9.67805162e-02f,
  2.88661689e-01f, 1.44279435e-01f, -1.40559286e-01f, 5.51476814e-02f, 1.53104886e-01f, -9.59880203e-02f, 3.38606886e-03f, 1.72003284e-02f, 6.78412169e-02f, -5.11777736e-02f,
  1.70706481e-01f, 4.28346321e-02f, -2.90972497e-02f, 9.45333764e-02f, 5.26189767e-02f, 1.99232809e-02f, -9.87950265e-02f, 1.40483538e-02f, -2.84236223e-02f, 2.37503499e-02f,
  1.04006365e-01f, 1.10820949e-01f, 2.89212838e-02f, 7.05597177e-02f, 8.05758163e-02f, 2.40844954e-02f, 1.93072274e-01f, 2.87048426e-02f, 7.61599839e-02f, -1.03013113e-01f,
  -4.68502529e-02f, 7.33737051e-02f, 1.12766512e-01f, 3.36343497e-02f, -5.17102294e-02f, 8.66196211e-03f, 3.93121280e-02f, -8.17271229e-03f, -5.00058457e-02f, 5.08305989e-03f,
  2.04626340e-02f, 6.14463948e-02f, 1.63950305e-02f, 2.27994639e-02f, 5.90481013e-02f, 2.94004381e-02f, 5.87125309e-02f, 2.11002473e-02f, -2.16133669e-02f, 2.48558703e-04f,
  7.63357729e-02f, 3.08228619e-02f, 7.66083226e-02f, -6.36838526e-02f, -1.60654467e-02f, -9.21298843e-03f, -2.51591280e-02f, 9.17551741e-02f, 3.84171568e-02f, -1.12166904e-01f,
  8.49462077e-02f, 1.59105316e-01f, -1.24626681e-01f, -4.87404615e-02f, -6.33570179e-03f, 1.59857944e-02f, 8.80641714e-02f, 6.69753551e-02f, 4.08986621e-02f, -1.80670470e-02f,
  1.64886564e-01f, -1.60649698e-02f, 1.58246264e-01f, 1.20840214e-01f, 3.31181288e-02f, 7.39482194e-02f, 7.26143196e-02f, -2.12623226e-03f, -2.93719191e-02f, -8.19463190e-03f,
  -1.29880086e-02f, -1.68123588e-01f, -4.38226685e-02f, 5.66885956e-02f, -3.66335399e-02f, -2.18822025e-02f, 1.38256192e-01f, 9.50689316e-02f, 1.97213423e-02f, -4.95644547e-02f,
  -6.96932912e-01f, 3.12055141e-01f, 3.01949888e-01f, -3.04176599e-01f, -8.86780582e-03f, 1.06055476e-01f, 9.83188823e-02f, -1.01922400e-01f, -1.92106724e-01f, 3.29175815e-02f,
  5.95643045e-03f, -1.59333870e-01f, -1.12554794e-02f, -6.23180903e-02f, -8.41453373e-02f, 3.04737031e-01f, 1.81640148e-01f, -9.18587595e-02f, -1.59755424e-01f, -1.89697087e-01f,
  -5.71104437e-02f, -1.07332401e-01f, -2.66766071e-01f, -1.26905560e-01f, 2.15340257e-01f, 4.31705117e-02f, 1.56952560e-01f, 2.44622100e-02f, 1.62705347e-01f, 3.21062922e-01f,
  2.19928429e-01f, -1.73431244e-02f, -2.00982064e-01f, -1.21223360e-01f, -5.93928173e-02f, -6.46769404e-02f, -5.00890939e-03f, -3.82083505e-02f, -1.07519314e-01f, 5.53792082e-02f,
  -9.35207158e-02f, -9.49611701e-03f, -1.35542884e-01f, 2.09586360e-02f, -1.41739190e-01f, 2.33488232e-02f, -1.05833210e-01f, -6.80788979e-02f, -3.58226262e-02f, 1.38810292e-01f,
  5.17575815e-02f, -9.70661640e-02f, 8.66532046e-03f, 3.70547995e-02f, 1.90638285e-02f, -2.09004343e-01f, 1.03070922e-01f, -4.07501198e-02f, -9.20207351e-02f, -7.35750571e-02f,
  -9.33202952e-02f, 2.47953255e-02f, -4.76712771e-02f, -2.69981436e-02f, -1.96416164e-03f, 6.29852340e-03f, 1.16986416e-01f, -1.98649969e-02f, -1.91576667e-02f, 8.20004940e-03f,
  1.57251544e-02f, 5.41646443e-02f, 4.70446199e-02f, 3.21391635e-02f, 1.12451762e-02f, 1.02641486e-01f, 4.46219072e-02f, 2.25673802e-02f, 1.13262236e-01f, 5.36348037e-02f,
  5.72948679e-02f, 4.32135724e-02f, 3.76389213e-02f, 8.56412128e-02f, 7.17582330e-02f, -2.47580581e-03f, 3.72693799e-02f, 4.83398978e-03f, -2.71301772e-02f, 7.27816224e-02f,
  -1.14272125e-01f, -2.53992021e-01f, 4.27899547e-02f, 9.87736508e-04f, 9.82955843e-03f, 3.70254368e-02f, -6.32436275e-02f, 1.89545483e-03f, -1.29519217e-02f, 1.17294183e-02f,
  1.05669171e-01f, -7.52208009e-02f, 3.30458805e-02f, 3.51963975e-02f, -8.24319124e-02f, -1.02449514e-01f, -9.52255353e-03f, -6.94761351e-02f, 2.79963203e-03f, 7.35501759e-03f,
  1.36315664e-02f, -1.16247512e-01f, -2.28912577e-01f, -1.91399194e-02f, -2.07409021e-02f, -1.35945320e-01f, -5.28669097e-02f, -4.23344150e-02f, -1.77581489e-01f, -1.64997607e-01f,
  -1.87035561e-01f, 3.28394085e-01f, 2.57866889e-01f, 1.45759270e-01f, 1.29390299e-01f, 7.58840218e-02f, 2.84166366e-01f, 1.35088086e-01f, 4.63575684e-02f, 1.60864398e-01f,
  -9.69029367e-02f, -2.66482502e-01f, -1.00146867e-01f, -5.80868796e-02f, 1.27217444e-02f, 2.80241966e-01f, 3.42557490e-01f, 7.88072273e-02f, -1.64458528e-01f, -1.14114188e-01f,
  -4.89632832e-03f, 6.58673719e-02f, -9.97541174e-02f, 2.33680494e-02f, 1.76097497e-01f, -2.75978148e-02f, 8.02089274e-02f, 1.23633906e-01f, 9.70042795e-02f, 3.02833200e-01f,
  1.21521331e-01f, -9.00530536e-03f, -9.58849266e-02f, -8.13930929e-02f, -5.75058945e-02f, 5.90361059e-02f, 8.29966664e-02f, 8.46922919e-02f, -8.84577930e-02f, 1.29725471e-01f,
  -9.91991460e-02f, -7.31782764e-02f, -8.98796916e-02f, 9.61551666e-02f, -4.91586514e-03f, 5.76768778e-02f, 5.41838631e-02f, -4.42577340e-02f, 1.05128862e-01f, -4.22106832e-02f,
  4.04493436e-02f, -6.06457293e-02f, 8.27267617e-02f, 8.38924423e-02f, 9.90401953e-02f, 6.78934529e-02f, 1.11627139e-01f, 3.95514667e-02f, 1.40693948e-01f, 2.70302445e-01f,
  -5.72411716e-02f, -3.46005820e-02f, 3.86185125e-02f, 5.56629859e-02f, 3.95718813e-02f, 5.45214005e-02f, 4.68922965e-02f, -7.85611290e-03f, 3.28265578e-02f, 4.74212728e-02f,
  -4.61838813e-03f, 4.81604802e-04f, -9.19495244e-03f, 5.02470769e-02f, 6.31163642e-02f, 1.17633909e-01f, 1.62279885e-02f, 8.70397165e-02f, -8.54998082e-03f, 3.36183980e-02f,
  -4.25536744e-02f, 1.59305346e-04f, 4.05922085e-02f, 8.51265192e-02f, 1.05065174e-01f, 9.49067101e-02f, 1.02242030e-01f, 4.75219861e-02f, 4.99956543e-03f, 8.35859478e-02f,
  1.67090535e-01f, -1.94450855e-01f, 1.24996312e-01f, 1.45862699e-02f, 5.51594198e-02f, -3.45861688e-02f, 1.11052312e-01f, 4.91724797e-02f, -2.35921759e-02f, 6.91188499e-02f,
  5.98168187e-02f, 3.58228199e-02f, 1.02142833e-01f, 5.05883135e-02f, 3.14482823e-02f, 1.01416022e-01f, 6.80486336e-02f, 4.72362861e-02f, -1.96514651e-02f, 1.63957939e-01f,
  1.05621845e-01f, 1.10220946e-01f, 1.33217260e-01f, 1.13060087e-01f, 1.07915781e-01f, -5.56310406e-03f, 1.53393716e-01f, 1.98880404e-01f, 1.11356251e-01f, 2.72626966e-01f,
  4.31145817e-01f, -1.51343329e-03f, 2.48376504e-01f, 2.42971987e-01f, 2.08420441e-01f, -4.61611860e-02f, -1.99642390e-01f, -2.85027236e-01f, 6.88116327e-02f, 5.16328551e-02f,
  -2.35370502e-01f, -3.41197073e-01f, -1.42191201e-01f, -3.10990602e-01f, -3.77148062e-01f, -1.46547481e-01f, 6.57443330e-02f, -8.20783973e-02f, -1.78962559e-01f, -1.63449392e-01f,
  -1.82991385e-01f, 2.56344769e-02f, -6.40069460e-03f, -9.21208039e-02f, 1.63090676e-01f, -8.13253522e-02f, 1.65551603e-01f, 1.62790686e-01f, -1.13642993e-04f, 2.16320336e-01f,
  2.42038459e-01f, 1.93366781e-01f, -8.48602727e-02f, -5.56701198e-02f, 4.06351350e-02f, -1.04645260e-01f, -8.89634565e-02f, -7.81701207e-02f, -8.59528556e-02f, -6.43967912e-02f,
  -8.40206444e-02f, -1.36298299e-01f, -9.82990935e-02f, -8.31292868e-02f, -2.50241254e-02f, -9.93617326e-02f, -1.02703623e-01f, -9.05721262e-02f, -3.37025560e-02f, -6.97587430e-02f,
  -5.62446415e-02f, 1.23281896e-01f, -4.93569672e-02f, -5.03251255e-02f, -1.82221025e-01f, -2.62179077e-02f, -8.10400769e-02f, -5.48047125e-02f, 8.28875881e-03f, 1.48594454e-01f,
  -1.15170330e-02f, -3.40936182e-04f, -4.86598313e-02f, -2.64537241e-02f, -1.54439909e-02f, 2.31524948e-02f, 3.26080509e-02f, -2.14733854e-02f, -1.65579596e-03f, 6.78194268e-03f,
  -4.70910519e-02f, 7.77644292e-02f, -2.01123748e-02f, 5.77014573e-02f, 1.86619908e-03f, 1.06221996e-02f, -6.68607131e-02f, -1.64197087e-02f, 7.33189890e-03f, -2.49952340e-04f,
  4.85218354e-02f, 9.37439948e-02f, 1.26048774e-01f, -5.31656146e-02f, -1.17539172e-03f, -9.53871757e-02f, 5.93587868e-02f, -5.45909964e-02f, -2.71975864e-02f, 6.90198541e-02f,
  -6.18346445e-02f, -1.93170920e-01f, 2.67512184e-02f, -5.22159375e-02f, 6.23658597e-02f, -1.02391802e-01f, 9.81203653e-03f, -9.26116575e-03f, -3.98301780e-02f, -1.11522160e-01f,
  -5.29998839e-02f, -1.41240075e-01f, -4.05922569e-02f, -3.55478413e-02f, -8.12017173e-02f, -6.60033002e-02f, -3.95969264e-02f, -3.74270491e-02f, -8.65585953e-02f, 1.74156409e-02f,
  1.04674632e-02f, -3.38830836e-02f, -6.46358505e-02f, 3.15590948e-02f, 7.43979290e-02f, 1.21755025e-03f, 4.26799767e-02f, -1.71329584e-02f, -1.38445720e-01f, 2.93770339e-02f,
  2.12704331e-01f, 1.29303023e-01f, -6.43931627e-02f, -6.28608987e-02f, 1.79852396e-02f, -4.07812260e-02f, -2.69114345e-01f, -1.49947673e-01f, -1.16061531e-02f, -1.66319832e-01f,
  2.83064432e-02f, -7.97897018e-03f, -2.75856387e-02f, -1.19161136e-01f, -3.49880636e-01f, -2.06472039e-01f, -2.84354478e-01f, -2.91980714e-01f, -3.05285662e-01f, -1.88564479e-01f,
  -1.27780288e-01f, -3.10954805e-02f, -8.34241658e-02f, -1.04034595e-01f, -1.38124563e-02f, 2.53158528e-02f, 2.63995975e-02f, 1.71769857e-02f, -7.70910317e-03f, -8.33833888e-02f,
  -1.01324767e-02f, 2.27861404e-01f, -5.24117760e-02f, 7.95937404e-02f, 1.31653205e-01f, 1.93956867e-02f, 1.29691288e-01f, 3.38516315e-03f, -2.92213988e-02f, -9.01483521e-02f,
  -4.36462089e-02f, 6.54115826e-02f, 7.74197280e-02f, -1.64156090e-02f, -4.38620895e-02f, -1.04891863e-02f, -4.29772101e-02f, 2.19586547e-02f, -4.59442548e-02f, 6.91818669e-02f,
  1.19456790e-01f, 6.23095445e-02f, -1.08595919e-02f, -2.22468711e-02f, 1.58596877e-02f, 6.39889538e-02f, 5.22703044e-02f, 1.17148878e-02f, 3.37496065e-02f, -8.10875669e-02f,
  -1.18506558e-01f, -8.46089870e-02f, -9.94360298e-02f, -1.58966988e-01f, -4.15350534e-02f, -9.15310681e-02f, -3.95592786e-02f, -1.77976668e-01f, -7.60628656e-02f, -9.03416947e-02f,
  -1.25716135e-01f, -1.53488936e-02f, -8.25387165e-02f, -1.23934835e-01f, -9.95063782e-02f, -1.44611567e-01f, -2.46091047e-03f, -1.26310065e-01f, -1.94535721e-02f, -4.86908806e-03f,
  -5.60621396e-02f, -3.93082984e-02f, -4.35896739e-02f, -8.72227401e-02f, 2.03350913e-02f, -1.56506836e-01f, -9.50868651e-02f, -1.30399033e-01f, -5.14897071e-02f, -1.13458775e-01f,
  -2.17695963e-02f, 2.17810795e-01f, 6.31494671e-02f, -3.64188626e-02f, 3.01344842e-02f, 1.73822582e-01f, 2.01350480e-01f, 3.65552455e-02f, 1.67576537e-01f, 4.46747476e-03f,
  1.10027298e-01f, 1.04010589e-02f, 6.59993514e-02f, 1.61980018e-02f, -5.40186204e-02f, -1.04394434e-02f, -8.89733434e-02f, 3.89327966e-02f, 1.05966583e-01f, 8.74739438e-02f,
  6.26224428e-02f, 6.51739389e-02f, 3.88328433e-02f, 2.63906969e-03f, 4.21735682e-02f, 1.79316893e-01f, -6.37988746e-02f, -1.12737622e-02f, -4.38774191e-02f, -1.49853811e-01f,
  -4.39124942e-01f, -2.13032737e-01f, -1.01665579e-01f, 2.62188334e-02f, 2.76432782e-01f, 2.30225936e-01f, 1.53408587e-01f, 8.59942585e-02f, -4.18352783e-02f, -4.84479405e-02f,
  1.26224132e-02f, -1.32373974e-01f, -2.06957072e-01f, -1.19643606e-01f, -1.41854778e-01f, -1.63333327e-01f, 3.13714780e-02f, -1.52704373e-01f, 3.11756087e-03f, 1.06770292e-01f,
  1.80076823e-01f, -3.10952845e-03f, -9.79509875e-02f, -3.57135162e-02f, 7.75204301e-02f, 1.04774348e-02f, -8.23011473e-02f, 7.49130100e-02f, 8.53360966e-02f, -1.10122479e-01f,
  -2.64017045e-01f, 3.21754813e-02f, -1.26053886e-02f, -7.31951278e-03f, 2.41503306e-03f, -1.50682554e-01f, -1.07603081e-01f, -4.21316624e-02f, -1.20502096e-02f, -6.04746714e-02f,
  -4.32717018e-02f, 2.40180194e-02f, 1.50415050e-02f, -2.51360051e-02f, -9.21943560e-02f, -5.23066297e-02f, -4.95880842e-02f, -7.52453655e-02f, -6.23081550e-02f, -6.93294629e-02f,
  1.38316065e-01f, 6.13720119e-02f, -1.57916665e-01f, -5.82249835e-02f, -9.73950177e-02f, -4.92116213e-02f, -1.81313410e-01f, -7.64068440e-02f, -1.88292369e-01f, -2.79167742e-01f,
  3.65231708e-02f, -8.81625805e-03f, 5.92547506e-02f, -2.74778735e-02f, 2.35934346e-03f, -9.56280250e-03f, 1.74084567e-02f, 1.04370169e-01f, 9.95024443e-02f, 2.92825736e-02f,
  8.97074193e-02f, 7.08394423e-02f, 6.55023083e-02f, 5.39672524e-02f, 9.59694162e-02f, 5.98444566e-02f, 1.14606492e-01f, -3.08601651e-02f, 9.29619521e-02f, -8.51364434e-03f,
  6.66706339e-02f, -9.16570704e-03f, 8.52986425e-02f, 1.37923419e-01f, 7.82756507e-02f, -2.25761980e-02f, -3.71672101e-02f, 5.85950054e-02f, -2.18048152e-02f, 6.65562600e-02f,
  -2.25185558e-01f, 2.09674239e-02f, -2.47459829e-01f, -1.42301872e-01f, -2.21619736e-02f, -1.05412543e-01f, -2.75283754e-02f, -6.22623712e-02f, -9.39665884e-02f, -9.94350016e-02f,
  5.28991967e-02f, -6.23205788e-02f, -9.35597196e-02f, -2.80761681e-02f, -8.23296979e-03f, -3.28863524e-02f, -9.26425830e-02f, -8.96727443e-02f, -1.03959285e-01f, 1.95879359e-02f,
  -1.13088906e-01f, -1.22721016e-01f, -2.01040357e-01f, -2.03210548e-01f, -4.83755134e-02f, -1.81081861e-01f, -1.90674782e-01f, -1.58208668e-01f, -1.43191591e-01f, -2.33639568e-01f,
  -3.55532974e-01f, -1.98462054e-01f, 1.72066242e-01f, 1.50052935e-01f, 5.70034683e-02f, -1.65156946e-01f, -3.95872951e-01f, -1.54093251e-01f, -4.41096164e-03f, -4.01953161e-02f,
  -2.23002210e-01f, -3.79405282e-02f, -5.06938510e-02f, -8.01637843e-02f, -1.49046510e-01f, -5.90516068e-02f, 1.41655833e-01f, 1.53885290e-01f, 1.94258155e-05f, -8.06788430e-02f,
  -7.50414729e-02f, -2.27676402e-03f, 1.18760802e-01f, 1.46872088e-01f, 2.97868639e-01f, 1.29371732e-01f, 2.27730483e-01f, 1.64439499e-01f, -6.39413968e-02f, 1.88618958e-01f,
  -2.83126690e-04f, -1.11246489e-01f, -1.76549759e-02f, -5.63416295e-02f, -6.51747957e-02f, -4.28623259e-02f, -1.50386661e-01f, 2.39119306e-02f, -9.55631360e-02f, 7.86396116e-03f,
  -7.25319283e-03f, 1.32901724e-02f, -1.73849780e-02f, -9.68499761e-03f, 6.33754134e-02f, 1.08957337e-02f, 1.33568734e-01f, 3.09610814e-02f, 9.37320217e-02f, -1.94773101e-03f,
  -1.62799507e-02f, -1.68032735e-03f, -1.12501919e-01f, -5.71838394e-02f, 2.72190198e-02f, 9.11212191e-02f, -7.99577609e-02f, 1.34183583e-03f, 4.96241264e-02f, -7.62099922e-02f,
  -1.36420071e-01f, -1.34143308e-02f, 9.35790688e-02f, 6.01307005e-02f, 5.53023964e-02f, 1.16383202e-01f, 6.77848607e-02f, 3.55995893e-02f, 5.18227406e-02f, 9.20826942e-02f,
  9.42947641e-02f, 2.64090337e-02f, 6.48874268e-02f, -3.42751318e-03f, 6.75276890e-02f, 1.87880080e-02f, 8.60106200e-03f, 3.15747596e-02f, 5.51120117e-02f, 6.64576218e-02f,
  2.56500840e-02f, 3.02239340e-02f, 6.16578870e-02f, 7.61733949e-02f, -1.91883370e-02f, 2.88920943e-02f, 5.72918281e-02f, -2.79809218e-02f, 6.26777206e-03f, 6.16445802e-02f,
  -1.64337754e-01f, -1.55870885e-01f, 1.07715065e-02f, -4.51654531e-02f, 9.12140906e-02f, -2.32201014e-02f, -6.78024068e-02f, 5.37494309e-02f, -2.04020664e-02f, -1.15719228e-03f,
  -6.98850602e-02f, -1.07788965e-01f, -2.41291132e-02f, 1.64367389e-02f, -6.67463765e-02f, -8.30478501e-03f, -3.10334750e-02f, 3.81370261e-03f, -8.51230919e-02f, -6.80439249e-02f,
  -9.96400416e-02f, -1.95289642e-01f, -1.64444879e-01f, -1.05400160e-01f, 7.49217644e-02f, -1.69289500e-01f, -1.72751367e-01f, -1.15748502e-01f, -1.15727924e-01f, -2.31076896e-01f,
  3.31561744e-01f, 2.29961470e-01f, -2.23681852e-02f, 3.12400937e-01f, -4.17883508e-02f, -4.92953658e-02f, 2.08813414e-01f, 2.87063476e-02f, 1.25029027e-01f, 1.68859214e-01f,
  -3.10760111e-01f, -4.16288823e-01f, -3.09100300e-01f, -2.44365707e-01f, -1.11085147e-01f, 2.94103920e-01f, 3.29320103e-01f, -8.29754099e-02f, -1.83587581e-01f, -8.91380012e-02f,
  1.05940424e-01f, 1.00684054e-01f, 7.86692873e-02f, 1.33563951e-01f, 1.20735668e-01f, -1.19980462e-02f, 2.23130956e-02f, 1.32656366e-01f, 5.21832798e-03f, 3.34155709e-01f,
  -3.41269560e-02f, -8.73280168e-02f, -1.77031979e-01f, -4.28352542e-02f, -7.73516223e-02f, -4.66984734e-02f, 1.54532576e-02f, 3.19336876e-02f, -5.57233766e-02f, 3.39652458e-03f,
  -7.85858780e-02f, -6.67867437e-02f, -1.14382051e-01f, -4.19933312e-02f, -2.20236368e-02f, 3.62636894e-02f, -2.87704282e-02f, -9.26710516e-02f, -5.81971779e-02f, -1.05758816e-01f,
  7.23085878e-03f, -5.27783185e-02f, -1.81809422e-02f, -9.20820534e-02f, -5.62836304e-02f, -8.71250853e-02f, -1.31351307e-01f, 1.72264297e-02f, -4.01384458e-02f, 1.15163758e-01f,
  8.82034376e-02f, 1.18189566e-01f, 1.19849160e-01f, 9.72571075e-02f, 1.57203987e-01f, 3.48151810e-02f, 1.53839722e-01f, 2.52948683e-02f, 8.80294740e-02f, 1.57171786e-01f,
  -9.35237040e-04f, 1.25993073e-01f, 1.84838623e-02f, 1.45336539e-01f, 2.10073870e-02f, 1.36559963e-01f, 8.05739090e-02f, 1.44637704e-01f, 2.60772798e-02f, 4.71085906e-02f,
  1.30863339e-01f, 8.81764572e-03f, 1.16917968e-01f, -1.10796490e-03f, 1.07567400e-01f, 6.61962926e-02f, 1.38079062e-01f, 7.88096245e-03f, 5.33501543e-02f, 1.23076282e-01f,
  -4.30147909e-02f, -3.06129277e-01f, 8.89263302e-03f, -1.33532390e-01f, -1.04630366e-01f, -8.89872238e-02f, -1.12662546e-01f, -9.14880335e-02f, -1.58516586e-01f, -5.39418645e-02f,
  -1.76542655e-01f, -7.25404471e-02f, -5.49204238e-02f, -6.27012849e-02f, -4.95714135e-02f, -2.79501285e-02f, 1.69757009e-03f, -3.62874381e-02f, -9.05500054e-02f, -5.96086942e-02f,
  4.65984233e-02f, 7.78417587e-02f, -3.33016180e-02f, -6.96533248e-02f, -1.52112260e-01f, -9.01110619e-02f, -5.63136153e-02f, -8.76355544e-02f, -1.58784002e-01f, 1.81085527e-01f,
  -6.59245700e-02f, -2.04224169e-01f, -3.86792094e-01f, -1.16053827e-01f, -9.00562853e-02f, -1.68708980e-01f, -2.07825124e-01f, 1.52862698e-01f, 6.85028881e-02f, -2.26558149e-01f,
  -1.28791809e-01f, 1.77127585e-01f, 1.53696388e-01f, 2.38250926e-01f, 1.47696093e-01f, -2.83213675e-01f, -2.97637135e-01f, 1.06912978e-01f, 2.82903284e-01f, 1.45181835e-01f,
  4.02797684e-02f, 1.63200200e-02f, 2.05261439e-01f, 8.95524025e-02f, -2.11542174e-01f, 5.12255132e-02f, -1.55248150e-01f, -1.18468456e-01f, -1.37844771e-01f, -3.03219616e-01f,
  -2.68817037e-01f, -2.02965602e-01f, 1.80750817e-01f, 1.15408853e-01f, 6.36857748e-03f, 5.37594296e-02f, 3.48102115e-02f, -2.61142030e-02f, -1.81992271e-03f, -5.42381406e-02f,
  -5.69221843e-03f, 7.32267946e-02f, -1.93014033e-02f, 5.20531461e-02f, 7.99734592e-02f, -5.57998614e-03f, -3.64923663e-02f, 1.06229059e-01f, 8.80902037e-02f, 4.99869436e-02f,
  -6.89246207e-02f, -3.86604890e-02f, 7.19763618e-03f, 1.12731524e-01f, 8.82222131e-02f, 4.11391743e-02f, -4.76284027e-02f, 3.27611007e-02f, 1.05358638e-01f, -8.79542679e-02f,
  -2.53179539e-02f, -2.26515513e-02f, 4.12453972e-02f, 4.96450774e-02f, 1.90266073e-02f, -6.27646223e-02f, 3.39696221e-02f, -4.17164005e-02f, 8.90719220e-02f, 2.46506650e-02f,
  7.33445361e-02f, -3.50077376e-02f, 7.06441328e-02f, -1.01942300e-04f, -4.21644300e-02f, 3.60336266e-02f, -3.07054222e-02f, -3.94897275e-02f, -2.88038165e-03f, 5.11720590e-02f,
  5.32390142e-04f, 4.29468928e-03f, 1.81372510e-03f, 2.54715439e-02f, -8.03976730e-02f, 3.69905457e-02f, -5.37662618e-02f, 9.94334370e-02f, 6.59351647e-02f, -7.89529160e-02f,
  3.80066305e-01f, 1.58790037e-01f, -1.22063041e-01f, 6.11715317e-02f, -1.42413929e-01f, -2.67358907e-02f, -7.27126300e-02f, 1.76968444e-02f, -7.97125399e-02f, -2.54281256e-02f,
  -3.16595994e-02f, 2.00651530e-02f, -1.56368259e-02f, -1.86615773e-02f, 3.09887435e-02f, -1.65890418e-02f, -4.58516879e-03f, -7.06351474e-02f, 7.90012032e-02f, 3.75396349e-02f,
  6.13255315e-02f, 3.26823816e-02f, 8.38625804e-02f, 1.62869066e-01f, 1.16396591e-01f, 1.76346615e-01f, 6.75794929e-02f, 1.35249317e-01f, 6.21467419e-02f, 6.21183217e-02f,
  3.18938911e-01f, 2.35530376e-01f, 2.57578880e-01f, 2.86979795e-01f, 2.79371142e-01f, 6.37196004e-02f, 2.00091228e-01f, 1.35397632e-02f, 2.96427472e-03f, 1.55596510e-01f,
  8.93682465e-02f, -7.64495581e-02f, 8.34464431e-02f, 8.02688673e-02f, 3.49147022e-02f, 1.91091657e-01f, 2.37678900e-01f, 1.53250456e-01f, 8.70392891e-04f, 1.94805875e-01f,
  2.09221736e-01f, 1.37948692e-01f, 2.07317129e-01f, 1.23729363e-01f, 3.71420570e-02f, 6.74699545e-02f, 1.46180704e-01f, 7.65301660e-02f, 1.11987591e-01f, 1.64473414e-01f,
  1.03354238e-01f, -1.36757083e-02f, -1.06956825e-01f, -1.46815728e-03f, -2.08637826e-02f, 3.79051385e-03f, 4.73373160e-02f, -1.62979215e-01f, -3.40214893e-02f, 3.13027650e-02f,
  -7.09035026e-04f, 3.41736451e-02f, -7.72574022e-02f, 4.13331911e-02f, 6.37437999e-02f, -3.19176284e-03f, -1.20174646e-01f, 1.98330805e-02f, -3.57768275e-02f, 6.68313205e-02f,
  2.98216827e-02f, 1.16950676e-01f, -2.89801843e-02f, -1.01394452e-01f, -6.65911846e-03f, -7.11423606e-02f, -6.79985806e-02f, -1.06590532e-01f, -1.03513263e-01f, 1.45023800e-02f,
  -6.33253455e-02f, 3.29692774e-02f, -6.22847117e-02f, -3.18436064e-02f, 3.42720933e-02f, -6.52339961e-03f, -1.87631808e-02f, 8.85235742e-02f, -3.08506265e-02f, -4.02384251e-02f,
  3.28062959e-02f, 6.71754032e-02f, 8.84518102e-02f, 1.22111432e-01f, 6.09137118e-02f, 2.34827632e-03f, 5.12026213e-02f, -2.67418697e-02f, 3.93991955e-02f, 5.45930117e-02f,
  -2.73239538e-02f, -4.87829559e-02f, 4.69650328e-02f, -7.05360025e-02f, 6.42611757e-02f, 1.79048404e-02f, -6.72170846e-03f, -2.76219714e-02f, -8.40190426e-03f, 8.43914151e-02f,
  -2.60148942e-01f, 2.16085631e-02f, -3.04906182e-02f, -1.41355649e-01f, -3.29860486e-02f, -9.40234810e-02f, -7.21802376e-03f, -1.34603053e-01f, 1.93235502e-02f, 6.13492727e-02f,
  -4.99168970e-02f, 1.03840055e-02f, 8.61451998e-02f, -5.02092913e-02f, 4.69865017e-02f, -6.30323961e-02f, 4.10830788e-02f, 1.72687229e-02f, -4.01413441e-02f, -7.58944079e-02f,
  -6.04487099e-02f, -5.77704050e-02f, -1.73813343e-01f, -1.94450900e-01f, -2.02620681e-02f, -1.18870221e-01f, -5.58471084e-02f, -1.08994305e-01f, -4.14104983e-02f, -1.07491910e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.20997322e-01f, -5.15545726e-01f, 1.16593651e-01f, 4.52160209e-01f, 5.29164374e-01f, 5.00767112e-01f, 2.00012222e-01f, 3.88030261e-01f, 3.87227058e-01f, 2.27158651e-01f,
  -1.93635765e-02f, 2.09555045e-01f, 1.49444565e-01f, 1.53410733e-01f, 5.30510321e-02f, 4.34929341e-01f, 4.35146600e-01f, 2.82826185e-01f, 2.16891125e-01f, 2.35975087e-01f,
  2.04439998e-01f, 1.76210869e-02f, -1.82384461e-01f, 1.09723113e-01f, 1.36372864e-01f, 2.27288380e-01f, 1.13762394e-01f, -6.29564002e-02f, -1.53015601e-02f, 2.07873181e-01f,
  -2.00805858e-01f, -3.49084944e-01f, 2.65733778e-01f, -2.20336154e-01f, -2.98318475e-01f, -1.22437507e-01f, -6.87160715e-02f, -1.43320903e-01f, -1.20038107e-01f, -2.51741707e-03f,
  -4.04424779e-03f, -1.95189580e-01f, -1.16443135e-01f, -1.31216854e-01f, -2.26381160e-02f, -1.05524138e-01f, -9.81094465e-02f, -5.24430070e-03f, 1.35922432e-01f, 4.80671972e-02f,
  9.07865763e-02f, 1.50264084e-01f, 1.25927016e-01f, 8.89839381e-02f, 5.83696738e-02f, -2.38425145e-03f, -1.94990695e-01f, -8.63534510e-02f, -8.75006691e-02f, -7.00491890e-02f,
  9.75741372e-02f, -1.08981859e-02f, 1.15542471e-01f, 5.61515801e-02f, -2.80832704e-02f, 1.07221343e-01f, 1.83405936e-01f, 3.71893123e-02f, 1.22593910e-01f, -1.89504549e-02f,
  1.51539594e-01f, 7.96050504e-02f, 1.26072958e-01f, -4.46099825e-02f, 9.98152643e-02f, 1.27803147e-01f, -4.74430732e-02f, -4.13997807e-02f, -1.47074565e-01f, -2.55997549e-03f,
  -4.20057178e-02f, -9.67308972e-03f, -9.73522216e-02f, -6.66727498e-02f, 1.21308789e-02f, 8.46059322e-02f, 1.57396898e-01f, 1.55650219e-03f, -8.27435683e-03f, -2.18567029e-02f,
  1.76493242e-01f, 6.19311854e-02f, 1.37840241e-01f, 1.01179533e-01f, -1.11744843e-01f, -2.12885395e-01f, 9.08000916e-02f, -5.31322844e-02f, -1.92558303e-01f, 1.41609572e-02f,
  -8.76793712e-02f, -9.86436903e-02f, -2.30412647e-01f, -4.29993942e-02f, -2.08094306e-02f, 1.49567900e-02f, -1.33944616e-01f, 2.38244727e-01f, 1.12302974e-01f, -2.64511574e-02f,
  -8.09354931e-02f, 3.05264115e-01f, 3.22481513e-01f, 2.89012551e-01f, 2.22050212e-02f, 2.36681774e-01f, -3.53976674e-02f, 5.05751446e-02f, 6.95721135e-02f, -3.20577659e-02f,
  8.40691477e-02f, -7.50821605e-02f, -2.80356288e-01f, 3.59391510e-01f, 3.95169914e-01f, 1.52399242e-01f, -1.42976224e-01f, -1.02525406e-01f, 1.06710635e-01f, 1.11854836e-01f,
  3.20789933e-01f, 4.99522805e-01f, 3.05916429e-01f, 3.15211982e-01f, -2.76662465e-02f, -9.80507880e-02f, -1.39445227e-04f, -1.66242681e-02f, -5.31567745e-02f, 1.19348153e-01f,
  3.61967295e-01f, 1.64286807e-01f, 1.49040923e-01f, 9.79234353e-02f, 9.87004489e-02f, 3.60653281e-01f, 1.42834902e-01f, 2.47364327e-01f, 7.87486583e-02f, 4.82303416e-03f,
  -1.16529286e-01f, -1.97390795e-01f, 1.21812969e-01f, 2.74595439e-01f, 1.49524257e-01f, -1.75614357e-01f, -1.04476146e-01f, -1.71477437e-01f, 4.85598706e-02f, -1.35480613e-01f,
  7.75402263e-02f, -6.41842857e-02f, 1.67750016e-01f, -6.55802563e-02f, -1.06175616e-01f, -1.29550204e-01f, -9.19596925e-02f, -2.79050887e-01f, -7.37805367e-02f, -1.46447256e-01f,
  1.97915286e-01f, 1.98483348e-01f, -4.45787832e-02f, 1.33168502e-02f, -1.10427372e-01f, 3.33811760e-01f, 7.33978599e-02f, -7.47428983e-02f, -1.04007512e-01f, -2.46220633e-01f,
  1.44344673e-01f, 7.88852014e-03f, 1.98218003e-01f, -1.28013194e-01f, 7.37531632e-02f, 2.34394446e-02f, 2.00712252e-02f, 1.02297731e-01f, 6.59058942e-03f, -4.05094447e-03f,
  -9.31397378e-02f, 1.16548073e-02f, -1.91818669e-01f, -3.27684656e-02f, 2.39755929e-01f, 6.59155324e-02f, -4.96595725e-02f, 1.54903624e-02f, 1.35610744e-01f, 1.29579917e-01f,
  2.53372062e-02f, -1.10563658e-01f, 2.45670807e-02f, -7.37338066e-02f, 4.04381864e-02f, 1.75264087e-02f, 3.29684615e-02f, 1.84342057e-01f, 2.13706151e-01f, 1.16813287e-01f,
  -2.75119264e-02f, 4.74298775e-01f, -1.86900347e-01f, -1.29225492e-01f, -7.50784501e-02f, -2.57385690e-02f, 1.31758019e-01f, -1.49269119e-01f, -2.07266398e-02f, -2.25838661e-01f,
  -6.78082556e-02f, -7.83744678e-02f, 7.81914219e-03f, -8.61604363e-02f, -9.77430493e-02f, 3.88406813e-02f, -3.33804674e-02f, 4.50744759e-03f, -1.31431669e-01f, -2.70370871e-01f,
  4.30057347e-02f, -1.50453985e-01f, -1.43407375e-01f, -1.45705968e-01f, 2.37944778e-02f, 2.09427595e-01f, -2.54556350e-02f, -1.67997539e-01f, -1.06570691e-01f, -1.95804507e-01f,
  9.53018546e-01f, 4.41099048e-01f, 3.43077958e-01f, 3.01461190e-01f, 1.09099194e-01f, 2.58919120e-01f, 3.03182751e-01f, 1.48442894e-01f, -1.93035218e-03f, 1.96829453e-01f,
  3.20598215e-01f, 2.56393775e-02f, 1.12978272e-01f, 3.90480552e-03f, 1.96569666e-01f, -1.55830249e-01f, -2.94331163e-01f, 8.17273036e-02f, 2.69838925e-02f, 1.77653298e-01f,
  -9.39495210e-03f, 2.13835731e-01f, 2.00692207e-01f, 6.25224179e-03f, 4.86292057e-02f, -1.04219757e-01f, 1.28329501e-01f, 1.22502103e-01f, 8.61677229e-02f, -1.58900738e-01f,
  2.55617291e-01f, 5.08708239e-01f, -2.78780103e-01f, -1.71411499e-01f, 1.28383785e-01f, -1.37736842e-01f, 8.25375021e-02f, -9.25606936e-02f, -8.16965029e-02f, -2.21665755e-01f,
  -2.72554383e-02f, -7.29733333e-02f, 4.91044112e-02f, 1.22588255e-01f, 4.03117910e-02f, 4.56758961e-02f, 7.44541213e-02f, -3.69788073e-02f, -5.97309247e-02f, 6.26323000e-03f,
  -2.44694892e-02f, 5.37012704e-02f, 8.19054469e-02f, 3.76470722e-02f, 1.53663203e-01f, -7.01595172e-02f, 4.90629859e-02f, 8.15752298e-02f, -1.30978655e-02f, 1.82801932e-02f,
  -2.57946521e-01f, -6.95084929e-02f, 2.06284672e-01f, 3.43783759e-02f, 5.58629259e-03f, 4.04730067e-02f, -2.73587555e-02f, 9.60726216e-02f, 8.16634521e-02f, 5.94632365e-02f,
  -9.90375578e-02f, -2.64741611e-02f, 4.77930009e-02f, -1.41617970e-03f, -4.39634621e-02f, 1.77231446e-01f, 8.25525224e-02f, 8.29793338e-04f, 2.24032417e-01f, -1.23229008e-02f,
  -4.96509522e-02f, -1.72581196e-01f, 3.43903191e-02f, -1.19673098e-02f, -1.54920176e-01f, -4.94934507e-02f, -2.35479660e-02f, 4.48497273e-02f, 4.14092699e-03f, -5.18212952e-02f,
  -3.23500931e-01f, 4.11051363e-01f, -1.24278583e-01f, -2.47718424e-01f, 6.13511540e-02f, -1.74225178e-02f, 8.28620419e-02f, -3.60288806e-02f, -1.01517379e-01f, -6.81671575e-02f,
  3.93709838e-02f, -7.66171366e-02f, 2.27971956e-01f, -7.74670616e-02f, -1.40971184e-01f, -1.01011589e-01f, -5.09740785e-02f, -1.65861472e-01f, -1.21420391e-01f, -1.05234191e-01f,
  -1.44707665e-01f, -2.03236699e-01f, -1.78824902e-01f, -2.47033209e-01f, -1.72448590e-01f, -2.88043737e-01f, -6.59988970e-02f, -1.19841985e-01f, -9.11011398e-02f, -1.19372256e-01f,
  5.69927931e-01f, 3.89003426e-01f, -1.59566075e-01f, 3.26643765e-01f, -3.23023528e-01f, -5.30960858e-01f, -6.49378419e-01f, -2.80918360e-01f, 7.82468468e-02f, 1.45824939e-01f,
  1.43940933e-02f, 1.64019570e-01f, 7.65285194e-02f, 3.80236804e-02f, -1.75501168e-01f, -3.26304853e-01f, -2.99694359e-01f, 4.31438610e-02f, -1.26096174e-01f, -7.42325112e-02f,
  -2.00571846e-02f, 2.63429523e-01f, 2.33850583e-01f, 1.75149560e-01f, 3.14766467e-01f, 7.23430440e-02f, 4.95054619e-03f, -1.80942789e-02f, -2.10075513e-01f, 1.20617904e-01f,
  3.78290981e-01f, 1.67957559e-01f, 3.62335308e-03f, 1.89516738e-01f, 1.26170471e-01f, 3.70919973e-01f, 8.15845132e-02f, 2.37736329e-01f, 1.82735950e-01f, 1.18612371e-01f,
  1.24253772e-01f, 5.73640354e-02f, 7.83693418e-02f, 7.57573396e-02f, 9.02936980e-02f, 1.46739647e-01f, 1.89313561e-01f, -1.09459534e-02f, -1.06649451e-01f, 7.68409520e-02f,
  6.86988458e-02f, -6.64805919e-02f, -2.26655424e-01f, -2.61114031e-01f, -1.00471795e-01f, -2.58068498e-02f, 1.33443838e-02f, 2.70776562e-02f, -1.66200295e-01f, -6.56386241e-02f,
  -2.17333645e-01f, -2.76181381e-02f, 4.35837992e-02f, 4.22451086e-02f, -1.78604305e-01f, -1.94060057e-02f, -1.28380015e-01f, -2.36960366e-01f, -2.45398805e-01f, -7.15077743e-02f,
  8.93002078e-02f, -1.26761943e-01f, -5.86199341e-03f, 1.68124381e-02f, 1.36770993e-01f, -7.84859508e-02f, 3.17637175e-02f, 1.11193554e-02f, -1.65254734e-02f, -5.29400930e-02f,
  -1.53331608e-01f, -1.17080390e-01f, 1.39231130e-01f, -2.35969201e-02f, 1.12857312e-01f, 1.53119862e-01f, 2.78787203e-02f, -5.02377078e-02f, -5.49867079e-02f, -7.10831303e-03f,
  1.84525326e-01f, -3.76969099e-01f, 1.55420318e-01f, 4.42732796e-02f, -5.07288007e-03f, 2.79221982e-01f, 4.94472906e-02f, 1.00991338e-01f, 1.26513138e-01f, 2.41301171e-02f,
  1.08142309e-01f, 1.29973263e-01f, 1.07391007e-01f, 1.67505909e-02f, 5.75401299e-02f, 1.16414994e-01f, 1.02108806e-01f, 1.12131439e-01f, 7.84780085e-02f, 2.36693919e-01f,
  1.60574257e-01f, -1.50696591e-01f, -1.50721580e-01f, -1.08165061e-03f, 2.87962728e-03f, -3.80671360e-02f, 4.58596237e-02f, 5.90689518e-02f, -2.39509970e-01f, -9.13773775e-02f,
  -6.69942141e-01f, -7.75179207e-01f, 5.17355680e-01f, -4.91396993e-01f, -1.28836617e-01f, -7.46102780e-02f, -9.07625377e-01f, 4.59377142e-03f, -3.32626216e-02f, -7.92754650e-01f,
  -1.69160068e-01f, 4.15570319e-01f, 3.81138414e-01f, 4.99742299e-01f, 2.99764872e-01f, -8.29064727e-01f, -4.72488970e-01f, 4.69188988e-01f, 7.83229649e-01f, 1.19944930e-01f,
  -4.56798285e-01f, -3.44243824e-01f, 3.38579148e-01f, 2.79268235e-01f, -7.63401330e-01f, -2.14187026e-01f, -1.78831875e-01f, -3.75363201e-01f, -3.18213403e-01f, -1.07566333e+00f,
  -2.08111882e-01f, 5.07483445e-03f, 4.68044996e-01f, 3.10629040e-01f, -2.38659889e-01f, -9.68448967e-02f, -1.32778855e-02f, 1.00928536e-02f, -4.43486199e-02f, -5.85500821e-02f,
  -1.24786057e-01f, 3.49748075e-01f, -1.53111473e-01f, -3.98486741e-02f, -2.83770621e-01f, 5.09713031e-03f, -1.27123697e-02f, 6.67179823e-02f, 1.15112804e-01f, -9.46129560e-02f,
  -6.27524912e-01f, -4.82214570e-01f, 1.64367482e-01f, 1.56571522e-01f, 2.26074621e-01f, 3.46177399e-01f, 2.79436857e-01f, 1.18745267e-01f, 1.60781026e-01f, -9.91396308e-01f,
  -1.52877793e-01f, -6.74929768e-02f, -4.81346846e-02f, 2.81546824e-02f, -1.33520320e-01f, -6.88352957e-02f, -1.76384635e-02f, -3.08067918e-01f, 2.20714986e-01f, -2.28959322e-01f,
  1.18129551e-01f, -3.73135880e-02f, 1.74594849e-01f, -1.09429240e-01f, 5.72069846e-02f, -1.10374384e-01f, -1.91592842e-01f, -1.37630865e-01f, -2.39110715e-03f, -7.65647218e-02f,
  5.02493456e-02f, -3.75932865e-02f, -2.28551459e-02f, 5.15773147e-02f, 9.13335010e-02f, 5.81332184e-02f, 2.29755342e-02f, 2.07884043e-01f, -7.15897679e-02f, 2.45512631e-02f,
  9.67342705e-02f, 6.06996357e-01f, -5.58857501e-01f, 2.40324527e-01f, -2.99789757e-01f, 1.22591116e-01f, -2.97243390e-02f, 1.12371199e-01f, 6.63924590e-02f, 3.15698385e-02f,
  3.63230556e-01f, -1.17443703e-01f, -2.50446256e-02f, 6.71125725e-02f, -1.56923644e-02f, -3.40964794e-02f, -3.40806782e-01f, -1.66032359e-01f, 6.73174933e-02f, -1.13015264e-01f,
  -8.89211595e-02f, -3.69914263e-01f, -1.85468167e-01f, -1.26356557e-01f, -3.12936187e-01f, 1.04864836e-01f, 1.62981480e-01f, -1.64376467e-01f, -6.09569363e-02f, -8.38129997e-01f,
  1.46056354e-01f, 2.74850041e-01f, -2.00545311e-01f, 3.07567000e-01f, 1.60406113e-01f, 3.42266619e-01f, 4.87952471e-01f, 4.53925788e-01f, 2.67606974e-01f, 3.42286021e-01f,
  3.44419837e-01f, 4.38485563e-01f, 2.95524836e-01f, 2.90123641e-01f, 2.87594020e-01f, 3.19914937e-01f, 2.35781863e-01f, -3.34537961e-03f, 3.11385654e-03f, 8.85066539e-02f,
  2.14778170e-01f, 4.78155129e-02f, -1.04479827e-01f, 2.31361408e-02f, 5.29627614e-02f, 2.10098609e-01f, 6.60655946e-02f, -4.87918779e-02f, 5.12478724e-02f, -1.36064008e-01f,
  -3.99776846e-01f, -2.54682750e-01f, 3.86700109e-02f, 2.09428538e-02f, -1.78925529e-01f, -4.75578271e-02f, -1.38383716e-01f, -6.43288642e-02f, 2.03964151e-02f, 8.92957393e-03f,
  -5.74035794e-02f, -2.07694873e-01f, -1.39344230e-01f, -9.18242037e-02f, -7.61844441e-02f, -1.66535974e-01f, -5.37679084e-02f, 2.25374922e-02f, 8.26849565e-02f, -1.25764664e-02f,
  -2.87425555e-02f, -7.55392909e-02f, -1.55600399e-01f, 5.99911585e-02f, 2.83907503e-02f, -2.60876399e-02f, 1.81939229e-02f, -2.95193326e-02f, 5.37521131e-02f, -1.02342419e-01f,
  3.35732512e-02f, 9.69419554e-02f, -5.88998944e-02f, -1.53719848e-02f, 9.48808417e-02f, -9.14240908e-03f, -3.14441025e-02f, 2.77319588e-02f, 1.16967902e-01f, -9.38910767e-02f,
  -1.15672730e-01f, -2.14893874e-02f, -1.75137058e-01f, 1.10423081e-02f, -1.34414628e-01f, -1.97068930e-01f, -1.75662756e-01f, -1.29607707e-01f, -2.57129610e-01f, -4.46707457e-02f,
  -1.24433264e-01f, 1.50381243e-02f, -2.49100327e-01f, -1.43294334e-01f, -2.13881835e-01f, -1.46308392e-01f, -1.48964882e-01f, 4.72926274e-02f, 3.43001001e-02f, 9.03940722e-02f,
  1.76455066e-01f, -7.09707290e-02f, 6.08169362e-02f, 6.33172095e-02f, -9.40002948e-02f, -9.74700078e-02f, -8.45004022e-02f, -1.00989066e-01f, -5.30541241e-02f, -2.90290429e-03f,
  -1.93648599e-02f, -1.82479694e-01f, 1.03766378e-02f, 4.95667160e-02f, -1.30175412e-01f, -1.59143597e-01f, -1.81584843e-02f, 5.90431020e-02f, 4.75888140e-02f, 9.37652122e-03f,
  5.61713204e-02f, -5.42380698e-02f, 6.18185401e-02f, 5.46137467e-02f, 1.48842797e-01f, 1.12265304e-01f, -4.91708703e-02f, -6.26251474e-02f, -4.63940315e-02f, 1.41068757e-01f,
  6.77612007e-01f, -7.65726924e-01f, 2.63186425e-01f, 3.06583613e-01f, 1.80294201e-01f, 3.02454650e-01f, -7.73399547e-02f, -2.21729670e-02f, 1.69373661e-01f, -1.10438414e-01f,
  -1.83278516e-01f, 7.96720088e-02f, 9.81461480e-02f, 4.37439866e-02f, 1.10453673e-01f, -7.49262273e-02f, 5.20193279e-02f, 4.33411896e-01f, 3.43863755e-01f, -5.65866567e-02f,
  -2.38414019e-01f, -9.88084525e-02f, 7.08630756e-02f, -9.29900035e-02f, -2.99972236e-01f, 1.81821764e-01f, 4.99486402e-02f, -1.81542948e-01f, -1.69898316e-01f, -2.56820947e-01f,
  -3.11562330e-01f, 2.22297199e-02f, 9.25269574e-02f, -2.85040066e-02f, -9.44330078e-03f, -5.27311638e-02f, 5.43206185e-02f, -1.74540266e-01f, -1.12083867e-01f, -7.79357031e-02f,
  -1.84413716e-02f, -1.96106434e-02f, -3.20026954e-03f, -1.42009240e-02f, -2.09198017e-02f, -3.83139104e-02f, -1.15163006e-01f, -4.96364646e-02f, -2.42693792e-03f, -1.08469330e-01f,
  -1.98421583e-01f, 4.19955403e-02f, 7.49829188e-02f, -4.07914259e-02f, 5.08373268e-02f, 1.64881155e-01f, -3.08170412e-02f, -1.98977571e-02f, 1.67935550e-01f, -9.21351314e-02f,
  -2.72303857e-02f, 5.15147373e-02f, 8.06828886e-02f, 9.08602551e-02f, 4.07322459e-02f, 1.46567568e-01f, 1.38754219e-01f, -4.05249782e-02f, 1.37281299e-01f, 4.02363501e-02f,
  -5.31054959e-02f, 9.68059972e-02f, 2.08789021e-01f, -2.09927354e-02f, 7.35394433e-02f, -3.35546657e-02f, 3.40777710e-02f, -5.36667220e-02f, 1.03084713e-01f, -5.77971376e-02f,
  2.55984366e-02f, -6.15637451e-02f, -9.26515013e-02f, -7.68106952e-02f, -1.42149821e-01f, 5.79060465e-02f, 1.32430103e-02f, -7.45274276e-02f, -6.80499300e-02f, -6.79602697e-02f,
  -4.39523280e-01f, 5.75589120e-01f, 1.56184837e-01f, 4.31769267e-02f, -9.80089977e-02f, 1.17262416e-02f, 7.72236586e-02f, -1.23663805e-01f, -1.67572781e-01f, -2.85175834e-02f,
  -9.62432623e-02f, 2.96210055e-03f, -1.38157457e-02f, -1.23418868e-01f, 7.00938031e-02f, 1.00136012e-01f, -1.35580003e-01f, 4.14813384e-02f, -2.77916137e-02f, -9.95524600e-02f,
  -1.40717477e-01f, 1.01159766e-01f, 2.46656507e-01f, 1.95676535e-01f, 8.24378207e-02f, 3.64580780e-01f, 2.33547986e-02f, 1.19197462e-02f, 1.70428693e-01f, 3.23994756e-02f,
  6.99718297e-01f, 4.46400136e-01f, 4.24501896e-01f, 1.34827942e-01f, -4.10073966e-01f, -2.28416100e-01f, -1.35968938e-01f, -1.05500720e-01f, -1.83591634e-01f, -2.11619195e-02f,
  -9.80877355e-02f, -2.83479780e-01f, -6.05371557e-02f, 9.52287391e-02f, 3.30146760e-01f, 2.19639912e-01f, 2.00606048e-01f, 3.61078233e-01f, 2.59628773e-01f, 6.36412278e-02f,
  -7.99672416e-05f, 2.00245395e-01f, 3.80132884e-01f, 2.30529428e-01f, 1.44224182e-01f, -1.93407506e-01f, 1.39787599e-01f, 8.26193690e-02f, 1.65310010e-01f, 3.89618903e-01f,
  1.97385624e-01f, 3.24033439e-01f, -4.20296729e-01f, -1.78215131e-01f, 9.85557120e-03f, 6.46602511e-02f, 4.60160673e-02f, 1.95266455e-02f, -1.12394184e-01f, -9.88694131e-02f,
  -8.11874419e-02f, 1.62769351e-02f, 6.88952729e-02f, -8.93295109e-02f, -3.06910984e-02f, -1.50051862e-01f, 1.59575537e-01f, 1.70924947e-01f, 3.53302695e-02f, 8.89456272e-02f,
  -1.16412722e-01f, -1.73887372e-01f, -5.15545299e-03f, -1.53368250e-01f, 7.52000287e-02f, -3.23863417e-01f, 5.99502102e-02f, -3.01842224e-02f, -1.54537812e-01f, 1.99736971e-02f,
  -4.74389613e-01f, 1.09552823e-01f, 1.83382835e-02f, -4.86116298e-02f, -5.89721650e-02f, -2.01975346e-01f, -5.72567098e-02f, 2.51412131e-02f, 2.13901307e-02f, -7.73845762e-02f,
  -1.32482469e-01f, -4.31136340e-02f, -8.34207460e-02f, -7.56826773e-02f, -1.42687604e-01f, -2.86120027e-02f, 1.87061671e-02f, -1.01503514e-01f, -1.53831035e-01f, -1.11588120e-01f,
  -6.37476966e-02f, 5.44089377e-02f, -9.54401642e-02f, -3.46964411e-02f, -2.32411221e-01f, -1.20378703e-01f, -1.19750112e-01f, -1.76019266e-01f, -1.41678303e-01f, -1.87865630e-01f,
  -3.97973508e-01f, -2.86666989e-01f, 2.14901771e-02f, 3.33339840e-01f, 1.68675452e-01f, 1.02671258e-01f, 1.47849515e-01f, 1.47545636e-01f, 7.11712092e-02f, 4.26183529e-02f,
  1.48141280e-01f, 1.41354620e-01f, 5.39545268e-02f, 7.97703043e-02f, -2.73048729e-01f, -1.75866365e-01f, 2.00123852e-03f, 1.17261566e-01f, 5.67965060e-02f, 6.19504042e-02f,
  -9.60097164e-02f, -2.00224206e-01f, -2.96995997e-01f, -1.59376323e-01f, -1.42460436e-01f, -3.66269261e-01f, -2.16677576e-01f, -1.60959527e-01f, -2.17193738e-01f, -3.07734072e-01f,
  2.42726222e-01f, -8.79016936e-01f, 2.05484420e-01f, -7.44584054e-02f, 1.57326013e-01f, 3.58210027e-01f, -4.79695882e-04f, -3.39802019e-02f, -9.20577422e-02f, -3.51745069e-01f,
  -4.98222202e-01f, -2.63992339e-01f, -2.47014910e-01f, -2.64203280e-01f, -1.78230733e-01f, -1.84594050e-01f, 6.16143830e-02f, 4.43595946e-01f, 6.76249743e-01f, 3.05146843e-01f,
  -9.04168859e-02f, 2.33427193e-02f, 1.45755202e-01f, 4.92219515e-02f, -3.62703770e-01f, 6.91459253e-02f, -1.56637922e-01f, -1.37313917e-01f, -3.39657724e-01f, -5.21015704e-01f,
  1.95680052e-01f, -2.76662976e-01f, 2.48965696e-01f, -2.48057485e-01f, -6.01176545e-02f, -2.11916231e-02f, 1.41675577e-01f, -7.85487518e-02f, -1.09043628e-01f, 1.32579240e-03f,
  -9.68485978e-03f, -2.11122986e-02f, -5.13414703e-02f, 2.37347446e-02f, 1.29908264e-01f, 1.47256836e-01f, -3.57501693e-02f, -1.04812689e-01f, -2.37026185e-01f, -1.24777921e-01f,
  -2.64071822e-01f, -3.90855297e-02f, 7.01041296e-02f, 5.71329668e-02f, -3.57086360e-02f, 1.46953300e-01f, 3.83369252e-02f, -3.66060100e-02f, 2.68121511e-02f, 7.71039426e-02f,
  2.99807787e-02f, -9.88461375e-02f, -1.19411750e-02f, 4.81802933e-02f, 1.13532886e-01f, 6.58254176e-02f, 3.14682238e-02f, 3.22805941e-02f, 6.72951564e-02f, 4.41619335e-03f,
  -1.04551069e-01f, 1.29466783e-02f, -7.61782080e-02f, 5.04160970e-02f, -1.22996062e-01f, -2.33301148e-01f, -1.40634492e-01f, -8.20026100e-02f, -5.67368045e-02f, -1.67358577e-01f,
  -7.79509218e-03f, -5.70427813e-02f, -2.85688434e-02f, -3.58547717e-02f, -1.10902622e-01f, 1.05177043e-02f, -7.53731504e-02f, 1.01590483e-02f, -6.30492419e-02f, -1.51587144e-01f,
  -1.07446782e-01f, 1.02157168e-01f, 1.07116491e-01f, -1.77367434e-01f, -1.08538978e-02f, -1.78715631e-01f, 1.07613299e-02f, 9.42118689e-02f, -8.72896239e-02f, 1.57934159e-01f,
  -1.89310778e-02f, 7.33335689e-02f, -3.72152478e-02f, -3.94014046e-02f, 3.95331979e-01f, 2.97527254e-01f, -3.30913961e-02f, -1.31050125e-02f, -1.55939594e-01f, -1.90710396e-01f,
  -1.55904338e-01f, 1.07582949e-01f, 1.96708471e-01f, 3.61013785e-02f, 9.86595675e-02f, 2.59106845e-01f, 1.99615866e-01f, 2.08593547e-01f, 2.52357304e-01f, 2.36969709e-01f,
  -7.41291702e-01f, -2.41118267e-01f, -7.66403258e-01f, -3.62070829e-01f, -3.06430310e-01f, 2.05370948e-01f, 6.31335199e-01f, 3.59540641e-01f, -4.81993973e-01f, -2.85100788e-01f,
  -2.39724219e-01f, -2.09819481e-01f, -5.90575099e-01f, -1.26951173e-01f, 2.08700076e-01f, 1.50596946e-01f, -2.98466440e-02f, 4.05375212e-02f, 5.30599236e-01f, 8.22401881e-01f,
  3.87423843e-01f, 3.95417288e-02f, 8.19537491e-02f, 3.54837775e-01f, -7.47191086e-02f, -1.71330422e-01f, -2.86923379e-01f, -2.01481938e-01f, 1.57056212e-01f, -2.71001995e-01f,
  -4.16159689e-01f, 1.54775959e-02f, 1.26147553e-01f, -1.80433705e-01f, -3.77141386e-01f, -5.91437742e-02f, 1.63612753e-01f, -4.08593774e-01f, -1.56078801e-01f, -7.80303329e-02f,
  -3.53918135e-01f, -3.61965485e-02f, -4.03090924e-01f, -2.99300812e-02f, 4.58475538e-02f, 2.94726372e-01f, 4.48163822e-02f, 1.75742030e-01f, -2.58858770e-01f, 3.36939096e-02f,
  1.45960271e-01f, 1.74184423e-02f, -3.35801095e-01f, 1.45126551e-01f, 2.39728883e-01f, -2.98744619e-01f, 1.58181116e-01f, 4.29048836e-01f, -1.87941808e-02f, -1.92977652e-01f,
  1.12436891e-01f, -2.50887871e-01f, -1.61835223e-01f, -2.53575388e-02f, 2.12229297e-01f, -1.33785427e-01f, 9.02192947e-03f, 2.70803291e-02f, -3.29522491e-02f, -2.50272434e-02f,
  6.08337075e-02f, -1.19778678e-01f, 1.25464648e-01f, -3.64232622e-02f, 8.16450082e-03f, -1.30092338e-01f, 3.91894169e-02f, 1.61798149e-01f, 7.07215741e-02f, -3.28527056e-02f,
  -9.60702449e-03f, -4.62882482e-02f, -1.95602044e-01f, 2.95949936e-01f, 4.13097367e-02f, 6.73644170e-02f, -7.88713992e-02f, 1.00515157e-01f, -1.32226378e-01f, 1.15726076e-01f,
  -3.51194650e-01f, 1.95635512e-01f, -3.43963265e-01f, 2.22794577e-01f, -2.11510494e-01f, 4.88208495e-02f, 1.98345594e-02f, 3.21350852e-03f, -2.54594862e-01f, 7.37662688e-02f,
  1.78382322e-01f, -7.96473399e-02f, -2.32888594e-01f, 1.68742672e-01f, 5.70492744e-02f, -4.80506942e-02f, 6.84711188e-02f, -2.08296329e-01f, -2.96081672e-03f, 3.28191221e-02f,
  -8.35275725e-02f, 1.35932863e-01f, -4.44593877e-01f, -2.61754662e-01f, -9.74639039e-03f, -2.87598908e-01f, -2.65120119e-01f, -3.07949688e-02f, -2.19506666e-01f, -2.31736124e-01f,
  2.63951480e-01f, 8.05644751e-01f, -2.27964684e-01f, -6.17190190e-02f, -1.77715763e-01f, 1.75536245e-01f, 8.26911449e-01f, 5.92249751e-01f, -7.81450048e-02f, 4.53794479e-01f,
  1.60641402e-01f, -7.84810662e-01f, -5.95116675e-01f, -5.46370685e-01f, -1.71440542e-01f, 2.82824695e-01f, -2.50184357e-01f, -6.41450405e-01f, -9.35330391e-01f, -2.67258525e-01f,
  -3.13057363e-01f, -1.12987302e-01f, -3.53983521e-01f, -4.48097676e-01f, -2.72637963e-01f, -9.70030785e-01f, -4.73944992e-02f, -6.17628060e-02f, -1.64939955e-01f, -6.07688367e-01f,
  -1.99133858e-01f, 5.53140461e-01f, -5.45137346e-01f, -5.08642972e-01f, 7.24702254e-02f, -1.43755749e-01f, 1.24568604e-01f, 3.48568372e-02f, -1.00948839e-02f, 1.70294508e-01f,
  -6.74505979e-02f, -8.93449783e-02f, -6.67222887e-02f, -3.74521524e-01f, 3.83471437e-02f, -8.65455568e-02f, -1.38665080e-01f, -1.41736239e-01f, -2.09947959e-01f, 2.49825671e-01f,
  1.47397146e-01f, 9.84175950e-02f, 8.62995256e-03f, 1.71058372e-01f, 6.96357936e-02f, -3.82658899e-01f, 2.09755629e-01f, -2.05607831e-01f, -2.89409488e-01f, 5.97432666e-02f,
  3.12263016e-02f, 9.76011977e-02f, -2.71069277e-02f, 2.78626472e-01f, 1.18315555e-02f, 9.47690383e-02f, -5.56889139e-02f, 9.50900912e-02f, 9.18757617e-02f, 7.63582299e-04f,
  -1.72006842e-02f, 2.40780756e-01f, -7.70144816e-03f, 9.02110636e-02f, -3.58158574e-02f, -1.09893471e-01f, -2.63597444e-02f, 1.22031994e-01f, 2.39643753e-02f, -1.78716362e-01f,
  -2.20701694e-01f, -1.24040760e-01f, -1.06674388e-01f, -1.46827087e-01f, 5.29021062e-02f, 1.11670882e-01f, 9.01481286e-02f, -1.00366017e-02f, 1.48051390e-02f, -1.10971808e-01f,
  -3.31092894e-01f, -9.49454755e-02f, 1.18336396e-03f, -1.21022157e-01f, -9.79291461e-03f, -1.14645973e-01f, 8.59716758e-02f, 1.16463602e-02f, 7.25617632e-02f, 2.02733129e-01f,
  1.18459284e-01f, 9.38321427e-02f, 1.98272131e-02f, -3.24639566e-02f, 3.24401855e-02f, 4.24870811e-02f, 1.46620765e-01f, -3.55896801e-01f, -8.07287917e-02f, 2.04133794e-01f,
  1.47848159e-01f, 4.97145504e-02f, -1.09755479e-01f, -1.70242772e-01f, 2.42106169e-01f, -5.03564537e-01f, -3.84582192e-01f, -2.04637393e-01f, -1.62990749e-01f, 2.62787521e-01f,
  1.00512516e+00f, 2.81385988e-01f, 4.81908113e-01f, 7.91073442e-02f, 1.69081818e-02f, 3.01393658e-01f, 3.34103405e-01f, 3.47318649e-01f, 1.29408523e-01f, 1.32055119e-01f,
  3.94545309e-02f, -1.36665538e-01f, 8.02621916e-02f, -7.02975765e-02f, 6.39400333e-02f, 1.17497839e-01f, 8.63446295e-02f, 2.33263567e-01f, 2.88716644e-01f, 1.61620647e-01f,
  -2.21099645e-01f, 1.33607313e-02f, 1.50476053e-01f, 1.63178742e-01f, -2.09919028e-02f, -1.84231490e-01f, 5.82251810e-02f, -2.47317348e-02f, -4.00702208e-02f, 3.72305140e-02f,
  1.30945429e-01f, 4.55916315e-01f, -1.43129572e-01f, -1.78523809e-01f, 4.63149697e-03f, -3.40499878e-02f, -6.42414168e-02f, -8.64493996e-02f, -1.01188652e-01f, -1.45086184e-01f,
  -1.55288965e-01f, -3.27043943e-02f, 3.68723720e-02f, 3.76160489e-04f, 8.48266929e-02f, 5.29260654e-03f, 1.21196367e-01f, 1.17370747e-01f, 9.65301841e-02f, -7.47049600e-02f,
  -2.46108115e-01f, -4.01196623e-04f, 1.56273518e-03f, -2.42243260e-02f, 1.90544918e-01f, -3.41576859e-02f, 7.71823302e-02f, 4.85171266e-02f, 1.02208458e-01f, 1.42806888e-01f,
  6.73459992e-02f, 6.69314712e-02f, 1.38042331e-01f, 1.08776428e-01f, 1.30259514e-01f, 1.02276303e-01f, 8.67832899e-02f, -1.15544334e-01f, 3.55115458e-02f, 9.07334313e-02f,
  6.98166639e-02f, 1.42395809e-01f, 2.79462188e-01f, 3.34534720e-02f, -1.82461992e-01f, -1.32567525e-01f, -9.48517323e-02f, -1.14459693e-01f, 1.24775488e-02f, 1.48846377e-02f,
  9.00501683e-02f, 1.30164161e-01f, 1.90120623e-01f, 1.37273580e-01f, 1.69659540e-01f, 8.09830725e-02f, 1.45434933e-02f, -8.77318904e-04f, 6.75926954e-02f, 2.42884103e-02f,
  -5.08680403e-01f, -1.83600672e-02f, 1.63769051e-02f, 5.82640618e-02f, 2.76116095e-03f, -4.03621942e-02f, -9.11197662e-02f, -1.07797049e-01f, -2.69266963e-01f, -1.60551444e-01f,
  -8.36461633e-02f, 6.14556558e-02f, 4.29115705e-02f, 6.90949410e-02f, 1.55175542e-02f, -2.14389771e-01f, -6.09379038e-02f, 4.57343161e-02f, -1.24748386e-01f, -2.15816274e-01f,
  -8.49100798e-02f, 2.17757188e-02f, -3.94994859e-03f, -2.12173928e-02f, -1.40604470e-02f, 3.46035622e-02f, -4.82965261e-02f, -3.65215056e-02f, 1.30125880e-02f, -8.23128521e-02f,
  2.56862372e-01f, -6.45707622e-02f, 9.66599807e-02f, -7.60774165e-02f, 4.62422729e-01f, 5.77625036e-01f, 1.10602140e+00f, 4.09173280e-01f, -1.09844714e-01f, 2.81575888e-01f,
  1.60265137e-02f, -7.69126534e-01f, -6.39384866e-01f, -7.20620215e-01f, -2.52688736e-01f, 3.60649049e-01f, 3.67036909e-01f, -1.98262841e-01f, -1.80293202e-01f, 1.82525322e-01f,
  4.53230552e-03f, 3.96150440e-01f, 2.11344406e-01f, 3.32095381e-03f, -1.50804386e-01f, -3.88423532e-01f, 2.41917074e-01f, 1.80823028e-01f, 1.43595725e-01f, -5.64141810e-01f,
  -4.08443242e-01f, 1.56515270e-01f, 2.13620421e-02f, -1.03011593e-01f, -8.83968771e-02f, 1.34335116e-01f, 1.44365504e-01f, -4.40217555e-02f, -9.79793146e-02f, -1.03353098e-01f,
  -1.28464535e-01f, -1.92086294e-01f, -2.62474507e-01f, -1.06651723e-01f, -3.37598845e-02f, 1.64537966e-01f, 2.66629811e-02f, -1.17210142e-01f, -5.67014217e-01f, -1.97838187e-01f,
  -2.67974943e-01f, 1.76897094e-01f, 1.78471416e-01f, 1.00049181e-02f, -3.62454444e-01f, -1.23528950e-01f, -3.49888988e-02f, -2.18554571e-01f, -1.14993893e-01f, -1.79566368e-01f,
  7.24820793e-02f, -1.07329659e-01f, 8.76136422e-02f, 1.16432980e-01f, 3.75503190e-02f, -6.54336112e-03f, -2.30168924e-01f, -1.93103582e-01f, -1.23866171e-01f, 1.65942013e-01f,
  -4.16392125e-02f, 9.59810801e-03f, -1.63573235e-01f, 1.03902884e-01f, -5.51533476e-02f, -3.68522177e-03f, 1.36118367e-01f, -1.79836303e-01f, -1.61014423e-02f, 2.22371876e-01f,
  5.75448349e-02f, 5.55227138e-03f, -7.91386887e-02f, -2.85821795e-01f, 1.78925261e-01f, -8.00946280e-02f, 4.99800146e-02f, -1.50966719e-01f, -3.25315185e-02f, 2.57055819e-01f,
  -1.00256152e-01f, 2.87715375e-01f, -1.72194853e-01f, -4.17958982e-02f, -9.24539566e-03f, -6.72030821e-02f, -2.03204751e-02f, 3.58165316e-02f, -1.16802510e-02f, -2.02673569e-01f,
  5.45690209e-02f, -2.06254110e-01f, -3.44649673e-01f, 5.73716238e-02f, -2.12448202e-02f, 8.85498896e-02f, 6.24732673e-02f, -6.63147196e-02f, -8.03497657e-02f, 2.87339576e-02f,
  -5.62889613e-02f, 2.06451505e-01f, 2.64761865e-01f, 5.10682426e-02f, -1.92209166e-02f, 2.24780813e-01f, 1.28653377e-01f, 1.92382801e-02f, 2.12473303e-01f, 6.21840835e-01f,
  -5.49777269e-01f, 2.34998986e-01f, -3.04516345e-01f, -4.40786123e-01f, 4.42899972e-01f, 2.40650892e-01f, -1.81576051e-02f, -1.37900025e-01f, -3.40056010e-02f, -1.44033223e-01f,
  4.41779941e-01f, 2.46092811e-01f, -3.97904724e-01f, -1.86992452e-01f, -7.34130502e-01f, -5.70808232e-01f, -7.01851964e-01f, -7.76921868e-01f, -3.09678048e-01f, 6.05202377e-01f,
  4.86111939e-01f, -1.51057318e-01f, -4.72763956e-01f, -3.43283117e-01f, 5.22589460e-02f, -1.07468389e-01f, -4.48030710e-01f, -2.12403402e-01f, 1.40242502e-01f, -1.80109873e-01f,
  -2.26064473e-01f, 2.72599101e-01f, 8.01988095e-02f, 2.29619160e-01f, 2.72601187e-01f, -1.44684851e-01f, 9.43247974e-02f, -1.40763983e-01f, 1.33059509e-02f, -7.20767453e-02f,
  2.99526095e-01f, 3.12993824e-01f, 1.19171910e-01f, 8.24452043e-02f, -1.92170236e-02f, -1.37171507e-01f, -9.84877869e-02f, -2.21613884e-01f, -2.61760324e-01f, 3.13484043e-01f,
  4.45308536e-01f, 1.22332647e-01f, -2.85016567e-01f, -2.41927013e-01f, -1.91427425e-01f, -2.99554586e-01f, 1.83927864e-01f, 8.33029449e-02f, -5.56867123e-01f, -5.07422864e-01f,
  -9.76963937e-02f, 4.47911136e-02f, 2.81250805e-01f, 9.48188230e-02f, -2.17052549e-01f, -3.10195722e-02f, -9.90745127e-02f, -1.17506333e-01f, 5.97974733e-02f, -4.48145755e-02f,
  -3.02806739e-02f, 1.60461175e-04f, -6.38786256e-02f, -2.67324358e-01f, -1.53300494e-01f, -6.73786104e-02f, -1.58789814e-01f, -3.51972759e-01f, -3.03311497e-01f, -8.69699344e-02f,
  5.01831397e-02f, -1.06196301e-02f, 4.96574603e-02f, -1.90278634e-01f, 9.11171734e-02f, -1.61373690e-01f, 1.53038472e-01f, 1.47697315e-01f, 2.49837086e-01f, 3.05883437e-02f,
  -4.63587075e-01f, 3.45761068e-02f, -3.65234733e-01f, 3.12607698e-02f, 5.85593991e-02f, -4.69684824e-02f, 6.85295323e-03f, 2.45777562e-01f, 7.69307911e-02f, 7.15539679e-02f,
  4.03442144e-01f, -5.91734685e-02f, -5.45482561e-02f, 3.16675425e-01f, 1.12835780e-01f, 8.14569145e-02f, -1.03806913e-01f, -1.51809707e-01f, 9.62184742e-03f, 3.60059500e-01f,
  -1.87723055e-01f, -6.85649872e-01f, -5.98954976e-01f, -6.65596843e-01f, -4.73080240e-02f, -6.23773336e-01f, -3.36354643e-01f, -3.64634424e-01f, -7.46378958e-01f, -1.07245958e+00f,
  -9.99104381e-01f, 5.92758730e-02f, -3.99438262e-01f, 3.29749346e-01f, 4.67781216e-01f, -2.99435079e-01f, -6.71926200e-01f, -4.41162318e-01f, 1.44288599e-01f, -8.12408254e-02f,
  -6.20333217e-02f, 9.40473899e-02f, 1.73367560e-01f, 7.36622810e-02f, -4.64968711e-01f, 2.95100778e-01f, 5.50831020e-01f, -1.95309937e-01f, -7.13340998e-01f, -2.93211609e-01f,
  4.56433237e-01f, 1.54697835e-01f, -4.26029027e-01f, -1.22495927e-01f, 3.97166520e-01f, 3.70915323e-01f, 4.96316671e-01f, 2.74508715e-01f, 9.53296423e-02f, 4.83949631e-01f,
  -5.50886452e-01f, -5.65019786e-01f, 3.57943811e-02f, 2.46512815e-01f, 1.75087288e-01f, -4.75811809e-01f, -1.26514137e-01f, -4.32888977e-04f, -5.86933047e-02f, -1.24675877e-01f,
  1.99355856e-01f, -2.77672499e-01f, 2.24430874e-01f, 7.90580437e-02f, -1.57313734e-01f, -5.17637730e-01f, 1.14564337e-01f, -4.72406149e-01f, -4.30110693e-01f, -6.62321627e-01f,
  4.23916936e-01f, 9.95215625e-02f, -4.26778316e-01f, -2.69142807e-01f, -3.94077897e-01f, 1.23131454e-01f, -6.02218807e-01f, -6.55096591e-01f, -7.01340020e-01f, -6.17982864e-01f,
  -1.98018461e-01f, 8.38693008e-02f, -2.76663546e-02f, -6.65171519e-02f, 1.39710933e-01f, 2.38352895e-01f, 1.21465310e-01f, -7.34123513e-02f, -2.42838897e-02f, -1.00131005e-01f,
  1.90318581e-02f, -2.92667057e-02f, -3.73800248e-02f, -9.12679583e-02f, 3.81968506e-02f, -6.90466315e-02f, 6.80321530e-02f, -1.02039762e-02f, 1.26584649e-01f, 1.39782792e-02f,
  -1.61588624e-01f, -3.25507581e-01f, 2.89348364e-01f, -2.95249261e-02f, 5.23292869e-02f, 3.23664956e-02f, 5.67090651e-03f, -2.56625295e-01f, -6.41470850e-02f, -1.56244904e-01f,
  2.41776496e-01f, 4.67129499e-01f, -1.78834110e-01f, 6.67286813e-02f, -3.67954858e-02f, 1.34824768e-01f, 1.60579994e-01f, -1.08977705e-02f, 8.96777958e-03f, -3.33403260e-01f,
  -2.90598661e-01f, -2.85707563e-01f, 2.35888973e-01f, -4.22791168e-02f, -1.47084400e-01f, 8.47074240e-02f, 5.47200561e-01f, 1.18843645e-01f, 2.09110260e-01f, 7.41654560e-02f,
  3.67118627e-01f, -2.35490605e-01f, -2.17448875e-01f, -1.34768277e-01f, 1.12381987e-01f, -1.65612087e-01f, -3.54024023e-01f, -4.37289566e-01f, -4.49093610e-01f, -2.96360314e-01f,
  1.31046101e-01f, 5.81007600e-01f, -4.48907465e-01f, 3.24743807e-01f, 2.04748511e-01f, -2.80928940e-01f, -9.69609469e-02f, -3.85880142e-01f, -1.39344960e-01f, -7.24199601e-03f,
  -1.82920650e-01f, 6.59788847e-02f, 1.03273891e-01f, 1.97304010e-01f, 1.61013659e-03f, 1.97451577e-01f, 2.98007369e-01f, 1.15370959e-01f, -3.81130981e-03f, 2.02624470e-01f,
  4.63455319e-01f, 3.82707417e-01f, 2.12418452e-01f, -1.62508152e-02f, 5.05013168e-01f, 3.45315009e-01f, -1.76994875e-03f, 4.70832229e-01f, 3.12092602e-01f, 7.05478311e-01f,
  8.43606368e-02f, -4.95593756e-01f, -4.24933970e-01f, 3.20840538e-01f, 9.82168391e-02f, -3.73548232e-02f, -6.48925453e-02f, 2.02704445e-02f, 1.60040464e-02f, 3.03006500e-01f,
  4.31610793e-01f, -9.25711021e-02f, 1.35349110e-01f, 1.71657294e-01f, 2.48340428e-01f, -2.10708633e-01f, -1.46783099e-01f, -3.88395578e-01f, -3.30694705e-01f, -3.44580114e-01f,
  5.87844133e-01f, 1.52688459e-01f, -4.00390238e-01f, -4.82415944e-01f, -3.78459811e-01f, 5.97996712e-02f, -1.36267364e-01f, -1.83895841e-01f, -5.36486387e-01f, 6.64226040e-02f,
  -1.99559450e-01f, -1.67030804e-02f, 1.20148621e-01f, 5.89877628e-02f, 3.05405885e-01f, 1.47884652e-01f, 1.17854223e-01f, 6.83325976e-02f, 2.25009620e-01f, 7.19591156e-02f,
  1.98903065e-02f, -9.99166667e-02f, -1.45632386e-01f, -5.06246090e-02f, 3.05984281e-02f, -2.90493108e-02f, 2.93948293e-01f, 3.49556543e-02f, -2.93237846e-02f, -3.03783178e-01f,
  1.37528658e-01f, 4.44390923e-02f, 6.16858006e-02f, -1.47552295e-02f, -5.66601604e-02f, -1.32912904e-01f, 2.07594752e-01f, 1.45495698e-01f, 1.27980694e-01f, 1.29181370e-01f,
  1.23016141e-01f, -5.50997734e-01f, 3.01858559e-02f, 9.92071778e-02f, 5.03799915e-02f, -8.70456025e-02f, -4.22296077e-02f, 4.42617163e-02f, -2.23845299e-02f, 1.74825415e-01f,
  -1.92340575e-02f, 1.19757932e-02f, -5.51441312e-02f, 1.92584097e-02f, -1.17229186e-01f, -2.52689868e-01f, 1.50267616e-01f, -8.98627639e-02f, -1.19776256e-01f, -1.83207124e-01f,
  2.65832722e-01f, -1.96836680e-01f, -1.25855342e-01f, -2.96197355e-01f, -3.17411155e-01f, -1.89015180e-01f, 2.91524455e-02f, -1.12032227e-01f, -5.48100352e-01f, -4.93859351e-02f,
  -1.30414799e-01f, 2.21252114e-01f, 8.86795402e-01f, -2.70085424e-01f, -6.72125220e-01f, -4.92106199e-01f, -8.05812299e-01f, -2.61950344e-01f, 2.30250154e-02f, 1.41168386e-01f,
  -3.20904404e-01f, -5.36851346e-01f, 1.67974904e-01f, -3.28012332e-02f, -2.12504137e-02f, 3.30219030e-01f, 5.74282527e-01f, 2.84094006e-01f, -4.20047909e-01f, -9.67701256e-01f,
  -7.11122751e-01f, -2.88937598e-01f, 1.30997926e-01f, 1.05372377e-01f, 2.07262129e-01f, 6.43043667e-02f, 7.41080105e-01f, 1.56429067e-01f, 1.62286013e-01f, 7.03081191e-01f,
  4.28949475e-01f, 4.76345479e-01f, -1.08788796e-01f, -1.97843611e-01f, -3.89495268e-02f, 1.62128791e-01f, -4.19674441e-03f, 4.23776746e-01f, -9.52409580e-02f, 3.34617436e-01f,
  -3.13121140e-01f, -1.03622444e-01f, -2.69083202e-01f, -1.89578943e-02f, -1.97437048e-01f, -6.69914261e-02f, 4.32087272e-01f, 2.17962712e-01f, 2.07635239e-01f, -3.66381444e-02f,
  -7.42352664e-01f, -5.43702126e-01f, 4.57368344e-02f, 2.26435348e-01f, 3.24590564e-01f, -2.84308642e-01f, 4.15271483e-02f, 1.29411861e-01f, 3.65464181e-01f, 5.22063494e-01f,
  3.00774928e-02f, 1.18555330e-01f, 2.53313910e-02f, 2.60974884e-01f, -1.27745092e-01f, 2.80134883e-02f, 1.91996977e-01f, -1.87971473e-01f, 3.21232225e-03f, -7.42708072e-02f,
  7.58149847e-02f, -2.60844547e-02f, -6.69387681e-03f, 8.90995041e-02f, 2.00499862e-01f, 5.54905646e-02f, -7.84395114e-02f, 7.08427206e-02f, 1.02728039e-01f, 4.81679514e-02f,
  -2.23176941e-01f, -9.95726511e-02f, -6.37235269e-02f, 6.21372946e-02f, 1.46380126e-01f, 1.43135294e-01f, 2.80057453e-03f, -1.05424030e-02f, 5.73946238e-02f, -1.18628133e-03f,
  -4.58608508e-01f, 1.14302617e-02f, -8.34596977e-02f, -8.59732181e-03f, -3.34842242e-02f, 8.74909982e-02f, 8.31027478e-02f, -3.65365446e-02f, -8.16777349e-02f, -1.17810421e-01f,
  -1.05224386e-01f, -1.86229404e-02f, 1.57181889e-01f, -6.36189505e-02f, -3.25680614e-01f, -1.42244890e-01f, -2.97341049e-01f, -3.31279665e-01f, -3.03031206e-01f, -9.37128812e-02f,
  -1.05850399e-02f, -6.42379105e-01f, -7.23987818e-01f, -5.16195953e-01f, -2.51222610e-01f, -6.73169196e-01f, -1.18203685e-01f, -2.94293344e-01f, -5.01311779e-01f, -2.90597558e-01f,
  -3.50290954e-01f, 9.59625319e-02f, -4.03855771e-01f, -6.42818332e-01f, -3.55753422e-01f, 1.84468646e-02f, 4.42265749e-01f, 9.99921747e-03f, -1.61953360e-01f, 2.01004967e-01f,
  1.36359632e-01f, 2.30511323e-01f, 2.18512595e-01f, 2.31622681e-01f, 3.75989974e-01f, 2.25286230e-01f, -7.56994411e-02f, -8.93834159e-02f, 2.08387822e-01f, 2.29865760e-01f,
  1.87676132e-01f, -1.61185011e-01f, -2.34830573e-01f, -2.35853612e-01f, -4.91875142e-01f, -3.50246802e-02f, -2.68680453e-01f, -3.27089429e-01f, -3.56049240e-02f, -3.82793248e-01f,
  4.01173443e-01f, -4.06713992e-01f, 7.68139884e-02f, -3.39663103e-02f, -2.09982783e-01f, -4.31751981e-02f, 3.27947028e-02f, -3.08895677e-01f, -4.17822674e-02f, -1.20098703e-01f,
  -2.79527813e-01f, -1.21304624e-01f, -9.78009850e-02f, -3.24192643e-02f, -1.25381425e-01f, -1.10144727e-01f, -1.46056473e-01f, -1.04996338e-01f, -6.33046776e-02f, 5.24877237e-07f,
  1.01660028e-01f, -1.33807957e-01f, -3.26297469e-02f, 7.48062730e-02f, -1.19713299e-01f, 3.96112613e-02f, -1.12076081e-01f, -2.00651079e-01f, 9.90576949e-03f, 4.22092527e-02f,
  9.53539908e-02f, 9.05512795e-02f, 8.03726241e-02f, -1.02647536e-01f, 1.39541507e-01f, 5.02272882e-02f, 1.80709548e-02f, 1.29628494e-01f, -7.35439733e-03f, -1.92315895e-02f,
  4.26964909e-02f, 6.55490085e-02f, -2.31813546e-02f, -1.98196191e-02f, -3.91511023e-02f, -4.77950349e-02f, 2.58384813e-02f, 6.34334162e-02f, -1.08427353e-01f, -1.44973874e-01f,
  -3.40204351e-02f, -1.42578512e-01f, -1.94383651e-01f, 2.42947098e-02f, -2.85081416e-02f, -1.67544425e-01f, -5.13193831e-02f, 6.01311214e-02f, 4.22557845e-04f, 4.10984568e-02f,
  4.13937837e-01f, -3.15012261e-02f, 1.54137745e-01f, 1.52151138e-02f, -1.34988859e-01f, -3.94123271e-02f, -6.99340701e-02f, -6.85841590e-02f, -1.23309411e-01f, -8.13620165e-02f,
  -6.71548098e-02f, -4.69437130e-02f, 2.73162834e-02f, -2.59353872e-02f, 3.55116874e-02f, -9.67083722e-02f, 5.13555110e-02f, 1.29019260e-01f, -7.70805497e-03f, 8.21737107e-03f,
  9.71487164e-02f, 1.57109380e-01f, 3.42816353e-01f, 2.44483039e-01f, -2.77235098e-02f, 1.90371960e-01f, 2.31750652e-01f, 1.12142049e-01f, 2.98913807e-01f, 3.85718673e-01f,
  -1.35096502e+00f, 2.31800944e-01f, 6.12545490e-01f, -5.03398895e-01f, 1.33105054e-01f, 1.37156948e-01f, 1.90064177e-01f, -4.45304871e-01f, -2.88841069e-01f, 2.83048570e-01f,
  2.90766537e-01f, -9.82043371e-02f, -1.76508620e-01f, -2.64302492e-01f, -4.30909663e-01f, 1.85061887e-01f, 1.12963647e-01f, -3.69368643e-01f, -5.53063810e-01f, -4.52322572e-01f,
  -3.79274875e-01f, -5.06658733e-01f, -7.57881045e-01f, -2.92265922e-01f, 1.30883679e-01f, 1.27786159e-04f, 2.20726520e-01f, -2.83786077e-02f, 2.66476631e-01f, 2.99419940e-01f,
  6.73515022e-01f, -8.30645114e-02f, -1.61466211e-01f, -3.33167613e-01f, 8.97644740e-03f, -1.95998624e-01f, -4.93278503e-02f, -1.53406546e-01f, -9.25809965e-02f, -3.81340533e-02f,
  -5.30094691e-02f, 6.71321154e-02f, -2.87814122e-02f, 6.37114570e-02f, -1.18576109e-01f, -1.16090640e-01f, -1.57807648e-01f, -2.46878281e-01f, -1.20411783e-01f, 2.89248079e-01f,
  2.08446726e-01f, 7.24343434e-02f, 4.93725911e-02f, -6.49072416e-03f, -2.19144840e-02f, -2.11041532e-02f, 1.48239329e-01f, -4.38086130e-02f, 4.75333035e-02f, -1.44992517e-02f,
  -1.70549467e-01f, -4.06639688e-02f, -1.01337813e-01f, -2.03261115e-02f, -4.53025475e-02f, -7.72491172e-02f, -6.57861680e-03f, -3.97912152e-02f, -1.51894867e-01f, -9.31361616e-02f,
  1.17289223e-01f, 1.22307159e-01f, -5.35713881e-02f, -3.61959897e-02f, -5.24231568e-02f, -7.67290816e-02f, -1.19481280e-01f, -9.00740772e-02f, 1.11623406e-01f, -1.49138629e-01f,
  -9.46497172e-02f, 7.58677050e-02f, 2.47025006e-02f, -2.50183027e-02f, 5.00114746e-02f, 1.90760400e-02f, -5.05100834e-05f, 1.52307805e-02f, -4.85986508e-02f, 7.02249259e-03f,
  -1.71383679e-01f, -1.53789409e-02f, 2.08046168e-01f, -1.39934748e-01f, 7.06183091e-02f, 5.51738515e-02f, 1.48929238e-01f, -2.60916143e-03f, 1.41088963e-01f, 1.06647082e-01f,
  1.72868520e-01f, -2.40464564e-02f, 7.64413103e-02f, 7.55629614e-02f, -7.11214021e-02f, 1.05464965e-01f, -3.41316797e-02f, -1.21821873e-02f, 1.57666177e-01f, 2.38398507e-01f,
  1.24860853e-01f, 5.28084673e-03f, -2.21020982e-01f, 5.00536226e-02f, -4.69012372e-02f, -1.12166822e-01f, 3.36353958e-01f, 1.23929009e-01f, 7.51372799e-02f, -3.36374678e-02f,
  6.85056210e-01f, 1.28736958e-01f, -1.12895226e+00f, 4.43988115e-01f, -8.09879422e-01f, -8.08636844e-01f, -3.92423034e-01f, 3.39259982e-01f, 5.28518498e-01f, -8.53908435e-02f,
  -3.36554885e-01f, 4.00011167e-02f, 1.14949785e-01f, -1.58030391e-01f, -1.98783591e-01f, -4.69801277e-01f, -5.92305779e-01f, -5.40819764e-01f, -6.00465894e-01f, -5.02140224e-01f,
  -1.15650877e-01f, 1.92156911e-01f, 6.03802241e-02f, -1.93964362e-01f, -6.12698421e-02f, -2.46987328e-01f, -3.49039793e-01f, -1.68067843e-01f, -5.83946884e-01f, -5.00884414e-01f,
  -4.81293917e-01f, -4.84029919e-01f, -2.43170068e-01f, 3.76057625e-02f, -9.86731797e-02f, 6.52408274e-03f, 1.34160062e-02f, 1.93328261e-01f, 1.49487510e-01f, -2.65526380e-02f,
  -4.83390361e-01f, -3.03943336e-01f, -1.24993749e-01f, -1.04623079e-01f, -1.93167225e-01f, -6.29124641e-02f, 6.54825717e-02f, -1.67953447e-01f, -1.15149459e-02f, -1.98341057e-01f,
  -3.99314612e-01f, -7.28245616e-01f, -5.73463500e-01f, -1.98943436e-01f, -3.41924250e-01f, -3.61466914e-01f, -2.06307679e-01f, -3.61595303e-01f, -5.11938870e-01f, 5.08352280e-01f,
  -2.96209045e-02f, -1.01022325e-01f, -2.91602537e-02f, 2.43795261e-01f, 3.72555614e-01f, 2.91111656e-02f, 1.14578448e-01f, 4.39713411e-02f, -7.27516487e-02f, 2.87573010e-01f,
  1.35702500e-02f, 1.07799396e-01f, 5.10723479e-02f, 5.49173243e-02f, -6.64613396e-02f, -1.52789816e-01f, -8.55041593e-02f, 7.48232305e-02f, 6.71429038e-02f, 3.60421129e-02f,
  6.50833026e-02f, -1.45859569e-01f, -1.18359588e-01f, 1.92427173e-01f, -2.80231029e-01f, -9.09355134e-02f, 9.89929363e-02f, 1.14968427e-01f, 1.72215879e-01f, -7.00282976e-02f,
  7.38346457e-01f, -5.97280800e-01f, 4.94102746e-01f, 1.84184581e-01f, -2.91183233e-01f, -1.00832202e-01f, 1.19918913e-01f, -8.58098175e-03f, 2.89014056e-02f, 4.46470529e-02f,
  -3.27762127e-01f, 4.26665172e-02f, -2.70345993e-02f, 4.10049446e-02f, -1.97882593e-01f, -5.01781665e-02f, 1.83155671e-01f, -2.77938753e-01f, -4.80167903e-02f, 1.08188085e-01f,
  3.62891346e-01f, 4.60169353e-02f, 3.56933177e-01f, 2.83260882e-01f, 8.01414773e-02f, 9.68713835e-02f, 1.67134225e-01f, 9.50824544e-02f, -3.81666049e-02f, 9.72028375e-01f,
  6.09243274e-01f, -3.97418141e-01f, 3.53617996e-01f, 3.74811254e-02f, -1.58655986e-01f, -4.64040399e-01f, -5.89771688e-01f, -3.41935039e-01f, 6.61924714e-03f, 1.15884215e-01f,
  2.13267520e-01f, 5.35346508e-01f, 3.12769979e-01f, 2.58874476e-01f, 4.45745252e-02f, -4.49593328e-02f, -2.12645978e-02f, 3.32969427e-01f, 3.68454009e-01f, 2.09035829e-01f,
  1.78972036e-01f, -1.26266226e-01f, 1.84326455e-01f, 8.20219293e-02f, 8.30794722e-02f, 2.40592197e-01f, -1.49159819e-01f, -5.51102236e-02f, 7.30615631e-02f, 4.11856413e-01f,
  6.49613619e-01f, -1.13034777e-01f, 2.38610715e-01f, -2.04929486e-02f, 8.11061263e-02f, -1.99441798e-02f, 1.75164551e-01f, -1.29476367e-02f, -2.52052583e-02f, -6.51749820e-02f,
  8.63850396e-03f, 6.58667367e-03f, -1.34545967e-01f, -1.52222931e-01f, -9.45298150e-02f, -1.06003962e-01f, -8.67924765e-02f, -1.02715462e-01f, -1.38349682e-01f, 1.09741047e-01f,
  4.67295684e-02f, 9.85255614e-02f, 4.19052551e-04f, -1.61864296e-01f, -1.69529095e-01f, 4.09950577e-02f, -9.22962874e-02f, -2.23543867e-03f, -6.38839379e-02f, 4.34544981e-02f,
  1.45120651e-01f, -3.89964506e-02f, 1.21254221e-01f, 2.12125823e-01f, 3.22401114e-02f, 1.06505685e-01f, -6.56863907e-03f, 1.01810182e-02f, 1.45331761e-02f, -3.78781706e-02f,
  -1.48152316e-03f, -4.57419604e-02f, -7.31017441e-02f, -1.15081407e-01f, 8.58603641e-02f, 8.79422575e-02f, 7.53475204e-02f, -7.48462304e-02f, 8.08104575e-02f, 6.01113960e-02f,
  1.36531651e-01f, 6.80397674e-02f, 4.42079715e-02f, 7.28231743e-02f, -6.61053434e-02f, 4.88074720e-02f, 1.91027790e-01f, -5.01318723e-02f, 2.47033127e-02f, -1.16735518e-01f,
  -1.93412974e-01f, -3.77704501e-01f, 2.91341633e-01f, 1.13447018e-01f, -7.28129596e-02f, -4.37904568e-03f, 1.79000780e-01f, -1.53700318e-02f, -9.92492512e-02f, -3.89109179e-02f,
  -1.48585150e-02f, -1.98581014e-02f, -2.32570201e-01f, -7.37322345e-02f, -2.01723296e-02f, 4.72593121e-02f, -3.85386087e-02f, 1.20690174e-01f, -4.23592329e-02f, 5.40709198e-02f,
  -9.06556025e-02f, -1.30001634e-01f, 2.69944803e-03f, -5.17477058e-02f, -1.37547374e-01f, 7.65511245e-02f, 4.00242023e-02f, -3.11763529e-02f, -1.34138605e-02f, -1.46667823e-01f,
  -5.45166731e-01f, -6.49439573e-01f, -5.60074866e-01f, -1.00992513e+00f, -5.17639577e-01f, 1.66591078e-01f, -2.43059099e-02f, -2.70893164e-02f, -3.63605678e-01f, -5.95109463e-01f,
  9.36532691e-02f, 3.66937697e-01f, -2.21145794e-01f, 1.24475576e-01f, 2.67040879e-01f, -5.69298685e-01f, -7.66686141e-01f, -2.90192693e-01f, 2.29863957e-01f, 6.21738434e-02f,
  -2.80434966e-01f, -7.13104725e-01f, -4.16313082e-01f, -2.77497411e-01f, -6.00655615e-01f, -3.53698701e-01f, -7.97439694e-01f, -6.32413983e-01f, 2.44067032e-02f, -7.87557185e-01f,
  -2.92699814e-01f, 2.04519615e-01f, 2.90603101e-01f, 2.03574166e-01f, -1.77443922e-01f, 3.15546900e-01f, -2.03328002e-02f, -2.27529854e-01f, 1.59455314e-01f, -2.05739401e-02f,
  -1.59397393e-01f, 1.41442046e-01f, -4.30709049e-02f, 6.52873367e-02f, -2.24427879e-01f, 1.68277338e-01f, -3.52884024e-01f, -2.41755083e-01f, -2.10321322e-01f, -1.10082738e-02f,
  -1.25527620e-01f, -1.92073286e-01f, 8.43767002e-02f, 3.41831185e-02f, 2.46533468e-01f, 1.82564706e-01f, -1.19522952e-01f, 1.33735895e-01f, 7.36366734e-02f, -6.32518411e-01f,
  -2.04037786e-01f, -5.46937808e-02f, -1.51601493e-01f, -6.42323345e-02f, 6.35996535e-02f, -6.54475242e-02f, 8.37797578e-03f, -8.76237452e-02f, 1.11137226e-01f, -7.35980049e-02f,
  -2.90792584e-02f, 1.16190165e-01f, 2.90514193e-02f, -7.04277381e-02f, -1.35447472e-01f, -2.13036388e-01f, 6.53889552e-02f, 8.95833299e-02f, 1.21316992e-01f, 5.74409217e-02f,
  2.17698887e-02f, 3.56130898e-02f, -1.85338065e-01f, 7.01008365e-02f, 4.24854122e-02f, -1.68177605e-01f, 3.36326770e-02f, 2.86844056e-02f, -7.37317279e-02f, 1.47355825e-01f,
  -4.69944477e-01f, 4.11812276e-01f, -8.84279236e-02f, 6.40367195e-02f, -1.60851553e-01f, 9.59457234e-02f, 3.08883004e-02f, 1.18425965e-01f, 7.73002505e-02f, -9.69629660e-02f,
  3.17365937e-02f, -2.47521266e-01f, -1.17710114e-01f, -4.46808338e-02f, -9.57560018e-02f, 2.87477318e-02f, -8.59612823e-02f, -2.08970234e-01f, -2.12639309e-02f, -7.26507306e-02f,
  -1.63151488e-01f, 1.16004005e-01f, 1.00391367e-02f, -4.41262461e-02f, 1.18329003e-02f, 2.82334864e-01f, -1.33358434e-01f, -8.88916478e-02f, 2.12091342e-01f, -4.14735258e-01f,
  -1.11265910e+00f, 3.65451455e-01f, 6.66261852e-01f, -6.61922634e-01f, 1.24944404e-01f, 4.36275125e-01f, 7.15138912e-01f, 7.53331631e-02f, -3.44254166e-01f, 5.21662347e-02f,
  -1.32368550e-01f, -4.51286286e-01f, -6.92590848e-02f, 1.06179811e-01f, 1.95529506e-01f, 4.91505176e-01f, 5.18240929e-01f, 2.78603017e-01f, -8.31691176e-02f, -1.07764713e-01f,
  1.69309527e-02f, -3.75162512e-01f, -4.74203110e-01f, -7.30873272e-02f, -2.21824989e-01f, -1.46053791e-01f, 3.75316322e-01f, -9.15960297e-02f, 3.38446707e-01f, 1.08104602e-01f,
  -5.22694826e-01f, -4.30611223e-01f, 9.94180739e-02f, -1.22789636e-01f, 3.53050083e-02f, -7.56467432e-02f, -4.87612560e-02f, -7.34360814e-02f, 9.56779048e-02f, 9.63856280e-02f,
  -1.48119256e-01f, -2.81614587e-02f, -8.56446251e-02f, 1.16986930e-01f, -1.92094952e-01f, -1.47729740e-01f, 1.49883300e-01f, 1.20638520e-01f, 1.21612996e-01f, 4.85077575e-02f,
  2.32398286e-01f, -1.50039509e-01f, -2.17645869e-01f, 2.49166474e-01f, 1.27729982e-01f, 1.65990088e-02f, 8.37176740e-02f, -1.15027383e-01f, 2.62363374e-01f, -3.86018723e-01f,
  -1.16618956e-02f, -8.96674022e-03f, 1.38688132e-01f, 7.49408901e-02f, 2.06250679e-02f, 2.23846715e-02f, -1.29134022e-03f, 6.72843456e-02f, 3.59101854e-02f, -1.62627980e-01f,
  1.25572518e-01f, -2.47878698e-03f, -5.54133691e-02f, -9.89771187e-02f, -1.99940637e-01f, 2.04625353e-02f, 1.38748944e-01f, 2.68152636e-02f, 8.08677450e-02f, 6.70661777e-02f,
  2.94007827e-02f, 2.13027090e-01f, 1.11853510e-01f, 4.82434891e-02f, 1.82265952e-01f, 2.30979532e-01f, -9.07244831e-02f, 6.18091561e-02f, -2.25337371e-01f, -3.79432850e-02f,
  -7.82011211e-01f, 6.51444733e-01f, -4.78757977e-01f, -4.80447821e-02f, -1.44064024e-01f, 2.34259591e-02f, -3.91599303e-03f, 6.70776702e-04f, 5.08226119e-02f, -1.25699237e-01f,
  1.53562605e-01f, -1.10869370e-01f, 9.93098319e-03f, 1.45403132e-01f, -1.34074792e-01f, -3.81512605e-02f, -1.77126024e-02f, -4.36122678e-02f, 3.66980359e-02f, -6.06058538e-02f,
  2.40508869e-01f, -1.78339869e-01f, -5.72694361e-01f, -8.04784447e-02f, -8.76296759e-02f, -1.88275337e-01f, -6.13456368e-02f, -1.73641980e-01f, 8.71101320e-02f, -3.83158088e-01f,
  2.80507833e-01f, -1.58851668e-01f, -6.24541283e-01f, -2.30764955e-01f, -4.81946230e-01f, -2.74887532e-01f, -2.59682447e-01f, -2.38492060e-02f, 4.20910865e-02f, -1.63002670e-01f,
  1.81536302e-01f, 1.70471892e-01f, 1.32926986e-01f, 1.67096115e-03f, -5.49231283e-03f, -3.93104583e-01f, -4.29576844e-01f, -2.98483461e-01f, -3.49195927e-01f, -2.78355867e-01f,
  -2.89007276e-01f, -4.48382705e-01f, -2.60062337e-01f, -2.10340604e-01f, -3.88094515e-01f, -2.75533855e-01f, -1.87921941e-01f, -3.03642571e-01f, -1.29099980e-01f, -3.80126715e-01f,
  -6.36817873e-01f, 8.96341130e-02f, 1.43960807e-02f, 1.75193712e-01f, -6.98067993e-02f, 1.71416700e-01f, 3.27098742e-02f, 8.14816058e-02f, 5.22982813e-02f, -5.86380847e-02f,
  3.98308709e-02f, -7.37658739e-02f, -6.49347454e-02f, -6.36805445e-02f, -1.11559890e-01f, -1.49537986e-02f, 2.50909984e-01f, 6.95406124e-02f, 9.31828618e-02f, 1.41925812e-01f,
  1.66351363e-01f, 2.91343272e-01f, 2.52259910e-01f, 2.82881826e-01f, 1.86448261e-01f, 2.32248634e-01f, 4.48020808e-02f, 2.02962652e-01f, 2.23936409e-01f, 2.83406377e-01f,
  7.06382692e-02f, 7.94631615e-02f, 1.31642781e-02f, 1.02127567e-01f, 3.73245850e-02f, 7.88997039e-02f, -1.30092666e-01f, 1.20441616e-01f, 3.23879384e-02f, -4.61664684e-02f,
  -8.65736604e-02f, -6.18603602e-02f, 1.04578160e-01f, 8.85220617e-03f, -1.45311162e-01f, 5.55336773e-02f, 3.86645924e-03f, 5.54856360e-02f, 2.36749891e-02f, -2.57762875e-02f,
  2.12762970e-03f, 1.06401972e-01f, -1.11361720e-01f, -5.15509881e-02f, -2.42011119e-02f, 9.59068611e-02f, 2.06268616e-02f, 4.98233587e-02f, -3.03133316e-02f, -1.72018353e-02f,
  -2.42635712e-01f, 1.30513027e-01f, -2.00770590e-02f, 1.95726529e-02f, 6.31688349e-03f, 1.62941441e-02f, -8.96753073e-02f, 7.05179945e-03f, -2.02162445e-01f, -1.86619774e-01f,
  8.81926250e-03f, -1.79955494e-02f, -4.55517061e-02f, 4.89571467e-02f, -8.72528702e-02f, 5.03563136e-02f, 2.44164646e-01f, 7.27720410e-02f, 1.39643446e-01f, -1.00344129e-01f,
  2.63843238e-02f, 3.05929095e-01f, 2.15746894e-01f, 1.20015047e-01f, 2.13459343e-01f, -4.17542737e-03f, -1.21120177e-01f, 2.25421861e-02f, 7.38255233e-02f, 8.79475176e-02f,
  -1.07051265e+00f, 2.47627005e-01f, 4.90392238e-01f, -6.70535386e-01f, -1.35673434e-01f, 2.33947024e-01f, 5.37727535e-01f, -1.06577709e-01f, -4.42399889e-01f, -1.49000634e-03f,
  1.65284708e-01f, -2.07446337e-01f, -1.50143756e-02f, 1.05414204e-01f, 1.81425229e-01f, 3.66211861e-01f, 8.66409466e-02f, 3.00952438e-02f, 6.29838035e-02f, -1.90406069e-01f,
  -2.10222885e-01f, -2.46668592e-01f, -3.20642769e-01f, -2.05993831e-01f, -2.45343119e-01f, -4.38833460e-02f, 1.33386567e-01f, -5.70058413e-02f, 1.68414459e-01f, -1.03646025e-01f,
  7.00580120e-01f, -1.41830534e-01f, -1.35253623e-01f, -2.23283976e-01f, 6.44176751e-02f, -4.57911044e-02f, -2.28973888e-02f, -1.28776193e-01f, -3.85621339e-02f, -2.85989102e-02f,
  -1.65867545e-02f, -6.27928879e-03f, 1.40733495e-01f, 1.09619379e-01f, 1.52549058e-01f, 6.15048176e-03f, -6.59494400e-02f, 2.81427931e-02f, 1.61887407e-01f, 2.08917782e-01f,
  8.09794962e-02f, 1.30876914e-01f, 3.03588420e-01f, 1.30153403e-01f, 7.74885789e-02f, 1.25497850e-02f, 2.06430763e-01f, -1.18840728e-02f, 8.66460428e-02f, 5.42498231e-02f,
  -2.15324480e-02f, -4.75180224e-02f, -1.04132809e-01f, -3.59029546e-02f, -7.20126852e-02f, 2.10502464e-03f, 7.33160824e-02f, 2.33509704e-01f, 1.96655363e-01f, 2.01140210e-01f,
  7.45324343e-02f, 9.06988755e-02f, 1.98296025e-01f, 5.19891307e-02f, 3.19842622e-02f, 5.94919063e-02f, 7.08219483e-02f, 3.09798717e-02f, -3.83571796e-02f, -1.35140255e-01f,
  2.24531125e-02f, -3.26982960e-02f, -5.66483513e-02f, 4.66660149e-02f, 1.22860231e-01f, -6.59188852e-02f, 8.64720270e-02f, 6.97011873e-02f, 4.27305289e-02f, -1.75968483e-01f,
  3.40931892e-01f, 1.77829608e-01f, -3.35018784e-02f, -7.58792982e-02f, 4.28717658e-02f, -1.53946102e-01f, -1.33008301e-01f, -1.44939944e-01f, -1.85337648e-01f, 3.30278575e-02f,
  -2.71474430e-03f, -1.49930716e-01f, 1.93091780e-01f, 1.84415504e-02f, -2.60011684e-02f, 1.70463193e-02f, -6.13995232e-02f, -2.02799812e-02f, -2.81984676e-02f, 4.70089912e-02f,
  -5.06762303e-02f, 5.78670762e-02f, 2.25191340e-01f, 1.49933949e-01f, 1.00491546e-01f, 1.12308003e-01f, 1.34407818e-01f, 1.53387487e-01f, 1.61271706e-01f, 1.59400687e-01f,
  1.39022216e-01f, 1.23255804e-01f, -6.94984794e-01f, 5.68020761e-01f, 1.10387199e-01f, -4.75569844e-01f, -6.47953212e-01f, -1.99997112e-01f, 6.41210854e-01f, 2.01459348e-01f,
  3.00572544e-01f, 1.98667601e-01f, 7.02215731e-02f, -4.43970114e-01f, -7.54474163e-01f, -5.36921978e-01f, -5.24646282e-01f, -7.90656269e-01f, -8.43267500e-01f, -5.17883658e-01f,
  3.48327197e-02f, 7.68257827e-02f, -2.49909535e-01f, -2.35441804e-01f, 7.78701067e-01f, 4.47857559e-01f, 4.47750509e-01f, 2.15215579e-01f, -1.78060144e-01f, 3.33629817e-01f,
  2.22632904e-02f, 1.24174297e-01f, -3.27432692e-01f, 8.07469711e-02f, 3.17135751e-01f, -7.86856413e-02f, -1.06190145e-01f, 2.98862681e-02f, -2.48933122e-01f, 4.73311078e-03f,
  7.60773420e-02f, -2.42855832e-01f, -2.98315473e-02f, 1.00852780e-01f, -5.49797937e-02f, -2.12741598e-01f, -3.04629207e-01f, -4.98343229e-01f, -1.97259024e-01f, -1.85009748e-01f,
  -7.12200487e-03f, -1.13895558e-01f, -2.96269268e-01f, -3.57521653e-01f, -1.80236414e-01f, -2.67946459e-02f, 1.13438204e-01f, 5.61961085e-02f, -3.89092237e-01f, 3.39352936e-01f,
  8.04413706e-02f, -2.16257339e-03f, -9.11488459e-02f, -6.24374896e-02f, 6.51625842e-02f, 1.36955604e-01f, 3.59714143e-02f, 5.01932688e-02f, 2.29682606e-02f, -2.97391117e-02f,
  -1.24432810e-01f, -6.81717461e-03f, 6.64754733e-02f, -5.36941411e-03f, 3.32801230e-02f, -2.90618781e-02f, 5.04266061e-02f, -6.73560500e-02f, -2.76237488e-01f, 5.00836261e-02f,
  -5.01548126e-02f, 2.51202825e-02f, 2.24416777e-01f, 5.80576109e-03f, -6.35164529e-02f, -3.47395204e-02f, 1.03524573e-01f, -1.15197472e-01f, -5.34367897e-02f, 4.77739200e-02f,
  5.05313039e-01f, -4.28829819e-01f, 3.05028528e-01f, -2.49703556e-01f, 6.35659397e-02f, 1.76716000e-01f, 3.42062026e-01f, -1.26398906e-01f, 5.83085045e-02f, -1.80823356e-01f,
  -1.31961346e-01f, -1.22870795e-01f, 1.46712782e-02f, 7.95294121e-02f, -1.51206300e-01f, -1.63373664e-01f, -3.17261130e-01f, 5.10825068e-02f, -4.23684120e-01f, 3.23253810e-01f,
  -2.15092730e-02f, -2.12700397e-01f, -1.98116243e-01f, -6.96097538e-02f, -1.23298895e-02f, -1.26920611e-01f, 3.24065909e-02f, 6.80467337e-02f, -6.01770520e-01f, 2.38741755e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.95911431e-01f, 4.00858968e-01f, 6.77293360e-01f, 1.11459959e+00f, 7.74227977e-01f, 2.23473191e-01f, 6.21567905e-01f, 3.87075305e-01f, 9.30395246e-01f, 3.11585456e-01f,
  7.94609487e-01f, 6.48579538e-01f, 9.23446298e-01f, 3.60893637e-01f, 6.22940898e-01f, 5.62524676e-01f, 7.04219401e-01f, 7.71664143e-01f, 7.90271401e-01f, 7.33289838e-01f,
  1.05995178e+00f, 3.07090245e-02f, 7.69689679e-01f, 1.53711796e-01f, 6.53484106e-01f, 3.58242124e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.06611140e-01f, -4.49577153e-01f, -2.40110800e-01f, -5.19545227e-02f, -1.21786594e-01f, -3.41480598e-02f, -2.51000047e-01f, -4.43243504e-01f, 1.71334848e-01f, -1.02974109e-01f,
  -1.31396115e-01f, -3.68699074e-01f, -7.84207359e-02f, 1.79456715e-02f, -2.62781978e-01f, 1.86954126e-01f, -2.91126519e-01f, -5.10733724e-01f, -7.27396756e-02f, -1.93537116e-01f,
  3.06122392e-01f, 4.85865846e-02f, -8.43405277e-02f, -3.36850256e-01f, -2.95282334e-01f, 4.29630488e-01f, -7.34471977e-02f, -4.57323156e-02f, -4.44142967e-02f, -4.49176878e-01f,
  1.08423628e-01f, -3.50372016e-01f, -2.05387071e-01f, 2.57038891e-01f, 1.90613531e-02f, -1.74613088e-01f, 3.55536491e-01f, 1.78178310e-01f, -7.07334101e-01f, -5.29554524e-02f,
  -1.50630310e-01f, 8.93899873e-02f, 3.96571100e-01f, -1.21014975e-01f, -1.68081626e-01f, -5.99774897e-01f, -7.29596466e-02f, 1.10125256e+00f, -3.99183482e-03f, -1.77727848e-01f,
  -6.03385985e-01f, 4.38093781e-01f, -2.24535674e-01f, -3.08267266e-01f, -1.00044847e+00f, -2.90915310e-01f, -9.85449970e-01f, 6.10474646e-02f, -3.00907463e-01f, 2.53777683e-01f,
  -6.19572639e-01f, 2.85043478e-01f, -1.35917008e-01f, -9.64298919e-02f, -1.82211965e-01f, -5.84505200e-02f, 1.32636651e-01f, -2.98710734e-01f, 4.48805280e-03f, -1.25065252e-01f,
  1.03726014e-01f, 3.00720423e-01f, 1.59825042e-01f, 1.19252063e-01f, -3.07820946e-01f, 2.40534976e-01f, 8.58328715e-02f, -6.32897764e-02f, 4.69276309e-02f, -7.64923543e-02f,
  4.98226881e-02f, -1.18193835e-01f, -2.77604580e-01f, -4.86340672e-01f, 2.45066375e-01f, 3.78725767e-01f, -4.27755684e-01f, 3.62141043e-01f, -2.73853242e-01f, 2.29775414e-01f,
  -7.14409724e-02f, -3.27689320e-01f, -6.21556900e-02f, -4.01251405e-01f, -3.81649673e-01f, -4.27418947e-01f, 2.52069067e-02f, -2.22049326e-01f, -3.88745576e-01f, -4.56218213e-01f,
  2.25352675e-01f, 1.74710900e-01f, 8.05847421e-02f, 3.18775475e-01f, 3.92760843e-01f, -1.18065692e-01f, 6.67094469e-01f, 8.99021029e-02f, 5.66076815e-01f, -1.34719238e-01f,
  5.15816621e-02f, -8.57446790e-01f, -8.23087633e-01f, 2.74747789e-01f, -6.37002170e-01f, -1.12278914e+00f, -1.14326620e+00f, -3.44295472e-01f, -9.90527332e-01f, 2.24572957e-01f,
  -9.93163764e-01f, 1.86136842e-01f, 2.70092219e-01f, 8.63500714e-01f, -1.18709016e+00f, 3.74482512e-01f, -2.96052843e-01f, -1.10466301e+00f, -7.59080499e-02f, 2.74132472e-02f,
  1.01993941e-01f, 2.56220430e-01f, 1.52395651e-01f, 1.06746428e-01f, 2.51507998e-01f, 2.48314515e-01f, -8.42103362e-02f, 1.63455695e-01f, 6.15823977e-02f, -1.55531287e-01f,
  2.32052758e-01f, 3.03947091e-01f, 2.02563524e-01f, -1.42680854e-01f, 2.21696645e-01f, 3.42435807e-01f, 3.15944850e-01f, -3.60780269e-01f, 1.70838103e-01f, 3.42951715e-01f,
  1.74049079e-01f, 5.29503301e-02f, -2.76710421e-01f, -1.92434251e-01f, -1.68102399e-01f, -1.29379794e-01f, -1.77301481e-01f, -1.25682861e-01f, -3.37750226e-01f, -2.26828560e-01f,
  -1.22063853e-01f, 3.33879180e-02f, 4.39759165e-01f, -3.49775136e-01f, 3.64942789e-01f, -1.81963593e-02f, -2.95017749e-01f, 1.45352706e-01f, -6.23125613e-01f, 2.12508276e-01f,
  1.11229920e+00f, -4.27101254e-01f, 3.25898051e-01f, -2.40530953e-01f, 7.23034963e-02f, 1.02367941e-02f, -6.00198150e-01f, -3.61375898e-01f, -6.72831059e-01f, -5.57487488e-01f,
  4.34547752e-01f, -3.66678506e-01f, 7.40579903e-01f, -4.08877611e-01f, -4.25465435e-01f, -6.74785912e-01f, -2.25530192e-02f, -6.69950366e-01f, 7.70170510e-01f, -1.57111377e-01f,
  -2.44216442e-01f, -7.69933522e-01f, -8.28616694e-02f, 2.66822930e-02f, -3.79569605e-02f, 8.10024738e-02f, -8.58776346e-02f, -2.20682397e-01f, -1.43933799e-02f, 4.29491669e-01f,
  -3.99454474e-01f, -4.99985904e-01f, -5.81465006e-01f, -1.29050791e-01f, -9.31691974e-02f, 2.41722956e-01f, -2.23781228e-01f, 2.15279274e-02f, -1.91096798e-01f, 3.93010583e-03f,
  5.35574630e-02f, 2.90314760e-02f, -2.62391925e-01f, 2.03577474e-01f, 4.79290456e-01f, 3.10329683e-02f, 6.39905870e-01f, -6.10248521e-02f, -1.20372541e-01f, -1.13669934e-03f,
  1.47205681e-01f, 3.53650540e-01f, -2.00261042e-01f, -4.45073366e-01f, 2.19239384e-01f, 2.03455970e-01f, -3.01570177e-01f, -1.53267393e-02f, -2.82601267e-01f, -1.97960019e-01f,
  -2.47801453e-01f, -4.95916337e-01f, -6.30757749e-01f, -1.56038165e+00f, 2.72397156e-04f, -5.94731748e-01f, -3.99737477e-01f, -5.65684140e-01f, -5.76787651e-01f, 5.08500576e-01f,
  2.07102463e-01f, -5.39935768e-01f, 2.40079656e-01f, 2.30896965e-01f, 5.08224219e-03f, -4.03453171e-01f, 2.35317171e-01f, 3.66497338e-01f, 7.29797721e-01f, -8.65593493e-01f,
  -9.14225876e-01f, 2.73506939e-01f, 9.68294978e-01f, 1.50092483e-01f, 3.18019390e-01f, -6.83310688e-01f, 2.19948255e-02f, 1.97225794e-01f, 3.00793182e-02f, 2.71530032e-01f,
  -2.64883608e-01f, -1.02831805e-02f, -1.56875495e-02f, -3.65206122e-01f, 1.51622929e-02f, 1.11794353e-01f, -8.49173591e-02f, -3.94493528e-02f, -3.88054878e-01f, -3.54907870e-01f,
  5.62082827e-02f, 3.49655040e-02f, 1.35921419e-01f, 4.31227893e-01f, 1.04922447e-02f, 1.32651240e-01f, 1.02629125e-01f, 1.04659125e-01f, 3.11684251e-01f, -4.21208560e-01f,
  -1.56375661e-03f, -3.70124847e-01f, -2.49341756e-01f, 2.64736444e-01f, 4.23728138e-01f, 5.01043200e-01f, -3.24671090e-01f, 5.31990409e-01f, -3.24334856e-03f, 1.29178658e-01f,
  4.41958189e-01f, -2.61515677e-01f, -1.90686062e-01f, -4.82080072e-01f, 2.24451020e-01f, -6.91894293e-01f, -2.52468228e-01f, 1.54262455e-02f, -2.67579742e-02f, 1.12096004e-01f,
  -1.48324728e-01f, -4.91449654e-01f, -6.46804869e-01f, -1.03367066e+00f, 1.73568681e-01f, -8.55931342e-02f, -4.72904831e-01f, 8.53148103e-02f, 2.67169893e-01f, -1.38381040e+00f,
  7.85619795e-01f, -8.91050816e-01f, 5.32573581e-01f, 9.89763737e-02f, -1.14442757e-03f, -2.10852578e-01f, -4.37116563e-01f, 5.93448021e-02f, -1.46798983e-01f, 6.98401392e-01f,
  3.42527509e-01f, 2.58044064e-01f, 3.24521899e-01f, 1.05228461e-02f, 1.53044313e-01f, 1.86074197e-01f, 3.72082205e-03f, 3.52293015e-01f, 7.38273039e-02f, 1.47009671e-01f,
  1.79130152e-01f, 2.73991972e-01f, 8.96609500e-02f, 2.63016000e-02f, 2.32107446e-01f, 7.47030750e-02f, 1.82618648e-01f, 2.56558776e-01f, -1.30821213e-01f, 4.63672251e-01f,
  -3.95731658e-01f, -9.44655910e-02f, -4.00893241e-01f, 4.24138233e-02f, -1.17020048e-01f, 2.46286690e-01f, 7.05403686e-02f, 5.35952330e-01f, -4.33904827e-01f, -5.37107706e-01f,
  1.03163570e-01f, 1.42510921e-01f, 3.29186440e-01f, -3.27055663e-01f, -3.92785788e-01f, 5.43346107e-01f, 4.42264616e-01f, -4.43162322e-01f, -1.27345383e-01f, 3.33591342e-01f,
  -2.98547894e-02f, 4.95586358e-02f, -1.26514411e+00f, 3.18547517e-01f, -7.34756470e-01f, -3.75510275e-01f, -1.70712218e-01f, -2.58883208e-01f, 5.12348235e-01f, -6.67971134e-01f,
  6.22682571e-01f, -5.47833145e-01f, 2.37249300e-01f, 3.09997886e-01f, -5.23906767e-01f, 2.14693740e-01f, -7.86596060e-01f, 9.74785388e-01f, -7.98270881e-01f, -3.55954826e-01f,
  -1.08216357e+00f, 2.00280145e-01f, -4.21308666e-01f, 3.46257031e-01f, 6.59626275e-02f, 4.41893265e-02f, 2.30868936e-01f, -2.91683644e-01f, 1.04550146e-01f, -1.50668189e-01f,
  -3.26385736e-01f, 1.66569635e-01f, 6.41996711e-02f, -2.34471738e-01f, 1.97505765e-03f, 1.68230161e-01f, 6.45907945e-04f, 7.92688653e-02f, 1.69510111e-01f, 6.49934933e-02f,
  -1.86812207e-01f, -6.78238645e-02f, -2.69949853e-01f, -1.31616563e-01f, -4.90412235e-01f, -2.62534976e-01f, 1.70307204e-01f, -2.39007264e-01f, -4.75966483e-01f, -5.26845992e-01f,
  -8.73710886e-02f, 4.00659032e-02f, -4.31162804e-01f, 9.58603323e-02f, 2.70387501e-01f, 2.44909868e-01f, -3.72696161e-01f, -3.91076207e-01f, 1.96289837e-01f, 3.13559353e-01f,
  -2.88778037e-01f, 2.19935924e-01f, -4.49539512e-01f, -5.41129827e-01f, 3.00804842e-02f, 2.51782328e-01f, -7.69259334e-01f, -1.12483397e-01f, -5.80904007e-01f, 5.15429616e-01f,
  -5.17437279e-01f, 6.53934538e-01f, -8.24386299e-01f, 4.06440854e-01f, -9.23595011e-01f, -8.54753196e-01f, -1.04713559e+00f, 2.81909913e-01f, 9.93900001e-01f, -1.70858666e-01f,
  -4.95348781e-01f, -3.58438253e-01f, 3.66504252e-01f, -2.02202693e-01f, -3.88294220e-01f, -5.33262253e-01f, -8.51307392e-01f, -5.25811911e-01f, -2.85908282e-01f, -4.05557215e-01f,
  -1.88099533e-01f, -6.45636082e-01f, -1.20907634e-01f, -2.66126394e-01f, -7.73501173e-02f, -4.79658460e-03f, -1.26335427e-01f, -1.80646107e-02f, -5.34125604e-02f, 1.18941320e-02f,
  -6.62500635e-02f, -2.16822013e-01f, -3.17577749e-01f, -3.71957235e-02f, -1.90636814e-01f, -2.51935929e-01f, -2.33850792e-01f, 3.49491984e-01f, -2.49475494e-01f, -9.74914953e-02f,
  4.10606898e-03f, -1.10208750e-01f, 3.39372367e-01f, 3.00683349e-01f, 1.34525262e-02f, 4.33872491e-01f, -1.63760725e-02f, 3.85219276e-01f, 2.83883333e-01f, -1.75710216e-01f,
  -2.72641033e-01f, 2.07551941e-01f, 8.69483203e-02f, -1.89154875e-02f, -2.83497721e-01f, 9.63345319e-02f, 4.01177853e-01f, 4.62107174e-02f, -5.12367845e-01f, -2.53435254e-01f,
  -4.30622548e-01f, 2.51334459e-01f, 2.13666242e-02f, -3.12240154e-01f, -6.12963438e-01f, 3.86293948e-01f, -7.31465042e-01f, -5.52865565e-01f, -2.53644109e-01f, 2.87540466e-01f,
  7.58683443e-01f, 2.12395385e-01f, -6.56807899e-01f, 1.16326042e-01f, 2.95765877e-01f, -5.98838091e-01f, -3.52328449e-01f, -6.22949719e-01f, 7.76687622e-01f, -5.04011154e-01f,
  5.70188574e-02f, 3.28987867e-01f, 7.80556574e-02f, 2.52381057e-01f, -7.35996813e-02f, 1.69939160e-01f, -1.08244065e-02f, 1.88038900e-01f, 2.50668228e-01f, -5.59202492e-01f,
  -5.00483178e-02f, -2.12071817e-02f, 1.81695253e-01f, -2.24575892e-01f, 1.14420198e-01f, -3.84141713e-01f, 1.27286986e-01f, 3.98251377e-02f, -6.22778572e-02f, 9.22115520e-02f,
  2.74657398e-01f, 9.92360339e-02f, -1.55577555e-01f, -4.20074463e-01f, -1.82921682e-02f, 2.91553497e-01f, 1.28180414e-01f, 4.73456293e-01f, 4.21406657e-01f, -5.20406008e-01f,
  -4.19174880e-01f, -2.98473984e-01f, 3.92463058e-01f, 4.92915422e-01f, -1.66636676e-01f, -4.21100706e-02f, -1.01253517e-01f, 4.10748661e-01f, 3.50909270e-02f, -3.30041535e-02f,
  2.80914456e-01f, -5.80273449e-01f, -5.39741695e-01f, -4.31624770e-01f, -6.72938585e-01f, -3.05030078e-01f, 5.17800570e-01f, -2.62814611e-01f, 8.49101543e-01f, -2.29076520e-01f,
  -5.23523211e-01f, 1.36488304e-01f, 1.10234034e+00f, -2.92288214e-01f, -6.90302700e-02f, -2.07946096e-02f, -5.00538230e-01f, -3.23675685e-02f, -1.51050091e-01f, -7.23305404e-01f,
  1.93101615e-02f, -4.11456317e-01f, -1.10845581e-01f, -4.99889672e-01f, 4.06456068e-02f, -4.44207728e-01f, 1.59068018e-01f, 2.28411898e-01f, 6.01410046e-02f, 2.03798652e-01f,
  -1.86922461e-01f, 2.20252827e-01f, 4.43227202e-01f, -4.22387332e-01f, 5.71531095e-02f, 1.01966880e-01f, 2.97774166e-01f, -1.26086310e-01f, -2.54171252e-01f, -1.60263807e-01f,
  -9.90880132e-02f, -2.40173489e-02f, 2.53808200e-01f, -1.60383597e-01f, 3.05380493e-01f, 7.01080188e-02f, 3.12812984e-01f, 5.55928111e-01f, 3.21210921e-01f, 1.12855896e-01f,
  -2.21928209e-01f, -9.39707756e-02f, -2.88339257e-01f, -4.49639261e-01f, -7.63916075e-02f, 9.12155211e-02f, -4.45631295e-01f, 3.27701509e-01f, 6.55793726e-01f, 4.42961514e-01f,
  3.95753771e-01f, 1.56921506e-01f, -3.67081761e-01f, 2.43964568e-01f, -2.97295958e-01f, 4.76496130e-01f, -1.20969750e-01f, 2.17136964e-01f, -1.26098669e+00f, -4.27097261e-01f,
  -4.60308015e-01f, -1.44530818e-01f, -1.29772574e-01f, -6.19592130e-01f, -5.29501617e-01f, -4.14330602e-01f, -1.23034358e+00f, 5.52047253e-01f, 6.69497490e-01f, 3.85896504e-01f,
  -4.26959634e-01f, -4.58944976e-01f, 3.02069426e-01f, -4.01205391e-01f, 7.21054733e-01f, -6.43597722e-01f, -8.42224419e-01f, -4.92376298e-01f, -4.20206517e-01f, 7.36273587e-01f,
  1.34160640e-02f, -1.29180819e-01f, 1.72268376e-01f, 2.49740407e-01f, -9.14494395e-02f, 4.21456695e-02f, 2.71335393e-02f, -5.48502021e-02f, 2.00447813e-01f, -2.06796184e-01f,
  -4.84188907e-02f, 1.69853985e-01f, 2.38933980e-01f, 1.43857539e-01f, -2.85445005e-01f, 1.42804801e-01f, 3.72205651e-03f, 2.04353616e-01f, -1.69052958e-01f, 3.12945515e-01f,
  3.62618148e-01f, 4.25302029e-01f, -1.48172807e-02f, 3.69050384e-01f, 5.78897238e-01f, 4.00030106e-01f, 2.37523273e-01f, 3.07023734e-01f, 4.76895124e-01f, 6.53790057e-01f,
  4.04555827e-01f, -4.32237446e-01f, -4.64696199e-01f, -2.15622857e-01f, -2.73206443e-01f, -3.87493819e-01f, 2.43039772e-01f, -2.58536547e-01f, -5.60989141e-01f, -5.27919114e-01f,
  -6.72513485e-01f, -5.32931387e-01f, 3.57370451e-02f, -2.37578481e-01f, -7.01943576e-01f, -6.45444542e-02f, 2.41703615e-01f, -5.58038116e-01f, -7.35143960e-01f, -6.27223432e-01f,
  -3.77630174e-01f, -6.36004210e-01f, -6.92567229e-01f, 2.51358271e-01f, -3.85952204e-01f, 8.62820089e-01f, 7.67106950e-01f, 1.56670928e-01f, 3.54150563e-01f, -1.28132775e-01f,
  -2.66841412e-01f, -8.40516329e-01f, 6.73386633e-01f, -1.97966501e-01f, 1.73690632e-01f, 1.77589715e-01f, -2.77687192e-01f, 1.86670050e-01f, -1.50096295e-02f, -5.89211471e-03f,
  -4.04959172e-02f, 2.55027860e-01f, -1.12658264e-02f, 8.88450295e-02f, 1.56146243e-01f, 1.36989504e-01f, -3.06038782e-02f, 1.96191728e-01f, 5.63798212e-02f, 1.91827774e-01f,
  2.82343570e-02f, -2.27534831e-01f, 6.74640313e-02f, -4.01775241e-01f, 8.25452507e-02f, -3.19867730e-01f, 2.99561948e-01f, -4.49496329e-01f, 4.39340234e-01f, -4.22946960e-01f,
  3.39161046e-02f, 1.52174369e-01f, 5.09670675e-01f, 2.43505239e-01f, 7.48844445e-03f, 1.16057649e-01f, 1.05261132e-01f, 3.07133943e-01f, -4.78020787e-01f, 8.46515596e-02f,
  -4.15868282e-01f, 5.19952737e-02f, -6.68504238e-01f, -6.65040687e-02f, 7.95654655e-01f, -3.77555907e-01f, -2.46497154e-01f, 4.65859994e-02f, -3.82081479e-01f, 4.45039719e-01f,
  -8.30664039e-01f, -4.33263034e-02f, 7.91235507e-01f, 4.23558593e-01f, 6.19162500e-01f, 1.23367913e-01f, -8.02809715e-01f, -1.67554542e-01f, -5.57240427e-01f, -3.45862240e-01f,
  -1.24380544e-01f, -8.45247746e-01f, -8.34561825e-01f, -4.55952317e-01f, -4.18317430e-02f, -1.35741204e-01f, 4.91046250e-01f, -5.16564369e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.55713999e-01f, -5.57754003e-03f, 7.26186484e-02f, -1.75118655e-01f, -3.08984425e-02f, 1.02450497e-01f, -9.85655934e-02f, -9.38639492e-02f, 1.40891243e-02f, -3.81804630e-02f,
  1.52783036e-01f, 9.60834473e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    