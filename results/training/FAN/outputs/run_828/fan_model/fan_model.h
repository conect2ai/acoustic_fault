/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.25632569e-01f, -2.69173652e-01f, -2.76433945e-01f, -2.68512331e-02f, -4.11562443e-01f, -2.78637588e-01f, -4.36630666e-01f, 1.17387757e-01f, 1.24128923e-01f, -2.76620626e-01f,
  -1.35160342e-01f, 1.51369527e-01f, 1.43354192e-01f, 1.61171645e-01f, 1.69083759e-01f, -2.60963678e-01f, -2.63425469e-01f, 1.78756043e-02f, 1.43476963e-01f, 8.15036744e-02f,
  -1.13075279e-01f, 1.36529859e-02f, 2.12426513e-01f, 1.89543545e-01f, -4.85455170e-02f, 1.01298206e-01f, 4.80417977e-04f, -5.93332499e-02f, -2.93803103e-02f, -3.10651392e-01f,
  -3.87426242e-02f, 3.68780419e-02f, 8.62458572e-02f, -4.32910444e-03f, -1.25686929e-01f, 5.69475479e-02f, 4.54787798e-02f, -2.94324523e-03f, -8.70082825e-02f, -7.05403788e-03f,
  -1.79726526e-01f, 3.32694277e-02f, 4.40344075e-03f, 4.70125256e-03f, 1.23754116e-02f, -2.35259049e-02f, -9.71067138e-03f, 6.46803379e-02f, 3.89270633e-02f, -6.31385669e-02f,
  -1.85441837e-01f, -3.50042462e-01f, -8.22034180e-02f, 4.37429436e-02f, 6.41083196e-02f, -4.35720161e-02f, 3.73795256e-02f, 1.31679103e-01f, 1.60072669e-01f, 1.29084840e-01f,
  -9.07348748e-03f, -3.83350328e-02f, 1.24011934e-02f, 7.96817243e-03f, -3.98032293e-02f, -3.30788307e-02f, -2.96692774e-02f, -5.47735253e-03f, 2.79301014e-02f, 6.27786294e-02f,
  -3.08959372e-02f, 1.08664762e-02f, -1.55126406e-02f, -5.00521995e-03f, -1.79494508e-02f, -5.15310988e-02f, -4.51963171e-02f, -4.30859774e-02f, 1.41277919e-02f, -4.77713393e-03f,
  -2.90843286e-03f, 6.84758928e-03f, -4.13596816e-02f, 6.70692399e-02f, -5.52667007e-02f, -9.60016996e-03f, -5.08374982e-02f, 4.55543287e-02f, 6.62970468e-02f, -3.95736583e-02f,
  2.74893433e-01f, -7.71500915e-02f, 3.98000479e-02f, 5.64469062e-02f, -4.90606464e-02f, 2.14403570e-02f, -1.01927459e-01f, 5.89276627e-02f, 2.03953143e-02f, -2.99343020e-02f,
  5.81861921e-02f, 3.46232168e-02f, -6.25731125e-02f, -4.24277186e-02f, 5.38419932e-03f, 2.31800284e-02f, -1.26237646e-01f, -9.53587145e-02f, 2.05031503e-03f, 5.04466938e-03f,
  -1.44128362e-02f, -8.64170715e-02f, -1.14639640e-01f, -1.13717550e-02f, 4.92920652e-02f, -2.33818535e-02f, -5.30155422e-03f, 8.94143246e-03f, 1.38881207e-02f, -1.96096208e-02f,
  4.69242394e-01f, -2.77173042e-01f, -5.48052639e-02f, 2.16424853e-01f, -1.73242256e-01f, -2.17195690e-01f, -4.25085545e-01f, -1.70451358e-01f, 1.90968782e-01f, -2.03802083e-02f,
  -2.47053042e-01f, 1.43379256e-01f, 1.17613330e-01f, 1.25886053e-01f, 3.32154408e-02f, -7.34766573e-02f, 1.64859131e-01f, 2.25542113e-01f, 1.87317669e-01f, -6.83276802e-02f,
  -7.00329393e-02f, 2.80299913e-02f, 1.21261828e-01f, 1.76808268e-01f, -7.42680430e-02f, 9.69305784e-02f, 3.50793148e-03f, 1.63256899e-02f, -5.75542934e-02f, 8.92796144e-02f,
  -8.09198990e-02f, -2.47560546e-01f, 1.03018135e-01f, 8.14974904e-02f, -1.30740777e-01f, 1.09279394e-01f, -2.33746022e-02f, 9.79784038e-03f, -2.83412691e-02f, 8.90800264e-03f,
  -2.35592015e-02f, 1.95037816e-02f, -3.92355537e-03f, -1.98732633e-02f, -3.57026160e-02f, 1.23456530e-02f, -1.50467483e-02f, 1.34469047e-01f, 9.27407295e-02f, -5.15544601e-02f,
  -3.80013064e-02f, -1.11703314e-01f, -6.64693862e-03f, -3.11710387e-02f, 5.79302646e-02f, 1.70674860e-01f, -1.17440090e-01f, -6.96670189e-02f, -4.70788144e-02f, 6.67680800e-02f,
  1.32692248e-01f, -1.30976671e-02f, -1.75448507e-02f, -3.63639183e-02f, 3.76689062e-02f, 6.60450384e-03f, 9.41564236e-03f, -1.69438086e-02f, -8.55488330e-03f, -4.21315618e-02f,
  5.69707481e-03f, 4.84318333e-03f, 1.36421090e-02f, 2.57359492e-03f, -1.16109885e-02f, -3.38120423e-02f, -6.22358173e-02f, 2.85650361e-02f, -2.12802384e-02f, -3.79454903e-02f,
  -2.14644950e-02f, 6.63111955e-02f, -4.30688001e-02f, -4.55182381e-02f, 2.77712997e-02f, 2.13883258e-02f, 5.31175025e-02f, -7.03693926e-02f, 2.14955080e-02f, 9.04449075e-02f,
  1.08343735e-01f, -5.17649688e-02f, 1.06901020e-01f, 1.43598150e-02f, 7.16096312e-02f, 3.65808494e-02f, 1.39272900e-03f, 4.29448634e-02f, -1.06032006e-03f, 7.62865990e-02f,
  -5.27765676e-02f, 6.79338127e-02f, 9.52810198e-02f, -4.86342935e-03f, -8.71191267e-03f, -3.56034152e-02f, -2.28320956e-02f, 4.52686138e-02f, -9.25409123e-02f, 4.03227732e-02f,
  4.94138487e-02f, 7.15130046e-02f, 1.01944000e-01f, 6.24300800e-02f, 1.52117806e-02f, 3.25940639e-01f, 3.13224085e-02f, 4.69430164e-02f, 2.11649939e-01f, 2.02788323e-01f,
  2.64523864e-01f, -1.79690391e-01f, 4.23185006e-02f, 4.26479802e-02f, -4.21284139e-02f, -2.14017425e-02f, 3.77227031e-02f, 1.54039681e-01f, 5.86273782e-02f, -8.95310193e-02f,
  -1.42919377e-03f, -3.67985293e-02f, 1.34383785e-02f, 2.63152290e-02f, 1.06463172e-01f, -1.24819659e-01f, -1.97315291e-01f, 1.02548867e-01f, 2.03546926e-01f, 7.30338767e-02f,
  -1.04528360e-01f, -2.09225696e-02f, 1.17066473e-01f, 3.16516981e-02f, -2.05967024e-01f, -1.79550439e-01f, -1.25332534e-01f, -1.01854943e-01f, -1.81431964e-01f, -3.35470706e-01f,
  -1.13497727e-01f, 1.42764330e-01f, -2.02575773e-02f, -9.83217210e-02f, -6.56663477e-02f, -8.57563615e-02f, -5.18544838e-02f, -2.46902369e-02f, 3.51961181e-02f, 1.39615461e-02f,
  -1.31568447e-01f, 3.00105363e-02f, -3.61857042e-02f, -1.64308101e-02f, 8.67474303e-02f, 4.59137782e-02f, 2.96006026e-03f, 1.18242331e-01f, 1.93602331e-02f, -7.83690345e-03f,
  -2.32240617e-01f, -1.06134087e-01f, -1.20790794e-01f, 4.84810770e-02f, 5.06420955e-02f, -5.11608385e-02f, -8.26021805e-02f, -6.47655874e-02f, -4.49198820e-02f, -1.70832753e-01f,
  -3.83979864e-02f, -5.03851026e-02f, 6.35017082e-02f, 2.08941400e-02f, 6.41294345e-02f, -3.55554791e-03f, -1.24511179e-02f, -2.20983569e-02f, 2.64080614e-02f, -3.11254933e-02f,
  2.38012429e-02f, 1.11357933e-02f, 7.82644153e-02f, -6.09012768e-02f, -1.29593629e-02f, 1.43345529e-02f, -5.74549139e-02f, -4.84771430e-02f, -6.96838722e-02f, -1.80072302e-03f,
  2.62891855e-02f, -1.06366351e-03f, -7.36329425e-03f, -1.03132771e-02f, -2.08035819e-02f, 2.29797196e-02f, 1.62817854e-02f, -3.81091796e-02f, 1.19192395e-02f, -2.67135110e-02f,
  3.52822207e-02f, 1.89199686e-01f, -6.96017593e-02f, 1.48714548e-02f, -3.54070924e-02f, -2.61572730e-02f, 3.66672873e-02f, 7.04995021e-02f, 5.40060289e-02f, 6.60760850e-02f,
  9.34606642e-02f, 7.24782124e-02f, -2.41941051e-03f, 1.54191805e-02f, 5.42885065e-02f, 3.35761383e-02f, 4.93142195e-03f, 6.32087328e-03f, -1.83611903e-02f, -8.15508068e-02f,
  -8.70597921e-03f, -1.01644464e-01f, -2.91223284e-02f, -8.24891627e-02f, -4.88550179e-02f, 3.18499953e-02f, -8.81742090e-02f, -6.73607066e-02f, -3.83081995e-02f, -2.08973214e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.09071746e-01f, -2.07365856e-01f, 7.14048222e-02f, 4.01109457e-02f, 7.47861266e-02f, 1.38707280e-01f, 4.39147167e-02f, 4.08640690e-02f, -1.00816227e-01f, -2.49035023e-02f,
  -4.33025360e-02f, -6.57269582e-02f, -1.51008040e-01f, -8.15674141e-02f, -1.61199331e-01f, 2.16005351e-02f, 7.12460801e-02f, 2.37436369e-02f, -1.27251968e-02f, 1.75228585e-02f,
  -1.13763131e-01f, -8.83928537e-02f, 4.02679518e-02f, -1.11502096e-01f, 2.16005873e-02f, 4.24567005e-03f, -6.64984062e-02f, -6.65139258e-02f, -1.94520652e-01f, -5.92498370e-02f,
  1.40143037e-01f, -2.14531675e-01f, -2.22402159e-02f, -1.49364129e-01f, -9.80919823e-02f, -1.02750305e-03f, -6.39484078e-03f, 4.51850295e-02f, 3.51862027e-03f, 5.06694727e-02f,
  -8.16204622e-02f, -5.32362312e-02f, -5.51210158e-02f, 2.40615904e-02f, 8.00144225e-02f, 4.74807248e-03f, -6.93425685e-02f, -1.35309875e-01f, -9.63569712e-03f, -1.24921396e-01f,
  -4.07040417e-02f, -1.00340836e-01f, 8.81748423e-02f, -4.50749090e-03f, -1.92895383e-01f, -9.59914029e-02f, -7.29930252e-02f, -1.27697319e-01f, -1.40920475e-01f, 5.18365502e-02f,
  -3.66531946e-02f, 2.57940609e-02f, 4.66794660e-03f, -3.99230830e-02f, -4.60486747e-02f, 8.63772035e-02f, 8.86166170e-02f, 6.01543039e-02f, -9.52705089e-03f, -3.62745896e-02f,
  -6.18910491e-02f, 3.16046216e-02f, -9.92293376e-03f, -2.59051844e-02f, 2.31430884e-02f, -3.47528420e-02f, -5.61509877e-02f, -4.76530101e-03f, 2.89280247e-02f, -8.62401575e-02f,
  -4.94867228e-02f, 1.48491552e-02f, 1.34051321e-02f, 1.64198602e-04f, -1.48719326e-01f, -7.74695054e-02f, -4.99062724e-02f, -1.33175135e-01f, 1.51974149e-02f, 4.96974625e-02f,
  1.29464880e-01f, -1.38132483e-01f, 1.66845277e-01f, -9.46865305e-02f, -5.28160483e-03f, 1.92607939e-02f, -1.13048673e-01f, -6.54378384e-02f, -3.54560427e-02f, -2.88344640e-02f,
  -3.84808667e-02f, -3.30355428e-02f, -4.99309637e-02f, 6.58512414e-02f, 1.19948581e-01f, -3.05837542e-02f, -2.42578797e-02f, 1.24025606e-01f, -3.48489708e-03f, -9.09531489e-02f,
  -3.31504084e-02f, 4.36842740e-02f, 1.73666120e-01f, 1.32060871e-01f, 7.58491606e-02f, 1.74913481e-01f, 1.40919894e-01f, 1.26281276e-01f, 1.64041415e-01f, 3.15509528e-01f,
  -4.62195963e-01f, -3.45907301e-01f, -2.68309891e-01f, -3.56169313e-01f, -8.94538760e-02f, 1.22437723e-01f, 1.23060741e-01f, 6.85996860e-02f, -8.70036334e-02f, -2.25494474e-01f,
  -1.74717717e-02f, -1.33432642e-01f, -2.30379980e-02f, 7.79263070e-03f, 8.00751001e-02f, -9.48626269e-03f, 2.92717153e-03f, 7.72404596e-02f, 1.59768164e-01f, 2.65638351e-01f,
  8.61265585e-02f, -2.76021305e-02f, -8.36304277e-02f, 2.31344141e-02f, -9.34194475e-02f, 2.05638353e-03f, -1.23881899e-01f, -2.37987731e-02f, 2.04461422e-02f, -2.19206288e-01f,
  -2.68236369e-01f, -2.25584537e-01f, 1.37409046e-01f, 2.03089360e-02f, -6.84183687e-02f, -7.07676751e-04f, -7.46439863e-03f, -1.32269531e-01f, 2.53345165e-02f, -9.34015065e-02f,
  -9.90957841e-02f, -4.61125448e-02f, -9.00386497e-02f, -3.77680995e-02f, -8.10654275e-03f, 5.07543981e-02f, -5.41862808e-02f, 1.43532511e-02f, 6.34591188e-03f, 7.15211034e-02f,
  1.16204098e-01f, -2.51163058e-02f, 4.20927592e-02f, 1.11819029e-01f, -1.62071437e-02f, 4.44170721e-02f, -8.06551278e-02f, 2.30229273e-02f, 5.57431802e-02f, -1.83281779e-01f,
  6.28401563e-02f, -3.33516300e-02f, -2.46866979e-02f, 4.51227687e-02f, -9.14314166e-02f, -8.26913342e-02f, -7.90418964e-03f, 4.31164727e-02f, 8.29053968e-02f, -2.59306002e-03f,
  1.28982088e-03f, 1.17336940e-02f, -2.53553856e-02f, -3.85190099e-02f, -8.01701248e-02f, 1.16249928e-02f, 3.63618992e-02f, -2.02337503e-02f, 7.15977848e-02f, 8.64391122e-03f,
  -3.67668979e-02f, 1.48564400e-02f, -6.28614351e-02f, 9.12492424e-02f, 5.70230260e-02f, -4.87788841e-02f, -1.28097367e-02f, 1.47462906e-02f, -2.68554228e-04f, -2.89986581e-02f,
  -2.88719982e-01f, 1.95918486e-01f, -1.86682209e-01f, -1.16753867e-02f, -1.23471640e-01f, 1.24964258e-03f, -1.34763822e-01f, -7.14055402e-03f, -1.22090593e-01f, 1.33833475e-02f,
  5.13570458e-02f, -5.25594540e-02f, -1.18668526e-01f, 7.27930143e-02f, 2.90991832e-02f, 4.78860959e-02f, -3.68332043e-02f, -6.95532709e-02f, 9.22465771e-02f, 4.61349823e-02f,
  -1.49046187e-03f, 8.24742094e-02f, -7.98759162e-02f, 1.53597873e-02f, -1.66801065e-02f, 5.10819107e-02f, 5.88589290e-04f, -7.00064674e-02f, 1.42854914e-01f, -2.02674463e-01f,
  2.86204759e-02f, 1.04808055e-01f, 9.81034562e-02f, 9.53283161e-02f, 1.12598250e-02f, 1.50361016e-01f, 1.17596567e-01f, 5.91644645e-02f, 6.41961247e-02f, -5.00287339e-02f,
  5.81072047e-02f, -6.97129890e-02f, -2.88245529e-02f, 4.78543062e-03f, -4.32309229e-03f, 1.97401289e-02f, 5.38364351e-02f, -2.09616404e-02f, -6.53791204e-02f, -8.21821913e-02f,
  -1.14208600e-02f, -4.60778959e-02f, -3.25534306e-02f, -6.98717907e-02f, -3.31394421e-03f, 1.90995610e-03f, 5.98476082e-02f, 1.04991801e-01f, -6.86365515e-02f, -5.13092689e-02f,
  1.60736702e-02f, 7.99652264e-02f, -1.14806071e-01f, -2.04711463e-02f, 9.45584252e-02f, 3.58204842e-02f, -8.31256136e-02f, 8.58213305e-02f, 3.78155597e-02f, -3.60157974e-02f,
  6.24857768e-02f, -4.73994240e-02f, 7.58598149e-02f, 6.76300824e-02f, 2.86321882e-02f, 3.66743430e-02f, -8.54319260e-02f, -6.44404069e-02f, 1.06405420e-02f, 6.04850017e-02f,
  -3.83218564e-02f, 6.04993524e-03f, 9.21928585e-02f, 7.70707875e-02f, -8.37728679e-02f, 8.08884110e-03f, -3.41738425e-02f, 5.17101474e-02f, 6.60248399e-02f, -5.30525893e-02f,
  -4.33887765e-02f, -7.74486735e-02f, 3.03539447e-02f, -3.95151079e-02f, 5.56933880e-02f, -2.98989168e-03f, -1.21879363e-02f, 9.66731757e-02f, -4.32791971e-02f, 4.03270647e-02f,
  9.10989270e-02f, -3.45469709e-03f, 4.80888970e-03f, 5.12607442e-03f, 6.02561273e-02f, -4.11627591e-02f, -4.38940413e-02f, 7.66023472e-02f, 5.13146073e-03f, 5.95962815e-02f,
  8.69005471e-02f, 8.10188875e-02f, 7.62373284e-02f, -1.95189938e-02f, 2.42213067e-03f, -3.42202932e-02f, 2.39914134e-02f, 2.21335460e-02f, 1.46439066e-02f, 2.69527687e-03f,
  3.66265103e-02f, -5.61004989e-02f, -2.36588363e-02f, -6.48110062e-02f, -8.03724490e-03f, -5.94003387e-02f, 5.78193292e-02f, -7.74390250e-03f, 7.40706995e-02f, -6.97695836e-02f,
  4.84763123e-02f, 5.41421399e-02f, -1.59236994e-02f, 1.35900779e-02f, 5.26334671e-03f, -2.58315373e-02f, 2.19528400e-03f, -8.63957219e-03f, -1.59616377e-02f, -8.78402218e-02f,
  3.87976070e-05f, 7.40855141e-03f, 4.68105152e-02f, -5.75489551e-02f, -1.78832226e-02f, 3.32062729e-02f, 4.91750725e-02f, -1.18163200e-02f, -5.06988503e-02f, 5.68119772e-02f,
  -3.53941679e-01f, 2.43692547e-02f, -1.87843621e-01f, -2.33302832e-01f, -6.15377165e-02f, 1.23610869e-01f, 2.37038612e-01f, 1.43283427e-01f, 2.68811658e-02f, -8.42860192e-02f,
  -8.11199173e-02f, -6.79096952e-02f, -1.09003834e-01f, -6.02709502e-02f, -6.89137653e-02f, -2.41879025e-03f, -6.70147836e-02f, -1.47707000e-01f, -9.59031656e-02f, 6.90111592e-02f,
  -6.49568066e-02f, -2.33788550e-01f, -3.22148442e-01f, -1.48906246e-01f, -5.96437827e-02f, -2.43763819e-01f, -1.69966996e-01f, -2.20141262e-01f, -7.44217560e-02f, -2.54491478e-01f,
  1.42138207e-03f, -1.16997927e-01f, 5.75326681e-02f, 4.50000446e-03f, 1.00996448e-02f, -4.42788266e-02f, 8.65357667e-02f, -1.13948576e-01f, 3.10785398e-02f, 5.41210407e-03f,
  -7.50974193e-03f, -1.33371232e-02f, 3.54387262e-03f, -5.11904657e-02f, -7.86489900e-03f, 1.02031246e-01f, 6.86634853e-02f, -8.67863670e-02f, 1.07496197e-03f, 1.15435451e-01f,
  1.15212142e-01f, 3.73541028e-03f, -9.46588293e-02f, 7.42246062e-02f, 6.47986308e-02f, -5.89935891e-02f, 4.68046144e-02f, 9.51093957e-02f, -7.86090866e-02f, -6.88947737e-02f,
  7.91687667e-02f, -5.79588376e-02f, -8.74581933e-03f, -6.70069456e-02f, 3.63023835e-03f, -5.26032075e-02f, 4.05935384e-02f, -5.98737560e-02f, -1.07680606e-02f, 6.12679236e-02f,
  9.80095845e-03f, -2.74625197e-02f, -9.83857736e-03f, -1.91276744e-02f, -6.47688583e-02f, -7.27564692e-02f, -3.98304639e-03f, -3.63326557e-02f, -2.81437244e-02f, -6.49609342e-02f,
  8.44738334e-02f, 4.50648181e-03f, 2.75325757e-02f, 8.93897787e-02f, -1.65803023e-02f, 5.30250221e-02f, 1.05051205e-01f, 7.24020377e-02f, 5.37188090e-02f, 1.33922268e-02f,
  -2.26029962e-01f, 5.42393327e-02f, 5.37921339e-02f, -1.21701621e-01f, -1.02547936e-01f, -3.18836495e-02f, -7.46731693e-03f, -7.53673259e-03f, -5.30285947e-02f, -4.19642963e-02f,
  -1.47533044e-02f, 1.58258285e-02f, 4.39719521e-02f, 1.02942139e-01f, 1.06372321e-02f, 7.10619465e-02f, -2.68669613e-02f, -1.72382504e-01f, -3.57363559e-02f, 3.78534310e-02f,
  6.63763136e-02f, -1.07423298e-01f, -1.42102744e-02f, -2.48868503e-02f, -6.32071793e-02f, -1.19746558e-01f, -1.03696354e-01f, -5.91038167e-02f, -9.79170576e-02f, -5.82218952e-02f,
  1.42777249e-01f, -2.31116995e-01f, 2.27581009e-01f, 2.12665051e-02f, 1.70985758e-01f, 2.37560585e-01f, 1.65131897e-01f, 2.68418733e-02f, -8.49257037e-02f, -3.35964561e-03f,
  -2.00077653e-01f, -1.71336114e-01f, -7.75608793e-03f, -1.42248496e-01f, -2.72976533e-02f, 1.18156597e-01f, 1.84967872e-02f, 2.06098989e-01f, 2.41553053e-01f, 3.02460734e-02f,
  -5.89880459e-02f, 1.34119699e-02f, -2.38303021e-02f, -1.12407133e-01f, 1.57945137e-03f, 5.33682778e-02f, 2.69003194e-02f, -3.46084833e-02f, -1.91637263e-01f, -4.66369204e-02f,
  1.19647101e-01f, -1.73274726e-01f, 6.48586527e-02f, -1.65848941e-01f, -2.38426924e-02f, -1.35187238e-01f, 9.53558311e-02f, -9.29164439e-02f, 3.20905000e-02f, -1.72747970e-02f,
  -9.90468487e-02f, -1.02503307e-01f, 4.19114158e-02f, -1.52477086e-01f, 3.53190750e-02f, 2.82551199e-02f, -1.69877365e-01f, -6.38773590e-02f, -9.53636467e-02f, -4.11518291e-02f,
  -1.48653641e-01f, -8.05141702e-02f, 1.06094934e-01f, -3.36920880e-02f, -1.05802953e-01f, -2.85943095e-02f, -6.15976099e-03f, -1.48568392e-01f, 3.02281156e-02f, -3.17803286e-02f,
  -2.73162276e-02f, -4.91473963e-03f, 3.09575368e-02f, -8.79336894e-03f, -5.39883673e-02f, 8.66619125e-02f, 5.96286394e-02f, 2.50825994e-02f, 2.05413010e-02f, 5.61443046e-02f,
  6.39832625e-03f, 1.45598263e-01f, 4.08230051e-02f, 6.35542870e-02f, -9.45999697e-02f, 8.22848752e-02f, 1.17861517e-01f, -6.85824305e-02f, 6.34154752e-02f, -7.64780957e-03f,
  1.91516802e-02f, 7.21802935e-02f, 7.82310516e-02f, 2.39531640e-02f, -2.68354286e-02f, -2.91211195e-02f, -2.87527713e-04f, -4.70880046e-02f, 2.36791205e-02f, -1.12285083e-02f,
  8.15953314e-02f, 6.63737021e-03f, -7.46863429e-03f, 4.46302444e-02f, 1.81310847e-02f, -5.38326837e-02f, -9.55769345e-02f, -3.89585011e-02f, -1.15246005e-01f, 1.08508952e-01f,
  2.27820463e-02f, -8.58199410e-03f, -6.01897649e-02f, -3.29048224e-02f, 2.08292827e-01f, 9.31640118e-02f, -4.11015861e-02f, 4.85813618e-03f, -1.23571515e-01f, 4.47525531e-02f,
  -1.51706323e-01f, 1.14576258e-01f, 2.52924949e-01f, 1.41758829e-01f, -8.31551757e-03f, 1.26340479e-01f, 9.11449939e-02f, 1.48091525e-01f, 1.27078757e-01f, 2.33203784e-01f,
  6.42594516e-01f, 6.43838644e-02f, 1.47128448e-01f, 1.32645488e-01f, -2.54636019e-01f, -3.86562258e-01f, -3.38757515e-01f, -9.30509865e-02f, -3.19158509e-02f, 7.70059377e-02f,
  -1.50494978e-01f, -7.03459233e-02f, 7.94000998e-02f, 1.27822131e-01f, 1.68617517e-01f, 6.67221425e-03f, 9.77814570e-02f, 3.45033079e-01f, 1.71966851e-01f, 1.55425489e-01f,
  8.36417777e-04f, 1.14674546e-01f, 3.28240514e-01f, 2.09570542e-01f, 9.23624933e-02f, -2.76920982e-02f, 5.25732897e-02f, 4.14668620e-02f, 2.87203435e-02f, 4.14671540e-01f,
  3.60647500e-01f, 1.13943651e-01f, -9.04930234e-02f, 5.76575845e-02f, -3.96014601e-02f, 1.00115553e-01f, -2.52344422e-02f, 7.97901005e-02f, -1.17693484e-01f, 6.14459701e-02f,
  -3.39661874e-02f, 8.06109384e-02f, -8.89194235e-02f, -4.67574485e-02f, 2.71176957e-02f, -6.47661611e-02f, 7.24722147e-02f, 2.42928922e-01f, -2.71330820e-03f, 4.21125628e-03f,
  -9.46473405e-02f, -8.17264989e-03f, -6.76898137e-02f, -1.90584108e-01f, -9.85404570e-03f, -5.65297864e-02f, -3.86616252e-02f, 1.88062582e-02f, -3.15429270e-02f, 1.52287647e-01f,
  6.05148077e-03f, 6.11018110e-03f, -1.89532582e-02f, 4.26008068e-02f, 9.71857551e-03f, -2.82703750e-02f, 2.52525210e-02f, -3.18094045e-02f, -6.62860870e-02f, 5.72635382e-02f,
  2.46507954e-02f, 2.41535455e-02f, -2.76236273e-02f, 3.44509855e-02f, 1.64343435e-02f, 2.77580936e-02f, -3.44760343e-02f, 4.24189568e-02f, -3.41785960e-02f, -2.56298687e-02f,
  6.04574196e-02f, -5.24952896e-02f, 1.58386398e-02f, 2.42386833e-02f, 1.01817854e-01f, 8.53926688e-02f, -1.71870999e-02f, -1.34459883e-02f, -7.40750805e-02f, 4.25733514e-02f,
  -1.45225003e-01f, -2.93672860e-01f, 1.61075845e-01f, 1.48347750e-01f, 7.57122226e-03f, 3.36493775e-02f, -2.38634460e-02f, 1.73261855e-02f, -3.59514728e-02f, 7.77992280e-03f,
  2.19293963e-02f, 2.84974780e-02f, -8.00242648e-02f, 4.16029729e-02f, -7.63722882e-02f, 8.76482949e-03f, -1.84208248e-02f, 7.40930717e-03f, -1.07180153e-03f, 4.68001179e-02f,
  -9.80261490e-02f, -1.00546725e-01f, -9.64835361e-02f, -1.73938408e-01f, -7.56653696e-02f, -7.69706145e-02f, -9.61965024e-02f, -1.00794114e-01f, -8.38076770e-02f, -1.00502260e-01f,
  2.77171209e-02f, 2.87020225e-02f, 2.96819538e-01f, -1.91335708e-01f, -7.15502426e-02f, 1.88077372e-02f, 5.44698909e-03f, -5.16080260e-02f, -1.01581305e-01f, -1.03196315e-01f,
  -4.49837483e-02f, -9.80899334e-02f, -9.11786407e-03f, -7.43833110e-02f, -8.75060633e-03f, -2.86033517e-03f, 7.11499676e-02f, 1.80608243e-01f, 8.51474255e-02f, -1.05108574e-01f,
  -9.35578346e-02f, -1.17101252e-01f, 1.72876418e-02f, -9.94758084e-02f, -1.50765240e-01f, -8.14848542e-02f, -1.81230586e-02f, -1.03380494e-02f, 9.73645970e-02f, -1.56778485e-01f,
  -4.81682196e-02f, 2.89674662e-02f, 1.90645568e-02f, -1.33070365e-01f, -3.91657911e-02f, 5.61792292e-02f, -1.12374879e-01f, 3.66993174e-02f, 4.00762074e-02f, 3.28761302e-02f,
  -3.01739108e-03f, 1.92410443e-02f, -8.94254670e-02f, -8.70110318e-02f, 1.01231290e-02f, -6.31838739e-02f, -2.79123392e-02f, 4.25426140e-02f, 9.43602324e-02f, -6.58622459e-02f,
  -1.25525475e-01f, 3.21410075e-02f, 2.13570163e-01f, 1.28487749e-02f, -3.34761180e-02f, 1.05590619e-01f, 4.89983968e-02f, -2.58772187e-02f, 1.03921130e-01f, -1.53706923e-01f,
  -4.40082699e-03f, 3.37892659e-02f, 2.53238939e-02f, 4.11177576e-02f, 5.44377901e-02f, -4.13034745e-02f, -6.36964887e-02f, -3.22926184e-03f, 2.92616244e-02f, -1.51343113e-02f,
  -1.00324750e-01f, -2.05732547e-02f, -7.88939223e-02f, -4.79179211e-02f, 6.16604760e-02f, -5.14956899e-02f, 5.27889878e-02f, -4.54333425e-02f, 7.82324523e-02f, -3.94341871e-02f,
  -1.38275037e-02f, -6.38119830e-03f, -2.00331770e-02f, -5.72089292e-02f, 4.77222726e-02f, -3.71887498e-02f, -5.01141697e-02f, 6.76977709e-02f, 7.06332102e-02f, 8.83064047e-02f,
  -1.81714565e-01f, 3.65617365e-01f, -1.71560422e-01f, -7.86035061e-02f, -3.09711173e-02f, 5.91936521e-03f, 1.80568714e-02f, 6.44514337e-02f, 8.22791383e-02f, 1.83011796e-02f,
  -8.17640424e-02f, -5.18130921e-02f, -5.23985513e-02f, -9.16410424e-03f, -6.28067851e-02f, -6.21412508e-02f, 6.15242310e-02f, -1.29459277e-02f, 8.25098157e-02f, -9.19247493e-02f,
  -1.84067823e-02f, 1.03106283e-01f, -1.05193704e-02f, 1.86485071e-02f, -3.33938152e-02f, 5.55809550e-02f, -5.31435423e-02f, -3.40713151e-02f, 5.95553741e-02f, -1.17077164e-01f,
  3.24145943e-01f, 1.87990829e-01f, -2.80904412e-01f, 3.09124291e-01f, -3.23522985e-02f, -1.37696207e-01f, -1.86633430e-02f, 1.28999382e-01f, 1.60792381e-01f, 3.91124152e-02f,
  -6.91152737e-02f, -3.21335085e-02f, -9.99062434e-02f, -1.21150307e-01f, -1.51641250e-01f, -1.37291506e-01f, -5.53452931e-02f, -5.93759902e-02f, -9.04484615e-02f, -6.90138042e-02f,
  8.12629685e-02f, 1.80469081e-01f, 1.41154930e-01f, 9.68544334e-02f, -3.77311893e-02f, -4.79209311e-02f, -5.77095449e-02f, -8.05259198e-02f, -2.12427542e-01f, -2.29646817e-01f,
  -3.98424536e-01f, 3.21708573e-03f, -2.03984320e-01f, -1.20503327e-03f, -1.50384471e-01f, -1.05339312e-03f, -1.07665874e-01f, 1.40841212e-02f, -5.97000644e-02f, 2.31311005e-02f,
  -4.20946814e-02f, -4.95118555e-03f, -8.53561014e-02f, -2.76561640e-02f, 7.54715577e-02f, -1.88675430e-02f, 8.24888423e-02f, -4.23900411e-02f, 3.34966891e-02f, -1.28514245e-01f,
  -1.10768773e-01f, -1.49627730e-01f, -1.48465067e-01f, -6.28605261e-02f, -8.03311989e-02f, -1.23377346e-01f, -9.14432183e-02f, -1.62393168e-01f, -9.67841819e-02f, 6.95565715e-02f,
  2.67489813e-02f, -3.98428403e-02f, -4.83317636e-02f, 4.57782149e-02f, 6.39357511e-03f, 1.81345511e-02f, -4.11440358e-02f, 5.31752175e-03f, 4.72593978e-02f, 1.05151176e-01f,
  6.18177874e-04f, 2.77734566e-02f, 5.32202004e-03f, 6.05028905e-02f, -2.25541345e-03f, -2.20715720e-02f, -6.02035262e-02f, 1.91829894e-02f, -2.79885661e-02f, 6.53972290e-03f,
  -2.63695605e-02f, -2.66409181e-02f, 1.04932509e-01f, -2.57721841e-02f, -1.57823712e-02f, -1.60581544e-02f, -7.70802349e-02f, 2.94607114e-02f, 5.92564754e-02f, 6.59793466e-02f,
  2.73887843e-01f, -3.67654525e-02f, -6.70289248e-02f, -8.26636180e-02f, -6.58379346e-02f, 4.13631238e-02f, -2.28817537e-02f, -1.24202864e-02f, -2.68863402e-02f, -1.95926353e-02f,
  -4.30327393e-02f, 5.51826730e-02f, 5.96753657e-02f, -5.49118919e-03f, 7.53454398e-03f, -2.98517011e-02f, 6.00894727e-02f, 3.62628442e-03f, -4.82040420e-02f, 8.48954394e-02f,
  8.97448882e-02f, 7.08502010e-02f, 8.89674574e-02f, -1.31619778e-02f, -6.88817874e-02f, 4.03937092e-03f, -9.58004147e-02f, 3.46485786e-02f, -3.59119363e-02f, 2.17447951e-01f,
  5.38040757e-01f, -2.26346090e-01f, -2.71100607e-02f, -3.58674042e-02f, -1.67487562e-01f, 5.57363480e-02f, -3.14811356e-02f, -4.89153527e-02f, 6.96984082e-02f, -9.91961882e-02f,
  6.91152513e-02f, 2.10279763e-01f, 2.78187037e-01f, 1.78827181e-01f, 2.24476218e-01f, -1.18671127e-01f, -3.53513211e-02f, 7.75201172e-02f, 2.43399993e-01f, -4.31728698e-02f,
  -8.06469992e-02f, -1.62033141e-01f, 1.34913564e-01f, -6.66887313e-02f, -2.56170362e-01f, 5.36285155e-02f, -1.68040246e-01f, -1.11759350e-01f, -1.19169749e-01f, -2.54638791e-01f,
  3.55972052e-02f, 1.21341087e-01f, 1.61473498e-01f, 9.53156799e-02f, -1.59932952e-02f, -2.77543743e-03f, 2.30534431e-02f, -7.15714693e-02f, 2.75666807e-02f, -3.15729044e-02f,
  3.53303850e-02f, -2.32886262e-02f, 7.78489411e-02f, -1.08359888e-01f, -1.07491188e-01f, 6.50432780e-02f, -2.78111640e-02f, 4.87457067e-02f, 6.31475225e-02f, -2.78444067e-02f,
  -1.80887319e-02f, 7.99370557e-02f, 1.15133055e-01f, 5.34492433e-02f, 1.67602926e-01f, 1.05925754e-01f, -1.12286676e-02f, -1.82882287e-02f, 2.02314004e-01f, -1.10587053e-01f,
  5.45254583e-03f, 5.54542355e-02f, -3.58219482e-02f, -3.85898910e-02f, -1.85162928e-02f, 7.74023822e-03f, -3.45880073e-03f, -1.38523262e-02f, -2.21697893e-02f, -5.66939488e-02f,
  -1.46679888e-02f, -2.52112728e-02f, 2.18715668e-02f, 2.90420256e-03f, 6.90485165e-02f, -4.25542742e-02f, 2.13950928e-02f, 9.30862967e-03f, -1.80754326e-02f, 4.16508727e-02f,
  6.42760983e-03f, 9.36550740e-03f, 1.45981484e-03f, 2.38737874e-02f, -7.62356445e-02f, -4.65631671e-02f, 1.87387578e-02f, -7.11392239e-02f, -2.82944497e-02f, -6.78527504e-02f,
  -8.62435922e-02f, 2.17003495e-01f, 4.58236635e-02f, -1.97590813e-02f, -3.69433239e-02f, 1.69830397e-02f, 5.43561019e-02f, -5.94855323e-02f, -6.51153103e-02f, -1.62547082e-02f,
  3.34154516e-02f, 4.50050682e-02f, -3.14410925e-02f, -1.06722419e-03f, 2.03643590e-02f, -3.15891802e-02f, -5.71889430e-02f, 8.46941695e-02f, 3.44291888e-02f, -2.36299410e-01f,
  -1.77699625e-01f, -1.52243292e-02f, 1.07338510e-01f, 1.09163284e-01f, -7.88884982e-03f, 2.69139111e-01f, -1.46370260e-02f, 5.86343370e-02f, 2.12491810e-01f, -2.40081534e-01f,
  1.09794617e-01f, -4.80233412e-03f, 1.36521786e-01f, 4.44138981e-02f, -1.06536396e-01f, -2.60704607e-01f, -4.06289667e-01f, -2.29766890e-01f, 2.79982593e-02f, -5.01631275e-02f,
  -1.11806691e-02f, 9.26671829e-03f, 3.59701626e-02f, 2.73896120e-02f, -8.53315890e-02f, -1.09526105e-02f, 7.50972703e-02f, -1.31194270e-03f, -1.92990988e-01f, -1.84485346e-01f,
  -5.28997555e-02f, 1.21679828e-01f, 1.05310649e-01f, 3.37470360e-02f, 1.25312313e-01f, 3.49465795e-02f, 6.84258342e-02f, 4.91274893e-02f, 2.97505800e-02f, 2.02194124e-01f,
  1.38958439e-01f, -2.89680175e-02f, -1.32854823e-02f, 1.32819265e-01f, 1.52134195e-01f, -3.90208289e-02f, 5.01376204e-03f, -4.86414097e-02f, -1.13103185e-02f, -5.13016758e-03f,
  -7.13427435e-04f, -1.10254608e-01f, 3.96070592e-02f, -1.13322310e-01f, 3.66475210e-02f, -9.27475616e-02f, -1.69841424e-02f, -4.71986644e-02f, -1.18305013e-02f, -5.47325909e-02f,
  -4.92413230e-02f, -2.60870066e-02f, -1.70110345e-01f, -1.13431633e-01f, -1.36457935e-01f, -8.14864635e-02f, -1.04853034e-01f, -6.87602684e-02f, -7.09692836e-02f, 2.85184588e-02f,
  -6.59241006e-02f, 2.18109619e-02f, -4.04022960e-03f, 6.07330464e-02f, -4.44224514e-02f, -8.97212625e-02f, 6.96991012e-02f, -6.44302964e-02f, 2.59685013e-02f, 3.20405923e-02f,
  -1.18914740e-02f, 3.05022672e-02f, -5.21364622e-03f, 1.20042311e-02f, -7.10359635e-03f, 1.50323557e-02f, -4.19936962e-02f, -9.18416828e-02f, -5.14221862e-02f, 2.36009154e-02f,
  5.28828427e-02f, -1.51988966e-02f, 9.63267982e-02f, 6.46888912e-02f, -4.12902748e-03f, -8.33210722e-03f, 2.62802057e-02f, -7.63380304e-02f, -2.04479061e-02f, -5.88443913e-02f,
  5.14217392e-02f, -7.09902123e-02f, -1.56558938e-02f, -6.79283589e-02f, 7.95524195e-02f, 3.78877968e-02f, 1.04034573e-01f, -9.44303535e-03f, 3.25073339e-02f, -1.22948125e-01f,
  -6.96775392e-02f, -9.85297114e-02f, 5.46475500e-02f, 2.69794837e-02f, -1.40330404e-01f, -1.79093257e-02f, 7.88745377e-03f, -5.39851189e-02f, -8.19636136e-02f, -3.48415896e-02f,
  8.31640884e-02f, -1.39483854e-01f, -2.18396753e-01f, -4.25901487e-02f, 3.91457267e-02f, -1.05656385e-01f, -1.60945147e-01f, -1.61522493e-01f, -1.39411584e-01f, -8.40345323e-02f,
  -2.67465692e-02f, -7.48142153e-02f, -9.94475409e-02f, 2.66440567e-02f, 7.45700896e-02f, -2.49290541e-01f, -3.04806083e-01f, -2.54318446e-01f, -4.39831391e-02f, -6.47254661e-02f,
  -3.39959073e-03f, 6.72623292e-02f, 1.21131083e-02f, -6.63902909e-02f, -1.48764923e-01f, -2.02187389e-01f, -8.39050207e-03f, 1.05527192e-02f, -9.96518135e-02f, -7.09486241e-03f,
  1.78840142e-02f, 4.61118370e-02f, 1.01920843e-01f, 3.66430879e-02f, 1.38549268e-01f, 1.71413600e-01f, 1.09188676e-01f, 1.51391104e-01f, 1.18678115e-01f, 1.28193021e-01f,
  -7.70270899e-02f, -6.55498281e-02f, 1.89060587e-02f, 3.48190926e-02f, 5.35140410e-02f, 1.85611695e-02f, 1.75608601e-02f, -3.06687616e-02f, -1.52830239e-02f, -8.49397182e-02f,
  3.42089199e-02f, 2.25017890e-02f, 8.42066258e-02f, -1.04047051e-02f, -1.11007608e-01f, -1.46828946e-02f, -4.56920564e-02f, -1.24372467e-01f, 4.63422127e-02f, 1.76072260e-03f,
  -7.75262117e-02f, 7.08327862e-03f, -8.70466884e-03f, -2.27312557e-02f, 5.65003231e-02f, 8.50309357e-02f, 5.63426455e-03f, 2.01811325e-02f, 8.28699321e-02f, -4.57319096e-02f,
  -1.76687054e-02f, -3.48074734e-02f, 4.45172526e-02f, -2.69295685e-02f, -3.93426120e-02f, 3.73464078e-02f, -2.53366772e-02f, -4.87091020e-03f, 2.01198738e-02f, 3.86523418e-02f,
  6.86081052e-02f, -3.23817991e-02f, -5.15689105e-02f, 2.45543383e-02f, 1.05856173e-01f, -2.04218347e-02f, 9.28912386e-02f, -7.85292475e-04f, 1.80746894e-02f, 2.70509347e-03f,
  -4.08744812e-02f, 3.66193727e-02f, -1.75423846e-02f, -4.93262485e-02f, 7.39666075e-02f, -3.62749994e-02f, 2.58235121e-03f, 9.46915075e-02f, 6.64193705e-02f, 5.40781394e-02f,
  -8.87161717e-02f, 1.19932912e-01f, -4.95981164e-02f, 1.38772158e-02f, 1.04358852e-01f, 5.04117943e-02f, 1.09288663e-01f, 2.44536214e-02f, 1.17398538e-01f, -1.01799339e-01f,
  5.64746857e-02f, 2.27875728e-02f, 3.42724635e-03f, -8.52650180e-02f, -6.12734966e-02f, -7.39251822e-03f, -1.83069743e-02f, 3.07621211e-02f, -1.86124705e-02f, -1.13385327e-01f,
  -8.42946768e-02f, -1.99476957e-01f, -2.03906164e-01f, -1.49492845e-01f, -1.05419658e-01f, -2.75423881e-02f, -8.13976745e-04f, -4.59788404e-02f, -1.82855397e-01f, -2.37600207e-01f,
  -2.17864797e-01f, 5.80680231e-03f, 8.25797617e-02f, -2.06136972e-01f, -2.41217390e-02f, 2.19861567e-02f, 1.20996296e-01f, -5.86635955e-02f, -1.43929660e-01f, 4.46568057e-02f,
  -5.65628521e-02f, -2.87330337e-02f, 9.31007490e-02f, 3.46419774e-02f, 5.49315438e-02f, 6.63925260e-02f, 9.82038304e-02f, -1.90381287e-03f, -4.02885228e-02f, 7.75633156e-02f,
  -4.31129821e-02f, -3.48634683e-02f, -7.47266635e-02f, -1.41393647e-01f, -5.43302223e-02f, 2.00569741e-02f, -7.56519958e-02f, -6.07602224e-02f, 3.63858193e-02f, -2.41818326e-03f,
  4.32686895e-01f, -2.22840160e-02f, 1.00963391e-01f, -2.74599176e-02f, -2.18463875e-02f, -4.39756401e-02f, 6.85725138e-02f, -4.48557213e-02f, -1.00165159e-01f, 6.22558258e-02f,
  -1.93513166e-02f, 7.18697682e-02f, 5.61658964e-02f, 3.14692222e-02f, -1.53407110e-02f, 8.40479806e-02f, 3.36319692e-02f, 4.13528122e-02f, 5.14331385e-02f, 1.63636275e-03f,
  -6.13030717e-02f, 9.55584273e-02f, 1.45162344e-01f, 5.72475009e-02f, -1.14922382e-01f, 8.08962900e-03f, 9.62718427e-02f, -9.78394449e-02f, -9.79591627e-03f, 2.22362741e-03f,
  2.59698033e-02f, 3.41483951e-02f, 7.67112449e-02f, -3.41394991e-02f, -8.78256261e-02f, -2.40590535e-02f, 8.24960247e-02f, -3.26093398e-02f, -1.01555422e-01f, -9.84988660e-02f,
  -6.23041810e-03f, -2.76022367e-02f, 5.43419831e-02f, 5.11507690e-02f, 1.98926940e-03f, 5.48026338e-02f, -7.39620402e-02f, -8.40329900e-02f, -1.98323168e-02f, 2.81842239e-02f,
  -4.28665169e-02f, -4.69138548e-02f, 2.00075861e-02f, 1.15439501e-02f, -1.79281365e-02f, 1.10974535e-03f, -2.33256388e-02f, -7.45915473e-02f, -8.81357044e-02f, -1.35482084e-02f,
  2.67477155e-01f, -1.47674263e-01f, 9.24464092e-02f, 3.06667201e-02f, 1.17748370e-02f, -1.22626156e-01f, -8.34501442e-03f, -3.45379785e-02f, 7.38113299e-02f, 5.95548861e-02f,
  6.89525306e-02f, 2.72863340e-02f, 2.89281365e-02f, -7.89048746e-02f, 5.62948771e-02f, -3.98861505e-02f, -7.49069601e-02f, 1.90515779e-02f, 6.53540390e-03f, 5.90621717e-02f,
  6.79512545e-02f, 4.33852226e-02f, 6.76222146e-02f, 1.73184425e-01f, 6.33563846e-02f, 1.52644208e-02f, 2.26301104e-01f, 1.53563350e-01f, 2.77597439e-02f, 8.15531984e-02f,
  4.46135461e-01f, -5.81208095e-02f, -1.01653356e-02f, -3.98212895e-02f, -1.31928891e-01f, -1.64791811e-02f, 4.66923509e-03f, -7.86682684e-03f, 9.05110911e-02f, 5.63081503e-02f,
  1.00979038e-01f, 1.41813159e-01f, 8.07785317e-02f, 1.65866874e-02f, 1.27138659e-01f, 4.46961075e-02f, 1.84457644e-03f, 1.19077675e-01f, 3.41574103e-02f, 1.03119910e-01f,
  2.54969969e-02f, -1.76314113e-03f, 1.24289535e-01f, 1.23779997e-01f, -1.47637904e-01f, 3.73832621e-02f, -4.60682586e-02f, -1.14241075e-02f, 2.40197871e-02f, -1.33016944e-01f,
  2.31312923e-02f, 8.32612738e-02f, -1.61387790e-02f, 1.65520385e-02f, -1.05007932e-01f, -6.04797341e-02f, -3.71037908e-02f, 4.64091599e-02f, 5.04104570e-02f, -6.30894601e-02f,
  -7.01984540e-02f, -1.82756726e-02f, 7.08557991e-03f, 4.08494510e-02f, -4.57328558e-02f, -4.18451540e-02f, 5.46982698e-02f, 6.12894930e-02f, -1.01705445e-02f, -6.82210773e-02f,
  -1.33240763e-02f, -5.72997928e-02f, -1.82577185e-02f, -3.42307463e-02f, -3.70244980e-02f, -3.57879959e-02f, 3.06151081e-02f, 3.06140841e-03f, 6.21068813e-02f, 3.81054580e-02f,
  -4.55012694e-02f, -8.38788599e-03f, 3.35293114e-02f, -2.77962033e-02f, 1.22562551e-03f, -2.67802123e-02f, 4.18408699e-02f, 4.88022529e-03f, 1.74215902e-02f, -9.38561335e-02f,
  -4.36803838e-03f, 9.61673930e-02f, -5.83635680e-02f, 8.97925347e-02f, -4.80579138e-02f, 7.59631172e-02f, 7.11481692e-03f, 5.30072022e-03f, 3.33547108e-02f, 1.05881793e-02f,
  -2.55769994e-02f, 4.27281074e-02f, 7.29170889e-02f, -2.53081452e-02f, -3.42680179e-02f, 6.93561211e-02f, 8.76600444e-02f, -2.13218853e-02f, 7.47054741e-02f, -5.42433234e-04f,
  -5.96542284e-02f, 4.11665477e-02f, 8.44055414e-02f, 2.58263797e-02f, -1.87860448e-02f, -4.19337153e-02f, -9.97384116e-02f, 2.83125490e-02f, -1.59431510e-02f, -7.60307834e-02f,
  -1.29448161e-01f, 1.03414267e-01f, -3.98774073e-02f, 3.26511031e-03f, -8.39976687e-03f, 3.09785381e-02f, -5.19868098e-02f, 3.90967987e-02f, -5.14008924e-02f, -1.68011501e-01f,
  -1.59993917e-02f, 2.49040611e-02f, 5.71619906e-02f, 7.75633752e-02f, -1.97055191e-02f, -1.35166841e-02f, -3.97132784e-02f, 9.81802214e-03f, -4.14165407e-02f, -6.99964091e-02f,
  -4.25023809e-02f, -3.01482193e-02f, -3.27002555e-02f, 1.85284674e-01f, 1.32696137e-01f, 1.31088778e-01f, 3.03994790e-02f, 1.85329184e-01f, 2.39792302e-01f, 1.60403058e-01f,
  1.14184976e-01f, 8.69783536e-02f, 1.01685315e-01f, 1.52749449e-01f, 1.20636217e-01f, 1.18262902e-01f, 2.03809768e-01f, 6.21547997e-02f, 9.83554944e-02f, 2.24058367e-02f,
  1.54291958e-01f, 1.41022429e-01f, -4.31418158e-02f, 1.10059641e-01f, 3.73138301e-02f, 1.42238855e-01f, 1.05979018e-01f, 9.45035145e-02f, 7.02959299e-02f, 9.25609171e-02f,
  -1.47547424e-01f, -1.67108878e-01f, 3.57781425e-02f, -1.90833248e-02f, -5.79305701e-02f, 5.29640866e-03f, 4.22824994e-02f, 2.04016324e-02f, 2.84160841e-02f, -2.07899548e-02f,
  -6.11241870e-02f, 2.40150304e-03f, 3.91912684e-02f, 1.54449251e-02f, -1.59170534e-02f, 7.24344328e-02f, -5.49275726e-02f, -4.39420007e-02f, 2.25720443e-02f, -1.71678811e-02f,
  5.46395741e-02f, 7.85855800e-02f, -6.58178329e-02f, -6.66047335e-02f, -3.58525328e-02f, 9.21906307e-02f, -7.47120231e-02f, -1.12775251e-01f, -1.31151788e-02f, -3.74878906e-02f,
  1.99231543e-02f, -4.12931759e-03f, 8.40991959e-02f, 7.90532678e-02f, -1.58114731e-02f, 8.37341920e-02f, -3.44246626e-02f, 7.10257366e-02f, 8.35209042e-02f, 1.93817094e-02f,
  -4.97982139e-03f, 4.03452106e-02f, 1.66631136e-02f, 7.84335379e-03f, 6.65477440e-02f, 5.55905290e-02f, -3.33948508e-02f, 3.83459181e-02f, -4.74979281e-02f, -7.35884085e-02f,
  3.62905525e-02f, 2.87832634e-04f, -1.00808829e-01f, -5.47162443e-02f, 7.61676952e-02f, -7.00032637e-02f, 8.48029479e-02f, -4.53185402e-02f, -3.29298079e-02f, -2.78770202e-03f,
  6.18060725e-03f, 6.71651959e-02f, 5.66636510e-02f, -6.21631257e-02f, 1.04664499e-02f, -7.81445280e-02f, -6.98017403e-02f, -9.55713354e-03f, -4.68517840e-02f, 3.86157297e-02f,
  -3.03376783e-02f, -9.32446048e-02f, -1.29741300e-02f, 2.39331461e-02f, -9.77927353e-03f, -5.78227639e-03f, 6.99180961e-02f, 2.45643817e-02f, 2.03740690e-03f, -7.65044987e-02f,
  -4.76867296e-02f, 1.41564365e-02f, -3.89655419e-02f, 1.76219828e-02f, 7.95721039e-02f, 3.56725119e-02f, -7.35497177e-02f, -4.15852778e-02f, 8.41027200e-02f, -4.70583178e-02f,
  -3.74734104e-01f, -2.16644138e-01f, 1.67598844e-01f, -1.10449128e-01f, -9.93288085e-02f, -1.18180968e-01f, -2.40704659e-02f, -1.70420215e-01f, -8.77900273e-02f, -1.23128146e-01f,
  -5.17845787e-02f, -7.01447129e-02f, -1.05756551e-01f, 7.84937590e-02f, 5.63955121e-03f, 1.33384928e-01f, 2.47072265e-01f, 1.14471041e-01f, 7.98010007e-02f, -8.04797858e-02f,
  -9.67427492e-02f, -1.23044759e-01f, -4.82413843e-02f, 6.22987486e-02f, -1.99669264e-02f, -1.68164615e-02f, 1.62168384e-01f, 8.91320556e-02f, 1.76614430e-02f, -7.17319781e-03f,
  -1.37275588e-02f, -4.41989787e-02f, 8.25717822e-02f, -2.87572946e-02f, -1.24534424e-02f, -7.10934475e-02f, -4.62710634e-02f, 4.31879908e-02f, -8.03536996e-02f, 2.98686195e-02f,
  3.05415299e-02f, -6.89313933e-02f, -1.87480338e-02f, -4.60032597e-02f, -9.05500427e-02f, -1.47358268e-01f, 2.08969768e-02f, 9.14812386e-02f, 7.29856715e-02f, 2.27107126e-02f,
  4.70684282e-02f, -1.58435762e-01f, -1.08806066e-01f, -2.35852273e-03f, -6.91959187e-02f, -5.70004806e-02f, -7.18397647e-02f, -4.65726815e-02f, 4.72991318e-02f, -1.21419586e-01f,
  7.02923983e-02f, 1.63693838e-02f, 6.70328364e-02f, -4.29781638e-02f, 7.44490623e-02f, 8.22112858e-02f, 2.95678712e-02f, -2.28248350e-02f, -4.19888161e-02f, -9.04262289e-02f,
  6.31404594e-02f, -3.36383879e-02f, 2.41943058e-02f, -2.72089317e-02f, 6.68162555e-02f, 5.05057536e-02f, -7.44693503e-02f, 8.05883408e-02f, 8.61954782e-03f, -6.93928404e-03f,
  -8.53588060e-02f, -3.50700854e-03f, 3.30502689e-02f, -3.07036266e-02f, 2.08694078e-02f, 1.41614480e-02f, 2.05664076e-02f, 2.97012459e-03f, -1.04829453e-01f, -1.83378514e-02f,
  -2.73071826e-01f, 3.51403385e-01f, -8.75510797e-02f, 2.04022937e-02f, 5.87677844e-02f, 7.14602694e-02f, -1.04299724e-01f, 9.01718736e-02f, -2.69576050e-02f, -1.21498898e-01f,
  -2.68891323e-02f, -1.34977639e-01f, -1.19655550e-01f, -2.41279490e-02f, -6.75326064e-02f, 1.63740739e-02f, -7.76940063e-02f, 2.86856126e-02f, -4.51989882e-02f, -1.01166867e-01f,
  1.43951671e-02f, -2.08095357e-01f, -1.71408266e-01f, -1.74424976e-01f, -1.10527717e-01f, -7.12076128e-02f, -1.29008785e-01f, -1.42089710e-01f, -1.53562874e-01f, -2.08225474e-01f,
  2.59855956e-01f, -1.64731275e-02f, -6.98053986e-02f, 1.27838671e-01f, 1.16241381e-01f, 5.62431552e-02f, 1.11855984e-01f, 5.97804338e-02f, 7.15626031e-02f, 6.82375729e-02f,
  -2.14730442e-01f, -2.63639987e-01f, -1.81941837e-01f, -9.06996354e-02f, -1.35254487e-01f, 8.73081908e-02f, 8.18585530e-02f, -1.79372076e-02f, -7.68752652e-04f, -6.49695694e-02f,
  -5.94398677e-02f, 7.34435990e-02f, 1.48505554e-01f, -4.92695495e-02f, 6.82564359e-03f, -2.53178813e-02f, -3.64751443e-02f, 5.04891239e-02f, -3.77632640e-02f, -3.19066979e-02f,
  -3.42595756e-01f, -1.52339712e-01f, -1.24661848e-02f, 6.50430331e-04f, 4.00693305e-02f, 2.78814267e-02f, 8.60023052e-02f, 5.03835715e-02f, 4.62401845e-02f, 1.25847936e-01f,
  -3.34707983e-02f, 3.04787159e-02f, -1.43697783e-01f, -2.52946112e-02f, 9.60930288e-02f, 3.71371508e-02f, 5.70153035e-02f, 4.25011627e-02f, 1.68392854e-03f, -5.94074726e-02f,
  4.04779537e-04f, -9.97657925e-02f, -5.96051663e-02f, -3.15315388e-02f, -8.64235312e-02f, -6.76390976e-02f, -7.30255842e-02f, -1.00415617e-01f, -5.77046238e-02f, 1.01019870e-02f,
  1.00306183e-01f, 3.31570860e-03f, -2.34020576e-02f, -4.58643660e-02f, 4.07469198e-02f, -6.19072430e-02f, -3.75082158e-02f, -8.32982138e-02f, -5.34974597e-02f, 8.30850154e-02f,
  -2.36891322e-02f, 1.16030080e-02f, -4.76284996e-02f, 7.23675732e-03f, 1.56191923e-03f, 2.71213111e-02f, 6.26539588e-02f, -4.42095101e-02f, -3.02930288e-02f, 7.56005719e-02f,
  -6.32150695e-02f, -3.77774201e-02f, -3.20522413e-02f, -1.19022138e-01f, -1.96652375e-02f, 5.83262332e-02f, -7.43230199e-03f, -1.14176422e-01f, -2.69810371e-02f, -1.91234294e-02f,
  2.45217606e-03f, -1.93152979e-01f, 1.02961056e-01f, -7.70928934e-02f, -2.13728403e-03f, 9.47617665e-02f, -9.26012546e-02f, -8.45030602e-03f, -2.19163578e-02f, 2.11088806e-02f,
  -1.39903232e-01f, -8.38761553e-02f, -1.26022354e-01f, 5.30233234e-03f, 5.67434430e-02f, -8.85512084e-02f, 1.11052856e-01f, 9.26644728e-02f, -3.52850184e-02f, -3.07186618e-02f,
  1.13549739e-01f, 1.07118934e-01f, 4.33860086e-02f, 1.44975603e-01f, 2.83760056e-02f, -5.63337803e-02f, -6.32009609e-03f, -4.23356444e-02f, 2.94101778e-02f, 3.67117107e-01f,
  1.83222100e-01f, -9.18875188e-02f, -4.37380910e-01f, 6.34728819e-02f, -1.00769654e-01f, -2.90370256e-01f, -2.05885530e-01f, 7.74080679e-02f, 1.51168913e-01f, -8.04695487e-02f,
  -2.02206671e-02f, 1.47491038e-01f, 2.53498182e-02f, 3.69579643e-02f, -1.24223508e-01f, -3.02723169e-01f, -3.62537026e-01f, -2.70320863e-01f, -1.18686318e-01f, -6.01034649e-02f,
  -2.76066363e-02f, 1.04990348e-01f, 1.71089284e-02f, 3.80846905e-03f, 1.30498081e-01f, 5.24642318e-02f, -1.20245636e-01f, -8.52441117e-02f, -1.17577098e-01f, -5.79780340e-02f,
  -6.49644015e-03f, -1.11086145e-01f, -6.20665215e-02f, -8.35814551e-02f, -4.70618121e-02f, -4.27285582e-02f, 1.06127132e-02f, -9.13299434e-03f, 1.04087867e-01f, 4.53341790e-02f,
  -2.58211009e-02f, -4.74135913e-02f, -5.07098623e-02f, -1.03423133e-01f, 2.55537145e-02f, -7.72167146e-02f, -1.05379649e-01f, -1.09549567e-01f, -6.04287372e-04f, -1.88490860e-02f,
  -1.28081031e-02f, -1.08366475e-01f, -2.14342196e-02f, 5.11221327e-02f, -1.08888835e-01f, -9.79334339e-02f, 3.92325073e-02f, -4.86385869e-03f, 2.47851629e-02f, 4.34234925e-02f,
  -2.31732894e-02f, 2.00062860e-02f, -3.55512742e-03f, 1.00449324e-01f, 6.96385354e-02f, 7.27196783e-02f, 1.76308723e-03f, 8.99252668e-02f, 2.37801820e-02f, 4.69342694e-02f,
  -3.46696191e-02f, -1.23171462e-02f, 9.96830538e-02f, -9.16937552e-03f, -3.25973704e-02f, -4.56300899e-02f, 2.35976353e-02f, -8.27511102e-02f, 8.13043416e-02f, -7.82327354e-03f,
  -1.58249475e-02f, -6.71350434e-02f, 3.93188819e-02f, 1.13025203e-01f, -1.37337357e-01f, -7.43344650e-02f, 3.22758872e-03f, 3.25003415e-02f, 3.23872231e-02f, -8.04240853e-02f,
  5.25124609e-01f, -2.45796457e-01f, 8.99129659e-02f, 5.71480542e-02f, -5.45904301e-02f, 8.30880851e-02f, 4.64741662e-02f, 1.19505282e-02f, -2.19512954e-02f, 8.63470417e-03f,
  -2.52060648e-02f, 7.53187612e-02f, -7.76387528e-02f, -2.80547347e-02f, -1.59941928e-03f, 3.89275365e-02f, -6.90870136e-02f, -3.63934576e-03f, -6.70044720e-02f, -2.57780012e-02f,
  1.55635811e-02f, 7.08250478e-02f, 8.70166346e-02f, 1.16446562e-01f, 7.23456265e-03f, -1.26259125e-04f, 7.61702508e-02f, 6.60515809e-03f, -6.47137836e-02f, 2.14281112e-01f,
  -1.69625193e-01f, 1.09378152e-01f, -1.27410162e-02f, 2.70430923e-01f, 3.68147224e-01f, 3.37019801e-01f, 3.75476122e-01f, 2.50977159e-01f, 1.57987118e-01f, 5.39260730e-02f,
  4.70065325e-02f, -3.92476395e-02f, 1.12578377e-01f, 1.36452094e-01f, 1.63338855e-01f, 3.02740335e-01f, 3.03138167e-01f, 7.44062243e-03f, -1.33578867e-01f, 8.02373663e-02f,
  9.99772027e-02f, 7.98134506e-02f, -2.07046881e-01f, 3.80910449e-02f, 1.45038053e-01f, 1.91410277e-02f, 3.82860638e-02f, 1.19842198e-02f, 1.16849961e-02f, 1.85897142e-01f,
  -1.30520687e-01f, 1.41079957e-02f, 1.80698782e-02f, -1.42716840e-01f, -1.23123683e-01f, -1.54470623e-01f, -1.28510922e-01f, -2.07473963e-01f, -6.78736642e-02f, 1.72691117e-03f,
  -2.01674234e-02f, -1.26743317e-01f, -7.25194113e-03f, -4.81822863e-02f, -2.00759377e-02f, -3.49404775e-02f, -3.92495394e-02f, -6.15591109e-02f, 1.09076373e-01f, -5.18439598e-02f,
  6.17746152e-02f, -1.23340348e-02f, 4.24551219e-02f, 3.53650376e-02f, 6.42086565e-02f, -1.23048268e-01f, -1.18767187e-01f, -4.71368060e-02f, -1.09405681e-01f, -8.18648338e-02f,
  -7.71939531e-02f, -2.63858195e-02f, 6.98704319e-03f, -1.03706896e-01f, -3.24004516e-02f, -7.79130608e-02f, 2.53592730e-02f, 8.11841935e-02f, -7.16329142e-02f, -1.61828175e-02f,
  -1.66196171e-02f, 1.12076566e-01f, -4.71928753e-02f, 7.35049844e-02f, -1.74180586e-02f, 3.73888537e-02f, -7.93991610e-02f, -8.43956694e-02f, -6.99161291e-02f, 3.32651027e-02f,
  -1.04382765e-02f, 3.86558957e-02f, -1.14252962e-01f, 9.67936367e-02f, -5.55754639e-03f, 4.68650199e-02f, -4.99334112e-02f, -3.33867930e-02f, -4.63490523e-02f, -1.67392232e-02f,
  -7.66529050e-03f, 3.93787958e-02f, -3.69671173e-03f, 5.71219139e-02f, 4.39705700e-02f, -4.67270501e-02f, 3.62158604e-02f, -2.52979668e-03f, -5.65575622e-02f, -4.63889986e-02f,
  -6.86030835e-02f, -5.52660972e-02f, -1.15532894e-02f, -3.66353057e-02f, -1.03604034e-01f, -5.03171347e-02f, 4.92358347e-03f, -2.29823999e-02f, 2.59346422e-02f, 3.30864303e-02f,
  -1.00469897e-02f, 1.22231962e-02f, -6.61590770e-02f, 2.43611950e-02f, 1.19736493e-01f, -1.11271963e-01f, -2.64227167e-02f, -1.66257881e-02f, 1.91585105e-02f, -1.39857039e-01f,
  5.29121697e-01f, -2.34553769e-01f, 1.69047713e-02f, 1.08015701e-01f, 4.25413856e-03f, 9.42771807e-02f, -7.40926340e-02f, 8.54427889e-02f, -3.78196798e-02f, -4.51827757e-02f,
  1.83476098e-02f, 1.31078362e-01f, 1.09143741e-01f, -4.13816841e-03f, 1.57788366e-01f, -1.05266698e-01f, -5.56876250e-02f, 4.09695655e-02f, 1.94779992e-01f, -2.96663716e-02f,
  -1.15308091e-01f, 4.18364480e-02f, 1.15159526e-01f, 3.21631953e-02f, -2.68052071e-01f, -7.78324530e-02f, -2.22016871e-01f, -1.42406568e-01f, -2.19384003e-02f, -2.98726231e-01f,
  -7.96896890e-02f, -1.20734877e-03f, 4.96184342e-02f, 3.92387435e-02f, -2.20904239e-02f, -4.95283715e-02f, 6.48567230e-02f, -6.89501539e-02f, -2.57665869e-02f, -1.39805600e-01f,
  -5.71298711e-02f, 8.64368863e-03f, 6.56034201e-02f, -1.23140961e-01f, 4.27115597e-02f, 7.44544938e-02f, -1.15119785e-01f, -5.84136546e-02f, -2.13560741e-02f, -1.51891932e-01f,
  -2.04492837e-01f, -1.12631805e-01f, 4.08329256e-02f, 5.61458282e-02f, -7.97544420e-02f, 1.40420571e-01f, -7.26838708e-02f, -5.33194281e-02f, -8.25808570e-03f, -1.26002859e-02f,
  -4.48617339e-03f, 4.25968915e-02f, 9.19136871e-03f, -1.39199328e-02f, 8.03729519e-02f, 7.00995848e-02f, -3.26002277e-02f, -2.76362207e-02f, 1.06452769e-02f, 6.49723485e-02f,
  -4.43016645e-03f, -1.85895171e-02f, -9.57548677e-04f, -3.52445319e-02f, 5.07287718e-02f, -2.39180028e-02f, 6.95973868e-03f, -7.42539912e-02f, 6.29407307e-03f, 5.46301678e-02f,
  8.15114602e-02f, 5.43549955e-02f, -9.90585685e-02f, -1.70512833e-02f, -4.34776172e-02f, -4.07423489e-02f, -5.49300462e-02f, -1.57266650e-02f, 5.42787760e-02f, -2.38634553e-02f,
  9.24926400e-02f, 1.68192521e-01f, 3.48830735e-03f, 5.41677661e-02f, 2.84095705e-02f, 7.11997459e-03f, 7.66445473e-02f, -2.70979609e-02f, -6.67449087e-02f, -5.87603115e-02f,
  -2.30540205e-02f, 3.16546075e-02f, -7.45994225e-02f, -1.86075475e-02f, 8.10508206e-02f, -1.13580776e-02f, -2.90093701e-02f, 9.33902115e-02f, -5.22209480e-02f, -6.17072061e-02f,
  1.58801842e-02f, 1.64936066e-01f, 2.75622308e-01f, 4.35079299e-02f, 1.05876572e-01f, 1.45228937e-01f, 6.10538125e-02f, 6.15965342e-03f, 1.35698035e-01f, 1.36792600e-01f,
  -8.43695551e-02f, 7.61291310e-02f, -1.84041843e-01f, 1.16364099e-01f, 2.47343227e-01f, 3.23064290e-02f, -6.91058254e-03f, -1.46245420e-01f, 7.26365624e-03f, 1.06894478e-01f,
  1.87289089e-01f, 1.82716385e-01f, 1.01817615e-01f, -6.87919930e-03f, -2.60882288e-01f, -6.25423267e-02f, 7.52087757e-02f, -7.22690746e-02f, -1.74629733e-01f, 5.35405613e-02f,
  2.55987227e-01f, 8.66852850e-02f, -1.13783166e-01f, -3.33462395e-02f, 1.99581057e-01f, 1.85048386e-01f, -7.64893964e-02f, 8.58960301e-02f, 6.46528453e-02f, 3.43542933e-01f,
  -2.45302506e-02f, -9.77406874e-02f, -1.19925894e-01f, 1.09983630e-01f, -3.78366560e-02f, -1.17656223e-01f, -1.50099602e-02f, -1.20594271e-01f, 7.43025262e-03f, 5.09000989e-03f,
  6.25823513e-02f, -7.73881450e-02f, 5.87725677e-02f, -2.84210630e-02f, 1.98702281e-03f, -7.29244128e-02f, -1.28071934e-01f, -1.47106260e-01f, -2.24757150e-01f, -5.35445027e-02f,
  2.25004375e-01f, 5.02370074e-02f, -1.78041965e-01f, -1.20760866e-01f, -1.39995754e-01f, 3.20988297e-02f, -1.23069875e-01f, 1.57848764e-02f, -2.61889040e-01f, -5.06407544e-02f,
  2.22985782e-02f, 1.81927215e-02f, 3.19712982e-02f, 4.23250441e-03f, 5.95408641e-02f, 2.33698580e-02f, 7.52287433e-02f, -2.89985016e-02f, 4.34451625e-02f, -3.80547196e-02f,
  -5.60240820e-02f, -2.54483949e-02f, -2.25306749e-02f, -2.66757775e-02f, -3.35317031e-02f, -3.15933600e-02f, -2.13123597e-02f, -8.13831389e-02f, -2.93056462e-02f, -3.36999707e-02f,
  -1.55127337e-02f, 4.11565090e-03f, 4.98455837e-02f, 1.01275533e-03f, -7.36784283e-03f, -7.51472786e-02f, -6.71709403e-02f, 9.97446291e-03f, 9.76525247e-03f, 1.78159382e-02f,
  -2.28994593e-01f, -7.90646151e-02f, -1.65685546e-02f, -6.56341016e-02f, -6.64284676e-02f, -9.38041732e-02f, 3.41100134e-02f, -8.53276700e-02f, -5.29923737e-02f, -4.29934338e-02f,
  6.23198077e-02f, -5.02809472e-02f, -8.40277374e-02f, -2.43810099e-02f, 3.88938934e-02f, 2.00518817e-02f, -1.30166365e-02f, -5.44588938e-02f, -2.32855212e-02f, -5.63957058e-02f,
  -8.34797546e-02f, -1.83769107e-01f, -2.20358074e-01f, -1.28890797e-01f, -6.04699440e-02f, -6.31757751e-02f, -2.39805609e-01f, -1.93538964e-01f, -2.45384544e-01f, -2.80923933e-01f,
  -1.84240952e-01f, 1.93359762e-01f, 4.76864606e-01f, -1.87479004e-01f, -9.05148163e-02f, -2.51560677e-02f, 6.71576709e-02f, -7.62394816e-02f, -4.90762144e-02f, -9.46502462e-02f,
  -5.91406375e-02f, -2.10991874e-01f, -9.69121382e-02f, 4.74316366e-02f, -1.40362652e-02f, 1.26875445e-01f, 1.20648488e-01f, 5.27294278e-02f, -1.22904517e-01f, -3.07849973e-01f,
  -2.71642476e-01f, -2.34215006e-01f, -1.13734491e-01f, -9.34445392e-03f, -1.96429081e-02f, -1.11804530e-01f, 1.66590154e-01f, -7.01373667e-02f, 2.78843269e-02f, 9.56665445e-03f,
  -8.46181531e-03f, 1.09679163e-01f, -3.49195190e-02f, -9.13331509e-02f, -6.79153726e-02f, -9.55574773e-03f, 5.26856482e-02f, 1.47706449e-01f, 7.41295964e-02f, 1.04169995e-01f,
  -1.16601661e-01f, 1.29726820e-03f, 3.23988162e-02f, -7.96354041e-02f, -1.89393421e-03f, 1.43398708e-02f, -1.13916481e-02f, -1.52112786e-02f, 3.88784781e-02f, -1.21100713e-02f,
  -1.00821264e-01f, -1.13352142e-01f, 4.19587791e-02f, 9.24587250e-02f, 1.11426733e-01f, -1.16819944e-02f, -4.63032909e-02f, 1.12539688e-02f, 3.05277314e-02f, -4.99008745e-02f,
  -6.06420077e-02f, 1.77288502e-02f, -2.38816831e-02f, 4.41745073e-02f, -8.04745480e-02f, 8.21308792e-02f, 2.81346422e-02f, -3.40661965e-03f, -9.21993107e-02f, -2.26254575e-02f,
  7.68904984e-02f, 1.26833186e-01f, 4.87725660e-02f, -3.34153958e-02f, 3.66256386e-02f, -5.70441782e-02f, -4.53853942e-02f, -8.48020911e-02f, 2.80317618e-03f, 5.96860088e-02f,
  -8.21553450e-03f, -3.85099160e-03f, 5.32182259e-03f, 1.07157733e-02f, 7.97022432e-02f, 2.00117715e-02f, -8.59678090e-02f, -6.81647733e-02f, 3.14505100e-02f, 3.07880100e-02f,
  -1.57910556e-01f, 1.33686185e-01f, -1.59075022e-01f, -1.58161804e-01f, 7.47023448e-02f, 5.20498641e-02f, -5.66354766e-02f, 6.03680983e-02f, -9.99189913e-02f, -6.33701906e-02f,
  4.67791818e-02f, -4.58085909e-02f, -2.09277030e-02f, -2.91722454e-02f, -8.34608525e-02f, -7.10890517e-02f, -2.37106644e-02f, -9.41260830e-02f, 5.34829451e-03f, -1.31590124e-02f,
  -1.01281516e-01f, -1.90180659e-01f, -2.77341336e-01f, -1.31635159e-01f, -1.21635586e-01f, -2.70099998e-01f, -1.39374658e-01f, -1.67722270e-01f, -1.70781955e-01f, -1.58448845e-01f,
  6.10387504e-01f, 3.69142950e-01f, 2.25435913e-01f, 1.47935227e-01f, -6.41317666e-02f, -1.60314068e-02f, 6.55017272e-02f, -1.20905740e-02f, -1.33527026e-01f, 1.87487081e-01f,
  1.84887320e-01f, -7.59739280e-02f, -1.17713965e-01f, -1.84660226e-01f, 4.86400984e-02f, 2.28672493e-02f, -1.87732264e-01f, -6.53862879e-02f, -1.28266960e-01f, -1.33327739e-02f,
  -2.45287493e-02f, 9.62675884e-02f, 1.55182809e-01f, -1.64798424e-02f, 9.15098414e-02f, -1.26782805e-01f, 7.47401193e-02f, 1.52395666e-01f, 9.99847725e-02f, 4.47997861e-02f,
  1.88847333e-01f, 4.97828811e-01f, -3.18427414e-01f, -8.36266428e-02f, -8.89356155e-03f, 1.95830688e-02f, 3.87436384e-03f, 5.58588728e-02f, 1.73291247e-02f, -1.84837338e-02f,
  5.29942848e-03f, -1.40925113e-04f, -1.72902029e-02f, 5.34129143e-02f, -4.59167138e-02f, 5.69201186e-02f, -3.22419629e-02f, -1.46148512e-02f, -9.24827680e-02f, 6.82932287e-02f,
  -5.06375395e-02f, 7.57221878e-02f, -1.78037975e-02f, -7.01053888e-02f, -5.70718199e-02f, -8.68697837e-02f, 3.45800668e-02f, 9.91326720e-02f, 2.87395902e-02f, 1.95322298e-02f,
  -5.37187494e-02f, 2.60822903e-02f, -3.68992761e-02f, -4.33883183e-02f, 2.68707070e-02f, -1.93105042e-02f, -9.56900939e-02f, 1.55971209e-02f, 4.70646657e-04f, -3.50788087e-02f,
  -9.34568793e-02f, 1.07064014e-02f, -6.31097180e-04f, 7.16901617e-03f, -9.69323423e-03f, -9.49958153e-03f, -3.06002349e-02f, -6.11001775e-02f, 3.39308120e-02f, 2.12534275e-02f,
  -2.38466728e-03f, -3.38011235e-02f, 1.13938870e-02f, -8.74249339e-02f, -4.20879610e-02f, -4.80528921e-02f, 4.14580740e-02f, 4.29191813e-02f, -3.97186838e-02f, -3.77651420e-03f,
  -1.75220534e-01f, -5.89488149e-02f, -9.84963775e-02f, -4.03578915e-02f, 6.64152205e-02f, 5.89218130e-03f, 4.20751162e-02f, -7.58447126e-02f, 7.85579681e-02f, 1.29112735e-01f,
  2.86492985e-02f, -3.09319738e-02f, 4.96621951e-02f, -3.94848967e-03f, -3.24878283e-02f, -1.85485873e-02f, -1.00582987e-02f, -5.26110902e-02f, -1.78337663e-01f, 7.57133588e-02f,
  -1.18782870e-01f, -1.10888630e-01f, -4.65420559e-02f, -1.04646854e-01f, -1.09113574e-01f, -7.87790120e-02f, -1.39364630e-01f, -7.59769753e-02f, -1.21401183e-01f, -1.62321150e-01f,
  2.17278123e-01f, -2.74481446e-01f, -6.70281947e-01f, 3.29940878e-02f, -2.24561498e-01f, -2.51161307e-01f, -2.77541727e-01f, 1.60605520e-01f, 6.81014434e-02f, -1.80336803e-01f,
  -1.19858071e-01f, 6.30168756e-03f, 2.09001191e-02f, -8.97289291e-02f, -5.48495119e-03f, -3.26063424e-01f, -3.49697322e-01f, -1.95574448e-01f, -5.10500669e-02f, 5.53293675e-02f,
  -6.53385743e-03f, -1.25311047e-01f, -3.81935597e-03f, -4.40040007e-02f, -1.84905589e-01f, -1.28251418e-01f, -3.05349827e-01f, -2.48946786e-01f, -1.96843311e-01f, -4.12812769e-01f,
  -5.92582583e-01f, -2.51468550e-02f, 1.09848462e-01f, 1.25353768e-01f, -5.96074872e-02f, 1.40750155e-01f, 3.04239662e-03f, 9.48551819e-02f, 7.40983635e-02f, -7.09857652e-03f,
  2.80501116e-02f, 5.14497422e-02f, 7.07560480e-02f, 8.49886388e-02f, -2.28584334e-02f, 6.18034638e-02f, 8.09608623e-02f, -4.82357219e-02f, -3.25272083e-02f, -1.44029967e-02f,
  2.75028199e-02f, -2.05616816e-03f, -1.00184202e-01f, 7.54140466e-02f, 1.56347007e-02f, 4.84525599e-02f, -1.21609911e-01f, -4.73558381e-02f, -5.36128180e-03f, -1.34186924e-01f,
  3.18264030e-03f, -5.17180301e-02f, -2.68668868e-03f, 9.64985602e-03f, 4.45634015e-02f, -1.78459249e-02f, 2.09365655e-02f, -1.06416168e-02f, -1.60211939e-02f, -5.02545126e-02f,
  4.04866152e-02f, -6.58626258e-02f, -1.16306087e-02f, -6.37768358e-02f, 2.62255855e-02f, -5.23221903e-02f, 2.24444568e-02f, -6.34581819e-02f, 3.46277840e-02f, 1.49107045e-02f,
  4.19003814e-02f, -4.82413098e-02f, -3.97611521e-02f, -2.21646316e-02f, -7.31218830e-02f, -7.81853274e-02f, 6.05301410e-02f, 7.62018608e-03f, 5.63316159e-02f, 1.03443950e-01f,
  2.08431706e-02f, 4.40159580e-03f, -6.57343715e-02f, 1.12268999e-01f, 5.10849468e-02f, -7.42452890e-02f, -8.34841505e-02f, 6.56186193e-02f, 4.75788116e-02f, 3.27786803e-02f,
  4.97743934e-02f, -6.08722214e-03f, -1.23954348e-01f, -8.00727904e-02f, 1.68893877e-02f, 1.00632645e-01f, 6.98896572e-02f, -2.01635323e-02f, 1.06969528e-01f, -1.21908961e-02f,
  -1.97263844e-02f, 1.80492029e-02f, 1.10978857e-01f, -5.11160120e-02f, 1.83427949e-02f, -5.12361974e-02f, -1.28344744e-01f, -1.02855712e-02f, -2.19115876e-02f, 6.09620921e-02f,
  4.82240885e-01f, -2.65701078e-02f, 2.78067440e-01f, 2.55007446e-01f, 1.83083132e-01f, 2.78837055e-01f, 2.03695297e-01f, 6.84231967e-02f, -5.33918552e-02f, 1.26864174e-02f,
  -9.24485847e-02f, -2.70171762e-01f, -2.53141433e-01f, -1.12183496e-01f, -9.80704650e-02f, 1.29608870e-01f, 1.76968992e-01f, 1.92421600e-01f, 1.23807989e-01f, 1.48962244e-01f,
  2.80277003e-02f, 2.06713498e-01f, 2.07136422e-01f, -5.21938037e-03f, 4.24066745e-02f, -1.27369210e-01f, 1.13610208e-01f, 1.12438940e-01f, 1.94901042e-02f, -1.34226717e-02f,
  -6.98773861e-02f, 1.40974000e-01f, -6.63010105e-02f, -7.77097344e-02f, -1.04895167e-01f, 5.52483797e-02f, 8.89732689e-02f, -1.12404764e-01f, -1.08284533e-01f, -3.06754801e-02f,
  -1.09645836e-01f, -1.15730509e-01f, -9.06708762e-02f, -1.16095655e-01f, 1.05579481e-01f, -3.38939428e-02f, 3.72663215e-02f, 3.43753286e-02f, 6.42250702e-02f, -1.17198192e-01f,
  -1.15601070e-01f, 5.34027889e-02f, 1.45410344e-01f, -2.33036485e-02f, -6.74119964e-02f, -8.48216414e-02f, -1.61893722e-02f, -1.76976472e-02f, -1.54395513e-02f, 9.09320787e-02f,
  1.05343563e-02f, -6.01531193e-02f, 2.76931524e-02f, 4.59501110e-02f, 7.22483099e-02f, -9.42180380e-02f, -5.25685251e-02f, -5.84202930e-02f, 8.66891146e-02f, 1.03376560e-01f,
  -9.51440036e-02f, -5.12639917e-02f, -9.13424476e-04f, 7.07862293e-03f, -4.84067351e-02f, -6.84993491e-02f, 2.50915512e-02f, -2.35919096e-02f, 1.71800964e-02f, -1.05506778e-01f,
  3.41253192e-03f, 3.34825180e-02f, 6.26035361e-03f, -2.49654483e-02f, -7.10538700e-02f, -2.22637840e-02f, 4.85245604e-03f, -2.29778755e-02f, -2.50681303e-02f, 9.17365924e-02f,
  -1.35697126e-01f, 3.48369293e-02f, -8.50372314e-02f, -1.39382863e-02f, 8.87532309e-02f, -1.16070002e-01f, -9.65297781e-03f, -7.76580274e-02f, -7.90431648e-02f, 2.54552681e-02f,
  5.70707396e-02f, -3.25985774e-02f, -2.71021053e-02f, -6.28403528e-03f, 8.24406967e-02f, 1.04922257e-01f, -8.61824602e-02f, 9.36443731e-03f, -6.16820678e-02f, 6.04606830e-02f,
  -8.29452723e-02f, 3.40295210e-02f, 1.08993143e-01f, 5.11117540e-02f, -2.14427486e-02f, 8.63187909e-02f, 1.93355363e-02f, 8.21190253e-02f, 5.05855791e-02f, -7.96721969e-03f,
  -3.50126773e-01f, -2.49793828e-02f, -1.03156172e-01f, -1.60103306e-01f, -1.18703887e-01f, -9.58292335e-02f, -5.75114861e-02f, -1.29252777e-01f, -7.51572996e-02f, -3.64281535e-02f,
  -1.13400994e-02f, -1.10097796e-01f, -1.07910484e-02f, -4.05486450e-02f, -2.79376507e-01f, -1.49308383e-01f, -1.83899790e-01f, -3.33076209e-01f, -2.79892981e-01f, -1.09694868e-01f,
  -3.18677351e-02f, -1.86164588e-01f, -2.77404189e-01f, -7.75039420e-02f, 8.99961814e-02f, -7.49287978e-02f, 8.35925713e-02f, -1.59122180e-02f, 4.84632403e-02f, 1.35960057e-02f,
  2.56950706e-01f, 4.96845432e-02f, -7.60794356e-02f, -3.60462032e-02f, 4.09760512e-02f, 7.91746378e-02f, 3.92639861e-02f, 1.59364089e-03f, -7.98133165e-02f, 4.56508398e-02f,
  2.11442877e-02f, 1.44806821e-02f, -1.08695142e-01f, 9.13102031e-02f, 2.82785539e-02f, 9.27905925e-03f, -5.01253940e-02f, -1.14451237e-01f, -7.76442811e-02f, 5.99181131e-02f,
  1.00554690e-01f, 5.16861230e-02f, -5.06636314e-02f, 2.34989263e-02f, 1.18392900e-01f, 6.70144856e-02f, 1.02717549e-01f, 8.51197019e-02f, 4.67479974e-02f, 6.23569228e-02f,
  6.31003007e-02f, 7.21061230e-02f, -7.67672295e-03f, -2.11648736e-02f, -3.21887769e-02f, 2.81326827e-02f, -4.08571884e-02f, -8.65954012e-02f, -3.38672139e-02f, -9.60093588e-02f,
  7.22010210e-02f, -1.57339256e-02f, -1.13934483e-02f, -7.04065040e-02f, 8.52372311e-03f, -3.03199850e-02f, -6.34104386e-03f, 1.31995175e-02f, 7.40730204e-03f, -7.19033107e-02f,
  -5.24459854e-02f, 1.03631385e-01f, -6.03813864e-02f, -2.99869180e-02f, 4.22924049e-02f, 2.66107125e-03f, -2.09836438e-02f, 3.28815430e-02f, 6.50584185e-03f, 2.19710227e-02f,
  2.39759702e-02f, -1.13889568e-01f, -3.35879214e-02f, -3.32055464e-02f, -1.26800248e-02f, 3.14875096e-02f, 3.11518889e-02f, -4.76322807e-02f, 1.84530579e-02f, 3.83019187e-02f,
  6.87413067e-02f, 8.33738223e-02f, -8.82890746e-02f, 1.69862397e-02f, -1.19356290e-01f, -8.87087733e-02f, -8.61097574e-02f, -9.53215510e-02f, -1.40429949e-02f, 1.53666496e-01f,
  2.25186255e-02f, -1.00490548e-01f, -8.55035931e-02f, -5.03749661e-02f, 3.41103822e-02f, -7.40953982e-02f, 2.86026988e-02f, 1.41417444e-01f, 3.29391435e-02f, 2.74016988e-04f,
  2.46571630e-01f, 4.85081047e-01f, 2.48454928e-01f, -6.70972839e-02f, -2.11131915e-01f, 1.00904301e-01f, 3.15147698e-01f, 2.17982441e-01f, -8.44383761e-02f, 8.08764026e-02f,
  -1.24241546e-01f, -2.29098842e-01f, -9.22516137e-02f, -1.33677036e-01f, 1.50471792e-01f, 2.49410883e-01f, 8.75363573e-02f, -4.23608348e-02f, -1.29264668e-02f, 2.53641773e-02f,
  -8.22293982e-02f, 3.89398145e-03f, 7.32666329e-02f, 3.08700986e-02f, -3.64891589e-02f, -1.69267341e-01f, 3.92418727e-02f, 1.41558900e-01f, 1.38137132e-01f, 1.23929620e-01f,
  -5.47558703e-02f, 2.86163718e-01f, -1.91965863e-01f, -1.33719787e-01f, 2.35972572e-02f, -6.72008619e-02f, -4.08111960e-02f, 1.15235178e-02f, -8.41607600e-02f, 5.05330749e-02f,
  5.69556793e-03f, -4.84157056e-02f, 3.75702716e-02f, 5.40392958e-02f, 6.69728070e-02f, -2.70568449e-02f, 1.09964229e-01f, 2.03063667e-01f, 6.05267175e-02f, 3.83004807e-02f,
  -1.04130723e-03f, -6.66713566e-02f, 7.85901099e-02f, 4.79539409e-02f, 1.15182243e-01f, -5.63584566e-02f, 1.40183613e-01f, 1.62668243e-01f, 6.76380917e-02f, 1.80835992e-01f,
  -1.71294846e-02f, 4.41352241e-02f, 4.10729460e-02f, 1.83070991e-02f, 1.50164403e-02f, -5.65286838e-02f, 5.76831289e-02f, -8.90305042e-02f, 5.99840060e-02f, -3.80120473e-03f,
  6.99586282e-03f, 4.82519669e-03f, -3.45068611e-02f, 1.00605346e-01f, -9.64488834e-02f, 5.68769574e-02f, 7.94646367e-02f, 1.20099559e-02f, -1.35765737e-02f, -4.17342968e-02f,
  1.68465171e-02f, 1.08569957e-01f, -1.48916338e-02f, 3.67974602e-02f, -3.94897722e-03f, 2.24018749e-02f, -1.04934216e-01f, 2.15212512e-03f, 2.49989200e-02f, -5.20394258e-02f,
  -2.94191658e-01f, -2.66784787e-01f, -6.06890209e-02f, 2.85697971e-02f, 8.29613768e-03f, -3.29370014e-02f, -1.22321937e-02f, -9.24491659e-02f, -5.95466513e-03f, -2.15247218e-02f,
  3.43738683e-02f, -9.37774498e-03f, 6.52057901e-02f, -5.47755659e-02f, -7.09397048e-02f, -7.95106441e-02f, -6.02254495e-02f, -5.96073084e-02f, -6.29604459e-02f, -2.94549041e-03f,
  -9.10768360e-02f, -1.06849059e-01f, -2.56539702e-01f, -3.15823071e-02f, -2.80162506e-02f, -2.31406331e-01f, -1.47451371e-01f, -1.65043786e-01f, -7.10651129e-02f, -4.67105396e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.21282884e-01f, 1.83203146e-01f, -4.37766110e-04f, 7.79655352e-02f, 3.79818171e-01f, 1.26446709e-01f, 4.24043745e-01f, 3.66296649e-01f, 2.37515166e-01f, 3.01674515e-01f,
  1.16252773e-01f, 5.88742970e-03f, 1.20817035e-01f, 9.76844132e-02f, 1.87211096e-01f, 3.19065005e-01f, 3.93737882e-01f, 2.16284946e-01f, 3.53982925e-01f, 2.09493399e-01f,
  3.41817319e-01f, 3.50331903e-01f, 2.27532730e-01f, 3.96895051e-01f, 2.72852451e-01f, 2.02954724e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.28124434e-01f, -5.35586774e-02f, 2.51895219e-01f, -4.59421933e-01f, -9.91331488e-02f, 4.77228910e-02f, -9.82833281e-02f, -1.56601712e-01f, -1.44624665e-01f, -5.91525435e-02f,
  -6.00205734e-02f, 3.82504195e-01f, -1.08446375e-01f, 7.97021296e-03f, -5.31342030e-02f, -3.85961309e-02f, -6.80673197e-02f, 1.41135454e-01f, -4.02015671e-02f, 2.29807198e-01f,
  8.10760409e-02f, 1.51466206e-01f, -2.59710521e-01f, 2.60987431e-01f, -1.40755430e-01f, 2.32101679e-01f, -1.12750724e-01f, 2.76452929e-01f, -2.78759867e-01f, 3.42391521e-01f,
  -3.93099450e-02f, 5.29508442e-02f, -4.44848388e-01f, 9.86592844e-02f, -1.05843343e-01f, -1.93571404e-01f, -3.56551260e-01f, -1.17220357e-01f, -2.86131322e-01f, -1.68760985e-01f,
  3.83896120e-02f, -1.86167598e-01f, -1.76872805e-01f, -4.41579074e-01f, -1.17292106e-01f, 1.31468862e-01f, -6.31308928e-02f, 2.64733788e-02f, 3.62807810e-01f, -1.33970678e-01f,
  -7.12550133e-02f, 8.76178369e-02f, -5.21836914e-02f, -1.66990936e-01f, 2.47532815e-01f, 2.33931467e-01f, -8.20062384e-02f, 3.92147422e-01f, -1.18277438e-01f, 1.01595692e-01f,
  3.18607748e-01f, -3.91865879e-01f, 2.19735559e-02f, -2.33596280e-01f, -3.36289763e-01f, 1.88838497e-01f, -2.68826246e-01f, -2.36546814e-01f, -7.72097409e-02f, 7.44450837e-02f,
  -1.43775225e-01f, 1.71250105e-01f, 1.12013131e-01f, -5.83900791e-03f, -2.22864836e-01f, -2.92045355e-01f, -2.26770669e-01f, 3.41229498e-01f, -3.73325467e-01f, -1.30735502e-01f,
  1.37488529e-01f, -4.08503354e-01f, -1.32684544e-01f, 2.42472827e-01f, -6.31636754e-03f, 2.57894516e-01f, 1.92451283e-01f, 3.29939649e-02f, -9.77161899e-02f, 1.48386449e-01f,
  -2.84245044e-01f, -2.30435953e-01f, 1.75653145e-01f, 1.24942116e-01f, -2.30130814e-02f, -2.01666281e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -3.80484425e-02f, 1.04219206e-01f, -1.51480570e-01f, -2.79255752e-02f, -1.22000210e-01f, 7.07942434e-03f, 4.40301187e-02f, 1.54130936e-01f, -8.15359317e-03f, 4.77655046e-03f,
  2.02812944e-02f, 7.70245120e-02f, 7.07560033e-02f, 1.49723617e-02f, -2.81943101e-02f, -1.67263538e-01f, -8.72249156e-03f, -2.46068258e-02f, -1.62372254e-02f, -2.93067526e-02f,
  -7.00420886e-02f, 7.49683455e-02f, -1.16076365e-01f, -5.54192364e-02f, 1.24828339e-01f, 1.04865111e-01f, -1.21486440e-01f, -1.23941377e-01f, -6.45401999e-02f, 8.32708180e-03f,
  -1.39232785e-01f, -1.29219115e-01f, -1.18313730e-01f, -2.93355048e-01f, 2.96708494e-02f, -2.19471846e-02f, -2.78416663e-01f, 2.23137930e-01f, -4.79346812e-02f, 5.83688021e-01f,
  -3.59780304e-02f, 4.59753662e-01f, 5.14772758e-02f, 1.73344880e-01f, 1.98699877e-01f, -2.81659484e-01f, 2.64436036e-01f, -4.13665742e-01f, -1.73680022e-01f, -1.41272753e-01f,
  1.53207779e-01f, -4.46338654e-02f, 2.49505922e-01f, -1.01229481e-01f, -8.70219022e-02f, 4.62665439e-01f, 2.19672397e-01f, 1.69436112e-01f, 2.34062478e-01f, 2.06076596e-02f,
  4.38146055e-01f, 1.69685811e-01f, 2.32835129e-01f, 4.01492804e-01f, 5.83153293e-02f, 4.13695306e-01f, 3.97675812e-01f, -4.34016913e-01f, 1.05991922e-01f, -1.17601238e-01f,
  1.77035898e-01f, 1.66920096e-01f, 2.93209907e-02f, 1.82742961e-02f, 3.19877535e-01f, -3.59687567e-01f, 1.97625741e-01f, 1.23361431e-01f, -3.15861583e-01f, 3.00412662e-02f,
  9.05482545e-02f, 1.78733602e-01f, -2.74221748e-01f, -2.86914427e-02f, 1.08987749e-01f, 1.61902875e-01f, 5.13818190e-02f, 3.64536434e-01f, 1.52321965e-01f, 4.49258327e-01f,
  7.87816420e-02f, -2.04607695e-01f, -2.07461119e-01f, 3.17324460e-01f, -1.42459944e-01f, 4.96702939e-02f, 1.12929069e-01f, 1.60743877e-01f, -2.46450510e-02f, 1.39595836e-01f,
  2.88121644e-02f, -1.18158750e-01f, 2.22304761e-01f, 1.70938581e-01f, -1.76529244e-01f, 2.02999085e-01f, 4.25363220e-02f, 8.26742724e-02f, 2.19632193e-01f, -3.35582867e-02f,
  1.72182053e-01f, -1.02747418e-01f, 7.96689764e-02f, 1.17075734e-01f, 1.35972813e-01f, -1.83046058e-01f, 5.95014961e-03f, 1.27080292e-01f, -1.13292590e-01f, -3.59346196e-02f,
  -1.40843296e-03f, -8.29434171e-02f, 1.63019016e-01f, 3.00387088e-02f, -1.68570235e-01f, 7.29335472e-02f, -1.16067238e-01f, -1.12738758e-01f, 1.51032344e-01f, 4.96170938e-01f,
  3.67588788e-01f, 4.61908460e-01f, 1.55497044e-02f, -1.93856075e-01f, 4.31364775e-01f, -3.80069643e-01f, 3.53666805e-02f, 6.78905323e-02f, 2.87628233e-01f, -1.82462096e-01f,
  -9.89079624e-02f, 2.56407261e-01f, -2.16187745e-01f, 2.52104849e-01f, -1.62625164e-01f, 9.69972759e-02f, -1.55982897e-01f, 1.33827507e-01f, -2.40660429e-01f, -1.40685797e-01f,
  5.92789888e-01f, -1.00992195e-01f, 2.62464225e-01f, -1.01546787e-01f, -9.16508660e-02f, -1.28426820e-01f, -2.93838903e-02f, -9.92255984e-04f, 1.50100380e-01f, -1.87871262e-01f,
  3.08533698e-01f, 1.63596515e-02f, 2.82226205e-01f, -2.16234133e-01f, 9.73730013e-02f, -5.00998013e-02f, 2.74746388e-01f, 1.49873629e-01f, 7.59534687e-02f, -1.59951612e-01f,
  3.59134704e-01f, 2.34595060e-01f, 2.47216642e-01f, -1.94805115e-01f, 6.19921573e-02f, 2.08611608e-01f, 2.52538264e-01f, -2.93742716e-01f, 4.88343239e-02f, 6.02848977e-02f,
  2.69520760e-01f, -3.11138737e-03f, -3.07090968e-01f, -2.50440300e-01f, 2.30758429e-01f, 7.05894232e-02f, 8.43496621e-02f, 1.52197376e-01f, -1.54180571e-01f, 3.63579243e-01f,
  1.38513865e-02f, -2.62400687e-01f, 2.05073040e-02f, 1.09328046e-01f, 2.86054820e-01f, -5.88571317e-02f, 1.91933915e-01f, 2.14383509e-02f, 1.28113165e-01f, -1.76853493e-01f,
  -8.09746087e-02f, 1.39489606e-01f, 9.87147167e-02f, 1.83251649e-01f, -8.00828338e-02f, 2.98506141e-01f, 1.63714271e-02f, -1.90946683e-01f, -2.18735665e-01f, -8.19724947e-02f,
  -1.83139499e-02f, 9.88370478e-02f, -5.75870164e-02f, 3.00645918e-01f, 1.38380483e-01f, -5.40589355e-02f, -6.23076968e-02f, -1.42386585e-01f, 1.51205733e-01f, 9.71944034e-02f,
  -7.77715743e-02f, 2.39773527e-01f, -1.35914654e-01f, -1.81997959e-02f, 2.94337571e-01f, 9.76441428e-02f, 2.77551502e-01f, 8.44672024e-02f, -3.98353338e-01f, -8.14100578e-02f,
  3.72994132e-02f, -3.10812026e-01f, 9.30633843e-02f, 2.83002377e-01f, 1.81021079e-01f, 1.59687370e-01f, 1.58752069e-01f, -2.90032923e-01f, -2.35773593e-01f, -5.98399639e-02f,
  -9.46141630e-02f, 1.20595984e-01f, -1.53101832e-01f, -2.84440011e-01f, 2.92822123e-02f, 8.93033668e-02f, 1.06953941e-01f, -6.54845238e-02f, -3.09597254e-01f, -3.65345180e-02f,
  3.95402938e-01f, 4.67080563e-01f, -2.03750074e-01f, 1.07353866e-01f, 5.11798143e-01f, 2.45217040e-01f, -1.47140831e-01f, -7.74783120e-02f, -6.22041076e-02f, -1.69863906e-02f,
  -2.61607260e-04f, 5.64150549e-02f, 1.51111543e-01f, -8.58205855e-02f, -1.23623788e-01f, -4.31862958e-02f, 3.77109088e-02f, -1.19892530e-01f, 1.42510727e-01f, 7.05896541e-02f,
  -1.72037750e-01f, 1.29190460e-01f, -4.19264175e-02f, -1.84391767e-01f, 1.17050931e-01f, 1.30504057e-01f, 2.33629003e-01f, -1.44777864e-01f, -1.02545924e-01f, -6.12741970e-02f,
  -4.46093380e-02f, 7.51132742e-02f, 2.13366523e-01f, -1.39526084e-01f, 9.98689979e-02f, 4.45973910e-02f, 7.33648017e-02f, -7.81580731e-02f, 5.60422204e-02f, -1.57301035e-02f,
  1.20770499e-01f, 1.93184704e-01f, 2.00675465e-02f, -5.09531819e-04f, -6.15140945e-02f, 3.41127306e-01f, -1.53917879e-01f, 2.68718868e-01f, -3.97970863e-02f, -9.91243571e-02f,
  -1.55408591e-01f, -4.15294021e-02f, -2.97698956e-02f, -1.28059182e-02f, -9.54656675e-02f, 1.66973159e-01f, 4.43468168e-02f, -1.02138475e-01f, -5.14164232e-02f, -6.46746680e-02f,
  4.35065955e-01f, 2.94092804e-01f, -4.82577048e-02f, 1.73655991e-02f, 6.33424520e-02f, -2.08385289e-01f, 3.95645946e-01f, 1.13188149e-02f, 2.17217088e-01f, -1.32953256e-01f,
  -1.34818166e-01f, -1.37264445e-01f, -3.59574482e-02f, -3.39996032e-02f, 2.32421786e-01f, 1.45835012e-01f, 1.02436259e-01f, 1.58009473e-02f, 2.07181205e-03f, -2.13031903e-01f,
  3.20361465e-01f, 7.42173716e-02f, 1.27426341e-01f, -1.14759803e-01f, 2.32706562e-01f, -1.33725837e-01f, -1.08171850e-01f, -2.69520491e-01f, 1.10609913e-02f, 3.23990405e-01f,
  -4.42287177e-02f, -4.63420153e-02f, 8.35893750e-02f, 5.02015054e-01f, 3.50225329e-01f, 3.54327321e-01f, -1.16073154e-01f, -1.66939124e-01f, 1.58386618e-01f, 2.28397682e-01f,
  -1.66637316e-01f, -8.22714716e-02f, -8.00087452e-02f, 1.34568751e-01f, 2.69776940e-01f, 1.52242899e-01f, -1.09444767e-01f, -1.83166325e-01f, 5.27853221e-02f, -2.48166606e-01f,
  -4.15101238e-02f, -1.76098138e-01f, 1.51430503e-01f, -1.08662546e-01f, 5.88834919e-02f, 2.38038749e-02f, -1.80251122e-01f, 2.29754567e-01f, 2.26416960e-01f, 2.94283986e-01f,
  -2.19801351e-01f, 3.94072860e-01f, 2.33127534e-01f, 1.47833899e-01f, 1.51266858e-01f, 3.93076330e-01f, -1.70193270e-01f, 4.59109768e-02f, 3.53287160e-01f, -3.11196834e-01f,
  -1.37579486e-01f, -1.25812575e-01f, 3.17933559e-01f, -8.19640309e-02f, -4.85007055e-02f, 1.70655742e-01f, 2.11669892e-01f, 1.62906110e-01f, -2.06953600e-01f, 4.40912813e-01f,
  -2.24921063e-01f, -1.63605601e-01f, 2.19344050e-02f, -1.54958725e-01f, -1.05416581e-01f, 3.21511120e-01f, 3.57348919e-01f, 2.18228161e-01f, 1.75417617e-01f, -5.61299771e-02f,
  -3.04506309e-02f, -3.10034994e-02f, 1.94993690e-01f, 1.11378506e-01f, -8.64163637e-02f, 3.34375130e-04f, -1.40457943e-01f, 1.56036913e-01f, 1.55630454e-01f, -5.68694100e-02f,
  3.39584440e-01f, 6.60015643e-01f, 2.03973144e-01f, 3.05730850e-01f, -1.94454253e-01f, 7.84332037e-01f, 7.40420938e-01f, 4.64274079e-01f, 5.44053435e-01f, 3.46239597e-01f,
  3.77731472e-01f, 6.69080839e-02f, 9.34459195e-02f, -1.16986468e-01f, -2.58398026e-01f, 1.82164982e-01f, -2.06789955e-01f, 5.12578547e-01f, 2.39858329e-02f, 1.49948746e-01f,
  -4.07000363e-01f, 4.17633802e-01f, 1.53808579e-01f, -2.40139559e-01f, -5.02487319e-03f, -4.68343943e-02f, 3.80039454e-01f, 2.81035483e-01f, 4.81121875e-02f, -2.89486796e-01f,
  -2.55813301e-01f, 1.20266311e-01f, 2.84800917e-01f, -3.12293749e-02f, -5.56569546e-02f, 8.26882422e-02f, -4.86922301e-02f, -1.10335715e-01f, -2.33896058e-02f, 1.88918002e-02f,
  -9.03969929e-02f, 1.92787752e-01f, 3.23256046e-01f, 1.06937416e-01f, 4.08103429e-02f, 2.59349287e-01f, -1.87733918e-01f, -1.11067660e-01f, -4.27239388e-02f, 1.07288495e-01f,
  8.25423747e-02f, -1.23295166e-01f, 2.42215171e-01f, -9.93997157e-02f, 1.64883256e-01f, -1.88038945e-01f, 1.27207339e-01f, 1.89369261e-01f, 7.02078119e-02f, -2.65575293e-02f,
  2.71461040e-01f, 2.73532420e-01f, 9.05151069e-02f, 2.74948776e-01f, -8.98324251e-02f, -2.09786713e-01f, 1.49904907e-01f, 6.74831355e-03f, -7.62972534e-02f, 1.96997151e-01f,
  3.33758891e-01f, 3.49129558e-01f, 2.62311548e-01f, -1.09197954e-02f, 1.98719636e-01f, -3.95080000e-01f, 1.19189918e-01f, -2.87600964e-01f, -1.26756161e-01f, 7.90335685e-02f,
  -1.05344243e-01f, 6.23257101e-01f, -3.08165878e-01f, 7.06804767e-02f, -3.35957855e-01f, 4.68899727e-01f, 3.15257698e-01f, -1.25752345e-01f, 8.32357034e-02f, 1.75313294e-01f,
  -1.91443235e-01f, 2.13384941e-01f, 1.43422410e-01f, 2.18682494e-02f, -2.45373502e-01f, 6.44860744e-01f, -2.48906538e-01f, 2.35318765e-01f, 1.52683020e-01f, -2.16112927e-01f,
  2.12609485e-01f, -1.35471195e-01f, 1.61045775e-01f, 5.92654459e-02f, 2.60109276e-01f, -2.34372720e-01f, 1.76027969e-01f, -7.48508200e-02f, 4.00247037e-01f, -1.24337591e-01f,
  -3.47812986e-03f, 3.20298746e-02f, 5.83891094e-01f, -2.64840186e-01f, 2.14813218e-01f, 5.01260385e-02f, -1.30899653e-01f, -1.33273154e-01f, -3.28403801e-01f, -5.27485227e-03f,
  1.05770633e-01f, -5.35846315e-02f, -2.83996761e-01f, 2.94172168e-01f, 3.55243802e-01f, 2.65435278e-01f, 1.58402920e-01f, -5.80203421e-02f, -1.92831725e-01f, -4.12766673e-02f,
  1.06525399e-01f, 2.25035310e-01f, 1.57375693e-01f, -1.73857231e-02f, -1.47847623e-01f, -1.37529060e-01f, 2.26750329e-01f, -2.89739724e-02f, -1.77495867e-01f, -3.07746343e-02f,
  1.24198020e-01f, 1.45638198e-01f, -2.41609216e-02f, -1.57854587e-01f, 1.43555284e-01f, -2.59361863e-01f, 4.74754907e-02f, 8.72256532e-02f, -1.80618525e-01f, -6.59538880e-02f,
  1.76939130e-01f, -2.80703697e-02f, -9.82969552e-02f, 3.35112810e-02f, 3.48772965e-02f, 2.86274016e-01f, -1.47037715e-01f, 2.66257614e-01f, 1.75995708e-01f, 1.41137630e-01f,
  -1.08778439e-01f, 3.22568323e-03f, -8.08757246e-02f, 1.28040448e-01f, -1.42726839e-01f, 2.20353156e-01f, -1.76292762e-01f, 1.03359282e-01f, 1.05699398e-01f, -1.85525820e-01f,
  -8.93940218e-03f, 8.99488181e-02f, 1.87315434e-01f, -2.07758278e-01f, 1.54632851e-01f, 5.70991337e-02f, 1.70408800e-01f, -2.01322943e-01f, -2.19962731e-01f, 5.20456612e-01f,
  -2.42793500e-01f, 1.69667870e-01f, -1.16338253e-01f, 3.08318846e-02f, 3.32078785e-02f, 2.39643887e-01f, -1.68908060e-01f, 4.75122035e-01f, 2.43248478e-01f, 8.30819383e-02f,
  -1.28306776e-01f, -7.79971108e-02f, -5.49158938e-02f, 2.72657663e-01f, 3.55121136e-01f, 4.25378501e-01f, 1.67928152e-02f, -1.24164812e-01f, 1.74091518e-01f, -4.14529406e-02f,
  1.39670476e-01f, 1.53898150e-01f, 3.79672766e-01f, 1.73122063e-01f, -7.24361017e-02f, -2.94933245e-02f, -1.57050967e-01f, -9.15135369e-02f, 2.88590789e-01f, 2.62772858e-01f,
  8.30260068e-02f, 3.35618734e-01f, 2.74708360e-01f, -8.95782188e-03f, -1.08755544e-01f, -1.01076610e-01f, 3.40456307e-01f, 1.28382519e-01f, -4.99529541e-02f, 3.36259812e-01f,
  6.53048828e-02f, -9.42534674e-03f, 2.51831114e-01f, -3.24786097e-01f, 4.15274575e-02f, 6.66564405e-02f, 3.14085692e-01f, 4.16878611e-01f, -2.93175310e-01f, 8.61749500e-02f,
  1.18766524e-01f, -2.31730379e-02f, 3.04250330e-01f, 2.04279825e-01f, 3.86435360e-01f, 3.08232456e-01f, -4.55168523e-02f, 4.43045944e-02f, -9.53132734e-02f, 6.73329383e-02f,
  -8.12657103e-02f, -1.17862344e-01f, 9.88455117e-02f, 4.76850122e-01f, 2.27358058e-01f, 4.02125604e-02f, -6.83765039e-02f, -2.77446479e-01f, 2.51517564e-01f, 1.25730425e-01f,
  -2.35340983e-01f, 1.12256989e-01f, 2.51978457e-01f, 1.19462050e-01f, 5.41101336e-01f, 1.24167755e-01f, -2.38784254e-01f, 8.15813169e-02f, 6.97982609e-01f, 4.38573249e-02f,
  -2.95930505e-02f, -4.00231510e-01f, 4.00980860e-01f, 1.07389279e-01f, 1.86474621e-01f, 4.54612732e-01f, 1.73787981e-01f, 3.84877145e-01f, -2.56738603e-01f, 3.49389613e-01f,
  -9.82150063e-02f, 1.24740854e-01f, -4.99884337e-02f, -2.80722547e-02f, 3.18406940e-01f, 2.84921261e-03f, -1.93971977e-01f, 2.24329963e-01f, 1.48124754e-01f, -1.71382025e-01f,
  -2.24323049e-02f, -4.54394966e-02f, 5.65956056e-01f, 7.22199753e-02f, -2.47773081e-01f, -1.36734962e-01f, -6.31563589e-02f, -1.80904299e-01f, 4.35815126e-01f, -3.06681603e-01f,
  6.21344522e-02f, -8.81218016e-02f, 9.49112028e-02f, -8.67801756e-02f, -4.07522619e-01f, 2.06644163e-01f, 7.42738768e-02f, 3.75085741e-01f, 1.32665709e-01f, 3.39490205e-01f,
  -1.52283125e-02f, -1.13283105e-01f, -1.41828567e-01f, -5.31170182e-02f, -8.07461441e-02f, 1.56299114e-01f, -1.94027841e-01f, 2.47206941e-01f, 4.01880622e-01f, 1.52724788e-01f,
  2.43138477e-01f, -1.90452244e-02f, 1.57005921e-01f, 8.11355785e-02f, -7.57800192e-02f, -2.32210718e-02f, 4.70982879e-01f, -1.06293179e-01f, 1.23241171e-01f, -1.00624450e-01f,
  -8.07091296e-02f, 8.19012895e-02f, 6.35723710e-01f, -7.58041814e-02f, -5.47872931e-02f, 2.79512495e-01f, 1.18807256e-01f, -1.18226193e-01f, 6.42299801e-02f, -2.47521877e-01f,
  1.42461389e-01f, 1.35087669e-01f, 1.17911607e-01f, -1.07822470e-01f, 1.33967653e-01f, -1.11003600e-01f, 1.37199715e-01f, 4.45996076e-01f, 1.07160024e-01f, -8.16211104e-03f,
  2.10099928e-02f, 1.09424584e-01f, 6.19661920e-02f, -1.14783347e-01f, 1.92337558e-01f, -1.83229342e-01f, -1.17200278e-01f, -1.37740970e-01f, 7.70967975e-02f, -6.37241453e-03f,
  2.39813536e-01f, -2.00664718e-03f, 5.97075000e-02f, 3.33727807e-01f, 7.14412481e-02f, 2.35755652e-01f, 6.34858683e-02f, 2.99249023e-01f, 3.51520106e-02f, 1.01999275e-01f,
  2.53385189e-03f, -2.45353151e-02f, -4.08148579e-03f, 5.79667874e-02f, 4.40887874e-03f, -3.22666198e-01f, 4.95957024e-02f, -1.00213468e-01f, 2.39908863e-02f, -9.73141640e-02f,
  1.03301615e-01f, 7.16878846e-02f, -1.58000946e-01f, 2.03567043e-01f, -3.11512710e-03f, 8.11073929e-02f, -1.12422608e-01f, -1.61777541e-01f, 5.61133213e-02f, 1.17834575e-01f,
  9.07827169e-02f, -1.72087565e-01f, -7.95481950e-02f, -5.52210025e-02f, 3.35978895e-01f, 1.54188082e-01f, -4.44011427e-02f, -6.20420463e-02f, 3.02336365e-01f, -1.13274723e-01f,
  1.32688567e-01f, -2.09339783e-01f, -1.85888946e-01f, -1.98240578e-01f, -6.13110125e-01f, 3.83230060e-01f, -5.16804829e-02f, 1.53535768e-01f, -1.38623253e-01f, 5.69736481e-01f,
  -1.98345721e-01f, -2.64391631e-01f, 3.31117585e-02f, -4.52542603e-02f, -2.17784807e-01f, 1.41548529e-01f, 2.56466776e-01f, 1.10922949e-02f, 4.11033817e-02f, -1.15207739e-01f,
  7.10665211e-02f, -1.09584957e-01f, 1.47228032e-01f, -5.99862672e-02f, -2.57248640e-01f, 3.05794537e-01f, 2.59375930e-01f, 2.93001413e-01f, 3.56381804e-01f, 7.48037547e-02f,
  4.56320375e-01f, 1.48975298e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -1.60488874e-01f, 2.36067232e-02f, 2.79657900e-01f, -3.37457880e-02f, 3.21897417e-01f, 2.42562681e-01f, 3.82715128e-02f, 4.22657341e-01f, -1.32741749e-01f, 1.50765672e-01f,
  5.36320470e-02f, 2.72217959e-01f, 3.15472662e-01f, 3.14332038e-01f, 3.47616225e-02f, 2.08944410e-01f, 3.31529826e-01f, 4.38157767e-02f, 2.41359174e-01f, 7.24883229e-02f,
  3.13075811e-01f, 3.90655130e-01f, 1.08757794e-01f, 1.52496278e-01f, 9.24271718e-02f, 2.73034662e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.65933686e-01f, -3.24479431e-01f, -6.26409411e-01f, -4.69754748e-02f, 3.93602699e-01f, 5.41052759e-01f, 6.83576018e-02f, 4.01170135e-01f, -3.31215590e-01f, 1.74362794e-01f,
  -2.19766900e-01f, -3.77003141e-02f, -1.21009007e-01f, -2.73217618e-01f, 1.63528413e-01f, 5.44364691e-01f, -1.69279218e-01f, -2.93784469e-01f, -2.83579439e-01f, -4.69743550e-01f,
  2.41690099e-01f, -1.99197218e-01f, -9.57021937e-02f, 1.15200095e-01f, 2.26973623e-01f, -9.29542556e-02f, 2.73485541e-01f, -1.49704628e-02f, 6.99795723e-01f, -2.68820852e-01f,
  -3.21259290e-01f, 5.25543630e-01f, -2.65707850e-01f, 1.88239038e-01f, -2.24784821e-01f, -1.68771356e-01f, -1.03760533e-01f, -3.03552479e-01f, -1.59579575e-01f, 2.93504715e-01f,
  -5.55638969e-01f, -1.46063166e-02f, 1.05240032e-01f, 5.69695272e-02f, -1.49777859e-01f, -4.53369290e-01f, -9.71463323e-03f, 3.27108502e-02f, 5.75692713e-01f, -4.01487172e-01f,
  2.37530008e-01f, -7.29784846e-01f, 4.79887187e-01f, -2.07885593e-01f, 8.76691714e-02f, -2.57393837e-01f, -3.05037051e-01f, 4.89775717e-01f, 8.14296126e-01f, -2.47574463e-01f,
  5.23226440e-01f, 2.00301692e-01f, -2.17494696e-01f, -3.73267472e-01f, 7.47920275e-01f, 1.19948782e-01f, 8.92230421e-02f, 2.61260629e-01f, -2.52341419e-01f, -1.59341961e-01f,
  -1.84452727e-01f, -3.20640445e-01f, 5.50211258e-02f, 2.46328339e-01f, -8.55778605e-02f, 4.35932726e-01f, -1.48749530e-01f, -2.04612538e-01f, 2.13951636e-02f, -1.36688426e-01f,
  -2.26539791e-01f, 1.87628806e-01f, 9.34840441e-02f, 7.95717239e-01f, 1.62420988e-01f, -1.87042207e-01f, -4.69357431e-01f, -9.38363075e-02f, -3.84696633e-01f, 2.62066096e-01f,
  6.92792907e-02f, 1.02795899e+00f, 7.59539604e-02f, -2.62887985e-01f, 4.52250019e-02f, -3.58549774e-01f, 3.54799479e-01f, 2.41712362e-01f, -1.80727821e-02f, -2.34705091e-01f,
  -3.21465731e-01f, -2.36292571e-01f, 8.47392976e-02f, 7.50878632e-01f, -1.48346037e-01f, 1.04788356e-01f, -5.68856239e-01f, -2.52292305e-02f, -4.77689430e-02f, 4.62875366e-01f,
  9.60386172e-02f, 2.65979171e-01f, -2.32824489e-01f, -1.01135798e-01f, -3.22735846e-01f, 8.68505016e-02f, -1.85312137e-01f, -3.05907696e-01f, -7.11930469e-02f, -8.95385295e-02f,
  -4.28278416e-01f, -1.62968338e-01f, -1.91916004e-01f, 5.24147928e-01f, -6.20011568e-01f, -2.47389629e-01f, -1.81079552e-01f, 6.60952985e-01f, -3.60853486e-02f, 7.30818138e-02f,
  9.28020030e-02f, -4.95732188e-01f, 4.54063714e-01f, 1.06658846e-01f, -9.59510356e-02f, -2.12336868e-01f, -4.71278876e-01f, -1.90916464e-01f, 1.36344239e-01f, -4.71911818e-01f,
  -1.70790926e-01f, 5.88870525e-01f, 1.87699959e-01f, -7.36351535e-02f, 1.32082803e-02f, 4.91452634e-01f, 1.82655334e-01f, 1.52577758e-01f, -4.99565490e-02f, 2.38139853e-02f,
  -3.83853465e-01f, -1.05189487e-01f, 2.13353202e-01f, -3.08569446e-02f, -1.78542778e-01f, 2.97396958e-01f, 3.68410110e-01f, -1.37945920e-01f, 4.20127600e-01f, 6.35807991e-01f,
  1.20974101e-01f, 9.13298875e-02f, 2.35885561e-01f, -3.58078122e-01f, -2.49287598e-02f, 5.78099132e-01f, -6.22107871e-02f, -4.42082286e-01f, 1.91377942e-02f, -8.80472735e-02f,
  4.08263922e-01f, -3.06581736e-01f, 2.59977788e-01f, -3.76265526e-01f, -1.72126412e-01f, 5.87346144e-02f, -1.72460303e-01f, -1.41485497e-01f, -5.16784489e-02f, 2.89394468e-01f,
  -6.05212077e-02f, 1.80253044e-01f, 2.53988147e-01f, -1.05047924e-02f, 6.80477798e-01f, 3.64312559e-01f, 6.84970856e-01f, -5.01539260e-02f, 1.09320596e-01f, -2.24697575e-01f,
  -1.75489992e-01f, -1.17976494e-01f, -5.12889087e-01f, -5.23402154e-01f, -3.83615196e-01f, 2.85325378e-01f, -5.15889406e-01f, -1.46482900e-01f, -1.23005278e-01f, -6.10253103e-02f,
  -3.70498657e-01f, 5.21924347e-02f, -2.79122561e-01f, -5.13545834e-02f, 1.60347670e-01f, 2.54819185e-01f, -1.79961398e-01f, -1.07775919e-01f, -2.59010643e-01f, -2.92155147e-01f,
  6.24574304e-01f, 3.98768336e-01f, 4.57193628e-02f, 4.81814206e-01f, -3.61727566e-01f, -2.58054346e-01f, -2.33737290e-01f, 2.57953614e-01f, -5.48170626e-01f, -1.18333921e-01f,
  9.28232744e-02f, 3.16907823e-01f, -1.25588134e-01f, -4.74102587e-01f, -4.65726286e-01f, -2.90327877e-01f, -7.42769837e-02f, 1.27261788e-01f, 5.55585802e-01f, 2.35715240e-01f,
  -1.08341821e-01f, 2.78822929e-01f, 6.11095130e-01f, -2.06312150e-01f, -2.31849805e-01f, -3.51079404e-01f, -2.44991958e-01f, -3.86796385e-01f, 4.67504710e-02f, 9.43371430e-02f,
  4.89313722e-01f, 4.24117327e-01f, -4.43084212e-03f, -3.99299860e-01f, 4.42795277e-01f, 1.50233179e-01f, -3.80121693e-02f, 3.02701026e-01f, -8.69489163e-02f, -2.72656709e-01f,
  -3.30020756e-01f, -2.07393929e-01f, -1.20751359e-01f, -4.09191638e-01f, -6.31052628e-02f, -9.32624415e-02f, 1.84276596e-01f, -5.50266504e-01f, -7.06726089e-02f, 3.52195740e-01f,
  -2.01078251e-01f, 1.48789421e-01f, 1.22526564e-01f, -3.36266965e-01f, 5.56731224e-01f, 1.79090202e-01f, -7.51150101e-02f, 6.14713132e-01f, 2.62938946e-01f, -1.86599687e-01f,
  -8.78461301e-02f, -4.30811703e-01f, 3.43316793e-01f, -1.06581353e-01f, -5.02191067e-01f, -2.98326790e-01f, -5.89700453e-02f, -1.42778218e-01f, 5.88336706e-01f, 2.83549637e-01f,
  4.57510322e-01f, 3.13300610e-01f, -4.41576280e-02f, -3.45747501e-01f, -2.96550721e-01f, 3.14438082e-02f, 1.55478328e-01f, -6.07726648e-02f, -2.23501578e-01f, 4.36942518e-01f,
  2.64133096e-01f, 6.99605942e-01f, 4.01215374e-01f, -1.06614307e-01f, -6.98624477e-02f, -4.47222114e-01f, 1.54891863e-01f, -6.50053024e-02f, -1.52755558e-01f, 3.66325885e-01f,
  -2.89578140e-01f, 9.20004845e-02f, -1.87169164e-01f, -1.54636651e-01f, -9.31777060e-03f, -1.02083370e-01f, -2.72719026e-01f, 5.04561841e-01f, -3.60910408e-02f, 1.15732574e+00f,
  -3.35338682e-01f, -8.40490311e-02f, -3.18554416e-02f, -5.09073973e-01f, 4.90991287e-02f, -1.77725852e-01f, -2.22203866e-01f, 9.52668414e-02f, 6.78011551e-02f, 1.41910374e-01f,
  5.23501992e-01f, 3.04920316e-01f, -2.55334582e-02f, -3.66675675e-01f, -3.80058438e-01f, -5.62287211e-01f, -3.71510200e-02f, -4.75485474e-01f, 1.55440345e-01f, 9.80973765e-02f,
  9.72256482e-01f, -6.15235157e-02f, -6.70008510e-02f, 3.60287756e-01f, -2.18782853e-02f, 2.51553506e-01f, -3.14240396e-01f, 3.60216290e-01f, -5.71645856e-01f, -8.08293074e-02f,
  -2.54848767e-02f, 9.40086246e-02f, 4.75622028e-01f, -1.27198115e-01f, -1.11353695e-01f, -3.84332657e-01f, -3.45096260e-01f, -1.70351624e-01f, -2.12935776e-01f, -2.78145105e-01f,
  2.89817061e-02f, -3.04753900e-01f, -2.00901151e-01f, 1.85187653e-01f, 1.63024753e-01f, 4.52671856e-01f, 1.06048450e-01f, -3.66613925e-01f, -3.10489200e-02f, 2.43802935e-01f,
  1.07802026e-01f, 9.42765772e-02f, -3.02143633e-01f, 1.26852050e-01f, 6.13147654e-02f, 4.92343903e-01f, 5.50508238e-02f, -2.93121487e-01f, -1.90546110e-01f, -3.38394225e-01f,
  9.44187403e-01f, -5.31050086e-01f, -2.46944204e-01f, -5.99098921e-01f, 5.52566834e-02f, 2.07160741e-01f, 1.16305694e-01f, -1.16907924e-01f, -2.72637457e-01f, -2.55750686e-01f,
  -2.74647415e-01f, 2.80059665e-01f, -7.12931305e-02f, 2.18537003e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.96672076e-01f, -1.52050692e-03f, 2.78376285e-02f, -2.78094094e-02f, -3.48982215e-02f, 1.84742659e-01f, -9.83226150e-02f, -3.13205533e-02f, -2.09718972e-01f, 9.73695964e-02f,
  3.51577997e-01f, -3.85001972e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    