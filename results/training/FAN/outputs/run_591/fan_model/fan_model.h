/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.95665044e-01f, 4.07275617e-01f, 2.13647574e-01f, -4.23818380e-01f, 3.09354931e-01f, 3.93643975e-01f, 3.95909697e-01f, 7.86093548e-02f, -3.14102620e-01f, 1.02884859e-01f,
  3.30181122e-01f, -1.40188292e-01f, -1.15996942e-01f, -7.30836615e-02f, 5.54154105e-02f, -8.47196020e-03f, -3.04057002e-01f, -2.41630942e-01f, 5.80704026e-03f, 1.63292304e-01f,
  -2.15746220e-02f, 2.28670053e-02f, -2.30180606e-01f, -2.63586879e-01f, -2.66285300e-01f, -2.74928391e-01f, -1.15142083e-02f, 1.26001227e-03f, 2.99730450e-01f, -4.28964853e-01f,
  1.46572605e-01f, 1.04964592e-01f, -1.17050625e-01f, -1.80552565e-02f, 9.64703485e-02f, -9.31510404e-02f, -4.26181480e-02f, -9.09936577e-02f, -2.47187205e-02f, -5.41384295e-02f,
  -2.11697873e-02f, -4.91278013e-03f, -3.74849997e-02f, 3.24812159e-02f, 5.22288941e-02f, -4.14421856e-02f, -3.16206329e-02f, -3.57870362e-03f, -2.49658190e-02f, 7.84301385e-02f,
  1.07827336e-01f, 1.21229038e-01f, 1.61755145e-01f, 2.20992193e-02f, 8.90746862e-02f, -3.08097675e-02f, 8.93421173e-02f, 4.71746288e-02f, 7.88229406e-02f, -1.31069601e-01f,
  6.25083148e-02f, 5.81030287e-02f, 8.06579441e-02f, 5.87812327e-02f, 2.79357675e-02f, 6.04540184e-02f, -3.37538570e-02f, 4.49538007e-02f, 7.06310272e-02f, -1.51666198e-02f,
  4.44343090e-02f, 5.86931333e-02f, 7.41725564e-02f, 3.10372412e-02f, -1.69770271e-02f, 1.14423700e-01f, 9.09347087e-02f, 2.11136676e-02f, 9.15636048e-02f, 2.22633108e-02f,
  1.28856227e-01f, -1.07609970e-03f, -2.25619078e-02f, 2.13440508e-02f, 1.10573761e-01f, 1.55478725e-02f, 5.31919561e-02f, 1.06710941e-01f, 7.90700763e-02f, 1.23076923e-02f,
  -8.75383615e-02f, 7.30737597e-02f, -1.40214577e-01f, -3.57375666e-02f, -1.05172377e-02f, -5.81776127e-02f, -7.58545101e-02f, -1.50552420e-02f, 3.65185924e-02f, -6.11030236e-02f,
  2.02850997e-02f, -2.16123592e-02f, 6.13774396e-02f, -3.27214077e-02f, -8.78240913e-02f, 1.27874995e-02f, 4.59782593e-02f, -7.44446786e-03f, -2.84651779e-02f, -7.83118904e-02f,
  -8.27042982e-02f, -4.97270487e-02f, 1.33125577e-02f, -3.69956605e-02f, 6.39994070e-03f, -1.15191638e-01f, 9.49243084e-02f, -3.66160274e-02f, 3.57083082e-02f, -1.57682240e-01f,
  -5.66139698e-01f, 1.16067506e-01f, -1.31049007e-01f, -5.24731100e-01f, -3.76529485e-01f, -3.59537476e-03f, 1.72274426e-01f, 1.54183507e-01f, -2.50041604e-01f, -1.85094580e-01f,
  -1.84761137e-01f, -1.88953996e-01f, -1.24413498e-01f, 5.55233993e-02f, 1.57865554e-01f, 2.73646116e-02f, -2.45175332e-01f, -1.13491163e-01f, -1.22227529e-02f, 3.08785439e-02f,
  -4.05934872e-03f, -1.18040614e-01f, -2.01630384e-01f, -7.23064244e-02f, -3.79229970e-02f, -5.38202040e-02f, 5.66192269e-02f, -1.39254093e-01f, 1.92329258e-01f, -2.17253342e-01f,
  -3.33020389e-01f, -2.18067110e-01f, -2.09967494e-01f, -3.00723106e-01f, -2.21478418e-01f, -2.07262561e-01f, -1.70720384e-01f, -2.43332863e-01f, -2.12963790e-01f, -1.83137551e-01f,
  -2.70041376e-01f, -1.66790172e-01f, -2.31824353e-01f, -2.39318013e-01f, -2.60116607e-01f, -1.10939324e-01f, -1.55812591e-01f, -1.42412990e-01f, -2.49988306e-02f, -8.26770589e-02f,
  -1.92449674e-01f, -2.07545832e-01f, -1.78719804e-01f, 2.97602918e-03f, -3.53567563e-02f, -1.21800639e-01f, -1.44553594e-02f, -3.18039358e-02f, -2.72179674e-02f, -4.90286723e-02f,
  -4.39096056e-02f, 4.17480059e-02f, 2.64121383e-01f, 2.27777511e-01f, 2.33000860e-01f, 1.77404612e-01f, 9.98197123e-02f, 1.34996250e-01f, 2.58508146e-01f, 7.95829669e-02f,
  2.31701359e-01f, 1.99199602e-01f, 1.88086018e-01f, 1.52842283e-01f, 2.22956851e-01f, 1.61549091e-01f, 2.03315899e-01f, 1.52432010e-01f, 1.32757723e-01f, 5.18654957e-02f,
  1.45467803e-01f, 2.12813318e-01f, 8.09570178e-02f, 1.83096215e-01f, 3.04816335e-01f, 1.78571865e-01f, 2.66215265e-01f, 2.56308705e-01f, 1.84923604e-01f, 1.05780594e-01f,
  -1.88132152e-01f, -3.23813707e-02f, -2.42094532e-01f, -1.14839256e-01f, -1.76714644e-01f, -7.37072155e-02f, -2.26435661e-01f, -1.70515686e-01f, -2.38150477e-01f, -1.43045172e-01f,
  2.54243724e-02f, -6.14194982e-02f, -1.41465425e-01f, -6.89579695e-02f, -1.42788425e-01f, -3.70447524e-02f, -1.08754151e-01f, -1.89438552e-01f, -9.63582993e-02f, -1.88239202e-01f,
  -2.21654233e-02f, -1.07479185e-01f, -1.33023500e-01f, -1.44877002e-01f, -8.42010230e-02f, -2.35249907e-01f, -4.95614409e-02f, -5.04519120e-02f, 8.53393599e-03f, -3.32187712e-02f,
  2.20973775e-01f, -4.21531230e-01f, -1.55237615e-01f, 5.74041940e-02f, -1.92799121e-01f, -1.88873425e-01f, -3.76252055e-01f, 9.44436528e-03f, 4.42546159e-02f, -1.31381795e-01f,
  -1.76368088e-01f, 4.28047180e-02f, 1.90269396e-01f, 1.22006997e-01f, -6.15009144e-02f, -4.20639902e-01f, -2.81789660e-01f, 1.97709024e-01f, 3.47081661e-01f, 2.10468665e-01f,
  -6.54619932e-02f, 2.10237041e-01f, 1.93670228e-01f, 1.62937835e-01f, -1.87438160e-01f, 7.28032216e-02f, -5.47658652e-02f, -1.04796946e-01f, -3.28509212e-01f, -4.98978496e-01f,
  -1.42574623e-01f, -2.70243108e-01f, 1.20277636e-01f, -3.34791914e-02f, -2.97617149e-02f, 1.56160563e-01f, 4.15209942e-02f, 1.20497108e-01f, -2.34341645e-03f, 3.85192111e-02f,
  -1.30540967e-01f, -1.33788101e-02f, 5.28298356e-02f, 2.96365935e-02f, 6.98948791e-03f, -6.34445921e-02f, 1.61503423e-02f, 5.84470853e-02f, -2.45761443e-02f, -4.77917679e-02f,
  -1.25897676e-01f, -2.87172973e-01f, -9.86269116e-02f, -1.02719843e-01f, -4.86107357e-02f, -1.01997316e-01f, -9.42683667e-02f, -6.26613647e-02f, -1.56383887e-02f, -9.58781764e-02f,
  1.46748111e-01f, -4.24658274e-03f, 4.56748158e-02f, 4.57700193e-02f, 7.92344064e-02f, 4.62720431e-02f, 3.05615850e-02f, 3.80471610e-02f, 4.55007739e-02f, 9.23536718e-02f,
  7.59010017e-02f, 1.25676310e-02f, -4.68831360e-02f, -1.24884648e-02f, -2.97319815e-02f, -2.52434053e-02f, -4.05740477e-02f, -3.42558161e-03f, -4.39753868e-02f, 1.68992337e-02f,
  4.43269908e-02f, -2.76563242e-02f, -5.23553789e-02f, 3.07329744e-02f, -5.60242124e-02f, 4.25815955e-02f, -2.66801342e-02f, 8.91123712e-02f, 1.40319631e-01f, -7.13744909e-02f,
  3.86723489e-01f, -1.27785742e-01f, -5.57146110e-02f, 5.40904813e-02f, -2.42565516e-02f, 8.42465647e-03f, -5.75896278e-02f, -7.15244338e-02f, -1.14972748e-01f, -1.44233584e-01f,
  -6.85360730e-02f, 1.22894226e-02f, -1.15399443e-01f, -4.54450166e-03f, 5.53663597e-02f, -7.84418080e-03f, -3.53272222e-02f, -5.92195839e-02f, -1.03632823e-01f, -9.55443382e-02f,
  -5.94603047e-02f, 8.04584753e-03f, 7.83927068e-02f, 5.91310300e-03f, -7.68929124e-02f, 1.99855827e-02f, 9.05721784e-02f, 4.61500324e-02f, 4.27396372e-02f, 1.90745860e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.42941225e+00f, -1.12407804e-01f, -5.68293966e-02f, -6.35287881e-01f, 2.37472922e-01f, 2.06925184e-01f, 2.27506965e-01f, -8.10492784e-02f, -2.61929303e-01f, -4.63060886e-01f,
  -4.24447864e-01f, -9.38093066e-02f, 5.46940081e-02f, 3.13975275e-01f, 3.34421337e-01f, 1.47327274e-01f, 4.92071062e-01f, 4.35508758e-01f, 2.47274429e-01f, -9.30805132e-02f,
  2.32830644e-01f, -5.57584688e-03f, -2.89693564e-01f, 1.80684388e-01f, -3.15212578e-01f, 4.68120165e-02f, 2.35535689e-02f, -9.29297954e-02f, 1.33815035e-01f, -3.59137319e-02f,
  -7.06519902e-01f, -7.89482653e-01f, 2.10408106e-01f, -1.12075217e-01f, -2.23463863e-01f, -1.17821231e-01f, -4.20654751e-02f, -2.72092164e-01f, 5.52305169e-02f, -2.65856031e-02f,
  -2.66682178e-01f, -2.79989745e-02f, 6.00680895e-02f, 5.29859029e-02f, -2.55185574e-01f, 1.27607346e-01f, 3.98818739e-02f, 7.34026358e-02f, 7.10444059e-03f, -1.63240269e-01f,
  1.66274056e-01f, 3.74088883e-02f, -3.17022949e-01f, 3.96162659e-01f, 7.43145496e-02f, 3.44791234e-01f, -1.18423998e-02f, -2.14199334e-01f, 2.90115066e-02f, -5.43816090e-01f,
  -2.33336370e-02f, -5.61138317e-02f, 8.12062807e-03f, -7.08624208e-03f, 1.05558366e-01f, 6.32270798e-02f, 1.02222906e-02f, -1.37520358e-01f, 1.99605688e-01f, -1.20837316e-01f,
  2.24947825e-01f, -1.61295131e-01f, 1.50548860e-01f, -9.06961039e-02f, -5.24784103e-02f, 2.25521084e-02f, 5.68531640e-02f, 9.65870246e-02f, 3.27426605e-02f, -4.05868776e-02f,
  -1.56427607e-01f, -3.02852131e-03f, -4.16487232e-02f, 2.05757126e-01f, 6.17489144e-02f, 1.73214599e-02f, -1.44458979e-01f, -9.23350900e-02f, -1.64467841e-01f, -5.38861454e-02f,
  -2.03911677e-01f, 5.78124166e-01f, -2.96747923e-01f, -1.67776961e-02f, -8.36443976e-02f, 6.13705367e-02f, -6.61229249e-03f, 8.73262659e-02f, -1.61116689e-01f, -6.56967163e-02f,
  -1.25261936e-02f, -9.62013677e-02f, -5.94676984e-03f, 1.17124259e-01f, 1.70472113e-03f, -6.00431226e-02f, -2.24617179e-02f, -1.44557403e-02f, -4.68989946e-02f, 1.16984956e-01f,
  1.17917381e-01f, 5.22092283e-02f, -3.59505922e-01f, -1.09883793e-01f, -6.87348023e-02f, -2.81275481e-01f, -4.61728871e-02f, -2.60066539e-01f, -1.96522653e-01f, -4.57108676e-01f,
  2.86285371e-01f, 5.43328226e-01f, 3.89808297e-01f, 4.98127565e-02f, 2.82145920e-03f, -1.88772485e-01f, 3.42477001e-02f, -8.53669941e-02f, -1.57811508e-01f, 2.64470071e-01f,
  5.59313968e-02f, -3.80450696e-01f, -1.99852690e-01f, -2.66371220e-01f, -1.44850656e-01f, 4.60247964e-01f, 4.43872660e-01f, -1.30867660e-01f, -8.35425735e-01f, -4.35799092e-01f,
  -2.96863943e-01f, -2.39657983e-01f, -2.37154946e-01f, -1.62432984e-01f, 4.03824449e-01f, -2.35269859e-01f, 3.95280957e-01f, 4.16291296e-01f, 3.68400663e-01f, 9.76911128e-01f,
  5.13412774e-01f, 6.15180075e-01f, -4.44601029e-01f, -1.46495521e-01f, 1.67599693e-01f, 9.07159820e-02f, 1.62407905e-02f, 1.37348220e-01f, -1.33945689e-01f, 1.58199117e-01f,
  2.03065619e-01f, 8.24919045e-02f, -5.73369823e-02f, -1.15351789e-01f, -1.80321187e-01f, -3.17765385e-01f, 1.20393224e-01f, 1.86501201e-02f, -1.14112079e-01f, 1.09373875e-01f,
  -6.46008104e-02f, 6.88754544e-02f, -2.82258261e-02f, -1.84879139e-01f, -2.32797917e-02f, -4.25642282e-01f, 4.71026488e-02f, 7.72254020e-02f, -4.11723517e-02f, 3.57492656e-01f,
  -9.64788049e-02f, 3.82577106e-02f, 5.66405766e-02f, 1.09316982e-01f, -5.90140186e-02f, 1.61519021e-01f, 2.12412272e-02f, -1.92890048e-01f, -5.72362766e-02f, 1.20103568e-01f,
  -6.95799291e-02f, -5.15575781e-02f, 7.54513070e-02f, 5.91918826e-02f, -2.10261289e-02f, -4.51684818e-02f, 7.21383244e-02f, -1.10949958e-02f, -7.82882124e-02f, 2.72002965e-02f,
  -2.41505727e-01f, 3.32152359e-02f, 1.07152477e-01f, 7.69281164e-02f, 2.01462507e-02f, 6.57564029e-02f, -5.09484373e-02f, -3.13319750e-02f, -1.11484706e-01f, 2.46450007e-01f,
  -3.62984568e-01f, -4.77905750e-01f, 2.56586730e-01f, -7.25385472e-02f, 1.14652716e-01f, 3.15363295e-02f, 1.75618663e-01f, -1.37170041e-02f, 9.55714658e-02f, -1.58541322e-01f,
  -2.41972476e-01f, -7.61451432e-03f, 1.97839439e-01f, -7.25786248e-03f, -1.88365504e-01f, -1.20167762e-01f, 6.22739270e-02f, -2.14378223e-01f, -2.00627476e-01f, 3.47433947e-02f,
  2.43884120e-02f, -4.82220411e-01f, -4.13970262e-01f, -1.67852774e-01f, -1.36899665e-01f, -4.73315418e-01f, -2.63880730e-01f, -2.24765390e-01f, -4.27954555e-01f, -3.89519036e-01f,
  1.52046874e-01f, 7.38401830e-01f, 3.52939576e-01f, 5.15208840e-01f, 3.00947905e-01f, 5.43495715e-01f, 6.67163372e-01f, 4.49667603e-01f, 1.89608276e-01f, 1.70901865e-01f,
  2.11197004e-01f, 1.50092483e-01f, 2.47825235e-01f, 1.40621156e-01f, 3.62558275e-01f, 3.79645079e-01f, 3.77396584e-01f, 9.40416604e-02f, 4.10562344e-02f, 6.70356229e-02f,
  2.20066518e-01f, 1.00876749e-01f, -1.33603692e-01f, 1.33809716e-01f, 1.24534845e-01f, 5.22298552e-02f, 1.05398834e-01f, 8.95340666e-02f, 5.37303202e-02f, 2.59464025e-01f,
  -1.12129062e-01f, 6.05181813e-01f, -1.11083567e-01f, -5.47937006e-02f, -2.10809246e-01f, -2.51662672e-01f, -1.00491114e-01f, -2.36275062e-01f, -1.08766094e-01f, -7.93500319e-02f,
  -1.46445274e-01f, -1.87918454e-01f, 3.68962251e-02f, -1.87028885e-01f, -8.90897661e-02f, -1.65138364e-01f, -1.25595927e-01f, 8.23758841e-02f, 1.47379693e-02f, -9.21005160e-02f,
  -1.68705620e-02f, -1.57108933e-01f, -2.28397250e-02f, 1.10071026e-01f, 1.74659714e-01f, -8.28778520e-02f, -8.14908817e-02f, -6.40637353e-02f, 7.40783289e-02f, -8.56607407e-02f,
  4.65236045e-02f, 4.56666462e-02f, -2.34160069e-02f, 2.58394368e-02f, -6.46729209e-03f, -3.84172350e-02f, 2.58262269e-02f, -1.71348434e-02f, 7.53774941e-02f, -5.06304726e-02f,
  1.50530203e-03f, 3.82559672e-02f, 3.59396599e-02f, -6.67410716e-02f, -4.44678441e-02f, -9.55539197e-02f, -1.32063821e-01f, -1.04934841e-01f, -1.52451815e-02f, -1.42885745e-01f,
  -1.43083021e-01f, 6.30775639e-06f, -4.25572544e-02f, 7.51916617e-02f, -4.13420387e-02f, 7.86611587e-02f, -9.74990800e-02f, -4.13568579e-02f, -4.77177948e-02f, -9.72171575e-02f,
  -2.24155605e-01f, 1.06917500e-01f, 5.71585968e-02f, 2.60354821e-02f, 7.71498457e-02f, -1.06325433e-01f, 1.46424949e-01f, -1.02233149e-01f, -7.10304379e-02f, 1.87966913e-01f,
  -7.68145248e-02f, -3.80594172e-02f, 4.54097539e-02f, 1.38809495e-02f, -1.80533215e-01f, -2.03133076e-01f, -7.39611834e-02f, -2.79831626e-02f, -4.05377708e-02f, -1.80929214e-01f,
  -1.39355600e-01f, -1.61672786e-01f, -3.27121556e-01f, 1.84509140e-02f, 2.17160657e-02f, -3.94213498e-02f, -1.16725430e-01f, -2.17951760e-01f, -5.70622049e-02f, -2.35962451e-01f,
  -9.38027084e-01f, -2.67687082e-01f, 4.24233913e-01f, -8.02637577e-01f, 2.88507968e-01f, -1.73440784e-01f, -5.29091001e-01f, -8.17954838e-01f, -3.53203684e-01f, 1.49799287e-01f,
  6.32927001e-01f, 5.94994366e-01f, 3.82221639e-01f, 1.39258072e-01f, -8.56870592e-01f, -4.99181449e-01f, -6.86016977e-01f, -3.42219532e-01f, -1.37514278e-01f, 1.05161592e-01f,
  3.36522490e-01f, -2.05464691e-01f, -4.50327963e-01f, -2.28251413e-01f, -2.69781612e-02f, -1.51306232e-02f, 3.95422056e-03f, -2.88886905e-01f, 2.60744512e-01f, 7.28647783e-02f,
  7.98898339e-01f, -4.88997370e-01f, 2.31291980e-01f, -1.85471296e-01f, 4.69601393e-01f, -3.78252603e-02f, 5.42084314e-02f, -1.17469437e-01f, 2.45537478e-02f, -3.60157043e-01f,
  4.50173244e-02f, 2.09227160e-01f, -1.89602956e-01f, -1.16195031e-01f, -3.36473525e-01f, -4.08227324e-01f, -3.39812905e-01f, -3.81440312e-01f, -2.14249864e-01f, 9.90412012e-02f,
  6.52101636e-02f, 4.11365665e-02f, -3.10211688e-01f, -5.56370728e-02f, -8.30910541e-03f, 1.94886565e-01f, 7.07201585e-02f, 2.86354013e-02f, -9.57115740e-02f, -5.63965023e-01f,
  -2.92145848e-01f, -6.12620935e-02f, 1.69374764e-01f, -5.64907938e-02f, -4.78430986e-02f, 1.16194233e-01f, -3.07793636e-02f, -9.23512280e-02f, 6.91671818e-02f, -6.71501085e-02f,
  -2.78930552e-02f, 4.22035903e-02f, 1.93657041e-01f, -1.61363631e-01f, 8.96742195e-02f, -1.73895255e-01f, -2.09741265e-01f, -9.35181901e-02f, -7.78041407e-02f, -5.08816764e-02f,
  4.03693356e-02f, 1.24228019e-02f, 1.24627426e-01f, -1.80785116e-02f, -1.91184767e-02f, -1.00528248e-01f, 1.78065374e-01f, 1.52659625e-01f, -5.78524321e-02f, 1.69080779e-01f,
  -2.72497505e-01f, 3.88701111e-01f, 5.16456403e-02f, -1.68315805e-02f, -2.40787223e-01f, 5.89309372e-02f, 1.51258081e-01f, 4.02625315e-02f, 1.37255147e-01f, -1.39155835e-01f,
  -7.79417902e-02f, -1.60174921e-01f, -1.79749414e-01f, 1.95741490e-01f, -1.42281964e-01f, -1.37719393e-01f, -2.93378234e-01f, -1.22731782e-01f, -1.65767148e-01f, 1.05719335e-01f,
  -4.53908473e-01f, -5.33283353e-01f, -2.71719158e-01f, -1.96524158e-01f, 6.49784282e-02f, -2.26150572e-01f, 1.05865166e-01f, -1.46746943e-02f, -2.06194788e-01f, -4.65395629e-01f,
  1.33800745e+00f, -6.72987401e-01f, 1.27202898e-01f, 2.17641577e-01f, -3.24843973e-01f, -5.22876829e-02f, -4.83786345e-01f, -1.63077220e-01f, 1.83146775e-01f, -2.06379920e-01f,
  -1.84601054e-01f, 2.89206654e-01f, 2.38591313e-01f, 2.52746940e-01f, 2.38694489e-01f, -7.76506662e-02f, 1.61781255e-02f, 5.39570689e-01f, 4.55046594e-01f, -2.66361665e-02f,
  -2.44053766e-01f, -2.68895656e-01f, 1.99551687e-01f, 2.72626951e-02f, -3.89806777e-01f, -4.67534846e-06f, -3.22784096e-01f, -3.48898798e-01f, -2.74344385e-01f, -1.95666596e-01f,
  3.32482696e-01f, -4.08351161e-02f, 2.58164912e-01f, 9.10807252e-02f, -9.03878286e-02f, 1.75067618e-01f, 4.39983346e-02f, 6.84288442e-02f, -1.41655296e-01f, -1.10521309e-01f,
  -3.46989781e-02f, 1.29155713e-04f, 5.89522906e-02f, -1.14086732e-01f, -5.12496047e-02f, -1.31174132e-01f, -5.96512109e-03f, 1.59538627e-01f, 1.29985111e-02f, 1.24935936e-02f,
  -1.56058758e-01f, -9.68718082e-02f, -3.20344139e-03f, -9.95472819e-03f, 2.06892461e-01f, 1.93357870e-01f, -2.20145747e-01f, 2.91484203e-02f, 1.52230009e-01f, 9.26322192e-02f,
  -5.69253638e-02f, 1.19824991e-01f, 1.26514331e-01f, -9.13404971e-02f, 3.02437637e-02f, 9.55157354e-02f, -2.60671042e-02f, -3.05944681e-03f, 8.10702816e-02f, 1.35533360e-03f,
  -7.02690259e-02f, 6.97139800e-02f, 1.64341237e-02f, -2.83174915e-03f, 1.08781137e-01f, 1.95920244e-02f, -6.53894246e-02f, -1.33348703e-01f, 1.38441324e-01f, 4.91363294e-02f,
  1.32768929e-01f, 7.42337629e-02f, -8.78153443e-02f, -8.76667127e-02f, -1.15565747e-01f, 1.21847633e-02f, 4.52485867e-02f, -7.81191736e-02f, -6.98605254e-02f, -1.21630184e-01f,
  -3.27300072e-01f, 3.54606062e-01f, 1.34251744e-01f, -7.47147901e-03f, 4.61159647e-02f, -1.24181107e-01f, 4.97734770e-02f, -7.20636621e-02f, -1.60777003e-01f, -1.58920642e-02f,
  -1.50300309e-01f, 3.49280015e-02f, -4.11425941e-02f, 3.27094793e-02f, 4.38967086e-02f, 6.03243336e-02f, -7.29040131e-02f, 5.29053807e-02f, -1.95123311e-02f, -1.75436571e-01f,
  -1.46497205e-01f, 4.75846715e-02f, 1.43058494e-01f, 1.14511102e-01f, 5.93338907e-02f, 1.37844622e-01f, -1.12400390e-01f, -3.37702036e-02f, 2.23788723e-01f, -1.69578195e-01f,
  3.16533506e-01f, -7.68950164e-01f, 6.56819463e-01f, 4.30576265e-01f, 8.50139081e-01f, 7.77667463e-01f, 6.93880916e-01f, 2.24679053e-01f, 3.05764023e-02f, 7.72873759e-02f,
  -3.08483690e-01f, -6.40686870e-01f, -5.22716224e-01f, -4.38411325e-01f, -3.30883890e-01f, 2.84743220e-01f, 4.16762471e-01f, 1.64038852e-01f, 2.61381388e-01f, 2.39255860e-01f,
  2.01791134e-02f, 2.60812789e-01f, 2.38981489e-02f, 2.33565792e-02f, 1.20627142e-01f, -1.25921756e-01f, 1.06094122e-01f, 1.80652916e-01f, -2.30355859e-01f, -2.55723417e-01f,
  -2.72383511e-01f, 7.53617436e-02f, 5.44108152e-02f, -2.99499094e-01f, 2.28625331e-02f, -1.58390924e-01f, -1.29986227e-01f, -1.50208892e-02f, -1.89385414e-01f, 8.81662741e-02f,
  -4.77418229e-02f, 1.97872357e-03f, 5.34355566e-02f, 1.01690337e-01f, 1.41552895e-01f, 7.32358992e-02f, -1.32525355e-01f, -1.76431984e-01f, -1.22853339e-01f, -2.48619273e-01f,
  -2.05368727e-01f, 3.74203809e-02f, 2.47081220e-01f, -1.69028100e-02f, -9.37242806e-02f, -7.02387840e-02f, -7.37570971e-02f, -7.72331208e-02f, 1.67957658e-03f, -9.70917270e-02f,
  -1.13972537e-01f, 1.61773130e-01f, -3.25835794e-02f, 1.34717114e-02f, -5.39224893e-02f, 5.07211126e-02f, 6.13327399e-02f, -4.20154631e-02f, 7.18313530e-02f, -2.55627315e-02f,
  -1.30873844e-01f, -1.14206605e-01f, -7.15595707e-02f, 1.05415918e-01f, -7.57491216e-02f, 2.41761766e-02f, -5.45887090e-02f, -1.25138193e-01f, -1.74090452e-02f, 1.73080340e-02f,
  -4.34260666e-02f, 8.36079121e-02f, 1.12276293e-01f, -1.36812061e-01f, -7.40635255e-03f, -1.19969197e-01f, -4.97902110e-02f, -1.57073483e-01f, -1.27712190e-01f, 8.61219242e-02f,
  -4.06267196e-01f, -5.33102546e-03f, -1.09885193e-01f, -1.73518434e-01f, 1.16332471e-01f, -1.86227709e-01f, -4.32812870e-02f, -5.58503792e-02f, -5.09004779e-02f, -1.02421001e-01f,
  -1.39800282e-02f, -5.87456040e-02f, -4.95694391e-02f, -4.25921418e-02f, 2.60724902e-01f, 1.03518143e-01f, -2.14458525e-01f, 5.71873784e-02f, -1.91684127e-01f, -5.45105971e-02f,
  -6.31198511e-02f, 1.24919556e-01f, -1.40550341e-02f, 2.46497132e-02f, -1.26019508e-01f, 4.97270003e-02f, 4.56914641e-02f, 1.56435028e-01f, 1.04259431e-01f, 2.58448869e-01f,
  -4.55592602e-01f, -6.22600734e-01f, -1.03110254e+00f, -4.87625867e-01f, -4.31697339e-01f, -2.16713786e-01f, -5.77915847e-01f, 1.65713087e-01f, -6.69776229e-03f, -8.74063730e-01f,
  -2.67612815e-01f, 1.98329479e-01f, -3.06763262e-01f, -2.35570539e-02f, -3.54034305e-01f, -1.23675716e+00f, -1.01006496e+00f, -8.21497023e-01f, -2.71224380e-01f, -1.12217866e-01f,
  -4.02642667e-01f, -6.98159575e-01f, -2.75981337e-01f, -1.03874020e-01f, -3.02883625e-01f, -3.26635540e-01f, -7.95129716e-01f, -5.07098556e-01f, -4.86677855e-01f, -1.03943980e+00f,
  -4.86297697e-01f, 2.89643556e-01f, -1.90654695e-02f, 1.41652077e-01f, -1.06049120e-01f, 7.91003704e-02f, -4.96908799e-02f, -3.60894293e-01f, 1.94451347e-01f, -2.90460646e-01f,
  -1.45887092e-01f, 9.29266680e-03f, 3.88593413e-02f, 7.90441930e-02f, -2.01767366e-02f, -1.43858101e-02f, -4.59666960e-02f, -1.77891463e-01f, -3.69697094e-01f, -1.42499935e-02f,
  8.03188011e-02f, -5.09821847e-02f, 1.62112445e-01f, 1.51672632e-01f, 3.64134043e-01f, -2.54648328e-01f, -8.06786679e-03f, 3.16859931e-01f, -1.53101414e-01f, -4.63843346e-01f,
  -6.87894598e-02f, 8.68226513e-02f, 8.33577216e-02f, 6.74798340e-02f, 2.06448305e-02f, -6.88984841e-02f, 1.14388913e-01f, -6.20939694e-02f, -3.95331979e-02f, -1.37498215e-01f,
  1.08744048e-01f, -2.56868694e-02f, 1.13664061e-01f, 1.90430701e-01f, 2.57438254e-02f, -3.16132754e-01f, -1.13136843e-01f, -6.03695959e-02f, 1.25357226e-01f, -3.39104198e-02f,
  -6.85405880e-02f, -1.44211709e-01f, 4.74935025e-02f, -2.62226164e-02f, -4.06861939e-02f, -1.59006596e-01f, -4.23636660e-02f, 3.73130366e-02f, 1.44886136e-01f, -4.16088887e-02f,
  -1.84768617e-01f, -1.77174702e-01f, -4.51233655e-01f, 9.13491994e-02f, -2.44813919e-01f, -6.86840191e-02f, 9.35734250e-03f, 1.23340055e-01f, 2.17988715e-01f, -8.00551847e-02f,
  1.60575762e-01f, -1.31530613e-01f, -2.85276353e-01f, 1.11093685e-01f, 3.10934503e-02f, 2.38486767e-01f, -8.91750902e-02f, -3.16704690e-01f, -8.60963017e-02f, -6.49952143e-03f,
  -1.79514170e-01f, 4.13469300e-02f, 4.36454676e-02f, -1.31620720e-01f, 1.72921672e-01f, -1.51589915e-01f, -7.28816018e-02f, -3.35233957e-02f, -1.03066832e-01f, -4.33164656e-01f,
  -4.92725462e-01f, -6.98922694e-01f, 2.96045572e-01f, 5.08506060e-01f, 4.50123876e-01f, -4.44878340e-01f, -1.02856147e+00f, -7.47652709e-01f, 2.67965317e-01f, -3.70085001e-01f,
  -1.95917532e-01f, 4.51823831e-01f, 4.03105468e-01f, 2.98745006e-01f, -1.32715553e-01f, 9.60408896e-03f, 5.81333637e-01f, 4.07045484e-01f, 1.23808034e-01f, -3.91514271e-01f,
  2.31751248e-01f, 2.21367970e-01f, 1.99156001e-01f, 5.92146441e-02f, 2.10316539e-01f, 5.84118843e-01f, 2.30390027e-01f, 2.18200728e-01f, -7.34956712e-02f, 7.46156156e-01f,
  5.79490438e-02f, -6.58343673e-01f, 4.81159449e-01f, 3.35188359e-01f, 1.29817769e-01f, -3.09688389e-01f, -2.44327143e-01f, 4.36446592e-02f, 3.60932276e-02f, 1.03465289e-01f,
  3.61914039e-01f, -1.29574224e-01f, 2.10347772e-01f, 2.13139579e-01f, 3.22072171e-02f, -3.46958011e-01f, -1.46287680e-01f, -1.39702469e-01f, -1.35855064e-01f, -2.92615443e-01f,
  4.33211148e-01f, 9.06570703e-02f, -4.50431645e-01f, -2.96165943e-01f, -4.54557598e-01f, 4.81632233e-01f, -4.53432113e-01f, -2.21305624e-01f, -6.15700066e-01f, -3.71648461e-01f,
  1.35204300e-01f, -4.89440449e-02f, -5.56455143e-02f, 7.86320306e-03f, -5.86925149e-02f, -1.01774156e-01f, 4.38930430e-02f, 1.37756944e-01f, 8.04889947e-02f, -1.03851765e-01f,
  -4.32532979e-03f, -2.15517953e-02f, 3.29312943e-02f, 1.37935961e-02f, 1.38759986e-01f, -8.50476846e-02f, -9.76336002e-02f, 1.26513734e-03f, 6.89012855e-02f, -1.15963809e-01f,
  1.49842873e-01f, 5.41355014e-02f, 1.38790041e-01f, -3.52738947e-02f, -4.11925539e-02f, -4.95371036e-02f, 2.04164699e-01f, -1.41473472e-01f, -3.50527279e-02f, -4.53706905e-02f,
  -6.85142428e-02f, 1.14083134e-01f, -9.24020559e-02f, 3.70971523e-02f, 2.03123897e-01f, 2.72956453e-02f, 1.10366121e-01f, 1.14947855e-02f, -1.64022520e-01f, -1.64960383e-03f,
  -3.01252246e-01f, -2.05251455e-01f, -1.14914842e-01f, 7.71873770e-03f, -2.42546573e-02f, 2.24129315e-02f, 2.28220791e-01f, 5.81024885e-02f, -7.22635770e-03f, -6.18060566e-02f,
  3.24750319e-02f, -3.07625651e-01f, -5.52519500e-01f, -2.05894336e-01f, -6.43063337e-02f, -2.22956195e-01f, -3.39994371e-01f, -3.30433190e-01f, -7.11145163e-01f, -1.01338792e+00f,
  6.55862570e-01f, 3.44078094e-01f, -1.23942935e+00f, 1.65813997e-01f, -8.64395618e-01f, -6.68698907e-01f, -3.95621806e-01f, -1.91566616e-01f, 1.52993098e-01f, -1.04461335e-01f,
  -2.84088492e-01f, 1.89865366e-01f, 4.04267371e-01f, 1.17552197e-02f, -1.41461462e-01f, -3.22077185e-01f, -4.63751584e-01f, -2.22242266e-01f, -3.26220095e-01f, -3.39416176e-01f,
  -8.46258700e-02f, 2.98515171e-01f, 1.81713775e-01f, -7.10230544e-02f, 6.81875497e-02f, 1.35426745e-01f, -3.26534152e-01f, -2.61297315e-01f, -5.06571949e-01f, -4.34286326e-01f,
  -2.82675415e-01f, -4.58986372e-01f, -3.48012149e-01f, -1.64968371e-01f, 8.30643848e-02f, 1.07634068e-03f, 1.35263037e-02f, -2.97837973e-01f, -3.06145977e-02f, -7.85504729e-02f,
  -2.30084822e-01f, -3.18037480e-01f, -2.82534391e-01f, -1.02081113e-01f, -1.56863838e-01f, -3.79005889e-03f, -1.51860118e-01f, -2.47114480e-01f, -1.32910639e-01f, -1.53711110e-01f,
  -1.33638039e-01f, -3.54227960e-01f, -1.39359608e-01f, 5.63758835e-02f, 2.90752458e-03f, 4.35632765e-02f, -1.05974739e-02f, -2.81885147e-01f, -3.83107603e-01f, 1.10204980e-01f,
  -5.99211194e-02f, -2.87447125e-02f, 5.80404550e-02f, 1.05845787e-01f, 2.26816997e-01f, 1.56302497e-01f, -4.24270444e-02f, 1.08172491e-01f, -1.19720355e-01f, 1.84162408e-01f,
  -1.23524062e-01f, 7.10846260e-02f, 1.56697348e-01f, 3.60994004e-02f, -5.87203503e-02f, -1.28777072e-01f, 9.36262235e-02f, 1.08319573e-01f, -1.32797822e-01f, 1.46270338e-02f,
  1.95734389e-02f, -2.09829912e-01f, 2.39192676e-02f, 7.56037608e-02f, -2.41948202e-01f, -1.52125224e-01f, -8.81293491e-02f, -3.46776396e-02f, 1.08036481e-01f, -1.55108348e-01f,
  7.76629925e-01f, -3.99423718e-01f, 4.77581173e-01f, -4.10696752e-02f, -1.64299220e-01f, 1.05092861e-01f, 4.00934547e-01f, -2.96737179e-02f, 1.60196215e-01f, 8.83916542e-02f,
  -3.11672658e-01f, 2.20024675e-01f, -1.27457781e-02f, -9.22657847e-02f, -1.25218689e-01f, -9.60660074e-03f, -5.51612824e-02f, -7.66301900e-02f, -9.76465568e-02f, 3.10556367e-02f,
  1.01835765e-01f, 9.84090939e-03f, 2.68215716e-01f, 2.84150690e-01f, 1.00590929e-01f, 1.41635284e-01f, 3.54734093e-01f, 1.18941307e-01f, 8.58467221e-02f, 7.17748284e-01f,
  -1.01602876e+00f, 4.89339948e-01f, 3.18825990e-01f, -3.55592310e-01f, -2.90711373e-01f, -3.79308075e-01f, 1.76182479e-01f, -1.36469275e-01f, -3.21776837e-01f, 4.26449776e-01f,
  1.61340892e-01f, -1.63655847e-01f, 1.10198542e-01f, 1.02943080e-02f, -3.96022618e-01f, 2.14428589e-01f, -2.23697260e-01f, -4.99956608e-01f, -6.15850687e-01f, -3.92392159e-01f,
  -1.53510496e-01f, -2.78575182e-01f, -5.35807788e-01f, -3.63196105e-01f, -6.20836671e-03f, -7.87568986e-02f, 2.33029127e-01f, -1.05920039e-01f, -1.14811599e-01f, 1.29546866e-01f,
  2.48922482e-01f, -3.24949056e-01f, -2.39465684e-02f, -1.96154982e-01f, 9.14940685e-02f, 1.20174736e-02f, -6.56178072e-02f, -1.80400703e-02f, -1.85497757e-02f, -2.14212686e-02f,
  -1.15853831e-01f, -1.42091990e-01f, -1.47380397e-01f, 1.18771166e-01f, -1.19705290e-01f, 1.37255073e-01f, 1.22675583e-01f, -5.26720583e-02f, 5.73672876e-02f, 5.87038025e-02f,
  1.11351766e-01f, -1.41057417e-01f, -5.43323532e-02f, 1.46834224e-01f, -6.21958934e-02f, -1.62004903e-01f, 7.23457038e-02f, -2.88960859e-02f, -9.54521969e-02f, 5.48315406e-01f,
  1.35682195e-01f, 2.72576094e-01f, 6.46399632e-02f, -4.02285531e-03f, 7.13037625e-02f, 2.76342910e-02f, 8.96854699e-03f, 1.18955582e-01f, 1.38474787e-02f, 1.25749394e-01f,
  1.33824036e-01f, -8.90576397e-04f, 5.36856912e-02f, 1.45286635e-01f, 7.99885616e-02f, -1.76095068e-01f, -7.22275078e-02f, 5.74000971e-03f, -1.72275491e-02f, 2.02781092e-02f,
  -1.05164923e-01f, -1.02532730e-01f, -1.37857776e-02f, -1.80646591e-02f, -7.77586475e-02f, -4.35317308e-02f, -8.92366171e-02f, -1.01407491e-01f, 1.04250379e-01f, -1.77394301e-01f,
  3.11623871e-01f, -2.38582939e-01f, -1.39470666e-03f, 9.40205082e-02f, -1.13806225e-01f, 6.33264929e-02f, -1.08386949e-01f, -5.14816456e-02f, -1.16261505e-01f, 5.76399677e-02f,
  -1.45233437e-01f, -7.73240402e-02f, 6.51730299e-02f, 1.65328428e-01f, 8.14843625e-02f, 7.41330758e-02f, 3.57689522e-02f, 7.22879320e-02f, -9.04940888e-02f, -4.43821251e-02f,
  -1.96429715e-02f, 1.59296528e-01f, 1.72473490e-01f, 1.66262239e-01f, 7.46418685e-02f, -1.41747266e-01f, 1.23621389e-01f, 1.10838942e-01f, -8.88937786e-02f, 6.70207381e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.14705545e-01f, 1.01353312e+00f, 8.01909268e-01f, 1.10818052e+00f, 7.07499802e-01f, 6.99049711e-01f, 1.02619827e-01f, 1.03650224e+00f, 9.68811572e-01f, 6.19329274e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.75627656e-02f, 2.13095993e-01f, -2.93999631e-02f, 3.08166116e-01f, -1.67276524e-03f, -1.09389111e-01f, 3.04715950e-02f, 1.40180215e-01f, -1.37444168e-01f, 3.05788040e-01f,
  -7.65479267e-01f, 2.87101299e-01f, -1.90932274e-01f, -2.99500167e-01f, 3.09211705e-02f, 4.10930753e-01f, -1.59230232e-01f, -5.16846068e-02f, 2.79872436e-02f, -7.89724365e-02f,
  1.17062747e-01f, 4.23865259e-01f, 7.80863225e-01f, -4.36149240e-01f, 1.41932905e-01f, 1.35048032e-01f, -7.77901173e-01f, -2.07989812e-01f, -2.86472235e-02f, 3.97145823e-02f,
  2.62202062e-02f, 5.40043294e-01f, 1.97504520e-01f, -1.19283013e-01f, 1.94664463e-01f, -3.41063350e-01f, -1.39619978e-02f, -1.26938149e-01f, -2.01565281e-01f, 1.71284303e-01f,
  9.30949897e-02f, -2.67949969e-01f, 2.37253621e-01f, -4.05614465e-01f, -1.77639478e-04f, 4.15544540e-01f, 2.96021372e-01f, -4.16387692e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.03146419e-01f, 4.19630855e-01f, 4.08393443e-01f, 1.74634025e-01f, 4.11512852e-01f, -2.41244599e-01f, 6.77412599e-02f, 1.00794303e+00f, 1.02124524e+00f, -5.42926848e-01f,
  1.11510389e-01f, 1.90441862e-01f, 8.19007754e-01f, -3.50398034e-01f, -2.04236269e-01f, 3.07891220e-01f, 3.92347425e-01f, 1.19257569e-01f, -4.08546746e-01f, 2.84544319e-01f,
  -1.43997461e-01f, 2.71879852e-01f, 1.29718697e+00f, -1.09218895e+00f, 4.13530916e-01f, 5.43721616e-01f, 8.60445321e-01f, -4.62657988e-01f, 7.53924072e-01f, 3.20586115e-01f,
  -1.61001608e-01f, -9.94611144e-01f, 7.97432184e-01f, 2.33779177e-01f, -2.09446445e-01f, 1.94659501e-01f, -7.40133584e-01f, -4.98593152e-01f, -6.71781421e-01f, 1.02019811e+00f,
  4.93608177e-01f, -1.01445474e-01f, 5.12316860e-02f, 1.09332955e+00f, 2.23407343e-01f, 5.01648247e-01f, 8.81833375e-01f, -6.92937970e-01f, 1.22205891e-01f, 3.41888070e-01f,
  1.18883312e-01f, -1.81180909e-02f, 2.95476485e-02f, -6.93125844e-01f, 1.32693613e+00f, 1.25227773e+00f, 3.22115660e-01f, 6.43055975e-01f, -4.84157711e-01f, -6.20654523e-01f,
  5.37927866e-01f, 6.25834942e-01f, -7.44830608e-01f, -1.36020347e-01f, 5.89103639e-01f, 4.71055984e-01f, 5.43670535e-01f, 4.25519317e-01f, 2.31360868e-01f, 4.02799755e-01f,
  1.38837051e+00f, -6.03066050e-02f, -3.27020854e-01f, 4.72155571e-01f, -2.82202035e-01f, 1.07055974e+00f, -6.73834443e-01f, 2.85670131e-01f, 7.12767303e-01f, 5.61554432e-01f,
  7.27687359e-01f, 3.96966040e-01f, 1.09902382e+00f, -1.17121434e+00f, -4.53066975e-01f, 2.88197875e-01f, -9.01946127e-01f, 5.71275413e-01f, -4.19880360e-01f, 3.63906503e-01f,
  1.20460443e-01f, 3.49296272e-01f, -2.00527743e-01f, 8.54135990e-01f, 5.23261428e-01f, 3.94474983e-01f, 3.79280388e-01f, -9.36018601e-02f, 1.47996724e-01f, 2.77987450e-01f,
  1.31786704e-01f, -2.17277527e-01f, 1.00956810e+00f, -8.09647664e-02f, -2.86306649e-01f, 1.36208534e+00f, -1.42254829e+00f, -2.29595587e-01f, 3.49076182e-01f, 7.71373868e-01f,
  -6.45168051e-02f, 1.36606348e+00f, 4.09510791e-01f, 1.12812050e-01f, 2.78306842e-01f, -3.18069667e-01f, -1.58803716e-01f, 4.36011016e-01f, -1.44540712e-01f, -1.20270073e+00f,
  -2.24983171e-01f, 2.20999226e-01f, -8.83816481e-02f, -9.13833439e-01f, 8.88176978e-01f, -4.96746838e-01f, 1.31921601e+00f, 4.07231003e-01f, 3.90786171e-01f, 3.04817289e-01f,
  -6.86697736e-02f, 1.87532604e-01f, 1.88247710e-02f, 1.45520717e-01f, -4.73426670e-01f, -8.85475695e-01f, 4.66456532e-01f, 1.93801597e-01f, -4.56226379e-01f, 7.77673781e-01f,
  1.33428067e-01f, 6.09580100e-01f, 1.08050847e+00f, -2.19828516e-01f, 3.18748057e-01f, 3.69884908e-01f, 7.85404325e-01f, -9.80269969e-01f, 2.19263360e-01f, 5.68464875e-01f,
  4.55011696e-01f, -3.54218394e-01f, 2.00742498e-01f, -4.52939719e-01f, 7.77272165e-01f, 4.70730543e-01f, 4.39899534e-01f, 1.00116527e+00f, 4.87548858e-01f, -6.76652670e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.57061964e-01f, -1.59705449e-02f, 2.88348868e-02f, 8.82461846e-01f, 1.92735508e-01f, 2.40894586e-01f, -8.77083465e-02f, 1.52847514e-01f, -3.36510837e-02f, 1.94389254e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -3.12710941e-01f, -8.51882398e-01f, 2.71209240e-01f, 6.42132759e-02f, 1.63661186e-02f, -3.97806823e-01f, -2.30704919e-01f, 7.30718374e-01f, -6.29805028e-01f, -1.92531437e-01f,
  -1.09643221e+00f, -4.66654778e-01f, -8.66868645e-02f, 4.79091883e-01f, 2.92471290e-01f, 3.08649898e-01f, -1.05552781e+00f, -3.62483025e-01f, -5.10725558e-01f, 1.53307959e-01f,
  -6.35505795e-01f, -6.43808991e-02f, 2.26149321e-01f, 6.83413148e-01f, 2.21317247e-01f, -7.98705578e-01f, -5.85436881e-01f, -1.61562979e-01f, -1.61593139e+00f, 6.16909266e-01f,
  1.47773057e-01f, 3.59094650e-01f, -5.94399273e-01f, -2.75597006e-01f, 2.19468012e-01f, -4.00304735e-01f, 6.35592759e-01f, 3.36372018e-01f, -1.01662064e+00f, 4.12243813e-01f,
  -8.30785751e-01f, 1.73954815e-01f, 2.47996062e-01f, 3.40816200e-01f, -6.79799542e-02f, -8.90960813e-01f, -6.33359015e-01f, 3.43996108e-01f, -4.67032164e-01f, -7.85049438e-01f,
  -9.05117914e-02f, 8.02000046e-01f, 7.77860820e-01f, -1.42297518e+00f, 2.88974345e-01f, 4.66570221e-02f, -1.35997975e+00f, 6.69951916e-01f, -2.30901957e-01f, -1.20610535e+00f,
  6.01780236e-01f, -9.74330027e-03f, -9.53012288e-01f, -1.09327149e+00f, -2.10843593e-01f, 5.13382673e-01f, 3.86460721e-01f, 5.08922517e-01f, 9.12797034e-01f, 8.94260287e-01f,
  5.44918597e-01f, 1.97769608e-02f, -1.22338928e-01f, -1.52871624e-01f, -4.21053082e-01f, 4.08937812e-01f, 4.39029694e-01f, -8.99301395e-02f, -5.69547191e-02f, -5.96006691e-01f,
  7.72144020e-01f, 8.75407517e-01f, -1.86355203e-01f, -3.39419067e-01f, 1.06551731e+00f, 8.42538238e-01f, 2.13934168e-01f, -7.23844588e-01f, -8.39822143e-02f, -7.66636610e-01f,
  7.52472505e-02f, 2.50569105e-01f, -4.25571918e-01f, 4.63839322e-01f, 6.42566621e-01f, 1.46411404e-01f, -1.25035599e-01f, -1.71349183e-01f, -7.23264337e-01f, -1.17677796e+00f,
  -6.46611810e-01f, 3.87734845e-02f, 6.08185709e-01f, -5.06065667e-01f, 9.07164160e-03f, 1.71892926e-01f, -1.23550475e+00f, 6.22628748e-01f, -1.39774311e+00f, -6.54825807e-01f,
  -1.12973738e+00f, 1.72367826e-01f, -3.27584594e-02f, 3.56395692e-01f, -2.40647003e-01f, -5.61791241e-01f, 4.26206261e-01f, 1.09283432e-01f, 1.95603639e-01f, 1.58772007e-01f,
  1.34398594e-01f, 3.76810461e-01f, 1.00562796e-01f, -1.34745347e+00f, -1.43381476e-01f, -3.28684390e-01f, -1.68709069e-01f, 7.12301135e-02f, 4.31180358e-01f, -3.57521713e-01f,
  5.48422158e-01f, -2.37013429e-01f, -5.02212942e-01f, -6.47629917e-01f, -3.11818182e-01f, -1.19729388e+00f, 3.15757573e-01f, -9.24769461e-01f, 8.64775956e-01f, 4.10837799e-01f,
  -8.99814606e-01f, -1.22285628e+00f, 1.58937469e-01f, 3.58654708e-01f, 4.79237735e-01f, 4.10620362e-01f, 1.41999304e-01f, 6.73293769e-02f, -1.04844594e+00f, 1.82284355e-01f,
  -9.73295093e-01f, -8.48956347e-01f, 3.70910674e-01f, 4.58466500e-01f, -7.94850349e-01f, 6.46547377e-01f, 1.72877833e-01f, -7.34204590e-01f, 1.62357852e-01f, -2.03165442e-01f,
  -1.04008007e+00f, -4.96397674e-01f, -1.37979597e-01f, 5.78567386e-01f, 1.59916103e-01f, -4.17556703e-01f, -1.10079658e+00f, -6.21012211e-01f, -1.24962234e+00f, -7.82387197e-01f,
  8.68759573e-01f, 1.40564814e-01f, 3.41499180e-01f, 3.88495147e-01f, 6.32574737e-01f, -1.60164082e+00f, 4.75555569e-01f, -2.02950820e-01f, 7.72149444e-01f, 1.43162239e+00f,
  -7.14326799e-01f, -3.24965894e-01f, 5.40137768e-01f, -1.28559303e+00f, 6.21934235e-01f, 7.90365711e-02f, 1.33465007e-01f, -9.53868330e-01f, -7.90245354e-01f, -1.92739084e-01f,
  -7.62112662e-02f, -8.97014558e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.75260025e-01f, -4.94185716e-01f, 2.68261191e-02f, -2.06450731e-01f, -5.38578350e-03f, 3.85636091e-01f, 2.69662261e-01f, 8.76041204e-02f, 7.67859370e-02f, 5.82369715e-02f,
  -6.40051737e-02f, 1.26600891e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    