/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.85378408e-02f, 2.07696855e-01f, 3.06072980e-01f, 4.95638549e-02f, -9.14031733e-03f, 2.41853315e-02f, 2.39517868e-01f, 2.25937292e-02f, 3.52618545e-01f, -2.11103737e-01f,
  -9.74690728e-03f, 5.88316508e-02f, 1.68183878e-01f, -9.35443416e-02f, -1.99858606e-01f, 1.54464200e-01f, -9.49074402e-02f, 3.13721634e-02f, 1.79388806e-01f, -8.16773027e-02f,
  -1.66321807e-02f, -3.15267324e-01f, 9.61563215e-02f, -1.22724459e-01f, -7.48680606e-02f, 5.39912842e-02f, -4.88098800e-01f, 1.52946711e-01f, -2.68061787e-01f, -4.89227325e-02f,
  1.77195147e-01f, 1.04060702e-01f, 9.11581069e-02f, 5.51468842e-02f, -5.82505986e-02f, -2.86339093e-02f, -1.28348162e-02f, 5.69284484e-02f, 1.51326016e-01f, 4.17145528e-02f,
  -5.91641255e-02f, -1.16254054e-01f, -7.88794179e-03f, -1.44203687e-02f, 2.51575299e-02f, 1.13266762e-02f, 1.44150965e-02f, 5.65170869e-02f, 1.49118528e-03f, 7.04052597e-02f,
  9.35353711e-02f, 2.29462776e-02f, -4.74154428e-02f, -7.84097835e-02f, 6.60114223e-03f, 7.29648545e-02f, 3.96185322e-03f, 8.10980704e-03f, -5.05031832e-03f, 4.75506112e-03f,
  -4.08998579e-02f, 3.33884507e-02f, 3.02798618e-02f, 2.14726254e-02f, -1.66972335e-02f, 2.99442559e-02f, -2.54453141e-02f, -6.38546273e-02f, -6.40418567e-03f, -2.40470488e-02f,
  -6.10344335e-02f, 4.11671698e-02f, 4.49102838e-03f, 6.36783391e-02f, -8.65522996e-02f, 2.02045385e-02f, -4.92336899e-02f, 1.68061368e-02f, -4.98793181e-03f, 3.55424546e-02f,
  -1.31785236e-02f, 3.21330242e-02f, 2.61206701e-02f, 1.23888664e-02f, 8.29071254e-02f, 2.32610460e-02f, -3.82111706e-02f, 3.47211845e-02f, 1.08511262e-01f, -7.59958327e-02f,
  -1.02670901e-01f, -3.19252193e-01f, 6.59455732e-02f, -5.03429677e-03f, 7.33015090e-02f, -6.23159371e-02f, -1.13687320e-02f, -5.84002435e-02f, -1.71029232e-02f, -7.02354014e-02f,
  -7.09208250e-02f, 5.77100851e-02f, -1.02044813e-01f, -3.04303854e-03f, 9.01207514e-03f, -2.79402379e-02f, -3.23055089e-02f, -8.54428783e-02f, -1.14647366e-01f, -8.79237875e-02f,
  -9.14065912e-02f, -6.31777123e-02f, -5.18610440e-02f, -5.29731959e-02f, -8.43145773e-02f, -4.87208068e-02f, 2.07956750e-02f, 7.85281584e-02f, -9.12674889e-02f, -5.93893230e-03f,
  -1.89360291e-01f, -5.45402877e-02f, 6.19026795e-02f, -2.31097937e-01f, 2.62494594e-01f, -5.04740961e-02f, -3.55973423e-01f, 1.27632588e-01f, -1.13897715e-02f, -6.53879717e-02f,
  -1.67057231e-01f, -1.64655715e-01f, -8.79387930e-02f, -3.15928966e-01f, -3.76367748e-01f, -1.71301976e-01f, -2.88370907e-01f, -2.13344991e-01f, 4.44979593e-02f, -9.69661549e-02f,
  -5.84362932e-02f, -1.01110153e-01f, -1.31674837e-02f, 2.89355338e-01f, 5.39384335e-02f, 2.40191534e-01f, 7.76903192e-03f, 1.29802629e-01f, 3.41130495e-02f, 1.25534432e-02f,
  -8.56859013e-02f, -1.56965002e-01f, 4.97398712e-02f, 8.87976065e-02f, -7.53414407e-02f, 3.69074056e-03f, -4.17239964e-02f, 7.04322159e-02f, 4.24496271e-02f, 5.98072484e-02f,
  5.08142747e-02f, 5.37064038e-02f, -6.27504336e-03f, 6.30899221e-02f, 5.01098260e-02f, 6.86704218e-02f, 8.99019614e-02f, 8.44625384e-02f, 6.29845262e-02f, -1.57224888e-03f,
  3.44855785e-02f, 6.15544524e-03f, -3.96948569e-02f, -2.77900137e-02f, 4.04610559e-02f, -3.70939299e-02f, 4.61360924e-02f, -3.93375270e-02f, 1.62487328e-02f, 6.30878890e-03f,
  2.19624420e-03f, -4.51397076e-02f, -1.03021758e-02f, 1.15225492e-02f, -3.27561796e-02f, 1.75067857e-02f, 2.08113566e-02f, -1.37966303e-02f, 1.54713243e-02f, -6.60772696e-02f,
  -6.70773908e-03f, -2.02512071e-02f, -2.49072071e-03f, 3.68087515e-02f, -6.11664578e-02f, -7.97266327e-03f, 4.86326497e-03f, 2.48420276e-02f, 2.30457503e-02f, 2.57888939e-02f,
  1.81085356e-02f, -5.68323284e-02f, -2.18105447e-02f, 3.21483873e-02f, -1.74062867e-02f, -8.33823360e-05f, 7.87037313e-02f, 7.16248006e-02f, -2.51842551e-02f, 8.24063364e-03f,
  -2.22148895e-01f, -2.65949309e-01f, -1.13069983e-02f, 1.78598464e-02f, -2.31760163e-02f, 4.34410246e-03f, 1.29438872e-02f, 6.05935007e-02f, -4.09819745e-02f, 1.69266015e-02f,
  -7.91486166e-03f, 3.70345749e-02f, 2.59452476e-03f, -3.97797115e-03f, -3.66439708e-02f, -2.34075747e-02f, -1.16673395e-01f, -1.07235156e-01f, -1.06424496e-01f, 2.26450828e-03f,
  -3.34371775e-02f, 3.79914641e-02f, 5.45547195e-02f, 2.83632521e-02f, 1.87292732e-02f, 1.06415460e-02f, -2.00861394e-02f, 5.95366992e-02f, 7.59799331e-02f, 1.90935694e-02f,
  -1.59777492e-01f, -7.07165524e-02f, -4.95122708e-02f, -2.31255308e-01f, -1.54449999e-01f, 3.57437879e-01f, 5.78907192e-01f, -2.13419050e-01f, -7.26864338e-02f, 1.97574437e-01f,
  6.14407733e-02f, -2.69053221e-01f, 3.83567423e-01f, -2.04613626e-01f, 1.45180188e-02f, 2.72363037e-01f, 2.61858255e-02f, 5.08736968e-02f, -7.95282051e-02f, -2.16359627e-02f,
  -8.83275643e-02f, -1.50675597e-02f, -4.42378409e-03f, -1.49487987e-01f, -1.02562919e-01f, -1.96325913e-01f, -1.05675764e-01f, 7.01465011e-02f, -1.95478663e-01f, -8.70533660e-02f,
  4.86652777e-02f, 3.35194021e-02f, -1.42158091e-01f, -2.62006540e-02f, 1.07968366e-02f, -2.89340448e-02f, 1.24226641e-02f, 4.28659581e-02f, -2.08909996e-02f, -1.17871575e-02f,
  1.47715611e-02f, -4.91583347e-02f, -5.17360829e-02f, -3.68518233e-02f, -8.02578311e-03f, -8.67132172e-02f, -2.65892167e-02f, 1.20546995e-02f, -6.57939985e-02f, -1.58644561e-02f,
  5.18798754e-02f, 9.00498591e-03f, 9.97003168e-03f, -1.85597204e-02f, -2.21045967e-02f, -1.16582308e-02f, 2.35396009e-02f, 1.00709442e-02f, 5.63988648e-03f, -8.14828500e-02f,
  3.50010209e-03f, -5.50813563e-02f, 4.96307807e-03f, -5.96769191e-02f, -1.35768000e-02f, -6.71535134e-02f, 4.13903818e-02f, -6.20965008e-03f, 2.45581637e-03f, 6.72026798e-02f,
  -2.13791933e-02f, -5.00673205e-02f, -3.36060934e-02f, 2.66478397e-03f, -9.60884336e-03f, -1.69985164e-02f, 3.81885171e-02f, -5.46001978e-02f, 2.78170537e-02f, -7.43258372e-02f,
  9.82226193e-05f, 4.42324148e-04f, -4.29210626e-03f, 7.06452578e-02f, 4.70794961e-02f, -4.57934337e-03f, -2.37598792e-02f, -1.24581531e-02f, 2.94317845e-02f, 5.97942062e-02f,
  1.46576881e-01f, 3.66676017e-03f, 6.60746396e-02f, -6.07287558e-03f, 6.23313673e-02f, -2.68109143e-02f, -1.94134675e-02f, -4.44915146e-02f, 1.57829467e-02f, 2.30498575e-02f,
  1.48912380e-02f, 4.71074991e-02f, -5.72860334e-03f, -1.93399321e-02f, 2.93718390e-02f, 5.52070253e-02f, 5.85392118e-02f, 1.87422801e-02f, 3.44736688e-02f, -8.98125023e-02f,
  -6.64046872e-03f, 5.15158698e-02f, 3.55444513e-02f, 7.50425532e-02f, 1.43369893e-02f, 7.34089091e-02f, -8.73785764e-02f, -7.11300469e-04f, 1.49762407e-02f, -5.32160979e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.16251214e-02f, 4.03478861e-01f, 2.00002193e-01f, 1.70316577e-01f, -1.36622012e-01f, -1.36569813e-01f, 1.49159327e-01f, -4.95405495e-02f, 6.44271672e-02f, 2.89898247e-01f,
  4.19024145e-03f, 3.71197224e-01f, 1.28819076e-02f, 6.25086129e-02f, -3.56077373e-01f, -2.01814950e-01f, -1.00337099e-02f, 1.57447189e-01f, -2.53078230e-02f, 2.14981273e-01f,
  -9.92210358e-02f, 2.29241438e-02f, -7.94561729e-02f, -2.85555404e-02f, 4.85960059e-02f, 1.40172780e-01f, -1.00118741e-01f, 7.13459849e-02f, 5.90240508e-02f, -7.05296248e-02f,
  -4.68289331e-02f, 1.00513056e-01f, 2.59584319e-02f, -1.68731753e-02f, -1.72002334e-02f, -1.77079197e-02f, -7.23085087e-03f, 4.71093468e-02f, -2.10425276e-02f, 5.01819216e-02f,
  1.87886268e-01f, 5.19613363e-02f, -6.41152561e-02f, -2.93233618e-02f, -1.34741105e-02f, -4.06771451e-02f, -5.92223965e-02f, -4.25510071e-02f, 1.34491399e-01f, -4.98664230e-02f,
  1.31600425e-01f, 1.46803325e-02f, 4.72623445e-02f, 5.43931015e-02f, 4.86221239e-02f, 3.05616166e-02f, -1.62806436e-02f, 1.31584499e-02f, 1.57317474e-01f, 5.59298582e-02f,
  1.06604569e-01f, -3.00939474e-02f, -5.99964987e-03f, 5.95579529e-03f, -2.65579391e-03f, -1.01272101e-02f, -8.14455673e-02f, -7.55463988e-02f, 8.70927945e-02f, -1.49459438e-02f,
  -1.29338522e-02f, 6.81863800e-02f, -7.04557374e-02f, 1.01512954e-01f, 3.30272433e-03f, -5.52859791e-02f, 2.66390096e-04f, 1.27909273e-01f, -1.75124332e-02f, 9.81544051e-03f,
  3.90598662e-02f, 5.53077422e-02f, 7.01175556e-02f, -5.36147356e-02f, -3.31720486e-02f, -6.63463026e-02f, -3.67699862e-02f, 8.35332051e-02f, -9.35603529e-02f, -7.17281327e-02f,
  1.29395232e-01f, 1.82290301e-01f, 5.21200113e-02f, 3.94820496e-02f, -3.74749005e-02f, -1.44672478e-02f, 2.71252804e-02f, -3.11637241e-02f, 6.91654608e-02f, -4.96839881e-02f,
  7.44319409e-02f, -5.05485088e-02f, 7.33099803e-02f, -8.19445625e-02f, 2.88227443e-02f, -6.80843368e-02f, -4.25437279e-02f, -9.96059622e-04f, 8.73044431e-02f, -3.30014490e-02f,
  5.78659847e-02f, 1.83009394e-02f, 2.81088781e-02f, 4.91353385e-02f, -1.64363515e-02f, 5.07865138e-02f, 5.65989390e-02f, -1.72220059e-02f, 5.19466363e-02f, 6.75009862e-02f,
  -9.45044398e-01f, 4.78039891e-01f, 2.67572477e-02f, -1.48422301e-01f, -1.91008076e-01f, 3.41975763e-02f, 4.98921424e-03f, -8.77809431e-03f, -9.71386880e-02f, 4.41567838e-01f,
  1.78659827e-01f, -2.51734525e-01f, 3.44552457e-01f, 3.71277094e-01f, -3.67127031e-01f, 4.01454657e-01f, 7.86250159e-02f, -2.62627639e-02f, 1.24024786e-01f, -1.97861135e-01f,
  -8.41488093e-02f, 6.73322305e-02f, 2.49549195e-01f, 1.70716405e-01f, -8.85779783e-02f, -1.18767373e-01f, -1.48837537e-01f, 1.05929002e-01f, -9.12219007e-03f, 2.42976379e-03f,
  -2.81792134e-01f, -2.67425776e-01f, -8.54132399e-02f, -8.32785368e-02f, -1.66848436e-01f, -1.07675985e-01f, -9.76854712e-02f, 1.62389278e-02f, -4.08754312e-02f, -5.84568717e-02f,
  -1.39182135e-01f, -6.23210259e-02f, 5.36415493e-03f, 2.56533269e-03f, -6.65485933e-02f, 5.13115861e-02f, 1.11602098e-02f, 4.27291282e-02f, 3.48064229e-02f, -6.98633492e-03f,
  4.82210964e-02f, 2.40425840e-02f, 2.51290035e-02f, 1.02034487e-01f, -4.31298763e-02f, 3.67302671e-02f, 3.17528099e-03f, -2.87648905e-02f, -4.88469638e-02f, -1.01545542e-01f,
  -9.56677552e-03f, -1.09351724e-02f, 1.91726238e-02f, -5.31037860e-02f, 3.09987739e-03f, 2.76015326e-02f, -1.54830832e-02f, -1.42493239e-02f, -3.64577696e-02f, 5.25048040e-02f,
  -2.10165232e-02f, -6.86772466e-02f, -3.29585560e-02f, 3.47273871e-02f, 2.42590755e-02f, -3.68648879e-02f, -5.09520918e-02f, -3.75031456e-02f, 1.27413617e-02f, 7.49024525e-02f,
  3.82550694e-02f, -4.07626405e-02f, 1.27752917e-02f, 4.67021838e-02f, -2.60070674e-02f, 1.07829627e-02f, -3.52159813e-02f, 2.92989854e-02f, 1.85814165e-02f, -1.21514723e-01f,
  -3.21642429e-01f, -3.71226907e-01f, -2.31456514e-02f, -9.43531692e-02f, -2.20651980e-02f, -5.57907112e-02f, 3.84200625e-02f, -5.73198982e-02f, -7.70091340e-02f, -1.00587673e-01f,
  -6.43239990e-02f, -3.93418185e-02f, -7.92878643e-02f, 5.02252951e-02f, 3.13565060e-02f, -4.01958413e-02f, -3.81737612e-02f, -8.57905746e-02f, -1.56357184e-01f, -9.01203696e-03f,
  -5.92927225e-02f, -7.62822926e-02f, 4.91871387e-02f, -9.14632436e-03f, -5.39934374e-02f, -6.33147731e-02f, -1.17486916e-01f, -3.92199308e-03f, -4.47258390e-02f, 4.86706868e-02f,
  -2.04761893e-01f, -8.11095238e-02f, -1.90542042e-01f, -1.86207563e-01f, 3.31905335e-01f, 1.46593213e-01f, -3.32957250e-03f, 1.88881010e-01f, 1.72676034e-02f, 1.80710107e-01f,
  9.98332277e-02f, -1.70710504e-01f, -9.51415151e-02f, -2.77154624e-01f, -3.07216406e-01f, -1.59422889e-01f, -1.38868526e-01f, -7.93281496e-02f, -1.17086291e-01f, 6.88136593e-02f,
  -1.22630276e-01f, -4.28002663e-02f, -2.77263373e-01f, 8.19884539e-02f, 6.11788891e-02f, 1.20265171e-01f, 2.15916470e-01f, 5.16788214e-02f, -6.11155033e-02f, -7.40522891e-02f,
  -8.74840170e-02f, -3.49503234e-02f, 6.68726936e-02f, -7.38427490e-02f, 1.98300686e-02f, 1.16724409e-01f, 5.11957221e-02f, -8.13242048e-02f, 2.77257618e-02f, -4.25685868e-02f,
  1.95034891e-02f, -8.17694664e-02f, -3.96180041e-02f, 2.22877711e-02f, -1.65404491e-02f, -1.05824275e-03f, -4.11554128e-02f, 3.28730568e-02f, 2.05310117e-02f, -7.00947344e-02f,
  -1.11765631e-01f, -5.05451895e-02f, 4.56595346e-02f, -1.07770592e-01f, -7.13707730e-02f, 1.03826299e-01f, 4.80240174e-02f, -7.73216933e-02f, -1.39151029e-02f, 1.96322631e-02f,
  2.26601139e-02f, 2.27057859e-02f, 3.45837772e-02f, -9.05122459e-02f, 4.19003284e-03f, 7.64363930e-02f, -6.52563274e-02f, 4.48894016e-02f, -3.28466855e-02f, 2.15727892e-02f,
  9.39702913e-02f, -4.80755381e-02f, 5.37171923e-02f, 3.28529887e-02f, -2.20941426e-03f, 4.86230478e-02f, -5.27299009e-02f, 7.24607110e-02f, 7.69299082e-03f, -4.02488783e-02f,
  5.53909093e-02f, 6.99570403e-03f, -3.14096734e-03f, 9.91304591e-02f, -5.65060787e-02f, 2.91011538e-02f, 2.31547169e-02f, -3.08139995e-02f, -5.59578463e-02f, 2.27439944e-02f,
  1.11554846e-01f, 7.39302486e-02f, -4.80183698e-02f, -6.00806400e-02f, 8.54567662e-02f, 8.80872309e-02f, -2.95985006e-02f, 4.63022739e-02f, 5.63386492e-02f, -4.47073765e-02f,
  1.28281191e-01f, 7.85331279e-02f, 6.59576729e-02f, -7.28099495e-02f, -2.36365795e-02f, 1.17339626e-01f, -2.82329135e-02f, -4.49343398e-02f, 3.18387598e-02f, -7.51412706e-03f,
  6.21849559e-02f, -3.34185250e-02f, -2.14240216e-02f, 5.11396639e-02f, 7.00036585e-02f, 5.13541065e-02f, 4.59571406e-02f, 6.23381324e-02f, 6.71859160e-02f, -6.89900666e-02f,
  4.63113002e-02f, 3.34907442e-01f, -3.68358567e-02f, -6.93320185e-02f, -1.25784650e-01f, -5.38389921e-01f, -3.85774046e-01f, -4.00742404e-02f, 4.44206685e-01f, 1.55648127e-01f,
  -1.95293024e-01f, 3.95525992e-01f, 1.32282451e-01f, -1.95697427e-01f, -3.14255446e-01f, 1.11522995e-01f, -4.04585510e-01f, -1.56165123e-01f, 2.06738770e-01f, -1.87809289e-01f,
  -9.98093560e-02f, -2.73484498e-01f, -2.08840221e-01f, -1.26791194e-01f, -2.69120723e-01f, 2.03478765e-02f, -8.55790451e-02f, -7.20079914e-02f, -2.05023095e-01f, -8.69164839e-02f,
  -2.02487595e-02f, 1.39486790e-01f, -3.46988216e-02f, 3.26821692e-02f, -1.08182453e-01f, -1.33119404e-01f, -5.63914776e-02f, -5.42604364e-03f, -4.79530245e-02f, 3.20423245e-02f,
  6.37953058e-02f, -1.98923573e-02f, 3.41566354e-02f, 1.08723938e-01f, -3.85163911e-02f, 4.52484265e-02f, 3.59527394e-02f, -1.04335427e-01f, 2.99507119e-02f, 5.21968715e-02f,
  8.48346949e-02f, 4.66821976e-02f, -1.48886684e-02f, -4.49496098e-02f, -4.50074226e-02f, 5.21842055e-02f, -2.25409083e-02f, -9.27685015e-03f, 3.57470252e-02f, 1.40102878e-02f,
  7.68070072e-02f, -6.54154345e-02f, -2.88709346e-02f, 3.18660587e-02f, -1.98105872e-02f, 2.58853547e-02f, 4.40910198e-02f, 3.12076453e-02f, 1.93381608e-02f, -2.55882405e-02f,
  -6.10580258e-02f, 9.59580839e-02f, 7.47012123e-02f, -8.58250037e-02f, 1.22421077e-02f, 1.30952820e-02f, -8.98979157e-02f, 3.25867832e-02f, 1.24943108e-04f, 5.50312810e-02f,
  5.59175648e-02f, 2.47416701e-02f, 1.53389731e-02f, -1.14020845e-02f, -6.68632984e-02f, 1.01082101e-02f, 3.67956273e-02f, 2.62361690e-02f, -4.68999930e-02f, -6.05283752e-02f,
  -8.52342993e-02f, -6.74251560e-03f, 1.56605821e-02f, 5.69567829e-02f, 6.06117956e-02f, -1.10861018e-01f, 1.80298164e-02f, 8.22593458e-04f, -7.13935941e-02f, -5.29993810e-02f,
  -1.07030958e-01f, -3.30852321e-03f, -4.63830121e-02f, 2.63518672e-02f, 9.86062884e-02f, -4.22616452e-02f, -4.37295204e-03f, 4.57656309e-02f, -1.36191025e-01f, -3.44728976e-02f,
  -5.16134165e-02f, -5.80258947e-03f, 4.94558439e-02f, 9.73068848e-02f, 4.89892475e-02f, 9.41196457e-03f, 3.10690049e-02f, 7.61925802e-02f, -8.43805522e-02f, 1.84087525e-03f,
  2.64249265e-01f, -2.35550076e-01f, 3.33692998e-01f, 2.62233645e-01f, 6.81974590e-02f, 5.17188050e-02f, 2.05124125e-01f, -9.92539227e-02f, -5.60397133e-02f, -4.81367916e-01f,
  -6.99989870e-02f, 8.34031105e-02f, -9.86234844e-02f, 4.83894423e-02f, 1.23283342e-01f, -1.27064958e-01f, -4.51945104e-02f, -4.82275859e-02f, 1.34135989e-04f, -4.69011366e-02f,
  4.96013910e-02f, -2.11007386e-01f, 2.02547610e-01f, -1.90404728e-01f, 1.74906477e-01f, 5.66215394e-03f, -9.70596895e-02f, 1.09846972e-01f, 5.87066635e-02f, 1.23001248e-01f,
  -1.50977194e-01f, -2.78591514e-02f, 1.72860213e-02f, 2.57572010e-02f, 2.63754223e-02f, -1.73729174e-02f, -2.02387013e-02f, 1.41236380e-01f, 1.13713495e-01f, 8.82952586e-02f,
  8.10641497e-02f, 8.47495645e-02f, 3.07111461e-02f, -9.47849301e-04f, 3.35984789e-02f, 9.08111781e-02f, 8.09969679e-02f, 3.11946142e-02f, 3.07011213e-02f, 1.41704962e-01f,
  1.35961235e-01f, -1.06851328e-02f, 1.30552053e-01f, -4.25527953e-02f, 3.06298770e-02f, -2.30998192e-02f, -1.96651705e-02f, 1.04790233e-01f, 5.38253374e-02f, 2.98264250e-02f,
  2.16559861e-02f, -1.05634639e-02f, -3.90610099e-02f, 7.46269419e-04f, 2.91830003e-02f, 4.05832939e-03f, 5.43230847e-02f, -4.24196608e-02f, 6.18372969e-02f, -2.91553028e-02f,
  -2.07630936e-02f, 4.58870903e-02f, 2.09495965e-02f, 3.97743657e-03f, -4.02148031e-02f, 1.64562296e-02f, 1.39996082e-01f, -8.79268870e-02f, 5.53529263e-02f, 2.52017435e-02f,
  -6.41295761e-02f, -6.32396638e-02f, -2.79159639e-02f, 1.11995917e-02f, 5.13740536e-03f, 5.24402894e-02f, -4.20539919e-03f, 6.56144172e-02f, -4.89928238e-02f, 6.74365601e-03f,
  -3.40180308e-01f, -3.72283548e-01f, -1.21480055e-01f, -1.39948577e-01f, -6.18130863e-02f, -5.03439344e-02f, -4.69491631e-02f, -8.33994001e-02f, -1.17532633e-01f, -9.97721851e-02f,
  -5.82668930e-02f, 2.54949871e-02f, -2.79369894e-02f, -4.20333296e-02f, -1.08719200e-01f, -6.91081807e-02f, -6.61462620e-02f, -1.88524425e-02f, 2.05332711e-02f, -1.78643293e-03f,
  4.59765457e-02f, -6.63612038e-02f, -1.69862788e-02f, -1.19553795e-02f, -8.89152512e-02f, -4.30948399e-02f, 4.31006029e-02f, 3.04056313e-02f, -4.33406560e-03f, -3.81526910e-02f,
  -1.94625676e-01f, -5.06204188e-01f, -5.25195956e-01f, -9.90776941e-02f, 2.19165832e-01f, 3.31755787e-01f, -1.01755038e-02f, -8.92070383e-02f, -4.98809159e-01f, 6.51811361e-02f,
  3.44656944e-01f, -1.69468924e-01f, -2.81566948e-01f, 2.35638916e-01f, 1.24156430e-01f, -1.73482493e-01f, 1.91526443e-01f, 2.93344676e-01f, -1.90164134e-01f, -1.12269856e-01f,
  8.52169842e-02f, 5.55525064e-01f, 8.05413816e-03f, 2.49011353e-01f, 2.04987139e-01f, -4.73783351e-02f, 2.74700522e-01f, -2.12045778e-02f, 4.59978938e-01f, 2.59773344e-01f,
  1.43253744e-01f, -1.59136415e-01f, -1.36132315e-01f, 2.16249004e-02f, 8.35477039e-02f, 3.36794965e-02f, 1.07558891e-01f, 9.14899036e-02f, 4.83528618e-03f, -6.55651614e-02f,
  -4.85107489e-02f, 2.95399856e-02f, 1.10843234e-01f, -2.06073057e-02f, -1.51761854e-03f, -6.78691640e-02f, -6.69106618e-02f, -8.50521401e-02f, -6.22184612e-02f, -7.10086524e-02f,
  -2.33380333e-01f, -3.22156735e-02f, -8.92411023e-02f, -2.29318142e-02f, -8.69206041e-02f, -4.09400873e-02f, -1.80435330e-02f, -8.97849202e-02f, 5.61251193e-02f, -1.64101329e-02f,
  9.83404890e-02f, 6.84721544e-02f, -3.33470516e-02f, -2.05474421e-02f, -4.52744029e-02f, 7.11031184e-02f, 3.27910855e-02f, 2.34817341e-02f, 4.50179763e-02f, -2.59445682e-02f,
  4.01226394e-02f, -9.63982567e-03f, 4.20267731e-02f, 4.81985621e-02f, 5.37620522e-02f, -5.20115606e-02f, 9.98416618e-02f, -8.31743050e-03f, -1.55576998e-02f, -8.74264911e-03f,
  -1.76350586e-02f, 3.53986360e-02f, -1.93646904e-02f, 8.65621343e-02f, 3.94176990e-02f, -9.35687572e-02f, 8.60386193e-02f, -8.76031816e-02f, -5.62925190e-02f, 3.05679664e-02f,
  5.76077253e-02f, -2.03013629e-01f, -9.18370485e-02f, -2.13192888e-02f, 4.17240895e-02f, 7.58802295e-02f, 5.94961736e-03f, -2.99520354e-04f, -5.54508641e-02f, -1.13142990e-01f,
  8.95362794e-02f, 6.48338050e-02f, -1.22965928e-02f, -9.00570583e-03f, 3.95386666e-02f, 1.69443395e-02f, -3.73849086e-02f, 5.92437424e-02f, -1.11376122e-02f, -1.40874321e-03f,
  -9.51187219e-03f, -6.44987747e-02f, 2.52200104e-03f, 1.43143181e-02f, 8.18886980e-02f, 4.46898974e-02f, -2.29615327e-02f, 2.17392426e-02f, 1.09014049e-01f, -5.00279479e-02f,
  1.97489932e-01f, 1.02636181e-01f, 9.65143666e-02f, 1.71007261e-01f, 1.30931526e-01f, -1.92518011e-02f, 9.85944569e-02f, 2.42491975e-01f, 4.48734850e-01f, -1.73926830e-01f,
  -1.81766868e-01f, -1.29972845e-01f, -1.69106781e-01f, -1.27670288e-01f, 1.41604468e-01f, 7.94108436e-02f, 1.77365035e-01f, -5.97490706e-02f, 2.98128158e-01f, -7.22178742e-02f,
  1.24241278e-01f, -1.26667649e-01f, -1.36090815e-01f, -2.58546293e-01f, -1.89516172e-01f, -1.21091316e-02f, -2.56972939e-01f, -3.53863873e-02f, -1.89397112e-01f, -6.89122304e-02f,
  -1.48508428e-02f, 9.28434804e-02f, -1.42293990e-01f, -2.36586165e-02f, 7.11710379e-02f, -9.97832492e-02f, -1.19717702e-01f, -1.37323351e-03f, -9.64556728e-03f, 4.78113294e-02f,
  -5.31304628e-02f, -2.06626616e-02f, 8.06913003e-02f, -1.42037049e-02f, -6.22569304e-03f, -6.35918304e-02f, -3.57841477e-02f, -5.50935380e-02f, 2.56987307e-02f, -5.90782538e-02f,
  -7.65993223e-02f, 1.29611241e-02f, 2.15375088e-02f, 1.23839498e-01f, 3.71186063e-02f, 1.82451997e-02f, 2.40113009e-02f, 3.28032039e-02f, 9.45866108e-03f, 7.94267133e-02f,
  -5.25231436e-02f, 5.89292422e-02f, -3.76047380e-02f, -5.41496947e-02f, -6.68167695e-02f, 6.12343475e-02f, -1.78430006e-02f, 3.34740989e-02f, 9.16745067e-02f, -7.35547990e-02f,
  6.47988766e-02f, -5.96393608e-02f, 5.34112155e-02f, 2.89824349e-03f, 5.93314134e-02f, -7.32654110e-02f, 3.46797667e-02f, -1.51781831e-02f, -9.82006174e-03f, -6.65685609e-02f,
  -6.21542037e-02f, 4.98033166e-02f, 3.82484570e-02f, 2.68561603e-03f, -1.64230634e-02f, -1.82301309e-02f, -7.97812641e-02f, -2.72290315e-02f, -2.45133583e-02f, 1.01351924e-02f,
  1.73412085e-01f, 2.08051875e-01f, 1.00381114e-02f, -1.22349575e-01f, -5.55333234e-02f, -2.34071948e-02f, 7.09846988e-02f, 4.96504903e-02f, 2.00597763e-01f, 3.57585996e-02f,
  -3.37291807e-02f, -5.15981987e-02f, -4.56863642e-03f, -1.07101146e-02f, -9.46922228e-02f, -1.60931014e-02f, 3.73434909e-02f, 8.92872363e-03f, -5.80569319e-02f, -6.07003756e-02f,
  -4.93566208e-02f, 3.84981632e-02f, 2.07025670e-02f, 6.48222538e-03f, -3.93636003e-02f, 2.48780847e-02f, 8.79023597e-03f, -8.40989500e-02f, 2.53539477e-02f, 1.13263302e-01f,
  7.98673742e-03f, -1.14658199e-01f, -3.49181235e-01f, -1.75025672e-01f, -7.63431489e-02f, -8.24569240e-02f, -5.82457073e-02f, -1.54036939e-01f, -1.72653705e-01f, 2.43115008e-01f,
  7.52821863e-02f, -1.84565842e-01f, -1.09219909e-01f, -2.52250373e-01f, -3.31649601e-01f, -2.31187105e-01f, -5.63339628e-02f, -7.19146710e-03f, -1.66336775e-01f, -6.65422380e-02f,
  -9.94005576e-02f, -4.87324186e-02f, -1.86280772e-01f, -3.09231225e-02f, 6.49307389e-03f, 3.42614241e-02f, 1.24083519e-01f, 4.98518981e-02f, 7.46888146e-02f, -8.68394822e-02f,
  -2.63618538e-03f, -9.36848223e-02f, -4.90237586e-03f, -5.98414317e-02f, 8.60881880e-02f, 1.06617644e-01f, 2.26002745e-02f, -1.12563670e-01f, 3.20414603e-02f, 4.97960523e-02f,
  1.04526937e-01f, 2.58376524e-02f, -9.83037353e-02f, -9.68115628e-02f, 7.21386969e-02f, -5.90051599e-02f, -8.06972086e-02f, 8.64710808e-02f, -7.60471076e-03f, -3.19986418e-02f,
  5.10995053e-02f, -3.93574834e-02f, 3.08034755e-02f, -6.02205656e-02f, -6.67557772e-03f, -5.51219424e-03f, 5.69299273e-02f, 1.04369834e-01f, 1.13549262e-01f, -4.07758355e-03f,
  3.09091303e-02f, 1.46241803e-02f, -7.66510591e-02f, 2.71746833e-02f, 5.81236742e-03f, 2.65974831e-02f, -3.37812379e-02f, 3.37134115e-02f, -7.02199265e-02f, -4.20276672e-02f,
  -1.77630540e-02f, -9.55917463e-02f, -2.71781292e-02f, -2.04850864e-02f, 4.68511693e-03f, -1.40729286e-02f, -3.08684446e-02f, 6.43618107e-02f, 4.68797348e-02f, -1.73349166e-03f,
  3.82421017e-02f, -4.89052609e-02f, 1.66557077e-02f, -6.33963617e-03f, -1.08264983e-02f, 9.32240412e-02f, 2.68391799e-02f, 2.09870692e-02f, 1.92367099e-02f, 3.77576761e-02f,
  -5.79518378e-02f, 2.48611979e-02f, -1.21506592e-02f, 1.96965653e-02f, 2.28120834e-02f, 4.10962477e-02f, -3.42526063e-02f, -5.39323054e-02f, -6.57048896e-02f, -5.77824935e-02f,
  8.53588581e-02f, 5.33907339e-02f, 9.47524011e-02f, 4.97998297e-02f, 6.46250546e-02f, -6.56595007e-02f, 1.02175206e-01f, 1.60973165e-02f, 2.89813168e-02f, -1.21955611e-02f,
  1.01955809e-01f, 1.43602967e-01f, 2.29796208e-02f, 7.09356070e-02f, 5.60343228e-02f, 7.91411474e-02f, 7.28464499e-02f, 2.03764830e-02f, -4.90654446e-02f, -3.99077907e-02f,
  2.91441232e-01f, -5.95623791e-01f, 1.36003671e-02f, 2.41878495e-01f, 2.34404638e-01f, 2.59930164e-01f, 3.43718678e-01f, -1.28303587e-01f, 1.07381251e-02f, -4.69901621e-01f,
  -8.47260430e-02f, -5.08494303e-02f, -2.71633327e-01f, 1.09202869e-01f, 6.10250175e-01f, -3.48656774e-02f, 1.28998265e-01f, 1.29120588e-01f, 8.59662192e-04f, 5.39508462e-02f,
  1.48910239e-01f, 2.57457882e-01f, 7.48137087e-02f, -2.02470854e-01f, 8.98198634e-02f, -1.81632251e-01f, 5.28655723e-02f, -7.03149708e-03f, -1.56410914e-02f, 2.72345483e-01f,
  8.71105865e-02f, -2.15264205e-02f, -2.44740974e-02f, -1.93397179e-02f, -1.07702874e-01f, -2.85655037e-02f, 1.71346348e-02f, 7.46417046e-02f, 8.62771645e-02f, -3.64992581e-02f,
  -6.89428626e-03f, -2.33372301e-02f, 6.54259650e-03f, -2.28582304e-02f, -3.20620835e-03f, -6.40235767e-02f, -5.42396717e-02f, -5.23952618e-02f, 8.04403797e-03f, -3.09760459e-02f,
  -4.38500196e-02f, 2.18983786e-03f, 5.74218854e-02f, -4.89959121e-02f, -1.78347416e-02f, -2.00568940e-02f, 1.41827036e-02f, 2.37206612e-02f, -2.08566207e-02f, 3.40158008e-02f,
  -2.96203308e-02f, -6.22745492e-02f, 4.22952399e-02f, 6.37715012e-02f, -1.77012831e-02f, 1.00089051e-01f, -3.55533510e-02f, -2.55962554e-03f, -3.94984521e-02f, -1.46867950e-02f,
  -2.25705840e-02f, 2.74670646e-02f, 9.79097001e-03f, 2.59034289e-03f, 6.28080070e-02f, 3.36324908e-02f, 2.50130873e-02f, 6.43678084e-02f, -3.09214499e-02f, -3.34689431e-02f,
  3.14553827e-02f, 5.35728633e-02f, 2.89060157e-02f, -3.98818776e-03f, -7.21150488e-02f, -2.00228915e-02f, -3.93095873e-02f, -2.54937187e-02f, -4.51940559e-02f, 1.25034720e-01f,
  -6.47961870e-02f, -2.00940475e-01f, 3.15782465e-02f, -2.41420846e-02f, -5.50336726e-02f, -6.58657681e-03f, 3.41133401e-02f, 4.95807081e-02f, 6.13231361e-02f, 6.86787739e-02f,
  -8.96368995e-02f, 1.64068211e-02f, 1.39961829e-02f, 3.54416557e-02f, 1.06261857e-01f, -8.58320817e-02f, -1.40253734e-02f, 2.57554464e-02f, -1.13790098e-03f, -1.09923385e-01f,
  -1.88365411e-02f, 4.09946591e-02f, 1.18896097e-01f, -5.77302575e-02f, -8.27167183e-02f, 3.51276696e-02f, 3.67724826e-03f, -1.81507450e-02f, 9.84890014e-03f, -2.08754260e-02f,
  -1.14911117e-01f, 1.76526934e-01f, 4.69082415e-01f, -1.34700686e-01f, -4.27680947e-02f, 1.02505468e-01f, -8.23938195e-03f, 1.45899385e-01f, -2.00802624e-01f, -1.11084551e-01f,
  -1.15686223e-01f, 1.00225009e-01f, 2.01217934e-01f, 6.15617260e-02f, -5.76499254e-02f, -3.22428010e-02f, -6.54756576e-02f, 6.69415519e-02f, 6.61384761e-02f, 4.95220870e-02f,
  -1.89325158e-02f, -1.91106871e-01f, 2.28337437e-01f, 1.16940841e-01f, 8.27869996e-02f, 8.90456364e-02f, -6.24056682e-02f, 1.71783835e-01f, 1.03716388e-01f, -8.77955556e-02f,
  -6.48831576e-02f, -2.25682091e-03f, 6.22964613e-02f, 1.78564250e-01f, 1.14686787e-01f, -3.74813154e-02f, 3.64622287e-02f, -2.58625578e-02f, 5.92429517e-03f, -4.58645597e-02f,
  -5.16303489e-03f, 1.19739790e-02f, 2.31153984e-03f, -4.17478867e-02f, 7.83726573e-02f, -1.83885153e-02f, 7.65903369e-02f, 1.01166219e-01f, 1.21580169e-01f, 1.47473857e-01f,
  9.83983204e-02f, 1.08715467e-01f, 5.38857318e-02f, 2.27853209e-02f, 6.41564652e-02f, -9.00260359e-03f, -4.75502275e-02f, -5.54662533e-02f, 8.84291083e-02f, -9.58540887e-02f,
  -9.21621993e-02f, -3.85734923e-02f, 4.41951640e-02f, 8.55831709e-03f, -6.31416170e-03f, 4.27596197e-02f, 6.53304979e-02f, 3.92684974e-02f, -3.39145884e-02f, -9.78833959e-02f,
  6.92828894e-02f, -2.67456435e-02f, 1.98735781e-02f, 1.05129061e-02f, 4.97644022e-02f, -2.40103956e-02f, 1.02131404e-01f, 3.19402702e-02f, -2.26451214e-02f, 5.69060445e-03f,
  -4.88846116e-02f, -6.81518912e-02f, 3.66279371e-02f, -5.33638597e-02f, -3.16824503e-02f, -4.44352441e-02f, -4.06825393e-02f, 3.44692059e-02f, 4.85044830e-02f, 7.07519148e-03f,
  1.34648317e-02f, -1.74992278e-01f, 2.03897841e-02f, 5.91033313e-04f, -6.88664988e-02f, -7.23895337e-03f, 2.46962272e-02f, -7.47910002e-03f, 1.89515669e-02f, -6.80074319e-02f,
  -6.49144351e-02f, -2.19607893e-02f, -4.46012467e-02f, -7.88849071e-02f, 6.97333515e-02f, -4.97088069e-03f, 4.85415161e-02f, -5.92727810e-02f, -1.94002874e-02f, 6.69520572e-02f,
  1.69799607e-02f, -5.31255044e-02f, -6.96806014e-02f, 4.33583045e-03f, -5.00487676e-03f, -2.33026836e-02f, 1.23089533e-02f, 8.88209045e-02f, -4.99916822e-02f, 7.59759545e-02f,
  -5.48187494e-01f, 1.33809984e-01f, -3.86013150e-01f, -2.88115531e-01f, -9.77974106e-03f, -2.33368799e-01f, -2.26224717e-02f, -1.56187592e-02f, 3.08371838e-02f, 5.14419198e-01f,
  2.98058122e-01f, -1.18527375e-01f, 3.51968259e-01f, -9.28473771e-02f, -5.99058628e-01f, 6.90667480e-02f, -3.18848282e-01f, -1.18601896e-01f, -1.46791592e-01f, -4.62502521e-03f,
  -2.88289428e-01f, 1.19673170e-01f, -1.84912294e-01f, 2.75501788e-01f, -5.64040951e-02f, -7.76583180e-02f, 1.44948959e-01f, 1.56617731e-01f, -2.07312420e-01f, -6.89503700e-02f,
  -6.79810718e-02f, 1.12968475e-01f, -7.93502927e-02f, 8.23041126e-02f, -3.44389379e-02f, -2.21519154e-02f, -4.85738665e-02f, -2.76561063e-02f, -6.76284656e-02f, 9.66122560e-03f,
  1.51012838e-02f, 6.12791367e-02f, -4.45029922e-02f, 2.58547477e-02f, -1.65592656e-02f, 3.04935072e-02f, -5.26196733e-02f, -9.82989594e-02f, 7.22478181e-02f, -1.91351563e-01f,
  -9.69011784e-02f, -1.21838532e-01f, -5.51842675e-02f, -1.61134191e-02f, -5.53927682e-02f, -3.39115635e-02f, -1.16142340e-01f, -1.01847067e-01f, -8.21539536e-02f, -4.22792211e-02f,
  -1.01163471e-02f, -1.98546052e-02f, 3.76756564e-02f, 5.03377691e-02f, 1.95240099e-02f, 6.28483817e-02f, 1.62403323e-02f, 6.68812841e-02f, 2.52770167e-02f, -2.01803027e-03f,
  -8.27614963e-03f, 5.54310456e-02f, 9.67535228e-02f, -6.70148805e-02f, 1.23727033e-02f, 3.76160257e-02f, 3.60573679e-02f, 6.22284450e-02f, -4.98345010e-02f, -6.02173805e-02f,
  1.24510415e-01f, -1.18655413e-01f, 5.34227453e-02f, -2.01344062e-02f, 5.76960146e-02f, 2.51836330e-02f, 7.34477863e-02f, -2.60560364e-02f, 2.83362940e-02f, 4.88367639e-02f,
  -3.00166905e-02f, 7.39449710e-02f, 9.27870274e-02f, 7.59645104e-02f, -2.50551477e-02f, 1.21988794e-02f, 3.93455885e-02f, -1.04787402e-01f, 1.44992238e-02f, 5.17306924e-02f,
  3.06586772e-02f, -1.74557995e-02f, -7.77614042e-02f, -6.90981671e-02f, -2.25571264e-02f, -3.72633636e-02f, 6.70891106e-02f, 6.97929040e-02f, -5.07394038e-02f, 9.47712804e-04f,
  1.37800977e-01f, 8.11379030e-02f, -5.93274720e-02f, 6.23753332e-02f, 1.30360562e-03f, 6.25093700e-03f, -3.05175618e-03f, 1.92223638e-02f, -3.42066865e-03f, -2.19867658e-02f,
  -1.41209602e-01f, 2.87603922e-02f, -1.09073678e-02f, 1.67555973e-01f, 6.30752593e-02f, -5.53706922e-02f, -5.27296290e-02f, 1.64865091e-01f, 1.26714200e-01f, 9.29388851e-02f,
  1.08390208e-02f, -8.12205076e-02f, -5.54694654e-03f, -1.66676790e-01f, -1.67510733e-01f, -2.39758715e-01f, -2.20315866e-02f, -1.35445952e-01f, 5.14449850e-02f, 1.40260696e-01f,
  1.73052609e-01f, -1.71445552e-02f, -9.82016772e-02f, 8.39217827e-02f, -1.66529827e-02f, 9.50161442e-02f, 2.35378787e-01f, 1.26220614e-01f, 2.50016730e-02f, -1.22068137e-01f,
  -1.20627500e-01f, -1.14293415e-02f, -1.10291019e-01f, -2.90829856e-02f, 6.01737611e-02f, 6.49879053e-02f, -6.18601069e-02f, -1.23391360e-01f, -6.11985847e-02f, 3.13861445e-02f,
  6.38983250e-02f, -4.92337681e-02f, 9.20124631e-03f, -1.61288697e-02f, -8.54384340e-03f, 5.31675294e-02f, -1.20386809e-01f, -7.62834027e-03f, -2.46379245e-03f, 1.73890889e-02f,
  -1.12093613e-01f, -6.53626695e-02f, 1.26098633e-01f, -4.03787419e-02f, -7.54732117e-02f, -2.76075229e-02f, -7.55463820e-03f, -9.59943514e-03f, 1.02237284e-01f, -3.26928869e-02f,
  3.85369435e-02f, 4.39892933e-02f, -4.58966568e-02f, -9.78130549e-02f, -5.78586124e-02f, -5.74733838e-02f, -4.29567210e-02f, 2.86773685e-02f, -2.69465670e-02f, 5.77334203e-02f,
  5.26750199e-02f, 3.39609422e-02f, -2.48353090e-02f, 9.47042927e-02f, -6.01277221e-03f, -2.37450860e-02f, -2.99938414e-02f, -3.72652672e-02f, -1.42552415e-02f, -2.61966921e-02f,
  -8.92521217e-02f, 4.69402000e-02f, -7.76464716e-02f, -6.29602373e-02f, -2.97430567e-02f, -6.03942797e-02f, 7.39967674e-02f, -3.71685177e-02f, 9.15651619e-02f, 9.53351259e-02f,
  1.24765351e-01f, 3.21857750e-01f, 8.75633955e-02f, -9.63650197e-02f, 3.05425953e-02f, 9.55905691e-02f, 5.41371778e-02f, 4.93792817e-03f, 3.83932069e-02f, 1.56363863e-02f,
  5.98056652e-02f, -4.09710826e-03f, 5.79382814e-02f, 2.88780127e-02f, 9.16478485e-02f, 1.56082943e-01f, 1.16356328e-01f, 1.21341735e-01f, 1.45005271e-01f, 6.73709884e-02f,
  6.51706429e-03f, 9.36298445e-02f, 1.39357388e-01f, 5.65447100e-02f, -3.16284853e-03f, 6.75234646e-02f, 2.27747690e-02f, -2.61048879e-03f, 9.35827475e-03f, 4.25009802e-03f,
  -5.90275228e-03f, -2.07963258e-01f, 3.38980928e-02f, 2.87664860e-01f, -4.21155319e-02f, 1.75819054e-01f, 2.99022406e-01f, -1.35371283e-01f, 2.13783532e-01f, -1.53648481e-01f,
  -1.70600727e-01f, -4.13874201e-02f, -7.01096430e-02f, 1.29563093e-01f, 2.75544077e-01f, 1.42855659e-01f, 2.27006584e-01f, 1.36224195e-01f, 1.77947059e-02f, -4.70503990e-04f,
  2.26202421e-02f, 2.56077852e-02f, -7.47959875e-03f, -2.08597332e-01f, -1.16772123e-01f, -9.67279002e-02f, -1.54795768e-02f, -1.21608153e-01f, -6.78355852e-03f, 1.37476418e-02f,
  -4.54370938e-02f, -6.91817980e-03f, 8.10169149e-03f, 1.00773223e-01f, -4.50014174e-02f, -6.74875528e-02f, 1.63981602e-01f, 6.86476560e-05f, 9.49967429e-02f, 2.53858417e-02f,
  -1.74947679e-02f, -5.40179126e-02f, -5.39648421e-02f, 4.95789060e-03f, -1.76024139e-02f, -8.17199647e-02f, -9.85681787e-02f, -9.44054127e-02f, 5.40861394e-03f, -9.19047892e-02f,
  3.63726281e-02f, 3.83504331e-02f, -9.63920653e-02f, 1.31955668e-01f, 1.33385658e-01f, 6.27776310e-02f, 5.79339862e-02f, 4.02831212e-02f, -1.10760517e-02f, 5.96277788e-02f,
  -1.34728432e-01f, 3.72930779e-03f, -5.58024831e-02f, -3.65845002e-02f, -7.17852712e-02f, -3.92180309e-02f, -4.57777940e-02f, -1.84620963e-03f, -5.17055653e-02f, 3.66030037e-02f,
  7.30435103e-02f, -3.87668125e-02f, 7.25191459e-02f, 5.42183183e-02f, -4.81438264e-02f, -6.74775392e-02f, 2.36513652e-02f, -2.18471549e-02f, 7.55456686e-02f, -2.59007141e-02f,
  1.02626961e-02f, 5.95680065e-02f, -2.54670195e-02f, 3.42878583e-03f, 6.60743788e-02f, -9.64896753e-02f, -1.13482587e-01f, -7.80621767e-02f, 2.24216040e-02f, 6.72391355e-02f,
  1.30137712e-01f, -1.22506889e-02f, -1.17622009e-02f, 9.58124548e-02f, -3.21542397e-02f, -4.34593186e-02f, 1.29956022e-01f, 4.77254540e-02f, 4.83890958e-02f, -9.98365059e-02f,
  -2.50293370e-02f, 7.76924193e-02f, -1.16236739e-01f, 1.49531225e-02f, 1.43199876e-01f, -1.26884505e-01f, 1.20402835e-01f, 1.35676652e-01f, -2.44722068e-02f, -1.28872693e-01f,
  -3.68328914e-02f, -9.29617044e-03f, 2.89173536e-02f, -1.51360221e-03f, 4.99843955e-02f, 1.06061744e-02f, -1.51509959e-02f, -1.62102561e-02f, -4.47171551e-05f, 9.05135497e-02f,
  -3.96916419e-01f, 2.35563561e-01f, -5.64526245e-02f, -4.04418498e-01f, 1.34993717e-01f, -8.02378505e-02f, -6.75994009e-02f, 4.81848605e-02f, -1.65326223e-01f, -7.79741183e-02f,
  -1.13671690e-01f, -2.74303049e-01f, 2.21122533e-01f, -2.38430619e-01f, -1.01420343e-01f, 2.55352985e-02f, -2.49187723e-01f, -2.18472913e-01f, 1.04526646e-01f, -8.08314532e-02f,
  -6.15147352e-02f, -5.75737804e-02f, 1.05042547e-01f, 3.15305591e-01f, -1.03366181e-01f, -5.82510531e-02f, 4.83613163e-02f, 2.92067200e-01f, -1.64057776e-01f, 6.62362128e-02f,
  -1.16031580e-01f, -1.90186292e-01f, -7.25489482e-02f, -1.36355489e-01f, -3.88561822e-02f, 5.22861199e-04f, -7.24596088e-04f, -3.42308767e-02f, -7.44444951e-02f, 6.05682470e-02f,
  -4.14353348e-02f, -5.61770890e-03f, -3.38132009e-02f, 1.09314241e-01f, -6.61151260e-02f, -1.09174019e-02f, 2.08706893e-02f, 4.94545233e-03f, -2.38222517e-02f, 1.78361367e-02f,
  -1.39721972e-03f, -2.86459718e-02f, -7.46993199e-02f, -1.10155091e-01f, -4.39035632e-02f, -1.88624649e-03f, -6.19263761e-02f, -5.09551205e-02f, 3.50139663e-02f, 4.70601674e-03f,
  4.84736729e-03f, -3.91529240e-02f, 5.14799803e-02f, -4.19837795e-02f, -7.37730488e-02f, -1.39997229e-02f, -5.08401841e-02f, -1.07842669e-01f, 1.33598736e-02f, 3.70892063e-02f,
  -5.99208176e-02f, -4.55874987e-02f, -4.54773083e-02f, 1.74409747e-02f, -1.18938990e-01f, -9.82578397e-02f, 1.68034919e-02f, -8.16049203e-02f, 3.97447608e-02f, -9.28667188e-03f,
  -2.45777573e-02f, 3.43897976e-02f, -3.34916823e-02f, -5.43167023e-03f, -7.67401904e-02f, 1.20661287e-02f, -3.03440969e-02f, -2.12511723e-03f, 4.56544757e-02f, 1.78930903e-04f,
  -1.78204224e-01f, -1.26878068e-01f, -6.47088662e-02f, -1.06117219e-01f, -3.10677495e-02f, 5.29342778e-02f, -5.28544858e-02f, -4.75885766e-03f, -4.27373908e-02f, 2.53919084e-02f,
  2.10267957e-02f, 2.43762881e-02f, -3.67490463e-02f, -8.19507614e-02f, 6.30789921e-02f, -8.36112574e-02f, -3.05033885e-02f, 3.15918378e-03f, -3.68569046e-02f, -5.81771098e-02f,
  4.53126244e-02f, 5.67689463e-02f, -2.92041134e-02f, 7.85444751e-02f, -6.35642372e-03f, 3.82154458e-03f, 1.60766467e-02f, 1.38082299e-02f, -3.64804305e-02f, -1.32680312e-02f,
  -5.42496778e-02f, 2.08962739e-01f, 2.60790437e-02f, 9.78329964e-03f, -2.74499178e-01f, -4.68368530e-01f, -3.85692418e-01f, 1.19269110e-01f, -2.02024981e-01f, -9.68175232e-02f,
  9.93467346e-02f, -1.48040354e-01f, 1.76014647e-01f, -2.63353661e-02f, 9.19413045e-02f, 1.33948460e-01f, 5.71010560e-02f, -1.06719740e-01f, 1.04325213e-01f, 3.48329395e-01f,
  2.95971304e-01f, 2.65902132e-01f, 4.90899891e-01f, 4.12313759e-01f, 1.01467863e-01f, 1.72335774e-01f, 4.57186192e-01f, 1.74728766e-01f, 1.74459457e-01f, -4.23008390e-03f,
  -1.04441382e-01f, 2.05506876e-01f, -3.04492079e-02f, -7.56854042e-02f, 1.41041279e-01f, 5.24088228e-03f, 1.60209797e-02f, -7.64081329e-02f, -3.82758789e-02f, -2.58458033e-02f,
  -6.61306009e-02f, 8.44214484e-02f, -8.68178010e-02f, -9.09496658e-03f, -4.45715040e-02f, 4.35275324e-02f, 8.10713544e-02f, -1.22769279e-02f, -8.79351795e-02f, 3.87509502e-02f,
  1.62393562e-02f, -3.54974717e-02f, -1.38171017e-02f, -6.53596446e-02f, 4.98313224e-03f, 6.73319097e-04f, -6.98718801e-02f, 8.34518224e-02f, -3.84547301e-02f, 1.67355016e-02f,
  1.35174602e-01f, -3.55765224e-02f, -4.79365066e-02f, -2.44499203e-02f, 4.28892300e-02f, -1.46696297e-02f, -2.37575229e-02f, -4.41471115e-02f, 9.41132288e-03f, 9.44649149e-03f,
  1.80226751e-02f, 7.20816255e-02f, 6.59274543e-03f, -5.37035838e-02f, 2.09629536e-02f, -9.56614781e-03f, -2.27460414e-02f, 9.78289694e-02f, -3.99644971e-02f, 7.36387148e-02f,
  3.58003005e-02f, 4.53494452e-02f, -3.08195911e-02f, 4.06058878e-02f, -8.10859576e-02f, -7.98081513e-03f, 1.11703463e-01f, -1.25345327e-02f, 3.59340943e-02f, 1.29848616e-02f,
  4.55791950e-02f, 5.65134227e-01f, 4.49481495e-02f, -1.00807533e-01f, 1.22369751e-01f, -6.13246113e-03f, -3.28593552e-02f, 2.32488103e-02f, 7.98519999e-02f, 5.36626950e-02f,
  1.19043998e-01f, -5.30949757e-02f, -4.41347547e-02f, -2.88317241e-02f, -8.98539741e-03f, -3.21658552e-02f, 1.05527855e-01f, -5.98006733e-02f, 4.36723279e-03f, 1.57766879e-01f,
  1.17893346e-01f, -4.18937579e-03f, -2.86553372e-02f, -1.57732815e-02f, -4.89291288e-02f, -3.65879685e-02f, -1.82049889e-02f, 6.67029843e-02f, 4.22424749e-02f, -9.52700060e-03f,
  -5.50936647e-02f, 2.59984136e-01f, 2.28896558e-01f, -3.65498140e-02f, -1.93853959e-01f, 1.12937838e-01f, 4.52187378e-03f, -1.64996311e-01f, 3.08938399e-02f, 3.04601789e-01f,
  -1.10786989e-01f, 2.75903612e-01f, -1.44414440e-01f, -8.29234421e-02f, -4.71785933e-01f, -2.75970936e-01f, -5.41816950e-02f, 5.54630458e-02f, -5.45188710e-02f, 7.13620111e-02f,
  -1.18092805e-01f, -2.87034720e-01f, -7.84469470e-02f, -8.38003382e-02f, 7.43038207e-02f, 1.96648106e-01f, -1.35857925e-01f, -8.17881748e-02f, 2.11719856e-01f, -1.66039601e-01f,
  -1.26373228e-02f, -1.32123545e-01f, 9.61719155e-02f, -3.61061725e-03f, 1.10428199e-01f, 1.18367113e-01f, 2.17062384e-01f, -6.83362186e-02f, -1.27710760e-01f, -3.70190404e-02f,
  1.28159329e-01f, 8.53082165e-03f, -6.64926991e-02f, -1.70945317e-01f, 1.88004710e-02f, 2.19931342e-02f, 8.95842537e-02f, 1.29232004e-01f, 5.24329394e-02f, 4.61715758e-02f,
  1.50354594e-01f, 1.64762512e-01f, 7.31025636e-02f, 8.45779553e-02f, -3.30220945e-02f, -4.09467258e-02f, 7.52315894e-02f, 1.47099137e-01f, 6.25436306e-02f, -3.51110473e-02f,
  -2.29406040e-02f, 4.30644490e-02f, -1.02301221e-02f, 2.91504208e-02f, -1.11352257e-01f, -1.52358785e-02f, 1.96216423e-02f, -8.14585295e-03f, 2.57369429e-02f, 7.73625076e-02f,
  1.67629011e-02f, 7.17096850e-02f, -1.54136459e-03f, -3.17669697e-02f, 3.71032767e-02f, 6.32793158e-02f, 1.48905637e-02f, 4.81411815e-02f, 1.07288212e-01f, 3.29338945e-02f,
  -5.83239682e-02f, -4.41016145e-02f, 1.40391942e-02f, 3.15569080e-02f, -4.33260351e-02f, -3.54836844e-02f, 1.95413344e-02f, 8.61068740e-02f, -3.15651856e-02f, 3.28868926e-02f,
  1.03033215e-01f, 4.35465015e-02f, 1.74876619e-02f, 8.59689415e-02f, 6.20335042e-02f, 1.46136191e-02f, -6.14923723e-02f, -1.37622803e-02f, 1.66531128e-03f, 5.55150099e-02f,
  4.69098054e-02f, 3.54990661e-02f, 1.17856421e-01f, -5.06408066e-02f, -7.83991218e-02f, -1.64756104e-02f, 6.86772168e-02f, 7.11702630e-02f, -4.53701690e-02f, -2.63205003e-02f,
  3.49284485e-02f, 3.53186503e-02f, -8.78560077e-03f, 6.65445030e-02f, 5.93839772e-02f, 1.02283068e-01f, 2.13086903e-02f, 6.20366558e-02f, 2.57596057e-02f, 7.44851157e-02f,
  -4.93610278e-02f, -6.70272112e-02f, -1.34442404e-01f, 2.62062922e-02f, -9.23136100e-02f, 8.09708536e-02f, 1.06000446e-01f, -3.28957997e-02f, 2.48237684e-01f, 1.84136741e-02f,
  -2.31097996e-01f, 1.93787843e-01f, 1.41672358e-01f, -2.30076477e-01f, -4.27160747e-02f, -5.30966965e-04f, -2.00502388e-02f, -4.82779592e-02f, 1.37513801e-01f, -3.99457552e-02f,
  -1.14562526e-01f, -2.45597810e-02f, -2.25167811e-01f, -8.98109972e-02f, -1.62363291e-01f, -8.64905640e-02f, -1.17873281e-01f, -6.24271743e-02f, -1.71815738e-01f, -9.90455151e-02f,
  -1.15020014e-01f, 3.80588584e-02f, -6.04940131e-02f, 9.39010307e-02f, -6.36132061e-02f, -7.50496238e-02f, -4.77900207e-02f, -4.53537889e-02f, 5.25832698e-02f, 4.97697666e-02f,
  9.84059926e-03f, 7.62631893e-02f, 4.33019188e-04f, -3.18371803e-02f, 5.61016351e-02f, -4.35729474e-02f, 4.72397693e-02f, -3.22843231e-02f, -6.04216605e-02f, -5.65566272e-02f,
  -1.17160797e-01f, -1.25163384e-02f, 3.45496684e-02f, 5.89426309e-02f, -6.22134507e-02f, 4.73191254e-02f, -7.05531659e-03f, 3.87710966e-02f, -1.60357282e-02f, -1.34297810e-03f,
  -3.15405875e-02f, 4.42459211e-02f, -2.37257779e-02f, -3.22944694e-03f, 2.00801920e-02f, 3.68796401e-02f, -5.61959594e-02f, -9.90625694e-02f, 8.94454599e-04f, -5.40245557e-03f,
  6.04903176e-02f, 5.07079586e-02f, 1.59989558e-02f, 1.64172426e-02f, 2.61255484e-02f, 3.12420707e-02f, 4.04635482e-02f, -6.49749860e-02f, -9.74267498e-02f, 1.86756870e-03f,
  -2.84127463e-02f, 5.33988066e-02f, -8.14568326e-02f, 5.81580102e-02f, 4.69770581e-02f, 6.93240836e-02f, -8.07550922e-03f, 5.83647937e-02f, -5.77442721e-02f, 8.05140212e-02f,
  2.75269989e-03f, 2.91115850e-01f, 6.04026653e-02f, -4.62737447e-03f, 2.64742412e-02f, -7.14262873e-02f, 4.59325733e-03f, -3.19610909e-02f, -2.45869849e-02f, -3.12158130e-02f,
  3.09668873e-02f, -4.17913646e-02f, 5.67995645e-02f, -3.34434733e-02f, 9.35040936e-02f, -1.39115900e-01f, -4.86479253e-02f, 2.17946433e-02f, 1.09192975e-01f, 4.44681048e-02f,
  -6.55404106e-02f, -2.72586495e-02f, 4.03489247e-02f, -8.90112203e-03f, 8.09670389e-02f, -6.39908537e-02f, 8.31458718e-02f, 4.11658846e-02f, -1.90536007e-02f, -1.69450864e-02f,
  2.86131084e-01f, -2.67689645e-01f, -1.53270900e-01f, -1.61068812e-01f, -6.02671802e-02f, -3.53479803e-01f, -1.99136585e-01f, -3.01180899e-01f, -2.82223653e-02f, -1.85402319e-01f,
  2.38061547e-02f, 3.16340961e-02f, 1.96427569e-01f, -1.60640970e-01f, 1.14442222e-01f, 2.25978747e-01f, -3.29736978e-01f, -7.94258192e-02f, 5.61826639e-02f, -1.53896943e-01f,
  -6.70659095e-02f, -1.51008695e-01f, -8.03650022e-02f, -2.99901545e-01f, -2.41560370e-01f, -1.42881930e-01f, 9.92561597e-03f, 1.45420611e-01f, -2.08612889e-01f, 2.08685677e-02f,
  -3.50673012e-02f, 6.64993450e-02f, -7.66053051e-02f, 1.03251627e-02f, -7.87813365e-02f, -7.01767206e-02f, 1.30054560e-02f, 1.48604304e-01f, 4.89434740e-03f, -2.63714734e-02f,
  -9.77564050e-05f, 8.49696994e-02f, -7.53734708e-02f, 8.79080221e-02f, -3.96102145e-02f, -7.11363330e-02f, -3.28877084e-02f, -3.28684039e-02f, -9.52186584e-02f, 4.34953384e-02f,
  -8.23804662e-02f, -5.89184389e-02f, -3.58922407e-02f, -7.72803947e-02f, -1.32334298e-02f, -5.34351915e-03f, 2.42749434e-02f, -4.42533754e-02f, -1.31978512e-01f, -4.37227227e-02f,
  4.31220010e-02f, 7.32991323e-02f, 3.32461391e-03f, -1.05524333e-02f, -3.96229476e-02f, -1.11500779e-02f, 4.79623151e-04f, -5.97945862e-02f, 9.16659832e-02f, 2.22366303e-02f,
  -1.78252615e-03f, -6.99952990e-02f, -9.12293606e-03f, 3.13524939e-02f, -5.08776726e-03f, 5.99653795e-02f, 6.84822574e-02f, -4.87543754e-02f, -1.32311275e-02f, -6.35932460e-02f,
  -1.27928331e-03f, -5.18253595e-02f, -5.30541427e-02f, -5.99098504e-02f, -4.74664988e-03f, 6.22291490e-02f, 3.75370122e-02f, 5.93658537e-02f, -5.16305678e-03f, -1.59872212e-02f,
  -1.53886035e-01f, -1.50501877e-01f, -2.62365062e-02f, 2.06875931e-02f, -3.98535840e-02f, -6.85939938e-02f, -2.09786687e-02f, -1.95092037e-02f, 2.47639846e-02f, -7.60408491e-02f,
  9.05275531e-03f, -3.24059166e-02f, -1.48698082e-02f, 4.34953012e-02f, -4.23680693e-02f, -1.31131798e-01f, 2.10167058e-02f, 2.85751792e-03f, 1.74646843e-02f, -1.32559061e-01f,
  8.41365978e-02f, -7.13851675e-02f, -1.01115173e-02f, 1.69890784e-02f, -1.14778683e-01f, 1.08974124e-03f, -5.36082759e-02f, 4.49784361e-02f, -5.77457016e-03f, -3.45970802e-02f,
  -2.60876894e-01f, 3.76615345e-01f, 2.21591637e-01f, -2.76212245e-01f, -1.74488559e-01f, 1.27056748e-01f, -1.85238048e-01f, 1.65819693e-02f, -1.29157200e-01f, 3.41372155e-02f,
  -2.67226011e-01f, 1.58489600e-01f, 1.02694608e-01f, -1.40581504e-01f, 4.47994880e-02f, 1.25233203e-01f, -1.82473987e-01f, -1.88213721e-01f, 2.42987480e-02f, -2.29956627e-01f,
  -1.02203593e-01f, -3.77160549e-01f, 3.55573744e-02f, -1.34457231e-01f, -2.34635219e-01f, -6.83749244e-02f, -2.88043827e-01f, -1.09084591e-01f, -1.25701100e-01f, 5.11774160e-02f,
  -1.44141719e-01f, -1.27874613e-01f, 1.18160881e-01f, 1.44472152e-01f, 9.20825824e-03f, -2.88223270e-02f, 1.64281689e-02f, -4.69267927e-03f, -1.84903275e-02f, 1.11296102e-01f,
  -6.38586879e-02f, 9.07821581e-02f, -3.38743702e-02f, 1.63199790e-02f, -4.21607606e-02f, 3.60556580e-02f, 8.21924061e-02f, -1.32705448e-02f, 1.34789452e-01f, 3.39789018e-02f,
  8.80078003e-02f, 1.47750780e-01f, -4.84286435e-02f, -2.00797580e-02f, -1.49107799e-02f, 5.56961223e-02f, 2.22576242e-02f, 8.47627521e-02f, 1.04626909e-01f, 5.79489358e-02f,
  -5.49435839e-02f, -7.40336478e-02f, 4.01002821e-03f, 4.59536649e-02f, -2.41058320e-02f, -5.20995520e-02f, -4.23251539e-02f, -1.84408072e-02f, -5.11653814e-03f, 1.84912849e-02f,
  -2.05984246e-02f, -2.18114757e-04f, -4.60409112e-02f, 4.98254448e-02f, -3.59836943e-03f, 4.03496921e-02f, -2.56442316e-02f, 2.66276877e-02f, -6.61538616e-02f, -6.91241398e-02f,
  -9.88591313e-02f, -4.54555191e-02f, -1.40850367e-02f, -2.79318411e-02f, 1.06989406e-01f, 4.49288860e-02f, -9.59954131e-03f, 1.56819001e-01f, -5.89510091e-02f, 1.23115294e-02f,
  -1.97692543e-01f, -2.06367895e-01f, -1.28026213e-02f, -2.77823154e-02f, -4.74824850e-03f, -2.51439884e-02f, 2.53712554e-02f, 8.85318443e-02f, 4.52284701e-02f, -5.54770343e-02f,
  5.53890690e-02f, -1.15834691e-01f, 7.19211996e-03f, -4.09897454e-02f, -2.00446043e-03f, 1.78420870e-03f, -1.23634122e-01f, 1.68307144e-02f, -1.88288633e-02f, 5.24231866e-02f,
  4.41647656e-02f, -7.38088563e-02f, -9.77823883e-03f, -4.86392267e-02f, -1.90762635e-02f, -1.13273405e-01f, -6.63959980e-02f, 8.97605792e-02f, 4.00042124e-02f, -2.07781605e-02f,
  -1.81251436e-01f, -6.54143617e-02f, -7.97890220e-03f, -2.15956151e-01f, -1.05448894e-01f, -1.73028320e-01f, -1.32334769e-01f, -1.53861150e-01f, -5.56048425e-03f, 8.19764286e-03f,
  6.72018752e-02f, 3.27583700e-02f, 2.07624108e-01f, -2.34550193e-01f, 8.14344510e-02f, 2.56514341e-01f, -2.02498302e-01f, -6.97692335e-02f, -8.29345658e-02f, -2.54425049e-01f,
  -6.68899119e-02f, -7.33848363e-02f, -1.14829607e-01f, -1.15742058e-01f, -1.67710051e-01f, -5.65971024e-02f, 1.98364124e-01f, 7.26269409e-02f, -1.13976322e-01f, -7.51631036e-02f,
  -9.87854600e-03f, -1.71880066e-01f, -2.09222715e-02f, -7.83407986e-02f, -8.72900039e-02f, -2.56883688e-02f, 8.60286355e-02f, -1.08698970e-02f, -4.62838635e-02f, 1.05968006e-02f,
  -1.97739229e-02f, 5.36515564e-02f, -3.92323621e-02f, -8.43722653e-03f, -7.25276470e-02f, -5.49484268e-02f, -6.17496073e-02f, 4.27985899e-02f, -3.89040820e-02f, 3.85726057e-02f,
  5.16728684e-02f, 2.84593720e-02f, 4.73405831e-02f, 1.10568561e-01f, -2.56616753e-02f, -1.12758391e-01f, -4.78617400e-02f, 5.94292767e-02f, -5.15283942e-02f, -1.58462021e-02f,
  -7.63235614e-02f, 1.09383404e-01f, 1.42628944e-03f, -7.47046396e-02f, -1.17304847e-02f, -3.79243754e-02f, -1.22360848e-02f, 1.09000998e-02f, -3.96076255e-02f, 1.22672366e-02f,
  -1.30836247e-03f, 5.15014902e-02f, 3.64816561e-02f, 1.62990559e-02f, 1.31237116e-02f, -2.30136830e-02f, -1.49606364e-02f, 4.13607731e-02f, -5.34332730e-02f, -4.69389791e-03f,
  5.07892706e-02f, 2.49286089e-02f, 1.06298001e-02f, 6.41022772e-02f, 4.52493504e-02f, 7.93086458e-03f, -7.59363102e-05f, -1.07870616e-01f, 8.99220482e-02f, 7.10891485e-02f,
  -1.46942526e-01f, -1.30970672e-01f, -1.71306897e-02f, -6.38466701e-02f, -7.00002983e-02f, 8.79099295e-02f, -3.86591032e-02f, -1.14651762e-01f, -3.24668288e-02f, -9.06884596e-02f,
  -7.99730867e-02f, 3.87065299e-02f, 2.66266149e-02f, 3.42390835e-02f, -1.83832403e-02f, -9.34981182e-02f, 5.25282174e-02f, -1.30768016e-03f, 2.44297236e-02f, 4.46241349e-02f,
  -3.36950086e-02f, 3.70845720e-02f, 1.26553088e-01f, -4.98723276e-02f, 7.78711662e-02f, 2.07110830e-02f, -7.48071000e-02f, 7.58502185e-02f, 4.24419492e-02f, 5.50768152e-02f,
  -2.88897663e-01f, -3.10458124e-01f, 3.13289344e-01f, -2.34106377e-01f, -1.27243191e-01f, 2.34287843e-01f, 2.24197358e-01f, -3.02781194e-01f, -3.30290109e-01f, -1.00887790e-01f,
  -4.39351946e-02f, -9.81830582e-02f, 3.63890946e-01f, -1.92361876e-01f, 4.45059389e-01f, 3.46964866e-01f, -8.91911015e-02f, 1.85254822e-03f, -1.24299955e-02f, -2.88094848e-01f,
  -1.44853204e-01f, -3.34886700e-01f, 2.90668786e-01f, -3.26634556e-01f, -2.46207714e-01f, -2.92409420e-01f, 1.71193536e-02f, 1.26678720e-01f, -1.91681296e-01f, 1.29560098e-01f,
  -2.19371811e-01f, -2.67550677e-01f, -1.41838849e-01f, 8.69504735e-03f, -3.06542870e-02f, 8.57902765e-02f, 9.15503874e-02f, 1.39941454e-01f, -6.46707341e-02f, -3.98329832e-02f,
  6.66393042e-02f, -4.39980514e-02f, -1.95336178e-01f, 2.97157969e-02f, -7.38013089e-02f, -5.39059490e-02f, 9.23500583e-03f, -2.67301407e-02f, -4.10812572e-02f, 8.22814405e-02f,
  -1.79526042e-02f, -1.14637921e-02f, 1.70676247e-03f, -1.93634089e-02f, 1.16204411e-01f, -3.92986760e-02f, 6.22738637e-02f, 6.51849285e-02f, -1.25820920e-01f, -5.75925112e-02f,
  3.42735015e-02f, 5.54615492e-03f, -8.68898258e-03f, -6.79970458e-02f, 2.77311564e-03f, -2.92565394e-02f, -2.64656413e-02f, 9.60457176e-02f, 4.27611321e-02f, 9.32911038e-03f,
  -4.39084023e-02f, -1.99153572e-02f, -5.26059419e-02f, -1.63542833e-02f, 3.46013494e-02f, -4.37061414e-02f, 1.16936594e-01f, -1.23388297e-03f, 1.65743865e-02f, -8.87919869e-03f,
  6.30593374e-02f, 1.36163142e-02f, -1.70878693e-02f, -2.48301774e-03f, -4.70859185e-02f, 7.66676143e-02f, -1.22872740e-01f, 2.75021158e-02f, -4.22581658e-02f, 5.55807650e-02f,
  -3.32733065e-01f, -3.56625050e-01f, -1.04348220e-01f, -3.58406454e-02f, -3.51766385e-02f, -6.36719316e-02f, 6.01836015e-03f, -7.89914504e-02f, 3.41463685e-02f, -4.75358218e-03f,
  -3.46267819e-02f, -1.14278430e-02f, -7.35838935e-02f, -6.49587810e-02f, -7.53031075e-02f, -3.44619006e-02f, -8.64844248e-02f, -4.04096544e-02f, -2.82169133e-02f, -2.27699671e-02f,
  -6.85625970e-02f, 1.02718240e-02f, 5.99909723e-02f, -6.64798319e-02f, -6.88118581e-03f, 1.36587936e-02f, -7.96080306e-02f, -1.57487355e-02f, 7.57008716e-02f, -2.06538364e-02f,
  -9.79632586e-02f, 3.89059372e-02f, 1.53919667e-01f, 8.67212862e-02f, 5.21010935e-01f, 3.06808919e-01f, 1.35583699e-01f, 4.64179575e-01f, 5.08531451e-01f, -8.30804333e-02f,
  8.37876499e-02f, -2.78145354e-02f, -3.85634154e-02f, 5.89344576e-02f, -3.39483172e-02f, 3.83948386e-02f, -5.15387990e-02f, -4.25220206e-02f, 1.61831975e-01f, 1.76545307e-02f,
  7.95886219e-02f, -2.51742993e-02f, -1.76974431e-01f, -6.70790076e-02f, -5.61944060e-02f, -1.78277776e-01f, -3.78173649e-01f, 1.88142585e-03f, -1.50917590e-01f, 8.14163499e-03f,
  -4.45621274e-03f, 2.42847614e-02f, 2.14904621e-02f, 5.57809556e-03f, -2.39247717e-02f, 1.31609123e-02f, -9.43402052e-02f, -7.43129328e-02f, -4.74300012e-02f, 5.41455708e-02f,
  -3.91710753e-04f, 5.71509488e-02f, 2.90638544e-02f, -2.84212362e-02f, 1.20013647e-01f, 4.29481268e-02f, -2.65985578e-02f, 1.73480324e-02f, 3.13740559e-02f, 2.47208364e-02f,
  9.34174880e-02f, -1.90975983e-02f, -4.79285643e-02f, -1.41417295e-01f, 6.17781393e-02f, 1.06126815e-01f, -4.23796028e-02f, -1.50904045e-01f, 2.74814088e-02f, 3.92695144e-03f,
  6.34330511e-02f, 6.67303205e-02f, 6.57568127e-03f, 3.87477735e-03f, 8.91125649e-02f, 2.25773156e-02f, 3.05137504e-02f, 3.40760909e-02f, 1.60006993e-02f, 5.10394536e-02f,
  1.32275531e-02f, 2.72281356e-02f, 1.88080128e-02f, 4.30043451e-02f, -4.38892544e-04f, -2.03185603e-02f, 1.10868248e-03f, 7.99368098e-02f, 8.68013948e-02f, 4.99603935e-02f,
  4.36067581e-02f, 7.21695414e-03f, 3.84895189e-04f, -6.53059874e-03f, 2.91368105e-02f, 4.45239507e-02f, -3.41019109e-02f, 4.25944813e-02f, -6.77631423e-02f, -3.73854302e-02f,
  -8.11815113e-02f, -1.71769615e-02f, 1.12578124e-02f, 1.06245115e-01f, -1.16773592e-02f, 6.41522184e-03f, -8.31158608e-02f, 1.64237281e-03f, -4.94204648e-02f, 5.84755316e-02f,
  -6.59176782e-02f, 4.73091658e-03f, 1.28685459e-02f, -7.57614225e-02f, -1.37114793e-01f, 9.31872874e-02f, -5.52569367e-02f, 1.62232984e-02f, -2.08053123e-02f, -6.67677075e-02f,
  -2.06091776e-02f, -5.72098270e-02f, -4.97726165e-02f, 3.95419151e-02f, -5.62882498e-02f, -1.37879610e-01f, -9.25029889e-02f, 4.13284963e-03f, -4.39944863e-03f, 3.38194915e-03f,
  2.82366753e-01f, -3.87065291e-01f, 1.92910239e-01f, 7.30088115e-01f, 1.40400693e-01f, -1.87128216e-01f, -4.34057340e-02f, 1.17246643e-01f, 4.29657847e-01f, -2.92925835e-01f,
  -1.25142215e-02f, -2.16996044e-01f, -2.17127278e-01f, 1.95034251e-01f, -1.84299722e-02f, -1.42850161e-01f, 1.48223370e-01f, -1.55524001e-01f, 1.87200710e-01f, 1.52154163e-01f,
  3.44256371e-01f, 6.33207262e-02f, 1.05564035e-01f, -1.03911363e-01f, 1.50320143e-01f, 2.31551260e-01f, -5.51667809e-02f, -1.93351015e-01f, -1.07194580e-01f, -1.96955502e-01f,
  -1.32598087e-01f, 2.06907511e-01f, 8.62701014e-02f, -1.09417336e-02f, 3.68929133e-02f, 1.24263056e-02f, -4.70748544e-02f, -7.80674145e-02f, 8.98198634e-02f, 2.45017782e-02f,
  -1.07092917e-01f, 4.38337475e-02f, 5.25693223e-02f, -1.17622629e-01f, 1.43453136e-01f, 1.09409221e-01f, 6.00163415e-02f, 1.02694526e-01f, -2.38393247e-02f, -7.03946641e-03f,
  1.25519469e-01f, -2.57042162e-02f, 1.51212126e-01f, -8.85245278e-02f, 9.36714411e-02f, 1.17042243e-01f, -7.94472694e-02f, -1.59634262e-01f, -1.49307484e-02f, 9.04617682e-02f,
  2.84965709e-02f, -9.96598136e-03f, 5.15251281e-03f, 2.75449678e-02f, 9.05003690e-04f, 5.50840050e-02f, -1.74190979e-02f, -7.42662475e-02f, 8.21378920e-03f, -1.29584810e-02f,
  7.42128044e-02f, 2.32083444e-02f, 3.05131227e-02f, 5.18882414e-03f, 3.85796912e-02f, 7.50944540e-02f, -6.84676841e-02f, -6.62052780e-02f, 1.69950470e-01f, 3.32208388e-02f,
  2.86981952e-03f, -5.15794717e-02f, -9.43039656e-02f, -8.35246779e-03f, -8.18048865e-02f, -2.73898523e-02f, 4.55679819e-02f, -2.18482222e-02f, 2.82251779e-02f, -8.50334689e-02f,
  -2.11589172e-01f, -3.14023010e-02f, -6.00934848e-02f, -5.43617755e-02f, -1.21991977e-01f, -9.91229713e-02f, -4.46346179e-02f, -6.21773899e-02f, -2.34355088e-02f, -2.78499592e-02f,
  -1.00564789e-02f, -1.21367890e-02f, -1.03797369e-01f, 1.86180044e-02f, -2.85698231e-02f, -4.55969237e-02f, 1.09665487e-02f, -6.62094355e-02f, 5.19005507e-02f, -6.76630884e-02f,
  -6.50414824e-02f, -3.14413160e-02f, 3.64955515e-02f, 5.85815869e-02f, -2.00490765e-02f, 1.45478072e-02f, 3.77136916e-02f, 2.34528296e-02f, -8.61145779e-02f, -8.17296654e-02f,
  -1.98037162e-01f, 4.99678940e-01f, 8.65239501e-02f, 1.19290918e-01f, -2.72319317e-01f, 2.01927125e-01f, 1.46170586e-01f, 6.37421981e-02f, 4.16678071e-01f, 1.69256717e-01f,
  -1.54216275e-01f, 2.03491881e-01f, 8.91285017e-02f, -3.88772320e-03f, 5.55220768e-02f, 1.74817309e-01f, 2.18789369e-01f, 1.30351797e-01f, 1.62932634e-01f, -7.73062855e-02f,
  -1.02223948e-01f, -1.75324619e-01f, -1.28003255e-01f, -3.36299539e-02f, -1.62605628e-01f, 1.31221367e-02f, -2.81337410e-01f, 2.30937568e-03f, -1.17754377e-01f, 5.15453257e-02f,
  -8.23707730e-02f, 4.95830290e-02f, -1.76226154e-01f, 1.84503272e-02f, -4.86288853e-02f, -2.57434510e-02f, 4.85245883e-02f, -1.62843484e-02f, -5.66877574e-02f, 2.05754209e-03f,
  5.73430881e-02f, 3.48263271e-02f, 6.17497563e-02f, 1.03391595e-02f, -1.17073196e-03f, -7.48118758e-02f, -8.95785838e-02f, -8.51699784e-02f, 6.36801347e-02f, 1.48482826e-02f,
  1.96102425e-03f, -1.22560427e-01f, -1.17247077e-02f, -3.09337163e-03f, -3.01970374e-02f, -1.87709704e-02f, 6.58410117e-02f, -1.22790709e-02f, -5.53831458e-02f, 4.68617380e-02f,
  8.89816731e-02f, 8.57428610e-02f, -3.74731049e-02f, -8.47427174e-02f, 2.80508446e-03f, -4.50528935e-02f, 2.82339323e-02f, -8.76624063e-02f, 7.70130157e-02f, -1.00872837e-01f,
  -1.20644562e-03f, -1.10630989e-01f, -4.96598743e-02f, -4.60872101e-03f, 4.74888384e-02f, 9.73651484e-02f, -4.18261290e-02f, 4.54029404e-02f, 5.97023219e-02f, -4.79466803e-02f,
  1.65063795e-02f, -2.32099858e-03f, -1.06549123e-02f, -3.74840349e-02f, -3.86950374e-02f, -2.69023851e-02f, 8.11255276e-02f, -5.90787008e-02f, -4.06887978e-02f, -1.21382251e-01f,
  1.74373806e-01f, 3.11342984e-01f, -6.46333396e-02f, 3.84207396e-03f, 1.23802409e-01f, -8.43030512e-02f, 8.15093368e-02f, -1.31197181e-02f, 1.05855659e-01f, 1.25290468e-01f,
  2.51529925e-02f, -1.22408671e-02f, -1.63616762e-02f, -3.96997593e-02f, 7.22894594e-02f, 9.08404440e-02f, 1.17646903e-02f, 1.22971907e-01f, 1.17647044e-01f, -4.96512167e-02f,
  -1.20067231e-01f, 2.16843989e-02f, -2.09126770e-02f, -3.06662116e-02f, 2.88656075e-02f, -4.96094897e-02f, 4.57844399e-02f, 4.36048806e-02f, 2.70364955e-02f, 4.12378348e-02f,
  -1.24900065e-01f, 4.52182829e-01f, -3.73281926e-01f, -5.85392416e-02f, -2.05823958e-01f, 3.66306961e-01f, 4.01229888e-01f, 5.27091064e-02f, 1.31922469e-01f, 5.23268461e-01f,
  2.48267606e-01f, -1.34588797e-02f, 1.34780243e-01f, 5.81358433e-01f, -6.28954843e-02f, 3.90432149e-01f, 5.46065152e-01f, 3.95764053e-01f, 2.56692804e-02f, 8.90649110e-02f,
  -8.56041089e-02f, 3.77887517e-01f, -9.20909122e-02f, 3.50275747e-02f, 9.27807540e-02f, -3.03205907e-01f, -1.34246022e-01f, -3.26033324e-01f, 5.98439313e-02f, 5.71756670e-03f,
  1.57193467e-01f, 2.09088586e-02f, -1.09297603e-01f, 5.51248295e-03f, 2.71736784e-03f, 5.16415127e-02f, -5.31001426e-02f, -8.60617384e-02f, -9.85239968e-02f, 2.75935363e-02f,
  3.90981026e-02f, -4.32950817e-02f, 1.26553163e-01f, -2.38139997e-04f, -4.29650955e-02f, -4.69917692e-02f, -1.60795003e-02f, -1.92721728e-02f, -5.43424338e-02f, -1.26480302e-02f,
  -6.26118155e-04f, 8.59458523e-05f, -9.06674191e-04f, 2.54971236e-02f, -1.04543164e-01f, -6.82865307e-02f, 6.23482838e-02f, -8.97955224e-02f, 1.62999909e-02f, 3.73347104e-02f,
  9.46135893e-02f, 1.59258898e-02f, 1.48766696e-01f, -1.73079725e-02f, -8.29593558e-03f, -1.17742559e-02f, 2.17492338e-02f, -4.04101312e-02f, -7.42876977e-02f, 6.87109455e-02f,
  -7.15291575e-02f, -1.32833850e-02f, 1.85887516e-02f, 7.90993199e-02f, 7.37748295e-02f, 1.10434284e-02f, -3.95802967e-02f, 2.51689646e-02f, 1.12742204e-02f, -1.15188293e-01f,
  3.40266079e-02f, 3.37210745e-02f, -2.08410225e-03f, 3.29614878e-02f, -1.79618262e-02f, -3.55948508e-02f, 6.93344846e-02f, 4.91205649e-03f, -5.94700351e-02f, -3.44702899e-02f,
  1.97219074e-01f, 2.75928229e-01f, 1.11339781e-02f, -3.40874419e-02f, -1.03806533e-01f, 1.06035821e-01f, 6.26808405e-02f, 7.51115754e-02f, 2.81333346e-02f, 6.76008910e-02f,
  -8.81451741e-02f, -8.97786841e-02f, -1.11554051e-02f, -8.21164399e-02f, -6.43792003e-02f, 1.35490879e-01f, 7.12353736e-02f, -5.53167351e-02f, -1.39144119e-02f, -2.51499042e-02f,
  -6.58798888e-02f, 1.09596670e-01f, -2.18646545e-02f, -3.58837992e-02f, -1.20834038e-02f, 5.07810675e-02f, 4.97711916e-03f, -2.70294324e-02f, 3.56051861e-03f, 4.43352759e-02f,
  -1.11406669e-01f, 3.06073755e-01f, 1.15345232e-01f, -1.99078321e-02f, 5.35805598e-02f, -3.13243389e-01f, -1.32582441e-01f, 3.58915552e-02f, -6.69527873e-02f, 2.66942501e-01f,
  -8.23307186e-02f, 2.26115659e-01f, -1.91379450e-02f, -1.65419996e-01f, -7.64920354e-01f, -4.57122654e-01f, -2.67042279e-01f, -1.90156817e-01f, -5.57014868e-02f, 7.66174821e-03f,
  -2.16731444e-01f, -7.78056681e-02f, -1.29811987e-01f, 1.99609563e-01f, 1.41763821e-01f, 2.23852202e-01f, 5.38836457e-02f, 2.80972987e-01f, 8.67530033e-02f, -5.32664508e-02f,
  -6.02428205e-02f, 6.06337301e-02f, 2.67629474e-02f, -1.18063774e-03f, -5.39998300e-02f, 4.93640192e-02f, 3.38738076e-02f, -4.35867421e-02f, -4.37878352e-03f, -8.06260705e-02f,
  5.47875166e-02f, -5.69042750e-02f, 9.77693498e-02f, 5.14225438e-02f, 5.22551686e-02f, 8.94443989e-02f, -1.54651850e-02f, 3.03684212e-02f, 4.01331075e-02f, 5.65710217e-02f,
  -4.08083275e-02f, 2.28560418e-02f, -8.18182155e-02f, -5.17665967e-02f, -1.25406487e-02f, 5.15026180e-03f, -9.20055807e-02f, 8.51039886e-02f, -1.11251287e-02f, 1.77453887e-02f,
  -7.90317450e-03f, -3.85504998e-02f, 1.60460100e-02f, -3.80708985e-02f, -2.03837194e-02f, -1.21198836e-05f, -3.73540190e-03f, -1.07322470e-03f, 1.40086552e-02f, -5.60786924e-04f,
  5.76964207e-02f, -9.19504184e-03f, -5.62023297e-02f, -2.05256790e-02f, -3.64947170e-02f, 3.01030353e-02f, 4.54445556e-02f, 2.03989055e-02f, 1.82987265e-02f, -3.87332700e-02f,
  6.85244333e-03f, -9.32908729e-02f, 6.11147583e-02f, 1.67024378e-02f, -9.68971327e-02f, 4.53489088e-02f, -1.49146412e-02f, -5.11961915e-02f, 1.44038768e-02f, -3.71393487e-02f,
  -1.72975793e-01f, 9.10826027e-03f, 3.46981212e-02f, 7.89078698e-02f, -2.47864835e-02f, 1.72115285e-02f, -7.96469525e-02f, -3.26697789e-02f, -4.44826297e-02f, 1.47844423e-02f,
  -6.96472451e-02f, 5.25108203e-02f, -8.54291320e-02f, 8.64905957e-03f, -5.18282168e-02f, -7.34548792e-02f, -5.27340919e-03f, 3.31526920e-02f, 2.50738543e-02f, 2.84751467e-02f,
  1.29590154e-01f, 1.00225307e-01f, 4.90894839e-02f, -5.07781059e-02f, -6.15038574e-02f, 2.49712765e-02f, -2.75985012e-03f, 1.44639611e-02f, 5.15209846e-02f, -2.26818845e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.86011606e-01f, 2.71463543e-01f, 1.97711200e-01f, 3.01557839e-01f, 3.92718107e-01f, 3.29820573e-01f, 2.20188752e-01f, 1.01898454e-01f, 4.43451345e-01f, 1.87178537e-01f,
  1.50437996e-01f, 2.53379196e-01f, 2.16797709e-01f, 2.70974815e-01f, 1.49218678e-01f, 3.49860847e-01f, 9.68062058e-02f, 1.08659193e-01f, 3.51622969e-01f, 1.05859227e-01f,
  4.05357093e-01f, 3.54832977e-01f, 2.41767958e-01f, 2.90049076e-01f, 4.05046135e-01f, 2.27169290e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  1.88996375e-01f, -3.24973136e-01f, -5.11124432e-01f, -1.82066076e-02f, -2.70914555e-01f, 3.50201935e-01f, 5.24746329e-02f, 1.02844250e+00f, -2.31989041e-01f, -3.28695238e-01f,
  -1.81082994e-01f, 1.54369444e-01f, -3.31459254e-01f, 1.25236854e-01f, -3.49561632e-01f, 2.54523586e-02f, 4.05406117e-01f, -2.44954810e-01f, 1.59118399e-01f, -1.36465698e-01f,
  -1.32126078e-01f, 8.45621526e-02f, -2.33590186e-01f, -1.99685633e-01f, -9.81924757e-02f, 1.75648093e-01f, 3.09577107e-01f, -3.27258319e-01f, 6.52935682e-03f, 9.56169441e-02f,
  7.68307149e-01f, -2.72326201e-01f, -8.03581998e-02f, -2.59938955e-01f, 6.29532933e-01f, -1.00788176e+00f, -5.81607044e-01f, 4.05720443e-01f, 7.35804718e-03f, -2.81648070e-01f,
  6.76468536e-02f, -4.35208529e-01f, -3.53840441e-01f, 4.92433190e-01f, -1.92601517e-01f, 1.48157373e-01f, 3.00552309e-01f, -1.66583359e-01f, -3.00608784e-01f, -5.71165904e-02f,
  -1.67314276e-01f, -3.01211327e-01f, 1.57084733e-01f, -2.98449725e-01f, -2.59410113e-01f, 3.86783481e-01f, -4.10565048e-01f, -2.90617079e-01f, -5.83949983e-01f, 3.33782166e-01f,
  -5.02981186e-01f, -1.33472756e-01f, 9.91735160e-01f, -4.71480519e-01f, -1.80073082e-01f, -1.79419555e-02f, -2.90586978e-01f, -5.99344611e-01f, 2.87461966e-01f, -7.50127792e-01f,
  -3.18892986e-01f, -1.42013967e-01f, -2.44385406e-01f, -8.25731754e-02f, 3.19710940e-01f, 9.84475076e-01f, -2.37440854e-01f, -1.75194427e-01f, 6.57417476e-01f, -1.41907796e-01f,
  -1.95521250e-01f, -1.58973202e-01f, 3.26456845e-01f, -2.30402052e-01f, -2.13518322e-01f, -3.17064703e-01f, -1.57441989e-01f, -2.59739161e-01f, -2.79993087e-01f, -2.41000533e-01f,
  -2.64157712e-01f, -3.51730794e-01f, 2.33280212e-01f, -3.26979667e-01f, -4.15804923e-01f, 9.41796601e-02f, 1.45947412e-01f, -3.51378530e-01f, 5.49907945e-02f, 3.48551899e-01f,
  2.20851958e-01f, -9.50031728e-02f, 2.04268545e-01f, 5.05605698e-01f, 1.22185692e-01f, 5.91506541e-01f, -2.18017936e-01f, -1.83666885e-01f, -2.53147483e-01f, -1.11782074e-01f,
  -9.63402018e-02f, -8.61520097e-02f, 9.98176575e-01f, -5.54424245e-03f, -2.50814825e-01f, 4.04657602e-01f, 2.10824143e-02f, -2.68139333e-01f, 1.04520537e-01f, 1.21466182e-01f,
  -7.08745569e-02f, 1.20797828e-01f, -3.70263100e-01f, 1.20354019e-01f, -2.42537670e-02f, 2.45756805e-02f, -2.01799676e-01f, 6.09273672e-01f, 3.50133665e-02f, 2.58206189e-01f,
  3.84883463e-01f, 5.38844883e-01f, 8.14407706e-01f, 5.35527170e-01f, -3.14658344e-01f, 6.92279756e-01f, -6.66657556e-03f, -5.38745783e-02f, 1.34657472e-01f, -5.17477430e-02f,
  -6.84534833e-02f, -2.75295317e-01f, -2.12118417e-01f, 5.45587420e-01f, -2.97399461e-01f, -2.52531826e-01f, -3.14473510e-01f, 6.15820110e-01f, 3.88164401e-01f, -1.03268223e-02f,
  -1.43409684e-01f, -2.69806713e-01f, 7.23611772e-01f, 4.45738807e-02f, 5.53611577e-01f, 3.94316971e-01f, -2.99936801e-01f, 5.78704327e-02f, -1.06370032e-01f, -2.84443945e-01f,
  2.39964500e-01f, -2.64270902e-02f, 1.00500010e-01f, 2.90818095e-01f, -7.03672886e-01f, 4.27236378e-01f, 3.51781219e-01f, -1.92559138e-01f, -1.29924729e-01f, 1.35053068e-01f,
  -2.63287663e-01f, -7.24479437e-01f, 5.52644193e-01f, -1.61717504e-01f, 5.36894761e-02f, -2.49839813e-01f, 8.08765413e-04f, 2.13764161e-01f, 4.87473339e-01f, -3.13999921e-01f,
  -3.23116392e-01f, 1.38852283e-01f, 4.40317661e-01f, -1.80250913e-01f, 8.96897316e-02f, -1.16496377e-01f, -1.60288706e-01f, 2.95449197e-01f, -3.88270281e-02f, 9.13046539e-01f,
  4.86635268e-01f, -4.75304335e-01f, -3.02570909e-02f, -1.13122031e-01f, 4.41931933e-01f, 6.98841810e-01f, 3.96653354e-01f, 3.56010348e-03f, -3.37667137e-01f, -3.69678408e-01f,
  1.01472646e-01f, -5.55785820e-02f, 4.35447872e-01f, -4.84039515e-01f, 4.76701885e-01f, -1.10316619e-01f, 4.98555571e-01f, -1.96054131e-01f, -3.18474889e-01f, 1.27037019e-01f,
  2.46523529e-01f, -1.55159561e-02f, -2.87452817e-01f, -3.75521809e-01f, 3.39396149e-02f, -6.47784248e-02f, -4.41392004e-01f, -2.29203925e-01f, -2.41048500e-01f, 5.83972931e-01f,
  1.06480253e+00f, -3.02339256e-01f, -3.49089265e-01f, -1.65554613e-01f, -1.35242641e-01f, -2.75135249e-01f, -3.33396494e-01f, -2.17871144e-01f, 2.48983309e-01f, -2.71466225e-01f,
  -3.59159797e-01f, -2.52568513e-01f, -9.58585516e-02f, 8.95798028e-01f, -1.72103401e-02f, -2.16662467e-01f, 1.39540166e-01f, 1.73204198e-01f, -7.13656619e-02f, -2.08904758e-01f,
  -3.22704688e-02f, -1.74810931e-01f, -1.26943722e-01f, 2.51149297e-01f, 1.40483335e-01f, -1.59930766e-01f, 1.79315835e-01f, 6.33549273e-01f, 3.99026364e-01f, 5.80571711e-01f,
  4.06318933e-01f, -1.59549639e-01f, -1.86565772e-01f, -8.09933618e-02f, -2.64135540e-01f, -2.87203014e-01f, -3.15880418e-01f, -1.95656657e-01f, -2.53092229e-01f, -3.26156825e-01f,
  -2.68703938e-01f, -6.11911535e-01f, 1.65053070e-01f, -6.03806339e-02f, -3.06398839e-01f, -3.03007159e-02f, 9.17918310e-02f, -3.28671396e-01f, 8.31165761e-02f, -3.75246316e-01f,
  -3.76228616e-02f, 1.47837758e-01f, -2.01683849e-01f, 3.48728776e-01f, -1.50500506e-01f, 2.89418211e-04f, 1.16998696e+00f, -2.55309641e-01f, -2.95026869e-01f, -2.37243384e-01f,
  -2.01562718e-01f, -1.04814261e-01f, -2.76652306e-01f, -2.07655683e-01f, 4.26453203e-01f, -3.97895947e-02f, -1.07528329e-01f, -2.39801756e-03f, 2.08850935e-01f, 2.95850396e-01f,
  -1.26088798e-01f, 4.55696553e-01f, -3.41520578e-01f, 5.33119380e-01f, 5.70199126e-03f, -4.02254313e-01f, -2.88837969e-01f, -2.18475446e-01f, 6.46690845e-01f, -3.79463546e-02f,
  -2.66080678e-01f, -2.86738187e-01f, 7.14131653e-01f, 6.88202307e-02f, -2.95927137e-01f, -3.33899230e-01f, 2.54174560e-01f, -8.74985382e-02f, -3.45108241e-01f, -1.26995221e-01f,
  -1.68009698e-02f, 3.38882744e-01f, -4.92177084e-02f, 2.71077842e-01f, 9.63948905e-01f, -1.87984854e-01f, -2.57540137e-01f, -3.15532416e-01f, -4.99101549e-01f, -1.46029249e-01f,
  -5.21321855e-02f, 7.04064295e-02f, 2.83550322e-01f, -7.87370145e-01f, 6.35844767e-01f, 1.05514929e-01f, 1.33601919e-01f, -4.12840813e-01f, 6.61731660e-01f, -3.10981244e-01f,
  -2.44024932e-01f, 3.71031076e-01f, -1.13518238e-01f, 5.73899329e-01f, -5.17262757e-01f, -8.98366123e-02f, 4.27435607e-01f, 4.89220887e-01f, -2.29029492e-01f, 2.65301257e-01f,
  7.27294162e-02f, 3.83150190e-01f, 3.44746113e-02f, -3.29649866e-01f, -3.18786949e-01f, 1.67780578e-01f, -9.34053883e-02f, -2.65676677e-01f, -1.61596254e-01f, -2.08297402e-01f,
  -2.59763211e-01f, 3.99847686e-01f, -6.37507346e-03f, 1.56372160e-01f, -3.98731208e-04f, 4.73670572e-01f, 3.45643878e-01f, -6.29584372e-01f, 6.35188818e-01f, -2.59635955e-01f,
  -2.24168882e-01f, 5.46466768e-01f, 4.42441493e-01f, -3.54512364e-01f, -1.73674539e-01f, 7.92530924e-02f, -3.43293428e-01f, 3.82149279e-01f, -5.06088018e-01f, -1.21459357e-01f,
  -2.60468185e-01f, -4.19951141e-01f, -3.31099451e-01f, 7.53298104e-01f, -8.28739554e-02f, -2.19356447e-01f, 3.08441103e-01f, -1.40337661e-01f, -2.96298206e-01f, -3.62844802e-02f,
  1.02100231e-01f, 9.00534242e-02f, -5.65382950e-02f, 5.95773697e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.43012622e-01f, 2.79162228e-01f, 2.91143954e-02f, -5.23134828e-01f, 1.73327878e-01f, 2.85493284e-01f, 1.33359268e-01f, -2.98206747e-01f, -1.08989179e-01f, 9.31093767e-02f,
  7.26969242e-02f, 1.04943395e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    