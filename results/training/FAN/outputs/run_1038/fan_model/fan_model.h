/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.09324893e-02f, -1.76895931e-01f, 6.04528049e-03f, -1.30562454e-01f, -1.84154198e-01f, -1.13765746e-02f, -1.78456604e-01f, 1.32159114e-01f, 3.03105209e-02f, -1.49078250e-01f,
  -3.09150875e-01f, -2.21662492e-01f, -2.80929983e-01f, -1.93842128e-01f, -8.32123384e-02f, -1.36302903e-01f, 1.53891712e-01f, 2.96482034e-02f, -9.86048505e-02f, -1.90451041e-01f,
  -1.73845008e-01f, -1.94689408e-02f, 1.02190249e-01f, 4.93146405e-02f, 8.70910138e-02f, -2.08095461e-03f, 4.20192517e-02f, 1.76673047e-02f, -3.91575769e-02f, 1.02890894e-01f,
  -1.99021056e-01f, 2.76174396e-01f, 1.64669715e-02f, -8.94642025e-02f, -8.70053545e-02f, 1.41506754e-02f, -8.08190480e-02f, 5.54804653e-02f, -3.84242274e-02f, -2.42575444e-02f,
  4.44436036e-02f, -9.43700969e-02f, 5.48984855e-03f, 8.29808936e-02f, 1.01089321e-01f, 6.93524927e-02f, 6.06917366e-02f, 1.09074943e-01f, -2.26086751e-02f, -6.54673278e-02f,
  -1.25474676e-01f, -6.84619769e-02f, -6.57190606e-02f, -7.22629428e-02f, 9.37915444e-02f, 2.80545540e-02f, 9.23134908e-02f, 1.32044340e-02f, 1.29051864e-01f, 8.95442292e-02f,
  -2.65767306e-01f, 2.25064307e-02f, 7.77519634e-03f, -2.71281302e-02f, -1.29284710e-01f, -6.15502559e-02f, 1.98178273e-02f, -9.98104140e-02f, -1.65994614e-02f, 5.24721108e-03f,
  -4.17506807e-02f, -1.48999587e-01f, -1.01416104e-01f, -1.85202938e-02f, -6.84767310e-03f, -1.18291340e-04f, -3.51084433e-02f, 1.54542120e-03f, -1.42705692e-02f, 9.72432122e-02f,
  -7.59212151e-02f, 1.35945916e-01f, 6.90234527e-02f, -1.19977929e-02f, -1.04950462e-02f, 1.21872686e-01f, 7.68608674e-02f, -4.39544544e-02f, -1.71761587e-02f, 1.51422955e-02f,
  -1.82320699e-01f, -1.18078880e-01f, -1.18781984e-01f, 3.95399146e-02f, 1.37787228e-02f, 1.60833597e-02f, -8.94001424e-02f, -2.49980483e-02f, -6.09471314e-02f, 1.69046223e-02f,
  3.07266042e-02f, -4.36241105e-02f, -4.46685515e-02f, 3.55664380e-02f, -9.61154476e-02f, -1.12067498e-02f, -1.28829867e-01f, -5.51729687e-02f, -8.36667418e-02f, 4.66508567e-02f,
  7.34069897e-03f, -8.39625448e-02f, -1.27330720e-01f, -1.51748303e-02f, -3.74663286e-02f, -1.50112644e-01f, -8.40982348e-02f, -2.78384816e-02f, -8.25331360e-02f, -3.37553918e-01f,
  1.50668517e-01f, 3.29036593e-01f, 1.40900061e-01f, 4.36871648e-02f, 9.28679407e-02f, -1.14815742e-01f, 2.66985118e-01f, 3.30961943e-02f, -1.47421688e-01f, 1.71669066e-01f,
  -5.38981780e-02f, -3.11231792e-01f, -7.27044195e-02f, -1.63325742e-01f, -1.28011599e-01f, 3.08659881e-01f, 1.71289310e-01f, 1.06465809e-01f, -1.76665485e-02f, -6.67429939e-02f,
  -4.86576632e-02f, 1.22141659e-01f, 1.64574739e-02f, -1.63094178e-01f, 6.90472648e-02f, -1.53827235e-01f, 1.92531794e-02f, -2.75198594e-02f, -1.54176071e-01f, 3.50334585e-01f,
  2.59500057e-01f, 1.65853962e-01f, -2.14265212e-02f, -7.25903660e-02f, 1.02601394e-01f, 1.20231211e-01f, 1.16058931e-01f, 1.09121025e-01f, -5.29462565e-03f, 7.75301829e-02f,
  2.76818220e-02f, 1.21166579e-01f, 1.22678548e-01f, 5.75069673e-02f, 2.14424074e-01f, 2.04833299e-01f, 7.21958578e-02f, 6.18097670e-02f, 1.00010492e-01f, 1.21743433e-01f,
  3.34564894e-02f, 6.52124584e-02f, 1.45252183e-01f, -1.77030507e-02f, -5.95615581e-02f, -2.57396568e-02f, 7.82466903e-02f, -7.05832765e-02f, -4.02249247e-02f, 9.49102715e-02f,
  -4.99646179e-02f, -1.04750879e-01f, -1.03959613e-01f, -6.84649870e-03f, -1.69925243e-02f, -6.00933619e-02f, 5.45377396e-02f, 1.56574138e-02f, 1.44636584e-02f, 1.52460495e-02f,
  -5.59591688e-02f, 6.25583231e-02f, 5.20078018e-02f, 4.76026870e-02f, -4.56339717e-02f, 1.25180148e-02f, 1.21041585e-03f, 2.32664566e-03f, -9.62178484e-02f, -6.48983493e-02f,
  1.52840279e-02f, 1.10955117e-02f, -3.24185268e-04f, 1.04272142e-02f, -8.07830617e-02f, -3.27964425e-02f, -9.57813393e-03f, 5.24374936e-03f, 7.86797106e-02f, -3.95111442e-02f,
  1.48154706e-01f, -1.09850056e-01f, 1.69742867e-01f, 1.42639473e-01f, 2.19281875e-02f, -1.23159550e-02f, 4.31016758e-02f, 6.08082823e-02f, 5.75568266e-02f, 1.24002501e-01f,
  -3.14076548e-04f, 1.19623654e-01f, 1.19466186e-01f, 8.58781189e-02f, 6.01081029e-02f, 1.12922164e-02f, 1.13009065e-01f, 4.85662743e-02f, -5.52898087e-02f, 5.75991813e-03f,
  1.83882713e-02f, 2.87654754e-02f, 4.82927524e-02f, 9.78850015e-03f, -1.34949163e-02f, -8.91469792e-03f, 1.29083302e-02f, 5.77885173e-02f, 6.96353316e-02f, 1.18332334e-01f,
  7.22808540e-02f, -4.31249477e-02f, 3.53185862e-01f, 6.93785846e-02f, 2.45972335e-01f, 3.24889809e-01f, 5.25902927e-01f, 8.36109966e-02f, -1.86961398e-01f, 2.13422969e-01f,
  -1.89561605e-01f, -4.18182611e-01f, -2.36218944e-01f, -1.77013606e-01f, -8.04167762e-02f, 3.73275489e-01f, 4.29136842e-01f, 1.13321580e-01f, -9.15469378e-02f, -4.29831408e-02f,
  8.49881908e-04f, -7.67899454e-02f, -1.81481168e-01f, -1.32957891e-01f, 7.35238343e-02f, -1.27039731e-01f, -9.34364833e-03f, -4.04014215e-02f, -1.09586239e-01f, 7.88357407e-02f,
  -5.40758260e-02f, 6.37192279e-02f, 1.91510879e-02f, -5.92848659e-02f, -7.46880984e-03f, 5.27456701e-02f, 3.48992236e-02f, -6.91900104e-02f, -3.58920693e-02f, 3.18724662e-02f,
  -1.12838650e-04f, -1.83558203e-02f, -2.24348269e-02f, 4.18581329e-02f, 3.05307955e-02f, 8.95466208e-02f, 7.77928391e-03f, -2.30112970e-02f, 5.07685021e-02f, -1.20090069e-02f,
  4.32931036e-02f, 6.10631239e-03f, 1.54817820e-01f, 6.48719594e-02f, 4.91726287e-02f, -8.46030563e-02f, -7.84660205e-02f, -3.02919559e-02f, 7.02588484e-02f, 2.48995218e-02f,
  -1.72741059e-02f, 6.26052916e-02f, 3.27615812e-02f, -6.95561990e-02f, -9.28266943e-02f, -8.40931907e-02f, -4.60010953e-02f, -9.11224335e-02f, -1.84225459e-02f, 9.07857250e-03f,
  -4.63068187e-02f, 1.04882549e-02f, 3.83488499e-02f, 7.75415823e-02f, -4.33637649e-02f, 8.97990987e-02f, 9.25654396e-02f, 7.77305337e-04f, -4.15728316e-02f, 6.69204742e-02f,
  -9.13130641e-02f, 7.73477554e-02f, 9.10857785e-03f, 4.44417335e-02f, 4.26173322e-02f, 1.96721759e-02f, 6.58674464e-02f, -4.36457843e-02f, -2.36018486e-02f, 8.11535642e-02f,
  -3.08551639e-01f, 1.12159036e-01f, -6.95537403e-02f, -1.48784131e-01f, 9.33207646e-02f, -1.05023131e-01f, -5.89196198e-02f, -5.28662466e-02f, -2.47338135e-02f, -6.43477216e-02f,
  -2.24854928e-02f, -6.96650743e-02f, -1.45791024e-02f, 6.35237694e-02f, 1.75658688e-02f, -2.15095151e-02f, -9.98105705e-02f, -9.97386873e-03f, -4.26418558e-02f, -6.94360631e-03f,
  -8.31825063e-02f, 3.66893806e-03f, -1.24612905e-01f, 6.35679951e-03f, -5.98859601e-02f, 2.55420934e-02f, 4.25254665e-02f, -2.21458562e-02f, 3.57899480e-02f, -3.11137121e-02f,
  2.89983898e-01f, 1.63505331e-01f, 3.48164767e-01f, 9.98486206e-02f, -3.64750251e-02f, -5.48521616e-03f, 2.09022164e-01f, 1.97006732e-01f, -7.76561648e-02f, -3.33863869e-02f,
  -1.39356181e-01f, -2.32820496e-01f, -1.12371556e-01f, -1.45072937e-02f, 3.09091896e-01f, 1.82602227e-01f, 2.43748948e-01f, 2.41724223e-01f, 1.02940202e-01f, -3.90409194e-02f,
  -9.61640924e-02f, 1.35823980e-01f, 2.18023121e-01f, 6.01442270e-02f, -2.29752615e-01f, -2.56412864e-01f, -1.13574892e-01f, -5.34291342e-02f, -1.61701009e-01f, -2.25213259e-01f,
  -2.25312412e-01f, 1.42531425e-01f, 1.28253624e-01f, 2.05405778e-03f, 5.69390766e-02f, 3.49173211e-02f, 6.61539845e-03f, 1.37979880e-01f, -2.10720319e-02f, 1.19284831e-01f,
  -3.27702388e-02f, -2.77572349e-02f, 2.52610520e-02f, 1.02939092e-01f, 6.79243430e-02f, 5.71770892e-02f, 2.00945184e-01f, 2.70445287e-01f, 2.86739692e-02f, 1.31109292e-02f,
  -9.64648351e-02f, -1.01454817e-02f, 9.62437093e-02f, 9.31855887e-02f, 1.03259675e-01f, -1.04618840e-01f, 6.96608126e-02f, 2.66011227e-02f, 1.36140227e-01f, 2.62614749e-02f,
  -1.78478226e-01f, -1.29465595e-01f, -7.47306570e-02f, 2.73215882e-02f, -6.89842105e-02f, -7.73289055e-02f, -1.20190075e-02f, -8.12883228e-02f, -5.09797083e-03f, -7.23255659e-03f,
  -2.96854340e-02f, -1.16263404e-02f, -6.61572218e-02f, 4.51766253e-02f, -6.91363439e-02f, 4.10870127e-02f, -2.54371017e-02f, -6.15940057e-02f, 1.97534673e-02f, 2.96203494e-02f,
  1.01614334e-02f, 2.76014004e-02f, -4.29604314e-02f, 6.31841645e-02f, 5.89930117e-02f, -1.29571017e-02f, -5.09121865e-02f, -8.29279888e-03f, -7.93823879e-03f, 3.64003852e-02f,
  9.45579261e-03f, 1.37220204e-01f, -5.62435016e-02f, 3.55882943e-02f, 3.29887234e-02f, 7.51619786e-03f, -6.42566662e-03f, 1.38106957e-01f, -7.06021721e-03f, -1.95185114e-02f,
  5.13025485e-02f, 1.04630709e-01f, 1.36550171e-02f, 2.97122356e-02f, 7.93599784e-02f, 6.27087131e-02f, 1.13042563e-01f, 6.90221135e-03f, 9.55606699e-02f, 5.25194257e-02f,
  1.61387548e-01f, 6.80720434e-02f, 1.21773593e-01f, 7.60133192e-02f, 1.85886584e-02f, 1.45774465e-02f, 6.79995194e-02f, 4.77682985e-02f, 7.33694136e-02f, 1.42741024e-01f,
  -4.48974997e-01f, -4.49523419e-01f, 4.71656583e-02f, -8.48613456e-02f, -3.70913967e-02f, 1.25793099e-01f, -2.69871298e-02f, 7.70381466e-02f, 9.57667381e-02f, -1.71406105e-01f,
  -1.71364382e-01f, -1.47830639e-02f, 6.08739778e-02f, 9.51638743e-02f, 2.83825751e-02f, -5.56209795e-02f, -5.98786175e-02f, 6.68262616e-02f, 4.04689431e-01f, 1.55692935e-01f,
  1.26152858e-01f, 1.23399585e-01f, 1.76572753e-03f, 1.58956543e-01f, -2.41368949e-01f, 7.30032921e-02f, -2.45328844e-01f, -2.08906338e-01f, -1.22434370e-01f, -4.07893986e-01f,
  4.44398000e-04f, -3.25778365e-01f, 2.95937628e-01f, 5.81991598e-02f, -5.50015271e-03f, 4.04230841e-02f, 1.06395364e-01f, 5.60462773e-02f, 7.90219456e-02f, 1.15437195e-01f,
  4.46047671e-02f, -8.27893708e-03f, 1.55124307e-01f, 1.33265108e-01f, 1.28244385e-01f, 1.64464653e-01f, -4.02155593e-02f, 5.84165566e-02f, 1.47828370e-01f, 4.44360971e-02f,
  6.45478219e-02f, -5.58980033e-02f, 7.78574198e-02f, 9.18240026e-02f, 5.47987334e-02f, 9.19906050e-02f, -3.70096453e-02f, -3.21307071e-02f, 8.52052197e-02f, -1.29187658e-01f,
  1.19899347e-01f, -5.27692512e-02f, -1.63042963e-01f, 1.96897965e-02f, -5.58769004e-03f, -1.65146943e-02f, 1.49270799e-02f, 5.12329005e-02f, 7.17470869e-02f, 6.08352274e-02f,
  4.06586984e-03f, 7.25911036e-02f, 1.48243949e-01f, 3.32162017e-03f, 1.12676866e-01f, 7.54346279e-03f, -5.30997962e-02f, 7.99827799e-02f, 4.00755294e-02f, 7.85119273e-03f,
  3.71407717e-02f, -8.09069350e-02f, -5.97141124e-02f, 9.39254463e-02f, -5.95806353e-02f, 2.11191885e-02f, -4.28301049e-03f, 4.03921828e-02f, 1.16764167e-02f, 2.32876893e-02f,
  3.49107593e-01f, 1.63597882e-01f, 4.20414209e-02f, 8.51575062e-02f, -6.13740087e-02f, -6.02640025e-03f, -8.74255151e-02f, -5.75417140e-03f, -3.76099423e-02f, 1.50441393e-01f,
  3.02949809e-02f, 5.07101901e-02f, -3.78129818e-02f, 1.07392073e-01f, 1.24939993e-01f, 1.10859543e-01f, 3.45672034e-02f, 5.28812110e-02f, 1.46207109e-01f, 2.80546024e-02f,
  9.87190679e-02f, 1.92532271e-01f, 2.15365395e-01f, 9.14066434e-02f, 8.99806991e-02f, 1.67929903e-01f, 1.70679614e-01f, 2.00400621e-01f, 1.62607968e-01f, 2.64550000e-01f,
  2.33264714e-01f, 5.50799817e-02f, 7.20081106e-02f, -6.83078244e-02f, 8.88764039e-02f, 3.23313504e-01f, 4.51561391e-01f, 1.67920947e-01f, -1.64140493e-01f, 4.38332297e-02f,
  2.64171697e-02f, 2.85012219e-02f, -1.32928833e-01f, -1.78315476e-01f, 3.44832987e-02f, 5.30849444e-03f, -1.26281455e-01f, -9.41817686e-02f, 2.19867200e-01f, 2.08306581e-01f,
  4.36208956e-02f, 1.49501786e-02f, -2.18662377e-02f, -3.42527330e-02f, -6.48678765e-02f, 4.05223593e-02f, -1.43424824e-01f, -8.93048123e-02f, 4.21578661e-02f, -3.67228091e-01f,
  -2.98927277e-02f, 1.22343667e-01f, -1.87502429e-02f, -1.18743226e-01f, -9.39379558e-02f, -1.06831528e-01f, 5.02040237e-02f, -1.42533988e-01f, -2.69822171e-03f, -7.48425797e-02f,
  -6.49713054e-02f, -3.74903344e-02f, -6.13469705e-02f, -4.61111106e-02f, 8.77986997e-02f, 2.76650861e-02f, -6.07628301e-02f, -1.14236593e-01f, 2.81995605e-03f, 2.45832410e-02f,
  -6.98176473e-02f, -8.96184742e-02f, 3.56226526e-02f, 4.48648483e-02f, -3.98371555e-03f, -1.43979505e-01f, 3.32489237e-02f, -1.43658161e-01f, 1.34304818e-02f, -6.86924830e-02f,
  -9.17109475e-02f, 4.20475639e-02f, 7.79276863e-02f, 1.57057270e-01f, 1.14616409e-01f, 2.45321412e-02f, -3.37642543e-02f, 7.05210343e-02f, 1.25360554e-02f, 5.15144505e-02f,
  -2.71774679e-02f, 7.90213794e-02f, 5.61198778e-02f, 3.26861702e-02f, 9.65093598e-02f, 6.16358081e-03f, -2.24188380e-02f, -2.26055365e-03f, 6.28667921e-02f, 3.49664837e-02f,
  -5.93475346e-03f, -3.78935002e-02f, -8.64057541e-02f, -1.13470629e-02f, -2.72487216e-02f, -1.03888206e-01f, -6.03832081e-02f, -2.75215842e-02f, -1.52968727e-02f, 5.75984269e-02f,
  2.23063603e-01f, -4.03994098e-02f, -7.39669055e-02f, -3.49000879e-02f, -3.57499681e-02f, -1.23805650e-01f, -1.30159054e-02f, -3.35983150e-02f, 4.10236418e-02f, 6.40250891e-02f,
  -2.17533018e-02f, -7.73576424e-02f, 8.25828165e-02f, -5.12874648e-02f, 8.19435045e-02f, 1.90821402e-02f, 1.78436060e-02f, 8.62985849e-02f, -9.48282108e-02f, 6.80799503e-03f,
  -4.26744036e-02f, 8.06802511e-02f, 1.82542697e-01f, 1.35019615e-01f, -7.04117715e-02f, 9.05158296e-02f, 9.02313441e-02f, -3.42833996e-03f, 1.28261998e-01f, 1.79913178e-01f,
  4.59110856e-01f, 4.28907245e-01f, -2.76154429e-01f, -3.25817838e-02f, -6.20124564e-02f, 1.32182524e-01f, 2.40916535e-01f, 1.88287631e-01f, 1.23188764e-01f, 9.73095819e-02f,
  -3.30505893e-02f, -1.07262686e-01f, -2.02940822e-01f, -1.18959665e-01f, 2.11071730e-01f, 8.88264850e-02f, 1.90997601e-01f, -2.16116775e-02f, -9.21873301e-02f, -6.72641546e-02f,
  -7.42411911e-02f, 1.49438977e-01f, 1.46333799e-01f, 2.84367800e-02f, -1.03258051e-01f, -1.48173019e-01f, -1.07666433e-01f, -6.11540526e-02f, -6.00133389e-02f, -2.36866102e-02f,
  -4.33860958e-01f, 2.16688156e-01f, -1.77213535e-01f, 4.36897166e-02f, -2.37054285e-02f, 8.51664767e-02f, -4.82900552e-02f, 9.46251210e-03f, -6.56196922e-02f, 2.80489326e-02f,
  5.06574623e-02f, 8.54324773e-02f, -4.17388231e-02f, -4.13632803e-02f, 3.91128026e-02f, -6.19002432e-02f, 6.21958822e-02f, 4.03810069e-02f, -7.39870816e-02f, 3.12933400e-02f,
  -4.70230691e-02f, -1.14686908e-02f, -4.96804751e-02f, -8.99697468e-02f, 5.08163460e-02f, 3.11520826e-02f, -9.24560353e-02f, -7.86849260e-02f, 3.53214815e-02f, 4.05683890e-02f,
  5.96285239e-02f, 6.13060407e-02f, 8.46637413e-02f, 3.04614417e-02f, 6.03186972e-02f, 6.77882358e-02f, 1.64160430e-02f, -1.96125060e-02f, 2.61828508e-02f, 6.00886717e-02f,
  4.88307932e-03f, 3.58100757e-02f, 8.94587189e-02f, 5.67456670e-02f, -1.42742783e-01f, 1.26273232e-02f, 6.03682287e-02f, 4.83326288e-03f, -6.43209368e-02f, 1.50213823e-01f,
  7.65366852e-02f, -3.27400081e-02f, 8.65008011e-02f, -1.08614303e-01f, 5.76487519e-02f, 2.50445977e-02f, 1.44179121e-01f, 8.87557566e-02f, 6.98704198e-02f, 2.44963001e-02f,
  -9.31329355e-02f, -8.77806358e-03f, -1.16775207e-01f, -1.06943235e-01f, 2.50282884e-02f, -2.35271193e-02f, -1.40227184e-01f, -8.64785835e-02f, -7.43252039e-02f, -1.59352776e-02f,
  -6.96829520e-03f, -6.45372346e-02f, -7.86455944e-02f, -1.13965146e-01f, -5.28006107e-02f, -6.26006126e-02f, -2.82908361e-02f, -1.39809549e-01f, -5.77941053e-02f, -1.18412010e-01f,
  -4.79157045e-02f, -4.95068990e-02f, 1.98565540e-03f, 8.89116433e-03f, -5.36112897e-02f, -8.61130655e-02f, -5.45653999e-02f, -7.33994544e-02f, 1.53962700e-02f, 1.67571440e-01f,
  -3.11330259e-01f, 1.24273255e-01f, -1.08777866e-01f, -3.12211633e-01f, -1.54798627e-01f, 1.11072548e-02f, -1.25129551e-01f, -8.40841904e-02f, -4.34190482e-02f, 4.46636193e-02f,
  1.93456724e-01f, 1.62581027e-01f, 1.53465658e-01f, 4.76771668e-02f, -1.16607863e-02f, -5.63091412e-02f, -2.12397963e-01f, -2.23804623e-01f, -4.76683713e-02f, -1.74762398e-01f,
  1.00931250e-01f, -1.45422354e-01f, -5.12393117e-02f, -5.45747578e-02f, -8.02519098e-02f, -2.12672986e-02f, 9.05921683e-02f, -8.22210982e-02f, 1.81879550e-01f, -1.79421052e-01f,
  3.97692770e-02f, -1.53356761e-01f, -3.13510969e-02f, -1.20542422e-02f, 4.20029648e-02f, -2.72600092e-02f, 2.16993690e-02f, -3.78205441e-02f, 2.67048161e-02f, -8.68903566e-03f,
  -5.22911847e-02f, 1.06772304e-01f, -5.20559326e-02f, 5.09845875e-02f, -8.94924849e-02f, -2.50399411e-02f, 1.40239624e-02f, 5.97884841e-02f, 1.93368681e-02f, 1.46929803e-03f,
  -4.53160293e-02f, -6.08788878e-02f, -2.73239519e-02f, 1.05086416e-02f, -1.27423333e-03f, -5.07548414e-02f, 7.59575665e-02f, -6.11690767e-02f, 1.16907783e-01f, -3.31500396e-02f,
  1.06206037e-01f, 1.81480259e-01f, 7.54354149e-03f, -8.32630694e-02f, 7.55047947e-02f, 2.79500652e-02f, -4.23259363e-02f, -4.58035097e-02f, -3.55640315e-02f, 7.60039985e-02f,
  2.36982573e-02f, -8.34683180e-02f, 1.43820578e-02f, -6.08649254e-02f, 9.06034783e-02f, -5.55029772e-02f, -6.02622852e-02f, 6.83797821e-02f, -4.72068377e-02f, -2.28893980e-02f,
  -1.48010422e-02f, 5.26434481e-02f, -6.63495660e-02f, -5.19660376e-02f, -2.69713029e-02f, -3.86314280e-02f, -4.60512936e-02f, 3.28132473e-02f, -9.14020743e-03f, -5.49879968e-02f,
  2.61695176e-01f, 3.30962613e-02f, 2.83450112e-02f, -2.89309546e-02f, -7.65164196e-02f, 5.89281656e-02f, 5.06118089e-02f, 4.65850160e-02f, 5.69306035e-03f, -4.00201082e-02f,
  1.33711575e-02f, 2.65175067e-02f, -5.92357665e-02f, 5.06077707e-02f, -9.70510617e-02f, 4.60821763e-03f, 1.10923825e-02f, 2.19414290e-03f, 1.30317202e-02f, -2.48688627e-02f,
  5.78690507e-02f, -9.18781087e-02f, -4.76461127e-02f, 1.13170855e-01f, 5.53559475e-02f, 3.27868685e-02f, 7.26691186e-02f, -1.60553008e-02f, 6.34948239e-02f, -5.07765310e-03f,
  -2.22965535e-02f, -2.78359354e-01f, -3.43059972e-02f, 2.04884604e-01f, -1.35073081e-01f, -3.22109818e-01f, -4.89339441e-01f, -8.98423716e-02f, 1.51876211e-01f, -2.33966798e-01f,
  -8.40738975e-03f, 1.70366004e-01f, 1.18053854e-01f, 3.70029137e-02f, -5.30494712e-02f, -3.84973139e-01f, -2.05496997e-01f, 7.69423321e-02f, 1.48780867e-01f, 7.60504976e-02f,
  -1.07239233e-02f, 2.32467391e-02f, 2.16069400e-01f, 8.61391798e-02f, -2.06903234e-01f, -1.10054739e-01f, -1.63276091e-01f, -3.11599597e-02f, -2.15313733e-01f, -2.92200029e-01f,
  -1.39603913e-01f, -3.32933641e-03f, -5.65211512e-02f, 2.36388743e-02f, -5.48406504e-02f, -1.12395175e-01f, -5.87415658e-02f, -3.03557925e-02f, -2.85903946e-03f, -7.39937089e-03f,
  -1.50962907e-03f, 5.23951277e-02f, 8.12761858e-02f, -7.81550184e-02f, -1.96143668e-02f, 2.59168423e-03f, 7.58983865e-02f, 8.95586386e-02f, -1.48619907e-02f, -6.32162839e-02f,
  -1.55383483e-01f, -4.48360816e-02f, -3.13941054e-02f, -8.76502842e-02f, -5.62872849e-02f, 2.56015956e-02f, -9.90165770e-02f, -1.05772935e-01f, -8.92998353e-02f, -1.49047494e-01f,
  -2.67713740e-02f, -5.97342439e-02f, 9.02597979e-02f, 3.62443812e-02f, 1.61666200e-02f, 2.42028683e-02f, 5.45036942e-02f, -1.21123195e-01f, 6.36834875e-02f, -3.44343223e-02f,
  8.86746123e-02f, -9.73358154e-02f, 9.90672335e-02f, 2.49777809e-02f, 2.51600202e-02f, 8.10680613e-02f, -1.85280163e-02f, 1.18896896e-02f, 5.46601005e-02f, 2.85123549e-02f,
  1.03298157e-01f, -3.74934524e-02f, 3.74775901e-02f, 6.60213083e-02f, 3.00163571e-02f, 9.00986977e-03f, 2.22959858e-03f, 4.72937673e-02f, 9.30739939e-02f, 5.57543635e-02f,
  8.84978995e-02f, -9.18417796e-02f, -9.12971646e-02f, -3.51033243e-03f, 5.66726662e-02f, -6.20362386e-02f, -7.95466900e-02f, -1.83421075e-02f, 4.04348373e-02f, 4.49900255e-02f,
  8.23793001e-03f, -4.41464931e-02f, 3.79764521e-03f, -6.60779923e-02f, -1.38206957e-02f, -4.34640534e-02f, -1.20088644e-01f, -1.13872521e-01f, -1.03843339e-01f, -4.70651761e-02f,
  4.17178875e-04f, -1.63393512e-01f, -1.66649356e-01f, -1.75879911e-01f, -6.85522854e-02f, -1.42311350e-01f, -1.93958193e-01f, -1.55538544e-01f, -1.92335919e-01f, -3.69499177e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.26580667e-01f, -1.55354500e-01f, -1.51272923e-01f, -5.36076605e-01f, -5.54768443e-02f, 4.28314805e-01f, 1.71173453e-01f, 1.85800001e-01f, 8.73218030e-02f, -1.54295132e-01f,
  1.63158476e-01f, 1.17045462e-01f, 7.73849040e-02f, 4.63682003e-02f, -1.28852306e-02f, -1.07951500e-01f, -2.30181277e-01f, -1.10804997e-01f, 3.26326728e-01f, 5.76330304e-01f,
  2.72985220e-01f, -2.46852949e-01f, -1.87033474e-01f, -4.74376120e-02f, -2.49352723e-01f, -2.82475024e-01f, -4.54389811e-01f, -2.77057946e-01f, -4.27603275e-02f, -6.47170782e-01f,
  -1.96429774e-01f, 9.83058289e-02f, 2.33210132e-01f, -3.52434739e-02f, -8.30002129e-02f, 6.41653761e-02f, -5.39633958e-03f, -2.38004819e-01f, 5.11052050e-02f, 5.97879337e-03f,
  -1.09580658e-01f, 1.53328493e-01f, -1.82170570e-01f, -3.04532759e-02f, -9.24656615e-02f, -6.59324452e-02f, -7.31622726e-02f, -1.37418762e-01f, 4.29571494e-02f, 1.79422021e-01f,
  1.00460658e-02f, -8.55014995e-02f, -1.53026015e-01f, -9.99929458e-02f, 2.11967364e-01f, -1.28090933e-01f, 4.19727638e-02f, -5.08107841e-02f, -7.66177997e-02f, -4.58796442e-01f,
  -2.12855339e-02f, -6.91794157e-02f, 1.40715286e-01f, 8.99126157e-02f, -1.42199188e-01f, -1.00746326e-01f, -1.00597695e-01f, 1.98872477e-01f, 1.38425976e-01f, -2.08562613e-01f,
  3.31135839e-03f, -5.88766187e-02f, -7.59312883e-02f, -1.86832875e-01f, 6.40123263e-02f, -5.80143146e-02f, -1.16714381e-01f, -3.87063697e-02f, -6.23578094e-02f, -2.27427542e-01f,
  7.18963295e-02f, 1.42959595e-01f, -1.11769341e-01f, 6.53717220e-02f, -3.38847525e-02f, -2.66185522e-01f, -4.61604558e-02f, 2.44748116e-01f, 1.56741261e-01f, 9.16770846e-02f,
  -4.32539880e-01f, 2.75800247e-02f, -1.93704158e-01f, 1.12653293e-01f, -1.75132193e-02f, -1.18984096e-02f, -1.06938362e-01f, 7.02652633e-02f, 2.45500612e-03f, 1.94026204e-03f,
  2.39408985e-01f, -1.04434855e-01f, -5.13939410e-02f, 1.13269739e-01f, 2.43991867e-01f, 1.21799279e-02f, -1.29583970e-01f, -1.45172663e-02f, 1.58535615e-01f, 1.32485330e-01f,
  1.18999884e-01f, 1.59834355e-01f, 7.96187110e-03f, -1.40326515e-01f, -5.14977761e-02f, -1.13213778e-01f, -1.74581319e-01f, -1.37936518e-01f, -1.18349925e-01f, -4.96313840e-01f,
  -2.58704394e-01f, -2.28799209e-02f, -3.90374213e-01f, 3.65630925e-01f, -7.91468397e-02f, -2.68283129e-01f, -4.17702734e-01f, 2.64506608e-01f, 4.86863136e-01f, 1.40089661e-01f,
  -1.41398543e-02f, -8.50620568e-02f, -2.86368877e-02f, -2.67033726e-01f, -5.06786048e-01f, -5.23703456e-01f, -3.38630855e-01f, -5.52455604e-01f, -5.32402456e-01f, -1.26703084e-01f,
  -3.03885609e-01f, -2.91729212e-01f, -4.09404308e-01f, -1.83458254e-01f, 1.39455274e-01f, -1.19794637e-01f, -7.80774280e-02f, -1.25775814e-01f, -3.06415617e-01f, -2.21468985e-01f,
  -2.81498253e-01f, 1.45949975e-01f, -7.93975890e-02f, -7.69341225e-03f, -4.69767489e-03f, 6.39946237e-02f, 4.96641137e-02f, 5.29535227e-02f, 3.30119096e-02f, 7.80633837e-02f,
  2.02715546e-02f, -2.47677509e-02f, 6.71849996e-02f, -3.20302695e-02f, 5.09262234e-02f, -8.80653560e-02f, 1.85556322e-01f, -5.14570810e-02f, 6.34081960e-02f, 1.59235448e-01f,
  7.22047165e-02f, -1.14195399e-01f, 2.66461689e-02f, 1.82024136e-01f, 9.35208797e-02f, -4.76971455e-02f, 1.86897054e-01f, 1.56164184e-01f, 1.16164394e-01f, 2.93313354e-01f,
  -4.64894213e-02f, -3.58419754e-02f, -6.01770729e-02f, -1.04142120e-02f, 1.25810606e-02f, 8.16116184e-02f, -2.76520494e-02f, 4.38072998e-03f, -6.51199594e-02f, -3.33832987e-02f,
  9.08103287e-02f, -3.44927311e-02f, 9.17447135e-02f, -5.86037189e-02f, -5.32858148e-02f, 2.78694369e-02f, -2.81879622e-02f, 6.30447045e-02f, -3.27285030e-03f, 1.49825409e-01f,
  6.82028756e-02f, 9.67403203e-02f, -4.09999639e-02f, -4.69650775e-02f, -1.68501306e-02f, 6.08521216e-02f, 8.17329064e-02f, -1.26228854e-01f, -2.12438069e-02f, 6.19687736e-02f,
  2.32275605e-01f, -4.61021692e-01f, 8.91836081e-03f, 1.65221706e-01f, -5.16469544e-03f, 1.20556638e-01f, 5.60290329e-02f, 6.25244994e-03f, -5.32114804e-02f, 5.85008413e-02f,
  8.27156082e-02f, -1.21516977e-02f, -4.79079485e-02f, 1.76277198e-02f, -1.92220174e-02f, 3.08070015e-02f, 1.72501430e-01f, 5.20394705e-02f, -7.63507783e-02f, 1.92337811e-01f,
  1.17352359e-01f, 1.27186030e-02f, 7.78645277e-02f, 4.10540067e-02f, 4.90858480e-02f, -2.11468533e-01f, -1.45941809e-01f, 1.93882845e-02f, -1.42514870e-01f, 7.94749185e-02f,
  6.30484164e-01f, -8.72858405e-01f, 2.23254845e-01f, 1.67527452e-01f, 4.62440774e-02f, 2.55466491e-01f, -3.87799740e-01f, -6.69894069e-02f, 6.06356598e-02f, -2.72332639e-01f,
  -2.52039284e-01f, 2.60420833e-02f, 1.21022478e-01f, 1.62872955e-01f, 1.00212306e-01f, -2.36362219e-01f, 1.24936670e-01f, 3.78870308e-01f, 6.06268823e-01f, 1.37372285e-01f,
  -1.46674469e-01f, -5.55057041e-02f, 2.81290561e-01f, 9.71920788e-02f, -2.72664994e-01f, 1.67379051e-01f, -2.21512169e-01f, -2.43991449e-01f, -2.20831484e-01f, -5.59810996e-01f,
  -1.46145165e-01f, -2.65560389e-01f, 3.10558945e-01f, -5.74135706e-02f, -1.46655381e-01f, -1.42408535e-02f, 3.93436700e-02f, -1.38090506e-01f, 1.47334430e-02f, -2.85018422e-02f,
  3.73249464e-02f, -5.08841760e-02f, 8.62970278e-02f, -1.26314968e-01f, -8.49202499e-02f, -2.11881697e-02f, -7.69367516e-02f, -1.08713768e-01f, -2.02939212e-02f, -8.35198537e-02f,
  -1.11493260e-01f, -5.86817153e-02f, -9.77445394e-02f, 2.18102057e-02f, 1.05049953e-01f, 1.37341112e-01f, -1.66458219e-01f, -6.91719577e-02f, 1.10037260e-01f, -1.95391521e-01f,
  -3.10557578e-02f, 3.04452274e-02f, 7.01518506e-02f, -1.88698675e-02f, 4.40096483e-02f, 2.04075426e-02f, 9.06981826e-02f, -3.63638699e-02f, 1.40972482e-02f, -7.78653193e-03f,
  -1.61169302e-02f, 1.14590831e-01f, 4.89839874e-02f, -5.76149635e-02f, -1.36859920e-02f, -2.15214361e-02f, 4.82509285e-03f, -7.49467090e-02f, -1.28951333e-02f, 1.90473236e-02f,
  -2.53628124e-03f, 2.75820475e-02f, 3.99380401e-02f, -4.42500338e-02f, -1.71411689e-02f, 2.72235330e-02f, 8.02443475e-02f, -9.71772820e-02f, -1.22970408e-02f, 1.86685678e-02f,
  -1.22131921e-01f, 3.43572408e-01f, -2.40932573e-02f, -6.90882131e-02f, 1.30904594e-03f, -3.79243903e-02f, 2.31770631e-02f, 4.76109236e-02f, -1.30407605e-03f, 3.89722325e-02f,
  6.44066185e-03f, 1.03282958e-01f, -7.17695504e-02f, -2.70594861e-02f, 1.40163243e-01f, 1.13252789e-01f, -1.29015088e-01f, 1.43263251e-01f, 2.61781458e-02f, -9.59664881e-02f,
  -7.07281604e-02f, -6.38668146e-03f, 1.76073685e-01f, 8.77578184e-02f, 8.47997069e-02f, 2.95774728e-01f, 7.55421743e-02f, 9.79631841e-02f, 2.01895222e-01f, -1.47948191e-01f,
  4.08515446e-02f, -2.54113805e-02f, 2.71119624e-01f, 3.49944085e-01f, 3.90441835e-01f, 3.07184786e-01f, 1.38824746e-01f, 1.66507721e-01f, 2.24523857e-01f, 2.21327946e-01f,
  2.01962784e-01f, 3.08483094e-01f, 2.15148211e-01f, 2.05130965e-01f, 1.79108649e-01f, 2.68579036e-01f, 1.90935567e-01f, 1.96160153e-01f, 2.36810088e-01f, 1.83326676e-01f,
  1.57487243e-01f, 8.86301771e-02f, 2.63307560e-02f, 2.01437891e-01f, 1.32164925e-01f, 9.73803997e-02f, 1.69776440e-01f, 1.48579046e-01f, 6.36872649e-02f, 7.52581879e-02f,
  -8.96419883e-02f, 1.13699645e-01f, 7.51902461e-02f, 8.28407854e-02f, -6.68038875e-02f, -2.80052006e-01f, -5.01317605e-02f, -2.07500115e-01f, -1.78415224e-01f, -4.86460179e-02f,
  -1.42179444e-01f, -7.08427727e-02f, 1.67264357e-01f, -6.97802678e-02f, -9.12655741e-02f, -8.91496092e-02f, 5.28379939e-02f, 1.29802385e-02f, 1.17243096e-01f, -1.23765364e-01f,
  1.43491060e-01f, 9.91690159e-02f, -5.98250248e-04f, 1.16620488e-01f, 1.19520932e-01f, 1.19596928e-01f, -4.69849966e-02f, -4.19881828e-02f, 5.09382226e-02f, 2.62503512e-02f,
  2.64046937e-01f, 2.92754471e-01f, 2.17702165e-01f, 9.92886499e-02f, 8.42012912e-02f, -5.26751652e-02f, -8.15543756e-02f, 1.24457031e-01f, 3.20367515e-01f, 9.13860872e-02f,
  -7.24344403e-02f, 1.02711588e-01f, -1.04524255e-01f, 1.56338230e-01f, 1.82810932e-01f, 3.25736105e-02f, -1.82347909e-01f, -8.99489149e-02f, -1.79387443e-02f, -3.91214192e-02f,
  7.50356913e-02f, -9.09755751e-02f, 7.77772395e-03f, -3.46474722e-02f, -8.95232782e-02f, 8.69856104e-02f, 2.57682502e-02f, -5.27662411e-02f, 1.07673474e-01f, -7.35515282e-02f,
  -4.68625389e-02f, 3.70058715e-01f, -9.11831781e-02f, -5.85919544e-02f, 7.41696358e-02f, -8.16811249e-02f, 1.12408713e-01f, -1.66500613e-01f, -2.69470364e-01f, -1.00011215e-01f,
  -9.01710317e-02f, 3.80092002e-02f, 6.61891848e-02f, 5.19162007e-02f, -1.20076500e-02f, -1.55420244e-01f, -5.71543500e-02f, 7.90831372e-02f, -7.04956353e-02f, -2.08291024e-01f,
  4.04646583e-02f, 8.98198038e-03f, -1.23834655e-01f, 5.17585091e-02f, 6.39668331e-02f, -1.08500443e-01f, -1.39814332e-01f, -1.90918431e-01f, -1.73771605e-01f, -1.98873803e-01f,
  -4.61524606e-01f, -3.30923021e-01f, -1.40398651e-01f, 2.79383622e-02f, 9.62982550e-02f, 2.52714083e-02f, -5.32686114e-01f, -3.66353728e-02f, 2.09137306e-01f, -3.49734485e-01f,
  -3.95764150e-02f, -7.52485823e-03f, 4.41778488e-02f, -1.06205530e-01f, -4.49846178e-01f, -3.51225376e-01f, -2.75954425e-01f, -3.04197580e-01f, 3.43950205e-02f, 1.89430222e-01f,
  5.78024164e-02f, -8.37908685e-02f, -1.21492550e-01f, 1.14364162e-01f, 1.54006124e-01f, 1.33773014e-01f, 1.79451302e-01f, -4.74841148e-02f, -1.13227569e-01f, -1.81768194e-01f,
  -2.19946623e-01f, 3.87978591e-02f, 1.62906229e-01f, 2.18942072e-02f, -7.50151521e-04f, -2.46486828e-01f, 1.01311110e-01f, 6.79064484e-04f, -3.22528556e-03f, 7.14759529e-02f,
  -7.88886473e-02f, -1.17875002e-01f, 7.22330287e-02f, -4.73119430e-02f, -3.45784947e-02f, 2.24973168e-02f, -6.23247288e-02f, 4.60411608e-02f, 4.47905660e-02f, 1.09867893e-01f,
  2.00069081e-02f, 1.39940334e-02f, -2.14370787e-01f, -2.52679549e-02f, -8.19166899e-02f, 5.77023700e-02f, -2.32566111e-02f, 1.39882907e-01f, 8.60195532e-02f, -9.18057486e-02f,
  3.00264768e-02f, 7.61817619e-02f, 2.18625572e-02f, -4.87099774e-02f, -1.35393545e-01f, 1.45098250e-02f, 9.71547961e-02f, -1.02508433e-01f, 7.02038333e-02f, -4.15931409e-03f,
  1.51063353e-01f, 1.82439849e-01f, 9.46881697e-02f, 6.89389259e-02f, 9.23554897e-02f, -3.19408141e-02f, 1.15727708e-01f, -4.59432490e-02f, -3.58346403e-02f, 6.53895438e-02f,
  -1.28114730e-01f, -5.77112027e-02f, -6.32691476e-03f, 5.08217327e-02f, -6.36696965e-02f, 1.81229990e-02f, -1.87249668e-02f, -3.06661204e-02f, -4.11530733e-02f, -1.32870106e-02f,
  -8.13298821e-02f, 1.75884366e-01f, -1.97281837e-01f, -1.22704364e-01f, -4.64559011e-02f, 5.07285036e-02f, -7.69865327e-03f, -5.17240539e-02f, -3.91032780e-03f, -1.94634080e-01f,
  -1.10700637e-01f, -1.01881750e-01f, -4.03756835e-03f, -2.54551750e-02f, -1.75866708e-02f, -1.10485509e-01f, -3.46213251e-01f, -1.59191027e-01f, -5.52892759e-02f, -3.00862435e-02f,
  -2.50650078e-01f, -2.46101588e-01f, -4.12881315e-01f, -2.54674286e-01f, -6.32121712e-02f, -1.00058347e-01f, -8.88103098e-02f, 3.20655070e-02f, -2.10946232e-01f, -5.30708075e-01f,
  -1.33091182e-01f, -2.79847592e-01f, 3.00832540e-01f, -3.09966654e-02f, -2.13761583e-01f, -3.85139257e-01f, -4.88075197e-01f, -2.47412175e-01f, -7.00875744e-02f, -3.04013789e-01f,
  -4.29644197e-01f, 3.62514406e-02f, 3.13452989e-01f, 2.69567728e-01f, 3.09794992e-01f, 2.01006547e-01f, 5.24128795e-01f, 6.27484083e-01f, 1.97376296e-01f, -2.03044683e-01f,
  6.01973832e-02f, 1.23459078e-01f, 1.00314386e-01f, 1.41297147e-01f, 4.32814658e-02f, 1.05835237e-01f, 1.41154215e-01f, 8.41750875e-02f, -7.91558698e-02f, 7.25075722e-01f,
  9.74728446e-03f, -2.25337610e-01f, 7.63567090e-02f, -1.27081724e-03f, 9.42589156e-03f, 3.33348066e-02f, -5.18003628e-02f, 1.12738796e-01f, -1.58650801e-02f, 9.95066762e-02f,
  1.01975054e-02f, 3.07342708e-02f, 4.73474450e-02f, 8.80778879e-02f, -8.39615688e-02f, -1.92568898e-01f, 7.02563599e-02f, 1.68780342e-01f, 1.31416426e-04f, -1.14037007e-01f,
  2.03497306e-01f, -2.93079138e-01f, -1.27974451e-01f, -1.62209794e-02f, -1.23588271e-01f, 3.36621888e-02f, -2.13323370e-01f, 1.31225690e-01f, -6.78829849e-02f, 1.43327177e-01f,
  -6.42397162e-03f, -1.02997817e-01f, -4.30200808e-02f, 1.65502623e-01f, 5.94341867e-02f, 2.90590692e-02f, 2.08099648e-01f, -2.54322253e-02f, 1.82888523e-01f, 4.50586900e-02f,
  5.44167161e-02f, -4.11812328e-02f, 7.58042112e-02f, -4.55882214e-02f, -9.91374850e-02f, 1.67481247e-02f, -3.49912904e-02f, 6.02486730e-02f, 1.50438482e-02f, 4.39686328e-03f,
  -3.34149636e-02f, 8.91469270e-02f, -6.30418882e-02f, 1.63572624e-01f, -1.77159205e-01f, -2.87421010e-02f, -9.67979506e-02f, -5.12689240e-02f, -5.21419756e-02f, 4.15128935e-03f,
  -3.11837137e-01f, 1.78234249e-01f, -1.18377812e-01f, 2.99349129e-02f, -7.71832233e-03f, -5.50737344e-02f, 1.81718394e-02f, 3.08229681e-02f, -1.12760030e-01f, -1.76121425e-02f,
  -2.63610721e-01f, -4.73028533e-02f, -5.94150163e-02f, 2.74090141e-01f, -3.97971421e-02f, -1.12242125e-01f, 6.38790950e-02f, -2.91218609e-02f, 3.28493305e-02f, -1.83020711e-01f,
  -1.29091721e-02f, -1.93712965e-01f, -3.63039613e-01f, -1.67701975e-01f, -2.52004147e-01f, -8.79392102e-02f, -2.89599240e-01f, -1.96489468e-01f, -2.43819594e-01f, -3.82183343e-01f,
  9.09610689e-01f, 9.87954140e-02f, 4.42787945e-01f, -2.23387871e-02f, -5.58396518e-01f, -4.39162284e-01f, -4.90242392e-01f, -1.00722671e-01f, -5.17928191e-02f, 3.17167975e-02f,
  1.16887324e-01f, 2.91936547e-01f, 3.92712891e-01f, 3.56427282e-01f, 3.62039745e-01f, -1.14096478e-01f, -3.89813446e-02f, 5.33108890e-01f, 3.13039660e-01f, 5.96371926e-02f,
  -2.38095656e-01f, -1.29629165e-01f, 2.64081657e-01f, 1.61450520e-01f, -4.31980267e-02f, 1.64143935e-01f, -2.36716829e-02f, -4.00442258e-02f, 1.60396677e-02f, 1.81301519e-01f,
  2.27711558e-01f, 5.11550009e-02f, 1.38489734e-02f, 7.81619251e-02f, 8.01460743e-02f, 6.47370592e-02f, 7.10084662e-02f, 4.31376882e-02f, 3.14095430e-02f, 1.87276136e-02f,
  1.50832953e-02f, 6.99381605e-02f, -1.87625632e-01f, -9.90813747e-02f, -1.04862735e-01f, 5.95479086e-02f, 1.16867363e-01f, 2.71412462e-01f, 2.58662760e-01f, 1.14130769e-02f,
  -1.37391448e-01f, -1.02618501e-01f, 8.93794373e-02f, -8.27236250e-02f, 4.10589688e-02f, 6.59196973e-02f, 5.51910792e-03f, 2.94705443e-02f, 6.58767894e-02f, 2.09192455e-01f,
  1.41462728e-01f, 4.83245365e-02f, 9.43352357e-02f, -1.56157732e-01f, 4.93409391e-03f, -1.86802626e-01f, -1.20125823e-01f, -3.36041600e-02f, -1.82438176e-02f, -1.12076096e-01f,
  -9.03833807e-02f, 6.74101636e-02f, 3.11858417e-03f, 2.61968225e-02f, 1.48509398e-01f, -5.67744523e-02f, 1.96882132e-02f, 6.35344759e-02f, -7.53703481e-03f, -2.50994805e-02f,
  -1.15518468e-02f, -1.44537156e-02f, -1.03161603e-01f, -4.76094335e-02f, 7.14764968e-02f, 2.08734363e-01f, 7.87009969e-02f, 4.22678962e-02f, 1.80038041e-03f, -9.29788351e-02f,
  -2.90866584e-01f, 6.73139691e-02f, 1.83501337e-02f, 2.11435288e-01f, 2.83216760e-02f, 1.24526583e-01f, 9.06139165e-02f, -6.25946000e-02f, -1.15116179e-01f, 1.04074612e-01f,
  6.46448042e-03f, 8.04076195e-02f, 3.76880057e-02f, 2.22407971e-02f, -1.76118776e-01f, -2.14377586e-02f, 3.42006423e-02f, 9.58752781e-02f, 1.60433315e-02f, -7.99892396e-02f,
  -7.74108097e-02f, -2.30834652e-02f, 7.90383369e-02f, -5.69484234e-02f, -1.85172886e-01f, -7.41237924e-02f, -9.65663195e-02f, -3.20601128e-02f, 5.20974621e-02f, -1.92608044e-01f,
  7.99233913e-01f, -2.94380128e-01f, -5.00554502e-01f, 2.61847042e-02f, -2.05670163e-01f, -4.08310741e-02f, -2.21255437e-01f, -1.15606301e-01f, 6.93520531e-02f, -1.70682803e-01f,
  1.39055103e-02f, 1.88049048e-01f, -1.53381646e-01f, -1.17002182e-01f, 3.02753121e-01f, -3.39400351e-01f, -2.45538324e-01f, 3.04427557e-02f, 3.60745430e-01f, 1.90229237e-01f,
  1.68845728e-02f, 8.26531053e-02f, 3.12677443e-01f, 6.03938922e-02f, -2.63797939e-01f, 1.71784870e-02f, -3.92614752e-01f, -4.06787358e-02f, -6.21259660e-02f, -2.30499715e-01f,
  -2.39715442e-01f, -1.47515476e-01f, -1.44876286e-01f, 1.75900802e-01f, -2.78030429e-02f, 2.46436168e-02f, -1.05374083e-01f, -1.32163301e-01f, -5.51798707e-03f, -2.18456108e-02f,
  -2.89424751e-02f, 8.04936215e-02f, 1.33905381e-01f, 8.84780958e-02f, 1.22530930e-01f, 1.54059619e-01f, -7.38189295e-02f, 7.40261599e-02f, -2.46688128e-02f, -1.13311797e-01f,
  -9.30156466e-03f, 5.38735092e-02f, -4.17164788e-02f, -1.36722922e-01f, -4.54508774e-02f, 1.36380959e-02f, -2.23595530e-01f, -1.61178708e-01f, -7.29578361e-02f, -2.41720915e-01f,
  1.58486187e-01f, -1.10285565e-01f, -6.53632954e-02f, -2.41896305e-02f, -5.81480786e-02f, -1.09670356e-01f, 3.25131640e-02f, -2.44092848e-02f, -3.11109945e-02f, -1.04889488e-02f,
  -1.61164656e-01f, -2.01661989e-01f, -4.38771062e-02f, -8.95733014e-04f, -7.52075156e-03f, 1.17232256e-01f, 1.34493649e-01f, -2.93341428e-02f, -3.22580189e-02f, 2.61177197e-02f,
  6.24724552e-02f, -1.44077314e-03f, 1.31557239e-02f, 9.16902721e-02f, -7.52450749e-02f, 3.22084837e-02f, 6.96814433e-03f, -3.68731022e-02f, 5.28256260e-02f, 2.01095045e-01f,
  4.45226021e-02f, -1.77113995e-01f, -2.99026296e-02f, 9.58399400e-02f, 5.34962453e-02f, -2.38941032e-02f, 4.12360281e-02f, -4.32347022e-02f, -1.64855719e-02f, 1.65222827e-02f,
  -1.98112398e-01f, 9.72616579e-03f, -4.44987640e-02f, -9.02647674e-02f, -5.86835109e-02f, 3.33397239e-02f, -6.82241395e-02f, 2.17378736e-01f, 1.31831959e-01f, -2.86463834e-03f,
  -1.12292338e-02f, 1.01611137e-01f, 9.86640342e-03f, -1.18734762e-02f, 2.28962433e-02f, 1.87966645e-01f, -1.32819861e-01f, -7.95054957e-02f, 2.61477828e-01f, -7.88952783e-02f,
  -9.62265968e-01f, 1.49927378e-01f, -2.39955802e-02f, -3.44430804e-01f, 1.69571728e-01f, 2.79791862e-01f, 5.48152864e-01f, 1.05748191e-01f, -8.02538618e-02f, 2.60412395e-01f,
  -1.57981873e-01f, -1.97816372e-01f, -1.13367736e-01f, 1.13648146e-01f, 1.00905508e-01f, 4.82499152e-01f, 4.43348646e-01f, 7.54239038e-02f, -2.43839934e-01f, 5.08565344e-02f,
  1.73395604e-01f, -2.62697250e-01f, -4.91255730e-01f, -1.82820067e-01f, -3.45105007e-02f, -1.04728796e-01f, -6.32307380e-02f, -8.72147679e-02f, 9.48100761e-02f, 3.88712287e-01f,
  -4.26984876e-01f, -2.14950949e-01f, 1.51120007e-01f, -9.68171954e-02f, -7.50195011e-02f, -2.37196282e-01f, -1.12933554e-01f, -1.09372132e-01f, -1.14281870e-01f, 7.54248956e-03f,
  -2.79789083e-02f, -1.20176747e-01f, -2.39163879e-02f, -6.11241609e-02f, -1.70488164e-01f, -1.59537017e-01f, -4.89220135e-02f, -1.02947764e-01f, 1.20057002e-01f, 7.89548829e-02f,
  4.09471363e-01f, -3.10880635e-02f, -2.25185633e-01f, 2.33697414e-01f, 8.10439959e-02f, 9.61767361e-02f, 9.88142844e-03f, -5.03495187e-02f, 8.03184062e-02f, -2.04129681e-01f,
  1.38155803e-01f, -1.25535876e-01f, 1.30779566e-02f, -7.26549998e-02f, 7.81917274e-02f, -6.55348524e-02f, 2.26463173e-02f, 3.02901119e-03f, -6.92110881e-02f, -1.77367821e-01f,
  6.02863096e-02f, 1.84454471e-01f, 3.48484069e-02f, -3.36149558e-02f, -9.65292379e-02f, 2.91191153e-02f, 1.63668841e-01f, 8.46497938e-02f, -1.53065016e-02f, 3.88788730e-02f,
  1.10302530e-01f, -8.20662007e-02f, -1.28759339e-01f, 4.75347452e-02f, 1.92731783e-01f, 8.99164006e-02f, -7.71866646e-03f, 3.27151129e-03f, -1.46625265e-01f, -4.81330492e-02f,
  -4.30113405e-01f, 4.54955369e-01f, -1.25277057e-01f, -1.74161009e-02f, 1.79652311e-03f, -6.88858777e-02f, 4.31269221e-02f, -3.95411290e-02f, -6.11383729e-02f, -8.39120075e-02f,
  1.90522358e-01f, 1.24451537e-02f, -1.15153931e-01f, 6.20182715e-02f, -3.19147818e-02f, -7.21654519e-02f, 2.10492671e-01f, -7.43998662e-02f, 1.26462668e-01f, 7.39139458e-03f,
  1.59683749e-01f, 5.48824556e-02f, -2.80532748e-01f, 1.10440858e-01f, 1.36703834e-01f, -9.39191803e-02f, -2.34911367e-01f, -1.69996724e-01f, 5.99895939e-02f, -9.92483497e-02f,
  2.09297433e-01f, -3.91411573e-01f, 2.61434674e-01f, 4.18796837e-01f, 4.38063592e-01f, 4.72067326e-01f, 3.86246502e-01f, 2.65738338e-01f, 3.05072099e-01f, 1.33417219e-01f,
  -3.99982668e-02f, 5.11385798e-02f, 1.08298464e-02f, -5.72680198e-02f, 7.14654997e-02f, 2.52830833e-01f, 3.84576023e-01f, 1.90042138e-01f, 3.50317776e-01f, 1.90332487e-01f,
  6.90271854e-02f, -1.62088983e-02f, -6.02728017e-02f, 3.50285321e-02f, -6.35265633e-02f, -6.92227930e-02f, 4.42962646e-02f, -3.85072641e-03f, -1.65851876e-01f, -2.45998681e-01f,
  -7.23990127e-02f, -5.64182643e-03f, 1.84647247e-01f, -2.91513763e-02f, -7.64991716e-02f, -1.69123292e-01f, -3.01975142e-02f, -4.39485861e-03f, 3.19787115e-02f, -6.44619092e-02f,
  -6.90815747e-02f, -1.41084800e-02f, -7.26961046e-02f, -1.00385182e-01f, 7.34436512e-02f, 2.79902872e-02f, -1.67496592e-01f, -1.08299978e-01f, 7.27193952e-02f, -4.84719779e-03f,
  -3.87857184e-02f, -3.58000435e-02f, 1.74681842e-02f, 2.08957076e-01f, 7.38882646e-02f, 7.51245692e-02f, -1.25654131e-01f, -4.63312306e-02f, 9.96443676e-04f, -1.46360263e-01f,
  3.16754520e-01f, 1.50586024e-01f, -7.22740442e-02f, -7.31901824e-02f, 7.02961385e-02f, 6.54413551e-02f, 6.94430768e-02f, 3.01194843e-02f, 1.55097187e-01f, -6.64292499e-02f,
  -2.22572405e-02f, 1.24413401e-01f, 1.49155498e-01f, 2.05511879e-03f, -9.59446505e-02f, -1.80737048e-01f, 1.90483518e-02f, -9.50355381e-02f, -5.43839224e-02f, -5.66532090e-02f,
  -4.54304963e-02f, 1.71563253e-02f, -9.16402116e-02f, -6.60282448e-02f, -1.20309152e-01f, -1.94799136e-02f, 7.33812340e-03f, -3.17864008e-02f, -9.04149562e-02f, -3.58190201e-02f,
  8.82038549e-02f, 2.00443417e-01f, 7.79608414e-02f, -1.37927517e-01f, -5.13512976e-02f, -1.14699624e-01f, 1.02429343e-02f, -2.05245577e-02f, 5.11452816e-02f, 1.46265313e-01f,
  2.11652610e-02f, 7.77496817e-03f, -1.69638470e-02f, -1.88921407e-01f, 1.07160464e-01f, 6.51955754e-02f, -1.94531888e-01f, 2.34794207e-02f, 3.40807326e-02f, 2.08990201e-02f,
  -1.16152614e-01f, 2.32908651e-01f, 2.44882256e-01f, 1.86208665e-01f, 1.73215345e-01f, 3.12033027e-01f, -7.57883638e-02f, -3.71306725e-02f, 1.67660862e-01f, -6.58323197e-03f,
  -3.14351797e-01f, 2.78284103e-01f, -5.15345514e-01f, 1.14922047e-01f, 2.10560918e-01f, -2.02857092e-01f, -2.77314603e-01f, -4.07020390e-01f, 4.20176759e-02f, 3.17559391e-01f,
  1.04180932e-01f, 3.48449498e-01f, 2.27340505e-01f, 8.62239078e-02f, -3.31063867e-01f, 1.38735324e-01f, 2.96455741e-01f, -2.77816325e-01f, -6.11910999e-01f, -1.52577221e-01f,
  3.58155251e-01f, -2.68704239e-02f, -3.57499480e-01f, -3.12318116e-01f, 3.08239847e-01f, 1.22209586e-01f, -2.05726177e-02f, 1.00424513e-02f, 2.15678886e-01f, 5.86858928e-01f,
  1.76079217e-02f, -3.01717430e-01f, 2.87564285e-03f, 2.43471533e-01f, 2.39009392e-02f, -1.20678566e-01f, -1.60095058e-02f, 2.39727623e-03f, 5.66770025e-02f, -1.02843745e-02f,
  1.98456109e-01f, 2.19327193e-02f, 1.17706016e-01f, -4.83489707e-02f, -1.77876368e-01f, -1.22563124e-01f, -2.79741466e-01f, -3.92243743e-01f, -5.04614115e-01f, -1.98592082e-01f,
  3.94467562e-01f, 1.50959879e-01f, -3.32747996e-01f, -1.52623862e-01f, -3.74318570e-01f, 1.62107304e-01f, -5.12371719e-01f, -3.51630956e-01f, -3.70869875e-01f, -4.96600047e-02f,
  -1.01590872e-01f, -2.04767212e-02f, 2.70244181e-02f, -3.82472901e-03f, 9.77150723e-02f, -3.35408859e-02f, 3.43964286e-02f, 1.05811164e-01f, 6.96135610e-02f, -6.24732561e-02f,
  -2.87506934e-02f, 8.09137884e-04f, -4.65130471e-02f, -5.82655668e-02f, 7.69362133e-03f, -8.53063762e-02f, -8.01283196e-02f, -8.92304704e-02f, -5.70275821e-02f, -1.71961933e-02f,
  6.28210008e-02f, -1.04477517e-02f, 4.07242440e-02f, -1.24808781e-01f, 1.37472779e-01f, -8.85859504e-02f, 1.69737823e-02f, 3.52562056e-03f, -8.03678557e-02f, 8.61866921e-02f,
  5.80481216e-02f, -2.48782430e-02f, 1.46774100e-02f, -1.17528476e-01f, 2.96381768e-02f, 2.58878265e-02f, 1.74508423e-01f, 7.65423924e-02f, 1.16655223e-01f, -5.55368923e-02f,
  -1.02475666e-01f, -7.92154297e-02f, 5.76783940e-02f, 9.33245756e-03f, -7.52538443e-03f, 1.27481177e-01f, 2.45999217e-01f, -7.14055821e-02f, -2.35452466e-02f, 1.38519928e-01f,
  -2.08368264e-02f, -1.27773449e-01f, 2.01789886e-02f, -4.25532972e-03f, 5.23177674e-03f, -1.19763929e-02f, -8.11830461e-02f, -1.27364874e-01f, -4.44452316e-02f, -2.04313219e-01f,
  -3.75188172e-01f, -7.88277909e-02f, -3.69704992e-01f, -6.89234138e-01f, -3.47326517e-01f, -5.34640886e-02f, 7.64803437e-04f, -6.28831312e-02f, -2.61873215e-01f, -3.61275971e-01f,
  4.62723598e-02f, 3.89320672e-01f, 3.54296356e-01f, 4.17613626e-01f, 5.08398890e-01f, -1.46605459e-03f, -5.32418668e-01f, -5.32642379e-02f, 3.76163810e-01f, 1.57970458e-01f,
  -1.20784184e-02f, -1.95422769e-01f, -2.03769460e-01f, -6.46369830e-02f, -3.44642937e-01f, -1.59135833e-02f, -6.90922379e-01f, -2.80588478e-01f, 2.06480756e-01f, -4.07207221e-01f,
  2.96403438e-01f, -1.45494252e-01f, -9.88533720e-02f, 2.33430099e-02f, -2.86441714e-01f, 9.09843370e-02f, 1.30876422e-01f, -2.33799055e-01f, -7.71760289e-03f, 3.65591794e-02f,
  -2.07129940e-01f, -5.68116903e-02f, -8.11822806e-03f, 1.48695752e-01f, -1.66911975e-01f, 5.76904118e-02f, -1.00739360e-01f, -1.12001203e-01f, -9.25887674e-02f, -1.78441610e-02f,
  3.27069731e-03f, -2.35469006e-02f, -8.71972963e-02f, -1.05598912e-04f, 1.26829982e-01f, 4.63570952e-02f, -1.91487204e-02f, 8.29298515e-03f, 7.39035308e-02f, -2.83573896e-01f,
  -7.02151731e-02f, -1.16393320e-01f, -1.93318520e-02f, -9.22593698e-02f, -8.90926793e-02f, 2.70220116e-02f, 9.06471908e-02f, -1.51375355e-02f, -1.91523824e-02f, -5.57044186e-02f,
  -5.60819395e-02f, -1.23427667e-01f, 7.20142499e-02f, -3.38922488e-03f, -9.86997485e-02f, 2.20132582e-02f, 3.35671939e-02f, 1.19723529e-02f, -7.94313625e-02f, 3.48740420e-03f,
  3.48196216e-02f, -3.98101136e-02f, -2.02329874e-01f, 9.76377279e-02f, -1.02815581e-02f, -3.72274444e-02f, 1.29349381e-01f, 7.43388459e-02f, 1.88492298e-01f, 4.05202527e-03f,
  -2.32605543e-02f, -8.36678818e-02f, -1.03053421e-01f, 1.53037369e-01f, -1.87338322e-01f, -4.89714555e-02f, -1.20474007e-02f, -1.33538879e-02f, -4.68171313e-02f, 1.14262857e-01f,
  7.70282596e-02f, 5.36860079e-02f, -3.91317382e-02f, -2.41038688e-02f, -6.19990006e-02f, 9.73527655e-02f, 1.65341064e-01f, 6.47268072e-02f, -5.11703491e-02f, -1.10479638e-01f,
  -1.62498787e-01f, -2.74638422e-02f, 1.87121302e-01f, 1.11019462e-01f, 2.48717815e-02f, 5.25033064e-02f, 7.33357519e-02f, -7.30468854e-02f, 1.55837670e-01f, 4.50115539e-02f,
  -6.26898587e-01f, 2.05694512e-01f, -1.05499864e-01f, -1.17396317e-01f, -2.37639949e-01f, -8.78106505e-02f, 8.08557048e-02f, 6.38986081e-02f, 1.90969016e-02f, 1.24223284e-01f,
  1.51340917e-01f, 4.14184891e-02f, 4.38005142e-02f, 1.16328530e-01f, 7.30163828e-02f, 5.20712025e-02f, -1.20709110e-02f, -3.92241441e-02f, -2.55580753e-01f, -1.74843878e-01f,
  -1.29021853e-01f, -3.06683987e-01f, -4.11069602e-01f, -1.17629543e-01f, -1.09696254e-01f, -4.91587333e-02f, -9.65352450e-03f, -2.10910618e-01f, 4.26649563e-02f, -3.68306786e-02f,
  2.51964927e-01f, -2.41935849e-01f, 4.43151733e-03f, -1.68902054e-02f, -5.58526553e-02f, -2.97082658e-03f, 3.60724479e-02f, -4.09989432e-02f, 3.56706046e-03f, 1.45123571e-01f,
  -5.06504513e-02f, -9.06002522e-03f, -1.41071454e-01f, -1.30593721e-02f, 1.22107659e-03f, -1.63916557e-04f, -2.47841794e-02f, -5.10152243e-02f, 1.16013512e-01f, 6.72849938e-02f,
  1.73732266e-01f, -3.87688801e-02f, 8.67780447e-02f, 1.44167200e-01f, 7.84361809e-02f, 9.77579784e-03f, 1.99685901e-01f, 1.70034431e-02f, -5.80294244e-02f, 6.46962374e-02f,
  -5.03659423e-04f, 2.02910244e-01f, 1.41842246e-01f, 8.60494375e-02f, 5.16727306e-02f, 1.96185753e-01f, 8.62850249e-02f, 1.69699104e-03f, 2.79014856e-02f, 3.26161236e-02f,
  1.71836048e-01f, 1.22002475e-01f, 1.00096099e-01f, 1.98844209e-01f, 2.43369378e-02f, -3.71622890e-02f, 3.59481648e-02f, 1.07053123e-01f, 2.04691989e-03f, -1.36175781e-01f,
  -3.45371291e-02f, -9.26703364e-02f, 2.45595668e-02f, -1.61999345e-01f, -2.67913267e-02f, 6.92206994e-02f, -9.97882243e-03f, -1.16249874e-01f, -1.81164414e-01f, -6.10456318e-02f,
  5.23670077e-01f, -1.70350578e-02f, 7.31992209e-03f, -2.58794483e-02f, -1.59704402e-01f, -6.42098561e-02f, -5.32496944e-02f, 1.26485720e-01f, 1.46911487e-01f, 9.23667997e-02f,
  1.97940003e-02f, 1.02243818e-01f, -1.13062367e-01f, -1.05002828e-01f, 4.57069948e-02f, -7.62013998e-03f, 1.33784175e-01f, 5.18664941e-02f, 1.64708555e-01f, 1.07867956e-01f,
  1.49944946e-01f, 2.01765031e-01f, 1.65414184e-01f, 2.59515494e-01f, 8.87309089e-02f, 1.87049672e-01f, 2.43308410e-01f, 4.15096730e-02f, 5.92597872e-02f, 2.28982985e-01f,
  7.77862906e-01f, -5.08065462e-01f, -7.22186804e-01f, 1.89413249e-01f, -1.84852228e-01f, -2.65048109e-02f, -1.90373853e-01f, 2.52693802e-01f, 3.40153396e-01f, -1.98838443e-01f,
  -1.26061127e-01f, 2.55679816e-01f, 2.12276150e-02f, -1.14675229e-02f, 1.11525588e-01f, -2.84207374e-01f, -2.23118886e-01f, -6.16923273e-02f, 3.36870372e-01f, 2.55480945e-01f,
  5.60175627e-02f, 1.27630815e-01f, 3.24297369e-01f, 2.40796983e-01f, -3.22755933e-01f, 1.81605011e-01f, -3.88844699e-01f, -2.71766931e-01f, -3.60680521e-01f, -6.54469788e-01f,
  -6.24378741e-01f, -1.97943568e-01f, 1.79213524e-01f, 2.69447565e-01f, -1.29015580e-01f, 1.62399888e-01f, 1.03427112e-01f, -1.32431276e-02f, 9.08530056e-02f, -4.34893817e-02f,
  -1.21359445e-01f, 3.68572809e-02f, 1.22937977e-01f, -5.57319559e-02f, 3.01386416e-02f, -5.42852916e-02f, -3.07872216e-03f, -3.00431959e-02f, -8.99807438e-02f, -7.92732462e-02f,
  -4.16361839e-02f, -4.67299744e-02f, -8.74525905e-02f, 7.38477111e-02f, -2.62242537e-02f, 1.19848937e-01f, -2.38118082e-01f, -1.81618705e-01f, -1.70161054e-01f, -2.33063206e-01f,
  2.22339015e-02f, -1.01471074e-01f, -1.35997813e-02f, 8.18747804e-02f, 1.38720259e-01f, 1.32159060e-02f, -9.21492502e-02f, -6.46423474e-02f, 8.02918077e-02f, 7.58505538e-02f,
  -3.00580083e-04f, 6.02592155e-03f, 2.06485633e-02f, 1.90220866e-02f, -6.70934096e-02f, -4.67311069e-02f, -8.17740560e-02f, -1.54130673e-02f, 5.48393168e-02f, 1.22853853e-01f,
  6.90754279e-02f, -1.85994804e-02f, -2.13782508e-02f, -3.39904949e-02f, -8.77903476e-02f, -6.45158216e-02f, -6.27912283e-02f, 5.27015105e-02f, 6.87571615e-02f, -2.35611014e-02f,
  1.17379196e-01f, 3.30737457e-02f, 7.09656999e-02f, 4.53301845e-03f, -1.56536967e-01f, -3.43102105e-02f, -1.70037255e-01f, 3.99539433e-03f, -7.29652122e-02f, -9.48676914e-02f,
  -3.10641937e-02f, -2.52644755e-02f, -1.23732060e-01f, -9.07370970e-02f, 1.22751795e-01f, 3.68310474e-02f, 4.21085358e-02f, 3.54564264e-02f, -6.47786930e-02f, -1.02128342e-01f,
  1.93144977e-02f, 2.24267989e-01f, 2.22326234e-01f, 7.49436095e-02f, 2.28154194e-02f, 2.16820642e-01f, -7.11421948e-03f, -7.29525983e-02f, 4.53103483e-02f, 2.26504937e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.67273179e-01f, 3.60776186e-02f, 5.18336356e-01f, 4.94359612e-01f, 4.63185869e-02f, 3.55085284e-01f, 2.62299150e-01f, 7.60398060e-03f, 1.27656460e-01f, 6.97015524e-02f,
  1.92781687e-01f, 2.92936802e-01f, 1.78352813e-03f, 4.00114954e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.41339242e-01f, -2.47068312e-02f, 4.05403413e-03f, 3.52831893e-02f, 3.62389162e-02f, 1.11776955e-01f, 1.60867465e-04f, -1.34643763e-01f, 1.70276806e-01f, 7.04721510e-02f,
  -3.93535830e-02f, 2.47305542e-01f, 1.48726881e-01f, 5.83039746e-02f, 1.01227112e-01f, -6.55138493e-02f, 3.63450237e-02f, 7.89086819e-02f, -4.88519892e-02f, -2.02554181e-01f,
  2.85128921e-01f, -1.45677075e-01f, -3.98997903e-01f, 4.23044950e-01f, 1.64574981e-01f, -4.00754102e-02f, 2.21220881e-01f, 1.31401137e-01f, -3.70956004e-01f, 3.04342717e-01f,
  3.73269394e-02f, -2.01383546e-01f, 1.47524737e-02f, 1.27941430e-01f, 1.34057522e-01f, -2.50342004e-02f, 2.20417753e-01f, 3.35150287e-02f, 9.69111547e-02f, 2.38705069e-01f,
  1.92767128e-01f, -1.74226433e-01f, 8.30791518e-02f, -7.89402657e-06f, -7.65536651e-02f, -1.47685632e-01f, 1.84796125e-01f, 1.03102237e-01f, 1.09184206e-01f, -2.43008614e-01f,
  -9.98299792e-02f, 7.09291101e-02f, -1.75845370e-01f, -1.81941893e-02f, -8.19243044e-02f, -1.96386367e-01f, -1.64173052e-01f, -5.51774353e-03f, 3.23754311e-01f, -1.90195933e-01f,
  8.31698000e-01f, -4.98361103e-02f, 1.91412091e-01f, -1.84347942e-01f, 5.62001280e-02f, -6.03721254e-02f, -8.40297565e-02f, -7.30130896e-02f, 1.25900313e-01f, 1.39534734e-02f,
  1.01692557e-01f, 2.28489026e-01f, -4.89741936e-02f, -7.90270194e-02f, 4.99177650e-02f, -1.38406474e-02f, 2.18414161e-02f, -6.65853024e-02f, -9.97412354e-02f, -6.01981990e-02f,
  -2.40778122e-02f, 4.56451848e-02f, -3.18847835e-01f, 1.47343993e-01f, 1.28680095e-01f, 1.18864536e-01f, -2.31029466e-01f, 1.94575235e-01f, -9.22850370e-02f, 5.50586224e-01f,
  -2.79401809e-01f, 2.72750705e-01f, 2.20699951e-01f, -2.37997666e-01f, -1.11051932e-01f, 3.54620814e-01f, -1.37098178e-01f, 6.03833701e-03f, 1.19957976e-01f, 3.49967778e-02f,
  -7.81821832e-02f, -2.86325980e-02f, -6.26423955e-02f, -9.85816568e-02f, 8.36217627e-02f, -2.05473509e-03f, -4.14577089e-02f, -1.96277481e-02f, -1.07951500e-01f, -7.34535903e-02f,
  -1.10196337e-01f, 6.75260574e-02f, 5.91444038e-03f, 3.23236547e-02f, -4.01729912e-01f, 2.39044458e-01f, -3.66939992e-01f, 1.19840153e-01f, 1.08059712e-01f, 2.99066663e-01f,
  -1.27995871e-02f, -2.12181080e-02f, -1.45937741e-01f, -1.26061261e-01f, 4.92923558e-01f, -2.55965292e-01f, -3.00985873e-01f, 9.03273672e-02f, 9.23109055e-03f, -4.99372138e-03f,
  -1.64113343e-01f, 8.17015544e-02f, -6.28585741e-02f, 5.81807420e-02f, -4.08970304e-02f, -8.87312591e-02f, -4.98643555e-02f, -4.85646538e-02f, 2.23505467e-01f, -2.75428966e-02f,
  1.53113246e-01f, 1.45003736e-01f, 3.88851985e-02f, -2.36324389e-02f, -4.75523248e-03f, -7.55668059e-02f, -4.96378131e-02f, -1.43653318e-01f, 3.18463206e-01f, -9.40432400e-02f,
  -2.45580807e-01f, -3.95534456e-01f, -1.91587180e-01f, 4.34545159e-01f, -2.72094905e-01f, -5.35264127e-02f, -1.24762930e-01f, 1.41784534e-01f, -1.35689631e-01f, 2.22399697e-01f,
  -1.57315079e-02f, -7.04198703e-03f, -8.66141990e-02f, 8.38966519e-02f, -4.33204919e-02f, 1.95259769e-02f, 6.35286793e-02f, 5.77937998e-03f, 3.56722102e-02f, 1.26943052e-01f,
  -2.16109138e-02f, 1.20982617e-01f, -9.89309996e-02f, -1.31745517e-01f, -1.38822898e-01f, -1.62325552e-04f, 3.31384912e-02f, 7.80424401e-02f, -1.78190306e-01f, -8.49260315e-02f,
  -1.18061630e-02f, -1.05514288e-01f, -3.38985622e-01f, -1.18213587e-01f, -5.75186685e-02f, 1.10534988e-01f, 4.22071993e-01f, 2.16735542e-01f, 8.50541592e-02f, -1.37118390e-02f,
  2.07374543e-01f, -1.95847675e-02f, -7.18525723e-02f, 6.39436245e-02f, -1.01670936e-01f, 9.92619971e-05f, 2.98756361e-01f, -1.07341170e-01f, 3.76603939e-02f, -9.32939947e-02f,
  1.72109634e-01f, -4.21162844e-02f, 1.25457957e-01f, 1.59751996e-01f, 1.84672922e-01f, 1.12575673e-01f, 1.56820297e-01f, 2.19393864e-01f, -1.13612168e-01f, 1.18482644e-02f,
  -2.72557259e-01f, 5.97278439e-02f, 4.39952649e-02f, 2.85003722e-01f, -3.25378299e-01f, 5.49947023e-02f, 2.12354079e-01f, 3.00176352e-01f, 9.08482522e-02f, 2.44364049e-02f,
  1.12020159e-02f, -2.22440764e-01f, -1.41921952e-01f, 3.94518018e-01f, -1.08457706e-03f, 1.23033158e-01f, 8.62444267e-02f, -3.20544019e-02f, -2.13265434e-01f, 9.53190923e-02f,
  -2.33192667e-02f, 4.80383225e-02f, 1.75944462e-01f, -7.52769262e-02f, 2.58628130e-01f, -1.69463530e-02f, -1.55716628e-01f, -1.42501175e-01f, 2.81358868e-01f, 1.23570219e-01f,
  -1.52464524e-01f, -1.16554491e-01f, -8.67083371e-02f, -3.12316895e-01f, -1.13247856e-02f, -3.33344713e-02f, -2.62887150e-01f, -1.34736165e-01f, 5.27167022e-02f, 2.24779278e-01f,
  -1.71102002e-01f, 1.93945453e-01f, 3.80213797e-01f, 4.00135443e-02f, 1.26340508e-01f, -2.10052426e-03f, 2.18246747e-02f, 2.64286138e-02f, 3.06921117e-02f, -9.30189714e-02f,
  -5.14885876e-03f, 4.01948998e-03f, 2.82052130e-01f, 2.79845782e-02f, 2.41003215e-01f, 2.84948014e-03f, 3.03429328e-02f, 3.17896694e-01f, -1.62815899e-01f, -2.41031468e-01f,
  1.00980580e-01f, -3.48921567e-02f, -2.11697221e-01f, -2.25694001e-01f, -6.67328909e-02f, -2.46454269e-01f, 2.71702290e-01f, -4.25331891e-02f, -2.90625125e-01f, 6.95939809e-02f,
  2.03679517e-01f, 2.57054150e-01f, 4.06350523e-01f, 1.00397825e-01f, 3.39562505e-01f, 2.98058361e-01f, -6.69814879e-03f, -1.97763950e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.03551397e-01f, 1.75569713e-01f, -4.51813713e-02f, 1.78396821e-01f, 1.61406547e-01f, 2.64962852e-01f, 1.96897775e-01f, 2.03954354e-01f, 2.68335968e-01f, 3.73396389e-02f,
  3.06059346e-02f, 1.42930657e-01f, 1.68266609e-01f, 2.74982005e-01f, 4.27382171e-01f, 1.45229265e-01f, -1.15335345e-01f, -1.35318607e-01f, 2.36516282e-01f, -8.98629650e-02f,
  3.26620221e-01f, 3.36951405e-01f, -2.23033383e-01f, -4.49236065e-01f, -1.54692814e-01f, 3.21024358e-01f, 1.20248884e-01f, -5.20552211e-02f, -2.64655888e-01f, 4.42135602e-01f,
  -1.59247085e-01f, 6.61105871e-01f, 3.14658195e-01f, 3.97801191e-01f, 4.10109937e-01f, 1.80401877e-01f, 1.77633628e-01f, 1.32129371e-01f, 1.35958299e-01f, 1.26439527e-01f,
  7.28544891e-02f, 2.81195819e-01f, 1.16499931e-01f, -1.32630405e-04f, 1.60478125e-03f, -1.60259411e-01f, -5.45038879e-01f, -1.13065271e-02f, -3.22884262e-01f, 2.30476409e-01f,
  -2.42822632e-01f, -5.77133119e-01f, 2.91273177e-01f, 1.09676853e-01f, -5.92526309e-02f, 1.02386820e+00f, 3.49542052e-02f, 1.36225959e-02f, 3.16750556e-01f, -4.40402538e-01f,
  -2.52524167e-02f, -5.82979918e-01f, -3.38880241e-01f, -1.09547272e-01f, 2.86429822e-01f, 2.24428788e-01f, 1.54033944e-01f, 3.75081487e-02f, 5.34623154e-02f, 1.05896248e-02f,
  3.36554706e-01f, 3.64945969e-03f, 1.14579938e-01f, -1.58541352e-02f, 7.67621547e-02f, 1.60362222e-03f, -2.75704771e-01f, -1.44205585e-01f, -2.58390047e-03f, 2.43472233e-02f,
  -1.39992192e-01f, 1.49709940e-01f, -2.28328720e-01f, 2.04213057e-02f, 3.68680567e-01f, 3.93447042e-01f, -2.61627018e-01f, 2.37381697e-01f, 2.32008964e-01f, 5.49207628e-01f,
  5.84907159e-02f, 1.22386388e-01f, 5.24117410e-01f, 7.63068870e-02f, -5.69491871e-02f, 2.98638076e-01f, 2.32813537e-01f, 3.15584630e-01f, 3.68317395e-01f, -9.20507759e-02f,
  8.94821882e-02f, 9.96527821e-02f, 5.09900570e-01f, 1.30107135e-01f, 1.38195246e-01f, 1.14534296e-01f, -2.07063228e-01f, 5.79410531e-02f, 3.57621722e-02f, -2.52633572e-01f,
  -3.43351215e-01f, -3.64397764e-01f, 2.62020770e-02f, 1.93483606e-01f, 3.21070328e-02f, 8.00625309e-02f, -1.51800871e-01f, -2.87279282e-02f, 3.19456816e-01f, 8.51313174e-01f,
  3.04349005e-01f, -1.52621657e-01f, 2.25187838e-01f, -4.69876558e-01f, 4.11179274e-01f, -1.35982469e-01f, 2.34138668e-02f, -8.30837429e-01f, 1.95912987e-01f, -8.57372433e-02f,
  2.03930563e-03f, -1.18191630e-01f, 3.64017516e-01f, 2.79842883e-01f, 1.62697494e-01f, 2.73066431e-01f, -1.99234933e-01f, 1.41354635e-01f, -3.07432830e-01f, -7.66205862e-02f,
  1.40774757e-01f, -7.96134863e-03f, -1.56922624e-01f, -1.12187110e-01f, 2.43258849e-01f, 1.81309447e-01f, 5.12324810e-01f, 1.91158652e-01f, 2.98886120e-01f, -1.50970191e-01f,
  7.06398904e-01f, 3.98084909e-01f, 2.97283739e-01f, -9.67899933e-02f, 2.06352636e-01f, 1.18972495e-01f, -1.14564635e-01f, 3.22031714e-02f, -1.59678549e-01f, 5.84677467e-03f,
  9.65943187e-02f, 1.66691497e-01f, -8.72441605e-02f, 9.34269279e-02f, 2.81860113e-01f, 2.05207825e-01f, 2.58455753e-01f, 2.38202617e-01f, 2.64972270e-01f, 8.87930021e-02f,
  -1.77129850e-01f, 1.08778544e-01f, 1.91800684e-01f, 2.56092966e-01f, 7.12602213e-02f, 1.38757741e-02f, 1.25135466e-01f, 5.65936230e-02f, 1.68214768e-01f, -1.74296752e-01f,
  6.55969858e-01f, 1.04095347e-01f, -8.40583295e-02f, 2.82787904e-02f, -1.73330069e-01f, 4.23616171e-02f, 5.97133934e-01f, 2.01240793e-01f, 1.19686261e-01f, 1.28160119e-01f,
  5.88529930e-02f, 4.11565721e-01f, 2.55146399e-02f, 1.63432181e-01f, 3.20004374e-02f, -1.72031999e-01f, -2.65806109e-01f, -1.12895645e-01f, 1.93330482e-01f, 9.19302274e-03f,
  -1.80788010e-01f, 6.79359511e-02f, 1.71753511e-01f, 6.47324681e-01f, 7.92770460e-02f, 3.57477099e-01f, 1.25128061e-01f, -1.14218637e-01f, -4.64001894e-01f, -2.92933017e-01f,
  -2.74159998e-01f, -3.65737259e-01f, 4.12675172e-01f, -4.61031571e-02f, -2.40274772e-01f, 4.14918095e-01f, -7.42973983e-01f, 2.09318265e-01f, 2.19204873e-01f, 3.06546330e-01f,
  3.72104526e-01f, -8.09895635e-01f, 3.42280082e-02f, -1.61715209e-01f, 6.24284446e-02f, 7.55679533e-02f, 7.06809312e-02f, 1.94167867e-01f, -7.35541955e-02f, 2.42669553e-01f,
  -6.97375983e-02f, -1.24170249e-02f, 1.19264476e-01f, 2.93314755e-01f, 5.07361293e-01f, 4.32129711e-01f, 3.73075277e-01f, -3.53994280e-01f, 2.86199987e-01f, 5.63598812e-01f,
  -3.16349804e-01f, -1.07721575e-01f, 7.54979998e-02f, -3.58916670e-01f, -9.24580038e-01f, 5.49908765e-02f, -1.65303096e-01f, 2.31306300e-01f, 2.00614631e-01f, -2.87344664e-01f,
  9.70886871e-02f, -1.01638712e-01f, -7.46237218e-01f, -4.24199700e-01f, -4.51618254e-01f, -7.08927989e-01f, 2.83878684e-01f, -3.34454002e-04f, 9.87928733e-02f, 2.62525707e-01f,
  3.36265385e-01f, 1.46720916e-01f, 1.76295727e-01f, 1.48102105e-01f, -8.19648057e-02f, 1.31377980e-01f, -1.23445645e-01f, -2.00422704e-01f, 1.43974528e-01f, 3.38108242e-01f,
  -3.42776999e-02f, 1.32238701e-01f, -5.68744726e-02f, 1.24464929e-01f, 3.11758339e-01f, 7.23122597e-01f, 3.47194791e-01f, 1.87629282e-01f, 3.69183004e-01f, 1.68959668e-04f,
  5.99757358e-02f, 4.86624509e-01f, -1.26618454e-02f, -1.21245086e-01f, 7.74548575e-02f, -1.59017026e-01f, -7.07683936e-02f, 7.63234019e-01f, -4.72205095e-02f, -2.24481508e-01f,
  1.14319548e-02f, 2.07705647e-01f, 1.59312636e-01f, 4.57007475e-02f, 3.78648341e-02f, -2.00628504e-01f, -8.39581862e-02f, -5.40339574e-02f, -1.66309513e-02f, -1.73041835e-01f,
  5.79201393e-02f, 3.77179265e-01f, 1.03538871e-01f, -3.77299517e-01f, 2.21409753e-01f, -2.01143086e-01f, 5.27409971e-01f, -9.14639384e-02f, 5.23737371e-01f, 2.27748692e-01f,
  8.82498994e-02f, 1.77157387e-01f, 1.03396170e-01f, 2.23270625e-01f, 7.85347402e-01f, 3.97821516e-02f, 5.08454703e-02f, 6.14576399e-01f, -3.86323743e-02f, 1.23075657e-01f,
  2.08153605e-01f, 1.99726418e-01f, -5.27356826e-02f, -2.09772214e-01f, -7.10192695e-02f, -3.68571952e-02f, 7.43053332e-02f, -1.95221491e-02f, -3.99003737e-02f, 2.10473016e-01f,
  1.62857026e-01f, 7.86191076e-02f, -2.37368628e-01f, -2.83414274e-01f, -1.36514381e-01f, 1.35074064e-01f, -2.87308991e-01f, 1.85765624e-01f, -7.18562156e-02f, -2.10123673e-01f,
  -6.40627146e-01f, 4.09785628e-01f, -8.89381170e-02f, 1.11797914e-01f, 5.12162894e-02f, 4.46834832e-01f, 4.89128292e-01f, 4.42702807e-02f, 4.49477613e-01f, -5.23782015e-01f,
  -4.70620245e-01f, -5.04209876e-01f, 1.97915763e-01f, 2.47524768e-01f, 1.83639020e-01f, 4.87494618e-02f, -9.21549797e-02f, 5.58523461e-02f, -1.23607993e-01f, 1.54481158e-01f,
  3.27439606e-01f, -2.40530446e-01f, -1.34902030e-01f, -2.69402266e-01f, -2.07971781e-01f, 2.40218211e-02f, 1.78612858e-01f, 2.85879433e-01f, 3.36194456e-01f, 7.07091242e-02f,
  6.12875760e-01f, 5.26172280e-01f, -3.43573302e-01f, 5.09481668e-01f, 5.62946618e-01f, -3.48023206e-01f, -3.97792906e-02f, 3.63289267e-02f, 3.47807780e-02f, -1.36345774e-01f,
  7.04375327e-01f, 7.37037182e-01f, 2.39924699e-01f, -1.19975023e-01f, 1.55868933e-01f, 3.15188050e-01f, -7.07683861e-02f, -3.89828831e-02f, -1.12338617e-01f, 2.10622326e-02f,
  1.83833316e-01f, 2.02513784e-02f, 8.87251943e-02f, 7.39539862e-02f, 3.43816996e-01f, 5.81233144e-01f, 9.79921520e-02f, 2.11839035e-01f, 3.81174237e-01f, 3.90604883e-01f,
  -1.02613010e-01f, -4.66644436e-01f, 1.64130870e-02f, -1.18178017e-01f, 2.32989296e-01f, -1.26178488e-01f, -2.00071186e-01f, 1.90653205e-02f, -4.10417318e-01f, 9.22686756e-02f,
  3.05299193e-01f, 4.38632518e-02f, 1.11076079e-01f, -4.99149740e-01f, -2.39249561e-02f, 1.36320472e-01f, 1.80403993e-01f, 4.55989182e-01f, 2.11631402e-01f, -2.80239731e-02f,
  2.53925025e-02f, 1.32268503e-01f, 8.69531408e-02f, 6.68627582e-03f, 3.27931046e-01f, 1.24013145e-02f, -1.44831941e-01f, 5.66053867e-01f, -8.27590153e-02f, -1.06878333e-01f,
  -9.64463875e-02f, 1.55347601e-01f, -1.99648350e-01f, -2.35812038e-01f, 3.02327484e-01f, 3.40826720e-01f, -5.83709657e-01f, 5.46318144e-02f, 1.21883437e-01f, -5.27559668e-02f,
  -6.06189907e-01f, 7.14807957e-02f, 8.12248826e-01f, 1.39253169e-01f, 7.47357845e-01f, 2.75942800e-03f, 1.34998351e-01f, 1.07229993e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.42428145e-01f, 3.33902657e-01f, -2.01150626e-02f, 2.21404329e-01f, 3.06556262e-02f, 1.06557265e-01f, 1.65077701e-01f, 4.74959880e-01f, 1.26415238e-01f, -2.03727242e-02f,
  2.96267956e-01f, 2.57999003e-01f, 1.89814091e-01f, 6.04272008e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.20946825e-01f, -2.63377577e-01f, -2.30758563e-01f, -1.15013786e-01f, 3.71159285e-01f, -3.92517596e-02f, -1.16498597e-01f, 1.64931819e-01f, -5.89858890e-02f, -2.10922763e-01f,
  2.79633343e-01f, 1.82485461e-01f, -1.06378943e-01f, 2.89243639e-01f, -4.74368967e-02f, -3.38252932e-01f, -1.91724911e-01f, 2.91342080e-01f, 4.22254443e-01f, -8.29174221e-02f,
  2.25771770e-01f, -7.09201694e-02f, 6.21983549e-03f, 2.19498709e-01f, -3.88102412e-01f, -3.79892617e-01f, -1.44809321e-01f, 7.30368271e-02f, -2.07128271e-01f, 1.18167944e-01f,
  -2.40118816e-01f, -2.87484974e-01f, -1.47603497e-01f, 3.63924131e-02f, 5.67320168e-01f, 4.20297198e-02f, 1.39117092e-01f, 4.40472007e-01f, -2.61457175e-01f, -5.44659048e-02f,
  2.61082113e-01f, 1.61770120e-01f, -4.23706174e-02f, -3.48700285e-01f, 1.08098023e-01f, -3.47569674e-01f, 2.55194157e-01f, -1.15355320e-01f, 1.65300537e-02f, -2.10124940e-01f,
  2.50090845e-02f, -9.48586129e-03f, -2.52427727e-01f, 4.55594361e-01f, -1.71989381e-01f, -2.21038833e-01f, -2.37712756e-01f, 1.71627209e-01f, 4.40273285e-02f, -1.79153785e-01f,
  1.48004606e-01f, 1.70342714e-01f, -1.14646956e-01f, -2.01689869e-01f, 7.25200176e-02f, 1.89471290e-01f, -3.90381850e-02f, 6.77250475e-02f, -2.21873552e-01f, 2.28694901e-01f,
  -3.87123972e-02f, 1.86516389e-01f, 1.17568702e-01f, 2.66372681e-01f, -3.67829472e-01f, -5.50073385e-01f, -1.90421659e-02f, -1.96463376e-01f, 2.61947930e-01f, 1.59890413e-01f,
  -1.61668420e-01f, 3.64818305e-01f, -1.03706107e-01f, 1.44044846e-01f, -1.73116267e-01f, 3.23156804e-01f, -1.87329262e-01f, -3.07894111e-01f, 2.89399326e-01f, 9.01542976e-02f,
  -2.02873498e-01f, 1.75917506e-01f, 5.21499626e-02f, -1.46527469e-01f, -1.31282032e-01f, 1.18112765e-01f, 2.04219967e-01f, 2.37133399e-01f, 3.10397059e-01f, 6.76280111e-02f,
  -1.02781586e-01f, 3.31722409e-01f, -1.30203575e-01f, 9.12180319e-02f, 9.85887349e-02f, -2.39889801e-01f, 9.32082534e-02f, -3.56286317e-01f, -3.08599025e-01f, -1.49783060e-01f,
  8.20445791e-02f, -2.75363982e-01f, 1.70703813e-01f, 1.98846176e-01f, 8.89410079e-02f, -1.59087986e-01f, -1.21514788e-02f, 1.11993730e-01f, 3.80357951e-02f, 9.08746347e-02f,
  -5.19045532e-01f, -3.28530490e-01f, -2.24473793e-02f, 9.63391215e-02f, 1.21390127e-01f, 2.63544381e-01f, -3.77726972e-01f, -1.72078505e-01f, -3.44371408e-01f, 1.15226910e-01f,
  2.82783806e-01f, -2.87144929e-01f, -1.91537410e-01f, -3.05624992e-01f, -8.88003409e-02f, -5.11360943e-01f, -2.00393066e-01f, 2.38918528e-01f, -3.39629620e-01f, 9.10928324e-02f,
  1.18271858e-01f, 4.09632415e-01f, -3.74457508e-01f, 6.19019903e-02f, -2.90236086e-01f, 2.02251732e-01f, 1.95854574e-01f, 1.79136261e-01f, -4.93573435e-02f, -6.41067922e-02f,
  -2.42384616e-03f, 1.81886237e-02f, 8.09386820e-02f, -3.27908009e-01f, 1.74962595e-01f, -1.79480743e-02f, -2.60992646e-01f, -4.12048064e-02f, -2.62428284e-01f, -3.58324021e-01f,
  9.36212838e-02f, -7.65018016e-02f, 1.30020399e-02f, -1.34326175e-01f, 1.36359215e-01f, -9.28293541e-02f, -1.48570044e-02f, -1.94918036e-01f, 1.01669123e-02f, -1.67730272e-01f,
  1.16910473e-01f, -2.85151958e-01f, 5.01702242e-02f, -1.15944825e-01f, -4.46968049e-01f, -3.91615808e-01f, -3.65109026e-01f, 5.03016748e-02f, -2.04723198e-02f, -3.34643960e-01f,
  -3.14979166e-01f, 5.49753569e-02f, 1.74333528e-01f, -1.52983218e-01f, 2.91501462e-01f, -4.93486822e-01f, 6.81529343e-02f, -1.86775997e-01f, -1.48064956e-01f, -1.57903537e-01f,
  2.96179980e-01f, 3.14385593e-01f, -2.30529815e-01f, 2.44741023e-01f, 1.67505369e-01f, -2.51356989e-01f, 1.38756856e-01f, 3.21698546e-01f, 3.25895809e-02f, 1.39120936e-01f,
  1.13475256e-01f, 2.16058224e-01f, 9.54406615e-03f, -4.66231078e-01f, -4.43562455e-02f, -3.63641649e-01f, -6.14531003e-02f, 1.21502131e-01f, 3.06629419e-01f, 1.89577088e-01f,
  -4.83142324e-02f, -6.55863807e-02f, 1.73376113e-01f, 5.01226485e-02f, -3.98556404e-02f, -2.77015090e-01f, -3.00109595e-01f, 4.54525024e-01f, -2.04498619e-01f, -2.33706310e-01f,
  1.05822086e-01f, 2.06825197e-01f, -2.57437766e-01f, -1.20621897e-01f, 2.13772014e-01f, 3.59867625e-02f, -1.93907812e-01f, 6.26485124e-02f, 2.87634343e-01f, 1.25515014e-01f,
  4.09782454e-02f, 2.65212238e-01f, 1.93239897e-01f, 1.71153441e-01f, 7.04416782e-02f, -9.45075601e-02f, -2.38111854e-01f, -5.50697669e-02f, 2.36942589e-01f, -9.04931203e-02f,
  4.44469452e-02f, 3.55256021e-01f, 1.35219231e-01f, 1.73612833e-01f, -1.74291283e-01f, 1.96152329e-01f, 1.48828924e-01f, 7.99636692e-02f, 4.20249343e-01f, 1.44450843e-01f,
  -3.14094126e-01f, -5.36623187e-02f, 2.28570893e-01f, -1.01048730e-01f, 1.03419147e-01f, 2.19502673e-01f, -1.20093934e-01f, 1.60070240e-01f, 5.18008530e-01f, 1.68603286e-01f,
  7.26282969e-02f, 2.25768611e-01f, 2.45967042e-02f, 2.36972272e-01f, 7.78158456e-02f, -8.88281167e-02f, -1.17642641e-01f, 1.99199263e-02f, 1.45060658e-01f, -4.54558954e-02f,
  -3.95456612e-01f, 3.46632272e-01f, 2.23961502e-01f, 1.98356688e-01f, -2.67978907e-01f, 6.54685572e-02f, 1.10648058e-01f, 3.34510893e-01f, 1.53502420e-01f, -2.99614459e-01f,
  1.34201631e-01f, 3.11879039e-01f, -8.59931409e-02f, -1.64577991e-01f, -1.69861361e-01f, -4.90838885e-02f, -1.85836572e-03f, -2.88856477e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.02775337e-02f, 2.79634595e-01f, 5.68203665e-02f, 2.48190552e-01f, 6.22422278e-01f, 4.64995325e-01f, 9.52978656e-02f, 1.58101216e-01f, 2.02389881e-01f, 5.17556131e-01f,
  -2.91327126e-02f, 1.16834179e-01f, -6.21751726e-01f, 3.99659455e-01f, 5.85213363e-01f, -7.98155516e-02f, 4.44133908e-01f, 2.27777302e-01f, 4.27722007e-01f, -1.50234118e-01f,
  1.68769553e-01f, -6.21790648e-01f, -1.54615387e-01f, 8.14539045e-02f, 3.59603286e-01f, 4.22199577e-01f, -2.41814330e-02f, 2.09713370e-01f, 3.97611618e-01f, 3.68601412e-01f,
  5.25384724e-01f, -2.07561672e-01f, 2.84926921e-01f, 2.55025208e-01f, -3.61815393e-01f, -1.77562255e-02f, -3.08275729e-01f, 8.76758546e-02f, 3.18764627e-01f, 5.45555115e-01f,
  -1.47243053e-01f, -9.60488975e-01f, 8.63934040e-01f, 3.26368690e-01f, 6.57266498e-01f, -4.74557161e-01f, -1.54291734e-01f, 1.71776772e-01f, -1.48124084e-01f, -7.73515701e-02f,
  -3.15291077e-01f, 3.30217630e-01f, 2.97271907e-01f, 4.04482991e-01f, -1.35530885e-02f, 1.76945716e-01f, 9.14136097e-02f, -9.66132462e-01f, -8.50860868e-03f, -7.00518489e-02f,
  1.90147698e-01f, 1.59608737e-01f, -4.08162922e-02f, 7.79185057e-01f, -4.38972086e-01f, 2.60928243e-01f, -4.07009095e-01f, -8.30761611e-01f, -3.83010745e-01f, -4.68072623e-01f,
  3.85155678e-01f, -4.15389597e-01f, -2.28450045e-01f, 4.46141541e-01f, -3.02511066e-01f, 3.28921646e-01f, -2.41986886e-01f, 2.03179106e-01f, 3.61052275e-01f, -3.77277136e-01f,
  6.63032830e-02f, 5.70327997e-01f, 2.30427254e-02f, 3.03227603e-01f, 2.69663215e-01f, 8.87676105e-02f, 8.93139765e-02f, 3.61943096e-01f, 7.53753066e-01f, -5.13217628e-01f,
  1.66100282e-02f, 3.65064472e-01f, 1.29185691e-01f, 5.22700511e-03f, 1.40199602e-01f, 9.41935703e-02f, 1.18172020e-01f, 4.46892202e-01f, -1.55457854e-02f, 1.85131684e-01f,
  -5.22491895e-02f, -3.86277065e-02f, 9.25673246e-02f, -4.00974810e-01f, -1.65762063e-02f, -4.45094913e-01f, 9.49742869e-02f, 2.23402858e-01f, -1.67853497e-02f, -4.60151702e-01f,
  4.51435558e-02f, -4.84964341e-01f, -5.88032007e-01f, -3.27366799e-01f, 2.14066505e-01f, -1.54470935e-01f, 7.15807304e-02f, 1.74411714e-01f, 2.64808267e-01f, -3.66710946e-02f,
  -1.08314656e-01f, -8.79486129e-02f, 5.97758055e-01f, 8.89846683e-03f, 4.44516301e-01f, 4.16229248e-01f, 2.09982097e-02f, 6.59935057e-01f, 2.67026961e-01f, 5.97849429e-01f,
  3.91707420e-01f, -2.68092573e-01f, 5.61038107e-02f, 3.10670853e-01f, 2.86219120e-01f, 4.57802832e-01f, 3.59799981e-01f, -4.13512671e-03f, 9.99525487e-02f, 2.77583301e-01f,
  1.99766248e-01f, -6.68717325e-01f, 1.80884451e-01f, 2.18816027e-01f, 1.00347149e+00f, 5.29428124e-01f, -3.74878198e-01f, 1.03710011e-01f, 2.56250441e-01f, 2.95830667e-01f,
  -4.28291261e-01f, -6.62796021e-01f, -3.81914303e-02f, 4.94962662e-01f, -1.00449100e-01f, -3.33833218e-01f, 7.17220485e-01f, 2.05104113e-01f, -1.02276757e-01f, 3.94154757e-01f,
  8.46745670e-02f, 8.32351893e-02f, 7.39662582e-03f, 3.99774969e-01f, 2.48170570e-01f, -1.68029472e-01f, 1.35679916e-01f, -9.61653069e-02f, 2.74608940e-01f, 1.76223144e-02f,
  7.86798894e-02f, 5.22305429e-01f, 1.01009503e-01f, 3.82597744e-01f, 2.99497038e-01f, 7.61610985e-01f, 3.32452685e-01f, -3.44029844e-01f, 5.88664636e-02f, 1.87463611e-02f,
  -9.79447439e-02f, -3.86811614e-01f, -3.70750457e-01f, 7.40651637e-02f, 8.41349304e-01f, 2.24194825e-01f, 4.61326353e-02f, -3.50986421e-01f, 1.95410848e-01f, 7.45381415e-02f,
  8.05941939e-01f, 6.34822905e-01f, -1.39196351e-01f, -1.66866004e-01f, 3.82538527e-01f, 7.15935111e-01f, -4.54189349e-03f, 2.33823881e-01f, -3.35679144e-01f, -3.38194519e-01f,
  1.62257046e-01f, 3.38651001e-01f, -4.52670991e-01f, 6.65582597e-01f, -2.67655283e-01f, 5.04783809e-01f, 3.36545974e-01f, 1.00361395e+00f, -1.19070038e-01f, -9.03080404e-02f,
  8.29009473e-01f, 3.45149249e-01f, 3.20600152e-01f, -2.34252866e-02f, 3.12033862e-01f, 1.92612916e-01f, -4.25765067e-02f, 7.86609948e-01f, 7.68609881e-01f, 1.11155979e-01f,
  1.71976656e-01f, -2.13291332e-01f, 2.03863546e-01f, -6.14816666e-01f, -6.74242437e-01f, -7.77830631e-02f, 3.46689999e-01f, -1.29717991e-01f, 5.13989151e-01f, -4.85056609e-01f,
  2.58719504e-01f, -3.60878944e-01f, -4.28395979e-02f, -2.22622901e-01f, -6.18353188e-01f, 9.25800949e-02f, 4.54382837e-01f, 2.81133294e-01f, -7.10434616e-01f, -3.33053321e-01f,
  -4.05204087e-01f, -1.87404096e-01f, 1.20614223e-01f, -5.58183640e-02f, 1.31608188e-01f, -3.70013207e-01f, 2.94347882e-01f, 5.28112352e-02f, 1.02002716e+00f, -3.26241910e-01f,
  3.20102960e-01f, 2.73672551e-01f, -1.98155791e-01f, 1.73665613e-01f, 5.42548895e-01f, -2.00220644e-01f, 2.12686211e-01f, 5.47666311e-01f, 5.75247288e-01f, 8.67784843e-02f,
  -4.32518899e-01f, 3.61632109e-01f, 9.28691104e-02f, 2.54917443e-01f, 2.40312174e-01f, 4.08664607e-02f, -3.06058079e-01f, 1.65245831e-01f, 5.42324185e-01f, -2.56252497e-01f,
  -1.52052969e-01f, 4.20013487e-01f, 2.39364523e-02f, 1.07583396e-01f, -3.36082429e-01f, 8.58561397e-01f, 3.02265018e-01f, 7.77277410e-01f, 1.54399157e-01f, -1.06410936e-01f,
  -4.68133688e-02f, 5.10311604e-01f, 1.42812908e-01f, -3.69569212e-02f, 2.44077248e-03f, -2.33936295e-01f, -2.69324899e-01f, -5.18154167e-02f, 5.28805912e-01f, 1.06474347e-01f,
  -1.85692817e-01f, 1.42636433e-01f, 2.89598018e-01f, 4.28164124e-01f, 3.17327417e-02f, 4.71423417e-01f, 4.43085283e-01f, 1.69653505e-01f, 5.06402791e-01f, 2.58514553e-01f,
  -7.45172203e-01f, 3.84047180e-01f, 8.46217275e-01f, 4.10358310e-01f, 6.17533326e-01f, 7.04332113e-01f, 5.71152568e-01f, -3.34542066e-01f, 9.93402898e-02f, -3.15026432e-01f,
  -2.26367757e-01f, 2.85189599e-01f, 5.94858732e-03f, 6.01381399e-02f, 1.10152818e-01f, 2.55644500e-01f, 2.40848288e-01f, 1.69295117e-01f, 5.38888872e-01f, 4.43705767e-01f,
  -2.20937282e-03f, 1.25333131e-03f, -1.87012777e-01f, -1.51250556e-01f, -3.71347100e-01f, -3.86138052e-01f, -4.40517724e-01f, 2.74661928e-01f, -1.74735561e-01f, 4.93451446e-01f,
  -2.16987655e-01f, 3.03587895e-02f, 3.50284189e-01f, -2.29604736e-01f, -9.20007974e-02f, 2.04823732e-01f, 1.56382233e-01f, 2.87209675e-02f, -5.43011487e-01f, 9.51624587e-02f,
  1.04855686e-01f, 1.60908010e-02f, 1.28229253e-03f, -2.18192160e-01f, 2.57081270e-01f, 2.38550097e-01f, -4.16748047e-01f, 3.25532496e-01f, 3.81005347e-01f, -5.25351167e-02f,
  1.38848005e-02f, 1.54204667e-01f, 2.13420510e-01f, 4.11278196e-02f, 1.36803806e-01f, 3.98515433e-01f, 1.42566785e-01f, 2.04493776e-02f, -1.61925703e-01f, 3.72052729e-01f,
  4.66860443e-01f, -2.45179594e-01f, -1.55196473e-01f, 4.75678265e-01f, 3.86649281e-01f, 1.01096846e-01f, 3.60389322e-01f, 8.51412654e-01f, 5.33057272e-01f, -2.13406608e-02f,
  6.18972033e-02f, 1.48438945e-01f, -6.79743439e-02f, 1.30154630e-02f, -3.15088093e-01f, 8.92066862e-03f, 6.82272136e-01f, 5.47202349e-01f, 1.57560810e-01f, -3.80822688e-01f,
  3.46530050e-01f, -1.37950480e-01f, 5.91547191e-01f, 7.05971599e-01f, 3.44131857e-01f, -1.97586627e-03f, -4.39640433e-02f, -1.90308839e-01f, -9.50457096e-01f, -6.88207597e-02f,
  -3.01240921e-01f, 1.72656462e-01f, 9.66204554e-02f, 6.50158465e-01f, -3.18584591e-01f, -1.93375841e-01f, -1.03973188e-01f, -2.42825806e-01f, 5.01358211e-02f, 2.63764739e-01f,
  -6.41847134e-01f, 4.07757699e-01f, -1.08575821e-02f, 8.30773473e-01f, 7.54935443e-02f, 5.79705298e-01f, 1.23910770e-01f, 2.32106075e-01f, 2.77121253e-02f, 3.53007972e-01f,
  -9.98864174e-02f, 2.51958370e-01f, 3.46397236e-02f, -2.13446826e-01f, -1.61831349e-01f, 3.00356835e-01f, 1.18896157e-01f, 1.84294581e-01f, 7.18745068e-02f, 3.56325090e-01f,
  5.55819094e-01f, 2.54524559e-01f, 6.45049475e-03f, 3.50824416e-01f, 2.14423642e-01f, -2.12341726e-01f, 6.38576984e-01f, -5.05166531e-01f, -1.96345940e-01f, -3.08331460e-01f,
  -4.99047637e-01f, -6.26723945e-01f, -1.72212824e-01f, -9.50393304e-02f, -7.56915808e-02f, -7.90799320e-01f, -3.57280195e-01f, -2.17885636e-02f, 4.38188493e-01f, -1.01165108e-01f,
  -3.71374428e-01f, -1.72653377e-01f, 3.93549576e-02f, 4.71935242e-01f, -3.76691610e-01f, 4.43204314e-01f, 4.19372976e-01f, 7.07990825e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.10364687e-01f, 1.10469162e-01f, -2.72358656e-01f, -1.26164198e-01f, 4.33917433e-01f, -3.33392178e-03f, 1.70234114e-01f, -6.21047318e-02f, 3.24981928e-01f, 1.55618861e-01f,
  1.16885938e-01f, 2.38875672e-01f, 3.09724540e-01f, 2.89347768e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.62523001e-01f, -3.80484125e-04f, 1.32176951e-01f, 1.78987741e-01f, -2.14950725e-01f, 5.12158751e-01f, -3.57206196e-01f, -2.48707995e-01f, -4.37739819e-01f, 3.04121912e-01f,
  -6.03069365e-01f, 2.61293262e-01f, 4.01423387e-02f, 6.53430283e-01f, 1.65841863e-01f, 2.59667546e-01f, -1.81301162e-01f, 3.02460432e-01f, -1.77101254e-01f, -6.47201180e-01f,
  -1.31085008e-01f, 1.66295707e-01f, -2.55637258e-01f, -4.19544190e-01f, 1.52762339e-01f, 5.17189920e-01f, -8.50618407e-02f, -3.17022800e-01f, -3.98261636e-01f, -3.79934996e-01f,
  -4.66698617e-01f, 2.56669551e-01f, -2.05776915e-01f, -3.29602480e-01f, -5.59385657e-01f, -9.43404660e-02f, 2.82960594e-01f, -5.24408579e-01f, 2.04458028e-01f, 2.56677806e-01f,
  -4.31635648e-01f, -7.14515746e-02f, -5.09654403e-01f, -2.88413703e-01f, 5.46562791e-01f, 4.62189466e-01f, 4.13898051e-01f, -1.12497367e-01f, -3.19898725e-01f, -1.05647720e-01f,
  2.10853323e-01f, -4.93702143e-01f, 4.07591909e-01f, 2.86926292e-02f, -1.32540211e-01f, -6.83214784e-01f, 4.69262242e-01f, -1.20236620e-01f, -1.90983981e-01f, 1.32943332e-01f,
  -2.49617025e-02f, -6.12996161e-01f, -1.57501310e-01f, -6.54922664e-01f, 2.96621680e-01f, 1.97904229e-01f, 1.85175687e-01f, 3.31427574e-01f, 1.12947993e-01f, -3.53405803e-01f,
  -4.01650816e-01f, -1.09559014e-01f, 1.03555597e-01f, 1.82633027e-01f, 1.05053253e-01f, 2.22211748e-01f, 1.19521543e-01f, 8.23580205e-01f, -1.98824003e-01f, -4.47407246e-01f,
  -1.60554461e-02f, 1.85523614e-01f, -7.93643475e-01f, -7.05795456e-03f, 1.02012195e-01f, -2.46313736e-01f, -9.26671267e-01f, -2.49766335e-01f, 3.81710887e-01f, -3.55244391e-02f,
  4.29870695e-01f, -7.20284700e-01f, -2.51687795e-01f, -6.50785983e-01f, 4.46925193e-01f, -4.51714754e-01f, 3.31721932e-01f, 3.30007464e-01f, 1.01876989e-01f, -1.67588163e-02f,
  -4.54143494e-01f, 3.34330499e-01f, -6.70467138e-01f, -7.62171447e-02f, -5.56623995e-01f, 1.37747437e-01f, -5.23765564e-01f, -4.27210517e-02f, -2.23939389e-01f, 3.65765274e-01f,
  4.75074738e-01f, -4.52753305e-01f, 7.00810790e-01f, 5.86201139e-02f, -6.08551323e-01f, 1.96839705e-01f, 1.24362364e-01f, 1.99856922e-01f, -6.69691741e-01f, -3.36557537e-01f,
  -6.13891602e-01f, -6.06362700e-01f, -7.35562027e-01f, 3.20004970e-01f, -3.05684596e-01f, -2.58939922e-01f, 4.93330777e-01f, 2.37064034e-01f, 2.40945652e-01f, -4.27074999e-01f,
  -2.83045918e-01f, -4.00033474e-01f, -4.23962958e-02f, -4.15929884e-01f, 5.15522659e-01f, 3.28568071e-01f, 6.31144881e-01f, -3.41843069e-01f, 9.89632189e-01f, -3.17246765e-01f,
  6.22157335e-01f, -3.74540061e-01f, 4.90532935e-01f, -2.35399768e-01f, -6.41565084e-01f, -5.64361870e-01f, -4.33562905e-01f, 2.17070952e-01f, -3.58623177e-01f, 3.46392870e-01f,
  -1.55635417e-01f, -1.55593738e-01f, -4.46793139e-01f, 3.73598151e-02f, -4.92493920e-02f, -6.88706338e-01f, 8.67513046e-02f, -1.32268474e-01f, -3.76301974e-01f, 3.17223877e-01f,
  -4.35610741e-01f, 4.41870987e-01f, -5.24393141e-01f, 6.17744803e-01f, 1.55804276e-01f, -3.61336730e-02f, -1.45689622e-02f, 5.05029798e-01f, -3.98597360e-01f, 5.71103394e-01f,
  -3.32066298e-01f, -3.90705287e-01f, 5.02990723e-01f, -6.24358416e-01f, -6.47942483e-01f, -6.65899098e-01f, 7.16275796e-02f, -4.24079627e-01f, -1.12834528e-01f, 2.46533960e-01f,
  -5.19931972e-01f, -4.81842384e-02f, -4.58954245e-01f, 4.79008436e-01f, 3.16933751e-01f, -3.87454748e-01f, -3.20777684e-01f, 3.26981872e-01f, -5.89040071e-02f, 3.03940296e-01f,
  -5.54258704e-01f, -6.65960014e-02f, -5.07776320e-01f, 6.93935389e-03f, -5.72556198e-01f, 2.24458858e-01f, 5.93509138e-01f, 4.75894988e-01f, -2.62716085e-01f, 9.27423686e-02f,
  -2.00929597e-01f, -1.26806468e-01f, 5.83413959e-01f, 3.77989471e-01f, -2.36848980e-01f, -3.61006945e-01f, 1.55089974e-01f, 1.78436652e-01f, 1.55521214e-01f, 1.53040856e-01f,
  -5.60477793e-01f, -2.17035666e-01f, -3.49730611e-01f, -7.18170166e-01f, 2.11337551e-01f, -2.78485864e-01f, 3.16502720e-01f, 2.70545810e-01f, 3.36445153e-01f, -5.81963956e-01f,
  4.63484138e-01f, 1.56340882e-01f, 2.03618959e-01f, 1.95729673e-01f, -1.71526462e-01f, -4.67696488e-01f, -1.78946808e-01f, -1.21289425e-01f, 2.33429503e-02f, 2.25996912e-01f,
  -5.55137768e-02f, 3.11335437e-02f, 1.71251073e-01f, -2.50475138e-01f, -1.66168615e-01f, 6.56479821e-02f, -6.82612002e-01f, 5.52303314e-01f, 1.39053449e-01f, 4.12153713e-02f,
  -2.24282563e-01f, -6.30637467e-01f, -2.67318487e-01f, 2.99935073e-01f, 4.23208773e-01f, -3.69925573e-02f, -5.49086034e-02f, 3.60383868e-01f, -2.47470394e-01f, 8.52026939e-02f,
  -2.29732826e-01f, -1.39284700e-01f, 4.02108580e-01f, 1.54507473e-01f, -1.36168906e-03f, -2.45362833e-01f, 6.26947403e-01f, -3.77747625e-01f, 5.48455656e-01f, -1.26036510e-01f,
  1.13477468e-01f, 2.58078873e-01f, -3.34854364e-01f, -6.46551728e-01f, -4.62554842e-02f, 2.29568370e-02f, 3.99858244e-02f, -2.61823833e-01f, -8.91417861e-01f, -2.86968917e-01f,
  -3.44281375e-01f, 7.90204480e-02f, 2.23928139e-01f, -2.59109408e-01f, 2.19636440e-01f, -2.82899112e-01f, 4.38404858e-01f, -4.31742489e-01f, -3.91802877e-01f, 4.64912683e-01f,
  1.73784699e-02f, 1.25689790e-01f, -4.49336171e-01f, 1.64945453e-01f, -3.75501186e-01f, 3.04152697e-01f, -3.13271582e-01f, -3.16013008e-01f, 4.14339393e-01f, 3.81432533e-01f,
  2.03350157e-01f, 1.35745719e-01f, -4.16462757e-02f, 2.30596717e-02f, 3.98407370e-01f, 2.39970908e-01f, 2.89500654e-01f, -4.71736759e-01f, 3.43077481e-02f, 2.76865363e-01f,
  5.00940859e-01f, -3.55738759e-01f, -6.53868437e-01f, 6.38584912e-01f, 3.17987561e-01f, 7.47884810e-01f, -5.21232426e-01f, 5.68081141e-01f, 2.57864356e-01f, -1.56931862e-01f,
  4.83877838e-01f, -6.24132395e-01f, -4.32050735e-01f, -6.98292494e-01f, 2.58644044e-01f, -1.73918709e-01f, -2.05166966e-01f, 5.58299152e-03f, -1.04760960e-01f, -4.71840501e-01f,
  -3.60845625e-01f, -3.13291103e-02f, 6.22987986e-01f, -5.01017272e-01f, -1.75526291e-01f, 4.22467172e-01f, 2.96198666e-01f, -1.80955186e-01f, 2.43359506e-02f, 5.96260965e-01f,
  6.33681715e-01f, 1.84291124e-01f, 1.58751801e-01f, -3.73577654e-01f, -3.03248376e-01f, 5.06569386e-01f, 7.63696909e-01f, -3.05214792e-01f, 6.35351241e-01f, -6.98225200e-01f,
  -3.58974069e-01f, -3.52526516e-01f, -3.43051180e-02f, -2.11548001e-01f, -8.04565251e-01f, -6.08612001e-01f, -6.45917177e-01f, 5.55733025e-01f, -7.06953645e-01f, -5.19284070e-01f,
  -5.35660744e-01f, 4.96870220e-01f, -5.56685440e-02f, 5.37993252e-01f, 5.58301449e-01f, -9.20752510e-02f, -3.81234109e-01f, -6.37966037e-01f, 3.93153101e-01f, -4.01627779e-01f,
  5.97727299e-01f, -4.04757410e-01f, 1.47953525e-01f, 3.80780011e-01f, -2.11550936e-01f, 1.93643361e-01f, 2.03808248e-01f, 5.84937692e-01f, -2.31641084e-01f, 4.08669055e-01f,
  3.90134096e-01f, -4.25637484e-01f, -8.61619353e-01f, -2.25226805e-01f, 2.79665649e-01f, 5.08386135e-01f, 1.81950852e-01f, -7.39649296e-01f, -7.15526752e-03f, 1.82170421e-01f,
  -1.04464613e-01f, 4.51881140e-01f, -1.12448297e-01f, -2.77195036e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.66983053e-02f, 1.76365189e-02f, 1.99033376e-02f, -1.99682280e-01f, -7.21097051e-04f, 1.46131709e-01f, 2.00770311e-02f, -3.08864266e-01f, -2.07203656e-01f, 7.11022317e-02f,
  2.13163525e-01f, 1.22800745e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    