/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.57749200e-01f, 1.37618601e-01f, 8.81069750e-02f, -1.57034948e-01f, -2.38389969e-01f, 8.41621235e-02f, 2.91158140e-01f, 1.32186085e-01f, -1.83054909e-01f, -1.16269970e-02f,
  -1.18939839e-02f, 2.52943542e-02f, -6.60860091e-02f, 1.11536207e-02f, 2.07508698e-01f, 9.21670124e-02f, -2.27486953e-01f, -4.22362685e-02f, 7.39377216e-02f, -1.49503797e-01f,
  -1.92020178e-01f, -2.22596243e-01f, -7.98724443e-02f, -1.40831575e-01f, -2.66849846e-01f, -9.40845162e-02f, -1.07380942e-01f, -1.69905066e-01f, -1.99757934e-01f, -2.04384521e-01f,
  -9.09304339e-03f, 1.58242151e-01f, 3.20034586e-02f, -1.18765451e-01f, -5.18356226e-02f, -5.93400188e-03f, -1.30159318e-01f, 4.22430634e-02f, -1.18042797e-01f, -4.60641533e-02f,
  -1.16365496e-02f, 3.67793813e-02f, -1.22935437e-02f, -6.35851026e-02f, -1.21765614e-01f, 4.39264514e-02f, 2.71176128e-03f, -1.64088160e-02f, -1.20603539e-01f, -1.04824126e-01f,
  -8.47838819e-02f, -6.74776733e-02f, 4.95037343e-03f, -6.95954710e-02f, 4.93799597e-02f, -1.00649655e-01f, -5.48780756e-03f, -4.55930978e-02f, -3.44815738e-02f, 4.69088089e-03f,
  1.94680378e-01f, -7.01577365e-02f, 2.42267288e-02f, -2.95610875e-02f, -6.19942974e-03f, -6.00462072e-02f, 4.23720013e-03f, -3.44444998e-02f, -8.15846995e-02f, 5.88213503e-02f,
  -1.89021006e-02f, 2.22309381e-02f, -8.04970879e-03f, -1.24740181e-02f, -5.27017787e-02f, -5.92703419e-03f, 6.35403395e-02f, 5.89714907e-02f, -4.42534238e-02f, 1.99340619e-02f,
  -1.48811461e-02f, -9.40720551e-03f, 6.96242135e-03f, 6.15363345e-02f, 1.78711101e-01f, 8.17964822e-02f, 6.47598207e-02f, 2.34748144e-02f, 4.73682694e-02f, -5.65060750e-02f,
  -2.00120077e-01f, -8.54710564e-02f, -3.78755592e-02f, -3.28011960e-02f, -9.82027426e-02f, 4.85448875e-02f, -8.99501443e-02f, 1.36859208e-01f, 2.86397524e-02f, 1.36142867e-02f,
  3.35498527e-02f, 6.06490038e-02f, -1.23294681e-01f, -1.32549614e-01f, -6.56819642e-02f, 7.51428977e-02f, -1.46790028e-01f, -5.73743992e-02f, -1.53867096e-01f, -1.74362972e-01f,
  -5.80692664e-02f, -1.40051264e-02f, -1.30387157e-01f, -9.72775090e-03f, -9.83415395e-02f, 1.97754093e-02f, -1.49029763e-02f, -3.25474120e-03f, -3.32972370e-02f, -4.69041541e-02f,
  -9.48644817e-01f, 2.35993817e-01f, 2.55124811e-02f, -2.39423275e-01f, 2.68563509e-01f, 1.45435482e-01f, 3.61155361e-01f, 1.44116923e-01f, -6.39538690e-02f, 5.52526526e-02f,
  9.84407812e-02f, 1.27051221e-02f, -1.56364992e-01f, 8.30181092e-02f, -4.81124334e-02f, 2.89430529e-01f, 2.09450126e-01f, -9.12848935e-02f, -4.94913645e-02f, 1.28501996e-01f,
  2.18823448e-01f, -2.37468392e-01f, -3.03373486e-01f, -9.47233215e-02f, -3.12036797e-02f, -5.87135851e-02f, -2.36399453e-02f, -4.18574475e-02f, 5.27317114e-02f, 5.67965955e-02f,
  -9.64969471e-02f, -7.05968514e-02f, 1.26931578e-01f, -4.90084887e-02f, -3.46755609e-02f, -1.37473652e-02f, -4.60640192e-02f, 4.36389633e-02f, -6.76193312e-02f, 7.46717080e-02f,
  9.09472778e-02f, -5.16155288e-02f, 2.03490667e-02f, -5.98204834e-03f, 1.19761210e-02f, -8.03112239e-02f, 5.20447716e-02f, -1.18163213e-01f, -7.92297255e-03f, -6.87894132e-03f,
  2.00914785e-01f, 8.13709721e-02f, -9.70572606e-02f, 3.71700116e-02f, 7.72513151e-02f, -8.87019932e-02f, 4.31057438e-02f, -5.32841347e-02f, -6.20020702e-02f, -1.01085640e-01f,
  -3.79259065e-02f, -3.49078886e-02f, 2.63616927e-02f, 8.48806463e-03f, -8.49854350e-02f, 6.18946105e-02f, -6.15028478e-02f, 8.78465362e-03f, 9.28695034e-03f, -8.66744220e-02f,
  7.56045654e-02f, -9.91725083e-03f, -5.58433309e-02f, -6.42127916e-02f, 2.16012876e-02f, -6.08018823e-02f, -3.08453888e-02f, 5.62827140e-02f, 2.03985367e-02f, -7.46979788e-02f,
  2.76282243e-02f, -2.71113645e-02f, -6.11396097e-02f, -1.01553043e-02f, 8.76457244e-03f, -2.66677905e-02f, -2.54899450e-02f, -1.89116336e-02f, 4.77527156e-02f, 5.72251789e-02f,
  1.09733559e-01f, 1.02704160e-01f, -5.63421696e-02f, 6.59935698e-02f, 1.04154378e-01f, 1.13300510e-01f, -9.14793345e-04f, 8.70184153e-02f, 3.70460302e-02f, 1.92565434e-02f,
  4.28660922e-02f, -1.34425294e-02f, 9.98593308e-03f, 8.04954469e-02f, -1.06459530e-03f, -3.66835273e-03f, -2.47646961e-02f, -1.82353090e-02f, 7.58053586e-02f, 7.34619275e-02f,
  1.60376325e-01f, 2.52392199e-02f, 8.26399028e-02f, 5.15915342e-02f, -1.75919104e-03f, -5.42444140e-02f, 1.02059864e-01f, 4.63395640e-02f, 5.76567911e-02f, 5.41030765e-02f,
  4.57168370e-01f, -2.50890553e-02f, 1.17699973e-01f, 1.91574261e-01f, -4.99033742e-02f, -2.30376087e-02f, 2.11632714e-01f, 1.71198100e-02f, -1.28130227e-01f, -1.12039514e-01f,
  -1.97590128e-01f, -2.51324594e-01f, -2.77739763e-01f, -1.91220596e-01f, 6.20344505e-02f, 1.00654013e-01f, -1.07092094e-02f, 1.78959772e-01f, 1.43095613e-01f, 2.98764873e-02f,
  -1.53721541e-01f, 1.41654700e-01f, 2.83320248e-01f, 2.62798872e-02f, -1.39193675e-02f, 3.29187256e-03f, 1.13595314e-02f, 1.28101736e-01f, -1.83042064e-01f, -1.41869485e-01f,
  4.98490743e-02f, 3.22741829e-02f, -1.52172372e-01f, -2.30050996e-01f, -2.17081934e-01f, -1.29661068e-01f, -5.58450408e-02f, -8.61047506e-02f, -9.77794081e-02f, -1.11355223e-01f,
  -2.63233840e-01f, -2.30995059e-01f, -1.82395220e-01f, -1.40632555e-01f, -2.60927575e-03f, -2.25117076e-02f, -2.11196169e-02f, -1.42586241e-02f, -1.15693882e-01f, -8.69821981e-02f,
  -1.66961581e-01f, -8.63125455e-03f, -2.47134473e-02f, -8.25019330e-02f, -1.05192147e-01f, -9.35990587e-02f, -2.21639164e-02f, -4.03389782e-02f, -3.97256538e-02f, -6.51531294e-02f,
  -4.61413432e-03f, -8.77725631e-02f, 1.99939795e-02f, 2.12715909e-01f, 3.02102752e-02f, -4.11706865e-02f, 4.68969494e-02f, 9.01768282e-02f, 1.64852443e-03f, -1.29676552e-03f,
  -1.12901017e-01f, 3.95189822e-02f, -5.08454964e-02f, 2.08906569e-02f, -3.56972553e-02f, -2.00709738e-02f, -1.17237307e-02f, 2.34677196e-02f, -4.43351232e-02f, -5.18295355e-02f,
  -8.67080968e-03f, 3.07380799e-02f, 5.26247583e-02f, -1.37350503e-02f, -2.14581774e-03f, 7.12046847e-02f, -4.40348275e-02f, -7.84551427e-02f, -3.35241482e-02f, 5.78429140e-02f,
  2.33762637e-01f, -9.70885456e-02f, -3.48883197e-02f, -6.66478872e-02f, 1.40456865e-02f, -1.81634918e-01f, -9.93011668e-02f, -2.99523752e-02f, -1.31441072e-01f, -3.62502858e-02f,
  -1.33515224e-01f, -8.82225484e-02f, -9.83097926e-02f, -3.01865451e-02f, -6.31062165e-02f, -4.11988311e-02f, -2.40868740e-02f, 8.30142125e-02f, -1.16046131e-01f, -4.49277461e-02f,
  -4.30804491e-02f, 3.05697806e-02f, 1.53804630e-01f, -3.73058356e-02f, 3.57027985e-02f, 5.84603548e-02f, -1.25578530e-02f, -3.46666649e-02f, 3.70269381e-02f, 1.95046425e-01f,
  4.05159295e-01f, 1.35034278e-01f, -5.97038269e-02f, 4.08960521e-01f, 1.30658939e-01f, -1.83339804e-01f, -1.51717886e-01f, 9.24670547e-02f, 2.22963229e-01f, 1.85114190e-01f,
  -1.61775783e-01f, -1.36881039e-01f, -1.82250693e-01f, -1.17856175e-01f, -2.38006368e-01f, 8.18728209e-02f, 2.00581104e-01f, -4.04718295e-02f, -2.53684610e-01f, -8.32877606e-02f,
  1.31961763e-01f, 2.37097085e-01f, 1.24717787e-01f, 2.12280415e-02f, 3.44004452e-01f, 1.02271205e-02f, 1.24742895e-01f, 6.06401227e-02f, 4.83722873e-02f, 4.18222934e-01f,
  1.04676828e-01f, -1.69541333e-02f, -1.45165771e-01f, 1.31768622e-02f, 3.94581147e-02f, -2.65448000e-02f, -1.85696650e-02f, 3.13814990e-02f, -1.42519979e-03f, 2.69499291e-02f,
  -1.14946850e-02f, -9.09436569e-02f, -1.97115494e-03f, -9.21155438e-02f, 6.37252480e-02f, 5.18783592e-02f, 1.01480158e-02f, 8.99852738e-02f, -9.52121988e-02f, -6.16650470e-02f,
  2.50266511e-02f, -5.92254736e-02f, 5.78359440e-02f, -3.17403302e-02f, -1.59898330e-03f, -6.75381571e-02f, 6.91154301e-02f, 7.20371529e-02f, -9.15225446e-02f, 2.09394619e-01f,
  2.36657374e-02f, -2.64890678e-03f, 4.70511876e-02f, 8.64636526e-02f, -3.46529223e-02f, 8.52140598e-03f, 2.37933360e-02f, -2.19259653e-02f, -1.01489246e-01f, -3.31758372e-02f,
  1.21357078e-02f, 1.42040895e-02f, 3.32040188e-04f, 4.98360880e-02f, -5.21198139e-02f, -9.12774727e-02f, -2.25852169e-02f, 2.02660840e-02f, -3.99391279e-02f, 3.35554183e-02f,
  3.76888849e-02f, -2.37034895e-02f, 4.57188152e-02f, 3.13185230e-02f, 1.11379446e-02f, -3.57054062e-02f, 2.61762813e-02f, -8.17860737e-02f, 5.49436547e-02f, 7.50399679e-02f,
  -1.57484822e-02f, -3.59526068e-01f, 1.28799111e-01f, -5.03233373e-02f, -1.88108403e-02f, 2.39795204e-02f, 2.05730144e-02f, 7.15031847e-02f, 9.88366548e-03f, 1.51725812e-02f,
  4.99442816e-02f, 1.59279779e-02f, -6.95758834e-02f, 2.45499946e-02f, 6.93279058e-02f, 4.11419338e-03f, -3.04460935e-02f, -1.08675517e-01f, 1.28697902e-02f, 1.11745141e-01f,
  1.48261577e-01f, -1.14326380e-01f, -7.22692385e-02f, -6.24548569e-02f, -5.80864884e-02f, -2.08816528e-02f, -7.32112676e-02f, -1.29822269e-01f, -2.18820691e-01f, 4.36537787e-02f,
  -3.33095491e-01f, 1.59205109e-01f, -1.53754324e-01f, -4.04708803e-01f, -2.76570976e-01f, -1.57176241e-01f, 3.66123542e-02f, 2.73143314e-02f, 6.59577036e-03f, 1.12460814e-01f,
  1.28277704e-01f, 8.67084600e-03f, 6.72354251e-02f, 1.95946380e-01f, 5.96027821e-02f, 2.13814974e-02f, -1.32412866e-01f, -1.62406594e-01f, -1.76829264e-01f, -2.00915992e-01f,
  -1.11708687e-05f, -3.31591547e-01f, -2.07165942e-01f, 1.13395691e-01f, 2.03454643e-02f, 4.35019173e-02f, 2.31501348e-02f, -3.01885605e-01f, -3.05361468e-02f, -1.90881938e-01f,
  5.74671738e-02f, -1.11152858e-01f, 1.06955931e-01f, -8.52301368e-04f, 1.59266725e-01f, 2.25932539e-01f, 5.68607375e-02f, 1.40436679e-01f, 1.48828715e-01f, 1.81776777e-01f,
  -8.14850926e-02f, 1.91084087e-01f, 6.33934373e-03f, -1.95177700e-02f, -3.01236212e-02f, -5.20374924e-02f, 9.11112055e-02f, 1.00971304e-01f, 5.21728247e-02f, 6.78244159e-02f,
  4.17368524e-02f, -9.94121879e-02f, -1.18038952e-02f, 6.78969175e-02f, 1.45570204e-01f, -3.35735045e-02f, 8.58712494e-02f, 1.19462177e-01f, 1.49955004e-01f, 1.36846989e-01f,
  3.04976609e-02f, 8.34494308e-02f, -5.62350673e-04f, -9.55315456e-02f, -3.30963321e-02f, 1.83305442e-02f, -1.06827624e-01f, -1.25035644e-01f, -6.24890663e-02f, -1.37417212e-01f,
  8.45917314e-03f, -6.15365505e-02f, -9.17266905e-02f, -1.79367270e-02f, -3.41240168e-02f, -2.56267413e-02f, -2.06055376e-03f, -8.99913833e-02f, -5.42145632e-02f, -8.92157555e-02f,
  -1.91411451e-02f, -6.49715140e-02f, -7.65340552e-02f, 1.41496323e-02f, -6.61356524e-02f, -4.44562547e-02f, -3.55500206e-02f, -8.12961906e-03f, -6.08005263e-02f, -1.24238513e-01f,
  3.08347456e-02f, 2.40478059e-03f, 1.61981001e-01f, 5.83157167e-02f, 1.26105256e-03f, 1.59463614e-01f, 8.49284455e-02f, 1.66490018e-01f, 9.23910812e-02f, 3.81362513e-02f,
  -1.26385177e-02f, 1.13639526e-01f, -1.72863510e-02f, 3.87802385e-02f, -4.81465012e-02f, 5.79361096e-02f, 1.05058417e-01f, 4.64256816e-02f, 1.68838680e-01f, 8.11636150e-02f,
  1.32326812e-01f, 4.08013687e-02f, -2.32939515e-02f, 1.62438691e-01f, 4.19509411e-02f, -2.21946668e-02f, 3.92078143e-03f, 3.91560830e-02f, 1.83033943e-01f, 2.57081032e-01f,
  1.24962114e-01f, -1.29297659e-01f, -2.51939565e-01f, 2.29923248e-01f, 5.17406501e-02f, 2.42906079e-01f, 1.43040165e-01f, 1.50337011e-01f, 2.08847955e-01f, -6.84171095e-02f,
  -1.30600715e-02f, 5.11937216e-03f, -1.35913461e-01f, -6.37326948e-03f, -4.19912860e-03f, -6.88397214e-02f, -2.54154265e-01f, -1.02623038e-01f, 2.94847518e-01f, 3.06176782e-01f,
  1.40962690e-01f, 1.42554849e-01f, 1.77939519e-01f, 1.69183835e-01f, -6.10081144e-02f, 1.51426308e-02f, -2.62932539e-01f, -9.95296016e-02f, -5.01980335e-02f, -3.36615354e-01f,
  -1.76479176e-01f, -2.83204834e-03f, 1.20022558e-01f, 1.84006736e-01f, 5.06673604e-02f, 5.71647771e-02f, -4.19591814e-02f, 1.63679775e-02f, 8.58107954e-02f, -2.71794349e-02f,
  4.69484366e-02f, 1.07528701e-01f, 5.53874671e-02f, -2.25542821e-02f, 8.23181793e-02f, 6.90710098e-02f, -2.50414833e-02f, 3.07096653e-02f, 2.60421298e-02f, 1.65481903e-02f,
  -4.97112684e-02f, -2.06712764e-02f, -8.60134438e-02f, 1.09666914e-01f, 7.40312645e-03f, -8.15027431e-02f, -7.19022676e-02f, 9.57227796e-02f, -6.82695508e-02f, 2.39472766e-03f,
  -1.89558566e-02f, 1.49359312e-02f, -5.64641021e-02f, 3.82965570e-03f, 4.93963063e-02f, -2.77723875e-02f, -2.23379321e-02f, 2.68876702e-02f, 4.39151712e-02f, 8.99256691e-02f,
  -4.44868132e-02f, -7.45108500e-02f, 2.82619447e-02f, -4.50604036e-03f, -3.74248587e-02f, -9.82780084e-02f, 1.07432932e-01f, -5.44219799e-02f, -9.83841345e-03f, 2.38566473e-03f,
  4.70405594e-02f, -1.03305608e-01f, -9.74164605e-02f, -5.66269159e-02f, 6.15507625e-02f, -1.21424474e-01f, 3.49158198e-02f, -3.40101048e-02f, 5.34385070e-02f, -4.13650833e-03f,
  1.83961987e-01f, 7.80431256e-02f, 1.16738625e-01f, 1.84483856e-01f, 1.15453325e-01f, 6.18274994e-02f, 1.04442932e-01f, 6.46373108e-02f, -1.00588627e-01f, 3.97420749e-02f,
  6.82817549e-02f, 4.06411253e-02f, 2.10667662e-02f, 7.61995185e-03f, 4.48112190e-02f, 1.66478194e-02f, -4.65386584e-02f, 1.02907598e-01f, 1.33250266e-01f, 8.23619068e-02f,
  4.07456234e-02f, 1.09745815e-01f, 1.51374280e-01f, 1.27751529e-01f, 9.58634838e-02f, 4.31471802e-02f, 1.22896299e-01f, 1.29808545e-01f, 1.34256288e-01f, 2.26277381e-01f,
  -1.25677168e-01f, -1.36037823e-02f, 9.39414576e-02f, -9.09825414e-02f, -1.76292986e-01f, -2.75224239e-01f, -5.31182051e-01f, -3.66795510e-01f, -1.63476765e-01f, -6.59311563e-02f,
  -3.02930530e-02f, 3.04860026e-01f, 3.16315293e-01f, 3.38776171e-01f, 1.26118600e-01f, -4.04311111e-03f, 5.34885079e-02f, 2.17986882e-01f, -1.13719240e-01f, -2.02636719e-01f,
  -7.38591775e-02f, -3.92829888e-02f, 2.34789923e-02f, -7.87547603e-02f, 9.43534747e-02f, 9.88335311e-02f, -1.64341927e-02f, -3.15567255e-02f, -2.46184645e-03f, 4.27752912e-01f,
  4.83755879e-02f, -1.74195617e-01f, 8.64612386e-02f, 1.57040104e-01f, -1.51634850e-02f, -8.10321122e-02f, -5.54661825e-02f, 7.63421040e-03f, 5.21955825e-03f, 1.25795538e-02f,
  9.75710824e-02f, 1.31068334e-01f, 1.05470479e-01f, -6.23751953e-02f, 1.44963805e-02f, -8.56858119e-02f, -6.84336424e-02f, 7.15740025e-02f, 1.65622700e-02f, -9.39733535e-02f,
  -3.80912535e-02f, -1.43135786e-01f, -9.17470753e-02f, -1.58008002e-02f, 3.01449578e-02f, 1.20779812e-01f, 6.77843243e-02f, -3.77332605e-02f, -1.13762380e-03f, 2.11074576e-02f,
  -2.23675042e-01f, 1.02339260e-01f, 1.63304731e-02f, -2.09056232e-02f, 1.74863977e-04f, -8.57568830e-02f, -1.20895440e-02f, 1.41239241e-02f, 1.19603962e-01f, 3.78442556e-02f,
  5.59723657e-03f, 1.87642816e-02f, -2.11945176e-02f, 3.99769284e-02f, -1.06283408e-02f, -6.10248893e-02f, -2.44465396e-02f, -3.23528610e-02f, 7.14734793e-02f, 4.97223884e-02f,
  -4.16139439e-02f, -3.78919803e-02f, 6.09336570e-02f, 8.35418776e-02f, -5.11027947e-02f, 6.88531026e-02f, 2.10468601e-02f, 2.41509788e-02f, 1.16468579e-01f, -9.10167471e-02f,
  1.65433511e-01f, 1.24551453e-01f, -9.02846456e-03f, 8.25361833e-02f, 9.13060009e-02f, 1.08076051e-01f, -4.30049077e-02f, 5.13087548e-02f, -8.19924008e-03f, -3.13251093e-02f,
  1.10348556e-02f, -9.97057557e-03f, 2.71357764e-02f, -9.29598734e-02f, -4.00464125e-02f, -1.46398604e-01f, -1.85285211e-02f, -6.04615454e-03f, 1.06131509e-01f, -2.39100382e-02f,
  1.85924452e-02f, -1.23139516e-01f, 2.60341243e-04f, -1.12270273e-01f, -1.09454598e-02f, -1.64696097e-01f, -6.55138958e-03f, -7.65404925e-02f, -3.33163887e-02f, -9.08715352e-02f,
  -1.10853978e-01f, -6.63399324e-02f, -2.63718367e-01f, -1.15264937e-01f, -5.36985211e-02f, -1.92478329e-01f, -4.44539219e-01f, -3.05476725e-01f, -1.73336506e-01f, -2.61214763e-01f,
  3.11912969e-02f, 2.80173600e-01f, 1.07273668e-01f, 4.49948236e-02f, -1.06100097e-01f, -4.51860875e-01f, -3.43632102e-01f, -1.18923344e-01f, -4.13648970e-02f, 6.38183430e-02f,
  1.02062777e-01f, -5.28426319e-02f, -1.41998962e-01f, -2.18970791e-01f, -9.10568684e-02f, 9.19114519e-03f, -4.26535994e-01f, -1.92377135e-01f, -9.44410264e-02f, 1.09226875e-01f,
  -8.89755692e-03f, -8.61831978e-02f, -1.99170440e-01f, -7.37061128e-02f, -1.64608538e-01f, -1.25865191e-01f, -1.23961285e-01f, -1.50412545e-01f, -1.10308707e-01f, -2.05059022e-01f,
  -5.35628758e-02f, -1.18156828e-01f, -6.34526461e-02f, -1.31440356e-01f, -1.26858324e-01f, -1.17469415e-01f, -1.05447821e-01f, -1.14701584e-01f, -1.67055011e-01f, -1.09188795e-01f,
  6.19528908e-03f, -7.45441541e-02f, -9.15341303e-02f, -2.82548875e-01f, -1.17253631e-01f, -1.04217790e-01f, -1.22707181e-01f, -9.58178863e-02f, -1.91032678e-01f, -5.91901597e-03f,
  1.77973777e-01f, 6.07490651e-02f, 5.72129413e-02f, 1.26199992e-02f, -8.07973463e-03f, 2.10231561e-02f, -2.09781118e-02f, -9.08965170e-02f, 1.66548714e-02f, -8.40304047e-02f,
  -7.97525197e-02f, -1.11842282e-01f, -8.24956745e-02f, -9.93398726e-02f, -3.04024946e-02f, -3.01029682e-02f, -6.89743534e-02f, -1.07805125e-01f, 1.02821076e-02f, -1.10905163e-01f,
  3.71177383e-02f, 6.75948337e-02f, -9.83147770e-02f, 2.00705286e-02f, 8.30664635e-02f, -2.85540149e-02f, -5.57837822e-02f, -1.77726168e-02f, 8.94714426e-03f, -7.41547765e-03f,
  -7.10263401e-02f, -2.65846908e-01f, -1.36622280e-01f, -1.59950674e-01f, -1.33811757e-01f, -1.31614521e-01f, -1.97896749e-01f, -1.50132731e-01f, -1.58817858e-01f, -2.02192768e-01f,
  -1.82180539e-01f, -1.21969946e-01f, -1.55436590e-01f, -8.16385448e-02f, -4.11673896e-02f, -8.35778341e-02f, -1.63280249e-01f, -3.31268422e-02f, -1.76638395e-01f, -2.12963179e-01f,
  -2.05654591e-01f, -2.14762241e-01f, -3.15681323e-02f, -1.69959426e-01f, -1.41406357e-01f, -1.39610171e-01f, -1.77326098e-01f, -9.16461200e-02f, -2.32357010e-01f, -2.39477962e-01f,
  -7.90192842e-01f, 2.33681396e-01f, -1.82437105e-03f, -4.21428420e-02f, 3.17265958e-01f, 2.63393577e-02f, -4.38669808e-02f, -4.06598747e-02f, 7.07371980e-02f, 1.03705980e-01f,
  -1.15140557e-01f, 1.31353354e-02f, -9.09859687e-02f, 8.39196332e-03f, -2.52893299e-01f, 1.15725420e-01f, 1.78011671e-01f, -1.43667996e-01f, -3.43265593e-01f, 3.41416262e-02f,
  1.90080300e-01f, -1.31145075e-01f, -3.04627448e-01f, -4.43314351e-02f, 2.21676454e-01f, 6.96391910e-02f, 1.22388721e-01f, -7.90605396e-02f, -2.80959625e-02f, 2.60507554e-01f,
  -1.13712467e-01f, -1.52095705e-01f, -1.19406022e-02f, -2.75973398e-02f, -2.97641587e-02f, -3.00171990e-02f, -3.06181442e-02f, -4.67140861e-02f, -4.42535430e-02f, -4.86825705e-02f,
  -3.95922214e-02f, 7.36029446e-02f, -7.37770870e-02f, 8.40399861e-02f, -2.20600404e-02f, -5.82151935e-02f, 3.23248357e-02f, -1.87079906e-01f, -1.55463085e-01f, -4.56561074e-02f,
  1.40285358e-01f, 4.55064476e-02f, -1.18779331e-01f, -1.15247086e-01f, -9.31693688e-02f, -6.15148544e-02f, -4.40406166e-02f, 7.98992440e-03f, -9.92917866e-02f, 9.73574668e-02f,
  4.32077833e-02f, -4.54760268e-02f, -3.62371132e-02f, -6.26969617e-03f, 6.30178973e-02f, -3.43874805e-02f, 4.25910428e-02f, 1.68943666e-02f, -3.96568887e-02f, 5.09707117e-03f,
  5.03959134e-02f, -3.47834341e-02f, 1.16878366e-02f, -3.26507539e-02f, 1.38184838e-02f, 5.72615024e-03f, -7.07180426e-02f, 1.49248941e-02f, -6.51653633e-02f, -5.71068469e-03f,
  4.21930514e-02f, -2.19050739e-02f, 4.65432070e-02f, 2.81501617e-02f, 8.87916461e-02f, -2.88221724e-02f, 1.14448026e-01f, 2.59698145e-02f, 4.53563500e-03f, 4.87175435e-02f,
  -7.40056578e-03f, -1.53177217e-01f, -4.10808772e-02f, 4.94898409e-02f, 7.11737014e-03f, 7.79501721e-02f, 2.41786093e-02f, -3.22203040e-02f, -2.26237960e-02f, -7.00943768e-02f,
  3.34878117e-02f, -6.65792599e-02f, 4.19943929e-02f, -3.80398072e-02f, 5.94980735e-03f, 2.79119294e-02f, 2.09842008e-02f, -7.19872937e-02f, -3.90970148e-02f, -8.67705513e-03f,
  5.13134636e-02f, -6.15731068e-02f, -5.48577458e-02f, 8.33914056e-02f, -3.11722271e-02f, -1.31784547e-02f, 7.27645215e-03f, -2.09947154e-02f, -7.82154053e-02f, 1.21783726e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.07057285e-01f, -1.54132068e-01f, 3.24736953e-01f, 2.09739078e-02f, 2.19062179e-01f, -2.16188848e-01f, -5.26684940e-01f, -3.20155859e-01f, -1.86680481e-01f, -1.21399686e-01f,
  3.38907577e-02f, 5.14205210e-02f, 7.22610205e-03f, 8.97089541e-02f, -2.06910938e-01f, 4.37226659e-03f, 1.98789731e-01f, 7.98767060e-02f, 4.29811887e-02f, -2.00947858e-02f,
  5.29048778e-02f, -8.83211792e-02f, 1.22923180e-01f, -3.08661703e-02f, -7.32445121e-02f, -7.06480742e-02f, 8.08454379e-02f, 9.30551440e-02f, 3.02473865e-02f, 2.30431408e-02f,
  2.39706308e-01f, -9.19270813e-02f, 2.19690278e-01f, 1.57712966e-01f, 7.83531144e-02f, -1.37837559e-01f, -1.87262505e-01f, 1.25823051e-01f, -2.32023261e-02f, 7.83142224e-02f,
  3.17640454e-01f, -2.97907591e-02f, -8.85097161e-02f, 1.06758289e-02f, -4.18023467e-02f, -6.78390488e-02f, 1.32727608e-01f, 1.06417034e-02f, -5.34517365e-03f, -6.01838715e-02f,
  -4.43373211e-02f, 2.44434506e-01f, 8.37990865e-02f, 7.55484924e-02f, -1.77420214e-01f, 1.09420806e-01f, -3.92839052e-02f, -4.84661721e-02f, -1.17699802e-01f, -4.20752913e-01f,
  2.82787774e-02f, 1.84959974e-02f, 9.65481997e-03f, -6.67325035e-02f, -1.13298647e-01f, 1.24959633e-01f, 6.59929076e-03f, -8.80843103e-02f, -7.66734481e-02f, 1.77267659e-02f,
  -2.47732088e-01f, 1.64061505e-02f, 4.70645446e-03f, -1.90288685e-02f, -1.14220893e-02f, 1.12511963e-01f, -3.01704723e-02f, -7.94083700e-02f, -1.01956232e-02f, 3.29393893e-02f,
  -9.23126414e-02f, 1.78970546e-01f, 7.81087531e-03f, 1.06853042e-02f, 6.18027300e-02f, 1.28913626e-01f, 1.00469179e-01f, -5.11180349e-02f, 6.41576648e-02f, 3.50782275e-02f,
  -1.72943279e-01f, 3.52473110e-01f, -1.29147038e-01f, -4.35590483e-02f, -2.46135294e-02f, 1.71805382e-01f, -2.88742762e-02f, 9.84665304e-02f, 3.66410539e-02f, -1.52759120e-01f,
  -2.69058030e-02f, -1.71746597e-01f, -7.25893630e-03f, 6.53020889e-02f, -2.75155097e-01f, 3.10709886e-02f, 9.43901890e-04f, -7.35039562e-02f, -2.90580168e-02f, 3.09043340e-02f,
  -1.51189342e-01f, -2.14520290e-01f, -3.44654024e-01f, -2.53410995e-01f, -2.42392004e-01f, -4.17849243e-01f, -1.96134850e-01f, -2.01017991e-01f, -3.16234469e-01f, -6.00759447e-01f,
  6.18282437e-01f, 1.94765389e-01f, 2.20944777e-01f, 4.19332504e-01f, 2.37700805e-01f, 4.12533462e-01f, 4.87386286e-01f, 3.02741379e-01f, 1.57071620e-01f, 1.94536954e-01f,
  2.30378076e-01f, -2.27398276e-02f, 3.59681388e-03f, -2.37991195e-02f, 7.43297487e-02f, 8.82890914e-03f, -1.71547279e-01f, -6.70327991e-02f, 1.07425340e-01f, 2.04909697e-01f,
  -1.23424716e-02f, -4.43681628e-02f, 4.43726815e-02f, -1.08415112e-02f, -1.33541092e-01f, 7.04809055e-02f, 1.33070871e-01f, -2.39395481e-02f, -1.77018270e-02f, -4.13268089e-01f,
  -2.01954857e-01f, 3.43925178e-01f, -2.96130851e-02f, -5.85299395e-02f, 8.76314864e-02f, 5.62293902e-02f, 4.02070172e-02f, -1.02621287e-01f, -2.09491029e-02f, -4.57958430e-02f,
  -1.21122643e-01f, -2.79484279e-02f, 6.92711323e-02f, 4.29166369e-02f, -1.50097879e-02f, -1.96566712e-02f, -4.53904010e-02f, -7.56645724e-02f, -2.19916552e-02f, 7.30923861e-02f,
  1.93166155e-02f, 2.15240847e-02f, 3.70528623e-02f, -5.66219096e-04f, 2.07365770e-02f, -7.65490532e-02f, 5.67267276e-02f, 6.66204691e-02f, 5.64137921e-02f, -8.65753442e-02f,
  -3.78177059e-03f, -4.31460328e-02f, 1.20553203e-01f, 4.16731238e-02f, 5.66252880e-02f, 6.86800852e-02f, -1.01381605e-02f, -8.63158777e-02f, 1.25416100e-01f, 3.20969149e-03f,
  -3.61358821e-02f, -1.81141831e-02f, -5.80028743e-02f, 3.01168580e-02f, 7.04335272e-02f, 5.42201065e-02f, -9.45863426e-02f, -1.40059888e-02f, -5.72192259e-02f, 5.10131754e-03f,
  1.01202801e-01f, -1.02785397e-02f, 8.37541819e-02f, 5.32723963e-02f, 9.77753177e-02f, 2.47991942e-02f, -3.64721715e-02f, 1.27805516e-01f, 2.61997841e-02f, -8.56687948e-02f,
  -2.46130288e-01f, 3.35105836e-01f, -9.21267197e-02f, -1.91850856e-01f, -9.42134410e-02f, -4.93884124e-02f, 1.52180314e-01f, -8.94781053e-02f, -2.68069685e-01f, -3.72227430e-02f,
  2.53042486e-02f, -1.83566231e-02f, 3.92972194e-02f, 9.97825414e-02f, -2.24997476e-03f, -1.53436974e-01f, -2.94581875e-02f, -6.10680506e-02f, -5.61337247e-02f, -2.46796295e-01f,
  -1.18657418e-01f, 3.55492420e-02f, 4.73568216e-02f, -2.94991955e-02f, -2.87817717e-01f, 2.27772593e-02f, -9.39135402e-02f, -4.10051942e-02f, 1.59611255e-01f, 6.05602935e-02f,
  1.28799558e-01f, -5.63309193e-01f, 2.91788220e-01f, 3.26788366e-01f, 4.21101987e-01f, 4.14043188e-01f, 3.46138835e-01f, 1.21193893e-01f, 1.70302004e-01f, -1.01619251e-01f,
  -1.70507774e-01f, -1.56018332e-01f, -1.92861617e-01f, -1.79544866e-01f, -1.18496053e-01f, 1.67888179e-01f, 3.83785158e-01f, 1.44731596e-01f, 3.32432061e-01f, 2.03864202e-01f,
  -4.31368425e-02f, 5.16955703e-02f, -1.30685776e-01f, 7.56072178e-02f, -5.10822944e-02f, 1.78195089e-01f, 1.03772499e-01f, -8.94346312e-02f, -8.31821859e-02f, -4.68726456e-02f,
  -3.00371051e-01f, -2.46611878e-01f, 2.34699205e-01f, -6.03832006e-02f, -1.12138726e-01f, -7.90478066e-02f, -1.39052728e-02f, -2.46843472e-02f, -9.97359492e-03f, 1.12934850e-01f,
  -8.41309428e-02f, -2.98528783e-02f, -3.00632976e-02f, -7.87212849e-02f, 1.56693868e-02f, 1.85857303e-02f, -8.73346552e-02f, 5.05402312e-03f, 5.20469770e-02f, -1.02258407e-01f,
  -1.39290750e-01f, 4.09555919e-02f, -5.26182093e-02f, 1.60246059e-01f, 1.03316411e-01f, 1.24899268e-01f, 1.11557849e-01f, -6.07040152e-02f, 5.66488393e-02f, 3.35921273e-02f,
  1.28110945e-01f, 5.56716062e-02f, -7.96953887e-02f, -5.04789688e-02f, -2.19496731e-02f, 1.35407047e-02f, 8.87033790e-02f, 8.03122669e-02f, 1.28042400e-01f, 3.83056030e-02f,
  -7.68833682e-02f, 5.72506338e-02f, -4.40423004e-02f, 8.44494440e-03f, -4.10293415e-02f, -1.00246906e-01f, -1.80678144e-02f, -7.74250478e-02f, -6.95436588e-03f, -1.10209063e-01f,
  5.74161997e-03f, 1.31119907e-01f, -5.14117777e-02f, -1.40183479e-01f, -3.88249978e-02f, -2.27655824e-02f, -1.00862402e-02f, -1.18582034e-02f, -2.03651916e-02f, -4.30634618e-03f,
  -3.72544020e-01f, -5.46751842e-02f, 2.41961214e-03f, -9.93326120e-03f, 3.28387902e-03f, -1.18038125e-01f, -3.35836969e-03f, -1.00662179e-01f, 6.65784255e-02f, 4.86669466e-02f,
  -8.65849108e-03f, -2.01687850e-02f, -1.46277100e-01f, -9.63344723e-02f, 2.09809735e-01f, 7.66224712e-02f, -2.16241077e-01f, -3.02487276e-02f, 3.65940668e-03f, 1.75454915e-02f,
  -1.12485215e-01f, 1.42810881e-01f, 1.60957962e-01f, 1.03265032e-01f, 3.44839171e-02f, 1.08421877e-01f, 2.10443027e-02f, 6.03028573e-03f, 5.03133163e-02f, 1.65601864e-01f,
  1.79667383e-01f, -1.87649503e-02f, -4.22927141e-01f, 2.99003929e-01f, -1.42542675e-01f, -1.95841208e-01f, -2.08711103e-01f, 1.89795136e-01f, 3.71130854e-01f, -1.20778717e-01f,
  -6.79017156e-02f, 2.00522572e-01f, -7.81976059e-02f, -7.61658698e-02f, 6.44509643e-02f, -2.16983438e-01f, -2.53436387e-01f, -1.30591646e-01f, 1.24364235e-02f, 1.72637906e-02f,
  5.88230491e-02f, 2.08993331e-01f, 2.65038550e-01f, 2.17993051e-01f, -4.46842946e-02f, 7.04835821e-03f, -2.95542479e-01f, -5.68461753e-02f, -4.04245466e-01f, -5.94908893e-01f,
  -4.73643273e-01f, -2.07548067e-01f, 1.05379269e-01f, 1.52904885e-02f, 1.42169883e-02f, 1.58115044e-01f, 8.56781080e-02f, 1.94519073e-01f, 2.40590289e-01f, 9.39306542e-02f,
  3.58950086e-02f, 1.54767051e-01f, 1.35380849e-02f, -2.42070444e-02f, 1.05542652e-01f, 5.80309741e-02f, 2.12908015e-01f, 3.77361523e-03f, -4.49628234e-02f, -5.00657707e-02f,
  2.82709040e-02f, 4.28479314e-02f, -1.16133183e-01f, 1.10187083e-01f, -5.88957332e-02f, 2.28278209e-02f, -7.67441168e-02f, -1.19232714e-01f, -2.17776552e-01f, -2.12305099e-01f,
  5.56350909e-02f, -4.83099185e-03f, -3.60430703e-02f, 4.67912331e-02f, 1.32311910e-01f, -6.88589504e-03f, -1.25905022e-01f, 6.84690177e-02f, 2.22478751e-02f, 6.50243759e-02f,
  5.24628125e-02f, -6.53240681e-02f, 1.47160413e-02f, -3.49769630e-02f, 6.49168994e-03f, 4.04660171e-03f, -3.97969224e-02f, -1.47571051e-02f, 7.47549674e-03f, 2.61704251e-02f,
  -4.04769517e-02f, -3.96021791e-02f, -5.29422872e-02f, -4.81204093e-02f, -7.85019994e-02f, -7.53268674e-02f, -4.82218191e-02f, 1.32922381e-02f, 5.72671629e-02f, -1.58012509e-02f,
  2.98077375e-01f, -2.69352615e-01f, -1.40860856e-01f, -9.04581696e-02f, -7.79655725e-02f, 6.74895719e-02f, -8.61278698e-02f, 9.74915028e-02f, 9.67022032e-03f, -7.23998770e-02f,
  -1.20708935e-01f, -1.49404006e-02f, -1.20978959e-01f, -2.23830827e-02f, 2.44016200e-03f, -1.10139415e-01f, 1.21711241e-03f, -1.98232085e-01f, -8.79345536e-02f, 1.24597125e-01f,
  1.19897343e-01f, 7.87541121e-02f, 1.32855043e-01f, -4.16319519e-02f, -6.89740330e-02f, 1.71932168e-02f, -4.92515787e-02f, -1.60598215e-02f, -9.33685452e-02f, 8.64959508e-02f,
  4.53734219e-01f, -2.11391866e-01f, -2.10797012e-01f, 1.27574816e-01f, -3.48402023e-01f, -4.29222375e-01f, -5.44671237e-01f, -1.16094366e-01f, -9.21344105e-03f, -2.72875398e-01f,
  -9.26744286e-03f, 6.37580931e-01f, 5.45023441e-01f, 3.08449209e-01f, 2.62679458e-01f, -3.47782344e-01f, -2.94280112e-01f, 1.67063057e-01f, 1.38295963e-01f, -1.16952725e-01f,
  -1.90284893e-01f, -8.69200826e-02f, 1.63213015e-01f, 9.83216763e-02f, -2.25960746e-01f, 1.34445921e-01f, -3.10603976e-01f, -1.50303051e-01f, -1.14009835e-01f, -2.18747213e-01f,
  8.41376632e-02f, 2.30601113e-02f, -1.80838946e-02f, -2.63380036e-02f, -5.63554242e-02f, 8.52776170e-02f, 4.75683510e-02f, 3.38333584e-02f, -4.75461707e-02f, 2.17449926e-02f,
  1.74844399e-01f, -7.66934156e-02f, 1.43085033e-01f, 1.22961752e-01f, -1.17024533e-01f, -6.40664101e-02f, -1.06828343e-02f, -1.13870628e-01f, -1.15446165e-01f, -1.27554042e-02f,
  4.20085602e-02f, -1.05469925e-02f, 5.29837701e-03f, -3.85972708e-01f, -9.17215124e-02f, 4.78498414e-02f, -3.46790910e-01f, -1.96388602e-01f, -3.04595083e-01f, -2.34205708e-01f,
  3.78048010e-02f, -2.43217554e-02f, -9.91354510e-03f, 4.99463752e-02f, -1.64068509e-02f, 1.06319137e-01f, 4.11175713e-02f, -6.48262128e-02f, -2.41273809e-02f, 1.80344917e-02f,
  2.48508286e-02f, -9.54725370e-02f, -2.71230899e-02f, -3.55439372e-02f, -1.08339585e-01f, -3.61116305e-02f, -7.70431338e-03f, -6.02750331e-02f, -4.29994985e-02f, -3.21292989e-02f,
  1.51841883e-02f, 2.63076928e-02f, -9.84912086e-03f, 2.67150141e-02f, -1.38777951e-02f, 9.34625342e-02f, 2.61667259e-02f, -3.18346806e-02f, 9.88728404e-02f, -5.88922948e-03f,
  2.74534702e-01f, 3.49439792e-02f, 1.17260419e-01f, 1.39999494e-01f, 1.94074083e-02f, -5.32318056e-02f, 4.67565134e-02f, -1.30658209e-01f, 8.23126510e-02f, -6.62148893e-02f,
  -1.24462850e-01f, 1.62422955e-02f, 1.44068506e-02f, -7.28477016e-02f, -3.41881104e-02f, 2.29879245e-02f, -4.01478931e-02f, 1.83032811e-01f, -5.31547032e-02f, -1.15726896e-01f,
  -5.06960973e-02f, 9.22131166e-03f, 1.85736924e-01f, -1.32337874e-02f, 4.68536392e-02f, 2.45464563e-01f, -8.22006352e-03f, 1.28423214e-01f, 1.53684795e-01f, -1.02790110e-01f,
  -6.16443217e-01f, 3.31304632e-02f, -3.12753350e-01f, 2.43809387e-01f, 1.85905486e-01f, 1.23124927e-01f, 7.97436312e-02f, 1.68398842e-01f, 2.08260179e-01f, 2.49155745e-01f,
  1.91614166e-01f, 3.97086322e-01f, 3.28712463e-01f, 3.01693499e-01f, 8.78868997e-02f, 3.17624658e-01f, 2.59377927e-01f, -1.28280848e-01f, -1.17582254e-01f, 2.00860545e-01f,
  3.26295078e-01f, -4.13261876e-02f, -2.20170617e-01f, -3.07128318e-02f, 9.11065377e-03f, 2.78701723e-01f, 4.17776629e-02f, -1.50969729e-01f, 2.01787427e-02f, 3.24782252e-01f,
  5.34345247e-02f, -3.50122720e-01f, 2.44301200e-01f, -5.23726875e-03f, -9.68554318e-02f, -7.23930299e-02f, 2.48137880e-02f, -1.20056570e-01f, -8.72510597e-02f, 2.71599926e-02f,
  7.56452233e-02f, -1.97552696e-01f, -5.05041778e-02f, -6.51423931e-02f, -2.03166813e-01f, -2.11276710e-01f, -1.78874046e-01f, 1.60352290e-02f, 8.68373513e-02f, 1.99750457e-02f,
  2.15761676e-01f, -8.47114064e-03f, -1.44365087e-01f, 1.62303373e-01f, 1.39858052e-01f, 7.26223066e-02f, -4.18930911e-02f, -5.75078875e-02f, 1.49251660e-02f, -1.03419954e-02f,
  1.93971410e-01f, 1.53678149e-01f, -1.19768523e-01f, 1.89910848e-02f, -9.07263951e-04f, 7.26342052e-02f, 7.42378831e-02f, -1.04186796e-02f, 9.61926505e-02f, -2.63944745e-01f,
  -6.51355758e-02f, 1.06240064e-01f, 1.50428876e-01f, 1.66112706e-01f, 1.46734148e-01f, -6.54056370e-02f, -1.34083098e-02f, 1.11391909e-01f, -6.66476181e-03f, -1.22940041e-01f,
  -5.29119074e-02f, -1.25214877e-02f, -1.33036777e-01f, 6.81594685e-02f, -7.65206143e-02f, -1.21936388e-03f, -1.67927425e-02f, -1.95842353e-03f, -1.25827687e-02f, -8.74296948e-02f,
  3.18649888e-01f, 1.02664642e-02f, 1.11843392e-01f, -7.73747079e-03f, -4.51046266e-02f, -1.17383890e-01f, 9.18754637e-02f, 4.08244407e-04f, -2.10958458e-02f, 8.93633813e-02f,
  -1.01435311e-01f, -1.23294005e-02f, -5.40873148e-02f, -2.46085241e-01f, -1.54947907e-01f, -3.45690362e-02f, -7.15662166e-02f, 1.74255744e-01f, 1.45830333e-01f, 5.51340319e-02f,
  -9.48336273e-02f, 1.34520620e-01f, 7.42992237e-02f, 5.89182489e-02f, 1.50160670e-01f, 3.75870951e-02f, -1.50406957e-01f, -5.05800322e-02f, -2.27046944e-02f, -1.58784375e-01f,
  2.58240998e-01f, -2.74400711e-01f, -4.50456202e-01f, 3.25053811e-01f, -1.93804860e-01f, -5.69470376e-02f, -1.64239898e-01f, 1.67721838e-01f, 3.61612529e-01f, -1.80238560e-01f,
  -3.05988431e-01f, -2.90211570e-02f, -1.62531078e-01f, -1.27546579e-01f, 5.87795451e-02f, -1.54495448e-01f, -2.14144960e-01f, -9.90365297e-02f, 1.68447554e-01f, 2.79276282e-01f,
  2.47113898e-01f, 2.88054645e-01f, 3.39448005e-01f, 3.06634337e-01f, -1.25918105e-01f, -7.07902089e-02f, -2.23774329e-01f, -1.05968736e-01f, -1.57631859e-01f, -4.50441629e-01f,
  -4.98986930e-01f, -8.04552957e-02f, 4.03260952e-03f, 5.63784167e-02f, -1.87497988e-01f, 1.47465887e-02f, -1.06949978e-01f, -1.17409877e-01f, -1.91258550e-01f, -4.78514507e-02f,
  -1.87728852e-02f, 3.75011563e-02f, -4.95034046e-02f, 7.57838190e-02f, -5.38910218e-02f, -2.49856357e-02f, 8.97270814e-03f, -3.46950851e-02f, -1.97733700e-01f, -1.39071435e-01f,
  -9.86864716e-02f, -1.55237392e-01f, -2.27947116e-01f, -9.46413279e-02f, -1.42000034e-01f, 3.75493504e-02f, -1.14064924e-01f, -1.50769919e-01f, -1.06174842e-01f, -1.39009371e-01f,
  4.65327379e-04f, -1.55137137e-01f, 6.39965013e-02f, -3.97812836e-02f, 4.80105653e-02f, 3.62040326e-02f, -1.03489906e-01f, 9.59719792e-02f, -3.08085289e-02f, -2.70666536e-02f,
  5.98671883e-02f, -4.93166707e-02f, 6.42750785e-02f, -5.69713078e-02f, 1.17913395e-01f, -6.11036904e-02f, 7.11649843e-03f, 6.87871128e-02f, -3.35530788e-02f, 8.42778534e-02f,
  5.48164658e-02f, 3.43167260e-02f, 3.69326472e-02f, 3.88712399e-02f, 2.19341870e-02f, -4.13075164e-02f, 9.73669067e-02f, 2.40149554e-02f, 5.48996888e-02f, -2.64791343e-02f,
  1.67157084e-01f, -3.32786739e-02f, -9.01114717e-02f, 2.23621372e-02f, 1.31011352e-01f, -1.54773012e-01f, -3.28499340e-02f, 5.25584556e-02f, 7.31326118e-02f, -1.48592833e-02f,
  7.77080357e-02f, 8.88497904e-02f, 2.34240685e-02f, -7.47683719e-02f, 4.17132452e-02f, 1.44750595e-01f, -1.65977143e-02f, 1.43657587e-02f, 9.13371518e-02f, 6.93787932e-02f,
  -2.01361980e-02f, 1.10281356e-01f, 8.17176253e-02f, 7.35283121e-02f, 8.37569013e-02f, 9.40366015e-02f, -2.25295853e-02f, 5.86250089e-02f, 7.03519434e-02f, 1.66543618e-01f,
  -4.93640304e-01f, -3.58102210e-02f, -2.72391230e-01f, -4.88181323e-01f, -3.43387187e-01f, -1.36343017e-01f, -1.00440092e-01f, -9.57844313e-03f, -2.46060222e-01f, -3.38255614e-01f,
  9.65100527e-02f, 3.19799483e-01f, 2.11046949e-01f, 2.59254754e-01f, 2.19977632e-01f, -3.26395810e-01f, -4.89265084e-01f, 1.81315877e-02f, 3.29647541e-01f, 1.83167592e-01f,
  3.70793380e-02f, -2.25985330e-02f, -6.52042106e-02f, 8.25168341e-02f, 2.76692025e-02f, 2.70019531e-01f, -2.02942908e-01f, 7.98067451e-02f, 1.82373270e-01f, -7.28137791e-02f,
  3.26759696e-01f, -2.66860694e-01f, 4.26749513e-02f, -9.09561440e-02f, -2.11943164e-02f, -4.41975929e-02f, -1.67793930e-02f, -4.13252190e-02f, -3.83606926e-02f, -7.97651038e-02f,
  -7.66757876e-02f, 3.69807445e-02f, -3.14283967e-02f, 6.21656552e-02f, -3.97888124e-02f, 6.51432052e-02f, -1.09425694e-01f, -1.54310599e-01f, -7.33965263e-02f, 2.97479481e-02f,
  -3.32054961e-03f, -2.70490468e-01f, 1.36896670e-02f, 1.37824878e-01f, -4.32011951e-03f, -7.46573508e-02f, 1.95736825e-01f, 1.23889104e-01f, 9.32219550e-02f, 4.27228585e-02f,
  -9.49926153e-02f, 1.21885300e-01f, -5.21509759e-02f, 1.57754589e-02f, -7.15831369e-02f, -1.37597811e-03f, 7.95755070e-03f, 2.17548255e-02f, 5.44956289e-02f, 1.18740566e-01f,
  -2.20943727e-02f, -1.34881601e-01f, 2.69443747e-02f, -1.10657901e-01f, 8.37614834e-02f, -7.03833178e-02f, 8.34093988e-02f, 4.84423414e-02f, 1.07992655e-02f, -4.30701859e-02f,
  2.44191419e-02f, -9.30062495e-03f, 6.74413666e-02f, 1.70680717e-01f, -1.45132154e-01f, -9.47793722e-02f, 2.35015191e-02f, 1.41051993e-01f, -1.06837330e-02f, -1.31213352e-01f,
  1.04868345e-01f, -1.47735566e-01f, -5.33211492e-02f, 7.11568221e-02f, -5.04268445e-02f, -1.49726242e-01f, -1.93815231e-01f, -1.15726158e-01f, 8.04839656e-03f, 1.21662721e-01f,
  -2.16540359e-02f, 6.04641736e-02f, -8.51338580e-02f, -3.72869298e-02f, 7.93323964e-02f, -3.19698341e-02f, -8.89380723e-02f, 5.54760024e-02f, -5.85353654e-03f, -1.57411337e-01f,
  -9.06846374e-02f, -2.03187704e-01f, 3.99840437e-03f, 2.26679936e-01f, 3.98461856e-02f, -5.45201898e-02f, 2.16258854e-01f, 1.40441796e-02f, 9.12560597e-02f, 6.70512840e-02f,
  -6.15130186e-01f, 3.71663831e-02f, -2.39981100e-01f, -3.59163821e-01f, 8.59904066e-02f, 8.43806267e-02f, -1.11241199e-01f, 5.99044096e-03f, -1.57487895e-02f, -2.17417702e-02f,
  8.02705064e-02f, 1.46260515e-01f, -2.11632743e-01f, 3.83832455e-02f, -6.05832696e-01f, -5.40911019e-01f, -6.10920250e-01f, -5.87000549e-01f, -1.59207225e-01f, 3.35249126e-01f,
  1.53294057e-01f, -1.93288535e-01f, -2.50343591e-01f, -8.44369680e-02f, 6.85065463e-02f, 4.07865606e-02f, -1.26609772e-01f, -4.52182703e-02f, 1.74687997e-01f, -9.26300734e-02f,
  3.68077331e-03f, 3.73353750e-01f, -1.33358225e-01f, -2.08718091e-01f, 5.79748526e-02f, 3.43442857e-02f, 1.17797218e-01f, -1.43693343e-01f, 7.78883249e-02f, -1.64205000e-01f,
  -1.12850681e-01f, 2.17461154e-01f, 2.97596082e-02f, 1.27473533e-01f, -1.63488671e-01f, 2.37691086e-02f, -2.50396729e-01f, 5.04125003e-03f, -2.15087414e-01f, 5.05896024e-02f,
  3.93042304e-02f, -2.90423241e-02f, -2.45522112e-01f, 9.84080881e-02f, -5.85963205e-03f, 1.50384810e-02f, 9.26752388e-02f, 9.62537974e-02f, 8.04366246e-02f, -6.16582558e-02f,
  2.02974789e-02f, -8.58185515e-02f, 9.41153150e-03f, -3.29553336e-02f, -4.73517515e-02f, 1.35058295e-02f, -9.13557112e-02f, -9.25662220e-02f, 8.49399269e-02f, 6.06333800e-02f,
  6.76098093e-02f, -4.97274362e-02f, 2.78218482e-02f, -1.29320314e-02f, -7.43915560e-03f, -5.66154085e-02f, -1.37423091e-02f, -1.20563470e-01f, -5.59464172e-02f, 5.94414510e-02f,
  7.61952624e-02f, 1.16440356e-01f, 2.86087603e-03f, 5.15076742e-02f, -6.66567385e-02f, -4.65287045e-02f, 7.53864497e-02f, 3.48135345e-02f, 1.29984409e-01f, 7.39452466e-02f,
  -2.73894101e-01f, 2.35918220e-02f, -2.25511149e-01f, 7.08202794e-02f, -1.41963491e-03f, -8.94744471e-02f, -3.64344530e-02f, -1.17328219e-01f, 1.64411411e-01f, 1.47639820e-02f,
  -1.58904605e-02f, 7.61237834e-03f, 2.52534188e-02f, -9.51874852e-02f, -3.54063101e-02f, 1.70244258e-02f, -1.73133239e-01f, -1.18703805e-01f, -1.37260351e-02f, 5.44555373e-02f,
  -1.72786772e-01f, -3.19783419e-01f, -2.56660879e-01f, -1.48105592e-01f, 1.83524638e-01f, -1.52337477e-01f, -2.15950429e-01f, -3.49371023e-02f, -2.13384151e-01f, -4.32174504e-01f,
  4.12586898e-01f, -6.46235764e-01f, -3.49628210e-01f, -1.26446029e-02f, -4.81305085e-02f, 1.12822019e-01f, -5.74603193e-02f, 5.88413104e-02f, 1.97622612e-01f, -1.12963803e-02f,
  4.95943651e-02f, 2.99780041e-01f, 1.78124696e-01f, 4.57885154e-02f, 1.88668892e-01f, -3.67095947e-01f, -2.70987064e-01f, -4.79648355e-03f, 3.15335095e-01f, 3.40228409e-01f,
  1.38581514e-01f, -1.50307193e-01f, -6.64457679e-02f, 6.62332121e-03f, -2.60816574e-01f, 1.82690320e-03f, -3.27800274e-01f, -3.63671184e-01f, -1.62128672e-01f, -5.90922534e-01f,
  -1.11251578e-01f, 2.79067736e-02f, 1.92363635e-01f, 1.45947531e-01f, -1.34803578e-01f, 8.50946978e-02f, 4.57010679e-02f, -2.64828429e-02f, 1.71010345e-01f, -6.95032394e-03f,
  3.65768187e-02f, -4.31401394e-02f, -1.74974762e-02f, 1.02883965e-01f, 3.75031754e-02f, 1.40075892e-01f, 7.46740550e-02f, 1.13739572e-01f, 6.57778010e-02f, -2.98187509e-02f,
  5.88836260e-02f, 1.07889935e-01f, 1.34509519e-01f, 1.60638049e-01f, 5.21032922e-02f, 1.41500667e-01f, -4.46972810e-02f, -3.15899886e-02f, 8.89199898e-02f, -6.05503134e-02f,
  -1.13429412e-01f, 8.19251500e-03f, 1.40798122e-01f, 7.31016919e-02f, 2.24541780e-02f, 6.16240241e-02f, 3.68403532e-02f, 1.19730368e-01f, 4.31250893e-02f, -2.26368368e-01f,
  1.63743168e-03f, 3.25771496e-02f, 1.13133853e-02f, -3.16836163e-02f, -4.20202017e-02f, 5.95042519e-02f, 1.11794834e-04f, -1.44086953e-03f, 6.79636076e-02f, -1.38610955e-02f,
  3.07423025e-02f, 6.26699850e-02f, -3.69462334e-02f, 1.70832034e-02f, -3.40785794e-02f, 8.28636289e-02f, 7.09278360e-02f, -1.37456777e-02f, 1.99556816e-02f, -1.34967510e-02f,
  -2.24927872e-01f, 8.15879181e-02f, -6.19889703e-03f, -1.20338105e-01f, -2.19194926e-02f, 3.30878352e-03f, -1.23889737e-01f, 1.04775010e-02f, 1.95720177e-02f, 3.01828422e-02f,
  1.10501304e-01f, -3.26656960e-02f, -1.75740048e-01f, -1.39783189e-01f, -4.24389802e-02f, 2.05197841e-01f, -1.00214936e-01f, 4.80780900e-02f, 7.64484480e-02f, 3.11478972e-03f,
  -8.29466060e-03f, 1.91016302e-01f, 1.90746099e-01f, 7.68154338e-02f, 6.00541160e-02f, 5.53808101e-02f, 2.70253811e-02f, 1.26624899e-02f, 9.94624719e-02f, 6.24184608e-02f,
  1.65815324e-01f, -7.92724118e-02f, -2.25906089e-01f, 1.19091198e-01f, 1.48699686e-01f, -1.48781031e-01f, -2.21859887e-01f, -1.87849537e-01f, 8.94148052e-02f, -3.61723453e-02f,
  3.64035256e-02f, 1.30947098e-01f, 1.34247631e-01f, 1.16391495e-01f, -7.26542771e-02f, 1.74663484e-01f, 1.62604064e-01f, 7.68652856e-02f, -2.54713565e-01f, -1.88801549e-02f,
  2.96678275e-01f, 7.34461918e-02f, -1.00158617e-01f, -9.28045958e-02f, 3.71553183e-01f, 3.57717648e-02f, -9.52024013e-02f, 6.96698204e-02f, 8.55044574e-02f, 7.27081001e-01f,
  2.63864957e-02f, -6.63026124e-02f, -8.99395347e-02f, 6.12993464e-02f, 9.86886695e-02f, 1.01925112e-01f, 6.88193142e-02f, 6.13766685e-02f, -9.56053734e-02f, -5.90961352e-02f,
  1.16989769e-01f, 7.83372670e-02f, -5.84465787e-02f, 9.02205929e-02f, -1.37670219e-01f, 1.27738714e-01f, -6.79186434e-02f, -1.12651117e-01f, -1.43072367e-01f, -1.30039349e-01f,
  2.83914924e-01f, 1.03897005e-01f, 8.24641213e-02f, -2.00538203e-01f, -2.29104728e-01f, -7.47537613e-02f, -1.39524370e-01f, -1.29442401e-02f, -2.05529734e-01f, 1.95951790e-01f,
  2.00400725e-02f, 1.54268872e-02f, -2.78013125e-02f, 1.01078808e-01f, 1.13316528e-01f, 2.47440133e-02f, 1.57840282e-01f, 4.22205999e-02f, -6.45846352e-02f, -2.36482583e-02f,
  -6.53775632e-02f, -6.33863732e-02f, 5.41724404e-03f, 4.26266622e-03f, -3.32404338e-02f, 6.54867962e-02f, 1.01059653e-01f, 9.82611552e-02f, -5.75049818e-02f, 7.74704069e-02f,
  -9.03859921e-03f, -1.86951999e-02f, 1.49694547e-01f, 3.71687599e-02f, 5.73336668e-02f, 3.64920087e-02f, 1.15101144e-01f, 1.56809613e-02f, 3.56333144e-02f, -5.24637662e-02f,
  -9.65832099e-02f, -1.09108627e-01f, 2.94071555e-01f, -3.65140177e-02f, 6.77120592e-03f, -9.17232409e-02f, 1.56157119e-02f, -4.51141894e-02f, 8.85389745e-02f, -6.97407499e-02f,
  -4.77746762e-02f, 6.42092153e-02f, 2.11543068e-02f, 5.43171391e-02f, -1.99506029e-01f, -1.13254420e-01f, 8.24849401e-03f, 1.62769656e-03f, -1.72339648e-01f, 2.46765427e-02f,
  1.27462491e-01f, -1.52572766e-01f, -1.40725136e-01f, -2.33985007e-01f, -5.79192191e-02f, 3.00380383e-02f, 5.31173795e-02f, -9.67485234e-02f, -2.24670216e-01f, -1.19057737e-01f,
  6.95456505e-01f, 5.19555986e-01f, 7.70356581e-02f, -2.69814972e-02f, -1.42250761e-01f, -5.31128757e-02f, 8.58572051e-02f, 5.31974249e-03f, -1.93246379e-01f, 8.10847729e-02f,
  1.41601965e-01f, 3.27684134e-02f, -5.34562543e-02f, 7.33957887e-02f, 9.19657797e-02f, -6.67276978e-02f, 1.04906308e-02f, 1.86378777e-01f, -1.64309949e-01f, 4.24415097e-02f,
  2.59917259e-01f, 2.03727454e-01f, 2.24928558e-01f, -2.04813443e-02f, 2.40518838e-01f, -8.07502940e-02f, -1.25405222e-01f, 1.13987945e-01f, 1.01042800e-01f, 5.93485177e-01f,
  4.46690768e-01f, 3.86713088e-01f, -3.14861119e-01f, 6.24648668e-02f, 1.58992395e-01f, 1.08831927e-01f, 6.12491183e-02f, 1.30722687e-01f, 1.38648860e-02f, 2.30448935e-02f,
  1.25709653e-01f, 1.88928202e-01f, -7.88552966e-03f, 5.47725596e-02f, 2.23122705e-02f, -4.36288491e-02f, 3.42771411e-02f, 1.31651476e-01f, 1.87031459e-02f, 1.12962857e-01f,
  1.99815899e-01f, 2.03339905e-01f, 7.83167779e-02f, -1.19376831e-01f, -4.87732235e-03f, -3.78753580e-02f, 1.45984022e-02f, 9.04056430e-02f, 2.23519970e-02f, 1.36003673e-01f,
  2.30633151e-02f, -4.29049088e-03f, -8.98825973e-02f, -3.47465351e-02f, -7.20394030e-02f, -1.12789571e-01f, -3.24609019e-02f, -6.52213097e-02f, -5.14796562e-02f, -7.32181445e-02f,
  -1.37739539e-01f, -1.48370877e-01f, 1.09671503e-01f, -4.66045141e-02f, 2.16874965e-02f, 1.21385880e-01f, 3.92754339e-02f, -2.27224641e-02f, -9.75657180e-02f, -7.43066669e-02f,
  -7.19634742e-02f, 6.34180456e-02f, 3.67752998e-03f, 1.15740798e-01f, 8.30191746e-02f, -4.28621620e-02f, 1.04687423e-01f, -6.29886612e-02f, 4.28263023e-02f, -7.86599815e-02f,
  -9.77206975e-02f, -4.81793940e-01f, -1.60965532e-01f, -2.29762564e-03f, 7.75775164e-02f, 2.36655455e-02f, -9.13852379e-02f, -8.14142600e-02f, 2.25045979e-02f, 7.34729245e-02f,
  3.15327831e-02f, 3.58394049e-02f, -1.43150777e-01f, -3.52067873e-02f, -2.07452908e-01f, -9.49288756e-02f, -1.01277325e-02f, -5.93191769e-04f, -5.71767166e-02f, 3.91635671e-02f,
  -5.53338006e-02f, -4.78931703e-02f, -1.16957471e-01f, -1.26361474e-01f, -9.38070118e-02f, -2.43434235e-01f, -1.38862982e-01f, -2.55091339e-02f, -1.39291421e-01f, -1.59785543e-02f,
  1.65989548e-01f, 8.96014348e-02f, -9.68093947e-02f, 1.73646316e-01f, 9.26818792e-03f, -6.23803120e-03f, 9.81113985e-02f, 2.06548333e-01f, 1.53985217e-01f, -2.97643244e-02f,
  -6.93746880e-02f, 1.35337427e-01f, 2.41177604e-01f, 2.27898806e-01f, 2.78508544e-01f, 2.37263158e-01f, 1.78782880e-01f, 2.19243363e-01f, 1.18514277e-01f, 1.14233010e-01f,
  3.74673083e-02f, -1.12021556e-02f, -1.08648367e-01f, 1.45870864e-01f, 2.05071121e-01f, -5.67968078e-02f, 1.94063946e-03f, -3.61536862e-03f, 5.37268817e-02f, 3.18947643e-01f,
  -1.08806327e-01f, 9.08720419e-02f, 1.98919717e-02f, -5.67965358e-02f, -1.30643845e-01f, -1.42332301e-01f, -1.10280372e-01f, 2.00800411e-02f, -7.00079352e-02f, -8.91464204e-02f,
  -1.72314301e-01f, -1.82476472e-02f, 9.37445387e-02f, -9.03367326e-02f, -1.24978542e-01f, -7.78535530e-02f, -4.43248563e-02f, 2.33552098e-01f, 1.32808119e-01f, -2.62803640e-02f,
  2.54476611e-02f, -4.23394032e-02f, -8.08710698e-03f, 1.24408938e-02f, 1.83965862e-01f, -7.14259073e-02f, 2.96609290e-02f, 2.54347771e-02f, 3.61884735e-03f, 5.53000346e-02f,
  7.34547079e-02f, 1.36701003e-01f, 2.11883839e-02f, 3.03088082e-03f, 6.87987357e-02f, 9.56514254e-02f, 7.84080550e-02f, 3.97891067e-02f, 1.90399930e-01f, -2.74391193e-02f,
  1.52553124e-02f, 7.14046881e-02f, 5.79638295e-02f, -7.82666951e-02f, 8.16600546e-02f, 3.80770303e-02f, -1.17519207e-01f, -1.27539309e-02f, -6.84289262e-02f, 6.74508661e-02f,
  3.33615281e-02f, 1.32154554e-01f, -4.43087555e-02f, 1.85143456e-01f, 3.15319039e-02f, 1.27232060e-01f, 2.65025962e-02f, -1.87375750e-02f, 6.78143725e-02f, 2.51095630e-02f,
  -3.79277974e-01f, 1.91261083e-01f, 1.92819998e-01f, 2.61372626e-01f, 2.72231773e-02f, -1.09099276e-01f, 1.53572425e-01f, -6.45001978e-02f, -1.54863626e-01f, -2.07854748e-01f,
  -2.00388536e-01f, -1.74252391e-02f, 7.39066228e-02f, 7.93927312e-02f, -1.16458550e-01f, -1.17491953e-01f, 1.37070594e-02f, 1.70881063e-01f, 6.42209500e-02f, -5.42648323e-02f,
  3.02791949e-02f, -1.26224816e-01f, -2.28347704e-01f, 5.74797951e-02f, -6.80613965e-02f, -6.91189691e-02f, -1.56420782e-01f, -1.55578298e-03f, -9.52780396e-02f, -2.25880533e-01f,
  -1.07251965e-01f, -3.04567069e-01f, 3.87185365e-02f, 4.64594997e-02f, 6.95342422e-02f, 1.45171836e-01f, 1.28093585e-02f, -3.99085283e-02f, 8.62076655e-02f, -3.70957702e-02f,
  -6.30103573e-02f, 1.19285397e-01f, 1.34471655e-01f, 5.49031049e-02f, 1.52707994e-01f, 8.56251642e-02f, 5.78637570e-02f, 1.38236389e-01f, 2.62861729e-01f, 1.85294583e-01f,
  4.16654646e-02f, -6.90714195e-02f, -2.18068853e-01f, -1.16970368e-01f, -1.50916532e-01f, 1.12358935e-01f, -1.43654272e-01f, -2.61645824e-01f, -1.55904710e-01f, -1.90440565e-01f,
  4.69807267e-01f, -3.92698944e-01f, 1.06488816e-01f, 5.74259125e-02f, -1.12030298e-01f, -9.02681127e-02f, 1.26027524e-01f, -2.63355188e-02f, -1.08420990e-01f, -2.60866452e-02f,
  -8.91231075e-02f, -8.14706609e-02f, -1.07344426e-01f, -8.50335360e-02f, 3.28496993e-02f, 8.96655247e-02f, -3.08600124e-02f, -1.20136246e-01f, -7.99574479e-02f, 7.86604509e-02f,
  -6.88816980e-02f, -1.22606039e-01f, 6.33430760e-03f, 4.97544035e-02f, 3.69194858e-02f, 4.69228812e-02f, 4.43659499e-02f, -8.75756294e-02f, 4.90930229e-02f, -5.59804142e-02f,
  1.20524868e-01f, 3.14468779e-02f, -6.51039705e-02f, -8.98971185e-02f, 4.34030257e-02f, -7.86896516e-03f, -1.23079076e-01f, -8.27570166e-03f, 1.21921457e-01f, -1.80586744e-02f,
  -1.27122113e-02f, 2.95241252e-02f, -2.11395882e-02f, -1.97456423e-02f, -6.49895519e-02f, -7.52580836e-02f, -1.69364177e-02f, 6.18232088e-03f, -8.43581781e-02f, -4.86417301e-02f,
  -9.46360826e-02f, 1.20655680e-02f, -1.52733922e-01f, -9.83142257e-02f, 5.81060313e-02f, -1.89287332e-03f, -9.67342481e-02f, -1.04820011e-02f, -3.30361128e-02f, 9.06918198e-02f,
  2.25012168e-01f, -1.56062797e-01f, 1.17932275e-01f, 1.17258225e-02f, -2.27039196e-02f, 1.30122947e-02f, 1.62664831e-01f, 9.92343873e-02f, -8.85299891e-02f, 1.23234354e-01f,
  5.49371950e-02f, 5.60444966e-02f, -1.78866554e-02f, 2.46624229e-03f, 2.06585497e-01f, 1.66008145e-01f, 1.98428575e-02f, 1.22791760e-01f, -2.02855140e-01f, 8.77630934e-02f,
  4.04757075e-02f, 2.09702536e-01f, 2.90656775e-01f, 2.07279593e-01f, 7.78109208e-02f, 2.34424740e-01f, 1.59359202e-01f, 1.03583828e-01f, -3.47095430e-02f, 1.90698877e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.44946933e-01f, 2.51044363e-01f, -2.75260415e-02f, 1.25535369e-01f, 3.69077951e-01f, 2.72147626e-01f, 4.09695506e-02f, 1.06559753e-01f, 1.06493637e-01f, 1.83517590e-01f,
  -1.09898418e-01f, -3.82118509e-04f, 4.72242385e-02f, 1.98464617e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.86299071e-01f, 2.47476250e-01f, -1.06162652e-01f, 2.91963038e-03f, -5.75459786e-02f, -2.59387136e-01f, -4.58739139e-02f, -1.04001783e-01f, -5.91030829e-02f, 2.16342092e-01f,
  -3.14998388e-01f, 8.95723253e-02f, 4.58479822e-02f, 2.46397015e-02f, 1.69387594e-01f, -2.18087241e-01f, 1.75426543e-01f, -1.76561534e-01f, -1.54835150e-01f, 4.20276165e-01f,
  5.12170270e-02f, 1.18522517e-01f, 2.77991831e-01f, -3.79622914e-02f, 2.10254401e-01f, -1.53315857e-01f, 2.92405523e-02f, 2.34244347e-01f, -3.46619517e-01f, 2.17707753e-02f,
  -3.30367126e-02f, -2.42274076e-01f, 1.20809391e-01f, 8.13394710e-02f, 1.58531696e-01f, 7.27604032e-02f, 8.89382139e-02f, 4.22516391e-02f, 1.18248397e-02f, 1.24881648e-01f,
  7.31768534e-02f, -1.80846661e-01f, -1.24851085e-01f, 1.47217467e-01f, -6.99229240e-02f, 3.69498849e-01f, -9.66184735e-02f, 2.16941610e-01f, -8.04939792e-02f, -9.86827388e-02f,
  -2.08055213e-01f, 1.80169027e-02f, -1.83658618e-02f, 1.88937694e-01f, 2.75092363e-01f, 7.61373341e-02f, 2.80963689e-01f, 2.89364576e-01f, 2.09157374e-02f, 1.87019765e-01f,
  -5.99387549e-02f, -2.40044788e-01f, -4.45521101e-02f, 3.42050008e-02f, 1.52900681e-01f, -9.54713393e-03f, 8.70618522e-02f, -1.32316038e-01f, -1.08910099e-01f, 1.81919798e-01f,
  1.14521518e-01f, 1.11354038e-01f, 4.38437462e-02f, 1.34130985e-01f, 1.40013471e-01f, -6.56824112e-02f, -2.22841844e-01f, -7.88071379e-02f, 2.92949945e-01f, -1.60634652e-01f,
  -5.21990880e-02f, 1.00100033e-01f, -1.21216863e-01f, 8.56636092e-02f, 1.20872900e-01f, -3.86980623e-02f, 1.04372434e-01f, 3.72971654e-01f, 2.34927237e-01f, 2.40326986e-01f,
  1.80357173e-01f, 1.75183088e-01f, -2.06655174e-01f, -3.31352204e-01f, -9.61342901e-02f, 3.18759888e-01f, 1.33428171e-01f, 1.93316594e-01f, -1.22806720e-01f, 4.12537694e-01f,
  1.54535756e-01f, -5.26700914e-02f, -1.21925756e-01f, -2.89143082e-02f, 3.76865156e-02f, 8.59609246e-02f, -2.56913126e-01f, 1.32995248e-01f, 1.85923368e-01f, -4.43334058e-02f,
  4.32948582e-02f, 9.93279815e-02f, -2.02637091e-01f, -9.27281901e-02f, -4.43807133e-02f, 1.86284900e-01f, 1.87486351e-01f, 6.47388324e-02f, -8.39888081e-02f, -1.91789657e-01f,
  3.90930176e-01f, 4.30162437e-02f, -3.48401189e-01f, 7.35961050e-02f, -3.91462982e-01f, -2.02669322e-01f, 2.36134101e-02f, 2.14331686e-01f, 7.98686221e-02f, -1.40212253e-01f,
  2.04371884e-02f, -2.25987062e-01f, -8.31551012e-03f, -1.27970606e-01f, -5.84980287e-02f, -1.03172302e-01f, -2.68599033e-01f, 6.35807812e-02f, -1.83618203e-01f, -5.71624003e-02f,
  1.31079659e-01f, -6.41633198e-02f, -1.03262722e-01f, 3.22653323e-01f, 9.94487852e-02f, -1.78152608e-04f, -2.78774440e-01f, -1.92673355e-01f, -1.08447425e-01f, -2.71154493e-01f,
  3.48349333e-01f, 1.30939722e-01f, -1.48984179e-01f, 1.64954346e-02f, -1.84373289e-01f, 1.87840134e-01f, 2.36232892e-01f, 1.90279916e-01f, -4.18016687e-02f, 2.05340981e-02f,
  8.54454562e-03f, -2.53311425e-01f, -1.41402170e-01f, -2.16331840e-01f, -2.45641351e-01f, 5.41836880e-02f, -2.23803073e-02f, 1.73937738e-01f, 3.04052066e-02f, 1.41665339e-01f,
  4.45327699e-01f, 1.70052648e-01f, 1.72170848e-02f, -3.34127188e-01f, 8.73360690e-03f, -2.96436995e-01f, 3.41665149e-02f, 7.60689378e-02f, 2.29516625e-01f, -3.16778384e-02f,
  6.24882206e-02f, -4.16137129e-02f, -4.06460106e-01f, -4.59029488e-02f, -1.69570357e-01f, -9.99729112e-02f, -5.47408164e-02f, -2.23422080e-01f, 8.76548663e-02f, -5.37156984e-02f,
  2.06868537e-02f, -1.47035629e-01f, -4.86081690e-02f, 8.23844597e-02f, 4.40845303e-02f, -1.99852720e-01f, 4.38122936e-02f, 4.87280376e-02f, 5.49217016e-02f, 3.38369794e-02f,
  2.71452125e-02f, -3.61846387e-03f, -4.01529446e-02f, -4.69533019e-02f, -5.01900166e-02f, 2.80426592e-01f, 1.94364503e-01f, -5.21388240e-02f, 1.39022216e-01f, -1.58833772e-01f,
  -2.45505169e-01f, -1.10924289e-01f, -1.99956045e-01f, 1.75296143e-01f, 2.45862573e-01f, -2.29076366e-03f, 2.85843492e-01f, 5.11489511e-01f, 5.99962510e-02f, -7.60499164e-02f,
  -8.14544410e-02f, 6.03861455e-03f, -2.58956015e-01f, -2.78698057e-02f, 1.31142661e-01f, 1.75446659e-01f, -2.65512392e-02f, 6.84017781e-03f, -1.56770736e-01f, 7.36109465e-02f,
  2.21829087e-01f, 3.05214506e-02f, -9.36602950e-02f, 5.04182167e-02f, -3.89384991e-03f, 1.39639020e-01f, 4.20802198e-02f, 1.15810581e-01f, 1.01533830e-01f, -2.01027423e-01f,
  -1.74868956e-01f, -2.23726884e-01f, -3.33479971e-01f, 2.41054922e-01f, 1.05886474e-01f, -3.07097733e-01f, 1.45442128e-01f, -8.56125206e-02f, 6.08740076e-02f, -3.10570657e-01f,
  -1.09981075e-01f, -2.87453458e-02f, -2.42746398e-01f, 2.14640945e-01f, 1.91054065e-02f, -4.87296283e-02f, -1.83974172e-03f, 1.42203957e-01f, 4.49957773e-02f, -1.04570344e-01f,
  1.57027617e-01f, 1.87067520e-02f, 7.44632706e-02f, 1.60437897e-01f, -2.54757762e-01f, 2.90581435e-01f, -3.23406726e-01f, -4.07681130e-02f, 8.37070122e-02f, -1.51482269e-01f,
  -1.42864287e-01f, 2.02328086e-01f, 1.12343773e-01f, -2.68874884e-01f, -2.52006054e-01f, 1.31905332e-01f, -1.14609830e-01f, 1.19794264e-01f, 2.66334653e-01f, -1.22606188e-01f,
  -1.93402618e-01f, 1.79042108e-02f, -2.78263181e-01f, -7.79968500e-02f, -2.54681826e-01f, 1.66873604e-01f, 1.13173656e-01f, -2.24757686e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.00363299e-01f, 1.74394563e-01f, 1.11091197e-01f, 3.15638602e-01f, 1.59051865e-02f, 2.84822375e-01f, 3.63526493e-01f, 1.48811504e-01f, 5.40411808e-02f, -2.96166211e-01f,
  2.93046117e-01f, -3.39533269e-01f, -2.52500083e-02f, 1.11155696e-01f, -2.40934148e-01f, 2.50102282e-01f, 4.30204980e-02f, 6.69923902e-01f, 4.79456991e-01f, -2.15847611e-01f,
  9.54076834e-03f, 1.33731723e-01f, 1.63297370e-01f, 4.48042490e-02f, -6.66737277e-03f, 2.06058368e-01f, 5.56057513e-01f, -2.79999286e-01f, 2.14686304e-01f, -1.45012334e-01f,
  1.57845661e-01f, -2.78792441e-01f, 1.04713418e-01f, 1.02879837e-01f, 2.61424258e-02f, 1.60112992e-01f, 2.78538465e-01f, 1.45307153e-01f, 1.07691474e-01f, 3.15782130e-02f,
  6.64328039e-02f, -8.58935416e-02f, -1.90787882e-01f, 9.69692916e-02f, 1.87114909e-01f, 1.54931873e-01f, 2.35844210e-01f, -6.74335882e-02f, 7.38707855e-02f, -7.03883916e-02f,
  2.25168094e-02f, 5.11179902e-02f, 3.24440747e-01f, 3.07418495e-01f, 2.73013175e-01f, -1.03731968e-01f, 6.23372257e-01f, 1.15637466e-01f, 1.84262574e-01f, 2.15595633e-01f,
  -8.30538198e-02f, -4.29785065e-02f, -8.49668011e-02f, 1.93885565e-01f, 1.16774417e-01f, -6.74055144e-02f, 1.70806780e-01f, 6.49803579e-02f, -1.20788939e-01f, 8.63241106e-02f,
  3.75293940e-01f, 2.73135960e-01f, -1.45554185e-01f, 1.65837824e-01f, -1.91825211e-01f, -4.43157088e-03f, -3.92407961e-02f, -2.39493158e-02f, 6.97054043e-02f, 3.79810423e-01f,
  2.03664809e-01f, -6.56773150e-02f, -3.32762897e-01f, -1.09248653e-01f, -1.16410144e-01f, 5.84782846e-02f, 4.56462055e-01f, 3.64575535e-01f, 1.08328812e-01f, 3.02274555e-01f,
  1.93913534e-01f, -2.25185528e-01f, -1.22989658e-02f, -1.24954574e-01f, 2.40734696e-01f, 2.99890788e-04f, 2.38700286e-01f, 3.26150239e-01f, -1.23507511e-02f, 1.94690317e-01f,
  1.16312139e-01f, -3.89857702e-02f, -1.22850306e-01f, -4.24902551e-02f, -1.44418135e-01f, 1.05598576e-01f, -2.08696112e-01f, -3.89637202e-02f, -1.23527162e-01f, 1.01309113e-01f,
  4.73512374e-02f, -4.85335626e-02f, -1.44630864e-01f, -7.06760362e-02f, 1.90003917e-01f, 4.31510717e-01f, 1.30738422e-01f, 4.65330929e-01f, 2.31907651e-01f, 2.59878282e-02f,
  3.74077618e-01f, -6.21029362e-02f, -1.70140266e-01f, 7.79144764e-02f, -2.57682979e-01f, -4.59071286e-02f, 1.84337303e-01f, -2.24872515e-01f, 2.71190047e-01f, 2.40884647e-01f,
  2.29287714e-01f, -1.44877553e-01f, 1.28136605e-01f, 1.80121213e-01f, 1.20683447e-01f, 1.52112111e-01f, 1.72949970e-01f, 1.34650022e-01f, -2.73889732e-02f, 1.13352440e-01f,
  -2.25500073e-02f, 2.17936754e-01f, -6.55082911e-02f, 1.76081732e-01f, -2.74533462e-02f, -2.91354209e-01f, -7.36689985e-01f, 1.20613519e-02f, -6.04691744e-01f, 1.97738577e-02f,
  2.55295277e-01f, -5.91951907e-02f, -6.02039210e-02f, 3.14497709e-01f, -2.91128099e-01f, -1.23088427e-01f, -8.90647694e-02f, 1.51880756e-02f, -1.07456036e-01f, 2.60290831e-01f,
  5.79444021e-02f, 1.15601458e-01f, 2.21070461e-02f, 5.86986206e-02f, 6.47100434e-02f, 4.03694883e-02f, 7.66037107e-02f, -1.03865508e-02f, -2.35306881e-02f, -2.04020619e-01f,
  -3.36319394e-02f, -1.39396176e-01f, 1.25581577e-01f, 4.35667969e-02f, -9.14953202e-02f, 7.11968839e-02f, -1.99772984e-01f, 3.74380738e-01f, 1.89029813e-01f, 6.84178844e-02f,
  8.92969891e-02f, -2.20270250e-02f, 2.52253801e-01f, 5.07239580e-01f, -2.11148068e-01f, -3.38034868e-01f, 3.43977839e-01f, -1.99221954e-01f, 1.93107620e-01f, 1.54899821e-01f,
  1.19763784e-01f, 4.06785794e-02f, 2.81706959e-01f, -1.73900545e-01f, 2.87478179e-01f, -1.77474916e-01f, 1.07059814e-01f, 2.70208389e-01f, 2.05386996e-01f, 1.89477995e-01f,
  -1.26314178e-01f, 1.82236269e-01f, -2.42120877e-01f, -2.67905831e-01f, -1.58888847e-01f, -1.53761044e-01f, -1.43804913e-02f, 3.66648704e-01f, 2.28711098e-01f, -1.11101046e-01f,
  -1.19025290e-01f, 2.00564057e-01f, -4.70216908e-02f, -3.66884142e-01f, 3.37787688e-01f, 1.34430066e-01f, -2.82518506e-01f, 2.71296322e-01f, -6.91490993e-03f, -4.78615053e-02f,
  2.30503723e-01f, 1.23336516e-01f, 3.45339954e-01f, 2.76083983e-02f, -3.74559239e-02f, -1.52275383e-01f, 9.15607437e-02f, -5.89824259e-01f, -3.31032537e-02f, 4.68600839e-02f,
  -6.97726989e-03f, 1.17260113e-01f, 1.58320278e-01f, -2.24763807e-02f, 1.12495594e-01f, -1.24275267e-01f, -4.60295677e-01f, 1.03675956e-02f, 3.64770144e-02f, -2.65248362e-02f,
  6.41893744e-02f, -1.11857839e-01f, 6.53120652e-02f, -2.66225934e-01f, -9.37157050e-02f, 1.41685888e-01f, -6.82261586e-02f, 5.08328043e-02f, 3.11206728e-01f, 2.51656324e-01f,
  1.76033482e-01f, 3.24108273e-01f, -3.45007569e-01f, 2.82935709e-01f, -3.03513050e-01f, 1.15236044e-01f, 3.71887118e-01f, 3.98059547e-01f, 3.46858829e-01f, 2.86581576e-01f,
  -6.12044558e-02f, 4.42023873e-01f, 4.03622016e-02f, 2.00476021e-01f, 5.14418602e-01f, 2.30202004e-02f, -4.45523262e-01f, -5.46446852e-02f, 2.97353804e-01f, -1.71123371e-01f,
  -4.06419903e-01f, 3.94366443e-01f, 9.27164555e-02f, -1.41482025e-01f, 4.19049293e-01f, -6.11938685e-02f, -1.96131408e-01f, 4.78671230e-02f, 1.50006548e-01f, -3.66727829e-01f,
  2.59350259e-02f, -1.21168904e-01f, -1.70687795e-01f, -6.79279804e-01f, 2.51917504e-02f, 3.20464343e-01f, 1.25985429e-01f, -3.60216200e-01f, 2.29237586e-01f, -3.75706814e-02f,
  1.16742335e-01f, 2.89786816e-01f, 1.54324770e-01f, 1.63687214e-01f, 2.54216492e-01f, -3.39195989e-02f, -2.16089517e-01f, -3.21357176e-02f, 4.51259427e-02f, -1.17104203e-01f,
  1.42800719e-01f, -1.44598454e-01f, 1.90018669e-01f, 1.11643234e-02f, -7.73159191e-02f, 3.99137959e-02f, -4.15010303e-01f, -9.23284665e-02f, 2.59053648e-01f, -4.16582115e-02f,
  -2.04329193e-02f, 3.97900224e-01f, 9.60578397e-02f, -1.17670864e-01f, 1.70617536e-01f, 8.60007927e-02f, -1.35566622e-01f, -3.06127787e-01f, 1.98759869e-01f, 1.41571447e-01f,
  2.04773620e-02f, 5.91437221e-01f, 8.57448578e-02f, 4.00703132e-01f, -9.05823633e-02f, -1.11687917e-03f, 6.62604645e-02f, 2.82052696e-01f, 3.42544049e-01f, 2.84671724e-01f,
  -3.02084118e-01f, 2.55147576e-01f, 3.13372254e-01f, -3.25180925e-02f, 2.56499648e-01f, -7.86195323e-02f, 6.47149384e-02f, -2.05356590e-02f, 8.21579844e-02f, 3.12611878e-01f,
  -5.68328351e-02f, 1.03735380e-01f, 4.19045120e-01f, -4.90035769e-03f, 3.92628461e-01f, 1.46020621e-01f, -2.71988437e-02f, -3.64270061e-01f, -1.88070431e-01f, -3.26202780e-01f,
  -1.35998100e-01f, 1.62394211e-01f, 1.86030716e-01f, -2.90814310e-01f, 1.14285462e-01f, -5.42316101e-02f, -1.69009537e-01f, 1.98951691e-01f, 2.24734113e-01f, 1.72437549e-01f,
  -2.16650933e-01f, 9.08888653e-02f, 3.76105756e-01f, 3.63750122e-02f, -1.27813652e-01f, 1.17924780e-01f, -2.04221264e-01f, 6.48105815e-02f, -1.16716065e-02f, 2.37104282e-01f,
  -2.34712526e-01f, 9.16249771e-03f, 1.18528031e-01f, -3.81302208e-01f, 3.99577878e-02f, 2.23988101e-01f, -2.96479523e-01f, 2.60600746e-01f, 1.52368692e-03f, -2.13934369e-02f,
  1.65074825e-01f, -2.82255381e-01f, -4.41963971e-02f, 1.59430683e-01f, 2.21641675e-01f, 1.88268363e-01f, -7.97880590e-02f, 9.50930417e-02f, -1.04309715e-01f, 2.40292281e-01f,
  2.56864905e-01f, 9.66769382e-02f, 1.68324292e-01f, -8.10705274e-02f, 2.00414196e-01f, 2.23895758e-02f, 2.40661934e-01f, 2.02068433e-01f, 1.06309131e-01f, -2.24780455e-01f,
  -9.65259504e-03f, 1.31154150e-01f, 1.81509241e-01f, 3.19863893e-02f, -1.11929521e-01f, 5.92872620e-01f, 1.49454817e-01f, -2.36030892e-02f, 4.87441957e-01f, 2.28260964e-01f,
  8.85267779e-02f, 6.14854582e-02f, 1.47409633e-01f, -1.43425018e-01f, -2.05980286e-01f, 6.86467886e-02f, 1.11815013e-01f, 2.20798567e-01f, 5.57574518e-02f, 8.73941109e-02f,
  -1.27466992e-02f, -9.51106995e-02f, 2.53378808e-01f, 2.23412901e-01f, 1.41854301e-01f, 1.26619488e-01f, 2.83978470e-02f, -3.34144942e-02f, 6.81737587e-02f, 1.96449474e-01f,
  5.90227395e-02f, 2.67868400e-01f, 2.66615557e-03f, 3.78970444e-01f, -7.97239020e-02f, 1.29945576e-01f, -4.71431106e-01f, 5.28315544e-01f, 2.21940994e-01f, 7.88487345e-02f,
  3.14321607e-01f, 5.28110862e-01f, 1.71567023e-01f, 3.77058722e-02f, -1.44248083e-01f, -1.59424692e-01f, -4.12791260e-02f, -5.55453040e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.08562279e-01f, -1.09615423e-01f, 2.69763380e-01f, 8.55826288e-02f, 2.52333760e-01f, 5.39727509e-02f, 1.99899733e-01f, -2.28309780e-01f, 1.39255285e-01f, -7.33457133e-02f,
  2.32676547e-02f, 1.71291351e-01f, 1.50804117e-01f, 2.40902752e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.71759248e-01f, -4.11697440e-02f, -3.66657406e-01f, 4.18187752e-02f, -1.67824656e-01f, -2.16046218e-02f, -1.46501049e-01f, -1.50627956e-01f, -1.14832342e-01f, 1.64031491e-01f,
  1.67187795e-01f, 4.46311176e-01f, 3.04183334e-01f, 5.74923009e-02f, 1.57987714e-01f, 1.79447114e-01f, 3.19742322e-01f, 7.69668072e-02f, -3.50650311e-01f, 3.42092276e-01f,
  1.06189046e-02f, 1.15768470e-01f, 3.75288576e-01f, -2.36136504e-02f, -1.47351595e-02f, 3.73400807e-01f, -2.38591760e-01f, 1.59787148e-01f, -6.44762591e-02f, -1.04362801e-01f,
  2.08636954e-01f, -4.35996465e-02f, 3.90100598e-01f, 4.78922091e-02f, 8.80434811e-02f, -1.90167874e-01f, -2.08482176e-01f, -1.97230041e-01f, 2.91641742e-01f, -5.49570806e-02f,
  1.60598561e-01f, 2.01405644e-01f, 1.01311103e-01f, -3.23960371e-02f, 3.13052833e-02f, 2.12819502e-01f, -2.72868782e-01f, -2.19978735e-01f, -9.26717594e-02f, -2.79859811e-01f,
  1.25759780e-01f, -1.59668043e-01f, -5.32238856e-02f, -1.72733497e-02f, -1.87028319e-01f, 1.98535621e-01f, -6.46140575e-02f, -1.10852569e-01f, 2.49869183e-01f, 9.16518271e-03f,
  -1.64903775e-01f, 2.58652642e-02f, -2.02250138e-01f, -2.27818847e-01f, 1.89818561e-01f, -2.04077542e-01f, -1.74106341e-02f, -3.04042548e-02f, -1.08415678e-01f, -5.85214142e-03f,
  1.53138846e-01f, 1.19676121e-01f, 1.73281714e-01f, -1.92618281e-01f, 4.82876658e-01f, -1.87845826e-01f, 5.13907336e-02f, -4.63954248e-02f, -6.42046690e-01f, 1.47188738e-01f,
  -3.50208610e-01f, -5.10797918e-01f, 2.63385832e-01f, -1.51176021e-01f, -1.07283164e-02f, -2.47518733e-01f, 1.11647636e-01f, -1.00385286e-01f, -2.11415946e-01f, -1.65803671e-01f,
  -8.96802321e-02f, 3.13841775e-02f, 8.79263505e-02f, 9.86941159e-02f, 8.52841958e-02f, 5.25443926e-02f, -3.56413946e-02f, -1.50808189e-02f, 2.43204340e-01f, 1.86873451e-01f,
  -1.00584798e-01f, 1.19568139e-01f, 1.53101742e-01f, -2.53674090e-01f, 1.66476686e-02f, 2.17791691e-01f, 2.37450168e-01f, 1.06154889e-01f, 2.63918281e-01f, -5.13993144e-01f,
  -1.74979806e-01f, -1.85208708e-01f, 1.16190955e-01f, 1.11487761e-01f, 7.03191152e-03f, -1.99034795e-01f, -3.20693143e-02f, 2.52155721e-01f, -2.19581366e-01f, 4.93553951e-02f,
  -3.01800102e-01f, -2.30955541e-01f, 1.09135449e-01f, -5.77531941e-02f, 2.93810725e-01f, -3.53774160e-01f, 2.39150167e-01f, -3.66364280e-03f, 1.39281452e-01f, 1.08740464e-01f,
  5.32208383e-01f, 1.02946302e-02f, 6.05196096e-02f, 2.27107659e-01f, 2.95508087e-01f, -2.48920377e-02f, -3.48872095e-02f, 9.12424177e-03f, -5.67503385e-02f, -4.79574800e-01f,
  -4.45082873e-01f, -1.96186393e-01f, -3.07479799e-01f, 1.23818897e-01f, -2.93021172e-01f, -4.32847664e-02f, 3.77068639e-01f, -1.81520194e-01f, -1.83606535e-01f, -1.29841939e-01f,
  -3.23485434e-01f, 2.46938869e-01f, 7.16017410e-02f, -5.71178347e-02f, 1.10213749e-01f, -2.19606951e-01f, -1.36911049e-01f, -1.11505702e-01f, -3.63571227e-01f, -1.45887762e-01f,
  1.91824228e-01f, 2.62132317e-01f, -1.78065449e-01f, 2.19054371e-01f, 2.39398852e-01f, 2.30449840e-01f, 2.64946133e-01f, -2.42006332e-02f, -1.87741727e-01f, 8.22810754e-02f,
  -2.24689096e-01f, -1.79745317e-01f, 1.38131186e-01f, -1.62254617e-01f, -5.35908565e-02f, -3.86771441e-01f, 4.39504176e-01f, 2.12547719e-01f, -6.25226274e-02f, -3.83697748e-02f,
  8.21507871e-02f, -2.84820162e-02f, 2.68691108e-02f, -5.25098033e-02f, 2.86677659e-01f, -2.23039418e-01f, 4.97025400e-02f, 1.90876067e-01f, 1.21744528e-01f, 9.00014564e-02f,
  -1.50437251e-01f, -3.28707665e-01f, 2.93175489e-01f, 2.39831790e-01f, -7.40795359e-02f, -2.85193294e-01f, 1.32946363e-02f, 1.68111563e-01f, 2.26680443e-01f, -5.39139938e-03f,
  4.83224988e-02f, 9.43751857e-02f, 1.12838954e-01f, 4.23904806e-02f, -2.38877669e-01f, -2.49146461e-01f, -5.30929640e-02f, 1.59372238e-03f, -3.19819480e-01f, -2.81480961e-02f,
  2.09576190e-01f, 2.16125146e-01f, -1.41823635e-01f, -1.93076104e-01f, -2.93995500e-01f, -9.00287405e-02f, -3.41345727e-01f, 5.72948121e-02f, -1.75297279e-02f, -1.36743858e-01f,
  7.75286108e-02f, -6.64329976e-02f, 2.14265183e-01f, -2.29372326e-02f, -4.22349572e-02f, 1.83797717e-01f, -1.23877041e-01f, 1.66282058e-01f, 2.51026094e-01f, -2.44160339e-01f,
  1.12568401e-02f, 1.75282702e-01f, 3.83631624e-02f, 3.43351550e-02f, -1.94030985e-01f, -8.57254639e-02f, -1.56184752e-02f, 5.91125011e-01f, -2.49031708e-01f, 3.14639807e-01f,
  -1.97096672e-02f, 1.28644809e-01f, -1.10192351e-01f, -1.82645768e-01f, 1.89515203e-01f, -3.31602432e-02f, 3.22174758e-01f, 1.78816810e-01f, 2.37919435e-01f, -1.95190117e-01f,
  -1.36225402e-01f, -1.24611959e-01f, -6.98999986e-02f, 3.12139206e-02f, -1.09148778e-01f, -1.12716228e-01f, -3.72619480e-01f, -1.22579895e-02f, -2.00848863e-01f, 1.32215321e-01f,
  3.59689929e-02f, -2.24640463e-02f, -2.94276237e-01f, -1.00919574e-01f, -1.43133968e-01f, -8.35869536e-02f, -3.27743828e-01f, 1.31730393e-01f, 7.99143612e-02f, 3.04262251e-01f,
  3.88498485e-01f, 2.09052470e-02f, 5.10389566e-01f, 4.53932196e-01f, -2.74022251e-01f, -1.64970621e-01f, 2.07145929e-01f, -3.10288090e-03f, 3.04593682e-01f, -1.33389980e-01f,
  2.06464186e-01f, 1.34843811e-01f, -1.25396335e-02f, 1.56533524e-01f, -1.76168784e-01f, 1.25629991e-01f, -2.11805835e-01f, 5.34920022e-03f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.71351153e-01f, 2.93969601e-01f, 5.35617828e-01f, -5.68170324e-02f, 3.16832095e-01f, 1.58560634e-01f, 3.55603755e-01f, 4.84498888e-01f, 2.87570864e-01f, -3.78736109e-01f,
  -1.70869485e-01f, -6.88457489e-03f, -4.99639362e-01f, 1.46110281e-01f, 2.56789178e-01f, -3.88415784e-01f, -7.64362738e-02f, 2.53467917e-01f, 4.74702030e-01f, -1.35656610e-01f,
  2.17779711e-01f, -3.21924567e-01f, -3.87051761e-01f, 4.07255918e-01f, 1.85640365e-01f, -1.66637614e-01f, 5.39910018e-01f, -8.54578093e-02f, -1.41391054e-01f, 2.58830260e-04f,
  6.26679882e-02f, -3.61472927e-02f, -3.66176158e-01f, -2.09992498e-01f, 2.09293351e-01f, 4.65690315e-01f, 3.16899657e-01f, -1.96745172e-01f, -4.65327017e-02f, -9.35858935e-02f,
  2.24331111e-01f, 7.33151585e-02f, 2.25189164e-01f, 1.68625191e-01f, 5.71247995e-01f, -7.81396776e-02f, -3.94809067e-01f, 4.25319821e-01f, -3.00323129e-01f, 4.02793050e-01f,
  -2.31454019e-02f, -8.96110758e-02f, 1.31920755e-01f, 4.41979825e-01f, 1.03896536e-01f, 2.52885614e-02f, -2.38577323e-03f, -3.49067777e-01f, 2.60985762e-01f, -1.23262936e-02f,
  4.01588351e-01f, -3.73279512e-01f, 2.28621498e-01f, 1.72418907e-01f, -2.04207584e-01f, -8.09376314e-02f, 4.85748425e-02f, 7.08316028e-01f, 1.89617515e-01f, -2.15321288e-01f,
  -3.61210078e-01f, -1.21626034e-01f, 7.66478404e-02f, 4.27002758e-01f, -1.35949641e-01f, 3.18410769e-02f, 2.07048535e-01f, 3.44186425e-01f, -3.27763498e-01f, 3.73025715e-01f,
  6.77581206e-02f, 4.66017008e-01f, 1.08166188e-01f, 7.74189085e-02f, 2.09538728e-01f, 4.76117820e-01f, 3.56086493e-01f, 2.59530544e-01f, 3.30834538e-01f, -1.05181202e-01f,
  4.47235823e-01f, -3.83885056e-02f, 4.65994596e-01f, -1.29240528e-01f, 2.15919339e-03f, 1.33598283e-01f, 8.72083902e-02f, -1.17647564e-02f, 4.40210849e-02f, 7.40169734e-02f,
  2.98858613e-01f, 5.06339729e-01f, 3.03541571e-01f, -2.92189837e-01f, -1.71852157e-01f, 5.06605029e-01f, 2.93845516e-02f, 2.91262597e-01f, -5.38519844e-02f, -6.25017881e-01f,
  3.47101539e-02f, -2.31095642e-01f, 6.06581904e-02f, -2.83512563e-01f, -9.43233892e-02f, 2.79201895e-01f, -1.03035182e-01f, 3.82064879e-01f, -1.73498616e-01f, 4.87178713e-02f,
  -1.67058781e-01f, -8.37443843e-02f, -9.40454528e-02f, -1.14050008e-01f, 2.65285522e-01f, -2.52704829e-01f, 2.63605654e-01f, 2.05363989e-01f, 3.54141742e-02f, 7.07742199e-02f,
  2.93800741e-01f, -8.49831700e-02f, 7.91134015e-02f, -4.53840792e-02f, -5.54623008e-02f, -2.54614919e-01f, -1.43522676e-02f, -7.71018863e-02f, -1.17675938e-01f, 2.13878125e-01f,
  -7.53346533e-02f, -3.19528908e-01f, 4.24521059e-01f, -6.29275382e-01f, 3.67758602e-01f, 1.32944107e-01f, -1.41492814e-01f, 4.26236987e-01f, 6.35077134e-02f, 1.31425992e-01f,
  -9.00217593e-02f, 7.95396343e-02f, 3.50008130e-01f, 1.07986331e-02f, 2.05167025e-01f, 3.09329808e-01f, 1.79588154e-01f, 6.82292581e-02f, 9.68428031e-02f, -4.06290174e-01f,
  3.96183699e-01f, -3.82378437e-02f, 2.25082174e-01f, 3.36894691e-01f, 6.94353282e-02f, 3.04499358e-01f, 1.54582644e-02f, 1.30072609e-01f, 6.45315787e-03f, -1.51621163e-01f,
  3.40976357e-01f, 2.39702743e-02f, 1.97523343e-03f, -5.12014568e-01f, -5.21954060e-01f, 4.15257484e-01f, -7.76558578e-01f, -4.02657390e-01f, 4.22068357e-01f, -1.12647749e-01f,
  1.02936983e-01f, -1.66299596e-01f, -2.14734644e-01f, 4.98368628e-02f, 5.63339621e-04f, 1.48624303e-02f, 5.57545051e-02f, -3.49715650e-01f, 1.02050573e-01f, 2.00824007e-01f,
  1.45025015e-01f, 2.77115047e-01f, -8.97830501e-02f, 3.13929915e-02f, 4.38995928e-01f, 2.91470379e-01f, 1.29996851e-01f, 6.56822398e-02f, 3.76378626e-01f, 2.74973124e-01f,
  4.73503053e-01f, 2.26341844e-01f, -8.36027265e-02f, -1.15514688e-01f, 2.60930777e-01f, 4.59162533e-01f, -4.36105847e-01f, -1.90853588e-02f, 1.10259548e-01f, 5.69594383e-01f,
  -9.56005827e-02f, 1.66342109e-01f, 2.83591300e-01f, 3.99890870e-01f, 5.99977076e-01f, -2.01286718e-01f, 2.96149164e-01f, -1.76098987e-01f, 8.31758857e-01f, -3.84287417e-01f,
  2.56608099e-01f, -3.00692737e-01f, 2.71952283e-02f, 1.55529961e-01f, -1.01685837e-01f, -2.37708166e-01f, -2.63518870e-01f, 1.53887033e-01f, 2.40164950e-01f, 2.96921790e-01f,
  -4.06849742e-01f, 3.05720538e-01f, -1.09528124e-01f, 3.18970084e-01f, 2.44666994e-01f, 1.08773448e-01f, -2.29345486e-01f, -2.21368968e-01f, -1.08537711e-01f, 3.92664671e-01f,
  -2.32172355e-01f, -1.45214215e-01f, 5.21751761e-01f, -4.30963235e-04f, 3.46255451e-01f, -2.69670427e-01f, 1.17596708e-01f, 1.27507970e-01f, 9.60256681e-02f, 2.05639869e-01f,
  -6.51186228e-01f, -7.83534646e-02f, 1.05620712e-01f, 1.33665904e-01f, 2.67365068e-01f, 3.64316255e-01f, 5.29357433e-01f, 1.95282131e-01f, 1.15071297e-01f, -2.18439009e-02f,
  3.05062443e-01f, -3.79917026e-01f, 8.49758312e-02f, 3.17660645e-02f, -6.93191960e-02f, -9.75004435e-02f, 7.57466024e-03f, 1.90529078e-01f, 9.65328515e-02f, 1.29398644e-01f,
  1.08829089e-01f, -9.35891271e-02f, -2.66487807e-01f, -5.65483570e-01f, 4.96894956e-01f, 3.92399102e-01f, 4.05678153e-01f, 7.32181296e-02f, -2.50080317e-01f, 5.80804706e-01f,
  -8.14141706e-03f, 1.29172996e-01f, -2.81023771e-01f, 3.42353553e-01f, -6.50290251e-02f, 2.97118723e-01f, 1.53232023e-01f, -1.92934036e-01f, 3.11883956e-01f, -4.68432717e-02f,
  -1.91559672e-01f, -6.62556812e-02f, 2.74247617e-01f, 3.10582161e-01f, -6.05858825e-02f, 7.97134787e-02f, 3.44899893e-01f, 1.79626092e-01f, 2.47739270e-01f, -5.51307909e-02f,
  1.13861948e-01f, -3.92099112e-01f, -4.23685670e-01f, 1.62076011e-01f, -5.13696849e-01f, -3.10826331e-01f, 4.95867580e-01f, 1.67998433e-01f, 2.32232198e-01f, -1.18547268e-01f,
  1.95090368e-01f, 1.55930758e-01f, 1.85495138e-01f, 8.43253136e-02f, -2.91827679e-01f, -2.21864413e-02f, 3.69089484e-01f, 9.44659412e-02f, 2.94850588e-01f, 3.61701280e-01f,
  -2.09018141e-01f, -1.74507335e-01f, 1.30186602e-01f, 3.93052280e-01f, 1.07166201e-01f, -3.06767225e-01f, -2.90988892e-01f, 2.59029895e-01f, 4.56714965e-02f, 3.04841101e-01f,
  3.96958850e-02f, 1.55121431e-01f, 2.24770233e-01f, 1.99476443e-02f, -3.36480588e-01f, 5.78901887e-01f, -3.34254026e-01f, -1.03023589e-01f, 7.01175705e-02f, 1.25695944e-01f,
  3.76419902e-01f, 9.49833989e-02f, -3.81419398e-02f, 4.56139714e-01f, 1.47168577e-01f, -1.69752270e-01f, -1.98827729e-01f, -3.65559943e-02f, 7.29495510e-02f, -1.79342121e-01f,
  1.34995192e-01f, 3.87279689e-01f, 8.80405083e-02f, 1.17505014e-01f, 7.79159606e-01f, 1.84911788e-01f, 7.90398419e-02f, 4.07843113e-01f, 4.61384952e-01f, 1.13536052e-01f,
  2.60671049e-01f, 3.13794076e-01f, 3.92220438e-01f, 3.28386456e-01f, 4.04966474e-01f, -8.31237197e-01f, -4.63799000e-01f, -4.32928801e-02f, 2.13308986e-02f, 1.23868294e-01f,
  2.55946398e-01f, 2.14630753e-01f, -1.25751898e-01f, 3.23368549e-01f, -2.61541605e-01f, 3.98902297e-02f, -2.14846402e-01f, -6.23133957e-01f, 2.93418288e-01f, -3.28231514e-01f,
  5.57694852e-01f, -5.59440911e-01f, 6.12243786e-02f, -3.93015426e-03f, -1.82119794e-02f, -3.23149532e-01f, -6.14003956e-01f, -2.96086252e-01f, 3.27291578e-01f, -6.83452655e-03f,
  -3.05769712e-01f, 1.30002886e-01f, 2.35806510e-01f, 1.72392234e-01f, 4.42176729e-01f, 3.67861331e-01f, -1.55421849e-02f, 2.82089680e-01f, -5.38252890e-01f, -1.62630957e-02f,
  5.42280912e-01f, 1.54057547e-01f, -3.61291200e-01f, 1.04620069e-01f, 1.77649677e-01f, 4.49931264e-01f, 1.90416381e-01f, 6.41029626e-02f, 2.61307150e-01f, -3.58100861e-01f,
  -4.77267951e-01f, 3.72584835e-02f, 3.17053884e-01f, 2.06032664e-01f, -1.65711306e-02f, -6.87872097e-02f, 4.97098148e-01f, 1.68235302e-01f, 5.82061596e-02f, -2.78173164e-02f,
  -3.56078707e-02f, 9.29569304e-02f, 4.19750839e-01f, 4.00372386e-01f, 3.99607509e-01f, -4.58744258e-01f, 8.24881643e-02f, -1.49865299e-01f, -2.69376278e-01f, 2.51372099e-01f,
  -2.79713482e-01f, 2.57183731e-01f, -4.04015034e-01f, 9.54353064e-03f, 1.99700668e-01f, -1.02644356e-03f, 1.41090780e-01f, -1.66541591e-01f, 3.88828039e-01f, 1.05941005e-01f,
  3.74022275e-01f, -1.47056386e-01f, 3.67134780e-01f, -3.77238661e-01f, -2.37793475e-01f, -4.01326753e-02f, -2.90044211e-02f, -8.83055627e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.03113288e-01f, 5.47593758e-02f, 2.03749567e-01f, 2.41347983e-01f, 3.62649471e-01f, -8.49721283e-02f, 5.19363165e-01f, -9.61768255e-02f, 1.58903703e-01f, 1.13132432e-01f,
  -4.17757556e-02f, 1.62447140e-01f, 1.96795389e-01f, 2.12540850e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.77826539e-01f, 1.64507553e-01f, 1.18557349e-01f, 3.23477685e-02f, 9.77278203e-02f, -7.88943395e-02f, -3.84186774e-01f, 4.12674397e-02f, -1.07796863e-01f, -3.64576280e-01f,
  -2.58916114e-02f, 1.10132322e-01f, -2.63540089e-01f, 2.02344641e-01f, 1.87165543e-01f, 4.35043275e-02f, -1.14974827e-01f, 2.97029585e-01f, 2.07602695e-01f, 5.44548407e-02f,
  6.28795996e-02f, -2.74364650e-01f, 1.40846036e-02f, 7.44216815e-02f, -1.42529935e-01f, -1.02923281e-01f, 2.77398348e-01f, -1.94675829e-02f, -1.42442539e-01f, -2.35936970e-01f,
  -1.92477047e-01f, 1.70665681e-01f, 1.65854603e-01f, 6.71093464e-02f, 2.97076285e-01f, -4.70735952e-02f, -1.31339252e-01f, 2.74724085e-02f, -3.47618431e-01f, 2.32126534e-01f,
  -6.04750626e-02f, -2.46783271e-01f, 9.44517925e-02f, 9.41505581e-02f, 8.09311867e-02f, 2.99789220e-01f, -1.73038706e-01f, 9.68452543e-02f, -6.91625774e-02f, -2.21134335e-01f,
  2.43574083e-01f, 1.58685848e-01f, -1.41895816e-01f, -1.76293015e-01f, -3.64920318e-01f, -5.16939797e-02f, 5.74855432e-02f, -8.25259164e-02f, -2.52876580e-01f, -2.04604715e-01f,
  1.18063048e-01f, 2.59516895e-01f, -9.32772309e-02f, 1.69818342e-01f, -3.28802429e-02f, 1.93081826e-01f, 2.92150319e-01f, -3.81584585e-01f, 4.58054803e-03f, 4.19097573e-01f,
  3.61641407e-01f, 2.54142703e-03f, -1.79474235e-01f, 4.32648450e-01f, -8.45527127e-02f, 3.18104297e-01f, 1.36258543e-01f, -4.14674401e-01f, -2.26380434e-02f, 3.13412361e-02f,
  -3.30890417e-01f, -7.26503134e-01f, -1.81569099e-01f, 8.50625932e-02f, 9.66248959e-02f, 1.42500073e-01f, 9.53792110e-02f, -1.86137035e-01f, -2.56494246e-02f, -2.08267316e-01f,
  3.26601326e-01f, 1.05615750e-01f, -5.18167391e-02f, -2.36796811e-02f, 9.22225881e-03f, -1.92372903e-01f, -2.85929561e-01f, -4.59722877e-01f, 1.36840880e-01f, -3.14269289e-02f,
  -1.08664341e-01f, 1.24379203e-01f, -8.15257356e-02f, -1.69172764e-01f, 9.03685838e-02f, 1.60963796e-02f, 7.36255199e-02f, 1.58758804e-01f, -1.53343365e-01f, -2.97023356e-02f,
  -3.83356303e-01f, -2.46515460e-02f, 1.85993850e-01f, -2.14073882e-01f, -2.62997806e-01f, 1.73661038e-01f, 2.59064853e-01f, -2.64609531e-02f, -3.19892198e-01f, -2.61646286e-02f,
  -2.81191021e-02f, 1.48245320e-01f, 1.48951322e-01f, -1.12849049e-01f, 2.93376088e-01f, -1.95254683e-01f, -1.08833596e-01f, -2.56408095e-01f, 8.39186460e-02f, -1.13275498e-02f,
  -6.81187212e-02f, -2.74319798e-01f, 1.94082081e-01f, 7.03802034e-02f, -3.36041488e-02f, 2.74576116e-02f, -1.16393954e-01f, 2.42691353e-01f, -3.40944886e-01f, 2.53911585e-01f,
  3.21302295e-01f, -4.85080015e-03f, 2.96425186e-02f, -1.81728303e-01f, -5.44736207e-01f, -1.90336987e-01f, -1.06436498e-01f, 1.26069307e-01f, 1.26126289e-01f, 1.74061045e-01f,
  1.33824468e-01f, 2.17751354e-01f, -1.89002335e-01f, -9.46011990e-02f, 6.92326725e-02f, 1.23742044e-01f, 1.65181294e-01f, 1.76606745e-01f, -3.18891048e-01f, -2.17148095e-01f,
  -6.92179501e-02f, -8.68780613e-02f, -4.68879156e-02f, -2.12918729e-01f, 1.38876438e-01f, -3.33818346e-02f, 2.62349427e-01f, 3.31220895e-01f, -5.42115606e-03f, 3.15093100e-01f,
  1.62027031e-01f, 4.01834212e-02f, 4.21730012e-01f, 1.65584952e-01f, -5.28577855e-03f, -3.42422903e-01f, -1.26630753e-01f, -5.30215539e-02f, -2.32257694e-01f, 1.91764042e-01f,
  2.14793190e-01f, 3.24664712e-02f, -7.55644441e-02f, 4.91716806e-03f, 1.42250448e-01f, -1.14155583e-01f, -1.68353245e-01f, -1.68440849e-01f, 1.59835279e-01f, 8.41760039e-02f,
  -4.01671045e-02f, -2.44716257e-01f, 1.42026007e-01f, 7.79142827e-02f, 1.12438023e-01f, -2.68441767e-01f, 2.01877337e-02f, 3.01448226e-01f, -8.87793452e-02f, -2.05247462e-01f,
  -2.36337528e-01f, -2.85199404e-01f, 3.88990827e-02f, 4.38850895e-02f, -4.15353566e-01f, -6.88367635e-02f, -2.42437735e-01f, 1.41721621e-01f, 1.28304660e-01f, -1.58378333e-01f,
  1.56750470e-01f, -2.33073533e-01f, -1.73122510e-01f, -2.36715704e-01f, 3.41451131e-02f, -5.01218513e-02f, 1.87577903e-01f, -1.15283981e-01f, 2.50092447e-01f, 1.55207932e-01f,
  -2.94449747e-01f, -1.19541578e-01f, -1.39406741e-01f, 2.39463359e-01f, -1.75517965e-02f, 5.75429276e-02f, 1.71652853e-01f, -1.82604909e-01f, 1.33529529e-02f, -8.23419616e-02f,
  -3.72681096e-02f, 1.00323759e-01f, 7.65045453e-03f, -1.26929194e-01f, -2.20847636e-01f, -2.75917411e-01f, 9.46762860e-02f, 1.40695542e-01f, -3.05009365e-01f, 1.69021130e-01f,
  -5.83642781e-01f, -5.94648793e-02f, -9.33760032e-02f, 2.24979699e-01f, 4.26143706e-02f, 3.94028127e-02f, 1.85009792e-01f, 1.05770983e-01f, 1.87895671e-01f, -1.63573250e-01f,
  -1.52222708e-01f, -1.28158152e-01f, -2.28039220e-01f, 2.11477384e-01f, 1.87865481e-01f, -2.57400006e-01f, 9.23232585e-02f, 4.52156603e-01f, 1.41233265e-01f, 2.25511983e-01f,
  5.47432184e-01f, 2.11410359e-01f, 1.28879488e-01f, 3.56700420e-01f, 1.30001700e-03f, -2.32589051e-01f, 1.04522415e-01f, -9.72226486e-02f, 1.40854642e-01f, 1.00206450e-01f,
  1.99161395e-01f, -1.66308478e-01f, -1.87265888e-01f, 8.84655192e-02f, 2.26827040e-01f, -9.94516462e-02f, 3.92883904e-02f, -9.87161510e-03f, 4.33496088e-02f, 1.46940919e-02f,
  7.03376457e-02f, -9.80002508e-02f, -2.27216884e-01f, -1.16831683e-01f, -2.16908574e-01f, 1.23239093e-01f, -3.04625034e-01f, 1.39542460e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -5.52997172e-01f, 2.89142460e-01f, 1.02990910e-01f, 7.19010755e-02f, -3.47375959e-01f, 2.52521574e-01f, 3.43078017e-01f, 1.26686901e-01f, -1.11933000e-01f, 4.97991405e-02f,
  -1.36780605e-01f, 5.63189127e-02f, 2.73827374e-01f, 1.91732436e-01f, -4.45931405e-01f, 2.62403578e-01f, -2.76837975e-01f, -4.16488200e-01f, 1.18805788e-01f, 3.61357599e-01f,
  1.21685728e-01f, -8.38736538e-04f, 2.72009164e-01f, -1.94123402e-01f, 3.44607420e-02f, -3.73527557e-01f, 1.47685498e-01f, 7.88467452e-02f, 1.29643001e-03f, 2.88285762e-01f,
  4.46801305e-01f, 1.77836940e-01f, 3.29088241e-01f, 4.29563731e-01f, 2.61058927e-01f, 1.73788369e-01f, 3.65746051e-01f, -1.97546840e-01f, -5.58463097e-01f, 3.85567546e-01f,
  -5.13478935e-01f, 1.89553395e-01f, 3.33579600e-01f, 2.71139562e-01f, -2.38125473e-01f, 1.34748116e-01f, 4.38059598e-01f, -1.21265976e-02f, -4.17569764e-02f, 1.30122826e-01f,
  3.95009011e-01f, -6.24182940e-01f, -1.23960644e-01f, -6.68271407e-02f, 2.84881324e-01f, 1.69769272e-01f, -9.59785104e-01f, 2.64023870e-01f, 1.88673750e-01f, -2.94760838e-02f,
  1.21607646e-01f, -3.79942544e-02f, -1.43470196e-02f, -1.73186883e-01f, -1.25528201e-01f, -2.60967672e-01f, 3.67154747e-01f, 1.84832379e-01f, -7.25538954e-02f, -6.14723921e-01f,
  -4.44129966e-02f, -1.72786132e-01f, 1.23240046e-01f, 6.07985914e-01f, -2.81035513e-01f, -2.73426235e-01f, 6.25308692e-01f, -2.23313704e-01f, 4.69254076e-01f, 3.73138309e-01f,
  -3.11662525e-01f, -5.70592321e-02f, -3.44397336e-01f, 2.07396835e-01f, 2.81843394e-01f, 6.44318819e-01f, 4.53840971e-01f, -2.22520024e-01f, 7.89304674e-02f, 3.35474941e-03f,
  2.04111174e-01f, 1.50269255e-01f, -8.84352550e-02f, 4.29737359e-01f, 7.45709017e-02f, -6.51550233e-01f, 5.69013834e-01f, 1.13688178e-01f, -1.46527335e-01f, -8.76667164e-03f,
  5.34201562e-01f, -2.24197760e-01f, 1.48605660e-01f, 2.69962102e-01f, 4.69098449e-01f, -4.52331305e-01f, -7.04475790e-02f, -5.41427672e-01f, 1.56422868e-01f, 1.80114225e-01f,
  2.52036512e-01f, -6.74640417e-01f, 2.54472345e-01f, 7.53010690e-01f, 3.53590250e-01f, 3.72790769e-02f, 2.37111166e-01f, 1.64180592e-01f, -1.99872833e-02f, -9.27485108e-01f,
  4.19463217e-01f, -6.80729628e-01f, -3.79781395e-01f, -8.49886179e-01f, -4.92133558e-01f, 1.62209332e-01f, -3.02645564e-01f, -5.02614677e-02f, -1.90590635e-01f, 2.28030056e-01f,
  1.31659746e-01f, -2.43708938e-01f, -2.69129843e-01f, 5.76478660e-01f, 4.01458740e-01f, 4.24896032e-01f, -2.49760821e-01f, 1.67562515e-01f, -2.27072626e-01f, 6.82960033e-01f,
  1.70067698e-01f, -1.47276372e-01f, -4.30673301e-01f, 7.42008030e-01f, -5.64344645e-01f, -1.05736125e+00f, 3.35514128e-01f, -1.14405330e-03f, -1.06921770e-01f, 1.76365092e-01f,
  -3.13143760e-01f, 3.92018467e-01f, 7.14018941e-02f, 1.63069665e-02f, -7.46084005e-02f, 2.47788399e-01f, 2.24742517e-02f, 6.14924490e-01f, -3.17352079e-02f, 2.81714648e-01f,
  1.26332909e-01f, 5.02380282e-02f, 2.14108840e-01f, 1.04350261e-01f, 4.78188917e-02f, 6.31732717e-02f, 1.32294253e-01f, 2.78328687e-01f, 8.80593285e-02f, 7.02308774e-01f,
  1.36582002e-01f, -3.83965224e-01f, 5.31837821e-01f, -2.82281429e-01f, 4.11741406e-01f, -1.38248339e-01f, -2.19200879e-01f, -2.12047577e-01f, -2.59431839e-01f, 2.01678768e-01f,
  2.26003364e-01f, 3.40542674e-01f, 7.53936470e-02f, -5.00682473e-01f, 4.46440801e-02f, -3.92514557e-01f, -1.15655713e-01f, -3.11852768e-02f, -8.02408829e-02f, 4.01409477e-01f,
  7.05108464e-01f, -3.12493235e-01f, 2.05293726e-02f, 4.69933361e-01f, -1.36253640e-01f, -1.83406338e-01f, 5.71845472e-01f, -1.18315972e-01f, -3.36945578e-02f, 3.57297778e-01f,
  2.13067248e-01f, -7.19654500e-01f, 4.10168171e-01f, -6.75806105e-01f, -6.81208670e-02f, 5.63075364e-01f, 2.52678216e-01f, -5.54957867e-01f, -1.75256684e-01f, 6.37222886e-01f,
  3.12999099e-01f, 2.52252877e-01f, 1.67389333e-01f, -1.00285411e-01f, 2.64182985e-01f, -2.58632123e-01f, 4.29116078e-02f, -1.13541394e-01f, 1.51772469e-01f, -9.19209719e-02f,
  3.07365745e-01f, 1.14598304e-01f, 4.30654101e-02f, -1.03237547e-01f, -2.40100577e-01f, 2.93895513e-01f, 2.40209848e-01f, 2.57652998e-01f, 1.00769155e-01f, -1.09601863e-01f,
  7.58783147e-02f, 4.45658624e-01f, 4.03649360e-01f, -3.29752475e-01f, 4.10455078e-01f, -5.18135369e-01f, -5.77162504e-01f, -2.34707799e-02f, 4.15424526e-01f, -7.87355483e-01f,
  6.42905474e-01f, 6.06627822e-01f, 7.35845745e-01f, -9.63436514e-02f, 3.84344578e-01f, -2.44691670e-01f, -7.21217915e-02f, -4.96554136e-01f, 3.47757012e-01f, 2.21366033e-01f,
  3.07891101e-01f, -5.46582453e-02f, 1.78783849e-01f, -3.74365121e-01f, 2.43518084e-01f, 5.37363231e-01f, -1.65216610e-01f, 3.00369352e-01f, -8.75356644e-02f, -1.33218035e-01f,
  4.13811386e-01f, -3.79452944e-01f, 3.36727887e-01f, 3.91195297e-01f, 3.29838961e-01f, -4.49170738e-01f, -1.65887550e-01f, -6.02615058e-01f, 2.47890323e-01f, 4.67541426e-01f,
  -2.81677306e-01f, 3.67972478e-02f, -6.58774972e-01f, 2.16954902e-01f, -2.43252646e-02f, 5.65936029e-01f, 4.33531851e-01f, 6.94008023e-02f, 4.14658874e-01f, 2.41394546e-02f,
  6.75691485e-01f, -2.51028895e-01f, 3.26971039e-02f, -2.02562004e-01f, 3.58582065e-02f, 5.50256550e-01f, -4.62902844e-01f, -3.91041040e-02f, 2.22303495e-01f, 2.57598788e-01f,
  6.24240041e-01f, 1.44308776e-01f, 1.64822981e-01f, 4.91834760e-01f, 4.59586591e-01f, 8.91474411e-02f, -7.66344741e-02f, -3.53679210e-02f, 1.01274028e-02f, 1.37517080e-01f,
  3.80889207e-01f, -2.46829152e-01f, 4.81148690e-01f, 2.07699299e-01f, -1.57278299e-01f, -4.59304273e-01f, 6.44305229e-01f, 1.01462513e-01f, -4.75036949e-02f, 7.21290149e-03f,
  2.01709121e-01f, -2.41925716e-01f, 3.93709302e-01f, -5.09136796e-01f, -6.98853284e-02f, -2.25303799e-01f, -4.15230691e-01f, 3.16554189e-01f, -1.35799572e-01f, 5.10247827e-01f,
  3.83310199e-01f, -4.44860756e-01f, 1.06174462e-02f, -2.10588530e-01f, -1.15032308e-03f, 1.39402926e-01f, 5.40974438e-02f, 1.03179708e-01f, 3.56973141e-01f, 1.74488142e-01f,
  -3.08910251e-01f, -2.49599099e-01f, -1.78112343e-01f, -4.15121704e-01f, -2.62219399e-01f, -6.38625085e-01f, 4.20751363e-01f, 3.08517456e-01f, -2.40015134e-01f, 5.04933417e-01f,
  5.29336870e-01f, 3.04955542e-02f, -2.87167877e-01f, 1.36825368e-01f, -5.33734122e-03f, 4.12077785e-01f, -1.48386747e-01f, 3.55716944e-01f, 3.67043912e-01f, -3.41930427e-02f,
  2.00126115e-02f, -3.24973434e-01f, -4.07365896e-02f, -2.64694154e-01f, 3.10701519e-01f, 5.28506152e-02f, -2.36064062e-01f, 4.72898155e-01f, 5.03649950e-01f, 3.47299516e-01f,
  3.20199504e-02f, 4.10605043e-01f, -2.90052980e-01f, -2.98697829e-01f, 2.63390869e-01f, -3.51341724e-01f, 4.75285739e-01f, -4.51510012e-01f, 2.92667270e-01f, -2.25213945e-01f,
  -1.84113327e-02f, 4.43339825e-01f, 5.50281346e-01f, -2.31335163e-01f, -2.62323380e-01f, 4.97289561e-02f, 6.09714985e-01f, -1.48194417e-01f, -2.27197677e-01f, 8.13562647e-02f,
  1.17412433e-01f, 4.28238541e-01f, 3.02886307e-01f, 3.27516109e-01f, -1.02793731e-01f, -2.93018818e-01f, -1.86927393e-01f, 5.69095872e-02f, -2.17390463e-01f, -1.64363936e-01f,
  -3.37850958e-01f, -4.68215197e-02f, 8.53418112e-02f, 3.58995944e-01f, -1.16913937e-01f, -1.10806897e-01f, -5.36769629e-01f, 5.47337011e-02f, -5.72159886e-01f, -3.95090692e-02f,
  1.90852642e-01f, 2.47096382e-02f, -3.34554374e-01f, 2.50425190e-01f, 1.11784033e-01f, 2.00404048e-01f, -3.84151116e-02f, 3.45823228e-01f, 1.08001806e-01f, 6.02301300e-01f,
  2.35264003e-01f, 4.76119369e-01f, 2.74581641e-01f, -1.22635655e-01f, 2.17527688e-01f, -5.30052483e-02f, -1.14771359e-01f, 7.24989891e-01f, 9.38534290e-02f, 6.73212782e-02f,
  4.35586274e-01f, -2.93270946e-01f, -4.24734592e-01f, 3.65519315e-01f, -5.47937572e-01f, -3.07420552e-01f, 4.19557601e-01f, 9.10326421e-01f, 4.52240378e-01f, 2.44105637e-01f,
  2.89350867e-01f, 2.01534525e-01f, -5.19051075e-01f, -3.62343967e-01f, 3.67018878e-01f, -2.12275267e-01f, 5.73365251e-03f, 4.18009788e-01f, -2.31702417e-01f, 6.87614441e-01f,
  -1.89688563e-01f, 1.26459464e-01f, 2.84286529e-01f, 2.95350403e-01f, 2.38297150e-01f, 5.67823410e-01f, -2.97084421e-01f, 1.55884877e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -3.53948362e-02f, 2.90747225e-01f, 1.57225415e-01f, 7.66071081e-02f, 1.14863321e-01f, 2.49602556e-01f, 3.05380542e-02f, 1.76590428e-01f, 1.35158703e-01f, 2.66891003e-01f,
  2.40029786e-02f, -6.24086373e-02f, 7.97014385e-02f, 1.70545205e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.77969629e-01f, -5.38943708e-01f, 2.32194781e-01f, -2.01281205e-01f, 1.01131126e-01f, 2.91244954e-01f, -2.23080203e-01f, 9.46738645e-02f, -3.55048542e-04f, -5.29281318e-01f,
  7.62274861e-01f, 5.27841806e-01f, -1.58440173e-01f, -1.63725942e-01f, 2.72337317e-01f, 2.01118231e-01f, -3.70701134e-01f, -1.88720655e-02f, -5.61301112e-01f, -1.93704292e-01f,
  4.43989009e-01f, -9.57245380e-03f, -5.92596382e-02f, -4.68977660e-01f, -4.73768741e-01f, -6.21475995e-01f, -2.51166701e-01f, -3.63962144e-01f, 2.87876040e-01f, -1.36647075e-01f,
  2.08293483e-01f, 1.40423924e-01f, -6.85158223e-02f, -1.98820069e-01f, -4.20260392e-02f, -5.69147579e-02f, 3.09506357e-01f, -3.58172834e-01f, -1.21098638e-01f, -2.68834606e-02f,
  -4.02190089e-01f, -1.56388637e-02f, -6.53847605e-02f, 5.25705993e-01f, -4.67311218e-02f, 2.21332654e-01f, 2.06653923e-01f, 6.79720417e-02f, 2.08631709e-01f, -3.62187862e-01f,
  1.86437204e-01f, 5.28064594e-02f, 4.54845913e-02f, -3.21956575e-01f, -3.38013560e-01f, 1.56292215e-01f, 9.40419957e-02f, 7.28678778e-02f, 3.51278596e-02f, -5.29553890e-01f,
  8.97515565e-02f, 1.94311708e-01f, 2.01610819e-01f, -6.91283941e-01f, 4.60379750e-01f, -4.78743792e-01f, 4.49742675e-01f, 1.73925474e-01f, 3.13333005e-01f, 2.38203362e-01f,
  7.31327116e-01f, -3.79284173e-02f, -8.45099390e-02f, 3.70536931e-02f, 4.14745599e-01f, 5.40084600e-01f, -1.70797706e-01f, 6.45453036e-01f, 3.46989125e-01f, 4.29621279e-01f,
  6.00030422e-01f, 3.75524312e-01f, 2.32243061e-01f, -2.63432682e-01f, -2.79364437e-01f, -6.58379853e-01f, -1.42885707e-02f, -5.62838137e-01f, 2.07204461e-01f, -5.64075589e-01f,
  4.10374135e-01f, 1.96054161e-01f, -2.72815108e-01f, 3.53260577e-01f, -2.05203965e-01f, 2.12013330e-02f, 9.39193666e-02f, 3.80860835e-01f, 1.96864218e-01f, 2.80414999e-01f,
  -2.84260094e-01f, -2.00275555e-01f, 1.64363101e-01f, 3.57511267e-02f, 5.61147809e-01f, 2.34282434e-01f, -9.79512632e-02f, -3.31157714e-01f, -2.39923552e-01f, 5.24440348e-01f,
  1.71567276e-02f, 4.48902965e-01f, -5.72730422e-01f, -8.14680308e-02f, -4.46649373e-01f, 6.89539313e-01f, -8.01853061e-01f, -1.11970484e-01f, 3.42812598e-01f, -2.83069223e-01f,
  -6.10091925e-01f, -6.93792462e-01f, -8.68320107e-01f, -6.28384650e-02f, -1.87776446e-01f, -7.44507968e-01f, 1.27864972e-01f, 4.08753604e-01f, 4.85900074e-01f, 6.94098294e-01f,
  7.95855299e-02f, 2.38038450e-01f, -2.87479311e-01f, 4.42179799e-01f, 2.63549179e-01f, 4.22975361e-01f, -1.47010118e-01f, 2.26756800e-02f, -5.88420272e-01f, -6.82773113e-01f,
  5.14618516e-01f, -5.99019825e-01f, -5.66911101e-01f, -3.72007698e-01f, -2.51149595e-01f, -5.51134706e-01f, 1.45277753e-01f, -4.87312585e-01f, -1.96219042e-01f, -1.19878113e-01f,
  3.28467101e-01f, -2.88080871e-01f, 7.67292678e-02f, -9.72153619e-02f, 1.45153508e-01f, -5.49030066e-01f, 5.67393228e-02f, -3.65722150e-01f, 5.09818122e-02f, 2.56202102e-01f,
  1.17580757e-01f, 3.69555652e-01f, -5.85629165e-01f, 3.18351835e-01f, -6.29916191e-01f, -6.61805153e-01f, -3.21405590e-01f, -1.16149150e-01f, -3.70145828e-01f, 5.21253586e-01f,
  -2.93139130e-01f, -6.07562251e-02f, 4.00015265e-01f, -8.27600509e-02f, 1.92095175e-01f, 2.69166119e-02f, 2.92923003e-01f, -1.80112958e-01f, 2.86882609e-01f, 2.47253388e-01f,
  7.61370957e-02f, -3.59542638e-01f, 3.41544002e-01f, 4.14344762e-03f, -4.28108066e-01f, -6.92991674e-01f, 7.55959973e-02f, -3.17631453e-01f, 1.59877539e-01f, 2.82841086e-01f,
  7.28079304e-02f, -2.09349275e-01f, 4.50248085e-02f, 5.21588802e-01f, -6.61761224e-01f, -8.03887099e-03f, -4.15973753e-01f, 1.73769772e-01f, 1.08242296e-02f, 5.23823082e-01f,
  -6.38132319e-02f, 5.08359790e-01f, 5.59089243e-01f, 6.17910177e-02f, -1.49892807e-01f, -3.87722626e-02f, -1.54117867e-01f, 5.26360810e-01f, -1.34523839e-01f, 8.22738335e-02f,
  -1.54401109e-01f, -1.89806730e-01f, -1.45673245e-01f, 5.92780173e-01f, -6.99096739e-01f, -6.76943064e-01f, 8.06030482e-02f, 3.97208929e-01f, 1.96984977e-01f, 9.77582783e-02f,
  -3.42770576e-01f, 6.05389336e-03f, -2.73876399e-01f, -4.55738068e-01f, -2.70807564e-01f, -1.13049395e-01f, 1.94055274e-01f, 1.42197236e-01f, -5.17316274e-02f, -2.01355353e-01f,
  -4.45065014e-02f, -1.65513277e-01f, 1.82576329e-02f, 1.07004994e-03f, -2.49259844e-02f, -2.61159450e-01f, -2.99656596e-02f, -7.53574520e-02f, -2.79646575e-01f, 1.34828374e-01f,
  -1.14187278e-01f, -2.41722122e-01f, -6.11815639e-02f, 4.18696821e-01f, -3.59663606e-01f, -1.71250612e-01f, -4.81263041e-01f, -1.03322059e-01f, 4.86874133e-01f, 4.34517354e-01f,
  4.01107371e-02f, -1.89109981e-01f, 1.01310924e-01f, -9.16860044e-01f, -6.87842891e-02f, -7.69026279e-02f, -3.96111518e-01f, -5.52756548e-01f, -4.31347281e-01f, -5.14771581e-01f,
  -1.32834598e-01f, 5.69194317e-01f, 2.32496530e-01f, -2.30127856e-01f, 3.83165538e-01f, -1.68465883e-01f, -6.96412027e-01f, -5.10281742e-01f, -4.35245812e-01f, 3.40388894e-01f,
  8.94120708e-02f, -4.83853728e-01f, 5.25092483e-01f, 1.36775866e-01f, 2.28480637e-01f, 1.85221598e-01f, 4.43256497e-01f, -4.29147393e-01f, 2.09172264e-01f, 4.76057708e-01f,
  -1.28221899e-01f, -3.68289500e-01f, -1.81224391e-01f, 2.31417149e-01f, -5.75942636e-01f, -1.92554951e-01f, -3.26443970e-01f, 6.36327779e-03f, -1.23716131e-01f, -1.09317154e-01f,
  3.46194983e-01f, 4.30627674e-01f, -9.39749256e-02f, -2.82635957e-01f, -1.15438633e-01f, 8.77582878e-02f, 2.91547865e-01f, 4.00494993e-01f, 2.59441346e-01f, -5.29524148e-01f,
  -2.57378995e-01f, -9.11930740e-01f, -4.92603153e-01f, 9.13225710e-02f, -6.77012265e-01f, 1.12262867e-01f, 1.65126219e-01f, -4.09564734e-01f, -5.80169916e-01f, -3.24690372e-01f,
  2.23333880e-01f, -2.28209645e-01f, -2.62127101e-01f, 2.69950092e-01f, -1.96367249e-01f, 4.32542950e-01f, -3.15132588e-01f, 2.82875925e-01f, -2.95016259e-01f, -1.16479933e-01f,
  3.82707328e-01f, -5.00676095e-01f, 2.98456520e-01f, -8.28467980e-02f, 1.37679189e-01f, 6.97839707e-02f, 4.69171017e-01f, -1.55470446e-01f, -1.94220260e-01f, -5.52421331e-01f,
  -2.67081946e-01f, 2.18191504e-01f, 3.87304366e-01f, 3.16340059e-01f, -1.97538942e-01f, -1.76071286e-01f, -5.24125457e-01f, 2.03992441e-01f, -1.88798264e-01f, -4.52816248e-01f,
  -9.18496549e-01f, -1.14054196e-01f, 1.94679707e-01f, -1.57351255e-01f, -1.02085817e+00f, 6.53188396e-03f, -9.43190873e-01f, -4.73776609e-01f, 5.11840165e-01f, 3.23928714e-01f,
  3.82282913e-01f, -2.48533159e-01f, -1.31975189e-01f, 4.39036846e-01f, 4.15486068e-01f, -2.04209924e-01f, 4.10072088e-01f, -3.47377807e-01f, 1.89924151e-01f, -3.03351164e-01f,
  -7.04733357e-02f, -4.88330901e-01f, -1.71831816e-01f, 1.78184032e-01f, -3.61111909e-02f, -4.54557799e-02f, 5.17884910e-01f, -6.35250568e-01f, 1.79325834e-01f, 5.56286514e-01f,
  -3.40033919e-01f, -3.83920431e-01f, 1.00549437e-01f, 5.60279310e-01f, -1.05759576e-01f, 1.06748998e-01f, 2.16336206e-01f, -2.02340409e-01f, 3.74686748e-01f, 1.09127246e-01f,
  -4.15450782e-02f, 1.63984463e-01f, -6.09562576e-01f, -3.15529466e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.03793049e-01f, 2.29192842e-02f, -3.43705527e-02f, 1.49448514e-01f, -5.45805953e-02f, -5.99059314e-02f, 2.07301155e-01f, -3.18246111e-02f, 2.48249769e-02f, 1.60693347e-01f,
  9.66338292e-02f, 1.19098306e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    