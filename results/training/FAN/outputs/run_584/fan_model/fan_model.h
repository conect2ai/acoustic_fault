/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.47395924e-01f, 1.10360794e-01f, 4.50730175e-01f, 2.04503372e-01f, 1.24314047e-01f, -2.54889101e-01f, -3.26634198e-01f, -2.00848609e-01f, 6.45687357e-02f, 1.13111183e-01f,
  1.04378268e-01f, -1.23958677e-01f, -5.63983880e-02f, -1.39278799e-01f, -1.56927124e-01f, 5.58894537e-02f, 2.87138522e-01f, -3.07081472e-02f, -3.18969697e-01f, -2.42615446e-01f,
  -1.89682111e-01f, 4.02687676e-02f, 2.37356424e-01f, 2.25192532e-02f, 1.68398798e-01f, -1.07858859e-01f, 3.46168637e-01f, 2.77361035e-01f, 1.33649126e-01f, 4.95722890e-01f,
  1.86542347e-01f, 3.05790335e-01f, -1.21948332e-01f, 1.05873115e-01f, 2.21437022e-01f, 5.02612665e-02f, 5.10433465e-02f, 9.54898819e-02f, 8.50386992e-02f, 6.33909404e-02f,
  1.72231466e-01f, 1.78057820e-01f, 1.44488186e-01f, 5.52921221e-02f, 7.83542246e-02f, -1.24269733e-02f, 7.96245635e-02f, 1.38010383e-01f, 1.10156685e-01f, 6.31982833e-02f,
  4.61155213e-02f, 2.83688754e-01f, 7.00695887e-02f, -4.48483638e-02f, -7.09299324e-03f, 1.11367047e-01f, 3.42298299e-02f, 1.24478452e-01f, 3.99933197e-02f, -8.43732525e-03f,
  -1.04993246e-01f, 4.27043326e-02f, 5.08566722e-02f, -2.73976438e-02f, -7.59393722e-02f, -1.69343166e-02f, -4.49186796e-03f, -4.78804000e-02f, -3.01189646e-02f, 7.82268047e-02f,
  -8.11183676e-02f, -3.73577029e-02f, 6.54450059e-03f, 4.37711999e-02f, 5.17731383e-02f, 1.23365857e-01f, -1.24590285e-02f, 2.02177204e-02f, -2.37493459e-02f, -5.51565958e-04f,
  3.58985327e-02f, -1.70509256e-02f, 1.21237263e-01f, -1.21315131e-02f, 5.86161427e-02f, 4.82263491e-02f, 6.28787056e-02f, 3.92214488e-03f, -1.81782953e-02f, 7.52268955e-02f,
  -1.46754354e-01f, 4.56532836e-02f, 9.91976857e-02f, -4.09412310e-02f, 1.54427096e-01f, 7.62915090e-02f, 1.09679669e-01f, 6.28567040e-02f, 9.44003388e-02f, -2.64949817e-02f,
  4.98962663e-02f, 1.53344087e-02f, 1.04367293e-01f, 5.91694601e-02f, -8.56263414e-02f, -2.34774463e-02f, 1.09987877e-01f, 1.44524435e-02f, 1.65103730e-02f, 3.93364616e-02f,
  5.44268526e-02f, -1.33410897e-02f, -1.29579425e-01f, -1.47563532e-01f, -1.18047640e-01f, -1.32539526e-01f, -1.05588004e-01f, -1.38481617e-01f, -1.56480044e-01f, -2.02770323e-01f,
  -9.28360999e-01f, -9.45252925e-03f, 2.16615829e-03f, -1.31755963e-01f, 5.42253256e-01f, 5.76721542e-02f, -9.75692570e-02f, -3.42701107e-01f, -1.59676880e-01f, -1.80861875e-01f,
  1.59366608e-01f, 3.03100944e-01f, 1.17483065e-01f, 1.58850834e-01f, -3.67590964e-01f, -9.47854016e-03f, 1.59575284e-01f, -1.44716650e-01f, -2.41016045e-01f, 4.14899401e-02f,
  2.96728969e-01f, -2.56671518e-01f, -6.04416430e-01f, -1.94847807e-01f, 3.89568865e-01f, 2.69915551e-01f, 5.62825315e-02f, 1.13721691e-01f, 2.30821416e-01f, 3.94472837e-01f,
  1.82619274e-01f, -3.68491597e-02f, 3.70104727e-03f, 2.55313870e-02f, 1.06082946e-01f, -1.68928981e-01f, 3.43924463e-02f, -8.37756246e-02f, 2.27765143e-02f, -1.00024141e-01f,
  1.34503171e-01f, 3.77806425e-02f, 1.23270236e-01f, 1.26584604e-01f, -7.78988823e-02f, 2.50625405e-02f, -1.43634737e-01f, -1.99440986e-01f, -9.07554105e-03f, 6.52340502e-02f,
  2.26962134e-01f, 1.43957332e-01f, 9.15195867e-02f, -9.23539102e-02f, -1.69770733e-01f, 9.10171028e-03f, 7.51956925e-03f, -4.38302010e-02f, -5.21092080e-02f, -7.27316886e-02f,
  -1.57720242e-02f, -2.56180409e-02f, 3.72668467e-02f, 4.16294904e-03f, -9.55819385e-04f, -5.72767816e-02f, 2.30964161e-02f, 4.72798347e-02f, -1.48852225e-02f, -7.34077841e-02f,
  6.94571137e-02f, 1.82952993e-02f, -3.37172598e-02f, -7.42933378e-02f, 7.31487200e-02f, -1.66075467e-03f, 3.22591290e-02f, -8.43061209e-02f, 1.20486230e-01f, -3.30728479e-02f,
  -3.32936607e-02f, 2.80400813e-02f, 9.88559332e-03f, -8.77748206e-02f, 7.58136958e-02f, -4.22381349e-02f, -6.50370214e-03f, 5.62132969e-02f, -4.44211923e-02f, -1.80868190e-02f,
  -1.01295218e-01f, -8.24053809e-02f, 2.87271384e-02f, -4.31681126e-02f, 8.58574808e-02f, -2.29268335e-02f, 7.57929534e-02f, 5.12397625e-02f, 6.11279793e-02f, 1.63811296e-02f,
  -4.06722873e-02f, -1.56975329e-01f, -5.13291322e-02f, -4.40088399e-02f, -3.74623947e-02f, -6.32664710e-02f, -1.01099145e-02f, 1.43084258e-01f, -5.47964759e-02f, 6.53044507e-02f,
  -5.73346652e-02f, -2.61584446e-02f, -5.20942472e-02f, -3.80922407e-02f, 6.65781274e-02f, 1.55492604e-01f, 1.20239615e-01f, 8.71111453e-02f, -5.33830673e-02f, -1.22288875e-01f,
  -4.81988311e-01f, 6.12888038e-01f, 5.46810925e-01f, -5.17834008e-01f, -3.53615820e-01f, -4.74512465e-02f, 4.43189204e-01f, 1.15121141e-01f, -5.25747359e-01f, 2.13299263e-02f,
  -1.81340531e-01f, -2.13588387e-01f, 4.51957202e-03f, 2.22030014e-01f, 3.38477522e-01f, 5.32589614e-01f, 3.07672799e-01f, 2.38370419e-01f, -5.19189350e-02f, -2.68228650e-01f,
  -5.68553209e-02f, -2.23023951e-01f, -2.77891308e-01f, -3.62897217e-02f, -1.22194603e-01f, -1.62324071e-01f, 1.75450072e-01f, -1.51807219e-01f, 2.54313529e-01f, 4.48327184e-01f,
  2.89578229e-01f, 1.75303325e-01f, -5.28087504e-02f, -1.09751761e-01f, -8.31106007e-02f, 1.20005347e-02f, -1.57792363e-02f, -9.41709802e-02f, -4.30534109e-02f, -1.06270984e-02f,
  -3.87190245e-02f, -5.61154857e-02f, -4.50782925e-02f, 6.99878950e-03f, -3.68166082e-02f, -4.20434494e-03f, 4.37135808e-02f, 2.15489313e-01f, 1.91339880e-01f, 9.95392725e-02f,
  1.41956797e-02f, -3.91324982e-02f, 2.85177510e-02f, 9.18957219e-02f, 1.32640705e-01f, -5.16447239e-02f, 5.44330776e-02f, 4.95645553e-02f, 8.89893249e-02f, -4.69746850e-02f,
  -3.98226902e-02f, -7.06907734e-02f, 8.22329894e-02f, 2.19700057e-02f, -1.23852575e-02f, -6.94215996e-03f, 5.44465557e-02f, -2.50422303e-02f, 1.56872510e-03f, -2.77902205e-02f,
  3.54238041e-02f, -1.79627296e-02f, 3.29675041e-02f, 3.65116671e-02f, -3.15046161e-02f, -1.39714796e-02f, 8.51028860e-02f, 1.75097818e-03f, -6.23969249e-02f, 1.20842466e-02f,
  -2.52779201e-02f, 1.18761711e-01f, -8.04082975e-02f, 1.15716688e-01f, 6.21789806e-02f, -1.10586090e-02f, -3.70406522e-03f, -3.35440342e-03f, -9.44583490e-02f, -9.25390944e-02f,
  -2.77896613e-01f, 3.94678637e-02f, -4.97685410e-02f, 1.76482096e-01f, -2.33667120e-02f, -5.00936946e-03f, -4.33278643e-02f, 1.33891432e-02f, -5.15997224e-02f, 7.27561722e-03f,
  8.55227485e-02f, 5.47115579e-02f, 2.50288881e-02f, 7.96535462e-02f, -1.54303700e-01f, -5.94968088e-02f, -1.20159246e-01f, 2.01227143e-02f, 2.96517964e-02f, -5.84376901e-02f,
  3.04552820e-02f, -8.42403322e-02f, -1.49474412e-01f, -2.31684558e-02f, -1.13611430e-01f, -1.41837001e-01f, 2.18110345e-02f, -5.41113876e-02f, -1.02176946e-02f, -2.58638829e-01f,
  3.45540375e-01f, 5.87069727e-02f, 4.88560200e-01f, 2.19682664e-01f, -1.14316575e-01f, -2.98191130e-01f, -3.78488541e-01f, -1.15904145e-01f, 1.53893590e-01f, 1.88436970e-01f,
  1.63327798e-01f, -1.00949883e-01f, 7.85948485e-02f, -5.32396883e-02f, 3.55793349e-02f, 1.80000644e-02f, 6.56212866e-02f, -2.57214233e-02f, -3.67512554e-01f, -4.64149565e-01f,
  -4.07268733e-01f, -1.85024604e-01f, 1.67504430e-01f, 3.89385857e-02f, 6.46850988e-02f, -1.65073976e-01f, 3.58950049e-01f, 1.14956386e-01f, -6.80973008e-02f, -7.89994746e-02f,
  1.67406514e-01f, 4.14992660e-01f, -4.55031544e-02f, 1.01944052e-01f, 2.40657151e-01f, 1.04899868e-01f, 5.33476919e-02f, 2.98821032e-01f, 9.11580101e-02f, 1.60272837e-01f,
  1.51939183e-01f, 7.65198916e-02f, 3.33312005e-02f, 1.19661447e-02f, 9.57642868e-02f, 6.61349595e-02f, 2.10040852e-01f, 2.96780199e-01f, 9.67811346e-02f, 1.53778613e-01f,
  -4.40641455e-02f, 1.94538161e-02f, 2.53679961e-01f, 7.13876635e-02f, 1.78418651e-01f, 1.19836159e-01f, 1.42264828e-01f, 1.60239652e-01f, 2.22385228e-01f, 2.25853875e-01f,
  1.72924027e-01f, 6.94331750e-02f, 4.00681561e-03f, -1.46577703e-02f, -1.35172233e-01f, -7.74782524e-02f, -2.45322846e-02f, -1.99218586e-01f, -5.70942573e-02f, -8.31740275e-02f,
  -5.91246039e-02f, 5.84660284e-03f, -4.91015688e-02f, -5.90648204e-02f, -9.21363682e-02f, -5.67723401e-02f, -2.47327119e-01f, -9.71744508e-02f, -1.02254368e-01f, -1.52177110e-01f,
  -3.76487263e-02f, -1.39897034e-01f, -7.57117420e-02f, -1.49976641e-01f, -9.62422788e-02f, -7.00213090e-02f, -9.67892334e-02f, -1.11751370e-01f, -3.92031632e-02f, 1.46546792e-02f,
  9.84582901e-02f, 9.64802057e-02f, 1.39850751e-01f, 9.50963721e-02f, 2.37650834e-02f, 9.31299701e-02f, 8.95214155e-02f, 9.74586606e-02f, 9.32065845e-02f, -2.91029382e-02f,
  -5.94101055e-03f, -6.66280976e-03f, 1.74245670e-01f, 1.12658711e-02f, -8.45406651e-02f, 4.35335562e-02f, -4.91174832e-02f, -1.49232736e-02f, 5.97406439e-02f, 5.83790150e-03f,
  1.00979015e-01f, -6.96750805e-02f, -1.04893833e-01f, 5.39546646e-02f, 1.57657769e-02f, -1.12922691e-01f, 1.50076002e-02f, -7.47226849e-02f, -9.77591500e-02f, -1.10821791e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.25025403e-01f, 4.01390553e-01f, 6.11103058e-01f, 4.09971401e-02f, 4.09529537e-01f, 1.74308538e-01f, 7.76552260e-01f, 2.17932448e-01f, -5.97672760e-02f, 4.65990722e-01f,
  -2.77775019e-01f, -1.22251177e+00f, -8.27480197e-01f, -8.71995211e-01f, -6.67904735e-01f, 1.80128008e-01f, 8.96522254e-02f, -4.30597097e-01f, -6.84889793e-01f, -2.44965553e-01f,
  -4.69014078e-01f, 6.35721684e-01f, 5.08033454e-01f, -1.71387017e-01f, 2.48344481e-01f, -4.13974941e-01f, 6.86259151e-01f, 5.23667991e-01f, -1.20526344e-01f, -3.44902486e-01f,
  -4.02695946e-02f, 8.52215111e-01f, -3.54508221e-01f, -5.28703094e-01f, -1.21768236e-01f, -1.68985590e-01f, -8.30229446e-02f, 7.02542765e-03f, -3.18425208e-01f, 1.77383441e-02f,
  -1.28808305e-01f, -2.83979088e-01f, -4.24067885e-01f, 1.31516561e-01f, 2.13619962e-01f, -2.04159230e-01f, -6.20833710e-02f, -2.93287694e-01f, -3.41092318e-01f, -2.07199350e-01f,
  -5.20748734e-01f, 1.79704368e-01f, 4.21344727e-01f, -9.41654816e-02f, -1.89130023e-01f, -3.80897999e-01f, 9.67879966e-02f, -5.26963733e-02f, -1.47120640e-01f, 3.03670228e-01f,
  -1.93725359e-02f, 1.45585686e-01f, 2.16701422e-02f, 1.46500424e-01f, -8.95018652e-02f, -4.04596664e-02f, 7.86421970e-02f, 4.58380841e-02f, -3.41643840e-02f, 3.15825194e-01f,
  -1.90558985e-01f, -4.66155969e-02f, 3.41070369e-02f, 4.03947532e-02f, -1.31899655e-01f, 1.40310019e-01f, 8.21333472e-03f, 6.29735063e-04f, -2.02391088e-01f, 6.94807023e-02f,
  -7.58714899e-02f, 4.54549231e-02f, 1.20974287e-01f, -2.47334272e-01f, 1.08279273e-01f, -9.08937007e-02f, -1.69579871e-02f, -2.53563136e-01f, -4.08273935e-02f, 1.52174413e-01f,
  8.06261413e-03f, -5.01295388e-01f, 2.27934550e-02f, -6.06051572e-02f, 1.11342542e-01f, -9.63528678e-02f, 4.95709702e-02f, 3.56218740e-02f, 1.99661225e-01f, -1.10094145e-01f,
  -4.59529981e-02f, -2.24489257e-01f, 1.65473938e-01f, 6.36352301e-02f, 1.23727843e-01f, 1.30697325e-01f, -2.52781510e-01f, -1.98873848e-01f, -9.91865396e-02f, 2.40706891e-01f,
  5.33839092e-02f, 2.50390440e-01f, 2.29063272e-01f, 4.10096422e-02f, -7.29916990e-02f, 3.32334824e-02f, 3.58277828e-01f, 5.88182695e-02f, -6.53336644e-02f, 5.26290715e-01f,
  1.36751580e+00f, -1.30154103e-01f, -1.23690522e+00f, 8.57993484e-01f, -1.01432490e+00f, -1.21844089e+00f, -1.43703115e+00f, -2.34972432e-01f, 5.73963284e-01f, -1.73933983e-01f,
  -5.66638350e-01f, 1.08095728e-01f, -1.81058928e-01f, -1.56859547e-01f, -1.81936875e-01f, -4.45530295e-01f, -1.55190542e-01f, -6.87712878e-02f, -3.78006458e-01f, 2.09838718e-01f,
  3.33124280e-01f, 5.60914814e-01f, 9.69151676e-01f, 2.53219038e-01f, 3.24802458e-01f, -1.95508331e-01f, -1.70375928e-01f, 4.04709041e-01f, -3.94113600e-01f, 5.89217424e-01f,
  -3.03964227e-01f, -9.60033759e-02f, -5.71066022e-01f, 1.30205080e-01f, 1.06236920e-01f, 3.18179280e-01f, -2.70081367e-02f, 2.93231070e-01f, -5.24585731e-02f, 1.99763596e-01f,
  -3.43473069e-02f, 1.09718166e-01f, 3.58920842e-02f, 5.37079806e-03f, 2.81909690e-03f, -5.08568287e-01f, 2.80911565e-01f, 2.17442706e-01f, -2.07911864e-01f, -8.25246274e-02f,
  -7.09385723e-02f, -1.18955918e-01f, -7.54326940e-01f, -6.15312576e-01f, -2.70021349e-01f, 6.99738115e-02f, -2.45903656e-01f, 2.29731277e-01f, -5.18605053e-01f, 8.05079520e-01f,
  1.31454006e-01f, 8.18137378e-02f, -6.94079623e-02f, 1.32255092e-01f, 1.42890722e-01f, 1.91035978e-02f, 4.34363745e-02f, 1.69476401e-02f, -1.44370005e-03f, 1.50625914e-01f,
  -2.94102490e-01f, 5.83399832e-02f, 8.25509280e-02f, -6.61735982e-02f, -1.60509452e-01f, -1.77976638e-02f, -1.02325343e-01f, 6.88480586e-02f, -3.18508856e-02f, -2.58412231e-02f,
  5.79269864e-02f, -1.39883548e-01f, 8.25275928e-02f, 1.54241294e-01f, -1.99269399e-01f, -7.97925889e-02f, 2.02185154e-01f, -1.07167877e-01f, 3.28906961e-02f, -7.22972453e-02f,
  2.46471107e-01f, -6.49808764e-01f, 2.32526168e-01f, 4.06873450e-02f, 4.33527716e-02f, -3.17696065e-01f, -9.81806815e-02f, 2.82198768e-02f, -2.20836848e-01f, -1.67286888e-01f,
  -2.55399704e-01f, -1.67115852e-01f, 9.32842940e-02f, -2.06446256e-02f, -5.45749031e-02f, -2.67960548e-01f, 9.72770005e-02f, -2.21918792e-01f, -1.64588779e-01f, 1.21758036e-01f,
  2.33064353e-01f, -3.13484669e-01f, -7.67039740e-03f, -3.07771415e-01f, 1.73603699e-01f, -4.85081285e-01f, -5.09036183e-01f, -2.28564918e-01f, -5.95668316e-01f, -9.53215435e-02f,
  1.01325941e+00f, -2.00424403e-01f, -8.63107085e-01f, 2.53735155e-01f, -3.60276878e-01f, -5.09321511e-01f, -1.25050986e+00f, -6.73281491e-01f, 8.98286179e-02f, -4.18316305e-01f,
  5.25430560e-01f, 1.36980677e+00f, 9.01263952e-01f, 3.97504658e-01f, -1.94866747e-01f, -9.48189020e-01f, -1.10077918e+00f, -4.55942631e-01f, -1.16659977e-01f, -1.46648541e-01f,
  3.68315876e-01f, -1.13457805e-02f, -1.55265227e-01f, -4.98307765e-01f, -3.61958258e-02f, 6.59993827e-01f, -2.64397979e-01f, 1.07589431e-01f, -2.46624038e-01f, -3.13141972e-01f,
  5.19505084e-01f, -5.59585631e-01f, -8.78857300e-02f, 9.65475887e-02f, 2.50998884e-01f, -1.89393565e-01f, -7.36104026e-02f, -2.28711694e-01f, -1.57695577e-01f, -2.79624730e-01f,
  4.18769091e-01f, 2.32968833e-02f, -1.43604338e-01f, 2.60296240e-02f, -5.57485104e-01f, -2.80988544e-01f, -6.09441042e-01f, -4.52984899e-01f, -1.07827470e-01f, -2.57972687e-01f,
  2.47069359e-01f, 7.60618225e-02f, -7.45890886e-02f, -4.93502051e-01f, -1.02190018e-01f, 3.07498246e-01f, -1.98761746e-01f, -3.26160550e-01f, -4.43138897e-01f, -3.78339797e-01f,
  6.58015460e-02f, 3.26122157e-02f, -3.15939561e-02f, 7.85517171e-02f, 1.75666511e-01f, 1.91585526e-01f, 1.08431190e-01f, 2.42851093e-01f, -1.78800359e-01f, 6.81590289e-02f,
  -5.18662371e-02f, 5.77663966e-02f, 1.02961501e-02f, -1.44744918e-01f, -3.57778510e-03f, -3.95996161e-02f, 4.58904989e-02f, -7.44940862e-02f, -1.19858213e-01f, -6.17466606e-02f,
  -1.10644978e-02f, 1.17598005e-01f, 1.86023265e-01f, 7.06892088e-02f, -2.00356513e-01f, -3.93204503e-02f, -1.19603083e-01f, 3.26114520e-02f, 3.37937381e-03f, -2.58132815e-01f,
  9.76707637e-01f, -5.73361255e-02f, 4.21788216e-01f, -4.70350385e-02f, -1.60175636e-01f, 4.26993100e-03f, 2.16235951e-01f, -7.06072673e-02f, 2.06652850e-01f, 9.85666588e-02f,
  -1.52215317e-01f, 1.88903183e-01f, 5.39963283e-02f, -8.11987072e-02f, -1.21099718e-01f, 4.13153693e-02f, -2.05021903e-01f, 1.33983344e-01f, -2.10609645e-01f, -2.60036349e-01f,
  -4.75484952e-02f, -8.79947394e-02f, 6.70061946e-01f, 4.61766958e-01f, 6.35657385e-02f, 5.32410204e-01f, 4.20060009e-01f, 2.15779051e-01f, 1.90467939e-01f, 4.16836679e-01f,
  2.76823401e-01f, 1.04408905e-01f, -1.18091309e+00f, -6.95224524e-01f, -9.02512312e-01f, -3.61790329e-01f, 1.78759664e-01f, 2.26982296e-01f, -1.17833409e-02f, -9.61334109e-02f,
  -1.34894758e-01f, 5.60236983e-02f, 4.53723818e-02f, -2.16590747e-01f, 4.00267065e-01f, -3.83007191e-02f, -3.31120908e-01f, -2.37728596e-01f, 4.57731560e-02f, -2.06576273e-01f,
  -2.04363987e-01f, -1.21006489e-01f, -1.31496405e-02f, -8.70727599e-02f, -5.96222043e-01f, 7.91452229e-02f, -2.98956066e-01f, -7.88931429e-01f, -1.29911080e-01f, -7.31174886e-01f,
  -3.49493414e-01f, -6.06734157e-01f, 1.65722296e-01f, 2.52851509e-02f, -9.87667069e-02f, 1.36732876e-01f, -4.35298942e-02f, -1.15786962e-01f, 1.58158675e-01f, -1.28132636e-02f,
  -2.49072120e-01f, -7.53454268e-02f, -4.19496633e-02f, 9.40549932e-03f, -2.43738890e-01f, -1.65275529e-01f, 5.01808226e-02f, 4.24952582e-02f, -1.14587761e-01f, -1.22195125e-01f,
  -1.29392281e-01f, -1.55366763e-01f, 1.55340016e-01f, 1.89176425e-01f, -1.21918984e-01f, -2.22399030e-02f, -7.49474317e-02f, -1.46996200e-01f, 2.74726981e-03f, 1.26501918e-01f,
  -1.12786807e-01f, 9.95495245e-02f, 7.19899014e-02f, 7.97927827e-02f, 2.05978394e-01f, 2.74287999e-01f, 1.10852763e-01f, 1.00134231e-01f, 8.73700008e-02f, 4.31605056e-02f,
  1.07595555e-01f, -3.89510170e-02f, 1.68580152e-02f, -1.43821567e-01f, -6.65623844e-02f, 2.91992314e-02f, 7.20181987e-02f, 4.58819456e-02f, 5.63043505e-02f, 2.08288938e-01f,
  -8.49427190e-03f, 7.75013417e-02f, -1.38737664e-01f, -6.59779925e-03f, -1.54218465e-01f, -7.29380697e-02f, -2.40448475e-01f, -6.55996501e-02f, 1.45799533e-01f, -1.61155641e-01f,
  3.70402247e-01f, -2.01407388e-01f, 3.49054225e-02f, 9.41730514e-02f, -7.52313882e-02f, 2.59052054e-03f, -3.21993887e-01f, 5.11296652e-03f, -1.14940941e-01f, -1.63223594e-01f,
  -2.44548157e-01f, -1.57401219e-01f, -8.11725482e-02f, 3.54991853e-02f, 1.54815271e-01f, 1.45038217e-02f, 3.22803468e-01f, 1.26750782e-01f, 4.87551019e-02f, -2.00881884e-01f,
  1.07844912e-01f, 4.19000357e-01f, 6.33599520e-01f, 4.95544732e-01f, 1.25866726e-01f, 3.94425243e-01f, 1.58467382e-01f, 1.86923876e-01f, 3.03573549e-01f, 5.83612680e-01f,
  8.76641572e-01f, 3.01910251e-01f, 2.11006343e-01f, 4.60111141e-01f, 4.34911400e-01f, 6.17316186e-01f, 7.61005878e-01f, 3.60549629e-01f, 2.21540987e-01f, 1.64111510e-01f,
  9.55243185e-02f, 5.34689911e-02f, 6.69774180e-03f, 8.76200348e-02f, 4.15091999e-02f, 2.52663225e-01f, 1.55331776e-01f, -2.56533325e-02f, -6.24254160e-02f, 1.10998631e-01f,
  9.52827930e-02f, -3.76320742e-02f, -2.21753761e-01f, -1.32200420e-01f, 2.59131324e-02f, -1.01499267e-01f, 6.62863255e-02f, 1.15476921e-01f, -2.79701166e-02f, -1.43739030e-01f,
  -1.27831459e-01f, 5.38967192e-01f, 8.37390348e-02f, -1.27119988e-01f, -5.76398000e-02f, -2.61444271e-01f, -1.09531628e-02f, -3.63841414e-01f, -3.02382201e-01f, -2.13474229e-01f,
  -1.11420661e-01f, -1.80031970e-01f, 5.68449683e-02f, -1.84055567e-01f, -2.45758146e-01f, -1.94943845e-01f, -6.90316707e-02f, 5.79679534e-02f, 2.97743250e-02f, -1.01293102e-01f,
  -1.40463784e-01f, -1.43677011e-01f, 5.99841438e-02f, 2.14282926e-02f, 1.84586048e-01f, 2.44093016e-02f, -4.26891772e-03f, 8.58336985e-02f, 8.11208412e-02f, 4.49242070e-02f,
  2.80400366e-01f, 1.05505057e-01f, 3.34832668e-01f, 1.81690872e-01f, 1.47373766e-01f, 2.23771110e-02f, -3.66130238e-03f, 7.15029538e-02f, 2.24585265e-01f, 1.17535673e-01f,
  -1.38218164e-01f, 7.03430027e-02f, -3.34060043e-02f, 1.99415430e-01f, 3.19299027e-02f, -1.55133843e-01f, -1.87103480e-01f, -1.97040178e-02f, 1.14835575e-01f, -1.06665060e-01f,
  1.32134244e-01f, -6.08977638e-02f, -3.15578073e-01f, -8.54572430e-02f, -1.93916321e-01f, 4.94763702e-02f, -9.59361121e-02f, -1.45678580e-01f, -2.06189249e-02f, -4.63820472e-02f,
  -5.40213287e-01f, 4.68221843e-01f, 2.23985180e-01f, 1.75496116e-02f, 2.91073248e-02f, -1.32065564e-01f, 4.00935233e-01f, -1.67396888e-01f, -3.06875706e-01f, -1.15431406e-01f,
  -1.17960989e-01f, -1.00600824e-01f, -7.36849010e-03f, -7.51271695e-02f, -1.25795245e-01f, -1.52003855e-01f, 7.65247717e-02f, 1.31514743e-01f, -8.71530473e-02f, -1.82531759e-01f,
  -1.24409728e-01f, 1.61744971e-02f, -7.02337921e-02f, 1.11635379e-01f, 2.19173357e-01f, 4.53175902e-02f, 1.12217022e-02f, -1.76447462e-02f, 4.65364903e-02f, -6.36368468e-02f,
  -1.95981538e+00f, 5.59666872e-01f, 2.37585440e-01f, -6.45007789e-01f, 1.24120057e-01f, -2.58403569e-01f, 7.04419240e-02f, -3.32233608e-01f, 1.55548304e-01f, 7.41305649e-01f,
  4.53822076e-01f, -4.74537492e-01f, 2.82820985e-02f, -1.46866873e-01f, -5.91390967e-01f, 4.14288729e-01f, 1.25757651e-02f, -9.93440390e-01f, -1.67932129e+00f, -1.15626574e+00f,
  -3.35491568e-01f, -6.41673863e-01f, -1.16853762e+00f, -2.22979218e-01f, 6.67977214e-01f, 2.23430902e-01f, 7.41510034e-01f, -1.91537410e-01f, 1.22010268e-01f, 3.80171448e-01f,
  8.87514576e-02f, -5.28778851e-01f, -1.95486411e-01f, -1.18752830e-01f, 3.87936801e-01f, -1.24042124e-01f, -1.75844327e-01f, 1.53239354e-01f, -1.71738863e-01f, 7.19065890e-02f,
  3.39684337e-02f, -4.73940670e-02f, -3.45117986e-01f, 2.78426185e-02f, -4.43928570e-01f, -2.70733029e-01f, -1.22552618e-01f, -4.60777998e-01f, -1.21545270e-01f, -5.73492199e-02f,
  -1.55889625e-02f, -6.24709010e-01f, -6.03092790e-01f, 3.66367131e-01f, 3.68383192e-02f, -4.61517096e-01f, 2.28317097e-01f, -1.04304627e-01f, -1.32864043e-01f, 1.07120268e-01f,
  1.53520880e-02f, 6.75841644e-02f, -4.15502079e-02f, -2.05208845e-02f, 6.05780594e-02f, 6.94379732e-02f, 1.53130084e-01f, 1.41116055e-02f, 5.77749461e-02f, 5.71627868e-03f,
  6.98057115e-02f, 1.09663703e-01f, 4.83684950e-02f, 9.94591489e-02f, 9.42324549e-02f, -1.49549142e-01f, 2.63874400e-02f, -7.63181448e-02f, -4.80418429e-02f, 1.78496037e-02f,
  -1.85438335e-01f, -8.55550766e-02f, -3.62851210e-02f, 2.44962916e-01f, 3.20249908e-02f, 1.49153084e-01f, 2.48924214e-02f, 3.56631875e-02f, 3.43026146e-02f, 1.30379703e-02f,
  2.43941471e-01f, -1.46960735e-01f, -8.11873302e-02f, -2.78224230e-01f, 1.78759806e-02f, 1.97261758e-02f, 2.56219152e-02f, 6.47611916e-02f, -1.21762045e-01f, -1.09769374e-01f,
  -6.62884191e-02f, 2.09921896e-02f, 3.38440925e-01f, 5.79189248e-02f, -3.31408501e-01f, -1.58276737e-01f, 2.72786200e-01f, -8.50968435e-02f, -8.52724537e-02f, 1.02143683e-01f,
  9.64530930e-02f, -5.34967422e-01f, -8.22537482e-01f, 2.33975902e-01f, -5.33833653e-02f, -4.51927453e-01f, 7.34557509e-02f, 4.06306935e-03f, -3.88162464e-01f, 1.10221975e-01f,
  -7.29394138e-01f, -1.04164743e+00f, -3.16354662e-01f, -1.18402994e+00f, -3.28679323e-01f, 2.92144448e-01f, -6.09837234e-01f, 1.72843501e-01f, -1.88832089e-01f, -1.27237785e+00f,
  -1.27761528e-01f, 2.87107617e-01f, -3.44488174e-01f, -6.88267127e-02f, -1.04211055e-01f, -1.45516443e+00f, -1.23847067e+00f, -2.20775515e-01f, 8.78204763e-01f, 7.68212318e-01f,
  -2.37417147e-01f, -4.75458235e-01f, 2.01744273e-01f, -4.05659378e-02f, -9.64286566e-01f, -3.80883038e-01f, -7.07680106e-01f, -4.95167226e-01f, -1.27973733e-03f, -1.22084451e+00f,
  -6.98012114e-01f, 3.48287761e-01f, 1.99689329e-01f, -2.20817775e-02f, -1.71372488e-01f, 1.97100081e-02f, -7.05516385e-03f, 5.04390628e-04f, 1.17260575e-01f, -1.65066332e-01f,
  -1.39184520e-01f, 3.21253687e-01f, -2.40933988e-02f, 2.57032901e-01f, 6.02621697e-02f, -8.44357684e-02f, -5.23243099e-02f, -4.56301793e-02f, -4.72017415e-02f, 2.49460101e-01f,
  -7.53189325e-02f, 2.45853156e-01f, 5.04621267e-01f, 4.52846497e-01f, 2.29021341e-01f, 1.69035181e-01f, 2.62168139e-01f, 4.20456499e-01f, 4.48809206e-01f, -1.20539570e+00f,
  -1.70569524e-01f, 1.45574257e-01f, -1.27896383e-01f, 2.03576222e-01f, 6.19449802e-02f, 1.00426160e-01f, 2.70874742e-02f, -1.11614913e-01f, 4.10076268e-02f, -2.63708889e-01f,
  3.65217514e-02f, 8.66654664e-02f, 1.84144050e-01f, -1.80715129e-01f, 2.44578682e-02f, -4.87599783e-02f, -2.49049291e-02f, -1.23751163e-01f, 1.35575160e-01f, -8.67726654e-02f,
  8.48558992e-02f, 3.18568796e-01f, -3.32816392e-02f, 2.55572274e-02f, -7.90292621e-02f, -1.21287197e-01f, -2.24727914e-02f, 2.91258246e-01f, -2.07941473e-01f, 1.02259152e-01f,
  -6.66071832e-01f, 7.02011466e-01f, -7.78678179e-01f, 1.48465052e-01f, -5.56844734e-02f, -1.59175798e-01f, -2.92027742e-01f, 1.52500700e-02f, -1.35448545e-01f, -1.13817818e-01f,
  2.86856234e-01f, -2.63195097e-01f, -3.90481353e-01f, 1.09701574e-01f, -1.95938841e-01f, 1.46016017e-01f, -2.75157362e-01f, -2.20667839e-01f, 2.68892318e-01f, -2.32549772e-01f,
  -2.18453094e-01f, -1.35993540e-01f, -4.64164406e-01f, -3.71348947e-01f, -5.48175462e-02f, -3.23818694e-03f, -1.77933782e-01f, -2.37667233e-01f, -1.12563245e-01f, -1.47950518e+00f,
  -6.08015597e-01f, -1.00993407e+00f, 8.09234619e-01f, 9.18285698e-02f, 5.13538837e-01f, 2.74922937e-01f, -4.71485734e-01f, -1.89495698e-01f, 1.45555034e-01f, -4.98292863e-01f,
  -1.05817294e+00f, -3.91624480e-01f, 1.32735208e-01f, 5.29111065e-02f, -1.18447170e-01f, 1.38081923e-01f, 9.53660011e-01f, 9.36741233e-01f, 6.13373816e-01f, -4.54452157e-01f,
  -1.67892024e-01f, -5.48333526e-02f, -2.96338588e-01f, 1.42183363e-01f, -1.59429118e-01f, 6.33598149e-01f, 6.66292682e-02f, -2.62425721e-01f, -4.75029469e-01f, 4.22777623e-01f,
  -6.65080667e-01f, -1.09659016e+00f, 6.55378878e-01f, -2.28220314e-01f, -8.73862505e-02f, -3.50781798e-01f, 1.28221866e-02f, -7.63125569e-02f, 1.29079431e-01f, 2.20535677e-02f,
  -2.33804919e-02f, -2.28502810e-01f, 3.55985731e-01f, -1.24526255e-01f, -2.41261229e-01f, -1.84320077e-01f, -6.41751736e-02f, -9.19610932e-02f, -5.95305376e-02f, -6.28289938e-01f,
  -1.79212928e-01f, -1.76296651e-01f, 5.19922003e-02f, -7.20444620e-02f, -4.65562101e-03f, 8.60007703e-01f, -2.90520966e-01f, -3.25801104e-01f, 8.28523040e-02f, -6.32986665e-01f,
  1.11182585e-01f, -1.06312230e-01f, 8.28597788e-03f, 2.53273863e-02f, -5.75864455e-03f, 7.77857974e-02f, 1.53154835e-01f, 2.72721779e-02f, 1.49094965e-02f, 1.07294016e-01f,
  1.35073066e-01f, -1.32047191e-01f, 7.64580145e-02f, -3.61905634e-01f, 7.34539405e-02f, -1.50186464e-03f, 1.44053772e-01f, -2.70842433e-01f, -1.99909862e-02f, 4.26953472e-02f,
  -8.15866217e-02f, 1.48553252e-01f, 1.66924186e-02f, 3.40308137e-02f, -2.08687913e-02f, 5.18877991e-02f, 4.33042683e-02f, -2.53174216e-01f, -1.39363483e-01f, -1.29153311e-01f,
  -1.40177697e-01f, 5.88576496e-01f, -2.99741060e-01f, -4.75733951e-02f, 1.07951708e-01f, -9.66532901e-02f, -3.06665758e-03f, -5.54576740e-02f, 6.53524622e-02f, -1.96666285e-01f,
  -3.78875256e-01f, 1.04763120e-01f, -1.77559778e-01f, 2.26219907e-01f, 2.33277425e-01f, -1.86087832e-01f, -3.49082589e-01f, 1.91120312e-01f, -7.77757317e-02f, -1.12614617e-01f,
  1.20105237e-01f, 4.46637459e-02f, 2.42584035e-01f, 2.73262084e-01f, -1.43712848e-01f, 4.72571224e-01f, 1.47058278e-01f, 1.62084535e-01f, 1.94657326e-01f, -6.15527183e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.71367764e+00f, 1.90550721e+00f, 1.66158295e+00f, 1.52385926e+00f, 7.22059131e-01f, 1.64991271e+00f, 9.36410666e-01f, 1.80678391e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.67523754e-01f, -6.54955387e-01f, -8.50835562e-01f, -4.05385911e-01f, -8.41422915e-01f, -6.17608786e-01f, -4.75763172e-01f, -6.51264012e-01f, -1.34781384e+00f, 2.39491895e-01f,
  -2.50972807e-01f, 1.77100617e-02f, -8.93225312e-01f, -6.23486102e-01f, 9.57204521e-01f, -1.03272176e+00f, 1.98208839e-01f, -4.09934163e-01f, -2.29320228e-02f, -1.14670642e-01f,
  -6.86258495e-01f, -1.38231492e+00f, -4.42869574e-01f, -1.08907901e-01f, -2.00030828e+00f, -4.17130113e-01f, 1.07868254e+00f, 3.56237710e-01f, 6.38827384e-01f, -2.51034260e+00f,
  4.22722161e-01f, -3.20824891e-01f, 2.01484323e-01f, 5.55258930e-01f, 3.40547621e-01f, 4.83788490e-01f, 6.30687296e-01f, -9.68167603e-01f, 2.47856215e-01f, 2.49345645e-01f,
  -1.54961741e+00f, 4.78505343e-01f, -3.43990862e-01f, -5.55405438e-01f, -1.27653193e+00f, -5.43142140e-01f, 1.34036615e-01f, 1.15609252e+00f, 1.01912953e-01f, -2.40630627e-01f,
  -2.42145628e-01f, 1.55487686e-01f, -4.98897105e-01f, 8.25090408e-01f, 1.24928939e+00f, -5.02249360e-01f, -4.61095810e-01f, -2.37100673e+00f, -1.95277166e+00f, 4.06608105e-01f,
  -6.40502572e-01f, 8.79651785e-01f, 6.21082425e-01f, -1.82083964e-01f, 4.91500050e-01f, 2.60618597e-01f, 4.80726868e-01f, -2.49031395e-01f, 1.14906073e+00f, 7.66487539e-01f,
  -9.11765873e-01f, 9.48615789e-01f, 1.49996862e-01f, -1.27610013e-01f, -1.10352531e-01f, -4.26554009e-02f, 2.16430929e-02f, 8.07372570e-01f, -1.80115715e-01f, -8.07270408e-01f,
  5.54747403e-01f, 1.69674158e-02f, -7.10145891e-01f, 1.66631863e-01f, -6.76815510e-01f, -1.54705465e+00f, -9.94857728e-01f, -3.18646699e-01f, 2.77389556e-01f, 5.35290003e-01f,
  4.12860692e-01f, 6.99115694e-01f, -1.67990550e-01f, -1.16828449e-01f, -1.30803037e+00f, -1.44854820e+00f, -2.19763979e-01f, 3.44458491e-01f, -2.99583793e-01f, 7.41028860e-02f,
  4.60527658e-01f, -1.77779841e+00f, 9.20715451e-01f, 8.12791109e-01f, 4.85178858e-01f, 1.38556755e+00f, -1.63995194e+00f, -9.86234307e-01f, -4.65481430e-01f, -1.46233773e+00f,
  -1.62490976e+00f, -1.16305339e+00f, 4.60747063e-01f, -5.58192790e-01f, -2.22031981e-01f, -4.15656924e-01f, -2.06221398e-02f, 1.86223483e+00f, 4.95332360e-01f, -2.96320111e-01f,
  -9.66070592e-01f, -3.94230485e-01f, -1.76774013e+00f, -1.03801680e+00f, 3.63834471e-01f, 6.35559678e-01f, -1.53189802e+00f, 1.21610522e+00f, -1.88753709e-01f, 5.40800810e-01f,
  -8.37596692e-03f, 2.75988638e-01f, -6.57419503e-01f, -8.59302059e-02f, -8.77172470e-01f, -3.82983953e-01f, 1.08147085e+00f, -1.35916030e+00f, -8.03885579e-01f, -2.21568003e-01f,
  -2.72455394e-01f, -1.26361930e+00f, -1.22472119e+00f, 1.18058026e+00f, -7.49887586e-01f, 4.97834533e-01f, 7.94965625e-01f, 2.63047934e-01f, 9.27111626e-01f, 2.38485527e+00f,
  -1.06347406e+00f, 9.81800035e-02f, -1.17877342e-01f, 1.11786175e+00f, 8.16344738e-01f, -1.93507206e+00f, -3.55297178e-01f, -3.58659178e-01f, -1.09512186e+00f, -4.11653668e-01f,
  -1.63908035e-01f, -8.66336226e-01f, 3.98831874e-01f, 1.71519697e-01f, -5.91770589e-01f, 1.55491793e+00f, 8.86116207e-01f, -4.95904058e-01f, -1.13537058e-01f, -2.45676017e+00f,
  1.29679871e+00f, 2.82998413e-01f, -1.27377379e+00f, 4.91280377e-01f, -1.51819444e+00f, -6.92468941e-01f, -3.15585695e-02f, 8.24075192e-02f, 6.51537329e-02f, -1.97185874e-02f,
  4.81251061e-01f, -9.06111598e-01f, 9.28079665e-01f, 6.28027976e-01f, 2.13153863e+00f, -1.71106327e+00f, -1.02509606e+00f, -1.48094666e+00f, -5.62308691e-02f, -5.59110463e-01f,
  6.97149992e-01f, -1.69992411e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.51323800e-02f, -2.56974231e-02f, 3.27128291e-01f, -8.19311023e-01f, -2.44662333e-02f, 1.84820425e-02f, 1.08645679e-02f, 1.15078561e-01f, -4.86180894e-02f, -1.31633148e-01f,
  -3.75122279e-01f, -1.07085966e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    