/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.71088797e-01f, 4.46327239e-01f, 6.22453354e-02f, -5.15673794e-02f, 1.94331631e-01f, -4.36611064e-02f, 1.93548471e-01f, -4.11291383e-02f, -4.67316806e-02f, 9.00233239e-02f,
  1.66767821e-01f, -2.14077719e-02f, -4.09936085e-02f, -1.07141539e-01f, -7.66356885e-02f, 1.49137869e-01f, -2.36210661e-04f, -1.75469726e-01f, -3.30272973e-01f, -1.96518913e-01f,
  1.01721637e-01f, 6.57762587e-02f, -1.99323267e-01f, -5.65132499e-02f, 1.26727730e-01f, 5.42584024e-02f, 1.08452395e-01f, 1.04121320e-01f, 1.26038134e-01f, 1.54721513e-01f,
  -4.51889746e-02f, 1.39631510e-01f, 1.65755730e-02f, 1.38571501e-01f, 1.76613376e-01f, 3.80019881e-02f, 1.77038774e-01f, 6.60502091e-02f, 1.36846915e-01f, 8.62175301e-02f,
  1.35673910e-01f, 1.51511699e-01f, 9.00224373e-02f, 8.92342925e-02f, 1.41905755e-01f, 6.12980053e-02f, 1.53597012e-01f, -4.73554395e-02f, 7.34328330e-02f, 1.16622560e-01f,
  1.33980989e-01f, 1.98018074e-01f, 1.06486514e-01f, 2.11929902e-01f, 4.36095744e-02f, 1.29997179e-01f, 1.53796479e-01f, 1.56002194e-01f, 4.28132853e-03f, 1.44376963e-01f,
  -4.26777340e-02f, 3.03050932e-02f, -8.44748393e-02f, -1.33624390e-01f, -1.01200216e-01f, -4.47878614e-02f, -1.62444398e-01f, -1.54026091e-01f, -1.97888896e-01f, -1.02152288e-01f,
  -7.66205564e-02f, -1.25082105e-01f, -1.03907876e-01f, -1.74131796e-01f, -1.85275599e-01f, -1.14622824e-01f, -9.20608267e-02f, -1.17417566e-01f, -1.50903091e-01f, -8.26844126e-02f,
  -2.01462895e-01f, -1.26267031e-01f, -1.57462195e-01f, -1.45535767e-01f, -4.26250361e-02f, -1.40520602e-01f, -1.18876003e-01f, -1.43328846e-01f, -9.15631577e-02f, -1.19638875e-01f,
  -4.66043912e-02f, -9.30389797e-05f, 8.06977078e-02f, 7.15662763e-02f, 5.67884445e-02f, 8.08234885e-02f, 2.84423418e-02f, 9.37529206e-02f, 9.80693176e-02f, 7.47347921e-02f,
  -4.94021084e-03f, -4.51732539e-02f, 7.39877522e-02f, 3.41687575e-02f, 1.59558170e-02f, 5.35845850e-03f, 8.76747221e-02f, -2.79102325e-02f, 4.72666770e-02f, 3.78484614e-02f,
  1.20791875e-01f, -2.29660105e-02f, -7.84642175e-02f, 9.95244738e-03f, 8.58045071e-02f, -5.05253375e-02f, 8.91687274e-02f, 4.64563221e-02f, -5.17566912e-02f, 2.86818985e-02f,
  -4.11241144e-01f, -2.14458898e-01f, 1.70398809e-04f, -1.54756725e-01f, 8.98613632e-02f, 9.67781842e-02f, 3.58054489e-02f, 1.84483435e-02f, -7.44650960e-02f, -1.02074429e-01f,
  -2.69844886e-02f, 1.70490161e-01f, 9.92440358e-02f, 1.04385294e-01f, 1.28226161e-01f, -6.34444654e-02f, 9.23997983e-02f, 2.57909805e-01f, 3.47781092e-01f, 1.52317539e-01f,
  9.81438309e-02f, 3.94802634e-03f, 9.88622941e-03f, -5.41779734e-02f, -1.88121185e-01f, 1.36566013e-01f, -9.51087400e-02f, -5.92422932e-02f, -3.95987891e-02f, -9.07513052e-02f,
  9.89356544e-04f, -9.90283117e-02f, 1.19730860e-01f, 7.72421509e-02f, 9.74877402e-02f, -1.51620945e-02f, 7.31946230e-02f, 3.47519889e-02f, 4.44113463e-02f, -4.66225445e-02f,
  2.86440970e-03f, 1.19428277e-01f, 1.37433976e-01f, 3.42833139e-02f, 2.91951522e-02f, -1.43735725e-02f, 2.66724527e-02f, -5.95020764e-02f, -1.82863157e-02f, -4.35545668e-02f,
  2.32735369e-02f, -4.71423641e-02f, -6.24295920e-02f, 1.10971794e-01f, 2.12959759e-02f, 1.31396219e-01f, -4.34031598e-02f, -2.23399606e-02f, -3.42188589e-02f, -4.01177444e-03f,
  7.09109101e-03f, -9.17242616e-02f, 3.75918038e-02f, -1.21056795e-01f, -5.27682304e-02f, 4.68882807e-02f, -2.41379137e-03f, -1.07698426e-01f, -9.13299713e-03f, -8.39786083e-02f,
  6.54934123e-02f, 3.23652625e-02f, 3.36519592e-02f, -7.40215788e-03f, 4.25383151e-02f, -4.52262573e-02f, 1.88577902e-02f, -1.07461549e-01f, 5.21760061e-02f, -1.80597790e-02f,
  -5.38895167e-02f, -6.24478720e-02f, -2.95005590e-02f, 3.16198207e-02f, -1.96043518e-03f, -7.93181825e-04f, -1.55541608e-02f, 2.10826732e-02f, 7.31264893e-03f, -7.26933703e-02f,
  -8.52560773e-02f, 1.12744637e-01f, -5.98007292e-02f, 3.28426063e-02f, 8.66544247e-02f, 9.50139109e-03f, 3.55221145e-02f, 2.23308466e-02f, 5.97399957e-02f, -6.67312816e-02f,
  -5.89983957e-03f, -6.04954455e-03f, 1.07190870e-02f, 6.82266727e-02f, 9.23485309e-02f, -1.17165614e-02f, 7.69376308e-02f, 7.98042491e-02f, -1.23660620e-02f, -8.22702870e-02f,
  1.11505836e-02f, 6.82558194e-02f, 6.05223812e-02f, 8.54423568e-02f, 6.31182175e-03f, 9.26328674e-02f, 1.28122540e-02f, -1.48633923e-02f, 9.79073346e-02f, -5.16535155e-02f,
  -4.03444231e-01f, -2.88900256e-01f, 1.16828017e-01f, 2.96799373e-02f, 1.34297550e-01f, 3.88765782e-02f, -2.10311338e-01f, -9.31423381e-02f, -4.30604666e-02f, -1.51211947e-01f,
  -7.23862946e-02f, 3.56371626e-02f, -4.85901348e-02f, 9.55718681e-02f, -9.54655558e-02f, -2.92983130e-02f, 4.43847738e-02f, 2.14056950e-02f, 1.25228256e-01f, -7.91292451e-03f,
  1.24897413e-01f, -7.45428503e-02f, -5.10782935e-02f, 1.32419914e-01f, -9.14382860e-02f, -2.55761873e-02f, -3.60702425e-02f, -1.21218218e-02f, -5.30336564e-03f, -2.98521537e-02f,
  -3.01293693e-02f, -1.98222354e-01f, 7.81961903e-02f, 6.03667609e-02f, -6.86032651e-03f, -1.35314865e-02f, 3.77975847e-03f, -5.83483055e-02f, -1.07169244e-02f, -1.67783760e-02f,
  2.74600834e-02f, -5.76366521e-02f, 7.52452004e-04f, 1.48969004e-02f, -5.37868179e-02f, -6.72069788e-02f, -2.27414109e-02f, -3.75441052e-02f, 4.18937998e-03f, -9.45744962e-02f,
  5.03881834e-02f, 7.58125037e-02f, 7.87149742e-03f, -1.45359589e-02f, 5.86068779e-02f, 1.21071830e-01f, -3.76423933e-02f, -1.03837535e-01f, 2.69995872e-02f, -2.89448559e-01f,
  -1.87524389e-02f, 4.27256897e-03f, 6.89577758e-02f, 1.02341482e-02f, -1.26822628e-02f, 5.86580709e-02f, 5.10593280e-02f, 4.52996697e-03f, 7.11146966e-02f, 6.36058450e-02f,
  4.16892692e-02f, 3.75312828e-02f, 6.04414791e-02f, -6.22976236e-02f, 1.13024637e-01f, -1.02778617e-02f, 1.04227558e-01f, 1.07864022e-01f, 1.71309724e-01f, 8.28726962e-02f,
  6.87261149e-02f, 7.01217279e-02f, 8.83569047e-02f, 6.17743544e-02f, 4.42486815e-02f, 6.70084730e-02f, 7.43431821e-02f, 8.65067840e-02f, 6.61146119e-02f, 4.12772670e-02f,
  -2.54210591e-01f, 1.99656799e-01f, -4.66980077e-02f, 4.19491455e-02f, -1.96240079e-02f, -1.02451621e-02f, 1.58480369e-02f, 5.98922893e-02f, 4.24832068e-02f, -8.80791689e-04f,
  8.83238986e-02f, -6.33255988e-02f, -9.54666454e-03f, 8.08912590e-02f, 1.03918135e-01f, 7.18191862e-02f, -1.43931974e-02f, -3.77839319e-02f, 4.17261496e-02f, -4.32220288e-02f,
  -3.17103975e-02f, -6.89435229e-02f, -1.44239575e-01f, -9.29577723e-02f, 2.17824103e-03f, -5.56282848e-02f, -6.29360527e-02f, -1.28768891e-01f, -1.11885779e-01f, -3.45807463e-01f,
  -2.78242230e-01f, 2.02351511e-01f, 1.23974040e-01f, -5.89371808e-02f, 1.01447769e-01f, -3.12513411e-02f, 2.74873465e-01f, -1.09275036e-01f, -1.72744825e-01f, 1.59884796e-01f,
  1.72274768e-01f, -3.59168410e-01f, -1.74541235e-01f, -1.59895644e-01f, -2.39762262e-01f, 1.90271020e-01f, -1.02324858e-01f, -3.35187346e-01f, -3.59491050e-01f, -8.60854760e-02f,
  -2.17912868e-01f, -1.76313490e-01f, -1.20431706e-01f, -2.00984120e-01f, 9.98900533e-02f, -2.02490076e-01f, 7.62329102e-02f, 3.64445634e-02f, -2.79117022e-02f, 8.11939687e-02f,
  1.13385962e-02f, 1.07050031e-01f, -7.43381213e-03f, 2.33903099e-02f, 6.55768067e-02f, -2.66882256e-02f, 1.53045589e-02f, 2.67917104e-02f, 6.64317608e-03f, -3.44112888e-03f,
  3.88515368e-02f, -9.60748866e-02f, -3.85759119e-03f, -1.46105569e-02f, 3.05170082e-02f, -3.72504853e-02f, 6.41013533e-02f, -4.19964977e-02f, -7.50950426e-02f, 1.05706543e-01f,
  7.13696182e-02f, -4.97865602e-02f, -1.58821756e-03f, -4.08851877e-02f, 5.35667911e-02f, -9.08072963e-02f, 5.34169264e-02f, 3.71536314e-02f, -6.58666641e-02f, 2.04532310e-01f,
  -8.92552733e-03f, 2.67909076e-02f, 5.07245101e-02f, 1.18258178e-01f, 1.00725163e-02f, 1.10104224e-02f, 1.96974687e-02f, 3.67152132e-02f, -5.92629462e-02f, 9.31572244e-02f,
  3.44274826e-02f, 1.60631701e-01f, 2.52323603e-04f, 3.58905531e-02f, 1.01551548e-01f, -2.93995608e-02f, 6.88775331e-02f, 3.39628793e-02f, -8.75784177e-03f, 4.13753949e-02f,
  2.54350882e-02f, -1.43251698e-02f, 3.98031659e-02f, 2.66099218e-02f, 1.19332280e-02f, 6.53516268e-03f, 5.70753356e-03f, -4.94368337e-02f, 7.40646124e-02f, -7.31344074e-02f,
  -5.99226542e-02f, -2.36879572e-01f, 5.13612181e-02f, -1.15755852e-03f, 1.02498151e-01f, 2.90230960e-02f, -6.34911098e-03f, 3.87449749e-02f, 6.24068864e-02f, 6.05772100e-02f,
  7.90250376e-02f, -2.24723089e-02f, -8.47546831e-02f, -3.10100038e-02f, -1.17917620e-02f, 8.59072134e-02f, 1.69376526e-02f, -5.03588915e-02f, -1.32564139e-02f, 4.54949811e-02f,
  9.42997411e-02f, 1.06748693e-01f, 1.97097030e-03f, 1.09984681e-01f, 8.22919980e-02f, -5.84179834e-02f, 6.20192327e-02f, 2.01665893e-01f, 4.46084552e-02f, 2.54942775e-01f,
  -7.13706255e-01f, 1.05950773e-01f, 1.57964870e-01f, -2.92397350e-01f, 2.66839355e-01f, 1.48372367e-01f, 3.50035548e-01f, -1.04458742e-01f, -1.88876748e-01f, 1.40174106e-01f,
  8.67110044e-02f, -4.53808680e-02f, -4.51598167e-02f, -1.47178548e-03f, -1.24329612e-01f, 3.20900470e-01f, 2.68525273e-01f, 1.07405568e-02f, -6.01128750e-02f, 1.22236855e-01f,
  1.75709039e-01f, 4.45165448e-02f, -2.50301391e-01f, -1.54808775e-01f, 1.26252249e-01f, 1.27627570e-02f, 1.81192458e-01f, 5.59243448e-02f, 1.44923553e-01f, 1.07365415e-01f,
  2.21056584e-02f, -1.26099989e-01f, 2.01494526e-03f, 4.07213485e-03f, 6.59330264e-02f, -7.18260333e-02f, -3.46391909e-02f, -2.59199180e-02f, -5.10842539e-02f, -4.62764874e-02f,
  1.01057768e-01f, -9.21628997e-02f, -1.73843224e-02f, -3.14684864e-03f, -2.71269474e-02f, -4.61749919e-03f, -4.43505533e-02f, 4.17304807e-04f, 4.20206785e-02f, 2.64965352e-02f,
  6.16566725e-02f, -1.26083568e-03f, 1.12854447e-02f, 7.80648440e-02f, -5.24481907e-02f, -6.80636615e-02f, 1.02184847e-01f, 2.83064842e-02f, 3.62409861e-03f, -9.05965548e-03f,
  1.30643963e-03f, -3.55838169e-03f, -2.33683921e-02f, -5.57749718e-03f, -3.02220955e-02f, -1.84515230e-02f, -3.10708093e-03f, -1.20790331e-02f, -5.41956574e-02f, -2.54299399e-02f,
  -7.24644458e-04f, -3.76747511e-02f, -3.88838463e-02f, -9.36882198e-03f, 2.72003766e-02f, 3.26622115e-03f, 1.96933886e-03f, -4.42164801e-02f, 1.53525788e-02f, -1.04140207e-01f,
  -5.74028380e-02f, 1.14470320e-02f, 4.60521318e-02f, 2.78333726e-04f, -4.02268097e-02f, -1.04400046e-01f, -2.84380373e-02f, -2.62511726e-02f, -3.64596844e-02f, 1.64840911e-02f,
  -6.43217266e-02f, 5.79037555e-02f, -5.46390042e-02f, -4.21623811e-02f, -6.37871772e-02f, -7.37079978e-02f, -3.00148446e-02f, 1.96596864e-03f, 9.90652293e-03f, -2.99402643e-02f,
  1.74094308e-02f, -9.48078781e-02f, -3.85128781e-02f, 4.51196320e-02f, -3.68191749e-02f, -7.41358548e-02f, -6.19059149e-03f, -1.94519386e-02f, -6.02030866e-02f, -1.30796218e-02f,
  -7.33314529e-02f, 8.79719555e-02f, -5.23749702e-02f, -8.37379415e-03f, 1.06799826e-02f, -1.68004539e-02f, 1.10343523e-01f, -4.44390699e-02f, -3.18635069e-02f, -1.17962230e-02f,
  2.33932629e-01f, 2.76763082e-01f, -1.78655535e-02f, 2.39017606e-01f, 9.58157554e-02f, 4.58755251e-03f, 2.82161869e-02f, -1.03409924e-01f, 8.44655093e-03f, 2.41236016e-01f,
  1.60283133e-01f, -8.94874483e-02f, -6.95531443e-02f, -8.62065628e-02f, -1.10796846e-01f, 2.09845632e-01f, -3.46492752e-02f, -1.16973184e-01f, -2.20534518e-01f, 4.65999320e-02f,
  2.76622679e-02f, 1.13634385e-01f, 2.37021465e-02f, 2.99426652e-02f, 3.22728604e-01f, 8.71186033e-02f, 1.62466735e-01f, 2.77407225e-02f, 1.09396942e-01f, 1.58688426e-01f,
  1.45992726e-01f, 6.01633899e-02f, -1.05921753e-01f, 1.91806871e-02f, 1.83296239e-03f, 6.30308166e-02f, 7.42391422e-02f, 1.91784631e-02f, 3.49260718e-02f, 1.35610551e-02f,
  7.02693239e-02f, 5.90197667e-02f, -1.31096067e-02f, 1.05939098e-01f, 3.30877826e-02f, 4.01264429e-02f, -2.51137681e-04f, -1.23099340e-02f, -1.12795055e-01f, 7.76377320e-02f,
  4.28089537e-02f, 6.21032380e-02f, 1.06187258e-02f, -6.63109794e-02f, -8.26941878e-02f, 7.33521488e-03f, 7.38645792e-02f, -9.72190965e-03f, -6.22034632e-02f, 2.24761024e-01f,
  -2.46313084e-02f, 9.54139084e-02f, 2.37553269e-02f, 5.56825660e-02f, -2.26872806e-02f, 8.06038529e-02f, 4.42334637e-02f, -4.75448836e-03f, 7.85987005e-02f, 4.44813818e-02f,
  -8.18058569e-03f, -3.56791131e-02f, 7.03645721e-02f, 1.56239673e-01f, 5.81778213e-02f, 1.00768544e-01f, -7.94232413e-02f, -2.13229246e-02f, -3.87979038e-02f, -3.05705164e-02f,
  -1.24306940e-01f, 4.17622551e-03f, 1.93908792e-02f, -2.24406440e-02f, -2.82596387e-02f, 8.16623122e-03f, 4.06001620e-02f, 6.36243122e-03f, 1.67511143e-02f, -7.52267381e-03f,
  1.50187969e-01f, -2.68229663e-01f, 1.41740561e-01f, 3.22048888e-02f, 3.33196446e-02f, -8.49234983e-02f, 5.06604686e-02f, 6.11239746e-02f, -4.81699221e-02f, 3.52493227e-02f,
  -3.32784615e-02f, -1.81883890e-02f, 1.09879307e-01f, -9.14647654e-02f, -1.25756208e-02f, 4.21780199e-02f, 6.35185279e-03f, -5.69397025e-02f, 2.11276375e-02f, 9.62663665e-02f,
  -3.93187441e-02f, 4.89406288e-02f, -1.12362802e-02f, 9.32293236e-02f, -2.62983963e-02f, 4.24547270e-02f, 9.71813202e-02f, 4.33875434e-02f, -8.53919834e-02f, 2.10524857e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.65300046e-02f, 2.99408734e-01f, 2.54974589e-02f, 2.79263765e-01f, -5.92749193e-03f, 1.50095046e-01f, 6.00797124e-03f, 1.09304510e-01f, 2.89869308e-01f, 1.28171146e-01f,
  2.35774636e-01f, 3.14230144e-01f, 2.62787223e-01f, 8.96516517e-02f, 1.87528983e-01f, 1.41667336e-01f, 2.97718316e-01f, 9.87761319e-02f, -5.08908443e-02f, -1.04599688e-02f,
  1.16114669e-01f, -1.10794194e-01f, 6.48297817e-02f, 5.92847914e-02f, 1.19350120e-01f, 7.55682290e-02f, 1.35788411e-01f, 2.14943979e-02f, 1.59540862e-01f, 2.16980353e-01f,
  -8.09915885e-02f, 1.29284680e-01f, 1.52692109e-01f, 1.57947596e-02f, -4.93971258e-02f, -3.67032923e-02f, -5.10940813e-02f, 5.09144785e-03f, -4.74709533e-02f, 9.03243423e-02f,
  9.10146385e-02f, 1.77861750e-02f, -1.29442826e-01f, -6.70211613e-02f, -9.29668769e-02f, -8.23424086e-02f, -4.83962782e-02f, -7.32383579e-02f, 9.11452100e-02f, 9.04231444e-02f,
  5.07590882e-02f, -6.13369681e-02f, -1.60476148e-01f, 3.53439227e-02f, 6.89163059e-02f, 1.51497662e-01f, 4.41404171e-02f, 1.08079493e-01f, 5.21635171e-03f, 2.86240876e-02f,
  1.16036102e-01f, 5.51238284e-02f, 4.99147875e-03f, -6.88696876e-02f, -9.37297344e-02f, -4.21660841e-02f, 1.85167529e-02f, -1.53999426e-03f, -3.81730311e-02f, -8.22648630e-02f,
  -2.28537336e-01f, 7.74550438e-02f, 4.73744683e-02f, -1.20346330e-01f, 9.22299549e-02f, 5.41991927e-03f, 9.78753269e-02f, 8.86196643e-02f, -6.21351274e-03f, 2.54836585e-03f,
  -6.25016466e-02f, -4.87873480e-02f, 2.99579352e-02f, -9.58001241e-02f, -3.37283537e-02f, -8.82848259e-03f, 4.10988592e-02f, 3.83944660e-02f, -6.32999986e-02f, 6.25212938e-02f,
  -1.06174134e-01f, 3.79307643e-02f, -5.53038083e-02f, 8.07652920e-02f, 1.12466305e-01f, 4.70882840e-02f, 2.80984551e-01f, 1.47011891e-01f, 1.41369388e-01f, 1.40459433e-01f,
  2.39793137e-02f, 7.03202933e-02f, 3.41885686e-02f, -2.84304656e-02f, -2.14909032e-01f, -5.64938001e-02f, 8.04538578e-02f, -1.43828178e-02f, 1.87545687e-01f, 3.66055630e-02f,
  5.76165430e-02f, 1.25951901e-01f, 2.37644762e-02f, 5.03558442e-02f, 2.97845677e-02f, 1.22505203e-02f, 3.30589004e-02f, -1.57524906e-02f, -4.82650287e-02f, -8.27058852e-02f,
  4.95982207e-02f, -1.89908192e-01f, 1.50259569e-01f, 2.57474899e-01f, -1.93692505e-01f, -1.80769265e-01f, -2.71059781e-01f, 2.51498036e-02f, 1.95931401e-02f, -7.06984177e-02f,
  -1.55556677e-02f, 1.37996987e-01f, 2.70345151e-01f, 1.96330860e-01f, 1.84905306e-01f, -7.69167170e-02f, 2.79547304e-01f, 3.12386692e-01f, 1.58402473e-01f, 7.11735636e-02f,
  7.49900863e-02f, -1.00516535e-01f, 7.09599629e-02f, 6.03396632e-02f, -4.15861532e-02f, 9.37400907e-02f, -6.02811612e-02f, -1.42831251e-01f, 1.66091993e-02f, 3.14368814e-01f,
  -1.50181598e-03f, 6.94311857e-02f, 1.74416944e-01f, 3.85071151e-02f, -1.52908242e-03f, 6.01512659e-03f, -9.24824327e-02f, 4.99134883e-02f, -1.29882529e-01f, -6.44422323e-02f,
  -4.32802401e-02f, 7.35038221e-02f, 2.42228657e-02f, -1.31747350e-02f, -1.10102095e-01f, -1.05342872e-01f, 7.68713206e-02f, 1.56665221e-01f, -3.22037153e-02f, -5.74878529e-02f,
  9.19796973e-02f, -6.34833891e-03f, -1.21548064e-01f, -5.32455370e-02f, -5.53205051e-02f, 1.03709325e-01f, -4.32127491e-02f, 3.03881727e-02f, -3.43194790e-02f, 3.36712785e-02f,
  2.09239218e-02f, 9.39974841e-03f, -1.12828590e-01f, 1.09571870e-02f, -1.41532077e-02f, -1.02051593e-01f, 1.12545922e-01f, -4.02338542e-02f, -2.52332236e-03f, -1.22417316e-01f,
  7.26493672e-02f, 7.79601410e-02f, 1.56761453e-01f, 2.92268228e-02f, 1.92146629e-01f, -5.98931648e-02f, -7.02596307e-02f, -1.00477681e-01f, -7.90403970e-03f, -2.86738668e-02f,
  -1.05788022e-01f, 1.36595875e-01f, -9.52826142e-02f, 8.27487111e-02f, 7.09695965e-02f, 1.16625957e-01f, -3.62654924e-02f, -3.05081848e-02f, -9.47791040e-02f, 4.17214027e-03f,
  -2.97221303e-01f, 8.85418504e-02f, 9.78428349e-02f, 7.29886591e-02f, 2.95895450e-02f, -1.37263000e-01f, -1.55921862e-01f, -2.16289870e-02f, -8.99079442e-02f, -8.87075998e-03f,
  -2.22640306e-01f, 1.76922791e-02f, -8.28812644e-02f, -1.33659780e-01f, -4.91045751e-02f, -1.31106496e-01f, -8.43441486e-02f, 1.79985061e-01f, -6.32062778e-02f, -8.68604407e-02f,
  -2.16278899e-02f, -7.13686645e-02f, -7.05510825e-02f, 5.11409640e-02f, -1.35179877e-01f, 3.56820528e-03f, -1.74864203e-01f, -1.52806193e-01f, -2.46082485e-01f, -3.24183643e-01f,
  -4.53442663e-01f, 4.03664298e-02f, 2.48637095e-01f, 7.03134313e-02f, 4.17760432e-01f, 1.57985508e-01f, 1.04400497e-02f, 2.81216763e-02f, 1.70620471e-01f, -1.71679538e-02f,
  2.28980228e-01f, 3.01103331e-02f, 4.67112288e-02f, 5.16385324e-02f, -1.92446008e-01f, -2.21830606e-01f, 3.91994715e-02f, -2.91134398e-02f, -6.49838373e-02f, -5.93006285e-03f,
  2.40843311e-01f, -3.80980447e-02f, -1.15280695e-01f, -1.42947324e-02f, -1.20372050e-01f, 1.46555349e-01f, 2.51949523e-02f, -1.01867706e-01f, -2.02534124e-01f, -2.82606333e-01f,
  -4.59280372e-01f, -1.11378543e-01f, -9.33235791e-03f, -6.42048791e-02f, -1.19315594e-01f, -5.98277561e-02f, -7.18866736e-02f, -1.37796253e-01f, 1.30673289e-01f, -3.72484587e-02f,
  -8.44628960e-02f, 6.53395727e-02f, 1.65043533e-01f, 6.94628507e-02f, 1.76479425e-02f, -3.46962027e-02f, 6.95515797e-02f, -1.40230104e-01f, -2.28470787e-02f, 2.06423104e-02f,
  4.65209894e-02f, -2.70870834e-04f, -2.19782889e-01f, -3.72503251e-02f, -9.16145220e-02f, -8.35644528e-02f, -2.34031573e-01f, -2.30251625e-01f, -1.84979558e-01f, -5.15772104e-01f,
  -2.12099589e-03f, 1.70173228e-01f, -2.99512353e-02f, -2.30409391e-02f, -4.56202216e-02f, 2.83336658e-02f, -1.46539643e-01f, -7.84152746e-02f, -4.33701426e-02f, -4.40243632e-02f,
  5.03570251e-02f, -3.77482846e-02f, 5.81591502e-02f, 1.33076638e-01f, -9.95108113e-02f, -7.54788443e-02f, -9.66463983e-02f, -2.31199056e-01f, -1.39110163e-01f, -1.49792973e-02f,
  3.88054959e-02f, -1.58728453e-05f, -3.09218243e-02f, -1.64451629e-01f, 1.35699362e-01f, -1.39671480e-02f, -1.15666598e-01f, -1.11027859e-01f, -5.64638153e-02f, -2.66579539e-02f,
  -1.25877962e-01f, 1.09721750e-01f, -2.30484352e-01f, -3.81050967e-02f, -1.74755469e-01f, 9.93259847e-02f, 5.04442528e-02f, -7.76565000e-02f, 3.95800360e-02f, 1.67256612e-02f,
  2.73237359e-02f, -1.16724811e-01f, -6.20418303e-02f, 4.88438122e-02f, 5.04907453e-03f, -2.68145613e-02f, -6.83554783e-02f, -7.97826201e-02f, -1.81179456e-02f, 1.02853365e-01f,
  -1.12989537e-01f, -1.23315603e-01f, -1.93200976e-01f, -2.83543706e-01f, -1.14923120e-01f, -3.29463035e-02f, -1.67339474e-01f, -1.72930166e-01f, -2.78322965e-01f, -3.84129912e-01f,
  -3.18852425e-01f, -2.97385678e-02f, -3.99811193e-02f, -1.69339254e-01f, 1.14065833e-01f, 2.28070438e-01f, -4.55157347e-02f, 1.76476225e-01f, 2.05954179e-01f, -6.21495470e-02f,
  1.50780544e-01f, -1.89482197e-02f, -1.48958698e-01f, -3.31654325e-02f, -3.54740955e-02f, -2.17398152e-01f, -4.51030970e-01f, -3.10102731e-01f, 9.09822136e-02f, 3.07161093e-01f,
  1.83429539e-01f, -1.37660168e-02f, -4.81179915e-02f, 8.50484297e-02f, -8.57846662e-02f, -2.45009080e-01f, -3.25975448e-01f, -2.92933583e-01f, -1.88846707e-01f, -5.42633295e-01f,
  -2.39117146e-01f, 2.71658838e-01f, 1.07931606e-01f, -2.55675917e-03f, -6.48229495e-02f, 1.26630273e-02f, 7.42124617e-02f, 4.72308993e-02f, 8.27230215e-02f, 1.04080155e-01f,
  8.17916244e-02f, 1.80058956e-01f, -1.22715168e-01f, 1.10107824e-01f, 2.56227441e-02f, 3.09657659e-02f, 1.71772704e-01f, 1.28618414e-02f, -1.13461763e-01f, 2.89053917e-01f,
  6.28800988e-02f, 8.63888953e-03f, -2.13780701e-01f, 6.14975300e-03f, 1.62224278e-01f, -1.65360436e-01f, -5.68226539e-03f, 1.67896867e-01f, -4.11442891e-02f, -2.33484998e-01f,
  1.07872769e-01f, 5.84370941e-02f, 9.28873271e-02f, -5.72095811e-02f, -1.29168049e-01f, 5.06837331e-02f, 8.77054408e-02f, -8.58947914e-03f, 5.77928796e-02f, 9.20047909e-02f,
  8.16652924e-02f, -8.75041634e-03f, 1.02474941e-02f, -4.06014845e-02f, -4.25977074e-02f, 6.40320405e-03f, -5.70345670e-02f, -1.57937735e-01f, -4.25155573e-02f, -1.82620183e-01f,
  -4.82275039e-02f, -2.68462952e-02f, -8.28381106e-02f, 7.71158263e-02f, -5.87187381e-03f, 4.58726697e-02f, -4.17808145e-02f, 6.77227899e-02f, 1.38542607e-01f, 1.52289107e-01f,
  -2.10371733e-01f, -1.17161773e-01f, -7.74552161e-03f, 1.95729703e-01f, 8.75473693e-02f, -7.53912181e-02f, -2.01433331e-01f, 1.93661228e-02f, -6.25615641e-02f, 3.62802632e-02f,
  1.16500452e-01f, -4.45660055e-02f, -1.74062122e-02f, 6.12557083e-02f, -6.61837980e-02f, -5.46758063e-02f, -3.40951495e-02f, -1.87498912e-01f, -1.20708078e-01f, 1.97922930e-01f,
  -7.01139644e-02f, 3.69499438e-02f, -2.91986287e-01f, -2.71988094e-01f, -1.37684450e-01f, -3.38800997e-01f, -2.54199952e-01f, -1.02399118e-01f, -2.54618049e-01f, -3.33741575e-01f,
  -2.97455430e-01f, 3.37914109e-01f, 8.63241404e-02f, -2.35189468e-01f, -2.32239500e-01f, -1.16336979e-01f, 3.42282683e-01f, 5.67650124e-02f, -1.02776222e-01f, 3.30348700e-01f,
  1.17288910e-01f, -3.42118263e-01f, -7.78513551e-02f, -6.63044453e-02f, -1.18619435e-01f, 3.07441235e-01f, -9.05393213e-02f, -3.23598236e-01f, -4.36707318e-01f, -2.00371787e-01f,
  -5.34795932e-02f, -1.40359893e-01f, -3.23853344e-01f, -1.63784251e-01f, -7.16104060e-02f, -2.18068868e-01f, 1.78297013e-01f, -1.45935044e-01f, -2.26309180e-01f, -1.07607752e-01f,
  9.30485781e-03f, -3.05697978e-01f, -1.13140889e-01f, -2.75931180e-01f, 1.03365570e-01f, -7.05253333e-02f, -1.03731923e-01f, -1.29375324e-01f, 8.19536485e-03f, -2.13922951e-02f,
  -1.18143797e-01f, -1.56214423e-02f, -1.87827781e-01f, 9.36938897e-02f, -1.18381582e-01f, -9.36208218e-02f, 8.39770120e-03f, -1.95744336e-01f, -1.92927495e-01f, -3.22015844e-02f,
  4.05633524e-02f, -1.21375032e-01f, -1.68418497e-01f, -8.93258676e-02f, -1.61370829e-01f, -2.71328241e-01f, -1.20969219e-02f, -7.87707493e-02f, -3.36175203e-01f, 1.78943545e-01f,
  2.77635250e-02f, 1.61518410e-01f, -3.40121910e-02f, 6.30474300e-04f, 4.90705669e-02f, -5.60544804e-02f, 3.25833187e-02f, 4.67296224e-03f, 4.39545559e-03f, 8.28826800e-02f,
  -8.81705582e-02f, 7.84837380e-02f, -1.60631705e-02f, -1.53724626e-02f, 2.79475283e-02f, -7.42560253e-02f, -1.06733795e-02f, 1.12781160e-01f, 1.49809942e-02f, -8.59066471e-02f,
  -1.18887194e-01f, -8.14560708e-03f, 1.46621391e-02f, 6.98401332e-02f, -6.96521923e-02f, 6.99841455e-02f, 2.04069577e-02f, -2.59887893e-02f, -1.58114806e-02f, -1.52055567e-04f,
  1.43635809e-01f, -2.27694258e-01f, 1.86932012e-01f, 6.02836534e-02f, 1.10333245e-02f, 1.07017100e-01f, -1.94924995e-02f, -4.16767560e-02f, -3.71971801e-02f, 1.12717077e-01f,
  -1.59089580e-01f, 5.60779274e-02f, 3.75481509e-02f, 7.97510818e-02f, 1.92954056e-02f, 1.00984452e-02f, 2.00344190e-01f, 2.07488537e-02f, -5.89258596e-02f, 9.16445032e-02f,
  2.26338491e-01f, 1.61047623e-01f, 5.87359816e-02f, -2.27781432e-03f, -4.27316539e-02f, -7.64736682e-02f, 1.07523493e-01f, 1.11609578e-01f, -9.34761092e-02f, 4.04410928e-01f,
  -1.20052087e+00f, 1.00681141e-01f, 1.58706024e-01f, -4.44845200e-01f, -4.80842358e-03f, -3.18218097e-02f, 1.54501259e-01f, -1.59010395e-01f, -2.56376088e-01f, -4.61912155e-02f,
  -3.45111527e-02f, -1.44024923e-01f, 1.36890076e-02f, 1.38421893e-01f, -1.84967015e-02f, 2.56919771e-01f, 1.45834044e-01f, -1.96061939e-01f, -2.40545183e-01f, -1.25409150e-02f,
  -4.54838276e-02f, -2.10342631e-01f, -3.81495267e-01f, -1.91940546e-01f, 5.57273813e-02f, 7.18170963e-03f, 2.77605861e-01f, 7.15776607e-02f, 2.32677311e-01f, 5.83377965e-02f,
  3.66144419e-01f, -1.85737431e-01f, -1.07270345e-01f, -1.49794683e-01f, -1.18415756e-02f, -1.63502768e-01f, 1.56915968e-03f, -6.98794201e-02f, -7.89151415e-02f, 1.08325608e-01f,
  2.86287367e-02f, 3.28679010e-02f, 3.28076482e-02f, 1.38178542e-02f, -1.17923744e-01f, -1.60196170e-01f, -7.39884973e-02f, 9.65484232e-02f, 1.35741368e-01f, 1.62586212e-01f,
  1.36552751e-01f, 7.86782578e-02f, 1.41538814e-01f, 1.65184692e-01f, 9.28501561e-02f, 5.71227223e-02f, 3.18535268e-02f, 8.36038440e-02f, 9.33143869e-02f, -4.65278141e-02f,
  -4.41359319e-02f, 9.77473054e-03f, 4.45668958e-03f, 1.41236885e-02f, 6.36441261e-02f, -6.71194866e-02f, 4.08047661e-02f, 5.29088974e-02f, -2.32255668e-03f, -1.92198068e-01f,
  1.45638272e-01f, 9.67807397e-02f, 9.11777914e-02f, 9.06819999e-02f, -8.44128802e-02f, 3.48923099e-03f, -7.52442777e-02f, 2.32007471e-03f, -6.34323759e-03f, -7.28093833e-02f,
  -7.22594187e-02f, 2.66513694e-02f, -1.79632138e-02f, 6.24643862e-02f, 1.04496412e-01f, -5.88414408e-02f, 6.60603195e-02f, -6.89087734e-02f, 3.59334126e-02f, -6.86100721e-02f,
  8.69053453e-02f, -4.22120169e-02f, -2.58812420e-02f, -3.93438861e-02f, -2.44483724e-02f, -6.93201087e-03f, 3.19103561e-02f, 8.07226896e-02f, 1.13190629e-01f, 1.34331748e-01f,
  6.58983365e-02f, 3.34337610e-03f, 9.06502381e-02f, 1.25388533e-03f, -8.07766765e-02f, 5.54941930e-02f, -1.38743773e-01f, -1.24930836e-01f, 1.76823750e-01f, 1.20696679e-01f,
  4.39053066e-02f, -6.15835451e-02f, 2.27843281e-02f, 8.35879371e-02f, 1.25036731e-01f, -2.08688881e-02f, 4.23139259e-02f, 9.12306458e-03f, 3.04461382e-02f, -3.42685319e-02f,
  -5.50101519e-01f, 2.55890340e-01f, 9.75310430e-02f, -4.02527042e-02f, 3.21803033e-01f, 1.49923116e-01f, 3.45788389e-01f, 1.31586734e-02f, -1.51411474e-01f, 3.64184119e-02f,
  -1.72558457e-01f, -2.38251954e-01f, -5.04437424e-02f, 4.13521528e-02f, 1.35603607e-01f, 3.53612244e-01f, 3.47121745e-01f, 1.63047075e-01f, -2.02816427e-01f, -2.52974480e-01f,
  5.70339076e-02f, -1.56059995e-01f, -2.92180479e-01f, -2.06815228e-01f, 3.78081948e-02f, -4.96885069e-02f, 1.02224484e-01f, 1.81236882e-02f, 1.88789099e-01f, 2.62675643e-01f,
  -2.32344165e-01f, -7.32473060e-02f, 1.05232470e-01f, -3.36478092e-02f, 1.29984394e-01f, -1.60712853e-01f, -1.97046980e-01f, -1.31658971e-01f, 3.80873904e-02f, -1.07635140e-01f,
  2.83727329e-02f, -1.04666412e-01f, 2.31235623e-01f, -4.63252924e-02f, -6.88769855e-03f, -1.25494853e-01f, -2.29498595e-02f, -1.71388984e-01f, -1.00799941e-01f, -2.25534737e-01f,
  3.89687330e-01f, 1.78125829e-01f, -3.61418054e-02f, 6.87659010e-02f, 7.34168589e-02f, -1.49256244e-01f, -1.83896851e-02f, -5.97479716e-02f, -3.09993565e-01f, -2.50743091e-01f,
  -3.21253426e-02f, -6.96488991e-02f, 7.33554438e-02f, 1.64305028e-02f, -5.83850630e-02f, 8.69595855e-02f, 7.92210996e-02f, 8.65050852e-02f, 1.59898162e-01f, 4.84641083e-02f,
  1.30876705e-01f, -7.15664104e-02f, -3.83436191e-03f, -2.42105555e-02f, 4.54192422e-02f, 9.37433094e-02f, 3.94916125e-02f, -1.30773857e-01f, -1.28993765e-01f, -1.20738328e-01f,
  -8.04225802e-02f, 7.19095469e-02f, -9.20181200e-02f, -1.40822440e-01f, 1.48211941e-01f, -9.35426727e-02f, 7.59750232e-02f, -2.29846709e-03f, 5.98769933e-02f, 4.23911624e-02f,
  -3.49935591e-01f, 1.87980995e-01f, -1.29418597e-01f, -1.06324546e-01f, 8.88801515e-02f, 6.55324431e-03f, -7.44548216e-02f, -9.25100744e-02f, -1.33904358e-02f, -5.59366345e-02f,
  9.66854841e-02f, 9.92473215e-02f, -4.41858731e-02f, -6.57246709e-02f, -9.66046304e-02f, 6.04826882e-02f, 1.19919737e-03f, -5.05732521e-02f, -8.97432491e-02f, -1.37162685e-01f,
  5.22015393e-02f, -8.31842329e-03f, -3.26119721e-01f, 2.74255872e-02f, -7.34429210e-02f, -2.65274495e-01f, -2.14042857e-01f, -2.40595281e-01f, -2.99756795e-01f, -2.36125097e-01f,
  3.98392767e-01f, -5.32874525e-01f, -6.39958024e-01f, -2.03818738e-01f, -4.51310515e-01f, -2.23442182e-01f, -4.03523207e-01f, 1.08037770e-01f, 2.05026552e-01f, -4.29353923e-01f,
  -3.40788774e-02f, 1.45606011e-01f, -5.80013636e-03f, -3.37629244e-02f, 3.33800130e-02f, -4.46385652e-01f, -5.21603584e-01f, -3.29664290e-01f, -1.02054946e-01f, -9.57584307e-02f,
  -1.50838435e-01f, -2.11171821e-01f, -9.09044221e-02f, -8.67379010e-02f, -3.75726134e-01f, -2.40264520e-01f, -5.80331743e-01f, -2.30827525e-01f, -2.46326253e-01f, -6.81785822e-01f,
  -2.56547391e-01f, -2.24268977e-02f, 3.91874416e-03f, 1.80295866e-03f, -2.08103031e-01f, 1.23633072e-01f, 4.81985277e-03f, 3.67080681e-02f, 5.75552173e-02f, -2.91490499e-02f,
  4.17205784e-03f, -6.93525523e-02f, 1.95436999e-01f, -1.67802066e-01f, -7.78180882e-02f, 1.40274186e-02f, -3.94824408e-02f, -2.48856410e-01f, -9.02774632e-02f, -5.04600964e-02f,
  1.25937328e-01f, -2.18340959e-02f, 8.39780942e-02f, 1.05443373e-01f, 2.25712672e-01f, -7.30497390e-02f, -1.48373887e-01f, 4.67918813e-02f, 8.00670385e-02f, -2.66407609e-01f,
  -1.01747401e-01f, -2.39956398e-02f, -1.16729038e-02f, 6.22032918e-02f, 9.33259130e-02f, -3.10574304e-02f, 9.65689421e-02f, -5.47966920e-02f, -1.63082988e-03f, -2.83323636e-04f,
  2.32125912e-02f, -7.77391717e-02f, -3.94484960e-02f, 1.01082087e-01f, -8.33356306e-02f, 5.56486472e-03f, 5.20741530e-02f, -3.57663073e-02f, 9.28531494e-03f, 4.33058525e-03f,
  4.63693170e-04f, -1.21163964e-01f, -1.27601594e-01f, 4.80825594e-03f, -1.16687128e-02f, -4.63921353e-02f, 4.96464921e-03f, -3.28420363e-02f, -2.11696774e-02f, 5.49933128e-02f,
  1.24878073e-02f, 2.53455639e-02f, -2.52869632e-02f, 5.77432439e-02f, -7.35845417e-02f, -5.19208238e-02f, 4.64847051e-02f, 1.59953721e-02f, 5.90562783e-02f, -6.10311367e-02f,
  3.18282545e-02f, 2.40346640e-02f, -1.17180450e-02f, 4.11297418e-02f, 2.97856121e-03f, 2.56211702e-02f, -1.86405946e-02f, -1.20913610e-01f, 1.71746880e-01f, 6.42271936e-02f,
  -5.91331236e-02f, 8.59704837e-02f, 1.30975679e-01f, -2.04636343e-02f, 8.23282599e-02f, 5.87085187e-02f, 9.19127371e-03f, 5.12561575e-02f, 2.04612762e-01f, -9.73175466e-03f,
  -4.50407982e-01f, 2.86489110e-02f, 2.64665633e-01f, -2.68818915e-01f, 1.42484322e-01f, 4.97793816e-02f, -6.17743097e-02f, -1.45367250e-01f, -6.51056394e-02f, 2.34402895e-01f,
  3.46453100e-01f, 1.92459710e-02f, 1.27010942e-01f, -1.33599535e-01f, -3.65540504e-01f, -7.43767917e-02f, -3.33607309e-02f, -1.86434567e-01f, -3.49978715e-01f, -1.79150119e-01f,
  7.68047106e-03f, -1.03269964e-01f, -2.81891584e-01f, -1.83870699e-02f, 1.69275716e-01f, -1.49261318e-02f, 3.61187965e-01f, 7.62907714e-02f, 2.17452988e-01f, 6.93992823e-02f,
  6.59136698e-02f, 1.58595428e-01f, 7.85916299e-02f, -1.55100927e-01f, 2.48590484e-01f, -9.62260067e-02f, 1.24524757e-02f, 1.19851723e-01f, -5.01309782e-02f, 5.33714145e-02f,
  -2.27407478e-02f, 9.22750458e-02f, -7.29484856e-02f, -7.37209097e-02f, -7.06593618e-02f, -1.41481861e-01f, -4.17802781e-02f, -1.11422561e-01f, -6.77185357e-02f, -1.63590714e-01f,
  -2.51627624e-01f, 8.42790008e-02f, -2.59575155e-02f, 7.83040151e-02f, 1.56868696e-02f, -9.72904414e-02f, 8.61234739e-02f, 8.46493524e-03f, 5.08872233e-03f, 9.20533836e-02f,
  2.73359865e-02f, -9.48586017e-02f, -1.10573992e-01f, -2.58637853e-02f, -3.56556214e-02f, -7.74503406e-03f, -1.70273352e-02f, 4.11248021e-02f, 4.61804271e-02f, -7.01599270e-02f,
  -1.61071777e-01f, 1.08396962e-01f, 5.99241294e-02f, 5.03786877e-02f, 1.34311998e-02f, 1.07392743e-02f, -2.79836562e-02f, 3.83809432e-02f, 2.54872311e-02f, 1.09398201e-01f,
  8.52760451e-04f, -4.40290682e-02f, 1.54824704e-01f, -6.44813664e-03f, -5.31395115e-02f, 1.22970402e-01f, 1.09708145e-01f, 1.48736313e-02f, -2.22974822e-01f, 7.19632581e-02f,
  -1.12587042e-01f, 1.26592636e-01f, 7.69450814e-02f, -7.20110387e-02f, 8.34589675e-02f, -1.27378171e-02f, 1.26179859e-01f, 1.16149120e-01f, 3.61597277e-02f, -1.12775601e-01f,
  -6.92623556e-02f, -1.10507943e-01f, 5.49879707e-02f, 4.36657369e-02f, -7.35085905e-02f, -1.28845036e-01f, -7.87054449e-02f, -5.25020063e-02f, -1.36206090e-01f, -6.60942867e-02f,
  -2.61347473e-01f, -1.22607827e-01f, -2.35988244e-01f, -8.14799294e-02f, -9.35094655e-02f, 6.07987642e-02f, 1.02772936e-01f, 1.27913558e-03f, -1.28498659e-01f, -6.05069585e-02f,
  -9.46869049e-03f, 5.22227705e-01f, 1.90529943e-01f, -1.64643213e-01f, 1.54159650e-01f, 2.60890156e-01f, 4.71914321e-01f, 1.99637339e-01f, -2.12300479e-01f, 2.62115188e-02f,
  -1.04388855e-01f, -3.26230735e-01f, -8.60861540e-02f, -1.42027736e-01f, 1.45570144e-01f, 1.99669003e-01f, 1.48166075e-01f, 8.60890560e-03f, -2.03153715e-01f, -1.53388202e-01f,
  -1.57724977e-01f, 5.92266060e-02f, -7.74150267e-02f, -8.83807242e-02f, 1.66588992e-01f, -2.81644166e-01f, 1.18214592e-01f, 2.56093204e-01f, -3.81487571e-02f, 4.64266613e-02f,
  -1.83724146e-03f, 3.65344644e-01f, -3.46431702e-01f, -8.21086671e-03f, -1.24470759e-02f, -1.41697884e-01f, -9.40930247e-02f, 8.62014741e-02f, -4.69993072e-04f, 4.89392653e-02f,
  8.96505862e-02f, 3.42242047e-02f, 2.77456284e-01f, 3.60015444e-02f, 4.88265753e-02f, 1.86847821e-02f, 2.21459240e-01f, -4.06611450e-02f, 1.13256849e-01f, -2.49434058e-02f,
  3.28679048e-02f, 4.46243174e-02f, 7.88654163e-02f, 2.61334460e-02f, 1.93180516e-01f, -1.94690466e-01f, 1.12799443e-01f, 4.98830192e-02f, -1.38845056e-01f, -2.34898061e-01f,
  -5.51866479e-02f, 3.22007611e-02f, 1.18659653e-01f, 6.77402243e-02f, -2.43590195e-02f, -5.78109757e-05f, 1.42130107e-02f, -1.67979360e-01f, -3.12296879e-02f, 9.20181945e-02f,
  -1.33109465e-01f, -1.31721660e-01f, -1.62662640e-02f, 5.39014523e-04f, -1.26144707e-01f, 3.67347635e-02f, -1.23373583e-01f, 5.99948801e-02f, 1.23558827e-01f, -2.96080876e-02f,
  -4.79612835e-02f, -5.58679476e-02f, 9.62807983e-03f, 1.21258646e-02f, -1.38083011e-01f, -8.31909552e-02f, -9.73306745e-02f, -3.91607285e-02f, -2.17978819e-03f, -1.33799687e-01f,
  -2.97465980e-01f, 5.18553704e-02f, -3.44568700e-01f, 1.23161105e-02f, 9.17761400e-02f, 7.71006793e-02f, -7.27006197e-02f, 3.77563462e-02f, 2.89793126e-02f, -1.94918558e-01f,
  1.65258929e-01f, -1.39317557e-01f, 8.97255018e-02f, -3.62540856e-02f, -1.46304220e-01f, -4.00593579e-02f, 9.59019288e-02f, -1.33471312e-02f, 6.56389222e-02f, 1.51433721e-02f,
  -5.64105920e-02f, -1.79787278e-01f, -2.58526444e-01f, -2.29248762e-01f, -3.56312990e-01f, -4.00169671e-01f, -3.07276756e-01f, -1.86122298e-01f, -6.77945390e-02f, -3.91214252e-01f,
  -8.70635808e-02f, -2.15252146e-01f, -2.06958711e-01f, 9.83264819e-02f, 2.73186006e-02f, 1.99187715e-02f, 4.66834866e-02f, -2.81944089e-02f, 1.45114213e-01f, 6.29884154e-02f,
  6.31998256e-02f, 3.00528824e-01f, 2.63518840e-01f, 3.34554881e-01f, 1.93605185e-01f, 7.13843852e-02f, 1.61308885e-01f, 1.59264624e-01f, 1.27883539e-01f, 1.04497992e-01f,
  2.07739428e-01f, 3.05015240e-02f, -8.56946260e-02f, 6.94255456e-02f, 1.17188096e-01f, 1.78686246e-01f, 5.87958507e-02f, 5.18606976e-02f, 3.86711098e-02f, 3.35926265e-01f,
  -1.41660064e-01f, -3.25645283e-02f, 5.13463914e-02f, 1.02466561e-01f, -1.30016450e-02f, -1.36993617e-01f, -2.29002163e-02f, -1.23944037e-01f, -4.61123250e-02f, 1.01343114e-02f,
  -1.40572146e-01f, -4.84003033e-03f, -2.10126173e-02f, 8.11102167e-02f, -6.22242037e-03f, -1.04332946e-01f, -5.37380949e-02f, 8.62357691e-02f, 5.58204055e-02f, 3.53473239e-02f,
  2.32816175e-01f, 3.78858559e-02f, -6.35145530e-02f, -6.73350766e-02f, 1.08418604e-02f, 5.00408523e-02f, 1.99288681e-01f, 9.69414860e-02f, 4.48813476e-02f, -4.36942391e-02f,
  4.62523401e-02f, -4.26012166e-02f, -2.95126066e-02f, 1.58241510e-01f, 1.32279769e-01f, 1.14314243e-01f, 6.00707084e-02f, 1.86331064e-01f, 2.49756351e-01f, 1.69645250e-02f,
  -1.08595960e-01f, -1.65266301e-02f, 5.33990562e-03f, 1.07369702e-02f, 6.76036403e-02f, 5.49616925e-02f, -4.48297597e-02f, -9.84570980e-02f, 3.30974273e-02f, 3.29796015e-03f,
  2.44623143e-02f, -5.73650002e-02f, -1.76316928e-02f, 9.36222821e-02f, -8.75866711e-02f, 2.31569689e-02f, 6.07011095e-02f, -7.85063207e-02f, 1.40660042e-02f, 6.39488697e-02f,
  -3.82019997e-01f, 1.37662552e-02f, 1.89218596e-01f, 1.22271106e-01f, 4.18363363e-02f, 2.05776263e-02f, 5.11683151e-02f, -1.27379104e-01f, -1.17175154e-01f, -2.00832650e-01f,
  -2.36332431e-01f, -1.35724157e-01f, -7.31679127e-02f, -8.52947533e-02f, 4.12605405e-02f, -6.48439080e-02f, 4.44852747e-02f, 4.13792394e-02f, 6.68116063e-02f, -7.13462234e-02f,
  -5.58009408e-02f, -8.43506306e-02f, -1.59896672e-01f, -7.33093992e-02f, -6.34100512e-02f, -8.62661451e-02f, -2.47001853e-02f, -2.31448516e-01f, -1.49965808e-01f, -1.21795349e-01f,
  5.93260109e-01f, -2.64709257e-02f, 3.32154214e-01f, -9.64704715e-03f, 1.07020497e-01f, 2.20715091e-01f, 3.53993386e-01f, 2.29060233e-01f, -4.01683487e-02f, 3.70676294e-02f,
  -1.94738954e-01f, -3.13984841e-01f, -2.85511881e-01f, -2.79952407e-01f, -3.36630568e-02f, 2.30305001e-01f, 9.40486044e-02f, 1.41367704e-01f, 2.93716967e-01f, 2.86277682e-01f,
  8.41403939e-03f, 1.99824497e-01f, 1.80847451e-01f, -4.95219491e-02f, -1.10779643e-01f, -9.14663747e-02f, 2.15474237e-02f, 8.97838771e-02f, -6.59080148e-02f, -1.55449331e-01f,
  -1.12192258e-01f, 2.29542807e-01f, -8.63463134e-02f, -6.06520772e-02f, 1.17359735e-01f, 5.00746770e-04f, 1.20762289e-02f, -1.68543737e-02f, -5.75407706e-02f, -6.70943037e-02f,
  -5.25589772e-02f, -1.78485587e-02f, -1.61126003e-01f, -1.36954680e-01f, -1.34170307e-02f, 3.65301967e-02f, -8.35209992e-03f, 5.66200428e-02f, -3.80977765e-02f, -1.07834287e-01f,
  -2.25878060e-01f, 6.88947067e-02f, 1.86325032e-02f, -6.01725094e-02f, -6.32794201e-02f, -1.52713284e-01f, -1.16217379e-02f, -5.20288646e-02f, -1.40997143e-02f, 3.79618406e-02f,
  -1.17167458e-01f, 1.71067446e-01f, -4.85389009e-02f, -2.00437352e-01f, -1.28853738e-01f, -7.33342618e-02f, -6.41554147e-02f, -1.97303053e-02f, 6.62439223e-03f, -3.27752307e-02f,
  -6.11940250e-02f, -1.85619235e-01f, -1.65962726e-01f, -7.93145075e-02f, -3.93766239e-02f, -7.94527233e-02f, 9.01648775e-02f, -1.75389439e-01f, -2.03588277e-01f, -1.83730572e-01f,
  -9.05896425e-02f, -5.49384914e-02f, 3.60521413e-02f, -7.70891458e-02f, -2.57923026e-02f, -6.85926229e-02f, -6.58649057e-02f, -6.79983348e-02f, 8.19092616e-02f, 2.88199037e-02f,
  -4.88567829e-01f, -1.75487012e-01f, 4.79340144e-02f, 2.68814582e-02f, 9.17415470e-02f, 2.32546292e-02f, -1.14575706e-01f, -1.86643098e-02f, 8.80388264e-03f, -8.04172307e-02f,
  1.23094276e-01f, 1.27135813e-01f, -1.41355142e-01f, -4.80946675e-02f, 8.66962299e-02f, 1.96946431e-02f, -8.82264748e-02f, 1.08141368e-02f, -7.49024898e-02f, -1.04366124e-01f,
  -1.47417456e-01f, -6.60317689e-02f, 1.73757412e-02f, -4.32550982e-02f, 8.21073726e-02f, 3.07816975e-02f, 3.29470001e-02f, 3.54882069e-02f, 1.58986509e-01f, 8.57407320e-03f,
  3.59791517e-01f, -5.78519404e-01f, 4.14249092e-01f, 2.32301116e-01f, 4.36085671e-01f, 5.79435706e-01f, 3.22660863e-01f, 3.59940827e-01f, 2.47607529e-01f, 5.33190593e-02f,
  -1.22780815e-01f, -5.89842796e-02f, -1.14008039e-01f, -3.79570387e-02f, -5.67215569e-02f, 1.10750027e-01f, 2.92825937e-01f, 1.82975829e-01f, 4.25887913e-01f, 2.25922510e-01f,
  -8.59901607e-02f, -7.56454691e-02f, -6.24444112e-02f, -3.29204984e-02f, -5.75583689e-02f, 9.19938236e-02f, 1.16382865e-02f, 7.67037943e-02f, -4.59509604e-02f, -2.94731468e-01f,
  8.24447125e-02f, -5.16434908e-02f, 1.31173775e-01f, -1.91456273e-01f, -1.12942323e-01f, -1.42644614e-01f, 4.93978187e-02f, -7.53455460e-02f, 2.00578570e-02f, -6.81602582e-02f,
  -1.50683289e-02f, -1.39280558e-01f, -5.57213873e-02f, -1.26445681e-01f, 2.22288202e-02f, -5.67337535e-02f, -6.58355132e-02f, 4.25218791e-02f, 5.12718111e-02f, -1.80273250e-01f,
  -1.57905191e-01f, 8.98792148e-02f, 1.46765679e-01f, 7.84229264e-02f, 1.27677172e-01f, 3.81491147e-02f, -1.71791632e-02f, -1.06284119e-01f, 5.78067563e-02f, -1.25824459e-04f,
  1.13552950e-01f, 1.11730359e-02f, 6.42939880e-02f, -2.35957876e-02f, -1.02206869e-02f, -1.61083154e-02f, 7.41617233e-02f, -1.25345951e-02f, 4.12818529e-02f, -4.86122705e-02f,
  2.92184800e-02f, 1.72123045e-01f, 7.46707395e-02f, 2.00914480e-02f, -4.79045585e-02f, -8.71800643e-04f, 3.27622928e-02f, -9.23393220e-02f, -4.53777350e-02f, 5.30280322e-02f,
  3.15380208e-02f, 4.35837917e-03f, -6.88609779e-02f, -1.27424285e-01f, -6.70546433e-03f, 1.22341529e-01f, 7.15480223e-02f, -2.81528011e-02f, 1.17123954e-01f, 9.20932926e-03f,
  -3.10695380e-01f, 1.15848564e-01f, -1.02534071e-02f, -1.53784886e-01f, 3.95634025e-02f, -1.19048893e-01f, 2.89749671e-02f, -5.12377061e-02f, -3.07977553e-02f, 1.10177778e-01f,
  5.55085503e-02f, -6.91510141e-02f, -1.11139014e-01f, -1.21471152e-01f, 2.05370218e-01f, 6.77572787e-02f, -1.83645785e-01f, -3.76136154e-02f, -4.51524854e-02f, -1.10226989e-01f,
  -6.54371753e-02f, 2.28257328e-01f, 2.08925202e-01f, 2.33242884e-01f, 1.17945649e-01f, 2.04865322e-01f, 1.81645676e-02f, 1.15495592e-01f, 1.44209415e-01f, 1.03167161e-01f,
  5.04267037e-01f, 4.30658609e-01f, 2.30990633e-01f, 1.03341319e-01f, -2.44970620e-02f, 1.96639121e-01f, 4.26775098e-01f, 3.08560640e-01f, 8.85901451e-02f, 1.45832554e-01f,
  4.97650616e-02f, -1.09726392e-01f, 4.60500903e-02f, 9.19791982e-02f, 3.11650902e-01f, 2.29429245e-01f, 1.30458444e-01f, 2.04331890e-01f, 1.50031820e-01f, 7.85772204e-02f,
  -1.01761194e-02f, 5.49341328e-02f, 1.91984504e-01f, 5.13162389e-02f, 4.94238511e-02f, -1.00331388e-01f, 7.61260763e-02f, 1.87230892e-02f, 1.39514238e-01f, 1.32713005e-01f,
  -5.52682057e-02f, 3.93642783e-01f, -1.33306995e-01f, -1.49176329e-01f, -8.56147408e-02f, 9.20394212e-02f, -3.06546688e-02f, 1.51713520e-01f, -9.57948938e-02f, -6.55218810e-02f,
  -1.48177624e-01f, -2.33028270e-02f, 1.14942402e-01f, -1.51137216e-02f, -2.14423537e-02f, -7.82506019e-02f, 1.33196503e-01f, 2.30119675e-01f, 2.44388003e-02f, -1.55542523e-03f,
  -3.99053916e-02f, -1.07439570e-02f, 6.61380589e-02f, -1.94728933e-02f, 2.02723905e-01f, -7.18774796e-02f, 8.27107579e-02f, 3.56786624e-02f, 9.38471854e-02f, 1.79242551e-01f,
  1.28917947e-01f, 1.09360173e-01f, 9.27352235e-02f, 1.19706601e-01f, 6.91483840e-02f, -1.09539749e-02f, -9.49608907e-02f, -5.61888702e-02f, -6.24967888e-02f, 8.62915888e-02f,
  7.11897463e-02f, 9.17314291e-02f, -4.03142854e-04f, 8.85998309e-02f, -1.58921376e-01f, 3.27158533e-02f, -2.20519882e-02f, -8.03295076e-02f, -3.07465792e-02f, -6.95040310e-03f,
  -2.79106554e-02f, -1.22513384e-01f, -1.02353707e-01f, 3.40366997e-02f, 2.69342288e-02f, 1.27793491e-01f, 7.69691821e-03f, 5.00334017e-02f, 1.23649895e-01f, 8.11915100e-02f,
  -5.72053790e-01f, -1.76119044e-01f, -7.71694407e-02f, -4.62632701e-02f, -2.05107108e-02f, -8.37857723e-02f, -7.16702715e-02f, -4.09135409e-02f, -1.82892308e-01f, -2.85319500e-02f,
  -7.34229609e-02f, -3.79988812e-02f, -3.63369100e-02f, 1.68529022e-02f, -1.38948858e-01f, -1.89118132e-01f, -2.67100986e-02f, -1.32508464e-02f, -1.05092786e-01f, -1.37067780e-01f,
  -8.77822340e-02f, -8.36291015e-02f, -1.15534246e-01f, -7.07863942e-02f, -7.21332654e-02f, -2.25907743e-01f, -1.93791553e-01f, -7.50492439e-02f, -8.32883939e-02f, -9.35439244e-02f,
  2.42427096e-01f, 3.31058772e-03f, 3.64465922e-01f, 9.05601457e-02f, 2.59238988e-01f, 4.32620198e-01f, 3.50961983e-01f, 2.75629550e-01f, 1.14793971e-01f, 7.48961344e-02f,
  -1.29319519e-01f, -2.66417325e-01f, -2.77840823e-01f, -2.35436469e-01f, -3.95321250e-02f, 1.45765066e-01f, 6.24248683e-02f, 3.15547548e-02f, 1.60811752e-01f, 1.66476980e-01f,
  -1.12800315e-01f, 2.62535989e-01f, 1.97586283e-01f, 2.69766301e-02f, -7.84611031e-02f, -1.21203721e-01f, 1.01077557e-01f, 9.53727961e-02f, 4.26743440e-02f, -1.88059941e-01f,
  6.75934972e-03f, 2.52375126e-01f, -1.73488438e-01f, -1.72586262e-01f, -2.41637621e-02f, 2.89794467e-02f, 4.43347842e-02f, -2.97131334e-02f, 5.87364542e-04f, -8.59508067e-02f,
  -6.73884600e-02f, -1.17902234e-01f, 3.26748900e-02f, 8.11172370e-03f, 1.87931120e-01f, -6.04968295e-02f, -5.98318391e-02f, 8.46045911e-02f, 1.81566253e-02f, -8.49584211e-03f,
  -1.36512429e-01f, 2.48939008e-03f, 1.35308430e-01f, -3.46836224e-02f, 2.62668598e-02f, -1.31048918e-01f, -2.62705646e-02f, -4.63213921e-02f, -1.36896208e-01f, -3.30662280e-02f,
  -6.86108768e-02f, -2.48399563e-02f, 2.35541500e-02f, 2.09833542e-03f, 9.55269951e-03f, 1.01292349e-01f, 3.23616564e-02f, 4.36189249e-02f, 1.91991508e-01f, 1.58980340e-01f,
  1.27805367e-01f, 1.51282817e-01f, 2.27316871e-01f, 1.73730478e-01f, 3.45929898e-02f, 7.31573999e-02f, 1.37171566e-01f, -4.05213162e-02f, 3.40302922e-02f, 7.45977685e-02f,
  1.28044337e-01f, 1.58006012e-01f, 9.25753042e-02f, 1.61645651e-01f, 1.02378272e-01f, 9.57691669e-02f, 7.85431638e-02f, 2.82048248e-02f, 8.78469087e-03f, 1.25745982e-01f,
  -4.74067926e-02f, 1.67757392e-01f, -7.59989396e-02f, -1.08120807e-01f, -1.13276271e-02f, 8.41862801e-03f, 3.09195984e-02f, 5.54625839e-02f, -4.07999381e-02f, 4.91790734e-02f,
  1.00630689e-02f, -1.58618931e-02f, 1.53090999e-01f, 9.11135301e-02f, 9.91029963e-02f, -6.92718662e-04f, -2.24353328e-01f, 5.33070415e-02f, -1.25770971e-01f, -1.11673534e-01f,
  -7.96609744e-02f, 1.22595001e-02f, 2.00986713e-02f, 4.02199142e-02f, -1.50322616e-01f, 2.59652976e-02f, 2.72496119e-02f, -1.18877493e-01f, 6.55328035e-02f, 5.34933321e-02f,
  6.33903563e-01f, 1.38210818e-01f, 1.67004704e-01f, 3.86941493e-01f, -2.19341338e-01f, -3.19082797e-01f, -3.18900824e-01f, -3.79909605e-01f, 3.43548716e-03f, -5.32186627e-02f,
  -5.22422679e-02f, -1.81862146e-01f, -2.91920099e-02f, -1.91520274e-01f, -2.19846889e-01f, -1.11214735e-01f, -6.99137524e-02f, -1.04379937e-01f, -3.38221014e-01f, -2.11394265e-01f,
  -1.99334100e-01f, -9.68928635e-03f, 1.90212026e-01f, 2.38904413e-02f, 2.83637941e-01f, -1.61120817e-01f, 2.19726562e-01f, 2.10534096e-01f, 3.95260267e-02f, 3.48369658e-01f,
  2.43887112e-01f, 2.25388080e-01f, -2.15099841e-01f, -1.96976662e-01f, 1.90597445e-01f, 1.06000014e-01f, 7.18623921e-02f, 8.06454420e-02f, -9.26726684e-02f, 3.43853980e-02f,
  1.44504607e-01f, -1.04605779e-02f, -8.57098214e-03f, -8.74785483e-02f, -7.09384978e-02f, -3.18074115e-02f, -5.76197468e-02f, 2.41495296e-02f, 9.63709354e-02f, 1.28958553e-01f,
  -1.55092835e-01f, 1.18200541e-01f, 6.48852289e-02f, -1.30705014e-01f, 5.58326393e-02f, -4.47615907e-02f, 1.04078092e-01f, 1.22173384e-01f, -1.31166920e-01f, 2.50607640e-01f,
  -6.57599345e-02f, -6.09160736e-02f, -3.23880725e-02f, 1.65616926e-02f, -5.45528494e-02f, 3.20764743e-02f, -1.13130757e-03f, 3.00759263e-02f, -2.22251937e-03f, 1.00273872e-02f,
  -3.10739763e-02f, 1.20650781e-02f, -1.19767770e-01f, 5.32401800e-02f, -2.34968942e-02f, 4.15793993e-02f, -9.74066630e-02f, -6.95697665e-02f, 4.27059457e-02f, 2.85457131e-02f,
  -3.00735757e-02f, 7.93134943e-02f, 5.94137348e-02f, 3.83932590e-02f, 8.10681880e-02f, 3.10309436e-02f, 8.05253536e-02f, -2.06868425e-02f, 2.13711001e-02f, 2.62933248e-03f,
  -1.21642634e-01f, -3.14694643e-01f, 1.48261622e-01f, -1.12780981e-01f, -2.23876555e-02f, -7.08746677e-03f, 1.02892853e-01f, -1.39838368e-01f, 1.44705534e-01f, -7.32182041e-02f,
  -5.08733559e-03f, 3.04388572e-02f, 1.56138092e-01f, -1.67436063e-01f, -9.63104591e-02f, -2.31634304e-02f, -9.79793742e-02f, -1.61737442e-01f, -1.36164635e-01f, 8.53761733e-02f,
  -6.04998171e-02f, -1.71546862e-01f, -1.93916008e-01f, -8.43988955e-02f, 3.66040096e-02f, -2.86714166e-01f, -1.79116175e-01f, -9.31938738e-02f, -3.68974298e-01f, -1.52468488e-01f,
  1.37652671e-02f, -3.53198051e-02f, 3.95168751e-01f, 3.09350044e-01f, -2.25934401e-01f, -4.11608815e-02f, -2.56762579e-02f, 9.42956954e-02f, 3.09042595e-02f, -1.00915916e-01f,
  -2.57957637e-01f, -1.35741055e-01f, 1.99092980e-02f, 1.05034985e-01f, 3.28033835e-01f, 3.24026048e-01f, 4.80260998e-01f, 4.45468247e-01f, 1.07115537e-01f, 4.97423708e-02f,
  5.44805005e-02f, -1.09175377e-01f, -1.16110504e-01f, 1.32994026e-01f, 2.11331695e-01f, 1.16457447e-01f, 1.47045314e-01f, 1.10168062e-01f, -8.50051083e-03f, 4.27875966e-01f,
  2.25432515e-01f, -1.28595769e-01f, -5.87683097e-02f, -1.82648569e-01f, -8.45730677e-02f, -7.96616729e-03f, -5.43854060e-03f, 1.38715692e-02f, -1.06678173e-01f, 4.77176681e-02f,
  -9.97766629e-02f, -2.47606590e-01f, 2.89939567e-02f, -6.24418072e-02f, 5.22637833e-03f, -1.22410536e-01f, 9.58052836e-03f, 2.35400870e-01f, 8.03895295e-02f, -7.30829388e-02f,
  2.47710310e-02f, -1.18084908e-01f, -2.14699447e-01f, 5.01186252e-02f, 1.82072312e-01f, 1.07709095e-01f, -9.20370221e-02f, 7.33652338e-02f, -9.22274068e-02f, 2.03864817e-02f,
  -6.70736190e-03f, -9.68259349e-02f, -9.84393880e-02f, -2.58540045e-02f, -1.77691877e-02f, -1.53919235e-01f, 1.12851404e-01f, -6.66817799e-02f, 1.72594458e-01f, -3.74228396e-02f,
  -1.29509801e-02f, 4.73754629e-02f, 1.82285346e-02f, 2.39246860e-02f, 4.18278301e-04f, -6.62343279e-02f, -8.35105777e-02f, -1.09316632e-02f, -1.36015275e-02f, -1.14993937e-01f,
  5.66314571e-02f, -3.01048486e-03f, -6.06651790e-02f, 1.59250230e-01f, 2.47286316e-02f, 1.06325887e-01f, -1.20550310e-02f, -4.32662964e-02f, -1.22162536e-01f, -1.10262007e-01f,
  -1.53420111e-02f, -2.77103603e-01f, 1.41061455e-01f, 1.43780679e-01f, -3.29440087e-02f, -1.40313968e-01f, -6.88461075e-03f, -2.80824956e-02f, -1.21247964e-02f, 9.84068513e-02f,
  -2.84152310e-02f, -1.71271097e-02f, -1.75893325e-02f, 4.17138636e-02f, 1.22304680e-02f, -1.21843748e-01f, -2.34166328e-02f, 3.38905156e-02f, -2.91248485e-02f, -5.92110828e-02f,
  4.10555489e-02f, -1.70017466e-01f, -2.63453037e-01f, 2.56858915e-02f, -7.68114254e-02f, -4.52516302e-02f, -1.76828019e-02f, -7.33205006e-02f, -1.15958005e-01f, -1.41808018e-01f,
  -7.07072973e-01f, 1.21719725e-01f, -9.35282372e-03f, -3.55789214e-01f, 2.61733830e-01f, 3.41582090e-01f, 2.98713088e-01f, 1.76256046e-01f, -1.37062250e-02f, 1.77082166e-01f,
  -3.53279114e-02f, -9.71244425e-02f, -1.42498896e-01f, 1.27865434e-01f, -2.35153846e-02f, 2.21852735e-01f, 2.16459408e-01f, -1.85523093e-01f, -9.75209922e-02f, 4.59475257e-02f,
  4.11804914e-02f, -2.68771529e-01f, -4.63526636e-01f, -8.35414305e-02f, -8.70022774e-02f, -6.55646771e-02f, -3.00964005e-02f, -2.25861818e-02f, 8.89945626e-02f, 1.23359665e-01f,
  -3.33103389e-01f, -7.30350837e-02f, 1.54703766e-01f, -1.36451617e-01f, -2.08337344e-02f, -2.52014920e-02f, -6.96587488e-02f, -7.41586611e-02f, -1.37807325e-01f, 6.01769760e-02f,
  2.01400067e-03f, 5.09355702e-02f, -1.49586588e-01f, 3.33800237e-03f, -4.16317172e-02f, -1.40095688e-02f, 3.14863175e-02f, -2.27573849e-02f, -3.50603461e-02f, -2.15157252e-02f,
  2.36482888e-01f, 1.45427391e-01f, -1.28285334e-01f, 1.19316995e-01f, -5.47186099e-02f, -8.49326178e-02f, -9.21065081e-03f, 1.26091793e-01f, 9.73791704e-02f, -4.43101004e-02f,
  7.49716982e-02f, -3.18234786e-02f, 8.18082467e-02f, -3.46920379e-02f, 6.70674592e-02f, 2.90484307e-03f, 5.13964072e-02f, 2.21079728e-03f, -1.59651674e-02f, -6.53789565e-02f,
  -9.55299586e-02f, 2.99363323e-02f, 1.59474872e-02f, -2.61258669e-02f, 1.59224644e-02f, -8.04667547e-02f, 1.58339754e-01f, -8.86600558e-03f, 1.02712899e-01f, 6.48602173e-02f,
  -3.99721488e-02f, -6.31188750e-02f, 5.06056994e-02f, 9.42815989e-02f, 1.75298899e-01f, -1.23482589e-02f, -4.67257127e-02f, -2.14084443e-02f, -7.57895485e-02f, 1.69695076e-02f,
  -4.60868597e-01f, 6.28965944e-02f, -6.32489100e-02f, 1.33241182e-02f, -1.55241847e-01f, 4.52672057e-02f, -1.80307046e-01f, -1.14452774e-02f, -1.66815460e-01f, -4.49565984e-02f,
  1.14906952e-01f, -8.94352123e-02f, -9.75091979e-02f, 5.59356995e-02f, -8.44636038e-02f, 5.41664809e-02f, 2.35136412e-02f, -2.22092904e-02f, 4.87608016e-02f, -1.08067170e-02f,
  1.14962935e-01f, 1.38039216e-01f, -7.50899985e-02f, 9.48440880e-02f, -3.52946930e-02f, -9.56453755e-02f, -1.07249774e-01f, 3.46647352e-02f, -4.37590340e-03f, -1.42987937e-01f,
  -4.70659018e-01f, -3.62318784e-01f, 1.14892855e-01f, -3.65879744e-01f, -8.02271143e-02f, 2.02251393e-02f, -3.48062098e-01f, 2.73540877e-02f, -1.26053914e-01f, -4.49285358e-01f,
  -2.15198234e-01f, 3.92383337e-02f, -2.00509414e-01f, 8.11799467e-02f, 1.14586666e-01f, -3.44239682e-01f, -2.07493767e-01f, 1.92910478e-01f, 5.39020240e-01f, 2.38939658e-01f,
  -4.89688292e-02f, -4.82001081e-02f, 3.05124909e-01f, 1.97101921e-01f, -3.07181835e-01f, 4.57947627e-02f, -2.36988708e-01f, -8.65794644e-02f, 7.30532110e-02f, -4.84598786e-01f,
  -2.92149246e-01f, -2.29829587e-02f, 7.54086822e-02f, -3.24435979e-02f, 5.66470139e-02f, -4.12044153e-02f, -5.75272068e-02f, -1.62265159e-03f, 7.24493489e-02f, -8.39175433e-02f,
  8.30087438e-03f, 1.16280153e-01f, -9.51444614e-04f, -5.46614174e-03f, -2.22561881e-02f, -7.58385137e-02f, 8.40705484e-02f, 8.19874704e-02f, 2.67297085e-02f, -7.91843683e-02f,
  -8.76890942e-02f, -3.91515233e-02f, 3.84511426e-02f, 1.11045867e-01f, 5.27009070e-02f, 9.59442556e-02f, 9.00116861e-02f, 3.17407161e-01f, 2.21782371e-01f, -2.83649087e-01f,
  4.32603732e-02f, -1.50877837e-04f, -1.53810736e-02f, 1.37246028e-02f, 1.61504578e-02f, 2.84104813e-02f, -6.22061975e-02f, -5.48519976e-02f, 1.72273144e-02f, -1.47521943e-02f,
  -5.79789802e-02f, -8.81283602e-04f, -1.30961919e-02f, -5.91448322e-02f, -3.55098881e-02f, -5.32902265e-03f, -1.54649615e-02f, 4.18328717e-02f, 5.20543344e-02f, -2.39521973e-02f,
  1.81866102e-02f, 1.27264056e-02f, 6.73408248e-03f, 3.16941626e-02f, -2.22367123e-02f, -7.74065731e-03f, 3.94268632e-02f, 2.67894212e-02f, 5.50546497e-02f, -9.85288993e-02f,
  -1.83558226e-01f, 2.40832359e-01f, -2.64903069e-01f, -7.86871067e-04f, -9.02006105e-02f, 8.31679925e-02f, -6.14567287e-02f, 1.30924135e-01f, -6.73743635e-02f, -8.67717937e-02f,
  9.23533589e-02f, -6.00964017e-02f, -9.06937644e-02f, 9.92734358e-02f, -2.12844014e-02f, -2.38716193e-02f, -1.70230210e-01f, -7.94646814e-02f, 8.43588188e-02f, 2.34366003e-02f,
  8.57405066e-02f, -5.74411266e-02f, -2.19049886e-01f, -1.20512761e-01f, -7.40950555e-02f, -1.53621197e-01f, -1.14358835e-01f, -1.28315389e-02f, -3.42206955e-02f, -3.05551887e-01f,
  -8.77538994e-02f, -1.54847324e-01f, 2.33074650e-01f, 1.11902662e-01f, 9.91206542e-02f, -3.70533943e-01f, -5.71639478e-01f, -5.54426551e-01f, -3.52829695e-02f, -5.89528792e-02f,
  -2.42111087e-02f, 1.70739561e-01f, 1.46376938e-01f, -3.29453335e-03f, -3.19633693e-01f, -2.31215924e-01f, 1.14601441e-01f, 1.18890539e-01f, -4.22674268e-02f, -1.67270094e-01f,
  1.35307461e-01f, 2.22771540e-01f, 2.10821301e-01f, -1.32226616e-01f, 1.23882398e-01f, 1.30764797e-01f, 7.84152374e-02f, 1.93955705e-01f, 2.02344686e-01f, 5.75061500e-01f,
  3.93568456e-01f, 1.52325956e-02f, -5.07134348e-02f, 6.09938242e-02f, 2.38040492e-01f, 4.39672545e-02f, -1.42459031e-02f, 2.83376426e-02f, -1.21871300e-01f, 3.41361538e-02f,
  2.59413719e-01f, 8.42069164e-02f, -8.33075680e-03f, 1.24238834e-01f, -1.85960513e-02f, -9.63724703e-02f, -1.58812273e-02f, -5.97984996e-03f, -1.87892482e-01f, -1.53205693e-01f,
  1.41357109e-01f, 1.78259775e-01f, -1.79742947e-01f, -3.52730274e-01f, -1.82741120e-01f, 1.01135038e-01f, -1.33066192e-01f, 3.56959961e-02f, -1.11116283e-01f, 3.37550021e-03f,
  8.18713754e-02f, 2.12566443e-02f, 1.34042606e-01f, 2.41181925e-02f, -1.02128804e-01f, -1.00470915e-01f, 1.36153087e-01f, -6.40378594e-02f, -2.78309286e-02f, -6.94763213e-02f,
  -3.45429056e-03f, 3.69370952e-02f, 7.72303790e-02f, -5.81762977e-02f, -8.71772468e-02f, 1.48560897e-01f, 2.54264772e-02f, 3.73489410e-02f, 4.23438475e-03f, -2.09420361e-03f,
  -5.14225895e-03f, -8.61572251e-02f, 7.46444464e-02f, -2.35506799e-02f, -3.08213197e-02f, 6.38201907e-02f, 4.04329225e-02f, -3.90256383e-02f, 4.78558093e-02f, 1.31767347e-01f,
  -1.36290833e-01f, -1.98617637e-01f, -8.47372413e-03f, -4.28989343e-02f, 8.55060369e-02f, 1.28448650e-01f, 7.42178261e-02f, 8.40135664e-02f, 1.25663504e-01f, -7.51838982e-02f,
  -1.78234279e-02f, -6.09604046e-02f, -7.55488798e-02f, -2.72811037e-02f, -8.60412791e-02f, 2.77801324e-02f, 3.57088521e-02f, -1.44810160e-03f, -5.80525845e-02f, -1.61971394e-02f,
  -9.67149138e-02f, -2.46022373e-01f, -2.58181423e-01f, -2.11162001e-01f, 4.72749770e-03f, -1.27763674e-01f, -8.66785869e-02f, -2.38471441e-02f, -1.28994659e-01f, -1.88521743e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -1.95560083e-01f, 2.29265615e-01f, 2.93817401e-01f, -2.50971347e-01f, 2.07718253e-01f, -2.82294955e-02f, 2.90583342e-01f, 1.13971874e-01f, 1.76073506e-01f, 3.06353420e-01f,
  -3.03028561e-02f, 6.64697066e-02f, 4.21512462e-02f, 3.97182666e-02f, 6.40444085e-02f, 3.33957046e-01f, 2.87768822e-02f, -8.92475396e-02f, 5.10757789e-03f, 9.28078219e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.43533254e-02f, 1.37770679e-02f, -7.25779906e-02f, -9.50746909e-02f, 8.94143209e-02f, 8.17528516e-02f, -6.79104775e-02f, -3.86975743e-02f, 9.44677666e-02f, 7.21339807e-02f,
  2.13296950e-01f, 1.16386367e-02f, 1.22523874e-01f, -1.41764924e-01f, 4.32380562e-04f, 1.68541059e-01f, 1.67695478e-01f, 2.66596437e-01f, -2.00792432e-01f, -1.39260679e-01f,
  3.11399132e-01f, -1.20559946e-01f, 4.99411784e-02f, -1.47745520e-01f, -2.97201257e-02f, -1.49928749e-01f, -1.95736349e-01f, -1.38009354e-01f, -2.63800204e-01f, -1.44334510e-01f,
  -1.15458705e-01f, 4.72791880e-01f, -3.82949077e-02f, -9.15809050e-02f, 2.85540894e-02f, -2.60622967e-02f, 6.38984665e-02f, -8.78819227e-02f, 1.24263048e-01f, -5.96313030e-02f,
  -6.46068901e-02f, 1.05418004e-01f, 2.56507099e-01f, 6.51103854e-02f, -2.73413450e-01f, -3.38877797e-01f, 1.37486890e-01f, 4.04486001e-01f, 2.38174617e-01f, 1.31728992e-01f,
  -1.82378814e-01f, 8.61829072e-02f, 2.51114577e-01f, 2.56815463e-01f, -3.47317189e-01f, 8.68327171e-02f, 5.44540174e-02f, 1.55636311e-01f, 1.67607218e-01f, -1.92245021e-01f,
  -2.07995549e-01f, -5.52773429e-03f, -2.46556967e-01f, -3.35384667e-01f, 6.85195103e-02f, 2.86953654e-02f, 6.95674717e-02f, 3.78130861e-02f, -2.04989742e-02f, 7.12966397e-02f,
  1.37534261e-01f, -1.69468030e-01f, -7.39328489e-02f, 1.33234710e-01f, -2.98823211e-02f, -1.03107050e-01f, 2.52213515e-02f, 1.64347216e-02f, -5.18675447e-01f, -2.63959050e-01f,
  4.17520627e-02f, -7.43028820e-02f, -1.17008403e-01f, 1.68313146e-01f, -1.52778551e-01f, 2.64580905e-01f, -9.35152471e-02f, 3.06570917e-01f, 3.01588058e-01f, 1.94703430e-01f,
  1.62184924e-01f, -6.07133918e-02f, 1.31321415e-01f, -4.01374459e-01f, -3.85826766e-01f, -4.41426545e-01f, -3.02685518e-03f, 7.08626509e-02f, 9.98569932e-03f, 8.40284377e-02f,
  3.72918919e-02f, 7.93250203e-02f, -1.49492711e-01f, 1.07927255e-01f, 1.10234700e-01f, -1.44326463e-01f, -3.00027668e-01f, -1.11589633e-01f, 1.35833904e-01f, 1.47354051e-01f,
  2.03987598e-01f, 1.43687457e-01f, -5.72433397e-02f, -2.22401455e-01f, -1.95460021e-01f, 8.10419768e-02f, -3.14571142e-01f, -4.13772225e-01f, -6.36845902e-02f, 2.67980504e-03f,
  3.56492400e-01f, -1.49280980e-01f, -6.80807382e-02f, -4.04881299e-01f, -1.39446184e-01f, -2.20581487e-01f, 3.23246568e-01f, -2.67854124e-01f, 8.56371373e-02f, -1.16120867e-01f,
  -1.23006992e-01f, -1.39803559e-01f, -2.52467953e-02f, -7.27732927e-02f, -1.54512927e-01f, 2.46646050e-02f, 8.11734796e-02f, -4.83075716e-02f, -6.25082403e-02f, -4.62574847e-02f,
  -1.70901760e-01f, 1.16202258e-01f, -4.13533486e-02f, 1.79710731e-01f, -1.28013581e-01f, -1.06078953e-01f, -2.23213643e-01f, -6.22920319e-02f, 1.81736853e-02f, 2.00450374e-03f,
  -1.33953661e-01f, -1.29336819e-01f, -1.75376385e-01f, 2.38877714e-01f, -1.27436087e-01f, 2.76625723e-01f, 7.01650381e-02f, 8.55153203e-02f, 5.81599236e-01f, 4.05292600e-01f,
  1.12136699e-01f, -4.54377308e-02f, 5.45417815e-02f, 7.13799670e-02f, 4.52655144e-02f, 1.16177381e-03f, 6.29530177e-02f, 1.39731902e-03f, -4.87230644e-02f, -7.40618557e-02f,
  -5.24417311e-02f, -6.87586814e-02f, -1.94706678e-01f, 1.25469655e-01f, -1.86696723e-01f, 2.16773078e-01f, 2.83695403e-02f, -9.30950642e-02f, -3.28807652e-01f, 2.75156289e-01f,
  -2.32160129e-02f, -1.54173568e-01f, 8.04658793e-03f, 1.17319673e-01f, 1.82856932e-01f, 1.71691626e-01f, 2.39909038e-01f, -4.42392845e-03f, -4.45092954e-02f, -2.08897606e-01f,
  1.91475432e-02f, -2.62967288e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -8.78625456e-03f, 2.28192851e-01f, 2.35311799e-02f, 1.22517325e-01f, -1.64476298e-02f, 5.36303446e-02f, 6.89466298e-02f, 1.92962095e-01f, -8.90569910e-02f, -7.18423426e-02f,
  -1.27459437e-01f, -1.65982276e-01f, 1.35130301e-01f, 3.02647799e-01f, 3.35463315e-01f, 1.50486842e-01f, -2.17188224e-01f, 1.35863885e-01f, 2.98841834e-01f, 1.56624347e-01f,
  1.29325604e-02f, -1.12334758e-01f, -1.43031210e-01f, -2.70023465e-01f, -2.63513182e-03f, 2.43031397e-01f, -1.73993126e-01f, 2.11118106e-02f, 1.89265341e-01f, 3.04679722e-01f,
  5.06880939e-01f, -1.78324804e-01f, 6.40674159e-02f, 7.59523064e-02f, 2.00014636e-01f, 1.54484764e-01f, 3.37408751e-01f, 1.80049881e-01f, -6.31777802e-04f, 6.71186000e-02f,
  8.52407981e-03f, 2.73852289e-01f, 3.03253462e-03f, 3.74513477e-01f, -7.24350810e-02f, -1.16599374e-01f, -7.94492960e-02f, 1.71295516e-02f, 4.09450591e-01f, -1.08103454e-01f,
  3.09840459e-02f, -1.08422093e-01f, 1.43496320e-01f, 4.44400817e-01f, 1.76481325e-02f, 2.27392435e-01f, -2.56775022e-01f, 5.54093011e-02f, 1.89361751e-01f, 3.92599672e-01f,
  -2.33826023e-02f, -3.22414339e-01f, -5.80878198e-01f, 2.87573218e-01f, -4.53026667e-02f, 1.65236935e-01f, 6.98174760e-02f, 1.53315648e-01f, -8.35291445e-02f, 2.35252559e-01f,
  -4.01290171e-02f, -1.49399387e-02f, -1.11588735e-04f, -7.72645473e-02f, -2.93536335e-01f, 8.13802034e-02f, 3.15654986e-02f, 3.38193446e-01f, 3.57999466e-02f, -3.35366160e-01f,
  1.05376944e-01f, -3.55294704e-01f, 3.49828571e-01f, 1.41647935e-01f, -2.20591933e-01f, 1.72352001e-01f, 3.14643592e-01f, -1.64488629e-01f, -1.23000897e-01f, 1.49791777e-01f,
  3.07650715e-01f, 2.16467813e-01f, 2.83700258e-01f, 1.23821631e-01f, -3.76369357e-01f, 9.69184190e-02f, -6.42765872e-03f, -2.39314586e-02f, -6.46309704e-02f, -9.54169780e-02f,
  1.43933669e-01f, 1.01476841e-01f, 2.80664358e-02f, -2.10299879e-01f, -6.53582290e-02f, 3.12431782e-01f, -1.33096576e-01f, 3.38285357e-01f, 6.16140328e-02f, 8.58768970e-02f,
  2.70231128e-01f, 3.58797282e-01f, 2.59273112e-01f, -3.52724977e-02f, -3.90873432e-01f, 2.75145143e-01f, 8.56444389e-02f, -2.21126810e-01f, 6.80895448e-02f, -1.14964887e-01f,
  -9.27402899e-02f, 1.84112415e-01f, -1.76988952e-02f, 5.23396358e-02f, -1.38763592e-01f, 2.77116030e-01f, -7.26735741e-02f, -1.19742878e-01f, 1.09345831e-01f, 9.68114510e-02f,
  -6.36785775e-02f, -3.34360674e-02f, 3.88648957e-01f, 1.80617586e-01f, -6.11433834e-02f, -1.27832338e-01f, 5.17168231e-02f, -3.34077269e-01f, -6.02065802e-01f, -9.24547836e-02f,
  -3.43427271e-01f, 3.56885493e-01f, 9.72889140e-02f, 2.22085044e-01f, -1.71272129e-01f, -2.28004217e-01f, -1.57283142e-01f, 1.35843828e-01f, 1.86758041e-01f, -1.86072122e-02f,
  8.79008695e-03f, -2.01430649e-01f, -3.72497439e-01f, -2.74132907e-01f, -4.60018730e-03f, 6.30987704e-01f, 1.82979167e-01f, -3.48332501e-03f, 7.43656576e-01f, 3.66839498e-01f,
  2.60430545e-01f, 2.04126075e-01f, 8.99595618e-02f, 1.61541123e-02f, 1.61428005e-01f, 2.55505204e-01f, -1.60311058e-01f, -9.83892530e-02f, -3.45728993e-02f, 2.25773543e-01f,
  -1.34476572e-01f, 1.94552109e-01f, -2.18574733e-01f, -1.31742686e-01f, 9.53761023e-03f, 1.19660916e-02f, 4.38653439e-01f, 9.44756642e-02f, -6.16927929e-02f, 2.16587842e-01f,
  2.91721113e-02f, 2.18058616e-01f, -6.10668994e-02f, 4.52662483e-02f, 2.41130907e-02f, 1.94682255e-01f, 3.32338780e-01f, 1.32653072e-01f, 1.35965705e-01f, -4.09261644e-01f,
  -2.51710176e-01f, -1.79710254e-01f, 1.17182016e-01f, 1.54605940e-01f, 1.87726319e-01f, 8.66396911e-03f, 8.21629167e-02f, -1.41202152e-01f, 1.69030607e-01f, 2.65388370e-01f,
  4.04095590e-01f, -1.40226126e-01f, 3.79679799e-01f, -1.96764246e-01f, -2.06242174e-01f, 8.04814324e-02f, 3.21198106e-01f, 3.30265194e-01f, 1.22378938e-01f, 1.30414397e-01f,
  4.92236644e-01f, 1.29783124e-01f, 2.43184298e-01f, 2.91669339e-01f, 2.15705857e-01f, -1.83572337e-01f, 2.05161627e-02f, -2.84128040e-01f, -1.21963158e-01f, -3.28069240e-01f,
  2.84408748e-01f, 6.98839545e-01f, 4.53585327e-01f, -2.01791897e-01f, 9.63316858e-02f, 2.03196213e-01f, 1.85927734e-01f, 3.82326722e-01f, 4.97923605e-02f, 5.04031479e-02f,
  -2.37939119e-01f, 2.44749263e-01f, -1.69979349e-01f, 2.15287521e-01f, 4.61013347e-01f, 3.19128707e-02f, -4.44369704e-01f, -3.45732234e-02f, -3.41365099e-01f, 7.54111335e-02f,
  4.42708790e-01f, 2.48123467e-01f, 2.02754468e-01f, -4.68746759e-02f, 2.07163423e-01f, -2.82230049e-01f, -1.03014447e-01f, 2.18734667e-01f, 3.79151702e-01f, -7.54472539e-02f,
  3.00283525e-02f, -5.88774204e-01f, 2.84304440e-01f, 1.41854137e-01f, -9.03789997e-02f, -3.67933363e-02f, 5.35805710e-02f, 2.01360375e-01f, 3.41990255e-02f, 1.89449549e-01f,
  -2.93444004e-02f, 3.24981570e-01f, 7.92491287e-02f, -4.31263477e-01f, -3.63706738e-01f, -1.49599537e-01f, -3.78958166e-01f, 7.80303553e-02f, -1.33697808e-01f, -1.34081960e-01f,
  -4.15973514e-02f, 1.89105272e-01f, 6.71254694e-02f, -2.57274777e-01f, -1.25007644e-01f, 2.14763775e-01f, -1.27796724e-01f, 1.70882076e-01f, -3.88060957e-02f, 4.47545163e-02f,
  -2.00891793e-01f, 2.85164475e-01f, 3.26754786e-02f, 4.96717930e-01f, -4.61462699e-03f, -4.70323175e-01f, -3.61042053e-01f, -4.84631360e-02f, 9.97083448e-03f, 2.11519703e-01f,
  1.89078286e-01f, -4.64705080e-02f, 1.29806295e-01f, 3.11400682e-01f, -1.88286483e-01f, 2.02148482e-01f, 1.45812824e-01f, -2.39464015e-01f, -3.49405408e-01f, -9.31202993e-02f,
  -3.82728912e-02f, 1.47231072e-01f, 3.63421470e-01f, 1.51504770e-01f, -3.14968079e-03f, -5.39073586e-01f, -4.96650815e-01f, 4.14208442e-01f, -1.36538461e-01f, -1.57358840e-01f,
  9.29618329e-02f, 1.15037717e-01f, 2.84668922e-01f, 1.38788968e-01f, 1.17680840e-01f, -1.55743971e-01f, -1.15552068e-01f, -9.14454460e-02f, 5.01141369e-01f, -1.54813200e-01f,
  -5.21565080e-02f, 1.12641610e-01f, 4.07717004e-02f, 1.57912835e-01f, -1.16140939e-01f, 3.92910503e-02f, 1.60152033e-01f, -5.28703891e-02f, 3.54858302e-02f, -4.67690229e-02f,
  -2.71622688e-02f, 2.07005665e-01f, 1.34620383e-01f, 1.62885189e-01f, -1.15990773e-01f, -1.62592366e-01f, -2.25498170e-01f, -2.16373146e-01f, 1.15902022e-01f, 1.74801692e-01f,
  -2.88718529e-02f, 3.30406219e-01f, 7.03607593e-03f, 3.73817116e-01f, -3.20637897e-02f, 1.73797593e-01f, -1.63697954e-02f, 3.93357277e-01f, 1.54570416e-01f, -3.02984146e-03f,
  -4.62257028e-01f, 3.15642297e-01f, 1.80676535e-01f, -5.43009676e-02f, 3.50692049e-02f, 2.67012149e-01f, 1.02301881e-01f, 9.98227671e-02f, -7.83190057e-02f, 1.85103435e-02f,
  2.67691433e-01f, 2.21776906e-02f, -2.69914061e-01f, -1.06392361e-01f, 4.25779186e-02f, 3.11669767e-01f, -1.02588041e-02f, -2.68512547e-01f, -1.38945624e-01f, -2.40945980e-01f,
  2.97687382e-01f, 1.15697026e-01f, -2.71221567e-02f, 2.60556906e-01f, 1.62801623e-01f, -1.33630736e-02f, -2.80820519e-01f, 1.30871236e-01f, -1.37629583e-01f, 3.07149529e-01f,
  1.61040470e-01f, -1.76660404e-01f, -5.00567667e-02f, 4.02046859e-01f, 1.46826819e-01f, 8.21060687e-02f, -1.17762968e-01f, 3.57020460e-02f, 2.64793307e-01f, 3.10737222e-01f,
  2.42439006e-02f, -3.11786175e-01f, -2.42301643e-01f, 1.28535345e-01f, 5.22837602e-02f, 1.87852606e-01f, -4.66675460e-02f, -2.57574558e-01f, 3.30523551e-01f, 3.49719882e-01f,
  3.78818452e-01f, 2.72614777e-01f, 5.98543324e-02f, 2.93086380e-01f, 3.86713743e-01f, -6.46202192e-02f, -1.11034900e-01f, -7.59532303e-02f, -3.46364498e-01f, -1.48491502e-01f,
  1.15826363e-02f, 3.68221790e-01f, -6.21329606e-01f, 7.55291283e-02f, -1.89653710e-01f, 5.90978898e-02f, 1.05164714e-01f, 7.93215111e-02f, 2.49099046e-01f, 1.14341095e-01f,
  1.41791761e-01f, 1.76232219e-01f, 7.61374310e-02f, 8.19082335e-02f, 5.45277782e-02f, -1.19816199e-01f, -8.38924274e-02f, 1.02616675e-01f, -8.51493180e-02f, -3.90256047e-02f,
  7.68162012e-02f, 9.72045735e-02f, -1.20260410e-01f, 8.03633779e-02f, -1.58625338e-02f, 2.08826318e-01f, -2.32355133e-01f, -5.78448027e-02f, -3.36881801e-02f, -4.33837157e-03f,
  4.25339431e-01f, -1.05942816e-01f, 2.05581218e-01f, -1.90920189e-01f, 1.50574803e-01f, 2.70404130e-01f, 1.50299877e-01f, -4.61107224e-01f, -4.22225147e-03f, 1.02039546e-01f,
  -5.18788621e-02f, 1.86927974e-01f, 2.54126757e-01f, 7.67110661e-02f, -4.43217270e-02f, -5.27580604e-02f, -2.28873745e-01f, 3.04717511e-01f, 9.31565017e-02f, -4.56966087e-02f,
  -2.10340217e-01f, -3.77119273e-01f, 1.70019958e-02f, 1.72069252e-01f, 1.69414237e-01f, 4.59076017e-01f, 5.99589050e-02f, -1.62461579e-01f, 3.34622681e-01f, 5.25379777e-01f,
  -1.86735362e-01f, 2.47375876e-01f, 1.83115005e-01f, 7.08295219e-03f, 3.68971199e-01f, -2.61036456e-02f, -1.78360999e-01f, -7.96614364e-02f, -5.54035082e-02f, -3.91736001e-01f,
  5.13397269e-02f, 1.06814317e-01f, 2.14350298e-02f, 3.20502281e-01f, 5.30719906e-02f, 5.58393784e-02f, -1.08382531e-01f, 5.35584316e-02f, -3.46227199e-01f, -1.69379339e-01f,
  -5.59344411e-01f, 7.90504664e-02f, -1.12936854e-01f, 1.02962323e-01f, -1.56970173e-01f, 1.79490671e-01f, -7.03249872e-03f, -6.16402745e-01f, -3.61728758e-01f, 4.05176044e-01f,
  -3.22793245e-01f, -2.15075240e-01f, 2.46187389e-01f, -1.96784616e-01f, 1.44885153e-01f, 2.44934991e-01f, 5.36709838e-02f, 6.85651451e-02f, 2.71804333e-01f, -1.87848747e-01f,
  -3.58642004e-02f, -1.86087728e-01f, -2.25903299e-02f, 2.85398871e-01f, 5.18811084e-02f, 1.02037348e-01f, 2.54146546e-01f, 1.46995466e-02f, 1.21752091e-01f, 1.35594383e-01f,
  4.47204262e-02f, 1.47529589e-02f, 2.04268098e-02f, -1.03772886e-01f, 1.39602162e-02f, 1.24836251e-01f, 1.32148102e-01f, 4.59430218e-02f, 3.83178949e-01f, 3.64776224e-01f,
  4.34272915e-01f, 1.45240590e-01f, 3.29277456e-01f, 6.22897089e-01f, 1.87354669e-01f, -2.45674357e-01f, 7.37266019e-02f, 1.66979387e-01f, 1.53225228e-01f, 1.50941074e-01f,
  1.28053114e-01f, 5.45117736e-01f, 5.32560982e-02f, 1.20022610e-01f, 9.09905732e-02f, -6.75291419e-02f, -8.54525492e-02f, 1.38375401e-01f, 1.46636054e-01f, -5.23836203e-02f,
  -3.14549766e-02f, -8.07291642e-02f, -3.83720659e-02f, 2.52811700e-01f, -7.48386830e-02f, -1.50254384e-01f, 2.78576165e-02f, -1.89802574e-03f, -3.06422357e-02f, -3.48852836e-02f,
  -2.84649611e-01f, -2.38968849e-01f, -6.86364844e-02f, 8.61062109e-02f, -2.02735022e-01f, 2.50848651e-01f, -2.07627475e-01f, 4.62124884e-01f, 3.12295258e-01f, 2.72076845e-01f,
  -1.76615361e-02f, 2.34153926e-01f, 8.39642957e-02f, -6.21529371e-02f, -7.91128352e-02f, -3.37066770e-01f, -4.66056131e-02f, 3.18281651e-01f, 1.79847836e-01f, 2.26052687e-01f,
  1.09666340e-01f, 2.43557364e-01f, -9.32310745e-02f, 2.86973536e-01f, -1.42239004e-01f, -7.10572675e-02f, -2.45162144e-01f, 1.22367166e-01f, -1.99597657e-01f, 2.76940670e-02f,
  -1.10375568e-01f, -2.00420581e-02f, 1.18913963e-01f, -2.23121092e-01f, -3.95952970e-01f, 2.98452824e-01f, -2.72232383e-01f, -2.62902111e-01f, 2.71875560e-01f, 1.43039927e-01f,
  3.65875036e-01f, -3.31469923e-01f, 3.27046998e-02f, -2.57002860e-01f, 1.14026658e-01f, 1.79574296e-01f, 3.31621664e-03f, -3.04978579e-01f, -1.46228090e-01f, -6.95710108e-02f,
  -6.77514225e-02f, -7.64266700e-02f, -1.11005843e-01f, -9.86430794e-02f, -3.01281456e-02f, -6.51547536e-02f, 1.05571724e-01f, 6.09902740e-02f, 1.10084645e-01f, -8.30779001e-02f,
  5.13352342e-02f, -8.09421763e-03f, 1.15411408e-01f, 2.80259550e-01f, -1.78140998e-01f, 2.27097645e-01f, 2.78632522e-01f, 3.47369790e-01f, -2.85899714e-02f, -3.26845944e-02f,
  1.55338764e-01f, -4.45652544e-01f, 2.14827031e-01f, 1.35489389e-01f, -3.63406055e-02f, -4.38514739e-01f, 1.00665696e-01f, 4.88224745e-01f, 1.51254550e-01f, -4.37142104e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -5.85030094e-02f, 6.40611798e-02f, 1.07971251e-01f, 2.79360950e-01f, 2.09526211e-01f, -7.61917755e-02f, 1.44318134e-01f, -1.06475102e-02f, 7.19169080e-02f, -1.03112064e-01f,
  7.32121617e-02f, 3.11616540e-01f, 2.01595068e-01f, 1.45173492e-03f, 2.19691053e-01f, 1.40517980e-01f, 1.93439528e-01f, -8.33924338e-02f, 1.47356048e-01f, -2.60962158e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.77198648e-01f, 1.20283954e-01f, -1.28613994e-01f, 1.97210148e-01f, 4.91213620e-01f, 9.08967778e-02f, 8.55280235e-02f, 2.19800752e-02f, -1.14796184e-01f, -3.38333070e-01f,
  -1.94165438e-01f, -8.16124678e-02f, -8.47614482e-02f, 2.17282504e-01f, 1.17054641e-01f, -9.78900492e-02f, -2.12974012e-01f, -8.07943940e-02f, 1.81235731e-01f, 3.38872492e-01f,
  -1.39508277e-01f, -5.74191734e-02f, -5.97003624e-02f, -9.44540799e-02f, 1.16714798e-01f, -5.50467409e-02f, -3.46870758e-02f, -2.64892936e-01f, 2.05908865e-01f, -1.68607607e-02f,
  4.35797721e-02f, -4.53066155e-02f, -1.34832308e-01f, 1.25114009e-01f, 1.24795981e-01f, -8.96056592e-02f, -1.22180544e-02f, -1.11816369e-01f, -9.07635391e-02f, -4.92320210e-01f,
  -2.44637690e-02f, 2.92141363e-02f, 5.80370165e-02f, -1.33023351e-01f, 2.72810251e-01f, -1.33978054e-01f, 1.10083520e-01f, 2.95726806e-01f, 4.26944979e-02f, -1.61006957e-01f,
  -2.03630880e-01f, -4.42806482e-01f, 3.98262531e-01f, -1.40760038e-02f, -3.23360157e-03f, -4.97950017e-02f, -4.74046916e-02f, -1.06410787e-01f, -4.65296149e-01f, 4.29772705e-01f,
  6.66436702e-02f, -9.78511572e-02f, -5.66006377e-02f, 2.34114945e-01f, 1.09817877e-01f, -1.16490483e-01f, 2.84306258e-01f, 2.90868133e-01f, -1.17473945e-01f, 1.18672848e-01f,
  1.94889113e-01f, 1.69977084e-01f, -6.05044253e-02f, -3.72092515e-01f, -4.85112011e-01f, -4.57137339e-02f, -1.88705876e-01f, 3.15785825e-01f, 1.06031828e-01f, 6.76789954e-02f,
  -2.32737839e-01f, 1.82486072e-01f, 1.10594764e-01f, -1.24965264e-02f, 1.46568492e-01f, -2.53773868e-01f, -8.52127597e-02f, -4.19167290e-03f, 2.72522360e-01f, -2.27214441e-01f,
  2.38802880e-01f, -3.82721834e-02f, 1.11273574e-02f, -2.07709387e-01f, -2.82331377e-01f, -2.31678307e-01f, 3.07772964e-01f, 2.63531059e-01f, -5.16444780e-02f, 3.38169634e-01f,
  2.59013087e-01f, 2.33986914e-01f, 3.20370913e-01f, -2.10072696e-01f, -1.40723974e-01f, 2.61684239e-01f, -2.30259914e-02f, -1.30443379e-01f, 2.00075787e-02f, -1.44244090e-01f,
  2.39552945e-01f, 4.07033920e-01f, 1.42058926e-02f, -1.05114825e-01f, 1.12168126e-01f, -4.62511837e-01f, 4.56125848e-02f, 1.66537106e-01f, -1.82029977e-01f, 8.28940272e-02f,
  4.21533436e-01f, -1.10247739e-01f, -2.28427202e-01f, 2.69875705e-01f, 1.62113588e-02f, -2.55281091e-01f, 2.31633320e-01f, 3.07825413e-02f, 2.71730036e-01f, -5.25009260e-02f,
  1.91135183e-01f, 9.29157957e-02f, 1.53981298e-01f, 4.30855364e-01f, 6.20360672e-01f, -2.72773296e-01f, 4.59333397e-02f, -4.06034999e-02f, 1.23729102e-01f, -2.16181844e-01f,
  -1.95864871e-01f, 7.27254823e-02f, 1.75615177e-01f, 9.03947800e-02f, -1.63476422e-01f, 1.68896094e-01f, 8.27635676e-02f, 5.78205138e-02f, 7.18837306e-02f, -1.21277496e-01f,
  -2.75299698e-01f, -1.59365624e-01f, 2.95096308e-01f, -1.54438421e-01f, -3.11961751e-02f, 3.84960622e-02f, -5.05361520e-02f, -2.92021304e-01f, 9.79670882e-02f, -1.06368333e-01f,
  8.26255456e-02f, 8.38720426e-02f, 4.35153246e-01f, 2.51362771e-01f, 1.22427121e-01f, 9.79826599e-02f, -2.76947152e-02f, 4.30028588e-01f, -1.88014984e-01f, -1.05850726e-01f,
  -1.31011024e-01f, 2.32615083e-01f, 1.63117170e-01f, 2.56921053e-01f, -1.85212940e-01f, 1.59932062e-01f, -1.73465684e-01f, -2.07230393e-02f, -3.08395356e-01f, 1.11975051e-01f,
  4.80970740e-02f, 3.42410267e-03f, 1.46559447e-01f, -2.24396680e-02f, 2.39562511e-01f, -1.56652957e-01f, -2.49531567e-01f, -1.92643806e-01f, 6.53522238e-02f, 5.44404276e-02f,
  -1.34704426e-01f, -3.12666467e-04f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.45017880e-01f, 2.01641411e-01f, 1.18922591e-01f, 4.82673734e-01f, 3.21927100e-01f, 3.65843385e-01f, -2.54109263e-01f, 4.81160522e-01f, 5.72670519e-01f, 1.59113944e-01f,
  -3.65454197e-01f, 8.82715583e-02f, -2.68664926e-01f, 4.18695509e-01f, 8.91618505e-02f, -8.48080292e-02f, 2.36510083e-01f, 2.81767040e-01f, -2.19455495e-01f, -3.86871070e-01f,
  4.58218217e-01f, -1.52321002e-02f, -3.98738794e-02f, 7.73412436e-02f, 7.82398954e-02f, -5.69668114e-02f, 2.01236993e-01f, -1.40672941e-02f, -4.14436907e-02f, 8.79382640e-02f,
  -1.56142488e-01f, -1.95818767e-01f, 2.08790481e-01f, 3.59330982e-01f, 5.71031980e-02f, 1.93886198e-02f, -2.04196215e-01f, -1.02563180e-01f, -2.92862833e-01f, -2.19174281e-01f,
  2.74379551e-01f, 3.77718836e-01f, -3.59482825e-01f, 1.70716777e-01f, -3.67895029e-02f, -4.87687699e-02f, 1.16784424e-01f, -8.59554932e-02f, -2.07087919e-01f, 3.33456427e-01f,
  1.19397871e-01f, 4.98660028e-01f, 1.85768269e-02f, 3.99631262e-02f, 1.75765499e-01f, -3.56506743e-02f, -4.28753495e-01f, 3.66501153e-01f, 2.05582812e-01f, 6.02381229e-01f,
  -3.00484244e-02f, 2.72915691e-01f, 6.26000524e-01f, 2.71781534e-01f, 2.22661212e-01f, 2.76001811e-01f, 4.94463071e-02f, 3.30816984e-01f, 1.37912780e-01f, 5.43132424e-01f,
  4.31346148e-01f, -1.09946981e-01f, -6.71412528e-01f, 1.48961961e-01f, 3.86019230e-01f, -1.85937077e-01f, -4.51740474e-02f, 1.71263237e-02f, -3.83911997e-01f, 2.44910628e-01f,
  5.65540850e-01f, 2.18914077e-01f, 2.28197277e-01f, 2.96214670e-01f, -8.53742138e-02f, 6.66879639e-02f, -3.90378833e-01f, 3.73905189e-02f, 5.81575096e-01f, -1.65354893e-01f,
  2.09928930e-01f, -1.23118959e-01f, 8.99659246e-02f, -2.77910233e-01f, -1.13355748e-01f, -3.96803319e-02f, 1.92704335e-01f, 4.18375075e-01f, 6.50311336e-02f, 3.87787402e-01f,
  5.66028655e-01f, 4.67834413e-01f, -2.61741012e-01f, -5.55070117e-02f, 1.68649316e-01f, -3.65340263e-01f, -2.87031233e-01f, 2.25939289e-01f, 3.02426592e-02f, 3.65781546e-01f,
  1.15816504e-01f, -1.68779567e-01f, 1.27325609e-01f, 2.13620082e-01f, -2.64970422e-01f, -9.25725549e-02f, 5.59270978e-01f, -2.20824592e-02f, 3.17751855e-01f, 2.48087212e-01f,
  2.45039105e-01f, -2.61991024e-01f, -2.01873496e-01f, 1.57503486e-01f, 4.84593473e-02f, 1.34403616e-01f, -2.17697904e-01f, -1.61336556e-01f, 1.73813719e-02f, -3.53172384e-02f,
  5.06499037e-02f, -1.29225701e-02f, -1.19313151e-01f, 4.84648421e-02f, -2.61688024e-01f, -3.39762181e-01f, 1.93790004e-01f, 3.80086869e-01f, 2.59400010e-01f, -1.37056753e-01f,
  1.72593102e-01f, -3.26304138e-02f, 1.70209050e-01f, -1.45501748e-01f, 1.71370670e-01f, 3.45910788e-02f, -2.59219371e-02f, -1.71652973e-01f, 2.27496743e-01f, 1.83385521e-01f,
  8.04557372e-03f, 2.04024568e-01f, -2.65784204e-01f, -7.28624016e-02f, -4.23631370e-01f, 1.59377962e-01f, 7.71002099e-02f, 2.21981198e-01f, 3.80799145e-01f, 1.64289951e-01f,
  2.31384411e-01f, 2.36259803e-01f, 1.83357168e-02f, 3.26286286e-01f, 1.49229718e-02f, 3.05042624e-01f, 1.50030598e-01f, 6.22591913e-01f, 6.06330410e-02f, 3.25166702e-01f,
  -1.40122071e-01f, 9.34016034e-02f, 2.41923541e-01f, -9.10156816e-02f, -7.81911761e-02f, 2.61968434e-01f, -1.29751191e-01f, 2.96815544e-01f, 3.08314353e-01f, 4.31666553e-01f,
  -7.32628852e-02f, 3.01800072e-01f, -2.08310232e-01f, -2.06250489e-01f, 4.69163001e-01f, 3.99978220e-01f, 3.92067194e-01f, -5.55111356e-02f, 2.89112926e-01f, 1.31987482e-01f,
  2.06504479e-01f, 2.40382820e-01f, 1.03219785e-02f, -1.13930643e-01f, 7.90632516e-02f, 1.45518690e-01f, -5.68241775e-02f, -1.20855972e-01f, 2.15295464e-01f, 2.74950683e-01f,
  -4.16688472e-01f, 2.68706799e-01f, 3.44499022e-01f, 7.24488720e-02f, 1.35780275e-01f, -2.98097312e-01f, -8.39438960e-02f, 2.69386530e-01f, 3.72019500e-01f, -9.38212220e-03f,
  2.11345270e-01f, -2.87524074e-01f, 1.83303773e-01f, 4.05138820e-01f, 1.49872720e-01f, 6.04738183e-02f, 3.93372983e-01f, -9.54169873e-03f, -1.36750564e-01f, -2.54151851e-01f,
  1.07499480e-01f, -8.04357044e-03f, -5.61024994e-02f, -4.10352573e-02f, 1.20014951e-01f, 3.01545799e-01f, 2.35848367e-01f, 1.18111514e-01f, 3.92291993e-01f, 4.25669938e-01f,
  3.05540353e-01f, 2.76876986e-01f, -5.64715303e-02f, -5.03869832e-01f, -7.27953091e-02f, -2.31479406e-01f, -4.78659123e-02f, 6.03792369e-01f, -3.18621807e-02f, 2.08901927e-01f,
  1.41862333e-01f, 2.04918399e-01f, -1.13168672e-01f, 2.14126274e-01f, 3.77051644e-02f, -1.78463504e-01f, 2.18075156e-01f, -1.39757410e-01f, 3.96744460e-01f, -7.28371814e-02f,
  5.08303761e-01f, -3.09340417e-01f, 1.78854451e-01f, 5.79285063e-02f, -1.69579446e-01f, 2.76341382e-02f, 3.04417253e-01f, 8.46444443e-02f, -1.35729223e-01f, 1.86991885e-01f,
  2.04488114e-01f, 1.39789999e-01f, -1.57115117e-01f, -7.06164017e-02f, 3.60545903e-01f, -2.86745697e-01f, 1.02940641e-01f, -3.78599837e-02f, 8.95692334e-02f, 2.90838540e-01f,
  1.18333302e-01f, 2.28429258e-01f, 1.82076260e-01f, 2.36297265e-01f, -1.70876682e-01f, -3.06084752e-01f, 2.62313962e-01f, 1.89849347e-01f, 1.99667215e-01f, 2.57293612e-01f,
  -5.69460802e-02f, 1.11238016e-02f, -3.91976714e-01f, 2.15850636e-01f, -1.06827296e-01f, 2.11263731e-01f, -5.98549098e-02f, 1.93554416e-01f, 3.15254003e-01f, 5.91252565e-01f,
  2.84184277e-01f, -5.85383438e-02f, 1.42188415e-01f, 2.88774431e-01f, -2.86082238e-01f, 1.90302618e-02f, 5.09746373e-01f, 3.54856461e-01f, -6.44468307e-01f, 4.63055938e-01f,
  -9.21188742e-02f, 1.90721333e-01f, -7.11551756e-02f, 9.77200493e-02f, -6.83032125e-02f, 3.34428340e-01f, -4.33138341e-01f, 7.64781892e-01f, 2.56401569e-01f, 1.07079238e-01f,
  9.94475558e-02f, 1.94277409e-02f, -2.59057820e-01f, -4.74387221e-03f, 2.50057936e-01f, 4.52658474e-01f, 7.55673945e-02f, 1.43445060e-01f, 4.11334842e-01f, -2.60062575e-01f,
  3.30364376e-01f, 1.57466605e-01f, -1.25598952e-01f, 2.32883200e-01f, -1.53852040e-02f, 6.60478845e-02f, -3.00172895e-01f, -5.44791698e-01f, -1.03708424e-01f, 4.81382012e-01f,
  -2.51171649e-01f, -2.51989633e-01f, 1.13901123e-01f, -2.12730005e-01f, 1.04414402e-02f, -3.64233777e-02f, 1.09481663e-02f, 5.04668765e-02f, 4.69568223e-01f, 5.18403113e-01f,
  -2.04204306e-01f, -1.02745838e-01f, -1.56502858e-01f, 4.71461378e-02f, -2.53294617e-01f, 3.68784606e-01f, -1.56202670e-02f, 1.80027828e-01f, 1.02201864e-01f, -5.37340902e-02f,
  5.86116433e-01f, 2.31332898e-01f, 9.19608399e-02f, -1.28846452e-01f, 1.90817043e-02f, 3.39825153e-02f, 3.28731630e-03f, -7.37193078e-02f, 6.31358773e-02f, -4.03536819e-02f,
  -4.43785280e-01f, 2.21985042e-01f, 1.53074145e-01f, -1.27526462e-01f, 3.25349510e-01f, -7.75912702e-02f, 1.96708739e-01f, 2.51203924e-02f, 3.40310425e-01f, -2.56698340e-01f,
  4.99361813e-01f, -4.07585323e-01f, -2.14840889e-01f, 1.58607528e-01f, 1.31158635e-01f, 1.75809730e-02f, 6.57363385e-02f, -1.29289225e-01f, 6.27880841e-02f, -1.13139138e-01f,
  9.77406874e-02f, -1.14339329e-01f, 1.92864299e-01f, 2.81546593e-01f, 2.20750973e-01f, 1.79459751e-01f, 1.17171280e-01f, -2.09211018e-02f, 3.90312001e-02f, 4.69778329e-02f,
  -4.82272476e-01f, -3.71306419e-01f, 2.91427642e-01f, 5.91390848e-01f, -1.70159470e-02f, 5.20479739e-01f, 6.75203055e-02f, -7.35072419e-02f, -4.70514372e-02f, 1.40832230e-01f,
  3.07788432e-01f, 6.95092157e-02f, -1.25776559e-01f, -1.59854323e-01f, 1.28105775e-01f, 3.05264115e-01f, -1.05021007e-01f, 8.78186971e-02f, -9.93903801e-02f, 2.01842748e-02f,
  -1.33131355e-01f, 6.37725353e-01f, -8.67640972e-02f, -1.20584086e-01f, 4.41270381e-01f, -7.06888065e-02f, 2.78305579e-02f, -1.97798103e-01f, -6.43960834e-02f, -8.73525441e-03f,
  -2.74453729e-01f, 1.37300591e-03f, -1.99065790e-01f, -2.35793471e-01f, 1.66370749e-01f, 1.13811620e-01f, -1.23803504e-01f, -3.09842020e-01f, 2.29833975e-01f, -2.07899854e-01f,
  1.18313208e-01f, -9.39453170e-02f, -1.81271046e-01f, -2.00208440e-01f, 2.76610017e-01f, -2.81166583e-01f, -1.99245587e-01f, 1.58056729e-02f, 1.26125619e-01f, 1.56923950e-01f,
  -2.50365347e-01f, 5.93870021e-02f, -2.36249462e-01f, 3.35098565e-01f, 2.50502735e-01f, 1.07593521e-01f, 3.16846192e-01f, 4.50689942e-01f, 2.59283662e-01f, 1.44487217e-01f,
  2.30006836e-02f, 4.87779975e-02f, -1.56834841e-01f, -4.74264063e-02f, -1.83683068e-01f, 2.31642812e-01f, 7.56942183e-02f, 7.49762177e-01f, -1.86033323e-01f, 4.76472348e-01f,
  -8.23859200e-02f, -1.35254964e-01f, 1.71388403e-01f, 1.63557291e-01f, 2.95693451e-03f, 1.65908009e-01f, -4.48976830e-02f, 2.24295735e-01f, 1.14615418e-01f, 4.89513606e-01f,
  -2.15518121e-02f, -1.79160818e-01f, 2.17908531e-01f, 2.97337890e-01f, 3.06150950e-02f, 6.30858779e-01f, -5.31726480e-02f, 1.70986071e-01f, 6.93463624e-01f, 1.16063967e-01f,
  -1.08445413e-01f, 2.87060708e-01f, 5.98524064e-02f, -2.52624124e-01f, -4.11119491e-01f, -2.52807081e-01f, -1.52246103e-01f, -2.87264008e-02f, -2.22376257e-01f, 1.13328472e-01f,
  -1.68178946e-01f, -1.50317252e-01f, 1.98189303e-01f, 2.46840548e-02f, -2.77167596e-02f, 8.24622530e-03f, -2.03717202e-01f, -4.76850523e-03f, 2.14211136e-01f, 6.68723732e-02f,
  -8.68607759e-02f, -1.37709036e-01f, 7.74748530e-03f, -1.09888569e-01f, 1.02387957e-01f, 6.48535192e-02f, 2.44484439e-01f, -1.26705796e-01f, 2.45777488e-01f, -1.01702556e-01f,
  1.68978810e-01f, 3.67320627e-01f, 4.79830839e-02f, 9.99226496e-02f, -2.09508426e-02f, 5.31209931e-02f, 1.67131200e-01f, 6.12179041e-02f, 4.34415527e-02f, -2.24041864e-01f,
  -2.85696775e-01f, -4.00632024e-01f, -8.79726633e-02f, -4.55922037e-01f, 2.71471947e-01f, 2.24224374e-01f, 4.61748280e-02f, -2.86130130e-01f, -1.76465400e-02f, -6.91405088e-02f,
  4.18817192e-01f, 2.20613614e-01f, -1.42232046e-01f, -2.70880133e-01f, -3.34531479e-02f, 1.95495069e-01f, -9.38756168e-02f, 9.45919529e-02f, 1.25684828e-01f, -4.77029026e-01f,
  3.32986504e-01f, -1.37552977e-01f, -7.58706778e-02f, 1.18964598e-01f, -2.28671613e-03f, 7.25726411e-02f, 3.85427922e-01f, 5.03195405e-01f, -1.31890953e-01f, -1.15848362e-01f,
  -2.04395670e-02f, 3.94962549e-01f, -1.73367634e-01f, 5.31502306e-01f, 2.14138061e-01f, 2.58825481e-01f, 3.33696187e-01f, -2.96213776e-01f, -1.98692128e-01f, 3.32619429e-01f,
  5.75396419e-01f, -4.67854440e-02f, 3.60011697e-01f, -1.55003056e-01f, 4.42965515e-02f, 3.43266964e-01f, -9.25442576e-02f, -1.64361522e-01f, 3.65784168e-01f, 1.30306482e-01f,
  -7.86863491e-02f, 1.26610249e-01f, -4.00299244e-02f, 2.48842873e-02f, -2.22282950e-02f, 5.87292947e-02f, 2.81346709e-01f, -1.30995959e-01f, 1.35448307e-01f, 2.36605227e-01f,
  3.45730513e-01f, 7.64494762e-02f, -2.76675552e-01f, -4.70377088e-01f, 2.53383309e-01f, -2.85019785e-01f, 3.13900501e-01f, -1.04926340e-02f, 1.11872956e-01f, 2.41714016e-01f,
  3.28145295e-01f, 5.45512279e-03f, 5.41792512e-01f, -3.98366014e-03f, -2.79421806e-01f, -6.52447164e-01f, 4.48064715e-01f, 9.50968340e-02f, 4.37641710e-01f, 5.33584177e-01f,
  1.93197370e-01f, -5.78295216e-02f, -1.32663772e-01f, 2.62018621e-01f, 1.35375217e-01f, 5.17141744e-02f, -2.10477948e-01f, -1.58361167e-01f, -9.43888500e-02f, 3.04507613e-01f,
  -3.10921967e-01f, 4.47748508e-03f, 3.34913224e-01f, -2.66441312e-02f, -2.57982999e-01f, 3.76755416e-01f, 1.14161372e-01f, -3.67431730e-01f, -3.17652106e-01f, 3.66303086e-01f,
  -1.71659991e-01f, 4.37158078e-01f, 2.51781136e-01f, -2.98769474e-01f, -1.86904192e-01f, 4.24907625e-01f, 9.95473191e-02f, 3.04342926e-01f, 2.34799340e-01f, -9.85353887e-02f,
  -4.54247072e-02f, 5.15373200e-02f, 6.58243075e-02f, 1.56162865e-02f, 5.62915564e-01f, -3.85269284e-01f, 9.19778422e-02f, 1.88419327e-01f, -9.44020972e-02f, -2.30638579e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.17612594e-01f, 1.87803134e-01f, 1.80993721e-01f, 3.30814540e-01f, 1.75689831e-01f, 1.11442972e-02f, 1.30052403e-01f, 2.82567926e-02f, 4.46712971e-02f, 4.41655982e-03f,
  1.31710395e-01f, -3.05692339e-03f, -9.07427743e-02f, 4.69284579e-02f, -8.71186107e-02f, -2.48030081e-01f, 1.97500572e-01f, 1.16240568e-01f, 2.44692817e-01f, 1.82720736e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.34155095e-01f, -1.11920111e-01f, 1.66089907e-01f, 2.51635969e-01f, 8.09713081e-03f, -1.25442803e-01f, -1.22407667e-01f, -2.10310085e-04f, 4.58632171e-01f, -3.05278867e-01f,
  -2.67464757e-01f, -1.70013853e-04f, 1.17170088e-01f, -1.40715659e-01f, -2.84200814e-02f, -1.04861520e-01f, -1.50065839e-01f, 9.56636593e-02f, -2.87331063e-02f, 1.78307340e-01f,
  -1.39444396e-01f, -1.91626281e-01f, -6.63711950e-02f, -4.54325005e-02f, -1.73923466e-03f, 8.93693939e-02f, -1.68505564e-01f, 2.04675034e-01f, 1.12018898e-01f, 3.75573859e-02f,
  -1.00968130e-01f, 1.55224577e-01f, -8.54024515e-02f, -2.32545108e-01f, 1.28629401e-01f, -2.05946863e-01f, -6.13226220e-02f, -6.10132655e-03f, 6.36530891e-02f, -1.66266635e-01f,
  1.35418400e-01f, -1.32436991e-01f, -2.22310409e-01f, 2.22714394e-01f, -1.43883839e-01f, -1.30518213e-01f, 2.24839717e-01f, -1.53883636e-01f, -2.13033721e-01f, -1.79143585e-02f,
  -3.00830640e-02f, 1.22746125e-01f, -2.28966743e-01f, 1.30892530e-01f, -3.13132465e-01f, -1.40396968e-01f, 4.93721813e-02f, -1.41478717e-01f, -1.40732586e-01f, 1.54360175e-01f,
  7.36070275e-02f, 1.54218063e-01f, 1.32447332e-01f, 2.03717634e-01f, 1.77015588e-01f, -1.65422127e-01f, -2.15238030e-03f, 6.50002062e-02f, -3.99947241e-02f, 9.19745490e-02f,
  9.67907384e-02f, -5.01102302e-03f, 3.79983813e-01f, -1.58530354e-01f, -7.08904266e-02f, -3.18798572e-01f, -4.31326404e-02f, -7.48640820e-02f, -2.80257732e-01f, 1.59643769e-01f,
  1.19641207e-01f, -1.91746607e-01f, -2.39732908e-03f, 1.74193218e-01f, 2.54668772e-01f, 1.13070391e-01f, 1.69891402e-01f, -3.48946974e-02f, 1.93532690e-01f, -3.17694135e-02f,
  -8.57547000e-02f, 1.26391068e-01f, 1.93547875e-01f, -1.20353505e-01f, -7.77808577e-02f, 1.80141002e-01f, -1.43810064e-01f, -1.48339337e-02f, 2.45807558e-01f, 1.49368569e-01f,
  3.17645758e-01f, 1.44930050e-01f, 1.30788863e-01f, 3.15625072e-02f, 2.25670531e-01f, 3.67041409e-01f, 4.88338202e-01f, 4.97252084e-02f, 1.38778359e-01f, -7.27704614e-02f,
  1.73305482e-01f, 1.10042848e-01f, -2.35866830e-01f, 4.62969467e-02f, -1.88597113e-01f, 3.03523451e-01f, 4.04836312e-02f, -2.50341713e-01f, 3.12812954e-01f, 1.79585382e-01f,
  -1.47901727e-02f, 7.72907436e-02f, -1.34570464e-01f, -2.67884247e-02f, 1.57884032e-01f, 2.25517511e-01f, -1.24171868e-01f, -6.10603802e-02f, 8.22285116e-02f, -6.81407610e-03f,
  -1.09079264e-01f, 6.49982244e-02f, 2.19400883e-01f, 2.00606644e-01f, 6.44229949e-02f, -1.21358223e-01f, 4.83709276e-02f, -2.95658827e-01f, -1.93590164e-01f, 7.14734942e-02f,
  2.42311686e-01f, 3.09784169e-04f, 1.04658713e-03f, 1.82678908e-01f, 1.05840996e-01f, -4.65016514e-02f, -3.66490451e-03f, -1.85736716e-01f, 1.75304621e-01f, 1.48881245e-02f,
  -1.63378455e-02f, -9.09765363e-02f, 7.21874014e-02f, -1.65592760e-01f, -3.36941406e-02f, -2.46379361e-01f, -1.81045935e-01f, 9.10360813e-02f, -1.23329766e-01f, 2.43912891e-01f,
  -1.94371805e-01f, -2.79496342e-01f, -3.62752020e-01f, 1.51197299e-01f, 9.90761667e-02f, -8.65429267e-02f, -1.30440354e-01f, 4.37390245e-03f, -1.37705356e-01f, -5.11287868e-01f,
  -3.25201117e-02f, -2.37036929e-01f, -6.64780242e-03f, 2.33924896e-01f, -3.20976168e-01f, 9.71159339e-02f, 1.07225008e-01f, 7.22875595e-02f, -1.56011283e-01f, -1.89947531e-01f,
  1.14454381e-01f, -6.12772033e-02f, -4.39468585e-02f, -4.24266756e-02f, 1.62849370e-02f, 1.90274879e-01f, -2.22327281e-02f, -1.21422932e-01f, 1.25583401e-03f, -1.23655379e-01f,
  3.52274701e-02f, 2.18932971e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.89099999e-02f, 3.18709552e-01f, 1.84855103e-01f, 3.49117994e-01f, 3.00813943e-01f, 3.57472211e-01f, 1.87022299e-01f, 2.49369517e-02f, 2.15415806e-01f, 1.63565934e-01f,
  -1.76226810e-01f, 3.50330412e-01f, -1.10703595e-01f, -2.03879729e-01f, 3.34688514e-01f, 2.35740557e-01f, 9.77065638e-02f, -3.13068151e-01f, 3.42608750e-01f, 3.41076255e-01f,
  1.07194014e-01f, -3.95317785e-02f, -4.20416415e-01f, 3.97164971e-02f, -2.58644432e-01f, -5.36113009e-02f, -2.59102136e-01f, -8.65373164e-02f, 5.20510972e-02f, -1.96507603e-01f,
  3.97425592e-01f, -2.08013728e-02f, 4.45084840e-01f, 4.53370303e-01f, 2.31779907e-02f, -9.40967873e-02f, 3.37130904e-01f, -2.75466610e-02f, 9.40714553e-02f, 2.07088023e-01f,
  -6.02904446e-02f, 4.03185338e-01f, -5.95546126e-01f, -3.22126716e-01f, 3.12458754e-01f, 1.91927403e-01f, -1.93312883e-01f, 3.53428662e-01f, 2.66472191e-01f, -1.49488866e-01f,
  -1.82894617e-01f, 9.67198703e-03f, 2.74608247e-02f, 1.35647029e-01f, 3.17700475e-01f, 1.11601025e-01f, 2.21792698e-01f, 1.87487707e-01f, -1.42087936e-01f, -2.77248114e-01f,
  2.16024622e-01f, -2.27880344e-01f, 3.19793582e-01f, 9.16802660e-02f, -6.02011681e-01f, -7.95798540e-01f, 8.30658749e-02f, 2.29747176e-01f, 1.20495901e-01f, -2.01643735e-01f,
  1.68365929e-02f, -3.54887456e-01f, -9.65904370e-02f, -1.68472409e-01f, -5.33607453e-02f, -3.94430429e-01f, -2.24785045e-01f, 2.72858381e-01f, -1.40730396e-01f, -8.47892314e-02f,
  -1.24388285e-01f, 3.36455315e-01f, -4.34153378e-02f, 6.53380752e-02f, -2.82904834e-01f, 2.33624339e-01f, 4.25726652e-01f, 9.67593305e-03f, 6.48278520e-02f, 2.48473734e-01f,
  -1.28548667e-02f, 2.64981925e-01f, 3.04303944e-01f, -8.00427496e-02f, -2.56198645e-01f, 2.92096764e-01f, -9.22192410e-02f, -6.07656479e-01f, -3.64040792e-01f, 1.57064199e-01f,
  -1.34264573e-01f, -6.05283119e-02f, -1.28588572e-01f, -9.42825153e-02f, -3.93113136e-01f, -3.92749399e-01f, -3.66172135e-01f, -2.35018507e-01f, -5.18422499e-02f, 2.38832235e-01f,
  -2.31682360e-01f, 1.25672325e-01f, 1.69812277e-01f, 2.89631486e-01f, 4.79097292e-02f, 1.82218969e-01f, 8.57600644e-02f, 4.51597303e-01f, -1.43325076e-01f, 1.65454652e-02f,
  4.34513092e-02f, 2.51888148e-02f, 3.54397684e-01f, 9.82469469e-02f, -2.83620089e-01f, 3.24419402e-02f, -1.04949869e-01f, 4.07046318e-01f, 4.09413248e-01f, -1.02240788e-02f,
  9.59557071e-02f, -1.44910619e-01f, 3.36376190e-01f, 7.60742500e-02f, -2.31827214e-01f, 7.98998401e-02f, 1.04438350e-01f, -1.79795325e-01f, -5.88074684e-01f, -2.68193871e-01f,
  4.30523336e-01f, 2.02336133e-01f, -6.81875348e-01f, 3.36704224e-01f, 8.49305391e-02f, -2.25684673e-01f, -2.62788743e-01f, 3.01629990e-01f, 2.65647709e-01f, 2.63210177e-01f,
  -8.84239525e-02f, 1.16982467e-01f, 1.16237752e-01f, 1.91739500e-01f, 1.06778644e-01f, 1.65317997e-01f, 2.56231099e-01f, -4.43918169e-01f, 4.64134723e-01f, 4.23363179e-01f,
  -4.87852208e-02f, 1.69771507e-01f, 5.99501841e-02f, 1.36590913e-01f, -2.54467912e-02f, 1.66681096e-01f, 5.12238264e-01f, -3.29568684e-01f, 5.88325202e-01f, 1.99670792e-01f,
  6.36079490e-01f, 1.66025937e-01f, 1.94422051e-01f, -2.55789042e-01f, 5.26235521e-01f, 1.11135222e-01f, -2.78314173e-01f, 2.97469646e-01f, 1.66135773e-01f, 3.85186672e-01f,
  -1.48935735e-01f, 5.16409613e-02f, -9.85458195e-02f, -1.96415428e-02f, -2.87841469e-01f, -2.30203792e-01f, 1.49104834e-01f, -3.36965956e-02f, -5.33450730e-02f, 1.54967666e-01f,
  -2.17460811e-01f, 3.52782160e-01f, -3.48558985e-02f, 1.36445343e-01f, -2.76658237e-01f, -1.07924901e-01f, -1.33503303e-01f, -8.51763859e-02f, -5.09806395e-01f, 4.45239455e-01f,
  -8.33045721e-01f, 2.03920886e-01f, -5.85992992e-01f, -1.30688623e-01f, -2.81566083e-01f, 7.29782432e-02f, 1.83934122e-01f, -5.47107831e-02f, 2.68510610e-01f, 9.73181352e-02f,
  2.92369366e-01f, -4.91073966e-01f, -1.20291777e-01f, 4.98370826e-03f, 2.57551104e-01f, 9.00934637e-02f, 2.99671978e-01f, 3.01060736e-01f, 7.53072798e-02f, 2.69552797e-01f,
  6.29166514e-02f, 1.73808008e-01f, 6.38744682e-02f, -2.94585526e-01f, 5.86592257e-02f, -2.97764301e-01f, 3.79017815e-02f, -1.72055244e-01f, 3.15229110e-02f, 1.86755762e-01f,
  2.11061776e-01f, -3.58860373e-01f, 2.69374847e-01f, -2.46646162e-02f, 4.25638646e-01f, 1.40462741e-01f, 1.97224706e-01f, 2.39180937e-01f, 2.69655902e-02f, 1.22553967e-01f,
  -1.13294043e-01f, 3.83242100e-01f, 1.52928963e-01f, 2.38528073e-01f, -1.90979876e-02f, 2.78294504e-01f, 2.75494158e-01f, 7.42525235e-03f, -4.37240452e-02f, 4.60934304e-02f,
  4.69334483e-01f, 6.70921579e-02f, 4.94306348e-02f, -7.98212662e-02f, -3.85511190e-01f, 3.39142263e-01f, 3.74512315e-01f, 2.90739357e-01f, -5.14527038e-02f, 2.15306386e-01f,
  4.44432162e-02f, 2.72260427e-01f, 3.81544530e-01f, 3.49237323e-02f, 7.35854208e-01f, 6.45257607e-02f, 6.29085600e-01f, 3.79507363e-01f, 4.29399878e-01f, -2.55191773e-01f,
  9.62217301e-02f, 4.56179231e-01f, -4.67571728e-02f, -2.86489092e-02f, 1.77450597e-01f, 4.48387951e-01f, 8.47794563e-02f, 1.74398348e-01f, -5.35048187e-01f, -1.83832183e-01f,
  -3.70842963e-02f, -8.08358341e-02f, -9.18895379e-02f, -3.84826548e-02f, -3.41882631e-02f, -1.46941632e-01f, 4.46022809e-01f, 2.05375120e-01f, 1.59053072e-01f, 1.69094399e-01f,
  1.73292577e-01f, 1.03657432e-01f, 1.27499908e-01f, 1.21414520e-01f, -4.24859792e-01f, 1.00874370e-02f, -4.22002286e-01f, -1.59231499e-01f, -2.90401995e-01f, -1.02147639e-01f,
  1.94673941e-01f, 4.76499945e-01f, -2.58228689e-01f, 1.61091253e-01f, 1.99779674e-01f, -8.87445360e-02f, -2.14867383e-01f, -1.18185602e-01f, 2.05562666e-01f, 4.83345181e-01f,
  3.90983135e-01f, -6.49555027e-02f, 6.61926806e-01f, 1.47673532e-01f, 4.21080559e-01f, 1.39362171e-01f, -9.59308594e-02f, -7.10119307e-02f, -7.74036422e-02f, -3.77458818e-02f,
  1.71188042e-02f, -1.29704237e-01f, 4.00463611e-01f, 1.18399724e-01f, 2.01098904e-01f, 8.34131017e-02f, 3.15721989e-01f, -2.06898659e-01f, 9.25276726e-02f, 8.77560154e-02f,
  7.13151833e-03f, -2.37991177e-02f, -3.71155798e-01f, -6.28168136e-02f, 4.41911697e-01f, -1.76646397e-01f, 1.55390754e-01f, 1.71946019e-01f, 1.17726736e-01f, 3.22502792e-01f,
  -7.54186511e-02f, -4.92518723e-01f, 3.35233033e-01f, 4.34610397e-01f, -4.16651607e-01f, 8.50436315e-02f, -1.83440983e-01f, 2.39358634e-01f, 5.62432110e-01f, 1.66618556e-01f,
  4.70982604e-02f, -2.08698586e-01f, -2.41784863e-02f, 6.71937466e-02f, -2.80716389e-01f, -1.58287331e-01f, -4.43098426e-01f, 7.72678778e-02f, -3.57887506e-01f, 4.02387679e-01f,
  -8.60617876e-01f, -2.98995107e-01f, -3.07234675e-01f, 3.69386002e-02f, 5.78917563e-02f, -5.23172095e-02f, 4.99766096e-02f, 2.41475269e-01f, 2.12488338e-01f, -7.90349543e-02f,
  1.99035928e-01f, -1.80290624e-01f, 2.35128954e-01f, 2.01036632e-01f, 2.24004332e-02f, 1.60163805e-01f, 6.29456997e-01f, -8.03752467e-02f, 2.33288437e-01f, -1.85988575e-01f,
  -3.34340483e-01f, 2.91062951e-01f, 1.30155697e-01f, -3.64101350e-01f, -9.11916867e-02f, 3.55477482e-01f, -8.04254264e-02f, -3.53921503e-01f, 1.89128041e-01f, 7.73520544e-02f,
  1.95327848e-01f, -2.51025707e-01f, -3.25898200e-01f, 3.25399250e-01f, -4.09430951e-01f, -4.69952554e-01f, -4.05802697e-01f, 3.78028825e-02f, 1.84143841e-01f, -2.22493857e-01f,
  7.53814802e-02f, 1.85537755e-01f, 3.05504292e-01f, -6.65872172e-02f, 1.18594393e-01f, -3.55647504e-01f, 2.77151138e-01f, 2.80782610e-01f, -3.85139957e-02f, 3.48517150e-01f,
  5.82378358e-02f, 1.42629519e-01f, 3.43566924e-01f, 2.78865993e-01f, 1.25177085e-01f, -2.37494797e-01f, 1.09468251e-01f, 1.66734800e-01f, -1.72039524e-01f, -2.86113992e-02f,
  4.14709114e-02f, 1.01648547e-01f, 1.27823010e-01f, 2.93996893e-02f, 9.07520711e-01f, 2.57740915e-01f, 4.51046795e-01f, 1.72596991e-01f, 3.31944227e-01f, -4.75497991e-02f,
  -2.43124157e-01f, 4.37991619e-01f, 1.84565242e-02f, 9.60355699e-02f, -9.53411218e-03f, 1.38553739e-01f, 3.65908653e-01f, -5.00124646e-04f, -3.16746235e-01f, 1.12000570e-01f,
  -3.19809020e-01f, 2.18221396e-01f, -7.22492337e-02f, -5.97645864e-02f, -1.59654856e-01f, -1.45816396e-03f, 3.59461904e-01f, 2.10441127e-01f, -1.32889807e-01f, 2.57391751e-01f,
  -4.85695124e-01f, -3.26067865e-01f, 2.02981289e-02f, 4.02427390e-02f, -2.18243897e-01f, 5.18187582e-01f, -1.08089127e-01f, 4.24871922e-01f, -4.35926840e-02f, 1.04583487e-01f,
  4.13323119e-02f, 8.74984562e-02f, 4.37564850e-02f, 1.84035584e-01f, 2.16002405e-01f, 4.09000739e-02f, 1.45648658e-01f, -2.19649807e-01f, 7.03120753e-02f, -8.16194490e-02f,
  -1.44841135e-01f, 5.47960028e-02f, 4.93074477e-01f, 2.25290239e-01f, 2.81576186e-01f, -8.67403373e-02f, -4.52645063e-01f, 1.64150938e-01f, 1.31973132e-01f, -2.85668373e-01f,
  -3.41995776e-01f, -3.29074204e-01f, 1.12604965e-02f, 8.17105100e-02f, -1.77527145e-01f, 1.98166162e-01f, 3.66609931e-01f, 1.60758644e-02f, 4.02191669e-01f, 1.21658839e-01f,
  9.96596813e-01f, 6.96220279e-01f, 9.45103988e-02f, 2.51822174e-01f, 3.04020971e-01f, 5.83045967e-02f, -8.45381171e-02f, 4.55119312e-01f, -4.34557348e-02f, 3.63517553e-01f,
  7.27581233e-02f, 3.12557489e-01f, 8.26987177e-02f, -8.23240578e-02f, 9.98895764e-02f, 2.33878531e-02f, 1.59326807e-01f, 6.93476945e-02f, -8.63353312e-02f, 2.00441673e-01f,
  -3.01490515e-01f, -8.25444236e-02f, 3.82120341e-01f, 8.49190235e-01f, 1.89794227e-01f, -8.18409324e-02f, 4.39197749e-01f, 1.40507057e-01f, -8.49735141e-02f, 3.73238146e-01f,
  4.82808530e-01f, 6.95860982e-01f, 1.60808831e-01f, -1.76702470e-01f, 1.50987566e-01f, -1.46531984e-01f, -4.81849387e-02f, 3.32270503e-01f, 2.70658433e-01f, -1.04099728e-01f,
  -4.45891172e-02f, -7.21574351e-02f, 4.09026027e-01f, 6.81542009e-02f, 2.23632902e-01f, -5.76549284e-02f, 2.34797001e-01f, 5.16624786e-02f, 4.92177717e-02f, -1.08669303e-01f,
  1.44718051e-01f, -2.02000160e-02f, 5.34890890e-01f, -1.62378043e-01f, 3.19704413e-01f, 6.13696873e-01f, 2.25809216e-01f, -3.95828992e-01f, 2.35085145e-01f, 1.00820981e-01f,
  -1.24633454e-01f, -3.09028216e-02f, -9.80575234e-02f, 3.52606297e-01f, -6.56782836e-02f, 1.68117255e-01f, 1.31391734e-01f, -1.98400140e-01f, 5.39904594e-01f, -1.44302055e-01f,
  -2.80317143e-02f, 3.64255458e-01f, 3.29766303e-01f, -8.40123277e-03f, -1.52590042e-02f, -2.64955968e-01f, -1.39045566e-01f, 3.71793956e-01f, 2.81089172e-02f, 4.21080068e-02f,
  3.52867275e-01f, 7.64743164e-02f, -1.61906824e-01f, 4.63263184e-01f, 2.94621617e-01f, -4.07370657e-01f, 3.74397449e-02f, -1.81232318e-01f, 2.85456050e-02f, 6.25680611e-02f,
  -1.65286213e-01f, 1.11461811e-01f, 1.00991085e-01f, 1.47089183e-01f, -9.74906012e-02f, 1.01369277e-01f, -4.35901545e-02f, -8.24849159e-02f, 8.22423957e-03f, -1.06242366e-01f,
  -5.31888641e-02f, -1.50459155e-01f, 1.04738504e-01f, 5.45961708e-02f, -1.81958005e-01f, -4.41568419e-02f, 8.78782943e-02f, -3.02685928e-02f, -1.42406359e-01f, -2.15545014e-01f,
  1.79024726e-01f, -4.03938908e-03f, -1.49877846e-01f, 3.05948667e-02f, 6.00976646e-02f, -1.85270831e-01f, -1.63998023e-01f, -8.84506404e-02f, 2.75123805e-01f, 2.58048356e-01f,
  1.66502327e-01f, -2.02925667e-01f, -1.85783044e-01f, 1.09572731e-01f, 2.12500840e-01f, -3.32894236e-01f, 2.38651723e-01f, -1.34557426e-01f, 1.61385208e-01f, -1.51565313e-01f,
  2.84027338e-01f, 3.50188583e-01f, -7.85381868e-02f, 1.78626683e-02f, 4.66669314e-02f, 2.91571021e-01f, 1.61659867e-01f, 5.74523918e-02f, -4.41301875e-02f, 1.67665914e-01f,
  4.90797199e-02f, -4.24098298e-02f, -3.78631912e-02f, -5.34941629e-02f, 1.26111999e-01f, 6.53050989e-02f, -1.31699905e-01f, -7.23633543e-02f, -1.88316181e-01f, 1.28357545e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  1.34927288e-01f, 2.85937607e-01f, -6.44824505e-02f, -7.72734806e-02f, 2.43078731e-02f, 4.95338514e-02f, 9.33222324e-02f, -3.79927736e-03f, 1.83946475e-01f, -1.56720251e-01f,
  -1.20419279e-01f, 8.14218353e-03f, 1.82045758e-01f, -3.54201831e-02f, -1.30036756e-01f, 2.04532251e-01f, 3.58046383e-01f, 3.37896720e-02f, -1.53351009e-01f, 4.63578142e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  3.85409482e-02f, 5.05147219e-01f, -2.76582390e-01f, -1.89849436e-01f, -9.59114954e-02f, -1.84441641e-01f, -1.77786589e-01f, -7.67962262e-02f, -1.76460728e-01f, -2.89688647e-01f,
  -6.04132712e-02f, -3.24308991e-01f, -3.40522230e-01f, -7.71325350e-01f, -2.46443406e-01f, 1.33693099e-01f, -3.06510001e-01f, -3.76628786e-02f, 3.06894273e-01f, -2.63078213e-01f,
  -2.10652992e-01f, -2.63334308e-02f, 1.77455340e-02f, 4.16284442e-01f, -3.26377852e-03f, -2.69936293e-01f, 1.95794955e-01f, 3.17843445e-02f, -3.48630369e-01f, 3.04804862e-01f,
  6.43572118e-03f, -9.44631025e-02f, -1.36411533e-01f, -2.30664164e-01f, 3.35968137e-01f, -1.23422571e-01f, -1.98018506e-01f, 5.01186736e-02f, 2.25578576e-01f, 5.72457351e-02f,
  -3.56862731e-02f, -2.83113867e-01f, 7.97550157e-02f, 2.32143849e-01f, 5.90407997e-02f, 1.82553120e-02f, -5.26387207e-02f, 1.70881703e-01f, 2.95570083e-02f, -4.43358511e-01f,
  2.31419429e-01f, -1.52532801e-01f, -4.49545175e-01f, 2.05895022e-01f, -4.22155589e-01f, 1.13843381e-01f, 5.13928160e-02f, -7.40264729e-02f, 3.84414762e-01f, -1.53377056e-01f,
  1.90400004e-01f, 1.93629023e-02f, 2.99331686e-03f, -7.32229725e-02f, -4.37381566e-02f, 8.71002525e-02f, 1.53554320e-01f, -7.24973679e-02f, 2.84476101e-01f, -5.25199585e-02f,
  -3.36484462e-01f, -3.26055765e-01f, -3.92497450e-01f, -3.11828345e-01f, -1.34890839e-01f, -3.92387360e-01f, -5.72501943e-02f, 2.17634216e-01f, -7.90177166e-01f, -3.50022554e-01f,
  -3.57592613e-01f, -8.67276713e-02f, 2.28455558e-01f, -7.31605947e-01f, -3.88566196e-01f, -2.98134238e-01f, 8.64881873e-02f, 2.20362931e-01f, 3.20923686e-01f, -3.04673314e-01f,
  1.09180711e-01f, -8.10024858e-01f, 1.57860845e-01f, 2.32879207e-01f, -1.50365338e-01f, -1.80196255e-01f, -1.01679847e-01f, 5.20509668e-02f, -3.46657366e-01f, -3.20868869e-03f,
  -4.01652843e-01f, 8.43812674e-02f, 6.89289197e-02f, 2.61693835e-01f, -2.67223358e-01f, -5.41278422e-02f, 1.67595804e-01f, -2.66394138e-01f, -7.13377774e-01f, -5.29087901e-01f,
  3.27424020e-01f, -2.33347025e-02f, -7.69567728e-01f, 1.37419939e-01f, -8.66639838e-02f, -1.16258813e-02f, -6.03991330e-01f, -3.75475913e-01f, 2.77217895e-01f, -4.24471051e-01f,
  2.24609002e-01f, -3.53907794e-01f, -4.41812247e-01f, 8.26772861e-03f, -6.11244261e-01f, 1.83548704e-01f, 3.81636582e-02f, -7.47562665e-03f, 1.97724476e-01f, -3.83603543e-01f,
  -2.06348404e-01f, 1.06870331e-01f, 2.51770884e-01f, -3.53064507e-01f, 2.92067349e-01f, 2.06436679e-01f, -2.56267518e-01f, 1.17310463e-02f, -2.97216713e-01f, 2.24889949e-01f,
  -1.30017996e-01f, -3.51466000e-01f, -3.32783729e-01f, -1.54905324e-03f, -2.02029213e-01f, 1.01942912e-01f, -2.20092684e-01f, -7.27747753e-02f, 2.06772566e-01f, -3.00799847e-01f,
  9.03381705e-02f, -1.39910817e-01f, 9.13184062e-02f, 2.62933403e-01f, 5.11401258e-02f, 1.05488122e-01f, 3.80052105e-02f, 2.72345364e-01f, -1.70822918e-01f, 1.13595471e-01f,
  5.88452108e-02f, 1.86504483e-01f, 8.75414684e-02f, 9.33365002e-02f, -4.62024733e-02f, 4.10996884e-01f, -6.09277010e-01f, -3.42427462e-01f, 1.73483372e-01f, -7.55580664e-02f,
  8.08877125e-02f, -3.99774075e-01f, -5.09188712e-01f, 2.43611168e-02f, -3.93959880e-01f, -1.13857269e-01f, -1.33722052e-01f, 1.94750175e-01f, -2.60239214e-01f, 2.10954055e-01f,
  1.88524842e-01f, 1.11508355e-01f, -4.29945618e-01f, -1.01627856e-01f, -3.28368902e-01f, 5.71311302e-02f, 7.91791305e-02f, 1.57662481e-01f, 2.53430635e-01f, 7.62539282e-02f,
  -1.77304357e-01f, 2.61147320e-01f, 1.74997095e-02f, 4.47712466e-02f, -1.71723098e-01f, 2.37618923e-01f, -4.02290285e-01f, 1.98270045e-02f, -3.59521121e-01f, -3.35444033e-01f,
  1.95209175e-01f, 3.90507542e-02f, 1.99973509e-01f, 4.00802344e-01f, 2.25365818e-01f, 1.54072508e-01f, -4.10534680e-01f, 1.08259231e-01f, 2.57175893e-01f, -2.97773391e-01f,
  -1.56732976e-01f, -5.89925408e-01f, 1.18204333e-01f, 2.03161731e-01f, -5.17482162e-01f, 2.39633992e-01f, -5.45825064e-01f, 1.48963109e-01f, -1.00733057e-01f, -4.69852984e-01f,
  1.62407026e-01f, -6.33584976e-01f, 1.51281819e-01f, -1.93920419e-01f, 2.44849510e-02f, -4.33834493e-01f, -2.33633384e-01f, -1.85251951e-01f, 1.11695882e-02f, -9.67937633e-02f,
  3.97459209e-01f, -1.23245958e-02f, -2.42597815e-02f, 2.27171063e-01f, -2.32615590e-01f, 3.01591426e-01f, -3.70038360e-01f, 5.75332418e-02f, 3.00160110e-01f, -1.78211614e-01f,
  -1.21169366e-01f, -4.06356007e-01f, 2.61182904e-01f, -2.13695224e-02f, -3.13247561e-01f, 1.32605299e-01f, 2.91638851e-01f, -3.80427718e-01f, 2.13362113e-01f, 2.93058474e-02f,
  -1.47139117e-01f, -1.77433968e-01f, 3.18932869e-02f, -2.68155128e-01f, -8.03362206e-02f, -1.82674915e-01f, 2.75259852e-01f, -7.23660365e-02f, 1.26534730e-01f, -3.44253778e-01f,
  -2.87495971e-01f, -7.43383691e-02f, -9.15756747e-02f, -8.88771787e-02f, 3.73695850e-01f, -3.34412009e-01f, 2.36038417e-01f, 1.77542686e-01f, -4.46191519e-01f, -2.30463147e-02f,
  4.12630975e-01f, 3.24100494e-01f, 1.27170295e-01f, -1.85256168e-01f, -2.25598603e-01f, 2.78759152e-01f, -6.37800038e-01f, 2.92112976e-01f, -1.34774879e-01f, -2.29124740e-01f,
  -8.38605687e-02f, -3.87505949e-01f, -3.83475691e-01f, -9.47839953e-03f, -3.18950206e-01f, -3.96784186e-01f, 7.26089552e-02f, 3.24819952e-01f, 2.05023512e-01f, 2.76633531e-01f,
  -9.09933150e-02f, 7.55936652e-03f, 4.45066571e-01f, 3.71048063e-01f, -1.18356161e-01f, 2.16823801e-01f, 5.04583418e-01f, 4.07800913e-01f, -1.83381531e-02f, -6.49760664e-01f,
  4.44535553e-01f, 1.46252438e-01f, -4.50800061e-01f, -5.00395417e-01f, 1.42327726e-01f, -8.26062486e-02f, -2.73051411e-01f, -5.61831832e-01f, 2.99813509e-01f, -3.08048725e-01f,
  8.04228261e-02f, -4.39341426e-01f, -1.24637447e-01f, 6.60298392e-02f, -1.58414975e-01f, -3.13100219e-01f, 1.90511569e-01f, 7.56905004e-02f, -1.36485040e-01f, -5.67726493e-01f,
  -4.48273905e-02f, -1.52016133e-01f, 3.56828123e-01f, -3.15959603e-02f, 3.62625241e-01f, 3.14623713e-01f, 3.90273452e-01f, 3.77949089e-01f, -7.73510709e-02f, 1.59130737e-01f,
  -2.11047828e-01f, -6.15141034e-01f, -2.70281613e-01f, -2.39801422e-01f, 3.57913435e-01f, 2.08134428e-01f, -7.20199287e-01f, 2.67471671e-01f, -5.95480561e-01f, 2.73878634e-01f,
  1.00527473e-01f, -3.37722510e-01f, -1.36801675e-01f, -4.39192355e-01f, -4.98135507e-01f, -2.29351535e-01f, -3.86817366e-01f, 4.84335959e-01f, -4.01757687e-01f, -5.15373588e-01f,
  1.06578089e-01f, -5.39349727e-02f, -1.65173233e-01f, -2.45469678e-02f, -3.62164348e-01f, 1.63743109e-01f, -2.46415496e-01f, -3.48504096e-01f, 6.46576703e-01f, 3.93481731e-01f,
  -2.14342862e-01f, -1.27357632e-01f, 8.88780579e-02f, 4.87798840e-01f, -2.80608445e-01f, 3.59417871e-03f, 8.72151752e-04f, 2.59738266e-01f, 2.94039875e-01f, 9.83259454e-02f,
  -3.37611586e-01f, 1.99054047e-01f, 4.13866907e-01f, -1.19481280e-01f, -2.83913076e-01f, -7.39409924e-01f, -3.97752732e-01f, 2.65650034e-01f, -7.66527355e-01f, -2.92436510e-01f,
  -2.03396454e-01f, -4.98261809e-01f, 2.34307703e-02f, 1.41033784e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.73770085e-01f, -6.91811554e-03f, 2.61490606e-02f, -1.10215247e-01f, -1.14768989e-01f, 1.91983327e-01f, -8.94284621e-03f, -2.38625690e-01f, -7.24532828e-02f, -1.23853879e-02f,
  9.93911996e-02f, -9.81812105e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    