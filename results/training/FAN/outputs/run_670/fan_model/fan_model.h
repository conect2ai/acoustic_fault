/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.81911662e-01f, -3.14535409e-01f, 1.07591137e-01f, -3.51343602e-01f, -8.75652656e-02f, 1.14140481e-01f, -1.92987472e-01f, -1.34697765e-01f, -1.68946281e-01f, -2.18106508e-01f,
  -7.66459703e-02f, -2.87964135e-01f, -1.75076634e-01f, -1.10577770e-01f, -2.33952329e-01f, -2.29977086e-01f, -1.32307693e-01f, -4.88360040e-03f, -5.46342656e-02f, 1.24689266e-02f,
  -2.88251191e-01f, -1.47470430e-01f, -1.90099049e-02f, 1.13742754e-01f, -5.04961163e-02f, -8.66264552e-02f, 7.58605376e-02f, 1.37539944e-02f, 4.57738061e-03f, -4.93193045e-03f,
  -1.33907750e-01f, -6.19766228e-02f, 7.44977873e-03f, -1.08698688e-01f, -1.47665754e-01f, -5.55849448e-02f, -1.59195229e-01f, -1.58510834e-01f, -9.34915319e-02f, -7.52960443e-02f,
  -1.18116863e-01f, -1.07731275e-01f, -1.65525720e-01f, -5.60732894e-02f, -1.20428026e-01f, -4.11136970e-02f, -1.58157960e-01f, -9.84419063e-02f, -1.23163842e-01f, -3.27838771e-02f,
  -2.26214662e-01f, -7.11503029e-02f, -5.06415553e-02f, 4.47149575e-02f, -6.61888048e-02f, -1.21911921e-01f, -4.48167399e-02f, -7.58438976e-03f, 2.13429565e-03f, -1.06107160e-01f,
  4.10351716e-02f, -2.21745986e-02f, -3.17399763e-02f, -5.04562557e-02f, -1.43749386e-01f, -5.39544411e-02f, 4.21839282e-02f, -2.02596970e-02f, -1.19326962e-02f, -1.36621431e-01f,
  -4.38913442e-02f, -3.01777013e-02f, -9.55402702e-02f, 4.70926948e-02f, 4.59127873e-02f, -5.94045967e-02f, -2.90161278e-02f, -2.28205211e-02f, 2.17295513e-02f, 1.59951001e-02f,
  -2.44524106e-02f, 1.60213664e-01f, -8.16694722e-02f, -2.34120488e-02f, 7.46505484e-02f, 6.75029606e-02f, -4.57129031e-02f, 9.69983414e-02f, -1.98649801e-02f, 7.59364665e-02f,
  -4.82325703e-01f, 1.17623113e-01f, -2.50355124e-01f, -2.29500800e-01f, -1.86038196e-01f, -2.63267457e-02f, -1.38508394e-01f, -5.28108664e-02f, -1.97683051e-01f, -1.66391984e-01f,
  -9.37663317e-02f, -1.37379125e-01f, -1.46180585e-01f, -1.13801390e-01f, -1.46642640e-01f, -1.02157086e-01f, -1.47854477e-01f, -2.54784971e-01f, -5.62409051e-02f, -8.27561617e-02f,
  -8.64613429e-02f, -2.22042814e-01f, -2.51074344e-01f, -2.58072704e-01f, -1.57041118e-01f, -3.33129823e-01f, -1.38093889e-01f, -2.54354179e-01f, -2.59376884e-01f, -4.92097646e-01f,
  7.70120382e-01f, 5.72510846e-02f, 9.06636119e-02f, 2.75444835e-01f, 4.03184071e-02f, -6.99309632e-02f, 1.65796533e-01f, -7.83757120e-02f, 2.57801060e-02f, 9.87788104e-03f,
  -4.06983048e-02f, 3.99203077e-02f, 4.51133549e-02f, -4.39949632e-02f, -7.67193921e-03f, -1.60785019e-02f, 1.47762656e-01f, 1.40624076e-01f, -3.43728140e-02f, -9.93272439e-02f,
  7.41362572e-02f, 2.90938169e-01f, 2.75650710e-01f, 1.95600167e-02f, -1.95768774e-02f, 1.31241912e-02f, -3.22475024e-02f, 7.61619881e-02f, -1.18445903e-01f, -2.67344294e-03f,
  -8.88066143e-02f, -6.97381571e-02f, -8.57185498e-02f, -2.10021827e-02f, -1.43834203e-01f, -6.88794404e-02f, -9.79566053e-02f, -1.06171302e-01f, -9.84627977e-02f, -9.02423114e-02f,
  -5.49825802e-02f, -6.42550215e-02f, -1.98938865e-02f, -1.20867312e-01f, 7.97247514e-03f, -1.27197811e-02f, -2.52356473e-02f, -1.37585014e-01f, -1.84013262e-01f, -5.01998998e-02f,
  -5.31337271e-03f, 4.00715210e-02f, 6.92074075e-02f, -4.94490042e-02f, -1.52868956e-01f, -8.35728496e-02f, -1.31266313e-02f, -1.96886957e-01f, -4.08117175e-02f, -8.45196620e-02f,
  8.25623497e-02f, 5.41284643e-02f, 1.69124138e-02f, 4.95460182e-02f, 4.84696366e-02f, -4.07980420e-02f, -1.38935680e-02f, 6.03827946e-02f, 1.63449738e-02f, 6.29742071e-02f,
  -2.89165992e-02f, 8.36192351e-03f, -3.05639487e-02f, 2.04649940e-02f, -2.51917988e-02f, 1.52618834e-03f, 6.05902225e-02f, 2.52795890e-02f, -4.99611646e-02f, 1.53709287e-02f,
  -2.10207421e-02f, 4.94454280e-02f, 1.88852251e-02f, -2.22921968e-02f, -1.06414221e-01f, -4.83948775e-02f, 2.73191407e-02f, -1.25734463e-01f, 6.01977259e-02f, 1.75865851e-02f,
  1.26576155e-01f, -1.57289505e-01f, -4.25716266e-02f, -6.15702346e-02f, 9.91548691e-03f, -7.19229355e-02f, 9.30347852e-03f, -5.37768155e-02f, -1.06167945e-03f, -6.18216991e-02f,
  -8.53601322e-02f, 6.41445220e-02f, 1.64217595e-02f, -2.00419454e-03f, -7.18479380e-02f, 9.52897891e-02f, -8.60067084e-03f, 5.78555129e-02f, -1.15644813e-01f, -7.11736381e-02f,
  9.11492407e-02f, 1.06721483e-01f, 2.07542330e-01f, 2.38396134e-02f, -4.76200581e-02f, 6.99174628e-02f, 9.91090434e-04f, -2.05409434e-02f, 3.44080999e-02f, 2.29577467e-01f,
  3.79305333e-01f, -2.62598187e-01f, 1.39244229e-01f, -5.03108352e-02f, -4.07171100e-01f, -1.01331495e-01f, -1.05800159e-01f, 3.93505916e-02f, -5.21091521e-02f, -1.64082631e-01f,
  -5.46084978e-02f, -5.17477933e-03f, 1.15050912e-01f, 1.51011959e-01f, 4.43849146e-01f, 1.46377370e-01f, 3.65771711e-01f, 4.53167528e-01f, 3.31078321e-01f, -5.42212874e-02f,
  -3.72927226e-02f, 8.72621015e-02f, 3.30631882e-01f, 1.69054419e-01f, -1.51908040e-01f, -8.60403553e-02f, 7.49507844e-02f, -1.84533074e-02f, 1.39447227e-02f, 1.89004615e-02f,
  -1.15959331e-01f, -6.29449040e-02f, 8.75036195e-02f, 6.47533173e-03f, -1.55733749e-01f, -7.63037521e-03f, -6.31579161e-02f, 1.20577905e-02f, -7.99303874e-02f, 1.75545067e-02f,
  -3.03082634e-03f, -7.91017059e-03f, 7.56586045e-02f, -1.13852806e-02f, 3.97361740e-02f, -5.52458279e-02f, -4.76615503e-02f, 1.38796136e-01f, 3.11949234e-02f, -1.21770568e-01f,
  -1.60922006e-01f, -2.98564248e-02f, -1.28269494e-01f, -1.36414468e-01f, 3.72461230e-02f, 2.89777806e-03f, -1.62527129e-01f, -6.50481954e-02f, -4.45439890e-02f, 1.27318809e-02f,
  -7.12430850e-02f, 7.18830153e-02f, -4.07148637e-02f, -7.64411241e-02f, 5.44770695e-02f, -5.05640265e-03f, 9.26471949e-02f, 1.04331009e-01f, 5.66453263e-02f, -5.90916313e-02f,
  -7.53284665e-03f, 3.21837999e-02f, 5.59540875e-02f, -3.42064314e-02f, 9.49769244e-02f, 1.09681692e-02f, 7.87109137e-02f, 1.98978819e-02f, 9.92611144e-03f, 6.86708391e-02f,
  -4.97286767e-02f, 2.84346356e-03f, 3.84633876e-02f, -3.17168087e-02f, -1.54312337e-02f, 4.81573418e-02f, -3.93170938e-02f, -1.79331452e-02f, -1.25891343e-03f, -2.64115259e-02f,
  1.06923690e-04f, 1.39275149e-01f, 8.06327760e-02f, -1.12632448e-02f, 5.70298247e-02f, -3.21066417e-02f, -2.26628873e-02f, -6.98829368e-02f, -3.43271792e-02f, 3.08399964e-02f,
  -8.38706456e-03f, 1.32751748e-01f, 9.24525037e-02f, 2.18234695e-02f, -2.01859195e-02f, -5.86375967e-03f, -7.32778609e-02f, 4.61078575e-03f, 7.68328905e-02f, -4.10374328e-02f,
  1.24559969e-01f, -3.87505186e-03f, 3.96452881e-02f, -5.32042980e-02f, -2.70827673e-02f, 8.96556601e-02f, -2.08584797e-02f, -1.23577990e-01f, -1.70689914e-02f, -1.47873238e-01f,
  2.97196686e-01f, -7.49366581e-02f, 1.41128048e-01f, -6.15000818e-03f, -8.20381939e-02f, 2.71593668e-02f, -2.80106872e-01f, -5.98737821e-02f, -1.23456465e-02f, -1.41352132e-01f,
  1.71816304e-01f, 6.12216629e-02f, -3.61040533e-02f, 4.81877960e-02f, -4.04336974e-02f, -2.43388996e-01f, -2.94225425e-01f, 6.05830699e-02f, -1.28105089e-01f, -5.00988998e-02f,
  -1.46522835e-01f, -4.81856763e-02f, 1.99565485e-01f, -5.75254625e-03f, 7.96006918e-02f, -1.94314420e-01f, -1.16467930e-03f, 9.88994315e-02f, 9.06871781e-02f, 1.39983356e-01f,
  3.06625873e-01f, 2.81721532e-01f, -7.58992210e-02f, -2.58855578e-02f, -1.73862674e-03f, -2.13429276e-02f, -3.96065377e-02f, 3.49814892e-02f, 3.65070254e-02f, -5.18197604e-02f,
  -8.93178284e-02f, -6.21565711e-03f, 1.38327613e-01f, 5.24497032e-02f, 7.70630836e-02f, -3.79895121e-02f, -3.35962847e-02f, 1.00098163e-01f, 1.05577782e-02f, 5.04593849e-02f,
  -4.79019880e-02f, 1.05098277e-01f, 2.31923088e-01f, 2.85156593e-02f, 2.05257945e-02f, -7.34818950e-02f, 4.09228206e-02f, 1.25473663e-01f, -1.38004674e-02f, -4.17476706e-02f,
  9.11463946e-02f, 8.93245414e-02f, 4.88324612e-02f, -4.21996266e-02f, -2.11344231e-02f, 5.58512518e-03f, 4.45691198e-02f, 6.33423179e-02f, -1.08565511e-02f, -1.38970546e-03f,
  4.87792538e-03f, -4.69330885e-02f, 4.95405756e-02f, 5.50042540e-02f, 7.23386556e-02f, 4.14466187e-02f, -7.36130625e-02f, -3.29864817e-03f, 8.72577727e-02f, 1.21400589e-02f,
  -6.92725182e-02f, 8.44062790e-02f, -3.63926739e-02f, 4.25818469e-03f, -1.58390366e-02f, 3.03777959e-02f, -2.69192215e-02f, 2.75047999e-02f, -9.64836776e-02f, -9.21550207e-03f,
  -1.58352032e-01f, 3.51714380e-02f, 2.41339058e-02f, -1.70619458e-01f, -7.13127404e-02f, -2.72196587e-02f, 3.92878279e-02f, 4.51981742e-03f, 2.65776049e-02f, -2.63436586e-02f,
  -2.95160450e-02f, -7.72189796e-02f, -2.15740260e-02f, -1.30815785e-02f, -1.00203961e-01f, -4.55505364e-02f, -6.68057054e-02f, 3.55978683e-02f, 1.39527377e-02f, 9.72629189e-02f,
  -1.03365164e-02f, -2.31308080e-02f, -1.09351799e-01f, -1.13495968e-01f, -5.09762652e-02f, -1.51936293e-01f, -1.42117947e-01f, -1.65072754e-01f, -5.82508966e-02f, -4.33776259e-01f,
  -5.90383530e-01f, 4.00681615e-01f, -1.21641979e-01f, -2.34612018e-01f, -1.53809920e-01f, -1.86358556e-01f, -1.45148799e-01f, -2.92111598e-02f, 2.71904171e-02f, -1.96301639e-02f,
  8.04169029e-02f, 2.32368499e-01f, 1.31067380e-01f, 2.21891329e-01f, -1.29723892e-01f, -1.10034272e-01f, -1.64737493e-01f, -1.57738805e-01f, -8.29234719e-02f, 6.89158663e-02f,
  1.22361928e-01f, 1.73759386e-01f, -3.67229134e-02f, 2.92899162e-02f, 1.15336003e-02f, -2.76800413e-02f, -1.94555987e-02f, -1.17455505e-01f, 7.87140355e-02f, -9.04051214e-03f,
  8.98288935e-02f, 8.58434103e-03f, -2.03824230e-03f, 5.71541265e-02f, 3.79430503e-02f, 7.95711589e-04f, 4.84374678e-03f, 3.21644731e-02f, 1.14878021e-01f, 2.69803759e-02f,
  5.76444753e-02f, 6.35443702e-02f, -1.10355653e-01f, 8.93992335e-02f, 1.45648746e-02f, 9.82018486e-02f, 4.27172892e-02f, 5.15330322e-02f, 1.26723975e-01f, 4.40582773e-03f,
  8.20507109e-02f, -9.48129520e-02f, -3.35873477e-02f, -3.10523733e-02f, -8.31563622e-02f, 7.30887204e-02f, 1.66786700e-01f, 9.30953473e-02f, 4.83433902e-02f, 1.74782351e-01f,
  -2.67083719e-02f, -2.85734367e-02f, -1.30039066e-01f, -1.97952264e-03f, -4.48140800e-02f, 4.19840682e-03f, -6.27333820e-02f, 9.29115117e-02f, -5.61862662e-02f, -1.12788472e-02f,
  -1.58044826e-02f, -6.58777058e-02f, 5.04858941e-02f, 3.56993228e-02f, 7.46351928e-02f, 1.92033034e-02f, -1.57746598e-02f, 5.13704382e-02f, 4.38309908e-02f, 8.23140070e-02f,
  1.25446334e-01f, -2.39019711e-02f, 1.68175418e-02f, -3.66252102e-02f, -3.71701317e-03f, -6.47549555e-02f, 8.27480927e-02f, -1.88705064e-02f, 2.29770015e-03f, -5.36021851e-02f,
  4.19524252e-01f, -9.44370851e-02f, 1.48692112e-02f, 1.52354643e-01f, 1.12008840e-01f, -1.29743004e-02f, -6.64313361e-02f, 8.40383843e-02f, 3.03586405e-02f, 9.54096243e-02f,
  4.88771964e-03f, -1.08215911e-02f, 9.33068320e-02f, 6.59340546e-02f, 1.17201488e-02f, -3.65175083e-02f, 3.53744300e-03f, 8.47232863e-02f, 4.36180122e-02f, 5.12919351e-02f,
  4.33921032e-02f, 3.20315138e-02f, 2.09616590e-02f, 4.93677817e-02f, 4.86491956e-02f, -9.71868783e-02f, 2.80747600e-02f, 4.28465083e-02f, -8.88072252e-02f, 9.16848853e-02f,
  -5.03797121e-02f, -4.12117153e-01f, -2.65320867e-01f, -3.11395884e-01f, -3.28416169e-01f, 3.26966345e-02f, -1.45868793e-01f, -6.88472018e-02f, 7.51047879e-02f, -1.24817058e-01f,
  -1.89751491e-01f, -2.34179311e-02f, -1.49862794e-02f, -6.31141404e-07f, -1.35205790e-01f, -1.13078207e-02f, -9.62689742e-02f, 5.76105826e-02f, -1.02641843e-02f, -1.27806082e-01f,
  -1.76270634e-01f, -1.35126814e-01f, -1.46202058e-01f, -1.10987825e-02f, -6.79937899e-02f, 1.86157674e-02f, -3.81780228e-05f, -1.06937684e-01f, 3.49972327e-03f, -3.05042475e-01f,
  6.58975765e-02f, -2.20233232e-01f, -1.51010111e-01f, -2.11488530e-01f, -1.54422075e-01f, -8.39385316e-02f, -2.38782316e-02f, -8.55625495e-02f, -1.18289188e-01f, -1.50040001e-01f,
  -2.15694144e-01f, -2.54764885e-01f, -2.57433534e-01f, -5.22565395e-02f, -9.18340087e-02f, -1.15219437e-01f, 5.08598648e-02f, -1.64204121e-01f, -1.43330216e-01f, -1.17678307e-01f,
  -3.36955249e-01f, -2.50023097e-01f, -7.97516629e-02f, 6.18743412e-02f, -6.08461536e-02f, -1.21564776e-01f, -1.07742526e-01f, -1.33190110e-01f, 2.93913484e-02f, -1.36010915e-01f,
  -3.95796867e-03f, 3.51611674e-02f, 1.59361243e-01f, 3.84648480e-02f, 1.56368583e-01f, 4.62100096e-03f, 2.67760940e-02f, 1.63413808e-02f, -2.22877692e-02f, 6.96717277e-02f,
  1.21607874e-02f, 2.92410702e-02f, -7.32696578e-02f, -5.48690557e-02f, -2.31326725e-02f, -9.16804373e-02f, 1.84539482e-02f, 3.32453847e-02f, 2.17316840e-02f, 7.56791160e-02f,
  -3.79310995e-02f, 4.02423926e-02f, 1.26891792e-01f, 7.43873268e-02f, -4.63957451e-02f, 5.21277301e-02f, 1.27327859e-01f, 7.94591159e-02f, 3.64122055e-02f, 1.27843156e-01f,
  2.14446500e-01f, 2.16411408e-02f, -7.47458935e-02f, -5.18461540e-02f, -1.99602880e-02f, 8.01352132e-03f, 1.14003299e-02f, -9.35385749e-02f, -3.19516994e-02f, -4.58223857e-02f,
  -1.32859945e-01f, -9.69907269e-02f, -1.25440329e-01f, -4.61438447e-02f, -1.16544724e-01f, 2.50011738e-02f, 2.06900705e-02f, -7.18382299e-02f, -1.16393410e-01f, -2.19908506e-02f,
  -9.14500356e-02f, 4.28398252e-02f, 1.69122681e-01f, 1.34798765e-01f, -3.40763107e-02f, 1.33825421e-01f, 1.28000811e-01f, 4.40856330e-02f, 1.25028357e-01f, 2.16398105e-01f,
  8.26429576e-02f, 1.90993845e-01f, -1.52592227e-01f, -2.03758683e-02f, 1.12098157e-01f, 8.77677426e-02f, 1.77487448e-01f, -2.52758320e-02f, 6.67869598e-02f, 9.47398618e-02f,
  4.81516030e-03f, 1.38753250e-01f, 7.20517486e-02f, -1.83325615e-02f, 2.17963755e-02f, 1.58552617e-01f, 8.86522681e-02f, -1.13824055e-01f, -8.39598477e-02f, -7.34911785e-02f,
  6.65258020e-02f, -5.62619045e-02f, -1.21109188e-01f, -8.51113796e-02f, 6.40529692e-02f, 1.18400663e-01f, 7.59084104e-03f, -1.62808746e-01f, 5.69079109e-02f, 4.67122048e-02f,
  1.55588845e-02f, -1.74352154e-01f, 1.84331775e-01f, 1.35438800e-01f, 1.04579628e-01f, 9.91272032e-02f, 1.50917456e-01f, -2.12283134e-02f, 7.87976310e-02f, 3.83833498e-02f,
  8.64198357e-02f, -1.02153253e-02f, 1.64471760e-01f, 8.09504315e-02f, 1.16518382e-02f, 8.05537179e-02f, -3.26844640e-02f, -5.29684238e-02f, 1.26646012e-01f, 1.52403072e-01f,
  2.40688249e-01f, 1.35475844e-01f, 1.13123238e-01f, 1.97350662e-02f, 8.06073248e-02f, -1.58754811e-02f, 9.25957486e-02f, -4.12405580e-02f, -5.48662059e-02f, -5.44104464e-02f,
  -7.44582042e-02f, -1.15695469e-01f, -2.34541520e-02f, -9.49339301e-04f, -2.80824043e-02f, 1.11756176e-02f, -1.17231473e-01f, -3.12777832e-02f, -4.04393785e-02f, -1.99540928e-02f,
  -1.19048193e-01f, 5.17159924e-02f, -4.68456186e-02f, -3.36212181e-02f, -4.72580791e-02f, -1.21391416e-01f, -1.13017239e-01f, -2.05273964e-02f, -1.07745178e-01f, 1.04163550e-02f,
  -4.62026009e-03f, -8.24544132e-02f, 9.26645752e-03f, -4.29762378e-02f, -5.79643622e-02f, -1.34937853e-01f, -4.69738990e-02f, 1.32645816e-02f, -1.03814052e-02f, -3.47231291e-02f,
  1.68083727e-01f, -5.74773923e-03f, 1.07616164e-01f, 1.03105672e-01f, 1.20488487e-01f, 2.22198695e-01f, 1.03001982e-01f, 1.38314083e-01f, 8.30925778e-02f, 1.30806461e-01f,
  1.60039425e-01f, 1.09960370e-01f, 8.67828801e-02f, 7.78189152e-02f, 2.89291173e-01f, 1.98671311e-01f, 1.84872836e-01f, 1.06077150e-01f, 1.26634300e-01f, 5.34024462e-02f,
  1.48080930e-01f, 1.95017695e-01f, 3.26470375e-01f, 2.04017207e-01f, 1.93086818e-01f, 2.67350763e-01f, 2.87216008e-01f, 2.73029983e-01f, 1.65437490e-01f, 4.39533204e-01f,
  -2.38720015e-01f, 4.08763997e-02f, -7.88904950e-02f, 1.27261773e-01f, -2.16014415e-01f, -1.42959766e-02f, -1.70040414e-01f, 1.19447142e-01f, 6.09783269e-02f, -1.43833339e-01f,
  4.35486585e-02f, 5.25307432e-02f, 7.92945176e-02f, 2.32676670e-01f, 5.98702431e-02f, -1.37323409e-01f, -3.10707003e-01f, -6.62902817e-02f, 2.43423656e-01f, 1.92889258e-01f,
  -2.04835702e-02f, 8.60471558e-03f, 1.10682808e-01f, 1.50291383e-01f, -1.31146431e-01f, 6.66448474e-02f, -4.88815494e-02f, -7.90067017e-03f, 7.50969222e-04f, -1.09354623e-01f,
  1.55771941e-01f, 6.56258687e-02f, 1.03756770e-01f, -5.36308698e-02f, 9.56468955e-02f, -1.87500268e-02f, 2.59013269e-02f, 9.94731039e-02f, 2.13964358e-02f, 2.51034033e-02f,
  -1.18853860e-01f, 1.83056563e-03f, -1.35205891e-02f, 1.68258935e-01f, 1.12481698e-01f, 9.00726207e-03f, 7.68947974e-02f, 5.82778528e-02f, 8.96775723e-02f, 2.01862194e-02f,
  3.32738049e-02f, 2.82825064e-02f, 9.78622865e-03f, 1.31878495e-01f, 1.27985537e-01f, 1.20204203e-01f, 1.77958935e-01f, 1.68912292e-01f, 2.42240205e-01f, 1.64969936e-01f,
  -2.73018014e-02f, 3.03932391e-02f, 7.76163489e-02f, -4.54380810e-02f, -7.53979832e-02f, -7.18812598e-03f, -4.16405313e-02f, -4.21246700e-02f, 7.85000250e-02f, -1.23441303e-02f,
  1.61679890e-02f, 3.49919759e-02f, -4.46159542e-02f, -4.86094840e-02f, 4.28610668e-02f, -2.19643228e-02f, -4.19635139e-02f, 5.01597151e-02f, -5.74481348e-03f, -7.77649805e-02f,
  -7.79642463e-02f, -8.81988963e-04f, -9.37545449e-02f, 8.05287212e-02f, -1.24120168e-01f, -4.48989533e-02f, -1.65043369e-01f, -3.78192891e-03f, 7.46299773e-02f, -6.36399165e-02f,
  2.56873429e-01f, 1.16168551e-01f, 6.71942309e-02f, 5.83418943e-02f, 1.72160584e-02f, -5.82670495e-02f, 2.21071951e-02f, -2.38349605e-02f, -8.79477337e-02f, 6.39869869e-02f,
  1.87548976e-02f, -3.62527221e-02f, 2.11328901e-02f, 7.54512772e-02f, 6.79499507e-02f, 9.68472213e-02f, -8.92501622e-02f, -4.38786931e-02f, 9.05343369e-02f, 1.75505299e-02f,
  -1.06724147e-02f, 6.34445399e-02f, 4.92026396e-02f, -2.74046492e-02f, -4.22116257e-02f, -1.03292532e-01f, -8.94502737e-03f, -1.35436524e-02f, -4.52915467e-02f, -1.26068652e-01f,
  8.98295105e-01f, -2.09322765e-01f, 1.11291468e-01f, -8.57895091e-02f, -1.17920965e-01f, 2.16906130e-01f, 1.69027701e-01f, -5.64311855e-02f, -7.45783672e-02f, 1.65350139e-02f,
  3.42994630e-02f, -1.37558475e-01f, -4.54149842e-02f, -1.84501305e-01f, 1.45794317e-01f, -7.46451644e-03f, -7.40651935e-02f, 1.46491125e-01f, 1.60682976e-01f, -4.58614603e-02f,
  -2.34958261e-01f, 4.67917062e-02f, 8.78622681e-02f, 3.92826125e-02f, -1.67338297e-01f, -9.19817761e-02f, -1.94059033e-02f, -4.88574384e-03f, -3.16121057e-02f, -3.38675976e-01f,
  2.01747820e-01f, 2.78765112e-01f, -6.35485947e-02f, -7.78225660e-02f, -7.46683702e-02f, 4.95212036e-04f, 7.51684085e-02f, 2.12328322e-02f, 1.79516971e-02f, 2.62835696e-02f,
  6.89325780e-02f, -1.29954750e-03f, 2.88634142e-03f, -1.24432677e-02f, 8.92672688e-02f, 1.11666834e-02f, -2.00441945e-02f, 1.63622834e-02f, 4.39178348e-02f, -2.41100285e-02f,
  -8.65256339e-02f, 9.92966932e-04f, 1.73400745e-01f, 5.64914681e-02f, 9.82513800e-02f, 6.69445693e-02f, -6.73135221e-02f, 8.52136239e-02f, 1.34441420e-01f, -1.68995649e-01f,
  8.80275201e-03f, 3.55583392e-02f, 5.46540320e-02f, -5.84261231e-02f, -9.69275087e-02f, -2.41066553e-02f, -2.91753304e-03f, 2.05714088e-02f, -3.76454666e-02f, 8.06774721e-02f,
  -8.49425718e-02f, -2.79076900e-02f, 4.00157794e-02f, 3.16193365e-02f, -2.15625335e-02f, 2.29701344e-02f, 8.36742520e-02f, -7.25262389e-02f, 4.08311887e-03f, 3.66346538e-02f,
  1.08727170e-02f, 7.29448453e-04f, 2.77620051e-02f, -6.78188279e-02f, 3.83921303e-02f, 1.72319934e-02f, -1.36199957e-02f, -3.41802277e-02f, 8.80807638e-03f, -2.51372103e-02f,
  -1.50862768e-01f, 6.21882528e-02f, -1.05414269e-02f, 1.55958617e-02f, 7.04368502e-02f, -4.63607870e-02f, -5.58905117e-03f, 7.36300321e-03f, -2.64514070e-02f, -1.61954723e-02f,
  -5.22608384e-02f, 1.03206513e-02f, 3.75068597e-02f, -8.28245729e-02f, 2.06848141e-02f, -3.01306453e-02f, -4.49957438e-02f, 3.40724885e-02f, 4.85907192e-04f, -5.71852177e-02f,
  -1.43242463e-01f, 1.10538818e-01f, 8.60172883e-02f, -3.71299917e-03f, -2.22476888e-02f, 3.11515052e-02f, 1.21767661e-02f, -2.28790920e-02f, 5.01483195e-02f, -1.46740317e-01f,
  7.65698850e-01f, -2.84970552e-01f, -4.37139673e-03f, 1.67265519e-01f, -2.60050207e-01f, 1.99825212e-01f, -6.09058850e-02f, 2.83984661e-01f, 2.53264427e-01f, -1.29209459e-01f,
  -1.25082195e-01f, -1.88309848e-01f, -1.17183670e-01f, -5.11206836e-02f, 2.47331157e-01f, -1.02935776e-01f, -8.81758854e-02f, 1.72218263e-01f, 2.76413679e-01f, 1.83989435e-01f,
  -2.08155304e-01f, -1.83412191e-02f, 3.60236615e-01f, 2.25986317e-01f, -2.12614596e-01f, 1.07001677e-01f, -1.36140585e-01f, -1.42016947e-01f, -1.00533821e-01f, -1.65196642e-01f,
  -1.67868182e-01f, -6.35032281e-02f, -1.50858266e-02f, 4.16848958e-02f, -1.83078960e-01f, 1.52043387e-01f, -2.54053660e-02f, 4.32788730e-02f, -4.62785829e-03f, -3.27429958e-02f,
  -1.01040103e-01f, -1.04834899e-01f, 2.34699016e-03f, -6.81360364e-02f, -1.40524954e-02f, 4.44116779e-02f, -1.29858805e-02f, 1.22700416e-01f, 9.38113630e-02f, -9.66681540e-02f,
  -2.44833052e-01f, -1.81464002e-01f, -9.28027853e-02f, -6.42974377e-02f, -2.13653408e-03f, -1.04142889e-01f, -1.01645358e-01f, -2.99476888e-02f, 6.84766052e-03f, 2.44551711e-02f,
  9.40557048e-02f, -1.34817585e-02f, 6.71306998e-03f, 1.10938750e-01f, 1.93242934e-02f, 7.47738220e-03f, -4.34773676e-02f, -4.02207114e-02f, 6.58446476e-02f, 7.24932328e-02f,
  -8.36150907e-03f, -3.01162014e-03f, 6.04492314e-02f, 1.09366458e-02f, -6.84491917e-03f, -1.85744222e-02f, 7.31036812e-02f, -2.75016949e-02f, -3.10954228e-02f, 3.01369429e-02f,
  -2.25220881e-02f, 1.10077992e-01f, -8.51665810e-02f, 7.34089091e-02f, 1.08817276e-02f, -1.82317626e-02f, 9.38650891e-02f, -3.57519947e-02f, 4.41248752e-02f, -1.60278414e-05f,
  -4.27779406e-02f, -3.57337035e-02f, -3.76508273e-02f, -2.85099912e-02f, 3.09526529e-02f, 9.50510502e-02f, -4.90019061e-02f, 6.31895661e-02f, -5.61196208e-02f, -3.61568555e-02f,
  1.39317652e-02f, 3.18293609e-02f, -5.37195429e-02f, -4.02688198e-02f, 3.45345959e-02f, 5.67780733e-02f, -9.98483971e-03f, 1.19830705e-01f, -1.86332427e-02f, -4.83813658e-02f,
  1.66060869e-02f, 1.81396008e-01f, 1.33959666e-01f, 6.64850473e-02f, -5.89461476e-02f, 3.16420421e-02f, -1.05041116e-01f, 7.42063746e-02f, 1.20800488e-01f, 6.92821965e-02f,
  5.71778893e-01f, -2.18392909e-01f, -1.02162085e-01f, 2.13142395e-01f, -3.71629208e-01f, -2.18449652e-01f, -4.75919366e-01f, 4.04526554e-02f, 1.62627652e-01f, -6.26275390e-02f,
  -5.56718893e-02f, 1.19447164e-01f, 2.10634395e-01f, -5.87612614e-02f, 8.06479678e-02f, -2.04859853e-01f, -1.67862177e-01f, 1.68814853e-01f, 2.92476773e-01f, -5.01620248e-02f,
  -1.41780064e-01f, 1.45415831e-02f, 3.35611224e-01f, 1.14846714e-01f, 5.92178702e-02f, 7.14935735e-02f, -2.31078379e-02f, -8.11457336e-02f, -5.63443974e-02f, -4.51284684e-02f,
  1.13679275e-01f, -2.54438430e-01f, -1.36029292e-02f, 1.11344002e-01f, -7.40950480e-02f, 6.89987019e-02f, 1.80757008e-02f, -2.00296100e-02f, -1.14266723e-02f, -3.73167284e-02f,
  1.44643597e-02f, -3.96859199e-02f, 3.23801599e-02f, -1.89400557e-02f, -1.05738826e-01f, -1.33266794e-02f, -2.90409867e-02f, 5.66986576e-02f, -3.06555630e-05f, -4.80930209e-02f,
  -1.09334596e-01f, -1.13167405e-01f, -1.59396484e-01f, -1.66650400e-01f, -2.64471211e-02f, 1.18484180e-02f, -1.22095622e-01f, -3.15388851e-02f, -3.59686837e-02f, 1.55854411e-02f,
  6.07692003e-02f, -3.16033773e-02f, 9.13388841e-03f, -1.29429735e-02f, -2.44438858e-03f, 6.05888218e-02f, -4.68935166e-03f, -1.30119538e-02f, -1.24312071e-02f, 3.18208300e-02f,
  2.24364456e-02f, 2.67172488e-03f, 6.41835853e-02f, -3.41568664e-02f, -9.26065221e-02f, -1.25475368e-02f, 3.04673966e-02f, 6.12681219e-03f, -3.00526023e-02f, -2.73077432e-02f,
  8.15464854e-02f, -5.68426847e-02f, 2.99731065e-02f, 1.95748862e-02f, -3.31242085e-02f, 6.63814619e-02f, 8.67113192e-03f, -1.47958135e-03f, 8.38111192e-02f, 6.19769506e-02f,
  4.31682542e-02f, -1.71653703e-01f, 6.99663237e-02f, -5.83195733e-03f, -1.36425167e-01f, -5.47090992e-02f, -1.04351036e-01f, -5.32623716e-02f, -2.10676640e-02f, -1.34952858e-01f,
  -8.55495259e-02f, -4.74358425e-02f, -1.07146069e-01f, 9.74160712e-03f, 5.64913005e-02f, -9.00235698e-02f, 1.52995884e-02f, 7.49375485e-03f, -4.19280827e-02f, -6.63690567e-02f,
  -3.19448858e-02f, -8.44080672e-02f, -2.59161629e-02f, -6.58530295e-02f, 7.01745600e-02f, -2.81969178e-02f, -5.61482869e-02f, -1.40451901e-02f, -8.86316895e-02f, -2.62060054e-02f,
  -1.87464997e-01f, 1.46561742e-01f, -1.64475113e-01f, 6.84688799e-03f, 1.82016909e-01f, 2.27242410e-02f, -1.24642635e-02f, -1.00930971e-04f, -1.25440434e-01f, -4.09669802e-02f,
  1.59715906e-01f, 1.62222574e-03f, -6.64967224e-02f, 3.51093933e-02f, -5.14279455e-02f, -6.52013272e-02f, -3.19364741e-02f, -8.11378807e-02f, -2.58513033e-01f, 1.17748538e-02f,
  1.46241188e-01f, 2.00865287e-02f, -4.58156094e-02f, -1.15514778e-01f, 8.91263708e-02f, -6.46960214e-02f, -3.01768240e-02f, 2.22161382e-01f, 1.82636961e-01f, 2.18156308e-01f,
  1.16695592e-03f, 2.79815853e-01f, -9.26057473e-02f, -3.22992206e-02f, -2.16130819e-02f, -1.73575990e-02f, 3.53582203e-02f, 2.64971741e-02f, -8.03991780e-02f, -4.10025008e-02f,
  7.62321576e-02f, -2.22652592e-02f, 3.38394009e-02f, 6.59055039e-02f, 5.95954917e-02f, 1.09989140e-02f, 1.09163754e-01f, 6.73568668e-03f, -8.65605380e-03f, 6.04361808e-03f,
  9.69709754e-02f, 1.29972950e-01f, 9.87924710e-02f, 4.68056053e-02f, -3.58245559e-02f, -7.12348195e-03f, 7.60119855e-02f, 1.50530294e-01f, -3.97009216e-02f, 2.49929223e-02f,
  2.16051284e-02f, 1.73917953e-02f, 5.30210286e-02f, -5.33823948e-03f, -1.64621491e-02f, -1.61586329e-02f, 9.87974331e-02f, -9.01828334e-02f, -4.95996289e-02f, 1.14192879e-02f,
  -5.50039019e-03f, -6.11597747e-02f, -3.71352360e-02f, -4.43111397e-02f, -1.32792490e-02f, 3.37537425e-03f, -7.89512917e-02f, -4.00163196e-02f, -6.01610951e-02f, -7.45337903e-02f,
  -1.04370210e-02f, 8.46220553e-03f, -5.16559854e-02f, -9.30108428e-02f, 1.22367710e-01f, -4.49885018e-02f, 2.20228899e-02f, -3.31079736e-02f, -3.09686996e-02f, -4.34549572e-03f,
  -2.70361573e-01f, -5.74002787e-02f, -1.29512414e-01f, 2.26080716e-02f, -5.70465811e-03f, 1.79056469e-02f, -4.35275584e-02f, 6.05052151e-02f, 9.33997612e-03f, -7.13181421e-02f,
  4.85628694e-02f, -1.86455399e-02f, -2.30032252e-03f, -1.21041164e-01f, 2.52052024e-02f, -6.41233921e-02f, -4.91623729e-02f, -3.62203643e-02f, 8.90524834e-02f, 9.16444231e-03f,
  3.37880775e-02f, -9.35783423e-03f, -9.16009992e-02f, -4.27055210e-02f, -1.47853484e-02f, -7.89596662e-02f, -1.10678136e-01f, -1.16117239e-01f, -7.85116851e-02f, -2.40849242e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.88625291e-01f, -9.59573239e-02f, -3.04510653e-01f, 2.21285541e-02f, -1.33687735e-01f, -7.80433714e-02f, -1.31817251e-01f, 7.26229101e-02f, 6.49734363e-02f, -3.99152264e-02f,
  5.68654276e-02f, 2.93810368e-01f, 2.37782851e-01f, 1.98104620e-01f, 1.72843367e-01f, -1.58654317e-01f, -2.60148823e-01f, -9.66387764e-02f, 1.96063623e-01f, 8.13064799e-02f,
  8.34857207e-03f, -2.11697280e-01f, -1.93104163e-01f, -1.09400913e-01f, -2.54552692e-01f, -6.67815581e-02f, -3.71095866e-01f, -3.77806515e-01f, -2.76168078e-01f, -4.12459105e-01f,
  4.63839173e-01f, -1.82532950e-03f, 9.25627425e-02f, 5.13609387e-02f, -6.73781261e-02f, 8.43629241e-02f, 1.20366126e-01f, 6.29840195e-02f, 1.59671947e-01f, 1.21549323e-01f,
  -1.32643683e-02f, -3.81550789e-02f, 5.41820899e-02f, -4.42328006e-02f, 5.62511981e-02f, -1.13310702e-02f, -8.36551338e-02f, 4.56892960e-02f, -2.11041644e-02f, 7.32669085e-02f,
  2.74352860e-02f, -5.69578633e-02f, 1.39766172e-01f, 5.11590838e-02f, -2.56965831e-02f, 6.73300847e-02f, 4.14584391e-02f, -4.38613370e-02f, 1.19721971e-03f, 3.10717169e-02f,
  1.65254742e-01f, 8.69659614e-03f, -2.13264957e-01f, 9.48068723e-02f, 8.26601014e-02f, 5.21936687e-04f, 1.44980013e-01f, 3.04736961e-02f, -1.29782734e-02f, -1.98840484e-01f,
  1.22677334e-01f, 6.83975890e-02f, 9.97360423e-02f, -2.29046755e-02f, -3.46675366e-02f, -1.19406722e-01f, -1.46773666e-01f, 9.94873643e-02f, -1.18199788e-01f, -8.09273869e-02f,
  7.15075061e-02f, 3.34083401e-02f, -3.07681412e-02f, -4.40674797e-02f, -6.19744807e-02f, -1.55255524e-02f, -3.43415588e-02f, -4.55196984e-02f, -9.35968906e-02f, -1.04865715e-01f,
  4.58102852e-01f, 1.38398096e-01f, 2.09369436e-01f, 8.37952539e-04f, -1.92465186e-01f, -2.08281949e-02f, 3.54238227e-02f, 6.53641894e-02f, 3.67060937e-02f, 1.60869911e-01f,
  1.79965496e-01f, 1.75615266e-01f, 8.36857036e-02f, -1.01565234e-01f, 3.29908393e-02f, 9.64917243e-02f, -1.35254025e-01f, 4.45243269e-02f, 1.23803109e-01f, 1.02801219e-01f,
  4.61285636e-02f, 1.97926369e-02f, 3.71406317e-01f, 2.21246928e-01f, 1.80768833e-01f, 1.99764758e-01f, 2.31211990e-01f, 1.11001022e-01f, 1.22047342e-01f, 2.26594105e-01f,
  -5.00784397e-01f, 3.92872430e-02f, -5.81801891e-01f, -3.56648386e-01f, -2.67867118e-01f, -1.64843127e-02f, -2.48173974e-03f, 3.37608784e-01f, 1.36491984e-01f, -2.16000289e-01f,
  -3.55940573e-02f, 3.25051770e-02f, -1.92229316e-01f, 2.70246179e-04f, 5.21705560e-02f, -2.75921851e-01f, -4.40476775e-01f, -3.68442893e-01f, -2.47516632e-02f, 1.29609048e-01f,
  9.95257311e-03f, -1.57746166e-01f, -9.09032673e-02f, -5.12270257e-02f, -1.24074057e-01f, -8.19123089e-02f, -3.67675722e-01f, -3.87682468e-02f, 8.28039944e-02f, -4.45166916e-01f,
  -4.45508868e-01f, -9.17412415e-02f, -2.69854907e-02f, 1.34140132e-02f, -2.37407953e-01f, -7.59187415e-02f, -1.88631359e-02f, -1.25274226e-01f, -4.68723141e-02f, -8.07974581e-03f,
  -1.69284821e-01f, 1.31115690e-01f, -3.83539237e-02f, -5.22360951e-02f, -9.24546570e-02f, -9.21677053e-02f, -2.68715285e-02f, -1.48668706e-01f, -4.37348150e-02f, 1.76346693e-02f,
  1.03736915e-01f, -6.82909116e-02f, 6.70085996e-02f, 5.51317707e-02f, 1.85188483e-02f, 3.17468047e-02f, 7.06501678e-02f, 1.53491572e-01f, 5.32563664e-02f, 6.94457591e-02f,
  1.12889722e-01f, 3.47002931e-02f, 3.42778570e-04f, -1.08937798e-02f, 4.42807749e-02f, -3.03310566e-02f, -3.26031935e-03f, 1.31311253e-01f, 1.52604235e-02f, 4.82047983e-02f,
  -2.53988449e-02f, -8.37650895e-02f, 5.47486991e-02f, -9.28224921e-02f, -1.11751027e-01f, 4.30735536e-02f, -2.66655404e-02f, 8.30083191e-02f, -1.10487491e-02f, 4.51371372e-02f,
  -4.12676372e-02f, 3.02981194e-02f, -8.08289871e-02f, -3.13558057e-02f, -1.64378867e-01f, -5.07031940e-02f, -3.39159593e-02f, 7.64061976e-03f, 2.59673614e-02f, 3.83197417e-04f,
  7.93909933e-03f, -4.10057865e-02f, -7.16517717e-02f, 2.56884526e-02f, -7.22145438e-02f, -6.62677959e-02f, -9.22781155e-02f, -8.18221569e-02f, -9.43715405e-03f, -1.22610144e-01f,
  1.12474822e-01f, 8.49404559e-02f, -5.26074134e-02f, -2.56897453e-02f, 2.99204160e-02f, 2.81127412e-02f, 2.43707094e-02f, 1.73626523e-02f, 2.92051155e-02f, 1.01824082e-01f,
  2.67817855e-01f, 1.59886032e-01f, 1.80385783e-01f, 2.26695314e-01f, 2.02839017e-01f, 2.36262813e-01f, 2.39413902e-02f, 1.16292611e-01f, 4.38552313e-02f, 3.39576453e-01f,
  -7.80232191e-01f, -1.76221117e-01f, 4.10232574e-01f, -3.90551418e-01f, 1.63316712e-01f, 2.51202375e-01f, 5.79282403e-01f, 8.21092948e-02f, -2.50295579e-01f, 9.38379914e-02f,
  -2.61077613e-01f, -2.66609162e-01f, -3.25013369e-01f, 2.56603081e-02f, -6.57127379e-03f, 3.66856456e-01f, 3.42626184e-01f, 1.02920003e-01f, 2.44736716e-01f, 2.30649218e-01f,
  6.87521100e-02f, -1.18193537e-01f, -4.44033921e-01f, -1.20212905e-01f, -5.91881126e-02f, 4.14913930e-02f, 7.12956255e-03f, -1.53355673e-01f, -4.23348844e-02f, -5.29961288e-02f,
  1.91174567e-01f, -1.05570935e-01f, 1.01104550e-01f, -2.38607794e-01f, -8.94941315e-02f, -1.69413641e-01f, 3.94602679e-02f, -2.67501883e-02f, -1.43746227e-01f, -5.92515580e-02f,
  -1.56479791e-01f, -9.67852771e-02f, -1.98386833e-02f, 2.70750504e-02f, 5.79397101e-03f, -1.04588047e-01f, -6.95004240e-02f, -1.09741792e-01f, -1.64616574e-02f, 2.29391158e-02f,
  -1.29139990e-01f, -7.61913434e-02f, -6.36957735e-02f, 1.04103200e-01f, 6.02646135e-02f, -4.27594334e-02f, -4.00280319e-02f, -7.54976273e-02f, -5.19359931e-02f, -1.50419697e-01f,
  9.25079808e-02f, -8.47934373e-03f, 5.37546575e-02f, 1.23281525e-02f, -2.61226241e-02f, 2.94306949e-02f, 6.81163073e-02f, 2.85617299e-02f, 8.36279616e-02f, 3.78827080e-02f,
  -1.76103245e-02f, 2.68829521e-02f, 1.93926841e-02f, -7.45180016e-03f, -2.23388597e-02f, -1.08088903e-01f, 9.62373018e-02f, -3.51377688e-02f, -2.12969221e-02f, -1.21780328e-01f,
  -1.05702551e-02f, -4.71059728e-04f, -8.37284178e-02f, 4.36973795e-02f, -2.05319952e-02f, 4.12982563e-03f, -6.49457946e-02f, -6.71478882e-02f, 1.46949552e-02f, -5.86346090e-02f,
  -1.28900290e-01f, -1.17040444e-02f, -1.74551196e-02f, -8.64105001e-02f, 7.35585168e-02f, -6.48210272e-02f, -1.36049539e-01f, -2.46563796e-02f, -4.76203226e-02f, 6.07090071e-02f,
  1.01104437e-03f, 4.55407649e-02f, -2.52435021e-02f, 2.21547354e-02f, 6.08233847e-02f, 6.94472939e-02f, -5.71368113e-02f, 1.98111776e-02f, 5.57051562e-02f, 7.76892602e-02f,
  -3.32579874e-02f, 1.13062724e-01f, 2.10001126e-01f, 1.06845960e-01f, 2.71198852e-03f, 1.70663744e-02f, 1.88616470e-01f, 1.19141050e-01f, 1.79270342e-01f, 2.43397623e-01f,
  -2.65697539e-01f, -1.84171274e-01f, -2.19360828e-01f, -4.19314839e-02f, 1.09627284e-02f, 2.46989593e-01f, -2.02384129e-01f, 2.42339537e-01f, 3.85632604e-01f, -1.54927924e-01f,
  -2.45843753e-02f, 7.81387389e-02f, -1.60595939e-01f, -6.01987392e-02f, -5.32710403e-02f, -1.61009416e-01f, -2.34356955e-01f, -1.49385422e-01f, 2.65471637e-01f, 4.96770948e-01f,
  5.83431982e-02f, -1.56160638e-01f, -1.33444369e-01f, 1.28216133e-01f, 7.63252825e-02f, -7.70925507e-02f, -3.04274350e-01f, -1.26793623e-01f, -1.61494210e-01f, -5.45068204e-01f,
  -1.34144440e-01f, 2.04304829e-01f, 5.30810244e-02f, -1.22407533e-01f, -6.99921921e-02f, 3.37498300e-02f, 1.52345791e-01f, 7.26283807e-03f, -6.26393128e-03f, 4.00099866e-02f,
  -3.35662737e-02f, 1.62067205e-01f, -9.62594617e-03f, -2.72881780e-02f, 9.02321637e-02f, 1.32466942e-01f, 8.84091947e-03f, -4.07557981e-03f, 1.04021828e-03f, 1.81427270e-01f,
  -1.53423339e-01f, -2.26572230e-01f, -2.05605105e-01f, 1.89663712e-02f, 3.61703672e-02f, -3.11394334e-02f, 2.68298499e-02f, 3.67948115e-02f, -1.03973821e-01f, -2.17744440e-01f,
  5.47353476e-02f, 7.40312636e-02f, 3.26067209e-02f, -3.26016545e-02f, -1.14728980e-01f, -8.71756487e-03f, -6.10268936e-02f, -7.77146891e-02f, 1.52451536e-02f, -8.22728723e-02f,
  9.55343023e-02f, -8.84983782e-03f, -2.21023634e-02f, 2.41649430e-02f, -5.64184338e-02f, 1.50794433e-02f, -2.11658683e-02f, -5.73433936e-02f, 7.42848124e-03f, -7.85015076e-02f,
  -1.09128259e-01f, 4.14042845e-02f, -4.29288782e-02f, 1.36553288e-01f, -7.57248551e-02f, -5.36187291e-02f, -3.43851931e-02f, -2.82038581e-02f, -2.69771609e-02f, 1.11947499e-01f,
  -7.25176372e-03f, -5.30891865e-03f, -2.49833874e-02f, -6.03040457e-02f, -1.95120573e-02f, -8.16800669e-02f, -1.08652398e-01f, -1.12622783e-01f, -9.12503600e-02f, 5.04257716e-02f,
  -1.54495146e-03f, -3.57883461e-02f, -2.24407583e-01f, 1.83977205e-02f, 1.81319974e-02f, 5.99343963e-02f, -1.81291416e-01f, -1.35043442e-01f, -6.00389997e-03f, 7.64848143e-02f,
  -2.70298511e-01f, -5.16986623e-02f, -8.70295838e-02f, -1.18168190e-01f, -8.53381231e-02f, -1.80533472e-02f, -9.37517881e-02f, -2.45141946e-02f, -1.11183889e-01f, -2.08694711e-01f,
  -2.93156624e-01f, 8.01207945e-02f, -4.05551732e-01f, -2.07399085e-01f, 3.03934157e-01f, 3.69728580e-02f, 6.45414665e-02f, -1.02890089e-01f, -7.35506341e-02f, 4.07910980e-02f,
  1.26734510e-01f, 1.96017697e-01f, 1.16703309e-01f, 4.45048511e-02f, -2.23541811e-01f, 1.52497038e-01f, 5.24586663e-02f, -2.06794024e-01f, -2.49555126e-01f, -1.02573708e-01f,
  2.76010185e-01f, -3.47573832e-02f, -2.61006117e-01f, -7.53742754e-02f, 1.15245856e-01f, 5.57639524e-02f, 5.17697819e-02f, 1.35585189e-01f, 2.67808288e-01f, 2.00335458e-01f,
  -2.50101358e-01f, -1.88802585e-01f, 7.50396028e-02f, 1.77087501e-01f, 6.28307927e-03f, -1.01760283e-01f, -5.46741784e-02f, 4.95325262e-03f, 2.09244937e-02f, -4.55534570e-02f,
  1.67932495e-01f, -1.46995008e-01f, 9.20023397e-02f, 1.07793696e-02f, -7.60064945e-02f, -7.46372044e-02f, 3.66619490e-02f, -8.39839652e-02f, -2.52459973e-01f, -2.80856580e-01f,
  2.36056924e-01f, 3.29228222e-01f, -3.31750959e-02f, -5.41471355e-02f, -1.83455497e-01f, 1.05213411e-02f, -3.08837682e-01f, -2.41759434e-01f, -3.13349634e-01f, -4.15053725e-01f,
  5.98623343e-02f, -1.14428243e-02f, 2.46847123e-02f, -9.10817534e-02f, -1.29298508e-01f, 1.07386917e-01f, 6.04167357e-02f, 5.70349060e-02f, 1.20527586e-02f, 2.95192376e-02f,
  -6.72107786e-02f, 5.14022224e-02f, -2.75741927e-02f, -9.01840851e-02f, -3.35833579e-02f, 1.99483000e-02f, 6.25136048e-02f, -6.13886863e-03f, 2.76842099e-02f, 3.81230488e-02f,
  -2.30185632e-02f, -5.47038466e-02f, 1.37309423e-02f, 6.64811209e-02f, 1.04398429e-01f, -1.18382480e-02f, 2.73180027e-02f, 2.07077079e-02f, -1.33959264e-01f, -3.55245918e-02f,
  -1.34152338e-01f, 1.87992677e-01f, -1.43790413e-02f, 2.60327887e-02f, 2.97042392e-02f, 3.59393209e-02f, 3.02134138e-02f, 1.15556613e-01f, 3.85336950e-02f, -9.23529565e-02f,
  1.91987567e-02f, -7.89122656e-02f, -6.22585006e-02f, 2.40749307e-02f, -2.15528980e-01f, 7.47474730e-02f, 4.85802963e-02f, 1.06681451e-01f, -7.30494503e-03f, -7.91022405e-02f,
  -1.18099146e-01f, -6.36864081e-02f, -9.82065722e-02f, -1.01953827e-01f, 5.36857136e-02f, -2.79501416e-02f, -1.84488252e-01f, 2.60081235e-02f, -1.51287884e-01f, -4.30470705e-01f,
  -1.89488366e-01f, -5.24656296e-01f, -7.74451271e-02f, 5.82875572e-02f, -1.63640201e-01f, 9.46645066e-03f, -4.72582102e-01f, 6.57396689e-02f, 1.44813746e-01f, -4.63783264e-01f,
  -2.62179375e-01f, 2.80933440e-01f, 9.28475037e-02f, 1.37731612e-01f, 2.14166567e-01f, -4.79862094e-01f, -1.90649778e-01f, 1.11917049e-01f, 5.24932683e-01f, 1.76003650e-01f,
  -3.21475454e-02f, 4.49513532e-02f, 2.98903912e-01f, 2.06420630e-01f, -1.86719626e-01f, -7.07501397e-02f, -2.42582321e-01f, 4.55532136e-04f, -7.42596760e-02f, -5.97197890e-01f,
  -3.13137710e-01f, -1.37457758e-01f, 2.06755236e-01f, 9.26764309e-02f, -1.53203130e-01f, -1.21333502e-01f, -1.11952953e-01f, -9.56930667e-02f, -1.11590073e-01f, -3.14281844e-02f,
  9.25365165e-02f, 7.95311704e-02f, 1.34732783e-01f, 8.92655477e-02f, -4.66889851e-02f, -2.30702404e-02f, 5.94307249e-03f, 2.86447164e-02f, -7.96296000e-02f, -1.23354070e-01f,
  -1.30947486e-01f, 1.52100280e-01f, 1.18762963e-01f, 4.78717238e-02f, 8.68423805e-02f, 9.66863483e-02f, -3.69203761e-02f, 8.60866308e-02f, 8.13484117e-02f, -3.91734898e-01f,
  -5.45940548e-02f, -1.00177422e-01f, -2.30454598e-02f, 5.31236418e-02f, 4.92329746e-02f, -3.11163031e-02f, 1.06666461e-02f, -1.44563671e-02f, 4.29304093e-02f, -2.30854731e-02f,
  -2.51670871e-02f, 2.00177431e-02f, -1.18382263e-03f, 1.66552048e-02f, -8.57542828e-02f, 6.66693002e-02f, -4.57667187e-02f, 3.76707055e-02f, 3.16381231e-02f, 3.26524004e-02f,
  1.05389588e-01f, 8.56349617e-02f, -1.05372272e-01f, 5.91420233e-02f, 1.32416664e-02f, 3.10693979e-02f, 1.59041435e-02f, 9.29422851e-04f, 1.76989716e-02f, -6.08069524e-02f,
  2.59881094e-02f, 1.84291303e-01f, -2.20547318e-01f, 4.33622934e-02f, -4.93885204e-03f, -6.92792535e-02f, -3.85688171e-02f, 3.08835693e-02f, 6.07597418e-02f, -2.91790403e-02f,
  1.45296171e-01f, -6.72037378e-02f, -1.46576583e-01f, -5.19449487e-02f, 3.55896726e-02f, 4.99517508e-02f, -2.44106073e-02f, -1.10988226e-02f, 1.51189432e-01f, 3.41777727e-02f,
  -1.17887231e-02f, 5.45569137e-03f, 6.42936230e-02f, -2.04996765e-02f, 6.86035901e-02f, 9.13389921e-02f, -1.17726654e-01f, -1.12952068e-01f, -3.77048887e-02f, -3.95341545e-01f,
  7.00125098e-01f, 5.17098069e-01f, 5.86978376e-01f, 8.98142010e-02f, -1.02233849e-01f, 1.99709579e-01f, 3.55115175e-01f, 1.83455840e-01f, -1.49136528e-01f, 7.71215856e-02f,
  1.15301855e-01f, -1.43312201e-01f, -2.05647394e-01f, -5.42495213e-02f, 1.09350614e-01f, 6.81745261e-02f, -1.54597864e-01f, 1.25106603e-01f, -6.19614087e-02f, -9.77184810e-03f,
  -2.53309935e-01f, 2.56711040e-02f, 8.69470537e-02f, 1.94790121e-02f, -1.56938750e-02f, -1.54649824e-01f, -2.75302269e-02f, 1.32755026e-01f, -4.87288274e-03f, 1.48993745e-01f,
  3.86660606e-01f, 4.68898505e-01f, -2.74278671e-01f, -1.35067254e-01f, 8.53397474e-02f, 1.48514251e-03f, 1.27970735e-02f, -2.57340204e-02f, -5.78317940e-02f, -6.82097375e-02f,
  2.31039096e-02f, 1.76794908e-03f, -6.45132810e-02f, 5.03705926e-02f, 6.78644925e-02f, 7.19648749e-02f, 1.38868168e-01f, 5.90648502e-02f, 8.84516258e-03f, 8.38330016e-02f,
  -4.46658544e-02f, 1.41114742e-01f, 7.31009915e-02f, 4.33165841e-02f, -2.40346370e-03f, -1.13488287e-01f, 2.10685968e-01f, 6.83814287e-02f, 1.03251025e-01f, 9.85301733e-02f,
  -1.59711123e-01f, -5.71608990e-02f, -1.62258409e-02f, -7.39618167e-02f, -7.55036026e-02f, -1.29837245e-02f, 1.78993624e-02f, 1.36003410e-02f, -3.26814763e-02f, -4.51532491e-02f,
  -5.81181655e-03f, 6.21245690e-02f, 1.04581803e-01f, -9.28181857e-02f, -1.18240211e-02f, 1.26228407e-01f, 1.61253095e-01f, 4.45083715e-02f, 5.97240888e-02f, -4.50810567e-02f,
  -8.22602957e-03f, 5.47405519e-02f, 3.73126119e-02f, 7.38706663e-02f, -1.02393730e-02f, 4.80347760e-02f, 5.08039780e-02f, -1.75934434e-02f, -1.50823006e-02f, 1.66440161e-03f,
  -5.81562668e-02f, -3.65749858e-02f, 2.26783846e-03f, 2.85350047e-02f, 1.91762224e-01f, 1.33508649e-02f, 9.78568345e-02f, -6.37472747e-03f, -1.06086731e-01f, 1.74857266e-02f,
  1.47799999e-01f, 4.55311462e-02f, -2.24313475e-02f, 4.60367948e-02f, -1.40462309e-01f, -9.52729434e-02f, 9.53024179e-02f, 9.66473389e-03f, 6.21923506e-02f, 3.33425142e-02f,
  1.84152685e-02f, -9.77344662e-02f, 1.21760657e-02f, -1.50186509e-01f, -1.35958284e-01f, -3.62715751e-01f, -8.75245705e-02f, -3.45457159e-03f, -2.15648711e-02f, -2.26033628e-01f,
  5.18138885e-01f, -4.92182672e-01f, 1.54827505e-01f, 3.80135894e-01f, 5.07912874e-01f, 5.07494211e-01f, 4.13856685e-01f, 2.85437673e-01f, 9.04840305e-02f, 5.93828000e-02f,
  -3.13434154e-02f, 1.15347393e-01f, 5.99834062e-02f, 4.28459272e-02f, 3.04029379e-02f, 5.62398918e-02f, 4.52991901e-03f, 6.55180514e-02f, 3.91947508e-01f, 2.88785100e-01f,
  -4.52694744e-02f, -2.08964106e-02f, -7.25768209e-02f, -3.93736102e-02f, -1.32182077e-01f, 1.62794903e-01f, 1.43532157e-02f, -2.41232682e-02f, -4.26960625e-02f, -2.36588597e-01f,
  -2.17591584e-01f, -4.47954200e-02f, 1.26754373e-01f, -1.02357537e-01f, -2.39706159e-01f, -5.98921217e-02f, -5.80498651e-02f, -1.01785518e-01f, -4.55480330e-02f, -6.12109080e-02f,
  -9.69083384e-02f, -1.52504826e-02f, -7.53801540e-02f, 5.21576963e-02f, 7.58671984e-02f, -5.13124466e-02f, -2.11203247e-01f, 6.90412894e-02f, 6.62692264e-02f, -3.64824384e-02f,
  -1.17480025e-01f, 4.34058271e-02f, 1.46670178e-01f, 1.00075945e-01f, 1.60062894e-01f, 3.51427235e-02f, -1.39263496e-01f, 2.34650187e-02f, 7.30542392e-02f, -1.00436576e-01f,
  1.84219945e-02f, 1.30967647e-01f, -1.19849615e-01f, -5.95631115e-02f, -5.86652085e-02f, -6.06572116e-03f, 6.18613884e-02f, 2.13391215e-01f, 1.23049326e-01f, -8.83634612e-02f,
  1.18937728e-03f, 4.06450853e-02f, -6.97360784e-02f, 6.72821775e-02f, -3.72840464e-02f, 1.24194156e-02f, 5.46842813e-02f, 4.75724861e-02f, -4.99018468e-02f, 4.53387126e-02f,
  -5.19547835e-02f, 1.17369421e-01f, -9.31367651e-02f, -6.10603876e-02f, -7.16283843e-02f, 8.84856135e-02f, 2.20422801e-02f, -1.37376897e-02f, -1.63864158e-02f, 6.48382232e-02f,
  -1.20283023e-01f, 1.36201307e-01f, 9.64992959e-03f, -6.94620982e-02f, -5.18669374e-02f, -2.04301089e-01f, -3.18077579e-02f, -1.09785385e-01f, -3.90616208e-02f, -4.08386625e-02f,
  6.11204952e-02f, 2.77869385e-02f, -8.69282633e-02f, -5.26745766e-02f, 2.21828014e-01f, 1.17770337e-01f, -2.80408144e-01f, 9.18749273e-02f, -2.26655900e-02f, 1.32548921e-02f,
  -4.76427451e-02f, 2.83920109e-01f, 3.10245395e-01f, 1.41064674e-01f, 4.86600064e-02f, 2.48523980e-01f, 5.66981174e-02f, -6.81971461e-02f, 1.63971379e-01f, 5.14533408e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.75040677e-01f, 3.13042253e-01f, 2.08873466e-01f, -1.43245041e-01f, 3.14358734e-02f, -8.94041732e-02f, 6.32216334e-02f, 1.42557649e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.92913711e-01f, 5.35616502e-02f, -2.16129459e-02f, 1.65339023e-01f, -1.18434139e-01f, -3.62260491e-02f, 8.43150690e-02f, 1.10979170e-01f, 2.28135169e-01f, -5.92456460e-02f,
  2.20267680e-02f, 1.77006140e-01f, -5.62197082e-02f, 2.80782759e-01f, 2.00828269e-01f, -6.02328479e-02f, 3.77852619e-02f, 1.49886519e-01f, 6.48513436e-02f, -8.09175074e-02f,
  4.13534977e-02f, 1.73576295e-01f, 2.17636764e-01f, -2.68596828e-01f, 3.68826747e-01f, 1.69279471e-01f, 9.03050676e-02f, -3.11377078e-01f, -4.31220323e-01f, -3.69864464e-01f,
  -8.54638144e-02f, 2.60154545e-01f, 1.23964310e-01f, 2.02900127e-01f, 3.15271646e-01f, 1.60259366e-01f, -8.67308304e-02f, 1.83546022e-02f, 5.80186211e-03f, 8.04861821e-03f,
  -1.24670707e-01f, -1.75613567e-01f, 1.05022162e-01f, -2.52251588e-02f, -1.09710522e-01f, 2.31788799e-01f, -1.57908723e-01f, -2.62892812e-01f, -3.02367657e-03f, 1.24230020e-01f,
  -2.98616849e-02f, -2.67587185e-01f, 1.33324981e-01f, -1.16441824e-01f, -1.06114317e-02f, -1.30706772e-01f, -3.47127765e-02f, -6.33796677e-02f, 3.81913155e-01f, -2.84658343e-01f,
  2.01872930e-01f, -4.30956393e-01f, -4.62022237e-02f, 2.16343738e-02f, -4.27742079e-02f, 1.56552985e-01f, -2.19760790e-01f, -6.59590289e-02f, 7.90649578e-02f, -1.06131006e-02f,
  -2.62714382e-02f, 6.19620755e-02f, 9.57455114e-02f, 6.60188571e-02f, 2.50840425e-01f, -5.34328483e-02f, -6.39721006e-03f, 5.70561644e-03f, 1.35755967e-02f, -7.57291541e-02f,
  8.34388733e-02f, 1.94803596e-01f, 6.88320026e-03f, 2.70210318e-02f, -3.33831720e-02f, 1.24079652e-01f, 4.19287294e-01f, -1.68255106e-01f, 6.08564653e-02f, -4.21967953e-02f,
  -3.99551928e-01f, 1.32867798e-01f, -2.09657952e-01f, 6.17251806e-02f, 5.47906123e-02f, -4.07164812e-01f, -5.59197515e-02f, -4.51264605e-02f, -7.98376501e-02f, -1.31510282e-02f,
  -2.84702420e-01f, 5.10449335e-02f, -1.15727872e-01f, -2.55145967e-01f, 7.43181556e-02f, -1.42312676e-01f, 1.16406620e-01f, -7.83037394e-02f, -3.48161459e-02f, -1.54681355e-01f,
  -3.80283713e-01f, 6.90078810e-02f, 2.13113219e-01f, 1.35210827e-01f, -4.20728736e-02f, 1.53314859e-01f, -2.19862387e-01f, -2.95295209e-01f, -1.49599046e-01f, -2.08524000e-02f,
  1.61945403e-01f, 2.68035475e-02f, -2.74425535e-03f, 4.20336157e-01f, 1.23155370e-01f, -3.73517312e-02f, -4.77136634e-02f, -1.15394808e-01f, 1.33253941e-02f, -2.93260306e-01f,
  -3.03851008e-01f, -1.29678428e-01f, -7.14373514e-02f, 4.42441478e-02f, -2.65631191e-02f, -1.34230897e-01f, 1.08366005e-01f, 1.02869719e-02f, -1.00073501e-01f, -6.69605657e-02f,
  3.15847918e-02f, -1.95532903e-01f, 9.10898671e-02f, 1.87843546e-01f, -1.10663921e-01f, -3.70028727e-02f, -2.45707948e-02f, 2.57539153e-02f, -1.14641704e-01f, 6.85980842e-02f,
  7.12505579e-02f, 1.19284503e-01f, -1.04824387e-01f, 1.74872965e-01f, -3.62862021e-01f, 1.38749093e-01f, -2.19270810e-02f, 6.73404476e-03f, -1.59968987e-01f, -8.37642774e-02f,
  -7.56681412e-02f, -1.18187524e-01f, -2.45064601e-01f, -1.38402715e-01f, 4.22025584e-02f, 1.23956934e-01f, -5.12922779e-02f, -4.39156890e-02f, 6.59433305e-02f, 1.60761759e-01f,
  -8.58912058e-03f, 4.99540148e-03f, 1.45282373e-01f, -1.50013238e-01f, -4.90394607e-03f, -2.10506618e-01f, 8.96072388e-02f, 2.58449614e-01f, 2.62490902e-02f, 1.47221878e-01f,
  -7.25601912e-02f, 8.24522525e-02f, -1.68979600e-01f, -1.83612749e-01f, -9.82384458e-02f, 1.57340229e-01f, 2.30815142e-01f, 2.90455043e-01f, -2.81011939e-01f, 2.84813106e-01f,
  -2.19347849e-01f, -7.57078901e-02f, -1.27856523e-01f, 2.71179676e-01f, -1.84790939e-01f, -4.91470061e-02f, -3.47037474e-03f, 4.37719859e-02f, 5.43691637e-03f, -7.72652552e-02f,
  -3.96638177e-02f, 1.11075908e-01f, 1.24659121e-01f, -3.21569927e-02f, 1.51872877e-02f, -1.60609096e-01f, 3.27278942e-01f, 4.04150449e-02f, 8.30054954e-02f, -8.46067742e-02f,
  -1.24508366e-01f, 1.32418022e-01f, -1.07845888e-01f, 3.27109426e-01f, 2.77057409e-01f, 3.02680489e-02f, 2.79188246e-01f, 1.10733047e-01f, -6.34431660e-01f, 1.41009465e-01f,
  -1.74105257e-01f, 3.78053576e-01f, 1.76502630e-01f, -1.03389733e-01f, 2.01436058e-02f, 5.32230884e-02f, -4.69242446e-02f, -1.71639454e-02f, -2.54676007e-02f, -3.90466191e-02f,
  -6.07263669e-02f, 9.98121873e-02f, 4.80299965e-02f, -7.09570870e-02f, -1.21457554e-01f, 1.06925212e-01f, 1.42245516e-01f, 1.71744838e-01f, 3.27238351e-01f, 4.01021577e-02f,
  -2.54356503e-01f, -1.56816036e-01f, 9.04258713e-03f, -4.21253368e-02f, 3.10916334e-01f, 3.89900327e-01f, 1.14491954e-01f, -6.98053017e-02f, 9.46697667e-02f, -1.07604228e-01f,
  2.37402059e-02f, -3.08601767e-01f, -3.12285513e-01f, 3.51005822e-01f, 3.83430831e-02f, 4.64750715e-02f, -4.17135805e-02f, -6.62383139e-02f, 5.99689595e-02f, -1.54416874e-01f,
  3.34178209e-02f, 3.86893414e-02f, -1.65906809e-02f, 1.79362804e-01f, -3.31498832e-01f, 1.18594088e-01f, -3.21382910e-01f, 3.17544490e-02f, 1.17808439e-01f, 1.62776738e-01f,
  -4.56543826e-02f, 1.18012540e-02f, -2.20544592e-01f, -1.00405388e-01f, 1.11276768e-02f, -7.32024461e-02f, 2.20770314e-01f, 7.50583634e-02f, -1.21710360e-01f, 1.24089625e-02f,
  -4.69888076e-02f, -2.25235134e-01f, 3.76674205e-01f, -1.47363797e-01f, -8.81654099e-02f, -2.69134432e-01f, 2.23281756e-01f, 2.00713843e-01f, 6.97610527e-02f, 2.21013382e-01f,
  2.12643389e-02f, -1.34589761e-01f, -1.81986555e-01f, -8.58701691e-02f, -3.51626426e-02f, -1.35694012e-01f, -1.82754576e-01f, -3.59180197e-02f, 1.46019682e-01f, -4.63771224e-02f,
  -2.44519025e-01f, -7.62499124e-02f, -1.46827936e-01f, -2.85110921e-01f, -3.02184746e-02f, 1.34186968e-01f, 1.58651248e-01f, 1.34206772e-01f, -1.51460797e-01f, 6.91545457e-02f,
  1.20194340e-02f, 3.60663012e-02f, 1.85951382e-01f, -3.57112378e-01f, 2.70870507e-01f, -2.49658793e-01f, 1.50156170e-01f, -4.85278100e-01f, -8.47816095e-02f, 1.56430334e-01f,
  -8.87755230e-02f, -2.85869781e-02f, 8.26990083e-02f, 3.20191048e-02f, -1.30626380e-01f, -3.70168574e-02f, -3.04853413e-02f, 4.16342691e-02f, -9.10397694e-02f, 7.81998038e-02f,
  7.41729140e-02f, 3.78080904e-02f, -8.60501379e-02f, -5.24812900e-02f, 3.08598489e-01f, -2.37143636e-01f, -9.40944850e-02f, 5.69504686e-02f, 7.46532083e-02f, 2.65443444e-01f,
  2.18490109e-01f, 4.93665248e-01f, 2.98927516e-01f, -1.03038087e-01f, 2.89444122e-02f, 2.90626884e-01f, -2.22812258e-02f, 8.60541761e-02f, -1.24902822e-01f, 5.62702239e-01f,
  -4.11301374e-01f, 1.15605757e-01f, 2.37646271e-02f, -1.95342392e-01f, 7.08107604e-03f, -1.66203976e-01f, 2.83828098e-02f, 5.66827459e-03f, -6.06008456e-04f, -1.08228819e-02f,
  3.13948914e-02f, -1.02856703e-01f, -5.90679906e-02f, -1.12978788e-02f, -1.15394294e-01f, 2.12147161e-02f, -2.12779209e-01f, -1.80670261e-01f, 7.06851557e-02f, 2.22623404e-02f,
  -7.58993346e-03f, -1.72684446e-01f, -2.58062869e-01f, -1.70056507e-01f, -1.56462982e-01f, -3.09862439e-02f, 1.39772058e-01f, -3.55871022e-02f, 4.12461787e-01f, -8.56901705e-02f,
  3.38057309e-01f, -6.65926397e-01f, -2.23533809e-01f, -5.08964770e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -5.90183772e-02f, 2.66854782e-02f, 5.38859144e-02f, -8.21736827e-02f, -6.78980127e-02f, 2.08303809e-01f, 7.99881015e-03f, 1.28268316e-01f, 1.26233235e-01f, -2.65360698e-02f,
  1.00280799e-01f, 1.65649042e-01f, -1.38259917e-01f, 4.81922142e-02f, -1.53801432e-02f, -2.26443931e-01f, 1.15217373e-01f, 5.12841530e-02f, 1.12208150e-01f, -6.64850846e-02f,
  2.42968928e-02f, 2.22229764e-01f, 1.23007134e-01f, -2.06295952e-01f, 2.25806087e-01f, 4.43579197e-01f, 1.43637106e-01f, 3.42217475e-01f, -1.65357143e-01f, -1.71393469e-01f,
  -2.96796501e-01f, 2.45020866e-01f, 1.17581747e-01f, -7.95540735e-02f, -8.57725739e-02f, 1.51087567e-01f, 2.78708071e-01f, 1.12338066e-02f, -1.33006675e-02f, 1.57122836e-01f,
  1.49870000e-03f, -2.58919131e-02f, 1.31291179e-02f, 2.32870150e-02f, -9.39003974e-02f, -1.24386847e-02f, 2.74456948e-01f, 7.36123174e-02f, -4.39463072e-02f, 1.93987358e-02f,
  -8.46392363e-02f, -2.67596822e-03f, 3.03512253e-02f, 6.19365163e-02f, 7.32985586e-02f, 3.65885720e-02f, 2.53668129e-01f, 1.25152886e-01f, -5.53325891e-01f, 4.82823923e-02f,
  -5.29694669e-02f, 4.99785811e-01f, 3.10737789e-01f, -1.13786392e-01f, -1.32990731e-02f, -1.62407190e-01f, 1.23033121e-01f, 6.10165223e-02f, 7.40968511e-02f, 4.54579145e-02f,
  3.00001260e-02f, 4.58938740e-02f, -8.03772658e-02f, 3.87285128e-02f, -2.11113006e-01f, 8.19927454e-02f, -1.46539584e-01f, -1.89666569e-01f, -2.07212910e-01f, 1.60576791e-01f,
  8.91134813e-02f, -7.95942321e-02f, 5.31852022e-02f, -1.64961278e-01f, -1.41796852e-02f, -4.09783065e-01f, 1.43079013e-02f, 1.30359098e-01f, 1.64288208e-01f, 9.25563425e-02f,
  3.27164620e-01f, 3.00828815e-01f, 5.03369927e-01f, -1.93373382e-01f, -1.32063448e-01f, -1.30561471e-01f, -1.80770040e-01f, -2.01925606e-01f, -2.55271405e-01f, 8.63938108e-02f,
  5.10867238e-01f, 3.31945926e-01f, 6.27081469e-03f, 2.51009256e-01f, 3.33564341e-01f, 3.23048979e-01f, 1.03280302e-02f, 1.56220421e-01f, 5.37520461e-02f, 5.50380982e-02f,
  -5.51864170e-02f, 4.03394662e-02f, -2.58064661e-02f, 1.68327361e-01f, 6.10463843e-02f, 2.07041390e-02f, -2.70555079e-01f, 2.93044336e-02f, -5.79152219e-02f, 1.29328609e-01f,
  -2.53504366e-01f, 4.03484732e-01f, -1.36642605e-01f, 3.65873963e-01f, -5.44878319e-02f, 3.14517975e-01f, -1.22048169e-01f, -2.11759165e-01f, -4.53808205e-03f, -3.19480300e-02f,
  2.88252514e-02f, 5.64944223e-02f, 1.74767360e-01f, 5.92982732e-02f, 1.36259541e-01f, 3.25494371e-02f, 2.94525921e-01f, 1.64582297e-01f, 7.35015720e-02f, 2.48706564e-01f,
  1.32474720e-01f, -1.17949903e-01f, 1.11661181e-02f, -4.79837209e-01f, -2.62346095e-03f, 7.97250792e-02f, -1.75733753e-02f, -1.46930534e-02f, -4.51398492e-01f, -1.66337103e-01f,
  -2.00507969e-01f, -1.48607850e-01f, -2.60577291e-01f, 1.77412361e-01f, 5.40432513e-01f, 2.27715418e-01f, 3.09745491e-01f, 1.35423675e-01f, -2.18234017e-01f, 3.35713923e-02f,
  -8.44381377e-02f, -1.05137654e-01f, 9.86258239e-02f, -3.56433056e-02f, 8.38664398e-02f, -9.53402817e-02f, 1.30652100e-01f, -2.51210928e-02f, 1.67866737e-01f, -1.65684929e-03f,
  -5.18095419e-02f, -6.50828332e-02f, -5.43799512e-02f, 1.27739549e-01f, -1.35697603e-01f, 5.26795387e-02f, 1.10280856e-01f, 3.83173041e-02f, 2.03232065e-01f, -1.97225660e-02f,
  1.16291970e-01f, 2.64362246e-01f, 3.39443572e-02f, -7.41852075e-02f, 9.56023261e-02f, 7.95025304e-02f, -3.22247624e-01f, 2.68478543e-01f, 4.14020903e-02f, 9.27016735e-02f,
  2.46552657e-02f, 4.70995605e-01f, 1.59962177e-02f, 1.91556379e-01f, 2.91181475e-01f, -2.03513261e-02f, 1.08028635e-01f, -2.88702268e-02f, 7.42656887e-02f, 2.49738456e-03f,
  -1.52752325e-01f, 3.93088609e-02f, 2.17253521e-01f, 1.32488340e-01f, -3.12109329e-02f, 1.26860008e-01f, -2.68380702e-01f, -2.08701089e-01f, 5.36961704e-02f, 1.35367915e-01f,
  2.06898060e-02f, -1.30111247e-01f, 1.70701638e-01f, 2.54094183e-01f, 1.01303749e-01f, -1.92886546e-01f, 4.54375148e-02f, 1.37878299e-01f, 1.74522236e-01f, -4.47720662e-02f,
  1.39717003e-02f, -2.68473417e-01f, -1.63921624e-01f, 5.05271673e-01f, 4.99367341e-02f, 1.70987785e-01f, -2.01022923e-02f, 1.18692704e-01f, -1.78501219e-01f, -9.42385793e-02f,
  -4.24297154e-02f, -6.90594092e-02f, 1.52034566e-01f, 1.28611088e-01f, 1.67842910e-01f, -4.06903774e-03f, 1.09365135e-01f, -2.56196529e-01f, 2.95668934e-02f, 2.50974864e-01f,
  1.67212769e-01f, 8.53691027e-02f, 1.48373106e-02f, 5.85992485e-02f, -1.48166969e-01f, -4.03881133e-01f, 6.13146946e-02f, -1.90756813e-01f, 1.31887823e-01f, 3.25076014e-01f,
  2.37834558e-01f, 8.06321874e-02f, -4.77853954e-01f, 5.88564388e-02f, -3.61672699e-01f, -2.15451494e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.13303578e-02f, 1.69558585e-01f, 1.91533729e-01f, 4.68066335e-02f, 2.55008906e-01f, -8.30766484e-02f, 2.43047699e-01f, 2.75467664e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  4.86946367e-02f, -8.16934034e-02f, 1.43802881e-01f, -1.23305377e-02f, -5.68575815e-05f, -4.11415361e-02f, -2.31870845e-01f, 1.19612500e-01f, -2.75579482e-01f, 8.72017741e-02f,
  -2.73476720e-01f, -5.75536527e-02f, -2.58876681e-01f, -1.68595451e-03f, 1.26504421e-01f, -3.22147086e-02f, -1.56981908e-02f, -9.51415598e-02f, 3.20710063e-01f, 3.49992625e-02f,
  1.50186926e-01f, -1.50660351e-01f, -3.51504415e-01f, -5.87577045e-01f, -1.60559013e-01f, 2.67607361e-01f, -7.69280195e-02f, 2.25475095e-02f, 3.07797119e-02f, 1.11524455e-01f,
  -3.25715169e-03f, -1.92789823e-01f, 1.99497715e-01f, -3.30472253e-02f, -2.44492725e-01f, 1.67150185e-01f, 2.29237840e-01f, -7.94598088e-02f, 4.08453017e-01f, 9.44003016e-02f,
  2.31048942e-01f, -6.35828599e-02f, 1.40872881e-01f, 1.47396252e-01f, -3.71572971e-01f, 2.14344531e-01f, 3.87537889e-02f, -3.22682291e-01f, -1.67371497e-01f, 1.41183615e-01f,
  -4.65937376e-01f, -2.44826302e-01f, 1.07430540e-01f, 5.06969206e-02f, -8.64325538e-02f, 2.81276613e-01f, -3.02561224e-01f, -2.84450740e-01f, -6.57259440e-03f, 2.55158562e-02f,
  1.82731733e-01f, -1.32428631e-01f, -2.56390691e-01f, -2.95723259e-01f, -2.08470061e-01f, -1.74742237e-01f, 4.64980043e-02f, -2.60027032e-02f, 1.46638393e-01f, 1.20197065e-01f,
  -9.48441622e-04f, 1.88940540e-01f, 2.42246777e-01f, -2.43245557e-01f, 1.68254852e-01f, 2.79170245e-01f, 1.42253101e-01f, 2.16473807e-02f, -1.27515554e-01f, 8.60232413e-02f,
  4.80972417e-02f, 2.56062537e-01f, 8.15540254e-02f, -1.50289744e-01f, -2.03430101e-01f, 1.33991599e-01f, 3.84173810e-01f, 2.16033936e-01f, 1.21204510e-01f, -3.71705294e-01f,
  -1.15712985e-01f, 6.98019788e-02f, 1.12948351e-01f, -1.65263176e-01f, 3.37188281e-02f, 1.36141971e-01f, -1.44768417e-01f, 1.63383991e-01f, 2.18113661e-01f, 5.36291786e-02f,
  1.72696903e-01f, -2.29246795e-01f, -1.89504191e-01f, -2.42327433e-02f, 4.19220254e-02f, 3.91544282e-01f, -1.81973711e-01f, 3.31742987e-02f, 1.02171913e-01f, -3.63758326e-01f,
  1.85549229e-01f, -3.60949002e-02f, 4.30684164e-02f, 1.21014237e-01f, 1.54404268e-01f, 1.45728827e-01f, -1.14168413e-01f, 3.55394557e-02f, -2.06471846e-01f, -4.96699125e-01f,
  4.61349078e-02f, 7.68008307e-02f, -1.71169356e-01f, 2.72779197e-01f, -2.49796167e-01f, 1.34663329e-01f, 7.85200149e-02f, 1.45725310e-01f, -1.55551523e-01f, -6.90819323e-02f,
  2.05255002e-01f, 2.72664160e-01f, 2.09075898e-01f, 1.46891698e-01f, 4.09230709e-01f, 1.97423562e-01f, 1.23345308e-01f, -1.14660397e-01f, 2.10772634e-01f, 3.12892050e-01f,
  1.79325610e-01f, 2.62342840e-01f, -2.75111467e-01f, 1.83895662e-01f, 8.54116529e-02f, -1.61551908e-01f, -2.97260702e-01f, -1.49487838e-01f, -1.75760984e-01f, 6.76821694e-02f,
  2.78242052e-01f, 6.14786148e-01f, 2.36480832e-01f, -1.35653242e-01f, 6.08527362e-02f, -1.10844910e-01f, 1.33637637e-01f, 5.15720248e-02f, 2.48340294e-01f, -2.40769625e-01f,
  1.87767863e-01f, -3.39005768e-01f, -1.23337120e-01f, -5.19199409e-02f, -7.73644671e-02f, 5.78006394e-02f, -1.19996250e-01f, -7.12331831e-02f, -6.05876669e-02f, -2.85843521e-01f,
  -2.36902073e-01f, -2.49698665e-02f, -7.09853321e-02f, -2.66165346e-01f, -1.94162011e-01f, 2.99861342e-01f, 1.61833569e-01f, 7.23862574e-02f, 2.70757526e-01f, -2.24319905e-01f,
  -7.00895861e-02f, 5.19396998e-02f, 2.99787015e-01f, -5.78504317e-02f, 5.47527149e-02f, -2.59909987e-01f, 1.39029443e-01f, 1.68017715e-01f, 1.47928938e-01f, 4.23029102e-02f,
  4.35367338e-02f, 1.73622116e-01f, -4.28905070e-01f, -3.17798257e-01f, -2.34278843e-01f, -8.63222629e-02f, 1.93587691e-02f, 1.60170004e-01f, -1.36223793e-01f, 4.36775796e-02f,
  -2.59172767e-01f, -1.86041489e-01f, -3.74812067e-01f, -2.51511842e-01f, 1.57230332e-01f, -1.81153849e-01f, -3.84947777e-01f, 1.13737985e-01f, 1.03737243e-01f, 7.73477927e-02f,
  2.41258696e-01f, -3.69651243e-02f, -2.05132172e-01f, 1.24709100e-01f, 1.26074627e-01f, -2.81365722e-01f, 6.28322959e-02f, -1.22337319e-01f, -1.73343703e-01f, -1.53181806e-01f,
  -1.51883513e-01f, 8.91449079e-02f, 2.35708416e-01f, 1.02945253e-01f, 3.88369933e-02f, 5.01008034e-02f, -9.94177461e-02f, -1.94918662e-01f, 1.83451775e-05f, 1.28042951e-01f,
  -1.43329948e-01f, -4.92685474e-02f, 2.02703491e-01f, -3.16167921e-01f, 2.91141182e-01f, 1.57104414e-02f, 2.19886288e-01f, -2.15713888e-01f, 2.32946157e-01f, 1.91732511e-01f,
  2.08370641e-01f, 1.99848622e-01f, 3.83271605e-01f, -2.79018402e-01f, -4.06501502e-01f, -1.28813386e-01f, 2.63757497e-01f, 1.97261393e-01f, 8.13748911e-02f, 1.97323427e-01f,
  2.37461343e-01f, 8.92807823e-03f, 7.91672021e-02f, -1.71161667e-01f, -1.15492411e-01f, 3.65445465e-01f, 1.65295750e-02f, -1.98530614e-01f, -2.50021368e-01f, 7.11050779e-02f,
  2.56498575e-01f, -1.43929824e-01f, 4.00085524e-02f, 1.58805519e-01f, -2.71716695e-02f, -5.42182438e-02f, -7.62278363e-02f, 1.45161122e-01f, -2.19749272e-01f, 5.64028090e-03f,
  -8.44443589e-02f, 1.82045251e-01f, 2.29908556e-01f, 4.80311050e-04f, -1.92536667e-01f, -3.17607671e-01f, -1.54599413e-01f, 1.62266791e-01f, -2.95062780e-01f, 2.11754933e-01f,
  8.45974386e-02f, 2.47675613e-01f, 3.03219944e-01f, 3.36674035e-01f, 1.77710459e-01f, -4.97872895e-03f, -1.35545939e-01f, -1.70779482e-01f, 2.54430383e-01f, 7.12814629e-02f,
  -2.24105660e-02f, 8.78567025e-02f, -3.39232050e-02f, -1.51594132e-01f, 4.41763550e-02f, 2.27976143e-01f, -2.56924778e-01f, 6.23897240e-02f, 6.13679625e-02f, -2.51216412e-01f,
  -2.51096249e-01f, 5.13499789e-03f, 7.85200670e-03f, 3.12131882e-01f, 5.25697283e-02f, -1.14873849e-01f, 1.11526228e-01f, -2.23708525e-01f, 1.71739295e-01f, 1.81010291e-01f,
  -2.28040442e-01f, 2.67946541e-01f, -1.62294492e-01f, -2.51875281e-01f, 2.75379658e-01f, -1.92992832e-03f, 4.19334210e-02f, -1.28071532e-01f, -2.29066744e-01f, 2.69921452e-01f,
  2.82303095e-01f, 2.41541043e-01f, 2.01022863e-01f, 1.91022471e-01f, 1.69418883e-02f, 9.31019932e-02f, 1.56511068e-01f, 1.47055134e-01f, 2.05618978e-01f, 1.90803066e-01f,
  2.34087557e-01f, 4.41932976e-01f, -1.23505957e-01f, -1.56281590e-01f, 7.08661914e-01f, 1.18370160e-01f, 3.52720022e-02f, -2.69034803e-01f, 2.02205867e-01f, -8.98793414e-02f,
  -2.28921607e-01f, -1.63646281e-01f, -2.47134313e-01f, -3.62506837e-01f, -4.18179482e-02f, 1.51887670e-01f, -6.31287768e-02f, 7.02129975e-02f, -2.68480122e-01f, 1.56163588e-01f,
  7.96997026e-02f, -6.99917451e-02f, 7.27796555e-02f, -7.38359243e-02f, -2.01857120e-01f, -2.78408319e-01f, 1.22814663e-01f, -2.62492150e-01f, -2.47053578e-02f, -8.70872214e-02f,
  1.66596070e-01f, 6.89862072e-02f, -2.76257526e-02f, -1.12336040e-01f, -4.13727127e-02f, -1.90655410e-01f, -6.65472224e-02f, 9.56046730e-02f, 3.48956317e-01f, 1.48539603e-01f,
  1.95638150e-01f, -7.11339116e-02f, -4.43081409e-01f, -1.03261277e-01f, 4.01922673e-01f, 2.32841879e-01f, 9.95970070e-02f, 9.65939835e-02f, -3.13133411e-02f, 2.47270510e-01f,
  1.62952468e-01f, 1.93023011e-01f, -2.49543682e-01f, 2.34870669e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.11439265e-01f, -9.28585306e-02f, 1.91745326e-01f, -2.80317992e-01f, -3.42141271e-01f, 7.25504085e-02f, -8.92535001e-02f, -1.14047162e-01f, 3.22150230e-01f, -7.19998851e-02f,
  1.25045091e-01f, -3.15822035e-01f, 3.12318444e-01f, 3.44447047e-01f, -3.59777302e-01f, 3.32846373e-01f, -4.28294428e-02f, -3.87984067e-02f, -2.10460857e-01f, -3.01194400e-01f,
  -2.65715569e-01f, 2.82722443e-01f, 5.23408949e-02f, 1.50879547e-01f, 1.03199892e-01f, -2.18898028e-01f, 2.35679485e-02f, -1.95755631e-01f, 6.24218360e-02f, -1.62840173e-01f,
  -2.58953571e-01f, 4.57750142e-01f, -3.49631906e-02f, -2.74953783e-01f, -1.79459713e-02f, -7.19340816e-02f, -1.57183394e-01f, 9.83611271e-02f, 3.58093232e-02f, -2.12593703e-03f,
  -1.57066718e-01f, 4.60487558e-03f, 3.74358922e-01f, 5.91928437e-02f, 1.98855191e-01f, 2.69871950e-01f, -3.82057399e-01f, 4.07658547e-01f, 6.18285406e-03f, -3.01346511e-01f,
  -6.50376156e-02f, -1.78469181e-01f, 1.93383604e-01f, 2.20289156e-01f, -1.74871627e-02f, 4.99752671e-01f, -6.76355362e-02f, -1.86958387e-01f, 5.87247610e-02f, -6.42477393e-01f,
  2.08495155e-01f, -4.24396843e-02f, 5.90941645e-02f, 9.83719751e-02f, 3.66211981e-01f, 2.14636445e-01f, 3.30856234e-01f, 2.22955108e-01f, 4.15714115e-01f, 3.49152118e-01f,
  5.10338843e-01f, 2.53253996e-01f, 6.15814507e-01f, 1.72393396e-01f, 8.01583886e-01f, 2.35235691e-01f, -9.07406434e-02f, 1.48693159e-01f, 3.93790901e-01f, 2.79115159e-02f,
  -5.71377762e-02f, 1.09796509e-01f, 1.58179477e-01f, -1.24728017e-01f, -3.87862384e-01f, -1.73428878e-01f, 2.66167760e-01f, 5.45389771e-01f, -1.31525248e-01f, -2.12212235e-01f,
  2.27757767e-01f, 3.62111360e-01f, 1.71733513e-01f, -2.43790060e-01f, -1.06859356e-01f, 1.79888621e-01f, 5.71802676e-01f, 2.48884913e-02f, -2.57180452e-01f, -1.66570231e-01f,
  2.08164766e-01f, 2.27026626e-01f, 3.03890556e-01f, 2.38365196e-02f, 2.38014877e-01f, 2.76356876e-01f, 9.91242304e-02f, -3.29276845e-02f, -5.24552643e-01f, -2.77948827e-01f,
  -1.38905093e-01f, 1.51223212e-01f, 4.21842128e-01f, 1.71127558e-01f, -4.62667406e-01f, -3.87411982e-01f, -2.71363497e-01f, -2.97320247e-01f, 4.55234647e-01f, 1.98819056e-01f,
  2.17886224e-01f, 1.50101244e-01f, 3.71277332e-01f, 4.30139601e-01f, 3.79243284e-01f, 8.46832395e-02f, -3.49630602e-02f, 1.41079649e-01f, -3.70686889e-01f, 1.07633002e-01f,
  4.51418422e-02f, 3.10215473e-01f, -1.39314279e-01f, 5.13537936e-02f, -6.82675093e-02f, 6.47748932e-02f, -8.97690207e-02f, 2.70885061e-02f, 3.02151451e-03f, -1.19253330e-01f,
  2.70298392e-01f, 2.50049740e-01f, -4.77319688e-01f, -2.57748514e-01f, -4.02980328e-01f, -1.52290106e-01f, 6.44412339e-02f, 5.73874004e-02f, 2.32114241e-01f, 1.33191586e-01f,
  -7.75148571e-02f, -6.28799051e-02f, 3.05190295e-01f, 2.64681038e-02f, 5.36921108e-03f, -1.75967768e-01f, 2.52570689e-01f, 4.17915732e-01f, 4.18641001e-01f, 3.10779475e-02f,
  3.66767466e-01f, 3.31949651e-01f, 1.33210927e-01f, 1.14555024e-01f, 3.93857509e-01f, 2.11093098e-01f, 4.99990404e-01f, 2.28531333e-03f, 5.89424908e-01f, 2.40060970e-01f,
  3.15987229e-01f, 3.98476422e-01f, -1.47401184e-01f, 2.91503102e-01f, -7.10178465e-02f, 5.11075974e-01f, 2.97948807e-01f, -1.31749466e-01f, -2.14284077e-01f, -4.16494727e-01f,
  -5.30813098e-01f, -1.75362360e-02f, -2.46779695e-02f, 7.62742281e-01f, 7.77026787e-02f, -2.13153794e-01f, 1.03772454e-01f, -7.35248476e-02f, 4.16960306e-02f, -2.37339176e-03f,
  -3.83722968e-02f, 2.31796980e-01f, 3.98031265e-01f, 2.66535670e-01f, -1.51932780e-02f, 3.97406369e-01f, -5.70531609e-03f, -3.78002942e-01f, 2.49662116e-01f, 2.60090500e-01f,
  -2.44968221e-01f, 2.02993944e-01f, -6.36458024e-02f, 4.72415835e-02f, -7.46218979e-01f, 1.67007282e-01f, -4.80692059e-01f, 3.17021459e-03f, -3.15635413e-01f, -3.57744545e-01f,
  -4.98153776e-01f, -1.19966112e-01f, 4.16129470e-01f, -1.82351857e-01f, -2.56098270e-01f, 2.53817797e-01f, -4.01751846e-01f, 8.62632412e-03f, 3.35391521e-01f, 1.62181556e-01f,
  2.12125897e-01f, -1.50500149e-01f, -8.62234682e-02f, -9.18088332e-02f, -5.63014627e-01f, 5.89346699e-02f, 1.96167633e-01f, 3.56331199e-01f, 2.81831831e-01f, 3.29248488e-01f,
  -5.18592745e-02f, 3.67673367e-01f, 8.91087353e-02f, 1.63727000e-01f, 2.62715966e-02f, 2.74302334e-01f, 3.69772434e-01f, 3.91175061e-01f, -3.01923543e-01f, -2.50184715e-01f,
  -5.58654785e-01f, 1.50356889e-01f, 1.03977293e-01f, -2.00635660e-02f, -1.70985267e-01f, 4.06615794e-01f, 6.19787693e-01f, 1.68886095e-01f, 2.40934476e-01f, -1.83365583e-01f,
  -9.22512263e-02f, 3.65379333e-01f, 4.32238996e-01f, 1.46607503e-01f, 4.71460164e-01f, 2.74526894e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -2.08692923e-01f, 3.91826630e-02f, 1.76091000e-01f, -3.21115814e-02f, 2.22079366e-01f, 4.47061621e-02f, 4.45046537e-02f, 2.80430824e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -6.41699374e-01f, 4.48102891e-01f, -3.33364308e-01f, 1.81359485e-01f, 1.63880229e-01f, 8.40290189e-02f, 3.80451567e-02f, -8.45673960e-03f, 3.64174515e-01f, 7.24628046e-02f,
  -3.42263207e-02f, -2.09985431e-02f, -9.45705697e-02f, -3.20301168e-02f, -1.87403813e-01f, -5.90058118e-02f, 3.19065750e-02f, -2.27953821e-01f, -2.12523282e-01f, -1.15163691e-01f,
  -1.51417449e-01f, -1.47118241e-01f, -2.01186404e-01f, -2.30582699e-01f, 3.82661164e-01f, 4.79679793e-01f, -1.13708384e-01f, -2.08781138e-01f, 3.19896817e-01f, -8.10061544e-02f,
  2.55777389e-01f, -9.24961492e-02f, -1.77656054e-01f, 2.61911660e-01f, -4.15802240e-01f, 3.14362824e-01f, -2.17638403e-01f, -1.03904754e-01f, 3.57392371e-01f, -5.03948092e-01f,
  -4.97296691e-01f, -9.94371548e-02f, 6.45863041e-02f, -4.64153886e-01f, -3.91661346e-01f, 2.45808855e-01f, 1.75861746e-01f, 1.61732584e-02f, 1.10958569e-01f, 3.33978891e-01f,
  -1.27899960e-01f, 2.66006552e-02f, 1.30292289e-02f, 3.32917154e-01f, -1.38469145e-01f, -6.84952140e-02f, -7.57538080e-02f, 3.18630815e-01f, -2.70566672e-01f, 2.70608008e-01f,
  2.75861204e-01f, 2.43889496e-01f, 9.98197496e-02f, -9.48650092e-02f, -2.71403193e-02f, -1.55592814e-01f, -1.37525603e-01f, -1.65816650e-01f, 2.01136544e-01f, 3.29771578e-01f,
  1.78548813e-01f, -1.31126285e-01f, 1.58279315e-01f, 4.47065569e-02f, 2.35452890e-01f, -1.53837264e-01f, 1.27958536e-01f, 4.34749871e-01f, -1.23350739e-01f, -2.17764884e-01f,
  2.04565763e-01f, -1.96495906e-01f, 2.03518689e-01f, -2.48385921e-01f, 8.28452408e-02f, 3.30772251e-02f, -1.31859228e-01f, -5.07967435e-02f, 5.75926304e-02f, 3.75661850e-01f,
  -3.25831354e-01f, -2.19233617e-01f, 3.74950677e-01f, -9.82088316e-03f, 3.26912224e-01f, 1.59418210e-02f, -4.28716362e-01f, 8.00458118e-02f, -2.50462174e-01f, 2.02163041e-01f,
  1.39218897e-01f, -1.81142956e-01f, 7.21456707e-02f, -5.22069640e-05f, 4.02118713e-02f, 3.44033688e-01f, -4.36399430e-02f, 3.08186561e-02f, -3.08416456e-01f, 1.93596482e-01f,
  6.51316568e-02f, -3.14993232e-01f, 3.85154366e-01f, 6.69012293e-02f, 1.72356412e-01f, -9.19287503e-02f, 2.02545077e-02f, 6.18833974e-02f, -1.77578226e-01f, -5.96734583e-01f,
  2.21932083e-01f, 1.97701603e-01f, 3.75423245e-02f, -1.08463787e-01f, -7.64838532e-02f, 1.94401726e-01f, 3.00320417e-01f, -7.62584433e-02f, 2.29666740e-01f, -2.95243338e-02f,
  1.66876912e-01f, 1.89698383e-01f, 1.68645874e-01f, -1.47115231e-01f, -1.40737787e-01f, -8.74476805e-02f, -2.67890394e-02f, 5.78347109e-02f, -4.69411677e-03f, 4.14177291e-02f,
  3.41029838e-02f, -2.73787320e-01f, 9.00307000e-02f, -8.39612819e-03f, -2.24169433e-01f, 3.52750450e-01f, -1.35894001e-01f, 2.30340809e-01f, 1.22663252e-01f, 5.31668924e-02f,
  -6.91045597e-02f, 3.00425828e-01f, 1.81193277e-01f, 3.35342363e-02f, 2.16894835e-01f, 2.36997157e-01f, -2.68756539e-01f, 3.00076991e-01f, -3.40949029e-01f, -2.94856399e-01f,
  2.70998418e-01f, 1.88154861e-01f, -6.38628751e-02f, 4.11921926e-02f, 1.60339490e-01f, 2.75142044e-01f, -1.07419789e-01f, 3.26314598e-01f, 7.93745965e-02f, 1.01100795e-01f,
  -2.72532254e-01f, 1.77460566e-01f, 3.06001484e-01f, -2.33434990e-01f, -3.34037185e-01f, 4.11277384e-01f, -1.19877048e-01f, -3.48511368e-01f, -3.41699541e-01f, 2.16489024e-02f,
  2.22987592e-01f, -2.65848637e-01f, 4.47284341e-01f, -2.72503751e-03f, 2.50649489e-02f, -2.85906702e-01f, 1.20635852e-02f, -1.60871804e-01f, -1.09281488e-01f, -1.19638860e-01f,
  1.72344089e-01f, -1.01178192e-01f, 3.25607747e-01f, 3.05806965e-01f, -1.14002720e-01f, -2.82912385e-02f, 1.54373616e-01f, 4.79264230e-01f, 6.52800202e-02f, 2.39164025e-01f,
  9.25394297e-02f, -1.31297916e-01f, -2.15897292e-01f, 1.98567525e-01f, 1.93195403e-01f, -4.54038650e-01f, -2.65193015e-01f, 5.15574276e-01f, -1.31088063e-01f, -2.80129671e-01f,
  -2.11048007e-01f, 1.42496243e-01f, 4.61945176e-01f, -1.49361948e-02f, 4.49370742e-01f, 4.26235229e-01f, -7.26743564e-02f, -1.95974410e-01f, 5.25732152e-02f, 7.35993758e-02f,
  6.45736828e-02f, 4.58321907e-02f, -2.61016607e-01f, -1.25513956e-01f, 1.11942902e-01f, 1.48565546e-01f, -3.22604440e-02f, -1.50153622e-01f, 1.92590997e-01f, 9.01281685e-02f,
  -2.68779956e-02f, -1.71590462e-01f, 2.43684053e-01f, -1.13555081e-01f, 7.40009174e-02f, 2.20546082e-01f, 2.53318459e-01f, 6.94580227e-02f, -4.96419996e-01f, -7.09259957e-02f,
  -5.54161131e-01f, 4.44090739e-02f, -9.73954722e-02f, -3.70107472e-01f, -2.02019483e-01f, -2.66456842e-01f, 3.37339789e-02f, -1.00340500e-01f, 1.11663595e-01f, 9.11505297e-02f,
  -6.24929778e-02f, -3.47067028e-01f, -4.91704084e-02f, -2.68948257e-01f, -1.41277447e-01f, -5.13023101e-02f, 1.44302189e-01f, -4.63386208e-01f, 2.26295397e-01f, -1.46507233e-01f,
  2.94999808e-01f, -3.74591261e-01f, -2.15902880e-01f, 1.75908893e-01f, 2.16237027e-02f, 4.98058081e-01f, 8.78183618e-02f, 1.45559607e-03f, 2.95057207e-01f, 4.95313764e-01f,
  -1.80583268e-01f, -2.59081703e-02f, -5.47102317e-02f, -2.23054931e-01f, 1.41576260e-01f, -2.23608822e-01f, -5.98459132e-02f, 3.38463098e-01f, 1.73406869e-01f, -2.05504119e-01f,
  -1.60374805e-01f, -1.35575086e-01f, -1.24634512e-01f, 1.53724417e-01f, 5.93049638e-02f, 2.17978001e-01f, 3.22881460e-01f, -2.08856344e-01f, -1.03808738e-01f, 1.19665496e-01f,
  -5.16916700e-02f, 1.81714386e-01f, 2.36336544e-01f, -3.65023196e-01f, -2.62638152e-01f, -1.03771150e-01f, 2.05902886e-02f, 4.08633560e-01f, 2.51179244e-02f, -1.31969497e-01f,
  1.33907884e-01f, 1.06087297e-01f, -2.53014922e-01f, 2.09266469e-01f, 2.83639252e-01f, 2.23701969e-01f, 8.35633725e-02f, -6.06787615e-02f, 1.94952518e-01f, 3.62832218e-01f,
  -8.85011535e-03f, -9.22087859e-03f, -3.82884368e-02f, 5.29516935e-02f, -3.87621224e-02f, 1.68103874e-01f, -1.05790764e-01f, 2.99747914e-01f, 3.93413335e-01f, -1.94540873e-01f,
  1.74992666e-01f, 1.01227956e-02f, -3.41910779e-01f, -1.03999977e-03f, -2.53845304e-01f, 1.12237804e-01f, 1.45521462e-01f, 5.56753278e-01f, 3.37901145e-01f, -1.20980725e-01f,
  2.34074164e-02f, 6.35904849e-01f, 8.40268433e-02f, -3.17152798e-01f, -1.78934470e-01f, 2.93081731e-01f, 3.27693045e-01f, -2.97674894e-01f, -2.78760935e-03f, 2.53140807e-01f,
  3.16217750e-01f, -2.95594782e-01f, 4.41472828e-01f, 1.92635477e-01f, -5.03360108e-02f, -1.55235054e-02f, -4.83657010e-02f, -7.49908537e-02f, -2.13766121e-03f, 1.75296411e-01f,
  -5.08544028e-01f, 1.13477949e-02f, -4.81531709e-01f, 1.55766338e-01f, -1.52681500e-01f, -3.12602609e-01f, 2.29799673e-01f, -3.20068181e-01f, -2.18829662e-01f, -6.29518107e-02f,
  -3.20595115e-01f, -3.53795111e-01f, -3.10876779e-02f, -6.80950955e-02f, 3.55434567e-01f, -7.60553181e-02f, -3.07247579e-01f, 3.61476481e-01f, -1.24183781e-01f, 8.54146760e-03f,
  7.46824034e-03f, 2.78576285e-01f, -5.23811936e-01f, 2.75706977e-01f, -1.99993595e-01f, 3.13067473e-02f, 4.06693637e-01f, -1.97486639e-01f, 8.53507593e-03f, 4.05102104e-01f,
  -1.57109439e-01f, 8.59505534e-02f, -6.25625849e-02f, -2.25175560e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -3.22387964e-01f, 2.75441140e-01f, 3.17065120e-02f, 3.76680464e-01f, -3.11939120e-01f, 2.23090142e-01f, 2.85036951e-01f, -5.64558983e-01f, 7.08655566e-02f, 2.33935833e-01f,
  2.64194220e-01f, -1.11811355e-01f, -7.34183371e-01f, -8.03015709e-01f, 8.66970003e-01f, 2.23635361e-01f, -6.96015581e-02f, 5.33957541e-01f, -3.65154058e-01f, 3.52380842e-01f,
  2.97969311e-01f, -2.03240097e-01f, 2.28277504e-01f, 5.13998389e-01f, 7.70282328e-01f, -3.05602819e-01f, 6.36994123e-01f, 2.86623538e-01f, -1.18685206e-02f, 3.70396942e-01f,
  -4.87532526e-01f, 4.46092218e-01f, -1.87634225e-20f, -1.93097317e-20f, -2.18723017e-20f, -1.78675665e-20f, 2.53283011e-20f, -1.71878700e-21f, -3.32340588e-20f, -1.95782455e-20f,
  -1.96026102e-20f, 3.63152096e-20f, -2.28092162e-20f, -1.98466236e-20f, 2.24124555e-20f, -2.81271095e-21f, -1.27364149e-20f, -2.19845139e-20f, -9.37262923e-21f, 3.12413160e-20f,
  1.15767433e-20f, 3.18294447e-20f, 3.05716132e-20f, 1.79008573e-20f, -2.27708783e-20f, 3.13621523e-20f, -1.02146133e-21f, -6.70100589e-21f, -1.09206800e-20f, 8.25438929e-21f,
  -1.32231606e-19f, -7.19285888e-21f, 1.76458223e-21f, -1.67584828e-19f, 6.32921886e-03f, -1.58735320e-01f, 1.46932274e-01f, 1.30081624e-01f, -3.42899501e-01f, 3.48365724e-01f,
  2.01344773e-01f, -1.63608596e-01f, 3.51062000e-01f, -3.75343949e-01f, 1.08133718e-01f, 3.10373396e-01f, -4.09279704e-01f, -4.90953952e-01f, 4.29118305e-01f, -2.68436134e-01f,
  1.45050541e-01f, 3.09049059e-02f, 4.21439409e-01f, 1.16625473e-01f, -4.84178901e-01f, -4.54883695e-01f, -1.51569441e-01f, 7.15754330e-02f, 5.36033988e-01f, 1.53546914e-01f,
  -1.01543237e-02f, -2.72268504e-01f, 3.00648242e-01f, 8.62460285e-02f, -6.11043751e-01f, 4.40137982e-01f, 1.71536833e-01f, 8.89058053e-01f, 2.88995445e-01f, 6.22252762e-01f,
  5.08846223e-01f, -7.34972119e-01f, -5.09706616e-01f, 5.86100340e-01f, 7.14614749e-01f, 9.03014123e-01f, -9.22843456e-01f, 6.16917729e-01f, 5.82598269e-01f, -3.59639376e-01f,
  -7.74952829e-01f, 5.39730847e-01f, -4.08318222e-01f, -6.07548356e-01f, -8.18377435e-01f, -1.95032105e-01f, 1.17798217e-01f, -5.98656356e-01f, 6.96886480e-01f, -7.26555824e-01f,
  -5.84467113e-01f, -2.66314596e-01f, 7.06267953e-01f, -1.12446606e-01f, -4.38384771e-01f, 1.70662194e-01f, 4.54472005e-01f, -2.02453643e-01f, 5.45766115e-01f, -5.01493931e-01f,
  1.92974642e-01f, -1.40319929e-01f, -3.24220002e-01f, 4.01514024e-01f, 2.95976382e-02f, 6.38216853e-01f, -7.70623563e-03f, -2.73468345e-01f, -8.07670727e-02f, 4.87529367e-01f,
  1.14486761e-01f, 5.27322948e-01f, -1.96836427e-01f, -2.62960643e-01f, 5.84921300e-01f, -2.19526306e-01f, 6.67186603e-02f, -2.02399820e-01f, 5.13754189e-01f, 4.94308956e-02f,
  1.00645706e-01f, -9.26514119e-02f, -4.85592723e-01f, 2.58035064e-01f, 3.58282365e-02f, -1.27153710e-01f, 6.44929409e-01f, 3.62972558e-01f, 3.86866391e-01f, 4.56945330e-01f,
  3.91907960e-01f, 1.15776032e-01f, 1.81223869e-01f, 1.21035978e-01f, -1.90972283e-01f, 5.44060469e-01f, -3.97054940e-01f, 4.36590403e-01f, 9.56838503e-02f, 4.26725477e-01f,
  1.03854969e-01f, 3.00269425e-01f, -5.31542718e-01f, 2.08744004e-01f, 1.14658602e-01f, 5.23701608e-02f, 7.09571958e-01f, 1.87024295e-01f, -3.94830376e-01f, 5.32789052e-01f,
  1.00862789e+00f, 2.25531057e-01f, 2.70678904e-02f, 3.64861995e-01f, -1.13374695e-01f, -1.49933502e-01f, 7.16134608e-01f, 3.10381144e-01f, -9.28303376e-02f, 8.88032913e-01f,
  7.92436838e-01f, 3.13108832e-01f, 1.95914045e-01f, -3.54790747e-01f, 6.75572038e-01f, -1.19020864e-01f, 4.87896144e-01f, -6.34383457e-03f, 5.57694256e-01f, -5.51494360e-01f,
  3.76536191e-01f, -4.26777482e-01f, 6.77034855e-01f, 4.56396155e-02f, 6.11505508e-01f, 1.02055520e-01f, -2.30660364e-01f, 4.35290337e-01f, -4.28688169e-01f, -2.49064535e-01f,
  -9.31749344e-02f, -5.92262864e-01f, -5.87824047e-01f, -6.61289752e-01f, 6.48738146e-01f, 1.67147830e-01f, -4.59812015e-01f, -8.47160742e-02f, -1.19679701e-02f, 2.14523643e-01f,
  3.67247164e-01f, -6.43440068e-01f, 3.51975709e-01f, 5.90040743e-01f, 2.17422664e-01f, 2.62702703e-01f, 1.68880552e-01f, 3.44523579e-01f, -6.45474911e-01f, 2.87427336e-01f,
  3.95712167e-01f, 1.44337015e-02f, 6.44109428e-01f, 2.75061429e-01f, 2.79815555e-01f, 1.14948235e-01f, -6.27892375e-01f, -4.57309812e-01f, 6.37532234e-01f, -7.43311703e-01f,
  -2.53811419e-01f, 8.17277506e-02f, -1.88293293e-01f, -1.65072381e-01f, 6.70445487e-02f, -7.41622567e-01f, -3.30878586e-01f, -6.67271078e-01f, 3.85742694e-01f, 4.32865888e-01f,
  -4.63954806e-02f, -2.69005597e-01f, 3.08450013e-01f, 6.74418509e-02f, 2.95577049e-01f, 3.54539603e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  1.55565858e-01f, -1.75578859e-20f, 3.78186218e-02f, 4.25292581e-01f, 1.38183787e-01f, -9.75268111e-02f, 4.27315116e-01f, -1.79493241e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -8.22377205e-01f, 3.97985041e-01f, 4.30083841e-01f, -3.51421237e-02f, 3.58149707e-01f, -3.99171114e-01f, 4.98197287e-01f, 1.26534253e-01f, -2.57726073e-01f, 3.69637072e-01f,
  -1.14291273e-01f, 8.80125239e-02f, -5.27857006e-01f, 4.03837889e-01f, -5.14201820e-01f, -4.72317427e-01f, 5.63888848e-01f, -5.94089866e-01f, -7.02647686e-01f, -4.98420656e-01f,
  6.63193703e-01f, 3.87083471e-01f, -6.58341587e-01f, 2.57679880e-01f, 8.54387656e-02f, -8.31757571e-22f, -4.21397418e-01f, -1.05242229e+00f, -4.09071058e-01f, -3.52741659e-01f,
  5.36388576e-01f, -3.86551589e-01f, 3.09851170e-01f, -4.24707960e-03f, -3.48601565e-02f, -3.67134839e-01f, -9.90687013e-02f, 4.28708076e-01f, 1.83368355e-01f, 4.24773246e-01f,
  4.70138848e-01f, -1.78350076e-01f, -5.43605536e-02f, 2.75253773e-01f, -2.71378402e-02f, -5.46064734e-01f, 4.73905653e-01f, -5.53238809e-01f, -3.79781336e-01f, 3.77175838e-01f,
  3.82359177e-01f, 5.66900611e-01f, -1.52457327e-01f, -4.52260762e-01f, 4.27830458e-01f, -3.00818175e-01f, -5.35909891e-01f, -5.32419083e-21f, 2.18079120e-01f, -7.37889230e-01f,
  2.54397601e-01f, -5.89916170e-01f, 5.68374038e-01f, -3.39151740e-01f, 3.26988131e-01f, -4.98566389e-01f, -2.64894456e-01f, -3.14937562e-01f, -1.33700177e-01f, -7.20014498e-02f,
  -7.04824150e-01f, 6.33017778e-01f, 9.24784467e-02f, 2.51596600e-01f, 3.45398486e-01f, 5.03655314e-01f, -5.62383056e-01f, -3.63917977e-01f, -1.76803648e-01f, -4.85611498e-01f,
  5.67144036e-01f, 7.42554903e-01f, 5.57823516e-02f, -4.26798910e-01f, -9.23146725e-01f, -3.30637515e-01f, 6.58971190e-01f, 5.02474964e-01f, 2.35589385e-01f, -6.18609808e-21f,
  -2.90469885e-01f, -2.49496952e-01f, -5.96077979e-01f, -1.21067263e-01f, 1.86393574e-01f, -4.37296540e-01f, 2.12752432e-01f, -1.55536726e-01f, -5.37783690e-02f, -8.94462913e-02f,
  -3.49511504e-02f, -6.96801186e-01f, -7.83794224e-02f, 6.49613559e-01f, 2.81468213e-01f, -2.73094088e-01f, -5.31161487e-01f, -4.34426516e-01f, -5.18245697e-01f, -5.46295285e-01f,
  -4.05743867e-01f, 7.21703470e-01f, 3.60919625e-01f, 2.98792481e-01f, -1.32372904e+00f, 3.18327606e-01f, 1.90082669e-01f, -2.30759755e-01f, -3.57465476e-01f, 4.19856638e-01f,
  3.31350088e-01f, 6.23291537e-21f, -2.14885250e-01f, -1.05738521e+00f, -3.58328633e-02f, 3.67350399e-01f, -8.44905138e-01f, -3.57011408e-01f, -4.17456836e-01f, -5.69610186e-02f,
  -3.62699628e-01f, 6.49978697e-01f, -8.91137064e-01f, 5.23531079e-01f, -3.63481753e-02f, -8.15564871e-01f, 4.83967096e-01f, -4.00219947e-01f, 4.35417801e-01f, 4.38203812e-01f,
  -1.99501872e-01f, 9.36405718e-01f, -1.54966146e-01f, -4.19397280e-02f, -1.22303478e-01f, -5.67829013e-01f, 9.12708998e-01f, 2.05149353e-02f, 1.36335954e-01f, 4.46849942e-01f,
  -1.82180598e-01f, 8.60226676e-02f, 3.16374987e-01f, -6.06081616e-21f, -3.34161371e-01f, -2.89549947e-01f, -1.42990485e-01f, 2.34315366e-01f, -4.65074092e-01f, -5.66722512e-01f,
  9.41322893e-02f, 3.90186459e-01f, 3.43747050e-01f, 2.32648924e-01f, 3.61854225e-01f, 4.31315064e-01f, 3.83667871e-02f, -4.51232612e-01f, -4.30940449e-01f, -1.77902833e-01f,
  -5.99537551e-01f, -7.66254425e-01f, -3.66227627e-01f, -6.03750229e-01f, -1.26908824e-01f, -3.99248093e-01f, -4.77024913e-01f, -2.09153414e-01f, 7.47048438e-01f, -2.64480829e-01f,
  -4.38974857e-01f, -4.03060526e-01f, 7.34475330e-02f, -5.82130924e-02f, 2.15438038e-01f, -3.73275203e-20f, 1.27659068e-01f, -4.05564815e-01f, 1.29993901e-01f, 9.83608365e-02f,
  -1.08288281e-01f, 1.34387061e-01f, 3.61693054e-01f, -8.39248240e-01f, 7.85600115e-03f, 4.93746340e-01f, 7.42529333e-01f, -1.27891123e-01f, -3.66995752e-01f, -8.69797543e-02f,
  3.94229501e-01f, 4.17930663e-01f, -6.91894069e-02f, -2.18885243e-01f, 7.02896535e-01f, -1.53128520e-01f, -4.42642391e-01f, -5.15473306e-01f, 1.21212132e-01f, -2.25707546e-01f,
  5.56549728e-01f, 4.38755900e-01f, -2.35585377e-01f, -9.01085511e-02f, 3.97362500e-01f, 5.71370304e-01f, -4.53916550e-01f, 3.58657516e-21f, -3.58324707e-01f, 4.56630290e-01f,
  -2.98523277e-01f, -8.37147355e-01f, 2.93231173e-03f, -3.54863465e-01f, 1.93955347e-01f, 2.90535092e-01f, -5.12427092e-01f, -8.26052725e-02f, -1.44519359e-01f, 2.28147998e-01f,
  -1.93024442e-01f, -1.06744975e-01f, 2.92200111e-02f, 3.04823935e-01f, -1.84753224e-01f, -2.89648145e-01f, 4.48288113e-01f, 1.43811733e-01f, 4.64733392e-01f, 3.06299329e-01f,
  -4.72472996e-01f, -4.48590636e-01f, -2.98381358e-01f, -2.43717179e-01f, 4.00341004e-01f, 3.06414753e-01f, -2.07480729e-01f, -4.02609408e-01f, -6.38115346e-01f, -1.23215328e-21f,
  -2.63838619e-01f, -8.37015152e-01f, 5.25077820e-01f, 3.87519300e-01f, -3.45324308e-01f, 2.09680960e-01f, -1.58668622e-01f, -1.39741436e-01f, -2.40013078e-01f, 3.82600009e-01f,
  -2.08455145e-01f, -4.49495405e-01f, -1.43195540e-01f, 1.36477739e-01f, -2.46948779e-01f, -4.04716700e-01f, 3.93546671e-01f, -2.08867833e-01f, 3.58101845e-01f, 6.64510548e-01f,
  4.26667571e-01f, 2.60162801e-01f, 7.10703507e-02f, -4.27707314e-01f, -8.57914627e-01f, 5.18799312e-02f, -1.63682804e-01f, -1.21350117e-01f, -1.89903229e-01f, 7.71240219e-02f,
  -2.13716365e-02f, -4.03956510e-22f, 3.32793027e-01f, -7.66661227e-01f, 1.11614898e-01f, -5.06651342e-01f, -9.38694850e-02f, 5.92422903e-01f, 5.42680979e-01f, -5.41318990e-02f,
  2.72732854e-01f, 4.22366187e-02f, 2.79715538e-01f, -7.48887137e-02f, 5.97045384e-02f, 6.39460608e-02f, -1.36440292e-01f, -2.76435167e-01f, 4.48290288e-01f, 1.22625008e-01f,
  -1.12733319e-02f, -4.71679360e-01f, -2.78222263e-01f, 6.59880102e-01f, 4.85726923e-01f, 5.29985428e-01f, 3.43391925e-01f, -6.27195477e-01f, 4.54212815e-01f, 3.62262547e-01f,
  2.32387319e-01f, -3.94142568e-01f, -5.85252583e-01f, 4.23776018e-21f, -5.15081763e-01f, 2.50084013e-01f, 1.69040382e-01f, 3.78188550e-01f, -7.23888516e-01f, -4.11744356e-01f,
  -3.01215321e-01f, -1.49204671e-01f, 4.21380728e-01f, -5.64920247e-01f, 3.14449430e-01f, -4.60377604e-01f, -4.68679219e-02f, -6.14238560e-01f, -7.05641925e-01f, 1.94016665e-01f,
  3.39287370e-01f, 7.17812628e-02f, 6.89507604e-01f, 2.98575431e-01f, 1.17983118e-01f, 7.73867130e-01f, 2.54372150e-01f, 3.02048773e-01f, -6.70733869e-01f, -2.34048530e-01f,
  -3.42029959e-01f, -2.45302305e-01f, 3.43163192e-01f, -4.90333200e-01f, 4.06194538e-01f, -1.59598895e-21f, 3.28076124e-01f, -7.77372420e-01f, -1.65057421e-01f, -3.40263061e-02f,
  -1.51362932e+00f, 3.90815020e-01f, -5.68867624e-01f, 6.69158101e-01f, 2.17266619e-01f, 2.20596731e-01f, -4.96673465e-01f, -1.14777759e-01f, 4.99095798e-01f, 1.02277905e-01f,
  -6.62971213e-02f, -5.36962338e-02f, -1.18981302e-01f, 2.83318698e-01f, 2.68618882e-01f, 3.00428420e-02f, 8.94241691e-01f, 7.68929958e-01f, -8.26868534e-01f, 4.69335586e-01f,
  -3.84778120e-02f, 6.29873335e-01f, 4.40478772e-01f, 3.62737894e-01f, -4.45526302e-01f, -3.47598165e-01f, -9.42986906e-01f, -2.47433006e-21f, -5.39454341e-01f, 2.23569676e-01f,
  -2.28230521e-01f, -5.55871189e-01f, 4.01991338e-01f, 2.81497777e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.33601591e-01f, 7.51418769e-02f, 3.94515470e-02f, 1.15784794e-01f, 2.04499975e-01f, -2.20229089e-01f, 2.08124653e-01f, 9.19359177e-03f, -1.70718014e-01f, -1.50221795e-01f,
  -2.69745231e-01f, -3.51530984e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    