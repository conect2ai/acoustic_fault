/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.41450542e-01f, 8.07733238e-02f, -9.37127024e-02f, -3.81339848e-01f, -1.51961580e-01f, 1.67724580e-01f, 1.42780751e-01f, -1.47761270e-01f, -3.16338211e-01f, 1.92875922e-01f,
  -2.03854963e-02f, 9.78899002e-02f, 1.92379624e-01f, -1.78147763e-01f, -2.47436613e-01f, 1.33403763e-01f, -1.81280479e-01f, 2.10602954e-02f, -6.66807890e-02f, -1.37150273e-01f,
  -2.05355003e-01f, -1.11374073e-01f, -1.93235889e-01f, -8.29850659e-02f, -1.17631719e-01f, -1.05809256e-01f, -1.01191409e-01f, 1.21480398e-01f, -2.87673511e-02f, 5.45192733e-02f,
  2.17221002e-03f, -5.07430062e-02f, -3.43091004e-02f, 4.92225066e-02f, -2.50074547e-02f, 1.31813372e-02f, 8.95900726e-02f, 1.03026494e-01f, -1.07305385e-01f, 3.61513235e-02f,
  6.08954579e-02f, -3.94973811e-03f, -3.57718468e-02f, -5.02912281e-03f, -4.88290302e-02f, -9.13923904e-02f, -4.00051735e-02f, -4.14949097e-02f, -1.16607131e-04f, 1.97700989e-02f,
  2.88511906e-02f, -2.40106098e-02f, -5.63769825e-02f, 3.83803956e-02f, -1.89568140e-02f, -9.92302224e-03f, 3.37133184e-02f, 6.07091188e-02f, -4.76877234e-04f, -1.34911118e-02f,
  3.28153819e-02f, 3.71918194e-02f, -1.57781690e-02f, -1.85180381e-02f, -5.39968871e-02f, -1.19974241e-02f, -4.32731807e-02f, 3.06534749e-02f, -2.35891975e-02f, 1.75253265e-02f,
  -4.44799140e-02f, -5.06118126e-02f, -8.03200062e-03f, -2.91782003e-02f, 2.46025808e-02f, -1.21971061e-02f, 2.27738973e-02f, 7.56013324e-04f, -3.81759256e-02f, -7.04600140e-02f,
  4.14846316e-02f, -1.55858723e-02f, 5.10115549e-02f, -2.00401107e-03f, 1.70837920e-02f, 9.93444212e-03f, -7.23753683e-03f, 2.36026980e-02f, -1.59039181e-02f, 3.13513502e-02f,
  3.40523161e-02f, 1.16709024e-01f, 3.61742638e-02f, 9.13494639e-03f, 5.73402382e-02f, 4.27115895e-02f, -3.02251540e-02f, -3.83603796e-02f, 5.28682284e-02f, -3.98966596e-02f,
  8.91317334e-03f, -6.01905286e-02f, 8.67594853e-02f, 8.20672698e-03f, 5.16376644e-03f, 6.61619008e-02f, 3.19085270e-02f, 1.26486542e-02f, -2.39630863e-02f, -5.67549206e-02f,
  1.41300596e-02f, 3.46041434e-02f, 4.58258092e-02f, -2.79791094e-02f, -1.45182433e-03f, 4.49182875e-02f, -1.18517280e-02f, 1.39743916e-03f, 3.52952033e-02f, 1.80530939e-02f,
  4.43618923e-01f, 1.63633272e-01f, 3.10661763e-01f, 1.66182727e-01f, -1.18442856e-01f, 4.48551103e-02f, 1.21105567e-01f, 6.68302970e-03f, 4.11316574e-01f, -1.11564025e-01f,
  -1.47030130e-01f, 2.01738089e-01f, -9.25441738e-03f, -1.67088825e-02f, 7.04297200e-02f, 1.18176751e-01f, 3.81941870e-02f, 2.04083975e-02f, 1.29459172e-01f, -2.21288875e-02f,
  8.63082558e-02f, -3.11110735e-01f, 6.52976409e-02f, -2.72227377e-01f, -1.83544103e-02f, 6.77934960e-02f, -3.38296592e-01f, -8.69839489e-02f, -2.17607930e-01f, -4.26288620e-02f,
  3.68160568e-02f, 1.52607679e-01f, 2.53154570e-03f, 2.87738498e-02f, -3.37935239e-02f, -8.25669467e-02f, 1.91627797e-02f, -2.12891176e-02f, 3.10816318e-02f, 6.14275821e-02f,
  6.08822424e-03f, -3.16295512e-02f, -1.49546117e-02f, -1.61867440e-02f, 2.09235735e-02f, 2.97722667e-02f, 4.01454791e-02f, 2.57137790e-02f, 7.42495432e-02f, 5.51287197e-02f,
  9.62143838e-02f, 2.80538015e-03f, -1.94729213e-02f, 3.87337394e-02f, 2.80213617e-02f, 3.66364494e-02f, -1.10554416e-02f, 3.67474034e-02f, -5.71080111e-03f, 6.72859624e-02f,
  -3.21978070e-02f, -3.70344631e-02f, 1.95401460e-02f, -6.39182478e-02f, -2.99145631e-03f, -7.49783814e-02f, -1.66847724e-02f, -9.49723572e-02f, 5.70407547e-02f, -5.98101877e-02f,
  1.07022922e-03f, 2.40303334e-02f, -4.84020002e-02f, -1.46640353e-02f, -1.89693440e-02f, 1.02069853e-02f, -4.06978354e-02f, -1.00474134e-02f, 3.68957929e-02f, -1.42555078e-02f,
  -1.79922041e-02f, 1.09924632e-03f, -5.26839122e-02f, -6.77680746e-02f, 1.54032577e-02f, 2.29373630e-02f, -2.89468709e-02f, 3.30963805e-02f, 3.08906734e-02f, 9.40757245e-03f,
  -6.99122846e-02f, -1.51895627e-01f, 3.67332175e-02f, 5.95025606e-02f, 6.02027308e-03f, -2.23065689e-02f, -2.83143995e-03f, 9.07861814e-03f, 4.47165500e-03f, -9.36735701e-03f,
  -3.46099101e-02f, -2.03067195e-02f, -5.46033345e-02f, -1.27758028e-03f, 5.27550932e-03f, -7.11418362e-03f, -6.23247698e-02f, -1.32891452e-02f, -1.07599005e-01f, -4.96098548e-02f,
  -1.17124632e-01f, -1.09388400e-02f, 3.24090533e-02f, -5.44859655e-02f, -6.34552613e-02f, -3.35821733e-02f, -4.30678055e-02f, 6.09548166e-02f, -7.30445459e-02f, -3.58521603e-02f,
  -6.26643062e-01f, 1.35097936e-01f, 5.78400902e-02f, -1.65799454e-01f, 4.13725749e-02f, 1.01051793e-01f, -1.74183667e-01f, 1.35169908e-01f, -1.08878501e-01f, 2.03113198e-01f,
  -1.63553968e-01f, -2.51015455e-01f, -1.58538014e-01f, 3.43978107e-02f, -6.13133788e-01f, -1.63818821e-01f, -1.14348076e-01f, -4.03797999e-02f, -2.57476438e-02f, -2.75347028e-02f,
  -1.08404182e-01f, -3.34091075e-02f, -2.19308380e-02f, 2.38453642e-01f, 1.45429313e-01f, 1.06979482e-01f, -1.65214650e-02f, 6.73901513e-02f, 8.89762565e-02f, -4.75834049e-02f,
  4.48027626e-02f, 5.50993979e-02f, 3.42961773e-02f, 1.20347306e-01f, 2.54056007e-02f, 3.61478585e-03f, -3.23169469e-03f, -6.77194893e-02f, -5.88147677e-02f, -1.81748439e-02f,
  -8.23371578e-03f, -2.80451309e-02f, 1.73882879e-02f, -3.22602578e-02f, 1.63672734e-02f, 2.75318753e-02f, 6.43939599e-02f, 3.99882570e-02f, 7.01661706e-02f, -4.14364319e-03f,
  4.54012007e-02f, 2.78334673e-02f, 4.77325656e-02f, 1.30429845e-02f, 3.76594998e-02f, 1.63420979e-02f, 9.64257680e-03f, 1.39201460e-02f, 3.03280428e-02f, 1.09654041e-02f,
  -5.34899943e-02f, 1.52760269e-02f, -1.66426413e-02f, 3.83147746e-02f, -1.52672185e-02f, 7.25104287e-02f, -1.57277454e-02f, -2.89235357e-03f, -4.74758409e-02f, 3.98538494e-03f,
  -1.70149263e-02f, -2.58146953e-02f, 1.71871651e-02f, 3.27561423e-02f, -1.13017736e-02f, 5.81646711e-02f, -3.14128250e-02f, 3.87709998e-02f, -1.70726713e-03f, -1.40848635e-02f,
  3.03643532e-02f, -1.79261174e-02f, 2.00580480e-03f, 3.46428491e-02f, -9.32456739e-03f, -2.20409930e-02f, 3.29156704e-02f, 3.08362339e-02f, 7.08429469e-03f, -7.44844079e-02f,
  1.88628528e-02f, -1.42138347e-01f, 1.16333775e-02f, -3.14424261e-02f, -1.42279183e-02f, -2.12980378e-02f, -1.05890231e-02f, 4.29862039e-03f, 4.54449803e-02f, -1.56254042e-02f,
  3.80363092e-02f, 5.20620048e-02f, -1.59827098e-02f, -9.17880423e-03f, -9.55176726e-03f, -3.15404087e-02f, -1.86604355e-02f, -2.74045998e-03f, -2.37226542e-02f, -6.27925023e-02f,
  -2.38532238e-02f, 2.48873793e-02f, -6.96813911e-02f, 5.18753976e-02f, 2.72312853e-02f, 1.55913671e-02f, -2.66859718e-02f, 8.77237692e-03f, -1.89747903e-02f, 3.83685194e-02f,
  3.70721892e-02f, 3.03633869e-01f, -2.52472073e-01f, 1.10130854e-01f, -1.69852108e-01f, -1.41976327e-01f, -7.94683546e-02f, 6.92613795e-02f, 1.28046528e-01f, 3.94608974e-01f,
  -5.28790755e-03f, 1.26491368e-01f, -2.64069401e-02f, 7.96566829e-02f, -2.74023265e-01f, -4.48171124e-02f, 6.75996915e-02f, 1.25274464e-01f, -5.26811332e-02f, 1.24859624e-01f,
  -1.41892686e-01f, 1.56065181e-01f, -2.33844876e-01f, -5.28765582e-02f, -2.09299009e-02f, -1.34629654e-02f, 7.76576847e-02f, -1.23415262e-01f, 7.81628489e-02f, -9.15087312e-02f,
  -1.39685003e-02f, 1.03865042e-01f, -5.57396226e-02f, 3.09227202e-02f, -5.53376637e-02f, -6.14436269e-02f, -1.54250097e-02f, -1.20556764e-01f, -3.05402856e-02f, -2.43509654e-02f,
  1.33033865e-03f, 4.20763269e-02f, -6.14149170e-03f, -3.66121270e-02f, 1.23130605e-02f, 1.54347224e-02f, -4.92177904e-02f, 1.20569514e-02f, -2.41815317e-02f, -1.02325857e-01f,
  -8.65925029e-02f, -1.27916811e-02f, -2.89238393e-02f, 5.52741401e-02f, -1.05871506e-01f, -2.56166272e-02f, -5.17783128e-02f, -6.66620806e-02f, 1.20891836e-02f, 1.79592241e-02f,
  -1.38669601e-02f, 7.71057978e-03f, 2.41667572e-02f, -1.55441808e-02f, 1.50534054e-02f, -1.17611587e-02f, 4.18564193e-02f, 1.32990368e-02f, 2.35461369e-02f, 2.75976043e-02f,
  1.25196846e-02f, 5.74534498e-02f, 2.19840072e-02f, 2.82094814e-02f, 5.84162921e-02f, 3.88729051e-02f, -5.45373596e-02f, 4.58146147e-02f, -4.18911614e-02f, -5.27173914e-02f,
  9.49517563e-02f, -1.34713612e-02f, 4.66239452e-02f, -1.88859291e-02f, 8.93199071e-03f, 1.85894929e-02f, 5.99268004e-02f, 8.31314847e-02f, -2.84278039e-02f, -7.65593797e-02f,
  3.00816655e-01f, 4.25719678e-01f, 4.49329615e-03f, 3.76140997e-02f, 6.65338188e-02f, -3.70144136e-02f, 1.78059936e-02f, 4.47966307e-02f, 8.09343532e-02f, 1.46830305e-02f,
  3.36012729e-02f, 8.18510234e-05f, 2.98641883e-02f, 1.59726199e-02f, 1.19851232e-02f, 4.59278002e-02f, 3.58435586e-02f, 3.01205907e-02f, 1.34371491e-02f, 6.34000152e-02f,
  7.08107874e-02f, -1.92359686e-02f, -7.49782473e-02f, -1.92675199e-02f, 2.59076972e-02f, 5.70790051e-03f, 2.43906695e-02f, 2.43221712e-03f, 3.79126854e-02f, 9.27956775e-03f,
  -5.96842766e-02f, -7.91171566e-02f, -9.12007391e-02f, -1.68141708e-01f, -1.41713366e-01f, 4.47121739e-01f, 3.34412128e-01f, -1.05819583e-01f, -4.41686451e-01f, 2.32120633e-01f,
  4.73352671e-02f, -4.79186401e-02f, 8.63236859e-02f, 1.63880408e-01f, 1.15954950e-01f, 3.82173918e-02f, 2.11353615e-01f, 9.13319513e-02f, -1.83505714e-01f, -2.14602635e-03f,
  -4.56927568e-02f, 1.03347063e-01f, 1.71616569e-01f, -1.45521211e-02f, 7.09563121e-03f, -9.66787115e-02f, 2.53309496e-02f, -1.21259538e-03f, 4.88019288e-02f, 3.03423479e-02f,
  5.13170324e-02f, -1.71903327e-01f, -4.31792773e-02f, -7.00991228e-03f, 8.36913362e-02f, 8.53351057e-02f, 3.96530256e-02f, 3.62435356e-02f, 8.23565945e-03f, -2.57495120e-02f,
  5.89592345e-02f, 8.11704621e-03f, -5.35510071e-02f, -6.23907857e-02f, -4.59232740e-02f, -7.31686130e-02f, -3.17002982e-02f, -3.88628878e-02f, -7.32898191e-02f, 2.18948126e-02f,
  -2.98858956e-02f, -1.73899084e-02f, 2.51104012e-02f, -9.75176878e-03f, -6.10096939e-02f, -8.52990523e-02f, 7.10334629e-02f, 3.43238860e-02f, -1.73076298e-02f, -3.13827582e-02f,
  4.80750613e-02f, -1.83706190e-02f, 3.16301547e-02f, -2.70017162e-02f, 3.27344090e-02f, -6.71834499e-02f, 5.83767928e-02f, -6.48436882e-03f, -3.59569043e-02f, 3.15134451e-02f,
  -6.04310865e-03f, -1.43729737e-02f, -7.15237390e-03f, 3.64832953e-03f, 2.25367006e-02f, 9.59414337e-03f, 3.56153548e-02f, 6.55911863e-03f, -4.06911261e-02f, 2.91850208e-03f,
  -2.39006579e-02f, 2.42698193e-02f, 2.43124124e-02f, 2.63514556e-02f, 4.61941725e-03f, 1.53971948e-02f, -2.30116751e-02f, -5.52543206e-03f, -2.32512411e-03f, 4.79697064e-02f,
  -1.28173949e-02f, 8.93233810e-03f, -3.87961082e-02f, -7.23109916e-02f, -3.48356515e-02f, 4.20998558e-02f, -2.20086109e-02f, -2.57250741e-02f, -4.88204956e-02f, 3.15272436e-02f,
  4.08444926e-02f, 2.12071966e-02f, -5.36873052e-03f, 3.35326195e-02f, -2.06597126e-03f, 8.71533528e-02f, 8.00705142e-03f, 1.69498790e-02f, 2.72242539e-02f, -5.31271994e-02f,
  5.95924407e-02f, 2.88118012e-02f, -2.22228691e-02f, -7.07341963e-03f, 5.14336191e-02f, 7.57399499e-02f, -4.61853258e-02f, -3.80839184e-02f, 5.16210916e-03f, -6.06481545e-03f,
  3.01935285e-01f, -1.81806743e-01f, 5.81470840e-02f, 1.48448348e-01f, 1.26857176e-01f, 4.32010591e-01f, 2.65371382e-01f, 7.88200721e-02f, 1.37358114e-01f, -1.86469898e-01f,
  3.77333537e-02f, -7.51884133e-02f, -1.89122498e-01f, 1.45094782e-01f, 2.56136894e-01f, -2.05471944e-02f, 1.52220294e-01f, 6.22476377e-02f, -6.76074065e-03f, 2.29556058e-02f,
  4.42595854e-02f, 1.32747799e-01f, -3.79572362e-02f, -1.81927085e-02f, 2.99550034e-02f, -9.95861441e-02f, -1.60499066e-01f, 1.52739312e-03f, -4.96470258e-02f, 5.36859706e-02f,
  1.66873381e-01f, -1.19915336e-01f, -9.17146206e-02f, 8.53095353e-02f, 1.16657108e-01f, 2.00651642e-02f, 4.23670076e-02f, 6.75861016e-02f, -9.51410737e-03f, 3.19217914e-03f,
  -2.44746283e-02f, 2.23315563e-02f, 6.37944564e-02f, 5.89567460e-02f, 6.00633174e-02f, -2.75719780e-02f, -3.23195309e-05f, 8.93054437e-03f, 9.67129692e-03f, 2.60623929e-04f,
  2.06013918e-02f, 1.20998244e-03f, -7.94276781e-03f, -3.99730913e-03f, 1.52293721e-03f, 5.79616614e-02f, 5.74748497e-04f, -5.21010831e-02f, 3.11394595e-02f, 4.03310210e-02f,
  1.09498668e-02f, 4.92134392e-02f, -2.45422646e-02f, 3.91200297e-02f, -1.05350828e-02f, 4.87146676e-02f, 2.81010699e-02f, 7.25513417e-03f, 3.40750604e-03f, 2.05438174e-02f,
  1.83961187e-02f, 5.38050849e-03f, 5.37974685e-02f, 7.04591349e-03f, 4.55721188e-03f, 6.97898492e-03f, 8.18506256e-03f, -2.71840654e-02f, 3.03344503e-02f, 7.83987623e-03f,
  -2.01223101e-02f, 2.90751010e-02f, -1.70051511e-02f, 2.87589021e-02f, 4.26008068e-02f, -1.67536139e-02f, -7.83855934e-03f, -3.01234145e-02f, 6.43358799e-03f, 2.62021422e-02f,
  -7.45562613e-02f, -2.39803251e-02f, -7.06304517e-03f, 5.80295571e-04f, -6.25058711e-02f, -8.44030306e-02f, 3.14874128e-02f, -9.95424483e-03f, 1.57670267e-02f, 1.18551394e-02f,
  1.85659751e-02f, -2.21959241e-02f, -3.11451172e-03f, -4.44652773e-02f, 4.51646969e-02f, -1.29395658e-02f, 3.24646309e-02f, 3.88844907e-02f, -1.29727693e-02f, -4.08927351e-03f,
  -2.82321088e-02f, 2.46720179e-03f, 2.10620537e-02f, -2.71705538e-02f, 5.21724373e-02f, -2.46964656e-02f, 2.29931995e-02f, -3.09186894e-02f, -3.99681227e-03f, -3.58481035e-02f,
  3.64518583e-01f, 1.98258422e-02f, -2.00395212e-02f, 4.98689152e-02f, 1.23179890e-01f, -1.93235800e-01f, -6.58702627e-02f, 6.00209460e-02f, -1.11996904e-01f, -1.49971293e-02f,
  1.12289779e-01f, 7.53689855e-02f, -2.44391132e-02f, -1.13947026e-01f, -6.79872334e-02f, -7.02507943e-02f, -9.18661579e-02f, 6.37962967e-02f, -7.48683140e-02f, 1.15421526e-01f,
  3.20726000e-02f, 2.83745714e-02f, -8.97381380e-02f, -4.20662202e-02f, 7.34721050e-02f, 6.37064874e-02f, 8.15478936e-02f, 1.15305902e-02f, 2.72753648e-02f, -9.65439007e-02f,
  4.85773617e-03f, 2.17596978e-01f, 6.60731494e-02f, 1.54967196e-02f, 5.06896041e-02f, 2.50698291e-02f, 8.99561506e-04f, -8.91764909e-02f, -6.67575374e-02f, 9.79060028e-03f,
  5.01287729e-02f, 1.80164389e-02f, 8.49759486e-03f, -7.94160590e-02f, -8.24498534e-02f, -1.83973126e-02f, -3.45378160e-03f, 1.00650801e-03f, 5.15799969e-02f, 1.38699375e-02f,
  2.07810458e-02f, 3.27133276e-02f, 1.30644878e-02f, 2.68347859e-02f, 2.72533786e-03f, -3.81615572e-03f, -4.32396084e-02f, 2.50446331e-02f, 4.75127511e-02f, -3.82335484e-02f,
  2.60900557e-02f, -7.84863606e-02f, 2.20620893e-02f, -2.14802288e-02f, 4.66981716e-02f, 1.45622613e-02f, -3.90087487e-03f, 2.01795530e-03f, -1.50738275e-02f, 1.63366031e-02f,
  5.37901372e-02f, 6.81284443e-02f, 6.41014278e-02f, -5.61127579e-03f, 4.74529862e-02f, 4.61534932e-02f, 1.89245101e-02f, 1.68208517e-02f, -3.46353240e-02f, -3.08046974e-02f,
  -2.94441095e-04f, 3.27442586e-02f, 3.59498858e-02f, 1.42748468e-02f, 7.52658909e-03f, 1.73193831e-02f, -4.54394380e-03f, 9.78747965e-04f, -2.89332774e-02f, 4.36113253e-02f,
  9.98677760e-02f, 1.45977944e-01f, -3.52875777e-02f, 3.81881148e-02f, -3.89804691e-02f, -4.69372720e-02f, -8.56776759e-02f, 1.99581683e-02f, -5.35248499e-03f, 1.09693059e-03f,
  -1.62936952e-02f, -6.48101978e-03f, 3.08099464e-02f, -1.31969259e-03f, -7.49511411e-03f, 1.39195053e-03f, 2.92770639e-02f, 3.94727010e-03f, -1.73869841e-02f, -2.39764955e-02f,
  4.09927107e-02f, 1.24836266e-02f, -2.42799427e-02f, 2.11626869e-02f, 2.96872500e-02f, 3.22124758e-03f, -3.06300912e-03f, -5.69969453e-02f, 5.56965210e-02f, -1.55706666e-02f,
  4.59622145e-01f, 1.09605260e-01f, -7.59957656e-02f, 1.45770267e-01f, 1.88676402e-01f, 2.80989349e-01f, 9.00303125e-02f, 9.40337926e-02f, 8.18665102e-02f, 7.92119727e-02f,
  -5.15964925e-02f, 1.09735593e-01f, -2.56054819e-01f, 7.87024423e-02f, -1.72441363e-01f, -2.41978124e-01f, 2.01439410e-01f, 7.54544735e-02f, -4.19493727e-02f, 1.19654961e-01f,
  7.23838899e-03f, 4.45711892e-03f, -8.43373239e-02f, 3.60945910e-02f, 1.62169874e-01f, 7.05330670e-02f, -3.66622582e-02f, -5.79211004e-02f, -2.65806448e-03f, -6.52189851e-02f,
  -6.55037835e-02f, -6.28471151e-02f, 1.02231884e-02f, -7.29266703e-02f, 8.51044431e-02f, 2.67394595e-02f, 1.01134218e-01f, -8.09107721e-02f, -7.69057423e-02f, -3.01712286e-02f,
  -1.61229055e-02f, 1.40304342e-02f, 1.07947737e-02f, -8.08151811e-03f, 2.62943581e-02f, -1.51814288e-02f, -3.52537958e-03f, -1.33301364e-03f, -2.81776339e-02f, -1.85509641e-02f,
  -3.75008807e-02f, -4.02081646e-02f, 6.77719191e-02f, -3.24597843e-02f, 1.69369914e-02f, -3.94642120e-04f, 1.08854556e-02f, -3.31907049e-02f, 3.94103639e-02f, 3.98069583e-02f,
  4.85782735e-02f, 2.82679219e-03f, -5.90199837e-03f, -1.50394579e-02f, -4.12910692e-02f, -8.52797180e-03f, -5.85295820e-05f, -3.74118872e-02f, 2.67227925e-02f, -6.17592782e-03f,
  2.47731265e-02f, 2.11630743e-02f, 3.48381735e-02f, 4.34675030e-02f, 3.66149768e-02f, 2.62336191e-02f, 1.35854753e-02f, -8.78213439e-03f, 1.10055991e-02f, 2.62258276e-02f,
  -6.13825917e-02f, 2.54726615e-02f, -3.76856215e-02f, -2.52329186e-02f, -1.39497584e-02f, -5.73184981e-04f, 2.34317463e-02f, 2.82754190e-02f, 1.65967755e-02f, 3.46771516e-02f,
  5.17425081e-03f, 2.28371155e-02f, -6.37824312e-02f, 3.13533731e-02f, -2.05423385e-02f, 7.34580606e-02f, -1.64838880e-02f, 3.39573584e-02f, 2.91839056e-03f, 5.12970760e-02f,
  9.22594443e-02f, 1.94010530e-02f, 2.22874787e-02f, 4.03357996e-03f, 3.24017927e-02f, 2.08170507e-02f, -9.15676262e-03f, 5.20901904e-02f, 5.40421493e-02f, 6.77930843e-03f,
  4.68042344e-02f, 3.48031782e-02f, -4.90814112e-02f, 6.55298233e-02f, -1.22225005e-02f, 4.19139490e-02f, 1.03867553e-01f, -1.60022955e-02f, -4.12050076e-02f, -2.83067357e-02f,
  1.82632968e-01f, 1.22763313e-01f, 4.19989787e-02f, 2.14450192e-02f, 2.71120250e-01f, 1.49069782e-02f, -3.10461726e-02f, 1.94136888e-01f, -1.11419514e-01f, 6.33240771e-03f,
  8.16799514e-03f, -1.09682478e-01f, -1.94021478e-01f, 3.57433036e-02f, -3.99315029e-01f, -3.66419584e-01f, -9.63286906e-02f, -1.28886849e-01f, -6.00482114e-02f, 2.14393977e-02f,
  4.25701030e-02f, 1.05893455e-01f, 1.30755734e-02f, 2.94640392e-01f, 3.23242456e-01f, 1.63487688e-01f, -1.83618907e-02f, 9.07990411e-02f, 1.61737621e-01f, 1.49947265e-02f,
  7.57240504e-02f, -3.28804813e-02f, 7.48871863e-02f, -6.97751418e-02f, -2.65068542e-02f, 5.12194149e-02f, -2.16881074e-02f, -3.48852985e-02f, 2.27038059e-02f, 2.55229976e-02f,
  -4.47607376e-02f, -2.99370959e-02f, -1.69236381e-02f, -1.60522610e-02f, 8.76350477e-02f, 1.03297010e-02f, 1.36061953e-02f, 7.95479566e-02f, 6.80204779e-02f, 9.17467568e-03f,
  2.42181029e-02f, -3.15944850e-02f, 1.87103683e-03f, -5.25476262e-02f, -5.00240363e-02f, -3.56480964e-02f, -2.19795313e-02f, 2.66808867e-02f, -1.07794190e-02f, -1.03813307e-02f,
  -3.20266448e-02f, -2.54449584e-02f, -1.19517362e-02f, 4.58037714e-03f, -3.46181681e-03f, 1.17313154e-02f, -8.28111768e-02f, -4.22086939e-03f, -1.85848046e-02f, 1.85289644e-02f,
  -6.81109726e-03f, 5.54440059e-02f, -1.67478509e-02f, 3.53084900e-03f, -5.40450029e-03f, 3.33289541e-02f, 9.03260894e-03f, -2.30916720e-02f, 8.40086956e-03f, 3.06948163e-02f,
  7.70189287e-03f, -4.54946980e-02f, -1.51822926e-03f, 2.24621631e-02f, -2.66846251e-02f, -4.14786339e-02f, -4.89877537e-03f, 2.54601818e-02f, 2.83623999e-03f, 1.29919238e-02f,
  -1.84935227e-01f, -1.62996382e-01f, 1.43406233e-02f, 4.82598878e-02f, -2.61827875e-02f, 2.30206382e-02f, -4.25579697e-02f, 5.35201579e-02f, -7.73095563e-02f, -4.86529246e-02f,
  4.36495990e-02f, 2.32553706e-02f, -2.67647998e-03f, -2.59361183e-03f, -1.94123723e-02f, -3.89160812e-02f, -8.80899206e-02f, -6.86728908e-03f, 4.48892675e-02f, -3.16257924e-02f,
  5.35053313e-02f, -3.39460000e-02f, 6.85988441e-02f, 7.02244714e-02f, 1.00166485e-01f, -1.34729862e-03f, -4.78293933e-03f, -1.64735354e-02f, -1.80942751e-02f, -1.05427857e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.53436989e-01f, -2.03252465e-01f, 7.73630515e-02f, 1.65375635e-01f, -3.44822668e-02f, -2.65744984e-01f, -5.28052170e-03f, -1.69027761e-01f, -4.36805449e-02f, -1.57364324e-01f,
  -1.07408762e-01f, 1.34933412e-01f, -1.24846011e-01f, 6.03948161e-02f, 3.48909259e-01f, -2.31005568e-02f, 7.98696093e-03f, 8.80421977e-03f, 5.18365838e-02f, -3.00151166e-02f,
  1.56057596e-01f, 1.62293971e-01f, 2.01410934e-01f, 6.72457218e-02f, 1.27971187e-01f, 4.14646380e-02f, 2.94808269e-01f, 2.61292439e-02f, 4.27262634e-02f, 1.25630081e-01f,
  -7.54862726e-02f, -7.77479708e-02f, 3.40595618e-02f, 6.61513954e-02f, 1.24768224e-02f, -1.00500502e-01f, -8.57364982e-02f, 4.92470227e-02f, -1.38832508e-02f, -6.42937347e-02f,
  1.76487379e-02f, 8.66229273e-03f, -9.61517319e-02f, 2.92284414e-02f, -1.13269404e-01f, -3.08553176e-03f, 2.40172595e-02f, 2.15609279e-02f, 5.20446487e-02f, -2.30705459e-02f,
  1.14924079e-02f, -7.96862692e-03f, 7.78262243e-02f, -3.94602045e-02f, 1.39049022e-02f, 2.18647299e-03f, -6.71308627e-03f, 2.36555003e-02f, 3.85408252e-02f, 5.31233810e-02f,
  -8.96042213e-02f, 4.88145053e-02f, -3.68603952e-02f, 8.87356848e-02f, 1.29544679e-02f, -6.62820274e-03f, -3.92344780e-02f, 6.77749664e-02f, -6.90852776e-02f, -3.03388480e-02f,
  -3.83681804e-02f, -2.36059446e-02f, -5.87841757e-02f, -5.39585575e-02f, -2.04994120e-02f, 1.54845631e-02f, 4.83754873e-02f, 1.71781536e-02f, -6.28324226e-02f, -1.69857796e-02f,
  7.56984577e-02f, 1.43897897e-02f, 7.54723279e-03f, 3.77511568e-02f, -1.45440958e-02f, 3.50800506e-03f, 2.52837632e-02f, -1.68668665e-02f, 3.00810370e-03f, -3.53719816e-02f,
  -6.38401359e-02f, 8.41794685e-02f, -7.97709916e-03f, 4.00105864e-02f, -3.81562393e-03f, -5.90514997e-03f, 6.88465387e-02f, -8.29270557e-02f, 1.09463809e-02f, -5.78369088e-02f,
  -2.65515633e-02f, -1.34660886e-03f, 7.21155405e-02f, 2.39464082e-03f, 5.98939583e-02f, -5.47521003e-02f, 2.27134600e-02f, 6.43702522e-02f, 8.07408094e-02f, 1.07373474e-02f,
  2.75080558e-02f, -4.24555205e-02f, 3.23863253e-02f, 7.90933594e-02f, -6.67663515e-02f, 2.80984063e-02f, 4.46952656e-02f, 1.67303830e-02f, -5.18449880e-02f, 2.95742340e-02f,
  7.50373164e-03f, -4.38631624e-01f, 1.84852675e-01f, -3.74877751e-02f, 2.41430447e-01f, 2.43877769e-01f, 1.18746996e-01f, -1.16555296e-01f, -1.85216174e-01f, -3.30743343e-01f,
  -1.14319332e-01f, -1.87902510e-01f, -1.95860118e-02f, 3.43843438e-02f, 1.96064040e-01f, 9.47020873e-02f, 1.29560744e-02f, 7.66180307e-02f, 7.32664838e-02f, -5.06456010e-02f,
  8.38418454e-02f, 1.20444559e-01f, 2.46785551e-01f, 5.41248266e-03f, 1.33610860e-01f, -7.79491216e-02f, -8.41310993e-02f, 1.99540645e-01f, -2.18558758e-02f, 4.08075899e-02f,
  -5.35762161e-02f, -1.67702362e-01f, -3.38526592e-02f, -7.00218007e-02f, -2.12777052e-02f, -1.02243558e-01f, 3.81616727e-02f, 1.38872728e-01f, 5.54783791e-02f, -1.22409193e-02f,
  6.47014985e-03f, 8.03785846e-02f, 6.48757850e-05f, 3.40555757e-02f, -3.59193957e-03f, 2.75922809e-02f, -5.68985706e-03f, -4.50202562e-02f, -1.17173968e-02f, 4.45046797e-02f,
  3.24609652e-02f, -6.64398521e-02f, 6.98747626e-03f, 3.59810479e-02f, -2.06606854e-02f, -5.22422828e-02f, 6.16044141e-02f, -5.52304871e-02f, -1.75657328e-02f, 2.06108056e-02f,
  5.33718504e-02f, 6.39136136e-02f, -2.96857767e-02f, 1.02243964e-02f, -2.09489651e-02f, 2.28846427e-02f, 1.79772247e-02f, -3.44758593e-02f, -3.47320549e-02f, -7.17997178e-02f,
  -5.53524774e-03f, -4.53657955e-02f, -7.67435133e-03f, 3.62473018e-02f, 3.05496436e-03f, -6.14296761e-04f, 1.39170429e-02f, -3.93043011e-02f, -4.86021228e-02f, 2.26265332e-03f,
  -3.36515345e-02f, -1.60864349e-02f, -6.29598647e-03f, 1.03867920e-02f, 3.28374654e-02f, 4.41638641e-02f, 5.18578105e-03f, 2.78143566e-02f, 2.21895371e-02f, 5.64795323e-02f,
  -2.90004402e-01f, -3.14559191e-01f, 1.09363608e-02f, -1.06144249e-02f, -4.95567247e-02f, 3.80947185e-03f, -3.04651279e-02f, -4.09686677e-02f, -7.72137642e-02f, -3.61580625e-02f,
  -7.65137374e-02f, 1.83067732e-02f, -1.73578896e-02f, 7.04549402e-02f, -1.83523279e-02f, 2.57078521e-02f, -6.61811754e-02f, -7.27017447e-02f, -9.56786573e-02f, -9.25546661e-02f,
  -6.97028711e-02f, 5.90153271e-03f, -5.12410374e-03f, 9.07469615e-02f, 2.61525773e-02f, 4.46749199e-03f, -4.57011920e-04f, -1.28250299e-02f, 3.58996168e-02f, -4.80504474e-03f,
  -2.25493267e-01f, 1.61869973e-01f, -1.31858587e-01f, -2.58203477e-01f, -1.58715248e-01f, -7.75976554e-02f, -2.14509696e-01f, -4.72053364e-02f, 3.14445142e-03f, 1.33335009e-01f,
  -6.25767335e-02f, 6.08004071e-02f, 1.17727205e-01f, -6.69803768e-02f, -8.51958692e-02f, 3.16161722e-01f, -5.65317497e-02f, 1.89747736e-02f, -3.08429077e-02f, -1.27034187e-01f,
  3.28823626e-02f, -1.63065359e-01f, -6.18673153e-02f, 4.15043496e-02f, -2.13301510e-01f, -1.50662839e-01f, -4.72839512e-02f, -1.75481483e-01f, -2.48531923e-01f, -1.34484544e-01f,
  -1.53448358e-01f, -2.06358001e-01f, -1.85406581e-01f, -4.28029597e-02f, -1.20396540e-01f, -8.27930495e-02f, -7.21930014e-03f, -1.00546673e-01f, -8.65932181e-02f, -5.79363666e-02f,
  -2.47998014e-02f, -2.14024987e-02f, 4.20132317e-02f, 5.80551513e-02f, -3.60330530e-02f, -5.26784882e-02f, -4.37219488e-03f, 3.64336604e-03f, -4.13528755e-02f, -5.85181825e-03f,
  -1.30398860e-02f, -6.50767703e-03f, -6.87210336e-02f, 7.20854178e-02f, -5.43874465e-02f, -1.33335099e-01f, -1.06117763e-02f, -8.89760852e-02f, -5.49394451e-02f, -1.03453301e-01f,
  1.40564190e-02f, -5.40501811e-02f, -7.07533956e-02f, 2.82037202e-02f, -7.82013312e-03f, -4.23620492e-02f, -6.92908689e-02f, -3.10205668e-03f, -2.07188334e-02f, -4.34117801e-02f,
  4.63974476e-02f, 4.45488747e-03f, 2.95346994e-02f, 2.91336570e-02f, -1.46003561e-02f, 2.15376671e-02f, 2.13608518e-02f, -6.48064166e-02f, 2.58500706e-02f, 8.68658442e-03f,
  1.67833567e-02f, -2.49908324e-02f, 5.74229620e-02f, 5.69507712e-03f, -8.18484947e-02f, -5.25618605e-02f, -6.82337135e-02f, 7.21165165e-02f, 3.94810364e-02f, -3.22801173e-02f,
  -2.22341627e-01f, -2.30060756e-01f, -6.03621788e-02f, -9.98593271e-02f, 3.71551770e-03f, -5.43348119e-02f, -2.82134046e-03f, -3.68522760e-03f, -1.50555983e-01f, -4.54055518e-02f,
  7.04966411e-02f, -1.00650601e-02f, -1.40800908e-01f, -3.49595957e-02f, 1.24277085e-01f, 1.84904598e-02f, -2.36058254e-02f, 7.24823773e-02f, -1.00378431e-01f, -2.57195178e-02f,
  -1.27548259e-02f, 7.09075667e-03f, 6.09476268e-02f, 3.54161337e-02f, -3.45945964e-03f, -1.99434161e-02f, 5.16492054e-02f, -4.86317556e-03f, -7.85744861e-02f, -2.06482206e-02f,
  -8.73682201e-02f, 9.18132365e-02f, -2.93340117e-01f, 1.63470849e-01f, -6.58768341e-02f, 2.50948966e-01f, 2.00732902e-01f, -3.32022607e-02f, 6.44948781e-02f, 3.16207319e-01f,
  2.52360791e-01f, -9.42244232e-02f, -1.08362939e-02f, 5.37122309e-01f, 5.87812811e-02f, 2.01403245e-01f, 4.62097585e-01f, 2.27057144e-01f, 7.30221998e-03f, -5.23368567e-02f,
  2.81707384e-02f, 3.80570203e-01f, -6.26542270e-02f, 1.05638020e-02f, 1.86365023e-02f, -1.90235168e-01f, -4.23286334e-02f, -3.34009290e-01f, 2.21745417e-01f, 9.75837708e-02f,
  1.12337798e-01f, 1.65914204e-02f, -3.90879028e-02f, -5.38257472e-02f, -9.08607170e-02f, -5.13448082e-02f, -2.90270261e-02f, -4.10584174e-02f, -9.94101763e-02f, 8.31424892e-02f,
  -9.35376063e-02f, -5.71338348e-02f, 5.26516922e-02f, -4.11889516e-02f, -9.66177043e-03f, -5.07801585e-02f, -4.79991660e-02f, -4.53370623e-02f, 1.50398808e-02f, -6.25539720e-02f,
  -5.50094731e-02f, 3.52729224e-02f, 2.06586942e-02f, 6.87449947e-02f, -3.86890694e-02f, 5.15854843e-02f, 5.49162216e-02f, -5.61353453e-02f, 1.02615602e-01f, -8.93823220e-04f,
  -4.19159196e-02f, 1.01975333e-02f, -7.17766359e-02f, 8.42938051e-02f, -3.45412060e-03f, 2.91714706e-02f, 1.75902452e-02f, 1.92001965e-02f, -5.30868955e-02f, -1.26667405e-02f,
  2.26524677e-02f, -1.21953269e-03f, -1.60848368e-02f, 1.94667764e-02f, 7.65562654e-02f, 1.53375454e-02f, -3.29072252e-02f, 7.83555880e-02f, 1.88022256e-02f, 1.93684292e-03f,
  -1.92120261e-02f, 1.75690223e-02f, -2.18838057e-03f, 2.52645072e-02f, 1.60201248e-02f, -4.35808636e-02f, 3.95313352e-02f, -7.42919222e-02f, -2.81721819e-02f, -3.18794418e-03f,
  1.59292340e-01f, 5.04706614e-02f, -4.62810788e-03f, 3.92919295e-02f, 3.42886038e-02f, -6.29021302e-02f, 2.77610254e-02f, -1.71476211e-02f, 1.68558827e-03f, -6.66942745e-02f,
  -5.05371243e-02f, -4.19366322e-02f, 2.14356799e-02f, -2.75828298e-02f, -1.48931227e-03f, 5.94420545e-02f, 6.82210028e-02f, 2.91566327e-02f, -2.18442753e-02f, -3.21937613e-02f,
  -1.00757755e-01f, 3.25919613e-02f, -3.91813740e-02f, 6.67444989e-02f, 1.24990322e-01f, -4.86582518e-02f, 7.06677791e-03f, -1.95935275e-02f, -8.99842009e-03f, 7.81255439e-02f,
  3.51729751e-01f, 2.65617073e-01f, 1.12063386e-01f, 1.18261054e-01f, -1.44408256e-01f, 1.53707638e-01f, -3.79956178e-02f, -2.09211521e-02f, 1.16180800e-01f, 1.51211694e-01f,
  -9.60473046e-02f, 4.15656686e-01f, -2.04353645e-01f, -7.19120502e-02f, -1.40734643e-01f, -1.31836459e-01f, 1.35790020e-01f, 9.34617519e-02f, 1.62729304e-02f, 1.37066469e-01f,
  -2.41780449e-02f, -9.45733190e-02f, -1.49136215e-01f, -1.31672084e-01f, 1.31940335e-01f, 1.27272129e-01f, -1.46444008e-01f, -9.35635716e-02f, 6.35677874e-02f, -1.64652675e-01f,
  -2.69500930e-02f, -5.70692029e-03f, -5.27015068e-02f, 8.84339362e-02f, 9.18634981e-03f, 3.30394506e-02f, -3.52659114e-02f, -5.58884554e-02f, -1.55478576e-02f, 6.86572418e-02f,
  1.00613400e-01f, 1.77736674e-02f, -8.20436107e-04f, 8.83218925e-03f, 7.89118856e-02f, 7.24883303e-02f, -1.76347308e-02f, 8.32971483e-02f, -9.56391077e-03f, 7.15984330e-02f,
  6.82691038e-02f, 1.15824044e-01f, 8.30998793e-02f, -5.72019294e-02f, -3.15393470e-02f, -7.68863736e-03f, 1.33076355e-01f, -3.31590585e-02f, -1.09129306e-02f, 1.37809187e-01f,
  -3.91573533e-02f, 2.37072613e-02f, -1.08606517e-02f, -1.70613360e-02f, -3.43322828e-02f, -2.71068309e-02f, 1.18568633e-02f, 9.59826354e-03f, -1.92730334e-02f, -4.76291291e-02f,
  5.72049953e-02f, -7.88391680e-02f, -5.52708320e-02f, 7.92836323e-02f, 5.34366630e-02f, -1.65563803e-02f, -1.81387756e-02f, 3.38098183e-02f, 3.21036093e-02f, 2.12724507e-02f,
  -8.78314003e-02f, 2.22711563e-02f, 8.42405856e-03f, -2.32282970e-02f, -1.85878109e-02f, -9.86370891e-02f, 1.89943146e-02f, -3.32922451e-02f, -4.13314849e-02f, -6.95448667e-02f,
  -1.80790294e-02f, 1.17021658e-01f, 1.10749103e-01f, 2.32738256e-02f, -3.73748876e-02f, 6.55885488e-02f, 4.94305678e-02f, 7.50727877e-02f, 7.48269781e-02f, -1.04017500e-02f,
  1.36667574e-02f, 3.30084451e-02f, 5.35251945e-02f, 4.19510119e-02f, -7.40374103e-02f, 1.13072218e-02f, -2.88039017e-02f, -1.77330971e-02f, -6.78908825e-02f, -2.06835624e-02f,
  2.92730201e-02f, -3.05918586e-02f, 4.02016193e-02f, 6.25633970e-02f, 4.49380167e-02f, -2.84617096e-02f, 1.28190890e-01f, 2.67325826e-02f, -6.99566752e-02f, -1.62906144e-02f,
  -7.15491548e-02f, 3.01014837e-02f, 1.13815121e-01f, 2.01015264e-01f, -8.02210048e-02f, -9.00893584e-02f, -5.68611431e-04f, -4.43095043e-02f, -2.43732974e-01f, 6.57502189e-03f,
  -6.35737851e-02f, 9.83492211e-02f, -3.78247201e-02f, 2.47455928e-02f, -1.14045665e-01f, -2.23769918e-01f, -5.18232919e-02f, -5.02046607e-02f, -1.20430045e-01f, 1.81876868e-01f,
  -5.43828532e-02f, -5.73820397e-02f, 6.04735762e-02f, 1.05572209e-01f, 1.04660988e-01f, 3.04813415e-01f, 2.54251182e-01f, 1.66933805e-01f, 2.43013352e-01f, 8.77441280e-03f,
  -7.48998001e-02f, 4.74425852e-02f, 1.21558560e-02f, 4.11468151e-04f, 1.42571423e-02f, 3.75787430e-02f, 1.48640975e-01f, 3.74103338e-02f, -1.35157313e-02f, -3.42743360e-02f,
  3.48044522e-02f, 2.62028426e-02f, 3.82202193e-02f, 5.29565699e-02f, 4.60160933e-02f, 1.91289317e-02f, 7.53738452e-03f, 8.20402727e-02f, -7.40446597e-02f, 3.02574784e-02f,
  1.20878927e-01f, 4.64981459e-02f, 1.03197590e-01f, 5.38404845e-02f, 1.45763848e-02f, 1.74024664e-02f, 6.54532090e-02f, 1.00037090e-01f, 3.67810242e-02f, -3.17567959e-02f,
  -2.63041779e-02f, 3.90973911e-02f, -1.54201668e-02f, -4.33552042e-02f, -6.25247136e-02f, -4.34551165e-02f, 5.42003894e-03f, 3.79736386e-02f, 7.07278401e-02f, -3.58572155e-02f,
  4.98608947e-02f, -3.10525466e-02f, -3.99123393e-02f, -6.61874469e-03f, -2.76973471e-02f, 3.39523889e-02f, 3.07230987e-02f, -4.01308313e-02f, 2.16643550e-02f, 3.38754319e-02f,
  1.99168827e-02f, -7.01958388e-02f, -2.35100444e-02f, -3.42166051e-02f, -9.69099998e-02f, -3.97833064e-02f, -6.74835593e-03f, 2.99064629e-02f, 4.00850512e-02f, 2.29454525e-02f,
  6.11345172e-02f, 2.79096007e-01f, -6.79019988e-02f, -4.90154736e-02f, -3.33232321e-02f, 4.27508205e-02f, 2.58334279e-02f, -5.97163476e-02f, -5.45847788e-03f, -2.76511703e-02f,
  1.14452258e-01f, 2.05546413e-02f, -4.93871747e-03f, -1.07562253e-02f, 8.89077336e-02f, 3.64564136e-02f, 3.75211574e-02f, 7.16836527e-02f, 1.02113493e-01f, 1.43803164e-01f,
  6.25344440e-02f, -1.85650028e-02f, -5.19131087e-02f, 7.98308663e-03f, -9.93695389e-03f, 5.72182285e-03f, -3.25036906e-02f, 1.13527834e-01f, 1.32824317e-01f, 3.04089971e-02f,
  -3.27140152e-01f, 5.62287383e-02f, 2.12282706e-02f, -1.92888200e-01f, 1.84154108e-01f, -7.45593756e-02f, -4.63470723e-03f, 1.57505199e-01f, 9.81542096e-02f, 1.52938724e-01f,
  1.45286232e-01f, 6.81796148e-02f, 1.49525121e-01f, -1.16134554e-01f, -3.84443909e-01f, -1.17989607e-01f, -2.71126240e-01f, -1.78753719e-01f, -1.46150973e-03f, -9.88712162e-02f,
  -2.12926090e-01f, -1.86404679e-02f, -1.11748055e-01f, 1.57588556e-01f, 4.10365984e-02f, 1.41373843e-01f, -5.83320335e-02f, 2.77084947e-01f, -1.05330579e-01f, 6.17533773e-02f,
  -2.15386152e-02f, 1.24436282e-01f, -1.77223457e-03f, 3.92965749e-02f, -1.05084129e-01f, -8.31301957e-02f, -4.90255021e-02f, 9.76844802e-02f, -3.53828333e-02f, 7.18867360e-03f,
  -6.06905967e-02f, 7.13462979e-02f, -1.36187579e-02f, 8.22061971e-02f, 3.29290219e-02f, -8.10844079e-03f, 8.11513886e-02f, -6.76476434e-02f, 4.81549799e-02f, 6.06437288e-02f,
  2.61647552e-02f, 1.74090341e-02f, -6.06545731e-02f, -9.13125724e-02f, -3.63955572e-02f, 1.09312370e-01f, -8.41458589e-02f, -7.96301141e-02f, -6.60747429e-03f, -6.11524610e-03f,
  -1.18314764e-02f, -4.46556173e-02f, 8.93130973e-02f, 8.93717334e-02f, 2.41310112e-02f, 9.45008639e-03f, 5.55448309e-02f, 1.72485430e-02f, 1.99781451e-02f, -9.87019483e-03f,
  -5.26413284e-02f, -1.40523519e-02f, 6.67608306e-02f, -6.15755320e-02f, -1.00295141e-01f, 5.61083667e-02f, -6.44689426e-02f, 2.99332328e-02f, -9.50865448e-02f, -3.30429971e-02f,
  -3.94448899e-02f, -1.78136583e-02f, 2.14396473e-02f, -3.82921025e-02f, 6.17214628e-02f, 3.35034803e-02f, 6.45126391e-04f, -4.13543768e-02f, -3.69120426e-02f, -3.25403996e-02f,
  -1.34642079e-01f, -1.94635406e-01f, -4.90399785e-02f, 8.00980106e-02f, -4.44932878e-02f, -2.58620456e-02f, -1.06510930e-02f, -5.38802110e-02f, -7.30935335e-02f, -4.86673079e-02f,
  2.49453541e-02f, -1.23998448e-02f, -7.83767179e-02f, -4.60266077e-04f, 4.25860696e-02f, 6.31719232e-02f, -3.39445099e-02f, -2.65249684e-02f, -1.15109138e-01f, 3.85091491e-02f,
  2.50847358e-02f, -7.63639575e-03f, -8.81732162e-03f, 1.11441575e-02f, -5.83136305e-02f, -4.49567661e-02f, -5.05914912e-02f, 8.33338499e-03f, -2.29768585e-02f, -5.62906750e-02f,
  9.89961252e-02f, 8.41960236e-02f, -3.61413993e-02f, -9.08905342e-02f, -1.67962862e-04f, -1.09507635e-01f, -1.29295960e-01f, 2.46344935e-02f, -1.02098480e-01f, -8.89587104e-02f,
  -7.35185072e-02f, -6.29237518e-02f, -9.47220773e-02f, 1.48838863e-01f, 4.17487286e-02f, 4.76916879e-03f, 2.06040487e-01f, 4.32049446e-02f, 1.36276633e-01f, 1.90077186e-01f,
  2.01469153e-01f, 1.11365661e-01f, 2.86621124e-01f, 2.60266900e-01f, 5.18527552e-02f, 4.07077074e-02f, 7.22375289e-02f, 8.77195597e-02f, 1.61419779e-01f, -1.90438423e-02f,
  7.68306404e-02f, 5.76724261e-02f, 9.21706781e-02f, 2.24639568e-02f, 2.83631682e-02f, 8.49187523e-02f, 3.28627713e-02f, 3.72492783e-02f, -2.52847616e-02f, -3.74994799e-02f,
  -7.24258497e-02f, 6.26255050e-02f, 5.66438027e-03f, 4.37445231e-02f, -4.08948436e-02f, 1.43905738e-02f, 2.88116336e-02f, -4.02870066e-02f, -4.33166139e-02f, -7.27276364e-03f,
  1.61376018e-02f, -3.68777500e-03f, 3.15733887e-02f, -4.22725044e-02f, 2.11171117e-02f, -1.08582921e-01f, 1.95066109e-02f, -2.70503014e-02f, -2.91288570e-02f, 4.76792529e-02f,
  7.71234483e-02f, -8.00735131e-02f, -6.36687353e-02f, 9.77786817e-03f, 1.86412074e-02f, 8.95809904e-02f, -2.30953507e-02f, -7.49332234e-02f, -6.54213950e-02f, 8.76139775e-02f,
  -3.93878780e-02f, -9.12001878e-02f, 4.84341662e-03f, 2.45491993e-02f, 5.81261665e-02f, 4.28529568e-02f, 4.01351266e-02f, 6.32694438e-02f, -4.77684708e-03f, 2.11172476e-02f,
  -8.06976780e-02f, 5.21254018e-02f, -7.89235625e-03f, 1.58287939e-02f, 6.47030324e-02f, -2.50041634e-02f, 1.09905191e-02f, -3.63487899e-02f, 3.65423821e-02f, -1.42052826e-02f,
  9.92713571e-02f, 1.60598084e-02f, -8.74972641e-02f, -8.73104855e-02f, 6.28834367e-02f, -2.83510368e-02f, 5.72060980e-02f, -5.38069941e-03f, -1.02053294e-02f, 7.30951056e-02f,
  -5.39311245e-02f, 4.61799577e-02f, 6.85828477e-02f, 7.46320784e-02f, -3.85863222e-02f, 5.97328320e-02f, 4.60817665e-02f, -2.69032866e-02f, -7.76634291e-02f, 1.00300953e-01f,
  2.07908102e-03f, -7.78391659e-02f, 2.65766736e-02f, -7.31204823e-02f, 1.40702352e-02f, -5.20951822e-02f, 6.34014979e-03f, -4.78974357e-02f, 6.43929765e-02f, -2.28063273e-03f,
  -3.73159312e-02f, 1.87385585e-02f, 5.67571074e-02f, 2.87067443e-01f, -2.80713737e-02f, -2.69246757e-01f, -1.29444689e-01f, 1.92266017e-01f, -1.28218278e-01f, -5.12047336e-02f,
  1.33709788e-01f, -1.27612159e-01f, -7.40480572e-02f, 5.28112389e-02f, 1.37777790e-01f, -1.41233772e-01f, 8.50522369e-02f, -1.20144159e-01f, -5.85853271e-02f, 1.65787578e-01f,
  2.40234330e-01f, 2.24306911e-01f, 1.82271123e-01f, 2.65883863e-01f, 8.66270214e-02f, 1.79864585e-01f, 3.19919735e-01f, 8.41537304e-03f, 2.40056083e-01f, 3.31460312e-02f,
  -1.16384730e-01f, 1.24264151e-01f, 2.26925425e-02f, -6.86575323e-02f, 1.64837688e-02f, -5.58197964e-03f, -9.32787433e-02f, -6.59038946e-02f, 6.20136932e-02f, 2.85342187e-02f,
  -2.95571964e-02f, -3.77160870e-02f, 6.37494549e-02f, -1.84677597e-02f, -3.02820858e-02f, 1.26361191e-01f, -2.78985947e-02f, -2.22618524e-02f, -8.48263800e-02f, 2.39564385e-02f,
  -4.70693409e-02f, -1.52781485e-02f, 4.80789831e-03f, -5.60513176e-02f, 1.04636014e-01f, -5.07874833e-03f, 3.13366689e-02f, 3.17638107e-02f, -4.12488766e-02f, 9.61289704e-02f,
  2.85616983e-02f, -3.61665748e-02f, -2.56828852e-02f, -6.00259602e-02f, -2.95677651e-02f, 4.56481166e-02f, -4.18627672e-02f, -5.63160107e-02f, 2.96598654e-02f, -6.99363202e-02f,
  8.76720995e-02f, -4.24800441e-02f, -2.45645978e-02f, 4.20763204e-03f, -7.77915306e-03f, -2.17811633e-02f, -4.94458713e-02f, 2.84816995e-02f, 1.19974781e-02f, 1.53783513e-02f,
  -4.11046594e-02f, 3.89538035e-02f, -1.19695291e-02f, -6.55193999e-02f, -3.57147418e-02f, 2.53206734e-02f, 7.69682899e-02f, -1.77995637e-02f, -1.60940867e-02f, 3.95779172e-03f,
  3.28629347e-03f, 3.40450764e-01f, 4.07221355e-03f, -5.42833358e-02f, 7.34846890e-02f, -8.15994442e-02f, 8.34150985e-03f, 8.50058533e-03f, 4.87475954e-02f, -2.38674693e-02f,
  1.05031058e-01f, 2.76580863e-02f, -6.94312854e-03f, 1.65261105e-02f, -8.59185006e-04f, 1.82138232e-03f, 3.78516950e-02f, 1.50948726e-02f, 1.04001448e-01f, 4.28427309e-02f,
  7.63591975e-02f, -7.72713497e-02f, 2.32141484e-02f, -2.04873849e-02f, 6.30659163e-02f, 3.53790075e-02f, 6.61921129e-02f, 1.64785720e-02f, 2.70076692e-02f, -3.85073759e-02f,
  2.59864509e-01f, -1.47182122e-01f, 3.60756069e-01f, 1.71716735e-01f, 2.30687141e-01f, 2.38274395e-01f, 3.09884727e-01f, -8.27036519e-03f, 5.88860251e-02f, -1.58757836e-01f,
  -1.33070499e-01f, 1.51384667e-01f, 6.07431494e-02f, -1.66514446e-03f, 5.71744703e-02f, -1.24418221e-01f, -5.62794060e-02f, -1.34385787e-02f, 1.61041487e-02f, 1.24732152e-01f,
  3.06457896e-02f, -2.02713877e-01f, 2.87854243e-02f, -3.02125424e-01f, 1.23816930e-01f, 3.19433101e-02f, -2.38749042e-01f, -2.05763727e-02f, -1.02381885e-01f, -2.20910888e-02f,
  9.62632447e-02f, -8.25882033e-02f, 9.26190913e-02f, 7.42782205e-02f, -4.03683968e-02f, -4.65704277e-02f, -3.13141979e-02f, -1.99415870e-02f, -3.87266465e-02f, 1.58743635e-02f,
  -1.30318422e-02f, -3.79153946e-03f, -2.21971106e-02f, -2.90091913e-02f, -2.02810932e-02f, -3.63605954e-02f, 1.29198983e-01f, 1.00464992e-01f, -2.35092849e-03f, 6.28934056e-02f,
  1.40234008e-01f, 1.14906229e-01f, 5.31304665e-02f, -7.71932900e-02f, 3.94498408e-02f, -6.27660751e-02f, -3.21480855e-02f, 5.24771623e-02f, 9.40566361e-02f, -5.96609041e-02f,
  -1.39375642e-01f, -1.52898831e-02f, -4.85358313e-02f, 8.49342197e-02f, -9.97635443e-03f, 2.68176720e-02f, 1.91048309e-02f, -1.09601235e-02f, 7.04851076e-02f, 7.62862414e-02f,
  -2.19392055e-03f, 3.65074389e-02f, -3.77661064e-02f, 9.08880234e-02f, -4.09481339e-02f, -2.55019851e-02f, 5.46826571e-02f, -2.44684815e-02f, -6.58944398e-02f, -6.99406769e-03f,
  7.43689165e-02f, -3.45314033e-02f, 4.73741479e-02f, 2.28367466e-02f, -8.09588805e-02f, -2.62296740e-02f, 9.01332498e-03f, 1.08712621e-01f, -8.12324286e-02f, 9.40954033e-03f,
  -8.19974989e-02f, -2.34721601e-01f, -1.07209750e-01f, -6.45564944e-02f, -5.89432307e-02f, -3.98640074e-02f, 1.96145736e-02f, 3.57018644e-03f, -4.70890664e-02f, 1.18494090e-02f,
  -7.85117690e-03f, 1.63411796e-02f, 4.62477840e-02f, 5.53045310e-02f, -8.66042599e-02f, 5.05912118e-02f, -5.75407669e-02f, -1.12146072e-01f, -7.01177791e-02f, -2.12238226e-02f,
  -3.82522866e-02f, -9.63125844e-03f, -7.28059327e-03f, -7.33522000e-03f, -1.08392574e-01f, -4.29515839e-02f, -2.51326356e-02f, 1.06921503e-02f, 1.36841564e-02f, 1.88001096e-02f,
  8.96325260e-02f, -1.89339779e-02f, 2.04933546e-02f, 1.29349977e-01f, 3.72915529e-02f, 1.23879015e-01f, 1.38645560e-01f, -7.53195491e-03f, 2.53259540e-01f, -1.15571089e-01f,
  2.88130920e-02f, 9.60759073e-02f, 1.91587377e-02f, 6.24316395e-04f, 6.14900514e-02f, 5.83099248e-03f, 8.01467746e-02f, 7.02975765e-02f, 8.20754096e-02f, -1.53687596e-02f,
  5.44165596e-02f, -6.69699684e-02f, -1.76538169e-01f, -2.09498256e-01f, -3.96497212e-02f, -6.20955378e-02f, -9.99867320e-02f, 9.65513885e-02f, -1.46902815e-01f, 4.37438227e-02f,
  -4.57791612e-02f, -1.27715664e-02f, -2.59616300e-02f, -7.68399090e-02f, -1.18857147e-02f, 5.58572114e-02f, 1.43119290e-01f, 6.95748329e-02f, -1.18820379e-02f, -8.28642622e-02f,
  -4.10824828e-02f, -2.72085760e-02f, 5.17462902e-02f, -4.89663370e-02f, 3.90527993e-02f, -5.37929423e-02f, 1.82431005e-02f, -3.53909023e-02f, -8.39208066e-02f, -1.23910926e-01f,
  -5.16033210e-02f, 3.90430738e-04f, 9.77035537e-02f, 1.48627013e-02f, -4.55570444e-02f, -7.50628263e-02f, 6.84799850e-02f, 5.81690855e-02f, -4.95000407e-02f, 3.71036716e-02f,
  -1.42895859e-02f, -1.01389596e-02f, -6.19784184e-03f, 6.10979758e-02f, -5.61389141e-03f, -6.05999455e-02f, 2.36203503e-02f, -8.45673308e-02f, -3.63000520e-02f, -6.35740384e-02f,
  2.90608183e-02f, 1.70268770e-02f, 8.41859803e-02f, 7.46917799e-02f, -4.00723815e-02f, 8.91250819e-02f, 6.17950857e-02f, 8.49298984e-02f, -2.88426839e-02f, -4.19444069e-02f,
  -3.32736187e-02f, 3.89420241e-02f, -3.55124325e-02f, 7.12348986e-03f, -3.11955493e-02f, 7.01326504e-03f, -8.52832869e-02f, 6.50069565e-02f, 6.26679361e-02f, -3.37498710e-02f,
  -1.07720410e-02f, 1.64034709e-01f, -4.10619304e-02f, -8.06774274e-02f, 4.22121026e-02f, -6.10226206e-02f, 9.85655859e-02f, -2.97685191e-02f, 5.93712321e-03f, 5.12544848e-02f,
  2.40802225e-02f, 8.65542293e-02f, 9.33958665e-02f, -6.94727004e-02f, -2.37776097e-02f, -8.63176771e-03f, 8.90763178e-02f, -2.68169586e-02f, 1.65288355e-02f, -7.73775801e-02f,
  -2.91103963e-03f, 8.22511092e-02f, -3.83729935e-02f, 3.31301391e-02f, 7.87810311e-02f, 4.01197672e-02f, -3.71208526e-02f, -5.45976348e-02f, 7.17871115e-02f, 4.76099141e-02f,
  2.89337724e-01f, -3.64393771e-01f, -3.44457626e-01f, 1.33086503e-01f, 2.55754441e-01f, 2.58185834e-01f, -7.67742544e-02f, 7.43980287e-03f, -1.60343125e-01f, -8.48847330e-02f,
  9.03633982e-02f, -2.29473561e-01f, -3.36131930e-01f, 8.58334601e-02f, 1.08102553e-01f, -2.74177819e-01f, 1.14883408e-01f, 4.01348770e-02f, -8.91914964e-02f, 5.39821535e-02f,
  8.88734981e-02f, 3.13764960e-01f, -1.06842399e-01f, 1.67720422e-01f, 1.09134853e-01f, -2.97808126e-02f, 1.16826281e-01f, -1.02593876e-01f, 1.97280139e-01f, 1.69708356e-01f,
  1.13869004e-01f, -9.82258096e-02f, -1.55967390e-02f, -5.46880476e-02f, -2.80690622e-02f, 1.05003476e-01f, -2.87551954e-02f, 4.68344800e-02f, -5.08688018e-02f, -2.00902428e-02f,
  -5.09507470e-02f, -7.57302798e-04f, 1.76459644e-02f, -4.74574044e-02f, 9.42487195e-02f, -2.82344241e-02f, -5.66391721e-02f, -5.28409295e-02f, -1.29356384e-01f, 1.87704936e-02f,
  -1.22024320e-01f, -2.39762869e-02f, -8.17511827e-02f, -1.72590595e-02f, -6.54461384e-02f, 1.24082332e-02f, -7.11575523e-02f, -8.23101252e-02f, -4.69300114e-02f, 7.20380200e-03f,
  3.27789262e-02f, -8.64406116e-03f, -5.30360192e-02f, 5.48833683e-02f, -3.01965140e-03f, 2.46689096e-02f, 2.74790730e-02f, -3.21824178e-02f, -6.22823238e-02f, 5.79526573e-02f,
  -4.69884202e-02f, 3.04594040e-02f, -2.26510558e-02f, 2.72039268e-02f, 1.64032355e-02f, -9.95590724e-03f, -6.98807836e-02f, 7.31708109e-02f, -7.93049810e-04f, -2.79798377e-02f,
  -1.43500441e-03f, -2.91683935e-02f, 3.01685799e-02f, -1.06230266e-02f, -4.18471843e-02f, 3.58715616e-02f, 2.79655401e-02f, 3.50836106e-02f, -3.74708958e-02f, -3.19382548e-02f,
  -2.17477921e-02f, -1.95080459e-01f, -8.71470273e-02f, 6.19755387e-02f, -6.70859218e-02f, 9.00943875e-02f, -6.66450113e-02f, 2.19445955e-02f, -4.28886293e-03f, 1.55884465e-02f,
  7.95900747e-02f, 3.02990917e-02f, -1.67572927e-02f, 7.48115629e-02f, 2.57407525e-03f, 5.01266606e-02f, -6.20009527e-02f, -1.85190123e-02f, 2.71082129e-02f, 5.37036210e-02f,
  -1.45187667e-02f, 6.11530105e-03f, 3.43419909e-02f, -3.95140573e-02f, -6.43541943e-03f, -4.27577458e-02f, -1.80150904e-02f, 1.75951459e-02f, -2.58484762e-02f, -9.04711634e-02f,
  -1.57134756e-01f, 2.49965355e-01f, -1.67872399e-01f, -1.83664002e-02f, -3.59130874e-02f, 2.45055277e-02f, 1.14728704e-01f, 4.36905771e-02f, -3.76081355e-02f, 2.07613751e-01f,
  1.77383468e-01f, -1.49132773e-01f, 3.32467295e-02f, 2.25928634e-01f, -4.57285997e-03f, 1.55372337e-01f, 1.99207544e-01f, 1.39479816e-01f, 1.69178974e-02f, 1.56712104e-02f,
  -3.19354758e-02f, 1.45966023e-01f, 1.66507408e-01f, 1.41008958e-01f, -2.17329748e-02f, -1.96878221e-02f, -1.07770674e-01f, 1.49674527e-02f, -3.54225077e-02f, -8.67253318e-02f,
  9.07494649e-02f, -3.06345504e-02f, -9.40459967e-02f, -5.24875261e-02f, -6.29304647e-02f, -4.09689322e-02f, -6.29505143e-02f, -9.94028375e-02f, -9.48346257e-02f, -1.02358055e-03f,
  -3.93988937e-02f, 4.15783599e-02f, 3.20509635e-02f, 4.63521248e-03f, -7.59602785e-02f, -7.40433037e-02f, 8.77358094e-02f, 6.02411106e-02f, -3.99141237e-02f, 2.25680135e-02f,
  5.97481765e-02f, 8.62989798e-02f, 5.40538095e-02f, -2.17149183e-02f, -1.07946865e-01f, 2.67381091e-02f, -3.68040279e-02f, 1.29325166e-02f, -9.91752893e-02f, -4.76080552e-03f,
  -7.94123262e-02f, -6.87716156e-02f, 6.41807914e-02f, -1.23746330e-02f, -7.37123489e-02f, 7.75856972e-02f, 5.76526597e-02f, -4.67314534e-02f, -7.78378993e-02f, 2.38288268e-02f,
  5.45933028e-04f, -3.91363224e-04f, 1.10742534e-02f, -2.49975752e-02f, -2.06732377e-03f, 3.61742340e-02f, 7.18866736e-02f, -5.93430027e-02f, -2.86534708e-02f, -4.30191271e-02f,
  5.41776270e-02f, 1.47121586e-02f, 8.71889815e-02f, 1.47485675e-03f, -3.65553461e-02f, -1.87136307e-02f, -6.55392706e-02f, 1.10404991e-01f, 3.20112295e-02f, -8.65757391e-02f,
  8.71364474e-02f, -8.55458975e-02f, 1.40817976e-02f, 1.54991494e-02f, 1.05178766e-02f, 3.97213027e-02f, 4.71767895e-02f, 1.76776499e-02f, 2.25894470e-02f, 5.32208197e-02f,
  -5.29890507e-02f, -6.73408061e-02f, -5.68322167e-02f, -4.59547900e-02f, -1.06544428e-01f, -2.30110455e-02f, -1.98075082e-02f, -6.44263774e-02f, 5.23316339e-02f, 5.90014495e-02f,
  4.84098643e-02f, -4.97354493e-02f, 2.72822604e-02f, -5.12767322e-02f, 4.46152361e-03f, 2.41034310e-02f, -5.02947420e-02f, -4.83784452e-02f, -5.89518994e-02f, -3.95411961e-02f,
  1.52687177e-01f, 1.42623633e-01f, 1.85085982e-01f, 1.84373111e-01f, -9.85007957e-02f, -1.08177736e-01f, -1.49590150e-02f, 2.18066145e-02f, 2.73117334e-01f, -5.89185208e-02f,
  -1.56589061e-01f, 2.16355205e-01f, -1.61255568e-01f, 1.19507514e-01f, -1.73397094e-01f, -7.64088035e-02f, -4.27815430e-02f, 9.23159625e-03f, 1.35880977e-01f, -7.39967776e-03f,
  2.62485165e-02f, -1.66500464e-01f, -8.55836868e-02f, -6.43867627e-02f, 1.18309349e-01f, 3.13034095e-02f, -2.39318416e-01f, -1.36630595e-01f, 8.41995776e-02f, -9.55597684e-02f,
  8.79425704e-02f, 1.97088812e-02f, 9.41039920e-02f, -1.00452565e-02f, -1.12683773e-01f, -6.53979033e-02f, -1.27664339e-02f, -8.07604268e-02f, -2.13482287e-02f, 5.25680184e-02f,
  9.99264196e-02f, -3.88683267e-02f, 5.56398071e-02f, -2.79621687e-02f, 6.00077845e-02f, 9.68149751e-02f, 1.83958542e-02f, 2.90620532e-02f, -1.53636038e-02f, 2.17157695e-02f,
  1.12106927e-01f, 3.61657701e-02f, -5.95001020e-02f, 6.51322976e-02f, 4.95102443e-02f, 1.05750285e-01f, 1.62028300e-03f, -6.61860555e-02f, 1.16610929e-01f, -2.27456633e-02f,
  2.69290376e-02f, 1.74316987e-02f, -5.65329082e-02f, 3.25302174e-03f, -2.58495249e-02f, -2.78304480e-02f, -1.22719863e-02f, 2.82642301e-02f, 1.64157227e-02f, 3.97732966e-02f,
  -9.52696148e-03f, 3.42701504e-04f, 9.98861939e-02f, -2.37617213e-02f, 2.48053204e-02f, -8.91317893e-03f, -1.28087746e-02f, 9.02139675e-03f, 9.60000828e-02f, -9.31589492e-03f,
  -1.47633208e-02f, 4.20421176e-02f, -1.74544901e-02f, -2.42372639e-02f, -2.47025825e-02f, -3.24663031e-03f, -9.89605114e-03f, 3.74602824e-02f, -1.36901224e-02f, -7.06707314e-02f,
  4.42954786e-02f, -8.31570476e-02f, -4.59288508e-02f, 1.55940838e-02f, 2.28874926e-02f, 3.75913951e-04f, -2.11689547e-02f, 5.57406666e-03f, -2.92445309e-02f, -3.96336168e-02f,
  -3.29619646e-02f, 4.43132222e-03f, 3.69467627e-04f, -1.69042405e-02f, -2.55328063e-02f, -1.07968766e-02f, 1.82600059e-02f, 4.66851480e-02f, 2.73831058e-02f, 1.00378320e-02f,
  -5.97165413e-02f, 1.79887619e-02f, 2.74993498e-02f, -1.51032712e-02f, 5.46926521e-02f, -2.97019240e-02f, 4.29967642e-02f, 1.49621652e-03f, -6.50244998e-03f, -9.89031978e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.90678090e-01f, 1.93058923e-01f, 1.70217976e-01f, 2.94832349e-01f, 1.39785573e-01f, 1.98607728e-01f, 1.53226137e-01f, 4.54339124e-02f, 1.70411080e-01f, 3.30294758e-01f,
  5.22076525e-02f, 2.76170641e-01f, 1.22185253e-01f, 1.90249979e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.49648800e-01f, -4.61607091e-02f, 1.52705401e-01f, 1.81877151e-01f, -9.32428986e-02f, 1.34178862e-01f, -1.88029967e-02f, -1.11431137e-01f, -1.83859557e-01f, 2.60204107e-01f,
  -3.66459578e-01f, 5.58539331e-01f, 2.96097964e-01f, 1.46051675e-01f, -9.26420838e-02f, -3.23874861e-01f, -1.58391789e-01f, -2.35301882e-01f, -2.62989044e-01f, -1.59823045e-01f,
  1.41402900e-01f, 2.66718030e-01f, -1.27200156e-01f, 1.01771876e-01f, -7.32409880e-02f, -4.04889695e-02f, -2.25314288e-03f, -2.18677670e-01f, -1.39931962e-01f, -1.10377029e-01f,
  8.01280215e-02f, -4.76746745e-02f, -2.27929950e-02f, -1.06382631e-01f, -3.03179473e-01f, -2.57733539e-02f, 1.51106402e-01f, -1.09305263e-01f, 4.06599119e-02f, 2.64660805e-01f,
  2.37242281e-01f, 2.31167272e-01f, -5.33006728e-01f, 3.33994061e-01f, -2.56125659e-01f, 1.65844262e-01f, 1.81110114e-01f, -4.48181033e-02f, 2.40770921e-01f, 2.28512064e-01f,
  -1.65624395e-01f, 3.36263865e-01f, -1.81318820e-01f, 3.46900411e-02f, -1.45138666e-01f, 2.20323205e-02f, 1.52380630e-01f, -2.77455658e-01f, -1.68958437e-02f, -1.38336331e-01f,
  5.11947609e-02f, 2.88565993e-01f, -1.30854696e-01f, -2.65589297e-01f, -4.07905340e-01f, -1.93236306e-01f, -1.52623028e-01f, -4.05933795e-04f, 9.80409533e-02f, -3.51045877e-01f,
  1.16223164e-01f, -2.48932809e-01f, -1.70238942e-01f, -2.09571227e-01f, -4.08359736e-01f, 1.98747739e-01f, -1.85503215e-01f, -5.97897410e-01f, -3.65573645e-01f, 5.43373339e-02f,
  -2.38249600e-01f, 1.18518613e-01f, 9.84455943e-02f, 1.39976591e-01f, -1.22469421e-02f, -1.38540283e-01f, -2.35712081e-01f, -1.02974847e-01f, 2.60541528e-01f, 1.14027381e-01f,
  3.81517500e-01f, -2.06596941e-01f, -6.27431348e-02f, -5.58367297e-02f, -1.13087893e-01f, 8.78750905e-02f, -7.75131583e-02f, -7.06743598e-02f, -1.14384085e-01f, 2.90797092e-02f,
  1.49563849e-01f, -2.24152297e-01f, -7.85532072e-02f, 4.00350764e-02f, -1.36518121e-01f, -4.40614671e-01f, 8.40038732e-02f, -3.12472910e-01f, -5.03379037e-04f, 1.23297177e-01f,
  6.25954270e-01f, -8.36267620e-02f, 4.31905806e-01f, -1.07511722e-01f, 8.73609483e-02f, 1.49495572e-01f, -2.73451477e-01f, 1.20643437e-01f, 6.59477711e-02f, -1.58733353e-01f,
  -2.02910721e-01f, -4.50222753e-02f, -4.23079962e-03f, -1.05310909e-01f, -6.42106533e-02f, 2.58413732e-01f, 6.07515909e-02f, -1.88134257e-02f, -2.79733539e-01f, 2.69276053e-01f,
  -8.71341228e-02f, -2.50961423e-01f, 1.68280631e-01f, -2.17760392e-02f, -6.42309114e-02f, 9.87708122e-02f, 2.55752772e-01f, -3.04965615e-01f, 2.70937830e-01f, -3.37107182e-01f,
  -5.30581534e-01f, -2.48163983e-01f, -6.49762899e-02f, -1.77513614e-01f, -3.34395498e-01f, -1.60966679e-01f, 1.54955819e-01f, 3.06874186e-01f, -7.46216811e-03f, -3.06357801e-01f,
  -2.89068997e-01f, -1.08572863e-01f, 1.43694192e-01f, 2.20718067e-02f, 2.40940720e-01f, 1.85172617e-01f, -2.29947120e-02f, -3.80644619e-01f, 3.19777131e-02f, -1.65087387e-01f,
  -3.95965308e-01f, -5.06171472e-02f, -9.05578583e-02f, 4.42172326e-02f, -1.37523815e-01f, -9.56616476e-02f, 6.05202429e-02f, -3.70360523e-01f, -2.61263281e-01f, -4.62159157e-01f,
  -2.00435847e-01f, -3.55293751e-01f, -1.13840058e-01f, -1.15569189e-01f, -2.29520462e-02f, 2.59471983e-01f, -2.44249195e-01f, -8.44875872e-02f, 3.14835966e-01f, 1.74119025e-01f,
  6.21436164e-03f, 2.05815304e-02f, -2.25517541e-01f, 1.94314256e-01f, -2.37122819e-01f, 2.29776666e-01f, 7.08679035e-02f, -2.35639721e-01f, -1.94874719e-01f, 1.76255509e-01f,
  1.48473591e-01f, -7.10158646e-02f, 1.23310953e-01f, 1.55664474e-01f, -3.64012986e-01f, -1.67652324e-01f, -2.31210351e-01f, -2.14337617e-01f, 3.30912471e-02f, -1.49835989e-01f,
  7.14622736e-02f, 3.06396782e-01f, -3.95688474e-01f, -2.05075905e-01f, 2.65820354e-01f, -1.11343265e-01f, -4.52521235e-01f, 1.40529916e-01f, -5.02254546e-01f, -8.49463940e-02f,
  5.52299209e-02f, -9.62961987e-02f, 1.29450858e-01f, -2.05165446e-02f, -2.55668700e-01f, 1.76053956e-01f, 2.76373416e-01f, -7.18787685e-02f, 2.10077062e-01f, -2.20306486e-01f,
  1.05724640e-01f, -1.98039427e-01f, 1.47539964e-02f, -1.66531295e-01f, -2.79478043e-01f, 1.35609716e-01f, -1.89437687e-01f, -6.10598065e-02f, -1.14231922e-01f, -1.30853832e-01f,
  -2.85957810e-02f, 9.04405937e-02f, -1.62761897e-01f, 4.97949645e-02f, 2.47175861e-02f, 2.01142430e-01f, -1.49488524e-01f, -2.33450830e-01f, -3.64817172e-01f, -1.37194738e-01f,
  -9.87787321e-02f, -1.22588992e-01f, 6.37764707e-02f, 2.37505957e-01f, 8.38081539e-02f, 7.02622086e-02f, -2.86652386e-01f, -2.70691782e-01f, 2.93544054e-01f, -2.77369529e-01f,
  -2.82497078e-01f, 3.00735664e-02f, 8.53792485e-03f, -3.84355150e-02f, 1.03167050e-01f, -1.45741478e-01f, -1.20549962e-01f, -1.38607681e-01f, -4.54768203e-02f, -7.63762519e-02f,
  5.82688255e-03f, 8.25881734e-02f, -2.85007685e-01f, -9.68278125e-02f, -6.39035478e-02f, -7.04121366e-02f, -2.64306784e-01f, -2.66300440e-01f, 4.00435776e-01f, 3.20909142e-01f,
  2.61289835e-01f, 9.72129181e-02f, 1.49259090e-01f, -3.10667664e-01f, -3.23147066e-02f, -1.24080501e-01f, -1.44576624e-01f, 3.91740322e-01f, -2.43087888e-01f, 8.47641006e-02f,
  -3.15387338e-01f, 5.87455556e-02f, 2.23671317e-01f, -8.15551430e-02f, 9.43793431e-02f, 2.58488387e-01f, 1.74356043e-01f, -2.10501194e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.48633495e-01f, 3.60498130e-02f, -7.28403851e-02f, 2.22470820e-01f, 6.11382946e-02f, -1.15400299e-01f, 1.91074684e-01f, 6.73403591e-02f, -4.38424274e-02f, 8.25488120e-02f,
  2.15492234e-01f, -1.21625334e-01f, 2.41873398e-01f, -1.63631633e-01f, 1.04143932e-01f, -1.30438998e-01f, -2.19614506e-01f, -1.83637857e-01f, 2.12547243e-01f, -9.45134461e-02f,
  3.47224884e-02f, 8.19283277e-02f, -8.68037865e-02f, 1.81504730e-02f, -5.95697686e-02f, 8.90113879e-03f, -6.97718263e-02f, 4.94675115e-02f, 1.54413730e-01f, -1.72828257e-01f,
  5.04519679e-02f, -7.80397281e-02f, 4.09422755e-01f, 2.97367990e-01f, 2.35547144e-02f, 6.31647781e-02f, 2.24287361e-01f, 3.61903757e-01f, -9.36675817e-02f, 4.96619910e-01f,
  6.13281906e-01f, 5.69226980e-01f, -4.01138097e-01f, 7.17238426e-01f, 1.11672610e-01f, 4.00848240e-01f, -1.26469538e-01f, -2.86463201e-01f, -2.83334285e-01f, 2.33793169e-01f,
  -4.59578156e-01f, 1.67553857e-01f, 1.69423416e-01f, 2.46122360e-01f, -1.58934996e-01f, -1.95281833e-01f, 4.15651500e-01f, 1.93986312e-01f, -1.61906958e-01f, -1.04149491e-01f,
  -2.53447801e-01f, 9.26553607e-02f, 4.02707875e-01f, -1.37200385e-01f, 2.74667978e-01f, 2.74008930e-01f, 1.27616435e-01f, 7.89857432e-02f, 2.93259829e-01f, 2.82462329e-01f,
  2.67481238e-01f, 3.44905376e-01f, 9.86427963e-02f, 3.56498897e-01f, 4.22834724e-01f, -4.76141602e-01f, 2.67845601e-01f, 1.54207632e-01f, 4.57650036e-01f, -4.26214904e-01f,
  -2.24900305e-01f, -6.95074797e-01f, 4.36391011e-02f, 1.53202534e-01f, 2.54823893e-01f, 1.47064971e-02f, -5.13076596e-02f, 1.22239450e-02f, -4.23075333e-02f, -2.58581311e-01f,
  -2.06272617e-01f, -1.63305961e-02f, 3.37620348e-01f, -3.20743024e-01f, 6.13821037e-02f, -8.85638073e-02f, 3.35713148e-01f, -9.09703821e-02f, -5.19985631e-02f, 2.91892618e-01f,
  4.28809345e-01f, 3.75152409e-01f, 4.08034533e-01f, 4.69741464e-01f, 4.47732270e-01f, -1.44311279e-01f, -1.97642922e-01f, -5.53204060e-01f, 2.31729329e-01f, 2.14867696e-01f,
  1.96192369e-01f, 5.99146485e-01f, 6.11674249e-01f, 1.94226742e-01f, 2.06655055e-01f, -1.82579637e-01f, -3.50292206e-01f, 9.62090269e-02f, 2.81884700e-01f, 3.87283385e-01f,
  -1.94264442e-01f, -6.39765710e-02f, 4.55810547e-01f, 2.68573970e-01f, 2.09546983e-01f, 5.19444227e-01f, -2.30984285e-01f, -8.60650241e-02f, -4.75474715e-01f, -1.09641753e-01f,
  2.40813181e-01f, 2.08695173e-01f, 2.08197460e-01f, -2.68030554e-01f, 2.71898776e-01f, 9.24592912e-02f, -2.44036481e-01f, -4.16724116e-01f, 6.49019927e-02f, 8.37755278e-02f,
  -3.95789176e-01f, -4.16502446e-01f, 1.17959663e-01f, 1.04651712e-02f, 4.67058234e-02f, 4.38588150e-02f, -1.93988010e-02f, 6.43353760e-02f, 1.23724937e-01f, 2.13818938e-01f,
  2.74178274e-02f, -1.61043495e-01f, 1.81473717e-02f, 3.81444953e-02f, 1.84223399e-01f, 9.44484323e-02f, 2.34686404e-01f, 4.00604337e-01f, -1.37580663e-01f, 1.85776189e-01f,
  1.00305580e-01f, -1.65291965e-01f, 4.61428612e-01f, 1.85281977e-01f, 3.87626290e-01f, 2.43522972e-01f, 4.03309055e-02f, 1.96194738e-01f, 1.58570260e-02f, -1.42081216e-01f,
  5.79550207e-01f, 2.78667152e-01f, -3.44382636e-02f, -3.74667346e-01f, 5.91407344e-02f, 5.73108941e-02f, 2.67467469e-01f, 2.41192907e-01f, -4.49712500e-02f, -1.20737888e-01f,
  -8.72359127e-02f, 2.10594282e-01f, 2.21254319e-01f, 2.03432962e-01f, -1.32464692e-01f, 8.63038935e-03f, 1.55823529e-01f, 4.17025596e-01f, 1.67449698e-01f, -1.77789658e-01f,
  4.69088890e-02f, 3.07018638e-01f, 2.11839154e-01f, 9.11079198e-02f, -1.53423194e-02f, 9.65383500e-02f, 3.82739268e-02f, 9.24639553e-02f, 2.39850488e-02f, 3.12810123e-01f,
  1.42179459e-01f, 1.00185156e-01f, 5.08603528e-02f, 5.96536517e-01f, -2.11772770e-02f, -1.35881230e-01f, -4.02550429e-01f, -6.50337636e-02f, 7.95473754e-02f, 2.39406362e-01f,
  -1.97249725e-01f, 8.12025741e-02f, 1.58317000e-01f, -4.21384862e-03f, 3.34598094e-01f, 2.00911701e-01f, 2.88030088e-01f, -7.92982280e-02f, -1.90825745e-01f, 8.11116397e-02f,
  4.59492132e-02f, -8.77240077e-02f, 1.63450018e-01f, 3.65182817e-01f, 1.00678891e-01f, -2.38578562e-02f, -1.29429638e-01f, -1.31044790e-01f, -7.74312094e-02f, -4.12419960e-02f,
  1.29349306e-01f, 2.27794975e-01f, -7.99473934e-03f, 7.32348189e-02f, 1.19836353e-01f, -1.81478485e-01f, 2.48858370e-02f, 2.90233254e-01f, -5.96970990e-02f, 1.23240791e-01f,
  -1.79020241e-01f, -1.90625697e-01f, -1.09632038e-01f, 1.74258530e-01f, -1.91799402e-01f, -1.62094176e-01f, -1.93096504e-01f, -1.12133011e-01f, -5.06494418e-02f, -1.74564362e-01f,
  -2.01088801e-01f, 3.19595426e-01f, -3.82279940e-02f, -9.67987627e-02f, -1.68273225e-01f, 2.62357742e-02f, -6.59778491e-02f, 2.60727871e-02f, -3.25630195e-02f, -2.44609062e-02f,
  -2.13297113e-04f, 1.68598235e-01f, 8.87234956e-02f, -8.37151557e-02f, -1.03183083e-01f, -4.23982814e-02f, 9.76235196e-02f, 2.83596907e-02f, -1.60108626e-01f, 1.99007347e-01f,
  8.92895907e-02f, 1.79362506e-01f, 1.77863255e-01f, 1.38913587e-01f, -8.79957452e-02f, 1.09985933e-01f, -1.60523862e-01f, -4.76371571e-02f, -4.14817743e-02f, 2.16297776e-01f,
  6.07980937e-02f, -9.63605121e-02f, -1.19959274e-02f, 1.43704221e-01f, 3.75912450e-02f, -7.94542059e-02f, -1.26613319e-01f, -6.63992539e-02f, -3.72971594e-02f, -4.65597585e-02f,
  -6.85272887e-02f, 5.95966987e-02f, 2.25239694e-01f, 2.64707208e-01f, 1.89495772e-01f, 1.47657037e-01f, 2.29226407e-02f, 1.50820985e-01f, -2.77957380e-01f, 3.21506143e-01f,
  1.25905618e-01f, -1.90617099e-01f, -2.64719009e-01f, 8.65120739e-02f, 1.32469878e-01f, 1.51905760e-01f, 9.22881067e-02f, -8.14538449e-02f, -9.30881351e-02f, -6.31157532e-02f,
  1.30134910e-01f, 3.49766552e-01f, -4.13352065e-02f, 1.90267384e-01f, 7.97755048e-02f, 7.30235204e-02f, 4.76450287e-02f, -1.65937260e-01f, -1.35654256e-01f, -5.37441038e-02f,
  3.16309929e-01f, 4.20187026e-01f, 3.28554571e-01f, 2.43121043e-01f, 1.95340484e-01f, 2.03610002e-03f, 9.08681974e-02f, 5.45749404e-02f, -1.93770319e-01f, 2.85765409e-01f,
  4.70103741e-01f, -9.20415521e-02f, -2.77700778e-02f, -1.88788801e-01f, -1.47777334e-01f, -2.97313273e-01f, -4.58758622e-01f, -5.99221110e-01f, 2.15082899e-01f, -1.00002766e-01f,
  6.62561417e-01f, 6.58902004e-02f, 1.70587793e-01f, -7.93727934e-02f, -1.23548329e-01f, 1.58117697e-01f, -1.21509850e-01f, -4.44168337e-02f, -1.61260776e-02f, -1.67397588e-01f,
  -8.43008086e-02f, 9.93732810e-02f, 8.00177455e-02f, 4.42745209e-01f, 1.13928122e-02f, 1.38148367e-01f, -2.52001226e-01f, 2.42090493e-01f, 4.67351452e-02f, 1.32458866e-01f,
  2.23862350e-01f, -1.20293707e-01f, -4.14109379e-01f, 2.63048913e-02f, 3.21874678e-01f, 4.79860872e-01f, 2.63901651e-01f, -2.21694097e-01f, -2.90739499e-02f, -1.19608983e-01f,
  1.93197146e-01f, 6.41446114e-02f, -7.59854019e-02f, 9.23103869e-01f, -1.79857284e-01f, 1.20269418e-01f, -2.89362609e-01f, 3.22710961e-01f, 1.50184929e-01f, -2.12486520e-01f,
  -1.97665840e-01f, 4.19812858e-01f, 4.00445938e-01f, -2.27942899e-01f, -1.74381107e-01f, -5.28543293e-02f, -1.31742671e-01f, 2.22881421e-01f, -2.37927493e-02f, -1.02922566e-01f,
  1.04330115e-01f, 1.61459252e-01f, -7.84350708e-02f, 1.11594670e-01f, -3.61680299e-01f, -9.27865729e-02f, 2.53326399e-03f, -8.10489729e-02f, -3.27842534e-01f, 1.63975179e-01f,
  2.51137894e-02f, 1.15562521e-01f, 1.30890727e-01f, -7.48251379e-02f, 1.51605844e-01f, 5.44573218e-02f, -2.19427839e-01f, 4.15281236e-01f, 3.55636060e-01f, -2.57463602e-04f,
  5.00294864e-01f, -1.00532666e-01f, 1.38298655e-02f, 1.51621222e-01f, -5.00191525e-02f, -7.12123513e-02f, 1.09914772e-01f, 2.43342653e-01f, -3.65838856e-02f, -2.12185860e-01f,
  2.27320865e-01f, 1.81537941e-01f, 3.67044985e-01f, 2.35837325e-01f, 1.47018015e-01f, -9.21501294e-02f, 2.17896700e-01f, 1.05042011e-01f, -8.19651484e-01f, 2.71152735e-01f,
  3.14870685e-01f, -2.64488459e-01f, -3.06719303e-01f, -1.27092943e-01f, 2.47638002e-01f, 6.91972375e-01f, -2.86899973e-02f, -2.54582375e-01f, -1.46952793e-01f, 1.90630443e-02f,
  7.22298585e-03f, 9.78565961e-02f, -1.08319834e-01f, 5.52881598e-01f, -8.17489475e-02f, 2.18820363e-01f, -3.97897623e-02f, -2.35633880e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -6.69922680e-02f, 3.16917419e-01f, 2.98432052e-01f, 4.08460140e-01f, 2.66178101e-01f, 7.72083625e-02f, 2.10998610e-01f, 4.52193916e-02f, -8.22176710e-02f, 8.41032863e-02f,
  3.53362143e-01f, 5.61342984e-02f, 2.74830759e-01f, 3.45107764e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -6.81676447e-01f, 1.45593062e-01f, -1.30741134e-01f, 1.68432921e-01f, -1.92033544e-01f, 1.00049935e-01f, 2.81766623e-01f, -8.81001726e-02f, 8.85171890e-02f, 4.22469139e-01f,
  -7.60273123e-03f, -2.04894453e-01f, -1.78566545e-01f, -2.91040421e-01f, -1.32231310e-01f, 8.81199241e-02f, 3.41214240e-01f, 5.61513245e-01f, 8.99307504e-02f, 5.63190281e-01f,
  2.27104470e-01f, -9.03202474e-01f, -3.14252041e-02f, -1.19754031e-01f, 9.42911282e-02f, 2.83594541e-02f, -1.36345103e-01f, -2.08704859e-01f, 1.08793333e-01f, 8.07029665e-01f,
  5.45721315e-03f, -2.78870493e-01f, 2.42764428e-01f, 6.57587126e-02f, -3.36530358e-01f, -1.92186646e-02f, -2.43799239e-01f, 2.31917009e-01f, 1.97650120e-01f, -3.11895847e-01f,
  -4.51777726e-01f, 1.56925648e-01f, 1.22257076e-01f, -3.40170294e-01f, 6.14032447e-01f, -6.54187500e-01f, 8.10391158e-02f, -2.42218480e-01f, -2.76682109e-01f, 3.97833228e-01f,
  -1.50245577e-02f, 3.45614880e-01f, -2.27446005e-01f, 5.72561264e-01f, -3.11718106e-01f, -2.83176959e-01f, -2.79617608e-01f, -7.50603005e-02f, 9.53977406e-02f, -2.98112392e-01f,
  -3.64030600e-01f, 7.57611811e-01f, -2.89060652e-01f, -2.93788850e-01f, -5.09951822e-03f, -3.36703300e-01f, 3.34992200e-01f, -4.61904824e-01f, 3.19861323e-01f, -5.73240757e-01f,
  -1.75382465e-01f, -8.05154294e-02f, -7.21885189e-02f, -1.53555050e-01f, 6.00405812e-01f, 3.80934566e-01f, 4.77094054e-01f, -2.30960801e-01f, 6.42717361e-01f, -6.55812025e-01f,
  -2.66065300e-01f, 5.78486025e-01f, 4.71120924e-02f, -5.64045906e-01f, -4.21284497e-01f, 2.63791919e-01f, 4.83447492e-01f, -1.40802324e-01f, -5.32880276e-02f, 9.61496606e-02f,
  1.68217435e-01f, -1.56291887e-01f, -3.07107329e-01f, 4.22010541e-01f, 2.41928190e-01f, 3.69530499e-01f, 2.14004293e-01f, 1.22185178e-01f, -4.02303226e-02f, -1.78516507e-01f,
  3.73579383e-01f, -7.26332590e-02f, -6.34871244e-01f, -1.46669045e-01f, -3.31143707e-01f, 3.43457937e-01f, 3.75603259e-01f, 7.40345001e-01f, -4.34085995e-01f, 1.61480561e-01f,
  -4.72353846e-01f, 6.40021324e-01f, 5.26160181e-01f, -2.49745920e-01f, 3.23002227e-02f, 7.34591067e-01f, -1.52364209e-01f, -6.93859875e-01f, 7.41761327e-02f, -3.40321362e-01f,
  4.93277848e-01f, -2.85989661e-02f, -2.24473253e-01f, -3.84450541e-04f, -1.94704428e-01f, -4.47123230e-01f, 3.56346041e-01f, -4.03589278e-01f, 3.20843041e-01f, 1.33449405e-01f,
  3.29201669e-01f, 1.20202318e-01f, 4.35667150e-02f, -3.04896533e-01f, 3.04460883e-01f, 2.33031018e-03f, 3.68737206e-02f, 2.73554891e-01f, 1.13069743e-01f, -2.51818329e-01f,
  -4.51621860e-01f, 6.31961644e-01f, -1.77337881e-02f, -4.10753101e-01f, 3.92991453e-02f, -4.37193662e-01f, -8.55602399e-02f, 8.43523920e-01f, 8.24389085e-02f, -7.13251114e-01f,
  -6.72554821e-02f, 1.34633526e-01f, 2.19262600e-01f, 6.17208891e-03f, -1.65664747e-01f, -8.82427171e-02f, 1.76800340e-01f, -1.92633390e-01f, -3.25384021e-01f, 7.27100551e-01f,
  3.63024652e-01f, -2.65866462e-02f, -4.17631686e-01f, 2.81321079e-01f, 2.09957749e-01f, -8.65271911e-02f, 8.02752003e-02f, -1.80740841e-02f, 4.21745062e-01f, 2.54495144e-01f,
  -4.47012186e-01f, -1.67516828e-01f, 3.51599157e-01f, -3.56682569e-01f, -4.48341995e-01f, -5.22429287e-01f, -3.83835733e-01f, 2.72835076e-01f, 2.84983575e-01f, -3.57674092e-01f,
  1.01530516e+00f, 1.38276130e-01f, 3.03386617e-02f, 3.54947954e-01f, -2.94414163e-02f, -9.96193737e-02f, 7.71825686e-02f, -2.54771173e-01f, 3.98826480e-01f, -1.89741448e-01f,
  -2.46193275e-01f, -4.25393313e-01f, -4.94561493e-01f, 3.44175488e-01f, 4.07075882e-01f, -8.75777528e-02f, 8.43258947e-02f, 4.88637090e-01f, -6.34937465e-01f, 2.59265155e-01f,
  1.30396992e-01f, -5.81047416e-01f, 9.44948047e-02f, -1.02111690e-01f, 4.59508836e-01f, 6.26240730e-01f, 5.09112366e-02f, -3.82755756e-01f, 1.01267546e-01f, -2.55608648e-01f,
  -1.16442181e-01f, -5.79077840e-01f, -1.06076010e-01f, 3.16675693e-01f, 7.50834644e-01f, 4.49724704e-01f, -1.23935230e-01f, -5.92435636e-02f, 8.16367939e-02f, -2.35987112e-01f,
  -4.39039201e-01f, -5.98796070e-01f, -1.25474453e-01f, 3.95290405e-01f, 2.45594561e-01f, -3.32378775e-01f, 4.33471203e-01f, -9.62179080e-02f, 1.26727194e-01f, 1.59426525e-01f,
  6.43949956e-02f, 2.06198737e-01f, 1.84696153e-01f, 1.44022584e-01f, -6.65576577e-01f, 3.66054028e-01f, -4.04913545e-01f, 1.91419199e-01f, 3.62894088e-01f, 6.42398775e-01f,
  3.38693529e-01f, -3.64556760e-01f, 2.81076133e-01f, -6.10857785e-01f, 3.41270417e-01f, -4.64477032e-01f, 2.10196018e-01f, -2.88881183e-01f, -1.43729031e-01f, -1.36002585e-01f,
  3.15537304e-03f, -1.58960506e-01f, 9.95961130e-01f, -3.00797850e-01f, -2.42610443e-02f, 1.87447928e-02f, -5.07473350e-02f, -4.91228886e-02f, -3.22893262e-02f, 3.80040467e-01f,
  5.95665872e-02f, -5.49499750e-01f, 1.53241545e-01f, -3.24503809e-01f, 1.32904574e-02f, -1.30250916e-01f, -5.42439342e-01f, 5.69287121e-01f, -2.01777950e-01f, 5.62308133e-01f,
  5.75463176e-01f, 5.09876370e-01f, -1.72665417e-01f, 5.08186817e-01f, -3.49658728e-02f, -3.63841623e-01f, -3.02863777e-01f, 6.18442476e-01f, -5.26434518e-02f, 4.99331132e-02f,
  -2.50701517e-01f, 6.37506768e-02f, -1.99048266e-01f, 2.31943429e-01f, -2.63530254e-01f, 1.96669713e-01f, 5.15861213e-01f, -3.41725945e-01f, -3.13655287e-01f, -1.24712572e-01f,
  -3.88792008e-01f, 8.53997767e-02f, -2.87063241e-01f, 1.56377792e-01f, 2.33872846e-01f, 7.26176724e-02f, 1.12799563e-01f, -5.54212809e-01f, 1.65712535e-01f, -5.09552419e-01f,
  5.23333848e-02f, 4.18279171e-01f, -1.60217151e-01f, -1.39384404e-01f, -1.96144842e-02f, -1.16884403e-01f, 2.19221637e-02f, -3.62396628e-01f, 7.21029639e-01f, 2.39325359e-01f,
  -5.24163246e-01f, -4.58827704e-01f, -3.48894835e-01f, 4.82761681e-01f, 1.82236955e-01f, -1.91921711e-01f, -9.26072896e-02f, -2.57333875e-01f, -9.06105787e-02f, 9.03135777e-01f,
  -1.05411308e-02f, -3.72992307e-01f, 3.83252978e-01f, 1.50882453e-01f, -3.41224998e-01f, 1.96563885e-01f, 4.09863651e-01f, 1.19508505e-01f, 2.50296265e-01f, 4.12456095e-01f,
  6.80172443e-01f, 2.03339949e-01f, -4.87984270e-01f, -5.12748003e-01f, -4.18520957e-01f, 3.50521505e-01f, -6.32661134e-02f, -9.04159527e-03f, -1.66993335e-01f, 3.88479471e-01f,
  -4.11735356e-01f, 6.47923470e-01f, -1.09173208e-01f, -1.82970241e-01f, 2.33791500e-01f, -1.78826407e-01f, 1.65486708e-01f, 4.30083454e-01f, -5.44512987e-01f, -3.35179240e-01f,
  2.78512776e-01f, -3.88383895e-01f, 1.81775764e-01f, 1.42329514e-01f, 7.44516551e-02f, 2.85953611e-01f, -1.29620671e-01f, -9.72452834e-02f, 9.31123830e-03f, -4.34466153e-02f,
  -5.24140894e-01f, -4.42115098e-01f, -4.17599231e-01f, -3.63720834e-01f, -4.34189379e-01f, -3.10417145e-01f, -5.27722657e-01f, -4.14316177e-01f, -3.84254038e-01f, -6.25292420e-01f,
  -1.18297540e-01f, -2.87115484e-01f, -3.90463024e-01f, 2.30963334e-01f, -6.69932291e-02f, 6.89211369e-01f, 7.03830957e-01f, 3.66231576e-02f, 2.20766112e-01f, 1.60707310e-01f,
  -1.14204973e-01f, -4.06109780e-01f, -2.06193209e-01f, -2.49202579e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -8.62474144e-02f, -1.29263729e-01f, -2.94826832e-02f, 1.25803813e-01f, 1.29871182e-02f, -1.28678679e-01f, -6.55106083e-02f, 1.28992572e-01f, -5.98028079e-02f, 5.45075871e-02f,
  -4.15040404e-02f, 2.33192649e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    