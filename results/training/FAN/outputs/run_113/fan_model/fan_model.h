/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.47039223e-01f, 7.21992925e-02f, -5.17421577e-04f, -3.26915592e-01f, -1.33210748e-01f, 1.84140548e-01f, 7.05983043e-02f, -1.66456178e-01f, -6.74341843e-02f, 1.51629746e-01f,
  -8.25087354e-02f, -9.47710574e-02f, 1.88026205e-01f, -6.62983283e-02f, -2.17963055e-01f, 1.13965020e-01f, -3.33959199e-02f, -6.89111790e-03f, 3.70155945e-02f, -6.22780025e-02f,
  -8.68472755e-02f, -9.49562788e-02f, -1.73597172e-01f, 8.76694098e-02f, -2.06047252e-01f, -8.02209303e-02f, 2.68426947e-02f, -1.78597625e-02f, -1.27602473e-01f, -3.65220457e-02f,
  -1.00658685e-01f, -8.57232064e-02f, -4.24614660e-02f, 4.86627817e-02f, -7.78307319e-02f, 2.70195473e-02f, -5.75106367e-02f, -3.77933085e-02f, -2.96451300e-02f, -5.55167608e-02f,
  2.34899065e-03f, -1.81746349e-01f, 5.99017404e-02f, 1.21239819e-01f, -1.31952679e-02f, -2.97282971e-02f, -1.12120070e-01f, -2.87922584e-02f, -5.28621078e-02f, -1.98260136e-02f,
  -2.87114531e-02f, -1.08385526e-01f, -2.35050404e-03f, -8.29658434e-02f, -4.03958149e-02f, 9.08885375e-02f, 1.02601364e-01f, 3.64620201e-02f, -1.42676130e-01f, -1.14934891e-01f,
  1.72001973e-03f, 8.78060088e-02f, -3.60337272e-02f, -7.09945932e-02f, 3.53373848e-02f, -1.60934385e-02f, 1.67133406e-01f, 4.04934362e-02f, 1.07682139e-01f, -5.69112487e-02f,
  -1.05539069e-01f, -4.86843064e-02f, 7.10831210e-02f, -2.83189062e-02f, 7.88270906e-02f, 3.60857770e-02f, 6.40139505e-02f, -1.34442121e-01f, -1.61381185e-01f, -9.41663012e-02f,
  -2.88975220e-02f, -9.37114470e-03f, -1.04360372e-01f, 1.17770638e-02f, -1.76365022e-02f, 4.38452046e-03f, 5.17804436e-02f, 7.29716718e-02f, 7.15191662e-02f, -5.93005726e-03f,
  -1.15078941e-01f, -6.32284135e-02f, 3.39010358e-02f, -1.21322490e-01f, 5.83481975e-02f, -4.78501245e-02f, 6.98815659e-02f, 5.15370071e-02f, -6.06354587e-02f, -3.78603116e-02f,
  2.32447479e-02f, 5.76188304e-02f, -1.35408878e-01f, 1.04068369e-01f, 4.38048355e-02f, 1.03705702e-02f, -6.42346740e-02f, -3.73741910e-02f, -6.43304288e-02f, 3.65836881e-02f,
  -4.26246673e-02f, 5.16770706e-02f, 1.20388838e-02f, -2.18417384e-02f, 6.63591400e-02f, 9.79955029e-03f, -2.97150575e-02f, 3.59420329e-02f, -4.11313474e-02f, -9.17859599e-02f,
  -3.37592721e-01f, 1.06234059e-01f, 2.64142659e-02f, 1.69566438e-01f, 6.16211779e-02f, 2.87003934e-01f, 2.24953473e-01f, 1.40534639e-01f, -1.27114668e-01f, 2.49805197e-01f,
  3.53269815e-01f, -1.42385721e-01f, 8.86792094e-02f, 2.54156083e-01f, 1.91825017e-01f, 2.55630642e-01f, 2.49939069e-01f, 3.70903052e-02f, -1.14641063e-01f, -1.12382531e-01f,
  -7.54218921e-02f, 2.37761557e-01f, 2.60878503e-01f, 1.19372860e-01f, 1.51028559e-01f, -8.75146315e-02f, 2.34411508e-01f, -1.20238073e-01f, 1.42422542e-01f, 1.02604859e-01f,
  -4.63999622e-02f, -1.66673765e-01f, -9.13638026e-02f, -1.29397601e-01f, 2.28414894e-03f, -5.08932620e-02f, -7.43725672e-02f, -4.18176763e-02f, -8.01299140e-03f, 3.18556912e-02f,
  3.65412002e-03f, -5.00658248e-03f, 5.66083333e-03f, 4.94192019e-02f, -7.25746080e-02f, 3.98871563e-02f, -3.20718698e-02f, 1.43242359e-01f, -2.28699427e-02f, 1.26288459e-01f,
  5.98343424e-02f, 8.84917304e-02f, 1.01971678e-01f, 1.07288733e-01f, 1.06201403e-01f, 1.54512510e-01f, 5.74866980e-02f, 7.36630857e-02f, 6.28352836e-02f, 5.17153218e-02f,
  6.79750741e-02f, -1.39377922e-01f, -9.95675698e-02f, -6.00637496e-02f, -1.08559124e-01f, 6.91929981e-02f, 4.25064899e-02f, 1.76378954e-02f, 9.87368822e-03f, 4.25859950e-02f,
  -8.31220150e-02f, -6.03116527e-02f, -5.11782095e-02f, -7.61300698e-02f, 3.43391187e-02f, -1.29279234e-02f, -2.21373979e-02f, 2.44436674e-02f, -6.56472147e-02f, 3.09500261e-04f,
  -1.28070682e-01f, -1.66039452e-01f, -1.09854102e-01f, 2.11755671e-02f, 1.92607790e-02f, 4.96176071e-02f, -5.20209894e-02f, 4.08570990e-02f, -1.01990834e-01f, 1.24595299e-01f,
  5.16423490e-03f, -1.60818219e-01f, -6.34233505e-02f, -8.16850886e-02f, -2.32664738e-02f, -5.27474955e-02f, -8.82160887e-02f, 1.02751730e-02f, 5.21044135e-02f, -1.04520999e-01f,
  6.38791770e-02f, -7.46366978e-02f, -1.10554276e-02f, 3.54287773e-02f, 5.07343858e-02f, 1.17863026e-02f, -7.41936117e-02f, 1.20331161e-02f, 5.75991161e-02f, 5.96735924e-02f,
  1.25528648e-01f, 9.81532335e-02f, 3.59433591e-02f, 1.44740149e-01f, 7.42367208e-02f, 1.38526201e-01f, 3.97078432e-02f, -3.03624161e-02f, 6.02236018e-02f, 1.11057535e-01f,
  -2.43607551e-01f, 4.29767258e-02f, 5.79949794e-03f, -1.92910522e-01f, -2.89738197e-02f, -9.94869247e-02f, -9.64550301e-02f, -1.09557785e-01f, -1.91906244e-01f, 5.71426041e-02f,
  5.62723447e-03f, 7.58479163e-02f, 8.04275796e-02f, -1.04155160e-01f, -2.92150557e-01f, 8.58080238e-02f, -2.80957311e-01f, -6.74140500e-03f, -1.28457258e-02f, -2.89434940e-01f,
  -9.94722545e-02f, -1.09510958e-01f, 5.09010255e-02f, -3.11064608e-02f, -3.46400542e-03f, 1.59876481e-01f, -3.36337015e-02f, 1.93936378e-01f, 5.60528710e-02f, 6.04546741e-02f,
  -1.02239333e-01f, -1.71086062e-02f, 1.16100907e-01f, 7.13433549e-02f, -1.23982728e-01f, 3.33798006e-02f, 2.90389284e-02f, 6.51516765e-02f, 1.40074313e-01f, 5.11348099e-02f,
  9.76803526e-02f, -2.35162415e-02f, -5.61000556e-02f, 6.61236867e-02f, 4.97914711e-03f, 7.42564797e-02f, 9.07155052e-02f, 1.22253445e-03f, 3.92196700e-02f, -5.54373488e-02f,
  1.07372329e-01f, 1.44401127e-02f, 3.97638194e-02f, 1.76263917e-02f, 1.06626801e-01f, -5.95848076e-02f, -5.53321689e-02f, -1.36165647e-02f, 3.55504453e-02f, -8.04628655e-02f,
  8.89912397e-02f, -1.06300168e-01f, 4.76439893e-02f, -8.62841606e-02f, -4.01875935e-02f, -6.91225752e-03f, -2.84420196e-02f, 1.18592719e-03f, -3.69988456e-02f, 6.40910235e-04f,
  -1.27920136e-01f, 1.95232406e-02f, -7.05225095e-02f, -1.71360690e-02f, -2.39379574e-02f, -7.97771141e-02f, -2.25961059e-02f, 1.51475310e-01f, -7.39228874e-02f, -3.90823893e-02f,
  -2.62330789e-02f, -1.21894933e-01f, -4.82907705e-02f, 3.71803418e-02f, 1.16449241e-02f, 1.00452732e-02f, 2.33774763e-02f, 4.55270745e-02f, -4.09782343e-02f, 5.60214370e-02f,
  -2.12944865e-01f, -2.30106384e-01f, 5.35432808e-02f, 7.07309842e-02f, 3.49611938e-02f, 8.26521590e-02f, -5.91563173e-02f, 8.30968097e-02f, 7.73734227e-02f, -1.37325283e-03f,
  1.13414064e-01f, -1.02306753e-01f, -1.03701696e-01f, -4.63586859e-02f, -7.96960220e-02f, -6.16077632e-02f, -4.39458713e-02f, 4.50499868e-03f, -7.41783082e-02f, -6.42846078e-02f,
  6.37673065e-02f, -4.30555157e-02f, 5.42746596e-02f, -1.68750715e-02f, 4.81400825e-02f, 7.75251165e-03f, -1.11936852e-01f, 4.60786521e-02f, 9.19697285e-02f, 2.38837581e-02f,
  -8.27598665e-03f, 2.45100334e-01f, 1.28961399e-01f, -1.11908317e-01f, -1.58303771e-02f, -1.48501739e-01f, 1.72300324e-01f, 3.08962408e-02f, -3.05085126e-02f, 5.97124062e-02f,
  -1.01489268e-01f, 2.72063792e-01f, 5.74984141e-02f, -2.33147904e-01f, -1.24813810e-01f, -5.93255535e-02f, -1.02632508e-01f, 5.11006825e-02f, 5.71756586e-02f, 5.33613143e-04f,
  -6.23525381e-02f, -2.15190962e-01f, -2.22807545e-02f, 3.33435163e-02f, 2.05327552e-02f, 1.11836001e-01f, -1.44703150e-01f, 1.30626708e-01f, -9.08884332e-02f, 1.05167650e-01f,
  1.65231712e-02f, -4.51987460e-02f, 1.29419431e-01f, -5.45907728e-02f, -7.72121772e-02f, -5.95727861e-02f, 7.97715113e-02f, 3.17904688e-02f, -3.82383540e-02f, -6.82553798e-02f,
  5.61586879e-02f, -9.31469351e-02f, 1.32306619e-02f, 8.00675750e-02f, 6.32511526e-02f, 2.35067606e-02f, -3.13524269e-02f, 1.58246215e-02f, 1.93123445e-02f, 9.13707837e-02f,
  -5.23227034e-03f, 2.50221640e-02f, -5.40684685e-02f, 4.94887494e-02f, -1.39475809e-02f, 1.77672822e-02f, 9.50660333e-02f, 1.12253062e-01f, 1.52448460e-03f, 1.77366119e-02f,
  -5.80165125e-02f, 7.03184530e-02f, 6.29902631e-02f, 3.38343941e-02f, -3.75203528e-02f, 9.28987097e-03f, 6.84657600e-03f, 2.05108654e-02f, 1.00309283e-01f, 4.33956496e-02f,
  -1.02340087e-01f, 1.37993068e-01f, 7.89634883e-02f, -5.29729128e-02f, 1.18916743e-01f, 5.87244555e-02f, 1.69201139e-02f, 4.60213646e-02f, -5.81877977e-02f, -2.31362283e-02f,
  -2.94534415e-02f, -1.14328310e-01f, 5.19381315e-02f, 2.63824984e-02f, 6.95246756e-02f, 2.56744102e-02f, -2.82114651e-02f, 2.46028807e-02f, 2.27205046e-02f, -7.75247887e-02f,
  -1.31261215e-01f, -6.54718876e-02f, 9.86489132e-02f, -2.58358265e-03f, 7.27954432e-02f, -1.03917658e-01f, -7.61133572e-03f, 4.11928222e-02f, -1.19253278e-01f, -1.58029437e-01f,
  -5.84637560e-02f, 2.46131420e-02f, -6.64804131e-02f, 2.12717801e-02f, 1.32491738e-01f, -2.20189523e-02f, -4.25069071e-02f, 7.62823746e-02f, 7.32169822e-02f, 1.03496477e-01f,
  -7.56005347e-02f, 4.63574417e-02f, 7.90321007e-02f, 2.02302802e-02f, 1.76889617e-02f, 2.84108371e-02f, 9.22320783e-02f, -4.63323966e-02f, -7.74052292e-02f, -3.70115489e-02f,
  3.00379723e-01f, 3.50845218e-01f, -3.54808159e-02f, 1.20293133e-01f, -7.00878948e-02f, 3.03895539e-03f, 1.76631749e-01f, -2.54536476e-02f, 1.16324328e-01f, 1.17473863e-01f,
  -1.08888664e-04f, 1.39468670e-01f, -7.76291639e-02f, 1.13820046e-01f, -2.15302348e-01f, -1.31625906e-01f, 6.39326721e-02f, 1.33575320e-01f, -7.08666369e-02f, 1.17277965e-01f,
  -1.70531809e-01f, -7.31498152e-02f, -2.00762108e-01f, -4.22132425e-02f, 7.14640096e-02f, -3.55288684e-02f, -1.84041321e-01f, -1.94737405e-01f, -8.86286795e-03f, -4.68534455e-02f,
  1.68248981e-01f, 7.98898339e-02f, -6.95422739e-02f, -2.19518375e-02f, -2.80590244e-02f, -1.32202536e-01f, -3.63981649e-02f, -5.34875542e-02f, -7.67478645e-02f, -6.91288859e-02f,
  1.07437670e-02f, 1.68604534e-02f, 2.68048644e-02f, 1.86485145e-02f, 1.01921484e-01f, 5.24735339e-02f, -1.89211307e-04f, -2.75594480e-02f, 7.71673173e-02f, -4.60927039e-02f,
  -2.17737444e-02f, 3.09668332e-02f, -1.00828279e-02f, 2.34421305e-02f, -3.29523012e-02f, 4.33116443e-02f, -8.01167712e-02f, 1.26093598e-02f, -4.66900691e-02f, -2.36076973e-02f,
  -5.91055378e-02f, -5.38124144e-02f, -4.05882634e-02f, 1.02276586e-01f, 4.36238758e-02f, -1.13926893e-02f, 7.05833063e-02f, 3.35142575e-02f, 2.19094977e-02f, 5.48166633e-02f,
  5.98817505e-02f, 8.89885575e-02f, 7.57695585e-02f, 4.64180745e-02f, -4.08074856e-02f, 9.69682112e-02f, 5.83996847e-02f, 4.27109702e-03f, -1.84986144e-02f, -1.19644612e-01f,
  2.88370065e-02f, 2.71572126e-03f, 9.39519927e-02f, 9.02237296e-02f, -1.11241695e-02f, -2.59472057e-02f, -2.61401702e-02f, 4.80406471e-02f, -5.18721417e-02f, -8.16120133e-02f,
  2.22080156e-01f, 6.93422705e-02f, 3.89566645e-02f, 5.78217357e-02f, -1.95561070e-02f, -1.30447626e-01f, 7.92187452e-03f, 3.16249169e-02f, -2.15877406e-03f, -3.53672616e-02f,
  -4.95584421e-02f, 1.99270174e-02f, -5.47873341e-02f, 1.29637346e-01f, 9.40019265e-02f, -1.27260629e-02f, -1.95644032e-02f, 4.96356338e-02f, -3.23246196e-02f, 8.74733552e-02f,
  -4.25147004e-02f, 9.74187907e-03f, -9.06875730e-02f, -3.45926844e-02f, -4.81725261e-02f, -1.19979354e-02f, 8.72563720e-02f, -1.31006651e-02f, -7.23254383e-02f, -4.47154269e-02f,
  -1.59585401e-01f, 7.75607768e-03f, 2.20991895e-02f, -3.06513101e-01f, 1.59256995e-01f, 2.23322242e-01f, -2.36737803e-02f, 1.76180284e-02f, 7.21167913e-03f, -7.47070312e-02f,
  -1.05244786e-01f, -3.87640409e-02f, 1.25653461e-01f, -3.86909992e-01f, 1.37677789e-01f, -9.06495675e-02f, -2.71663189e-01f, -1.44216552e-01f, 1.08288251e-01f, -7.40799308e-02f,
  1.87074412e-02f, -1.32567093e-01f, -6.39965832e-02f, 2.11929873e-01f, -2.50774971e-03f, 1.31207667e-02f, 2.09821127e-02f, 1.02041550e-01f, -9.11155939e-02f, 1.16009608e-01f,
  -6.98779384e-03f, -1.69342503e-01f, -6.74134269e-02f, 3.73218805e-02f, -1.49948031e-01f, -7.65992049e-03f, 9.61310789e-03f, 3.51410694e-02f, 2.12584380e-02f, -2.53280122e-02f,
  -2.55598221e-02f, 9.11557749e-02f, -4.64862250e-02f, 1.85946710e-02f, 6.64197803e-02f, 3.78691331e-02f, -3.33969854e-02f, -3.82308736e-02f, 2.62695607e-02f, -6.43320056e-03f,
  -7.53305554e-02f, -6.21475913e-02f, -5.33901528e-02f, -4.70213220e-02f, 1.00459971e-01f, -8.01753625e-03f, 4.18467894e-02f, -1.51039502e-02f, -7.33697340e-02f, -6.30446747e-02f,
  -3.22768055e-02f, 3.93518694e-02f, -1.42467171e-02f, -4.79858369e-02f, 2.98164394e-02f, 2.85011157e-02f, 4.85312603e-02f, 4.32810448e-02f, 1.20682055e-02f, 4.33078408e-02f,
  -2.04362068e-02f, 1.55832935e-02f, 5.95982559e-02f, 3.76387760e-02f, 9.79875587e-03f, 1.67489157e-03f, 2.69942358e-02f, -2.38906331e-02f, -1.44159481e-01f, 1.33533012e-02f,
  -5.84631227e-02f, 8.25101584e-02f, -5.39666303e-02f, 2.64960378e-02f, 2.86117904e-02f, 7.50894099e-03f, 2.91210730e-02f, 2.33513652e-03f, 2.80544385e-02f, 3.66856083e-02f,
  -1.23057298e-01f, 7.28879403e-03f, -9.11250804e-03f, -2.06855815e-02f, 5.27338386e-02f, -2.25176755e-02f, 1.94346197e-02f, 2.38046963e-02f, 3.31218578e-02f, -3.64728309e-02f,
  -1.00538462e-01f, 7.32462704e-02f, -7.31373876e-02f, 4.38672416e-02f, -6.30213460e-03f, 3.78785320e-02f, -9.38944370e-02f, 7.94407651e-02f, -5.97298257e-02f, 1.34277999e-01f,
  -7.20153674e-02f, 1.10208556e-01f, -1.98701937e-02f, 7.52281025e-02f, 1.36911878e-02f, -2.41365712e-02f, 3.59660573e-02f, -3.60002704e-02f, -4.52905074e-02f, 1.50866648e-02f,
  1.31329417e-01f, 9.45596248e-02f, -2.21589670e-01f, 2.09762380e-01f, 2.11539030e-01f, -1.10551432e-01f, -1.06340431e-01f, 1.68870732e-01f, 1.95178408e-02f, 1.24236709e-02f,
  6.51699975e-02f, -2.35624701e-01f, -9.86643359e-02f, -1.37036517e-01f, -3.13725024e-01f, -2.19242632e-01f, -7.76086450e-02f, -9.02375653e-02f, -7.42126182e-02f, 3.19807716e-02f,
  -2.29967684e-02f, 1.62091851e-01f, -9.98283327e-02f, 2.97664672e-01f, 1.50627106e-01f, 8.88780504e-02f, 9.00171399e-02f, -3.65111455e-02f, 1.75455045e-02f, -5.31317219e-02f,
  9.51766670e-02f, 1.12556763e-01f, 3.76459584e-02f, -5.38249910e-02f, -5.71382092e-03f, -4.66536209e-02f, -3.56957465e-02f, -1.58588722e-01f, -1.53818548e-01f, -7.99398497e-02f,
  -9.92826298e-02f, 2.10032724e-02f, 5.58544025e-02f, -2.03846022e-02f, 5.52681647e-02f, 9.49628372e-03f, -7.31190294e-02f, -7.65531212e-02f, 2.03515068e-02f, 2.60949004e-02f,
  -8.79089162e-02f, -1.18649870e-01f, 2.01671086e-02f, -5.75431027e-02f, -5.24074323e-02f, -6.72064573e-02f, -4.85925525e-02f, -7.60289282e-02f, -3.93341221e-02f, 7.97166117e-03f,
  7.37775341e-02f, 1.94282010e-02f, -6.61655888e-02f, 1.67869683e-02f, 3.30194086e-02f, 4.20485437e-02f, -4.37920131e-02f, 4.64219274e-03f, 6.99716285e-02f, -2.66053225e-03f,
  -6.81091547e-02f, 1.06679842e-01f, 4.49379608e-02f, -7.67065510e-02f, -2.66128164e-02f, 4.24016379e-02f, -4.39469889e-02f, -7.49451853e-03f, -2.46937145e-02f, -2.77317315e-02f,
  5.80689777e-03f, 3.68709899e-02f, 5.43689765e-02f, 3.94146033e-02f, -8.58652592e-03f, -4.19797637e-02f, 7.31080323e-02f, 2.64418852e-02f, -6.39635623e-02f, 3.68156396e-02f,
  1.92576259e-01f, 2.26551116e-01f, 9.17901322e-02f, 9.89854410e-02f, -6.65616542e-02f, -7.28779808e-02f, -7.81118870e-02f, 8.76641925e-03f, -1.19791284e-01f, 5.41698560e-03f,
  -7.44677708e-02f, 7.89307132e-02f, 5.74353871e-05f, 8.85879472e-02f, -4.73684259e-02f, -2.02531577e-03f, -3.92067619e-02f, -2.27987804e-02f, 3.90701415e-03f, 1.03175893e-01f,
  7.58303329e-02f, 1.00350063e-02f, -6.99439719e-02f, 8.28227624e-02f, 4.69537042e-02f, 4.02331129e-02f, 9.61310267e-02f, 1.37501571e-04f, -9.80274752e-03f, -4.61661927e-02f,
  4.40325767e-01f, -1.08414009e-01f, 2.33783945e-01f, -5.11643961e-02f, -1.63583718e-02f, 4.16872725e-02f, -1.25639394e-01f, -1.77563384e-01f, 6.10488392e-02f, -3.97228271e-01f,
  -2.97178328e-01f, 6.57355711e-02f, -1.20495804e-01f, -3.61046433e-01f, 3.14107649e-02f, -4.04617563e-02f, -9.72644836e-02f, -1.54057732e-02f, -4.05739620e-02f, 1.43226637e-02f,
  2.19707802e-01f, -8.32859874e-02f, -1.08871378e-01f, -1.17550716e-01f, -1.08082168e-01f, -8.25755745e-02f, -1.99541032e-01f, -9.27964225e-02f, -1.24362066e-01f, -8.51031020e-02f,
  2.22649612e-02f, 1.98833812e-02f, 6.04631081e-02f, 6.64690929e-03f, 2.51578540e-02f, 8.78155902e-02f, 6.55981079e-02f, 9.19212401e-03f, -8.73763207e-03f, 5.32911047e-02f,
  7.25039095e-03f, -2.19272301e-02f, -6.48074150e-02f, 8.93049091e-02f, -1.17871407e-02f, -1.70110483e-02f, -9.35017783e-03f, 1.37688398e-01f, 2.48392634e-02f, 3.95586230e-02f,
  -3.11876200e-02f, 5.77843413e-02f, -2.28637550e-03f, 3.13617475e-02f, 3.26143466e-02f, -1.90671943e-02f, 9.66774579e-03f, 2.52249725e-02f, 1.21262945e-01f, -6.66642748e-03f,
  4.81032720e-03f, 7.76043460e-02f, 1.44402623e-01f, 7.92049617e-03f, 3.72129143e-03f, -6.62412792e-02f, 2.99329113e-04f, -8.87618810e-02f, -6.12100400e-02f, -5.50630279e-02f,
  -5.30939316e-03f, 3.92600484e-02f, -1.38145303e-02f, 1.10691600e-01f, -9.71558839e-02f, 1.71562638e-02f, 1.10881468e-02f, -1.45446241e-01f, -3.06390040e-02f, -5.70546240e-02f,
  -5.50463460e-02f, -5.75335994e-02f, -3.09642851e-02f, 4.23369929e-02f, 1.26344850e-02f, 1.36021838e-01f, 1.08889947e-02f, 7.57759623e-03f, -6.99564293e-02f, 1.71682239e-02f,
  -1.89293250e-01f, -1.49782568e-01f, -1.31233275e-01f, 7.07544014e-03f, -4.40797359e-02f, 9.03560966e-02f, -3.55823971e-02f, -4.93972190e-02f, -7.44161233e-02f, 8.80750176e-03f,
  7.15567730e-03f, -3.22307982e-02f, -8.17344040e-02f, 1.85052212e-03f, -7.65140057e-02f, 1.42950369e-02f, -6.74589500e-02f, -4.33990471e-02f, -5.44571765e-02f, -8.48405585e-02f,
  -1.48989754e-02f, -4.13524583e-02f, 7.20261484e-02f, 2.26912685e-02f, 2.52809899e-04f, -3.28104720e-02f, -1.25962114e-02f, -1.64344460e-02f, -1.36457924e-02f, -1.08071610e-01f,
  -6.39437586e-02f, 2.28745595e-01f, 7.09483251e-02f, 1.65854946e-01f, 1.51468873e-01f, -1.05964921e-01f, -7.60499761e-02f, 1.86843306e-01f, 1.63151249e-01f, 9.44336727e-02f,
  -5.16886935e-02f, 8.96094367e-02f, -1.64536953e-01f, -6.28941059e-02f, -3.02575052e-01f, -2.59076148e-01f, -1.22406863e-01f, -4.48766835e-02f, 1.60026789e-01f, 8.02099854e-02f,
  -1.54129982e-01f, -1.92257926e-01f, -1.73632994e-01f, 1.15621224e-01f, -9.14080162e-03f, 6.97817057e-02f, -7.66123086e-02f, -9.61805433e-02f, 4.43431213e-02f, -7.33180121e-02f,
  -1.79581881e-01f, -6.67946115e-02f, -6.48234636e-02f, -1.46172583e-01f, -1.38103560e-01f, -4.09470275e-02f, -1.20707758e-01f, -1.85486123e-01f, -3.63498703e-02f, -8.84848088e-03f,
  -1.64936632e-01f, -5.90142496e-02f, 2.37117609e-04f, 2.45896801e-02f, 7.55648315e-02f, 1.22763468e-02f, 9.51844174e-03f, -8.56458861e-03f, -1.00919222e-02f, 9.48778936e-04f,
  1.08030187e-02f, 5.57077816e-03f, 9.81842875e-02f, 9.27338377e-04f, -1.30743545e-03f, 5.70800155e-02f, 1.14649914e-01f, -5.85058704e-02f, 1.55258970e-02f, 9.72146168e-02f,
  -5.21874577e-02f, 3.33801471e-02f, 2.42641494e-02f, 5.16398288e-02f, 9.36508030e-02f, -2.51325350e-02f, 2.26101782e-02f, 3.61483470e-02f, 1.23582102e-01f, -4.91707660e-02f,
  -3.75023894e-02f, 5.05692437e-02f, -1.74493939e-02f, 4.30934578e-02f, 8.01755339e-02f, 1.36145771e-01f, -1.45580359e-02f, 2.71702241e-02f, -4.52783667e-02f, 1.66694783e-02f,
  -1.16622128e-01f, -1.01499818e-02f, -1.42556885e-02f, -3.61707956e-02f, -7.40984827e-02f, -2.27475036e-02f, -3.54779698e-02f, 3.38349678e-02f, 1.16667241e-01f, -2.62811873e-02f,
  -1.58579215e-01f, -7.13254064e-02f, -1.21687315e-01f, -4.96989042e-02f, -7.01467171e-02f, 7.52328485e-02f, -4.76251915e-02f, -1.02160171e-01f, -8.77671242e-02f, 5.99482330e-03f,
  -1.31282851e-01f, 4.56708483e-03f, 2.26153992e-02f, 8.75935797e-03f, -1.04874395e-01f, 2.28967573e-02f, -7.35901818e-02f, 4.90485355e-02f, -4.54373285e-02f, 1.55008301e-01f,
  -5.30891120e-02f, -1.44297564e-02f, 2.22780686e-02f, 1.38004854e-01f, 4.37936112e-02f, -1.26357796e-02f, 1.68841124e-01f, 1.15245497e-02f, -9.39035863e-02f, 7.54446164e-02f,
  -2.20911950e-01f, 9.61630642e-02f, -5.50864823e-02f, -2.21126825e-01f, -7.40414336e-02f, -2.00065840e-02f, 1.35462314e-01f, -1.53598696e-01f, -1.10696465e-01f, 1.09347418e-01f,
  -8.68218839e-02f, 7.60416314e-02f, 1.94008365e-01f, -8.94389525e-02f, -1.51409715e-01f, 1.20784201e-01f, -2.48982981e-01f, -1.83944758e-02f, 1.69550143e-02f, -6.02176711e-02f,
  -9.01208818e-02f, 3.48740577e-04f, -9.85968560e-02f, -2.13483293e-02f, -7.38773644e-02f, -7.64262397e-03f, -8.57096910e-03f, 1.02728151e-01f, -1.98998734e-01f, 7.91273564e-02f,
  -8.60581268e-03f, 6.95603564e-02f, 4.53996286e-02f, 1.52876288e-01f, -4.54615988e-02f, 1.78247783e-02f, 4.02268395e-02f, 6.21756725e-02f, -2.19570342e-02f, -1.92346536e-02f,
  6.57896325e-02f, -4.31102142e-02f, 1.38178738e-02f, 2.89858487e-02f, -1.40593201e-01f, -2.82994509e-02f, -7.22641423e-02f, -8.80636424e-02f, 5.94767556e-02f, -2.68889908e-02f,
  -1.13319242e-02f, -7.87841305e-02f, -1.24325968e-01f, -6.66838884e-02f, -6.44193515e-02f, -3.22601907e-02f, 4.77799885e-02f, 5.53408712e-02f, -4.01111580e-02f, -1.44565040e-02f,
  -2.33170930e-02f, 1.21456005e-01f, 5.81745915e-02f, 4.27528881e-02f, 9.87225324e-02f, 2.01855917e-02f, 3.36311422e-02f, 6.43393919e-02f, 4.41368856e-02f, 6.64110407e-02f,
  -1.14567958e-01f, -4.82404456e-02f, 6.23611510e-02f, -1.18844852e-01f, -3.91258188e-02f, -1.03597678e-02f, 2.88910717e-02f, 2.52287388e-02f, -1.72270775e-01f, -8.71778056e-02f,
  1.20598763e-01f, 1.45857111e-02f, 3.01679168e-02f, 3.54532376e-02f, 7.17468932e-02f, -2.79351361e-02f, 2.05935016e-02f, -7.28695318e-02f, -3.41518894e-02f, -8.19806904e-02f,
  4.21670713e-02f, 1.58848494e-01f, 9.23912823e-02f, 9.48977172e-02f, 1.18357547e-01f, -2.79130433e-02f, 1.13585599e-01f, -6.17868975e-02f, 1.16335768e-02f, -1.17853999e-01f,
  -3.84823158e-02f, 3.35082598e-02f, -2.21504681e-02f, 7.76033616e-03f, -3.55116129e-02f, 8.45723972e-02f, 8.41786042e-02f, -3.49658020e-02f, -1.27750263e-01f, -2.92886868e-02f,
  -5.35254441e-02f, 9.33468342e-02f, -2.38034036e-02f, -6.32306635e-02f, -9.90154129e-03f, -1.63746830e-02f, 2.60563530e-02f, -5.50453365e-02f, -1.90543924e-02f, -6.62411749e-02f,
  -3.61432910e-01f, 1.53050661e-01f, -1.39172986e-01f, -7.27566779e-02f, 2.58593142e-01f, -1.48323551e-01f, -1.08460747e-01f, 6.10409342e-02f, -1.79086894e-01f, 2.62482256e-01f,
  4.35082950e-02f, 5.81289418e-02f, 4.97885756e-02f, 5.39764389e-02f, -1.37054682e-01f, -1.12031639e-01f, -8.49638879e-02f, -3.02697308e-02f, -2.12088823e-02f, -5.50706871e-02f,
  -7.02732205e-02f, 3.26385170e-01f, 1.36988396e-02f, 2.32587069e-01f, 1.59336314e-01f, -3.54908928e-02f, 2.61036426e-01f, -1.85780460e-03f, 1.58290297e-01f, 1.30656213e-01f,
  -1.03599340e-01f, -6.12106621e-02f, 9.85826273e-03f, -9.38727930e-02f, -5.79219870e-02f, -5.05060479e-02f, -5.06800488e-02f, -4.13472913e-02f, 2.86826920e-02f, 5.37657142e-02f,
  1.10592857e-01f, 8.16559196e-02f, 1.60337985e-02f, 5.78941666e-02f, 8.53737593e-02f, 6.94030449e-02f, 5.67353219e-02f, -2.31108963e-02f, 1.23813488e-01f, -1.58155262e-02f,
  -2.17119735e-02f, 2.63224766e-02f, 7.27323396e-03f, -1.04953209e-02f, 5.63519523e-02f, 4.75415364e-02f, -6.21296428e-02f, 5.70501238e-02f, 8.45194608e-02f, 3.35958451e-02f,
  -9.12837833e-02f, -4.84602638e-02f, -2.83426140e-02f, 3.37435678e-02f, -2.46789549e-02f, 7.59483278e-02f, 4.42215949e-02f, 8.08317140e-02f, 1.18090093e-01f, 6.37308806e-02f,
  3.90630811e-02f, 2.73537785e-02f, 7.88909942e-02f, 3.81761342e-02f, 7.38241524e-02f, -6.21952191e-02f, -2.67603341e-02f, 5.31306304e-02f, -3.30320373e-02f, -1.37181535e-01f,
  -8.57135430e-02f, -5.72636761e-02f, -2.86363717e-02f, 7.17151761e-02f, -6.97453320e-02f, 1.78936303e-01f, 7.66982585e-02f, -5.66661134e-02f, -1.12654917e-01f, 4.34692279e-02f,
  -3.22126523e-02f, 1.56538382e-01f, 1.75638124e-02f, 2.82484721e-02f, 4.23750691e-02f, 6.31760880e-02f, -8.07627067e-02f, -6.09329864e-02f, 3.02127525e-02f, -2.77084354e-02f,
  6.15727454e-02f, 5.60258105e-02f, -3.79397571e-02f, 5.32305688e-02f, 1.19939908e-01f, 2.06099860e-02f, 2.67052017e-02f, 4.40934487e-02f, 1.43989414e-01f, -2.48185247e-02f,
  2.04543024e-02f, 1.45283684e-01f, 2.33148541e-02f, 6.24846714e-03f, 1.20100871e-01f, 1.01065665e-01f, -3.05693392e-02f, 5.86660840e-02f, 5.78984283e-02f, 8.51486102e-02f,
  1.77771822e-01f, -1.20350622e-01f, -1.41814768e-01f, -1.49324525e-03f, 1.52893439e-01f, 8.30042642e-03f, -1.01008818e-01f, -6.25614598e-02f, -5.86995892e-02f, -1.16310321e-01f,
  -3.59027199e-02f, -3.28318663e-02f, -4.77628876e-03f, -1.97595403e-01f, 1.25875324e-01f, -1.36735097e-01f, 4.23792377e-02f, -6.95348829e-02f, -1.24417715e-01f, 1.35929033e-01f,
  -2.55825352e-02f, 9.82824191e-02f, -1.93981424e-01f, 1.23329926e-02f, 3.72131877e-02f, -9.57359150e-02f, 4.17547300e-02f, -7.48400912e-02f, -2.50219996e-03f, -1.25874439e-02f,
  9.18300748e-02f, -9.59924459e-02f, -5.27579077e-02f, -5.77975884e-02f, 1.27836801e-02f, -3.31409015e-02f, -8.46264288e-02f, -8.38878080e-02f, -8.87732655e-02f, 7.20189931e-03f,
  3.28178592e-02f, 1.55262202e-02f, -7.71539472e-03f, -4.37254533e-02f, 8.45338628e-02f, -8.06774721e-02f, -5.18226959e-02f, 1.40798208e-03f, -4.44922261e-02f, 4.54760506e-04f,
  -8.60166326e-02f, -3.88740487e-02f, -3.00274361e-02f, 4.74465359e-03f, 5.78968525e-02f, 2.56949645e-02f, 6.75632898e-03f, 3.18588391e-02f, 6.10665791e-02f, 4.33738017e-03f,
  2.86823255e-04f, 2.20604092e-02f, -8.87834467e-04f, 5.79820597e-04f, 1.11833334e-01f, 6.50652349e-02f, 6.94279298e-02f, 6.19444512e-02f, 8.44488963e-02f, 7.56173879e-02f,
  2.17435770e-02f, 4.40327786e-02f, 4.43278179e-02f, -4.00536843e-02f, -6.51057959e-02f, -4.94464859e-02f, 1.14602651e-02f, 8.46193917e-03f, -9.84502509e-02f, -5.71195558e-02f,
  -7.48822019e-02f, 4.27356698e-02f, 3.74730453e-02f, 1.42536759e-01f, -9.55900922e-02f, 2.40873434e-02f, -1.44409537e-02f, -1.00127399e-01f, 2.24204343e-02f, -1.35017382e-02f,
  2.91979134e-01f, 2.20047340e-01f, -3.24796438e-02f, 9.93867218e-02f, -1.69268586e-02f, -4.21349853e-02f, -7.73934573e-02f, -1.18129458e-02f, -3.54985101e-03f, -2.68428568e-02f,
  -2.46626604e-02f, 8.67788717e-02f, 7.05197230e-02f, 1.03589304e-01f, 1.11834399e-01f, 6.66926429e-02f, 1.27218561e-02f, 4.12145667e-02f, 1.18305743e-01f, 1.18913725e-01f,
  1.02191353e-02f, 6.64075613e-02f, -4.63806428e-02f, 1.22575788e-02f, 5.11255786e-02f, 4.88309301e-02f, 1.29146159e-01f, -8.53635222e-02f, 1.15280554e-01f, -6.88614398e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.65334789e-02f, 8.93223807e-02f, 1.89099595e-01f, 2.33499452e-01f, -1.13923810e-01f, -3.74695271e-01f, -3.73502344e-01f, 1.52270168e-01f, -6.04229718e-02f, -3.12188387e-01f,
  -5.78702614e-02f, -7.05496147e-02f, 3.06202713e-02f, 7.38499016e-02f, 2.04968065e-01f, 8.06772262e-02f, 1.30194023e-01f, -1.17155850e-01f, 1.23795003e-01f, 2.12493956e-01f,
  1.00557081e-01f, 1.45669058e-02f, 3.06374282e-01f, 3.99171449e-02f, -4.10072766e-02f, 4.97633778e-02f, 1.73635602e-01f, 5.13225887e-03f, -5.29617332e-02f, -5.74224740e-02f,
  -4.26232181e-02f, 6.73039481e-02f, 4.87409271e-02f, -6.64805099e-02f, 1.09529249e-01f, -8.74722097e-03f, -7.18777254e-02f, -2.74935849e-02f, -1.28117606e-01f, -6.60060570e-02f,
  -6.11375980e-02f, -4.25057635e-02f, -2.02950388e-02f, 4.00598459e-02f, -3.61434445e-02f, -5.51407272e-03f, -3.72069404e-02f, 1.46857863e-02f, -5.86451441e-02f, 1.03773095e-01f,
  2.48182807e-02f, 4.15093414e-02f, 6.21596351e-02f, 4.32406105e-02f, 8.48755520e-03f, 3.87566118e-03f, -5.53032830e-02f, 5.51337898e-02f, -1.36071324e-01f, 6.69344813e-02f,
  -1.73902325e-02f, -8.38912800e-02f, -1.13480113e-01f, -9.42461342e-02f, -5.96758462e-02f, -4.36890386e-02f, -1.84260197e-02f, -4.52384427e-02f, 4.10955139e-02f, 6.51389966e-03f,
  -1.00756504e-01f, 1.43402636e-01f, -5.56865614e-03f, -9.37715769e-02f, 1.59438681e-02f, 3.81361023e-02f, 1.69754103e-02f, -1.04620405e-01f, -1.29946247e-02f, -9.69797466e-03f,
  -4.37324345e-02f, -4.03296575e-03f, -7.21103102e-02f, 4.14422899e-02f, -9.84488130e-02f, -2.98031941e-02f, -4.69950326e-02f, 8.97746347e-03f, 3.41790058e-02f, 9.22603905e-02f,
  -9.11881309e-03f, 2.25620195e-01f, 2.49033757e-02f, -1.19277045e-01f, -2.21690722e-02f, 2.27947882e-03f, -6.52839430e-03f, 1.77744925e-02f, -4.34443615e-02f, -7.14786956e-03f,
  6.60308003e-02f, -2.70809624e-02f, 2.68064011e-02f, 3.11799161e-02f, 7.43628293e-02f, 9.26765241e-03f, -7.79592916e-02f, -1.20085999e-01f, 6.63955584e-02f, 2.31145069e-01f,
  -3.42399627e-02f, -1.09665506e-01f, 1.09196538e-02f, -3.73296477e-02f, -1.08332476e-02f, 9.03773680e-02f, 1.36653073e-02f, -3.68711501e-02f, 9.77838486e-02f, 7.20667094e-02f,
  3.54851075e-02f, 1.41608775e-01f, 9.79226530e-02f, 1.50018960e-01f, 3.74023080e-01f, 2.15320602e-01f, 2.17432007e-01f, 2.93079972e-01f, 5.22682369e-01f, -4.44091447e-02f,
  -2.40490213e-02f, 2.80578248e-02f, -1.39473855e-01f, 7.54579231e-02f, -1.16701610e-01f, -9.52184945e-02f, 3.16321403e-01f, 5.74285239e-02f, 3.65745246e-01f, 5.24105737e-03f,
  1.53371781e-01f, -9.79862511e-02f, -1.98909089e-01f, -1.04418114e-01f, -6.92350343e-02f, 3.36274393e-02f, -3.54525566e-01f, 5.32976352e-02f, -1.08984523e-01f, 1.02887794e-01f,
  1.76994018e-02f, 6.88502789e-02f, -4.83109429e-02f, -5.38672954e-02f, 1.72577091e-02f, -8.91587511e-02f, -7.19590262e-02f, -1.07448928e-01f, 1.72128789e-02f, 5.45873772e-03f,
  3.98776643e-02f, -1.19508505e-01f, -3.40764299e-02f, -1.66778222e-01f, 1.45421743e-01f, -9.32129007e-03f, -7.01565519e-02f, 1.29430920e-01f, -3.18168812e-02f, 1.30279493e-02f,
  -4.06438336e-02f, 6.85285181e-02f, 1.93905607e-01f, 1.39634788e-01f, 1.08533792e-01f, 1.30189419e-01f, 5.95528483e-02f, -4.33085002e-02f, 1.59037579e-02f, 9.83794034e-02f,
  -1.07105542e-02f, 1.57477483e-01f, -8.39228332e-02f, -3.78281139e-02f, -4.25318517e-02f, 1.35913771e-02f, -4.57361266e-02f, -7.67448097e-02f, 5.68179376e-02f, -2.47360324e-04f,
  -2.38913875e-02f, -3.71258222e-02f, 3.47435400e-02f, 2.90565733e-02f, 9.43004116e-02f, 4.81603667e-02f, 7.69285718e-03f, -1.40035311e-02f, 2.00414881e-01f, -1.27718762e-01f,
  -7.72415996e-02f, 1.48217315e-02f, -4.05008011e-02f, 1.23492843e-02f, -2.47416012e-02f, -8.83878954e-03f, -1.29588664e-01f, -2.32701898e-02f, -1.91805102e-02f, -3.21115926e-02f,
  8.71257484e-02f, 1.84797421e-01f, 7.78489700e-03f, -1.21874474e-01f, -4.14221175e-02f, -4.44275998e-02f, -5.77935055e-02f, 5.79753444e-02f, 6.05484545e-02f, 9.23994929e-02f,
  1.32168353e-01f, -2.87681203e-02f, 4.40956913e-02f, -1.09911069e-01f, 9.89407534e-04f, -5.24688885e-02f, 3.89771610e-02f, 1.65262923e-01f, 7.42831677e-02f, -4.50747907e-02f,
  -8.04938897e-02f, 1.11270837e-01f, 8.68654922e-02f, 1.63996741e-01f, 1.27696291e-01f, -7.10799992e-02f, -1.63226505e-03f, -3.22399251e-02f, -8.48642960e-02f, 1.05561532e-01f,
  -5.84800653e-02f, 2.17053011e-01f, 3.25659782e-01f, -3.26525927e-01f, -8.00236315e-02f, 6.84317201e-02f, -3.00750017e-01f, 1.17576256e-01f, -4.23692651e-02f, 1.69525016e-02f,
  -2.44861171e-01f, 1.44477123e-02f, 1.17824506e-02f, -1.92885876e-01f, 6.84236959e-02f, 3.40524018e-02f, -2.20148355e-01f, -2.38098472e-01f, -7.21779391e-02f, -1.84521809e-01f,
  -1.49590969e-01f, -2.31449783e-01f, 2.13505179e-02f, -3.14243250e-02f, -7.54340887e-02f, 9.57272798e-02f, -6.90651387e-02f, 1.37201309e-01f, 7.39877224e-02f, 1.79264173e-01f,
  -3.56204174e-02f, -1.98540524e-01f, -1.69533089e-01f, 3.78631540e-02f, 7.08808098e-03f, 8.94770128e-05f, -3.33333435e-03f, -1.57147959e-01f, 4.28652130e-02f, 7.05546439e-02f,
  -1.72747336e-02f, 2.16597412e-02f, -8.62287283e-02f, -4.43561003e-02f, 3.80272232e-02f, 1.26555234e-01f, 8.12344849e-02f, 3.07613183e-02f, 8.42645019e-02f, 1.65671229e-01f,
  1.09314606e-01f, 6.92620203e-02f, 7.59907216e-02f, 1.10629492e-01f, 7.56608397e-02f, -5.05618639e-02f, -2.92738006e-02f, 1.11990526e-01f, 1.20955944e-01f, -4.14039902e-02f,
  -9.90183726e-02f, -1.85696222e-02f, 3.10455151e-02f, 1.29416257e-01f, -3.69633697e-02f, 3.68530266e-02f, -2.05416810e-02f, -3.68777779e-04f, 2.00545248e-02f, 2.72275247e-02f,
  7.29946792e-02f, -7.81679805e-03f, -2.56591830e-02f, 1.00633115e-01f, -4.05558348e-02f, -9.99233034e-03f, -6.91015497e-02f, 9.23586264e-02f, 3.76290530e-02f, -1.05662160e-02f,
  -1.72309712e-01f, -6.12259433e-02f, 9.31941941e-02f, 2.88101453e-02f, 2.61976440e-02f, 5.03236800e-03f, 4.52257991e-02f, 2.08891869e-01f, -1.30045354e-01f, 4.09927825e-03f,
  -1.97583973e-01f, -2.49648809e-01f, -2.09177315e-01f, -3.18034776e-02f, -1.18990920e-01f, 4.14220095e-02f, -1.17720827e-01f, -7.78813064e-02f, 1.14595816e-01f, -1.49029540e-02f,
  5.56464978e-02f, -4.33584601e-02f, -7.02332938e-03f, -4.62325886e-02f, -8.66850913e-02f, -5.22952154e-03f, -1.24914929e-01f, -1.62274614e-01f, -1.19136311e-01f, 7.46854022e-02f,
  -2.24004500e-02f, -9.13326964e-02f, 1.53361619e-01f, -2.94338930e-02f, -7.13232309e-02f, 1.25985608e-01f, -6.70639127e-02f, 9.83233377e-02f, 9.46057588e-02f, 1.01447128e-01f,
  2.60264557e-02f, 1.27656594e-01f, 1.24163583e-01f, -1.45752400e-01f, -2.01987281e-01f, 7.06757046e-03f, -8.89830515e-02f, 7.50780702e-02f, 1.12193309e-01f, 1.89088821e-01f,
  -2.11232886e-01f, 2.91318506e-01f, 1.51735187e-01f, -2.13589817e-01f, 1.55435111e-02f, -3.56662199e-02f, -2.34088510e-01f, -3.45487110e-02f, -7.12200999e-02f, -9.19052586e-03f,
  -1.13552414e-01f, -2.19586372e-01f, -1.00826003e-01f, 2.99599990e-02f, -1.41511992e-01f, -2.41895113e-02f, -2.42184624e-01f, -2.15609372e-01f, -1.47470757e-01f, -1.17433809e-01f,
  -1.59030199e-01f, -1.54324263e-01f, -4.22512144e-02f, 6.22751527e-02f, -9.62752998e-02f, -2.80764676e-03f, 2.36094054e-02f, -4.39425595e-02f, -1.17498234e-01f, -9.71881673e-03f,
  1.58377141e-01f, 1.73586145e-01f, 9.06319618e-02f, -5.18759117e-02f, -2.92934920e-03f, -8.96137580e-02f, -1.62142068e-02f, 2.00704895e-02f, -1.28118714e-04f, 5.74321784e-02f,
  1.41865864e-01f, 1.44299325e-02f, -4.75188829e-02f, 5.97921722e-02f, 3.30221429e-02f, -2.86865067e-02f, 1.12784237e-01f, 1.02733172e-01f, -4.76043969e-02f, 2.05898341e-02f,
  -1.23846129e-01f, -7.04407087e-03f, -5.71619384e-02f, 3.08921398e-03f, -2.22516600e-02f, -1.03546688e-02f, -3.43675427e-02f, 7.14870589e-03f, 1.00376330e-01f, 3.86079326e-02f,
  2.69908272e-02f, 3.66698988e-02f, -1.02954498e-02f, -2.78041977e-02f, -2.40493026e-02f, 9.76240784e-02f, 1.00539830e-02f, 7.34036341e-02f, 3.33256833e-02f, 1.35474831e-01f,
  -1.17088974e-01f, 5.29085174e-02f, 3.32792513e-02f, -1.34035558e-01f, -4.19320315e-02f, 1.43807800e-02f, 1.16074771e-01f, 3.21835391e-02f, -7.66534433e-02f, -6.84136450e-02f,
  -8.69102404e-03f, -2.01582033e-02f, -5.78595279e-03f, 1.41109645e-01f, -1.05557619e-02f, -1.98753574e-03f, -6.76560551e-02f, -7.82431103e-03f, -9.95663032e-02f, -1.00416085e-02f,
  2.27024574e-02f, 2.33197033e-01f, 7.63632506e-02f, 2.51978100e-03f, 7.75881335e-02f, -7.92514831e-02f, -3.65125984e-02f, 4.46003377e-02f, 4.53068642e-03f, 4.51739766e-02f,
  7.14665502e-02f, 8.54282230e-02f, 1.20108068e-01f, -5.46471439e-02f, 7.13637695e-02f, -3.68417650e-02f, 1.01447619e-01f, 6.24239072e-02f, -7.47705698e-02f, 8.16187039e-02f,
  3.39358926e-01f, 3.29615712e-01f, 2.45108351e-01f, 3.20612669e-01f, -1.48524195e-01f, 1.40610144e-01f, 2.84419507e-01f, -1.14935361e-01f, 2.80727744e-01f, 1.93550080e-01f,
  -2.30448246e-01f, 4.22853351e-01f, -2.98141241e-01f, 2.00661838e-01f, -2.44481042e-01f, -1.84274361e-01f, 2.17490226e-01f, 2.81873554e-01f, 1.42117292e-01f, 1.96986362e-01f,
  -7.57349283e-02f, -3.42782617e-01f, -1.38951614e-01f, -7.83675984e-02f, 1.54299617e-01f, 1.81882948e-01f, -4.18681353e-01f, 6.85077207e-03f, 1.19547836e-01f, -3.18130217e-02f,
  1.19753651e-01f, 8.32649916e-02f, 4.98559102e-02f, 6.23303950e-02f, -5.07868342e-02f, -5.55884503e-02f, 3.34605239e-02f, -3.98880839e-02f, -3.74642834e-02f, 5.54090887e-02f,
  6.88765123e-02f, 1.49749350e-02f, 1.19640768e-01f, -6.40132874e-02f, 1.34310991e-01f, 1.05586618e-01f, 1.76527798e-02f, 7.46659338e-02f, 3.45026106e-02f, 5.47584221e-02f,
  9.39084440e-02f, 8.65918025e-02f, 3.83645552e-03f, 6.12101033e-02f, 2.75467709e-02f, 1.15292646e-01f, 2.07705930e-01f, 2.96621323e-02f, 1.35923252e-01f, 1.46982834e-01f,
  3.00369859e-02f, 3.98379052e-03f, 5.99045865e-02f, -5.17130718e-02f, -5.37431333e-04f, -1.09150365e-01f, -5.33113293e-02f, 5.39339148e-02f, 1.24964945e-01f, -3.78222615e-02f,
  5.84100522e-02f, 3.35790180e-02f, -4.89092879e-02f, 1.07485637e-01f, 3.84814031e-02f, 3.32278125e-02f, -5.88415712e-02f, 8.82024318e-02f, 1.47055939e-01f, 2.21180040e-02f,
  -1.69574901e-01f, -1.84693765e-02f, 1.38291288e-02f, -7.23398104e-02f, -4.11375463e-02f, -2.94309277e-02f, -5.11432402e-02f, -1.94434077e-03f, -5.72002232e-02f, -8.81139711e-02f,
  2.43334062e-02f, 5.61012290e-02f, 5.31317741e-02f, -4.57895221e-03f, -1.12565599e-01f, -3.30658592e-02f, 5.84738478e-02f, 1.03098795e-01f, 4.41475622e-02f, -2.78455447e-02f,
  -4.99177091e-02f, 6.34728968e-02f, 8.59843045e-02f, -4.94120382e-02f, -1.45800933e-02f, -2.98392624e-02f, 7.26687163e-02f, -6.80378154e-02f, -1.88577678e-02f, -1.27129391e-01f,
  -2.90860161e-02f, 5.10605462e-02f, 5.63200861e-02f, 6.40449673e-02f, 6.54334351e-02f, -6.26532137e-02f, 4.40576784e-02f, 7.50495419e-02f, -6.00995459e-02f, 2.87309010e-02f,
  2.30803296e-01f, 9.79954004e-02f, -2.38655522e-01f, -3.63730118e-02f, -8.97502080e-02f, 3.01840425e-01f, 1.67213216e-01f, -3.85827422e-02f, -1.20082773e-01f, 1.84305742e-01f,
  7.42327720e-02f, 4.38180119e-02f, 1.40202232e-02f, 3.81590843e-01f, 1.47367954e-01f, 8.51483345e-02f, 2.15144143e-01f, 1.67927012e-01f, -1.46891279e-02f, 1.29133001e-01f,
  8.91227648e-02f, 4.29416209e-01f, -1.95748791e-01f, 9.73372608e-02f, 1.63662806e-01f, -2.74202973e-01f, -7.71089047e-02f, -1.49348050e-01f, -1.79818273e-03f, 1.01618931e-01f,
  5.76061644e-02f, 6.02379814e-02f, -3.52084264e-02f, -2.39927471e-02f, 7.68967392e-03f, 2.16583591e-02f, -2.16827970e-02f, -1.39514054e-03f, -1.47993058e-01f, 1.91073883e-02f,
  7.39959478e-02f, -2.79137548e-02f, 2.01440360e-02f, -6.82644621e-02f, 3.34349908e-02f, -8.98378268e-02f, 5.52482251e-03f, -9.77941826e-02f, -6.88250661e-02f, 1.47899259e-02f,
  -9.34667811e-02f, -1.87282991e-02f, -3.07325032e-02f, -1.46793857e-01f, -8.80238637e-02f, -3.83910649e-02f, -5.74532710e-02f, -1.11874215e-01f, -7.13629089e-03f, 1.77413151e-02f,
  -5.01271635e-02f, 1.11796960e-01f, 1.17952846e-01f, 1.38134127e-02f, -2.88903713e-02f, -6.53733388e-02f, 7.78335184e-02f, -5.74847050e-02f, -9.44499508e-04f, 7.63033181e-02f,
  -6.20246343e-02f, -9.42466930e-02f, -2.45618150e-02f, 6.76599517e-02f, 7.07890689e-02f, 1.77946128e-03f, -2.68274676e-02f, 8.60344470e-02f, -4.24549729e-03f, -4.32383232e-02f,
  -2.07370948e-02f, 3.85391638e-02f, 9.20438487e-03f, -3.69171426e-02f, -5.52150570e-02f, -3.83944251e-02f, 1.82760507e-01f, -3.72111574e-02f, -1.54719949e-01f, -2.96791340e-03f,
  2.25516199e-03f, 9.11004841e-02f, -2.21169461e-02f, -4.92231213e-02f, -3.84134613e-02f, 2.19723850e-01f, 1.14474662e-01f, 3.50317806e-02f, -4.44340743e-02f, 2.03589842e-01f,
  5.29831694e-03f, -1.13112025e-01f, -3.31222191e-02f, -9.14617032e-02f, -1.45499393e-01f, 3.24215405e-02f, 4.73971330e-02f, -1.76835075e-01f, -1.13973506e-01f, -6.09776527e-02f,
  1.34157185e-02f, 1.11891294e-03f, 5.38503639e-02f, 3.28251235e-02f, 6.27837330e-02f, -3.15126404e-02f, -3.54721211e-02f, -4.60102707e-02f, 1.08055165e-02f, -1.10550240e-01f,
  -2.61772424e-01f, 3.39842051e-01f, -1.20889567e-01f, 2.17088282e-01f, -1.29975736e-01f, 3.85236233e-01f, 4.44253623e-01f, 8.29831511e-02f, 2.87788391e-01f, 3.30493957e-01f,
  1.67713970e-01f, 5.87645844e-02f, 1.62133813e-01f, 3.59322548e-01f, 1.68566078e-01f, 2.69430727e-01f, 3.39215904e-01f, 2.61114299e-01f, 7.31262490e-02f, 1.51741490e-01f,
  8.67365971e-02f, 1.62117362e-01f, -6.75133094e-02f, -1.32707215e-03f, -5.05757518e-02f, -2.39661917e-01f, -1.51989028e-01f, -2.25279018e-01f, 1.64698940e-02f, -3.58913317e-02f,
  -5.39888740e-02f, -7.37664402e-02f, -1.09512158e-01f, 1.67800691e-02f, -5.46774752e-02f, -8.18012208e-02f, -8.56258422e-02f, -7.77217820e-02f, -8.21695179e-02f, 3.77923227e-03f,
  1.14595391e-01f, 4.98235524e-02f, 1.84256405e-01f, -1.62244476e-02f, -5.18702008e-02f, -2.72690784e-02f, -3.78135033e-02f, 3.09659932e-02f, 1.72233619e-02f, -2.24166568e-02f,
  -2.37507615e-02f, -3.00208200e-02f, 2.09882902e-03f, 8.73722583e-02f, -9.11726505e-02f, 5.32252304e-02f, 3.24741900e-02f, 1.44118685e-02f, 3.53173050e-03f, 7.77790621e-02f,
  6.73364252e-02f, -7.46924058e-02f, 1.43387243e-02f, -1.88773088e-02f, 1.65850110e-02f, -8.36209878e-02f, -4.37257346e-03f, -2.60461587e-02f, -4.44003642e-02f, -9.58912000e-02f,
  4.95944619e-02f, -2.52569895e-02f, -4.44227792e-02f, 6.89112991e-02f, 1.22011565e-02f, -3.73686217e-02f, -3.07266638e-02f, 2.14033350e-02f, 9.22232196e-02f, 2.12563016e-02f,
  -4.17203568e-02f, 4.32316028e-02f, 6.11520112e-02f, 1.82585344e-02f, -5.12052290e-02f, -2.64886636e-02f, 2.23997906e-02f, -6.10877462e-02f, 4.79869246e-02f, -3.29577662e-02f,
  1.93746150e-01f, 2.33621553e-01f, 4.43257391e-02f, 1.12681231e-03f, -9.42101851e-02f, -3.55004631e-02f, 4.94996980e-02f, 6.83585033e-02f, 5.70306778e-02f, 4.48387824e-02f,
  2.43917219e-02f, 4.62575555e-02f, 7.35891983e-03f, -1.02589309e-01f, -2.58460268e-02f, 4.18559127e-02f, 1.20160870e-01f, 8.70630816e-02f, 2.33935304e-02f, -1.27668396e-01f,
  -3.36489640e-02f, 6.62567765e-02f, 5.68855228e-03f, 8.82105976e-02f, 1.19542338e-01f, -1.64789297e-02f, 5.85258566e-02f, -3.94810885e-02f, -9.95574519e-03f, 6.86980262e-02f,
  2.57652551e-01f, -1.11137882e-01f, 2.04647616e-01f, 2.11975336e-01f, -8.62483121e-03f, 1.57803610e-01f, 2.94696689e-01f, -8.80240351e-02f, 3.47164184e-01f, -2.42218032e-01f,
  -1.64244696e-01f, 4.01661731e-02f, 1.75632358e-01f, -1.13078929e-01f, 2.40263417e-01f, 1.92595452e-01f, 2.51803786e-01f, 1.33896425e-01f, 6.83100745e-02f, -1.13704219e-01f,
  -3.78371663e-02f, -1.82305604e-01f, -5.35133742e-02f, -1.22084647e-01f, -1.80179253e-01f, -1.81784719e-01f, -2.61069506e-01f, 8.81316438e-02f, -3.02230954e-01f, -1.62584204e-02f,
  -1.82990059e-02f, 2.28439607e-02f, 2.28956845e-02f, 5.09566329e-02f, 2.11520586e-02f, -6.74681142e-02f, -8.77707154e-02f, 2.10059136e-02f, 1.73143387e-01f, -1.28959402e-01f,
  4.96468060e-02f, -1.47021059e-02f, 3.56740169e-02f, 9.22294427e-03f, 5.77527210e-02f, 1.58542488e-02f, 9.65081006e-02f, -7.35077367e-04f, 5.23294099e-02f, -6.92097917e-02f,
  7.31618702e-02f, 4.76088375e-02f, 8.65835845e-02f, 4.83045876e-02f, 2.26578683e-01f, 1.16953529e-01f, -6.22080592e-03f, 1.21390849e-01f, 5.35857677e-02f, 3.50068063e-02f,
  -7.17367232e-02f, 2.16054097e-02f, -8.50093067e-02f, -2.03052223e-01f, -2.42462684e-03f, -6.33470714e-02f, -8.47990811e-02f, -9.18594152e-02f, 8.28760862e-02f, -2.66174804e-02f,
  1.28988279e-02f, 1.45262834e-02f, 1.25223562e-01f, 9.27523747e-02f, -8.66722465e-02f, -9.29529890e-02f, -2.62886100e-02f, -2.03050226e-02f, 9.74515676e-02f, -1.55574381e-02f,
  -1.41499564e-01f, 9.44772288e-02f, 4.65179756e-02f, -3.63558680e-02f, -7.18945861e-02f, -8.32682848e-03f, -7.19836131e-02f, 1.22422017e-02f, -8.16824734e-02f, 8.09208974e-02f,
  1.06062517e-01f, -6.05722442e-02f, 1.58593021e-02f, 1.44214928e-02f, -5.05675189e-02f, -1.33115470e-01f, -4.11175787e-02f, -6.09097779e-02f, 1.06605768e-01f, -1.39571890e-01f,
  6.34018506e-04f, 5.16844541e-02f, 1.12653278e-01f, 2.58685574e-02f, 4.26190905e-02f, -1.45864055e-01f, 1.32015064e-01f, 5.07548489e-02f, 5.68643734e-02f, -1.36385977e-01f,
  6.69565126e-02f, 1.48494784e-02f, 9.83075351e-02f, 4.35352586e-02f, 1.16671316e-01f, -2.63212640e-02f, -1.91820636e-02f, 8.29325095e-02f, 3.03640701e-02f, 1.34773567e-01f,
  2.23485544e-01f, -1.17360063e-01f, -2.78125256e-01f, -7.50966519e-02f, 1.01620421e-01f, 1.89169422e-01f, -7.79481679e-02f, 1.38287365e-01f, -2.39873931e-01f, 2.62061842e-02f,
  2.00891886e-02f, -1.76728740e-01f, -2.54640758e-01f, 2.19215564e-02f, -1.01741664e-02f, -3.28716397e-01f, 1.95932195e-01f, 4.17100340e-02f, -1.95836768e-01f, 7.89543688e-02f,
  3.87758166e-02f, 4.33492541e-01f, 4.24079262e-02f, 3.95842910e-01f, 3.99062932e-01f, 1.31762818e-01f, 2.98310548e-01f, 5.62886745e-02f, 2.69859612e-01f, 2.03283280e-01f,
  3.02426983e-03f, -2.67957840e-02f, -1.06390707e-01f, -1.70046538e-02f, -9.83180758e-03f, 1.27692774e-01f, 4.27214615e-02f, 7.95913860e-03f, -5.61166964e-02f, -5.64031489e-03f,
  4.66240831e-02f, 6.03215471e-02f, -5.22822812e-02f, -5.63313514e-02f, 1.02635711e-01f, 6.72982931e-02f, -5.50359339e-02f, 3.46102156e-02f, -9.07009691e-02f, -3.18007320e-02f,
  -1.06890537e-01f, -1.43958684e-02f, 5.33131883e-02f, 1.02200974e-02f, -5.71751706e-02f, -1.25156029e-03f, 1.30080387e-01f, 7.90584162e-02f, -2.42023729e-03f, 3.06720193e-03f,
  1.55023620e-01f, 8.17420930e-02f, 9.14611444e-02f, -1.20863371e-01f, -4.15999256e-02f, -1.43662646e-01f, -9.90429521e-02f, -1.24462336e-01f, -9.66503024e-02f, -2.35680472e-02f,
  -1.11911027e-02f, -1.00057520e-01f, -1.06748924e-01f, 1.30193129e-01f, 7.23456889e-02f, -2.76386812e-02f, -2.15224680e-02f, -1.56062050e-02f, -4.79255952e-02f, -1.15922220e-01f,
  -3.66062038e-02f, 3.36174518e-02f, 4.41575050e-02f, 4.08088788e-02f, -5.33546284e-02f, 1.26991525e-01f, 1.61418647e-01f, 1.33299679e-02f, -1.79475043e-02f, 5.70038892e-02f,
  -2.19400320e-03f, -1.31500978e-02f, -1.55944051e-02f, 5.27402125e-02f, -8.18445235e-02f, 1.00355953e-01f, 1.23704048e-02f, 4.40214761e-02f, 1.23602785e-01f, -8.30362726e-04f,
  1.60891190e-01f, 3.69867906e-02f, -6.06253929e-03f, -3.12987678e-02f, -6.83729872e-02f, 9.91750434e-02f, 3.60042527e-02f, 4.58249636e-03f, 8.68803263e-02f, -1.98253542e-02f,
  1.53263003e-01f, -2.88673695e-02f, 1.07936054e-01f, -6.70260340e-02f, -1.93787497e-02f, 6.10283576e-02f, 3.16409655e-02f, 9.81988013e-02f, 5.17664701e-02f, -4.03215438e-02f,
  -4.86581355e-01f, -3.48294638e-02f, 1.52336612e-01f, 5.66243147e-03f, -1.60552010e-01f, 2.46505648e-01f, 4.21562046e-01f, -1.37629017e-01f, -1.99281037e-01f, 1.06603079e-01f,
  1.07584059e-01f, -3.56252119e-02f, 2.97713846e-01f, 1.59728199e-01f, 1.85908943e-01f, 1.97050720e-01f, 2.21272036e-01f, 1.54198691e-01f, -1.63934767e-01f, -9.46636423e-02f,
  3.11872810e-02f, -4.35821563e-02f, 2.49953195e-01f, -3.04273844e-01f, -1.10197186e-01f, -2.44727820e-01f, 4.95661385e-02f, 7.01551661e-02f, 1.27667664e-02f, -8.01341459e-02f,
  -1.85971498e-01f, -2.84167498e-01f, -2.44884845e-02f, 1.80734415e-02f, -1.16322659e-01f, 4.55867033e-03f, 1.29874364e-01f, 1.01846680e-01f, -4.69548814e-02f, 2.38984674e-02f,
  -4.28876327e-03f, -1.09460399e-01f, -2.43658647e-01f, 6.74914494e-02f, -5.16342893e-02f, -1.73088536e-01f, -1.91160459e-02f, 2.03058466e-01f, 1.21540725e-01f, 3.51771479e-03f,
  1.14070244e-01f, -3.15558575e-02f, 3.88102420e-02f, -7.04601547e-03f, -3.58373336e-02f, 7.10503310e-02f, 3.95415388e-02f, 6.08721413e-02f, -9.36998352e-02f, -3.64300571e-02f,
  -3.35311666e-02f, 1.09082930e-01f, -4.75914069e-02f, -1.18068114e-01f, -6.86365739e-02f, -3.67426686e-02f, 1.38103077e-02f, -1.28061464e-02f, -7.02141747e-02f, 6.72268718e-02f,
  -2.85737608e-02f, -2.40930077e-03f, 1.66679192e-02f, 2.87849791e-02f, -3.44895087e-02f, 3.13306674e-02f, 3.63545604e-02f, -1.23747952e-01f, -5.51337413e-02f, 2.08887439e-02f,
  5.72140003e-03f, -1.19251005e-01f, -1.01954967e-01f, -5.20495838e-03f, -4.62272614e-02f, 1.00939810e-01f, -1.36469990e-01f, -4.28325795e-02f, -6.90944195e-02f, 7.83497617e-02f,
  -1.70353025e-01f, -2.12782338e-01f, -1.27382219e-01f, -2.32380219e-02f, 4.70282622e-02f, 4.98409150e-03f, -6.80526644e-02f, -8.40317905e-02f, -9.47727710e-02f, 5.57227023e-02f,
  2.18579313e-03f, 8.87471158e-03f, -1.69185176e-01f, 6.33738041e-02f, 7.69276172e-02f, -6.19582087e-02f, 4.26229229e-03f, -6.73303660e-03f, 1.87065303e-02f, -1.04439497e-01f,
  -6.27219211e-03f, -6.66632354e-02f, 4.34495173e-02f, -4.55815308e-02f, -5.93570806e-02f, 6.08427674e-02f, -1.58062294e-01f, 5.65553233e-02f, -1.90092370e-01f, 2.26159748e-02f,
  -2.11617976e-01f, -3.86473797e-02f, 2.21221343e-01f, -3.84056509e-01f, 7.95435011e-02f, 1.93440735e-01f, -1.03265494e-01f, -3.25096212e-03f, -1.45682782e-01f, -2.78701067e-01f,
  -7.57469684e-02f, -7.95255303e-02f, 1.50472164e-01f, -2.84665704e-01f, 2.57880777e-01f, 1.30879328e-01f, -2.49518856e-01f, -1.37164727e-01f, -9.44013521e-02f, -2.60900259e-01f,
  -2.35000238e-01f, -3.57800692e-01f, 1.70151219e-01f, -1.09313726e-01f, -1.91518053e-01f, -9.17825177e-02f, -1.10115737e-01f, -1.40199840e-01f, -2.28212267e-01f, -3.08011957e-02f,
  5.88372909e-02f, 2.42695417e-02f, 6.75914288e-02f, 1.32926673e-01f, 1.00992613e-01f, -5.65897413e-02f, 1.69350673e-02f, 8.14984813e-02f, 2.88920309e-02f, -5.69487289e-02f,
  -8.56708065e-02f, 9.93941501e-02f, -1.32362127e-01f, -1.66699588e-02f, -1.14928596e-01f, 3.24818529e-02f, 3.58622223e-02f, 2.25557853e-02f, 7.89912641e-02f, 3.09874155e-02f,
  -5.89835271e-02f, 1.17364511e-01f, -7.40377679e-02f, -8.97010937e-02f, -2.45700907e-02f, -4.62143794e-02f, -2.73370501e-02f, -1.24618725e-03f, 1.13555568e-03f, -1.15726665e-01f,
  -9.32193641e-03f, -6.75366968e-02f, 2.84390114e-02f, 5.02588321e-03f, 2.86200680e-02f, 5.86329326e-02f, -7.59152025e-02f, 5.30986525e-02f, -5.33588193e-02f, -1.75374094e-02f,
  -1.29577573e-02f, 1.48031548e-01f, 6.97384328e-02f, -1.56920031e-01f, -3.87876220e-02f, 5.04916646e-02f, 7.34417886e-02f, 7.83694983e-02f, -1.54174566e-01f, 6.19721040e-02f,
  -1.66415673e-04f, -5.41969240e-02f, -2.14619450e-02f, 4.03165519e-02f, 1.76263034e-01f, -4.18004505e-02f, -1.61350787e-01f, 6.39766753e-02f, 7.22511411e-02f, -1.06628187e-01f,
  1.25826120e-01f, -6.25278428e-02f, 9.92562547e-02f, 3.24474946e-02f, 1.82599902e-01f, -4.62030694e-02f, -3.78145687e-02f, -5.92817366e-02f, 1.50642423e-02f, -1.25295877e-01f,
  -1.29871011e-01f, 1.82791762e-02f, -6.95827529e-02f, -2.20092270e-03f, 6.22980250e-03f, 5.89526147e-02f, -2.51026787e-02f, 5.84278218e-02f, 6.54154718e-02f, 6.23877048e-02f,
  -7.74754807e-02f, 1.45530375e-02f, -4.25038561e-02f, -1.54938430e-01f, -9.21654478e-02f, -9.15631950e-02f, 1.03007466e-01f, -2.42090803e-02f, -8.34259316e-02f, -5.10309301e-02f,
  -2.67112609e-02f, -5.71479760e-02f, -7.51654580e-02f, 2.35609964e-01f, -6.31886395e-03f, -4.59971875e-02f, -6.19305968e-02f, -7.71498261e-03f, 8.44153482e-03f, 7.59738684e-03f,
  -1.43854162e-02f, 1.30229056e-01f, -1.57072231e-01f, 2.34605044e-01f, 3.12267601e-01f, -8.24075490e-02f, 3.02136779e-01f, 8.00871626e-02f, 2.07935739e-03f, 1.23738490e-01f,
  9.25853103e-02f, 2.03055695e-01f, 5.60250096e-02f, 3.03534102e-02f, -2.83086207e-02f, 7.98620842e-03f, 1.74060166e-01f, -6.67096227e-02f, 2.15801537e-01f, 1.66859969e-01f,
  1.75240692e-02f, 6.83220699e-02f, 2.30975654e-02f, -2.75170431e-02f, 2.19499189e-02f, -3.51921730e-02f, -1.64767057e-02f, 3.34682576e-02f, 1.28926486e-02f, 4.28344868e-02f,
  1.04784314e-02f, 4.95872833e-02f, -9.31799319e-03f, 4.42231670e-02f, -1.94930602e-02f, 8.93988162e-02f, -1.36475102e-03f, -3.17576788e-02f, 1.57919303e-02f, 4.28704061e-02f,
  -4.01392430e-02f, 3.00308503e-02f, 2.88195778e-02f, 8.37017149e-02f, -1.45602562e-02f, 1.32433563e-01f, 1.35137029e-02f, 1.18047133e-01f, 4.82874922e-02f, 1.07567966e-01f,
  3.08488123e-02f, -9.17399228e-02f, -1.75588921e-01f, -1.33819416e-01f, -9.46417451e-03f, -1.55598056e-02f, -9.97923017e-02f, -9.27713215e-02f, -5.07278815e-02f, 3.39874253e-02f,
  1.04230881e-01f, -1.17847277e-02f, 2.03500222e-02f, 7.55880401e-03f, -2.54941732e-02f, -9.22350883e-02f, -8.95302370e-02f, 4.47191671e-02f, 5.91070466e-02f, -6.76071644e-02f,
  -1.40077872e-02f, 1.00960610e-02f, -9.12293270e-02f, -1.00249993e-02f, 7.43394578e-03f, -5.58678769e-02f, -1.08242296e-02f, 5.36657907e-02f, -5.34814224e-02f, -6.54843301e-02f,
  9.04407725e-02f, 1.94622368e-01f, -5.51353500e-04f, -3.18749137e-02f, 4.48570102e-02f, 1.75441988e-02f, -6.07024366e-03f, 3.28401476e-02f, 4.14879583e-02f, -2.80985069e-02f,
  1.71845108e-01f, -9.25773308e-02f, -3.41483712e-04f, 7.94174373e-02f, 6.86485991e-02f, -7.03379977e-03f, 1.62418261e-02f, 1.97835732e-02f, 1.88267037e-01f, -4.51159151e-03f,
  -2.51377583e-03f, -8.88062567e-02f, -5.58929401e-04f, -1.51676491e-01f, 5.62532060e-02f, 7.22209960e-02f, 4.18214165e-02f, 1.73218120e-02f, 5.04002310e-02f, 1.37131006e-01f,
  2.11660862e-01f, -2.67203331e-01f, -3.40954125e-01f, -1.02470526e-02f, 1.68110222e-01f, 2.64195740e-01f, 1.05879292e-01f, -1.82486251e-01f, -2.16249928e-01f, 1.30663877e-02f,
  7.87990633e-04f, -5.85595891e-02f, -2.24689052e-01f, 3.22169453e-01f, 2.55468249e-01f, -5.71171530e-02f, 2.17865780e-01f, 1.58235446e-01f, -3.69498357e-02f, -7.62322843e-02f,
  1.21058807e-01f, 4.03772891e-01f, -1.02148011e-01f, 1.56404778e-01f, 1.72747031e-01f, -1.04830109e-01f, 8.14711899e-02f, -4.38993126e-02f, 3.04661542e-01f, 1.69869885e-01f,
  7.70085901e-02f, -6.95834234e-02f, -1.03177816e-01f, 7.67006129e-02f, -2.82296985e-02f, 6.17936663e-02f, 1.64426774e-01f, 1.32256433e-01f, -1.36519372e-02f, -4.40600738e-02f,
  7.96557218e-02f, 8.16869140e-02f, 3.13855521e-02f, -1.05327126e-02f, 8.12769681e-02f, -2.99949422e-02f, -6.64134175e-02f, -6.15734011e-02f, -1.51614189e-01f, -1.04562886e-01f,
  -1.06022865e-01f, -7.75946602e-02f, 5.22641726e-02f, 2.75087892e-03f, -3.81827611e-03f, 1.45564396e-02f, -4.68626954e-02f, -1.33283526e-01f, 1.28204167e-01f, -4.16507460e-02f,
  5.40130176e-02f, 5.51875904e-02f, 3.89080718e-02f, -6.30688434e-03f, -4.72391993e-02f, 4.24667671e-02f, 1.22362010e-01f, -7.35453963e-02f, -6.41040131e-02f, -6.39806688e-02f,
  -1.71416607e-02f, -8.97548795e-02f, -2.82596312e-02f, 1.40170649e-01f, 4.55589890e-02f, -2.78602690e-02f, 6.06429987e-02f, -1.16235274e-03f, -1.19251572e-01f, -1.26229092e-01f,
  3.58025245e-02f, -6.19847560e-03f, -6.27902746e-02f, 3.08540482e-02f, -2.49458564e-04f, -4.27754037e-02f, 2.00288147e-01f, -7.62891173e-02f, -1.05730534e-01f, 5.12461029e-02f,
  -5.33350860e-04f, -8.05809498e-02f, -7.31076971e-02f, 1.10184640e-01f, -9.53569487e-02f, -2.37367097e-02f, 8.53974894e-02f, 2.41214558e-02f, 5.26569784e-02f, 3.51817384e-02f,
  7.55515844e-02f, 3.74344811e-02f, 5.13151363e-02f, -3.63691933e-02f, 2.57204007e-02f, -2.00854633e-02f, 1.32953763e-01f, -5.19274659e-02f, -9.32868123e-02f, -4.52398695e-02f,
  9.35108587e-02f, 3.13671678e-02f, 8.03812370e-02f, 5.84678315e-02f, 8.99559483e-02f, 3.22060548e-02f, -1.10470012e-01f, -5.35051003e-02f, 1.04131974e-01f, -3.72111350e-02f,
  3.29108119e-01f, -3.99114907e-01f, 1.62840739e-01f, 2.50182778e-01f, 2.99927324e-01f, 1.23175327e-02f, 3.23982924e-01f, 1.69591472e-01f, 1.76187888e-01f, -3.42136770e-01f,
  -9.63142328e-03f, -1.62232190e-01f, 2.47651394e-02f, -1.44143298e-01f, 3.09531033e-01f, 3.28085423e-02f, -5.74272089e-02f, -1.87331304e-01f, 2.41516843e-01f, -3.33946315e-04f,
  1.36476874e-01f, -9.12043825e-02f, 1.85787857e-01f, -1.57772332e-01f, -1.09052367e-03f, -4.58996780e-02f, -1.13345765e-01f, -5.79375215e-02f, -2.52374619e-01f, -3.40506248e-02f,
  -8.59989822e-02f, 3.29345278e-02f, 2.49926765e-02f, -8.77184868e-02f, 3.15344855e-02f, 1.42151853e-02f, -1.52561218e-01f, -5.98534127e-04f, 7.57866949e-02f, 9.47433244e-03f,
  -5.48396036e-02f, 4.72242646e-02f, -5.45528568e-02f, 4.61809821e-02f, 3.00792083e-02f, 7.10017756e-02f, 7.68258944e-02f, 1.57466363e-02f, 1.66619588e-02f, 9.65159684e-02f,
  8.18788260e-02f, -7.93387368e-02f, 1.47248611e-01f, -7.22919479e-02f, 5.04740179e-02f, 6.79381266e-02f, -2.35246047e-02f, -1.72360510e-01f, -5.99371046e-02f, 8.76172259e-02f,
  1.31268993e-01f, 3.18086818e-02f, 5.49164554e-03f, -9.18508619e-02f, -1.61254153e-01f, -3.04802824e-02f, -5.54261394e-02f, -4.77962308e-02f, -5.12752682e-02f, -1.27175182e-01f,
  -4.03572321e-02f, 1.36465179e-02f, 3.73484381e-02f, 4.59408946e-02f, 6.34252429e-02f, 1.24350816e-01f, -1.15276113e-01f, -1.58304259e-01f, 4.37926203e-02f, 1.21455878e-01f,
  2.13566385e-02f, -7.66178709e-04f, -1.19467631e-01f, 6.27605245e-02f, -2.15682760e-02f, -9.45719611e-03f, -9.84613076e-02f, -1.43815624e-02f, 2.86105163e-02f, 9.33946297e-02f,
  -4.57070589e-01f, -4.19662088e-01f, -9.27132592e-02f, -1.76613361e-01f, -2.15361252e-01f, -8.79708771e-03f, -2.89593544e-02f, -1.31922081e-01f, -6.84670582e-02f, 9.26984325e-02f,
  -5.49766608e-02f, -1.26169637e-01f, -4.15126756e-02f, 9.55720544e-02f, -8.27799886e-02f, -2.80624405e-02f, -1.03660740e-01f, -1.51830375e-01f, -1.89517718e-02f, -7.32917413e-02f,
  -1.48531303e-01f, -5.25350757e-02f, 1.28490347e-02f, 1.24085151e-01f, -6.61660135e-02f, 8.20270851e-02f, 5.52094989e-02f, -1.95819084e-02f, -2.69340184e-02f, -8.07279907e-03f,
  -3.94297801e-02f, -4.84110564e-01f, 2.48906121e-01f, -5.54266572e-02f, 2.71038413e-01f, 1.84324950e-01f, 1.86868846e-01f, 7.11189508e-02f, -1.23370051e-01f, -2.45244399e-01f,
  -1.84116498e-01f, -2.28545800e-01f, -1.58260405e-01f, -2.39543423e-01f, 2.66194761e-01f, 3.37485187e-02f, -3.23550813e-02f, -6.72652759e-03f, 1.54673131e-02f, -1.08119056e-01f,
  1.75928205e-01f, 1.16557486e-01f, 1.75809130e-01f, 4.11745086e-02f, 2.17800774e-02f, -2.72250571e-03f, 2.88413931e-02f, 1.67634249e-01f, -2.93236803e-02f, 1.53604820e-01f,
  -1.05071612e-01f, -8.35573971e-02f, -5.73705882e-02f, 2.91517866e-03f, 7.11774752e-02f, -4.03321832e-02f, 3.60831954e-02f, 8.62416327e-02f, -1.86854377e-02f, 1.63697358e-02f,
  -9.88937765e-02f, 8.35510641e-02f, 2.46804934e-02f, -5.57734864e-03f, -6.49690777e-02f, -3.66962217e-02f, 1.06101118e-01f, -9.50455442e-02f, -3.27051468e-02f, 5.41009121e-02f,
  -3.52049582e-02f, -3.14236269e-03f, -9.00574774e-02f, 3.82209681e-02f, -1.23431012e-02f, -5.70579246e-02f, 3.52495946e-02f, 5.04127070e-02f, 9.77950078e-03f, -1.54862404e-02f,
  1.71260595e-01f, 8.28891844e-02f, -4.03208658e-02f, -4.04624678e-02f, 1.49131352e-02f, -1.92429069e-02f, 1.54041382e-03f, 5.95604861e-03f, 5.56904674e-02f, -2.87888907e-02f,
  -1.39167532e-02f, -9.07411203e-02f, -6.12879135e-02f, -2.09827558e-03f, 2.05154400e-02f, -1.09560125e-01f, -6.64803162e-02f, -3.15480866e-02f, -5.49233221e-02f, -4.43824045e-02f,
  -7.53139853e-02f, 3.75559367e-02f, 3.40892486e-02f, 4.16021869e-02f, -2.05041133e-02f, 6.64001033e-02f, -7.59222731e-02f, 4.15676348e-02f, -1.35929659e-01f, -1.56904738e-02f,
  -3.26736301e-01f, -2.20160261e-01f, -6.32968843e-02f, -3.67425592e-03f, 1.42265111e-02f, -3.65072638e-02f, 1.66338161e-02f, -2.48239934e-03f, -1.14549331e-01f, 4.21864241e-02f,
  -3.18613127e-02f, 2.59630922e-02f, -1.22500755e-01f, 7.00444309e-03f, -1.12567097e-01f, -3.44078429e-02f, 1.63960829e-02f, -1.86358124e-01f, -1.64645225e-01f, -5.24017736e-02f,
  -1.22148685e-01f, 4.57379483e-02f, 6.54712915e-02f, 3.88499862e-03f, 2.48107109e-02f, 4.75269668e-02f, -5.45292161e-02f, 4.58065979e-02f, 6.27335608e-02f, -5.30188829e-02f,
  -2.66218692e-01f, 3.05150330e-01f, -2.98654884e-01f, 1.94354150e-02f, 5.27658425e-02f, 3.63406241e-01f, 2.95028657e-01f, 2.87665557e-02f, 8.90796334e-02f, 3.23910683e-01f,
  1.80295408e-01f, 7.99507201e-02f, 5.63116595e-02f, 2.82998830e-01f, 2.54011098e-02f, 1.08664036e-01f, 2.73664683e-01f, 2.42905885e-01f, -4.31225970e-02f, 2.16307212e-02f,
  -1.65112048e-01f, 1.80395678e-01f, -1.07381888e-01f, -3.80189158e-02f, 3.21853794e-02f, -2.12383941e-01f, -9.86627564e-02f, -1.96836263e-01f, 7.65608922e-02f, 8.39152038e-02f,
  7.24993721e-02f, -1.23010635e-01f, -2.52037849e-02f, -4.37512696e-02f, -1.34783506e-01f, -1.50427952e-01f, -7.80067295e-02f, -3.96981053e-02f, -1.24794640e-01f, -5.81630878e-02f,
  1.81969232e-03f, -2.90309712e-02f, 1.66176911e-03f, -9.27227661e-02f, -9.31522548e-02f, -2.53807148e-03f, 7.28095472e-02f, 7.94087648e-02f, 2.71877851e-02f, -3.50670144e-02f,
  -1.67501599e-01f, -6.00083470e-02f, 6.04909919e-02f, -1.77301336e-02f, -5.51156923e-02f, -6.05711248e-04f, 2.76385304e-02f, 1.50179258e-02f, 5.67808300e-02f, 4.09942644e-04f,
  1.40518649e-02f, -3.32191661e-02f, -6.72906116e-02f, 4.34771404e-02f, 2.68422458e-02f, 1.02242606e-03f, 7.12413341e-02f, 9.26132873e-02f, 5.70674147e-03f, 5.57339191e-02f,
  9.38042700e-02f, 6.01288937e-02f, -4.63899449e-02f, -1.60205772e-03f, -5.10208728e-03f, -1.44103222e-04f, -4.60524224e-02f, -6.78454265e-02f, 9.78988782e-03f, 5.45881949e-02f,
  -2.06831414e-02f, -1.85664017e-02f, 1.03511497e-01f, 6.67223111e-02f, -7.00369012e-04f, -6.88308179e-02f, -5.45022860e-02f, -2.13027559e-02f, 3.65443379e-02f, 2.84885173e-03f,
  3.59420598e-01f, 1.01054624e-01f, 5.67838512e-02f, -4.90146317e-02f, -5.81755675e-02f, -2.13662758e-02f, -2.95357686e-02f, -2.45821220e-03f, -2.78734546e-02f, -1.15932658e-01f,
  -6.82431608e-02f, -1.35286460e-02f, 5.82267670e-03f, -1.18585676e-02f, 6.69466779e-02f, 1.24765299e-01f, 7.31852353e-02f, 9.41521395e-03f, 3.94286290e-02f, -1.01694325e-02f,
  -3.30616012e-02f, 2.22345558e-03f, -6.15458898e-02f, 4.73181047e-02f, 9.09046531e-02f, 7.97897503e-02f, 3.96651998e-02f, 1.76355173e-03f, 7.16282055e-02f, 3.37317698e-02f,
  3.15319896e-01f, -1.07671224e-01f, -2.08155200e-01f, 2.52448320e-02f, -8.41287256e-04f, 5.83531708e-03f, -1.00355059e-01f, -4.74316105e-02f, -2.82740276e-02f, -6.47659227e-02f,
  2.38608997e-02f, 1.22867033e-01f, -1.75665140e-01f, 3.67852032e-01f, 2.51939923e-01f, -8.00922662e-02f, 2.31716901e-01f, 3.71386930e-02f, 2.90078223e-02f, 1.34840861e-01f,
  1.96273297e-01f, 4.37137276e-01f, 3.45849656e-02f, 5.27828857e-02f, 1.55991063e-01f, -1.08715303e-01f, 8.66294354e-02f, -9.77122635e-02f, 2.01175153e-01f, 7.58459643e-02f,
  5.10995016e-02f, 2.97505111e-02f, 2.95278174e-03f, 1.86602911e-03f, -3.49150486e-02f, 2.41378900e-02f, -2.84812506e-02f, -4.15201113e-02f, -5.62600568e-02f, -4.66580689e-02f,
  2.84951343e-03f, 1.04005843e-01f, -3.54988351e-02f, 7.70924389e-02f, 6.39020503e-02f, 3.94049324e-02f, 2.77679712e-02f, -4.94642034e-02f, -5.19165844e-02f, 1.53245807e-01f,
  -1.95319075e-02f, -4.26314622e-02f, -3.12693715e-02f, -2.33541839e-02f, -5.55592291e-02f, -6.64525479e-02f, -7.12559745e-02f, -5.75636066e-02f, 7.29074050e-03f, 6.91029131e-02f,
  1.05272822e-01f, -3.30823138e-02f, 7.02052563e-02f, -4.27554874e-03f, -7.27194129e-03f, -2.66089011e-02f, 4.09245165e-03f, -7.18237832e-02f, -6.41560629e-02f, 2.37310007e-02f,
  -1.20458283e-01f, 4.16086987e-03f, -2.58700848e-02f, 7.12553924e-03f, 4.17959355e-02f, -2.37703547e-02f, 1.54623529e-02f, -1.41593572e-02f, -1.03445493e-01f, -1.34280518e-01f,
  -1.95646156e-02f, 7.26717189e-02f, -2.59195715e-02f, -9.62189659e-02f, -9.71028488e-03f, -3.04186344e-02f, 1.79763034e-01f, 3.78340445e-02f, -1.00485772e-01f, -2.93816514e-02f,
  3.26479748e-02f, 1.00058049e-01f, -7.83039555e-02f, -4.19198908e-02f, -7.76349977e-02f, 1.59415051e-01f, 7.16232508e-02f, 2.47684624e-02f, -2.83565503e-02f, 1.49581786e-02f,
  4.64695804e-02f, -1.30810648e-01f, -9.88431126e-02f, 4.28768899e-03f, -1.69930413e-01f, -6.60722479e-02f, -7.52577034e-04f, -1.34862766e-01f, -4.56361659e-02f, 3.55802365e-02f,
  7.10631609e-02f, -3.34149711e-02f, -2.38509234e-02f, -2.62144748e-02f, -4.26560501e-03f, -1.87346600e-02f, -6.20440431e-02f, -1.17554748e-02f, 8.44305232e-02f, -4.48595881e-02f,
  5.22989571e-01f, -5.17116070e-01f, -1.53575882e-01f, 2.23141059e-01f, 2.61876762e-01f, 1.33885130e-01f, 2.63194889e-01f, -2.33934805e-01f, -8.37261304e-02f, -3.32602739e-01f,
  1.42791271e-01f, 2.78035793e-02f, -5.58408499e-02f, 1.20511077e-01f, 4.19442236e-01f, -1.16917387e-01f, 7.02437088e-02f, 4.43782099e-02f, -4.43759374e-03f, 2.53016241e-02f,
  2.44410217e-01f, 2.60066152e-01f, 5.12638353e-02f, -3.01496983e-01f, 1.65357739e-01f, -2.68613011e-01f, -7.19163865e-02f, -6.39769286e-02f, 3.15732136e-03f, 8.43848735e-02f,
  3.78431976e-02f, 4.11998071e-02f, 7.73149133e-02f, 1.95666701e-02f, -5.64981140e-02f, 1.80718765e-01f, 1.04023501e-01f, -1.97041426e-02f, 1.78079948e-01f, -1.42007298e-03f,
  -6.01604208e-02f, 8.88491198e-02f, -6.57949895e-02f, 7.55417719e-02f, 1.07405737e-01f, 1.74086005e-03f, 2.10466646e-02f, 6.77049858e-03f, -6.92167506e-02f, 5.03196418e-02f,
  5.04993610e-02f, -2.09470326e-03f, 5.63736819e-02f, -9.46040601e-02f, -5.78041114e-02f, -5.76960966e-02f, -2.16566190e-01f, -6.11503534e-02f, -1.10940039e-01f, -1.08912131e-02f,
  -5.03979810e-02f, -3.14977393e-02f, -1.81793713e-03f, 4.87596466e-04f, 5.26471585e-02f, 1.12181582e-01f, 8.40637386e-02f, -4.67465818e-02f, -1.99476220e-02f, -2.48589348e-02f,
  7.09980680e-03f, 4.68058363e-02f, -5.00352532e-02f, 1.44705754e-02f, -5.42538054e-02f, 4.36811671e-02f, 1.00226793e-02f, -7.52769858e-02f, 2.95323110e-03f, 1.23488833e-03f,
  5.75405657e-02f, -4.67677880e-03f, -3.96256968e-02f, -9.76789892e-02f, -4.75476384e-02f, 4.42786962e-02f, 5.09859957e-02f, 1.04487456e-01f, -3.24593969e-02f, 3.51773053e-02f,
  -8.01641047e-02f, -2.90694535e-01f, -9.10445079e-02f, -4.07025665e-02f, -3.25793251e-02f, 6.31085187e-02f, 3.75321843e-02f, -1.29206538e-01f, 1.74393435e-03f, 2.14542504e-02f,
  -2.73801237e-02f, -3.54052372e-02f, -1.10483430e-02f, 3.32975909e-02f, -8.10499117e-02f, -5.99493161e-02f, -3.35284099e-02f, -5.11587933e-02f, -2.24720966e-03f, -6.79129809e-02f,
  -5.65605052e-02f, -1.83248837e-02f, 4.36426178e-02f, -5.97967487e-03f, -1.23956457e-01f, -4.90105562e-02f, -8.98269042e-02f, 9.01309075e-04f, -8.13242495e-02f, -1.03547856e-01f,
  -4.00013089e-01f, -2.02804692e-02f, -2.79770792e-01f, -9.82728507e-03f, 4.26370949e-02f, 2.92863548e-01f, 9.36817378e-02f, -1.00316219e-01f, -2.71735817e-01f, 2.52820641e-01f,
  1.64585754e-01f, -2.64012486e-01f, -1.44025639e-01f, 2.64798820e-01f, -1.60689279e-01f, -3.78928669e-02f, 2.31641576e-01f, 1.12123683e-01f, -1.02796853e-01f, -1.59388304e-01f,
  -1.87095940e-01f, 1.59244508e-01f, -1.19943671e-01f, 1.12905271e-01f, 1.39804766e-01f, -2.76702194e-04f, 1.61902547e-01f, -1.76873818e-01f, 2.90074855e-01f, 2.92172283e-02f,
  2.83970423e-02f, -1.70937568e-01f, -6.70828372e-02f, -2.14715432e-02f, -2.31510922e-02f, 4.52462733e-02f, 3.55130322e-02f, 7.18940422e-02f, -5.34961857e-02f, -5.46960868e-02f,
  3.52801345e-02f, -1.03425846e-01f, 9.22527835e-02f, -1.59623563e-01f, -8.57504532e-02f, -7.76885301e-02f, 9.15414244e-02f, 4.56351489e-02f, 2.98274960e-02f, -1.68858737e-01f,
  -1.73072740e-01f, 9.26333144e-02f, 7.27271512e-02f, 1.02975540e-01f, -1.17590547e-01f, 4.63391170e-02f, -5.43036982e-02f, -6.59548724e-03f, 1.04179837e-01f, -2.21079085e-02f,
  1.71899870e-02f, 1.88830367e-03f, 3.79105285e-02f, 1.22946873e-02f, 2.23774984e-02f, 1.92530155e-01f, 1.49432555e-01f, 8.29792246e-02f, -3.58143821e-02f, -8.03954378e-02f,
  -2.13870090e-02f, -2.91316863e-02f, 3.76335122e-02f, 6.95347264e-02f, 9.57919657e-03f, 8.35521296e-02f, -2.63008736e-02f, -9.45370793e-02f, -1.09170847e-01f, 2.72936299e-02f,
  1.35286778e-01f, -1.33324072e-01f, 5.22208586e-02f, 6.98183104e-02f, 1.60218459e-02f, -1.43504024e-01f, -9.15406123e-02f, -8.93126503e-02f, 6.24494143e-02f, -7.30946846e-03f,
  1.36986062e-01f, -1.05428033e-01f, -2.53562927e-02f, 1.10589005e-01f, 1.25340801e-02f, 5.53705497e-03f, 6.94416910e-02f, 5.18124402e-02f, -4.24694158e-02f, -3.72790992e-02f,
  2.47343369e-02f, 3.85058597e-02f, 8.59408379e-02f, -6.79525062e-02f, -2.53503546e-02f, 4.02178150e-04f, 9.83863473e-02f, -7.93843642e-02f, 6.59354106e-02f, -7.35980365e-03f,
  -1.55836521e-02f, 6.87960461e-02f, -3.38278450e-02f, 2.78815702e-02f, -2.72835102e-02f, 1.13880374e-01f, 1.29128676e-02f, -6.48636324e-03f, 2.05696315e-01f, -5.93791418e-02f,
  1.96653262e-01f, -2.66997721e-02f, -2.22125530e-01f, -1.66436717e-01f, -4.44895513e-02f, -3.07168961e-01f, -3.09035122e-01f, -1.14469975e-01f, 6.52715564e-02f, 1.27183899e-01f,
  -1.35190904e-01f, 1.56780943e-01f, 6.99471235e-02f, -2.96566576e-01f, -2.21541449e-01f, -8.97175050e-04f, -3.13845515e-01f, -1.41438365e-01f, 5.13245910e-02f, -1.07860200e-01f,
  -9.85619798e-02f, -1.80964604e-01f, -1.17980920e-01f, -1.35549575e-01f, -2.00170696e-01f, -3.66027094e-02f, -4.95290570e-02f, -9.53589305e-02f, -1.65619433e-01f, -1.41991284e-02f,
  -1.18744671e-01f, 7.30535686e-02f, 1.11135943e-02f, 5.11149578e-02f, -5.36484718e-02f, 7.99794197e-02f, -5.24212569e-02f, -8.38891789e-02f, 1.09817572e-01f, 6.96551278e-02f,
  1.20671093e-01f, 1.38148785e-01f, 6.85187653e-02f, 8.51209015e-02f, -2.55132038e-02f, 2.63803676e-02f, -5.31352917e-03f, 4.30844985e-02f, 6.56547993e-02f, -2.78303958e-02f,
  2.14386042e-02f, 6.68537244e-02f, -1.79330073e-02f, 6.14606626e-02f, 5.94653077e-02f, -1.19713999e-01f, -8.55287090e-02f, 1.14544034e-02f, -4.38951477e-02f, 8.87141004e-02f,
  4.48901616e-02f, -6.58463836e-02f, -1.23250745e-01f, -2.51572002e-02f, -7.50043988e-02f, -1.47026554e-01f, -9.55838487e-02f, 1.19711794e-01f, -2.07469724e-02f, -1.25723584e-02f,
  -3.95771712e-02f, 1.09093646e-02f, -3.50009017e-02f, -2.84372419e-02f, 3.52567644e-03f, 1.68145001e-01f, -5.13418205e-02f, 2.05435976e-02f, -8.92028271e-04f, -1.09244600e-01f,
  -6.58872165e-03f, -9.85006094e-02f, -3.60771455e-02f, 5.25066443e-02f, -7.14152232e-02f, 8.73376057e-03f, 1.07887134e-01f, 3.27478871e-02f, -4.40198854e-02f, -3.59240547e-02f,
  -1.21981770e-01f, -6.72150776e-02f, 2.68433485e-02f, 6.03316948e-02f, 3.26002389e-02f, 4.77446914e-02f, -7.31133521e-02f, -1.00330032e-01f, -4.39691998e-04f, 3.97892445e-02f,
  -6.77532628e-02f, -1.13202306e-02f, 1.73732638e-01f, -1.17300553e-02f, 2.98774689e-02f, -1.57206759e-01f, 3.79505381e-02f, 8.26550126e-02f, 4.09439690e-02f, 1.39201377e-02f,
  4.13005240e-02f, 1.36828437e-01f, 8.16805139e-02f, -3.52538214e-03f, 7.67060518e-02f, 5.72711751e-02f, 2.89373212e-02f, -2.09198613e-02f, 5.71202114e-02f, 1.81146711e-01f,
  -3.94108742e-01f, -2.46007547e-01f, 1.66939035e-01f, 3.67251039e-02f, -5.38834836e-03f, -2.61210442e-01f, -3.39901537e-01f, -1.24834247e-01f, -1.74555048e-01f, -2.78393865e-01f,
  -2.68871129e-01f, 9.18400213e-02f, -1.74714327e-01f, 1.35181174e-01f, 4.00865704e-01f, 1.48402810e-01f, 1.27931088e-02f, 1.04488656e-01f, 1.89983591e-01f, -1.15085766e-01f,
  3.90077323e-01f, 2.28413686e-01f, 5.27826428e-01f, 1.79048583e-01f, 1.00849472e-01f, 2.07112923e-01f, 3.15135539e-01f, 2.50453264e-01f, 2.68874347e-01f, 1.39043018e-01f,
  -7.73190930e-02f, -2.14204282e-01f, 1.00382924e-01f, 4.46488336e-03f, -8.46012980e-02f, -8.97057056e-02f, -1.18006036e-01f, 8.65139961e-02f, -7.60326087e-02f, -5.84397800e-02f,
  9.98722315e-02f, 6.80024624e-02f, 1.42662197e-01f, 2.88665444e-02f, -9.53178555e-02f, 1.48721207e-02f, 1.65514320e-01f, -1.93611858e-03f, 7.39311427e-03f, -1.15891740e-01f,
  6.23990223e-02f, 6.87946007e-02f, -4.95823473e-02f, 1.77706018e-01f, 1.19322434e-01f, -1.58249676e-01f, 7.15867057e-02f, 1.48213223e-01f, 4.29060087e-02f, 4.02149744e-02f,
  -1.42062873e-01f, 2.05709785e-01f, 9.98420939e-02f, 9.62839127e-02f, -2.45683510e-02f, -5.62785342e-02f, -4.41072099e-02f, -3.73067632e-02f, 3.67100090e-02f, -3.22043896e-02f,
  4.23065387e-02f, -2.43905578e-02f, -1.00777656e-01f, -1.95257030e-02f, -1.52640103e-03f, -4.75231465e-03f, 4.14390266e-02f, 8.82983580e-02f, 6.38341904e-02f, 8.17445219e-02f,
  -1.94364339e-02f, -9.36761871e-02f, 1.57468878e-02f, 6.45153001e-02f, -1.70617431e-01f, 7.28266779e-03f, 1.10577866e-02f, -1.10854641e-01f, -2.23459117e-02f, 1.16279781e-01f,
  -1.33923918e-01f, 2.60740798e-02f, 9.53682438e-02f, -1.91911310e-02f, 3.58754732e-02f, -3.97111773e-02f, 7.92204887e-02f, 1.38036357e-02f, -1.26546130e-01f, 9.33400542e-03f,
  -1.83076952e-02f, 6.70849457e-02f, 2.04587951e-02f, -1.00500695e-01f, 1.31140456e-01f, -1.31623000e-01f, -6.41349182e-02f, -1.36860758e-01f, 4.40560803e-02f, -7.09054843e-02f,
  3.25457267e-02f, 5.61003399e-04f, 1.03271030e-01f, 6.03258424e-02f, 4.67932560e-02f, -6.14923723e-02f, -9.08756480e-02f, 7.11856503e-03f, 9.64592844e-02f, -3.45739685e-02f,
  -5.45880318e-01f, -1.20629191e-01f, -6.00069053e-02f, 6.48872554e-02f, -2.92797238e-02f, -8.64808410e-02f, -4.36636992e-02f, -9.46046710e-02f, -1.96581662e-01f, 1.20979033e-01f,
  3.64880040e-02f, -1.38656586e-01f, -8.88953954e-02f, 3.09448302e-01f, -1.18676394e-01f, 1.92742407e-01f, 2.20040739e-01f, 1.23038083e-01f, -8.12749192e-03f, -1.10126980e-01f,
  2.67390572e-02f, 1.83035836e-01f, 1.38901874e-01f, 1.10058576e-01f, -4.96947728e-02f, -3.94932330e-02f, 1.04229234e-01f, -8.55361968e-02f, 2.19838262e-01f, -3.41015607e-02f,
  -1.71198756e-01f, -4.00422290e-02f, 8.76641348e-02f, 9.24796984e-03f, -1.38383895e-01f, 4.96935062e-02f, -1.21540785e-01f, -8.26023147e-03f, -6.29136860e-02f, -6.41905367e-02f,
  -1.05202354e-01f, -9.08175111e-02f, 7.23223463e-02f, -1.59271955e-02f, -6.21803105e-02f, -5.53011782e-02f, -3.57415564e-02f, -1.94616336e-02f, -5.91120943e-02f, 1.01859495e-02f,
  3.87092531e-02f, -1.10039916e-02f, 9.42576602e-02f, 1.65531069e-01f, 1.72834173e-02f, -2.09740493e-02f, 1.24427885e-01f, -1.15797542e-01f, 2.22605895e-02f, 2.55596489e-02f,
  9.98432711e-02f, 4.97379936e-02f, 2.42038891e-02f, -9.57670435e-02f, -7.43016079e-02f, 1.38873328e-02f, 1.08710267e-01f, -2.14037318e-02f, -3.09779011e-02f, -1.80280022e-02f,
  1.73226148e-02f, 2.37307735e-02f, -1.12194538e-01f, -2.59933062e-02f, -1.77037474e-02f, -3.45163383e-02f, -1.23284012e-01f, -5.98298088e-02f, -7.11982399e-02f, 1.06739290e-01f,
  -2.20809486e-02f, 4.91594058e-03f, -1.15719642e-02f, 2.99218986e-02f, -4.58992086e-02f, -3.75138186e-02f, 5.90204680e-03f, -2.76651978e-02f, -4.53269705e-02f, -7.66926035e-02f,
  -3.99172425e-01f, -1.43208966e-01f, -1.26681983e-01f, 2.46422756e-02f, 8.41746628e-02f, 4.01274255e-03f, -6.05126768e-02f, 2.95250653e-03f, -7.59875253e-02f, -8.38803723e-02f,
  -3.22528221e-02f, 3.70338559e-02f, -1.05321564e-01f, -4.59836200e-02f, 9.12423953e-02f, -1.34684935e-01f, -7.81217888e-02f, -8.19640756e-02f, -8.76094550e-02f, -2.64122393e-02f,
  -4.85554151e-03f, -4.84682582e-02f, 7.96281621e-02f, 1.62657276e-01f, 6.46882504e-02f, -8.35024193e-03f, -7.94615373e-02f, -1.66096710e-04f, 2.43236683e-02f, 8.36837068e-02f,
  -6.34522557e-01f, 2.84446537e-01f, 7.76183186e-03f, -9.97560248e-02f, -1.42085418e-01f, -1.77790731e-01f, 1.49005741e-01f, 1.47708088e-01f, 1.52160287e-01f, 3.73823315e-01f,
  2.05122679e-01f, 9.28081572e-02f, 1.59457356e-01f, 2.39340901e-01f, -3.65621895e-01f, 8.94594789e-02f, -1.48659185e-01f, 5.38465269e-02f, -4.91601601e-02f, -1.51599750e-01f,
  -1.77589372e-01f, -5.40344119e-02f, -8.27418342e-02f, 1.88317429e-02f, -1.10688791e-01f, -2.79095806e-02f, -5.99144697e-02f, 2.36077476e-02f, -1.04132686e-02f, 7.15438724e-02f,
  -2.34220207e-01f, 1.23999499e-01f, 7.86554590e-02f, 3.51174474e-02f, -2.06325904e-01f, 3.56433615e-02f, -1.59172341e-01f, -4.31727991e-02f, 9.92236137e-02f, 1.35774480e-03f,
  -7.50325322e-02f, -1.03589281e-01f, 1.05463183e-02f, 1.18467599e-01f, 3.52222919e-02f, 4.90607470e-02f, 9.72118229e-03f, -6.44659400e-02f, 4.53478917e-02f, 2.81473622e-02f,
  1.07417442e-01f, -1.06514737e-01f, 8.72696936e-02f, -4.91408631e-02f, -7.25819310e-03f, 2.42882296e-02f, 2.41046418e-02f, -1.13610044e-01f, 3.49495281e-03f, 5.13181239e-02f,
  -2.24571973e-02f, -1.06587391e-02f, 1.29992828e-01f, 8.00611526e-02f, -4.70880512e-03f, -2.77226847e-02f, 1.27921626e-01f, -2.01225989e-02f, -9.09946412e-02f, -1.53708914e-02f,
  -8.96401238e-03f, 4.50460762e-02f, 5.09710871e-02f, -2.07399018e-02f, -6.53339848e-02f, 9.52367112e-02f, 2.01211553e-02f, 1.36042843e-02f, -2.20666841e-01f, -1.05292752e-01f,
  1.44739389e-01f, 3.82373855e-02f, 2.18570046e-02f, -9.08950493e-02f, 2.03831196e-02f, 3.86090651e-02f, -4.82478924e-02f, 1.31132364e-01f, -9.27425474e-02f, -1.67301953e-01f,
  -4.74457979e-01f, -2.71954089e-01f, -1.92796811e-03f, 1.76289931e-01f, 4.92198579e-02f, 7.35095739e-02f, -7.48413205e-02f, 1.54247340e-02f, 2.91583762e-02f, -8.51751212e-03f,
  -3.02094612e-02f, 2.62517165e-02f, -9.88200381e-02f, 3.60472947e-02f, -4.29503992e-02f, -7.89975747e-02f, -8.10140222e-02f, -6.00430332e-02f, -1.51287287e-01f, -9.52836499e-02f,
  4.63777408e-02f, -1.32907078e-01f, 6.04432896e-02f, 3.42627466e-02f, 4.82436828e-02f, -3.05157769e-02f, -1.15080550e-01f, 5.03688864e-02f, -1.05434455e-01f, -1.14440033e-02f,
  6.28685653e-02f, -3.60241175e-01f, -1.81284532e-01f, 2.94314593e-01f, 3.53038371e-01f, 1.40167981e-01f, -6.27108514e-02f, 2.02813938e-01f, 1.70199513e-01f, -2.20421210e-01f,
  1.19730391e-01f, 5.81504516e-02f, -4.01658803e-01f, 2.60861009e-01f, 2.81507909e-01f, -1.86182842e-01f, 3.56224984e-01f, 1.87103316e-01f, 1.23367772e-01f, -1.02457991e-02f,
  1.65855899e-01f, 3.13860714e-01f, -3.37441713e-02f, 1.34899765e-01f, -9.49352141e-03f, -4.48519476e-02f, -1.03748523e-01f, -2.29903877e-01f, 2.12997586e-01f, 1.42913789e-01f,
  1.18895791e-01f, -7.40345418e-02f, 1.45937512e-02f, 3.55742825e-03f, -5.71068041e-02f, -9.29764584e-02f, -7.40628242e-02f, -3.35213579e-02f, 4.51886058e-02f, -4.78771068e-02f,
  -9.52246040e-02f, 1.12980872e-01f, 9.60936099e-02f, 4.36654054e-02f, 1.26661122e-01f, 1.88924834e-01f, 4.95743528e-02f, 7.42875636e-02f, 1.38482332e-01f, -1.10019229e-01f,
  -7.06977174e-02f, 3.19696739e-02f, 5.61414175e-02f, 5.41506149e-02f, 3.45153990e-03f, 1.68320224e-01f, -1.92364838e-04f, -1.43316332e-02f, -6.66713982e-04f, 1.36152625e-01f,
  -3.14133391e-02f, -1.53315380e-01f, -1.32413313e-01f, -8.99550021e-02f, -4.09312621e-02f, 3.42241302e-02f, 9.91841778e-02f, -6.31133793e-04f, -4.73083183e-02f, -1.43417306e-02f,
  8.67273286e-02f, 8.42038542e-02f, 5.74689135e-02f, 4.75009792e-02f, -1.34891421e-02f, 2.78630294e-02f, 2.70708222e-02f, -1.55600123e-02f, 4.14667241e-02f, 5.23060076e-02f,
  -4.88803759e-02f, 6.64899647e-02f, -2.03883294e-02f, 2.70724837e-02f, 1.39960438e-01f, -7.49666169e-02f, -6.62548989e-02f, 7.94976503e-02f, -3.87597419e-02f, 2.60782652e-02f,
  -1.07173033e-01f, -3.73498827e-01f, 3.36714624e-03f, 1.14529863e-01f, 2.51617661e-04f, 1.15001470e-01f, 2.03073071e-03f, 1.39628693e-01f, 3.64663266e-02f, -1.08561255e-01f,
  8.50062966e-02f, -9.68718752e-02f, 4.46602292e-02f, 7.60851875e-02f, 1.06180713e-01f, -1.07880004e-01f, -1.01425052e-02f, 8.09654817e-02f, 2.09909707e-01f, 1.99433137e-02f,
  -1.50781304e-01f, -9.75825787e-02f, -1.13851239e-03f, 1.49072543e-01f, 4.56993058e-02f, 2.74271821e-03f, -8.36028950e-04f, 4.29469161e-03f, -9.17156041e-02f, 1.27684966e-01f,
  -5.81514537e-01f, 4.03778166e-01f, -7.26900101e-02f, -1.67008340e-01f, 1.20669648e-01f, -2.42962345e-01f, -2.21737877e-01f, 1.38004169e-01f, -9.05816033e-02f, -6.08238690e-02f,
  5.51177301e-02f, -3.90333161e-02f, -1.90407336e-02f, 1.54285561e-02f, -3.31092834e-01f, 5.65003753e-02f, -2.95041353e-01f, -2.16223434e-01f, 9.46405381e-02f, -5.99488355e-02f,
  -9.55461562e-02f, 1.80898264e-01f, 2.76692547e-02f, 3.46088737e-01f, -5.82108693e-03f, 6.23308867e-02f, -1.14699185e-01f, 2.12768376e-01f, -4.09494974e-02f, 1.99044511e-01f,
  -3.52265984e-01f, -1.63372412e-01f, -2.89405286e-01f, -1.33900061e-01f, -1.56371772e-01f, -1.44062206e-01f, -1.57081038e-01f, -3.49131562e-02f, 6.23173863e-02f, -8.15202743e-02f,
  -3.71739082e-02f, 2.44181976e-02f, 6.66056350e-02f, 1.05450444e-01f, -1.81786735e-02f, -4.24695127e-02f, -7.34918192e-02f, -8.45308974e-02f, -1.40388124e-02f, 1.20529644e-02f,
  1.46406963e-01f, -5.10883555e-02f, -1.08211286e-01f, -7.65403807e-02f, 4.19325952e-04f, -1.34046465e-01f, 2.50306055e-02f, -1.97422840e-02f, -9.56424028e-02f, -9.30845812e-02f,
  -1.21492399e-02f, -2.38573980e-02f, 2.62705553e-02f, 6.87998906e-02f, 9.85560492e-02f, 4.44796160e-02f, 7.71243870e-02f, 9.32435542e-02f, -3.91893163e-02f, -8.71967599e-02f,
  4.56064902e-02f, -3.93751003e-02f, 3.02457400e-02f, -6.79356158e-02f, -4.52787094e-02f, -1.70708895e-02f, -1.12673528e-02f, -2.23515090e-02f, 1.39664477e-02f, -1.57564431e-02f,
  -1.20199705e-02f, 1.18888207e-01f, -6.32668706e-03f, -2.86749266e-02f, -5.55755710e-03f, -5.88024792e-04f, 5.13930283e-02f, 3.42544429e-02f, -1.92609653e-01f, 9.10132676e-02f,
  -5.35575628e-01f, -3.45504135e-01f, -1.52466685e-01f, -5.61657436e-02f, -4.16559502e-02f, -1.15200698e-01f, 2.19499487e-02f, -2.09807381e-02f, -5.03645800e-02f, -1.02890968e-01f,
  -7.23861754e-02f, -4.27356623e-02f, 7.39447260e-03f, 1.90406363e-03f, 3.93439308e-02f, -6.12749159e-02f, -8.29246789e-02f, -3.08512303e-04f, -2.28179872e-01f, -3.86910327e-02f,
  -7.93121755e-02f, 1.47816343e-02f, -7.54966438e-02f, -5.87063283e-02f, -1.14562646e-01f, -1.26617188e-02f, 2.66503613e-03f, 6.52578287e-03f, -1.08424174e-02f, 1.56725779e-01f,
  2.07752451e-01f, 2.32994467e-01f, 2.17883825e-01f, 2.47503757e-01f, -2.17794389e-01f, -3.43510866e-01f, -1.79023072e-01f, -1.19393393e-01f, 1.74491107e-01f, -6.06080368e-02f,
  -2.57289410e-01f, 3.07207793e-01f, -1.70873642e-01f, 9.73104462e-02f, 9.26664397e-02f, -9.68181193e-02f, 1.43285275e-01f, -8.66837874e-02f, 7.17384741e-02f, 1.76657379e-01f,
  1.78251445e-01f, -7.78120384e-02f, 5.20522222e-02f, -1.12357639e-01f, 1.39636826e-02f, 1.45127565e-01f, 5.20807654e-02f, -8.85410458e-02f, 3.83942835e-02f, -7.55671412e-02f,
  -4.83880080e-02f, 2.37454429e-01f, -3.42839696e-02f, 4.48583402e-02f, 3.86238135e-02f, -3.40029858e-02f, -1.33879101e-02f, 9.51295253e-03f, 1.56236161e-02f, 2.47018654e-02f,
  5.50739616e-02f, 4.89562638e-02f, 9.02984217e-02f, -1.05007790e-01f, -1.13653295e-01f, 1.74823813e-02f, 3.73003893e-02f, 8.55616666e-03f, 6.23366199e-02f, 3.68497968e-02f,
  1.71315223e-01f, 8.48990530e-02f, 1.26702562e-01f, 1.43576130e-01f, 1.76869214e-01f, 1.74171887e-02f, 5.38218841e-02f, 8.49917233e-02f, 7.10697770e-02f, 2.14359179e-01f,
  6.95484057e-02f, -1.97508913e-02f, -2.67501753e-02f, -1.12541981e-01f, 3.47372591e-02f, 3.23671335e-03f, -2.54519656e-02f, -2.75847837e-02f, -1.88393500e-02f, -2.19743606e-02f,
  -4.50212173e-02f, -8.38254318e-02f, -6.73200935e-02f, 3.73751298e-02f, 9.61733311e-02f, 3.38569134e-02f, -6.13832250e-02f, -1.85104534e-01f, 1.48255736e-01f, 3.80506366e-02f,
  -3.87892537e-02f, -6.98483363e-02f, 5.45193106e-02f, 4.43126969e-02f, -2.13984489e-01f, -5.55329360e-02f, 6.90755248e-02f, 6.40418380e-02f, -1.82771757e-01f, 4.82571200e-02f,
  7.67433345e-02f, 4.38419163e-01f, 1.32865787e-01f, 4.84933853e-02f, -1.15179503e-02f, 2.63387989e-02f, 3.51663344e-02f, 1.12694420e-01f, 1.34912178e-01f, 8.68361369e-02f,
  4.88202013e-02f, -7.45212659e-02f, 8.78216606e-03f, -1.10701784e-01f, -2.27104430e-03f, 1.39410123e-01f, 7.99886882e-02f, 1.12488993e-01f, 1.95443079e-01f, -3.97917032e-02f,
  6.51126727e-02f, -2.09644791e-02f, 1.84668094e-01f, 7.40873814e-02f, 7.58469105e-02f, 9.15386379e-02f, -8.02331939e-02f, 6.97754174e-02f, 1.06759422e-01f, 1.21757127e-01f,
  -2.27220774e-01f, 2.05369800e-01f, 8.70365724e-02f, 1.99668407e-01f, -1.30564705e-01f, 3.46722491e-02f, 2.34151736e-01f, -1.77258998e-02f, 4.32589352e-01f, 1.98411927e-01f,
  -2.96263337e-01f, 6.08653538e-02f, 8.96482766e-02f, -1.01887016e-02f, 2.53055125e-01f, 9.03378353e-02f, 6.48855492e-02f, 1.04143046e-01f, 7.83931538e-02f, -1.81897078e-02f,
  1.12213679e-01f, -5.76532492e-03f, -1.28621310e-01f, -6.54047653e-02f, -2.59023756e-01f, -1.20748691e-02f, -1.14934230e-02f, 5.22767454e-02f, -1.70772597e-01f, -2.54259314e-02f,
  -2.07152143e-01f, -5.71571151e-03f, -5.28982356e-02f, -1.15590498e-01f, -1.37834266e-01f, -1.24586821e-01f, 5.29455729e-02f, -3.76054877e-03f, 3.79850045e-02f, -6.99296072e-02f,
  5.43546900e-02f, -7.67753571e-02f, 1.04941830e-01f, 1.13901481e-01f, -9.24138259e-03f, -4.05592620e-02f, -1.47287786e-01f, -1.91799715e-01f, -9.57754329e-02f, -7.18726218e-02f,
  -5.65788187e-02f, -4.29161713e-02f, -1.05522797e-01f, -8.63361135e-02f, -7.13768080e-02f, -5.30000888e-02f, -1.74699689e-03f, -7.15456903e-02f, -5.57882385e-03f, 5.20298593e-02f,
  5.97065091e-02f, 1.11683264e-01f, -3.42366584e-02f, 1.10354612e-03f, -4.49469239e-02f, -1.58891547e-02f, 7.15609789e-02f, -1.29403189e-01f, -1.98631525e-01f, -3.85468043e-02f,
  -2.04023808e-01f, -1.31063417e-01f, -1.30696073e-01f, -7.20094368e-02f, -7.33950958e-02f, -7.34253302e-02f, 2.10442916e-02f, 2.23310459e-02f, -8.77612159e-02f, 2.06307508e-02f,
  1.46940440e-01f, -6.99682608e-02f, -1.08558618e-01f, -1.77563444e-01f, 4.66844775e-02f, 5.74057084e-03f, 5.83982430e-02f, -5.24683185e-02f, 1.07466631e-01f, -3.86303999e-02f,
  1.08978122e-01f, 3.54094356e-01f, -2.85509024e-02f, -1.82745531e-01f, 1.14510439e-01f, -9.37452540e-02f, 1.58568189e-01f, 5.96686751e-02f, 1.69782460e-01f, 3.82749061e-03f,
  2.08560396e-02f, -6.74350038e-02f, -7.44882002e-02f, 3.44779454e-02f, 1.09240815e-01f, 6.52612522e-02f, 1.62009984e-01f, 2.38882564e-02f, -3.22364420e-02f, -4.41087112e-02f,
  7.39571005e-02f, 1.12351894e-01f, -2.78863963e-02f, -1.02286585e-01f, -3.12328227e-02f, -1.54284120e-01f, -4.13566381e-02f, -1.47601351e-01f, -6.19733967e-02f, -6.78305775e-02f,
  -2.43669003e-02f, -1.87630489e-01f, 3.14339727e-01f, 4.27139830e-03f, -6.02482446e-02f, 1.75331295e-01f, 3.47075969e-01f, -3.71878833e-01f, -4.53351289e-01f, -5.53984046e-02f,
  -6.40009418e-02f, 2.67981321e-01f, 2.98427612e-01f, -1.97689220e-01f, 2.62019634e-01f, -2.11379603e-02f, -1.98726475e-01f, 1.46430105e-01f, -2.53556550e-01f, -8.02383274e-02f,
  -1.50861393e-03f, -1.35195032e-01f, 2.71476477e-01f, -2.65633523e-01f, 7.19038099e-02f, 5.71157085e-03f, -2.14416701e-02f, 2.21361458e-01f, -3.53734270e-02f, 1.89118236e-01f,
  -1.12895019e-01f, -1.96506381e-01f, 1.82154290e-02f, -9.74695683e-02f, -9.70951393e-02f, 9.11340788e-02f, 1.69429898e-01f, 2.39113823e-01f, 7.52959177e-02f, 4.15701717e-02f,
  1.01924174e-01f, -9.38242376e-02f, -1.64618090e-01f, 5.70543557e-02f, -8.08532834e-02f, -1.60535023e-01f, -5.18751703e-02f, -4.23076488e-02f, -6.04701490e-05f, 1.20223552e-01f,
  8.40567723e-02f, 8.66369233e-02f, 3.33129987e-02f, 4.68302779e-02f, -1.17927212e-02f, -2.67934427e-02f, -8.22104514e-03f, 2.45452851e-01f, 8.04332644e-02f, 2.76583619e-02f,
  -1.76412947e-02f, -3.21875811e-02f, -6.25238419e-02f, -9.69510749e-02f, -8.63224640e-02f, -4.78601083e-02f, 4.22408991e-03f, -7.70005956e-02f, 1.87868401e-02f, -2.64379736e-02f,
  -8.44219625e-02f, -1.19126499e-01f, -1.09602407e-01f, -2.53245980e-02f, -5.25808558e-02f, -2.56929368e-01f, 1.42210796e-01f, -3.38522741e-03f, -4.05795909e-02f, -2.02940311e-02f,
  1.36438925e-02f, -4.64417078e-02f, -7.71573186e-02f, 3.01853521e-04f, -1.05814300e-01f, 6.58157393e-02f, -6.83408405e-04f, -4.15937118e-02f, -8.11559409e-02f, 1.35559112e-01f,
  -3.62046845e-02f, -1.20138161e-01f, -9.59746912e-02f, 4.61754948e-02f, 5.51013276e-02f, 3.59046794e-02f, -2.60421988e-02f, -4.64001633e-02f, 3.98435770e-03f, -8.33079815e-02f,
  -1.57258958e-02f, 2.98410133e-02f, -7.59319589e-02f, -4.18161526e-02f, 2.51478143e-02f, -8.07006881e-02f, -4.79217544e-02f, 3.76081876e-02f, 4.92457226e-02f, -1.37843676e-02f,
  1.28596425e-01f, 8.54877681e-02f, 3.61473747e-02f, -2.33249366e-02f, -6.33904710e-02f, 5.07047586e-02f, -6.84835613e-02f, 7.37101138e-02f, 6.59235707e-03f, 8.73967260e-02f,
  -1.46216795e-01f, -4.09085564e-02f, -8.45957324e-02f, -3.91592950e-01f, 9.08371583e-02f, 1.70544416e-01f, -8.44357908e-02f, 1.50889978e-01f, -2.05197036e-01f, 2.28861153e-01f,
  6.02918975e-02f, -3.34459096e-01f, 4.47736271e-02f, -3.10319722e-01f, -3.21534336e-01f, -2.19720900e-01f, -2.67616719e-01f, -1.13245048e-01f, -1.65663391e-01f, 1.96764078e-02f,
  -1.59475103e-01f, -8.10630023e-02f, -1.63946986e-01f, 2.65813023e-01f, 1.16025358e-01f, 8.97259042e-02f, 2.31535316e-01f, 2.46836409e-01f, 6.44845366e-02f, 4.16961350e-02f,
  4.32739407e-02f, 3.45065929e-02f, 1.10047989e-01f, -2.36056577e-02f, 2.22873196e-01f, 9.41048115e-02f, 1.43456221e-01f, -3.31026129e-02f, -1.81823775e-01f, -1.66058969e-02f,
  1.00311534e-02f, -1.20786779e-01f, -1.23564899e-02f, 3.22973728e-02f, 2.48888712e-02f, 3.28490883e-02f, -4.14445475e-02f, 2.57016886e-02f, -1.23279750e-01f, -1.17722787e-01f,
  -9.46044996e-02f, -1.33162573e-01f, -2.49925908e-03f, -5.77463731e-02f, -9.15366337e-02f, -6.31280243e-02f, 7.41382167e-02f, 3.93036641e-02f, -8.50156248e-02f, -6.95120841e-02f,
  1.24046132e-01f, 8.66771415e-02f, 3.15733925e-02f, 1.73345092e-03f, 1.63625292e-02f, 2.65532117e-02f, -1.68325733e-02f, 1.30085023e-02f, -2.43496802e-02f, 7.04180226e-02f,
  -5.46221957e-02f, 5.58549725e-03f, 3.37212346e-02f, -3.80518064e-02f, 2.60179788e-02f, 1.06681939e-02f, 1.27115518e-01f, 3.16241160e-02f, -1.66950330e-01f, -2.05076877e-02f,
  3.41638364e-02f, 3.10533866e-02f, 6.11087531e-02f, 1.06059715e-01f, 1.78814009e-02f, -2.13670451e-02f, 3.17164860e-03f, -1.37869911e-02f, 9.28584933e-02f, 9.00746137e-02f,
  4.35000435e-02f, 1.31251976e-01f, 3.20290476e-02f, -6.88992664e-02f, 4.76950929e-02f, 7.13511184e-02f, 1.75935891e-03f, -5.64125217e-02f, -3.77007462e-02f, 8.38605836e-02f,
  6.30937666e-02f, 4.09930348e-02f, 1.32920230e-02f, -1.44016398e-02f, -9.89123210e-02f, 1.97368592e-01f, -1.52977565e-02f, 2.29152478e-02f, -3.91786769e-02f, 6.75002038e-02f,
  9.81425568e-02f, -3.80552672e-02f, -1.27733365e-01f, -5.65825552e-02f, -5.68728149e-02f, 5.32480627e-02f, 1.39874488e-01f, -2.28587762e-02f, 1.03056664e-02f, -3.37137580e-02f,
  -2.87608176e-01f, 1.98178872e-01f, -1.86965719e-01f, 3.25382054e-01f, -1.77626625e-01f, -1.42123044e-01f, -5.57767041e-03f, -4.73365374e-03f, -2.54425883e-01f, 1.90134272e-01f,
  3.20014656e-01f, -1.76429048e-01f, 1.48990676e-01f, 4.60317254e-01f, 9.69353840e-02f, 3.10886353e-01f, 3.68025094e-01f, 1.17504776e-01f, 6.50928542e-02f, 1.80195108e-01f,
  5.53745739e-02f, 2.50820637e-01f, 3.08385372e-01f, 1.65674672e-01f, 7.37109557e-02f, 4.52928850e-03f, 1.10071175e-01f, -1.07165247e-01f, 1.89100012e-01f, -8.63618851e-02f,
  -5.36552304e-03f, 6.65158406e-02f, -3.94214466e-02f, -1.30754784e-01f, 1.70101877e-03f, -5.97235672e-02f, -2.69148108e-02f, -3.10516581e-02f, -2.53406167e-02f, -3.81384604e-02f,
  -4.93099540e-02f, -4.87422198e-03f, 6.70261830e-02f, 1.85340876e-03f, -1.45317791e-02f, -6.38905317e-02f, 3.68727334e-02f, -9.56911370e-02f, 2.10335143e-02f, 6.36814386e-02f,
  1.23870578e-02f, 7.47325346e-02f, 6.03414774e-02f, 3.93841155e-02f, -6.78232759e-02f, -2.10413281e-02f, -8.09998363e-02f, -7.08444864e-02f, -2.99759358e-02f, -1.33182071e-02f,
  -1.67167336e-02f, 1.22754984e-02f, 6.47832602e-02f, 4.56648357e-02f, -3.77824381e-02f, 3.88643108e-02f, -3.57597731e-02f, 3.50596048e-02f, -1.55126572e-01f, 1.18578911e-01f,
  1.18125789e-01f, 2.10782560e-03f, -1.49689456e-02f, 7.94245582e-03f, -3.97951044e-02f, -8.84207264e-02f, 2.31596045e-02f, 2.61880904e-02f, -1.30405398e-02f, -3.05307824e-02f,
  -1.61987711e-02f, -2.49479618e-02f, 2.43880544e-02f, 7.83110335e-02f, 2.82673929e-02f, -2.44511273e-02f, 5.87439106e-04f, 2.89262440e-02f, 5.14400266e-02f, -5.98558597e-02f,
  1.62228882e-01f, 1.28036991e-01f, -1.07287690e-02f, -5.93231730e-02f, 3.44860032e-02f, -4.84094284e-02f, -6.27414137e-02f, -5.06770276e-02f, 8.41486901e-02f, -9.49745066e-03f,
  2.73163579e-02f, -1.53431043e-01f, 1.55396998e-01f, -4.36491407e-02f, -3.41200568e-02f, -5.68357706e-02f, 1.17726736e-01f, -5.90955466e-02f, -2.38504843e-03f, 2.18252391e-02f,
  1.06667444e-01f, 3.00228912e-02f, 1.87918451e-02f, -2.32251221e-03f, 7.49322847e-02f, 2.87883412e-02f, -1.09472603e-01f, -3.99832763e-02f, 9.61577743e-02f, -2.02726480e-02f,
  -2.91188180e-01f, -7.60346279e-02f, 3.69050503e-02f, 3.29646915e-01f, 1.16384096e-01f, -1.75969243e-01f, -1.36217013e-01f, 1.50706962e-01f, -1.61409095e-01f, -3.96676734e-02f,
  2.08076704e-02f, 1.88493002e-02f, -2.25547373e-01f, 1.54187381e-01f, 4.14606303e-01f, -8.34384710e-02f, 7.63801113e-02f, -2.31735758e-03f, -3.12745422e-02f, 6.72022477e-02f,
  1.15731820e-01f, 1.42201766e-01f, 2.64513969e-01f, 1.72691002e-01f, 8.65534022e-02f, 1.22363389e-01f, 3.79734010e-01f, 2.14472696e-01f, 3.35279495e-01f, 1.80931345e-01f,
  -1.02778532e-01f, -4.27767560e-02f, -7.24987537e-02f, -6.54836372e-02f, -1.03042088e-02f, 4.66144234e-02f, 5.21377660e-02f, 1.12057395e-01f, 1.94404833e-02f, 3.01706679e-02f,
  3.73424105e-02f, 9.18905511e-02f, -2.28077956e-02f, 9.14539471e-02f, 4.78884671e-03f, 1.18220374e-01f, -2.73512602e-02f, -2.10922863e-02f, 6.18999712e-02f, -5.20386286e-02f,
  -8.55041668e-02f, -1.20501518e-02f, -2.79151928e-02f, 1.08928047e-02f, -2.97312182e-03f, -4.70190495e-03f, -7.16701001e-02f, 8.93463120e-02f, -6.57798201e-02f, 1.01671770e-01f,
  -7.69273117e-02f, -5.16337401e-04f, -2.07588196e-01f, -5.45541458e-02f, 9.01098270e-03f, 4.34818119e-02f, -1.14217408e-01f, -1.01464532e-01f, 3.14728618e-02f, 1.55634597e-01f,
  1.34623796e-01f, 6.99106976e-02f, -5.44655845e-02f, -2.87317857e-02f, 3.22800875e-02f, -1.19944781e-01f, 8.33497196e-02f, 3.18345577e-02f, -1.35576844e-01f, 2.51073521e-02f,
  -3.00366860e-02f, 1.15449153e-01f, 8.83909613e-02f, -5.11405952e-02f, -9.19257626e-02f, 1.13382630e-01f, -1.71536747e-02f, 2.22541541e-02f, 4.53316197e-02f, 1.52549148e-02f,
  3.44188549e-02f, 1.28690675e-01f, -1.74403023e-02f, -1.04976356e-01f, 2.10871045e-02f, 1.62493512e-01f, -8.41384009e-02f, 3.12438197e-02f, 3.23621854e-02f, 1.31447706e-02f,
  2.06073865e-01f, 5.94121106e-02f, 6.95074871e-02f, 1.10946469e-01f, 1.03603058e-01f, 5.23635522e-02f, -8.37043207e-03f, 4.98939119e-02f, 9.56906825e-02f, 8.76928642e-02f,
  5.13089038e-02f, -8.74791890e-02f, 2.87488084e-02f, -1.04113080e-01f, -5.98571710e-02f, -2.09582187e-02f, -2.91409623e-03f, -1.28894737e-02f, -3.30486521e-02f, 2.11416334e-02f,
  1.04633644e-01f, -1.93737552e-01f, -1.41387582e-01f, -1.71288580e-01f, 4.37973440e-02f, -1.22026585e-01f, -1.18807532e-01f, -1.78071871e-01f, -1.91111609e-01f, -2.14730352e-01f,
  -1.24059387e-01f, 1.46042570e-01f, 1.50384679e-01f, -2.54442275e-01f, 2.89010048e-01f, 1.96828499e-01f, -2.53446370e-01f, -7.20579475e-02f, -5.94841689e-02f, -2.16433093e-01f,
  -6.27096072e-02f, -2.39027590e-01f, 5.60048297e-02f, -2.20867857e-01f, -1.97177500e-01f, -1.07860856e-01f, 1.09248884e-01f, -8.29953775e-02f, -1.52382001e-01f, 7.13464171e-02f,
  -8.05488825e-02f, -1.50394157e-01f, -5.47662303e-02f, -2.73176078e-02f, -1.31439105e-01f, -3.44342068e-02f, 3.04948837e-02f, 7.48565700e-03f, 2.40194481e-02f, -9.22555849e-02f,
  5.07080592e-02f, 1.29809016e-02f, -1.37413010e-01f, 1.48403570e-01f, -2.91201603e-02f, -8.56694654e-02f, 6.18402511e-02f, 6.11622296e-02f, 2.68143620e-02f, 9.17925313e-02f,
  -6.65274933e-02f, 7.23050022e-03f, -3.30797359e-02f, 4.73571084e-02f, -7.28696585e-03f, -5.24768345e-02f, 1.08211953e-02f, 7.09723681e-02f, 5.12600504e-02f, 1.64821167e-02f,
  -7.04332218e-02f, 5.77728786e-02f, -3.73725183e-02f, -8.39000791e-02f, -1.52189247e-02f, 1.28492549e-01f, 5.20819090e-02f, 4.41984087e-02f, 4.47076522e-02f, -4.07877602e-02f,
  -1.41390234e-01f, 4.67709899e-02f, -2.08202899e-02f, -3.11389323e-02f, 5.12692379e-03f, 6.10769019e-02f, -1.66555401e-02f, -4.41143755e-03f, -1.55531257e-01f, 1.56401377e-02f,
  3.33038755e-02f, -4.29154746e-02f, -1.35703310e-01f, 3.84759507e-03f, -8.90386254e-02f, -1.84151884e-02f, -2.99871024e-02f, -7.30146691e-02f, -6.68229386e-02f, -4.33075521e-03f,
  -2.14568190e-02f, -2.21262082e-01f, -9.89442915e-02f, -4.50981669e-02f, 8.32211748e-02f, -4.24697883e-02f, -4.63267043e-02f, -1.62408948e-01f, -7.30342492e-02f, -1.97220355e-01f,
  -6.81010857e-02f, 7.25619718e-02f, 1.47769013e-02f, 9.97960344e-02f, -4.58429009e-02f, -5.51603809e-02f, 6.45837188e-02f, 4.53122444e-02f, 2.21924409e-02f, 3.61724831e-02f,
  -9.96275544e-02f, 1.11881541e-02f, 9.35311019e-02f, -9.26964730e-02f, 6.50651846e-03f, 6.98221177e-02f, 6.36640936e-02f, -6.50060847e-02f, 8.61613899e-02f, -2.43116673e-02f,
  -2.61547536e-01f, -4.39552069e-02f, -1.87504664e-01f, -2.64337599e-01f, 7.62918741e-02f, -8.78026560e-02f, -1.64818093e-01f, 6.86343610e-02f, -1.36891812e-01f, 1.65816203e-01f,
  -2.76025422e-02f, -1.98012903e-01f, 1.13052584e-01f, -4.60206926e-01f, -6.07508719e-01f, -3.48244101e-01f, -3.30557585e-01f, -2.61173487e-01f, -1.52100444e-01f, -3.18079703e-02f,
  -1.70351967e-01f, -1.87406912e-01f, -1.86883450e-01f, 1.62983492e-01f, -5.38558029e-02f, 2.64234215e-01f, 2.51217365e-01f, 1.70956194e-01f, 1.01850778e-01f, 2.78477371e-03f,
  -2.14171663e-01f, -2.82622091e-02f, -2.94400267e-02f, -7.16351205e-03f, 4.47922386e-02f, 1.37964934e-01f, 8.80062953e-02f, -1.01830788e-01f, 4.11244929e-02f, 4.65993844e-02f,
  1.22448899e-01f, 6.76051974e-02f, -9.49172750e-02f, -1.94656346e-02f, -8.79430305e-03f, 8.61894991e-03f, -3.77810247e-05f, 1.09003633e-01f, -2.04965323e-02f, -1.02759883e-01f,
  -4.74034399e-02f, -6.02276511e-02f, 1.23426586e-01f, 1.02104791e-01f, 1.38559956e-02f, 3.75934616e-02f, -5.26517779e-02f, 1.50498077e-01f, 9.82231498e-02f, 3.04968543e-02f,
  9.22115371e-02f, -5.79105504e-02f, -1.45152077e-01f, -1.92208201e-01f, -1.04720041e-01f, -6.39339611e-02f, -2.59363949e-02f, -1.10615352e-02f, 4.62953635e-02f, -3.28613445e-02f,
  -4.59768949e-03f, -1.03291035e-01f, -1.70815326e-02f, 7.68803060e-02f, -8.30270350e-02f, -1.60035014e-01f, -1.11025255e-02f, 5.82449436e-02f, 8.80555436e-02f, -4.18022461e-02f,
  -1.37883410e-01f, 2.07044445e-02f, -2.97128800e-02f, 8.86231437e-02f, -1.61634713e-01f, -4.18056399e-02f, 1.31273016e-01f, -6.87716380e-02f, -4.94198725e-02f, 1.09324001e-01f,
  6.71525225e-02f, 1.41272500e-01f, -1.39458673e-02f, -2.26231869e-02f, -5.39264232e-02f, 4.63195927e-02f, -2.17267781e-01f, -1.24586716e-01f, 4.32822853e-02f, 3.99037972e-02f,
  1.32023647e-01f, 7.27757812e-02f, 1.89664230e-01f, -3.45729180e-02f, -1.79804824e-02f, 1.67813711e-02f, 6.89421967e-02f, 9.65164602e-02f, 2.19821304e-01f, -6.40253648e-02f,
  1.42574966e-01f, 4.46894690e-02f, 2.32260418e-03f, -1.14398636e-02f, 1.21195443e-01f, 1.66758373e-01f, 1.11128174e-01f, 3.38834785e-02f, 1.30401224e-01f, 7.68584758e-02f,
  3.01561117e-01f, 1.17378786e-01f, 3.31231147e-01f, 4.88545656e-01f, 9.44404081e-02f, -3.16638380e-01f, -1.24853857e-01f, 2.79866666e-01f, 3.44434083e-01f, -1.49628788e-01f,
  -7.01744482e-02f, -3.49877812e-02f, -7.36299530e-02f, 2.93171227e-01f, -4.22143519e-01f, -1.61284372e-01f, -4.03997712e-02f, -2.08101631e-03f, 2.45910846e-02f, 4.66605388e-02f,
  7.42235780e-02f, -1.56791627e-01f, 1.05897859e-01f, 3.60067338e-02f, 3.85798544e-01f, 2.36202657e-01f, -1.72485799e-01f, -9.96924099e-03f, 9.77481082e-02f, -2.64646202e-01f,
  -1.35438770e-01f, 4.11114424e-01f, 1.22198828e-01f, 9.45387334e-02f, 7.66255483e-02f, -1.60034195e-01f, -5.36095873e-02f, -7.52076283e-02f, -6.88908100e-02f, -4.53441329e-02f,
  2.82212477e-02f, -2.37957314e-02f, 1.12496326e-02f, -6.26977533e-02f, 2.76290998e-02f, 1.40880764e-01f, 1.13240682e-01f, 1.64610192e-01f, 1.18030287e-01f, 1.20004967e-01f,
  1.63303912e-01f, 8.23704377e-02f, -2.30004769e-02f, -7.25041553e-02f, 9.99676660e-02f, 5.90035133e-02f, -5.18953912e-02f, -9.79735404e-02f, 1.03941970e-01f, 5.87454773e-02f,
  1.89216748e-01f, -1.22297652e-01f, -3.12673673e-02f, -1.39006348e-02f, -5.39700277e-02f, 1.37891039e-01f, -1.11441091e-01f, -1.00561000e-01f, 3.31866890e-02f, -7.22627193e-02f,
  -1.50714949e-01f, 3.81152406e-02f, 6.41771629e-02f, 7.94625431e-02f, 9.98205766e-02f, 1.49998352e-01f, -1.76510662e-01f, -5.83745167e-02f, 6.87598810e-02f, 7.54909590e-02f,
  1.36698887e-01f, -1.17080070e-01f, 1.56483650e-02f, -1.23126402e-01f, -6.27595112e-02f, 3.57492827e-02f, 1.72615916e-01f, 1.32654041e-01f, 1.10572400e-02f, -9.87904295e-02f,
  -3.40388268e-01f, -1.65386945e-02f, -1.01399533e-01f, -8.85336027e-02f, -2.47681458e-02f, -8.17216039e-02f, 2.63050534e-02f, -1.08239211e-01f, -4.26314771e-02f, -4.62292619e-02f,
  -7.94363916e-02f, -4.02346551e-02f, -1.96224511e-01f, -7.13169873e-02f, -1.25808686e-01f, -4.20860350e-02f, -9.34503675e-02f, -2.20642984e-01f, -1.55723453e-01f, 3.79992872e-02f,
  -2.40377728e-02f, 3.60094942e-02f, -6.24181814e-02f, -9.55720246e-02f, -5.61885238e-02f, 3.33541725e-03f, -1.74828723e-01f, 4.05117162e-02f, -7.82221183e-02f, -9.33431610e-02f,
  -5.31646013e-01f, 1.60698190e-01f, 1.16348550e-01f, -1.40054077e-01f, -5.97796552e-02f, -1.03601143e-02f, -6.46133274e-02f, 1.10094368e-01f, -1.42931432e-01f, 1.13061607e-01f,
  9.86761674e-02f, -1.12856254e-01f, 1.76575974e-01f, -8.27371180e-02f, 5.86273149e-02f, 1.31288871e-01f, -1.11704931e-01f, -7.71653354e-02f, 9.01938230e-03f, -6.79576620e-02f,
  -1.00650392e-01f, -8.53327885e-02f, 1.00606985e-01f, 1.57074347e-01f, -1.47044390e-01f, 4.88849496e-03f, -4.39074896e-02f, 2.12135240e-01f, -1.65240109e-01f, 6.68651015e-02f,
  -3.60068195e-02f, 2.69630086e-02f, -1.73698798e-01f, -3.70998792e-02f, -1.42061785e-01f, -8.20069239e-02f, -3.93335894e-02f, -1.01028271e-01f, -3.37669179e-02f, 1.91481709e-02f,
  -8.05366114e-02f, 9.18885022e-02f, 7.11350888e-02f, 3.30632506e-03f, -1.28155708e-01f, -6.10731766e-02f, 2.31447164e-04f, -7.33505934e-02f, -1.70550887e-02f, 3.34302452e-03f,
  8.64966512e-02f, -3.77490558e-02f, 2.96989996e-02f, 1.55604202e-02f, 1.10227205e-01f, 2.96314415e-02f, -6.30223304e-02f, -9.36678797e-02f, -5.37915155e-02f, 8.06398094e-02f,
  -8.83231834e-02f, 6.27682963e-03f, -7.67047480e-02f, 3.20418589e-02f, -2.20638942e-02f, 9.42802206e-02f, 1.03106415e-02f, -6.35431111e-02f, -8.09397399e-02f, -5.82772121e-03f,
  4.65369411e-03f, 1.00703619e-01f, 4.80375029e-02f, -5.01078516e-02f, -6.15919493e-02f, -8.65573585e-02f, -3.09057180e-02f, 5.24048209e-02f, -3.18410024e-02f, 2.97987312e-02f,
  5.66799939e-02f, 1.40017465e-01f, 5.82916429e-03f, -6.22712187e-02f, 7.12320507e-02f, 2.92464215e-02f, 5.86858690e-02f, -6.65756932e-04f, 5.36976717e-02f, 2.80716419e-02f,
  -4.05227356e-02f, 3.61676477e-02f, -6.81618378e-02f, 5.63713871e-02f, -2.18170602e-02f, -1.51939660e-01f, -3.87918353e-02f, -1.01684891e-01f, -1.68499108e-02f, -1.13634162e-01f,
  -1.32074773e-01f, 9.73213911e-02f, -5.41802049e-02f, -3.71758305e-02f, 6.93122596e-02f, -5.74715203e-03f, -1.37327388e-01f, -3.81513983e-02f, -1.11835688e-01f, 4.32599336e-02f,
  6.38714209e-02f, 1.20313158e-02f, 8.19717571e-02f, 4.10215780e-02f, -1.08043328e-02f, 6.91578314e-02f, -1.29931703e-01f, -4.36136797e-02f, -1.77926738e-02f, 1.02576628e-01f,
  -2.61554718e-01f, -1.17439881e-01f, -3.49204212e-01f, -4.81409840e-02f, -1.50514334e-01f, -3.04405630e-01f, 7.63339782e-03f, -1.46657422e-01f, -1.04671568e-01f, 3.97690892e-01f,
  2.26579517e-01f, -5.09774871e-02f, 3.53504360e-01f, 1.71022817e-01f, -4.75264192e-01f, 3.00783724e-01f, -1.61591113e-01f, 1.23854764e-01f, -4.08659577e-02f, -1.35664240e-01f,
  -2.10900545e-01f, 1.26457348e-01f, 4.95166816e-02f, -6.40682317e-03f, -9.48193073e-02f, -1.27750143e-01f, 1.78437188e-01f, 6.02373108e-02f, -1.03176475e-01f, -5.35726249e-02f,
  5.47528006e-02f, 1.85622588e-01f, -1.76580064e-02f, 3.29704024e-02f, -8.80180746e-02f, 7.08196871e-03f, 2.21161712e-02f, 5.58050014e-02f, 1.98532175e-02f, 4.71522138e-02f,
  4.21557017e-02f, -3.70127782e-02f, -1.83529463e-02f, -6.13257326e-02f, -9.81215164e-02f, -5.14343604e-02f, -2.69490052e-02f, -1.53080717e-01f, 5.51007837e-02f, 4.50326279e-02f,
  1.80012994e-02f, 5.37786186e-02f, 1.50616365e-02f, 1.53587714e-01f, -1.09626442e-01f, 8.46921727e-02f, -6.55781627e-02f, 2.30100797e-03f, -3.15974504e-02f, -1.62264071e-02f,
  -4.13644612e-02f, -4.35315557e-02f, 7.25245476e-02f, 7.28652440e-03f, -1.08019942e-02f, 1.89898834e-02f, -9.52728838e-02f, 1.04874924e-01f, -3.99513729e-02f, -2.03513484e-02f,
  4.12109755e-02f, -1.35361075e-01f, 8.48869905e-02f, -4.52037938e-02f, -1.02157667e-01f, 7.25482628e-02f, -3.59668210e-02f, -2.08157431e-02f, -1.41263515e-01f, -2.07744330e-01f,
  1.79633662e-01f, -8.86872634e-02f, 5.85538382e-03f, 6.93261996e-02f, -7.41918907e-02f, -1.28397308e-02f, 3.42979729e-02f, 5.03619388e-02f, -5.71683748e-03f, -5.65070435e-02f,
  -1.34131461e-02f, -7.57761002e-02f, 1.26348820e-03f, -2.72101839e-03f, 1.57661960e-02f, -5.34830242e-02f, -4.63666953e-02f, -1.09934390e-01f, -2.94541754e-02f, -1.91939902e-02f,
  -2.07663160e-02f, -4.07247469e-02f, 1.95938163e-03f, -6.54779449e-02f, -1.41828060e-01f, -1.57119676e-01f, 2.37633005e-01f, 4.70857248e-02f, -5.63094355e-02f, -1.40233159e-01f,
  1.02391534e-01f, 1.13222219e-01f, 4.93608452e-02f, 1.12592183e-01f, 2.30959486e-02f, 9.63103101e-02f, -1.55814752e-01f, 8.48891512e-02f, 1.44415991e-02f, 6.20048353e-03f,
  -4.02824074e-01f, -1.01669915e-01f, -1.73972577e-01f, -1.52002990e-01f, -2.26487488e-01f, -2.16781974e-01f, -1.42563850e-01f, -2.37623975e-01f, -1.18728630e-01f, 2.20587868e-02f,
  -2.46690124e-01f, -1.04216725e-01f, 1.38425887e-01f, 8.14885870e-02f, 8.25627521e-02f, 2.30132014e-01f, -6.82754070e-02f, 7.49549568e-02f, 3.53994779e-02f, -1.82151437e-01f,
  1.05285920e-01f, 9.90308914e-03f, 1.05115525e-01f, -8.60447958e-02f, -2.61351466e-01f, -1.24095432e-01f, 1.24411330e-01f, -1.15970723e-01f, -8.24565887e-02f, -1.58384949e-01f,
  -1.87770769e-01f, -2.01375350e-01f, -5.64129017e-02f, -3.31939459e-02f, -1.94728345e-01f, 3.18537578e-02f, 5.06059080e-02f, -6.54688105e-02f, -3.70273590e-02f, -3.24749611e-02f,
  3.91403213e-02f, -1.92841217e-02f, -7.11147115e-02f, 6.76670447e-02f, 8.48620012e-02f, -2.11845025e-01f, -1.96992680e-02f, -4.41093780e-02f, -6.68896362e-02f, -3.16386931e-02f,
  -6.09653182e-02f, -7.48167112e-02f, -6.78687170e-02f, 1.45085454e-01f, -7.18056038e-02f, -7.48071000e-02f, 8.42342675e-02f, -9.68332682e-03f, -7.46421516e-02f, -1.00403793e-01f,
  -2.30422709e-02f, 1.49015009e-01f, -5.96435033e-02f, -1.82477869e-02f, -7.73153407e-03f, -8.83587226e-02f, 2.77997665e-02f, -2.20083501e-02f, -6.11714311e-02f, -1.34352790e-02f,
  -9.37247556e-03f, -8.56154561e-02f, -8.81001055e-02f, 7.37449154e-02f, -6.29963949e-02f, -8.97009671e-02f, -3.65905128e-02f, -1.08195528e-01f, -4.33464572e-02f, 2.19717845e-02f,
  -8.83699805e-02f, -1.37179926e-01f, 1.23346075e-02f, 6.13866709e-02f, -9.97214317e-02f, 1.60237178e-01f, 1.21553419e-02f, -1.31480722e-02f, -1.43482581e-01f, -8.08760822e-02f,
  -2.34777287e-01f, -2.25977108e-01f, -9.58644524e-02f, -1.22651786e-01f, 6.89152554e-02f, -2.00195555e-02f, 1.23795822e-01f, 7.80738331e-03f, -1.14502788e-01f, -8.55387449e-02f,
  9.61091928e-03f, 1.21769048e-01f, -1.76041480e-02f, -1.84247494e-02f, 3.89555655e-02f, -3.43807600e-02f, 5.38944714e-02f, -6.99371099e-02f, -1.44329041e-01f, -1.47575527e-01f,
  1.37350513e-02f, -2.36820411e-02f, 1.14266925e-01f, 6.91590831e-02f, 8.78736451e-02f, -1.09260969e-01f, -1.29224285e-01f, 1.21619776e-02f, -2.06250604e-02f, 2.54042447e-03f,
  -1.87569469e-01f, 1.06283510e-02f, -2.45939523e-01f, -1.63917392e-01f, -7.40776164e-03f, -1.96826875e-01f, -1.41208321e-01f, 7.52615482e-02f, 3.24540466e-01f, 1.94333345e-01f,
  2.50218599e-03f, -3.17746885e-02f, 2.07127169e-01f, -3.56700361e-01f, -2.38863677e-01f, 1.90038085e-01f, -3.24596375e-01f, -2.11215943e-01f, 1.15134202e-01f, -1.96363926e-01f,
  -1.01222977e-01f, -1.68895543e-01f, -2.14800850e-01f, -8.69491473e-02f, -3.92637908e-01f, -1.31096020e-01f, -1.68928593e-01f, -6.20653480e-02f, -3.81140798e-01f, 7.85259232e-02f,
  -1.38267294e-01f, 1.82909042e-01f, -1.23885378e-01f, -5.69841592e-03f, -7.96957910e-02f, -8.15888494e-02f, -1.03703767e-01f, -8.43047425e-02f, 5.43768965e-02f, -3.92934121e-02f,
  4.77328785e-02f, 1.69611886e-01f, 6.11878186e-02f, 1.04689851e-01f, 5.83760552e-02f, -4.28456962e-02f, -9.50597003e-02f, -1.30049139e-01f, -6.09135181e-02f, 3.76510210e-02f,
  -1.66430190e-01f, 8.41284990e-02f, -1.08559109e-01f, 1.18264169e-01f, 1.87805984e-02f, 1.58465914e-02f, -1.80408843e-02f, 3.08036571e-03f, 2.72087776e-03f, 1.02524020e-01f,
  7.94832557e-02f, -9.44482237e-02f, -6.40788302e-02f, -6.34944905e-03f, 2.16826145e-02f, 5.10967895e-02f, -6.66710734e-02f, 1.08327806e-01f, 4.41459194e-03f, -9.11138281e-02f,
  -1.27700949e-02f, -2.52394881e-02f, 6.35027587e-02f, -1.44353494e-01f, -2.42279489e-02f, 9.62334722e-02f, 5.05842902e-02f, 3.47729288e-02f, -6.13863172e-04f, -3.78971286e-02f,
  7.03647286e-02f, 7.31761009e-02f, -9.25778821e-02f, -5.93184158e-02f, -3.21269557e-02f, -1.40299918e-02f, 3.87053727e-03f, -6.24381304e-02f, -9.92238000e-02f, -2.49216072e-02f,
  8.98018256e-02f, 2.75234431e-01f, 6.54181689e-02f, 1.04199098e-02f, 2.35490804e-03f, -8.11476856e-02f, 6.43966272e-02f, -5.85336201e-02f, 3.82199660e-02f, -2.09095161e-02f,
  -5.05109243e-02f, 2.33433372e-03f, -1.05139777e-01f, 7.99910575e-02f, 7.80101493e-02f, -8.75818133e-02f, -2.48939451e-02f, 8.63019899e-02f, 7.69134844e-03f, 8.31277203e-03f,
  -6.11114800e-02f, 9.77103710e-02f, 5.55715002e-02f, 3.07100173e-02f, 4.48984504e-02f, 2.99022663e-02f, 5.63764535e-02f, -4.58510034e-02f, 7.27754971e-03f, 1.31424665e-01f,
  -5.18183470e-01f, 5.43912292e-01f, 1.85475618e-01f, -2.91148335e-01f, 1.27172798e-01f, 5.60322180e-02f, -8.40296075e-02f, 2.16082782e-01f, -1.12267941e-01f, 8.60870034e-02f,
  -8.64694268e-02f, 1.69908032e-01f, 1.18413702e-01f, -3.16912532e-02f, -3.51929307e-01f, -1.20015353e-01f, -2.36665457e-01f, -1.66810483e-01f, 1.52462915e-01f, -7.78111145e-02f,
  -6.82705864e-02f, -1.17680915e-01f, 6.63394779e-02f, 1.52478755e-01f, 1.46143734e-01f, 1.65868208e-01f, -1.69861063e-01f, 2.26335824e-01f, -1.88292731e-02f, 1.73270911e-01f,
  3.38885114e-02f, -2.10282862e-01f, 1.48778185e-01f, 1.05855577e-01f, -1.13611639e-01f, 5.53866196e-03f, -7.22553357e-02f, 6.71202540e-02f, 7.22469836e-02f, 3.08354236e-02f,
  3.51737328e-02f, 8.20782557e-02f, 4.68174629e-02f, 9.58779231e-02f, 1.04613326e-01f, 1.35688007e-01f, 1.45529494e-01f, 1.01644218e-01f, 1.90230414e-01f, 7.98940063e-02f,
  1.42590016e-01f, 5.29055409e-02f, -2.39857305e-02f, -1.25445783e-01f, 8.98724347e-02f, 1.38084712e-02f, -9.70860869e-02f, -1.71272345e-02f, 9.78215560e-02f, -9.95163396e-02f,
  -3.77423801e-02f, -1.62793752e-02f, 2.62924414e-02f, 9.83343124e-02f, -6.85222214e-03f, -5.94107583e-02f, -4.02983576e-02f, -3.04646529e-02f, -2.22020913e-02f, 3.81486607e-03f,
  -1.85243338e-02f, 5.34620918e-02f, -6.25112802e-02f, -6.17641360e-02f, -3.46627720e-02f, 5.36819845e-02f, -7.75606651e-03f, -1.69665716e-03f, 4.97559085e-02f, -9.11706015e-02f,
  -2.42711464e-03f, -1.28924578e-01f, -5.15778959e-02f, 6.70880899e-02f, 1.32631496e-01f, 2.10702643e-02f, 6.29861131e-02f, 9.85665172e-02f, -7.62418434e-02f, -4.24061678e-02f,
  -1.89669192e-01f, -4.36888158e-01f, 4.12305444e-02f, 3.59686688e-02f, 2.17423718e-02f, 9.37642381e-02f, 2.72490475e-02f, 5.30119427e-02f, 1.47391960e-01f, -9.73416213e-03f,
  1.98363122e-02f, -7.14482367e-02f, -4.86405641e-02f, 2.37988699e-02f, -2.06932183e-02f, -1.55460751e-02f, -1.28972694e-01f, -2.23707072e-02f, -5.35989692e-03f, -1.27301058e-02f,
  3.67567688e-02f, 4.52126451e-02f, -3.12267244e-02f, -5.50705716e-02f, -3.20217125e-02f, 6.61146417e-02f, -9.03248265e-02f, 1.28259972e-01f, 3.12105101e-02f, 5.21974936e-02f,
  -6.24654114e-01f, 4.71227318e-01f, 1.03064112e-01f, -1.63187787e-01f, 1.19162112e-01f, 6.29164398e-01f, 1.89466417e-01f, 1.90965593e-01f, -3.77353304e-03f, 1.38620781e-02f,
  8.04882217e-03f, -1.47862047e-01f, 7.20962062e-02f, 6.58758357e-02f, 2.46097773e-01f, 2.83977449e-01f, 1.61918491e-01f, -5.34984702e-03f, 2.81642616e-01f, 3.75147015e-02f,
  5.93409799e-02f, 4.50401977e-02f, 9.00981203e-02f, 6.90768138e-02f, -1.42215878e-01f, -1.79549605e-01f, -3.38507205e-01f, 5.42346537e-02f, 1.55915180e-02f, 1.30667269e-01f,
  2.13052370e-02f, -2.34132752e-01f, -1.15066566e-01f, 1.01396292e-02f, -1.68808475e-02f, -1.25595286e-01f, 5.16630709e-02f, -7.46511742e-02f, -6.09767577e-03f, 7.20306262e-02f,
  1.40985260e-02f, -5.20911589e-02f, -1.55060872e-01f, -2.29005497e-02f, 6.95533529e-02f, 3.20379017e-03f, 1.60882041e-01f, 5.80775291e-02f, 1.53249532e-01f, 1.24414280e-01f,
  -1.82644557e-02f, 6.78746700e-02f, 8.54582805e-03f, 1.08983025e-01f, 9.20505896e-02f, 8.40299129e-02f, 7.18071684e-02f, -8.22075680e-02f, 3.19902450e-02f, 9.54231918e-02f,
  6.04268909e-02f, -1.94908641e-02f, -6.91120103e-02f, -9.75783393e-02f, 3.81312408e-02f, -2.61438750e-02f, -1.16183534e-01f, -1.78102747e-01f, -1.29928827e-01f, 3.79191451e-02f,
  5.85498102e-02f, -4.34054285e-02f, -6.92053372e-03f, 1.18175022e-01f, -1.45901576e-01f, -1.28267080e-01f, 4.30599265e-02f, -1.10014994e-02f, -1.02855869e-01f, -4.85447198e-02f,
  -4.51309010e-02f, 8.11403990e-02f, -1.65499210e-01f, -6.24797419e-02f, 9.40216631e-02f, 7.21985474e-02f, 4.96940687e-02f, 1.27169872e-02f, -5.97031787e-03f, -2.00952720e-02f,
  1.85773894e-01f, 5.21396883e-02f, -2.84761246e-02f, 3.92792337e-02f, -1.10219035e-03f, 1.09873571e-01f, 7.68102258e-02f, 7.30081573e-02f, 5.49870133e-02f, 7.87827969e-02f,
  -2.51939502e-02f, -8.62447545e-02f, 4.95206192e-02f, -3.01941391e-02f, 6.87961504e-02f, 4.35286053e-02f, 2.86578480e-02f, 4.38225642e-02f, -4.14017513e-02f, 9.72127020e-02f,
  -9.99649242e-02f, -1.81526039e-02f, -1.59638245e-02f, -3.18117812e-02f, -4.21641357e-02f, -1.45803377e-01f, -1.17303260e-01f, 1.58677045e-02f, 1.38257325e-01f, -3.36468555e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.43750682e-01f, 2.62520313e-01f, 2.25573137e-01f, 2.60219097e-01f, 3.27997506e-01f, 1.77419320e-01f, 1.52200133e-01f, 2.33705163e-01f, 1.84658512e-01f, 1.98618010e-01f,
  1.46426186e-01f, 1.15440674e-01f, 2.60546237e-01f, 2.91995466e-01f, 2.96039611e-01f, 1.12240776e-01f, 1.55569747e-01f, 3.28828543e-01f, 2.39449069e-01f, 2.19469473e-01f,
  2.85563827e-01f, 4.38397117e-02f, 4.64028418e-02f, 2.13414934e-02f, 1.07347265e-01f, 2.67075032e-01f, 3.24246675e-01f, 2.40205079e-01f, 1.80520773e-01f, 1.20194189e-01f,
  1.03605084e-01f, 1.79234341e-01f, 2.50874728e-01f, 3.27283025e-01f, 2.71351010e-01f, 2.77867496e-01f, 1.12140492e-01f, 2.09520444e-01f, 2.01129600e-01f, 3.54538947e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.05110101e-01f, 2.38300133e-02f, 2.00484153e-02f, -3.03469915e-02f, -2.12309062e-02f, 7.07704946e-02f, -1.00017786e-01f, 9.01816937e-04f, -1.40468609e-02f, 1.11889662e-02f,
  -1.85187422e-02f, -2.75151357e-02f, -1.12968884e-01f, 1.23374462e-02f, -1.67818680e-01f, -8.93078819e-02f, 6.34831414e-02f, 3.11291637e-03f, 3.25804763e-02f, 3.21949534e-02f,
  -1.44918427e-01f, -5.87391108e-02f, -9.95831564e-02f, 1.06370606e-01f, 7.78166205e-02f, -5.75463921e-02f, 6.47853017e-02f, 3.56527716e-02f, -1.51998565e-01f, 1.31537402e-02f,
  -6.34149462e-03f, 1.03912406e-01f, 1.55845627e-01f, 9.73142385e-02f, -6.57802001e-02f, -2.73634326e-02f, 9.61065218e-02f, 1.83164090e-01f, 7.79000372e-02f, -5.63244596e-02f,
  7.53483698e-02f, 1.99477047e-01f, -3.08707841e-02f, -5.25857545e-02f, 4.39209789e-02f, -4.86607030e-02f, -1.41727522e-01f, 8.63879323e-02f, -1.31175771e-01f, 4.86076884e-02f,
  -3.54546681e-02f, 8.61380249e-02f, -1.27080888e-01f, -4.97436486e-02f, 1.24142893e-01f, 2.05936134e-02f, -7.24068135e-02f, -1.08038850e-01f, -3.21753882e-02f, -2.06609800e-01f,
  -1.52310640e-01f, -1.06556378e-01f, -1.54093742e-01f, -1.28987385e-02f, 7.78502822e-02f, 4.59256880e-02f, 7.82961249e-02f, 7.09147453e-02f, -2.22354159e-02f, 1.03351153e-01f,
  5.40746823e-02f, 1.46098323e-02f, 8.72848108e-02f, 3.84361558e-02f, 2.07803518e-01f, 4.11567502e-02f, 9.69795808e-02f, -2.01425087e-02f, 7.69155547e-02f, 1.56807862e-02f,
  -4.97628935e-02f, 1.09932363e-01f, -2.26642847e-01f, 1.53747732e-02f, -4.49580401e-02f, 6.24630935e-02f, -1.15849271e-01f, 9.20845866e-02f, -1.06372990e-01f, -5.47902510e-02f,
  1.07117355e-01f, 1.20971151e-01f, 1.51914299e-01f, -2.43709348e-02f, -5.65871634e-02f, -3.08783986e-02f, -1.11933663e-01f, 6.30540401e-02f, 1.47924274e-01f, -4.92358468e-02f,
  7.34969452e-02f, -1.52700335e-01f, 3.97724770e-02f, 5.13054207e-02f, -8.94458741e-02f, -7.39643052e-02f, -4.33365107e-02f, 1.75651181e-02f, 4.72855940e-02f, -2.49898043e-02f,
  -1.01151951e-01f, -1.19321555e-01f, -1.11096941e-01f, -2.65600830e-02f, 7.60655329e-02f, 2.06658259e-01f, -1.41363502e-01f, -1.35382265e-01f, -5.73898144e-02f, 1.43077537e-01f,
  -7.14248344e-02f, -1.35691687e-01f, -7.55958334e-02f, -9.33396220e-02f, 8.36418644e-02f, -4.42859195e-02f, -1.84026323e-02f, 2.00187579e-01f, 4.24052440e-02f, 2.16834262e-01f,
  -7.72878528e-02f, -8.20284858e-02f, 2.93760933e-02f, -3.20532434e-02f, 7.85635598e-03f, 1.80035323e-01f, 1.32077439e-02f, -3.22549827e-02f, 9.50272083e-02f, 3.55434902e-02f,
  -8.16352963e-02f, 4.08987962e-02f, 4.33945209e-02f, 4.49412577e-02f, -2.12214850e-02f, 4.78662411e-03f, -7.51803070e-02f, 1.94738835e-01f, 1.09452941e-01f, -1.04668863e-01f,
  -1.83264777e-01f, -3.60640883e-02f, -1.32331818e-01f, 1.15687689e-02f, 9.73831490e-02f, -3.15773189e-02f, 2.09216669e-01f, -7.18713552e-02f, -2.05636084e-01f, 1.57068759e-01f,
  -6.26684213e-03f, -3.74873467e-02f, -9.87286493e-02f, -4.02255394e-02f, 1.17334304e-02f, 1.94017664e-01f, 1.57070294e-01f, -1.61112696e-01f, 5.00284061e-02f, 1.61936924e-01f,
  -3.97539996e-02f, -1.50005057e-01f, -5.96017353e-02f, 5.13273571e-03f, -1.48698121e-01f, 2.08732009e-01f, -5.18194400e-02f, -1.05436489e-01f, -4.81647179e-02f, 1.84935451e-01f,
  -1.05153501e-01f, -2.55786389e-01f, -5.33421859e-02f, -4.50729914e-02f, -1.00584611e-01f, 7.51731843e-02f, -1.75760806e-01f, -2.01031446e-01f, -1.34970680e-01f, -2.00636342e-01f,
  -4.51945551e-02f, -1.08300745e-01f, 5.25879255e-03f, -3.60902748e-03f, 1.96111389e-02f, 1.61976129e-01f, 3.42679471e-02f, -6.64914772e-02f, -4.39203754e-02f, -7.13271648e-03f,
  -5.94092272e-02f, 2.82790232e-02f, 1.46590015e-02f, -4.99341451e-02f, 2.03048408e-01f, 1.51463315e-01f, 7.10910484e-02f, 2.73133330e-02f, -3.01697910e-01f, 7.89093301e-02f,
  -1.23878993e-01f, -1.20059021e-01f, -7.92471021e-02f, -6.38095522e-03f, -1.31930128e-01f, -2.20996141e-02f, -7.01857135e-02f, 6.16445281e-02f, -5.63607514e-02f, 6.61915168e-02f,
  -8.90432522e-02f, -1.47672087e-01f, 1.48729265e-01f, 5.19283041e-02f, -1.85690254e-01f, 1.55858740e-01f, 1.45069763e-01f, -1.43692464e-01f, -1.34014562e-01f, 8.07592124e-02f,
  1.15871683e-01f, 5.77146597e-02f, -1.66199908e-01f, -1.66551575e-01f, -1.21870562e-01f, 1.12984078e-02f, -4.55775931e-02f, -2.01948243e-03f, -5.28432103e-03f, -2.75101006e-01f,
  9.46743228e-03f, -1.64237678e-01f, 1.38119861e-01f, 1.09832004e-01f, -3.33787524e-03f, 4.78942990e-02f, -4.20465469e-02f, 2.38874294e-02f, 9.31593031e-03f, -1.22442342e-01f,
  1.11681558e-01f, 1.48185119e-01f, 1.91236585e-01f, 9.52415541e-02f, -1.08404525e-01f, 2.43159235e-01f, 2.31370330e-02f, -1.44264176e-01f, -1.06622435e-01f, -7.77132809e-02f,
  -9.28103849e-02f, 1.45298745e-02f, -1.17035665e-01f, -6.92316666e-02f, 1.79163720e-02f, -1.49939939e-01f, -5.58324046e-02f, -9.76625234e-02f, -1.85468838e-01f, 1.20247103e-01f,
  -1.78137764e-01f, -7.65798613e-02f, 4.13853489e-02f, -6.31231740e-02f, 1.56435832e-01f, -1.21386684e-02f, -3.49772200e-02f, -1.33762017e-01f, 1.09620564e-01f, 1.29965782e-01f,
  2.56077856e-01f, -2.00840488e-01f, -1.80678964e-01f, -1.95481464e-01f, -1.80529431e-01f, 9.59254354e-02f, -6.03314973e-02f, -1.80220440e-01f, 8.12264308e-02f, -7.76088312e-02f,
  -5.83297759e-02f, -5.67289721e-03f, 4.76626344e-02f, 4.56143962e-03f, -3.01141646e-02f, 4.25391272e-02f, 2.03142971e-01f, 6.84094802e-02f, 1.73550993e-02f, -5.74815832e-02f,
  2.10126817e-01f, 1.49664998e-01f, -1.66491702e-01f, 1.89730719e-01f, 3.87405790e-02f, -6.34277388e-02f, -1.47662327e-01f, -7.69640133e-02f, 1.74064582e-04f, 9.25477669e-02f,
  1.34953380e-01f, 1.92554686e-02f, -1.86073303e-01f, 3.41830216e-02f, -7.74320289e-02f, -1.78208768e-01f, -1.02308065e-01f, -2.26155326e-01f, -8.36489052e-02f, -4.88485768e-02f,
  8.30795616e-02f, -2.25307420e-03f, -8.42745975e-02f, 5.12014478e-02f, -3.79494205e-02f, -2.05055326e-02f, -5.52605418e-03f, -7.33412802e-02f, 4.91037173e-03f, -6.85735345e-02f,
  -1.12257838e-01f, -6.76305126e-03f, -9.96190086e-02f, -1.66814312e-01f, -2.17968315e-01f, -4.33022976e-02f, 2.77366191e-01f, -1.27611384e-01f, 7.04014003e-02f, -8.92981980e-03f,
  4.46446501e-02f, -1.54593205e-02f, 1.24188056e-02f, 2.01936483e-01f, 1.53758526e-01f, 3.54065211e-03f, 3.13483216e-02f, 3.27355713e-02f, 7.20137358e-02f, 1.17777869e-01f,
  4.39207070e-02f, -5.44377081e-02f, 1.14739135e-01f, -1.43578440e-01f, -6.30020276e-02f, 4.00548652e-02f, -2.34498214e-02f, -1.75045237e-01f, -1.77930817e-01f, 5.41562364e-02f,
  1.33368745e-01f, -9.43543538e-02f, -1.03206806e-01f, 1.12022281e-01f, 1.22038061e-02f, -1.33107886e-01f, -1.71540812e-01f, -8.15121084e-03f, -2.48855621e-01f, 2.32369870e-01f,
  7.83294886e-02f, -7.11903721e-02f, -8.06679428e-02f, 2.73331199e-02f, 1.39661312e-01f, 2.84692459e-02f, -3.30931321e-02f, 7.38984346e-02f, -4.63957079e-02f, -2.90628127e-03f,
  -1.27200723e-01f, 1.20386355e-01f, -1.25976115e-01f, -3.97018641e-02f, -3.34039293e-02f, -1.57609861e-02f, -8.28850083e-03f, 4.76953341e-03f, 3.84932645e-02f, -5.56424893e-02f,
  1.26669686e-02f, 7.69747198e-02f, 2.59674042e-02f, -6.56327233e-02f, 7.64388144e-02f, 5.74683724e-03f, 1.05999976e-01f, -9.21114907e-02f, 2.18224064e-01f, 5.15091904e-02f,
  -1.27357125e-01f, 3.44706327e-02f, 3.62812243e-02f, -7.58003742e-02f, 1.32915452e-01f, 7.50214607e-02f, 1.26771212e-01f, -1.14525460e-01f, 6.54278845e-02f, -3.10423169e-02f,
  5.30062206e-02f, -1.30248792e-03f, -8.55007321e-02f, -2.60185264e-02f, -1.87536031e-01f, -1.03508413e-01f, -4.67197411e-02f, -1.96175024e-01f, 1.69642955e-01f, 2.46114358e-02f,
  -9.22629535e-02f, -7.73767680e-02f, -9.13027441e-04f, -1.45408705e-01f, -7.32719973e-02f, -1.41752899e-01f, 5.52660972e-02f, 6.36015460e-02f, 2.07083911e-01f, 1.28558204e-01f,
  -3.60948332e-02f, 1.23222567e-01f, 1.82027668e-01f, 1.16300462e-02f, -6.73326701e-02f, -1.24033935e-01f, 1.72636494e-01f, 3.90676446e-02f, 3.78796123e-02f, 7.89484158e-02f,
  1.57711238e-01f, 9.65446979e-02f, 5.41398525e-02f, 7.91183487e-02f, 1.59718037e-01f, 1.40072837e-01f, 1.36884809e-01f, -1.77684858e-01f, 6.81963712e-02f, 3.58811952e-02f,
  -4.53433692e-02f, 3.92980650e-02f, -7.61337355e-02f, 7.64835905e-03f, -1.25181943e-01f, -9.50911955e-04f, -4.90739048e-02f, 1.09697074e-01f, -2.28968710e-02f, -1.02478161e-01f,
  -3.65130119e-02f, -1.33425266e-01f, 2.33582146e-02f, 6.01416752e-02f, -1.36980116e-01f, 5.02784327e-02f, -5.90538792e-02f, 1.21225536e-01f, -9.23994705e-02f, -1.23754337e-01f,
  -2.61009902e-01f, -2.22208519e-02f, -2.97290068e-02f, 3.10482103e-02f, -2.25703716e-02f, -4.09220010e-02f, 6.84332997e-02f, 7.56055815e-03f, -2.05745295e-01f, 1.08753897e-01f,
  -2.61611324e-02f, -7.84722716e-02f, 2.29396969e-01f, -3.67583856e-02f, 5.66769997e-03f, 2.29427248e-01f, 1.14334904e-01f, -1.71009451e-01f, 5.97153939e-02f, 2.37139642e-01f,
  -2.01658323e-01f, 1.92421272e-01f, -5.97165525e-02f, -1.74335286e-01f, -2.48000547e-01f, -1.11834876e-01f, -1.23045743e-01f, 5.38782449e-03f, -1.98324993e-01f, 5.14855869e-02f,
  3.44646126e-01f, -1.48308530e-01f, -2.03225926e-01f, 1.03094451e-01f, 1.77969381e-01f, 7.04418272e-02f, -2.13833556e-01f, 1.60587323e-03f, -9.86882150e-02f, -6.73663914e-02f,
  -1.01712927e-01f, -2.16039807e-01f, 1.42418006e-02f, 2.41702855e-01f, 7.11717531e-02f, 1.21392068e-02f, 8.21614638e-02f, 6.20421767e-02f, 9.85793248e-02f, 1.96623802e-01f,
  -4.61481102e-02f, -1.35231111e-02f, 4.68735285e-02f, 1.59974217e-01f, 6.16240390e-02f, -8.44736993e-02f, 4.69774976e-02f, 1.13918528e-01f, 3.11392695e-02f, 1.20984182e-01f,
  1.20135825e-02f, 1.47689596e-01f, 8.45872089e-02f, 5.38144000e-02f, -1.95919961e-01f, -6.43260255e-02f, -2.33266383e-01f, 2.44596779e-01f, 1.69482082e-01f, 2.32176393e-01f,
  1.52033538e-01f, -9.59000066e-02f, -6.94004679e-03f, 2.04489946e-01f, -1.57540262e-01f, -1.37747511e-01f, 7.71868452e-02f, 2.37927418e-02f, -8.89055282e-02f, 1.30125195e-01f,
  -2.28282940e-02f, -1.05343431e-01f, -2.75571365e-02f, -4.87117544e-02f, -1.59041062e-01f, 1.68884739e-01f, -2.04560295e-01f, -2.53601640e-01f, -5.64464973e-03f, -9.86828580e-02f,
  -7.09808990e-02f, -4.86820098e-03f, 6.80601075e-02f, -4.51862216e-02f, -1.35971988e-02f, -2.34427229e-01f, -1.81760654e-01f, 9.32376366e-03f, 8.22174773e-02f, 6.04980700e-02f,
  -1.05571700e-03f, -7.39468113e-02f, -4.09107134e-02f, 2.08792448e-01f, 1.14858508e-01f, 8.38238075e-02f, 1.00042336e-01f, 5.23860604e-02f, -1.05807804e-01f, 2.69261189e-02f,
  1.66399162e-02f, 9.89533402e-03f, 1.73789889e-01f, 9.51391552e-03f, 1.33208841e-01f, 2.18405221e-02f, -7.59290084e-02f, 1.37510777e-01f, -8.35824758e-02f, -1.98161200e-01f,
  -1.85482919e-01f, 1.49569986e-02f, 3.26841563e-01f, -8.82445872e-02f, 1.32124558e-01f, 1.00888297e-01f, 8.67277086e-02f, 1.23343371e-01f, -3.64984684e-02f, 3.30650993e-02f,
  8.62826928e-02f, 1.47967726e-01f, 4.90352027e-02f, 1.30050451e-01f, 1.95954725e-01f, 6.64968267e-02f, 5.75013049e-02f, 5.20263463e-02f, -4.00133543e-02f, -1.28128305e-01f,
  -1.72092780e-01f, -8.32881927e-02f, -9.35433656e-02f, -4.79425974e-02f, -7.23592564e-02f, 1.53910741e-02f, 6.11284981e-03f, -6.31445721e-02f, -2.34114975e-01f, 1.66758358e-01f,
  -1.37520969e-01f, -2.04445332e-01f, -1.50944799e-01f, -9.21997055e-02f, -8.83327574e-02f, 2.35203072e-01f, 2.30793148e-01f, -1.50054663e-01f, -4.49232608e-02f, -1.05458021e-01f,
  -9.53740552e-02f, -1.20092528e-02f, -9.19494778e-03f, 1.33405104e-01f, -5.05807176e-02f, 5.61858639e-02f, -4.89665717e-02f, 1.78031445e-01f, 2.51727104e-02f, 7.09568486e-02f,
  6.38838559e-02f, 1.48114219e-01f, 1.01005174e-01f, 3.77198309e-02f, -5.19894883e-02f, 4.09853905e-02f, 2.03027297e-02f, 1.10419296e-01f, 1.23646036e-01f, 4.52795401e-02f,
  1.51102871e-01f, -8.90203342e-02f, 1.60932496e-01f, 6.58822879e-02f, 1.21810459e-01f, 1.53354377e-01f, 1.19594298e-01f, 5.86545467e-02f, -1.10900722e-01f, -9.33726355e-02f,
  1.06234953e-01f, 3.62202413e-02f, -9.92762595e-02f, 2.24002637e-03f, -4.24573831e-02f, 7.74365589e-02f, 9.90603268e-02f, 6.85018525e-02f, 1.89873800e-01f, 1.01354957e-01f,
  -1.34621365e-02f, -3.17671821e-02f, 1.53718973e-02f, 9.29894000e-02f, -6.74224123e-02f, -8.87318328e-02f, 6.13209940e-02f, -2.19937176e-01f, -1.03973769e-01f, 5.22851944e-02f,
  -3.24182622e-02f, -9.80156511e-02f, 3.61698940e-02f, -5.04089482e-02f, -1.20437860e-01f, -4.28123809e-02f, 6.01423904e-02f, -1.97396457e-01f, 4.72011156e-02f, -4.74250130e-02f,
  -8.27122554e-02f, 3.90010476e-02f, 3.99892293e-02f, -3.50751914e-02f, -9.41081643e-02f, -5.93122318e-02f, -2.68261358e-02f, 1.90392043e-02f, -6.80557787e-02f, 6.90387040e-02f,
  -7.88729191e-02f, -2.01033801e-01f, 1.42535686e-01f, 1.35716736e-01f, 9.14286450e-02f, -1.00727774e-01f, 1.19481224e-03f, -1.33104235e-01f, -2.15213522e-02f, 1.84748322e-02f,
  -7.01630190e-02f, -6.03499711e-02f, 7.61350989e-02f, -6.89221099e-02f, -1.13299087e-01f, -4.52058949e-02f, -2.15162560e-01f, 7.21508414e-02f, -1.00268893e-01f, -4.62703826e-03f,
  2.08290890e-01f, -1.40417874e-01f, 1.75717086e-01f, 1.22184224e-01f, 2.10387073e-02f, -1.26605004e-01f, 4.22623195e-02f, 7.24720061e-02f, 1.22353345e-01f, -3.68367843e-02f,
  -1.01770774e-01f, -1.05035141e-01f, -5.20962328e-02f, 1.79015771e-01f, 9.45164356e-03f, -3.19005586e-02f, 2.67581880e-01f, -7.04348609e-02f, -1.00188132e-04f, 5.59504516e-02f,
  1.59531385e-01f, 6.15940355e-02f, 1.08018760e-02f, 3.77647988e-02f, 2.57261068e-01f, 2.12840587e-01f, -1.26852524e-02f, -7.93224275e-02f, -1.15745761e-01f, 2.20672600e-02f,
  -1.39660597e-01f, 2.46659026e-01f, -1.63418993e-01f, -8.68437886e-02f, -1.20813124e-01f, -1.58336952e-01f, 1.12873092e-01f, 9.21569113e-03f, 4.67855856e-02f, 1.05824405e-02f,
  -1.48543999e-01f, 8.46516620e-03f, -2.39046767e-01f, -1.45785794e-01f, -1.77377477e-01f, -1.29036382e-01f, -1.81787074e-01f, -1.60172388e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.33297786e-01f, 3.26282620e-01f, 7.31277093e-02f, 1.41608506e-01f, 1.73727274e-01f, 7.61563107e-02f, 7.73256794e-02f, 3.26318592e-01f, 1.46637499e-01f, 2.33356282e-01f,
  7.15818554e-02f, 2.38438904e-01f, -3.38351205e-02f, -1.99399903e-01f, -1.18591078e-01f, 1.40022293e-01f, 7.42513686e-02f, -6.70261905e-02f, 4.65745665e-02f, 3.46051574e-01f,
  1.49294868e-01f, -1.60372794e-01f, -3.26361179e-01f, -1.74877733e-01f, -1.32677960e-03f, 3.62167448e-01f, 4.60063964e-02f, 1.94619358e-01f, 4.21939969e-01f, -4.78934310e-03f,
  5.80421090e-02f, 3.37479353e-01f, -1.01177886e-01f, -1.23991922e-01f, -3.91607992e-02f, 7.18905497e-03f, -1.29243180e-01f, 2.97494709e-01f, 1.02412291e-02f, -6.29171506e-02f,
  -6.37922287e-02f, 5.69401234e-02f, -1.89214170e-01f, 9.24666598e-02f, -2.15063259e-01f, -2.05297843e-01f, -7.38011003e-02f, -3.59131470e-02f, -2.89097965e-01f, 2.46251374e-01f,
  1.73541054e-01f, -1.39826447e-01f, -6.02978729e-02f, -2.17963472e-01f, -2.26021081e-01f, -1.40785113e-01f, 3.64173837e-02f, 2.50432491e-01f, -1.57907411e-01f, -1.20034836e-01f,
  -1.52818039e-01f, 6.64820299e-02f, -3.22813839e-02f, 7.22423643e-02f, 4.13072780e-02f, 8.95871669e-02f, 9.26066339e-02f, 1.25657678e-01f, 9.48526412e-02f, 8.54404941e-02f,
  4.70761657e-02f, 5.56498356e-02f, 1.30621821e-01f, 1.72737926e-01f, 1.58508524e-01f, -1.84236537e-03f, 1.93751678e-01f, 1.39214858e-01f, 2.24537671e-01f, 2.25000441e-01f,
  -2.20564771e-02f, -8.85656103e-03f, -1.89308494e-01f, 5.45573942e-02f, 7.87434801e-02f, -5.61324181e-03f, -1.32516623e-01f, -3.02896142e-01f, -3.89506668e-03f, 9.12719145e-02f,
  1.74094990e-01f, 2.16823537e-02f, 2.12899461e-01f, -6.64803237e-02f, -1.50706340e-02f, 7.06727803e-02f, -1.71414435e-01f, 2.80050665e-01f, 2.23753929e-01f, -1.79087400e-01f,
  -1.17106557e-01f, 1.60633251e-01f, 9.30312872e-02f, 8.33408386e-02f, -1.05227917e-01f, 2.72521898e-02f, 7.21681193e-02f, -1.71970353e-01f, 3.10865156e-02f, 2.06830710e-01f,
  3.42121780e-01f, -1.63607121e-01f, 2.16860548e-01f, -1.48668841e-01f, -1.10229284e-01f, 1.24187032e-02f, -1.17395055e-02f, 1.45988926e-01f, -1.53445527e-01f, -1.00391880e-01f,
  -1.97273403e-01f, 2.44353741e-01f, 2.86840722e-02f, 8.67775232e-02f, 4.57622297e-02f, -2.43942738e-01f, 3.17682892e-01f, 2.24719226e-01f, -1.70398876e-01f, 1.74609572e-01f,
  -4.94001620e-02f, 1.77779540e-01f, 1.06240503e-01f, 7.72392601e-02f, 1.30862176e-01f, -7.68356305e-03f, 4.77715302e-03f, 3.60760046e-03f, 7.30972663e-02f, 3.94555889e-02f,
  2.69359767e-01f, 1.13568053e-01f, -8.25290661e-03f, 2.54826248e-02f, -1.35685608e-01f, -3.09944488e-02f, -2.45727435e-01f, -1.92786962e-01f, -2.37093698e-02f, 1.68769106e-01f,
  1.21665522e-02f, -2.55996883e-01f, 1.64948955e-01f, 1.33557975e-01f, -2.67199546e-01f, 1.48762017e-01f, 1.06857441e-01f, -7.76498914e-02f, 1.83388963e-01f, 1.28601000e-01f,
  -2.75090337e-01f, 2.45416120e-01f, 9.84792411e-02f, 4.71446142e-02f, -4.59489673e-02f, 1.02079904e-03f, -5.29047400e-02f, -6.59598187e-02f, -1.96652606e-01f, -3.47388327e-01f,
  7.14409426e-02f, -1.32857904e-01f, 1.70699164e-01f, 7.22081512e-02f, 3.55165929e-01f, -1.97484270e-01f, 2.04114109e-01f, 1.66489959e-01f, 4.03012186e-01f, -9.38585773e-02f,
  -7.22469836e-02f, 1.06970176e-01f, 1.55894861e-01f, -2.38741353e-01f, -1.11288562e-01f, 1.04857489e-01f, 1.99639186e-01f, 2.40700930e-01f, 1.07503131e-01f, 2.35705823e-01f,
  8.36010054e-02f, 1.89380825e-01f, 3.17450576e-02f, 1.18316740e-01f, -1.57649757e-03f, -4.07544002e-02f, 1.72775432e-01f, 1.17986314e-01f, -5.67464344e-02f, 1.91595584e-01f,
  1.69033147e-02f, 5.20971902e-02f, 1.52678385e-01f, 8.77324790e-02f, -6.10990562e-02f, 6.22816160e-02f, 1.56488478e-01f, 1.13469504e-01f, -1.60871863e-01f, 2.45255716e-02f,
  4.38927263e-02f, 1.94495857e-01f, 1.26989588e-01f, -1.45235643e-01f, -7.05035031e-02f, -1.71691746e-01f, -1.59058034e-01f, -1.74482409e-02f, -4.26364169e-02f, -2.52363440e-02f,
  1.36464283e-01f, -1.62908167e-01f, -2.83790946e-01f, 1.62744358e-01f, 3.39265279e-02f, 2.67126486e-02f, 4.45697792e-02f, -3.78610520e-03f, 1.29800677e-01f, 2.61326104e-01f,
  2.97733903e-01f, -2.40487292e-01f, 5.04433326e-02f, 3.42277944e-01f, 9.04916674e-02f, -7.26221055e-02f, 1.32453293e-01f, 7.58462921e-02f, 8.13404918e-02f, 3.76265764e-01f,
  1.93342030e-01f, -1.99164435e-01f, -2.20999703e-01f, 2.26417795e-01f, 6.06436282e-04f, -1.24627218e-01f, 4.44156677e-03f, 2.30308510e-02f, -1.68778021e-02f, 1.99775040e-01f,
  -1.25412300e-01f, -1.44735560e-01f, -2.86840312e-02f, -1.36371151e-01f, 1.75857678e-01f, -2.53766805e-01f, 1.21619821e-01f, 1.16964266e-01f, -2.01585721e-02f, 1.16188496e-01f,
  8.13257992e-02f, 1.40677154e-01f, 7.71897733e-02f, 4.11184132e-02f, 8.89964700e-02f, 1.02098107e-01f, -1.42093943e-02f, 1.06075607e-01f, -6.64692149e-02f, -1.66030601e-01f,
  -1.76220015e-01f, -1.49212524e-01f, 3.04070324e-01f, -3.74821424e-02f, 2.26964787e-01f, -1.40236899e-01f, 4.79228646e-02f, 8.88700336e-02f, 1.74066603e-01f, 2.76888192e-01f,
  1.58976689e-01f, 1.37003571e-01f, -1.25510350e-01f, 3.51301767e-02f, -3.59285101e-02f, 2.28761628e-01f, 2.07069591e-01f, -1.07262909e-01f, 1.91272482e-01f, -1.26002342e-01f,
  -1.86755449e-01f, 1.04527272e-01f, 4.93522100e-02f, -2.25719452e-01f, -2.27638349e-01f, 1.59158751e-01f, 1.28470004e-01f, -9.12794657e-03f, -3.78061235e-02f, 1.63619071e-01f,
  -2.19726697e-01f, -1.79208994e-01f, -1.74907390e-02f, -1.24169625e-01f, 1.11063709e-02f, 2.45694056e-01f, 4.93635572e-02f, -5.03085554e-03f, 2.29748741e-01f, 1.42259613e-01f,
  2.66191103e-02f, -9.11970362e-02f, 3.08597744e-01f, 6.45143166e-03f, 1.36669695e-01f, 1.76456183e-01f, -1.52030528e-01f, 1.20159537e-01f, 5.31617366e-02f, 1.09996021e-01f,
  1.40473470e-01f, -3.65076326e-02f, 2.05672324e-01f, 9.84560251e-02f, 6.78548738e-02f, 2.34903350e-01f, 7.87606183e-03f, 7.69349635e-02f, 1.51169673e-01f, 9.47447345e-02f,
  1.02471761e-01f, -5.84464930e-02f, -3.58447358e-02f, 9.87760052e-02f, 1.57487988e-02f, -9.89767462e-02f, 2.01787457e-01f, -3.03140879e-02f, -4.10690531e-02f, -1.86319038e-01f,
  -9.63392928e-02f, -3.41339894e-02f, -3.02923024e-02f, 1.30652472e-01f, -1.11183405e-01f, -6.74746856e-02f, 7.74468482e-02f, -5.98806106e-02f, 1.98810920e-02f, 1.91036955e-01f,
  7.52347708e-02f, -7.20777437e-02f, 2.69688189e-01f, 1.62339032e-01f, 1.83511581e-02f, -9.28803012e-02f, 2.96475619e-01f, -1.11515693e-01f, 3.18299942e-02f, 2.13160425e-01f,
  5.84469885e-02f, 2.82142282e-01f, 2.82575518e-01f, -4.50006835e-02f, -1.49784863e-01f, 9.24013779e-02f, 2.56579127e-02f, 1.37743980e-01f, -6.85090721e-02f, -1.69389546e-01f,
  -2.38465831e-01f, 1.77926466e-01f, 1.08255215e-01f, 1.32357135e-01f, 1.93542670e-02f, 1.54571697e-01f, 3.61000262e-02f, -1.78074732e-01f, -4.81189275e-03f, 8.62178057e-02f,
  -4.08365726e-02f, -2.58023530e-01f, 3.29228514e-03f, 7.90914074e-02f, 4.81960438e-02f, 1.12479702e-01f, 2.47760862e-02f, 9.67913941e-02f, 5.33681549e-02f, 7.63307586e-02f,
  1.03721537e-01f, 6.40415624e-02f, 1.35011390e-01f, 1.42929479e-01f, -3.13393772e-02f, 1.25351802e-01f, -1.97488442e-01f, -5.64376600e-02f, -2.88373113e-01f, -1.15782306e-01f,
  3.10765862e-01f, -2.46442124e-01f, 9.78755355e-02f, 5.85425012e-02f, 2.31075622e-02f, -7.22862631e-02f, -7.33522549e-02f, 1.03590503e-01f, 2.08786070e-01f, 2.47779012e-01f,
  -1.41630337e-01f, 5.71795963e-02f, 2.28814602e-01f, 2.86519825e-01f, 3.58876646e-01f, 1.37352571e-01f, 1.20775595e-01f, 4.96715531e-02f, -1.82239741e-01f, 9.56956819e-02f,
  -1.17078545e-02f, -3.86773944e-02f, -1.54010668e-01f, 2.38834605e-01f, 9.48635489e-02f, 5.10248765e-02f, -5.72544076e-02f, 5.24366871e-02f, -2.28420779e-01f, -1.44130275e-01f,
  -8.25530067e-02f, -1.55437261e-01f, -3.05028141e-01f, 4.23199207e-01f, 2.45861515e-01f, -7.35408515e-02f, -6.28646975e-03f, 1.84897125e-01f, 2.80251931e-02f, -1.30928189e-01f,
  -1.30411565e-01f, 1.28540069e-01f, -1.21950641e-01f, 1.95139367e-02f, -1.08265623e-01f, 5.49723804e-02f, -1.84167027e-01f, 1.59615666e-01f, 1.52179673e-01f, 5.01900800e-02f,
  5.12118153e-02f, 4.44853567e-02f, 2.99880989e-02f, 8.98944959e-02f, 1.29279748e-01f, 9.27182361e-02f, 1.69009548e-02f, 4.46121432e-02f, 1.68165475e-01f, 1.24112725e-01f,
  8.53793547e-02f, -1.82564437e-01f, 2.82898664e-01f, 2.59950995e-01f, 8.29088539e-02f, 1.45191342e-01f, 4.84139733e-02f, 6.94568232e-02f, 2.02052817e-01f, 4.59314734e-02f,
  8.00914168e-02f, -5.00512272e-02f, -1.16167806e-01f, -4.12088856e-02f, 2.78993130e-01f, 1.46642596e-01f, 2.67785013e-01f, -1.93193763e-01f, -2.22639710e-01f, -1.32186532e-01f,
  -1.01869944e-02f, -1.27426282e-01f, 5.96681014e-02f, -7.37272277e-02f, -2.08066612e-01f, -2.76572585e-01f, -1.93715572e-01f, -4.90491502e-02f, -1.21725880e-01f, -1.17917947e-01f,
  1.29501456e-02f, 2.18007669e-01f, 4.47257422e-02f, 6.66184649e-02f, 1.30936235e-01f, 1.35598620e-02f, 3.76801461e-01f, -4.05042805e-02f, -1.30585581e-01f, 2.07409803e-02f,
  1.93073869e-01f, -1.49875417e-01f, -1.01699658e-01f, 5.19491173e-02f, 3.81109238e-01f, 2.64895022e-01f, 1.15203187e-01f, 1.42544836e-01f, 9.72949192e-02f, 1.49811670e-01f,
  4.13501978e-01f, -7.49054402e-02f, -2.35615894e-02f, -1.33743703e-01f, 1.25304282e-01f, 1.37740988e-02f, 5.34095950e-02f, 1.09244630e-01f, -4.34988253e-02f, 4.95838895e-02f,
  7.64621869e-02f, 6.65647984e-02f, 7.00935647e-02f, -8.30504075e-02f, -7.39515573e-02f, 1.44342050e-01f, -2.10861474e-01f, -1.70554012e-01f, 2.96442538e-01f, -2.63540417e-01f,
  3.12449187e-02f, -1.20995238e-01f, -7.91637674e-02f, -1.17283314e-01f, 1.74765587e-02f, 1.18789719e-02f, 6.47301376e-02f, 5.75468317e-02f, -1.05017528e-01f, -1.26560286e-01f,
  1.25646457e-01f, 2.96968192e-01f, 2.31654629e-01f, -9.16160643e-02f, 2.00244069e-01f, 1.73686504e-01f, -1.02902241e-01f, 7.43484870e-02f, 2.88477927e-01f, -2.01967731e-01f,
  -3.85879166e-02f, 2.86635756e-01f, 2.73819566e-01f, 1.31964594e-01f, 1.55008882e-01f, -3.66487354e-02f, -1.81741595e-01f, 9.05622095e-02f, 1.33056909e-01f, 1.26564428e-01f,
  -5.79450093e-02f, 3.57353985e-02f, 5.69548421e-02f, -1.15117371e-01f, 7.21441135e-02f, 2.69250929e-01f, 4.76333778e-03f, 5.97277321e-02f, -2.65958995e-01f, 1.59298279e-03f,
  -5.20818718e-02f, 1.54274568e-01f, 5.19794831e-03f, -1.67635322e-01f, -1.07801773e-01f, 2.16254983e-02f, 1.56870604e-01f, 1.26443237e-01f, 1.39180645e-01f, 1.00631379e-01f,
  1.07872091e-01f, 2.85465568e-02f, 3.26987244e-02f, 1.14697531e-01f, 6.38264120e-02f, 7.86949545e-02f, 1.43205762e-01f, 2.76715029e-02f, 4.52762283e-02f, -7.93171227e-02f,
  1.58684060e-01f, 1.97783336e-01f, -1.59288332e-01f, 1.46831095e-01f, -9.22867656e-02f, 2.27111682e-01f, 2.14855783e-02f, 1.41596673e-02f, -1.92090139e-01f, -9.61055756e-02f,
  4.05696891e-02f, -1.59982238e-02f, 3.05509716e-01f, 4.45444919e-02f, -1.91334281e-02f, -7.37340748e-02f, -1.88862488e-01f, 1.60675973e-01f, -1.46802023e-01f, 6.07197657e-02f,
  3.23058456e-01f, -3.08554262e-01f, -1.87338829e-01f, 3.99781257e-01f, 2.57724077e-01f, -6.53161481e-02f, -8.28760266e-02f, 3.04695904e-01f, -1.56848833e-01f, 2.60792598e-02f,
  2.23917328e-02f, 5.90960383e-02f, 1.06054567e-01f, -5.73267490e-02f, 2.61042684e-01f, -2.69764036e-01f, -1.85871556e-01f, 1.37806401e-01f, 8.51834193e-02f, -7.06481561e-02f,
  -1.24349058e-01f, 1.25984073e-01f, -3.86898220e-02f, 1.00375608e-01f, 9.72719640e-02f, -1.19690103e-02f, 3.41275334e-02f, -7.00263456e-02f, 2.82438487e-01f, 2.15036422e-01f,
  4.92267683e-02f, 8.81062970e-02f, 1.10093065e-01f, 1.79689810e-01f, 1.74106248e-02f, -4.42129886e-03f, 2.81825475e-02f, 1.23301037e-01f, 4.64730822e-02f, 1.15037307e-01f,
  2.08556265e-01f, 4.81846146e-02f, 1.68360159e-01f, 7.69890472e-02f, 1.99121580e-01f, -2.91968640e-02f, -3.40990663e-01f, 2.62876779e-01f, 1.28956214e-01f, -6.17706738e-02f,
  1.27327695e-01f, 9.70426667e-03f, 1.47916764e-01f, 6.50320249e-03f, -5.75822778e-02f, 2.18650158e-02f, 2.80003875e-01f, 8.89918581e-02f, -1.88760340e-01f, -1.46598712e-01f,
  -1.30592480e-01f, -1.32871777e-01f, 8.67443308e-02f, -1.18578747e-01f, 2.24785939e-01f, -2.99490169e-02f, 2.03082971e-02f, -5.01855165e-02f, 6.55567646e-02f, 7.32523855e-03f,
  -1.00372449e-01f, -1.38031378e-01f, 1.40327662e-01f, 1.63250759e-01f, 2.17087433e-01f, 1.39033899e-01f, -1.72010511e-02f, 1.52389199e-01f, 2.24594936e-01f, -2.30012000e-01f,
  -1.18667081e-01f, -2.01813981e-01f, 3.44518840e-01f, -9.73691866e-02f, 2.82458235e-02f, 7.95026273e-02f, 4.55241501e-01f, -8.35781097e-02f, 2.18129396e-01f, 5.64660802e-02f,
  9.37475711e-02f, 1.97588727e-01f, 2.18482688e-01f, 2.09086508e-01f, 1.44441232e-01f, 2.18189787e-02f, 6.43845946e-02f, 4.03578952e-02f, 1.60345629e-01f, 6.53504878e-02f,
  1.67036906e-01f, 1.14100620e-01f, 4.70587090e-02f, 5.19676507e-02f, 4.33009639e-02f, 2.00053871e-01f, -8.31561461e-02f, -2.27616593e-01f, 1.89882994e-01f, 5.53346016e-02f,
  6.51155189e-02f, 3.25611122e-02f, 1.42397970e-01f, 6.77170679e-02f, 1.11137412e-01f, 1.64411776e-02f, 1.59348413e-01f, -7.48589560e-02f, -2.01272443e-01f, -2.05349065e-02f,
  1.33796617e-01f, 7.61493221e-02f, 2.37368539e-01f, -2.01269627e-01f, -2.94698983e-01f, -1.22921795e-01f, 1.02301031e-01f, -2.10974827e-01f, -2.06083983e-01f, -5.38059361e-02f,
  -1.39697209e-01f, 3.49411927e-02f, -6.88635632e-02f, -2.39816189e-01f, -1.58628792e-01f, 1.72343832e-02f, 1.28430143e-01f, 1.98165968e-01f, -2.04648394e-02f, -4.13489435e-03f,
  2.66110338e-02f, 1.00669332e-01f, 2.06240401e-01f, 5.97214662e-02f, -1.79428294e-01f, 3.46782282e-02f, 2.00161859e-01f, -1.86564922e-01f, -1.32548541e-01f, -2.04568659e-03f,
  4.12318289e-01f, 3.16368908e-01f, 4.20997776e-02f, 8.48622620e-02f, 2.11290214e-02f, 1.10321172e-01f, 2.26226017e-01f, -3.32604349e-01f, 3.48737761e-02f, 2.39165761e-02f,
  8.23269337e-02f, 1.01506226e-01f, 3.38026471e-02f, 5.64884059e-02f, 2.82339193e-02f, -4.18658182e-02f, -6.90633152e-03f, 1.18982621e-01f, 2.24677473e-01f, 1.53079331e-02f,
  1.60128832e-01f, 1.78295411e-02f, 1.44109860e-01f, 4.16644402e-02f, -3.09321612e-01f, 1.01981148e-01f, -1.57436445e-01f, 2.89574359e-02f, -1.35943711e-01f, 1.41120926e-01f,
  -5.69827184e-02f, -6.44689947e-02f, 5.09173386e-02f, -1.01498842e-01f, 9.58791301e-02f, 1.04236223e-01f, -1.97790086e-01f, -1.01103112e-01f, -2.37125880e-03f, 1.62762120e-01f,
  -2.10605606e-01f, 1.95991620e-01f, 3.69379789e-01f, -1.19455352e-01f, -3.43114659e-02f, 2.40910694e-01f, 1.79387212e-01f, 1.22152921e-02f, -8.67848694e-02f, 5.85132726e-02f,
  -4.68871854e-02f, 1.11156859e-01f, 1.52195752e-01f, 9.39099714e-02f, 1.25651047e-01f, -1.39467597e-01f, 2.10591376e-01f, -1.61241099e-01f, 1.09273791e-01f, 1.90576971e-01f,
  -5.22732027e-02f, -2.51785433e-03f, -4.54356782e-02f, 1.94912642e-01f, -8.64678398e-02f, -1.36851013e-01f, 1.84026077e-01f, 2.25275055e-01f, 3.11715335e-01f, 2.15266362e-01f,
  6.54548705e-02f, 1.84948921e-01f, 2.92239219e-01f, 2.42937922e-01f, 1.86216012e-01f, 2.67075628e-01f, 4.88143340e-02f, 1.69744536e-01f, 1.12864390e-01f, 2.24805057e-01f,
  1.81609839e-01f, 2.16646910e-01f, 3.11353266e-01f, 5.87823056e-02f, 4.12146822e-02f, 8.08515698e-02f, 3.04684732e-02f, 5.97323775e-02f, -9.75546762e-02f, 2.92183042e-01f,
  -6.60845488e-02f, 1.00794077e-01f, -1.29850626e-01f, -5.78789786e-02f, -2.42079407e-01f, 1.39097542e-01f, -3.61278057e-02f, 7.87054002e-02f, 2.93201566e-01f, 1.75587341e-01f,
  2.64364555e-02f, -7.59533234e-03f, -4.12713811e-02f, 9.78086963e-02f, -2.71724653e-03f, 1.39954197e-03f, 1.57984301e-01f, -8.57018828e-02f, -2.08573770e-02f, 9.76306871e-02f,
  1.85425326e-01f, -2.61542876e-03f, 1.17871631e-02f, -1.61934609e-03f, -3.81752625e-02f, 8.06157663e-02f, 1.77212268e-01f, -1.57714739e-01f, -2.36116201e-01f, -8.50249603e-02f,
  -1.66615307e-01f, -3.23329605e-02f, 5.71747124e-02f, 1.52830333e-01f, 6.99090958e-02f, -1.56728402e-01f, 5.94720840e-02f, 1.87910169e-01f, 1.96922436e-01f, -2.05765545e-01f,
  1.53128970e-02f, -1.87013745e-01f, -5.76479593e-03f, -2.95660887e-02f, -5.46164028e-02f, 3.25564742e-01f, 2.78353654e-02f, -9.40281078e-02f, 1.88409522e-01f, 3.65599170e-02f,
  1.24756217e-01f, 1.73820436e-01f, -3.46824080e-02f, -5.26631661e-02f, 9.08447206e-02f, 7.30373561e-02f, 6.58213273e-02f, 2.26443075e-03f, 2.51543410e-02f, 1.71839632e-02f,
  -9.80886593e-02f, -2.75250785e-02f, 1.26704067e-01f, -1.31837428e-01f, -2.69639224e-01f, -1.32152736e-01f, -3.16992372e-01f, 1.30277187e-01f, -1.64676309e-01f, 9.48203206e-02f,
  -6.86923563e-02f, -1.78534418e-01f, -1.79779500e-01f, 9.08245239e-03f, -7.62249604e-02f, 1.70333177e-01f, 1.99232057e-01f, 1.50364086e-01f, -1.07645586e-01f, 3.13943297e-01f,
  1.34422807e-02f, 3.41754220e-02f, 2.66053140e-01f, 4.82286401e-02f, 7.81039596e-02f, 1.55795559e-01f, 7.17265010e-02f, 2.86681443e-01f, 1.24891974e-01f, 1.06954366e-01f,
  -1.29814938e-01f, 1.38239786e-02f, 2.21301299e-02f, -2.68602788e-01f, -2.56569117e-01f, -2.28433851e-02f, 1.27123296e-01f, 3.48994195e-01f, -9.10087675e-02f, 1.50334418e-01f,
  -3.68100144e-02f, 2.61633337e-01f, -1.79603621e-01f, -3.50748211e-01f, 1.64857861e-02f, 3.00815076e-01f, 2.27132067e-01f, -4.22959104e-02f, -2.26702422e-01f, -8.83608833e-02f,
  -7.18629360e-02f, 1.79468453e-01f, 1.92285448e-01f, 1.42311379e-01f, 2.11758599e-01f, 1.26206920e-01f, 2.30384797e-01f, 1.68125331e-01f, 6.77649751e-02f, 1.53769210e-01f,
  7.35008484e-03f, 1.48304000e-01f, 9.84941423e-02f, -3.68108638e-02f, 7.25773647e-02f, 1.50579941e-02f, 1.76390901e-01f, -1.66787013e-01f, -1.13172889e-01f, -1.40430838e-01f,
  1.46260411e-01f, 1.18416868e-01f, 1.12593606e-01f, -1.16353862e-01f, -2.33569637e-01f, 2.48509422e-01f, -4.13025245e-02f, 1.45213917e-01f, 3.29038352e-01f, 1.49096936e-01f,
  1.47453368e-01f, 1.90339033e-02f, -1.25686601e-01f, 1.16620153e-01f, -2.18177080e-01f, 1.38317108e-01f, 5.34447357e-02f, -2.48653501e-01f, -1.83732525e-01f, 1.39054537e-01f,
  -1.07016198e-01f, -2.95104861e-01f, 2.07617849e-01f, -7.17074201e-02f, -1.60467282e-01f, 6.73408573e-03f, 8.69393349e-02f, -9.37579349e-02f, -9.13995281e-02f, 1.81623816e-01f,
  1.65708452e-01f, 4.79675233e-02f, 8.14429075e-02f, -7.14986632e-03f, -1.00403510e-01f, -2.43694901e-01f, 1.23990096e-01f, 1.01417959e-01f, 5.63406013e-03f, 2.45352715e-01f,
  6.82016313e-02f, 2.40564477e-02f, 1.11086108e-01f, 6.41112775e-02f, 1.24220259e-01f, 1.31548107e-01f, 1.42928928e-01f, 1.95759654e-01f, 3.96696217e-02f, 2.27574050e-01f,
  1.21395066e-02f, 1.88171938e-01f, 2.37635911e-01f, 1.01114497e-01f, 2.15761811e-01f, -1.00091130e-01f, 1.26222044e-01f, 2.11872518e-01f, -1.08451255e-01f, -3.93305346e-02f,
  1.32525653e-01f, 4.95911129e-02f, -2.33724043e-01f, -1.45643800e-01f, -8.88477340e-02f, 1.09326886e-02f, -2.64714032e-01f, 4.32571284e-02f, -3.96303684e-02f, 9.89705101e-02f,
  1.14808038e-01f, 1.03958979e-01f, 7.78009295e-02f, 2.94751793e-01f, 2.22616956e-01f, 1.69583410e-02f, 7.04308376e-02f, 2.68223137e-01f, 1.85692415e-01f, 1.61321387e-02f,
  2.49632075e-01f, -2.08823264e-01f, 1.06857002e-01f, 2.88640261e-01f, 9.47636664e-02f, 4.76298779e-02f, 1.43908530e-01f, -2.16960266e-01f, -1.54858502e-02f, 1.42398566e-01f,
  2.14119479e-01f, 3.56676728e-02f, 8.90242681e-02f, -1.36977613e-01f, 3.22142825e-03f, 6.16470724e-02f, 1.51717924e-02f, 1.05132982e-01f, 1.24669904e-02f, 5.17524965e-02f,
  -3.71614099e-01f, -1.95033118e-01f, 9.05855000e-02f, -3.10598221e-02f, 3.34219448e-02f, -1.64762467e-01f, 5.30165918e-02f, 4.59716767e-01f, -6.41948506e-02f, 2.05934614e-01f,
  -1.44023120e-01f, 7.21905008e-02f, -4.74737585e-03f, -6.07813075e-02f, 1.90112680e-01f, 1.64832637e-01f, 1.17846973e-01f, -1.72871631e-02f, 3.91255990e-02f, 2.31792375e-01f,
  1.02295227e-01f, -4.66451831e-02f, -6.50728401e-03f, 2.67167762e-02f, -1.73605472e-01f, 3.29313874e-02f, 1.09060304e-02f, 2.29973361e-01f, 1.37842059e-01f, 3.92986350e-02f,
  -2.60333512e-02f, -2.04304501e-01f, 7.19475299e-02f, 2.74494708e-01f, 8.14018250e-02f, 2.07741603e-01f, 2.12064147e-01f, -1.76686779e-01f, 7.35966712e-02f, 1.68412656e-01f,
  -8.45251605e-02f, -1.84220463e-01f, 1.15033448e-01f, 1.82671368e-01f, -3.54372188e-02f, 1.47928625e-01f, 1.50805458e-01f, -1.20165445e-01f, 8.40682015e-02f, -1.35807961e-01f,
  -1.77169010e-01f, 2.11495847e-01f, 4.15831089e-01f, 1.00084886e-01f, 1.64402559e-01f, 3.06750357e-01f, 2.99576372e-01f, 2.90953159e-01f, 3.46587569e-01f, -2.62251854e-01f,
  -5.49962483e-02f, -5.87263480e-02f, 1.27916917e-01f, -5.05222613e-03f, 5.49725369e-02f, 2.92373627e-01f, 8.54965374e-02f, 2.36054454e-02f, 1.02801867e-01f, 4.03456807e-01f,
  1.51042804e-01f, 1.11924410e-01f, -1.07745707e-01f, -4.36333977e-02f, 1.33584365e-01f, 1.32226339e-02f, 8.67926106e-02f, 6.44638836e-02f, 1.32253505e-02f, -6.72049522e-02f,
  -7.10647330e-02f, 1.68948054e-01f, 1.55537263e-01f, 5.72771952e-02f, 1.25293195e-01f, 8.21538568e-02f, 1.28845617e-01f, -4.20028977e-02f, -3.58628839e-01f, -3.48445438e-02f,
  -3.69854003e-01f, -6.26524761e-02f, -2.90691614e-01f, 1.22873083e-01f, -1.76924154e-01f, -9.17667449e-02f, -1.00091077e-01f, -2.80949444e-01f, -8.04753080e-02f, 9.55120251e-02f,
  -1.87812015e-01f, -1.25541419e-01f, 4.41242233e-02f, 1.77176744e-01f, -2.37708271e-01f, 4.06613261e-01f, 2.63509959e-01f, 1.13755241e-01f, 2.01624334e-01f, 7.46635646e-02f,
  1.45986527e-01f, -3.86743359e-02f, -8.55391026e-02f, 1.23476446e-01f, 1.59182116e-01f, 1.28928319e-01f, 2.03572273e-01f, 7.06755519e-02f, -4.20283899e-03f, -1.24371119e-01f,
  -1.74013495e-01f, 9.94211808e-02f, 2.21979052e-01f, 4.50772345e-01f, -2.42566466e-01f, 2.28203703e-02f, 1.26809523e-01f, 3.25880617e-01f, -7.06887692e-02f, -3.98760647e-01f,
  2.25480851e-02f, 2.50272393e-01f, 4.29267943e-01f, 1.46213561e-01f, -2.65169889e-01f, -1.23260938e-01f, 1.29930116e-02f, -7.90769458e-02f, 9.34453011e-02f, 6.45353794e-02f,
  6.67822408e-03f, 8.46783891e-02f, 1.48097172e-01f, -7.16100857e-02f, 1.74600989e-01f, 1.01753667e-01f, 3.47140208e-02f, 1.27727523e-01f, 1.69323348e-02f, -1.41616017e-01f,
  8.92962664e-02f, 9.98327211e-02f, 2.67564446e-01f, -2.05223739e-01f, -1.26672432e-01f, -4.87491004e-02f, 4.68982048e-02f, 7.37936124e-02f, 1.25212610e-01f, -3.64866294e-02f,
  1.20830191e-02f, 1.09983593e-01f, 8.57994035e-02f, 1.31935170e-02f, 2.72689581e-01f, 9.72213522e-02f, 1.61944047e-01f, -1.06250525e-01f, -1.01152379e-02f, -7.54355779e-03f,
  -5.69221098e-03f, 7.81334564e-02f, 1.95417833e-02f, -2.68569678e-01f, -2.48548955e-01f, 1.99338555e-01f, 1.41577899e-01f, -4.49028723e-02f, 1.31294414e-01f, 2.35995576e-01f,
  -6.73366636e-02f, 1.15494139e-01f, 1.65279120e-01f, -1.26832902e-01f, 1.43964648e-01f, 1.50271580e-01f, 1.56869054e-01f, -5.91423176e-02f, 4.42746617e-02f, 1.86150834e-01f,
  -1.16755947e-01f, 6.94219321e-02f, -1.27691412e-02f, 1.63182765e-01f, 1.13964848e-01f, 3.60865831e-01f, 2.20326424e-01f, 9.18598771e-02f, 1.28268108e-01f, 4.57966290e-02f,
  2.27658376e-01f, -7.45511502e-02f, 1.00059904e-01f, 1.31312748e-02f, 1.92494273e-01f, 1.53865471e-01f, 7.46133626e-02f, 1.31511778e-01f, 6.94797412e-02f, 9.58918259e-02f,
  -5.12697026e-02f, 1.61912113e-01f, -1.29265770e-01f, 3.27291191e-02f, -1.39612943e-01f, -2.35616848e-01f, -1.56302556e-01f, 3.44754718e-02f, 3.02703947e-01f, 3.05230673e-02f,
  1.22070394e-01f, -1.60154864e-01f, 1.48109883e-01f, 1.99784234e-01f, 5.32208942e-02f, 1.22902900e-01f, 1.34011894e-01f, -4.43306863e-02f, -2.35398710e-01f, 5.78745604e-02f,
  4.20192536e-03f, 4.25981171e-02f, 3.78146172e-01f, -9.34296623e-02f, -1.80217382e-02f, 1.30512685e-01f, 2.14420676e-01f, 3.78518522e-01f, 9.85588133e-02f, 3.66698913e-02f,
  7.75161460e-02f, 3.18379700e-01f, 1.51453078e-01f, 2.18258351e-01f, 9.27502569e-03f, 6.20596521e-02f, -2.75963277e-01f, 3.41682106e-01f, -1.15173750e-01f, 9.39209852e-03f,
  -1.17608614e-01f, -1.98430046e-01f, 2.09204972e-01f, -3.95441093e-02f, 7.30612800e-02f, 2.00799584e-01f, 4.13896054e-01f, 2.99238078e-02f, -7.16707259e-02f, -2.68060770e-02f,
  -6.52597621e-02f, 1.80516362e-01f, -2.22239420e-01f, -2.07380697e-01f, 1.87738866e-01f, 1.69264637e-02f, 1.64287865e-01f, 2.51510680e-01f, 1.82884067e-01f, 1.88003004e-01f,
  -4.64923913e-04f, 3.70901003e-02f, 5.10455389e-03f, 1.25813499e-01f, 1.48675442e-01f, -3.18189198e-03f, 2.82805297e-03f, 2.07874015e-01f, 4.86595854e-02f, -2.10908428e-02f,
  -1.83629036e-01f, 2.24624515e-01f, 7.54976571e-02f, -2.09311426e-01f, -1.31709889e-01f, -8.13145470e-03f, 1.04527809e-01f, 2.93342471e-01f, 3.29349451e-02f, -1.68380544e-01f,
  -4.99373116e-03f, -8.01125634e-03f, -2.81019539e-01f, 1.38404025e-02f, -7.86858499e-02f, 2.90091578e-02f, 2.88556427e-01f, 2.56046772e-01f, -5.19542880e-02f, 5.23953363e-02f,
  1.88900128e-01f, 1.06774643e-01f, 2.21975371e-01f, -1.78917905e-03f, -2.16192044e-02f, 1.55803531e-01f, 2.24311426e-01f, -1.11895896e-01f, 2.39240691e-01f, -7.99306184e-02f,
  -3.20006758e-01f, 2.96484176e-02f, -1.77997708e-01f, -1.11225411e-01f, -1.18066065e-01f, 4.54353929e-01f, 2.39789337e-01f, -9.04750079e-02f, 3.53310198e-01f, 1.57190710e-01f,
  4.26252306e-01f, -3.27012897e-01f, 4.09311280e-02f, -1.15372621e-01f, -1.09899066e-01f, -2.61245579e-01f, -1.12347431e-01f, -3.31824198e-02f, 8.44245702e-02f, 3.02684158e-01f,
  8.76318440e-02f, 8.45036954e-02f, 7.93103650e-02f, 1.00374691e-01f, 1.25019565e-01f, 2.10707963e-01f, 1.90072194e-01f, 1.69489160e-01f, 1.61772415e-01f, 1.95220485e-01f,
  -1.48690686e-01f, -2.20931426e-01f, -1.49008527e-01f, 5.47765791e-02f, -5.78210922e-03f, -3.57244611e-02f, -6.49729520e-02f, 3.34614724e-01f, -2.20665280e-02f, -1.47400098e-02f,
  -2.88452119e-01f, -2.40091924e-02f, -1.61044553e-01f, 2.82467753e-01f, 9.91873518e-02f, 1.86587229e-01f, 2.05288306e-01f, 1.06915586e-01f, 5.73760085e-02f, 3.38766098e-01f,
  -1.64122239e-01f, -5.30593991e-02f, 9.30914581e-02f, -8.26513320e-02f, -7.24459589e-02f, 2.84297556e-01f, 1.33299798e-01f, -7.36572742e-02f, 4.20064405e-02f, 1.74118221e-01f,
  -2.00568646e-01f, 1.51336983e-01f, -1.05846442e-01f, -1.80834338e-01f, -7.51261115e-02f, -6.31123185e-02f, -2.36425281e-01f, 1.92422375e-01f, 2.42765158e-01f, 5.21873757e-02f,
  -1.82253927e-01f, -2.54672438e-01f, -7.32892230e-02f, 1.15610048e-01f, -4.58555073e-02f, -6.24147570e-03f, -1.13789618e-01f, 1.42278876e-02f, 3.26874084e-03f, 2.61725277e-01f,
  -1.22607984e-01f, 8.30121636e-02f, 4.38434966e-02f, 2.05415249e-01f, -3.18871923e-02f, 1.81645110e-01f, 5.75251728e-02f, 8.68866965e-02f, 7.25385128e-03f, 1.88605040e-01f,
  8.27477276e-02f, 1.02580421e-01f, 1.54308513e-01f, 1.04443580e-01f, 1.73462033e-01f, 8.63866955e-02f, 9.86963958e-02f, 4.14132001e-03f, -2.30752558e-01f, 2.40514264e-01f,
  8.19953680e-02f, -4.19485159e-02f, 1.05182029e-01f, 2.60157101e-02f, 9.21926573e-02f, -9.27489775e-04f, -9.61258188e-02f, 2.18460530e-01f, 9.66943800e-02f, 2.06758045e-02f,
  -7.43553340e-02f, -1.10100418e-01f, -1.11670695e-01f, -4.99504134e-02f, 7.53534734e-02f, -4.71967496e-02f, 1.22981653e-01f, 5.97009510e-02f, 8.98718312e-02f, 4.18796465e-02f,
  2.02134207e-01f, -8.45076442e-02f, -4.45201769e-02f, -1.31130397e-01f, 6.91132993e-02f, -7.09057748e-02f, 1.65394187e-01f, 4.61028442e-02f, 4.29936983e-02f, 2.32966244e-01f,
  2.46703684e-01f, -4.57703434e-02f, -3.81351053e-03f, -1.75799027e-01f, 2.71928787e-01f, -1.32712945e-01f, 8.99771079e-02f, -1.79071948e-01f, 2.45786354e-01f, 4.80569303e-02f,
  1.45455256e-01f, -5.75970933e-02f, -9.36368406e-02f, 1.54855028e-01f, 2.64927864e-01f, 2.92826295e-01f, 7.16144964e-02f, -2.62174401e-02f, -5.06949611e-02f, -3.10665835e-02f,
  -5.33158612e-03f, -2.20755464e-03f, 1.14444926e-01f, -1.57985285e-01f, 5.73339462e-02f, 7.08599016e-02f, -5.00327908e-03f, 1.36492252e-01f, -1.52652338e-01f, -2.37813219e-01f,
  2.97853611e-02f, 2.72573233e-01f, 2.78827071e-01f, -1.70924604e-01f, -3.22812423e-02f, 3.72355953e-02f, 4.56266925e-02f, 5.63260056e-02f, 9.91053805e-02f, 4.28064317e-02f,
  3.01643878e-01f, -2.59405524e-01f, 1.09553374e-01f, 7.22077787e-02f, 1.97205499e-01f, -1.23304226e-01f, -2.61984199e-01f, -6.95254505e-02f, -2.18695160e-02f, -2.01863348e-01f,
  9.51296010e-04f, 6.26888573e-02f, -1.08878754e-01f, -1.54754117e-01f, -2.84084052e-01f, -2.47311562e-01f, 1.12923838e-01f, 1.04835428e-01f, -1.91142276e-01f, 4.02630836e-01f,
  2.50500470e-01f, 1.95944738e-02f, 1.46791115e-01f, -1.83228195e-01f, 2.94510394e-01f, 3.42097461e-01f, 7.64599219e-02f, 7.75228888e-02f, -9.05838683e-02f, 1.27745390e-01f,
  2.01863162e-02f, 2.74580747e-01f, 4.66149300e-02f, 3.12263161e-01f, 8.15240964e-02f, 2.58693337e-01f, 2.41218463e-01f, 2.02916369e-01f, 2.27542803e-01f, -3.92091066e-01f,
  2.17716351e-01f, 1.71796277e-01f, 1.57951236e-01f, 1.39020458e-01f, 2.73429174e-02f, 6.06474914e-02f, 1.24123909e-01f, 1.43290564e-01f, 9.33985040e-02f, 1.59660995e-01f,
  2.77959138e-01f, 7.74447024e-02f, -1.10994549e-02f, 2.23166570e-02f, 4.67896648e-02f, 1.81075364e-01f, 1.48666240e-02f, 7.62495622e-02f, -8.50173309e-02f, 1.37830466e-01f,
  6.44894987e-02f, -1.15067147e-01f, -1.14961609e-01f, -7.04919249e-02f, 1.91419080e-01f, 1.02535216e-02f, 3.27419102e-01f, 1.19649097e-01f, 2.71070570e-01f, -4.57137935e-02f,
  -1.22960858e-01f, 3.92295122e-02f, 1.61219109e-02f, 1.21427856e-01f, 1.79059699e-01f, -7.96161667e-02f, -1.07795253e-01f, 1.13062225e-01f, 5.72202504e-02f, 1.11735370e-02f,
  3.53280716e-02f, 8.21950585e-02f, -6.51466474e-02f, -3.97452116e-02f, 2.44649306e-01f, -1.37281604e-02f, 1.84724312e-02f, -7.57317692e-02f, 1.07475976e-03f, 1.05257295e-01f,
  -1.39283776e-01f, 1.98980212e-01f, -7.06819147e-02f, -7.03178346e-03f, 4.62566130e-02f, 3.92493010e-02f, -1.29952848e-01f, 1.92195788e-01f, 4.16840538e-02f, -2.51904249e-01f,
  -4.17967811e-02f, -2.18584195e-01f, 2.08196610e-01f, 1.75743893e-01f, 5.11927530e-02f, 1.42800212e-01f, 1.89804763e-01f, -4.96376380e-02f, 1.95258170e-01f, 8.70997831e-02f,
  8.15364793e-02f, 2.36120358e-01f, -1.11261448e-02f, 8.28724205e-02f, 6.65166304e-02f, 2.21611753e-01f, -2.04271674e-01f, -8.18522647e-02f, -2.49099545e-02f, 1.12452894e-01f,
  1.23981319e-01f, -1.78325653e-01f, -5.03856950e-02f, 2.29660571e-01f, 4.82988358e-02f, -1.23391777e-01f, -1.41371801e-01f, -1.79727405e-01f, -9.35223699e-02f, 6.46123886e-02f,
  2.94943135e-02f, 8.08297098e-02f, 3.29106510e-01f, -9.35593843e-02f, -1.64934888e-01f, 3.05116951e-01f, 1.56079549e-02f, 4.12111841e-02f, -1.34282410e-01f, 2.40326347e-03f,
  7.49459788e-02f, 3.00433159e-01f, 1.99265987e-01f, -1.91612005e-01f, -7.14691542e-03f, 3.37527186e-01f, 2.25578938e-02f, -5.12207337e-02f, -6.48808619e-03f, -6.41366765e-02f,
  5.37287965e-02f, 2.51705229e-01f, -6.46022558e-02f, 1.80837825e-01f, -5.56224212e-02f, 1.74763814e-01f, -2.12368891e-01f, -2.68668056e-01f, -2.38545388e-02f, 2.51717586e-02f,
  -7.34649524e-02f, 2.85244644e-01f, -2.33177707e-01f, -1.54385805e-01f, -1.16750464e-01f, -1.37121364e-01f, 9.73594841e-03f, -2.69158095e-01f, 1.59146190e-01f, 2.22435787e-01f,
  4.52175178e-02f, 1.18020028e-01f, 2.25048810e-01f, 6.79454133e-02f, 1.41735226e-01f, 1.69482306e-01f, 1.56697363e-01f, 2.04890758e-01f, -8.39757696e-02f, 1.05728298e-01f,
  -1.57629102e-01f, -5.80139682e-02f, -2.95839280e-01f, -1.34770662e-01f, 3.19041550e-01f, -1.42286837e-01f, 2.55728602e-01f, 5.46336658e-02f, 8.91279131e-02f, -1.83982730e-01f,
  -6.60756901e-02f, 1.56562626e-01f, 2.54292727e-01f, 2.75920212e-01f, -6.65885210e-02f, -1.41810030e-02f, 1.39428362e-01f, 2.36090660e-01f, 2.52930880e-01f, 1.48132861e-01f,
  2.02266663e-01f, -9.33474228e-02f, -2.14474484e-01f, 6.06924742e-02f, -2.83271093e-02f, 1.55798495e-01f, -5.13876555e-03f, 1.98385358e-01f, 9.78065506e-02f, 8.27963203e-02f,
  -1.38590811e-02f, 5.74091151e-02f, -2.42384374e-01f, -1.72100008e-01f, -2.03430235e-01f, 1.97176542e-02f, -3.32967877e-01f, 2.36516207e-01f, 3.53324413e-02f, -2.20560253e-01f,
  2.02347979e-01f, 1.12287946e-01f, 4.49688286e-02f, -1.29805624e-01f, 1.91393748e-01f, 1.21580228e-01f, -6.46476150e-02f, -9.72911790e-02f, -2.63167858e-01f, 5.96129941e-03f,
  -1.41459480e-01f, 1.33230761e-01f, -1.18685804e-01f, 2.55807154e-02f, -2.85054483e-02f, -8.77374932e-02f, 1.63142160e-01f, -7.79842362e-02f, -2.14933958e-02f, 7.18688294e-02f,
  -4.89079878e-02f, -8.97637904e-02f, -8.17947388e-02f, 7.40533024e-02f, -1.99227020e-01f, 7.64696300e-02f, -1.30439684e-01f, -1.30914718e-01f, -1.78653404e-01f, -1.21189162e-01f,
  2.04677507e-01f, 1.54933989e-01f, 1.15762606e-01f, -2.49489099e-01f, 7.70640075e-02f, -1.25843734e-01f, 2.49379367e-01f, 7.07214475e-02f, -1.51944935e-01f, -1.42260328e-01f,
  -7.59847611e-02f, -1.87687337e-01f, -1.37919009e-01f, 1.49930328e-01f, 7.86372647e-02f, -1.65932953e-01f, -5.13319038e-02f, 2.57083327e-01f, 6.54670671e-02f, 4.23040360e-01f,
  1.49860248e-01f, -2.20526516e-01f, 9.05645713e-02f, 1.69796109e-01f, 9.29359067e-03f, -1.40101552e-01f, 3.69261026e-01f, 1.16881005e-01f, -1.32144824e-01f, 4.20429438e-01f,
  -8.51306543e-02f, 1.46357402e-01f, 5.70586212e-02f, -1.78731933e-01f, -7.96628445e-02f, 4.36984636e-02f, 1.98195949e-01f, -1.24752305e-01f, -2.90562436e-02f, 3.85472804e-01f,
  -8.49182829e-02f, -2.09538728e-01f, -1.21299565e-01f, -9.31852497e-03f, -2.08303154e-01f, -3.16771924e-01f, 1.00027166e-01f, 7.73389870e-03f, 1.12278663e-01f, 2.32237682e-01f,
  -3.63339018e-03f, 9.87888798e-02f, 1.12554565e-01f, 7.02650547e-02f, 1.43312991e-01f, 1.21174134e-01f, 2.31837720e-01f, -5.38232103e-02f, 6.86391816e-02f, 1.37064189e-01f,
  -6.87121227e-02f, -1.14429913e-01f, -3.86779904e-02f, 8.78014714e-02f, -1.52796105e-01f, -2.62078673e-01f, -9.64285880e-02f, 7.40279034e-02f, 2.87213475e-02f, 1.97846144e-01f,
  1.48830876e-01f, -6.64705783e-02f, 1.63892373e-01f, 1.25138685e-01f, -1.62232071e-01f, 1.45161003e-01f, 1.92154005e-01f, -1.16343781e-01f, 2.08429992e-01f, 1.21819630e-01f,
  2.07313493e-01f, 1.88236564e-01f, 2.93941855e-01f, -2.48481959e-01f, 1.93213373e-01f, 2.60556579e-01f, 1.67900130e-01f, 4.71384376e-02f, 1.94659412e-01f, 7.58945197e-02f,
  3.58650714e-01f, 1.32960394e-01f, -1.20702013e-01f, 7.57453889e-02f, -1.16248965e-01f, -3.25474888e-02f, 1.56770304e-01f, 1.08589143e-01f, 1.22688986e-01f, 1.23187326e-01f,
  2.43925199e-01f, 1.79739609e-01f, 5.89180319e-03f, -3.05199564e-01f, 1.18558459e-01f, -1.52664781e-02f, 1.48861691e-01f, 5.19183017e-02f, -1.19981609e-01f, 2.69006908e-01f,
  -7.78936297e-02f, -1.47389352e-01f, 7.97236562e-02f, 2.22349726e-02f, 7.11900890e-02f, -5.32001629e-02f, 5.09954570e-03f, -7.12586865e-02f, 8.16979557e-02f, -4.10325965e-03f,
  1.87018350e-01f, 2.02853139e-03f, 7.98764974e-02f, 1.58725187e-01f, 6.71029985e-02f, 4.41562310e-02f, -1.10924557e-01f, -1.33687466e-01f, 6.08042665e-02f, -1.72142670e-01f,
  -7.68597890e-03f, -1.00976929e-01f, 1.82600409e-01f, -1.37782693e-01f, 3.12650234e-01f, -1.61606044e-01f, 4.53588665e-02f, -1.64012209e-01f, -1.20754838e-01f, -1.23680625e-02f,
  1.05342440e-01f, -1.77319840e-01f, 8.02632701e-03f, 1.82221830e-01f, 2.99049765e-01f, 1.49053007e-01f, -5.72173558e-02f, -5.13247587e-02f, -4.29506749e-02f, 2.42178246e-01f,
  1.67589068e-01f, -1.13768160e-01f, 1.22005314e-01f, -3.68296704e-03f, 2.92100787e-01f, 2.99474895e-01f, 2.75585175e-01f, -5.30611873e-02f, 3.24891299e-01f, 3.53705883e-02f,
  2.50722580e-02f, -1.25110149e-01f, 3.99975590e-02f, 4.35949117e-01f, 1.72044218e-01f, -1.80391651e-02f, -1.49397910e-01f, 2.44169995e-01f, 2.15997979e-01f, 1.56753957e-01f,
  2.09677428e-01f, 5.58955185e-02f, 1.56535089e-01f, 1.24712721e-01f, 2.00243279e-01f, 3.30282003e-01f, 7.59582147e-02f, 2.44923592e-01f, 3.20940763e-02f, 9.30904597e-02f,
  9.63771790e-02f, 1.99746698e-01f, 1.56584442e-01f, 2.41932437e-01f, 3.27322274e-01f, 1.97885528e-01f, 7.25001935e-03f, -6.64907098e-02f, -5.80080971e-02f, 1.50394052e-01f,
  -1.25783887e-02f, 1.31591529e-01f, -1.49344146e-01f, 2.23058030e-01f, -5.93755841e-02f, -2.98705027e-02f, -3.26266170e-01f, -9.75905657e-02f, 8.05355161e-02f, 1.81019410e-01f,
  2.82015473e-01f, 2.23355815e-01f, 2.77138919e-01f, -4.09099609e-02f, -6.42831773e-02f, 1.97082996e-01f, -1.42344713e-01f, 7.96450749e-02f, 2.42477983e-01f, -1.19905449e-01f,
  -1.60974339e-01f, 2.60559559e-01f, 1.74882144e-01f, -9.47233960e-02f, 6.84326235e-03f, -3.64783010e-03f, -2.05665037e-01f, 4.77619190e-03f, 2.03916624e-01f, -1.42515332e-01f,
  -4.90451418e-02f, -1.28996596e-01f, -1.43530900e-02f, 1.41866073e-01f, 6.83507398e-02f, 1.02625981e-01f, -1.68413609e-01f, -1.41487017e-01f, -5.50603261e-04f, 5.90115264e-02f,
  -2.51132339e-01f, 6.64528385e-02f, 5.43100014e-02f, -2.67318904e-01f, -5.31849451e-02f, -6.25851303e-02f, 9.22180414e-02f, 3.22052330e-01f, 5.11721671e-02f, 7.49014467e-02f,
  1.03633307e-01f, 8.16749632e-02f, 2.05158800e-01f, 2.03697421e-02f, 1.31894484e-01f, 6.26656786e-02f, -2.62552476e-03f, 1.83856606e-01f, 1.31698102e-01f, 2.05438197e-01f,
  -1.71672162e-02f, -6.37083128e-02f, 8.50042328e-02f, 1.43723756e-01f, 5.58495298e-02f, -2.94267889e-02f, 6.59480914e-02f, -1.23895891e-01f, 1.13201514e-01f, -6.08655587e-02f,
  2.77808011e-01f, -3.29880007e-02f, 1.54881850e-01f, 5.71523830e-02f, 5.35532907e-02f, 1.97776034e-01f, 2.81160295e-01f, -1.22279368e-01f, -2.47324351e-02f, -7.65984803e-02f,
  1.64220348e-01f, -7.61238486e-02f, -1.74885467e-01f, 1.83682337e-01f, -2.12014616e-01f, -2.59112746e-01f, -3.53787214e-01f, -4.27028537e-02f, -1.32822230e-01f, -2.28189170e-01f,
  1.07873730e-01f, 1.16181403e-01f, 2.64142722e-01f, -8.35357383e-02f, -3.65309827e-02f, -2.00664744e-01f, -4.83639352e-02f, 4.14299846e-01f, 7.78420642e-02f, 2.11779401e-01f,
  1.28779784e-01f, 3.70524265e-02f, 2.80734718e-01f, -2.19096214e-01f, 4.60054159e-01f, 3.43101591e-01f, 1.19827986e-01f, 3.36707868e-02f, -2.56875068e-01f, -5.27193211e-02f,
  2.07499459e-01f, -1.31107673e-01f, 1.83731824e-01f, 2.02363789e-01f, 6.61588982e-02f, 1.06792159e-01f, 1.37121528e-01f, 1.59180328e-01f, -1.13530392e-02f, 1.55190468e-01f,
  3.74107137e-02f, 1.09721497e-01f, -3.44100259e-02f, 8.56858268e-02f, -1.92688778e-01f, -2.77424287e-02f, -2.52326071e-01f, -1.23635769e-01f, 9.17391255e-02f, 4.61807824e-04f,
  -7.95021504e-02f, 7.19557181e-02f, -1.88639611e-01f, 4.93404409e-03f, -2.25799248e-01f, 1.13586709e-01f, -7.05549642e-02f, 8.64015147e-02f, -1.67212844e-01f, 5.88678978e-02f,
  -9.43465857e-04f, 1.84609011e-01f, 5.30283488e-02f, 3.02337885e-01f, 1.26020625e-01f, 9.26010385e-02f, -5.68991825e-02f, 9.30219591e-02f, 3.40079129e-01f, 2.70060360e-01f,
  2.94299453e-01f, -4.28197123e-02f, 1.51483119e-01f, 3.61814678e-01f, -5.41634448e-02f, -2.17289273e-02f, -9.05119926e-02f, -1.37053713e-01f, -1.58983052e-01f, 2.81301558e-01f,
  -1.52680531e-01f, 4.05354798e-02f, 1.25493556e-01f, 1.91921726e-01f, -1.76713064e-01f, -2.02548400e-01f, 9.93362740e-02f, 6.38391748e-02f, -2.06702590e-01f, -1.88649252e-01f,
  -6.56451136e-02f, -1.35710299e-01f, -1.19744159e-01f, 1.37544181e-02f, -2.21827701e-01f, 7.23930150e-02f, 1.94150880e-01f, 1.42426237e-01f, 1.34227006e-03f, 1.52265012e-01f,
  2.52803182e-03f, 1.47190765e-01f, 6.77922517e-02f, 1.90809101e-01f, 1.89615697e-01f, 4.33611684e-02f, 1.14481831e-02f, 1.45591736e-01f, -2.57476652e-03f, 5.96996490e-03f,
  -2.15046987e-01f, -1.16777912e-01f, 1.35086343e-01f, 1.12093374e-01f, 1.11999102e-01f, -1.85448080e-01f, 6.40086234e-02f, 6.62613884e-02f, 1.66368380e-01f, 2.90902466e-01f,
  5.46541484e-03f, 9.96480435e-02f, -4.61508073e-02f, 3.47519256e-02f, -1.63210705e-02f, 2.52385378e-01f, 1.12448350e-01f, -1.57077029e-01f, 2.58135408e-01f, -1.92076713e-01f,
  -5.90762757e-02f, 1.20373107e-01f, 1.87560111e-01f, -2.92655289e-01f, 4.71002422e-02f, 1.89510763e-01f, 2.19064444e-01f, -5.90715222e-02f, 6.80524707e-02f, -3.09853023e-03f,
  3.51692513e-02f, -3.85500342e-02f, -5.05357534e-02f, 2.40404099e-01f, 1.02736793e-01f, 8.30153301e-02f, 7.37312809e-02f, -6.47461638e-02f, 1.22553721e-01f, 4.98414673e-02f,
  2.51676053e-01f, -6.74412772e-02f, 1.71008721e-01f, -1.44952580e-01f, 1.22912467e-01f, 7.38103017e-02f, -1.76561847e-01f, 1.68052793e-01f, 6.90813810e-02f, 2.79595017e-01f,
  1.28722176e-01f, 1.06431253e-01f, 4.99687269e-02f, 1.30113035e-01f, 7.74072930e-02f, 9.30880085e-02f, 5.40082306e-02f, 1.31429061e-01f, 9.34610963e-02f, 7.94370398e-02f,
  1.46257862e-01f, 4.94439080e-02f, -3.15133408e-02f, 1.50929034e-01f, -1.92208424e-01f, -5.50906137e-02f, -1.68891728e-01f, 1.04477979e-01f, 1.58400148e-01f, -2.49017812e-02f,
  -3.51241492e-02f, -1.23462468e-01f, -4.73785847e-02f, -3.06781437e-02f, 2.60565013e-01f, 7.64452815e-02f, 2.79013962e-02f, 6.61578625e-02f, -1.81964606e-01f, -1.55907804e-02f,
  -8.97819549e-03f, 1.23174861e-01f, 2.28142947e-01f, 5.35500720e-02f, 1.82075024e-01f, 1.58493176e-01f, 1.68715060e-01f, 2.22341716e-01f, 2.98807442e-01f, -1.84768401e-02f,
  1.46100134e-01f, 2.39687234e-01f, -4.87334169e-02f, -1.23664759e-01f, 3.83592665e-01f, 1.05698280e-01f, -6.01280145e-02f, 2.06325829e-01f, 1.22079700e-01f, 1.00933433e-01f,
  7.53981844e-02f, -8.66686925e-03f, -3.65531035e-02f, 7.52591863e-02f, 3.26181710e-01f, -3.30719836e-02f, -8.72559994e-02f, 7.82090947e-02f, 1.23165198e-01f, -2.44864032e-01f,
  -1.48617029e-01f, -3.57050151e-02f, 2.87441025e-03f, 1.13730378e-01f, -2.93208994e-02f, 3.53320478e-03f, -9.12455916e-02f, 7.27412552e-02f, -2.29301583e-02f, -3.65136378e-02f,
  7.61536211e-02f, -1.92720089e-02f, 1.40075222e-01f, 7.59023726e-02f, 2.43313164e-01f, 4.31543998e-02f, 9.24156308e-02f, -7.64170364e-02f, 1.15639247e-01f, 1.89100266e-01f,
  -8.07198063e-02f, 2.63191499e-02f, -9.95633453e-02f, 9.38429385e-02f, 1.05718598e-01f, 1.36315554e-01f, 1.29011750e-01f, -1.81911513e-01f, 1.48831606e-01f, 4.01329957e-02f,
  7.98034370e-02f, 1.72823116e-01f, 2.39468172e-01f, -5.15242182e-02f, 5.09581082e-02f, -1.23086376e-02f, -1.91758245e-01f, -6.43312559e-02f, 2.46895671e-01f, 6.85257763e-02f,
  -1.42274246e-01f, -9.67366770e-02f, -1.06247120e-01f, 6.47831336e-02f, 1.74757451e-01f, -2.05081090e-01f, -1.24362156e-01f, 1.57927722e-01f, 3.40052724e-01f, 9.64233205e-02f,
  3.21756184e-01f, -3.13967094e-02f, 3.45024586e-01f, 1.75395191e-01f, 2.55571872e-01f, -1.40807748e-01f, 7.31009915e-02f, 1.72459230e-01f, 1.07166193e-01f, 4.86982204e-02f,
  -4.10116166e-02f, 2.78482348e-01f, 2.13985771e-01f, 1.50759563e-01f, 2.45896488e-01f, 3.31394821e-01f, 2.52116919e-01f, 2.53602743e-01f, 2.47501098e-02f, 1.14845298e-01f,
  1.43606126e-01f, 6.28658608e-02f, 1.26499191e-01f, 1.02370039e-01f, 1.07246168e-01f, 3.22635286e-02f, -2.74479692e-03f, 1.81349471e-01f, 5.16415313e-02f, 2.04765946e-01f,
  3.30637693e-02f, -1.13041066e-01f, -4.59232777e-02f, -3.76262292e-02f, -2.64575839e-01f, 1.43015310e-01f, -6.40446767e-02f, -9.54315737e-02f, -1.36801302e-01f, 9.87083167e-02f,
  6.79529384e-02f, 2.13189289e-01f, 1.01679467e-01f, -1.00675769e-01f, -3.15022953e-02f, 1.29631296e-01f, -2.68785924e-01f, -1.55509099e-01f, 3.10838446e-02f, 2.07763925e-01f,
  -3.53116319e-02f, 7.37846270e-02f, 4.15730067e-02f, 1.51567563e-01f, -4.45728451e-02f, 1.05609447e-01f, 4.82612364e-02f, -6.03755862e-02f, -4.54040393e-02f, 3.32810581e-02f,
  1.90325249e-02f, 2.32563168e-01f, 3.10540944e-01f, -1.80094138e-01f, -2.24297702e-01f, -1.89985529e-01f, -2.51928747e-01f, 2.81094342e-01f, 3.52208495e-01f, 3.15214396e-01f,
  2.11252980e-02f, -1.23544440e-01f, 2.36982748e-01f, 2.22300157e-01f, 4.16453600e-01f, -2.29193941e-01f, 1.69687867e-01f, 1.12453021e-01f, 2.15957016e-01f, 3.45332086e-01f,
  -2.35102281e-01f, -1.47185847e-01f, -1.83336455e-02f, -1.23140058e-02f, 1.92537040e-01f, 1.34347826e-01f, 1.20036304e-01f, 7.06528574e-02f, 1.18450867e-02f, -2.21491745e-03f,
  8.74899477e-02f, 1.39527217e-01f, 1.10882632e-01f, -3.08749974e-02f, 2.14669541e-01f, 1.72530651e-01f, 3.27967465e-01f, 1.12520866e-01f, -2.09085494e-01f, 7.97919780e-02f,
  -1.96573958e-01f, -2.34242558e-01f, 1.00909397e-01f, 9.66444537e-02f, 2.73764990e-02f, -2.68073499e-01f, -9.24474597e-02f, 7.37386495e-02f, 2.59805750e-02f, -8.05237591e-02f,
  -3.97190899e-02f, -8.93719494e-02f, -2.44356897e-02f, -4.19587418e-02f, -1.21628374e-01f, 3.22743326e-01f, 1.77589878e-01f, -8.74395892e-02f, -6.87009022e-02f, -7.06148818e-02f,
  -1.23519665e-02f, 1.02664724e-01f, -2.53971815e-01f, -1.71481431e-01f, 3.07830364e-01f, -1.30452946e-01f, -1.77011304e-02f, 2.02455506e-01f, 3.01397026e-01f, -1.67294219e-01f,
  2.76499897e-01f, -2.30184540e-01f, -6.75242171e-02f, 1.43665150e-02f, 3.21439683e-01f, 1.30078778e-01f, -9.46515948e-02f, -1.63235739e-01f, 1.80739924e-01f, 6.28184825e-02f,
  1.61930740e-01f, 2.31852949e-01f, 1.64763242e-01f, -2.53147911e-02f, 2.66163945e-01f, 8.90257582e-02f, 1.53283179e-01f, 1.69803113e-01f, -2.27986854e-02f, 1.77180484e-01f,
  6.71096817e-02f, 1.35054186e-01f, 6.27386272e-02f, 1.29515439e-01f, 2.22671345e-01f, 1.40226215e-01f, -4.20005359e-02f, 1.55962765e-01f, -1.36251189e-02f, -1.17813677e-01f,
  -1.52351022e-01f, -3.39878686e-02f, 3.38150382e-01f, -1.23096570e-01f, 8.60124081e-02f, -6.69815987e-02f, 4.22750041e-02f, 8.57599601e-02f, 6.08917028e-02f, 1.33987024e-01f,
  -7.23216757e-02f, 2.33630210e-01f, -1.14784554e-01f, 4.42436412e-02f, 2.24998266e-01f, 2.76421756e-01f, 2.09272593e-01f, -1.92875694e-02f, 1.00481600e-01f, 2.29493566e-02f,
  -1.59334496e-01f, -7.22262338e-02f, 1.35193393e-01f, -1.46562681e-01f, -1.28548786e-01f, 2.76410013e-01f, 2.92194132e-02f, 5.27794547e-02f, 3.25902156e-03f, 7.31442943e-02f,
  -3.71813208e-01f, -1.19181737e-01f, 2.24319309e-01f, -1.14434138e-01f, 4.77659069e-02f, 1.43016770e-03f, 6.26073033e-02f, -5.99161647e-02f, 1.02681614e-01f, 1.44792765e-01f,
  -1.12975881e-01f, -1.04896121e-01f, 4.60475571e-02f, -3.64960544e-02f, 2.86583155e-02f, 2.10714370e-01f, -7.76093155e-02f, 1.77692220e-01f, 1.01344660e-01f, 2.45287269e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.87516779e-01f, 1.30787700e-01f, 1.00895733e-01f, 1.33085623e-01f, 1.70199469e-01f, 1.27725661e-01f, 1.25246555e-01f, 5.12396805e-02f, 1.47932246e-01f, 1.62789539e-01f,
  9.31981802e-02f, 3.96718085e-02f, 1.00384012e-01f, 1.14693761e-01f, 7.94437528e-02f, 8.44985992e-02f, 1.05200395e-01f, 9.94969308e-02f, 3.49922217e-02f, 1.02564581e-01f,
  1.38745382e-01f, 1.28520951e-01f, 1.45239994e-01f, 1.11522622e-01f, 1.08484767e-01f, 1.52406797e-01f, 1.58825040e-01f, 1.18837357e-01f, 2.40153484e-02f, 1.69534341e-01f,
  8.83402228e-02f, 1.55934989e-01f, 1.39520586e-01f, 1.73441440e-01f, 1.29416525e-01f, 7.12982416e-02f, 6.83921427e-02f, 1.39080122e-01f, 8.32119584e-02f, 2.14115083e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -9.98616070e-02f, 6.72977120e-02f, -1.89985350e-01f, -4.77752686e-02f, 3.92060131e-02f, -7.55585311e-03f, 1.84596583e-01f, -1.34008020e-01f, -3.22765633e-02f, -1.31120175e-01f,
  -9.56967697e-02f, 1.96099907e-01f, -1.75505102e-01f, 4.26752977e-02f, 1.57351658e-01f, 2.42629379e-01f, -2.10908353e-01f, -2.24646494e-01f, -4.09417078e-02f, 1.09978758e-01f,
  -1.27104834e-01f, -1.76340595e-01f, 5.83585240e-02f, -1.56511888e-01f, -3.89931291e-01f, 2.59619713e-01f, 3.69237959e-01f, -1.98001668e-01f, -1.57047510e-01f, 1.83491796e-01f,
  -5.20076379e-02f, -2.53212750e-01f, 2.72307515e-01f, -3.63362968e-01f, -2.49850556e-01f, -1.79653570e-01f, 7.29545727e-02f, -4.21383500e-01f, 3.94505322e-01f, 3.40731472e-01f,
  2.72304147e-01f, -2.75344402e-01f, 4.26115423e-01f, 2.81332135e-01f, -4.32928890e-01f, -1.84445620e-01f, -3.49128336e-01f, -2.63608783e-01f, -1.21084824e-01f, -3.22804391e-01f,
  -2.96474546e-01f, -1.43650129e-01f, -1.01511903e-01f, 1.12163216e-01f, 2.92460442e-01f, -4.22912031e-01f, -1.83011010e-01f, -4.13708329e-01f, -1.92455664e-01f, -1.94637135e-01f,
  9.30147991e-03f, -2.40464076e-01f, 3.92040968e-01f, 1.09580092e-01f, 1.24477342e-01f, 6.09671734e-02f, -3.74508016e-02f, 2.34948993e-01f, 1.58117101e-01f, -7.78569356e-02f,
  -1.94831137e-02f, -1.42076954e-01f, -6.09236397e-02f, 3.54326099e-01f, 1.42492771e-01f, -1.24964915e-01f, 1.28586918e-01f, 6.96960464e-03f, -2.46907234e-01f, -3.46975237e-01f,
  3.84047270e-01f, 2.82624424e-01f, -2.38825083e-01f, -5.54769449e-02f, -3.82777274e-01f, 2.41771177e-03f, 1.07384995e-01f, 3.48412186e-01f, -4.49255377e-01f, -3.37304175e-01f,
  -3.23499322e-01f, -3.85634333e-01f, 3.74326378e-01f, 3.65435839e-01f, 2.37477541e-01f, -1.65849239e-01f, 3.79120499e-01f, -1.38243645e-01f, -2.63620198e-01f, -2.71562010e-01f,
  -3.23897421e-01f, -3.04085612e-02f, 2.43173867e-01f, -5.18345498e-02f, 2.79477090e-01f, -6.14298224e-01f, -3.24028045e-01f, 1.11390896e-01f, 4.93471362e-02f, 7.15846121e-02f,
  -1.40741706e-01f, -3.36758822e-01f, 5.67490906e-02f, -1.46284550e-01f, -3.10609847e-01f, 2.48454675e-01f, -3.45692933e-01f, 2.36255780e-01f, -1.79378707e-02f, -2.76012391e-01f,
  -4.02716249e-01f, 9.15537402e-02f, 3.25392365e-01f, 2.19687987e-02f, -2.48092860e-01f, -3.06258529e-01f, -3.74420941e-01f, 3.57048899e-01f, -3.27516496e-02f, 3.65174725e-03f,
  1.20159224e-01f, -2.46743783e-01f, -2.09302157e-01f, 8.61886144e-02f, 1.05595507e-01f, 8.19600150e-02f, -1.09934047e-01f, -3.01191926e-01f, 9.95848328e-02f, -2.36927971e-01f,
  2.04717025e-01f, -2.87678409e-02f, 2.41744205e-01f, -4.90266122e-02f, 2.09285453e-01f, -5.04284725e-02f, 9.41679161e-03f, -8.28589424e-02f, -2.31699884e-01f, -2.08630666e-01f,
  -1.16514988e-01f, -2.28847861e-02f, -4.36684757e-01f, -3.85477126e-01f, -1.75301924e-01f, 3.86165440e-01f, -3.71568531e-01f, 1.31397262e-01f, -5.83654523e-01f, -8.55752453e-02f,
  7.35838190e-02f, -4.23964709e-01f, 9.56344455e-02f, 8.41258913e-02f, -2.69342810e-01f, -1.36187464e-01f, -1.39313981e-01f, -2.58702487e-01f, 4.72299494e-02f, 1.94535941e-01f,
  9.22609046e-02f, -3.70575488e-01f, 2.97136635e-01f, 2.20385358e-01f, -3.79513830e-01f, 1.80530086e-01f, -4.21029836e-01f, -1.98076665e-01f, 1.56753883e-01f, -2.41644949e-01f,
  3.77043396e-01f, 2.44212270e-01f, -6.43900633e-02f, -3.98934156e-01f, -2.06263170e-01f, 2.18331516e-01f, 2.04308599e-01f, 3.28607798e-01f, -2.86570340e-01f, -1.94315150e-01f,
  -2.33335853e-01f, -5.10760486e-01f, -2.80147523e-01f, -4.92000952e-02f, 1.60311186e-03f, 3.83510068e-02f, -3.85802761e-02f, -1.00275904e-01f, -2.60685056e-01f, 2.06820518e-01f,
  3.86191085e-02f, 6.13243766e-02f, 1.03872731e-01f, -1.87338620e-01f, 1.15088008e-01f, -2.39284620e-01f, -4.98417132e-02f, 2.08482370e-01f, -7.32233822e-02f, -1.48616791e-01f,
  -2.36435700e-03f, -1.92280844e-01f, 6.39631152e-02f, -1.00178579e-02f, 1.53912324e-02f, -5.93150035e-02f, -4.18261945e-01f, -3.92893553e-02f, 2.14960858e-01f, 1.25063479e-01f,
  2.14490011e-01f, -4.09265131e-01f, -2.32422307e-01f, 4.16770667e-01f, -2.55521268e-01f, 3.86921316e-02f, 1.28720671e-01f, 2.66309559e-01f, 1.00026116e-01f, -4.83787060e-01f,
  -2.87091225e-01f, 1.18910722e-01f, -4.37252194e-01f, 2.55083561e-01f, -3.71658057e-01f, 2.53025055e-01f, -2.72201777e-01f, -5.60603917e-01f, -3.55590016e-01f, 1.79624990e-01f,
  3.78117472e-01f, -5.51092982e-01f, -2.67161638e-01f, -4.37606275e-01f, -6.77442998e-02f, -4.95282918e-01f, 2.24046692e-01f, -5.29242456e-01f, 4.61751819e-02f, -8.13240781e-02f,
  1.01301372e-01f, -4.09854233e-01f, 3.84564787e-01f, -8.62353668e-02f, 2.54017323e-01f, 2.43651167e-01f, 7.93590397e-02f, -6.30345345e-02f, 2.14375064e-01f, -1.81089208e-01f,
  -3.25931087e-02f, -1.65634617e-01f, 2.89571196e-01f, 3.34347039e-02f, 1.50676873e-02f, -1.21149421e-01f, -7.39522576e-02f, -1.84817836e-01f, -2.66307265e-01f, 1.50632262e-01f,
  -9.31563601e-02f, 2.19131678e-01f, 1.37853071e-01f, -1.79950237e-01f, 4.06486988e-01f, -2.75789857e-01f, -2.39570141e-02f, -1.95416883e-01f, 1.11871377e-01f, -2.87888031e-02f,
  -6.24250621e-02f, 4.02870715e-01f, 1.06511593e-01f, 2.59012207e-02f, -3.71904284e-01f, -5.58015108e-02f, -4.93096352e-01f, -8.65156855e-03f, -2.48946294e-01f, 3.79934967e-01f,
  2.48153642e-01f, -3.65677774e-01f, 2.81271160e-01f, 2.71244913e-01f, -3.43109637e-01f, -1.30006641e-01f, 3.06795567e-01f, 1.21851236e-01f, -1.69918045e-01f, -9.69128683e-02f,
  -2.93591976e-01f, 2.77751163e-02f, -3.25581878e-02f, 2.56150097e-01f, -4.21156138e-01f, 2.75385559e-01f, -3.89334083e-01f, -2.93755025e-01f, -1.88744843e-01f, 1.23562552e-01f,
  2.04277813e-01f, 3.64525795e-01f, -1.74782559e-01f, -4.40969020e-01f, -4.24335226e-02f, 1.63026914e-01f, 1.95386961e-01f, -3.57279509e-01f, 2.77759969e-01f, -1.54615834e-01f,
  1.83180675e-01f, 3.82393561e-02f, 2.22115725e-01f, -6.83341324e-02f, -4.53089885e-02f, -4.85291146e-02f, -1.09746620e-01f, 1.76974222e-01f, 1.86153263e-01f, -2.18358804e-02f,
  -6.76168548e-03f, 2.29729474e-01f, -4.82599884e-02f, 1.22876056e-01f, -5.03073893e-02f, 1.07819110e-01f, -3.23682010e-01f, 1.48348525e-01f, -2.77153164e-01f, -4.28363293e-01f,
  3.20796072e-01f, 3.90471816e-01f, 1.26221195e-01f, -2.98046142e-01f, 3.25557530e-01f, -1.19757250e-01f, 3.44487846e-01f, -4.09466028e-01f, 1.16997398e-01f, -2.08079100e-01f,
  2.84828573e-01f, -5.06195009e-01f, -9.03322995e-02f, -4.50272620e-01f, -3.63618433e-01f, -3.26221496e-01f, -8.78516510e-02f, 1.56695634e-01f, 3.85822766e-02f, 3.46534610e-01f,
  1.35850564e-01f, 2.83771396e-01f, 5.82459271e-02f, -2.78954003e-02f, -4.74801928e-01f, -3.49538118e-01f, 3.95384878e-01f, 6.74655139e-02f, -3.34913254e-01f, -1.20601058e-01f,
  -3.05630229e-02f, 1.21367045e-01f, -2.10621178e-01f, -1.90629326e-02f, -4.85927045e-01f, 2.65432745e-01f, -9.16515663e-02f, 1.65107995e-01f, 1.47565708e-01f, -2.35363450e-02f,
  2.56353933e-02f, 1.52601495e-01f, -2.09674701e-01f, 2.93024480e-01f, -1.85641740e-02f, 3.90681364e-02f, -4.43904027e-02f, 1.39980614e-01f, 2.93629151e-02f, 3.01061179e-02f,
  -2.84936987e-02f, -6.23969920e-03f, 1.01603083e-01f, 2.20402405e-01f, 2.19695553e-01f, -7.39544034e-02f, 2.48895779e-01f, -2.93230087e-01f, 2.44156152e-01f, -2.13985160e-01f,
  -5.32981381e-03f, -9.15455967e-02f, -2.18020439e-01f, 3.43647718e-01f, 2.45800167e-01f, 2.29876339e-01f, -8.34289417e-02f, 3.08108479e-01f, 4.25144374e-01f, 9.80511755e-02f,
  -2.92269319e-01f, 2.66369581e-01f, -2.71515518e-01f, -1.02784432e-01f, 1.20304979e-01f, -3.29631358e-01f, -7.98413754e-02f, 2.49419630e-01f, -1.91827267e-01f, 6.96921647e-02f,
  -1.46071345e-01f, 1.62120238e-02f, -1.53559580e-01f, -3.64974499e-01f, -1.93315074e-01f, 9.87044424e-02f, -5.45486629e-01f, -3.49706680e-01f, 3.66340965e-01f, -2.83121824e-01f,
  3.10309619e-01f, -1.35732651e-01f, -2.52600640e-01f, 8.89587998e-02f, 3.88719082e-01f, 3.67977947e-01f, 3.67570162e-01f, -5.36997139e-01f, -2.90338278e-01f, 1.90763742e-01f,
  -4.48899806e-01f, 1.63215220e-01f, -3.96189511e-01f, 1.81343973e-01f, -4.39608783e-01f, -3.70130777e-01f, -2.61206031e-01f, -1.25692608e-02f, -1.08660430e-01f, -2.14949727e-01f,
  -1.92590341e-01f, 2.93471515e-02f, -1.49927229e-01f, 6.15476370e-02f, -1.54165179e-01f, 2.43723821e-02f, -9.88910198e-02f, 1.35690514e-02f, 1.88978110e-02f, -2.26361342e-02f,
  -8.83706510e-02f, 1.34355843e-01f, 1.67664047e-02f, 8.11211169e-02f, -1.02980003e-01f, 1.16805390e-01f, 3.93529832e-02f, 9.78868008e-02f, 9.01427062e-04f, 3.51593979e-02f,
  -1.68282181e-01f, -1.21299677e-01f, -1.27313539e-01f, -4.18229282e-01f, -1.68226883e-01f, -2.50237077e-01f, -1.86321169e-01f, -2.83273041e-01f, -1.05339274e-01f, 8.51931423e-02f,
  -1.91027716e-01f, 1.65338013e-02f, 1.57617584e-01f, -3.32975462e-02f, 3.32984239e-01f, 2.02915967e-01f, 1.03787571e-01f, -2.38471344e-01f, -3.65334421e-01f, 2.94600427e-01f,
  3.69421721e-01f, 1.75279349e-01f, 1.41416624e-01f, -2.05973610e-01f, 2.94111013e-01f, -2.28124857e-01f, 3.71869355e-01f, -1.43395588e-01f, -2.46002793e-01f, -2.43774861e-01f,
  -1.52606726e-01f, 1.22609526e-01f, 4.91618887e-02f, 8.91501531e-02f, -3.24579030e-01f, -2.33387873e-01f, -2.16885880e-01f, -2.39527494e-01f, 2.86848783e-01f, 3.80671114e-01f,
  -2.61850119e-01f, -3.13177526e-01f, -1.48321139e-02f, -1.19518921e-01f, -9.63191018e-02f, -5.25869094e-02f, -1.55169129e-01f, -2.79306948e-01f, -7.38971531e-02f, 5.06848544e-02f,
  -1.12723641e-01f, -4.79208305e-04f, 8.78361538e-02f, -5.84488846e-02f, 1.26750469e-01f, -2.32769683e-01f, -1.01363324e-01f, -1.87812194e-01f, 1.08148292e-01f, 1.24236897e-01f,
  1.28230065e-01f, -2.26925850e-01f, -9.78909880e-02f, 6.21851869e-02f, -2.21594572e-01f, 3.52131613e-02f, 4.52293409e-03f, -1.46769688e-01f, 1.59469128e-01f, -3.58521491e-01f,
  2.01959163e-01f, -4.29707587e-01f, 2.14429393e-01f, -1.96960285e-01f, -2.93474495e-02f, -1.71674564e-01f, -2.22787723e-01f, -2.08263144e-01f, -2.18030974e-01f, -1.64655983e-01f,
  -3.01310241e-01f, -1.75083667e-01f, -3.45229626e-01f, 1.41947702e-01f, -2.39818901e-01f, -6.81181401e-02f, -2.59461645e-02f, 8.43504518e-02f, -1.97725400e-01f, -1.88923314e-01f,
  3.19802165e-01f, 9.51122865e-02f, -1.78307146e-01f, 2.17265591e-01f, 3.44734520e-01f, 9.10492335e-03f, 3.90673459e-01f, -7.84740597e-03f, 4.92242455e-01f, -3.25131059e-01f,
  5.53046502e-02f, 3.26243609e-01f, 1.45940021e-01f, 1.97524980e-01f, -3.03869724e-01f, -2.09718168e-01f, -9.53125581e-02f, 7.71894306e-03f, 9.08324774e-03f, 1.15912914e-01f,
  -5.28969690e-02f, -1.76063910e-01f, 3.70160723e-03f, -1.42808920e-02f, 1.63672626e-01f, -1.45978510e-01f, -2.08656210e-02f, 9.05158743e-02f, 1.90566033e-01f, 1.70578659e-01f,
  3.24046105e-01f, 2.61586428e-01f, -1.34443268e-01f, -1.72295377e-01f, -3.07702780e-01f, 2.92003900e-01f, 1.50236905e-01f, -2.22380266e-01f, -4.17884886e-02f, -1.33329213e-01f,
  -1.50326267e-01f, 6.00215532e-02f, -1.52665854e-01f, 2.17824697e-01f, -1.53734431e-01f, 5.50021082e-02f, -3.89572322e-01f, -2.04160944e-01f, -3.47394824e-01f, 2.74956226e-01f,
  -4.48838234e-01f, -2.23824933e-01f, 3.37889850e-01f, 2.14229882e-01f, 4.74462509e-01f, -3.63096297e-01f, -2.50722561e-02f, -4.36310738e-01f, 5.63488781e-01f, -4.33648497e-01f,
  -2.21829891e-01f, 4.78901386e-01f, 1.66894734e-01f, -2.67420143e-01f, 1.43058449e-02f, 1.29179850e-01f, 1.49743408e-01f, -3.65579009e-01f, -2.48687744e-01f, -8.29743743e-02f,
  -3.91903400e-01f, 2.00930774e-01f, 7.78482109e-02f, 2.37519562e-01f, -3.93750548e-01f, 1.05355889e-01f, -4.61930454e-01f, 3.62562478e-01f, -1.09287448e-01f, -3.19753021e-01f,
  6.47440627e-02f, 1.15379237e-01f, 1.02524087e-01f, 1.68618068e-01f, -4.81729321e-02f, 2.36318652e-02f, -4.35925312e-02f, -2.31920276e-02f, 1.27238676e-01f, 9.34959427e-02f,
  3.18324519e-03f, 8.31469521e-02f, -2.05319539e-01f, -1.28205135e-01f, -1.19446121e-01f, -3.73442769e-02f, -2.92063147e-01f, 3.93591002e-02f, 1.67966098e-01f, 3.09210867e-01f,
  1.16644993e-01f, 4.51078638e-02f, -3.21023874e-02f, -1.47162572e-01f, 6.01565428e-02f, -4.63595748e-01f, -3.41835350e-01f, -1.53692976e-01f, 3.07581633e-01f, 2.87247356e-02f,
  -5.94641790e-02f, 2.34679610e-01f, -3.95079345e-01f, -2.63230175e-01f, 3.63119215e-01f, 3.25310379e-01f, -3.66562486e-01f, 2.07428008e-01f, -3.42251092e-01f, 2.83632964e-01f,
  -3.70135427e-01f, -2.89587885e-01f, -2.22501099e-01f, -7.08947852e-02f, 3.62768978e-01f, 4.84903157e-01f, -1.31078064e-01f, 2.72570074e-01f, -3.70400339e-01f, -2.11866975e-01f,
  -2.39642918e-01f, 1.74014762e-01f, -3.66648585e-01f, -1.22232083e-02f, -4.24575269e-01f, -3.02507967e-01f, 4.33768868e-01f, -4.37330306e-01f, 2.04298720e-01f, -3.29293191e-01f,
  -4.18458700e-01f, 3.27060670e-01f, 1.75232470e-01f, 1.01629451e-01f, 4.79390658e-02f, -7.55132586e-02f, -4.45405319e-02f, -9.72749963e-02f, -7.10245743e-02f, 8.95090699e-02f,
  1.77829698e-01f, 1.51510999e-01f, -2.63174810e-02f, -5.69410529e-03f, -1.48655444e-01f, 8.46811682e-02f, -1.64651588e-01f, 1.29978344e-01f, 3.36441249e-01f, -3.46531838e-01f,
  -2.36475989e-01f, 1.63433224e-01f, 5.72900251e-02f, 2.06222624e-01f, 2.36563742e-01f, 1.59516379e-01f, 1.69296026e-01f, -9.59708691e-02f, 2.50328600e-01f, 2.26106897e-01f,
  -3.49203676e-01f, 2.66287863e-01f, -1.32427067e-01f, -4.37657423e-02f, 6.54066354e-02f, 4.06755567e-01f, -7.30273128e-02f, 3.94539163e-02f, -3.93431842e-01f, 3.69309872e-01f,
  -4.34720218e-01f, 2.84752175e-02f, -2.10277066e-01f, 2.64516383e-01f, -1.57093808e-01f, 4.89331186e-02f, -2.77451754e-01f, 2.21154049e-01f, -4.65510994e-01f, -3.85904163e-01f,
  1.79082081e-01f, -2.13138014e-01f, 5.12399971e-01f, 3.60547662e-01f, 3.50196153e-01f, -1.43525273e-01f, -2.43526503e-01f, -4.71644998e-01f, -3.13595742e-01f, 2.84511507e-01f,
  3.77525628e-01f, -3.22364897e-01f, -3.13864470e-01f, -4.56447661e-01f, 9.06157047e-02f, -4.39394623e-01f, -1.72251552e-01f, 4.47491780e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.61849558e-02f, -7.37500936e-02f, -9.53895748e-02f, -9.36004706e-03f, -2.22068094e-02f, 1.06968649e-01f, 5.60843535e-02f, 2.78420411e-02f, 7.25469068e-02f, -1.11441612e-01f,
  -4.86613065e-02f, 7.89223984e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    