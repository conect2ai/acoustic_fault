/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.58835876e-01f, -1.87093362e-01f, 1.85864475e-02f, 2.26288542e-01f, 4.06451970e-02f, 1.51224688e-01f, 2.43550658e-01f, -3.53125073e-02f, 1.90380991e-01f, -9.94034037e-02f,
  6.86532184e-02f, 1.40783563e-02f, -6.55905157e-02f, 1.72059521e-01f, 2.58418202e-01f, 6.79004239e-03f, 1.41872138e-01f, 7.92893246e-02f, 1.22326799e-02f, -4.77724858e-02f,
  6.52783886e-02f, 1.12316452e-01f, 1.32039249e-01f, -8.03779438e-02f, -1.93096846e-02f, -1.84964836e-01f, -1.56431690e-01f, -1.07909292e-01f, -1.00642197e-01f, 6.90337643e-02f,
  1.69135571e-01f, 4.68717776e-02f, 1.21360412e-02f, -3.41021381e-02f, -4.87433299e-02f, -6.38611168e-02f, 2.56181918e-02f, 6.58555776e-02f, 4.71714810e-02f, -2.89554684e-03f,
  -3.16949002e-02f, 4.66521084e-02f, 4.20314372e-02f, 4.04069684e-02f, 1.69787686e-02f, 3.05764787e-02f, -1.73589177e-02f, -1.59210103e-04f, 3.63468751e-02f, 5.53094074e-02f,
  5.21001546e-03f, -1.87720284e-02f, -4.20214236e-03f, -6.24140054e-02f, 8.31416156e-03f, 8.60510990e-02f, -4.00948450e-02f, -1.51338940e-02f, 1.63270021e-03f, -2.75082700e-02f,
  -9.93917286e-02f, -6.47825971e-02f, -1.46670295e-02f, 2.58031990e-02f, 2.29707696e-02f, 1.70937795e-02f, -9.66296182e-04f, -1.85934603e-02f, 2.25406364e-02f, -5.39726717e-03f,
  5.43000735e-02f, 2.91723646e-02f, 3.40453610e-02f, -1.47462776e-03f, 4.70789848e-03f, 4.16584499e-03f, 1.29090790e-02f, -1.40670557e-02f, -6.59740865e-02f, 4.77790162e-02f,
  -1.51726995e-02f, 4.24966356e-03f, 2.07140744e-02f, -4.63915356e-02f, -1.49202496e-02f, 1.02128321e-02f, -1.92515198e-02f, 2.26095086e-03f, -4.40047383e-02f, -1.90224836e-03f,
  -1.48181513e-01f, -2.42998481e-01f, -5.37314415e-02f, 5.27275279e-02f, -2.19053589e-02f, -2.18908209e-02f, 3.74054164e-02f, -1.88781600e-02f, -2.91781500e-02f, -1.74474064e-02f,
  -7.73348147e-03f, 8.38027056e-03f, -1.10337891e-01f, -1.81116731e-04f, 5.79162426e-02f, -2.59615500e-02f, -1.74194593e-02f, -8.21585115e-03f, -3.07171289e-02f, -2.72269361e-02f,
  -9.46217254e-02f, 4.84385677e-02f, 3.24817486e-02f, 1.91365443e-02f, -1.48182362e-02f, -7.56892338e-02f, 3.31665911e-02f, 2.24817041e-02f, -4.70231250e-02f, -4.35116664e-02f,
  5.62303483e-01f, -1.38896048e-01f, 2.07126975e-01f, 4.22367714e-02f, 1.82617038e-01f, -4.48817946e-02f, -5.00590056e-02f, 2.43920907e-01f, 4.94324937e-02f, -8.09891671e-02f,
  7.30017275e-02f, 8.77045766e-02f, 6.40401840e-02f, -6.38207346e-02f, 6.97857514e-02f, -1.96341291e-01f, 8.15272406e-02f, 6.21550679e-02f, -4.79255281e-02f, 9.52967703e-02f,
  6.15624972e-02f, -1.24732189e-01f, 3.10470965e-02f, 5.23500852e-02f, 1.14715807e-01f, 4.29344214e-02f, -7.99189284e-02f, -6.65004402e-02f, -4.16243859e-02f, -3.94096859e-02f,
  1.59826159e-01f, 2.16773212e-01f, 1.24780335e-01f, 3.21809538e-02f, 5.50842285e-02f, 1.01151571e-01f, 3.23045477e-02f, -8.46876055e-02f, -1.30037600e-02f, 3.64321433e-02f,
  -5.01274802e-02f, -2.88465377e-02f, -7.24307215e-03f, -2.31856667e-02f, -8.28441605e-02f, 1.83503833e-02f, -2.94504855e-02f, 3.92042063e-02f, -2.54758005e-03f, 5.00841141e-02f,
  -4.79819588e-02f, 8.99441466e-02f, 1.50179015e-02f, 2.94636916e-02f, -1.03478469e-02f, -7.79844224e-02f, 2.46495754e-02f, 4.50537838e-02f, 7.32114986e-02f, 4.20465991e-02f,
  7.25494772e-02f, -4.48768511e-02f, -5.70043316e-03f, 4.42011505e-02f, 6.63965661e-03f, 4.20416370e-02f, -1.80616323e-02f, -3.15592922e-02f, 1.52981828e-03f, -3.15723494e-02f,
  2.61325724e-02f, -9.96927824e-03f, 3.80833610e-03f, -3.77154090e-02f, -3.26007395e-03f, 1.25688482e-02f, -8.82985405e-05f, 1.40626132e-02f, 1.92917697e-02f, -5.50595336e-02f,
  -1.11176986e-02f, -4.06884328e-02f, -2.70598345e-02f, 2.48101447e-02f, 4.71162647e-02f, -2.53056157e-02f, -3.26532908e-02f, -2.51877569e-02f, -3.92866973e-03f, 3.72820571e-02f,
  -9.29745510e-02f, 1.13495275e-01f, -2.74290666e-02f, 6.14221394e-02f, -3.32493745e-02f, -5.59254847e-02f, -4.30232249e-02f, 5.81038855e-02f, -4.56398986e-02f, 1.78022161e-02f,
  -5.36989188e-03f, 2.45555509e-02f, 2.51527429e-02f, -6.18681125e-02f, 9.21901874e-03f, -2.74610966e-02f, -1.15022240e-02f, -5.62300310e-02f, 6.14471771e-02f, 2.10217130e-03f,
  6.92434609e-02f, -1.52041595e-02f, 3.68639231e-02f, 4.86438274e-02f, 6.64833114e-02f, 1.47461623e-03f, 2.36848984e-02f, -7.62628531e-03f, 5.73594347e-02f, -1.40121337e-02f,
  -2.29255095e-01f, -1.08365580e-01f, 3.54945883e-02f, 3.25421393e-02f, -1.10995285e-01f, 4.36417237e-02f, 4.51726802e-02f, -7.34560341e-02f, 6.90330639e-02f, -2.14958228e-02f,
  9.70058143e-02f, -9.77062955e-02f, 1.61817834e-01f, 7.89862648e-02f, 9.39931944e-02f, 1.85557589e-01f, -3.00031360e-02f, 1.56314559e-02f, -4.88750227e-02f, -1.45767286e-01f,
  9.31603927e-03f, -4.44947071e-02f, 1.89822048e-01f, 4.93404046e-02f, -1.20051242e-01f, 2.02006251e-02f, -1.75763257e-02f, 1.26290619e-01f, -3.35073844e-03f, 6.75024688e-02f,
  -7.19188228e-02f, -5.11870049e-02f, -5.34935668e-02f, -2.28002444e-02f, 2.26750746e-02f, 2.40083635e-02f, -3.85321192e-02f, 5.97291365e-02f, 3.10023222e-03f, -5.46252960e-03f,
  -4.23305202e-03f, -5.99107221e-02f, 5.71602657e-02f, 1.78064536e-02f, -2.20032465e-02f, 3.42657678e-02f, -2.80666966e-02f, 2.80960184e-02f, -5.89938574e-02f, 1.80034656e-02f,
  1.31149944e-02f, 4.81325164e-02f, 8.56082141e-02f, 3.79528143e-02f, 4.55495417e-02f, -3.74594796e-03f, 6.26784116e-02f, -5.77121526e-02f, 7.64304623e-02f, -6.73628971e-02f,
  1.07273377e-01f, -8.00142288e-02f, -2.07339253e-04f, -1.27873458e-02f, -3.16535905e-02f, -1.06838383e-02f, -2.73701921e-02f, 1.61807910e-02f, 8.93163774e-03f, -7.28240833e-02f,
  1.41278785e-02f, 4.97024395e-02f, -3.10488101e-02f, 9.26926136e-02f, -1.73411239e-02f, -6.36488870e-02f, -2.00399570e-02f, 2.11323407e-02f, -8.68583769e-02f, 1.58562697e-02f,
  1.92028768e-02f, 7.16218650e-02f, -6.64863130e-03f, -4.85616997e-02f, 2.95098536e-02f, 4.71778475e-02f, 4.86809649e-02f, 1.28018456e-02f, 2.54700482e-02f, 1.29623339e-03f,
  -6.72259033e-02f, 9.43355449e-03f, 5.85303567e-02f, -2.30015405e-02f, 2.70352419e-02f, -2.94328239e-02f, 4.58147787e-02f, 2.59335581e-02f, 9.74234045e-02f, -6.23089680e-03f,
  -2.96381060e-02f, 2.09518522e-02f, -2.96010021e-02f, 7.12981215e-04f, 6.96762651e-02f, 7.82121345e-02f, -2.43752766e-02f, 3.64575721e-02f, 3.18215229e-02f, -9.05793309e-02f,
  1.44271990e-02f, 1.87361389e-02f, 2.35238932e-02f, -1.24567654e-02f, -1.87403206e-02f, -1.02466494e-02f, -6.27140254e-02f, 5.72807416e-02f, 2.54179109e-02f, 3.98193225e-02f,
  -8.09799731e-02f, 1.46715818e-02f, 2.10732266e-01f, -1.51021808e-01f, 4.42330204e-02f, 3.60179335e-01f, 2.73836493e-01f, 2.42278725e-02f, -1.03653088e-01f, -5.87087274e-02f,
  1.12629086e-01f, -4.70291823e-02f, 2.42680162e-02f, 5.16567975e-02f, 1.64973989e-01f, -7.14488747e-03f, 1.76486641e-01f, 3.74766886e-02f, -9.85623896e-02f, -1.09898392e-02f,
  1.20918127e-03f, 7.77965132e-03f, 1.06485173e-01f, -4.16923873e-02f, 1.17849536e-01f, -7.14146271e-02f, -9.72573310e-02f, 1.81449379e-03f, 7.50248879e-02f, 4.54954468e-02f,
  1.58177450e-01f, -8.81256685e-02f, 2.00862885e-02f, 2.54876744e-02f, 4.28140759e-02f, 2.43776869e-02f, -1.23206628e-02f, 6.77308515e-02f, -1.23847192e-02f, 4.67954800e-02f,
  -5.79086877e-03f, -4.11628745e-02f, -2.28643436e-02f, -2.54341476e-02f, 3.23948525e-02f, -4.61156964e-02f, -4.76410761e-02f, 6.39437735e-02f, -8.98674037e-03f, 3.25426608e-02f,
  5.50580919e-02f, 3.43332700e-02f, -1.94455162e-02f, 3.15380208e-02f, 7.15704728e-03f, 6.14273176e-02f, 5.01819625e-02f, 2.63520200e-02f, -3.00504155e-02f, -2.75715459e-02f,
  -4.76402827e-02f, -3.94907258e-02f, 6.14608172e-03f, -6.07247353e-02f, 4.93375733e-02f, -1.39253559e-02f, 6.03391267e-02f, -8.08936823e-03f, -3.68392207e-02f, 1.03306407e-02f,
  -1.26298666e-02f, -2.60113124e-02f, 3.48922759e-02f, 3.84543911e-02f, -7.45771546e-03f, 1.28003350e-02f, 2.69574597e-02f, -6.04420863e-02f, -1.51206776e-02f, 3.25198770e-02f,
  -8.19076411e-03f, -2.51450017e-02f, -1.42453630e-02f, -5.37332594e-02f, -1.43263889e-02f, 1.00924075e-02f, -5.65788820e-02f, -7.57512590e-03f, -3.85274291e-02f, 4.25854325e-02f,
  1.46377115e-02f, -1.15050390e-01f, 4.40108925e-02f, -5.97194582e-02f, -8.75531987e-04f, -1.57504790e-02f, 6.19966984e-02f, 1.17907925e-02f, -9.21820849e-03f, -3.64442468e-02f,
  -5.33801094e-02f, 2.75057778e-02f, 5.26303202e-02f, -5.60682127e-03f, 3.74273472e-02f, 2.99307816e-02f, -4.10514958e-02f, -1.17044267e-03f, 1.12247644e-02f, 1.92953590e-02f,
  -4.21383493e-02f, 1.52672315e-02f, 7.52853579e-04f, -6.21119179e-02f, -1.47662647e-02f, -3.32755372e-02f, -2.53573488e-02f, -2.49411329e-03f, 5.16453497e-02f, 1.00745048e-04f,
  9.63039175e-02f, 3.25343877e-01f, 2.04865098e-01f, 2.60299146e-01f, -1.84095889e-01f, -3.44249718e-02f, 2.87731171e-01f, 3.24814059e-02f, 2.66812801e-01f, 1.09864045e-02f,
  -1.38741598e-01f, 1.33348510e-01f, 4.87886332e-02f, 1.12645395e-01f, -2.02433050e-01f, 1.24434166e-01f, 5.85594773e-02f, 2.80759353e-02f, 8.93393084e-02f, 8.38102251e-02f,
  7.30184764e-02f, -4.31415103e-02f, 7.58877695e-02f, -1.52855843e-01f, -3.36307511e-02f, 8.34163949e-02f, -1.01691023e-01f, -2.65809596e-02f, -3.95266712e-02f, -1.26834422e-01f,
  1.39651328e-01f, 1.36223063e-01f, 6.78353831e-02f, 5.42973913e-02f, -3.13854367e-02f, -3.58579843e-03f, -3.08201592e-02f, -4.66818511e-02f, -9.69879515e-03f, 6.27759546e-02f,
  -3.81541178e-02f, -4.57451120e-03f, -7.30702141e-03f, -3.33070830e-02f, 9.33389645e-03f, -7.84136076e-03f, -5.44089498e-03f, 1.57598238e-02f, 1.09538026e-01f, -3.88687029e-02f,
  7.22843483e-02f, -3.61496024e-03f, 9.12145525e-03f, -4.23768274e-02f, 4.27684039e-02f, 5.71588278e-02f, 1.04699675e-02f, -1.44183189e-02f, -1.16998479e-02f, 8.23492743e-03f,
  -3.86425704e-02f, 3.86810452e-02f, 2.20151041e-02f, -2.93237921e-02f, 4.25041020e-02f, -7.91738406e-02f, 2.04946361e-02f, -3.16879526e-02f, 2.43451353e-02f, -1.58291534e-02f,
  -4.47195163e-03f, 7.00972416e-03f, -1.18719982e-02f, 2.01966837e-02f, 2.72013750e-02f, 8.31958279e-02f, -1.97778456e-02f, 6.57611853e-03f, 3.96749936e-02f, -1.25174383e-02f,
  1.71378795e-02f, -9.37728037e-04f, -1.39289964e-02f, 1.19838724e-03f, -1.40723726e-02f, 4.73510958e-02f, 4.96626645e-02f, 2.05034427e-02f, 4.40361686e-02f, -2.29456015e-02f,
  -1.84801564e-01f, -8.78991038e-02f, -2.17305403e-02f, -3.81082594e-02f, -1.12431860e-02f, -2.51680557e-02f, -3.56911570e-02f, -1.26323579e-02f, 1.19646005e-02f, -5.19452319e-02f,
  3.84073257e-02f, 8.58358946e-03f, -4.56135310e-02f, -1.46887572e-02f, 4.35848394e-03f, -2.15618294e-02f, 6.60755485e-02f, -2.64361557e-02f, -5.13747633e-02f, -1.68679059e-02f,
  -8.43439251e-02f, -1.50691057e-02f, -1.34012559e-02f, -1.86662562e-02f, 4.92720259e-03f, -6.75406009e-02f, -2.37756521e-02f, 4.20072628e-03f, -5.16497679e-02f, 3.15990597e-02f,
  -1.61555976e-01f, 2.75262833e-01f, 1.19050868e-01f, -7.23276287e-02f, -2.36786976e-01f, 4.10420522e-02f, 1.22031726e-01f, 1.07642096e-02f, 1.91476405e-01f, 1.06892757e-01f,
  -1.19744904e-01f, 2.16444403e-01f, 1.56841397e-01f, 6.66971691e-03f, 3.05621959e-02f, 2.30637431e-01f, -1.31989673e-01f, -2.07212735e-02f, 1.28665984e-01f, -6.93987682e-02f,
  -4.98110056e-02f, -5.52752577e-02f, 2.71237213e-02f, -5.13847619e-02f, 2.48853676e-02f, -4.22283337e-02f, -2.03315020e-01f, 4.45906743e-02f, -2.13769853e-01f, -9.60644893e-03f,
  5.49460128e-02f, 4.87641804e-02f, 1.79816317e-02f, 2.86713429e-02f, -1.30003123e-02f, -1.26161844e-01f, 3.20371613e-02f, 2.41102315e-02f, -2.48219427e-02f, -5.68462629e-03f,
  6.85867444e-02f, -2.67233625e-02f, 5.63989170e-02f, -1.45420097e-02f, -3.27321626e-02f, -3.90769094e-02f, 7.73605099e-03f, -3.19513157e-02f, -3.90836075e-02f, 9.81548242e-03f,
  -9.16589610e-03f, -3.47058363e-02f, -8.35452154e-02f, 2.19557229e-02f, 1.08797783e-02f, 1.51347788e-02f, 5.02079800e-02f, 1.16781211e-02f, 5.48659489e-02f, 2.09930763e-02f,
  -3.38703021e-02f, 3.33100110e-02f, 1.21096959e-02f, 6.18254812e-03f, -1.89919043e-02f, -4.87077050e-03f, -4.38305140e-02f, 1.26375891e-02f, 9.22813825e-03f, -1.39931375e-02f,
  -6.53217137e-02f, -5.32541163e-02f, -9.00288019e-03f, -7.00540990e-02f, -1.15878666e-02f, -3.32340412e-02f, 1.98712386e-02f, 2.93189916e-03f, 5.22058504e-03f, -6.53901836e-03f,
  3.87247205e-02f, 1.63417347e-02f, -1.14210462e-02f, -4.42169569e-02f, 5.85357100e-03f, -2.17901655e-02f, -7.39219934e-02f, 4.36092839e-02f, 2.39178296e-02f, -3.49467248e-02f,
  1.74715964e-03f, 5.79012856e-02f, 2.36935094e-02f, -1.40975816e-02f, 1.87479313e-02f, -3.57256420e-02f, 3.31930742e-02f, 2.99585722e-02f, 3.37259173e-02f, -5.05164871e-03f,
  -9.76852626e-02f, -7.35837733e-03f, -1.61337890e-02f, -5.76043949e-02f, -9.12506366e-04f, -4.01971750e-02f, -2.16677878e-02f, 2.32226821e-03f, 9.06834006e-03f, 4.31232573e-03f,
  -1.79047137e-02f, 5.71485125e-02f, 8.52645840e-03f, -1.27008101e-02f, -3.99580635e-02f, -3.84564437e-02f, -3.99257764e-02f, -9.02238302e-03f, -2.34372187e-02f, 9.70206875e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.10340023e-01f, -2.53546000e-01f, 1.70684978e-02f, -1.76830783e-01f, -4.67712380e-04f, -2.21668780e-01f, -2.02460643e-02f, -3.28616321e-01f, -2.12100908e-01f, -3.00152957e-01f,
  -5.13069741e-02f, 1.58905596e-01f, 1.75796539e-01f, -3.21903586e-01f, 2.95926601e-01f, 2.06310943e-01f, -3.35089773e-01f, 5.02594328e-03f, -1.44827336e-01f, -2.78462738e-01f,
  -3.85900140e-02f, -2.54491657e-01f, 1.30138278e-01f, -2.33031601e-01f, -1.74168929e-01f, -6.10719360e-02f, 2.10144669e-01f, 6.24194741e-02f, -2.17069089e-01f, 7.85374343e-02f,
  1.45736905e-02f, -2.35855542e-02f, -6.68254122e-02f, 9.42390189e-02f, -4.10533622e-02f, 7.47601390e-02f, 9.19897482e-02f, 1.91986844e-01f, 2.83741131e-02f, -1.03170993e-02f,
  8.95713177e-03f, 4.31000143e-02f, -9.67200398e-02f, 1.93495806e-02f, -1.10202976e-01f, -3.50417867e-02f, -1.09936278e-02f, -8.31321999e-02f, -7.35372603e-02f, 5.54060116e-02f,
  -1.89861916e-02f, -2.89330259e-02f, -6.38444498e-02f, -5.45616336e-02f, -4.59050834e-02f, 8.08357960e-04f, 5.69890998e-03f, 8.08244348e-02f, -5.10291904e-02f, -5.68990670e-02f,
  4.93548885e-02f, 8.60673413e-02f, 2.04875488e-02f, -3.75784524e-02f, 2.70488821e-02f, -3.17502245e-02f, -1.40648196e-02f, 4.05446403e-02f, 3.79878990e-02f, -3.82114500e-02f,
  -2.93238964e-02f, 3.53357755e-02f, -3.42410803e-02f, -8.26664269e-03f, 1.72285195e-02f, 4.46100719e-02f, 8.47633481e-02f, -6.90878034e-02f, -1.07642293e-01f, -2.19439417e-02f,
  -8.68326053e-03f, 1.95657872e-02f, -4.14330438e-02f, 1.18721426e-01f, 4.07317467e-03f, 4.72222306e-02f, -2.02889107e-02f, -1.39963217e-02f, 7.19229057e-02f, 9.41415802e-02f,
  -1.21272430e-01f, -2.89941840e-02f, -5.19878976e-02f, -6.72186986e-02f, 1.83529109e-02f, -5.83077520e-02f, -5.90076717e-03f, -7.49411583e-02f, 9.37846955e-03f, -3.32404599e-02f,
  -2.15826239e-02f, 7.13875666e-02f, -1.72613002e-02f, -5.11492044e-02f, -6.46440163e-02f, -1.02083176e-01f, 8.56529176e-03f, -1.75214503e-02f, -2.77536772e-02f, -6.79638684e-02f,
  -3.60213742e-02f, 2.26430148e-02f, 1.20321913e-02f, 2.46713627e-02f, 5.42218573e-02f, 1.43162142e-02f, -2.95522413e-03f, -3.30278203e-02f, -3.49858813e-02f, 2.92700753e-02f,
  1.55328870e-01f, -4.61405486e-01f, 4.91895014e-03f, 1.89771220e-01f, 1.71620131e-01f, -5.27661256e-02f, 1.21786445e-01f, -1.21729776e-01f, -1.71485558e-01f, -2.79565364e-01f,
  -5.27545810e-02f, -8.72204378e-02f, -1.53118849e-01f, -3.25913541e-02f, 6.67041987e-02f, -2.31259972e-01f, -2.44773310e-02f, -4.37793545e-02f, -5.89839667e-02f, 4.02514003e-02f,
  1.29220799e-01f, 1.06830098e-01f, 8.79639387e-02f, 6.12700470e-02f, 8.04524943e-02f, 1.60860136e-01f, 1.94604889e-01f, 8.20514783e-02f, 1.11836679e-01f, 4.13518399e-02f,
  -1.41813740e-01f, -7.13644102e-02f, 1.08677737e-01f, -1.02369348e-03f, 4.33620475e-02f, -8.67640004e-02f, 2.28956640e-02f, 5.00110537e-02f, 7.60655254e-02f, -1.90120656e-02f,
  -3.59743983e-02f, -3.62078361e-02f, 5.54703884e-02f, -4.44168691e-03f, 1.58176180e-02f, 1.25241475e-02f, 5.86339571e-02f, -5.06129973e-02f, -1.09576307e-01f, -5.75670563e-02f,
  -4.89245169e-02f, -5.63735366e-02f, -4.89374846e-02f, 4.29736339e-02f, 7.95913860e-02f, 5.14040850e-02f, 6.08550198e-03f, 1.02747366e-01f, -1.11749992e-02f, 1.01229623e-01f,
  6.68759793e-02f, 6.27409741e-02f, -4.41048965e-02f, -1.97378616e-03f, -6.07620105e-02f, 1.16446353e-02f, -5.98702207e-02f, -2.01944672e-02f, 4.89701144e-02f, -1.14867680e-01f,
  -3.03628333e-02f, -2.65426077e-02f, -3.57135795e-02f, -1.26121759e-01f, 6.58049583e-02f, -6.43446967e-02f, 4.27466109e-02f, 2.09985897e-02f, 1.00671135e-01f, 2.92279162e-02f,
  -8.98943469e-03f, 2.69794948e-02f, -1.19934365e-01f, -1.26822824e-02f, -2.17335504e-02f, 7.09135691e-03f, -8.74284506e-02f, 1.60271190e-02f, 4.82639484e-02f, 4.52015586e-02f,
  -7.02062100e-02f, -1.03566669e-01f, -5.36444299e-02f, -4.90869284e-02f, -4.02797237e-02f, -6.76687062e-02f, -4.00847644e-02f, 5.61643019e-02f, -1.38965517e-01f, 3.65842022e-02f,
  -6.02434836e-02f, 1.99086480e-02f, -2.94822324e-02f, -1.92734995e-04f, -2.32606120e-02f, -3.94545794e-02f, -1.05624206e-01f, 5.17944284e-02f, -5.32890968e-02f, -1.11584412e-02f,
  1.69924311e-02f, -5.63152786e-03f, -5.05649410e-02f, 2.35252213e-02f, -5.85883893e-02f, 5.33576682e-02f, 4.49389964e-02f, -3.54347788e-02f, -4.41334806e-02f, -6.60876483e-02f,
  1.12535477e-01f, 3.90492976e-02f, -2.06162572e-01f, -1.84835568e-02f, -1.77206203e-01f, 1.09710567e-01f, 7.13226348e-02f, -3.62072960e-02f, -5.24453335e-02f, 3.50269049e-01f,
  2.02804714e-01f, -6.67377338e-02f, 1.62821978e-01f, 2.92313367e-01f, -3.62667459e-04f, 2.16457278e-01f, 1.34419829e-01f, 2.12065786e-01f, 9.63548431e-04f, 6.41139671e-02f,
  -2.40817778e-02f, 1.71243638e-01f, 6.83052689e-02f, 8.25725645e-02f, 1.49303198e-01f, -1.24766849e-01f, -3.58561575e-02f, -1.44769102e-01f, 1.20296823e-02f, 6.85441419e-02f,
  9.84111354e-02f, 9.70766693e-02f, -6.07306510e-02f, 1.47657292e-02f, 5.48362639e-03f, 2.71639321e-02f, 3.06814630e-02f, -5.93983792e-02f, -4.54084985e-02f, 5.12628891e-02f,
  -5.15487269e-02f, 2.97803571e-03f, 1.77233722e-02f, 1.42299449e-02f, -1.19126581e-01f, 7.16558192e-03f, -1.03591487e-01f, 1.05430251e-02f, -6.00892715e-02f, -5.97141571e-02f,
  -5.20907976e-02f, 5.65466247e-02f, -7.24424943e-02f, -1.98149923e-02f, -5.96912093e-02f, -8.90754163e-02f, -5.02412766e-02f, 3.74207012e-02f, 3.82402577e-02f, -4.99515329e-03f,
  5.23220785e-02f, -4.10002619e-02f, 5.67415170e-02f, 4.16379608e-02f, -2.06600502e-02f, 8.78177583e-03f, 1.64244091e-03f, -6.45766258e-02f, -1.65191200e-02f, -5.56465723e-02f,
  4.36134376e-02f, -1.62363313e-02f, 1.77370310e-02f, -2.94291563e-02f, 6.06282130e-02f, 1.33030610e-02f, -4.85970266e-02f, -8.75562057e-03f, -6.47331625e-02f, -5.72918691e-02f,
  1.90720502e-02f, -4.55350522e-03f, 3.23636644e-02f, -2.96523049e-02f, -4.69621755e-02f, -1.54764326e-02f, 2.11634450e-02f, 1.71171352e-02f, 9.02790762e-03f, -2.20176056e-02f,
  8.64561945e-02f, 9.23048183e-02f, -7.87156168e-03f, 4.38745432e-02f, -2.73742550e-03f, 9.77946669e-02f, 4.59557213e-02f, 8.36424977e-02f, -8.70186603e-04f, 1.13307208e-01f,
  -1.54481335e-02f, 2.07323786e-02f, 2.99917627e-02f, -1.04969606e-01f, -1.98598988e-02f, 6.47068620e-02f, -8.17135733e-04f, 3.76002192e-02f, 1.71637107e-02f, 4.58065681e-02f,
  -8.20167065e-02f, -2.17245258e-02f, -6.81617036e-02f, 4.17539552e-02f, -5.69496974e-02f, 6.54369667e-02f, -6.22579679e-02f, 7.39791170e-02f, 3.98098957e-04f, 3.11963055e-02f,
  4.83452044e-02f, 1.46391953e-03f, -2.17539109e-02f, -6.40228093e-02f, -2.02086195e-01f, 1.27272338e-01f, 7.45089427e-02f, -2.45705247e-01f, -2.61403233e-01f, 4.02018690e-04f,
  -7.40394834e-03f, -1.37097936e-03f, 2.87804782e-01f, 3.62891592e-02f, 1.99648157e-01f, 1.34465635e-01f, 2.63204961e-03f, -3.75799574e-02f, 2.29176600e-02f, -1.90081783e-02f,
  2.67330073e-02f, 1.58311650e-02f, 1.65156633e-01f, -1.47366226e-01f, 1.42897544e-02f, -5.67390174e-02f, 7.59525895e-02f, -1.24242725e-02f, -1.03359625e-01f, 1.39565608e-02f,
  -2.33164839e-02f, -8.87606144e-02f, -4.06822376e-02f, 4.19290811e-02f, 1.59640070e-02f, 6.66671316e-04f, 4.36045378e-02f, 2.02042405e-02f, -5.48159296e-04f, -2.27926280e-02f,
  3.66350822e-02f, -1.92890968e-02f, -6.37693927e-02f, 1.13714915e-02f, 3.71706635e-02f, -4.66376804e-02f, -3.56988274e-02f, -9.08307917e-03f, -1.02989696e-01f, 5.18275760e-02f,
  -4.56352979e-02f, 6.91813901e-02f, -4.41052951e-03f, -7.83108249e-02f, -4.44365218e-02f, -8.92200246e-02f, -4.87997457e-02f, 2.07458455e-02f, -7.67420679e-02f, 3.00048981e-02f,
  4.06152420e-02f, 2.35274173e-02f, 3.65753360e-02f, 4.44440953e-02f, 3.28930281e-02f, 3.83147597e-02f, 1.72873475e-02f, 6.81995377e-02f, 2.60004755e-02f, 3.43025774e-02f,
  -1.13491504e-03f, -6.33764863e-02f, -2.83526555e-02f, 5.05752601e-02f, 2.97793075e-02f, 1.33512756e-02f, 1.39389848e-02f, 3.79316993e-02f, 6.66816607e-02f, 9.33053643e-02f,
  7.52835022e-03f, -2.82722525e-02f, 1.94741730e-02f, -3.34349251e-03f, -1.10250842e-02f, 2.80212332e-02f, -2.88974214e-02f, -1.07614566e-02f, -4.86692153e-02f, 5.94872721e-02f,
  -7.69308656e-02f, -1.47562206e-01f, 4.91348803e-02f, 1.72369573e-02f, -4.10460457e-02f, -4.47140448e-02f, 4.96815778e-02f, -1.16851382e-01f, -8.78218282e-03f, -5.52206114e-02f,
  7.92754441e-02f, -1.18701477e-02f, -4.68504652e-02f, -1.80756655e-02f, 9.77110937e-02f, -8.51662084e-02f, 2.58478019e-02f, 7.58118927e-02f, -1.50208073e-02f, 8.23971182e-02f,
  4.06358577e-03f, -4.99715842e-02f, 8.61938149e-02f, -4.35330719e-02f, 4.89657139e-03f, 1.18103772e-02f, -9.69998364e-04f, -3.94446291e-02f, 4.88931015e-02f, -2.67419405e-02f,
  1.64451241e-01f, 1.81183983e-02f, -7.39262775e-02f, 2.17405513e-01f, -8.48090425e-02f, -3.72108340e-01f, -2.65450180e-01f, 1.70043573e-01f, -2.22613260e-01f, -5.32924831e-02f,
  1.82928786e-01f, 1.29242027e-02f, -3.14914659e-02f, 2.98254520e-01f, 3.59102517e-01f, 1.99786276e-02f, 1.99883401e-01f, -3.66075113e-02f, -2.43799444e-02f, 1.58657640e-01f,
  2.87323028e-01f, 2.74926454e-01f, 3.27347577e-01f, 2.81785637e-01f, 8.07872117e-02f, 2.01214373e-01f, 3.88728529e-01f, -7.55539979e-04f, 2.27003902e-01f, 8.90721232e-02f,
  -1.51093081e-01f, -5.37465699e-02f, 2.87632123e-02f, -3.00182234e-02f, 8.30584690e-02f, -7.33616725e-02f, -8.17027017e-02f, -9.15480331e-02f, 9.15136486e-02f, 2.54549049e-02f,
  -9.37374160e-02f, 6.94655702e-02f, 2.88685109e-03f, 4.85575162e-02f, 7.65041113e-02f, 1.89141929e-02f, -1.67750977e-02f, -1.72921699e-02f, -5.12665212e-02f, -2.33527832e-02f,
  8.32616724e-03f, -6.24654852e-02f, -5.73918484e-02f, -8.54561031e-02f, 2.50640828e-02f, -4.40693982e-02f, -5.35761155e-02f, -1.92364398e-03f, -8.19596872e-02f, 4.89164926e-02f,
  9.08851773e-02f, -5.66165298e-02f, 4.00932580e-02f, -1.50526091e-02f, 6.76430389e-03f, -2.63943356e-02f, -5.10091111e-02f, 4.52824645e-02f, 6.28379779e-03f, 5.24131320e-02f,
  3.09712486e-03f, 3.48138697e-02f, 6.27087578e-02f, -9.31993872e-02f, 5.56641817e-02f, -4.72821854e-02f, -4.04090732e-02f, 6.98026344e-02f, -1.66226961e-02f, -4.38056551e-02f,
  -7.74169490e-02f, 8.47341195e-02f, 2.06794813e-02f, -2.11671498e-02f, 4.04375643e-02f, 6.20552637e-02f, 8.88749063e-02f, 3.76202986e-02f, -5.97821921e-02f, -3.26498784e-02f,
  8.83485153e-02f, 3.03200424e-01f, -4.11106199e-02f, -6.36051297e-02f, -7.43041039e-02f, 6.16234951e-02f, 4.65172343e-02f, 7.98145607e-02f, 1.61082912e-02f, -2.82438821e-03f,
  2.97131645e-03f, -2.74071936e-02f, -4.16581966e-02f, -1.22651672e-02f, 3.43629085e-02f, -1.78935621e-02f, 1.90110561e-02f, -6.79258769e-03f, 1.08257651e-01f, 1.72598049e-01f,
  -1.40990894e-02f, 3.61132249e-02f, 6.59181084e-03f, -9.99526605e-02f, -1.00217899e-02f, -6.63526803e-02f, -1.75891258e-02f, -5.97361624e-02f, 4.06517088e-02f, 1.48655130e-02f,
  -4.98839170e-02f, 1.64287370e-02f, -2.32106060e-01f, -1.98444247e-01f, 9.96238925e-03f, -1.61387503e-01f, -2.36385286e-01f, -1.21236272e-01f, 5.47776930e-02f, -5.65087050e-02f,
  -8.22524205e-02f, 5.90992905e-02f, -8.13574716e-03f, -2.60125250e-01f, 4.79217321e-02f, 3.33255418e-02f, -2.03299746e-01f, -5.94300143e-02f, 6.35296181e-02f, -6.86017796e-02f,
  -1.16119310e-02f, -8.47163573e-02f, -1.19212933e-01f, 5.38841672e-02f, -1.60246834e-01f, -7.47883469e-02f, 1.82171643e-01f, -9.84148029e-03f, -4.47150245e-02f, 7.87767693e-02f,
  -5.97520173e-02f, -7.87409469e-02f, -4.36188988e-02f, -4.69250977e-02f, -1.12659469e-01f, 3.83952807e-04f, 1.05912955e-02f, 5.03940415e-03f, -5.87852597e-02f, -1.55245988e-02f,
  -3.61170508e-02f, 4.49186824e-02f, 1.42431865e-02f, 3.17232348e-02f, -4.76389118e-02f, -6.26927018e-02f, -3.51487324e-02f, 4.68161665e-02f, -3.98876742e-02f, -1.00073069e-01f,
  4.83792163e-02f, -8.58499948e-03f, -7.81132355e-02f, 3.49344574e-02f, 4.74817418e-02f, -4.27812934e-02f, 3.39909047e-02f, -9.83515084e-02f, 4.10265401e-02f, -2.78116167e-02f,
  9.65254903e-02f, -3.36114317e-02f, -1.13957664e-02f, 1.00239433e-01f, -5.46557605e-02f, -8.07494521e-02f, 5.75016486e-03f, -2.52235699e-02f, 7.04738498e-02f, -7.99560100e-02f,
  4.29343358e-02f, 2.77691726e-02f, 5.72530665e-02f, -6.05594441e-02f, 5.22649325e-02f, -7.03301979e-03f, -2.61710547e-02f, 4.64326218e-02f, -1.66973732e-02f, -2.23306194e-02f,
  6.35353029e-02f, 8.97228345e-03f, -5.30341454e-02f, -1.05292141e-01f, -7.18857870e-02f, 2.98752077e-02f, -9.92829329e-04f, -9.16107222e-02f, -3.06959096e-02f, -7.92261511e-02f,
  7.47341737e-02f, 4.31286953e-02f, -9.67068225e-02f, 3.57413606e-04f, -6.17064089e-02f, -8.71370733e-02f, -9.24297236e-03f, -1.40578160e-02f, -9.72398892e-02f, -4.14735544e-03f,
  3.09473723e-02f, 7.96039402e-02f, -2.11285036e-02f, 6.44258689e-03f, 4.25211042e-02f, 4.93038855e-02f, -1.06241545e-02f, 4.85568494e-02f, 8.98778904e-03f, 5.52816279e-02f,
  1.49160884e-02f, 3.47330160e-02f, -3.72171439e-02f, 6.88412040e-02f, 4.21552882e-02f, 1.44405905e-02f, 7.78393224e-02f, 9.19158291e-03f, 8.29224754e-03f, -5.68422750e-02f,
  -4.81280535e-01f, -1.62210595e-02f, 1.81688234e-01f, -3.50174576e-01f, -1.24139890e-01f, 8.69476702e-04f, -1.15830101e-01f, 7.96486512e-02f, -1.50146604e-01f, 1.78944655e-02f,
  -1.23761922e-01f, 4.31723967e-02f, 2.06269160e-01f, 4.43670861e-02f, -2.87109278e-02f, 1.68981969e-01f, -1.71107307e-01f, -4.64684404e-02f, -3.62315103e-02f, -6.85528666e-02f,
  -4.74515967e-02f, -2.81139407e-02f, 1.03230193e-01f, 1.64770335e-01f, -4.43945304e-02f, -9.65862721e-02f, -1.09649785e-01f, 1.11162718e-02f, -1.45777296e-02f, -2.96076778e-02f,
  -2.41443425e-01f, -1.94698706e-01f, -1.31412163e-01f, -8.63081738e-02f, 7.34394416e-04f, -2.35596136e-03f, -4.09940928e-02f, 1.08402977e-02f, -2.37362068e-02f, -1.51937474e-02f,
  4.09840830e-02f, 3.60671543e-02f, -4.77028340e-02f, 3.71849537e-02f, -8.26720819e-02f, -3.84968668e-02f, -3.33894230e-02f, -1.60791110e-02f, 9.79340225e-02f, 1.21280752e-01f,
  3.14722843e-02f, 2.83409748e-03f, -4.72619869e-02f, -5.65053709e-02f, -6.18911209e-03f, -5.56776449e-02f, -1.00908190e-01f, 4.15030904e-02f, -8.57669190e-02f, -3.58962640e-02f,
  -5.81286149e-04f, 2.67541688e-02f, -1.19259641e-01f, 1.15417074e-02f, -2.68929414e-02f, 1.50142470e-02f, -3.08506750e-02f, -2.61044316e-02f, -2.25651055e-03f, -7.93173090e-02f,
  5.67792952e-02f, -1.77139901e-02f, -8.17520922e-05f, -6.87254146e-02f, -6.80302829e-02f, -1.76972698e-03f, -2.40500122e-02f, -4.43944335e-02f, 5.57042360e-02f, -6.38951659e-02f,
  6.15205709e-03f, 1.56127997e-02f, 2.54569836e-02f, -3.77730615e-02f, 1.38026616e-02f, -2.84160916e-02f, -4.30443212e-02f, 1.60788745e-02f, -3.47128101e-02f, -3.55923139e-02f,
  -2.81934798e-01f, -2.73943514e-01f, -3.28330025e-02f, -1.24901697e-01f, -8.93629193e-02f, -1.38917407e-02f, -3.77707146e-02f, -3.91879827e-02f, -1.34052157e-01f, -8.66611116e-03f,
  -1.40519544e-01f, 9.41826124e-03f, -1.26910992e-02f, 3.23533863e-02f, 8.37819427e-02f, 3.92818116e-02f, -5.52453883e-02f, -8.55943263e-02f, -3.48482952e-02f, -1.00938514e-01f,
  3.71097103e-02f, -6.85033295e-03f, 4.38782610e-02f, 1.10697195e-01f, 6.11060746e-02f, -8.26582015e-02f, 3.41401715e-03f, -4.60260548e-02f, -3.03978007e-02f, 1.37444818e-02f,
  -8.12909529e-02f, -3.82758044e-02f, 4.19877935e-03f, -1.72164924e-02f, -1.87977701e-01f, -1.10713907e-01f, -9.01421458e-02f, -1.05571948e-01f, 8.44281316e-02f, 7.01961368e-02f,
  -5.56395873e-02f, 1.12257190e-01f, 9.76622701e-02f, -1.36327848e-01f, 1.98707744e-01f, 1.39836147e-01f, -4.04214002e-02f, 7.69966021e-02f, -8.65344554e-02f, -1.26043007e-01f,
  -3.52267511e-02f, -1.39176354e-01f, -3.36604379e-02f, -1.21885471e-01f, -1.25645772e-01f, -6.83510602e-02f, 5.64457364e-02f, -2.04518586e-02f, -1.18674226e-01f, -5.67216314e-02f,
  -4.22138274e-02f, -7.24315420e-02f, 1.14716822e-03f, 1.22461293e-03f, -7.25182891e-02f, -6.11944050e-02f, 1.86757315e-02f, -3.76997776e-02f, -2.52581376e-04f, 5.90972193e-02f,
  3.23049724e-02f, -7.22206533e-02f, -6.90473337e-03f, 3.40236351e-02f, 6.98633585e-03f, 1.39458980e-02f, -1.01474792e-01f, 3.49712446e-02f, -5.18471487e-02f, -8.21481794e-02f,
  -3.44988480e-02f, -1.61536373e-02f, 6.93810955e-02f, 3.34071778e-02f, -2.90639773e-02f, -3.91089879e-02f, -2.08519977e-02f, 4.49793879e-03f, 5.31747229e-02f, -3.75839113e-03f,
  -5.80924861e-02f, -8.57209265e-02f, 2.19789073e-02f, -4.95140553e-02f, -3.68668996e-02f, 4.83374558e-02f, -8.55898708e-02f, 3.55605148e-02f, -1.87138300e-02f, 4.25698645e-02f,
  -4.43722382e-02f, 1.17737707e-02f, 8.52803327e-03f, 3.16107161e-02f, -2.31490340e-02f, 2.07344443e-02f, -5.33416215e-03f, 6.32552207e-02f, -5.51803745e-02f, -4.13204655e-02f,
  -2.56452858e-02f, 1.60461757e-03f, -1.23684453e-02f, 1.44574925e-01f, 7.13125542e-02f, -4.03416716e-02f, -5.62228225e-02f, -6.65906891e-02f, -4.77307010e-03f, 3.80550325e-02f,
  -7.18973801e-02f, 9.79293138e-03f, -8.02956000e-02f, 4.83401716e-02f, 7.21606240e-02f, 5.72977513e-02f, -2.86085047e-02f, -7.72263333e-02f, 7.24501209e-03f, 2.36749966e-02f,
  -5.40618077e-02f, 6.85286447e-02f, -2.58948021e-02f, -5.74629232e-02f, 1.54019473e-02f, -2.63367835e-02f, 2.85490621e-02f, 2.69685443e-02f, 5.08370884e-02f, -3.21817100e-02f,
  -3.53503251e-03f, -3.93173322e-02f, -2.71034474e-03f, 1.30794747e-02f, 4.10999097e-02f, 8.15865695e-02f, -9.57642775e-03f, 9.79101285e-02f, 6.96432590e-02f, -3.61247547e-02f,
  8.63032490e-02f, 4.50978667e-01f, 3.26665670e-01f, 2.97681302e-01f, -5.67466430e-02f, -4.43857670e-01f, -2.16737837e-01f, -3.35190780e-02f, -5.63900508e-02f, 2.65089911e-04f,
  -8.61147270e-02f, 2.10115731e-01f, 8.70228782e-02f, 1.29175559e-01f, -3.62343669e-01f, -5.22386990e-02f, -9.08087417e-02f, -3.50219347e-02f, -6.39946386e-02f, 1.60676569e-01f,
  -6.73618317e-02f, 5.62509429e-03f, 1.49172157e-01f, 4.64703552e-02f, 1.67568892e-01f, 1.67764455e-01f, 5.70429787e-02f, 9.95596647e-02f, 9.54063311e-02f, -7.02229664e-02f,
  -1.39335647e-01f, 1.08838566e-01f, 9.30201933e-02f, 4.83256020e-02f, -4.89481278e-02f, -2.05035787e-03f, 2.05189120e-02f, -1.91134624e-02f, 1.69707220e-02f, 5.02676740e-02f,
  5.32190017e-02f, -4.43108287e-03f, -7.69454688e-02f, -3.96611467e-02f, 1.29427901e-02f, 9.26509351e-02f, 5.06566316e-02f, 4.24076356e-02f, 6.53035641e-02f, 5.08669578e-02f,
  1.97950061e-02f, 5.73062673e-02f, -5.60401268e-02f, -9.09956545e-03f, 7.52806142e-02f, 4.23287116e-02f, -3.79699506e-02f, -2.25678906e-02f, 2.66049914e-02f, 2.43896972e-02f,
  2.44973209e-02f, -5.05113117e-02f, 3.20774205e-02f, -2.44143661e-02f, 8.47523957e-02f, 3.22454982e-02f, 1.78195331e-02f, -7.15388805e-02f, 2.80030835e-02f, -2.59939171e-02f,
  -8.21457207e-02f, 2.60414090e-02f, -5.74524282e-03f, 1.11089079e-02f, 5.10044806e-02f, 5.07904440e-02f, -3.99430506e-02f, -4.63638864e-02f, -1.31469537e-02f, 8.19533989e-02f,
  2.35461425e-02f, 2.46385969e-02f, -2.39189435e-02f, -6.51791021e-02f, -3.06702834e-02f, -3.21047567e-02f, -1.17515083e-02f, -2.36827806e-02f, 1.17826853e-02f, -7.52284452e-02f,
  -4.61373804e-03f, 3.68810147e-02f, -6.94869831e-02f, 3.07433791e-02f, 7.86592439e-02f, -6.78555146e-02f, -2.97807623e-02f, -3.29240449e-02f, 9.33417398e-03f, -6.87396303e-02f,
  -6.82230443e-02f, -6.17734110e-03f, -4.65195552e-02f, 7.38749746e-03f, 3.58708836e-02f, -4.74397279e-02f, -4.79878485e-02f, 2.63268803e-03f, 1.40336966e-02f, -8.58017989e-03f,
  1.30263269e-01f, -2.92305574e-02f, -6.32011816e-02f, -5.54940626e-02f, -6.09277152e-02f, 4.36092615e-02f, -6.36854628e-03f, 3.38999182e-02f, -4.77694944e-02f, -6.35331571e-02f,
  -2.89065778e-01f, 1.41729593e-01f, 1.11569040e-01f, 4.20741923e-03f, 6.52545644e-03f, 1.19768210e-01f, 1.31514758e-01f, 1.08285155e-02f, -2.31650528e-02f, 1.43135279e-01f,
  4.77855057e-02f, 2.93141138e-02f, 3.39420736e-02f, 3.54839712e-02f, -9.44017842e-02f, -1.95097402e-02f, -4.82504927e-02f, 8.12789947e-02f, 9.57417935e-02f, -1.14049591e-01f,
  -1.15335226e-01f, -5.87818287e-02f, 4.10955064e-02f, 9.93621573e-02f, -4.00135806e-03f, 2.46431846e-02f, 3.97903249e-02f, -5.98295443e-02f, 3.19663174e-02f, -5.05019426e-02f,
  6.58524921e-04f, 1.13895662e-01f, -9.31285620e-02f, -1.59387346e-02f, -8.31988156e-02f, 3.90627384e-02f, 3.65755497e-03f, -1.65992826e-02f, 1.70209333e-02f, 1.38202682e-01f,
  -4.66801338e-02f, -2.89404355e-02f, 1.76706016e-02f, 2.53985077e-02f, -2.20411103e-02f, -6.02598451e-02f, -2.52833329e-02f, 7.00239390e-02f, -8.20238888e-03f, -3.82473343e-03f,
  7.02710748e-02f, 7.62869269e-02f, 5.42620234e-02f, 7.97730014e-02f, -2.46512964e-02f, 4.57955822e-02f, 6.21447526e-02f, 1.37408879e-02f, -1.09325559e-03f, 8.01841915e-02f,
  5.27323745e-02f, -4.02620398e-02f, 1.24768298e-02f, 5.56485467e-02f, 1.15858808e-01f, 1.13333380e-02f, -2.57553766e-04f, -8.54356587e-02f, 7.99414888e-02f, -7.82213658e-02f,
  1.26110520e-02f, -3.50163467e-02f, 3.15639488e-02f, -4.33653668e-02f, 3.28374058e-02f, 7.08921105e-02f, 4.53105615e-03f, 1.02812611e-02f, 1.15031421e-01f, -9.94760245e-02f,
  -6.44793808e-02f, -1.27010748e-01f, 4.09771129e-02f, 9.41489488e-02f, -5.27536944e-02f, -5.17787971e-02f, -3.84574272e-02f, 1.01139760e-02f, 1.28822066e-02f, 5.44580445e-02f,
  2.88975034e-02f, -4.42652032e-02f, 7.04001868e-03f, 5.81134856e-03f, 3.86606939e-02f, -7.73879290e-02f, 4.41199206e-02f, -6.25175610e-02f, 6.40141368e-02f, -3.68027948e-03f,
  -6.79261908e-02f, -3.03478409e-02f, -8.07609856e-02f, -5.07276952e-02f, -2.60002706e-02f, -3.13791260e-02f, 2.00082697e-02f, -4.06590709e-03f, -3.82761769e-02f, 1.35203628e-02f,
  -7.78718591e-02f, -3.86992693e-02f, -6.67831898e-02f, -8.73318687e-02f, 1.26919299e-01f, 1.26559306e-02f, 2.55323313e-02f, -9.23294947e-03f, -3.06970943e-02f, -3.89373451e-02f,
  -4.47435789e-02f, 1.93469539e-01f, 6.33407161e-02f, 1.00257196e-01f, -7.70081952e-02f, -1.64515618e-02f, 8.82358402e-02f, -6.85912669e-02f, -6.41001016e-02f, 8.54867101e-02f,
  1.78702623e-01f, 2.87923822e-03f, 1.11933835e-01f, 9.71090794e-02f, -7.38195106e-02f, 1.37639999e-01f, 1.44153684e-01f, 5.64099774e-02f, -1.50733531e-01f, -3.16898967e-03f,
  2.19478700e-02f, 8.23256094e-03f, -1.09126111e-02f, 5.95214590e-02f, 1.58557687e-02f, 5.50860241e-02f, 7.72041231e-02f, -9.43430066e-02f, 3.65647748e-02f, -7.88801908e-02f,
  -9.20411646e-02f, -2.36187074e-02f, 6.55533448e-02f, -4.21897247e-02f, 3.94471139e-02f, -5.46714924e-02f, -2.13079317e-03f, 6.43524826e-02f, -9.46799368e-02f, -1.83738973e-02f,
  -2.33159140e-02f, -1.04623280e-01f, -3.92761976e-02f, -8.64713043e-02f, 4.87113297e-02f, 5.10537624e-02f, -3.00766788e-02f, 1.27486642e-02f, -5.97244315e-02f, -8.04251432e-02f,
  1.76676251e-02f, 2.86181569e-02f, -6.11187704e-02f, -3.56880911e-02f, -1.17047057e-01f, -2.93629449e-02f, 3.20050791e-02f, 1.28388954e-02f, 8.35115984e-02f, -5.10536060e-02f,
  -1.23775220e-02f, 2.65080966e-02f, -5.15544973e-02f, -3.52075957e-02f, -4.34061736e-02f, 7.11406395e-02f, -4.25505526e-02f, 5.27396752e-03f, 1.53035787e-03f, -4.35547903e-02f,
  -2.56250277e-02f, 4.08767574e-02f, -8.10501948e-02f, 2.30005831e-02f, -1.88901443e-02f, 4.28423584e-02f, 3.52211148e-02f, 3.51064117e-03f, -5.83787039e-02f, 6.12009550e-03f,
  -7.52904639e-02f, 6.60938919e-02f, -5.91265550e-03f, 6.73175007e-02f, 1.84549466e-02f, 4.74769734e-02f, -6.11594692e-02f, -1.74149834e-02f, -1.29877625e-03f, -5.66796176e-02f,
  -1.17755540e-01f, -4.68762480e-02f, 7.14107603e-03f, -4.54034321e-02f, -4.94542904e-02f, 2.09735204e-02f, -9.82860103e-02f, -4.55374531e-02f, -8.53693262e-02f, -7.17922524e-02f,
  3.05506717e-02f, -2.57570185e-02f, 1.53376488e-02f, 1.97370723e-03f, 1.86852179e-02f, 5.92356175e-02f, -6.71242699e-02f, -1.21316262e-01f, 4.09824811e-02f, -6.05717488e-02f,
  8.86547044e-02f, 2.15422809e-02f, 4.00457010e-02f, -9.05748010e-02f, -5.13275415e-02f, 2.71404367e-02f, -2.49660164e-02f, -6.50571063e-02f, 4.68711555e-02f, 2.67000683e-03f,
  -2.05248177e-01f, 7.13519007e-02f, 9.29274485e-02f, -1.06597975e-01f, -2.53637191e-02f, -6.79868758e-02f, 6.65816143e-02f, 1.55496791e-01f, 8.65978003e-02f, -2.18592528e-02f,
  7.43290037e-02f, 2.30604354e-02f, -9.55684017e-03f, -8.15578736e-03f, -1.16986811e-01f, -1.50355011e-01f, -7.13092387e-02f, -8.13485086e-02f, -5.53284623e-02f, -3.05700824e-02f,
  -9.16397199e-02f, -7.97307640e-02f, -2.85512507e-02f, 4.98902611e-03f, 6.12027720e-02f, 6.83455989e-02f, -5.24347872e-02f, 3.86954956e-02f, -1.10407144e-01f, 1.23433322e-02f,
  9.06161740e-02f, 1.50920928e-01f, 1.06436601e-02f, 1.04931809e-01f, 3.62469517e-02f, -3.49663720e-02f, -1.40226316e-02f, -4.22217287e-02f, 9.14431810e-02f, 6.02094643e-02f,
  -1.37854382e-01f, 3.57803255e-02f, 2.14203000e-02f, 5.83453327e-02f, -8.67435895e-03f, -2.74119270e-03f, -4.46780510e-02f, -7.13520050e-02f, 4.55492400e-02f, 7.75760505e-03f,
  -1.74768828e-02f, 2.97606201e-03f, -2.79845335e-02f, 4.62927623e-03f, -5.45297563e-02f, 8.39205086e-03f, -6.75718114e-02f, 1.14968084e-02f, 6.50409004e-03f, 6.52348027e-02f,
  3.51913050e-02f, -7.60960765e-03f, 6.64113909e-02f, 9.31075290e-02f, -5.91155142e-02f, -1.87244751e-02f, 1.88987013e-02f, -9.11996409e-04f, -1.87922604e-02f, 1.13071138e-02f,
  -4.42240424e-02f, 1.20773740e-01f, -1.60901863e-02f, -8.32059886e-03f, -1.45428488e-03f, -3.66645195e-02f, -6.82210848e-02f, -2.41355877e-02f, -2.79364195e-02f, -4.19518873e-02f,
  -5.56558184e-02f, -7.70915672e-02f, -1.58372093e-02f, 4.84950282e-02f, 1.30622074e-01f, 5.06578311e-02f, 3.18498686e-02f, 6.44876584e-02f, -3.37464698e-02f, -9.19402838e-02f,
  2.40807645e-02f, 1.92035071e-03f, 8.73067230e-02f, 8.32754225e-02f, -6.54314905e-02f, 5.55075845e-03f, -7.93824345e-02f, 6.53737411e-02f, -1.02980569e-01f, -2.13309675e-02f,
  -6.68163747e-02f, -3.87157947e-02f, -1.19584121e-01f, 2.26404183e-02f, -5.78240529e-02f, 3.39440703e-02f, -2.14393027e-02f, 2.39501819e-02f, -1.66791473e-02f, -4.79582027e-02f,
  -6.78007305e-02f, -5.81521653e-02f, -9.00182407e-03f, 4.32086289e-02f, -1.13068454e-01f, -1.09609244e-02f, 7.37561705e-03f, 6.30152449e-02f, 7.13900179e-02f, 3.85860205e-02f,
  -4.66648936e-01f, -1.66370273e-01f, -1.29964992e-01f, -3.18532795e-01f, 1.50022581e-01f, -1.10903708e-02f, -1.67109177e-01f, -7.25102425e-02f, -1.41025260e-01f, -8.87066647e-02f,
  -2.73695178e-02f, -2.15766951e-01f, 4.52988222e-02f, -3.89257967e-01f, -1.07375592e-01f, -5.80895767e-02f, -2.37531781e-01f, -2.14427099e-01f, 2.22870875e-02f, -4.94142845e-02f,
  -1.88236702e-02f, -1.60584599e-01f, -1.55448377e-01f, 1.39623925e-01f, -1.35753244e-01f, 4.13464494e-02f, -3.83348688e-02f, 1.30168140e-01f, 7.22713396e-02f, 6.45012455e-03f,
  -1.09731242e-01f, -1.06154844e-01f, 1.37330145e-02f, 3.99921536e-02f, 3.15261036e-02f, -1.17653999e-02f, -1.06742745e-02f, 3.63487937e-02f, -5.19948043e-02f, 6.66655302e-02f,
  -3.71038988e-02f, 2.41415184e-02f, -8.32999274e-02f, -5.51126301e-02f, 2.31497996e-02f, 3.41503881e-02f, -2.24081706e-02f, -6.19706837e-03f, 2.96896752e-02f, -1.09463027e-02f,
  -6.07416444e-02f, 7.00028390e-02f, -5.21155372e-02f, -7.51185343e-02f, 5.63168153e-03f, 8.75224918e-02f, -1.00204609e-01f, 5.90644404e-02f, 5.22241294e-02f, -3.63765247e-02f,
  -4.73556034e-02f, -1.83449183e-02f, -5.94961131e-03f, -3.74944173e-02f, 6.76973015e-02f, 6.99832365e-02f, 9.50019341e-03f, 2.35857372e-03f, -2.37954892e-02f, 4.67215888e-02f,
  -2.46046949e-02f, -8.69202390e-02f, 2.34797467e-02f, 1.64874587e-02f, -7.92641342e-02f, 2.72201188e-02f, 2.02971743e-03f, 2.92355735e-02f, -1.60620213e-02f, 1.58705674e-02f,
  -1.88562013e-02f, 2.41125375e-02f, 2.16431562e-02f, 1.66671202e-02f, 3.00612170e-02f, -2.46013571e-02f, 5.46057597e-02f, -3.65410931e-02f, -2.04910319e-02f, -2.52299514e-02f,
  8.44725873e-03f, 3.88801731e-02f, 3.04146651e-02f, 8.87816325e-02f, -7.48572424e-02f, 9.59907994e-02f, -7.01508671e-02f, -2.10311599e-02f, 3.82803418e-02f, -5.30585088e-02f,
  5.35555780e-02f, -4.47066687e-02f, 3.65402433e-04f, -6.19318075e-02f, 3.40714194e-02f, -1.87502813e-03f, -8.19229484e-02f, -8.97106156e-03f, -5.58703505e-02f, 9.17661339e-02f,
  6.71631694e-02f, 2.74873208e-02f, -4.31828089e-02f, -3.26764509e-02f, -8.64490792e-02f, -7.38197705e-03f, 3.63024771e-02f, 4.01535295e-02f, 4.77448404e-02f, -7.67625589e-03f,
  -7.19388202e-02f, -7.49546811e-02f, 1.07931845e-01f, -1.50189906e-01f, -9.25021097e-02f, -1.97786884e-03f, 1.11647144e-01f, -1.37848750e-01f, -2.46207356e-01f, -8.64568874e-02f,
  1.51005108e-02f, 1.08131692e-02f, 1.66096389e-01f, -3.33705097e-02f, 6.95707202e-02f, 7.70995468e-02f, 3.78067605e-02f, 8.08851644e-02f, 7.39318728e-02f, 7.43916929e-02f,
  -1.41936196e-02f, 1.86129827e-02f, 2.26675466e-01f, -4.61347625e-02f, 6.16737306e-02f, -9.57484916e-02f, -3.26962695e-02f, 1.74604222e-01f, -4.75214329e-03f, -6.08000234e-02f,
  4.84613888e-02f, -1.01430915e-01f, 4.99691032e-02f, 9.82486382e-02f, 5.16809151e-02f, -2.77231503e-02f, -3.64885875e-03f, 3.92859541e-02f, -6.18824884e-02f, -3.03446557e-02f,
  -1.44374399e-02f, -1.62827969e-02f, -5.84094413e-02f, -2.80717835e-02f, -1.78710259e-02f, -3.19965594e-02f, 2.86486902e-04f, 6.86298683e-02f, 7.21812546e-02f, 6.20489568e-02f,
  2.36968379e-02f, -6.69984445e-02f, -1.07397800e-02f, 4.62831594e-02f, -1.65971648e-02f, -8.17452222e-02f, -2.93575525e-02f, 9.72824618e-02f, -5.88421039e-02f, -1.14235781e-01f,
  3.15725729e-02f, 5.58864549e-02f, 6.78773373e-02f, 5.22922613e-02f, -5.44755533e-02f, -1.78124309e-02f, 3.76585200e-02f, -3.31471935e-02f, 7.87724406e-02f, -2.74233241e-02f,
  -5.40901050e-02f, -8.74425769e-02f, -1.06425416e-02f, 5.32029048e-02f, -3.71293798e-02f, -1.23197511e-02f, -1.34898741e-02f, -3.57550196e-02f, -1.01553358e-01f, -4.26598042e-02f,
  -3.18329372e-02f, -9.80846062e-02f, -7.21783563e-02f, 3.13756503e-02f, -6.11747131e-02f, 3.87385860e-02f, 6.91824928e-02f, 3.58263068e-02f, 2.28703506e-02f, 1.14760093e-01f,
  -3.86711136e-02f, -9.17221680e-02f, -1.74185298e-02f, -4.37663384e-02f, 9.68962386e-02f, 9.23499558e-03f, 5.55434525e-02f, 6.34086281e-02f, -5.38728498e-02f, 4.39298078e-02f,
  -1.11731607e-03f, -9.78106186e-02f, -5.13601601e-02f, 1.50600811e-02f, -8.56693760e-02f, -8.03942829e-02f, -3.79484035e-02f, -6.00730553e-02f, 9.48875770e-03f, 6.45245751e-03f,
  3.96466851e-02f, -5.14957905e-02f, 1.06182918e-02f, -3.25124967e-03f, -3.79934236e-02f, 3.38894955e-04f, 9.68374126e-03f, -3.33036743e-02f, 2.09183851e-03f, -9.45511013e-02f,
  1.49281293e-01f, -2.10727900e-01f, 1.45248786e-01f, 7.88127184e-02f, 1.02315672e-01f, 1.79612577e-01f, 3.18494678e-01f, -2.27552336e-02f, 1.10244237e-01f, -2.22323328e-01f,
  -7.91004524e-02f, 3.55120655e-03f, 8.12279526e-03f, -3.07095423e-02f, 2.72559077e-01f, 9.71281528e-03f, -2.31846403e-02f, -3.71184237e-02f, -4.44940738e-02f, 3.85168917e-03f,
  3.87491584e-02f, -7.56773576e-02f, 5.78716993e-02f, -1.09538481e-01f, 8.92815813e-02f, -3.07799187e-02f, -1.11989759e-01f, 8.22773203e-02f, -1.90884784e-01f, 1.79805513e-02f,
  -1.35579007e-02f, -5.87694719e-02f, 3.56939919e-02f, -9.83054265e-02f, -2.85533927e-02f, -1.87656805e-02f, -6.48462698e-02f, 7.23071173e-02f, 5.77539811e-03f, 1.72090866e-02f,
  -5.68786263e-02f, 3.84375677e-02f, -9.63656902e-02f, 4.21241596e-02f, -2.66574603e-02f, -4.63888608e-02f, -1.13303177e-02f, -1.06208138e-01f, -4.86903451e-02f, -2.83254143e-02f,
  3.16501111e-02f, -9.19014886e-02f, -5.48410080e-02f, -3.82383876e-02f, 1.84466857e-02f, -4.05003764e-02f, 5.35262264e-02f, -5.02309017e-02f, -4.38636588e-03f, 1.58209298e-02f,
  5.64528927e-02f, 5.48768714e-02f, 5.08191399e-02f, -3.48422974e-02f, 3.92929688e-02f, -7.53177628e-02f, -2.31715515e-02f, 4.80374135e-02f, 1.17767034e-02f, 8.46747833e-04f,
  -2.95241121e-02f, -2.08985955e-02f, -3.49681862e-02f, -2.44781785e-02f, 5.46195684e-03f, 6.84994459e-02f, -4.51880395e-02f, -1.86522696e-02f, 6.20534308e-02f, 1.37903821e-02f,
  9.59397703e-02f, 7.59629998e-03f, -2.71176454e-02f, 1.37412786e-01f, 4.93729152e-02f, 4.38876338e-02f, 5.49392737e-02f, -9.58311111e-02f, -1.21036675e-04f, -9.18248966e-02f,
  -1.21551007e-01f, -1.31540924e-01f, -4.96593816e-03f, -5.69952652e-02f, 1.59192784e-03f, 2.29989029e-02f, -6.08933643e-02f, -8.39971900e-02f, -5.81022725e-02f, -8.65527149e-03f,
  2.80906428e-02f, 5.74932359e-02f, 4.91434783e-02f, 4.64051031e-02f, -3.10699781e-03f, 5.13673387e-02f, 3.69695537e-02f, 2.30507329e-02f, 4.31411043e-02f, -1.00294098e-01f,
  3.16244899e-03f, -4.95482199e-02f, -4.77053318e-03f, -6.57189041e-02f, -8.00605044e-02f, 4.45748940e-02f, -7.57284239e-02f, -1.11741602e-01f, 1.02628991e-02f, 2.27192901e-02f,
  1.04152225e-01f, 1.62081374e-03f, 1.25260845e-01f, 1.00514749e-02f, 8.84825736e-02f, 1.62877850e-02f, 1.19795606e-01f, 2.49592513e-02f, 1.79742221e-02f, 4.78331223e-02f,
  6.43422827e-03f, 4.04818021e-02f, 7.56637529e-02f, 8.67310446e-03f, -1.92603335e-01f, -1.05887517e-01f, -2.19303183e-02f, 3.89091335e-02f, -5.63582517e-02f, 6.26553148e-02f,
  5.57592250e-02f, -1.24689564e-01f, -2.60257553e-02f, -7.62277618e-02f, -3.47919483e-03f, 8.63456130e-02f, -1.60595611e-01f, -3.26192230e-02f, -1.06088296e-01f, -5.14988275e-03f,
  -8.23011547e-02f, -4.28146422e-02f, 2.04671808e-02f, 3.53605114e-02f, 2.19461303e-02f, 2.31221318e-02f, -2.42699720e-02f, 2.98004784e-02f, -4.79299054e-02f, 6.63860664e-02f,
  6.05148859e-02f, 3.07915676e-02f, -4.71530221e-02f, -3.22568323e-03f, -1.96133852e-02f, 8.70338902e-02f, 3.85693386e-02f, 8.11697319e-02f, 1.03978086e-02f, 1.01840734e-01f,
  1.33993432e-01f, 8.75313580e-02f, -8.93793441e-03f, -7.93708116e-02f, 2.61272211e-02f, 6.60567824e-03f, 7.29250088e-02f, 4.11556475e-02f, 2.58313306e-02f, -3.72744091e-02f,
  -5.98072000e-02f, 3.68407369e-02f, -8.83277804e-02f, -1.16345458e-01f, -9.37585905e-02f, 3.45960967e-02f, 2.25866865e-02f, 8.86680000e-03f, -9.15888604e-03f, -5.40903062e-02f,
  3.10503747e-02f, 3.13511351e-03f, 1.10346243e-01f, 6.43156618e-02f, 5.78195695e-03f, -4.00481895e-02f, -8.75356346e-02f, 8.96575768e-03f, -4.66479138e-02f, 6.82773888e-02f,
  -6.87537938e-02f, -2.52656005e-02f, -3.44680287e-02f, 2.06231028e-02f, 2.13461835e-02f, 3.98035832e-02f, -3.45081426e-02f, -4.48474921e-02f, -7.16707706e-02f, -4.92919870e-02f,
  -1.57256231e-01f, -1.53297588e-01f, 1.40383104e-02f, -5.75897470e-02f, 3.67489979e-02f, -6.27228804e-03f, 6.42142072e-02f, 8.44101235e-03f, -7.37781227e-02f, 6.41228184e-02f,
  8.05386379e-02f, 4.37531546e-02f, 4.07200865e-02f, 7.45271295e-02f, 2.48009339e-02f, -5.48370108e-02f, -1.39432043e-01f, -6.63068667e-02f, -3.43841477e-03f, 1.06197551e-01f,
  8.35631192e-02f, -1.03880093e-01f, -9.63089094e-02f, 7.12661892e-02f, 5.57223596e-02f, -1.62208695e-02f, -2.30728532e-03f, -1.90503933e-02f, 2.64823604e-02f, 4.09841500e-02f,
  -3.07087949e-03f, -4.25876640e-02f, -5.74254096e-02f, -6.19706362e-02f, 3.28899664e-03f, 1.15673892e-01f, 2.06252020e-02f, 4.60803770e-02f, -1.63621809e-02f, 7.87774920e-02f,
  1.51954871e-02f, -1.64139032e-01f, -7.81012401e-02f, -2.36957699e-01f, -1.88157395e-01f, -1.79856643e-01f, -7.86177889e-02f, -8.17767531e-02f, -6.68284968e-02f, 8.17515235e-03f,
  -7.34636411e-02f, -1.03186199e-03f, -1.07861497e-02f, 9.56888348e-02f, 8.51351470e-02f, 9.68128145e-02f, 2.00894788e-01f, 7.39219561e-02f, 3.55890654e-02f, -8.30821767e-02f,
  5.86731099e-02f, -4.95534018e-02f, -5.14193885e-02f, -1.21213794e-02f, 1.40625238e-03f, -4.95219603e-03f, 2.98806094e-02f, 5.34944311e-02f, 3.57593521e-02f, 5.98505214e-02f,
  -3.35727744e-02f, -4.12178077e-02f, -1.48728937e-02f, 9.60756615e-02f, 1.02514382e-02f, -4.06673066e-02f, -1.96745433e-02f, 7.21078664e-02f, 7.96396937e-03f, -1.15590125e-01f,
  -9.92360041e-02f, 6.38756603e-02f, -1.76899005e-02f, 7.62952724e-03f, 6.52772421e-03f, -4.08918150e-02f, 7.45696053e-02f, -2.80543901e-02f, -4.89782840e-02f, -4.61196080e-02f,
  -5.66802472e-02f, -6.28443668e-03f, 5.25932238e-02f, -2.54354032e-04f, 4.90177684e-02f, 4.46535535e-02f, -1.63427778e-02f, -2.97153983e-02f, 8.22774023e-02f, 5.95667176e-02f,
  7.87389502e-02f, 6.89833462e-02f, -5.36106713e-02f, 7.02639446e-02f, 4.94347364e-02f, 5.72189502e-02f, 1.10428734e-03f, -3.10526062e-02f, -8.53889957e-02f, 6.55669197e-02f,
  8.45990609e-03f, 3.85250486e-02f, 3.35577726e-02f, 8.71887431e-02f, -3.05879507e-02f, 1.57098118e-02f, -4.20485623e-02f, 4.63291965e-02f, 1.05384048e-02f, -1.27594983e-02f,
  5.46274940e-03f, 6.48183897e-02f, 8.83946288e-03f, -1.97455045e-02f, 2.21532881e-02f, 1.63364429e-02f, -3.62201743e-02f, -2.16497611e-02f, 3.92667539e-02f, 4.16992530e-02f,
  -6.63308240e-03f, -1.70429202e-03f, 4.00539450e-02f, 1.60496179e-02f, -4.49009240e-03f, -9.62737948e-03f, -5.49001507e-02f, -6.04126090e-03f, 5.62410392e-02f, 4.79289852e-02f,
  -3.89493406e-02f, 6.64861202e-02f, -5.30603006e-02f, 4.04358022e-02f, 7.86073580e-02f, 6.01163730e-02f, -6.68092743e-02f, -1.11282423e-01f, -1.34022888e-02f, 6.22493140e-02f,
  -1.13302125e-02f, 2.85601944e-01f, 1.92347746e-02f, -1.07301407e-01f, 2.47552879e-02f, -2.58668572e-01f, 7.73316948e-03f, 9.18439999e-02f, -8.65086168e-02f, 1.82286441e-01f,
  3.46621014e-02f, 3.36785354e-02f, 2.58750864e-03f, -1.19767025e-01f, -3.83092821e-01f, -2.67751873e-01f, -1.86511338e-01f, -1.03190549e-01f, -1.36012420e-01f, 3.62071842e-02f,
  -8.65080282e-02f, -8.49420801e-02f, 3.44930254e-02f, 1.69667885e-01f, 8.76512378e-02f, 2.67831534e-01f, 2.14947432e-01f, 2.43376374e-01f, 2.32480951e-02f, 1.30358982e-04f,
  -1.50831908e-01f, 2.47870106e-02f, 8.78500938e-02f, -4.92041931e-03f, 5.07005192e-02f, 3.31690311e-02f, -4.73669730e-02f, 3.48963439e-02f, -7.42105693e-02f, -3.23763862e-02f,
  2.52545662e-02f, -5.34246862e-02f, 2.24804711e-02f, 2.62829456e-02f, -1.00717666e-02f, 8.52148607e-03f, -5.09478487e-02f, -7.08857551e-02f, -4.82430831e-02f, -1.66124552e-02f,
  -4.66252752e-02f, -3.98657322e-02f, 1.05016574e-01f, -3.47544416e-03f, -8.24550688e-02f, -4.10455279e-02f, -5.07658385e-02f, -2.04911791e-02f, -1.69310533e-02f, -1.21204332e-01f,
  2.75720423e-03f, 9.75433141e-02f, 6.27033636e-02f, 4.92202602e-02f, 2.20539197e-02f, -3.31395008e-02f, 1.58648901e-02f, 3.09543777e-02f, 3.03910132e-02f, -1.98537931e-02f,
  6.74130172e-02f, 3.19270464e-03f, -1.31910732e-02f, -5.96422739e-02f, -4.88757901e-02f, 3.28889862e-02f, 3.08356378e-02f, -4.35781889e-02f, -7.94890299e-02f, 3.63825187e-02f,
  2.00649165e-02f, -8.64763632e-02f, 7.60386884e-02f, 9.21894982e-02f, -6.62650988e-02f, -2.04618089e-02f, 1.84147130e-03f, -3.41021665e-03f, -4.06233221e-02f, 7.31100962e-02f,
  -5.39356321e-02f, -1.10932672e-02f, 7.19831884e-02f, -5.57879470e-02f, 1.82616897e-02f, -5.53481840e-02f, 3.43356170e-02f, 1.24107888e-02f, 6.33253083e-02f, -1.93067174e-02f,
  5.06699495e-02f, 6.96164668e-02f, 2.38404539e-03f, -3.00250463e-02f, 2.24613249e-02f, 8.63429345e-03f, 4.02288027e-02f, 6.59293830e-02f, 9.26532522e-02f, 3.05302255e-02f,
  3.98598984e-03f, -7.20568560e-03f, 6.30538464e-02f, -5.64352125e-02f, -3.52665186e-02f, -4.05091420e-02f, 5.43350875e-02f, 1.20141963e-02f, 4.48992588e-02f, -3.16359252e-02f,
  -2.30263665e-01f, 9.78596881e-02f, -3.92182171e-01f, 7.06740543e-02f, 4.26322222e-02f, 3.16208959e-01f, 2.21133575e-01f, 7.63024166e-02f, -6.59408718e-02f, 3.80303174e-01f,
  2.69245952e-01f, -1.39952600e-01f, -5.00891693e-02f, 4.14508641e-01f, -8.15260783e-02f, 5.40436655e-02f, 4.15013015e-01f, 2.77486116e-01f, -1.72112435e-01f, 1.57283284e-02f,
  -8.66453350e-02f, 3.80085617e-01f, 2.29098517e-02f, -2.37966217e-02f, 1.35112181e-01f, -2.26234630e-01f, 8.01706463e-02f, -2.00253502e-01f, 2.15411901e-01f, 1.16671242e-01f,
  6.38808981e-02f, -5.05970083e-02f, 3.64480950e-02f, -1.25036925e-01f, -1.89020727e-02f, 6.44217292e-03f, 1.36576155e-02f, -9.29214209e-02f, -3.11499368e-02f, 4.02157456e-02f,
  9.58405156e-03f, -1.72813609e-03f, 2.34931633e-02f, -2.45864224e-02f, -7.36813992e-02f, -6.41948506e-02f, -8.92759394e-03f, -1.64245907e-02f, 1.53433690e-02f, -3.83276604e-02f,
  -1.08162485e-01f, 8.92655402e-02f, -2.67835166e-02f, 8.06162804e-02f, -9.24814269e-02f, 3.26973610e-02f, 6.13833517e-02f, 1.08269313e-02f, 4.53464240e-02f, -1.46971736e-02f,
  -1.86015945e-02f, 8.10908712e-03f, 8.22826754e-03f, 8.87432974e-03f, 9.11265239e-03f, 3.73060293e-02f, 2.34935321e-02f, 2.79196389e-02f, -7.51771927e-02f, 6.31636679e-02f,
  -3.88425738e-02f, -1.27578042e-02f, -8.52601416e-03f, -2.43473276e-02f, 2.38053990e-03f, 3.57884690e-02f, -4.80581634e-03f, -3.31528508e-03f, 6.50306270e-02f, 4.24538665e-02f,
  7.80826360e-02f, -7.30648413e-02f, 4.93272357e-02f, 7.66862780e-02f, 6.03072420e-02f, -2.46202797e-02f, 3.35825831e-02f, -6.51549771e-02f, -2.11932100e-02f, -5.58429658e-02f,
  1.26911744e-01f, -6.84316158e-02f, -4.62220646e-02f, 6.93487516e-03f, -1.83255076e-02f, 8.98891538e-02f, -2.24227794e-02f, 3.42285149e-02f, -5.85975908e-02f, -8.99812579e-02f,
  6.09690845e-02f, 1.23089389e-03f, 2.77592223e-02f, 3.48691307e-02f, 1.29255857e-02f, 8.98639932e-02f, -1.62016395e-02f, -9.42012016e-03f, 3.23029459e-02f, -1.97771508e-02f,
  8.48649591e-02f, -3.24666761e-02f, -5.39854951e-02f, 4.01143208e-02f, 1.02284513e-01f, 3.48445326e-02f, -4.80947718e-02f, -1.23914056e-01f, 2.54714154e-02f, 4.42121131e-03f,
  -2.69980639e-01f, 4.44369093e-02f, -2.64500529e-01f, -2.11239889e-01f, -2.44302712e-02f, -2.01104596e-01f, -2.79493064e-01f, 3.21950354e-02f, -2.49802947e-01f, 3.62520590e-02f,
  1.76473409e-02f, -7.66774490e-02f, 1.38796151e-01f, -1.48385271e-01f, -1.20513067e-01f, 1.73769683e-01f, -1.85657665e-01f, -9.68625695e-02f, 7.19022006e-02f, -1.94534343e-02f,
  -8.09793174e-02f, -8.31330419e-02f, 4.61893342e-02f, 6.00818656e-02f, -1.37062714e-01f, -6.63241223e-02f, 4.81086373e-02f, -1.52522996e-02f, -9.90095884e-02f, -4.30512168e-02f,
  1.23120219e-04f, -3.53130586e-02f, 5.13170622e-02f, -3.73550840e-02f, -1.56640023e-01f, -5.89457192e-02f, -7.10511114e-03f, 9.70125850e-03f, 1.08918838e-01f, 2.21543433e-03f,
  -1.01828516e-01f, -4.15259711e-02f, -1.88590083e-02f, -1.50716063e-02f, 2.54090056e-02f, -5.57011850e-02f, 9.47367176e-02f, -1.67997088e-02f, -5.87085634e-02f, -1.85648426e-02f,
  -1.77720040e-02f, -6.96365833e-02f, -1.09570034e-01f, 4.03976738e-02f, -1.21031374e-01f, -1.50844485e-01f, 6.71554506e-02f, 4.37725037e-02f, 2.98509896e-02f, -2.41712760e-02f,
  -7.66742751e-02f, -6.22722134e-02f, 5.66225639e-03f, 8.04834738e-02f, 3.66033837e-02f, 1.95039599e-03f, -4.15864252e-02f, 4.81815077e-02f, -9.73598287e-02f, 3.51104736e-02f,
  -5.63898534e-02f, -6.61494210e-04f, -5.98681457e-02f, -5.56501597e-02f, 5.96053619e-03f, -3.56100798e-02f, 1.37469666e-02f, -1.99664161e-02f, -6.00370532e-03f, 2.22861357e-02f,
  7.03588948e-02f, 4.53922935e-02f, -5.93200214e-02f, 8.68424997e-02f, -6.21476956e-02f, 7.10148811e-02f, 7.43509457e-02f, 1.58297047e-02f, 7.36508220e-02f, -4.05983254e-03f,
  -8.33978318e-03f, -1.27802819e-01f, 5.78833818e-02f, -1.68866478e-03f, 1.77085083e-02f, -7.05356598e-02f, -5.90140671e-02f, -2.17011031e-02f, -1.02468587e-01f, -7.76710510e-02f,
  6.99004298e-03f, 8.74903332e-03f, -3.59028988e-02f, -2.72935163e-02f, -6.31726161e-02f, -3.10067255e-02f, -8.17251485e-03f, -3.20606232e-02f, -8.10172707e-02f, 2.50329748e-02f,
  -1.09742686e-01f, -2.21372359e-02f, 7.61325732e-02f, -2.07607169e-02f, -1.85311921e-02f, -7.71762338e-04f, -6.86470121e-02f, -5.79146035e-02f, -9.18998197e-02f, -4.95590158e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.77356559e-02f, 2.36537695e-01f, 1.91109300e-01f, 1.52131587e-01f, -3.30194016e-03f, 1.50211304e-01f, 2.26939633e-01f, 6.28860146e-02f, 1.03254803e-01f, 1.04668617e-01f,
  -4.60798182e-02f, 3.78370285e-02f, 4.50744927e-01f, 7.11353570e-02f, 1.47812665e-01f, 1.06114104e-01f, 8.12869221e-02f, 2.46862277e-01f, 7.06191733e-02f, 2.09711894e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  4.61218543e-02f, -7.61057064e-02f, 9.24611613e-02f, -4.58931960e-02f, 1.83589876e-01f, 5.98594621e-02f, -1.90126553e-01f, -6.83134645e-02f, 3.95088978e-02f, 4.15123776e-02f,
  2.28653267e-01f, 3.40154201e-01f, 7.05030113e-02f, -1.52655169e-01f, -4.25588526e-02f, 6.45565838e-02f, -1.45572811e-01f, 1.83309823e-01f, 2.39667818e-01f, 9.46673974e-02f,
  -4.92484346e-02f, -9.22745019e-02f, -4.69191521e-02f, 1.75205067e-01f, 1.33650497e-01f, -6.10332238e-04f, -9.99091472e-03f, 1.44205585e-01f, -1.01065643e-01f, -4.98017948e-03f,
  -3.71097594e-01f, 2.70594299e-01f, 1.31339692e-02f, 5.52521683e-02f, -1.69884235e-01f, 2.14246847e-02f, -1.34391621e-01f, -7.72537291e-02f, -7.63599053e-02f, -3.71461846e-02f,
  -2.68961281e-01f, -2.49642745e-01f, -4.38637525e-01f, -3.53276551e-01f, -2.13795170e-01f, -5.63950203e-02f, 2.72746116e-01f, -1.42441943e-01f, 4.07192081e-01f, 1.06542915e-01f,
  -3.85355771e-01f, -2.42997646e-01f, 3.11682224e-02f, -2.04769775e-01f, 2.33847611e-02f, -1.63656607e-01f, 3.60790789e-02f, -1.52368411e-01f, -3.03392380e-01f, -2.19781607e-01f,
  1.81962132e-01f, 1.50162637e-01f, 3.39820176e-01f, 7.33475909e-02f, -5.77943064e-02f, -2.18366593e-01f, -1.53309122e-01f, -5.30166477e-02f, -8.99360850e-02f, -5.31900041e-02f,
  -2.68683791e-01f, 3.04738015e-01f, -1.54961139e-01f, -3.06276560e-01f, 2.84672827e-01f, -1.76420361e-01f, -1.52534738e-01f, -1.64349213e-01f, -2.42417324e-02f, -1.65984154e-01f,
  4.88620177e-02f, -1.18175782e-01f, 3.06670219e-02f, -1.86505660e-01f, 4.41279769e-01f, -1.51397273e-01f, 5.56434505e-02f, 2.95923408e-02f, -1.49043277e-01f, 9.39107388e-02f,
  -2.37655398e-02f, 1.49055749e-01f, 1.55114844e-01f, 2.33327582e-01f, -2.71590650e-01f, -1.50098950e-02f, 4.44063209e-02f, 2.99367066e-02f, -2.98923496e-02f, 1.38829136e-02f,
  1.38161719e-01f, -1.36233240e-01f, -4.10657644e-01f, -1.85425207e-01f, 1.40135303e-01f, -1.38606444e-01f, -3.13597947e-01f, 8.73117335e-03f, -7.53230676e-02f, 2.34172627e-01f,
  -2.30902791e-01f, -1.79031834e-01f, -1.90848827e-01f, 9.31917503e-02f, 3.10777783e-01f, 1.81527272e-01f, -3.41304064e-01f, 1.35287687e-01f, -2.13756204e-01f, 1.88988388e-01f,
  4.44819629e-01f, -1.44240603e-01f, -6.72122836e-02f, 9.80463624e-02f, 9.30449292e-02f, -3.30843925e-02f, -2.04481885e-01f, 2.55622417e-01f, 2.20419005e-01f, -8.05522501e-02f,
  -4.67890352e-02f, -2.14508981e-01f, 1.15287244e-01f, 1.02088988e-01f, 5.44331223e-03f, 4.13795002e-02f, 1.96665108e-01f, 4.63499278e-02f, -2.22299695e-01f, -4.99746799e-02f,
  1.91239864e-01f, -1.49405584e-01f, -3.56373303e-02f, 1.70139834e-01f, -1.16923293e-02f, 1.29984006e-01f, -1.58320755e-01f, 2.54891008e-01f, -3.30344737e-01f, 4.01269197e-02f,
  -4.90878448e-02f, -9.28844288e-02f, 7.55087659e-02f, 1.92991540e-01f, 4.78445590e-02f, 5.80989756e-02f, -3.41223814e-02f, -3.73144925e-01f, 2.05686286e-01f, 2.97904406e-02f,
  -4.92230570e-03f, 2.64534116e-01f, 6.54160231e-03f, 4.67908233e-02f, 5.85009623e-03f, -3.13288927e-01f, 1.11744935e-02f, -1.03992738e-01f, -3.99647020e-02f, 1.70309573e-01f,
  -4.06540275e-01f, -7.04988390e-02f, 4.26376820e-01f, 2.54136682e-01f, -1.07496399e-02f, 9.19568315e-02f, -9.63878259e-03f, 1.40366375e-01f, 8.56523365e-02f, 1.98643699e-01f,
  -3.90177846e-01f, -1.89881518e-01f, -2.96911150e-01f, -1.54724911e-01f, 1.77841112e-01f, 9.95652452e-02f, 1.43496543e-01f, -1.23151340e-01f, 8.39255750e-02f, -2.78942317e-01f,
  -3.78871322e-01f, -4.64957841e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.91203725e-01f, -2.36931413e-01f, -5.90285622e-02f, 2.77221918e-01f, 1.43399537e-01f, 6.01888783e-02f, -6.90990016e-02f, -3.96584243e-01f, 1.60094425e-01f, -9.91829708e-02f,
  1.12947799e-01f, 3.34136575e-01f, -6.66567311e-02f, -1.88590080e-01f, 5.09368479e-01f, 2.30259225e-01f, -1.16206311e-01f, 4.27912623e-02f, 1.69441789e-01f, 1.05475068e-01f,
  1.75926700e-01f, 2.09834352e-01f, 1.67879954e-01f, 7.56043792e-02f, -1.46109268e-01f, 8.84283856e-02f, -1.70124173e-01f, 2.91054640e-02f, 6.52494803e-02f, -3.02306730e-02f,
  5.55899203e-01f, 3.29867840e-01f, -1.62510872e-02f, 6.07220572e-04f, -1.61563456e-01f, 5.22665568e-02f, -1.61251977e-01f, 1.85691509e-02f, 1.12929463e-01f, -4.33991514e-02f,
  6.52088001e-02f, 1.85812980e-01f, -6.47742003e-02f, -6.21161312e-02f, -9.78476405e-02f, 8.64563733e-02f, -8.54620785e-02f, 1.61603227e-01f, -3.66319828e-02f, -1.37135938e-01f,
  3.64696383e-02f, -6.29645139e-02f, -4.59885262e-02f, 1.30525991e-01f, -5.58558404e-02f, -6.45979121e-02f, 5.91197871e-02f, 1.53548002e-01f, 1.55992135e-01f, -1.26717165e-01f,
  1.21639788e-01f, 3.22668324e-03f, -1.35569632e-01f, -5.14608063e-02f, -6.03868254e-02f, 3.47556978e-01f, 3.88781041e-01f, 5.28983399e-02f, 2.91290134e-01f, 3.17968205e-02f,
  5.30033648e-01f, 3.67385834e-01f, 5.40687703e-03f, 1.12284780e-01f, -2.24975288e-01f, -1.44064799e-01f, 4.75787133e-01f, 5.61155379e-01f, -4.72443067e-02f, 2.19501674e-01f,
  5.04955709e-01f, 8.44991803e-02f, -2.85623044e-01f, 1.35690317e-01f, -2.44741961e-01f, -1.71108499e-01f, -2.13861372e-02f, -9.94900391e-02f, 1.05830684e-01f, 1.32198572e-01f,
  4.12633240e-01f, -1.33097500e-01f, 2.33758632e-02f, -1.00828139e-02f, 2.78259277e-01f, -1.66582257e-01f, 6.16968535e-02f, 1.13933735e-01f, 3.83268267e-01f, 2.05524147e-01f,
  1.75860167e-01f, 8.19390193e-02f, -3.01362742e-02f, 1.79174587e-01f, -1.24301992e-01f, -1.53100610e-01f, 1.63848072e-01f, 2.52941012e-01f, -3.10559094e-01f, 2.48221949e-01f,
  -2.66621821e-02f, -1.56230733e-01f, -2.67698050e-01f, 1.71002194e-01f, 2.29945138e-01f, -6.48645088e-02f, 4.51088659e-02f, 4.69471626e-02f, -6.32426962e-02f, 1.73106238e-01f,
  3.05127054e-01f, 1.12497479e-01f, 4.22732346e-02f, 1.93246424e-01f, 2.89297700e-01f, 1.53064668e-01f, -2.43517295e-01f, 6.77757934e-02f, -1.55455962e-01f, 3.06432664e-01f,
  -1.35351457e-02f, -1.12134807e-01f, 2.05112219e-01f, 1.31812636e-02f, -2.00184435e-01f, 1.80328474e-03f, -1.02061436e-01f, -4.14817668e-02f, -3.22610319e-01f, -3.51328403e-01f,
  4.01068509e-01f, 7.91611522e-02f, 2.02781390e-02f, 7.09184185e-02f, 2.94420063e-01f, 3.05442244e-01f, 1.39776438e-01f, 2.61728428e-02f, 2.97422022e-01f, -2.38787886e-02f,
  -4.23626602e-02f, -8.55288357e-02f, 1.91933647e-01f, 2.09103897e-01f, -2.48714045e-01f, -1.25823349e-01f, -1.08174168e-01f, 2.70731300e-01f, 3.26830924e-01f, 2.85890549e-01f,
  2.83745915e-01f, 1.80581450e-01f, 1.11076981e-01f, -1.66619986e-01f, 3.66318583e-01f, 3.17915380e-01f, -4.88305539e-01f, -3.96159142e-01f, 2.05835104e-01f, -1.01243213e-01f,
  -3.40271026e-01f, 8.42504725e-02f, 4.55353886e-01f, -3.89992259e-02f, 2.86427643e-02f, 2.92684007e-02f, 3.00744683e-01f, 3.86762261e-01f, 4.48762447e-01f, 1.22759836e-02f,
  -8.54145586e-02f, 2.16742471e-01f, 2.57182866e-02f, -4.22470383e-02f, 5.55636644e-01f, 1.88975602e-01f, -1.54098682e-02f, 3.37463222e-03f, 1.06431521e-01f, -3.06735523e-02f,
  -6.80987537e-02f, 4.01484877e-01f, -5.41107133e-02f, 1.77262008e-01f, 3.79617400e-02f, -1.37388527e-01f, 2.17113167e-01f, 8.78689364e-02f, 1.29618406e-01f, -5.95541708e-02f,
  1.71718225e-01f, 2.98669785e-01f, 4.81461957e-02f, -5.13256118e-02f, 4.11617421e-02f, 1.06306784e-01f, -1.75625142e-02f, 2.04580754e-01f, 2.52290964e-01f, -5.42879850e-02f,
  6.71139657e-02f, -1.99888840e-01f, -1.43272042e-01f, -5.75165935e-02f, -7.77882291e-03f, -6.79859426e-03f, 5.98475449e-02f, 2.80853033e-01f, -1.37933344e-02f, 1.03578992e-01f,
  9.26209837e-02f, -3.16973589e-02f, -2.48870641e-01f, -4.38348576e-02f, -1.69133544e-01f, -9.17960033e-02f, 8.05866644e-02f, -2.84456722e-02f, 1.15178548e-01f, -5.73498495e-02f,
  7.10074082e-02f, 3.15151848e-02f, -1.50382280e-01f, 3.56230736e-02f, -4.71393839e-02f, 9.39579308e-03f, 3.88607174e-01f, 7.28166848e-02f, 4.39944230e-02f, 2.34325662e-01f,
  -9.60822776e-02f, -2.78262608e-02f, 1.37176082e-01f, 1.81463912e-01f, -1.13799885e-01f, -1.74624488e-01f, 1.36715230e-02f, 5.47424778e-02f, 2.05727816e-01f, 5.47441021e-02f,
  4.67256196e-02f, 7.18074143e-02f, 1.66164622e-01f, -7.86821768e-02f, -9.35819745e-02f, 1.21231951e-01f, 1.58819348e-01f, -4.51662093e-02f, 9.73240584e-02f, -2.48898622e-02f,
  8.33973140e-02f, 1.53022418e-02f, 1.44125700e-01f, 4.14996818e-02f, -2.21528545e-01f, 1.15760766e-01f, -3.33713949e-01f, -3.78254533e-01f, -4.00724746e-02f, 2.86538415e-02f,
  2.70947009e-01f, -8.20892751e-02f, 3.23665917e-01f, -1.12489960e-03f, -1.13228105e-01f, -5.38255535e-02f, 1.82860214e-02f, -1.46933094e-01f, -1.27336159e-01f, -1.90283712e-02f,
  -5.25893047e-02f, 3.58539540e-03f, -9.30320919e-02f, -1.75300688e-01f, 2.09535614e-01f, 1.02450430e-01f, 3.28015059e-01f, 1.90019980e-02f, -1.13448389e-02f, -1.62456736e-01f,
  -1.03599310e-01f, 1.83495566e-01f, -5.36687952e-03f, 4.62429002e-02f, -1.26838744e-01f, -1.19312085e-01f, 2.88972948e-02f, 4.42324877e-02f, -1.29378885e-01f, -2.16377378e-01f,
  -1.75046638e-01f, -1.05772816e-01f, 4.63469289e-02f, -4.11879569e-02f, 7.27907661e-03f, -1.19469821e-01f, 2.91614681e-02f, 8.90242159e-02f, -3.19223665e-02f, 1.79904461e-01f,
  2.00329483e-01f, -1.65798813e-01f, -5.87047487e-02f, -1.11913435e-01f, -1.74905553e-01f, 1.67480022e-01f, 6.31739646e-02f, -6.95729954e-03f, 2.56412089e-01f, 7.61322379e-02f,
  1.60950929e-01f, -1.62692621e-01f, 1.55764790e-02f, 6.00136332e-02f, 1.38616875e-01f, 2.89682060e-01f, -2.23896846e-01f, -4.09715354e-01f, 1.26532754e-02f, 2.53285915e-02f,
  -2.00655647e-02f, -2.46391445e-03f, -1.99638009e-01f, -7.85808414e-02f, -1.86070148e-02f, 3.02614067e-02f, 3.39394622e-02f, 1.68625444e-01f, 3.16658944e-01f, 3.67042571e-02f,
  -4.44147587e-02f, 2.10717529e-01f, 1.56107411e-01f, 2.71759242e-01f, 2.80236661e-01f, 2.23567992e-01f, -1.55057296e-01f, -9.57124829e-02f, -7.13929757e-02f, 2.25286007e-01f,
  1.70982823e-01f, 1.51670069e-01f, -5.79362772e-02f, 3.07140350e-01f, 3.63813728e-01f, 1.85614437e-01f, 1.15230910e-01f, 2.71251559e-01f, -2.90598534e-02f, -1.49323374e-01f,
  -8.89933705e-02f, 2.04677716e-01f, 5.47629744e-02f, -1.15573049e-01f, 4.81341146e-02f, 1.19918004e-01f, 1.13985181e-01f, 1.03780972e-02f, -2.57670075e-01f, -1.84762198e-02f,
  1.03011988e-01f, -1.17169075e-01f, -1.71374649e-01f, 2.25061610e-01f, 8.53811428e-02f, 1.73612952e-01f, 2.78542608e-01f, -1.24699190e-01f, 1.64349303e-01f, 6.05994910e-02f,
  2.20502451e-01f, 1.58346966e-01f, 1.59975275e-01f, 2.48144269e-01f, 5.84892631e-01f, -5.04641123e-02f, 1.10862806e-01f, 3.54442447e-01f, 2.67319590e-01f, 4.14594531e-01f,
  4.27066982e-01f, 3.75372581e-02f, 1.03290752e-01f, 4.78159308e-01f, 3.44583690e-01f, 1.26239151e-01f, 4.85411584e-02f, 8.54889154e-02f, 3.70912552e-01f, 2.66644120e-01f,
  -1.64752588e-01f, -2.81452596e-01f, 2.99616456e-01f, 2.14299895e-02f, 5.86309321e-02f, 1.80129081e-01f, 3.88970412e-02f, -2.53167637e-02f, -2.20874935e-01f, 2.93280482e-01f,
  3.11365426e-01f, 2.84090042e-01f, -1.51633754e-01f, -1.11454383e-01f, 1.85263455e-01f, 6.43630372e-03f, -1.03807613e-01f, 2.63456911e-01f, 3.00642252e-01f, 3.36207569e-01f,
  9.64726284e-02f, 8.18253830e-02f, 1.48186475e-01f, 2.04055473e-01f, 8.56432319e-02f, 7.02997446e-02f, -3.13729644e-02f, -2.62838632e-01f, -1.83858037e-01f, 2.26010814e-01f,
  4.22408059e-02f, -3.46931294e-02f, 2.29220569e-01f, 1.31553441e-01f, -1.28526524e-01f, -9.41154733e-02f, 1.83155611e-01f, -2.80517209e-02f, -7.78279603e-02f, -2.92544551e-02f,
  2.58259386e-01f, -1.04200594e-01f, 5.33239543e-02f, 2.19082177e-01f, 2.83166140e-01f, 2.93298632e-01f, -1.70643017e-01f, 2.74697468e-02f, 1.42416477e-01f, 1.98715255e-01f,
  1.70808822e-01f, -3.58987264e-02f, -1.87624600e-02f, 1.12411372e-01f, 1.46264970e-01f, -1.51352093e-01f, -1.57812592e-02f, 1.19062379e-01f, -1.67350486e-01f, 1.88790217e-01f,
  2.04556614e-01f, -4.30277102e-02f, 8.97850767e-02f, 2.96879262e-02f, 8.87836367e-02f, 7.55006522e-02f, 8.62392783e-02f, 1.01673655e-01f, -1.38680398e-01f, -1.16288185e-01f,
  -1.01661816e-01f, -9.08827111e-02f, 6.16345480e-02f, -3.07595786e-02f, 1.38285026e-01f, -2.85280365e-02f, -5.02653560e-03f, 6.68135509e-02f, -8.71663019e-02f, -1.26404554e-01f,
  -1.51274472e-01f, -9.24717411e-02f, -1.08196095e-01f, 5.99092767e-02f, 9.99543965e-02f, -1.68262795e-01f, -7.49427453e-02f, 1.43918931e-01f, 7.88842216e-02f, 1.00935727e-01f,
  -5.48744109e-04f, -5.93132339e-02f, 1.55316487e-01f, 9.17266011e-02f, -1.01068817e-01f, 1.81155652e-01f, -1.51874959e-01f, -1.20149948e-01f, -1.23758189e-01f, 8.98738205e-02f,
  -6.99020550e-02f, 1.34465814e-01f, -6.44390881e-02f, 3.64855751e-02f, -3.78331803e-02f, -6.43614531e-02f, -1.27256736e-01f, -4.74793315e-02f, -2.81937420e-02f, -6.27519712e-02f,
  -1.50238693e-01f, -1.19484462e-01f, 5.89999482e-02f, -1.02341428e-01f, -2.78297961e-02f, -1.50551215e-01f, -6.53815120e-02f, -1.07100174e-01f, 5.07464372e-02f, -4.90000509e-02f,
  -6.40402734e-02f, 1.12887479e-01f, -1.00211985e-01f, 1.15561537e-01f, -9.39357430e-02f, -4.26147357e-02f, -6.56354427e-02f, 5.57291731e-02f, -2.02591568e-02f, 1.63432598e-01f,
  -1.51358336e-01f, 1.31496508e-02f, 1.43113688e-01f, -1.13948267e-02f, -1.61748707e-01f, -7.52590373e-02f, -1.28745601e-01f, 1.38091639e-01f, 3.18243764e-02f, 3.92894708e-02f,
  -7.01412335e-02f, 1.81764476e-02f, -5.40497480e-03f, 8.46710131e-02f, -9.30809695e-03f, 1.95042938e-01f, 6.65025488e-02f, 1.77149624e-01f, 2.82416165e-01f, 8.89293775e-02f,
  2.98325896e-01f, 2.24929854e-01f, -1.00653715e-01f, -3.10749803e-02f, -9.23832804e-02f, -2.77223438e-01f, -1.18065625e-01f, 3.37463319e-01f, -1.60501316e-01f, -7.60829449e-02f,
  -1.86855420e-01f, 1.40707240e-01f, 6.58531785e-02f, -9.73252021e-03f, -3.40905279e-01f, -7.33699128e-02f, 7.51414010e-03f, 8.88052061e-02f, 2.47779220e-01f, 1.18904598e-01f,
  2.84428418e-01f, 9.58599970e-02f, 2.81205833e-01f, 2.43676066e-01f, -5.44218533e-03f, 4.57899310e-02f, 4.32399288e-02f, 1.08545102e-01f, 8.35438594e-02f, 1.41713575e-01f,
  2.20477149e-01f, 1.77453697e-01f, -1.24168724e-01f, 3.11010599e-01f, -1.61245063e-01f, -3.13478321e-01f, 2.00208142e-01f, -2.13305846e-01f, 5.87634780e-02f, 1.93770081e-01f,
  1.50656477e-01f, 8.92855823e-02f, 6.00742400e-01f, 1.38688207e-01f, -1.31273776e-01f, -7.86139593e-02f, 4.41153914e-01f, -1.47734694e-02f, 1.24989420e-01f, -1.49927914e-01f,
  -4.55418006e-02f, -5.42894900e-02f, 4.44583148e-02f, 2.07038820e-01f, -9.91860256e-02f, 4.14312690e-01f, 1.58252686e-01f, 3.94602269e-02f, 3.16050917e-01f, 3.77905928e-02f,
  8.23426098e-02f, -1.47790253e-01f, 3.27612489e-01f, 1.06836125e-01f, 2.74996273e-02f, -2.79461503e-01f, 2.82209873e-01f, 1.95372209e-01f, -4.46637273e-02f, 1.97648317e-01f,
  3.65948945e-01f, -1.86989889e-01f, 2.86364615e-01f, 2.91476399e-01f, -3.19073983e-02f, 7.18724877e-02f, 3.84478062e-01f, 1.23471282e-01f, -1.32162511e-01f, 2.01570820e-02f,
  1.34275228e-01f, 1.87956020e-01f, 1.04371272e-01f, 3.05883914e-01f, 1.08386353e-01f, -1.59429554e-02f, -1.01844147e-02f, -3.47421974e-01f, -7.09838187e-03f, 2.57375300e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.14127833e-01f, -1.95874088e-02f, 3.22733760e-01f, 2.54100591e-01f, 2.56339908e-01f, 2.17718571e-01f, 1.37352452e-01f, -5.25279492e-02f, 7.05875978e-02f, 9.18818265e-02f,
  1.89968348e-01f, 3.79047990e-01f, 2.51028806e-01f, 3.55598599e-01f, -7.92165846e-02f, 2.72651445e-02f, -1.78662062e-01f, 7.57732466e-02f, 1.85419172e-02f, 9.06935856e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.39757318e-02f, -3.19980383e-01f, -1.41037166e-01f, -2.29895443e-01f, 8.79736170e-02f, -6.41794279e-02f, -5.54524064e-02f, 1.51912048e-01f, 2.49949798e-01f, 2.31050085e-02f,
  -2.89867781e-02f, 3.62435520e-01f, -4.18006659e-01f, -1.31073862e-01f, 1.62604645e-01f, 9.61530134e-02f, 9.08615217e-02f, 1.14293694e-01f, 2.83962995e-01f, 8.51667970e-02f,
  -8.09527561e-02f, -1.37577668e-01f, -1.19811349e-01f, -2.57172137e-01f, 1.41753376e-01f, 2.10153252e-01f, 1.06017821e-01f, -9.98448879e-02f, -6.53130189e-02f, 6.50758445e-02f,
  5.11861928e-02f, 2.07407288e-02f, 2.07864732e-01f, 2.16432124e-01f, 9.79724899e-02f, -4.26647514e-02f, 1.75318018e-01f, 1.64110839e-01f, -1.20971520e-02f, 1.79236308e-01f,
  4.05470043e-01f, -3.75269055e-01f, -1.80396996e-02f, -2.49627486e-01f, -1.58779621e-01f, -1.70491248e-01f, 2.16185227e-01f, -5.37234508e-02f, -1.30624205e-01f, -2.75532544e-01f,
  -2.57520191e-02f, -1.66497231e-02f, 1.73347890e-01f, -2.06371248e-02f, 1.88108956e-04f, -4.06008922e-02f, -4.26236056e-02f, 2.21192524e-01f, -1.19782180e-01f, 1.82473455e-02f,
  -1.28359601e-01f, -5.08969510e-03f, 3.59698415e-01f, -2.58349121e-01f, -4.76329289e-02f, -8.58061295e-03f, -5.65570630e-02f, 8.72795209e-02f, 1.92406401e-02f, 2.07384810e-01f,
  -2.33696654e-01f, 3.10222119e-01f, -6.02407642e-02f, -2.26150185e-01f, 1.25283390e-01f, 3.72973591e-01f, -2.31915131e-01f, 2.26285402e-02f, 3.59688103e-01f, -5.03211580e-02f,
  4.20023128e-02f, -3.39774728e-01f, 7.42572621e-02f, 2.00304866e-01f, 2.16955528e-01f, 1.38666451e-01f, -1.22228533e-01f, 9.29895137e-03f, -8.92793294e-03f, 1.98165759e-01f,
  3.19646262e-02f, 1.58641204e-01f, 1.12843871e-01f, 1.84499443e-01f, -1.36614352e-01f, -3.01694840e-01f, 1.61609516e-01f, 1.39550731e-01f, -7.20615685e-02f, -7.07169324e-02f,
  -1.91396266e-01f, -3.16890955e-01f, -1.65843740e-01f, 2.32941788e-02f, 3.44952673e-01f, -2.16429293e-01f, -1.28635928e-01f, -4.09382313e-01f, 3.21482509e-01f, 7.60348737e-02f,
  -1.98790088e-01f, -2.61585563e-01f, 1.75067037e-01f, -4.37288135e-02f, -2.56234091e-02f, 4.45682444e-02f, -5.77957407e-02f, 1.02241263e-01f, 1.91924423e-01f, -2.57140934e-01f,
  2.28505775e-01f, -2.32152045e-01f, -1.90618664e-01f, -9.57470089e-02f, -5.27112968e-02f, -3.17674071e-01f, 1.24319859e-01f, -1.19707815e-01f, -1.71868309e-01f, -2.88666114e-02f,
  -1.40012369e-01f, -7.41046518e-02f, -1.87822193e-01f, -1.55699626e-01f, 2.89108995e-02f, 1.94704100e-01f, -1.10448666e-01f, 3.75591636e-01f, 1.66864827e-01f, 3.90425235e-01f,
  4.85142954e-02f, 2.15451401e-02f, -1.11021355e-01f, 1.54859528e-01f, 2.74594873e-01f, 2.18740821e-01f, -1.51338562e-01f, 1.75861139e-02f, -2.94335280e-02f, 1.64004847e-01f,
  1.84602633e-01f, 3.79858948e-02f, -1.52286291e-01f, 4.68892269e-02f, -9.85247120e-02f, 6.00188076e-02f, 1.70592517e-01f, 1.74422488e-01f, -3.64508063e-01f, -1.24920465e-01f,
  6.51279092e-02f, -1.69208422e-01f, -2.79860105e-02f, -2.49239564e-01f, -2.20644444e-01f, 3.12034134e-02f, -4.14001308e-02f, 4.87345815e-01f, -7.01745898e-02f, -5.31773549e-03f,
  -6.78518414e-02f, -5.60448058e-02f, 1.95985183e-01f, -1.17341422e-01f, 6.99816123e-02f, -3.42328548e-01f, 4.40121070e-02f, 2.72562563e-01f, -1.26324482e-02f, -9.34023112e-02f,
  3.48074913e-01f, -5.15513532e-02f, 2.27931932e-01f, -6.64554536e-02f, -3.17563891e-01f, -5.65171707e-03f, -7.67407997e-04f, 3.57766785e-02f, 2.58920100e-02f, -2.02616490e-02f,
  -3.38824908e-03f, -1.68683410e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.52306914e-01f, 1.66705921e-01f, -1.62536576e-01f, -4.92419973e-02f, -1.00853354e-01f, -2.04226360e-01f, 1.69164464e-01f, -1.43838525e-01f, 1.67299202e-03f, -2.07004979e-01f,
  -1.18249141e-01f, -9.89580676e-02f, 3.03112328e-01f, -9.29472446e-02f, -1.03153855e-01f, -6.29265308e-02f, 2.24960987e-02f, 1.22891888e-01f, -3.87496091e-02f, -3.45869474e-02f,
  1.18550509e-02f, 2.29950875e-01f, -8.59666318e-02f, 7.55423382e-02f, 3.78125012e-02f, -2.93232524e-03f, -1.93779692e-01f, 1.21401101e-02f, -6.72939569e-02f, 9.99836028e-02f,
  9.54387337e-02f, 1.59736127e-01f, -1.46904275e-01f, 1.17976345e-01f, 2.60109216e-01f, -2.20771194e-01f, -4.21656407e-02f, 1.15585245e-01f, 2.46756956e-01f, 1.52978405e-01f,
  1.56289544e-02f, 2.89028108e-01f, 2.06489339e-01f, 1.28240436e-01f, 1.32156357e-01f, 9.99420434e-02f, -2.85373598e-01f, 8.40750188e-02f, 5.78747749e-01f, 1.02017641e+00f,
  1.80925671e-02f, 2.12566942e-01f, 1.00492053e-01f, -1.33142844e-01f, 3.86946976e-01f, 4.28093344e-01f, -1.89057916e-01f, 7.03287795e-02f, 1.63247719e-01f, 1.40960023e-01f,
  1.71165615e-01f, -1.76063418e-01f, 1.73871845e-01f, 3.00227225e-01f, 1.56872079e-01f, 1.04700722e-01f, 1.33525461e-01f, -1.73746228e-01f, -1.40165627e-01f, -5.23453727e-02f,
  -8.99733901e-02f, 1.17057815e-01f, -3.31806019e-02f, 2.52162427e-01f, 1.21266171e-01f, -1.37957409e-01f, 3.35163996e-02f, -1.47277921e-01f, -2.10617840e-01f, 9.03432965e-02f,
  3.15707982e-01f, 4.33510393e-01f, -1.66049480e-01f, 2.49507189e-01f, 5.24654286e-03f, 6.10997081e-02f, 2.80031800e-01f, -1.74621101e-02f, -3.13300550e-01f, -6.89071566e-02f,
  1.06416196e-01f, -2.33556088e-02f, -1.75892696e-01f, 4.62042838e-02f, 9.91220996e-02f, 6.61664158e-02f, 3.64881843e-01f, 5.27129173e-02f, 2.67557114e-01f, 1.81692868e-01f,
  9.00262520e-02f, 3.98511052e-01f, 3.42504859e-01f, -7.68131092e-02f, -2.16477439e-02f, 2.41238058e-01f, -7.41095468e-03f, -1.35668114e-01f, 1.87254041e-01f, -1.07369937e-01f,
  -2.72469789e-01f, 1.74931183e-01f, -3.08927983e-01f, 4.43065912e-02f, 4.71505970e-02f, -5.88702783e-02f, -1.57169119e-01f, -3.15594859e-02f, 2.52200693e-01f, 1.76848114e-01f,
  3.41598749e-01f, 2.06054032e-01f, -1.29119948e-01f, 7.54891569e-03f, 7.05228597e-02f, 2.00847179e-01f, -1.31508112e-01f, 1.58750340e-01f, 7.33937770e-02f, 3.46474290e-01f,
  2.38470867e-01f, -3.96505930e-02f, 1.96531326e-01f, 2.37663195e-01f, 4.94395085e-02f, 2.81788260e-01f, -1.75568964e-02f, 3.17471594e-01f, -2.03168944e-01f, 1.60215646e-01f,
  6.84505627e-02f, -1.67788371e-01f, 7.53427669e-02f, 2.79342532e-01f, 4.50352356e-02f, 3.42581213e-01f, -2.48622447e-01f, 8.36326256e-02f, -7.80975968e-02f, 1.03286579e-01f,
  1.02825621e-02f, 2.48235911e-01f, -4.35284734e-01f, 3.09871525e-01f, 9.35346540e-03f, -1.52596518e-01f, -1.58488676e-01f, 3.58038664e-01f, 2.88189083e-01f, -1.45393670e-01f,
  -2.04696283e-02f, -7.69444630e-02f, 1.48294726e-02f, -1.75893500e-01f, 8.80833268e-02f, -2.19775379e-01f, -7.71179423e-02f, 9.73733068e-02f, 6.84982240e-02f, -3.09053391e-01f,
  -1.31047428e-01f, -1.40169293e-01f, 2.14016631e-01f, 7.32442662e-02f, 1.71568349e-01f, -1.03546634e-01f, 5.22607327e-01f, 2.01553375e-01f, 7.84271583e-03f, 1.94929875e-02f,
  1.14016883e-01f, -4.10398170e-02f, -2.71188002e-02f, -2.69138049e-02f, -1.20689817e-01f, 8.66572484e-02f, 3.62725481e-02f, 2.56787743e-02f, -7.75790140e-02f, -6.58596084e-02f,
  3.67957562e-01f, 8.31625611e-02f, -1.06998784e-02f, -8.11907947e-02f, 2.49319430e-02f, -1.76068038e-01f, -1.42765552e-01f, -1.43577605e-02f, -5.29031269e-02f, -4.60797399e-02f,
  6.15422167e-02f, -1.08680427e-01f, 1.06106855e-01f, -1.46052450e-01f, 3.00368597e-03f, 1.62935397e-03f, -1.72196180e-01f, -8.60692263e-02f, 1.02259196e-01f, 4.27967086e-02f,
  -1.02689736e-01f, 9.63098854e-02f, -9.43617895e-02f, -1.75200641e-01f, 1.13990873e-01f, -1.80967435e-01f, 8.10617805e-02f, 1.45343840e-01f, -2.08256785e-02f, -1.49978399e-01f,
  -1.08397484e-01f, -1.51998848e-01f, -4.83514480e-02f, -4.99399975e-02f, 1.13286134e-02f, -1.52998492e-02f, 2.73222998e-02f, -6.05051555e-02f, -2.42043491e-02f, -1.25078201e-01f,
  2.19566286e-01f, -2.38693431e-01f, 2.44657099e-01f, 4.29854058e-02f, -2.49545142e-01f, -2.24085212e-01f, -1.99415892e-01f, -6.84374571e-02f, -1.97761822e-02f, 2.52649099e-01f,
  1.29579127e-01f, 1.03123903e-01f, 1.02383666e-01f, 9.39278975e-02f, -1.60904393e-01f, -2.55155321e-02f, 2.06875786e-01f, 2.13104650e-01f, 1.05940662e-01f, 7.35993758e-02f,
  -1.08011857e-01f, 4.81162742e-02f, 1.26622856e-01f, 1.71030432e-01f, 1.51047915e-01f, -7.52838841e-03f, 3.49432677e-01f, -4.80059944e-02f, 1.06913000e-01f, 5.31471930e-02f,
  1.35207742e-01f, 2.13102475e-01f, 7.93802887e-02f, -5.00945926e-01f, -4.40264344e-01f, -3.78193468e-01f, 3.58000517e-01f, 7.58227855e-02f, 1.63654730e-01f, 5.27447313e-02f,
  4.03324574e-01f, -2.44306102e-02f, -2.51269013e-01f, -3.95591073e-02f, -2.56084781e-02f, 1.00371480e-01f, -1.11887664e-01f, -1.64498627e-01f, -3.03757787e-01f, 1.60021201e-01f,
  6.99760616e-01f, -1.21516973e-01f, 7.53492787e-02f, -9.16526914e-02f, 5.16352663e-03f, 6.80840611e-02f, -1.98010281e-01f, 3.73642266e-01f, 7.15521425e-02f, -1.82316557e-01f,
  -1.01550348e-01f, -1.80444047e-01f, 8.27369019e-02f, 5.39222732e-02f, 7.11430311e-02f, -9.14440379e-02f, -9.25002843e-02f, 2.76187398e-02f, 1.33308962e-01f, -1.34041429e-01f,
  8.34691823e-02f, 1.57504424e-01f, 1.10377714e-01f, -9.71554145e-02f, -3.11701279e-02f, -1.03409790e-01f, 1.11392669e-01f, -9.83589366e-02f, 1.19180866e-01f, 4.92752157e-02f,
  7.93003011e-03f, 7.75489509e-02f, -1.84179664e-01f, -1.41315356e-01f, -4.31157872e-02f, 7.58509263e-02f, 4.90145870e-02f, -2.20588520e-02f, -1.46615967e-01f, -1.87105294e-02f,
  2.07646424e-03f, -6.46605417e-02f, 1.06891012e-02f, 5.86979464e-02f, -1.25961006e-02f, -2.32343107e-01f, 4.07876931e-02f, 1.73756614e-01f, -2.45811388e-01f, -2.02762172e-01f,
  2.69233495e-01f, 1.48353741e-01f, -2.18190160e-02f, 1.34926513e-01f, 4.55256969e-01f, -3.14749688e-01f, 2.33397931e-01f, 4.07904774e-01f, 2.95999199e-01f, 1.14555307e-01f,
  -6.97803264e-03f, 9.13644210e-02f, -1.08022012e-01f, -1.67175755e-01f, 2.16610521e-01f, 5.86256608e-02f, 1.36266023e-01f, 8.26226696e-02f, 1.11662142e-01f, -2.31317282e-01f,
  1.48163870e-01f, 3.83323640e-01f, -1.17337711e-01f, -3.59722674e-02f, -9.25629660e-02f, -6.43519498e-03f, 5.91884218e-02f, 1.78760812e-02f, -1.63080394e-01f, -1.08029805e-01f,
  -3.55558433e-02f, 3.05317994e-02f, 5.59038371e-02f, -5.69039956e-02f, -9.90918726e-02f, -4.23526838e-02f, 1.66351721e-02f, 1.68550257e-02f, 1.65115058e-01f, 1.59957871e-01f,
  9.82241482e-02f, 1.09711640e-01f, -1.54084712e-01f, 1.36117309e-01f, 2.44088117e-02f, -1.35707721e-01f, -1.70759521e-02f, -1.33687928e-01f, -1.50633037e-01f, 1.05788194e-01f,
  -2.79559325e-02f, 2.27541942e-02f, -2.31723040e-02f, -1.27958104e-01f, -1.99501328e-02f, -1.58849880e-01f, -1.53699562e-01f, 1.75025031e-01f, -5.52403852e-02f, -9.35446247e-02f,
  6.71119839e-02f, -1.72243044e-01f, -7.62477219e-02f, -1.08143397e-01f, 8.02356973e-02f, -1.13620974e-01f, -1.53063133e-01f, -1.31436467e-01f, 1.62343293e-01f, -3.29513997e-02f,
  -1.60848796e-01f, 1.25140175e-01f, 1.20628402e-02f, 1.21325411e-01f, -4.40902300e-02f, 4.52134460e-02f, 7.64072826e-03f, -1.44967273e-01f, -1.41514301e-01f, -1.69026896e-01f,
  -3.55721684e-03f, -1.58824489e-01f, 8.03005882e-03f, 1.13252379e-01f, -1.44460872e-01f, -1.17224284e-01f, 3.52776706e-01f, 1.83247954e-01f, 2.19274908e-01f, 3.47345844e-02f,
  -3.06106992e-02f, 5.68263084e-02f, -1.50777847e-01f, -2.79964581e-02f, 2.20303666e-02f, -1.66418687e-01f, -1.14359662e-01f, -4.13964838e-01f, 5.13282537e-01f, -1.26832202e-01f,
  -2.77798206e-01f, 7.05532730e-02f, 8.79376084e-02f, -2.09230036e-01f, -1.84396818e-01f, 3.73464935e-02f, 2.41519995e-02f, 2.37019733e-01f, 1.96924180e-01f, 3.49557936e-01f,
  2.28937894e-01f, -1.38309402e-02f, 8.08549821e-02f, 1.68350741e-01f, 2.65866462e-02f, 1.79537505e-01f, 1.33219123e-01f, -1.31103352e-01f, 2.78993398e-01f, 3.14150304e-02f,
  3.81589204e-01f, 3.06293130e-01f, 3.52812171e-01f, 3.54686201e-01f, -3.06710929e-01f, 4.79436189e-01f, -3.15446444e-02f, -5.73756874e-01f, -1.91543877e-01f, -6.15960434e-02f,
  -2.66883075e-01f, 6.61730096e-02f, 8.46794665e-01f, 1.33799136e-01f, 3.50450724e-01f, -3.82404834e-01f, 1.54309988e-01f, 1.03317112e-01f, 5.30899823e-01f, -2.46830638e-02f,
  -2.94526070e-01f, 1.00103252e-01f, 2.02298731e-01f, 5.82404852e-01f, -6.13684133e-02f, -1.39121816e-01f, 1.59099832e-01f, 1.94180802e-01f, 6.42347515e-01f, -3.43869150e-01f,
  1.83364574e-03f, 2.72190094e-01f, 3.04876804e-01f, 2.58452624e-01f, 6.87660724e-02f, 3.47382635e-01f, 1.01146504e-01f, -2.85622805e-01f, -1.59007266e-01f, 1.08213313e-01f,
  -2.03390971e-01f, 2.66906142e-01f, -9.93292928e-02f, -5.40892743e-02f, 2.60718137e-01f, 4.46286052e-01f, -9.00904555e-03f, -9.14424732e-02f, 5.29300645e-02f, -1.27249390e-01f,
  -1.43157676e-01f, -2.11641550e-01f, -3.66102979e-02f, 3.08470875e-01f, -7.52232745e-02f, 2.93653250e-01f, 6.90732300e-02f, -7.83923045e-02f, 3.98484841e-02f, 2.30168045e-01f,
  -1.35128081e-01f, -1.01524644e-01f, 1.04923353e-01f, -1.24247156e-01f, -2.22271591e-01f, 1.14338301e-01f, 2.33170420e-01f, 1.92293093e-01f, -7.27637345e-03f, -1.86977983e-01f,
  -8.71885002e-01f, 2.43966505e-01f, 4.63259280e-01f, 5.56597114e-01f, 4.09074992e-01f, 1.41472727e-01f, 4.36717689e-01f, -2.17653438e-01f, -8.27072114e-02f, 1.84219465e-01f,
  1.69055656e-01f, 2.59378344e-01f, 1.65783226e-01f, -1.00329332e-01f, 2.29466736e-01f, 2.99096793e-01f, 6.47986531e-01f, -2.58388132e-01f, 1.29069194e-01f, -5.95633835e-02f,
  1.10862195e-01f, 1.77353278e-01f, -3.14064741e-01f, 6.05266392e-01f, 1.08579777e-01f, 2.09507853e-01f, -2.85484903e-02f, 5.95208071e-02f, 1.13739215e-01f, -9.64597613e-02f,
  -1.10521622e-01f, -4.02080864e-02f, 1.56585932e-01f, 1.03151664e-01f, -1.46517709e-01f, -8.52623582e-02f, 3.19286078e-01f, -9.92877111e-02f, -1.90438643e-01f, 2.90139522e-02f,
  -1.29579991e-01f, -4.03575134e-04f, 8.64426643e-02f, -1.75971016e-01f, 3.20467614e-02f, 1.67040706e-01f, 1.37746483e-01f, -1.68659852e-03f, 3.69527102e-01f, 8.30148980e-02f,
  -1.36028275e-01f, -4.91187759e-02f, -1.34302109e-01f, -1.25080764e-01f, 7.15893954e-02f, 2.01047629e-01f, 3.58368546e-01f, 1.79351047e-01f, 2.72190839e-01f, 2.98584968e-01f,
  3.82585526e-01f, 2.04905301e-01f, 3.88673306e-01f, -4.22307611e-01f, -6.09971620e-02f, 2.18610287e-01f, -2.34831542e-01f, 1.63988307e-01f, -3.00195038e-01f, -1.38197348e-01f,
  7.58743361e-02f, 3.81372869e-01f, -1.77660689e-01f, 5.32524213e-02f, 2.58247912e-01f, -6.58613956e-03f, -1.79648459e-01f, -2.30546907e-01f, -1.25077024e-01f, 4.05506968e-01f,
  1.48862571e-01f, 3.20501715e-01f, 6.48552738e-03f, 1.13817260e-01f, 1.53882012e-01f, 4.91010875e-01f, -1.49200693e-01f, -1.51607081e-01f, 2.06802487e-01f, 4.73011643e-01f,
  1.08341388e-01f, 4.40519989e-01f, 7.13277236e-02f, 1.23929136e-01f, 4.49266404e-01f, -4.94266599e-01f, 2.75124192e-01f, -7.31420517e-02f, -3.84510517e-01f, -5.57645977e-01f,
  6.79851770e-01f, -4.51013409e-02f, -4.66641873e-01f, 3.79833788e-01f, -1.67892829e-01f, 7.27125385e-04f, -9.49428901e-02f, -2.79156804e-01f, -2.55433947e-01f, -7.82500356e-02f,
  3.52779180e-01f, 3.60257749e-04f, 4.88164395e-01f, -6.29613400e-02f, -2.81012971e-02f, -1.63588062e-01f, -3.52572948e-02f, -2.77920097e-01f, 1.32660195e-01f, 1.82532728e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  1.82750627e-01f, 1.16652258e-01f, 9.70466733e-02f, 1.50151610e-01f, 3.05762708e-01f, 3.06541529e-02f, -6.68436810e-02f, -6.55590147e-02f, 2.51823127e-01f, -1.94320172e-01f,
  -3.20797078e-02f, -1.40847027e-01f, -2.50721071e-02f, 1.27231330e-01f, 4.88788188e-01f, 2.33425781e-01f, 2.79471904e-01f, -3.40627357e-02f, 4.12889570e-01f, 4.21465307e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -5.32310367e-01f, 3.97518352e-02f, -1.98800433e-02f, -3.83935958e-01f, 1.13810956e-01f, -1.40031353e-01f, -3.76466870e-01f, -3.31413537e-01f, -1.62913769e-01f, 5.38427413e-01f,
  -2.39239112e-02f, 1.92762837e-02f, 2.47033015e-01f, -1.45065561e-01f, 6.37347475e-02f, 2.46264651e-01f, -4.54262286e-01f, 1.01973459e-01f, -5.31903096e-02f, -1.71589404e-02f,
  2.56824076e-01f, -7.42909759e-02f, 9.49909445e-03f, 1.29973844e-01f, 3.43722366e-02f, 3.91548634e-01f, -5.62917292e-01f, -5.35262942e-01f, 4.45425421e-01f, 4.28712308e-01f,
  -3.85681748e-01f, 5.30245006e-01f, 2.49938905e-01f, 6.26779348e-02f, 2.87106872e-01f, 3.98241222e-01f, 2.52563566e-01f, 2.70832404e-02f, -2.87222385e-01f, 1.91207558e-01f,
  6.01453662e-01f, 4.31438714e-01f, -9.93309096e-02f, 3.98445845e-01f, 1.78224519e-02f, 2.12019652e-01f, -6.14468493e-02f, -2.43784428e-01f, -2.99329132e-01f, 2.23005295e-01f,
  8.23852234e-03f, -1.90283135e-01f, 2.12368250e-01f, -1.32024392e-01f, 2.86511064e-01f, 1.18336067e-01f, -1.71791703e-01f, 3.47284615e-01f, 4.18766499e-01f, -4.34091121e-01f,
  3.57278734e-01f, 4.75249290e-02f, -5.19010305e-01f, -2.87512004e-01f, 1.93408076e-02f, -9.13047343e-02f, -6.34678960e-01f, -3.24284852e-01f, 3.19578081e-01f, 1.84339568e-01f,
  5.77774167e-01f, 3.16129118e-01f, 2.54114985e-01f, -3.07899117e-01f, 2.04859316e-01f, 2.31016472e-01f, -1.85272679e-01f, -3.96657676e-01f, -6.22719675e-02f, -5.71057320e-01f,
  2.68362015e-01f, 1.65895432e-01f, 1.38610184e-01f, -2.20911086e-01f, -4.04227942e-01f, -7.28972256e-02f, 1.27668768e-01f, 1.43884957e-01f, 1.26141310e-01f, -2.67389536e-01f,
  8.23973358e-01f, 3.36066216e-01f, 1.39354050e-01f, -1.64080426e-01f, -5.16190752e-02f, -4.14552808e-01f, -6.35179505e-02f, 2.21076742e-01f, -5.06542027e-01f, 9.77245197e-02f,
  -1.92011908e-01f, 1.69835195e-01f, -5.08071542e-01f, -2.73520350e-01f, -4.47803736e-01f, -1.69558227e-01f, 7.36731365e-02f, 7.28573184e-04f, 2.24781968e-02f, 6.45648479e-01f,
  4.18727547e-01f, 5.90035580e-02f, 3.22025627e-01f, 1.08686551e-01f, 5.86726405e-02f, 3.37642074e-01f, -5.73363304e-01f, 6.18767440e-02f, -1.64525717e-01f, -7.28854463e-02f,
  1.04860961e-01f, 3.40488255e-02f, -6.26507103e-01f, 2.45494619e-01f, -5.24788439e-01f, -7.08993524e-02f, 2.36376554e-01f, 4.16799307e-01f, 1.37869135e-01f, -1.74639016e-01f,
  -2.18581438e-01f, 1.48619544e-02f, 2.02049032e-01f, 3.04874945e-02f, 1.19306013e-01f, -3.45392257e-01f, -4.05855626e-01f, 4.47759293e-02f, 3.79820406e-01f, -7.59237409e-02f,
  -2.09319174e-01f, 5.13613701e-01f, -1.22063458e-01f, 5.26428163e-01f, -9.78337601e-02f, -3.63194466e-01f, 3.85407358e-02f, 1.40546620e-01f, -1.11459464e-01f, -2.72448473e-02f,
  1.98181868e-02f, -1.68563187e-01f, 1.50996700e-01f, -3.17790955e-01f, -7.22851694e-01f, 9.12030488e-02f, 5.60207844e-01f, 1.72722027e-01f, 5.02009869e-01f, 1.95782840e-01f,
  1.60202816e-01f, 5.18242240e-01f, 5.92827857e-01f, 4.71141636e-01f, 4.38789342e-04f, -8.94343033e-02f, -4.56263989e-01f, -1.90716088e-01f, -2.84609586e-01f, -2.53331810e-01f,
  -1.23546183e-01f, -2.41976753e-01f, -1.19819731e-01f, -4.24602151e-01f, -2.84277260e-01f, 2.41335064e-01f, 2.68227179e-02f, -3.65675390e-01f, 1.68109968e-01f, -2.40869328e-01f,
  4.62288767e-01f, -1.64483503e-01f, -1.61037281e-01f, -6.53251782e-02f, 1.70292944e-01f, 8.52056220e-02f, -1.45655230e-01f, 3.37548971e-01f, 3.97070557e-01f, 6.87692314e-02f,
  3.26606959e-01f, 6.99397564e-01f, 2.31373772e-01f, -2.24031076e-01f, 1.45189064e-02f, -1.49686620e-01f, 1.01143764e-02f, -1.77124843e-01f, 1.64282635e-01f, 4.19965506e-01f,
  6.30370557e-01f, -1.50436684e-01f, -3.34880412e-01f, -2.93522179e-01f, -1.71569586e-01f, -7.33711064e-01f, -3.51553503e-03f, 2.72074103e-01f, 9.61110070e-02f, -3.28159899e-01f,
  1.37100041e-01f, 1.25680238e-01f, 4.41927910e-01f, 8.89835656e-02f, -3.61124218e-01f, 5.76983206e-02f, -1.63523018e-01f, -2.31761672e-02f, 5.81799805e-01f, 4.36204255e-01f,
  -2.79066771e-01f, 8.93467106e-03f, 6.65673733e-01f, -2.65806764e-01f, -1.66579504e-02f, -3.61337483e-01f, -1.92233801e-01f, -5.85991219e-02f, -8.09079856e-02f, -5.48931994e-02f,
  -2.24818885e-02f, -4.81653899e-01f, -2.45280579e-01f, 7.67941847e-02f, 2.18844891e-01f, 1.07910022e-01f, 2.04349265e-01f, 6.30872309e-01f, 4.38470721e-01f, -3.50238323e-01f,
  2.36436754e-01f, 1.95593506e-01f, -1.57689884e-01f, -1.55014008e-01f, -1.97055116e-02f, -5.81083894e-02f, 3.40077102e-01f, -6.03359379e-02f, -3.59720178e-02f, -4.54694360e-01f,
  -6.78807020e-01f, -2.54678071e-01f, 2.78831303e-01f, -2.15883628e-01f, -3.50507140e-01f, -4.38005656e-01f, -3.05164278e-01f, -6.54308558e-01f, 5.54758422e-02f, 2.40805820e-01f,
  -2.97461241e-01f, -1.83572859e-01f, 4.33842808e-01f, 5.94547614e-02f, 4.87180054e-01f, 1.09104570e-02f, -1.17197938e-01f, 2.00361252e-01f, 4.69028577e-02f, 1.67516246e-01f,
  -1.52590098e-02f, -2.71829545e-01f, 7.24106804e-02f, 5.17210186e-01f, 1.60658956e-01f, 1.39049459e-02f, -3.94316345e-01f, 3.44381779e-02f, 3.23528856e-01f, 1.53602874e-02f,
  1.32873952e-01f, -1.93161532e-01f, 8.01962256e-01f, -2.51788974e-01f, -8.50420654e-01f, -5.72320037e-02f, -5.34756541e-01f, -3.22186388e-02f, -1.96235210e-01f, 8.09953138e-02f,
  9.59238261e-02f, -1.95428520e-01f, 1.38630077e-01f, -1.08454652e-01f, 5.38835764e-01f, -3.47493678e-01f, 2.25994438e-01f, -1.89834788e-01f, -4.10331786e-03f, -3.17427397e-01f,
  -2.01355338e-01f, -1.90067798e-01f, -1.30096376e-01f, -2.56003529e-01f, -5.52807033e-01f, -1.59066450e-02f, -1.38091579e-01f, 1.34857550e-01f, 6.23178303e-01f, 4.62078191e-02f,
  4.66234237e-01f, -1.63075298e-01f, 1.16720386e-01f, -3.11880976e-01f, -8.92171785e-02f, 8.26599598e-02f, 6.14259243e-01f, -3.17972869e-01f, 3.01281840e-01f, -4.65257704e-01f,
  6.36261255e-02f, 1.88446417e-01f, 5.42034805e-01f, -9.53516588e-02f, 2.19007842e-02f, 5.61807640e-02f, 2.00088099e-01f, 1.20742954e-01f, 1.63200483e-01f, -2.18913943e-01f,
  3.88836563e-01f, 3.69612932e-01f, -2.01491043e-01f, 3.72751981e-01f, 3.60753000e-01f, 1.77285165e-01f, 6.73268497e-01f, -7.41072223e-02f, -6.27577603e-02f, -1.57981124e-02f,
  -5.77010572e-01f, 3.14838625e-02f, -3.84216785e-01f, 1.04601227e-01f, 3.41270305e-02f, 2.31907904e-01f, 2.68726975e-01f, 1.72349453e-01f, -3.33884537e-01f, -1.55780062e-01f,
  3.34425539e-01f, -5.47127843e-01f, 2.92845368e-01f, 9.90033336e-03f, 3.01479042e-01f, 3.94575372e-02f, -4.39811014e-02f, -4.73188981e-02f, -1.35724917e-01f, 4.33290958e-01f,
  -3.42976362e-01f, 4.73971963e-01f, -2.93553710e-01f, -3.61002296e-01f, 1.24384128e-01f, -2.87853122e-01f, -2.05385461e-01f, 1.00509912e-01f, 5.81130981e-02f, 1.63750440e-01f,
  2.74836496e-02f, 4.25366372e-01f, -2.25052431e-01f, 1.39311910e-01f, -4.13038075e-01f, -1.19300656e-01f, -4.00617979e-02f, 4.60192800e-01f, 2.23294660e-01f, 9.11213085e-02f,
  -8.42172623e-01f, 2.51377761e-01f, 3.85746628e-01f, 9.21756089e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.62189141e-01f, -6.51850402e-02f, -4.71049286e-02f, -5.57442242e-03f, -2.49394542e-03f, 6.15598448e-02f, -1.14955850e-01f, -7.15316460e-03f, 1.20564690e-02f, 6.46903785e-03f,
  1.44638807e-01f, 1.00521892e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    