/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.84426761e-01f, 2.44112968e-01f, -3.28889973e-02f, -3.04593742e-01f, 1.39155611e-01f, -2.80087255e-03f, -1.17720969e-01f, 8.53780657e-02f, 1.14164777e-01f, 1.37924552e-01f,
  7.17404932e-02f, -1.98164165e-01f, 3.29778075e-01f, -6.87425733e-02f, -5.33976629e-02f, 2.05626428e-01f, -1.93822309e-01f, -9.55075100e-02f, 9.59555954e-02f, 3.44509892e-02f,
  -2.23296601e-02f, -4.84831166e-03f, -1.93406492e-02f, 7.93322846e-02f, -3.64656672e-02f, -1.73445299e-01f, 2.35071220e-03f, 3.61553170e-02f, -2.73611814e-01f, -2.57552881e-02f,
  -5.99492118e-02f, -1.99077904e-01f, 4.48182002e-02f, -2.24010497e-02f, -2.76030544e-02f, -9.10535753e-02f, -9.67762992e-02f, -1.13531679e-01f, 2.69876719e-02f, -2.81461421e-02f,
  6.30521774e-02f, -7.12320730e-02f, -3.69732901e-02f, 4.70968597e-02f, 2.79284939e-02f, -9.89176109e-02f, 1.94907989e-02f, 1.22744404e-02f, -4.49290462e-02f, -1.35389224e-01f,
  1.07390784e-01f, -4.06013802e-02f, 4.91179153e-02f, -1.16733141e-01f, 1.09452888e-01f, 3.89209539e-02f, -1.11169256e-01f, 4.62913886e-02f, -1.93110093e-01f, -7.45100677e-02f,
  4.36028950e-02f, -1.45145096e-02f, 7.49529973e-02f, 5.20143323e-02f, -2.71169236e-03f, -1.81592014e-02f, 1.17888078e-01f, 2.39604488e-02f, -3.85398674e-03f, -2.89661083e-02f,
  7.82315806e-02f, -2.40869243e-02f, -8.27609841e-03f, -2.08692793e-02f, -1.14847101e-01f, -2.24863905e-02f, -5.85789699e-03f, 4.50721418e-04f, -1.08264089e-01f, -3.68774608e-02f,
  -1.05487205e-01f, 7.39092305e-02f, -1.13238152e-02f, -9.54547059e-03f, 9.76537615e-02f, -2.26902985e-03f, 4.73674480e-03f, -3.65085267e-02f, 4.17768024e-02f, 5.22348769e-02f,
  -8.91147405e-02f, -1.08108975e-01f, 5.86759709e-02f, -1.01685315e-01f, 3.17594670e-02f, 9.89840850e-02f, -3.06376647e-02f, 4.86617535e-02f, 6.70700744e-02f, 8.13990906e-02f,
  -2.54764520e-02f, -1.73427127e-02f, -2.28402540e-02f, -1.73305608e-02f, 2.69471556e-02f, 3.96070406e-02f, 2.75509786e-02f, -4.13667746e-02f, 1.69717725e-02f, 9.80937481e-03f,
  -5.67614771e-02f, 4.93771583e-02f, 1.96185950e-02f, -3.51788774e-02f, -1.29261762e-01f, -3.80331092e-02f, 1.52997319e-02f, -1.21207565e-01f, 9.98909250e-02f, 1.41472509e-02f,
  -3.24793346e-02f, -6.21067882e-01f, -1.89241424e-01f, -2.65655398e-01f, -1.93727091e-02f, -1.98244199e-01f, -1.00084484e-01f, -1.36918902e-01f, -2.82263577e-01f, -6.59817159e-02f,
  -5.47365472e-02f, -1.19591273e-01f, -4.30107750e-02f, -2.56309092e-01f, 4.70840326e-03f, -2.44981989e-01f, 1.40017616e-02f, 6.75486550e-02f, -9.26585793e-02f, 5.99214584e-02f,
  -9.05408189e-02f, 8.20408314e-02f, -6.38333987e-03f, 6.53432012e-02f, 4.12116162e-02f, -1.76902134e-02f, 1.79940000e-01f, -1.80699080e-02f, -4.43761935e-04f, -3.93249094e-02f,
  -3.38670127e-02f, -1.53121531e-01f, 1.69715602e-02f, -2.00139340e-02f, -1.91226369e-03f, 4.20497879e-02f, 4.71038967e-02f, -3.62823764e-03f, -8.19379240e-02f, 2.74785683e-02f,
  2.85693295e-02f, -4.29193564e-02f, -1.70757212e-02f, 3.18043940e-02f, -3.52982176e-03f, -8.44897181e-02f, 1.49533469e-02f, -1.21815072e-03f, -5.67091852e-02f, -4.64079715e-02f,
  -4.20669690e-02f, -3.33880372e-02f, 2.81906724e-02f, -2.61710789e-02f, 3.67676616e-02f, -2.82760989e-02f, 2.39244588e-02f, 7.44831283e-03f, 2.22179797e-02f, -3.45777310e-02f,
  -3.14072073e-02f, 4.12959196e-02f, 5.35063958e-03f, 1.54981241e-02f, -3.91334780e-02f, 1.30421920e-02f, 2.65355129e-02f, 8.72629695e-04f, 3.30304243e-02f, -3.63793299e-02f,
  6.11279644e-02f, 1.01893162e-02f, -2.25676633e-02f, -5.52544743e-02f, 1.68287195e-02f, -8.73516966e-03f, -6.61734119e-02f, 1.83160286e-02f, 7.22478237e-03f, 2.53308136e-02f,
  1.58457868e-02f, -2.26510111e-02f, 3.17877308e-02f, 2.18179263e-02f, -7.03499019e-02f, -9.27272532e-03f, 1.90173415e-03f, -6.42415434e-02f, 2.56450661e-02f, 3.00306603e-02f,
  4.04515564e-02f, 3.39354612e-02f, -4.07941733e-03f, 2.28273124e-02f, -1.01393918e-02f, 7.98691809e-03f, 1.17116692e-02f, -2.83805411e-02f, 6.95805401e-02f, 6.74328255e-03f,
  -2.33498681e-03f, 8.49007815e-02f, 8.63796622e-02f, -2.55289841e-02f, 3.60107422e-02f, 1.35118198e-02f, 6.19382672e-02f, 2.25149915e-02f, 7.12501556e-02f, 3.23487595e-02f,
  4.44964655e-02f, 5.52717485e-02f, -6.65482059e-02f, 8.49384293e-02f, 2.90655885e-02f, 3.89927812e-02f, 3.71604525e-02f, -2.59675318e-03f, 4.41240966e-02f, 5.49528413e-02f,
  3.51691507e-02f, 1.58070594e-01f, 3.00325692e-01f, -1.02564342e-01f, 1.20271496e-01f, 8.32677782e-02f, 1.32966563e-02f, 7.71933198e-02f, 2.37644538e-01f, -1.84824094e-01f,
  -4.55022007e-02f, 1.04318723e-01f, 1.01331651e-01f, -2.52789617e-01f, -7.19039068e-02f, -5.57750172e-04f, -1.86005518e-01f, -9.89308879e-02f, 1.03133671e-01f, -8.83315876e-02f,
  5.84945418e-02f, -3.11996460e-01f, -3.03720515e-02f, -4.09697033e-02f, -5.34595139e-02f, 1.60069779e-01f, -2.01053411e-01f, 1.39071181e-01f, -1.95045486e-01f, -5.00912499e-03f,
  -1.25250190e-01f, 2.62150774e-03f, 4.09432463e-02f, 1.69226397e-02f, 4.76529775e-03f, -2.58035604e-02f, 3.94331068e-02f, 5.23472615e-02f, 1.25159144e-01f, 6.59290850e-02f,
  2.70791836e-02f, 6.14269897e-02f, 6.06960244e-03f, 2.03044154e-02f, -4.44772206e-02f, -1.14830704e-02f, 2.22082157e-02f, 2.52079107e-02f, 5.60205169e-02f, 1.97019633e-02f,
  6.20929077e-02f, -2.35209260e-02f, 1.62731670e-02f, -3.44296470e-02f, 5.23911901e-02f, 6.93451241e-02f, -1.09988749e-02f, 2.53512785e-02f, -3.43235768e-02f, 9.01095755e-03f,
  -8.90030041e-02f, 2.13948134e-02f, -2.69411840e-02f, -3.10198665e-02f, -2.64133234e-02f, 1.31492317e-02f, -3.46969366e-02f, -8.44741240e-03f, 4.79312949e-02f, -4.92704920e-02f,
  3.31956856e-02f, -2.92803231e-03f, -2.59349365e-02f, -5.54832350e-03f, 1.47145474e-02f, -5.62077165e-02f, -2.27777995e-02f, -2.37180721e-02f, 1.46713620e-02f, -1.02406926e-02f,
  -2.97212675e-02f, 2.49768514e-02f, -1.85410585e-02f, -4.93582077e-02f, -1.65262877e-03f, 9.27049853e-03f, -2.18678806e-02f, -4.15808447e-02f, 4.58588265e-02f, -1.51170250e-02f,
  6.61072880e-02f, -4.80003795e-03f, 5.20540290e-02f, 1.24980453e-02f, -2.98071560e-02f, -4.82089408e-02f, -5.37545942e-02f, 1.92368776e-02f, -6.19186042e-03f, -4.10819761e-02f,
  -3.04294825e-02f, -5.02203591e-02f, -4.86579128e-02f, -3.26192379e-02f, 6.67316988e-02f, 1.75894797e-02f, -9.70637947e-02f, 1.98646933e-02f, -6.11598231e-02f, -9.35942400e-03f,
  -3.91926654e-02f, -1.40296957e-02f, 3.57241748e-04f, -4.06873450e-02f, -4.52687703e-02f, -2.73347087e-02f, -1.20413080e-02f, 2.73090061e-02f, -4.70861048e-02f, -1.73649341e-02f,
  -1.99655201e-02f, -4.58129168e-01f, 1.77272558e-01f, -1.99798718e-01f, 3.47199410e-01f, 1.86398596e-01f, -1.61099546e-02f, -4.24644211e-04f, -3.88044380e-02f, -1.45916745e-01f,
  8.15181881e-02f, -3.51272762e-01f, -7.27720782e-02f, -1.96827516e-01f, 2.10927710e-01f, -2.30023250e-01f, 8.51277635e-02f, -1.01539921e-02f, -4.15588282e-02f, 4.04734239e-02f,
  1.06071919e-01f, 5.84865436e-02f, 8.89462084e-02f, 1.07802615e-01f, 1.85269758e-01f, -1.24583654e-02f, 1.42941922e-01f, 1.68235600e-02f, 2.03375239e-02f, -1.23381943e-01f,
  -4.43383567e-02f, -1.95696935e-01f, -5.59659414e-02f, 3.02108731e-02f, 1.90192267e-01f, 1.00846171e-01f, -5.15523106e-02f, 2.17071287e-02f, 4.28940207e-02f, 4.63146232e-02f,
  5.61666908e-03f, 1.05941552e-03f, -4.99375015e-02f, 3.80358882e-02f, 2.02045217e-02f, 8.80944729e-02f, 3.69752757e-02f, 5.92509806e-02f, 1.77807286e-02f, -2.40810681e-02f,
  3.94273587e-02f, 1.43087702e-03f, 9.11349282e-02f, -3.14150080e-02f, 3.37765440e-02f, 4.35248530e-03f, 3.65057997e-02f, 2.68264133e-02f, -3.42796929e-02f, 3.53007615e-02f,
  7.07557499e-02f, 1.59806274e-02f, 2.32895818e-02f, -2.16768216e-03f, 2.72161011e-02f, 1.10075716e-02f, 3.49483527e-02f, -3.50297838e-02f, -6.21411623e-03f, 3.75499986e-02f,
  7.81534414e-04f, -4.11609225e-02f, -8.72104242e-03f, 3.80444713e-02f, 8.22382420e-03f, -6.81792274e-02f, 2.18718648e-02f, -7.21045658e-02f, 9.37074888e-03f, -4.17574942e-02f,
  -1.73456222e-02f, 2.04514917e-02f, -3.10395937e-02f, 7.25147128e-02f, 3.26490426e-03f, 7.50551280e-03f, -6.28319057e-03f, -1.97722130e-02f, 5.83770014e-02f, 3.40196267e-02f,
  8.51791203e-02f, 1.13269918e-01f, -7.28197815e-03f, -4.03143913e-02f, -6.76402301e-02f, -6.20490983e-02f, 2.01998390e-02f, -6.59047514e-02f, 2.79773101e-02f, -1.88301001e-02f,
  8.45855549e-02f, 2.25540008e-02f, 1.11083058e-03f, -1.42618560e-03f, -2.90675703e-02f, -1.03988694e-02f, 3.79084833e-02f, -2.25621853e-02f, 2.02712510e-02f, 1.01694930e-02f,
  1.28018996e-02f, 4.73334566e-02f, 3.51743918e-04f, 1.78533588e-02f, -2.77271271e-02f, 1.15219271e-03f, -8.08557421e-02f, -3.56331989e-02f, 6.73550963e-02f, -4.06717882e-02f,
  -1.91846237e-01f, -5.63287325e-02f, -8.03856831e-03f, -1.43267810e-01f, -1.67498603e-01f, 4.14096355e-01f, 3.89679521e-02f, -6.17676973e-03f, -1.82286099e-01f, 8.14581886e-02f,
  1.11684747e-01f, -1.62442103e-01f, 4.54238914e-02f, 1.61392447e-02f, 2.92134583e-01f, 1.10776953e-01f, 3.13493282e-01f, -2.58872402e-03f, 3.53685464e-04f, -2.50992905e-02f,
  4.66862731e-02f, 1.52705982e-01f, 7.20568225e-02f, -1.73659511e-02f, 1.04061209e-01f, -1.06158808e-01f, 6.25293255e-02f, -6.06358983e-02f, 5.08381575e-02f, 2.88237724e-02f,
  3.11871450e-02f, -1.27606556e-01f, 3.16730589e-02f, -1.65303163e-02f, 8.54351893e-02f, -5.53403571e-02f, 3.85684147e-02f, -6.86582625e-02f, -8.42997953e-02f, 5.68044605e-03f,
  7.62563990e-03f, 5.74745238e-03f, -2.65939832e-02f, 6.94850320e-03f, -9.72995907e-02f, -1.07526645e-01f, -1.64679121e-02f, 4.73911949e-02f, -1.07437208e-01f, -1.28815072e-02f,
  2.30569914e-02f, 1.11175487e-02f, 2.52062082e-02f, -4.71088551e-02f, 1.85762309e-02f, 2.13589445e-02f, 3.83720472e-02f, 1.51026873e-02f, 1.08964788e-02f, -2.50428598e-02f,
  -2.70555746e-02f, -6.83159893e-03f, -4.03434932e-02f, -3.33134867e-02f, -4.32885922e-02f, 3.70089747e-02f, -2.87058111e-02f, -1.65732373e-02f, 3.18375751e-02f, -9.67455562e-03f,
  5.40023036e-02f, -6.83840644e-03f, -5.30886985e-02f, 1.82731748e-02f, 5.30678369e-02f, -3.62325385e-02f, -5.83918579e-02f, 1.81685854e-02f, 5.77180646e-03f, 2.56024431e-02f,
  -3.67020369e-02f, -7.69052003e-03f, -6.42024353e-03f, -3.40959104e-03f, -1.42186861e-02f, -3.73160355e-02f, 4.28844169e-02f, -1.05933379e-02f, -2.81516928e-03f, 4.98657301e-02f,
  1.27783015e-01f, 2.39394188e-01f, -6.25105053e-02f, -4.37574275e-02f, -1.72648784e-02f, 6.90097138e-02f, -2.48362683e-03f, 3.82486582e-02f, 1.09442644e-01f, 6.52349070e-02f,
  1.08853374e-02f, -3.00964657e-02f, 6.68445751e-02f, -5.27353361e-02f, 6.83057085e-02f, 1.34399399e-01f, 5.07473648e-02f, 9.25973058e-03f, 8.73764828e-02f, 2.54453756e-02f,
  4.66805371e-03f, 2.31253058e-02f, -6.22716285e-02f, 3.11351698e-02f, 1.67240184e-02f, 1.92370992e-02f, -1.22269085e-02f, -1.85870510e-02f, -2.84921676e-02f, 7.37415180e-02f,
  -6.78831995e-01f, -1.05417900e-01f, -8.50964859e-02f, -1.26244187e-01f, -5.70038613e-03f, 3.66890192e-01f, -5.94785474e-02f, 6.01697378e-02f, -1.36746556e-01f, 6.35814667e-03f,
  4.67675813e-02f, -5.83393276e-02f, -1.33833811e-01f, 8.18913952e-02f, -4.65220772e-02f, -1.04053825e-01f, -6.83992505e-02f, -3.10342051e-02f, -1.52178043e-02f, -7.51346350e-02f,
  -1.19441748e-01f, 9.49346423e-02f, -6.24461100e-02f, 1.09053835e-01f, -3.64122801e-02f, 4.46282700e-02f, -7.83196762e-02f, 4.34517190e-02f, 1.27283335e-01f, 1.32270083e-01f,
  1.80965960e-01f, 4.01503667e-02f, -3.64331715e-02f, 4.25864793e-02f, -4.39163558e-02f, -1.59341004e-02f, 3.66784371e-02f, 9.30942297e-02f, -8.60542152e-03f, -1.42627647e-02f,
  -2.65210383e-02f, -1.36356587e-02f, -6.24338258e-03f, -7.27368742e-02f, -1.02226427e-02f, 1.10270577e-02f, -1.32369911e-02f, -8.46263580e-03f, 5.01205167e-03f, -4.14203703e-02f,
  -1.05280485e-02f, -1.07813478e-02f, -2.13120971e-02f, 1.53434165e-02f, -3.99167538e-02f, 1.45956883e-02f, 4.43708636e-02f, -1.55565450e-02f, 3.17663164e-03f, 2.16594469e-02f,
  -2.58064829e-03f, 2.03859899e-02f, -2.85591446e-02f, 5.97921535e-02f, 6.74070499e-04f, -3.69847752e-04f, -3.59598943e-03f, -1.60612946e-03f, -5.11740111e-02f, 3.40007134e-02f,
  -9.04964283e-03f, 3.96186812e-03f, 1.74027774e-02f, 3.08558792e-02f, 1.78126764e-04f, 5.86630218e-02f, 7.47536682e-03f, 4.07580733e-02f, -8.25597718e-03f, 4.54875864e-02f,
  -5.54269645e-03f, 3.07582077e-02f, -2.42732335e-02f, 4.36948380e-03f, 7.37606063e-02f, -7.25152902e-03f, 3.67107354e-02f, -2.20803916e-02f, -2.85602808e-02f, -1.34758614e-02f,
  1.31626427e-02f, -3.45732234e-02f, -4.63312538e-03f, 5.50214872e-02f, -8.16040114e-03f, -5.47285017e-04f, 1.31423650e-02f, 2.11481284e-02f, -8.59931558e-02f, 1.13066826e-02f,
  -1.05300425e-02f, 2.11431608e-02f, -2.30089556e-02f, 5.34449331e-02f, 5.98133216e-03f, -3.17811780e-02f, -2.57108919e-02f, 9.44884773e-03f, 2.31138673e-02f, 4.10911534e-03f,
  2.67066481e-03f, -4.38156351e-02f, 1.50057254e-02f, 3.64163704e-02f, 2.43767258e-02f, -2.73704622e-02f, -2.19435245e-02f, 2.47109290e-02f, -1.92227606e-02f, -4.45627756e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.55552530e-01f, -1.81501642e-01f, 4.60322127e-02f, -1.24034926e-01f, 1.13356061e-01f, 3.77670713e-02f, 1.46014914e-01f, -7.84126073e-02f, 2.26949528e-01f, -3.96323204e-01f,
  -2.27167472e-01f, 8.86799693e-02f, 1.84031829e-01f, -3.79741639e-01f, 3.98463458e-01f, 3.48004967e-01f, -2.55386531e-01f, 8.27465430e-02f, 1.78761035e-01f, -1.71961069e-01f,
  6.71882136e-03f, -2.56453931e-01f, -1.73194055e-02f, -4.16347831e-01f, -4.28880543e-01f, -1.20169356e-01f, -2.52770036e-01f, 2.73649935e-02f, -5.38605869e-01f, 3.59135345e-02f,
  -5.04336171e-02f, -1.27297178e-01f, -1.15346089e-01f, -5.36551175e-04f, -1.65172875e-01f, -3.76762450e-02f, -1.97277758e-02f, 9.15337875e-02f, 2.06136648e-02f, -2.02245452e-03f,
  -6.21837601e-02f, 7.10438043e-02f, -2.10954975e-02f, 3.87937203e-02f, -8.47175270e-02f, -8.14133063e-02f, 1.14356957e-01f, -1.51150255e-02f, 6.99699856e-04f, -2.17592418e-02f,
  4.67765816e-02f, -7.45854080e-02f, -5.00293113e-02f, 2.43685879e-02f, -1.65286753e-02f, 3.03800181e-02f, 1.38276577e-01f, 9.16663930e-02f, 4.69050668e-02f, 1.86912604e-02f,
  5.69371879e-02f, 7.34981596e-02f, -2.71372292e-02f, 4.85872701e-02f, 1.74976960e-02f, -1.38611672e-02f, 2.51410324e-02f, 6.40912866e-03f, -5.92498295e-02f, 6.92953868e-03f,
  -8.68291631e-02f, 3.37848440e-02f, 5.22401184e-02f, 1.37512654e-01f, -8.91496018e-02f, 9.86621901e-02f, -1.08127715e-02f, 6.57835826e-02f, -2.97941845e-02f, -1.63160358e-03f,
  -2.61990186e-02f, 5.16061634e-02f, -1.13079697e-01f, -7.90757835e-02f, 1.86289936e-01f, 3.16321626e-02f, 6.17658347e-03f, 8.99159908e-02f, 4.39198725e-02f, -5.78423366e-02f,
  -1.62351474e-01f, -4.27249670e-01f, 5.96258603e-02f, 2.84248926e-02f, 1.17070407e-01f, -1.11753173e-01f, 1.13899261e-02f, -6.42268807e-02f, -5.61295897e-02f, -2.28449926e-02f,
  -7.68590346e-02f, -1.91583242e-02f, 7.52689829e-03f, 4.88353595e-02f, 3.08748474e-03f, -8.03892091e-02f, -1.09143637e-01f, -7.05755353e-02f, -6.59266487e-02f, -6.53273016e-02f,
  -8.31613764e-02f, -2.83258297e-02f, 5.03487028e-02f, -4.10046205e-02f, -4.58930619e-02f, 4.09313068e-02f, -1.03960589e-01f, -9.19524301e-03f, -4.95648235e-02f, 7.30244536e-03f,
  7.14812428e-02f, 5.31276762e-02f, 2.27525413e-01f, 3.02248776e-01f, -6.28376156e-02f, -1.82333604e-01f, 2.88305789e-01f, -1.18599117e-01f, -2.60194331e-01f, -1.23469390e-01f,
  2.81894296e-01f, 1.85129002e-01f, 2.15703920e-01f, 1.66809216e-01f, 6.31803334e-01f, 1.22900650e-01f, -6.88025206e-02f, -7.90115595e-02f, -3.90517041e-02f, 2.24919058e-02f,
  2.72160005e-02f, -4.57555205e-02f, 2.53579348e-01f, 5.61218560e-02f, 4.01156675e-03f, 3.03021185e-02f, 2.79906929e-01f, 1.27051964e-01f, 2.34824300e-01f, 3.70800972e-01f,
  -1.39879048e-01f, -1.77072140e-03f, 6.68068975e-02f, -1.04936972e-01f, -7.58071169e-02f, -1.65753718e-02f, 4.01265696e-02f, 1.80767685e-01f, 2.00855985e-01f, -8.49513113e-02f,
  -5.95821403e-02f, 5.22307307e-02f, -5.16329706e-02f, -7.11808875e-02f, -8.18443894e-02f, -6.26921728e-02f, -8.24613199e-02f, -1.84970163e-02f, 1.03249282e-01f, 2.68878359e-02f,
  -1.58365257e-02f, -2.07039732e-02f, -9.42557082e-02f, 2.75539942e-02f, -3.43171954e-02f, -6.15779534e-02f, -6.82586804e-02f, 9.08292308e-02f, -5.61354421e-02f, -7.85612240e-02f,
  4.71005775e-02f, -1.40506774e-02f, -3.33248451e-02f, 7.18089845e-03f, -2.66317837e-02f, 7.00938702e-02f, -3.46641056e-02f, 6.40973821e-02f, 9.16982070e-02f, 5.62307751e-03f,
  4.15734574e-02f, 4.19442765e-02f, 1.72758400e-02f, -1.30732402e-01f, 1.60819702e-02f, -8.77809376e-02f, 9.23658013e-02f, 5.46449423e-02f, -3.58418114e-02f, -2.39407737e-02f,
  1.84387388e-03f, -3.92847583e-02f, 7.11469874e-02f, -2.06086393e-02f, -6.12500720e-02f, 7.93592036e-02f, 4.53967527e-02f, -2.87439525e-02f, -1.73880849e-02f, 7.39590153e-02f,
  -1.50156841e-01f, 9.20901895e-02f, 7.68593699e-02f, -1.17705520e-02f, -3.59879062e-02f, -8.40018615e-02f, -5.34252115e-02f, -5.76925576e-02f, -1.35564223e-01f, -2.15674611e-03f,
  -8.08580443e-02f, -4.37871255e-02f, -6.72290996e-02f, -6.36177659e-02f, 1.30952880e-01f, -6.13967031e-02f, -5.28916679e-02f, -9.15079005e-03f, -6.57239333e-02f, 3.51413228e-02f,
  -3.43289897e-02f, -1.32009936e-02f, 9.09842327e-02f, -1.17471501e-01f, -7.44329914e-02f, -2.79768948e-02f, 1.24671794e-02f, 5.73070720e-02f, -8.54685009e-02f, -3.55886929e-02f,
  9.28281695e-02f, 8.21534544e-02f, 2.38622248e-01f, 4.11296934e-01f, -1.20762244e-01f, -5.04679441e-01f, -4.74286675e-01f, 1.35536030e-01f, -8.73283576e-03f, -1.68705508e-01f,
  -1.05150521e-01f, -1.47298783e-01f, -1.68991566e-01f, 3.09496015e-01f, 2.48331144e-01f, -1.92508653e-01f, 1.53118730e-01f, -1.16277069e-01f, 5.44477860e-03f, 8.91774744e-02f,
  1.23672076e-01f, 9.65082571e-02f, 3.12474072e-01f, 2.69663125e-01f, 6.35544509e-02f, 2.43188903e-01f, 2.57765710e-01f, -6.06136322e-02f, 3.40083271e-01f, 3.21683474e-02f,
  -4.22344403e-03f, 5.57181016e-02f, 6.68609217e-02f, -6.68569654e-02f, -2.41173757e-03f, -9.24838148e-03f, -3.07245515e-02f, -9.70708728e-02f, -2.24168655e-02f, -3.65648903e-02f,
  -1.86122973e-02f, 7.12952912e-02f, 4.07363512e-02f, 8.71442780e-02f, -7.04100803e-02f, -2.71571465e-02f, 1.20378748e-01f, -3.41264941e-02f, -3.38254049e-02f, -3.03464141e-02f,
  -3.85057107e-02f, 5.67241665e-03f, -4.74683344e-02f, 7.76185989e-02f, 4.86841984e-02f, 8.22821818e-03f, -4.88949418e-02f, 2.71093026e-02f, 2.03763898e-02f, 9.78934690e-02f,
  -5.82228191e-02f, -2.37570554e-02f, -4.41036746e-02f, -9.61138681e-03f, 9.76271462e-03f, -1.35926353e-02f, 1.66818302e-03f, -7.94538930e-02f, 2.68312059e-02f, 2.10380536e-02f,
  3.40701938e-02f, -3.88323963e-02f, -1.49526438e-02f, 1.88468043e-02f, 4.54590917e-02f, -1.17054898e-02f, -2.50188503e-02f, -1.88334920e-02f, -8.01746249e-02f, -2.88819484e-02f,
  2.27713212e-02f, 6.80269897e-02f, -9.02059004e-02f, 2.86252163e-02f, -1.91361066e-02f, -9.40604415e-03f, 2.95435488e-02f, -2.90151667e-02f, 6.19746298e-02f, 3.87888425e-03f,
  5.58404857e-03f, 1.04914702e-01f, -6.67154565e-02f, 1.89363360e-02f, -4.47339639e-02f, -1.10647701e-01f, 7.38717169e-02f, 9.31316689e-02f, 7.30587319e-02f, 3.49671319e-02f,
  4.42704558e-02f, -4.09215242e-02f, -7.62886927e-02f, -8.69660266e-03f, 1.16736203e-01f, 6.65415227e-02f, -9.27241966e-02f, 3.19703408e-02f, 1.26239210e-01f, -5.18339686e-02f,
  -6.91325963e-03f, -1.80055022e-01f, 4.61088866e-02f, -9.69476476e-02f, 4.41099256e-02f, -2.31202040e-02f, -1.42299747e-02f, -4.93867323e-02f, 6.03219904e-02f, -6.43021166e-02f,
  -1.19319153e+00f, 4.34933156e-01f, 2.94932090e-02f, 2.39011705e-01f, -2.88475841e-01f, 6.10402599e-02f, -9.03964415e-03f, -1.03715718e-01f, -1.38348401e-01f, 9.39845443e-02f,
  -1.73149943e-01f, -1.35519043e-01f, 3.76212113e-02f, 1.28527567e-01f, -1.01353198e-01f, 2.79281944e-01f, -9.55362432e-03f, -6.10811114e-02f, 2.26539113e-02f, -3.47331837e-02f,
  -5.23950867e-02f, 8.96935686e-02f, 1.58429727e-01f, 2.60848850e-02f, -7.39711747e-02f, -1.00314736e-01f, -2.51600947e-02f, -2.81657632e-02f, -5.99494297e-03f, -7.12904334e-02f,
  2.26372201e-02f, -1.95120543e-01f, -2.35468149e-02f, -3.64918225e-02f, -6.88566938e-02f, -6.66346177e-02f, 3.62175517e-02f, -1.48823783e-02f, -2.04294790e-02f, -8.43805075e-03f,
  -4.53988276e-02f, -3.98875922e-02f, 5.39310463e-03f, 7.32251070e-03f, -1.82972141e-02f, 7.04228133e-02f, 1.48932502e-01f, 4.51819524e-02f, 1.23107411e-01f, 1.48956135e-01f,
  7.32295439e-02f, 9.34124440e-02f, 7.44754598e-02f, 5.35671785e-02f, 3.01112160e-02f, 2.85141151e-02f, 8.47519264e-02f, -1.34267071e-02f, 3.33467796e-02f, -7.12847039e-02f,
  1.27562359e-02f, -5.64296134e-02f, -1.13499882e-02f, -2.52372939e-02f, 5.80672268e-03f, -4.75651100e-02f, 1.33259427e-02f, -4.15978283e-02f, 1.11153983e-02f, -2.99677551e-02f,
  -4.22593653e-02f, -4.15362008e-02f, -3.57047003e-03f, 2.50743292e-02f, -3.05774175e-02f, 3.10743619e-02f, -5.47654089e-03f, -4.00015488e-02f, -8.81989375e-02f, -3.53443995e-02f,
  2.14515850e-02f, -3.19543444e-02f, -9.05501377e-03f, 1.20761499e-01f, -8.88116192e-03f, 5.61254136e-02f, -6.76029474e-02f, 1.41301095e-01f, 2.39055920e-02f, -5.88527806e-02f,
  -3.92986953e-01f, -1.57090560e-01f, -1.07080871e-02f, -5.06573394e-02f, 8.47605169e-02f, 1.11732623e-02f, -2.14529708e-02f, -1.05594262e-01f, 5.32872416e-02f, -4.05861959e-02f,
  -3.17867957e-02f, 2.60631088e-02f, 9.30023659e-03f, -1.61335599e-02f, -2.03158446e-02f, 2.48690764e-03f, -9.59955975e-02f, -1.07892081e-01f, -8.08904171e-02f, -1.10840037e-01f,
  -6.22184128e-02f, -8.07537660e-02f, 4.97356581e-04f, -2.93874815e-02f, -1.58707406e-02f, -1.35734119e-02f, -1.88860387e-01f, 5.87710850e-02f, -3.40500847e-02f, 2.47071292e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  3.57450843e-01f, -3.76090914e-01f, -3.70857507e-01f, -1.11711398e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.04872055e-01f, 5.40713608e-01f, -3.00714463e-01f, 5.95612749e-02f, -1.07239477e-01f, -3.39227796e-01f, 1.38548121e-01f, -2.73768306e-01f, -7.62728214e-01f, -3.95178437e-01f,
  3.12138200e-02f, -3.27322692e-01f, -7.59133101e-02f, 2.69402638e-02f, 3.20917547e-01f, -2.39498571e-01f, -3.51175845e-01f, 1.56314909e-01f, 6.53000399e-02f, -2.42865756e-01f,
  -3.21007490e-01f, -1.81947231e-01f, -2.55560398e-01f, -3.65675837e-02f, 4.42316830e-01f, -4.92469996e-01f, -7.26074040e-01f, -4.11364526e-01f, -8.80624577e-02f, -5.43099999e-01f,
  1.54540658e-01f, 3.08006606e-03f, -2.74990559e-01f, -5.60773090e-02f, -6.03782833e-01f, -2.54557908e-01f, -1.27986863e-01f, -3.71284068e-01f, 5.78372657e-01f, 7.23186791e-01f,
  -4.17438775e-01f, 1.73742950e-01f, -8.72425660e-02f, 8.91710877e-01f, -2.30945706e-01f, -2.76069131e-05f, -2.25443304e-01f, 3.81987840e-01f, 1.59338892e-01f, -1.46347091e-01f,
  1.19944625e-01f, 1.94945231e-01f, 3.21103990e-01f, 2.75513798e-01f, -4.68891934e-02f, 2.52325088e-01f, 4.80505586e-01f, 9.26752388e-01f, -1.52103961e-01f, 4.32743967e-01f,
  3.30339335e-02f, 4.49648231e-01f, 3.46656740e-01f, -5.53381681e-01f, 1.56818897e-01f, 1.37378350e-01f, 2.31793791e-01f, 5.96240833e-02f, 4.54852618e-02f, -2.81408310e-01f,
  -3.99723262e-01f, 7.72702515e-01f, 3.99391428e-02f, 6.23658717e-01f, -5.87817192e-01f, -2.03098118e-01f, 6.74655512e-02f, 1.98759660e-01f, 2.28333771e-01f, -3.87515217e-01f,
  -1.47094369e-01f, -3.21947873e-01f, 2.95709699e-01f, -7.17141628e-02f, 3.25595856e-01f, -3.92166495e-01f, -1.11665882e-01f, 6.70279264e-01f, 5.14386855e-02f, 1.85361698e-01f,
  7.30919316e-02f, -2.45423410e-02f, 3.89985532e-01f, 5.62864780e-01f, 4.18715268e-01f, -3.63243401e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  9.87338722e-02f, 3.14892791e-02f, -3.70462954e-01f, 5.57414770e-01f, 2.41286188e-01f, -1.70980636e-02f, 3.72594334e-02f, -7.09162280e-02f, -6.37194753e-01f, 3.14084738e-01f,
  3.20523977e-01f, 3.24106008e-01f, -5.84908962e-01f, 1.77765295e-01f, 4.53123420e-01f, -3.98811698e-01f, 1.00530861e-02f, 3.29070002e-01f, 7.16168582e-02f, 2.84108311e-01f,
  1.20084710e-01f, 4.33807850e-01f, 4.27079737e-01f, 5.54124117e-01f, -3.41821998e-01f, -2.63567597e-01f, 1.06574818e-01f, 3.37572694e-01f, 1.73863336e-01f, 3.19173515e-01f,
  -6.33030683e-02f, 4.41361248e-01f, 4.22032058e-01f, -7.18409047e-02f, 1.42987862e-01f, 3.90718766e-02f, 1.90929472e-01f, 2.55257547e-01f, 1.87113751e-02f, -2.11046245e-02f,
  -3.00392777e-01f, 9.22748148e-02f, 1.01411171e-01f, -4.95017380e-01f, 4.90026146e-01f, 3.45783323e-01f, 1.86351016e-02f, -4.87507284e-01f, 6.42399676e-03f, -6.85241297e-02f,
  -1.68972969e-01f, 3.67085129e-01f, 8.23189989e-02f, -3.01035702e-01f, 3.20120454e-01f, -4.49682809e-02f, -6.16047621e-01f, -1.09201491e-01f, 2.45283946e-01f, -3.30301553e-01f,
  3.08385432e-01f, 2.04397872e-01f, 5.70701003e-01f, -4.67826515e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.42799872e-01f, 2.59164870e-01f, 2.61613548e-01f, 1.52546808e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.28063002e-01f, -2.65219390e-01f, 6.29181623e-01f, 6.70898035e-02f, -1.83679350e-02f, 2.26172924e-01f, -9.75798294e-02f, -2.36928493e-01f, 4.12517518e-01f, 2.69245148e-01f,
  -6.03015125e-01f, 2.13470254e-02f, 2.54159451e-01f, 4.99447703e-01f, -2.35483065e-01f, -4.27579042e-03f, 2.53847182e-01f, 2.25284584e-02f, 2.25586236e-01f, 6.64777011e-02f,
  5.89631438e-01f, -4.53682214e-01f, 6.59621835e-01f, 4.94500339e-01f, 1.16997153e-01f, -1.05927862e-01f, 2.75187045e-01f, -5.46181440e-01f, 4.85687464e-01f, 4.23603505e-02f,
  -5.25373757e-01f, 2.58991450e-01f, -3.06525528e-01f, 1.74352273e-01f, 1.54520152e-02f, -3.05102646e-01f, -5.46106637e-01f, -3.13301861e-01f, -5.98451197e-02f, -4.95185345e-01f,
  -3.02852333e-01f, -2.39801839e-01f, 1.04494140e-01f, 7.63235450e-01f, 3.49728227e-01f, 5.25440797e-02f, 1.86042905e-01f, 3.56413364e-01f, 4.25377756e-01f, -3.79349172e-01f,
  1.22651249e-01f, 5.96851707e-01f, 5.56851327e-01f, 1.60695091e-01f, -6.63072050e-01f, 8.83205116e-01f, -3.75838548e-01f, -5.04593432e-01f, 1.51849523e-01f, -8.96509886e-02f,
  -5.12038827e-01f, 6.87380061e-02f, 1.30547255e-01f, -2.54897982e-01f, -1.94972605e-01f, 6.16621599e-02f, 5.21067798e-01f, 1.61252409e-01f, 2.34026566e-01f, 1.76580310e-01f,
  3.39621156e-01f, -1.19133726e-01f, 4.45898652e-01f, 1.82816051e-02f, -6.39064848e-01f, -3.34776759e-01f, 1.17454693e-01f, 1.76821962e-01f, -2.34879881e-01f, 1.12101518e-01f,
  3.01258802e-01f, 5.81309497e-01f, -6.14081658e-02f, 4.17269379e-01f, 3.76712620e-01f, 4.30182993e-01f, -5.66301584e-01f, 8.41235459e-01f, -3.94993015e-02f, 2.52371609e-01f,
  -3.19188982e-01f, -1.03363775e-01f, -4.50241834e-01f, -6.13357574e-02f, -3.21895890e-02f, 3.89101580e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.37850481e-01f, -7.17047006e-02f, 2.29859516e-01f, 7.43737519e-01f, 4.33665961e-01f, 1.87062755e-01f, 8.44507635e-01f, -7.82402232e-02f, -9.92116407e-02f, 2.45330945e-01f,
  -5.73596135e-02f, -7.76701093e-01f, 2.74049163e-01f, -3.44650477e-01f, 1.09560303e-02f, 1.17828131e-01f, 4.33452100e-01f, 4.90386307e-01f, 5.78812182e-01f, -2.85781741e-01f,
  -1.25486183e-03f, 4.63457882e-01f, 2.56059319e-01f, -3.12109798e-01f, 5.59784651e-01f, -2.08298296e-01f, -4.96311545e-01f, -3.68020050e-02f, 3.23740780e-01f, 8.73826683e-01f,
  -3.65718186e-01f, -1.69623181e-01f, 2.17769459e-01f, -5.22711754e-01f, 4.10417914e-01f, -1.55244976e-01f, 1.56933144e-01f, -7.97515452e-01f, 5.79618037e-01f, -7.79505819e-02f,
  -4.56462085e-01f, 3.04416299e-01f, 9.34310496e-01f, 6.88003242e-01f, 8.19518149e-01f, -2.51888614e-02f, 8.20662498e-01f, 6.32477999e-01f, 3.37243646e-01f, 6.10810995e-01f,
  -2.30628595e-01f, 7.55328774e-01f, 4.32878017e-01f, 2.86173522e-01f, 4.50813651e-01f, 6.76937819e-01f, -8.58773112e-01f, -3.68406892e-01f, -3.63212585e-01f, 6.74181134e-02f,
  2.06181571e-01f, -1.79224670e-01f, 3.03973168e-01f, 4.61265147e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  -1.11089973e-02f, 2.88341254e-01f, 3.99963528e-01f, 2.32449383e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.42556936e-01f, 7.00148940e-02f, 1.82483830e-02f, -2.46560991e-01f, -3.95228714e-01f, 2.10315108e-01f, -2.90184990e-02f, -3.44387949e-01f, 1.57047525e-01f, 4.45746854e-02f,
  -4.78050649e-01f, -4.29610699e-01f, 2.44660005e-01f, -6.58560872e-01f, 4.78133321e-01f, -1.09255262e-01f, 3.31708461e-01f, 4.56160195e-02f, -5.76283753e-01f, -3.41145754e-01f,
  1.38868570e-01f, -2.35364065e-01f, 7.57779777e-01f, 4.70440000e-01f, -2.59927548e-02f, -3.28745157e-01f, 6.75462365e-01f, -2.59250075e-01f, -5.21460116e-01f, 4.32041794e-01f,
  -2.10570887e-01f, -2.25437030e-01f, -1.21432990e-01f, -1.67728961e-01f, 9.26238596e-02f, 7.61669204e-02f, -2.29628399e-01f, -1.51875779e-01f, -4.79627550e-01f, 4.64161575e-01f,
  -4.42253530e-01f, 6.38744354e-01f, -3.81619602e-01f, 6.57453835e-01f, 3.99889767e-01f, -3.37999910e-01f, -2.73829252e-01f, 4.03828740e-01f, 2.91802913e-01f, -1.98191598e-01f,
  2.02918261e-01f, 7.81993046e-02f, -2.43897334e-01f, -1.06317334e-01f, 6.15340769e-01f, 6.60090208e-01f, 2.57268488e-01f, -6.61447346e-01f, 2.66401112e-01f, -6.65695846e-01f,
  1.73270434e-01f, 1.54550448e-01f, 8.32950547e-02f, -6.18978322e-01f, 2.50824511e-01f, -7.14030802e-01f, 5.05228162e-01f, 8.82584631e-01f, -1.50856078e-01f, -3.60924751e-02f,
  -3.16042379e-02f, 2.71491587e-01f, -5.27956128e-01f, -2.11589590e-01f, 3.40464771e-01f, 1.10975198e-01f, 7.22307205e-01f, 3.76690358e-01f, -4.17424768e-01f, 4.38487798e-01f,
  1.02133982e-01f, -1.02167301e-01f, -4.46297348e-01f, -5.84435523e-01f, -1.17724337e-01f, 3.00633818e-01f, -1.90125734e-01f, 9.51705575e-01f, -1.68488175e-01f, 3.25436592e-01f,
  -1.29878119e-01f, -9.68858078e-02f, 1.02311097e-01f, -4.91959125e-01f, 2.05020949e-01f, 3.66174251e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.21565455e-01f, 3.07348698e-01f, 1.07311082e+00f, 2.54491270e-01f, 4.24727798e-01f, 1.21668778e-01f, 1.03305411e+00f, 5.67951202e-01f, 7.26129353e-01f, -1.44133389e+00f,
  7.99656808e-01f, -6.73387766e-01f, 3.57588738e-01f, 6.65780663e-01f, 1.25364274e-01f, 1.18116148e-01f, 2.12166414e-01f, 6.50684014e-02f, -1.06876576e+00f, -1.60733199e+00f,
  6.98071718e-01f, -6.83295190e-01f, 3.20492545e-03f, 1.75929189e+00f, -9.69110310e-01f, -1.89857319e-01f, 6.69980347e-02f, 3.02796036e-01f, 9.11577165e-01f, -3.79690975e-02f,
  8.38395000e-01f, 6.68012798e-01f, 6.41637266e-01f, 5.06807804e-01f, 5.03045082e-01f, 6.54465079e-01f, 5.41023612e-01f, 9.51620817e-01f, -1.13434458e+00f, -1.39857769e+00f,
  6.94647610e-01f, 5.33655763e-01f, -1.45633841e+00f, 7.39063770e-02f, -2.88218111e-01f, -5.51442564e-01f, 1.08070242e+00f, 7.30218232e-01f, 5.04280150e-01f, 1.41753675e-02f,
  -6.99345291e-01f, -3.17000568e-01f, 8.42637599e-01f, -3.31745222e-02f, 1.07209468e+00f, -3.24732482e-01f, 1.07808650e-01f, -7.89085329e-01f, -5.55690706e-01f, -7.39790082e-01f,
  -8.86461377e-01f, 5.61325252e-02f, 8.16750705e-01f, -9.53792393e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  3.67472470e-01f, 2.13865399e-01f, 7.74263024e-01f, 3.81955624e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -7.81806827e-01f, -1.49626040e+00f, -1.56983650e+00f, -1.18376970e+00f, 1.66787460e-01f, -5.03359318e-01f, -1.83358878e-01f, 3.11355591e-01f, -1.24869086e-01f, 1.21103632e+00f,
  6.45277083e-01f, -4.75806683e-01f, 6.57657206e-01f, -1.22344005e+00f, -1.45954990e+00f, -2.39321843e-01f, 1.56600571e+00f, 1.00404882e+00f, 4.12824273e-01f, -3.95257473e-01f,
  4.06038761e-02f, 1.11737335e+00f, -3.12637210e-01f, 1.17884971e-01f, -1.18956923e+00f, 1.46790552e+00f, 4.77822393e-01f, -1.99561715e-01f, 2.98925996e-01f, 3.18399549e-01f,
  -5.96632063e-01f, -7.78150022e-01f, 5.80166221e-01f, -7.08620071e-01f, -9.01469588e-01f, -2.23875359e-01f, -5.51952600e-01f, 4.96413618e-01f, 5.39267421e-01f, 1.08557725e+00f,
  -7.79438838e-02f, 6.53502405e-01f, -9.72872376e-01f, 1.01632535e+00f, -4.63168442e-01f, 2.35954508e-01f, -6.10648572e-01f, 7.56504476e-01f, -1.09861898e+00f, -9.09325242e-01f,
  9.51531708e-01f, 8.75658035e-01f, -6.76852822e-01f, 1.12414992e+00f, 1.94059774e-01f, 1.14628685e+00f, 8.79267514e-01f, -7.05961645e-01f, 4.64165598e-01f, 2.43759781e-01f,
  -4.76870149e-01f, 9.65057373e-01f, -1.22349393e+00f, -1.43419397e+00f, -1.01496851e+00f, 1.35904598e+00f, 5.46330631e-01f, 1.16588700e+00f, -6.32316887e-01f, -1.36721432e+00f,
  -1.04078424e+00f, 1.31742942e+00f, -1.35759902e+00f, -1.53282917e+00f, 1.61204064e+00f, -7.19451308e-01f, 4.05179150e-02f, -1.18802524e+00f, -6.81756377e-01f, -9.06803310e-01f,
  1.24547973e-01f, 8.35776985e-01f, 7.55208135e-01f, -5.99553585e-01f, -1.13920689e+00f, 1.14434481e+00f, -1.61421454e+00f, -1.79346240e+00f, 1.26583302e+00f, -8.08158457e-01f,
  9.73362625e-01f, -7.17800438e-01f, -3.79576653e-01f, -7.94423461e-01f, 4.83067483e-01f, -8.18706155e-01f, 1.09946334e+00f, -1.47975051e+00f, -2.96143681e-01f, -4.57437009e-01f,
  1.40526283e+00f, 1.08896506e+00f, 1.64377880e+00f, 2.77460665e-01f, 7.48284161e-01f, -6.05202615e-01f, 3.00512731e-01f, -2.59327263e-01f, -1.42836916e+00f, -1.60146952e+00f,
  7.57936656e-01f, -1.24359286e+00f, -7.00718701e-01f, -3.28451633e-01f, 6.14554822e-01f, -8.73271823e-01f, -4.55125511e-01f, -1.18209553e+00f, 9.93596375e-01f, 6.36819080e-02f,
  6.61385477e-01f, 4.72741544e-01f, -1.63307238e+00f, 1.13495493e+00f, -7.80983090e-01f, -1.40963629e-01f, 5.54876149e-01f, -1.32480860e+00f, -1.84454247e-01f, -1.95895970e-01f,
  9.57397938e-01f, 8.70609403e-01f, 8.02577555e-01f, -9.85688567e-01f, 3.36704403e-01f, -1.02884388e+00f, -2.47728184e-01f, -7.18968749e-01f, -6.48837686e-01f, 1.37540355e-01f,
  -6.20856106e-01f, 5.45929015e-01f, -1.40876383e-01f, -2.71645375e-02f, -1.10345578e+00f, -2.49737084e-01f, -3.13562006e-01f, 8.63727331e-01f, -1.70545042e-01f, 5.06976783e-01f,
  2.78747410e-01f, -8.45868349e-01f, -1.12380946e+00f, -3.56280297e-01f, -9.51173306e-01f, 6.71805918e-01f, -1.44490170e+00f, -1.13030803e+00f, 5.62346041e-01f, 6.40266120e-01f,
  8.51846933e-01f, 1.05559194e+00f, -2.91461498e-01f, 7.21465588e-01f, 1.09076488e+00f, -5.05755842e-01f, 5.48544645e-01f, 7.42285013e-01f, -1.54602334e-01f, 7.97892928e-01f,
  -9.07786012e-01f, -1.44481218e+00f, 2.30734840e-01f, -1.30946624e+00f, 1.03766724e-01f, 5.90463638e-01f, 5.25133789e-01f, 3.99989158e-01f, -1.02510226e+00f, -7.42434263e-01f,
  2.68473536e-01f, -7.57869899e-01f, -9.64577377e-01f, -1.09802866e+00f, 4.59459662e-01f, -5.35309203e-02f, 8.63772810e-01f, 1.12902641e+00f, -1.62090564e+00f, 9.59565938e-01f,
  -2.69814581e-01f, -1.95800555e+00f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  9.09726620e-02f, -1.63364988e-02f, -3.40922654e-01f, 1.47417292e-01f, 6.46714091e-01f, 5.01897156e-01f, 4.75396097e-01f, -3.27907413e-01f, -6.22629225e-01f, -1.98804811e-01f,
  8.58641118e-02f, -4.51398455e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    