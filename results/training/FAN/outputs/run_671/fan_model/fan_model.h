/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.55605081e-02f, -1.50741160e-01f, -2.97619462e-01f, 3.01951747e-02f, -1.38924256e-01f, -3.12988788e-01f, -4.62414056e-01f, -1.20412067e-01f, 3.44847739e-02f, -2.40963504e-01f,
  -5.47781587e-02f, 3.12584043e-01f, 3.23544621e-01f, 1.49783283e-01f, -1.53319305e-02f, -3.31137896e-01f, -2.48899430e-01f, -4.84133139e-02f, 1.47663474e-01f, 3.70004997e-02f,
  3.08648814e-02f, 8.59433785e-02f, 1.69821605e-01f, 7.59643540e-02f, -1.19487517e-01f, 1.49522424e-01f, -2.50025779e-01f, -8.15818980e-02f, -3.09625622e-02f, -1.03654720e-01f,
  -2.57249475e-02f, -1.90353036e-01f, 7.10697621e-02f, 1.26895219e-01f, 5.65113947e-02f, 3.41290236e-02f, 1.09585501e-01f, 3.74481012e-03f, 4.26608324e-02f, -3.84016312e-03f,
  1.20481834e-01f, 9.47894230e-02f, 5.15937321e-02f, 1.36148363e-01f, 9.56030563e-02f, 5.69710732e-02f, 4.56883982e-02f, 7.87239894e-03f, 4.69374731e-02f, 3.71893332e-03f,
  7.15811327e-02f, -6.07613474e-02f, -1.41927242e-01f, -2.05561429e-01f, -6.22375160e-02f, 3.47069055e-02f, -1.16171136e-01f, -7.45363533e-02f, -2.22440325e-02f, 8.60613212e-03f,
  -7.32020512e-02f, 2.37039272e-02f, 6.12658374e-02f, -3.93128693e-02f, 3.48571129e-02f, 1.20054896e-03f, -3.53247300e-02f, 4.39538583e-02f, 6.62830323e-02f, 7.34820738e-02f,
  3.94335575e-02f, -9.51115787e-03f, -6.35571703e-02f, -4.45036143e-02f, -2.48752199e-02f, -3.63408998e-02f, -4.19023745e-02f, 3.83792184e-02f, 2.35178862e-02f, 5.14277741e-02f,
  6.71808645e-02f, 8.87809619e-02f, 1.70996748e-02f, 6.83161244e-02f, -5.68155274e-02f, -6.37772353e-03f, 2.32480261e-02f, 2.00634245e-02f, 2.59659812e-03f, 3.15970890e-02f,
  2.23138690e-01f, -5.73356338e-02f, -3.50357476e-03f, 8.78014639e-02f, 7.68486317e-03f, 3.21600889e-03f, 4.61101793e-02f, 2.35938970e-02f, 1.08230188e-02f, -1.19351529e-01f,
  1.78998075e-02f, -3.25816274e-02f, 5.61561249e-02f, 5.18596638e-03f, 3.78409214e-02f, -5.35194296e-03f, -6.70814887e-02f, 3.95577736e-02f, 2.99208239e-02f, -5.39050065e-02f,
  3.64053361e-02f, 7.07997084e-02f, 1.01624988e-01f, 2.36140154e-02f, -7.56170601e-02f, 1.12998202e-01f, -3.97512279e-02f, 3.37892435e-02f, -5.90173062e-03f, -6.17006607e-02f,
  -2.95214057e-01f, -3.58015448e-02f, -1.90481186e-01f, -1.89075410e-01f, -1.44788384e-01f, -1.00349858e-01f, -1.90415308e-01f, 2.51088850e-02f, 9.90112424e-02f, -8.97045657e-02f,
  1.69273615e-01f, 4.19107080e-01f, 3.07850361e-01f, 3.65274191e-01f, 2.89987087e-01f, -1.25481829e-01f, -1.58437356e-01f, 7.50629902e-02f, 1.20577365e-01f, -2.37891860e-02f,
  7.47342408e-02f, -1.76007189e-02f, 6.04790784e-02f, 1.06002584e-01f, -1.02430671e-01f, 2.69753844e-01f, -9.55139622e-02f, -1.32946074e-01f, 9.45706815e-02f, -3.02906334e-01f,
  1.60272047e-02f, -2.01786131e-01f, 2.12026425e-02f, 1.92518495e-02f, 4.79660034e-02f, 6.33541569e-02f, 4.96678315e-02f, 8.19650367e-02f, 4.63355519e-02f, 1.08027756e-02f,
  1.08001651e-02f, -1.58505738e-02f, 9.82736126e-02f, 7.18915612e-02f, 7.05032572e-02f, 9.56236869e-02f, 4.63003591e-02f, -4.02412638e-02f, 3.45159546e-02f, 8.22194517e-02f,
  1.00398600e-01f, -6.46128878e-02f, -1.07180037e-01f, -7.09947273e-02f, -3.54980188e-03f, 7.46593699e-02f, 2.91009271e-03f, -7.21364394e-02f, 1.55556232e-01f, 2.16595549e-02f,
  9.04178713e-03f, 2.16289964e-02f, 3.70217711e-02f, 3.48765180e-02f, -2.55883131e-02f, -7.01892972e-02f, -3.55042741e-02f, -4.04347330e-02f, -4.23619002e-02f, -4.57405373e-02f,
  -9.20172315e-03f, -7.50752538e-02f, 6.53867796e-02f, -5.51350713e-02f, 3.84634510e-02f, -3.52187380e-02f, -1.73992123e-02f, -5.61675951e-02f, -9.01309848e-02f, -6.87731579e-02f,
  -3.56470644e-02f, -5.56835905e-02f, 1.58873070e-02f, 4.59093275e-03f, -5.42098060e-02f, 2.15928406e-02f, 5.86760454e-02f, -4.88047823e-02f, 7.60480575e-03f, -8.33366588e-02f,
  1.92393079e-01f, -2.87089800e-03f, -7.82169327e-02f, -2.40592528e-02f, -8.91129673e-02f, 6.42173812e-02f, 5.11244312e-03f, 6.03010617e-02f, -1.46171059e-02f, -6.53597340e-03f,
  -1.11259557e-01f, 8.02080259e-02f, 1.01424213e-02f, -2.28230823e-02f, -1.68127287e-02f, -9.08794776e-02f, -8.09950083e-02f, 4.42239754e-02f, -5.78241248e-04f, -1.68960728e-02f,
  -5.95818907e-02f, -1.92979444e-02f, 1.80507021e-03f, 5.68973720e-02f, -1.19713880e-02f, 3.29903476e-02f, 7.18320310e-02f, 7.36310184e-02f, 1.01272881e-01f, 1.46757141e-01f,
  3.74008447e-01f, 1.36620760e-01f, -1.19014502e-01f, 2.83866256e-01f, 1.39353216e-01f, 5.52769005e-02f, 2.93056399e-01f, -2.17168103e-03f, -1.42173925e-02f, 2.60277480e-01f,
  5.52809834e-02f, 1.13264218e-01f, 1.05773523e-01f, -2.74578594e-02f, -3.00466605e-02f, 1.20247357e-01f, 8.43554661e-02f, -1.90651208e-01f, -3.00220400e-01f, -2.30516493e-01f,
  -5.84410056e-02f, 6.20649084e-02f, -2.39465803e-01f, -2.14672193e-01f, 3.04214746e-01f, 1.11209251e-01f, 2.37504750e-01f, 5.81343658e-02f, 2.48890016e-02f, 4.16825175e-01f,
  -1.59267709e-02f, -1.66641679e-02f, 6.00752095e-03f, 3.27502675e-02f, -1.44989304e-02f, -9.49213728e-02f, 3.83095518e-02f, -3.51065695e-02f, 3.97078805e-02f, 4.80626561e-02f,
  -1.61081334e-04f, -1.35456786e-01f, -3.53417136e-02f, -6.26868680e-02f, -7.89907575e-02f, 1.90183427e-02f, -8.55457932e-02f, -4.54806574e-02f, 3.28995548e-02f, -1.12393210e-02f,
  1.25918329e-01f, -2.70213764e-02f, -1.44482881e-01f, 6.34918585e-02f, -7.03816414e-02f, -1.18654095e-01f, -6.45286515e-02f, 6.50361925e-02f, 3.57883424e-02f, 2.44803712e-01f,
  5.96931130e-02f, 9.58889499e-02f, 5.80385029e-02f, -1.52966157e-02f, 8.69010240e-02f, -3.84862646e-02f, -8.48454796e-03f, 7.69682825e-02f, -5.56728020e-02f, 3.59681211e-02f,
  -3.15596461e-02f, -1.78526156e-02f, 5.94647275e-03f, 3.15489136e-02f, 7.57300854e-02f, -2.28729425e-03f, -4.08519842e-02f, 1.94779970e-02f, -1.71600003e-02f, 1.60857569e-02f,
  -4.62604221e-03f, -4.47791442e-02f, 1.45145515e-02f, 1.11058727e-02f, -9.18481313e-03f, -1.40550043e-02f, -8.12608674e-02f, -9.44279283e-02f, 2.61183176e-02f, -2.79617943e-02f,
  5.31151295e-02f, -4.90522683e-02f, 6.55692369e-02f, -5.26459478e-02f, -7.35971257e-02f, 1.35955270e-02f, 1.36855796e-01f, -2.45971866e-02f, -3.95622291e-03f, -9.64033306e-02f,
  -1.36569262e-01f, 6.57885596e-02f, 7.32471347e-02f, -9.05330479e-03f, 4.03677076e-02f, 3.96084711e-02f, 6.57365471e-02f, 1.05279304e-01f, -1.69409588e-02f, -8.39266032e-02f,
  6.27313107e-02f, 5.56007475e-02f, 2.05535498e-02f, 9.85064358e-02f, 1.35914370e-01f, 2.88641322e-02f, 5.83698153e-02f, 6.86361119e-02f, 7.84172043e-02f, 2.59566009e-01f,
  -1.86701626e-01f, 2.46642351e-01f, 1.82114542e-01f, -1.70246698e-02f, 6.98040565e-03f, -2.58714795e-01f, -2.35966161e-01f, -2.08772853e-01f, -1.80024296e-01f, -4.51064818e-02f,
  3.76532041e-02f, 9.13841128e-02f, 1.46901309e-01f, 1.08313650e-01f, -6.24982454e-02f, 1.45507883e-02f, 2.06289232e-01f, 1.66310161e-01f, -2.26012453e-01f, -2.20292330e-01f,
  -7.96675235e-02f, -1.09340191e-01f, 5.26194200e-02f, -7.59995803e-02f, 9.11828279e-02f, -8.77631754e-02f, 1.54699296e-01f, 1.37256309e-01f, 1.19231507e-01f, 6.13700747e-01f,
  1.40534937e-01f, 1.42807543e-01f, 2.97000762e-02f, 1.13652274e-01f, 6.20842911e-02f, 5.40823378e-02f, 2.87556415e-03f, 1.09930813e-01f, 5.54822758e-03f, 3.13979983e-02f,
  9.26805288e-02f, -5.33754453e-02f, 3.03868558e-02f, 3.31475958e-02f, -3.37331519e-02f, -5.06523922e-02f, 3.55473757e-02f, 3.93681452e-02f, 6.91824555e-02f, -6.99341064e-03f,
  4.06753160e-02f, 1.39090508e-01f, 2.82478146e-03f, -3.43343504e-02f, 5.16055711e-02f, 2.79128626e-02f, 7.88728520e-02f, 4.91463318e-02f, 5.70988618e-02f, 5.10945767e-02f,
  -3.55225764e-02f, -6.19447529e-02f, 1.38010785e-01f, -2.70129666e-02f, -2.71963198e-02f, -1.10789081e-02f, -2.18288933e-05f, 4.44503985e-02f, 4.93147820e-02f, -2.34115701e-02f,
  5.96586801e-02f, -3.13578430e-03f, 4.95164096e-03f, 1.47854658e-02f, 7.05651939e-02f, 1.21279405e-02f, 1.28402226e-02f, -6.68801591e-02f, -6.58467133e-03f, -3.61956097e-02f,
  -4.58383374e-02f, 3.90153602e-02f, -1.94725282e-02f, 1.70399547e-02f, 4.43618596e-02f, -2.44086236e-02f, -7.32941777e-02f, 5.18036783e-02f, -2.86871009e-02f, -1.85685661e-02f,
  -1.14654958e-01f, 8.06835294e-02f, -7.87833929e-02f, -6.88685328e-02f, 1.17120296e-02f, 2.80603324e-03f, 2.88237091e-02f, 6.27801046e-02f, 8.13064426e-02f, -3.94380316e-02f,
  2.61487085e-02f, 7.12273791e-02f, 1.36693433e-01f, 4.63187471e-02f, -3.39386202e-02f, -8.79032444e-03f, -1.41516712e-03f, -1.01067699e-01f, 1.08680688e-02f, -1.03305981e-01f,
  -1.52543308e-02f, -2.17588976e-01f, -2.04140544e-01f, -9.81866941e-02f, -9.88336429e-02f, -1.62630290e-01f, -1.28510267e-01f, -1.61840081e-01f, -2.54003793e-01f, -3.48271877e-01f,
  1.32599678e-02f, 2.84617424e-01f, 4.49104272e-02f, 3.08439165e-01f, 3.05458605e-01f, 2.35599875e-01f, 1.63118228e-01f, 4.74478193e-02f, 1.22733660e-01f, -1.76522899e-02f,
  2.13829517e-01f, 1.82582766e-01f, 4.45760833e-03f, -7.98151642e-02f, -7.24796578e-02f, -9.54692140e-02f, -1.01625487e-01f, -1.13217190e-01f, 2.05114767e-01f, 1.70861438e-01f,
  1.88609570e-01f, 6.11171946e-02f, -1.19599469e-01f, 9.93994474e-02f, -2.87727892e-01f, 3.10163591e-02f, -1.33744046e-01f, -7.67884851e-02f, -2.94691678e-02f, -2.91211694e-01f,
  -1.46724209e-01f, 3.30603756e-02f, -2.67062876e-02f, 7.49539677e-03f, -1.40124008e-01f, -1.32559910e-01f, -4.76356968e-02f, -1.93018362e-01f, -2.78584585e-02f, -8.12316388e-02f,
  4.58663941e-04f, -1.09377578e-02f, -1.02741756e-01f, 3.18643302e-02f, 1.16385063e-02f, -1.12667503e-02f, -1.72565743e-01f, -1.54752329e-01f, -8.81465971e-02f, -1.08243272e-01f,
  -6.55908436e-02f, -7.02858344e-02f, -1.06134966e-01f, -4.16624770e-02f, -1.20464973e-01f, -3.37692760e-02f, -6.85071200e-02f, -1.02938414e-01f, -9.31217149e-02f, -2.91351676e-01f,
  -5.17297313e-02f, 1.72895025e-02f, -1.31238729e-03f, 8.99841951e-04f, -2.06266921e-02f, -5.98583780e-02f, -5.88847399e-02f, 5.44515885e-02f, -6.93097860e-02f, -4.55783196e-02f,
  -3.00012324e-02f, 1.14194229e-01f, 1.66647485e-03f, 1.83221437e-02f, -3.70568521e-02f, 8.78786966e-02f, 1.28243938e-01f, -9.91862714e-02f, -8.21431801e-02f, 1.14675127e-02f,
  6.01770841e-02f, -1.21733919e-02f, 6.52555972e-02f, 5.50858527e-02f, -6.43456280e-02f, 2.33389381e-02f, 1.56947941e-01f, 7.53004849e-02f, -2.90189101e-03f, -3.67533416e-03f,
  1.51776113e-02f, -7.18756393e-02f, -1.10862240e-01f, 1.19655631e-01f, 3.58536430e-02f, 2.67302915e-02f, 3.97157744e-02f, -4.41574492e-03f, 1.01164117e-01f, 4.85389009e-02f,
  -1.05592972e-02f, 1.50205851e-01f, -6.77272007e-02f, -3.52363437e-02f, 8.04663971e-02f, 1.25664383e-01f, 6.26896471e-02f, -4.96934354e-02f, 1.05494797e-01f, -9.59620103e-02f,
  -7.61555089e-03f, 5.70770875e-02f, -1.79753721e-01f, -9.32381228e-02f, -4.30470854e-02f, -1.64773539e-02f, 9.39825084e-04f, -6.92689940e-02f, -2.04833850e-01f, -1.18465051e-01f,
  1.23021100e-02f, 2.04225466e-01f, 3.24231058e-01f, 1.99974418e-01f, 1.98507160e-01f, 1.61312968e-01f, 2.69390523e-01f, 3.43036428e-02f, 7.87782110e-03f, 1.68852448e-01f,
  1.24383964e-01f, -9.37959254e-02f, 6.77545294e-02f, 3.80161814e-02f, -3.38945538e-02f, 2.20814660e-01f, 1.18694320e-01f, 9.93613824e-02f, 1.33683756e-01f, 2.68686891e-01f,
  2.02813327e-01f, 1.93365633e-01f, -2.76698507e-02f, -8.79199654e-02f, 1.25701621e-01f, -6.69767410e-02f, -2.45710928e-02f, 3.12756225e-02f, 5.92779890e-02f, 2.27000684e-01f,
  2.34846517e-01f, 5.52495643e-02f, 1.04986623e-01f, 1.57929078e-01f, 7.14499578e-02f, 1.72022119e-01f, 1.55019805e-01f, 1.26815692e-01f, -4.59672697e-02f, 1.66623011e-01f,
  4.09424864e-02f, 6.32980019e-02f, 1.41994596e-01f, -2.22506635e-02f, 2.73405369e-02f, 1.12796582e-01f, -1.55552939e-01f, 5.40254749e-02f, 3.30874114e-03f, 1.49189487e-01f,
  8.84033591e-02f, 1.95601538e-01f, 4.31230031e-02f, -1.07838832e-01f, -2.84412559e-02f, 3.13345566e-02f, -7.56269991e-02f, 2.76702177e-02f, -4.86364700e-02f, 1.99692473e-02f,
  2.16872524e-02f, 7.79116526e-02f, -2.88892444e-02f, -7.08015859e-02f, -6.20258152e-02f, 5.76052479e-02f, 5.16765825e-02f, 9.40271933e-03f, -3.42198350e-02f, -2.09739693e-02f,
  -5.73734082e-02f, 7.19983177e-03f, 7.64501318e-02f, 4.44376022e-02f, 7.68150911e-02f, 2.67341007e-02f, 4.84961458e-02f, 8.45770165e-02f, -6.99180812e-02f, 7.56632015e-02f,
  3.29841375e-02f, -4.23234142e-02f, 1.73829775e-02f, 2.06337757e-02f, 4.37319232e-03f, 2.26709917e-02f, 1.03472412e-01f, 7.36349402e-03f, -3.99156846e-02f, -8.69700499e-03f,
  4.11493890e-02f, -6.11248687e-02f, 3.92063707e-02f, 8.57311413e-02f, 1.14107758e-01f, -7.94806518e-03f, 8.60449374e-02f, 3.07108629e-02f, 6.80309758e-02f, 4.83193882e-02f,
  3.81270796e-02f, -3.59104052e-02f, -4.01278436e-02f, 2.40318384e-02f, 7.78326839e-02f, -3.48912291e-02f, -5.32295089e-03f, 4.80598658e-02f, 1.74563631e-01f, 6.94707632e-02f,
  4.24599387e-02f, -1.17276385e-02f, -1.84678789e-02f, -5.63803762e-02f, -9.41549689e-02f, 3.97997163e-02f, -5.71401790e-04f, 1.97579619e-02f, -1.11532710e-01f, -1.02850705e-01f,
  1.55367434e-01f, -4.12231654e-01f, -3.08186173e-01f, -5.35246618e-02f, -2.23842666e-01f, -1.49702877e-01f, -3.45163882e-01f, -6.03362471e-02f, 1.65018559e-01f, -2.65146971e-01f,
  -1.92705452e-01f, -6.90373629e-02f, -7.56739378e-02f, -6.14935197e-02f, -6.03502728e-02f, -2.92865157e-01f, -2.81008422e-01f, -4.49388325e-02f, 2.59371847e-01f, 2.05536693e-01f,
  9.79348347e-02f, 1.77081913e-01f, 1.01713702e-01f, 2.21872061e-01f, 6.10637553e-02f, 1.06193312e-02f, -1.74184591e-01f, 1.69125630e-03f, -1.08520433e-01f, -1.10129431e-01f,
  -3.11401546e-01f, -9.92230028e-02f, 3.79450358e-02f, 4.89292108e-02f, -1.30918145e-01f, 1.38472646e-01f, -1.28457407e-02f, 8.57333560e-03f, 5.54014649e-03f, -1.01719927e-02f,
  -6.27177283e-02f, 1.50516003e-01f, 2.40846500e-02f, 8.14687237e-02f, 4.95065562e-03f, 6.01457134e-02f, -2.77681760e-02f, -4.61163707e-02f, -5.59608638e-02f, -1.30605251e-01f,
  -1.83902740e-01f, -1.45723030e-01f, -1.18534029e-01f, -1.03356317e-01f, -3.59157845e-02f, 4.38455530e-02f, -5.75894937e-02f, 7.26031438e-02f, -6.52632862e-02f, 4.62913327e-02f,
  -3.82178426e-02f, -4.63763773e-02f, 5.75307235e-02f, 3.44797038e-02f, 5.72744459e-02f, 4.95904610e-02f, 6.67699426e-03f, -1.84144583e-02f, 1.01246573e-01f, 5.62366191e-03f,
  -3.59449498e-02f, -5.58015034e-02f, 7.56976828e-02f, -6.59532472e-02f, -7.22129317e-03f, 3.33019951e-03f, -8.89766589e-03f, -3.92311439e-02f, -1.00924158e-02f, 9.45103471e-04f,
  1.99732389e-02f, 1.33281842e-01f, 2.82969140e-03f, 9.18039605e-02f, -1.03980787e-01f, -8.48681629e-02f, 6.74862415e-04f, -7.25438744e-02f, 2.86450032e-02f, -7.94219449e-02f,
  1.49931982e-01f, -1.84466183e-01f, 9.14461911e-02f, -3.66477445e-02f, 9.40536987e-03f, -1.90429837e-02f, -1.06035158e-01f, -5.42913564e-02f, 2.98254415e-02f, 3.29047665e-02f,
  -2.56242324e-02f, 3.31396349e-02f, -1.17412530e-01f, 1.08883053e-03f, -3.79489847e-02f, 6.00515231e-02f, -3.82688865e-02f, -8.37515816e-02f, 1.00263599e-02f, 4.59371358e-02f,
  -1.88531429e-02f, -3.52263153e-02f, 1.37765273e-01f, -2.66805105e-02f, 1.65445179e-01f, 1.41181266e-02f, 8.91128555e-02f, 7.54051283e-02f, 1.68004837e-02f, -4.20202017e-02f,
  3.40289265e-01f, -1.81813642e-01f, -2.20084503e-01f, -8.04909784e-03f, 1.97768025e-02f, 1.20180741e-01f, 3.45469303e-02f, 1.71310708e-01f, -5.72655685e-02f, -8.20640996e-02f,
  1.95828408e-01f, 2.77904838e-01f, 1.50846675e-01f, 1.09399080e-01f, 1.69775799e-01f, -2.39043832e-01f, -3.85280460e-01f, 1.55520905e-02f, 3.06166828e-01f, 2.62599558e-01f,
  3.38119417e-02f, 1.02345161e-02f, -2.27480568e-02f, 1.12668060e-01f, -2.58331507e-01f, 1.17110759e-01f, -1.66675463e-01f, -2.62333333e-01f, -1.48263983e-02f, -4.87209052e-01f,
  -2.07776502e-02f, -2.14121547e-02f, 1.19568743e-01f, 5.67262508e-02f, -3.92242409e-02f, -6.87069222e-02f, -1.88285597e-02f, -9.64679271e-02f, -7.62902573e-02f, -1.24309257e-01f,
  1.74392760e-02f, -2.11742576e-02f, -8.42594355e-02f, -9.92363542e-02f, -7.64499232e-02f, 3.73247378e-02f, -1.55391678e-01f, 4.93469322e-03f, -4.24809828e-02f, -5.57367243e-02f,
  2.69196182e-02f, 1.02922097e-01f, 1.60857916e-01f, 9.26444232e-02f, 1.34022549e-01f, 7.66861662e-02f, 1.03221513e-01f, -7.35202953e-02f, -7.28735030e-02f, -2.42701754e-01f,
  -7.96515378e-04f, -7.56153241e-02f, -4.53478247e-02f, 2.47286614e-02f, 8.25809911e-02f, 7.37277791e-02f, -1.55308545e-02f, 1.67017318e-02f, 5.70202395e-02f, -2.01727375e-02f,
  -1.16544897e-02f, 6.76666796e-02f, -6.90129818e-03f, -6.41241148e-02f, -1.03120366e-03f, -5.16212992e-02f, 4.63950559e-02f, 5.46139926e-02f, 1.05536357e-02f, -3.71141993e-02f,
  1.03402935e-01f, 1.10964105e-01f, -3.09969559e-02f, 2.67647468e-02f, 2.62300540e-02f, -2.51788646e-03f, 1.48570184e-02f, 6.26013502e-02f, -8.67275596e-02f, 6.91714287e-02f,
  -5.50860986e-02f, 1.64647803e-01f, -2.74592917e-02f, 6.83802227e-03f, -1.37508027e-02f, 1.71700884e-02f, -5.21487147e-02f, 6.39582500e-02f, -6.57547936e-02f, -5.20415045e-02f,
  3.04814801e-02f, -4.49869595e-02f, -5.84516721e-03f, -2.16135792e-02f, 1.72929950e-02f, 1.07926112e-02f, -2.51355767e-03f, 1.05177984e-01f, 1.31687121e-02f, 4.63345181e-03f,
  -8.25651176e-03f, 6.89924583e-02f, 1.35808811e-01f, 5.51078953e-02f, 4.02322114e-02f, 1.97518617e-01f, 5.31348474e-02f, 3.99183258e-02f, 9.77423266e-02f, 2.84021981e-02f,
  -2.67052770e-01f, 2.69232213e-01f, -4.01640832e-01f, -7.63608515e-02f, -5.06998837e-01f, -4.27833408e-01f, -2.98574865e-01f, -1.22758754e-01f, 2.30776817e-02f, 2.85077076e-02f,
  -2.97638439e-02f, 1.33810595e-01f, 2.30032668e-01f, 2.31824443e-01f, 1.33408323e-01f, -7.91590735e-02f, -2.25878701e-01f, -1.48899481e-01f, -2.14259148e-01f, -1.95426568e-01f,
  3.53756063e-02f, -6.45092949e-02f, -7.56067336e-02f, -1.73501279e-02f, 6.18481375e-02f, -3.81154120e-02f, -1.71131283e-01f, -1.17706709e-01f, -1.10168025e-01f, -3.18335630e-02f,
  1.80506527e-01f, -1.36072025e-01f, 2.47370638e-02f, 3.76327783e-02f, 4.61627133e-02f, 1.06779970e-01f, 4.79211137e-02f, 9.53282230e-03f, 5.01148291e-02f, 1.36693409e-02f,
  -3.07424031e-02f, -1.14868698e-03f, 1.22872531e-01f, 3.10403239e-02f, -6.45148754e-02f, -5.77095188e-02f, 1.26149133e-01f, -4.46682274e-02f, 6.94710910e-02f, 6.23295940e-02f,
  1.35995373e-01f, -4.72197868e-02f, -8.49995017e-02f, 1.74130201e-02f, 4.81959768e-02f, -2.82572675e-03f, 2.26708855e-02f, -5.93251586e-02f, -1.53122708e-01f, 4.07682694e-02f,
  4.21841890e-02f, -3.69908139e-02f, -1.12009253e-02f, -2.74186581e-02f, 2.36156806e-02f, 1.90184843e-02f, -1.21408161e-02f, 5.37159890e-02f, -7.32228085e-02f, 9.06048808e-03f,
  1.09496541e-01f, -8.25287700e-02f, 9.61835235e-02f, -3.87768969e-02f, 3.32580544e-02f, -6.01960756e-02f, 8.64194110e-02f, 7.49996305e-02f, 3.09065077e-02f, 2.30554659e-02f,
  4.08353880e-02f, 3.41783725e-02f, 9.57491696e-02f, 6.20190687e-02f, -1.21239545e-02f, 7.83202611e-03f, -1.56672690e-02f, -8.11972469e-02f, 7.43821859e-02f, -5.43666594e-02f,
  1.56979322e-01f, 2.37569101e-02f, 1.94154814e-01f, 1.10094957e-01f, 3.37210856e-02f, 1.37192264e-01f, 3.38429287e-02f, 2.25260239e-02f, 3.86621105e-03f, 1.00037478e-01f,
  -4.84310538e-02f, 1.93949118e-01f, 1.32673115e-01f, 7.34796422e-03f, 5.83448932e-02f, -9.82109830e-02f, 3.77910994e-02f, -1.14607140e-02f, 9.22617037e-03f, 1.33932576e-01f,
  1.22661062e-01f, -7.28957057e-02f, -1.50484189e-01f, -2.11646780e-02f, 5.29836752e-02f, 3.57468836e-02f, -1.14381447e-01f, -6.48717955e-02f, -1.72507480e-01f, 9.76167843e-02f,
  -3.20001721e-01f, -1.23760998e-01f, -2.60978634e-03f, -4.06533659e-01f, -3.45978066e-02f, 1.05359182e-01f, 2.64252163e-03f, -3.36732641e-02f, -1.48130566e-01f, -1.19991317e-01f,
  8.30531958e-03f, 1.60079628e-01f, 2.98528373e-01f, 4.09576058e-01f, 1.69216380e-01f, -1.22413024e-01f, -1.21237777e-01f, 1.62435621e-01f, 2.63604909e-01f, 1.32324070e-01f,
  5.57718426e-02f, -2.57481635e-01f, -2.49316797e-01f, -3.90988588e-03f, -1.17211431e-01f, 1.49517283e-01f, -1.08242199e-01f, -1.15036979e-01f, 1.57844871e-01f, -2.66099926e-02f,
  3.65835458e-01f, -6.32111058e-02f, 2.34955549e-01f, -4.32432964e-02f, -8.90673429e-04f, -3.33577543e-02f, -1.45830875e-02f, -1.03327222e-01f, -5.18770367e-02f, -1.02149814e-01f,
  5.20215668e-02f, 5.17206267e-02f, 4.18689400e-02f, -1.47066135e-02f, -9.87943709e-02f, -3.11664585e-02f, -6.82750568e-02f, -1.78899616e-02f, 9.36880484e-02f, 4.84234765e-02f,
  1.90820056e-03f, -1.86406448e-01f, -1.34438081e-02f, 3.00029963e-02f, 2.30302047e-02f, 5.20541444e-02f, 4.00479957e-02f, 6.24081716e-02f, 8.32422525e-02f, 6.78183213e-02f,
  1.21581763e-01f, -8.29562843e-02f, 4.86401021e-02f, 6.22694055e-03f, 5.48067056e-02f, 8.54838789e-02f, 2.72056647e-02f, -4.66858037e-04f, -1.77030247e-02f, -1.00099035e-01f,
  1.94942672e-02f, -4.38850708e-02f, 2.81333867e-02f, -5.56574203e-02f, -3.86507958e-02f, -9.58491936e-02f, 2.01531071e-02f, -1.00925736e-01f, -3.96269150e-02f, 2.21095812e-02f,
  -1.81337893e-02f, 2.76264288e-02f, -3.94365527e-02f, 7.77789531e-03f, -1.02077372e-01f, 8.04690644e-03f, 6.14592023e-02f, -1.05935663e-01f, -1.73806380e-02f, -7.64566660e-02f,
  4.60228883e-02f, 2.11262017e-01f, 9.53522474e-02f, 3.17125544e-02f, 3.34025780e-03f, 1.09813750e-01f, 3.17952503e-03f, 1.04151644e-01f, -1.67113878e-02f, 5.22753373e-02f,
  5.22954054e-02f, -5.84723474e-03f, 3.26133594e-02f, -1.36015369e-02f, 5.79360537e-02f, 1.63217392e-02f, 3.40732448e-02f, 2.30720490e-02f, 2.77960673e-02f, -9.56345275e-02f,
  -7.60539621e-02f, 1.30361421e-02f, 1.50760919e-01f, 7.65966922e-02f, 1.38568148e-01f, 1.24967352e-01f, 2.31938452e-01f, 1.38857380e-01f, 2.04354212e-01f, 1.01640172e-01f,
  6.16371147e-02f, -6.78746551e-02f, 5.37663460e-01f, -2.60717630e-01f, 8.90489370e-02f, 2.60381281e-01f, 4.14974958e-01f, 7.53705874e-02f, -3.19126993e-01f, 2.10400466e-02f,
  2.94125173e-02f, -1.14066616e-01f, -4.53074984e-02f, 7.94226229e-02f, 1.80913746e-01f, 2.51683831e-01f, 1.32278726e-01f, 1.16192341e-01f, 3.70046109e-01f, 1.93142250e-01f,
  -1.51508182e-01f, -1.73153475e-01f, -1.21319510e-01f, -2.02537939e-01f, -7.55330771e-02f, -1.08418301e-01f, -2.62761936e-02f, -5.94616234e-02f, 6.02833591e-02f, -8.16275477e-02f,
  4.41431373e-01f, 9.48257446e-02f, -1.01956874e-02f, -1.50612015e-02f, 1.22038379e-01f, -1.30796824e-02f, 1.51005894e-01f, 6.34454340e-02f, -1.54035063e-02f, -7.26698758e-03f,
  -3.84142175e-02f, 1.37567008e-02f, 1.03573106e-01f, 2.74969973e-02f, 1.22957356e-01f, 9.36887190e-02f, -6.19416907e-02f, 5.42523563e-02f, 1.02785833e-01f, 1.03322260e-01f,
  1.33217191e-02f, -3.46918814e-02f, 1.81773618e-01f, 1.27149643e-02f, 8.24161340e-03f, 2.46676654e-02f, 9.02923942e-02f, -8.73756185e-02f, 7.06333965e-02f, -5.64005896e-02f,
  8.65583941e-02f, 4.47276421e-02f, 7.25241005e-02f, 7.18531907e-02f, -2.60477196e-02f, 3.35505344e-02f, 2.73239054e-02f, 5.67016974e-02f, -1.68350283e-02f, -4.16647717e-02f,
  6.31361306e-02f, 1.99435633e-02f, -2.33335840e-03f, 3.11107635e-02f, 3.88917630e-03f, 1.14943143e-02f, -3.19571979e-02f, -1.04659954e-02f, 5.09001948e-02f, -3.63288969e-02f,
  -3.99972722e-02f, 2.58446634e-02f, -1.75972003e-02f, 1.47049889e-01f, 1.20162301e-01f, 7.62905851e-02f, -1.99862085e-02f, -5.48275150e-02f, -2.64937505e-02f, -4.21087258e-02f,
  -8.15521255e-02f, 5.81739412e-04f, 6.00774996e-02f, 6.33805431e-03f, 1.41470721e-02f, 1.53319526e-03f, -7.70380720e-02f, -3.53392549e-02f, -3.22519056e-02f, 1.76552534e-02f,
  -2.01745518e-02f, -3.51970345e-02f, 3.57922763e-02f, -1.02564506e-01f, -1.04362331e-02f, -3.15843560e-02f, -4.72663715e-02f, 3.57536338e-02f, -1.03086822e-01f, -1.73280798e-02f,
  -9.53253135e-02f, 3.15971188e-02f, 1.18625119e-01f, -3.00368131e-03f, 1.48023777e-02f, 4.78304327e-02f, 2.13998258e-02f, 8.99562761e-02f, 1.10625923e-01f, -6.49267063e-02f,
  -1.02670893e-01f, 9.06551331e-02f, 2.13099286e-01f, -1.84622463e-02f, -9.41043720e-02f, -7.09817857e-02f, 1.57285824e-01f, -6.94908947e-02f, -1.48649544e-01f, 1.43686518e-01f,
  -1.60923123e-01f, -1.90792635e-01f, -2.04845324e-01f, -1.82156026e-01f, 2.60458011e-02f, 3.35501522e-01f, 2.75566757e-01f, 9.94228721e-02f, -1.55293122e-01f, -1.63678914e-01f,
  6.61402047e-02f, 1.90643236e-01f, 7.40623772e-02f, -2.20422074e-01f, 5.02716452e-02f, -1.28853485e-01f, 2.49613598e-01f, 1.22922771e-01f, -9.00869593e-02f, 3.28355849e-01f,
  3.06231737e-01f, -1.90775231e-01f, -8.77151042e-02f, -1.52556896e-01f, 5.87697774e-02f, -1.60285551e-02f, 4.35316265e-02f, 4.19430464e-04f, -1.25857219e-01f, 6.61779344e-02f,
  -9.15345326e-02f, -3.79570536e-02f, -1.24338530e-01f, -1.20530367e-01f, 4.72855903e-02f, -1.12781130e-01f, 9.05621871e-02f, 2.92882118e-02f, -4.20331359e-02f, -5.25752157e-02f,
  1.89754423e-02f, -6.96917027e-02f, -4.89679798e-02f, -1.08258978e-01f, -1.38659105e-01f, -5.56355827e-02f, -1.02911316e-01f, -1.33192822e-01f, -2.19484702e-01f, 1.57986999e-01f,
  -1.74171589e-02f, -1.19649793e-03f, -2.10081097e-02f, 1.75217865e-04f, 4.22832370e-02f, 4.88127023e-02f, -7.88146630e-02f, 9.01955664e-02f, 7.88324699e-02f, -2.88379844e-02f,
  -1.56676307e-01f, 9.46660414e-02f, -4.33637984e-02f, -8.18668008e-02f, -3.14155184e-02f, 3.84612493e-02f, 6.38563633e-02f, -8.67927913e-03f, -6.82223216e-02f, 4.25796397e-02f,
  -5.61847016e-02f, -4.95829061e-02f, 4.43810821e-02f, -7.16021704e-03f, 5.25914766e-02f, -1.63225061e-03f, 5.68554476e-02f, -2.04033051e-02f, -1.40692210e-02f, 4.52662334e-02f,
  1.16567984e-01f, -1.40102297e-01f, 7.77738392e-02f, -1.02587119e-01f, 3.70083973e-02f, 6.40842458e-03f, -1.73783284e-02f, -6.46205470e-02f, -9.69782546e-02f, -1.04363956e-01f,
  -3.80635075e-03f, -5.84881119e-02f, 3.29361251e-03f, 2.51036342e-02f, -3.84961963e-02f, -4.17279489e-02f, 5.83352335e-02f, -2.15833988e-02f, -4.68668081e-02f, 4.47190888e-02f,
  1.27455935e-01f, 1.28217846e-01f, 1.79502830e-01f, 4.90868874e-02f, -1.37314675e-02f, -1.38915822e-01f, 9.89944786e-02f, 7.17781903e-03f, -9.23423320e-02f, 2.91399479e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.68799597e-01f, -1.24079555e-01f, 5.25293410e-01f, 3.45139927e-03f, 2.98639119e-01f, 3.57239425e-01f, 3.28728169e-01f, 1.05311193e-01f, -1.12690754e-01f, -6.11023605e-02f,
  -1.01703122e-01f, 4.15984020e-02f, -8.82565510e-03f, -7.05868006e-02f, 1.03230394e-01f, 1.44530475e-01f, -3.65727278e-03f, 1.50151685e-01f, 2.72524416e-01f, 3.19355577e-01f,
  1.22282475e-01f, 1.09744258e-01f, -2.14445069e-01f, -2.08919376e-01f, 2.00233310e-01f, 1.85339645e-01f, 2.26129442e-02f, 4.92494814e-02f, -3.74931842e-02f, 1.21264279e-01f,
  5.19921243e-01f, -5.55052459e-02f, 2.01982975e-01f, -1.35721818e-01f, 1.19033558e-02f, -1.90475449e-01f, -4.37624529e-02f, -6.33061752e-02f, -3.25299837e-02f, 9.22175646e-02f,
  -4.61222455e-02f, -1.61106899e-01f, -6.41535744e-02f, -2.38351896e-02f, 8.82945675e-03f, -4.28923145e-02f, -2.16439292e-01f, 1.50408922e-02f, 4.58871797e-02f, 3.46304700e-02f,
  -3.54856476e-02f, 4.67823036e-02f, 8.91828984e-02f, 2.61354260e-02f, -1.07339844e-01f, 1.44593911e-02f, 7.86630362e-02f, -8.40711743e-02f, -1.97461783e-03f, 6.78538233e-02f,
  -5.51071018e-02f, -3.67707573e-02f, 9.62105170e-02f, 1.20681427e-01f, -5.85969873e-02f, 1.84848923e-02f, 6.19564466e-02f, 1.09193437e-01f, -1.89417936e-02f, 1.39357280e-02f,
  1.14624433e-01f, 6.09138533e-02f, -2.04706546e-02f, -5.37683815e-03f, -7.90761933e-02f, -2.47092526e-02f, 6.79725185e-02f, -3.60530503e-02f, -2.03815103e-01f, -4.22654338e-02f,
  2.97768886e-04f, 1.05193913e-01f, 2.16771439e-02f, -9.66205224e-02f, -2.16556549e-01f, -1.86159685e-02f, -2.44690180e-02f, -6.36086846e-03f, -1.39236853e-01f, -1.25099076e-02f,
  2.84768164e-01f, -1.94885671e-01f, 1.51635885e-01f, -5.97069561e-02f, -1.17192352e-02f, -1.38020784e-01f, 2.22702082e-02f, 1.17757069e-02f, 5.93712442e-02f, -4.22441624e-02f,
  8.95396918e-02f, 3.80809046e-02f, 5.16693890e-02f, 1.49900094e-02f, 1.40172645e-01f, 1.61635771e-01f, -1.50501043e-01f, 5.58810532e-02f, -5.97882159e-02f, 2.11083889e-01f,
  -1.73760336e-02f, 8.04766119e-02f, 2.40026072e-01f, 1.06704324e-01f, 1.74846768e-01f, 3.06297597e-02f, 3.83264691e-01f, 1.95226252e-01f, 1.82986662e-01f, 4.44668196e-02f,
  5.70614696e-01f, 2.60964602e-01f, 4.41016294e-02f, -1.94694940e-02f, -1.98242471e-01f, -1.53060332e-01f, -2.23389845e-02f, 1.03518166e-01f, -1.59227476e-01f, 4.07752432e-02f,
  -3.72992903e-02f, -7.42249656e-04f, 5.41882701e-02f, -6.29013125e-03f, 1.25251129e-01f, 1.39410049e-01f, 2.08651870e-01f, 2.14743152e-01f, 5.70581667e-02f, 4.58386913e-02f,
  6.28438368e-02f, 5.79677969e-02f, 5.75875379e-02f, 1.72666516e-02f, 3.07090372e-01f, -1.19683668e-01f, -2.79251691e-02f, 1.24753349e-01f, 5.47246868e-03f, 5.27611434e-01f,
  2.28949010e-01f, 4.46099229e-03f, -1.79943800e-01f, 1.32376538e-03f, 5.47314957e-02f, -1.12428265e-02f, 8.77246484e-02f, 6.91659525e-02f, -3.71337011e-02f, 9.66597721e-02f,
  4.36332487e-02f, -4.29582112e-02f, -2.26226244e-02f, -5.40088527e-02f, -5.67274541e-02f, -3.63526680e-02f, 3.70852128e-02f, 1.08816005e-01f, 1.11096233e-01f, 7.97660947e-02f,
  1.13580197e-01f, -1.01465344e-01f, -1.74315378e-01f, -2.25994468e-01f, 1.36446804e-01f, -1.68864697e-01f, -2.24255621e-01f, 4.97704782e-02f, -1.13528825e-01f, 1.63089231e-01f,
  5.24089336e-02f, 4.79384214e-02f, 7.78193846e-02f, -2.51016375e-02f, 4.74162959e-02f, 9.34129283e-02f, 1.84571394e-03f, -3.58992182e-02f, 6.86205402e-02f, 3.47656533e-02f,
  -1.18746661e-01f, -3.41827273e-02f, -1.03377625e-02f, -1.46419816e-02f, -6.42184168e-02f, -8.34277198e-02f, 2.23498209e-03f, -4.38527986e-02f, 7.52446055e-02f, -5.23167960e-02f,
  -6.11503534e-02f, 2.26817746e-02f, -8.04808736e-02f, 6.12981804e-02f, -3.35111022e-02f, 7.82062560e-02f, 1.41361095e-02f, -1.01263411e-01f, -7.76167214e-02f, 4.59523834e-02f,
  -3.83460045e-01f, -4.57268476e-01f, -2.42776610e-03f, 1.35958716e-01f, 8.39137007e-03f, -8.92546177e-02f, -3.72910239e-02f, 2.68474333e-02f, -9.75106135e-02f, 9.71893594e-02f,
  -2.85295676e-02f, 1.32229581e-01f, -1.61849871e-01f, 3.58626177e-03f, 6.52241260e-02f, -5.63984513e-02f, -1.34303812e-02f, 6.17211871e-02f, -4.00484651e-02f, 4.89990339e-02f,
  -6.80199936e-02f, -7.45119229e-02f, -1.11046471e-01f, -9.59493034e-03f, -3.40672322e-02f, -2.07139701e-01f, -2.80426234e-01f, -7.45787695e-02f, -2.96642751e-01f, -2.10136265e-01f,
  9.56008881e-02f, 3.20581160e-02f, 3.14170539e-01f, -1.12394460e-01f, -2.79746562e-01f, -2.98773408e-01f, -4.48668212e-01f, -1.27442420e-01f, -8.88021961e-02f, -4.21992987e-02f,
  -1.52204782e-01f, 1.72361076e-01f, 1.91013262e-01f, 2.20087826e-01f, 2.98596472e-01f, -8.27614665e-02f, 5.27910218e-02f, 4.11982387e-01f, 8.43643621e-02f, -2.65213139e-02f,
  -1.76217049e-01f, -4.16170172e-02f, 5.54399192e-02f, -8.96490142e-02f, 4.85457778e-02f, -4.48638871e-02f, 6.65718243e-02f, 5.56928255e-02f, 6.19873498e-03f, 1.60294503e-01f,
  4.05773371e-01f, 4.43317980e-01f, 2.65831411e-01f, 7.73182437e-02f, 1.17142916e-01f, 3.71981934e-02f, -4.74996492e-02f, 9.17712301e-02f, 3.52230370e-02f, -4.31647860e-02f,
  -1.27769932e-02f, 9.44138020e-02f, -6.12407550e-02f, -8.59109536e-02f, -8.18925127e-02f, -6.19665161e-02f, 1.39701767e-02f, 1.20499365e-01f, 3.86586674e-02f, 8.28310624e-02f,
  5.91643378e-02f, -1.22387879e-01f, -7.10818311e-03f, -3.35231982e-02f, 6.51224181e-02f, 8.00253153e-02f, -2.47804988e-02f, 6.94771558e-02f, 3.45909186e-02f, -1.35665521e-01f,
  1.23859785e-01f, 1.73428804e-02f, -2.22269688e-02f, 7.95754343e-02f, -5.23693971e-02f, -1.62154213e-01f, -1.20990023e-01f, -8.09400529e-02f, -2.12839365e-01f, -1.72940865e-01f,
  -2.55825311e-01f, 1.15815718e-02f, 8.99529383e-02f, -5.59855476e-02f, 1.32001773e-01f, -1.69736166e-02f, 1.43892959e-01f, 1.32069411e-02f, 4.92312983e-02f, -2.50913057e-04f,
  1.10192202e-01f, 6.24033026e-02f, -5.99005930e-02f, -9.35749933e-02f, 9.53754317e-03f, 7.99543783e-03f, 2.15595230e-01f, -5.26856119e-03f, -1.07980557e-01f, 1.44720068e-02f,
  2.88923606e-02f, 4.62891579e-01f, 1.81320429e-01f, 1.44717768e-01f, -1.51445055e-02f, -6.45685242e-03f, 1.57214969e-01f, 9.50244069e-02f, 1.95053920e-01f, 7.68321604e-02f,
  4.31704558e-02f, 1.42798409e-01f, -1.04954936e-01f, -5.17107211e-02f, -2.43143588e-01f, -8.15496445e-02f, 8.86322558e-03f, -3.69654633e-02f, 1.10794768e-01f, -1.09743914e-02f,
  1.76172256e-02f, -1.34438932e-01f, -1.15402294e-02f, -9.53911804e-03f, 8.75236541e-02f, 1.45236731e-01f, 1.19793795e-01f, 8.03779811e-02f, 4.39555645e-02f, -2.69387513e-01f,
  -6.32156730e-01f, 2.01841056e-01f, 1.42076612e-01f, -1.42954737e-01f, 8.22916403e-02f, 2.52425104e-01f, 9.13037434e-02f, 1.72255665e-01f, 4.92327958e-02f, -5.43121547e-02f,
  1.55954733e-01f, -7.43159056e-02f, -3.82936239e-01f, -1.76630244e-01f, -3.54524016e-01f, -1.95061088e-01f, -3.33027631e-01f, -3.98021132e-01f, 4.28737514e-02f, 1.57513961e-01f,
  -6.91550504e-03f, -2.66938806e-01f, -4.05405492e-01f, -3.56713794e-02f, -4.62516807e-02f, -1.57917216e-01f, -1.61175996e-01f, -1.33477703e-01f, 8.61003250e-02f, -1.15233086e-01f,
  6.51779622e-02f, 1.61187336e-01f, 7.55391568e-02f, -8.57248083e-02f, 7.77090760e-03f, 9.96675063e-03f, 7.22776502e-02f, 2.33524549e-03f, 7.28580877e-02f, 6.12434633e-02f,
  -2.84036994e-02f, 2.24530488e-01f, -4.87349443e-02f, 9.67575908e-02f, -1.51037142e-01f, 6.90989867e-02f, 9.01170149e-02f, -8.30514655e-02f, -4.06444557e-02f, 2.68942744e-01f,
  3.20160016e-02f, -5.78158759e-02f, -2.09764481e-01f, 8.94220620e-02f, 8.19790587e-02f, -1.84356585e-01f, 3.94603014e-02f, 2.59753108e-01f, 6.70382753e-02f, -1.16273284e-01f,
  1.35509968e-01f, 3.96454446e-02f, 9.82913151e-02f, 8.52754265e-02f, -1.72959059e-01f, 1.61795914e-02f, 6.23574145e-02f, -1.01349749e-01f, 1.67657182e-01f, -1.15579225e-01f,
  -2.26420490e-03f, 1.89602692e-02f, -7.43015334e-02f, -1.53139001e-02f, -6.02348186e-02f, -1.71911474e-02f, -1.12908751e-01f, -1.65228248e-01f, 3.49781811e-02f, 2.58084852e-02f,
  -9.15153474e-02f, 1.82721149e-02f, 1.25909306e-03f, -4.28620614e-02f, -8.23570695e-03f, -5.36068454e-02f, 1.24325253e-01f, 2.05714166e-01f, 7.18572177e-03f, 1.11441806e-01f,
  -1.89222649e-01f, -1.63537636e-01f, -1.68471858e-01f, -5.60587756e-02f, 6.72318712e-02f, -1.25417728e-02f, -1.12031465e-02f, 2.95059700e-02f, -2.67212987e-02f, 2.95105111e-02f,
  -5.97507507e-03f, -8.93830359e-02f, -1.04217112e-01f, -2.45522875e-02f, -1.72079727e-01f, -1.47933513e-01f, -7.94914216e-02f, -8.54553208e-02f, -6.94151744e-02f, 3.05687170e-02f,
  -2.01167420e-01f, -2.82612771e-01f, -4.73166645e-01f, -2.71661520e-01f, -1.19388275e-01f, -4.90487665e-01f, -2.91472435e-01f, -1.58617031e-02f, -2.04603776e-01f, -3.92123550e-01f,
  5.71512818e-01f, 4.88694221e-01f, 3.62832218e-01f, -1.51147216e-03f, 5.46939224e-02f, 2.16067746e-01f, 6.45880580e-01f, 3.60015631e-01f, -1.39387801e-01f, 8.60922560e-02f,
  8.11938867e-02f, -2.01355428e-01f, -1.54547706e-01f, -7.37935677e-02f, 2.70733833e-01f, 1.42566025e-01f, -1.48579970e-01f, -4.70203012e-02f, -5.43220863e-02f, -4.00483869e-02f,
  -1.33519754e-01f, -2.50978232e-03f, 5.33008166e-02f, -7.44186416e-02f, 8.62253010e-02f, -4.00002807e-01f, -4.45999429e-02f, 9.78954881e-02f, 5.95356934e-02f, -7.14324042e-02f,
  5.69364689e-02f, 6.35557175e-01f, -3.85896266e-01f, -2.70052999e-01f, -5.08145615e-02f, -7.83240423e-02f, -1.20048784e-01f, 6.41833831e-05f, -8.94263610e-02f, -8.96759853e-02f,
  1.50394021e-02f, -2.91354805e-02f, 1.39593169e-01f, 1.57392621e-01f, 9.65743363e-02f, 1.19910631e-02f, 6.62112013e-02f, 1.73908204e-01f, -6.36313343e-03f, -2.29670182e-02f,
  1.19488105e-01f, 1.70792520e-01f, 2.53362209e-01f, 7.51988366e-02f, 1.44698068e-01f, -5.84576316e-02f, 2.55041093e-01f, 1.25805601e-01f, 1.71719417e-01f, 5.28053492e-02f,
  -2.64902353e-01f, -2.34989841e-02f, 4.31878790e-02f, 3.91789936e-02f, -5.60432002e-02f, -6.71939179e-02f, -4.73211408e-02f, 7.10225403e-02f, 1.65458175e-03f, -4.51257173e-03f,
  -3.19098681e-02f, -3.08739524e-02f, 5.11256233e-02f, -1.30731627e-04f, -1.40333802e-01f, 1.10651337e-01f, 1.76043645e-01f, 8.81722271e-02f, -3.23620848e-02f, -7.45598674e-02f,
  2.75856648e-02f, 9.34323147e-02f, 1.25059187e-01f, 8.58375356e-02f, 3.19117643e-02f, 1.37986615e-01f, 1.95093267e-02f, 3.50944363e-02f, -4.98286188e-02f, -8.51721242e-02f,
  -3.31212342e-01f, 1.28739685e-01f, -8.84730369e-02f, -5.24339005e-02f, 3.99770439e-02f, 5.08971810e-02f, -3.91052011e-03f, 1.07581122e-02f, -6.75098002e-02f, 7.29421750e-02f,
  6.46339282e-02f, 1.97784845e-02f, 1.02920495e-01f, 2.75075901e-02f, -1.40874505e-01f, -7.90407583e-02f, 6.66043237e-02f, -6.98956335e-03f, 3.71837206e-02f, -4.25074436e-03f,
  6.00358732e-02f, -1.78464502e-02f, -6.45454600e-03f, -4.31600679e-03f, 4.48211655e-02f, -3.45223963e-01f, -2.89154295e-02f, -1.72464754e-02f, -8.17794725e-02f, -2.66570657e-01f,
  -1.17605209e+00f, -6.92678392e-02f, 1.56993587e-02f, -3.16093355e-01f, 1.51106134e-01f, 1.57909080e-01f, 5.31265773e-02f, -9.59566832e-02f, -5.45451269e-02f, -1.66355204e-02f,
  -1.23955481e-01f, -1.29005536e-01f, -1.96492430e-02f, 1.09411575e-01f, 2.83651128e-02f, 2.34249711e-01f, 4.61862773e-01f, 1.48132712e-01f, -1.08109370e-01f, 8.47630203e-02f,
  1.78008616e-01f, -1.57320470e-01f, -1.98295280e-01f, 1.13565043e-01f, 1.26380185e-02f, -1.00649539e-02f, 2.36321911e-01f, -8.54045227e-02f, 2.65816540e-01f, 1.85017705e-01f,
  -3.59732628e-01f, -3.43600124e-01f, 3.26034799e-02f, -6.01200685e-02f, 6.60552010e-02f, -7.93821365e-02f, -1.08825462e-02f, -1.21088456e-02f, 4.93138805e-02f, 4.23654635e-03f,
  -1.04131885e-01f, 4.60300632e-02f, -7.00338855e-02f, -4.24230797e-03f, -6.45717680e-02f, -8.95844027e-02f, 3.89887616e-02f, 8.71770531e-02f, -2.78938040e-02f, -1.62030254e-02f,
  2.72044957e-01f, 1.79925904e-01f, -1.95476487e-01f, 6.31621256e-02f, 7.48874098e-02f, -2.36577131e-02f, -5.39528318e-02f, -2.45645717e-01f, -6.36213943e-02f, -2.28270084e-01f,
  3.16282660e-02f, -8.92092288e-03f, 2.77286507e-02f, 4.75852657e-03f, 6.06509261e-02f, -3.38390358e-02f, 7.17663318e-02f, 9.26136971e-02f, 1.09691441e-01f, -3.96393333e-03f,
  1.05530389e-01f, 3.08284573e-02f, 1.49510637e-01f, -8.63244906e-02f, 3.28826858e-03f, -6.74579153e-03f, 8.01594481e-02f, 1.85548007e-01f, 3.12506035e-02f, 3.47540863e-02f,
  9.65984389e-02f, 9.43198502e-02f, 6.68009147e-02f, 9.14084688e-02f, 7.14208409e-02f, 8.31259489e-02f, -5.10249985e-03f, -1.24089696e-01f, -1.84780434e-01f, -5.97288534e-02f,
  -3.52895409e-01f, 2.17092246e-01f, -2.73592919e-01f, -7.55962804e-02f, -2.09012516e-02f, 8.30813795e-02f, -4.84162592e-04f, -2.02989355e-02f, -8.58674869e-02f, 3.36628151e-03f,
  -3.83149534e-02f, -8.88131931e-02f, -6.86518028e-02f, 1.66440964e-01f, 2.89633255e-02f, 1.21239675e-02f, 1.19023673e-01f, 8.31675082e-02f, 1.36484832e-01f, 1.25774974e-02f,
  1.10032938e-01f, -1.12077095e-01f, -2.84880787e-01f, -4.89201620e-02f, -1.98140889e-02f, -1.57889009e-01f, -9.74702612e-02f, -2.45129943e-01f, -1.49533212e-01f, -4.80449736e-01f,
  -8.24231863e-01f, -1.03177223e-03f, -1.60178974e-01f, -6.50572777e-01f, -3.33184808e-01f, -7.19792023e-02f, -4.48679589e-02f, -6.86431378e-02f, -2.89362729e-01f, -2.49440596e-01f,
  4.97030355e-02f, 1.70918584e-01f, 5.53652421e-02f, 1.98248550e-01f, 8.83790292e-03f, -3.84714067e-01f, -4.03185487e-01f, -2.37566561e-01f, 1.69834569e-01f, 1.67835265e-01f,
  -6.07138239e-02f, -4.95769441e-01f, -1.58933938e-01f, -6.43274114e-02f, -2.63370693e-01f, 1.61141008e-02f, -2.55329788e-01f, -2.68233746e-01f, 1.10464171e-01f, -2.92469800e-01f,
  1.80207174e-02f, -1.96565166e-02f, 1.40314996e-01f, 1.33221105e-01f, -1.16785757e-01f, 3.48844193e-02f, 6.59169676e-03f, -5.18403156e-03f, 3.90907563e-02f, -3.23951356e-02f,
  3.22853550e-02f, 4.02178057e-02f, 2.11168621e-02f, 2.79429182e-03f, -7.24730641e-02f, -2.33676168e-03f, -6.08751662e-02f, 2.76071276e-03f, 1.14974519e-02f, 5.86431697e-02f,
  3.51278335e-02f, 3.98138650e-02f, 2.45095849e-01f, 1.51220664e-01f, 1.79606378e-01f, 1.01993186e-02f, 1.19635135e-01f, 1.28335789e-01f, 3.26086640e-01f, 1.86781302e-01f,
  -8.88390616e-02f, -6.73983898e-03f, -3.41088437e-02f, 2.74499152e-02f, -1.72244031e-02f, -3.51928454e-03f, 1.36978030e-02f, -7.72244632e-02f, -1.31229144e-02f, -2.74053145e-05f,
  -9.99965370e-02f, 1.29434722e-03f, 6.79511726e-02f, -2.13267356e-02f, -1.67271420e-02f, -9.28390250e-02f, -1.01333380e-01f, 2.30996236e-02f, 8.10421407e-02f, 4.71749045e-02f,
  -9.47463885e-03f, 2.11302303e-02f, -9.94733721e-02f, 6.05581468e-03f, -1.62745509e-02f, -1.41470551e-01f, -5.37837520e-02f, 8.62810090e-02f, 2.02136058e-02f, -3.04508228e-02f,
  1.58281494e-02f, 1.67841569e-01f, -1.38569161e-01f, 1.40555665e-01f, 1.04763068e-03f, 3.44559401e-02f, 2.08416558e-03f, -1.20133668e-01f, -1.69220120e-01f, -6.78934529e-02f,
  8.90184417e-02f, -8.89551733e-03f, 5.93751743e-02f, 4.62538004e-02f, 9.91678536e-02f, 7.46948943e-02f, -7.31037483e-02f, -6.77226251e-03f, 6.10623844e-02f, 7.09120408e-02f,
  1.93145406e-02f, -3.51040252e-02f, 6.37379512e-02f, 1.04964793e-01f, 7.97922090e-02f, 7.07916543e-02f, 8.34505185e-02f, 4.25086394e-02f, 1.10792950e-01f, -7.05815181e-02f,
  -4.92947519e-01f, 3.11296666e-03f, -4.37890738e-01f, 3.75359952e-01f, 2.83700049e-01f, 2.46501461e-01f, 2.66638398e-01f, 1.86905593e-01f, 2.33322069e-01f, 1.76601276e-01f,
  6.40372261e-02f, 1.65074542e-01f, 9.03320462e-02f, 1.84151679e-01f, 7.01013133e-02f, 2.14116633e-01f, 4.09774810e-01f, -1.01893291e-01f, -1.83999538e-01f, 1.16350085e-01f,
  3.15037251e-01f, 1.49661079e-01f, -2.54924387e-01f, -3.93294357e-02f, 1.19853765e-01f, 8.84926692e-02f, 1.04948610e-01f, 7.53581431e-03f, 7.96556547e-02f, 2.94330120e-01f,
  -1.87498555e-01f, -1.53086826e-01f, 7.95971975e-02f, 7.63176382e-02f, -1.23296313e-01f, -2.67154157e-01f, -1.74814425e-02f, -1.98318258e-01f, -7.93525279e-02f, -3.26292254e-02f,
  9.93352085e-02f, -3.35106067e-02f, 1.96175113e-01f, -2.00766176e-02f, -1.33227006e-01f, -1.24064013e-01f, -4.65860963e-02f, -1.83258981e-01f, -5.40571734e-02f, -1.03538208e-01f,
  2.34248996e-01f, 1.91038668e-01f, -5.93955182e-02f, 1.37294561e-01f, 1.15818612e-01f, 7.55326599e-02f, -4.59297076e-02f, -2.15409234e-01f, -3.37143481e-01f, -2.54717231e-01f,
  -1.31474644e-01f, -1.91905543e-01f, 3.33544379e-03f, -3.08773946e-02f, -2.23972928e-02f, -2.92687025e-03f, 4.94932421e-02f, 7.57647157e-02f, 3.55008319e-02f, -3.31450664e-02f,
  2.72058342e-02f, -8.18771645e-02f, 6.33958429e-02f, -2.61655226e-02f, -5.34042753e-02f, -2.10766960e-02f, 7.83461556e-02f, -4.88941558e-02f, 2.11260021e-02f, 3.62676708e-03f,
  7.03311265e-02f, -7.44243786e-02f, -9.48625207e-02f, 3.71588655e-02f, 3.26891355e-02f, -7.64672682e-02f, -2.95705255e-02f, -1.31064191e-01f, -7.59042725e-02f, -7.76222870e-02f,
  2.75582910e-01f, 8.60683024e-02f, 2.22168803e-01f, 8.71473923e-02f, 3.60742509e-02f, -7.46071786e-02f, 1.50839565e-02f, -9.16040875e-03f, 5.85854203e-02f, -1.66620836e-02f,
  5.01951724e-02f, -1.18364893e-01f, 8.00647587e-02f, -1.07044250e-01f, -2.02627495e-01f, -8.21719393e-02f, 1.85950361e-02f, 7.25638121e-02f, 1.31097972e-01f, -3.04945726e-02f,
  1.25906482e-01f, -3.11037023e-02f, -2.05375417e-03f, 5.48200533e-02f, -6.69997707e-02f, 1.14854701e-01f, -1.87989026e-01f, -2.21270397e-01f, -2.99193412e-01f, -2.97261000e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -3.50590758e-02f, 9.16110948e-02f, 3.21561784e-01f, -1.32829309e-01f, 3.26049924e-02f, 3.25185299e-01f, 1.26014113e-01f, -1.11074978e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.45865127e-01f, -6.70965314e-02f, 1.42828882e-01f, 8.35101679e-02f, 1.56767875e-01f, -6.97815344e-02f, 6.73627621e-03f, -3.49702500e-02f, -9.06346589e-02f, -2.04720572e-01f,
  1.21830143e-01f, 1.32439509e-01f, -1.51578158e-01f, 1.28389532e-02f, -9.01623517e-02f, -1.38919607e-01f, -1.29899066e-02f, 2.19344124e-02f, -4.90640774e-02f, 7.10606501e-02f,
  1.03967898e-01f, 1.84349090e-01f, 3.91120762e-01f, -8.86913612e-02f, 3.61720443e-01f, 3.54396790e-01f, 1.73411835e-02f, -2.86986351e-01f, 2.82733679e-01f, -4.25926805e-01f,
  9.30319205e-02f, -4.04933840e-01f, -8.97175074e-02f, 2.76998449e-02f, -1.55804709e-01f, 1.93265211e-02f, -4.66322824e-02f, -4.76035699e-02f, -1.90362915e-01f, -3.17251608e-02f,
  1.59025565e-02f, 2.24166326e-02f, -7.46913329e-02f, -9.23274606e-02f, 1.82422459e-01f, 1.54816836e-01f, -2.41892599e-02f, -3.55973691e-01f, 6.28690347e-02f, -3.34133245e-02f,
  7.90531375e-03f, 2.45202556e-01f, 1.29218265e-01f, -1.84821766e-02f, 9.63218231e-03f, -1.53790221e-01f, 2.23944057e-02f, -7.77381882e-02f, -5.61768562e-02f, -9.06696841e-02f,
  -1.43641621e-01f, -1.58762857e-01f, -1.04543634e-01f, -1.48910150e-01f, 9.39001292e-02f, 1.39872387e-01f, 2.69075871e-01f, -7.39391521e-02f, 1.43258408e-01f, -2.23914348e-02f,
  1.83943450e-01f, 1.47455230e-01f, -3.19796205e-01f, 4.69410904e-02f, -4.51972038e-02f, 1.25014603e-01f, 1.35889038e-01f, -1.30579427e-01f, 1.78858995e-01f, 5.64041808e-02f,
  -8.54262039e-02f, -2.88774706e-02f, 2.32135653e-01f, -2.10837021e-01f, -1.11685526e-02f, 4.16789809e-03f, 1.00655243e-01f, 3.73899698e-01f, 2.96931505e-01f, 1.82613328e-01f,
  -7.26100355e-02f, 7.26829618e-02f, -2.44420975e-01f, -1.33616075e-01f, -1.42533451e-01f, -2.62336493e-01f, 2.71770447e-01f, 6.10846914e-02f, 1.85880184e-01f, 1.43988594e-01f,
  1.30769655e-01f, -4.05396633e-02f, 2.53570318e-01f, 5.54456115e-02f, 2.25883320e-01f, 8.23691860e-02f, 2.31539264e-01f, 9.51842964e-02f, -1.03723615e-01f, 1.02590747e-01f,
  -1.37152821e-01f, 9.91905481e-03f, 5.38956486e-02f, -1.01130726e-02f, -4.76193652e-02f, 1.19268417e-01f, -7.51170516e-02f, 1.45431489e-01f, 3.15448046e-01f, 6.35737032e-02f,
  -8.97418186e-02f, 4.66173217e-02f, 9.04658362e-02f, 3.53845060e-02f, 6.51390329e-02f, -1.35743484e-01f, 2.37008005e-01f, -3.02698255e-01f, 2.83445507e-01f, -7.73417726e-02f,
  -1.54317226e-02f, -9.15036574e-02f, 1.12525411e-01f, -4.06176411e-02f, 1.54333994e-01f, 3.38760406e-01f, -4.09474134e-01f, -8.31466094e-02f, -6.54473379e-02f, -4.17438522e-02f,
  -6.58780038e-02f, 1.51988998e-01f, 1.57131985e-01f, -5.45907021e-01f, 1.90364406e-01f, 1.03853852e-01f, 1.05933078e-01f, -3.95169714e-03f, 1.71098337e-01f, 2.74433613e-01f,
  1.16339006e-01f, 1.59549713e-01f, 2.50709429e-02f, -1.00329034e-01f, -2.45768860e-01f, 2.57340074e-01f, -3.77572954e-01f, 1.55422250e-02f, 1.71522424e-01f, 4.01675031e-02f,
  -2.25609183e-01f, -1.29673913e-01f, -3.69713038e-01f, -1.31997585e-01f, -1.59110203e-01f, 5.82618378e-02f, -1.49966493e-01f, 2.16975547e-02f, 1.02535754e-01f, -3.11094463e-01f,
  -3.03091537e-02f, -2.36247078e-01f, 2.68295497e-01f, 2.31141359e-01f, -3.47551256e-01f, 1.71697717e-02f, -2.01549694e-01f, -1.23081736e-01f, -8.03518854e-03f, -1.26772359e-01f,
  5.17938197e-01f, -1.05250612e-01f, -1.09520853e-01f, 6.52143955e-02f, 1.38132110e-01f, -2.77012169e-01f, 5.02240025e-02f, 2.05005389e-02f, -5.51452823e-02f, 2.42319822e-01f,
  -3.25677358e-02f, -1.67391106e-01f, 7.70316049e-02f, -1.77075192e-02f, 1.66738778e-01f, 2.13310272e-01f, 1.11781754e-01f, 7.83211142e-02f, 2.31460169e-01f, 1.01564452e-01f,
  3.49959619e-02f, -1.49232134e-01f, 1.05303973e-01f, 1.36040628e-01f, -1.00985728e-01f, 2.41324138e-02f, 3.96907292e-02f, 1.07515030e-01f, -4.94897515e-02f, 1.11522444e-01f,
  -1.71019033e-01f, -7.52560869e-02f, -1.72424138e-01f, 8.85365233e-02f, 3.51607889e-01f, -1.20771453e-01f, -3.10859978e-02f, 1.86062410e-01f, -1.56166926e-01f, -9.89935324e-02f,
  4.16501850e-01f, -2.44930848e-01f, -2.30625182e-01f, -1.11869790e-01f, -1.18849829e-01f, -2.00500321e-02f, -7.85828158e-02f, -1.49004638e-01f, 1.11568568e-03f, 7.14260265e-02f,
  -2.32237399e-01f, -9.72183608e-03f, -8.80078152e-02f, 4.98891734e-02f, -1.81382403e-01f, -9.68481377e-02f, -1.47664994e-01f, -1.64818719e-01f, 1.51032016e-01f, 1.10777549e-01f,
  -8.30989853e-02f, 6.56930804e-02f, -1.11719087e-01f, -7.20340088e-02f, -1.96049288e-01f, -4.07740101e-02f, -5.26709557e-02f, -8.82884562e-02f, 1.98769867e-01f, 1.39896795e-01f,
  1.94750667e-01f, -3.35322507e-02f, 1.07646331e-01f, -5.37690818e-02f, 1.21461777e-02f, -8.86751637e-02f, -2.93895185e-01f, -8.70635286e-02f, -1.37857646e-01f, -3.08572918e-01f,
  -6.58994615e-02f, -6.91133067e-02f, -2.19681963e-01f, -1.95886400e-02f, -4.02749747e-01f, -7.61129186e-02f, -9.57297608e-02f, -7.58898631e-02f, 7.22770020e-02f, -1.64838716e-01f,
  1.87892616e-01f, 2.93619223e-02f, -5.25936335e-02f, 6.55333698e-02f, 1.96020544e-01f, -5.54279983e-02f, -9.02028196e-03f, -2.82372594e-01f, -3.54775563e-02f, 5.57621801e-03f,
  1.41056016e-01f, 2.78945237e-01f, -2.78986096e-02f, 1.18297912e-01f, 2.60516226e-01f, -5.97089231e-01f, -2.41863772e-01f, -1.29967317e-01f, -7.15003461e-02f, 1.15292735e-01f,
  -1.71207428e-01f, 9.34855193e-02f, -9.24656093e-02f, 2.48946939e-02f, -2.05599338e-01f, -3.36475581e-01f, 8.39693770e-02f, 2.00471319e-02f, 4.74380841e-03f, 1.84597634e-02f,
  -5.04699796e-02f, 2.84262449e-02f, 9.61360633e-02f, -2.19637439e-01f, 2.01947540e-02f, 1.14264645e-01f, -5.60437888e-02f, 1.16723984e-01f, 5.75464331e-02f, 6.53682798e-02f,
  4.68059368e-02f, -2.13065177e-01f, -2.06725657e-01f, -1.02876469e-01f, -8.26583989e-03f, 1.62677348e-01f, -2.54271686e-01f, 3.52250069e-01f, 1.10236555e-01f, 2.12374777e-01f,
  -3.98442894e-02f, -9.94908512e-02f, -1.07692860e-01f, 1.20556042e-01f, -3.66785675e-02f, 1.35380119e-01f, -3.27424258e-02f, 1.79152563e-01f, -1.72094759e-02f, -8.15453455e-02f,
  1.36024535e-01f, 1.58616751e-02f, -2.82491356e-01f, -6.32844865e-02f, 1.87457368e-01f, -3.04373085e-01f, 5.77593893e-02f, 1.13144532e-01f, -2.40556434e-01f, 2.52956301e-01f,
  -2.69793551e-02f, 4.54952009e-02f, 3.05635601e-01f, -6.76215738e-02f, 1.40063107e-01f, -4.28622395e-01f, -2.24789396e-01f, 2.96515763e-01f, 2.59031087e-01f, 4.01280187e-02f,
  2.67723918e-01f, 2.29650781e-01f, 2.66701058e-02f, -5.82457967e-02f, -9.56619978e-02f, 2.20191926e-01f, 8.78307149e-02f, 2.48247366e-02f, -5.84233701e-02f, -1.00880213e-01f,
  1.39889508e-01f, -8.77846852e-02f, 5.43017872e-02f, 1.40330698e-02f, 5.72998151e-02f, 7.52913356e-02f, -9.51389447e-02f, -9.38589871e-02f, 1.63782641e-01f, -7.77715594e-02f,
  -1.07031785e-01f, 1.78935990e-01f, -1.58839338e-02f, 1.49894759e-01f, 2.12741300e-01f, -9.83999670e-02f, 1.30010977e-01f, 4.16719876e-02f, 2.27001846e-01f, -6.89679349e-04f,
  -7.26669058e-02f, 7.95637723e-04f, 3.65566641e-01f, -1.96217373e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.51191914e-01f, 1.31223034e-02f, 1.12770922e-01f, 2.98622668e-01f, 1.48755908e-01f, -1.90419510e-01f, 6.24199927e-01f, 1.44684553e-01f, 2.93363836e-02f, 1.34408340e-01f,
  3.41016412e-01f, 2.05088422e-01f, 7.97760393e-03f, -2.04505518e-01f, -5.42273782e-02f, 6.21777892e-01f, -1.04687378e-01f, -8.82343724e-02f, -2.64782935e-01f, -3.40729773e-01f,
  5.81978112e-02f, 1.39223650e-01f, 2.39554629e-01f, 9.23404172e-02f, 8.61799717e-02f, 6.60521984e-02f, 4.05514194e-03f, 1.73927203e-01f, -3.07612389e-01f, 4.63655889e-01f,
  -2.09365413e-02f, 3.76090616e-01f, 1.72413453e-01f, 1.43266425e-01f, 9.44628567e-02f, 2.24975511e-01f, 2.81223774e-01f, 1.76528543e-01f, 3.09469495e-02f, 2.17093267e-02f,
  1.45943046e-01f, 3.82312573e-02f, -5.26267849e-02f, 8.95149484e-02f, 7.71642551e-02f, 1.05594188e-01f, 1.92591026e-01f, 2.92757377e-02f, 5.53111844e-02f, 6.00928580e-03f,
  -4.03784513e-02f, 1.06116295e-01f, -1.85962580e-02f, 2.25427866e-01f, 1.62536919e-01f, -1.63605034e-01f, 9.49483812e-02f, 5.98372400e-01f, 2.14086562e-01f, -1.47980079e-01f,
  3.00817788e-01f, 2.30957299e-01f, -2.82907486e-01f, 2.29446292e-01f, -9.33095664e-02f, 3.39645147e-02f, 3.01022708e-01f, 1.54044792e-01f, 2.09399790e-01f, 5.33761568e-02f,
  -9.02924612e-02f, 8.88628140e-02f, 1.50249854e-01f, 1.28578901e-01f, 2.09098071e-01f, -1.51716946e-02f, -1.07630916e-01f, -1.66241705e-01f, 2.41172597e-01f, 6.15911186e-01f,
  -1.82190970e-01f, 2.10998580e-01f, -9.11517814e-02f, -4.21640843e-01f, 6.29510581e-02f, -2.53649443e-01f, 6.87449984e-03f, -1.12017266e-01f, -5.04165530e-01f, 2.56980538e-01f,
  -1.41146883e-01f, 1.69205200e-02f, 2.35617831e-01f, 1.94527909e-01f, -5.86425997e-02f, -9.43790749e-02f, 1.94283083e-01f, 4.09030430e-02f, 1.04024529e-01f, 1.05233386e-01f,
  8.02584067e-02f, 5.47496788e-02f, 1.53937340e-01f, -2.44790837e-02f, 1.30607799e-01f, 3.96832302e-02f, 1.27160028e-01f, 7.14821666e-02f, 2.26995334e-01f, 2.74028510e-01f,
  -1.77796245e-01f, 1.66075721e-01f, -1.02962874e-01f, -2.66499758e-01f, 1.27539039e-01f, -8.79985318e-02f, 1.94352359e-01f, -1.71782285e-01f, -2.58291572e-01f, 1.34189263e-01f,
  -4.19059992e-02f, -3.43773842e-01f, 1.10510655e-01f, 9.77227315e-02f, -1.49954438e-01f, 2.68145919e-01f, 5.52059829e-01f, -4.17523354e-01f, 1.61958009e-01f, 1.12304285e-01f,
  -4.60559905e-01f, 2.32015535e-01f, -2.58631527e-01f, 6.46972936e-03f, -6.25101523e-03f, -9.04713757e-04f, 9.75627229e-02f, -1.55327830e-03f, 1.09134421e-01f, -1.75443292e-02f,
  -3.62134546e-01f, -6.38178512e-02f, -1.93692327e-01f, 2.30714574e-01f, 1.72593117e-01f, -7.28293955e-02f, -1.27831236e-01f, -3.79935235e-01f, -8.30366015e-02f, 5.88682108e-02f,
  -3.36243451e-01f, -1.47807160e-02f, -3.38289261e-01f, -1.77240714e-01f, -4.54101026e-01f, 4.90781575e-01f, -1.15713194e-01f, 5.79185665e-01f, 3.08528125e-01f, 2.68933445e-01f,
  4.27162588e-01f, 3.87695312e-01f, 1.77156284e-01f, -1.80048063e-01f, 1.88589901e-01f, 7.14862868e-02f, 5.20274699e-01f, 3.35783541e-01f, 1.71345457e-01f, 5.91336906e-01f,
  4.04183477e-01f, 3.65200847e-01f, -4.14143354e-02f, -1.84709534e-01f, 2.07483247e-01f, 7.71001041e-01f, -1.55983884e-02f, -1.48494959e-01f, -9.19094756e-02f, -5.43758094e-01f,
  8.05945843e-02f, 2.56858598e-02f, -5.22537470e-01f, 4.23407376e-01f, -4.53541940e-03f, 1.57878578e-01f, -7.55801424e-02f, 1.42741948e-01f, -4.06310499e-01f, 5.70428312e-01f,
  -1.88662514e-01f, 8.78355280e-02f, 2.25304082e-01f, 8.59058648e-02f, -3.84424061e-01f, 8.12268704e-02f, -3.30146253e-01f, -3.40060964e-02f, 1.73667222e-01f, -1.37237176e-01f,
  -8.40409473e-02f, 1.78441674e-01f, -5.54872379e-02f, -5.17165810e-02f, -1.47825629e-01f, -1.77569920e-03f, -2.66780615e-01f, 2.92299867e-01f, 3.66930425e-01f, 1.57837383e-02f,
  -2.33342439e-01f, -1.36111349e-01f, 1.22194901e-01f, 3.71749997e-02f, 1.56801030e-01f, -2.28163660e-01f, -5.82402170e-01f, -1.17960200e-02f, -4.39344108e-01f, 5.84155500e-01f,
  -2.00861748e-02f, 9.13507417e-02f, 1.82412505e-01f, -7.28290454e-02f, 1.05028570e-01f, 2.29297847e-01f, -2.02770326e-02f, -1.22795232e-01f, 1.48047820e-01f, -1.28122196e-01f,
  2.99948305e-01f, -5.13517484e-02f, 3.42871904e-01f, 3.72227103e-01f, 2.96159089e-01f, 1.33280858e-01f, 2.19110310e-01f, -4.97206487e-02f, 3.66928838e-02f, 3.41009021e-01f,
  -2.36448705e-05f, -1.29050642e-01f, 1.52257726e-01f, 1.11173220e-04f, 5.91253191e-02f, -3.99266295e-02f, -2.31996164e-01f, -2.05399320e-01f, 4.97153029e-02f, 1.87474653e-01f,
  4.00169045e-01f, 2.71197498e-01f, -9.84261855e-02f, 1.80017754e-01f, -5.48151694e-02f, 1.23247430e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.48268538e-02f, 2.79910296e-01f, 2.03405693e-01f, 2.26843446e-01f, -2.71410253e-02f, 1.55005410e-01f, 1.78399086e-01f, 1.03537068e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.14417635e-01f, -7.44102299e-02f, -1.02861062e-01f, 9.88002643e-02f, 2.78264612e-01f, -2.52873212e-01f, -3.88939679e-01f, 2.39860818e-01f, 6.06195867e-01f, -1.53813571e-01f,
  -1.52223140e-01f, -8.96428600e-02f, -3.06859240e-02f, 7.64563829e-02f, 8.13665055e-03f, -1.64193913e-01f, -9.96681079e-02f, -1.43692538e-01f, 1.39740869e-01f, -1.48852244e-01f,
  -1.88899070e-01f, -1.05698399e-01f, 1.04915455e-01f, -2.94371903e-01f, 1.61221921e-02f, 2.22713381e-01f, 3.10733497e-01f, -3.63956660e-01f, 1.27892466e-02f, -1.12888642e-01f,
  -1.78221405e-01f, -2.20986735e-02f, -1.33292004e-01f, 1.43960714e-01f, -1.71722874e-01f, 1.97309807e-01f, -1.05953149e-01f, 1.53039113e-01f, -3.84315610e-01f, -5.80351688e-02f,
  5.58740377e-01f, -3.67871337e-02f, 4.30724397e-02f, 6.97445422e-02f, -4.65524457e-02f, 8.94434284e-03f, 2.61901826e-01f, -9.91264731e-02f, -3.60231730e-03f, -1.49969354e-01f,
  -1.13828219e-01f, 2.18563661e-01f, -1.68839306e-01f, -4.66430008e-01f, 1.32708147e-01f, -5.64810634e-01f, -1.78527892e-01f, -6.54781610e-02f, 1.97824940e-01f, -1.68902338e-01f,
  -2.90429324e-01f, -4.04127464e-02f, -3.51093262e-02f, -3.54042649e-02f, 1.65901452e-01f, 2.54989445e-01f, -8.10154974e-02f, -1.39582351e-01f, 7.84277990e-02f, 1.25763696e-02f,
  3.65322351e-01f, 3.19140464e-01f, -8.77534747e-02f, -1.58328742e-01f, -5.35833417e-03f, 2.34507006e-02f, -4.37399685e-01f, 8.27792287e-02f, -1.76044106e-01f, -2.88073272e-01f,
  1.86314344e-01f, 6.89279847e-03f, 3.53997573e-02f, -4.89805669e-01f, -9.47893262e-02f, 3.43352526e-01f, 1.95970386e-01f, 4.26415466e-02f, 2.52246588e-01f, -2.02595979e-01f,
  -1.82666063e-01f, -2.05667078e-01f, 4.76395577e-01f, -1.24095865e-02f, 4.23816800e-01f, -3.24959680e-02f, 1.14936635e-01f, 1.73130125e-01f, 8.74494612e-02f, 2.01519549e-01f,
  -1.40754148e-01f, 2.45422170e-01f, 5.06979227e-01f, -3.26225385e-02f, -2.19839618e-01f, 2.65715957e-01f, -2.31421620e-01f, -2.57079095e-01f, 2.44474962e-01f, -2.06617743e-01f,
  1.31876916e-01f, 2.41883904e-01f, 3.06421574e-02f, 3.36957932e-01f, 1.86354116e-01f, 1.02148943e-01f, -5.62005211e-03f, -2.22876258e-02f, 4.05325055e-01f, 1.32417917e-01f,
  1.19858049e-01f, -2.88866431e-01f, -1.65054604e-01f, 2.60244906e-01f, 5.09176627e-02f, 1.83891580e-01f, -1.82270616e-01f, -1.83922127e-01f, -9.01327953e-02f, -1.11008517e-01f,
  3.50496918e-01f, -1.92284688e-01f, -2.59578824e-01f, 2.62658358e-01f, 1.03172648e-03f, 1.57473937e-01f, -1.28884226e-01f, -7.85809681e-02f, 2.22977791e-02f, -4.60798860e-01f,
  4.91192847e-01f, 1.93057045e-01f, -3.70788753e-01f, 1.89722806e-01f, -1.79938808e-01f, 3.30231518e-01f, 9.79551226e-02f, -1.60429940e-01f, 7.88054541e-02f, 2.92467386e-01f,
  2.87629247e-01f, 4.54673201e-01f, 1.13550477e-01f, -3.66588011e-02f, 1.02877699e-01f, 1.27552614e-01f, 1.67269260e-01f, -2.32427835e-01f, 4.06663805e-01f, -1.35364503e-01f,
  1.16637766e-01f, 1.92796454e-01f, 6.18298464e-02f, -1.72468096e-01f, -3.35399091e-04f, -1.13460142e-03f, -3.83474767e-01f, 2.98959136e-01f, -2.58657485e-01f, -1.05303444e-01f,
  -2.82492548e-01f, 1.84707016e-01f, -3.09452951e-01f, 5.26957586e-02f, -7.37367034e-01f, 2.46401966e-01f, -2.51194209e-01f, -2.35967413e-01f, 7.15325475e-02f, -1.56800598e-01f,
  2.10365668e-01f, 3.41142297e-01f, 3.20678055e-02f, -2.03505322e-01f, 4.58637774e-02f, -7.89467022e-02f, 1.17803499e-01f, 1.40696213e-01f, 4.36863750e-01f, 9.52425506e-03f,
  5.42134419e-02f, -2.09978297e-01f, -2.11955547e-01f, -8.21383670e-02f, -2.51234442e-01f, -3.00209392e-02f, -2.45186344e-01f, 1.64734364e-01f, -8.96814913e-02f, -8.52972455e-03f,
  1.06045470e-01f, -3.48330066e-02f, -5.04400283e-02f, -4.12680328e-01f, 3.84273887e-01f, -1.57054752e-01f, -1.34971282e-02f, 2.58174628e-01f, -2.13755295e-01f, -1.24599256e-01f,
  -5.88457324e-02f, 3.71547826e-02f, 1.39799520e-01f, -4.90310222e-01f, -1.88926205e-01f, -2.47910306e-01f, 1.24752775e-01f, -1.01208955e-01f, 2.53433526e-01f, 9.65672880e-02f,
  -2.11648211e-01f, 6.99437736e-03f, -4.23020959e-01f, -2.29403749e-01f, -7.02816481e-03f, 1.57378372e-02f, 2.09056344e-02f, -1.04218200e-01f, -9.23757162e-03f, 7.58409351e-02f,
  1.77877724e-01f, 8.19205120e-02f, 7.69524369e-03f, 1.06895603e-02f, -1.91180855e-01f, 3.00998986e-01f, 4.48942780e-02f, -2.46317754e-03f, 9.60203111e-02f, 1.52364075e-01f,
  4.73241620e-02f, -2.99328621e-02f, -3.11426759e-01f, -1.15513243e-01f, 7.18482397e-03f, -3.03793192e-01f, -6.15123391e-01f, -3.71522725e-01f, 8.64077434e-02f, -2.29216486e-01f,
  4.27959591e-01f, 8.06147978e-02f, -1.70986101e-01f, 3.68261814e-01f, -2.47914419e-01f, 7.49454498e-02f, 6.67679757e-02f, -2.09649250e-01f, -1.89062282e-01f, 2.72280276e-01f,
  1.63502067e-01f, -2.57525831e-01f, -2.05568254e-01f, -1.46110535e-01f, 3.54112864e-01f, -2.76661128e-01f, 2.37343356e-01f, 3.61902207e-01f, 3.72568399e-01f, -1.34981453e-01f,
  3.99428047e-02f, -1.93857804e-01f, -4.87747900e-02f, 5.44139072e-02f, -1.28308937e-01f, 3.88277978e-01f, -9.95241627e-02f, -2.02925101e-01f, -1.30397588e-01f, -4.13054615e-01f,
  -2.30971187e-01f, 7.22867548e-02f, 1.07420608e-01f, -2.20261052e-01f, -2.40198135e-01f, -5.16941361e-02f, -9.37898755e-02f, 5.88238202e-02f, -1.57850459e-01f, -7.74678728e-03f,
  -2.78496761e-02f, -3.12545270e-01f, -3.05940174e-02f, -6.06767423e-02f, -1.73864111e-01f, -4.44410622e-01f, -1.05288632e-01f, -7.14370282e-03f, 2.52804440e-02f, -2.30265051e-01f,
  7.94544458e-01f, -2.07165584e-01f, -1.01139978e-01f, 1.07393980e-01f, -1.09839015e-01f, 1.95362836e-01f, 1.31945372e-01f, 4.26347017e-01f, 1.34268060e-01f, -2.81083047e-01f,
  3.96876812e-01f, 2.24141013e-02f, 2.01186821e-01f, 2.38178283e-01f, 1.07302904e-01f, -1.20749183e-01f, -4.03004169e-01f, -1.86520174e-01f, -1.93663776e-01f, 1.54502681e-02f,
  -1.27727211e-01f, -1.75384372e-01f, 1.60679705e-02f, -1.70185901e-02f, 5.03631718e-02f, 1.87296066e-02f, -1.10820025e-01f, -9.85720009e-02f, -1.62529126e-01f, -1.03555523e-01f,
  -2.37712473e-01f, -1.66685820e-01f, -3.78704071e-01f, -1.25239357e-01f, -3.81325960e-01f, 2.16274522e-02f, -4.24616784e-01f, -2.51613092e-02f, 1.03370048e-01f, 1.86739773e-01f,
  2.50627577e-01f, 2.30150037e-02f, -3.59642744e-01f, 2.11047858e-01f, -6.11591935e-02f, 2.27109045e-01f, 1.14997208e-01f, -1.31027415e-01f, -1.05526783e-01f, 3.26715022e-01f,
  7.67507106e-02f, 2.81227410e-01f, 9.91216972e-02f, -2.00653926e-01f, -3.00714076e-01f, -5.10783494e-02f, -1.08718395e-01f, -7.69153684e-02f, -1.05814368e-01f, 2.85412341e-01f,
  -9.25941542e-02f, -6.94878399e-02f, 6.17354847e-02f, 1.43997684e-01f, 4.14679013e-02f, -2.33416513e-01f, 1.01987705e-01f, -2.27550834e-01f, 2.33028948e-01f, -6.71670556e-01f,
  3.04829538e-01f, 5.28705955e-01f, 1.48836344e-01f, -5.39094470e-02f, 1.00789659e-01f, -2.03107566e-01f, 4.84099090e-02f, -4.55142409e-02f, 1.19854353e-01f, -3.34927827e-01f,
  1.68298557e-01f, 9.60470885e-02f, -8.93162191e-02f, -2.05339924e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.37971696e-02f, 5.11271775e-01f, 7.92225730e-03f, 6.74208283e-01f, 4.67993647e-01f, 5.60276747e-01f, 3.51360321e-01f, 6.26089871e-02f, 3.24469894e-01f, 3.94042253e-01f,
  3.51860404e-01f, 4.19792026e-01f, -6.50187790e-01f, -9.75277796e-02f, 3.72988790e-01f, -4.66462635e-02f, 3.67015749e-01f, -9.58682504e-03f, -2.75436789e-02f, -5.47421098e-01f,
  -5.38794875e-01f, 3.98626514e-02f, -5.14075567e-04f, -2.32023761e-01f, 1.55955687e-01f, -2.83989497e-02f, -2.38668919e-01f, 4.51523542e-01f, -5.67648932e-02f, 2.12381870e-01f,
  6.28017411e-02f, 6.95123523e-02f, -1.59773409e-01f, 2.87682284e-02f, 4.48631912e-01f, -5.96941829e-01f, -1.98030528e-02f, 4.23227735e-02f, 4.42186296e-01f, -1.23998605e-01f,
  -2.89654344e-01f, 2.94467837e-01f, -7.47055039e-02f, -5.18127084e-01f, 4.07306105e-02f, -2.39358842e-01f, -2.51526445e-01f, -2.00695753e-01f, 3.89602967e-02f, -1.54542640e-01f,
  -3.86204481e-01f, 3.76152635e-01f, 1.26511410e-01f, 3.02587926e-01f, 8.39174032e-01f, 1.43664507e-02f, 1.25914112e-01f, -5.25469631e-02f, 1.22043699e-01f, 3.85511816e-02f,
  7.30936587e-01f, 3.28304708e-01f, 3.69510323e-01f, 6.94654435e-02f, 6.05795793e-02f, 6.18508756e-02f, 4.84333098e-01f, -6.24333918e-02f, -4.29418683e-02f, 1.13489285e-01f,
  4.56394583e-01f, 1.97704211e-01f, -1.13866828e-01f, -5.98047003e-02f, 1.26920512e-03f, -2.44895414e-01f, -1.13200724e-01f, -3.09182048e-01f, 2.93872446e-01f, -1.51353213e-03f,
  -3.80844802e-01f, 2.98150361e-01f, 2.14364693e-01f, 1.59559757e-01f, 3.96046430e-01f, 1.20068938e-01f, -7.08423913e-01f, 1.07289860e-02f, 5.07877886e-01f, 1.75889298e-01f,
  4.20346200e-01f, -1.65440321e-01f, 2.68484890e-01f, 5.93583167e-01f, -1.03273645e-01f, 4.08177495e-01f, 8.22408348e-02f, 1.29341735e-02f, 2.50550985e-01f, 9.17750672e-02f,
  2.83771813e-01f, -1.09517597e-01f, -5.10781892e-02f, 1.16668716e-01f, 3.36593688e-01f, 2.81107843e-01f, 5.42932332e-01f, 2.87356377e-01f, 1.38597280e-01f, 3.69509250e-01f,
  -2.24613786e-01f, 2.11178102e-02f, 1.46877274e-01f, 9.11784992e-02f, 4.28952873e-02f, -3.98029804e-01f, -4.38754231e-01f, 1.44365042e-01f, 5.74594960e-02f, 1.87115043e-01f,
  -1.33595675e-01f, 2.55046755e-01f, -2.57158101e-01f, 1.74993366e-01f, 1.68258026e-01f, -3.84196281e-01f, 3.04323226e-01f, 2.83952475e-01f, 3.21798980e-01f, 2.36446187e-01f,
  5.48754334e-01f, 3.62359911e-01f, 2.04247013e-01f, 4.45900023e-01f, 6.94302857e-01f, 2.65931249e-01f, 1.60847813e-01f, 1.29633531e-01f, -2.65716873e-02f, 3.67282569e-01f,
  -8.48154604e-01f, -4.81317192e-01f, 2.06597075e-01f, -1.34426340e-01f, -4.86621827e-01f, 2.48938650e-01f, -4.34490234e-01f, 1.69570446e-01f, -6.35723695e-02f, 1.11410590e-02f,
  -4.29553837e-01f, -5.71928382e-01f, -1.58292502e-02f, -1.82393774e-01f, 4.40150380e-01f, 3.35708618e-01f, 2.86830336e-01f, 4.79050785e-01f, 2.74612129e-01f, 1.97718248e-01f,
  -1.43058598e-01f, 1.33073360e-01f, 1.87960695e-02f, 9.23739597e-02f, -3.53848368e-01f, -1.45078689e-01f, 6.18742872e-03f, -2.25515574e-01f, -9.96708497e-02f, -2.46633679e-01f,
  -6.49514556e-01f, 3.23681742e-01f, -1.47254869e-01f, 8.28721464e-01f, -9.38107252e-01f, -3.82207215e-01f, -8.36698338e-02f, 2.02645138e-01f, -3.48021954e-01f, -2.60907020e-02f,
  -1.21095352e-01f, 3.60455513e-01f, 4.01272625e-01f, 1.69471413e-01f, -7.70727932e-01f, -1.61340535e-02f, -4.72379982e-01f, 1.28679961e-01f, 2.83342183e-01f, -4.30760920e-01f,
  2.58586437e-01f, -1.85042113e-01f, 1.83560744e-01f, -7.05095530e-02f, 2.06344947e-01f, -2.51313783e-02f, 4.83603299e-01f, 2.32890293e-01f, 3.45196016e-02f, 2.92739645e-02f,
  -1.31506711e-01f, 4.28804383e-03f, 2.49533102e-01f, 7.36239776e-02f, 2.41281111e-02f, 8.69674683e-02f, -5.50268233e-01f, 3.74692559e-01f, 3.31630886e-01f, 2.20639154e-01f,
  -3.08109164e-01f, 1.01481177e-01f, 1.01937413e-01f, 5.37517011e-01f, 1.49692282e-01f, 3.15756589e-01f, -1.36823833e-01f, -3.79260600e-01f, 4.02912311e-02f, 3.98463011e-01f,
  4.46499079e-01f, -1.48328260e-01f, 6.76243901e-01f, 2.15172961e-01f, -9.67376232e-02f, 2.87648499e-01f, -2.85439581e-01f, 4.14172620e-01f, -1.86180219e-01f, -4.52782959e-02f,
  3.79318118e-01f, 3.03550661e-01f, 8.66886377e-02f, 3.15171391e-01f, 2.45427638e-01f, 2.78016925e-01f, 1.03539139e-01f, -3.35960984e-01f, 3.68547797e-01f, -3.17819826e-02f,
  5.91284931e-01f, -1.19591050e-01f, 3.95381078e-02f, -8.49402249e-02f, 9.66031402e-02f, -2.12762475e-01f, 3.25020105e-01f, -2.95485765e-01f, 4.17643227e-02f, 7.88496286e-02f,
  -4.48223129e-02f, 1.06978722e-01f, -1.67316362e-01f, 3.71867537e-01f, -2.94852108e-01f, 2.16921307e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.76678014e-01f, 2.02524781e-01f, 1.25426510e-02f, 1.17094830e-01f, 1.44881397e-01f, 4.04744633e-02f, -1.36330184e-02f, 4.16178882e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -3.30938607e-01f, -3.48814689e-02f, 6.31675646e-02f, 3.04810762e-01f, 2.83346504e-01f, -5.86219691e-02f, -2.46900588e-01f, 4.53780964e-03f, 2.18274906e-01f, -1.20157316e-01f,
  -8.79405215e-02f, 1.11480907e-01f, 9.34203565e-02f, -2.03494087e-01f, 1.11739218e-01f, -2.16632947e-01f, 5.07640559e-03f, 3.27405930e-01f, -4.33729202e-01f, -2.39108399e-01f,
  -1.16252571e-01f, -3.73130590e-01f, 1.50015086e-01f, 6.19805157e-02f, -1.31631196e-01f, 3.51769149e-01f, -3.98662351e-02f, 1.46044288e-02f, -2.17204347e-01f, 2.07794264e-01f,
  1.54987916e-01f, -3.51446599e-01f, 1.47684813e-01f, -8.39601830e-02f, 5.76887906e-01f, 3.93486768e-01f, -2.51167953e-01f, -1.03840157e-01f, 3.14497977e-01f, -3.69105875e-01f,
  2.86791354e-01f, 1.27856717e-01f, -2.47685835e-01f, 1.01909235e-01f, 1.23655558e-01f, -1.25805900e-01f, -1.47309363e-01f, -9.55573916e-02f, -1.28184319e-01f, -2.71456450e-01f,
  -6.28275871e-01f, -6.96368143e-02f, -6.70399889e-02f, -4.57821995e-01f, 1.49933606e-01f, 1.43789977e-01f, 6.45050928e-02f, 1.16653964e-02f, 8.37546214e-02f, 1.55992419e-01f,
  -5.94992265e-02f, 5.44073284e-01f, -1.14683688e-01f, -2.39054218e-01f, -2.07111627e-01f, 1.78224877e-01f, -4.62727487e-01f, -2.17205703e-01f, 4.39474359e-02f, -5.71164548e-01f,
  -1.71834677e-01f, -2.48314857e-01f, -1.91867381e-01f, -1.55951500e-01f, -2.27030173e-01f, 2.12921351e-01f, -2.27683317e-02f, 7.56174773e-02f, -2.10397378e-01f, -3.02848727e-01f,
  -7.94302747e-02f, -3.58498931e-01f, -1.69038549e-01f, -3.26841176e-01f, 2.19588816e-01f, 6.06746793e-01f, 3.11951220e-01f, -4.70512033e-01f, -1.54763818e-01f, 1.34533450e-01f,
  3.51734936e-01f, -1.08121717e-02f, -1.19891755e-01f, 2.62373865e-01f, -7.00714812e-02f, -8.15287232e-02f, 1.34861767e-01f, -1.00339979e-01f, -1.60878927e-01f, -1.08605549e-01f,
  1.09559104e-01f, 1.71887830e-01f, 2.22507223e-01f, 4.58869368e-01f, 1.00997649e-01f, 6.40957290e-03f, 1.68011352e-01f, -1.93818763e-01f, -3.55270803e-01f, -1.87896311e-01f,
  -1.29702166e-01f, 2.58240521e-01f, 4.15719777e-01f, 1.99778140e-01f, -1.44913867e-01f, 2.87855506e-01f, -2.09655300e-01f, -2.24594697e-01f, -2.60558575e-01f, -2.62264833e-02f,
  5.76691367e-02f, 1.78117235e-03f, -2.78672665e-01f, 2.60473877e-01f, 2.39132449e-01f, -7.56443620e-01f, 2.36576274e-01f, -1.04381219e-02f, -2.29810432e-01f, 3.42415988e-01f,
  -9.13253948e-02f, -8.69227871e-02f, -1.86803415e-01f, -1.57883972e-01f, 1.11525366e-02f, 3.09789807e-01f, -3.50195080e-01f, -2.57179856e-01f, -1.22292496e-01f, 2.05104157e-01f,
  7.52117336e-02f, 3.98583531e-01f, -8.93503428e-02f, -1.18825786e-01f, -4.51139838e-01f, 6.83263270e-03f, 3.03519189e-01f, 1.61935896e-01f, 4.66545165e-01f, -8.06489214e-03f,
  1.37544647e-01f, -8.87398273e-02f, -6.39819205e-02f, -3.77504043e-02f, 1.07722916e-01f, -3.60740095e-01f, 2.48947978e-01f, -3.99635553e-01f, 8.78117755e-02f, 3.37845802e-01f,
  -3.08246344e-01f, 1.55261844e-01f, 3.54102850e-01f, -2.28267580e-01f, -4.19276834e-01f, -2.01575816e-01f, 1.43594131e-01f, -3.85342270e-01f, -2.71354169e-01f, -3.84690970e-01f,
  -2.35499665e-01f, 2.18804806e-01f, 2.76315436e-02f, 2.84082472e-01f, 3.61651391e-01f, 3.09476078e-01f, -3.60418171e-01f, 1.31893262e-01f, 8.13258588e-02f, 4.50431891e-02f,
  -2.99168915e-01f, -3.93164337e-01f, -7.00341091e-02f, -1.31167620e-01f, 5.89943193e-02f, -1.54298767e-01f, 3.16245481e-02f, -3.57834101e-01f, 4.01699133e-02f, -1.57142088e-01f,
  -1.78838566e-01f, 1.11241229e-01f, -1.60792112e-01f, 6.62883148e-02f, -7.04716146e-02f, 5.38278341e-01f, 1.52675152e-01f, 2.50677824e-01f, -3.97830606e-02f, -3.23090762e-01f,
  1.43105328e-01f, -3.14655840e-01f, 4.24729794e-01f, 5.33335924e-01f, -2.41677865e-01f, -6.47983402e-02f, 1.01976261e-01f, 2.37785190e-01f, 6.44732174e-03f, 1.88796163e-01f,
  -1.03639647e-01f, -3.22537720e-02f, 5.03158122e-02f, -2.78819889e-01f, -6.27371743e-02f, -2.20100731e-01f, 2.19304100e-01f, -1.14687532e-01f, -3.32256347e-01f, -3.10442373e-02f,
  3.34620327e-01f, 3.29259545e-01f, 2.54343487e-02f, -2.76484191e-01f, -9.77626164e-03f, -1.03556231e-01f, 7.62716085e-02f, 2.65828937e-01f, -7.08815828e-02f, 5.32374196e-02f,
  1.27795234e-01f, -1.90582141e-01f, -2.11533055e-01f, 1.18377805e-01f, 3.13451201e-01f, -2.47590572e-01f, -3.19772035e-01f, -1.24402694e-01f, 1.33317057e-02f, 6.71688795e-01f,
  -4.88121323e-02f, 8.25166702e-02f, 1.52832359e-01f, 3.21579576e-01f, -2.64370531e-01f, -9.98103619e-02f, -5.02340734e-01f, -1.08929195e-01f, 3.15680534e-01f, -3.72339487e-01f,
  -1.09019063e-01f, -1.65019676e-01f, 2.49119028e-01f, -2.94424146e-01f, 3.17316860e-01f, -3.30566227e-01f, 2.89346427e-01f, -3.81390393e-01f, 1.28820166e-01f, 2.30422705e-01f,
  1.83660001e-01f, 3.39158252e-02f, 1.53213367e-01f, 2.10536927e-01f, 4.39524144e-01f, 2.27784470e-01f, 3.56732339e-01f, -3.95694137e-01f, 1.38220847e-01f, -7.92406276e-02f,
  -1.49525940e-01f, -1.98775962e-01f, 2.01778188e-01f, -3.70421201e-01f, 1.55426443e-01f, -9.88117605e-02f, 1.30645081e-01f, 2.64006853e-01f, -1.69175595e-01f, 2.90204704e-01f,
  -6.93561435e-02f, -7.87779540e-02f, -1.24741048e-01f, 1.05536737e-01f, -2.43278190e-01f, 3.20094407e-01f, 9.20403674e-02f, 4.82335165e-02f, -1.66605026e-01f, -2.19214484e-01f,
  -3.88512999e-01f, 6.41697049e-01f, -6.82409294e-03f, -9.89553556e-02f, -3.21651399e-01f, -2.63748825e-01f, -1.46585420e-01f, -1.02235593e-01f, 1.54029846e-01f, 1.35442197e-01f,
  -2.92563677e-01f, 8.67738053e-02f, 2.97620803e-01f, -6.43840879e-02f, 1.82464980e-02f, -6.98870420e-02f, -1.88046664e-01f, -3.12927961e-01f, 5.97959720e-02f, 1.33037850e-01f,
  2.93184429e-01f, 1.63484618e-01f, -1.75057277e-01f, -2.96786726e-01f, 1.47706479e-01f, 1.19569130e-01f, -3.29848495e-03f, 3.71206343e-01f, 3.36463481e-01f, -3.02556247e-01f,
  3.77090156e-01f, 1.52776048e-01f, 6.41785741e-01f, -2.60527909e-01f, -9.50351655e-02f, -2.61764318e-01f, 2.96518326e-01f, 3.74639273e-01f, 2.26988122e-01f, 1.28323376e-01f,
  -2.19101936e-01f, -2.00549349e-01f, 5.47519326e-01f, 7.11906999e-02f, -6.38059005e-02f, -1.20326564e-01f, -7.19959289e-02f, -1.20990999e-01f, 2.23702878e-01f, 2.40645200e-01f,
  1.72752991e-01f, -4.37052138e-02f, -2.47796938e-01f, 4.04300898e-01f, 8.96475762e-02f, 3.48317862e-01f, -3.96331847e-02f, -1.78104684e-01f, -8.77793506e-02f, -2.97284842e-01f,
  -3.28887820e-01f, 3.56704772e-01f, -3.56397957e-01f, -1.39917552e-01f, 2.46444494e-01f, -3.24538976e-01f, -3.16828579e-01f, -7.27581754e-02f, -2.82861404e-02f, -4.47480291e-01f,
  1.85440965e-02f, 5.31305932e-03f, -3.01575601e-01f, -8.53487030e-02f, 4.95916456e-01f, 4.90290314e-01f, -9.87958610e-02f, -3.25341076e-01f, -2.62604237e-01f, -3.80216800e-02f,
  3.17578912e-02f, -2.62263000e-01f, 1.66209295e-01f, -6.17515862e-01f, 2.17508808e-01f, 4.51666653e-01f, -1.47689834e-01f, -8.16966295e-02f, 1.30828381e-01f, -1.39813587e-01f,
  -5.30829281e-02f, 1.70216590e-01f, -5.81593104e-02f, 1.60822511e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  4.75372225e-01f, 1.32326826e-01f, 3.74874920e-01f, 5.46031058e-01f, 2.23486945e-01f, 3.16915542e-01f, -2.47904519e-03f, -5.00726521e-01f, 3.65723491e-01f, -3.19766343e-01f,
  -1.48145501e-02f, 4.96351570e-01f, -8.31179321e-02f, -2.47401446e-01f, 3.72884929e-01f, 1.87874705e-01f, -5.33262730e-01f, 3.14545065e-01f, -8.28607738e-01f, 1.83403492e-01f,
  -2.19033897e-01f, -7.43280232e-01f, 5.49863040e-01f, -5.07809162e-01f, 3.62452000e-01f, 5.52341826e-02f, 4.80695188e-01f, 2.59356797e-01f, 7.22804964e-01f, -8.14425051e-01f,
  -9.72466394e-02f, 2.09367916e-01f, 2.44882405e-01f, -4.52044040e-01f, -2.44126562e-02f, 4.74797003e-02f, 7.08746463e-02f, 2.62036651e-01f, -1.82212338e-01f, -1.81715757e-01f,
  -6.54741079e-02f, 2.60039449e-01f, -3.49523664e-01f, -4.01320547e-01f, -1.44361660e-01f, -1.57266006e-01f, -7.28656054e-02f, -3.05097759e-01f, -2.18527988e-01f, -3.52970779e-01f,
  3.61523569e-01f, -2.42078453e-01f, 1.31964266e-01f, 1.09427974e-01f, 9.63258266e-01f, -1.73005760e-02f, -4.90786023e-02f, -6.19724393e-01f, 6.19885266e-01f, -3.52516711e-01f,
  5.61759531e-01f, -1.43385664e-01f, -2.47233912e-01f, -2.32555661e-02f, -9.76095200e-02f, 2.19366625e-01f, -3.74566674e-01f, 5.14408708e-01f, 4.54872131e-01f, 7.33872727e-02f,
  2.67649114e-01f, 2.03420490e-01f, 1.35841846e-01f, 2.91320905e-02f, 3.83915365e-01f, -1.58867851e-01f, 7.45890260e-01f, 4.24626052e-01f, -2.10301846e-01f, -1.66991904e-01f,
  -4.94696647e-01f, -2.51790613e-01f, 3.77687812e-01f, 1.26167402e-01f, 6.36602581e-01f, 5.60200870e-01f, -8.98349732e-02f, 8.41031373e-01f, -2.54626125e-01f, 1.49320856e-01f,
  5.97523928e-01f, -1.39486670e-01f, -6.35968223e-02f, -5.73077261e-01f, -8.67307842e-01f, 2.58512646e-01f, 5.89578040e-03f, 1.74661428e-01f, 7.30116248e-01f, 1.74123973e-01f,
  8.39463398e-02f, 6.30534708e-01f, 4.22156006e-01f, 7.80019015e-02f, 2.82216728e-01f, 5.41849852e-01f, 3.03580910e-01f, -9.26913172e-02f, -2.66708642e-01f, -2.32666701e-01f,
  -2.07368061e-01f, 1.76001519e-01f, 1.07167669e-01f, -3.87096465e-01f, -5.24697542e-01f, 4.32878703e-01f, -2.62836814e-01f, -2.22947836e-01f, -6.53587401e-01f, -7.83662349e-02f,
  7.34858155e-01f, -4.63949651e-01f, -2.91405432e-02f, 3.51120621e-01f, 1.74987186e-02f, -4.35367882e-01f, -2.24634092e-02f, 5.49542069e-01f, 4.31289524e-01f, 3.01138192e-01f,
  6.87694907e-01f, -3.94674778e-01f, -6.39360249e-01f, -1.08118936e-01f, 6.88600242e-01f, 3.55413519e-02f, 2.24535495e-01f, 4.62949991e-01f, -5.21215834e-02f, -7.48150572e-02f,
  6.99266121e-02f, 5.09511173e-01f, -3.71359110e-01f, 2.77374059e-01f, -2.59225398e-01f, -5.97209990e-01f, -5.32991439e-02f, 1.68456957e-01f, 3.47761959e-01f, -2.43481204e-01f,
  -7.26559311e-02f, 3.34487036e-02f, 4.11380738e-01f, -3.75677086e-02f, 8.19234625e-02f, -4.08588976e-01f, -1.20455641e-02f, -2.17375472e-01f, 1.01709366e-01f, 2.46429652e-01f,
  1.69825956e-01f, 3.81584018e-01f, 1.41225472e-01f, 9.09626842e-01f, -1.84489340e-01f, 4.34062928e-01f, 5.99084914e-01f, 1.74482033e-01f, 5.68451941e-01f, -3.18415351e-02f,
  4.59226638e-01f, 5.88902652e-01f, 7.98942864e-01f, 1.18789780e+00f, 7.99103454e-03f, 1.18895777e-01f, -5.92646599e-01f, -5.41933000e-01f, 3.24820029e-03f, 5.16826093e-01f,
  7.41649091e-01f, -1.14341363e-01f, -2.02667311e-01f, 8.64770949e-01f, 4.19769257e-01f, -5.16614676e-01f, -1.54401883e-01f, -2.45411262e-01f, 1.21918589e-01f, -4.61564571e-01f,
  -1.86567649e-01f, 3.20552766e-01f, -4.79424655e-01f, 1.21546373e-01f, 1.90845504e-01f, -1.23221047e-01f, 3.04747283e-01f, -1.56187847e-01f, 2.14638993e-01f, 3.28690976e-01f,
  7.53231496e-02f, 3.60283971e-01f, -1.84616059e-01f, 2.17649370e-01f, 2.50896364e-01f, 1.33779228e-01f, -4.17921953e-02f, -1.54667810e-01f, 1.09767981e-01f, 4.32977080e-01f,
  4.93515193e-01f, 2.80283839e-01f, 1.73307046e-01f, -4.34095651e-01f, 7.49873996e-01f, 1.46439567e-01f, -6.28425833e-03f, 6.80114627e-01f, 5.15766799e-01f, -3.93770248e-01f,
  4.33156401e-01f, -4.72164840e-01f, 1.55789122e-01f, -6.59659356e-02f, 3.65452379e-01f, -1.17959417e-01f, -1.01338458e+00f, 1.62753519e-02f, 3.26442085e-02f, -4.26248610e-01f,
  -6.00457132e-01f, 5.23639396e-02f, -2.09941745e-01f, -6.30709469e-01f, 4.24631953e-01f, 2.95512646e-01f, -2.99601614e-01f, 7.75779337e-02f, 5.05083799e-01f, 3.46288770e-01f,
  -7.54400417e-02f, 2.85848945e-01f, 1.75288886e-01f, -9.97052118e-02f, -2.85388995e-02f, 3.50765437e-01f, 6.10802462e-03f, -2.77999610e-01f, 4.70421374e-01f, 7.37166822e-01f,
  -1.65562809e-01f, 3.59962821e-01f, 3.92213106e-01f, 4.16175902e-01f, 6.42637432e-01f, -3.10775667e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -8.26803967e-02f, 1.43677086e-01f, 5.57897151e-01f, 2.97247529e-01f, 1.08856158e-02f, 2.33116880e-01f, 1.38842121e-01f, 7.53408894e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.22107863e-01f, 4.76693571e-01f, -9.12080891e-03f, -1.85157761e-01f, -7.69212067e-01f, -3.60807627e-01f, -5.00989318e-01f, -5.76169133e-01f, 3.51520479e-01f, -4.73458230e-01f,
  -2.10972235e-01f, -3.84250522e-01f, 5.24827182e-01f, 2.05669895e-01f, 2.76246697e-01f, 5.19824386e-01f, -2.95742065e-01f, 1.79521158e-01f, -4.26106960e-01f, 1.10923201e-01f,
  3.88974130e-01f, 2.82080710e-01f, 2.26729885e-01f, -3.58571768e-01f, -7.28059486e-02f, -1.93229821e-02f, -2.28649303e-01f, -3.93682390e-01f, -6.41982377e-01f, -2.93154210e-01f,
  -6.53397858e-01f, 5.22711158e-01f, 8.77789378e-01f, 2.94470340e-02f, -1.80980578e-01f, 4.86428916e-01f, -1.04788530e+00f, -5.92788696e-01f, 3.95427555e-01f, 3.30244675e-02f,
  6.59900486e-01f, 6.15400493e-01f, 1.91927329e-01f, -1.86565608e-01f, 3.20340633e-01f, 8.90491009e-01f, 3.67591292e-01f, -6.25531852e-01f, -3.63780051e-01f, -8.06036353e-01f,
  2.31247604e-01f, -2.86302179e-01f, 6.15819275e-01f, -2.05472022e-01f, -4.20749307e-01f, -2.29039058e-01f, 1.63908646e-01f, -2.14123517e-01f, -5.54682054e-02f, 4.03362632e-01f,
  -2.06468925e-01f, -1.10705391e-01f, -3.56403440e-01f, -3.42086881e-01f, -1.93768684e-02f, -1.59368008e-01f, 1.26584088e-02f, 3.11526239e-01f, 2.36843586e-01f, -5.13103962e-01f,
  4.18410748e-02f, -3.22118849e-01f, -1.03792727e-01f, -8.20837263e-03f, 3.89716148e-01f, 4.47077572e-01f, -3.04367572e-01f, 1.09199941e-01f, -3.18317980e-01f, 7.14422941e-01f,
  2.65130997e-01f, 9.68999028e-01f, 3.86782855e-01f, 8.04466382e-02f, 5.22852302e-01f, -1.77300908e-02f, -3.05199623e-01f, -1.78296417e-01f, 3.55926484e-01f, 4.59579468e-01f,
  -6.70460820e-01f, -4.93241958e-02f, 5.69046140e-02f, -9.02070045e-01f, -3.32450494e-02f, -3.49102587e-01f, -2.61012286e-01f, -9.93167311e-02f, 9.21119824e-02f, -5.19541800e-01f,
  4.51117568e-02f, 4.51023936e-01f, 7.18094707e-01f, 4.46803182e-01f, 3.83991562e-02f, -3.76966521e-02f, 7.17661500e-01f, 3.71780932e-01f, 2.46663585e-01f, -5.78363657e-01f,
  2.52705991e-01f, 8.75975490e-01f, -1.46066407e-02f, -4.22915637e-01f, 2.12718263e-01f, 9.06152189e-01f, -5.51026091e-02f, -2.26037741e-01f, 9.73695591e-02f, -3.75883073e-01f,
  -1.66526794e-01f, -4.93213832e-01f, -6.45521104e-01f, -6.07528508e-01f, 3.68957639e-01f, -9.05263126e-02f, 3.74688566e-01f, 1.65611878e-01f, 1.57016426e-01f, -5.45652628e-01f,
  4.51176465e-01f, 3.59283686e-02f, 7.82163978e-01f, -4.98430878e-02f, -4.07958388e-01f, -7.55848810e-02f, -5.89361072e-01f, 3.29349488e-01f, -2.91670859e-01f, -5.36489546e-01f,
  -1.52015239e-01f, -8.40971410e-01f, -5.91317892e-01f, -4.20287430e-01f, 1.76949218e-01f, 2.27666236e-02f, 2.82093793e-01f, -1.06540851e-01f, -3.20525348e-01f, -1.33481994e-01f,
  -4.25045490e-01f, 5.51421165e-01f, 2.05455080e-01f, -3.60092282e-01f, -2.61461347e-01f, -6.60478324e-02f, -5.73969603e-01f, -2.00788975e-01f, -8.35213959e-02f, 2.52124041e-01f,
  -2.11075410e-01f, 9.87244993e-02f, -7.65454233e-01f, -4.27533150e-01f, 5.79481065e-01f, 3.16708326e-01f, -7.88084567e-01f, -4.10837084e-01f, -8.12845901e-02f, -3.43814194e-01f,
  2.03701526e-01f, 1.57950342e-01f, -3.35391641e-01f, -1.53838903e-01f, -3.70629549e-01f, 1.86782360e-01f, 1.72249094e-01f, 4.97166604e-01f, 5.86390495e-01f, 1.72396794e-01f,
  -1.01490545e+00f, -4.12272602e-01f, 5.32850027e-01f, -1.13018095e-01f, 2.78029442e-01f, -5.02745926e-01f, -2.20932469e-01f, 1.37313634e-01f, 7.07243830e-02f, 5.14076293e-01f,
  -5.95457077e-01f, -1.09499425e-01f, -2.57528335e-01f, 3.02751869e-01f, -7.29102194e-01f, -4.01090831e-01f, 4.23780769e-01f, -2.47664869e-01f, -5.05190432e-01f, 4.11628813e-01f,
  1.32204682e-01f, 1.33760840e-01f, 5.77931583e-01f, -7.27692187e-01f, -4.46471035e-01f, -5.82442164e-01f, 2.08647788e-01f, 3.61877650e-01f, -3.97418529e-01f, 3.12710643e-01f,
  -1.73685417e-01f, -6.94266288e-03f, 5.89368120e-02f, 7.09813595e-01f, 2.16438249e-01f, -2.95748502e-01f, -3.85621846e-01f, 4.68205184e-01f, 4.28400278e-01f, -4.65318561e-01f,
  -1.55721664e-01f, 3.09964344e-02f, 1.24617934e-01f, -2.01562092e-01f, -1.66679457e-01f, 1.14755876e-01f, -3.36720832e-02f, 3.02587092e-01f, 2.38936752e-01f, 9.86163765e-02f,
  -3.32354784e-01f, -4.70580369e-01f, -3.41224037e-02f, -1.48076087e-01f, -5.39723456e-01f, 3.65541548e-01f, 7.67122567e-01f, 5.77165008e-01f, -1.15954608e-01f, -3.44609976e-01f,
  9.52908397e-02f, 6.21392159e-03f, -2.11155161e-01f, -3.59449476e-01f, -3.98633443e-02f, -4.76553023e-01f, 1.32538065e-01f, 4.02463526e-01f, 1.41630113e-01f, -9.47603509e-02f,
  9.58111361e-02f, -3.35527390e-01f, -2.26521820e-01f, -7.76809096e-01f, 4.69502360e-01f, -3.29282165e-01f, -9.68586057e-02f, 3.89770567e-01f, -1.56950846e-01f, 3.60907435e-01f,
  3.71860862e-02f, 4.25355464e-01f, 2.79634029e-01f, 5.02245724e-01f, -3.65963250e-01f, -1.94775552e-01f, -2.31100559e-01f, 3.40396971e-01f, -3.78015898e-02f, 3.21139306e-01f,
  -5.64319074e-01f, -6.26635775e-02f, 3.96849692e-01f, 3.59713048e-01f, -7.95990169e-01f, 1.90943420e-01f, 2.09999725e-01f, 1.19991407e-01f, -6.72483623e-01f, 3.63709450e-01f,
  -5.13306022e-01f, -2.71486133e-01f, 2.45357633e-01f, 1.70225844e-01f, 4.64968026e-01f, 5.25337636e-01f, -3.87425900e-01f, -4.07280117e-01f, -1.87890723e-01f, -4.01892990e-01f,
  2.03462407e-01f, -1.49742022e-01f, -2.95358092e-01f, -2.40099147e-01f, 1.06609002e-01f, 4.75561261e-01f, -3.23404670e-01f, -1.62158683e-02f, -6.04614854e-01f, -4.82602775e-01f,
  -1.54251903e-01f, 1.35712236e-01f, 6.47096395e-01f, -6.41621351e-01f, -1.39078526e-02f, 3.59219611e-01f, 3.82118784e-02f, 1.42032743e-01f, 3.29092853e-02f, -2.05599099e-01f,
  5.83994985e-02f, 1.38751432e-01f, 3.81256789e-02f, 1.08150862e-01f, -8.00046474e-02f, -2.58678962e-02f, 4.16805744e-01f, 3.24884176e-01f, 2.10330248e-01f, -1.00330544e+00f,
  -6.94733143e-01f, 3.01397234e-01f, 4.30359960e-01f, -5.97822547e-01f, 4.09566492e-01f, 4.07331884e-01f, 1.90230668e-01f, 3.48471761e-01f, 9.94612426e-02f, -8.77087653e-01f,
  -2.32952356e-01f, -2.55229980e-01f, -4.05754298e-01f, -5.21358490e-01f, -6.49745941e-01f, 6.54514313e-01f, -4.27700669e-01f, -2.02635109e-01f, -9.31251049e-01f, 6.06793106e-01f,
  -1.68474577e-02f, 1.05381645e-01f, 6.58621371e-01f, -4.80021268e-01f, -5.48764706e-01f, -5.73414087e-01f, -9.98608828e-01f, 5.39880335e-01f, 4.69144464e-01f, -9.80448663e-01f,
  -4.24382351e-02f, -6.54263794e-01f, 6.08434796e-01f, -4.56831008e-01f, 7.50822663e-01f, 4.53127623e-01f, -4.06475335e-01f, 3.85637939e-01f, 5.86221993e-01f, -2.33465537e-01f,
  4.67270494e-01f, 2.78581083e-01f, 2.49289289e-01f, 5.84602058e-01f, 1.82472095e-02f, -3.98046851e-01f, 5.62693119e-01f, -2.42865860e-01f, 4.93639350e-01f, -6.15107954e-01f,
  -9.32781547e-02f, -4.36036259e-01f, 5.02536058e-01f, 5.76970242e-02f, 3.61498356e-01f, 5.28690517e-01f, -1.12623274e+00f, -1.70402914e-01f, 4.24720734e-01f, -8.70257914e-01f,
  -6.41678572e-01f, 3.66724700e-01f, 1.78358808e-01f, -7.07759917e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  8.15017000e-02f, 4.54677105e-01f, -4.98901121e-02f, 1.75940663e-01f, -4.84271608e-02f, -1.87047884e-01f, -6.14309162e-02f, 6.96130469e-02f, 8.91518891e-02f, -8.55851248e-02f,
  2.61229426e-01f, 8.08026567e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    